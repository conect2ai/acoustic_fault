/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 3 x 120)
const int L0_fan_Wp_rows = 3;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  2.65833765e-01f, 1.19162828e-01f, -8.34627971e-02f, 1.24758199e-01f, 1.92531839e-01f, 2.63498016e-02f, -2.73474189e-03f, -1.84978977e-01f, -7.86641538e-02f, -7.67798722e-02f,
  -8.07396099e-02f, -5.17796502e-02f, -1.33930231e-02f, -8.56537819e-02f, -1.38309181e-01f, 1.04637751e-02f, 1.70302957e-01f, 1.57773942e-01f, -4.98731621e-02f, 1.01747170e-01f,
  1.55336142e-01f, 1.13453835e-01f, 1.70623675e-01f, 7.32364208e-02f, 2.96463016e-02f, 5.31946793e-02f, -1.11218773e-01f, 1.59111783e-01f, 6.19280525e-02f, 3.25500697e-01f,
  -2.16126181e-02f, 7.21902400e-02f, -1.33942649e-01f, 4.72043455e-02f, -4.11676951e-02f, -1.22404443e-02f, 2.11251359e-02f, -6.64492557e-03f, -1.17243472e-02f, -9.25969891e-03f,
  -3.17879929e-03f, -4.79963720e-02f, 9.78539065e-02f, -1.81896184e-02f, 5.21834195e-02f, 9.94106904e-02f, -4.81659248e-02f, -4.36536074e-02f, -8.96815956e-02f, -4.46298905e-02f,
  8.69823992e-02f, 2.09369078e-01f, -1.41113836e-04f, -1.13093503e-01f, -8.40136334e-02f, 2.45589949e-02f, 8.69248156e-03f, 4.01574895e-02f, -9.09886509e-03f, -2.83961073e-02f,
  -1.74339525e-02f, 3.26517783e-02f, -4.01521288e-02f, 9.47303399e-02f, 3.77630778e-02f, -1.05095275e-01f, 2.58036349e-02f, -1.37561494e-02f, 2.88479235e-02f, -2.10005119e-02f,
  -4.97809276e-02f, -2.56470628e-02f, -2.92238407e-02f, -3.72038148e-02f, -2.42754892e-02f, -6.52631512e-03f, 5.18802460e-03f, 2.27289852e-02f, 3.41043025e-02f, 7.86430538e-02f,
  -9.04482510e-03f, 3.08796857e-02f, -5.41014946e-04f, -3.40506285e-02f, 2.57815644e-02f, 2.17395369e-02f, -6.18880102e-03f, -1.69761013e-02f, -8.31672456e-03f, 1.08902052e-01f,
  -3.44011545e-01f, -6.46337718e-02f, -2.62456089e-02f, -4.87654321e-02f, -5.18100187e-02f, 3.64793390e-02f, -4.44601513e-02f, 5.37444018e-02f, 2.78005246e-02f, -7.96719175e-03f,
  -2.51987819e-02f, 7.90586695e-02f, -2.07618605e-02f, -1.29105940e-01f, -5.29762134e-02f, 1.57473405e-04f, 1.58813912e-02f, 4.55314219e-02f, -7.00018927e-02f, -2.49322094e-02f,
  1.45948753e-02f, -9.18108746e-02f, 3.10549978e-02f, 7.34163402e-03f, -5.15743308e-02f, 1.84845813e-02f, -1.42518848e-01f, -9.36319828e-02f, -9.73362103e-02f, -1.11536600e-01f,
  4.33763593e-01f, 1.72424272e-01f, -1.24083094e-01f, 3.70618068e-02f, 1.12179488e-01f, 1.53494686e-01f, 3.94510895e-01f, 7.62203485e-02f, -2.62758136e-02f, 1.48971781e-01f,
  2.26998165e-01f, -4.42369394e-02f, 1.08220078e-01f, -1.24467626e-01f, 4.25024591e-02f, 7.01684207e-02f, -3.22692513e-01f, -1.11430936e-01f, 9.83666331e-02f, 5.69936037e-02f,
  -1.19004086e-01f, 2.06851400e-02f, 1.08170360e-01f, -4.60942835e-03f, -3.86937968e-02f, -4.11159210e-02f, 5.99647760e-02f, -4.61089872e-02f, -5.75703755e-02f, -4.13307339e-01f,
  2.13337261e-02f, 6.51193038e-03f, -6.33819625e-02f, 1.50411269e-02f, 4.13747765e-02f, 6.61817268e-02f, -2.18762048e-02f, -6.47742078e-02f, 3.09487409e-03f, -6.69217855e-02f,
  -5.81635088e-02f, -1.39325157e-01f, 5.82596008e-03f, -8.69848356e-02f, 7.06488043e-02f, -4.58470695e-02f, -5.11211008e-02f, -1.26438886e-01f, 1.13849584e-02f, -7.07429042e-03f,
  -5.03675938e-02f, -9.05971602e-02f, 1.75768420e-01f, -2.67468411e-02f, 3.31487283e-02f, -1.32310733e-01f, 6.08590320e-02f, -2.16371343e-01f, -1.27301350e-01f, -1.09633952e-01f,
  -1.43364510e-02f, -2.75122020e-02f, 9.40941088e-03f, 7.26910532e-02f, 1.21889010e-01f, -4.58299108e-02f, -9.02794302e-02f, 7.15332255e-02f, -5.03468625e-02f, 8.00483376e-02f,
  -5.65278865e-02f, 4.81749289e-02f, 7.46596456e-02f, -8.71789269e-03f, 1.32345865e-02f, -6.72386913e-03f, 1.19018583e-02f, -3.13614942e-02f, 4.54752669e-02f, -2.30033007e-02f,
  8.43784865e-03f, -6.69934899e-02f, -3.59727219e-02f, -1.10467479e-01f, -8.56671557e-02f, -9.30108353e-02f, 1.03212558e-02f, 1.84634794e-02f, 1.07111000e-01f, -2.43989211e-02f,
  3.72319192e-01f, -5.70192449e-02f, 3.66527028e-02f, -2.04627905e-02f, -8.99444614e-03f, -6.01482280e-02f, 5.37591949e-02f, -1.01750731e-01f, -3.37301195e-02f, 3.84119153e-02f,
  4.87126522e-02f, 4.38984521e-02f, 6.31932169e-02f, -4.06315960e-02f, 1.25367586e-02f, 6.05052970e-02f, 5.04408628e-02f, 3.90649401e-02f, -5.81496656e-02f, 4.58500395e-03f,
  7.18864426e-02f, 2.45664701e-01f, 3.57869297e-01f, 9.78406966e-02f, 1.04752824e-01f, 1.94379196e-01f, 1.62776396e-01f, 1.63032815e-01f, 2.66365230e-01f, 5.25319219e-01f,
  -3.38765532e-01f, 2.55091846e-01f, -1.01188133e-02f, -1.45713538e-01f, -1.76912714e-02f, -5.77130690e-02f, 1.05773248e-01f, -4.67198528e-02f, -1.43123139e-02f, 1.25510663e-01f,
  7.40274414e-02f, -2.06627455e-02f, -8.71527791e-02f, -4.30500843e-02f, -6.04011230e-02f, 3.20966206e-02f, -2.93625798e-02f, -8.04808140e-02f, -2.60383517e-01f, 1.32146692e-02f,
  9.65199247e-02f, 3.30414474e-02f, -6.29911870e-02f, -1.81001186e-01f, 7.48875588e-02f, -1.65251531e-02f, 1.03155434e-01f, -4.63921800e-02f, 4.33216058e-03f, 1.80525750e-01f,
  5.86216897e-02f, 3.63126956e-02f, -2.24250294e-02f, -8.14785957e-02f, -9.21420678e-02f, 2.05784431e-03f, -2.37608142e-02f, -7.47005418e-02f, 1.52552361e-02f, 2.62327828e-02f,
  5.54703176e-02f, 6.15519397e-02f, -8.67605396e-03f, 1.91535149e-02f, -4.79563512e-02f, 6.11494072e-02f, -4.00176644e-02f, -1.39060587e-01f, -5.79357222e-02f, 3.16066630e-02f,
  -4.88351099e-02f, 5.21756010e-03f, 2.44610012e-04f, 5.79653531e-02f, -5.08164577e-02f, -2.64755730e-02f, -6.12183437e-02f, -7.92961940e-02f, -4.87661883e-02f, 1.79521725e-01f,
  4.24595214e-02f, 2.32469663e-02f, 1.79853626e-02f, 2.63327286e-02f, 5.39574288e-02f, 4.39774655e-02f, 1.08921360e-02f, 4.45240140e-02f, 3.69122438e-02f, -4.00009751e-03f,
  1.11156451e-02f, 5.42528480e-02f, 3.24772298e-02f, 2.31969096e-02f, -1.16588548e-02f, -3.37657742e-02f, 8.97041056e-03f, 4.33686748e-02f, -2.11439766e-02f, 3.79353762e-02f,
  2.56744139e-02f, 7.40744025e-02f, 1.67884789e-02f, -2.00979132e-02f, -2.40154769e-02f, -4.61205058e-02f, 2.05299724e-02f, -6.01331256e-02f, -6.30031824e-02f, -4.84282374e-02f,
  8.96775648e-02f, -1.51703581e-01f, 1.90101415e-01f, -2.34121587e-02f, -2.91366577e-02f, 1.20315077e-02f, -5.60249873e-02f, -3.05791367e-02f, 1.16060376e-02f, -7.06335679e-02f,
  -6.58982396e-02f, -5.61436713e-02f, 1.50689501e-02f, -6.98417649e-02f, 5.78387938e-02f, -4.16324995e-02f, 6.00939654e-02f, -5.93950152e-02f, -6.08563311e-02f, 3.53218317e-02f,
  -7.16983825e-02f, 9.59161371e-02f, 4.16676607e-03f, 1.20622411e-01f, 5.56906834e-02f, -3.21885869e-02f, 1.31023839e-01f, -1.23053149e-03f, -7.07171857e-02f, 1.24660328e-01f
};

// L0_fan_Wp_bar (Shape: 26 x 120)
const int L0_fan_Wp_bar_rows = 26;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  3.46422255e-01f, -3.01852703e-01f, -2.58079767e-01f, 4.69023921e-02f, 1.47279063e-02f, -7.97509849e-02f, -7.10394755e-02f, 6.27192333e-02f, 1.95615306e-01f, -2.61490867e-02f,
  -2.05530033e-01f, -7.00434819e-02f, -7.44917616e-02f, -8.36932510e-02f, -8.72465074e-02f, -1.88356221e-01f, 1.59898289e-02f, -1.11920424e-01f, -5.97529579e-03f, 7.85735175e-02f,
  4.50867321e-03f, -7.15840310e-02f, 1.01346441e-01f, -7.95413926e-03f, -7.49390498e-02f, 1.24639301e-02f, -1.15137093e-01f, -1.27301216e-01f, -1.41525075e-01f, -2.70377219e-01f,
  -1.68588594e-01f, -5.58648668e-02f, 6.21502548e-02f, -1.02533050e-01f, -8.40509906e-02f, 5.13768569e-02f, -3.59538794e-02f, 1.00184381e-01f, 6.15970530e-02f, 5.65854134e-03f,
  -3.19898943e-03f, 1.00786701e-01f, 1.07762128e-01f, -6.52707890e-02f, 1.27957553e-01f, 4.46796231e-02f, -2.90286099e-03f, 2.05591433e-02f, 1.27514172e-02f, -7.06190541e-02f,
  -1.13967463e-01f, -8.11646357e-02f, -5.91402985e-02f, -1.27369054e-02f, 5.33292033e-02f, -3.79968109e-03f, -1.34835914e-01f, 1.20908609e-02f, -3.11575066e-02f, 5.46242148e-02f,
  -1.08988686e-02f, 7.59704923e-03f, 9.43275355e-03f, 6.97246492e-02f, 8.21825638e-02f, 6.18977621e-02f, 1.03912823e-01f, 1.11935019e-01f, 8.44483450e-02f, 3.46348993e-03f,
  -3.46889384e-02f, 4.50270548e-02f, -7.43654147e-02f, -7.76538476e-02f, -1.94520317e-02f, 1.75115652e-02f, -4.59057605e-03f, -3.31498384e-02f, -3.95823736e-03f, -2.37789340e-02f,
  -7.95015991e-02f, 9.19016253e-04f, 4.00787592e-03f, -7.69431219e-02f, -6.87338263e-02f, -6.06952347e-02f, -6.46234676e-02f, 5.70991673e-02f, -3.38740200e-02f, 8.52548052e-03f,
  1.74473777e-01f, -1.95462763e-01f, -4.05073399e-03f, 3.59283984e-02f, 7.46172145e-02f, -2.40931716e-02f, -4.57424335e-02f, -5.11977226e-02f, 4.92033847e-02f, -2.61612260e-03f,
  -1.10057354e-01f, -3.16567980e-02f, -1.44938556e-02f, -4.34170812e-02f, 8.64637271e-02f, 6.56909123e-02f, 8.10055993e-03f, 8.47379789e-02f, 3.93941961e-02f, 5.15320636e-02f,
  2.49545258e-02f, 1.80974901e-01f, 1.61394805e-01f, 1.14894584e-01f, 1.06092438e-01f, 1.28516838e-01f, 7.63786882e-02f, 1.21726863e-01f, 4.65328395e-02f, 1.87586427e-01f,
  2.38267511e-01f, -1.21621035e-01f, 1.32134731e-03f, 1.08358316e-01f, 5.62521704e-02f, 6.64910898e-02f, -4.62426506e-02f, -1.86903849e-02f, 1.36690065e-01f, 1.91743933e-02f,
  -3.42270844e-02f, 1.40859827e-01f, 8.09358433e-02f, 1.43991888e-01f, 2.30930187e-02f, -1.02015333e-02f, 1.57270245e-02f, 7.69168660e-02f, 1.01148807e-01f, 1.21754497e-01f,
  4.33793552e-02f, -5.44271320e-02f, 3.15534733e-02f, -5.39853191e-03f, -4.50067036e-02f, -4.89546023e-02f, -1.02540841e-02f, 8.29973817e-03f, -1.00760281e-01f, -9.10169184e-02f,
  3.19946110e-02f, 1.11224584e-01f, 1.14226900e-01f, 2.73601469e-02f, 8.55048560e-03f, -3.56951393e-02f, 4.67738248e-02f, -1.74660701e-02f, 1.76736563e-02f, -6.96600750e-02f,
  2.95678843e-02f, -6.39075115e-02f, 1.15240887e-01f, -5.67431888e-03f, -5.94672561e-02f, -4.41977829e-02f, -8.63811448e-02f, 4.27714847e-02f, 1.21054508e-01f, -7.33692292e-03f,
  7.80565199e-03f, 4.36460674e-02f, 8.53270516e-02f, 4.62599583e-02f, 9.08096507e-02f, -3.73686142e-02f, 8.35454930e-03f, 8.03798437e-03f, 6.89295456e-02f, 5.02816252e-02f,
  -4.54552360e-02f, -7.28182727e-03f, 4.88392636e-02f, -4.95654205e-03f, -4.26053964e-02f, 3.65971625e-02f, 3.77252363e-02f, 6.49258718e-02f, -7.56174698e-02f, -1.10080570e-01f,
  -8.56983103e-03f, 1.11063279e-01f, 5.80704808e-02f, 2.41332501e-02f, 1.95497684e-02f, -9.80919823e-02f, 5.94044328e-02f, -3.51639763e-02f, -6.51660040e-02f, -6.30402118e-02f,
  2.53816973e-02f, -5.31156212e-02f, -2.49362029e-02f, -6.09359965e-02f, 2.28689052e-02f, 5.74284568e-02f, -2.89583728e-02f, -2.77935714e-02f, 5.09468615e-02f, 5.24755120e-02f,
  5.39868744e-03f, 1.14925735e-01f, 5.97968288e-02f, 1.37310633e-02f, 7.07130274e-03f, -8.36094022e-02f, 4.72303070e-02f, -8.38296562e-02f, -8.82170796e-02f, 1.28408968e-02f,
  5.58370650e-02f, 2.32042056e-02f, -8.13777372e-02f, -2.13780645e-02f, -6.08446728e-03f, 5.52717745e-02f, -4.51626144e-02f, 5.27329035e-02f, 6.04528114e-02f, -7.13056028e-02f,
  -1.63374126e-01f, 4.61478196e-02f, 5.20730577e-02f, 1.50412209e-02f, 6.98793158e-02f, 7.40218163e-03f, -1.25793830e-01f, -7.11825490e-02f, -9.17670596e-03f, -2.04387889e-03f,
  5.46038337e-02f, -1.61478549e-01f, 2.08168000e-01f, 2.06546888e-01f, 1.17173471e-01f, 1.72928900e-01f, 6.04108572e-02f, -3.96574521e-03f, -1.93532445e-02f, 9.51443538e-02f,
  6.59710616e-02f, -1.46631831e-02f, -1.99040733e-02f, -4.69038822e-02f, 8.31527170e-03f, -1.78261045e-02f, 6.77393898e-02f, 1.30794302e-01f, 1.77990392e-01f, 5.30084893e-02f,
  -3.00786383e-02f, -2.47474611e-02f, 7.19592124e-02f, 6.53036535e-02f, 5.03314063e-02f, -9.43410303e-03f, -2.13230792e-02f, 8.27065110e-03f, -3.15530673e-02f, -1.07110284e-01f,
  -5.71945608e-02f, 3.00391368e-03f, 1.80773005e-01f, -3.79092731e-02f, 3.69314775e-02f, -9.86386240e-02f, -8.84501263e-02f, -2.22634617e-03f, -1.13652490e-01f, 6.50207326e-02f,
  2.19364930e-03f, -2.56224466e-03f, -1.47286858e-02f, 2.98945401e-02f, 1.16296010e-02f, -1.76844839e-02f, -1.15606964e-01f, 2.95145158e-02f, 5.61709702e-03f, 4.35540527e-02f,
  -9.80642345e-03f, 8.45400244e-02f, 1.57010928e-02f, 8.23366866e-02f, 3.23093124e-02f, 9.18584540e-02f, -8.29230249e-03f, 2.38652378e-02f, 4.56787758e-02f, -1.10556595e-02f,
  6.52606413e-02f, -3.05610038e-02f, -5.24846949e-02f, 5.48517480e-02f, 4.45830785e-02f, -1.81783121e-02f, 3.01032122e-02f, 6.01759106e-02f, 6.06401227e-02f, 4.75153700e-02f,
  -1.43810920e-02f, 5.15447557e-02f, 9.32192337e-03f, 4.93788607e-02f, -5.68989441e-02f, -6.97104335e-02f, -9.27351266e-02f, -4.79345471e-02f, 3.80882211e-02f, -1.02196112e-01f,
  3.66074331e-02f, -5.83226085e-02f, 3.77517380e-02f, 4.93784808e-02f, 5.74751422e-02f, 6.61378056e-02f, -1.62132792e-02f, 3.87751497e-02f, -2.02259272e-02f, -4.83609512e-02f,
  -1.21424615e-01f, 8.84007812e-02f, 9.25080702e-02f, -5.34866601e-02f, 4.99009229e-02f, -3.81843410e-02f, 6.58704489e-02f, -7.84742385e-02f, -9.93002653e-02f, -5.70503809e-02f,
  9.92603227e-03f, 3.40651511e-03f, -2.59485301e-02f, -4.75630499e-02f, 5.51523417e-02f, -2.07453780e-02f, -1.62617043e-02f, -2.24157721e-02f, -5.83034456e-02f, -5.26021458e-02f,
  2.04921048e-02f, -2.63602678e-02f, -1.69248190e-02f, -3.12701575e-02f, -7.66413510e-02f, -3.12602594e-02f, -9.44456160e-02f, 7.37975910e-02f, 4.16229367e-02f, 4.81989756e-02f,
  4.88044508e-02f, 2.25015450e-02f, -4.76507954e-02f, 1.20101525e-02f, -8.05401653e-02f, -1.11929625e-01f, 4.52768654e-02f, -8.73863995e-02f, -4.24918197e-02f, -9.93729159e-02f,
  -6.22579567e-02f, 8.33909214e-03f, -4.47063334e-02f, -8.91742408e-02f, -6.47288188e-02f, -1.73469577e-02f, 5.10276705e-02f, 7.57711381e-02f, -3.55632417e-02f, -2.31864695e-02f,
  2.41054017e-02f, -6.21532612e-02f, -7.22977221e-02f, -7.93249235e-02f, 8.40791464e-02f, 5.20612188e-02f, -8.88528973e-02f, 6.63558096e-02f, 8.60211346e-03f, -1.09496914e-01f,
  3.21237147e-02f, -6.51312545e-02f, 2.49310844e-02f, -1.00821266e-02f, -3.30189429e-02f, -8.11259523e-02f, 7.74641559e-02f, -2.87253596e-02f, 6.02869503e-02f, -8.49918053e-02f,
  6.93067238e-02f, -3.07674315e-02f, -4.12054686e-03f, 5.31024337e-02f, 8.16948563e-02f, 8.12207982e-02f, -4.03402634e-02f, -2.88308412e-02f, 4.18502465e-02f, 6.98031634e-02f,
  -6.43897280e-02f, 2.78231502e-02f, -1.41441403e-03f, 5.53208552e-02f, 3.08290846e-03f, 2.24711020e-02f, -5.36625423e-02f, -1.83972884e-02f, -6.27189130e-02f, -7.11312294e-02f,
  5.20298965e-02f, -3.32502462e-02f, 7.60672707e-03f, 2.75716931e-02f, 4.97148633e-02f, -3.64167765e-02f, -6.75970018e-02f, -6.10262416e-02f, -1.10402443e-02f, 1.74333137e-02f,
  -4.92252819e-02f, -3.73865366e-02f, -2.52716877e-02f, 8.17589089e-03f, 5.80482185e-02f, 7.19260946e-02f, -2.28449330e-02f, 1.92750618e-02f, 6.08121371e-03f, 2.33266708e-02f,
  6.23678267e-02f, -3.64004001e-02f, -2.44847462e-02f, 7.72811100e-02f, -4.37816931e-03f, 5.36622964e-02f, -1.48995807e-02f, 6.27898797e-02f, -1.83899608e-02f, -1.45949479e-02f,
  -6.34901598e-02f, -5.02963588e-02f, 1.27212098e-02f, 1.03408610e-02f, 1.01041645e-02f, -4.97677885e-02f, 6.35599643e-02f, -6.33055493e-02f, -7.17198327e-02f, -7.39134923e-02f,
  6.02659658e-02f, 4.02011946e-02f, 5.67186177e-02f, 9.29192156e-02f, 6.04613163e-02f, -4.24092673e-02f, -8.78821388e-02f, -4.88908701e-02f, 4.95728478e-02f, 3.39567065e-02f,
  -7.88585842e-03f, -6.63982183e-02f, -8.24946836e-02f, -7.40350336e-02f, 3.89467254e-02f, 8.34661275e-02f, -3.28895077e-02f, 8.37907791e-02f, -2.99973413e-02f, 4.03199159e-02f,
  1.01232819e-01f, 8.99451375e-02f, 2.42629543e-01f, -9.40681547e-02f, -3.06920018e-02f, -1.55350536e-01f, -9.76799652e-02f, -2.33782977e-02f, -2.88945474e-02f, -1.52009269e-02f,
  -1.86782740e-02f, -5.07993996e-02f, -4.05943347e-03f, 3.26365829e-02f, 3.08043286e-02f, 4.33398783e-03f, 4.01738621e-02f, 1.23105660e-01f, -4.86833677e-02f, 2.02313345e-02f,
  -2.61872057e-02f, -4.66231816e-02f, 1.12993471e-01f, -1.29295175e-03f, -3.25278714e-02f, -4.16580327e-02f, 1.10717431e-01f, 3.10344957e-02f, -4.30882461e-02f, 1.23587297e-02f,
  6.26520589e-02f, 5.89950047e-02f, -7.28378519e-02f, -3.75582166e-02f, -1.65434312e-02f, 1.06366398e-03f, 4.81559262e-02f, 1.31963894e-01f, -1.83065347e-02f, 8.97844955e-02f,
  4.94818054e-02f, 1.95199773e-02f, -9.38589964e-03f, -7.80615434e-02f, -3.33323218e-02f, 5.87817654e-02f, -2.16968469e-02f, 1.09575272e-01f, -1.28798652e-02f, -3.72975245e-02f,
  -4.52023931e-02f, -1.27523541e-01f, -1.30180363e-02f, -6.55194521e-02f, 8.89113247e-02f, -5.52625880e-02f, -1.55273853e-02f, 6.24520443e-02f, 4.58377693e-03f, -4.13046256e-02f,
  -1.33709330e-02f, 4.12432887e-02f, 1.94385946e-02f, 5.20532057e-02f, -2.77353972e-02f, -3.13760117e-02f, -4.09277864e-02f, 6.59866398e-03f, 8.80686007e-03f, -4.03562300e-02f,
  -1.15188016e-02f, 3.25247496e-02f, 2.87894681e-02f, 5.69740161e-02f, -1.54060815e-02f, -3.84866521e-02f, 4.38259207e-02f, 4.74146716e-02f, 1.99063011e-02f, -3.03548370e-02f,
  -5.30951060e-02f, 6.08596466e-02f, -1.00636482e-02f, 2.44541597e-02f, -2.78078560e-02f, -1.09216862e-03f, -4.94389497e-02f, -4.31858562e-02f, 4.25205305e-02f, -3.34543874e-03f,
  -9.17759091e-02f, 3.18769775e-02f, -4.46999222e-02f, -5.31456508e-02f, -5.22119962e-02f, 8.77272338e-02f, -6.65295124e-02f, -1.73511487e-02f, 3.07821594e-02f, 9.16883443e-03f,
  -3.22858542e-02f, 3.86584066e-02f, 4.66774311e-03f, -2.25999542e-02f, -1.12577103e-01f, -7.39969537e-02f, -1.33172218e-02f, -2.88664103e-02f, 8.55788365e-02f, -5.40732145e-02f,
  -9.17512476e-02f, -4.84282710e-02f, -1.52867988e-01f, -2.17888150e-02f, -1.13493286e-01f, -7.51760080e-02f, 1.52387489e-02f, -1.60474572e-02f, -9.49426964e-02f, -1.13460034e-01f,
  -2.64713960e-03f, 2.07186304e-02f, -4.62850481e-02f, -9.46992710e-02f, -2.13360459e-01f, -1.57269284e-01f, -2.89452393e-02f, -4.03398387e-02f, -7.11311996e-02f, 3.37100103e-02f,
  -6.52655438e-02f, -1.86363366e-02f, 5.47755994e-02f, -1.94668900e-02f, -8.92729610e-02f, 6.33967295e-02f, -2.81304563e-03f, -1.67595129e-02f, -1.62143081e-01f, -1.75713375e-01f,
  -1.13720477e-01f, 1.27531467e-02f, 3.82613689e-02f, 4.86396207e-03f, 6.05174825e-02f, -1.30656539e-02f, 5.33110201e-02f, -3.19601446e-02f, -1.71559557e-01f, -4.73886728e-02f,
  2.03673437e-01f, -2.21926998e-02f, -5.57240024e-02f, -3.25440690e-02f, -7.64535964e-02f, -1.53031256e-02f, -3.18000577e-02f, -3.08507048e-02f, -2.49844417e-02f, -8.48689228e-02f,
  -7.97831789e-02f, 2.68338453e-02f, -3.55755240e-02f, 3.47697772e-02f, -7.74630681e-02f, -1.02398269e-01f, 2.23908154e-03f, -2.91685108e-02f, -7.78850988e-02f, 7.92740211e-02f,
  -1.50803095e-02f, -1.84361950e-01f, -1.40717208e-01f, -2.60161553e-02f, -4.05091085e-02f, -7.66055435e-02f, -8.92921463e-02f, 2.03514453e-02f, -1.03997640e-01f, 1.37318417e-01f,
  2.01695152e-02f, 9.54121444e-03f, -3.08835506e-02f, 7.32687041e-02f, -7.03808889e-02f, 7.55553171e-02f, -4.57989015e-02f, 2.91752275e-02f, -4.43355814e-02f, 2.07672399e-02f,
  5.90354428e-02f, 3.38947065e-02f, 1.09963208e-01f, -3.30624320e-02f, -1.57163646e-02f, -4.45616692e-02f, 3.79000679e-02f, 3.80121730e-02f, -2.78535532e-04f, 8.05103108e-02f,
  3.66844796e-02f, -1.59502700e-02f, -1.01339677e-02f, 3.98613513e-02f, -6.34009345e-03f, 3.87561768e-02f, 8.71287733e-02f, -3.83036733e-02f, 8.75288621e-02f, -1.46960486e-02f,
  2.56998837e-01f, -2.54994392e-01f, 1.19657107e-01f, 1.29427627e-01f, -1.77673586e-02f, -5.89633780e-03f, 9.09211263e-02f, -3.01502328e-02f, 3.52979265e-02f, 9.70659256e-02f,
  -5.96844219e-02f, -2.72057075e-02f, -4.40040231e-02f, -1.07459404e-01f, -1.18908565e-02f, 2.55165324e-02f, -4.88103889e-02f, -5.64535968e-02f, -7.09153786e-02f, -2.52260473e-02f,
  1.08998865e-01f, 2.46867537e-02f, 8.17686394e-02f, 1.02586403e-01f, -3.79948802e-02f, -2.22469075e-03f, 2.27767825e-02f, 3.57716121e-02f, 4.26118821e-02f, 7.67315850e-02f,
  2.22210199e-01f, -2.21357375e-01f, 2.73782551e-01f, 2.20643148e-01f, 2.57841676e-01f, 2.50247598e-01f, 2.44584382e-01f, 1.14697710e-01f, 2.90627927e-02f, 1.02253117e-01f,
  -1.81921557e-01f, -2.64954925e-01f, -3.01403999e-01f, -2.13362977e-01f, -2.63687372e-02f, -8.66611488e-03f, 5.53849712e-03f, 5.87956398e-04f, 1.13486178e-01f, 1.43728197e-01f,
  -6.35168254e-02f, 3.65288071e-02f, -1.04280347e-02f, -4.13210131e-02f, 5.10671549e-02f, -3.82618718e-02f, -8.76152888e-03f, 6.26481250e-02f, -5.49957203e-03f, -1.72112182e-01f,
  -8.27750862e-02f, 1.81166247e-01f, 4.17476110e-02f, -2.88234260e-02f, -9.58523825e-02f, -1.83464643e-02f, -8.63353759e-02f, -3.30071710e-02f, -1.97388195e-02f, 4.02758043e-04f,
  1.49792675e-02f, -9.52266678e-02f, -6.66001141e-02f, 4.63904329e-02f, 9.51412367e-05f, 5.20881377e-02f, -4.68502790e-02f, -3.94466929e-02f, -6.52990043e-02f, 1.79430656e-02f,
  -4.59540710e-02f, -7.23412912e-03f, 1.24788970e-01f, 4.20735739e-02f, 7.87759274e-02f, -6.85731322e-02f, -6.64912090e-02f, 1.18429393e-01f, 3.41242924e-02f, 3.91727686e-02f,
  8.30804408e-02f, 3.57729346e-02f, -3.12220608e-03f, -4.13236246e-02f, -1.97969526e-02f, -1.86346676e-02f, -1.54292015e-02f, -5.29367924e-02f, -3.94935049e-02f, -3.73273231e-02f,
  2.32581086e-02f, 7.31358826e-02f, -5.99053502e-02f, 2.33238842e-02f, -5.77886682e-03f, 2.22009812e-02f, 6.70667738e-02f, 4.58848923e-02f, -5.58755249e-02f, -5.94666181e-03f,
  -3.86799052e-02f, 1.49907218e-02f, 9.41344425e-02f, -3.26172449e-02f, 4.10892582e-03f, 4.77592088e-02f, -2.84051653e-02f, -1.36925206e-02f, -7.67738596e-02f, 4.60807234e-02f,
  -2.80827522e-01f, -4.28779423e-02f, -4.87145456e-03f, -1.14894837e-01f, 4.76005487e-02f, -7.87623748e-02f, 3.09146196e-02f, -2.94941310e-02f, 8.89078993e-03f, -3.50957736e-02f,
  6.29266724e-02f, -4.38832343e-02f, 3.54114212e-02f, 3.70347574e-02f, 1.26254261e-01f, 4.76748422e-02f, -7.21831322e-02f, -6.36551064e-03f, -7.22862035e-02f, -6.50631487e-02f,
  -1.06419295e-01f, 1.04223080e-01f, 5.83876558e-02f, 6.67639077e-02f, 2.11240184e-02f, 1.05173267e-01f, 2.39330344e-02f, -8.24685246e-02f, 9.60705280e-02f, 2.76639704e-02f,
  7.56846666e-02f, -1.18432283e-01f, 1.19133838e-01f, -4.27391455e-02f, 3.42069864e-02f, 4.58393916e-02f, 3.88494716e-03f, -1.64884739e-02f, -5.42655140e-02f, 7.84507990e-02f,
  -3.67406569e-02f, -1.08568057e-01f, -2.69540548e-02f, 8.09744094e-03f, -2.03437526e-02f, 7.46540874e-02f, -4.72085066e-02f, 2.37868866e-03f, -2.95901373e-02f, 1.92245748e-02f,
  4.47391383e-02f, -3.75539772e-02f, 6.05338886e-02f, -5.50998654e-03f, 3.57377343e-02f, -8.51092711e-02f, -7.49567002e-02f, -2.99858265e-02f, -6.49791136e-02f, 5.85200749e-02f,
  4.88867576e-04f, 4.68761846e-02f, -1.71916466e-02f, -6.92260340e-02f, 3.74364965e-02f, -1.93145731e-03f, 1.22953653e-02f, -1.81424227e-02f, -1.00601271e-01f, -1.34952599e-02f,
  -8.77843723e-02f, -6.05023541e-02f, -7.48640820e-02f, 3.16383690e-02f, 2.70054501e-04f, 7.06091374e-02f, -7.76668254e-04f, 5.88150322e-02f, 3.44459824e-02f, 5.92330145e-03f,
  -1.14479829e-02f, 9.54351351e-02f, 6.75889477e-02f, -2.08309162e-02f, 2.34397780e-03f, -3.86787392e-02f, 1.05138510e-01f, 3.86421569e-02f, -5.64960912e-02f, 4.85455021e-02f,
  -5.95805645e-02f, -6.38616877e-03f, -3.43037024e-02f, 2.52560955e-02f, 1.63383614e-02f, -8.94618686e-03f, 1.07575022e-01f, -8.58040079e-02f, -2.04440188e-02f, 7.43220374e-02f,
  -3.09784003e-02f, -6.09425530e-02f, 4.44131671e-03f, 7.38589913e-02f, 3.66007239e-02f, -4.89677005e-02f, 4.85062832e-03f, 8.28280896e-02f, 6.51915073e-02f, -6.36553913e-02f,
  -4.61598597e-02f, 5.49264299e-03f, -7.45833293e-02f, 9.13125426e-02f, 3.91670391e-02f, -5.06129153e-02f, 2.73303483e-02f, 6.17210474e-03f, 3.27170305e-02f, -6.05664998e-02f,
  6.86993152e-02f, 6.26692027e-02f, -9.14519131e-02f, 3.50024328e-02f, -6.32019639e-02f, -8.20386335e-02f, 2.66742501e-02f, -2.46296115e-02f, 5.48865274e-02f, 7.43748322e-02f,
  4.95980717e-02f, 1.14548896e-02f, 5.32967485e-02f, 5.39044440e-02f, -5.55749200e-02f, -4.87371907e-02f, -7.31663927e-02f, 6.29577637e-02f, -1.47480238e-02f, 2.25358568e-02f,
  -6.59741089e-02f, 1.01143820e-02f, 7.28006139e-02f, 6.98080733e-02f, 4.55199741e-02f, 6.18548458e-03f, 5.04717417e-02f, 3.73648219e-02f, 4.50566821e-02f, -4.33924980e-02f,
  2.10586458e-01f, -3.05396050e-01f, 4.73783016e-02f, 8.44770372e-02f, -1.59958303e-02f, 1.16462342e-01f, 2.56011561e-02f, -5.97770363e-02f, 5.05072847e-02f, 3.88550647e-02f,
  -4.23324816e-02f, 2.12016273e-02f, -4.54947501e-02f, 3.97704579e-02f, 2.14134958e-02f, -4.58323248e-02f, 2.35324185e-02f, 9.05758217e-02f, 1.76934123e-01f, 1.60867885e-01f,
  8.74291584e-02f, -9.48769879e-03f, 3.04131508e-02f, 9.00181457e-02f, -5.45500964e-02f, 4.57860157e-02f, 7.34195695e-04f, -1.97035056e-02f, -3.71310562e-02f, -8.72078538e-02f,
  -4.73279580e-02f, -5.51574258e-03f, 4.57572229e-02f, 6.90102205e-02f, -1.00501351e-01f, 4.24602441e-02f, 2.92845704e-02f, -6.83422163e-02f, 1.03700478e-02f, -5.89108430e-02f,
  5.99737512e-03f, 2.44789999e-02f, 4.55848053e-02f, -1.97157394e-02f, -2.39568371e-02f, 5.10858744e-02f, 5.49711213e-02f, -8.71299729e-02f, 1.74792130e-02f, 4.30550873e-02f,
  -1.16960622e-01f, -1.13109918e-02f, -5.92088327e-02f, -7.01007154e-03f, 2.24762429e-02f, -1.55723868e-02f, -4.90690172e-02f, -6.33193776e-02f, -2.58352067e-02f, -8.22208747e-02f,
  1.18964359e-01f, -1.05057266e-02f, 1.14823066e-01f, 4.89678197e-02f, 5.16915098e-02f, 3.76638360e-02f, -6.97321147e-02f, 2.93495338e-02f, -1.99184921e-02f, 3.29471231e-02f,
  4.12525423e-02f, 4.63369600e-02f, 5.24170212e-02f, 3.37275378e-02f, 5.70126250e-02f, -5.51372133e-02f, -2.85416935e-02f, -6.08494394e-02f, 1.13142468e-02f, -5.54024009e-03f,
  1.24734826e-02f, 3.20687965e-02f, -9.87331755e-03f, -3.78769040e-02f, -5.90265281e-02f, -4.48401608e-02f, -2.97679789e-02f, -7.72116482e-02f, 4.44047041e-02f, -4.44004405e-03f,
  -3.50609533e-02f, 6.37721410e-03f, 5.74349575e-02f, -6.18983731e-02f, -8.84166658e-02f, 4.84931581e-02f, -4.10947986e-02f, -6.75761253e-02f, -4.34279405e-02f, -4.63465601e-02f,
  5.88009395e-02f, 1.83718726e-02f, -7.54472911e-02f, -4.95594628e-02f, 7.50052258e-02f, -2.25565732e-02f, -1.36119619e-01f, -4.23672423e-02f, 5.87807745e-02f, 4.01869044e-02f,
  4.48308326e-02f, 6.67793974e-02f, 1.02984220e-01f, 1.91639382e-02f, -2.20522191e-02f, 1.46735251e-01f, 5.98921739e-02f, 4.88340594e-02f, 5.35224862e-02f, 5.15424460e-02f,
  -5.08409441e-02f, -8.05171579e-02f, 7.43596777e-02f, -6.89900815e-02f, -8.54380801e-02f, -1.85293376e-01f, -1.61018446e-01f, -5.01247346e-02f, -3.34973484e-02f, 3.37046832e-02f,
  1.14415787e-01f, 1.72209032e-02f, 1.34766638e-01f, 1.42308891e-01f, 5.30087985e-02f, 4.87106740e-02f, -1.00026399e-01f, 1.49483606e-01f, 6.71651736e-02f, -1.46413362e-02f,
  -3.81132849e-02f, 9.84379575e-02f, 1.36935368e-01f, 6.51684254e-02f, 4.85356189e-02f, 1.74597912e-02f, 2.90270168e-02f, -3.25219184e-02f, 1.26780597e-02f, -9.72415954e-02f,
  1.24398164e-01f, -5.43225929e-02f, 1.21610694e-01f, -5.45274578e-02f, -3.32914181e-02f, 2.19434686e-02f, 5.68596460e-02f, 9.15118903e-02f, 3.05419397e-02f, -8.85815918e-03f,
  1.39868576e-02f, 1.79669391e-02f, -2.70199589e-02f, -3.76761816e-02f, -4.96533886e-03f, 6.97657838e-02f, -1.04120988e-02f, 5.51488213e-02f, 7.63306245e-02f, -8.44249327e-04f,
  -1.26839252e-02f, -8.26080330e-03f, 2.50625331e-02f, 2.01957729e-02f, -2.79139485e-02f, 1.86166037e-02f, 4.25069258e-02f, -4.34800982e-02f, 8.08029100e-02f, -7.71766230e-02f,
  7.81401992e-02f, -4.61053140e-02f, -3.05482820e-02f, -4.18242998e-02f, 3.77896391e-02f, -4.15648632e-02f, -6.75713867e-02f, -5.40901311e-02f, 5.22500612e-02f, -1.19632063e-02f,
  6.38890415e-02f, 4.72467989e-02f, 1.41589995e-02f, 4.76808026e-02f, -7.15595856e-02f, -8.21595341e-02f, -2.67590061e-02f, -3.58168259e-02f, -1.79655254e-02f, -2.14731470e-02f,
  -8.91178250e-02f, 1.54735186e-04f, 3.65925431e-02f, -1.94566697e-02f, 1.50766121e-02f, 2.42082472e-03f, -6.17607981e-02f, -3.07753924e-02f, -6.40907362e-02f, -1.65487546e-02f,
  6.49354681e-02f, 5.75089455e-02f, 5.90139739e-02f, 3.42950970e-02f, -8.69106427e-02f, -1.23973107e-02f, -3.60588171e-02f, -4.37379740e-02f, 9.78423879e-02f, 2.10762229e-02f,
  4.87039872e-02f, 3.50219943e-02f, 4.28725332e-02f, -3.14861983e-02f, -7.45607838e-02f, 2.61603226e-03f, 7.33677894e-02f, -2.59304885e-02f, 5.66027313e-02f, -1.00010997e-02f,
  -1.68872848e-02f, 2.11700276e-02f, -1.70273222e-02f, 5.17309122e-02f, -6.93358779e-02f, -7.14750364e-02f, 1.14678048e-01f, 1.01429466e-02f, 6.98881671e-02f, 1.31556857e-02f,
  -3.88254434e-01f, 2.44079679e-02f, 1.45083934e-01f, 6.00221753e-02f, 2.74247319e-01f, 3.34426969e-01f, 5.10270476e-01f, 2.52023071e-01f, -5.28120361e-02f, 7.49635920e-02f,
  -5.02131879e-02f, -1.76427186e-01f, -9.03133452e-02f, -1.84640810e-01f, 1.20950371e-01f, 2.53197551e-01f, 1.31475106e-01f, -8.66490453e-02f, -2.31971350e-02f, 1.53573444e-02f,
  -5.11708744e-02f, -1.04299769e-01f, -2.09129527e-01f, -1.29527941e-01f, 5.13391979e-02f, -2.83941929e-03f, 2.41617318e-02f, -1.21771349e-02f, -2.55415041e-04f, -6.20442852e-02f,
  -1.53803736e-01f, 5.65981455e-02f, -3.27647999e-02f, -4.65078391e-02f, -4.78442647e-02f, -1.21442489e-01f, -2.80685294e-02f, -9.76557136e-02f, -8.90467223e-03f, 1.70099679e-02f,
  -8.78383666e-02f, -8.36668387e-02f, 9.44809914e-02f, -6.72926083e-02f, -5.53082637e-02f, 9.21508521e-02f, -1.17077351e-01f, 5.78627782e-03f, -8.73419363e-03f, -9.46727321e-02f,
  -6.40440080e-03f, 1.16875738e-01f, 9.45666432e-02f, 9.87591818e-02f, 3.13962507e-03f, -1.15122400e-01f, 9.41666439e-02f, 4.65230532e-02f, -4.65298481e-02f, -1.82996809e-01f,
  -4.29539904e-02f, 6.88540265e-02f, 5.57251461e-02f, 4.84898724e-02f, -8.21278915e-02f, 3.04982960e-02f, 7.04442561e-02f, 3.59537918e-03f, 6.17992654e-02f, 5.22557981e-02f,
  -9.59868953e-02f, 4.15005088e-02f, 2.24274267e-02f, -3.25745605e-02f, -1.17243603e-01f, 2.71629784e-02f, 5.54803312e-02f, 2.82191448e-02f, -1.41102955e-01f, -2.95846891e-02f,
  -2.57140566e-02f, 1.74242426e-02f, 2.80836932e-02f, -5.25227189e-02f, 2.87312665e-03f, 1.20933345e-02f, 5.36718629e-02f, -3.29949055e-03f, -1.00303665e-01f, -7.41352811e-02f,
  -2.31669948e-01f, 5.43999486e-02f, -1.29532278e-01f, -5.89161888e-02f, -7.96439946e-02f, -6.27701953e-02f, -6.40984401e-02f, -1.00779809e-01f, 9.00565386e-02f, 2.62577515e-02f,
  1.78727247e-02f, -5.86289950e-02f, -6.93369061e-02f, -9.37155262e-03f, -5.41289523e-02f, -8.56034923e-03f, 1.80103779e-02f, 1.36437118e-02f, -5.80218472e-02f, -6.70801401e-02f,
  3.91688459e-02f, -4.39751260e-02f, -1.12204932e-01f, 3.61466147e-02f, -1.54830158e-01f, -1.40682504e-01f, -3.34397927e-02f, -1.56688303e-01f, -5.92806116e-02f, -9.17210951e-02f,
  -2.62177378e-01f, -1.64772406e-01f, -1.38682812e-01f, -1.82142884e-01f, 5.54990731e-02f, 1.10433429e-01f, -1.03259660e-01f, 9.89963580e-03f, 1.22979015e-01f, -6.99516460e-02f,
  4.35953960e-02f, 6.52572373e-03f, -6.64591119e-02f, 7.67398626e-02f, -2.24499814e-02f, -2.31081814e-01f, -1.60158038e-01f, -1.64891966e-02f, 1.11892574e-01f, 1.14583068e-01f,
  3.64472009e-02f, 2.76531149e-02f, -6.21088818e-02f, -4.54745628e-02f, -8.06661919e-02f, -9.77356881e-02f, -1.86787561e-01f, -1.81558922e-01f, -2.48099584e-02f, -2.34580398e-01f,
  -4.95241173e-02f, -2.39580870e-03f, 7.32265711e-02f, -7.54199624e-02f, -4.96199466e-02f, -5.58831841e-02f, -4.10042424e-03f, -4.09243023e-03f, 8.23778883e-02f, -1.89935695e-02f,
  -1.14420049e-01f, 8.01450238e-02f, -7.67013952e-02f, -8.29419214e-03f, -7.24619031e-02f, -8.37975740e-03f, -9.98938456e-02f, 7.65390620e-02f, -3.53740938e-02f, -1.34636750e-02f,
  -6.01161309e-02f, -8.19672793e-02f, -1.43668316e-02f, 4.07618545e-02f, -2.75995880e-02f, 3.98992235e-03f, -4.41569313e-02f, -1.36394814e-01f, 2.68740710e-02f, -1.41845509e-01f,
  3.40198316e-02f, 2.56524291e-02f, 1.56197054e-02f, -2.35278104e-02f, -2.08585318e-02f, -4.78736088e-02f, 4.27630953e-02f, 2.67774314e-02f, 4.65643220e-02f, -5.22404052e-02f,
  1.13656335e-02f, 1.69540092e-01f, -1.41053619e-02f, -3.06699518e-02f, -4.39124964e-02f, 1.75675619e-02f, -1.81128387e-03f, 3.23501341e-02f, 5.19684926e-02f, -4.84624691e-02f,
  -1.99965667e-02f, 1.72685310e-02f, 9.58367251e-03f, -1.08009204e-02f, -1.17672630e-01f, 6.14432693e-02f, -5.20274304e-02f, 5.08159101e-02f, 5.65787889e-02f, 2.12549940e-02f,
  -1.62379481e-02f, 1.94325969e-01f, -9.85196978e-02f, -1.46583289e-01f, -2.18427591e-02f, 3.07769584e-03f, -4.48924750e-02f, -4.62658778e-02f, -2.55705439e-04f, -2.97795888e-02f,
  8.17663036e-03f, -1.05062284e-01f, -1.01164632e-01f, -2.23920774e-03f, 4.15640883e-02f, -2.89962105e-02f, -1.30402341e-01f, 2.76207831e-02f, -5.34462556e-02f, 3.17543522e-02f,
  -3.00993677e-02f, -3.41758914e-02f, 1.69186778e-02f, -2.79816538e-02f, 1.52917570e-02f, -3.37553471e-02f, -7.43597150e-02f, -8.99987072e-02f, -1.08661518e-01f, -2.32556283e-01f,
  6.44085854e-02f, -1.40560523e-01f, 1.16348974e-01f, 7.66912848e-02f, 4.62800488e-02f, -2.84692086e-02f, -1.42222280e-02f, -5.94932102e-02f, 9.04365852e-02f, -8.51107836e-02f,
  -6.86193183e-02f, 8.57278183e-02f, -6.15552999e-02f, 1.07232146e-01f, 6.99163228e-02f, -8.00423771e-02f, 8.26750100e-02f, 8.33332017e-02f, 1.43282458e-01f, 7.98840225e-02f,
  -7.38423094e-02f, 2.53105219e-02f, 6.98270567e-04f, 9.40124691e-03f, -3.65020894e-02f, 1.52177373e-02f, -3.56490687e-02f, 2.01321598e-02f, -4.29049358e-02f, -1.15006439e-01f,
  -1.39861526e-02f, -9.16762725e-02f, 5.91167063e-02f, 3.09910923e-02f, 6.23866655e-02f, 3.98068987e-02f, 6.11347146e-02f, -7.00064227e-02f, -4.84733190e-03f, -9.79074687e-02f,
  4.58422229e-02f, -5.61204441e-02f, 8.73120595e-03f, -3.56151699e-03f, 2.07732301e-02f, -1.07975632e-01f, -2.28804592e-02f, -5.18654026e-02f, -2.72746366e-02f, -6.81650043e-02f,
  3.58801298e-02f, 3.58268656e-02f, -3.80835379e-03f, 9.86500271e-03f, 6.70855641e-02f, 9.84520465e-02f, 6.66647255e-02f, 9.28934887e-02f, 1.85088869e-02f, 5.78174479e-02f,
  1.02211379e-01f, 7.96810016e-02f, -4.10472751e-02f, -8.54280218e-03f, -6.61115795e-02f, -6.16384670e-03f, 5.93130104e-02f, 1.07514020e-02f, 2.17535757e-02f, -2.00413773e-03f,
  5.95220886e-02f, 1.38731180e-02f, -5.33035211e-02f, 6.06682375e-02f, 1.02443462e-02f, -3.17440964e-02f, -4.82596718e-02f, 4.29324880e-02f, -6.31197467e-02f, -7.70576745e-02f,
  7.17494041e-02f, -3.19983885e-02f, 3.26540172e-02f, 2.15615090e-02f, 3.09570078e-02f, -4.00809525e-03f, 1.64070968e-02f, 6.36887401e-02f, -6.78304955e-02f, -1.60117522e-02f,
  -1.35171693e-02f, 1.50440037e-01f, -6.88861087e-02f, -7.75726810e-02f, -2.23710053e-02f, -6.01710975e-02f, 2.55654398e-02f, 7.02542812e-02f, -2.67357584e-02f, -1.03961885e-01f,
  2.53810845e-02f, 4.18511145e-02f, 6.13883808e-02f, -3.68554108e-02f, -2.96594054e-02f, -3.56268510e-02f, 3.53169553e-02f, 7.29786381e-02f, -3.78305689e-02f, -1.61972940e-02f,
  2.79336832e-02f, -8.43634009e-02f, -5.14764972e-02f, 8.29936191e-02f, -8.50998387e-02f, 5.91587983e-02f, 7.26052299e-02f, -3.36390920e-02f, 2.69691907e-02f, -9.59605873e-02f,
  -5.68895459e-01f, -2.43974999e-01f, -4.22144204e-01f, -3.75364453e-01f, 3.01951002e-02f, 2.32042432e-01f, 8.42850953e-02f, 1.29462048e-01f, 2.73575075e-03f, -2.55712215e-02f,
  -5.07881865e-03f, -4.52963486e-02f, -1.12631522e-01f, 3.67083363e-02f, 8.79785642e-02f, -1.78510055e-01f, -1.82696968e-01f, -2.02419892e-01f, 4.58619073e-02f, 2.25248531e-01f,
  8.81511569e-02f, -3.03394705e-01f, -1.85244486e-01f, 6.53967354e-03f, -1.26829863e-01f, -1.86937928e-01f, -2.29060903e-01f, -2.28383347e-01f, 5.17863333e-02f, -2.87802219e-01f,
  -2.64829606e-01f, -1.07591478e-02f, 1.18497834e-01f, -4.12326632e-03f, -1.18569300e-01f, 7.84681514e-02f, -4.07393500e-02f, -1.40301317e-01f, -2.40236055e-02f, 5.93617372e-02f,
  -3.00147999e-02f, 4.40204367e-02f, -1.03611842e-01f, -5.16646281e-02f, -1.45586254e-02f, 5.01095541e-02f, 2.81079076e-02f, -4.39925008e-02f, -2.70477775e-03f, 1.62275881e-01f,
  -1.94650199e-02f, 7.61625394e-02f, 3.48992348e-02f, 1.54621929e-01f, 1.64025113e-01f, -1.74885765e-02f, -1.67268291e-02f, 1.65021047e-01f, 1.16267987e-01f, 2.89430693e-02f,
  6.67633042e-02f, 9.33692791e-03f, 2.59821247e-02f, 7.49457851e-02f, 9.14852321e-03f, 9.48361494e-03f, -3.45765650e-02f, -6.19854443e-02f, 1.13745742e-02f, 2.89853606e-02f,
  -5.56113548e-04f, 1.19155217e-02f, 4.08532619e-02f, -1.09508730e-01f, -4.48774174e-02f, 6.76589608e-02f, 1.86224543e-02f, -3.74609679e-02f, 2.83229537e-02f, 1.15460018e-02f,
  5.64015955e-02f, -2.72049699e-02f, -1.07077196e-01f, 2.31364761e-02f, 6.08893558e-02f, -3.70035507e-03f, 4.49969918e-02f, 7.85823688e-02f, 3.07260435e-02f, 4.79032099e-02f,
  -2.99019575e-01f, 7.54289553e-02f, -1.83678329e-01f, 3.08239907e-02f, -6.41546547e-02f, -1.18708517e-02f, -1.01628959e-01f, 4.48958911e-02f, -5.26708104e-02f, 3.50021683e-02f,
  2.88877618e-02f, 2.72060372e-02f, -1.14227779e-01f, 9.31879655e-02f, 4.43896912e-02f, 4.00984399e-02f, 8.26278180e-02f, -4.06823941e-02f, 1.46738261e-01f, 2.38338411e-02f,
  6.53084880e-03f, 1.23953730e-01f, -1.27790319e-02f, 1.30020622e-02f, 1.10790335e-01f, -1.08075999e-01f, -1.47192050e-02f, 3.31541374e-02f, -3.80521789e-02f, -2.22515091e-01f,
  -6.24951571e-02f, -1.06975742e-01f, -1.22999303e-01f, 1.01413898e-01f, 1.09300017e-01f, -1.01493269e-01f, -1.77759036e-01f, -1.48227900e-01f, 4.15806025e-02f, 2.94371624e-03f,
  1.73381880e-01f, 1.07730135e-01f, 6.43590763e-02f, 6.97475150e-02f, -6.85790647e-03f, -1.28668342e-02f, -8.15479606e-02f, 6.53751642e-02f, -4.36761938e-02f, 4.41861749e-02f,
  -3.68561270e-03f, 3.47784758e-02f, 6.88697621e-02f, -6.31968752e-02f, 7.54075348e-02f, 2.80577410e-02f, -4.50197011e-02f, -2.06174701e-02f, 1.00682750e-01f, 5.27056940e-02f,
  1.16691574e-01f, -1.67334415e-02f, 9.06433538e-02f, 9.91946906e-02f, 4.52412181e-02f, 3.63431834e-02f, -4.60634269e-02f, 4.55193333e-02f, -3.53674889e-02f, -9.96125937e-02f,
  9.10758134e-03f, 6.13237508e-02f, -1.02027088e-01f, -4.86198813e-02f, -7.10043684e-03f, -2.95357741e-02f, -1.18725762e-01f, -9.41618904e-02f, -5.41793741e-02f, -1.15078621e-01f,
  9.27466527e-02f, 9.17687118e-02f, -8.12951196e-03f, -4.26464304e-02f, -9.09171402e-02f, -3.76101211e-02f, 1.69894062e-02f, 5.91184199e-02f, 2.26729047e-02f, -9.70411673e-02f,
  -5.61811253e-02f, 5.21556884e-02f, 4.43158746e-02f, 3.90077289e-03f, -4.10895385e-02f, 6.51878789e-02f, 8.62558708e-02f, 1.20027820e-02f, -3.64731997e-02f, 7.02551529e-02f,
  7.80844986e-02f, -2.57353224e-02f, -3.09256781e-02f, -7.33170286e-02f, -1.61570162e-02f, 7.44579732e-02f, 8.60152766e-02f, 4.69386429e-02f, 7.31066754e-03f, -2.06040479e-02f,
  5.06115593e-02f, -3.43699567e-02f, 1.95043758e-02f, 5.02270833e-03f, 1.14771403e-01f, 8.23710859e-02f, 3.11011467e-02f, 9.74833146e-02f, -9.73798484e-02f, 5.18206619e-02f,
  1.30024897e-02f, -1.91319082e-02f, -5.06140701e-02f, 9.59463324e-03f, -3.15221027e-02f, 8.61275494e-02f, 6.83370084e-02f, 3.80445085e-02f, 5.30353077e-02f, 8.64939857e-03f,
  6.31949455e-02f, -7.13113546e-02f, 9.37960371e-02f, -6.58998340e-02f, -5.14693707e-02f, 4.34439853e-02f, 7.53131062e-02f, -7.38884509e-03f, 7.57811144e-02f, 3.12445387e-02f,
  2.62538418e-02f, -3.24992067e-03f, 4.66007851e-02f, -5.37511185e-02f, -1.28553121e-03f, 1.14906207e-01f, -5.91497356e-03f, -6.74160151e-03f, 4.19945223e-03f, -4.74470258e-02f,
  6.74399555e-01f, -6.85984194e-01f, -2.00964719e-01f, 1.54215172e-01f, -1.68041468e-01f, 6.12345822e-02f, -2.57689297e-01f, 4.81515490e-02f, 2.46491462e-01f, -1.46781564e-01f,
  -9.83987376e-02f, 1.08160354e-01f, 1.67379558e-01f, -6.34651538e-03f, 1.78743824e-01f, -1.62512615e-01f, -1.30380735e-01f, 6.65815398e-02f, 3.79536986e-01f, 1.14387043e-01f,
  -1.16649836e-01f, 2.93112826e-02f, 2.34732389e-01f, 2.39214301e-01f, -2.66069204e-01f, 9.34201851e-02f, -2.35412717e-01f, -2.28302866e-01f, -1.44701660e-01f, -5.26010334e-01f,
  -4.83382381e-02f, -2.30465665e-01f, 1.16244070e-01f, 6.49540126e-02f, -1.00451365e-01f, 4.36259620e-02f, 2.41913814e-02f, -9.41809416e-02f, -4.76085506e-02f, -1.18705193e-02f,
  -7.81273320e-02f, -3.18115205e-02f, 2.61459034e-02f, -6.59155995e-02f, -4.00705338e-02f, 6.32360671e-03f, -1.10418536e-02f, -9.54000801e-02f, 3.36911790e-02f, -4.18439135e-02f,
  -5.56132607e-02f, -9.32454243e-02f, -5.85760660e-02f, -4.48955409e-02f, 8.04118812e-02f, 5.07747754e-02f, -1.39830768e-01f, -1.11520991e-01f, 4.99982685e-02f, -3.31260383e-01f,
  -5.39569296e-02f, 3.79729718e-02f, 2.79398765e-02f, -3.19509432e-02f, 6.82492256e-02f, -4.22863215e-02f, -3.05006746e-02f, -8.76256973e-02f, 3.91169451e-02f, -5.32580651e-02f,
  2.86004525e-02f, -2.40996741e-02f, 3.48334014e-02f, -1.90628245e-02f, -6.51426464e-02f, -2.31864024e-02f, 2.91379765e-02f, 7.91103812e-04f, 8.98989290e-02f, 6.84697852e-02f,
  6.31623045e-02f, 4.36118729e-02f, -2.87228879e-02f, -4.90745492e-02f, -1.20031582e-02f, -2.50635147e-02f, 8.21893513e-02f, -2.89457873e-03f, 3.34500079e-03f, 4.54531610e-02f,
  1.61504894e-01f, 1.66611403e-01f, 1.06894664e-01f, 2.30547972e-02f, -5.14022596e-02f, 4.66463389e-03f, -3.84307168e-02f, 5.99398613e-02f, 1.89686660e-03f, 1.29375206e-02f,
  1.58840267e-03f, 4.54983674e-02f, -6.17323555e-02f, -6.20072754e-03f, 8.02074000e-03f, 5.03600203e-02f, -9.18432605e-03f, 5.28486148e-02f, -5.41164959e-03f, -1.56964622e-02f,
  -6.13210350e-03f, 1.13141760e-01f, 1.57701984e-01f, 1.19474284e-01f, -1.16210990e-03f, 1.59126818e-01f, -2.40427442e-03f, 1.86816975e-02f, 8.91328305e-02f, 4.43655662e-02f,
  6.57227263e-02f, -1.29793182e-01f, -8.61726254e-02f, -1.19800381e-01f, -2.41170913e-01f, -1.90600246e-01f, -2.05285043e-01f, -1.09900325e-03f, -1.06818609e-01f, -2.41042271e-01f,
  -1.98312953e-01f, -1.22266099e-01f, 6.64852560e-02f, -1.33566523e-03f, 1.34747058e-01f, -9.42583755e-02f, -4.10353951e-02f, 5.72332591e-02f, 3.07463687e-02f, -1.05787665e-01f,
  -1.54506862e-01f, -9.97686014e-02f, 9.04088020e-02f, -4.27244566e-02f, -7.85187781e-02f, -9.20087993e-02f, -3.82603630e-02f, -1.20888375e-01f, -7.73428679e-02f, -1.20961264e-01f,
  -2.21124738e-01f, -6.06354810e-02f, -2.09631845e-02f, -1.36438729e-02f, 1.71765722e-02f, -8.19908641e-03f, -8.22805390e-02f, 1.87898371e-02f, -4.56529530e-03f, 6.68283179e-02f,
  -8.04338530e-02f, -8.59746430e-03f, -7.43476972e-02f, 2.00520921e-02f, -7.52994120e-02f, -3.89086083e-02f, -2.81279255e-03f, 1.34233490e-01f, 2.86367070e-02f, -4.46874201e-02f,
  -8.22318792e-02f, -1.64635018e-01f, 9.70565435e-03f, 6.99570626e-02f, -8.71128961e-03f, 7.08545893e-02f, -1.31762236e-01f, -2.79199594e-04f, 4.06531133e-02f, -1.87265515e-01f,
  7.09451884e-02f, -9.30206701e-02f, -6.78707361e-02f, 2.34510936e-03f, -2.56522442e-03f, 1.14502713e-01f, -1.91859975e-02f, -8.40522908e-03f, -1.10263713e-02f, -2.83765197e-02f,
  5.89541495e-02f, 2.58692112e-02f, 4.61585373e-02f, -8.15180168e-02f, 1.08698577e-01f, 3.49681824e-02f, 4.60967161e-02f, -5.75420000e-02f, -9.84664448e-03f, 4.33147326e-02f,
  -5.73285446e-02f, 3.64008285e-02f, -1.24312863e-02f, 8.67894664e-02f, 5.08668423e-02f, -3.23999149e-04f, 2.10646708e-02f, 1.63557697e-02f, 9.54767689e-03f, -1.48898354e-02f,
  -1.28102958e-01f, 1.94276214e-01f, -1.15174003e-01f, 4.27601021e-03f, 9.91512672e-04f, 2.38532871e-02f, -1.01659462e-01f, -4.92685894e-03f, -2.41451967e-03f, -8.24291781e-02f,
  -3.33638526e-02f, -1.52445007e-02f, -2.90238149e-02f, -7.88355898e-03f, -2.24829838e-03f, -1.03856757e-01f, 3.21132429e-02f, -7.16093183e-02f, 8.96976143e-02f, -6.85310885e-02f,
  1.05048805e-01f, -9.62910354e-02f, 6.74905442e-03f, -7.78782666e-02f, 1.77066773e-02f, -3.93239409e-02f, -2.18551178e-02f, -1.07399590e-01f, 8.35302100e-02f, -1.00142255e-01f,
  -1.63188383e-01f, -8.08321983e-02f, -2.67712295e-01f, -1.19312495e-01f, -5.97140845e-03f, -1.54346123e-01f, -3.06309372e-01f, 3.07600759e-02f, 1.12549216e-01f, -2.28347361e-01f,
  -1.02067553e-01f, 6.52661920e-02f, -5.67288287e-02f, 6.29778057e-02f, -2.23049894e-01f, -4.20258760e-01f, -4.21168685e-01f, -2.69094229e-01f, 3.03692720e-03f, 7.35861436e-02f,
  -8.15783739e-02f, -9.47861746e-02f, 3.62780243e-02f, 3.42304036e-02f, 1.25329062e-01f, 1.35264635e-01f, -1.56972334e-01f, -3.46958116e-02f, -7.85775408e-02f, -8.21868032e-02f,
  -4.27633554e-01f, -5.94350584e-02f, -5.23808263e-02f, -4.88603525e-02f, -5.49389198e-02f, 2.19524428e-02f, -9.45886746e-02f, 2.66217515e-02f, 7.35905617e-02f, -1.61402188e-02f,
  -7.34777153e-02f, 6.02967218e-02f, 7.43320510e-02f, 4.88497391e-02f, -3.45447920e-02f, -8.01917911e-02f, -8.85286648e-03f, -2.24947259e-02f, 3.34139802e-02f, -1.03946384e-02f,
  -5.89341857e-02f, -1.86050795e-02f, -1.16849922e-01f, 1.22921653e-01f, -2.67813302e-04f, 3.00405789e-02f, 7.01452941e-02f, 1.11166261e-01f, 1.01638824e-01f, -4.63221073e-02f,
  -2.25010943e-02f, -8.05661529e-02f, -1.18964899e-03f, 5.32720387e-02f, -6.34580627e-02f, -1.03110867e-02f, -5.74699156e-02f, 3.99416573e-02f, -2.72451229e-02f, -3.17998491e-02f,
  -4.88517433e-02f, -4.79269177e-02f, -2.05114298e-03f, -3.34763862e-02f, 1.33151244e-02f, 1.61567908e-02f, 5.28121367e-03f, -2.95750070e-02f, -1.62389129e-02f, 2.36611068e-02f,
  -7.20715746e-02f, 3.33212726e-02f, -4.00006771e-02f, 8.25185254e-02f, -7.70366266e-02f, -9.54468250e-02f, 2.47305520e-02f, -8.67028197e-04f, 1.84387155e-02f, -4.46713604e-02f,
  1.43646553e-01f, -9.79584605e-02f, -8.16590264e-02f, 5.98528124e-02f, -5.39661869e-02f, 3.97595949e-03f, 4.02281135e-02f, -1.99724874e-03f, 1.89759620e-02f, -2.08491292e-02f,
  -2.09833272e-02f, 5.58695011e-02f, -4.90260869e-02f, 6.90689217e-03f, -3.89001565e-03f, -1.60324946e-02f, -7.82343745e-02f, -8.28777105e-02f, -4.78157029e-02f, 4.64668870e-02f,
  -8.61254334e-02f, -5.12117967e-02f, -4.43133079e-02f, -7.21398294e-02f, 8.49043876e-02f, -3.41940522e-02f, -3.20111327e-02f, 8.48566517e-02f, -7.82429576e-02f, -8.00939873e-02f,
  2.73829959e-02f, -9.07857195e-02f, -9.45739355e-03f, 8.64367038e-02f, -2.63312943e-02f, -1.14240102e-01f, -9.65911373e-02f, 1.80220082e-02f, 3.92870419e-02f, 8.81465450e-02f,
  -2.43301652e-02f, -9.13989991e-02f, 2.82777548e-02f, -1.58113390e-01f, -3.08519769e-02f, -1.25679553e-01f, 3.94567996e-02f, -9.64622870e-02f, -1.61022544e-01f, -3.11690383e-02f,
  -1.24082297e-01f, -1.19976483e-01f, -1.11238435e-01f, -5.24543598e-03f, -7.72386882e-03f, -2.68426742e-02f, -5.30027151e-02f, -6.86915219e-02f, -1.38526648e-01f, -1.25785157e-01f,
  3.58801335e-02f, -5.12802452e-02f, -9.74622443e-02f, -2.17954647e-02f, 6.94103092e-02f, 3.56941931e-02f, 3.17675732e-02f, 5.57425395e-02f, -1.85495801e-02f, 3.07749771e-02f,
  -9.84427854e-02f, -1.06837243e-01f, -6.25944734e-02f, -1.25547498e-02f, 4.77164285e-03f, -3.55673693e-02f, 4.96620908e-02f, 4.54596505e-02f, -8.48475322e-02f, -3.52150239e-02f,
  -3.57418321e-02f, -3.18209268e-02f, -1.50346914e-02f, 8.65423772e-03f, -9.18936059e-02f, -8.74053314e-02f, 6.47941530e-02f, 3.54421735e-02f, -5.68091571e-02f, 1.04957461e-01f,
  7.40126967e-02f, -1.04864547e-02f, -4.96031065e-03f, -8.19586292e-02f, -2.55864430e-02f, -3.59217003e-02f, 1.00587979e-02f, 5.73819019e-02f, 7.04540014e-02f, 5.90077899e-02f,
  -7.11643547e-02f, 2.96463072e-03f, -3.99837270e-02f, 2.87775625e-03f, 1.91639625e-02f, 7.49421865e-02f, 6.68705851e-02f, -4.55583781e-02f, 3.57473865e-02f, -1.30825210e-02f,
  6.72207922e-02f, -9.69273504e-03f, 2.16124989e-02f, -6.66854307e-02f, -7.43139442e-03f, 9.02804881e-02f, 5.04273921e-04f, 3.34897898e-02f, -4.70182113e-03f, -4.67348173e-02f,
  -2.69324929e-02f, -1.27917051e-01f, 1.73931308e-02f, -6.17050529e-02f, -3.65166515e-02f, 1.34191617e-01f, 9.72466730e-03f, 2.59257271e-03f, 5.74890189e-02f, -4.91371863e-02f,
  -6.05483390e-02f, 5.86345531e-02f, 2.65648346e-02f, -5.68200648e-02f, -9.39722583e-02f, 7.79239461e-03f, -6.30401894e-02f, -8.10092036e-03f, -2.84237601e-02f, 4.47370559e-02f,
  -1.70687921e-02f, -5.38084074e-04f, 2.63978615e-02f, 1.39123006e-02f, 7.16083646e-02f, -9.00753960e-02f, -8.90047476e-02f, -5.96983582e-02f, -6.67714328e-02f, 1.29632577e-01f,
  -2.55245298e-01f, 5.78102544e-02f, -1.47928700e-01f, 2.49518603e-01f, 3.56129587e-01f, 2.24397793e-01f, 2.65885085e-01f, 2.01331213e-01f, 4.50654551e-02f, 4.71256301e-02f,
  2.34093238e-02f, 3.57915089e-02f, 1.08034521e-01f, 3.71405929e-02f, -1.02040796e-02f, 6.70007244e-02f, 2.42380440e-01f, -2.70399489e-02f, -1.84929311e-01f, 3.64459492e-02f,
  1.00548960e-01f, 3.16365361e-02f, -1.45922333e-01f, 4.00716290e-02f, 6.73757643e-02f, -4.30719228e-03f, -4.11213674e-02f, 9.49717611e-02f, 6.30474910e-02f, 2.59179056e-01f,
  -1.26523897e-01f, 3.03163915e-03f, 2.24483851e-03f, -6.74854368e-02f, 3.35469246e-02f, -1.21564709e-01f, 1.34452954e-02f, -1.04597420e-01f, 2.72191446e-02f, -4.51317653e-02f,
  7.17156678e-02f, -1.04879834e-01f, 1.49610648e-02f, 2.71037761e-02f, -1.01462103e-01f, -5.82490154e-02f, -1.41490936e-01f, -5.50231785e-02f, -5.48842959e-02f, 1.35173155e-02f,
  1.74583778e-01f, 7.11274594e-02f, 4.33601066e-03f, -6.06628172e-02f, 6.28615767e-02f, 7.67368600e-02f, 2.18028165e-02f, -5.26858494e-02f, -5.45048080e-02f, 1.63674540e-05f,
  2.07175203e-02f, 4.00477499e-02f, 1.24531733e-02f, -5.30172661e-02f, 8.57488066e-02f, 9.00188684e-02f, -8.44339803e-02f, 1.05013256e-03f, 4.48486507e-02f, -3.07339169e-02f,
  -4.59309034e-02f, -2.32141223e-02f, -1.57311573e-04f, 2.26940922e-02f, 1.76550262e-02f, -1.02385040e-02f, 7.86230192e-02f, 5.33471890e-02f, -5.47930747e-02f, -8.31998326e-03f,
  -3.43387984e-02f, 1.86003670e-02f, -4.91262674e-02f, 4.25426364e-02f, -3.30438912e-02f, 6.10178337e-03f, 4.18933518e-02f, -1.20874293e-01f, -1.07473675e-02f, -8.17070454e-02f,
  1.73608381e-02f, -5.14470860e-02f, 2.20163483e-02f, -6.31175861e-02f, 3.01433988e-02f, -7.26713538e-02f, 6.29312173e-02f, -7.49673396e-02f, -6.83388263e-02f, 5.96197695e-02f,
  1.38221700e-02f, 5.04882112e-02f, 1.21020421e-03f, -5.52678630e-02f, -9.78502408e-02f, -2.01368798e-02f, -5.91402911e-02f, -3.67492177e-02f, 4.78113703e-02f, 3.07776462e-02f,
  6.10734560e-02f, 3.51620130e-02f, -1.24096736e-01f, -6.44440204e-02f, 1.12167783e-01f, 9.63156670e-03f, -4.99476530e-02f, -7.41828904e-02f, 1.79513413e-02f, -1.58114344e-01f,
  3.24599594e-02f, -6.14679381e-02f, -7.55943879e-02f, 6.88917860e-02f, 1.08951248e-01f, 1.02875993e-01f, 3.26164924e-02f, -4.72307168e-02f, 9.27745849e-02f, -7.93837830e-02f,
  -2.63569411e-03f, -3.12100258e-02f, 6.24155328e-02f, 5.50852902e-02f, 3.17460895e-02f, -3.05350404e-02f, -4.31299489e-03f, -2.48312447e-02f, -5.27075082e-02f, -3.74531336e-02f,
  4.20817025e-02f, -6.74445555e-02f, -3.26345563e-02f, 3.65766622e-02f, 3.52121219e-02f, -5.68992123e-02f, 7.80212134e-02f, -3.23840380e-02f, -4.02828269e-02f, -7.02403039e-02f,
  4.92394306e-02f, -1.53630376e-02f, 7.69993290e-02f, -6.77605392e-03f, -2.51708496e-02f, -9.29590017e-02f, -2.44173454e-03f, -2.17818916e-02f, 8.03054944e-02f, 2.18957197e-02f,
  3.19827422e-02f, -2.74499897e-02f, -3.44862081e-02f, -3.22641246e-03f, -9.50950310e-02f, 4.69736345e-02f, -6.87104389e-02f, 4.76089306e-02f, 7.34728351e-02f, -8.76828749e-03f,
  8.99761543e-02f, -7.27292225e-02f, -8.63795169e-03f, 3.64264622e-02f, -7.71457888e-03f, 7.24427076e-03f, -6.47493750e-02f, -4.73583490e-02f, -7.59182945e-02f, -8.81582033e-03f,
  -6.56640083e-02f, 7.58335963e-02f, -1.42513644e-02f, -3.62073444e-02f, 3.19919772e-02f, -7.50121102e-03f, 1.02010351e-02f, 6.80516884e-02f, 5.59889711e-03f, -1.18731074e-01f,
  -7.65068131e-03f, -6.90217540e-02f, -7.24672899e-02f, -6.68172762e-02f, -6.72670454e-02f, -5.11375368e-02f, -6.86205477e-02f, -9.15367380e-02f, -6.21786416e-02f, -4.38213982e-02f,
  -2.51731221e-02f, 6.26139343e-02f, -7.78197944e-02f, -3.19173783e-02f, 2.62056943e-02f, 2.17926446e-02f, 8.15838277e-02f, 5.48857152e-02f, -2.95576379e-02f, -4.71895784e-02f,
  -8.13193023e-02f, 1.27307966e-01f, 2.51263119e-02f, 8.99797119e-03f, -4.65012379e-02f, 7.74826184e-02f, 8.25893357e-02f, 6.39575198e-02f, 4.11275662e-02f, 2.19486691e-02f,
  -8.45826715e-02f, 5.20886369e-02f, -7.38043115e-02f, 6.49044570e-03f, -4.80688885e-02f, 3.49930860e-02f, 3.16689946e-02f, -7.87341967e-03f, 5.91976196e-02f, 8.50438327e-02f,
  7.97894299e-02f, 4.62639071e-02f, 6.20725118e-02f, -2.87987827e-03f, -5.29024377e-02f, -3.62388454e-02f, 8.64965655e-03f, 3.05249151e-02f, -4.40790094e-02f, 2.27463897e-02f,
  4.13881801e-02f, -1.45880699e-01f, -2.63472777e-02f, 1.53711423e-01f, 1.27651945e-01f, 1.05732158e-01f, -1.89776227e-01f, -6.75046146e-02f, 2.88189407e-02f, -2.95059173e-03f,
  2.71626394e-02f, 2.67098695e-01f, 1.06295712e-01f, 2.96551101e-02f, -2.22956296e-02f, -4.68685664e-02f, -9.85453427e-02f, -6.63013160e-02f, 7.34015321e-03f, 1.06610563e-02f,
  1.69601873e-03f, 9.42533463e-02f, 4.23527509e-03f, -4.65350449e-02f, -3.31151783e-02f, -7.18376506e-03f, -1.21596515e-01f, -4.40047495e-03f, -1.45399868e-02f, 8.87475312e-02f,
  1.50027037e-01f, -1.03346840e-01f, -3.02496441e-02f, -5.61200827e-02f, -1.94632448e-02f, -5.03338650e-02f, 5.82296140e-02f, -6.16783835e-03f, -4.76987474e-02f, -1.48795992e-02f,
  3.22681554e-02f, -6.98003769e-02f, -1.69327948e-02f, 7.41883293e-02f, -8.05015415e-02f, 2.30230484e-03f, -1.14115641e-01f, -6.07640576e-03f, -2.48189736e-02f, -1.05879873e-01f,
  5.62808104e-02f, -5.87570705e-02f, -7.88514540e-02f, -3.46886776e-02f, -1.02173656e-01f, 4.27383594e-02f, -4.49883491e-02f, -5.08338166e-03f, -1.11820206e-01f, -2.72441786e-02f,
  7.69972475e-03f, -1.26819033e-02f, 2.59971321e-02f, 5.33406660e-02f, -9.87012964e-03f, 1.76974162e-02f, 3.35125476e-02f, -2.14327686e-02f, -1.05275065e-01f, -1.77275147e-02f,
  5.79932518e-02f, -4.48768102e-02f, -1.14366189e-02f, 1.87228601e-02f, -5.18981740e-02f, -4.40703221e-02f, -5.58075681e-02f, -7.14177713e-02f, -1.23338494e-02f, -2.54278257e-02f,
  -8.11034292e-02f, -3.00740618e-02f, -2.27709506e-02f, -3.51630189e-02f, -1.20252952e-01f, 5.77010214e-02f, -5.54873087e-02f, -2.61575822e-03f, -2.19570063e-02f, 5.65976091e-02f,
  9.60564241e-02f, 1.57297164e-01f, 9.42152515e-02f, 2.32755188e-02f, 5.74265886e-03f, -5.26419207e-02f, -6.79670796e-02f, 1.80792455e-02f, 3.79374214e-02f, 3.36611867e-02f,
  -7.70470053e-02f, -1.04845886e-03f, 2.14425568e-03f, -6.00843951e-02f, -4.29442935e-02f, -2.45056320e-02f, -9.90927070e-02f, -2.29180325e-02f, -9.46909338e-02f, -7.35068992e-02f,
  -9.37725753e-02f, -1.69384956e-01f, -9.14293453e-02f, -7.20416307e-02f, -4.10418622e-02f, -3.00077591e-02f, -7.76383728e-02f, -5.10235950e-02f, 1.76554034e-03f, -1.15909234e-01f,
  -9.83390585e-02f, 3.36497538e-02f, 2.02055853e-02f, -1.00443006e-01f, -7.20894337e-02f, -3.82557907e-03f, -5.28290346e-02f, -1.71593651e-02f, -5.82898855e-02f, 1.59691200e-02f,
  1.04642898e-01f, 4.22631875e-02f, 1.04648843e-01f, 1.52690515e-01f, -7.49852806e-02f, 4.88154925e-02f, 2.65287869e-02f, -9.58482027e-02f, -1.14627682e-01f, -5.44210598e-02f,
  -4.29660901e-02f, -3.23051214e-02f, -3.61175835e-02f, 4.11129184e-02f, 4.03411947e-02f, -1.61425024e-02f, -2.19467971e-02f, 7.59254768e-02f, -4.04030308e-02f, 9.43774059e-02f,
  8.95773619e-02f, -7.36555085e-02f, 7.62497634e-02f, 7.31486902e-02f, -6.30264031e-03f, 1.28745260e-02f, -5.88894561e-02f, -5.43115474e-02f, 1.67702697e-02f, 9.04662609e-02f,
  6.17407523e-02f, -1.14158411e-02f, -8.18720236e-02f, 6.31441548e-02f, 7.47534679e-03f, 1.22941202e-02f, -3.24032977e-02f, -2.70198360e-02f, 5.59428670e-02f, 1.91464238e-02f,
  -6.00615628e-02f, -8.20253268e-02f, -1.69692505e-02f, 1.01398766e-01f, 3.97153422e-02f, 1.46473080e-01f, 1.11458644e-01f, 1.12499297e-01f, 7.34264031e-02f, 6.09911457e-02f,
  -1.17334001e-01f, 8.68095644e-03f, -3.24238464e-02f, 4.26333882e-02f, -5.51280640e-02f, -8.19392577e-02f, 8.05400684e-03f, -5.96808270e-02f, -8.58429521e-02f, -7.27748424e-02f,
  -6.56400248e-02f, -4.05505896e-02f, -2.01982036e-02f, -8.03816598e-03f, -3.95571440e-02f, 3.93737922e-04f, -8.94252062e-02f, -7.38256499e-02f, 5.16697317e-02f, -4.91689406e-02f,
  -3.95724215e-02f, 1.93896927e-02f, 5.06833419e-02f, -6.06244914e-02f, 1.57489034e-03f, 1.76457595e-02f, -8.99792165e-02f, 9.12088528e-02f, -5.73664345e-02f, -4.10038643e-02f,
  6.91501126e-02f, 9.20241550e-02f, 1.26402617e-01f, -4.30998355e-02f, 7.04358146e-02f, -8.66121128e-02f, 3.46813798e-02f, -1.22675896e-02f, 7.59882256e-02f, 9.38125700e-03f,
  6.36388808e-02f, -6.08248040e-02f, -7.65714720e-02f, -1.30911972e-02f, 6.48626313e-02f, 1.00949526e-01f, -5.44953682e-02f, 1.45220282e-02f, 5.04197180e-02f, 5.93906157e-02f,
  1.05177566e-01f, 1.50060402e-02f, 1.33373395e-01f, 8.89861882e-02f, 4.94245924e-02f, -1.46892744e-05f, 5.98371625e-02f, -1.66716203e-02f, 6.93427250e-02f, 5.10010384e-02f,
  -1.43627524e-01f, -1.42129853e-01f, -1.03535123e-01f, 5.45883700e-02f, 8.84135719e-03f, 9.67034474e-02f, 2.69397628e-02f, -8.34843889e-02f, -1.45799974e-02f, 5.14488108e-02f,
  8.52606073e-02f, 1.38860151e-01f, 1.36548758e-01f, 6.04966655e-03f, 2.09133513e-02f, 1.34926932e-02f, 9.08974782e-02f, 9.15603638e-02f, -5.18155359e-02f, 6.27496764e-02f,
  1.47493452e-01f, 4.42232229e-02f, -2.07489040e-02f, 5.82366902e-03f, 7.50062093e-02f, 1.11663997e-01f, -9.42670852e-02f, 1.14340456e-02f, 4.82070670e-02f, -9.41723883e-02f,
  2.72081532e-02f, -1.10399820e-01f, 2.46056784e-02f, 1.20717265e-01f, -2.74495478e-03f, -1.22500762e-01f, -4.49115830e-03f, 1.30032916e-02f, -1.28771989e-02f, -1.14146441e-01f,
  2.87538320e-02f, -7.70373270e-02f, 1.11661274e-02f, 9.41004902e-02f, -1.01559527e-01f, -6.93321377e-02f, 5.47596365e-02f, -6.87523857e-02f, -4.14253259e-03f, -5.19737899e-02f,
  -7.14904675e-03f, 1.99696352e-03f, 1.70393493e-02f, -1.12758569e-01f, -8.62340778e-02f, 2.99855955e-02f, -1.01683803e-01f, -1.01033546e-01f, 4.95610107e-03f, -6.97263405e-02f,
  8.05872008e-02f, 1.71993356e-02f, -1.69274155e-02f, -2.02178843e-02f, -2.94165798e-02f, 1.37118641e-02f, -2.68668737e-02f, 2.97004990e-02f, 7.54194856e-02f, -6.87774569e-02f,
  -3.24348360e-02f, 7.42565244e-02f, 9.14040545e-04f, -3.49085890e-02f, 6.31137267e-02f, 5.48587143e-02f, 4.42471206e-02f, 7.81067386e-02f, 8.25553089e-02f, -3.27311978e-02f,
  2.08470486e-02f, -5.99326454e-02f, 7.75272697e-02f, 8.28933194e-02f, 1.10734321e-01f, 3.34778652e-02f, 2.03881529e-03f, -9.09911618e-02f, -1.10016242e-02f, 2.03418080e-02f,
  -1.23972982e-01f, 1.34249896e-01f, 5.39554954e-02f, -2.50631440e-02f, 8.00512433e-02f, 6.80615660e-03f, 6.55975044e-02f, -1.06065579e-01f, 6.41428456e-02f, 4.56528226e-03f,
  -1.38830114e-03f, 6.52301833e-02f, 8.94673318e-02f, 6.26725554e-02f, -6.32356033e-02f, -3.91036831e-02f, 7.53214136e-02f, 3.87702510e-02f, 8.07292014e-02f, -8.36912990e-02f,
  -3.37939039e-02f, -9.20233727e-02f, 2.48201843e-02f, -4.61291522e-02f, -8.03956389e-02f, 6.93038553e-02f, -1.11530215e-01f, -2.21101157e-02f, 1.72529276e-02f, -3.98631729e-02f,
  1.36038750e-01f, 3.65605094e-02f, 1.83966950e-01f, 7.53292739e-02f, 2.45839953e-02f, 1.68084636e-01f, 1.99040070e-01f, 5.17735519e-02f, -1.84456352e-02f, -1.80293173e-02f,
  -7.80412406e-02f, -5.71421459e-02f, -1.71053320e-01f, -8.76622647e-02f, -1.05054848e-01f, 9.93801951e-02f, 6.38235314e-03f, 1.89826125e-03f, -8.38405080e-03f, -3.29443589e-02f,
  4.89102192e-02f, 5.57148866e-02f, 6.82206601e-02f, -2.99274866e-02f, -2.09381003e-02f, 1.08906266e-03f, 5.68717066e-03f, 9.12694186e-02f, -3.76512185e-02f, -1.89718697e-02f,
  4.85918708e-02f, 1.69917196e-01f, -9.34058949e-02f, -1.05161592e-01f, -3.02246194e-02f, 5.98309785e-02f, -1.94043741e-02f, 2.98173148e-02f, -2.52600331e-02f, 4.83228490e-02f,
  -2.33542603e-02f, 5.18634394e-02f, 5.09236939e-02f, -5.24917394e-02f, 1.23481683e-01f, 9.93258953e-02f, 6.84919942e-04f, -1.07560484e-02f, 1.08631238e-01f, 9.26880687e-02f,
  5.91607541e-02f, 5.95123917e-02f, 9.87981781e-02f, -1.08430339e-02f, 1.17038228e-01f, 4.94098216e-02f, 6.15094639e-02f, 6.91014826e-02f, -1.42221740e-02f, 6.92954510e-02f,
  -4.45971861e-02f, 3.41472179e-02f, 2.65926868e-02f, -8.43541473e-02f, 3.27689014e-02f, 7.06228167e-02f, 3.61725092e-02f, -3.96933779e-03f, -3.61944474e-02f, -9.67991278e-02f,
  -7.17583373e-02f, 9.04222112e-03f, -7.63894469e-02f, -1.62820369e-02f, -7.33259171e-02f, 3.24290320e-02f, 2.27171071e-02f, -9.32857469e-02f, -8.07213709e-02f, -6.34549111e-02f,
  3.37968245e-02f, 7.86118060e-02f, 4.76474389e-02f, 5.67828864e-02f, 4.16513793e-02f, -6.45809099e-02f, -7.81120779e-03f, -4.83973734e-02f, 2.01655738e-02f, 7.49466568e-02f,
  -4.18200195e-02f, 1.03679247e-01f, -5.43630607e-02f, 6.27665892e-02f, -2.38785744e-02f, -9.71743912e-02f, 5.35267554e-02f, -2.58941523e-04f, -5.20271398e-02f, 3.51507217e-02f,
  -6.99739084e-02f, 3.21090817e-02f, 2.88248397e-02f, 9.93967988e-04f, 6.35239929e-02f, -7.08743464e-03f, 2.30576154e-02f, -6.27581254e-02f, 4.05189097e-02f, -2.07816940e-02f,
  -8.66783503e-03f, 1.24060132e-01f, 4.36072983e-02f, -1.43478559e-02f, 1.21154025e-01f, 8.74370635e-02f, 4.31092083e-02f, 5.64525500e-02f, 1.50477350e-01f, -3.52796391e-02f,
  -1.79766715e-01f, -5.76210283e-02f, -6.49761260e-02f, 9.76923183e-02f, -5.92407510e-02f, -2.10625798e-01f, -3.10265422e-01f, -1.20262533e-01f, 1.26426920e-01f, -1.88039970e-02f,
  -1.53402686e-02f, 1.94343895e-01f, 1.36184499e-01f, -2.71716099e-02f, -1.73441589e-01f, -3.33691001e-01f, -2.76432246e-01f, -1.08242892e-01f, -4.01199870e-02f, -1.28760323e-01f,
  -1.30915523e-01f, -1.50967732e-01f, -8.64494294e-02f, 7.18408078e-02f, 1.48945050e-02f, 7.98351467e-02f, 1.08423337e-01f, 6.88377321e-02f, -4.14608903e-02f, -3.52461524e-02f,
  -1.52510107e-01f, -6.63203821e-02f, 4.36755158e-02f, -2.21641418e-02f, 1.87028740e-02f, -5.61756156e-02f, -1.26126453e-01f, -2.09158622e-02f, 7.79286399e-02f, 2.25761198e-02f,
  -2.39159502e-02f, 4.40732762e-02f, -1.62869301e-02f, 7.44702294e-02f, 8.53666663e-03f, 2.71867849e-02f, -2.12977864e-02f, -5.39133810e-02f, -2.61540134e-02f, 2.66808737e-03f,
  -1.72319505e-02f, -1.04557425e-01f, 7.94455875e-03f, 1.59172006e-02f, -1.57812284e-03f, 1.66386999e-02f, 1.24473963e-03f, 1.15626991e-01f, 1.00746438e-01f, 6.05469104e-03f,
  3.93491946e-02f, 5.49933407e-03f, -2.74951160e-02f, 1.40747828e-02f, 9.98761207e-02f, 4.53726426e-02f, 1.03970375e-02f, 1.37369530e-02f, -3.23494561e-02f, -1.99837014e-02f,
  5.61260022e-02f, -5.07305004e-02f, 4.14326265e-02f, 7.49306530e-02f, 6.93555325e-02f, -1.31272465e-01f, 1.16351480e-02f, -3.15116835e-04f, -6.85792267e-02f, -5.16568087e-02f,
  -1.12940464e-02f, 6.43115714e-02f, 2.12569050e-02f, 2.77643017e-02f, 2.52929274e-02f, 1.01518549e-01f, 1.70686804e-02f, -1.10193841e-01f, 3.29324827e-02f, -5.03232218e-02f,
  2.33878493e-01f, -1.01558872e-01f, -9.16660354e-02f, 5.34713361e-03f, -2.43195482e-02f, 5.77135310e-02f, 1.44628614e-01f, -1.08773997e-02f, 1.25409691e-02f, 1.64353307e-02f,
  1.10388145e-01f, 5.42010814e-02f, 4.45413254e-02f, -3.40804122e-02f, -5.18666580e-02f, 5.47744520e-02f, 1.16368629e-01f, 7.30699226e-02f, -5.99496998e-02f, 1.78269241e-02f,
  2.76149204e-03f, -5.25255501e-02f, 4.73459922e-02f, 3.66640016e-02f, -3.79092284e-02f, 5.46512194e-02f, -4.12473641e-02f, -1.19179385e-02f, -3.48627418e-02f, 1.02122739e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 26)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 26;
const float L0_fan_Bp_bar_data[] = {
  1.49339631e-01f, 3.10841184e-02f, 3.55218239e-02f, -9.71138477e-02f, 6.98470548e-02f, 5.93441492e-03f, 4.79490720e-02f, -1.73782073e-02f, 5.15058301e-02f, 3.09425984e-02f,
  1.92131922e-01f, 3.95705737e-02f, 8.03999901e-02f, 2.12163866e-01f, 1.22932851e-01f, 3.71769488e-01f, 2.29860410e-01f, 3.11541766e-01f, 8.66121501e-02f, 1.24156840e-01f,
  8.63082558e-02f, 7.01394007e-02f, -5.74146351e-03f, 5.02527021e-02f, -1.17605506e-03f, 3.13648850e-01f
};

// L1_fan_Wp (Shape: 3 x 32)
const int L1_fan_Wp_rows = 3;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  2.77688056e-01f, 4.03386317e-02f, 2.11285546e-01f, -2.44623885e-01f, 2.28284314e-01f, -3.76067817e-01f, -7.24494234e-02f, -5.33881299e-02f, 1.95887819e-01f, 2.34109424e-02f,
  2.04663396e-01f, -1.98929589e-02f, 9.55767483e-02f, 5.12910746e-02f, 1.97848603e-01f, 1.91743523e-01f, 4.20048553e-03f, 2.29104254e-02f, 2.41735801e-02f, -3.21991742e-01f,
  -9.54439342e-02f, 4.03821647e-01f, 3.29902917e-01f, -1.06207885e-01f, 6.65476397e-02f, -2.33445868e-01f, 3.04552857e-02f, -1.35210022e-01f, -1.56312719e-01f, -9.20895562e-02f,
  -1.72423527e-01f, 6.43576533e-02f, -8.18569958e-02f, -1.58234358e-01f, -4.59286906e-02f, -8.74592066e-02f, -2.61475056e-01f, -1.44626394e-01f, -8.48283768e-02f, 5.93827032e-02f,
  7.43313506e-03f, -9.67005715e-02f, 2.78334040e-03f, -1.75582632e-01f, -1.77619770e-01f, -6.96793199e-02f, -7.15770870e-02f, 6.65141502e-03f, -1.68466851e-01f, 2.17277884e-01f,
  -9.04435962e-02f, -1.84753835e-02f, 2.47399881e-01f, 2.52313614e-01f, -8.06018189e-02f, 3.65584433e-01f, -1.82848170e-01f, -9.77765322e-02f, -1.70265958e-02f, 1.18461683e-01f,
  1.65953025e-01f, 2.03371137e-01f, -3.23265284e-01f, 3.32223624e-01f, -8.18032026e-03f, -4.90673967e-02f, -5.21578304e-02f, -6.36173859e-02f, 1.26021788e-01f, -3.42268907e-02f,
  8.51886943e-02f, 2.64469162e-02f, -1.59862116e-01f, 1.15508310e-01f, 2.21918523e-01f, 4.35286425e-02f, 1.79363087e-01f, -1.27150178e-01f, -1.26407772e-01f, 3.36745381e-03f,
  1.85633838e-01f, -1.58321299e-02f, -5.76199740e-02f, -2.15778068e-01f, -1.42904401e-01f, 8.64641815e-02f, 1.94466293e-01f, -9.26844329e-02f, -6.68441728e-02f, -2.49877647e-01f,
  1.46260813e-01f, -1.74200758e-01f, 1.48012519e-01f, -1.00498877e-01f, 1.81786984e-01f, -2.66316086e-01f
};

// L1_fan_Wp_bar (Shape: 26 x 32)
const int L1_fan_Wp_bar_rows = 26;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  -1.00740893e-02f, -1.18040621e-01f, -8.27924162e-02f, -1.36431336e-01f, 6.19160645e-02f, 2.28897259e-01f, -1.12255625e-01f, -1.04561843e-01f, -9.51040015e-02f, -3.96675132e-02f,
  -1.52433187e-01f, -1.15619719e-01f, -1.99223176e-01f, 1.86424717e-01f, -3.87796026e-04f, 1.43955424e-01f, 1.84889898e-01f, 2.50168592e-01f, 7.15398341e-02f, 9.04615968e-02f,
  -1.00854132e-02f, -1.57375678e-01f, -1.17337584e-01f, 2.07059994e-01f, 8.72008950e-02f, 2.39212960e-01f, 1.40397176e-01f, 1.15363054e-01f, 1.48489073e-01f, -1.02788270e-01f,
  5.77050522e-02f, 4.46325615e-02f, -3.70709449e-02f, 2.39428859e-02f, -1.89746186e-01f, -1.48719713e-01f, -1.90334991e-01f, -8.26250985e-02f, 1.38936684e-01f, -2.32856348e-03f,
  -1.53126186e-02f, 1.66926563e-01f, -1.22173093e-01f, -8.76360461e-02f, -4.83606569e-02f, -1.51941389e-01f, -2.22028419e-02f, 1.63500130e-01f, 4.49349498e-03f, 1.29538298e-01f,
  1.05732486e-01f, 1.28675839e-02f, -1.38919175e-01f, 1.35171264e-01f, 5.06486162e-04f, 4.09786254e-02f, -1.25072196e-01f, 8.31482634e-02f, 1.09748885e-01f, -4.17519584e-02f,
  1.81720480e-01f, 8.67533758e-02f, 1.71461403e-01f, -9.00283605e-02f, 4.52141017e-01f, 3.82343739e-01f, 4.55238849e-01f, 1.03418335e-01f, -5.74245930e-01f, -1.09838761e-01f,
  -1.74452275e-01f, -5.38375191e-02f, 5.47602065e-02f, 2.70562936e-02f, -2.05117345e-01f, -3.09383035e-01f, -3.03091764e-01f, -1.78274289e-01f, 6.97823167e-02f, -8.58107507e-02f,
  -2.11718112e-01f, 5.95716059e-01f, 1.55964404e-01f, 7.95096934e-01f, 2.42807344e-01f, 1.90177366e-01f, 3.59348327e-01f, 4.02302682e-01f, 1.27917320e-01f, 2.15009242e-01f,
  1.60930187e-01f, 2.78317451e-01f, 1.03739142e-01f, 3.53103280e-01f, -2.19588801e-01f, 3.19189221e-01f, 2.21296668e-01f, 3.64311822e-02f, 1.45406365e-01f, -1.80415720e-01f,
  6.96582943e-02f, -1.66419193e-01f, 2.79926568e-01f, -1.03533380e-01f, 4.78884839e-02f, -8.35922286e-02f, -1.20665587e-01f, 9.13100541e-02f, 3.49362046e-01f, 6.83967397e-02f,
  1.65394425e-01f, -1.41943753e-01f, 1.45219713e-01f, -6.39249310e-02f, 2.89540868e-02f, -4.52387370e-02f, -1.60407260e-01f, 3.19430858e-01f, 4.21259068e-02f, 9.18134525e-02f,
  2.14440450e-02f, 1.16796657e-01f, -1.37708545e-01f, -2.24015474e-01f, -8.29339996e-02f, -1.61858767e-01f, 1.37782648e-01f, 3.88667583e-02f, -9.79897454e-02f, 1.86410710e-01f,
  -1.52493104e-01f, -2.49020785e-01f, 1.67764574e-01f, -1.02168821e-01f, 1.39958924e-02f, 7.35462010e-02f, -1.37913495e-01f, -8.04134309e-02f, 8.17665309e-02f, 1.23831145e-01f,
  1.30183205e-01f, 1.22435181e-03f, 4.42497693e-02f, -2.10432615e-02f, 1.69869080e-01f, -1.15966015e-01f, -1.68706086e-02f, 1.86114028e-01f, -2.29498949e-02f, 7.95653611e-02f,
  1.92010969e-01f, -8.30591395e-02f, -1.30105048e-01f, 2.28304863e-01f, -1.15174234e-01f, 9.97078121e-02f, 2.52112113e-02f, -1.37011290e-01f, -1.52889520e-01f, 1.02627710e-01f,
  1.74213395e-01f, 6.45637186e-03f, -3.27282138e-02f, -4.17015493e-01f, 3.48649859e-01f, 1.23873882e-01f, 2.73350000e-01f, -1.38587743e-01f, -1.00693867e-01f, 1.25661090e-01f,
  -1.34322464e-01f, 1.17394373e-01f, -1.20595038e-01f, -1.51260734e-01f, -5.53022958e-02f, 1.76786423e-01f, -2.08630815e-01f, 4.57141325e-02f, 6.88061118e-02f, 9.89085883e-02f,
  -4.79493439e-02f, 3.66355330e-01f, -4.25855070e-02f, 5.54047942e-01f, 8.25179294e-02f, -5.60260862e-02f, 1.12834342e-01f, -1.33903772e-01f, -7.60686249e-02f, -3.18389945e-02f,
  -2.38559604e-01f, 3.42912734e-01f, -1.80082381e-01f, -9.24647599e-02f, -1.57382637e-01f, -8.89515877e-02f, -2.19160076e-02f, -1.20265938e-01f, -1.38381906e-02f, -7.92189091e-02f,
  1.41567126e-01f, -1.02506485e-02f, 8.78909975e-02f, -1.11468434e-01f, -9.29004550e-02f, 7.35421404e-02f, -1.55753363e-02f, 2.18275085e-01f, -1.00886762e-01f, 7.50783756e-02f,
  -6.09571114e-03f, 3.18013988e-02f, -6.11683726e-02f, 2.03308776e-01f, 5.79166226e-02f, -3.53309065e-02f, -1.49506822e-01f, -6.16756864e-02f, -1.27313972e-01f, -1.35919005e-01f,
  9.41124409e-02f, 1.79620132e-01f, -1.76624373e-01f, 1.30518362e-01f, 1.54440001e-01f, -2.17714727e-01f, 2.17181072e-01f, -2.50356406e-01f, 2.12936714e-01f, 1.56297788e-01f,
  2.69644439e-01f, -1.95858646e-02f, 1.06147923e-01f, -1.22515179e-01f, 1.02116233e-02f, 4.61899638e-02f, 1.87571213e-01f, 1.88262910e-01f, 1.01986267e-01f, -8.67292508e-02f,
  5.95518127e-02f, 4.23717536e-02f, 1.56574711e-01f, -1.29953489e-01f, -4.41190228e-02f, 1.53913483e-01f, 1.40665367e-01f, -2.45013610e-02f, 7.64128119e-02f, -1.25383630e-01f,
  -5.76491319e-02f, -1.93615586e-01f, -4.44297120e-02f, -1.52487054e-01f, -7.08999112e-02f, 2.59205159e-02f, 1.42900318e-01f, -6.94505200e-02f, 1.95340648e-01f, 3.13596576e-02f,
  8.61465037e-02f, 6.89257905e-02f, -1.88311920e-01f, 5.32386974e-02f, -1.52658656e-01f, -4.20850292e-02f, -1.11745037e-01f, -1.44534195e-02f, 1.12940297e-02f, -6.87016314e-03f,
  -1.10424533e-01f, -1.69680879e-01f, 1.06805511e-01f, 9.42116454e-02f, -3.96909425e-03f, 4.64306861e-01f, 1.28930882e-01f, -2.95491576e-01f, 9.97238532e-02f, 3.86058502e-02f,
  -5.21248318e-02f, 2.76260018e-01f, 4.04678620e-02f, 1.31471560e-03f, 1.77975968e-01f, -1.28330007e-01f, -8.05355161e-02f, -1.72285601e-01f, 2.68970817e-01f, 1.50923491e-01f,
  3.66506316e-02f, -9.35666859e-02f, 2.87109196e-01f, -1.66019619e-01f, 2.44680554e-01f, -1.53449671e-02f, 8.89535807e-03f, 1.12726569e-01f, 1.58887684e-01f, 1.01331465e-01f,
  2.61400431e-01f, -1.19823895e-01f, 1.80484965e-01f, -1.71015784e-01f, 2.04123631e-02f, -1.27250860e-02f, -1.28194511e-01f, 5.13429381e-02f, 2.68298760e-02f, 3.92490178e-01f,
  1.48376197e-01f, 5.41403294e-02f, 9.85020772e-02f, 1.15209684e-01f, 9.74615067e-02f, 5.40757355e-05f, 1.93640927e-03f, -6.99395388e-02f, 2.70933267e-02f, 9.78023112e-02f,
  -1.36409709e-02f, 1.65331542e-01f, 4.59370352e-02f, -1.76574200e-01f, 5.00913635e-02f, -9.44934040e-02f, 9.95982997e-03f, 2.73915321e-01f, 1.30000293e-01f, 3.85203138e-02f,
  -1.57508850e-01f, -4.97638844e-02f, 1.36643916e-01f, 1.32746860e-01f, 7.58172423e-02f, 4.23851870e-02f, -4.12047952e-02f, -5.39889745e-02f, 1.11220449e-01f, 1.63858056e-01f,
  1.52749136e-01f, 3.47525030e-01f, 1.43211275e-01f, 1.16641656e-01f, -1.56109128e-02f, -8.18933081e-03f, -1.39835730e-01f, -6.92793205e-02f, 1.90542579e-01f, 1.07808016e-01f,
  7.26428479e-02f, 2.28342563e-01f, 2.14501590e-01f, 3.52109410e-02f, 2.74210632e-01f, 2.68789470e-01f, -1.69614647e-02f, -6.03287816e-02f, -1.44410476e-01f, -1.13551229e-01f,
  8.11955854e-02f, -1.27681926e-01f, -3.30686532e-02f, -1.84877604e-01f, 3.12443703e-01f, 1.03672944e-01f, -1.65237546e-01f, -2.43907914e-01f, 6.18585229e-01f, 5.81168793e-02f,
  -7.46864155e-02f, 1.89388484e-01f, -1.34792076e-02f, -5.46589419e-02f, -4.00590263e-02f, -9.36259627e-02f, -1.77211538e-01f, 4.67646301e-01f, 4.01096232e-02f, -2.06134319e-01f,
  -9.86912176e-02f, 1.62466332e-01f, 3.43753070e-01f, -2.42879242e-01f, 3.70146818e-02f, 2.15002507e-01f, 6.89123571e-02f, 1.65066168e-01f, -1.59012794e-01f, 4.57098335e-02f,
  -9.16138962e-02f, 1.60227597e-01f, 8.04852918e-02f, 5.34360856e-02f, 1.89992994e-01f, -1.56309634e-01f, -1.37244806e-01f, -2.55714264e-03f, -1.49190009e-01f, -2.00374722e-02f,
  5.36669344e-02f, 9.68742184e-03f, 1.37137249e-01f, 1.73495606e-01f, -1.12582505e-01f, -1.87381029e-01f, 1.30822167e-01f, 1.14432037e-01f, 8.18694383e-03f, 9.78059173e-02f,
  1.32417917e-01f, 9.41119157e-03f, 1.23027787e-01f, -1.43526375e-01f, 2.09045485e-02f, 7.83897638e-02f, -7.11176097e-02f, -2.43601352e-01f, 1.02433622e-01f, -2.41374046e-01f,
  1.86458174e-02f, 8.58732834e-02f, 6.89957887e-02f, -1.08907916e-01f, -3.33864987e-02f, 1.54332399e-01f, -7.52709657e-02f, 2.08166808e-01f, -1.89455777e-01f, 1.19140819e-01f,
  -1.02068581e-01f, -7.97048435e-02f, 5.25959916e-02f, -9.75108966e-02f, 1.17005341e-01f, -6.11156337e-02f, 1.18693985e-01f, -1.01842415e-02f, 1.67999893e-01f, 1.81721319e-02f,
  -2.34828722e-02f, -1.28405280e-02f, -5.45545202e-03f, -1.22573115e-02f, 3.37705649e-02f, 1.35965899e-01f, -1.14777662e-01f, 6.38323426e-02f, 2.15419605e-01f, -2.61405427e-02f,
  1.15886129e-01f, -3.06665182e-01f, 1.10340841e-01f, 1.49003983e-01f, -1.48023233e-01f, -1.89272404e-01f, -1.53311238e-01f, -6.25055805e-02f, 1.04930215e-01f, 1.59958005e-02f,
  -2.49630868e-01f, 1.52231321e-01f, -1.39044911e-01f, 1.07380273e-02f, 1.04050457e-01f, 2.38067910e-01f, 1.78063333e-01f, 3.12721342e-01f, 6.34967238e-02f, 6.67771921e-02f,
  3.30045193e-01f, 8.06632414e-02f, -6.00607991e-02f, -1.63001388e-01f, -2.09439900e-02f, 2.13474393e-01f, 2.31765136e-02f, 1.29053295e-01f, 2.70377435e-02f, 9.91666019e-02f,
  9.87083316e-02f, 1.55450374e-01f, 5.19278832e-02f, -2.25340158e-01f, 2.55417168e-01f, -3.66452634e-01f, 2.53738046e-01f, 2.28127643e-01f, 2.09915370e-01f, -3.43261622e-02f,
  -1.31560490e-01f, -1.10983364e-02f, 3.32032628e-02f, -1.61007941e-02f, 8.26670155e-02f, -7.86771998e-02f, 1.18831463e-01f, -3.25492173e-02f, -6.95097866e-03f, 9.24929976e-03f,
  1.25991866e-01f, 5.39396048e-01f, 6.75133839e-02f, 2.28513643e-01f, 7.00178668e-02f, 1.47234455e-01f, 1.09490827e-02f, 2.25297939e-02f, 2.32053958e-02f, 1.42508373e-01f,
  -8.98492336e-02f, -1.23757631e-01f, 4.45337415e-01f, 8.29884931e-02f, 2.52947569e-01f, -3.26299071e-02f, 1.35063350e-01f, -4.03686255e-01f, 3.07284027e-01f, 7.75125399e-02f,
  3.16095591e-01f, -8.60062093e-02f, 2.09318660e-02f, -1.73457131e-01f, 2.79750705e-01f, 1.34271741e-01f, 2.59606481e-01f, 9.48708225e-03f, 2.00105071e-01f, -9.99671146e-02f,
  2.96273082e-01f, 3.84690054e-02f, -2.23424107e-01f, 7.38231361e-01f, 3.33429188e-01f, 2.75298268e-01f, 2.64245383e-02f, 4.24360968e-02f, 4.27372679e-02f, -1.80586189e-01f,
  -1.50499538e-01f, -1.00850761e-01f, -5.94982132e-02f, -5.86208254e-02f, -9.13715959e-02f, -9.73488763e-03f, 1.41283460e-02f, 3.19229992e-04f, 1.11338191e-01f, -6.85049742e-02f,
  -1.11059785e-01f, -1.39109313e-01f, 1.50223389e-01f, 4.12657298e-02f, -5.66974767e-02f, -3.00884824e-02f, 7.97182098e-02f, -4.84338552e-02f, -4.00288291e-02f, -2.21342281e-01f,
  4.67837542e-01f, -1.24958664e-01f, 1.45577826e-02f, -8.33239313e-03f, -2.09743693e-01f, 4.14451696e-02f, -9.23869088e-02f, -1.10905416e-01f, -3.88885364e-02f, 4.01129335e-01f,
  1.28934100e-01f, -1.27007529e-01f, -1.13100052e-01f, 1.51998788e-01f, -6.75900877e-02f, -7.52856061e-02f, -4.83223200e-02f, 1.38556004e-01f, -9.39404294e-02f, 4.80509512e-02f,
  -1.28523588e-01f, 2.10603699e-03f, 1.48926571e-01f, -8.32276326e-03f, -2.04484344e-01f, 1.24996551e-03f, -1.62048474e-01f, -2.60972202e-01f, -1.14910640e-01f, 6.94962963e-02f,
  3.47603336e-02f, -1.26553178e-01f, 4.53184769e-02f, 2.69805312e-01f, -6.01018257e-02f, 6.07483387e-01f, -6.03225678e-02f, 2.74089780e-02f, -8.10414627e-02f, 3.79611462e-01f,
  -1.11212067e-01f, -1.13537975e-01f, 6.13258108e-02f, -7.58143980e-03f, -6.21507838e-02f, 2.08813950e-01f, -9.97812604e-04f, 7.02128047e-03f, 6.11438975e-02f, -1.61508158e-01f,
  -1.30043915e-02f, 2.18168840e-01f, -1.27142221e-01f, -1.65559754e-01f, -6.86546862e-02f, -2.55516637e-02f, -8.57661963e-02f, -1.44325614e-01f, 4.31507826e-02f, -1.03043601e-01f,
  -1.27734303e-01f, -7.87353441e-02f, -8.86687636e-02f, -8.19650218e-02f, 3.42202000e-02f, 1.46405146e-01f, 7.92707969e-03f, -1.20314874e-01f, 2.60336548e-02f, 1.17390648e-01f,
  -1.24281254e-02f, -1.71932340e-01f, -9.10436288e-02f, 1.42936975e-01f, -9.38379541e-02f, -6.74442425e-02f, -1.03952348e-01f, -1.40219927e-01f, 6.50216788e-02f, 6.38196692e-02f,
  -6.84023947e-02f, 2.59512011e-02f, -2.61829812e-02f, 2.88030747e-02f, 2.09697992e-01f, -2.35959217e-01f, -4.99980263e-02f, 2.94789881e-01f, 2.20643640e-01f, -1.03032790e-01f,
  -7.01620653e-02f, 4.79936004e-02f, -4.71771555e-03f, -6.57442212e-02f, 1.42949030e-01f, 1.87801704e-01f, 4.38919803e-03f, 1.82475656e-01f, 1.35044307e-01f, -3.61727439e-02f,
  -1.13147415e-01f, 3.52745205e-01f, -4.70981710e-02f, 2.93623060e-01f, -1.79308280e-01f, 2.87362367e-01f, 7.96859935e-02f, 2.00647429e-01f, 7.03808516e-02f, -6.79367632e-02f,
  9.67169739e-03f, -5.00515569e-03f, -4.49047945e-02f, -1.54437765e-01f, 2.15956703e-01f, 3.62999961e-02f, -1.40164807e-01f, 1.01123624e-01f, 7.65839266e-03f, -1.45840999e-02f,
  -5.96079081e-02f, -1.01094052e-01f, -1.03007324e-01f, 1.07371934e-01f, 1.28149807e-01f, 1.40383944e-01f, -1.58859596e-01f, -2.08697572e-01f, 3.97895247e-01f, -1.41837895e-01f,
  -1.19021893e-01f, 1.10399984e-01f, 1.89601947e-02f, -1.86367601e-01f, 6.14009500e-02f, -1.93804041e-01f, 3.76345497e-03f, 1.40405804e-01f, -3.29422974e-03f, -1.72872823e-02f,
  -1.56980902e-01f, -9.36380681e-03f, -7.93517232e-02f, -1.50459811e-01f, 1.65062591e-01f, 7.36365467e-02f, 9.89444777e-02f, -4.84257825e-02f, 3.29609662e-02f, 1.24086171e-01f,
  1.83959484e-01f, 1.82941273e-01f, -1.20987915e-01f, 6.99880123e-02f, 1.06925592e-01f, 7.63939470e-02f, -1.32065520e-01f, -4.56032827e-02f, 1.70726310e-02f, 8.79693627e-02f,
  -8.05858970e-02f, 2.92200565e-01f, 1.86077252e-01f, 2.52246499e-01f, 5.50750010e-02f, -6.09510716e-05f, 4.04516533e-02f, 1.84370279e-01f, -7.80142397e-02f, -9.07028615e-02f,
  -1.45774812e-01f, 8.12484473e-02f, 6.75111637e-02f, -1.42104760e-01f, -1.58909172e-01f, 7.58311758e-03f, 2.85854906e-01f, 1.35178849e-01f, 2.54258782e-01f, 4.19889688e-02f,
  -3.57551058e-03f, 6.71660453e-02f, 2.99774140e-01f, 1.52571172e-01f, 1.35996059e-01f, 1.72298864e-01f, -9.49427709e-02f, 1.18383151e-02f, 4.02826741e-02f, -1.52239561e-01f,
  1.15776032e-01f, 1.20050609e-01f, 2.39773914e-01f, -1.08809017e-01f, -1.13590546e-01f, 1.61499813e-01f, -1.10490791e-01f, 2.86917955e-01f, 1.05512060e-01f, 7.28754550e-02f,
  1.42799607e-02f, 5.80701344e-02f, -1.09407201e-01f, -1.67059436e-01f, -1.17166415e-01f, -8.08272883e-03f, 2.97323838e-02f, 6.67213649e-02f, 1.69332922e-01f, -6.51722029e-02f,
  -1.98781535e-01f, 9.35505554e-02f, 1.56640127e-01f, -2.18871981e-01f, -1.68073937e-01f, 1.88204274e-01f, 5.56726307e-02f, -1.74521878e-01f, 7.15768486e-02f, 1.17567144e-01f,
  1.76842920e-02f, 4.18117754e-02f, 5.06026857e-02f, 1.47338346e-01f, -3.19428034e-02f, 6.31573517e-03f, 1.89087972e-01f, -1.20963074e-01f, -2.11727293e-03f, 1.21606559e-01f,
  8.39948654e-02f, 1.23720221e-01f, 1.59489781e-01f, 1.99316163e-02f, 1.59545958e-01f, 1.67109758e-01f, -1.08852342e-01f, 1.24199957e-01f, 4.19070609e-02f, -7.11862594e-02f,
  2.87819088e-01f, 5.27435727e-02f, 2.32662484e-01f, -2.45956078e-01f, 3.71215791e-01f, 1.65285155e-01f, 2.86665946e-01f, -2.68192828e-01f, -3.27350870e-02f, -9.93833840e-02f,
  -2.37255991e-02f, 4.31617260e-01f, 2.88008936e-02f, -3.73533256e-02f, -1.54383987e-01f, 4.35723439e-02f, -1.96911693e-01f, 8.03091452e-02f, -1.74625650e-01f, 2.95586903e-02f,
  6.83379248e-02f, -2.42939726e-01f, 1.21883145e-02f, 4.46044743e-01f, 3.64482760e-01f, -5.71382567e-02f, -6.79640770e-02f, 1.38993472e-01f, 2.46946141e-01f, 4.91717979e-02f,
  3.72868613e-03f, 3.80832702e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 26)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 26;
const float L1_fan_Bp_bar_data[] = {
  1.69968680e-01f, -1.18702009e-01f, 5.43098330e-01f, 1.37832642e-01f, -1.24251798e-01f, 3.14344287e-01f, -9.73187685e-02f, 1.31690621e-01f, 7.03526363e-02f, 8.26031640e-02f,
  -1.91048086e-01f, 9.11276937e-02f, -2.55605206e-02f, -4.07843664e-02f, 4.04237688e-01f, 9.91324894e-03f, 3.32090199e-01f, 1.62344441e-01f, 1.54711992e-01f, 3.43263075e-02f,
  7.08509386e-02f, 2.61784419e-02f, -1.03568651e-01f, 1.52688965e-01f, -1.69965923e-01f, 3.77764344e-01f
};

// L2_fan_Wp (Shape: 3 x 32)
const int L2_fan_Wp_rows = 3;
const int L2_fan_Wp_cols = 32;
const float L2_fan_Wp_data[] = {
  -1.21716216e-01f, -7.62186646e-02f, 1.50103401e-03f, 3.64690751e-01f, -4.99048941e-02f, 1.34477481e-01f, -2.15711430e-01f, -1.31710276e-01f, -3.41573715e-01f, 1.39925838e-01f,
  1.43287003e-01f, 2.27507591e-01f, 6.71101958e-02f, -1.66360289e-01f, -2.22118527e-01f, 1.88894495e-01f, 1.82499796e-01f, 2.12417003e-02f, 3.80727239e-02f, -7.73755386e-02f,
  1.41601309e-01f, 3.04911494e-01f, 1.60826176e-01f, -4.30340916e-02f, 6.46873191e-02f, -5.60509302e-02f, 2.83509076e-01f, -2.52872288e-01f, -7.25622103e-02f, -4.71276566e-02f,
  2.56122738e-01f, 2.41590142e-01f, -1.08040810e-01f, -1.34145394e-01f, 1.48981884e-01f, 4.42266196e-01f, -3.35908622e-01f, 2.03982860e-01f, 2.54910532e-02f, 5.57451285e-02f,
  -3.27102125e-01f, 1.16744764e-01f, 1.92651138e-01f, -2.23796844e-01f, -6.62649721e-02f, 1.14002667e-01f, 2.12196242e-02f, -3.95243578e-02f, -3.79900001e-02f, 2.91739643e-01f,
  -1.91854477e-01f, 1.37435287e-01f, 2.02840507e-01f, 1.87552273e-02f, 1.64960712e-01f, 8.23596641e-02f, -1.83479935e-01f, 1.19218417e-01f, -4.21138182e-02f, 1.88464090e-01f,
  -5.60933612e-02f, -6.30567223e-02f, 1.71418682e-01f, -7.03823343e-02f, 1.69616252e-01f, 1.48565590e-01f, 3.62022035e-02f, 7.33769834e-02f, -1.23657189e-01f, 2.05371246e-01f,
  1.45524696e-01f, 1.79077134e-01f, 5.46319708e-02f, -3.04333251e-02f, 1.15737222e-01f, 6.70773089e-02f, 8.21838900e-02f, 1.48051277e-01f, 6.06990419e-02f, 5.22593036e-02f,
  2.46214256e-01f, -2.63181895e-01f, -1.09170690e-01f, 2.12154165e-02f, 2.58129120e-01f, 1.98266804e-01f, 9.62888449e-02f, -2.60173470e-01f, -1.05652601e-01f, -7.56556075e-03f,
  1.51612505e-01f, -7.61460885e-02f, 1.63486362e-01f, -8.31393246e-03f, -1.52602956e-01f, -7.86176026e-02f
};

// L2_fan_Wp_bar (Shape: 26 x 32)
const int L2_fan_Wp_bar_rows = 26;
const int L2_fan_Wp_bar_cols = 32;
const float L2_fan_Wp_bar_data[] = {
  9.57410634e-02f, -5.70758395e-02f, 1.01297259e-01f, -2.46447697e-01f, 1.48959741e-01f, 8.86461586e-02f, 4.27578352e-02f, 3.99605781e-02f, 1.88932076e-01f, -1.44170113e-02f,
  3.76334228e-02f, -6.97659478e-02f, -7.75364861e-02f, -8.25909302e-02f, -8.78484473e-02f, 1.43858209e-01f, 2.30212197e-01f, -1.01053186e-01f, -1.61943585e-01f, -6.94926828e-02f,
  1.46627858e-01f, 2.29057908e-01f, 1.00036517e-01f, 3.39681506e-02f, 1.99712023e-01f, 8.81138220e-02f, 1.82985887e-01f, 9.65038538e-02f, -7.30374679e-02f, 2.00129841e-02f,
  -1.37392491e-01f, -2.33902946e-01f, -2.72147208e-02f, 1.71443559e-02f, 1.23316057e-01f, -9.58626419e-02f, -2.72673760e-02f, 8.88368189e-02f, -9.65489820e-03f, 6.01837561e-02f,
  3.80320162e-01f, -1.07006408e-01f, -3.74335423e-02f, 6.63955435e-02f, 3.56412567e-02f, 4.98384498e-02f, 8.68505016e-02f, -1.08330198e-01f, -1.15719713e-01f, -5.27986400e-02f,
  -4.66394052e-02f, -1.70467108e-01f, 2.01986581e-01f, -5.67413345e-02f, -1.23748360e-02f, 9.83020961e-02f, -4.98369336e-02f, -6.24883212e-02f, -6.26096427e-02f, 1.49299502e-01f,
  1.94979236e-01f, -1.48640927e-02f, -5.03747724e-02f, 1.32020518e-01f, 1.15802959e-01f, 2.78520912e-01f, 2.48271197e-01f, 6.41482174e-02f, 4.48847830e-01f, -5.51899411e-02f,
  -1.16425455e-01f, 5.21295480e-02f, 7.22280025e-01f, -1.98986426e-01f, -1.51018336e-01f, -1.63257509e-01f, 1.09631624e-02f, -1.11067086e-01f, 7.27969781e-03f, 7.11690215e-03f,
  -2.22120017e-01f, -2.95087695e-01f, 1.33126646e-01f, 1.59565523e-01f, 2.55536526e-01f, 5.13822362e-02f, 1.65079132e-01f, -2.39087582e-01f, -6.76749647e-02f, 9.98398140e-02f,
  1.10202439e-01f, -2.12433442e-01f, 1.15355365e-01f, -6.09800592e-02f, -1.30670145e-01f, 2.40378100e-02f, 1.94687143e-01f, 2.41299830e-02f, 3.17301244e-01f, 2.55942881e-01f,
  1.82181850e-01f, 8.81272927e-02f, 6.79189190e-02f, -1.09083861e-01f, 5.71594834e-02f, 1.25490027e-02f, 4.89978194e-02f, 1.81936733e-02f, -8.65670666e-03f, 1.86534300e-01f,
  7.04674143e-03f, 7.49375857e-03f, 6.14927821e-02f, -3.78779210e-02f, 1.34595141e-01f, 8.34375396e-02f, 1.48330659e-01f, 6.67518377e-02f, -1.66570261e-01f, 6.20840788e-02f,
  -1.21314779e-01f, 1.36967391e-01f, -1.67040676e-01f, 5.06736264e-02f, 4.13910858e-02f, 1.37773871e-01f, 7.66816139e-02f, 2.59541385e-02f, 1.66828424e-01f, 3.04990143e-01f,
  2.52908975e-01f, -2.27071568e-01f, 1.37775436e-01f, -2.18081728e-01f, -1.27497390e-01f, 6.50114715e-02f, 5.97948670e-01f, -2.22893685e-01f, -3.57519500e-02f, -3.25543314e-01f,
  -1.78036377e-01f, -2.17804641e-01f, 1.55942455e-01f, -1.90126568e-01f, -1.88225448e-01f, -1.21246435e-01f, 2.47958422e-01f, -1.89122766e-01f, 1.50263861e-01f, -2.13631913e-01f,
  6.39656186e-02f, -2.68028080e-01f, 3.13050181e-01f, -6.15840703e-02f, -2.12552801e-01f, -2.07568929e-01f, 8.11291207e-03f, -1.34417236e-01f, -1.20773390e-01f, -8.13613236e-02f,
  2.44966283e-01f, 2.36636847e-01f, 1.39227733e-01f, -2.13467047e-01f, 2.44336754e-01f, -3.20865840e-01f, 8.43995214e-02f, -1.82727516e-01f, 6.24386549e-01f, 4.39558364e-02f,
  -1.79923594e-01f, 5.24840951e-02f, 4.07184400e-02f, -1.58212379e-01f, 2.66861945e-01f, 2.56948601e-02f, -5.41378446e-02f, 8.57705697e-02f, -1.18003458e-01f, -1.15121901e-01f,
  1.46983713e-01f, 2.05321610e-02f, 1.73961967e-01f, 1.37926415e-01f, 3.33689690e-01f, 3.00781569e-03f, 2.39280596e-01f, 6.96241632e-02f, 1.29440299e-03f, 8.26266706e-02f,
  1.81270376e-01f, 1.29514188e-01f, 1.71996713e-01f, 1.35300428e-01f, 3.66177648e-01f, 5.30873001e-01f, -3.40004504e-01f, 4.03068036e-01f, -1.42623648e-01f, -1.24853402e-02f,
  -3.95111665e-02f, 5.27217567e-01f, -7.15517402e-02f, 2.79117316e-01f, -1.45010710e-01f, 1.07758574e-01f, -2.55623788e-01f, 3.56072903e-01f, 1.62512138e-02f, 1.59786016e-01f,
  -1.34351894e-01f, -1.74268723e-01f, -1.57396868e-01f, 2.10149854e-01f, 7.09653258e-01f, 7.76296780e-02f, -1.19433641e-01f, -7.91508406e-02f, -1.85770094e-02f, 1.32523164e-01f,
  2.41731033e-02f, 3.21056068e-01f, -1.31035224e-01f, 6.03978857e-02f, 1.07400194e-01f, 2.88492488e-03f, -1.66623630e-02f, -1.89065158e-01f, -7.55736008e-02f, -7.58464783e-02f,
  1.17047071e-01f, -9.95699838e-02f, -1.38528843e-03f, -7.23587796e-02f, -4.85278592e-02f, 2.02662498e-01f, -7.89751112e-02f, -1.15791410e-01f, 9.30354893e-02f, 9.64608714e-02f,
  -1.04053877e-01f, 9.88957286e-02f, 2.41443831e-02f, -1.51887223e-01f, -7.71309733e-02f, -1.06263749e-01f, -1.48917913e-01f, 8.13568234e-02f, 3.22130136e-02f, -1.66559428e-01f,
  1.02556553e-02f, 7.56470039e-02f, 1.88303798e-01f, -1.25670075e-01f, -1.53851196e-01f, 4.76861484e-02f, 5.41024730e-02f, 2.48796418e-01f, 5.26367463e-02f, 3.97063404e-01f,
  -3.93885076e-02f, -3.06171854e-03f, -1.50742143e-01f, -1.09031610e-01f, 2.97479600e-01f, 1.01506233e-01f, -4.70343009e-02f, 1.47186831e-01f, 7.09250420e-02f, 5.68601079e-02f,
  -1.01919755e-01f, 1.59255549e-01f, 9.41784382e-02f, 6.51486292e-02f, 8.93433243e-02f, -1.15663104e-01f, 2.43247613e-01f, 1.03934579e-01f, 3.52596998e-01f, -1.49544567e-01f,
  -1.24579400e-01f, 5.36214039e-02f, -3.10123544e-02f, -1.98550969e-01f, 1.15449969e-02f, 2.12116241e-01f, 1.16389655e-01f, -3.20146373e-03f, 4.98729311e-02f, 1.40122727e-01f,
  1.53457299e-01f, 9.66117233e-02f, 3.00216168e-01f, -8.01505893e-02f, 1.17522292e-02f, 1.11352541e-01f, 3.48124921e-01f, -2.23056525e-01f, 7.92358369e-02f, -1.21293426e-01f,
  2.96209995e-02f, 8.81721303e-02f, -1.00325353e-01f, -2.24864557e-01f, 2.88778041e-02f, -7.82091767e-02f, 8.31119269e-02f, -5.01693934e-02f, 4.53087203e-02f, 2.28060223e-02f,
  2.81058718e-02f, -2.09671408e-01f, -2.87028644e-02f, 1.68702468e-01f, -2.87708361e-02f, -1.96606405e-02f, 1.36405885e-01f, -1.02603748e-01f, 5.68057317e-03f, -8.91844109e-02f,
  -6.78264350e-02f, 1.87262222e-02f, 1.43095450e-02f, 1.87526882e-01f, -2.19306543e-01f, -1.85895622e-01f, 1.52156383e-01f, -3.09144314e-02f, -1.24728590e-01f, 5.71777932e-02f,
  -2.34863423e-02f, -9.05859843e-03f, -1.08208768e-01f, -4.03864048e-02f, -1.47469997e-01f, 1.56021297e-01f, 1.59801483e-01f, 9.53719765e-02f, -1.12647511e-01f, -1.19070970e-01f,
  -8.04269388e-02f, 8.31442997e-02f, 3.49869323e-03f, -1.05004892e-01f, -1.39588580e-01f, -1.24040321e-01f, 1.72396582e-02f, 1.48313373e-01f, 1.35447979e-01f, -1.56713322e-01f,
  1.27181903e-01f, -4.14475352e-02f, -3.60104591e-02f, -3.85897942e-02f, 7.99712315e-02f, -1.74988866e-01f, -1.56180143e-01f, -1.65559769e-01f, 2.06402764e-01f, 1.50188237e-01f,
  -3.27250361e-02f, -6.83169663e-02f, -9.82957482e-02f, 7.24510327e-02f, -3.69250812e-02f, -1.09229967e-01f, -1.16512693e-01f, -7.08299950e-02f, 6.92071207e-03f, 2.67155707e-01f,
  1.23342142e-01f, 7.92695489e-03f, -1.50237665e-01f, 1.33344948e-01f, 5.04323132e-02f, 1.62338346e-01f, -8.60891491e-02f, 1.73451856e-01f, 8.25838447e-02f, -6.98190182e-02f,
  -1.92094699e-01f, 8.26785490e-02f, -1.87933929e-02f, 3.59925511e-03f, 3.68471473e-01f, 3.08958471e-01f, 2.62366056e-01f, 2.84818947e-01f, -3.21760885e-02f, -2.48105805e-02f,
  1.05344899e-01f, -1.74172297e-01f, -2.22365275e-01f, 2.30825841e-02f, -4.14286926e-02f, 3.94793004e-01f, -3.20046954e-02f, 3.36754888e-01f, -1.63723275e-01f, 1.66489109e-01f,
  -1.53815478e-01f, -3.14009070e-01f, -1.41249627e-01f, 2.73814410e-01f, 2.20780596e-01f, -1.67639241e-01f, 1.44528359e-01f, -2.03098789e-01f, -1.16343185e-01f, -2.25422621e-01f,
  -2.72163302e-01f, -2.01196462e-01f, -9.60130543e-02f, 1.00796312e-01f, -1.58823565e-01f, 6.30463064e-01f, -1.53914660e-01f, 1.11370608e-01f, -2.03766469e-02f, -2.23073759e-03f,
  -1.40688820e-02f, 1.67908341e-01f, 6.73984438e-02f, 4.45395708e-02f, -1.02576040e-01f, 1.87522490e-02f, -1.07030906e-01f, -1.93210796e-01f, -1.10011816e-01f, -6.90241978e-02f,
  1.83397129e-01f, -1.16125181e-01f, 3.95905115e-02f, 7.42017701e-02f, 4.16753702e-02f, -4.75696363e-02f, 1.01105615e-01f, -1.47983819e-01f, 7.63161704e-02f, -1.35945052e-01f,
  -1.77853510e-01f, 5.12465276e-02f, 1.84201419e-01f, 1.20120637e-01f, -1.39337406e-01f, -7.53681129e-03f, -1.47204220e-01f, -6.35444373e-02f, -2.54294276e-01f, -1.02007367e-01f,
  8.57710913e-02f, 4.16269451e-02f, 2.86490142e-01f, 4.34549339e-02f, 1.57544583e-01f, 6.93830401e-02f, 1.71736538e-01f, 1.52461573e-01f, 1.86528489e-01f, 1.31813616e-01f,
  1.80144191e-01f, -9.20919031e-02f, -1.10090105e-02f, 1.75912261e-01f, 2.31446952e-01f, 1.58806350e-02f, 5.35196289e-02f, 1.03553109e-01f, 1.66082680e-01f, 2.81438202e-01f,
  4.99198794e-01f, 8.25968664e-03f, 7.29095042e-02f, 3.39793861e-02f, 2.94957787e-01f, 5.43894805e-02f, 1.16514876e-01f, 2.79184133e-01f, 1.62568510e-01f, -2.10608184e-01f,
  2.72061508e-02f, -1.62519872e-01f, 1.21253930e-01f, -1.40118793e-01f, 3.41950990e-02f, -3.24131660e-02f, 2.48112023e-01f, 1.90806109e-02f, 5.45657635e-01f, 2.36150716e-02f,
  1.02834597e-01f, 2.36703336e-01f, -1.44267514e-01f, 5.29892184e-02f, -1.98537428e-02f, -1.10248968e-01f, 8.27215090e-02f, 1.51188606e-02f, 1.61226973e-01f, -8.93922895e-02f,
  2.48704389e-01f, -1.39006928e-01f, -1.72327489e-01f, -2.91562844e-02f, 4.05102640e-01f, 5.06593985e-03f, -1.70831710e-01f, -4.33063181e-03f, 1.33797720e-01f, -4.59351838e-02f,
  3.01435962e-02f, 3.06591719e-01f, 2.84575615e-02f, -6.31568879e-02f, 9.19379368e-02f, -1.36994585e-01f, -1.93735197e-01f, -1.42659292e-01f, 8.67716894e-02f, 6.88299239e-02f,
  -2.96254028e-02f, 1.13202192e-01f, 1.91898599e-01f, 1.99679837e-01f, -7.49480426e-02f, 1.07948363e-01f, -6.57030791e-02f, 1.06543168e-01f, -1.02667883e-02f, 3.05401891e-01f,
  -8.87797251e-02f, 3.10846362e-02f, 1.28532484e-01f, 3.97549607e-02f, 2.12980643e-01f, 1.05732746e-01f, 8.85229260e-02f, 1.18331499e-01f, 4.64407057e-02f, 1.03466094e-01f,
  1.16805829e-01f, 6.53806701e-02f, 2.98981331e-02f, -1.90308481e-01f, 5.30920625e-01f, 5.40163338e-01f, 2.67993748e-01f, -2.53997535e-01f, -1.29601926e-01f, -9.69626382e-02f,
  1.02202505e-01f, -1.01212204e-01f, 2.65601277e-01f, 8.66892561e-02f, -1.56848818e-01f, -1.93351492e-01f, -2.68660128e-01f, -1.43131271e-01f, 2.89640695e-01f, -6.18694611e-02f,
  -2.16620356e-01f, 4.46383834e-01f, 1.46347106e-01f, -1.44670874e-01f, 1.81095436e-01f, -2.56708354e-01f, -1.11696020e-01f, 1.09084584e-01f, -1.09584942e-01f, -6.86179698e-02f,
  -8.56964439e-02f, 2.09996104e-01f, -2.84726620e-02f, 2.15712398e-01f, -2.40855202e-01f, -9.31749344e-02f, 1.65859804e-01f, 8.52062404e-02f, 1.79286852e-01f, 8.54482278e-02f,
  1.45719662e-01f, 1.51630014e-01f, 1.36426866e-01f, -1.40923247e-01f, 8.62189755e-02f, -1.65359691e-01f, 6.15466759e-02f, 1.59890294e-01f, 1.05239386e-02f, 5.32803982e-02f,
  -1.88006442e-02f, -1.60624325e-01f, -4.05615903e-02f, -1.14088655e-01f, 1.67180702e-01f, 1.18637964e-01f, 2.73418855e-02f, -8.22813064e-02f, -1.66569903e-01f, -6.24989495e-02f,
  1.10097438e-01f, 8.67860094e-02f, -1.21270739e-01f, -1.31668597e-01f, -1.41863957e-01f, -1.36707947e-01f, -8.38657618e-02f, -1.44347802e-01f, -1.03686586e-01f, -2.85246167e-02f,
  -9.80775654e-02f, -2.43613318e-01f, -1.45931944e-01f, -1.93888061e-02f, 2.50558347e-01f, -6.35865927e-02f, 3.65732104e-01f, 3.47152315e-02f, 1.54131770e-01f, -8.02197829e-02f,
  3.94913182e-02f, -1.13620915e-01f, 3.48078728e-01f, 2.80187838e-02f, 6.76074028e-02f, 5.02175689e-01f, 3.17622125e-02f, 9.23511907e-02f, 2.17941061e-01f, 1.47061303e-01f,
  -6.98058680e-02f, 2.45916739e-01f, 4.12373602e-01f, 1.70278147e-01f, 3.76686938e-02f, 2.45689079e-01f, 8.55518971e-03f, 2.14918733e-01f, -1.88343897e-01f, -2.18379766e-01f,
  -1.88615993e-01f, -2.23914888e-02f, -2.43831463e-02f, 4.81141433e-02f, 2.58645445e-01f, -1.91397682e-01f, -8.33323970e-02f, 7.17450827e-02f, 2.35640407e-01f, -8.95317867e-02f,
  1.56503946e-01f, 2.10735753e-01f, 1.18099444e-01f, 7.89200440e-02f, -1.50996208e-01f, 2.30055392e-01f, 1.86415583e-01f, 1.42244369e-01f, -6.90830797e-02f, 2.31287461e-02f,
  -6.91000372e-03f, 2.55731821e-01f, 3.23324233e-01f, 5.11441082e-02f, 5.25321811e-02f, -1.08061865e-01f, 2.29627773e-01f, -1.70808695e-02f, 8.38209391e-02f, 1.45564764e-03f,
  2.18106639e-02f, -1.09215491e-01f, 2.01546073e-01f, -4.24463265e-02f, -1.68742668e-02f, 1.72128677e-01f, 2.88105607e-01f, -1.46868587e-01f, 4.00716551e-02f, -7.79682249e-02f,
  5.64300776e-01f, -3.66942259e-04f, 4.05653715e-02f, 5.87492406e-01f, -6.36662096e-02f, -1.12284366e-02f, 5.44744469e-02f, 2.65841335e-02f, 3.51224951e-02f, -3.25647771e-01f,
  -3.96491922e-02f, 1.44852117e-01f, 2.76410431e-01f, 3.46454605e-02f, -7.76932761e-03f, -5.78451678e-02f, 3.43410254e-01f, -3.78745645e-02f, 1.44509494e-01f, -8.10286179e-02f,
  3.18175554e-01f, 1.78324595e-01f, -1.58068597e-01f, 5.68857193e-01f, 3.23506713e-01f, 4.10579622e-01f, 4.41152751e-01f, -6.89079687e-02f, -3.07660222e-01f, 1.13022879e-01f,
  1.08142048e-01f, -1.67572066e-01f, -2.09546611e-01f, 1.29919857e-01f, 1.13489293e-02f, 1.63842961e-02f, -7.20952302e-02f, 2.47051775e-01f, 1.84194982e-01f, 1.21259540e-01f,
  -1.73543543e-01f, 1.29450828e-01f, -5.27299754e-02f, -6.39614910e-02f, 7.61162536e-03f, -6.03815764e-02f, -5.80241764e-03f, 2.60328222e-02f, -1.72512338e-01f, 1.76067382e-01f,
  -8.47368464e-02f, 2.33879775e-01f, -1.80090070e-01f, 4.76671085e-02f, -1.61395758e-01f, 3.37283462e-01f, -5.20375222e-02f, 1.69460535e-01f, 3.78408581e-02f, -1.35801077e-01f,
  6.65246695e-02f, 3.45434174e-02f, -2.19292138e-02f, -1.78645775e-01f, 2.37336934e-01f, -1.87883332e-01f, -1.49643496e-01f, -2.00375929e-01f, -8.06784555e-02f, -9.26074907e-02f,
  5.45895956e-02f, 2.85504404e-02f, -9.94317010e-02f, -1.19855888e-01f, 1.83787614e-01f, -6.27665743e-02f, 8.02384466e-02f, -1.56488821e-01f, -7.69648999e-02f, -7.33604655e-02f,
  -7.05730468e-02f, -8.57858732e-03f, 2.69811731e-02f, 7.16499090e-02f, -8.01252201e-02f, 9.09642279e-02f, -1.24178849e-01f, 2.12383315e-01f, -1.93627805e-01f, 1.52324483e-01f,
  9.61879790e-02f, 2.81647891e-01f, -3.79003912e-01f, 3.02357078e-01f, -2.19206601e-01f, -7.43541941e-02f, 7.48676434e-02f, 2.53536552e-01f, 4.30348255e-02f, 5.39380275e-02f,
  -2.20188782e-01f, 2.66160220e-01f, -1.24825716e-01f, 2.43927181e-01f, 9.31045637e-02f, 3.91328275e-01f, 8.25607032e-02f, 2.41802540e-02f, -5.48683368e-02f, 3.51042837e-01f,
  6.70905054e-01f, 2.50202775e-01f, 1.38464421e-01f, -1.01122737e-01f, -7.72403553e-02f, 8.43418762e-02f, 1.00536369e-01f, 2.82417119e-01f, -1.49518237e-01f, -1.07445776e-01f,
  -1.55354813e-01f, -1.21233515e-01f, -1.49578482e-01f, -6.58272132e-02f, -1.00113295e-01f, -1.27639443e-01f, 8.59664679e-02f, 4.46337014e-02f, 1.32509992e-01f, -1.02720179e-01f,
  -1.57618716e-01f, -5.55933788e-02f, 2.27853060e-02f, -2.18316410e-02f, -1.02073990e-01f, -2.79852599e-02f, 1.11345291e-01f, 2.88233198e-02f, 8.76951814e-02f, 9.44514573e-02f,
  -1.84802637e-01f, 3.32113579e-02f, -2.04335868e-01f, 1.65141657e-01f, 8.44201967e-02f, -7.61818141e-02f, 3.86221632e-02f, 3.95231210e-02f, 2.36284994e-02f, -1.16123550e-01f,
  1.68835655e-01f, -1.21143702e-02f
};

// L2_fan_Bp_bar (Shape: 1 x 26)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 26;
const float L2_fan_Bp_bar_data[] = {
  -8.84162933e-02f, 1.16398148e-01f, 3.96960765e-01f, 8.41146633e-02f, 1.88807547e-01f, 1.54494196e-01f, 1.95325449e-01f, 3.26890647e-02f, 4.02013846e-02f, 2.19536394e-01f,
  6.77110180e-02f, 3.02003641e-02f, 4.33734626e-01f, 1.24496825e-01f, 1.09006226e-01f, -4.98443563e-03f, -1.47316055e-02f, 4.24549580e-01f, 3.54140550e-02f, 1.13961302e-01f,
  2.99010519e-03f, 2.39735231e-01f, 3.69795412e-01f, -3.89399529e-02f, 1.27912208e-01f, 1.07254190e-02f
};

// L3_fan_Wp (Shape: 3 x 32)
const int L3_fan_Wp_rows = 3;
const int L3_fan_Wp_cols = 32;
const float L3_fan_Wp_data[] = {
  -1.74334701e-02f, 1.13645017e-01f, -1.47238016e-01f, 1.13984466e-01f, 2.72487670e-01f, 3.42281684e-02f, -7.37311766e-02f, -1.62119776e-01f, -7.65542835e-02f, -3.55015174e-02f,
  -4.12234254e-02f, -2.02004179e-01f, 2.84123778e-01f, 3.60910408e-02f, 2.70566404e-01f, 7.18551874e-02f, 1.92111477e-01f, 1.20648578e-01f, 1.60779082e-03f, 9.58749428e-02f,
  2.00721204e-01f, -8.63104761e-02f, 2.34303977e-02f, -7.27658123e-02f, 1.43613843e-02f, -1.01806648e-01f, 1.31473765e-01f, -2.36148298e-01f, -5.42033091e-02f, 8.67237896e-02f,
  1.17320843e-01f, 1.49274737e-01f, 1.45455882e-01f, -5.42111229e-03f, 1.73954070e-01f, 3.64801943e-01f, 1.99065685e-01f, 1.11660808e-01f, -2.48453468e-01f, 2.16960106e-02f,
  1.86090708e-01f, 7.14617670e-02f, -1.02312397e-02f, -2.41900712e-01f, 2.79441804e-01f, -1.15265846e-01f, 2.46099219e-01f, -6.18810542e-02f, -8.84657428e-02f, -4.84492332e-02f,
  2.41085976e-01f, 1.42314164e-02f, -1.16094857e-01f, -1.21961758e-01f, -8.77292827e-02f, -1.85425118e-01f, -2.06791200e-02f, -1.72742054e-01f, -2.08062157e-01f, -2.06266999e-01f,
  4.60238047e-02f, -9.90416557e-02f, 2.00213432e-01f, 3.86155304e-03f, 1.63776621e-01f, 1.51083693e-01f, 1.77192822e-01f, 4.17649560e-02f, 1.80147260e-01f, 6.00282662e-02f,
  2.84736268e-02f, -1.88040808e-01f, 7.67270401e-02f, 8.68757591e-02f, -2.23187327e-01f, -1.68937668e-01f, 2.99486965e-01f, -1.80616871e-01f, 9.66257527e-02f, 1.24588907e-01f,
  1.52521580e-01f, -3.92390881e-03f, 2.68509060e-01f, -6.01345189e-02f, -8.53251964e-02f, -1.97294265e-01f, 1.39873371e-01f, -2.50554886e-02f, 1.46269407e-02f, -3.63802612e-01f,
  8.97648111e-02f, -5.19926250e-02f, -1.10222898e-01f, 5.73532842e-02f, 8.83549899e-02f, -6.54581748e-03f
};

// L3_fan_Wp_bar (Shape: 26 x 32)
const int L3_fan_Wp_bar_rows = 26;
const int L3_fan_Wp_bar_cols = 32;
const float L3_fan_Wp_bar_data[] = {
  3.27741504e-01f, 4.52156454e-01f, 4.80188578e-01f, 7.02257380e-02f, -1.45557418e-01f, 6.40386641e-02f, 9.18943882e-02f, 6.45745695e-02f, 5.77948503e-02f, 1.81199476e-01f,
  -5.00239022e-02f, 1.58015743e-01f, 1.06274158e-01f, -5.36586484e-03f, -1.25318140e-01f, -5.97836487e-02f, 3.53686400e-02f, -1.11866362e-01f, 3.37016374e-01f, -1.43656701e-01f,
  -1.86151013e-01f, -2.39292696e-01f, 4.31455858e-02f, 1.21867679e-01f, 6.45709857e-02f, -2.06203237e-01f, -5.95185198e-02f, 1.02329776e-01f, 4.20513541e-01f, -5.21465577e-02f,
  -2.04095423e-01f, -2.13867828e-01f, 2.86481678e-01f, 3.24343145e-01f, 1.71543494e-01f, 2.08421111e-01f, -1.93240017e-01f, 3.32360178e-01f, 9.91625860e-02f, 7.86769539e-02f,
  2.64494717e-01f, 1.12384081e-01f, -5.22775538e-02f, -2.54958197e-02f, -7.52966702e-02f, 7.97801092e-03f, 8.44736118e-03f, 1.11289628e-01f, -7.67927766e-02f, 6.87030554e-02f,
  5.86829484e-01f, 4.29922380e-02f, 9.91712809e-02f, 9.55417380e-03f, -1.97116613e-01f, -1.91470161e-02f, 1.75221816e-01f, -2.63486385e-01f, 1.12991616e-01f, 3.34884107e-01f,
  4.95695099e-02f, -4.07980084e-02f, -2.23757446e-01f, -1.97642177e-01f, 2.60579854e-01f, -4.98104841e-02f, 2.95513630e-01f, 3.64618719e-01f, 9.06908959e-02f, 1.33815140e-01f,
  -1.32934928e-01f, 2.82881279e-02f, -8.37930068e-02f, 1.94102928e-01f, -1.72585532e-01f, 1.32750168e-01f, 2.82339305e-01f, 1.00368150e-01f, 8.27747956e-02f, -9.07630846e-02f,
  2.96490844e-02f, -1.82272688e-01f, 1.96831971e-01f, 2.33496111e-02f, -2.20166981e-01f, 1.35123760e-01f, -5.86121492e-02f, 1.28694654e-01f, -8.44285786e-02f, -1.48093611e-01f,
  -7.23134354e-02f, 8.44963640e-02f, 3.07975531e-01f, -1.11288670e-02f, -2.20479965e-02f, 5.89191355e-02f, 1.52736768e-01f, 2.21294314e-01f, 4.85161645e-03f, 1.93761915e-01f,
  7.92148113e-02f, 9.26551297e-02f, 1.00044116e-01f, 1.85639396e-01f, 1.86285943e-01f, 1.85548842e-01f, -1.57829463e-01f, 1.81022644e-01f, -1.15961552e-01f, 1.71278670e-01f,
  3.20193172e-02f, 8.88684019e-02f, -1.81447178e-01f, -1.22058086e-01f, 2.51499295e-01f, 1.59642592e-01f, 1.64138377e-02f, -9.10686702e-02f, -6.50314689e-02f, 2.69364528e-02f,
  2.16931254e-01f, -5.84879033e-02f, -3.19625326e-02f, 2.28199899e-01f, 1.26361609e-01f, -9.80246514e-02f, -1.39360383e-01f, -1.59088835e-01f, 3.79824489e-02f, 9.71746892e-02f,
  8.51812214e-02f, 2.35890634e-02f, -1.96488574e-02f, -7.46292993e-02f, 6.80881413e-03f, 1.84042424e-01f, -1.52791992e-01f, 1.80423513e-01f, -1.33136868e-01f, 2.54117977e-02f,
  -6.87749237e-02f, -1.81214020e-01f, 1.80381075e-01f, -1.27791569e-01f, 9.60003361e-02f, 1.44309089e-01f, 1.50298595e-01f, 1.42335981e-01f, 1.52954474e-01f, 1.32543415e-01f,
  -1.37876138e-01f, 1.51687130e-01f, 1.18123874e-01f, -1.80369988e-02f, -5.61731905e-02f, -3.85447592e-02f, 1.61970377e-01f, -5.11823706e-02f, -1.24917917e-01f, -1.58762887e-01f,
  1.09407440e-01f, 5.85485995e-02f, 2.08353296e-01f, -5.54817878e-02f, 1.87178001e-01f, -2.13308647e-01f, 3.10693812e-02f, 7.69739449e-02f, -1.69289261e-01f, -4.42169532e-02f,
  -2.10712910e-01f, -1.57115176e-01f, 2.28827208e-01f, 9.64802280e-02f, -1.43480405e-01f, 5.38308844e-02f, -5.75672574e-02f, 1.97994232e-01f, -5.22830710e-02f, -1.03580348e-01f,
  -3.98840979e-02f, -6.01048321e-02f, -5.82612678e-02f, 2.85585552e-01f, -1.11677617e-01f, 1.51594669e-01f, -1.54092968e-01f, -2.86969066e-01f, 1.42846018e-01f, -9.58757102e-02f,
  3.17585886e-01f, -1.65818393e-01f, -1.62144173e-02f, -3.05732012e-01f, -5.06690741e-02f, -8.36856365e-02f, -4.43695366e-01f, 1.89573318e-01f, -2.04126716e-01f, 1.09542303e-01f,
  3.57610524e-01f, 1.13567919e-01f, 2.54017472e-01f, 2.25387990e-01f, -1.87266439e-01f, 6.90723658e-02f, 8.58233273e-02f, 1.15888879e-01f, -2.02160835e-01f, 4.39307578e-02f,
  3.30342740e-01f, -9.58191752e-02f, -3.07008743e-01f, 3.73157889e-01f, -1.92646578e-01f, 7.71757960e-02f, -8.25124159e-02f, -9.08931419e-02f, -1.33665791e-02f, 4.39285815e-01f,
  -8.37283302e-03f, 1.58418015e-01f, -2.90244818e-01f, 1.08685911e-01f, -6.16944954e-02f, -2.06786305e-01f, -1.00890063e-01f, -3.61779965e-02f, 7.97817204e-03f, 6.63829669e-02f,
  5.83016686e-02f, 4.56156135e-02f, -1.09313600e-01f, -1.23568483e-01f, -2.27604508e-01f, -1.84583902e-01f, 2.79163957e-01f, -1.19950116e-01f, -9.15511325e-03f, -9.02454257e-02f,
  1.31248206e-01f, -4.78450023e-02f, 1.75057650e-01f, 1.24076076e-01f, -4.44281399e-02f, -2.29710788e-01f, 5.60603803e-03f, -1.86135843e-01f, 5.28724045e-02f, -1.17925763e-01f,
  -1.65576518e-01f, -8.65326449e-02f, 1.12072885e-01f, -1.06426693e-01f, 2.56746620e-01f, 6.19131066e-02f, -3.48671824e-01f, 1.08981244e-02f, 7.95296133e-02f, 2.11205110e-01f,
  1.39385343e-01f, -9.63191614e-02f, -1.28764674e-01f, -9.69521701e-02f, -1.90939859e-01f, -1.24762766e-02f, -1.86761335e-01f, -9.08879861e-02f, 6.07451320e-01f, -1.60485014e-01f,
  4.65127230e-02f, -2.32777640e-01f, -7.58527517e-02f, 1.28551334e-01f, -6.71599284e-02f, -9.89690721e-02f, 1.08708218e-02f, -5.14861420e-02f, -3.52042094e-02f, 2.73827743e-02f,
  -2.90327426e-02f, 1.45687358e-02f, 7.78585225e-02f, 1.36345491e-01f, -1.67112635e-03f, -1.59540832e-01f, 4.71940905e-01f, -9.54176709e-02f, -2.03370765e-01f, -1.43042639e-01f,
  -2.01720446e-01f, 4.15533818e-02f, -2.68817861e-02f, 7.56300939e-03f, 1.78513810e-01f, -1.10452466e-01f, 1.90434381e-01f, 7.56619349e-02f, -2.72801165e-02f, -7.75917843e-02f,
  -1.04769602e-01f, -1.59459159e-01f, 8.05241540e-02f, 1.08127259e-01f, -1.34940753e-02f, -1.95153654e-01f, 7.65511319e-02f, 1.03127688e-01f, 1.14541836e-01f, 2.41562471e-01f,
  1.36680588e-01f, 3.99112515e-02f, -6.22376986e-02f, -1.74184628e-02f, 8.90705213e-02f, 5.23422919e-02f, 9.40572843e-02f, 1.73607264e-02f, -7.29989037e-02f, -1.54501915e-01f,
  -1.94598094e-01f, -7.54523352e-02f, -1.21476255e-01f, -8.99888128e-02f, 2.26085514e-01f, -6.45693243e-02f, -5.21967225e-02f, 1.02150545e-01f, -1.23677338e-02f, 8.73156041e-02f,
  -5.88769279e-02f, -2.01346919e-01f, 2.12230876e-01f, -1.15774244e-01f, -7.83369020e-02f, -7.62355924e-02f, 1.37589380e-01f, -1.36805147e-01f, 1.52848318e-01f, 7.60197965e-03f,
  -1.39344148e-02f, -6.09080605e-02f, -9.88922045e-02f, -7.71611333e-02f, -1.89415097e-01f, -1.71843395e-01f, -6.75712451e-02f, -1.87864751e-01f, 2.53688935e-02f, -8.27833414e-02f,
  3.41326207e-01f, -2.95157228e-02f, -3.14905405e-01f, 1.83808327e-01f, 1.62364244e-01f, 5.96626699e-01f, 3.23271900e-01f, -4.46656793e-02f, -1.31358728e-01f, 7.31475130e-02f,
  3.64858136e-02f, 3.25428881e-02f, -2.65247822e-01f, 1.56724885e-01f, 7.63488650e-01f, -1.99128106e-01f, 4.39031839e-01f, -1.58654496e-01f, -9.39919651e-02f, -1.80371985e-01f,
  1.90532774e-01f, -1.23643987e-01f, 3.47886801e-01f, -1.53801665e-01f, -6.38921186e-02f, -2.39238888e-01f, -3.31930518e-02f, 5.37445731e-02f, 1.31838426e-01f, 2.09918022e-01f,
  -9.01954770e-02f, -2.17680514e-01f, 5.68088174e-01f, -2.32707128e-01f, 4.05852705e-01f, 2.10353091e-01f, 1.56982616e-01f, -4.44138646e-01f, -5.51804483e-01f, -5.61032258e-02f,
  -1.83299378e-01f, 1.47466213e-01f, 4.82245058e-01f, 2.49572285e-02f, 3.10333490e-01f, 2.44457394e-01f, -2.00237960e-01f, 3.92202698e-02f, 2.80537438e-02f, 3.42765242e-01f,
  6.14488833e-02f, -3.19012702e-02f, 6.73563629e-02f, -1.52963594e-01f, -8.37508589e-02f, 4.92959842e-02f, -1.83409095e-01f, 1.90605715e-01f, 1.27923176e-01f, -2.67041147e-01f,
  -1.44087911e-01f, -5.69882281e-02f, -2.25568041e-02f, 2.34294653e-01f, -1.52761459e-01f, -1.54786453e-01f, 3.40014458e-01f, 2.92092353e-01f, 2.02047303e-01f, -4.16040093e-01f,
  -3.71068567e-01f, 2.10166276e-01f, 2.56987568e-03f, 2.55483631e-02f, 4.09968495e-01f, 1.33319676e-01f, 5.47270715e-01f, 5.38702235e-02f, 9.04662460e-02f, -7.81037807e-02f,
  6.53903484e-02f, 4.43745106e-02f, -2.03597769e-01f, -1.27100423e-01f, -1.92582592e-01f, -8.76880437e-02f, -6.94980994e-02f, -1.18034013e-01f, -2.18022138e-01f, 3.29119086e-01f,
  6.07582182e-02f, 1.23306029e-02f, -1.98780969e-01f, -5.40293939e-02f, 7.54748797e-03f, -6.68102652e-02f, -1.46338031e-01f, -1.99773908e-01f, -7.44893700e-02f, 1.16867512e-01f,
  9.30574760e-02f, -4.04948920e-01f, -1.93758860e-01f, -1.59721479e-01f, 1.78406820e-01f, 1.56060547e-01f, 3.68965417e-01f, 3.59273180e-02f, 3.92984539e-01f, 8.44514072e-02f,
  -2.73707926e-01f, 2.11604863e-01f, -1.60215914e-01f, 2.47153997e-01f, 7.07152262e-02f, 3.94203402e-02f, -2.19737604e-01f, -1.34451419e-01f, 6.02466837e-02f, 1.98444262e-01f,
  -1.94200531e-01f, 2.17565134e-01f, 1.54486164e-01f, -1.29489740e-03f, 3.11443787e-02f, 3.32885608e-02f, -1.21768869e-01f, 9.72943455e-02f, -1.81502670e-01f, -7.72400573e-02f,
  -8.13776106e-02f, -1.99240774e-01f, -2.16294929e-01f, -5.19896969e-02f, 6.91551864e-02f, -1.40181378e-01f, -5.98699600e-02f, 2.96298079e-02f, 9.90960523e-02f, -9.11315456e-02f,
  -1.62618786e-01f, 3.69507045e-01f, 7.63910040e-02f, -6.22560121e-02f, 7.65684396e-02f, -1.84172034e-01f, -1.79087460e-01f, -1.32258222e-01f, 4.04422171e-02f, -1.37365565e-01f,
  2.73998827e-01f, 1.98406979e-01f, 1.92569703e-01f, -1.22462653e-01f, -1.28155183e-02f, 2.86454231e-01f, 2.25152418e-01f, 3.67564291e-01f, -1.10932082e-01f, 3.93048450e-02f,
  8.44379216e-02f, -4.41991753e-04f, 2.50718687e-02f, 1.58841938e-01f, 1.22166209e-01f, -1.90515622e-01f, 2.20463485e-01f, 1.47772357e-01f, -2.28874926e-02f, 1.39445737e-01f,
  1.06148735e-01f, 4.99485880e-02f, 1.72200501e-01f, 2.22736269e-01f, -3.78930313e-03f, 5.87885045e-02f, 1.74590126e-01f, 1.84516117e-01f, -1.87865049e-01f, 5.77226952e-02f,
  -8.92932862e-02f, -1.25752911e-01f, 1.39159620e-01f, 2.70845741e-01f, 1.59312859e-01f, -1.38906706e-02f, 6.08042441e-02f, 3.32987964e-01f, 1.18019015e-01f, 4.44804393e-02f,
  -1.14902034e-01f, -1.68875158e-01f, 2.05996577e-02f, -1.06027126e-01f, 2.73682088e-01f, 3.95819873e-01f, 1.64716884e-01f, -3.39200407e-01f, 7.93695673e-02f, -2.30930030e-01f,
  -6.46224841e-02f, 3.05343196e-02f, -2.92627394e-01f, 2.58589201e-02f, -8.31462890e-02f, -2.26376969e-02f, 7.14310110e-02f, 9.60829854e-02f, -4.16000672e-02f, -1.89856261e-01f,
  -1.63885718e-03f, 3.03158730e-01f, -2.71619380e-01f, 1.51166171e-01f, -1.75977647e-02f, -7.95799568e-02f, 3.05728227e-01f, 7.60155439e-01f, -1.60227284e-01f, 4.38942015e-01f,
  -2.57314723e-02f, -4.89636421e-01f, 4.60528255e-01f, -1.83740072e-02f, 3.89107466e-01f, 5.74771650e-02f, -3.48783374e-01f, -4.47632432e-01f, -5.25115393e-02f, 6.45909831e-02f,
  -1.46193057e-01f, 1.81197956e-01f, -5.98688014e-02f, 1.97203711e-01f, 2.56804135e-02f, -1.66674659e-01f, 1.17310710e-01f, 8.42979625e-02f, -8.49186182e-02f, 2.04679947e-02f,
  3.43544930e-02f, -6.37374306e-03f, -9.63426009e-02f, -9.67752635e-02f, -8.78916904e-02f, -1.15202442e-01f, 4.94952537e-02f, 4.43893701e-01f, -8.17717686e-02f, -2.34126613e-01f,
  -3.73387150e-03f, 1.46426231e-01f, -2.26861332e-02f, 4.26269889e-01f, -4.05941755e-02f, -7.48800337e-02f, 1.40125141e-01f, 1.32925540e-01f, -2.95184236e-02f, 6.97059184e-02f,
  5.27665205e-02f, 1.79024935e-02f, -1.59353048e-01f, 7.21989572e-02f, -1.46731317e-01f, 1.32418320e-01f, 3.11133116e-01f, 1.44573450e-01f, -9.89934206e-02f, 7.02470690e-02f,
  -8.78678933e-02f, -6.63118437e-02f, 2.60092109e-01f, 1.89373359e-01f, -1.04791358e-01f, 1.03672326e-01f, 2.29968518e-01f, 5.24963066e-02f, 2.12899432e-01f, 1.30499586e-01f,
  9.01898220e-02f, -2.08341658e-01f, -1.07129991e-01f, -9.03096348e-02f, 1.62834093e-01f, 4.18494701e-01f, -2.16182873e-01f, 8.65157247e-02f, 1.14174537e-01f, -6.48372667e-03f,
  2.25861877e-01f, 2.28291675e-01f, -4.81524020e-02f, -2.54141122e-01f, 1.16098545e-01f, -1.99334666e-01f, 1.72276348e-01f, 2.46118288e-02f, 2.23702028e-01f, 1.70462355e-02f,
  2.86740631e-01f, 2.28099629e-01f, 1.10445261e-01f, -1.34635702e-01f, 2.32910305e-01f, 2.29708940e-01f, 9.86772552e-02f, -5.88462539e-02f, -1.89541280e-01f, -4.32288088e-02f,
  2.76635569e-02f, -1.43974438e-01f, 4.51545343e-02f, 1.72862023e-01f, 2.83067971e-02f, 1.84269324e-01f, 1.08677946e-01f, -2.36857310e-03f, -1.78781375e-01f, 3.78003791e-02f,
  -4.09216434e-02f, 1.15637355e-01f, 5.34523606e-01f, 2.41784215e-01f, 4.22326177e-01f, 5.51683009e-01f, 3.53988081e-01f, 2.93604106e-01f, -2.84120858e-01f, 1.62147164e-01f,
  -4.01908308e-02f, 2.32835606e-01f, -4.83615547e-02f, -1.52858138e-01f, 3.78761411e-01f, 7.23014250e-02f, 1.29126072e-01f, -1.14186220e-01f, 9.58269164e-02f, -2.16774568e-02f,
  5.82078815e-01f, -1.23680718e-01f, -5.00748634e-01f, 3.65452692e-02f, -3.32059041e-02f, 2.82117873e-01f, -1.28785193e-01f, -6.54574186e-02f, -4.09067005e-01f, 1.30156294e-01f,
  4.93424773e-01f, 1.25375584e-01f, 1.51312649e-01f, -2.20230848e-01f, -2.43671760e-01f, -3.25483888e-01f, 1.58142611e-01f, -1.78633481e-01f, -2.22312331e-01f, -1.04913846e-01f,
  6.47557452e-02f, 1.09733120e-01f, 1.49301603e-01f, 5.86587526e-02f, 3.67997974e-01f, 4.85984504e-01f, -3.30723971e-01f, 9.56152081e-02f, -2.13956326e-01f, -3.15620527e-02f,
  -1.84899732e-01f, 9.22044292e-02f, -3.02891225e-01f, -1.11822292e-01f, 8.01392496e-02f, 3.01504463e-01f, -1.03282094e-01f, 7.50562996e-02f, -5.10701761e-02f, 3.55815053e-01f,
  1.33852243e-01f, 3.19651246e-01f, -1.07910536e-01f, 1.26096457e-01f, -1.97921857e-01f, 2.04837322e-01f, -8.76898170e-02f, -2.97352094e-02f, 1.29858494e-01f, 9.15954188e-02f,
  -1.28114581e-01f, 1.96725875e-01f, 2.09203497e-01f, 1.17708199e-01f, 1.52005762e-01f, 1.47142678e-01f, -4.40999418e-02f, 6.07049949e-02f, 2.71017700e-01f, -1.54309481e-01f,
  2.58859217e-01f, 1.60542533e-01f, -1.08434958e-02f, -1.53343394e-01f, -1.23914279e-01f, -1.60424694e-01f, 4.33261096e-01f, -1.11210309e-01f, 1.32932857e-01f, -3.16721648e-01f,
  -1.84954971e-01f, -4.40993942e-02f, 3.16682041e-01f, -7.38324830e-03f, -2.08470508e-01f, 1.21332696e-02f, 3.75268370e-01f, -1.00427985e-01f, -3.92689332e-02f, 1.18119329e-01f,
  2.36546218e-01f, -4.99408275e-01f, -3.91035080e-01f, -1.32997364e-01f, 1.69653967e-01f, 1.24658309e-01f, 1.18833296e-01f, 9.29002762e-02f, 3.56039822e-01f, 3.90153855e-01f,
  -1.62657052e-01f, -7.74603710e-02f, 1.36589110e-01f, 1.85086593e-01f, 3.74848358e-02f, -4.48135771e-02f, -2.83615589e-01f, 1.76688045e-01f, -1.05377309e-01f, -8.19891393e-02f,
  -3.33568938e-02f, 3.40612739e-01f, 9.04093236e-02f, 1.68294355e-01f, -1.79266408e-01f, -2.11712047e-01f, 9.54042003e-02f, 2.34239608e-01f, -2.64348071e-02f, -1.01521211e-02f,
  -4.70404960e-02f, 3.36509272e-02f, -1.25370219e-01f, 1.68925375e-01f, 1.02322973e-01f, 3.68699841e-02f, -1.54111966e-01f, 1.02166064e-01f, -8.85908157e-02f, 1.39973328e-01f,
  7.73390532e-02f, -1.37689427e-01f, -9.30360034e-02f, 7.57042021e-02f, 7.52233714e-02f, 1.21025331e-01f, 2.64126156e-02f, -1.16605693e-02f, -4.50630002e-02f, 1.33126983e-02f,
  1.23471186e-01f, 7.87205100e-02f, 1.57779932e-01f, 9.06838179e-02f, -8.58436152e-02f, -9.33450088e-02f, -1.20388046e-01f, 1.03021123e-01f, -1.01560727e-01f, 1.46836549e-01f,
  -3.04346159e-02f, 1.31225064e-01f
};

// L3_fan_Bp_bar (Shape: 1 x 26)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 26;
const float L3_fan_Bp_bar_data[] = {
  3.08879822e-01f, 1.68130979e-01f, 1.10617578e-01f, 1.91144913e-01f, 5.72039038e-02f, 2.57198960e-01f, 1.36099204e-01f, 1.03524685e-01f, -8.12746063e-02f, -3.40883881e-02f,
  -5.21123875e-03f, 2.43124828e-01f, 4.01069671e-01f, 3.39689106e-01f, -3.19839455e-03f, -1.04062892e-01f, -1.17220849e-01f, 4.02930081e-01f, -2.86577363e-03f, 1.83629900e-01f,
  7.85715654e-02f, 4.65637147e-01f, -3.00668236e-02f, -1.06137380e-01f, 1.86023563e-01f, 7.03804716e-02f
};

// L4_linear_W (Shape: 12 x 32)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 32;
const float L4_linear_W_data[] = {
  -2.86398858e-01f, -1.42159849e-01f, -2.70181239e-01f, -1.21345565e-01f, 1.79052547e-01f, 2.82140076e-01f, 7.08801346e-03f, -8.38922858e-02f, -8.85318965e-02f, 4.43516811e-03f,
  -1.34106070e-01f, -1.41617715e-01f, 4.32473160e-02f, 1.64082766e-01f, 5.06847315e-02f, 2.19018206e-01f, 1.26249075e-01f, -8.47052634e-02f, -4.44218308e-01f, -2.87740886e-01f,
  4.79903854e-02f, 4.79602516e-01f, 2.54659444e-01f, -3.12407136e-01f, 4.88350302e-01f, 1.45932108e-01f, 5.14357239e-02f, -3.72149318e-01f, 4.85968322e-01f, 2.07284465e-01f,
  -1.96388617e-01f, 3.92274223e-02f, -6.55587137e-01f, 1.72734588e-01f, -3.00757021e-01f, 4.43354785e-01f, 3.84526044e-01f, 3.59054118e-01f, -3.21389258e-01f, -9.13261995e-02f,
  -1.01100557e-01f, -1.19977668e-01f, 9.86139774e-02f, 5.36520733e-03f, -2.46799856e-01f, -9.01305396e-03f, 3.18132132e-01f, 6.12719171e-02f, -7.93458670e-02f, 6.73958123e-01f,
  -4.34276253e-01f, -3.32177907e-01f, -3.07035465e-02f, 2.51343101e-01f, -7.73006082e-02f, -8.19093287e-02f, 9.55030397e-02f, 2.84892499e-01f, -1.83008760e-01f, -6.35865629e-01f,
  -1.62660837e-01f, 4.53195065e-01f, -1.21690996e-01f, -5.60634583e-02f, 4.86300349e-01f, 2.36376107e-01f, 5.01423240e-01f, -9.34980810e-02f, -1.23469229e-03f, -9.11416393e-03f,
  2.79937573e-02f, 2.07127139e-01f, -1.84926420e-01f, 1.82560071e-01f, 7.93579295e-02f, -3.25143903e-01f, -1.16256118e-01f, -1.37251869e-01f, -2.32617006e-01f, 1.01678140e-01f,
  -1.11480519e-01f, 1.95889071e-01f, 3.83292317e-01f, 3.00452977e-01f, 1.80148333e-01f, -1.25253007e-01f, 3.31449807e-01f, -6.29580617e-01f, -3.60614896e-01f, 3.32691431e-01f,
  4.37937737e-01f, -1.40447751e-01f, -1.18246719e-01f, 4.16164607e-01f, -2.31167581e-02f, 9.64199156e-02f, -1.34980500e-01f, -5.35677373e-01f, -6.94973409e-01f, -1.93926707e-01f,
  9.55499858e-02f, -1.86097939e-02f, -4.02266622e-01f, -3.08995306e-01f, -3.43763262e-01f, -3.30221020e-02f, -1.43015152e-02f, -7.37180263e-02f, 3.84840250e-01f, -2.97246929e-02f,
  9.94244218e-02f, 1.68303013e-01f, 1.11886121e-01f, -3.96981269e-01f, 1.35978743e-01f, 2.77042806e-01f, 4.90308195e-01f, 7.52067044e-02f, 3.01706046e-01f, -2.19682768e-01f,
  2.39230499e-01f, -8.80631134e-02f, 1.94115341e-01f, -2.25835696e-01f, 5.15405655e-01f, -1.53403014e-01f, 4.18464303e-01f, -7.66325295e-02f, -3.52212548e-01f, -5.10749638e-01f,
  -6.89921796e-01f, -3.62634271e-01f, -4.39647347e-01f, -5.45517862e-01f, -2.51648754e-01f, 2.28237584e-01f, 2.22327769e-01f, 2.81568263e-02f, 1.12087697e-01f, -1.90346912e-01f,
  5.91738462e-01f, 5.58667518e-02f, -2.21860290e-01f, 1.15728468e-01f, 1.56121021e-02f, -2.29423985e-01f, 3.51026297e-01f, -1.56414926e-01f, 1.80448860e-01f, 1.86213218e-02f,
  -1.67402476e-01f, -1.61933675e-02f, 3.40633154e-01f, 3.12844694e-01f, -1.63810149e-01f, -8.86365324e-02f, 3.34203273e-01f, 3.90207022e-02f, -9.29158181e-02f, 1.10455053e-02f,
  1.06348619e-01f, -3.80390584e-01f, -3.99686657e-02f, 4.15895134e-01f, 2.38385379e-01f, 4.02921677e-01f, 1.13437973e-01f, 6.66722581e-02f, 3.55251342e-01f, 1.10712822e-03f,
  1.22387335e-01f, -6.41975701e-02f, -2.77242381e-02f, -8.42382833e-02f, 1.69220507e-01f, -1.55079529e-01f, -7.14290962e-02f, 6.75638855e-01f, -2.38433599e-01f, -2.17763305e-01f,
  -2.37353504e-01f, 1.26368105e-01f, 6.48159906e-02f, -3.39670002e-01f, -5.46943285e-02f, 2.05250159e-01f, -2.17136160e-01f, 4.50989127e-01f, 1.04373150e-01f, -3.41761634e-02f,
  -1.53416942e-03f, 3.57708745e-02f, 4.66393054e-01f, 8.36834192e-01f, 6.13190293e-01f, -5.82620129e-02f, 6.73916489e-02f, 4.71659452e-02f, 5.13591290e-01f, -1.90550368e-02f,
  1.89300090e-01f, -8.35713893e-02f, 1.76848307e-01f, -4.07077000e-02f, -3.00182462e-01f, -2.34214440e-01f, -2.22976476e-01f, -1.23334579e-01f, -2.62646060e-02f, -4.50972706e-01f,
  4.00688797e-01f, 6.10169828e-01f, 6.27944712e-03f, -3.33786935e-01f, -8.39009508e-02f, 2.90547758e-01f, -3.31119835e-01f, -1.95962548e-01f, 8.85720626e-02f, 3.45505595e-01f,
  -3.55154067e-01f, -1.61987394e-01f, 4.21653122e-01f, 7.24936053e-02f, 2.36855596e-01f, 2.67789423e-01f, 2.77576685e-01f, -2.06866786e-01f, -3.74756485e-01f, -2.98843235e-01f,
  -4.07729633e-02f, -3.71205002e-01f, -2.57685274e-01f, 2.13834420e-02f, 1.57791898e-01f, 2.67651051e-01f, -4.58087415e-01f, -1.08419523e-01f, -9.96752754e-02f, -1.77698568e-01f,
  9.02823880e-02f, -4.04706776e-01f, -2.54991770e-01f, -2.22501114e-01f, 1.77622125e-01f, 1.58691257e-01f, 1.68312475e-01f, 8.81983817e-01f, -2.68845826e-01f, -2.45651305e-01f,
  2.01686203e-01f, -4.15546924e-01f, 1.77388310e-01f, 1.05249718e-01f, 3.06718409e-01f, -6.14847392e-02f, -3.72486860e-01f, -6.76379204e-01f, -4.97238904e-01f, -2.26861075e-01f,
  -2.90714055e-01f, 3.15457731e-02f, -1.87399209e-01f, -2.28679076e-01f, 1.80109411e-01f, -2.95960605e-01f, 2.39238683e-02f, 9.59300771e-02f, -1.45181134e-01f, 4.87189144e-01f,
  5.94581544e-01f, 1.74981933e-02f, 4.18756634e-01f, 5.37870586e-01f, -5.09010023e-03f, -3.54714513e-01f, -1.70513883e-01f, -5.89622036e-02f, -2.97759652e-01f, -8.44565872e-03f,
  4.61398065e-02f, -3.19765776e-01f, -2.44940922e-01f, 2.22454369e-01f, -6.82253987e-02f, 2.81713128e-01f, -2.32018724e-01f, 1.46023964e-03f, 4.39890660e-02f, 1.09459162e-01f,
  4.22334105e-01f, -5.52012861e-01f, -7.90399551e-01f, -7.12055862e-01f, 1.05183095e-01f, -4.64252979e-02f, -8.89387801e-02f, -5.57372756e-02f, -1.74157605e-01f, -2.31101736e-01f,
  3.95856529e-01f, 4.59708050e-02f, -2.40973577e-01f, -1.65869698e-01f, -1.37470722e-01f, -5.11993825e-01f, 5.72584987e-01f, 3.82183462e-01f, 5.44144273e-01f, -1.03622392e-01f,
  -1.60976097e-01f, -1.23702526e-01f, -3.23071182e-01f, -8.23163018e-02f, 8.81281570e-02f, -5.14984190e-01f, 4.72564548e-01f, -1.97494671e-01f, 5.48884571e-01f, -1.85203388e-01f,
  4.95640010e-01f, 3.40787351e-01f, 1.84707612e-01f, -2.93003619e-02f, 3.75446290e-01f, 5.95109940e-01f, 5.65878689e-01f, 6.49045348e-01f, 2.07575679e-01f, 4.00365353e-01f,
  2.34748513e-01f, -1.49435729e-01f, 2.30838507e-01f, 9.73678082e-02f, -3.64306182e-01f, 4.26917709e-03f, -2.02844039e-01f, -1.61801681e-01f, -1.77597642e-01f, -2.12502673e-01f,
  -2.01280668e-01f, -1.45552024e-01f, -2.66226679e-01f, -3.67049843e-01f, -7.74086267e-02f, 1.12560064e-01f, -2.74431229e-01f, 6.79523528e-01f, -3.18617672e-01f, -3.05317044e-01f,
  -4.45364624e-01f, 1.49244949e-01f, 1.29682213e-01f, 3.44609231e-01f, 2.87101030e-01f, 6.21121109e-01f, 6.17786348e-01f, 5.16213059e-01f, 1.56066507e-01f, -3.55138272e-01f,
  2.79763997e-01f, -3.58857848e-02f, 1.01981886e-01f, 4.34277654e-01f, -3.45046639e-01f, 9.49143842e-02f, 1.20514207e-01f, -1.96362346e-01f, 1.36207387e-01f, 8.12217221e-02f,
  -3.57577682e-01f, -2.75914907e-01f, -3.45377296e-01f, -3.54718655e-01f, -3.62789035e-02f, 5.33451200e-01f, -3.06720823e-01f, -1.65801153e-01f, 4.97317053e-02f, 6.11418784e-01f,
  -3.57766151e-01f, -3.26597393e-01f, -1.62259594e-01f, 8.76697972e-02f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  -3.57826144e-01f, -1.68825746e-01f, 1.66558668e-01f, -3.55302095e-01f, -2.44828194e-01f, -3.87992971e-02f, 5.17633557e-01f, 1.39841139e-01f, -3.33132148e-01f, 7.70923123e-02f,
  4.02094014e-02f, 1.04519516e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 3, 26
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 3, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        32, 3, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        32, 3, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        32, 12
    );
    }
    