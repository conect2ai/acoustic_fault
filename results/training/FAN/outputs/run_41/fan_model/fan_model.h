/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 3 x 120)
const int L0_fan_Wp_rows = 3;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  1.06223650e-01f, 1.25547573e-01f, 4.63700071e-02f, 1.78633273e-01f, 2.03282252e-01f, -5.85749224e-02f, -1.24265261e-01f, 2.59447485e-01f, -7.90643767e-02f, 1.29011810e-01f,
  8.84825066e-02f, -1.44186076e-02f, -1.83636591e-01f, 2.14615002e-01f, -1.87964633e-01f, -2.18798950e-01f, 1.27642974e-01f, 1.46066630e-02f, 5.15380118e-04f, 4.00708951e-02f,
  -4.83850483e-03f, 2.25228786e-01f, 6.82629365e-03f, 2.48134837e-01f, 1.60322025e-01f, 1.03027537e-01f, 5.78833558e-02f, -1.92400843e-01f, 2.67889231e-01f, 2.76509337e-02f,
  -7.32406080e-02f, -9.06054117e-03f, 9.13064107e-02f, -1.37278540e-02f, 6.51317164e-02f, 1.67657845e-02f, 4.59668152e-02f, -9.67931226e-02f, -4.11664955e-02f, 1.92029718e-02f,
  -9.94075760e-02f, -2.41905581e-02f, 5.34162596e-02f, -7.54093304e-02f, -1.87457427e-02f, -1.90235768e-02f, -2.99305581e-02f, 9.85112935e-02f, 1.04179624e-02f, -7.76236504e-02f,
  -5.83666340e-02f, -8.04721005e-03f, 6.78006094e-03f, -2.69326922e-02f, -4.67204638e-02f, -1.14047611e-02f, 3.83619629e-02f, 2.31940262e-02f, -3.93907027e-03f, 4.17906828e-02f,
  -5.79621568e-02f, 2.13898602e-03f, 2.56693903e-02f, 4.80728783e-02f, -3.69922780e-02f, 7.19042122e-02f, -3.03218029e-02f, -1.71315987e-02f, -4.63581011e-02f, 4.79322374e-02f,
  -1.84311284e-04f, 2.10475717e-02f, 2.51631532e-03f, 5.11736572e-02f, 2.65726838e-02f, -1.01060253e-02f, -6.39467165e-02f, 1.34860203e-02f, -3.33053656e-02f, 3.02012544e-02f,
  3.02533638e-02f, -1.36508876e-02f, -2.11992264e-02f, 6.56159222e-03f, -4.03017886e-02f, -3.14618386e-02f, -3.09124347e-02f, 4.81495343e-04f, -5.28140634e-04f, 1.38697550e-02f,
  -1.63481727e-01f, 2.46733036e-02f, 6.09337119e-03f, -2.28766483e-04f, 3.24058272e-02f, -2.28054170e-02f, -3.45663242e-02f, 3.30272540e-02f, -6.83983564e-02f, 5.79362847e-02f,
  7.02109784e-02f, 4.78180349e-02f, 5.72574884e-03f, -1.04566794e-02f, -4.26287204e-02f, 6.86898604e-02f, -4.78795823e-03f, 9.81171802e-03f, 3.96808460e-02f, -6.03369251e-02f,
  -9.86512657e-03f, -6.63643703e-02f, -2.58646123e-02f, 5.29792570e-02f, 5.56518920e-02f, 1.13487475e-01f, 5.87569475e-02f, -2.65840404e-02f, -1.42375603e-02f, 2.66743544e-03f,
  2.42411509e-01f, -8.49195868e-02f, 1.15886599e-01f, 3.06193262e-01f, 9.72567573e-02f, 2.57483959e-01f, 2.49643415e-01f, -2.34895404e-02f, -9.22833979e-02f, -6.58534989e-02f,
  2.22714230e-01f, -1.43662348e-01f, -1.01976112e-01f, 3.31473857e-01f, 3.56073797e-01f, -9.00987834e-02f, 3.35539848e-01f, -4.15277667e-02f, -7.53706321e-02f, 6.40474334e-02f,
  3.48140895e-02f, 2.34360129e-01f, 2.45259583e-01f, 4.73648198e-02f, 5.05295433e-02f, -1.74142376e-01f, 1.64740905e-01f, -1.06252261e-01f, 1.16505474e-01f, 1.06766634e-03f,
  4.25685477e-03f, 3.39317992e-02f, 7.84841925e-03f, -1.89901274e-02f, 3.99843603e-02f, 1.56973358e-02f, 8.62271637e-02f, -5.27140200e-02f, -2.65935268e-02f, -3.84748466e-02f,
  -4.08892147e-02f, 4.13825922e-03f, -5.95486090e-02f, -3.74950841e-02f, 4.28350009e-02f, 1.69159248e-02f, 3.08968760e-02f, 2.48960312e-02f, 1.90052316e-02f, 4.47849669e-02f,
  -1.70329381e-02f, -4.07174928e-03f, 7.93298781e-02f, -3.68581675e-02f, 7.57693639e-03f, -3.27033326e-02f, 3.28106321e-02f, -2.46220380e-02f, 1.59212966e-02f, -4.69090417e-02f,
  5.40208519e-02f, 3.86443064e-02f, 3.45602855e-02f, 1.03424918e-02f, 3.06196865e-02f, 1.65964849e-02f, -2.17451341e-02f, -8.59368127e-03f, -3.58006693e-02f, 1.87316462e-02f,
  6.66135028e-02f, -9.15057375e-04f, 3.80301120e-04f, 4.56131510e-02f, 8.95291641e-02f, 3.81201468e-02f, -6.86521409e-04f, -3.51503002e-03f, 1.43980868e-02f, 2.20043771e-02f,
  -3.24939676e-02f, 1.42867733e-02f, -6.49436489e-02f, 4.46909033e-02f, -3.35993581e-02f, 1.81317348e-02f, -2.78710891e-02f, -1.86630187e-03f, 3.71757220e-03f, 7.16034696e-02f,
  7.24365786e-02f, 2.78425012e-02f, -6.27750084e-02f, -3.94455995e-03f, -7.02470094e-02f, 1.71061177e-02f, 2.60988250e-02f, -6.07692683e-03f, -4.87041809e-02f, 2.16258448e-02f,
  4.31354642e-02f, 3.10418047e-02f, 2.08591446e-02f, 2.19757948e-02f, -1.59528479e-02f, 4.37748954e-02f, -2.29969043e-02f, -4.55819108e-02f, 6.19304627e-02f, -3.87773663e-02f,
  3.04555316e-02f, -5.27752526e-02f, -6.21323362e-02f, 3.70332338e-02f, 4.47455086e-02f, 5.52862510e-03f, 2.39181183e-02f, 3.88088003e-02f, -3.69036272e-02f, 3.35570723e-02f,
  5.20140707e-01f, -2.30524734e-01f, 2.94094712e-01f, -8.97005126e-02f, -5.65581620e-02f, -1.98849678e-01f, -1.89360008e-01f, -8.29489455e-02f, 9.27256420e-02f, -1.40168160e-01f,
  2.16300804e-02f, 4.12861481e-02f, 1.23313196e-01f, -2.22936556e-01f, 3.38581502e-01f, 7.25680739e-02f, -1.09737748e-02f, -1.87414158e-02f, -3.45465988e-02f, -1.40278805e-02f,
  3.74539271e-02f, -1.48617089e-01f, 7.81956688e-02f, -1.85297072e-01f, -9.20337066e-02f, 7.27950707e-02f, 2.56688707e-02f, 7.02868216e-04f, -5.29025793e-02f, 6.87917843e-02f,
  1.20973259e-01f, 1.71574324e-01f, -1.82316471e-02f, 3.67187336e-02f, 7.50420541e-02f, 7.12651247e-03f, -3.04566342e-02f, 3.88145819e-02f, 3.23627628e-02f, -2.09510364e-02f,
  -2.22630594e-02f, 2.46066265e-02f, 2.05175783e-02f, -1.64057836e-02f, -2.55507249e-02f, -1.92566514e-02f, -7.27010611e-03f, 5.20399399e-03f, -4.90017533e-02f, 3.22632678e-02f,
  -3.45025659e-02f, -1.12457445e-03f, -2.23064311e-02f, 5.87014016e-03f, -2.34242063e-02f, 3.37592978e-03f, 5.57149574e-02f, 2.45945100e-02f, 1.17433649e-02f, 8.90655164e-03f,
  -6.64976193e-03f, 5.63834272e-02f, -1.60630941e-02f, -8.75151251e-03f, 2.97657140e-02f, 3.73681150e-02f, -3.75907123e-02f, 2.35698447e-02f, 4.91477810e-02f, -1.19525157e-02f,
  -2.75402833e-02f, 2.47478504e-02f, 1.17487786e-02f, 1.97930634e-03f, -2.48115975e-02f, -2.35992041e-03f, 5.16891107e-02f, -2.17219107e-02f, -3.24297547e-02f, 1.41922859e-02f,
  2.72445264e-03f, 3.36639513e-03f, -3.60791273e-02f, -8.46718326e-02f, 8.99923965e-03f, 2.27920022e-02f, -1.10480815e-01f, -1.86804519e-03f, -4.03805487e-02f, 5.64158671e-02f,
  4.74358499e-02f, 9.89929289e-02f, -5.62467538e-02f, -8.16118866e-02f, 4.45545614e-02f, -5.52620403e-02f, -3.19556668e-02f, -7.81785790e-03f, 3.45450379e-02f, 5.19184396e-03f,
  3.93059663e-02f, 2.83107236e-02f, 2.03157961e-02f, 2.96698809e-02f, 2.25946233e-02f, -2.36602314e-02f, 3.26225013e-02f, -6.53479528e-03f, -4.38286439e-02f, -3.38335522e-02f,
  -6.57783297e-04f, 2.57243053e-03f, 9.16506276e-02f, -3.47452089e-02f, 7.67661200e-04f, 4.68445607e-02f, -5.06168716e-02f, -6.82678120e-03f, 7.21786246e-02f, -4.76346165e-02f
};

// L0_fan_Wp_bar (Shape: 10 x 120)
const int L0_fan_Wp_bar_rows = 10;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -6.77993894e-01f, 7.92324319e-02f, -4.00897264e-01f, -9.83985956e-05f, -3.25454473e-01f, -5.23831725e-01f, -1.25452012e-01f, -1.37415707e-01f, 7.22007379e-02f, 4.14090335e-01f,
  2.73961633e-01f, -4.70265634e-02f, 4.19163078e-01f, 3.22642662e-02f, -3.38585615e-01f, 3.46123099e-01f, -1.04855970e-01f, 1.08157866e-01f, -4.69719172e-02f, -2.88284272e-01f,
  -1.40926808e-01f, -8.29380602e-02f, -1.86126009e-01f, -2.00169273e-02f, -2.99446613e-01f, -1.37009257e-02f, 1.35638416e-01f, 9.37391911e-03f, -1.09509841e-01f, -1.02975816e-01f,
  -3.13871413e-01f, 7.53618497e-03f, -3.77379768e-02f, -1.01294257e-01f, -1.68735623e-01f, -8.01990274e-03f, -1.05962619e-01f, 1.58868078e-02f, -4.26398069e-02f, -6.95389956e-02f,
  -4.90197167e-03f, 2.31836876e-03f, 1.14105664e-01f, -2.40334384e-02f, -2.35168971e-02f, -4.83465604e-02f, -2.25891005e-02f, -9.94083565e-03f, 1.11972382e-02f, -7.98754022e-02f,
  2.31682882e-02f, -2.84893569e-02f, -4.97519635e-02f, -5.69098024e-03f, 1.20722000e-02f, 9.53123271e-02f, 6.45301268e-02f, 3.47799622e-02f, -9.95058715e-02f, -9.04922932e-02f,
  9.12254769e-03f, 7.86496922e-02f, 2.07584221e-02f, -3.78591157e-02f, -7.88341276e-03f, 5.18029593e-02f, -4.73042093e-02f, 8.07886496e-02f, 2.56444942e-02f, -7.39472359e-02f,
  -4.43605296e-02f, -2.77808104e-02f, -1.81530174e-02f, -8.00053701e-02f, -6.82702065e-02f, 2.52247173e-02f, 3.30675766e-02f, -6.73045889e-02f, -1.38501283e-02f, -5.48000671e-02f,
  -5.50173633e-02f, -5.13450913e-02f, 1.08215302e-01f, 8.31607208e-02f, -8.12262371e-02f, 6.66846633e-02f, -6.86677843e-02f, -6.91596344e-02f, 2.46785805e-02f, -3.90190743e-02f,
  -6.48264825e-01f, -3.20091009e-01f, 9.69152972e-02f, -4.83368747e-02f, 1.02829002e-01f, -4.11044387e-03f, 2.05930341e-02f, -7.98712596e-02f, -2.11017635e-02f, -9.47079211e-02f,
  -5.17395101e-02f, -1.24950809e-02f, -1.70786440e-01f, 9.34571698e-02f, 5.79874851e-02f, -3.09629515e-02f, 3.89924310e-02f, -1.65555086e-02f, -6.86135888e-02f, -5.36747873e-02f,
  3.90198007e-02f, 1.68606185e-03f, 2.67588850e-02f, 1.11386053e-01f, 6.64467365e-02f, 1.78131163e-02f, -9.78038833e-02f, 5.56797273e-02f, -1.06860131e-01f, -3.49990577e-02f,
  1.26824677e-01f, -2.66153902e-01f, -4.72965389e-01f, 1.95444822e-01f, -3.21449459e-01f, -3.22455704e-01f, -4.80680406e-01f, -1.24580771e-01f, -2.54762232e-01f, 6.56142384e-02f,
  7.78119415e-02f, -1.87232450e-01f, -3.49752665e-01f, 4.60788131e-01f, 2.09682047e-01f, -5.41919544e-02f, 1.66388437e-01f, 1.30925819e-01f, -7.52121657e-02f, 1.17142260e-01f,
  2.10772261e-01f, 4.63133186e-01f, 9.51277688e-02f, 2.09130868e-01f, 1.66068971e-01f, 1.59378693e-01f, 2.94739664e-01f, -2.61681676e-01f, 3.50548446e-01f, 2.22302228e-01f,
  7.44379684e-02f, 5.10029029e-03f, -9.54785105e-03f, 1.59199402e-01f, 7.99713880e-02f, -8.82984772e-02f, -1.08360775e-01f, 3.86399217e-02f, -2.91489251e-02f, -1.00528128e-01f,
  6.52461201e-02f, 7.50918612e-02f, 1.25010297e-01f, 9.21255723e-02f, -2.89914124e-02f, -5.28740473e-02f, -8.65032226e-02f, 1.21753076e-02f, -1.94665730e-01f, 6.16991334e-03f,
  -4.82368842e-02f, 1.45744523e-02f, 5.16467616e-02f, 3.04502938e-02f, -6.43871129e-02f, -2.04828888e-04f, 1.63287353e-02f, -6.28000125e-02f, 1.23987496e-02f, 4.59578522e-02f,
  5.81733584e-02f, -2.66096499e-02f, -5.20441756e-02f, 5.57897799e-02f, -4.16356437e-02f, 4.27072272e-02f, -8.47027358e-03f, -9.10255015e-02f, -1.23741059e-02f, -1.69467926e-01f,
  7.24299438e-03f, -6.73021972e-02f, 3.54186748e-03f, -4.69139107e-02f, -3.90792638e-02f, 2.80614793e-02f, 6.81390166e-02f, 5.72106205e-02f, 1.68900210e-02f, -7.07025677e-02f,
  -4.67948355e-02f, -4.66202274e-02f, -2.11566705e-02f, -2.70535015e-02f, 1.34357244e-01f, -2.43155770e-02f, 8.96841139e-02f, -3.52085158e-02f, -8.20326582e-02f, -6.49864823e-02f,
  -1.48017034e-01f, -6.27791509e-02f, -5.86202219e-02f, 3.24935615e-02f, -6.16285279e-02f, -6.11987226e-02f, 1.40156168e-02f, 1.05450310e-01f, -7.97887705e-03f, -1.99748017e-03f,
  5.28053343e-02f, -1.03536762e-01f, -6.12755977e-02f, 2.44301576e-02f, 9.03735384e-02f, -4.68337573e-02f, 6.50631040e-02f, 5.22266701e-02f, 5.28887957e-02f, 3.03227119e-02f,
  5.05111516e-02f, -1.92429572e-02f, -3.03953215e-02f, -1.03041045e-01f, 7.99785182e-02f, -4.48474474e-02f, -9.91911665e-02f, 4.98217158e-02f, 3.84160206e-02f, 1.69384293e-02f,
  -6.82066530e-02f, 3.67055714e-01f, -8.69542826e-03f, 4.11497384e-01f, 6.49278685e-02f, -6.24388158e-02f, -1.35084867e-01f, 4.15133595e-01f, -9.59405378e-02f, 1.72913335e-02f,
  2.83926129e-02f, 1.42828688e-01f, 6.54630437e-02f, 3.15937012e-01f, 2.54063547e-01f, -3.51134330e-01f, 2.50067294e-01f, -4.06958573e-02f, 1.28847182e-01f, 2.01466262e-01f,
  3.13912556e-02f, 2.46868804e-01f, -2.55714096e-02f, 2.47142702e-01f, 1.01116441e-01f, 1.33286715e-01f, 2.71525800e-01f, -4.10917401e-02f, 3.54072303e-01f, 9.45329219e-02f,
  -9.95955840e-02f, 9.14976671e-02f, -1.11915581e-01f, -7.56813362e-02f, -9.46651995e-02f, -6.57472387e-02f, -1.72581404e-01f, -2.97847986e-02f, 5.51620722e-02f, 9.47867334e-02f,
  3.45963659e-03f, 3.43841836e-02f, 6.41988516e-02f, -1.25600949e-01f, -3.17017958e-02f, 1.02664329e-01f, -4.55031097e-02f, -1.16737604e-01f, -8.11975542e-03f, -3.19538750e-02f,
  3.45225036e-02f, 7.44222105e-02f, -1.18565887e-01f, 3.47524509e-02f, -2.53442302e-02f, 5.72448000e-02f, -6.30370453e-02f, 3.99474874e-02f, 1.38617098e-01f, 4.86886837e-02f,
  5.01303747e-02f, -1.31897911e-01f, -5.55468541e-05f, 6.67689368e-02f, 4.90411408e-02f, 1.92486756e-02f, 8.77107829e-02f, 5.63752018e-02f, -1.95034090e-02f, 1.19531592e-02f,
  5.81444800e-02f, 6.81755021e-02f, -1.54492520e-02f, -6.54349625e-02f, -1.90183684e-01f, 2.09110398e-02f, -4.11140807e-02f, -6.25028228e-03f, -1.65670421e-02f, -2.62162723e-02f,
  -9.92552843e-03f, 1.28828153e-01f, -3.25291455e-02f, -2.04106867e-01f, 3.78819518e-02f, 1.11509904e-01f, 2.32451230e-01f, -1.07201591e-01f, 5.67696579e-02f, -5.93674965e-02f,
  -1.40130967e-01f, 1.92169651e-01f, 4.64861318e-02f, -9.50503349e-02f, 4.76265177e-02f, 3.01576052e-02f, -1.24236852e-01f, 1.14733674e-01f, 2.53024735e-02f, 2.48738658e-02f,
  -9.46479961e-02f, -9.00603384e-02f, -1.43470783e-02f, -5.60473418e-03f, 1.09078363e-01f, -2.60286573e-02f, 9.07005221e-02f, -3.40628177e-02f, 1.39900118e-01f, 1.56252474e-01f,
  1.44356154e-02f, 3.63143124e-02f, 4.61287685e-02f, -4.90758270e-02f, -5.41846603e-02f, -5.23980856e-02f, 1.78299230e-02f, -1.50313735e-01f, 6.68045878e-02f, 4.52022208e-03f,
  -2.10928246e-01f, 2.81668454e-01f, 1.25273645e-01f, -5.60090877e-03f, -1.69699416e-01f, -4.68930840e-01f, -3.99626136e-01f, 1.05789900e-01f, -6.37402683e-02f, 2.74575114e-01f,
  8.31234977e-02f, -3.05105001e-02f, -2.80795917e-02f, -1.88150495e-01f, -4.71885979e-01f, -4.57650304e-01f, -1.52959436e-01f, -4.47366610e-02f, -3.24937195e-01f, 1.02473147e-01f,
  2.84958389e-02f, -1.52649328e-01f, 6.29439354e-02f, 2.01859221e-01f, 1.53524786e-01f, 3.63394350e-01f, 3.46934080e-01f, 1.14368260e-01f, 4.22379732e-01f, -1.60788581e-01f,
  -9.15769115e-02f, -1.32192492e-01f, 2.09900379e-01f, -1.49176242e-02f, 1.38185307e-01f, 9.66713578e-02f, 1.43891379e-01f, 3.10318987e-03f, 2.30918434e-02f, -4.75079268e-02f,
  3.41483764e-02f, -2.87809828e-03f, 5.38111702e-02f, -5.41747026e-02f, 3.49028818e-02f, -3.18525359e-02f, 9.69706755e-03f, 4.00879569e-02f, 1.13634042e-01f, -9.38200876e-02f,
  8.74231569e-03f, 6.23714849e-02f, 6.37956560e-02f, -7.10887276e-03f, -1.82036329e-02f, -2.34577060e-02f, -2.95084864e-02f, 1.17104858e-01f, -4.06350307e-02f, 5.50222620e-02f,
  1.71559472e-02f, -6.42992835e-03f, -3.31235044e-02f, -9.99231637e-02f, -6.90534040e-02f, -3.89609113e-02f, -1.30603522e-01f, 4.98512797e-02f, -4.27817479e-02f, -5.56527637e-02f,
  1.80883091e-02f, 2.10848055e-03f, -4.90596294e-02f, 1.11961029e-02f, 2.83623897e-02f, -1.05230756e-01f, 8.77436399e-02f, 2.54376680e-02f, 1.71342120e-02f, 9.31297988e-02f,
  -5.87638356e-02f, 3.01549188e-03f, 1.02762349e-01f, 4.27535959e-02f, -1.11165389e-01f, 4.96205389e-02f, 2.97957212e-02f, 1.04921520e-01f, 2.12526228e-03f, 5.67603968e-02f,
  9.05006602e-02f, 2.67586052e-01f, 1.43720545e-02f, 6.34469884e-03f, -6.83238804e-02f, -2.51220241e-02f, -1.60006478e-01f, -1.72503553e-02f, 4.43541855e-02f, -1.47700861e-01f,
  1.87860578e-01f, 3.15089785e-02f, -1.07119000e-02f, -7.06297755e-02f, 7.67149553e-02f, 1.03021532e-01f, 1.69774249e-01f, 7.26336017e-02f, 1.15602590e-01f, 1.96500868e-01f,
  1.61945984e-01f, -7.57754520e-02f, -5.79647943e-02f, -1.49016539e-02f, 2.15299912e-02f, 3.54333296e-02f, -3.30115482e-02f, 1.06886603e-01f, 9.19742975e-03f, -1.07053429e-01f,
  -5.39684296e-01f, 6.38117671e-01f, -2.27430895e-01f, 1.32653728e-01f, -2.59091228e-01f, 6.23659074e-01f, 2.58000553e-01f, 1.31236851e-01f, 1.34507626e-01f, 4.11142319e-01f,
  9.45688635e-02f, 8.62014815e-02f, 1.29074261e-01f, 4.35501695e-01f, 4.88724224e-02f, 4.11912709e-01f, 3.56368005e-01f, 2.89385647e-01f, 8.42661634e-02f, 1.22590050e-01f,
  -1.30938534e-02f, 2.33038545e-01f, 1.33936293e-03f, 5.98199107e-02f, -1.38090536e-01f, -1.36279494e-01f, -2.43064627e-01f, -2.18275517e-01f, 8.01875070e-02f, -1.27073182e-02f,
  8.36674497e-02f, -9.95266959e-02f, -1.88308030e-01f, -8.88685808e-02f, 6.43978938e-02f, -3.88394371e-02f, 5.22286706e-02f, -1.63465232e-01f, -1.03064522e-01f, 6.11724257e-02f,
  -1.54981045e-02f, -9.92247742e-03f, 3.02785430e-02f, -1.26366705e-01f, -5.14510237e-02f, -1.09615833e-01f, -7.43062124e-02f, 1.89364608e-02f, 2.05917079e-02f, -2.54375190e-02f,
  4.61930670e-02f, 6.64705858e-02f, -3.95057015e-02f, 8.70559886e-02f, -1.02317095e-01f, 3.77724580e-02f, 1.80364862e-01f, 1.94537565e-02f, 7.64518231e-02f, 7.66944587e-02f,
  6.34148866e-02f, 4.31503728e-02f, -1.57261523e-03f, -6.95599765e-02f, 7.05482662e-02f, -9.31565664e-05f, 1.36104301e-02f, 1.02555351e-02f, -4.15439345e-02f, 9.46403518e-02f,
  3.94245870e-02f, -6.91731349e-02f, 9.32881143e-03f, 1.22538887e-01f, 5.90847991e-02f, 8.05312768e-02f, -4.19361554e-02f, -6.55821105e-03f, 3.01808435e-02f, 9.83667076e-02f,
  5.67866787e-02f, -2.22248659e-02f, -2.79165320e-02f, -2.82881856e-02f, -7.31936097e-03f, -2.88191270e-02f, 5.51068969e-03f, 4.17149067e-03f, -6.20246790e-02f, 1.49741117e-02f,
  3.64035845e-01f, 2.72842914e-01f, 6.77179843e-02f, -3.78738455e-02f, 6.69342503e-02f, -2.57092761e-03f, 8.28437693e-03f, 3.67978103e-02f, 1.35824710e-01f, 1.01593276e-02f,
  1.01520577e-02f, -6.26239460e-03f, 3.95801812e-02f, 1.64036057e-03f, -3.27983010e-03f, 9.87742320e-02f, 3.41455191e-02f, 4.01830822e-02f, -5.11578955e-02f, 3.21683846e-02f,
  -4.26469110e-02f, -3.66525538e-03f, 1.20144542e-02f, -1.46739865e-02f, 2.34843027e-02f, 2.48197597e-02f, -5.39896004e-02f, 7.27430824e-03f, -7.93981645e-03f, 2.95691825e-02f,
  7.79260695e-01f, -2.34170128e-02f, 2.04380617e-01f, 5.65076828e-01f, 2.44404778e-01f, -9.12896469e-02f, -3.14792804e-02f, 2.55166560e-01f, 5.77752173e-01f, -2.12424621e-01f,
  1.08132590e-04f, -6.18045367e-02f, -4.05940890e-01f, 2.15883926e-01f, -1.07603669e-01f, -2.14768544e-01f, 3.53293210e-01f, 6.68005422e-02f, 1.74557403e-01f, -1.48954345e-02f,
  2.60689169e-01f, 6.54200315e-02f, -1.16908729e-01f, -1.80939548e-02f, 1.77521184e-01f, 1.46237269e-01f, -1.90285474e-01f, -1.44639015e-01f, 4.12299559e-02f, -3.62209417e-02f,
  1.08510680e-01f, 7.51104280e-02f, 1.09070346e-01f, -2.00711321e-02f, -1.90681368e-02f, -1.25627816e-02f, -1.37044579e-01f, -1.58449605e-01f, 7.22519606e-02f, -3.08916587e-02f,
  -8.44168365e-02f, 1.02577209e-02f, 5.64810298e-02f, -3.27014178e-02f, 1.21215589e-01f, 9.78412852e-02f, 8.40288475e-02f, 4.74133752e-02f, 5.08331023e-02f, 3.88777989e-04f,
  9.76874605e-02f, 5.07749058e-02f, 7.19029829e-02f, -3.46848443e-02f, 7.32911900e-02f, 2.53349748e-02f, -3.38303111e-02f, -6.38399944e-02f, 3.01322229e-02f, 9.70789269e-02f,
  -8.55552927e-02f, -2.72978768e-02f, 2.21697912e-02f, 1.24288373e-01f, 5.16261011e-02f, 5.81990965e-02f, 7.57168047e-04f, -3.74137424e-02f, 5.80305047e-02f, -3.25293392e-02f,
  8.77170414e-02f, 3.18208411e-02f, 1.08128451e-01f, 3.44297588e-02f, 1.23218810e-02f, 2.97281686e-02f, -2.19693333e-02f, -7.77726471e-02f, 5.25412746e-02f, 8.83780196e-02f,
  9.99048632e-03f, 2.05967370e-02f, -6.86608255e-02f, 4.83575976e-03f, -1.17090028e-02f, 8.28856952e-04f, 5.83498031e-02f, 1.72682051e-02f, -2.13605054e-02f, -3.57721443e-03f,
  -6.99973032e-02f, -2.08085224e-01f, -9.25792754e-02f, 1.28539139e-02f, -1.81915220e-02f, -8.46629217e-02f, 9.13138911e-02f, 4.00355123e-02f, -8.59702777e-05f, 1.01686344e-01f,
  -2.05185711e-02f, -1.05821360e-02f, -6.65791035e-02f, 8.67951959e-02f, -3.39792250e-03f, -5.25954776e-02f, -6.79378223e-04f, 2.01060642e-02f, 2.44022924e-02f, -1.86289959e-02f,
  -5.68827838e-02f, -1.13310799e-01f, -1.01536484e-02f, 1.15524583e-01f, 1.01281330e-02f, -1.58419356e-01f, 6.71558008e-02f, 2.87218671e-02f, -5.07777594e-02f, 5.50041348e-03f,
  1.21123664e-01f, -2.30026975e-01f, -1.23645663e-01f, 1.13733141e-02f, 1.15770318e-01f, 9.75178257e-02f, -1.17218293e-01f, -3.55324522e-02f, -3.11905146e-02f, 2.02395141e-01f,
  9.35082212e-02f, -2.03500176e-03f, -3.48971516e-01f, -1.46453261e-01f, -3.53588045e-01f, -4.45425898e-01f, -4.27193046e-02f, 2.49053463e-02f, -1.86947063e-01f, 1.94273189e-01f,
  3.41083072e-02f, -4.64654714e-02f, -1.40704572e-01f, 1.12253182e-01f, 2.13226378e-01f, 3.44644010e-01f, 1.61674201e-01f, -2.14519992e-01f, 1.40725166e-01f, -2.76757747e-01f,
  2.82942574e-03f, -1.78040177e-01f, 4.43374775e-02f, -3.70589085e-02f, 1.36254773e-01f, 1.68778688e-01f, 4.47280258e-02f, -2.03543022e-01f, -1.13642039e-02f, -5.34476675e-02f,
  3.76374610e-02f, -1.07295595e-01f, 8.29887688e-02f, -2.64632367e-02f, 2.30897274e-02f, 1.75683815e-02f, 1.25952316e-02f, 1.37519976e-02f, -1.54512107e-01f, -4.74195415e-03f,
  1.69384722e-02f, -5.79058053e-03f, 1.84939817e-01f, -9.12169553e-03f, -3.23943794e-03f, 7.48481974e-02f, 1.25439391e-01f, -1.67833157e-02f, 1.35947764e-01f, -6.94770589e-02f,
  -2.23328099e-02f, 3.78454998e-02f, 4.13769716e-03f, -1.70050859e-02f, -1.15486108e-01f, 1.19133249e-01f, -1.43233454e-02f, 3.21791023e-02f, 5.12741283e-02f, 5.08583896e-02f,
  3.10031995e-02f, -3.76041681e-02f, 7.41719753e-02f, -9.36057325e-03f, -7.22866459e-03f, 1.69092063e-02f, 1.60248298e-02f, -6.97672144e-02f, 7.81526938e-02f, -4.21554898e-04f,
  -1.53241782e-02f, 7.35206231e-02f, -3.97449248e-02f, -3.10748303e-03f, -1.99931245e-02f, 2.45371237e-02f, -8.12568963e-02f, -1.44585326e-01f, 7.87239801e-03f, 7.37864748e-02f,
  5.80509044e-02f, 1.39150202e-01f, 6.43461794e-02f, 2.62565538e-03f, 8.25204179e-02f, 3.56384404e-02f, -7.42362589e-02f, 4.82559316e-02f, -7.62349963e-02f, -1.80681869e-02f,
  2.12933764e-01f, 1.06305242e-01f, 1.82733178e-01f, -1.74411163e-02f, 7.63783827e-02f, 2.18005711e-03f, 4.44785990e-02f, 8.70088041e-02f, 1.37406915e-01f, -2.66561545e-02f,
  5.23607843e-02f, 1.05537333e-01f, -1.35303782e-02f, 1.75331011e-02f, 1.30564705e-01f, 4.83068563e-02f, 6.88121542e-02f, -1.12484477e-01f, -5.99930249e-03f, 1.75243728e-02f,
  3.90810609e-01f, 5.44145525e-01f, 5.45246005e-01f, 4.63654011e-01f, -2.59467095e-01f, -5.18757761e-01f, -1.32487625e-01f, 7.29944557e-02f, -5.01811877e-02f, 1.06927261e-01f,
  -6.53309971e-02f, 4.04918522e-01f, -1.49670079e-01f, 2.31284142e-01f, -2.92517900e-01f, -1.57562509e-01f, 6.12131692e-02f, 1.75785959e-01f, 1.01972662e-01f, 3.09189022e-01f,
  3.37911658e-02f, -2.61087775e-01f, 2.17792854e-01f, -1.12007827e-01f, 1.99955627e-01f, 3.17857027e-01f, -1.54803663e-01f, -1.06540360e-01f, 1.71108469e-01f, -1.54001281e-01f,
  -1.56290084e-01f, 1.01498380e-01f, 1.41796872e-01f, -5.49924187e-02f, -5.84466122e-02f, 2.37547164e-03f, 9.99837443e-02f, -1.33481666e-01f, -3.70546393e-02f, 2.78355405e-02f,
  -3.47263403e-02f, 1.17632262e-02f, 9.82582420e-02f, -3.91965099e-02f, -5.00369631e-02f, 7.81749412e-02f, 7.29923397e-02f, 7.25944117e-02f, -9.61860716e-02f, 1.00209266e-01f,
  1.13325633e-01f, 1.34927869e-01f, 5.56323379e-02f, 3.70131470e-02f, 1.90307990e-01f, 5.08616082e-02f, -6.56107534e-03f, 1.23828046e-01f, 2.90979631e-02f, -1.03100287e-02f,
  4.54212353e-03f, -9.42174271e-02f, -1.02430575e-01f, -8.30486324e-03f, -2.00795550e-02f, -5.19075170e-02f, 2.56422367e-02f, -4.62526046e-02f, -7.85993636e-02f, -9.54825431e-02f,
  4.89060357e-02f, 2.46271677e-02f, -5.49469516e-02f, -1.48795741e-02f, 1.13658987e-01f, -1.81339364e-02f, -2.60417201e-02f, 2.37432048e-02f, 2.32363176e-02f, 1.22950766e-02f,
  5.68957701e-02f, -7.09235892e-02f, 8.04618187e-03f, -2.37052720e-02f, -1.17193311e-01f, 9.22179297e-02f, 3.57807130e-02f, 5.72757721e-02f, -4.08508757e-04f, -8.47709700e-02f,
  -2.27456003e-01f, 8.20645690e-03f, 6.42726794e-02f, -2.27263360e-03f, -3.67171355e-02f, -3.78029566e-04f, 4.50799912e-02f, 2.55219955e-02f, 5.04217930e-02f, -1.01280369e-01f,
  8.70353505e-02f, -5.16378731e-02f, -1.01870082e-01f, 4.07685526e-02f, -4.38719578e-02f, 5.23358025e-02f, -1.14437990e-01f, 2.10676640e-02f, -1.22604202e-02f, 1.27674952e-01f,
  3.36146615e-02f, -4.22917567e-02f, -9.07443911e-02f, 1.75816398e-02f, -2.70471759e-02f, -2.86805518e-02f, 3.97809409e-02f, 1.36649415e-01f, -7.10480660e-02f, -9.30050481e-03f,
  -2.72332907e-01f, 7.49277622e-02f, -8.86058137e-02f, 1.90307856e-01f, -2.39816219e-01f, -6.23613358e-01f, -5.63992202e-01f, -7.73553774e-02f, -6.42053410e-02f, 2.99022645e-02f,
  -9.88405105e-03f, 4.22105119e-02f, 5.54667041e-03f, 1.07995421e-01f, -2.21604913e-01f, 2.67656356e-01f, -2.09829628e-01f, -4.40827720e-02f, 1.32938221e-01f, 5.76361902e-02f,
  1.71483383e-02f, 1.59707084e-01f, 1.71020865e-01f, 1.07553363e-01f, -5.13445586e-02f, 2.39910603e-01f, 7.80387521e-02f, 1.65976752e-02f, -1.67542592e-01f, -9.62077826e-02f,
  4.03845981e-02f, 3.13207060e-01f, -3.38097103e-02f, 4.51771431e-02f, -1.92706697e-02f, -2.40815699e-01f, -2.20175507e-03f, 1.73736531e-02f, 1.46527160e-02f, -3.68791138e-04f,
  1.17625911e-02f, 8.74289125e-02f, -2.89880298e-02f, 4.83889841e-02f, -8.51471499e-02f, 1.55836985e-01f, 1.06688440e-01f, 3.41021679e-02f, 8.82757008e-02f, -6.13412112e-02f,
  -4.28023748e-02f, 5.06345145e-02f, -5.34743955e-03f, 8.13459679e-02f, 3.09899487e-02f, 3.87434624e-02f, -3.24239321e-02f, 5.69059439e-02f, -1.31450370e-02f, 8.31557736e-02f,
  -1.43075556e-01f, -7.51651973e-02f, 4.29142378e-02f, 3.72113511e-02f, 1.82065647e-02f, 2.40089484e-02f, -4.01152968e-02f, -8.18964019e-02f, 1.61294751e-02f, 1.84763521e-02f,
  -1.06668264e-01f, -6.58912435e-02f, 1.17905550e-01f, -1.77410543e-02f, -2.25083847e-02f, 6.70657158e-02f, 4.77239937e-02f, 2.95272712e-02f, -1.47539005e-01f, 1.47740170e-02f,
  9.74951982e-02f, 1.40167661e-02f, -7.54522681e-02f, 2.38829199e-02f, 2.05716509e-02f, 1.54950982e-02f, 9.92069487e-03f, -6.72207633e-03f, 9.99610424e-02f, -6.88431272e-03f,
  -4.43370864e-02f, 2.83361644e-01f, 3.73261794e-02f, 9.07822475e-02f, 3.92531827e-02f, 4.69633937e-02f, 8.11517611e-02f, -2.45896667e-01f, 3.52700837e-02f, -1.18352935e-01f,
  -3.89796421e-02f, -1.50667429e-02f, -7.50390887e-02f, 1.01181176e-02f, -1.81395300e-02f, -3.90883349e-03f, 3.59563455e-02f, 1.13591462e-01f, -1.95769463e-02f, -1.59193315e-02f,
  6.55182824e-02f, 8.91843159e-03f, -1.75433848e-02f, -1.20040476e-01f, -5.27495146e-02f, 4.21879813e-02f, -4.76733968e-02f, -3.56256403e-02f, 5.84206544e-03f, -9.56096500e-02f,
  -8.42767179e-01f, 2.21388310e-01f, 3.89519900e-01f, -6.67912483e-01f, 1.46562487e-01f, 3.21622580e-01f, -5.28702922e-02f, 1.42561719e-01f, -2.94163376e-01f, -8.33798349e-02f,
  -5.28381504e-02f, -1.79517884e-02f, 1.42867461e-01f, -2.36718263e-02f, -1.35153025e-01f, 9.66666937e-02f, -2.69179881e-01f, -1.39029816e-01f, 7.40775317e-02f, -2.12171957e-01f,
  -1.06756851e-01f, -2.94389755e-01f, 4.75592613e-02f, 1.15114331e-01f, -6.72185123e-02f, -1.53825760e-01f, -2.60852247e-01f, 2.08891183e-01f, 9.82114021e-03f, -1.21174306e-02f,
  -4.98812556e-01f, -9.13898796e-02f, 2.53084600e-02f, 1.64233983e-01f, -5.81625663e-02f, 3.10647134e-02f, -1.52812237e-02f, -8.17836076e-02f, -7.78123960e-02f, -4.57474217e-02f,
  -1.06661711e-02f, 5.46675660e-02f, -5.22530712e-02f, 2.43459214e-02f, 1.50202857e-02f, 9.65471491e-02f, 6.61865473e-02f, 8.80292282e-02f, 2.61839689e-03f, 1.97150782e-01f,
  9.06146839e-02f, 1.03551392e-02f, 4.77562845e-02f, 4.05025622e-03f, 6.08414896e-02f, -3.91323902e-02f, 1.55621078e-02f, 2.94020474e-02f, 1.16696777e-02f, -1.04401730e-01f,
  -6.37635530e-04f, 5.58211952e-02f, 1.01393564e-02f, 4.49289642e-02f, 3.60888653e-02f, -3.78938504e-02f, 1.20149292e-02f, -6.60364926e-02f, 5.45391740e-05f, -5.80498911e-02f,
  -4.24914956e-02f, -2.89233942e-02f, 1.74761079e-02f, -7.02104792e-02f, -1.66075118e-02f, -5.51800393e-02f, -7.77100474e-02f, -4.89053614e-02f, 4.82171588e-02f, 2.18873825e-02f,
  -1.26327807e-02f, 1.72970374e-03f, 3.84167358e-02f, -8.13061371e-02f, 3.80596183e-02f, 4.33049956e-03f, -3.09867738e-03f, 3.14412750e-02f, -5.48409224e-02f, -3.97930779e-02f,
  -5.76691747e-01f, -4.89868879e-01f, -6.08788207e-02f, -1.01567730e-01f, -3.02018058e-02f, 1.31550711e-02f, -1.09965354e-02f, 6.92199990e-02f, -1.46736383e-01f, 1.72419958e-02f,
  -5.86025044e-02f, -7.39485323e-02f, -3.87993343e-02f, 4.12519276e-02f, 1.36694118e-01f, -1.40783533e-01f, -9.22753811e-02f, -7.14204684e-02f, -8.09271261e-02f, -8.64915624e-02f,
  -2.31921822e-02f, -2.99751069e-02f, -2.62312703e-02f, 1.88216995e-02f, 2.64516659e-02f, -1.56830728e-01f, -4.62593213e-02f, -5.61729781e-02f, -3.99771146e-02f, 1.30110756e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 10)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 10;
const float L0_fan_Bp_bar_data[] = {
  3.84789258e-02f, -5.15602790e-02f, 1.44577874e-02f, 1.76417500e-01f, 2.13553622e-01f, 2.54478008e-01f, -1.26371486e-02f, -9.93929505e-02f, 4.46363837e-01f, 7.23572969e-01f
};

// L1_fan_Wp (Shape: 3 x 16)
const int L1_fan_Wp_rows = 3;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  1.00295186e-01f, 1.41953245e-01f, 1.78342447e-01f, 3.06151688e-01f, -3.95424277e-01f, 1.06742539e-01f, -1.10263333e-01f, -2.08091125e-01f, 1.55212238e-01f, 4.46924239e-01f,
  -3.93328041e-01f, -5.49745739e-01f, 1.88940093e-02f, 3.26364309e-01f, 1.34943664e-01f, 2.47521296e-01f, 6.68874457e-02f, 2.98436791e-01f, 1.79494306e-01f, -7.80583918e-02f,
  7.86837190e-02f, -3.29020023e-01f, 5.77687994e-02f, 3.74391347e-01f, -1.51910022e-01f, 6.47727773e-03f, 4.81477439e-01f, 2.89147437e-01f, 3.05772871e-01f, -4.24567342e-01f,
  -3.03052485e-01f, -2.65771121e-01f, 1.23357043e-01f, 1.11996204e-01f, -2.45785549e-01f, 3.37253064e-02f, -2.24803746e-01f, -4.27301526e-01f, 1.00398129e-02f, -2.49473155e-01f,
  9.45819840e-02f, -1.54558616e-02f, 4.76971298e-01f, -2.92559296e-01f, 8.00627023e-02f, -3.31490993e-01f, 4.12666388e-02f, -2.95666277e-01f
};

// L1_fan_Wp_bar (Shape: 10 x 16)
const int L1_fan_Wp_bar_rows = 10;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  -8.34234059e-03f, -3.25522691e-01f, -4.46535736e-01f, 1.24459572e-01f, 2.39595503e-01f, -2.81368464e-01f, 6.77294075e-01f, 5.92824996e-01f, 3.82440299e-01f, 2.82238424e-01f,
  2.17467323e-01f, 9.74858701e-02f, -1.53124675e-01f, -3.62911746e-02f, 5.86568058e-01f, -2.39538867e-02f, 1.05373904e-01f, -5.90514988e-02f, -4.23764259e-01f, 1.92194397e-03f,
  5.08690834e-01f, -6.90121710e-01f, 4.58479017e-01f, 3.42309654e-01f, 3.08504887e-02f, 2.66153932e-01f, 2.33038768e-01f, -2.15450019e-01f, 5.87678611e-01f, -2.35926241e-01f,
  -3.52556957e-03f, -1.80629581e-01f, 4.42528844e-01f, 3.40683937e-01f, 2.29029670e-01f, 5.28163373e-01f, -4.77741390e-01f, -3.53017122e-01f, -1.40520930e-01f, -2.34951943e-01f,
  -3.36504281e-01f, 4.53019261e-01f, -5.71324706e-01f, 7.05612779e-01f, 2.01134250e-01f, 5.39456010e-01f, -8.46097991e-02f, -6.58429563e-02f, 4.62285966e-01f, -1.03466295e-01f,
  -5.52543215e-02f, -3.68539593e-03f, -3.34973276e-01f, -8.85320306e-01f, -8.12088400e-02f, -3.64691705e-01f, 4.46828425e-01f, -1.98159873e-01f, -8.81294720e-03f, -5.44321686e-02f,
  -3.62856686e-01f, -7.22230365e-03f, 2.97268480e-01f, 3.60925466e-01f, 5.91587722e-01f, 8.52772832e-01f, 6.52908623e-01f, -2.39340231e-01f, -5.46094179e-01f, -3.13872665e-01f,
  1.61228925e-01f, -1.01645514e-01f, -2.80325472e-01f, 6.96489513e-01f, 4.80783880e-01f, -4.20647144e-01f, 5.09096324e-01f, 1.88515812e-01f, 4.51221824e-01f, 6.06330931e-01f,
  1.35257989e-02f, 3.49567056e-01f, 8.22795331e-02f, -6.71030998e-01f, 5.18770516e-02f, 4.24132384e-02f, 7.29667664e-01f, 2.08960384e-01f, -4.76800770e-01f, -4.51022983e-01f,
  2.65679777e-01f, -2.43245453e-01f, -3.51040334e-01f, -2.54152000e-01f, 5.00918984e-01f, 5.70998132e-01f, 3.33158076e-01f, -4.43008840e-01f, -2.81328708e-01f, -3.25134061e-02f,
  1.47476539e-01f, 2.13128906e-02f, 8.19647789e-01f, -1.37858763e-01f, 2.41125926e-01f, -5.38284481e-02f, -1.43613726e-01f, -2.93416709e-01f, -5.24109960e-01f, -1.76762938e-01f,
  6.06683612e-01f, 5.45376360e-01f, -2.78619945e-01f, -5.37411869e-01f, 2.37214029e-01f, 3.62853795e-01f, 1.95254572e-02f, 3.75103265e-01f, 2.88955957e-01f, 5.16830862e-01f,
  5.75064242e-01f, 2.38517553e-01f, -2.94747680e-01f, 4.89455163e-01f, -6.34547472e-02f, 7.34760344e-01f, 4.37186271e-01f, 2.33020887e-01f, 3.81418824e-01f, 2.84649491e-01f,
  1.27040669e-01f, -1.38101727e-01f, 3.43476832e-01f, -5.65857947e-01f, 2.79018104e-01f, 1.23552389e-01f, -8.12410843e-03f, -5.77503204e-01f, 7.90919483e-01f, 5.07168472e-01f,
  5.11616562e-03f, -2.92437106e-01f, 2.06414074e-01f, -1.24626420e-01f, 4.83775139e-01f, 6.72445297e-01f, 7.48693407e-01f, -4.45346504e-01f, -2.20752597e-01f, 7.90023804e-02f,
  -7.59474710e-02f, -6.06483340e-01f, -2.14424729e-01f, 1.57956555e-01f, 1.75533488e-01f, 6.53815985e-01f, 3.51123512e-01f, 1.88548774e-01f, -2.92447120e-01f, 4.46648866e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 10)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 10;
const float L1_fan_Bp_bar_data[] = {
  -5.67034408e-02f, 9.07936469e-02f, 2.48613909e-01f, -1.03216670e-01f, 4.07534301e-01f, 1.66732132e-01f, 4.28904235e-01f, 4.37928796e-01f, 4.37476099e-01f, 6.38782442e-01f
};

// L2_fan_Wp (Shape: 3 x 16)
const int L2_fan_Wp_rows = 3;
const int L2_fan_Wp_cols = 16;
const float L2_fan_Wp_data[] = {
  -6.98104873e-02f, 4.14167792e-02f, 1.95082203e-01f, -3.69654447e-01f, -2.70136684e-01f, 3.50433141e-01f, -3.96973267e-02f, 8.73051211e-02f, -3.69159698e-01f, 2.32528150e-01f,
  1.44436629e-02f, 3.36666524e-01f, 2.61203796e-01f, -3.19519132e-01f, 2.71006990e-02f, 4.89252293e-03f, 4.42031100e-02f, 1.86700225e-01f, 4.40717451e-02f, 8.60839114e-02f,
  -1.51952878e-01f, -1.04279898e-01f, -1.36404270e-02f, 3.07262778e-01f, 2.23386697e-02f, 2.75201220e-02f, 1.50943041e-01f, 2.45922014e-01f, 3.13148856e-01f, -4.29805636e-01f,
  9.28418189e-02f, -3.24997157e-01f, 4.16961797e-02f, -4.20976460e-01f, 1.81366950e-01f, -6.37226939e-01f, 4.89213467e-01f, 1.61231637e-01f, 1.51328281e-01f, 4.48339969e-01f,
  2.09928557e-01f, -3.18877071e-01f, -9.52019915e-02f, -1.02298968e-01f, -1.94550857e-01f, -2.23835498e-01f, 3.62277716e-01f, 6.83303177e-02f
};

// L2_fan_Wp_bar (Shape: 10 x 16)
const int L2_fan_Wp_bar_rows = 10;
const int L2_fan_Wp_bar_cols = 16;
const float L2_fan_Wp_bar_data[] = {
  -4.99644466e-02f, 3.70417893e-01f, 3.56672138e-01f, 3.51628542e-01f, 2.87605494e-01f, -3.09279561e-01f, -3.84934932e-01f, -3.60669613e-01f, 5.68019569e-01f, -1.94400519e-01f,
  6.77058160e-01f, 6.78642169e-02f, -4.68791723e-01f, 4.05191928e-02f, -1.47268906e-01f, 7.06726432e-01f, 1.01485208e-01f, -1.45208478e-01f, 3.97543281e-01f, -4.45208848e-01f,
  2.53103822e-01f, 6.06765032e-01f, 3.18141013e-01f, 2.99050957e-01f, -4.56009567e-01f, 5.22454619e-01f, 6.10135317e-01f, 6.25301778e-01f, 9.02171209e-02f, -3.50840688e-01f,
  7.71368980e-01f, 1.94693178e-01f, 6.94815695e-01f, 5.55486739e-01f, 1.14147484e-01f, -9.64178666e-02f, -1.60675704e-01f, -9.99974310e-01f, 4.01040733e-01f, -1.45228356e-01f,
  1.16868004e-01f, -8.67805719e-01f, -2.81499982e-01f, 1.34908020e-01f, 1.22667655e-01f, 8.24774981e-01f, -3.43611449e-01f, 2.88698852e-01f, -5.17147720e-01f, 1.64437100e-01f,
  -3.80456895e-02f, 8.77587020e-01f, -2.90239841e-01f, 2.27790982e-01f, 2.03219697e-01f, 2.94856757e-01f, 6.75389528e-01f, 8.86318445e-01f, 9.12026048e-01f, -2.05522165e-01f,
  3.95459116e-01f, 2.57224321e-01f, -3.36725593e-01f, 9.78550315e-02f, 5.04261374e-01f, 4.96583521e-01f, -3.24369371e-02f, 5.03641248e-01f, -9.82006788e-01f, -7.98073649e-01f,
  2.47013032e-01f, -7.33790040e-01f, -5.78341745e-02f, -4.60307710e-02f, 8.74929652e-02f, 2.93082297e-01f, 8.66366088e-01f, 6.66589737e-01f, -3.32357198e-01f, 1.59355760e-01f,
  2.02833980e-01f, 1.67279080e-01f, 4.06980246e-01f, -3.77717651e-02f, -1.96518358e-02f, 2.54592955e-01f, 5.62378585e-01f, 3.34675372e-01f, -5.56355178e-01f, -1.44628093e-01f,
  5.38894475e-01f, 3.94129038e-01f, 8.22064817e-01f, 1.49631351e-01f, 7.07658708e-01f, -1.18191674e-01f, 4.64687198e-02f, -2.14189172e-01f, 2.11109862e-01f, -9.79957998e-01f,
  5.83876669e-01f, -5.45384943e-01f, -2.66215019e-02f, 1.15986295e-01f, 5.39144218e-01f, -2.08977580e-01f, -3.87360118e-02f, -2.68314838e-01f, -7.65741706e-01f, 4.74472463e-01f,
  5.94884217e-01f, 6.14897966e-01f, 1.43406257e-01f, 3.17780465e-01f, 1.57218248e-01f, 2.96929389e-01f, 5.19077241e-01f, -4.51116204e-01f, -6.97313786e-01f, -7.46906936e-01f,
  5.44107974e-01f, -6.25548840e-01f, 6.51656985e-01f, 3.25844362e-02f, -4.48877931e-01f, -9.03763771e-02f, 1.21179059e-01f, 8.36037755e-01f, 2.66650885e-01f, 5.74771762e-01f,
  3.43182087e-01f, -2.49929875e-01f, 3.14204872e-01f, 2.66568273e-01f, 1.76330835e-01f, -1.51228592e-01f, -2.67438084e-01f, -4.38740104e-02f, 6.22846723e-01f, 9.65480387e-01f,
  5.75338006e-01f, -4.94887829e-01f, 3.91905010e-01f, 5.73223174e-01f, 4.90177542e-01f, 8.22245657e-01f, 6.84514940e-01f, 2.79191226e-01f, -2.36819476e-01f, -2.37827107e-01f,
  -3.63683581e-01f, -4.89168376e-01f, 2.01032013e-01f, 3.01100492e-01f, 6.94423676e-01f, 1.01970911e-01f, 3.41676652e-01f, -1.29734024e-01f, 9.41032842e-02f, 8.58681440e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 10)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 10;
const float L2_fan_Bp_bar_data[] = {
  2.91426122e-01f, 4.28172290e-01f, 6.39029741e-01f, -3.03685874e-01f, 6.09064698e-01f, 5.72820902e-01f, 4.43639517e-01f, 4.95029598e-01f, 2.30449036e-01f, 4.20972288e-01f
};

// L3_fan_Wp (Shape: 3 x 16)
const int L3_fan_Wp_rows = 3;
const int L3_fan_Wp_cols = 16;
const float L3_fan_Wp_data[] = {
  -3.25782248e-03f, 2.78800398e-01f, 1.70533597e-01f, 1.88409328e-01f, 1.76891088e-01f, 4.76994552e-03f, 1.86456531e-01f, -8.57072994e-02f, -2.31473789e-01f, 3.17537606e-01f,
  -1.87736340e-02f, -3.21250856e-02f, -7.93608278e-02f, -1.88321725e-01f, -1.76462486e-01f, 1.93347201e-01f, 3.12524177e-02f, 3.06551486e-01f, -1.29575074e-01f, 4.24288034e-01f,
  1.74393654e-01f, -2.00129673e-01f, -2.30027482e-01f, 2.37797752e-01f, 1.87448606e-01f, 1.41255846e-02f, 3.84167492e-01f, -1.54515773e-01f, 9.67895091e-02f, -3.23827386e-01f,
  -3.08646619e-01f, 2.13819951e-01f, 5.88212311e-02f, -7.63669536e-02f, -1.17954358e-01f, 3.64871830e-01f, 8.32692236e-02f, -3.10201138e-01f, -2.62091458e-01f, 1.72169611e-01f,
  -2.03805268e-02f, 8.51961598e-02f, 6.82532266e-02f, 3.83072942e-02f, -1.58367336e-01f, -2.52218068e-01f, -6.36776611e-02f, 1.50515670e-02f
};

// L3_fan_Wp_bar (Shape: 10 x 16)
const int L3_fan_Wp_bar_rows = 10;
const int L3_fan_Wp_bar_cols = 16;
const float L3_fan_Wp_bar_data[] = {
  -1.57189950e-01f, -4.59093183e-01f, -3.51900965e-01f, 5.68339586e-01f, -8.02203864e-02f, -1.72467604e-02f, -2.16326743e-01f, 4.50876087e-01f, -5.81929982e-01f, 7.25844279e-02f,
  3.20931911e-01f, 2.39238665e-01f, -1.89468846e-01f, -2.27128983e-01f, 7.18663216e-01f, 3.73555750e-01f, -8.02605227e-02f, -3.00524861e-01f, -9.91175324e-02f, 1.82279900e-01f,
  2.77932763e-01f, 2.61797644e-02f, -1.43629283e-01f, 3.20543766e-01f, -1.02670170e-01f, 4.79116470e-01f, 4.08934467e-02f, 5.24187744e-01f, -1.60011441e-01f, -8.76805961e-01f,
  1.93322659e-01f, -3.38918306e-02f, -7.15715647e-01f, -2.95535594e-01f, 1.81062564e-01f, -2.01524675e-01f, -1.70875624e-01f, -4.57619190e-01f, 6.35498583e-01f, 3.13287348e-01f,
  -4.48172867e-01f, 1.21832955e+00f, -2.20830619e-01f, 6.63321000e-03f, -5.59546769e-01f, 3.64639819e-01f, 3.10730904e-01f, 3.44845235e-01f, 1.48795918e-01f, 8.63067731e-02f,
  7.38810778e-01f, 1.04719125e-01f, 3.27784538e-01f, -8.74298573e-01f, 5.13291657e-01f, -5.52763462e-01f, 4.17886049e-01f, 6.29993856e-01f, 9.56990421e-01f, 8.31903517e-03f,
  -5.82928419e-01f, 4.02045101e-01f, 1.46960765e-01f, 6.00592077e-01f, -3.82901758e-01f, 2.86809444e-01f, -3.18099782e-02f, -1.93944886e-01f, -6.01804495e-01f, -2.48511419e-01f,
  1.69583052e-01f, -4.41683978e-01f, 9.75445926e-01f, -3.50369513e-01f, 8.05165172e-01f, -2.79477537e-01f, 7.51699448e-01f, 4.07798171e-01f, -2.95337170e-01f, -6.15558848e-02f,
  2.82917231e-01f, 4.44657922e-01f, -3.29294026e-01f, 1.11845642e-01f, 8.84601474e-02f, -4.57287103e-01f, -4.92676973e-01f, 6.64726496e-02f, 9.14754570e-01f, -1.88394681e-01f,
  8.34947586e-01f, 6.16767049e-01f, 3.23606610e-01f, -7.38949418e-01f, -1.69467628e-01f, -2.21044853e-01f, -4.96285260e-02f, 4.39787470e-02f, -1.10521242e-01f, -2.82409251e-01f,
  -6.53650388e-02f, -4.37221583e-03f, -2.45417580e-01f, -2.83092737e-01f, 5.64302146e-01f, -1.80100933e-01f, 6.73444629e-01f, 2.18263224e-01f, 9.75417793e-02f, -3.86768013e-01f,
  -3.17997545e-01f, -3.25767756e-01f, 3.12594980e-01f, 6.45318627e-01f, 4.40351032e-02f, -6.30272508e-01f, -2.97295451e-01f, 9.47604954e-01f, 8.21871817e-01f, 5.11012413e-02f,
  3.81028593e-01f, -3.35417420e-01f, -5.52666783e-01f, -8.88830721e-02f, 1.24047136e+00f, 1.09440899e+00f, 3.12599480e-01f, 5.19661486e-01f, 9.06979889e-02f, 1.15170525e-02f,
  -1.07164353e-01f, 4.96355444e-02f, 6.96314499e-02f, 3.39101017e-01f, -2.21128896e-01f, 8.09946120e-01f, -3.38987023e-01f, -3.96506369e-01f, -7.16645420e-01f, 4.61068094e-01f,
  1.15740061e-01f, -1.68000683e-01f, 4.13326502e-01f, -8.40223730e-02f, 7.80736446e-01f, 6.98985279e-01f, 1.75549567e-01f, 8.74760985e-01f, 6.03091896e-01f, -8.82662775e-04f,
  -1.20210081e-01f, 8.74940813e-01f, -1.11089371e-01f, -3.23494941e-01f, 2.95271724e-01f, 6.98098958e-01f, -3.99631441e-01f, -1.23337559e-01f, 9.04640615e-01f, 5.58878958e-01f
};

// L3_fan_Bp_bar (Shape: 1 x 10)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 10;
const float L3_fan_Bp_bar_data[] = {
  -2.42091373e-01f, 6.16136640e-02f, 1.37991263e-02f, 1.14376798e-01f, 4.23249066e-01f, 4.80147183e-01f, 1.18141115e-01f, 3.95548433e-01f, 7.37344548e-02f, 2.08473399e-01f
};

// L4_linear_W (Shape: 12 x 16)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 16;
const float L4_linear_W_data[] = {
  -3.60167176e-01f, -1.69247389e-01f, -2.31713280e-01f, 3.53256948e-02f, -7.04097450e-01f, 1.47965133e-01f, 3.94327462e-01f, 5.24795890e-01f, 1.30857313e-02f, -5.84885776e-01f,
  5.30849919e-02f, -4.35684711e-01f, 1.35063782e-01f, -6.54729843e-01f, 5.41980505e-01f, -3.47842947e-02f, 3.38100106e-01f, 4.46336985e-01f, 4.80289757e-01f, -6.27084911e-01f,
  9.48486507e-01f, 5.96914411e-01f, -2.12421231e-02f, 3.20977479e-01f, -1.25895989e+00f, -6.59585118e-01f, -5.38422048e-01f, 3.38674575e-01f, -2.56931722e-01f, -1.39272004e-01f,
  5.19734085e-01f, 2.39650071e-01f, -1.30675331e-01f, 1.56967059e-01f, -2.16839332e-02f, -4.98107672e-01f, 7.67109394e-01f, -6.11513615e-01f, -3.09200317e-01f, -3.26075524e-01f,
  -1.17102072e-01f, -6.59575224e-01f, 5.07538855e-01f, 4.38128322e-01f, 2.94866025e-01f, 1.31284848e-01f, -2.53348827e-01f, -7.84421682e-01f, 1.72881275e-01f, -1.89514965e-01f,
  -3.78107488e-01f, 3.83130491e-01f, 4.93073821e-01f, 4.83332872e-01f, 1.49477869e-01f, 4.44761544e-01f, 7.43120536e-02f, 6.98726997e-02f, -5.05871713e-01f, -6.11425862e-02f,
  -7.07206786e-01f, -8.94471586e-01f, -5.29403031e-01f, 1.76762983e-01f, -1.75360262e-01f, 5.21134853e-01f, 4.54402208e-01f, 3.72213274e-01f, 1.06467068e-01f, -1.10790066e-01f,
  3.25843692e-01f, -1.39240548e-01f, 3.36726695e-01f, 5.50785586e-02f, -7.92554438e-01f, -1.02512693e+00f, 8.60693604e-02f, -1.96736008e-01f, -1.05123319e-01f, 1.02396101e-01f,
  -3.21610086e-02f, -2.80924402e-02f, 2.19275057e-02f, -3.81945550e-01f, -5.17236590e-01f, -4.71078128e-01f, 1.81332439e-01f, -4.52647895e-01f, 1.00598447e-01f, -9.91457999e-01f,
  -3.96969169e-01f, -7.89884865e-01f, -2.02713504e-01f, 4.68648285e-01f, 7.87705705e-02f, 2.08468705e-01f, 1.28931865e-01f, 1.76504686e-01f, -3.61279488e-01f, -3.41722786e-01f,
  -5.06182730e-01f, 2.83422232e-01f, -4.90577191e-01f, 1.12755619e-01f, -5.64520299e-01f, -2.94340909e-01f, 3.02228808e-01f, -7.33971119e-01f, -1.80529967e-01f, 6.30425692e-01f,
  -5.65139413e-01f, -7.55806267e-01f, -1.49526745e-01f, -1.37360975e-01f, -1.55832663e-01f, -2.50915259e-01f, 1.17428973e-01f, 5.02980649e-01f, 1.68778263e-02f, -3.73229571e-02f,
  -6.75494492e-01f, 1.02752164e-01f, -4.20172989e-01f, 5.05144060e-01f, 2.76189685e-01f, -9.53066111e-01f, -4.17371482e-01f, 2.30519921e-01f, 4.01016250e-02f, -1.47707090e-01f,
  1.92288607e-01f, 6.20106831e-02f, -1.91658631e-01f, 2.52590299e-01f, -7.33221531e-01f, 2.04076424e-01f, 1.56837761e-01f, 3.66851747e-01f, 2.80796170e-01f, 4.14202660e-01f,
  2.54719228e-01f, -6.41057134e-01f, -8.85681659e-02f, -6.06530964e-01f, 5.99540293e-01f, 4.47307378e-01f, 2.45199963e-01f, -2.77102947e-01f, -8.52403138e-03f, -7.86720037e-01f,
  -3.35090309e-01f, -6.76201403e-01f, -3.39466542e-01f, 3.62532109e-01f, -5.47592565e-02f, 6.56236857e-02f, -4.00034428e-01f, 1.42291591e-01f, -8.31702888e-01f, 3.26378405e-01f,
  -4.47057456e-01f, -7.92543411e-01f, -3.85496378e-01f, 4.00150329e-01f, -3.18657517e-01f, -2.15851799e-01f, -4.11146373e-01f, -3.25392038e-01f, 4.67532218e-01f, 1.13742940e-01f,
  -1.08136034e+00f, -2.09100977e-01f, 2.53016315e-03f, 4.14764702e-01f, -2.59956628e-01f, -2.61909574e-01f, 3.68730165e-02f, 1.00806721e-01f, -2.67643452e-01f, 4.71730620e-01f,
  -4.70264778e-02f, 5.10673330e-04f, -3.33812416e-01f, -1.07539512e-01f, 2.65753508e-01f, 3.96509737e-01f, 2.52331853e-01f, -3.17332000e-01f, -2.27004185e-01f, 3.77507731e-02f,
  3.67080308e-02f, -8.68782341e-01f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  -2.12925807e-01f, 4.58405912e-01f, 1.62204072e-01f, -6.23247139e-02f, -2.62377411e-01f, 7.30506703e-02f, 1.09923981e-01f, 1.70330107e-02f, -3.16070437e-01f, 3.85841727e-01f,
  -2.25911021e-01f, -1.72050461e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 3, 10
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 3, 10
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        16, 3, 10
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        16, 3, 10
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        16, 12
    );
    }
    