/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -3.58680218e-01f, 6.10530019e-01f, -1.37347028e-01f, -1.32382050e-01f, 2.17167735e-01f, 6.41982779e-02f, 4.40667123e-01f, 1.16714165e-01f, -1.31769821e-01f, 2.08274201e-01f,
  1.20145999e-01f, -1.63401783e-01f, -2.59961724e-01f, -1.34870991e-01f, -9.91114229e-02f, 1.56077221e-01f, -2.66795214e-02f, -4.79607075e-01f, -4.03029174e-01f, 1.54571280e-01f,
  3.52373213e-01f, 8.16133320e-02f, -1.79909065e-01f, -1.57964855e-01f, 1.59775153e-01f, -2.49879003e-01f, 9.90782026e-03f, 3.12344264e-02f, 1.60852283e-01f, -7.57816508e-02f,
  5.70720844e-02f, 1.00883938e-01f, -1.90735534e-01f, 5.77059155e-03f, 7.62655511e-02f, -3.51167284e-02f, 2.73047108e-02f, -6.42943084e-02f, 3.04321200e-02f, -5.58059243e-03f,
  -1.07365903e-02f, 3.44136506e-02f, -9.73468944e-02f, -4.37050723e-02f, 2.49748416e-02f, 8.85735359e-03f, -6.23995773e-02f, -9.81261805e-02f, -4.54113521e-02f, 8.39601681e-02f,
  1.17395826e-01f, 3.25709619e-02f, 1.03699245e-01f, 7.45663792e-02f, 2.50697043e-02f, -8.50066170e-02f, 1.03953175e-01f, 4.41919826e-02f, 9.47268622e-04f, 5.90097718e-02f,
  1.73774583e-03f, 6.72426075e-02f, 4.17953394e-02f, 2.09639054e-02f, -6.41330779e-02f, -2.67260391e-02f, -2.73554716e-02f, 2.19200440e-02f, 3.92727144e-02f, 9.55111813e-03f,
  -4.54023778e-02f, 2.05449257e-02f, -8.63962248e-03f, 1.48589723e-02f, 1.32646905e-02f, 2.18130276e-02f, -2.68715830e-03f, 6.67807609e-02f, 1.62578803e-02f, 3.27873304e-02f,
  -3.28385383e-02f, -4.51994650e-02f, -1.48159089e-02f, 2.27788556e-02f, 6.42283633e-02f, -6.26567081e-02f, -2.12590564e-02f, 3.97012830e-02f, 5.41582704e-02f, 2.72360574e-02f,
  -6.05902448e-02f, -7.28433803e-02f, -1.06750332e-01f, -5.20626418e-02f, 2.65234038e-02f, 6.93327375e-03f, 3.98909710e-02f, 5.10447193e-03f, 5.77031858e-02f, -1.64842885e-02f,
  6.10940345e-02f, -7.50677884e-02f, 7.60249095e-03f, 2.95192190e-02f, -2.15379111e-02f, 5.95458485e-02f, 1.11747459e-02f, -2.14783959e-02f, 2.60461699e-02f, 8.83624330e-02f,
  -1.02745842e-04f, 9.32122860e-03f, -9.05006453e-02f, -6.97729886e-02f, 5.68833537e-02f, -7.74368048e-02f, 4.95247990e-02f, -6.37543350e-02f, -6.67120963e-02f, 7.76792169e-02f,
  -2.02957794e-01f, -3.63632858e-01f, -2.25029528e-01f, -2.08208129e-01f, -1.01028487e-01f, 3.80196720e-02f, -3.04537475e-01f, -1.04935482e-01f, 1.28152892e-01f, -2.15714276e-02f,
  1.07588626e-01f, 2.38809168e-01f, 1.04421206e-01f, 6.56948090e-02f, -9.32370573e-02f, -2.18274474e-01f, -8.33591819e-02f, -9.90357697e-02f, 9.79053378e-02f, -4.17924300e-02f,
  1.91247109e-02f, -7.95523152e-02f, 1.75233483e-02f, 1.22175358e-01f, -9.86418054e-02f, 2.76472539e-01f, 1.51878610e-01f, -3.36152129e-02f, -3.51027306e-03f, -2.77777076e-01f,
  -1.34259716e-01f, -2.71603942e-01f, 6.95980387e-04f, 6.85435385e-02f, -1.66513454e-02f, -6.14846200e-02f, -1.09636337e-01f, -9.70000029e-02f, -2.49878969e-02f, -7.64749125e-02f,
  1.36611778e-02f, -2.59740464e-02f, 1.38822682e-02f, 7.00845337e-03f, -7.28981271e-02f, -6.46117702e-02f, -6.93720160e-03f, -1.14004306e-01f, -9.27789807e-02f, -3.90846469e-02f,
  -4.77792323e-02f, -1.10071570e-01f, -1.21680893e-01f, 3.14511992e-02f, -1.15513399e-01f, -7.35271126e-02f, -2.62497924e-02f, -5.56542911e-02f, -4.55127470e-02f, -5.47278952e-03f,
  -6.75109476e-02f, 1.39790690e-02f, 2.07704995e-02f, -5.03797606e-02f, 1.59378443e-02f, 7.34885558e-02f, 4.47246283e-02f, 6.01094328e-02f, 4.92745228e-02f, -3.83360423e-02f,
  4.41935211e-02f, -1.14222758e-01f, 4.62779254e-02f, -1.78699307e-02f, 2.73829568e-02f, -1.31147597e-02f, -1.69686973e-02f, -1.32551864e-02f, 1.08353436e-01f, -5.13445996e-02f,
  -1.64185893e-02f, -2.25450099e-02f, 4.67268862e-02f, -2.36059390e-02f, -4.56899107e-02f, 3.06233764e-02f, -5.64978942e-02f, 2.11704709e-02f, -1.51275378e-03f, 2.74379607e-02f,
  8.00232589e-02f, 1.19148366e-01f, -9.21745133e-03f, -1.16919868e-01f, 7.55410120e-02f, -4.22775224e-02f, -1.01177655e-02f, 2.76916306e-02f, -3.79432403e-02f, -6.50020763e-02f,
  -2.42241509e-02f, -5.38961627e-02f, -1.04218675e-02f, 2.25971136e-02f, -3.53145115e-02f, 3.10640335e-02f, 4.01269607e-02f, 9.98193920e-02f, 7.30773807e-03f, -5.77233285e-02f,
  -4.75776307e-02f, -4.61416207e-02f, 2.18250323e-02f, -3.68563794e-02f, -1.20552473e-01f, -3.57536785e-02f, -4.42742780e-02f, -4.72716652e-02f, 1.78844705e-02f, 3.58974114e-02f,
  -9.54741538e-02f, -2.16667742e-01f, 5.47668099e-01f, -2.87060261e-01f, 1.23868547e-01f, 3.43660444e-01f, 2.67443180e-01f, 4.44260053e-02f, -1.01646855e-01f, 1.52712138e-02f,
  7.61397555e-02f, -7.41726086e-02f, 4.61987928e-02f, -9.19820294e-02f, 4.65755314e-02f, 1.17417000e-01f, -1.79593921e-01f, -2.95754615e-02f, 3.16598177e-01f, -1.72003116e-02f,
  -3.33596647e-01f, -1.16514362e-01f, -1.22241154e-01f, -9.63431150e-02f, -2.04302490e-01f, 4.55602957e-03f, 1.16956972e-01f, -9.30367131e-03f, -3.10691707e-02f, -7.03673899e-01f,
  -1.51903396e-02f, 5.37587851e-02f, 4.54178490e-02f, -1.30216733e-01f, -5.34997694e-02f, -3.15216370e-02f, 1.45085501e-02f, -6.41507283e-02f, 2.42687459e-03f, -9.97820683e-03f,
  -6.03827313e-02f, -2.85561867e-02f, -1.02012046e-02f, -6.38279393e-02f, 4.67368066e-02f, 1.84716284e-02f, 1.58880465e-02f, -3.67564033e-03f, 2.76286192e-02f, 4.58861962e-02f,
  -7.20390156e-02f, -1.62390713e-02f, 1.96668625e-01f, 5.33187874e-02f, 1.16241083e-01f, -8.50757491e-03f, -2.13104803e-02f, -4.52273078e-02f, 1.45987213e-01f, -1.62016466e-01f,
  1.20109720e-02f, -1.05644052e-03f, 7.90001545e-03f, 5.25596254e-02f, -2.92465240e-02f, 3.14589366e-02f, -9.45298150e-02f, -2.08751000e-02f, -3.15699801e-02f, 3.51720639e-02f,
  -2.52605397e-02f, 1.73054822e-02f, -1.47305774e-02f, 1.48709724e-02f, -9.73188039e-03f, -3.47196385e-02f, -3.52930389e-02f, -4.87928391e-02f, -5.42797670e-02f, -1.85871348e-02f,
  2.13485193e-02f, -1.02606239e-02f, 4.70587946e-02f, -6.30156919e-02f, -3.60390320e-02f, -1.99810155e-02f, -2.92974189e-02f, -4.46843030e-03f, 6.41269088e-02f, -1.81914214e-02f,
  -2.79358514e-02f, 9.65198427e-02f, -1.05388492e-01f, 5.12681827e-02f, -4.65905406e-02f, -1.37470465e-03f, -1.40857445e-02f, -5.14123142e-02f, 6.10237569e-03f, -3.13051604e-02f,
  1.22568021e-02f, 4.85053174e-02f, 4.76182140e-02f, -4.31273058e-02f, 4.72160988e-02f, 1.72494091e-02f, -6.45264983e-02f, 2.09726579e-02f, -7.23092109e-02f, 2.77785100e-02f,
  -1.16561903e-02f, 4.07599956e-02f, 3.23355161e-02f, -7.04425341e-03f, -1.56928189e-02f, 8.15821532e-03f, 8.63570869e-02f, -6.31233444e-03f, 7.10601956e-02f, -1.57349259e-02f,
  -3.13075215e-01f, -2.37400830e-01f, 4.47168835e-02f, -2.90142018e-02f, -2.30365843e-01f, 3.67615651e-03f, -3.17612141e-01f, 1.90257326e-01f, 1.02902457e-01f, -1.80569321e-01f,
  2.28347573e-02f, -4.65846546e-02f, -7.98966885e-02f, 1.48584917e-01f, -8.17227811e-02f, -2.43795186e-01f, -2.50883669e-01f, 4.91561927e-02f, 2.18800470e-01f, 2.37100855e-01f,
  -1.06845044e-01f, -4.08941656e-01f, 1.76487342e-02f, 1.01999849e-01f, -1.24555282e-01f, -5.36092296e-02f, -1.31056130e-01f, -9.87080932e-02f, 3.45272534e-02f, -3.50274891e-01f,
  6.39274204e-03f, -7.48195453e-03f, -1.26666306e-02f, 9.84952319e-03f, -4.24849950e-02f, 6.67114109e-02f, 3.34426798e-02f, 5.48666902e-02f, 3.51971649e-02f, 6.09794110e-02f,
  6.31189905e-04f, 7.15219229e-02f, 2.44119149e-02f, 8.40567867e-04f, 1.42595116e-02f, 1.65445041e-02f, 1.11560859e-01f, 4.11475636e-02f, 5.94083779e-02f, 8.99461657e-02f,
  -2.20409557e-02f, 1.06632477e-02f, -2.32894643e-04f, 1.42581657e-01f, 1.09436661e-01f, 1.30766898e-01f, 9.03116763e-02f, 2.39910349e-01f, 1.71866059e-01f, -8.53030682e-02f,
  -2.50975452e-02f, 3.35473344e-02f, -1.67077989e-03f, 4.96550053e-02f, -5.44720292e-02f, -6.34604990e-02f, -1.62503924e-02f, -1.21520981e-02f, 4.26008813e-02f, -5.37077934e-02f,
  3.53450216e-02f, 2.98046786e-02f, 1.89613383e-02f, 1.59598496e-02f, 2.37723645e-02f, -5.61888479e-02f, 4.57923040e-02f, -2.37976259e-04f, 4.39905152e-02f, -4.04981077e-02f,
  3.99069451e-02f, 4.77252975e-02f, -9.47996005e-02f, 1.16400700e-02f, 4.22716662e-02f, 5.74150421e-02f, -5.25586773e-04f, 6.79042414e-02f, 1.45794209e-02f, 5.11902478e-03f,
  -3.15104574e-01f, -8.13285762e-04f, -1.83654234e-01f, 4.43218574e-02f, -3.29850130e-02f, -3.62589024e-02f, -5.61891273e-02f, 6.55612499e-02f, -4.32568714e-02f, -1.92036331e-02f,
  1.16780899e-01f, -1.39906025e-02f, -9.75410268e-02f, -2.31043678e-02f, -3.74960131e-03f, -2.79721455e-03f, -4.42473777e-02f, -8.42694417e-02f, -2.73008794e-02f, -4.15452197e-02f,
  -7.27080926e-02f, -1.55708212e-02f, -1.73944030e-02f, -8.09713528e-02f, -1.85773242e-03f, -3.65881547e-02f, -1.22216055e-02f, -1.96199920e-02f, -3.49473581e-02f, -1.82636559e-01f,
  -4.77689803e-01f, 3.38942438e-01f, -4.37482893e-01f, -3.47127944e-01f, -4.69653398e-01f, -9.15206224e-03f, 5.60392365e-02f, 1.89394280e-01f, 2.81590875e-02f, 1.39475428e-02f,
  1.89038575e-01f, 9.18940008e-02f, 1.54460981e-01f, 2.18242854e-01f, 1.29862234e-01f, -6.30854592e-02f, -2.90783405e-01f, -2.17322677e-01f, -2.72067130e-01f, -3.25552970e-02f,
  5.70480712e-02f, -1.25603780e-01f, -1.58603713e-01f, 2.19792221e-02f, -5.16167805e-02f, 8.96522403e-02f, -1.15869958e-02f, -2.59625405e-01f, 2.30082259e-01f, -3.74991804e-01f,
  -5.95576428e-02f, -1.37671545e-01f, -9.39674452e-02f, -8.63417163e-02f, -1.14027448e-01f, 6.30009547e-02f, -4.90461625e-02f, -1.41624585e-01f, 1.56167392e-02f, 3.06913089e-02f,
  -4.72533554e-02f, 5.64946681e-02f, -8.75457227e-02f, -4.85867821e-03f, -8.27963352e-02f, -2.03175712e-02f, 9.09226686e-02f, -1.72523707e-02f, -5.96000953e-03f, 5.99535741e-02f,
  1.89103354e-02f, -9.20937508e-02f, -1.72084600e-01f, 2.37065442e-02f, 9.04753730e-02f, -1.23006433e-01f, 2.04133373e-02f, -5.99551667e-03f, 2.80645192e-02f, 2.59378571e-02f,
  3.97649826e-03f, 8.29424337e-03f, 3.12479921e-02f, 1.47332903e-02f, -1.06366177e-03f, 9.00053382e-02f, -3.80841866e-02f, -9.47524887e-03f, -1.90859661e-02f, -2.18910296e-02f,
  -1.51354140e-02f, -1.20534208e-02f, 2.82551926e-02f, -6.50899634e-02f, 4.67233211e-02f, -4.92247492e-02f, -5.25930002e-02f, 4.31174375e-02f, -3.24745029e-02f, 2.88148243e-02f,
  4.77415184e-03f, 1.37463994e-02f, -2.62514409e-02f, 1.10805884e-01f, -1.59866884e-02f, -5.16753830e-03f, -5.89052029e-02f, 3.11508160e-02f, -1.57982558e-02f, -2.85990927e-02f,
  1.80547386e-01f, -3.19342874e-02f, 7.56103024e-02f, 1.05972335e-01f, -1.74626932e-02f, 6.17560297e-02f, 1.52043579e-02f, 6.68519884e-02f, 2.66662962e-03f, -6.81151077e-02f,
  -5.27600199e-02f, 4.54603396e-02f, 3.47881392e-02f, 3.03532239e-02f, -4.78062890e-02f, -2.94775777e-02f, 4.54377867e-02f, 3.28324875e-03f, 9.66783762e-02f, 2.08651591e-02f,
  2.43521333e-02f, -8.77977163e-03f, 8.24135393e-02f, 2.45315991e-02f, 1.46079175e-02f, -4.27165926e-02f, 9.32461470e-02f, -3.06710489e-02f, 8.35277066e-02f, 9.88082215e-02f,
  -2.76935264e-03f, -2.69155353e-01f, -3.84507120e-01f, -2.28487298e-01f, -1.97317809e-01f, 2.02162676e-02f, 2.38874048e-01f, 2.27155551e-01f, 4.55712341e-02f, 8.40490162e-02f,
  -2.63241231e-01f, -3.17879140e-01f, -1.56611398e-01f, -9.40172300e-02f, 5.21923900e-02f, 1.89552233e-01f, -7.81521350e-02f, -3.63876410e-02f, -4.24433164e-02f, 3.34529690e-02f,
  1.68471187e-01f, 7.82903805e-02f, -3.09163500e-02f, 1.07196510e-01f, -8.07327628e-02f, -4.98425998e-02f, -1.88980550e-01f, -2.22015634e-01f, -1.40479162e-01f, -4.04398829e-01f,
  -8.18081647e-02f, -1.77321464e-01f, -3.31215747e-02f, -1.72048971e-01f, -3.86994854e-02f, 4.02664319e-02f, -3.94152850e-02f, -9.35072266e-03f, -2.18735635e-02f, 7.19642863e-02f,
  -2.04194561e-01f, -2.16583982e-02f, -1.20183028e-01f, -6.70187324e-02f, 2.58549601e-02f, 5.29715903e-02f, -2.14473139e-02f, 5.23061939e-02f, 6.96989801e-03f, -7.39279836e-02f,
  -6.42411634e-02f, -2.89031059e-01f, -1.35023579e-01f, 4.66661192e-02f, 3.65529023e-02f, -9.62401107e-02f, -1.19971871e-01f, -6.65373961e-03f, -2.61173323e-02f, 1.38009816e-01f,
  -3.08920406e-02f, 1.86063740e-02f, -7.15333819e-02f, 3.09439767e-02f, -7.53041776e-03f, 2.12063566e-02f, 6.70547364e-03f, -8.04151315e-03f, 6.05357885e-02f, 9.05980840e-02f,
  1.82315614e-02f, -4.21634726e-02f, 1.92622691e-02f, -6.65889063e-04f, -1.02367498e-01f, 5.60295396e-02f, 6.51815906e-03f, 3.20661217e-02f, -7.89377317e-02f, 4.95259948e-02f,
  -9.36804414e-02f, -5.41086029e-03f, -6.24041446e-02f, -4.31163888e-03f, -1.46599650e-01f, 2.52435636e-02f, -4.18248624e-02f, 3.69132794e-02f, 9.75183211e-03f, 1.12294227e-01f,
  2.57651269e-01f, -1.44155204e-01f, 7.51920566e-02f, -4.71219607e-02f, -1.28730744e-01f, -3.77414078e-02f, -1.43691018e-01f, 1.48369819e-02f, -5.13109900e-02f, 3.32445763e-02f,
  -6.58686981e-02f, -5.47352657e-02f, -7.99682662e-02f, 3.33626345e-02f, -3.92164551e-02f, 6.17040358e-02f, -8.80164802e-02f, -6.26661405e-02f, -6.93884939e-02f, -2.64326893e-02f,
  2.02359213e-03f, 2.16634721e-01f, 1.48496836e-01f, 8.09212103e-02f, -7.14755803e-02f, 1.84898172e-02f, 1.64048076e-01f, 1.15674764e-01f, 5.53137101e-02f, 5.92785060e-01f
};

// L0_fan_Wp_bar (Shape: 4 x 120)
const int L0_fan_Wp_bar_rows = 4;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  4.09812361e-01f, 2.51293868e-01f, -8.09897959e-01f, 4.39441502e-01f, -1.75692350e-01f, -1.68645367e-01f, -1.92508891e-01f, 4.11452085e-01f, 3.45833182e-01f, -1.97301835e-01f,
  -1.67091656e-02f, 3.21876615e-01f, 1.73994433e-02f, -1.72548629e-02f, -6.36231294e-03f, -3.96685332e-01f, -4.56138551e-01f, -5.00380874e-01f, -2.34713200e-02f, 4.17881280e-01f,
  2.37922862e-01f, 1.96898758e-01f, 2.92090625e-01f, 2.12665081e-01f, 1.89790465e-02f, -1.46035373e-01f, -5.36388874e-01f, -1.26300275e-01f, -2.53820509e-01f, -8.00004959e-01f,
  -3.48575830e-01f, 9.84089524e-02f, 7.45669454e-02f, 4.38210219e-02f, -3.09835654e-02f, 8.19777399e-02f, 1.08530864e-01f, 1.22123584e-02f, 6.20657168e-02f, 3.84574123e-02f,
  7.42983148e-02f, 1.26374274e-01f, 1.17275186e-01f, -2.35700980e-02f, 5.14755622e-02f, 8.76055732e-02f, 1.01074554e-01f, -2.92759649e-02f, -1.19072497e-01f, 1.45468833e-02f,
  3.06803770e-02f, -2.19186217e-01f, -2.40259841e-01f, -6.90763220e-02f, -9.26353317e-03f, -1.58595994e-01f, -8.73374566e-03f, -1.68802962e-01f, -2.46141523e-01f, -1.43519014e-01f,
  3.05476543e-02f, -2.98834182e-02f, -2.60596741e-02f, 1.35844257e-02f, 9.92544368e-02f, -5.52884452e-02f, -4.60910797e-02f, -4.10714038e-02f, -2.26630121e-02f, 7.11903647e-02f,
  3.83243784e-02f, -1.09308936e-01f, 1.38991354e-02f, 5.97138926e-02f, -1.43153509e-02f, -4.70585376e-02f, -1.06331401e-01f, 4.89905663e-02f, -4.37844098e-02f, 1.61441844e-02f,
  7.13781565e-02f, -6.64521828e-02f, 3.21670212e-02f, 2.66957134e-02f, -5.12287393e-02f, -1.82559304e-02f, -1.72126573e-02f, -2.61642728e-02f, 1.45751268e-01f, 5.02119437e-02f,
  3.61094028e-01f, -1.12087980e-01f, 1.94170251e-02f, 3.88299078e-02f, -6.27154931e-02f, 4.14047912e-02f, -8.66646543e-02f, -5.28359488e-02f, -4.30256724e-02f, 1.85759645e-02f,
  -7.08144456e-02f, 1.23548377e-02f, -1.20654339e-02f, -4.48581874e-02f, 3.31150554e-02f, 3.08113284e-02f, 1.83098745e-02f, -7.48346224e-02f, 1.13538271e-02f, 3.48858014e-02f,
  7.59701664e-03f, 7.43285567e-02f, 1.58682600e-01f, 7.33154193e-02f, 3.97064816e-03f, 8.21480900e-02f, -9.17619765e-02f, 5.27604185e-02f, -4.05758172e-02f, 2.60888696e-01f,
  -5.54935969e-02f, 6.26325846e-01f, 2.47744128e-01f, -3.05455476e-01f, -2.44229972e-01f, 2.39482336e-02f, 4.22342926e-01f, 2.61106938e-01f, -1.92172870e-01f, 1.82313502e-01f,
  -1.78159952e-01f, -2.92650849e-01f, 6.84306994e-02f, 2.58202821e-01f, 5.11873841e-01f, 3.28167170e-01f, 4.06197339e-01f, 2.48666868e-01f, -1.11240141e-01f, -1.16380557e-01f,
  1.09757856e-01f, -9.65511501e-02f, -9.51454192e-02f, 9.82614383e-02f, -6.41630888e-02f, -4.41427290e-01f, 1.32063016e-01f, 8.76083449e-02f, 7.10418299e-02f, 2.46093735e-01f,
  -2.49552935e-01f, 2.85015851e-01f, -1.54703930e-01f, -3.96632142e-02f, 3.49915139e-02f, -9.19975620e-03f, 3.55259515e-02f, 6.83245948e-04f, -1.14463747e-01f, -5.46688624e-02f,
  -2.95707565e-02f, -6.58905581e-02f, 1.59120440e-01f, 8.36333632e-02f, 3.94784026e-02f, 1.14928253e-01f, 2.53445268e-01f, 2.90771186e-01f, 1.74946308e-01f, 1.07621774e-01f,
  -4.11140081e-03f, -1.41338572e-01f, -6.35135025e-02f, 1.09211318e-01f, 2.34600633e-01f, -1.58782959e-01f, -5.12716249e-02f, 5.49120419e-02f, -3.06475423e-02f, 6.76500574e-02f,
  -1.34494677e-01f, -5.49521260e-02f, 1.36999443e-01f, 3.20515484e-02f, -5.85191250e-02f, 6.74169092e-03f, 8.59703496e-02f, 4.99523617e-02f, -3.04913931e-02f, 1.16492873e-02f,
  8.57400056e-03f, -4.67117578e-02f, 8.27995092e-02f, 1.33473082e-02f, -2.81076133e-02f, 1.17200434e-01f, -3.13652232e-02f, 6.23715632e-02f, 2.14864928e-02f, 4.06068265e-02f,
  -5.29096462e-02f, 3.03470045e-02f, -4.45385352e-02f, 1.63574189e-01f, 1.81011744e-02f, 7.42151961e-02f, -7.74739385e-02f, -3.39706279e-02f, -1.27228230e-01f, -1.23309597e-01f,
  -2.16909215e-01f, 1.43935293e-01f, -8.63522813e-02f, 1.95019916e-01f, -4.40913551e-02f, -2.45745014e-02f, -1.37148434e-02f, -1.95477512e-02f, -1.18152268e-01f, 2.89030559e-03f,
  9.54264309e-03f, 3.25058140e-02f, 1.02589667e-01f, 5.40012680e-02f, -1.29739836e-01f, -6.09414279e-02f, 1.60054807e-02f, -8.34989771e-02f, 6.73630834e-02f, -4.32553403e-02f,
  4.02700007e-02f, -1.95203558e-01f, -3.03647846e-01f, 3.48727405e-02f, -3.18906635e-01f, -4.60643142e-01f, -6.04883349e-03f, -2.73163736e-01f, -1.75345615e-01f, -1.37384281e-01f,
  1.53376862e-01f, -5.05942106e-03f, 4.00616467e-01f, -5.88856675e-02f, -5.06369360e-02f, 1.86905906e-01f, 1.12579271e-01f, -1.08047187e-01f, -1.43210754e-01f, 8.31650104e-03f,
  8.56457651e-02f, 3.48341227e-01f, 2.26821721e-01f, 2.38521695e-01f, 2.28169948e-01f, -1.19822603e-02f, -1.53636724e-01f, 1.38158813e-01f, 4.71187204e-01f, 4.19976115e-01f,
  -3.55161279e-02f, -1.15569584e-01f, -4.36559506e-02f, -3.09796166e-02f, 1.84754077e-02f, 2.24726126e-01f, -2.48488918e-01f, -3.80112052e-01f, -1.58772185e-01f, -1.47696480e-01f,
  5.99623740e-01f, -4.88472469e-02f, 3.26224208e-01f, 2.99336668e-02f, 6.09602146e-02f, 1.07629135e-01f, 3.14868510e-01f, -2.62454990e-03f, -2.35717720e-03f, 9.15826336e-02f,
  5.17446995e-02f, 7.91909844e-02f, 1.16378739e-02f, -2.00788267e-02f, 7.68426992e-03f, 2.00401098e-01f, -2.27709398e-01f, -3.65017578e-02f, 1.51353836e-01f, 2.57770449e-01f,
  -4.22666781e-02f, 4.26599719e-02f, 8.02040026e-02f, 2.28284765e-02f, -7.31660565e-03f, 2.40762979e-02f, -4.85696085e-02f, -4.75960337e-02f, 6.20310716e-02f, -7.34947100e-02f,
  8.90014470e-02f, 1.04078636e-01f, 4.28849682e-02f, 7.39228651e-02f, -2.61162240e-02f, -4.34719250e-02f, -5.56045808e-02f, 3.90306078e-02f, 5.67711191e-03f, -8.36880803e-02f,
  3.27664204e-02f, 1.38430998e-01f, -1.00632586e-01f, 5.29413633e-02f, 1.94984913e-01f, -1.38696477e-01f, 2.21067742e-02f, 1.30150840e-01f, 9.35894344e-03f, -4.69002351e-02f,
  -3.26036522e-03f, -7.60177299e-02f, -8.14558044e-02f, -2.64568580e-03f, -9.05931816e-02f, 2.40320638e-02f, 9.72430259e-02f, 6.64489120e-02f, 1.23886243e-02f, -1.22506633e-01f,
  1.20710820e-01f, 8.51644278e-02f, 2.26971149e-01f, 8.65577161e-02f, -6.47753403e-02f, -1.39400333e-01f, 8.47821608e-02f, -5.30269705e-02f, -1.21224463e-01f, 2.82945205e-02f,
  8.08908716e-02f, 7.12906569e-02f, -4.79439162e-02f, -6.76401779e-02f, 1.03351951e-01f, 7.86635932e-03f, -1.82498932e-01f, 1.87198922e-01f, 1.08422205e-01f, 5.09524159e-02f,
  -2.53306538e-01f, 1.03440359e-01f, 1.68669492e-01f, 8.50826949e-02f, 1.74070857e-02f, 2.56349798e-02f, 2.45114014e-01f, 1.18289344e-01f, 6.06864765e-02f, 3.82683277e-02f,
  -1.19318759e+00f, -1.02807321e-01f, -1.98317811e-01f, -1.07642896e-01f, 2.56626785e-01f, 2.38097653e-01f, 2.85983145e-01f, 1.69778675e-01f, 9.34920609e-02f, -1.20564565e-01f,
  4.48564254e-02f, 1.20426245e-01f, -2.97005065e-02f, 1.65707782e-01f, -2.28443500e-02f, 1.09438755e-01f, -9.68744159e-02f, -3.29890341e-01f, 9.90386605e-02f, 4.62714642e-01f,
  3.16833973e-01f, -2.67015815e-01f, -5.58746040e-01f, 6.44725095e-03f, -1.23969736e-02f, -1.08874515e-01f, -1.96654767e-01f, -1.20889127e-01f, 3.98658514e-02f, -2.82343268e-01f,
  -2.41096571e-01f, -2.02473253e-01f, 2.40542367e-01f, -2.77837306e-01f, -9.86387208e-02f, -8.32705051e-02f, 8.11564922e-02f, -1.30351320e-01f, 7.87243322e-02f, 7.08664581e-02f,
  -1.13028482e-01f, 9.49773192e-02f, 6.02729283e-02f, -9.59243160e-03f, -1.84367970e-02f, 1.13397710e-01f, -1.24957569e-01f, -1.16673179e-01f, -3.53591666e-02f, 7.28772730e-02f,
  1.88435510e-01f, 1.22000389e-01f, -3.00437268e-02f, 1.83915570e-01f, 1.92159817e-01f, -9.93112624e-02f, 6.53263479e-02f, -9.88082886e-02f, 2.13918202e-02f, -4.83040154e-01f,
  -3.19382623e-02f, -1.00648761e-01f, -1.26405375e-03f, 1.81419570e-02f, 3.64457630e-02f, -8.30184482e-03f, 3.72317396e-02f, -2.30732430e-02f, 7.54288137e-02f, -1.01870202e-01f,
  1.55824184e-01f, 3.25804763e-02f, 4.85692406e-03f, -2.83252709e-02f, 7.30952546e-02f, -9.52738747e-02f, 7.66226277e-02f, 4.22788411e-02f, 4.89734113e-03f, -3.89823038e-03f,
  -2.43723430e-02f, 4.16575978e-03f, 7.20886979e-03f, 8.94810706e-02f, -3.21721546e-02f, -6.46843091e-02f, -4.94789630e-02f, 1.08410075e-01f, -1.08008429e-01f, 3.28861584e-04f,
  4.40404490e-02f, 1.77688330e-01f, -1.48383677e-01f, 8.46500546e-02f, -3.61688174e-02f, 6.96859583e-02f, -8.76904503e-02f, -4.30453531e-02f, -7.29539394e-02f, -9.57659358e-05f,
  -8.51573236e-03f, -1.04895674e-01f, -1.87177360e-02f, 6.50593713e-02f, 4.28793393e-02f, -6.09098515e-03f, -3.98610979e-02f, -3.65838669e-02f, 1.56749666e-01f, 6.47093654e-02f,
  -5.14874384e-02f, -5.48691228e-02f, -2.41137967e-01f, 1.77327111e-01f, -1.46107316e-01f, 4.21361625e-02f, -2.70405799e-01f, -3.51600610e-02f, -1.98206484e-01f, -5.10311902e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 4)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 4;
const float L0_fan_Bp_bar_data[] = {
  1.54901162e-01f, 4.81511116e-01f, 2.03136634e-02f, 8.07759538e-02f
};

// L1_fan_Wp (Shape: 6 x 16)
const int L1_fan_Wp_rows = 6;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  -3.71444672e-01f, -2.39128053e-01f, 5.47182977e-01f, -4.17962015e-01f, -1.52913425e-02f, 3.57482404e-01f, -3.51055205e-01f, 1.75093189e-01f, 7.40154862e-01f, 2.54031837e-01f,
  1.35347992e-01f, -2.34964833e-01f, 5.70994437e-01f, -3.73106077e-02f, 2.15305582e-01f, 4.01608229e-01f, -1.66713014e-01f, 1.40439823e-01f, 3.41009021e-01f, 4.89983171e-01f,
  2.55930305e-01f, 1.09819300e-01f, -4.62750256e-01f, 2.06798747e-01f, 8.36110562e-02f, 2.21498802e-01f, -1.09557889e-01f, -1.03751056e-01f, -2.30062097e-01f, -7.73802996e-02f,
  1.44611612e-01f, -4.67407465e-01f, 4.73098695e-01f, 2.50727236e-01f, -5.00787562e-03f, -2.22264975e-02f, -1.90459490e-02f, -1.42326966e-01f, -3.21184427e-01f, 6.61610141e-02f,
  4.74859625e-02f, -2.75329500e-01f, 3.89053188e-02f, 2.90729523e-01f, 3.89868408e-01f, -3.22998106e-01f, 1.81414068e-01f, -2.95533419e-01f, 4.89919394e-01f, 8.31829309e-02f,
  -6.28601834e-02f, -1.96102515e-01f, 5.52724749e-02f, -3.31705421e-01f, 4.94355597e-02f, 1.65813804e-01f, -4.36748266e-01f, -1.78115860e-01f, 5.03114700e-01f, 1.29221037e-01f,
  8.73678803e-01f, -5.39706409e-01f, 8.98796767e-02f, -1.87655896e-01f, 9.24483985e-02f, 1.31368414e-01f, 2.95271426e-02f, -1.37370348e-01f, 3.89409393e-01f, 1.08732149e-01f,
  -2.87727326e-01f, 3.95222902e-01f, -7.99009740e-01f, 3.04407269e-01f, 7.16708079e-02f, -3.85214299e-01f, 6.04672372e-01f, -1.07211508e-01f, -1.87885568e-01f, -1.71291888e-01f,
  2.29274467e-01f, 1.54702552e-02f, -5.85801192e-02f, 2.37693936e-01f, -8.20207819e-02f, -1.94229946e-01f, -3.20770293e-01f, -3.51848193e-02f, -4.35057223e-01f, -5.60439527e-01f,
  -3.76274943e-01f, -2.13019103e-01f, -1.17059655e-01f, 6.69265017e-02f, 2.52626419e-01f, -4.81013715e-01f
};

// L1_fan_Wp_bar (Shape: 4 x 16)
const int L1_fan_Wp_bar_rows = 4;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  2.34427691e-01f, 8.95308018e-01f, 1.01439393e+00f, 1.06626260e+00f, 5.36264516e-02f, 2.25775421e-01f, -2.42060676e-01f, 3.67474556e-01f, 8.90104175e-01f, -5.26000746e-02f,
  3.94013226e-01f, 1.33605659e-01f, -1.45707890e-01f, 6.31562471e-01f, -7.43822604e-02f, 2.32711166e-01f, 4.36427295e-01f, 3.85546535e-01f, 1.35200381e-01f, -7.08493143e-02f,
  5.69753587e-01f, 3.59974951e-01f, -3.07817489e-01f, 2.00607747e-01f, -2.31895342e-01f, 6.86257541e-01f, 4.07697409e-01f, -2.31904507e-01f, -1.37719110e-01f, 4.26807791e-01f,
  -7.57854998e-01f, 7.10288882e-01f, 2.40037590e-01f, 1.77835003e-02f, 1.62484288e-01f, 9.99544442e-01f, 4.78223324e-01f, 3.65108162e-01f, -8.31165552e-01f, -5.22481203e-01f,
  -8.00493002e-01f, -4.12868887e-01f, -9.16886926e-01f, -3.89559269e-01f, -5.25518119e-01f, 6.00914717e-01f, -1.57792792e-01f, 1.59570143e-01f, -2.62330532e-01f, 5.12269020e-01f,
  1.35443792e-01f, 1.73156381e-01f, 9.60559100e-02f, -7.86462277e-02f, -8.83060277e-01f, 4.75207537e-01f, 8.73444006e-02f, 3.75675503e-03f, 2.01048598e-01f, -8.35101455e-02f,
  -2.01581180e-01f, 1.97090402e-01f, 2.28838876e-01f, -5.74307382e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 4)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 4;
const float L1_fan_Bp_bar_data[] = {
  5.52135289e-01f, 5.23148715e-01f, 2.76014417e-01f, 5.78492463e-01f
};

// L2_fan_Wp (Shape: 6 x 16)
const int L2_fan_Wp_rows = 6;
const int L2_fan_Wp_cols = 16;
const float L2_fan_Wp_data[] = {
  5.56552187e-02f, -2.69412547e-01f, -1.47337243e-01f, 3.48622173e-01f, 1.33576140e-01f, -5.41847408e-01f, 3.55315864e-01f, 4.45283234e-01f, 1.36300951e-01f, -3.32405090e-01f,
  -9.01492536e-01f, 4.13607240e-01f, -1.45490378e-01f, -1.83727011e-01f, 8.53516877e-01f, -3.52519862e-02f, -6.00348711e-01f, 5.76161563e-01f, 2.75476485e-01f, 1.10792138e-01f,
  -3.18529427e-01f, -2.39767253e-01f, 9.27132294e-02f, 5.85212469e-01f, 4.49507713e-01f, 6.41996264e-01f, 2.46935830e-01f, -3.08189005e-01f, 2.95795232e-01f, -2.35944286e-01f,
  -4.42162871e-01f, 4.60546315e-01f, -1.46485806e-01f, -3.52636516e-01f, -6.01004101e-02f, -1.56860217e-01f, 5.08541925e-05f, -4.05102819e-01f, -5.84609568e-01f, -5.92911720e-01f,
  -3.84163380e-01f, -2.49318823e-01f, 5.50879300e-01f, -9.83337387e-02f, -2.11116403e-01f, 5.32470226e-01f, 3.40246022e-01f, -3.86597395e-01f, -3.56449522e-02f, -3.37696135e-01f,
  -5.45018971e-01f, -6.73433661e-01f, -2.83061534e-01f, 7.69977391e-01f, -2.05078021e-01f, -3.27917844e-01f, -2.48602599e-01f, 8.99565518e-02f, 5.86631954e-01f, -4.14760053e-01f,
  2.29108125e-01f, 8.59471336e-02f, -5.66392839e-01f, 5.77239931e-01f, -5.28101504e-01f, -6.88254163e-02f, 1.82172626e-01f, -1.83222160e-01f, -5.10498555e-03f, -3.28886434e-02f,
  3.92535329e-02f, 7.79234767e-02f, 7.15624869e-01f, 1.94346402e-02f, 8.57214749e-01f, -2.85991609e-01f, -3.14571828e-01f, 5.33733249e-01f, -4.44243886e-02f, 3.71169597e-01f,
  3.29826266e-01f, -8.35935295e-01f, -1.82225659e-01f, -4.33765888e-01f, 1.74363554e-02f, -1.92204013e-01f, 3.87682289e-01f, -4.05117720e-01f, -6.11869276e-01f, -2.29262471e-01f,
  6.65396988e-01f, 1.14234321e-01f, -2.67031014e-01f, 4.04888153e-01f, -5.49257100e-02f, 1.38337627e-01f
};

// L2_fan_Wp_bar (Shape: 4 x 16)
const int L2_fan_Wp_bar_rows = 4;
const int L2_fan_Wp_bar_cols = 16;
const float L2_fan_Wp_bar_data[] = {
  -5.67292213e-01f, -3.62422019e-01f, 3.33139867e-01f, 5.63126922e-01f, 4.74352390e-02f, -2.40874216e-01f, 6.01810157e-01f, 1.07265842e+00f, 5.99663556e-01f, -7.65005887e-01f,
  4.77392256e-01f, -2.03056455e-01f, 1.12477243e-01f, -1.77221373e-01f, 1.86208940e+00f, 6.34266198e-01f, -9.52862322e-01f, 9.12153125e-01f, 4.15877610e-01f, 1.05794394e+00f,
  6.91265106e-01f, -1.32233948e-01f, 1.48186827e+00f, -5.77652082e-02f, -1.09874523e+00f, 5.46377361e-01f, 2.00600103e-01f, -9.17222977e-01f, 7.58987427e-01f, 8.47234905e-01f,
  -1.74642026e-01f, -1.74544454e-02f, 1.28279185e+00f, 1.82572514e-01f, -7.43898690e-01f, -1.39490151e+00f, 2.97994047e-01f, 1.23185074e+00f, 1.73642635e-01f, -4.28955197e-01f,
  -1.59019065e+00f, -9.80731308e-01f, -8.13603640e-01f, 3.09794575e-01f, 3.54419440e-01f, 5.01236677e-01f, 6.55651152e-01f, -8.51502419e-01f, 8.02306950e-01f, -2.96420362e-02f,
  -5.85631847e-01f, -6.79932833e-02f, -1.00614369e-01f, 1.27771604e+00f, 9.42023277e-01f, 6.42140329e-01f, 1.00374961e+00f, -9.04620647e-01f, -3.29360485e-01f, 3.59216988e-01f,
  1.20007288e+00f, -7.19777644e-01f, -1.98787615e-01f, 1.63317978e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 4)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 4;
const float L2_fan_Bp_bar_data[] = {
  5.23693621e-01f, 8.25946108e-02f, 3.40466678e-01f, -3.49236615e-02f
};

// L3_linear_W (Shape: 12 x 16)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 16;
const float L3_linear_W_data[] = {
  -2.52660006e-01f, 1.68838239e+00f, -1.47328126e+00f, 3.00713509e-01f, -1.72733152e+00f, 1.65008187e-01f, -1.41817904e+00f, 4.76668268e-01f, 4.24405605e-01f, 1.12824130e+00f,
  7.12510407e-01f, 1.59044826e+00f, -3.59308392e-01f, -2.92529404e-01f, -1.69734836e-01f, -6.52583241e-01f, -2.46429726e-01f, -8.58033359e-01f, -4.02312428e-01f, -1.12383568e+00f,
  -1.92961559e-01f, 4.43243086e-01f, -6.67466164e-01f, -7.76985586e-01f, -1.15133345e+00f, 6.66612701e-04f, 1.31038457e-01f, -7.19105363e-01f, 4.20385510e-01f, 7.97339752e-02f,
  -1.88433743e+00f, 1.68182999e-01f, -1.92061350e-01f, 3.08844179e-01f, 1.07072318e+00f, 4.74736512e-01f, -1.59615919e-01f, 6.38409495e-01f, 7.04258025e-01f, -5.89912295e-01f,
  8.98262635e-02f, -8.24431106e-02f, 1.05026865e+00f, 2.06303644e+00f, 3.00617963e-01f, -3.00523251e-01f, -1.14731885e-01f, 6.45421520e-02f, 1.59302950e+00f, 9.20278430e-01f,
  9.53426063e-02f, 3.79563332e-01f, 1.45964062e+00f, 2.30852634e-01f, 6.96238339e-01f, -1.10616803e+00f, 6.34089410e-01f, -2.46293604e-01f, -8.09790313e-01f, 3.98871243e-01f,
  -1.66938365e+00f, 6.87315762e-01f, -4.02504690e-02f, -8.45449269e-01f, -7.44899213e-01f, -1.16048205e+00f, 8.52951705e-01f, 8.09504509e-01f, 3.70667756e-01f, -3.07641059e-01f,
  -4.33745116e-01f, 1.27858412e+00f, 5.50465584e-01f, 2.03784078e-01f, 9.93063927e-01f, -4.93881464e-01f, -4.15372163e-01f, 8.57873976e-01f, -1.12787271e+00f, -7.83162236e-01f,
  -4.47628237e-02f, 5.79308033e-01f, 1.29113245e+00f, 8.54814574e-02f, 9.56686258e-01f, 7.03115463e-01f, -1.04473352e+00f, 9.20384347e-01f, -1.25755453e+00f, 7.33161509e-01f,
  1.13623488e+00f, -1.75561622e-01f, -6.32503867e-01f, -5.12600064e-01f, 7.21587464e-02f, 5.75202823e-01f, -5.43724895e-01f, -5.71300209e-01f, -8.50371778e-01f, -5.89471757e-01f,
  8.93285453e-01f, 4.06102717e-01f, -9.09123003e-01f, -3.25961024e-01f, 8.30333754e-02f, -6.30651861e-02f, -7.40674615e-01f, -2.50131398e-01f, 5.60598493e-01f, -9.15061772e-01f,
  3.21642846e-01f, -9.61295784e-01f, -1.28399491e-01f, -1.47524655e+00f, -5.77514350e-01f, 7.39883244e-01f, 2.39176765e-01f, -3.05944949e-01f, 4.24727112e-01f, 1.10670054e+00f,
  -1.27711520e-01f, -2.38962650e-01f, 6.82938620e-02f, 9.76299524e-01f, -9.30690840e-02f, -2.68887162e-01f, 7.00255930e-01f, -6.31225705e-01f, -4.35124427e-01f, 1.01529086e+00f,
  -2.77442425e-01f, 3.00489187e-01f, -7.66171694e-01f, -1.29321873e+00f, 9.68444347e-01f, -4.09658343e-01f, -8.33743751e-01f, -1.07139075e+00f, -1.42972684e+00f, 1.40253045e-02f,
  8.86713341e-02f, -1.53589606e+00f, -4.72871393e-01f, 7.19880223e-01f, -4.56038296e-01f, 1.56036615e+00f, 7.90016055e-01f, -8.26288044e-01f, 7.16264904e-01f, -6.63546994e-02f,
  1.23569965e+00f, -1.07872985e-01f, 1.62181151e+00f, -7.88697183e-01f, 4.69032049e-01f, -1.39168823e+00f, 5.23847938e-01f, -3.65239292e-01f, -1.20298016e+00f, -1.51476502e+00f,
  1.21748066e+00f, -8.85520995e-01f, -4.13694203e-01f, 6.04580268e-02f, -2.03464434e-01f, -1.58419681e+00f, -1.07663773e-01f, 5.74978888e-01f, 9.96590376e-01f, 8.99074912e-01f,
  -1.79781187e+00f, 7.42921084e-02f, -9.58871603e-01f, 2.04142481e-01f, -9.31590497e-01f, 6.65587008e-01f, 1.44785434e-01f, -4.82797444e-01f, 7.40238845e-01f, 4.92236674e-01f,
  -1.33426988e+00f, 4.28165317e-01f, 8.52926612e-01f, -8.92572224e-01f, -4.91173826e-02f, -6.35690570e-01f, -6.98355198e-01f, -1.39371240e+00f, -2.20051274e-01f, -9.21886444e-01f,
  7.84848511e-01f, 6.11296967e-02f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  9.52940285e-01f, -2.36810014e-01f, -9.83932972e-01f, -4.44096774e-01f, 1.13153388e-03f, -3.05563342e-02f, -2.66822964e-01f, 4.12311684e-03f, -2.51438856e-01f, 1.80832788e-01f,
  -8.87614906e-01f, 1.94981456e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 4
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 6, 4
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        16, 6, 4
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        16, 12
    );
    }
    