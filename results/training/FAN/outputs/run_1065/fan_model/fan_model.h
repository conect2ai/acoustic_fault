/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 25 x 120)
const int L0_fan_Wp_rows = 25;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -8.20688009e-01f, 1.49056464e-01f, 2.97329545e-01f, -1.59014165e-01f, 2.84814119e-01f, 3.40331674e-01f, 3.79936725e-01f, -1.02188133e-01f, -8.29461962e-02f, 2.07475469e-01f,
  2.56585836e-01f, -1.06321638e-02f, -6.84984773e-02f, 1.09566204e-01f, 2.69083697e-02f, 2.58713067e-01f, 1.32025331e-01f, -6.23929761e-02f, -6.91607445e-02f, -1.36316251e-02f,
  5.41345403e-03f, -8.77582580e-02f, -2.85950124e-01f, -1.10576734e-01f, -3.58468816e-02f, -2.67701782e-02f, 2.10104108e-01f, 5.87543547e-02f, 2.74310380e-01f, 1.86239253e-03f,
  1.40246570e-01f, -9.06829685e-02f, 7.72377104e-02f, 6.58493862e-02f, 1.11707836e-01f, -4.93900850e-02f, 6.38076812e-02f, -3.03329080e-02f, 5.43996096e-02f, -4.19908687e-02f,
  8.81954953e-02f, 2.96654683e-02f, 1.10793166e-01f, 8.07655454e-02f, -3.90120521e-02f, 1.52085153e-02f, -6.61822781e-02f, -1.25821561e-01f, 7.65521973e-02f, -5.06122187e-02f,
  2.19112203e-01f, 2.27131754e-01f, 8.12544897e-02f, 1.03126697e-01f, -5.12576848e-02f, 1.83922514e-01f, 2.67473180e-02f, 1.44674880e-02f, 9.11824107e-02f, -1.98873594e-01f,
  -9.30954590e-02f, -8.57515484e-02f, 2.69708503e-02f, -8.05627778e-02f, -2.13756757e-05f, -2.03230437e-02f, 1.14062363e-02f, 9.19660553e-02f, 5.18485941e-02f, -9.82355326e-02f,
  1.34911351e-02f, 1.68474950e-02f, -2.25165449e-02f, -1.17109336e-01f, 2.36220956e-02f, 1.21519053e-02f, 6.08249344e-02f, 2.81063374e-02f, 7.44859353e-02f, 7.40058795e-02f,
  2.74160020e-02f, 4.08122055e-02f, -9.83696282e-02f, -1.28717022e-02f, 8.23213980e-02f, 4.75786105e-02f, 1.04665477e-02f, 5.87408952e-02f, 1.47132166e-02f, -7.16488585e-02f,
  -1.69371903e-01f, 3.27391148e-01f, -7.85626471e-02f, -2.48017982e-02f, 8.49021450e-02f, 2.42739078e-02f, -3.69819477e-02f, 4.52289023e-02f, 4.53121588e-03f, 2.61286087e-02f,
  9.95235443e-02f, -1.28856212e-01f, -7.30500615e-04f, 6.58750534e-02f, 6.46407455e-02f, 3.20101716e-02f, 7.38152042e-02f, 6.71885535e-02f, 1.40011013e-01f, 5.31614311e-02f,
  1.10746669e-02f, -3.04223020e-02f, -1.24511510e-01f, -1.21483758e-01f, -2.12321524e-02f, -5.74751198e-02f, -2.23278832e-02f, -8.58769566e-02f, 4.72991876e-02f, -2.16917813e-01f,
  -6.16221786e-01f, 1.63735747e-01f, -2.54116505e-01f, 2.81789806e-02f, 2.72889853e-01f, 7.46797100e-02f, 1.07558994e-02f, -5.72090037e-02f, 1.52330205e-01f, 5.80089837e-02f,
  2.35828325e-01f, 2.68956542e-01f, 1.76243484e-01f, 7.32452571e-02f, -7.06600547e-02f, 5.49637340e-02f, -1.17639592e-02f, -3.23992312e-01f, -2.85537243e-01f, -8.74650776e-02f,
  1.34590507e-01f, -1.59812883e-01f, -2.40987256e-01f, -2.24994272e-02f, 1.94972202e-01f, 1.12030298e-01f, 2.10711986e-01f, 1.15233503e-01f, 1.80975363e-01f, 2.79355943e-01f,
  -4.63206507e-02f, -1.34560078e-01f, -3.03294454e-02f, 1.71739012e-01f, 9.72995535e-02f, 5.35348952e-02f, 2.24440731e-02f, 8.50070342e-02f, 6.89277351e-02f, 9.37981531e-02f,
  1.20025925e-01f, 6.78528398e-02f, 1.17882118e-01f, 7.12598264e-02f, -2.33665556e-02f, 6.30050451e-02f, -3.14862207e-02f, 5.99498721e-03f, -5.21706752e-02f, 7.14647770e-02f,
  1.96485102e-01f, 3.18277031e-02f, -7.78568983e-02f, 1.74783599e-02f, 9.63761285e-02f, -8.86524282e-03f, 1.08369291e-01f, 8.92263129e-02f, 9.06538665e-02f, 9.96146351e-02f,
  1.17670894e-01f, -7.74454027e-02f, -9.22309533e-02f, -9.94125381e-02f, -1.01710796e-01f, 7.62094883e-03f, -2.49190368e-02f, -4.60522473e-02f, -2.28343289e-02f, -9.99193788e-02f,
  -3.54709588e-02f, -7.42641985e-02f, -7.56366998e-02f, -5.50273582e-02f, 1.76947413e-03f, -9.23943818e-02f, -2.13494841e-02f, -9.00040194e-02f, -5.91984503e-02f, -9.67245847e-02f,
  -5.87121723e-03f, -2.64038816e-02f, 1.79795809e-02f, -5.74781857e-02f, -5.33077978e-02f, -3.21774073e-02f, -1.06151709e-02f, 1.23659931e-02f, -6.46143556e-02f, -3.31378542e-02f,
  1.46248460e-01f, -1.07815869e-01f, 3.56850326e-02f, 2.23974865e-02f, 1.10632196e-01f, 3.85951959e-02f, 1.44956648e-01f, 9.18774959e-03f, 1.08548626e-01f, -4.44228156e-03f,
  3.34047601e-02f, 9.34868935e-04f, 7.92384967e-02f, 1.43816814e-01f, 4.67399089e-03f, 3.47954407e-02f, 3.79955322e-02f, 1.59909367e-03f, 8.68985057e-02f, 8.66390243e-02f,
  2.19674602e-01f, -6.86486065e-02f, -7.81268477e-02f, 8.44895467e-02f, 6.34738505e-02f, -7.45905563e-03f, 4.72018532e-02f, 3.79568115e-02f, -1.26021877e-01f, -1.55368671e-01f,
  3.48044604e-01f, 3.03524345e-01f, 3.22531730e-01f, 3.12678218e-01f, -2.79044993e-02f, -9.08272937e-02f, -1.00519851e-01f, -7.02217370e-02f, -1.31411225e-01f, 1.71509191e-01f,
  1.17929697e-01f, 8.11617263e-03f, -1.07143171e-01f, -2.36582950e-01f, -1.91672459e-01f, 1.14461947e-02f, -2.43666898e-02f, 2.72157919e-02f, -1.01177499e-01f, -3.80086713e-02f,
  -9.55410823e-02f, 2.58050978e-01f, 1.70534089e-01f, 1.05666369e-01f, 2.24374264e-01f, 1.48466855e-01f, 2.00927719e-01f, 2.96061486e-01f, 2.06596553e-02f, 2.60081291e-01f,
  3.43550771e-01f, 2.84913450e-01f, -2.07848772e-01f, -8.12111869e-02f, 1.70285534e-02f, -2.55716983e-02f, -6.64205011e-03f, -4.04010341e-02f, -3.13690677e-02f, -1.24531630e-02f,
  5.09193614e-02f, -1.75054744e-02f, 3.50626260e-02f, -5.40429428e-02f, 7.08678924e-03f, -7.73857608e-02f, -8.68479386e-02f, -6.72941580e-02f, -4.26923260e-02f, -3.42154875e-04f,
  -2.27962807e-02f, 9.25586671e-02f, 4.29412462e-02f, -1.61954880e-01f, -1.16061360e-01f, -2.09161445e-01f, -2.03640778e-02f, -1.95253305e-02f, -7.32533708e-02f, 7.10269660e-02f,
  -1.38104320e-01f, 4.51713949e-02f, 5.12972474e-02f, 7.98057094e-02f, 4.65183258e-02f, 5.44379912e-02f, 1.62184760e-01f, 6.90425709e-02f, 8.31250250e-02f, 5.87712340e-02f,
  4.79099005e-02f, 9.93938819e-02f, 3.35974023e-02f, 1.21942922e-01f, 7.76027143e-02f, 1.54744387e-01f, 2.42402684e-02f, 6.23754561e-02f, 4.61120307e-02f, 1.17926672e-01f,
  1.65872321e-01f, 7.00450540e-02f, 9.79739130e-02f, 6.86657503e-02f, 7.30232522e-02f, 9.05312896e-02f, 3.37430537e-02f, 4.90981117e-02f, 1.46981299e-01f, 1.43511757e-01f,
  7.24701658e-02f, -3.07630956e-01f, 3.86282168e-02f, -6.62440667e-03f, 2.65941285e-02f, -4.40054461e-02f, 2.77618747e-02f, 5.57561293e-02f, 4.61257286e-02f, -5.30979522e-02f,
  -6.16818294e-02f, 1.58086531e-02f, 4.19248128e-03f, -8.67062993e-03f, 1.46490224e-02f, -5.68812862e-02f, 3.64297405e-02f, 3.83984298e-02f, -1.32275477e-01f, 8.51097628e-02f,
  -6.59039542e-02f, -6.52457625e-02f, 7.13111088e-02f, -7.54785091e-02f, -7.41905719e-02f, -1.21621050e-01f, 7.02186627e-03f, -3.26159410e-02f, -1.31461576e-01f, 1.24359047e-02f,
  4.65600044e-01f, 8.83219540e-02f, 1.34800121e-01f, -2.19936706e-02f, -4.00206037e-02f, 2.02577397e-01f, 2.03574926e-01f, -1.55846972e-03f, 8.61231536e-02f, -1.28384037e-02f,
  9.34182256e-02f, 7.67556876e-02f, -2.62692047e-04f, 1.65208466e-02f, 6.07765000e-03f, 8.58264416e-02f, -4.47941534e-02f, 6.13114126e-02f, 1.43227667e-01f, -1.81922801e-02f,
  -1.46500617e-01f, -3.44935851e-03f, 9.32105556e-02f, -4.84163910e-02f, -2.51104593e-01f, -4.56272289e-02f, 8.14855937e-03f, -1.36236638e-01f, -5.24312072e-02f, -1.68197200e-01f,
  2.35033929e-01f, 1.26758413e-02f, 6.73889294e-02f, -6.38921931e-02f, -9.68401041e-03f, -6.84300438e-02f, 8.87539908e-02f, 3.88913080e-02f, -8.33151489e-02f, -3.90727706e-02f,
  -5.38370050e-02f, 7.44966492e-02f, -9.28022787e-02f, -8.62824246e-02f, -5.58202807e-03f, -2.29084101e-02f, 4.00999300e-02f, -1.76593568e-02f, -3.60978991e-02f, 4.23027873e-02f,
  -1.64879292e-01f, 1.31532531e-02f, 9.78716239e-02f, 6.89787939e-02f, 5.93837490e-03f, 1.34882629e-01f, 9.98966694e-02f, 1.96176507e-02f, 1.39965907e-01f, -7.19940364e-02f,
  -8.27951804e-02f, 6.10237159e-02f, -5.56857139e-03f, -4.66076285e-02f, -2.69409199e-03f, -6.42407835e-02f, -7.16092065e-02f, -5.96695468e-02f, -8.03541839e-02f, -3.52963619e-02f,
  -1.40414238e-01f, 6.90593431e-03f, -7.59924874e-02f, -3.26391272e-02f, -5.73557802e-02f, -3.31611112e-02f, -8.04226324e-02f, -1.19436793e-01f, -1.11432590e-01f, -5.19467890e-02f,
  -8.23057294e-02f, -7.09325867e-03f, -7.06843659e-02f, -1.61654443e-01f, 3.89445387e-02f, -6.61447039e-03f, 3.03889774e-02f, -3.30674313e-02f, 2.92432513e-02f, 5.13589606e-02f,
  7.19128735e-03f, 1.21174254e-01f, 2.08129995e-02f, 8.54992867e-02f, -2.03481130e-02f, 2.85350829e-02f, 6.38943389e-02f, -6.26987666e-02f, 4.85428758e-02f, -7.60982977e-03f,
  7.75225237e-02f, 1.13130875e-01f, 7.10427910e-02f, 3.34640872e-03f, 8.11310783e-02f, 6.59850463e-02f, 3.92054059e-02f, 1.01578027e-01f, 1.79427173e-02f, -2.91376784e-02f,
  6.74244389e-02f, 1.07829548e-01f, 2.88616896e-01f, 8.62378702e-02f, 7.75453374e-02f, 2.62385607e-01f, 1.17460154e-01f, 6.52805865e-02f, 2.63923049e-01f, 8.51316825e-02f,
  2.62325466e-01f, 4.12088856e-02f, 1.00516319e-01f, 2.04499915e-01f, 6.75751567e-02f, 1.02655537e-01f, 3.41325432e-01f, 1.97415769e-01f, 9.76148322e-02f, 1.35534108e-01f,
  -9.75823477e-02f, -2.34445110e-01f, -2.23118663e-01f, -2.05308184e-01f, 6.03792779e-02f, 3.02351475e-01f, 3.53695184e-01f, 3.18474352e-01f, 1.27466589e-01f, 2.21810654e-01f,
  1.79705113e-01f, 2.45786101e-01f, 2.76931494e-01f, 1.34095073e-01f, 1.76148906e-01f, -3.22788651e-03f, 1.03087738e-01f, 2.79335469e-01f, 1.31217286e-01f, 2.30181411e-01f,
  -1.09527640e-01f, 1.16149738e-01f, -4.93434966e-02f, -8.32057744e-02f, 5.65336235e-02f, 1.38301492e-01f, 6.05288111e-02f, 9.39937085e-02f, 9.26470309e-02f, 1.30722627e-01f,
  6.11731689e-03f, -3.18388641e-02f, -3.29950117e-02f, 9.60175470e-02f, 7.66423494e-02f, 6.27842695e-02f, 1.16575472e-01f, 2.38191381e-01f, 1.03379592e-01f, 9.64417085e-02f,
  1.21075818e-02f, 1.36279881e-01f, 2.94703513e-01f, 1.72519043e-01f, 1.77668884e-01f, 9.65514034e-02f, 1.95962131e-01f, 2.23090470e-01f, 1.41352311e-01f, 3.12039435e-01f,
  -6.49470612e-02f, 4.73786369e-02f, -7.58077204e-03f, 5.39300144e-02f, -9.04459879e-02f, -1.23496791e-02f, -3.66361029e-02f, 1.42576732e-02f, 3.95370945e-02f, 9.89864692e-02f,
  -5.45261912e-02f, -1.25514865e-02f, 1.05583854e-01f, 1.28367662e-01f, 3.83596867e-02f, 1.36671156e-01f, 2.07156949e-02f, -4.89401747e-04f, 6.43326319e-04f, 7.58779701e-03f,
  1.05844326e-01f, 7.68933147e-02f, 8.89826342e-02f, 8.63355100e-02f, 4.93809804e-02f, 6.30153790e-02f, 4.80049551e-02f, -2.97044739e-02f, -4.83998284e-02f, 2.14507245e-02f,
  -1.60711318e-01f, -6.04870915e-02f, 3.30623277e-02f, 1.02801993e-01f, 1.20933838e-01f, 7.49398172e-02f, 8.07057023e-02f, 9.70492661e-02f, 3.68793756e-02f, 1.83853433e-02f,
  -7.92273693e-03f, 8.44820142e-02f, 6.10440820e-02f, 5.60481399e-02f, 1.28984958e-01f, 7.25431591e-02f, 1.90356344e-01f, 1.08770899e-01f, 7.70119950e-02f, 1.30571872e-01f,
  5.29013164e-02f, 3.09035778e-01f, 6.09414540e-02f, 2.80543212e-02f, 1.81980595e-01f, -4.09133583e-02f, 1.01038352e-01f, 7.04892278e-02f, 2.14697141e-02f, 1.14126451e-01f,
  -3.72239470e-01f, -4.22161305e-03f, 5.10559857e-01f, -4.27282929e-01f, -1.95643559e-01f, 2.09804356e-01f, 2.72753239e-01f, 1.95666432e-01f, -1.97632328e-01f, -1.35578200e-01f,
  -1.59534335e-01f, -2.38624960e-01f, -8.45740214e-02f, 9.86644924e-02f, 2.55235434e-01f, 3.20857763e-01f, 3.60841841e-01f, 3.06124419e-01f, 2.35240132e-01f, 5.48774190e-02f,
  -1.75891846e-01f, -2.16427758e-01f, 1.49558252e-02f, 9.46877152e-02f, -7.27028102e-02f, -2.26801466e-02f, 1.37048841e-01f, -4.78648990e-02f, 1.91316411e-01f, 1.09983541e-01f,
  -7.49062076e-02f, 1.16147548e-01f, 7.97099173e-02f, -1.42078608e-01f, -7.05810636e-02f, -3.12179066e-02f, -1.44685162e-02f, 3.69045069e-04f, -6.89272285e-02f, -4.39681821e-02f,
  -5.60495682e-05f, -4.11225483e-02f, 9.29441117e-03f, 4.25495394e-02f, 2.58351006e-02f, -3.71184312e-02f, 9.68313590e-02f, 1.99605092e-01f, 7.68926218e-02f, 1.43752143e-01f,
  9.66421980e-03f, -6.68083727e-02f, 2.52680108e-02f, 1.93785518e-01f, 2.28516847e-01f, 2.19389535e-02f, 1.42735913e-01f, 1.29011676e-01f, 2.42924154e-01f, -3.01284492e-02f,
  -6.76513985e-02f, -3.62443998e-02f, -8.08253232e-03f, 3.36610749e-02f, -8.18235800e-02f, -4.81139310e-02f, -4.68358472e-02f, -7.69411027e-02f, 2.07498553e-03f, -9.55834985e-02f,
  8.41206759e-02f, -1.94111448e-02f, 6.97244108e-02f, -8.63708928e-02f, -6.24474548e-02f, -2.60332376e-02f, 3.59126329e-02f, -5.95415980e-02f, -8.46474022e-02f, 1.07834423e-02f,
  -6.19689114e-02f, -1.12454658e-02f, -1.12734616e-01f, 1.07997872e-01f, 5.92272542e-02f, -3.27051729e-02f, -1.64316352e-02f, -8.03924575e-02f, -1.13567337e-01f, -6.81649297e-02f,
  -2.51694828e-01f, 2.69500077e-01f, -7.58827627e-02f, 5.46340458e-02f, -1.07646316e-01f, -9.34732426e-03f, -9.62253958e-02f, -1.42586734e-02f, -2.53771693e-02f, 1.65406000e-02f,
  1.07258102e-02f, 3.09682749e-02f, 4.73732464e-02f, 4.17452008e-02f, -2.40648389e-02f, -6.38954192e-02f, -5.44986911e-02f, -1.71918981e-02f, 1.03268571e-01f, -7.20692873e-02f,
  -3.98858264e-03f, -6.19153343e-02f, -7.40430579e-02f, -5.36481664e-02f, -3.72918956e-02f, -5.40020242e-02f, -3.04323312e-05f, -2.38218345e-02f, -4.65562120e-02f, -1.91256449e-01f,
  4.21069294e-01f, 2.39343464e-01f, -4.54007871e-02f, 2.50524189e-02f, -1.23299882e-01f, -2.16484904e-01f, -1.45515099e-01f, -1.53689131e-01f, -3.36677139e-03f, 1.79792404e-01f,
  2.40559220e-01f, 1.18636742e-01f, 2.58952957e-02f, -1.57323945e-02f, -2.37263694e-01f, -1.87294006e-01f, -3.64169180e-01f, -2.30376184e-01f, -2.82614350e-01f, -1.96621448e-01f,
  -2.00760067e-01f, 1.18245132e-01f, -5.11525683e-02f, -5.87546639e-02f, 1.12460896e-01f, 3.65512036e-02f, 1.16313070e-01f, 3.45715657e-02f, -1.28402054e-01f, -9.32432860e-02f,
  1.78768873e-01f, 1.71678558e-01f, -1.63956732e-01f, -1.43315464e-01f, -7.75630847e-02f, 2.03324854e-02f, -3.93692292e-02f, -4.45308909e-02f, -2.13505439e-02f, 5.57142198e-02f,
  1.36919143e-02f, 2.76507828e-02f, -6.89290762e-02f, -8.31929222e-02f, 6.41024634e-02f, -1.19234370e-02f, -4.60032970e-02f, -6.55119047e-02f, -6.63810745e-02f, 6.89369142e-02f,
  -4.79748584e-02f, -3.31844129e-02f, 1.60733953e-01f, -7.73476511e-02f, -6.94491342e-02f, -4.62109372e-02f, -1.43676309e-03f, 6.21578842e-02f, -9.43526104e-02f, 4.43298779e-02f,
  -6.35876553e-03f, 6.69361576e-02f, -8.80042315e-02f, 7.50153065e-02f, 6.63759038e-02f, -3.19399014e-02f, 3.55588226e-03f, 2.20521455e-04f, -2.68119574e-02f, 5.07951118e-02f,
  2.97635160e-02f, -3.15502882e-02f, -4.54329140e-02f, 2.11417954e-02f, -7.62540754e-03f, 9.10545513e-02f, 5.41032143e-02f, 6.07274398e-02f, 2.55408101e-02f, 2.98498906e-02f,
  6.11648597e-02f, 1.08356163e-01f, 1.05685025e-01f, -3.21096070e-02f, -2.86988113e-02f, 3.76632921e-02f, 8.86913985e-02f, 1.63490385e-01f, 4.87269349e-02f, 8.28179866e-02f,
  2.90394127e-01f, -3.26868325e-01f, 1.01493537e-01f, -1.87170953e-02f, 9.88595933e-03f, -5.39732650e-02f, 5.01295589e-02f, -1.57288328e-01f, 2.48877779e-02f, -1.96319167e-02f,
  -4.80612069e-02f, -8.62642676e-02f, 3.38926096e-03f, -1.28753647e-01f, -1.49893284e-01f, -1.24544173e-01f, -2.79048234e-02f, -2.61972658e-02f, -1.46116629e-01f, -2.31730528e-02f,
  -7.89063647e-02f, -6.23679906e-02f, 1.15226485e-01f, -1.07806027e-01f, -1.28985504e-02f, -3.79890837e-02f, 7.63029605e-02f, -8.44163261e-03f, -7.87325874e-02f, 8.33183452e-02f,
  -4.37300771e-01f, 2.26943225e-01f, 5.24285436e-01f, 1.30742695e-02f, 4.40266766e-02f, 7.17306286e-02f, 1.06202215e-01f, -9.58110616e-02f, 1.90090947e-02f, 7.04605281e-02f,
  8.83401409e-02f, -1.71264037e-01f, -4.06213887e-02f, -1.16123566e-02f, -1.21943288e-01f, 1.89058855e-01f, 3.11601043e-01f, 7.71852136e-02f, -1.74482211e-01f, -2.54138470e-01f,
  -2.62222797e-01f, -2.60798842e-01f, -1.60825342e-01f, -2.35450510e-02f, 1.18153162e-01f, -3.07886507e-02f, 2.85265654e-01f, 8.75492096e-02f, 1.29720628e-01f, 1.99293599e-01f,
  2.01567575e-01f, 2.10786790e-01f, -9.58413705e-02f, -1.07466042e-01f, 8.07895884e-02f, -8.23119283e-02f, 7.06191640e-03f, -2.62512974e-02f, 3.85423489e-02f, 5.80199808e-02f,
  1.70597862e-02f, -7.63767362e-02f, 1.20911803e-02f, 1.48283388e-03f, 1.27983345e-02f, -1.88396182e-02f, -3.15861255e-02f, 7.28144720e-02f, 3.83889116e-02f, 7.59859085e-02f,
  -4.36987281e-02f, 1.28457114e-01f, 1.35519966e-01f, 2.49603968e-02f, 1.45096689e-01f, -7.65933329e-03f, -6.60199905e-03f, 4.37828107e-03f, -2.80117318e-02f, -3.07278447e-02f,
  -2.01283976e-01f, 6.78349435e-02f, 8.07937458e-02f, 2.44963691e-02f, -1.16269197e-02f, 1.10602625e-01f, 1.07448824e-01f, 2.40196120e-02f, -2.20865346e-02f, -7.19365245e-03f,
  7.27351829e-02f, 9.61542130e-02f, 4.21623588e-02f, 1.64710414e-02f, 1.13341413e-01f, 1.15805626e-01f, 3.35247852e-02f, 2.54673678e-02f, 6.39918521e-02f, 8.46891999e-02f,
  1.17772780e-02f, 7.48674944e-02f, 6.63295090e-02f, -2.27805488e-02f, 1.07469149e-01f, 1.17412381e-01f, 6.09358139e-02f, 1.32416403e-02f, 4.46696915e-02f, 6.27494827e-02f,
  -3.15951198e-01f, -2.65595485e-02f, -7.83210620e-02f, -9.60783213e-02f, 3.54111455e-02f, 3.92252393e-02f, 2.51247287e-02f, 3.99384648e-02f, -3.25546190e-02f, -1.43115297e-01f,
  -1.65935920e-03f, -9.72756594e-02f, -8.55236687e-03f, 1.61987636e-03f, -1.51040062e-01f, -5.96592873e-02f, -6.88504428e-02f, -8.66346881e-02f, 2.56347973e-02f, -6.78106025e-02f,
  -3.44590619e-02f, -1.45139590e-01f, -2.72456318e-01f, -1.36198431e-01f, -1.45356700e-01f, -1.35637075e-01f, -9.51162651e-02f, -9.20686871e-02f, -1.56578153e-01f, -3.74869645e-01f,
  -4.15263921e-01f, -2.63376623e-01f, 3.60852480e-01f, 4.21690829e-02f, 5.68481945e-02f, 8.51161629e-02f, -1.60013020e-01f, -3.16581219e-01f, -1.46440461e-01f, -1.34890154e-01f,
  -1.63874224e-01f, -1.69860303e-01f, -2.56162882e-02f, -1.62119363e-02f, -5.86085804e-02f, 1.24114618e-01f, 2.43947536e-01f, 3.42252642e-01f, 1.95908979e-01f, -1.54494986e-01f,
  -7.10749328e-02f, 2.70055588e-02f, -2.42023729e-02f, -4.81386855e-02f, -5.01446873e-02f, 1.06642293e-02f, -1.52586512e-02f, 2.66046692e-02f, -9.29120854e-02f, 2.21669942e-01f,
  1.36668026e-01f, -3.93960834e-01f, 1.56739578e-02f, -8.03701431e-02f, -6.33513033e-02f, -4.89600711e-02f, -1.40233440e-02f, -4.13635522e-02f, -2.09030390e-01f, -4.34659347e-02f,
  -1.18427955e-01f, -3.55309173e-02f, 2.74944436e-02f, -8.19165632e-02f, -1.25375226e-01f, -7.62616247e-02f, -5.97202852e-02f, -7.31186420e-02f, -8.90116766e-02f, -1.82469130e-01f,
  -5.06916419e-02f, -2.95866542e-02f, 2.25297790e-02f, -1.35364935e-01f, -4.29195985e-02f, 9.87250134e-02f, -1.68675378e-01f, -1.48018807e-01f, -1.16845697e-01f, -1.06903128e-01f,
  -3.39285918e-02f, 3.81644145e-02f, 3.89764011e-02f, 2.00429074e-02f, 4.25358899e-02f, 2.78656073e-02f, 1.02034032e-01f, 1.40977785e-01f, 1.05464971e-03f, 1.20261930e-01f,
  3.19279693e-02f, 4.13891263e-02f, 2.85824388e-02f, -1.89558081e-02f, 6.33702353e-02f, 1.20830379e-01f, 7.68519416e-02f, -1.24923363e-02f, 7.14886636e-02f, 6.95188120e-02f,
  2.89484970e-02f, 1.37918144e-01f, 7.01960549e-02f, 1.00808457e-01f, 1.11149214e-01f, 1.02665536e-01f, 2.28322726e-02f, -2.51267455e-04f, 8.70394409e-02f, 7.52384588e-02f,
  -1.90861896e-01f, 7.20210224e-02f, -4.50261496e-02f, -8.55562463e-02f, 5.31388074e-03f, -9.12222043e-02f, -2.02062875e-02f, -9.22548771e-02f, 2.43641958e-02f, -8.65355656e-02f,
  -1.34029895e-01f, -2.24131588e-02f, -5.94973974e-02f, 2.90981564e-03f, -3.61300707e-02f, -1.18759230e-01f, -2.84787323e-02f, 6.38955906e-02f, -2.84720082e-02f, -1.30739138e-01f,
  -7.88118877e-03f, 8.97500217e-02f, -5.18974196e-03f, 2.48179678e-02f, -5.35720959e-02f, 8.31133872e-02f, 1.56156301e-01f, 1.10277189e-02f, 9.13202167e-02f, -6.36900514e-02f,
  6.64551854e-01f, 1.93492472e-01f, 3.64680469e-01f, 3.98904085e-01f, 9.78478715e-02f, -2.69680291e-01f, -3.05746049e-01f, -2.21540675e-01f, 6.34506047e-02f, 2.00877249e-01f,
  3.28866392e-02f, -6.55306727e-02f, 1.12313822e-01f, -1.23688042e-01f, -1.21077575e-01f, 2.17728794e-01f, 2.45675445e-01f, 2.85754919e-01f, -2.70686537e-01f, -3.93405855e-01f,
  -9.36729759e-02f, 1.79250881e-01f, 1.28132999e-01f, 4.93453234e-04f, 1.07603773e-01f, -4.20917310e-02f, 2.72624135e-01f, 2.19743684e-01f, 2.83894571e-03f, 4.20320123e-01f,
  2.05058038e-01f, 1.98227614e-01f, -6.05777018e-02f, 4.88686264e-02f, 7.48547837e-02f, -1.72416586e-02f, 2.03486253e-03f, 9.36639234e-02f, 8.09917673e-02f, 2.00750995e-02f,
  6.77873492e-02f, -1.54636055e-02f, -5.65398019e-03f, -2.16783304e-02f, -5.99279217e-02f, -7.80324712e-02f, 9.95330215e-02f, 1.25680000e-01f, 1.05000850e-04f, -5.57115637e-02f,
  5.46026900e-02f, 2.72105075e-02f, 4.15463857e-02f, -1.22861177e-01f, -9.48388316e-03f, 6.19600341e-02f, -1.06115207e-01f, -1.25911310e-02f, -8.61043260e-02f, -8.95322394e-03f,
  1.06987469e-02f, -6.91004992e-02f, -1.06142178e-01f, -1.09314911e-01f, -5.56633137e-02f, -2.56664790e-02f, -1.82712432e-02f, -9.31400210e-02f, -8.40875506e-02f, -5.20506725e-02f,
  -2.37458032e-02f, -4.33275737e-02f, -1.10882133e-01f, -3.84817384e-02f, -4.87103276e-02f, 4.68218923e-02f, -8.62445086e-02f, -1.14068221e-02f, -4.29347456e-02f, -1.12617224e-01f,
  -3.58488411e-02f, 1.48348212e-02f, -4.43226993e-02f, -1.39009953e-01f, -7.83748031e-02f, 6.22995794e-02f, -3.04815583e-02f, -1.56627491e-01f, 1.99596044e-02f, 7.43610435e-04f,
  -9.82833132e-02f, -6.95682317e-02f, 6.85874447e-02f, -7.15214312e-02f, 1.02657042e-01f, 6.06690161e-02f, 7.48446658e-02f, -9.53887962e-03f, 2.81426571e-02f, 4.52321023e-03f,
  -9.40254554e-02f, 2.11499762e-02f, 9.81385186e-02f, 5.69706373e-02f, -1.12542801e-01f, -1.09339543e-02f, 2.56176619e-03f, 7.73651227e-02f, -1.16799772e-01f, 8.53144913e-04f,
  8.38108584e-02f, -6.69548139e-02f, -8.39883089e-03f, 3.41741554e-02f, -1.50908560e-01f, 6.58287182e-02f, -3.57185081e-02f, -7.66306743e-02f, -8.62590745e-02f, 2.39480995e-02f,
  1.18860498e-01f, -2.42140740e-01f, -2.26371169e-01f, -1.13450505e-01f, -3.97660643e-01f, -3.15513551e-01f, -4.00929630e-01f, 1.92995697e-01f, 1.39809519e-01f, -2.48962730e-01f,
  -4.20571715e-01f, -2.97354758e-01f, -1.05964459e-01f, -2.02357564e-02f, 5.26876822e-02f, -5.45130149e-02f, -8.20816234e-02f, 2.47084163e-02f, 9.73938331e-02f, -1.47192150e-01f,
  -2.57097363e-01f, -1.14484340e-01f, 1.19068637e-01f, 1.17206089e-01f, -4.43962440e-02f, -1.73177317e-01f, -4.07128856e-02f, -4.15638946e-02f, -1.64143890e-01f, -1.89888492e-01f,
  -4.18925047e-01f, 1.49307838e-02f, -1.55381143e-01f, -1.27949178e-01f, -2.69551158e-01f, -2.95213107e-02f, -8.90060142e-02f, -9.99413654e-02f, -1.35198340e-01f, -5.47091179e-02f,
  -1.94716528e-01f, -1.17318630e-01f, -1.51907757e-01f, -1.38623983e-01f, -1.62481412e-01f, -1.82812363e-02f, 7.07351118e-02f, 1.09451763e-01f, -9.74687859e-02f, -1.18698157e-01f,
  -2.12515309e-01f, -2.21690983e-01f, -2.42586315e-01f, 1.67252794e-02f, 1.40673980e-01f, -1.35403767e-01f, -1.30795181e-01f, 4.08846475e-02f, 2.83359569e-02f, 7.12485313e-02f,
  -2.24350020e-02f, 1.10479742e-01f, 1.22222938e-01f, 1.55570894e-01f, 4.88054268e-02f, 2.61503849e-02f, 1.30276293e-01f, 5.49062230e-02f, 1.14137620e-01f, 7.81573355e-02f,
  1.11362733e-01f, 7.96170607e-02f, 1.36397317e-01f, 1.70022309e-01f, 6.37288392e-02f, 1.29446059e-01f, 6.01356663e-02f, 8.11794698e-02f, 8.05201605e-02f, 4.77482826e-02f,
  1.42969340e-01f, 1.48965985e-01f, 4.89084423e-02f, 1.89543635e-01f, 1.14556931e-01f, 1.70086816e-01f, 1.01572759e-01f, 1.69615358e-01f, 1.52511567e-01f, 5.94014525e-02f,
  -1.70763150e-01f, -3.25595915e-01f, -1.26869544e-01f, 3.43439281e-02f, -1.48458362e-01f, -9.21188667e-02f, -2.09363073e-01f, -6.06632903e-02f, -1.87080353e-01f, -1.28367990e-01f,
  -9.71733183e-02f, 2.98517067e-02f, -2.46530592e-01f, -5.73915131e-02f, -1.49916321e-01f, -1.61535352e-01f, -1.82610303e-01f, -2.72244364e-01f, -5.79406656e-02f, -8.87455046e-02f,
  -1.21685438e-01f, -1.68580607e-01f, -1.71378493e-01f, -1.76335394e-01f, -9.21563208e-02f, -9.37002972e-02f, -1.15170218e-01f, -8.60166922e-02f, -1.26129121e-01f, -1.42287746e-01f,
  6.56604841e-02f, -1.21245287e-01f, -4.26006109e-01f, 2.16344371e-01f, 2.11536795e-01f, 7.10317343e-02f, 3.26257572e-02f, 9.19813514e-02f, 1.35080308e-01f, -7.15054870e-02f,
  -9.17289108e-02f, -4.41081449e-02f, -1.98544532e-01f, -9.90005061e-02f, -1.39751717e-01f, -2.05212519e-01f, -1.21319719e-01f, 3.71976197e-03f, 1.24675140e-01f, 2.39167139e-01f,
  2.82707185e-01f, 2.90815771e-01f, 1.53283581e-01f, 3.14503200e-02f, 1.39729083e-01f, 1.22394199e-02f, -7.73583502e-02f, 1.14179179e-01f, -1.24291614e-01f, -8.35513789e-03f,
  -4.89303619e-01f, -2.33158879e-02f, 1.02745079e-01f, 2.88257264e-02f, 6.74920380e-02f, 1.02120399e-01f, 5.33333831e-02f, -2.57230457e-03f, -2.19153203e-02f, -6.24047928e-02f,
  -3.03037055e-02f, 1.24442905e-01f, 1.22564785e-01f, 1.22368775e-01f, -6.19400572e-03f, 5.26609011e-02f, 8.65286961e-02f, -1.09211117e-01f, -1.00011835e-02f, -1.33553579e-01f,
  2.53590383e-02f, -4.38691080e-02f, -2.02669296e-02f, -8.49983767e-02f, 7.48798400e-02f, 4.87447456e-02f, 1.53604224e-02f, 1.10585004e-01f, 5.43385670e-02f, -7.93688297e-02f,
  -9.22279879e-02f, -7.78187439e-02f, 1.92026030e-02f, -1.03338687e-02f, -3.37757803e-02f, -9.09818485e-02f, -1.11144513e-01f, -9.09505114e-02f, -2.15322692e-02f, 2.22568866e-02f,
  -4.66831960e-03f, -1.76142484e-01f, 5.79198599e-02f, 2.93991789e-02f, -3.50551084e-02f, -2.86303144e-02f, 6.07441068e-02f, -2.09069978e-02f, -7.00153559e-02f, 8.97840038e-02f,
  -3.03010549e-02f, 8.04116670e-03f, -1.88494381e-02f, 2.76808273e-02f, -3.38901170e-02f, -1.38284508e-02f, 5.38360886e-02f, -3.12277600e-02f, 9.51986462e-02f, -1.63681414e-02f,
  5.65952770e-02f, -7.95812830e-02f, -9.67842564e-02f, 1.19176894e-01f, 4.66107577e-02f, 3.04175038e-02f, 3.96325300e-03f, 2.68650204e-02f, 2.79272534e-02f, -4.32583429e-02f,
  1.19098730e-01f, -1.88389178e-02f, -5.53621463e-02f, 1.52426409e-02f, 1.62870467e-01f, 8.46896544e-02f, 1.23612866e-01f, -4.68913792e-03f, 4.54199538e-02f, -2.40333490e-02f,
  8.05396512e-02f, 9.41618439e-03f, -2.26028729e-02f, -4.60346341e-02f, -3.98522951e-02f, -8.22054595e-02f, -1.06847033e-01f, 4.45013978e-02f, -1.45260483e-01f, 4.74615507e-02f,
  5.93217969e-01f, -1.70831084e-01f, -2.33135670e-01f, 2.60143787e-01f, -2.22575039e-01f, 1.16740810e-02f, 1.69716701e-02f, 9.46245864e-02f, 5.45799583e-02f, 9.59087834e-02f,
  -2.58987397e-01f, -2.94269212e-02f, -1.94870099e-01f, -1.54377267e-01f, 8.65142494e-02f, -2.81640068e-02f, 1.03926271e-01f, 9.07046273e-02f, 8.01346302e-02f, 1.34876117e-01f,
  5.28069846e-02f, 1.21739566e-01f, 2.08541766e-01f, 1.60515726e-01f, -5.25049269e-02f, 7.33697340e-02f, -1.01862825e-01f, -2.35680882e-02f, -1.07442327e-01f, 1.18039198e-01f,
  -1.13080837e-01f, -5.00408933e-02f, 3.93039174e-02f, 4.82952185e-02f, -2.19092712e-01f, 9.97912288e-02f, -5.57964556e-02f, -8.86538625e-02f, -1.10879183e-01f, -1.84343220e-03f,
  -2.68847048e-02f, 2.89123431e-02f, -4.01525907e-02f, 2.33055856e-02f, 4.77754191e-04f, 9.74196419e-02f, 7.67304227e-02f, 5.28074130e-02f, -1.21459598e-03f, 2.70064324e-02f,
  -1.01027712e-01f, 7.04499483e-02f, 9.23859142e-03f, 5.28346896e-02f, 4.10376024e-03f, 1.89147014e-02f, -6.43501058e-02f, 2.62143500e-02f, 3.34757231e-02f, 2.47547045e-01f,
  4.46511842e-02f, -4.69872691e-02f, -9.56455769e-04f, 9.31245312e-02f, -1.70321530e-03f, -2.33666468e-02f, 3.78472134e-02f, -1.93177704e-02f, 8.52441713e-02f, 3.85101251e-02f,
  -8.16123560e-03f, -8.29886571e-02f, -4.42051739e-02f, -1.20569710e-02f, -4.86179106e-02f, 8.42573494e-03f, -4.66893427e-02f, 7.01810643e-02f, -3.91839966e-02f, -6.71717227e-02f,
  -8.26455536e-04f, 5.90832438e-03f, -5.36892191e-02f, -8.89260843e-02f, -8.50322936e-03f, -9.20738000e-03f, 4.90148664e-02f, -3.56647186e-02f, 3.61287668e-02f, -2.27773115e-02f,
  1.24406859e-01f, -2.63141334e-01f, 1.21012673e-01f, 1.34623587e-01f, -2.88054459e-02f, -4.28535929e-03f, -6.81824312e-02f, 5.35296835e-03f, -1.07680120e-01f, 7.76972398e-02f,
  -1.79755557e-02f, 3.63113135e-02f, -7.34557956e-02f, 8.75559151e-02f, 8.69453251e-02f, 9.70990583e-02f, 1.07254304e-01f, 4.82972823e-02f, 2.14004051e-02f, 6.58420399e-02f,
  6.53887093e-02f, 1.63152054e-01f, 2.36183733e-01f, 6.01276569e-02f, 3.18107791e-02f, 1.60836294e-01f, 6.59803823e-02f, 1.16913840e-01f, 1.55276403e-01f, 3.29552710e-01f,
  5.61484575e-01f, 2.26935279e-02f, -3.63969803e-01f, 4.65307117e-01f, -1.84530333e-01f, -6.36852086e-01f, -6.10969543e-01f, -1.74452662e-01f, 9.61001292e-02f, -6.35471120e-02f,
  -1.78423956e-01f, 5.69058694e-02f, 1.00680448e-01f, -3.97393256e-02f, -1.31505772e-01f, -7.77436867e-02f, 8.09566900e-02f, 9.43223387e-02f, -1.63295463e-01f, -2.11957037e-01f,
  2.39633963e-01f, 3.51788610e-01f, 4.41544801e-01f, 9.08540487e-02f, 2.54519939e-01f, 1.67415544e-01f, 2.31571663e-02f, 7.54623935e-02f, -3.68098877e-02f, 4.13924307e-01f,
  -1.43782720e-01f, -6.77861646e-02f, -9.25258324e-02f, 1.37888014e-01f, -7.12513179e-02f, 2.12049168e-02f, -5.39519005e-02f, 4.64614481e-02f, -8.18318650e-02f, -5.51425666e-02f,
  2.92815827e-02f, 5.66699058e-02f, 1.94502771e-02f, -5.32885827e-02f, 4.29907534e-03f, -6.99899793e-02f, 6.97854385e-02f, -7.05545992e-02f, -8.45965520e-02f, -1.14672452e-01f,
  5.14364280e-02f, 3.53184640e-02f, -1.68276608e-01f, -1.99013546e-01f, -1.55952930e-01f, 1.18230302e-02f, -1.45154268e-01f, -1.54834211e-01f, -1.28840551e-01f, -6.16601221e-02f,
  -5.56059256e-02f, -7.68229216e-02f, -5.74174859e-02f, 2.74089985e-02f, 3.51155624e-02f, -1.28832692e-02f, 7.22595006e-02f, 2.72447262e-02f, -9.77899730e-02f, 1.38441501e-02f,
  -1.37486514e-02f, 8.42181221e-02f, 2.98633557e-02f, 8.04859027e-02f, 1.27973452e-01f, 3.08286715e-02f, 4.16909643e-02f, 6.47558048e-02f, 1.22394916e-02f, 5.58695104e-03f,
  4.49607894e-02f, -7.24224597e-02f, 9.54288319e-02f, 6.67873546e-02f, 2.31511686e-02f, 2.31590662e-02f, 5.69804199e-02f, -8.25605169e-03f, 3.05165220e-02f, 8.24060217e-02f,
  1.42015859e-01f, -4.34947349e-02f, 9.60560292e-02f, -4.62468155e-02f, 1.31750721e-02f, -4.83146384e-02f, 1.26914009e-02f, 3.32495309e-02f, 4.56848852e-02f, -2.10155230e-02f,
  -7.38146529e-02f, 3.36844735e-02f, -1.99593324e-02f, -4.58207652e-02f, -4.90572751e-02f, -3.36603969e-02f, 5.51222824e-02f, -5.09752333e-03f, 6.09806366e-03f, -1.05132274e-01f,
  -3.21852416e-02f, -3.33489627e-02f, -1.79111008e-02f, -1.20894231e-01f, -1.13110043e-01f, 3.29312310e-02f, -2.21703853e-03f, -1.17489673e-01f, -1.35281309e-01f, 9.85271484e-02f,
  -1.11462213e-01f, -2.56801695e-01f, -2.54349530e-01f, -1.46301880e-01f, -9.23533961e-02f, -1.17603838e-01f, -2.14169115e-01f, 2.06802655e-02f, -2.15552077e-02f, -3.32871079e-01f,
  -1.19954590e-02f, 6.83271736e-02f, -1.35066479e-01f, -1.20661840e-01f, -4.77912575e-02f, -3.92436266e-01f, -3.64942968e-01f, -2.24948987e-01f, 2.12457832e-02f, 1.10730827e-01f,
  -3.73460837e-02f, -1.19681142e-01f, -6.66748136e-02f, 2.99894735e-02f, -1.86753616e-01f, -1.31274149e-01f, -2.28324205e-01f, -2.43475839e-01f, -2.40508705e-01f, -3.29605699e-01f,
  -4.99338061e-01f, 3.26807909e-02f, 1.26896068e-01f, 8.08741823e-02f, -2.47085840e-02f, 5.67033552e-02f, -1.77319422e-02f, 8.74834359e-02f, 1.47349641e-01f, -1.11193042e-02f,
  3.10020498e-03f, 4.63170521e-02f, 8.72575399e-03f, -3.75814401e-02f, -8.25048462e-02f, 6.04827255e-02f, -6.69859871e-02f, 7.35284761e-03f, 3.42362858e-02f, 2.86160130e-03f,
  -2.75641382e-02f, -9.23606940e-03f, -3.46156210e-02f, 1.61795523e-02f, 2.33003777e-02f, 6.23631813e-02f, 1.33946603e-02f, 6.90388680e-02f, 3.85735929e-02f, -1.76710829e-01f,
  -3.00244316e-02f, 1.89079661e-02f, 4.27505635e-02f, 5.09780347e-02f, 8.39245692e-02f, 3.51581350e-02f, -3.53334770e-02f, -5.05469330e-02f, 1.37839904e-02f, 4.65895087e-02f,
  5.95893413e-02f, -2.61886511e-02f, -3.20168771e-02f, -1.36390906e-02f, -5.22576459e-02f, 6.53755516e-02f, 7.24988580e-02f, -4.79835384e-02f, 1.00589532e-03f, 2.22199820e-02f,
  -2.33256817e-02f, 8.09909925e-02f, 7.28094056e-02f, -4.73031662e-02f, -3.65205668e-02f, -7.90517330e-02f, 3.22595946e-02f, 4.79953028e-02f, 1.18405119e-01f, 9.61797759e-02f,
  -7.59837776e-02f, 1.52703598e-01f, -9.95496809e-02f, -6.80217296e-02f, -1.05814539e-01f, -5.48740514e-02f, 4.17046770e-02f, -5.39818741e-02f, 7.57509544e-02f, 3.75109464e-02f,
  -1.72780640e-02f, -4.75109275e-03f, -8.99186358e-02f, 3.35547216e-02f, 8.53476077e-02f, -8.39646012e-02f, -6.16223365e-02f, -5.26758954e-02f, 1.99484429e-03f, 3.62890549e-02f,
  -3.69109549e-02f, -1.50397681e-02f, -1.17100049e-02f, 9.14224423e-03f, -1.94502454e-02f, 4.78668883e-02f, -1.28888354e-01f, -4.38717306e-02f, -5.06001078e-02f, -2.59278655e-01f,
  -1.32380739e-01f, 2.53720880e-01f, 1.93013117e-01f, 2.35661730e-01f, 1.18824042e-01f, 5.97535213e-03f, 2.79879957e-01f, 1.77986130e-01f, 1.22020304e-01f, 1.33481652e-01f,
  1.45414010e-01f, -1.44425765e-01f, -1.85044631e-01f, -1.98795214e-01f, -1.80245578e-01f, 2.17372119e-01f, 1.60534941e-02f, -3.56064737e-01f, -3.00922722e-01f, -1.44554973e-01f,
  -1.77627485e-02f, -1.09363273e-01f, -2.39245862e-01f, -2.31192075e-02f, 2.32508153e-01f, -3.64632197e-02f, 1.87137738e-01f, 2.06793830e-01f, 3.71148959e-02f, 1.22709498e-01f,
  7.23107904e-02f, 3.43465894e-01f, -7.84375295e-02f, -6.28852472e-03f, 1.29333496e-01f, 4.61775064e-02f, 1.16606191e-01f, 6.32631034e-02f, 1.21268578e-01f, 7.59430677e-02f,
  4.97424789e-02f, 6.27910942e-02f, 4.18364629e-02f, 1.02670491e-01f, 1.33389905e-01f, 3.65311950e-02f, 5.44390678e-02f, 6.00793101e-02f, -4.97792289e-03f, 9.95058790e-02f,
  1.64732412e-01f, 1.20361052e-01f, 1.78192034e-01f, 1.93456769e-01f, 1.08500712e-01f, 3.23675275e-02f, 2.39667207e-01f, 7.82869831e-02f, 5.70652336e-02f, 1.62979692e-01f,
  4.17496860e-02f, 6.11176454e-02f, -3.51839513e-02f, 2.73564458e-03f, -5.38952015e-02f, -5.85475005e-02f, 2.16213781e-02f, -6.79157078e-02f, -4.24148478e-02f, -5.38141504e-02f,
  2.55307574e-02f, 2.82166582e-02f, 4.78277565e-04f, 2.02311873e-02f, 4.81411722e-03f, 1.52469249e-02f, -5.40444478e-02f, 1.57305517e-03f, -9.25025567e-02f, -6.62309006e-02f,
  -6.04290254e-02f, -9.93957743e-02f, 4.32202965e-02f, -1.23588488e-01f, 1.52711933e-02f, -1.47900162e-02f, 2.49570026e-03f, -1.38609391e-02f, -4.39757183e-02f, -3.98424640e-02f,
  1.04457624e-01f, -1.34175241e-01f, 9.49430391e-02f, 7.76184606e-04f, 5.51471971e-02f, 5.02578802e-02f, 9.79664922e-02f, 7.50196502e-02f, 2.42265090e-02f, 1.22044817e-01f,
  2.15604492e-02f, 3.49962041e-02f, 1.10999241e-01f, 2.78995261e-02f, -5.35133819e-04f, 2.55531389e-02f, 2.74516977e-02f, 1.40112685e-02f, 2.51446050e-02f, 1.85413420e-01f,
  1.48637265e-01f, 4.54080030e-02f, -1.28813520e-01f, -3.06078140e-02f, 6.07720390e-02f, -1.56318799e-01f, 1.18773535e-01f, 3.20232101e-03f, -6.24050684e-02f, 1.12015463e-01f,
  2.81826347e-01f, 2.25694418e-01f, -1.47351876e-01f, 3.41424674e-01f, 8.97766743e-03f, 7.21359923e-02f, 1.67188555e-01f, 2.90559709e-01f, 1.46929324e-01f, 2.65062183e-01f,
  -7.93016776e-02f, 3.86376455e-02f, 7.02758357e-02f, 5.39197261e-03f, 1.33479789e-01f, 3.55214417e-01f, 3.38462293e-01f, 1.03500672e-01f, 8.11512172e-02f, 1.39310211e-01f,
  1.83875069e-01f, 1.73753351e-01f, 1.70251906e-01f, 2.17209518e-01f, 1.79572150e-01f, 2.16331616e-01f, 2.05944240e-01f, 1.73760474e-01f, 1.02144405e-01f, 4.54719722e-01f,
  -1.33909568e-01f, 7.39814192e-02f, -1.24648269e-02f, 4.99651991e-02f, -1.09208867e-01f, -2.32548844e-02f, -2.67156530e-02f, 1.80382386e-03f, 9.11835488e-03f, 1.31693855e-01f,
  5.44948364e-03f, 4.85332757e-02f, 6.93706498e-02f, -2.06661820e-02f, 1.04674973e-01f, 8.47092420e-02f, 9.37511250e-02f, 1.15104608e-01f, 1.25993583e-02f, -2.06075795e-02f,
  6.78706020e-02f, -5.83886951e-02f, -7.98973143e-02f, 6.87641203e-02f, 2.83467658e-02f, 6.46844134e-02f, 5.33673763e-02f, 4.82433736e-02f, 1.39430389e-02f, 1.99950650e-01f,
  1.76901162e-01f, -5.85508766e-03f, 5.75760612e-03f, -5.46272472e-03f, 1.18299825e-02f, 2.57289633e-02f, 4.40689586e-02f, 1.01740152e-01f, 6.13952614e-02f, -4.38679159e-02f,
  -4.55409326e-02f, -2.19776761e-02f, -5.30110523e-02f, 3.95124070e-02f, 7.02439575e-03f, 2.03051735e-02f, -1.24538597e-02f, 1.94641314e-02f, 2.00162381e-02f, 2.08160258e-03f,
  -2.81700809e-02f, 8.65566265e-03f, -6.18730374e-02f, -7.54451230e-02f, -9.44956169e-02f, 3.68502811e-02f, -8.08449611e-02f, -1.07892469e-01f, -4.41256426e-02f, 3.81051973e-02f,
  -1.29896000e-01f, -1.98559806e-01f, 9.99064147e-02f, 7.94580281e-02f, -3.01527046e-03f, 3.81917134e-02f, -5.28605469e-02f, 8.80978778e-02f, -7.11660832e-02f, 3.20638791e-02f,
  -1.65313482e-02f, 3.61544006e-02f, -3.88650298e-02f, -8.77873525e-02f, -2.89177950e-02f, 3.80026847e-02f, 1.02774531e-01f, 1.63243651e-01f, -2.79196189e-03f, 3.91484275e-02f,
  4.66904454e-02f, 1.09924011e-01f, 7.69606382e-02f, -4.95611988e-02f, 9.53349099e-02f, 3.08046467e-03f, 1.66576952e-02f, 1.05639569e-01f, 5.24612330e-02f, 2.53914624e-01f,
  -4.17051375e-01f, 2.38285184e-01f, 1.44580200e-01f, -1.33104965e-01f, 1.20628655e-01f, 3.18613946e-01f, 4.18088019e-01f, 1.57145098e-01f, -1.57281801e-01f, 7.20998868e-02f,
  -2.10880026e-01f, -4.90753263e-01f, -3.16657364e-01f, -3.88331383e-01f, -1.89172283e-01f, 2.75254488e-01f, 2.75349587e-01f, -1.69476107e-01f, -1.90465555e-01f, -3.83382402e-02f,
  9.03865993e-02f, -1.09700218e-01f, -1.46632105e-01f, -1.03259772e-01f, -7.66786709e-02f, -1.98501438e-01f, 1.14224525e-03f, -6.74644411e-02f, 9.64683369e-02f, -3.88511494e-02f,
  -2.66618878e-01f, 3.87204997e-02f, -2.86349356e-01f, -1.99859440e-01f, -8.09995010e-02f, -5.33791333e-02f, -6.72743171e-02f, -1.51773885e-01f, -4.14169580e-02f, -8.78593698e-02f,
  -1.23798802e-01f, -9.61210728e-02f, -1.56807482e-01f, -8.09741318e-02f, -8.86727870e-03f, -5.78744598e-02f, -2.20560730e-02f, -3.63259688e-02f, 1.16562028e-03f, 4.04389687e-02f,
  -3.86079885e-02f, 1.11894816e-01f, 3.62443328e-02f, 5.93206435e-02f, -9.94090736e-02f, -9.07975957e-02f, -8.93228687e-03f, -4.67102118e-02f, -2.18124874e-02f, -1.56964779e-01f,
  -1.21785123e-02f, -2.08948515e-02f, 1.14920370e-01f, 4.38029803e-02f, 2.44631357e-02f, 8.97009224e-02f, 9.26157087e-02f, 1.01172775e-01f, 5.09095192e-02f, -1.45222887e-03f,
  9.73269045e-02f, 7.52235651e-02f, 1.79117665e-01f, 3.77848521e-02f, 8.52647424e-02f, 1.44219235e-01f, 4.30632122e-02f, 5.68377785e-02f, 3.12180929e-02f, 2.47865804e-02f,
  1.79059338e-02f, -2.54627224e-02f, 2.34819427e-02f, 3.16860080e-02f, 1.57633603e-01f, 4.45465893e-02f, 5.30827120e-02f, 1.04854532e-01f, 2.40595583e-02f, 1.80815041e-01f,
  -3.79145205e-01f, -6.92848340e-02f, -3.22954357e-01f, -2.27253705e-01f, -6.20573685e-02f, -1.89473405e-01f, -2.07934335e-01f, -1.74930140e-01f, -5.54758981e-02f, -7.05793276e-02f,
  -6.18995652e-02f, -7.28276521e-02f, -3.93399857e-02f, -5.88106215e-02f, -2.37294734e-01f, -1.25330165e-01f, -1.12965807e-01f, -2.02301070e-01f, -1.09712876e-01f, -6.61317632e-02f,
  1.06654922e-02f, -2.16817614e-02f, -2.60637194e-01f, -8.15401450e-02f, -1.19582362e-01f, -2.19987750e-01f, -1.74530134e-01f, -2.14709088e-01f, -1.01355784e-01f, -7.74028897e-02f,
  6.12863898e-01f, -1.26692131e-01f, -3.96910340e-01f, 2.13101462e-01f, 7.31781051e-02f, -1.01834536e-01f, -1.46149084e-01f, 1.06458716e-01f, 3.40899974e-01f, 7.11891651e-02f,
  7.27931857e-02f, 2.70307153e-01f, 7.86265433e-02f, 2.11415086e-02f, 1.46151381e-02f, -9.82362553e-02f, -1.00477681e-01f, 1.21712517e-02f, 1.02512188e-01f, 3.75614055e-02f,
  1.67469233e-01f, 2.61659622e-01f, 1.94523618e-01f, 1.62539199e-01f, 5.62828854e-02f, 1.04312211e-01f, 6.84787845e-03f, 1.92307681e-01f, 2.11580284e-02f, -1.37420401e-01f,
  -2.05968305e-01f, 6.19979016e-02f, 3.95695269e-02f, 1.45179108e-01f, 2.41369382e-02f, 9.83959213e-02f, 8.87897238e-02f, 2.08419003e-02f, 1.76392630e-01f, 9.52066854e-02f,
  9.08878520e-02f, 6.82677627e-02f, 4.97912131e-02f, 6.72478601e-02f, 1.68658167e-01f, 1.05835870e-01f, 5.19391559e-02f, -3.34552042e-02f, -8.51480570e-03f, 2.83107460e-02f,
  1.32512962e-02f, 8.85661319e-02f, 8.97830650e-02f, -2.67458986e-03f, -4.05774079e-02f, 1.22874819e-01f, 2.83939093e-02f, 1.16146430e-01f, 4.03801277e-02f, -5.59081149e-04f,
  -1.87453195e-01f, -9.25123841e-02f, -7.53894672e-02f, -1.52115431e-02f, 6.46131858e-02f, -4.65832315e-02f, -4.15229984e-02f, -1.07610844e-01f, -5.70641924e-03f, -4.88708094e-02f,
  -7.24265128e-02f, -1.69387668e-01f, -9.37814638e-02f, -1.24710210e-01f, -1.51297972e-01f, -1.04972482e-01f, -4.27871235e-02f, -2.05621079e-01f, -6.37045130e-02f, 3.57932202e-03f,
  -8.32492393e-03f, -3.12101562e-02f, -5.08092046e-02f, -7.53289014e-02f, -1.40973762e-01f, -1.29163772e-01f, -7.39341155e-02f, -7.80711472e-02f, -7.04082474e-02f, -3.03793419e-02f,
  4.48050886e-01f, 5.84239885e-02f, 9.92597044e-02f, 1.07353188e-01f, 2.46910341e-02f, 1.23316191e-01f, 8.40023160e-02f, 9.55882594e-02f, 5.98138906e-02f, -1.27561428e-02f,
  6.27117082e-02f, 1.04285084e-01f, 6.55463636e-02f, 8.95140618e-02f, 2.17134394e-02f, 1.29237935e-01f, 1.36326000e-01f, 6.67582601e-02f, 9.44381580e-02f, 6.52624592e-02f,
  -2.81445943e-02f, 1.38949379e-01f, 3.14224005e-01f, 1.56532496e-01f, 1.02584720e-01f, 2.29878843e-01f, 1.25830308e-01f, 6.76384270e-02f, 1.93554074e-01f, 2.09081411e-01f,
  -3.05235028e-01f, 3.23731065e-01f, 2.05386221e-01f, -2.29019120e-01f, 2.13298380e-01f, 1.06154792e-01f, 1.72382280e-01f, 8.22415296e-03f, -2.40914449e-02f, 3.35128084e-02f,
  2.16625288e-01f, -9.96694416e-02f, -1.45191178e-01f, -2.28059664e-02f, -1.38913468e-02f, 8.57524201e-02f, -2.26766244e-02f, -5.76387756e-02f, -1.61940560e-01f, 6.97152093e-02f,
  2.56139208e-02f, -1.10609747e-01f, -1.24320894e-01f, -5.43760061e-02f, 3.14102285e-02f, -1.72890753e-01f, 9.88011882e-02f, 1.19283117e-01f, 2.15654328e-01f, -1.83957443e-01f,
  1.20786592e-01f, 3.36322635e-01f, -1.95771139e-02f, -7.56782293e-02f, 1.88277990e-01f, -3.12939622e-02f, 7.31589198e-02f, 7.67900273e-02f, 2.57466547e-02f, 1.00381888e-01f,
  5.70767485e-02f, 2.72512417e-02f, 3.17412987e-02f, 1.07324183e-01f, 1.84349492e-01f, 1.01893336e-01f, 1.40840217e-01f, -2.52841525e-02f, -3.96386907e-02f, 1.95782110e-01f,
  1.95541203e-01f, 2.47924432e-01f, 1.60203993e-01f, 1.31214589e-01f, 6.21638112e-02f, -1.79775674e-02f, 1.64009124e-01f, -1.02974521e-02f, -2.65110601e-02f, -3.13732438e-02f,
  -1.54692352e-01f, -4.97073457e-02f, 2.29426734e-02f, 3.79010290e-03f, -1.69411555e-01f, -4.37275358e-02f, -5.30936345e-02f, -7.66918138e-02f, 2.69330703e-02f, -8.67685452e-02f,
  -4.98210406e-03f, -2.59644352e-02f, -5.18213846e-02f, -1.09154329e-01f, -8.59951079e-02f, -1.12712026e-01f, -6.66028708e-02f, -8.55039731e-02f, 1.87446643e-02f, -7.26895630e-02f,
  -5.24839126e-02f, -3.60554978e-02f, -6.18922263e-02f, -5.02621150e-03f, -8.81542861e-02f, -8.16175044e-02f, -4.52945605e-02f, -7.15864077e-02f, -2.73601599e-02f, -5.04591689e-02f,
  -2.17770785e-01f, 2.35421285e-01f, -4.64555174e-02f, -7.28860917e-03f, 1.02174014e-01f, 4.19401489e-02f, 3.02415714e-02f, 1.23778343e-01f, 9.11905840e-02f, 3.13513912e-02f,
  2.09334001e-01f, 4.02837135e-02f, 4.41017151e-02f, 1.69289470e-01f, -3.57184187e-02f, 1.03734635e-01f, 7.41385594e-02f, 6.17384911e-02f, 6.21731915e-02f, 1.66222915e-01f,
  -2.56582145e-02f, -1.02967108e-02f, -1.51004300e-01f, -1.98655594e-02f, 1.10383909e-02f, -2.04502493e-01f, -8.90543759e-02f, -7.84920007e-02f, -1.62555292e-01f, -2.43039042e-01f,
  -3.42726856e-01f, -2.37676688e-02f, -3.47981513e-01f, -2.85225332e-01f, 4.48872633e-02f, 1.69792816e-01f, 1.89156845e-01f, 1.16238207e-01f, 2.55966242e-02f, -3.46458666e-02f,
  9.13472474e-02f, 6.46121055e-03f, 4.05863300e-02f, 1.87303901e-01f, 1.36267856e-01f, 9.90177691e-02f, -4.50724699e-02f, -2.99911052e-02f, -7.56801888e-02f, 8.56613368e-02f,
  1.28350765e-01f, -1.83109343e-01f, -1.65960267e-01f, -1.64972935e-02f, 3.73376645e-02f, -5.39580472e-02f, 1.44239441e-02f, -7.52276853e-02f, 8.24548379e-02f, -9.75851268e-02f,
  -2.55593479e-01f, -7.17523471e-02f, -6.95817545e-02f, 5.82206734e-02f, -5.82094528e-02f, -1.12433530e-01f, -7.79857934e-02f, -3.55564207e-02f, 7.75307715e-02f, 2.40261704e-02f,
  -7.77515545e-02f, 5.05304411e-02f, -3.09381206e-02f, -1.03085265e-01f, -4.74568866e-02f, -1.04595900e-01f, -1.47326887e-01f, -8.86687264e-02f, -5.40529005e-03f, -9.47251469e-02f,
  -4.47722152e-03f, -1.29157960e-01f, -1.22619346e-01f, -7.85188749e-05f, 5.04570082e-02f, -6.19283207e-02f, -8.92773643e-02f, 4.14539464e-02f, 3.14601995e-02f, -4.73533459e-02f,
  4.32067588e-02f, -5.40037677e-02f, -6.96660802e-02f, -2.96573080e-02f, 8.86215717e-02f, 1.81674194e-02f, 1.80743709e-02f, 7.66983554e-02f, 2.60624336e-03f, -4.91064601e-02f,
  6.38861954e-03f, -5.76771498e-02f, 5.32954261e-02f, 1.10130265e-01f, 4.84808944e-02f, -4.83591342e-03f, 4.01703008e-02f, 2.78791655e-02f, -2.54086331e-02f, -8.20206031e-02f,
  -8.90065730e-02f, -9.55242440e-02f, -2.01741233e-02f, 3.42773423e-02f, 4.10916395e-02f, 5.96546493e-02f, -6.77862540e-02f, -2.12011822e-02f, -9.35983807e-02f, 2.17799540e-03f,
  -2.24438697e-01f, 2.23264888e-01f, -6.46764711e-02f, 7.38585144e-02f, -1.07172772e-01f, -6.82327375e-02f, -3.74558531e-02f, -8.57527480e-02f, 3.31876837e-02f, -6.17956631e-02f,
  -1.55365560e-02f, -2.26783212e-02f, -1.56711917e-02f, 1.64768733e-02f, -1.06234223e-01f, -7.58424625e-02f, -1.77659318e-01f, -7.26464689e-02f, -4.80074137e-02f, -1.30136356e-01f,
  -5.57337925e-02f, -6.40921295e-02f, -2.30315387e-01f, -1.75202976e-03f, -7.61896297e-02f, 2.31453823e-03f, -8.62661898e-02f, -9.81149301e-02f, -1.24255203e-01f, -1.02984063e-01f,
  -7.07779050e-01f, -3.74014139e-01f, -3.91510278e-01f, -2.63916045e-01f, -8.60069990e-02f, 4.20581400e-02f, 8.85093808e-02f, -5.49902068e-03f, -7.30598420e-02f, -1.30532876e-01f,
  -1.99989378e-01f, -1.52689666e-01f, -1.76131874e-01f, -4.38757278e-02f, -1.66507840e-01f, -1.01111352e-01f, -2.60429591e-01f, -3.19090098e-01f, -7.18261153e-02f, 1.09810099e-01f,
  1.12076044e-01f, -8.50551575e-02f, -2.36031920e-01f, -1.38497382e-01f, -1.69588462e-01f, -6.97041452e-02f, -2.08689168e-01f, -2.59234339e-01f, -6.16264977e-02f, -3.11120063e-01f,
  -1.85907349e-01f, -4.95707422e-01f, -2.77118292e-02f, -1.82279691e-01f, -1.76083177e-01f, -1.56994566e-01f, -2.85112590e-01f, -2.62509167e-01f, -2.26157293e-01f, -1.70155391e-01f,
  -2.24372104e-01f, -2.50712425e-01f, -2.68775374e-01f, -1.16066344e-01f, -1.89816937e-01f, -1.21318094e-01f, -1.30892992e-01f, -2.23073751e-01f, -2.28581294e-01f, -1.39164150e-01f,
  -1.05963953e-01f, -3.43940735e-01f, -3.39437276e-01f, -4.67616059e-02f, -2.02063382e-01f, -2.85208046e-01f, -9.65616107e-02f, -1.04961440e-01f, -1.58959135e-01f, -1.02627277e-01f,
  -1.15410373e-01f, 1.03039995e-01f, 3.53359096e-02f, 3.81001532e-02f, 1.87839627e-01f, 3.46368514e-02f, 1.37933359e-01f, 1.67863294e-01f, 1.67298734e-01f, 2.19231069e-01f,
  8.94596726e-02f, 1.85463563e-01f, 1.04969762e-01f, 1.37687579e-01f, 1.27894044e-01f, 3.28001343e-02f, 9.69570056e-02f, 1.63561329e-01f, 1.56516761e-01f, 6.94530010e-02f,
  1.01953186e-01f, 8.83166939e-02f, 9.54935700e-02f, 1.44787878e-01f, 1.24181345e-01f, 1.25010744e-01f, 1.38334796e-01f, 2.03755796e-01f, 1.78204730e-01f, 1.08391054e-01f,
  6.37389421e-02f, -1.90220416e-01f, -2.21552521e-01f, -1.66997313e-01f, -2.00661451e-01f, -1.48997545e-01f, -9.53147486e-02f, -1.16529323e-01f, -1.79676801e-01f, -7.78969675e-02f,
  -3.87247801e-02f, -1.71009034e-01f, -1.50822431e-01f, 2.26077493e-02f, -8.05609673e-02f, 1.44700035e-02f, -1.21647649e-01f, -2.34709576e-01f, -8.13551694e-02f, -6.33561537e-02f,
  -4.54312712e-02f, -6.36076927e-02f, -1.21023282e-01f, -6.07130080e-02f, -8.25270191e-02f, -1.60286486e-01f, 8.53841081e-02f, -9.17042606e-03f, -8.22153986e-02f, 9.57722068e-02f,
  1.56595130e-02f, -1.92985013e-01f, -2.88508147e-01f, -3.28422457e-01f, -4.39043760e-01f, -3.98843408e-01f, -4.02539760e-01f, -8.34174380e-02f, -3.13742459e-02f, -1.24650359e-01f,
  -2.32441768e-01f, -1.52576268e-01f, -1.08782612e-01f, -2.63751745e-02f, 4.70405370e-02f, -1.41921833e-01f, -1.54016361e-01f, -5.82693517e-02f, -8.91921073e-02f, -1.36216834e-01f,
  -1.87892660e-01f, -9.35013145e-02f, 4.20473665e-02f, -3.54704745e-02f, -7.50087276e-02f, -7.82754198e-02f, -2.08899602e-01f, -6.47693053e-02f, -1.08473122e-01f, -1.78178146e-01f,
  -3.34997386e-01f, 6.78078905e-02f, -9.57443789e-02f, -2.71952823e-02f, -1.52778566e-01f, 1.21337071e-01f, -9.95016024e-02f, 7.35898688e-02f, 2.54628509e-02f, -7.23857060e-02f,
  -1.04038967e-02f, 4.31112759e-02f, 1.65527221e-02f, -1.19856745e-02f, -4.76457141e-02f, 3.36364880e-02f, 1.70724392e-01f, 6.42342716e-02f, 9.81184393e-02f, 6.91305026e-02f,
  -8.07035062e-03f, -4.91895936e-02f, -4.95019043e-03f, 6.27189055e-02f, 1.21924832e-01f, -9.95086879e-02f, -2.55564954e-02f, 4.04684758e-03f, 1.27959430e-01f, -4.21276577e-02f,
  -8.81859660e-02f, -5.67227639e-02f, -1.23735934e-01f, 5.05485982e-02f, -1.50917834e-02f, 2.21235286e-02f, -7.26300180e-02f, 2.25417013e-03f, -1.68193299e-02f, 1.21424206e-01f,
  -2.19380925e-03f, -2.08567325e-02f, -3.00544780e-02f, -9.66951903e-03f, 1.19689768e-02f, -8.54497775e-02f, -1.78839806e-02f, 8.69717915e-03f, 7.21270218e-02f, -2.88019478e-02f,
  5.34423888e-02f, 4.93111871e-02f, -1.17796905e-01f, -9.09702666e-03f, 5.72842099e-02f, -3.95506769e-02f, 2.48155314e-02f, -5.59097156e-02f, -8.25530365e-02f, 1.33649305e-01f,
  -2.93576121e-01f, 7.77309388e-02f, 1.21918041e-02f, 1.64067984e-01f, -3.04662976e-02f, 3.42370011e-02f, 1.95840895e-02f, 4.43393737e-02f, 3.55525985e-02f, -5.59092872e-02f,
  -3.83057003e-03f, -2.33012959e-02f, -9.54237953e-02f, -9.30958800e-03f, -7.82444142e-03f, 6.71845078e-02f, 8.97147581e-02f, -5.43278679e-02f, -2.35006399e-02f, -3.88571322e-02f,
  6.73289597e-02f, -5.48991747e-02f, -4.34209444e-02f, -1.00220755e-01f, -2.26687081e-02f, -1.34043694e-01f, -1.60192683e-01f, -1.19430134e-02f, 5.22246957e-03f, -2.42718756e-01f,
  5.06650984e-01f, 4.41514432e-01f, -4.09242094e-01f, 2.96728075e-01f, -4.98176999e-02f, -7.69472942e-02f, 1.70881331e-01f, 1.51359700e-02f, 8.68388116e-02f, 1.98949546e-01f,
  -8.59970972e-02f, -1.44946560e-01f, -5.64040877e-02f, -8.92548636e-02f, -1.40663862e-01f, 7.43933395e-02f, 2.31078714e-02f, -1.45594627e-01f, -2.26397455e-01f, 1.96033157e-02f,
  1.00094453e-01f, 2.70932615e-01f, -4.38384600e-02f, 1.94895733e-03f, 2.65413970e-01f, 5.16404919e-02f, 7.17646852e-02f, 1.41870961e-01f, 9.17525664e-02f, 2.54738271e-01f,
  -1.69654652e-01f, 5.93969002e-02f, -1.40319392e-01f, 1.28125638e-01f, -1.52772544e-02f, 8.65091532e-02f, 6.08130395e-02f, 3.08392979e-02f, 4.55597267e-02f, 9.64160040e-02f,
  1.25583902e-01f, 4.16185893e-02f, 2.98657753e-02f, 1.21145450e-01f, 1.01998635e-01f, 7.70831481e-02f, 4.98733036e-02f, 4.86115627e-02f, -5.26439808e-02f, 2.83075254e-02f,
  6.36239722e-02f, 3.48530822e-02f, 6.29376844e-02f, -7.91538060e-02f, 2.59901751e-02f, 3.10535766e-02f, -5.10388315e-02f, -8.07175189e-02f, -2.65796613e-02f, 2.24105895e-01f,
  1.93800643e-01f, -3.02948784e-02f, -1.17681980e-01f, 4.92210649e-02f, -9.23313666e-03f, -3.74239460e-02f, -2.72489991e-02f, 7.38987327e-02f, -7.66587555e-02f, 1.05266057e-01f,
  -4.55344953e-02f, -1.34819910e-01f, -8.72039497e-02f, -1.09800296e-02f, -7.31555372e-02f, -3.25167999e-02f, -1.17031373e-02f, 4.03745286e-02f, -1.03966676e-01f, -8.26460421e-02f,
  -3.58296707e-02f, -9.80814546e-02f, -3.24899033e-02f, -2.98687275e-02f, -5.31992726e-02f, -9.76566672e-02f, -9.77334380e-03f, -7.65459538e-02f, -7.31544048e-02f, 4.34477329e-02f,
  1.23391405e-01f, -2.58627266e-01f, 6.96638301e-02f, 7.07493443e-03f, 9.61015448e-02f, 3.93415913e-02f, -4.17323969e-02f, -5.31435059e-03f, -1.34995393e-02f, -2.30223946e-02f,
  -1.64289791e-02f, -2.78329179e-02f, -6.04659691e-03f, 3.67754810e-02f, 1.04837669e-02f, 3.46382940e-03f, 1.44575432e-01f, 1.16350991e-03f, -1.24707725e-02f, -4.91753854e-02f,
  9.97772142e-02f, 1.24414019e-01f, 1.21682227e-01f, 8.14430043e-02f, 5.21771833e-02f, -5.28194793e-02f, 2.80907843e-02f, 7.75197893e-02f, -4.71082516e-03f, 1.94764316e-01f,
  6.88624263e-01f, -7.82985091e-02f, -5.38634658e-01f, 3.07345331e-01f, -6.91957423e-04f, -3.57591778e-01f, -3.73053193e-01f, -7.29725733e-02f, 2.89433569e-01f, -1.75713733e-01f,
  2.05038279e-01f, 2.44013265e-01f, 8.91300440e-02f, 1.59779284e-02f, -1.05860397e-01f, -4.72580016e-01f, -4.15256113e-01f, -1.94559395e-01f, -9.80026424e-02f, 4.48105559e-02f,
  1.34431913e-01f, 2.51661897e-01f, 3.12013328e-01f, 1.09798819e-01f, -6.99752895e-03f, 5.50406165e-02f, -8.74976516e-02f, 1.34135574e-01f, -7.59030953e-02f, -1.32006854e-01f,
  -2.42749572e-01f, 1.47557288e-01f, -1.69574529e-01f, 9.26601067e-02f, -5.08050621e-03f, -6.96011186e-02f, -1.28479540e-01f, -5.10817766e-02f, 3.44695076e-02f, -9.73462984e-02f,
  1.95159093e-02f, 2.14491878e-02f, -2.95608826e-02f, -8.61334652e-02f, -3.25260833e-02f, -9.77063477e-02f, -1.25585675e-01f, -8.03216919e-03f, -7.19409212e-02f, -1.12005673e-01f,
  4.52248827e-02f, 1.12282231e-01f, -3.68010788e-03f, -8.39467421e-02f, -1.45065635e-01f, 1.77250765e-02f, -6.31740168e-02f, 3.50782983e-02f, -1.87388659e-01f, -5.47314510e-02f,
  -3.01323961e-02f, 4.19864338e-03f, -4.21868414e-02f, -2.10968293e-02f, 3.55255194e-02f, -4.95078005e-02f, -6.49813488e-02f, -1.00317433e-01f, -1.50540227e-03f, -4.80087884e-02f,
  -4.53554690e-02f, 1.77317839e-02f, -1.57288425e-02f, -5.06338887e-02f, 4.14231308e-02f, -8.61949287e-03f, -4.15562987e-02f, -8.96836072e-03f, -6.20195502e-03f, 2.61127371e-02f,
  7.23150978e-03f, 3.90399098e-02f, 1.08501287e-02f, 6.20626099e-03f, -4.42867689e-02f, -8.78220424e-02f, 1.10028367e-02f, -3.63960899e-02f, 3.78495753e-02f, 2.47904044e-02f,
  2.58715861e-02f, -1.00857168e-01f, -1.14555195e-01f, -1.68964136e-02f, -5.62392324e-02f, 6.18310273e-02f, 2.07569133e-02f, -3.07116378e-02f, 2.29047257e-02f, -5.88723607e-02f,
  -1.45581076e-02f, -5.20537943e-02f, -3.07584042e-03f, 1.44358948e-02f, -4.13002893e-02f, -6.26140907e-02f, -1.95726566e-02f, -8.01128969e-02f, -3.34719345e-02f, -2.35129129e-02f,
  -2.26315707e-02f, -1.07613564e-01f, -3.10479738e-02f, -1.20472111e-01f, -2.82719247e-02f, -2.01782659e-02f, -1.68777093e-01f, -2.03937128e-01f, -1.65886506e-01f, -2.40647376e-01f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  7.76072860e-01f, -8.41661453e-01f, 5.14630154e-02f, 4.57135439e-01f, 3.70298564e-01f, 2.59259552e-01f, 4.61564772e-03f, 1.16840586e-01f, 1.66346371e-01f, -1.79172933e-01f,
  -2.57246286e-01f, -1.31104887e-01f, -1.76768839e-01f, -6.26370236e-02f, -3.26537155e-02f, 1.14622481e-01f, 1.33319035e-01f, 1.38121098e-01f, 3.55565190e-01f, 6.56878799e-02f,
  3.42664532e-02f, 1.82717457e-01f, 1.51220292e-01f, 6.17630081e-03f, -3.67265314e-01f, 8.77108946e-02f, -8.38717818e-02f, -1.43454537e-01f, -1.99130759e-01f, -4.89305496e-01f,
  -6.63710594e-01f, -3.84920806e-01f, 1.82551280e-01f, -8.98487568e-02f, -1.78857408e-02f, -5.90162277e-02f, 5.73052727e-02f, -5.78932352e-02f, 1.19912513e-01f, 1.15310036e-01f,
  -6.31820187e-02f, -1.25785872e-01f, -1.05665810e-01f, -8.80983993e-02f, 1.38467466e-02f, -7.69074038e-02f, -9.14749131e-02f, -4.12026420e-02f, -6.48070797e-02f, -2.33225048e-01f,
  -3.21796328e-01f, -1.12140290e-01f, 3.27409827e-03f, 1.76284686e-02f, 1.71904489e-02f, 1.44287452e-01f, -1.03524856e-01f, -2.95671523e-02f, 1.88959055e-02f, 2.12512482e-02f,
  -1.94097066e-03f, -1.11346468e-01f, -2.91781694e-01f, -2.44124681e-02f, 7.52248541e-02f, 2.71597147e-01f, 1.94517627e-01f, 8.30093995e-02f, -9.98368300e-03f, -5.47449477e-03f,
  3.34231406e-02f, -8.94739944e-03f, -7.00797066e-02f, 5.40022627e-02f, -1.66040182e-01f, -1.71526462e-01f, 2.00690213e-03f, -2.22075731e-01f, -1.69474840e-01f, -1.56312302e-01f,
  -1.47532597e-01f, -4.30731997e-02f, -1.28062084e-01f, -2.43331552e-01f, -2.16930568e-01f, 2.43198797e-02f, -5.92912212e-02f, -1.58615455e-01f, -1.30812414e-02f, 7.63418153e-02f,
  -4.82342869e-01f, -6.23985305e-02f, 1.04027890e-01f, -1.62759304e-01f, -5.74135147e-02f, -2.20194027e-01f, -2.10556567e-01f, -4.36656363e-03f, -2.83197723e-02f, -5.90923987e-02f,
  -1.06225029e-01f, -7.31653944e-02f, -3.07654262e-01f, -1.38159707e-01f, 1.76287055e-01f, 1.48614019e-01f, -1.71951860e-01f, -2.48145522e-03f, -2.92389002e-02f, -1.46138281e-01f,
  -1.87501669e-01f, 2.10020170e-01f, 2.51743644e-01f, 1.89092353e-01f, 2.04193845e-01f, 3.60994607e-01f, 7.68246874e-02f, 8.78408924e-02f, 1.93706632e-01f, 4.85953480e-01f,
  1.06684935e+00f, 3.26202720e-01f, 1.37152314e-01f, 7.55459666e-01f, -2.02646747e-01f, -6.87912822e-01f, -9.13379610e-01f, -2.36987159e-01f, 4.92859453e-01f, 4.71633375e-01f,
  -1.42665416e-01f, -3.47720742e-01f, 3.43939573e-01f, -3.66249263e-01f, -7.23919094e-01f, -5.57782762e-02f, 2.09875211e-01f, -2.82765925e-01f, -1.25309861e+00f, -1.15723431e+00f,
  -4.03370708e-01f, 2.14280352e-01f, 3.42389464e-01f, -7.26880059e-02f, 3.30861777e-01f, 6.51872382e-02f, 6.02681100e-01f, 3.78311813e-01f, -1.18792802e-01f, 6.69346511e-01f,
  2.88844824e-01f, 6.77975953e-01f, -5.99051893e-01f, 1.16333447e-03f, 1.48411676e-01f, -4.42863367e-02f, -1.51883319e-01f, 2.09834695e-01f, -1.75771285e-02f, 3.75533819e-01f,
  9.45269223e-03f, -1.12472907e-01f, -2.79310942e-01f, -7.47909918e-02f, -1.63099393e-01f, -3.00417244e-01f, 2.43076682e-01f, -7.47239292e-02f, 2.03564256e-01f, 1.11513309e-01f,
  -3.09021205e-01f, -9.80586037e-02f, 1.74979687e-01f, -6.63703009e-02f, -3.05289209e-01f, -1.05707824e-01f, -1.57770247e-03f, -3.63589488e-02f, -3.61720212e-02f, 6.32939935e-01f,
  -5.32014444e-02f, -1.00752056e-01f, -9.16973036e-03f, 1.79034740e-01f, -1.00907430e-01f, 5.77966273e-02f, 1.44996762e-01f, -5.63375577e-02f, -1.00597162e-02f, 1.23768315e-01f,
  -9.10888165e-02f, 2.38468405e-02f, -4.37237732e-02f, 4.24574688e-02f, -1.42315691e-02f, -1.54445982e-02f, -9.44902450e-02f, 9.73327830e-02f, 1.10776097e-01f, 8.81650522e-02f,
  -1.53521255e-01f, -5.41075431e-02f, 4.97252867e-02f, -1.28344670e-01f, -6.32190779e-02f, -2.23533139e-02f, 1.17092252e-01f, -1.52336851e-01f, -4.28572036e-02f, -2.14815512e-02f,
  1.93132743e-01f, -5.43310106e-01f, 3.97809565e-01f, -8.63413662e-02f, 2.02252716e-01f, -5.19341975e-02f, 3.22154164e-01f, -1.39249623e-01f, 1.96671486e-01f, -7.05630034e-02f,
  -3.38389248e-01f, -1.19759470e-01f, 3.80209923e-01f, -9.80383307e-02f, -1.96246967e-01f, -4.30522114e-02f, -7.59415254e-02f, -2.62880847e-02f, -2.71498561e-01f, 5.50732501e-02f,
  1.10313773e-01f, -2.48012558e-01f, -1.60339579e-01f, 6.50035590e-03f, 4.69203517e-02f, -3.56918156e-01f, -3.77409384e-02f, -2.27187306e-01f, -4.40057367e-01f, 1.32902578e-01f,
  8.21964204e-01f, -5.38407564e-01f, -5.75534165e-01f, -4.43008482e-01f, -4.50228631e-01f, 5.96001372e-03f, -1.38524249e-01f, -2.67928895e-02f, -1.66011959e-01f, -1.06437705e-01f,
  1.04709685e-01f, 4.19633955e-01f, 2.45825484e-01f, 2.41317332e-01f, 4.01322484e-01f, -2.24040359e-01f, -4.62665677e-01f, 1.56981081e-01f, 5.50545335e-01f, 3.10710400e-01f,
  5.63952848e-02f, -8.71214420e-02f, 2.92972654e-01f, 3.08566764e-02f, -4.65140671e-01f, 8.72676522e-02f, -3.43173176e-01f, -1.76809698e-01f, -1.56550542e-01f, -6.85317576e-01f,
  -3.26781087e-02f, 1.38781160e-01f, 1.67379618e-01f, 2.27155715e-01f, -2.58694403e-02f, 4.09270935e-02f, 2.46715499e-03f, -4.30579260e-02f, -1.59566104e-02f, -1.10201277e-01f,
  -9.83932093e-02f, 1.39309447e-02f, -6.57991320e-02f, -1.70250349e-02f, -3.40032540e-02f, 3.36720385e-02f, 1.26479954e-01f, 3.81690525e-02f, -3.69498543e-02f, -8.54756385e-02f,
  -3.27535942e-02f, 5.74068278e-02f, -4.66099419e-02f, 1.42860577e-01f, 2.15857431e-01f, 1.95210248e-01f, 4.31385264e-02f, 1.47919446e-01f, 1.11174360e-01f, 1.95023455e-02f,
  -6.95402967e-03f, -1.41299054e-01f, 1.29426762e-01f, 6.73908591e-02f, 1.96752027e-01f, 7.61388168e-02f, -3.90335657e-02f, 1.65442422e-01f, 1.57130033e-01f, 2.98125092e-02f,
  -1.48867995e-01f, 2.02475511e-03f, 1.22030592e-02f, 2.27394793e-02f, 4.65523340e-02f, -1.53149456e-01f, -1.00198261e-01f, 6.59761280e-02f, 1.27692595e-01f, -1.09572582e-01f,
  1.86215788e-01f, -1.52316978e-02f, -2.04325095e-01f, 3.73962261e-02f, -1.30387753e-01f, -7.65356123e-02f, 2.52706874e-02f, 1.13645159e-01f, -1.13239720e-01f, -2.29026809e-01f,
  -4.17184345e-02f, 4.11275148e-01f, 6.08866885e-02f, 1.34635540e-02f, -1.43829897e-01f, -2.32089475e-01f, 1.02783747e-01f, -1.13631561e-01f, -1.52878493e-01f, -1.24956250e-01f,
  -9.23968554e-02f, 4.07785550e-02f, -3.04451045e-02f, -1.23804882e-02f, 4.84442897e-03f, 1.03810057e-01f, 8.34563747e-02f, 3.72896343e-02f, -3.98113690e-02f, -2.40054429e-01f,
  -2.00809151e-01f, 3.44576291e-03f, 1.55411229e-01f, 3.98579910e-02f, 1.17952101e-01f, 1.35387197e-01f, -4.67432402e-02f, 4.50077467e-02f, -1.65919792e-02f, -2.83522718e-02f,
  8.63681138e-01f, 3.15181650e-02f, 4.73081887e-01f, 2.90054381e-01f, 5.20993948e-01f, 6.81336284e-01f, 6.57873273e-01f, 4.65162814e-01f, 8.65848809e-02f, 1.82519570e-01f,
  1.61579810e-02f, -4.69931275e-01f, -3.50937426e-01f, -4.39948350e-01f, -9.91801992e-02f, 2.03909636e-01f, 1.02354906e-01f, 1.21827517e-02f, 2.48636842e-01f, 2.47021407e-01f,
  -1.03486270e-01f, 1.95017010e-01f, 3.16663384e-01f, -9.61446241e-02f, -1.17399715e-01f, -3.46834958e-01f, 7.56115466e-02f, 2.48828590e-01f, -1.30358450e-02f, -5.59334457e-01f,
  -8.16886127e-02f, 3.14124078e-01f, -3.26968908e-01f, -4.14287388e-01f, -1.92831919e-01f, -1.29581451e-01f, 7.51474081e-03f, 1.52656054e-02f, -1.01960741e-01f, -1.25735581e-01f,
  -8.09973329e-02f, -1.03577651e-01f, 8.08230713e-02f, 1.50101691e-01f, 1.60605580e-01f, 1.23081915e-01f, -3.72442603e-02f, -2.36112382e-02f, -8.28610808e-02f, -1.02336712e-01f,
  -1.62200794e-01f, 2.54938364e-01f, 2.43993804e-01f, 4.08701934e-02f, -1.29573010e-02f, -4.22932319e-02f, 5.39691001e-02f, -1.17764637e-01f, 1.49897598e-02f, -2.15630352e-01f,
  -2.31967252e-02f, 4.79587801e-02f, 2.38943566e-02f, 4.99664135e-02f, 4.87781689e-02f, -1.56792551e-02f, -1.17328413e-01f, 1.44437384e-02f, -8.27342621e-04f, 2.02487066e-01f,
  -1.09499820e-01f, 8.72394070e-02f, 1.53326869e-01f, 1.37534633e-01f, -1.65222451e-01f, 2.07356662e-01f, 1.63619384e-01f, -3.58433872e-02f, 6.11596480e-02f, 4.78626974e-02f,
  1.82290256e-01f, 7.63605833e-02f, 1.82798475e-01f, 5.45361340e-02f, 1.85368463e-01f, -3.36540700e-03f, 2.91841719e-02f, 6.07189722e-02f, 6.60934150e-02f, 1.89394355e-01f,
  -2.29827985e-02f, 3.84871364e-01f, -2.66719520e-01f, -2.94835478e-01f, -2.74349586e-04f, -1.01812802e-01f, -5.52113689e-02f, -1.15670808e-01f, -1.15769416e-01f, 1.37011977e-02f,
  -3.32070403e-02f, -1.02219701e-01f, 8.44398066e-02f, 4.68121236e-03f, 2.22861141e-01f, 5.96402772e-02f, -5.44350594e-02f, -2.29798146e-02f, -2.40130201e-01f, -2.05726534e-01f,
  -1.19464852e-01f, 2.09301531e-01f, 2.29843676e-01f, -5.24472147e-02f, -2.21616887e-02f, 4.88497540e-02f, 4.88110930e-02f, -6.39973730e-02f, 1.37704507e-01f, 9.82563049e-02f,
  -4.69407409e-01f, 3.62282127e-01f, -4.04757261e-01f, -1.60560146e-01f, 8.14034641e-01f, 7.24023953e-02f, -3.62426788e-01f, -4.64075446e-01f, 1.58887804e-01f, 4.99774784e-01f,
  8.47131908e-01f, 4.14503753e-01f, -6.49970770e-01f, -2.72674084e-01f, -1.56924164e+00f, -1.09390712e+00f, -8.84248793e-01f, -1.35366952e+00f, -8.82968783e-01f, 3.40603411e-01f,
  8.28203976e-01f, -4.00879234e-01f, -8.84272575e-01f, -3.39437246e-01f, 6.61980391e-01f, 1.23722687e-01f, 6.95060343e-02f, 4.04749513e-01f, 4.21052009e-01f, 3.94073993e-01f,
  9.31344032e-02f, 2.55537689e-01f, 1.47413999e-01f, 2.07231194e-01f, 1.99328050e-01f, -1.06756687e-01f, -3.11078310e-01f, -1.53562814e-01f, -3.28820460e-02f, -2.87843406e-01f,
  3.48061234e-01f, 2.69051582e-01f, 1.30400613e-01f, 5.12335114e-02f, -1.70505181e-01f, -2.35408366e-01f, -9.24063027e-02f, -7.29698718e-01f, -8.62561643e-01f, 8.26503113e-02f,
  5.87640524e-01f, 4.97018129e-01f, -3.64923626e-01f, 1.47486450e-02f, -2.29458377e-01f, 4.92452160e-02f, 2.52883106e-01f, 4.63433802e-01f, -3.95270437e-01f, 6.05183281e-02f,
  2.29626179e-01f, -1.04932390e-01f, 1.39858156e-01f, -9.23346207e-02f, -1.38547331e-01f, 3.16691041e-01f, -1.63106486e-01f, 7.36948401e-02f, 7.79094100e-02f, -1.05232798e-01f,
  -2.05758959e-01f, 1.61407143e-01f, -1.15947470e-01f, -1.39850721e-01f, -1.20232821e-01f, 4.07511108e-02f, -5.36510944e-02f, -1.23771280e-01f, -8.13209042e-02f, -1.92751691e-01f,
  -1.80203423e-01f, 6.14248365e-02f, 1.26292026e-02f, -3.81283671e-01f, 2.43103579e-01f, -4.74950895e-02f, 1.12062678e-01f, 2.14792386e-01f, 8.54456574e-02f, 1.60646737e-01f,
  -4.80374545e-01f, -1.08774722e-01f, -1.23367995e-01f, -2.96642214e-01f, 6.42583938e-03f, 2.23150551e-01f, 1.59191042e-01f, 2.84929574e-02f, 4.96332720e-02f, -1.50166243e-01f,
  -9.30454060e-02f, -1.87690556e-01f, 6.09803014e-02f, -1.58897135e-02f, 9.73616075e-03f, 7.59811178e-02f, 8.60521421e-02f, -5.96139617e-02f, 1.84208043e-02f, 2.15391681e-01f,
  -1.07660189e-01f, -5.08092463e-01f, -5.45634568e-01f, -5.23334980e-01f, 5.26097864e-02f, -1.12173952e-01f, -3.74851912e-01f, 1.61514774e-01f, -7.43441701e-01f, -7.37294972e-01f,
  5.15055120e-01f, 1.03052855e+00f, 3.52979273e-01f, 2.93871528e-03f, 1.39929667e-01f, 4.19603020e-01f, 8.23634684e-01f, 2.14055851e-01f, -3.82227004e-01f, 3.18747193e-01f,
  3.62893701e-01f, -3.12342793e-01f, -1.91949725e-01f, -3.66541632e-02f, 3.51733834e-01f, 4.31677699e-01f, 1.98858187e-01f, 4.67014685e-02f, -2.54523993e-01f, -6.52747080e-02f,
  -1.13963820e-02f, -2.27153957e-01f, -4.48964119e-01f, -2.28249997e-01f, -2.46484298e-02f, -4.26485479e-01f, -1.51931405e-01f, 1.70766026e-01f, 3.67524803e-01f, 4.10085768e-01f,
  4.18362021e-01f, 6.99793160e-01f, -7.94194221e-01f, -2.56178621e-02f, 1.05715781e-01f, -1.59999996e-01f, -1.45308271e-01f, -2.39096671e-01f, -1.45942003e-01f, -1.06011391e-01f,
  9.16873515e-02f, 2.41332978e-01f, 8.91426280e-02f, 7.80216008e-02f, -3.57953273e-02f, 3.82838026e-02f, -3.02077848e-02f, 1.13592586e-02f, -1.18502975e-01f, 5.29975109e-02f,
  1.81518704e-01f, 1.35164171e-01f, 1.69124156e-01f, -4.72957082e-02f, 2.63821244e-01f, -3.46724927e-01f, 1.56452268e-01f, 1.81269124e-01f, -1.25082299e-01f, 7.73275942e-02f,
  -3.13739926e-01f, 5.87670039e-03f, 1.12718984e-01f, 7.56866410e-02f, 7.10970315e-04f, -1.21932171e-01f, 6.19564615e-02f, 1.49421215e-01f, 1.33299911e-02f, -9.30362940e-02f,
  2.14280616e-02f, -6.43043220e-02f, 4.12126854e-02f, -1.24430835e-01f, -2.07873896e-01f, 5.82655221e-02f, 1.50946870e-01f, 8.03501233e-02f, -2.79323645e-02f, -1.54990822e-01f,
  -8.17600861e-02f, -5.75784408e-03f, -1.90121889e-01f, -8.17678869e-02f, -2.08526894e-01f, -5.62932938e-02f, -2.51385301e-01f, -8.01080186e-03f, -1.99324295e-01f, -1.03006020e-01f,
  -9.26393986e-01f, -1.78374827e-01f, -3.31687808e-01f, 8.16026852e-02f, 3.17160755e-01f, -5.62816709e-02f, 3.86333768e-03f, -3.25866938e-02f, 1.86141893e-01f, 4.45308127e-02f,
  1.69411913e-01f, 6.65821061e-02f, 1.20417528e-01f, -4.42793854e-02f, -4.54490662e-01f, -2.42313623e-01f, 2.14655995e-01f, 1.00056842e-01f, -7.80419856e-02f, 1.61385685e-02f,
  -8.30989107e-02f, -3.02846730e-01f, -3.24055791e-01f, -2.71306247e-01f, -5.30359805e-01f, -7.98539758e-01f, -3.21066886e-01f, -3.32735240e-01f, -3.02322775e-01f, -4.35657382e-01f,
  -7.36949265e-01f, -2.83075780e-01f, 9.36322570e-01f, -3.26885819e-01f, -2.45668024e-01f, -6.93371177e-01f, -8.62444043e-01f, -6.48786664e-01f, -3.51826727e-01f, -1.07610799e-01f,
  -5.42003587e-02f, -1.91370379e-02f, 1.24286763e-01f, 2.09841311e-01f, -4.98177074e-02f, -9.72226858e-02f, 1.82867497e-01f, 5.24136782e-01f, 2.51642168e-01f, -1.68230563e-01f,
  -1.94725603e-01f, 1.79066524e-01f, 2.20537946e-01f, 1.37922898e-01f, 2.51361817e-01f, 1.50984988e-01f, 3.08382988e-01f, 2.51887947e-01f, 7.31928647e-02f, 7.67697453e-01f,
  8.38884175e-01f, -2.59255975e-01f, -1.26499400e-01f, -7.46622309e-02f, 3.41042072e-01f, -6.60611838e-02f, -5.80411591e-02f, 1.17646374e-01f, -1.93888962e-01f, 1.79310627e-02f,
  4.51485924e-02f, -2.63738967e-02f, 3.37137468e-02f, 4.55388352e-02f, -1.11253999e-01f, -1.17309928e-01f, 2.31470857e-02f, 1.69762801e-02f, -2.25462932e-02f, 1.23070002e-01f,
  -1.08290359e-01f, 7.92900100e-03f, -9.06686708e-02f, -2.83832908e-01f, -2.60340303e-01f, 1.66451326e-04f, 2.84279194e-02f, 1.21986695e-01f, -1.01759657e-01f, 1.77247986e-01f,
  -1.64890364e-01f, 4.12755124e-02f, 1.55528754e-01f, 5.52375168e-02f, 8.07595775e-02f, -1.03933856e-01f, 5.84614975e-03f, 1.06521156e-02f, 8.14728998e-03f, 9.11017805e-02f,
  -7.49581978e-02f, -5.12832925e-02f, -4.14664112e-02f, 4.33639437e-02f, 1.95133150e-01f, 7.15494901e-02f, 3.64745744e-02f, 5.21729104e-02f, 8.04261677e-03f, -4.04897630e-02f,
  2.53154151e-02f, 3.41586620e-02f, 1.65121943e-01f, 6.14270978e-02f, -6.99040741e-02f, -4.22983393e-02f, -1.47464633e-01f, -6.07848205e-02f, 1.08597100e-01f, -2.58860234e-02f,
  1.03107236e-01f, -2.84187317e-01f, 1.19282775e-01f, 3.00817434e-02f, 3.32238562e-02f, 1.01114787e-01f, 1.90125644e-01f, -5.50288297e-02f, -3.16304043e-02f, -2.39991341e-02f,
  -3.12002897e-02f, -2.67566796e-02f, 4.13460433e-02f, 1.46616220e-01f, -1.20686064e-03f, 7.35151842e-02f, -6.83965459e-02f, 3.46691422e-02f, -1.99931681e-01f, -7.87778050e-02f,
  -1.10350594e-01f, -2.63412714e-01f, -1.81293368e-01f, -1.54665351e-01f, -1.21533290e-01f, -1.76734239e-01f, 2.08417147e-01f, 8.70875418e-02f, -2.05334783e-01f, -2.91652560e-01f,
  8.18379581e-01f, -1.00015688e+00f, -3.45988981e-02f, 2.01149777e-01f, -9.62114334e-02f, -3.95335913e-01f, -1.47461724e+00f, -2.68064559e-01f, 3.44889760e-01f, -7.49142051e-01f,
  1.62955120e-01f, 9.03017938e-01f, 5.30535340e-01f, 5.82473218e-01f, -3.19589414e-02f, -1.14234650e+00f, -6.89718902e-01f, 4.99265015e-01f, 7.09026456e-01f, 1.44642085e-01f,
  -3.02372694e-01f, -1.83624804e-01f, 4.64434087e-01f, 3.18031281e-01f, -3.63824308e-01f, 2.56848276e-01f, -4.75643724e-01f, -1.25581965e-01f, -4.13108498e-01f, -6.39292717e-01f,
  -2.02738881e-01f, -3.86371389e-02f, 2.87336856e-01f, 3.51098597e-01f, 2.41228263e-03f, -2.49554142e-01f, -1.36063725e-01f, -6.36070296e-02f, -2.34154146e-02f, -3.82838473e-02f,
  2.78135777e-01f, 9.50675905e-02f, 2.45248184e-01f, -3.04735377e-02f, -7.99314827e-02f, -6.93925396e-02f, 1.29944772e-01f, 1.69277012e-01f, 3.88111100e-02f, -1.61896512e-01f,
  -1.49181515e-01f, 2.98750820e-03f, 2.42007524e-01f, -1.14768641e-02f, -8.10284726e-03f, 4.09096003e-01f, -2.41023049e-01f, 1.27480432e-01f, 1.39255617e-02f, -6.43734515e-01f,
  -3.00705694e-02f, -5.26361875e-02f, 6.93791881e-02f, 3.67054231e-02f, -1.04140386e-01f, 4.10949960e-02f, -5.93323968e-02f, -9.03621688e-02f, -1.87797216e-03f, -2.14135461e-02f,
  2.27258429e-02f, 5.89841753e-02f, 3.96569259e-02f, -1.11851543e-01f, 5.54411151e-02f, 7.06966296e-02f, -1.39877364e-01f, -3.28621790e-02f, 1.37047440e-01f, -6.05642013e-02f,
  1.06445082e-01f, 7.02818632e-02f, 2.20832136e-02f, 3.88738737e-02f, 1.22987321e-02f, 3.94661650e-02f, -2.93322597e-02f, 1.34402037e-01f, 5.77754080e-02f, -2.43676051e-01f,
  7.98021909e-03f, 2.38430008e-01f, -3.59984249e-01f, 2.14877278e-01f, -2.30749231e-02f, 1.18784599e-01f, -1.71475485e-01f, 1.62446007e-01f, 7.75987282e-02f, 3.62547450e-02f,
  1.85920298e-01f, -1.01408407e-01f, -1.25500094e-02f, 4.33348976e-02f, 6.37502456e-03f, -5.67590706e-02f, -5.16576953e-02f, 2.09743097e-01f, -1.13235243e-01f, -7.32636079e-03f,
  -1.68800205e-01f, -2.57622123e-01f, -4.72294800e-02f, -2.93496430e-01f, -2.59994585e-02f, 5.06748669e-02f, -5.37543774e-01f, -4.02381390e-01f, -9.57564171e-03f, -1.06429899e+00f,
  -4.15554643e-01f, 4.79704477e-02f, -1.23619154e-01f, 4.58498925e-01f, 4.67048854e-01f, 3.09232622e-01f, 2.99623728e-01f, 9.32828560e-02f, 3.21569443e-01f, 2.92645454e-01f,
  4.22293782e-01f, 5.59807122e-01f, 4.21809971e-01f, 2.98430204e-01f, 1.99129343e-01f, 2.31211171e-01f, 3.71589124e-01f, 8.94271117e-03f, -1.39439600e-02f, 2.30983898e-01f,
  3.76851410e-01f, 1.03985898e-01f, -2.04754010e-01f, 1.02562979e-01f, 2.02642575e-01f, 3.74404252e-01f, 2.11596698e-01f, 3.03853542e-01f, 2.84263462e-01f, 4.40917730e-01f,
  2.16991723e-01f, -1.13573126e-01f, 8.19303170e-02f, -2.11109431e-03f, -4.48642895e-02f, -2.74310946e-01f, -1.35976315e-01f, -1.87546983e-01f, -1.31759465e-01f, -5.96268587e-02f,
  6.47130469e-03f, -1.51823148e-01f, -2.80289426e-02f, -1.83435082e-02f, -2.33822316e-01f, -2.00220332e-01f, -1.11240312e-01f, 4.30935137e-02f, 1.53954417e-01f, 6.31130412e-02f,
  1.38934851e-01f, 1.42661616e-01f, -3.07689235e-02f, -4.39590998e-02f, 3.59388478e-02f, 1.13098755e-01f, -1.65839016e-01f, -1.55310944e-01f, -6.26864135e-02f, -1.00136101e-02f,
  2.98425406e-01f, -8.58298037e-04f, 1.65306449e-01f, 2.07057491e-01f, 5.19717559e-02f, -5.82329463e-03f, 2.05605756e-02f, 1.21262744e-01f, 1.98706761e-02f, -2.82613616e-02f,
  -2.85610161e-03f, 3.28969002e-01f, 3.09753604e-02f, 1.43323794e-01f, 8.28161836e-02f, 1.13100447e-01f, -1.42013669e-01f, 3.09696198e-02f, -3.63379940e-02f, -8.19283128e-02f,
  4.63975547e-03f, -6.62635714e-02f, -3.13137680e-01f, -1.82166472e-01f, -9.78507474e-02f, 3.14006135e-02f, 1.00731015e-01f, 6.35865629e-02f, -6.32171482e-02f, -8.97647962e-02f,
  4.91390556e-01f, -8.28627571e-02f, 1.38844907e-01f, 1.09077699e-01f, -3.73278856e-02f, -2.84078628e-01f, 4.04282585e-02f, -9.00127366e-02f, -9.60772708e-02f, -1.81246139e-02f,
  5.89547493e-02f, -2.32998639e-01f, -1.28380656e-01f, -5.84200621e-02f, -1.95791826e-01f, -1.14086099e-01f, -6.87140226e-02f, 2.51040846e-01f, 1.23361178e-01f, 1.29819373e-02f,
  5.73975183e-02f, 2.08968110e-02f, -1.61956891e-03f, -4.17912453e-02f, 3.25541496e-02f, 5.03055528e-02f, -1.12127490e-01f, -2.33395603e-02f, -1.70799389e-01f, -2.27638990e-01f,
  1.68009675e+00f, 8.18078220e-01f, 3.83029193e-01f, 2.72914395e-02f, -5.03105462e-01f, -1.08783409e-01f, 8.39383528e-02f, 3.20140898e-01f, 1.09706059e-01f, 2.64698327e-01f,
  1.13641769e-01f, 1.70098349e-01f, 1.33629665e-01f, 1.77735284e-01f, 2.01251552e-01f, 2.71984749e-02f, -2.07739353e-01f, 1.81736067e-01f, 1.60477415e-01f, 1.80328712e-02f,
  -2.62792617e-01f, 3.63607593e-02f, 2.72113442e-01f, 1.60105661e-01f, -1.31638825e-01f, -1.48387134e-01f, -1.48042858e-01f, -1.51735008e-01f, -2.02610046e-01f, -1.64589956e-01f,
  -3.75995159e-01f, 4.21971142e-01f, -1.91495448e-01f, -1.01261688e-02f, 4.29080687e-02f, 3.86234105e-01f, 5.37673347e-02f, 1.15701064e-01f, -6.32920861e-02f, -1.90191761e-01f,
  -3.36956531e-02f, 7.55074099e-02f, 5.53901009e-02f, -3.82746048e-02f, -1.11824158e-03f, -2.15781573e-02f, 1.20346420e-01f, 1.73045974e-02f, -6.96034804e-02f, 1.17016345e-01f,
  -6.65366724e-02f, -1.05853945e-01f, -1.46305546e-01f, -9.25895497e-02f, 3.59403007e-02f, 3.20629515e-02f, -1.03475088e-02f, 2.78163180e-02f, 4.32792902e-02f, 1.30532995e-01f,
  2.24699974e-01f, 3.03837597e-01f, 7.68378004e-02f, -1.59975052e-01f, 1.16599211e-02f, -2.36865059e-02f, -1.64552957e-01f, -1.76835313e-01f, 5.41969500e-02f, -1.45298112e-02f,
  -1.83365479e-01f, -2.83475667e-01f, -5.16945459e-02f, -8.67426097e-02f, 6.64996207e-02f, 1.18923448e-02f, 3.35533312e-03f, -1.84923261e-02f, -1.64637133e-01f, 2.10825726e-02f,
  -4.49695252e-02f, -4.90188338e-02f, 1.09336853e-01f, 1.49551956e-02f, -8.35660473e-02f, -1.10490672e-01f, -1.54600488e-02f, 1.15779586e-01f, 1.13359153e-01f, -3.94389741e-02f,
  -5.18084466e-01f, -8.52411520e-03f, -9.75408703e-02f, 1.75678641e-01f, 9.31506790e-03f, 2.79085428e-01f, 1.33252470e-02f, -1.61985815e-01f, -2.58971810e-01f, -1.24843746e-01f,
  -1.31101370e-01f, 1.69897050e-01f, 1.07764505e-01f, 7.19593540e-02f, -2.07626045e-01f, -1.31234586e-01f, 6.52932525e-02f, 6.97507337e-02f, 2.01498829e-02f, -4.90752682e-02f,
  1.86647162e-01f, -7.15071782e-02f, -5.66767063e-03f, -2.95484103e-02f, -8.69396180e-02f, -8.21768045e-02f, -1.21328637e-01f, -4.68732677e-02f, -1.43352775e-02f, -1.05986126e-01f,
  -9.80640113e-01f, 2.15391323e-01f, -1.13668895e+00f, -1.00775802e+00f, -8.95274282e-01f, -7.99448609e-01f, 5.12041077e-02f, -1.71496496e-02f, -4.32785392e-01f, 8.63080919e-02f,
  2.19927505e-01f, 2.40572646e-01f, 4.01847184e-01f, 9.47656929e-02f, 3.95380288e-01f, 1.24953188e-01f, -7.58305490e-01f, -8.27823639e-01f, -6.27915442e-01f, -2.96521604e-01f,
  -1.78482100e-01f, -5.08242667e-01f, -6.19385898e-01f, -3.60138685e-01f, -3.58637631e-01f, -1.90669686e-01f, -4.82883662e-01f, -7.62109280e-01f, -3.11855227e-01f, -5.09651124e-01f,
  1.49110198e-01f, -5.04241347e-01f, 4.45061550e-02f, 1.63474940e-02f, -5.75765967e-02f, -1.05621129e-01f, -1.26024485e-01f, 2.57448386e-03f, 8.84362310e-02f, -9.42857563e-02f,
  -1.32981420e-01f, -8.15310106e-02f, -1.44542322e-01f, 3.28585915e-02f, -9.63333920e-02f, -1.50210217e-01f, -1.21738864e-02f, 1.02365976e-02f, -4.80314419e-02f, 8.23518932e-02f,
  1.67191252e-02f, -6.11146279e-02f, 9.22961906e-02f, 2.01910868e-01f, -3.42798419e-03f, -5.47448210e-02f, -1.05687128e-02f, -9.56382900e-02f, -1.59968771e-02f, 1.66809514e-01f,
  1.11086942e-01f, 1.07653171e-01f, -7.24086389e-02f, -7.00009689e-02f, 8.65405053e-02f, 1.04452267e-01f, -1.68876603e-01f, 5.86540103e-02f, -5.99628054e-02f, 1.93341479e-01f,
  1.88238516e-01f, -1.98954538e-01f, -8.12903121e-02f, 1.31225392e-01f, -1.28162913e-02f, -1.00611918e-01f, 8.95266533e-02f, 1.39512822e-01f, -4.93599102e-02f, -7.66422004e-02f,
  -2.43348274e-02f, -3.32133938e-03f, -1.00019023e-01f, 7.09051788e-02f, -1.61156222e-01f, -1.00543216e-01f, -5.14136255e-02f, 5.04849590e-02f, 2.19601002e-02f, -9.59076136e-02f,
  6.45965815e-01f, -2.73588270e-01f, 3.14837515e-01f, 1.54569104e-01f, -1.78541720e-01f, -5.42679317e-02f, -3.01126182e-01f, -1.13770559e-01f, -1.39656737e-01f, -1.66149378e-01f,
  -2.69857585e-01f, -1.47905439e-01f, 8.90596956e-03f, 1.67892277e-01f, -3.53731103e-02f, -2.19681021e-02f, 1.12054773e-01f, 1.29340082e-01f, -1.25907689e-01f, -1.43591419e-01f,
  4.10889573e-02f, 3.62968296e-01f, 5.87808609e-01f, 3.50395173e-01f, -2.75095403e-02f, 1.35633349e-01f, 1.86038956e-01f, 8.50171521e-02f, 1.67746380e-01f, 4.31054682e-01f,
  7.77141154e-01f, 9.96547043e-02f, -2.73467481e-01f, 5.80162227e-01f, -2.30286524e-01f, -4.31278706e-01f, -3.44671488e-01f, -9.63305309e-03f, 2.90344834e-01f, 1.17643617e-01f,
  -3.02866101e-01f, 2.79620707e-01f, 2.50238389e-01f, 1.84566811e-01f, 9.57644135e-02f, 1.56365350e-01f, 2.55009443e-01f, 2.33696029e-01f, 2.47349530e-01f, 2.41076916e-01f,
  2.53235668e-01f, 3.54150116e-01f, 3.58233482e-01f, 2.90222883e-01f, 3.58478099e-01f, 3.62284809e-01f, -2.87769549e-02f, -1.31945282e-01f, -1.26114428e-01f, 5.13450623e-01f,
  7.46081322e-02f, -2.15257376e-01f, 2.82241427e-03f, -3.23073864e-02f, -1.80344373e-01f, 2.96617597e-01f, 2.77947307e-01f, 1.15959570e-01f, 3.48780975e-02f, 1.57393947e-01f,
  -1.56790778e-01f, -5.57589531e-02f, 1.41869813e-01f, 3.60067822e-02f, 1.84504513e-03f, -2.38132849e-01f, -1.99694112e-02f, 1.76398605e-01f, 1.85875595e-01f, -4.37951945e-02f,
  2.24774718e-01f, -1.78056866e-01f, -5.32145798e-01f, -3.58303964e-01f, -1.10760622e-01f, 5.40287048e-03f, -3.81284058e-01f, -7.41846440e-03f, -3.71130496e-01f, 3.02878976e-01f,
  8.62111896e-02f, -2.27614213e-02f, 3.46541293e-02f, 1.46439433e-01f, 3.91458929e-01f, 1.15222773e-02f, 1.41583920e-01f, 1.59281537e-01f, 8.32824707e-02f, 7.62697682e-03f,
  -6.33550575e-03f, 1.25897780e-01f, -4.23469543e-02f, -7.36056641e-02f, 9.04343873e-02f, -6.59813583e-02f, -1.46938264e-01f, 4.03831229e-02f, 9.46710184e-02f, -8.46999735e-02f,
  3.01219635e-02f, -4.04881053e-02f, -4.68999008e-03f, 6.95255958e-03f, -5.36246337e-02f, -2.86334958e-02f, 2.18042448e-01f, 3.89877744e-02f, 1.15179131e-02f, 7.74911195e-02f,
  -1.73166692e-01f, -5.64579308e-01f, 3.27502161e-01f, 4.70874123e-02f, -1.08309761e-01f, -1.59634873e-01f, -6.50719134e-03f, 3.21195312e-02f, -9.14173946e-02f, 1.89456567e-01f,
  -2.48333186e-01f, -5.18793501e-02f, -3.10288463e-02f, 4.48930962e-03f, 8.84975046e-02f, -8.39045420e-02f, -7.38058463e-02f, 3.17643546e-02f, -1.70998704e-02f, -1.47946641e-01f,
  1.35284197e-02f, -8.27664435e-02f, -1.53154016e-01f, -1.98312685e-01f, -1.40237734e-01f, 2.85802409e-02f, -3.32314849e-01f, -2.16071159e-01f, -3.76587272e-01f, 6.00246014e-04f,
  8.73699486e-01f, -6.34553432e-01f, 2.04502955e-01f, 2.88472444e-01f, 2.97340572e-01f, 1.44485399e-01f, -1.17185354e-01f, -5.68002500e-02f, 2.48231798e-01f, 3.60831022e-02f,
  1.61202159e-02f, 3.06679934e-01f, 2.95144945e-01f, 5.42506613e-02f, -3.29882167e-02f, -1.33862972e-01f, 1.36464089e-01f, 3.60121638e-01f, 2.79141873e-01f, 1.01634730e-02f,
  3.66651034e-03f, -5.05510904e-02f, -2.96113268e-02f, 2.33437843e-03f, -4.76042368e-02f, 1.89069822e-01f, -2.25325413e-02f, -7.47523904e-02f, -9.22403857e-02f, -2.26254880e-01f,
  -2.97691584e-01f, -1.37125447e-01f, 2.58414000e-01f, 2.76431683e-02f, -4.69074324e-02f, -9.20280665e-02f, 2.99359781e-05f, -1.67996675e-01f, -2.14794576e-01f, -1.52674496e-01f,
  -1.47977784e-01f, -3.00220773e-02f, -7.97716677e-02f, -4.69946824e-02f, -1.46601051e-01f, -1.01637140e-01f, -2.70468276e-03f, -5.41236177e-02f, -1.42406762e-01f, -4.03984226e-02f,
  3.07010692e-02f, 8.81564710e-03f, 4.24937718e-02f, 1.05729960e-01f, -2.19694059e-02f, 1.41452879e-01f, -3.77446637e-02f, 4.14398946e-02f, 1.09974131e-01f, -1.86013635e-02f,
  1.59813955e-01f, 1.72690570e-01f, 1.83441982e-01f, 9.07920972e-02f, 1.28594413e-01f, 9.68800038e-02f, 9.83665511e-02f, 7.62791699e-03f, 2.02624127e-01f, 6.89566182e-03f,
  9.26236808e-03f, 1.01138726e-01f, -1.07453307e-02f, 3.81839052e-02f, 1.65304184e-01f, 1.02431849e-01f, 5.40781999e-03f, -6.88489676e-02f, 1.72696970e-02f, 7.11257905e-02f,
  9.01780352e-02f, -2.31319331e-02f, -6.17865063e-02f, -2.44389161e-01f, -8.74531195e-02f, 8.81953612e-02f, 1.49427772e-01f, 1.09177700e-03f, -3.64794210e-02f, -9.55516025e-02f,
  -4.56855297e-01f, 5.65501869e-01f, 2.40672037e-01f, 3.17408168e-03f, -6.41067550e-02f, 5.99516695e-03f, 1.98774472e-01f, -1.54686436e-01f, -2.78319597e-01f, -2.21395373e-01f,
  -1.14544146e-01f, -5.08877784e-02f, -1.05533011e-01f, -1.23610713e-01f, 9.35834274e-02f, 1.37054533e-01f, -4.10695150e-02f, 4.58295308e-02f, -2.15216931e-02f, -1.69254661e-01f,
  -9.05950367e-02f, 2.42999747e-01f, 3.04840267e-01f, 2.56121397e-01f, 1.29709184e-01f, 3.07463259e-01f, 9.68495831e-02f, 5.49687780e-02f, 1.40593603e-01f, 5.57950549e-02f,
  -8.41199338e-01f, 5.76025546e-01f, -1.00097990e+00f, 5.03625929e-01f, 1.82141319e-01f, -3.79185587e-01f, 4.03619319e-01f, -4.82142530e-02f, 3.16418797e-01f, 4.94673818e-01f,
  1.33647561e-01f, -3.44532341e-01f, 1.20508879e-01f, -6.72655031e-02f, -4.12259579e-01f, 7.96508491e-01f, 7.47824013e-01f, -7.59625435e-01f, -9.98904943e-01f, -2.36988083e-01f,
  4.61496323e-01f, 1.77923009e-01f, -4.34706002e-01f, -3.11361760e-01f, 2.38020658e-01f, -3.21975946e-01f, 2.25303233e-01f, -2.34860443e-02f, -7.21687675e-02f, 3.22924912e-01f,
  -9.09212232e-01f, -4.83684123e-01f, -3.17803234e-01f, 1.13580942e-01f, -9.48724747e-02f, -1.57451794e-01f, -2.47212887e-01f, -2.41157189e-01f, 6.19139802e-03f, 2.26517305e-01f,
  1.09944977e-01f, -7.30913319e-03f, -1.20991297e-01f, -2.07794979e-01f, -2.66234912e-02f, -1.08467847e-01f, -2.70740744e-02f, -3.38386893e-01f, -4.44682628e-01f, -1.82590067e-01f,
  4.62062150e-01f, -4.33573067e-01f, -7.50218272e-01f, -1.67346224e-01f, -9.52794850e-02f, -2.59313017e-01f, -4.58206087e-01f, -9.13856447e-01f, -8.80290568e-01f, -3.23958814e-01f,
  -3.11172716e-02f, -3.96354832e-02f, 5.61219491e-02f, 8.76914859e-02f, 3.17040503e-01f, -1.07585594e-01f, -5.41683100e-03f, 6.24060491e-03f, 7.00002611e-02f, 6.08647019e-02f,
  -7.22812489e-02f, -1.03995092e-02f, -2.37768479e-02f, -5.44641800e-02f, 1.24140166e-01f, -5.02550602e-02f, -1.35575324e-01f, 1.94069222e-01f, -9.16974023e-02f, 1.90925688e-01f,
  -5.28145917e-02f, -2.33911518e-02f, 2.50748813e-01f, -1.08391993e-01f, 3.97155322e-02f, 5.34252338e-02f, -5.82478270e-02f, -7.98340067e-02f, -4.76490259e-02f, -1.75173637e-02f,
  4.14799333e-01f, -7.75573775e-02f, -1.64782807e-01f, 1.18974507e-01f, -1.78296387e-01f, -4.00622666e-04f, 3.04793399e-02f, 3.98408361e-02f, -7.11960495e-02f, -6.61870791e-03f,
  -1.29066840e-01f, 7.26757944e-03f, 1.16982728e-01f, 2.76774734e-01f, -2.17064291e-01f, -4.12680767e-02f, 5.42069077e-01f, -8.60778466e-02f, -9.39444378e-02f, 1.64648145e-01f,
  4.74063188e-01f, 2.03192830e-01f, -3.38571072e-02f, 8.17866921e-02f, 1.47766933e-01f, -2.37548813e-01f, -2.90149271e-01f, -8.03475603e-02f, -3.55720937e-01f, 5.59833288e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  7.86033392e-01f, 7.30966151e-01f, 4.55357999e-01f, 7.98817635e-01f, 4.26773399e-01f, 9.60211277e-01f, 1.19527781e+00f, 9.71354783e-01f, 2.16667056e-01f, 5.54444313e-01f,
  1.23411405e+00f, 8.88218760e-01f, 5.75269520e-01f, 1.34227335e+00f
};

// L1_linear_W (Shape: 12 x 64)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 64;
const float L1_linear_W_data[] = {
  -2.14791130e-02f, 2.09570490e-02f, -1.00622237e-01f, -1.63518652e-01f, 1.24851786e-01f, -5.81801720e-02f, 8.82803798e-02f, -1.11263216e-01f, -9.91135836e-02f, -7.24428654e-01f,
  -3.45412880e-01f, -2.65799105e-01f, 2.51772732e-01f, 7.15085492e-03f, -2.50502765e-01f, -4.85862233e-02f, -4.64732163e-02f, 1.52357712e-01f, -2.15763167e-01f, 2.76571482e-01f,
  -2.43093714e-01f, -1.11576289e-01f, -2.15855449e-01f, -3.21938805e-02f, -2.87186474e-01f, -4.87778217e-01f, -2.17596013e-02f, -1.41176194e-01f, -3.18373293e-01f, -2.02036992e-01f,
  5.75208925e-02f, -1.53893441e-01f, -5.29514253e-01f, -3.02489787e-01f, -7.72323285e-04f, 1.21285304e-01f, 8.44956100e-01f, -2.10780993e-01f, -2.56484270e-01f, -2.06560597e-01f,
  -4.35863048e-01f, -2.93819271e-02f, -2.12626874e-01f, 2.85950065e-01f, 2.33105108e-01f, 1.33109957e-01f, 8.36935267e-02f, -4.31486331e-02f, -2.03020409e-01f, 2.15207234e-01f,
  -3.90871674e-01f, -1.29962397e+00f, 6.31270826e-01f, -4.51410532e-01f, 4.18470293e-01f, -1.12455523e+00f, -8.52084756e-01f, 7.33071029e-01f, -8.01059961e-01f, 1.42533705e-01f,
  -6.18380159e-02f, -4.75047231e-02f, -1.10414839e+00f, -1.50689140e-01f, -6.60048649e-02f, -1.06971920e-01f, 1.03636049e-01f, -1.41730979e-01f, 9.70978141e-02f, 6.09910628e-03f,
  6.29119650e-02f, -1.57476425e-01f, -4.84601557e-02f, -3.46901193e-02f, -1.63006976e-01f, 1.15966260e-01f, 1.06494389e-01f, 3.59316885e-01f, -9.56232324e-02f, -2.40678191e-01f,
  -1.15853854e-01f, -1.41440138e-01f, -2.25926712e-01f, -4.69145514e-02f, 6.69232309e-02f, 6.63895309e-02f, -2.13371098e-01f, 1.98001161e-01f, 1.84861928e-01f, -2.17443869e-01f,
  -2.22989708e-01f, -1.81682095e-01f, 2.20615640e-01f, -3.45159918e-01f, -2.07519978e-01f, 1.79934055e-01f, -2.90505886e-01f, 8.13990738e-03f, 5.72839044e-02f, 3.09790552e-01f,
  -4.22208726e-01f, 2.20986098e-01f, 1.87795624e-01f, 9.84002650e-03f, -2.38351673e-01f, -1.12056628e-01f, -4.28187132e-01f, 7.62105808e-02f, -3.01837653e-01f, -2.30479240e-02f,
  -1.78265259e-01f, 2.51937155e-02f, 3.20004709e-02f, 3.93366784e-01f, 1.69426039e-01f, -5.55069506e-01f, 5.51396549e-01f, -5.58771044e-02f, -1.50974441e+00f, -9.58539248e-02f,
  -1.16803932e+00f, 1.18762887e+00f, -8.65538663e-04f, 6.33768588e-02f, 7.33858626e-03f, 3.24500442e-01f, 3.77308875e-01f, -1.70110798e+00f, 2.09646568e-01f, 2.55057588e-02f,
  1.74858257e-01f, 4.73952778e-02f, 4.25494537e-02f, -7.12265968e-02f, 5.72740920e-02f, 2.11761132e-01f, -1.05899125e-01f, 2.26829857e-01f, -2.43845787e-02f, -6.41439930e-02f,
  -1.16749249e-01f, 3.11312854e-01f, 3.41400318e-02f, -1.10832110e-01f, 2.75305331e-01f, -1.25591096e-03f, 5.21738864e-02f, 1.09745592e-01f, 2.01114610e-01f, 2.20287919e-01f,
  4.18219231e-02f, 1.73980668e-02f, 1.38561785e-01f, 1.46032870e-01f, -1.86609894e-01f, -8.00816342e-02f, -2.26865306e-01f, -1.46825790e-01f, 6.40688837e-01f, -5.41885376e-01f,
  1.81249589e-01f, 3.39127660e-01f, 2.04299197e-01f, 3.64328176e-01f, 6.60460815e-02f, -3.45553041e-01f, 3.51723313e-01f, 8.04171562e-02f, -7.04409957e-01f, -2.42647544e-01f,
  -7.70551115e-02f, -1.69314116e-01f, 4.49688956e-02f, 7.08864555e-02f, 7.94877335e-02f, 2.65699029e-01f, -7.03900218e-01f, 1.76122040e-01f, 3.05094738e-02f, -3.40632021e-01f,
  2.85137087e-01f, -9.70279157e-01f, -1.22220588e+00f, -9.24650788e-01f, 5.19389570e-01f, 1.25581610e+00f, -8.40107977e-01f, 1.79079145e-01f, -1.41241777e+00f, 1.21388687e-02f,
  3.31796080e-01f, -3.27952117e-01f, -1.34990931e-01f, 2.09718525e-01f, -3.72396231e-01f, 1.44336388e-01f, 1.40052419e-02f, -1.14481844e-01f, 2.51605421e-01f, 8.25209543e-02f,
  1.14727996e-01f, -6.42840922e-01f, 4.37035948e-01f, 2.87649632e-01f, -4.85715389e-01f, -1.06316769e+00f, 1.32467613e-01f, 1.48412973e-01f, 2.74290796e-02f, -1.95262462e-01f,
  9.05857086e-02f, -5.15014827e-01f, -7.74989426e-01f, -1.53297722e-01f, 1.59397855e-01f, -3.06799829e-01f, 4.63862240e-01f, 1.30203676e+00f, 2.27914471e-02f, -4.12055194e-01f,
  -2.19743788e-01f, 6.72561349e-03f, 1.18837857e+00f, -7.93420434e-01f, 5.73229611e-01f, -1.88266739e-01f, -4.56818700e-01f, -4.53373641e-02f, -7.64643669e-01f, -4.93783318e-02f,
  -2.32091192e-02f, 1.89367816e-01f, -8.61984566e-02f, -2.39581391e-01f, 8.23938251e-01f, -6.02486432e-01f, 3.94216835e-01f, 3.28073382e-01f, 3.01873863e-01f, 4.76040632e-01f,
  -1.03150778e-01f, -8.97659719e-01f, -4.18228477e-01f, -1.62938666e+00f, -1.70985609e-01f, -1.32680237e-01f, 4.29182261e-01f, 4.27668154e-01f, -7.84790277e-01f, -1.31600058e+00f,
  -8.43393207e-01f, -1.03251386e+00f, 4.48395759e-01f, -4.34370935e-01f, 2.48141155e-01f, 5.08678854e-01f, 1.47844017e-01f, -2.78266191e-01f, 5.21255359e-02f, -1.48941383e-01f,
  -4.88503963e-01f, 1.56166494e-01f, 2.68125366e-02f, 2.35960081e-01f, -1.13367975e-01f, 7.50828624e-01f, -8.34221318e-02f, 7.03139883e-03f, -4.91753429e-01f, 5.81642330e-01f,
  -1.03770509e-01f, 6.39019301e-03f, -4.23795253e-01f, -4.77040857e-02f, 6.59474880e-02f, -2.80024558e-01f, -1.31090447e-01f, 1.32018074e-01f, -8.10728744e-02f, -9.04488489e-02f,
  1.02433398e-01f, -2.73483425e-01f, 3.32060367e-01f, 1.07881524e-01f, -3.27797979e-01f, -2.90706307e-02f, -2.60730207e-01f, 2.26501167e-01f, 5.64896941e-01f, -1.84586033e-01f,
  -8.79613757e-02f, 2.51161128e-01f, -3.26900423e-01f, -3.33849877e-01f, -4.50984776e-01f, 1.73302680e-01f, 6.92788243e-01f, 1.19339392e-01f, 5.41069321e-02f, 6.77642878e-03f,
  2.69194871e-01f, 4.61743087e-01f, 8.10809731e-02f, 2.96608508e-01f, -1.45313472e-01f, 3.82263660e-01f, -5.96055329e-01f, 1.04967761e+00f, -9.93286252e-01f, -3.15534472e-01f,
  2.75258780e-01f, -5.14056325e-01f, 6.72309324e-02f, -2.53685832e-01f, 1.63208351e-01f, 2.07569197e-01f, 1.18919283e-01f, -1.42938089e+00f, 1.50760205e-03f, -2.32852418e-02f,
  -3.69353622e-01f, 7.18104765e-02f, 1.55331135e-01f, 4.43038374e-01f, 4.28835958e-01f, -2.38884374e-01f, -6.57203281e-03f, -2.54738897e-01f, -1.05304182e-01f, 4.15408164e-01f,
  -9.58597288e-02f, 3.59217636e-02f, 1.73115164e-01f, 7.87114128e-02f, 2.36885950e-01f, 8.90493169e-02f, -6.67403713e-02f, 2.67155200e-01f, -2.58201808e-01f, 3.97077084e-01f,
  4.22412515e-01f, 1.47418827e-01f, 2.65731484e-01f, 6.39185682e-02f, 4.08598959e-01f, -3.64690542e-01f, -3.12540054e-01f, -5.33040613e-02f, 1.00472122e-01f, -1.72875941e-01f,
  -5.57639539e-01f, 4.31679815e-01f, -5.65088749e-01f, -1.77512407e-01f, 1.60854738e-02f, 2.03003228e-01f, 3.66306931e-01f, 5.41789472e-01f, 5.94575942e-01f, 2.59925604e-01f,
  -1.25442401e-01f, -1.41866907e-01f, -3.88494045e-01f, 3.07500869e-01f, -6.29096985e-01f, -3.29303324e-01f, 1.71838641e-01f, 2.62000293e-01f, 4.17433202e-01f, 3.40534508e-01f,
  3.27534676e-01f, 6.63485229e-01f, -3.16853136e-01f, -4.08428386e-02f, -4.66030687e-01f, -1.31936574e+00f, -1.32787848e+00f, -1.58238983e+00f, -8.75353813e-02f, 1.47351578e-01f,
  3.63858670e-01f, 4.51152205e-01f, -6.26514256e-01f, 8.55539262e-01f, 1.32540867e-01f, -5.06592952e-02f, -1.93238139e-01f, -3.66395265e-02f, -1.88305199e-01f, -1.77206204e-03f,
  -8.86798948e-02f, -9.14842114e-02f, 2.53994405e-01f, -2.49694750e-01f, -1.19932160e-01f, -2.40850344e-01f, -9.27713662e-02f, -2.81811208e-01f, 2.89162192e-02f, 9.89384055e-02f,
  -2.19366878e-01f, 2.16796890e-01f, 1.22865215e-01f, 1.38730273e-01f, 3.78849953e-02f, -1.58800423e-01f, 2.50169367e-01f, 3.06359981e-03f, 5.16726486e-02f, -5.57464838e-01f,
  -4.13239628e-01f, 2.73394167e-01f, -1.98946521e-02f, 6.25528336e-01f, 3.56729180e-01f, 1.01227775e-01f, 2.38510922e-01f, -8.90342370e-02f, 1.85430899e-01f, 4.42779005e-01f,
  -1.58839285e-01f, 4.24792796e-01f, 2.55357146e-01f, -4.23332006e-01f, 3.17459792e-01f, 2.89101869e-01f, 9.87730846e-02f, -1.96748957e-01f, -1.99097041e-02f, -1.80571511e-01f,
  -2.47443199e-01f, 2.17097551e-01f, 3.04775778e-02f, 3.72236937e-01f, -7.06977069e-01f, 8.95697713e-01f, -8.24925005e-01f, -4.90384609e-01f, -1.57531774e+00f, 2.26571813e-01f,
  5.14138937e-01f, -4.97934878e-01f, -2.92181194e-01f, 5.28186262e-01f, -9.04313266e-01f, 4.89770442e-01f, -9.20006931e-01f, -1.39399064e+00f, -2.95859903e-01f, -1.55240029e-01f,
  -4.84633371e-02f, -4.35327560e-01f, 1.52422115e-01f, 1.25090718e-01f, -1.49649620e-01f, -8.30735895e-04f, -2.85324097e-01f, 1.80352300e-01f, -1.05846278e-01f, -1.92538261e-01f,
  -1.21740378e-01f, 2.51119226e-01f, -1.60754651e-01f, -1.64797857e-01f, -6.16271906e-02f, -1.65744662e-01f, -2.46434480e-01f, 1.55894607e-02f, -2.92999893e-01f, 1.21195376e-01f,
  -1.63456395e-01f, -1.26156984e-02f, 2.93020364e-02f, 1.24009341e-01f, 4.01991725e-01f, -2.26060033e-01f, -2.35323489e-01f, 1.25497207e-01f, 1.58364654e-01f, -1.20164394e-01f,
  2.18069226e-01f, 1.46733373e-01f, -1.10809557e-01f, 3.74792516e-03f, 3.86783928e-01f, -1.40959769e-01f, -8.11732486e-02f, -2.14728899e-03f, 3.00712019e-01f, -8.21874738e-02f,
  2.95385480e-01f, -2.85548326e-02f, -2.25034237e-04f, 2.87155002e-01f, 1.32719632e-02f, -1.89158633e-01f, 2.42310196e-01f, -6.72417581e-02f, -2.17906088e-01f, -4.19511855e-01f,
  -4.73228127e-01f, -8.30289364e-01f, -9.01699215e-02f, 1.79327466e-02f, -6.62824869e-01f, -1.38313460e+00f, 5.96364558e-01f, -5.79147875e-01f, -1.24151540e+00f, -2.38153413e-01f,
  -1.44863233e-01f, 1.26865005e+00f, 3.60741317e-01f, 1.43530279e-01f, 9.59557071e-02f, -1.32694557e-01f, -4.01402086e-01f, 2.84733593e-01f, 1.19161427e-01f, 1.14301503e-01f,
  6.27893955e-02f, 4.23032969e-01f, 1.91022904e-04f, 2.33529598e-01f, -3.05432737e-01f, 2.25781903e-01f, -8.79918784e-02f, 2.43697986e-01f, 1.19120650e-01f, 2.15493500e-01f,
  2.32321277e-01f, 1.15113676e-01f, 5.15693836e-02f, 2.79210210e-01f, -2.10854381e-01f, 1.85406074e-01f, -2.62780875e-01f, -1.66506216e-01f, -4.41639721e-01f, -1.12326935e-01f,
  1.74576029e-01f, 5.88887155e-01f, -1.95653006e-01f, -3.06650639e-01f, -4.07854319e-01f, 1.97132543e-01f, -9.42736268e-02f, -3.05493355e-01f, 3.86915617e-02f, 3.43244880e-01f,
  -2.18075261e-01f, -1.30731106e-01f, 9.55960155e-02f, 2.59820998e-01f, 1.73590288e-01f, 5.38451448e-02f, -3.95315915e-01f, -6.10437930e-01f, -8.11462291e-03f, -1.45395368e-01f,
  1.70591533e-01f, -6.20071828e-01f, 1.03589213e+00f, -1.22202945e+00f, -5.53258240e-01f, 5.64488113e-01f, -4.77967560e-01f, -3.85594189e-01f, -2.99100187e-02f, -1.16447937e+00f,
  -3.11102241e-01f, -9.64273095e-01f, -6.45742238e-01f, -2.08991826e-01f, 3.79711032e-01f, -6.00032687e-01f, -2.74121970e-01f, 7.49966055e-02f, -3.08213413e-01f, -3.68401915e-01f,
  5.10515153e-01f, -1.28415488e-02f, -3.81534934e-01f, -3.62741947e-02f, -6.67200536e-02f, -3.58420551e-01f, 4.97974195e-02f, 2.53581349e-02f, 4.35135067e-02f, -8.51754785e-01f,
  1.62530884e-01f, 5.93422055e-02f, 2.21778736e-01f, -3.85987237e-02f, 6.93356842e-02f, 2.49630392e-01f, 1.25009045e-01f, -1.42374694e-01f, -4.28516865e-01f, 2.80794770e-01f,
  -4.21808153e-01f, 5.51077604e-01f, 5.29645264e-01f, 4.92945850e-01f, -2.22751901e-01f, -4.27673638e-01f, -9.33853865e-01f, 3.75698537e-01f, 1.46816686e-01f, 1.77207813e-01f,
  5.21211922e-01f, -8.01834345e-01f, 2.25689337e-01f, -3.54481459e-01f, 4.36451972e-01f, 3.58956754e-01f, 1.34673528e-03f, 5.33258542e-02f, -2.91468829e-01f, 3.26004833e-01f,
  1.71466976e-01f, -8.70690588e-03f, -4.06069666e-01f, -4.02290016e-01f, 4.79635507e-01f, 3.30778927e-01f, -3.81251693e-01f, 8.83279070e-02f, -4.67271030e-01f, -7.75169075e-01f,
  8.09400380e-01f, 2.55858898e-02f, 6.66080534e-01f, 1.51660115e-01f, 1.55726830e-02f, -6.71381652e-01f, -1.94958961e+00f, 2.17810452e-01f, 2.00095773e-01f, -2.05083624e-01f,
  4.23439950e-01f, 1.16036639e-01f, 1.68506682e-01f, 1.02769278e-01f, 6.71686828e-02f, 2.15255335e-01f, -9.82155129e-02f, 9.49975103e-02f, 9.39090401e-02f, 1.56030014e-01f,
  -1.72380377e-02f, -3.07648927e-01f, 2.78989822e-01f, -1.90542608e-01f, 3.34526956e-01f, 2.33227864e-01f, 1.19407520e-01f, 2.40562647e-03f, 2.98579752e-01f, 2.10348055e-01f,
  3.84312540e-01f, -2.90682465e-01f, 1.98951036e-01f, 1.21320061e-01f, -4.79110897e-01f, -1.85877625e-02f, 2.88991541e-01f, 8.32146704e-02f, 2.78672248e-01f, -4.62157845e-01f,
  -6.12664372e-02f, 2.79102266e-01f, -3.01863045e-01f, 1.77661359e-01f, -3.42528015e-01f, -4.98994023e-01f, -4.87994313e-01f, -7.43676350e-02f, -6.29261136e-01f, -4.23715234e-01f,
  -1.22465335e-01f, -4.97665823e-01f, -5.29105306e-01f, -3.47939819e-01f, -5.12671590e-01f, -4.21535134e-01f, 3.91687602e-01f, -7.75252640e-01f, -2.06669345e-01f, -5.34320533e-01f,
  -1.65252119e-01f, -1.19590640e+00f, 1.39802501e-01f, -7.52298057e-01f, -8.69081497e-01f, -4.48584229e-01f, 7.71651685e-01f, -1.23748326e+00f, -1.83124114e-02f, -1.03515124e+00f,
  6.60551310e-01f, -2.42097661e-01f, -6.15130126e-01f, -6.79066777e-01f, 1.76490366e-01f, -2.27843374e-02f, 1.35016255e-02f, 9.98901501e-02f, -5.75343557e-02f, 8.40596929e-02f,
  1.99728087e-01f, -4.09657657e-02f, 1.30258888e-01f, 7.10331500e-02f, -2.87923235e-02f, 2.00121582e-01f, 1.75895646e-01f, 3.73010367e-01f, 4.21064496e-02f, -3.77655029e-01f,
  1.51837319e-01f, -2.71384805e-01f, 5.11193462e-02f, -1.73149943e-01f, -3.57450694e-02f, -1.05606414e-01f, -3.90486717e-02f, 9.87577066e-02f, 1.30169868e-01f, 3.04947674e-01f,
  -4.30994153e-01f, 3.70169580e-01f, 2.40904793e-01f, 2.85340577e-01f, 3.04740608e-01f, 2.63999015e-01f, 1.94119021e-01f, -2.59009778e-01f, 2.04939410e-01f, -1.99124858e-01f,
  -2.49267414e-01f, -1.15343533e-01f, -3.57411474e-01f, -3.38145979e-02f, 2.74897844e-01f, -1.22929931e-01f, 3.87948364e-01f, -2.63255835e-01f, 6.07426941e-01f, 2.18601916e-02f,
  -1.77654803e-01f, -2.48042569e-01f, 1.57157183e-01f, 1.79933265e-01f, -6.11997247e-01f, 2.47517303e-01f, -6.78801909e-02f, 9.42576349e-01f, -1.19970687e-01f, 9.98060167e-01f,
  -8.69514108e-01f, -6.62197530e-01f, -3.15962195e-01f, 2.01023351e-02f, -7.62085557e-01f, -8.24283183e-01f, -7.18134224e-01f, -8.03197563e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -2.79180948e-02f, -5.93480825e-01f, 5.94568290e-02f, 3.98854166e-02f, 1.67562813e-01f, 1.22169249e-01f, -1.50452331e-01f, 2.51386702e-01f, -4.84079458e-02f, 3.03967088e-01f,
  -2.64291137e-01f, -8.18957239e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 25, 14
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        64, 12
    );
    }
    