/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 19 x 120)
const int L0_fan_Wp_rows = 19;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  1.32627666e-01f, -3.34431887e-01f, -2.05745935e-01f, -1.41456932e-01f, 3.69173914e-01f, 3.87485981e-01f, 3.47478092e-02f, 4.38053571e-02f, -2.78284013e-01f, -1.75194532e-01f,
  2.29969963e-01f, -2.49631241e-01f, -1.47674009e-01f, 9.58581492e-02f, 2.17728555e-01f, -3.69420469e-01f, 1.38857350e-01f, 3.47385146e-02f, -3.60594019e-02f, 1.70285121e-01f,
  2.65629049e-02f, 3.16515326e-01f, 8.59275460e-02f, 2.04338238e-01f, 1.26957104e-01f, -2.38335095e-02f, 1.98280632e-01f, -1.65688097e-02f, 2.26337552e-01f, -3.56440842e-02f,
  3.86792608e-02f, -5.80761814e-03f, -9.63194221e-02f, -7.94636384e-02f, 1.57540441e-01f, 7.41018802e-02f, -2.84880977e-02f, -6.96901930e-03f, 2.93079447e-02f, 2.03318968e-02f,
  -5.04192300e-02f, 8.04928467e-02f, -2.82433424e-02f, -2.83848420e-02f, 3.82282585e-02f, -9.32726562e-02f, 4.75870520e-02f, 2.30876151e-02f, -7.67387673e-02f, -1.35331312e-02f,
  -2.30806116e-02f, -1.87817384e-02f, 4.80156615e-02f, -2.24131458e-02f, 5.55047393e-02f, 1.57037023e-02f, -2.71311961e-02f, 5.49930241e-03f, -1.21407993e-01f, 2.42014248e-02f,
  6.87115118e-02f, 1.53656676e-02f, 8.17834213e-02f, -7.43689761e-02f, 3.29923853e-02f, -3.95683013e-03f, 2.36180071e-02f, 3.54648903e-02f, -7.56639391e-02f, -7.54378317e-03f,
  5.97130693e-02f, -1.97956115e-02f, -4.69030663e-02f, 7.06581771e-02f, 6.05692379e-02f, -6.53928444e-02f, -2.97064185e-02f, -4.40850249e-03f, 8.83079097e-02f, -1.41670713e-02f,
  -4.54707779e-02f, 4.49865125e-02f, 3.13211828e-02f, 2.41995137e-02f, -3.49300504e-02f, 4.75742444e-02f, -3.61658186e-02f, -5.97524904e-02f, -1.48099931e-02f, 5.19154556e-02f,
  1.22731902e-01f, -3.03385090e-02f, -1.02286808e-01f, 7.60456622e-02f, -1.47169083e-01f, -2.47477349e-02f, -1.46962956e-01f, 2.79670805e-02f, -8.21841788e-03f, 1.63866188e-02f,
  1.55454367e-01f, -3.82786281e-02f, -1.62577387e-02f, 5.62658869e-02f, 2.61817500e-02f, 4.56079245e-02f, -3.06383036e-02f, -6.62557706e-02f, -1.29014561e-02f, 1.21014617e-01f,
  6.01157397e-02f, 1.09158076e-01f, -5.06193601e-02f, 8.34731981e-02f, 9.01692286e-02f, 3.46856341e-02f, 2.54533952e-03f, 4.47117686e-02f, 7.19697550e-02f, -1.11825161e-01f,
  -6.01978064e-01f, 4.89602357e-01f, -2.31134921e-01f, -1.48816019e-01f, 4.00614962e-02f, -3.48417833e-03f, -8.66768882e-02f, 1.77976772e-01f, -3.01856905e-01f, 4.60200280e-01f,
  2.03438833e-01f, 1.97037850e-02f, 7.02426881e-02f, 2.24038363e-01f, -4.37832296e-01f, -1.35794565e-01f, -6.98198751e-02f, 5.97276399e-03f, -1.59827337e-01f, 3.76078039e-02f,
  -1.75985485e-01f, 6.41164929e-02f, -1.97962821e-02f, 1.02314688e-01f, 1.31919786e-01f, 2.32279697e-03f, 8.50683823e-02f, 8.88690539e-03f, 2.62278944e-01f, 7.81117901e-02f,
  6.89306855e-02f, 5.38003631e-03f, 6.24670740e-03f, -2.23546606e-02f, 7.54062459e-03f, 1.23697482e-01f, 5.19158207e-02f, 9.64512862e-03f, -6.25796570e-03f, 1.02265589e-02f,
  -2.70350892e-02f, 5.91343418e-02f, -5.26385196e-03f, -9.75435451e-02f, 9.23721958e-03f, 2.33070273e-02f, 7.62028098e-02f, 1.97740123e-02f, 2.44562048e-02f, 4.28776741e-02f,
  1.15731638e-03f, 7.85832927e-02f, -8.42528604e-03f, 1.03425749e-01f, -1.03433289e-01f, -2.21411232e-02f, 3.73830013e-02f, 1.69039443e-02f, -2.62704957e-02f, 1.65484976e-02f,
  3.95781873e-03f, -7.49093220e-02f, -2.52928361e-02f, 4.43400554e-02f, -1.22028375e-02f, 3.85102108e-02f, 2.81242258e-03f, 1.05441757e-01f, -6.75126091e-02f, 8.84267166e-02f,
  -4.24083509e-03f, -1.12835551e-02f, 4.39872872e-03f, 1.90581698e-02f, 8.68770257e-02f, -2.38973554e-03f, -6.93670809e-02f, 9.52637643e-02f, -1.15875483e-01f, 3.79288420e-02f,
  2.27696244e-02f, -3.36328894e-02f, 4.08634879e-02f, 8.92022811e-03f, -2.55490653e-02f, -9.60501283e-02f, 4.38996144e-02f, 4.44893651e-02f, 7.57229999e-02f, -1.26813129e-02f,
  1.20172903e-01f, 5.13457768e-02f, 1.07435430e-04f, 7.08460137e-02f, -7.15895509e-03f, 9.78851598e-03f, -3.47477011e-02f, 3.21378708e-02f, -2.78662797e-02f, -1.66097730e-02f,
  5.23502706e-03f, -2.31304741e-03f, 1.20396875e-02f, -2.07578447e-02f, -6.89550415e-02f, 3.38164568e-02f, -1.69064535e-03f, 3.86825688e-02f, -7.65361190e-02f, 5.11932075e-02f,
  2.80293506e-02f, 9.90542695e-02f, -7.34672742e-03f, -3.09449304e-02f, 1.11239199e-02f, 6.73032179e-02f, -2.46439762e-02f, -5.32249101e-02f, 4.32252921e-02f, -3.80332619e-02f,
  -3.32508087e-01f, 1.45051926e-01f, 1.57415081e-04f, -2.21827831e-02f, 1.72219157e-01f, 3.70966971e-01f, -1.15537472e-01f, 1.38061896e-01f, -8.85753483e-02f, 8.46884027e-02f,
  8.47150758e-02f, -1.37601122e-01f, -2.64452338e-01f, 2.17509568e-01f, -1.48163140e-01f, -1.51467785e-01f, 2.12725282e-01f, 1.01311363e-01f, -1.06187493e-01f, 3.17092836e-02f,
  -7.79685676e-02f, 9.73645449e-02f, -3.89333963e-02f, 1.07949823e-01f, 1.13168418e-01f, -3.70147638e-02f, -2.66600102e-02f, -2.08925560e-01f, 2.54313082e-01f, 1.02489605e-03f,
  7.98793882e-02f, -5.72771952e-02f, 8.17581266e-02f, -4.68651243e-02f, 1.18750893e-01f, -8.01330525e-03f, 5.50687946e-02f, -9.41521004e-02f, -5.56321666e-02f, -6.11022897e-02f,
  -4.33268063e-02f, -1.01741262e-01f, 1.51951436e-03f, -2.63334904e-02f, 1.22671165e-02f, 7.47106150e-02f, 3.39278989e-02f, 1.39383718e-01f, 2.30264440e-02f, -4.92085051e-03f,
  1.80108417e-02f, 8.50018929e-04f, 1.04546368e-01f, 3.26190181e-02f, -2.00491101e-02f, 1.08093033e-02f, 2.21875496e-02f, 5.49432971e-02f, 1.17021143e-01f, 8.32545832e-02f,
  -5.59093431e-02f, -1.52706429e-02f, 2.42312234e-02f, 1.76553708e-02f, -1.58275478e-02f, -2.66239736e-02f, -8.33902285e-02f, 8.53364170e-03f, -2.84268502e-02f, 5.74107766e-02f,
  -3.19322268e-03f, 4.53001000e-02f, -9.94522795e-02f, 1.71561390e-02f, 5.82834780e-02f, -2.21901853e-02f, -3.80489323e-03f, -8.82764980e-02f, 5.37471436e-02f, 3.82253639e-02f,
  -1.20434575e-01f, 2.44775955e-02f, -5.72111383e-02f, 3.17986496e-02f, 2.22827196e-02f, -1.28834769e-02f, 2.60003898e-02f, -2.05989908e-02f, 8.26812238e-02f, -2.31621582e-02f,
  1.87478259e-01f, -2.74701659e-02f, -1.08450092e-01f, 1.66337397e-02f, -5.51923970e-03f, 2.39391308e-02f, 3.29780169e-02f, 5.23771197e-02f, -2.50221342e-02f, 2.48579886e-02f,
  6.29475638e-02f, 3.47424410e-02f, 4.79271524e-02f, -1.06326798e-02f, 1.29231149e-02f, 9.28170308e-02f, -1.04607731e-01f, -4.64088283e-02f, 1.38796316e-02f, 3.30359526e-02f,
  -2.53555216e-02f, -8.68658721e-02f, -5.75412530e-03f, 1.10004500e-01f, 6.00289442e-02f, -1.49284760e-02f, 2.92541888e-02f, -1.19883325e-02f, -1.07464373e-01f, -3.28080691e-02f,
  5.04701018e-01f, -8.26283768e-02f, -2.12646767e-01f, -4.08451781e-02f, 3.31146896e-01f, 3.13186914e-01f, 6.80843659e-04f, 1.56688020e-01f, 3.41867864e-01f, -2.75491506e-01f,
  -8.11241418e-02f, -8.72039199e-02f, -3.77484635e-02f, -1.04841158e-01f, 4.36802059e-01f, 5.42652467e-03f, -3.55222225e-02f, -1.09821916e-01f, 1.02759473e-01f, 2.05129273e-02f,
  1.36224478e-01f, 1.37709126e-01f, -1.39157176e-01f, 1.68840624e-02f, 7.57447779e-02f, -1.32144615e-01f, -1.34705275e-01f, -9.14640948e-02f, -1.15710437e-01f, 1.06779680e-01f,
  5.66208400e-02f, 8.04263949e-02f, -6.68730401e-03f, -1.29595413e-04f, -2.26376262e-02f, 4.21486935e-03f, -2.74990452e-04f, -1.72145461e-04f, -1.87727008e-02f, 3.92651465e-03f,
  -3.67130525e-02f, 1.20124951e-01f, 6.12995103e-02f, -3.73853855e-02f, 7.88852572e-02f, 1.33604817e-02f, 1.74192429e-01f, -6.10121945e-03f, -1.27209909e-02f, 3.60438973e-02f,
  7.25815967e-02f, 3.79213206e-02f, -1.25230430e-02f, -7.02202246e-02f, 6.83908118e-03f, -2.41537485e-02f, 1.47430040e-02f, -7.18618976e-03f, 5.11678234e-02f, 9.03519243e-02f,
  9.30836722e-02f, -4.19873111e-02f, -1.06064633e-01f, 5.58662321e-03f, 9.94710326e-02f, 1.36457169e-02f, -6.37133121e-02f, 2.38002073e-02f, -3.45490919e-03f, 9.47141275e-03f,
  -6.17306400e-03f, -4.28625382e-02f, 5.34846336e-02f, 3.43892984e-02f, -1.64953414e-02f, -1.11003555e-02f, -9.25996527e-02f, -2.57506892e-02f, 5.76773565e-03f, -6.13053609e-03f,
  2.96427123e-02f, 5.38704060e-02f, 1.53939556e-02f, -6.48995414e-02f, 1.89959742e-02f, 4.37440947e-02f, -7.53420368e-02f, -7.30498880e-02f, -2.74676848e-02f, -8.29981118e-02f,
  1.00835867e-01f, -1.45321235e-01f, -6.93087354e-02f, 7.93140307e-02f, -8.06057081e-02f, 7.49317138e-03f, 1.86029971e-02f, 5.95733300e-02f, 4.85657714e-03f, 3.16297839e-04f,
  -7.70029193e-03f, -1.04060665e-01f, -2.56746658e-04f, 7.00011058e-03f, 3.35643701e-02f, 2.83068996e-02f, -6.08641058e-02f, -5.07389903e-02f, -2.83522643e-02f, -2.88558546e-02f,
  -7.45184049e-02f, 1.80226900e-02f, -1.19798286e-02f, 1.47110634e-02f, -5.55091612e-02f, -3.81507725e-02f, -8.44048802e-03f, 5.63261099e-02f, 2.88716219e-02f, -1.13490177e-03f,
  9.67547446e-02f, -3.74408662e-02f, 2.25148425e-01f, 1.42174959e-01f, -9.05274451e-02f, 6.10391051e-02f, 7.81190768e-02f, 1.22965880e-01f, 7.29201511e-02f, -1.80600941e-01f,
  -2.42503174e-02f, -1.91821888e-01f, 4.08789106e-02f, 2.04050437e-01f, 3.77884567e-01f, 1.47115305e-01f, 1.82769999e-01f, -1.16204359e-01f, 6.59945533e-02f, -1.28534678e-02f,
  9.71099734e-02f, -6.61677420e-02f, 3.26996237e-01f, -4.69382554e-02f, 7.74658695e-02f, -2.87252720e-02f, -6.49785101e-02f, 2.40529906e-02f, -2.03408916e-02f, -3.09662521e-02f,
  -2.67434530e-02f, 7.13309795e-02f, 2.69097611e-02f, 1.94098577e-02f, 9.82989818e-02f, -1.78422946e-02f, -2.81010829e-02f, 7.39069283e-02f, 5.82756475e-02f, 7.80565590e-02f,
  -1.24335006e-01f, 5.37027530e-02f, 3.42611782e-02f, -5.80974147e-02f, 6.99276626e-02f, 8.59718248e-02f, 1.74263436e-02f, 9.20875221e-02f, 4.57704514e-02f, 1.25564560e-01f,
  1.10414967e-01f, 1.14204675e-01f, 7.93811679e-02f, 8.11977778e-03f, 1.38205001e-02f, 6.41975105e-02f, 2.97648869e-02f, -2.67973519e-03f, -3.69437225e-02f, 9.69821513e-02f,
  4.98340949e-02f, -4.40372759e-03f, 4.65303485e-04f, -1.52606172e-02f, -4.13539708e-02f, 4.75128321e-03f, -5.42613864e-02f, -4.50899415e-02f, -1.33666033e-02f, -4.47157957e-02f,
  -5.55201881e-02f, -8.02813321e-02f, -1.10443393e-02f, -3.25978920e-03f, -1.21135591e-02f, -1.60887949e-02f, -5.50032593e-02f, -7.84813985e-02f, 6.15849458e-02f, 1.20779388e-02f,
  -3.16577591e-02f, 2.92524006e-02f, 7.69443111e-03f, -6.03658240e-03f, 1.98888429e-03f, -1.16569279e-02f, 6.67848960e-02f, 2.98498832e-02f, -5.72621915e-03f, -6.48310855e-02f,
  -2.74136841e-01f, -1.79243267e-01f, -2.31153052e-02f, -5.68511747e-02f, -9.79155488e-03f, -2.32861135e-02f, 3.63764656e-03f, -3.65625434e-02f, -4.79964726e-03f, -1.37311436e-04f,
  -1.39509467e-02f, -1.91005394e-02f, -2.50346530e-02f, -4.53235991e-02f, -6.17351662e-03f, -4.23868932e-02f, -2.92820428e-02f, -7.05844834e-02f, -1.55397788e-01f, 6.44554757e-03f,
  -8.45092013e-02f, -4.93111871e-02f, 7.29029998e-02f, 4.69830725e-03f, -6.03953376e-02f, -5.31017371e-02f, -6.31764531e-02f, 2.24565491e-02f, -3.87231670e-02f, 2.50941725e-04f,
  -1.03471003e-01f, 4.02449876e-01f, -2.49757364e-01f, 9.01124328e-02f, -1.10990442e-02f, 4.83021766e-01f, 8.20690393e-02f, 6.92329258e-02f, 7.62946010e-02f, 2.19484866e-01f,
  1.33612799e-02f, 2.25181624e-01f, -9.96406823e-02f, 3.74774933e-01f, 1.62953421e-01f, 2.03159347e-01f, 3.34359020e-01f, 1.76964313e-01f, 2.17836816e-02f, 8.90152678e-02f,
  8.44180062e-02f, 1.34360671e-01f, -5.54643758e-02f, 9.90536064e-02f, -3.40804234e-02f, -1.36464849e-01f, -2.42698401e-01f, -1.54694512e-01f, 4.94474806e-02f, 2.15403829e-02f,
  9.84610175e-04f, -1.73861891e-01f, -6.02833033e-02f, -3.23243886e-02f, -7.06074983e-02f, -1.02946267e-01f, -3.11583243e-02f, -7.09524378e-02f, -4.97510098e-02f, 6.62001371e-02f,
  4.16462906e-02f, 6.00811690e-02f, 5.82480840e-02f, -9.41215269e-03f, 1.49528841e-02f, -2.84256153e-02f, 5.58795482e-02f, -1.46771604e-02f, 7.48310834e-02f, -2.23435611e-02f,
  9.47036073e-02f, 5.75729534e-02f, 1.19745575e-01f, 1.13802351e-01f, -3.77137505e-04f, 5.43936156e-02f, -3.48087922e-02f, -1.31044025e-02f, 1.05204493e-01f, 1.77780315e-02f,
  5.35805188e-02f, -7.39212381e-03f, -6.42131492e-02f, -6.16376661e-02f, -6.47392273e-02f, -1.24892443e-01f, 6.63646534e-02f, -2.49973070e-02f, -5.35366908e-02f, 3.30990404e-02f,
  5.47075793e-02f, -5.32872342e-02f, 1.18832011e-02f, 2.56094360e-03f, -6.22642599e-03f, -4.79901657e-02f, 2.80111060e-02f, 8.81680055e-04f, 3.19827013e-02f, -1.53042963e-02f,
  -1.13879643e-01f, 1.28055081e-01f, 1.94851868e-03f, 1.81996729e-02f, 3.47519889e-02f, -6.15671240e-02f, 7.03754369e-03f, 1.68932509e-02f, -6.24279231e-02f, -1.05468724e-02f,
  1.47519797e-01f, 3.83740030e-02f, -3.98902223e-02f, 7.42059052e-02f, -8.49697459e-03f, 5.72106987e-03f, -4.84754005e-03f, 1.05117438e-02f, 5.08853830e-02f, -9.72124040e-02f,
  2.57380977e-02f, -7.35373423e-02f, 2.86156908e-02f, 2.25042067e-02f, -1.53013959e-03f, 4.97135967e-02f, -1.95577592e-02f, -2.61126906e-02f, 6.50817826e-02f, -1.53783942e-02f,
  -1.09642096e-01f, -2.14593671e-03f, 3.10592297e-02f, -7.57471398e-02f, -2.73190346e-02f, -6.41259830e-03f, 1.43819610e-02f, -2.54160501e-02f, 1.31807867e-02f, 9.27760676e-02f,
  -3.80316794e-01f, 1.78787127e-01f, -1.46892607e-01f, -6.51910380e-02f, -1.73245490e-01f, 4.09514368e-01f, 7.98455626e-02f, -1.23429537e-01f, -3.06513101e-01f, 1.26314282e-01f,
  1.78520847e-02f, 5.17700277e-02f, 2.59633437e-02f, 2.45727777e-01f, 3.02058607e-01f, 2.03926414e-01f, 3.38826597e-01f, 1.84270367e-01f, -6.49209775e-04f, 6.43045604e-02f,
  -1.36176236e-02f, 2.83215284e-01f, 9.08410996e-02f, 5.09243011e-02f, -1.30830094e-01f, -1.32244125e-01f, 1.28700528e-02f, -8.03894103e-02f, 1.42200187e-01f, 1.22099996e-01f,
  9.31146517e-02f, -2.56335229e-01f, -2.20591992e-01f, -1.35984458e-02f, -3.81087512e-02f, -8.44118819e-02f, 1.49567407e-02f, 2.07784376e-03f, -2.65796464e-02f, 2.49655750e-02f,
  -5.56644648e-02f, -6.14962280e-02f, 7.20164105e-02f, 7.91881531e-02f, -9.83138680e-02f, -5.27163930e-02f, -4.89738360e-02f, -1.08266342e-02f, -6.10555336e-02f, -6.46229237e-02f,
  -3.27197462e-02f, 8.16653222e-02f, 6.56349584e-02f, 5.19334562e-02f, -3.00996061e-02f, -7.14287013e-02f, 4.24020402e-02f, -1.11826332e-02f, 3.10379453e-02f, -4.88910638e-02f,
  -1.55640561e-02f, 3.07674911e-02f, 5.37527204e-02f, 4.56844643e-02f, 3.49960662e-02f, -8.98829252e-02f, 1.46842226e-01f, 4.70826216e-02f, -6.74709082e-02f, -6.21391879e-03f,
  -5.16114011e-02f, -5.62506877e-02f, -9.66747850e-02f, -3.90737988e-02f, 2.32943688e-02f, -1.28803328e-02f, 8.90606046e-02f, -3.41766048e-03f, -5.46132140e-02f, -2.10052393e-02f,
  1.08741259e-03f, -7.97279552e-03f, 1.80608109e-02f, 2.15160884e-02f, 9.90774333e-02f, 1.25829028e-02f, -6.12296872e-02f, -7.31864721e-02f, -6.19275682e-02f, 1.01317272e-01f,
  3.37882996e-01f, 1.09729759e-01f, -4.34622839e-02f, 7.43446648e-02f, 3.98749039e-02f, 2.20602471e-03f, -3.19619551e-02f, -1.17861442e-02f, 9.45616513e-02f, -6.29296303e-02f,
  -4.50000949e-02f, 5.83371846e-03f, 7.28893280e-02f, -2.10553017e-02f, 1.29124552e-01f, -2.02923380e-02f, 4.61915024e-02f, -1.14030698e-02f, 4.21998426e-02f, 3.11678946e-02f,
  3.34117226e-02f, 6.98260171e-03f, 9.34630912e-03f, -1.58376545e-02f, 1.52696697e-02f, -2.30481877e-04f, 3.90089452e-02f, -2.19785664e-02f, 5.58940992e-02f, 3.75799239e-02f,
  -6.23967052e-01f, 2.42494747e-01f, 5.01245586e-03f, -2.65165895e-01f, -5.18086646e-03f, -2.52601445e-01f, -3.95040482e-01f, 5.35599515e-02f, -1.02584951e-01f, 1.02386974e-01f,
  5.70690744e-02f, -2.03692421e-01f, 1.96018428e-01f, -7.04622567e-02f, -2.41138116e-01f, 2.26965576e-01f, -1.43578112e-01f, -2.08892703e-01f, -3.27857099e-02f, 1.31520759e-02f,
  -6.23340569e-02f, 2.77155172e-02f, 1.84036903e-02f, 2.61300355e-01f, -1.72887519e-01f, -1.11577585e-02f, 2.06005231e-01f, 1.48615167e-02f, -2.90268492e-02f, -1.49776950e-01f,
  -7.06549510e-02f, 6.35996535e-02f, -7.12204874e-02f, 5.69490008e-02f, 3.57765704e-02f, -7.94270486e-02f, -1.12342514e-01f, -1.20046847e-01f, -5.00944592e-02f, -2.30464470e-02f,
  -4.02727760e-02f, 1.56297758e-02f, -7.84353241e-02f, 2.24659499e-03f, -5.10857776e-02f, -1.68892480e-02f, -1.75333805e-02f, -4.85925972e-02f, 1.29020866e-02f, 9.60095320e-03f,
  -7.00513367e-03f, -8.24140161e-02f, 2.17160136e-02f, -4.73405272e-02f, -3.17276567e-02f, -1.95711423e-02f, 7.39957765e-03f, -3.86235416e-02f, 3.58485430e-03f, -4.25956808e-02f,
  2.45030820e-02f, 3.60695980e-02f, -4.12379159e-03f, 9.93889570e-03f, 6.89964890e-02f, -1.04819834e-02f, -9.03060511e-02f, -2.02213395e-02f, -5.28870896e-02f, -1.49212964e-03f,
  1.28949871e-02f, -3.75648253e-02f, 3.46638225e-02f, -1.98190361e-02f, -3.24964076e-02f, -6.28387704e-02f, -1.69450641e-02f, 7.19022676e-02f, -3.34562659e-02f, -4.06526811e-02f,
  -2.49056146e-02f, -7.03573553e-03f, -6.07282743e-02f, -5.43052182e-02f, 2.87136016e-03f, -7.27677625e-03f, 1.10124692e-01f, -1.46913147e-02f, 1.53671612e-03f, -4.35894951e-02f,
  1.49719819e-01f, 3.20529580e-01f, 3.29380855e-02f, -7.72383139e-02f, -4.97550070e-02f, -5.16391061e-02f, 4.92262580e-02f, -2.54742173e-03f, 7.35067762e-03f, -3.26849446e-02f,
  4.00608107e-02f, -9.72297862e-02f, 8.13087076e-02f, -4.03489545e-02f, -5.68245389e-02f, 1.25491098e-01f, 1.86123624e-02f, -6.12273952e-03f, 1.95710594e-03f, 2.48124357e-04f,
  1.81656610e-02f, -4.24335338e-02f, -9.68329310e-02f, -3.97668108e-02f, -3.07597443e-02f, -1.96473300e-02f, 8.04339256e-03f, 4.24554348e-02f, 6.63616806e-02f, 4.64775078e-02f,
  -5.12587309e-01f, 2.67769426e-01f, -3.99264693e-01f, 1.17714472e-01f, -1.43769095e-02f, -2.49097962e-02f, 1.85782090e-02f, 1.59229934e-01f, 9.62516814e-02f, 3.30986649e-01f,
  1.75188854e-01f, -6.44624606e-02f, 7.85020217e-02f, 3.08807552e-01f, -1.31230548e-01f, 6.47725537e-02f, 1.77580357e-01f, 1.33087680e-01f, -9.14815255e-03f, 1.65619195e-01f,
  -1.02871686e-01f, 3.87239963e-01f, -1.46102577e-01f, 2.26877406e-01f, -3.20593528e-02f, -1.01428479e-01f, 6.54559731e-02f, -7.03800693e-02f, 1.15105189e-01f, 3.46335955e-02f,
  -1.15545198e-01f, 7.46662393e-02f, -1.29183549e-02f, -7.35672414e-02f, -3.93127576e-02f, -5.49407750e-02f, -7.31180832e-02f, -5.41692507e-03f, -7.18442425e-02f, -1.63630135e-02f,
  -1.06844809e-02f, 1.38867320e-02f, 1.01012684e-01f, 4.96155471e-02f, -1.46594802e-02f, -4.74949703e-02f, -5.66469394e-02f, -1.06845841e-01f, 1.00231424e-01f, -1.36880770e-01f,
  -2.19669361e-02f, -1.37325704e-01f, -1.01982914e-01f, 3.44086625e-02f, -8.39916617e-02f, 1.66580100e-02f, -2.61100847e-02f, -7.89865628e-02f, -3.20360549e-02f, 1.45378849e-02f,
  1.94421057e-02f, -1.00518204e-02f, -1.70202162e-02f, -3.36868614e-02f, 4.54719812e-02f, -2.16871817e-02f, 7.67563432e-02f, 7.93581270e-03f, -6.41242489e-02f, 4.67098989e-02f,
  1.10883871e-02f, 1.04057752e-02f, 2.42149886e-02f, 5.14179643e-04f, 3.57239670e-03f, -3.22568417e-02f, -6.32353202e-02f, 2.63035372e-02f, -3.43069136e-02f, -2.81689465e-02f,
  -2.80477535e-02f, 3.11682746e-02f, 4.73757423e-02f, -3.74617130e-02f, 4.63372320e-02f, -3.00240871e-02f, 3.50996442e-02f, -4.91250530e-02f, -9.09270719e-04f, -3.02769653e-02f,
  2.08895549e-01f, 3.06971610e-01f, 4.31547463e-02f, 6.71541318e-02f, 5.80156296e-02f, -3.26926634e-02f, 1.54236574e-02f, 4.02365625e-02f, 1.68672688e-02f, 7.31770322e-02f,
  -3.57804336e-02f, 8.48788861e-03f, -8.52666497e-02f, -2.91006640e-02f, 6.22147657e-02f, 4.97156009e-02f, 7.90143386e-02f, 2.89890673e-02f, 6.81961700e-02f, 2.92615816e-02f,
  1.65123085e-03f, 3.03748753e-02f, -1.35201048e-02f, 2.29657926e-02f, 7.05937892e-02f, -6.16376773e-02f, 8.05790629e-03f, -3.99119742e-02f, -7.18212547e-03f, 9.11087245e-02f,
  6.75071418e-01f, -1.53431788e-01f, -2.12734449e-03f, 2.91443408e-01f, 2.31770471e-01f, 1.00552794e-02f, 1.03564240e-01f, -3.64088602e-02f, 1.02090448e-01f, -3.30682278e-01f,
  1.14046648e-01f, 7.28397965e-02f, -6.09556362e-02f, 1.84056275e-02f, 4.58340377e-01f, -6.42424747e-02f, 1.25127986e-01f, 6.55168993e-03f, -3.58699746e-02f, 1.54510774e-02f,
  1.57540128e-01f, 3.17113362e-02f, 9.70391333e-02f, -1.71871990e-01f, 1.62272096e-01f, -4.84635830e-02f, -1.92413349e-02f, -1.04706354e-01f, -2.68355738e-02f, 8.27855989e-02f,
  -7.34548969e-03f, 1.88398082e-02f, 8.50413553e-03f, -7.80150667e-02f, 7.40256906e-02f, 3.20358165e-02f, 3.61345592e-03f, 1.85439624e-02f, 3.84769402e-02f, 8.84886272e-03f,
  5.53157926e-03f, 1.30645279e-03f, -3.53857800e-02f, 6.23183651e-03f, 8.97276625e-02f, -1.14220884e-02f, 9.50101484e-03f, 8.43394250e-02f, -2.95862686e-02f, 1.12646684e-01f,
  1.19317481e-02f, 1.33710280e-02f, 7.63058215e-02f, -1.88114513e-02f, 5.15155345e-02f, -2.17960849e-02f, 6.92654168e-03f, 3.95478755e-02f, 3.16432789e-02f, 7.87206888e-02f,
  2.67298277e-02f, -1.89988092e-02f, 7.67788617e-03f, -6.62095193e-03f, 9.48981941e-03f, -4.95940074e-03f, 1.44727826e-02f, -3.45681682e-02f, 2.67780144e-02f, -8.93600937e-03f,
  -5.66972932e-03f, 2.03982890e-02f, 4.94777504e-03f, 4.19854335e-02f, 2.54434086e-02f, -7.59859802e-03f, -4.21442371e-03f, -3.61103714e-02f, 7.32255355e-02f, 2.49278359e-02f,
  -7.67112570e-03f, -6.24566944e-03f, -2.84725949e-02f, -3.08921374e-02f, -2.77886856e-02f, 7.03886077e-02f, 1.35961724e-02f, 6.08840361e-02f, -1.62017010e-02f, 5.48144691e-02f,
  -3.32050654e-03f, -2.11862147e-01f, -7.78727680e-02f, -5.60154989e-02f, -7.00633824e-02f, 5.49259596e-02f, 1.51766120e-02f, 9.99563094e-03f, -5.14661260e-02f, -2.84709129e-02f,
  -4.27111797e-03f, -2.49050111e-02f, -3.16199213e-02f, 5.60801961e-02f, -2.18546242e-02f, -1.10052703e-02f, -6.32621199e-02f, -3.54532227e-02f, 5.80189563e-03f, -8.36212561e-03f,
  -2.09398698e-02f, 2.94206422e-02f, 1.41886957e-02f, -2.79648248e-02f, -3.65651376e-03f, -3.73758487e-02f, 5.92399985e-02f, -1.67596340e-02f, 2.66315043e-02f, -5.10590263e-02f,
  2.30915666e-01f, 2.94132084e-01f, 1.61551297e-01f, 2.64955193e-01f, -1.01573579e-01f, -2.33798593e-01f, -2.86354572e-01f, 6.76535144e-02f, 4.73743379e-01f, -1.42379673e-02f,
  -2.42044121e-01f, 2.41429105e-01f, -2.16593612e-02f, -1.67426124e-01f, -2.42143139e-01f, -1.58359632e-01f, -2.03693047e-01f, -1.31800815e-01f, 4.12659459e-02f, 5.12857642e-03f,
  -1.53638180e-02f, -3.12554061e-01f, -1.76226839e-01f, -1.56171277e-01f, -5.83776133e-03f, 1.59666821e-01f, -4.16781604e-02f, -1.03032321e-01f, -1.61075026e-01f, -1.75883517e-01f,
  -1.46760121e-01f, 1.40167266e-01f, 2.84463335e-02f, 1.40253101e-02f, -5.26918247e-02f, -7.85302669e-02f, -1.47589654e-01f, -1.63329437e-01f, -5.21629080e-02f, -8.54853690e-02f,
  1.90386586e-02f, -1.84816308e-02f, 2.58076400e-03f, -5.05870301e-03f, 2.53337454e-02f, 6.18824735e-02f, 3.22982594e-02f, -1.54806813e-02f, 5.33042662e-02f, -8.88406113e-03f,
  6.02039695e-02f, 3.06221005e-02f, -1.33114476e-02f, -8.05501491e-02f, 8.12388607e-04f, 2.63455119e-02f, -6.88200537e-03f, -5.30876778e-02f, -3.42062563e-02f, 8.84961784e-02f,
  -5.79812080e-02f, -8.53931624e-03f, -1.29638687e-02f, -2.90086791e-02f, -3.79527546e-02f, -4.41028811e-02f, -1.90289952e-02f, -8.19247141e-02f, 2.04127971e-02f, -2.47062948e-02f,
  2.48315372e-03f, -5.13410792e-02f, -1.91033520e-02f, 1.09969946e-02f, 1.45146940e-02f, 9.10620540e-02f, -3.22128274e-02f, -7.40100592e-02f, 4.04013321e-02f, -3.06755546e-02f,
  -3.82090965e-03f, -4.04638574e-02f, 6.36357144e-02f, -2.77201664e-02f, -4.17820998e-02f, 1.26983719e-02f, 6.34114146e-02f, 3.43431830e-02f, 1.29805906e-02f, -5.06254807e-02f,
  9.20656994e-02f, 1.88847274e-01f, 3.73101868e-02f, -1.16205141e-02f, 1.28006842e-02f, 3.05524431e-02f, 3.56451944e-02f, 3.44405286e-02f, 4.46479656e-02f, -4.53905948e-02f,
  -7.95551389e-02f, -1.04036145e-02f, 4.96485308e-02f, -6.68828785e-02f, -2.65184324e-02f, 4.49833348e-02f, -3.52890007e-02f, 3.02191009e-03f, -5.41781336e-02f, 2.88212541e-02f,
  2.91614998e-02f, -7.19927847e-02f, -3.77256423e-02f, -2.64275931e-02f, -1.91532671e-02f, 9.55795683e-03f, 8.35594982e-02f, 1.05937742e-01f, -5.57029732e-02f, 2.89266221e-02f,
  4.52948540e-01f, 1.80853661e-02f, -1.98247910e-01f, 3.17771077e-01f, -1.84401479e-02f, 1.07494593e-01f, 5.93141839e-03f, 9.73072425e-02f, 1.88790113e-01f, 7.74690062e-02f,
  1.97466016e-01f, -1.13128111e-01f, -3.35994840e-01f, 3.76146972e-01f, -1.07219972e-01f, -2.08662108e-01f, 3.21127653e-01f, 1.87137976e-01f, 5.96476682e-02f, 2.09294092e-02f,
  4.31226082e-02f, 2.94788748e-01f, -1.23032175e-01f, 1.02173142e-01f, 1.83387086e-01f, -3.01191583e-02f, -9.83317420e-02f, -1.42137811e-01f, 1.64036393e-01f, 1.86144821e-02f,
  1.41816780e-01f, 2.95849144e-02f, 2.45053768e-02f, -2.30565872e-02f, 3.60915698e-02f, 3.37398201e-02f, -1.95415877e-02f, -8.28400701e-02f, -6.50027618e-02f, -2.14287452e-03f,
  -5.51149212e-02f, 2.84597371e-02f, 6.74892291e-02f, -3.90587114e-02f, 1.88628033e-01f, 5.74469827e-02f, 4.17032093e-02f, 8.54276121e-02f, -3.76665429e-03f, -6.25282852e-03f,
  5.95535599e-02f, 3.26965414e-02f, 8.80985782e-02f, -1.49357561e-02f, -7.44592920e-02f, 3.48733775e-02f, 5.60870348e-03f, -5.84554598e-02f, 2.44572163e-02f, 9.95801464e-02f,
  7.42174394e-04f, 1.88082438e-02f, -3.71881239e-02f, 2.90588364e-02f, 3.89952883e-02f, -4.67025489e-03f, -5.80299366e-03f, 1.13404393e-02f, 5.97821025e-04f, -1.49703715e-02f,
  4.88662161e-02f, 6.62111565e-02f, 1.31050527e-01f, 3.56828794e-02f, 5.79819120e-02f, 2.54900772e-02f, -8.97943676e-02f, 3.54775460e-03f, 1.44147128e-02f, 9.79400240e-03f,
  -6.41976818e-02f, 6.20556017e-03f, -3.18320580e-02f, 2.22756080e-02f, 9.84872952e-02f, -6.40890226e-02f, 9.86579061e-02f, -7.53692910e-02f, -1.45207914e-02f, -3.23003195e-02f,
  -9.88155007e-02f, -2.12555692e-01f, -1.05034657e-01f, -4.37118905e-03f, -1.07859612e-01f, -2.11378094e-02f, 1.59580838e-02f, 6.29332149e-03f, -2.35987063e-02f, 9.10869800e-03f,
  3.85233685e-02f, 3.21137048e-02f, -1.70843247e-02f, 3.68294306e-02f, -6.88838884e-02f, -4.06807885e-02f, -8.26206282e-02f, -5.91275021e-02f, -1.43126631e-02f, 4.84826043e-02f,
  -3.93274464e-02f, -7.16797635e-02f, -4.14524488e-02f, 4.98961620e-02f, 2.13124380e-02f, -6.07763827e-02f, 1.10410608e-01f, 1.47683416e-02f, -6.66218773e-02f, -1.20710861e-02f,
  4.41316754e-01f, -8.01483989e-02f, 4.15588059e-02f, 3.58761221e-01f, -5.81120625e-02f, 1.64576769e-01f, 2.71153361e-01f, -1.77658215e-01f, 1.43896952e-01f, 1.45937838e-02f,
  1.87648878e-01f, 2.16124207e-01f, -1.52012572e-01f, 4.40152168e-01f, 7.25251511e-02f, -9.34000164e-02f, 4.49583977e-01f, 3.14327002e-01f, -1.64820358e-01f, 2.89829612e-01f,
  3.74746360e-02f, 1.12901337e-01f, 2.96797650e-03f, -2.93962479e-01f, 1.08587645e-01f, -1.45057619e-01f, -5.90239912e-02f, -2.70387828e-01f, 1.24813460e-01f, -1.06076337e-01f,
  3.54635939e-02f, 5.47199100e-02f, 2.94773914e-02f, -1.12533413e-01f, 2.60046199e-02f, 4.40901928e-02f, 9.25222859e-02f, -7.08244070e-02f, 5.55834826e-03f, 9.11372621e-03f,
  2.68115271e-02f, -1.55368634e-02f, 2.68202778e-02f, -9.25079808e-02f, -3.95377316e-02f, 6.10595383e-03f, 3.99398543e-02f, 4.47949134e-02f, -5.67222796e-02f, 2.10710224e-02f,
  6.85534999e-02f, 4.12504897e-02f, 9.97635722e-02f, 1.00373467e-02f, 3.50856371e-02f, 6.36207461e-02f, 7.14085847e-02f, 6.04893267e-02f, 4.48105764e-03f, -2.38775909e-02f,
  -2.41922755e-02f, -4.12848480e-02f, -1.09524708e-02f, -1.01054296e-01f, -3.54907401e-02f, 3.36631089e-02f, 4.37973216e-02f, 3.33016180e-02f, -3.00388243e-02f, 6.04287013e-02f,
  -5.01365820e-03f, -8.88122059e-03f, -4.15518880e-02f, 1.12732239e-02f, 8.18421617e-02f, 2.03584973e-02f, 4.27861102e-02f, -1.34078774e-03f, -1.76975213e-03f, -2.42131725e-02f,
  3.39268241e-03f, 2.60595549e-02f, -8.46170336e-02f, -8.74605328e-02f, -1.53805362e-02f, -6.49218112e-02f, -6.48749853e-03f, 7.37770423e-02f, -1.93838943e-02f, 2.19409652e-02f,
  3.84965166e-02f, -3.40104997e-02f, -5.65697066e-02f, -1.95497330e-02f, 3.06363553e-02f, 3.18095982e-02f, 9.46737081e-02f, -1.73180588e-02f, -6.04856089e-02f, -9.84363928e-02f,
  5.92182204e-02f, 6.85513541e-02f, -9.37237311e-03f, 3.66036780e-02f, 7.35112205e-02f, -3.79978754e-02f, 1.26585782e-01f, 5.32335229e-02f, 5.29537387e-02f, -8.70325193e-02f,
  1.28002940e-02f, -9.87839978e-03f, 4.48191538e-02f, -3.63742374e-02f, 5.32896817e-02f, 3.25186327e-02f, 1.39624598e-02f, -2.53177690e-03f, -6.44219667e-03f, 4.86953221e-02f,
  -6.59346282e-02f, -4.88097459e-01f, 2.77406186e-01f, 1.55776995e-03f, 1.20799430e-01f, 2.61142731e-01f, 1.12639576e-01f, 6.10249192e-02f, 6.00279532e-02f, -2.55196750e-01f,
  -1.40818089e-01f, -2.29901239e-01f, -1.80203453e-01f, -6.74371645e-02f, 2.82106549e-01f, 6.87312111e-02f, 1.70614794e-01f, -2.53907475e-03f, 2.53767986e-02f, -8.08003843e-02f,
  1.86798405e-02f, -1.09913439e-01f, 1.10439047e-01f, -9.77100208e-02f, -4.36407514e-02f, -1.24855535e-02f, -8.61544833e-02f, 5.49241565e-02f, 2.27432400e-02f, 5.39249815e-02f,
  2.64904313e-02f, -1.50438905e-01f, -4.48982604e-02f, -6.49470314e-02f, 5.22193424e-02f, -2.21179449e-03f, 1.17947385e-02f, 5.34409024e-02f, -3.67947109e-03f, -2.29012556e-02f,
  -4.13691066e-02f, 5.52317649e-02f, 2.15829257e-02f, -1.01189048e-03f, -2.28647329e-02f, -1.19999729e-01f, 5.24728186e-02f, 8.19372758e-02f, -8.61460343e-02f, 8.17367285e-02f,
  1.16420649e-02f, 9.08277929e-02f, 7.48890592e-03f, -6.64069578e-02f, 2.77355313e-02f, 1.81929991e-02f, 1.10771656e-01f, 7.97215700e-02f, 2.16117855e-02f, 1.03688829e-01f,
  -1.12841241e-02f, 5.74078709e-02f, 3.07284649e-02f, 6.08593132e-03f, -3.89233269e-02f, -6.20567463e-02f, -7.01590162e-03f, -2.01755073e-02f, -5.35524086e-05f, -2.86260583e-02f,
  6.13811128e-02f, -4.43554781e-02f, 4.75432537e-02f, 6.71012625e-02f, 6.96386211e-03f, 3.06729190e-02f, -7.54535012e-03f, 6.69516400e-02f, 2.19231080e-02f, 6.50672764e-02f,
  -3.34602059e-03f, -1.03891985e-02f, -9.19222385e-02f, 4.53504473e-02f, -1.17226364e-02f, -1.59231909e-02f, -5.56905679e-02f, 6.52003139e-02f, -3.30515876e-02f, 7.51710534e-02f,
  -1.74879447e-01f, -1.87550649e-01f, -8.19267780e-02f, -1.24138333e-01f, -1.79553609e-02f, 3.35179530e-02f, 9.78594571e-02f, -4.59062755e-02f, -8.74086991e-02f, -3.26169692e-02f,
  3.78149673e-02f, -3.15175578e-02f, -1.98488194e-03f, 7.42075741e-02f, -4.61688032e-03f, -7.34141888e-03f, -3.52679640e-02f, -7.71219209e-02f, -3.08851581e-02f, -9.56354588e-02f,
  2.07089577e-02f, -4.86389175e-02f, 7.25977197e-02f, -3.29925604e-02f, 1.28151691e-02f, -4.65394668e-02f, -9.51632485e-02f, 8.31663311e-02f, 5.31097576e-02f, -1.71070062e-02f,
  -2.37230524e-01f, 2.68745542e-01f, 6.88315332e-02f, -3.95203568e-02f, 1.17562525e-01f, -1.74823835e-01f, -1.12180851e-01f, 1.58992529e-01f, 9.75861177e-02f, 8.10863376e-02f,
  -1.34775296e-01f, -1.04188276e-02f, -2.89780404e-02f, -1.43743962e-01f, -4.61150467e-01f, -1.80520430e-01f, -3.11149448e-01f, -2.15350896e-01f, -2.26355288e-02f, 4.66252714e-02f,
  -4.00054790e-02f, -4.23987536e-03f, 2.12002685e-03f, 3.26295495e-01f, 1.91506431e-01f, 2.04346061e-01f, -5.20575270e-02f, 2.14746445e-01f, 3.15219201e-02f, -1.26557887e-01f,
  9.86432075e-04f, 8.75934288e-02f, 7.98521265e-02f, 3.20262499e-02f, -1.08817317e-01f, -3.75621542e-02f, -5.11664711e-02f, -1.41592196e-03f, 1.41070792e-02f, 2.47445889e-02f,
  -4.32049483e-02f, -8.18163231e-02f, -1.53805932e-03f, 1.10180294e-02f, 6.13775402e-02f, 3.40517797e-02f, 8.34124163e-03f, -2.16982476e-02f, 9.10074338e-02f, -4.47939225e-02f,
  5.02394997e-02f, -9.54479650e-02f, -7.68068209e-02f, -1.07456148e-01f, -1.98860057e-02f, -1.87944807e-02f, -3.74996662e-02f, -4.27901261e-02f, -4.77445126e-02f, -3.02752573e-02f,
  -1.29985988e-01f, -3.26376073e-02f, 2.40262672e-02f, 2.00671591e-02f, 5.52354120e-02f, -3.43928710e-02f, 4.67513390e-02f, -2.83926576e-02f, 5.78712523e-02f, 2.86764977e-03f,
  -1.36565964e-03f, 4.92812842e-02f, -1.59341330e-03f, -7.40040606e-03f, -5.21855541e-02f, 3.64301614e-02f, -2.46022232e-02f, -4.83196042e-02f, 4.51162681e-02f, -3.48396003e-02f,
  6.81221634e-02f, -5.89983165e-03f, 9.40656215e-02f, 5.06761204e-03f, 4.85281013e-02f, 1.71658117e-02f, -1.47303781e-02f, 1.39512671e-02f, 3.12369695e-04f, -7.77865574e-02f,
  -7.89009035e-02f, 3.60963866e-03f, 4.84484099e-02f, 4.60735932e-02f, 3.59888300e-02f, 3.31726335e-02f, 4.10515722e-03f, -4.03001942e-02f, 5.10574579e-02f, -1.28550623e-02f,
  -5.09248301e-02f, 1.57582276e-02f, 3.51113640e-02f, 2.93986150e-03f, -1.36520360e-02f, -6.42826557e-02f, -6.70250952e-02f, 1.73890423e-02f, -5.62206805e-02f, -6.50287718e-02f,
  3.53842638e-02f, -6.97958022e-02f, 5.76504916e-02f, 7.86535516e-02f, -5.86036667e-02f, -5.38262390e-02f, 1.42533686e-02f, 6.39675558e-02f, -4.01013484e-03f, -2.82788314e-02f,
  1.34665102e-01f, -2.22414225e-01f, -1.75402611e-01f, 3.93127680e-01f, -1.59060657e-01f, 1.11933097e-01f, 1.48645580e-01f, 7.54524171e-02f, 1.25276819e-01f, 1.17431894e-01f,
  2.78414279e-01f, -2.45782897e-01f, -1.69076726e-01f, 2.62668967e-01f, 2.49565482e-01f, 1.16130374e-02f, 2.95422077e-01f, 1.41309828e-01f, -1.29168600e-01f, 8.00025985e-02f,
  6.46614507e-02f, 1.74886122e-01f, -1.96032524e-02f, -9.90489870e-02f, -1.11920856e-01f, -6.44221678e-02f, 8.44188780e-02f, -1.24521330e-01f, 1.22392088e-01f, -1.10399917e-01f,
  6.80042580e-02f, 1.41162321e-01f, -1.05877362e-01f, -1.65129304e-02f, 1.02241389e-01f, -1.10675029e-01f, -1.60877104e-03f, -6.05508983e-02f, 8.11201462e-04f, -3.14282738e-02f,
  -6.77871257e-02f, -8.59687701e-02f, 5.20338193e-02f, -4.28115502e-02f, -6.66520372e-02f, -8.83252695e-02f, -5.36459796e-02f, -1.26390427e-01f, -9.45030823e-02f, -6.98897988e-02f,
  -8.45876932e-02f, -6.04686327e-02f, 1.62698962e-02f, -1.14468373e-02f, -2.77455058e-03f, 4.49672006e-02f, -5.83248632e-03f, -6.86559156e-02f, -1.56689796e-03f, 4.09597419e-02f,
  1.58625487e-02f, 3.45513895e-02f, -3.53267938e-02f, -1.57259684e-02f, 2.48404443e-02f, -8.99818763e-02f, -1.91796161e-02f, -9.15754400e-03f, -4.17730547e-02f, 1.63950883e-02f,
  -4.28924784e-02f, 4.38848808e-02f, 1.03310989e-02f, 4.55772914e-02f, 9.95683298e-02f, -4.34388686e-03f, -7.76206926e-02f, 3.11724860e-02f, -5.39239906e-02f, 5.17237559e-02f,
  -3.91094238e-02f, 9.25998960e-04f, 3.58673069e-03f, -2.99275238e-02f, 5.32580316e-02f, -1.06774978e-02f, -6.35379404e-02f, -5.37686162e-02f, 5.35682216e-02f, -2.45103054e-03f,
  1.28263161e-01f, 3.61045688e-01f, 6.80959374e-02f, 1.17301624e-02f, 3.80684901e-03f, 1.02554429e-02f, -7.48892548e-03f, -2.76473779e-02f, -4.18606438e-02f, 7.55758062e-02f,
  9.28025097e-02f, 2.24393886e-02f, 1.49411215e-02f, 3.50090303e-03f, 1.87364519e-02f, -1.50893005e-02f, 3.76306698e-02f, -1.11076031e-02f, 9.48357433e-02f, 7.69001245e-02f,
  8.58119503e-02f, 2.01364886e-02f, 2.12789234e-02f, -1.09100901e-02f, 1.53881703e-02f, -1.76183153e-02f, 2.73351874e-02f, -2.33411044e-02f, 5.86226285e-02f, -1.40277639e-01f,
  1.58783913e-01f, 2.32487023e-01f, -9.85916629e-02f, 9.32446495e-02f, 8.39677581e-04f, 5.30849174e-02f, -3.15858275e-02f, 2.50996858e-01f, -1.76567584e-01f, 2.36523777e-01f,
  8.62172395e-02f, -5.50518110e-02f, -1.20650873e-01f, 2.85372227e-01f, -2.98981816e-01f, -1.99362472e-01f, 1.07795604e-01f, 1.16099797e-01f, -2.04095364e-01f, 1.61077142e-01f,
  1.15099438e-01f, 1.77418932e-01f, 5.96066192e-02f, 8.66329521e-02f, 2.57259846e-01f, 1.05642125e-01f, 1.99245453e-01f, -1.67483896e-01f, 2.80226409e-01f, -1.02233663e-01f,
  1.63755909e-01f, -6.78404514e-03f, 9.77705196e-02f, -1.48821399e-01f, 1.66984826e-01f, -5.23030944e-02f, -1.01234931e-02f, -1.12958364e-01f, -9.22054872e-02f, 2.99321720e-03f,
  8.61144159e-03f, 5.92199154e-02f, 1.27562150e-01f, -5.56693301e-02f, -7.41849616e-02f, -3.73857729e-02f, 2.50439197e-02f, 1.06167294e-01f, -4.25689444e-02f, -3.23744677e-02f,
  3.85749899e-03f, 2.12357845e-02f, 7.09655276e-03f, 2.46168934e-02f, -8.93980414e-02f, -9.50144380e-02f, -6.57473579e-02f, 2.50380319e-02f, 8.54412466e-02f, -3.03410981e-02f,
  -6.87324554e-02f, -1.20808929e-01f, 9.10677761e-03f, -3.91843589e-03f, 3.17605436e-02f, 1.50779381e-01f, -8.64122286e-02f, 2.57763453e-02f, -4.37648827e-03f, 5.71287833e-02f,
  1.24198817e-01f, -1.85897965e-02f, -1.78017877e-02f, -8.46188236e-03f, 6.66586831e-02f, 3.87178883e-02f, -2.44287588e-02f, 4.77939248e-02f, 9.72932279e-02f, 3.81603613e-02f,
  9.25349537e-03f, -3.53363603e-02f, -7.71088991e-03f, -6.40254840e-02f, -3.59575935e-02f, 3.71435210e-02f, 5.81457987e-02f, 1.74933821e-02f, -9.85726640e-02f, 2.33603101e-02f,
  1.87312737e-01f, 9.28570852e-02f, -2.32450590e-02f, -6.06250092e-02f, 6.89891651e-02f, -5.15542785e-03f, -7.40747005e-02f, 5.91680519e-02f, 1.82310883e-02f, -3.01777385e-02f,
  2.50536688e-02f, 6.78940490e-02f, 2.38767918e-02f, -1.69288199e-02f, -4.87035327e-03f, -9.68785491e-03f, 4.58148718e-02f, 3.25675262e-03f, 6.62195981e-02f, 2.52874251e-02f,
  3.79878022e-02f, -8.02897513e-02f, -2.07014270e-02f, 6.35924265e-02f, -1.97315658e-03f, 9.00447443e-02f, 6.40270906e-03f, -1.24093622e-01f, -6.26513967e-03f, 2.18601618e-02f,
  4.06980366e-01f, -1.74075887e-02f, 1.27496570e-01f, 1.50827616e-01f, 2.37175047e-01f, -1.97532058e-01f, -3.73908281e-01f, 2.60216177e-01f, 6.69406354e-02f, -1.57565817e-01f,
  9.09761488e-02f, -2.49455854e-01f, -2.02750668e-01f, -2.52687987e-02f, -2.58989111e-02f, -7.14563280e-02f, 7.79891908e-02f, -1.31340593e-01f, 9.41432267e-02f, 2.20012799e-01f,
  1.70764133e-01f, 6.58097565e-02f, 1.52448311e-01f, 1.71717510e-01f, 2.80916929e-01f, 1.73890561e-01f, 1.43477693e-01f, -5.52625284e-02f, 9.27152205e-03f, -1.51597977e-01f,
  1.45985082e-01f, 1.88034385e-01f, -3.17197479e-02f, 1.46420179e-02f, 1.16378076e-01f, -6.73347637e-02f, -1.96742974e-02f, -8.83224532e-02f, -1.03936589e-03f, -1.71754113e-03f,
  -2.55107414e-03f, 9.99390408e-02f, -6.04584515e-02f, -7.47059807e-02f, 6.67254478e-02f, 8.33496638e-03f, 1.07000917e-01f, 6.79907650e-02f, 5.46194352e-02f, 7.44779706e-02f,
  -2.53622662e-02f, 9.00156125e-02f, 9.81784612e-02f, -5.89204766e-03f, 7.89463520e-02f, -2.09301040e-02f, -5.56696206e-02f, -5.90519011e-02f, -2.45334562e-02f, 6.26600161e-02f,
  -2.89339907e-02f, 4.53216992e-02f, 4.66453396e-02f, -2.32751183e-02f, -6.59624487e-02f, 2.48155370e-02f, -7.96758085e-02f, -4.66403216e-02f, -2.23542172e-02f, -1.13116074e-02f,
  4.37329635e-02f, 4.49933447e-02f, 6.41133860e-02f, 2.31549982e-02f, -1.93140581e-02f, 4.19996828e-02f, -2.01124698e-02f, -1.24997343e-03f, 6.67393804e-02f, -2.84875371e-02f,
  1.57489296e-04f, 1.51837608e-02f, -6.34148493e-02f, 3.40245180e-02f, -3.04277185e-02f, -1.95661783e-02f, 4.94381972e-02f, 1.44664152e-02f, 5.07875904e-02f, -3.61059308e-02f,
  -1.63835250e-02f, -3.42002809e-02f, -3.82843576e-02f, -2.77010165e-02f, -9.61294621e-02f, 4.63926373e-03f, 9.43057612e-03f, 1.16096467e-01f, -2.70916638e-03f, 1.38596620e-03f,
  1.10286497e-01f, -1.60064586e-02f, 8.21519643e-02f, 5.53712212e-02f, 1.92009490e-02f, -2.68961798e-04f, -6.77828640e-02f, -5.21956533e-02f, -2.59309430e-02f, 2.56210305e-02f,
  8.84581581e-02f, 6.16472848e-02f, -5.45957834e-02f, 4.37425748e-02f, -1.98425353e-02f, -4.62661795e-02f, -7.28729591e-02f, -9.78499930e-03f, -1.73048060e-02f, -2.93189120e-02f,
  3.09372306e-01f, -1.54703274e-01f, -1.10053994e-01f, 2.31787130e-01f, 2.22074807e-01f, 1.37165915e-02f, -8.62731189e-02f, 1.07870646e-01f, -4.72355969e-02f, -2.75136322e-01f,
  2.69546747e-01f, -2.30434552e-01f, -2.53774971e-03f, 2.41447166e-01f, 4.82856870e-01f, 6.43274933e-02f, 1.80559918e-01f, -8.16795006e-02f, -1.40109435e-01f, 1.29324719e-01f,
  1.22535191e-01f, 2.25725457e-01f, 2.00319812e-01f, -6.68013170e-02f, 4.24265489e-02f, -1.10743850e-01f, 2.02842891e-01f, -1.62329361e-01f, 1.00736342e-01f, 7.27101713e-02f,
  1.50564447e-01f, 1.58376023e-02f, -1.81633919e-01f, -5.95181845e-02f, 4.27149795e-02f, -4.54816818e-02f, -1.12837501e-01f, 3.13581973e-02f, 1.70550626e-02f, -1.18526526e-01f,
  -7.87539557e-02f, 5.33080474e-02f, 1.63223147e-02f, -7.80790821e-02f, -8.60434175e-02f, -4.03913744e-02f, -2.70201899e-02f, -6.66870177e-02f, -1.60217490e-02f, 3.58493328e-02f,
  -1.02490544e-01f, -6.75105602e-02f, -6.46011764e-03f, -4.51132879e-02f, 7.26858452e-02f, -4.87865834e-03f, -4.39555384e-02f, -4.96067703e-02f, 3.37003991e-02f, -1.10638086e-02f,
  -3.65401842e-02f, -2.59404676e-03f, -6.22439990e-03f, 4.63097058e-02f, -2.69744955e-02f, 4.46420982e-02f, -7.01353252e-02f, 9.88349766e-02f, -1.70524448e-01f, 5.70496805e-02f,
  7.67106265e-02f, 6.84488518e-03f, -1.80160010e-03f, -2.14049071e-02f, -7.35062808e-02f, 6.40967023e-03f, -1.02264443e-02f, 2.38691084e-02f, -4.44973335e-02f, 6.02191091e-02f,
  -3.05361245e-02f, 7.17761219e-02f, -3.14059755e-04f, 2.43401770e-02f, -4.73675840e-02f, 3.28262374e-02f, 1.23072052e-02f, -4.12391201e-02f, 3.95958312e-02f, 8.37829411e-02f,
  1.55317932e-01f, 2.83303618e-01f, -1.38193835e-02f, 2.01490503e-02f, -5.15986457e-02f, 4.31572944e-02f, -1.63006634e-02f, -3.83495018e-02f, -4.49056886e-02f, 5.83373159e-02f,
  -1.10011436e-02f, -1.27856471e-02f, 4.62816954e-02f, 3.64582390e-02f, -4.40951735e-02f, 5.01810126e-02f, 2.63474658e-02f, -8.97733960e-03f, 9.57843885e-02f, -1.53041165e-02f,
  5.74361794e-02f, 9.97982826e-03f, -8.01100433e-02f, 1.24800382e-02f, -9.83312260e-03f, 1.28514683e-02f, 7.43004456e-02f, -6.31493479e-02f, 8.27862415e-03f, -6.25325441e-02f
};

// L0_fan_Wp_bar (Shape: 26 x 120)
const int L0_fan_Wp_bar_rows = 26;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -3.03924590e-01f, -1.24860648e-02f, -1.41231641e-01f, 3.92519422e-02f, 3.85779478e-02f, -4.39123124e-01f, -2.76346296e-01f, 1.06185608e-01f, -2.24858791e-01f, 1.00437209e-01f,
  5.39779700e-02f, -1.00064807e-01f, 8.40075389e-02f, -3.75027269e-01f, -4.05408889e-01f, -2.97890633e-01f, -2.05765933e-01f, -2.25637034e-01f, -1.13975428e-01f, 2.45623499e-01f,
  -2.98951343e-02f, 1.78270340e-02f, 9.52516031e-03f, 1.67461365e-01f, -6.46704584e-02f, 3.66841644e-01f, 4.96720642e-01f, 1.11406773e-01f, 1.16599180e-01f, -1.37281463e-01f,
  -2.02378452e-01f, 5.16996793e-02f, -2.29750723e-02f, -8.84248391e-02f, 1.35866612e-01f, 4.01098356e-02f, -1.81290731e-02f, -5.04962169e-02f, -1.27508538e-03f, 3.27611975e-02f,
  6.63632108e-03f, 2.24495362e-02f, -4.96582948e-02f, -4.46681939e-02f, -6.54862225e-02f, -6.53369427e-02f, -2.80686468e-02f, -1.23903509e-02f, -1.00433445e-02f, -5.71220070e-02f,
  -4.02787328e-02f, 1.63639169e-02f, 7.74952769e-03f, 1.27523497e-01f, 1.31675988e-01f, -4.11858372e-02f, 4.25875485e-02f, 1.60067186e-01f, 1.07863676e-02f, 1.73205752e-02f,
  3.14166467e-03f, 1.57591347e-02f, -4.74064164e-02f, -1.72930002e-01f, 8.03168863e-03f, 3.28111500e-02f, -1.01458810e-01f, 3.97028215e-02f, -9.08716768e-03f, 6.52285144e-02f,
  2.05014367e-02f, 1.43732922e-02f, -5.71427383e-02f, 3.29863690e-02f, 9.55871120e-02f, -6.22682050e-02f, -3.13678347e-02f, 9.26701054e-02f, 1.06331453e-01f, -8.98954645e-02f,
  7.28932396e-03f, -9.41544295e-06f, 7.78883696e-02f, 2.64800899e-02f, -1.32662654e-01f, 1.24831408e-01f, 6.94974735e-02f, -5.29341623e-02f, -5.70629612e-02f, 2.19483506e-02f,
  1.97124794e-01f, 3.01425815e-01f, 1.53772086e-02f, -1.22115361e-02f, 1.60895679e-02f, -4.21476290e-02f, -1.74137041e-01f, -4.32012975e-02f, 1.13698184e-01f, -3.67967635e-02f,
  8.57500061e-02f, 5.85746542e-02f, 7.16807395e-02f, 3.47144715e-02f, 8.06492567e-03f, 8.80642831e-02f, 8.00151154e-02f, 1.39444619e-01f, 9.49996263e-02f, 1.75464317e-01f,
  1.60821244e-01f, 6.28227293e-02f, 2.97191064e-03f, -4.22274023e-02f, 4.15111780e-02f, 9.63366702e-02f, -4.92378920e-02f, 4.84302528e-02f, 6.36129454e-02f, 6.40993491e-02f,
  -2.26290345e-01f, 4.54009116e-01f, 3.06452513e-01f, 2.26359650e-01f, 3.27815711e-01f, -3.47952217e-01f, -2.76713252e-01f, 3.28648239e-01f, 1.37976900e-01f, -3.25480700e-01f,
  8.45187232e-02f, -1.39021665e-01f, 1.07597545e-01f, 1.70580849e-01f, -4.24515605e-01f, 9.46575031e-02f, -2.56777018e-01f, -1.14525333e-01f, 1.54135630e-01f, 9.09810662e-02f,
  3.90644744e-02f, 4.16217186e-02f, 1.59342051e-01f, 3.13439041e-01f, 2.36527473e-01f, 9.22102854e-02f, -2.28274524e-01f, 1.48336306e-01f, -2.77144294e-02f, -1.09776951e-01f,
  -1.43233597e-01f, 4.20937926e-01f, -7.68034905e-02f, -1.10001706e-01f, -6.54484034e-02f, -2.01695070e-01f, -1.65997326e-01f, -5.33886179e-02f, 2.15466833e-03f, -5.42907976e-02f,
  -5.62718026e-02f, -4.52076979e-02f, -3.55667137e-02f, 9.98512208e-02f, -6.53557330e-02f, 2.52509047e-03f, 1.39395803e-01f, 4.95354794e-02f, 1.38621479e-01f, 9.05888304e-02f,
  1.76986501e-01f, 3.81550081e-02f, -7.91044310e-02f, -8.97086486e-02f, 5.07569946e-02f, 8.42234790e-02f, -8.03930759e-02f, -8.84547681e-02f, 3.60241979e-02f, -4.51122634e-02f,
  1.32196918e-01f, -1.51712179e-01f, 2.33067349e-02f, 1.71882212e-02f, 1.27440140e-01f, 7.06000924e-02f, 2.42539346e-02f, -3.27985547e-02f, -3.94739502e-04f, -3.38138491e-02f,
  -6.07361682e-02f, 1.08384140e-01f, 1.66538179e-01f, -9.97433625e-03f, 5.14259189e-03f, -3.78737114e-02f, 2.68838387e-02f, 3.51335965e-02f, 1.28131304e-02f, 2.78648939e-02f,
  7.78451189e-02f, -6.35591149e-02f, 4.66966406e-02f, -9.25221965e-02f, -1.87143803e-01f, 2.87403222e-02f, 8.56288895e-02f, 1.63515165e-01f, -2.09262278e-02f, -3.13514434e-02f,
  -4.75567549e-01f, -8.79333448e-03f, -2.06969500e-01f, -7.02811703e-02f, -6.00777604e-02f, -8.93979073e-02f, 9.16700903e-03f, -5.21199368e-02f, -1.02724172e-01f, -5.64078391e-02f,
  -1.25471219e-01f, -5.82400374e-02f, -1.32386357e-01f, -5.83162569e-02f, -4.52277297e-03f, 3.30545716e-02f, -2.70037595e-02f, -7.48543069e-02f, -1.64875180e-01f, -1.55612200e-01f,
  -2.80584358e-02f, 8.65014717e-02f, -1.27636462e-01f, 3.12069687e-03f, -1.28596023e-01f, -7.58854672e-02f, 5.58633395e-02f, -8.49007629e-03f, 6.82909042e-02f, 4.29715738e-02f,
  -7.18999684e-01f, 4.95208681e-01f, 5.49876988e-01f, -7.40006864e-02f, -1.25790626e-01f, 1.21423207e-01f, -1.59994066e-01f, 3.35164607e-01f, 1.65264666e-01f, -7.11218789e-02f,
  -1.45591155e-01f, -2.81115204e-01f, 2.35270634e-01f, -1.06447376e-01f, 3.27247620e-01f, 2.65065283e-01f, 1.57941997e-01f, -1.30957976e-01f, 2.60703862e-01f, 1.15748517e-01f,
  2.92797446e-01f, -1.64583981e-01f, 3.06413561e-01f, 7.17490241e-02f, -5.71748652e-02f, 7.00860620e-02f, 1.01728939e-01f, 2.06825733e-01f, -4.36109975e-02f, 1.16324390e-03f,
  -1.26492947e-01f, -1.07484296e-01f, -1.08320117e-01f, 6.18784912e-02f, 8.44530314e-02f, -9.22745541e-02f, 2.32364293e-02f, -7.48181790e-02f, -2.58414540e-02f, 5.68458550e-02f,
  -1.84411258e-01f, -6.95616566e-03f, -1.20594017e-01f, 2.51742192e-02f, -1.33211550e-03f, -1.58163824e-03f, 2.74522137e-02f, 8.31073448e-02f, 3.23793828e-03f, 2.95233857e-02f,
  6.13771118e-02f, 1.22203872e-01f, 3.61583233e-02f, 5.90973571e-02f, 3.29658054e-02f, 2.11718362e-02f, 8.76192525e-02f, -2.79870722e-03f, -1.35437511e-02f, -2.96515822e-02f,
  9.84412432e-02f, 1.42875120e-01f, -8.09228234e-03f, -1.67217653e-03f, -2.87873931e-02f, 6.34888187e-02f, 4.86514904e-02f, -8.39549825e-02f, 2.10543722e-02f, -3.73073220e-02f,
  -1.45348877e-01f, -7.16864131e-03f, 9.25195888e-02f, 1.27977282e-02f, 3.18557434e-02f, -6.10740036e-02f, -1.38828717e-02f, -1.07192442e-01f, 3.21832374e-02f, -4.30015139e-02f,
  1.02193858e-02f, 3.66579648e-03f, -8.13364983e-02f, -2.14532446e-02f, 9.43959877e-03f, 1.12829953e-01f, 1.02622457e-01f, 5.21026254e-02f, 4.80583571e-02f, 7.04576075e-02f,
  3.16723317e-01f, 4.91302490e-01f, -4.71466035e-02f, -2.58517623e-01f, 4.87240441e-02f, -4.57953336e-03f, 1.23848557e-01f, -8.82777870e-02f, 1.65433973e-01f, 1.92698883e-03f,
  2.48978715e-02f, -2.53176223e-02f, 8.84675514e-03f, -6.90811798e-02f, 3.47725041e-02f, 1.40530154e-01f, 2.49302341e-03f, -5.93853220e-02f, 8.41968954e-02f, 1.17292628e-01f,
  -2.63339002e-02f, -5.34122810e-03f, 7.25268498e-02f, -4.30640504e-02f, -1.27947330e-01f, -2.12444048e-02f, 3.58747318e-02f, -1.89478286e-02f, -2.11390965e-02f, 1.04477398e-01f,
  -5.75385928e-01f, 2.54987240e-01f, -4.22853559e-01f, 2.51399308e-01f, -3.86402197e-02f, -3.60169947e-01f, 1.10836655e-01f, 5.19648492e-02f, -6.65294975e-02f, 5.01822591e-01f,
  5.55580139e-01f, -2.42419288e-01f, 3.94810349e-01f, 6.20545983e-01f, -4.15404975e-01f, 3.49024564e-01f, 1.75732806e-01f, 1.21731572e-01f, -1.09242491e-01f, 2.96345260e-02f,
  -1.48254171e-01f, 4.99701381e-01f, 1.68108404e-01f, -3.94868851e-02f, 1.25614926e-01f, -2.40807161e-01f, 3.39749336e-01f, -9.14595723e-02f, 1.48521125e-01f, -3.72604132e-02f,
  1.27844527e-01f, 3.21023017e-01f, -1.83288492e-02f, -1.49040952e-01f, -8.86130333e-02f, -2.72658002e-03f, -4.26981449e-02f, -4.78913821e-02f, 1.86820868e-02f, -2.31168829e-02f,
  -7.61356130e-02f, -4.68688458e-02f, -7.88738672e-03f, -2.74505913e-02f, -3.14698368e-03f, -1.37431100e-02f, -2.66604219e-02f, 4.43481728e-02f, 1.97904930e-02f, -6.83536604e-02f,
  7.78570622e-02f, -3.22923437e-02f, 4.69908081e-02f, 4.96393926e-02f, -1.08225912e-01f, -3.83596681e-02f, -1.18626542e-01f, -7.92149529e-02f, -7.31279850e-02f, -1.55846998e-01f,
  -1.47693962e-01f, -8.54986161e-02f, 4.09225971e-02f, 1.12308465e-01f, 3.04818135e-02f, 9.89699662e-02f, 1.06754236e-01f, 2.49643177e-02f, -6.73613548e-02f, -8.66233930e-03f,
  4.15107533e-02f, -4.45914902e-02f, 2.26237234e-02f, -2.55995709e-02f, -1.19993417e-02f, 9.03698057e-02f, -1.53203219e-01f, -3.60070206e-02f, 1.91311371e-02f, 3.49299051e-02f,
  1.73882976e-01f, -1.27114043e-01f, 7.54973963e-02f, 1.30601346e-01f, 2.38111764e-02f, 6.66985437e-02f, 6.26939833e-02f, -2.63644126e-03f, 5.22059463e-02f, -5.37836552e-02f,
  1.99773703e-02f, -1.53598981e-02f, 1.37742713e-01f, 5.30690663e-02f, 1.52698932e-02f, -5.77158481e-02f, -1.13729695e-02f, -1.83208480e-01f, -3.00683291e-03f, -7.81235546e-02f,
  -1.56237856e-01f, 6.75726263e-03f, -1.19868405e-01f, 8.73954222e-02f, -6.87494548e-03f, 4.37748283e-02f, 6.22960106e-02f, -5.64751439e-02f, 3.15087140e-02f, -3.28878351e-02f,
  2.63993833e-02f, -2.96587590e-03f, -3.58825549e-02f, 6.36228472e-02f, 2.60382202e-02f, 9.63957310e-02f, -1.69145584e-01f, -2.39236411e-02f, -5.86944818e-03f, 8.59441329e-03f,
  3.50322157e-01f, -5.48746049e-01f, 3.39969486e-01f, 1.27435446e-01f, 4.03032005e-01f, 1.63737133e-01f, 6.10875130e-01f, -2.07317457e-01f, -4.01668623e-02f, -5.04572630e-01f,
  1.79845523e-02f, 4.32103965e-03f, 2.82761067e-01f, -2.16233701e-01f, 3.77211601e-01f, 6.63129985e-02f, -2.60406405e-01f, -1.31347954e-01f, 3.34725529e-02f, 6.44512773e-02f,
  8.10729638e-02f, -1.31644011e-01f, 2.90760636e-01f, -5.38147092e-01f, 1.47543490e-01f, -1.48321688e-01f, -1.51497722e-01f, 2.08129391e-01f, -3.73371601e-01f, 1.07604302e-01f,
  -9.27105770e-02f, -7.81636834e-02f, 1.57987505e-01f, -1.08712777e-01f, -6.98372796e-02f, 5.16137443e-02f, 7.90386647e-02f, 2.26502776e-01f, 1.95328563e-01f, 6.43724576e-02f,
  8.48781541e-02f, -4.13303338e-02f, -1.37910470e-01f, 9.80598703e-02f, -2.49140747e-02f, -9.44276229e-02f, 2.36277059e-02f, 2.91646793e-02f, 4.09266353e-02f, 6.53256625e-02f,
  1.44618601e-01f, -1.92769244e-02f, 8.36977065e-02f, -1.47655457e-01f, 5.83831593e-02f, -8.36530551e-02f, 2.05264948e-02f, 2.95193624e-02f, -5.49221672e-02f, -9.44565460e-02f,
  -1.54782727e-01f, -4.60067913e-02f, 3.08807865e-02f, -3.74037251e-02f, 3.77555005e-02f, 4.75355089e-02f, -1.91107020e-02f, -3.45081724e-02f, -1.52594624e-02f, 2.27100886e-02f,
  2.40125088e-03f, 3.34155606e-03f, -4.91922162e-02f, 7.51435980e-02f, -2.57684980e-02f, -2.12646816e-02f, 1.06910348e-01f, 1.25380931e-02f, -4.65653315e-02f, -2.56608799e-02f,
  3.89694981e-02f, 3.10221016e-02f, 2.81122550e-02f, 3.09357401e-02f, -1.54604495e-01f, 1.42324746e-01f, -3.82191986e-02f, 3.83911058e-02f, 5.78839518e-02f, 9.79680195e-02f,
  -2.73519814e-01f, -4.53880280e-01f, 6.41439576e-04f, -5.74731305e-02f, -9.52165127e-02f, -1.60825104e-01f, -7.34520406e-02f, -1.47533849e-01f, -1.54698035e-02f, 5.85405380e-02f,
  -1.28993630e-01f, 8.13205689e-02f, -5.95500842e-02f, -1.11424439e-02f, -1.35855839e-01f, -1.17109194e-02f, 4.95629758e-02f, -2.00243350e-02f, -7.00216740e-03f, -1.75696895e-01f,
  6.23404095e-03f, -8.19340628e-03f, -3.42498138e-03f, -9.70674399e-03f, -1.44142389e-01f, -3.10264388e-03f, -4.62430827e-02f, -1.11104712e-01f, 5.86261079e-02f, -6.40742704e-02f,
  -7.65360594e-01f, 6.12620749e-02f, -6.08449131e-02f, -1.09885655e-01f, -3.66674870e-01f, -2.37068757e-01f, -7.73022398e-02f, -1.05134189e-01f, 7.95058683e-02f, 3.15009743e-01f,
  1.70050219e-01f, -2.78541923e-01f, 3.30315769e-01f, 1.04209125e-01f, -1.78475544e-01f, 4.88322705e-01f, 5.34767322e-02f, 6.33603111e-02f, -4.44434099e-02f, -3.22223872e-01f,
  -1.65721610e-01f, -2.41761699e-01f, -2.05728412e-02f, -2.57608443e-01f, -4.21568036e-01f, -2.30292633e-01f, -6.84222812e-03f, -1.83031723e-01f, -1.07274003e-01f, -5.92519529e-02f,
  -3.30052972e-01f, -2.93547243e-01f, -1.53967083e-01f, -5.80486208e-02f, -1.26265168e-01f, 6.21343823e-03f, -5.38552329e-02f, -7.72596970e-02f, -5.75722568e-02f, -2.10197233e-02f,
  -1.19556924e-02f, -3.18496190e-02f, -1.00512370e-01f, 2.72800848e-02f, -6.65690675e-02f, -7.72703364e-02f, 2.27929354e-02f, 4.00420018e-02f, -3.77440751e-02f, 5.65734692e-02f,
  -2.37256326e-02f, 1.35983616e-01f, 4.20547090e-02f, 7.93305263e-02f, -4.49517444e-02f, 3.09922267e-02f, 7.56782740e-02f, -4.72483365e-03f, -7.71354244e-04f, -6.35223761e-02f,
  3.36185060e-02f, -1.40906293e-02f, -5.64397238e-02f, -5.30041680e-02f, -1.15891434e-02f, 5.29287718e-02f, -2.20093932e-02f, 5.83042391e-02f, 8.89611151e-03f, 1.43578406e-02f,
  -4.28306591e-03f, -6.86995313e-02f, -4.05173786e-02f, 5.94200529e-02f, 2.60847043e-02f, 6.77024126e-02f, -5.22747375e-02f, -5.21695539e-02f, 1.07153572e-01f, 4.78391238e-02f,
  -8.97373408e-02f, -2.99133714e-02f, 1.94482822e-02f, 4.24110256e-02f, -6.44921837e-03f, 2.25425009e-02f, 5.27292006e-02f, 8.84388387e-02f, -5.29652112e-04f, -1.01985440e-01f,
  -4.85611856e-01f, -4.52918351e-01f, -1.59845352e-01f, -1.56559229e-01f, -9.05401185e-02f, -1.00428723e-02f, 6.77618161e-02f, -7.20721632e-02f, -1.18270457e-01f, -4.93839942e-02f,
  -5.26123261e-03f, 9.13808821e-04f, -1.03257284e-01f, 6.09991439e-02f, 6.85761170e-03f, 4.56656478e-02f, -8.05029050e-02f, -3.83840837e-02f, -1.60911128e-01f, -6.39969260e-02f,
  -3.14593762e-02f, -9.94825885e-02f, 8.69842097e-02f, -6.56265542e-02f, 7.24886730e-02f, -4.79588844e-02f, -1.16677657e-01f, 6.78007230e-02f, -9.78279635e-02f, 3.79781872e-02f,
  -4.54715431e-01f, 6.18691027e-01f, 3.15915287e-01f, -3.27579618e-01f, 1.04960606e-01f, 1.27903104e-01f, -2.66021729e-01f, 3.25516731e-01f, 1.54073477e-01f, 2.28745997e-01f,
  -1.13862760e-01f, 3.71320784e-01f, 2.17608199e-01f, -1.23297580e-01f, -2.15797514e-01f, -7.63181821e-02f, -3.43533188e-01f, -1.15774773e-01f, 9.54350084e-02f, -1.37152001e-01f,
  -1.63489759e-01f, -3.52336347e-01f, -2.74422675e-01f, 4.99872491e-02f, -9.19816196e-02f, 6.16916493e-02f, -4.30893242e-01f, 7.28482828e-02f, -1.62789330e-01f, 3.38825025e-02f,
  -1.67197585e-01f, -3.00232172e-02f, -5.00370562e-03f, 1.80154853e-02f, -3.83468866e-02f, -1.01584624e-02f, -1.61405608e-01f, -3.21200192e-02f, 3.41015942e-02f, 1.63723007e-01f,
  7.84954354e-02f, 1.70742482e-01f, -3.52879763e-02f, 1.32018968e-01f, 1.00807874e-02f, 1.21223271e-01f, 8.05391967e-02f, -5.42524122e-02f, 1.13170147e-01f, 1.52903542e-01f,
  1.19234644e-01f, 8.73155892e-02f, -5.09932116e-02f, -4.31127176e-02f, 1.37145026e-02f, 3.24361934e-03f, -7.65355378e-02f, -3.41290087e-02f, -1.64070092e-02f, 4.75506857e-02f,
  -3.99676487e-02f, 4.14835811e-02f, 3.41091380e-02f, 2.65480601e-03f, 5.02283536e-02f, 4.31898683e-02f, -8.03622324e-03f, -9.46131423e-02f, -3.49622630e-02f, -9.80186015e-02f,
  -6.43087700e-02f, -1.85426176e-02f, -1.42449522e-02f, -6.02781661e-02f, -1.64986514e-02f, 2.46927589e-02f, -7.67511353e-02f, 1.13310620e-01f, -1.05158657e-01f, 2.54968870e-02f,
  5.17185368e-02f, -1.33779958e-01f, -4.74389456e-02f, -7.00400546e-02f, 4.07910906e-02f, 5.26522473e-02f, -3.45665514e-02f, 8.29602331e-02f, 1.44513659e-02f, -8.48084986e-02f,
  -3.06868047e-01f, -2.90632516e-01f, 4.98525053e-02f, 7.55556151e-02f, 6.97131604e-02f, 4.96804528e-02f, -6.58190623e-02f, 1.34386867e-01f, -2.53065508e-02f, 8.08725208e-02f,
  3.60526517e-02f, -3.47039336e-03f, -1.83858678e-01f, 4.23221551e-02f, -3.69991711e-03f, -1.07862353e-01f, -1.67329609e-01f, -9.26317796e-02f, -8.66200700e-02f, 5.21396771e-02f,
  -1.34834806e-02f, -1.10141791e-01f, -2.46363580e-02f, -6.96312264e-02f, -5.08834086e-02f, -5.26513532e-02f, -5.49122877e-02f, 5.05738817e-02f, -6.26901835e-02f, -4.91672866e-02f,
  -6.20665491e-01f, 1.84705138e-01f, 5.19312739e-01f, -4.36638266e-01f, 1.92402303e-01f, 6.51020333e-02f, -1.52787179e-01f, 2.24702638e-02f, -2.49664739e-01f, -2.63882428e-01f,
  -8.82286876e-02f, 1.09836362e-01f, 1.75086156e-01f, -2.83807963e-01f, 1.47671327e-01f, 8.36745724e-02f, -5.30092359e-01f, -3.26835096e-01f, 7.10484907e-02f, -1.96788728e-01f,
  -7.23025873e-02f, -1.63656101e-01f, 2.00559460e-02f, 1.27599500e-02f, -4.80011292e-02f, -9.65610668e-02f, -1.75115258e-01f, 3.29214841e-01f, -1.60861328e-01f, 2.08093092e-01f,
  -2.30079919e-01f, -2.65573561e-01f, -1.16101049e-01f, -8.10489804e-02f, -1.10164903e-01f, -3.55552174e-02f, -2.69651730e-02f, 1.26820609e-01f, -1.19586416e-01f, -6.61155209e-02f,
  -2.02200445e-03f, 8.94620270e-02f, -5.84932566e-02f, 4.81767654e-02f, -4.33467142e-02f, -3.54483016e-02f, 3.93757112e-02f, -4.68161376e-03f, 2.34581660e-02f, 1.10763110e-01f,
  1.35629833e-01f, 1.65818930e-02f, -2.11439263e-02f, 2.85337232e-02f, 2.06750005e-01f, -5.52719347e-02f, -7.74786994e-02f, 1.74797833e-01f, -2.70105191e-02f, -5.93544953e-02f,
  -5.39263412e-02f, -3.40247191e-02f, 7.24737644e-02f, 1.37161128e-02f, 1.09174326e-02f, 1.09947007e-02f, 4.40323725e-02f, 2.95440108e-02f, -8.57939012e-03f, -4.23996076e-02f,
  -4.44909781e-02f, 6.27364963e-02f, -1.25547960e-01f, -1.25742674e-01f, -4.38755229e-02f, -1.58402264e-01f, -3.26688997e-02f, -3.20743732e-02f, 6.54566810e-02f, 4.30515781e-02f,
  -5.83865084e-02f, 2.50341780e-02f, 6.78986609e-02f, -5.53286895e-02f, -5.61560951e-02f, 4.09816578e-02f, -2.50356365e-02f, -3.52512784e-02f, -9.26377252e-02f, 8.67216289e-02f,
  -4.33986127e-01f, -4.46722269e-01f, -6.20270483e-02f, -6.80888444e-02f, -3.55611332e-02f, 1.44034335e-02f, 2.47649327e-02f, -5.86757772e-02f, -1.30502403e-01f, -1.29197612e-01f,
  -1.35298744e-01f, -1.24187805e-01f, -2.72631203e-03f, -4.30652313e-02f, 1.08131349e-01f, -7.39175677e-02f, -1.53904036e-01f, -5.32415435e-02f, -1.24345161e-01f, 1.26280859e-02f,
  -1.01580866e-01f, -6.47913665e-02f, 1.94535017e-01f, -7.11193606e-02f, -6.10723421e-02f, -4.42818515e-02f, -4.43319567e-02f, 3.34965996e-02f, -1.41380047e-02f, 3.09128147e-02f,
  -1.37889991e-02f, -1.03424199e-01f, -3.97896379e-01f, 2.16048341e-02f, -2.82290310e-01f, -4.22903955e-01f, -4.09243941e-01f, -1.21633008e-01f, 2.96939254e-01f, 2.21571788e-01f,
  -9.29922387e-02f, 2.20276475e-01f, 2.41969436e-01f, -2.91334003e-01f, 2.46895134e-01f, 5.01001120e-01f, -2.84024328e-01f, -9.00254101e-02f, 1.99726924e-01f, -9.09949690e-02f,
  1.55069068e-01f, -1.33026555e-01f, -1.78282887e-01f, -1.73209384e-01f, -5.21254122e-01f, -1.19865641e-01f, 4.32893559e-02f, -2.87534952e-01f, -3.54907721e-01f, -2.14860186e-01f,
  -6.98687062e-02f, 1.39037162e-01f, -8.13462120e-03f, 2.03789421e-03f, -1.02866627e-02f, -8.88561606e-02f, -1.23157680e-01f, -4.00903448e-02f, 9.70883369e-02f, 8.48237053e-02f,
  1.48524538e-01f, 2.11083233e-01f, 1.16268964e-02f, 7.48691559e-02f, -9.27882344e-02f, -6.59210160e-02f, 3.56959552e-02f, -8.16790164e-02f, -1.21980691e-02f, -2.47933380e-02f,
  -7.25075901e-02f, 1.15580987e-02f, -5.82355224e-02f, 1.26677632e-01f, 8.38262513e-02f, -8.83779954e-03f, -1.08593300e-01f, -5.03744781e-02f, -5.87594546e-02f, 1.16229475e-01f,
  1.05827274e-02f, 4.72800024e-02f, -4.21432182e-02f, -2.71152724e-02f, -2.31391471e-02f, -6.99484572e-02f, 9.05934796e-02f, -8.32461342e-02f, -6.29994199e-02f, -3.92983221e-02f,
  -6.75707683e-02f, 5.06082177e-03f, -2.50497255e-02f, -6.79848269e-02f, -1.56502407e-02f, 2.65909825e-02f, -2.50246115e-02f, -6.64443970e-02f, -4.87498231e-02f, -4.51820483e-03f,
  7.45471865e-02f, -5.32404408e-02f, 1.17817089e-01f, -3.29537201e-03f, -6.91523701e-02f, 2.31062397e-02f, 3.85366976e-02f, -5.35261817e-02f, 5.64601645e-02f, -1.21552415e-01f,
  5.94866055e-04f, 7.60191828e-02f, 4.57735434e-02f, 1.97857544e-01f, 3.97079960e-02f, -5.44649586e-02f, -7.04491064e-02f, 3.23264599e-02f, -2.58547161e-02f, 7.09980056e-02f,
  -3.19072157e-02f, -7.67752575e-03f, -4.79064360e-02f, 3.52402553e-02f, 1.07920967e-01f, -1.06781937e-01f, 1.85175762e-02f, 1.44470319e-01f, 3.50039481e-04f, 1.21625355e-02f,
  3.95328104e-02f, -6.33593928e-03f, 1.21090710e-01f, 1.27862081e-01f, 5.52782156e-02f, 3.14169563e-02f, -9.51702222e-02f, -3.71014401e-02f, -2.48713680e-02f, 4.35897224e-02f,
  1.71635836e-01f, -1.26324683e-01f, -5.23688793e-01f, -3.96296948e-01f, 8.37874934e-02f, -5.12242138e-01f, -4.67008531e-01f, -1.52662843e-01f, -1.08526759e-02f, 1.79920986e-01f,
  -7.26414397e-02f, -7.26746917e-02f, 2.39857554e-01f, -5.21822095e-01f, -5.49584031e-01f, -7.72283524e-02f, -4.97949898e-01f, -2.91882545e-01f, 7.12360442e-02f, -1.29429206e-01f,
  -8.13560113e-02f, -1.22295544e-02f, -3.69512558e-01f, 1.85461551e-01f, -1.63487449e-01f, 1.22555591e-01f, 1.85991362e-01f, 2.55853295e-01f, -2.44400993e-01f, -1.53062558e-02f,
  -8.75902399e-02f, 1.06361382e-01f, -1.55416697e-01f, 2.59392872e-03f, -1.18207894e-01f, 6.88477159e-02f, 1.49872350e-02f, -1.34704590e-01f, 8.71113210e-04f, -1.18847236e-01f,
  6.45578206e-02f, 1.28969505e-01f, -7.44318888e-02f, 9.38177556e-02f, 1.82070315e-01f, -9.32570454e-03f, -1.28162414e-01f, -1.33360341e-01f, -2.10507642e-02f, -8.11848491e-02f,
  -1.68317646e-01f, -3.90519425e-02f, 2.18864921e-02f, -4.58127484e-02f, -5.13274372e-02f, 3.53053361e-02f, -9.67409611e-02f, 7.36561662e-04f, -3.02810967e-02f, -7.14439154e-03f,
  1.97436698e-02f, 1.77939653e-01f, 9.20572281e-02f, 9.01509523e-02f, 2.26801429e-02f, 4.41194735e-02f, 9.28612500e-02f, 6.11987803e-03f, 5.07792719e-02f, -3.56279090e-02f,
  4.94087599e-02f, -1.86887663e-02f, 1.55567333e-01f, -1.81823187e-02f, -3.66525352e-02f, 5.78653924e-02f, 6.63300306e-02f, 2.02785563e-02f, -1.48227021e-01f, -1.43512234e-01f,
  5.37258871e-02f, 2.11813096e-02f, -7.16494247e-02f, -2.19391845e-03f, -8.57682228e-02f, 2.48210020e-02f, 1.20479524e-01f, -7.42257982e-02f, -1.95758808e-02f, 5.69128990e-02f,
  -1.89911768e-01f, -5.85265346e-02f, -4.54543382e-02f, 2.72415429e-02f, -2.07018610e-02f, 5.09302132e-03f, -3.46420780e-02f, -1.43169403e-01f, -6.87141791e-02f, 2.97006294e-02f,
  -3.10421102e-02f, 1.02801934e-01f, 1.61540627e-01f, 3.82575281e-02f, 1.43453442e-02f, -1.49870828e-01f, 1.33778349e-01f, 9.68239009e-02f, -7.23645985e-02f, 4.26301695e-02f,
  5.82724623e-02f, 1.52790532e-01f, 7.04761818e-02f, -2.21246686e-02f, 2.29360089e-02f, -3.40504199e-02f, 4.48026583e-02f, 8.50526690e-02f, 5.41742034e-02f, -3.66850719e-02f,
  3.14651102e-01f, -1.20629393e-01f, -1.89940840e-01f, -2.63684958e-01f, -1.69152677e-01f, 3.64920557e-01f, 4.82164025e-01f, -2.61105478e-01f, -3.23527068e-01f, 1.02046616e-01f,
  1.71744257e-01f, 4.75177728e-02f, 5.38889289e-01f, 1.66153774e-01f, 4.41251069e-01f, 4.17101860e-01f, 1.80920884e-02f, 2.00437188e-01f, -2.46748373e-01f, -1.90687522e-01f,
  -1.34158984e-01f, -2.04527155e-02f, 2.40611866e-01f, -3.77020389e-01f, 2.38391571e-02f, -3.98034304e-01f, -3.11781801e-02f, 4.81031537e-02f, -1.07612699e-01f, 1.45265043e-01f,
  5.99180460e-02f, -1.66413233e-01f, -1.51167527e-01f, -5.49826138e-02f, 3.90226245e-02f, -9.67051648e-03f, 1.24617517e-01f, 2.29597509e-01f, -7.36166760e-02f, -7.19678914e-03f,
  1.12312742e-01f, -7.15715885e-02f, -1.63222849e-01f, 2.10780725e-02f, -8.47199485e-02f, -1.86100200e-01f, -1.17058530e-01f, -2.95525286e-02f, -5.71072288e-02f, 1.25536457e-01f,
  5.84391281e-02f, 1.52585609e-02f, -3.94907556e-02f, -9.31100100e-02f, -5.29127903e-02f, -9.43845436e-02f, 5.43700010e-02f, 1.83774605e-01f, -7.96115492e-03f, 1.62319262e-02f,
  3.41870040e-02f, 1.37704685e-01f, 1.65021531e-02f, -5.32198735e-02f, 6.21614000e-03f, -1.66826062e-02f, -3.71674784e-02f, 8.35755989e-02f, 1.73852872e-02f, 8.24802890e-02f,
  -7.37509504e-02f, 1.04717538e-02f, -1.56920608e-02f, 1.89138763e-02f, 8.24989453e-02f, -2.89399382e-02f, 1.65410697e-01f, -7.43012950e-02f, -8.46219063e-02f, 3.10876127e-02f,
  -5.50980046e-02f, -1.53328730e-02f, 4.19366769e-02f, -6.59243762e-02f, 2.31180303e-02f, 6.37071878e-02f, -3.90906446e-02f, 3.76716033e-02f, -9.06641856e-02f, 1.22001916e-01f,
  2.29110196e-02f, -1.93433374e-01f, -1.44846246e-01f, -5.67440204e-02f, 8.72866064e-03f, -5.09731919e-02f, -4.69706766e-02f, -5.80210574e-02f, -5.09916916e-02f, -2.51318160e-02f,
  -1.21478163e-01f, -6.67188838e-02f, -5.23421839e-02f, -1.36690428e-02f, -6.91481233e-02f, 2.29460318e-02f, 1.01275183e-01f, -8.52272511e-02f, 1.81177724e-02f, -2.13893633e-02f,
  -2.28274874e-02f, -1.07593415e-02f, -4.54122126e-02f, -7.45322332e-02f, -3.70362438e-02f, 1.28708422e-01f, -8.56159180e-02f, -6.08716160e-02f, -1.77758094e-02f, -1.16567491e-02f,
  5.69209874e-01f, 1.51529565e-01f, 4.22070503e-01f, 3.56885135e-01f, 1.25378981e-01f, 3.85886252e-01f, 3.66106540e-01f, 1.30755812e-01f, 6.08682990e-01f, -1.90166458e-02f,
  -3.80428255e-01f, 4.28283781e-01f, -1.35453522e-01f, 7.36754239e-02f, 7.11276680e-02f, -3.22912224e-02f, 9.53674912e-02f, 1.80814371e-01f, 5.39746732e-02f, 2.21265182e-01f,
  1.06107540e-01f, -2.55950361e-01f, -2.33260840e-01f, -3.67816001e-01f, -3.98756936e-02f, -5.98526262e-02f, -5.18894434e-01f, -5.43710701e-02f, -2.18734130e-01f, -4.31082770e-02f,
  -6.13933280e-02f, -8.94385111e-03f, -4.58394475e-02f, -7.47949556e-02f, -2.00952720e-02f, 4.08297591e-02f, 5.67776673e-02f, -4.26536724e-02f, 3.49496566e-02f, -6.33837236e-03f,
  3.91725227e-02f, 9.51518789e-02f, -1.41648864e-02f, 1.40871489e-02f, 9.73218456e-02f, -1.08849844e-02f, 2.61595622e-02f, -7.94259924e-03f, -6.41259225e-03f, 4.22711782e-02f,
  7.39177689e-02f, 1.02210660e-02f, -5.71985394e-02f, 3.70033905e-02f, -4.43167761e-02f, -8.98001790e-02f, 8.71093646e-02f, 1.78843830e-02f, 4.46555130e-02f, 1.22386090e-01f,
  -6.70357868e-02f, 8.58971030e-02f, -8.76682326e-02f, 4.30394039e-02f, 4.52135578e-02f, -2.80794054e-02f, -1.25892879e-02f, -9.93469544e-03f, 5.34343533e-02f, 5.34559861e-02f,
  8.08059573e-02f, 1.24366665e-02f, -6.97876588e-02f, 6.09576553e-02f, -5.10237962e-02f, 2.82164346e-02f, 3.65986936e-02f, 1.45165268e-02f, -3.52179352e-03f, 4.72040102e-02f,
  -2.54121199e-02f, -1.50445625e-02f, -4.63244282e-02f, -3.31853814e-02f, -4.17896137e-02f, -2.77658235e-02f, -2.61786804e-02f, 7.89251328e-02f, -1.47670269e-01f, -7.04334825e-02f,
  8.11295509e-02f, 2.75334179e-01f, 1.04768751e-02f, -5.07465638e-02f, -3.55637679e-03f, -4.89797406e-02f, 1.52078167e-01f, 6.53932318e-02f, 5.62041737e-02f, 2.94276346e-02f,
  -3.28418463e-02f, 7.70725161e-02f, -1.08164530e-02f, 8.36291909e-03f, -1.18412857e-03f, -9.93031263e-02f, -7.78135890e-03f, 1.25204669e-02f, -4.54100519e-02f, -8.71916190e-02f,
  -7.39610270e-02f, 1.12559617e-01f, 1.72430143e-01f, -3.27774435e-02f, -7.56129697e-02f, -1.12378478e-01f, 2.88970191e-02f, 2.14544404e-02f, -1.25062987e-01f, 1.20799495e-02f,
  5.82553923e-01f, -3.03119391e-01f, 2.27201059e-01f, 5.24992347e-01f, 2.01185554e-01f, -3.14028412e-01f, -2.46470034e-01f, 1.01354353e-01f, 2.73399651e-01f, -3.57843041e-01f,
  -2.06812456e-01f, 2.73484856e-01f, -6.14998281e-01f, 2.18400776e-01f, -2.71762729e-01f, -4.12715048e-01f, 1.26064360e-01f, 5.29448614e-02f, 1.07347429e-01f, 2.59210318e-02f,
  2.67838150e-01f, -1.53067976e-01f, -4.68333736e-02f, -2.45548002e-02f, 2.43466958e-01f, 2.83004165e-01f, -1.77434847e-01f, -1.35545477e-01f, 2.53807455e-01f, 3.35461497e-02f,
  -5.24791107e-02f, 1.09374017e-01f, 6.49791956e-02f, 5.48317982e-03f, -6.00653738e-02f, 5.14931697e-03f, 9.24500171e-03f, -5.00315949e-02f, 6.62307665e-02f, 6.80690929e-02f,
  -4.74273637e-02f, 5.65492772e-02f, 1.09638147e-01f, -2.72624716e-02f, 1.02360599e-01f, 1.15057074e-01f, 1.07055470e-01f, 4.32970040e-02f, 3.02597024e-02f, 1.20565206e-01f,
  -1.24623002e-02f, 1.74245998e-01f, 1.20934725e-01f, 3.92788127e-02f, 2.96465755e-02f, 3.92063744e-02f, 5.59994727e-02f, -6.82865549e-03f, 2.32179891e-02f, 1.24951117e-01f,
  -6.02013133e-02f, -8.39794651e-02f, 2.81380452e-02f, 5.37233837e-02f, -4.97995839e-02f, 1.14434011e-01f, -5.10822469e-03f, 3.98945473e-02f, 2.15276908e-02f, -5.80317676e-02f,
  2.27331966e-02f, 6.13403395e-02f, 4.61445674e-02f, 6.45694369e-03f, -2.14797072e-02f, 8.11852440e-02f, 3.35092843e-02f, -4.15362976e-02f, -5.77732213e-02f, 7.92446658e-02f,
  -1.10741608e-01f, -4.03533876e-02f, -9.13954154e-02f, 6.42428622e-02f, -7.99713209e-02f, -1.58885747e-01f, 7.33948499e-02f, 4.39100936e-02f, 9.14346147e-03f, -2.78445575e-02f,
  -6.59433067e-01f, -6.47188485e-01f, -1.41564459e-01f, -5.44229038e-02f, -8.45793933e-02f, -2.50178343e-03f, 3.04230209e-02f, 9.85046849e-02f, -2.18237624e-01f, -4.05898690e-02f,
  -2.17951294e-02f, 9.20561031e-02f, -6.85611218e-02f, 6.74163476e-02f, -1.49452165e-01f, -6.15141504e-02f, -1.09259903e-01f, -4.30947356e-02f, -6.66920915e-02f, 2.25489046e-02f,
  1.77902938e-03f, -8.10256377e-02f, 9.62829292e-02f, 8.00470933e-02f, 4.98108082e-02f, -1.51308216e-02f, 3.73062231e-02f, 2.13653538e-02f, -1.97662879e-02f, -8.29385146e-02f,
  -3.60101163e-01f, -4.21620578e-01f, -6.23553395e-02f, 2.77536809e-01f, 1.52534328e-03f, -2.97763705e-01f, -3.41994554e-01f, -2.28268534e-01f, -1.76244572e-01f, -4.29919988e-01f,
  -1.99177712e-01f, 2.71479517e-01f, -4.28752124e-01f, 3.54745328e-01f, 3.46274674e-01f, -1.39478177e-01f, 1.46846935e-01f, 1.32163838e-01f, 1.39114857e-01f, -1.66124865e-01f,
  2.40190178e-01f, 2.35920027e-01f, 2.98685968e-01f, 2.78468013e-01f, 4.13206778e-02f, 2.64157295e-01f, 4.96794224e-01f, 2.19720230e-01f, 4.92816299e-01f, 3.14208359e-01f,
  -3.95679995e-02f, -7.64506832e-02f, -8.31893086e-02f, 1.43757954e-01f, -4.99708466e-02f, -5.93714267e-02f, 1.08971670e-01f, 1.08865730e-01f, 1.55003577e-01f, 6.33323342e-02f,
  -7.26481481e-03f, 1.49139762e-01f, 1.47677496e-01f, 1.13117069e-01f, -8.11131448e-02f, 1.20704554e-01f, 3.90462019e-02f, -1.03404924e-01f, -5.98624274e-02f, -1.92530766e-01f,
  -2.03016862e-01f, -6.88069016e-02f, -5.95894083e-02f, 7.94793814e-02f, 2.44435016e-02f, -6.70755506e-02f, 4.59685139e-02f, -3.42221148e-02f, 9.56913084e-02f, -1.36993127e-02f,
  -1.06656931e-01f, 3.66043411e-02f, -3.08007542e-02f, 7.71514848e-02f, 4.32227887e-02f, 9.25495923e-02f, -4.16696332e-02f, 8.17929115e-03f, 7.31811598e-02f, -3.21956389e-02f,
  1.01996243e-01f, 1.95261426e-02f, 6.27285019e-02f, -2.66371444e-02f, -3.12880725e-02f, 1.48638086e-02f, 1.23039611e-01f, 7.18875453e-02f, -3.19031626e-02f, 2.23914348e-02f,
  2.21698987e-03f, 6.25895038e-02f, 2.24880315e-02f, -5.15568852e-02f, -1.15810066e-01f, 1.11891609e-02f, 1.11394286e-01f, -1.97247490e-02f, 3.15349996e-02f, 2.15877462e-02f,
  5.32952286e-02f, 2.53116321e-02f, 1.79258008e-02f, 8.37279931e-02f, 8.42451379e-02f, -6.81470847e-03f, 7.44868070e-02f, 5.09673543e-03f, 5.99637814e-02f, -6.58892691e-02f,
  1.51503468e-02f, 9.54719409e-02f, -2.29293890e-02f, 5.49828708e-02f, 1.46488592e-01f, -1.62449077e-01f, 8.81889090e-02f, 1.42401457e-01f, 4.24688570e-02f, 1.86800361e-02f,
  3.72150615e-02f, -1.47795696e-02f, 2.47032531e-02f, 5.78847714e-03f, -2.58418061e-02f, -2.92261988e-02f, 1.65387671e-02f, -3.22506912e-02f, 4.26573455e-02f, 1.11281060e-01f,
  5.05853117e-01f, -2.88995832e-01f, 1.96405426e-02f, 5.31318903e-01f, 2.55141199e-01f, -2.39598304e-01f, -5.25606945e-02f, 2.56013364e-01f, 2.68561780e-01f, -2.82666713e-01f,
  1.22549169e-01f, -3.34713697e-01f, -3.06752056e-01f, 2.91980416e-01f, 4.16392565e-01f, -2.36824781e-01f, 3.61621022e-01f, -8.11915174e-02f, 1.41611695e-01f, 2.22528547e-01f,
  3.45310271e-01f, 3.36659372e-01f, 2.39972129e-01f, 1.95489839e-01f, 2.22485423e-01f, 1.89004496e-01f, 2.52610385e-01f, -1.05965525e-01f, 1.74793467e-01f, -1.99216139e-03f,
  -2.44670976e-02f, 7.73986056e-02f, 8.39354172e-02f, -8.16581324e-02f, 8.00608993e-02f, -8.77450407e-02f, -8.61863047e-02f, -1.05626680e-01f, 1.19727023e-01f, -5.42219654e-02f,
  -7.38906562e-02f, 3.59900342e-03f, 4.14312445e-02f, 5.34992889e-02f, 1.05596513e-01f, 1.19709998e-01f, -3.78139354e-02f, -4.11296561e-02f, -6.06216975e-02f, -8.50472152e-02f,
  2.96402797e-02f, -7.56558478e-02f, 9.78610218e-02f, -5.24196811e-02f, 3.54343243e-02f, 4.62811068e-02f, -6.69401959e-02f, -1.04147010e-01f, -8.54273438e-02f, 2.49072090e-02f,
  -1.23278238e-02f, 1.37061384e-02f, -2.22879015e-02f, 5.40100336e-02f, 7.33801275e-02f, 1.03266880e-01f, 4.04525585e-02f, -1.56246707e-01f, 8.44961032e-02f, -2.60107126e-02f,
  1.23231538e-01f, 1.05778329e-01f, 4.55441065e-02f, 7.52120744e-03f, 1.10959105e-01f, 4.93209995e-02f, -4.06679809e-02f, -1.95945781e-02f, 5.85464761e-03f, -5.99952135e-03f,
  -3.23712528e-02f, 9.75053981e-02f, 9.14728642e-03f, -3.12196966e-02f, 1.65539756e-02f, 3.74338813e-02f, 2.16978812e-03f, -5.49146160e-02f, 3.54112126e-02f, 1.65051520e-02f,
  -7.63401166e-02f, 3.49374078e-02f, -1.95477530e-03f, -3.27612646e-02f, -3.38480361e-02f, 5.21136262e-02f, -2.30790470e-02f, 3.81156504e-02f, 6.51677847e-02f, 6.65826425e-02f,
  4.40470390e-02f, -2.57325079e-02f, -8.21242705e-02f, -8.01726012e-04f, -3.43976244e-02f, 6.67604730e-02f, -4.81158383e-02f, 6.75034374e-02f, 8.79878998e-02f, 1.85899995e-02f,
  4.41405401e-02f, -5.76463491e-02f, 4.01665643e-02f, 6.55884221e-02f, -4.80768420e-02f, -8.45651552e-02f, -4.82331961e-02f, -3.01958565e-02f, -5.31332046e-02f, -7.48319626e-02f,
  5.93493462e-01f, 3.64633322e-01f, 2.19322488e-01f, 4.48921919e-01f, 5.39035350e-02f, 9.74038392e-02f, 2.47757673e-01f, 2.98683316e-01f, 7.52307057e-01f, -1.57023966e-01f,
  -1.94461927e-01f, 7.34480545e-02f, -1.44800976e-01f, 3.48320268e-02f, -3.13925385e-01f, -6.09904751e-02f, 1.19972147e-01f, 7.46345073e-02f, 3.60493720e-01f, 1.86969209e-02f,
  1.48737863e-01f, -4.32727218e-01f, -2.25757077e-01f, -2.16604128e-01f, -2.73490380e-02f, 2.70836651e-01f, -5.50707400e-01f, -2.43205316e-02f, -3.40564936e-01f, -8.68030190e-02f,
  -1.67467222e-02f, 2.28136212e-01f, 5.53077683e-02f, 1.75499067e-01f, 8.74750763e-02f, -1.48155605e-02f, -3.23768146e-02f, -9.12237689e-02f, 1.19881853e-01f, 3.77950147e-02f,
  3.30605134e-02f, -1.05313726e-01f, 8.09739158e-02f, -7.95177668e-02f, 2.33620808e-01f, 5.55898584e-02f, 8.97226930e-02f, 1.13860279e-01f, 2.25711986e-02f, -2.89050676e-02f,
  8.75093117e-02f, 4.46758978e-02f, 4.92496490e-02f, 5.74726239e-02f, 1.39445171e-01f, 2.25378349e-01f, 5.46949990e-02f, -4.18054946e-02f, 3.53092588e-02f, 6.09462000e-02f,
  -7.60085657e-02f, 9.07366574e-02f, -5.97790517e-02f, -4.76853922e-02f, -1.28555372e-02f, 4.74944897e-02f, -2.64467653e-02f, -7.57846460e-02f, 1.34560049e-01f, -9.61600021e-02f,
  2.01051738e-02f, 4.46248911e-02f, 1.01614252e-01f, 1.79234937e-01f, 9.92150232e-03f, 1.30989522e-01f, -9.62959081e-02f, -4.51619737e-02f, 1.51289299e-01f, -3.53416875e-02f,
  -5.15698642e-02f, 5.68515398e-02f, -1.10916384e-02f, -7.55332485e-02f, 1.13079157e-02f, 1.02271400e-02f, -1.24114444e-02f, -3.91041227e-02f, 2.38694735e-02f, -1.01757318e-01f,
  -1.67200379e-02f, 4.17963304e-02f, 7.79004842e-02f, -4.27417606e-02f, -1.69242993e-02f, -1.03942953e-01f, 1.24790892e-02f, 8.81586596e-02f, 3.95655110e-02f, -6.56275004e-02f,
  2.20049974e-02f, -1.92825776e-02f, -5.86918741e-02f, -9.89554897e-02f, -4.70911041e-02f, -7.51396567e-02f, -7.14267278e-03f, 1.44063443e-01f, 1.91564951e-03f, -8.61831158e-02f,
  -3.64556797e-02f, 8.07799026e-02f, 1.96584873e-03f, 4.66110781e-02f, 2.78935153e-02f, -7.22691417e-02f, 2.25287843e-02f, 8.78357738e-02f, -1.17056899e-01f, 3.74664366e-03f,
  -1.98120669e-01f, 2.96264529e-01f, -9.08667222e-02f, -1.74155816e-01f, 1.00852743e-01f, -7.35014305e-03f, 7.07755834e-02f, 1.24449126e-01f, -9.25102457e-02f, 3.28093410e-01f,
  -7.68758580e-02f, -2.15546694e-03f, -1.36489719e-01f, -2.72069395e-01f, -6.61000729e-01f, -5.20536363e-01f, -2.78308719e-01f, -9.20897424e-02f, -2.87434936e-01f, 4.68898052e-03f,
  -1.44348204e-01f, -1.65277392e-01f, -1.03676051e-01f, 1.68656379e-01f, 2.96395242e-01f, 2.93921262e-01f, 3.79134193e-02f, 2.12976217e-01f, 7.91667476e-02f, -4.63217758e-02f,
  1.26353219e-01f, 1.51141325e-03f, 1.17960498e-01f, 1.09362965e-02f, -2.44503394e-02f, 1.26845390e-01f, 1.53827250e-01f, -3.61775383e-02f, -1.18535357e-02f, -1.25335068e-01f,
  1.51230330e-02f, -1.88901369e-02f, -1.44947127e-01f, -8.58619362e-02f, 1.57072186e-01f, 1.34508470e-02f, -5.03395870e-02f, 6.66162223e-02f, -1.14998529e-02f, -1.16500594e-01f,
  4.70682159e-02f, -2.24318225e-02f, 3.08396425e-02f, -9.32602584e-02f, -2.08298471e-02f, -2.83282492e-02f, -2.56627221e-02f, 5.87174147e-02f, 3.07688024e-02f, -3.62216122e-02f,
  -5.90467174e-03f, 1.00775115e-01f, -5.68462089e-02f, 5.93365282e-02f, -4.29467894e-02f, 7.94040710e-02f, -3.43895443e-02f, -4.00681943e-02f, -4.57098484e-02f, -4.22249474e-02f,
  -1.57853682e-02f, 4.06234935e-02f, 4.90653154e-04f, 5.08572301e-03f, -3.35864052e-02f, 7.78681933e-05f, 5.54363206e-02f, -4.48559970e-02f, -2.35133599e-02f, 5.96347731e-03f,
  2.31353343e-02f, 4.08609621e-02f, 8.60635415e-02f, 7.28310123e-02f, -6.12604581e-02f, -3.78681459e-02f, 1.14713181e-02f, 1.70045160e-02f, -3.84800718e-03f, -6.78283051e-02f,
  1.96399018e-02f, -1.15631789e-01f, -6.85870871e-02f, 7.16708750e-02f, -6.49399497e-03f, -8.48648250e-02f, -5.64185716e-02f, -6.43349960e-02f, -2.80423928e-02f, -6.28480539e-02f,
  4.16901112e-02f, 4.20259722e-02f, 9.97475684e-02f, -1.47494553e-02f, -1.16695659e-02f, 5.80161698e-02f, 5.07331602e-02f, 8.95094033e-03f, 3.28004025e-02f, 7.12200010e-04f,
  1.61414117e-01f, -1.94714107e-02f, -8.52031484e-02f, 3.07633393e-02f, 6.39976189e-02f, 4.14575972e-02f, 2.64345128e-02f, 5.66367172e-02f, -8.61136541e-02f, 1.89713351e-02f,
  4.95279163e-01f, 1.40244380e-01f, -2.58204162e-01f, 8.47239885e-03f, 3.42351086e-02f, -1.32484827e-02f, -3.74971718e-01f, 1.67022094e-01f, -4.78137106e-01f, -2.56567776e-01f,
  7.87451565e-02f, 2.23445762e-02f, -3.30377549e-01f, 4.14126486e-01f, 4.25887853e-01f, -1.96160764e-01f, 4.15492743e-01f, 2.16645733e-01f, 7.69425556e-02f, 3.71113807e-01f,
  1.49942324e-01f, 4.73064512e-01f, 1.04020864e-01f, 4.14953947e-01f, 3.96785378e-01f, 1.40491918e-01f, 2.00534865e-01f, -1.15698852e-01f, 3.15230906e-01f, 2.20011473e-01f,
  -6.50405809e-02f, 4.51409668e-02f, 2.14865785e-02f, -7.03833029e-02f, -1.69228669e-02f, -5.45630157e-02f, -2.31482070e-02f, 1.78386979e-02f, -1.17894642e-01f, -6.40358627e-02f,
  -7.08905309e-02f, 7.30853826e-02f, 1.42805800e-01f, -5.84444776e-02f, 2.30427831e-02f, -5.04592620e-03f, -5.73298559e-02f, -8.21219087e-02f, -1.14609376e-01f, 7.21748993e-02f,
  -1.36430085e-01f, -1.44161591e-02f, 9.06461850e-02f, -9.80061386e-03f, -6.26537651e-02f, -7.93703925e-03f, -5.87481521e-02f, -6.85542747e-02f, 4.66571040e-02f, 1.54152634e-02f,
  1.10364184e-01f, -2.38681491e-02f, -6.03157422e-03f, -2.65868008e-02f, 1.20468093e-02f, -4.55756821e-02f, 8.54163915e-02f, -7.31735770e-03f, -6.69329762e-02f, -4.43299673e-03f,
  -7.06482381e-02f, 4.15200368e-02f, -9.56102386e-02f, -1.23216927e-01f, 8.84115323e-02f, 2.49678697e-02f, 3.56982425e-02f, 2.39860788e-02f, -1.59074873e-01f, -3.96333523e-02f,
  -6.44989908e-02f, 3.63921598e-02f, -1.08069025e-01f, -1.15654962e-02f, -4.66517359e-02f, -1.13810360e-01f, 7.59115964e-02f, -4.79818806e-02f, -1.14176348e-02f, 4.29083779e-02f,
  9.12909433e-02f, 1.97523341e-01f, -4.35515903e-02f, -9.38690379e-02f, -5.13164327e-02f, 1.25977173e-01f, -1.17702130e-02f, 1.21208668e-01f, 5.75158522e-02f, 1.50363576e-02f,
  1.47888355e-03f, -4.86347489e-02f, -5.42999990e-02f, 3.33522297e-02f, 8.06483498e-04f, -2.04026941e-02f, -6.38621822e-02f, -2.42909417e-01f, -3.90947908e-02f, 1.60147205e-01f,
  1.66768804e-02f, -1.00689515e-01f, 2.02774853e-02f, -7.26006553e-02f, -2.04529874e-02f, -5.07429354e-02f, 1.01399288e-01f, -8.19210988e-03f, 1.16617925e-01f, -1.10800333e-01f,
  -7.60900676e-01f, 3.89892608e-01f, -2.03491375e-01f, -4.99864407e-02f, -1.03859194e-01f, -8.46348032e-02f, 1.90711617e-01f, 3.11422329e-02f, 1.26695126e-01f, 3.60571593e-01f,
  1.79192677e-01f, -1.11232037e-02f, 2.99377382e-01f, 3.66692036e-01f, -4.39446419e-01f, 2.29048669e-01f, -1.06012486e-02f, 8.05944875e-02f, 5.44581972e-02f, 4.36573066e-02f,
  -1.12390660e-01f, 1.89481691e-01f, -7.02034831e-02f, 1.78253815e-01f, -1.41493931e-01f, -1.32731050e-01f, -1.83923289e-01f, 5.25758341e-02f, -7.54307806e-02f, -3.72794382e-02f,
  -3.14519018e-01f, -2.21351445e-01f, -6.38269559e-02f, -1.77367032e-01f, -1.44466117e-01f, -9.59461704e-02f, -9.77861062e-02f, 4.68593538e-02f, 1.96813643e-02f, -5.49265295e-02f,
  1.82794370e-02f, 2.22480018e-02f, 1.01364896e-01f, 6.82078823e-02f, -7.24943774e-03f, -4.19426933e-02f, 1.16772559e-02f, -7.60276020e-02f, 8.56028572e-02f, -1.74939223e-02f,
  4.04174216e-02f, -6.19236147e-04f, -3.89692225e-02f, 1.38415173e-02f, -1.08086899e-01f, -1.64589789e-02f, 2.23024711e-02f, -1.06833637e-01f, -1.25961944e-01f, -1.14626229e-01f,
  1.35864448e-02f, 4.17763591e-02f, 4.52268980e-02f, 1.58915482e-02f, 5.29731400e-02f, 1.29037499e-02f, 3.45356986e-02f, -1.67197024e-04f, -3.01237684e-03f, -5.07735042e-03f,
  5.30020799e-03f, -5.33937775e-02f, -6.91675171e-02f, -2.29773466e-02f, 1.87389664e-02f, 3.85260605e-03f, -1.49982693e-02f, -8.92889723e-02f, -1.98530573e-02f, -9.26185176e-02f,
  3.57436133e-03f, 3.52760553e-02f, -1.28252618e-02f, -8.29124451e-03f, -4.27512378e-02f, -3.66615802e-02f, -1.38517842e-02f, -3.59618217e-02f, -6.23765169e-04f, -9.41954330e-02f,
  -4.54387277e-01f, -4.21940267e-01f, 2.87338383e-02f, -1.00758456e-01f, 2.73808278e-03f, -5.37293181e-02f, 6.60156384e-02f, -4.01481614e-02f, -1.76561892e-01f, 2.52863131e-02f,
  1.29772071e-02f, 2.89762486e-02f, -6.70940652e-02f, 1.33619495e-02f, 3.06982435e-02f, -2.04012506e-02f, 7.13809673e-03f, -9.79378447e-03f, -9.86265689e-02f, -7.84255639e-02f,
  3.40714231e-02f, 3.34304199e-02f, 1.02446616e-01f, 6.15239050e-03f, 1.73659287e-02f, -7.97218680e-02f, -7.42525607e-02f, -9.84094385e-03f, -1.89181507e-01f, 7.55714178e-02f,
  1.28122494e-01f, 8.85529816e-02f, -5.95749497e-01f, -3.57481420e-01f, 2.74616003e-01f, 3.82040776e-02f, -8.92535150e-02f, 2.54982799e-01f, -7.07110837e-02f, 4.08326179e-01f,
  3.37636262e-01f, -1.96734164e-02f, 2.05543876e-01f, 1.61128730e-01f, -2.30151236e-01f, -1.64143424e-02f, -1.20348386e-01f, -3.51416990e-02f, 2.58026812e-02f, 6.85557798e-02f,
  -7.02537373e-02f, 4.55661148e-01f, -3.69301081e-01f, 2.09526837e-01f, 2.07645535e-01f, -1.42617017e-01f, 1.93037078e-01f, 6.68529421e-02f, -4.39919159e-03f, 1.69910312e-01f,
  -7.68200010e-02f, 1.88172475e-01f, -3.85614671e-02f, -4.41024117e-02f, 1.02232862e-02f, 1.61296632e-02f, -8.93415287e-02f, 1.49983913e-02f, -3.68577987e-02f, -1.68958884e-02f,
  6.91649243e-02f, 3.16404961e-02f, 3.83700989e-02f, 4.21530642e-02f, 8.84346440e-02f, -1.74616072e-02f, -7.17302263e-02f, -7.31125474e-02f, -8.53356272e-02f, 3.58705744e-02f,
  -7.98857287e-02f, -7.47333393e-02f, -2.21923646e-02f, -9.93768945e-02f, -4.04230766e-02f, 6.97657317e-02f, -1.53784961e-01f, -4.66760956e-02f, 1.34279840e-02f, 2.92536207e-02f,
  1.25815958e-01f, -3.43518588e-03f, -9.61392839e-03f, -7.54243508e-02f, 1.07129419e-03f, -3.67405452e-02f, 6.69916812e-03f, -1.28431663e-01f, -3.00646145e-02f, 5.68892770e-02f,
  -6.34040833e-02f, -1.86589193e-02f, 1.48369402e-01f, 1.68113280e-02f, 1.17534593e-01f, 3.36021557e-02f, -1.65646281e-02f, 5.67668006e-02f, -7.59430379e-02f, -9.18260589e-02f,
  -2.18490604e-02f, -8.39158799e-03f, -2.29688175e-02f, 9.30230543e-02f, 1.03852088e-02f, 5.23154289e-02f, 9.23992172e-02f, 1.75951160e-02f, -7.92146772e-02f, -3.56628560e-02f,
  9.02392715e-02f, 2.51998425e-01f, 6.10094517e-03f, -3.06526124e-02f, -1.46877751e-01f, 9.04377922e-02f, 1.55061614e-02f, -9.47958604e-03f, -1.96958170e-03f, 5.33340015e-02f,
  6.92502782e-02f, -2.68326327e-02f, 1.58757847e-02f, 8.85352120e-03f, -1.47304177e-01f, 1.43281281e-01f, 1.58292521e-02f, -6.15663119e-02f, -4.31833835e-03f, 2.61782901e-03f,
  2.92070527e-02f, 1.05758660e-01f, -3.08625158e-02f, -4.24759164e-02f, -2.99620572e-02f, 8.72792974e-02f, 8.67245942e-02f, -3.76062095e-02f, 2.19838005e-02f, -1.29210383e-01f,
  -1.78319678e-01f, 1.44456878e-01f, -1.42881081e-01f, 2.20187515e-01f, 3.94609183e-01f, 4.73049879e-01f, 2.92058259e-01f, 4.63920623e-01f, 5.46802223e-01f, 3.47470231e-02f,
  1.49273023e-01f, -2.52286911e-01f, -6.41204193e-02f, 1.99457422e-01f, -1.24838851e-01f, 6.27292022e-02f, 1.33067206e-01f, 1.24498293e-01f, 3.37310851e-01f, -3.40904505e-03f,
  7.67340884e-02f, 7.33382925e-02f, -3.33581120e-01f, -6.01864047e-02f, -1.67103693e-01f, -9.73367691e-02f, -2.67464727e-01f, -1.76993117e-01f, -1.39600992e-01f, 5.07383719e-02f,
  4.92414050e-02f, 2.09287509e-01f, -1.77209869e-01f, -1.16143525e-01f, -1.43772200e-01f, -1.03988148e-01f, -1.62293077e-01f, -6.00953139e-02f, 1.03304966e-03f, 8.37737247e-02f,
  -1.38828814e-01f, -2.97259521e-02f, 1.34550169e-01f, 5.46282269e-02f, 9.19313952e-02f, -2.92130653e-02f, 4.85528372e-02f, 1.37961665e-02f, 7.21736103e-02f, -4.23187613e-02f,
  -1.06101513e-01f, 4.09973077e-02f, -2.18854081e-02f, 2.61191428e-02f, -2.83760428e-02f, 1.15078449e-01f, -5.90570867e-02f, -3.85947600e-02f, -1.38973156e-02f, 3.55596617e-02f,
  -1.24229519e-02f, 9.53274220e-03f, 2.88362079e-03f, 2.44441908e-02f, 5.11717563e-03f, 2.38902271e-02f, -8.91091768e-03f, -3.06401029e-02f, -2.10417286e-02f, -1.71009731e-02f,
  1.04925990e-01f, -1.27582373e-02f, 1.19080894e-01f, 3.11052725e-02f, 5.33150416e-03f, 3.06888502e-02f, -7.20890760e-02f, 7.74397030e-02f, -5.24829887e-03f, -2.43340675e-02f,
  -1.54739013e-02f, 2.07259646e-03f, 1.08524738e-02f, -5.52546978e-02f, -7.95151964e-02f, 5.90482131e-02f, 1.30728230e-01f, 9.08359662e-02f, 5.45722581e-02f, -4.18504048e-03f,
  1.00476898e-01f, 1.45415798e-01f, 5.49359582e-02f, 6.01423122e-02f, -7.45847002e-02f, 1.56585909e-02f, -5.90986349e-02f, 1.12391673e-01f, 6.87844902e-02f, 7.42947534e-02f,
  -3.28041762e-02f, -4.21291031e-02f, -5.30897081e-02f, 7.49416277e-02f, -8.98562893e-02f, 1.24037035e-01f, -3.85094285e-02f, -2.58962228e-03f, -4.53286283e-02f, -4.28198429e-04f,
  -2.05351830e-01f, -6.32715225e-02f, -1.43193737e-01f, 9.03120786e-02f, 7.12870359e-02f, -3.85081433e-02f, 6.17070347e-02f, 1.08693764e-02f, -5.95667288e-02f, 4.01569940e-02f,
  -6.58475831e-02f, 4.54589993e-01f, 5.59874177e-01f, 2.04271749e-01f, -2.58354485e-01f, -3.82122308e-01f, -3.35731089e-01f, 2.13262349e-01f, -1.04047783e-01f, 7.61614516e-02f,
  -8.50766152e-02f, 2.75489092e-01f, 7.88796395e-02f, 1.58485353e-01f, -2.40185916e-01f, -2.03503907e-01f, -1.10905617e-02f, 2.29830835e-02f, 3.23403860e-03f, 2.92264432e-01f,
  7.07632154e-02f, -3.32552105e-01f, 3.13080341e-01f, -2.63478905e-02f, 2.29615465e-01f, 2.80893624e-01f, 8.09236616e-02f, 6.12217076e-02f, 2.81346917e-01f, -1.33277133e-01f,
  -3.14790756e-02f, 1.14926957e-01f, 2.16333613e-01f, 7.03400327e-03f, 1.43053964e-01f, 8.88282713e-03f, 5.50690070e-02f, -9.31350589e-02f, -7.67693147e-02f, 8.03247094e-02f,
  3.40237841e-02f, 6.48836344e-02f, 3.50325294e-02f, -5.55886813e-02f, 9.32037458e-03f, 9.68108028e-02f, 1.45497963e-01f, 1.00942060e-01f, 1.64533466e-01f, 1.75211847e-01f,
  1.84166700e-01f, 1.84635267e-01f, 8.46087262e-02f, 6.06154352e-02f, 9.73081663e-02f, -6.05014898e-02f, -3.90536971e-02f, 1.32236227e-01f, 4.18042429e-02f, -2.88900863e-02f,
  -2.90005635e-02f, -1.02889396e-01f, -6.14025854e-02f, 4.25396301e-02f, -8.30079541e-02f, -5.49267940e-02f, -2.62095351e-02f, -3.88797484e-02f, -5.56185097e-02f, 8.95355083e-03f,
  -3.58485430e-02f, 6.42476827e-02f, -1.39223114e-01f, -6.97911084e-02f, -1.37026822e-02f, -4.15782630e-02f, -4.33288654e-03f, 5.62828034e-02f, 5.71152642e-02f, 1.39745409e-02f,
  -1.20941326e-01f, -1.45068005e-01f, -1.10150300e-01f, 4.27261274e-03f, -1.12218387e-01f, 2.18288619e-02f, 1.03269197e-01f, 6.05205521e-02f, 6.54075444e-02f, 2.52309870e-02f,
  4.78028059e-02f, 1.82749286e-01f, 8.10781196e-02f, -5.43092750e-02f, 1.02628479e-02f, 7.18437210e-02f, -2.29487345e-02f, 1.12960771e-01f, 5.74635230e-02f, -8.30549523e-02f,
  1.19775884e-01f, -2.62224358e-02f, 1.62801566e-03f, -3.04342452e-02f, -5.68741048e-03f, 6.70667589e-02f, -4.88413423e-02f, -2.85933912e-02f, 9.26998034e-02f, 1.28250003e-01f,
  1.47758976e-01f, -7.65389204e-02f, -1.69243440e-02f, -7.34508932e-02f, 1.49870319e-02f, 5.27820960e-02f, -8.07584301e-02f, 1.07368879e-01f, 2.54390594e-02f, -3.37212486e-03f,
  3.16049278e-01f, 6.29101813e-01f, 8.54709558e-03f, 1.47417769e-01f, -1.16921321e-01f, 2.31693432e-01f, 1.01604223e-01f, -5.95858656e-02f, 9.34441760e-03f, 3.68412375e-01f,
  -1.73714131e-01f, 4.49671358e-01f, -1.23366781e-01f, 2.48850375e-01f, -1.73252523e-01f, -2.30720311e-01f, 3.89874518e-01f, 2.34709695e-01f, -1.15793154e-01f, 2.99571037e-01f,
  -1.25234783e-01f, 1.64516345e-01f, -2.57529825e-01f, -1.14402436e-02f, 3.28177989e-01f, 1.33699864e-01f, -5.69598973e-02f, -1.60321265e-01f, 2.69517899e-01f, -5.05842417e-02f,
  -8.00307989e-02f, 1.50061753e-02f, 9.04203020e-03f, 1.12351207e-02f, 1.71973743e-02f, 5.02044149e-02f, 9.14413631e-02f, -5.49593493e-02f, -1.74671203e-01f, 6.59962595e-02f,
  2.02949822e-01f, -7.00489804e-02f, 7.69054741e-02f, 7.22458353e-03f, 1.17303558e-01f, 6.01710081e-02f, -4.09277901e-03f, 3.87988314e-02f, 9.77340043e-02f, -1.51769277e-02f,
  -1.16683496e-02f, 4.20207568e-02f, 4.20357250e-02f, 8.38313699e-02f, -5.65564670e-02f, -1.26169985e-02f, 1.19644836e-01f, 8.41993988e-02f, 2.06811845e-01f, 1.34768918e-01f,
  2.00652517e-02f, 9.12840739e-02f, 1.21466983e-02f, -5.56388460e-02f, 2.05004439e-02f, -8.47418532e-02f, 6.70854375e-03f, -1.21916205e-01f, -8.04669857e-02f, 2.20011156e-02f,
  -2.13278383e-02f, 4.11333553e-02f, 7.75425211e-02f, 6.18667863e-02f, 9.91343614e-03f, 8.72520655e-02f, -5.14957681e-02f, 2.08443962e-02f, 1.00019863e-02f, -1.23716943e-01f,
  -5.29114045e-02f, 2.80743707e-02f, 6.22624345e-02f, -8.66353735e-02f, -1.20816983e-01f, -3.14588621e-02f, 1.15623273e-01f, 1.27682500e-02f, -6.28062785e-02f, 1.79446060e-02f,
  1.53867289e-01f, 5.20858943e-01f, -2.59663295e-02f, 4.51240242e-02f, -2.70552877e-02f, 9.74849537e-02f, 7.60387480e-02f, 1.05907312e-02f, 1.00186363e-01f, 8.79705027e-02f,
  9.12076905e-02f, -2.74894312e-02f, 1.16856031e-01f, -4.87615019e-02f, -5.37138730e-02f, 1.04835637e-01f, 6.46869838e-02f, 5.53614274e-02f, 4.76634353e-02f, 7.88041651e-02f,
  9.92816910e-02f, 6.59973472e-02f, -1.25335976e-02f, 3.82744446e-02f, 5.44320270e-02f, 6.09279284e-03f, 1.48103565e-01f, -2.26016771e-02f, 5.42643890e-02f, -9.87332221e-03f,
  -5.91647066e-02f, 3.43875408e-01f, -1.41439408e-01f, -2.80731022e-01f, -2.52040029e-01f, 5.16531646e-01f, 2.92428255e-01f, -3.52505296e-02f, -2.65815616e-01f, 2.52084702e-01f,
  1.50005549e-01f, -2.84450054e-01f, 2.94604540e-01f, 3.54180992e-01f, 8.49799626e-03f, 5.44971168e-01f, 2.80209661e-01f, 1.71307892e-01f, 1.72837935e-02f, 3.78794037e-02f,
  -1.37230948e-01f, 2.42580056e-01f, 2.33225092e-01f, 4.90757786e-02f, 1.18752994e-01f, -2.70867646e-01f, -3.28265190e-01f, -1.95399702e-01f, -1.08822800e-01f, -3.11177373e-02f,
  2.60516882e-01f, 7.39036277e-02f, 1.17067724e-01f, 1.03708640e-01f, 1.20001487e-01f, 4.76141721e-02f, -8.17892253e-02f, -5.56442887e-02f, -7.13904649e-02f, -6.06906042e-02f,
  -1.16022937e-01f, -1.21185090e-02f, 1.94394160e-02f, -1.10762298e-01f, -1.06952578e-01f, -5.31436503e-02f, 1.36693818e-02f, 7.37299994e-02f, -2.60727797e-02f, 1.10844418e-01f,
  3.14433090e-02f, 9.25589874e-02f, -9.36281011e-02f, -4.51869667e-02f, -1.23798952e-01f, -3.57662477e-02f, 1.14967428e-01f, -8.50327760e-02f, 7.98367485e-02f, -1.15363382e-01f,
  -1.48034349e-01f, 2.22781543e-02f, 2.19732881e-01f, 7.38340020e-02f, 6.73040524e-02f, 1.08378783e-01f, -9.87854227e-03f, 2.54918896e-02f, -1.28702462e-01f, 1.44876301e-01f,
  -3.98923680e-02f, -8.21170658e-02f, 5.94875887e-02f, 5.80892861e-02f, -2.54196506e-02f, 1.08924732e-01f, 4.18489333e-03f, -5.37731722e-02f, -4.08097990e-02f, -6.56514987e-02f,
  -4.02299240e-02f, -6.35734275e-02f, 9.80586261e-02f, -6.28263950e-02f, 1.20266043e-01f, -9.47205797e-02f, 2.53490321e-02f, 7.43303895e-02f, 5.07887788e-02f, -1.18244484e-01f,
  6.07291944e-02f, -3.08908578e-02f, 9.53669176e-02f, 8.11801553e-02f, 3.68247330e-02f, 1.57625571e-01f, 3.77007760e-02f, -1.81981605e-02f, -2.69852187e-02f, 5.92929907e-02f,
  -8.46835151e-02f, -4.01356183e-02f, -5.20365238e-02f, -1.68137029e-01f, -1.10788926e-01f, 8.72543305e-02f, -4.31790994e-03f, -8.74349475e-02f, -1.65667251e-01f, -6.31571338e-02f,
  9.64195468e-03f, 3.57755870e-02f, -5.13887256e-02f, 2.66036317e-02f, -1.83368266e-01f, -2.59907134e-02f, -3.89446765e-02f, -2.65344866e-02f, -3.36296968e-02f, -1.73462760e-02f,
  1.58371478e-01f, -7.59428963e-02f, -3.26673388e-01f, 8.49106982e-02f, 4.12144572e-01f, 3.05599451e-01f, 2.64684618e-01f, 3.03861111e-01f, 3.07445139e-01f, 1.25150576e-01f,
  8.94921124e-02f, -2.57780313e-01f, -1.15757406e-01f, -1.91237420e-01f, -7.14835674e-02f, -1.59095034e-01f, 1.81396469e-01f, 4.27955873e-02f, 2.62903310e-02f, 1.97400108e-01f,
  1.51066497e-01f, 9.76041630e-02f, -3.42172682e-01f, 5.34151644e-02f, 7.68413544e-02f, -5.72575033e-02f, -2.15664413e-02f, -1.57999739e-01f, -1.39363423e-01f, -1.04497455e-01f,
  -9.47862864e-02f, -3.52974050e-02f, -9.68885794e-02f, -1.73115715e-01f, 1.61851361e-01f, 1.63472667e-01f, 1.61384158e-02f, -1.13668248e-01f, -1.17993660e-01f, 1.44014852e-02f,
  -1.17341219e-03f, -9.91174951e-02f, -4.19894494e-02f, -9.99399349e-02f, 5.64027131e-02f, 9.95233580e-02f, -8.21043402e-02f, 2.67663207e-02f, -2.96934992e-02f, -7.33884797e-02f,
  -6.52072281e-02f, -5.64926676e-03f, 1.16483770e-01f, -3.30613814e-02f, -1.11839160e-01f, 1.84639227e-02f, -2.24403664e-02f, -5.46437129e-02f, -9.06191580e-03f, 1.51044391e-02f,
  4.60555479e-02f, 3.90090756e-02f, 5.77918515e-02f, -1.36615997e-02f, -1.06854131e-03f, 5.13514504e-02f, 4.78652604e-02f, 2.60551218e-02f, 5.20660579e-02f, 3.01152691e-02f,
  1.29603520e-01f, -9.58782621e-03f, -5.54956356e-03f, -1.17159681e-02f, 7.28380233e-02f, -8.17766935e-02f, 5.61420880e-02f, -4.03872170e-02f, 1.34291679e-01f, -7.38321664e-03f,
  -3.57157737e-02f, 7.38715306e-02f, -1.00994527e-01f, 2.20761728e-02f, -1.94700155e-02f, -4.66685779e-02f, 7.45200515e-02f, -3.30686718e-02f, 3.33190039e-02f, 1.30878553e-01f,
  2.12761343e-01f, 2.54643410e-01f, -8.22223630e-03f, -1.81992084e-01f, -9.87587404e-03f, 8.97900388e-02f, 4.03476832e-03f, 3.35728154e-02f, -3.90248001e-02f, 7.68256634e-02f,
  1.68197304e-01f, 1.20461628e-01f, 2.07461491e-01f, -1.13960631e-01f, -3.89844961e-02f, 2.10649952e-01f, -5.26960306e-02f, 5.03006671e-03f, 6.01929910e-02f, -2.04204284e-02f,
  6.26952350e-02f, 2.07736015e-01f, 4.00107987e-02f, 1.14842258e-01f, 1.06401429e-01f, 3.93051542e-02f, 1.63033783e-01f, -1.01476386e-01f, 4.83739842e-03f, 1.04810502e-02f,
  -4.32691067e-01f, -4.08513784e-01f, -2.12705866e-01f, -5.01935899e-01f, 5.19183040e-01f, 7.33328938e-01f, -2.35936195e-01f, 1.19289413e-01f, -5.06975293e-01f, -7.78907388e-02f,
  1.08348086e-01f, -4.47421670e-01f, -3.39935452e-01f, -1.51665315e-01f, 6.77594077e-03f, -3.00537825e-01f, 5.34060709e-02f, -1.75248712e-01f, -2.82860488e-01f, -1.58875406e-01f,
  -4.43472266e-02f, 3.07494938e-01f, -1.22876190e-01f, 3.25538427e-01f, 7.42537677e-02f, -4.13744822e-02f, 2.01387092e-01f, 6.57684952e-02f, 2.38670275e-01f, 1.63171396e-01f,
  5.47822677e-02f, -2.87099451e-01f, 2.20878832e-02f, -3.72053348e-02f, 1.73671290e-01f, 1.55460581e-01f, 8.38360004e-03f, -3.91061092e-03f, -1.55461291e-02f, -1.62752196e-02f,
  -8.22440162e-03f, 5.47697060e-02f, -4.34984080e-02f, -3.77016291e-02f, 7.37573719e-03f, 3.88134234e-02f, 3.74676883e-02f, 4.86683547e-02f, -4.39849608e-02f, -1.39505789e-01f,
  -1.27674669e-01f, -1.24102216e-02f, -9.65488404e-02f, -8.72338712e-02f, -1.32388785e-01f, -5.75343706e-02f, -7.50690624e-02f, -2.30194419e-03f, 4.92834635e-02f, -4.69193421e-02f,
  2.11282372e-02f, -5.86006977e-02f, -1.26568899e-02f, -4.72542569e-02f, -2.48007961e-02f, 1.07882336e-01f, -2.18988266e-02f, 6.94087595e-02f, -8.75011086e-02f, 1.04001023e-01f,
  4.98038009e-02f, -2.96627283e-02f, -1.47537114e-02f, 7.52481446e-02f, -3.92505005e-02f, -2.88357865e-02f, 3.81118990e-02f, -3.50808688e-02f, -5.86182661e-02f, 5.19514605e-02f,
  -3.61911692e-02f, -5.81071861e-02f, 5.92667460e-02f, -5.66612510e-03f, 2.96253078e-02f, -6.59800321e-02f, 1.22793661e-02f, 7.13871792e-02f, -1.28219593e-02f, 1.49410660e-03f,
  -4.95713763e-03f, -1.33805305e-01f, 2.20088363e-02f, 2.43086573e-02f, 2.14209724e-02f, 1.87103927e-01f, 4.90392298e-02f, 4.39063683e-02f, 3.17219719e-02f, -1.68740042e-02f,
  7.31240734e-02f, 5.13532236e-02f, 9.01584923e-02f, -1.78898461e-02f, 4.34037223e-02f, 8.10609013e-02f, -2.26822887e-02f, 1.07268564e-01f, 1.79635435e-01f, 1.06851153e-01f,
  3.03144772e-02f, 3.22107635e-02f, -2.00204309e-02f, -7.74279563e-03f, 1.15114506e-02f, 5.17048091e-02f, 5.05522676e-02f, -9.52369645e-02f, -1.26933474e-02f, -3.48696159e-03f
};

// L0_fan_Bp_bar (Shape: 1 x 26)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 26;
const float L0_fan_Bp_bar_data[] = {
  3.44816267e-01f, 4.17154402e-01f, 5.89182436e-01f, 2.71383315e-01f, 3.69348198e-01f, 1.69937700e-01f, 3.31309855e-01f, 3.69758129e-01f, 1.54295504e-01f, 3.23838681e-01f,
  5.60935318e-01f, 5.92475295e-01f, 4.56797838e-01f, 1.94215834e-01f, 4.19356227e-01f, 4.49990690e-01f, 5.19081831e-01f, 3.39743763e-01f, 1.64269462e-01f, 4.82159257e-01f,
  3.62217933e-01f, 4.00777131e-01f, 6.12605751e-01f, 3.68092477e-01f, 4.16106761e-01f, 8.50638866e-01f
};

// L1_linear_W (Shape: 12 x 64)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 64;
const float L1_linear_W_data[] = {
  9.38803032e-02f, -3.65884364e-01f, -1.90366022e-02f, -2.44740188e-01f, 4.58172895e-02f, -5.73288649e-02f, -3.52422386e-01f, 4.58087288e-02f, -1.38679847e-01f, -2.04204202e-01f,
  -2.04758495e-01f, 1.00711323e-01f, 8.99908692e-02f, 4.56561744e-02f, -1.60037100e-01f, -2.01052148e-02f, 2.00190723e-01f, -3.37504745e-01f, 2.13995248e-01f, -9.14183781e-02f,
  3.69721562e-01f, 4.07796562e-01f, -5.84849596e-01f, 1.41919449e-01f, 4.63703834e-02f, 1.65495738e-01f, 3.03116113e-01f, 2.54086584e-01f, -3.64074916e-01f, -3.22276711e-01f,
  1.92952961e-01f, 3.82888973e-01f, 1.21856377e-01f, -1.56316966e-01f, 2.01914892e-01f, 1.37020275e-01f, -2.28619710e-01f, -2.19075933e-01f, -1.31756961e-01f, -1.38122544e-01f,
  7.96835590e-03f, 7.19452143e-01f, -2.71092862e-01f, 8.33328426e-01f, -4.90264624e-01f, -5.55670619e-01f, -5.24217486e-02f, -6.17077529e-01f, 2.73019940e-01f, -7.60670304e-01f,
  -1.72013491e-01f, -1.24662712e-01f, -5.23847461e-01f, -4.83333737e-01f, -1.74859799e-02f, -7.12553561e-01f, 5.95867395e-01f, -2.07505539e-01f, 1.08131178e-01f, -1.58901900e-01f,
  -1.05771780e-01f, 5.56050956e-01f, -1.95619777e-01f, -3.42913568e-01f, -3.00004840e-01f, 1.37304336e-01f, -3.55140924e-01f, 1.05796620e-01f, 2.56187022e-01f, -5.58653533e-01f,
  -2.27434695e-01f, 1.00773305e-01f, -2.16072693e-01f, 9.41924378e-02f, -6.56572133e-02f, -2.39585295e-01f, -1.64716348e-01f, 9.14794877e-02f, -9.40428227e-02f, -1.19456023e-01f,
  -1.34463191e-01f, -6.28222227e-02f, -3.33297700e-01f, 6.20282471e-01f, 4.59104240e-01f, 1.78535819e-01f, 6.19241953e-01f, -2.95007229e-01f, 2.19083369e-01f, 1.97706923e-01f,
  -3.00788432e-01f, 2.47327209e-01f, 4.96312141e-01f, -4.98674273e-01f, 5.71572006e-01f, 1.18224069e-01f, -3.65444869e-01f, -5.00628829e-01f, 2.27337345e-01f, 5.67940295e-01f,
  1.30087927e-01f, 5.84186971e-01f, -3.75285536e-01f, -1.05477579e-01f, -5.32848835e-01f, 1.61718398e-01f, -3.98999631e-01f, -7.76678920e-01f, -5.14471114e-01f, -2.24367172e-01f,
  -3.82386804e-01f, 2.88272262e-01f, 4.15381104e-01f, -2.07937378e-02f, -6.67170823e-01f, -5.61547399e-01f, -3.94994672e-03f, -6.41695440e-01f, -2.75166065e-01f, 4.52209830e-01f,
  -2.38315374e-01f, 5.90325296e-01f, 4.29298341e-01f, -3.80862832e-01f, 4.75967765e-01f, 2.96704948e-01f, 3.56720001e-01f, 8.24390128e-02f, -3.74698818e-01f, 8.07635933e-02f,
  8.16951767e-02f, 1.88284125e-02f, -6.54512420e-02f, 1.47839323e-01f, -9.00854096e-02f, -1.86679766e-01f, 2.90164232e-01f, -1.79024227e-02f, -2.77175367e-01f, -3.35880637e-01f,
  -5.96012659e-02f, -1.74111590e-01f, -1.59320474e-01f, -1.98532324e-02f, 6.15703911e-02f, 3.38497199e-02f, -8.31417516e-02f, 1.53170332e-01f, -6.94372430e-02f, 2.90122360e-01f,
  2.01544955e-01f, 3.66997011e-02f, 4.25364226e-02f, 1.57597706e-01f, -3.47451866e-01f, 1.71209395e-01f, 2.62748063e-01f, -1.94962114e-01f, 2.95576364e-01f, 1.79284036e-01f,
  4.51423168e-01f, -6.76360130e-02f, 2.84973770e-01f, 9.30796191e-02f, 6.03943467e-02f, 1.35540664e-01f, -1.48368508e-01f, -2.44032189e-01f, -5.48161447e-01f, -4.00699496e-01f,
  -4.83538628e-01f, -1.69510037e-01f, -8.54138583e-02f, -2.41237860e-02f, -1.82674989e-01f, -2.84627497e-01f, -3.90759289e-01f, -3.89958590e-01f, 5.49771011e-01f, 6.97981596e-01f,
  3.76182556e-01f, -4.22088265e-01f, 2.05487162e-01f, 3.61036956e-01f, -1.44364864e-01f, -4.33625698e-01f, -2.23601624e-01f, -5.81721604e-01f, -1.64959714e-01f, -5.04926145e-01f,
  -3.55482608e-01f, 5.91897905e-01f, 1.34004995e-01f, -2.53191292e-01f, 1.85972881e-02f, -1.55454993e-01f, -1.81175500e-01f, 1.17881652e-02f, -2.14565858e-01f, -1.34101778e-01f,
  -1.19320787e-01f, -4.54131663e-01f, -1.79057196e-02f, -1.16098233e-01f, -4.24920857e-01f, -3.00821126e-01f, -6.11119986e-01f, -4.43059117e-01f, 1.78979412e-01f, -9.58899260e-02f,
  -3.32120806e-01f, -5.27955174e-01f, 1.71772361e-01f, -2.59476691e-01f, -2.08785146e-01f, -4.06962931e-01f, -3.46909285e-01f, -3.18037003e-01f, -1.25691533e-01f, 4.87244993e-01f,
  -3.48969996e-02f, 2.03037858e-01f, -1.00021809e-01f, -1.19056739e-01f, -3.16082805e-01f, 1.68495685e-01f, -3.35158631e-02f, -3.05841237e-01f, -2.18631029e-01f, 1.16348132e-01f,
  4.87245955e-02f, 7.14555860e-01f, -3.08330476e-01f, 4.50648040e-01f, -1.88946456e-01f, -6.36831895e-02f, 4.19978112e-01f, 3.92345250e-01f, -3.76053788e-02f, 4.58939642e-01f,
  -6.99977934e-01f, -6.22906685e-01f, -1.94474056e-01f, -3.88131797e-01f, -2.31920123e-01f, -1.52895674e-01f, 3.16951245e-01f, -3.78690004e-01f, 5.43691456e-01f, 4.42395329e-01f,
  6.40272796e-02f, -1.36833146e-01f, -2.79475540e-01f, -3.26816916e-01f, -2.94732094e-01f, -1.43576980e-01f, 1.64220497e-01f, 2.07173288e-01f, 1.05871215e-01f, 3.63467604e-01f,
  9.85902026e-02f, 1.12360336e-01f, 7.08997324e-02f, 3.13169360e-01f, 3.30124170e-01f, 1.71053439e-01f, -6.87688915e-03f, 4.03600857e-02f, -7.86808282e-02f, 1.11536458e-01f,
  3.10068697e-01f, -4.65434231e-02f, 4.80335206e-02f, 1.36301935e-01f, 1.11135781e-01f, 8.42446461e-02f, 1.21663705e-01f, 2.68524349e-01f, 1.33030593e-01f, 3.79367948e-01f,
  4.31600749e-01f, 2.95020759e-01f, 6.73833311e-01f, -3.93794835e-01f, -5.02057195e-01f, -8.41228366e-02f, -5.23286223e-01f, -7.85267770e-01f, 5.14861286e-01f, 3.68314534e-01f,
  -6.94821835e-01f, -3.92673969e-01f, 8.58484209e-02f, -4.79638487e-01f, -6.47838414e-01f, 3.11020851e-01f, 6.99363708e-01f, -5.25780082e-01f, -7.33713359e-02f, 2.03033194e-01f,
  5.22882879e-01f, 7.37573922e-01f, -5.12292206e-01f, -6.68336272e-01f, -1.12549052e-01f, -2.65729219e-01f, -4.56568509e-01f, -5.91721758e-02f, -3.94905806e-01f, -8.52686539e-02f,
  -9.44175646e-02f, 1.84925213e-01f, 9.21868011e-02f, -3.67487818e-01f, 8.57652724e-02f, 1.88008398e-01f, -6.76989973e-01f, 3.66953939e-01f, -4.10918593e-01f, 4.52400625e-01f,
  2.70982534e-01f, 4.63395655e-01f, 2.16119811e-01f, 1.38292134e-01f, 2.04522222e-01f, -3.54546696e-01f, 1.84385240e-01f, 3.56711358e-01f, 3.21364462e-01f, 3.42389554e-01f,
  3.60571325e-01f, 2.68501192e-01f, 1.39966488e-01f, 2.28137061e-01f, 2.49376982e-01f, 2.67977417e-01f, 3.08005303e-01f, 3.05811130e-02f, 4.71313506e-01f, -5.15519321e-01f,
  -6.74435854e-01f, -1.49749503e-01f, 1.47764996e-01f, -9.64530259e-02f, 4.56201494e-01f, 6.32618189e-01f, -1.13792554e-01f, 6.40663743e-01f, -2.00166538e-01f, 4.77768630e-01f,
  -1.39529750e-01f, 3.32906365e-01f, 1.85115978e-01f, -2.08222464e-01f, 5.51746070e-01f, -4.96277571e-01f, -4.47367549e-01f, -1.06479086e-01f, -1.90100953e-01f, -2.98196524e-01f,
  5.01609802e-01f, -7.88620532e-01f, -4.56165850e-01f, -2.47775823e-01f, -1.48375332e-02f, -7.38497794e-01f, 2.70686924e-01f, -3.33119035e-01f, -2.49839667e-02f, 6.64090157e-01f,
  -7.65466988e-01f, -6.54214844e-02f, -2.51461893e-01f, 5.71680367e-01f, -6.56504393e-01f, -3.85458887e-01f, 4.93204705e-02f, -3.56356174e-01f, 4.12946492e-01f, -3.09533626e-01f,
  3.84890676e-01f, 1.48263067e-01f, 1.86794475e-01f, -9.28740323e-01f, 1.62780449e-01f, -4.03715461e-01f, 2.21981242e-01f, -3.96882534e-01f, -1.34541884e-01f, -4.59045172e-02f,
  -3.76200736e-01f, -1.81029007e-01f, 2.45246254e-02f, -3.71858627e-01f, 3.44147325e-01f, -2.12076609e-03f, -3.71200532e-01f, -2.73754925e-01f, 6.65191785e-02f, 4.99441195e-03f,
  4.81989160e-02f, -8.56496170e-02f, 1.11767426e-01f, 1.60025924e-01f, -3.78997236e-01f, -4.73571345e-02f, 3.13603669e-01f, 3.42152506e-01f, -1.72311723e-01f, -5.66442072e-01f,
  -2.44415492e-01f, -3.33857954e-01f, 2.60390133e-01f, 3.49752009e-01f, 5.94921768e-01f, -2.62115955e-01f, 2.67663419e-01f, 2.54949093e-01f, 1.14169806e-01f, -3.41513529e-02f,
  6.87328279e-01f, 3.11895818e-01f, -2.48545319e-01f, 2.97133476e-01f, -4.02680933e-01f, -7.65459985e-02f, 2.38192156e-01f, -1.33649305e-01f, -4.49791431e-01f, -5.95053971e-01f,
  1.01347096e-01f, -6.31546155e-02f, -3.13477784e-01f, 3.46530974e-01f, 7.07931757e-01f, -7.38015175e-01f, 5.57660818e-01f, 6.20456398e-01f, 5.70679381e-02f, -4.14519370e-01f,
  -3.10833752e-01f, -2.45820671e-01f, 4.21199292e-01f, -4.30831373e-01f, -7.89658904e-01f, -1.41909167e-01f, 4.01973248e-01f, -1.31437778e-01f, -2.97898680e-01f, -1.44174293e-01f,
  -3.46709996e-01f, -2.61935722e-02f, 3.68925487e-03f, -1.67281270e-01f, -7.53858536e-02f, 1.70407277e-02f, -1.86873436e-01f, 2.40214959e-01f, -2.60721594e-01f, -2.60585397e-01f,
  -1.13679625e-01f, 1.81511343e-01f, 1.45736232e-01f, 5.72814196e-02f, -3.70434523e-01f, -5.37167117e-02f, 9.72164422e-02f, -1.79284617e-01f, -3.35780054e-01f, -2.07067132e-01f,
  1.83787405e-01f, -2.45180696e-01f, -1.12551145e-01f, -3.90989482e-02f, 2.62227744e-01f, -3.17641318e-01f, 9.36128497e-02f, 3.39927375e-01f, -1.81497961e-01f, -1.51459679e-01f,
  8.19532480e-03f, -2.22378209e-01f, -2.62467057e-01f, -9.08758715e-02f, 2.46508848e-02f, -1.34060502e-01f, 1.12292483e-01f, -2.67542601e-01f, -1.70341477e-01f, -3.52886111e-01f,
  -1.66762292e-01f, 5.03920794e-01f, 1.04415514e-01f, 2.11614296e-01f, 7.74275720e-01f, 5.82458198e-01f, 3.52751128e-02f, -2.11095095e-01f, 1.44585788e-01f, 3.43336999e-01f,
  -3.35277289e-01f, -9.78514850e-02f, -5.22340178e-01f, -3.11180860e-01f, -3.19379717e-01f, -7.02569857e-02f, -1.92757890e-01f, -2.81756282e-01f, -1.54816225e-01f, -1.92881748e-01f,
  -2.05407411e-01f, -2.93673098e-01f, 7.71460310e-02f, -4.71543483e-02f, -5.97261190e-02f, -8.93190578e-02f, -1.06310435e-01f, -3.66460212e-04f, 9.46938172e-02f, 5.19991331e-02f,
  -1.20433323e-01f, -1.93565339e-02f, 1.82872728e-01f, 1.63719922e-01f, 7.46703288e-03f, 1.00025795e-01f, 4.06500883e-02f, -1.21285571e-02f, -2.03136772e-01f, -3.62632453e-01f,
  -1.87933862e-01f, -5.02651110e-02f, -1.08543679e-01f, -1.64561555e-01f, -3.47091943e-01f, 2.24055693e-01f, -2.71901309e-01f, 8.76799971e-03f, 4.11809474e-01f, 2.25879252e-01f,
  7.97185488e-03f, 2.47376844e-01f, -1.46556377e-01f, 7.44065866e-02f, -4.16404724e-01f, 1.01352498e-01f, 1.67300984e-01f, 1.92666858e-01f, 2.99225003e-01f, 2.18153924e-01f,
  4.09591019e-01f, 3.57982606e-01f, 5.70926845e-01f, 1.51179463e-01f, -2.73458153e-01f, -1.13989741e-01f, -2.18079835e-01f, -7.84651116e-02f, 5.22479340e-02f, -5.42919993e-01f,
  -4.62163240e-01f, -1.79550380e-01f, -2.28444949e-01f, 3.46156687e-01f, 3.96109879e-01f, -1.83993712e-01f, -4.23863739e-01f, 4.05753821e-01f, -2.87511259e-01f, -8.73763338e-02f,
  -3.83048147e-01f, 5.63818395e-01f, 2.31258973e-01f, -5.62812269e-01f, -1.36810869e-01f, -6.37887776e-01f, 1.66702479e-01f, -6.16092980e-03f, 3.79815102e-02f, 1.61945447e-01f,
  1.52076989e-01f, 3.86939734e-01f, 5.08522689e-01f, -2.16652170e-01f, -2.00729921e-01f, -1.74987406e-01f, -5.30411378e-02f, 3.51369798e-01f, 4.17885810e-01f, -3.05303768e-03f,
  -6.51635677e-02f, 2.70397365e-01f, -2.47357905e-01f, 3.22647423e-01f, 1.34667292e-01f, 1.35084108e-01f, -1.03851728e-01f, -5.68895102e-01f, 1.61414728e-01f, 2.83901751e-01f,
  -5.13452768e-01f, 6.04074895e-02f, -4.32755023e-01f, -4.46882337e-01f, 4.19842035e-01f, -5.34342527e-01f, -5.41023493e-01f, 4.67531413e-01f, 2.34134614e-01f, -5.27720511e-01f,
  -2.38858476e-01f, -3.83861333e-01f, -4.85245407e-01f, 1.11627705e-01f, -5.93963154e-02f, -6.38163090e-01f, -1.76304474e-01f, -1.71772197e-01f, 8.33793998e-01f, -1.42053202e-01f,
  -5.03207743e-01f, 4.04596150e-01f, -3.25263202e-01f, -1.91854835e-01f, 8.15322280e-01f, 1.28633916e-01f, -3.10159296e-01f, -1.72032993e-02f, -2.48841286e-01f, -3.92728001e-01f,
  -2.51200318e-01f, -3.35365802e-01f, -4.26017195e-01f, -2.62074560e-01f, -5.75220585e-01f, -2.24114299e-01f, -3.01320583e-01f, -1.55160815e-01f, -3.39188337e-01f, -8.75739902e-02f,
  -2.78644525e-02f, -1.30862892e-01f, 1.01931103e-01f, -4.14972678e-02f, -2.85920054e-01f, -2.45366581e-02f, 2.95930326e-01f, 8.65413845e-02f, 2.95472652e-01f, -5.66619188e-02f,
  5.36300801e-02f, 8.13106745e-02f, 1.43716753e-01f, 1.80778936e-01f, 7.94107541e-02f, 2.97657132e-01f, 1.28608271e-01f, 1.88669935e-01f, 4.09421355e-01f, 5.51126540e-01f,
  3.53084743e-01f, 3.43720376e-01f, -2.85441697e-01f, -2.94139653e-01f, -2.55130678e-01f, -2.31071964e-01f, 4.83879596e-01f, 6.27306923e-02f, -4.66458082e-01f, -1.12203760e-02f,
  -1.74273133e-01f, -2.00143963e-01f, -3.13399702e-01f, 1.89504176e-01f, -7.44505897e-02f, 3.07883322e-01f, 1.79805726e-01f, -2.84678578e-01f, 6.39714122e-01f, -6.82976484e-01f,
  4.81316298e-02f, -2.86904514e-01f, -2.89478302e-01f, -4.82938141e-01f, -4.96816993e-01f, -3.29949677e-01f, -5.95082879e-01f, 4.54025924e-01f, -1.71999738e-01f, -3.32446605e-01f,
  -4.13517118e-01f, -2.43613556e-01f, -3.09967101e-01f, -3.03044975e-01f, 6.12684488e-01f, -4.28961635e-01f, -5.52126288e-01f, 2.38267243e-01f, -4.34709907e-01f, 2.86927242e-02f,
  1.54355720e-01f, -6.23161912e-01f, 5.00076532e-01f, 6.89783871e-01f, -1.36308968e-01f, 1.81520239e-01f, 1.59773722e-01f, 3.08247134e-02f, 2.02783793e-01f, 2.57383168e-01f,
  4.12040912e-02f, 5.66934086e-02f, 7.23233372e-02f, 1.78971097e-01f, -2.18512610e-01f, 4.65853326e-02f, 7.58755133e-02f, 1.00497454e-01f, 6.99753612e-02f, -8.35583284e-02f,
  1.31186917e-01f, 1.78238079e-01f, -2.77827084e-01f, -3.50874156e-01f, 3.60415012e-01f, 1.01271093e-01f, -4.24510092e-01f, -1.13168254e-01f, 1.14966510e-02f, -2.67297685e-01f,
  -4.08514440e-01f, -3.55314493e-01f, 6.52042925e-02f, 2.11733207e-01f, 2.19479337e-01f, 4.45556611e-01f, -2.54244208e-01f, 3.83249581e-01f, -2.71741599e-01f, 3.76518458e-01f,
  8.34248737e-02f, -3.01977724e-01f, -1.64082229e-01f, 2.74994105e-01f, -4.77213621e-01f, -2.88932949e-01f, -2.45737702e-01f, -3.66960108e-01f, 3.91473621e-01f, -6.48831502e-02f,
  -1.72977328e-01f, -2.02432722e-01f, -2.66658515e-01f, 3.75243694e-01f, 6.31425321e-01f, -4.05604690e-01f, -6.00323498e-01f, 4.75600690e-01f, 4.16004837e-01f, -9.16064754e-02f,
  -3.19566995e-01f, -4.68495369e-01f, -5.27845621e-01f, 6.45336092e-01f, 4.79015470e-01f, -3.53978127e-01f, -3.93409550e-01f, -5.04635990e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  3.99171077e-02f, 5.37564494e-02f, -2.88791806e-02f, -5.56735359e-02f, 9.42845941e-02f, 1.34407088e-01f, 3.11738923e-02f, 2.00233832e-02f, -1.27795756e-01f, 5.24743423e-02f,
  4.10206132e-02f, 1.00564897e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 19, 26
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        64, 12
    );
    }
    