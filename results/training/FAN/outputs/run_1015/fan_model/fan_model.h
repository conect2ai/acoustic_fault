/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 9 x 120)
const int L0_fan_Wp_rows = 9;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -2.98375487e-01f, 2.04210669e-01f, 4.87450421e-01f, -7.57220984e-02f, 2.36921921e-01f, 2.93706566e-01f, 3.21221679e-01f, -9.97512862e-02f, -2.39917800e-01f, 1.97994694e-01f,
  5.08612022e-02f, -3.86710614e-01f, -2.65219957e-01f, -2.20504031e-01f, -1.47635341e-01f, 4.99372423e-01f, 3.63598585e-01f, 1.54214963e-01f, -2.86945730e-01f, -2.27244750e-01f,
  -1.76538080e-01f, -2.07212016e-01f, -2.72404939e-01f, -1.82958990e-01f, 8.09234455e-02f, -1.84789807e-01f, 3.38208050e-01f, 1.03874899e-01f, 1.84995398e-01f, 4.46800768e-01f,
  1.69753671e-01f, 1.39680907e-01f, -1.48575678e-01f, -1.70870483e-01f, 5.16859815e-02f, -6.43293373e-03f, 7.12476112e-03f, -7.74668753e-02f, -1.22475298e-02f, 2.56054178e-02f,
  1.52539779e-02f, -6.94659352e-02f, 5.14405333e-02f, -4.88222130e-02f, 2.33466346e-02f, -5.32684214e-02f, -8.91597643e-02f, -8.36763345e-03f, 5.90805300e-02f, 1.09052122e-01f,
  4.56020236e-02f, 1.60141438e-01f, 1.26219675e-01f, -1.00260638e-02f, 6.18940331e-02f, -5.56372106e-02f, 7.56110176e-02f, 1.62285734e-02f, 1.20380834e-01f, 1.45951658e-01f,
  -1.11548208e-01f, 9.59174857e-02f, 4.46283184e-02f, -7.39318803e-02f, -2.94512287e-02f, -3.30830663e-02f, 5.97307570e-02f, -2.55700741e-02f, -1.06473351e-02f, 1.40307304e-02f,
  -1.76871680e-02f, 1.30214514e-02f, -1.86093058e-03f, 3.74304652e-02f, 5.69753051e-02f, 1.48179695e-01f, 8.89366418e-02f, -6.48734495e-02f, -1.26533695e-02f, -3.97075862e-02f,
  -9.33009759e-02f, 7.11178919e-03f, 2.38642879e-02f, 8.75076931e-03f, 4.64556254e-02f, 1.66077423e-03f, 4.77132462e-02f, -3.36473249e-02f, -2.44550849e-03f, 1.01492479e-02f,
  -3.60587716e-01f, -1.48222856e-02f, -3.52547467e-02f, -1.14856623e-01f, 8.47085640e-02f, -2.00915746e-02f, -3.32804881e-02f, 1.35446815e-02f, -4.24210429e-02f, 3.63391116e-02f,
  -1.57843325e-02f, -1.31238922e-01f, -3.89235513e-03f, 2.10248828e-02f, -1.71664357e-02f, -4.77933884e-02f, -3.70688327e-02f, -3.55129037e-03f, -4.19368409e-02f, 4.85255308e-02f,
  -4.54526544e-02f, 4.43041883e-02f, -7.08168074e-02f, -2.36372333e-02f, -2.92296242e-02f, -6.40927553e-02f, -1.23697827e-02f, -7.38254562e-02f, -4.18085828e-02f, -3.19736525e-02f,
  -2.56061345e-01f, -3.87611508e-01f, 1.04677871e-01f, -4.50007111e-01f, 2.38111019e-01f, 4.30110902e-01f, 1.49277508e-01f, 4.24282160e-03f, -1.61560461e-01f, -1.51802287e-01f,
  1.20331720e-01f, 2.32920945e-01f, 1.78814918e-01f, 1.99250937e-01f, 1.91127434e-01f, -4.49594297e-02f, -1.77714691e-01f, 2.53635924e-02f, 3.87301803e-01f, 3.28724325e-01f,
  1.54243195e-02f, -3.54025513e-01f, -3.74835908e-01f, -1.29719451e-01f, -2.97102273e-01f, 3.51184830e-02f, -3.13910872e-01f, -1.84029415e-01f, 1.30707487e-01f, -4.08443153e-01f,
  8.82220194e-02f, -1.92271039e-01f, 1.45185426e-01f, 2.19257046e-02f, 7.89113622e-03f, -3.90426479e-02f, 6.55387118e-02f, -9.01001468e-02f, -2.81389523e-02f, -1.11744098e-01f,
  -7.80900940e-02f, 1.34031940e-02f, -3.60972807e-02f, -5.13573401e-02f, -1.03677958e-01f, 9.44515411e-03f, -2.02127069e-01f, -7.23058060e-02f, -1.76345576e-02f, 1.39009077e-02f,
  -4.65306900e-02f, 1.17561780e-03f, 5.93899228e-02f, 9.09906160e-03f, 1.98632106e-02f, 9.09878314e-02f, -5.03051169e-02f, -6.73748851e-02f, 1.18599780e-01f, -2.16033220e-01f,
  -1.38518780e-01f, 4.75459248e-02f, 1.02367938e-01f, 1.42850457e-02f, -5.91853261e-02f, 6.05954975e-02f, -1.41573381e-02f, 2.20882650e-02f, -2.37757228e-02f, -7.12684020e-02f,
  6.08019941e-02f, 2.38930639e-02f, -2.10433379e-02f, 1.28481667e-02f, -2.10552961e-02f, 9.95785743e-03f, 3.76268998e-02f, -4.55548279e-02f, -8.48170444e-02f, -8.22031125e-02f,
  2.39529628e-02f, 9.74576697e-02f, -6.06717356e-02f, 5.91011047e-02f, -2.44451724e-02f, 8.11580941e-02f, -7.69896284e-02f, 2.59943474e-02f, -7.53581524e-03f, 2.69690738e-03f,
  -1.12797052e-01f, 1.15587853e-01f, -3.65258791e-02f, 2.57167518e-02f, -9.72054806e-03f, 2.93681510e-02f, 8.19219463e-03f, 9.67473444e-03f, -2.57943943e-02f, 7.64003396e-02f,
  5.40577509e-02f, 7.46241538e-03f, -8.73486921e-02f, -4.48969714e-02f, 2.26574112e-02f, 7.23640546e-02f, 2.71899849e-02f, 4.64652330e-02f, 4.65931259e-02f, -5.06153367e-02f,
  -1.03678800e-01f, 3.93904336e-02f, 1.79552764e-01f, 7.05914050e-02f, 5.42193763e-02f, 2.05552906e-01f, 8.87007192e-02f, 7.62503669e-02f, 2.69770980e-01f, -1.63408041e-01f,
  3.66178334e-01f, 6.17692769e-01f, -2.43021235e-01f, 2.09539756e-01f, -2.04483956e-01f, -2.52406985e-01f, -7.51088485e-02f, -6.00011228e-03f, 9.08584073e-02f, 3.08175325e-01f,
  -9.28050801e-02f, -6.15545176e-02f, 5.35536669e-02f, -6.57825619e-02f, -1.47956908e-01f, 2.41497636e-01f, 1.00332461e-01f, -2.36893088e-01f, -4.30150568e-01f, -2.37483576e-01f,
  4.66841981e-02f, 2.13142157e-01f, 2.05327403e-02f, 3.81279923e-02f, 5.21272302e-01f, 6.63112998e-02f, 2.48759627e-01f, 2.00724497e-01f, 9.57306772e-02f, 5.35662591e-01f,
  -1.48923462e-02f, 7.43264006e-03f, -1.98909968e-01f, -3.43985260e-02f, -9.08688605e-02f, 5.85623309e-02f, 4.39611301e-02f, 3.96728739e-02f, -2.66231447e-02f, 9.82630998e-02f,
  -5.70939332e-02f, -5.55260666e-03f, -2.13415790e-02f, 1.55863920e-02f, 1.96666247e-03f, 2.40955949e-02f, 2.99960412e-02f, 3.31180207e-02f, -7.88838640e-02f, -6.28423020e-02f,
  4.18262519e-02f, -2.92478651e-02f, -1.55944943e-01f, 1.94756954e-03f, -7.01086521e-02f, -8.99943337e-02f, -7.48937391e-03f, 3.96666341e-02f, -9.20188427e-03f, 3.77081662e-01f,
  1.93661265e-03f, -5.95065439e-03f, -9.05535445e-02f, 3.66368592e-02f, 3.71328220e-02f, 1.22947395e-02f, -2.53338292e-02f, 4.04952802e-02f, -1.17464932e-02f, 2.84783971e-02f,
  -6.40646294e-02f, -6.88503776e-03f, -7.61268660e-02f, 6.75162748e-02f, 1.33167338e-02f, -2.90685706e-02f, 7.37629225e-03f, 5.90667985e-02f, -3.08072213e-02f, 2.60095373e-02f,
  -2.78341528e-02f, -5.55793159e-02f, 7.05306372e-03f, 6.96338480e-03f, -8.32754150e-02f, -4.90732305e-02f, -1.24314027e-02f, -6.85771927e-02f, -1.57686397e-02f, -1.20257877e-03f,
  1.67630255e-01f, -3.04568976e-01f, 1.41498819e-01f, 3.51793356e-02f, -8.65766034e-03f, -4.59566899e-02f, 1.36373062e-02f, 4.01225761e-02f, 5.52165741e-03f, 3.93069573e-02f,
  -4.67585437e-02f, -4.13590530e-03f, 4.76026274e-02f, 6.64599091e-02f, -4.55978811e-02f, -6.81368494e-03f, 4.83978689e-02f, -3.57048325e-02f, -2.59048422e-03f, 2.05441955e-02f,
  2.30190214e-02f, -2.39647776e-02f, 8.38767663e-02f, 5.44442236e-02f, -3.37535962e-02f, -9.32753384e-02f, 5.51177301e-02f, 6.22601733e-02f, -1.84035003e-01f, 3.72439116e-01f,
  1.18279025e-01f, 2.86448121e-01f, 1.18405581e-01f, 2.32887059e-01f, 2.43808359e-01f, 2.59022862e-02f, 1.48088694e-01f, 1.55308545e-01f, 1.82251975e-01f, 1.08329378e-01f,
  -1.20224021e-01f, -2.86172330e-01f, -2.77016342e-01f, -2.49215320e-01f, -2.13746101e-01f, 4.95955534e-02f, 2.10826799e-01f, -1.31608307e-01f, -2.91318417e-01f, -8.22616294e-02f,
  5.06384410e-02f, 2.31426150e-01f, 2.05174014e-01f, 6.69659451e-02f, 3.68075103e-01f, 9.90778580e-03f, 1.79863751e-01f, 2.51412928e-01f, -1.15120389e-01f, 1.95943058e-01f,
  -3.14982414e-01f, 3.23877960e-01f, -1.35554940e-01f, -3.30481194e-02f, 5.24983294e-02f, 2.51373835e-02f, 3.69402058e-02f, 1.34341717e-01f, 4.19550389e-02f, 1.47832230e-01f,
  5.47659723e-03f, 4.50506434e-02f, -2.72614812e-03f, 8.42753351e-02f, 1.19688161e-01f, -3.16756517e-02f, 1.14059910e-01f, 5.09386547e-02f, -3.28439623e-02f, -2.42050346e-02f,
  -1.03295664e-03f, 7.06603099e-03f, -1.71536691e-02f, 6.04873821e-02f, 7.37208351e-02f, -9.14266929e-02f, 1.54582024e-01f, 8.59583467e-02f, 1.26454756e-02f, 1.80813327e-01f,
  1.30183890e-01f, 4.77751978e-02f, 6.35351464e-02f, 2.69392282e-02f, -3.34839970e-02f, 1.48675535e-02f, -1.98581778e-02f, -6.08549006e-02f, 5.02635799e-02f, 9.69853029e-02f,
  -1.24967963e-01f, -1.04755193e-01f, -4.02389690e-02f, -1.46890897e-02f, -1.06755607e-01f, -1.62083153e-02f, -4.05556411e-02f, -1.28225863e-01f, -5.17891012e-02f, -2.62766778e-02f,
  -1.56961866e-02f, -1.18522570e-01f, 7.97960982e-02f, -6.03082851e-02f, -1.00789338e-01f, -7.40975291e-02f, -1.29389623e-02f, -2.02912418e-03f, 7.09747383e-03f, 5.95596470e-02f,
  1.68163814e-02f, -1.62387326e-01f, -3.48978192e-02f, 4.71530184e-02f, 1.67292416e-01f, 2.04114784e-02f, 3.82430889e-02f, 6.90705776e-02f, 6.15600012e-02f, -3.72350886e-02f,
  -4.38406654e-02f, 2.25062892e-02f, 5.36684543e-02f, 5.89436740e-02f, 2.07364336e-02f, 5.24822958e-02f, 7.11101964e-02f, -4.43717800e-02f, 1.39051517e-02f, 1.64867729e-01f,
  1.31456479e-01f, 4.20420431e-02f, -9.99575108e-02f, -2.33485960e-04f, 5.53882457e-02f, -1.21101536e-01f, -7.45723471e-02f, 6.16475828e-02f, -1.38070926e-01f, 3.59735489e-02f,
  5.76471984e-01f, 1.41960859e-01f, 1.90311551e-01f, -2.33170614e-01f, -2.53623754e-01f, 2.40096092e-01f, 5.14836490e-01f, 2.03937978e-01f, -2.63162583e-01f, -4.68135066e-02f,
  -2.18220934e-01f, -4.30942476e-01f, -3.39453965e-01f, -1.22210927e-01f, 2.36219600e-01f, 2.65504897e-01f, -2.07722913e-02f, 4.77426276e-02f, 9.51732099e-02f, -3.43134552e-02f,
  -3.23259920e-01f, -1.98292106e-01f, -8.73166025e-02f, -8.73466730e-02f, -3.37868452e-01f, -3.22213978e-01f, -1.99842453e-01f, -2.79730380e-01f, -5.14392033e-02f, -2.85426736e-01f,
  -2.20212430e-01f, 1.94995910e-01f, -1.13542385e-01f, -1.86775461e-01f, -2.13288262e-01f, -6.56927153e-02f, -7.60438442e-02f, -1.33343413e-01f, -6.01907708e-02f, -1.06567785e-01f,
  -2.11157471e-01f, -8.37550238e-02f, -1.50881261e-01f, -1.40286490e-01f, -3.55467945e-02f, -1.00477729e-02f, -1.02153555e-01f, 2.32388526e-02f, -8.66771340e-02f, -9.00118500e-02f,
  -1.98223352e-01f, -1.09380648e-01f, 4.58719879e-02f, -3.30003202e-02f, 6.71747327e-02f, -1.09872945e-01f, -3.21631543e-02f, -1.02713391e-01f, -3.11094448e-02f, -1.89348862e-01f,
  1.02785891e-02f, 3.48103940e-02f, 9.04647559e-02f, 1.17976137e-01f, 5.97523637e-02f, 1.57369643e-01f, 9.93439034e-02f, 5.38240783e-02f, 1.62428454e-01f, 2.23238338e-02f,
  1.25812441e-01f, 1.01165913e-01f, 7.77761266e-02f, 8.19964632e-02f, 2.53957231e-02f, 1.05995841e-01f, 1.11941874e-01f, 7.51230717e-02f, 8.80100429e-02f, 1.19129963e-01f,
  4.62687202e-02f, 1.13829523e-01f, 3.18920724e-02f, 4.77477089e-02f, 1.86143115e-01f, 1.18927173e-01f, 1.03384145e-01f, 1.24191694e-01f, -7.07733585e-03f, 1.22055545e-01f,
  -3.34506482e-01f, 8.01456794e-02f, -1.05936468e-01f, -1.22317128e-01f, -1.81687936e-01f, -1.26680151e-01f, -1.98698938e-01f, -1.89147308e-01f, -1.68980926e-01f, -7.43809268e-02f,
  -8.42412934e-02f, -2.69699544e-02f, -1.47278666e-01f, -9.86025557e-02f, -1.61865801e-01f, -1.18552484e-01f, -1.97311029e-01f, -1.53381899e-01f, -6.93015605e-02f, -1.41949102e-01f,
  -9.61818248e-02f, -7.70019665e-02f, -1.09082125e-01f, -1.80711851e-01f, -1.94728360e-01f, -1.07707128e-01f, -1.89737305e-01f, -6.52893633e-02f, 9.81447548e-02f, -8.83527286e-03f,
  -8.03344786e-01f, 3.86390835e-01f, 1.35808557e-01f, -8.81967247e-02f, 4.55509484e-01f, 3.04690868e-01f, 4.58167821e-01f, 1.44869804e-01f, -8.95255059e-02f, 2.46396556e-01f,
  1.52196705e-01f, -2.67601735e-03f, -9.10375863e-02f, 5.22483401e-02f, -2.56257765e-02f, 3.07193965e-01f, 4.09199089e-01f, -2.31296450e-01f, -2.80357540e-01f, 1.15218297e-01f,
  1.63505867e-01f, -3.69084217e-02f, -3.70070159e-01f, -1.75091580e-01f, 1.74009189e-01f, 8.31319615e-02f, 1.54648766e-01f, 1.13837712e-01f, 2.44828373e-01f, 2.99755901e-01f,
  -1.12925820e-01f, -7.53322616e-02f, 2.38334965e-02f, 7.88246691e-02f, 6.18068501e-02f, 2.46630665e-02f, 3.64645831e-02f, 5.74941337e-02f, 7.04813655e-03f, 1.03621870e-01f,
  1.28255546e-01f, -4.19290876e-03f, 9.82788950e-02f, 7.30733648e-02f, -5.82990609e-03f, 3.43354680e-02f, 3.47954929e-02f, 4.21063555e-03f, 3.12735364e-02f, 1.56563878e-01f,
  2.98573256e-01f, 1.32116050e-01f, 5.57398312e-02f, 1.24155335e-01f, 1.00807980e-01f, 1.57353487e-02f, 3.67891341e-02f, 8.62794667e-02f, 4.77030780e-03f, -2.63948087e-02f,
  1.34152230e-02f, -8.23172629e-02f, -2.52840924e-03f, -2.15499084e-02f, -1.14761934e-01f, -3.44645306e-02f, -4.97365780e-02f, -7.96542782e-03f, -9.65006053e-02f, -7.94433653e-02f,
  -6.90500662e-02f, 9.95308161e-03f, -8.55257511e-02f, 2.71167662e-02f, 1.36158410e-02f, 6.66333437e-02f, -2.44336352e-02f, 2.21557748e-02f, -1.07064933e-01f, -4.06265222e-02f,
  -1.40839294e-01f, -5.90933189e-02f, -9.72936004e-02f, -7.22592250e-02f, -8.41769110e-03f, -3.64357829e-02f, -3.21815051e-02f, -4.58690859e-02f, -7.35664889e-02f, -4.24178652e-02f,
  -9.84489992e-02f, 6.16106316e-02f, 3.69742815e-03f, -2.54244767e-02f, 3.22505133e-03f, 1.23581160e-02f, 6.50218353e-02f, 2.49384660e-02f, 8.76342803e-02f, 3.86592769e-03f,
  -2.98323687e-02f, -1.35530056e-02f, -6.79771304e-02f, 9.60353948e-03f, 1.30109088e-02f, 2.44147927e-02f, 1.88246258e-02f, 7.65024051e-02f, 1.34077623e-01f, 8.16629454e-02f,
  1.12514451e-01f, 5.63045293e-02f, -1.50102628e-02f, 1.84731871e-01f, 1.86396092e-02f, 3.06414962e-02f, 1.25842646e-01f, 3.88000980e-02f, 1.15224691e-02f, 1.05799519e-01f,
  -4.18628342e-02f, 4.15050052e-02f, 2.21137583e-01f, 7.64922053e-02f, 1.96870565e-01f, 3.26217413e-01f, 5.14442861e-01f, 5.44478185e-02f, -1.48690268e-01f, 1.30514547e-01f,
  -4.92015705e-02f, -2.17965990e-01f, -1.55945532e-02f, 1.16655111e-01f, 2.61795849e-01f, 4.05605942e-01f, 3.08555573e-01f, 2.14355662e-01f, 2.59045452e-01f, 2.32132837e-01f,
  1.43149033e-01f, -7.04130530e-03f, -1.19640261e-01f, -4.37840074e-02f, -5.65329082e-02f, -1.73167467e-01f, -8.75309110e-02f, -1.02044679e-01f, -1.08710587e-01f, -1.67993382e-01f,
  6.33232370e-02f, -1.31576627e-01f, 1.30828246e-01f, -4.79577407e-02f, -1.23015065e-02f, 1.60610564e-02f, 1.07267693e-01f, 7.06447847e-03f, -7.86897317e-02f, 4.74309437e-02f,
  -5.47451116e-02f, 4.36507240e-02f, 1.22007295e-01f, 5.46332896e-02f, 1.30388528e-01f, 1.20498061e-01f, 3.44951265e-02f, -1.14780595e-03f, -7.50139588e-03f, -6.96097910e-02f,
  -9.93532389e-02f, -2.24192161e-02f, 4.71614189e-02f, 1.75148137e-02f, 4.48054634e-02f, 7.65568465e-02f, 2.77289674e-02f, -9.68099087e-02f, 8.59769955e-02f, 2.41669845e-02f,
  2.84675099e-02f, 1.19191017e-02f, -1.12365112e-02f, -2.95562521e-02f, -5.13652861e-02f, -1.69093367e-02f, 5.77248521e-02f, -4.02603560e-04f, 3.33666243e-02f, 2.04895474e-02f,
  5.42900488e-02f, -1.35693408e-03f, 1.50827616e-02f, 9.30868462e-02f, 1.08669617e-03f, 4.05923203e-02f, -6.54012803e-03f, -2.00145189e-02f, -9.32560638e-02f, -3.55112590e-02f,
  -1.16335694e-02f, -1.45752998e-02f, 1.82900652e-02f, 9.41218995e-03f, -1.22090049e-01f, 9.88009050e-02f, 1.70019106e-03f, -2.13325303e-02f, 2.02370901e-02f, -9.11651924e-03f,
  3.11426278e-02f, 5.63358814e-02f, 1.61365628e-01f, 5.03690653e-02f, 7.36923590e-02f, -5.53345308e-02f, -1.56101752e-02f, 3.14130285e-03f, -1.26370387e-02f, 6.94473162e-02f,
  6.97344989e-02f, 6.06611222e-02f, 8.57414976e-02f, 5.74902557e-02f, 1.79525599e-01f, 6.91211596e-02f, 2.83773661e-01f, 9.52920765e-02f, 4.51164320e-02f, -3.02429963e-02f,
  5.39108589e-02f, 4.48835120e-02f, 1.71656728e-01f, 1.11579672e-01f, 9.61563375e-04f, 3.19025032e-02f, 1.13315903e-01f, 1.38597906e-01f, 1.42055467e-01f, 2.77236402e-01f,
  4.81287301e-01f, 2.52773046e-01f, -2.19733909e-01f, 8.65265206e-02f, 1.58679467e-02f, 4.08207066e-02f, 9.13212597e-02f, 2.31680661e-01f, 3.11161671e-02f, 9.22095329e-02f,
  2.23953143e-01f, 1.62708342e-01f, 1.14972048e-01f, -4.50695828e-02f, -3.91617790e-02f, -1.95367455e-01f, -2.91192144e-01f, -3.44043881e-01f, -2.59692222e-01f, -1.05476595e-01f,
  -2.21154392e-01f, -4.16992828e-02f, -1.12775132e-01f, -1.82908460e-01f, -2.11462766e-01f, -1.86545104e-01f, -7.47336745e-02f, -1.93089798e-01f, -1.34463787e-01f, -4.42000359e-01f,
  -1.73976645e-01f, -4.66413068e-04f, -2.08555833e-01f, -1.91836655e-01f, -1.50178447e-01f, -1.29853845e-01f, -9.18084085e-02f, -1.09114073e-01f, -1.22169830e-01f, -1.28294766e-01f,
  -1.26813367e-01f, -1.37004778e-01f, -1.16087161e-01f, -3.01042140e-01f, -2.00448155e-01f, -2.08021134e-01f, -2.16410354e-01f, -1.42453119e-01f, -1.73863485e-01f, -1.89088568e-01f,
  -2.53693074e-01f, -2.21790746e-01f, -9.83259007e-02f, -1.40083045e-01f, -2.79106796e-01f, -2.44149446e-01f, -1.07251644e-01f, -2.84814090e-01f, -1.85054511e-01f, -2.42983013e-01f,
  -1.66039363e-01f, 1.94955438e-01f, 2.15550318e-01f, 1.73050597e-01f, 1.48663014e-01f, 1.42477855e-01f, 9.79816020e-02f, 1.68139398e-01f, 9.88795310e-02f, 1.26706794e-01f,
  2.03459397e-01f, 8.67341012e-02f, 1.78245053e-01f, 2.35282391e-01f, 2.04999208e-01f, 1.64283916e-01f, 1.30599901e-01f, 1.76576346e-01f, 7.56037533e-02f, 1.26090437e-01f,
  1.30632654e-01f, 1.86799198e-01f, 1.64482251e-01f, 1.23369642e-01f, 1.37310877e-01f, 1.60362527e-01f, 9.60992351e-02f, 1.68334782e-01f, 1.40533477e-01f, 1.37352541e-01f,
  2.30863497e-01f, -9.69834104e-02f, -1.60294399e-01f, -6.30102307e-02f, -2.12820292e-01f, -1.59942344e-01f, -2.31532827e-01f, -1.76684678e-01f, -9.75862220e-02f, -1.05590872e-01f,
  -8.07570517e-02f, -1.65949255e-01f, -1.28388718e-01f, -1.42452821e-01f, -1.76605314e-01f, -1.74096346e-01f, -1.06834762e-01f, -1.61131099e-01f, -1.61190003e-01f, -9.63097289e-02f,
  -1.35789394e-01f, -1.60540804e-01f, 2.76570264e-02f, -1.38082832e-01f, -2.13934407e-01f, -7.81945605e-03f, -1.68760493e-01f, -1.51500553e-01f, 2.57417150e-02f, 6.04997156e-03f,
  -1.58740833e-01f, -1.66193128e-01f, -2.36090288e-01f, -3.26623887e-01f, 1.07517652e-02f, 3.66602719e-01f, 3.25232625e-01f, 2.42565796e-01f, -8.99959654e-02f, -5.83054610e-02f,
  -1.28385186e-01f, 2.59162933e-02f, 6.58488721e-02f, 2.46020425e-02f, 1.87796488e-01f, 1.41461313e-01f, 2.78045610e-02f, -7.17056077e-03f, 1.61156461e-01f, 1.90170750e-01f,
  1.03282444e-01f, -2.20943004e-01f, -2.66410679e-01f, -1.02578163e-01f, -2.26308286e-01f, -3.21147256e-02f, -2.13120446e-01f, -2.92604566e-01f, -5.69129363e-02f, -4.81536865e-01f,
  -1.73856765e-01f, -2.59792328e-01f, 8.57377797e-02f, -1.38730496e-01f, -1.57909274e-01f, 5.08381575e-02f, 5.72092123e-02f, -1.77376717e-01f, -7.81846568e-02f, -1.25196483e-02f,
  -1.53321818e-01f, -1.25384599e-01f, -1.11538626e-01f, -9.23277959e-02f, -5.35106920e-02f, -1.25148403e-03f, -1.12986706e-01f, -1.35143682e-01f, -8.90669748e-02f, -1.33881733e-01f,
  -6.67642802e-02f, -1.57067686e-01f, -4.74922694e-02f, -1.40694985e-02f, -1.00763058e-02f, -8.27886984e-02f, -1.21592268e-01f, -1.02661796e-01f, 6.88164011e-02f, -9.52619612e-02f,
  -6.14078119e-02f, 2.19659936e-02f, 6.57546744e-02f, -3.14161889e-02f, 7.27544874e-02f, 3.87232341e-02f, -3.97468284e-02f, -2.05037929e-02f, 8.81993175e-02f, -6.24344777e-03f,
  5.94540359e-03f, 5.53006753e-02f, -3.35214250e-02f, 8.59600119e-03f, -4.59787697e-02f, -8.74903500e-02f, -7.97577575e-03f, -6.40075281e-02f, -1.36712613e-02f, -4.65788953e-02f,
  3.91743286e-03f, 1.35076553e-01f, -4.87203710e-02f, -1.90596096e-02f, -2.56941114e-02f, -3.24281789e-02f, -2.29657255e-02f, 4.03943881e-02f, -3.77150974e-03f, -9.01960805e-02f,
  6.15853556e-02f, 1.01664357e-01f, -3.93753648e-02f, 4.77583669e-02f, 1.12540601e-02f, -3.72510515e-02f, -8.64271596e-02f, -8.09389725e-02f, -1.46604925e-01f, -1.24523984e-02f,
  5.66248596e-02f, 1.61522366e-02f, 1.19163073e-03f, 3.54855396e-02f, 7.56957084e-02f, 2.02855803e-02f, -1.13128843e-02f, 1.66152082e-02f, 7.32156858e-02f, -5.08665070e-02f,
  7.11213099e-03f, 2.15868577e-01f, 1.65041298e-01f, 1.61912575e-01f, 7.98263997e-02f, 1.96022302e-01f, 1.54798776e-01f, 1.85228437e-01f, 3.51069808e-01f, 1.93166897e-01f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  8.03321660e-01f, 1.92162022e-01f, 6.73001707e-01f, 2.45018691e-01f, 3.30146074e-01f, 5.36888540e-01f, 5.14733434e-01f, 2.98436433e-01f, -1.35063067e-01f, 1.31130740e-01f,
  -2.74479669e-02f, -4.68262285e-01f, -4.83716726e-01f, -3.40638757e-01f, -1.67001829e-01f, -1.78229176e-02f, -1.26558021e-01f, 1.94404349e-01f, 3.48121196e-01f, 6.65887222e-02f,
  -4.10799474e-01f, -4.43354957e-02f, 3.50154042e-01f, -5.56859113e-02f, -9.64227691e-02f, -3.52263838e-01f, 1.64721116e-01f, 1.50951505e-01f, 4.74166300e-04f, -2.46127725e-01f,
  3.58223647e-01f, 4.19654965e-01f, -3.23697925e-01f, -3.21262568e-01f, 1.49175599e-01f, 2.06827838e-02f, -6.10990636e-02f, 1.23695798e-01f, -7.79933780e-02f, -1.38218299e-01f,
  -1.66484360e-02f, 2.19965028e-03f, -1.46349007e-02f, 7.72103369e-02f, 1.81850597e-01f, 7.39177391e-02f, 1.63088962e-01f, 1.16963245e-01f, -4.56828251e-02f, 3.19955754e-03f,
  -2.42023557e-01f, 2.74711043e-01f, 3.48609328e-01f, -8.95316713e-03f, 1.31028257e-02f, -1.04845054e-01f, 6.83464631e-02f, -1.98205877e-02f, 4.91764732e-02f, 2.57746107e-03f,
  -6.06060699e-02f, -4.92413826e-02f, 2.96658259e-02f, 1.21731214e-01f, -4.56556454e-02f, 9.84571502e-02f, 3.44759487e-02f, -7.59130344e-02f, -3.90154570e-02f, 2.28597239e-01f,
  1.15103044e-01f, -2.29688063e-02f, 1.92108974e-01f, 8.83510932e-02f, -2.40266323e-02f, 2.44443163e-01f, 1.96183443e-01f, -8.31404626e-02f, 8.73230249e-02f, 4.23645601e-02f,
  -5.86415734e-03f, 1.14865497e-01f, 1.92064047e-01f, 8.48961547e-02f, 1.13670044e-02f, 1.92991257e-01f, 4.97201681e-02f, -5.63002937e-02f, 9.17166322e-02f, 6.80197328e-02f,
  -3.28304350e-01f, 4.30689305e-02f, -2.29062587e-01f, -1.46678701e-01f, 7.26360753e-02f, 5.91720864e-02f, -8.19548070e-02f, -1.36257932e-01f, -2.49965712e-01f, -1.89295024e-01f,
  -1.08094150e-02f, 7.58624449e-02f, 1.06397212e-01f, 2.72408873e-02f, 2.30037168e-01f, 2.49649771e-02f, 3.71023640e-02f, 3.23244147e-02f, -2.70855874e-01f, 3.34223211e-02f,
  -1.61942214e-01f, 1.31522447e-01f, 1.39412463e-01f, 5.14734685e-02f, 4.90523875e-03f, -1.00414408e-02f, 8.20040405e-02f, -1.31624546e-02f, 2.47087833e-02f, -1.72017157e-01f,
  -1.09643149e+00f, -6.87577844e-01f, 3.90510887e-01f, -1.95137560e-01f, 2.83169836e-01f, 4.14535105e-01f, 3.05175096e-01f, 7.75855407e-02f, -2.45956257e-01f, -3.01333040e-01f,
  -5.80473423e-01f, -3.95944297e-01f, -3.82786393e-01f, -2.51061738e-01f, -1.81213140e-01f, 2.68225402e-01f, 4.96509343e-01f, 3.58735025e-01f, 3.71873736e-01f, 3.07747900e-01f,
  1.16591968e-01f, 8.86134356e-02f, -1.58774316e-01f, -1.84247904e-02f, 3.10040964e-03f, 1.99394062e-01f, 2.18346938e-02f, 4.70471792e-02f, -4.22535092e-02f, -3.31627056e-02f,
  3.51667911e-01f, -5.65516889e-01f, -1.45590594e-02f, -4.52159137e-01f, -1.80717722e-01f, -3.00496578e-01f, 3.38186696e-02f, -1.18998833e-01f, -2.27209911e-01f, 6.36606812e-02f,
  -2.56321788e-01f, -9.80843231e-02f, -4.89817187e-02f, 8.58884677e-02f, 1.05776228e-01f, -3.12151778e-02f, -1.17918313e-01f, -1.29883781e-01f, -1.89627841e-01f, -1.43410787e-01f,
  -1.43108703e-02f, -7.81915486e-02f, 2.89017763e-02f, 7.91483819e-02f, -2.11493775e-01f, -6.55578077e-02f, -6.70903027e-02f, -2.05012530e-01f, -4.71491963e-02f, -3.34481671e-02f,
  3.31214443e-02f, 5.73881119e-02f, -1.64957345e-01f, 1.27597332e-01f, 5.70824184e-02f, 8.28504413e-02f, 1.24971636e-01f, 3.00165247e-02f, 6.42869323e-02f, 1.29199117e-01f,
  9.76278167e-03f, 7.71783441e-02f, 7.11671188e-02f, -2.90234424e-02f, -4.44542542e-02f, -9.29061882e-03f, -3.77610475e-02f, -5.91239966e-02f, -9.63859707e-02f, -2.15133101e-01f,
  -1.79106612e-02f, 3.94533873e-02f, 2.24048309e-02f, 2.01604087e-02f, 5.51650189e-02f, -1.03301033e-01f, 8.68022144e-02f, 2.29155645e-02f, 7.09220096e-02f, -8.22057761e-03f,
  2.46004596e-01f, -2.62693673e-01f, 2.37163320e-01f, 5.12000434e-02f, 5.98331541e-02f, -6.97355270e-02f, -1.19494133e-01f, -2.69036107e-02f, -8.34344104e-02f, 1.71964809e-01f,
  1.14554157e-02f, 5.44968061e-02f, 9.00057238e-03f, 3.90837900e-02f, 2.16228321e-01f, 1.99736401e-01f, -2.41361707e-01f, -5.33217303e-02f, 3.63175683e-02f, 1.90440868e-03f,
  5.97850420e-02f, 1.94468707e-01f, 2.96981692e-01f, 1.49778366e-01f, 2.92031895e-02f, 2.91919172e-01f, 3.35485071e-01f, 2.25085482e-01f, 3.07614416e-01f, 4.21608180e-01f,
  -4.97930765e-01f, 4.99728858e-01f, 2.16166928e-01f, 1.64347515e-02f, -2.18255877e-01f, -6.68812633e-01f, -4.37828839e-01f, -3.03143233e-01f, -1.07406341e-01f, 6.51489615e-01f,
  3.62584233e-01f, -2.13644058e-01f, 5.37484549e-02f, -1.73968524e-01f, -6.29846632e-01f, 2.73519993e-01f, 1.28999531e-01f, -5.96777678e-01f, -1.27510476e+00f, -9.28268611e-01f,
  -3.93141747e-01f, -3.43431920e-01f, -5.21686733e-01f, -2.43754491e-01f, 4.34338629e-01f, 5.06364852e-02f, 5.52078009e-01f, -3.58910449e-02f, 2.93671619e-02f, 6.58425093e-01f,
  4.92893428e-01f, -2.11130321e-01f, -3.10557067e-01f, -2.03269735e-01f, 1.68144673e-01f, 1.04063191e-01f, -5.29787093e-02f, 1.61103997e-02f, 1.13644838e-01f, 1.06933620e-02f,
  5.06029092e-02f, -6.35031164e-02f, -9.09150094e-02f, 4.75348048e-02f, -1.13989942e-01f, -1.11914627e-01f, 6.66195899e-02f, -1.53752849e-01f, -1.11515023e-01f, 2.31132969e-01f,
  1.48951069e-01f, -1.02315240e-01f, -4.61724848e-02f, -8.08437839e-02f, -2.56945997e-01f, -2.21676663e-01f, 1.94610357e-02f, -1.62003279e-01f, -1.51006356e-01f, 3.71126771e-01f,
  -6.84760511e-02f, 4.55870479e-02f, 3.15876002e-03f, 5.25010340e-02f, 7.43108802e-03f, 5.73682673e-02f, 2.69982163e-02f, 9.04101953e-02f, -1.51860073e-01f, 7.41450191e-02f,
  1.13693744e-01f, 3.13733891e-02f, -1.15644947e-01f, 7.01903924e-02f, 3.01172137e-02f, -1.07797654e-02f, -7.51230493e-02f, 7.98296928e-02f, 8.07272419e-02f, 8.20498392e-02f,
  -1.50035903e-01f, -2.82673668e-02f, 2.34593794e-01f, -9.50591713e-02f, 6.85030371e-02f, 5.41911460e-02f, -1.07275330e-01f, -4.30166908e-02f, -9.01159197e-02f, -1.05643734e-01f,
  2.34218419e-01f, -5.70932567e-01f, 3.44781727e-01f, -3.13576707e-03f, 1.36734173e-01f, 1.97705239e-01f, 9.64825898e-02f, 2.92889532e-02f, 1.53526634e-01f, -7.17512146e-02f,
  -2.70123214e-01f, -1.88219994e-02f, 1.56570718e-01f, 9.00288373e-02f, -1.56022534e-01f, -1.21664666e-01f, 2.49485448e-01f, 9.10921842e-02f, -4.38437648e-02f, 3.52431744e-01f,
  2.97970146e-01f, -9.37981978e-02f, -2.49362942e-02f, 2.23731279e-01f, -1.31929871e-02f, -1.91632107e-01f, 1.49472266e-01f, 1.49255112e-01f, -1.10190518e-01f, 2.71973819e-01f,
  -1.38154089e+00f, -6.68343723e-01f, 5.30042648e-01f, -5.40025353e-01f, -6.06990196e-02f, 1.10165395e-01f, -4.46287394e-01f, 2.20690593e-01f, 3.06074709e-01f, -4.51803744e-01f,
  -1.88679814e-01f, -4.42225486e-01f, -2.25084335e-01f, -8.94470513e-02f, -9.26962588e-03f, -4.02995735e-01f, -3.32172890e-03f, 3.00183892e-01f, 6.09417856e-01f, 8.70562941e-02f,
  -2.48662308e-01f, -9.46455821e-02f, 3.25649649e-01f, 2.59181380e-01f, -6.55541122e-01f, -2.15874627e-01f, -1.39024602e-02f, -1.96778059e-01f, -3.65935177e-01f, -9.00107741e-01f,
  -4.07770097e-01f, -3.36464107e-01f, 7.03551352e-01f, -9.81245711e-02f, -1.13708951e-01f, -1.01733439e-01f, 4.64406349e-02f, 9.26641375e-02f, -9.61501002e-02f, 1.33051306e-01f,
  -3.15664649e-01f, 2.53638953e-01f, -2.95243859e-01f, 9.55973491e-02f, 2.64885444e-02f, -4.50389683e-02f, 5.64262509e-01f, 4.74485993e-01f, 1.49733216e-01f, 1.39868543e-01f,
  -3.62391472e-01f, -5.70633650e-01f, -2.48257160e-01f, 5.81965148e-01f, 4.73596960e-01f, 1.16234712e-01f, 2.72124350e-01f, 2.16731399e-01f, 2.86851555e-01f, -1.15480196e+00f,
  -2.10862786e-01f, 6.07973635e-02f, 1.77663088e-01f, 1.62158474e-01f, -4.21606563e-02f, 2.64227539e-02f, -7.67015037e-04f, -1.07364006e-01f, 5.87571152e-02f, -2.76179165e-01f,
  3.07473242e-01f, -1.52093038e-01f, 8.42792317e-02f, -1.38003320e-01f, 6.18892834e-02f, 1.84979197e-02f, -1.43710822e-01f, 1.80977568e-01f, 1.55424550e-01f, -2.86834627e-01f,
  -3.73960808e-02f, 6.96308315e-02f, 3.26746665e-02f, -1.00145519e-01f, -8.78752023e-02f, 1.22670695e-01f, -1.98608890e-01f, -7.01042544e-03f, -1.60081178e-01f, -2.20644772e-01f,
  -5.36953926e-01f, 7.19459653e-01f, -8.64631355e-01f, -6.63188994e-02f, -2.79947281e-01f, 7.88579807e-02f, -9.45755541e-02f, 6.66164532e-02f, -1.58880889e-01f, -1.22302912e-01f,
  1.72014222e-01f, 1.33079076e-02f, -1.11718707e-01f, 2.29591846e-01f, 4.11063852e-03f, 2.35499581e-03f, -1.16278514e-01f, -3.71002913e-01f, -6.29095510e-02f, -7.71602392e-02f,
  4.94131185e-02f, -6.30994499e-01f, -1.10933399e+00f, -5.05528748e-01f, -4.35187340e-01f, -4.01210934e-01f, -3.08778405e-01f, -3.34743053e-01f, -5.80995798e-01f, -1.46475220e+00f,
  -4.54849601e-01f, -1.44371986e-01f, -1.38108408e+00f, -6.86584115e-01f, -8.79826188e-01f, -2.35087872e-01f, 4.72279489e-01f, 2.91208118e-01f, -7.43974373e-02f, 9.49478298e-02f,
  4.10956107e-02f, -1.96992338e-01f, -5.53783536e-01f, -2.18116611e-01f, 2.52633452e-01f, -9.67769474e-02f, -6.52193189e-01f, -5.63431323e-01f, -3.29848528e-01f, 3.04281980e-01f,
  1.78713903e-01f, -4.32082802e-01f, -3.59199017e-01f, -2.12738201e-01f, -6.32778168e-01f, -5.69031954e-01f, -9.71565306e-01f, -6.64589345e-01f, -1.57877773e-01f, -9.68616784e-01f,
  -5.51903009e-01f, -4.09938812e-01f, -1.60004392e-01f, 1.13940500e-01f, -4.40168500e-01f, -3.13456208e-02f, -3.53005528e-02f, -3.55814338e-01f, -2.55753379e-02f, -1.13514923e-01f,
  -3.55046958e-01f, 1.52182624e-01f, -2.92678893e-01f, -1.36631593e-01f, -2.76880145e-01f, -9.63855442e-03f, -7.47200325e-02f, -1.65462270e-01f, -7.49157742e-02f, 2.13278383e-01f,
  1.56236380e-01f, -1.91357434e-02f, -1.60856739e-01f, 1.93389490e-01f, 2.54022747e-01f, -9.84427556e-02f, 1.26946822e-01f, 1.05670698e-01f, 6.07100874e-02f, 9.30139888e-03f,
  4.26762015e-01f, -1.43731534e-01f, 9.11792926e-03f, 2.16967575e-02f, 2.16278121e-01f, 7.45268613e-02f, -1.39087752e-01f, 9.88582820e-02f, 1.10121213e-01f, -3.99053916e-02f,
  -3.72321941e-02f, 1.71730608e-01f, 1.51226982e-01f, 2.92623956e-02f, -2.01719478e-02f, -3.76901031e-02f, 9.58857238e-02f, 1.01132490e-01f, 3.90367284e-02f, 1.85862593e-02f,
  1.08760007e-01f, 1.25965312e-01f, -2.74285674e-02f, 6.17657565e-02f, 1.20986469e-01f, 2.06223354e-02f, 8.56002346e-02f, 2.75246918e-01f, 8.62528011e-02f, 2.07784474e-01f,
  -2.15819344e-01f, 3.27332199e-01f, -7.88852423e-02f, 8.97649825e-02f, -3.09771121e-01f, 5.87138757e-02f, -9.57104936e-02f, 6.76786900e-02f, -3.18519205e-01f, -5.77515811e-02f,
  2.10359156e-01f, 2.03870445e-01f, -2.10792959e-01f, 7.68465400e-02f, -6.53362693e-03f, 6.52202442e-02f, 2.51365453e-01f, -1.21279128e-01f, 2.43118152e-01f, 2.09739849e-01f,
  3.11378092e-01f, 4.60205913e-01f, 2.97883898e-01f, 1.71443135e-01f, 2.48514131e-01f, 2.81409044e-02f, -6.46981522e-02f, 2.84671098e-01f, 2.78091758e-01f, 4.20235962e-01f,
  7.52611458e-01f, -2.61952577e-04f, 9.14935172e-01f, 1.44934013e-01f, -6.03693068e-01f, -2.55524218e-01f, -2.04292655e-01f, 5.51625416e-02f, 4.44512554e-02f, -1.48828223e-01f,
  -6.89022958e-01f, -5.09695172e-01f, -1.87819570e-01f, 1.48543015e-01f, 5.46022296e-01f, 3.13332707e-01f, 4.55169261e-01f, 7.34161496e-01f, 6.28854692e-01f, -9.05319974e-02f,
  -2.54901201e-01f, 8.33778903e-02f, 4.84964579e-01f, 2.93626964e-01f, -6.14829138e-02f, -8.27894211e-02f, 1.24563806e-01f, -2.10856259e-01f, -1.61784157e-01f, 4.26572680e-01f,
  -1.93461701e-01f, 7.88042918e-02f, -8.27096868e-03f, -8.28868598e-02f, 4.21366431e-02f, 2.29658574e-01f, 8.64501223e-02f, 1.27772063e-01f, -1.91410854e-02f, 1.74405612e-02f,
  4.65627648e-02f, -4.66390327e-02f, -1.20231107e-01f, -1.30394533e-01f, -1.97177991e-01f, -1.57615393e-01f, 1.65228724e-01f, 2.58791029e-01f, 1.42200947e-01f, 1.44017115e-02f,
  -2.68426538e-01f, -3.89647663e-01f, -1.75076827e-01f, -2.35930234e-01f, 1.50593407e-02f, -7.71709085e-02f, -8.89049545e-02f, -1.29942354e-02f, -9.21356678e-02f, -6.34534210e-02f,
  -2.71776587e-01f, 1.16895139e-01f, -1.69954859e-02f, -6.23845756e-02f, -2.40383036e-02f, -6.99178800e-02f, -8.93875062e-02f, -1.11044317e-01f, 8.79798234e-02f, 1.39663685e-02f,
  -1.17621094e-01f, -8.51009712e-02f, 5.23511842e-02f, -2.77542900e-02f, -3.01080309e-02f, -2.08625197e-03f, 6.70804828e-02f, -3.97051685e-02f, -1.19726293e-01f, 5.78482226e-02f,
  5.48688369e-03f, 1.04661016e-02f, -4.67934981e-02f, 5.38931042e-02f, -1.35276198e-01f, -3.98011245e-02f, -1.24348141e-01f, -2.50703543e-01f, -2.54416466e-01f, -3.06325674e-01f,
  -6.32940352e-01f, 1.76382009e-02f, 3.62606458e-02f, 3.57546359e-01f, 2.46929452e-02f, 6.14245497e-02f, 8.08261707e-02f, 9.94174741e-04f, -8.17185491e-02f, 1.16162017e-01f,
  4.87514064e-02f, 2.71255195e-01f, -5.68727516e-02f, 9.16353166e-02f, -1.22557893e-01f, -1.49778634e-01f, -1.27825871e-01f, 1.53191864e-01f, 1.26760781e-01f, -3.91270705e-02f,
  4.20530066e-02f, -1.24234684e-01f, -1.32303625e-01f, -1.54873475e-01f, -2.55458057e-01f, -2.18823105e-01f, -1.47902563e-01f, -1.93088744e-02f, -1.38730973e-01f, -2.30730891e-01f,
  4.57292318e-01f, -4.11356926e-01f, 1.18915386e-01f, 1.76177397e-01f, -1.70318946e-01f, -3.76995295e-01f, -4.29503560e-01f, -2.98734635e-01f, 6.63664844e-03f, -4.94559929e-02f,
  3.85852098e-01f, 6.04259312e-01f, 6.45363510e-01f, 4.11569625e-01f, 2.45988622e-01f, -1.31462561e-02f, -3.18540148e-02f, 2.05117702e-01f, 1.99533910e-01f, -3.05647969e-01f,
  -2.53431976e-01f, -1.97795957e-01f, -9.50168595e-02f, -1.09927773e-01f, -3.93835574e-01f, 8.73903558e-02f, -2.51584332e-02f, -2.49274567e-01f, -2.40673274e-01f, -2.40632936e-01f,
  2.68296868e-01f, -2.79923409e-01f, 1.71866611e-01f, 2.34699864e-02f, -8.78664013e-03f, -5.30303679e-02f, 4.74936143e-02f, -1.06676377e-01f, -1.52729809e-01f, -5.68330921e-02f,
  -1.07564390e-01f, -1.00421585e-01f, -8.88109300e-03f, -1.25210896e-01f, -2.66455680e-01f, -8.57196525e-02f, -1.99477911e-01f, -6.16654493e-02f, -6.63513467e-02f, -6.92671239e-02f,
  -6.33576512e-02f, -8.57266262e-02f, 5.16206324e-02f, 7.82338828e-02f, 1.06477924e-01f, 1.01896204e-01f, -6.45439327e-02f, -1.62696794e-01f, -6.41425177e-02f, -8.39981362e-02f,
  -2.05574796e-01f, 1.86573684e-01f, 3.07664443e-02f, 1.52207091e-01f, 1.06206506e-01f, 4.47635911e-02f, 1.11852936e-01f, 3.19798551e-02f, 1.25838175e-01f, 2.61107530e-03f,
  -2.48443577e-02f, 1.90095291e-01f, -3.14245932e-02f, 1.00581273e-01f, 2.28363574e-01f, 5.95444022e-03f, -4.77843173e-02f, -7.66345784e-02f, 5.32928370e-02f, -9.73632336e-02f,
  1.64901409e-02f, -9.43388045e-03f, -3.71357612e-02f, -1.79492921e-01f, -2.37867281e-01f, -7.28937089e-02f, -4.04219143e-02f, -1.03403471e-01f, -2.11144723e-02f, -1.85656905e-01f,
  2.83993274e-01f, 2.84979880e-01f, 2.42484182e-01f, 2.19770195e-03f, -2.39356518e-01f, -9.33545008e-02f, 3.71240377e-02f, -3.59667949e-02f, -8.84210020e-02f, -8.26824456e-02f,
  -1.64118350e-01f, 1.17795505e-01f, -2.68327873e-02f, -1.31513372e-01f, -7.48980790e-02f, -5.60418814e-02f, 7.27866637e-03f, 1.68479756e-01f, -8.12653860e-04f, -9.27606151e-02f,
  -2.12859083e-02f, 9.48196203e-02f, 3.81119698e-01f, 2.11861089e-01f, 1.58314914e-01f, 2.43701175e-01f, 2.59999543e-01f, -1.20566795e-02f, 2.36581728e-01f, 1.45415142e-01f,
  1.51012421e+00f, -2.86428362e-01f, -1.11789989e+00f, 6.30040288e-01f, 9.57008079e-02f, 1.69399589e-01f, -5.42787253e-04f, 3.57361108e-01f, 4.76202339e-01f, 6.49367943e-02f,
  -9.51726213e-02f, 9.82509255e-02f, -2.55486816e-01f, -3.18456531e-01f, -1.03907399e-01f, -3.00023586e-01f, -3.48009527e-01f, -2.40634650e-01f, 1.65036529e-01f, 4.46428955e-01f,
  2.64110029e-01f, 4.79210287e-01f, 4.42100644e-01f, 8.03221315e-02f, -2.02703804e-01f, -2.74389796e-02f, -6.33309424e-01f, -3.34513187e-01f, -4.29672569e-01f, -6.99860632e-01f,
  -6.98096335e-01f, -2.46214598e-01f, 3.40813845e-02f, 7.99413621e-02f, -1.85593784e-01f, 2.29663253e-01f, 3.94289866e-02f, 7.45067894e-02f, 1.49991721e-01f, 1.12344705e-01f,
  -8.57112780e-02f, -7.91171286e-03f, -6.47234842e-02f, -1.03527367e-01f, 1.77342370e-01f, 1.99000891e-02f, -7.76149929e-02f, -3.16548697e-03f, -1.26203656e-01f, -1.30408078e-01f,
  -2.68047512e-01f, -1.85674831e-01f, 3.03839147e-02f, 6.81882873e-02f, -9.32091773e-02f, -6.05076645e-03f, -2.87116557e-01f, -3.50337364e-02f, -1.05040073e-01f, 1.84955254e-01f,
  -2.81110525e-01f, -9.99106746e-03f, -5.48391864e-02f, 1.56877656e-02f, 1.74198464e-01f, 1.33157954e-01f, -3.87729309e-03f, 2.94283610e-02f, -5.01951203e-04f, 1.26243262e-02f,
  9.60808247e-02f, -1.24072894e-01f, -4.70413752e-02f, 8.23776424e-02f, -1.80173755e-01f, -1.09038271e-01f, 7.47065842e-02f, -2.76745427e-02f, -1.01978324e-01f, 1.64181709e-01f,
  1.35225644e-02f, 4.94682929e-03f, -9.16538239e-02f, -6.84980974e-02f, -1.91571549e-01f, -1.06106393e-01f, -1.79364100e-01f, -6.44707233e-02f, 1.08510479e-01f, 6.30510971e-02f,
  4.82072443e-01f, -4.20510322e-01f, 1.63088411e-01f, -3.81225124e-02f, -1.35729164e-01f, -6.94532841e-02f, -2.34444022e-01f, -2.14260407e-02f, 5.02790995e-02f, -9.32378974e-03f,
  -2.41483510e-01f, -6.71631470e-02f, -1.74723372e-01f, -2.22584791e-02f, 2.52555341e-01f, 4.47588041e-02f, 8.95621330e-02f, 5.40139638e-02f, -1.56224221e-01f, -5.70938624e-02f,
  -4.56960537e-02f, 3.61276209e-01f, 4.02148545e-01f, 1.60483092e-01f, 6.37107864e-02f, 1.83098778e-01f, -4.01234366e-02f, 5.56059405e-02f, 7.04494491e-02f, 6.71839595e-01f,
  -1.22202349e+00f, 7.58811653e-01f, 1.66213423e-01f, -5.06181836e-01f, 7.03447640e-01f, 6.93235338e-01f, 1.21533668e+00f, 1.58367187e-01f, -5.38926065e-01f, 2.69995779e-01f,
  6.19750977e-01f, -2.56866753e-01f, -2.01565549e-01f, -3.32442001e-02f, 2.61976749e-01f, 6.24383032e-01f, 2.96769589e-01f, -2.84895837e-01f, -4.25629050e-01f, 6.53817058e-02f,
  3.12064290e-01f, -3.09814900e-01f, -7.37104058e-01f, -1.75971165e-01f, 1.33685758e-02f, -2.84826487e-01f, 1.26826856e-02f, 1.34049758e-01f, 5.62023103e-01f, -8.78114775e-02f,
  -2.03693569e-01f, 5.52004501e-02f, 3.96838486e-02f, -1.45718664e-01f, 2.20816825e-02f, -4.26898688e-01f, -2.55723447e-01f, -3.65972966e-01f, 8.17453191e-02f, -1.96257651e-01f,
  1.06386960e-01f, -8.22485611e-03f, 2.81150937e-01f, 8.46940726e-02f, 1.48841320e-02f, 1.60251468e-01f, -7.29872286e-02f, -1.72741696e-01f, -2.69150019e-01f, -2.85756532e-02f,
  4.83452290e-01f, 3.61345887e-01f, 2.07777217e-01f, 4.04852748e-01f, 3.20473351e-02f, -8.81686360e-02f, 2.21892044e-01f, -2.10400715e-01f, -1.49282247e-01f, -5.52911282e-01f,
  -1.93199456e-01f, 4.40039299e-02f, 2.37516120e-01f, -1.20495096e-01f, 3.19085754e-02f, 8.99400190e-03f, 7.09352046e-02f, 1.95232928e-01f, -1.81241129e-02f, 5.30534470e-03f,
  8.30603093e-02f, -3.67256589e-02f, -2.00974330e-01f, -1.74576715e-01f, -1.40247405e-01f, -8.86538848e-02f, 1.23217385e-02f, -1.43792611e-02f, 1.21822663e-01f, 4.18662466e-02f,
  -4.66615148e-02f, 1.13130603e-02f, -2.02698112e-01f, 5.82956113e-02f, 1.30434155e-01f, -9.57827047e-02f, -2.94442326e-01f, -8.75093713e-02f, -1.98617294e-01f, -1.09541908e-01f,
  -7.39665449e-01f, 8.78671288e-01f, -5.17113268e-01f, -5.33110648e-02f, 5.62593900e-02f, 8.09745267e-02f, 7.52713904e-02f, 1.58029750e-01f, 1.62790254e-01f, -2.65680671e-01f,
  1.58479467e-01f, -5.76524511e-02f, 1.11144550e-01f, 4.30385955e-02f, -9.47607905e-02f, -1.76317021e-01f, 2.79218644e-01f, 2.14053188e-02f, -9.83179430e-04f, -5.20825796e-02f,
  -3.06143705e-02f, -1.87067896e-01f, -4.67604727e-01f, -1.21417366e-01f, -3.29161614e-01f, -6.79685712e-01f, -2.15915799e-01f, -2.56457269e-01f, -1.05901137e-02f, -4.87812102e-01f,
  1.20258439e+00f, 1.61725000e-01f, 2.53978550e-01f, 2.91873902e-01f, -4.86475416e-02f, -2.36335337e-01f, -2.30870306e-01f, -1.89056158e-01f, -8.27239975e-02f, 1.90985456e-01f,
  2.93173015e-01f, 2.98329651e-01f, 1.95483133e-01f, 2.81556137e-02f, 1.73237436e-02f, 2.05255747e-02f, -1.57128811e-01f, 1.80943459e-01f, 1.97239935e-01f, 2.20485792e-01f,
  2.56572574e-01f, 2.03790903e-01f, 3.40959877e-01f, 1.57424822e-01f, 2.69497365e-01f, 3.86624336e-02f, 8.17303662e-04f, 2.49040499e-01f, 2.22862557e-01f, 4.26315457e-01f,
  9.55978036e-01f, 5.74334502e-01f, -1.46184266e-01f, -3.74800414e-02f, 5.12299798e-02f, -4.63616960e-02f, -2.16134954e-02f, -6.20314889e-02f, -5.13332598e-02f, -4.89167795e-02f,
  -2.60021035e-02f, 1.49773890e-02f, 4.98047471e-02f, 2.46170107e-02f, 3.14799361e-02f, -9.92699787e-02f, -4.60514836e-02f, 8.70352834e-02f, -9.27352458e-02f, 6.59866333e-02f,
  -4.64781523e-02f, 6.90070167e-02f, -7.43406415e-02f, -2.54284352e-01f, 1.51247717e-02f, 8.71895254e-02f, 6.20013140e-02f, 2.71429904e-02f, -7.73581266e-02f, 1.89877719e-01f,
  1.83821037e-01f, 2.75559753e-01f, 3.98750931e-01f, 7.25492314e-02f, 2.90052623e-01f, -9.28064063e-02f, -5.01298718e-02f, 6.28937930e-02f, 9.66144875e-02f, 8.90935585e-02f,
  -3.87685397e-03f, 1.04629561e-01f, -2.46998832e-01f, -3.86407599e-02f, 1.02200918e-03f, -1.26300916e-01f, -9.71555859e-02f, -1.65977865e-01f, -6.41513988e-02f, -1.04027942e-01f,
  6.79189637e-02f, -5.35037108e-02f, -1.22939870e-02f, 2.13515051e-02f, -7.27470368e-02f, 1.50248215e-01f, 1.03509657e-01f, 3.88495736e-02f, 1.17667466e-01f, 4.68904637e-02f,
  -9.06247795e-01f, -1.63456887e-01f, 2.12494984e-01f, -7.80923590e-02f, 9.24791247e-02f, 7.00928494e-02f, 1.26720563e-01f, -5.30876704e-02f, -1.02316722e-01f, -1.07103094e-01f,
  4.85249981e-02f, 8.01984817e-02f, -5.17707653e-02f, -6.23948919e-03f, -1.10878281e-01f, -7.78691173e-02f, 3.81316021e-02f, -1.55751377e-01f, -2.21777007e-01f, -1.63367212e-01f,
  -2.35298336e-01f, -3.77112985e-01f, -3.02032679e-01f, -2.47731239e-01f, -1.40725791e-01f, -2.12727651e-01f, -1.09663092e-01f, -1.21430106e-01f, -2.01804727e-01f, -2.40040451e-01f,
  -5.12218356e-01f, 7.88323581e-01f, 5.64711869e-01f, -5.88873446e-01f, 4.08973813e-01f, 5.49778163e-01f, 5.10659575e-01f, -6.59958348e-02f, 1.75972104e-01f, 5.48230112e-01f,
  7.40439177e-01f, -2.75593191e-01f, -1.72570139e-01f, -5.31189322e-01f, -1.02261758e+00f, -3.58072221e-01f, -5.39311469e-01f, -9.07653093e-01f, -1.20785761e+00f, -9.17472839e-01f,
  -5.97670674e-01f, -5.14745116e-01f, -6.77122831e-01f, -5.02368450e-01f, 3.85580063e-01f, -5.40750548e-02f, 5.93599796e-01f, -5.36408350e-02f, -1.34509176e-01f, -2.95739789e-02f,
  5.59969023e-02f, 5.62060118e-01f, -1.41214535e-01f, -2.44654283e-01f, 3.70880365e-01f, -4.18745100e-01f, -2.43966624e-01f, 8.58792439e-02f, -9.11004692e-02f, 3.06335781e-02f,
  2.42506579e-01f, -2.23692179e-01f, -5.08742854e-02f, -1.23705804e-01f, -1.34564653e-01f, -3.65534484e-01f, -3.28899801e-01f, -5.61160266e-01f, -2.96453714e-01f, -1.37334019e-01f,
  -4.67079461e-01f, 3.30386341e-01f, 4.07412231e-01f, 2.49358281e-01f, 2.82580238e-02f, -3.51537883e-01f, 4.41418111e-01f, 4.04215790e-02f, -3.87580357e-02f, 4.06556457e-01f,
  1.04449689e-01f, 9.27120075e-02f, -3.40677099e-03f, 1.95589393e-01f, -1.50950059e-01f, 2.55860239e-01f, 7.96460360e-02f, -8.97211060e-02f, 6.78877309e-02f, -3.39112356e-02f,
  -9.55963880e-02f, 2.42614418e-01f, 5.01552485e-02f, 2.86392216e-02f, -7.97647685e-02f, 2.65605561e-02f, -3.47562991e-02f, -2.18617633e-01f, -1.42188892e-01f, 1.52525321e-01f,
  -9.40384194e-02f, 4.36847731e-02f, 1.26885846e-01f, -2.80893333e-02f, 1.33006066e-01f, -1.67687759e-01f, 1.46969497e-01f, 3.35527323e-02f, -7.61875436e-02f, 5.95057905e-02f,
  -1.22420549e-01f, -2.15077326e-01f, 2.82392409e-02f, -2.55472749e-01f, 3.72281186e-02f, -2.32047439e-02f, 2.98389196e-01f, -6.54606819e-02f, 2.90945590e-01f, 1.13847060e-02f,
  3.31642590e-02f, -6.47805631e-02f, 3.42217028e-01f, -1.13416933e-01f, -3.81399870e-01f, 5.70429303e-02f, -3.81295323e-01f, -3.48439932e-01f, -1.77197367e-01f, -8.17195848e-02f,
  -2.52118826e-01f, -2.51231283e-01f, -4.53038126e-01f, -2.02222571e-01f, 5.01665510e-02f, -2.70684808e-01f, 2.21030321e-02f, 9.36572254e-03f, -4.03139681e-01f, -5.87178133e-02f,
  -1.08000553e+00f, -4.67797190e-01f, -6.71105325e-01f, 3.09291571e-01f, 1.05302179e+00f, -1.30412072e-01f, -8.56345534e-01f, -6.72944367e-01f, 1.40799701e-01f, -4.94870782e-01f,
  4.33592618e-01f, 6.45465970e-01f, -1.16059110e-01f, 3.56703214e-02f, -7.42585540e-01f, -5.67056179e-01f, -1.65317431e-01f, -3.96843761e-01f, 8.25269055e-03f, 5.68293989e-01f,
  8.15362632e-01f, 1.85845867e-01f, -2.41717994e-01f, -1.51960496e-02f, 5.77542543e-01f, 2.65350282e-01f, -2.40659356e-01f, 3.60353321e-01f, 1.45973295e-01f, 2.67016232e-01f,
  -5.01805723e-01f, -6.95514619e-01f, 1.45514747e-02f, 5.43077707e-01f, 3.42522323e-01f, -1.32129893e-01f, -3.16195667e-01f, -2.02570051e-01f, 4.09551449e-02f, -1.47374943e-01f,
  5.37904382e-01f, 1.52148739e-01f, 3.36739153e-01f, 5.54413907e-02f, 2.25180686e-01f, -2.34432518e-01f, -1.45064220e-01f, -4.29535359e-01f, -6.68445528e-01f, -3.22510809e-01f,
  7.98300028e-01f, 3.37891042e-01f, -3.83780211e-01f, -3.78056347e-01f, -5.42443752e-01f, 2.06625417e-01f, -1.95495695e-01f, -2.89130863e-02f, -9.73146081e-01f, -7.08760321e-01f,
  -1.12594217e-01f, 7.48400092e-02f, 1.87262088e-01f, -2.72073537e-01f, 1.59160674e-01f, 1.99621573e-01f, -2.15288494e-02f, 8.20049345e-02f, 1.71222407e-02f, -7.49863386e-02f,
  3.98144275e-02f, -1.78015716e-02f, -8.54101703e-02f, -1.68850616e-01f, 2.17263713e-01f, -8.85880366e-02f, 1.55398130e-01f, -1.65012971e-01f, -1.03818431e-01f, -1.16692774e-01f,
  6.43040240e-02f, -3.60282511e-02f, 9.14981291e-02f, 5.23913950e-02f, -1.75142065e-01f, -2.26121768e-01f, -8.48555565e-03f, 8.28102604e-02f, -8.83562714e-02f, -2.12649480e-01f,
  -1.20222993e-01f, 1.29179329e-01f, -2.57881880e-01f, -4.74175960e-02f, -8.71557221e-02f, 1.24520734e-01f, 1.09498799e-02f, 1.69373199e-01f, -1.85490046e-02f, -2.96128243e-01f,
  -4.12740633e-02f, -2.32067600e-01f, -1.87847391e-01f, -4.81556021e-02f, 1.04450002e-01f, -2.12571740e-01f, -9.60053429e-02f, 8.72441009e-02f, -1.24204285e-01f, 3.80215883e-01f,
  3.44820619e-02f, -3.99673998e-01f, -3.17002624e-01f, -5.96273780e-01f, -2.88565010e-02f, -2.82075524e-01f, -3.64834040e-01f, -3.13854963e-01f, -8.73231471e-01f, -9.94364917e-01f,
  5.09072185e-01f, -1.01253450e+00f, -4.28643860e-02f, 3.15266699e-02f, -3.72282177e-01f, -4.55380410e-01f, -1.11273217e+00f, -2.92291313e-01f, 1.55087709e-01f, -8.30061495e-01f,
  -4.30449158e-01f, 3.61096472e-01f, 3.91869724e-01f, 1.39962465e-01f, 7.44054019e-02f, -9.99298513e-01f, -4.74970907e-01f, 3.37138236e-01f, 5.88198662e-01f, -3.50703180e-01f,
  -6.17465913e-01f, -1.49830833e-01f, 3.05859178e-01f, 2.61819065e-01f, -3.11311692e-01f, 1.78265020e-01f, -3.05490848e-02f, -5.44832498e-02f, -3.19535375e-01f, -4.36083019e-01f,
  -9.60473865e-02f, 3.69567424e-01f, 2.71613538e-01f, 1.41147673e-01f, -6.71467036e-02f, 7.37395659e-02f, 4.87839878e-02f, 2.36182258e-01f, 5.19859977e-02f, -7.54826814e-02f,
  1.56758144e-01f, -3.25954407e-02f, 3.36296707e-01f, 6.10807315e-02f, 3.62908356e-02f, 9.87620428e-02f, 6.49795160e-02f, 2.02846661e-01f, -5.58325574e-02f, -3.84030908e-01f,
  -3.65541637e-01f, -1.63544849e-01f, 1.39380068e-01f, 1.16632119e-01f, 2.99935669e-01f, 3.51450354e-01f, 7.93215558e-02f, 2.36243024e-01f, 4.58629727e-01f, -1.67872891e-01f,
  -6.41583353e-02f, 2.53192261e-02f, -1.39344033e-04f, 5.44010215e-02f, -1.11271925e-01f, -7.68914521e-02f, -2.91006663e-03f, -1.61272705e-01f, 4.64980938e-02f, -6.19474500e-02f,
  -9.44730341e-02f, -1.56962555e-02f, -2.87287310e-02f, -1.59406587e-01f, 3.33021507e-02f, -1.79058239e-02f, -4.11010236e-02f, -5.61189763e-02f, -1.85817387e-02f, 1.16268478e-04f,
  8.44419673e-02f, -4.11811434e-02f, -1.88082624e-02f, 5.66810668e-02f, -3.05392109e-02f, 1.58373788e-01f, 1.15348391e-01f, 1.09743632e-01f, 4.84929346e-02f, -1.04391992e-01f,
  -7.73226283e-03f, 4.40479368e-01f, -2.42112070e-01f, 7.64806792e-02f, 4.08204980e-02f, 7.71257654e-02f, 9.54521745e-02f, 7.24866167e-02f, 1.97702765e-01f, -8.11327398e-02f,
  7.20287859e-02f, 5.93062006e-02f, 1.87076461e-02f, 4.71011177e-02f, 4.03428413e-02f, 9.50058177e-02f, -2.12165371e-01f, -6.97038770e-02f, -5.64355822e-03f, -1.92588359e-01f,
  -2.15110615e-01f, -1.35647535e-01f, 4.59950566e-02f, -1.27240941e-02f, 6.73319399e-02f, 2.55362064e-01f, -1.64558530e-01f, -4.02479842e-02f, 9.99336913e-02f, -6.36836112e-01f,
  -2.85648525e-01f, 1.03577286e-01f, -1.34618223e-01f, 6.34465039e-01f, 5.66025198e-01f, 4.69840080e-01f, 4.81137365e-01f, 4.96219307e-01f, 5.21314859e-01f, 4.29469943e-01f,
  4.43661451e-01f, 6.28636956e-01f, 5.42538762e-01f, 3.68898273e-01f, 3.42039406e-01f, 3.77159774e-01f, 4.30311859e-01f, -3.66462432e-02f, -5.17434515e-02f, 3.34763229e-01f,
  3.54827285e-01f, 8.91754255e-02f, -2.34237283e-01f, 1.12131156e-01f, 2.92845219e-01f, 3.58845919e-01f, 3.02346200e-01f, 4.66741882e-02f, 1.36107534e-01f, 1.25406116e-01f,
  -6.14393115e-01f, -2.92905241e-01f, 1.10368088e-01f, -2.28598285e-02f, -2.38637879e-01f, -2.30381504e-01f, -1.18640594e-01f, -1.15503803e-01f, -1.84310228e-01f, -1.18666445e-03f,
  -1.13723360e-01f, -2.28181705e-01f, -4.75838594e-02f, -1.39096215e-01f, -6.75193593e-02f, -2.00414807e-01f, -1.13761604e-01f, 1.01797417e-01f, 9.73830000e-02f, 3.89982946e-02f,
  1.36761859e-01f, 8.76453593e-02f, 4.35657101e-03f, 7.77202100e-02f, 1.03450410e-01f, 3.66764925e-02f, -8.16422775e-02f, -1.43683985e-01f, -6.92832917e-02f, 7.83598050e-02f,
  3.79192710e-01f, 4.66856211e-02f, 4.42473628e-02f, 1.66213885e-01f, 1.38766943e-02f, 4.39794101e-02f, 9.71520394e-02f, 1.19074006e-02f, 2.26846442e-01f, -7.42524788e-02f,
  1.69842333e-01f, 1.19705677e-01f, 1.10822938e-01f, 7.50584230e-02f, 1.55324847e-01f, 8.03480670e-02f, -1.97539613e-01f, 3.71915437e-02f, -8.21143296e-03f, -8.00901651e-02f,
  -5.41325286e-02f, -5.76293608e-03f, -1.09392241e-01f, -6.87519014e-02f, 1.00371376e-01f, 2.08250895e-01f, 5.84061593e-02f, -7.08198920e-02f, 3.94201837e-02f, 9.43001360e-02f,
  3.03251326e-01f, 2.68115439e-02f, 2.36318470e-03f, 1.03733977e-02f, -2.41149858e-01f, -2.04725236e-01f, 4.10905071e-02f, -1.16168581e-01f, -2.68892348e-01f, -7.81842917e-02f,
  -5.88927381e-02f, -2.28391826e-01f, -5.93796298e-02f, -2.53217034e-02f, -1.24711424e-01f, -5.04357927e-02f, 6.71298355e-02f, 2.45106310e-01f, 1.53679088e-01f, 3.04146353e-02f,
  -4.68457863e-02f, 1.70188829e-01f, 1.19389696e-02f, 7.65735358e-02f, 3.72253172e-02f, 9.56293344e-02f, -1.33996338e-01f, -5.30239120e-02f, 2.96731368e-02f, -2.24851985e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  7.15670228e-01f, 1.02068961e+00f, 1.10129154e+00f, 4.76915121e-01f, 4.87898976e-01f, 9.89273906e-01f, 1.07395661e+00f, 1.04827976e+00f, 3.49905849e-01f, 4.71926481e-01f,
  7.95086861e-01f, 1.73371807e-01f, 1.54704511e-01f, 8.62958282e-02f
};

// L1_linear_W (Shape: 12 x 32)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 32;
const float L1_linear_W_data[] = {
  -1.07058406e+00f, -1.69406712e-01f, -3.08135569e-01f, -3.21891129e-01f, -1.27649099e-01f, -2.27764696e-01f, -2.87744045e-01f, -3.59108932e-02f, -8.29281509e-02f, -4.83063340e-01f,
  1.90844893e-01f, -3.97946626e-01f, 8.13062564e-02f, -1.79483250e-01f, -3.07520688e-01f, 1.91874400e-01f, -4.29445790e-04f, -1.78896543e-02f, -4.12162632e-01f, -6.65563464e-01f,
  -8.30282032e-01f, 3.91415387e-01f, 3.72745752e-01f, -9.43765581e-01f, -1.39000332e+00f, 9.64018777e-02f, -1.04625297e+00f, -1.02096999e+00f, -2.32981995e-01f, 5.09494603e-01f,
  6.42540336e-01f, -7.80778706e-01f, -5.21087408e-01f, 2.63037980e-02f, 1.62804142e-01f, -2.84580737e-01f, 1.58765391e-01f, -3.53774816e-01f, -7.19451681e-02f, -1.74835071e-01f,
  2.13363275e-01f, -3.81362438e-01f, 4.75432366e-01f, -5.51863611e-01f, -5.39915144e-01f, 9.28583145e-02f, -2.03974590e-01f, 2.10749283e-01f, 1.81853667e-01f, 1.74809352e-01f,
  -9.29525793e-02f, -1.13853633e+00f, -1.37241387e+00f, -4.51583207e-01f, 3.08324367e-01f, 5.32023460e-02f, 8.50863278e-01f, 4.37189996e-01f, -8.08322489e-01f, 6.11532211e-01f,
  -1.55102956e+00f, -1.38888109e+00f, 4.96330649e-01f, 1.40545085e-01f, 6.25893101e-02f, 1.07830167e-01f, 3.31864543e-02f, 2.67230868e-01f, 2.50771582e-01f, 1.58972949e-01f,
  2.10940033e-01f, 1.61415279e-01f, 1.98845938e-02f, -5.36700368e-01f, -7.51283616e-02f, -6.09825611e-01f, -1.45090267e-01f, -9.86882672e-03f, -4.32178736e-01f, -3.00992101e-01f,
  -5.16749084e-01f, -4.23562936e-02f, 1.37899250e-01f, -3.36698681e-01f, -6.96692765e-01f, 1.21302545e+00f, -1.62298810e+00f, 9.67235491e-02f, 3.53322119e-01f, -5.80665350e-01f,
  -4.58498806e-01f, -7.17712939e-01f, -1.21670640e+00f, -7.10411370e-02f, 5.22242308e-01f, -3.23402107e-01f, 7.88484961e-02f, -6.14905119e-01f, -7.86098301e-01f, 4.63199206e-02f,
  1.00924440e-01f, -5.15531182e-01f, 6.52874291e-01f, 1.41640708e-01f, -3.27641129e-01f, 1.23313153e+00f, 7.09549069e-01f, -3.29629779e-01f, -6.75634444e-01f, 3.27270955e-01f,
  1.04310238e+00f, -4.42000210e-01f, -4.55194592e-01f, 4.66235071e-01f, -8.47706914e-01f, -1.01291453e-02f, -2.91414708e-02f, 4.26985264e-01f, 7.08560646e-01f, -6.31275952e-01f,
  -1.20956492e+00f, -1.93758881e+00f, 1.05707967e+00f, -6.93670809e-01f, 1.23181812e-01f, -4.81782734e-01f, -1.37941360e+00f, -7.84534395e-01f, 6.30272329e-01f, 4.29331869e-01f,
  8.69008675e-02f, 1.33236069e-02f, -1.17203847e-01f, 1.25878751e-01f, -5.68828940e-01f, -3.34257632e-02f, 4.09377486e-01f, -1.92493916e-01f, -3.99406523e-01f, -1.31993502e-01f,
  5.81249237e-01f, -1.28410622e-01f, 1.68701321e-01f, -1.34154148e-02f, 7.86993057e-02f, -2.70556599e-01f, -1.95030898e-01f, -9.87046778e-01f, 9.15123284e-01f, 2.67075330e-01f,
  -3.06418717e-01f, -5.96829057e-01f, -3.47628891e-01f, -9.75908399e-01f, -9.01987016e-01f, -8.83330703e-01f, 7.80501604e-01f, 1.60952106e-01f, -2.49153778e-01f, 3.25394690e-01f,
  8.94161835e-02f, 4.52521622e-01f, 9.35722291e-02f, 5.20671189e-01f, -4.89087850e-02f, 3.77851069e-01f, 6.31452680e-01f, -8.51760358e-02f, 1.99910283e-01f, -1.01515782e+00f,
  -9.68071401e-01f, 9.87757087e-01f, 2.77809322e-01f, 1.56277418e-01f, -4.56072897e-01f, -2.07264051e-01f, 6.32078528e-01f, 3.62583250e-01f, -7.65467763e-01f, -4.66386139e-01f,
  2.39083707e-01f, -4.67813641e-01f, 3.66180211e-01f, -3.23557615e-01f, -3.74388248e-01f, 1.01901281e+00f, -5.58975339e-01f, -4.14106041e-01f, -6.56663105e-02f, -4.84409392e-01f,
  -8.92851353e-01f, 9.42581147e-02f, 1.44386962e-01f, -8.01504433e-01f, -6.31851256e-01f, 1.12014264e-01f, 5.30325592e-01f, 1.65775999e-01f, 4.77478564e-01f, 1.04717866e-01f,
  -5.38130164e-01f, 6.51788294e-01f, -3.85328978e-01f, 4.78508323e-01f, 5.86920321e-01f, 5.85045218e-01f, -6.67446017e-01f, -4.63140517e-01f, -1.61360294e-01f, -2.65118897e-01f,
  7.89308995e-02f, -1.08862758e+00f, -2.33604088e-01f, -4.66688901e-01f, -8.40626717e-01f, 1.01602435e+00f, -5.68899632e-01f, -3.18076462e-01f, -1.10645425e+00f, 7.68907964e-01f,
  -1.12937307e+00f, -1.02800071e+00f, -3.28148097e-01f, -5.17334461e-01f, 1.73549905e-01f, 1.05827905e-01f, -2.42722467e-01f, -2.31949002e-01f, 5.79858609e-02f, -7.58935630e-01f,
  2.75455676e-02f, -1.83404192e-01f, 1.18260644e-01f, 2.56522387e-01f, -1.08004853e-01f, -2.37183064e-01f, 3.60119432e-01f, 2.03849413e-02f, 4.90072161e-01f, 1.55448422e-01f,
  3.80384028e-02f, -1.56986434e-02f, -8.87805343e-01f, 3.27206433e-01f, -1.67767733e-01f, -2.03696445e-01f, -1.12788081e+00f, -4.83852744e-01f, 1.01318195e-01f, -9.30120707e-01f,
  7.14068115e-01f, -8.06128085e-01f, -2.15778291e-01f, 6.26438558e-01f, -6.36744380e-01f, 3.74598861e-01f, 4.71077502e-01f, -1.58479795e-01f, 2.88395613e-01f, 1.72952995e-01f,
  3.83738205e-02f, 1.08064003e-01f, -6.24438941e-01f, 3.43003720e-01f, 6.63432106e-02f, 6.77233577e-01f, 2.90223330e-01f, -3.96407366e-01f, 3.20376366e-01f, 3.35034370e-01f,
  3.13628972e-01f, 3.72849345e-01f, -1.79023713e-01f, 4.93111253e-01f, 5.29299378e-01f, 1.07073319e+00f, -1.74277723e+00f, -8.64146769e-01f, -7.99280524e-01f, 2.03849301e-01f,
  -2.14771971e-01f, 5.99824250e-01f, -3.59408468e-01f, -6.51056409e-01f, -1.22721374e+00f, -5.13867795e-01f, -1.24270841e-01f, -2.44356260e-01f, 3.11980128e-01f, -2.46461034e-01f,
  2.29103863e-01f, 3.65464956e-01f, -2.33241245e-01f, 4.90674168e-01f, -6.72966361e-01f, -2.97977597e-01f, -7.19958663e-01f, -1.25065386e-01f, -6.30814791e-01f, 7.23794162e-01f,
  8.82175751e-03f, -7.97926366e-01f, 7.48219267e-02f, -5.82460523e-01f, -4.00271267e-01f, -1.69835240e-01f, -2.58783162e-01f, -6.55889630e-01f, 6.48656011e-01f, -1.21624267e+00f,
  -1.30198026e+00f, -5.13369083e-01f, 1.53030261e-01f, -6.94585323e-01f, -4.49634850e-01f, 5.55928290e-01f, -1.65381238e-01f, 1.33959186e+00f, -6.63506463e-02f, -5.21769822e-01f,
  6.64045930e-01f, -3.47346395e-01f, 2.66348869e-01f, -3.39887828e-01f, -1.73731875e-02f, 2.30258927e-01f, 4.87521648e-01f, 1.19264007e-01f, 4.98725399e-02f, -5.99923909e-01f,
  4.81921077e-01f, 1.11059144e-01f, -5.27204394e-01f, -4.37236190e-01f, 5.47981143e-01f, 6.88564718e-01f, 5.34524620e-02f, 3.62037331e-01f, -9.08087730e-01f, 1.06728673e+00f,
  5.20274639e-01f, -1.08908105e+00f, -4.47786063e-01f, -5.68148017e-01f, 7.81128228e-01f, -1.31961334e+00f, -1.93792045e-01f, -7.13663936e-01f, 2.27277666e-01f, -5.27182281e-01f,
  -9.77740228e-01f, -1.04799259e+00f, -1.74773976e-01f, 4.49427754e-01f, 3.14098209e-01f, -3.01279962e-01f, -2.42388338e-01f, 1.63170889e-01f, 1.30316541e-01f, 1.54170513e-01f,
  2.36467928e-01f, 3.38935345e-01f, -1.81374922e-01f, -1.27809182e-01f, 3.53334807e-02f, 5.18777072e-01f, 3.06257874e-01f, 2.59910166e-01f, 3.81463975e-01f, -4.29972410e-02f,
  8.95254135e-01f, -1.23357272e+00f, -6.37134731e-01f, -5.51166415e-01f, -5.18045783e-01f, 7.55947530e-02f, -7.35752225e-01f, -4.30849552e-01f, 1.02810466e+00f, -2.35412896e-04f,
  8.01905930e-01f, -1.35800385e+00f, -3.96672577e-01f, -4.88660604e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  2.50383675e-01f, -1.52853176e-01f, 2.26107866e-01f, -3.80655885e-01f, -2.70703763e-01f, 3.03239495e-01f, 3.25176865e-01f, -4.93548512e-01f, -2.80661196e-01f, 2.98063487e-01f,
  1.87238723e-01f, 1.25458643e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 9, 14
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        32, 12
    );
    }
    