/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 19 x 120)
const int L0_fan_Wp_rows = 19;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  1.75609767e-01f, 8.24285299e-02f, 2.34292112e-02f, 1.33171856e-01f, 2.86861181e-01f, 1.14622667e-01f, 7.37563288e-03f, 1.58213824e-01f, 1.81804910e-01f, 1.04487084e-01f,
  -1.84694648e-01f, 8.11835472e-03f, -3.04350734e-01f, 1.14904635e-01f, -6.07256144e-02f, -2.42191568e-01f, 1.50311410e-01f, 1.54286306e-02f, -6.29548132e-02f, 9.16639939e-02f,
  -1.18784495e-02f, 8.38490054e-02f, -8.83628875e-02f, 1.16711915e-01f, 1.73549596e-02f, 9.45852697e-02f, -3.66460308e-02f, -1.03928350e-01f, 1.04276776e-01f, -4.56754081e-02f,
  7.77565762e-02f, 1.30300015e-01f, 8.52330849e-02f, 1.13517165e-01f, 5.81300221e-02f, -2.67516598e-02f, -9.46136788e-02f, -6.12063631e-02f, -4.41222191e-02f, -1.03705011e-01f,
  -9.57426429e-02f, 9.25073959e-03f, -2.12415867e-02f, -3.59817930e-02f, 4.25028019e-02f, 1.81255899e-02f, 9.96203721e-03f, -4.30084881e-04f, 3.33404057e-02f, 9.74424370e-03f,
  5.76034151e-02f, -8.47443752e-03f, 5.75000457e-02f, -7.16804415e-02f, 2.48012366e-03f, 3.53316478e-02f, -5.48009649e-02f, -1.12705611e-01f, 9.32540298e-02f, 2.30157718e-01f,
  -8.91874433e-02f, -4.52889428e-02f, -4.98265624e-02f, 7.25796744e-02f, -5.70970252e-02f, 9.49951410e-02f, 1.05434507e-01f, 2.82412283e-02f, -8.43810886e-02f, 9.65085253e-02f,
  -4.16527921e-03f, -1.06437206e-02f, -2.97375061e-02f, -3.23531330e-02f, -1.70243643e-02f, 3.29288244e-02f, 5.35088927e-02f, -1.78233981e-02f, 3.88905616e-03f, -6.57571852e-02f,
  2.59116907e-02f, 2.73166411e-02f, -3.92808914e-02f, 5.11699356e-02f, 4.01867591e-02f, -6.38151020e-02f, -1.39177904e-01f, -5.58345020e-02f, 6.67702332e-02f, 1.67060997e-02f,
  2.40716323e-01f, 2.42338017e-01f, 1.15648888e-01f, 1.70075372e-01f, 8.69632587e-02f, 4.47825156e-02f, -9.51688329e-04f, -5.29457517e-02f, 2.47359090e-02f, 8.47422238e-03f,
  4.25727479e-02f, 1.96604803e-02f, 7.03036264e-02f, -1.20838685e-02f, 8.10427219e-03f, 8.38188082e-02f, -8.90235677e-02f, -4.51172441e-02f, 1.36918589e-01f, -5.37337139e-02f,
  1.06089279e-01f, 9.72985700e-02f, 1.03342161e-01f, 3.57883945e-02f, -1.94319654e-02f, 2.05892902e-02f, 5.77275455e-02f, 2.89299730e-02f, -6.29987195e-02f, 1.14948554e-02f,
  4.01133858e-02f, -1.24978520e-01f, 1.85338750e-01f, 4.71542478e-02f, -8.38111266e-02f, -1.38506427e-01f, 1.63877085e-01f, -1.41022369e-01f, 3.07791114e-01f, 7.55699575e-02f,
  -1.13104150e-01f, 1.65101364e-01f, 1.02853708e-01f, 5.89351170e-02f, -5.88812791e-02f, 1.70659274e-01f, -9.75191146e-02f, 1.97718553e-02f, 1.23301826e-01f, 5.06288074e-02f,
  -1.50915151e-02f, -7.91120008e-02f, -8.80012065e-02f, -1.44445464e-01f, -1.05149768e-01f, -1.59473479e-01f, -2.32928127e-01f, 1.02582946e-02f, -2.18878895e-01f, -4.65645082e-02f,
  -1.35282516e-01f, 8.70813876e-02f, -9.23169330e-02f, -3.81442718e-02f, -1.34012565e-01f, 4.94453572e-02f, 1.03579737e-01f, 5.03826551e-02f, 8.99595171e-02f, 2.84874463e-03f,
  3.10470313e-02f, 1.55616468e-02f, 1.66355819e-02f, -1.21923042e-02f, 2.26598233e-02f, -3.95844132e-02f, 8.11065808e-02f, -3.59608419e-02f, -5.36277564e-03f, -2.84457870e-04f,
  5.00959866e-02f, -3.40789668e-02f, 1.16916761e-01f, -6.34806380e-02f, -6.20321967e-02f, 4.90181744e-02f, 1.23713315e-01f, -1.05942599e-01f, -8.91329497e-02f, 4.54713032e-02f,
  6.72141016e-02f, 4.52273265e-02f, 1.25958592e-01f, -1.71508819e-01f, -5.17562740e-02f, -3.28286216e-02f, 5.41222021e-02f, -6.20670058e-02f, -2.22419091e-02f, -5.95172048e-02f,
  -8.37690160e-02f, -5.32422774e-03f, -5.55104241e-02f, 8.53510275e-02f, 7.88595807e-03f, -5.87512786e-03f, -2.82994621e-02f, -4.16846648e-02f, 4.37739864e-03f, -2.70737372e-02f,
  1.61320969e-01f, 2.48343069e-02f, -1.00454986e-01f, -4.32029665e-02f, -1.45162210e-01f, 3.52670737e-02f, 1.07483275e-01f, 7.84881487e-02f, 2.47029383e-02f, 6.15752256e-03f,
  -1.25468031e-01f, -3.05867903e-02f, -1.32765740e-01f, -7.50079192e-03f, -6.19185902e-02f, -1.30813003e-01f, 5.83463535e-03f, -4.54777330e-02f, 7.51363337e-02f, -1.17181614e-02f,
  -5.39746024e-02f, 6.54663369e-02f, 1.75521243e-02f, 6.05525151e-02f, -6.82168594e-03f, 3.13684754e-02f, 6.50952309e-02f, -4.68006283e-02f, -1.09605096e-01f, -8.12282488e-02f,
  -8.11943263e-02f, -2.93576885e-02f, -8.77321288e-02f, 2.31709164e-02f, 2.87760030e-02f, -6.06657527e-02f, 1.16412463e-02f, 3.53138968e-02f, 3.43343541e-02f, -1.30939120e-02f,
  1.22098319e-01f, 2.69689015e-04f, 1.76398426e-01f, 1.65154055e-01f, 1.32187694e-01f, 7.63051808e-02f, 1.15720006e-02f, 1.09350823e-01f, -6.81413710e-02f, 3.26412320e-02f,
  7.27723241e-02f, 8.49749371e-02f, -2.86541969e-01f, 1.08232982e-01f, -2.69871384e-01f, -2.93893158e-01f, 2.06330772e-02f, 2.07089528e-01f, 3.14010233e-02f, 1.38532355e-01f,
  8.53581131e-02f, 2.28462983e-02f, 3.46854888e-02f, 9.13568586e-02f, 1.27234876e-01f, 2.03493461e-01f, -2.67212628e-03f, -1.08323945e-02f, 3.39193523e-01f, -7.75804091e-03f,
  4.94301096e-02f, -6.74419403e-02f, 3.20685431e-02f, -3.16841924e-03f, 4.38413173e-02f, -4.19529248e-03f, 3.81215177e-02f, 6.50200844e-02f, 1.00939963e-02f, -1.99555140e-02f,
  -9.39802546e-03f, 1.88313928e-02f, -5.52502312e-02f, 4.33197320e-02f, 1.16321919e-02f, 9.14180800e-02f, 1.20395653e-01f, 1.31075874e-01f, 1.00231953e-01f, 1.51214704e-01f,
  2.01216802e-01f, -1.20310085e-02f, -4.56055403e-02f, 5.29915132e-02f, -3.53827849e-02f, -3.14717852e-02f, 9.51909125e-02f, 1.09920539e-01f, 3.08793951e-02f, 1.86177380e-02f,
  -2.23124828e-02f, 1.92085374e-02f, 7.24780113e-02f, 5.40814400e-02f, 9.14180279e-03f, 7.86751434e-02f, -2.86921784e-02f, -6.77464306e-02f, -5.03046773e-02f, 9.56234261e-02f,
  -2.57208645e-02f, 2.66910926e-03f, -2.83833239e-02f, 1.48324236e-01f, -5.27702197e-02f, 2.77448483e-02f, -3.31035852e-02f, 4.30592671e-02f, -1.20032420e-02f, 9.19683874e-02f,
  -8.20745304e-02f, -6.48356751e-02f, 7.93603137e-02f, 1.40435994e-02f, -3.08787413e-02f, -3.61659750e-02f, 4.58252952e-02f, 3.60927843e-02f, -2.63154544e-02f, -6.68879598e-02f,
  -1.08022995e-01f, -1.44709259e-01f, -6.68631494e-02f, 1.43953562e-02f, 6.60197949e-03f, -7.04281628e-02f, -8.11654434e-04f, 9.28741097e-02f, 7.35253515e-03f, -3.68911587e-02f,
  7.74945319e-02f, -4.46589626e-02f, -1.35357007e-01f, -3.42622623e-02f, -8.85883123e-02f, 2.59934720e-02f, -1.47839868e-02f, -1.34214059e-01f, -7.94251487e-02f, -1.40404711e-02f,
  3.57230566e-02f, -5.11052795e-02f, -7.44604245e-02f, -2.32218020e-02f, -9.48630739e-03f, 4.62504365e-02f, 1.69522464e-02f, 3.54479663e-02f, -5.15843667e-02f, -6.52698129e-02f,
  -1.13721810e-01f, 6.06700107e-02f, 8.76428261e-02f, -1.35748565e-01f, 1.12151660e-01f, -1.76757082e-01f, -4.88129072e-02f, 2.46884152e-02f, -2.15636566e-03f, -1.58861771e-01f,
  -4.15906962e-03f, 1.73428267e-01f, 5.46423569e-02f, -4.96261604e-02f, 8.20978358e-03f, 1.66876242e-03f, -2.41783321e-01f, -6.13814853e-02f, 2.48799339e-01f, -1.33810267e-01f,
  -8.44964683e-02f, -9.47678555e-03f, 6.18801191e-02f, 2.02216115e-02f, -4.54074889e-02f, 4.40267175e-02f, -1.49195120e-01f, 1.61954045e-01f, -2.29859456e-01f, 3.05260010e-02f,
  -5.93744852e-02f, 1.79332614e-01f, 8.78108218e-02f, 8.54374748e-03f, -9.40841660e-02f, 1.40742594e-02f, -2.98431031e-02f, 1.38144284e-01f, 5.55248652e-03f, -2.24484485e-02f,
  -1.32458195e-01f, 4.46813852e-02f, -7.14295581e-02f, -4.35529910e-02f, -7.41890222e-02f, 1.04095295e-01f, 1.15645863e-01f, -3.78940143e-02f, 9.78394691e-03f, 5.02276011e-02f,
  3.39877047e-02f, -5.77902682e-02f, -1.16519883e-01f, -1.51314229e-01f, 8.01941603e-02f, 4.19856012e-02f, -3.35446820e-02f, -1.47616401e-01f, 1.44212833e-02f, 6.86998814e-02f,
  6.20478392e-02f, 6.77884221e-02f, -9.92342681e-02f, -4.88925315e-02f, -7.06597716e-02f, -8.32511261e-02f, -2.88091395e-02f, 1.98388062e-02f, -3.90907750e-02f, -1.46627977e-01f,
  -1.74617525e-02f, -2.83734147e-02f, -1.18059665e-02f, -6.11437783e-02f, -3.94756161e-02f, -1.12105206e-01f, -4.33956385e-02f, -1.27499178e-03f, -2.94043291e-02f, 4.69419248e-02f,
  8.54872167e-02f, 6.21819869e-02f, -1.11581283e-02f, -7.19608963e-02f, -1.04610279e-01f, 3.52156535e-02f, 4.23086844e-02f, -8.94447342e-02f, 1.61822498e-01f, -4.93852496e-02f,
  -4.62751351e-02f, 2.44746152e-02f, -1.24821179e-02f, 1.04976326e-01f, 3.44591476e-02f, 6.71340525e-02f, 1.52253553e-01f, -9.91324261e-02f, -9.11874175e-02f, -6.66918308e-02f,
  5.08207083e-03f, -1.37171090e-01f, 1.44869415e-02f, 1.37294957e-03f, -2.87335031e-02f, 8.05791989e-02f, 3.57243381e-02f, -1.15247577e-01f, 9.62512568e-03f, 8.39796960e-02f,
  -1.89600904e-02f, 8.49065036e-02f, -6.04535304e-02f, -7.93701112e-02f, 5.66472188e-02f, -9.28280428e-02f, 1.17272800e-02f, 8.65229964e-02f, -5.26919924e-02f, 7.80679658e-02f,
  8.21172167e-03f, -2.21262082e-01f, -2.82529563e-01f, -3.72259840e-02f, 1.74872950e-01f, -4.96288296e-03f, -3.02747726e-01f, -2.16633622e-02f, -3.53031531e-02f, -6.98784366e-02f,
  -1.84012204e-02f, 1.60189927e-01f, -1.81745127e-01f, 1.90274030e-01f, 7.03164265e-02f, -1.24880180e-01f, 1.30898431e-01f, 1.61806419e-01f, 1.14716776e-02f, -7.99642354e-02f,
  9.06082522e-03f, 1.67460784e-01f, -1.08753048e-01f, 6.31428882e-02f, 2.27476135e-02f, -6.90400451e-02f, 1.10409066e-01f, -1.38286024e-01f, 1.42203078e-01f, 1.41329899e-01f,
  3.46843130e-03f, -6.67933933e-03f, -4.14180495e-02f, -5.90094142e-02f, -6.52415976e-02f, -3.26814651e-02f, -5.67227490e-02f, 3.85887772e-02f, -5.74691817e-02f, -3.63218263e-02f,
  -1.05665505e-01f, -2.71227043e-02f, -1.99622400e-02f, -3.80757935e-02f, -6.80263340e-02f, 3.40388753e-02f, 6.70253187e-02f, -1.58312339e-02f, 4.04162221e-02f, 6.98888153e-02f,
  -5.29668182e-02f, 3.11764758e-02f, -3.74693610e-02f, -5.66051900e-02f, 1.11700289e-01f, -9.34394374e-02f, -1.01656891e-01f, -4.10874747e-02f, 7.35575974e-04f, -3.84849589e-03f,
  -7.67313763e-02f, 2.07830220e-02f, 7.22519904e-02f, 3.43783870e-02f, 4.53869253e-02f, 4.78829667e-02f, 3.14155663e-03f, 1.85501669e-02f, 9.69833042e-03f, 8.28530192e-02f,
  1.34947434e-01f, -2.81271599e-02f, 6.14141338e-02f, -6.48263842e-02f, -3.57094966e-03f, 8.76033977e-02f, 4.16021347e-02f, 9.12625641e-02f, -1.08440347e-01f, 4.77878302e-02f,
  -7.31722862e-02f, 1.44725621e-01f, -8.18732828e-02f, 2.44480520e-02f, -1.87463704e-02f, 2.76977709e-03f, -1.11524789e-02f, -7.43353739e-02f, -1.06728278e-01f, 6.26807064e-02f,
  2.94500813e-02f, -1.65853724e-02f, -5.99860102e-02f, -4.00984921e-02f, 5.95280305e-02f, 6.14234284e-02f, -1.61564176e-03f, -7.16984645e-02f, -3.54195461e-02f, 5.54930344e-02f,
  1.50744785e-02f, -6.91952035e-02f, 7.31122270e-02f, 6.87089488e-02f, -9.82599184e-02f, 1.45627279e-02f, -5.52627221e-02f, 7.87598565e-02f, 1.05712354e-01f, 9.65115055e-02f,
  7.04631954e-02f, -3.67029272e-02f, -1.67210624e-02f, -5.05197905e-02f, 1.28531560e-01f, 2.38086749e-02f, -2.91530434e-02f, 1.15028862e-02f, -3.52513930e-03f, 8.87243673e-02f,
  2.03495368e-01f, -1.85556695e-01f, 1.68685734e-01f, 1.19135186e-01f, 2.16731019e-02f, -2.70683646e-01f, -1.42629653e-01f, 7.83562213e-02f, -8.01176131e-02f, -3.05776417e-01f,
  -1.87033936e-02f, 3.84173766e-02f, -4.60513830e-02f, 5.58734946e-02f, 1.69918254e-01f, -5.43952920e-02f, -6.04800135e-02f, -1.43212765e-01f, 5.15683964e-02f, 4.11432423e-02f,
  1.05589263e-01f, 5.43272831e-02f, 2.24743098e-01f, 7.95953199e-02f, 1.54254973e-01f, 1.22379340e-01f, 9.18700397e-02f, 1.52479738e-01f, 7.49980807e-02f, 1.03002982e-02f,
  -1.61418773e-03f, 7.38457292e-02f, 5.98888695e-02f, -2.14977283e-02f, -4.35503013e-02f, -3.84162329e-02f, 1.33175766e-02f, -4.05744165e-02f, 2.45261397e-02f, 3.54526900e-02f,
  -6.95315152e-02f, 5.78801930e-02f, 8.60878453e-02f, 2.67541353e-02f, 1.82228182e-02f, 1.65829118e-02f, 1.47765651e-01f, 1.61720570e-02f, 1.15834631e-01f, -9.04197432e-03f,
  6.49225116e-02f, 2.49110367e-02f, -3.12393624e-02f, 6.24121875e-02f, 5.02770431e-02f, -1.70222465e-02f, -3.60965952e-02f, 3.73274721e-02f, -8.51936638e-03f, -1.74424127e-02f,
  -1.25895783e-01f, 4.10300978e-02f, 5.48715796e-03f, 5.30331619e-02f, 2.38925461e-02f, 3.10498592e-03f, 3.34608294e-02f, -1.71277393e-02f, 5.21326065e-02f, -6.81640729e-02f,
  -2.55771447e-02f, 2.42655296e-02f, 3.34299803e-02f, -3.30060162e-02f, -4.53905091e-02f, 5.28633036e-02f, 6.73987493e-02f, -1.01638369e-01f, 1.42620914e-02f, 2.50594039e-02f,
  -4.50140648e-02f, 4.16614376e-02f, -6.97028041e-02f, -1.16411299e-01f, 1.42964302e-02f, -3.31809116e-03f, -9.82264709e-03f, 3.14961523e-02f, 3.65420580e-02f, 6.87018707e-02f,
  -1.66253582e-01f, -1.08299322e-01f, -6.93663955e-02f, 6.15874492e-02f, -4.14385535e-02f, -6.90812767e-02f, -3.61121558e-02f, -6.69908524e-02f, -4.07836773e-02f, -9.24298260e-03f,
  4.47721547e-03f, -1.64871197e-02f, -1.35107730e-02f, 4.95049767e-02f, -1.62293408e-02f, -1.63664266e-01f, 5.22589199e-02f, -2.53581181e-02f, 1.35431275e-01f, 6.52798563e-02f,
  -6.01196475e-03f, -2.85602990e-03f, -1.43338777e-02f, 8.02843720e-02f, -9.27184969e-02f, -1.97322126e-02f, -4.58904952e-02f, 8.65659937e-02f, -1.86178647e-02f, -2.50153802e-02f,
  6.20452948e-02f, -8.53769034e-02f, -1.14324847e-02f, -2.40025133e-01f, 3.22388560e-02f, -2.21041560e-01f, -2.83709884e-01f, -4.14192453e-02f, -1.33059770e-01f, 2.35135257e-02f,
  -7.24996030e-02f, 9.33170542e-02f, -1.09764352e-01f, -1.09708488e-01f, -2.10135311e-01f, -2.12388113e-01f, -2.66880482e-01f, -6.68641105e-02f, -6.41276166e-02f, -6.90151602e-02f,
  -7.27582052e-02f, -1.19223073e-01f, -1.98906869e-01f, -1.00159300e-02f, -7.73869306e-02f, 7.18463734e-02f, 1.69642586e-02f, 1.04277708e-01f, 4.01883498e-02f, 5.90617582e-02f,
  -1.13757536e-01f, 6.39114231e-02f, 9.19381529e-02f, 1.17659129e-01f, -7.16331452e-02f, -1.36498036e-02f, -1.58035848e-02f, -7.89764076e-02f, -4.85067815e-02f, -6.38200194e-02f,
  3.21642496e-02f, 1.57957468e-02f, 1.88189279e-02f, -2.95653343e-02f, -4.83934907e-03f, -7.31497421e-05f, -3.54943536e-02f, 5.46345413e-02f, -2.15323791e-02f, 1.33365067e-02f,
  1.25257988e-02f, -8.58480409e-02f, 5.86553589e-02f, -5.62427118e-02f, -1.16468240e-02f, -1.22369379e-02f, -1.04892626e-01f, 2.75860075e-02f, 5.88491298e-02f, -1.15622096e-02f,
  -3.10489885e-03f, -7.16017932e-03f, 2.50259670e-03f, -4.67875041e-02f, -7.78292269e-02f, 6.17984086e-02f, -1.23495445e-01f, 7.63942748e-02f, 8.47166032e-03f, -3.50851975e-02f,
  7.07340017e-02f, -1.34915290e-02f, -7.58192614e-02f, 2.62731314e-02f, -1.12638362e-01f, 6.30660448e-03f, 7.30349263e-03f, -2.70957593e-02f, 6.31125132e-03f, -2.43926477e-02f,
  -2.91848611e-02f, -3.49440314e-02f, 2.90524978e-02f, 5.45104640e-03f, -1.16970040e-01f, 7.62328552e-03f, -6.05165176e-02f, -3.50445248e-02f, 1.44183710e-02f, -8.93753842e-02f,
  -1.43467516e-01f, -8.94269496e-02f, 2.97336057e-02f, 2.65895780e-02f, 7.99116939e-02f, -2.97835525e-02f, -5.43625206e-02f, 2.90572215e-02f, 1.31319258e-02f, 2.57612448e-02f,
  -3.08471583e-02f, -5.79290129e-02f, -8.85000452e-03f, 2.47852188e-02f, -1.85798295e-02f, 4.43323031e-02f, -1.15866110e-01f, 1.07101286e-02f, 9.25491080e-02f, 3.60177867e-02f,
  -3.84708792e-02f, -1.52713154e-02f, 6.99785799e-02f, -4.58439114e-03f, -1.47752976e-02f, 1.46627590e-01f, -2.59041805e-02f, 5.70130199e-02f, 8.75573084e-02f, -4.37331498e-02f,
  3.28670323e-01f, 1.99792504e-01f, 1.80065140e-01f, 3.06571990e-01f, 9.91051346e-02f, 1.61817566e-01f, 2.35440031e-01f, 9.69884694e-02f, 2.38183603e-01f, 4.31060754e-02f,
  -1.46110933e-02f, 2.10077628e-01f, -1.71791360e-01f, 2.41835356e-01f, 2.16503277e-01f, -9.13683325e-02f, 2.52066374e-01f, -8.69822409e-03f, -2.53959075e-02f, 1.26752824e-01f,
  8.75841677e-02f, 5.45905009e-02f, -5.39998934e-02f, -8.81460011e-02f, 2.44484782e-01f, -2.21159942e-02f, -1.79410174e-01f, 6.22059312e-03f, 1.05933353e-01f, 8.87061879e-02f,
  9.85927880e-02f, 7.18360320e-02f, 4.83602360e-02f, 4.68434114e-03f, -8.17502365e-02f, 2.52777501e-03f, -7.78231472e-02f, -9.40595418e-02f, 1.70700271e-02f, 6.37189820e-02f,
  4.16099932e-03f, 3.30312550e-03f, 1.53069608e-02f, 3.73917855e-02f, 4.91354167e-02f, 4.81227264e-02f, 1.39431925e-02f, 1.04585856e-01f, -2.28448510e-02f, 5.17656803e-02f,
  4.94538061e-02f, -5.44408076e-02f, -6.69261515e-02f, 6.06514094e-03f, 4.53093573e-02f, -4.23222259e-02f, 6.46272972e-02f, 1.88490916e-02f, -3.98036130e-02f, 1.18663780e-01f,
  -1.59364399e-02f, 4.67497446e-02f, -8.47189315e-03f, -5.43803070e-03f, 5.41398861e-02f, -5.72601482e-02f, -2.55759601e-02f, -6.97869360e-02f, -4.21399862e-04f, 2.93898140e-03f,
  -1.57241151e-02f, -8.04423317e-02f, 2.44616214e-02f, -1.14849005e-02f, 2.18120264e-03f, -1.21434322e-02f, -5.61624803e-02f, -4.09092158e-02f, 9.29742381e-02f, 4.16847095e-02f,
  -4.34641503e-02f, 1.35003198e-02f, 2.40264181e-02f, -9.63426530e-02f, -2.09815241e-02f, -6.65420070e-02f, -4.13498469e-02f, 5.57262860e-02f, -5.54051250e-02f, -4.90156673e-02f,
  8.91504530e-03f, 2.77601145e-02f, -1.38561905e-03f, 1.92519219e-03f, -7.00079575e-02f, 1.52853448e-02f, 7.94734284e-02f, 9.53677595e-02f, 3.18971351e-02f, -4.75946218e-02f,
  -3.66039784e-03f, -1.13172624e-02f, -1.64944585e-02f, -4.76450957e-02f, 2.84318831e-02f, 2.09207982e-02f, -1.04902200e-02f, -3.22553935e-03f, -5.67476451e-02f, -4.47213873e-02f,
  -1.71521809e-02f, 1.82491671e-02f, 6.67269677e-02f, -5.22456430e-02f, -1.00654992e-03f, 1.90308429e-02f, 5.29322587e-02f, 4.28685471e-02f, 3.11067514e-02f, 6.10651784e-02f,
  1.75412986e-02f, 2.12110460e-01f, 2.68424392e-01f, 7.54169002e-02f, -1.43032193e-01f, -2.21736357e-01f, -1.84301898e-01f, 3.20696458e-02f, 2.49087006e-01f, 1.42600648e-02f,
  -1.36731893e-01f, 2.24679917e-01f, 9.49998796e-02f, -1.43029854e-01f, -1.85244143e-01f, 5.62186986e-02f, -1.99244976e-01f, 4.24357131e-02f, 1.49427906e-01f, 1.82887502e-02f,
  5.60448281e-02f, -2.27953911e-01f, -1.91575699e-02f, -1.71914175e-01f, 1.18310548e-01f, 2.78434884e-02f, -1.31335422e-01f, 4.17564027e-02f, -1.75892159e-01f, -1.95172742e-01f,
  -8.67170654e-03f, 2.58817095e-02f, 3.65816839e-02f, 1.62471719e-02f, 6.06271960e-02f, -1.28132969e-01f, -1.91864029e-01f, -1.27249420e-01f, 1.22791439e-01f, 6.60320371e-02f,
  -4.41046022e-02f, -1.08426988e-01f, -2.93945484e-02f, 1.11454912e-01f, -1.98160931e-02f, 6.17245249e-02f, 3.34063210e-02f, 9.92473662e-02f, -1.09955128e-02f, -5.19181639e-02f,
  1.01867899e-01f, 6.38908669e-02f, -3.79168876e-02f, 3.72228548e-02f, 7.78237730e-02f, -4.97363694e-02f, -4.98660430e-02f, 1.00984760e-01f, 8.88829678e-03f, 8.68500471e-02f,
  3.29776760e-03f, -4.91776429e-02f, -5.93267493e-02f, -7.05797318e-03f, 5.92561029e-02f, 8.12339708e-02f, 2.97856107e-02f, -4.80158478e-02f, 5.80332316e-02f, -1.19019691e-02f,
  1.05105951e-01f, 1.40020046e-02f, -3.80467661e-02f, -1.80315189e-02f, 4.05019298e-02f, 3.65339853e-02f, -4.60570026e-03f, 6.37270212e-02f, 2.78515667e-02f, 4.10083346e-02f,
  -7.62930512e-02f, 8.09867233e-02f, 1.06315114e-01f, 3.72344255e-02f, 1.40162855e-02f, 2.35909526e-03f, -8.14564601e-02f, 1.70586169e-01f, -1.29010994e-03f, 6.61095371e-03f,
  -1.35207959e-02f, -1.57750361e-02f, 7.47510418e-03f, -8.66108835e-02f, 8.21444243e-02f, -1.33138348e-03f, -5.46402410e-02f, -8.97253491e-03f, 6.90745488e-02f, 3.67874056e-02f,
  4.29252274e-02f, -6.73776343e-02f, 5.73354512e-02f, 3.57743129e-02f, -7.44604971e-03f, -2.13063578e-03f, -1.41264647e-02f, 7.81738684e-02f, -8.69231822e-04f, 5.54414885e-03f,
  5.00554852e-02f, -4.04889956e-02f, -2.08905656e-02f, 3.50832455e-02f, -7.96540349e-04f, -5.42568825e-02f, 2.42226608e-02f, 2.11757366e-02f, -6.11376613e-02f, 7.12259114e-03f,
  -4.36771691e-01f, 1.93188533e-01f, -1.52424514e-01f, 6.41385233e-03f, -1.04963385e-01f, -7.43480325e-02f, -9.17335600e-02f, 1.27581626e-01f, -1.82441652e-01f, 1.82775378e-01f,
  3.42593007e-02f, -1.47382736e-01f, 5.83001114e-02f, 1.42369106e-01f, -1.91920578e-01f, -1.57606404e-03f, 6.54005110e-02f, -6.99488167e-03f, -4.03796285e-02f, 1.26040652e-01f,
  -3.87261040e-04f, 5.08625135e-02f, 5.40693663e-02f, 1.77397624e-01f, 1.06992967e-01f, -4.53552194e-02f, 6.89558983e-02f, 5.95465973e-02f, 1.46918982e-01f, -6.91555291e-02f,
  8.86084139e-02f, -3.30608077e-02f, -4.42638323e-02f, -8.64826664e-02f, -6.34355918e-02f, -1.35402335e-03f, 4.53256890e-02f, -9.73638520e-02f, 4.22166958e-02f, -6.72045052e-02f,
  3.04644555e-02f, -4.03560465e-03f, -1.09024644e-01f, -2.70216409e-02f, -1.24417860e-02f, 8.48064781e-04f, 2.89672967e-02f, 3.14042009e-02f, 4.47710156e-02f, -1.21882290e-01f,
  -2.28084698e-02f, 1.69799887e-02f, 5.45342639e-02f, -4.60223444e-02f, -5.28591126e-02f, 3.99073958e-03f, -4.55402099e-02f, 5.66049553e-02f, 7.06266761e-02f, 1.39159430e-02f,
  -6.23095781e-03f, -5.45855016e-02f, 1.27863035e-01f, 4.06246036e-02f, 2.43623015e-02f, 8.25804695e-02f, 1.18151769e-01f, 3.31546701e-02f, -4.96619157e-02f, -3.47999819e-02f,
  9.65482518e-02f, 4.40448858e-02f, 3.50697264e-02f, -4.09819037e-02f, -5.44321947e-02f, 1.05746882e-02f, -6.27192706e-02f, 8.84204954e-02f, 6.07047090e-03f, -6.99190199e-02f,
  -2.94776671e-02f, 7.43554980e-02f, -5.31923957e-03f, 7.52364025e-02f, -2.61243358e-02f, -4.47379984e-03f, 3.38538401e-02f, 1.09249257e-01f, 2.77335271e-02f, 7.25632608e-02f,
  6.92888396e-03f, 6.56099468e-02f, -4.42370549e-02f, -7.44517427e-04f, -4.92910407e-02f, 5.06436639e-02f, -2.77860742e-02f, 8.79287943e-02f, -1.37623604e-02f, -2.58515887e-02f,
  2.21454469e-03f, -5.73552437e-02f, -6.94501586e-03f, 2.05493569e-02f, 1.42293833e-02f, -3.01116258e-02f, 4.91140224e-02f, -2.94725355e-02f, -1.12117633e-01f, 6.02451377e-02f,
  3.21289822e-02f, -2.11737752e-02f, 4.00294997e-02f, 7.97587484e-02f, 1.91508066e-02f, 4.33970848e-03f, -9.04003605e-02f, -1.10552907e-02f, -1.82597674e-02f, -4.84715775e-02f,
  3.74165699e-02f, 2.37792000e-01f, 2.04914555e-01f, 1.64669752e-01f, -9.59228054e-02f, -3.83610278e-01f, -2.54857779e-01f, 1.15130946e-01f, -1.72099785e-03f, 4.48909290e-02f,
  3.57021838e-02f, 3.13910931e-01f, -9.58609283e-02f, 1.67215973e-01f, -1.09465294e-01f, -1.52895246e-02f, -5.19473143e-02f, 2.20575444e-02f, 1.04395032e-01f, 6.58709332e-02f,
  -4.52969223e-03f, 7.14385882e-02f, 1.10515513e-01f, 5.22345491e-02f, 1.32423878e-01f, 6.86343759e-02f, 8.01015124e-02f, 3.49928401e-02f, 9.63499323e-02f, -9.81152058e-02f,
  -1.74337357e-01f, 4.18849550e-02f, 4.15165387e-02f, -1.72138214e-02f, -1.49456859e-02f, -1.99167617e-02f, -2.97560287e-03f, -9.62005779e-02f, -3.13683823e-02f, -5.19949012e-02f,
  1.70048792e-02f, -9.25375894e-02f, -1.94704346e-02f, 1.56703126e-03f, -1.26047656e-01f, 6.54872879e-02f, 8.18115249e-02f, -1.08069800e-01f, -4.01292630e-02f, 2.67189592e-02f,
  7.05116764e-02f, -2.66609881e-02f, 1.07330671e-02f, 3.12037487e-02f, -5.13771772e-02f, -1.07561544e-01f, -5.52431457e-02f, 6.03632331e-02f, 2.06610262e-02f, 4.07363921e-02f,
  1.75423637e-01f, 4.64988872e-02f, 4.21333686e-02f, 5.87833822e-02f, -2.13717408e-02f, 6.57547340e-02f, 2.56727282e-02f, -1.46260619e-01f, -4.14703786e-02f, 1.39311096e-02f,
  1.75773147e-02f, 7.38488734e-02f, -2.48200167e-02f, -1.04913808e-01f, -3.18591669e-02f, 5.23194373e-02f, 3.34884524e-02f, -6.90815747e-02f, 3.31484862e-02f, 5.14114611e-02f,
  6.57637715e-02f, -7.73078501e-02f, 2.95314807e-02f, 2.66472762e-03f, 6.18153811e-02f, -6.94038859e-03f, 4.00871411e-02f, -7.76539072e-02f, 7.23016486e-02f, -1.10254869e-01f,
  -2.13831425e-01f, 1.31690383e-01f, 1.15472004e-01f, 1.80164315e-02f, 4.56845164e-02f, -5.69543727e-02f, 1.51923075e-02f, 3.13262343e-02f, -4.44902517e-02f, 9.60317776e-02f,
  -2.35372186e-02f, 1.64722782e-02f, -6.90434873e-02f, -6.82954043e-02f, 4.44791876e-02f, -7.64635801e-02f, -1.08969603e-02f, -8.29457194e-02f, -3.05688903e-02f, -6.28181547e-02f,
  1.93299372e-02f, -1.58421099e-02f, 1.53852195e-01f, 2.65586581e-02f, -2.08416153e-02f, -9.08235759e-02f, 7.18495026e-02f, 9.88393440e-04f, -4.30883318e-02f, -4.05851528e-02f,
  -4.71572757e-01f, 3.12781900e-01f, -8.25915784e-02f, -1.75889861e-02f, 2.74364576e-02f, -1.28814876e-01f, -1.10699736e-01f, 1.25318527e-01f, -1.24969199e-01f, 1.46632314e-01f,
  1.48014173e-01f, -1.52318373e-01f, 4.40053605e-02f, 1.22787096e-01f, -2.47713655e-01f, 2.54085511e-02f, 2.38465983e-02f, -4.69301082e-02f, 8.12193230e-02f, 1.28265321e-01f,
  -4.62525822e-02f, 2.35553309e-01f, 1.37739345e-01f, 2.89641768e-01f, 8.77247937e-03f, 4.89447899e-02f, -7.97343031e-02f, 9.43241715e-02f, 6.12624437e-02f, -1.41512305e-02f,
  1.57169849e-02f, 9.65115055e-02f, 9.05289035e-03f, 5.49882203e-02f, 9.01319236e-02f, -5.62065393e-02f, -9.67920348e-02f, -1.55520603e-01f, 3.69485691e-02f, 1.62890814e-02f,
  2.71311663e-02f, 1.94741022e-02f, -2.73175519e-02f, 2.90257707e-02f, -5.68064116e-03f, 2.66744737e-02f, 3.22408378e-02f, 1.99513137e-02f, -2.66262814e-02f, -2.64068395e-02f,
  8.11770186e-02f, 8.86945873e-02f, -7.56639242e-03f, 1.23317717e-02f, -2.36075930e-02f, 4.57131257e-03f, 9.96551383e-03f, -6.08363226e-02f, 2.64772661e-02f, 2.70269234e-02f,
  1.18228763e-01f, 3.49229909e-02f, 2.54341215e-02f, -4.34774207e-03f, -5.17309234e-02f, 1.56440549e-02f, 9.79103148e-02f, 1.45313833e-02f, -2.49340665e-02f, 1.74438264e-02f,
  1.39713660e-02f, 3.13886553e-02f, 4.53319065e-02f, 2.11497135e-02f, 2.79775448e-02f, 8.85278359e-03f, -2.53384411e-02f, 7.45832399e-02f, -3.70893218e-02f, -2.35424489e-02f,
  9.67789888e-02f, -3.31631340e-02f, -5.07432111e-02f, -4.60278876e-02f, -5.56799434e-02f, -1.24989161e-02f, 4.68294472e-02f, 5.56660779e-02f, 8.71217325e-02f, 3.18230130e-02f,
  5.62473610e-02f, 1.36548325e-01f, 2.67321728e-02f, 5.47114797e-02f, -5.05381078e-02f, -4.01093177e-02f, 1.15580536e-01f, 4.46312837e-02f, -5.43532241e-03f, 8.59938115e-02f,
  -5.38437292e-02f, 5.84513918e-02f, -9.89693180e-02f, 1.89032289e-03f, -3.86454314e-02f, 6.73127174e-02f, -9.43565834e-03f, -4.08501700e-02f, -1.61071755e-02f, 1.09041259e-01f,
  2.13398971e-02f, 2.15691179e-02f, 2.78419405e-02f, -7.84616545e-02f, -7.79771879e-02f, 6.47630021e-02f, -1.03908695e-01f, 1.34959035e-02f, -1.33019891e-02f, -3.90331261e-02f,
  -4.46499318e-01f, 3.31440866e-02f, 2.18476325e-01f, -7.59240612e-02f, -7.63737336e-02f, -1.55316256e-02f, 2.07370639e-01f, -1.27517894e-01f, -2.53143191e-01f, -8.14830288e-02f,
  8.94731283e-02f, -1.22461557e-01f, 1.86693653e-01f, 1.64189446e-03f, -6.48559257e-02f, 8.37723613e-02f, -1.04003005e-01f, -5.82109317e-02f, -2.49107108e-02f, -1.21912314e-02f,
  -4.40222695e-02f, -3.06066070e-02f, 2.22769156e-01f, 3.42562124e-02f, 2.89030075e-02f, 4.70538773e-02f, 8.28560349e-03f, 2.19301909e-01f, -9.29500675e-04f, 2.53196550e-03f,
  -1.80157628e-02f, 3.33390199e-02f, 3.07986755e-02f, -1.06347995e-02f, -3.08376011e-02f, -1.27548441e-01f, 8.04590285e-02f, 9.40722004e-02f, -3.06779295e-02f, 5.71544329e-03f,
  -1.04401559e-01f, -3.52196465e-03f, -7.99446180e-02f, -3.42191532e-02f, -1.44755632e-01f, 8.03974196e-02f, -2.66698953e-02f, -5.12836426e-02f, 2.99542397e-02f, 5.89377061e-03f,
  -8.35290328e-02f, 4.18245643e-02f, -1.57788483e-04f, -2.17454564e-02f, -1.07594468e-01f, 2.76861265e-02f, 2.57027932e-05f, 2.10708622e-02f, 5.99149205e-02f, -6.73754588e-02f,
  -1.47250071e-01f, -1.15264738e-02f, -3.79140414e-02f, 1.12563767e-01f, 1.23742444e-03f, -9.86672379e-03f, 2.67069954e-02f, 2.75972094e-02f, 3.87541577e-02f, -6.80429637e-02f,
  4.29500379e-02f, -2.68673655e-02f, -4.70169708e-02f, -5.02092913e-02f, -7.05249980e-02f, 4.17196527e-02f, 1.45944925e-02f, -4.27955650e-02f, -2.78878063e-02f, -4.25970070e-02f,
  2.04478130e-02f, 3.59295867e-03f, 1.05364695e-02f, 2.02409439e-02f, -1.33395463e-03f, 2.96561066e-02f, 9.46787000e-03f, -4.42303866e-02f, 4.14433926e-02f, 4.27314900e-02f,
  -4.73868884e-02f, -4.64833379e-02f, 1.27743497e-01f, 4.13025320e-02f, 1.88761372e-02f, 2.76608225e-02f, -2.05488801e-02f, -3.77065651e-02f, -2.05496904e-02f, 3.80159654e-02f,
  -4.49707545e-02f, -3.75710707e-03f, -3.89381833e-02f, 2.39095800e-02f, -8.17429647e-02f, -1.94337126e-02f, 5.39628193e-02f, 6.27840459e-02f, -1.48284566e-02f, -8.78782570e-03f,
  1.97719689e-02f, -5.28615713e-02f, -3.99612729e-03f, -4.18245681e-02f, -3.74018103e-02f, 4.03061025e-02f, -3.51894647e-02f, -3.57079878e-02f, -5.40578477e-02f, -1.13088340e-02f,
  8.04148093e-02f, 1.18071631e-01f, 3.23065013e-01f, 3.71504687e-02f, -1.30455956e-01f, -6.63935021e-03f, 6.69966787e-02f, 4.03821804e-02f, 2.85555243e-01f, -1.42244399e-01f,
  -1.95241630e-01f, 2.34334365e-01f, 1.27822652e-01f, -4.00762595e-02f, -4.52311113e-02f, 9.19934660e-02f, -1.64838284e-01f, -9.17790681e-02f, 2.18490168e-01f, -1.06889218e-01f,
  1.12995483e-01f, -3.20201099e-01f, 2.87601780e-02f, -2.46482119e-01f, -9.99715179e-02f, 5.45846187e-02f, -3.09341729e-01f, 2.11160295e-02f, -1.93559304e-01f, -7.84537569e-02f,
  7.78170303e-03f, 1.13316253e-01f, 9.56743360e-02f, 2.75409017e-02f, -7.99126849e-02f, -8.11719596e-02f, -7.71290506e-04f, -4.24398035e-02f, 1.91654544e-02f, -9.71563440e-03f,
  -3.40917185e-02f, -1.80839375e-02f, 1.32433297e-02f, -5.80770187e-02f, 1.77239832e-02f, -4.70238030e-02f, 5.66362627e-02f, 3.20206843e-02f, 7.47383162e-02f, -5.43307997e-02f,
  -8.58490914e-02f, 3.51987146e-02f, 4.37702574e-02f, -6.64545000e-02f, 1.07965015e-01f, 3.20195779e-02f, 1.13195926e-01f, -4.59655374e-02f, 1.90422777e-02f, 8.34439769e-02f,
  -8.17804858e-02f, -1.21373422e-02f, -2.13247444e-02f, -4.32298742e-02f, -2.22737789e-02f, -6.02625385e-02f, -9.95814875e-02f, -4.10750555e-03f, 4.65525575e-02f, -5.12799993e-02f,
  2.84586344e-02f, 2.56698094e-02f, -3.08461711e-02f, 2.46716887e-02f, -6.27348125e-02f, -2.73318915e-03f, -5.76163083e-03f, 1.73844267e-02f, 2.56504342e-02f, 7.11646350e-03f,
  4.88531701e-02f, 1.01044409e-01f, -3.82197052e-02f, -5.39197922e-02f, -1.83640269e-03f, 1.08899042e-01f, 2.25105379e-02f, 3.38722318e-02f, -2.13855375e-02f, -1.14938440e-02f,
  -6.77821338e-02f, 4.34679426e-02f, 8.64357874e-02f, 1.79447397e-03f, 1.94984414e-02f, -2.81063449e-02f, -6.17619082e-02f, -1.79949701e-02f, 7.16710985e-02f, 6.72282055e-02f,
  -1.95808988e-02f, -3.49078067e-02f, 2.14576144e-02f, -5.08253612e-02f, 3.59726138e-02f, -5.74614070e-02f, -3.11212316e-02f, 3.45401354e-02f, -8.15459341e-02f, -1.28214106e-01f,
  -3.99072431e-02f, -5.84475026e-02f, 3.31876464e-02f, 1.24916863e-02f, -4.69034314e-02f, 6.84067756e-02f, 4.49434295e-02f, 2.10780520e-02f, -9.91524458e-02f, 8.08409080e-02f,
  1.84995934e-01f, -6.28950214e-03f, 3.74641180e-01f, -6.25058636e-02f, 6.83730543e-02f, 1.63734108e-01f, 2.99341027e-02f, 6.14466481e-02f, 1.17027156e-01f, -9.95986238e-02f,
  -9.74042639e-02f, 1.74984649e-01f, 2.13793311e-02f, 7.93201663e-03f, -9.39198490e-03f, 1.25351042e-01f, -1.28959849e-01f, -9.02693644e-02f, 6.65187314e-02f, -1.72213018e-02f,
  6.95358962e-02f, -2.37588421e-01f, 8.16130638e-02f, -2.54443903e-02f, -4.00500782e-02f, -4.11538128e-03f, -2.74225652e-01f, 7.84238502e-02f, -3.23940255e-02f, -1.19760305e-01f,
  -2.86076189e-04f, -6.61044940e-02f, 9.09219868e-03f, -5.23826964e-02f, 4.40489538e-02f, -7.39880949e-02f, -3.54324118e-03f, -6.19716523e-03f, -1.10359900e-01f, 2.89846528e-02f,
  8.85373801e-02f, 4.49431837e-02f, -7.04228505e-02f, 9.86440107e-02f, -8.18216801e-03f, 6.01184703e-02f, -3.85499969e-02f, 1.99102052e-02f, 2.29232013e-02f, 9.40889716e-02f,
  2.12614521e-01f, -1.51894009e-02f, 2.47486494e-02f, 1.30566917e-02f, -5.16739897e-02f, -1.19718686e-01f, 7.31394589e-02f, 5.47830351e-02f, -2.03493587e-03f, 6.43049255e-02f,
  5.79125732e-02f, -6.08432591e-02f, -3.00988313e-02f, 7.65688643e-02f, -1.88529063e-02f, 1.90941077e-02f, 6.74364939e-02f, -2.42041480e-02f, -1.45841623e-02f, -1.63456593e-02f,
  -1.34582547e-02f, -7.30145425e-02f, -6.15318082e-02f, -8.11111182e-03f, -4.41567525e-02f, 2.32621953e-02f, 4.32962365e-02f, 9.41372439e-02f, 8.69222656e-02f, -2.15466954e-02f,
  -1.70493778e-02f, -2.30022427e-02f, 1.43194376e-02f, 6.45170659e-02f, 8.81683305e-02f, -8.92153308e-02f, -2.73366142e-02f, -3.98624362e-03f, -2.36046501e-03f, -1.35160133e-01f,
  -1.51553795e-01f, -1.51113883e-01f, -7.56271556e-02f, -3.01213730e-02f, 5.68572022e-02f, -1.27439305e-01f, 6.44520372e-02f, 4.12209257e-02f, -1.02114808e-02f, 6.05533905e-02f,
  -5.75220734e-02f, -2.78087109e-02f, 3.11013553e-02f, -4.45091650e-02f, -1.56120285e-02f, -4.37805727e-02f, -1.51283024e-02f, -8.26137587e-02f, -1.02260068e-01f, -6.60813600e-02f,
  4.19574007e-02f, -9.70023964e-03f, 5.88342175e-03f, -8.55217278e-02f, -9.56356823e-02f, 6.86041042e-02f, 1.37320325e-01f, 2.30145417e-02f, -5.34021528e-03f, 5.29956259e-02f,
  2.17659865e-02f, 1.89251676e-01f, -1.01797834e-01f, -1.12250715e-01f, -8.52259696e-02f, 3.70396972e-01f, 2.21766204e-01f, 6.53235689e-02f, 1.35821328e-01f, 2.03311935e-01f,
  -4.19752352e-04f, -4.57107760e-02f, 1.82641342e-01f, 1.92805067e-01f, 6.80388585e-02f, 1.63955435e-01f, 1.18045852e-01f, 3.83675694e-02f, -5.83447330e-02f, 2.37395000e-02f,
  5.85432947e-02f, 1.42703563e-01f, -1.01843312e-01f, -3.64050828e-02f, -6.11113645e-02f, -1.88998863e-01f, -1.70445040e-01f, -1.96197510e-01f, -6.09642789e-02f, -5.61988801e-02f,
  6.90159872e-02f, -1.54322768e-02f, -6.26476109e-03f, -3.82607542e-02f, 9.48981792e-02f, -9.62691233e-02f, 4.62116674e-02f, -1.25921555e-02f, 3.21705192e-02f, 9.30436105e-02f,
  2.01488763e-01f, -1.09337957e-03f, 1.21758664e-02f, -6.85409307e-02f, 3.81655283e-02f, -9.21875611e-02f, -1.75300948e-02f, -7.08889440e-02f, -5.64730726e-02f, 2.19715526e-03f,
  -2.03413256e-02f, 1.09160077e-02f, 2.42564399e-02f, 3.77317891e-02f, 3.15975212e-03f, 4.48351726e-02f, 3.70340459e-02f, -5.19046783e-02f, -3.69488187e-02f, 5.77075444e-02f,
  1.19969390e-01f, -2.22355896e-03f, 1.07539892e-02f, -7.24563822e-02f, 1.55685274e-02f, 1.22995367e-02f, 4.01369259e-02f, -2.72875875e-02f, -4.39760163e-02f, 6.73887283e-02f,
  -5.08319512e-02f, -5.11815324e-02f, 2.06556898e-02f, 2.58745439e-02f, 1.35640698e-02f, 1.06651271e-02f, -3.35315987e-02f, 8.76766862e-05f, 2.59298384e-02f, -5.88004431e-03f,
  4.19703685e-02f, -2.44715307e-02f, -8.48204084e-03f, 6.90039694e-02f, 1.20268203e-02f, -3.90097499e-02f, 1.18506730e-01f, -2.00477671e-02f, 1.91666801e-02f, -4.00777496e-02f,
  1.54324889e-01f, 7.05095381e-02f, -4.16976996e-02f, -9.25870463e-02f, -5.24705835e-02f, -1.35413315e-02f, -1.33863883e-02f, -6.97934953e-03f, -3.38276173e-03f, 4.73301336e-02f,
  1.41227514e-01f, -8.57224241e-02f, 5.09667546e-02f, -7.77087808e-02f, -2.92502362e-02f, 3.32171880e-02f, 3.32875550e-02f, -4.38318737e-02f, -2.42802799e-02f, 1.81630198e-02f,
  1.55572069e-03f, 7.48239607e-02f, -4.40710187e-02f, -5.90370968e-02f, 7.92422704e-03f, -2.26217695e-03f, 3.55637409e-02f, 6.39842032e-03f, -6.28207847e-02f, -2.47980598e-02f,
  -3.74748945e-01f, 5.56497574e-02f, 1.62304536e-01f, -2.20398858e-01f, 1.01657704e-01f, -4.22869101e-02f, -1.03403635e-01f, -2.89479494e-02f, -1.31173119e-01f, -1.01548702e-01f,
  -2.32159555e-01f, -9.55713633e-03f, 6.55216025e-03f, -4.23217833e-01f, -2.98708946e-01f, -1.12677604e-01f, -3.38194132e-01f, -1.67240873e-01f, -1.31850522e-02f, -1.65239964e-02f,
  -9.33554545e-02f, -2.44566634e-01f, -8.79253969e-02f, -1.41060101e-02f, 2.50292588e-02f, 8.60363767e-02f, 7.62544051e-02f, 1.72113448e-01f, -1.63343742e-01f, -9.00521129e-02f,
  -6.53240606e-02f, -7.41600469e-02f, -4.64456305e-02f, 8.34914148e-02f, 5.44274710e-02f, 3.50707695e-02f, 4.06977721e-02f, -4.81592789e-02f, 6.20179437e-02f, -1.96218397e-03f,
  -1.56243090e-02f, 8.86507258e-02f, -8.62804148e-03f, -2.61675939e-02f, -2.57566199e-02f, -5.76504394e-02f, 3.37097398e-03f, -6.25772402e-02f, -2.01510917e-02f, -6.05351143e-02f,
  -6.77748723e-03f, 2.80793663e-02f, 7.95286968e-02f, -1.95741206e-02f, -8.23604036e-03f, 4.13528346e-02f, -6.67280657e-03f, 7.78098330e-02f, 6.88708015e-03f, -5.82583100e-02f,
  -2.09809281e-02f, 5.05916551e-02f, 3.68918851e-02f, -1.04110157e-02f, 6.74923062e-02f, 2.38240454e-02f, -2.17016358e-02f, -1.35209942e-02f, -3.23167583e-03f, 2.89315283e-02f,
  -3.21325138e-02f, 2.08345708e-03f, -1.47290267e-02f, 1.18656186e-02f, -5.70287034e-02f, -1.03665739e-01f, 2.00255364e-02f, -9.49208997e-03f, 1.24664325e-02f, -7.22869709e-02f,
  6.82074875e-02f, -3.43521708e-03f, -1.63963772e-02f, 4.56190370e-02f, -5.55108413e-02f, 2.70247143e-02f, 1.43476157e-02f, -4.56115417e-02f, 1.12524427e-01f, 2.57299356e-02f,
  3.65296914e-03f, 1.41908243e-01f, -3.25296558e-02f, 6.06524795e-02f, 4.38637361e-02f, 2.18652710e-02f, -6.17175177e-02f, -2.80243624e-02f, 5.72807118e-02f, -2.40841769e-02f,
  1.00949697e-01f, 9.29729044e-02f, 1.08621225e-01f, -1.95419639e-02f, -3.41258571e-02f, 3.70752849e-02f, 6.32148385e-02f, 3.13243121e-02f, 2.97762919e-02f, -7.07904110e-03f,
  9.86998081e-02f, 1.01254910e-01f, 4.04291227e-02f, 9.17544588e-03f, -2.83561628e-02f, 8.43264461e-02f, 1.53314311e-03f, 7.54419640e-02f, 6.25302941e-02f, -2.17426065e-02f,
  1.97376668e-01f, 1.72287226e-01f, 1.89077631e-01f, 1.36050150e-01f, 5.52342013e-02f, -2.16595344e-02f, -3.29934172e-02f, 1.95744634e-01f, 2.51116231e-02f, -1.05890304e-01f,
  1.44023467e-02f, -1.80516057e-02f, -1.59163773e-01f, 1.89503416e-01f, 1.89111218e-01f, -1.74561113e-01f, 2.56409317e-01f, -3.57243195e-02f, -8.60148296e-02f, 1.35453522e-01f,
  4.47011851e-02f, 1.24727651e-01f, -2.67041530e-02f, -5.04067205e-02f, 2.13280544e-01f, -8.05268288e-02f, 8.99341628e-02f, -5.38582355e-02f, 1.15929917e-03f, -7.35844150e-02f,
  -7.67995417e-02f, -2.67328508e-02f, -3.51776555e-02f, -5.49778007e-02f, -2.60173399e-02f, -1.26700543e-04f, -1.30967975e-01f, -3.74293625e-02f, -4.55168039e-02f, -2.24799141e-02f,
  -7.23939240e-02f, 1.23498328e-01f, 9.54154581e-02f, -5.29197492e-02f, 8.24318677e-02f, -4.60750125e-02f, 8.61536041e-02f, 6.93325400e-02f, -3.45246755e-02f, 1.05672158e-01f,
  1.25886813e-01f, 2.79603712e-02f, 1.08244844e-01f, 6.94204047e-02f, 7.74225667e-02f, 6.82443157e-02f, -2.01394521e-02f, -2.45158118e-03f, 2.40376350e-02f, 8.18380434e-03f,
  -6.15526643e-03f, -3.01063084e-03f, -2.21626665e-02f, 7.00526545e-03f, 1.96522498e-03f, 4.24476480e-03f, 8.16998910e-03f, -8.39160606e-02f, -7.66947493e-02f, 4.78765257e-02f,
  -3.59974578e-02f, 5.63105568e-02f, -6.14089184e-02f, 4.96085025e-02f, 1.37061775e-02f, 6.42914101e-02f, -1.01927496e-01f, 4.72424030e-02f, -1.05758533e-02f, 4.37635854e-02f,
  -7.38298446e-02f, 3.13249510e-03f, -2.00275686e-02f, -4.57858965e-02f, 1.51795633e-02f, 2.99933646e-02f, 6.52722642e-02f, -5.81493899e-02f, 2.36311071e-02f, 8.39048903e-03f,
  -1.71019528e-02f, -3.23559791e-02f, -2.02743664e-01f, 5.91433421e-03f, -7.56547600e-02f, 7.65242800e-02f, -6.27395809e-02f, 8.67763981e-02f, 2.32380312e-02f, 3.11014075e-02f,
  8.46734792e-02f, 5.30481003e-02f, 8.85223150e-02f, -2.26105899e-02f, 3.84882540e-02f, -4.04505171e-02f, -2.64423657e-02f, 2.36088992e-03f, 6.78101256e-02f, 1.00289751e-02f,
  1.14344746e-01f, 2.32734270e-02f, -7.02788867e-03f, 5.14957048e-02f, 4.34525646e-02f, 9.55182593e-03f, -4.51763608e-02f, 1.18697256e-01f, 2.20568292e-02f, -5.18003292e-02f,
  3.57138902e-01f, -1.67143829e-02f, 3.26586817e-03f, -6.33611344e-03f, 8.82991850e-02f, -2.53689766e-01f, -2.25154415e-01f, 7.64103755e-02f, 1.19943552e-01f, -1.75213277e-01f,
  -1.97320625e-01f, -5.50111569e-02f, -2.95354396e-01f, -1.33129343e-01f, -1.59404799e-01f, -1.96442649e-01f, 6.88258484e-02f, -4.74568307e-02f, -3.91652882e-02f, -8.07485953e-02f,
  1.14237465e-01f, -4.91902381e-02f, -7.11419806e-02f, 7.81074762e-02f, -5.55948205e-02f, 7.18075261e-02f, -1.21843442e-01f, -2.11989671e-01f, 1.03186756e-01f, 9.91067104e-03f,
  1.04761366e-02f, -1.06865279e-01f, 3.04696783e-02f, -5.12742391e-03f, -1.05551913e-01f, 2.48990357e-02f, -1.17558462e-03f, -1.12933442e-01f, 4.39629406e-02f, -3.17113847e-02f,
  -8.65482539e-02f, -3.30650099e-02f, -1.15524251e-02f, -2.35966779e-02f, 4.53297831e-02f, 3.16531658e-02f, 9.31746811e-02f, 9.32070091e-02f, 7.61923864e-02f, 1.28925755e-03f,
  -8.20640533e-04f, -5.91053963e-02f, 3.05579342e-02f, 6.25271723e-02f, -3.66675779e-02f, 7.79473707e-02f, -3.19914669e-02f, -3.94215662e-04f, 1.06388271e-01f, 8.56407136e-02f,
  -1.07111089e-01f, -2.05426035e-03f, 1.98209453e-02f, 1.45737618e-01f, 6.33993000e-02f, 6.17483072e-02f, -1.36842638e-01f, -7.76602402e-02f, -2.95059942e-02f, 3.67853120e-02f,
  9.06038284e-02f, 5.24525233e-02f, 3.78769040e-02f, -5.49835619e-03f, 4.48812917e-03f, 6.26727492e-02f, 1.07572246e-02f, -6.18484057e-02f, 7.68987602e-03f, 3.84201147e-02f,
  -2.21867226e-02f, 9.21488702e-02f, -2.16835295e-03f, 5.97821362e-02f, -5.44735789e-02f, 3.20208892e-02f, 3.69487181e-02f, -2.80545987e-02f, -2.94546131e-02f, -1.36737570e-01f,
  -4.58922870e-02f, -2.33568400e-01f, 8.32725968e-03f, -4.76135463e-02f, -1.03160493e-01f, 4.50383835e-02f, -1.13332860e-01f, -1.16100060e-02f, -1.36656687e-01f, -2.65341345e-02f,
  -7.39502907e-03f, -7.57145742e-03f, -4.51637479e-03f, 3.71303558e-02f, -4.30795886e-02f, -5.55820577e-02f, -1.19700268e-01f, 9.60779656e-03f, 1.00653777e-02f, -6.09244294e-02f,
  -6.65481836e-02f, -1.81347445e-01f, 8.13156068e-02f, -6.17782585e-03f, -8.38254578e-03f, 4.75955904e-02f, 7.50812702e-04f, -2.19461434e-02f, 4.75681154e-03f, -2.36689355e-02f
};

// L0_fan_Wp_bar (Shape: 26 x 120)
const int L0_fan_Wp_bar_rows = 26;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  2.87065208e-01f, -1.12665676e-01f, -2.72021711e-01f, -2.57048517e-01f, -3.12928915e-01f, -9.81732309e-02f, -1.89992160e-01f, -2.09995210e-01f, -2.18288004e-01f, 2.97306050e-02f,
  -7.42769465e-02f, -3.77769768e-03f, 2.24882588e-01f, -7.44050071e-02f, 1.06329009e-01f, 2.71787316e-01f, -6.23046719e-02f, -5.17040752e-02f, -5.71708232e-02f, 4.24143113e-02f,
  -8.92574117e-02f, -1.74384750e-02f, -4.25994098e-02f, -7.61710554e-02f, -2.35466257e-01f, -9.46253017e-02f, 7.07262987e-03f, -1.42709002e-01f, -2.60334790e-01f, -2.17408866e-01f,
  -5.55542903e-03f, 3.18725258e-02f, -5.87468557e-02f, 7.35041825e-03f, 4.69002966e-03f, 8.26411173e-02f, 3.28330472e-02f, 9.99170262e-03f, -8.27894881e-02f, 2.23281495e-02f,
  5.76128997e-03f, -2.05823947e-02f, 1.92374177e-02f, 7.57105425e-02f, -6.55515790e-02f, -1.34261236e-01f, -9.31922421e-02f, -8.87504146e-02f, -1.99644461e-01f, 8.73326436e-02f,
  -1.38719559e-01f, -9.78623405e-02f, -1.23427384e-01f, -6.65604025e-02f, -1.12602189e-01f, -3.97394113e-02f, -1.12394514e-02f, -5.87368608e-02f, -7.93628395e-02f, -9.14191082e-02f,
  2.87894625e-02f, 6.25077337e-02f, 5.04524000e-02f, -9.66345984e-03f, -3.03955078e-02f, -2.67678853e-02f, -1.17428511e-01f, 1.01584621e-01f, 1.51046701e-02f, -2.64349319e-02f,
  -8.66015926e-02f, -1.50762752e-01f, 7.79838264e-02f, -8.05391893e-02f, 4.65574637e-02f, 1.97555944e-02f, 9.04086083e-02f, 3.81575637e-02f, -7.57842213e-02f, -8.04673508e-02f,
  1.22451521e-02f, 6.03307262e-02f, -1.83350628e-03f, -9.91372466e-02f, -3.16181853e-02f, -6.00948073e-02f, 2.46384256e-02f, 1.92845613e-02f, 1.96886435e-02f, 3.27616036e-02f,
  7.48931337e-03f, -1.00125797e-01f, -6.78273942e-03f, -8.39307457e-02f, -2.30463943e-03f, 1.38356462e-01f, 7.46253273e-03f, -4.71363105e-02f, -8.74630138e-02f, 8.51569846e-02f,
  -1.03543125e-01f, -8.16849619e-02f, 9.40159038e-02f, 1.92012619e-02f, -4.08518761e-02f, 2.88250726e-02f, -1.53296301e-02f, -1.02157667e-01f, -1.86550409e-01f, -4.11435775e-02f,
  1.52854566e-02f, -2.13322137e-02f, 4.01966013e-02f, 2.30846759e-02f, -9.11977887e-02f, -1.91837363e-02f, 6.24564327e-02f, 3.43480147e-02f, -1.05620772e-01f, -9.08306241e-02f,
  1.12807892e-01f, 3.19819823e-02f, -4.87637408e-02f, 9.66168419e-02f, -6.40932992e-02f, -1.98271602e-01f, -2.27285072e-01f, 1.84533194e-01f, 4.37394269e-02f, -3.11412066e-02f,
  8.76615271e-02f, -1.63593981e-02f, -1.37147814e-01f, 2.10299656e-01f, 2.62451351e-01f, -7.02195242e-02f, 1.41844675e-01f, 4.51043732e-02f, -1.40210344e-02f, 1.18754424e-01f,
  1.49256781e-01f, 1.79694086e-01f, 1.18135728e-01f, 8.18027034e-02f, 9.87480506e-02f, -3.03149819e-02f, 1.85908526e-01f, -8.62446129e-02f, 2.26214901e-01f, -1.17782904e-02f,
  3.37721710e-03f, 2.81174779e-02f, -1.07777370e-02f, 1.34064825e-02f, -8.51107240e-02f, 2.00149119e-02f, -1.42091699e-02f, -2.31057741e-02f, 1.00134939e-01f, -2.19347794e-03f,
  1.20462980e-02f, 5.21995127e-02f, 2.10357364e-02f, -6.83537172e-03f, 6.74030185e-02f, 1.21432319e-01f, 6.62486069e-03f, -2.21570693e-02f, -6.67160824e-02f, 8.38741288e-03f,
  4.48187478e-02f, -3.52007970e-02f, 9.15872306e-02f, -9.77363344e-03f, 8.66266042e-02f, -2.47640498e-02f, 1.79427359e-02f, -7.14063272e-02f, -5.99570461e-02f, 1.66504588e-02f,
  1.67180989e-02f, -9.29055095e-04f, -7.35658854e-02f, -6.96572289e-02f, 2.07827892e-02f, 4.98195775e-02f, -1.01344858e-03f, -4.99576405e-02f, -2.55492199e-02f, 6.00526892e-02f,
  -2.30909642e-02f, -1.61315594e-02f, 5.11123054e-02f, 5.04399389e-02f, -9.97614115e-03f, -1.06147919e-02f, -3.71231064e-02f, -4.94771227e-02f, -2.31939586e-04f, -1.29555045e-02f,
  1.48749063e-02f, 1.19980262e-03f, 9.05349571e-03f, -1.72449206e-03f, 7.03390241e-02f, 1.72405206e-02f, 3.31164189e-02f, 8.18934664e-02f, 4.70442772e-02f, -1.43901743e-02f,
  5.21949343e-02f, 2.74190493e-03f, 3.83045711e-02f, 2.24281941e-02f, -2.36753821e-02f, -5.86189851e-02f, 2.18171552e-02f, 3.49360183e-02f, 2.88286563e-02f, -3.13483179e-02f,
  7.67065361e-02f, -8.56966078e-02f, -4.50048558e-02f, -4.09756638e-02f, 1.07592419e-01f, -4.41915132e-02f, 6.59574941e-02f, 6.47474080e-02f, 1.09956831e-01f, 4.20059934e-02f,
  3.83588523e-02f, -3.78342830e-02f, 7.33141303e-02f, -3.03318854e-02f, 6.59538209e-02f, -3.28801386e-02f, 4.06274423e-02f, -5.49309030e-02f, 9.48781297e-02f, 6.61902949e-02f,
  -3.30752343e-01f, -7.04721510e-02f, 3.07888091e-01f, -3.82379025e-01f, -3.46236005e-02f, 2.38601848e-01f, 2.54826486e-01f, -1.08663611e-01f, -3.41564089e-01f, -3.03878129e-01f,
  -1.00513466e-01f, -2.60772984e-02f, 1.95605755e-01f, -1.45962775e-01f, 3.11003476e-01f, 2.46600822e-01f, -1.48256466e-01f, -5.59848063e-02f, -2.47149519e-03f, -1.37467921e-01f,
  -5.24194352e-02f, -1.99692920e-01f, 2.15732783e-01f, -8.14049616e-02f, 2.61177681e-02f, -2.16512263e-01f, -6.44604862e-02f, 1.34573162e-01f, -7.36956075e-02f, 6.62053153e-02f,
  -6.65076124e-03f, -3.41390520e-01f, 3.91101465e-02f, 2.80826185e-02f, 6.98467791e-02f, 4.24479134e-02f, 4.12613265e-02f, 1.58447683e-01f, -3.33494917e-02f, 2.97408123e-02f,
  3.68930735e-02f, 6.48392886e-02f, -3.59210558e-02f, -4.35555279e-02f, -7.42126927e-02f, -1.07404571e-02f, -6.52482826e-03f, -1.11689686e-03f, 1.78496838e-02f, 7.91560337e-02f,
  1.18009135e-01f, -4.40403335e-02f, 6.43216744e-02f, -4.49780710e-02f, 4.42157313e-02f, -5.33354431e-02f, -4.17860709e-02f, 6.84486404e-02f, -3.79204634e-03f, -3.72248404e-02f,
  1.07362084e-01f, 2.00227462e-03f, 1.12678250e-02f, -1.51864439e-02f, 2.62704231e-02f, -6.52557909e-02f, -1.78853627e-02f, 8.40738788e-03f, -7.84991980e-02f, -4.18230332e-03f,
  -7.72097334e-03f, -4.76808026e-02f, -1.31653138e-02f, -4.69777361e-02f, -4.65654768e-02f, -1.04802929e-01f, 9.09914002e-02f, 7.04135224e-02f, 8.33893120e-02f, -8.13863724e-02f,
  -3.83396111e-02f, -9.23603424e-04f, 2.89329812e-02f, 3.91655788e-02f, 1.70805398e-02f, -5.75317722e-03f, -4.88658175e-02f, 8.50245133e-02f, 5.00942059e-02f, 3.56038995e-02f,
  -1.53268710e-01f, -3.87573004e-01f, 1.62972081e-02f, 1.63408648e-02f, -1.80578828e-02f, 1.55873951e-02f, 3.74098793e-02f, -8.60341191e-02f, -8.77107382e-02f, -1.08252121e-02f,
  -3.20856161e-02f, 2.43500378e-02f, 1.85441561e-02f, 2.58000791e-02f, -6.95708543e-02f, -9.56337601e-02f, -1.20391332e-01f, -7.79519677e-02f, -1.24242783e-01f, -9.70802270e-03f,
  -1.45507641e-02f, -1.01377301e-01f, 6.05262555e-02f, -5.71054593e-03f, 6.00884557e-02f, -6.19903877e-02f, -1.14641547e-01f, -8.80454928e-02f, 6.36452138e-02f, 7.64836743e-02f,
  1.78024247e-01f, -4.84043919e-02f, -1.53502420e-01f, 6.63079023e-02f, -1.24553017e-01f, 3.15196365e-02f, 9.16168317e-02f, -1.10988291e-02f, -2.34266192e-01f, 1.38203174e-01f,
  2.34402254e-01f, -1.59394175e-01f, 1.37900084e-01f, 1.40692145e-01f, 1.43199004e-02f, 1.50351282e-02f, 1.96575776e-01f, 2.22620815e-01f, -1.58009771e-02f, 1.69011429e-01f,
  1.15257628e-01f, 2.41921902e-01f, 1.25984862e-01f, 2.01738775e-01f, 4.38080467e-02f, -2.30351724e-02f, 8.34486783e-02f, -2.14819666e-02f, 1.11629017e-01f, -5.27867340e-02f,
  6.30358085e-02f, 2.03689542e-02f, 7.18211606e-02f, -6.14920221e-02f, 1.36884347e-01f, 2.18359694e-01f, 7.21977428e-02f, 9.90512688e-03f, -5.73173463e-02f, 4.36922796e-02f,
  1.74904931e-02f, 5.12200184e-02f, 1.49675757e-01f, -3.17699946e-02f, 2.92384978e-02f, -1.97692122e-02f, -5.36595732e-02f, -8.80150646e-02f, -1.00269258e-01f, -4.61371765e-02f,
  -9.47602242e-02f, -8.87172520e-02f, -1.16639905e-01f, -7.64320642e-02f, -1.87719036e-02f, -1.43963292e-01f, 1.09822135e-02f, 5.00030629e-02f, -4.59562615e-02f, 4.14058194e-02f,
  5.66862598e-02f, 5.80639727e-02f, 1.65125936e-01f, -8.43451824e-03f, 6.74009994e-02f, 5.84224202e-02f, 1.20159522e-01f, -6.36164695e-02f, -2.60708593e-02f, 3.61750275e-02f,
  -7.95387756e-03f, 1.78007588e-01f, -3.86195667e-02f, 3.07977106e-02f, 3.01297139e-02f, -5.41574284e-02f, 7.18843639e-02f, 7.66064040e-03f, -7.99214467e-02f, -1.75384209e-02f,
  5.18511981e-03f, 2.91478578e-02f, 5.80026060e-02f, -5.04962588e-03f, 2.69094668e-02f, 9.25096124e-03f, 2.16742530e-01f, 7.77655244e-02f, -4.95667607e-02f, 7.93839470e-02f,
  1.37423337e-01f, 1.10892944e-01f, 2.36438345e-02f, -6.27270415e-02f, 1.32517386e-02f, 1.48327842e-01f, -2.50051636e-02f, 6.26301542e-02f, -5.65109961e-03f, -4.01826389e-03f,
  7.41656572e-02f, -7.40132257e-02f, 8.75727646e-03f, -1.60981026e-02f, 1.64518822e-02f, 1.16980076e-01f, 2.01964956e-02f, -3.67154786e-03f, -1.30907625e-01f, 6.27206862e-02f,
  -9.06054080e-02f, -5.43143712e-02f, -1.09399430e-01f, 4.97544818e-02f, -1.48119200e-02f, -5.62789403e-02f, 1.11320289e-02f, 1.17993377e-01f, 2.18505543e-02f, -1.30618244e-01f,
  3.15155052e-02f, 1.34314522e-01f, 1.63503811e-01f, -5.22288121e-02f, 2.44503114e-02f, -7.16499835e-02f, -1.57424182e-01f, 3.89312506e-02f, 1.02580860e-01f, 2.50833184e-01f,
  -1.43245906e-01f, 1.84035674e-01f, -6.01514727e-02f, -7.61746336e-03f, -4.59842026e-01f, -2.87150085e-01f, -2.13583440e-01f, 5.38362563e-02f, -4.01543789e-02f, 3.13212834e-02f,
  -1.30796805e-01f, -2.22389340e-01f, -1.39052868e-01f, -2.01262519e-01f, 2.01741874e-01f, 3.10746789e-01f, -6.22339100e-02f, -3.95474248e-02f, 2.50341326e-01f, -7.34146461e-02f,
  -5.55804409e-02f, 1.26142113e-03f, 1.09519966e-01f, 5.45873456e-02f, 2.24032216e-02f, 2.36296803e-01f, 1.07905693e-01f, -1.35090873e-01f, 4.56089079e-02f, 5.68829738e-02f,
  4.35276218e-02f, 3.37253287e-02f, 2.67425384e-02f, 1.90303475e-02f, 6.52591437e-02f, 8.52543265e-02f, 1.15849920e-01f, 1.04399711e-01f, 3.72489430e-02f, -3.70035395e-02f,
  1.17851563e-01f, -9.00930725e-03f, 1.50856182e-01f, -1.69983543e-02f, 3.61785293e-02f, -2.12047528e-02f, 1.19902283e-01f, -2.24856045e-02f, 1.69640467e-01f, 3.19498628e-02f,
  -5.93805090e-02f, 1.14765309e-01f, -4.03771214e-02f, -6.19532680e-03f, 1.96314007e-02f, 6.18866086e-02f, -3.22298333e-02f, 6.13971055e-03f, 5.00545092e-02f, 1.08589884e-03f,
  -8.97980016e-03f, -1.00114115e-01f, 4.42275638e-03f, 1.55159652e-01f, 1.94132677e-03f, 1.27533332e-01f, 1.17500592e-02f, -1.25767604e-01f, -9.70179401e-03f, -1.43993851e-02f,
  -2.95960102e-02f, -4.60387170e-02f, 3.24117430e-02f, -1.57208275e-02f, -1.16296351e-01f, 1.68544252e-03f, 3.37237045e-02f, 9.44109857e-02f, -4.01557051e-03f, -1.53923957e-02f,
  -1.11511126e-02f, -1.02481991e-03f, 3.42899300e-02f, -9.35997143e-02f, 4.88842912e-02f, 3.78793268e-03f, -3.12507749e-02f, 7.94299021e-02f, 1.25960752e-01f, -4.91572954e-02f,
  4.62147482e-02f, 6.16123676e-02f, 8.75163674e-02f, -2.60726479e-03f, -5.42658642e-02f, -4.45451209e-04f, 3.93222719e-02f, 3.74017060e-02f, 8.19704235e-02f, 1.34751843e-02f,
  6.46221787e-02f, 8.86847600e-02f, -7.65326992e-02f, -2.10126061e-02f, -1.57696370e-03f, 1.97028577e-01f, 4.76997867e-02f, 4.37592603e-02f, -4.90291836e-03f, 1.76767148e-02f,
  3.10105354e-01f, -9.73264053e-02f, 1.97315514e-01f, 2.49538079e-01f, 6.11389130e-02f, -1.03171907e-01f, 1.86208576e-01f, 8.75200424e-03f, 1.94213226e-01f, -6.85944334e-02f,
  -6.54598922e-02f, 1.34244382e-01f, -7.13319704e-02f, 4.34768610e-02f, 7.59687051e-02f, -1.22171044e-01f, 2.69514993e-02f, -7.69095644e-02f, 4.82600480e-02f, 1.23341121e-01f,
  6.56963885e-02f, -7.37724453e-02f, -4.82204594e-02f, -1.45751655e-01f, 4.86812517e-02f, 8.12829584e-02f, -1.35539174e-01f, -1.77922344e-03f, -2.10918233e-01f, -9.44771543e-02f,
  2.92127095e-02f, 1.20361485e-01f, 1.81450713e-02f, -5.16525693e-02f, 6.74300175e-03f, 1.35223242e-02f, -4.41695610e-03f, 5.09934919e-03f, 1.10831074e-01f, 6.54709935e-02f,
  4.12521176e-02f, 1.07098958e-02f, -1.86944683e-03f, -2.30327584e-02f, 1.04601331e-01f, -1.66418068e-02f, -1.17527996e-03f, -4.56859991e-02f, 5.53370267e-02f, -2.32882947e-02f,
  -3.08083091e-03f, 3.19797546e-02f, 4.59442884e-02f, 2.74751280e-02f, 7.21653774e-02f, 1.00511108e-02f, -6.82072761e-03f, 2.01722793e-02f, 9.37349629e-04f, -5.37342131e-02f,
  -4.43085730e-02f, 4.39819433e-02f, -8.47196057e-02f, -8.92217532e-02f, -6.71570301e-02f, -3.53735387e-02f, -2.87967566e-02f, -1.76593033e-03f, 8.84319320e-02f, -4.48582470e-02f,
  6.11180328e-02f, 1.36878639e-01f, 2.70936191e-02f, 1.20520480e-01f, 7.45581761e-02f, 4.90575098e-03f, 1.27444550e-01f, -6.95616752e-02f, 1.20931894e-01f, -4.14036289e-02f,
  6.70465380e-02f, 1.02297645e-02f, -5.73739521e-02f, 2.33805948e-03f, 1.22025743e-01f, 4.55220789e-03f, 6.13839291e-02f, 9.77915227e-02f, 4.00929488e-02f, -5.29638305e-02f,
  -1.68240547e-01f, -1.24136232e-01f, 2.83985008e-02f, 1.38516854e-02f, -5.13740778e-02f, 7.58329853e-02f, 3.42584252e-02f, 3.82438712e-02f, -3.59500013e-02f, -1.08113941e-02f,
  2.77829021e-02f, 6.33538440e-02f, 5.57951778e-02f, -1.85819212e-02f, -1.99224539e-02f, 2.49194745e-02f, 1.21288769e-01f, -3.07045244e-02f, 3.56228910e-02f, -1.96607739e-01f,
  -8.63262787e-02f, 2.07511429e-02f, -3.03828567e-02f, 1.01510249e-01f, 1.13994762e-01f, 1.56010650e-02f, 1.03170887e-01f, -1.70494504e-02f, -8.24704990e-02f, -7.23912045e-02f,
  1.60227612e-01f, -1.25963092e-01f, -8.02610889e-02f, 2.17460468e-01f, -3.24111506e-02f, -2.34735608e-01f, -2.19420820e-01f, 1.35719746e-01f, -1.47876784e-01f, -6.05379529e-02f,
  2.18778387e-01f, -1.95575207e-02f, -6.94790259e-02f, 2.39967406e-01f, 3.07829916e-01f, 3.57934311e-02f, 2.00780705e-01f, 8.67441669e-02f, 5.02433581e-03f, 9.16237310e-02f,
  2.28275195e-01f, 1.61937609e-01f, 2.31029257e-01f, 1.74642399e-01f, 3.65816057e-02f, 1.54324874e-01f, 2.81694651e-01f, -2.71488703e-03f, 1.68919563e-01f, 8.81488770e-02f,
  -3.00863571e-03f, -4.04141620e-02f, -4.33065295e-02f, 3.09544262e-02f, 7.66800269e-02f, 2.74917260e-02f, 2.28456166e-02f, 2.41809431e-03f, 4.35823202e-02f, 1.31828384e-02f,
  -4.09458019e-02f, -8.49169306e-03f, -4.28765938e-02f, -9.51849110e-03f, -3.87140848e-02f, -1.88872200e-02f, -8.36796090e-02f, -8.03984702e-02f, -9.56317708e-02f, -2.23629083e-02f,
  7.41635682e-03f, -2.55222581e-02f, -7.95311928e-02f, -1.33557161e-02f, -3.89022827e-02f, -2.07763119e-03f, -5.80138117e-02f, 1.05413646e-02f, -4.24166955e-02f, 7.16384947e-02f,
  3.15549485e-02f, 1.97453033e-02f, 3.70208621e-02f, -9.33396593e-02f, -1.14121009e-02f, 2.86866743e-02f, -2.00934391e-02f, -7.12022334e-02f, -5.39318100e-02f, 1.07956149e-01f,
  -2.92180013e-02f, 5.81732057e-02f, 3.25226737e-03f, 5.74842133e-02f, 3.99304554e-02f, -5.65688312e-02f, 4.29835543e-02f, 4.58215624e-02f, 2.69560982e-02f, 2.72063147e-02f,
  -5.98670952e-02f, 2.90088803e-02f, 2.79961284e-02f, -4.60306220e-02f, -5.50119169e-02f, 9.87929329e-02f, 8.06437656e-02f, -1.17014507e-02f, 4.06125747e-02f, 3.87455262e-02f,
  6.01504408e-02f, 3.87587287e-02f, -3.28871831e-02f, -3.55148055e-02f, 5.10492921e-02f, 7.52653461e-03f, 6.43642172e-02f, 8.24770518e-03f, 6.16977401e-02f, -2.82144174e-02f,
  6.98780864e-02f, -6.63199350e-02f, -1.58428177e-02f, 2.04869639e-02f, 3.33723538e-02f, 7.97662884e-02f, 2.28662509e-02f, -2.88169719e-02f, 8.95836428e-02f, 6.27441779e-02f,
  1.12996697e-01f, 7.53776450e-03f, 3.52859683e-02f, 4.73517179e-03f, 3.22925523e-02f, -7.82224312e-02f, 1.28981648e-02f, -7.29832873e-02f, 5.38261309e-02f, -1.11462958e-02f,
  -2.71857649e-01f, 1.61876246e-01f, -6.01132996e-02f, -1.04656234e-01f, 4.60385233e-02f, -1.37430310e-01f, -1.20363936e-01f, 1.11701928e-01f, -1.19865134e-01f, 1.20850138e-01f,
  5.53888492e-02f, -1.24709167e-01f, 6.96394071e-02f, -1.29743516e-01f, -4.01451916e-01f, -1.44825101e-01f, -1.94574416e-01f, -1.30178198e-01f, -1.01281978e-01f, 1.20915927e-01f,
  -2.94293836e-02f, -1.16140053e-01f, -1.03578940e-01f, 2.04056218e-01f, 5.69199249e-02f, 9.59969237e-02f, 1.71596408e-01f, 1.31764829e-01f, -3.12495753e-02f, 1.63272563e-02f,
  -6.02735393e-02f, 2.14528926e-02f, -1.01831332e-02f, -4.06168774e-02f, -1.39607955e-02f, -2.16098726e-02f, 6.79218173e-02f, -1.99015737e-02f, -2.22099274e-02f, -4.65836823e-02f,
  -4.69569117e-02f, -4.52600829e-02f, 3.80522087e-02f, -6.09766468e-02f, -4.85206097e-02f, -5.14471382e-02f, 5.10401018e-02f, 1.04946615e-02f, -7.94222020e-03f, -1.45663172e-02f,
  1.07566118e-01f, -4.28371765e-02f, -1.24557670e-02f, -7.73357600e-02f, -1.38026858e-02f, 3.18306237e-02f, -1.36688530e-01f, 1.47920847e-02f, 7.95209128e-03f, -1.03180133e-01f,
  -5.51225804e-02f, 9.19934083e-03f, 8.57373178e-02f, -3.53539623e-02f, -1.27547663e-02f, 2.15383861e-02f, 4.29694094e-02f, -2.46059373e-02f, 7.94916824e-02f, -1.98587477e-02f,
  5.77402860e-02f, 1.39985690e-02f, -4.19548489e-02f, 8.22994451e-04f, 1.11038545e-02f, 5.87632181e-03f, 7.13295788e-02f, -2.66439430e-02f, -1.24358181e-02f, -7.56607875e-02f,
  -6.75695762e-03f, 2.45421287e-02f, -3.75275180e-04f, -1.70490779e-02f, -6.53879121e-02f, -4.02779272e-03f, -6.86638174e-04f, -2.31907354e-03f, 5.26226088e-02f, -4.24980707e-02f,
  -2.44760383e-02f, 1.32372126e-01f, -8.91227201e-02f, -3.33635099e-02f, 4.76997495e-02f, -1.17008008e-01f, -1.27914604e-02f, 3.60543728e-02f, 8.35087821e-02f, -4.75164677e-04f,
  1.30197192e-02f, 6.92147985e-02f, 5.02663217e-02f, -4.39598598e-02f, -5.14188372e-02f, -3.84300426e-02f, -1.15058189e-02f, 7.83689848e-06f, -1.78641137e-02f, 3.89312021e-02f,
  4.38305177e-02f, 8.15112069e-02f, -1.02901965e-01f, 2.58825123e-02f, 1.33653888e-02f, -8.03243928e-03f, -1.15046382e-01f, -4.33294810e-02f, 3.53516825e-02f, -7.64953345e-02f,
  -1.09451905e-01f, 1.41861379e-01f, 1.74676329e-01f, 1.83201939e-01f, -2.16808449e-02f, -4.71394956e-01f, -3.34268242e-01f, 1.14713468e-01f, -1.13087036e-01f, -5.76584749e-02f,
  7.21415728e-02f, -1.73559394e-02f, 1.74283698e-01f, 3.57390083e-02f, 1.25109985e-01f, 5.14440686e-02f, -6.53770939e-02f, -1.14530489e-01f, -3.72731648e-02f, 5.58987297e-02f,
  1.32845670e-01f, 1.12350874e-01f, 3.23224455e-01f, 4.22255173e-02f, 3.05713657e-02f, 8.59397501e-02f, 2.20523208e-01f, 9.66300368e-02f, -5.09401746e-02f, -9.77321938e-02f,
  -9.43096057e-02f, 2.52453208e-01f, 7.43662706e-03f, -1.98512222e-04f, 1.60206179e-03f, -7.11524859e-02f, -1.43195242e-01f, 3.00837457e-02f, 6.90746382e-02f, 6.40007928e-02f,
  -9.93070081e-02f, -1.59349795e-02f, -3.11285369e-02f, -1.15050666e-01f, -5.97844198e-02f, 8.43948349e-02f, 3.44021395e-02f, -8.95986632e-02f, 5.58224730e-02f, -1.76845212e-02f,
  -3.06522585e-02f, 2.65043061e-02f, 3.21333222e-02f, -3.04987542e-02f, -3.71566005e-02f, -6.34750947e-02f, -1.23322412e-01f, -6.86435923e-02f, 2.95630991e-02f, 7.76625192e-03f,
  -7.91916400e-02f, -9.21077430e-02f, -1.42689690e-01f, 1.92692466e-02f, 4.15320992e-02f, -4.16112766e-02f, -4.83499318e-02f, 8.74023512e-03f, 8.06007907e-02f, 1.04581267e-01f,
  1.73970219e-02f, 1.11683220e-01f, -5.33548407e-02f, -2.63461415e-02f, 1.09962737e-02f, 1.87830403e-02f, -4.23600078e-02f, 1.14640646e-01f, -1.06032051e-01f, 3.84837873e-02f,
  -9.14514251e-03f, 4.28434387e-02f, -3.41408998e-02f, -2.82591917e-02f, -9.49068964e-02f, 8.14941227e-02f, -3.18625290e-03f, -5.05371504e-02f, 1.27973273e-01f, -6.57627955e-02f,
  7.49981031e-03f, 2.66849548e-01f, 2.38447562e-02f, -3.34890634e-02f, 3.78044769e-02f, -9.53115709e-03f, -2.04378017e-03f, -1.72226131e-02f, 7.22138882e-02f, -6.71581086e-03f,
  1.95364133e-02f, -4.77348119e-02f, -1.60542596e-03f, -3.71095315e-02f, -3.29917483e-02f, 3.40955034e-02f, 5.40638790e-02f, 3.71494074e-03f, 1.09758139e-01f, 1.14981666e-01f,
  1.75936848e-01f, 2.63002701e-03f, -6.59139603e-02f, -8.67606774e-02f, -5.92695028e-02f, 4.20725085e-02f, -3.82084548e-02f, -5.59231406e-03f, 3.58289890e-02f, 3.48697864e-02f,
  4.41195518e-01f, -4.19537455e-01f, 1.35645255e-01f, 1.78120166e-01f, 2.80054748e-01f, 3.94696407e-02f, 3.07243437e-01f, -1.48853198e-01f, -5.85170761e-02f, -3.59895229e-01f,
  2.26748884e-02f, -5.41105494e-02f, 2.75775474e-02f, -5.99383302e-02f, 3.02429110e-01f, -1.37474015e-02f, 7.92899802e-02f, 8.22600275e-02f, -6.09555170e-02f, -2.51028426e-02f,
  -2.51725912e-02f, 6.00581840e-02f, 3.57653648e-02f, -1.53333873e-01f, 1.18920445e-01f, -9.25584733e-02f, 9.28245783e-02f, 1.46098837e-01f, -1.21487111e-01f, 6.62720129e-02f,
  7.09259808e-02f, -6.48974627e-02f, -6.44758642e-02f, -8.72273371e-02f, -3.16835716e-02f, 5.70424367e-03f, 4.48704436e-02f, 7.53844827e-02f, 4.86222319e-02f, -8.21598098e-02f,
  -7.95065835e-02f, 1.29068317e-02f, 6.70399368e-02f, 4.50596176e-02f, 2.12626774e-02f, -1.16445340e-01f, 3.48488577e-02f, -7.25082681e-02f, -7.53745511e-02f, 3.17847840e-02f,
  -5.90092577e-02f, 4.25657810e-04f, -3.24545726e-02f, -5.70334941e-02f, 2.95918602e-02f, -3.27968448e-02f, 2.53986195e-02f, 2.12242305e-02f, -8.44472870e-02f, -5.50430678e-02f,
  -4.24799770e-02f, 8.46158862e-02f, -7.75694894e-03f, 1.32598616e-02f, 2.76734438e-02f, -5.21103740e-02f, -1.29289860e-02f, 9.40091163e-02f, -2.82775816e-02f, 3.03615257e-02f,
  1.42432358e-02f, 1.98538024e-02f, -2.65695918e-02f, -7.82598183e-03f, 3.40871960e-02f, -2.27716118e-02f, -4.39877212e-02f, -2.15476844e-02f, 8.79414938e-03f, 6.04525991e-02f,
  1.35666341e-01f, 7.94993341e-02f, 3.13452967e-02f, 5.23112379e-02f, -1.79672521e-02f, 6.64465204e-02f, -2.95560826e-02f, -1.07847996e-01f, 5.83302602e-02f, -7.95017648e-03f,
  -1.51918083e-01f, -2.69406915e-01f, -1.40220774e-02f, -1.09660603e-01f, -3.90013419e-02f, -5.49518578e-02f, 7.92017281e-02f, -1.22769549e-01f, -1.01773068e-01f, -3.66126224e-02f,
  -4.11491729e-02f, 2.56191045e-02f, 2.74198893e-02f, 4.54900637e-02f, -7.19812512e-02f, -5.99451214e-02f, -1.62544176e-02f, -8.40724558e-02f, -2.01982446e-02f, -1.16370134e-02f,
  5.12424372e-02f, 1.27406223e-02f, 5.31052565e-03f, -3.54465954e-02f, -2.02619638e-02f, -2.70333495e-02f, -3.07160001e-02f, 4.94411178e-02f, 1.36761874e-01f, -2.40694396e-02f,
  3.14987242e-01f, -3.60749662e-01f, -3.02972142e-02f, 2.60063231e-01f, 2.74236917e-01f, 8.62379670e-02f, 3.05269718e-01f, -3.22337672e-02f, 1.48563489e-01f, -2.64189124e-01f,
  6.60879463e-02f, -2.22700760e-01f, -1.27514720e-01f, 7.34214261e-02f, 2.91119933e-01f, -8.05265233e-02f, 5.66596091e-02f, -8.45968351e-02f, -7.15989918e-02f, -7.37551739e-03f,
  1.27596453e-01f, 1.06809959e-01f, 1.20002404e-02f, -1.33566305e-01f, 9.69298333e-02f, -7.23471567e-02f, 5.43319881e-02f, -7.19199181e-02f, -1.19139381e-01f, -2.51516625e-02f,
  8.22465215e-03f, 1.76744331e-02f, 5.43811694e-02f, -5.23139387e-02f, -6.07014112e-02f, 4.51104566e-02f, -2.42610984e-02f, 1.23103731e-03f, 7.26999938e-02f, -7.60050640e-02f,
  -6.52797893e-02f, -2.37370953e-02f, 2.65871044e-02f, -2.07988545e-03f, 6.09105490e-02f, -8.96893535e-03f, 2.76943706e-02f, -8.44814032e-02f, -1.94442242e-01f, -1.50000127e-02f,
  -6.27757311e-02f, -1.05548777e-01f, 5.67750111e-02f, -5.15350848e-02f, -1.22477338e-01f, -5.02954284e-03f, -4.06999514e-02f, -9.86923277e-02f, -3.55532281e-02f, -9.60985571e-02f,
  -9.69217792e-02f, -1.76165346e-02f, 4.56144623e-02f, -1.21251233e-02f, 6.43280707e-03f, 8.02677125e-02f, 5.64896055e-02f, -1.51957469e-02f, -3.72859626e-03f, -7.36180693e-02f,
  5.45483157e-02f, 6.37936816e-02f, -7.21350610e-02f, 1.67989314e-01f, -3.20450068e-02f, 6.40864521e-02f, 1.35955259e-01f, -5.26189134e-02f, -1.89836398e-02f, -4.57920581e-02f,
  1.89050455e-02f, -1.38352076e-02f, -8.32217038e-02f, 2.63751466e-02f, 7.25583062e-02f, 3.66391279e-02f, 3.63752767e-02f, -8.60612392e-02f, -2.95945276e-02f, 3.31958495e-02f,
  5.69746830e-02f, -1.85120389e-01f, -8.53185430e-02f, -1.18919283e-01f, -6.25734553e-02f, -3.10345516e-02f, -3.03987544e-02f, -4.83832546e-02f, -5.92342243e-02f, 6.86839819e-02f,
  3.33725964e-03f, 1.97547693e-02f, 2.54679304e-02f, -6.38759211e-02f, -4.27807085e-02f, 2.72130854e-02f, -5.25898337e-02f, 2.77831443e-02f, -1.05860457e-01f, -2.90519148e-02f,
  -1.72672980e-02f, 4.63599488e-02f, 2.44734865e-02f, 8.93870965e-02f, -5.55124395e-02f, -5.72783276e-02f, -5.73473722e-02f, 2.90369941e-03f, -9.81801301e-02f, -1.79006737e-02f,
  -4.71574187e-01f, 6.77329078e-02f, 4.55974154e-02f, 3.87402028e-02f, -2.73939073e-01f, -3.04439222e-03f, 1.75427064e-01f, -3.49804126e-02f, 1.26638457e-01f, 1.77713767e-01f,
  1.23754449e-01f, 1.67832151e-02f, 9.01751965e-02f, 9.18679088e-02f, -6.92221597e-02f, 1.45245522e-01f, 1.49606196e-02f, 5.58663793e-02f, -5.33267483e-02f, -7.97837973e-02f,
  -3.47322859e-02f, 1.17134206e-01f, 2.17911303e-02f, -1.74084511e-02f, 3.61220092e-02f, -6.34613708e-02f, 6.27593026e-02f, 1.59998965e-02f, 5.79570495e-02f, -3.87579203e-02f,
  -2.44326830e-01f, -1.43964961e-01f, -6.13838956e-02f, 1.23738004e-02f, 6.63711876e-02f, -2.14973278e-02f, 2.12716144e-02f, -4.67556007e-02f, -3.51587795e-02f, 9.54811554e-03f,
  -6.33546710e-02f, 2.05629083e-04f, 4.27251235e-02f, -2.31002793e-02f, -1.72067836e-01f, -1.46462750e-02f, 3.95793933e-04f, 5.05990945e-02f, 8.64615515e-02f, -5.01381308e-02f,
  1.61804669e-02f, 1.90030877e-02f, -1.44546374e-03f, 1.04071416e-01f, -3.03854998e-02f, 2.99243797e-02f, 3.07111088e-02f, -8.36767722e-03f, -1.42129973e-01f, -9.03527960e-02f,
  -1.15781598e-01f, 6.01236634e-02f, 6.35167211e-02f, 2.66238302e-02f, -1.83495656e-02f, 7.51483887e-02f, 5.97803108e-02f, -7.09953085e-02f, -6.39437661e-02f, -5.29960766e-02f,
  4.50749584e-02f, -3.27621438e-02f, -1.72630157e-02f, 7.96404202e-03f, -2.94284858e-02f, 1.26094908e-01f, -1.36582572e-02f, -7.86946565e-02f, 8.15905482e-02f, -9.25749242e-02f,
  2.54173949e-02f, -1.01610601e-01f, 5.32281250e-02f, -5.58629781e-02f, 1.14684589e-02f, -8.80095083e-03f, -3.33154425e-02f, 6.31946549e-02f, 6.04240596e-02f, -4.27791737e-02f,
  -1.88875824e-01f, -8.45040455e-02f, 1.11097572e-02f, 2.28621089e-03f, -6.42421097e-03f, -1.39651120e-01f, 6.80920901e-03f, -7.88312852e-02f, -1.22472830e-01f, -2.54437570e-02f,
  -7.72079900e-02f, 9.54897795e-03f, -8.99892226e-02f, 2.94316802e-02f, -5.74486814e-02f, 3.56578524e-03f, -4.16228212e-02f, -4.83448878e-02f, -1.49901081e-02f, 2.52705812e-03f,
  1.37556391e-02f, -4.94584383e-04f, 1.22264005e-01f, 2.56867129e-02f, 7.86595568e-02f, -5.63658250e-04f, -7.65433982e-02f, 1.67102646e-02f, -1.76813006e-01f, -4.18098904e-02f,
  -6.14275932e-01f, 2.59753287e-01f, -1.00654528e-01f, -4.79865149e-02f, -1.30300716e-01f, 8.59024003e-02f, 7.33639672e-02f, -1.36664599e-01f, -2.83586327e-02f, 1.74627587e-01f,
  -6.62495419e-02f, -2.33636826e-01f, 1.16972670e-01f, 1.36675835e-01f, -2.87851542e-01f, 2.93604761e-01f, 2.75111217e-02f, 2.14380380e-02f, 8.07852298e-02f, -8.37030858e-02f,
  -3.15876938e-02f, 1.27032176e-01f, 2.43435726e-02f, 1.78509578e-01f, -2.21883729e-01f, -7.12331757e-02f, -1.25332713e-01f, -1.32832751e-01f, -6.80308565e-02f, -1.82314634e-01f,
  -9.78874490e-02f, -3.68452668e-01f, -5.92421740e-02f, -1.92232490e-01f, -6.27269894e-02f, -1.12233378e-01f, -9.60303620e-02f, -9.36740041e-02f, -7.56940767e-02f, -5.94035946e-02f,
  -4.76079769e-02f, 2.91688479e-02f, -7.05180243e-02f, 3.42800431e-02f, 2.54395101e-02f, -7.70475268e-02f, 3.88543047e-02f, 3.21511440e-02f, 5.17947637e-02f, 5.69611148e-05f,
  1.67682464e-03f, 2.00423859e-02f, 2.88394094e-02f, 9.51681957e-02f, -9.31002386e-03f, -3.04905195e-02f, 6.08348288e-02f, -1.04640029e-01f, -1.48057351e-02f, -5.47120869e-02f,
  -5.15680090e-02f, 3.10791731e-02f, 8.66044238e-02f, -1.77608952e-02f, 1.03922198e-02f, 9.89062525e-03f, 1.98403057e-02f, -1.66677944e-02f, 1.04984842e-01f, 4.37221350e-03f,
  2.83561014e-02f, -8.92719179e-02f, -9.27919075e-02f, 7.41586536e-02f, 4.67343181e-02f, -1.68544948e-02f, 1.02448482e-02f, -7.15580434e-02f, 7.04678744e-02f, -1.38447853e-02f,
  1.17431283e-02f, -1.16816670e-01f, 9.16095544e-03f, 5.57565130e-03f, 8.98501053e-02f, 1.68852806e-02f, -4.77314554e-02f, 6.92326054e-02f, -6.53183535e-02f, -7.48740435e-02f,
  -1.40967071e-01f, -3.06232691e-01f, -5.68796173e-02f, 2.46289205e-02f, 8.13561399e-03f, -3.39265615e-02f, 4.93476912e-02f, -4.56103459e-02f, -3.33664790e-02f, -8.57043639e-02f,
  -1.08738318e-01f, 1.55384997e-02f, -9.04159620e-02f, 5.09425774e-02f, 6.52216226e-02f, 8.05475712e-02f, 8.31433292e-03f, -1.52986003e-02f, -1.26166549e-02f, -5.80039360e-02f,
  -1.88601520e-02f, -4.03492339e-02f, -3.18145193e-02f, 8.35170783e-03f, -1.51138054e-02f, -5.47383428e-02f, -8.50617960e-02f, 1.26636156e-03f, 5.17796399e-03f, -4.22598515e-03f,
  5.54533601e-01f, -1.15788087e-01f, 1.07120976e-01f, 2.89566308e-01f, 1.36919141e-01f, 1.16325065e-01f, 1.52138919e-01f, 1.77601889e-01f, 3.65498006e-01f, -3.57792974e-02f,
  3.90746519e-02f, -8.53473917e-02f, 3.61605338e-03f, -7.95699432e-02f, -8.22586268e-02f, -3.93284224e-02f, 1.14430264e-01f, 7.31396116e-03f, 2.06393838e-01f, 1.85844481e-01f,
  2.35462978e-01f, -2.66658086e-02f, -1.71196356e-01f, -1.85117811e-01f, 1.16677113e-01f, 3.82999033e-02f, -2.39502743e-01f, -8.13475624e-02f, -1.32079884e-01f, -2.49757096e-01f,
  3.65444086e-02f, 3.33123170e-02f, -6.59849569e-02f, 4.11855318e-02f, 2.55325623e-02f, -6.95704669e-02f, -2.17880215e-02f, -2.18333706e-01f, -1.36569459e-02f, -6.48916140e-03f,
  8.06797761e-03f, -3.36742774e-02f, -1.15873506e-02f, -2.19603572e-02f, -2.04930548e-03f, 4.06878814e-02f, -4.52474058e-02f, 3.04618087e-02f, -3.95867042e-02f, 4.49241400e-02f,
  8.44637491e-03f, -2.30835062e-02f, 1.26270711e-01f, -7.01187700e-02f, -5.68323135e-02f, -3.43104452e-03f, -5.60171492e-02f, -1.33659407e-01f, -2.52406113e-02f, -1.02236226e-01f,
  -3.57698579e-03f, -6.41740784e-02f, -7.66410213e-03f, -4.78948355e-02f, 6.71272278e-02f, -3.63780721e-03f, 4.18434255e-02f, 2.39385441e-02f, -4.31752913e-02f, 6.99118823e-02f,
  8.55682045e-02f, -7.94562250e-02f, -4.43878546e-02f, 7.48478100e-02f, -6.83203014e-03f, 2.19412590e-03f, -2.51253247e-02f, 1.09043285e-01f, -5.64500317e-02f, -9.14992392e-03f,
  -3.81257795e-02f, 2.19932925e-02f, -1.13978706e-01f, 5.00537362e-03f, -8.75395685e-02f, -4.59489524e-02f, -7.19269738e-02f, 1.82017311e-01f, 2.54091900e-02f, 3.68426219e-02f,
  -8.99956971e-02f, -1.55628219e-01f, -1.50053026e-02f, 1.95450126e-03f, 2.29921509e-02f, -4.53669243e-02f, 9.32953954e-02f, 5.15634865e-02f, 1.99369006e-02f, 7.53454864e-02f,
  -9.57130119e-02f, 5.55446818e-02f, -2.53676251e-02f, -1.50931701e-02f, -5.30022494e-02f, 7.92864524e-03f, 4.05606478e-02f, 9.71983559e-03f, -1.40694290e-01f, -3.86537686e-02f,
  -5.23219220e-02f, 7.83889666e-02f, -3.59407514e-02f, 8.85957181e-02f, -8.86297300e-02f, -6.83203619e-03f, -4.78756754e-03f, 4.33446793e-03f, -9.00207385e-02f, -1.16011068e-01f,
  -1.94083508e-02f, 4.97141778e-02f, -8.25367793e-02f, -2.66953018e-02f, 2.07128868e-01f, 9.64601710e-02f, -1.29548684e-01f, 6.61411658e-02f, -2.02228144e-01f, 3.16222534e-02f,
  -1.42083630e-01f, -1.58624053e-01f, -2.18288094e-01f, -1.51280791e-01f, -2.10234746e-01f, -2.23741278e-01f, -3.02712638e-02f, -1.70361862e-01f, -1.07842818e-01f, 8.96678790e-02f,
  -9.51557159e-02f, -8.85974765e-02f, -8.26290250e-02f, 8.29110444e-02f, 1.01131849e-01f, 1.75699443e-01f, 1.20405525e-01f, -2.22710427e-02f, 9.53876302e-02f, -5.36048636e-02f,
  -1.57902092e-01f, -1.00409843e-01f, -1.49872869e-01f, -2.46711783e-02f, -8.53952952e-03f, 1.24684051e-01f, 1.13244735e-01f, -1.33242667e-01f, 4.07105237e-02f, -1.47740290e-01f,
  1.84551459e-02f, 9.10298675e-02f, -7.58768320e-02f, -4.79666963e-02f, -2.01677885e-02f, -4.03225161e-02f, -1.05458237e-02f, -5.80790080e-02f, -1.00840561e-01f, -1.01084642e-01f,
  -2.19289735e-02f, 6.75158575e-02f, 5.64719327e-02f, -2.80507598e-02f, 1.12249807e-01f, -1.92479156e-02f, 6.83605745e-02f, 1.01087563e-01f, -1.36150662e-02f, 3.85861471e-02f,
  2.34178081e-02f, 1.33441865e-01f, 1.29373163e-01f, -8.10371935e-02f, -1.11507900e-01f, 1.00621972e-02f, 1.77486464e-02f, -1.52604394e-02f, -4.50041555e-02f, 9.14302915e-02f,
  -2.83129122e-02f, -1.13867842e-01f, -5.78259639e-02f, 5.90511449e-02f, -2.69144978e-02f, 5.64026795e-02f, 9.87143144e-02f, 6.08688639e-03f, -7.77162164e-02f, 8.56925733e-03f,
  -7.88938329e-02f, 7.72070736e-02f, -3.37034240e-02f, -4.97801788e-03f, -2.23594643e-02f, -2.58220686e-03f, -7.21763354e-03f, -5.63793108e-02f, 1.63898066e-01f, 4.03831713e-02f,
  1.11353010e-01f, 1.26455307e-01f, -7.52590746e-02f, -9.62454379e-02f, -1.41639963e-01f, -4.77832556e-02f, -1.30047351e-01f, 8.99430960e-02f, -1.62563007e-02f, 2.40454711e-02f,
  1.99509785e-01f, 1.23470746e-01f, 1.77332815e-02f, 5.96841313e-02f, -4.09984961e-03f, 1.11305133e-01f, -3.36178904e-03f, 4.47843932e-02f, -3.06170405e-04f, 2.12677922e-02f,
  1.31894633e-01f, 3.24081779e-02f, 5.89785445e-03f, 1.91617552e-02f, 5.32599762e-02f, 1.00097209e-01f, 3.77080515e-02f, 1.20610580e-01f, 2.54176594e-02f, 5.44444397e-02f,
  -3.90417948e-02f, -3.06779199e-04f, 9.30762067e-02f, -1.03674226e-01f, 1.19186580e-01f, -5.34907021e-02f, -4.57522236e-02f, -2.61561543e-01f, -5.26629798e-02f, -3.29022050e-01f,
  -1.01319574e-01f, 7.38218427e-02f, 1.42843142e-01f, -2.17802465e-01f, 2.18541965e-01f, 6.78391457e-02f, -1.75289229e-01f, -8.04388076e-02f, -1.07461214e-02f, -2.01935261e-01f,
  -4.03187647e-02f, -1.77881002e-01f, 2.08761573e-01f, -2.19422922e-01f, -3.29176970e-02f, -1.56772044e-02f, -3.77802365e-02f, -1.24697834e-02f, -8.71916935e-02f, -4.05962579e-02f,
  -2.14906055e-02f, -8.21059048e-02f, 1.61943316e-01f, 1.37618799e-02f, 3.74655724e-02f, -9.02269334e-02f, -8.16882253e-02f, 7.70151615e-02f, 1.11480594e-01f, 5.10329604e-02f,
  6.86979014e-03f, -4.04558424e-03f, -1.15436792e-01f, -3.80399376e-02f, -1.99760243e-01f, -6.11631051e-02f, 4.67891060e-02f, 8.76035243e-02f, 5.56323603e-02f, -6.99373055e-03f,
  6.45254403e-02f, 1.30637527e-01f, 7.30443327e-03f, -6.83083460e-02f, -9.64107737e-03f, -1.65884912e-01f, -2.04921104e-02f, 1.68300271e-01f, 7.15320408e-02f, -1.26436740e-01f,
  -1.56423628e-01f, -7.90888593e-02f, -9.89352390e-02f, 1.42733335e-01f, 3.74457650e-02f, -2.50424761e-02f, -1.49873570e-02f, 3.81743796e-02f, 1.74876563e-02f, 4.51397114e-02f,
  6.70417547e-02f, -4.95918356e-02f, 7.18574673e-02f, 7.99214467e-02f, -5.27059697e-02f, 3.63794826e-02f, -1.14587909e-02f, 3.84230688e-02f, -4.89104688e-02f, -1.01647377e-01f,
  -1.45535260e-01f, -8.33118334e-02f, 9.09194797e-02f, 9.05014724e-02f, -1.92596633e-02f, 5.09948842e-02f, 1.36044649e-02f, 7.87916556e-02f, 2.95308810e-02f, -1.27733499e-02f,
  1.05592594e-01f, -3.26029032e-01f, -7.45266210e-03f, 6.30516261e-02f, 3.55005153e-02f, -7.97051117e-02f, -6.24636225e-02f, 1.33185713e-02f, -7.01376498e-02f, -1.86610986e-02f,
  -1.39496580e-01f, 4.92805466e-02f, -6.42003864e-02f, 8.40170309e-03f, -1.26568163e-02f, 3.17359045e-02f, -8.83999020e-02f, -1.43419625e-02f, 1.34083018e-01f, -7.25635961e-02f,
  1.80639103e-02f, -7.66069591e-02f, -7.50562362e-03f, 2.18401086e-02f, -4.11035605e-02f, 1.68267805e-02f, 2.96093691e-02f, -4.40696999e-02f, 4.39741127e-02f, 2.98488531e-02f,
  -2.49911621e-01f, 1.97097778e-01f, -1.32609069e-01f, 1.82390511e-01f, -5.51545210e-02f, 9.15248096e-02f, 9.47464705e-02f, -1.82743166e-02f, 1.81787640e-01f, 7.25076273e-02f,
  6.88509196e-02f, 1.30776554e-01f, 7.92816430e-02f, 2.14660376e-01f, 6.19087666e-02f, 1.62736297e-01f, 1.62861601e-01f, 1.51333615e-01f, -2.53225863e-02f, 7.08959773e-02f,
  1.03429928e-01f, 5.91488816e-02f, 1.13350146e-01f, 2.75976788e-02f, -5.32349013e-02f, -7.19978735e-02f, 3.42997797e-02f, -2.04389691e-02f, 4.05218787e-02f, 6.13203607e-02f,
  4.60120961e-02f, -4.40428741e-02f, -4.74913605e-02f, -8.88953581e-02f, -7.43228272e-02f, -7.46045783e-02f, -5.67746833e-02f, -1.02656290e-01f, 8.33666977e-03f, 6.99834898e-02f,
  2.26820298e-02f, 1.26801142e-02f, -1.34519532e-01f, -1.86303537e-02f, -8.73078257e-02f, 5.55592068e-02f, 5.03675081e-02f, 8.83602053e-02f, 1.44901946e-02f, -1.65175963e-02f,
  -4.27035280e-02f, -3.43900025e-02f, 6.21670187e-02f, 1.71179846e-02f, 2.05989946e-02f, 1.40371054e-01f, 1.26335919e-01f, -4.60422412e-02f, -2.99120136e-02f, 1.06625773e-01f,
  -1.31547123e-01f, 2.27483455e-02f, 8.55453499e-03f, 4.73271087e-02f, 5.50023001e-03f, -9.34664011e-02f, 9.41626504e-02f, -3.72373275e-02f, 1.45699568e-02f, 2.12809995e-01f,
  9.91328508e-02f, -2.06167111e-03f, 7.02514499e-03f, -6.22443333e-02f, -1.99581292e-02f, -1.17091807e-02f, -4.21656370e-02f, 8.26638490e-02f, -8.19732025e-02f, -9.45410952e-02f,
  1.81180425e-02f, 6.21391721e-02f, -1.68681182e-02f, 4.90187332e-02f, 5.86418882e-02f, -5.15453145e-02f, 1.00306831e-01f, 4.01212089e-02f, -9.29979514e-03f, -3.51543352e-02f,
  1.76440999e-01f, 6.33025616e-02f, 2.72613554e-03f, -4.82859947e-02f, 4.06211913e-02f, 4.39471975e-02f, 5.66115379e-02f, -1.92730743e-02f, 1.04202582e-02f, 1.39147155e-02f,
  -1.01493709e-01f, -6.61604553e-02f, -2.76568457e-02f, 1.20272916e-02f, -3.45508829e-02f, 4.32607830e-02f, 7.92886540e-02f, 3.38588618e-02f, -1.68564841e-02f, -6.59786761e-02f,
  1.64792631e-02f, -5.51330596e-02f, -1.52593255e-02f, 8.78476072e-03f, -7.26473425e-03f, -3.78314070e-02f, -1.91190578e-02f, 6.19538240e-02f, -1.09806977e-01f, 1.32611334e-01f,
  4.07945253e-02f, -2.39126429e-01f, -2.33628973e-01f, -2.44417340e-01f, 3.69529310e-03f, -7.73475319e-02f, -7.02064857e-02f, -5.71304224e-02f, -1.65511221e-01f, 9.53701884e-02f,
  1.13596618e-01f, -5.32821976e-02f, 2.82352623e-02f, -1.84753418e-01f, -5.65181859e-02f, -6.73897266e-02f, -9.39243510e-02f, 2.58089025e-02f, -9.14446823e-03f, 2.72639785e-02f,
  3.58722871e-04f, 5.61713018e-02f, -1.33964390e-01f, 7.75675476e-03f, -1.20663978e-01f, 7.77814165e-02f, 1.03143707e-01f, 4.47967276e-02f, 5.98866045e-02f, 9.93153080e-03f,
  3.64925116e-02f, 3.34997615e-03f, -7.20906332e-02f, 1.08943926e-02f, 1.13885654e-02f, 2.58963823e-01f, 3.14714275e-02f, -8.98623914e-02f, 1.60899758e-02f, 4.32442725e-02f,
  4.97091189e-02f, -8.37239157e-03f, 9.13169533e-02f, 5.02960570e-02f, -3.92555743e-02f, -7.72137716e-02f, -8.68497491e-02f, -1.02921471e-01f, -2.14149401e-01f, -4.40584645e-02f,
  -1.03754429e-02f, -1.74109861e-01f, -1.51988611e-01f, -1.46216527e-01f, -3.88750024e-02f, -4.80782352e-02f, 1.05039682e-02f, 6.64732531e-02f, 3.32609192e-02f, 3.20961848e-02f,
  1.54005095e-01f, 2.96649486e-02f, 1.66883860e-02f, -1.21754825e-01f, -2.62283441e-02f, 1.09204061e-01f, -7.06434250e-02f, -2.03898828e-02f, 5.40610962e-02f, -2.87915282e-02f,
  -1.02828428e-01f, -3.40190227e-03f, 2.95701418e-02f, 1.61479954e-02f, 9.26809385e-02f, -1.41335772e-02f, 3.74299213e-02f, 9.80306715e-02f, -5.03855832e-02f, 8.92393582e-04f,
  -2.53148861e-02f, 1.82375349e-02f, 4.21863161e-02f, 2.42821742e-02f, 3.99096236e-02f, -4.27167453e-02f, -3.43235470e-02f, 8.42816532e-02f, 2.50420850e-02f, -3.66913788e-02f,
  4.03486416e-02f, 5.89362308e-02f, -3.02202459e-02f, -6.13880195e-02f, 7.91115686e-02f, 4.88622487e-02f, 6.85321316e-02f, 7.49442801e-02f, 5.44416904e-03f, -9.29885209e-02f,
  6.62190616e-02f, -9.92758498e-02f, -3.39322798e-02f, -7.78917894e-02f, -7.08642751e-02f, 9.78882611e-03f, -8.52989256e-02f, 6.40920624e-02f, -9.32233855e-02f, -1.00821249e-01f,
  4.32740264e-02f, 8.29482973e-02f, -3.76810431e-02f, -3.24196517e-02f, -6.51592389e-03f, 5.31911440e-02f, 8.50677490e-02f, 1.38836265e-01f, -2.09217239e-02f, -1.68607146e-01f,
  5.70931956e-02f, 1.07362149e-02f, 8.10054597e-03f, 1.88919932e-01f, -9.77915898e-02f, -2.23916337e-01f, -2.28996247e-01f, 9.70728695e-02f, -2.43756194e-02f, -6.06552511e-02f,
  1.10823050e-01f, -1.07129268e-01f, 1.22838177e-01f, 1.27725735e-01f, 1.00219920e-01f, -5.55250756e-02f, -1.47877657e-03f, -2.75091734e-04f, 8.06804188e-03f, 1.45476833e-01f,
  1.11365892e-01f, 5.32345027e-02f, 2.00299829e-01f, 6.74796104e-02f, 8.40348657e-03f, 1.70174450e-01f, 1.92934811e-01f, -4.06303406e-02f, 2.12194890e-01f, -4.27515619e-02f,
  -1.24562219e-01f, 4.48705070e-02f, 9.26644951e-02f, -9.65417773e-02f, 7.93805048e-02f, -3.09686121e-02f, -1.01340905e-01f, -4.11623046e-02f, 4.04009931e-02f, 2.14294866e-02f,
  4.05776128e-02f, -3.62696708e-04f, 6.57647923e-02f, -3.68582159e-02f, -5.00605032e-02f, 4.64835158e-03f, 8.71881172e-02f, -8.54780618e-03f, -1.20802462e-01f, 7.31006116e-02f,
  1.08099945e-01f, 3.89766805e-02f, -4.96382676e-02f, 1.41015634e-01f, 9.98401791e-02f, 1.34130912e-02f, -3.11015062e-02f, -4.74725999e-02f, 2.78250314e-02f, 7.68125281e-02f,
  3.33184488e-02f, -7.58044645e-02f, -7.16403127e-02f, -1.37853205e-01f, -3.63054872e-02f, -2.28986051e-02f, 5.06276789e-04f, -4.24440652e-02f, -1.11679219e-01f, -1.10234357e-02f,
  4.21743095e-02f, 2.94923969e-02f, 8.45549256e-03f, -2.38840450e-02f, 3.81334522e-03f, -7.52852857e-02f, 2.58567221e-02f, 2.30051447e-02f, 9.95153114e-02f, -7.36769056e-04f,
  -3.95720787e-02f, 3.19246436e-03f, 2.26631742e-02f, 7.90982787e-03f, -2.32377686e-02f, -4.70123217e-02f, -3.49097587e-02f, -5.34035712e-02f, -3.44955251e-02f, -4.95166867e-04f,
  1.99103467e-02f, 1.52957946e-01f, -1.84524115e-02f, -9.39768851e-02f, 1.72724463e-02f, -1.25168368e-01f, -7.15054572e-02f, 2.69803349e-02f, 1.36819100e-02f, -2.87542176e-02f,
  7.52158239e-02f, -1.39811888e-01f, -6.47527203e-02f, 2.35084649e-02f, -4.08153310e-02f, 4.19347361e-02f, 1.97648387e-02f, -1.96054578e-02f, -2.88724899e-02f, 1.19301990e-01f,
  8.49163532e-02f, -2.44601667e-02f, -3.73099628e-03f, 1.95380524e-02f, 6.12565205e-02f, -1.98118612e-02f, 4.03014421e-02f, 2.21460667e-02f, 3.89336944e-02f, -1.70016922e-02f,
  -3.83668989e-02f, 2.55775988e-01f, -4.29202989e-02f, -2.68777320e-03f, -1.36544123e-01f, -3.35702181e-01f, -9.54338536e-02f, 7.42897689e-02f, 8.39181170e-02f, 1.10410690e-01f,
  1.44599332e-02f, 1.92061722e-01f, 3.39644775e-02f, 2.24584788e-02f, -3.18413377e-01f, -1.99659795e-01f, -3.21676016e-01f, -1.14867859e-01f, -2.83910092e-02f, -1.19183600e-01f,
  -1.46467596e-01f, -1.59223124e-01f, -2.37205371e-01f, 1.06484806e-02f, -2.62832325e-02f, 8.76684189e-02f, -2.43043765e-01f, 5.55406138e-02f, -6.27301559e-02f, 1.75903570e-02f,
  -4.30959798e-02f, 1.41920030e-01f, 6.19975552e-02f, 2.31514848e-03f, -1.24082014e-01f, -8.41780230e-02f, -9.11735669e-02f, 3.33992653e-02f, -6.01488687e-02f, -8.84629227e-03f,
  8.89601186e-03f, -7.54982792e-03f, 8.19807723e-02f, 7.07082748e-02f, 4.64560091e-02f, 8.44880193e-02f, 1.22815911e-02f, -5.66380955e-02f, -1.25984251e-02f, 7.86647126e-02f,
  7.66340345e-02f, 4.70570959e-02f, -8.25902000e-02f, -6.58525433e-03f, 3.39506902e-02f, 6.04155250e-02f, -5.94019145e-02f, -3.06545682e-02f, -5.62726073e-02f, 4.24193963e-02f,
  7.15515390e-02f, -1.52455941e-01f, -6.19791076e-02f, 8.58164206e-02f, -3.66016589e-02f, 5.65393008e-02f, 1.59205776e-02f, 2.65959688e-02f, 1.21323473e-03f, 4.12204228e-02f,
  -5.32644987e-02f, 9.71455574e-02f, 1.28791677e-02f, 4.93938988e-03f, -6.55993968e-02f, 1.66909620e-02f, -7.67763108e-02f, 1.91821028e-02f, -2.05798764e-02f, 7.74596306e-03f,
  1.28000723e-02f, -7.08756521e-02f, -2.11627334e-02f, -1.15292169e-01f, -1.61891747e-02f, 5.66929858e-03f, 7.29846284e-02f, 6.71145916e-02f, -1.08976014e-01f, -9.32581723e-02f,
  -3.61253560e-01f, -1.14899069e-01f, -8.19677263e-02f, 8.02177712e-02f, -5.30154724e-03f, -5.50680682e-02f, -1.46509215e-01f, 4.33074683e-02f, -7.90664554e-02f, -8.03384781e-02f,
  -5.65817244e-02f, -4.20277975e-02f, -2.45154072e-02f, -1.43161817e-02f, -4.50141169e-02f, 2.74110045e-02f, -1.17228307e-01f, -2.86779124e-02f, -5.16378582e-02f, 2.98542492e-02f,
  -1.76687725e-02f, -1.27380965e-02f, 9.77206156e-02f, -1.00158647e-01f, -2.48392206e-02f, 8.55407119e-02f, 5.47859911e-03f, -1.13324802e-02f, -4.73991185e-02f, -3.17061320e-02f,
  -2.02697963e-01f, 2.95595467e-01f, -1.60777286e-01f, 1.80200730e-02f, -2.93161869e-01f, 2.95627326e-01f, 3.56294632e-01f, -7.15268701e-02f, 1.65716246e-01f, 3.28397989e-01f,
  1.84527040e-01f, 1.25511423e-01f, 1.54073492e-01f, 2.64832377e-01f, 1.33086652e-01f, 4.00916666e-01f, 2.57062614e-01f, 2.36178458e-01f, 4.34673019e-02f, 4.42413427e-02f,
  -7.87293017e-02f, 1.62634850e-01f, -3.07359286e-02f, -2.15447277e-01f, -4.89331335e-02f, -2.75238186e-01f, -8.38228911e-02f, -7.13455305e-02f, -9.15430710e-02f, -2.23655272e-02f,
  -4.03121002e-02f, -9.69433114e-02f, -1.14586331e-01f, 8.37843418e-02f, -3.11294049e-02f, -6.89591989e-02f, -7.57286325e-02f, 1.80796925e-02f, -1.28612649e-02f, 1.20238271e-02f,
  5.85273467e-02f, -1.15261488e-01f, 5.70133179e-02f, -5.99499680e-02f, -5.05571179e-02f, -1.24696018e-02f, 2.61967033e-02f, 5.43881953e-02f, -6.03823038e-03f, -6.79403963e-03f,
  -4.50381525e-02f, 5.22219166e-02f, 8.70478004e-02f, 2.49484833e-02f, -6.07329942e-02f, 7.35130012e-02f, 5.00577353e-02f, 5.81823885e-02f, 3.72672901e-02f, 6.04511611e-03f,
  -8.67430866e-02f, 5.16749872e-03f, 7.99918344e-05f, 7.04637393e-02f, -2.34322865e-02f, 1.44658163e-02f, 7.39328414e-02f, -5.01873903e-03f, 4.57908474e-02f, 4.89366911e-02f,
  1.85465887e-02f, -3.73440944e-02f, 1.20057315e-01f, 9.16679278e-02f, 7.80849606e-02f, 6.00349829e-02f, -4.06167582e-02f, 3.58055420e-02f, 2.98039503e-02f, 5.85600212e-02f,
  -1.56339258e-02f, 7.22190812e-02f, 1.34215523e-02f, -2.93982290e-02f, 1.67946089e-02f, -1.13616578e-01f, -2.30098721e-02f, 4.09183577e-02f, 5.68996742e-02f, 1.98061969e-02f,
  2.27856174e-01f, 1.89920187e-01f, 6.42560944e-02f, 1.03634417e-01f, -3.03552253e-03f, -1.25944898e-01f, 1.11992180e-01f, -9.23344418e-02f, 5.00750206e-02f, -5.15460372e-02f,
  -3.12014930e-02f, 4.26783189e-02f, 1.08692665e-02f, -4.10962999e-02f, -5.11283465e-02f, 1.16398022e-01f, 1.25829130e-01f, -4.60459329e-02f, 2.38666516e-02f, -8.12196955e-02f,
  -7.49293417e-02f, 3.39838862e-02f, 7.17067271e-02f, -4.40375693e-02f, -3.79209267e-03f, 7.99273625e-02f, -2.18310170e-02f, 1.93848507e-03f, -8.54340103e-03f, 5.52395619e-02f,
  -2.03291789e-01f, 1.19898371e-01f, -2.17893764e-01f, -2.58688301e-01f, 1.50474265e-01f, -1.29600570e-01f, -1.41366810e-01f, 8.31397474e-02f, -1.63047701e-01f, 7.12148324e-02f,
  -1.15218408e-01f, -2.08483636e-01f, 7.03549907e-02f, -2.19690800e-01f, -3.80571604e-01f, -1.60601735e-01f, -4.40274656e-01f, -2.96453357e-01f, -8.72242451e-02f, -5.03872894e-02f,
  -1.41226426e-01f, -5.24024479e-02f, -3.04545552e-01f, 1.01352185e-01f, -1.13605894e-01f, -6.84212372e-02f, 8.08683261e-02f, 9.26520079e-02f, -6.16713353e-02f, 1.29567280e-01f,
  1.79919992e-02f, -2.92397030e-02f, -5.53124882e-02f, -1.25665769e-01f, -8.00482109e-02f, 6.30464181e-02f, -1.02387145e-01f, 7.99238980e-02f, -1.09738067e-01f, -4.08512466e-02f,
  -5.75262532e-02f, -7.92688653e-02f, -4.88840155e-02f, -3.21030710e-03f, -1.34631410e-01f, -1.24388533e-02f, 2.32505910e-02f, -8.38676989e-02f, -1.01296149e-01f, -1.00173369e-01f,
  -4.04049866e-02f, -5.64600341e-02f, -1.03841618e-01f, -8.46474692e-02f, -3.94670703e-02f, -7.73374885e-02f, -2.28220522e-02f, 4.27066386e-02f, -8.10611695e-02f, -1.60147008e-02f,
  8.30546021e-02f, -1.08650252e-01f, -3.96045670e-03f, -4.56155166e-02f, 1.49544887e-02f, 7.29354694e-02f, -2.70394683e-02f, -4.26200517e-02f, 7.76140913e-02f, 6.40850142e-02f,
  6.43575704e-03f, 2.95720398e-02f, 7.88537189e-02f, -3.89604531e-02f, -9.90055203e-02f, 4.67076711e-03f, 2.82171443e-02f, 5.00845872e-02f, 1.44681316e-02f, 1.58051159e-02f,
  4.40317765e-02f, 9.78570655e-02f, 6.75733062e-03f, 2.92225052e-02f, -6.08323552e-02f, -9.64977071e-02f, -1.19038902e-01f, -7.11826384e-02f, -1.02254748e-02f, -5.51467724e-02f,
  7.82989487e-02f, 5.64790443e-02f, -5.93935198e-04f, 9.78338905e-03f, 3.45828645e-02f, -8.95177200e-02f, -7.91325644e-02f, -5.82140125e-02f, -3.00587155e-02f, 1.21845432e-01f,
  -2.60952096e-02f, 5.73446369e-03f, -8.27456489e-02f, 3.10398825e-02f, 1.42436298e-02f, 6.87842146e-02f, 7.33418614e-02f, 1.89753063e-02f, -9.44962632e-03f, 1.65634267e-02f,
  -2.39636600e-02f, 3.04269628e-03f, -4.15463299e-02f, 9.07662883e-02f, 6.62015006e-02f, 4.31261621e-02f, 9.69463512e-02f, -6.70812419e-03f, 2.63953581e-02f, -1.20771393e-01f,
  4.21369821e-02f, -1.65516078e-01f, -2.83205807e-01f, -2.08142534e-01f, 5.69469035e-02f, -2.96332031e-01f, -3.51402104e-01f, -6.71625137e-02f, 1.37310661e-02f, 1.39483958e-01f,
  3.56567875e-02f, 8.06590542e-02f, 9.73624066e-02f, -1.74594194e-01f, -1.85843915e-01f, 1.61666628e-02f, -3.98930192e-01f, -2.52751768e-01f, -1.95939690e-02f, -2.37697616e-01f,
  -4.49589267e-02f, -6.95878342e-02f, -2.67071545e-01f, -5.11939405e-03f, -2.74894476e-01f, 1.94662884e-02f, 6.98271915e-02f, 2.73362044e-02f, -1.60296485e-01f, 2.82945409e-02f,
  -9.30028707e-02f, 6.81903735e-02f, -4.63709086e-02f, 1.15633048e-02f, -1.45633727e-01f, -5.74655607e-02f, -7.17535168e-02f, -2.37153913e-03f, 3.36536132e-02f, -8.74101371e-03f,
  -1.33463426e-03f, 3.41176614e-02f, -6.32702559e-02f, 1.06460690e-01f, -4.79903743e-02f, 3.17638647e-03f, -3.67272459e-02f, 3.29735689e-03f, -1.11992389e-01f, -2.51232497e-02f,
  -5.70283495e-02f, -7.48636946e-02f, -9.91920605e-02f, -1.17390566e-02f, 8.52061622e-03f, -7.90164024e-02f, -6.10533468e-02f, -8.74079168e-02f, -5.12726977e-02f, 6.07605763e-02f,
  -2.59466581e-02f, -3.95069532e-02f, -1.11322038e-01f, -1.54512189e-02f, 2.13113166e-02f, 2.93679386e-02f, -9.25132707e-02f, 2.80195437e-02f, 8.45817626e-02f, 3.85717116e-02f,
  -1.92894656e-02f, -9.29506496e-02f, 4.49685268e-02f, 4.84979851e-03f, 2.56271046e-02f, 9.40838754e-02f, -4.20366041e-02f, 1.42553896e-02f, -5.12439832e-02f, -3.18594500e-02f,
  2.33673248e-02f, -8.59542415e-02f, -8.66431743e-03f, -2.56328825e-02f, -1.42633021e-01f, -2.10146382e-02f, -3.77728157e-02f, -3.37766893e-02f, 7.88149908e-02f, 2.78693885e-02f,
  -7.12208524e-02f, -8.79342016e-03f, 8.45686048e-02f, 9.41483378e-02f, 3.84784117e-02f, 1.57636206e-03f, -7.35132322e-02f, -4.89378646e-02f, -2.34318506e-02f, -1.40789477e-02f,
  -5.76863736e-02f, -2.29397248e-02f, -2.23821793e-02f, -1.77148990e-02f, -4.27293144e-02f, -2.10468564e-02f, 1.08309248e-02f, 1.32514362e-03f, 2.71915644e-02f, 1.28253512e-02f,
  -4.91151698e-02f, -1.53859202e-02f, 8.73999968e-02f, -6.48264133e-04f, -1.18005145e-02f, -4.37289551e-02f, 1.13417534e-02f, 4.41573970e-02f, -4.00116062e-03f, 3.66230160e-02f,
  2.70113319e-01f, -3.25259328e-01f, -1.31737322e-01f, 1.33714288e-01f, 9.33006108e-02f, 2.78774388e-02f, -1.91248134e-01f, 2.42440626e-02f, -1.38089582e-01f, -8.55610967e-02f,
  9.13384333e-02f, -1.82467550e-01f, -2.49688759e-01f, 5.57526872e-02f, 9.21157300e-02f, -2.61531532e-01f, 4.77602589e-04f, 5.90108074e-02f, -1.30359054e-01f, 6.36397004e-02f,
  1.14513598e-01f, 1.87329099e-01f, 9.40028131e-02f, 2.69401789e-01f, 9.21758115e-02f, 2.20223308e-01f, 2.53327370e-01f, 1.54045165e-01f, 2.27477401e-01f, 1.17749862e-01f,
  -5.07175066e-02f, -1.43245846e-01f, -9.11088288e-02f, 9.85126868e-02f, 4.71043736e-02f, 5.97409941e-02f, -1.66624803e-02f, 5.23800636e-03f, 1.29570346e-02f, -6.19039219e-03f,
  -1.07589304e-01f, -3.02305613e-02f, 1.18098874e-02f, 1.57836303e-02f, 5.26365899e-02f, -2.47333404e-02f, -6.98640496e-02f, -4.60956171e-02f, -4.21929173e-02f, -1.75070725e-02f,
  -1.00660801e-01f, -6.97634146e-02f, -1.01429157e-01f, -1.30863683e-02f, 1.65962391e-02f, -1.70614030e-02f, -8.47634487e-03f, -1.12812690e-01f, 2.30328981e-02f, -9.43727267e-04f,
  6.91612810e-02f, -1.32166333e-02f, 3.49488966e-02f, -1.58804618e-02f, -5.00847399e-02f, 5.48245683e-02f, 6.55024275e-02f, 7.64530450e-02f, 1.10883433e-02f, 3.02837528e-02f,
  3.72375473e-02f, -1.10072512e-02f, 2.20358633e-02f, 5.70060052e-02f, -2.70331148e-02f, -8.18244815e-02f, 6.51368648e-02f, 1.39231822e-02f, 6.66515604e-02f, 1.67023279e-02f,
  -4.44582067e-02f, 1.18191689e-01f, 3.64414416e-02f, -4.56693582e-02f, -7.25303916e-03f, -2.28541587e-02f, 2.74878368e-02f, -3.36597972e-02f, -4.90155853e-02f, -2.04080716e-02f,
  -8.43020007e-02f, -1.28420442e-01f, -1.21984612e-02f, 9.26643983e-03f, 4.76135723e-02f, 2.52812691e-02f, -2.11959947e-02f, 1.15835778e-02f, -3.12107541e-02f, -8.14214125e-02f,
  4.89265434e-02f, 1.64188091e-02f, 2.51058526e-02f, 5.85822277e-02f, 5.98771647e-02f, 1.76826715e-02f, 2.88782418e-02f, 2.62516867e-02f, 8.77972990e-02f, 3.12515311e-02f,
  1.89347565e-02f, -7.39866644e-02f, -3.22318263e-02f, -4.72607538e-02f, 7.19051063e-02f, 4.36071381e-02f, 3.34405378e-02f, -5.11061810e-02f, 8.63286853e-02f, -6.07137866e-02f,
  -5.98777354e-01f, 1.20375618e-01f, 1.27517894e-01f, -2.17284352e-01f, 6.81366697e-02f, 1.52743816e-01f, 1.00573786e-01f, 3.52726597e-03f, 8.92190710e-02f, -5.79017289e-02f,
  -5.47083430e-02f, -5.82092740e-02f, 7.32627138e-02f, -6.80781752e-02f, -1.08505733e-01f, 5.98539598e-02f, -5.71801290e-02f, -9.30194631e-02f, 1.17006406e-01f, -1.11463860e-01f,
  -9.78795663e-02f, -6.40408695e-02f, 5.12428582e-02f, 5.28771691e-02f, -1.12570308e-01f, -1.48037732e-01f, -6.08528852e-02f, -7.04050297e-03f, 4.15526442e-02f, 5.64956367e-02f,
  -1.23845965e-01f, -1.16901696e-01f, 4.17728275e-02f, 4.44323458e-02f, -4.28781286e-02f, -5.27442386e-03f, 2.39292495e-02f, -3.22888978e-02f, 4.36078236e-02f, -2.18921658e-02f,
  5.98668531e-02f, -5.28509542e-02f, -4.92816307e-02f, -1.84521787e-02f, -3.99228670e-02f, 3.01244128e-02f, 8.11171010e-02f, 1.34305544e-02f, -2.38317251e-02f, 7.95671567e-02f,
  -1.33184204e-03f, 3.58212367e-02f, -8.87861699e-02f, -3.03985929e-04f, -3.60384770e-02f, 2.30718101e-03f, -1.51985837e-03f, -8.38542208e-02f, 2.54052784e-02f, -1.00904599e-01f,
  9.04635265e-02f, 3.44888540e-03f, 1.30359709e-01f, 3.78176617e-03f, 1.16674103e-01f, -6.72486499e-02f, 7.26918057e-02f, -3.23278904e-02f, 6.00397354e-04f, -5.85315451e-02f,
  -8.82377476e-03f, -2.73604244e-02f, -1.33003801e-01f, -1.51689172e-01f, 3.13717984e-02f, 5.07486872e-02f, 5.00734635e-02f, -1.90034602e-02f, 6.29181266e-02f, -8.59334171e-02f,
  2.72020251e-02f, -8.74056146e-02f, 1.11166136e-02f, 5.14852740e-02f, 5.61570786e-02f, -5.85489497e-02f, 8.04175902e-03f, -2.33941711e-02f, -7.02793822e-02f, -1.16944969e-01f,
  -5.22466898e-02f, -2.17771113e-01f, 6.46994114e-02f, -3.04377694e-02f, 1.52422071e-01f, -8.52080286e-02f, 3.95385586e-02f, 8.23372975e-03f, 7.39755481e-02f, -4.46839333e-02f,
  -2.26266794e-02f, 3.90248597e-02f, -1.24360450e-01f, -2.52402723e-02f, 1.00991100e-01f, 2.94657517e-02f, 6.31173402e-02f, 1.64389890e-02f, -2.19037128e-03f, 5.16180247e-02f,
  -8.37721229e-02f, 3.34826000e-02f, -8.91677961e-02f, 3.52544785e-02f, -2.30862163e-02f, -1.42201528e-01f, 4.99367937e-02f, 2.34824046e-02f, -2.50364468e-03f, -6.32008770e-03f,
  -1.68850362e-01f, 3.62023860e-02f, 2.36872993e-02f, 1.82954147e-01f, 2.77675539e-01f, 2.98539370e-01f, 2.11759254e-01f, 2.23046243e-01f, 3.44532192e-01f, 1.73981369e-01f,
  6.57825312e-03f, -1.36249149e-02f, -1.07333988e-01f, 8.59595016e-02f, 4.20802459e-02f, -2.36978754e-02f, 1.57657161e-01f, 8.33681747e-02f, 6.20569028e-02f, -1.21401235e-01f,
  2.67410222e-02f, 7.41057321e-02f, -1.15314968e-01f, -1.17825769e-01f, -9.48149934e-02f, -1.14298463e-01f, -6.85229301e-02f, -1.81356117e-01f, -2.08145455e-02f, 2.70948857e-02f,
  5.01687527e-02f, -2.03657430e-02f, -1.14245914e-01f, -9.10727754e-02f, -1.28277779e-01f, -1.08041659e-01f, -7.65068531e-02f, -7.11802691e-02f, -9.68802273e-02f, 2.70987954e-02f,
  4.44075279e-02f, 2.99988855e-02f, 7.09021837e-02f, -2.64344718e-02f, 1.00363577e-02f, 8.85527879e-02f, 4.73257005e-02f, -5.52594066e-02f, -4.18590270e-02f, -3.33277062e-02f,
  -6.19352236e-02f, 8.69108140e-02f, 4.29085307e-02f, -6.53016046e-02f, 8.12676549e-02f, -7.68713504e-02f, 7.94605631e-03f, -4.12810184e-02f, 8.29244331e-02f, 1.04107484e-01f,
  -2.19934806e-02f, 1.71550401e-02f, 3.55537795e-02f, 1.17432429e-02f, -3.75358649e-02f, -1.07910804e-01f, 8.53012875e-02f, -5.90349883e-02f, -5.24564944e-02f, -4.87740850e-03f,
  6.85269609e-02f, 5.80378100e-02f, -4.89908345e-02f, -4.95207310e-02f, 3.96898277e-02f, 8.37886781e-02f, 6.30171746e-02f, 9.62983370e-02f, 4.19492498e-02f, -6.96343428e-04f,
  -9.47340019e-03f, 2.88063604e-02f, 9.20746569e-03f, 4.48582023e-02f, -1.68476552e-02f, -1.39268991e-02f, -6.32076040e-02f, 1.35380682e-02f, 6.89614639e-02f, 7.44678006e-02f,
  2.13581368e-01f, 5.46073392e-02f, 1.46277212e-02f, -6.78362772e-02f, -7.85888284e-02f, -7.99274445e-03f, -5.41926771e-02f, 3.19148377e-02f, 5.34055056e-03f, 3.00662685e-02f,
  8.11938569e-02f, -1.87102351e-02f, -4.60808091e-02f, 2.53228247e-02f, 2.83731468e-04f, 5.21806404e-02f, -4.44555283e-02f, 5.53465299e-02f, 6.30543232e-02f, -1.23211697e-01f,
  -2.20245644e-02f, 5.75613081e-02f, 1.46627072e-02f, -3.93774584e-02f, 5.97735383e-02f, -1.14091642e-01f, -6.24142773e-02f, -4.64136377e-02f, 4.35736552e-02f, 4.63909889e-03f
};

// L0_fan_Bp_bar (Shape: 1 x 26)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 26;
const float L0_fan_Bp_bar_data[] = {
  -9.79934353e-04f, 7.76279196e-02f, 1.49030507e-01f, 3.54713798e-02f, 1.40530601e-01f, 4.60435674e-02f, 2.61039957e-02f, 1.05059430e-01f, -2.94034462e-02f, 1.86737493e-01f,
  1.16037898e-01f, 3.35048623e-02f, 3.69863659e-02f, 7.02037662e-02f, 8.03892910e-02f, 1.27246361e-02f, 7.81337693e-02f, 2.65772659e-02f, 6.02737702e-02f, 3.24783362e-02f,
  1.48935512e-01f, -1.16272653e-02f, 1.06861524e-01f, 5.97210899e-02f, 9.59112272e-02f, 9.96855125e-02f
};

// L1_fan_Wp (Shape: 19 x 64)
const int L1_fan_Wp_rows = 19;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  -1.38338670e-01f, 1.33036196e-01f, -1.57809675e-01f, -1.94232821e-01f, 1.45981144e-02f, 5.86090573e-05f, -4.28093448e-02f, 6.96880370e-02f, 8.30070227e-02f, -1.43320868e-02f,
  1.60064809e-02f, -2.30251282e-01f, -8.56585801e-02f, -1.76063031e-02f, 4.52267341e-02f, 2.55157314e-02f, 9.67673585e-02f, -5.44466265e-02f, -1.26105160e-01f, -2.71525621e-01f,
  1.06128432e-01f, 5.78801744e-02f, 5.12628518e-02f, -1.16325304e-01f, -2.03364924e-01f, 3.03742662e-02f, -1.34977177e-01f, -5.02537116e-02f, -9.41405743e-02f, -4.97957952e-02f,
  -6.94383308e-02f, 8.77916738e-02f, 5.63534498e-02f, 1.17807791e-01f, 4.58962694e-02f, 3.82618234e-02f, -1.38251707e-01f, -1.13589391e-01f, 2.24471971e-01f, -1.14262708e-01f,
  2.97436684e-01f, -1.40711114e-01f, -9.95324627e-02f, 1.06628975e-02f, -2.23115146e-01f, 2.54172031e-02f, -1.84656546e-01f, 3.99912223e-02f, 4.69820872e-02f, 7.44273216e-02f,
  1.90922841e-01f, -9.27572772e-02f, -1.05124995e-01f, 1.53601676e-01f, -5.27233770e-03f, 6.89647347e-02f, -1.72476023e-01f, 1.22984000e-01f, 1.42164156e-01f, -1.69042926e-02f,
  7.52435252e-03f, -9.24137756e-02f, 1.91877559e-01f, -3.40914950e-02f, 4.48631607e-02f, -2.49725785e-02f, -2.56333314e-02f, 5.39830178e-02f, -8.17382429e-03f, 1.17145114e-01f,
  9.81984194e-03f, 1.09025531e-01f, 4.16638292e-02f, 8.53175968e-02f, -8.20075646e-02f, 1.30263701e-01f, -1.46064591e-02f, 3.11460197e-02f, -7.34641925e-02f, -1.03827370e-02f,
  1.18549556e-01f, 1.28533050e-01f, -6.01199865e-02f, 7.35252053e-02f, 1.27775744e-01f, 9.13307294e-02f, 1.61151409e-01f, -2.24362165e-01f, -4.76752110e-02f, 1.04837036e-02f,
  1.76019847e-01f, 2.02253371e-01f, -9.25685465e-02f, 1.11572295e-02f, -1.76878318e-01f, -4.99257222e-02f, 3.43342453e-01f, 3.03030193e-01f, 7.24798217e-02f, 1.31742299e-01f,
  4.20904458e-02f, 9.32752118e-02f, 1.61800478e-02f, -4.86673974e-02f, 1.37546927e-01f, -1.16005354e-01f, 6.91221133e-02f, 1.13250814e-01f, -1.87178329e-01f, -2.62748990e-02f,
  -2.22480029e-01f, 7.01459348e-02f, -1.66626181e-02f, -9.10730287e-02f, -1.11372821e-01f, 2.60309368e-01f, -1.03531651e-01f, 8.45913514e-02f, -1.64457727e-02f, -1.54656202e-01f,
  -4.99250814e-02f, 6.73338324e-02f, -6.33576214e-02f, -2.17297897e-01f, -2.75881644e-02f, -1.29984349e-01f, 1.61128938e-02f, 9.96199399e-02f, 9.35387611e-02f, 2.18105558e-02f,
  8.11057016e-02f, -3.46982013e-03f, -3.57175879e-02f, 1.03375465e-01f, -1.36134192e-01f, 1.82687268e-02f, 2.09594574e-02f, -5.35050407e-02f, 1.30015556e-02f, -1.05063476e-01f,
  -7.62756467e-02f, -2.50075385e-02f, -1.04104429e-01f, -8.20520595e-02f, 6.75506443e-02f, 4.26848978e-02f, 5.60918776e-03f, 1.60576433e-01f, 2.48952042e-02f, -5.10263070e-03f,
  9.90613084e-03f, 8.87796376e-03f, -1.24139771e-01f, -1.45733774e-01f, 3.53066251e-02f, 6.03270456e-02f, 1.22334301e-01f, -2.28907838e-02f, 1.76803380e-01f, -4.42940518e-02f,
  9.12840292e-02f, 5.39984070e-02f, 6.65547326e-02f, 8.09538737e-02f, -2.11188681e-02f, -2.70854384e-01f, -1.81340680e-01f, 8.84187296e-02f, 2.28088861e-03f, -6.51927590e-02f,
  1.57448940e-03f, -3.14414091e-02f, -6.69256374e-02f, -2.63944548e-02f, 9.09524038e-02f, -3.08572233e-01f, -1.37091741e-01f, 9.18914080e-02f, 1.19100586e-01f, -1.46739900e-01f,
  -1.06900550e-01f, -1.08211316e-01f, 5.65745831e-02f, -1.89060822e-01f, -6.72663525e-02f, -4.55429871e-03f, 2.96310097e-01f, -1.28033414e-01f, -2.08302531e-02f, -2.04333588e-01f,
  1.21677779e-01f, 1.59664825e-01f, -9.07821134e-02f, 2.28666402e-02f, -1.50193900e-01f, -5.24988212e-03f, -9.93300900e-02f, -6.09748357e-04f, -5.31883538e-02f, 2.81208567e-02f,
  2.16403622e-02f, -7.19500110e-02f, -3.94438729e-02f, 7.32943416e-02f, -6.45610988e-02f, 1.23625426e-02f, -6.32074103e-02f, 2.62522139e-02f, 1.53541446e-01f, 8.37539583e-02f,
  -2.35514082e-02f, -9.10732970e-02f, 3.45862918e-02f, 8.94369632e-02f, 1.30128667e-01f, -1.46196615e-02f, -5.08069806e-02f, 1.77431241e-01f, -4.97226566e-02f, 1.81705102e-01f,
  -4.23701778e-02f, 1.07869551e-01f, 9.58293378e-02f, -4.37523611e-02f, 1.91703826e-01f, 1.02061614e-01f, 4.14859131e-02f, 1.49346858e-01f, -4.96248268e-02f, 1.62898481e-01f,
  1.11488104e-01f, 1.04796886e-03f, 2.44005620e-02f, -1.12485789e-01f, 1.41322896e-01f, -4.61783297e-02f, -1.94659129e-01f, 5.38647994e-02f, -7.52823874e-02f, -2.60737926e-01f,
  -1.66301325e-01f, 2.23259139e-03f, 1.15846314e-01f, 4.03366750e-03f, 9.44274142e-02f, 1.32973641e-01f, -3.73287648e-02f, -1.44704217e-02f, -5.05405068e-02f, 2.58907676e-01f,
  -1.20231800e-01f, 7.05104023e-02f, 1.66642204e-01f, -2.39306703e-01f, 1.12316117e-01f, -5.84042780e-02f, 8.58896598e-02f, 9.46629718e-02f, -9.09524858e-02f, 8.73580948e-02f,
  -1.57149844e-02f, 4.11346108e-02f, -8.99223834e-02f, -1.31667316e-01f, -1.07621156e-01f, 1.47278141e-02f, -5.93720563e-02f, 8.12075958e-02f, -3.65837216e-02f, 4.27801982e-02f,
  5.89502715e-02f, -6.73767924e-02f, 6.89176694e-02f, 3.35893361e-03f, -5.86149916e-02f, 1.21139549e-01f, -7.30787069e-02f, 2.08789669e-02f, 7.98727665e-03f, 8.19742978e-02f,
  9.36019421e-02f, 1.69889256e-01f, -8.68526101e-02f, 1.82332799e-01f, 9.36713517e-02f, 1.92483038e-01f, 1.30290076e-01f, -5.60938269e-02f, 2.67663561e-02f, -8.79618749e-02f,
  -1.93219572e-01f, 1.40939459e-01f, -1.34990796e-01f, 1.85924526e-02f, -1.07071646e-01f, 8.73899683e-02f, -2.11469665e-01f, -1.41389698e-01f, 2.02969909e-01f, -9.02680680e-02f,
  1.06748648e-01f, 1.60882860e-01f, 1.98392719e-01f, -1.95079401e-01f, -2.88874358e-01f, -3.89884487e-02f, -9.70627517e-02f, -2.33928472e-01f, 1.25287831e-01f, -4.53955531e-02f,
  1.64395068e-02f, 6.52955994e-02f, 1.29460156e-01f, 1.33002043e-01f, -2.06506073e-01f, 9.14169922e-02f, 1.14558533e-01f, 3.27642709e-02f, -4.47365269e-02f, -2.33529955e-01f,
  6.42974228e-02f, 1.23440243e-01f, 3.94758582e-02f, 3.06317694e-02f, 1.11847162e-01f, -2.82010506e-03f, 1.03643797e-01f, -1.34396181e-01f, 3.01003810e-02f, -9.39489305e-02f,
  3.11798416e-02f, -5.78087233e-02f, 3.67451683e-02f, -3.61414477e-02f, 1.14346743e-01f, 7.46271312e-02f, -2.35459004e-02f, -4.08284850e-02f, 1.29228793e-02f, -1.41774938e-01f,
  -2.70962622e-02f, -8.60368460e-02f, 6.58953271e-04f, -4.63663833e-03f, -1.43684819e-01f, 1.49722360e-02f, -2.10287973e-01f, -1.44311950e-01f, 8.66615996e-02f, -1.51237085e-01f,
  5.78297041e-02f, 1.54969320e-01f, -2.81043202e-02f, -1.56670008e-02f, 8.34645256e-02f, 1.23810552e-01f, -7.83980191e-02f, -1.65276632e-01f, -2.71004084e-02f, -1.36415735e-01f,
  2.29220748e-01f, 3.11774798e-02f, -5.23556024e-02f, -1.12089366e-01f, -7.02749416e-02f, 1.46829328e-02f, -9.97281373e-02f, 1.16591025e-02f, -1.35899946e-01f, 1.08409137e-01f,
  2.70754009e-01f, -1.90118015e-01f, 3.03404927e-02f, 7.29705393e-02f, -6.77965209e-02f, 1.42792702e-01f, -1.88075095e-01f, 3.14381309e-02f, -4.58071232e-02f, 2.58322984e-01f,
  1.10839829e-01f, -8.65781754e-02f, 1.13423720e-01f, 4.36553694e-02f, -8.34823549e-02f, 1.71514368e-03f, -9.54276975e-03f, -4.96645505e-03f, 9.19630304e-02f, 4.24255943e-03f,
  3.01337820e-02f, -1.82078138e-03f, 7.86016136e-03f, -1.88411232e-02f, -1.20407417e-01f, 1.03234099e-02f, -2.40449794e-02f, 9.12081227e-02f, 7.67867789e-02f, 2.32528523e-02f,
  1.53792769e-01f, 1.15932561e-01f, -4.92229462e-02f, -8.94032642e-02f, 6.72103092e-02f, -3.73498797e-02f, 8.08202103e-02f, -6.37178272e-02f, 2.16705594e-02f, -8.55024010e-02f,
  4.72086370e-02f, 3.80297564e-02f, 9.34681110e-03f, 1.34210214e-01f, -1.15766125e-02f, 2.00293586e-02f, 1.54568270e-01f, 1.35207593e-01f, 4.63162921e-02f, -1.31934971e-01f,
  -8.10877308e-02f, -1.88331977e-01f, -1.39862113e-02f, 6.41431957e-02f, -4.26732562e-02f, -7.70649165e-02f, -1.12311728e-01f, 8.08457807e-02f, -6.51545599e-02f, -1.65113121e-01f,
  9.15982574e-02f, -8.03154241e-03f, -8.65145251e-02f, 1.35742471e-01f, 7.79080912e-02f, 6.89374730e-02f, -1.49561673e-01f, -1.52198575e-03f, 9.36846212e-02f, -1.20120205e-01f,
  2.68251207e-02f, 4.11823913e-02f, 1.55472487e-01f, -1.55499145e-01f, 6.55854493e-03f, -1.47399545e-01f, 1.67749189e-02f, 1.06928833e-02f, 7.06669390e-02f, 3.56920287e-02f,
  -7.58367777e-02f, 5.13985194e-02f, -8.81740898e-02f, -1.48012862e-01f, -3.29262055e-02f, -1.10259898e-01f, -5.51226214e-02f, 5.16210161e-02f, 1.57263964e-01f, 2.83943769e-02f,
  1.38570750e-02f, -1.47055611e-01f, 1.10881761e-01f, -1.67862788e-01f, -1.97960392e-01f, -8.20041448e-02f, -9.25302133e-03f, 6.08061552e-02f, -6.45502135e-02f, -1.21555381e-01f,
  -1.16090044e-01f, 5.53371571e-02f, -1.13395020e-01f, -8.46521705e-02f, -9.04282928e-02f, -1.05366511e-02f, 5.36780991e-02f, -3.75830755e-02f, 6.46462515e-02f, -4.78672646e-02f,
  -5.79058565e-02f, -9.81968194e-02f, 9.00486298e-03f, -3.28097753e-02f, 4.01346236e-02f, -1.62034169e-01f, 2.02630639e-01f, -3.19972634e-02f, -3.26490372e-01f, 1.51277557e-01f,
  3.28237452e-02f, -1.54440567e-01f, -8.38716235e-03f, -3.12225595e-02f, -1.22189187e-01f, -1.53042734e-01f, -1.24688908e-01f, 2.49625575e-02f, 8.87611806e-02f, 7.34977005e-03f,
  8.02520216e-02f, -1.19394682e-01f, 1.30680308e-01f, 1.06965974e-01f, -4.67384867e-02f, -2.49873787e-01f, 3.50080103e-01f, -5.30473068e-02f, -1.07296251e-01f, -6.41221106e-02f,
  -4.39451598e-02f, 8.13422576e-02f, -3.69003937e-02f, -1.95185896e-02f, -8.98500253e-03f, 2.08031107e-02f, -5.23013957e-02f, 1.08406045e-01f, -3.13064456e-02f, -1.63114339e-01f,
  1.92484830e-03f, -8.37267935e-02f, 1.37291312e-01f, 6.87180310e-02f, -7.57849813e-02f, 1.38812643e-02f, 1.21849952e-02f, 3.30838338e-02f, -1.04553014e-01f, -1.07151233e-01f,
  -4.56650332e-02f, 1.58540756e-01f, -4.38624434e-02f, 2.39621010e-02f, -1.26539627e-02f, 1.66663546e-02f, -2.53957093e-01f, 7.40488842e-02f, -7.51897693e-02f, -3.76849137e-02f,
  1.11766897e-01f, -7.11547658e-02f, 1.68477580e-01f, -1.05613202e-01f, 3.92125808e-02f, -6.91727400e-02f, 1.92524597e-01f, 3.55835864e-03f, -5.53378798e-02f, -1.33379567e-02f,
  2.08172455e-01f, -5.34898154e-02f, -2.01779217e-01f, 6.16995469e-02f, 8.61723498e-02f, -9.12061855e-02f, -1.72475338e-01f, 1.04869269e-01f, -8.87557641e-02f, -2.19655350e-01f,
  -1.29340485e-01f, 9.64389965e-02f, 2.25002319e-01f, -3.18609513e-02f, 7.92959034e-02f, -1.81557611e-01f, 2.68221218e-02f, 9.63639934e-03f, -1.14028983e-01f, 1.18993945e-01f,
  1.16128623e-01f, 9.11026299e-02f, 1.34494931e-01f, -9.51958373e-02f, 8.76286700e-02f, 1.76140100e-01f, 9.02382359e-02f, 6.12368695e-02f, -7.66667351e-02f, 1.57467574e-01f,
  -5.98508418e-02f, 7.91971385e-02f, 3.22733894e-02f, -1.53929964e-02f, -1.11130312e-01f, 6.19631223e-02f, 1.13925792e-01f, 6.82604834e-02f, -4.04205732e-02f, 8.92216489e-02f,
  1.39680997e-01f, -8.76017213e-02f, 2.34691184e-02f, 1.63225502e-01f, 1.05197348e-01f, -4.60379124e-02f, -7.76681751e-02f, -1.02378463e-03f, -3.56238186e-02f, 5.27127832e-02f,
  1.19195702e-02f, 9.43885371e-02f, 5.99748790e-02f, -4.73442599e-02f, -1.37037188e-01f, -6.54441938e-02f, -1.43694267e-01f, -1.63598672e-01f, -5.60926981e-02f, 6.08393997e-02f,
  -2.15327237e-02f, -1.44848647e-02f, -1.01830050e-01f, 1.40887126e-01f, 2.42376365e-02f, -2.21207030e-02f, -3.27485837e-02f, -1.66531112e-02f, -1.13539189e-01f, -5.83168305e-02f,
  -1.59243215e-02f, -5.02782948e-02f, -1.01375699e-01f, 2.07316250e-01f, 1.82150170e-01f, -2.31261149e-01f, -2.76429534e-01f, 1.45312503e-01f, 7.73082823e-02f, 1.07892528e-01f,
  -4.92488034e-02f, 1.40083004e-02f, 3.71244969e-03f, -1.08688265e-01f, -4.15831804e-02f, -9.04857144e-02f, 1.41670808e-01f, 1.40371710e-01f, -1.50371611e-01f, -7.09600598e-02f,
  6.91362098e-02f, -8.57482385e-03f, 9.55629349e-02f, -2.19432768e-05f, -1.53092831e-01f, -6.69538826e-02f, -1.03316307e-01f, 5.33347093e-02f, -2.34684810e-01f, -2.50818711e-02f,
  1.29630432e-01f, 2.38687638e-02f, -3.62657569e-02f, -9.13323238e-02f, 5.39416187e-02f, -5.43509722e-02f, -2.65662640e-01f, -7.95002282e-03f, -1.31410072e-02f, 2.10940372e-02f,
  -2.57896751e-01f, 5.11865132e-02f, -2.22420737e-01f, 4.22050953e-02f, 5.38098700e-02f, -7.89319947e-02f, -1.96481630e-01f, -2.21621051e-01f, 7.36468136e-02f, -2.02343732e-01f,
  1.31169051e-01f, -3.62835489e-02f, -3.47097486e-01f, -2.56608427e-01f, -5.50106689e-02f, -5.60543872e-02f, 4.28759605e-02f, -1.39353752e-01f, -2.55449843e-02f, 2.89664068e-03f,
  -2.87422352e-02f, 1.61805272e-01f, -8.56627151e-02f, -1.60398766e-01f, 1.50382116e-01f, 1.03586622e-01f, -7.38376006e-03f, -4.08041254e-02f, -2.90043298e-02f, -9.10734832e-02f,
  -9.21475887e-02f, -2.39286184e-01f, 2.23729700e-01f, -1.33119464e-01f, 1.80597324e-02f, 3.14003862e-02f, 9.92309526e-02f, -2.44626969e-01f, -4.80112806e-02f, 1.47549242e-01f,
  -1.25931233e-01f, 2.47275487e-01f, -5.15078679e-02f, 6.93862140e-02f, -1.22859925e-01f, -1.24053568e-01f, -2.17764661e-01f, 1.15498970e-03f, -1.13856327e-02f, -5.39995953e-02f,
  6.56391354e-03f, -9.32807568e-03f, 1.13279298e-01f, 1.36166692e-01f, 1.32509079e-02f, 8.48684162e-02f, 9.26275551e-02f, -1.84227694e-02f, -1.06280163e-01f, -9.96330455e-02f,
  2.07972854e-01f, -1.46277249e-02f, -1.52361572e-01f, 7.62898549e-02f, 2.29738906e-01f, -3.00561078e-02f, 8.00292417e-02f, -1.40146106e-01f, -6.58844411e-02f, 2.99087018e-02f,
  2.31415167e-01f, 2.49701738e-01f, -2.15860605e-01f, 1.19483575e-01f, -1.93372220e-01f, -1.95763066e-01f, 3.27384233e-01f, 1.86819687e-01f, 4.81519215e-02f, -1.37613043e-01f,
  -8.66657030e-03f, 6.96719438e-02f, 2.03836501e-01f, -1.20396987e-01f, -1.25416324e-01f, -1.87059149e-01f, 7.77521580e-02f, 2.43224919e-01f, -1.07689843e-01f, -2.10513756e-01f,
  -1.13031268e-01f, 4.18726541e-02f, 5.55066764e-02f, -4.80134077e-02f, -2.34319255e-01f, 2.48999476e-01f, -1.35328129e-01f, 7.19089583e-02f, -1.88857336e-02f, -7.64981732e-02f,
  -6.69999747e-03f, 1.40460372e-01f, 1.01393342e-01f, -2.48698458e-01f, 7.03418329e-02f, -2.26982251e-01f, -1.20267384e-01f, -7.02970624e-02f, -1.36631146e-01f, -1.34777516e-01f,
  -4.59143855e-02f, -5.98887764e-02f, -1.14040963e-01f, 7.38836378e-02f, -5.31388335e-02f, -6.11432679e-02f, -1.96486432e-02f, 8.53270590e-02f, 3.85728106e-02f, 3.95428129e-02f,
  3.31445858e-02f, -1.32093072e-01f, 5.20009696e-02f, -9.53848660e-02f, 1.15236312e-01f, 1.04555994e-01f, -9.40060019e-02f, 9.77642536e-02f, 8.97383764e-02f, 3.63356322e-02f,
  -3.99458734e-03f, 8.63982588e-02f, 2.57032458e-02f, 1.92039423e-02f, 2.07941160e-01f, 1.22918889e-01f, -1.78393543e-01f, -5.42620532e-02f, -2.16384605e-01f, -1.75715134e-01f,
  1.51577741e-01f, 1.31093413e-01f, -8.23245347e-02f, -6.08007014e-02f, -1.04400307e-01f, 1.91929758e-01f, 2.28863135e-01f, 7.16829151e-02f, -3.46102566e-02f, -5.40192463e-02f,
  -9.79951620e-02f, 2.74156835e-02f, 5.38432077e-02f, -2.14154527e-01f, -1.27415493e-01f, 9.50996876e-02f, 2.19679102e-02f, -1.58226609e-01f, -1.05239682e-01f, 1.98534667e-01f,
  -1.43691510e-01f, 1.05599388e-01f, -4.07111160e-02f, 6.20195195e-02f, -8.45922604e-02f, -3.18807587e-02f, 7.07116500e-02f, -1.74356684e-01f, 6.49449825e-02f, -1.52119342e-02f,
  -8.86688679e-02f, 1.13801472e-02f, -7.51765296e-02f, 1.16705567e-01f, 7.12029636e-02f, -1.44469842e-01f, -6.65930891e-03f, -5.65290600e-02f, 5.27624525e-02f, 6.81162477e-02f,
  1.01401508e-01f, 6.71463236e-02f, -9.88450721e-02f, -1.71126485e-01f, -6.00810461e-02f, 9.54491794e-02f, -6.61693215e-02f, 1.94375180e-02f, 2.03717306e-01f, -5.49828857e-02f,
  -1.00635244e-02f, -2.19262272e-01f, 2.29558319e-01f, 7.72817209e-02f, 5.69306836e-02f, 4.56073955e-02f, 2.56269774e-03f, 4.09999080e-02f, -8.82114843e-02f, 1.25918701e-01f,
  1.05639994e-01f, 2.26686254e-01f, 2.09962521e-02f, 9.73906741e-02f, 1.41403183e-01f, -2.81293187e-02f, -2.56232731e-02f, 9.04915184e-02f, 1.02994256e-02f, -1.21077918e-01f,
  2.03348193e-02f, 1.08661093e-01f, 3.37684155e-01f, -1.03414319e-01f, 3.60876285e-02f, -4.02140766e-02f, 1.41531780e-01f, -8.53799190e-03f, 3.06336612e-01f, -2.23000124e-02f,
  -5.74405156e-02f, 1.11998163e-01f, 2.30680779e-01f, -1.07279114e-01f, -2.38842323e-01f, 3.21891695e-01f, 6.89881891e-02f, 1.51987690e-02f, 5.65285347e-02f, 2.49118328e-01f,
  8.29495490e-02f, -6.40683025e-02f, 1.68678463e-01f, -1.91267774e-01f, 1.01610661e-01f, -2.04709068e-01f, 4.70370473e-03f, -8.29656888e-03f, -7.83388969e-03f, -1.68010071e-01f,
  6.71086311e-02f, 1.85250137e-02f, -4.24435623e-02f, 1.09440595e-01f, -2.05604330e-01f, 1.49880918e-02f, -1.53776303e-01f, -1.45571306e-01f, -1.08466782e-01f, -2.31139269e-02f,
  7.53717646e-02f, 1.37341112e-01f, 1.63723871e-01f, 3.89943412e-03f, -6.96336338e-03f, -1.61554232e-01f, -9.21400040e-02f, 1.41872033e-01f, 7.12203234e-02f, -6.69720620e-02f,
  2.67951280e-01f, -1.36325851e-01f, 1.05147168e-01f, 6.10828213e-02f, 3.62965427e-02f, 2.20827669e-01f, -1.68689340e-02f, 2.33981967e-01f, 1.90315880e-02f, 4.97374199e-02f,
  -1.72760859e-01f, -1.31881848e-01f, 9.44098309e-02f, 2.45166495e-01f, -2.96219289e-01f, 1.66322008e-01f, 1.97444320e-01f, 9.95876640e-03f, 4.07692753e-02f, 1.52350321e-01f,
  1.33112788e-01f, -1.02277091e-02f, -7.26037249e-02f, 2.64365464e-01f, 2.22722769e-01f, 5.43139130e-02f, -1.86972827e-01f, 1.58403620e-01f, -5.01971133e-02f, 1.84671178e-01f,
  -1.61248855e-02f, -2.11487129e-01f, 1.10995881e-01f, 2.30207667e-02f, -2.44525462e-01f, -3.11296999e-01f, -3.03278297e-01f, 1.68917835e-01f, -2.20592320e-02f, -1.95037112e-01f,
  -6.31996170e-02f, 9.39915795e-03f, 1.23108439e-01f, 4.52471562e-02f, 3.39115374e-02f, -6.38890499e-03f, 1.05827048e-01f, 1.36747658e-01f, 2.03991532e-01f, -4.18437719e-02f,
  5.78257628e-02f, 1.69373993e-02f, -5.44053279e-02f, 3.67734060e-02f, 4.32653865e-03f, -1.34106949e-01f, -1.42419683e-02f, 4.99516986e-02f, -6.76944554e-02f, 5.70565611e-02f,
  9.25915465e-02f, -7.12521300e-02f, -1.51722860e-02f, -8.46624747e-03f, -1.65628925e-01f, -1.23312622e-01f, -1.72332078e-02f, -1.14190966e-01f, -6.74087256e-02f, -1.62904605e-01f,
  -9.67914388e-02f, 4.12100442e-02f, 1.99935362e-02f, 1.57306679e-02f, 1.83502555e-01f, -1.48432314e-01f, -5.05490042e-02f, -6.23913631e-02f, 8.45216885e-02f, -1.37224823e-01f,
  -1.75565630e-01f, 1.49265662e-01f, -2.53534764e-01f, 6.32664412e-02f, -1.21968081e-02f, -1.17891997e-01f, -9.42620561e-02f, 2.03491747e-01f, 1.82343826e-01f, 7.32563883e-02f,
  -3.64927724e-02f, 2.05408305e-01f, -1.57747909e-01f, 6.79828897e-02f, 3.29400226e-02f, -4.44318652e-02f, -1.60311103e-01f, -1.73598424e-01f, 2.91256160e-01f, -1.68981001e-01f,
  -1.90385133e-01f, -7.96576366e-02f, -1.39402866e-01f, 1.98162138e-01f, -4.55643162e-02f, -3.12631689e-02f, -1.47091106e-01f, -8.84781629e-02f, -1.32350132e-01f, -2.22936571e-02f,
  -2.86211595e-02f, -2.01109082e-01f, -4.74860482e-02f, -1.39905199e-01f, 3.94622125e-02f, -1.79172128e-01f, -5.67337163e-02f, -3.75289395e-02f, 1.11403773e-02f, -6.70401901e-02f,
  1.00676462e-01f, -4.04567868e-02f, -6.39700368e-02f, -7.55901262e-02f, 9.66908261e-02f, 2.93471683e-02f, 1.17452644e-01f, 9.67433453e-02f, -5.45266420e-02f, 1.54106766e-01f,
  -1.06621161e-01f, 8.38328004e-02f, 1.18405372e-03f, 1.06112309e-01f, 2.87651550e-02f, -9.26400200e-02f, 1.16701677e-01f, 4.49099839e-02f, -8.91256779e-02f, 9.16678086e-02f,
  -3.67949866e-02f, 3.15705650e-02f, 1.94842502e-01f, 3.76504287e-02f, -1.85814239e-02f, -2.27841601e-01f, 1.60278268e-02f, -6.24412186e-02f, -5.69013357e-02f, -4.74645942e-02f,
  -2.60621775e-04f, -1.01097904e-01f, -1.54274568e-01f, 2.51619760e-02f, 1.39347747e-01f, -1.35329694e-01f, -1.51094109e-01f, -9.39401239e-03f, -5.14381416e-02f, 1.28255814e-01f,
  1.81134306e-02f, 1.10593691e-01f, -1.58363566e-01f, 1.29869521e-01f, 2.10071236e-01f, -9.71257314e-02f, 3.30303013e-02f, -2.36581992e-02f, -9.57047418e-02f, 3.66154872e-02f,
  -4.19780016e-02f, -1.04502946e-01f, -4.11019213e-02f, 6.96686730e-02f, -4.98862639e-02f, -7.00495169e-02f, -1.27171397e-01f, -2.23656390e-02f, -1.17543630e-01f, -1.22705549e-01f,
  -2.93209553e-02f, -3.96710970e-02f, 5.75484075e-02f, 1.18237250e-01f, -4.08344269e-02f, 5.46629466e-02f, -3.17492299e-02f, -8.07415172e-02f, 2.99397688e-02f, 1.00017272e-01f,
  1.09985813e-01f, 9.22922231e-03f, 9.58261639e-02f, 1.03970289e-01f, -8.24045762e-02f, 9.76964552e-03f, -1.51628494e-01f, 6.45570643e-03f, -1.42002612e-01f, 6.44864365e-02f,
  -3.28880437e-02f, 3.68364714e-02f, -1.93603620e-01f, 4.19055670e-02f, -4.61268947e-02f, 1.59368813e-01f, 1.16160206e-01f, -5.70431575e-02f, 2.42305383e-01f, -1.55332178e-01f,
  9.35327820e-03f, 4.46834080e-02f, 9.91973802e-02f, 7.47348368e-03f, -4.91329655e-02f, 2.36332923e-01f, 8.39224532e-02f, -9.56191048e-02f, -1.32473022e-01f, 4.09871303e-02f,
  -1.15880361e-02f, 1.40259981e-01f, -2.00543672e-01f, 1.65713295e-01f, 5.51160388e-02f, 6.72150478e-02f, -2.14316070e-01f, -4.43588523e-03f, 1.02386996e-01f, 1.47399738e-01f,
  3.19495760e-02f, -4.87912819e-02f, -3.70802991e-02f, -4.52656485e-02f, 1.35029301e-01f, 1.06880777e-01f, -4.94361110e-02f, -8.43372494e-02f, 8.91277418e-02f, 1.25366785e-02f,
  -8.81449580e-02f, 6.08018413e-02f, -5.23592755e-02f, 8.67356285e-02f, -2.67097075e-02f, -1.15870535e-02f, -9.45159644e-02f, -1.97672062e-02f, -7.25493208e-03f, -5.48221879e-02f,
  4.10443023e-02f, 1.70880571e-01f, -1.01819910e-01f, 7.44792148e-02f, -1.28774807e-01f, 3.65766622e-02f, -9.18133408e-02f, 6.16686046e-02f, 1.30643859e-03f, 8.31089541e-02f,
  1.48185715e-01f, 1.16862752e-01f, 6.61146194e-02f, 3.31376493e-02f, -6.56456202e-02f, -8.69640708e-02f, 5.10621630e-02f, 2.39155125e-02f, 3.67792882e-02f, 1.30975386e-02f,
  5.65421060e-02f, 3.64225507e-02f, -1.85177639e-01f, 1.87134087e-01f, 1.13099113e-01f, -7.22764730e-02f, -8.37542396e-03f, 1.48886487e-01f, 6.63224906e-02f, -1.60867840e-01f,
  -1.44121677e-01f, 5.40002696e-02f, 1.51730433e-01f, 1.69938039e-02f, 4.13170531e-02f, -1.01628333e-01f, 1.31454229e-01f, -5.99152930e-02f, 1.05907351e-01f, -6.67549893e-02f,
  1.10912047e-01f, 2.89916750e-02f, -1.44232130e-02f, -5.87350093e-02f, 3.24134412e-03f, -3.01366765e-02f
};

// L1_fan_Wp_bar (Shape: 26 x 64)
const int L1_fan_Wp_bar_rows = 26;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  1.23115405e-01f, 4.98999134e-02f, 2.15741426e-01f, -3.98498252e-02f, 1.79864824e-01f, 8.68298709e-02f, 6.50119781e-02f, 1.86259046e-01f, 1.97541460e-01f, 2.43284684e-02f,
  -1.26805589e-01f, 9.19886958e-03f, 1.08672185e-02f, 1.82495803e-01f, 5.26045226e-02f, 1.08653836e-01f, 5.67177795e-02f, 8.19341913e-02f, 2.41926014e-02f, -2.38193125e-01f,
  6.06562849e-03f, -6.52476354e-03f, 8.37716460e-02f, -1.20445833e-01f, -2.03244928e-02f, 2.22478621e-02f, -1.07780516e-01f, 2.12944858e-02f, -2.12082099e-02f, 3.11918855e-02f,
  4.11484055e-02f, 1.66834459e-01f, -1.94197278e-02f, 8.28855932e-02f, 2.85976939e-02f, 1.34447858e-01f, 1.04928225e-01f, -1.06142595e-01f, -1.01312637e-01f, 1.53848799e-02f,
  3.67783368e-01f, 1.65084049e-01f, -5.82771972e-02f, -5.00433296e-02f, 1.43945858e-01f, 7.04874694e-02f, 2.27278352e-01f, 4.49102186e-02f, 2.71654129e-02f, 1.48323447e-01f,
  8.12390894e-02f, -1.00759879e-01f, 3.54986973e-02f, 1.21909074e-01f, -6.96023107e-02f, 1.73496753e-02f, 1.82467028e-01f, 1.47133311e-02f, 9.99350287e-03f, 2.56834682e-02f,
  -1.19253010e-01f, -1.46783227e-02f, 7.76314288e-02f, -4.28961664e-02f, 6.79660067e-02f, -2.59509925e-02f, 1.53340667e-01f, 9.78404507e-02f, 1.12909354e-01f, 3.18293050e-02f,
  -3.82450074e-02f, 7.23691881e-02f, 4.43984121e-02f, 1.20927326e-01f, 1.58591852e-01f, 1.73855364e-01f, 3.24444324e-02f, -5.58639690e-02f, -4.10795622e-02f, -7.81243816e-02f,
  -1.13372833e-01f, 6.36922196e-02f, 6.21719360e-02f, 1.81730136e-01f, -1.64967746e-01f, -9.04087648e-02f, -9.91946831e-02f, 7.74500221e-02f, -8.03816915e-02f, -1.22167237e-01f,
  1.05105024e-02f, -3.93734127e-02f, 5.08998968e-02f, -3.13891694e-02f, 6.58355206e-02f, -8.45094696e-02f, -7.06360966e-04f, -1.22349530e-01f, 1.98536143e-02f, -7.61852860e-02f,
  9.57481749e-03f, 1.95883942e-04f, -5.32325916e-02f, 8.47689733e-02f, -1.40442804e-01f, 1.55398712e-01f, 5.95053285e-03f, -3.24797654e-03f, 1.20831482e-01f, 3.09266467e-02f,
  -1.56340562e-03f, -8.72324035e-02f, 4.71258685e-02f, -3.88377942e-02f, -7.33314222e-03f, 8.44639167e-02f, -1.26722837e-02f, -5.17528877e-02f, 1.29763752e-01f, 3.94857042e-02f,
  1.47707433e-01f, -1.14716895e-01f, 2.26864770e-01f, -8.64078924e-02f, -8.74220133e-02f, 3.76183167e-02f, -1.55047458e-02f, 9.24988315e-02f, -8.82491246e-02f, -4.37046289e-02f,
  1.87664226e-01f, 3.72940414e-02f, 3.69808190e-02f, 2.20966693e-02f, 5.99563345e-02f, 6.86894804e-02f, -2.26264913e-02f, -4.61578928e-02f, 1.38408363e-01f, -1.49546852e-02f,
  7.95371756e-02f, -1.37443859e-02f, 3.09175681e-02f, -1.03131190e-01f, 1.10473530e-02f, 7.32947215e-02f, 1.09199202e-02f, 1.73062921e-01f, -1.04405418e-01f, -1.66766066e-02f,
  -9.91440862e-02f, -3.15410048e-02f, -3.27105336e-02f, -9.21534076e-02f, 1.21389581e-02f, -1.97816700e-01f, 1.91447176e-02f, 5.42846695e-03f, 8.44320506e-02f, 3.55823822e-02f,
  -2.17266858e-01f, -1.30907983e-01f, 6.07618503e-02f, -1.50507808e-01f, -4.50870469e-02f, -9.67083424e-02f, 1.57160401e-01f, 1.18702233e-01f, -1.70634732e-01f, 2.73735046e-01f,
  -7.13289455e-02f, -9.86329019e-02f, 1.12971999e-01f, -9.44666564e-02f, 8.86807665e-02f, 6.87235370e-02f, 1.39836535e-01f, 1.12393916e-01f, 4.92883176e-02f, 6.17447942e-02f,
  -7.27355927e-02f, -1.02361441e-01f, 5.21049052e-02f, 1.23479798e-01f, 1.49298623e-01f, -1.43920600e-01f, 1.25860587e-01f, -6.61074519e-02f, 3.69785689e-02f, 1.43073216e-01f,
  -1.13002494e-01f, 1.12796865e-01f, -6.35963008e-02f, 1.06305189e-01f, -5.93471192e-02f, -5.41509129e-02f, 7.26471096e-02f, 7.49064535e-02f, 6.79639354e-02f, 3.07604913e-02f,
  6.50663599e-02f, 3.50720686e-04f, 1.50340665e-02f, -1.18405804e-01f, 3.25821079e-02f, 9.67182294e-02f, 6.21404760e-02f, -2.59516742e-02f, 8.67395401e-02f, 2.99717858e-02f,
  5.20641170e-02f, -2.65839159e-01f, 1.08155631e-01f, -1.32579640e-01f, 1.80386957e-02f, 4.31477063e-04f, -6.53790012e-02f, 2.98002288e-02f, -5.03240265e-02f, 2.43309010e-02f,
  -8.04465190e-02f, -6.21234179e-02f, -2.05660105e-01f, 5.53145492e-03f, 8.08143169e-02f, 3.38692628e-02f, 3.81793268e-02f, -5.36569301e-03f, -3.32178771e-02f, -1.99655108e-02f,
  1.26739934e-01f, -2.52191518e-02f, 2.83248961e-01f, -9.93479639e-02f, -1.05017111e-01f, 1.66659970e-02f, -2.22727749e-02f, -1.45276830e-01f, 8.01785067e-02f, 1.21798329e-01f,
  1.54126167e-01f, -2.68263817e-02f, 1.11279907e-02f, -9.74160731e-02f, -6.19695298e-02f, 1.99173480e-01f, -3.72496806e-02f, 6.31323084e-02f, -8.59302506e-02f, 1.14736296e-02f,
  7.76472241e-02f, 9.89783928e-02f, 1.37599081e-01f, -8.77342969e-02f, 4.78120446e-02f, 1.06676463e-02f, 1.79556422e-02f, -1.02922283e-02f, 9.73497480e-02f, 8.84439703e-03f,
  1.20518573e-01f, 7.70748928e-02f, -5.99049311e-03f, 1.48380354e-01f, 1.65266693e-01f, 9.38814804e-02f, 1.24866284e-01f, 1.10991038e-01f, 3.74440253e-02f, -3.55736315e-02f,
  4.94885370e-02f, 2.23666988e-02f, 5.43676764e-02f, 1.15229778e-01f, -4.94238809e-02f, 6.97995573e-02f, 1.28448620e-01f, -1.19840778e-01f, 7.38552362e-02f, -1.11852020e-01f,
  -1.16034076e-02f, -8.77221450e-02f, 8.91495049e-02f, 2.52711643e-02f, -1.34688988e-01f, -2.21065938e-01f, -1.13818198e-02f, 4.32787277e-02f, 7.89019018e-02f, 1.56577274e-01f,
  9.28671062e-02f, 9.03506353e-02f, 4.06761542e-02f, -5.28075583e-02f, 1.92722455e-02f, -7.03495517e-02f, 1.44636603e-02f, 7.48425201e-02f, -2.56707706e-02f, 4.77710031e-02f,
  -1.08164154e-01f, -5.21503109e-03f, -1.24748625e-01f, 2.07953639e-02f, 1.03007033e-01f, -2.13197377e-02f, -8.91460702e-02f, 1.76892146e-01f, 1.01367272e-01f, 8.29763263e-02f,
  6.96926638e-02f, -9.36707333e-02f, -6.43420815e-02f, -1.31278068e-01f, 2.35665336e-01f, -6.58055097e-02f, -6.36450052e-02f, -2.05237884e-02f, 5.58819659e-02f, 2.45707020e-01f,
  4.07471061e-02f, 1.36463106e-01f, 7.77252540e-02f, -1.18569560e-01f, 3.44733894e-02f, 1.72141254e-01f, 2.51024161e-02f, 1.10826544e-01f, 1.86229914e-01f, 6.39816374e-02f,
  -3.97301726e-02f, -7.68926516e-02f, -8.69923923e-03f, 1.08894706e-01f, 1.39032751e-01f, 6.27876073e-02f, 3.21957432e-02f, 1.63575545e-01f, 3.11370417e-02f, -2.48311818e-01f,
  1.85962439e-01f, -1.93276033e-01f, 7.42321983e-02f, 6.10075220e-02f, -3.38584296e-02f, -2.47648042e-02f, -1.81711793e-01f, -3.45173478e-02f, -1.09635144e-01f, -3.63395922e-02f,
  -5.19898646e-02f, 1.63992882e-01f, 6.19718917e-02f, 6.05439991e-02f, -2.84067858e-02f, 8.86683613e-02f, -9.99513790e-02f, -1.78110525e-01f, 2.33791262e-01f, -9.14723240e-03f,
  4.06292140e-01f, -2.69879890e-03f, -2.27215722e-01f, -2.28240546e-02f, 1.07140653e-01f, 1.91340931e-02f, 1.25323638e-01f, 1.89955384e-01f, 6.20434918e-02f, 1.59878373e-01f,
  9.86466110e-02f, -1.70069367e-01f, -1.67335242e-01f, 1.66760936e-01f, -3.94363329e-02f, 5.09040803e-02f, -8.54163915e-02f, 1.08663604e-01f, 1.04039580e-01f, 3.01518887e-02f,
  2.01361477e-01f, -1.14692710e-01f, 1.19284272e-01f, -1.21410284e-02f, -7.90262967e-03f, 3.10751684e-02f, -6.64842874e-03f, -2.27894611e-03f, -8.54315795e-03f, 1.09104449e-02f,
  3.54659855e-02f, -8.26481432e-02f, 1.10143311e-01f, 2.79606748e-02f, 8.06831494e-02f, -1.33543229e-02f, 4.92031761e-02f, -3.57112102e-02f, 3.57244499e-02f, 4.15942594e-02f,
  -5.08548617e-02f, -4.40297164e-02f, 5.09959944e-02f, -4.59072329e-02f, 7.52543584e-02f, -1.10327765e-01f, -4.95889969e-02f, 8.97828937e-02f, -1.25439689e-01f, 9.84013006e-02f,
  -1.23516500e-01f, -2.17312737e-03f, 7.62036396e-03f, -6.33132644e-03f, 1.10792823e-01f, 3.38379852e-02f, 2.32729930e-02f, -5.38728833e-02f, 4.56048362e-03f, 7.39555433e-02f,
  -6.60292134e-02f, -6.24527298e-02f, 2.53655672e-01f, -4.71826456e-02f, -2.43911725e-02f, 9.97765511e-02f, 1.46326944e-02f, -3.26285101e-02f, 2.00094264e-02f, 5.77199124e-02f,
  2.87386868e-02f, -2.68138549e-03f, -8.66219327e-02f, 1.55601963e-01f, 1.83218166e-01f, -6.95630535e-02f, -5.50297797e-02f, -6.85077310e-02f, 7.64385834e-02f, 8.40313956e-02f,
  -5.18902466e-02f, 1.28250360e-01f, 1.56202078e-01f, 1.83597684e-01f, 2.34134093e-01f, -5.19603826e-02f, 9.14449543e-02f, 1.12465337e-01f, -6.42978400e-02f, 1.26284808e-01f,
  1.04669318e-01f, 1.44465044e-02f, 1.61001846e-01f, 1.26495391e-01f, 1.47917882e-01f, 1.12220183e-01f, 1.00615099e-01f, 1.95915569e-02f, 2.71679871e-02f, 7.63575435e-02f,
  2.25018356e-02f, 6.51170760e-02f, 1.48832917e-01f, -3.10718790e-02f, 1.68723047e-01f, 8.89262035e-02f, 7.04823732e-02f, -9.96023789e-02f, 1.19757086e-01f, -1.19655207e-01f,
  1.22045092e-02f, -1.47458846e-02f, -4.24124710e-02f, -7.03137591e-02f, 8.26506913e-02f, -8.15853700e-02f, -1.89446732e-01f, -1.32557839e-01f, -2.23266885e-01f, 7.11699128e-02f,
  1.19241975e-01f, 1.07613243e-01f, 5.71312271e-02f, -2.90766675e-02f, -6.13362566e-02f, -7.35546695e-04f, 7.26787969e-02f, -8.63222107e-02f, 2.66929209e-01f, 7.22524449e-02f,
  -2.34943464e-01f, 2.82512344e-02f, -4.13074344e-02f, -9.39169005e-02f, -8.76625255e-02f, 2.06078768e-01f, 1.63159117e-01f, 3.35206203e-02f, 5.04633524e-02f, -6.12065569e-02f,
  -2.06351932e-02f, 1.20461695e-01f, -5.90261072e-04f, -2.37847324e-02f, -2.41807606e-02f, -3.84315178e-02f, 9.62446555e-02f, -1.34397432e-01f, -2.94943899e-02f, -5.57186678e-02f,
  3.90782505e-02f, 1.13335915e-01f, 1.54219449e-01f, 1.91829652e-01f, 1.69788152e-01f, -3.59046049e-02f, 1.53092608e-01f, 1.22512713e-01f, 1.33957177e-01f, 3.50774936e-02f,
  2.50131428e-01f, 3.01842373e-02f, -1.78188626e-02f, 7.06114769e-02f, 1.28445262e-02f, 1.35566786e-01f, 7.45787099e-03f, 2.03410432e-01f, 1.13761514e-01f, 1.85640723e-01f,
  1.46273211e-01f, -5.39427213e-02f, 1.10586844e-01f, 6.22582957e-02f, 6.87169284e-02f, -9.24037397e-02f, -1.63508877e-01f, -6.04918897e-02f, -2.13929210e-02f, 2.96642557e-02f,
  4.37669642e-02f, -7.15814084e-02f, 4.35350239e-02f, 1.33870929e-01f, 1.82796836e-01f, 7.72657171e-02f, 1.52035311e-01f, 1.57985851e-01f, -3.63986045e-02f, -6.01054840e-02f,
  -1.24621451e-01f, -3.48571967e-03f, 2.33736143e-01f, 5.06758727e-02f, 1.47117496e-01f, -1.79830231e-02f, -7.89384544e-02f, 1.01148054e-01f, -2.92863026e-02f, -9.28469822e-02f,
  -1.60332382e-01f, 1.47091001e-01f, 2.60176897e-01f, -1.50215432e-01f, 2.62487703e-03f, 7.65447095e-02f, 7.88959637e-02f, -2.06937715e-02f, -9.27879289e-02f, 2.79640891e-02f,
  2.77909301e-02f, 1.43962100e-01f, -2.92613208e-02f, -2.94890348e-02f, 2.40888625e-01f, 1.17057256e-01f, -1.51720503e-02f, 1.47669360e-01f, 1.86258689e-01f, -1.50055224e-02f,
  1.51514471e-01f, 4.29661423e-02f, 1.37161389e-01f, 2.66513061e-02f, 8.78486484e-02f, -1.42546510e-02f, 1.51680201e-01f, -6.40138015e-02f, -2.20843256e-02f, 8.27197507e-02f,
  4.90218326e-02f, 5.71994670e-02f, 8.30902308e-02f, -8.08772165e-03f, 4.12326232e-02f, -8.32032040e-02f, 6.30428046e-02f, -6.33080229e-02f, -1.51404306e-01f, 7.53384735e-03f,
  -1.10271290e-01f, -2.00122699e-01f, 1.73386112e-02f, -1.39979795e-01f, 1.99878644e-02f, -2.04363503e-02f, 1.79106146e-01f, 1.86566606e-01f, -8.94851536e-02f, -5.02230190e-02f,
  2.42532149e-01f, -1.07310154e-02f, 7.24623725e-02f, -2.29985952e-01f, -6.83069751e-02f, 3.41192000e-02f, 1.88145444e-01f, 1.27141535e-01f, -8.08025673e-02f, -6.78397119e-02f,
  -4.85080853e-02f, -9.67214555e-02f, 1.58867426e-02f, -6.15251213e-02f, -1.82730570e-01f, 2.70192385e-01f, 2.79978663e-01f, -2.06967577e-01f, -9.53218862e-02f, 8.38496387e-02f,
  1.88649327e-01f, -3.74472402e-02f, 2.80652922e-02f, -6.78098649e-02f, 2.83921897e-01f, -6.69492483e-02f, -1.32545650e-01f, -2.16935039e-01f, 1.41054153e-01f, 8.39758441e-02f,
  1.94076404e-01f, 9.84291211e-02f, -5.03270281e-03f, 4.12739404e-02f, 8.81049260e-02f, 1.54763550e-01f, 1.37021214e-01f, -3.32746059e-02f, 1.85480639e-02f, 1.94228232e-01f,
  5.11078276e-02f, 1.52302176e-01f, 1.04544796e-01f, 4.67321537e-02f, -3.66018414e-02f, 2.37914890e-01f, 5.03158234e-02f, 7.39938617e-02f, 9.35668051e-02f, 6.55696467e-02f,
  1.34994060e-01f, 1.44618109e-01f, 1.12264253e-01f, 6.64975494e-02f, -1.22313537e-02f, 2.37966225e-01f, -5.03245145e-02f, 2.24409774e-01f, 1.00749984e-01f, 4.14907075e-02f,
  9.94730964e-02f, -5.92605248e-02f, 1.81177780e-01f, 6.27961978e-02f, -1.33640721e-01f, 2.50449270e-01f, -5.52775934e-02f, 1.83907777e-01f, -1.30527839e-01f, -3.61722782e-02f,
  2.53695045e-02f, -8.50108862e-02f, 3.70879948e-01f, -1.86600443e-02f, -6.92564100e-02f, 2.01849595e-01f, -3.13990302e-02f, -1.34166211e-01f, -2.01196954e-01f, 6.11025048e-03f,
  2.02985495e-01f, -4.07865122e-02f, 1.37426749e-01f, 2.43050829e-02f, -1.41634479e-01f, 1.05538599e-01f, -8.81194472e-02f, 3.52236629e-01f, -1.90666169e-01f, 1.87595785e-01f,
  2.78305769e-01f, 5.43037653e-02f, 9.85283181e-02f, -1.43496633e-01f, 1.09917127e-01f, -1.71634322e-03f, 1.04629420e-01f, 1.59150865e-02f, 1.68634340e-01f, -4.98020202e-02f,
  7.25558326e-02f, -1.73077807e-02f, 1.18524106e-02f, 1.05987437e-01f, -1.75330371e-01f, -8.27884749e-02f, 1.02243803e-01f, -4.34015784e-03f, -1.03316061e-01f, 7.47793019e-02f,
  -3.53576653e-02f, -3.49888094e-02f, 4.09416258e-02f, 1.48712412e-01f, -3.61569747e-02f, -1.38049051e-02f, -1.56676974e-02f, -1.64294586e-01f, 4.54620570e-02f, 1.85774546e-02f,
  -3.90838645e-02f, 1.31515071e-01f, 1.93576023e-01f, 1.14009403e-01f, 1.18503824e-01f, 8.29447340e-03f, -9.17483121e-03f, -7.29186684e-02f, -7.74917081e-02f, 1.70719147e-01f,
  1.38615526e-03f, -6.99398294e-02f, -2.55278528e-01f, 9.32453200e-02f, -9.96911973e-02f, 6.22095019e-02f, 4.81899865e-02f, -1.06380023e-01f, 1.70094907e-01f, 1.28893942e-01f,
  3.16667587e-01f, -2.48801634e-01f, -1.84583694e-01f, -7.89492503e-02f, -6.22603633e-02f, -4.59131300e-02f, 2.22060755e-01f, -1.76814049e-01f, 3.25535648e-02f, 6.58936799e-02f,
  1.13911808e-01f, 7.11755380e-02f, -1.03112511e-01f, 1.66037530e-01f, 1.76536187e-03f, -7.63519034e-02f, -4.27160710e-02f, -6.66349158e-02f, 3.49053554e-02f, 1.44235470e-04f,
  1.54398814e-01f, -4.46007513e-02f, 1.04396261e-01f, 1.48514900e-02f, 1.41753480e-01f, 1.37138456e-01f, 4.09852639e-02f, 3.60845737e-02f, -1.90601572e-01f, -6.36938736e-02f,
  8.54025185e-02f, 6.87420219e-02f, 5.78768142e-02f, 5.12611344e-02f, 1.39849335e-01f, 5.68373390e-02f, 5.04620746e-02f, -3.54270525e-02f, 6.22699782e-02f, 1.32410333e-01f,
  -5.55307344e-02f, -7.67982379e-02f, 2.44732872e-01f, -1.79068223e-01f, 1.76416844e-01f, 6.13269471e-02f, 2.46508303e-03f, 2.33267382e-01f, -1.27100274e-01f, 8.72266218e-02f,
  -4.57278602e-02f, 9.11046565e-02f, -1.32904693e-01f, -8.32849443e-02f, 7.12600648e-02f, 1.47975519e-01f, -1.68794572e-01f, 2.13190988e-01f, 1.57797724e-01f, 8.13011974e-02f,
  -6.53069615e-02f, 1.05209745e-01f, 1.18300632e-01f, -3.09723280e-02f, 2.56221980e-01f, 1.16604261e-01f, 2.86277264e-01f, 1.42222205e-02f, -2.53314912e-01f, 2.40803495e-01f,
  -7.65296072e-03f, 2.07925737e-01f, 4.97143306e-02f, -1.28526747e-01f, 1.75140172e-01f, 2.13569887e-02f, -1.45877153e-01f, -2.02665463e-01f, -1.39772862e-01f, 9.87490453e-03f,
  -1.31859303e-01f, -1.36853755e-01f, 3.88486870e-02f, -4.74440400e-04f, 2.16385964e-02f, 3.53016891e-02f, 4.18438613e-02f, 1.28034920e-01f, 1.42250419e-01f, 2.22596869e-01f,
  -8.27809125e-02f, 1.23701677e-01f, -1.27488598e-02f, 1.21557929e-01f, 1.33919895e-01f, -8.27040523e-03f, 7.33926445e-02f, 4.14300263e-02f, 1.31142616e-01f, 5.36905229e-02f,
  1.06677338e-01f, 1.26425147e-01f, -7.42462948e-02f, -1.14326291e-01f, -3.78027484e-02f, -6.28000796e-02f, 1.97573170e-01f, -1.03122093e-01f, 1.58709884e-01f, -5.91387637e-02f,
  -1.45281717e-01f, 1.87627915e-02f, -8.76535475e-02f, -1.74737290e-01f, 2.79758833e-02f, -7.36815631e-02f, -6.19659536e-02f, -2.25885600e-01f, 2.17344798e-03f, 5.40853515e-02f,
  -3.11348382e-02f, 1.44608542e-01f, -1.18691467e-01f, -7.94496015e-03f, -2.13282540e-01f, 1.75319672e-01f, 2.08575770e-01f, -1.10630557e-01f, 8.95374045e-02f, 2.98313081e-01f,
  2.92674184e-01f, -5.02328500e-02f, -2.91012645e-01f, 2.65110016e-01f, -1.32670254e-01f, -1.99766010e-02f, -3.65878344e-02f, -2.89083309e-02f, 1.20457530e-01f, -1.02546021e-01f,
  5.84900454e-02f, -2.26861641e-01f, -9.05744135e-02f, 2.19490916e-01f, -2.08074301e-01f, 3.99817117e-02f, 2.34170202e-02f, -7.86816329e-02f, 1.44399345e-01f, 1.47151485e-01f,
  7.58641809e-02f, 1.10270560e-01f, 6.66512921e-02f, -3.98842655e-02f, -3.79911065e-03f, -4.54856344e-02f, 2.09547132e-01f, 1.46668240e-01f, 2.04727761e-02f, 3.33482251e-02f,
  1.05525866e-01f, -8.55521336e-02f, -1.01966664e-01f, 4.85198721e-02f, -8.59800205e-02f, 2.28298813e-01f, -1.16236098e-02f, -7.52082020e-02f, -1.09089471e-01f, 9.05376971e-02f,
  -2.66517460e-01f, -8.83785114e-02f, -1.48270270e-02f, -4.94147539e-02f, 7.97601715e-02f, -7.44705722e-02f, 9.30460319e-02f, -1.32718176e-01f, -1.13632947e-01f, -1.39275745e-01f,
  1.91292629e-01f, -1.04571275e-01f, 1.22400830e-02f, -1.19713604e-01f, 1.72803149e-01f, 6.46289662e-02f, -2.04925835e-01f, 1.32596537e-01f, -1.23006143e-02f, -1.18252717e-01f,
  5.01849502e-02f, -4.37090024e-02f, -1.45002186e-01f, -8.33926201e-02f, 4.02105339e-02f, -2.19997996e-03f, 6.76450878e-02f, 7.38512576e-02f, 2.43290700e-02f, -1.11860678e-01f,
  1.08837873e-01f, 1.54421538e-01f, -1.23209186e-01f, -1.66991383e-01f, 3.04506809e-01f, -6.73136860e-02f, -9.45747942e-02f, 5.27132191e-02f, -7.35196993e-02f, 9.81021896e-02f,
  7.12129176e-02f, 6.68453565e-03f, 1.36709511e-01f, -6.90142019e-03f, 6.64051548e-02f, 1.10761810e-03f, -1.51317450e-03f, 4.99160253e-02f, 1.38966918e-01f, -1.04816183e-02f,
  5.95407039e-02f, 5.11008594e-03f, 9.41203162e-02f, 2.29514048e-01f, 7.35147744e-02f, 1.81261137e-01f, 1.84012324e-01f, 5.89331193e-03f, 1.86519012e-01f, -2.67582506e-01f,
  -9.84921865e-03f, -1.69440567e-01f, 6.31925091e-02f, 1.46243811e-01f, 7.40499422e-02f, 1.30055442e-01f, -1.93108037e-01f, -7.15888068e-02f, 6.20670356e-02f, 8.25171098e-02f,
  1.32219076e-01f, 1.35957852e-01f, -6.49697781e-02f, -3.84178124e-02f, 1.19629567e-02f, 2.22709589e-02f, -3.09199076e-02f, -1.84520602e-01f, 9.44685191e-02f, 8.76700282e-02f,
  2.81512678e-01f, 7.75086135e-02f, -1.02942854e-01f, -4.93815690e-02f, 2.77512074e-01f, 5.33106886e-02f, 2.61452526e-01f, 2.39788312e-02f, -7.31190071e-02f, 1.63333550e-01f,
  2.65442252e-01f, -1.38526306e-01f, -1.52303055e-02f, 9.34990197e-02f, 6.34819195e-02f, 2.84235030e-01f, 2.10644916e-01f, 5.00530079e-02f, -7.56978840e-02f, 1.93837717e-01f,
  3.10434461e-01f, -3.04936115e-02f, 1.82527587e-01f, -3.48940007e-02f, 1.78466499e-01f, 6.76852688e-02f, 3.99250686e-02f, 9.10357311e-02f, 6.02893829e-02f, 1.15683757e-01f,
  9.19598192e-02f, -3.75675336e-02f, 2.98309680e-02f, 4.53861803e-02f, 1.88170657e-01f, 1.42202705e-01f, 1.04442134e-01f, -8.45689327e-03f, -7.59765180e-03f, 1.22887064e-02f,
  -1.06954888e-01f, 1.76098868e-02f, 1.32536337e-01f, 1.71801284e-01f, -1.24810226e-01f, 1.33662522e-02f, -1.13410905e-01f, -3.74907367e-02f, -1.59734234e-01f, 8.08450058e-02f,
  -8.17805007e-02f, 8.10239557e-03f, 8.40072185e-02f, -9.93435234e-02f, 4.58901227e-02f, 6.03351519e-02f, 4.54538688e-02f, -3.30409221e-02f, -7.55615206e-03f, 2.10722968e-01f,
  3.93818691e-02f, -2.64522955e-02f, -1.68246552e-01f, -5.91131039e-02f, -1.29839495e-01f, 1.52980432e-01f, 2.94167250e-01f, 8.93509015e-03f, -8.09023902e-02f, 1.10566862e-01f,
  -1.34456918e-01f, -2.10576400e-01f, -1.44402087e-01f, -1.96357071e-03f, 7.27388859e-02f, -8.09922889e-02f, 1.69405788e-01f, -1.18079893e-01f, -3.00056022e-02f, 1.28387317e-01f,
  -6.66883662e-02f, -5.79916500e-02f, 2.65671667e-02f, 1.28837198e-01f, 7.69159645e-02f, -8.56411178e-03f, 8.38455409e-02f, 7.66326860e-02f, 7.55377188e-02f, 4.57341596e-02f,
  1.86365962e-01f, 1.25397190e-01f, 2.87934970e-02f, -5.27983010e-02f, 2.46650036e-02f, -1.53134977e-02f, 2.51736287e-02f, 9.79120880e-02f, 1.17922433e-01f, 1.01068631e-01f,
  7.04529230e-03f, 3.35951522e-02f, 7.82593638e-02f, 7.95676261e-02f, -4.40551788e-02f, -5.07808402e-02f, 1.31658176e-02f, 6.84153885e-02f, -1.35605916e-01f, 5.04929200e-03f,
  -6.46888763e-02f, -4.09551226e-02f, -8.72690454e-02f, -5.50202280e-03f, -9.61637571e-02f, -1.03322104e-01f, 1.34675756e-01f, -1.88129507e-02f, 2.39451930e-01f, 3.82518210e-02f,
  -9.25643966e-02f, -1.29053593e-01f, 1.56801805e-01f, -2.46840920e-02f, 2.14445926e-02f, -1.58435151e-01f, 6.34717122e-02f, 7.59032145e-02f, -5.16135395e-02f, 1.41988203e-01f,
  9.95616764e-02f, -1.57040924e-01f, 1.26028270e-01f, 1.76117197e-01f, 1.52189985e-01f, -1.78564638e-01f, -5.63474111e-02f, 9.37095284e-02f, 2.13251799e-01f, -9.37619880e-02f,
  1.18988514e-01f, -1.59667954e-01f, 8.15667883e-02f, 1.05329797e-01f, 7.90819153e-02f, 2.32989551e-03f, 1.51366234e-01f, 2.43491337e-01f, 1.73311979e-02f, -7.45450556e-02f,
  3.95124741e-02f, -5.81081957e-02f, -3.44525278e-03f, 5.86693883e-02f, -2.20581274e-02f, 1.60706282e-01f, 1.36025593e-01f, 1.20575376e-01f, 2.57097092e-02f, 1.98998651e-03f,
  6.79843128e-02f, 1.65706843e-01f, 2.16638118e-01f, 3.10035646e-01f, 1.67992145e-01f, -1.16247684e-02f, 9.76460055e-02f, -5.35483053e-03f, 7.15163499e-02f, 1.39244780e-01f,
  7.65916258e-02f, 2.53757298e-01f, 6.22881912e-02f, 8.84701014e-02f, 3.33175659e-02f, 3.71291046e-03f, 4.32660105e-03f, -4.74837050e-02f, 1.71576709e-01f, 1.34314403e-01f,
  -2.13663295e-01f, -1.50574952e-01f, -1.31900012e-01f, -1.80376962e-01f, 2.16846168e-01f, 7.01960251e-02f, -8.88770372e-02f, -6.47234777e-03f, 6.66600913e-02f, 8.05513263e-02f,
  6.93393424e-02f, 1.65037699e-02f, -2.67506093e-01f, -6.72509447e-02f, 1.07242264e-01f, 1.14657588e-01f, -1.46191940e-01f, 2.18043439e-02f, -2.62166500e-01f, 7.74549097e-02f,
  2.38585249e-01f, -1.26801834e-01f, -2.75149584e-01f, 3.44739318e-01f, 1.60755008e-01f, 3.35331969e-02f, 1.03998813e-03f, 4.13761325e-02f, -3.74702103e-02f, -9.83178243e-02f,
  2.07614750e-01f, -1.19984888e-01f, 7.59447142e-02f, 3.15186642e-02f, -1.63517594e-01f, 1.41654909e-01f, -5.81790842e-02f, 4.24683020e-02f, 4.98024374e-02f, 6.72237128e-02f,
  -3.36682200e-02f, 1.26784712e-01f, 1.85741764e-02f, 1.04536235e-01f, -3.87034635e-03f, 1.29332945e-01f, 1.41749367e-01f, 1.92463011e-01f, 1.30562618e-01f, -4.46984507e-02f,
  5.59475012e-02f, 5.18475510e-02f, 1.30850241e-01f, 1.47483706e-01f, 9.23888665e-03f, -5.08418903e-02f, 4.26865555e-02f, -4.87878770e-02f, -4.79039215e-02f, 1.54088661e-01f,
  4.74271970e-03f, 8.67806673e-02f, -1.48376757e-02f, 3.03485673e-02f, -1.48653939e-01f, -8.65561813e-02f, -2.11906344e-01f, -1.50827914e-01f, 8.51008669e-02f, 4.88116108e-02f,
  -9.78605002e-02f, -1.16737373e-01f, 9.57193039e-03f, 9.96356532e-02f, 3.41202289e-01f, -1.49643924e-02f, -2.66890656e-02f, 6.27695099e-02f, -2.09285989e-01f, 7.81418160e-02f,
  -4.67736199e-02f, -6.70823306e-02f, -7.68725872e-02f, 2.15495944e-01f, 1.84075519e-01f, -1.15632489e-01f, -1.16075560e-01f, 1.08963802e-01f, -5.40718921e-02f, 8.42261538e-02f,
  4.74403687e-02f, 5.46517484e-02f, -8.65634009e-02f, -5.69554605e-02f, 1.90208271e-01f, -6.64208233e-02f, 2.41937786e-01f, 1.67915300e-01f, -8.31797868e-02f, 1.12861954e-01f,
  -5.08094393e-02f, 2.08031712e-03f, 7.40450695e-02f, 8.74238610e-02f, -2.74969153e-02f, 5.54243699e-02f, 5.72910048e-02f, -4.47600335e-02f, -3.28401439e-02f, 1.15959667e-01f,
  3.12899977e-01f, 2.34834880e-01f, 3.24883908e-02f, 1.82794817e-02f, 1.03452280e-01f, 6.23001605e-02f, -1.06147543e-01f, 9.82120410e-02f, 9.81239043e-03f, 2.25572154e-01f,
  -1.94118604e-01f, 3.14711221e-02f, -1.43748716e-01f, 1.22081324e-01f, -1.51820913e-01f, -3.27331969e-03f, 4.76259701e-02f, -8.34828839e-02f, 4.84273396e-03f, -1.02911264e-01f,
  -3.82669084e-02f, -1.77753583e-01f, -2.15161860e-01f, -1.86111480e-01f, 1.21988781e-01f, -3.13546248e-02f, 1.23046366e-02f, 4.94846031e-02f, 2.16853440e-01f, 4.26527150e-02f,
  -2.46207103e-01f, 1.13615908e-01f, -4.29820493e-02f, -6.93849921e-02f, 5.86756021e-02f, 4.58277203e-02f, -2.28767559e-01f, 1.80909559e-01f, 1.55496612e-01f, -4.26517576e-02f,
  -7.36344745e-03f, 9.44668576e-02f, -1.45598361e-02f, -2.09189430e-01f, 1.42034307e-01f, 9.83965173e-02f, -9.63559225e-02f, -2.45858595e-01f, 7.30042532e-02f, -2.53499914e-02f,
  7.42035881e-02f, 2.31140122e-01f, -1.49132177e-01f, 5.68184219e-02f, 4.62350771e-02f, 7.72078484e-02f, 3.43832150e-02f, -1.09040767e-01f, 1.01354219e-01f, 5.72062358e-02f,
  8.33182707e-02f, 6.84749149e-03f, 1.18719563e-01f, -3.61732803e-02f, -5.01500182e-02f, -7.04120249e-02f, 5.69672100e-02f, 8.23095366e-02f, 2.30112784e-02f, 1.74888462e-01f,
  2.16192499e-01f, 1.33806244e-01f, 8.57707560e-02f, -9.63441432e-02f, 1.89647436e-01f, -4.58931737e-02f, 1.66446581e-01f, -1.98944076e-03f, 4.85653728e-02f, -6.99428767e-02f,
  1.41263111e-02f, -1.79979056e-02f, -1.37781892e-02f, 4.47644778e-02f, -2.20224671e-02f, 8.33509192e-02f, 1.42964229e-01f, 5.38108684e-02f, 1.87743325e-02f, 3.94302532e-02f,
  6.82400763e-02f, 2.65420023e-02f, -1.09145701e-01f, 2.82639582e-02f, 9.37199444e-02f, -1.08904950e-01f, 5.16159460e-03f, 1.12322852e-01f, 1.40874768e-02f, -1.37139084e-02f,
  1.15361370e-01f, 1.26989126e-01f, 1.93320364e-02f, 4.12289314e-02f, -1.55085167e-02f, 1.01268783e-01f, -9.74211469e-02f, 5.58352582e-02f, -1.75834130e-02f, -6.39719367e-02f,
  -2.21567862e-02f, 2.10482672e-01f, 1.37111722e-02f, 6.97629154e-03f, -2.26281583e-02f, -1.07849918e-01f, 9.72549841e-02f, 5.88370534e-03f, 1.38199508e-01f, -6.92983940e-02f,
  2.04252303e-01f, 2.11557969e-01f, -4.26385924e-02f, 3.94846275e-02f, -7.77302012e-02f, 5.90530112e-02f, -7.06843138e-02f, 7.03690425e-02f, 4.59759049e-02f, 1.65958226e-01f,
  -4.13010865e-02f, -6.50159642e-02f, 6.42193258e-02f, -2.00686371e-03f, -7.93003887e-02f, -1.03222802e-01f, -1.53918499e-02f, 1.53847039e-01f, -2.73028761e-01f, -3.30179483e-02f,
  -1.45990536e-01f, 9.05186459e-02f, 8.05789307e-02f, -8.80152360e-02f, -3.57184261e-02f, -1.64650574e-01f, 1.07273869e-01f, 4.15853895e-02f, 1.45587906e-01f, -3.61520536e-02f,
  -1.67719156e-01f, -1.97996184e-01f, -3.11533492e-02f, -1.36530995e-01f, 2.81045064e-02f, 4.14747791e-03f, 2.07073521e-02f, 1.91800028e-01f, -1.59096465e-01f, 1.22979149e-01f,
  -7.71157742e-02f, -9.74326655e-02f, 1.98962286e-01f, 1.17999727e-04f, 1.29314408e-01f, -1.34258512e-02f, -6.75266758e-02f, -8.80680978e-02f, -1.34850159e-01f, -2.03646477e-02f,
  -1.57352053e-02f, -1.32330686e-01f, 1.65779755e-01f, 7.87169561e-02f, 1.01046525e-01f, -8.03277493e-02f, -8.85550454e-02f, -1.74468011e-02f, 2.83530843e-03f, 2.46328890e-01f,
  -6.98772296e-02f, 7.00710192e-02f, 1.38962537e-03f, -1.64542459e-02f, -8.42428356e-02f, -1.98112186e-02f, -7.31319636e-02f, 3.20331976e-02f, 8.48856792e-02f, -6.09750412e-02f,
  -8.46734270e-03f, 5.92611693e-02f, 5.88125885e-02f, 2.82557830e-02f, 3.76779139e-02f, 6.70891628e-02f, -1.95752848e-02f, 9.38531235e-02f, 9.44348797e-02f, -5.86691350e-02f,
  7.36501291e-02f, -1.25440314e-01f, 1.09082758e-01f, 2.17137067e-03f, 2.31141299e-02f, 4.00289260e-02f, -7.79864416e-02f, 1.91107005e-01f, -5.73667996e-02f, 4.84497473e-02f,
  -4.87859063e-02f, -4.22860794e-02f, 1.68922115e-02f, -4.54110466e-03f, 5.85642308e-02f, -6.43813908e-02f, -1.04213553e-02f, 8.00860450e-02f, 3.18047702e-02f, 5.88623732e-02f,
  8.33425447e-02f, -2.68294290e-02f, 6.66026250e-02f, -1.53833002e-01f, 6.94209058e-03f, -6.30447119e-02f, 1.14365406e-02f, 7.71025643e-02f, 6.83716014e-02f, -1.42519951e-01f,
  -2.31892802e-02f, -3.16156335e-02f, 1.78187221e-01f, -1.46460906e-01f, 1.34926409e-01f, 7.18609989e-02f, -1.01839140e-01f, 1.77936599e-01f, -5.58832660e-02f, 1.71825990e-01f,
  -1.28652140e-01f, 3.16851944e-01f, 1.45085260e-01f, -2.06181481e-02f, 1.60834327e-01f, -3.68771404e-02f, 1.94148317e-01f, -8.15324485e-03f, -5.06696142e-02f, 1.83237866e-01f,
  5.91737889e-02f, 4.38277312e-02f, 6.12398498e-02f, 1.82925299e-01f, 5.22257388e-02f, 1.36621833e-01f, 3.02721374e-02f, 2.93861270e-01f, 9.32624787e-02f, 2.60028001e-02f,
  5.04124202e-02f, 2.97074616e-02f, 8.54825377e-02f, 1.39494270e-01f, 2.47308165e-02f, 2.03455061e-01f, -1.44891739e-02f, 2.34754711e-01f, -9.60412249e-02f, 1.81193184e-02f,
  9.52196047e-02f, -3.62995255e-04f, 2.67247260e-01f, 2.88714498e-01f, -4.14784532e-03f, 1.10058025e-01f, -6.39732406e-02f, -2.31481358e-01f, 1.88184544e-01f, 1.46950796e-01f,
  -1.21393636e-01f, -1.32598624e-01f, 1.57036722e-01f, 2.92932928e-01f, -1.85132325e-01f, 1.26957864e-01f, -1.98075518e-01f, 1.10000027e-02f, 2.93013871e-01f, 1.00619644e-01f,
  5.05120270e-02f, -4.93702572e-03f, -2.47921776e-02f, -1.04044341e-01f, -2.68354267e-02f, -1.39125571e-01f, -9.48350728e-02f, 2.32220948e-01f, 7.67439082e-02f, -2.49555730e-03f,
  1.95153907e-01f, -1.10177375e-01f, 4.90544289e-02f, 1.31785169e-01f, -2.52154320e-02f, -2.37722382e-01f, -1.50290027e-01f, 9.27935392e-02f, -1.35206103e-01f, 2.56328434e-02f,
  9.14076418e-02f, 1.32400826e-01f, 1.68581769e-01f, 6.14791512e-02f, 1.25035003e-01f, 2.72662379e-02f, 1.12764701e-01f, 1.79089665e-01f, 3.06402892e-01f, 6.09031832e-03f,
  4.89226095e-02f, -7.09726661e-03f, 1.36836320e-01f, 5.21678030e-02f, 1.50341138e-01f, -3.42293531e-02f, 1.87225297e-01f, 1.97141394e-01f, 3.08878198e-02f, -1.21497586e-02f,
  1.61301464e-01f, -8.05546418e-02f, 7.93217570e-02f, -1.26057550e-01f, -4.94726822e-02f, -1.60900846e-01f, 5.75377159e-02f, -8.19624737e-02f, -3.16714570e-02f, -1.63504258e-01f,
  2.75270119e-02f, 4.33180891e-02f, 1.81821808e-01f, 2.25968376e-01f, 1.58826411e-01f, -1.38206482e-02f, 1.85048822e-02f, -1.98462009e-01f, -2.51070485e-02f, 4.48655561e-02f,
  1.36122346e-01f, 9.09462124e-02f, -1.13092884e-01f, 6.26653507e-02f, -8.53152648e-02f, -1.55659497e-01f, -4.34184112e-02f, -6.08392209e-02f, -8.97053406e-02f, 1.14023767e-01f,
  1.74269691e-01f, -2.50633154e-02f, -7.45185390e-02f, 7.70413876e-02f, 1.45713866e-01f, -1.15744911e-01f, -8.61515403e-02f, -8.26551542e-02f, 2.52124429e-01f, -2.03768671e-01f,
  -1.93511412e-01f, -1.65760681e-01f, 1.74865395e-01f, 2.22539678e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 26)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 26;
const float L1_fan_Bp_bar_data[] = {
  -1.92940924e-02f, 3.50472378e-03f, 9.62190237e-03f, 1.65624097e-02f, 8.77108127e-02f, 1.86094325e-02f, 1.02313548e-01f, 2.94327401e-02f, -1.33317607e-02f, 7.95549974e-02f,
  1.70605257e-01f, 4.27198224e-03f, 1.56338602e-01f, 4.64317948e-02f, -2.07917020e-02f, 4.37845960e-02f, 1.47612438e-01f, 1.23916373e-01f, 5.33949845e-02f, 7.36139268e-02f,
  1.31276965e-01f, 1.35946691e-01f, 1.38742059e-01f, 8.32098052e-02f, 2.23997980e-01f, 1.73667353e-02f
};

// L2_fan_Wp (Shape: 19 x 64)
const int L2_fan_Wp_rows = 19;
const int L2_fan_Wp_cols = 64;
const float L2_fan_Wp_data[] = {
  -2.72610970e-02f, -5.68223819e-02f, -6.85044900e-02f, -5.29394597e-02f, 1.38744740e-02f, -3.49397063e-02f, -2.61783060e-02f, 1.11329995e-01f, 1.95416100e-02f, 1.44562488e-02f,
  -6.98138699e-02f, -7.06635863e-02f, 1.30069973e-02f, -3.15864831e-02f, -7.01497197e-02f, -9.07929242e-02f, -4.08172794e-02f, -7.09547251e-02f, 2.20293254e-02f, -1.52652144e-01f,
  -1.04918174e-01f, 2.53524389e-02f, 4.10602726e-02f, 1.65143814e-02f, -1.63440153e-01f, 8.10119137e-02f, 1.57501802e-01f, 7.30494186e-02f, -7.27452617e-03f, -7.03688040e-02f,
  5.53088188e-02f, 9.72972065e-02f, -5.28414063e-02f, -1.08535573e-01f, -6.06185608e-02f, 9.18866470e-02f, -6.48884922e-02f, 8.45069215e-02f, -1.60150871e-01f, 9.54815075e-02f,
  -7.83357024e-03f, -1.11909127e-02f, -1.11305334e-01f, -6.39289469e-02f, 1.16664715e-01f, -1.33058056e-01f, -1.22974105e-01f, 3.82660478e-02f, 4.93230633e-02f, 4.66121174e-02f,
  -5.74564189e-02f, 1.21557936e-01f, 6.58817440e-02f, -1.46116195e-02f, -6.51949123e-02f, 1.04160897e-01f, -1.44389067e-02f, 3.87310348e-02f, 5.82218803e-02f, 3.73213403e-02f,
  7.74135962e-02f, 5.47761209e-02f, 1.56993702e-01f, 2.93113720e-02f, -1.39745483e-02f, 2.00404786e-02f, -1.44195169e-01f, -2.27845624e-01f, 5.31791635e-02f, -3.26050036e-02f,
  -1.07113570e-02f, 1.27777055e-01f, 3.03563084e-02f, -1.77391339e-02f, -1.31023303e-01f, -2.21798271e-02f, -1.04728706e-01f, -9.53143835e-02f, 3.69694009e-02f, -1.87589601e-02f,
  -5.09316102e-02f, 3.85459289e-02f, 1.29257485e-01f, -2.40649268e-01f, -2.17114583e-01f, -9.86879393e-02f, 5.24784066e-02f, 5.99225536e-02f, 1.00095600e-01f, -4.16493192e-02f,
  -1.29482560e-02f, 7.42046088e-02f, 1.51497662e-01f, 1.56168774e-01f, -1.69743821e-01f, 1.00666815e-02f, -1.47404775e-01f, -1.13858752e-01f, -1.59687415e-01f, 1.29360512e-01f,
  1.17873296e-01f, 9.25010145e-02f, -1.69235304e-01f, -3.01230289e-02f, -5.22009470e-02f, -7.43007511e-02f, -8.34811851e-02f, 1.59883909e-02f, 5.32045588e-02f, -3.32327858e-02f,
  -2.67998688e-02f, -8.16651285e-02f, 5.45970090e-02f, -2.60548871e-02f, -2.02661678e-01f, 2.39292048e-02f, 2.48930976e-02f, 1.47257419e-03f, 2.21977234e-02f, 1.85463317e-02f,
  -1.45396039e-01f, 1.16245173e-01f, 1.65387735e-01f, -6.81802779e-02f, 1.75782174e-01f, 1.10128187e-01f, -2.34162286e-02f, -1.52749360e-01f, 7.36630009e-03f, -8.46252963e-02f,
  1.66520681e-02f, -1.01690605e-01f, -3.13318595e-02f, 1.69113707e-02f, -4.69716787e-02f, -1.61324106e-02f, -7.99008831e-03f, 8.30056029e-04f, 6.93539008e-02f, 6.54283091e-02f,
  -3.48642208e-02f, -2.89288093e-03f, 2.20232308e-02f, -5.28991036e-02f, 2.29747314e-02f, -6.24484532e-02f, -5.97756952e-02f, -7.25564584e-02f, -1.26438916e-01f, 1.29919767e-01f,
  -5.27872071e-02f, 1.00275733e-01f, -4.89116646e-02f, 9.12920013e-02f, 6.17597327e-02f, 1.64375231e-02f, -1.63678363e-01f, 9.75493789e-02f, -2.00463757e-01f, -9.71368477e-02f,
  1.40266970e-01f, -1.23866983e-01f, -1.02122650e-01f, 4.10328470e-02f, -6.48350939e-02f, 1.10539712e-01f, 7.84749817e-03f, 1.06038734e-01f, 5.81676997e-02f, -1.58627898e-01f,
  -1.05503619e-01f, 1.80268176e-02f, -1.52180046e-02f, -1.94106430e-01f, 4.99320328e-02f, 1.32927269e-01f, 4.15551178e-02f, 1.70529574e-01f, -1.67703796e-02f, 3.45530957e-02f,
  7.52609819e-02f, 8.15869868e-02f, 2.72001885e-02f, 6.88547492e-02f, -1.34477198e-01f, -1.36946037e-01f, -1.20845221e-01f, 3.29652131e-02f, 5.72100803e-02f, 7.44297262e-03f,
  -1.89805627e-02f, 4.03813459e-02f, 3.12879533e-02f, -8.62875655e-02f, -6.22249022e-03f, 1.94824681e-01f, 1.27133176e-01f, 5.12002520e-02f, -9.00185853e-02f, 5.38791269e-02f,
  1.35205418e-01f, 1.33366391e-01f, -1.24433182e-01f, -1.60998061e-01f, -5.16813211e-02f, 8.43319297e-02f, -1.70498304e-02f, -1.55891096e-02f, 6.34720251e-02f, 1.29246548e-01f,
  1.76605031e-01f, -2.02418551e-01f, -9.14613344e-03f, 2.46086251e-02f, 1.14071704e-02f, 6.11222945e-02f, -1.77998006e-01f, -1.26342461e-01f, 1.94985524e-01f, -3.27455029e-02f,
  1.09516457e-01f, 1.13671347e-01f, 1.40036374e-01f, 8.46510381e-02f, -2.63517231e-01f, -1.13936476e-01f, -3.60775702e-02f, -1.92292184e-01f, -1.51230901e-01f, 1.14388347e-01f,
  -1.08116142e-01f, 1.25451475e-01f, 6.99215233e-02f, -6.86040670e-02f, -2.68116333e-02f, -1.42557561e-01f, -1.19931839e-01f, -1.34177312e-01f, -2.83964183e-02f, -1.29471809e-01f,
  -4.47154194e-02f, 9.65498015e-02f, 7.46491477e-02f, 8.66493359e-02f, 9.87569913e-02f, -1.96554914e-01f, 1.24254860e-01f, 2.40694638e-02f, 2.92193264e-01f, -2.03858949e-02f,
  1.15578294e-01f, 2.88747624e-02f, 1.06618039e-01f, -2.76868488e-03f, 1.14794299e-01f, -8.21484178e-02f, -1.46570476e-02f, 4.76577170e-02f, 1.49698332e-01f, -8.04662481e-02f,
  -3.24640088e-02f, -1.38141792e-02f, 2.28640810e-02f, 9.90496278e-02f, 2.26484202e-02f, 8.68280232e-02f, 7.83434808e-02f, -5.50411940e-02f, 4.97796759e-02f, -4.19094861e-02f,
  1.82160810e-02f, 6.25997828e-03f, 2.78916284e-02f, 1.14141479e-01f, 4.00945470e-02f, 2.10069083e-02f, 1.75586026e-02f, -7.02287676e-03f, 9.09126699e-02f, 1.82833359e-01f,
  -1.00658007e-01f, 6.93957433e-02f, -8.65829811e-02f, -3.83785181e-02f, -4.95046079e-02f, -9.70288739e-02f, -4.01882716e-02f, -8.55883509e-02f, 1.73859045e-01f, 1.51431382e-01f,
  -1.51785910e-01f, 9.44950283e-02f, -1.30870804e-01f, 1.69085041e-02f, 3.56394127e-02f, -7.63527974e-02f, -8.82631391e-02f, -9.22548249e-02f, -4.87801023e-02f, -1.04710925e-04f,
  -7.01543093e-02f, -8.76386017e-02f, -2.34879889e-02f, -1.07315734e-01f, 8.03967118e-02f, 1.49981812e-01f, 6.26056865e-02f, -6.33803234e-02f, -8.60295817e-02f, 1.39852554e-01f,
  -4.39569131e-02f, 1.41764600e-02f, -7.27980137e-02f, -9.47888196e-02f, -1.81277499e-01f, 7.87123218e-02f, 1.26307141e-02f, -5.54979891e-02f, 1.02040038e-01f, -1.50729045e-01f,
  5.08804321e-02f, 7.82319009e-02f, -1.30234510e-01f, -4.45781350e-02f, -1.29883170e-01f, 2.26953235e-02f, -6.32640570e-02f, 5.04542924e-02f, -7.92368799e-02f, -1.76220462e-02f,
  -2.58857068e-02f, -8.23665559e-02f, -5.97415827e-02f, -8.42657760e-02f, -8.93614516e-02f, -1.62569508e-01f, -9.29702595e-02f, 4.06507635e-03f, -7.46923452e-03f, -2.23976597e-02f,
  4.24397625e-02f, -2.00637534e-01f, -1.49365202e-01f, -1.27411604e-01f, -7.67364800e-02f, -7.85460696e-02f, -4.59109247e-02f, -1.88002326e-02f, 2.38635942e-01f, -2.85896435e-02f,
  2.10371196e-01f, 1.11721262e-01f, -2.04520032e-01f, 4.17870469e-02f, 9.44777578e-02f, 1.67074446e-02f, 1.23576827e-01f, -1.89817086e-01f, -1.03967033e-01f, -5.22104017e-02f,
  -7.77068955e-04f, 2.48955097e-02f, 9.29912254e-02f, 1.23442061e-01f, 4.36760805e-04f, 7.57847130e-02f, -1.06615461e-01f, -1.76381692e-01f, -9.16536599e-02f, -1.52335882e-01f,
  8.80963430e-02f, 1.72439381e-01f, 4.29144921e-03f, -6.04111515e-02f, -1.59001440e-01f, -1.64389655e-01f, 9.89962146e-02f, 1.62181184e-01f, 4.95656133e-02f, -4.62162606e-02f,
  -8.23904648e-02f, -1.87131781e-02f, -1.97251990e-01f, -3.94028984e-02f, 5.52325770e-02f, 9.65213850e-02f, -9.83054489e-02f, 2.62033707e-03f, 1.27293589e-02f, 3.01007237e-02f,
  5.54630272e-02f, 9.34276506e-02f, 7.27139637e-02f, -6.84055313e-02f, 3.73896658e-02f, -2.28792261e-02f, 3.48632075e-02f, -5.95481917e-02f, -3.72746028e-02f, -1.72341149e-02f,
  7.30250999e-02f, 9.59886536e-02f, 7.79837668e-02f, 6.89332932e-02f, 1.79993361e-01f, -8.56560767e-02f, -5.74007519e-02f, -1.42926425e-01f, -2.04406902e-02f, 1.79020073e-02f,
  -9.03304741e-02f, -8.80922228e-02f, 1.46198288e-01f, -1.62065551e-01f, 2.55103916e-01f, 1.85186312e-01f, -7.04044849e-03f, 1.22239992e-01f, 5.38343191e-02f, 6.15760982e-02f,
  1.17074989e-01f, -1.60299167e-01f, -5.73429950e-02f, -3.53220142e-02f, -6.63425475e-02f, 1.34927899e-01f, 5.95546439e-02f, 1.84886456e-01f, 1.25736594e-02f, 1.40903875e-01f,
  -7.00161606e-02f, -1.53497547e-01f, -7.86329135e-02f, -1.30195767e-01f, 2.53222976e-02f, 1.44378349e-01f, -8.99410248e-02f, 1.56864226e-02f, -6.74403980e-02f, -9.53618214e-02f,
  9.38713774e-02f, 2.25667685e-01f, 1.04371764e-01f, 6.73559010e-02f, -2.63256263e-02f, 1.54731958e-03f, -1.52620347e-02f, -5.82590625e-02f, 8.57581720e-02f, -2.26876861e-03f,
  9.57434177e-02f, 2.19408184e-01f, 2.19050005e-01f, 6.40974641e-02f, 8.50725099e-02f, -6.59122318e-03f, 2.22388804e-01f, 5.64045198e-02f, -3.88252847e-02f, -1.11031182e-01f,
  1.12049766e-01f, 8.21556076e-02f, 6.94481954e-02f, 5.90671673e-02f, 1.19327664e-01f, 1.99397266e-01f, 1.20311350e-01f, 5.09910025e-02f, 2.40659997e-01f, -3.35469283e-02f,
  1.01915896e-01f, -2.07245618e-01f, -6.06565289e-02f, 1.23522535e-01f, -1.94393709e-01f, -1.52226314e-01f, 2.26076860e-02f, -2.09843174e-01f, 1.10218629e-01f, 6.33143336e-02f,
  5.51208220e-02f, 1.58258393e-01f, -8.17870200e-02f, -1.54917240e-01f, -7.91717917e-02f, -1.61220640e-01f, -2.04094294e-02f, -3.22987922e-02f, -1.61722600e-01f, -6.07462749e-02f,
  6.05831109e-02f, 8.90803412e-02f, -1.65780202e-01f, 1.51324496e-01f, 1.47834703e-01f, -9.67638940e-02f, 1.38142481e-02f, -1.18073605e-01f, 1.34980902e-01f, 7.27356179e-03f,
  -1.91676423e-01f, -1.26161739e-01f, -6.37630150e-02f, -9.41505656e-02f, 4.90220375e-02f, 4.62539792e-02f, -1.15706518e-01f, 1.35108680e-01f, 3.66195658e-04f, -6.36106655e-02f,
  7.21729249e-02f, 1.78279355e-01f, 5.80378696e-02f, -1.38464551e-02f, -1.99642759e-02f, 1.22701287e-01f, -7.30202161e-03f, -2.30858028e-02f, -5.96792400e-02f, 8.38230923e-02f,
  7.13021308e-02f, 4.27904492e-03f, -1.24775171e-01f, -1.36830270e-01f, -6.08481653e-02f, 6.42020404e-02f, 5.23491204e-02f, -2.64022257e-02f, 3.28622386e-02f, -1.72485393e-02f,
  1.24747947e-01f, -2.01793477e-01f, 2.12390628e-02f, -7.66130304e-03f, 1.84291694e-02f, 7.95791969e-02f, -1.75993368e-01f, 1.75617319e-02f, 1.93096176e-01f, 1.06940091e-01f,
  9.44861472e-02f, 3.12452503e-02f, 1.01722263e-01f, 1.61727928e-02f, -2.01799661e-01f, -1.09312370e-01f, -1.85816940e-02f, -1.82355382e-02f, -1.55853152e-01f, 5.99569604e-02f,
  -1.59134358e-01f, 1.19897630e-02f, 8.97298530e-02f, -1.19228065e-01f, 6.46519586e-02f, -1.34433672e-01f, -4.59729098e-02f, -1.09923258e-01f, -1.87334092e-03f, -2.30407640e-02f,
  6.53716326e-02f, 4.79520895e-02f, -8.92220810e-02f, 1.47777602e-01f, 1.21875525e-01f, -1.86729431e-01f, 1.77124619e-01f, 9.69797224e-02f, 2.68720329e-01f, -7.08674490e-02f,
  1.29582822e-01f, 3.45299095e-02f, 1.62010677e-02f, -3.76360640e-02f, 2.26260006e-01f, -3.76040228e-02f, 2.10907668e-01f, -7.15130568e-03f, -3.47555988e-02f, 6.23260019e-03f,
  -2.55523273e-03f, 2.00949647e-02f, 2.10429002e-02f, 6.56053200e-02f, 3.86906490e-02f, 8.48234631e-03f, -7.83043131e-02f, -2.69833039e-02f, -5.05977459e-02f, 8.28052908e-02f,
  -4.28895876e-02f, -1.15783930e-01f, -1.72466189e-02f, 2.87781768e-02f, 2.96764653e-02f, -1.08317852e-01f, 3.09660323e-02f, 7.72256311e-03f, 1.91586986e-01f, 9.61448029e-02f,
  3.74195985e-02f, -1.02499247e-01f, -2.96325292e-02f, 1.57089859e-01f, 5.87874763e-02f, -1.39308035e-01f, 1.79520428e-01f, 6.63364232e-02f, -1.03175245e-01f, -1.92636058e-01f,
  -3.98600101e-02f, 9.32675153e-02f, -4.94665429e-02f, 8.14365968e-02f, -8.66851062e-02f, 1.43621461e-02f, -9.60618779e-02f, 6.32888302e-02f, 1.63688120e-02f, -5.91821633e-02f,
  1.24563619e-01f, -1.13676816e-01f, 1.24254435e-01f, -1.65057406e-01f, 1.71241373e-01f, -2.48644724e-02f, -1.37362763e-01f, -5.85116148e-02f, -4.97389510e-02f, -9.63628292e-02f,
  1.71265230e-01f, 1.07882489e-02f, 1.79058626e-01f, 6.79187849e-03f, 1.05183914e-01f, -5.20482706e-03f, -5.99117912e-02f, 1.08765177e-01f, 7.63770416e-02f, -1.89534258e-02f,
  -7.03532025e-02f, 1.96204763e-02f, 9.43066925e-02f, 4.39608023e-02f, 4.22850950e-04f, -3.38023119e-02f, -6.26998991e-02f, -8.05592611e-02f, 6.35502208e-03f, 9.47348699e-02f,
  2.31882446e-02f, 8.23854208e-02f, 5.25033809e-02f, -5.99842593e-02f, -4.58314922e-03f, -1.13866832e-02f, -5.31712957e-02f, -3.28003243e-02f, -2.25213859e-02f, 1.68097820e-02f,
  -9.26442891e-02f, 9.81003717e-02f, -9.94447321e-02f, 1.39980186e-02f, 8.01358074e-02f, 6.42344505e-02f, 2.21502688e-03f, -3.25194374e-02f, -1.27729550e-01f, 2.37824954e-02f,
  -1.33381441e-01f, -9.69803482e-02f, 3.72065119e-02f, 7.92198908e-03f, 4.22919877e-02f, -3.23252343e-02f, -7.92576373e-02f, 5.03870845e-02f, 1.92410409e-01f, 5.26358467e-03f,
  2.10905578e-02f, -2.19335337e-03f, 5.26556885e-03f, 4.50456552e-02f, -1.04610361e-01f, -4.69163917e-02f, -3.27468924e-02f, 1.47033930e-01f, -4.69721407e-02f, 1.17954075e-01f,
  8.41704980e-02f, 4.36534211e-02f, -5.35351411e-03f, 5.00094630e-02f, 2.97162253e-02f, 1.04543373e-01f, -5.13796024e-02f, -1.27855331e-01f, -1.17935799e-01f, 7.00063631e-02f,
  5.07881073e-03f, -2.26881690e-02f, -1.90994725e-01f, 8.97432491e-02f, 1.32444248e-01f, 3.26586440e-02f, -8.11893959e-03f, 7.69009441e-02f, 1.15165025e-01f, -1.13818780e-01f,
  -1.05383858e-01f, 7.81708807e-02f, 6.13704836e-03f, -2.14597527e-02f, 1.01029329e-01f, 2.42939517e-02f, -7.55851567e-02f, 5.62865771e-02f, -2.33967267e-02f, 4.10464741e-02f,
  1.03001975e-01f, 7.40042105e-02f, 7.88143724e-02f, 8.41178074e-02f, 5.23125157e-02f, 8.24353620e-02f, 7.06601292e-02f, -1.26028014e-03f, 7.14601427e-02f, -6.78342283e-02f,
  7.49395043e-02f, 8.69937986e-02f, -1.04484774e-01f, -1.46526009e-01f, -6.03353344e-02f, -1.11335948e-01f, -4.58808951e-02f, -1.55884232e-02f, 1.01681381e-01f, -3.16769220e-02f,
  -8.39775614e-03f, 2.60633556e-03f, -9.82122272e-02f, -1.33647397e-01f, 1.01914927e-02f, -1.37789354e-01f, 7.96629488e-02f, 8.54309946e-02f, 6.40302822e-02f, -1.23703759e-02f,
  1.49908513e-01f, 1.47797450e-01f, 1.39546916e-01f, -2.10253969e-02f, -2.05687478e-01f, -1.68148369e-01f, -2.98764836e-02f, -1.31316399e-02f, 1.58102185e-01f, -2.39165332e-02f,
  -2.90399119e-02f, -6.74999654e-02f, -1.06721871e-01f, 7.70589858e-02f, -1.56745657e-01f, 8.10990632e-02f, -1.14416028e-03f, 8.97519141e-02f, 1.76963285e-01f, 2.19392087e-02f,
  -1.01554617e-01f, -1.21176243e-01f, 1.35288477e-01f, -5.87563263e-04f, -6.00725785e-02f, -4.51054908e-02f, -5.59445173e-02f, 4.93101068e-02f, -2.84371506e-02f, 5.84223755e-02f,
  -1.02663532e-01f, 4.09988500e-02f, 1.01648137e-01f, -2.98480615e-02f, -3.31896134e-02f, -3.41904387e-02f, 1.42786205e-02f, 2.20739581e-02f, -1.07344568e-01f, 1.35028496e-01f,
  1.13559902e-01f, -1.52470753e-01f, 1.06876254e-01f, -1.18609227e-01f, 1.81961194e-01f, 1.78780630e-01f, -1.31211638e-01f, -2.04727408e-02f, -1.55160561e-01f, 4.75612916e-02f,
  -9.93529856e-02f, -3.07256132e-01f, 7.48266131e-02f, 1.38337642e-01f, 4.46507707e-02f, 8.29798505e-02f, -4.54200096e-02f, 7.17667341e-02f, 2.20452286e-02f, -7.99586251e-02f,
  7.68782124e-02f, -7.01172650e-02f, 1.89784050e-01f, -1.28198490e-02f, 1.00008719e-01f, 1.07362404e-01f, 1.67120889e-01f, -1.01289593e-01f, -2.50706613e-01f, -1.17142007e-01f,
  1.49342850e-01f, 4.10496071e-02f, 1.63067490e-01f, 1.68628410e-01f, 6.92514703e-02f, 6.69344589e-02f, 6.56774193e-02f, -9.70007777e-02f, 4.89515737e-02f, 8.84091705e-02f,
  -1.01001233e-01f, -2.47184257e-03f, -2.55551059e-02f, 3.38620283e-02f, 6.40215576e-02f, -1.99848190e-02f, -2.16288548e-02f, -3.50631438e-02f, 6.79276139e-02f, -6.35202527e-02f,
  -9.82661322e-02f, 3.80851775e-02f, 8.95291194e-02f, 7.19344169e-02f, 2.70432755e-02f, 2.03344822e-02f, 4.36763354e-02f, 7.02734366e-02f, 2.63973475e-02f, 4.38375399e-02f,
  1.23826554e-03f, 2.34136030e-01f, -1.09873943e-01f, 5.15555553e-02f, 8.10002163e-02f, 2.58269757e-02f, 3.60285956e-03f, 9.61693842e-03f, -1.52891487e-01f, -5.86823970e-02f,
  -1.02329217e-01f, 1.82872228e-02f, -9.19523165e-02f, -1.11144409e-01f, 2.31932685e-01f, 6.16809875e-02f, -8.78174007e-02f, 1.49190843e-01f, 6.67299405e-02f, 6.21872693e-02f,
  7.19648227e-02f, 2.76698247e-02f, -8.76806304e-03f, 6.90508112e-02f, -9.77540314e-02f, 1.85263231e-01f, 1.68813411e-02f, 3.79961990e-02f, 9.10862312e-02f, 1.60814896e-01f,
  -3.60827856e-02f, 1.00972064e-01f, 1.15814582e-01f, -1.37022287e-01f, -9.98726040e-02f, 1.15343899e-01f, -7.63014033e-02f, 1.43962473e-01f, -1.35930002e-01f, 1.26907034e-02f,
  -1.07181609e-01f, 1.24401189e-01f, 4.70214449e-02f, 6.46417886e-02f, -5.80360703e-02f, -7.31085166e-02f, 1.31549528e-02f, -8.64500459e-03f, -7.42872506e-02f, -8.69824886e-02f,
  -1.14012100e-02f, -2.82482691e-02f, -8.20176229e-02f, 2.61019613e-03f, -6.71909526e-02f, -7.60507286e-02f, -1.31945789e-01f, 3.36929336e-02f, 2.87704896e-02f, -1.29462957e-01f,
  -7.39582255e-02f, -2.07139865e-01f, -8.60328153e-02f, -1.55487001e-01f, -2.51043588e-02f, -6.94572181e-02f, 5.44192642e-02f, 5.02979718e-02f, -1.17154904e-01f, -1.47392288e-01f,
  -2.08553020e-02f, 8.41966942e-02f, 1.52138814e-01f, 6.55519143e-02f, 7.74904490e-02f, -8.92819986e-02f, 1.56804308e-01f, 1.57130376e-01f, -8.41429904e-02f, -1.19010061e-01f,
  1.31645769e-01f, 9.70460549e-02f, 1.01885788e-01f, -7.08413646e-02f, -1.19261071e-01f, -5.03807329e-02f, 1.57093853e-01f, 6.04723059e-02f, -3.22922220e-04f, 1.06976822e-01f,
  1.49663329e-01f, 1.26464859e-01f, -2.08945081e-01f, -2.30120532e-02f, -2.49292418e-01f, -2.17112258e-01f, 2.43969262e-02f, 1.61593825e-01f, 1.44170865e-01f, -6.50289580e-02f,
  -8.61344188e-02f, -3.03331893e-02f, 1.72092721e-01f, 1.95032895e-01f, 1.65689066e-01f, 4.94801765e-03f, -2.22472232e-02f, -2.57576052e-02f, -6.08820692e-02f, 6.97779879e-02f,
  -1.11118063e-01f, -1.86491869e-02f, 1.07487909e-01f, -4.98102270e-02f, -4.07854505e-02f, -9.02859867e-02f, 5.28891198e-02f, -3.45307514e-02f, -1.18803799e-01f, -1.84462629e-02f,
  8.89402851e-02f, 7.64873400e-02f, -4.31438908e-02f, 6.68617524e-03f, 7.87613541e-03f, -2.35986318e-02f, 2.85176206e-02f, 2.74657626e-02f, -6.81117922e-02f, 2.25737780e-01f,
  -9.24608558e-02f, 1.13278903e-01f, 9.74199455e-03f, 9.62070376e-02f, -3.27135734e-02f, 1.11037254e-01f, -6.72461987e-02f, 1.40592642e-03f, -2.05309168e-01f, -7.08750263e-02f,
  -1.04539283e-01f, -1.49081349e-01f, 2.35102981e-01f, 1.27643213e-01f, -6.56278208e-02f, -6.68431073e-02f, -3.05894911e-02f, 3.01120859e-02f, 1.19815789e-01f, 6.56274334e-02f,
  4.39752219e-03f, -3.14528495e-02f, -1.21183336e-01f, 8.09362605e-02f, 4.79800105e-02f, -1.12900928e-01f, 7.38868713e-02f, 5.37823550e-02f, 3.49632464e-02f, 2.50583179e-02f,
  8.92023891e-02f, 7.16597354e-03f, -3.57626118e-02f, 9.78695303e-02f, -1.63064003e-02f, 5.19129746e-02f, -1.92583680e-01f, -1.51253596e-01f, -1.62887439e-01f, 1.09948948e-01f,
  1.97587609e-02f, -5.34361415e-02f, -6.71178252e-02f, 9.67113972e-02f, 5.14476839e-03f, -1.58513300e-02f, -1.53309079e-02f, -2.56280117e-02f, 4.94842492e-02f, 3.95596325e-02f,
  1.05100565e-01f, 1.20958015e-01f, 7.72940144e-02f, 3.49808969e-02f, -1.32449651e-02f, -1.55830055e-01f, -1.85670685e-02f, 6.22686073e-02f, 1.74013413e-02f, 2.92037483e-02f,
  1.45384260e-02f, 8.82892013e-02f, 1.02846958e-01f, -2.20768526e-01f, -2.99816281e-02f, -1.36056989e-01f, -4.68076542e-02f, 1.39414072e-01f, -1.17706038e-01f, -5.38901091e-02f,
  -3.93072292e-02f, 6.61902130e-02f, 1.71548679e-01f, 8.63409564e-02f, 8.85669142e-02f, 4.13316227e-02f, -1.96944296e-01f, -1.59876034e-01f, -5.53574972e-02f, 1.35061964e-02f,
  5.82421198e-04f, 5.13874069e-02f, -5.19720390e-02f, 9.23095550e-03f, 5.26565425e-02f, -1.04370713e-01f, -3.77425440e-02f, -3.07820775e-02f, -1.99177954e-02f, -7.18388408e-02f,
  -5.17965034e-02f, -1.01939932e-01f, 8.96948650e-02f, -1.69472601e-02f, -9.85730719e-03f, 7.61649534e-02f, 1.42107621e-01f, -8.36968943e-02f, 1.58972070e-01f, 4.29250374e-02f,
  2.32427612e-01f, -3.30103897e-02f, 1.20452076e-01f, -1.54480459e-02f, 1.33727953e-01f, 5.24582863e-02f, -5.94467798e-04f, -1.72653094e-01f, 4.70133349e-02f, 4.68083471e-02f,
  -8.36046562e-02f, 5.15828617e-02f, -2.42052972e-03f, 4.50004376e-02f, -3.67869809e-02f, -3.11576743e-02f, 1.03186466e-01f, -4.45951801e-03f, 1.62141677e-03f, -1.75690539e-02f,
  1.08592594e-02f, 5.89217655e-02f, 5.97233362e-02f, -5.14411516e-02f, 1.09664258e-02f, -7.70936236e-02f, 5.73166609e-02f, -5.47855459e-02f, -3.63405086e-02f, 1.13855280e-01f,
  -3.83555666e-02f, -1.02631435e-01f, -5.15943440e-03f, 1.80600230e-02f, 1.25430897e-01f, 1.31769270e-01f, -8.36574007e-03f, -1.69326589e-02f, 7.43862465e-02f, 2.93295868e-02f,
  -1.13799535e-01f, -2.42869452e-01f, 1.33555368e-01f, 7.70352595e-03f, 2.90031470e-02f, 3.10739521e-02f, -1.04394764e-01f, 3.76537740e-02f, 4.86613438e-02f, 1.21090598e-02f,
  1.35819793e-01f, -6.52276725e-02f, -4.11059102e-03f, 2.40129028e-02f, 4.42999639e-02f, 8.86888951e-02f, -7.48495609e-02f, -7.37574622e-02f, -9.69104767e-02f, -7.13122189e-02f,
  2.00818449e-01f, -1.10792093e-01f, 1.09945461e-01f, 1.18578210e-01f, 1.88693166e-01f, 8.55892599e-02f, 1.27102807e-01f, -1.04801290e-01f, 2.57929205e-04f, -6.58504218e-02f,
  7.92592987e-02f, 5.76116843e-03f, -5.58845475e-02f, -1.13940656e-01f, 1.66832104e-01f, 1.71126034e-02f, -3.56855989e-02f, -1.35226205e-01f, 5.40890098e-02f, -2.18273178e-02f,
  3.03949937e-02f, 1.21646106e-01f, 8.01273733e-02f, -9.97772254e-03f, 5.83875589e-02f, 1.51198334e-03f, -1.00831427e-01f, -4.35042083e-02f, 5.80178201e-02f, 6.06734082e-02f,
  -8.85098521e-03f, -8.22648313e-03f, 1.54744871e-02f, 1.44389898e-01f, 1.38904691e-01f, 1.03867315e-01f, -3.28299403e-02f, 1.21064603e-01f, -2.79166251e-02f, 4.75323275e-02f,
  -1.02689371e-01f, -1.24385290e-01f, 8.52923095e-02f, -1.07549556e-01f, 1.24219075e-01f, 3.84116694e-02f, -7.02848732e-02f, 6.14006780e-02f, -1.87057436e-01f, 1.71931162e-01f,
  -1.22580998e-01f, -1.12599067e-01f, -1.14032954e-01f, -8.76611173e-02f, -6.78561702e-02f, -1.14207864e-01f, 3.27047557e-02f, -1.72362015e-01f, 3.23365666e-02f, -1.51008010e-01f,
  1.00210205e-01f, 1.95861399e-01f, 8.59691873e-02f, -2.82956623e-02f, -1.83983088e-01f, 2.40720510e-02f, -2.33934987e-02f, 9.62562338e-02f, -1.35437757e-01f, -2.19144598e-01f,
  -1.70392290e-01f, 1.24465421e-01f, 7.70299956e-02f, -2.10497584e-02f, 9.14025530e-02f, -1.10104263e-01f
};

// L2_fan_Wp_bar (Shape: 26 x 64)
const int L2_fan_Wp_bar_rows = 26;
const int L2_fan_Wp_bar_cols = 64;
const float L2_fan_Wp_bar_data[] = {
  6.96000531e-02f, 1.30698802e-02f, 9.20818374e-02f, 4.97454107e-02f, -2.77380366e-02f, 2.29114126e-02f, 9.64610465e-03f, -6.57343417e-02f, 1.97366420e-02f, 4.59850468e-02f,
  1.53259560e-01f, 2.01528579e-01f, 1.13543808e-01f, 8.69380385e-02f, 1.12544864e-01f, 4.07513827e-02f, 4.77730669e-02f, 1.18586145e-01f, -1.45612592e-02f, 2.52933592e-01f,
  6.40369207e-02f, 3.10933143e-02f, 6.01997003e-02f, -1.40383884e-01f, 5.43115623e-02f, 7.18323812e-02f, -1.80253729e-01f, -8.21025148e-02f, 4.34075631e-02f, -1.21250689e-01f,
  9.69528183e-02f, 9.85483602e-02f, 2.17246562e-01f, 1.13679960e-01f, 1.13418967e-01f, 1.25243599e-02f, 1.11435028e-02f, -2.02572048e-01f, 2.17689291e-01f, -1.12324148e-01f,
  -7.81799033e-02f, 1.99997842e-01f, 1.13787182e-01f, 2.88033009e-01f, 8.31377134e-02f, 1.89068735e-01f, 1.83583438e-01f, 1.02503464e-01f, 5.77052571e-02f, -9.45890695e-02f,
  -2.89796200e-02f, -5.97643375e-04f, -9.19576436e-02f, 2.16926903e-01f, -1.55223355e-01f, 2.04144623e-02f, 4.24086787e-02f, 6.25536684e-03f, -1.63950026e-01f, 2.33390838e-01f,
  -1.65375665e-01f, 9.26825181e-02f, -1.76380664e-01f, 2.11177796e-01f, 8.55930224e-02f, 6.53476939e-02f, 8.23661089e-02f, 1.02362238e-01f, 1.28218651e-01f, -2.39621140e-02f,
  -1.50553994e-02f, 1.20452754e-02f, 5.50596192e-02f, 1.43905863e-01f, 1.12839624e-01f, 1.06127657e-01f, 1.02304310e-01f, 9.97068733e-02f, 9.96838361e-02f, 8.09066594e-02f,
  8.64100307e-02f, 1.12135825e-03f, -2.27356725e-03f, 1.65983126e-01f, 8.84491950e-02f, 3.23615313e-01f, -1.16143897e-01f, -2.73785919e-01f, 2.51261204e-01f, -6.83847740e-02f,
  3.15184728e-03f, 1.12830013e-01f, -1.87542111e-01f, 6.91236556e-02f, -1.74484849e-01f, -1.00316763e-01f, 1.37087598e-01f, -1.41602159e-01f, 1.15218855e-01f, -8.93187001e-02f,
  -1.43922061e-01f, 1.43625680e-03f, 1.52962103e-01f, 5.83729744e-02f, 1.47453815e-01f, 9.48777273e-02f, 1.22985080e-01f, 1.18666761e-01f, 6.96220547e-02f, 1.51749432e-01f,
  1.90501794e-01f, 2.61238873e-01f, 3.39360386e-02f, 7.13820010e-02f, -8.39305222e-02f, -1.75296351e-01f, 7.83800185e-02f, 1.47356659e-01f, 6.34997264e-02f, 1.18004128e-01f,
  -5.56213632e-02f, 7.46595189e-02f, 8.76084045e-02f, 5.05729280e-02f, -3.37899178e-02f, 1.12928428e-01f, -5.48067689e-02f, 2.34709248e-01f, -3.35702300e-02f, -5.08378819e-02f,
  2.47065034e-02f, -5.78595474e-02f, 1.31360069e-01f, 6.21378720e-02f, 7.80797079e-02f, 3.24761979e-02f, -2.02556653e-03f, 1.49968341e-01f, -1.11689866e-01f, 2.67228261e-02f,
  4.55280840e-02f, 1.18110061e-01f, 2.92531364e-02f, 2.23663785e-02f, 2.28436850e-02f, 1.72843207e-02f, 4.56104837e-02f, -1.94225192e-01f, -1.11290507e-01f, -1.42828122e-01f,
  -4.86685187e-02f, 1.64672673e-01f, -6.35764152e-02f, 1.28050009e-03f, 4.81716208e-02f, -1.31004289e-01f, 1.46379843e-01f, 1.92103028e-01f, -8.72919410e-02f, -8.80577043e-02f,
  -6.80845827e-02f, 1.11573115e-01f, -1.16195023e-01f, -1.49501607e-01f, -9.96748358e-02f, 1.42474964e-01f, 8.12453106e-02f, 1.34489760e-01f, 6.08829185e-02f, -1.25106797e-01f,
  -7.69644007e-02f, -2.24977240e-01f, -1.00278400e-01f, -8.23757499e-02f, -5.29254675e-02f, -5.60589246e-02f, 2.46426389e-02f, 1.55962080e-01f, 2.32009262e-01f, 1.29919559e-01f,
  4.80919369e-02f, -6.10989844e-03f, 3.95819545e-02f, 6.19658083e-02f, 1.98456328e-02f, 4.12778109e-02f, 1.34107500e-01f, -6.49069250e-02f, 2.72114813e-01f, -4.76119705e-02f,
  2.38583222e-01f, -9.22291279e-02f, 1.38531789e-01f, 4.20074584e-03f, -2.81826369e-02f, -3.13725695e-02f, 7.47142211e-02f, 1.30232334e-01f, 5.78894280e-02f, 5.22157252e-02f,
  3.73017490e-02f, 4.68535125e-02f, -1.57611594e-01f, -2.35223435e-02f, -1.45565262e-02f, 1.09947547e-02f, 3.34718847e-03f, 7.62105882e-02f, 1.75248738e-02f, -1.76815297e-02f,
  1.30565614e-01f, -1.90081030e-01f, -9.81120169e-02f, -7.66618177e-02f, 3.72042246e-02f, 8.96063522e-02f, 1.26632482e-01f, -1.35117248e-01f, 6.67495057e-02f, 1.19689718e-01f,
  2.45009497e-01f, 1.30167142e-01f, -6.33503199e-02f, 6.43649176e-02f, -1.71237677e-01f, -1.28146768e-01f, -5.27636595e-02f, 7.49849975e-02f, 4.49019670e-02f, -3.08967866e-02f,
  -1.44390076e-01f, -2.40379311e-02f, 1.02975098e-02f, 6.82753101e-02f, 1.76964179e-02f, 1.24500301e-02f, 1.74529642e-01f, -4.05145735e-02f, -6.12639636e-02f, -1.20767988e-01f,
  2.55670458e-01f, -1.27958748e-02f, -1.92994133e-01f, 4.61965846e-03f, 1.44701764e-01f, 1.01723239e-01f, 1.45212486e-01f, 7.85249174e-02f, 1.52033642e-01f, 1.65989101e-01f,
  2.79876530e-01f, -4.06076424e-02f, 1.10198401e-01f, 2.03941733e-01f, 5.32599054e-02f, -2.01720104e-01f, -3.77410650e-02f, -1.23651205e-02f, 6.83130175e-02f, -3.92583944e-02f,
  4.65757586e-02f, 1.07592647e-03f, 4.77800891e-03f, 1.01366855e-01f, -5.66570759e-02f, 7.11222092e-05f, -6.06234465e-03f, -1.90061349e-02f, 6.81867748e-02f, -3.73818688e-02f,
  -8.53629634e-02f, 1.67692378e-02f, 1.30209159e-02f, 4.56656702e-02f, 3.46623212e-02f, -1.12938553e-01f, -1.02844007e-01f, -1.38931885e-01f, -1.35189146e-01f, 1.13493077e-01f,
  -6.23678342e-02f, -2.14185193e-02f, -1.88273173e-02f, -1.63071930e-01f, 1.29323751e-01f, 2.19352409e-01f, -1.26247972e-01f, -7.09963143e-02f, -4.62842509e-02f, 1.80959493e-01f,
  -5.65909892e-02f, -6.92819282e-02f, -3.62344855e-03f, 2.81747896e-02f, 2.16897093e-02f, 6.40274510e-02f, 1.52351648e-01f, -5.35907447e-02f, 7.96793625e-02f, -1.27104074e-01f,
  -8.29040781e-02f, -3.69876176e-02f, -7.65325949e-02f, -1.26820982e-01f, -7.11159259e-02f, 1.68305174e-01f, 2.01833963e-01f, 1.86122671e-01f, -1.51893720e-02f, 6.20060414e-02f,
  7.53408819e-02f, -1.41619127e-02f, -9.75028574e-02f, -1.10607734e-02f, 8.96931887e-02f, -6.10021278e-02f, 1.36677355e-01f, -6.12904876e-02f, 1.35777354e-01f, -3.25969746e-03f,
  -1.03205452e-02f, -1.14849657e-01f, -9.07987878e-02f, 3.89735252e-02f, -3.86303179e-02f, -1.26397982e-01f, 3.79371643e-03f, -3.31366993e-02f, 5.73919900e-02f, -4.71901633e-02f,
  -7.94451311e-02f, -1.00385576e-01f, 2.02135947e-02f, 1.98642910e-02f, -1.33766234e-02f, 1.39963282e-02f, -7.22539201e-02f, 1.22784607e-01f, 2.02354919e-02f, -1.56873137e-01f,
  4.86136861e-02f, -1.91851854e-01f, 6.63314238e-02f, 5.08707836e-02f, -1.76740035e-01f, -2.57544331e-02f, -1.21587537e-01f, -1.26445949e-01f, 2.44640373e-02f, -1.02885410e-01f,
  7.36320168e-02f, -8.13687667e-02f, -1.44583166e-01f, 2.48989686e-01f, 8.10892030e-04f, -1.35170221e-01f, -7.73663968e-02f, -3.46662626e-02f, 6.68219943e-03f, 8.11645463e-02f,
  7.81241506e-02f, -1.34541154e-01f, 8.33457559e-02f, -2.08715945e-01f, -1.31681532e-01f, -7.84202889e-02f, -1.63452908e-01f, -2.83150613e-01f, 1.54523402e-01f, 8.56456533e-02f,
  1.94780126e-01f, 1.84235379e-01f, -9.57165435e-02f, -2.52571046e-01f, 1.77601574e-03f, -1.40590310e-01f, 2.38826424e-01f, 1.24914069e-02f, 3.74945290e-02f, 1.22459784e-01f,
  8.19148347e-02f, -6.07120916e-02f, 1.37573496e-01f, -1.01268440e-01f, -1.07719503e-01f, 1.25900833e-02f, 3.97444516e-02f, 8.14269483e-03f, 1.02699958e-02f, 1.30085528e-01f,
  2.16361713e-02f, -9.47458893e-02f, 3.51569690e-02f, 9.55130905e-02f, 8.58900230e-03f, 1.58562541e-01f, 6.15403429e-02f, 2.72566713e-02f, 1.44861430e-01f, 3.99965458e-02f,
  2.29350701e-02f, -1.47109225e-01f, 1.29513908e-02f, 2.68527474e-02f, 7.45967329e-02f, 1.33527339e-01f, -9.20987949e-02f, -2.32890248e-01f, 6.19312078e-02f, 1.31525353e-01f,
  1.49019986e-01f, -5.44081815e-02f, -1.09238893e-01f, 5.94723336e-02f, -1.33680897e-02f, 3.58224660e-02f, 1.06207922e-01f, -4.91578802e-02f, 1.79088384e-01f, -1.00981526e-01f,
  -8.57198015e-02f, 7.39723817e-02f, 1.75169110e-01f, 8.25481117e-02f, 2.12929130e-01f, 1.32785961e-01f, 1.19718529e-01f, 1.08853571e-01f, 8.34250301e-02f, 1.50090992e-01f,
  6.28432855e-02f, 2.09684730e-01f, -2.76118666e-01f, -2.46438738e-02f, 7.47424588e-02f, 5.72456121e-02f, 1.89835697e-01f, 1.56548932e-01f, -1.15742665e-02f, 7.47859553e-02f,
  -2.51067709e-02f, -1.69433281e-02f, 7.20191896e-02f, 1.09105390e-02f, 1.05532132e-01f, -6.14998676e-02f, 1.44863985e-02f, 3.33379537e-01f, -3.41433696e-02f, 2.44871024e-02f,
  -3.64924073e-02f, 1.16915181e-01f, -2.14801013e-01f, -2.08952464e-02f, 3.81892771e-02f, -1.28195137e-01f, -1.15707055e-01f, -4.87045124e-02f, 3.82445380e-02f, -4.46533188e-02f,
  -2.33877115e-02f, -5.10808527e-02f, -9.05955508e-02f, -1.37973353e-01f, -7.51397386e-02f, 1.19528454e-02f, -6.75075576e-02f, 1.89731698e-02f, 1.11017615e-01f, -1.94148630e-01f,
  -1.55059025e-01f, -5.90276904e-02f, -1.16882280e-01f, 7.09688291e-02f, -4.16839756e-02f, -8.36887062e-02f, 1.42616853e-01f, -8.22755247e-02f, 2.11205259e-01f, 5.71828708e-02f,
  -1.06463350e-01f, 1.28396988e-01f, 1.56795055e-01f, -1.04216658e-01f, 2.67897286e-02f, -8.71995911e-02f, -3.71270999e-02f, -1.03722543e-01f, 4.86706384e-02f, -5.16301394e-03f,
  1.71938971e-01f, -1.09810401e-02f, -8.64324644e-02f, 1.98672503e-01f, -4.24303301e-03f, -1.85230598e-02f, -2.59695888e-01f, -4.58475202e-02f, 2.33000129e-01f, 1.23593479e-01f,
  -8.62696767e-02f, -1.62587360e-01f, -1.67756587e-01f, -2.04597667e-01f, 1.29199281e-01f, 7.50954375e-02f, -4.59137335e-02f, 1.38962343e-01f, -1.41121432e-01f, -1.21573679e-01f,
  -3.78025919e-02f, 4.60687988e-02f, -5.83461393e-03f, 4.00999822e-02f, -4.86237518e-02f, 1.10589005e-01f, 2.93620839e-03f, 6.96171299e-02f, 5.08494787e-02f, 3.74921486e-02f,
  -2.16286164e-02f, 9.32790637e-02f, 1.61512289e-02f, 1.54856667e-01f, 3.88742462e-02f, 1.29716843e-02f, 4.82313372e-02f, -6.80146292e-02f, 9.53492969e-02f, -1.49154767e-01f,
  6.73439577e-02f, -3.63475569e-02f, 1.19320415e-02f, 3.04681323e-02f, -1.50226578e-01f, -2.59037942e-01f, -3.85994464e-02f, 1.24066927e-01f, 2.73626506e-01f, 1.27421781e-01f,
  -4.02469700e-03f, -1.02093615e-01f, 1.45755321e-01f, 1.57500327e-01f, -8.20700824e-02f, -2.64390230e-01f, 2.99150407e-01f, -1.68917149e-01f, -1.42768130e-01f, -5.23699783e-02f,
  -9.58235562e-02f, 2.27365166e-01f, 1.63161054e-01f, 1.00988641e-01f, 2.48572424e-01f, 4.21524495e-02f, 2.02502176e-01f, 2.17059702e-01f, 1.20569892e-01f, 1.27257288e-01f,
  -1.95063829e-01f, -1.66809291e-01f, 1.18390983e-03f, 1.46863326e-01f, 2.83118486e-01f, -1.75829381e-01f, 2.75916960e-02f, 1.56564843e-02f, 2.09188208e-01f, 2.23121420e-01f,
  2.09839344e-01f, 8.10736641e-02f, -4.82150503e-02f, -9.52448398e-02f, -3.74350585e-02f, 2.41913840e-01f, 1.08132280e-01f, -1.92637853e-02f, -1.50587738e-01f, -3.28679718e-02f,
  4.30557914e-02f, 5.98621033e-02f, 1.29835382e-01f, 1.12228170e-01f, -2.96201389e-02f, 1.89359076e-02f, -3.06855235e-03f, 7.12579191e-02f, 4.73794751e-02f, -1.23203002e-01f,
  -7.12282285e-02f, 3.61356847e-02f, -9.32315141e-02f, 3.95005420e-02f, 8.95938575e-02f, 3.75421271e-02f, 1.57532804e-02f, -1.05652533e-01f, 2.12180674e-01f, 4.38196585e-02f,
  6.02770858e-02f, 6.85197785e-02f, -1.37898058e-01f, 1.32556006e-01f, -1.78952292e-02f, -1.68448985e-01f, 2.08540484e-01f, 2.93601036e-01f, 2.23568425e-01f, 2.02627070e-02f,
  -1.92722395e-01f, 3.56852800e-01f, 2.23320842e-01f, -1.40438071e-02f, -5.86060807e-02f, -1.60294384e-01f, -8.27155542e-03f, 1.47534028e-01f, -2.00672224e-01f, 1.82018667e-01f,
  1.98500708e-01f, -1.87422018e-02f, -8.99173170e-02f, -5.61615638e-02f, 1.82576478e-01f, -5.91638871e-02f, -1.27873823e-01f, -1.00788772e-01f, -5.97682372e-02f, 3.01783860e-01f,
  -6.68908805e-02f, -8.94423760e-03f, -4.07978930e-02f, 1.09736316e-01f, -5.61160818e-02f, 1.60603393e-02f, -7.87152052e-02f, 3.18558455e-01f, 2.48904135e-02f, -1.65217906e-01f,
  -3.06152645e-02f, -9.42451414e-03f, 1.04463264e-01f, -6.13864213e-02f, 1.06948219e-01f, 9.94394571e-02f, 7.87043571e-02f, 1.08599581e-01f, 6.01085946e-02f, 1.28555134e-01f,
  -1.03505947e-01f, 5.49421180e-03f, 1.20762676e-01f, 3.87402512e-02f, -6.55587465e-02f, 1.56636611e-02f, 2.54408997e-02f, 1.02723809e-02f, 1.30746782e-01f, -2.16665000e-01f,
  -4.42596897e-03f, -5.77222854e-02f, 1.01791034e-02f, 1.58965960e-01f, -2.51514286e-01f, 8.33318681e-02f, -5.13467304e-02f, -4.21495698e-02f, 7.97608793e-02f, -1.40939429e-02f,
  9.15986076e-02f, 2.77518444e-02f, -7.88356662e-02f, 1.53179824e-01f, -4.18736301e-02f, -1.55247912e-01f, -4.16635051e-02f, 1.24070100e-01f, -8.15867111e-02f, 1.89769000e-01f,
  3.97832990e-02f, -1.41301319e-01f, -4.41682898e-02f, -2.82801598e-01f, -7.17061684e-02f, -9.30933729e-02f, -9.01232958e-02f, -1.27330601e-01f, 8.67363960e-02f, 1.37947723e-01f,
  2.04433993e-01f, 1.56582668e-01f, 9.15092900e-02f, -1.68753177e-01f, 1.05591051e-01f, 6.19123168e-02f, 1.25588879e-01f, 8.15499797e-02f, 1.54445395e-01f, -2.30968781e-02f,
  2.23751813e-01f, -6.30050972e-02f, 3.97148073e-01f, 7.51374150e-03f, -1.03168152e-01f, 4.95823054e-03f, 2.42569530e-03f, 2.64620092e-02f, -2.26899032e-02f, 8.04663301e-02f,
  8.17902535e-02f, 1.34552151e-01f, -4.35759488e-04f, 3.15475240e-02f, -1.08466804e-01f, -4.53945436e-03f, -1.03747360e-02f, 7.16558173e-02f, 1.61875636e-04f, 4.94720489e-02f,
  -7.20096007e-02f, -1.06287390e-01f, 3.88410389e-02f, -2.12413430e-01f, -1.58557266e-01f, -3.35347578e-02f, -1.16653398e-01f, 8.10185224e-02f, -1.39802247e-01f, 1.74510553e-02f,
  1.76984176e-01f, 4.98371245e-03f, 6.95029348e-02f, 8.42121020e-02f, 5.51499845e-03f, 6.52087620e-03f, -1.59748510e-01f, 4.19566594e-02f, -9.40708816e-03f, -1.39028104e-02f,
  -1.14116602e-01f, 1.29493609e-01f, -1.04151510e-01f, 1.98394001e-01f, 2.08113626e-01f, -1.36603639e-01f, 6.86987787e-02f, -6.32577464e-02f, 3.36597092e-04f, -1.20529085e-01f,
  -1.14765048e-01f, 4.93902005e-02f, 2.78957020e-02f, 1.32818282e-01f, 1.26560405e-01f, 2.54338473e-01f, 8.42186660e-02f, 7.31426179e-02f, -1.82264503e-02f, 1.30092189e-01f,
  8.75806957e-02f, 1.04605285e-02f, 1.97379440e-01f, -9.14609879e-02f, 2.19705790e-01f, -1.41241729e-01f, 2.25106061e-01f, 8.94046053e-02f, 1.40813598e-02f, 8.54669511e-03f,
  1.14173360e-01f, 1.57683671e-01f, 5.89685403e-02f, -1.62884705e-02f, 1.20958239e-01f, 4.37767208e-02f, 9.02825668e-02f, 1.60838321e-01f, 7.28508607e-02f, -4.48031276e-02f,
  4.42770123e-02f, 9.09964144e-02f, 2.03036703e-02f, 1.38375267e-01f, 9.68596935e-02f, 2.24735469e-01f, 7.49710128e-02f, 2.11047307e-02f, 3.32338899e-01f, -1.80082202e-01f,
  7.41268396e-02f, -2.31359869e-01f, -1.29090637e-01f, 1.56600192e-01f, -1.28209397e-01f, -1.36254892e-01f, 1.43729791e-01f, -2.65562922e-01f, 3.01606476e-01f, 1.38382286e-01f,
  2.92507727e-02f, 2.82454759e-01f, 8.58838633e-02f, -1.12861441e-02f, -5.19036464e-02f, -1.30728170e-01f, 1.30501464e-01f, 2.12148819e-02f, -1.22954294e-01f, 1.78965032e-01f,
  1.65160820e-01f, 1.01375379e-01f, -7.14237466e-02f, 2.00407103e-01f, 1.11031592e-01f, -1.20929815e-01f, -4.36286367e-02f, -1.50705427e-01f, 1.07622743e-01f, 1.85822815e-01f,
  -7.86004514e-02f, -4.44648489e-02f, -3.03885285e-02f, -1.87469676e-01f, 2.43220985e-01f, 7.56815150e-02f, -2.09340751e-02f, 2.17403188e-01f, -9.22814384e-02f, 9.63823795e-02f,
  2.02295631e-01f, 1.82235539e-01f, 1.36558712e-01f, -4.76882011e-02f, 2.19360381e-01f, 2.12356567e-01f, 1.10414900e-01f, 6.85188025e-02f, -3.68912914e-03f, -6.74809236e-03f,
  2.37572581e-01f, 7.57115111e-02f, 3.85239795e-02f, -5.37908450e-03f, 1.73112646e-01f, 5.21172024e-02f, 1.67760313e-01f, -1.95412640e-03f, 1.41224027e-01f, 1.40107930e-01f,
  1.15510970e-01f, 7.90790766e-02f, 3.64604622e-01f, 1.20879278e-01f, 1.80877343e-01f, -5.85696138e-02f, -1.53577819e-01f, 1.32700861e-01f, -3.33368815e-02f, 2.39099216e-04f,
  3.58665623e-02f, -3.07979256e-01f, 3.82270306e-01f, 1.25018820e-01f, 7.58159757e-02f, 1.49162099e-01f, -3.00936718e-02f, -1.48774803e-01f, -1.75068393e-01f, 1.18193578e-03f,
  1.45644844e-02f, -5.46349399e-02f, -1.65133744e-01f, -7.20811337e-02f, 1.80379674e-01f, -1.90368816e-01f, -6.17162287e-02f, 3.29672545e-02f, 1.42085195e-01f, -5.04234247e-03f,
  1.69407174e-01f, -3.96429654e-03f, 7.16713369e-02f, -2.12750845e-02f, -3.99512704e-03f, -2.65557200e-01f, 2.31695711e-03f, -4.05927375e-02f, 2.41437748e-01f, 6.28942996e-02f,
  -8.73555616e-02f, 8.76096264e-02f, -1.44190058e-01f, -1.07683107e-01f, 3.71313602e-01f, 2.60836363e-01f, -8.56022090e-02f, 7.29328170e-02f, -6.69346377e-02f, -4.31661867e-02f,
  -3.07577681e-02f, 1.10322200e-01f, -6.07884042e-02f, 6.55408278e-02f, 8.18637460e-02f, 8.14364329e-02f, 4.91959834e-03f, -4.43675965e-02f, -2.69927550e-02f, 1.46487385e-01f,
  -6.25639269e-03f, 5.90648092e-02f, -6.45777732e-02f, -4.66499440e-02f, 1.46069052e-02f, -2.00888991e-01f, -2.17695668e-01f, -2.17440017e-02f, -1.48303062e-01f, 1.56331524e-01f,
  -1.82074513e-02f, -2.21888199e-01f, 5.94884828e-02f, 2.28834599e-02f, 1.12855323e-01f, 3.79293650e-01f, -2.87630022e-01f, -1.97693720e-01f, -2.57024139e-01f, -1.76216096e-01f,
  -1.12811916e-01f, -1.62977964e-01f, -2.29862202e-02f, 4.87066805e-02f, 1.55673316e-02f, 9.56446305e-02f, 1.82265952e-01f, -4.09346968e-02f, -7.59504177e-03f, -1.43404096e-01f,
  -7.66107515e-02f, 1.48677174e-02f, -9.24715400e-02f, -3.73958573e-02f, -1.47494162e-02f, 1.53479740e-01f, -8.98529813e-02f, 6.28426820e-02f, 1.16308019e-01f, 4.51338701e-02f,
  1.05946086e-01f, 1.11109957e-01f, 5.82919009e-02f, -1.84988454e-02f, 1.97262585e-01f, -2.41228461e-01f, 1.63954318e-01f, -4.06240150e-02f, 3.08665130e-02f, -1.43362269e-01f,
  5.95852546e-02f, 7.79703856e-02f, 3.51423658e-02f, 7.84939751e-02f, 6.76964521e-02f, 3.14880013e-02f, 2.87017804e-02f, 3.61867025e-02f, 9.04814061e-03f, 7.54504204e-02f,
  4.84335572e-02f, 6.90456256e-02f, 1.16403826e-01f, 8.21225867e-02f, 1.39481887e-01f, 6.08414114e-02f, 5.10981083e-02f, -3.93533036e-02f, -7.05301464e-02f, -1.34742325e-02f,
  4.40738946e-02f, 8.68976936e-02f, -1.09636188e-01f, -1.91000149e-01f, 8.50092098e-02f, -3.87975983e-02f, 6.92297369e-02f, 9.41442177e-02f, 1.07875161e-01f, 5.06012328e-02f,
  2.19577551e-02f, 1.08825723e-02f, -7.92093799e-02f, -1.73921511e-01f, 1.27229750e-01f, -8.68424475e-02f, -1.23896301e-02f, -5.92218935e-02f, 1.82606533e-01f, 1.55083165e-01f,
  6.27224520e-02f, 1.10496722e-01f, 1.23158798e-01f, 1.22229427e-01f, -1.23148309e-02f, 1.25068262e-01f, 9.21847895e-02f, 1.28588215e-01f, -7.04953223e-02f, -4.03219536e-02f,
  -3.59282494e-02f, 4.63056052e-03f, 1.15305357e-01f, 2.40057125e-03f, 5.72613850e-02f, 3.91811430e-02f, 6.97467253e-02f, 1.65934965e-01f, 2.03926891e-01f, 1.59932952e-02f,
  -5.28573282e-02f, 3.69232800e-03f, -1.42295405e-01f, 2.07104683e-01f, 1.01880006e-01f, 6.30097836e-02f, 4.00841385e-02f, -7.55192246e-03f, 1.26655325e-01f, 5.23900613e-02f,
  -3.91302221e-02f, 9.65534300e-02f, 6.31979331e-02f, 4.90555838e-02f, -2.40577944e-02f, 5.75877912e-02f, 1.08440332e-02f, 1.07527375e-01f, 1.40861526e-01f, 4.81765345e-02f,
  1.03179038e-01f, -1.19668655e-01f, 4.94178012e-02f, -2.56304890e-02f, -3.23469117e-02f, 2.02476636e-01f, -1.12149201e-01f, -2.62089312e-01f, -1.20172780e-02f, -1.52015476e-03f,
  2.22812623e-01f, 2.22752273e-01f, 1.13183744e-01f, 1.01881474e-01f, 4.83673513e-02f, 9.12633985e-02f, -1.84059575e-01f, -2.50983417e-01f, 2.35909015e-01f, -7.47662596e-03f,
  -5.75777143e-02f, 4.85448986e-02f, -1.26642033e-01f, 2.24998638e-01f, 1.23996697e-01f, -4.69803475e-02f, 2.16393188e-01f, 9.31790397e-02f, 9.74988788e-02f, 1.35948151e-01f,
  2.56332140e-02f, 1.38265178e-01f, -1.24630697e-01f, -1.01471134e-01f, -1.85689747e-01f, -1.76765248e-02f, 2.64289260e-01f, 3.02954428e-02f, -6.51955372e-03f, -3.64210829e-02f,
  1.30623177e-01f, 1.27810225e-01f, 2.36210257e-01f, -1.19794562e-01f, 1.09923169e-01f, 4.08712924e-02f, 9.94319469e-02f, 1.68504849e-01f, 9.51136202e-02f, 8.46651345e-02f,
  6.70346469e-02f, -8.83308351e-02f, -2.78954171e-02f, 4.61146794e-02f, 1.44417673e-01f, 6.34959936e-02f, 1.66084711e-02f, 9.82936472e-02f, 1.37017936e-01f, 1.69423118e-01f,
  2.38676425e-02f, -6.03668392e-02f, 9.19472203e-02f, 1.44022554e-01f, 4.90663946e-02f, 1.09143831e-01f, 5.42277955e-02f, 1.47919953e-01f, 7.67268091e-02f, -1.83673222e-02f,
  1.40510306e-01f, -4.61917892e-02f, 6.55894205e-02f, 2.60018129e-02f, -3.32427442e-01f, -9.70996767e-02f, 3.26024257e-02f, -1.48418084e-01f, 1.70291308e-02f, 6.22243807e-02f,
  3.01800787e-01f, 2.73504823e-01f, -9.97942686e-02f, 4.19233082e-04f, 2.31066458e-02f, -1.85530692e-01f, 1.01213776e-01f, -1.73751280e-01f, -8.04678723e-02f, 1.92552552e-01f,
  5.63184097e-02f, 1.52523115e-01f, -1.01162560e-01f, 1.51483983e-01f, 1.89498916e-01f, -9.27470326e-02f, 1.43172279e-01f, -2.29950319e-03f, 5.37434705e-02f, 5.82764111e-02f,
  -2.30151489e-01f, 7.44123161e-02f, -3.28464583e-02f, -4.91057262e-02f, -7.19387829e-03f, 1.47743464e-01f, -1.80370495e-01f, 1.38710052e-01f, -1.09754413e-01f, 1.59273818e-01f,
  -2.23210845e-02f, -5.64966910e-02f, 3.08767892e-02f, -4.34560701e-04f, 3.89622874e-03f, 2.42061820e-02f, 1.40795246e-01f, 1.20705590e-01f, 1.36219993e-01f, 4.15723361e-02f,
  1.59097254e-01f, 1.06863305e-01f, 5.32498471e-02f, 3.93795632e-02f, 1.89829916e-01f, -4.97373044e-02f, 9.59682558e-03f, -5.53486608e-02f, 8.21056664e-02f, 7.02512413e-02f,
  4.15533558e-02f, -3.28754894e-02f, 3.47236991e-01f, -1.50976360e-01f, 6.85477257e-02f, -7.45376721e-02f, -9.20284241e-02f, 1.27736628e-01f, -1.26292691e-01f, -4.85999696e-02f,
  7.73036554e-02f, -3.23131740e-01f, 3.63156706e-01f, 2.34970823e-01f, -1.39728775e-02f, 2.13035792e-01f, 7.80415982e-02f, -1.01848789e-01f, 2.47058664e-02f, -6.69994652e-02f,
  -3.82756889e-02f, 2.16770824e-02f, -1.32107645e-01f, 1.56612754e-01f, 1.76759750e-01f, -2.97160652e-02f, -1.37328170e-02f, 2.47354120e-01f, -1.10182008e-02f, -1.47012442e-01f,
  1.83219314e-01f, -1.81975842e-01f, 1.94537371e-01f, 1.71861768e-01f, 1.22750364e-02f, -1.59233570e-01f, -2.82024266e-03f, -2.04570934e-01f, 3.06897104e-01f, 2.39351138e-01f,
  -8.93333089e-03f, 1.20671578e-01f, -1.09053642e-01f, 1.53967543e-02f, 2.98667759e-01f, 7.51229897e-02f, -3.63109857e-02f, 7.84577206e-02f, 1.75792396e-01f, -4.86185029e-03f,
  -4.63417657e-02f, -3.17930914e-02f, 1.18267618e-01f, 7.81320557e-02f, -1.74712539e-02f, 9.45605412e-02f, 7.63076469e-02f, 5.35454378e-02f, -2.80773193e-02f, 1.86245586e-03f,
  3.92342210e-02f, 3.09509840e-02f, 6.71383459e-04f, 2.14740053e-01f, 6.24450482e-02f, 6.22788928e-02f, -1.24075487e-01f, -1.77697539e-01f, 1.32526755e-01f, 2.68157095e-01f,
  6.35574060e-03f, -7.93857351e-02f, -2.95179456e-01f, -3.88624258e-02f, -1.95141379e-02f, -5.48786372e-02f, -2.25496754e-01f, -1.91249803e-01f, 2.27707416e-01f, 2.04557896e-01f,
  -2.57160425e-01f, -5.20837829e-02f, 3.91427986e-02f, -4.27037627e-02f, 2.40182757e-01f, -1.00340070e-02f, 6.48768246e-02f, 5.35486639e-02f, -1.11162119e-01f, 1.35291204e-01f,
  5.99513575e-02f, 1.68129187e-02f, 5.16393594e-02f, -1.61173046e-02f, 2.84312040e-01f, 2.13026464e-01f, 2.08042428e-01f, 1.01059869e-01f, -1.39079362e-01f, 2.62357146e-01f,
  7.85258263e-02f, 5.05098999e-02f, -1.68037727e-01f, -3.63928974e-02f, -1.25588551e-01f, 1.14483275e-01f, 9.67208073e-02f, 6.64457083e-02f, -1.62073248e-03f, -1.13752693e-01f,
  -5.24220169e-02f, 5.49343675e-02f, -9.03609544e-02f, -9.32495445e-02f, -1.06465943e-01f, 1.69655129e-01f, 1.58282593e-01f, 7.68186972e-02f, -8.32553357e-02f, 2.18243245e-02f,
  2.42971312e-02f, 7.27530345e-02f, 1.26273483e-01f, -5.95383383e-02f, -7.99958855e-02f, 1.05501022e-02f, -8.61271471e-02f, 1.00297935e-01f, -2.54464932e-02f, -8.59471858e-02f,
  -8.66535306e-02f, -3.49937320e-01f, -1.71427980e-01f, 9.85002443e-02f, -1.16428301e-01f, 1.02822080e-01f, -1.63033351e-01f, -2.16763198e-01f, 2.85530508e-01f, -5.66124963e-03f,
  5.47338389e-02f, 1.28066227e-01f, 8.72436389e-02f, 3.16958100e-01f, 6.41909167e-02f, 2.17345729e-02f, 1.89534128e-01f, -1.33962616e-01f, 6.12099282e-02f, 3.51999477e-02f,
  2.16137335e-01f, 1.30129397e-01f, -3.26504931e-02f, 2.15993688e-01f, -7.24077374e-02f, 1.13423698e-01f, -2.22532228e-01f, -1.08662084e-01f, -1.81984723e-01f, -1.67058799e-02f,
  3.14259559e-01f, 4.29831803e-01f, -4.00406718e-02f, 2.02624753e-01f, -2.93810308e-01f, -1.04391184e-02f, 1.11026347e-01f, 2.46036351e-01f, 8.67138579e-02f, 9.64990407e-02f,
  2.20998317e-01f, -1.12523369e-01f, -1.71312261e-02f, -8.57816357e-03f, 1.19779594e-02f, 3.14568169e-02f, 6.68912455e-02f, 7.32008740e-02f, 5.69058955e-02f, 6.39815181e-02f,
  7.24181682e-02f, 2.78564915e-02f, 9.50502530e-02f, 1.31011996e-02f, -7.13447183e-02f, -2.69845081e-03f, 6.09896071e-02f, 1.14255361e-01f, 1.55895412e-01f, 7.69372284e-02f,
  1.03042349e-01f, -7.06752539e-02f, 1.19350508e-01f, -1.15869112e-01f, -2.02892855e-01f, 1.68874338e-01f, -1.38028383e-01f, -7.21467659e-02f, 2.06420049e-01f, -6.16732091e-02f,
  2.77494788e-01f, 2.58004576e-01f, -7.65827065e-03f, 1.61457166e-01f, -2.41247788e-01f, -1.56147510e-01f, -8.01725835e-02f, -2.85424709e-01f, 7.50358701e-02f, -1.81170359e-01f,
  -1.66278079e-01f, 1.47839546e-01f, 9.72959995e-02f, 5.65305427e-02f, 2.28946418e-01f, -8.49509761e-02f, 4.52966020e-02f, -3.72643434e-02f, 1.69630557e-01f, -6.31689951e-02f,
  1.34594440e-01f, 1.49865225e-01f, -3.47939432e-02f, 1.76928997e-01f, -2.27717012e-01f, -3.49809602e-02f, 1.38252705e-01f, 2.22266600e-01f, 2.31836319e-01f, 2.02470899e-01f,
  6.88053519e-02f, 1.50087938e-01f, 1.01422228e-01f, -6.04925258e-03f, 2.00041771e-01f, 7.14212731e-02f, -7.50551596e-02f, 9.70970988e-02f, 1.43593550e-01f, -4.67876941e-02f,
  1.20191798e-01f, 5.28563522e-02f, 4.98035960e-02f, 8.76552053e-03f, 8.24348703e-02f, -1.64326020e-02f, 1.02550343e-01f, 1.24893375e-01f, 9.02205184e-02f, 2.55572293e-02f,
  -4.73160902e-03f, 1.47336677e-01f, 7.37213939e-02f, 1.57912776e-01f, 7.10542798e-02f, 1.22680292e-01f, -1.37226107e-02f, 1.44143552e-01f, -7.91598484e-03f, 1.85119376e-01f,
  7.43886605e-02f, -4.27718535e-02f, 1.26143485e-01f, -1.96318496e-02f, -1.17222019e-01f, 1.23232521e-01f, -1.14279270e-01f, 3.62137333e-02f, -1.21175535e-01f, -5.56447841e-02f,
  1.84025511e-01f, -1.09540418e-01f, -8.81815627e-02f, 2.34136358e-02f, -1.96981356e-02f, 2.16681361e-02f, 1.38191327e-01f, 6.24560658e-03f, 3.10958200e-03f, 1.14336852e-02f,
  2.81476328e-04f, 5.32144606e-02f, 1.20437585e-01f, -1.03968931e-02f, 1.48151413e-01f, 1.93626001e-01f, 2.01345995e-01f, 1.68685466e-01f, -6.91480795e-03f, -1.75197169e-01f,
  4.60284017e-02f, 1.30260542e-01f, 5.87906092e-02f, 2.10395992e-01f, -2.10273080e-02f, -5.06345928e-02f, 5.36235124e-02f, 4.95569594e-02f, -3.85104455e-02f, 1.14339918e-01f,
  9.55358148e-02f, 4.49001752e-02f, 7.11599216e-02f, 4.17216383e-02f, 2.04052985e-01f, 1.52424484e-01f, 8.16928148e-02f, -8.28613117e-02f, 1.05989285e-01f, 1.25211015e-01f,
  1.40100062e-01f, 1.95050821e-01f, 1.04878321e-01f, -6.01137318e-02f, 5.53629585e-02f, 8.89054462e-02f, 1.48924306e-01f, 1.61666960e-01f, 4.99504060e-02f, 1.53496042e-01f,
  7.33918771e-02f, 1.23978838e-01f, 1.35075271e-01f, 8.29334743e-03f, 8.87376890e-02f, 1.10954158e-01f, -8.80795717e-03f, -2.00384595e-02f, -1.89889461e-01f, -9.30952653e-02f,
  -8.74038115e-02f, -1.21244468e-01f, -1.63921714e-02f, -1.61993340e-01f, 2.08379149e-01f, 1.86856776e-01f, -2.45993286e-01f, -1.04501821e-01f, -8.16853940e-02f, -7.90241584e-02f,
  1.16863847e-01f, 1.09675251e-01f, -9.17544663e-02f, -5.72078899e-02f, 1.16307721e-01f, 7.57065564e-02f, -4.54002321e-02f, -4.35405225e-02f, 2.92701036e-01f, 7.89242052e-03f,
  2.68272102e-01f, 1.77595079e-01f, 3.98393422e-02f, 5.24531342e-02f, -5.76009229e-02f, 1.54340208e-01f, 1.61540926e-01f, 5.86711057e-02f, 3.97283770e-02f, -1.09373987e-01f,
  -1.89050108e-01f, 1.11633055e-01f, -6.91023543e-02f, 7.95224309e-02f, 2.65470922e-01f, 1.27609223e-01f, 1.78757623e-01f, 6.81054220e-02f, 7.61144459e-02f, 6.71828538e-02f,
  8.58403817e-02f, 2.88515016e-02f, 1.57737315e-01f, 1.22003295e-01f, 1.41262889e-01f, 8.54871273e-02f, -6.76794127e-02f, -8.94701928e-02f, -5.22699021e-03f, 5.30680269e-02f,
  -1.38573628e-02f, 4.48085964e-02f, 1.36884823e-01f, 2.05857918e-01f, 1.68941751e-01f, -4.32885885e-02f, -1.25573158e-01f, -7.20187873e-02f, 2.03366399e-01f, 2.74795502e-01f,
  1.60867199e-01f, -1.93019778e-01f, -1.65462792e-01f, 1.82744384e-01f, 1.08746800e-03f, -9.68524069e-02f, -1.47408890e-02f, -5.02764527e-03f, 1.00783907e-01f, -1.08643271e-01f,
  -3.08486849e-01f, 1.75078258e-01f, 6.37501925e-02f, -3.19775823e-03f, -4.46639694e-02f, -1.10288754e-01f, -1.58438146e-01f, 5.30845746e-02f, -5.83852790e-02f, -4.66941968e-02f,
  2.11300537e-01f, -1.06148660e-01f, 9.07432437e-02f, -1.95431277e-01f, 4.21137601e-01f, 1.35838985e-01f, -1.15104392e-01f, -2.18978077e-01f, -3.80826369e-02f, 7.71336854e-02f,
  3.12207043e-01f, 1.88522771e-01f, 1.33963659e-01f, 7.12253153e-02f, 1.69359371e-02f, 2.48532332e-02f, -5.75926080e-02f, 2.56952047e-01f, 1.70410290e-01f, -2.30269313e-01f,
  -3.31447017e-03f, -2.04329118e-02f, 5.69651499e-02f, -7.73928314e-02f, -4.16231491e-02f, -4.17887159e-02f, 2.08407193e-02f, -1.20167220e-02f, -1.09725125e-01f, -3.45813930e-02f,
  4.62897718e-02f, -1.50275258e-02f, -6.19196706e-02f, -4.72004712e-02f, -4.77304421e-02f, -5.23768589e-02f, -2.02386901e-02f, -2.72932723e-02f, -3.97419631e-02f, 3.69915701e-02f,
  -7.28403851e-02f, 5.96941635e-02f, 4.61298749e-02f, 1.36022583e-01f, -6.06294274e-02f, 9.05706808e-02f, -1.86353531e-02f, 9.22467280e-03f, -1.38572007e-01f, -9.95708928e-02f,
  -1.97208133e-02f, -6.64679483e-02f, 8.44303519e-02f, 5.43364044e-03f, -5.19475788e-02f, 7.17011765e-02f, -7.68557787e-02f, 6.35506660e-02f, -1.11591984e-02f, -2.44525373e-02f,
  -7.98766443e-04f, -8.35482702e-02f, -1.13035709e-01f, -1.37246130e-02f, 5.59155121e-02f, -1.32725403e-01f, 5.93572818e-02f, -4.35363082e-03f, 1.61945298e-01f, 1.00658514e-01f,
  3.24575640e-02f, 7.16588506e-03f, -4.16578352e-02f, 7.07514808e-02f, 3.63005400e-02f, 9.61678028e-02f, -9.12564918e-02f, -1.37641147e-01f, -9.23465341e-02f, 5.69150001e-02f,
  -9.03841201e-03f, 4.67510410e-02f, 2.30485443e-02f, -8.26033503e-02f
};

// L2_fan_Bp_bar (Shape: 1 x 26)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 26;
const float L2_fan_Bp_bar_data[] = {
  -4.55923676e-02f, 5.61369583e-02f, 1.25594139e-01f, 1.15411066e-01f, 5.21277748e-02f, 4.91273142e-02f, 9.44535956e-02f, -2.96773780e-02f, 7.31061958e-03f, 1.19046785e-01f,
  9.55581143e-02f, 2.06674561e-02f, 1.42832816e-01f, 1.03125028e-01f, 9.37381536e-02f, 6.96092285e-03f, -2.98840646e-02f, 1.22780554e-01f, 1.51598126e-01f, 1.61847323e-01f,
  7.90056586e-02f, 5.95717169e-02f, 2.78082062e-02f, 8.07633623e-03f, 8.82746950e-02f, -8.15143250e-03f
};

// L3_fan_Wp (Shape: 19 x 64)
const int L3_fan_Wp_rows = 19;
const int L3_fan_Wp_cols = 64;
const float L3_fan_Wp_data[] = {
  -5.52533055e-03f, 8.58088657e-02f, 6.01788200e-02f, 9.41258073e-02f, 9.12571102e-02f, -1.09999180e-02f, 7.32225971e-03f, 1.08939379e-01f, -1.93655398e-02f, 9.08639953e-02f,
  7.73681030e-02f, 1.36130854e-01f, 1.18455440e-01f, 4.27522510e-02f, -3.87945138e-02f, 1.09838946e-02f, -6.03169762e-02f, 3.81947160e-02f, 1.09926164e-01f, -8.39861855e-02f,
  4.55261879e-02f, 6.37292024e-03f, 2.14971393e-01f, -5.29819285e-04f, 6.15016222e-02f, -9.50000063e-03f, 5.96336275e-02f, 1.93682238e-01f, 6.29358888e-02f, 6.40558973e-02f,
  -3.70793045e-02f, -2.96938419e-02f, -4.56448346e-02f, -1.66166276e-02f, 4.62767072e-02f, 1.22717455e-01f, 5.46402410e-02f, -3.88542227e-02f, -1.56634059e-02f, -1.69811681e-01f,
  1.45409793e-01f, -3.83228506e-03f, 2.87286304e-02f, 9.50383171e-02f, -3.54469456e-02f, -4.09665108e-02f, 7.13592470e-02f, -6.67308047e-02f, 1.18788235e-01f, 5.66714630e-02f,
  -2.94078551e-02f, 6.00869432e-02f, 1.27141103e-01f, 6.64921626e-02f, 1.77548546e-02f, -1.62087101e-02f, 7.71716684e-02f, 9.70902592e-02f, 9.55606997e-02f, 4.26160060e-02f,
  -1.34288877e-01f, -5.73370159e-02f, 9.33402330e-02f, -2.84173619e-02f, -4.25262190e-03f, -4.45496151e-03f, -4.31452580e-02f, 2.82033905e-02f, 1.04110083e-02f, -1.15212306e-01f,
  2.03712210e-02f, 1.00884110e-01f, 5.92883080e-02f, -7.98451751e-02f, -5.09004369e-02f, -9.07409936e-02f, -4.32665600e-03f, 8.47680494e-02f, -4.34788615e-02f, -9.34934467e-02f,
  -7.63370693e-02f, 1.56330708e-02f, -2.60482938e-03f, -9.23371240e-02f, -1.02496661e-01f, 6.05970584e-02f, 2.26270124e-01f, 1.14755608e-01f, 1.10200783e-02f, -2.22545385e-01f,
  1.15915097e-01f, 1.34114936e-01f, -9.27751660e-02f, 8.39200616e-02f, -4.88036051e-02f, -1.40653774e-01f, 1.54380854e-02f, -9.87694710e-02f, 7.21071362e-02f, -1.04722772e-02f,
  -7.63587952e-02f, 1.10658064e-01f, -1.36496529e-01f, -8.86454508e-02f, 3.21849585e-02f, -1.71932027e-01f, 1.47921577e-01f, 1.60681605e-01f, 2.86045913e-02f, 1.22806363e-01f,
  -5.25776371e-02f, -1.96432650e-01f, 5.65393716e-02f, 1.01051619e-02f, 1.41399309e-01f, -2.24528927e-03f, 8.19313675e-02f, -7.99639244e-03f, -5.95416315e-02f, -2.25598607e-02f,
  4.14017476e-02f, 8.33780244e-02f, 1.22895148e-02f, -4.08721305e-02f, -8.32788348e-02f, 1.23187363e-01f, -2.80637182e-02f, 3.26733105e-02f, 8.46211463e-02f, -4.55196388e-03f,
  -1.30380616e-01f, 4.87877727e-02f, -3.67904082e-02f, -1.08491473e-01f, -9.32913423e-02f, -8.77617076e-02f, 4.87264916e-02f, -9.01938975e-02f, -4.92942370e-02f, -7.07211532e-03f,
  -1.52365223e-01f, -7.64635345e-03f, -8.71159732e-02f, 4.12646718e-02f, 3.25487293e-02f, -2.17608977e-02f, -3.02499835e-03f, 4.93259281e-02f, 6.12384453e-02f, 1.48553280e-02f,
  9.75174457e-02f, 4.42831144e-02f, -1.36655092e-01f, -2.00768486e-01f, -1.93065912e-01f, 5.30472547e-02f, 2.53071766e-02f, -3.61352228e-02f, -1.17027666e-02f, -6.77575544e-02f,
  2.16226000e-02f, -1.40870184e-01f, -1.41714141e-02f, 1.00101195e-01f, 4.74886125e-04f, 1.53188109e-01f, -1.27922237e-01f, -1.07494138e-01f, 6.11913316e-02f, 7.85254389e-02f,
  -5.54768890e-02f, 1.07633621e-01f, -5.65524511e-02f, 9.59575027e-02f, -1.26647934e-01f, 2.95202085e-03f, -1.20389966e-04f, 3.93828414e-02f, -1.15157723e-01f, 1.75309107e-02f,
  7.41876289e-02f, -9.73950475e-02f, -1.59275323e-01f, 2.18024552e-02f, -5.49581647e-02f, 1.38827506e-02f, -1.15436465e-02f, -2.43450180e-02f, 6.19682260e-02f, 2.56048026e-03f,
  1.19517080e-01f, -8.67054239e-03f, -5.59212677e-02f, -6.41116053e-02f, 3.01945838e-03f, -3.99503708e-02f, -4.27205861e-03f, 1.24218233e-01f, 2.90145818e-02f, -6.62248209e-02f,
  -1.18737310e-01f, 1.17456906e-01f, 2.77750511e-02f, 1.46535993e-01f, 7.61739444e-03f, -1.64362099e-02f, 6.06133901e-02f, 8.52710381e-02f, 2.09050979e-02f, -1.40321339e-02f,
  3.88427749e-02f, 7.24045485e-02f, 9.59388316e-02f, 1.71106867e-02f, 1.53692793e-02f, -8.56439918e-02f, -4.80337590e-02f, 4.78939265e-02f, -1.19227439e-01f, -6.91551566e-02f,
  1.32093966e-01f, -3.41603346e-02f, 6.87495470e-02f, 1.47391066e-01f, -5.54703437e-02f, 2.16519460e-01f, -4.86241169e-02f, -2.74002664e-02f, 1.00907534e-01f, -2.01455548e-01f,
  1.57464556e-02f, 3.65038626e-02f, -8.78002122e-02f, 1.29189163e-01f, -1.31997377e-01f, -7.81541318e-02f, 5.66677116e-02f, 5.69797717e-02f, 7.22259060e-02f, 1.71258733e-01f,
  -4.57657464e-02f, -6.73184916e-02f, 1.14442073e-02f, 4.54691164e-02f, 2.68841535e-02f, 1.46474332e-01f, 6.40786216e-02f, -9.38596651e-02f, -4.82624024e-03f, -1.22815154e-01f,
  -3.80638912e-02f, 9.34350640e-02f, 2.41163317e-02f, -2.26822346e-02f, 4.74736877e-02f, -5.50340265e-02f, 5.34330010e-02f, -4.99266945e-02f, -1.03000924e-01f, -1.66098177e-02f,
  -3.45889553e-02f, -2.47641295e-01f, -5.71733229e-02f, 1.38753131e-02f, 4.83852215e-02f, -1.44409174e-02f, -3.61691788e-02f, 6.92106783e-02f, -3.55537161e-02f, -5.24951331e-02f,
  -7.09605813e-02f, 3.51331718e-02f, -5.79765216e-02f, 2.63520982e-02f, 9.15114582e-03f, 4.65141423e-02f, 7.15263411e-02f, -7.26043880e-02f, -5.08644655e-02f, 8.02688077e-02f,
  -5.99162281e-02f, -2.25067601e-01f, -1.37236804e-01f, 6.50816560e-02f, 1.44484669e-01f, -1.13133200e-01f, 1.84528194e-02f, 4.05038744e-02f, -1.24471679e-01f, -6.04849160e-02f,
  -1.10915706e-01f, 5.01952432e-02f, 1.88972633e-02f, 1.16520166e-01f, -6.53202534e-02f, -1.04957066e-01f, -1.09329201e-01f, 1.03278674e-01f, -7.65621737e-02f, 1.72421724e-01f,
  -1.52539149e-01f, 3.42877209e-02f, -5.12436070e-02f, 3.21378410e-02f, 7.04299845e-03f, -8.76535103e-02f, -2.94764782e-03f, -1.10379241e-01f, -2.28492282e-02f, -4.80856895e-02f,
  -2.09081978e-01f, 5.70429489e-02f, -2.45075785e-02f, -1.62984338e-02f, 8.43362883e-02f, -9.02095661e-02f, -8.52803141e-03f, -3.81445028e-02f, 1.89433351e-01f, 1.50024164e-02f,
  -5.69371805e-02f, 4.61300090e-02f, 2.72699688e-02f, -9.12031829e-02f, -7.14783650e-03f, -1.90827958e-02f, -6.83780909e-02f, -4.44928966e-02f, -1.18724950e-01f, -1.40816361e-01f,
  4.50320914e-02f, 1.16959281e-01f, -9.67216715e-02f, -3.21053043e-02f, -2.04318506e-03f, 4.67982665e-02f, -3.24130096e-02f, -9.64182094e-02f, -9.96975973e-02f, 4.39254865e-02f,
  1.04234472e-01f, -8.80652200e-03f, -1.74950257e-01f, -1.14295017e-02f, 1.93744544e-02f, -7.64164850e-02f, -2.81267077e-01f, -1.13159075e-01f, -3.85758057e-02f, 3.42295170e-02f,
  5.04967384e-02f, 5.91750443e-02f, 8.88329819e-02f, 1.75393134e-01f, -7.32989237e-02f, 6.41601905e-02f, -4.47329804e-02f, -2.10886672e-02f, -2.12197900e-02f, 8.29625502e-02f,
  -7.65643716e-02f, 2.13646907e-02f, -5.34772314e-02f, -1.37172624e-01f, 4.96241711e-02f, -9.97265577e-02f, -5.78220561e-02f, 9.20734480e-02f, -1.39185816e-01f, 3.71505357e-02f,
  -1.95639729e-01f, -1.33303761e-01f, 1.54034853e-01f, 3.21783647e-02f, -3.01899598e-03f, 1.86682865e-02f, -1.20674841e-01f, -2.79697236e-02f, 4.08580489e-02f, 7.38328099e-02f,
  2.12480444e-02f, -1.78120837e-01f, 1.22511148e-01f, 7.74832396e-03f, 7.19595104e-02f, -1.02687618e-02f, -3.80439833e-02f, 1.27537996e-01f, 1.42376602e-01f, -1.32699749e-02f,
  -5.86619563e-02f, 2.77426206e-02f, 3.99220958e-02f, 3.13053615e-02f, 4.15354483e-02f, -3.51849608e-02f, -4.40593436e-02f, 8.26056749e-02f, 1.08320549e-01f, 1.54326826e-01f,
  3.71443643e-03f, -6.65899552e-03f, 1.70256495e-01f, 2.88747926e-03f, -7.23490641e-02f, 1.00810669e-01f, 9.59512740e-02f, -3.46784182e-02f, -8.00578445e-02f, -6.76451996e-02f,
  -4.03393991e-02f, 7.47596920e-02f, 1.86992690e-01f, -7.59167597e-02f, 5.53700291e-02f, 2.24200591e-01f, -2.98876762e-02f, 7.70893991e-02f, -9.87392142e-02f, 5.30972369e-02f,
  1.30651265e-01f, -1.83301762e-01f, -7.62815177e-02f, 5.22891916e-02f, -2.20168307e-02f, 1.25176311e-02f, -8.75933990e-02f, -1.50153814e-02f, 2.31366251e-02f, -4.49122861e-03f,
  6.65218160e-02f, 2.49616848e-03f, -6.66910410e-02f, -6.12395965e-02f, -9.81363654e-02f, 5.89220002e-02f, 7.34217186e-03f, 6.20369762e-02f, 1.63970932e-01f, -1.44188046e-01f,
  5.56892864e-02f, -1.68859705e-01f, -1.48254052e-01f, 1.24092892e-01f, 7.45718926e-02f, -1.16534472e-01f, 6.57352014e-03f, -4.06252556e-02f, 1.32532671e-01f, 6.51980797e-03f,
  -1.09895386e-01f, -5.45407757e-02f, 1.66339159e-01f, -1.32111073e-01f, -1.54584497e-01f, -1.29031807e-01f, 1.55337080e-01f, 1.10234693e-01f, 1.08804792e-01f, 2.82811932e-02f,
  -9.05448049e-02f, -4.39069271e-02f, 2.25019574e-01f, -2.90336441e-02f, 2.15034876e-02f, 1.41823366e-01f, -8.16007331e-02f, -1.11997515e-01f, 3.75982113e-02f, -7.92434067e-02f,
  -2.27746129e-01f, -1.34212151e-01f, 4.08146791e-02f, -2.26586144e-02f, -1.62610963e-01f, -6.74314573e-02f, -1.76642463e-01f, -4.06834297e-03f, 6.87065795e-02f, -6.66453466e-02f,
  1.11914217e-01f, 1.02973826e-01f, 5.62754348e-02f, -2.65360512e-02f, 1.95910960e-01f, -1.01815790e-01f, 1.96759760e-01f, 1.79347187e-01f, 1.68118905e-02f, 1.86882988e-01f,
  9.91725922e-02f, 1.36466682e-01f, 6.01311810e-02f, 1.62671462e-01f, 1.73185363e-01f, 1.71610013e-01f, 9.14928243e-02f, 1.64197683e-01f, 1.95759833e-01f, -8.49172324e-02f,
  -3.17533836e-02f, 2.06321299e-01f, 1.55307889e-01f, 2.26839602e-01f, 1.77979082e-01f, 8.79322514e-02f, 2.94061661e-01f, 1.63548753e-01f, 5.50667867e-02f, 6.03228956e-02f,
  1.63026303e-02f, 6.43749833e-02f, 6.98182434e-02f, 4.53891829e-02f, 4.88121472e-02f, 6.66944459e-02f, 7.38251731e-02f, 1.18653633e-01f, 8.87155086e-02f, 1.50266945e-01f,
  6.62795603e-02f, 1.23624513e-02f, 5.47531731e-02f, 5.72251529e-02f, 5.99159077e-02f, 8.78518894e-02f, 9.06231850e-02f, 9.96151492e-02f, 4.72098738e-02f, 1.06485467e-02f,
  9.51030329e-02f, 1.05026960e-01f, 1.10034436e-01f, 5.45184240e-02f, 2.08770052e-01f, 7.47731850e-02f, 5.80911599e-02f, 1.63350761e-01f, -2.15863343e-02f, 1.60164207e-01f,
  4.62608002e-02f, -5.09925000e-02f, -1.92947742e-02f, 1.45344259e-02f, 4.24565515e-03f, 2.71113943e-02f, -5.59551902e-02f, 1.48610309e-01f, -8.28323828e-04f, -9.03783366e-02f,
  -1.01391245e-02f, -9.54739302e-02f, 1.27586707e-01f, 8.16484243e-02f, 8.30347762e-02f, 4.29515094e-02f, -9.71876979e-02f, -1.19943984e-01f, 8.22261944e-02f, 1.13838896e-01f,
  1.33990675e-01f, 1.70719653e-01f, 1.19765975e-01f, -1.06938211e-02f, 1.44165546e-01f, -3.48912328e-02f, -1.31770608e-03f, -1.04554176e-01f, 2.94036176e-02f, -2.27978118e-02f,
  1.90852536e-03f, -8.74741375e-02f, -4.70744781e-02f, -2.65931003e-02f, 6.13686405e-02f, -3.51138003e-02f, 1.84769761e-02f, 3.72380167e-02f, 9.04101357e-02f, 4.87359613e-02f,
  -3.28686722e-02f, 3.56254280e-02f, 8.71353894e-02f, 6.20311350e-02f, -9.75251570e-03f, 5.67450114e-02f, -3.50963138e-02f, -1.37957623e-02f, 9.22907889e-02f, 2.89998837e-02f,
  -7.05370829e-02f, 7.52116218e-02f, -3.45705189e-02f, -3.23255211e-02f, 8.87423605e-02f, -1.07777975e-02f, 6.61102906e-02f, -2.35314220e-02f, 2.26987928e-01f, -9.50536504e-03f,
  -8.85285810e-02f, -3.33980918e-02f, 2.69508380e-02f, 1.36783421e-01f, 1.11788459e-01f, 4.85780351e-02f, 3.04866657e-02f, 1.36210863e-03f, -4.24866565e-02f, -1.24537781e-01f,
  3.88996787e-02f, 6.94672614e-02f, 5.39569482e-02f, 7.21001104e-02f, -1.09808199e-01f, -5.12893274e-02f, 8.54969174e-02f, 4.22518551e-02f, 2.16018893e-02f, -7.01185130e-03f,
  -1.37242049e-01f, -6.72836378e-02f, -1.47593394e-02f, 1.40947858e-02f, 1.63687244e-01f, 9.68357697e-02f, -9.93512943e-02f, 2.07285788e-02f, 1.03527538e-01f, -1.39651462e-01f,
  -7.50788972e-02f, -5.40174432e-02f, -5.24860509e-02f, -1.07371584e-01f, -8.63085911e-02f, 1.20017163e-01f, -6.26723319e-02f, 1.19973250e-01f, 1.51127875e-01f, 2.78190728e-02f,
  2.00704932e-01f, 2.45489608e-02f, 1.77301928e-01f, 1.74235199e-02f, 1.40599087e-01f, 7.73000941e-02f, 7.54590854e-02f, -5.56691661e-02f, 4.80545796e-02f, 9.83534381e-02f,
  1.76260233e-01f, 1.78591609e-01f, -3.20419259e-02f, 1.00642174e-01f, 3.22530009e-02f, 1.78479955e-01f, 9.04386416e-02f, 6.42908067e-02f, 7.23358765e-02f, -1.19319990e-01f,
  -1.24142105e-02f, -2.46425476e-02f, 4.48521711e-02f, -6.33223504e-02f, 3.09673864e-02f, 3.81211042e-02f, -1.12000935e-01f, 3.09824720e-02f, 2.55195145e-02f, 2.61002351e-02f,
  1.36010442e-02f, 6.59194365e-02f, 2.25709286e-02f, 7.99445361e-02f, 6.21740147e-02f, -2.92729959e-02f, 4.55964729e-02f, -1.48933515e-01f, -5.54617383e-02f, 1.22631788e-01f,
  2.73859520e-02f, 1.84761509e-01f, -1.87807344e-02f, 1.03400327e-01f, 6.11436740e-02f, 1.03975713e-01f, 2.05734223e-01f, 1.30222499e-01f, 4.07330468e-02f, 4.75117639e-02f,
  1.09647118e-01f, 1.84361205e-01f, 4.21831720e-02f, 7.92386904e-02f, 2.05859065e-01f, 1.37517648e-02f, 2.15340331e-01f, -4.45594965e-03f, 8.51691738e-02f, 1.38093129e-01f,
  8.81577879e-02f, 5.14445603e-02f, 4.58385609e-02f, 1.89714096e-02f, 1.08199473e-02f, -2.56748479e-02f, 9.78425518e-02f, -2.45998912e-02f, -7.53769204e-02f, 3.26216556e-02f,
  4.71015051e-02f, -3.44253816e-02f, 1.10585071e-01f, -1.16931207e-01f, 2.08300315e-02f, -1.80927031e-02f, 1.10021368e-01f, -7.86660314e-02f, 4.05940823e-02f, 8.48923530e-03f,
  1.08824959e-02f, 1.68318227e-01f, -1.39173746e-01f, 6.03257865e-02f, 8.37238058e-02f, -1.51254803e-01f, -2.12552086e-01f, 1.81313269e-02f, 4.84014302e-02f, 1.49356782e-01f,
  1.57896847e-01f, -1.16326593e-01f, 7.02888444e-02f, -1.54926434e-01f, -7.16561377e-02f, -7.58711025e-02f, 1.22818008e-01f, 4.44173105e-02f, -3.96027453e-02f, 1.88305043e-02f,
  3.60121913e-02f, 2.94432417e-02f, 2.14587990e-02f, -5.14775515e-02f, -5.11652976e-02f, -9.75562111e-02f, -6.59586266e-02f, -8.86237696e-02f, -7.88466334e-02f, -4.77221645e-02f,
  -7.21334964e-02f, 9.22131240e-02f, -3.54189090e-02f, -1.44522324e-01f, 2.29156706e-02f, -4.70320657e-02f, -1.35622591e-01f, -5.36869317e-02f, -1.04696326e-01f, 1.58133090e-01f,
  -5.17264083e-02f, 1.33385316e-01f, 5.93432188e-02f, -1.29554406e-01f, 7.64324069e-02f, 7.17582479e-02f, 1.11040175e-01f, -2.31901538e-02f, 6.32205606e-02f, 5.94940186e-02f,
  -7.83095881e-02f, 4.65776399e-03f, -1.09284870e-01f, 1.85052101e-02f, -7.61107681e-03f, 1.59489512e-01f, 5.20183519e-02f, -5.21451011e-02f, 3.81008275e-02f, -1.32194698e-01f,
  -1.17923744e-01f, 5.31227216e-02f, -5.20790555e-02f, -3.19088474e-02f, -5.19549958e-02f, -4.43115868e-02f, 4.05120067e-02f, 7.66986609e-02f, 1.01745158e-01f, 7.87726939e-02f,
  2.12452948e-01f, -4.12574485e-02f, 4.45293449e-02f, -5.34722246e-02f, -1.39224529e-01f, 1.90599665e-01f, 9.79983807e-03f, 5.04945172e-03f, -9.63190198e-02f, -1.05897002e-02f,
  -1.66355968e-02f, -7.56052416e-03f, 1.34442886e-02f, 1.08584344e-01f, -7.68058673e-02f, 2.27196366e-02f, -1.28362820e-01f, -1.18291013e-01f, 1.12854913e-01f, 5.38396090e-02f,
  6.76288307e-02f, 1.65761355e-02f, -8.41926783e-02f, 4.81145643e-02f, 7.58874640e-02f, -1.18974574e-01f, 4.60005887e-02f, 1.47170395e-01f, -4.70891520e-02f, -1.42309338e-01f,
  1.11343056e-01f, -1.16079837e-01f, -1.50658712e-02f, -1.74398735e-01f, -9.30055454e-02f, 7.74628147e-02f, -2.40040347e-02f, 4.64860611e-02f, -1.04734622e-01f, -7.27169067e-02f,
  -6.88014105e-02f, 4.95089591e-02f, 2.40597092e-02f, 2.24369820e-02f, 3.88974845e-02f, 1.05303917e-02f, -8.39134902e-02f, 5.96125387e-02f, 5.01626134e-02f, -1.51096404e-01f,
  7.95370936e-02f, -3.83739732e-02f, -7.12495521e-02f, 1.34514257e-01f, -6.64609522e-02f, 4.28413935e-02f, 1.30028669e-02f, 1.14593506e-02f, 7.37481713e-02f, -1.06437974e-01f,
  1.73345283e-02f, -7.62442425e-02f, -1.09753452e-01f, 2.05187909e-02f, -8.22359603e-03f, -1.67817637e-01f, 8.25139787e-03f, -9.32955965e-02f, -1.33831203e-01f, 5.85014969e-02f,
  -9.43460464e-02f, 1.08527787e-01f, 7.08975866e-02f, -4.70855348e-02f, 1.82439968e-01f, 3.82732712e-02f, 1.00762993e-01f, -5.27170599e-02f, -3.89645211e-02f, 5.71086593e-02f,
  -4.82540801e-02f, 1.57070130e-01f, 8.76044780e-02f, -7.33344778e-02f, -8.01656395e-02f, 1.60710029e-02f, 1.37468383e-01f, -2.35583633e-02f, 1.19907863e-01f, -5.89070562e-03f,
  8.27166140e-02f, 1.25550136e-01f, 1.24034919e-01f, 1.21083111e-01f, 9.51156914e-02f, 5.61082512e-02f, 1.41261090e-02f, -1.29122939e-02f, 1.15495898e-01f, -1.64050069e-02f,
  6.73397705e-02f, 1.00603867e-02f, -5.31618558e-02f, 9.38434619e-03f, -4.37299758e-02f, -2.85894740e-02f, 2.17082910e-03f, -3.08360197e-02f, 2.51110252e-02f, 7.19561875e-02f,
  5.38411997e-02f, -6.30588010e-02f, -2.81762201e-02f, 7.26817623e-02f, -4.08780985e-02f, 6.07959833e-03f, 4.82720733e-02f, -6.72311112e-02f, -8.66242722e-02f, 8.89498889e-02f,
  5.32970577e-02f, 5.27107306e-02f, -6.40628636e-02f, 3.10793128e-02f, -1.23401634e-01f, 8.44010264e-02f, -2.10422743e-02f, 2.79483274e-02f, 9.07785073e-02f, -6.66356236e-02f,
  1.54498383e-01f, 2.53065787e-02f, -1.75357163e-02f, 1.18631594e-01f, -1.47458717e-01f, 2.73339320e-02f, -6.28690571e-02f, -1.13004170e-01f, -5.74358664e-02f, 1.59943461e-01f,
  -3.18038103e-04f, -4.53678519e-02f, 4.90321703e-02f, -9.82751697e-02f, 2.63533723e-02f, -1.05317235e-01f, 7.16693625e-02f, -5.34634739e-02f, -3.16844061e-02f, 6.92595765e-02f,
  5.61498627e-02f, 9.23596025e-02f, 7.04399720e-02f, -1.80239663e-01f, 1.33005634e-01f, 5.01409210e-02f, -4.88398643e-03f, 1.14900386e-02f, -7.86135346e-03f, -6.10367907e-03f,
  1.57649126e-02f, -1.17949426e-01f, 1.21931039e-01f, -9.17269960e-02f, 8.80840570e-02f, 1.09713152e-01f, -4.47264202e-02f, -1.31874532e-02f, -2.20124319e-01f, -3.63743529e-02f,
  -1.07059449e-01f, -1.22884430e-01f, 6.36725277e-02f, -3.81666119e-03f, 1.77460574e-02f, -1.15997419e-01f, -3.90567482e-02f, 1.26158670e-01f, -1.09792128e-01f, -3.91566455e-02f,
  6.24145269e-02f, 5.58300912e-02f, 9.83546674e-02f, 4.71287295e-02f, 1.13361724e-01f, 1.10073410e-01f, -1.81461930e-01f, 5.14930300e-02f, 2.27380767e-02f, -5.15444465e-02f,
  1.62104294e-01f, -7.40387812e-02f, 1.54605564e-02f, 2.79003885e-02f, 5.24752922e-02f, -1.07864983e-01f, -6.92867041e-02f, 1.68750957e-02f, 2.32175086e-02f, -4.32178080e-02f,
  9.15591866e-02f, 2.31866073e-02f, -6.29194826e-02f, -4.15517502e-02f, 5.44295879e-04f, -9.98781528e-03f, 8.07509664e-03f, -1.02299437e-01f, 9.04431716e-02f, -1.15948524e-02f,
  1.98662654e-02f, 8.76985341e-02f, 3.85308899e-02f, 1.26968920e-01f, -1.76222771e-01f, 5.81041947e-02f, -6.54964000e-02f, -4.94542569e-02f, -8.43179151e-02f, -1.43768042e-01f,
  6.17489293e-02f, -1.06664002e-01f, 7.54973367e-02f, 5.13548218e-02f, -8.86405930e-02f, 5.72794490e-02f, 6.82184994e-02f, 9.01594609e-02f, -6.07603230e-02f, -1.31413341e-01f,
  -1.59656238e-02f, -5.15746027e-02f, 8.48822445e-02f, 2.73391195e-02f, 1.68651894e-01f, 6.70986027e-02f, 1.76509649e-01f, 1.00576036e-01f, 5.12658758e-03f, 5.11162691e-02f,
  5.63990586e-02f, -9.75201745e-03f, 1.39207616e-02f, 1.54785231e-01f, 3.54605168e-02f, 1.34179428e-01f, 2.02013701e-02f, 5.53712761e-03f, 6.23776391e-02f, 2.08165526e-01f,
  1.08457305e-01f, -3.96566615e-02f, -3.55766490e-02f, -2.87814010e-02f, 1.90917760e-01f, 4.41057943e-02f, 3.31782885e-02f, -7.88190514e-02f, 6.52374402e-02f, 5.44079505e-02f,
  -6.05366677e-02f, 6.77140728e-02f, 5.30951507e-02f, 4.99036610e-02f, 5.71013503e-02f, 1.49767905e-01f, 3.49044502e-02f, 1.06585771e-01f, 7.80585706e-02f, 4.52888645e-02f,
  7.61890486e-02f, -7.39994571e-02f, -2.66236477e-02f, 9.61172804e-02f, -2.21795943e-02f, 2.14378744e-01f, -3.26063894e-02f, -1.15164369e-02f, 2.22801939e-02f, -1.96904372e-02f,
  1.07151516e-01f, 2.04450130e-01f, 5.02004437e-02f, 6.77300394e-02f, -3.40577625e-02f, -2.51201019e-02f, 4.75816522e-03f, 5.18922918e-02f, 1.62702009e-01f, -7.48565421e-02f,
  -6.19896054e-02f, 1.32051324e-02f, -1.38022332e-02f, 7.20999688e-02f, 1.33011028e-01f, -1.77676857e-01f, 1.42331168e-01f, -7.36296223e-03f, 5.71992844e-02f, 8.06640461e-02f,
  3.49511728e-02f, -8.52418132e-03f, -1.14166252e-02f, 2.12761126e-02f, 9.69428420e-02f, 1.31212473e-01f, 1.12941220e-01f, 4.86865751e-02f, -1.52379535e-02f, -1.98312029e-02f,
  4.34056409e-02f, -2.49750037e-02f, 8.37107077e-02f, 1.31898513e-02f, 5.89880645e-02f, -1.57586690e-02f, 1.91082999e-01f, -1.65258218e-02f, 1.90328937e-02f, 1.23783603e-01f,
  6.94664940e-03f, 3.43772657e-02f, -1.60491616e-01f, -5.17493812e-03f, -3.23509239e-02f, 3.60826850e-02f, -3.01260781e-02f, 6.31693676e-02f, 6.74951822e-02f, 4.71271798e-02f,
  1.29471257e-01f, -1.57417938e-01f, 5.73968068e-02f, 5.85170351e-02f, 4.36854176e-02f, -2.05799611e-03f, 2.85303430e-03f, 1.43771395e-01f, 1.20073915e-01f, -2.94462796e-02f,
  -6.73206896e-02f, -7.29318187e-02f, 6.83959723e-02f, -9.38649997e-02f, 5.89315742e-02f, 1.00759335e-01f, -7.33718202e-02f, 6.91745207e-02f, -1.17551699e-01f, -1.52289674e-01f,
  1.53671205e-01f, -7.95028582e-02f, -8.50699246e-02f, 4.18223888e-02f, -1.45346090e-01f, 6.93314075e-02f, -8.42044421e-04f, 3.52834091e-02f, 6.09496050e-02f, 1.30507872e-01f,
  1.00783952e-01f, 6.47715852e-03f, -9.95495170e-02f, 8.96423161e-02f, -6.28216416e-02f, -1.00431882e-01f, -7.61086270e-02f, -1.69662595e-01f, 5.59448376e-02f, 9.30988342e-02f,
  5.99783957e-02f, -7.83627480e-02f, -1.44761978e-02f, -9.13843140e-02f, 3.00459471e-03f, -8.04562047e-02f, -6.15093336e-02f, -1.66162282e-01f, -5.11644147e-02f, -2.12323270e-03f,
  8.23260052e-04f, -8.55948254e-02f, -2.15749234e-01f, 2.53245085e-02f, 2.38520540e-02f, 7.67012462e-02f, -8.23094770e-02f, -1.57591239e-01f, 1.76745653e-01f, 1.00262217e-01f,
  -7.11344415e-04f, -7.05298921e-03f, -4.48376685e-02f, -1.52718842e-01f, -5.99191040e-02f, -2.16614917e-01f, 1.01525605e-01f, 3.99401337e-02f, -7.37900008e-03f, 1.93487808e-01f,
  -4.01338935e-02f, -1.60095338e-02f, 7.16344565e-02f, -1.55127540e-01f, -4.90100048e-02f, 3.53536494e-02f, 7.46411271e-03f, 1.18796155e-01f, -8.04688409e-02f, -1.94470629e-01f,
  1.13343820e-01f, 1.19817276e-02f, 1.69186428e-01f, 1.88194022e-01f, -8.56456310e-02f, -8.40627253e-02f, -1.31978139e-01f, 4.10552882e-02f, 1.07314661e-01f, 3.02528013e-02f,
  -1.90705974e-02f, -2.06026837e-01f, 9.22614615e-03f, 1.02136262e-01f, -9.65977013e-02f, 7.11890683e-02f
};

// L3_fan_Wp_bar (Shape: 26 x 64)
const int L3_fan_Wp_bar_rows = 26;
const int L3_fan_Wp_bar_cols = 64;
const float L3_fan_Wp_bar_data[] = {
  4.41747680e-02f, 1.89181250e-02f, -9.35630128e-02f, 2.29698680e-02f, -5.39951399e-02f, -4.88669984e-02f, -1.40983731e-01f, -1.98494717e-02f, 1.70691255e-02f, -1.07471280e-01f,
  1.54670840e-02f, -1.41312620e-02f, -1.69763982e-01f, -1.58761069e-03f, -1.09378576e-01f, -7.03067519e-03f, -1.03398606e-01f, -5.10559268e-02f, 4.33813147e-02f, 1.71904378e-02f,
  1.38123617e-01f, 1.14129372e-01f, 5.31909019e-02f, 5.75793092e-04f, -2.76919566e-02f, -1.33739099e-01f, -2.66121984e-01f, 5.29414751e-02f, 3.92537564e-02f, 1.19599618e-01f,
  6.12718426e-02f, 1.76244061e-02f, -4.52589756e-03f, -1.03634052e-01f, -6.60407590e-03f, 1.02709137e-01f, -5.26173078e-02f, 1.58541530e-01f, -1.21429995e-01f, -6.55048564e-02f,
  1.01209886e-01f, 4.38305438e-02f, 9.03537273e-02f, -4.68886197e-02f, -2.34863952e-01f, -1.65751693e-03f, -2.83192545e-01f, -5.01912758e-02f, 4.26512398e-02f, 7.68411160e-02f,
  -3.27863932e-01f, -2.65938073e-01f, 1.41451374e-01f, -8.75296816e-02f, -1.69301257e-01f, 2.44807247e-02f, -2.99469560e-01f, 2.32802898e-01f, -1.33617386e-01f, 2.23364845e-01f,
  2.41021663e-02f, 5.26469983e-02f, 1.74368680e-01f, 9.32590440e-02f, 1.08444631e-01f, 4.52055130e-03f, 2.57929087e-01f, 8.41351226e-02f, 9.00915861e-02f, 2.63265491e-01f,
  1.90825611e-01f, 4.80475463e-02f, -1.06270328e-01f, 5.97133301e-02f, 5.44695593e-02f, -6.31830990e-02f, 2.04016536e-01f, 2.59898484e-01f, -3.39058265e-02f, 1.82246432e-01f,
  -1.12149507e-01f, -5.33050112e-02f, 1.26312509e-01f, -4.54438664e-02f, -7.42825912e-04f, -5.39680338e-03f, 2.04850078e-01f, -9.14854854e-02f, 4.51443624e-03f, 8.14265013e-02f,
  7.62334093e-03f, 1.34201348e-01f, 1.17861629e-01f, 5.89249022e-02f, 1.43150270e-01f, 2.83774525e-01f, -9.48231667e-02f, 1.55011732e-02f, -6.90531954e-02f, -1.56682562e-02f,
  9.88417938e-02f, -1.43023372e-01f, -1.02226995e-01f, 1.02848887e-01f, 6.44089058e-02f, 7.71792829e-02f, -2.91312728e-02f, -1.57096192e-01f, 2.01860875e-01f, -1.80696905e-01f,
  1.43263474e-01f, -2.58991927e-01f, 1.58266544e-01f, 1.38671219e-01f, -7.50850812e-02f, 1.76311940e-01f, 1.58355400e-01f, 1.52587563e-01f, 1.75601080e-01f, -1.61338076e-01f,
  5.14661074e-02f, -1.28376827e-01f, -3.12029809e-01f, 2.78778821e-01f, 7.76733086e-02f, 7.29659125e-02f, 8.87938216e-02f, -9.31945667e-02f, -1.52368564e-02f, 4.34116945e-02f,
  2.45064214e-01f, -5.40913269e-02f, -4.88807335e-02f, 2.13792816e-01f, 2.42866546e-01f, -1.49234936e-01f, -7.76922330e-02f, -1.80521440e-02f, 4.78545837e-02f, 3.53296325e-02f,
  2.13872328e-01f, -2.64584669e-04f, -1.24100529e-01f, 4.55522388e-02f, 7.71373734e-02f, 1.33475184e-01f, 5.81520125e-02f, -6.25202954e-02f, -4.85431105e-02f, 3.45292389e-02f,
  -1.74006969e-02f, 1.12673573e-01f, -2.06548333e-01f, 1.30609259e-01f, 1.57054901e-01f, 5.67090511e-02f, 2.47459278e-01f, -7.01065958e-02f, 1.92493349e-01f, 1.77776977e-01f,
  -3.09027848e-03f, -2.76225597e-01f, -1.82909500e-02f, -1.05572417e-02f, -7.87113607e-02f, 1.13172218e-01f, 6.04981557e-02f, 1.28421888e-01f, 3.91342491e-02f, 2.69956946e-01f,
  -1.12977438e-01f, -9.20419246e-02f, -1.01298548e-01f, -1.68236971e-01f, -1.68816417e-01f, 1.51300892e-01f, 1.30512640e-01f, -8.57812241e-02f, 5.52661531e-02f, 2.57133096e-01f,
  -4.89050224e-02f, -5.00631928e-02f, -3.49777527e-02f, 2.28145987e-01f, 1.01366907e-01f, 6.61255494e-02f, -2.42239416e-01f, 1.57726631e-01f, 2.72326052e-01f, 1.93596974e-01f,
  4.59490120e-01f, 6.32936284e-02f, 6.59016520e-02f, 9.21243727e-02f, -5.90444496e-03f, -1.66892493e-03f, -1.76366121e-01f, -2.76316572e-02f, -2.88544712e-03f, -8.15121084e-02f,
  7.72851333e-02f, -3.35815996e-02f, -7.74974294e-04f, 7.08981305e-02f, -2.28662160e-03f, -6.12726621e-02f, -7.10002407e-02f, -1.19036034e-01f, 1.47021338e-01f, 3.90124060e-02f,
  -6.42833039e-02f, 8.23448673e-02f, -7.27972537e-02f, 1.45929931e-02f, -1.03573613e-01f, 4.11092825e-02f, -9.43412557e-02f, -4.73969616e-02f, -4.13298756e-02f, 3.89656145e-03f,
  3.48296724e-02f, 1.74341295e-02f, -6.45634532e-03f, -9.36512202e-02f, 1.13231674e-01f, -7.26889595e-02f, 1.57312706e-01f, 5.89273088e-02f, -9.93297845e-02f, 3.06163162e-01f,
  1.98926359e-01f, -1.64234433e-02f, 1.25483172e-02f, -2.59110108e-02f, 3.31241228e-02f, -6.40655681e-03f, -8.68186057e-02f, 6.31254688e-02f, -1.91575855e-01f, 2.74528712e-01f,
  1.11021250e-01f, -6.71719462e-02f, 5.78780333e-03f, 1.14966571e-01f, -1.44960538e-01f, -1.55436955e-02f, -2.21616060e-01f, 1.93884745e-01f, 1.46340564e-01f, 1.60055548e-01f,
  1.42968029e-01f, -1.22205168e-01f, 1.24945052e-01f, 2.30508462e-01f, 1.67561740e-01f, 8.74601901e-02f, -1.67353190e-02f, -6.80372417e-02f, -7.25613981e-02f, -1.47393476e-02f,
  3.72159593e-02f, -7.52867833e-02f, -7.60766491e-02f, -1.17941052e-01f, -8.83032158e-02f, -4.82183788e-03f, -4.20384221e-02f, -4.79905643e-02f, -1.59503579e-01f, 1.88616142e-02f,
  2.15287134e-02f, 1.27625503e-02f, -6.99058920e-02f, -1.39989898e-01f, -4.71659638e-02f, -4.34497278e-03f, -1.32828131e-01f, 7.52323791e-02f, -5.55262566e-02f, -3.31077687e-02f,
  -4.25668694e-02f, -1.46309286e-01f, -1.51604161e-01f, 5.88922463e-02f, -1.96639076e-02f, 1.67777702e-01f, 9.05292258e-02f, 6.25166669e-02f, 4.46374081e-02f, 3.05010844e-02f,
  7.85916448e-02f, -9.19161364e-02f, 6.09886386e-02f, -2.49504894e-02f, 1.46101877e-01f, 3.20262879e-01f, -7.00277761e-02f, 4.22413368e-03f, -3.78714353e-02f, -1.05489232e-01f,
  2.40360275e-01f, 1.26981080e-01f, 3.09275657e-01f, -2.50499487e-01f, -1.47556394e-01f, 7.32413754e-02f, -6.39625650e-04f, -1.51961073e-02f, -3.46818678e-02f, 3.04175198e-01f,
  1.71982750e-01f, -4.17516455e-02f, -4.16684002e-02f, -1.26086175e-03f, -6.82110339e-02f, 1.65708214e-01f, 1.74083263e-01f, 1.60074040e-01f, -1.34510294e-01f, -3.53402570e-02f,
  5.99167980e-02f, 3.34245451e-02f, 9.77360085e-02f, 9.74390209e-02f, -8.68943483e-02f, 8.25753659e-02f, 5.57065718e-02f, 1.17835328e-01f, 7.38150068e-03f, 7.71392360e-02f,
  5.21868914e-02f, 4.91595939e-02f, 5.00000119e-02f, 1.39679890e-02f, -8.15823954e-03f, 6.46969602e-02f, 1.60717264e-01f, 2.09003296e-02f, -3.75873335e-02f, 4.07802640e-03f,
  9.75460634e-02f, 5.35543300e-02f, 1.38159722e-01f, 3.26607190e-02f, 1.19743317e-01f, 5.22319674e-02f, -5.40656187e-02f, -1.83424875e-02f, -2.26002514e-01f, 6.94496632e-02f,
  -2.12556347e-01f, -8.09132606e-02f, -4.40442488e-02f, 5.11151962e-02f, 2.78332140e-02f, -1.55427726e-02f, -1.09623097e-01f, -5.37884189e-03f, -2.03839645e-01f, -7.56141320e-02f,
  2.94748366e-01f, 8.04095790e-02f, 1.82329252e-01f, -3.69318537e-02f, 1.99039087e-01f, -5.44249490e-02f, -4.53215428e-02f, 2.73073725e-02f, 1.76750362e-01f, 2.54575759e-01f,
  -8.32086653e-02f, -1.95771441e-01f, 1.63767993e-01f, 1.61631294e-02f, 4.61703585e-03f, -9.52749476e-02f, -8.29290524e-02f, 8.53028670e-02f, 2.86964744e-01f, 1.17581718e-01f,
  -1.22011237e-01f, -1.26677141e-01f, -2.41778389e-01f, -1.23399468e-02f, -2.77854837e-02f, 3.74532379e-02f, -1.07439481e-01f, -5.77882305e-02f, -1.21026628e-01f, -1.18244536e-01f,
  2.37016324e-02f, -1.05549738e-01f, -9.25984140e-03f, -2.49929633e-02f, -2.07019612e-01f, -3.94623838e-02f, -1.41480312e-01f, -6.85171857e-02f, -1.01493066e-02f, -1.40203476e-01f,
  -2.26120781e-02f, -1.11941613e-01f, -1.54691592e-01f, 3.51725295e-02f, -6.94457302e-03f, 5.34147508e-02f, -4.97950874e-02f, -1.05712861e-01f, -1.86486952e-02f, -2.14678615e-01f,
  -2.15768173e-01f, -7.52101690e-02f, -6.66414276e-02f, 2.67998651e-02f, -2.08147824e-01f, 1.01993576e-01f, -4.67486754e-02f, -3.40408869e-02f, -3.97740491e-02f, -3.01032085e-02f,
  1.78915672e-02f, 4.35653217e-02f, -1.35070160e-01f, 4.48016152e-02f, 6.00945465e-02f, -4.02118266e-02f, -4.33637798e-02f, -1.58840030e-01f, 8.91470909e-02f, -1.24313496e-01f,
  1.30514443e-01f, -3.82649153e-02f, 9.68521833e-03f, 9.25871059e-02f, -3.05310637e-01f, -2.35787645e-01f, 1.24714188e-01f, 1.29098266e-01f, 1.44529089e-01f, -1.71328560e-01f,
  -1.68323457e-01f, -1.37851477e-01f, 2.23516487e-02f, 1.84171841e-01f, 7.24961907e-02f, -1.95021391e-01f, -2.04643324e-01f, -4.12875526e-02f, -1.01139145e-02f, 3.18811424e-02f,
  -1.64340928e-01f, -5.25005423e-02f, -4.01875302e-02f, 2.28908472e-02f, 6.82399869e-02f, -6.41692728e-02f, 8.36026669e-02f, -2.66626347e-02f, -1.00534461e-01f, -1.72648191e-01f,
  -2.34646276e-01f, -1.53095707e-01f, 3.72964777e-02f, -7.15047866e-02f, 5.40708750e-03f, -4.46202047e-02f, 8.67276415e-02f, 4.90625836e-02f, -1.24495380e-01f, 2.10424766e-01f,
  -6.85465559e-02f, 4.67354506e-02f, -2.88224906e-01f, -1.67773485e-01f, -2.29363218e-01f, -2.29988638e-02f, -1.31356806e-01f, 1.21306941e-01f, -3.82364728e-02f, -2.02752799e-02f,
  1.66957244e-01f, -2.37607658e-01f, 1.61129236e-01f, -9.76856053e-02f, -4.21735980e-02f, 1.18868358e-01f, 1.29708380e-01f, 2.68177569e-01f, 1.24102332e-01f, -1.15557946e-01f,
  7.32520446e-02f, -7.58618787e-02f, 1.98162124e-01f, -2.07958639e-01f, -4.35141511e-02f, -3.30332294e-02f, 1.51313860e-02f, 6.40515685e-02f, -2.49527782e-01f, -2.17048079e-01f,
  1.11417949e-01f, 5.81459925e-02f, -9.50831920e-03f, -6.25646338e-02f, -4.18129832e-01f, 2.90572375e-01f, -1.55859187e-01f, 3.13230366e-01f, 2.80342460e-01f, 2.12476373e-01f,
  8.66202563e-02f, 8.74729678e-02f, 1.01903208e-01f, -4.85794805e-02f, 1.10004470e-01f, 1.10433984e-03f, -9.01018158e-02f, 8.36966857e-02f, 9.05086324e-02f, 1.45353526e-01f,
  -4.15581279e-02f, 5.83328195e-02f, -2.68180855e-02f, -1.22901782e-01f, 6.61475062e-02f, 9.29719731e-02f, -4.61686868e-03f, 4.42161262e-02f, 8.10804591e-02f, -1.52917102e-01f,
  -6.37113005e-02f, 1.62759438e-01f, 2.44205222e-02f, -7.62007257e-04f, 2.44487420e-01f, -8.12885910e-02f, 4.20988649e-02f, 1.52463138e-01f, 4.30911072e-02f, 1.97836399e-01f,
  -2.67677549e-02f, -9.88755096e-03f, -7.57840946e-02f, 6.70981407e-02f, -1.81354523e-01f, 1.07674651e-01f, -5.86977415e-02f, 9.37090889e-02f, 6.08780831e-02f, -3.29231434e-02f,
  -4.71413732e-02f, -1.26227453e-01f, 1.84950590e-01f, -5.06584160e-02f, 3.24500687e-02f, 4.57000211e-02f, 1.29321501e-01f, 3.71814780e-02f, 2.64260739e-01f, -7.73814470e-02f,
  2.54317552e-01f, 2.39286423e-01f, 1.62436292e-02f, 1.54357776e-01f, 3.24229896e-03f, -4.83466685e-02f, 2.49414891e-01f, -2.02515349e-01f, 1.62528038e-01f, -2.59675026e-01f,
  -4.62695807e-02f, 1.04332671e-01f, -1.15267321e-01f, 1.21722380e-02f, -2.02861071e-01f, -7.79001638e-02f, 1.62562996e-01f, 2.10104557e-03f, 1.22719750e-01f, 4.71915975e-02f,
  1.60184801e-01f, 1.03945792e-01f, 1.46573223e-02f, -8.25780258e-02f, -1.62253365e-01f, 1.11232080e-01f, 1.03562593e-01f, 1.59400925e-01f, 1.08290844e-01f, 1.08011447e-01f,
  1.11105163e-02f, 2.40697369e-01f, -2.23112199e-02f, 1.76509589e-01f, 1.55397430e-01f, 3.99967134e-02f, 1.75830811e-01f, 2.62202136e-03f, 3.28297794e-01f, 6.66889995e-02f,
  -3.22135799e-02f, 5.39626181e-02f, 1.64888315e-02f, 1.81826115e-01f, 8.23351368e-02f, -7.25160241e-02f, -1.99640132e-02f, 1.14081696e-01f, 1.19499788e-02f, -9.71452147e-02f,
  -1.42415509e-01f, 2.01805815e-01f, 8.20618793e-02f, -1.08979836e-01f, -1.76645011e-01f, -6.19013496e-02f, 3.30627471e-01f, 1.87588304e-01f, 2.92498648e-01f, 2.78079629e-01f,
  1.03783133e-02f, -7.83589557e-02f, 4.22938280e-02f, 7.64494464e-02f, 2.72283167e-01f, 2.72623241e-01f, 1.62346601e-01f, 7.11671859e-02f, 2.51621366e-01f, -2.10047364e-02f,
  2.55618244e-02f, 1.05647761e-02f, 2.03424186e-01f, 3.56795974e-02f, 5.07193580e-02f, 5.50641939e-02f, -1.07983112e-01f, 1.38618469e-01f, 1.02376707e-01f, -1.37614250e-01f,
  -8.11470207e-03f, 4.66180742e-02f, -1.04497641e-01f, 2.34814119e-02f, -8.37953389e-02f, -1.62078794e-02f, 6.75032213e-02f, -8.27049091e-02f, -7.66209289e-02f, 1.25021795e-02f,
  5.89895584e-02f, -2.99296509e-02f, 3.39976959e-02f, -7.55221248e-02f, -1.01522349e-01f, -1.29577100e-01f, 4.10211571e-02f, 1.01079904e-02f, 6.50546402e-02f, -4.69144098e-02f,
  -1.96734339e-01f, 8.86149406e-02f, 1.11404866e-01f, 1.42319575e-01f, -1.80380791e-01f, -1.41694233e-01f, 1.12544820e-01f, 4.70180847e-02f, 3.04848403e-02f, 9.80212688e-02f,
  -2.98208441e-03f, -1.40682161e-01f, 2.02192031e-02f, -2.64237612e-01f, 1.16541415e-01f, -3.29392758e-04f, -7.72486553e-02f, 2.50989467e-01f, 5.14263809e-02f, -8.28256905e-02f,
  2.50384416e-02f, -1.51905298e-01f, 1.34890914e-01f, 1.55894339e-01f, -1.04438737e-01f, 1.39627278e-01f, -2.13638291e-01f, -1.36584789e-01f, 1.48470432e-01f, 5.32182716e-02f,
  9.66600925e-02f, 2.18817472e-01f, -1.15149930e-01f, 4.90244254e-02f, -1.59848943e-01f, 2.73483098e-02f, 7.04099312e-02f, 1.66987255e-01f, 6.75357953e-02f, -8.76151323e-02f,
  1.25594977e-02f, 2.52841383e-01f, -2.11199000e-02f, 2.78386734e-02f, 7.21490160e-02f, 9.40948799e-02f, -4.96474132e-02f, 1.74044389e-02f, -8.96167681e-02f, -5.14643751e-02f,
  5.51080257e-02f, -1.04869500e-01f, 2.49113832e-02f, 4.43306677e-02f, -1.05169676e-02f, -1.22119233e-01f, 6.99515864e-02f, -3.20498459e-02f, -2.21633777e-01f, -4.04765271e-02f,
  -6.70894384e-02f, -5.97891584e-02f, -1.42288864e-01f, -1.14603937e-02f, -6.93453103e-02f, -3.10076084e-02f, 1.88808367e-02f, 1.25513431e-02f, -1.10708058e-01f, -5.02250902e-02f,
  -6.88963309e-02f, 2.75911167e-02f, 1.93978533e-01f, -6.32739812e-02f, 7.61285052e-03f, 1.40218720e-01f, -1.81064904e-01f, -1.22359030e-01f, -7.78529420e-02f, 8.98485724e-03f,
  4.30174507e-02f, 2.08049461e-01f, -4.14597318e-02f, 4.19926494e-02f, -4.33006622e-02f, 1.32865116e-01f, -7.15022534e-02f, 1.06185414e-01f, -7.81791192e-03f, -5.36400191e-02f,
  9.01389346e-02f, 3.51906344e-02f, 9.72631574e-02f, -5.12788482e-02f, -1.06539495e-01f, 1.14482194e-01f, -7.79587030e-02f, 8.94798525e-03f, 1.03800684e-01f, 2.44290568e-02f,
  8.03323239e-02f, 4.95281741e-02f, -1.82119489e-01f, 9.12063196e-02f, 9.93839502e-02f, 3.60620357e-02f, 5.52346595e-02f, 9.54208001e-02f, -2.62839571e-02f, -1.13159411e-01f,
  1.43065110e-01f, 7.45187253e-02f, 1.01874895e-01f, 9.01518390e-02f, -1.70678765e-01f, 5.28264008e-02f, -2.61723455e-02f, 9.86541808e-03f, 9.87159088e-02f, 1.79418743e-01f,
  4.59566116e-02f, 1.02166891e-01f, -1.99248940e-02f, 1.40843332e-01f, 7.00661466e-02f, 4.38901447e-02f, -7.45089948e-02f, 2.02842634e-02f, 1.35503542e-02f, -1.47527993e-01f,
  7.70309567e-03f, -9.06780809e-02f, 2.50154704e-01f, 2.09344193e-01f, 1.74267232e-01f, -3.80057357e-02f, 7.69646699e-03f, 2.18163226e-02f, 2.10649800e-02f, -9.23760161e-02f,
  -8.95400718e-02f, 2.41504833e-01f, 5.13089597e-02f, 2.62952261e-02f, -2.35671028e-02f, -2.23608971e-01f, 2.32995048e-01f, -1.55700237e-01f, 4.21552584e-02f, 2.49858908e-02f,
  5.74149005e-02f, 1.68737382e-01f, 2.34586950e-02f, 3.50266218e-01f, 1.60917148e-01f, 1.70233831e-01f, 7.79624134e-02f, -8.42027515e-02f, 3.16853225e-01f, 1.36601746e-01f,
  -1.21939577e-01f, 1.70409590e-01f, 9.45965052e-02f, 1.19604096e-01f, 3.52835536e-01f, 8.07299688e-02f, 4.22611654e-01f, -1.73402041e-01f, -1.42194062e-01f, 2.00399309e-02f,
  -8.20084289e-02f, -4.67533246e-02f, 6.86009526e-02f, 7.40037337e-02f, 7.82444775e-02f, -3.06757446e-03f, -5.23461327e-02f, 3.09618246e-02f, -5.58758155e-03f, -9.69325602e-02f,
  -5.87070510e-02f, 9.44347959e-03f, 2.68398821e-02f, 4.25685849e-03f, 9.06790867e-02f, -2.51738690e-02f, -1.14503518e-01f, 8.90888274e-02f, -3.37227508e-02f, 5.23180775e-02f,
  3.03068608e-02f, 1.27990302e-02f, 2.34823868e-01f, 5.92714250e-02f, 3.08057647e-02f, 1.17526583e-01f, -8.03840458e-02f, -7.49209374e-02f, -1.57781690e-01f, -2.91916821e-02f,
  1.74015492e-01f, -5.58732711e-02f, -3.45735773e-02f, 1.00988105e-01f, 3.79630886e-02f, -1.90903202e-01f, -4.06925753e-02f, 1.38347179e-01f, -5.26742190e-02f, 1.73610494e-01f,
  -7.48048946e-02f, -2.96252668e-02f, 1.08349994e-01f, 2.98951745e-01f, 5.75136282e-02f, -1.15215264e-01f, -2.28133090e-02f, -1.11269906e-01f, -1.91866413e-01f, 1.80471495e-01f,
  1.28035516e-01f, 1.65561974e-01f, -1.91166028e-01f, -1.04078516e-01f, 1.37109533e-01f, 9.18546543e-02f, 3.14409994e-02f, 5.41116223e-02f, -1.24621745e-02f, 2.65993536e-01f,
  -1.04337633e-01f, 1.88847765e-01f, 1.76026374e-01f, 1.68667689e-01f, 3.91169846e-01f, 8.20560306e-02f, -1.22332931e-01f, -1.90966446e-02f, 2.32830420e-01f, 5.31307049e-02f,
  9.23161879e-02f, 6.15252741e-02f, 1.07383005e-01f, -1.36590511e-01f, -7.49678761e-02f, 3.29065472e-02f, -6.58488497e-02f, 1.06456235e-01f, 1.00088887e-01f, -2.36805417e-02f,
  1.70464322e-01f, -1.14548532e-02f, -5.77481091e-03f, 8.21099151e-03f, 7.67023340e-02f, -1.00559317e-01f, -1.70556292e-01f, 7.76767731e-02f, -1.49900198e-01f, 1.58061907e-02f,
  -5.17180376e-02f, 9.97634511e-03f, 4.10308540e-02f, -2.38850459e-01f, -2.23449394e-01f, 1.22006513e-01f, 1.66519117e-02f, 3.39646451e-02f, 1.77058518e-01f, -1.80386640e-02f,
  1.39874950e-01f, -2.26803824e-01f, -9.58435014e-02f, -2.02533767e-01f, 1.57427520e-01f, 2.03501239e-01f, 3.21404226e-02f, -9.85848531e-02f, 1.69045165e-01f, -2.65438139e-01f,
  3.35761487e-01f, -3.67003419e-02f, 4.78455499e-02f, -1.79719627e-01f, -1.34012178e-01f, 5.35099804e-02f, -1.21004041e-02f, -6.67341333e-03f, 1.46143809e-01f, 1.82167664e-01f,
  1.36499971e-01f, 7.74261206e-02f, -1.03691161e-01f, 3.85336801e-02f, 4.12780680e-02f, 2.68102735e-01f, 4.34167311e-02f, 1.29265428e-01f, -2.77737588e-01f, -1.83679298e-01f,
  -5.08643575e-02f, -1.05691962e-01f, 1.39333159e-01f, 3.28408256e-02f, 1.28960937e-01f, 6.78295875e-03f, 1.83900744e-02f, -1.75699908e-02f, -1.46655599e-02f, 4.89981659e-02f,
  1.45055326e-02f, 3.62537727e-02f, 2.00923700e-02f, 6.02639727e-02f, 1.46613613e-01f, 7.71605000e-02f, -9.03028622e-03f, 1.00306183e-01f, 2.26421170e-02f, -1.30722448e-01f,
  -2.02551782e-01f, -1.09027863e-01f, -1.61602482e-01f, 1.96061679e-03f, 5.55858910e-02f, 1.08837068e-01f, 2.19258264e-01f, -8.16258341e-02f, -1.42161965e-01f, 4.12451327e-02f,
  1.16804548e-01f, -1.83671519e-01f, 1.52505890e-01f, 1.26406521e-01f, 1.58128649e-01f, -1.81157157e-01f, 3.49110998e-02f, -1.40505791e-01f, 3.28432500e-01f, 1.46774590e-01f,
  -3.42853703e-02f, -2.50585407e-01f, -2.72900157e-04f, 1.25516038e-02f, 1.73271000e-01f, 1.29541740e-01f, 1.97401345e-01f, -1.86422363e-01f, 1.48519017e-02f, -9.42934304e-02f,
  2.27450311e-01f, 2.19114080e-01f, -8.73917267e-02f, 1.03928231e-01f, -4.53403667e-02f, 1.93643048e-01f, 2.16874525e-01f, 7.39385858e-02f, 9.08130482e-02f, -1.10344112e-01f,
  5.25805280e-02f, 2.18130544e-01f, -1.63943365e-01f, -9.39273983e-02f, 8.54555964e-02f, -7.85297900e-02f, 1.67336121e-01f, -4.21474129e-02f, 8.55006203e-02f, 1.51178330e-01f,
  -1.10100685e-02f, 1.29829258e-01f, 1.20210819e-01f, 7.18751550e-02f, 9.92805511e-02f, -9.38594863e-02f, 1.38436377e-01f, -1.79691657e-01f, 5.63840829e-02f, 2.04965379e-02f,
  9.54415947e-02f, 2.41801050e-02f, -1.45611316e-02f, 5.43977767e-02f, -3.04523818e-02f, -4.39997725e-02f, -3.28379810e-01f, -6.90729124e-03f, 4.24952917e-02f, 1.81830406e-01f,
  2.24772096e-01f, -2.39886805e-01f, 3.02640116e-03f, 8.47113207e-02f, 1.68823704e-01f, 1.96328282e-01f, 8.59449729e-02f, 1.19017452e-01f, 8.35674778e-02f, -1.49889052e-01f,
  -9.99166165e-03f, -1.82679608e-01f, 3.39234143e-01f, 3.15412253e-01f, -2.85280883e-01f, -1.70218702e-02f, -1.94659382e-01f, -2.18723014e-01f, 1.26500994e-01f, -7.33330175e-02f,
  2.68825814e-02f, 2.62408227e-01f, -2.86385536e-01f, -7.73559958e-02f, 1.41473964e-01f, -5.84334619e-02f, -3.22498888e-01f, 1.06813572e-01f, 8.21314007e-03f, 1.85934320e-01f,
  1.23114407e-01f, 3.39476839e-02f, -9.69042704e-02f, 1.00623704e-01f, 1.68995872e-01f, 1.70323223e-01f, -6.79858541e-03f, 1.15570789e-02f, 9.92107540e-02f, 7.55255818e-02f,
  -7.06756637e-02f, 4.80019636e-02f, -1.17585495e-01f, 3.93509232e-02f, 1.26079351e-01f, -6.57786727e-02f, 1.29919827e-01f, 4.05062037e-03f, 1.98521279e-02f, -2.07161948e-01f,
  -1.23564504e-01f, -1.44272044e-01f, -7.62051195e-02f, -1.77726552e-01f, 1.68430924e-01f, -9.85612795e-02f, 6.06674291e-02f, 5.05701825e-02f, -2.43987843e-01f, 1.22774020e-01f,
  -1.17600702e-01f, 5.37174977e-02f, -2.71500081e-01f, -1.54885769e-01f, -1.04737170e-01f, 9.79914591e-02f, -5.00354283e-02f, 1.48570716e-01f, 1.43620357e-01f, -1.66879166e-02f,
  9.29215327e-02f, -1.35846213e-01f, 1.96627751e-01f, -8.05582106e-02f, -6.26007393e-02f, 2.69220740e-01f, 2.28739660e-02f, 2.40942910e-01f, 6.36185780e-02f, -1.95961706e-02f,
  8.40299646e-04f, 1.01601779e-01f, 1.00092821e-01f, -1.01604834e-01f, 1.04161929e-02f, -1.40485659e-01f, 1.07053056e-01f, -3.24207321e-02f, -1.22623846e-01f, 2.08745718e-01f,
  -1.09048389e-01f, 2.91214064e-02f, -7.64493644e-02f, 1.20354556e-01f, -1.00917809e-01f, 2.78432131e-01f, -1.36772275e-01f, 2.23911718e-01f, 2.13249668e-01f, 2.73257732e-01f,
  3.71716768e-02f, 9.98290330e-02f, 1.55364975e-01f, -4.38218303e-02f, 1.80820879e-02f, -7.20682442e-02f, 1.00425832e-01f, 5.96899714e-04f, -7.05208033e-02f, 1.23876885e-01f,
  2.36014090e-02f, -4.68762256e-02f, -2.75874939e-02f, 6.16963096e-02f, -1.53453387e-02f, 1.23689463e-02f, 2.00286105e-01f, 4.19852547e-02f, 1.22019887e-01f, 1.96487367e-01f,
  6.67559803e-02f, 2.29605567e-02f, 1.60534382e-01f, -9.62087065e-02f, 1.21010944e-01f, 6.87251287e-03f, 1.77872434e-01f, 1.65852636e-01f, 8.17939788e-02f, 1.49913295e-03f,
  -1.41401254e-02f, -1.86365470e-01f, -1.27033055e-01f, -2.73249775e-01f, 3.29386331e-02f, 1.51158005e-01f, -1.89750995e-02f, 6.00840859e-02f, -6.94876909e-02f, -6.09823614e-02f,
  -6.38433173e-02f, -3.52070272e-01f, 1.72320202e-01f, -1.33293262e-02f, 1.01292796e-01f, 3.57093722e-01f, -9.14388672e-02f, 1.34481296e-01f, -1.61906034e-01f, 2.75941372e-01f,
  1.88500538e-01f, 1.53744921e-01f, 1.85022697e-01f, 4.15947475e-02f, -8.67196172e-02f, -2.11731523e-01f, -2.33457193e-01f, 6.17961073e-03f, 3.10014993e-01f, 1.54202968e-01f,
  4.09768432e-01f, -1.66261345e-01f, -1.93249270e-01f, 8.87095854e-02f, 8.34782347e-02f, -5.48868030e-02f, 1.33016080e-01f, -3.39632444e-02f, 6.42414540e-02f, 8.75251889e-02f,
  7.51626268e-02f, 6.79727346e-02f, -3.16827856e-02f, -1.41622378e-02f, 3.62087935e-02f, -8.58013034e-02f, -1.35483025e-02f, -4.55655716e-03f, -1.38241112e-01f, 2.00174004e-01f,
  1.11970991e-01f, 1.54017091e-01f, -1.01853453e-01f, 4.40469347e-02f, -7.89377466e-03f, -5.23123145e-03f, 3.28748114e-02f, 1.31925642e-01f, 6.27133325e-02f, -9.35328826e-02f,
  -8.22789669e-02f, -1.02194086e-01f, -1.81676909e-01f, 1.52091801e-01f, -1.55392975e-01f, 1.53386042e-01f, -1.53757453e-01f, 8.90087932e-02f, 6.92145675e-02f, 8.02441016e-02f,
  7.20903976e-03f, 1.13118365e-01f, 9.36961249e-02f, 1.06462529e-02f, -1.73964366e-01f, 8.84825215e-02f, 2.68488556e-01f, 2.07560703e-01f, 1.96089700e-01f, -4.39142473e-02f,
  9.21719074e-02f, -1.56101778e-01f, 1.57528102e-01f, -1.83942363e-01f, 1.14796840e-01f, 1.78447470e-01f, -2.46390626e-01f, -3.14555019e-01f, 3.11312735e-01f, 1.80657372e-01f,
  2.44811937e-01f, -2.53575921e-01f, -2.26220861e-01f, 1.97983515e-02f, 2.93142051e-02f, 3.24291527e-01f, -1.95560977e-02f, 4.13094200e-02f, -8.90499130e-02f, -6.06291480e-02f,
  -6.16083145e-02f, -2.00361367e-02f, 1.01745553e-01f, -1.94755103e-02f, 1.04043551e-01f, 5.14567345e-02f, -2.44579837e-02f, 1.39279515e-01f, 3.72734517e-02f, -2.03317706e-03f,
  -2.06454415e-02f, 1.17872365e-01f, 3.65695320e-02f, -4.17651795e-02f, 6.57957122e-02f, 3.63474600e-02f, 1.46081463e-01f, 9.47162285e-02f, -3.89751904e-02f, 9.22719240e-02f,
  2.54413307e-01f, -8.30165669e-02f, -2.16895327e-01f, 1.36001846e-02f, 2.59392679e-01f, 1.12577014e-01f, 3.61959636e-02f, -2.95468956e-01f, -1.73665866e-01f, 1.93280336e-02f,
  -1.65264785e-01f, -1.15595490e-01f, 1.22613207e-01f, 2.10108519e-01f, 1.09295025e-02f, 3.88162844e-02f, -2.26611450e-01f, -4.52839918e-02f, 2.56101549e-01f, -6.30353540e-02f,
  1.14978321e-01f, 1.35455266e-01f, 1.64830744e-01f, -2.19487071e-01f, 7.16725215e-02f, 1.18408903e-01f, -6.38677850e-02f, 4.56909120e-01f, -3.00975665e-02f, 4.92041744e-02f,
  -9.81254224e-03f, -3.84326279e-01f, 2.83197705e-02f, 2.67060827e-02f, 6.74146181e-03f, 3.47410172e-01f, -7.17915297e-02f, 2.69157290e-01f, 4.76522386e-01f, -6.14833273e-02f,
  -3.72846536e-02f, -6.58428892e-02f, -3.28365229e-02f, 2.04456262e-02f, 2.06031948e-02f, 1.10485286e-01f, -1.43029630e-01f, -5.23883738e-02f, -1.15632512e-01f, -2.12820828e-01f,
  8.16092119e-02f, -4.18429039e-02f, 1.58882558e-01f, -5.03218174e-02f, -1.31612895e-02f, -7.88690001e-02f, -9.68565047e-02f, -9.94688645e-02f, -1.76782291e-02f, -1.14734337e-01f,
  1.51700884e-01f, -1.73538402e-02f, 2.17048731e-02f, -3.16448919e-02f, -2.29385868e-01f, 1.27426326e-01f, -3.37671749e-02f, 1.60683736e-01f, -2.01821670e-01f, -1.18536435e-01f,
  3.48620713e-02f, 4.00207900e-02f, -1.11768954e-01f, 5.85551821e-02f, -7.47453198e-02f, -2.22647354e-01f, 1.99921224e-02f, -2.67527580e-01f, 1.44046351e-01f, -4.90028858e-02f,
  -1.20590337e-01f, 2.69834995e-01f, 1.11521278e-02f, -1.31950006e-01f, 1.78913295e-01f, -2.58374244e-01f, 1.96971327e-01f, 1.51336014e-01f, 1.05937809e-01f, 1.60934418e-01f,
  -1.88804880e-01f, 1.21960893e-01f, 1.68851152e-01f, 1.50051638e-01f, 1.35109350e-01f, 2.69995630e-01f, -1.27535984e-01f, -1.29632637e-01f, -2.98907518e-01f, 1.96724683e-01f,
  1.78655475e-01f, 2.17800707e-01f, 1.66863203e-01f, -2.05986217e-01f, 1.99064370e-02f, 1.08841240e-01f, 1.25193940e-02f, 8.21409747e-02f, -7.99811929e-02f, -4.13133539e-02f,
  8.55715945e-02f, -4.62009422e-02f, 1.21350877e-01f, 2.85419952e-02f, 1.40588030e-01f, -5.13709560e-02f, -5.81097715e-02f, 1.30542502e-01f, 1.01210475e-01f, -2.61131907e-03f,
  1.36111513e-01f, -4.66580763e-02f, 3.53282057e-02f, 7.24461395e-03f, 4.24855500e-02f, 5.53084388e-02f, 1.34901062e-01f, -1.32841319e-01f, -1.29435867e-01f, -4.74000461e-02f,
  1.06441127e-02f, 3.75908986e-02f, 2.53224783e-02f, 1.29769519e-01f, 2.91304260e-01f, -2.82769185e-02f, -2.48387549e-03f, 5.54707050e-02f, 7.81438649e-02f, -6.63608611e-02f,
  -1.36400834e-02f, -1.42891882e-02f, 2.40421500e-02f, -3.72174531e-02f, 8.96091610e-02f, -1.90586999e-01f, 1.77507237e-01f, 8.48925263e-02f, -5.98384701e-02f, -1.77127942e-01f,
  1.20840715e-02f, 1.92759618e-01f, -7.26421997e-02f, 1.36728182e-01f, 1.39919341e-01f, -1.46773875e-01f, -3.85765508e-02f, -2.61962879e-02f, 3.70816320e-01f, 3.61800224e-01f,
  -1.93435341e-01f, 6.03652410e-02f, -8.33615661e-03f, 2.05889642e-01f, 2.01918960e-01f, 1.93353239e-02f, 3.42715420e-02f, -1.36766195e-01f, 1.25690222e-01f, 2.36481518e-01f,
  -2.10970640e-01f, -8.18607807e-02f, 1.65583134e-01f, 6.21003956e-02f, 5.40164895e-02f, -2.91449036e-02f, 1.93663384e-03f, 9.71801710e-05f, 8.57520325e-04f, 1.74006164e-01f,
  3.31676528e-02f, -5.54059818e-03f, 7.34604001e-02f, -1.54943846e-04f, 1.50170317e-02f, -6.60379836e-03f, -5.27747627e-03f, 3.85805778e-02f, 8.48042369e-02f, 7.58052617e-02f,
  6.41492233e-02f, 8.13990086e-02f, 1.58101618e-01f, -2.09337845e-02f, 6.51700199e-02f, 8.97157639e-02f, -4.92941141e-02f, -5.28167328e-03f, -1.47475824e-01f, 6.92451000e-02f,
  1.15640990e-01f, -8.53498057e-02f, 3.00505739e-02f, 6.59717945e-04f, 2.15713736e-02f, -9.60860401e-02f, 1.91887617e-02f, 1.65476888e-01f, -7.29454830e-02f, 1.66592851e-01f,
  -1.43703446e-01f, -2.61346549e-01f, 9.17005762e-02f, 1.23882569e-01f, 1.13301925e-01f, 1.94956556e-01f, -2.93209970e-01f, -1.44515902e-01f, -2.06284806e-01f, 1.75166264e-01f,
  2.25435540e-01f, 5.03461361e-02f, -9.34417248e-02f, -1.49176210e-01f, 2.21054837e-01f, -7.84625635e-02f, -2.38644660e-01f, -4.03057113e-02f, -5.67160584e-02f, 2.68516302e-01f,
  -1.56113775e-02f, 5.01117930e-02f, 2.30722465e-02f, 2.14196295e-01f, 3.01516861e-01f, 7.89296925e-02f, 2.42284369e-02f, -8.02403763e-02f, 4.18153852e-02f, 2.30660718e-02f,
  -6.31531999e-02f, 9.42925960e-02f, 4.77906056e-02f, 6.61699772e-02f, -1.13255225e-01f, 5.92163838e-02f, 7.80924484e-02f, 1.85945891e-02f, 4.61570583e-02f, 1.50013909e-01f,
  -7.37547651e-02f, 1.01081081e-01f, 6.13822453e-02f, -2.00135067e-01f, -9.54474434e-02f, 1.33116052e-01f, -1.10045839e-02f, -9.14669037e-02f, 3.07760686e-01f, -8.97517726e-02f,
  1.03597522e-01f, 1.51404902e-01f, 9.29428339e-02f, 2.03801960e-01f, 6.80557564e-02f, -5.98655306e-02f, -1.58032514e-02f, 1.60225737e-03f, -2.12634623e-01f, 2.07934350e-01f,
  -1.79477021e-01f, 1.24698617e-01f, 8.59867595e-03f, -5.65072931e-02f, -3.81857157e-02f, -1.32059485e-01f, 1.46138564e-01f, -8.79580248e-03f, 2.11620703e-02f, 1.14987180e-01f,
  5.64736091e-02f, 1.43066600e-01f, 2.83618480e-01f, -1.33075118e-01f, 3.17396700e-01f, 2.19588801e-01f, 2.49919042e-01f, 2.19834536e-01f, 3.54843438e-02f, 8.79266039e-02f,
  3.09943229e-01f, -6.14795424e-02f, 2.16496482e-01f, -3.33895057e-01f, 1.62257224e-01f, 2.15691645e-02f, -1.35682479e-01f, -5.08556031e-02f, -2.02291951e-01f, -1.09465726e-01f,
  -1.91542767e-02f, 4.25736494e-02f, 3.59558761e-01f, -7.92993531e-02f, 7.56118223e-02f, 3.30526978e-01f, 1.64496526e-01f, -2.50787903e-02f, -7.79062584e-02f, 9.35799181e-02f,
  1.67416722e-01f, 2.51742192e-02f, 1.94507584e-01f, -5.23937233e-02f, -2.49844491e-02f, 8.08256045e-02f, 4.98724654e-02f, 6.02857880e-02f, 1.96101397e-01f, -6.67526722e-02f,
  -3.86473089e-02f, -8.53680074e-03f, 7.27683380e-02f, 1.23091906e-01f, -5.68460859e-02f, 2.85222828e-01f, 3.13321143e-01f, -8.07648152e-02f, 2.12633193e-01f, -9.91420373e-02f,
  1.74960613e-01f, 1.93104044e-01f, 1.23021873e-02f, -2.53853202e-01f, -3.18816155e-02f, -5.32190017e-02f, -3.17859054e-02f, -1.02293737e-01f, 2.54628304e-02f, 1.31683186e-01f,
  9.25991088e-02f, 1.83662787e-01f, -5.32674864e-02f, -1.47440299e-01f, -9.27817822e-02f, -2.44877204e-01f, -1.40077338e-01f, 2.05299988e-01f, 4.04501334e-02f, -1.40036508e-01f,
  8.46019611e-02f, 3.03390622e-01f, -5.83252050e-02f, 1.12424403e-01f, 3.96610126e-02f, 1.24464341e-01f, 1.39187872e-01f, 6.68851286e-02f, -2.25073770e-01f, 4.95185703e-02f,
  7.00610206e-02f, 2.29473069e-01f, 2.20195577e-01f, -7.61890188e-02f
};

// L3_fan_Bp_bar (Shape: 1 x 26)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 26;
const float L3_fan_Bp_bar_data[] = {
  8.11075196e-02f, 8.10629651e-02f, -2.85830814e-03f, 1.13053218e-01f, 7.81222731e-02f, 2.32068002e-02f, 3.07397712e-02f, 1.15497010e-02f, -1.03569506e-02f, 5.91374934e-02f,
  4.98792389e-03f, -3.05300038e-02f, 3.26338597e-02f, 1.31019324e-01f, 7.20623434e-02f, 3.40057425e-02f, -3.99914943e-03f, 8.11963752e-02f, 9.23472494e-02f, -2.54930649e-02f,
  1.10173814e-01f, 5.07367179e-02f, -1.15941279e-02f, 2.86978576e-02f, -7.74664730e-02f, 3.69885825e-02f
};

// L4_linear_W (Shape: 12 x 64)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 64;
const float L4_linear_W_data[] = {
  4.49729264e-02f, -2.94633675e-02f, -2.88669169e-02f, -1.15918413e-01f, 4.42936681e-02f, -1.10617451e-01f, -1.16716072e-01f, 1.23688862e-01f, -4.01362441e-02f, -1.41035497e-01f,
  1.02303229e-01f, 7.04119429e-02f, 1.28823340e-01f, -2.62934603e-02f, 8.25263560e-02f, -4.97397557e-02f, 6.26070052e-02f, -1.13344910e-02f, -1.26890808e-01f, -1.54016271e-01f,
  -1.12943478e-01f, -2.43185647e-02f, 1.06440030e-01f, -5.67133352e-02f, 2.21943811e-01f, 1.61697447e-01f, 1.31008580e-01f, -1.01799689e-01f, -1.40549809e-01f, -1.73804343e-01f,
  -2.12956831e-01f, 9.53026523e-04f, -1.78061739e-01f, 1.07766524e-01f, -1.32254317e-01f, 1.25624418e-01f, 1.99448228e-01f, -3.93891819e-02f, -8.60715955e-02f, 3.20275500e-02f,
  -2.31166646e-01f, -3.07719946e-01f, 2.52124786e-01f, -2.09970117e-01f, 2.07022682e-01f, 3.01214427e-01f, -1.26217544e-01f, -4.77122456e-01f, -9.23261270e-02f, 8.60605687e-02f,
  -3.52146804e-01f, -1.14224002e-01f, 2.11138815e-01f, 2.96431910e-02f, -5.02182357e-03f, 1.70335963e-01f, -1.65469218e-02f, 1.90886155e-01f, -3.15342933e-01f, -7.22161233e-02f,
  -1.25843391e-01f, -2.19920635e-01f, -2.43886366e-01f, -3.11636776e-01f, -9.40123945e-02f, 1.32121183e-02f, -2.28300155e-03f, -8.97089392e-02f, 8.51787440e-03f, -5.39304949e-02f,
  1.32008404e-01f, -9.03365538e-02f, -9.06206667e-03f, 7.48920394e-03f, -1.07919537e-01f, 7.27677271e-02f, -1.36170581e-01f, -1.92678925e-02f, -1.62770718e-01f, -7.01095676e-03f,
  -1.75156578e-01f, 4.36978675e-02f, -2.40752716e-02f, 1.83497891e-01f, -9.09996778e-03f, -1.38385430e-01f, 1.16958596e-01f, 2.06571221e-02f, 2.17118740e-01f, 1.40053749e-01f,
  1.21470727e-01f, 1.81077838e-01f, 5.10716774e-02f, 4.27452587e-02f, 1.95958123e-01f, 1.56793669e-01f, 1.82126641e-01f, 1.16683491e-01f, -1.67368889e-01f, 1.35666132e-02f,
  -2.34666780e-01f, -8.57848749e-02f, -1.48270383e-01f, 1.57638714e-01f, -2.04351380e-01f, -2.19317839e-01f, 1.14278369e-01f, 2.24119291e-01f, 3.32416564e-01f, -2.56877970e-02f,
  1.64296612e-01f, 1.96989141e-02f, -2.14000076e-01f, 1.47686154e-01f, -1.54752180e-01f, 9.22351629e-02f, 1.16588950e-01f, -2.95541316e-01f, -3.52742106e-01f, -1.60598069e-01f,
  -3.35126519e-01f, 2.63186216e-01f, 6.21246621e-02f, -3.20048779e-01f, -2.86606550e-01f, -2.75096536e-01f, 1.92669466e-01f, -2.99221009e-01f, 1.19803781e-02f, 8.46870430e-03f,
  -8.48328844e-02f, 1.14564849e-02f, 9.40372050e-03f, 7.59367505e-03f, -4.33837622e-02f, 1.04470700e-01f, -1.59314498e-02f, -3.51233520e-02f, -1.14527583e-01f, 9.14987996e-02f,
  -9.67612863e-02f, 8.93797725e-02f, -1.19806871e-01f, 1.40007779e-01f, -2.59758513e-02f, 1.94815710e-01f, 2.42351651e-01f, -7.28987753e-02f, 2.59976804e-01f, -1.13810465e-01f,
  -3.05086136e-01f, -5.59069216e-02f, -2.61845827e-01f, -2.01652035e-01f, -1.19346067e-01f, -5.32791838e-02f, 4.47681434e-02f, 1.57161802e-01f, -2.12446660e-01f, 8.16327929e-02f,
  2.14535072e-01f, 9.73586831e-03f, 1.10431939e-01f, 2.97308803e-01f, -1.43813834e-01f, -2.07281038e-01f, -9.16694626e-02f, 4.06180955e-02f, -2.69058585e-01f, -3.45862597e-01f,
  -3.13881040e-01f, 2.75439322e-01f, -1.02564193e-01f, -2.63700962e-01f, 1.27827510e-01f, 1.73913598e-01f, -1.83200464e-01f, -1.43790230e-01f, -9.40309558e-03f, -1.69814508e-02f,
  -8.39128122e-02f, -1.07470833e-01f, -2.32653826e-01f, -4.03232336e-01f, 3.46042275e-01f, 9.85862762e-02f, 2.32080385e-01f, -8.92126635e-02f, -1.46813601e-01f, 1.50127262e-01f,
  6.79578856e-02f, -1.47151381e-01f, 8.83886591e-03f, 3.19748111e-02f, -5.59730977e-02f, 9.86568332e-02f, -1.26349255e-01f, 3.55726592e-02f, -1.10613614e-01f, 4.46649566e-02f,
  7.19112307e-02f, 1.72952741e-01f, -1.81698829e-01f, -1.54799879e-01f, 4.43850681e-02f, -1.80995598e-01f, -6.04455508e-02f, 5.58289960e-02f, -4.24375907e-02f, -1.64536640e-01f,
  1.76858440e-01f, -1.70313060e-01f, -1.44250169e-01f, 2.46965647e-01f, -1.66172273e-02f, 1.94546148e-01f, 2.39205733e-01f, -5.12597784e-02f, -2.19892457e-01f, -1.92738011e-01f,
  1.23342633e-01f, -1.38836935e-01f, 8.10092017e-02f, -2.72902787e-01f, -4.20443416e-02f, 1.11322872e-01f, 7.79426396e-02f, -2.15892613e-01f, 4.25882824e-03f, -1.26806170e-01f,
  2.09565580e-01f, -2.57347107e-01f, 1.40741631e-01f, 1.93278432e-01f, 2.89440807e-03f, 1.30813420e-02f, -2.08983924e-02f, 1.39880359e-01f, -9.36200470e-02f, -4.26592797e-01f,
  8.39428231e-02f, 1.69540271e-01f, -4.42417175e-01f, 1.47957474e-01f, -3.83251727e-01f, -3.59260410e-01f, 1.06387503e-01f, 2.59379119e-01f, -3.38309705e-01f, -4.15426373e-01f,
  7.38189220e-02f, 3.75506654e-02f, -3.02322716e-01f, 1.26444817e-01f, -1.34166470e-02f, -7.87964165e-02f, 7.77807534e-02f, 1.26630306e-01f, -4.40941900e-02f, 2.12169383e-02f,
  6.23753406e-02f, 1.23141184e-01f, 1.56299949e-01f, -6.23870790e-02f, -3.01930159e-02f, -7.91583359e-02f, -1.01986922e-01f, 1.68225020e-01f, -7.52556603e-03f, -9.06527042e-02f,
  1.15024269e-01f, 1.53935537e-01f, -1.60885248e-02f, 7.46480376e-02f, 1.79365396e-01f, -1.77243382e-01f, 3.58454846e-02f, -2.15309545e-01f, -1.90429650e-02f, -2.55648524e-01f,
  -2.23850340e-01f, 2.94767767e-02f, -3.70759852e-02f, -1.41538650e-01f, -1.45674989e-01f, 9.53852758e-02f, 2.10406750e-01f, 5.79104759e-02f, -1.21827172e-02f, -2.54034132e-01f,
  5.39427251e-02f, 2.75883116e-02f, 4.34209257e-02f, 1.27415508e-01f, -2.80652225e-01f, -3.42278592e-02f, 2.27553144e-01f, -2.05503870e-02f, 6.61821663e-02f, -3.03166895e-03f,
  -2.57978588e-01f, 6.09951280e-02f, -3.76089990e-01f, -8.03636089e-02f, 1.12763897e-01f, 1.00725722e-02f, -9.94511247e-02f, -3.57167087e-02f, 2.13197157e-01f, 8.89472142e-02f,
  2.33491868e-01f, 8.62411708e-02f, -4.16616410e-01f, -2.34340772e-01f, 1.93786703e-03f, -8.69369227e-03f, 1.83332101e-01f, -3.16111594e-01f, -4.07326669e-01f, 2.89706200e-01f,
  9.22175823e-04f, 1.20359227e-01f, -7.89861158e-02f, -1.83789432e-01f, -1.30290002e-01f, 4.51866873e-02f, 4.98765009e-03f, 1.96564034e-01f, -1.00422585e-02f, 5.57236783e-02f,
  9.84203890e-02f, -2.13806462e-02f, -4.63970099e-03f, 1.36701018e-01f, -7.65128210e-02f, 1.52312621e-01f, -1.06584989e-01f, -1.39140204e-01f, 1.86937422e-01f, 9.19770263e-03f,
  -1.43979609e-01f, 2.62415558e-02f, 1.46164864e-01f, 1.08553700e-01f, -2.06079260e-01f, 9.64720771e-02f, -1.18244335e-01f, 5.65701723e-02f, -1.04309395e-01f, 1.17464393e-01f,
  -1.69438794e-01f, -5.43166175e-02f, -1.33588776e-01f, 8.15986246e-02f, -1.86169922e-01f, 2.48593032e-01f, -1.30993113e-01f, -1.94109917e-01f, -7.92497098e-02f, 2.45368823e-01f,
  -6.20135479e-02f, -2.15506881e-01f, 1.68536574e-01f, -2.45580167e-01f, -2.18590125e-01f, -3.39729369e-01f, 1.73662201e-01f, -4.19289172e-02f, -1.00053675e-01f, 1.83182396e-02f,
  1.47890747e-01f, -2.84232527e-01f, -1.34988399e-02f, 6.64385334e-02f, 1.98796049e-01f, 1.32685974e-02f, -1.90789089e-01f, -1.19116470e-01f, -2.85530061e-01f, -4.47209924e-01f,
  1.25264108e-01f, -2.08501607e-01f, 2.32080951e-01f, 8.61197114e-02f, -1.23924389e-01f, -1.84676558e-01f, 7.04436675e-02f, 6.97354972e-02f, 2.25247353e-01f, -1.50317401e-01f,
  9.25816670e-02f, -2.43548006e-02f, -2.28988938e-02f, 1.35147527e-01f, -7.63228536e-03f, -1.18992902e-01f, 2.13753790e-01f, -4.22052927e-02f, -1.01667084e-01f, -6.45094961e-02f,
  9.79068801e-02f, -1.14193105e-03f, -1.20222688e-01f, -2.28195727e-01f, 1.01448826e-01f, -2.17423946e-01f, 9.25433633e-05f, -1.05083905e-01f, 1.38598368e-01f, -1.46716073e-01f,
  2.22097725e-01f, 1.89127311e-01f, -1.26524925e-01f, 1.31780311e-01f, -1.19461328e-01f, -7.43265525e-02f, 1.61333174e-01f, -5.18014356e-02f, 8.05464685e-02f, 4.77371886e-02f,
  -5.57121681e-03f, 5.05935512e-02f, 4.22948487e-02f, -2.78009623e-01f, -3.15796614e-01f, -3.64149287e-02f, -1.98366866e-02f, -1.65229157e-01f, -3.99324670e-02f, 1.37238009e-02f,
  4.72453125e-02f, 1.81918293e-01f, 1.11173645e-01f, -1.19240871e-02f, 1.87958822e-01f, -3.82074594e-01f, -3.11957061e-01f, 5.26009277e-02f, -2.30410233e-01f, -3.27067077e-01f,
  2.36012712e-01f, -3.77496541e-01f, -2.71604210e-01f, 1.67617992e-01f, 1.63592860e-01f, -3.69409591e-01f, 1.75470799e-01f, -2.59433001e-01f, 1.45581618e-01f, -2.06968725e-01f,
  -1.01451464e-02f, 2.40129158e-02f, -3.06735467e-02f, 1.81006730e-01f, 7.33422413e-02f, 1.28316447e-01f, -5.68439439e-02f, 1.98678419e-01f, 7.14526251e-02f, -1.99324608e-01f,
  -9.25360993e-02f, -6.19122125e-02f, -1.46000445e-01f, -9.62038562e-02f, -1.54288225e-02f, -2.06208490e-02f, -8.81883055e-02f, -1.46807479e-02f, -3.04824114e-01f, -7.96704460e-03f,
  2.65086919e-01f, 2.10973695e-01f, 1.64427474e-01f, -7.67338127e-02f, 1.81334272e-01f, 2.41827622e-01f, -1.81687504e-01f, -9.43333134e-02f, 1.00810520e-01f, -6.96057156e-02f,
  -2.15764329e-01f, -1.54846147e-01f, 7.73039460e-02f, 1.92365795e-01f, 2.27217078e-01f, -2.62586623e-01f, -1.94034413e-01f, -2.11916611e-01f, 8.77745375e-02f, 9.90872085e-02f,
  -2.45524600e-01f, -3.06525938e-02f, -6.38796240e-02f, -2.86066622e-01f, -2.46522248e-01f, 1.23872096e-02f, -4.10682291e-01f, -1.20563008e-01f, 1.18817084e-01f, 1.05856776e-01f,
  -2.57326126e-01f, -1.20097235e-01f, 2.20471159e-01f, -5.36032200e-01f, 2.98496276e-01f, -1.14824861e-01f, 4.07118410e-01f, -1.93433076e-01f, -1.53800264e-01f, 1.07656144e-01f,
  -2.67315894e-01f, 1.16605125e-01f, 1.41928755e-02f, -1.58602357e-01f, 2.37251278e-02f, -2.81183571e-01f, 4.27272730e-02f, -4.96402904e-02f, -1.93209291e-01f, 1.27018793e-02f,
  -8.79535079e-02f, 2.72672996e-02f, 2.88110655e-02f, 7.61461481e-02f, -5.99887259e-02f, -1.11916438e-01f, 2.05039587e-02f, -1.15951002e-02f, -4.88480181e-02f, -1.50609866e-01f,
  -3.18199769e-02f, -1.03303627e-03f, -6.62880950e-03f, 1.71954647e-01f, -5.46780229e-02f, -1.86179951e-01f, -3.00738048e-02f, 1.23305805e-01f, -5.54467812e-02f, 5.35709150e-02f,
  9.44778398e-02f, -2.44198844e-01f, -5.39663322e-02f, -1.59011148e-02f, 9.37727392e-02f, 1.66275263e-01f, -2.57774264e-01f, -3.50307792e-01f, 2.01177955e-01f, 2.78147012e-01f,
  1.45578399e-01f, -1.26605660e-01f, -1.76266968e-01f, 9.89864990e-02f, -5.66864274e-02f, 2.22316056e-01f, -4.50076610e-02f, 2.95229018e-01f, -1.49771664e-03f, 5.98880313e-02f,
  2.08209425e-01f, -2.22990066e-01f, -2.39345595e-01f, 2.96807233e-02f, 4.56585251e-02f, -1.28529713e-01f, -2.11837947e-01f, 2.76036918e-01f, 1.37282565e-01f, 5.06338179e-02f,
  1.78914949e-01f, 4.32439029e-01f, -1.51976332e-01f, 7.27623999e-02f, -1.62974045e-01f, -2.75730878e-01f, 1.32465243e-01f, -4.86066975e-02f, -5.08217141e-02f, 6.76535815e-03f,
  -3.04243620e-02f, 9.08106491e-02f, -6.01204932e-02f, -2.64657021e-01f, -1.17064193e-02f, -5.95934540e-02f, -1.88346636e-02f, 2.04177916e-01f, -5.41821346e-02f, 1.12567104e-01f,
  7.25847017e-03f, -1.07635789e-01f, 4.80830148e-02f, -9.46154892e-02f, -2.10813582e-02f, -4.19868790e-02f, 1.26549870e-01f, -9.77687538e-02f, 5.11090159e-02f, -1.84916452e-01f,
  -8.71770084e-02f, -1.95702508e-01f, 1.90215886e-01f, -1.44482538e-01f, 1.33842662e-01f, -2.65026808e-01f, 1.01088043e-02f, -3.54409665e-02f, -2.32451648e-01f, 1.54302955e-01f,
  5.87058924e-02f, -1.79362431e-01f, -2.38526449e-01f, 5.56068905e-02f, -2.09799167e-02f, -2.83907056e-01f, -4.33507502e-01f, 3.56841050e-02f, 1.59338742e-01f, -5.18107302e-02f,
  -3.31836343e-02f, -3.76133591e-01f, -3.08838397e-01f, -1.88763827e-01f, 7.34896362e-02f, -2.73645759e-01f, 2.27912694e-01f, -3.39011818e-01f, 2.02505156e-01f, 2.33644009e-01f,
  7.30278865e-02f, -1.68722957e-01f, -3.04509066e-02f, -2.64879584e-01f, 3.92994046e-01f, -1.34688234e-02f, 1.46934524e-01f, -1.58873990e-01f, -1.47158325e-01f, -2.10853502e-01f,
  -8.88513997e-02f, 2.17462927e-01f, -8.96064416e-02f, 1.67657852e-01f, 1.01864837e-01f, -3.38252708e-02f, 1.41554222e-01f, -8.24120343e-02f, 6.24696054e-02f, -2.43335813e-01f,
  7.42358640e-02f, 5.32616004e-02f, 9.67579186e-02f, 1.74211189e-01f, 1.17337763e-01f, 1.98369678e-02f, -1.29308030e-02f, 4.84914929e-02f, -1.27745584e-01f, 8.88897106e-02f,
  -6.70765489e-02f, 2.25874826e-01f, 5.39523400e-02f, 2.97197282e-01f, 1.39110625e-01f, 2.38958336e-02f, 3.48161533e-02f, 1.61289468e-01f, 1.25170082e-01f, 8.29650462e-02f,
  -3.71413562e-03f, 2.48147160e-01f, -9.47050676e-02f, -1.16825677e-01f, 2.70826906e-01f, 1.11098424e-01f, 1.56447858e-01f, -1.91939756e-01f, 3.04579169e-01f, 2.06200466e-01f,
  1.34384856e-01f, -1.33050457e-01f, 6.89765736e-02f, -1.90356970e-01f, -9.91981030e-02f, 9.48657691e-02f, -2.17207044e-01f, 2.84325898e-01f, -1.05409790e-02f, 3.50428279e-03f,
  -3.65754753e-01f, 2.07260177e-01f, -1.08384393e-01f, -4.28249151e-01f, -3.30861956e-01f, -4.22773010e-04f, -2.12956607e-01f, 1.10126749e-01f, -3.27143967e-01f, -4.55803782e-01f,
  -3.16790193e-01f, 1.99552700e-01f, -3.16240132e-01f, 5.22374026e-02f, 9.38526765e-02f, 1.25902146e-01f, 5.86903840e-02f, 3.21749225e-03f, 1.17922977e-01f, -1.53095767e-01f,
  -1.38711289e-01f, -2.48137768e-03f, -4.27403115e-02f, -6.16302043e-02f, 6.63150474e-02f, -3.57535644e-03f, -4.48077545e-02f, 7.27627128e-02f, 7.71567896e-02f, 3.21906470e-02f,
  -6.87674955e-02f, -1.79790296e-02f, -1.66086033e-01f, 1.12667590e-01f, 1.12671942e-01f, 1.84113085e-01f, -1.24742188e-01f, -5.96763305e-02f, -1.82844877e-01f, 2.81286221e-02f,
  -8.37588310e-02f, -5.48123680e-02f, 1.51758999e-01f, -1.11437172e-01f, 1.87437907e-01f, -7.23711401e-02f, 1.94616467e-01f, -9.42060351e-02f, 7.69717619e-03f, -6.78654164e-02f,
  -1.00092813e-01f, 1.64324299e-01f, -2.48470813e-01f, 1.44777782e-02f, 3.43250453e-01f, 1.85109869e-01f, -2.92344779e-01f, -2.38102674e-01f, 5.92092872e-02f, -2.97898799e-01f,
  -9.11838785e-02f, 9.65129137e-02f, 1.22960486e-01f, 1.65883452e-01f, -1.33920848e-01f, 3.76954153e-02f, -2.51854867e-01f, -1.77271385e-02f, -2.73292750e-01f, 4.79737818e-02f,
  1.52840838e-01f, -3.62538189e-01f, -4.91639763e-01f, 2.67702371e-01f, 7.77245592e-03f, 7.37711191e-02f, -6.82587475e-02f, 2.18200058e-01f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  -4.79148813e-02f, 7.52284452e-02f, -1.23292562e-02f, 8.66536945e-02f, 1.21753089e-01f, -5.21014631e-02f, -4.12159078e-02f, -3.96016985e-02f, 1.59253124e-02f, 6.64939657e-02f,
  -1.51686289e-03f, -2.42679957e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 19, 26
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 19, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        64, 19, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        64, 19, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        64, 12
    );
    }
    