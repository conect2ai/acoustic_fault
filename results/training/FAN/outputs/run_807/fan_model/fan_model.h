/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 3 x 120)
const int L0_fan_Wp_rows = 3;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  1.03571571e-01f, -2.35779598e-01f, 1.60871580e-01f, -2.44223885e-02f, 1.55421525e-01f, 1.60116658e-01f, 5.98119758e-03f, 1.71513543e-01f, 6.92727119e-02f, -1.45359278e-01f,
  -4.97397743e-02f, -1.30827725e-01f, -1.81572005e-01f, -1.09383531e-01f, 1.42742917e-01f, 1.12661608e-02f, 1.28264010e-01f, 2.82640010e-02f, 2.40934610e-01f, 9.35766473e-02f,
  -9.44806337e-02f, -1.28025293e-01f, 8.24654326e-02f, 5.90394177e-02f, -7.26186261e-02f, -3.72547358e-02f, -1.15682572e-01f, -2.76137665e-02f, -2.15558112e-02f, -3.27163160e-01f,
  -3.00182641e-01f, -1.55393809e-01f, 1.39570937e-01f, 1.94361843e-02f, -4.55662310e-02f, 2.17306446e-02f, -2.50417944e-02f, 1.10513987e-02f, -5.81865339e-03f, 2.36353409e-02f,
  -4.34894860e-02f, -9.48292091e-02f, 7.43973628e-02f, -9.37223807e-02f, -2.22256742e-02f, -3.16470340e-02f, -1.61956362e-02f, -2.20620017e-02f, -2.42232960e-02f, -6.12144433e-02f,
  -3.05430535e-02f, -8.81421790e-02f, -1.40529114e-03f, 1.62032634e-01f, 3.45522426e-02f, -1.61519293e-02f, 9.87587217e-03f, 9.59802512e-03f, 1.57755941e-01f, -1.17986612e-01f,
  4.04261090e-02f, -5.10500297e-02f, 5.59810363e-02f, -1.42590264e-02f, -4.23955673e-04f, -4.53149378e-02f, 5.64519353e-02f, -4.05489057e-02f, 4.99137752e-02f, -4.02075350e-02f,
  8.75277370e-02f, 2.74790972e-02f, -6.46755025e-02f, -1.45610869e-02f, -1.48493135e-02f, 1.60013195e-02f, 1.22595234e-02f, 1.87159907e-02f, 8.20239261e-02f, -3.96959111e-02f,
  -4.32923436e-02f, -1.26563972e-02f, -2.87888609e-02f, -1.72318090e-02f, -2.63826009e-02f, -1.41509818e-02f, 5.53946234e-02f, 2.96708546e-03f, 3.53547335e-02f, -2.62384322e-02f,
  -1.53740421e-01f, 2.00166360e-01f, -1.57954872e-01f, -2.76656952e-02f, -1.33360270e-02f, -4.48424332e-02f, -1.01255260e-01f, 1.14234895e-01f, -5.96026108e-02f, -6.73035206e-03f,
  -4.34503378e-03f, 3.39615382e-02f, -6.86355755e-02f, 1.97673496e-02f, 4.06726561e-02f, 4.31234054e-02f, 4.83488552e-02f, 9.80155077e-03f, 7.33909532e-02f, -1.79410689e-02f,
  9.02821198e-02f, 3.27983014e-02f, -7.05799367e-03f, -1.55492248e-02f, -7.82158524e-02f, 6.31892458e-02f, -1.07019041e-02f, -8.32426772e-02f, 4.76626717e-02f, -4.35070619e-02f,
  3.67080778e-01f, 1.46827651e-02f, -2.92891920e-01f, 3.01379040e-02f, -2.47506037e-01f, 6.05734298e-03f, -7.86862746e-02f, 6.21969551e-02f, -5.40196970e-02f, -1.03009477e-01f,
  6.69884011e-02f, 6.59372211e-02f, -6.53114617e-02f, 1.99971050e-02f, 1.18770257e-01f, 4.03646799e-03f, 3.21305431e-02f, -1.85228959e-02f, 1.82218596e-01f, 5.05588353e-02f,
  6.09490871e-02f, -5.18076383e-02f, 1.63103923e-01f, 2.36801937e-01f, -3.33787858e-01f, -5.75323179e-02f, -1.93888694e-01f, -6.99338168e-02f, 8.89980569e-02f, -5.74593782e-01f,
  -2.59981513e-01f, 5.67853712e-02f, -6.91505373e-02f, 1.31028831e-01f, -1.08499393e-01f, 4.76285554e-02f, 2.24120654e-02f, -2.74950471e-02f, -2.10311320e-02f, 6.02658130e-02f,
  7.07762432e-04f, 5.04162200e-02f, 3.60057987e-02f, -4.95133288e-02f, -5.66658303e-02f, -2.14892272e-02f, 4.33689691e-02f, 1.17999159e-01f, 2.88698468e-02f, -6.35398552e-02f,
  -3.33676003e-02f, 5.23120072e-03f, -5.24612144e-02f, -1.86623028e-03f, 7.56264254e-02f, -5.73742501e-02f, -8.49731639e-03f, -4.78624366e-02f, -4.88750963e-03f, -1.77926004e-01f,
  -5.12615554e-02f, -1.91658027e-02f, 1.49287740e-02f, 1.13220029e-02f, -3.07264831e-02f, -6.55738860e-02f, 1.03123607e-02f, 2.10375711e-02f, 2.44028424e-03f, -4.11512591e-02f,
  -1.18409181e-02f, -1.08815599e-02f, -2.34894976e-02f, -2.09722994e-03f, -4.09569778e-02f, -1.71352308e-02f, -1.49678150e-02f, 3.17867920e-02f, 6.39602393e-02f, 2.01796386e-02f,
  -2.75612250e-02f, 2.19260156e-02f, -4.62688804e-02f, 5.11807092e-02f, 2.68354472e-02f, -6.46679383e-03f, -1.51662051e-03f, 2.17829607e-02f, 3.02616078e-02f, -3.23927365e-02f,
  7.73106962e-02f, 2.66049542e-02f, -1.43956849e-02f, -4.91265673e-03f, 2.29392014e-02f, -3.66086848e-02f, -5.65142650e-03f, 1.43001862e-02f, 2.23708991e-02f, 1.50117837e-02f,
  6.50618598e-02f, 4.89237383e-02f, 3.05884760e-02f, 5.43058962e-02f, 1.30637195e-02f, 8.06836504e-03f, 4.46585789e-02f, -3.24393599e-03f, -2.18496677e-02f, 4.90157679e-02f,
  2.09463555e-02f, 8.47120360e-02f, 7.40948617e-02f, -1.25973513e-02f, -1.26535492e-02f, -3.17090601e-02f, -1.19019873e-01f, -5.38046844e-02f, 6.74579814e-02f, -3.46935429e-02f,
  -4.47741687e-01f, 3.08181256e-01f, 2.11815685e-01f, -1.06873967e-01f, 6.73726797e-02f, -1.16169378e-02f, 2.38389999e-01f, -2.19935980e-02f, 8.12751520e-03f, 2.05085412e-01f,
  7.81904310e-02f, -5.01825847e-02f, 1.41004682e-01f, -6.80128559e-02f, -1.11698747e-01f, 3.29490840e-01f, 2.29189277e-01f, -1.30056158e-01f, -3.54230791e-01f, -2.51986653e-01f,
  -3.49178314e-02f, 1.29040793e-01f, -2.65973836e-01f, -2.80256897e-01f, 2.30283678e-01f, -1.60020471e-01f, 3.08241576e-01f, 8.28478783e-02f, -1.69204637e-01f, 4.51133847e-01f,
  -1.04603402e-01f, -6.63533956e-02f, -7.35589042e-02f, -5.00994697e-02f, 1.42523954e-02f, 2.98002511e-02f, 6.50784466e-04f, 2.89590769e-02f, -5.24686873e-02f, 5.43811060e-02f,
  7.78403282e-02f, 3.36773433e-02f, 3.88681367e-02f, -2.76236366e-02f, -6.10451074e-03f, -1.22430716e-02f, -7.70466495e-03f, -3.53410989e-02f, -7.04465958e-04f, 3.65730636e-02f,
  4.27316092e-02f, -5.23510352e-02f, -1.12017523e-02f, -2.47143526e-02f, -6.17157146e-02f, -1.04441881e-01f, 4.05091755e-02f, -1.87817499e-01f, -1.21379063e-01f, 1.28311008e-01f,
  -3.59994359e-02f, 2.10201535e-02f, -5.61893638e-03f, 1.22891217e-02f, -8.73495713e-02f, 1.45118721e-02f, 1.46328481e-02f, 6.95307925e-02f, 3.22384760e-02f, -5.81083074e-02f,
  6.36433810e-02f, 1.98892616e-02f, -3.48660466e-03f, 2.16004215e-02f, 5.32542430e-02f, -6.39697444e-03f, -2.02512159e-03f, 7.24435002e-02f, -1.92241762e-02f, -5.75657599e-02f,
  -4.91848774e-02f, -8.65420559e-04f, 4.55932207e-02f, 7.69577641e-03f, -2.15755906e-02f, -5.80476224e-02f, 7.03518167e-02f, -3.82261984e-02f, 4.09065858e-02f, -5.25466017e-02f,
  1.10861883e-01f, -6.53205067e-02f, 1.80312190e-02f, -3.51913832e-02f, 3.73819470e-02f, -8.64483491e-02f, 3.18111591e-02f, -9.03935507e-02f, 7.36007914e-02f, 1.75310094e-02f,
  -3.19119431e-02f, -1.41003029e-02f, 7.33341947e-02f, -3.96706443e-03f, -8.24444741e-03f, -9.33795702e-03f, 9.32191759e-02f, 4.24550772e-02f, -3.24422531e-02f, 2.05416977e-02f,
  1.15003482e-01f, 5.49418032e-02f, -3.23502533e-02f, 4.80340756e-02f, -2.02776920e-02f, -6.00727163e-02f, 3.22031900e-02f, -1.87025163e-02f, -6.21838421e-02f, 7.54563585e-02f
};

// L0_fan_Wp_bar (Shape: 10 x 120)
const int L0_fan_Wp_bar_rows = 10;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -6.93988800e-01f, 2.51391768e-01f, 1.55703396e-01f, -2.24836633e-01f, 7.47179787e-04f, 1.37975201e-01f, -1.20697699e-01f, -4.29354273e-02f, 1.06864691e-01f, 1.75579637e-02f,
  1.11680053e-01f, -1.54467449e-01f, -6.78509101e-02f, 8.03982839e-02f, -1.55537695e-01f, 5.60408086e-02f, -1.53470799e-01f, -2.60127097e-01f, -2.83979625e-01f, -1.63205974e-02f,
  -1.34239838e-01f, -3.80758166e-01f, -3.71865302e-01f, -6.07461017e-03f, 3.87518704e-02f, -5.09573929e-02f, 7.61451349e-02f, -1.45676494e-01f, 1.45950213e-01f, 4.32719588e-02f,
  1.23552568e-01f, -4.26515341e-02f, -3.72851640e-02f, -5.44450022e-02f, -3.93237062e-02f, -5.90488464e-02f, -6.47849292e-02f, -6.88870326e-02f, -6.49758847e-04f, 1.20510068e-02f,
  -1.73340645e-02f, -8.22633058e-02f, -7.21173361e-02f, 2.72107106e-02f, -1.29138738e-01f, -1.17295785e-02f, 1.08704276e-01f, -3.61954495e-02f, 4.78989668e-02f, 1.26992568e-01f,
  9.77837220e-02f, 4.03223112e-02f, 7.38202855e-02f, 8.33904445e-02f, 9.80748907e-02f, -3.91102992e-02f, 1.61119327e-01f, 1.01474203e-01f, -1.42226534e-04f, 8.92591923e-02f,
  -1.82203613e-02f, 6.43352792e-02f, 3.76941524e-02f, -3.87512073e-02f, 2.13939301e-03f, 1.11231849e-01f, -4.02013958e-02f, -2.00134385e-02f, -1.76253691e-02f, -8.21992941e-03f,
  -9.72585287e-03f, 1.36154583e-02f, -3.24729420e-02f, -8.70216079e-03f, 7.42599070e-02f, -3.80732119e-02f, -4.54034880e-02f, 2.20192540e-02f, 2.93048900e-02f, -7.05635324e-02f,
  9.71889347e-02f, 5.23958281e-02f, 6.10017031e-02f, 3.17633934e-02f, -2.63455207e-04f, 7.29196984e-03f, -5.92017956e-02f, 2.19934266e-02f, -3.79931275e-03f, -1.25305606e-02f,
  -7.83554278e-03f, 5.76362833e-02f, -1.19009679e-02f, 4.51700650e-02f, -2.72844359e-02f, 8.12181234e-02f, 7.03112688e-03f, -2.59562451e-02f, 3.44246924e-02f, -1.16133988e-02f,
  1.12740628e-01f, -4.78392169e-02f, 6.28202260e-02f, -8.30157893e-04f, -2.19570752e-02f, 6.26575947e-02f, -5.26547246e-02f, -4.83689271e-03f, 3.52168567e-02f, 6.13504499e-02f,
  1.64877757e-01f, 7.33941123e-02f, 6.10133968e-02f, 4.18831296e-02f, 1.03308387e-01f, -7.40621239e-02f, 1.05319716e-01f, 7.32737035e-02f, -1.38051718e-01f, 6.83188587e-02f,
  1.91532299e-01f, 2.70198196e-01f, 6.07256442e-02f, 6.31670374e-03f, -1.75571740e-01f, 4.13531885e-02f, 1.14736155e-01f, -9.00388733e-02f, -7.48647600e-02f, 4.69413996e-02f,
  6.86957389e-02f, -5.78145944e-02f, -2.21381821e-02f, -8.28482434e-02f, 1.69589654e-01f, 1.50623083e-01f, 7.35870190e-03f, 2.49727890e-02f, -1.19264431e-01f, -4.88656275e-02f,
  -6.07580803e-02f, 1.46557942e-01f, 8.38267803e-02f, 7.85462409e-02f, 1.48282036e-01f, -1.95866346e-01f, 3.25228721e-02f, 8.26492831e-02f, -8.56251642e-02f, 2.12404355e-02f,
  1.41997766e-02f, 1.62938207e-01f, -1.17579058e-01f, 7.16493651e-02f, 5.31678237e-02f, 1.17351122e-01f, 8.51425305e-02f, -5.88334315e-02f, 2.27318276e-02f, -2.58608367e-02f,
  -4.33099316e-03f, -4.78121378e-02f, 5.08523993e-02f, -2.06775181e-02f, 9.65485349e-02f, 5.52720055e-02f, 4.22316864e-02f, 1.72581956e-01f, 2.61562802e-02f, 5.27569354e-02f,
  -6.22299351e-02f, 6.94348216e-02f, -1.18979178e-02f, -9.84628685e-03f, 3.30722779e-02f, 2.53626239e-02f, 1.75820515e-02f, 4.33286205e-02f, 2.55571958e-02f, 4.42722924e-02f,
  -5.87770492e-02f, -1.67665586e-01f, -2.67569069e-02f, -2.91784797e-02f, -5.10723814e-02f, -1.28171463e-02f, -1.08022345e-02f, 9.86851975e-02f, 2.76398808e-02f, 1.55417668e-02f,
  -5.04407212e-02f, -2.55954806e-02f, 1.90846231e-02f, 3.59340645e-02f, -2.03906707e-02f, 6.14703372e-02f, 3.08615789e-02f, -2.26210821e-02f, -1.63282529e-01f, 1.83425192e-02f,
  -9.53355208e-02f, 9.59267188e-03f, -3.46740056e-03f, 2.77425963e-02f, 9.48241130e-02f, 3.15008648e-02f, 1.63996518e-02f, 5.01740351e-02f, 2.12443303e-02f, -6.86107278e-02f,
  -3.98370400e-02f, -2.06938684e-02f, 5.52671216e-02f, 1.00390777e-01f, -8.61632973e-02f, 3.94049250e-02f, 1.05991825e-01f, -1.35705441e-01f, -8.21950473e-03f, -5.47311977e-02f,
  9.34484042e-03f, -1.74375623e-02f, 7.43872821e-02f, 1.14143111e-01f, -1.67267136e-02f, -7.05614984e-02f, -2.55056471e-03f, -3.23211811e-02f, 4.41615209e-02f, -4.68601175e-02f,
  -2.05936190e-02f, -8.96369144e-02f, -2.06641123e-01f, -1.22709952e-01f, -1.52892189e-03f, -1.81533754e-01f, -1.12445191e-01f, -4.75811027e-02f, -2.31430829e-02f, -1.23844057e-01f,
  -5.33708692e-01f, 3.09037082e-02f, -1.90459505e-01f, -2.55155563e-01f, 1.68065146e-01f, 1.50091827e-01f, -1.00816816e-01f, -2.60684285e-02f, 8.50948170e-02f, -3.71197760e-02f,
  8.04498717e-02f, -8.13399702e-02f, -1.23380713e-01f, -6.07729740e-02f, -3.51014346e-01f, -4.80250902e-02f, -3.01173925e-01f, -2.07308337e-01f, -1.83829352e-01f, 1.94772594e-02f,
  1.28634706e-01f, -2.49475434e-01f, -2.64528900e-01f, 2.02345163e-01f, 1.00393027e-01f, 1.20098889e-01f, -5.69672883e-02f, -8.85481909e-02f, 2.75541604e-01f, -5.24752289e-02f,
  -3.88823710e-02f, 2.42076859e-01f, -1.02288775e-01f, -7.16951191e-02f, 4.79457416e-02f, 1.20741367e-01f, -4.68660193e-03f, -1.98943214e-03f, 2.35905424e-02f, 1.03175482e-02f,
  1.31468129e-04f, 5.16935512e-02f, -8.50903466e-02f, 1.72122661e-02f, -1.09585410e-03f, -8.38269815e-02f, -3.06360219e-02f, -1.46835193e-01f, -1.54906750e-01f, 5.65946139e-02f,
  3.36908922e-02f, -1.50314914e-02f, -1.01634666e-01f, 9.67901796e-02f, -2.86024492e-02f, -1.20046295e-01f, -6.79740310e-03f, 1.05877295e-01f, -1.00080026e-02f, -8.23025033e-03f,
  1.08679221e-03f, -6.58361018e-02f, 1.45327048e-02f, 3.28609832e-02f, -4.16389741e-02f, 4.66175191e-02f, 2.11308282e-02f, 8.26025382e-02f, -6.51009381e-02f, -7.41734984e-05f,
  2.22040601e-02f, -1.81994848e-02f, 7.53923729e-02f, -4.87112477e-02f, -3.36828269e-02f, 3.73331644e-02f, -3.40953320e-02f, -2.77414620e-02f, -3.26538533e-02f, 6.36201948e-02f,
  -1.03860892e-01f, -2.25751605e-02f, -8.07165578e-02f, 5.12228645e-02f, 1.24175092e-02f, -8.85189977e-03f, -3.66077088e-02f, -3.78921852e-02f, 2.47026086e-02f, 5.82757108e-02f,
  -1.06168531e-01f, -7.26678446e-02f, -6.30075624e-03f, -4.41378402e-03f, 2.59204265e-02f, -6.37511443e-03f, 8.03916529e-02f, 1.49120018e-02f, 1.68076716e-02f, -6.50530085e-02f,
  -9.64851752e-02f, -2.49248929e-02f, 4.71760966e-02f, 3.27356234e-02f, -6.50058091e-02f, -3.07649694e-04f, -3.75342951e-03f, -2.76585086e-03f, -7.79789090e-02f, 5.11055775e-02f,
  -1.87060863e-01f, -1.39500752e-01f, -2.40859628e-01f, -1.85778007e-01f, -8.66760463e-02f, -1.08173162e-01f, -5.45641966e-02f, -1.36529552e-02f, -1.33444577e-01f, -1.56400785e-01f,
  2.69378752e-01f, 1.19148288e-02f, -8.47571120e-02f, 1.16587743e-01f, 5.44956140e-02f, -2.07618281e-01f, -1.94167554e-01f, -1.24424234e-01f, -9.25835129e-03f, 1.12666711e-01f,
  -6.63180277e-02f, 2.10612267e-02f, -1.45946532e-01f, -2.46488862e-03f, -1.98243931e-01f, -9.84280463e-03f, 7.74974301e-02f, 7.89587665e-03f, -7.71482214e-02f, -1.23183943e-01f,
  -7.42943957e-02f, 7.55618587e-02f, 1.16096295e-01f, -9.10959616e-02f, 2.24037454e-01f, -4.87886965e-02f, 5.63497543e-02f, 1.36747837e-01f, 7.17015862e-02f, 3.61765444e-01f,
  5.28121516e-02f, 2.28304312e-01f, -1.10309245e-02f, 8.54226127e-02f, -3.70285809e-02f, 1.94982216e-02f, -9.92857292e-02f, 5.80241680e-02f, -8.60537738e-02f, 4.17903662e-02f,
  -6.40344713e-03f, -6.75548390e-02f, -5.48470207e-02f, -4.24590707e-02f, -9.43905413e-02f, -7.11116567e-02f, -4.25069258e-02f, 4.23386581e-02f, -9.49516669e-02f, -5.62590063e-02f,
  6.33116961e-02f, 1.44125447e-02f, -6.32171854e-02f, -1.07016481e-01f, -3.75651605e-02f, 4.94622216e-02f, -7.46271908e-02f, 7.94394612e-02f, -5.68950437e-02f, -5.55974841e-02f,
  1.14796683e-02f, -3.22534591e-02f, 1.13424778e-01f, 5.17884903e-02f, 4.21070401e-03f, -5.27265258e-02f, 4.04722663e-03f, -4.78678010e-02f, -1.17282785e-01f, 4.27320674e-02f,
  -3.90888676e-02f, 1.98222399e-02f, -1.34736687e-01f, -2.51800707e-03f, 2.59754211e-02f, 2.04472058e-02f, -1.70213275e-03f, 3.26513760e-02f, 4.45304736e-02f, 1.04537368e-01f,
  -2.22706199e-02f, -6.70086872e-03f, -2.40511689e-02f, -3.69311720e-02f, 1.04958817e-01f, 1.16175637e-01f, -4.39887121e-02f, -5.03187031e-02f, 3.85047756e-02f, 3.25122289e-02f,
  -2.36585945e-01f, -1.06870539e-01f, 4.45502298e-03f, 8.32639821e-03f, 2.02017277e-02f, 3.73857617e-02f, 8.65502656e-02f, 8.81273001e-02f, 6.69330284e-02f, -1.78025644e-02f,
  -2.33491454e-02f, 2.76530191e-04f, 4.79726605e-02f, 4.62435074e-02f, -1.34185374e-01f, 5.67211956e-02f, -8.43267981e-03f, -1.29278556e-01f, -5.55460341e-03f, -8.30471981e-03f,
  -1.00778155e-01f, -1.13045186e-01f, -1.72907665e-01f, -1.38761356e-01f, -3.40281837e-02f, -5.24916165e-02f, -1.70006514e-01f, -3.84414680e-02f, -2.11086035e-01f, -2.23623663e-01f,
  -1.59425303e-01f, 4.32715826e-02f, 6.43183962e-02f, 2.59757102e-01f, 1.42622277e-01f, 1.92779582e-02f, 1.40357941e-01f, 6.74619153e-02f, 9.43780765e-02f, -4.78992499e-02f,
  -4.80369255e-02f, 1.37713343e-01f, 7.57661834e-02f, 3.51109020e-02f, 1.55258235e-02f, 2.12313652e-01f, 2.07507044e-01f, 5.20815030e-02f, -9.11795273e-02f, -6.23633079e-02f,
  1.49058148e-01f, -5.86505271e-02f, -1.35175407e-01f, -4.18915898e-02f, 1.99920878e-01f, 1.78808972e-01f, 1.04761936e-01f, -2.01643571e-01f, -1.95728261e-02f, 1.07907861e-01f,
  -7.06702545e-02f, -1.06972314e-01f, 8.12131241e-02f, -1.07517682e-01f, -8.18171650e-02f, -2.71844510e-02f, -8.27669203e-02f, -8.17119256e-02f, -4.83323410e-02f, -2.16319077e-02f,
  -3.19296755e-02f, -1.38375908e-01f, 9.52766538e-02f, -4.35532164e-03f, -2.01538410e-02f, -6.59987936e-03f, -4.19586748e-02f, 5.33271432e-02f, 8.86522755e-02f, 3.25292386e-02f,
  1.57031521e-01f, -6.51972964e-02f, -1.22682706e-01f, 1.24360844e-01f, 8.23437572e-02f, 5.05532362e-02f, 6.57378882e-02f, 1.39155775e-01f, 5.19981459e-02f, 3.22150141e-02f,
  9.99537036e-02f, -8.59657302e-03f, 1.67871112e-04f, -5.26444390e-02f, 1.99601743e-02f, 1.33352103e-02f, 5.59355319e-02f, -5.57175465e-03f, -3.60069866e-03f, -7.69193172e-02f,
  -7.15937987e-02f, 8.25987011e-02f, 3.13450918e-02f, 1.95620637e-02f, 9.98738483e-02f, 1.13573074e-02f, -1.00289965e-02f, 3.36151794e-02f, -6.96152216e-03f, -2.85000764e-02f,
  -2.39243209e-02f, -4.56641242e-02f, -1.83789991e-02f, 7.08882511e-02f, 3.67597193e-02f, 1.38144121e-02f, 6.31097853e-02f, -9.46313217e-02f, -5.30409962e-02f, -2.40154285e-02f,
  -1.70172349e-01f, 5.17347008e-02f, 8.76983479e-02f, 2.95352004e-02f, -2.48256102e-02f, 1.99994538e-02f, 1.14877276e-01f, -8.66818279e-02f, -2.14950480e-02f, 2.10150629e-02f,
  -1.05663486e-01f, -4.62610759e-02f, -4.56559248e-02f, -3.48056927e-02f, -4.86154594e-02f, -6.78961575e-02f, -5.18316776e-02f, -5.95418643e-03f, -4.19561155e-02f, -8.70409328e-03f,
  6.54325038e-02f, -1.10229753e-01f, -2.04486802e-01f, 6.56699464e-02f, 6.06644973e-02f, -5.39949676e-03f, -6.29637837e-02f, -1.12222679e-01f, -1.05289169e-01f, -4.29772539e-03f,
  -3.12613696e-02f, -2.32619435e-01f, 8.82008374e-02f, -2.21032538e-02f, 1.28667042e-01f, 6.60464540e-02f, 1.12151258e-01f, 2.68336851e-02f, -7.59947151e-02f, -2.28982773e-02f,
  1.80311184e-02f, -1.24333113e-01f, -1.43397823e-01f, -9.42855626e-02f, 5.81603982e-02f, 1.04988612e-01f, 1.95664644e-01f, 1.20177045e-01f, 8.79176110e-02f, -1.55733963e-02f,
  -1.10992856e-01f, 4.42300923e-02f, 6.42403066e-02f, -5.96275367e-02f, 6.53907508e-02f, -1.60595089e-01f, -2.90921554e-02f, 1.06476635e-01f, -4.37229872e-02f, 7.33097494e-02f,
  3.40829343e-02f, -3.62013397e-03f, -1.47742098e-02f, -4.93713394e-02f, -4.13937047e-02f, -7.87649956e-03f, 2.57149572e-03f, 4.77617271e-02f, 5.16572315e-03f, 4.43998873e-02f,
  -7.70157501e-02f, 7.70069733e-02f, -6.11289963e-02f, 4.03899662e-02f, 1.13954470e-02f, 1.11957453e-02f, 4.36324477e-02f, 1.05401399e-02f, 7.39821643e-02f, -1.32711068e-01f,
  -7.16101527e-02f, 3.78907546e-02f, -2.98937988e-02f, 1.03415269e-02f, 4.97664511e-02f, 4.15964471e-03f, 5.17085567e-02f, -7.72069246e-02f, 1.33471668e-01f, -8.88561979e-02f,
  -4.44702357e-02f, 1.44481808e-02f, 9.13936794e-02f, 4.26039025e-02f, -8.21947902e-02f, 2.94559319e-02f, 8.83682221e-02f, -3.94181311e-02f, 7.21999025e-03f, -1.90910473e-02f,
  -2.14037783e-02f, -5.37348948e-02f, 1.21740974e-01f, -4.13258821e-02f, -8.38635415e-02f, -5.32188118e-02f, -3.93368937e-02f, -8.56947005e-02f, -4.84016500e-02f, 1.02498673e-01f,
  1.03647478e-01f, -3.40134604e-03f, -9.14656650e-03f, 5.43915890e-02f, 7.43822902e-02f, 1.75434183e-02f, -3.15525122e-02f, -4.67733555e-02f, -1.04798853e-01f, 4.81748693e-02f,
  2.49132335e-01f, 1.55728936e-01f, 1.27696972e-02f, 8.81463811e-02f, 1.08153842e-01f, -7.24509805e-02f, 5.14287092e-02f, -7.54393563e-02f, -2.40886081e-02f, -1.64572056e-02f,
  8.15966576e-02f, -5.22650070e-02f, -1.04505420e-02f, -2.46575344e-02f, 9.59826447e-03f, -3.11996471e-02f, 7.29922578e-03f, 6.14592284e-02f, 3.24205197e-02f, 8.46234560e-02f,
  -5.13030738e-02f, 3.81682292e-02f, 4.58768290e-03f, 2.47767568e-02f, 6.31429106e-02f, -3.18200439e-02f, -6.42191768e-02f, 1.20296162e-02f, 5.95913231e-02f, -8.84782076e-02f,
  6.50771856e-01f, 1.68585375e-01f, 9.93405804e-02f, -1.17362559e-01f, 8.36486071e-02f, -3.43682873e-03f, 2.54385829e-01f, 1.02622248e-01f, -8.75334814e-02f, 4.40366790e-02f,
  4.00835052e-02f, -9.82694551e-02f, -1.78530291e-01f, -2.44270191e-01f, 5.32444566e-02f, -4.93148305e-02f, 5.77520058e-02f, -1.04652688e-01f, -2.19790012e-01f, 5.04202880e-02f,
  -2.06985772e-01f, 1.11562453e-01f, 2.68929422e-01f, -2.18335278e-02f, 8.06224793e-02f, -2.38056496e-01f, -3.19506265e-02f, 1.79060400e-01f, 4.09589559e-02f, 2.70126741e-02f,
  2.21257851e-01f, 4.54787344e-01f, -3.56605917e-01f, -1.45640761e-01f, 9.60704461e-02f, 2.29923278e-02f, -3.32803577e-02f, 6.76518679e-02f, -3.81853501e-03f, 2.54367758e-02f,
  1.48970753e-01f, -7.50382012e-03f, 1.58156771e-02f, -1.00114107e-01f, 1.02503128e-01f, -7.40833357e-02f, 5.99981286e-04f, 8.57610032e-02f, -1.13749534e-01f, -6.33233115e-02f,
  -4.60191779e-02f, 1.32357702e-01f, 1.73934683e-01f, -3.64765860e-02f, 1.32934913e-01f, -6.66389242e-02f, 8.86305422e-02f, 1.03652999e-01f, -3.26113999e-02f, 4.13988009e-02f,
  -1.38366740e-04f, 1.13998428e-01f, -7.00104460e-02f, 2.64636222e-02f, -4.16430086e-02f, 8.87480080e-02f, 1.26862284e-02f, -8.45847800e-02f, -3.74169573e-02f, 8.05228055e-02f,
  -3.19801196e-02f, -4.99291206e-03f, 3.80002968e-02f, 1.75359771e-02f, -9.29043069e-02f, 4.46826443e-02f, -9.57961306e-02f, 8.48987885e-03f, 9.51479897e-02f, 1.26978559e-02f,
  -8.88226628e-02f, 1.01276897e-02f, -3.98640595e-02f, 1.36131933e-02f, -9.83651448e-03f, -1.32437572e-01f, -9.46415365e-02f, 1.37422858e-02f, 2.93881297e-02f, 7.00770989e-02f,
  -2.76264131e-01f, -1.86826140e-01f, -1.03358783e-01f, -8.98715109e-03f, 3.77106257e-02f, -3.89068685e-02f, -5.32314479e-02f, 4.89181615e-02f, -3.07246819e-02f, -2.08926331e-02f,
  -8.89739320e-02f, 8.80357251e-02f, -2.82930546e-02f, -5.16693741e-02f, -1.10439621e-01f, 1.37680452e-02f, 4.62269783e-02f, -5.93520850e-02f, -9.78022963e-02f, 1.29493311e-01f,
  -7.85790533e-02f, -1.03314139e-01f, -7.87517056e-02f, -7.70713687e-02f, -9.26791653e-02f, -1.44153014e-01f, -1.84139729e-01f, -9.98354331e-02f, -8.76859576e-02f, -2.94728547e-01f,
  -5.20262957e-01f, 2.62887310e-02f, -5.41891195e-02f, 7.70837590e-02f, 1.25874653e-01f, 3.15249532e-01f, 4.64603245e-01f, 2.03439564e-01f, -3.00569888e-02f, 5.11227995e-02f,
  -2.47799791e-02f, -6.09775819e-02f, -6.30779862e-02f, -3.01826764e-02f, -1.65750049e-02f, 2.07662091e-01f, 1.81560293e-01f, -9.70083326e-02f, -1.44461900e-01f, 9.13966447e-02f,
  1.33936286e-01f, -1.40765637e-01f, -1.77307263e-01f, 4.60004807e-02f, 1.12466246e-01f, 1.81826204e-02f, -1.82165746e-02f, -6.90697655e-02f, 8.44915807e-02f, 1.90005317e-01f,
  -7.22982362e-02f, -6.88470826e-02f, 1.74264126e-02f, -1.46736130e-01f, 6.84528723e-02f, -7.66607150e-02f, -7.04952851e-02f, -1.68363765e-01f, -5.04938290e-02f, -6.13561086e-03f,
  -3.42780910e-02f, -6.74598441e-02f, -3.43134552e-02f, -6.09193072e-02f, -6.03968278e-02f, 2.77876947e-02f, -6.64715618e-02f, -7.76784346e-02f, -9.04228538e-02f, 5.25202453e-02f,
  5.10475598e-02f, 1.73597981e-03f, -9.30778906e-02f, -9.19108465e-02f, -6.49140328e-02f, -5.44691011e-02f, 2.28917948e-03f, -2.70356126e-02f, -1.17396884e-01f, -2.61619948e-02f,
  3.19546349e-02f, -2.99304500e-02f, 5.51440008e-02f, 2.33482067e-02f, 6.95525855e-02f, 5.54970815e-04f, 3.78749669e-02f, -4.83389087e-02f, -4.42852378e-02f, -1.33641707e-02f,
  6.87573664e-03f, 3.89459990e-02f, -2.22190730e-02f, 7.58848991e-03f, 3.05775814e-02f, -3.42622660e-02f, 1.14265373e-02f, 3.16273198e-02f, -3.97535823e-02f, 3.51168704e-03f,
  -6.89289346e-03f, -1.13852091e-01f, -8.67291689e-02f, -6.25133887e-02f, 2.22986899e-02f, 9.88577977e-02f, -4.64759097e-02f, -2.17271242e-02f, -1.30963502e-02f, -6.90729590e-03f,
  -1.81339085e-01f, 1.36685390e-02f, -1.24447927e-01f, 1.12743527e-02f, -4.22649458e-02f, 3.45984567e-03f, -3.90843023e-03f, -1.94144826e-02f, -2.47156061e-02f, 6.02646954e-02f,
  -3.39138396e-02f, -5.94144687e-02f, -7.19145080e-03f, 4.30403166e-02f, -9.08005238e-02f, 5.71816079e-02f, 1.62567366e-02f, -8.68823603e-02f, -3.79727334e-02f, -2.27321014e-02f,
  -2.70233527e-02f, -3.14772539e-02f, -1.95153862e-01f, -7.98374414e-02f, -6.61503449e-02f, -1.16009563e-01f, -1.14804603e-01f, 1.78998224e-02f, -1.18029937e-01f, -8.08569267e-02f,
  4.72075880e-01f, 1.35514498e-01f, -1.55244216e-01f, 3.32914889e-01f, 1.12191118e-01f, -3.52780819e-02f, -8.15718994e-03f, 2.58061569e-02f, 1.51649505e-01f, 1.61646888e-01f,
  2.44245574e-01f, 3.88310492e-01f, 3.71051699e-01f, 2.27031410e-01f, -2.63370965e-02f, -3.80258448e-02f, 4.45209593e-02f, -8.89729857e-02f, 2.71173194e-02f, 3.24066803e-02f,
  3.72854248e-02f, -8.42586458e-02f, -6.06078617e-02f, -2.95634139e-02f, -4.48805727e-02f, 1.35055095e-01f, -5.52598275e-02f, -1.75459981e-01f, -1.19402088e-01f, -1.25913352e-01f,
  1.46007642e-01f, -1.68668367e-02f, 2.54587680e-02f, 9.90342647e-02f, 5.62037006e-02f, 2.07099877e-02f, 3.51203121e-02f, -5.92445880e-02f, 5.06504998e-02f, -3.83002311e-02f,
  1.70879260e-01f, -3.02016307e-02f, -6.58054575e-02f, -2.43403912e-02f, -1.01672269e-01f, 2.02567559e-02f, -1.31220007e-02f, 3.57809886e-02f, 5.36920577e-02f, -7.96142500e-03f,
  -4.69372654e-03f, -2.30127797e-02f, -1.78220168e-01f, 8.84003714e-02f, 8.05991217e-02f, 4.70767990e-02f, -5.11949230e-03f, -2.89782509e-02f, -9.91894528e-02f, -5.77499270e-02f,
  1.92730117e-03f, -5.15671149e-02f, -1.04383584e-02f, -1.10611215e-01f, 5.88863678e-02f, -3.70035879e-02f, -4.33585458e-02f, -6.56093284e-02f, 1.11858450e-01f, -3.11218109e-02f,
  8.37770849e-02f, 2.99220700e-02f, 3.48447859e-02f, 1.13556489e-01f, 1.23851513e-02f, -1.54086472e-02f, -6.50033951e-02f, -3.68749537e-02f, -2.48952303e-02f, -6.58897907e-02f,
  5.71706779e-02f, -2.28220597e-03f, -2.07209960e-02f, -2.62874644e-02f, -3.42190713e-02f, 9.61145461e-02f, 1.20706414e-03f, 2.50670575e-02f, 4.44873013e-02f, -8.10774043e-03f,
  2.50226647e-01f, 1.40162811e-01f, 9.04165134e-02f, -3.51122804e-02f, -1.69540122e-02f, -3.27352323e-02f, 7.65851736e-02f, -4.68904600e-02f, -3.84996869e-02f, -1.38010783e-02f,
  -4.68147807e-02f, -2.08689533e-02f, 9.37055424e-03f, -9.21134800e-02f, 6.97808266e-02f, 4.90930825e-02f, 4.03130651e-02f, 5.55928871e-02f, -7.15358481e-02f, -1.05462953e-01f,
  -1.13084763e-02f, -2.90433131e-02f, 1.12314522e-01f, 5.66132925e-02f, -9.11490470e-02f, 8.68747607e-02f, -7.55733065e-03f, -1.08286180e-01f, 4.39104922e-02f, 1.18256338e-01f,
  -1.09848082e-01f, 3.37141044e-02f, 3.66386414e-01f, 2.46870741e-01f, 4.84020650e-01f, 3.51774186e-01f, 5.73164821e-01f, 3.30007374e-01f, 6.98134676e-02f, 5.27002588e-02f,
  1.23027086e-01f, -1.14572607e-01f, -2.24005491e-01f, -2.75378138e-01f, -9.59133878e-02f, 1.76670000e-01f, 1.73871070e-01f, -8.04909021e-02f, 6.69953078e-02f, 1.25403762e-01f,
  -1.23086758e-02f, -5.89891300e-02f, -1.59195259e-01f, -9.44022015e-02f, 1.96688026e-02f, -2.89120618e-02f, 1.79475341e-02f, -1.44638093e-02f, -2.48418584e-01f, -1.27495304e-01f,
  -8.38290453e-02f, 1.59250706e-01f, 9.92235728e-03f, -1.49600327e-01f, 4.76205535e-02f, -4.15423550e-02f, 5.74322753e-02f, -1.17630050e-01f, 4.00854163e-02f, -3.45014893e-02f,
  1.43980116e-01f, -8.93131047e-02f, -3.63291265e-03f, -3.58629860e-02f, 9.19009447e-02f, -1.87730510e-02f, -3.99110168e-02f, -1.12523399e-01f, -1.81971788e-02f, -9.20395702e-02f,
  -5.01087755e-02f, 1.24946736e-01f, 2.80300051e-01f, 1.06962226e-01f, 3.72954160e-02f, 1.07557811e-01f, 1.40080899e-01f, 8.16728696e-02f, 1.40839830e-01f, -1.10593311e-01f,
  -2.75302287e-02f, 3.10929101e-02f, 1.95031557e-02f, 3.96412052e-02f, 1.63539822e-04f, -3.34799141e-02f, -8.62386730e-03f, -5.47442883e-02f, 3.21138725e-02f, -9.45815146e-02f,
  -1.18771680e-02f, -4.71191928e-02f, 2.96797939e-02f, -1.94862988e-02f, 1.13236569e-02f, 9.12142843e-02f, 3.29626948e-02f, -2.87439879e-02f, -1.03180408e-01f, -9.93023664e-02f,
  -1.14901289e-01f, 1.34833366e-01f, 1.21766059e-02f, 1.72700807e-02f, 2.02325396e-02f, -3.63454744e-02f, -1.88951548e-02f, -6.23057000e-02f, 1.61295254e-02f, 5.33812419e-02f,
  -5.37236407e-02f, 1.10747963e-01f, -7.13009462e-02f, -9.18515995e-02f, 4.46476527e-02f, -1.24910347e-01f, 2.35210471e-02f, -5.98413683e-02f, 3.91140096e-02f, 1.19662071e-02f,
  5.23895286e-02f, 1.46249263e-03f, 6.22657351e-02f, -3.72544047e-03f, -1.42642315e-02f, 7.71417543e-02f, -1.30804367e-02f, 5.96157648e-02f, -3.41119021e-02f, 6.50631413e-02f,
  -9.12291463e-04f, 5.41469716e-02f, 3.70064415e-02f, -1.19540002e-02f, -4.84417332e-03f, 2.79411655e-02f, 3.58626246e-02f, -2.26997454e-02f, 1.10568248e-01f, -8.78329054e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 10)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 10;
const float L0_fan_Bp_bar_data[] = {
  1.48726150e-01f, 2.91531384e-02f, 1.77586764e-01f, 5.70988990e-02f, -5.40325455e-02f, 5.67721203e-02f, -1.87364608e-01f, 3.92784439e-02f, -1.17199644e-01f, 7.60002434e-02f
};

// L1_fan_Wp (Shape: 3 x 16)
const int L1_fan_Wp_rows = 3;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  1.01428136e-01f, -1.16273955e-01f, 1.58159330e-01f, 6.66333809e-02f, 1.28910363e-01f, 1.94976330e-02f, -2.05747783e-01f, -2.10389733e-01f, -2.56312191e-01f, -2.59447366e-01f,
  5.58245778e-02f, 2.67730862e-01f, 1.34770498e-01f, 7.37811401e-02f, -5.38077056e-01f, 1.09632328e-01f, -2.82128125e-01f, 2.48473197e-01f, 5.45753717e-01f, -4.02740747e-01f,
  -2.83981800e-01f, 4.14085537e-01f, 1.24778569e-04f, 2.44778812e-01f, -8.77834857e-02f, 5.07275939e-01f, -1.99565530e-01f, 1.77774325e-01f, 6.03898764e-01f, -5.47614276e-01f,
  -1.09795958e-01f, -2.46609822e-01f, 5.36841154e-01f, 1.33039448e-02f, 1.17923960e-01f, -8.77692327e-02f, 5.81617594e-01f, -2.34661862e-01f, 3.06071013e-01f, -2.92347431e-01f,
  1.36730835e-01f, -2.16726989e-01f, -9.22310874e-02f, -1.26658231e-01f, -5.55793531e-02f, -1.12243287e-01f, 3.66628796e-01f, -3.31473291e-01f
};

// L1_fan_Wp_bar (Shape: 10 x 16)
const int L1_fan_Wp_bar_rows = 10;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  2.89360046e-01f, -7.14709908e-02f, -2.51332104e-01f, 1.05853051e-01f, 4.33541760e-02f, -1.50183793e-02f, 2.79551208e-01f, -5.30292001e-03f, 7.67106891e-01f, -1.07394550e-02f,
  -2.36573994e-01f, -2.21930654e-03f, 9.96918697e-03f, 6.39330372e-02f, -8.50764513e-02f, -2.34415874e-01f, 2.34762818e-01f, 8.36117044e-02f, 6.01465821e-01f, -1.74218506e-01f,
  -3.29034865e-01f, 1.81479648e-01f, 5.36815405e-01f, -1.29967004e-01f, 8.59771252e-01f, 3.19633573e-01f, -1.35400727e-01f, -2.51148701e-01f, -5.23865968e-02f, 1.22845769e-01f,
  -2.29021996e-01f, -4.96663719e-01f, 1.17065713e-01f, -5.91799505e-02f, 3.54694761e-02f, -8.99890512e-02f, 4.30895716e-01f, -3.78773928e-01f, -2.96537071e-01f, 7.63949752e-03f,
  1.39310300e-01f, -3.36182535e-01f, 4.59155321e-01f, -9.35471505e-02f, -2.59999514e-01f, 5.62722921e-01f, 3.09913486e-01f, -1.37928784e-01f, -1.77699864e-01f, 1.19111352e-01f,
  6.09594762e-01f, -3.63914579e-01f, -3.55264753e-01f, 6.73333347e-01f, 6.13757670e-01f, -4.01937030e-02f, 4.99749184e-01f, 2.81580925e-01f, -2.66361654e-01f, -2.72212267e-01f,
  3.16164434e-01f, 7.39589334e-02f, 3.89903486e-01f, -3.31580490e-01f, -9.04703792e-03f, 3.97375047e-01f, -2.89441235e-02f, 3.40236187e-01f, -2.35739812e-01f, -8.86655077e-02f,
  -3.80611151e-01f, 3.55550885e-01f, -7.20288083e-02f, 2.45849475e-01f, -2.35284880e-01f, 1.97006941e-01f, 8.07194054e-01f, -1.24828897e-01f, -1.98952451e-01f, 4.88922775e-01f,
  -2.34632373e-01f, 4.03104685e-02f, 3.82992774e-02f, 1.08058855e-01f, -1.96555823e-01f, 2.23094150e-01f, -1.11726478e-01f, -1.55949175e-01f, -1.96098149e-01f, 5.07645942e-02f,
  5.82938977e-02f, 2.09789455e-01f, -2.35017404e-01f, -1.92514524e-01f, 3.38220179e-01f, 1.07845291e-01f, -2.11638838e-01f, -2.35318467e-01f, -6.68574497e-02f, 2.12895259e-01f,
  -2.33140755e-02f, -2.80948520e-01f, 3.25959980e-01f, -9.85905752e-02f, 6.91986084e-02f, -1.51008010e-01f, 1.63650274e-01f, -3.73423174e-02f, 1.57650575e-01f, -1.89719573e-01f,
  4.62184429e-01f, 3.75781834e-01f, 4.89809141e-02f, -4.98064682e-02f, -1.94130242e-01f, 1.49530232e-01f, 2.14346915e-01f, -2.25642715e-02f, 1.65840074e-01f, -1.96871087e-01f,
  -7.56842196e-02f, -5.78470491e-02f, 1.86777234e-01f, -2.05594543e-02f, -2.44140834e-01f, 2.12625451e-02f, 2.87098527e-01f, 2.54841894e-01f, -5.44287860e-02f, 3.07100356e-01f,
  2.65737996e-02f, -1.34133473e-01f, -2.58855850e-01f, -2.07360387e-01f, 1.46354586e-01f, 3.09058279e-02f, -4.02123779e-02f, 3.42057347e-02f, 2.36484960e-01f, 2.64967263e-01f,
  1.72005057e-01f, 5.66335857e-01f, 1.32475778e-01f, 2.74891585e-01f, 1.43438250e-01f, -7.90895000e-02f, -2.78848261e-01f, 8.90198201e-02f, 1.13934070e-01f, -2.80461460e-02f,
  2.00898290e-01f, 2.30525151e-01f, 2.46788282e-02f, 2.20533565e-01f, -1.57506652e-02f, -8.06328654e-02f, -6.75493777e-02f, 1.69649124e-01f, -1.85420156e-01f, -1.22113533e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 10)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 10;
const float L1_fan_Bp_bar_data[] = {
  -1.96194187e-01f, 3.58942449e-01f, 2.80598134e-01f, 4.79315192e-01f, 3.54621261e-01f, -2.38440782e-02f, -1.89111769e-01f, 1.67198464e-01f, 2.98443079e-01f, -1.47537142e-01f
};

// L2_fan_Wp (Shape: 3 x 16)
const int L2_fan_Wp_rows = 3;
const int L2_fan_Wp_cols = 16;
const float L2_fan_Wp_data[] = {
  3.44850481e-01f, 2.33919233e-01f, -4.37742501e-01f, 2.31332913e-01f, -9.53251362e-01f, -4.79242392e-02f, -2.83596575e-01f, 2.32271850e-01f, 6.04629397e-01f, -2.80391783e-01f,
  -5.03262639e-01f, 5.25383139e-03f, -1.29052058e-01f, 2.38033071e-01f, 1.99932158e-02f, 1.03661314e-01f, -4.84383315e-01f, 1.71505287e-01f, -2.64576524e-01f, 1.18383162e-01f,
  -4.01398808e-01f, 1.59321740e-01f, 4.30261195e-01f, 2.65247464e-01f, -2.60980725e-01f, -1.48236798e-02f, -2.09927261e-02f, 2.21432343e-01f, 1.48908481e-01f, 1.61840171e-01f,
  -6.93235099e-02f, -1.84769779e-01f, -3.44717890e-01f, 3.33534405e-02f, -1.27162591e-01f, -4.23121691e-01f, -4.26211208e-02f, 5.82294703e-01f, 3.78599495e-01f, 3.67937833e-02f,
  -1.46020502e-01f, 4.69743639e-01f, -2.94144005e-01f, 2.92603195e-01f, 3.07661116e-01f, -1.06398866e-01f, 1.56665161e-01f, -1.06016926e-01f
};

// L2_fan_Wp_bar (Shape: 10 x 16)
const int L2_fan_Wp_bar_rows = 10;
const int L2_fan_Wp_bar_cols = 16;
const float L2_fan_Wp_bar_data[] = {
  4.04004985e-03f, 4.22469646e-01f, 2.36149669e-01f, 1.94445863e-01f, 2.01133043e-01f, 3.62141818e-01f, 6.78869113e-02f, 2.86058523e-02f, -6.49402896e-03f, -2.22721472e-01f,
  3.26384902e-01f, -2.34279454e-01f, -1.38495103e-01f, 8.84054005e-02f, -1.68886885e-01f, -4.65552732e-02f, -1.93531662e-01f, -2.66627491e-01f, -1.54668331e-01f, -1.47380978e-02f,
  -5.68174757e-02f, -1.30317077e-01f, 9.50249285e-03f, -3.85747128e-03f, -1.77778959e-01f, -2.41398513e-01f, 3.79984766e-01f, -9.00901407e-02f, -1.88032106e-01f, 9.60281119e-02f,
  9.69067290e-02f, -9.58607793e-02f, -2.48154998e-01f, -1.70800224e-01f, 1.16961993e-01f, -3.01472127e-01f, -1.31322173e-02f, 1.88917652e-01f, -9.14523602e-02f, 6.41548410e-02f,
  -7.37962918e-03f, 3.65543813e-01f, 1.33934349e-01f, -3.20990197e-02f, 4.07741107e-02f, -2.37848714e-01f, -1.42935827e-01f, -1.79627195e-01f, -1.56205460e-01f, 9.43758339e-02f,
  -1.16337873e-01f, 2.11034343e-02f, 2.12273508e-01f, -2.15598598e-01f, 7.61727691e-02f, -3.22731957e-02f, -1.65748715e-01f, 1.21574439e-01f, 6.77958727e-02f, -5.44970632e-02f,
  5.65144829e-02f, 1.40503168e-01f, -2.90202796e-02f, -1.21218294e-01f, 7.22396851e-01f, 2.93777913e-01f, 1.75366506e-01f, -5.58284223e-01f, 2.85556078e-01f, 1.28861570e+00f,
  3.86032671e-01f, 1.24490082e+00f, -2.63978422e-01f, 1.02866745e+00f, -5.91285944e-01f, -1.41252531e-02f, -3.22613835e-01f, -3.12610835e-01f, -2.86026448e-01f, -1.94976985e-01f,
  -7.71827176e-02f, -8.69303197e-02f, 4.48057622e-01f, -1.11613683e-01f, 4.57881659e-01f, -2.35989138e-01f, 2.98717208e-02f, 3.80772114e-01f, -3.62746716e-01f, 1.32854238e-01f,
  5.04652619e-01f, -2.30729103e-01f, -1.13763608e-01f, -1.38846144e-01f, -6.60071708e-03f, 1.67522043e-01f, 7.25582063e-01f, -5.23517802e-02f, 9.39503133e-01f, -2.03496352e-01f,
  1.06100738e+00f, -6.63882315e-01f, -5.07632494e-01f, 2.94133663e-01f, -3.68988752e-01f, 6.14840150e-01f, 7.12477803e-01f, -1.98377594e-01f, -5.10039687e-01f, -4.74163890e-01f,
  2.63912678e-01f, -3.68875325e-01f, 1.46416038e-01f, 3.20311069e-01f, -7.57966265e-02f, -9.86828506e-02f, -1.66538849e-01f, -5.86416781e-01f, -2.24235967e-01f, 2.81190071e-02f,
  1.49300188e-01f, 2.42753103e-01f, 5.39526285e-04f, 6.30858243e-02f, -2.66172379e-01f, -1.10668197e-01f, 5.76141417e-01f, -2.03809753e-01f, 3.39719802e-01f, -2.71557271e-01f,
  -3.74403983e-01f, -3.30595881e-01f, -6.43420517e-01f, 2.68833190e-01f, 4.03692305e-01f, 3.23781282e-01f, 4.21683758e-01f, -5.96662536e-02f, 8.74216929e-02f, 9.75625068e-02f,
  9.81532559e-02f, -1.54083252e-01f, 2.87557960e-01f, 2.50060171e-01f, 3.30855176e-02f, -1.84315830e-01f, 3.39245081e-01f, -2.10558958e-02f, 2.65445113e-01f, 7.91478083e-02f,
  1.84044749e-01f, 9.58411098e-02f, -9.73622277e-02f, 5.91709495e-01f, -1.77104309e-01f, 5.71179241e-02f, -9.66547877e-02f, -1.66269720e-01f, 4.73913401e-02f, -2.09990852e-02f
};

// L2_fan_Bp_bar (Shape: 1 x 10)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 10;
const float L2_fan_Bp_bar_data[] = {
  3.64618659e-01f, 2.28926390e-01f, -1.74231485e-01f, -2.32372224e-01f, 6.54969752e-01f, 7.39063695e-02f, 7.81688631e-01f, 1.78468496e-01f, 2.11631402e-01f, -1.53750941e-01f
};

// L3_fan_Wp (Shape: 3 x 16)
const int L3_fan_Wp_rows = 3;
const int L3_fan_Wp_cols = 16;
const float L3_fan_Wp_data[] = {
  3.04533690e-01f, 2.71298409e-01f, 1.11070558e-01f, 5.97560704e-01f, 1.07460134e-01f, -1.23558335e-01f, 8.61450750e-03f, -2.69644231e-01f, -2.89786071e-01f, -2.83687174e-01f,
  3.45087528e-01f, -2.57345170e-01f, -3.76533061e-01f, 6.37699589e-02f, 3.71706039e-01f, -2.30330348e-01f, 2.15389375e-02f, -4.28768247e-02f, 1.82571799e-01f, -6.92826882e-02f,
  -3.54662687e-01f, 4.66343239e-02f, 1.59432933e-01f, 8.37962180e-02f, 2.98012234e-02f, -2.10701242e-01f, -2.11966097e-01f, -1.73085138e-01f, 5.79199612e-01f, 3.78217399e-01f,
  -3.88860822e-01f, -1.09304957e-01f, -2.34644234e-01f, 2.80393720e-01f, -1.20907620e-01f, -4.35650535e-02f, -2.67846286e-02f, 1.63801342e-01f, -2.47160286e-01f, 9.87962484e-02f,
  3.42950001e-02f, -3.68807465e-02f, 1.31965876e-01f, -2.39502527e-02f, 2.85072863e-01f, 3.39820445e-01f, -3.36728543e-01f, 1.29579216e-01f
};

// L3_fan_Wp_bar (Shape: 10 x 16)
const int L3_fan_Wp_bar_rows = 10;
const int L3_fan_Wp_bar_cols = 16;
const float L3_fan_Wp_bar_data[] = {
  7.35412478e-01f, 5.55160642e-01f, 4.53916788e-01f, 1.25504896e-01f, 1.60105795e-01f, 9.71436501e-01f, 4.00588483e-01f, -1.06999323e-01f, -1.80202127e-01f, -7.74049163e-02f,
  1.88796484e+00f, -3.89293224e-01f, -6.95753157e-01f, -2.86804646e-01f, 1.48712203e-01f, 6.96648359e-02f, -5.56965126e-03f, 3.36522430e-01f, -2.45612100e-01f, 1.48147911e-01f,
  -1.84451401e-01f, -3.15491766e-01f, 2.08267327e-02f, 2.18548983e-01f, 1.31541893e-01f, -9.91783738e-02f, -7.97009587e-01f, 2.87434995e-01f, 5.29682398e-01f, 2.86040813e-01f,
  -2.08591953e-01f, -2.45348588e-01f, -3.86471033e-01f, -3.60586256e-01f, -6.01367056e-01f, -3.84484619e-01f, 3.30193013e-01f, 1.83721304e-01f, -4.57331985e-01f, 2.25474522e-01f,
  3.07282358e-01f, 9.71109048e-02f, 6.78455591e-01f, 4.52574879e-01f, 3.69245648e-01f, 3.87892500e-02f, 1.21586651e-01f, 3.46774906e-01f, 3.74758765e-02f, 7.04927564e-01f,
  6.45255089e-01f, 1.32226264e+00f, -1.15432039e-01f, 1.22874252e-01f, -3.44455898e-01f, -1.12214405e-02f, -2.75515169e-01f, -3.00833642e-01f, 3.79599243e-01f, -5.06952584e-01f,
  -5.71212292e-01f, 5.08391678e-01f, 7.65863478e-01f, -3.53311181e-01f, 7.29963034e-02f, 8.31461279e-04f, -2.10975111e-01f, -1.59071326e-01f, 1.86780214e-01f, 9.10076201e-02f,
  9.97088179e-02f, -2.63349377e-02f, -1.60998553e-01f, -6.27790950e-03f, 2.12117717e-01f, -1.36898318e-02f, -2.79025197e-01f, 1.93272501e-01f, 2.19168253e-02f, 2.03130543e-01f,
  3.23034674e-01f, -1.51481062e-01f, -7.06048543e-03f, -8.00276875e-01f, -6.45143315e-02f, 4.07556832e-01f, -2.80769438e-01f, -6.14247806e-02f, 3.36234540e-01f, -1.79340601e-01f,
  1.02026284e+00f, -5.28328419e-02f, 2.64451534e-01f, -3.22641790e-01f, -2.69575771e-02f, 1.04555063e-01f, 3.76397312e-01f, 3.79775375e-01f, 3.57455552e-01f, -6.51092827e-01f,
  -2.72571802e-01f, -1.11428006e-02f, 2.74083823e-01f, -2.80567501e-02f, -1.61322221e-01f, 1.51217930e-04f, 2.74272621e-01f, 1.68800771e-01f, 1.02306557e+00f, 2.89481252e-01f,
  -5.72417736e-01f, 2.21082360e-01f, 6.82153523e-01f, 2.81591177e-01f, 6.59424782e-01f, -4.52103257e-01f, -5.03385544e-01f, -7.95552731e-01f, 1.55494437e-01f, 1.62348211e-01f,
  -1.97131187e-01f, 1.74901903e-01f, -3.03411126e-01f, 2.90304929e-01f, 1.12113500e+00f, -1.85602561e-01f, -3.52174282e-01f, -3.42905968e-01f, 2.66139686e-01f, 2.01297507e-01f,
  1.64227292e-01f, -3.00788760e-01f, -6.40226483e-01f, -5.85171580e-02f, -1.82779863e-01f, -1.33361369e-01f, -1.96481943e-01f, -2.04743087e-01f, 4.40176837e-02f, 3.14711779e-01f,
  9.98187482e-01f, 1.43907204e-01f, -3.35144326e-02f, 2.75103182e-01f, -2.50732392e-01f, -2.92399973e-01f, 6.17704913e-03f, -3.25296581e-01f, 5.95819531e-03f, -2.00030953e-02f,
  -7.16541931e-02f, 5.63355424e-02f, 4.69991155e-02f, 1.48017526e-01f, -3.85543436e-01f, 2.09601536e-01f, 5.17115533e-01f, 6.59304932e-02f, 1.19290121e-01f, 2.55878627e-01f
};

// L3_fan_Bp_bar (Shape: 1 x 10)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 10;
const float L3_fan_Bp_bar_data[] = {
  4.94638801e-01f, 3.07830989e-01f, -5.79538420e-02f, 6.14801705e-01f, -2.31565833e-01f, 4.22291346e-02f, 1.19294077e-01f, 6.34165466e-01f, 4.29511368e-01f, -1.87780589e-01f
};

// L4_linear_W (Shape: 12 x 16)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 16;
const float L4_linear_W_data[] = {
  -3.34015906e-01f, -6.24277651e-01f, 1.28682375e-01f, -5.57704985e-01f, -2.39822358e-01f, -3.29417109e-01f, 8.54705036e-01f, -1.57201439e-01f, 1.98404700e-01f, 6.02037549e-01f,
  1.72323987e-01f, 6.95719942e-02f, -9.66389596e-01f, -5.02249181e-01f, -9.28320587e-01f, -2.32128739e-01f, -2.39246473e-01f, 6.63281202e-01f, 2.55381465e-01f, 5.09857655e-01f,
  -7.18566418e-01f, 1.32597014e-01f, 7.36577332e-01f, 5.56231998e-02f, -3.75875294e-01f, 1.15344858e+00f, 5.45954071e-02f, -5.57441115e-01f, -7.18274593e-01f, -6.78234160e-01f,
  -5.05684733e-01f, -2.13196710e-01f, 6.71018004e-01f, 3.46582502e-01f, 3.04354101e-01f, 4.27349687e-01f, 3.19566011e-01f, 8.40144455e-02f, 3.31365854e-01f, -2.32715145e-01f,
  -5.37469327e-01f, -3.78211677e-01f, -1.43732786e-01f, 6.57683164e-02f, 2.65206337e-01f, 1.01301742e+00f, 1.24880724e-01f, -3.59740824e-01f, -7.31746376e-01f, -4.28418070e-01f,
  -4.13726300e-01f, -2.81202886e-02f, -4.26149219e-01f, 2.55888671e-01f, 5.23818195e-01f, -2.25512087e-01f, 5.16189635e-01f, 2.10117251e-01f, 2.58415222e-01f, 3.72375876e-01f,
  -2.80884445e-01f, -5.58202326e-01f, -2.15929374e-01f, -1.19471699e-01f, -2.97949791e-01f, -1.94019452e-01f, -4.05252695e-01f, 7.92123258e-01f, -1.07685006e+00f, -1.46061406e-01f,
  3.65644693e-01f, -7.19527062e-03f, 7.01133192e-01f, -8.26598883e-01f, 4.28297035e-02f, 5.33730626e-01f, -3.12630087e-03f, -7.76396036e-01f, -1.90771341e-01f, -2.82740504e-01f,
  1.04489207e-01f, 6.47683382e-01f, -1.04340635e-01f, 6.30909860e-01f, 5.04553970e-03f, 9.66111422e-02f, 9.69953716e-01f, -2.69637614e-01f, -6.53891027e-01f, 1.47178516e-01f,
  -2.65914112e-01f, 3.46326023e-01f, 1.64587036e-01f, -2.66845882e-01f, -9.59492400e-02f, 6.08265400e-02f, -1.16556346e+00f, -7.73580253e-01f, 9.43336338e-02f, -3.81205261e-01f,
  1.20058104e-01f, -6.99059060e-03f, -1.27881277e+00f, -3.37865390e-02f, 4.54741150e-01f, -8.97830650e-02f, 2.56901801e-01f, 2.18874410e-01f, 2.32821286e-01f, 3.88816088e-01f,
  5.09075165e-01f, 3.04713637e-01f, 3.64779115e-01f, 3.84996414e-01f, 2.92917013e-01f, 3.79290581e-01f, 8.01202059e-01f, 3.72240633e-01f, -8.56786251e-01f, 3.00377786e-01f,
  -2.89471984e-01f, 1.17176068e+00f, -1.15977190e-01f, -2.27816448e-01f, -1.32843822e-01f, 5.40241003e-02f, 3.08116347e-01f, -2.24270806e-01f, 1.01467395e+00f, -4.51862007e-01f,
  4.35982943e-01f, -6.85211957e-01f, 6.34427845e-01f, 3.40168148e-01f, -9.84295428e-01f, 3.88356030e-01f, -3.51274550e-01f, -1.46842822e-01f, 2.57300353e-03f, -5.75861871e-01f,
  5.51753819e-01f, 8.17964554e-01f, 2.34065309e-01f, -2.99679488e-01f, -1.06441937e-01f, -4.75504786e-01f, -2.32687905e-01f, -8.86684537e-01f, 3.35704178e-01f, -1.38801917e-01f,
  -4.76669163e-01f, -6.72007322e-01f, 4.35617477e-01f, -3.27259481e-01f, -4.68621626e-02f, 5.67769587e-01f, 5.27074814e-01f, -1.09723266e-02f, 2.81544179e-01f, 1.91945106e-01f,
  5.83796740e-01f, 4.11166698e-01f, -6.83743596e-01f, -3.81449699e-01f, 4.41901952e-01f, -1.96496561e-01f, 3.97360802e-01f, 6.85680881e-02f, 3.07656616e-01f, -7.73939848e-01f,
  -7.16176257e-02f, 4.43942249e-01f, 3.55313212e-01f, -3.41332942e-01f, 6.44437149e-02f, -1.98549852e-01f, -6.83130443e-01f, -2.04954252e-01f, -2.44528428e-01f, 1.06472813e-01f,
  -4.51721668e-01f, 9.57298577e-02f, -6.37485623e-01f, 7.84423351e-01f, 4.58630323e-02f, -3.58971357e-01f, 2.80696094e-01f, -6.97076380e-01f, 2.74461776e-01f, 5.71353257e-01f,
  2.35117748e-01f, 5.62226892e-01f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  -3.76164556e-01f, 2.81950921e-01f, 1.30354077e-01f, -5.30638881e-02f, 7.80490041e-02f, 1.33632183e-01f, -1.06438309e-01f, 5.55804431e-01f, 1.83827892e-01f, -2.47626677e-01f,
  -2.47027054e-01f, -2.57944912e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 3, 10
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 3, 10
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        16, 3, 10
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        16, 3, 10
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        16, 12
    );
    }
    