/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 12 x 120)
const int L0_fan_Wp_rows = 12;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  1.13424078e-01f, 2.91297138e-01f, -2.01939315e-01f, 2.60466635e-01f, 2.27938130e-01f, -1.48526087e-01f, 3.22071463e-02f, 1.75903141e-02f, 7.56028295e-02f, 1.08722985e-01f,
  5.65542243e-02f, -3.93125303e-02f, -1.73070371e-01f, -7.58721232e-02f, 1.73567736e-03f, -2.82842014e-02f, 1.54213086e-01f, -9.59429964e-02f, -2.57377833e-01f, 2.77498607e-02f,
  6.13809898e-02f, 1.86855838e-01f, 3.15657109e-02f, 1.29230609e-02f, 1.84001118e-01f, 1.90418251e-02f, -1.71333682e-02f, 1.38899356e-01f, -8.63339379e-02f, 3.84731650e-01f,
  -2.82403529e-01f, 2.18348593e-01f, -1.48876980e-01f, 1.11090668e-01f, 4.18292545e-02f, -5.85557781e-02f, -9.34701264e-02f, -1.98615883e-02f, 8.77862703e-03f, 6.12204708e-03f,
  6.34088740e-02f, 9.99223068e-03f, 4.83453535e-02f, 2.07402296e-02f, 5.66533357e-02f, 1.75944399e-02f, 9.68301445e-02f, 2.98457332e-02f, -5.60756214e-02f, 2.56600790e-02f,
  1.99444458e-01f, 7.96031132e-02f, 7.60739669e-02f, 2.07405183e-02f, 1.19793471e-02f, 3.22616398e-02f, -1.20905619e-02f, 4.32511158e-02f, -1.30960479e-01f, 9.56910290e-03f,
  -4.59757373e-02f, -1.75122060e-02f, 2.08584443e-02f, 2.64700712e-03f, -3.75259668e-03f, -8.22032057e-03f, 5.35649955e-02f, 1.30272517e-02f, -8.66524130e-02f, 3.25678363e-02f,
  -3.23647968e-02f, -9.20004547e-02f, 3.07787466e-03f, -1.37707237e-02f, -5.29513368e-03f, 5.75980470e-02f, -1.89689863e-02f, 2.66544633e-02f, -3.34567837e-02f, 6.72616735e-02f,
  4.87024188e-02f, -3.52396853e-02f, 8.11008178e-03f, -2.40402273e-03f, -5.14206924e-02f, -8.59321328e-04f, -6.52240822e-03f, -4.80442457e-02f, 3.07702459e-02f, 6.16804734e-02f,
  -1.44881234e-01f, -8.96175951e-02f, 6.05581924e-02f, -2.32109856e-02f, 2.40363646e-02f, 4.00691293e-03f, 4.93215397e-02f, 7.02833459e-02f, 6.80552050e-02f, 7.78907025e-03f,
  5.86663932e-02f, -8.58282968e-02f, 2.92279553e-02f, 8.00679624e-03f, -4.39837575e-02f, 2.96916962e-02f, 3.80243696e-02f, -3.41516407e-03f, -3.16245370e-02f, -3.30188386e-02f,
  -2.71181688e-02f, 3.73459123e-02f, 3.22995000e-02f, -8.33106861e-02f, 8.65132827e-03f, -2.68617291e-02f, -9.24541131e-02f, -7.18595320e-03f, -1.14141278e-01f, -1.57324791e-01f,
  4.67266381e-01f, -1.26274750e-01f, -1.85886830e-01f, -3.29518989e-02f, -3.35526288e-01f, -3.29577416e-01f, -3.71961713e-01f, -1.35481536e-01f, 3.84284034e-02f, -7.27902502e-02f,
  -1.10952981e-01f, 7.34112859e-02f, 9.54224765e-02f, -4.94661108e-02f, 8.25144630e-03f, -7.50420988e-02f, -8.65720659e-02f, 1.23877399e-01f, 8.85484070e-02f, 2.50760047e-03f,
  -7.23397806e-02f, 7.72801414e-02f, 1.19553417e-01f, 1.50099874e-01f, 7.82398954e-02f, 5.00093587e-02f, -8.76566023e-02f, 1.17624188e-02f, -1.66976582e-02f, 2.47005131e-02f,
  1.97862983e-01f, -3.61751504e-02f, -1.80274650e-01f, -4.27942909e-02f, -7.33703896e-02f, 5.14148325e-02f, 5.67922555e-02f, 1.37310838e-02f, 3.35276611e-02f, 2.01532710e-02f,
  -6.63979501e-02f, 1.70318559e-02f, -7.10971579e-02f, -2.99882852e-02f, 3.54080722e-02f, 2.95198127e-03f, 1.49691971e-02f, 3.45091037e-02f, 1.44308582e-02f, -1.47939222e-02f,
  -2.02385485e-01f, -4.87138256e-02f, -3.91686112e-02f, -1.51004866e-01f, 7.70711154e-03f, 2.10022945e-02f, -1.54118046e-01f, 1.30467312e-02f, -6.89646006e-02f, 1.63534284e-01f,
  -2.58271489e-02f, 3.78484912e-02f, -2.31879968e-02f, 3.76214609e-02f, 8.89374167e-02f, 9.20817629e-03f, 6.13688212e-03f, 3.09547465e-02f, -3.49797755e-02f, 6.41661361e-02f,
  -2.82586999e-02f, 2.34651975e-02f, -6.94495451e-04f, 2.16206778e-02f, -1.97520219e-02f, -7.52337947e-02f, -1.66045669e-02f, -4.70602177e-02f, 5.44019230e-02f, 8.14656168e-02f,
  5.52459769e-02f, -9.22510624e-02f, 9.19418130e-03f, 3.11536025e-02f, -2.29397900e-02f, -1.72181465e-02f, -2.64205541e-02f, 2.62273997e-02f, -2.40373481e-02f, -3.75827588e-02f,
  2.94775695e-01f, -3.56115311e-01f, 1.79253399e-01f, 2.75620706e-02f, 7.46407360e-02f, 5.89946844e-02f, -6.95627314e-05f, -2.09451504e-02f, 6.27858331e-03f, 4.47987951e-02f,
  -1.49944071e-02f, 6.09292053e-02f, 4.85741943e-02f, -2.69886889e-02f, 3.86304930e-02f, -2.39704195e-02f, 3.12456340e-02f, -1.61960721e-02f, -1.33779580e-02f, 8.21425021e-02f,
  -7.56660476e-03f, 8.04341361e-02f, 1.45379975e-01f, 1.71358464e-03f, 1.21579226e-02f, 2.88429912e-02f, 4.62005660e-02f, 9.72593054e-02f, 2.95682792e-02f, 1.39830425e-01f,
  -8.95803981e-03f, 2.56156117e-01f, 1.01520672e-01f, -6.73943460e-02f, 1.17393561e-01f, -1.02575921e-01f, -5.43945543e-02f, -1.33878142e-01f, -6.58932626e-02f, 1.07707977e-02f,
  1.31176531e-01f, 3.98336463e-02f, 2.75441557e-02f, 2.43037380e-02f, 3.83006781e-02f, 1.91137232e-02f, 1.78244889e-01f, -1.04625076e-01f, -3.19331855e-01f, -2.02957079e-01f,
  -6.29888996e-02f, 8.33434984e-02f, -8.91218930e-02f, 2.72362474e-02f, 1.01989783e-01f, -1.48761436e-01f, -2.52551064e-02f, 1.50426418e-01f, 1.10829510e-01f, 1.46435231e-01f,
  9.36933085e-02f, 1.98366001e-01f, -1.21524207e-01f, 5.23201711e-02f, 1.01150200e-01f, -6.84298947e-03f, 4.46113199e-03f, 1.10028312e-01f, 4.69426513e-02f, 1.31751988e-02f,
  4.49170507e-02f, 8.41319039e-02f, 7.23258182e-02f, 1.07324659e-03f, -9.60074738e-02f, -6.50326237e-02f, -2.14387681e-02f, 3.64697017e-02f, 2.49415394e-02f, -5.51414397e-03f,
  1.44581765e-01f, 1.91765711e-01f, -7.46884523e-03f, -2.76350863e-02f, -4.28523347e-02f, -7.20955506e-02f, 1.55871492e-02f, 7.97972009e-02f, -1.99755840e-02f, -2.05277037e-02f,
  -8.74353796e-02f, 4.27324809e-02f, 1.80181172e-02f, 1.11069828e-02f, -6.85632080e-02f, -1.43154664e-02f, 3.17658782e-02f, 1.06829114e-03f, -3.46673280e-02f, 4.23183776e-02f,
  4.22620587e-02f, -6.51757047e-02f, 1.15105286e-02f, -3.38541181e-03f, -1.38205513e-02f, 8.76617618e-03f, 1.63141787e-02f, -2.01289505e-02f, 1.37591241e-02f, -1.99618842e-03f,
  -8.20932724e-03f, 1.70374829e-02f, 6.13993667e-02f, 1.79659040e-03f, 4.57149222e-02f, 4.52478789e-02f, -6.17739297e-02f, -1.61980875e-02f, -3.70794944e-02f, -4.92575532e-03f,
  -1.48944110e-01f, 4.69202586e-02f, -1.07387260e-01f, -7.45228603e-02f, -4.27586734e-02f, -4.75400500e-03f, 1.14442743e-01f, -5.23684844e-02f, 5.94514571e-02f, -6.05888665e-02f,
  1.02588935e-02f, -9.60970819e-02f, -2.49538217e-02f, -1.11693054e-01f, -7.59430453e-02f, -9.90300402e-02f, 5.94106130e-02f, -1.35165468e-01f, -3.26544121e-02f, -3.95899825e-02f,
  2.04240214e-02f, -2.19480217e-01f, -2.12034687e-01f, -1.49457961e-01f, -3.74394134e-02f, -1.34649292e-01f, -1.44032344e-01f, -1.55925006e-01f, -1.10623069e-01f, -3.27126652e-01f,
  5.47671497e-01f, -1.29951820e-01f, 2.53305435e-01f, -9.36658755e-02f, -1.63840801e-01f, -6.62107542e-02f, -2.00481042e-02f, -6.10579476e-02f, -5.83961746e-03f, -6.93309233e-02f,
  -4.53004353e-02f, -9.08346176e-02f, -1.03870966e-01f, -8.52826014e-02f, 1.04744613e-01f, -5.33035696e-02f, -6.50602728e-02f, 1.93404496e-01f, 1.60061996e-02f, -4.83026430e-02f,
  -1.04071073e-01f, -2.01228727e-02f, 2.25762486e-01f, 1.16386518e-01f, 2.17452236e-02f, -2.47320533e-01f, -6.35342300e-02f, 9.57821608e-02f, 5.58200106e-02f, -1.33232856e-02f,
  1.27936676e-01f, 2.17481762e-01f, 2.55803242e-02f, -4.01822152e-03f, 3.07560600e-02f, 1.72724035e-02f, 9.88651766e-04f, 1.22979313e-01f, -7.45812878e-02f, 4.56197187e-02f,
  3.40552032e-02f, 3.67287099e-02f, 1.01260771e-03f, 1.15868635e-02f, 1.35012046e-01f, 3.27421091e-02f, 1.80622160e-01f, 1.19299240e-01f, 2.83763930e-02f, 1.95636563e-02f,
  -1.17764518e-01f, 4.81434204e-02f, 1.70581341e-01f, -1.99083555e-02f, 2.27309018e-02f, 3.43507528e-02f, 6.30022436e-02f, 9.74055231e-02f, 1.16434649e-01f, -4.76606339e-02f,
  -1.15041723e-02f, 3.14930826e-02f, -2.80384347e-02f, 3.11307400e-03f, -3.47458720e-02f, -1.35787213e-02f, 4.52162400e-02f, -4.66566980e-02f, -1.01404727e-01f, 4.20317948e-02f,
  -1.24063436e-02f, 2.38412693e-02f, 9.58123058e-03f, -3.88878980e-03f, -4.71204408e-02f, 2.50686500e-02f, -4.13640868e-03f, 4.11359891e-02f, 7.45931361e-03f, 3.02156899e-02f,
  -8.63361172e-03f, -3.27766896e-03f, -9.40933544e-03f, 9.83266532e-03f, 1.78477876e-02f, 8.63051564e-02f, -9.06130672e-03f, -1.93616711e-02f, -2.93482989e-02f, -8.17325152e-03f,
  -1.67274117e-01f, 8.48417729e-02f, -3.25221419e-02f, -9.48924199e-03f, 2.36499254e-02f, 2.44827732e-03f, -1.64542627e-02f, -4.89398427e-02f, -3.20521183e-02f, 6.41288701e-03f,
  2.51253638e-02f, 5.91040924e-02f, 4.65592183e-02f, 4.49352488e-02f, -7.30522498e-02f, -5.92744723e-02f, -6.26765266e-02f, -2.79090200e-02f, 6.31747860e-03f, -1.07042128e-02f,
  -1.58168320e-02f, -1.08110629e-01f, -9.57590863e-02f, -1.77262902e-01f, -7.79054761e-02f, -1.26213610e-01f, -6.16553463e-02f, -9.66272280e-02f, 1.24747325e-02f, -1.33087486e-01f,
  4.28479791e-01f, -1.92379668e-01f, -1.70523465e-01f, 3.24651927e-01f, 4.23059389e-02f, -1.10541821e-01f, -4.85263050e-01f, 7.64012262e-02f, 2.51415938e-01f, -2.14474171e-01f,
  4.54667956e-02f, 2.34725803e-01f, 2.95761190e-02f, -5.09247184e-02f, -1.91897646e-01f, -3.43634754e-01f, -2.47614369e-01f, -9.39749107e-02f, 7.03641251e-02f, 4.52716798e-02f,
  -1.68433152e-02f, 3.23493853e-02f, 2.71846831e-01f, 6.41907603e-02f, -3.07144877e-02f, 7.53074661e-02f, 7.67362583e-03f, 1.02575190e-01f, -2.63699349e-02f, -1.12583347e-01f,
  -9.77704078e-02f, 5.80762811e-02f, -2.20534541e-02f, 1.06224798e-01f, -2.70677693e-02f, 3.61463912e-02f, 7.94544537e-03f, 1.23553440e-01f, 3.24090496e-02f, -5.31697366e-03f,
  5.64209856e-02f, 4.15857472e-02f, 3.77893895e-02f, -2.09597573e-02f, 6.47037923e-02f, -3.96283669e-03f, 4.36456017e-02f, -5.81466034e-02f, 1.62365977e-02f, -8.61538760e-03f,
  -7.12692142e-02f, 1.27733290e-01f, 3.08710225e-02f, -6.44726381e-02f, -5.35799712e-02f, 4.20443229e-02f, 4.64325026e-03f, 3.90952937e-02f, 5.50249778e-02f, -7.37366453e-02f,
  -2.66086627e-02f, -2.00616326e-02f, -2.47056670e-02f, -2.39904355e-02f, 2.27891635e-02f, 4.21551727e-02f, -1.90508887e-02f, -6.83222041e-02f, 4.26783897e-02f, -2.42408495e-02f,
  8.65699071e-03f, 1.31522771e-02f, 1.86809059e-02f, 8.27073958e-03f, 1.66929010e-02f, 2.74590235e-02f, 1.34690115e-02f, -1.15163503e-02f, 3.16656530e-02f, 2.15261728e-02f,
  1.94796920e-02f, 4.90354300e-02f, -1.33209368e-02f, -8.44599307e-03f, -9.60672367e-03f, -1.37759987e-02f, -3.11056711e-02f, 4.43693921e-02f, 4.70087379e-02f, 3.39580476e-02f,
  5.75381108e-02f, -4.35618982e-02f, -6.30611330e-02f, -2.28170417e-02f, 7.99368229e-03f, 3.66470516e-02f, 1.33058848e-02f, 3.13285086e-03f, 3.13040838e-02f, 2.26828409e-03f,
  6.23130351e-02f, 1.03792883e-02f, 2.75106300e-02f, 5.86600080e-02f, -4.51746508e-02f, 8.18529204e-02f, -5.01816273e-02f, 1.28386458e-02f, -4.41247150e-02f, 3.39789763e-02f,
  -3.71720968e-03f, -1.19968057e-02f, -7.71889696e-03f, -1.80352759e-02f, 1.70421172e-02f, -4.02250402e-02f, -1.23412102e-01f, -4.24932651e-02f, -8.97638574e-02f, -1.62353456e-01f,
  3.51537138e-01f, 1.25343323e-01f, 1.31469235e-01f, 9.67409611e-02f, 4.41107638e-02f, -5.90311028e-02f, 4.02721837e-02f, 5.21233007e-02f, 8.96693170e-02f, 4.55127424e-03f,
  -8.21620747e-02f, -1.83334529e-01f, -3.25381048e-02f, -1.27009749e-01f, -6.42126724e-02f, -3.20185199e-02f, -3.70598324e-02f, 5.81927923e-03f, 3.48317996e-02f, -3.97783294e-02f,
  -1.11341767e-01f, 9.29474160e-02f, 1.38704516e-02f, -4.84533235e-02f, 5.84998056e-02f, -2.47430559e-02f, 2.87130545e-03f, 9.09731463e-02f, -1.45940438e-01f, -6.64017648e-02f,
  1.08135894e-01f, 1.67304054e-01f, -1.60795636e-02f, -1.51504040e-01f, -3.72838136e-03f, 3.92019078e-02f, -6.38037594e-03f, 5.10868896e-03f, -2.53142454e-02f, 5.30880615e-02f,
  -3.85805443e-02f, -7.10077882e-02f, -8.40892270e-02f, 8.54432210e-03f, -2.33601965e-03f, 1.77833121e-02f, 1.33775160e-01f, 7.90095981e-03f, 9.62649845e-03f, 1.38876513e-01f,
  -2.73092873e-02f, -3.59120853e-02f, 1.37170807e-01f, 4.14699279e-02f, 2.86088288e-02f, 5.18668294e-02f, 3.52031849e-02f, 1.56087935e-01f, 5.23432046e-02f, 9.74291041e-02f,
  -8.18769634e-02f, 2.76505966e-02f, -3.72772175e-03f, -3.65051231e-03f, 8.55700821e-02f, -3.72646153e-02f, -9.07367282e-03f, -4.36184406e-02f, 2.69777980e-02f, 7.81630799e-02f,
  1.58320391e-03f, -2.40740944e-02f, -2.48707156e-03f, -6.65059662e-04f, 1.74932163e-02f, 3.02495919e-02f, -2.98409518e-02f, -3.65233347e-02f, 3.57723497e-02f, -2.91324686e-02f,
  4.21391018e-02f, 4.42605279e-02f, 4.15806361e-02f, -5.73141314e-02f, 2.12163217e-02f, 3.11076399e-02f, -5.21049909e-02f, 3.07181161e-02f, 2.41368022e-02f, 1.01673447e-01f,
  9.86644402e-02f, -2.52971292e-01f, -1.91241316e-02f, 5.54292984e-02f, -3.28589678e-02f, -6.26193285e-02f, 6.16764389e-02f, 5.07543050e-02f, -4.74247299e-02f, -3.70594896e-02f,
  1.60769932e-02f, 6.92247227e-02f, -6.05792329e-02f, -7.92075917e-02f, -1.31270401e-02f, 1.09454922e-01f, 7.91758448e-02f, 1.99173894e-02f, 3.58190909e-02f, 1.48583248e-01f,
  8.67909268e-02f, 1.32317469e-01f, 1.30043417e-01f, 9.28633660e-02f, -3.44568933e-03f, -8.66557509e-02f, -2.80181915e-02f, 7.67240748e-02f, 5.68736624e-03f, 1.55050918e-01f,
  -7.12062791e-02f, -3.76624428e-02f, 1.97900668e-01f, -9.57407523e-03f, 6.42192811e-02f, 1.88594803e-01f, 3.65543187e-01f, 2.17052385e-01f, -1.50578961e-01f, -3.29728164e-02f,
  2.25732829e-02f, -1.26680747e-01f, -1.15501054e-01f, -8.13177526e-02f, 1.81620613e-01f, 5.03623784e-02f, 1.57388330e-01f, 1.49293169e-01f, 1.71939004e-02f, 1.18858805e-02f,
  -1.52722016e-01f, 3.61358784e-02f, 2.04522219e-02f, -4.15193327e-02f, 3.00721452e-02f, -1.28565207e-01f, -6.51053414e-02f, 3.13446894e-02f, 5.24307266e-02f, -1.09393016e-01f,
  -2.71369237e-02f, 1.32188126e-01f, -4.51944917e-02f, -2.35361271e-02f, -2.76143365e-02f, 9.57289059e-03f, -2.09105927e-02f, -1.11876167e-01f, 3.48232538e-02f, -4.09129895e-02f,
  -7.29447156e-02f, -1.36813484e-02f, 4.16461565e-02f, 3.57681476e-02f, -4.11703438e-02f, -7.03030378e-02f, -3.66784148e-02f, 4.14056368e-02f, 7.24531803e-03f, -3.96886142e-03f,
  -9.71366465e-02f, -2.06288900e-02f, 9.05814543e-02f, 4.20485943e-04f, 4.08367738e-02f, 2.87209824e-02f, -3.81381549e-02f, 4.39577214e-02f, 1.25272363e-01f, -1.84896499e-01f,
  1.08667659e-02f, 5.33243567e-02f, 2.03693137e-02f, 5.70524596e-02f, 4.88149337e-02f, -3.62406694e-03f, 7.17827678e-02f, -1.84979700e-02f, 5.01034260e-02f, 1.85078215e-02f,
  1.21760461e-02f, 4.52071195e-03f, -1.72237698e-02f, -8.80565718e-02f, -2.80871969e-02f, 2.88165789e-02f, 1.29546914e-02f, -2.20554173e-02f, 5.44767901e-02f, 1.72567125e-02f,
  4.87775169e-02f, 6.04967438e-02f, -8.90330598e-02f, 9.85992998e-02f, -7.16772303e-02f, 8.38903617e-03f, -1.35712162e-01f, -4.72261617e-03f, 1.22658415e-02f, -4.41064015e-02f,
  -1.22262284e-01f, 1.81432649e-01f, -1.36758715e-01f, -5.48950844e-02f, -1.47830751e-02f, -6.66124597e-02f, -1.23424223e-02f, 1.65945049e-02f, -1.11016724e-02f, -3.31606120e-02f,
  3.09884101e-02f, 2.41150055e-02f, 2.45779045e-02f, -5.58921089e-03f, -2.49137934e-02f, -1.88207794e-02f, -5.02516218e-02f, -7.68666901e-03f, 4.37443964e-02f, 3.06212027e-02f,
  -4.88752127e-02f, 3.81409787e-02f, 3.15883607e-02f, 6.14488460e-02f, 1.20362630e-02f, 6.31723776e-02f, -4.86815795e-02f, 4.14623357e-02f, 7.95598775e-02f, 2.02429928e-02f,
  3.99565846e-01f, -2.47037441e-01f, 5.66926561e-02f, 1.01641215e-01f, -1.10824712e-01f, -9.13181305e-02f, -1.79809943e-01f, 1.10871024e-01f, 4.83569205e-02f, -1.58760935e-01f,
  -1.43361613e-01f, 6.42357394e-02f, 7.96990022e-02f, -4.38793264e-02f, 1.43441083e-02f, -6.01485893e-02f, 2.45658997e-02f, 1.86043933e-01f, 1.34557039e-01f, 4.35445681e-02f,
  -1.21472906e-02f, 6.91514239e-02f, 1.60818264e-01f, 1.14175647e-01f, -7.55259693e-02f, -8.05908963e-02f, -1.34281442e-01f, -1.31535903e-01f, -1.00452393e-01f, -1.45972863e-01f,
  7.72771984e-02f, 6.97712302e-02f, 1.71282798e-01f, 9.32436213e-02f, 2.90281847e-02f, -9.60657746e-03f, -1.20884869e-02f, -3.52394804e-02f, 3.45228165e-02f, -4.77683395e-02f,
  6.23447485e-02f, 6.40975013e-02f, 1.15146503e-01f, 4.82745208e-02f, 2.41910480e-02f, -2.40278430e-02f, 6.22282326e-02f, 9.13946107e-02f, 4.21876498e-02f, -4.84607741e-03f,
  -1.28915355e-01f, -1.20672725e-01f, -4.81001399e-02f, -5.71606401e-03f, 6.03612326e-02f, 1.11012377e-01f, -1.02729365e-01f, 2.12701336e-02f, -3.95911373e-02f, -8.20490792e-02f,
  3.25701549e-03f, -2.06885058e-02f, -2.24461284e-04f, 1.61698200e-02f, -3.16115543e-02f, 2.18389127e-02f, -2.23630108e-02f, -3.50864045e-02f, -2.08145082e-02f, -2.81002931e-02f,
  -6.81433547e-03f, -8.69741812e-02f, 2.01182663e-02f, -1.24649536e-02f, -4.81389500e-02f, -5.75224543e-03f, -4.45221476e-02f, -4.24195901e-02f, 4.13114615e-02f, 6.67645484e-02f,
  -6.98922873e-02f, 3.87311019e-02f, -1.13397408e-02f, -2.76271533e-02f, -5.21695167e-02f, -3.49436747e-03f, 2.20842976e-02f, 8.21468420e-03f, 2.73741735e-03f, -4.30429652e-02f,
  9.27595771e-04f, 4.98021804e-02f, 4.28112485e-02f, 8.14867765e-03f, -3.74263264e-02f, -4.71533276e-02f, 6.23019002e-02f, -5.83804306e-03f, 1.80965271e-02f, 2.51836106e-02f,
  -4.54979688e-02f, 4.13642190e-02f, -3.60483192e-02f, -4.62603420e-02f, 8.57546460e-03f, -1.86173096e-02f, -1.13939777e-01f, 3.74506339e-02f, 3.00891716e-02f, -4.05347124e-02f,
  -1.58426166e-02f, -7.49752447e-02f, -5.57501763e-02f, -3.87342274e-02f, -7.68379122e-03f, 1.68896317e-02f, -1.09800093e-01f, -1.89341698e-02f, -6.71750382e-02f, -1.68602481e-01f,
  1.18070282e-01f, 1.94845229e-01f, 4.57976609e-02f, 1.54073671e-01f, 1.09730810e-01f, -2.10974425e-01f, 4.35524881e-02f, -4.00745086e-02f, -5.41881733e-02f, 1.55714571e-01f,
  -4.85856384e-02f, -1.13411248e-01f, -1.00411467e-01f, -1.92382738e-01f, -1.94788098e-01f, 1.53734550e-01f, 1.00104831e-01f, -6.13538697e-02f, -2.28202030e-01f, -1.31878302e-01f,
  9.42613743e-03f, 7.03358743e-03f, -8.36808383e-02f, -7.95734525e-02f, 3.40007812e-01f, 3.33219650e-03f, 1.54600173e-01f, 6.96904808e-02f, -9.51025188e-02f, 3.21057111e-01f,
  2.03315079e-01f, 1.62195802e-01f, -1.12445146e-01f, -5.76728992e-02f, 6.70756847e-02f, 2.98709087e-02f, 6.31567091e-02f, 1.04890823e-01f, 1.99274551e-02f, -4.29358985e-03f,
  7.52858073e-02f, 7.91029856e-02f, 4.05448079e-02f, 3.27652670e-03f, 3.26577201e-02f, 4.06458881e-03f, -3.33976522e-02f, -5.84453680e-02f, -9.26433206e-02f, 2.83024367e-02f,
  -5.90407327e-02f, -3.94309312e-02f, 7.44582564e-02f, -1.47036925e-01f, -1.64223030e-01f, -5.37628122e-02f, 1.91452727e-02f, -7.68159330e-02f, -1.17295288e-01f, 9.91810784e-02f,
  -3.68201314e-03f, 2.68249083e-02f, -6.64843023e-02f, 7.32368082e-02f, -9.33208242e-02f, 7.48223886e-02f, -5.17147370e-02f, 2.95456145e-02f, -3.32155973e-02f, 3.93679142e-02f,
  -3.47632952e-02f, -8.64159036e-03f, -9.26048774e-03f, 6.88029006e-02f, -2.73763351e-02f, 4.89867777e-02f, -7.71544222e-03f, -1.13943554e-02f, -7.41777420e-02f, 6.06055837e-03f,
  -5.48870116e-02f, -1.47590702e-02f, 8.89128894e-02f, -3.24108303e-02f, -8.32882375e-02f, -8.47937241e-02f, 2.11743806e-02f, 9.75575484e-03f, 5.05083613e-02f, 4.70483117e-02f,
  2.22516567e-01f, -3.26805055e-01f, 1.29795730e-01f, 1.92076396e-02f, 3.36222239e-02f, -6.23010062e-02f, -8.71872809e-03f, -2.52752434e-02f, -6.10517859e-02f, 5.32278493e-02f,
  -7.46665746e-02f, 4.82454039e-02f, 7.72066275e-03f, -1.45285372e-02f, -4.70182113e-02f, -5.24896942e-02f, -3.15422416e-02f, 3.89300399e-02f, -6.34221435e-02f, -1.32029541e-02f,
  -6.55160397e-02f, 3.34410509e-03f, -4.28321287e-02f, 2.88509205e-02f, -1.71346478e-02f, -7.26174191e-03f, 5.05895093e-02f, 1.11516044e-01f, -7.17254728e-02f, 2.24335819e-01f,
  3.64255488e-01f, 4.56099845e-02f, 1.77758843e-01f, -5.16249798e-02f, -1.39292344e-01f, -2.05743629e-02f, 1.66614890e-01f, 1.10217705e-01f, -6.09424338e-02f, 5.14593348e-03f,
  -2.04955399e-01f, -1.49462104e-01f, -2.17932556e-02f, 2.79800482e-02f, 2.75623143e-01f, 1.59433931e-01f, 2.48257801e-01f, 1.85587585e-01f, 3.81047055e-02f, -6.20309636e-02f,
  -2.02672154e-01f, -1.18158776e-02f, 1.07966304e-01f, 1.10850014e-01f, -1.21107914e-01f, -1.32045165e-01f, -1.03936689e-02f, 1.02088333e-03f, -1.90692663e-01f, 2.57093292e-02f,
  -2.48976827e-01f, -9.58023127e-03f, 3.60276625e-02f, -1.85479280e-02f, -6.11927733e-02f, 9.95473787e-02f, 5.83970994e-02f, 1.61539912e-01f, -5.21558523e-02f, 1.71696376e-02f,
  -1.19862072e-01f, -4.13803011e-02f, -1.53259756e-02f, -1.10496514e-01f, -2.04921886e-02f, 2.32434878e-03f, 1.17199747e-02f, 1.60433665e-01f, 6.82878122e-02f, -4.10054140e-02f,
  -7.03815371e-02f, -1.87020957e-01f, -2.76735961e-03f, -1.59952193e-02f, 2.85421666e-02f, -9.43728387e-02f, 7.52384681e-03f, -1.44360006e-01f, 9.19448119e-03f, 1.34133231e-02f,
  5.20774983e-02f, -2.94294618e-02f, 8.59232154e-03f, -3.73351350e-02f, -4.20942120e-02f, -2.51279045e-02f, -5.10668829e-02f, 1.39959063e-02f, 1.29825464e-02f, -2.87297815e-02f,
  2.18470441e-03f, 4.30573002e-02f, 1.36380838e-02f, 8.17767084e-02f, -3.40919346e-02f, -1.17901424e-02f, 2.27668844e-02f, 1.22045092e-02f, 9.02172551e-03f, -1.70046762e-02f,
  -2.37917844e-02f, 6.90832809e-02f, 8.13424867e-03f, 6.13992102e-03f, 3.67090553e-02f, 4.68374090e-03f, 4.20941226e-02f, -6.62362725e-02f, -4.38937955e-02f, -4.63041700e-02f,
  -8.09107497e-02f, 1.29086412e-02f, -1.26377502e-02f, 1.68277454e-02f, 5.24371443e-03f, 2.24461034e-02f, -9.66077894e-02f, -2.79496312e-02f, 2.94015855e-02f, -3.17886379e-03f,
  -8.28869175e-03f, 3.61075737e-02f, 5.89377880e-02f, 3.46113811e-03f, 6.77961484e-02f, 4.63347286e-02f, -1.57524589e-02f, -1.02157339e-01f, -5.55609688e-02f, -1.11835599e-01f,
  3.77655495e-03f, 4.42611612e-02f, 2.49392986e-02f, 1.29777700e-01f, -2.71190535e-02f, -1.20854517e-02f, 3.52129303e-02f, 4.48897108e-02f, 1.27285302e-01f, 2.75170892e-01f,
  2.86203146e-01f, 9.07319263e-02f, -7.33234212e-02f, 1.07809184e-02f, 9.13696140e-02f, 1.35749459e-01f, 2.71964520e-01f, 9.02574956e-02f, -4.07418124e-02f, 1.35941550e-01f,
  -2.88704168e-02f, -2.24488284e-02f, 1.23416580e-01f, 1.71422623e-02f, 1.74001098e-01f, 1.77069992e-01f, 8.24302509e-02f, -1.53850215e-02f, 7.42247934e-03f, -8.68891254e-02f,
  -8.99127591e-03f, 2.03839298e-02f, -2.95519903e-02f, -4.60473262e-03f, -9.13265049e-02f, 8.37961882e-02f, -1.38149813e-01f, -2.06049055e-01f, -1.49553806e-01f, -6.48439750e-02f,
  -5.38552999e-02f, -1.56886801e-01f, 6.82211667e-02f, 1.24010639e-02f, -5.11049069e-02f, 8.10127892e-03f, 5.78240156e-02f, 5.75656667e-02f, -1.42514734e-02f, -2.29988340e-02f,
  4.74526249e-02f, 8.72704387e-02f, 3.31812315e-02f, 3.32294852e-02f, 5.43914400e-02f, 1.10183552e-01f, 2.48909742e-02f, -3.43715586e-02f, 2.07784791e-02f, 8.51094443e-03f,
  -3.63828987e-02f, -6.47226647e-02f, 3.95749547e-02f, -7.30519146e-02f, -7.36693814e-02f, -1.55843124e-01f, -1.47280186e-01f, -1.11505099e-01f, -1.20464213e-01f, -6.59536719e-02f,
  -3.31163444e-02f, -7.99960196e-02f, -9.67811421e-03f, -7.50280246e-02f, 8.56455714e-02f, -2.20532785e-03f, -6.13501780e-02f, -4.86127064e-02f, 5.35244728e-03f, 1.07819818e-01f,
  -5.36175109e-02f, -4.49809618e-02f, -4.21944484e-02f, 9.71243083e-02f, -1.21259643e-02f, -2.76519358e-03f, 1.07847536e-02f, 5.73014542e-02f, -7.77055547e-02f, -1.62830809e-04f,
  1.21068722e-02f, -2.25733165e-02f, 1.24139441e-02f, -3.13451439e-02f, -4.31453399e-02f, -1.66576430e-02f, 4.63182516e-02f, 2.66713114e-03f, 4.87210136e-03f, -3.17281559e-02f,
  3.32656622e-01f, 8.21357593e-02f, 1.69206619e-01f, 7.53345415e-02f, 4.96688187e-02f, 1.08185876e-02f, 5.11139296e-02f, -1.00635350e-01f, -1.18874563e-02f, 4.92486432e-02f,
  3.76236960e-02f, -1.81697980e-02f, -2.33409088e-02f, -3.00396141e-02f, -7.27704493e-03f, 2.51021441e-02f, -1.00833764e-02f, 1.37744367e-01f, -2.22811708e-03f, -1.11155480e-01f,
  1.26265779e-01f, 1.55094862e-01f, 1.41301185e-01f, 1.64051279e-01f, -1.21155389e-01f, 1.53123379e-01f, 1.13101147e-01f, 1.12280153e-01f, 2.30037436e-01f, 3.49544615e-01f,
  3.38733904e-02f, -2.44694263e-01f, 5.42211235e-01f, 2.27505639e-01f, 1.56673461e-01f, -4.10940200e-02f, 1.86315551e-02f, -1.75243527e-01f, -1.63800448e-01f, 9.00113806e-02f,
  4.97773886e-02f, -8.80669616e-03f, -5.89570589e-02f, -1.38876857e-02f, -5.95330633e-02f, 1.29957870e-01f, 1.90975353e-01f, 1.78168327e-01f, 2.62913972e-01f, 4.56484891e-02f,
  -2.89791562e-02f, 1.06039748e-01f, 8.10372531e-02f, -5.96327819e-02f, 8.34654719e-02f, -4.54414487e-02f, 1.83290645e-01f, 1.43324556e-02f, -5.73219545e-02f, 2.39059299e-01f,
  2.80018181e-01f, 1.30680902e-02f, 1.80504218e-01f, -3.39603871e-02f, 2.32989751e-02f, -6.70298934e-02f, -2.28239819e-02f, 5.80815263e-02f, -7.06740841e-02f, -5.47331870e-02f,
  5.62175959e-02f, -1.19510390e-01f, 6.45245835e-02f, -1.39290588e-02f, 3.85809578e-02f, 5.71178570e-02f, -7.35715032e-02f, 1.33284638e-02f, 1.67859159e-02f, 1.92754846e-02f,
  4.90412898e-02f, 3.56055535e-02f, 1.65935844e-01f, -3.87626961e-02f, -3.61167314e-03f, 1.26368165e-01f, -4.31300737e-02f, -1.27069503e-02f, 6.22403948e-03f, -5.94441593e-02f,
  1.58121176e-02f, -4.69862670e-02f, -5.84244262e-03f, -1.19551746e-02f, -4.47785594e-02f, -2.73832232e-02f, 1.79793369e-02f, 5.38680470e-03f, 9.91997775e-04f, -4.06556763e-02f,
  1.25320712e-02f, 7.28139654e-02f, 2.69520679e-03f, -4.56179269e-02f, 6.67982250e-02f, -6.05853274e-04f, -1.18326517e-02f, 9.05997586e-03f, -2.23754020e-03f, -4.55004685e-02f,
  -3.86436842e-02f, -1.89464644e-03f, -4.46773767e-02f, -3.12837400e-02f, 6.40130490e-02f, 7.10518360e-02f, 4.81354184e-02f, 9.02272016e-03f, -5.42149618e-02f, 3.46807353e-02f,
  -1.77640483e-01f, 8.55154172e-02f, -2.89543252e-02f, 2.91726552e-02f, -2.93849837e-02f, -4.43973169e-02f, 5.95491640e-02f, -4.22470123e-02f, -1.17731234e-02f, 5.30113503e-02f,
  -4.62287432e-03f, -6.08676951e-03f, -4.22722138e-02f, 2.88453847e-02f, 3.71710397e-02f, -1.73345841e-02f, -4.15142514e-02f, 1.13780685e-01f, 1.93455946e-02f, -2.26201247e-02f,
  -4.62120846e-02f, -5.51720941e-03f, -1.19600169e-01f, -8.05581268e-03f, -4.46387157e-02f, 2.86900476e-02f, -1.09306145e-02f, -5.39472476e-02f, -5.20551056e-02f, -2.48958781e-01f
};

// L0_fan_Wp_bar (Shape: 8 x 120)
const int L0_fan_Wp_bar_rows = 8;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  5.54587804e-02f, -1.37812182e-01f, 5.39444424e-02f, 2.10296698e-02f, 8.07664841e-02f, 1.12241574e-01f, -4.71187979e-02f, -6.94374740e-02f, 2.33922768e-02f, -1.05219983e-01f,
  -1.62361205e-01f, -1.96291253e-01f, -9.95767638e-02f, -1.99005306e-02f, 4.48683184e-03f, 4.89420667e-02f, 3.04974336e-02f, 4.55094725e-02f, 1.38992354e-01f, -4.78762239e-02f,
  -1.20575808e-01f, -3.20447721e-02f, 2.22875811e-02f, 1.21695526e-01f, -8.00881758e-02f, -6.56013638e-02f, 3.12718526e-02f, 2.44804621e-02f, 4.11134884e-02f, -7.86994398e-03f,
  1.45593947e-02f, -2.26500612e-02f, 5.90915345e-02f, -3.74487229e-02f, -3.74449044e-02f, -2.09095702e-02f, -3.11296601e-02f, -1.01283878e-01f, 1.36378687e-02f, 3.51221301e-02f,
  4.44955565e-03f, -9.63571966e-02f, -6.79036900e-02f, 2.21780445e-02f, 1.34167830e-02f, 4.13890332e-02f, -1.16161071e-02f, 2.48861336e-03f, 5.60409278e-02f, 3.94100063e-02f,
  1.53711969e-02f, -6.37313500e-02f, 8.66920725e-02f, 6.22513145e-02f, -3.66644673e-02f, 2.55259126e-02f, 6.56951815e-02f, -3.19363289e-02f, 1.04673050e-01f, -2.22036708e-02f,
  5.65301850e-02f, 3.06649804e-02f, 8.00420269e-02f, -5.73155582e-02f, -2.48198714e-02f, 1.96927339e-02f, 1.38434004e-02f, 2.47254558e-02f, -6.56895712e-02f, -5.32354526e-02f,
  3.94791104e-02f, -8.79054144e-02f, -2.28570718e-02f, -1.10056465e-02f, 1.26640871e-02f, -9.27198958e-03f, -2.14349502e-03f, -2.51240283e-03f, 4.29734960e-02f, -1.40969474e-02f,
  -8.25619884e-03f, 3.82317603e-02f, 2.58861203e-02f, -1.71410441e-02f, -4.47110133e-03f, -4.75932807e-02f, 2.09012832e-02f, -4.07081582e-02f, 6.45396858e-02f, 1.68884490e-02f,
  -1.84643716e-01f, 2.52840351e-02f, -2.19379812e-02f, -1.00699216e-01f, 1.17561584e-02f, 5.61170140e-03f, -8.16060454e-02f, -3.08360010e-02f, -6.76596761e-02f, 6.04287386e-02f,
  2.53235027e-02f, -2.35012658e-02f, -1.20972015e-01f, 3.96055803e-02f, -8.34069997e-02f, 6.64424198e-03f, -7.52524659e-02f, -4.12855819e-02f, 8.28320831e-02f, -8.06903467e-02f,
  4.75604050e-02f, 9.17104334e-02f, 6.62723109e-02f, 2.45531444e-02f, -6.02768399e-02f, 5.69579601e-02f, 5.27603924e-02f, -5.50705232e-02f, -1.90728549e-02f, -4.11834046e-02f,
  -3.16278666e-01f, 7.24352896e-02f, -7.33046457e-02f, -8.51351395e-02f, -9.30707455e-02f, -7.15165362e-02f, -1.41400499e-02f, 1.66686922e-02f, -3.87377888e-02f, -6.35348707e-02f,
  -4.95093055e-02f, -3.37439366e-02f, -3.33876908e-02f, -6.47648871e-02f, -1.44122332e-01f, -7.49178678e-02f, -1.97030082e-01f, -1.66932106e-01f, -2.34536797e-01f, -1.10510103e-01f,
  3.76863815e-02f, -1.75894529e-01f, -1.18779540e-01f, -1.09955564e-01f, 9.61176381e-02f, -5.45317978e-02f, 6.09491840e-02f, -1.36951670e-01f, -2.56413762e-02f, -6.17110692e-02f,
  1.14134207e-01f, 6.79238737e-02f, -4.30634357e-02f, -8.10047239e-02f, 4.08931561e-02f, 3.05759329e-02f, 2.38766950e-02f, -2.12189481e-02f, -4.69557159e-02f, 1.09108984e-01f,
  -5.25183082e-02f, -4.97076707e-03f, -3.47119458e-02f, 3.87252793e-02f, 4.02594432e-02f, 3.73944938e-02f, 1.13935992e-01f, -8.03225636e-02f, -4.89771366e-03f, 1.23992436e-01f,
  9.07658488e-02f, -7.59038851e-02f, -2.60531511e-02f, 7.01405331e-02f, 3.22234444e-02f, -1.30647227e-01f, 1.55581713e-01f, 7.00403675e-02f, 4.14189994e-02f, 1.05314851e-01f,
  -6.05700612e-02f, 3.25643308e-02f, 3.46475989e-02f, -3.75790074e-02f, -4.60168021e-03f, -6.01127334e-02f, 1.19661558e-02f, -4.32356559e-02f, -1.39655173e-02f, 2.75628306e-02f,
  7.79442489e-02f, -1.34756125e-03f, 2.54211314e-02f, 1.81366894e-02f, 3.29765826e-02f, -1.09456196e-01f, 1.69890728e-02f, -3.57419178e-02f, 6.36521131e-02f, 2.84054745e-02f,
  -3.53906900e-02f, 2.41555721e-02f, 7.38080442e-02f, 1.83987562e-02f, 4.72105928e-02f, -1.06910609e-01f, 5.29339127e-02f, -3.59894000e-02f, -1.11635298e-01f, -1.48754315e-02f,
  1.09073184e-01f, -1.58809587e-01f, -4.80388999e-02f, -5.60597330e-02f, -4.37645204e-02f, -1.06371064e-02f, 1.37665598e-02f, -4.46770201e-03f, 9.80076641e-02f, 7.18168542e-03f,
  -4.17829640e-02f, 3.55719738e-02f, 9.14072767e-02f, 1.12868354e-01f, 5.65026775e-02f, -1.12346839e-02f, -1.68421753e-02f, 6.71096966e-02f, 6.43630773e-02f, 3.29452716e-02f,
  3.15450877e-02f, -1.50264530e-02f, 7.45863700e-03f, 7.07021803e-02f, 2.48404779e-02f, -1.17316976e-01f, 1.14100948e-01f, 1.09800629e-01f, -1.22138634e-02f, 1.28176764e-01f,
  1.67132154e-01f, 9.46465954e-02f, 2.56327782e-02f, 2.56982714e-01f, 1.58760577e-01f, 9.14999321e-02f, 1.44388359e-02f, 1.52458757e-01f, 9.68470797e-02f, 1.75920263e-01f,
  1.00538783e-01f, 2.58323401e-01f, 2.23347798e-01f, 1.96036592e-01f, 2.96712294e-03f, 2.85780169e-02f, 1.61208748e-03f, -5.37026487e-02f, 4.93535027e-03f, 1.18370838e-01f,
  -6.94936588e-02f, 2.64923694e-03f, -9.66671184e-02f, 3.90782431e-02f, -3.90899852e-02f, -9.68917459e-03f, -5.30775674e-02f, -1.47871301e-01f, -9.57472697e-02f, -5.15563367e-03f,
  2.14309953e-02f, 6.91191480e-02f, 1.85177907e-01f, 1.34198368e-01f, 8.93130377e-02f, 5.69012240e-02f, 2.96447258e-02f, -3.61819938e-02f, -3.47869657e-02f, 3.75523269e-02f,
  3.29255350e-02f, 3.86533067e-02f, -8.75707436e-03f, -5.68656884e-02f, -6.44390061e-02f, -7.23395720e-02f, -8.21887776e-02f, -7.98631459e-02f, -3.03163156e-02f, -2.99793538e-02f,
  3.85146961e-02f, -3.69437337e-02f, -4.74245995e-02f, 1.34801298e-01f, -3.40668485e-03f, 4.14985940e-02f, -4.03415747e-02f, -5.25416955e-02f, 1.88737512e-02f, 2.89957058e-02f,
  3.10962517e-02f, 6.56165555e-02f, -1.96392182e-02f, -3.02448217e-02f, 2.05498450e-02f, -1.03764340e-01f, -7.01944903e-02f, -1.50197595e-02f, -4.10309248e-02f, -5.73096499e-02f,
  3.90204005e-02f, -1.45498356e-02f, 1.17448522e-02f, -3.12843435e-02f, 6.14190251e-02f, -8.10138695e-03f, -9.84941199e-02f, 5.15546165e-02f, -2.14766674e-02f, -4.68259939e-04f,
  -2.08454812e-03f, -3.03477291e-02f, 3.59780006e-02f, -9.83847827e-02f, 1.09601356e-01f, 7.11819008e-02f, 4.13525477e-02f, 9.02070254e-02f, 1.60061643e-02f, -6.94523603e-02f,
  3.72997136e-03f, 1.28131762e-01f, 3.50404382e-02f, -4.44153398e-02f, -1.21249497e-01f, 4.60335426e-03f, 9.29442197e-02f, 3.79494317e-02f, 2.91916337e-02f, 3.69849466e-02f,
  1.92524772e-02f, 5.46362996e-02f, -5.04124500e-02f, -6.50726557e-02f, 3.03926766e-02f, 7.52520263e-02f, -9.12980214e-02f, -4.38656360e-02f, 1.02851294e-01f, 1.80708710e-02f,
  2.53647976e-02f, -6.35183379e-02f, 8.11116993e-02f, 4.08186540e-02f, -6.28370652e-03f, 1.61219075e-01f, -3.05224722e-03f, -4.96287569e-02f, -1.42816575e-02f, 2.88997833e-02f,
  -7.81811075e-04f, -1.76094975e-02f, 2.52912104e-01f, -4.49933745e-02f, 1.77980781e-01f, 2.61741310e-01f, 3.84961188e-01f, 9.99401957e-02f, -9.48034152e-02f, 6.60601556e-02f,
  7.77819604e-02f, -2.74473697e-01f, -1.18952945e-01f, -2.18685135e-01f, -2.07257681e-02f, 1.12158647e-02f, -6.05462119e-02f, -3.91881205e-02f, -3.08955312e-02f, -7.52441362e-02f,
  -1.26593947e-01f, -4.60126102e-02f, -9.20623168e-02f, -9.04374942e-02f, -1.50978729e-01f, -7.22478852e-02f, 7.98444897e-02f, 8.79119337e-02f, 2.22358163e-02f, -1.66941181e-01f,
  5.76192103e-02f, 1.86207548e-01f, -1.85390368e-01f, -1.84566826e-01f, 4.55813222e-02f, -9.12329927e-02f, 1.12573197e-02f, -7.00626429e-03f, -3.16008590e-02f, 8.11105408e-03f,
  8.85728449e-02f, 1.44623322e-02f, 1.66244414e-02f, -3.83734331e-02f, 5.86983673e-02f, -1.69240125e-02f, -3.54715772e-02f, -1.10643677e-01f, 3.01919449e-02f, 2.91376822e-02f,
  -1.49290055e-01f, 1.89831153e-01f, 1.83893472e-01f, 5.55500090e-02f, 4.60089706e-02f, 1.12178177e-02f, 1.01672418e-01f, -1.26954382e-02f, 1.47627424e-02f, -1.30688831e-01f,
  -4.40184213e-02f, -2.00062431e-02f, 7.47697800e-02f, -9.20692533e-02f, 3.17555927e-02f, -2.83320863e-02f, -7.48315006e-02f, 5.28426655e-02f, -1.69690419e-02f, -3.95156108e-02f,
  6.16727099e-02f, 2.17795428e-02f, 5.27074672e-02f, 7.87046924e-02f, -7.67345503e-02f, 6.79974183e-02f, 3.77365686e-02f, -2.11493000e-02f, 5.63886501e-02f, 6.93572983e-02f,
  -7.51431510e-02f, 6.69721738e-02f, 4.81728502e-02f, -9.21210647e-02f, 6.63635209e-02f, 4.67310660e-04f, 4.55840789e-02f, 6.92824833e-03f, -2.34713238e-02f, 8.03323761e-02f,
  -1.24538913e-01f, 9.53031853e-02f, -1.09559990e-01f, -4.77401502e-02f, 6.56088591e-02f, -2.33598761e-02f, -4.70699631e-02f, 1.80388484e-02f, 4.34666052e-02f, -1.61275268e-02f,
  5.60709536e-02f, 3.71357761e-02f, 3.00771557e-03f, 3.88061106e-02f, 6.73960671e-02f, 7.59156123e-02f, -4.62895911e-03f, -9.00906418e-03f, -8.07291716e-02f, 3.93661149e-02f,
  4.69237892e-03f, -2.44210809e-02f, 3.21190171e-02f, 1.51112406e-02f, -5.54746129e-02f, -3.97021584e-02f, 6.93781972e-02f, -4.47462909e-02f, 9.37437937e-02f, -5.31441197e-02f,
  3.28667194e-01f, -2.85618931e-01f, -3.05664271e-01f, -1.36744706e-02f, -1.94900930e-01f, 2.10850984e-02f, -2.59982109e-01f, 1.52966811e-03f, -3.36994790e-02f, -1.96718246e-01f,
  -1.45472899e-01f, 8.34174827e-02f, 6.92763180e-02f, 1.23385198e-01f, 2.24266320e-01f, -1.29764542e-01f, -1.76629364e-01f, 1.67534709e-01f, 2.15112492e-01f, 1.54717965e-02f,
  1.59048215e-02f, -1.29063176e-02f, 2.73112953e-01f, 1.37239143e-01f, -2.49591991e-01f, -6.61890879e-02f, -2.00862378e-01f, -1.41144320e-01f, -1.38540059e-01f, -3.27031612e-01f,
  -1.67191193e-01f, 2.74949931e-02f, -2.51190234e-02f, 2.77236179e-02f, -1.56060889e-01f, 3.45299728e-02f, 1.88229475e-02f, -6.65947199e-02f, 4.10300940e-02f, 1.81601997e-02f,
  -6.47512376e-02f, -1.88930258e-02f, 5.39768897e-02f, 2.14743316e-02f, -4.11684923e-02f, 3.84512357e-02f, -7.75086433e-02f, 1.10091940e-02f, -2.20866371e-02f, -1.39314204e-01f,
  -1.18676454e-01f, 6.84420578e-03f, 3.72345261e-02f, -6.05525151e-02f, 5.18210530e-02f, 2.14321874e-02f, -1.11320093e-01f, 2.21792143e-03f, -2.72217896e-02f, -1.07207708e-01f,
  -3.73055153e-02f, -2.91482080e-02f, -3.60973403e-02f, 5.73249757e-02f, -2.19034702e-02f, 1.51544940e-02f, 2.70735379e-02f, 1.53611451e-02f, -1.22131724e-02f, -7.06835417e-03f,
  4.70219646e-03f, -2.97388192e-02f, 3.52374241e-02f, -4.21900675e-02f, -2.77333166e-02f, -1.20573146e-02f, 7.21693262e-02f, -5.18231727e-02f, -5.15300110e-02f, 1.89807964e-03f,
  3.77312452e-02f, -6.35010153e-02f, -2.00821087e-04f, 3.08885127e-02f, -9.63119566e-02f, 2.11197790e-02f, 4.44924086e-02f, -3.33757140e-02f, -2.40768623e-02f, 6.87202662e-02f,
  5.24557941e-02f, 1.39346004e-01f, -7.94899091e-02f, 2.35223360e-02f, -1.57310814e-02f, -8.04955438e-02f, -1.73134916e-02f, 7.92015567e-02f, -8.84940010e-03f, -1.66062340e-02f,
  6.43288717e-02f, 6.85389787e-02f, -1.00256272e-01f, -9.68907028e-03f, 6.45822063e-02f, -1.85538400e-02f, -8.17999523e-03f, 6.46844953e-02f, 1.72715522e-02f, -6.80408925e-02f,
  -7.74722872e-03f, 6.42149225e-02f, 1.53045282e-01f, 8.15436020e-02f, 1.18733654e-02f, 1.10113785e-01f, 3.52410786e-02f, -9.50949714e-02f, 2.23172039e-01f, -1.56647667e-01f,
  -1.86320677e-01f, -3.65280993e-02f, -7.87785184e-03f, 3.99542712e-02f, 4.38096970e-02f, 1.35076325e-02f, -1.04738295e-01f, -8.91378373e-02f, 4.44174930e-02f, 3.28815319e-02f,
  -3.31224762e-02f, -4.28758673e-02f, -7.36259818e-02f, -1.35672733e-01f, -5.35680838e-02f, 3.33749317e-02f, -9.73367244e-02f, -1.28500864e-01f, 1.15472199e-02f, 5.96837141e-02f,
  -1.19847329e-02f, -1.48391023e-01f, -2.09547132e-01f, -1.14412427e-01f, 1.69558357e-02f, -1.00664735e-01f, -1.48417011e-01f, -1.22888356e-01f, -1.06782153e-01f, 2.21240278e-02f,
  7.11035505e-02f, 9.03627947e-02f, 4.07955162e-02f, -1.26858959e-02f, -5.99761552e-04f, -1.38011305e-02f, -2.67872941e-02f, 2.61308812e-02f, 1.37866819e-02f, -2.89001688e-02f,
  4.62815687e-02f, -5.13540693e-02f, 4.44603562e-02f, -6.61086338e-03f, 2.96603981e-02f, -8.02662745e-02f, -2.97956504e-02f, -8.35571289e-02f, -7.19276220e-02f, -4.51074950e-02f,
  -7.85084665e-02f, -3.90941426e-02f, -3.02925333e-02f, -8.15309137e-02f, -5.28908111e-02f, -3.38923298e-02f, -1.05485521e-01f, -4.34678420e-02f, -1.62055790e-01f, -6.03310466e-02f,
  4.98564914e-02f, -2.00696941e-03f, -4.79756594e-02f, 2.21288279e-02f, -7.07571134e-02f, -2.10920982e-02f, -1.19650494e-02f, -5.27686551e-02f, -4.44823839e-02f, 1.10658798e-02f,
  -1.55145745e-03f, 4.38735224e-02f, 2.04761941e-02f, -4.47953939e-02f, 2.76169199e-02f, 1.27116935e-02f, -5.37212566e-02f, -7.49080256e-02f, -1.08176269e-01f, -1.72492936e-02f,
  2.66621616e-02f, 1.02757365e-02f, 2.53768731e-02f, 6.32607564e-02f, -7.40726814e-02f, 7.60787502e-02f, 7.35481903e-02f, -5.27053364e-02f, 1.62696373e-02f, -3.83099802e-02f,
  3.23251225e-02f, 2.31031049e-02f, 5.68395108e-02f, -4.56452556e-02f, -8.42393860e-02f, -6.20259391e-03f, 2.18790751e-02f, -6.28119409e-02f, 7.21435472e-02f, 3.14180292e-02f,
  -7.90745486e-03f, -5.82608767e-02f, -1.06524713e-02f, -3.03276889e-02f, 3.44732814e-02f, 2.58097555e-02f, -1.26163274e-01f, -6.58203289e-02f, -1.13225184e-01f, 8.54690447e-02f,
  -4.46010344e-02f, -1.42456636e-01f, -6.84896559e-02f, -1.77062616e-01f, -5.18584847e-02f, -1.21810317e-01f, -1.52033240e-01f, -8.69903620e-03f, -8.27432424e-02f, -2.00162664e-01f,
  2.43420973e-01f, 1.10667283e-02f, 1.25042811e-01f, 8.84056613e-02f, -4.50962633e-02f, 6.27952591e-02f, -1.21839844e-01f, 1.01759240e-01f, 1.21394925e-01f, 8.92804787e-02f,
  8.73806849e-02f, 1.68966621e-01f, 1.37543485e-01f, 1.95231840e-01f, 8.64474848e-03f, -2.33128499e-02f, 4.59370352e-02f, 9.42768827e-02f, 5.14683537e-02f, 2.27262788e-02f,
  7.48272389e-02f, -4.80635725e-02f, -6.77933265e-03f, 7.91688263e-02f, 2.30369605e-02f, 1.17172010e-01f, 4.89977561e-02f, -4.21851054e-02f, -7.40950704e-02f, -7.40165040e-02f,
  -1.83177944e-02f, 4.71432097e-02f, 5.99153452e-02f, -2.27295272e-02f, 2.31472962e-02f, -1.14327604e-02f, 6.56967908e-02f, -8.36065263e-02f, -6.86809421e-02f, 8.09988100e-03f,
  -9.95940715e-02f, -6.84351996e-02f, 6.92095384e-02f, 1.79846324e-02f, -4.51846309e-02f, -8.48707277e-03f, -1.55712944e-02f, -9.39688273e-03f, -1.99058224e-02f, 1.88537706e-02f,
  -1.67883802e-02f, -8.69218484e-02f, -9.42295194e-02f, 3.19172256e-02f, 2.78354646e-03f, 1.43330898e-02f, -6.19006008e-02f, -5.13470732e-02f, 1.53125450e-02f, 4.08390723e-02f,
  5.93903214e-02f, 1.67978518e-02f, 2.06664689e-02f, 8.00279379e-02f, 7.11190794e-03f, 1.27223665e-02f, -3.06016742e-03f, 8.73886719e-02f, 5.05937748e-02f, 5.60875982e-02f,
  8.57179463e-02f, -6.97152317e-02f, 1.22484295e-02f, 9.09494162e-02f, -1.23239662e-02f, 3.33783589e-02f, -1.19027510e-01f, -4.36664931e-02f, 3.92478518e-02f, 1.44636100e-02f,
  4.93457206e-02f, 3.01148538e-02f, 4.85796407e-02f, -1.06717926e-03f, 5.18450849e-02f, -2.60692500e-02f, 8.46768916e-03f, -8.41048919e-03f, -1.62819773e-02f, -1.98998898e-02f,
  -9.38191172e-03f, 1.13134138e-01f, -2.09444901e-03f, -3.11321057e-02f, -1.08181231e-01f, 6.39474168e-02f, 9.27796587e-02f, -2.03944407e-02f, -1.47601947e-01f, -6.08591549e-02f,
  -5.37270121e-02f, 2.78860200e-02f, 4.41070506e-03f, -1.07770547e-01f, 1.48225399e-02f, -1.26272067e-01f, 8.36129189e-02f, 5.27137369e-02f, 6.18849471e-02f, -5.48529401e-02f,
  1.54465856e-02f, 2.67658047e-02f, -9.40591618e-02f, -4.01517283e-03f, -6.41175807e-02f, -4.06246409e-02f, -2.23292951e-02f, 2.62969807e-02f, 1.66403484e-02f, -8.07648078e-02f,
  -2.41298914e-01f, -4.69964109e-02f, -9.92017146e-03f, -1.83399349e-01f, 6.72359020e-02f, 4.00609523e-02f, 1.18108932e-02f, -6.96922168e-02f, -1.07229285e-01f, 1.36366242e-03f,
  5.11259027e-02f, -2.75739506e-02f, 1.08885737e-02f, -3.12793553e-02f, -2.14844774e-02f, 1.42302483e-01f, 3.68198231e-02f, 9.22946781e-02f, 7.65924826e-02f, 2.62705553e-02f,
  4.90642227e-02f, -2.49162726e-02f, -1.48326635e-01f, -2.06866600e-02f, -2.17724442e-02f, -2.06375811e-02f, -5.99566065e-02f, -3.49636227e-02f, 3.61522101e-02f, 1.70663670e-02f,
  1.92550912e-01f, -1.65813640e-02f, 2.58515105e-02f, -1.14304334e-01f, -9.94339120e-03f, -2.52011493e-02f, -2.24923971e-03f, 6.07837455e-06f, -6.12251945e-02f, -5.99707616e-03f,
  3.79613265e-02f, -5.50020076e-02f, -8.87531191e-02f, 2.03494336e-02f, -1.94305591e-02f, -5.94762675e-02f, -1.24298967e-02f, -4.31247242e-02f, -9.47591383e-03f, 8.78142864e-02f,
  6.98475614e-02f, 3.71345803e-02f, -2.41282638e-02f, -8.40401798e-02f, -1.23525612e-01f, -1.41102476e-02f, 1.39504476e-02f, -2.93311905e-02f, -1.12147229e-02f, -1.18828807e-02f,
  -1.47572806e-04f, -4.83179539e-02f, 9.01738182e-02f, 5.27862236e-02f, 4.35205325e-02f, 4.39845845e-02f, 1.04320303e-01f, -1.90163814e-02f, -7.33224005e-02f, -7.80009255e-02f,
  -2.90348902e-02f, -3.65364552e-02f, 4.34239842e-02f, 6.24575242e-02f, -8.05520192e-02f, -1.06612518e-01f, 3.71042602e-02f, -1.34487197e-01f, 2.01524142e-02f, -6.36281213e-03f,
  -3.56160998e-02f, -9.47286338e-02f, -4.65535410e-02f, 6.01758808e-02f, 1.21547263e-02f, 2.36889571e-02f, 4.06256169e-02f, -4.80865799e-02f, -1.42955128e-02f, -5.49347997e-02f,
  1.09021783e-01f, 6.38458803e-02f, -2.12938469e-02f, 1.49548640e-02f, -3.46995424e-03f, -4.98576425e-02f, 7.47327283e-02f, 1.77701097e-02f, -2.23843544e-03f, -1.07010128e-02f,
  -8.84516165e-02f, 9.73635763e-02f, 5.85946366e-02f, -5.87705225e-02f, -6.23460673e-02f, -5.07916436e-02f, 7.60416761e-02f, 3.57115641e-02f, 5.88206314e-02f, -4.72780801e-02f,
  -6.92809839e-03f, 4.65879636e-03f, 5.86659871e-02f, 9.70112532e-02f, 3.78979221e-02f, 1.09118439e-01f, 2.71956939e-02f, -5.22326156e-02f, 4.07306962e-02f, 6.46888539e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 8)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 8;
const float L0_fan_Bp_bar_data[] = {
  1.70411944e-01f, 1.98751405e-01f, 2.50002034e-02f, 1.87032923e-01f, 2.02552304e-01f, -7.39425793e-02f, 9.13786760e-04f, 7.06178844e-02f
};

// L1_fan_Wp (Shape: 12 x 32)
const int L1_fan_Wp_rows = 12;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  2.28204161e-01f, 1.61147535e-01f, 8.02457798e-03f, 1.37783527e-01f, 3.32561545e-02f, -2.10458646e-04f, 9.14798528e-02f, -1.07720047e-01f, -2.54586875e-01f, 7.33551458e-02f,
  -1.02069244e-01f, 4.53601219e-02f, -2.95400918e-01f, 1.99134782e-01f, -3.42244804e-01f, 2.44576305e-01f, 4.37849015e-01f, 3.90918493e-01f, 1.12700157e-01f, 3.48856598e-01f,
  -1.70406222e-01f, 3.94078255e-01f, -4.96306736e-03f, 1.27617136e-01f, 2.73261964e-01f, -9.93300602e-02f, -4.59332727e-02f, 1.09611228e-01f, 2.21181050e-01f, -4.98816185e-02f,
  2.15009809e-01f, -1.54031226e-02f, -1.23155557e-01f, 5.00283204e-02f, -1.52153835e-01f, 3.53224486e-01f, -2.65162528e-01f, -1.24744885e-01f, 4.80156168e-02f, 1.52255939e-02f,
  -1.04090899e-01f, -2.45092094e-01f, -4.63857614e-02f, -8.01324323e-02f, -1.83486342e-01f, 2.58327760e-02f, 7.56729543e-02f, -3.22642714e-01f, 2.61185199e-01f, -4.94076274e-02f,
  -3.04953963e-01f, -1.65524021e-01f, -2.19971687e-01f, -3.86546046e-01f, -1.25505373e-01f, -5.02389193e-01f, 8.75115395e-03f, 2.20862359e-01f, -1.29096210e-01f, -1.55498475e-01f,
  5.40686771e-02f, -6.61257422e-03f, 1.14101745e-01f, -9.81625542e-02f, -1.93403244e-01f, 9.72362701e-03f, 1.71389088e-01f, -3.25347513e-01f, 1.79044724e-01f, 3.67884710e-02f,
  -1.07888006e-01f, -4.76344861e-02f, 2.03437209e-01f, 1.77843183e-01f, 1.91131115e-01f, 2.42496118e-01f, 1.17811620e-01f, 5.24680875e-02f, 4.33285207e-01f, 4.34758365e-01f,
  -2.96033978e-01f, -3.11636250e-03f, 4.50602442e-04f, -1.65673718e-01f, 1.62720442e-01f, 1.72009796e-01f, -3.70635986e-01f, 4.18569237e-01f, 2.59651635e-02f, -4.27315431e-03f,
  -3.37778807e-01f, 3.14514749e-02f, -1.71076223e-01f, 1.37094513e-01f, 1.14261448e-01f, 1.67801946e-01f, 1.01712026e-01f, 7.50827556e-03f, -2.77496269e-03f, -1.83158189e-01f,
  3.42598706e-02f, 1.28252849e-01f, 1.67302221e-01f, -4.30071801e-02f, 1.78844050e-01f, -1.11998580e-01f, -1.05645634e-01f, -6.73905313e-02f, -1.43047124e-01f, 3.86293471e-01f,
  -2.23650366e-01f, 2.43385360e-02f, 1.36095986e-01f, 1.55476272e-01f, -7.06741810e-02f, 2.69930035e-01f, 1.37176514e-01f, 3.71020079e-01f, 2.67731309e-01f, 3.20122913e-02f,
  1.03751108e-01f, -1.10419549e-01f, -1.60192698e-01f, -1.51648045e-01f, 2.85333782e-01f, -1.50897741e-01f, -2.00978264e-01f, -2.00422648e-02f, 7.55076036e-02f, 1.83910936e-01f,
  -4.12611030e-02f, -9.00544897e-02f, -7.34199733e-02f, 2.11789250e-01f, 9.11484361e-02f, 2.41081595e-01f, 2.89364010e-01f, 1.69190094e-01f, 1.22132823e-01f, -5.72129637e-02f,
  4.11208451e-01f, 4.82702069e-02f, 1.19786620e-01f, -3.29518497e-01f, -3.42662513e-01f, -1.94665551e-01f, -2.66730003e-02f, -3.77232939e-01f, 2.14347899e-01f, 4.17906791e-02f,
  -8.21881443e-02f, -5.06832153e-02f, 1.17505332e-02f, 2.42992610e-01f, -2.96976030e-01f, -2.70972643e-02f, -3.45418245e-01f, 2.61958539e-01f, -5.06499335e-02f, 2.20713690e-01f,
  3.54046449e-02f, -1.53796030e-02f, 1.36328250e-01f, 2.23006755e-01f, -2.40971029e-01f, -1.78552523e-01f, 1.36488095e-01f, -2.79954761e-01f, -2.06388608e-01f, -1.70655787e-01f,
  -2.12201234e-02f, -3.99590172e-02f, -2.96492606e-01f, -3.37964594e-01f, -1.53673321e-01f, -1.06204361e-01f, 1.89738721e-01f, -4.10699695e-01f, 5.43693788e-02f, -7.00197648e-03f,
  -5.55191696e-01f, -1.50496185e-01f, -1.81047425e-01f, -1.04979865e-01f, -7.48986527e-02f, -5.71122132e-02f, -7.16745257e-02f, -8.84876549e-02f, 1.40268922e-01f, -2.51704268e-02f,
  1.47394076e-01f, -1.07623957e-01f, -2.31905617e-02f, -2.74435967e-01f, -1.62086803e-02f, 4.30983007e-02f, 2.39168033e-01f, 1.61475271e-01f, 2.58430928e-01f, 7.27434307e-02f,
  7.97874033e-02f, 3.48657072e-01f, 1.14067376e-01f, 1.55511200e-01f, -5.83513007e-02f, 6.25877455e-02f, -1.59288600e-01f, 1.41105533e-01f, -3.31215829e-01f, 6.48239702e-02f,
  1.77385718e-01f, -4.82610054e-02f, 1.04921088e-01f, 4.79186565e-01f, 3.20232600e-01f, 3.63274217e-01f, 2.06458509e-01f, -2.74390399e-01f, 1.70277670e-01f, -7.69010484e-02f,
  1.76502451e-01f, -2.99435705e-01f, 1.28269970e-01f, 2.23859504e-01f, -2.06684023e-01f, -2.87051350e-01f, -1.01012535e-01f, -6.24060333e-02f, -1.20485313e-01f, 7.83132613e-02f,
  -2.21252471e-01f, 1.83902830e-01f, 2.83074379e-01f, 1.06453843e-01f, -1.64084230e-02f, 9.08860192e-02f, 2.82908142e-01f, 7.41656199e-02f, -1.00812122e-01f, 2.69808515e-04f,
  -2.46555343e-01f, 3.21549535e-01f, 1.98467031e-01f, -1.52349144e-01f, 3.11993003e-01f, 2.03607515e-01f, 2.97374457e-01f, 3.26788813e-01f, -1.24902681e-01f, -3.90660651e-02f,
  8.58706310e-02f, 2.90649593e-01f, 2.79737404e-03f, -2.03668073e-01f, -6.51836842e-02f, 7.03556165e-02f, 2.02451125e-01f, -2.39714548e-01f, 2.06395537e-01f, 1.97428837e-01f,
  -1.59922075e-02f, -1.87402204e-01f, 6.76582977e-02f, 2.28866786e-01f, -1.27208278e-01f, 1.57890916e-01f, 1.59440264e-01f, 3.61943766e-02f, -2.36740872e-01f, -1.91196278e-01f,
  -7.29036853e-02f, 6.96366802e-02f, -2.28534773e-01f, 1.74053460e-02f, 3.07375461e-01f, 8.99645835e-02f, -3.91923100e-01f, 3.24845195e-01f, 3.37145440e-02f, 1.53240964e-01f,
  2.97395229e-01f, -3.13637912e-01f, -2.39847302e-01f, 8.91164914e-02f, 3.68262053e-01f, -7.80180693e-02f, -1.35381401e-01f, 7.78993070e-02f, -1.41574040e-01f, -3.96952868e-01f,
  8.80628154e-02f, -1.33086964e-01f, -3.15463722e-01f, 9.13979411e-02f, -4.22012247e-02f, -7.76370019e-02f, 1.07572787e-02f, -1.85930151e-02f, 1.92032814e-01f, -1.14810027e-01f,
  -1.00097783e-01f, 4.77660298e-02f, -2.08903968e-01f, -4.71497148e-01f, -2.02112764e-01f, -1.45887151e-01f, 4.78688255e-02f, 9.79360640e-02f, 1.71972755e-02f, 1.17141038e-01f,
  4.57998842e-01f, -3.02846283e-02f, -2.28690833e-01f, 1.86707973e-01f, 2.88240403e-01f, -4.83130485e-01f, 1.35848090e-01f, -2.46824592e-01f, 6.27559721e-02f, 1.93549678e-01f,
  1.03441410e-01f, 4.54924330e-02f, -1.82862893e-01f, -7.62996748e-02f, 1.12974286e-01f, 1.18239382e-02f, 1.53725268e-02f, 6.16177320e-02f, -1.13288857e-01f, -1.22189067e-01f,
  -2.74094373e-01f, -1.37110725e-01f, -3.01371992e-01f, -6.03705384e-02f, -3.17305118e-01f, -1.37361586e-01f, -4.18811142e-01f, 1.11834042e-01f, -4.58280556e-03f, -2.99590498e-01f,
  -9.24229920e-02f, -1.11780085e-01f, 6.85665309e-02f, -3.58957797e-01f, 1.46756127e-01f, 3.53176028e-01f, -2.93355048e-01f, 1.45339862e-01f, -3.25724512e-01f, 2.72676080e-01f,
  -1.49273604e-01f, 3.46264988e-02f, 4.70820814e-02f, -2.56647356e-02f, 3.51544544e-02f, 7.01423436e-02f, 9.11622643e-02f, 1.72146901e-01f, 4.31518033e-02f, -1.90072134e-01f,
  5.79907633e-02f, 5.11873029e-02f, -2.03738376e-01f, -2.61748910e-01f, -1.95411369e-01f, 1.29027545e-01f, -3.65675092e-01f, 9.52288210e-02f, 2.21620142e-01f, 2.83508241e-01f,
  -5.14743477e-02f, 3.72239761e-02f, 1.24211960e-01f, 3.95536497e-02f, 3.32548082e-01f, -3.38279694e-01f, -2.02650577e-02f, 6.01893179e-02f, 2.38344312e-01f, -3.77735831e-02f,
  1.80676162e-01f, -1.87379811e-02f, 7.89978504e-02f, 7.37999231e-02f
};

// L1_fan_Wp_bar (Shape: 8 x 32)
const int L1_fan_Wp_bar_rows = 8;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  3.98511514e-02f, 7.94829503e-02f, 7.82582238e-02f, 1.27489686e-01f, -1.30178273e-01f, 1.81307659e-01f, -1.43102668e-02f, 1.74175829e-01f, -1.06009014e-01f, 1.52004451e-01f,
  6.56776652e-02f, -2.09320143e-01f, -2.84383059e-01f, 3.23666669e-02f, -3.42293859e-01f, 1.30426615e-01f, 8.07981193e-02f, -1.02642722e-01f, 9.25514996e-02f, 1.77568600e-01f,
  -4.35256898e-01f, -2.50126421e-03f, 5.07526360e-02f, -2.16454342e-01f, -1.15412720e-01f, -1.49838358e-01f, 2.24968806e-01f, -2.48395354e-01f, 4.44886148e-01f, -1.71690598e-01f,
  3.31891209e-01f, -1.46661818e-01f, 2.82779019e-02f, -2.50544190e-01f, -3.37253474e-02f, -1.97843765e-03f, 1.06443532e-01f, 1.85490578e-01f, 4.91623320e-02f, 1.50934637e-01f,
  6.00048378e-02f, 3.22881788e-01f, 9.45158154e-02f, 2.20349550e-01f, -3.35035771e-01f, -5.69623053e-01f, 1.51571304e-01f, 1.02146454e-01f, -2.21456051e-01f, -2.20072955e-01f,
  1.94187537e-01f, 3.47485803e-02f, -4.12442714e-01f, -4.37699854e-02f, 1.00969538e-01f, 2.06419319e-01f, 1.56565264e-01f, 7.86713660e-02f, -1.61467213e-02f, 5.43411076e-01f,
  1.68274984e-01f, -3.91857363e-02f, -1.07406517e-02f, 1.44719601e-01f, 2.70924661e-02f, -1.36351854e-01f, -1.21395662e-01f, -1.57664865e-01f, -1.66403711e-01f, 1.24652013e-01f,
  1.09221749e-01f, -1.27713993e-01f, -6.59381077e-02f, -1.55191511e-01f, -4.73723784e-02f, 1.07830048e-01f, 3.74295712e-02f, -5.49655631e-02f, 7.65931383e-02f, -1.77379310e-01f,
  -2.50195134e-02f, -6.14055321e-02f, 5.39057236e-03f, -1.45054981e-01f, 6.69151023e-02f, -1.50979504e-01f, -1.02395847e-01f, 7.93103725e-02f, 1.05914980e-01f, 4.91904467e-02f,
  -9.02089998e-02f, 1.44836128e-01f, 1.00874424e-01f, -1.77076221e-01f, 8.28595012e-02f, -1.23396471e-01f, 3.12462658e-01f, 3.92441899e-01f, 4.05489028e-01f, 2.50078589e-01f,
  2.89515346e-01f, 1.56881616e-01f, 1.43335938e-01f, 1.51371375e-01f, 2.29303315e-02f, 1.09961830e-01f, 4.75845896e-02f, -2.91046560e-01f, -7.14120120e-02f, 3.14452320e-01f,
  1.72857046e-01f, 3.06483582e-02f, 5.63903928e-01f, -1.56096041e-01f, -3.59351277e-01f, 3.43924165e-01f, -3.65753055e-01f, 7.96011612e-02f, -3.76830608e-01f, -3.49945873e-01f,
  -2.28152052e-02f, 2.10186198e-01f, 1.76671669e-01f, -2.98003316e-01f, 4.91366804e-01f, 1.99975595e-01f, 2.32025281e-01f, -1.91625223e-01f, -1.02491975e-02f, -7.91337565e-02f,
  1.58294328e-02f, -7.99403340e-02f, 9.75974053e-02f, 7.59916529e-02f, -1.85626537e-01f, -9.16872844e-02f, 1.80475309e-01f, 2.03453694e-02f, 9.16914418e-02f, -2.24759772e-01f,
  -1.41414776e-01f, 2.30640993e-01f, 1.57007016e-04f, 9.54861194e-02f, 3.23164523e-01f, 1.97253734e-01f, -1.36120737e-01f, 1.51173934e-01f, -1.54550523e-01f, -4.15150151e-02f,
  -7.82720372e-02f, -1.49007151e-02f, -1.17490754e-01f, 2.12146312e-01f, -1.08824037e-01f, -1.38999760e-01f, 2.00914010e-01f, 1.97816834e-01f, 1.09184340e-01f, -1.66116476e-01f,
  1.77448019e-01f, 7.93739557e-02f, 3.52373064e-01f, 4.03916240e-01f, 5.08324131e-02f, 8.93173441e-02f, 1.32015869e-01f, 1.43909961e-01f, 3.02363276e-01f, 2.50678688e-01f,
  1.68266222e-01f, 5.69158606e-02f, -3.85364920e-01f, 1.02707213e-02f, -3.81479144e-01f, -4.89590824e-01f, -2.40966365e-01f, -2.57130086e-01f, 5.54840416e-02f, -3.18350643e-01f,
  -3.32883626e-01f, 4.78197485e-02f, 2.97323823e-01f, -5.57746470e-01f, 2.15276331e-02f, 2.38565683e-01f, -1.14108268e-02f, 1.10546667e-02f, 1.51356786e-01f, 1.23096883e-01f,
  2.28231862e-01f, 1.83601663e-01f, 2.81705707e-01f, 5.24591245e-02f, -8.92980173e-02f, 1.40861258e-01f, -3.31876613e-02f, 1.47616833e-01f, 4.77892667e-04f, 1.30643949e-01f,
  2.57655680e-01f, -7.95641914e-03f, -3.02390922e-02f, 1.30832791e-01f, -6.78886548e-02f, -4.59302291e-02f, -1.31249875e-01f, -1.31313084e-02f, -1.05267484e-02f, 1.77244902e-01f,
  3.13826770e-01f, 1.68804023e-02f, 1.39481142e-01f, 3.05011690e-01f, 2.29278803e-01f, 1.23418182e-01f, -6.10255357e-03f, -1.35914192e-01f, 8.15795828e-03f, 3.97300541e-01f,
  2.22643867e-01f, -1.59355268e-01f, -8.95821154e-02f, -7.60813281e-02f, 9.61595401e-02f, -4.90274467e-02f, -1.04914829e-01f, -1.43502310e-01f, -9.14572999e-02f, 1.52174994e-01f,
  1.27676114e-01f, 1.13431178e-01f, -7.75676221e-02f, -6.96481066e-03f, -7.67109245e-02f, -1.14158422e-01f, -1.24569433e-02f, 1.20057330e-01f, 1.20223105e-01f, -4.96577695e-02f,
  -1.38972640e-01f, 1.80149823e-01f, -1.38117015e-01f, 4.27667685e-02f, -4.24484275e-02f, -1.10204957e-01f, -4.53485623e-02f, 1.36549473e-01f, 3.42139788e-02f, 3.52526046e-02f,
  -9.69128534e-02f, -1.37972087e-01f, -2.65860166e-02f, -1.09344814e-02f, -8.03375691e-02f, -1.13060050e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 8)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 8;
const float L1_fan_Bp_bar_data[] = {
  1.11624777e-01f, 8.69401842e-02f, -2.93588899e-02f, 6.59614652e-02f, -1.38668856e-02f, 4.38710362e-01f, 6.37166016e-03f, -1.65471062e-02f
};

// L2_fan_Wp (Shape: 12 x 32)
const int L2_fan_Wp_rows = 12;
const int L2_fan_Wp_cols = 32;
const float L2_fan_Wp_data[] = {
  1.49465457e-01f, -3.93757671e-01f, -1.53980374e-01f, -1.49387747e-01f, 1.05227634e-01f, -2.54786223e-01f, -2.68963397e-01f, -8.17930326e-02f, -5.68152890e-02f, -1.31780326e-01f,
  1.12001292e-01f, -3.52381207e-02f, 3.97317767e-01f, 2.33076632e-01f, -2.86610395e-01f, -3.09196532e-01f, -5.25067627e-01f, 1.93150684e-01f, -3.20660174e-01f, -2.20718905e-01f,
  -1.34888366e-01f, -1.54610023e-01f, -2.43450761e-01f, 2.33141318e-01f, 2.42172852e-01f, 4.65728827e-02f, -3.18255089e-03f, 3.22235495e-01f, 1.69665724e-01f, -1.87752873e-01f,
  1.56057864e-01f, -1.56293735e-01f, -2.68072076e-02f, 1.31818905e-01f, 2.70541251e-01f, 1.49879321e-01f, 5.28137609e-02f, 6.15879931e-02f, 7.92476758e-02f, -1.03482373e-01f,
  -6.13072105e-02f, -9.39243510e-02f, -2.21483111e-02f, 2.80408144e-01f, -9.61492732e-02f, -3.83381486e-01f, 3.26409847e-01f, -1.68039814e-01f, 1.91900089e-01f, -3.02319050e-01f,
  1.51569158e-01f, 2.66598940e-01f, 1.68308109e-01f, -7.76733607e-02f, -2.75024801e-01f, -2.72314578e-01f, -3.31923664e-01f, 2.50021100e-01f, -4.32331450e-02f, -3.63508940e-01f,
  -6.58422112e-02f, -3.27734292e-01f, 2.12753698e-01f, 1.59563154e-01f, -1.33111939e-01f, -1.78748265e-01f, -3.39742377e-02f, -1.30018055e-01f, 2.13512003e-01f, -9.92781743e-02f,
  -3.00527126e-01f, -1.62246138e-01f, -1.78222552e-01f, -6.55289134e-03f, 1.19424321e-01f, 2.14706138e-01f, 4.80793089e-01f, -3.09144437e-01f, 9.48236808e-02f, 3.05862248e-01f,
  -8.84816423e-02f, 1.19396821e-01f, -7.88447708e-02f, -1.31276429e-01f, 2.20852897e-01f, -1.89263776e-01f, -3.06630522e-01f, -8.80116671e-02f, 1.25528708e-01f, -1.61935583e-01f,
  6.79438114e-02f, 3.43385130e-01f, -5.76608963e-02f, -7.85139427e-02f, -3.89893204e-02f, 1.55620143e-01f, 1.27340153e-01f, 2.27706194e-01f, 3.03334206e-01f, 1.32469147e-01f,
  1.01343356e-01f, 2.85059661e-01f, -3.33102345e-02f, 8.73518288e-02f, 1.00411169e-01f, 1.28857911e-01f, -1.61180720e-01f, 6.82454482e-02f, -3.24223459e-01f, -1.25513062e-01f,
  1.61830574e-01f, -2.84984767e-01f, 2.99783051e-01f, -4.55107391e-02f, 7.51281902e-02f, 2.65998811e-01f, 2.42286250e-01f, 2.90774137e-01f, -1.37899160e-01f, -3.27101082e-01f,
  -2.76723027e-01f, 4.07702118e-01f, 7.38003105e-02f, -5.02241313e-01f, -7.94104487e-02f, -1.32966682e-01f, 1.57540649e-01f, -1.12881862e-01f, 1.05779320e-01f, 6.87712654e-02f,
  -1.08778030e-01f, -9.46945846e-02f, 4.74906201e-03f, -1.57379471e-02f, -2.85934925e-01f, -2.28738308e-01f, -8.42338577e-02f, 1.79798499e-01f, 5.85198961e-02f, -3.37396339e-02f,
  -1.23319358e-01f, 2.52276715e-02f, -2.42703333e-01f, 1.13545142e-01f, 2.66649723e-01f, 1.10715538e-01f, -1.48101687e-01f, 3.40802133e-01f, -2.58157477e-02f, 4.77954984e-01f,
  3.38754654e-01f, -3.41642052e-02f, 1.28835052e-01f, -2.49972209e-01f, -1.68049201e-01f, -6.96850419e-02f, 1.16291896e-01f, 3.27203572e-01f, 3.52383070e-02f, 8.55635330e-02f,
  -2.77284145e-01f, -1.33356705e-01f, -3.29846650e-01f, -1.35607988e-01f, 5.44589460e-02f, -1.92754082e-02f, -5.51482290e-02f, -1.65279731e-01f, -2.00824156e-01f, -1.66360959e-01f,
  -9.40689221e-02f, 8.05143788e-02f, -1.82049319e-01f, -2.54014343e-01f, 1.67517185e-01f, -3.40427697e-01f, -3.55568290e-01f, 9.81596783e-02f, 2.71114528e-01f, 2.38184944e-01f,
  4.23360556e-01f, -1.43056870e-01f, -4.67992455e-01f, -2.96283573e-01f, 1.19554125e-01f, 5.18948555e-01f, -8.23970735e-02f, 1.72066130e-02f, -8.06492940e-02f, -2.37155512e-01f,
  -2.78819688e-02f, 1.04688622e-01f, 1.67011395e-01f, -2.36239627e-01f, 9.32511389e-02f, 1.97227038e-02f, 7.33020082e-02f, 7.49136508e-02f, 1.68366760e-01f, -3.21584225e-01f,
  -2.92311274e-02f, -1.68235347e-01f, 1.53999090e-01f, 4.49965335e-02f, -2.20884249e-01f, 3.94873954e-02f, 3.51535231e-01f, -5.08456647e-01f, -3.18878032e-02f, 2.31541499e-01f,
  -2.09403127e-01f, -1.76623315e-01f, 7.15047168e-03f, -3.29792291e-01f, -2.68448532e-01f, -3.47370803e-01f, 2.63200663e-02f, 3.35708767e-01f, 5.91109842e-02f, 3.66525054e-01f,
  5.46538569e-02f, -2.31662184e-01f, -1.58353522e-01f, -1.35467544e-01f, -3.93839866e-01f, 9.22217071e-02f, 7.92759955e-02f, -3.19646448e-01f, -2.32606024e-01f, 2.73922861e-01f,
  -2.63455734e-02f, 1.50169134e-01f, 4.46724035e-02f, -2.17615396e-01f, -2.02095896e-01f, -2.30290398e-01f, -2.63501555e-01f, -4.83129993e-02f, 9.45565011e-03f, -2.48291045e-01f,
  -2.49161273e-01f, 2.21485272e-01f, 2.58338511e-01f, -1.32518848e-02f, 1.02921193e-02f, 2.91614473e-01f, -1.56461388e-01f, -2.92067170e-01f, 2.24318877e-01f, 3.55053097e-01f,
  1.68623418e-01f, -3.04086059e-01f, -2.79760242e-01f, 8.26094598e-02f, -2.64191896e-01f, -7.25185797e-02f, 1.49359182e-01f, 4.06797588e-01f, 3.26839119e-01f, 2.50822008e-01f,
  3.02719213e-02f, 5.00964758e-04f, 3.08387935e-01f, 3.71931851e-01f, 1.51930898e-01f, 1.38981447e-01f, 1.35767922e-01f, 1.31589472e-01f, -1.71878636e-01f, 1.35931727e-02f,
  9.27693099e-02f, -1.60109308e-02f, 2.96235174e-01f, 4.84230816e-02f, 2.02794541e-02f, -3.17375332e-01f, -1.72538608e-01f, -3.48553270e-01f, 1.90535277e-01f, -1.63625807e-01f,
  -2.53616601e-01f, -3.63360196e-01f, 1.06521659e-01f, 3.24540824e-01f, -2.76170790e-01f, 5.40225953e-02f, -3.15760970e-01f, -7.22827092e-02f, -2.49873325e-02f, -1.66851461e-01f,
  -1.06501766e-01f, 7.76249245e-02f, 9.78789404e-02f, -3.11687529e-01f, -2.37217486e-01f, 9.68030766e-02f, -2.27135569e-01f, -1.12720631e-01f, -1.34075835e-01f, -4.12537530e-02f,
  2.14073956e-01f, -4.92586821e-01f, 4.63520616e-01f, 2.36518040e-01f, -1.60224125e-01f, -3.72132540e-01f, 3.73815149e-01f, 1.12844229e-01f, 2.39817217e-01f, -3.23317736e-01f,
  -4.30160463e-01f, -3.06818575e-01f, -1.01100788e-01f, 1.43515125e-01f, -2.58032270e-02f, -3.00705042e-02f, -1.01610888e-02f, -3.49686384e-01f, 8.30210075e-02f, -2.01775823e-02f,
  -8.01844895e-02f, 1.98521271e-01f, 1.25271708e-01f, -2.30501592e-01f, 7.42747262e-02f, 1.65298611e-01f, -5.73635809e-02f, -6.23591170e-02f, -1.49866819e-01f, 1.59126878e-01f,
  2.20725477e-01f, -9.27038416e-02f, 2.77079403e-01f, 1.57967955e-01f, -4.85939771e-01f, 1.44341558e-01f, -2.85280526e-01f, 1.46141097e-01f, -1.12668656e-01f, -2.16794863e-01f,
  2.15064943e-01f, -1.13784187e-01f, -8.80224630e-02f, 1.04333982e-01f, 1.26451373e-01f, -3.77099775e-02f, -3.12336418e-03f, 3.74857455e-01f, 9.02659148e-02f, 1.92179084e-01f,
  4.95699570e-02f, 1.51644289e-01f, -3.80023360e-01f, 3.47174220e-02f, 7.91380256e-02f, -3.70141059e-01f, -1.02350585e-01f, 1.66483223e-01f, 1.54148147e-01f, -2.02467456e-01f,
  -3.13760459e-01f, 1.01298556e-01f, 2.72005409e-01f, -1.60898089e-01f, 1.45318612e-01f, 3.40944022e-01f, -2.39686891e-01f, 3.36797208e-01f, -9.79720727e-02f, 3.79088908e-01f,
  -4.63191746e-03f, -1.12875216e-01f, 4.43937510e-01f, 4.55982536e-02f, 3.97545904e-01f, 1.24746904e-01f, 2.27947146e-01f, 1.20261289e-01f, -3.58447153e-03f, -2.60121617e-02f,
  -2.05418542e-02f, 4.47165072e-01f, 2.02395722e-01f, 6.74695447e-02f
};

// L2_fan_Wp_bar (Shape: 8 x 32)
const int L2_fan_Wp_bar_rows = 8;
const int L2_fan_Wp_bar_cols = 32;
const float L2_fan_Wp_bar_data[] = {
  3.02428454e-01f, 2.41122156e-01f, 3.82050335e-01f, 9.44010913e-02f, -6.91613704e-02f, -4.86159362e-02f, 3.32241684e-01f, -8.28076154e-02f, 7.35171810e-02f, -2.42779795e-02f,
  2.61431873e-01f, 3.23454261e-01f, -4.13841605e-01f, 4.94447440e-01f, -2.21485034e-01f, -2.14669630e-01f, 4.18507278e-01f, 3.86693329e-01f, -6.05918944e-01f, -3.90014142e-01f,
  -4.70568568e-01f, -3.83975208e-01f, 3.69717628e-01f, 1.25391677e-01f, -2.23137423e-01f, -1.06880650e-01f, 6.34833574e-02f, 4.86528575e-01f, -4.09141220e-02f, 4.75968659e-01f,
  -1.88527346e-01f, -5.67614697e-02f, 2.48251885e-01f, 9.29431245e-02f, 1.86071202e-01f, 1.22347213e-02f, 3.40645671e-01f, 4.67601120e-02f, 2.23898217e-01f, 3.93902287e-02f,
  3.37920368e-01f, 1.39339920e-03f, 3.17998491e-02f, 2.17659976e-02f, 1.48570344e-01f, 2.21057385e-01f, -1.69278786e-01f, 7.53467306e-02f, -3.39871682e-02f, 1.98391855e-01f,
  -1.14695206e-01f, -2.92098850e-01f, -8.77208635e-02f, -1.58947900e-01f, -3.48581135e-01f, 9.94972140e-02f, 1.02922447e-01f, -1.69707671e-01f, 1.64584607e-01f, 7.74738014e-01f,
  8.38303491e-02f, -1.41117992e-02f, -2.62793243e-01f, -1.01822652e-02f, 4.95812483e-03f, 1.39057741e-01f, 1.43433079e-01f, -3.93790156e-02f, 2.14913458e-01f, 2.59411931e-01f,
  8.19429308e-02f, 5.08115664e-02f, 2.58998901e-01f, 3.28116030e-01f, -6.78965226e-02f, -1.82184651e-01f, -1.56888086e-02f, 1.79886773e-01f, -4.44625944e-01f, 1.82272196e-02f,
  -1.32692322e-01f, 5.25283992e-01f, 3.97150457e-01f, -2.41809651e-01f, 7.15946853e-01f, 3.52414191e-01f, -8.62554926e-03f, 1.84657946e-01f, 4.83415812e-01f, 3.79660726e-01f,
  -3.87956463e-02f, 7.99917579e-02f, -1.05902903e-01f, 8.49826574e-01f, 1.51953101e-01f, -1.59313560e-01f, 2.64132451e-02f, -1.69714883e-01f, 1.52976513e-01f, 2.40682393e-01f,
  2.80161589e-01f, -8.16681832e-02f, -1.26240388e-01f, -3.79545763e-02f, 1.79859638e-01f, -7.73586035e-02f, 1.62990704e-01f, 1.73926055e-01f, 3.21506947e-01f, -2.10353479e-01f,
  -1.39048457e-01f, 3.50379318e-01f, 1.71035513e-01f, -4.20368016e-01f, 1.78456068e-01f, 4.71278876e-01f, 3.10492069e-01f, -3.59008700e-01f, 2.46953994e-01f, 2.33090401e-01f,
  -2.58086711e-01f, 2.35037833e-01f, -7.73451924e-02f, -1.95108742e-01f, -8.16225708e-02f, 2.62901515e-01f, 4.23486084e-01f, 3.84503305e-02f, 1.59405977e-01f, 3.98845375e-02f,
  8.59782919e-02f, 1.70302868e-01f, 8.51126090e-02f, 1.94742307e-01f, 1.14196517e-01f, 5.53136587e-01f, 4.47573394e-01f, 9.10975561e-02f, 1.91026419e-01f, -3.13436948e-02f,
  -1.60950705e-01f, -3.37264508e-01f, 1.31678686e-01f, 1.91693574e-01f, 2.67197460e-01f, -6.58368826e-01f, 6.88578665e-01f, 5.08660316e-01f, -8.89174491e-02f, 5.71338832e-01f,
  -3.76891315e-01f, 2.44102180e-01f, 1.87971249e-01f, -1.99259043e-01f, -1.46941707e-01f, 2.49157980e-01f, 1.70787826e-01f, 3.16479802e-01f, -3.65208536e-02f, 4.54677194e-02f,
  3.96521688e-01f, 2.19672352e-01f, -1.30965501e-01f, 1.94292903e-01f, -5.04160766e-04f, -2.26086676e-02f, 4.24188972e-01f, 8.87007341e-02f, 3.08237642e-01f, -4.39272672e-02f,
  7.93651268e-02f, 3.02790761e-01f, 1.00049406e-01f, -1.52123561e-02f, 3.61553311e-01f, -1.39887393e-01f, 1.65157184e-01f, -3.18809688e-01f, 3.50385159e-02f, -1.32898822e-01f,
  -1.47273289e-02f, -5.62216282e-01f, -4.83105108e-02f, -9.59193707e-02f, -1.83938116e-01f, 1.55660614e-01f, -1.67166620e-01f, 2.86659580e-02f, -1.73400491e-01f, 2.55838572e-03f,
  1.16757095e-01f, 6.11055568e-02f, -3.38565893e-02f, -1.08160898e-01f, -8.14878345e-02f, 2.22301483e-01f, 3.70135963e-01f, 1.16126955e-01f, 1.76200524e-01f, -1.80472955e-01f,
  2.44529229e-02f, 1.31336525e-02f, 2.37692282e-01f, -1.29985772e-02f, 2.70648211e-01f, 2.18137085e-01f, -8.89611151e-03f, 1.03931814e-01f, -2.38191132e-02f, 3.81062210e-01f,
  -7.48078339e-03f, -2.04821348e-01f, 1.89585730e-01f, -4.44303960e-01f, -1.49296194e-01f, 6.22263923e-02f, 2.40925625e-01f, 1.78503290e-01f, 7.82152489e-02f, 4.61741924e-01f,
  1.89487711e-01f, 1.73261166e-01f, -1.14470609e-01f, 5.69829307e-02f, 3.16018969e-01f, 3.46653074e-01f, 3.51860017e-01f, 3.97779234e-02f, -6.26868755e-02f, 4.31625023e-02f,
  3.98811661e-02f, -3.73546742e-02f, 1.81607798e-01f, 2.52484474e-02f, -1.23977112e-02f, 1.39340982e-01f, -3.36340159e-01f, 1.24172777e-01f, 2.88984746e-01f, -3.63560885e-01f,
  2.22518936e-01f, 1.60591587e-01f, -1.59437150e-01f, -1.15925901e-01f, -3.82204026e-01f, -1.35452941e-01f, 2.15341106e-01f, -2.01018929e-01f, -3.18285346e-01f, 4.28397864e-01f,
  9.31157842e-02f, -2.00831532e-01f, -2.20398277e-01f, 4.09220487e-01f, -1.58311144e-01f, -5.01610488e-02f
};

// L2_fan_Bp_bar (Shape: 1 x 8)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 8;
const float L2_fan_Bp_bar_data[] = {
  3.09261680e-01f, 2.15282291e-01f, -1.83343496e-02f, 1.26051709e-01f, 2.04726622e-01f, 2.94718146e-01f, 1.65349115e-02f, 2.66277224e-01f
};

// L3_linear_W (Shape: 12 x 32)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 32;
const float L3_linear_W_data[] = {
  -6.53968573e-01f, -1.89183801e-01f, -3.10574293e-01f, -2.89700240e-01f, -1.18863642e-01f, -2.05386892e-01f, -2.73342311e-01f, -5.65073133e-01f, 9.81388614e-03f, -1.76461890e-01f,
  -2.84559935e-01f, -1.00124232e-01f, 4.43917185e-01f, 1.40694678e-01f, 2.28110582e-01f, 1.46804392e-01f, 4.03532177e-01f, -1.20903485e-01f, 1.67350039e-01f, -6.22434951e-02f,
  -1.12310946e-01f, -1.10653706e-01f, -1.17327146e-01f, 6.20740913e-02f, 4.90682870e-01f, 4.26545143e-01f, 2.09109023e-01f, -5.93860038e-02f, -7.53234148e-01f, -4.49878037e-01f,
  3.65810484e-01f, -1.63803577e-01f, 5.14556363e-04f, -2.54879236e-01f, -1.07244037e-01f, -1.73732966e-01f, 1.97651416e-01f, 5.34887910e-01f, 4.85627115e-01f, 3.35368335e-01f,
  4.04423892e-01f, 1.49124697e-01f, -3.12836200e-01f, 1.16089336e-03f, 6.68840528e-01f, -4.88548763e-02f, 2.72265702e-01f, -1.65963080e-03f, 4.62027602e-02f, -1.07269205e-01f,
  -5.20348549e-01f, 3.99335265e-01f, -6.64857805e-01f, -3.91749144e-01f, -1.55354831e-02f, -5.90810664e-02f, -4.50367033e-01f, 2.08495408e-01f, 7.31148303e-01f, -3.53233486e-01f,
  1.99965358e-01f, -5.18751800e-01f, 1.27383426e-01f, -3.09609771e-01f, 1.96845472e-01f, 4.99708474e-01f, -4.12289739e-01f, 2.86894053e-01f, -2.34140560e-01f, 2.09910274e-01f,
  -2.02855691e-01f, 1.98883981e-01f, -2.28947535e-01f, 5.06003797e-01f, -2.81627238e-01f, 4.97643143e-01f, 1.12550817e-01f, -1.84774712e-01f, 3.18254352e-01f, -1.65708408e-01f,
  -5.82913458e-01f, 3.95562708e-01f, 4.07534659e-01f, -1.58783272e-01f, 4.44589198e-01f, 5.38804352e-01f, 3.79038006e-01f, 3.95721257e-01f, -2.36194462e-01f, 2.89923340e-01f,
  2.97899187e-01f, -2.13264406e-01f, -3.17150146e-01f, 1.47143621e-02f, 6.47475183e-01f, -1.17233030e-01f, 1.49128675e-01f, 6.06126897e-02f, 6.92936033e-02f, 2.24222496e-01f,
  -7.14605302e-02f, 2.00713113e-01f, -2.25360006e-01f, 3.48106682e-01f, -3.49619120e-01f, -1.20994210e-01f, 4.21244726e-02f, -3.22042018e-01f, -2.00356334e-01f, -4.33847398e-01f,
  -3.33280057e-01f, 7.71627352e-02f, -1.27642065e-01f, -5.11146262e-02f, 2.47984201e-01f, 3.04807186e-01f, 1.60953537e-01f, -2.61887938e-01f, 2.97603142e-02f, 3.47087950e-01f,
  4.77125555e-01f, -2.50947744e-01f, 5.39904535e-01f, -8.87945369e-02f, -9.26421165e-01f, 2.17971593e-01f, -1.04289383e-01f, 5.97124338e-01f, 1.27451837e-01f, -1.67827144e-01f,
  2.72128403e-01f, -1.09999448e-01f, 1.75224543e-02f, -5.42632878e-01f, -2.50946432e-01f, -3.99817199e-01f, -3.08296949e-01f, -4.46560472e-01f, 4.87092175e-02f, 4.98863339e-01f,
  5.77658772e-01f, -6.28678799e-01f, -9.85699520e-02f, -5.38729131e-01f, 8.23659301e-02f, -1.07121512e-01f, 2.21135810e-01f, -4.08190727e-01f, -1.85762122e-01f, -4.06564027e-01f,
  2.34374598e-01f, -3.15009430e-03f, 9.42401707e-01f, 8.40677842e-02f, -6.59786761e-01f, -4.55957949e-02f, -4.40399975e-01f, 4.42578904e-02f, 6.58427402e-02f, 3.46435159e-01f,
  5.67030430e-01f, -8.17391053e-02f, 2.27120981e-01f, 1.41715527e-01f, -7.74232447e-02f, -4.69726115e-01f, 4.11430970e-02f, -3.24339241e-01f, -2.23529711e-01f, -8.62060264e-02f,
  -4.80439484e-01f, -3.96417111e-01f, -2.74972051e-01f, -6.16280556e-01f, -1.56137764e-01f, -4.87470865e-01f, 2.26396233e-01f, -4.76204157e-01f, -4.68164653e-01f, -1.54562041e-01f,
  2.16280371e-01f, -3.68540108e-01f, 2.46035069e-01f, 3.38312179e-01f, 8.88907090e-02f, 1.26214564e-01f, 3.46183628e-01f, 1.56582296e-02f, 4.68498796e-01f, -1.46792322e-01f,
  -4.95476611e-02f, -4.28734332e-01f, 8.70766640e-02f, 3.05627853e-01f, -1.81392863e-01f, 5.70969164e-01f, -8.88631046e-02f, 4.56511676e-01f, 2.83133715e-01f, -1.31377220e-01f,
  5.69585189e-02f, -5.42397559e-01f, 2.70436615e-01f, -3.31336111e-01f, -2.08135828e-01f, 4.35330093e-01f, 4.91016954e-01f, -1.43918991e-01f, -3.08539808e-01f, 3.51909906e-01f,
  2.11869195e-01f, -3.34746897e-01f, 5.96906602e-01f, 5.93185425e-01f, -3.24953884e-01f, -3.84629935e-01f, -7.20212102e-01f, 4.88217659e-02f, -6.25886917e-01f, -1.76266022e-02f,
  4.79974151e-01f, 4.36889410e-01f, -1.35116592e-01f, -4.88032639e-01f, -7.97073245e-01f, -2.49155879e-01f, 2.10656106e-01f, -5.69795430e-01f, 1.92401424e-01f, 2.30338201e-01f,
  1.56597167e-01f, 1.23861670e-01f, 1.21279471e-01f, 4.59108621e-01f, 3.55250299e-01f, 4.03934389e-01f, -4.24621761e-01f, 5.20662010e-01f, -3.48468244e-01f, 1.24678418e-01f,
  2.85088331e-01f, 6.30130589e-01f, 5.64733259e-02f, 5.43646038e-01f, -1.45279929e-01f, 1.22181028e-01f, -3.14396411e-01f, -1.24830715e-01f, -3.08433175e-01f, -3.63525867e-01f,
  2.43232727e-01f, -3.71641785e-01f, 6.75419033e-01f, -3.03350270e-01f, -4.48630273e-01f, 2.74315655e-01f, 1.65369716e-02f, 3.56184721e-01f, -3.47653925e-02f, 2.67444074e-01f,
  3.18128765e-01f, 3.98238540e-01f, -1.24711424e-01f, 1.35966942e-01f, 1.43202856e-01f, 3.20921779e-01f, 8.09025466e-02f, -2.06219554e-01f, -5.08422494e-01f, 5.42622745e-01f,
  3.07762116e-01f, 3.66882950e-01f, 2.32141465e-01f, -1.78674638e-01f, -8.16441953e-01f, -3.90439749e-01f, -3.96603167e-01f, 3.80781442e-01f, 3.03620994e-01f, 6.18129730e-01f,
  -5.62102377e-01f, -5.28382421e-01f, 1.78119138e-01f, 8.81968200e-01f, 2.77574193e-02f, -8.63150209e-02f, -1.46002978e-01f, -2.54623473e-01f, 1.84765115e-01f, 5.26507318e-01f,
  1.99994221e-01f, 3.13526392e-01f, -1.74526468e-01f, 2.35749066e-01f, -1.22942463e-01f, 1.87074617e-01f, -5.61802030e-01f, 7.24228442e-01f, 1.88328683e-01f, -2.95643002e-01f,
  -1.19815402e-01f, 3.24836791e-01f, -1.40278801e-01f, 1.51892632e-01f, -2.53091991e-01f, -1.10426180e-01f, 1.17351308e-01f, -2.36746483e-02f, 9.52980444e-02f, 1.64777860e-01f,
  1.01024255e-01f, -7.51772761e-01f, 4.26700890e-01f, 5.49210846e-01f, -7.54384935e-01f, -5.40307820e-01f, -7.33243078e-02f, 4.60537225e-01f, -1.48325935e-01f, 3.31544966e-01f,
  -5.21009624e-01f, 3.05009902e-01f, -3.34125578e-01f, 9.13327038e-02f, -5.85504286e-02f, -7.46778965e-01f, -2.71318853e-01f, 2.91655123e-01f, -1.42617062e-01f, -5.38748145e-01f,
  4.24932063e-01f, 2.13038579e-01f, -4.31028605e-01f, -5.81040502e-01f, -3.09823006e-01f, 1.58797935e-01f, 3.51847351e-01f, -5.58638453e-01f, -6.83615625e-01f, 1.38255611e-01f,
  -3.70504186e-02f, -4.76188213e-01f, -2.18268752e-01f, 2.15785921e-01f, 9.71881896e-02f, -2.93621510e-01f, 1.23897709e-01f, 1.07241705e-01f, 2.93440253e-01f, -1.17131919e-01f,
  -4.58338886e-01f, 4.53032911e-01f, 2.16899827e-01f, -6.43854558e-01f, 5.98161519e-02f, -2.50571787e-01f, 9.05148685e-03f, -4.27983642e-01f, -7.95865133e-02f, 3.02955478e-01f,
  4.36749011e-01f, -2.06894472e-01f, 1.77026197e-01f, 6.26739021e-03f, -1.22470178e-01f, 2.99715370e-01f, -1.20633602e-01f, 4.73036915e-01f, -4.37021613e-01f, 5.30564070e-01f,
  4.71402138e-01f, -8.67012739e-02f, -5.90551317e-01f, 4.70470697e-01f, -4.20563877e-01f, -3.99498016e-01f, -3.40296894e-01f, -5.21476746e-01f, -4.12289053e-01f, 4.48852807e-01f,
  1.60588741e-01f, 4.82149959e-01f, -1.40435696e-01f, 8.91880617e-02f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  3.27151939e-02f, 1.46725923e-01f, -1.78430051e-01f, -2.98649639e-01f, 1.37645692e-01f, 1.58959776e-02f, 1.32267401e-01f, -4.31288667e-02f, 4.37911004e-02f, 1.05080232e-01f,
  1.08967982e-01f, 7.27666616e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 12, 8
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 12, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        32, 12, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        32, 12
    );
    }
    