/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 3 x 120)
const int L0_fan_Wp_rows = 3;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -2.58907583e-02f, 1.56429932e-01f, 4.22519267e-01f, 1.19857691e-01f, 4.52614993e-01f, -6.27460703e-02f, 7.98354670e-02f, -1.78474322e-01f, -1.40578806e-01f, 2.06680700e-01f,
  5.34307659e-02f, 1.48686031e-02f, -4.25783126e-03f, -1.38006825e-02f, -2.80128926e-01f, 2.41851375e-01f, 2.59594113e-01f, 4.32026722e-02f, -1.37253180e-01f, -8.69600475e-03f,
  1.75392732e-01f, 1.42534941e-01f, -2.17609510e-01f, -1.65649001e-02f, 3.52617234e-01f, 6.37235790e-02f, 2.01183125e-01f, 9.37023833e-02f, -9.42888036e-02f, 6.10534489e-01f,
  2.15280667e-01f, 8.55700448e-02f, -3.17921042e-02f, -2.99418643e-02f, 1.07941836e-01f, -6.13551587e-02f, 7.99721479e-03f, -1.47183752e-02f, -7.65223503e-02f, -5.17731905e-03f,
  1.49710909e-01f, 2.40310244e-02f, -1.26133105e-04f, 1.13053747e-01f, -2.04264726e-02f, -4.30134088e-02f, -1.16818786e-01f, -1.01026811e-01f, 1.16964653e-02f, -9.83114168e-03f,
  1.18095420e-01f, 9.95971188e-02f, -6.34551570e-02f, -4.74283062e-02f, -1.02585517e-01f, -1.03178136e-02f, -1.13777272e-01f, -1.66996140e-02f, -4.82322872e-02f, -3.17200273e-02f,
  -2.11553071e-02f, 7.46923164e-02f, -4.50757854e-02f, -1.48464534e-02f, -7.38705928e-03f, -2.27356981e-02f, 7.66625032e-02f, 6.45273104e-02f, -4.24394645e-02f, -1.77509170e-02f,
  -3.41965742e-02f, 2.60631796e-02f, -6.13645315e-02f, 1.45120900e-02f, -3.62521671e-02f, 6.58434480e-02f, 4.63686250e-02f, -4.16538008e-02f, 1.48312608e-02f, -5.27972542e-02f,
  -3.07827070e-02f, -1.78581066e-02f, 1.56740658e-02f, -7.89121352e-03f, 7.12518767e-02f, -6.81559928e-03f, 5.34359813e-02f, -4.58289236e-02f, -3.54022086e-02f, 1.06084421e-01f,
  -2.13208705e-01f, -2.33298734e-01f, 3.59418918e-03f, -7.88587406e-02f, -1.43390716e-04f, -4.37225997e-02f, 5.20797400e-03f, -7.28319734e-02f, -1.82417780e-02f, 2.75142156e-02f,
  -6.85638413e-02f, 1.60276685e-02f, -3.49388346e-02f, -9.70659778e-02f, 3.10135968e-02f, -2.92758923e-02f, 1.37714343e-02f, -2.73901038e-02f, -6.76469058e-02f, 8.98399111e-03f,
  -9.43288952e-02f, -1.53936893e-01f, -2.61994988e-01f, -4.90710847e-02f, -7.47490227e-02f, -2.43908297e-02f, -9.20565650e-02f, -4.84961197e-02f, -2.02884644e-01f, -1.71969131e-01f,
  -4.06602889e-01f, -1.58567145e-01f, 6.07974052e-01f, -3.23404789e-01f, -3.42787802e-02f, 6.93926737e-02f, 2.24551007e-01f, -2.43295562e-02f, -1.72113910e-01f, 7.42396638e-02f,
  -1.02946080e-01f, -2.28426933e-01f, -1.87164899e-02f, -1.96504481e-02f, 1.61575198e-01f, 3.28636616e-01f, 1.80495575e-01f, 2.67516196e-01f, 1.06263354e-01f, -1.55597776e-01f,
  -2.23160043e-01f, 1.29401699e-01f, 1.38977408e-01f, 3.71599346e-02f, 2.25669872e-02f, -1.78992003e-01f, 2.68771052e-01f, -8.59101564e-02f, 5.23570646e-03f, -1.01298004e-01f,
  1.12178877e-01f, 5.43947369e-02f, 1.78501338e-01f, -2.19927691e-02f, 3.73849235e-02f, -9.71944071e-03f, -1.97387580e-02f, 6.40263259e-02f, -4.66624349e-02f, 5.44113889e-02f,
  -4.18736115e-02f, -3.51786055e-02f, -1.00229718e-01f, -3.65396552e-02f, 2.71502454e-02f, -2.86581684e-02f, 6.30154833e-02f, 9.41391736e-02f, 1.60675660e-01f, 1.12930045e-01f,
  -6.30664900e-02f, -2.70390101e-02f, 3.75899300e-02f, 1.79194454e-02f, 8.21788013e-02f, 4.37330194e-02f, -6.32134452e-02f, -7.35421032e-02f, 2.72480939e-02f, -1.28148077e-02f,
  -3.72195989e-02f, 8.75184461e-02f, 3.00449766e-02f, -5.90944886e-02f, -2.67768688e-02f, -8.32016021e-02f, 1.77909024e-02f, -5.36242053e-02f, -5.49411029e-02f, -2.42974446e-03f,
  -1.03784455e-02f, 9.89023596e-03f, -7.42352102e-03f, -6.31121732e-03f, 3.82590219e-02f, 3.21683511e-02f, -7.85468072e-02f, 6.62680343e-03f, 4.16212752e-02f, 4.93044369e-02f,
  7.42587447e-02f, -1.06499180e-01f, -4.23849933e-02f, 1.01876825e-01f, 1.47462981e-02f, 3.42039801e-02f, -9.71279200e-03f, -7.63778836e-02f, -4.49416824e-02f, 1.44141167e-02f,
  -2.61782035e-02f, -2.63796058e-02f, -1.85658615e-02f, 3.52645516e-02f, -3.47656235e-02f, 1.34566784e-01f, 7.21655786e-02f, 3.96385277e-03f, -1.35789113e-02f, 3.13057285e-03f,
  5.03275953e-02f, 8.56000558e-03f, 5.19297980e-02f, 6.84178900e-03f, -1.65579822e-02f, -6.48066550e-02f, -4.37907362e-03f, 2.46648733e-02f, 1.29542187e-01f, 6.40739640e-03f,
  2.95866169e-02f, -7.45864538e-03f, -1.10063553e-01f, -9.54650156e-03f, -5.13568521e-02f, -1.07855145e-02f, 4.48333472e-02f, -5.35561927e-02f, -8.33286066e-03f, 9.65596549e-03f,
  -5.92452049e-01f, 5.25286317e-01f, -3.34017009e-01f, -1.11792415e-01f, 1.60359722e-02f, -4.20339964e-02f, 2.57643282e-01f, -1.38730958e-01f, -1.19820178e-01f, 1.95164368e-01f,
  8.97537246e-02f, 1.57567903e-01f, 1.88436255e-01f, 1.95425406e-01f, -3.49193215e-01f, -8.39703456e-02f, -2.49112695e-01f, -5.11891365e-01f, -5.12313247e-01f, 7.76039436e-02f,
  2.63536781e-01f, -2.53890157e-01f, -3.85942280e-01f, -9.33099464e-02f, 1.83805674e-01f, 5.54497615e-02f, 1.16246238e-01f, -2.08459541e-01f, 5.30091040e-02f, 8.29454884e-02f,
  5.00238650e-02f, -3.56935933e-02f, -2.79439986e-02f, -1.08266860e-01f, 8.62584542e-03f, -8.10493156e-02f, 3.25947143e-02f, -6.25689700e-02f, 1.28079727e-01f, -1.83185302e-02f,
  -3.94292437e-02f, 2.04128120e-02f, -5.68224490e-03f, 3.90256383e-02f, 5.54926544e-02f, 4.39647958e-02f, -7.33490288e-02f, -1.55570686e-01f, -9.74836722e-02f, 1.44393116e-01f,
  1.85796991e-01f, -1.65198427e-02f, -8.50063935e-02f, 2.22220737e-02f, -5.76046631e-02f, -1.18108243e-01f, 4.19891663e-02f, -2.30648499e-02f, -9.39971283e-02f, 9.15861502e-02f,
  8.40486512e-02f, -9.45459083e-02f, 6.36791438e-02f, 5.30113466e-02f, -3.56121026e-02f, -5.52258571e-04f, 4.98091765e-02f, -6.50112182e-02f, -4.27500457e-02f, -1.34359719e-02f,
  9.83971059e-02f, -5.25255650e-02f, 2.44692042e-02f, 8.21643919e-02f, 3.28383744e-02f, -7.10866693e-03f, -2.77561937e-02f, 5.26198559e-03f, -1.02905622e-02f, 3.26919518e-02f,
  3.44682438e-03f, -9.08651128e-02f, 8.70124176e-02f, 4.61512730e-02f, -6.26309365e-02f, -1.75966546e-02f, 8.29685852e-02f, 6.76039532e-02f, -1.32386843e-02f, -7.34893009e-02f,
  2.64199913e-01f, -4.60187458e-02f, 1.57566980e-01f, -3.38816233e-02f, 1.04945013e-03f, 9.47363526e-02f, 1.20211348e-01f, 1.32704359e-02f, -3.46852690e-02f, -6.11849949e-02f,
  -4.43382710e-02f, -9.57027152e-02f, 8.33568648e-02f, 1.00466438e-01f, -2.23275647e-02f, -1.02290055e-02f, 7.64150023e-02f, 6.20213412e-02f, -3.00055332e-02f, -3.75593789e-02f,
  -2.23518033e-02f, 2.49539930e-02f, 1.86075717e-02f, -1.01249991e-02f, -3.28996740e-02f, -5.24697267e-02f, 8.69999900e-02f, -6.65472914e-03f, -5.61466254e-02f, 1.88426167e-01f
};

// L0_fan_Wp_bar (Shape: 10 x 120)
const int L0_fan_Wp_bar_rows = 10;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  8.73158574e-01f, 7.54394755e-02f, 3.44789267e-01f, 2.77803719e-01f, 2.86588639e-01f, 4.59325016e-01f, 6.69298291e-01f, 3.47972721e-01f, 1.85193688e-01f, 3.03028464e-01f,
  6.28838316e-02f, -2.38016292e-01f, -2.12731168e-01f, -1.91558823e-01f, 1.30500393e-02f, 1.66967556e-01f, 9.83746052e-02f, 1.25515074e-01f, 2.87025452e-01f, 3.04291368e-01f,
  -6.17568903e-02f, 1.39703602e-01f, 1.59707084e-01f, 6.41118065e-02f, 2.64795810e-01f, -4.13456373e-02f, 2.79373340e-02f, 1.49500936e-01f, -4.55295993e-03f, 1.62353944e-02f,
  2.94268787e-01f, 6.03572249e-01f, -8.32752585e-02f, -2.44036332e-01f, -1.23680688e-01f, 1.54406458e-01f, 1.11470170e-01f, -4.19968739e-03f, -1.33138508e-01f, 2.97706705e-02f,
  -1.14789583e-01f, 6.68276846e-02f, 1.42254412e-01f, 9.20399502e-02f, 1.89606532e-01f, 1.08933806e-01f, 1.84693217e-01f, 1.13179751e-01f, -7.77782500e-02f, 8.72087479e-03f,
  -1.38452157e-01f, 1.62831634e-01f, 1.10469475e-01f, -2.33554188e-02f, 1.63011938e-01f, -1.09537862e-01f, -6.05031140e-02f, 8.38414580e-02f, -7.54859904e-03f, 1.18773833e-01f,
  -7.31123835e-02f, 9.88181308e-02f, 1.16361909e-01f, 1.43096238e-01f, 1.16783500e-01f, -2.74384171e-02f, -8.67754593e-03f, -3.53479572e-02f, 5.29947542e-02f, 4.73906845e-02f,
  -6.50350749e-02f, 1.36932768e-02f, -7.48027787e-02f, 2.44299904e-01f, -2.16931105e-02f, 4.44825441e-02f, 6.49451390e-02f, 1.54681206e-02f, -1.11616261e-01f, 2.04237062e-03f,
  -4.09009941e-02f, -2.82670036e-02f, 3.81356776e-02f, -3.35434489e-02f, 6.09860048e-02f, 8.12281147e-02f, 9.10119042e-02f, 3.18694040e-02f, 1.45063177e-01f, 7.04848543e-02f,
  -5.08014739e-01f, -1.70386881e-01f, 1.23259556e-02f, -1.32073477e-01f, 4.97580227e-03f, -1.01189628e-01f, 3.74685451e-02f, -2.76263714e-01f, -2.73226440e-01f, -2.52837725e-02f,
  -5.86153492e-02f, 3.55147980e-02f, -3.66904773e-02f, 3.05213220e-02f, -1.14335686e-01f, -1.38343334e-01f, -1.08687855e-01f, -5.80427945e-02f, -2.47798905e-01f, -1.98713481e-01f,
  -2.74863690e-02f, -1.84753910e-02f, -6.75944537e-02f, -8.38409662e-02f, -8.25719088e-02f, -2.15517610e-01f, -2.12830931e-01f, -8.58778413e-03f, 4.67257202e-02f, -8.18952918e-02f,
  -4.99418527e-01f, -6.92032203e-02f, -3.36924970e-01f, -1.32149473e-01f, 2.30270728e-01f, 3.98010552e-01f, 1.64832070e-01f, 3.16142768e-01f, 2.04211324e-01f, -1.83479249e-01f,
  -1.20665580e-01f, -5.81047125e-03f, -2.91654378e-01f, -1.30226359e-01f, -1.24785073e-01f, -1.61432177e-01f, -3.69731992e-01f, -2.05084860e-01f, 2.30544195e-01f, 6.99032247e-01f,
  4.60455954e-01f, -1.11212783e-01f, -2.79429853e-01f, 4.71703485e-02f, -1.25903681e-01f, -9.69404057e-02f, -4.54539657e-01f, -2.70533979e-01f, -7.82579556e-02f, -4.57454950e-01f,
  -2.04507038e-01f, 2.06315666e-01f, 2.63311952e-01f, 1.34164630e-03f, -8.58647227e-02f, -7.97976777e-02f, 1.10715315e-01f, -1.28979594e-01f, -4.87516634e-02f, -1.64743885e-01f,
  -1.13796614e-01f, 1.74574360e-01f, -9.24616978e-02f, 9.67330113e-02f, 3.16185094e-02f, -2.80372519e-02f, 6.84762895e-02f, -8.08454230e-02f, -3.17745447e-01f, 4.67954241e-02f,
  -1.03499733e-01f, -4.27799337e-02f, -1.01216257e-01f, 5.15788049e-02f, -9.12367459e-03f, 1.16976723e-01f, -1.63444206e-02f, 1.01124644e-01f, 2.94408426e-02f, -2.37662986e-01f,
  1.11310355e-01f, -8.61736163e-02f, 1.53865010e-01f, 1.29280433e-01f, -4.18273620e-02f, -2.65718326e-02f, 1.21035121e-01f, 6.19113185e-02f, 5.65459132e-02f, -1.88290611e-01f,
  -3.26223345e-03f, 1.26865268e-01f, 7.62759000e-02f, -1.21751800e-01f, -2.18030885e-01f, -2.65514245e-04f, 4.51199003e-02f, -1.16857126e-01f, -3.74140926e-02f, -1.13405570e-01f,
  2.13402018e-01f, 2.45776400e-02f, -4.77196649e-02f, 1.13570966e-01f, -1.25110865e-01f, -1.11627512e-01f, 1.92182809e-01f, 2.52043486e-01f, 2.01527644e-02f, 1.85675755e-01f,
  -2.76601434e-01f, 6.27692714e-02f, -1.67536616e-01f, 4.17815708e-02f, -4.81518768e-02f, 2.50769872e-02f, -3.36416401e-02f, 1.29095137e-01f, 7.68113285e-02f, 4.15977417e-03f,
  2.23750323e-01f, 1.73072964e-01f, -5.05066141e-02f, 4.36313413e-02f, 1.08387440e-01f, 1.93963870e-02f, -1.64440110e-01f, 7.52099007e-02f, 1.02747336e-01f, 6.86141998e-02f,
  -8.45509693e-02f, -3.53076756e-01f, -1.06857941e-01f, -7.12436065e-02f, -1.26939893e-01f, 2.37360895e-02f, -3.21533144e-01f, -9.04479548e-02f, -7.11639225e-02f, -4.63419944e-01f,
  -4.50640023e-01f, -2.34679684e-01f, -3.11129034e-01f, 1.37219518e-01f, 3.18399966e-02f, -1.49172759e-02f, -1.80422023e-01f, 2.00941205e-01f, 1.67253405e-01f, -4.28531468e-02f,
  8.33839104e-02f, -1.57784030e-01f, -4.10987884e-01f, -4.13165361e-01f, -6.44141078e-01f, -5.03387928e-01f, -4.26887572e-01f, -8.10704350e-01f, -5.31172454e-01f, 1.64451227e-01f,
  -3.29092711e-01f, -6.18585110e-01f, -4.01046425e-01f, -7.04040080e-02f, 1.41515762e-01f, -5.81546575e-02f, -1.09233908e-01f, -1.56308666e-01f, -1.38899252e-01f, -3.14009696e-01f,
  -1.71442792e-01f, 4.19698209e-02f, 1.86301067e-01f, -1.21135488e-01f, 1.23228550e-01f, 7.34825507e-02f, -6.28357753e-02f, 3.26366052e-02f, 5.08466065e-02f, 1.44410402e-01f,
  4.20804508e-02f, 6.35169148e-02f, -1.38202280e-01f, -5.20288385e-03f, -1.39203239e-02f, 1.06691398e-01f, 1.22639038e-01f, -8.02317113e-02f, -5.35255931e-02f, 2.90977269e-01f,
  -4.82966304e-02f, -4.78584431e-02f, 1.52850494e-01f, 1.02451302e-01f, 1.43056691e-01f, -9.86412838e-02f, 2.03838363e-01f, 2.96285748e-01f, 1.30223811e-01f, 1.77362934e-01f,
  -6.75547421e-02f, 2.11592972e-01f, 1.29404575e-01f, -8.11994169e-03f, 5.01278974e-02f, 3.29307429e-02f, 4.50085476e-02f, -2.34111920e-02f, -1.65409073e-01f, -7.74491727e-02f,
  1.44922808e-01f, 1.29194297e-02f, 2.41849590e-02f, -4.66104709e-02f, -6.06224537e-02f, 4.95614670e-02f, -1.00682199e-01f, -4.36744094e-02f, 8.70834962e-02f, 7.35828355e-02f,
  -6.26844121e-03f, 3.90636474e-02f, -4.26465459e-02f, -2.98820585e-02f, -1.88826267e-02f, -7.40357339e-02f, -5.14239930e-02f, -1.11105047e-01f, 1.18636534e-01f, 5.44438791e-03f,
  -1.57800615e-02f, -3.46387357e-01f, -6.08371384e-02f, 5.56810424e-02f, 4.60087368e-03f, 1.25450671e-01f, -1.72749072e-01f, -9.02834255e-03f, -7.08809271e-02f, -7.13738613e-03f,
  1.45921066e-01f, -6.04022183e-02f, -8.38179439e-02f, 2.07721770e-01f, -5.31411432e-02f, 2.46324111e-02f, 1.49842098e-01f, -4.08851244e-02f, -1.04484171e-01f, 2.94881374e-01f,
  7.31356516e-02f, 4.26392332e-02f, -1.16485618e-01f, -9.77913570e-03f, 4.02603932e-02f, -3.43968183e-01f, -8.38335976e-02f, -8.07527918e-03f, -2.03033090e-01f, 1.66483939e-01f,
  1.79311082e-01f, -2.45706648e-01f, 5.61413728e-02f, 3.50595802e-01f, 3.53117585e-01f, 3.09386432e-01f, -1.39587119e-01f, 1.62680671e-01f, 3.82992566e-01f, 1.13409750e-01f,
  1.93120286e-01f, 3.73410553e-01f, 2.98063040e-01f, 2.86164075e-01f, 1.53530002e-01f, 1.31774366e-01f, 1.48618400e-01f, 2.20260635e-01f, 3.10519993e-01f, 1.18567452e-01f,
  1.90592140e-01f, -1.18948981e-01f, -1.24109827e-01f, -3.43413167e-02f, -1.06160946e-01f, 1.15851589e-01f, 9.39745381e-02f, -3.56554911e-02f, 3.63452323e-02f, 2.13691354e-01f,
  -5.64178219e-03f, -1.23258568e-02f, 2.90813059e-01f, 3.63474973e-02f, -3.26923057e-02f, -2.11276151e-02f, 3.10965106e-02f, 2.66120937e-02f, 2.26010364e-02f, -4.09865789e-02f,
  1.49194822e-01f, -1.51440948e-01f, -2.80430657e-04f, -1.99478045e-02f, -5.10211429e-03f, 3.51651721e-02f, -1.18969612e-01f, 2.72665806e-02f, -1.28719732e-02f, -1.23701161e-02f,
  6.77996650e-02f, 3.17311063e-02f, 1.19072340e-01f, 1.43606335e-01f, 8.37102234e-02f, 2.44830966e-01f, -3.28874998e-02f, 6.76068440e-02f, 1.47636816e-01f, -1.03941839e-02f,
  -3.35360467e-01f, 1.62916332e-01f, -1.08465806e-01f, -1.64296910e-01f, -1.64369270e-01f, -4.80488501e-02f, 6.79982752e-02f, 6.69203997e-02f, 2.51643360e-02f, -2.67172396e-01f,
  -2.53087189e-02f, 2.71389000e-02f, -5.02868444e-02f, 1.12236962e-01f, 8.30705985e-02f, -1.93309449e-02f, 1.04902506e-01f, -2.56509818e-02f, -1.07968614e-01f, 4.30066474e-02f,
  -1.79780405e-02f, 4.79095802e-02f, -6.11780919e-02f, -1.31748468e-01f, 4.65352610e-02f, 1.74089149e-01f, 1.03428744e-01f, 1.63833410e-01f, 5.42275235e-02f, 3.85107547e-02f,
  3.89318988e-02f, 1.17167018e-01f, 1.45504326e-01f, -7.37986639e-02f, -3.79591510e-02f, -1.27969399e-01f, -1.37457578e-02f, -4.14111689e-02f, 1.80429351e-02f, 1.77890547e-02f,
  7.17211738e-02f, -5.19393536e-04f, -3.03409155e-02f, -1.14776038e-01f, -7.87671953e-02f, 4.43123244e-02f, -4.01331708e-02f, 1.80958107e-01f, 3.99099439e-02f, -1.21640973e-01f,
  -8.74825791e-02f, 1.54156342e-01f, 2.06120074e-01f, 3.83520722e-02f, 4.76398729e-02f, 2.53657967e-01f, -8.02574009e-02f, 2.09805686e-02f, 7.57408664e-02f, -1.22027479e-01f,
  6.52223229e-01f, -7.24629641e-01f, 4.63428535e-02f, -8.68810266e-02f, 3.80405217e-01f, 4.64619040e-01f, 3.98108155e-01f, -8.81015137e-03f, -2.03172356e-04f, 1.07368380e-01f,
  -2.60687053e-01f, -2.09449559e-01f, -7.54259899e-02f, -2.11014286e-01f, -2.79823150e-02f, 1.28438115e-01f, 2.51851737e-01f, 2.94936746e-01f, 2.49329567e-01f, -5.98949008e-02f,
  -3.14305931e-01f, -2.39574581e-01f, -1.18602991e-01f, -8.23793039e-02f, -1.09424286e-01f, -3.67249222e-03f, -9.80269983e-02f, -2.02567369e-01f, -2.56372899e-01f, -5.10015249e-01f,
  -5.45701012e-02f, -2.39627898e-01f, 1.55402208e-02f, -2.02291951e-01f, -1.64820537e-01f, -1.43152336e-02f, 6.93598017e-02f, -4.48771790e-02f, -4.24192138e-02f, 1.12868890e-01f,
  -9.21849236e-02f, -1.17957190e-01f, -7.28506222e-02f, -3.37406807e-02f, -9.73153394e-03f, -7.53963366e-02f, -1.76642641e-01f, -2.63823748e-01f, -1.53999969e-01f, -9.49800387e-02f,
  -1.83620483e-01f, -1.32033229e-01f, 2.39521991e-02f, -2.51696277e-02f, -7.34814703e-02f, 8.63295048e-02f, -1.97977111e-01f, -2.01130852e-01f, -3.25673670e-02f, -2.34185725e-01f,
  6.05614148e-02f, 1.46467313e-01f, 1.89320017e-02f, 1.96206924e-02f, 1.38341095e-02f, 1.07723407e-01f, 1.18116632e-01f, -2.25854088e-02f, -1.43250935e-02f, 2.21389569e-02f,
  9.28444788e-02f, -2.76118703e-03f, 9.56495758e-03f, 4.34662076e-03f, -1.00845329e-01f, 6.00589113e-03f, 4.56401296e-02f, -7.73861259e-02f, -5.51080368e-02f, 5.84591813e-02f,
  -1.40282303e-01f, -2.51137316e-02f, 9.47174728e-02f, -9.51687694e-02f, -5.16228564e-03f, -1.84652898e-02f, -1.98003724e-02f, -9.46302563e-02f, -2.61906534e-02f, -2.91781407e-02f,
  -2.40013659e-01f, 7.87655339e-02f, 2.17696413e-01f, -1.51009634e-01f, 7.51842037e-02f, -1.21444292e-01f, -1.91631280e-02f, -8.01237598e-02f, -6.71995655e-02f, -3.05096880e-02f,
  -1.97497513e-02f, 5.22569381e-03f, -1.44515205e-02f, -1.00868769e-01f, 1.38617322e-01f, 1.10246219e-01f, -2.09998041e-02f, 3.54052335e-02f, -1.91567745e-02f, 4.25056443e-02f,
  -2.23601684e-02f, 1.54037103e-01f, 2.30026662e-01f, 2.78922349e-01f, 4.05373946e-02f, 3.69347095e-01f, 2.30631247e-01f, 1.04231387e-01f, 2.46853977e-01f, 2.86938012e-01f,
  -3.24046910e-01f, -2.17532814e-01f, -6.23466015e-01f, 2.54665494e-01f, 3.05183083e-01f, 3.19643140e-01f, 2.88844764e-01f, 2.47053668e-01f, 3.00742179e-01f, 7.04632774e-02f,
  4.24193107e-02f, 2.11507514e-01f, 2.32414544e-01f, 1.25187784e-01f, 1.30447775e-01f, 2.52677441e-01f, 3.14769387e-01f, -1.72784030e-01f, -2.45296448e-01f, 1.34349078e-01f,
  3.87623787e-01f, -1.34068877e-01f, -3.59049141e-01f, 4.26827073e-02f, -1.01336427e-01f, 1.07932217e-01f, -2.17654198e-01f, -4.20678593e-02f, 7.60070086e-02f, -2.10682318e-01f,
  -3.82073134e-01f, -2.61473805e-01f, 5.37180379e-02f, -5.25872633e-02f, -2.38124758e-01f, -5.05100451e-02f, 4.55293953e-02f, -2.14447439e-01f, -2.47733332e-02f, 2.21198406e-02f,
  -5.05583137e-02f, 3.17593524e-03f, 2.14167815e-02f, -6.94437921e-02f, -8.10250789e-02f, -1.09170685e-02f, -1.15112253e-01f, -6.30834252e-02f, 7.39197880e-02f, 4.73690638e-03f,
  2.40523621e-01f, 8.50725472e-02f, -1.90596744e-01f, 1.69217363e-01f, -4.46649157e-02f, 4.04541269e-02f, -2.22313985e-01f, -1.27680004e-01f, -1.05492905e-01f, -2.57005394e-01f,
  1.76933795e-01f, -8.50619003e-02f, -7.06198737e-02f, -9.27878693e-02f, 1.17271960e-01f, 4.24407832e-02f, -1.10672846e-01f, -8.13411921e-02f, 1.46678556e-02f, -5.27791232e-02f,
  -1.73141994e-02f, 1.87363595e-01f, 7.27258390e-03f, 4.12955023e-02f, 1.71378747e-01f, -8.53662789e-02f, 8.94755404e-03f, -1.37150073e-02f, -1.18264444e-01f, -1.63665891e-01f,
  -1.02544919e-01f, -7.13312104e-02f, -5.75666167e-02f, -7.32891634e-02f, 1.09078258e-01f, 3.13695474e-03f, 5.75845577e-02f, -1.72454573e-03f, 5.90589643e-02f, 2.34369375e-02f,
  3.17943990e-01f, 3.10285628e-01f, -7.30912481e-03f, 1.91907957e-02f, -1.30534425e-01f, -5.48764952e-02f, 3.84046957e-02f, -5.39960526e-02f, -2.60717273e-02f, 4.12913524e-02f,
  -5.31111583e-02f, -2.23210469e-01f, -1.44177943e-01f, -1.48604140e-01f, -3.00657712e-02f, -8.92806500e-02f, -1.62082370e-02f, -1.39915291e-02f, 1.47266492e-01f, 4.14741449e-02f,
  8.62717927e-02f, 1.60510540e-01f, 9.34999138e-02f, 3.59516069e-02f, 3.80315296e-02f, 3.31442833e-01f, -7.65937194e-02f, -4.59523220e-03f, 4.59859371e-02f, 1.99628379e-02f,
  -7.85190225e-01f, 1.09627880e-01f, 2.58539110e-01f, -6.97417706e-02f, 3.20000708e-01f, 9.57075655e-02f, 3.89933109e-01f, 2.64975816e-01f, 1.90508682e-02f, 2.40685090e-01f,
  -1.59703061e-01f, -4.46115434e-01f, -2.61358082e-01f, -5.62543906e-02f, -2.29018033e-01f, 2.61402905e-01f, 1.66656241e-01f, -2.33228698e-01f, -2.12502047e-01f, 1.50095925e-01f,
  3.02770063e-02f, -2.29656696e-02f, -4.02827919e-01f, 5.67676388e-02f, 6.93697482e-02f, -5.04766703e-02f, 1.63505793e-01f, -1.35705814e-01f, 1.44115184e-02f, 1.66687537e-02f,
  -2.82766908e-01f, -2.43588284e-01f, -1.98661722e-02f, -9.92255509e-02f, -1.73466086e-01f, -2.16903329e-01f, -5.83901778e-02f, -2.49592103e-02f, -1.26274407e-01f, -2.59235855e-02f,
  -2.45190337e-01f, -1.47555426e-01f, -2.13408977e-01f, -5.95617704e-02f, -8.80432203e-02f, -1.25997409e-01f, -3.24330032e-02f, -2.57623028e-02f, -1.99799865e-01f, 7.38717243e-02f,
  -4.57524769e-02f, -2.67483257e-02f, 1.03661537e-01f, 1.04754940e-01f, -9.30307135e-02f, -1.40964106e-01f, -5.97521141e-02f, -1.26340076e-01f, -4.97740414e-03f, 2.55332083e-01f,
  2.86280867e-02f, 1.11097358e-02f, -1.32991420e-02f, 2.95118298e-02f, 1.33998901e-01f, 1.27080176e-03f, 1.51180848e-02f, 3.84137593e-02f, 9.32806358e-02f, 7.84967393e-02f,
  -3.50369364e-02f, -6.95897713e-02f, 4.26727161e-02f, 1.91763993e-02f, 3.49800773e-02f, -9.90579426e-02f, -9.10683721e-02f, -9.22541693e-02f, -2.56093089e-02f, 3.32934707e-02f,
  -6.93062879e-03f, 7.70139918e-02f, 5.04176356e-02f, -3.43131572e-02f, -5.45503199e-02f, -2.90790610e-02f, -7.67656043e-02f, 2.52257772e-02f, -1.79455969e-02f, -1.14447676e-01f,
  1.03953071e-01f, -1.41146481e-01f, -8.93048644e-02f, 1.68273479e-01f, 1.38846710e-01f, -1.62058815e-01f, -2.79328059e-02f, 7.26950467e-02f, -1.10755935e-01f, 3.56387347e-02f,
  -5.60322814e-02f, -1.46920666e-01f, 6.39113560e-02f, 1.12421311e-01f, 3.11852507e-02f, 2.12448444e-02f, 2.23689270e-03f, 8.52204952e-03f, -1.42203299e-02f, -3.55999134e-02f,
  3.24871019e-02f, 3.21595013e-01f, 2.48254254e-01f, 2.31732979e-01f, -1.87479926e-03f, 1.37387067e-01f, 1.21000871e-01f, 7.47023001e-02f, 9.20521393e-02f, 4.92817968e-01f,
  -1.87670253e-02f, 5.53551279e-02f, 2.97077715e-01f, -1.54042348e-01f, 5.32378614e-01f, 5.09645700e-01f, 7.28001237e-01f, 3.40637833e-01f, -1.33778080e-01f, 1.65617809e-01f,
  1.28590107e-01f, -4.15601462e-01f, -3.90728265e-01f, -3.83515298e-01f, -1.00987606e-01f, 2.00418666e-01f, -4.95619774e-02f, -1.42064869e-01f, 1.52132576e-02f, 1.42442852e-01f,
  -1.83415875e-01f, 1.19676322e-01f, 7.27441348e-03f, -1.34449631e-01f, -1.03575319e-01f, -3.83211583e-01f, 7.73497075e-02f, 2.10193887e-01f, 4.49471362e-02f, -4.03511614e-01f,
  -1.80706140e-02f, 2.33338952e-01f, -3.13831568e-01f, -2.85599798e-01f, -5.37102763e-03f, -1.08822167e-01f, -8.26248303e-02f, -9.08757150e-02f, -7.82553479e-02f, 2.21139658e-02f,
  2.15572882e-02f, 1.15349805e-02f, 1.29400253e-01f, 2.29592975e-02f, 2.25399911e-01f, 1.22980736e-01f, 8.10524449e-02f, -1.85197204e-01f, -1.78635523e-01f, -5.08134700e-02f,
  -2.32560277e-01f, 1.63280711e-01f, 2.73787588e-01f, 3.20373029e-02f, -1.01880999e-02f, -8.59591365e-02f, 9.69414711e-02f, -5.30597381e-02f, -5.72963916e-02f, -1.52706921e-01f,
  -1.32711064e-02f, -5.07095195e-02f, -3.55525389e-02f, -4.29716371e-02f, -1.32257700e-01f, 1.12223148e-01f, -8.14198554e-02f, -1.22706220e-01f, -1.48179695e-01f, 1.11260312e-02f,
  3.66430804e-02f, -1.86138768e-02f, 2.74810329e-04f, 9.41200554e-02f, -5.67961819e-02f, 7.97184035e-02f, 1.44713908e-01f, 4.89564054e-02f, 6.94130287e-02f, -5.51670119e-02f,
  -8.56904536e-02f, 9.58851650e-02f, 2.37418264e-02f, -1.43754552e-03f, -5.13813831e-02f, 1.02739874e-02f, -8.98523182e-02f, -3.88549939e-02f, 4.25565392e-02f, -1.67096294e-02f,
  -1.44386888e-01f, 6.08708821e-02f, -4.07374576e-02f, 8.12322646e-03f, 5.51771745e-02f, -1.66513368e-01f, -2.27533691e-02f, -1.40880197e-01f, 2.36167125e-02f, 8.90217796e-02f,
  1.96204856e-01f, -8.37671533e-02f, 1.50617212e-01f, 9.76965576e-03f, 1.45519190e-02f, 6.80860924e-03f, -8.16388801e-02f, -9.73714292e-02f, -1.01064444e-01f, 1.46329664e-02f,
  -8.87789354e-02f, 2.97822580e-02f, -9.39605534e-02f, -8.21635053e-02f, -1.27057597e-01f, -8.01875144e-02f, 2.00143573e-03f, 4.47922200e-03f, 1.10656284e-01f, 5.89505993e-02f,
  -7.60713041e-01f, -3.15729678e-01f, -3.30497801e-01f, 1.55769497e-01f, 2.60253459e-01f, 1.49713561e-01f, 1.10449716e-01f, 1.08461097e-01f, 1.33900657e-01f, -2.38299832e-01f,
  -6.03969470e-02f, 9.77072045e-02f, -2.05924846e-02f, 9.33820754e-02f, 2.40046699e-02f, 8.17188546e-02f, 1.57173783e-01f, -6.04952797e-02f, -4.13097478e-02f, 3.05928737e-01f,
  3.70482564e-01f, -3.90211642e-02f, -2.33539879e-01f, 2.32930891e-02f, -1.23956185e-02f, 1.12559646e-01f, -1.08723775e-01f, -7.00812638e-02f, 1.02254242e-01f, -1.38336614e-01f,
  -1.79597452e-01f, -3.19495916e-01f, -9.26628411e-02f, 3.68360206e-02f, 5.63480817e-02f, -9.30013210e-02f, 1.54178496e-03f, -9.66052040e-02f, 5.37249334e-02f, 1.23679295e-01f,
  4.18820279e-03f, -9.69656929e-02f, 1.80822775e-01f, -8.67170002e-03f, 1.88677851e-02f, 1.20598629e-01f, -1.03964806e-01f, -2.59508908e-01f, -1.47826701e-01f, -1.58048227e-01f,
  2.47820005e-01f, 3.22387397e-01f, -1.63304999e-01f, 6.79337606e-02f, -2.25184649e-01f, -1.54200420e-01f, -2.04152882e-01f, -8.27552751e-02f, -1.47804052e-01f, -4.31070089e-01f,
  -9.56956223e-02f, 2.25322251e-03f, -3.99648547e-02f, -1.21295668e-01f, -5.86348120e-03f, 9.94787365e-02f, -2.06978153e-02f, -3.83568406e-02f, -3.12563702e-02f, 3.33333947e-02f,
  8.18017870e-02f, -1.49969369e-01f, -1.17613584e-01f, 1.85400471e-02f, 1.35476202e-01f, -1.53268082e-02f, 2.28302673e-01f, -3.58114652e-02f, 2.04595014e-01f, -4.31543030e-03f,
  -1.27495497e-01f, -6.20267913e-02f, -6.39225021e-02f, 7.26165948e-03f, 5.21883741e-02f, -4.03290242e-03f, -6.12354763e-02f, -1.76380262e-01f, -1.86816886e-01f, -8.70990008e-02f,
  -9.84059349e-02f, 1.71295270e-01f, -4.19319561e-03f, -6.49726316e-02f, -2.09135916e-02f, 1.19705670e-01f, 7.03102872e-02f, -1.74161583e-01f, -1.51060149e-01f, -8.48694667e-02f,
  -7.88595974e-02f, -1.22012816e-01f, 9.56512243e-03f, -6.60698637e-02f, 1.49752796e-01f, 3.02752275e-02f, 4.47242102e-03f, -1.43379092e-01f, 7.31885135e-02f, -4.27277088e-02f,
  -5.65836951e-02f, 2.34342739e-01f, -2.04130188e-01f, -1.82872340e-01f, 8.00519809e-02f, 9.89485905e-02f, 1.53609307e-03f, -6.71768188e-02f, -4.03170213e-02f, -4.16837662e-01f,
  -9.57941651e-01f, 2.43758529e-01f, 4.83720452e-01f, -8.96238208e-01f, 2.27944374e-01f, 3.11146319e-01f, 7.17232645e-01f, 1.03130020e-01f, -4.70024765e-01f, 1.23966791e-01f,
  3.63189459e-01f, -1.89546585e-01f, -5.64444698e-02f, -4.22626883e-02f, 1.93607226e-01f, 3.02802742e-01f, 2.69326791e-02f, -1.72801509e-01f, -2.05267578e-01f, 3.05687971e-02f,
  -1.89370498e-01f, -3.32289159e-01f, -6.32159352e-01f, -2.40043983e-01f, -1.41156107e-01f, -2.84088135e-01f, 2.72389382e-01f, 1.32934749e-02f, 3.07756722e-01f, -2.03380719e-01f,
  4.76688206e-01f, 2.11920202e-01f, -8.54226798e-02f, -1.99441165e-01f, 9.37619284e-02f, -8.85151476e-02f, -1.17192296e-02f, 1.89346001e-02f, -2.81055178e-02f, 7.97311892e-04f,
  1.13982238e-01f, 2.47713011e-02f, -7.57950470e-02f, -1.99002749e-03f, 2.06651189e-03f, -4.99286652e-02f, -6.82467222e-03f, -5.31455642e-03f, 1.81732044e-01f, 2.62797713e-01f,
  1.54846415e-01f, 6.03105016e-02f, 2.09612861e-01f, 1.66739672e-01f, 2.26898238e-01f, -8.31795782e-02f, 2.20201910e-01f, -2.09380537e-02f, 8.87214169e-02f, -2.65006900e-01f,
  2.04204842e-02f, 5.77432141e-02f, 6.12583533e-02f, -6.18020110e-02f, -1.01458393e-01f, 7.10514039e-02f, 1.79377559e-03f, 2.56907735e-02f, -2.54839659e-02f, -2.34401431e-02f,
  -2.69656954e-03f, 1.00501567e-01f, 2.77763642e-02f, -3.29449438e-02f, 3.73183750e-02f, -1.54721877e-03f, -1.48778837e-02f, -7.76675530e-03f, -1.01259341e-02f, -2.88755782e-02f,
  -1.07491337e-01f, -8.10013041e-02f, -1.41213951e-03f, 1.20653026e-02f, 1.64361343e-01f, -3.18513699e-02f, 7.09403008e-02f, 1.00996625e-02f, -2.89273285e-03f, -5.82587440e-04f,
  -1.88236862e-01f, 1.11827500e-01f, -1.68320820e-01f, 1.23334099e-02f, -4.03085724e-02f, 2.59588398e-02f, -5.98943308e-02f, -9.84306727e-03f, 8.47496018e-02f, -1.33620538e-02f,
  7.71088898e-03f, -7.27032274e-02f, 8.17691237e-02f, 5.76668307e-02f, -1.49629399e-01f, -5.25825005e-03f, 6.81712106e-02f, -1.53622895e-01f, 1.15648843e-01f, -1.74402613e-02f,
  7.03589395e-02f, -1.84015661e-01f, -3.32870066e-01f, -3.63878235e-02f, -1.07690923e-01f, -1.79441601e-01f, 7.26996139e-02f, 8.55802465e-03f, 1.13256969e-01f, -4.29243408e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 10)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 10;
const float L0_fan_Bp_bar_data[] = {
  3.15556675e-01f, -8.97400156e-02f, 1.77526265e-01f, -2.58828640e-01f, 7.46524692e-01f, 1.75347507e-01f, 7.05372036e-01f, 5.14019392e-02f, 4.00631391e-02f, 3.37339491e-01f
};

// L1_fan_Wp (Shape: 3 x 16)
const int L1_fan_Wp_rows = 3;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  -8.89303163e-02f, -1.65752202e-01f, 1.32154420e-01f, 1.71599805e-01f, -1.32400945e-01f, 1.50763512e-01f, -1.11626908e-01f, 8.20587501e-02f, 1.04816176e-01f, 1.63054541e-01f,
  2.07358509e-01f, 3.77414107e-01f, -6.85663894e-02f, -6.75222799e-02f, 1.02476813e-01f, -4.59215343e-01f, 9.87936482e-02f, 5.70825450e-02f, 1.67716324e-01f, 1.50913849e-01f,
  -9.62752327e-02f, 2.09997222e-01f, -1.25792801e-01f, 3.92354131e-01f, -4.64281961e-02f, 8.01881477e-02f, -1.10338882e-01f, -4.42911051e-02f, 2.01763093e-01f, -3.95161539e-01f,
  3.61720473e-01f, 2.92334229e-01f, 9.69558135e-02f, 2.77261566e-02f, -1.17658295e-01f, -1.07187100e-01f, 1.08672574e-01f, 5.67206323e-01f, -4.06014966e-03f, -1.90791503e-01f,
  2.93816626e-01f, -6.48979023e-02f, -1.14976041e-01f, 3.23564410e-01f, 4.31463897e-01f, -2.66460657e-01f, -6.83761314e-02f, -2.18393639e-01f
};

// L1_fan_Wp_bar (Shape: 10 x 16)
const int L1_fan_Wp_bar_rows = 10;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  -2.28374377e-01f, 2.25262836e-01f, 7.80448854e-01f, -4.41823065e-01f, -1.02052295e+00f, 1.30441308e-01f, -2.39413589e-01f, 4.31744635e-01f, 5.27849495e-01f, -2.45362282e-01f,
  2.28752598e-01f, 1.55747697e-01f, 1.21779107e-01f, -4.16525006e-02f, -1.44771397e-01f, -1.41892612e-01f, 7.96601295e-01f, -4.79893424e-02f, -1.30470216e-01f, -4.32931393e-01f,
  1.69747099e-01f, 5.28185308e-01f, -2.60119557e-01f, 2.56389499e-01f, 3.04979086e-01f, -4.11333889e-01f, 9.52293631e-04f, 3.85086954e-01f, 6.37863576e-01f, -3.61552805e-01f,
  -1.81184392e-02f, 7.73260176e-01f, -3.57942432e-01f, 3.24640304e-01f, 5.47261477e-01f, 6.86824203e-01f, -4.81424212e-01f, 2.75843680e-01f, 3.15263897e-01f, 3.41685891e-01f,
  2.37350643e-01f, -6.99072555e-02f, -2.89708078e-01f, 3.79879586e-02f, -7.38658905e-02f, -2.82705367e-01f, 3.76722455e-01f, -4.76413757e-01f, 3.73692103e-02f, 2.30708241e-01f,
  -1.18996724e-01f, 3.96207750e-01f, 4.92196798e-01f, -2.14006558e-01f, 4.10267144e-01f, -1.73653528e-01f, -4.30073202e-01f, -1.99240685e-01f, 4.44559366e-01f, -8.62964988e-02f,
  3.55154306e-01f, 7.64375746e-01f, -3.16834688e-01f, 7.01554000e-01f, 4.17692721e-01f, 2.65979946e-01f, 3.39206576e-01f, 1.35466442e-01f, -5.17525971e-01f, 1.73015878e-01f,
  1.72725126e-01f, 7.15968311e-01f, 4.93449390e-01f, -2.64240116e-01f, -2.61429816e-01f, 1.58396915e-01f, -3.17957737e-02f, 8.80194426e-01f, 3.35116804e-01f, 6.70362711e-01f,
  8.66986394e-01f, 5.54877996e-01f, -2.00013831e-01f, -5.05320013e-01f, 4.24161136e-01f, -2.77274907e-01f, -1.17495768e-01f, 3.46643627e-01f, 4.89468098e-01f, -1.60406515e-01f,
  1.12011909e+00f, 6.11335263e-02f, 6.99524760e-01f, 3.55866462e-01f, 2.86421329e-01f, 2.23693460e-01f, -6.46635115e-01f, -1.37915730e-01f, 4.85202998e-01f, -4.58259322e-02f,
  -2.44309798e-01f, 8.81085470e-02f, 1.83454111e-01f, 7.96778679e-01f, -3.15247066e-02f, -8.54021758e-02f, 1.77150726e-01f, 7.56517112e-01f, 4.14844245e-01f, -1.36609644e-01f,
  7.84106433e-01f, 2.39768520e-01f, -1.27956375e-01f, 2.82503486e-01f, 3.35493714e-01f, 1.41252831e-01f, -3.68104279e-01f, -4.14036274e-01f, 1.45242453e-01f, 1.21438183e-01f,
  1.88679919e-01f, 3.49291526e-02f, 9.29833114e-01f, 8.26491714e-02f, -1.64111018e-01f, -3.48026246e-01f, -5.54925382e-01f, -8.82194281e-01f, -1.19768403e-01f, 9.04266089e-02f,
  5.48213795e-02f, 8.04517865e-01f, -1.83384553e-01f, -1.65522605e-01f, 4.15762037e-01f, 1.08169660e-01f, 1.40597383e-02f, 3.07266891e-01f, 4.34792936e-01f, 4.57551509e-01f,
  -9.44416150e-02f, 5.37774622e-01f, -3.37520361e-01f, -1.25466332e-01f, -3.28284204e-01f, 6.28331751e-02f, 1.61373481e-01f, 3.69010240e-01f, -1.02841616e-01f, 4.30931263e-02f,
  -4.27136617e-03f, 4.71569598e-01f, 4.00189906e-01f, 1.92118287e-01f, -2.51949966e-01f, 4.26536530e-01f, 8.86753127e-02f, -8.68276227e-03f, 7.15609252e-01f, 1.34577587e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 10)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 10;
const float L1_fan_Bp_bar_data[] = {
  2.97671556e-01f, 2.50884771e-01f, 2.43366882e-01f, 5.79380870e-01f, 3.03502500e-01f, 7.43988931e-01f, -1.53420463e-01f, 3.83878857e-01f, 3.27330172e-01f, -4.08907235e-03f
};

// L2_fan_Wp (Shape: 3 x 16)
const int L2_fan_Wp_rows = 3;
const int L2_fan_Wp_cols = 16;
const float L2_fan_Wp_data[] = {
  3.81235704e-02f, -2.88490206e-01f, 9.90963951e-02f, -3.96278232e-01f, 3.42523128e-01f, 3.13766440e-03f, 2.08386034e-01f, 2.85731703e-01f, 4.76687867e-03f, -2.36885831e-01f,
  -8.98529068e-02f, 7.62745738e-02f, 1.04656763e-01f, -2.13724583e-01f, -2.14011744e-01f, -1.63917229e-01f, -4.69055884e-02f, -4.47570421e-02f, 1.80559397e-01f, 3.66321355e-01f,
  2.86769152e-01f, -4.30434681e-02f, 2.66396016e-01f, 1.60972014e-01f, -6.25597119e-01f, -1.06645606e-01f, -2.73294169e-02f, 3.52790862e-01f, -2.24732794e-02f, 2.13017821e-01f,
  -1.63700506e-01f, -9.37145017e-03f, -2.36447081e-01f, 2.56668240e-01f, 1.46496654e-01f, 3.02096754e-01f, -4.33126045e-03f, -2.02386975e-01f, -2.28882149e-01f, -5.22732437e-01f,
  2.77467966e-01f, -4.78825234e-02f, 7.86136091e-02f, 7.12366924e-02f, -4.43664998e-01f, 2.94255801e-02f, 4.23635930e-01f, 2.81271458e-01f
};

// L2_fan_Wp_bar (Shape: 10 x 16)
const int L2_fan_Wp_bar_rows = 10;
const int L2_fan_Wp_bar_cols = 16;
const float L2_fan_Wp_bar_data[] = {
  2.04282925e-01f, 1.88137293e-01f, 1.92859873e-01f, -4.68730330e-01f, -5.02984345e-01f, -4.11389381e-01f, -2.92962581e-01f, 9.16088074e-02f, -2.24189416e-01f, 8.61568391e-01f,
  -8.26681480e-02f, 7.35508442e-01f, -3.44738849e-02f, 3.05454284e-01f, 8.04851734e-05f, -4.07907009e-01f, 9.03918445e-02f, -5.66872060e-01f, -8.34195502e-03f, 5.63775897e-01f,
  3.50707173e-01f, 7.68506201e-03f, 3.82554382e-01f, 6.20516419e-01f, -4.32670236e-01f, 3.39038670e-01f, 4.77435589e-01f, 5.60947835e-01f, 6.11133933e-01f, -2.93867469e-01f,
  -5.86060695e-02f, 5.12486398e-01f, -5.07269442e-01f, -6.49437666e-01f, 1.81142092e-02f, 3.02642763e-01f, 1.72720477e-01f, 1.05722599e-01f, 6.42202571e-02f, 1.99258372e-01f,
  1.53590322e-01f, -2.08608419e-01f, 7.11899340e-01f, 2.60224789e-01f, 6.34576797e-01f, -4.20722365e-01f, -5.04944921e-02f, 4.65763986e-01f, 7.83291273e-03f, 7.35476732e-01f,
  3.67252797e-01f, 1.03383648e+00f, -8.06486666e-01f, 1.00967562e+00f, 7.12437809e-01f, -3.74538153e-01f, 5.57493627e-01f, 1.05462670e-01f, 1.61093734e-02f, 5.72725758e-03f,
  3.16257030e-01f, 4.00648534e-01f, 2.03919113e-02f, -3.03983223e-02f, -8.98040384e-02f, -3.43019247e-01f, -2.63704747e-01f, -9.53590512e-01f, -7.79532969e-01f, -3.50940824e-01f,
  -6.41954124e-01f, 2.96395123e-01f, -5.63889369e-02f, 9.15865242e-01f, 2.58869052e-01f, 1.80622160e-01f, 3.69521797e-01f, -1.88932732e-01f, 1.61898464e-01f, -4.84991789e-01f,
  2.52904505e-01f, 1.71971217e-01f, -7.72666633e-02f, -2.88562365e-02f, 6.72669232e-01f, 7.37245798e-01f, 4.95204777e-01f, 7.22271800e-01f, -2.16961250e-01f, 6.46415949e-01f,
  7.55285978e-01f, 8.68369162e-01f, -7.41874158e-01f, -4.82269526e-01f, -2.85269827e-01f, -3.78756493e-01f, 3.09904426e-01f, 6.45745039e-01f, 6.19048417e-01f, -8.91070604e-01f,
  -3.91000390e-01f, -3.84836644e-01f, -1.31599709e-01f, -2.97815323e-01f, 5.11376917e-01f, 3.19196403e-01f, 5.53970098e-01f, -4.81812298e-01f, -7.00262249e-01f, 5.11910506e-02f,
  -1.78636119e-01f, -3.93444210e-01f, 4.77822900e-01f, 2.58816004e-01f, 7.85711884e-01f, 2.33101040e-01f, -7.53079176e-01f, 8.04596663e-01f, 1.81358039e-01f, -3.49871039e-01f,
  1.05137324e+00f, 4.95393872e-02f, -2.56021649e-01f, 6.30918965e-02f, 6.13970041e-01f, 2.72081226e-01f, 2.42519006e-02f, 9.12004113e-02f, 4.09680307e-01f, 5.78105092e-01f,
  6.62993848e-01f, 4.00591612e-01f, -8.53001177e-01f, -3.00733984e-01f, 5.67763031e-01f, -2.22063944e-01f, -1.30395934e-01f, -1.57232940e-01f, -1.95417613e-01f, 1.76459759e-01f,
  -1.76313072e-01f, 7.53642857e-01f, 4.63663667e-01f, 8.33334699e-02f, 3.14669639e-01f, 4.62318927e-01f, 1.82184279e-01f, -1.08174741e-01f, -5.84915102e-01f, -3.92364830e-01f,
  -1.25795290e-01f, 3.81274581e-01f, -7.44395733e-01f, 8.26876223e-01f, -2.70499736e-02f, 8.30699563e-01f, -1.02804929e-01f, 6.41361251e-02f, 1.20435029e-01f, -5.26647568e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 10)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 10;
const float L2_fan_Bp_bar_data[] = {
  3.56674790e-01f, 2.06539020e-01f, 9.41797625e-03f, 1.55015931e-01f, 1.63567841e-01f, 4.48135406e-01f, 3.87742788e-01f, 3.75634462e-01f, 2.48899922e-01f, 4.86522764e-01f
};

// L3_fan_Wp (Shape: 3 x 16)
const int L3_fan_Wp_rows = 3;
const int L3_fan_Wp_cols = 16;
const float L3_fan_Wp_data[] = {
  1.03558309e-01f, -5.75386107e-01f, 7.36706052e-03f, -1.19832046e-02f, -4.91681933e-01f, 1.86418463e-03f, 2.08746701e-01f, 7.64740109e-02f, -2.05002040e-01f, -6.61609136e-03f,
  3.29330444e-01f, -8.64451006e-02f, 3.39072406e-01f, 1.30070031e-01f, -3.93697470e-01f, 4.17164825e-02f, 5.97170889e-01f, 1.10067420e-01f, -1.41611710e-01f, 1.11934073e-01f,
  1.80648088e-01f, -2.55316824e-01f, 4.70427200e-02f, 2.50276476e-02f, 2.92622745e-01f, 1.70535922e-01f, 1.33504998e-02f, 2.82498896e-02f, -7.06576109e-02f, 1.16396517e-01f,
  -4.65544015e-01f, -1.74283832e-01f, 2.02034682e-01f, -5.61657727e-01f, 3.67644548e-01f, 8.94081533e-01f, -5.20762019e-02f, -6.75542131e-02f, -2.72221595e-01f, -1.03308819e-01f,
  1.14757955e-01f, 8.86116549e-02f, -4.16176096e-02f, 1.67220727e-01f, 4.08288762e-02f, 1.75452173e-01f, 4.27352004e-02f, -2.04108596e-01f
};

// L3_fan_Wp_bar (Shape: 10 x 16)
const int L3_fan_Wp_bar_rows = 10;
const int L3_fan_Wp_bar_cols = 16;
const float L3_fan_Wp_bar_data[] = {
  -2.61048973e-01f, 2.58835610e-02f, -1.93916131e-02f, 2.55275548e-01f, -5.05674362e-01f, 3.52185905e-01f, -4.94839758e-01f, 4.57696259e-01f, 7.11959839e-01f, -3.53278339e-01f,
  -1.23437300e-01f, 7.83902109e-02f, 2.58368284e-01f, -3.27131078e-02f, -5.15109360e-01f, 1.42300174e-01f, -1.35574475e-01f, -7.23411977e-01f, -5.88220596e-01f, 2.39296645e-01f,
  8.43857825e-01f, -1.27851236e+00f, 2.20869258e-01f, -8.14361647e-02f, -4.01361823e-01f, 8.75034332e-01f, 6.49457648e-02f, 2.42661342e-01f, -1.37429416e+00f, 3.25920105e-01f,
  2.23219708e-01f, 3.09879512e-01f, 2.94198059e-02f, -1.57253474e-01f, -4.01467904e-02f, 6.45991385e-01f, 5.39544970e-02f, 3.85871857e-01f, -1.19709700e-01f, 4.51669604e-01f,
  6.05289996e-01f, -1.19030751e-01f, -9.77533236e-02f, -1.17523551e-01f, 7.37230897e-01f, 5.36330119e-02f, 5.73508292e-02f, -4.58045721e-01f, 5.07986963e-01f, -6.32274508e-01f,
  -9.22758639e-01f, 6.59784853e-01f, 1.19355597e-01f, -7.08908975e-01f, -6.62653685e-01f, -1.19191650e-02f, 1.98717982e-01f, 2.43871376e-01f, -1.00019348e+00f, 5.84496737e-01f,
  7.71333203e-02f, 1.63530380e-01f, 3.16398330e-02f, -2.26883501e-01f, 9.12831247e-01f, 8.59188437e-01f, 1.27932048e+00f, -1.95747122e-01f, 6.06061518e-01f, 4.63465363e-01f,
  3.51201624e-01f, 8.18926618e-02f, 5.60256317e-02f, 5.73369920e-01f, -5.34125745e-01f, -5.59464931e-01f, 1.52648300e-01f, 7.58209586e-01f, 4.13808018e-01f, 1.67823717e-01f,
  4.73258942e-01f, 5.42123616e-01f, 3.79690140e-01f, -7.20194995e-01f, -3.18789393e-01f, 9.99418437e-01f, 5.12079954e-01f, -4.83677924e-01f, -3.77777725e-01f, 1.42234787e-01f,
  6.68918312e-01f, -3.98823947e-01f, 1.01657832e+00f, 6.28358722e-01f, 6.25404239e-01f, 3.25418591e-01f, -6.65121675e-01f, -3.99022490e-01f, -5.03226995e-01f, 4.71012056e-01f,
  1.41555503e-01f, -2.45468453e-01f, 1.50825843e-01f, 4.30011749e-01f, 4.56203401e-01f, -4.46561016e-02f, 2.63972022e-02f, 8.93198967e-01f, -5.23383379e-01f, -1.88466087e-01f,
  -3.05337489e-01f, -1.80261042e-02f, -3.20684433e-01f, -3.64724189e-01f, -5.64226359e-02f, 3.73594999e-01f, 9.14368629e-01f, -8.62810493e-01f, 4.00266618e-01f, 6.15107417e-01f,
  7.83230215e-02f, 3.97000939e-01f, 1.17519952e-01f, 8.09667945e-01f, -1.10536706e+00f, -6.48681670e-02f, 4.57528323e-01f, 6.95117533e-01f, 3.33920509e-01f, 3.31343561e-01f,
  1.93630606e-02f, -3.81452709e-01f, -9.21150565e-01f, 1.41384199e-01f, 5.38153127e-02f, 3.46588463e-01f, 4.58243191e-01f, 7.62608647e-01f, 5.09145081e-01f, -5.02556562e-01f,
  5.47877431e-01f, 9.09424543e-01f, 1.17711887e-01f, -8.67226198e-02f, 2.61613935e-01f, -5.83659075e-02f, -2.80492246e-01f, 1.58512354e-01f, 1.10280596e-01f, 2.46839508e-01f,
  9.76112843e-01f, 3.95121455e-01f, -1.27187088e-01f, -8.80263925e-01f, 9.46049035e-01f, 5.05818844e-01f, 8.65893960e-01f, -4.60639238e-01f, -2.33232647e-01f, 1.02653337e+00f
};

// L3_fan_Bp_bar (Shape: 1 x 10)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 10;
const float L3_fan_Bp_bar_data[] = {
  -3.42680424e-01f, -1.25908285e-01f, -4.30792212e-01f, 7.28570074e-02f, 3.71529460e-01f, 4.73829210e-02f, 2.81787626e-02f, 9.45108309e-02f, 2.76356280e-01f, 3.71532440e-01f
};

// L4_linear_W (Shape: 12 x 16)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 16;
const float L4_linear_W_data[] = {
  -1.88844904e-01f, 4.95015025e-01f, -2.37935498e-01f, 3.57992560e-01f, -2.37000272e-01f, -5.52846849e-01f, 1.03938825e-01f, 1.32189259e-01f, 4.89122808e-01f, 3.65710884e-01f,
  -2.94524491e-01f, -5.64500391e-01f, 2.25393727e-01f, 1.42238200e-01f, 7.38251880e-02f, -9.52107906e-01f, 1.34628624e-01f, -3.10409218e-01f, 2.44851084e-03f, -5.25650799e-01f,
  -2.60716498e-01f, 1.51969030e-01f, 9.93058383e-02f, 4.72863972e-01f, -4.74126875e-01f, -4.88269478e-01f, 3.05367470e-01f, 2.07459390e-01f, -1.08343840e+00f, 2.60025740e-01f,
  -5.34705259e-02f, -4.29211140e-01f, 7.95273483e-01f, 1.11558187e+00f, -1.04625598e-02f, 4.36691135e-01f, -8.50196302e-01f, -1.08856320e+00f, -4.46221590e-01f, -3.45461100e-01f,
  -6.20712221e-01f, -3.01764250e-01f, 4.14253175e-01f, 8.98420736e-02f, -7.03957796e-01f, 1.79586247e-01f, -7.68116772e-01f, 5.07713437e-01f, 1.03111684e-01f, -1.81467161e-01f,
  8.40039775e-02f, 3.61881793e-01f, -2.30597720e-01f, 1.44210324e-01f, 4.24299479e-01f, -8.78072679e-01f, 2.02014819e-01f, -3.78229558e-01f, -8.82373035e-01f, -6.38428748e-01f,
  1.64888874e-01f, 1.54542848e-01f, -3.91207516e-01f, 2.57404298e-01f, -3.73441011e-01f, -1.11136520e+00f, -1.35104910e-01f, -3.31949264e-01f, 4.99809206e-01f, 8.51936340e-01f,
  1.74051002e-01f, 1.21465676e-01f, -1.73465237e-02f, 5.37249327e-01f, -2.91778833e-01f, 3.07384878e-01f, 2.86371648e-01f, 2.36022398e-01f, -5.50809264e-01f, -1.52560458e-01f,
  7.67948687e-01f, 8.43653262e-01f, 3.64767581e-01f, -5.07318258e-01f, 9.01357055e-01f, 4.70459670e-01f, -8.92855525e-01f, 5.72247505e-01f, -4.08737779e-01f, 4.33009744e-01f,
  -1.91305235e-01f, -5.89181185e-01f, -2.24381551e-01f, 4.98992324e-01f, 1.34384930e-01f, -2.35722914e-01f, -1.00766027e+00f, -7.01916993e-01f, -4.12826210e-01f, -1.38578013e-01f,
  -6.00890815e-01f, -9.67668951e-01f, -9.84138474e-02f, -6.41804636e-01f, -8.72757435e-01f, -3.66223216e-01f, 1.76984042e-01f, 5.03162980e-01f, 3.98828872e-02f, -1.03669000e+00f,
  3.43069911e-01f, -6.26499485e-03f, 4.67241332e-02f, -5.39213955e-01f, -4.60163690e-02f, 3.06052625e-01f, 4.99578118e-01f, 4.92171317e-01f, 7.37387002e-01f, -4.97582614e-01f,
  2.79320538e-01f, -2.37060443e-01f, 2.60609746e-01f, -2.70284355e-01f, -2.43512869e-01f, -6.10009693e-02f, 3.26276630e-01f, -7.08271414e-02f, -7.42155552e-01f, -4.94052887e-01f,
  -3.05864990e-01f, 4.03067499e-01f, 4.10488546e-01f, 8.92109334e-01f, -3.97951640e-02f, 4.19534206e-01f, 3.33001763e-01f, 2.45420247e-01f, -4.59343717e-02f, 2.43674874e-01f,
  -3.39758068e-01f, 1.98525876e-01f, -5.48142552e-01f, 2.66346246e-01f, 1.19948423e+00f, 9.68803942e-01f, 6.83285713e-01f, 7.53453910e-01f, -2.28413999e-01f, 2.30546877e-01f,
  -7.31087506e-01f, -4.79067534e-01f, -2.19527557e-01f, -1.96403533e-01f, 5.13819873e-01f, 4.24167901e-01f, -7.95879245e-01f, -1.31196725e+00f, 3.98515433e-01f, -1.37010443e+00f,
  8.97801444e-02f, 4.06449974e-01f, 4.02961612e-01f, 6.39319003e-01f, 6.46425128e-01f, -3.82719845e-01f, -5.34392476e-01f, 3.49355131e-01f, -1.05148947e+00f, -4.04829323e-01f,
  -9.28943098e-01f, -8.31405818e-01f, 2.03568950e-01f, 2.80153275e-01f, -1.01195455e+00f, 3.74371409e-01f, 2.22717091e-01f, -4.37159926e-01f, -2.41017237e-01f, -3.33098769e-01f,
  -2.66970657e-02f, 2.41360560e-01f, -6.03441754e-03f, -4.44126517e-01f, -8.53695199e-02f, -7.13772699e-02f, -7.94876754e-01f, 4.14335340e-01f, 8.29300508e-02f, -3.53870541e-01f,
  -2.17826873e-01f, 6.06921136e-01f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  -2.60958582e-01f, 2.42947489e-02f, 8.52793038e-01f, -7.76829779e-01f, 3.54725778e-01f, 3.58864576e-01f, 7.95256570e-02f, 9.17815268e-02f, -7.43017912e-01f, -1.37929291e-01f,
  2.63190508e-01f, -2.43309766e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 3, 10
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 3, 10
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        16, 3, 10
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        16, 3, 10
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        16, 12
    );
    }
    