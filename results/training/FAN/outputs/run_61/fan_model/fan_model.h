/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 3 x 120)
const int L0_fan_Wp_rows = 3;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -1.49062350e-01f, 4.46748018e-01f, -1.65411085e-01f, 1.05562955e-01f, 6.47118762e-02f, -3.54819447e-02f, 7.71124512e-02f, 6.07730113e-02f, -6.75645769e-02f, 3.32802445e-01f,
  1.10729272e-02f, 1.08150482e-01f, -3.99377616e-03f, 2.62010008e-01f, -1.48186445e-01f, -1.03784546e-01f, 2.36829609e-01f, 2.33360618e-01f, -5.53646386e-02f, 2.02374175e-01f,
  -1.88407242e-01f, 1.80750385e-01f, -5.97822256e-02f, 7.79340267e-02f, 1.93419605e-01f, -8.61387923e-02f, 1.56611338e-01f, -4.53610606e-02f, 1.63610578e-01f, 1.16251856e-01f,
  -1.55155420e-01f, -2.00870961e-01f, -7.79574886e-02f, -4.66042198e-02f, 1.26613989e-01f, -6.01939969e-02f, 7.32503608e-02f, 1.03515815e-02f, -1.44576579e-01f, 1.77799985e-02f,
  6.45426586e-02f, -9.84160006e-02f, -8.37225765e-02f, -1.38276845e-01f, -1.48850922e-02f, -6.14783578e-02f, -5.58229499e-02f, 3.92940603e-02f, 2.54200865e-03f, -3.49724628e-02f,
  -3.69639620e-02f, 4.33793329e-02f, -4.95286584e-02f, 5.13407663e-02f, -6.37597218e-02f, 1.14220437e-02f, 4.49988917e-02f, 8.78488719e-02f, -1.60345845e-02f, 1.08871544e-02f,
  -9.09564570e-02f, -9.96763408e-02f, -3.77066620e-02f, 2.52373647e-02f, 5.31207025e-02f, -5.71132787e-02f, -4.97500040e-02f, 6.97412714e-02f, 8.00941437e-02f, -3.29218805e-02f,
  1.56904776e-02f, 1.04891956e-01f, -2.60727368e-02f, 1.30190207e-02f, 9.67406258e-02f, 1.93861146e-02f, -3.23256440e-02f, 1.24082170e-01f, 6.69689253e-02f, 8.31531808e-02f,
  -2.20519211e-02f, -5.94234355e-02f, 3.28691155e-02f, -5.44652306e-02f, -5.10764979e-02f, -9.77410562e-03f, -3.91569771e-02f, -2.06546467e-02f, 2.38561220e-02f, 4.43516076e-02f,
  5.53496964e-02f, 1.45025149e-01f, -5.71083464e-02f, -9.68699604e-02f, 9.19721499e-02f, 2.73653138e-02f, -9.50945690e-02f, 5.73238023e-02f, 3.29225138e-02f, 3.02332584e-02f,
  -5.15862927e-02f, -1.10888770e-02f, -1.31076172e-01f, 3.58136334e-02f, 8.93530399e-02f, -1.60667196e-01f, -1.96796609e-03f, 5.83820380e-02f, -2.49437336e-02f, 1.75034761e-01f,
  7.66653493e-02f, -5.09384684e-02f, 5.03077405e-03f, 4.08870094e-02f, 8.06225017e-02f, 6.84461892e-02f, -4.76828171e-03f, 7.87791684e-02f, 2.86589786e-02f, 9.87138301e-02f,
  1.08153284e-01f, -4.63517420e-02f, 1.74961373e-01f, 1.01897232e-02f, 1.43271172e-02f, 7.21980631e-02f, 8.88465531e-03f, -3.90133262e-03f, 6.48589060e-02f, -1.81014419e-01f,
  -8.14795569e-02f, 2.59044051e-01f, -2.93974340e-01f, 8.63474086e-02f, 3.78934979e-01f, -5.58448471e-02f, -9.09231454e-02f, -3.30611765e-02f, 1.61866218e-01f, -8.20796415e-02f,
  8.94360617e-02f, -1.79530486e-01f, 2.22550660e-01f, -3.69818583e-02f, -2.64136540e-03f, 2.01214805e-01f, -2.95393299e-02f, 1.35515139e-01f, 2.62027439e-02f, 1.11770682e-01f,
  -1.09526813e-02f, -8.84190872e-02f, 1.00079447e-01f, 1.23587012e-01f, 9.84096155e-03f, -1.23570353e-01f, 3.37163433e-02f, 1.35704488e-01f, 3.67262103e-02f, 9.60122123e-02f,
  2.36407239e-02f, 1.13212936e-01f, -1.44079458e-02f, 1.00512445e-01f, -6.07053004e-02f, 1.23645343e-01f, 7.32777715e-02f, 5.33734001e-02f, 1.20573997e-01f, 6.05184305e-03f,
  4.70755771e-02f, 1.38774693e-01f, -4.71637808e-02f, -2.87948642e-02f, 5.45134656e-02f, 7.80256242e-02f, 4.00731750e-02f, -4.54247333e-02f, 2.60129794e-02f, 4.21021953e-02f,
  -7.05713183e-02f, 7.72568360e-02f, 7.05177188e-02f, 6.83725253e-02f, -4.21051942e-02f, 7.17449412e-02f, 6.77333176e-02f, 3.98734286e-02f, 1.15542933e-01f, -3.35039757e-02f,
  4.17595543e-03f, 7.63230957e-03f, 5.22322655e-02f, 1.24866106e-01f, 2.16891691e-02f, 1.16249673e-01f, 1.88553169e-01f, -4.69921865e-02f, -4.72196564e-02f, 1.31682307e-01f,
  1.55126587e-01f, 9.82777774e-02f, 3.24474275e-02f, -1.24032393e-01f, 5.75880781e-02f, 6.23240955e-02f, 7.27569908e-02f, 7.80255646e-02f, 2.93039270e-02f, -1.40647292e-01f,
  -1.82714716e-01f, -3.21039498e-01f, 4.97949682e-02f, 5.37865236e-02f, -8.04847199e-03f, -2.91283485e-02f, 9.69353616e-02f, 4.08363678e-02f, -6.56581521e-02f, 2.06130221e-02f,
  1.77488755e-02f, 7.29093403e-02f, -3.47308069e-02f, 4.72866073e-02f, 1.66986529e-02f, 1.49528384e-02f, 3.47197317e-02f, 8.14254880e-02f, 4.43206877e-02f, -3.38100418e-02f,
  4.12937813e-02f, 1.70675237e-02f, -4.01492827e-02f, 3.80138494e-02f, -8.19551852e-03f, 2.10918691e-02f, -4.71657738e-02f, -8.75491723e-02f, -6.27271906e-02f, 1.24928966e-01f,
  -2.68345624e-01f, -9.84117687e-02f, -6.72378764e-02f, -3.40871841e-01f, 1.73350632e-01f, -2.35649541e-01f, -2.02720389e-01f, 1.46710279e-03f, -2.57924736e-01f, -8.01141113e-02f,
  1.02556543e-02f, -1.34968609e-01f, 1.91974148e-01f, -2.78983355e-01f, 2.43728142e-02f, 2.86063123e-02f, -3.39531153e-01f, -4.18882370e-02f, 4.93461359e-03f, 4.37321253e-02f,
  -8.37781951e-02f, -8.41035992e-02f, -1.08409181e-01f, 6.53595626e-02f, -7.27185840e-03f, -5.41334711e-02f, 1.06079869e-01f, 1.87767193e-01f, -6.43091798e-02f, -7.63479546e-02f,
  4.60313559e-02f, -5.41417636e-02f, -1.11185826e-01f, -1.17437048e-02f, -1.24511402e-02f, -2.96256375e-02f, 6.15456700e-02f, -6.27216510e-03f, 1.42723382e-01f, -9.98292118e-02f,
  7.43359048e-03f, 3.85926850e-02f, -1.40644744e-01f, -9.65712890e-02f, 1.01195211e-02f, -2.96339616e-02f, 1.31083615e-02f, -6.87151328e-02f, -4.43515368e-02f, -9.99467820e-02f,
  -1.15005925e-01f, -3.90739851e-02f, -3.03460918e-02f, -4.20283228e-02f, 2.13679876e-02f, 6.74455753e-03f, -8.19782391e-02f, -4.58288938e-02f, -7.73775429e-02f, -5.58748320e-02f,
  -9.68422070e-02f, 1.68235246e-02f, -3.13317254e-02f, -2.22706553e-02f, 2.64517218e-02f, -1.84819158e-02f, 4.07649763e-02f, -1.12638529e-02f, 2.73836032e-03f, 1.12875082e-01f,
  1.11017674e-01f, 5.65472208e-02f, 1.11844473e-01f, -7.87494704e-02f, 7.79523980e-03f, -7.35765249e-02f, -1.73055381e-02f, 5.78234680e-02f, -1.61900103e-01f, 1.51776761e-01f,
  9.87177435e-03f, 1.04066044e-01f, 9.44632739e-02f, 2.20064521e-02f, 1.40348906e-02f, 1.19023426e-02f, -1.19977735e-01f, -7.88079947e-02f, -5.54509573e-02f, -3.40928622e-02f,
  2.39831880e-01f, 1.74340472e-01f, 2.84994654e-02f, 2.96372101e-02f, 6.34863004e-02f, -4.16920930e-02f, -6.13056719e-02f, -2.06225514e-02f, 6.85171857e-02f, -6.26472160e-02f,
  1.42512188e-04f, 9.85475183e-02f, 4.05423865e-02f, -1.65449679e-02f, -2.72332635e-02f, -3.91157605e-02f, 9.96030048e-02f, -2.30494346e-02f, -3.40797305e-02f, -9.47332941e-03f,
  1.55877098e-02f, 2.31827796e-02f, 1.04916744e-01f, -9.32456627e-02f, 1.12160277e-02f, 1.82062965e-02f, -7.02308640e-02f, -1.08548976e-01f, -4.19072770e-02f, 7.37619773e-03f
};

// L0_fan_Wp_bar (Shape: 26 x 120)
const int L0_fan_Wp_bar_rows = 26;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -7.58021355e-01f, 1.67009652e-01f, -1.35515764e-01f, -9.61523056e-02f, -6.46597147e-02f, 4.33695674e-01f, 2.48990580e-01f, -2.38033682e-02f, -2.31669769e-01f, 7.15245083e-02f,
  1.31047532e-01f, -4.49019521e-02f, 1.82964459e-01f, 1.90920517e-01f, 1.00354426e-01f, 3.67381603e-01f, 1.92389131e-01f, -5.32112345e-02f, -3.33283134e-02f, -2.82325029e-01f,
  -1.13389127e-01f, 1.36970446e-01f, 9.07465219e-02f, -1.36835009e-01f, 3.52885723e-02f, -7.40318224e-02f, -5.50792851e-02f, -9.54674631e-02f, 1.19151808e-01f, 1.37591481e-01f,
  -6.41144905e-03f, -3.35733116e-01f, -6.55038208e-02f, -1.21836543e-01f, 6.91776816e-03f, -6.35046586e-02f, -1.63999721e-01f, 1.71887260e-02f, -6.50078384e-03f, -1.49168104e-01f,
  6.39369115e-02f, -7.68771991e-02f, -9.91313756e-02f, -2.82855462e-02f, -2.63447221e-02f, -2.10050195e-02f, 1.61302835e-01f, 2.03578919e-01f, 1.08170152e-01f, 1.31690368e-01f,
  3.93671580e-02f, 1.53866738e-01f, 7.70609528e-02f, -9.68261436e-02f, 2.65224516e-01f, 7.56863803e-02f, 6.06260374e-02f, 3.97387221e-02f, 1.17600843e-01f, -3.24094780e-02f,
  -7.26032630e-02f, -9.80868712e-02f, 6.00998811e-02f, 5.43899946e-02f, 8.90937373e-02f, 1.19030159e-02f, 1.25352830e-01f, 8.79683420e-02f, 9.32772234e-02f, 1.90747172e-01f,
  7.41169183e-03f, 2.97622494e-02f, -1.12810425e-01f, 1.87402219e-02f, 8.06460995e-03f, 5.02989143e-02f, -2.38196090e-01f, 1.79345086e-02f, 1.12441339e-01f, 4.29319106e-02f,
  -8.38484839e-02f, -1.76083550e-01f, 2.22655684e-02f, 3.63027863e-02f, -8.52845684e-02f, 4.42726398e-03f, -1.27520589e-02f, -4.71631363e-02f, -3.67858335e-02f, -6.65314496e-02f,
  -7.07079917e-02f, -3.51852536e-01f, 6.00157827e-02f, 1.46484468e-02f, -3.23198512e-02f, -4.83927764e-02f, -6.07739165e-02f, 6.77272901e-02f, 4.28325161e-02f, -7.75878802e-02f,
  -4.08699214e-02f, -2.14395188e-02f, 8.53120442e-03f, 5.07007213e-03f, 3.71568240e-02f, -1.10157682e-02f, 4.73029613e-02f, -4.24044393e-02f, 4.77380753e-02f, -9.56002995e-03f,
  8.62748325e-02f, 8.58476534e-02f, 1.97089985e-02f, -5.19135455e-03f, -9.61832181e-02f, 2.30550885e-01f, -1.02137379e-01f, -5.05033322e-03f, 5.56645207e-02f, 2.76156962e-02f,
  -6.59796819e-02f, -6.84004605e-01f, 6.62485808e-02f, -3.74161303e-02f, 3.97939742e-01f, 1.82170287e-01f, 2.90430933e-01f, -2.69726932e-01f, -2.76704937e-01f, -4.80847359e-01f,
  8.14233944e-02f, 8.13488513e-02f, -1.01716876e-01f, -1.57107353e-01f, 3.81644458e-01f, -8.61085504e-02f, -4.42711487e-02f, 6.45896494e-02f, 5.49121685e-02f, 3.55824456e-02f,
  2.26791829e-01f, 1.90810952e-02f, 2.33037621e-01f, -9.27850902e-02f, 7.73923844e-02f, 4.71488088e-02f, 8.19632784e-02f, 2.19287157e-01f, 1.09409606e-02f, 1.11903444e-01f,
  6.63421601e-02f, -1.91202506e-01f, 2.31110025e-03f, -6.13629706e-02f, 4.18859087e-02f, -1.70684922e-02f, -2.94279605e-02f, 9.70721319e-02f, 1.19622633e-01f, 5.51234558e-02f,
  5.39801717e-02f, 4.84357104e-02f, -5.96125908e-02f, 2.58271426e-01f, -6.06027432e-03f, -5.75159006e-02f, 1.02347627e-01f, 6.28902689e-02f, -1.21541478e-01f, 2.12927330e-02f,
  3.07707377e-02f, -6.12902902e-02f, -4.02243361e-02f, -7.33904913e-02f, 1.02585219e-01f, 6.86551630e-02f, 5.64293154e-02f, 1.01007015e-01f, -3.48659046e-02f, -6.30002245e-02f,
  -5.97892217e-02f, 7.35841226e-03f, -7.31509849e-02f, 1.65718943e-02f, -5.18435389e-02f, -9.61517096e-02f, 1.03845149e-01f, 1.11178257e-01f, 1.28797591e-01f, -4.92467657e-02f,
  -7.81272873e-02f, -9.09634773e-03f, -2.96501238e-02f, 6.74125254e-02f, 6.94820732e-02f, 3.60024133e-05f, 2.17282489e-01f, 1.06589563e-01f, 3.28197377e-03f, -1.58714950e-02f,
  4.15571034e-02f, 6.70617595e-02f, 6.14343137e-02f, 1.59597337e-01f, -6.75773770e-02f, 3.96461263e-02f, -1.34378701e-01f, -5.52083999e-02f, 9.90137383e-02f, 5.75322881e-02f,
  -6.76771775e-02f, -4.86882567e-01f, 5.97186759e-02f, 8.33269134e-02f, -1.82198826e-02f, 4.25554290e-02f, 1.02157235e-01f, -8.90138969e-02f, -7.53806829e-02f, -3.78371030e-02f,
  1.43170319e-02f, 1.66011721e-01f, -8.74924213e-02f, 5.83272800e-02f, -2.11939402e-02f, -1.17576877e-02f, 7.90607706e-02f, -5.02448808e-03f, 4.27579470e-02f, -1.38354883e-01f,
  -8.63340050e-02f, 9.90688875e-02f, -1.14980571e-01f, 1.36185708e-02f, -2.22794432e-02f, -5.84199689e-02f, -3.86397503e-02f, -3.37345898e-02f, 1.43036902e-01f, 1.00511260e-01f,
  4.01521832e-01f, -6.42960891e-02f, 1.09934554e-01f, 5.82845986e-01f, 2.00811252e-01f, -2.39105910e-01f, 1.69807877e-02f, 3.50034177e-01f, 4.19542372e-01f, -3.22322607e-01f,
  -7.10467398e-02f, -1.72226489e-01f, -4.76566166e-01f, 1.21950768e-01f, -8.39966312e-02f, -4.71007466e-01f, 2.69189477e-01f, -1.25087677e-02f, 1.61504164e-01f, 1.49171278e-01f,
  3.70482057e-01f, 4.00775000e-02f, 1.30051360e-01f, 1.70267776e-01f, 2.96122044e-01f, 2.78796136e-01f, 1.07298255e-01f, -1.69742271e-01f, 1.14987262e-01f, -8.00838023e-02f,
  -5.21589592e-02f, 8.43021646e-02f, 1.69777885e-01f, -7.22399727e-02f, 3.97959240e-02f, -5.55692911e-02f, -3.57299438e-03f, -2.42470950e-01f, 1.63805094e-02f, 6.79709911e-02f,
  -1.57763913e-01f, -1.86886583e-02f, 1.03944667e-01f, -1.88967332e-01f, 2.43815109e-02f, 1.41179115e-01f, 9.01584625e-02f, 1.09971665e-01f, 1.20227337e-01f, 1.13911696e-01f,
  1.37144521e-01f, -3.93899567e-02f, 1.15423746e-01f, -5.37610911e-02f, 1.68015599e-01f, 1.31081849e-01f, 3.32230553e-02f, -4.10218202e-02f, 1.21276610e-01f, 1.30922467e-01f,
  -2.08051115e-01f, 3.48283388e-02f, 4.65036817e-02f, 8.56595784e-02f, 6.73412830e-02f, 6.70261011e-02f, -1.51967434e-02f, -5.36901057e-02f, 3.23393010e-02f, -3.76203358e-02f,
  2.08403468e-01f, 5.16311750e-02f, 1.39502510e-01f, 1.41877323e-01f, -8.06995481e-02f, 1.41744211e-01f, -7.93028772e-02f, -4.57199216e-02f, 1.95660904e-01f, 1.13602847e-01f,
  -5.61443456e-02f, -6.40714541e-02f, -4.44537178e-02f, -1.43073779e-02f, 1.58318644e-03f, -5.91602884e-02f, 7.63881654e-02f, -1.31688774e-01f, 6.56592175e-02f, -2.33990904e-02f,
  -2.24809736e-01f, -2.27033108e-01f, -1.03680883e-03f, -9.81463119e-03f, -1.71025038e-01f, -3.99383083e-02f, -6.20590858e-02f, 2.12244168e-02f, -8.34696665e-02f, 9.69781056e-02f,
  -1.35591405e-03f, 3.30666192e-02f, -1.29103690e-01f, -9.70799662e-03f, -1.74173284e-02f, -2.86933798e-02f, -4.50623818e-02f, 2.16381848e-02f, -4.57996018e-02f, -3.24044749e-03f,
  -8.47580750e-03f, -9.96019840e-02f, 1.56122101e-02f, 9.21605378e-02f, -4.00195941e-02f, -1.76884942e-02f, -7.79892690e-03f, 4.12132405e-02f, -1.12214684e-01f, -6.54543564e-02f,
  -5.55784702e-01f, 6.32729709e-01f, 4.11239445e-01f, -2.33149737e-01f, -8.95500034e-02f, -2.32169047e-01f, -1.38225764e-01f, 1.47853881e-01f, 3.01915389e-02f, 2.44909242e-01f,
  4.00970085e-03f, 4.22102362e-01f, -5.81312440e-02f, 2.84948260e-01f, -3.91198099e-01f, -1.18274927e-01f, -2.43866175e-01f, 6.72021834e-03f, -4.90880795e-02f, 6.53303647e-03f,
  -9.18700248e-02f, -2.36444741e-01f, 3.92819829e-02f, -1.41295716e-02f, 9.74959657e-02f, 6.52383193e-02f, -4.12980437e-01f, 6.25034794e-02f, 5.97626530e-02f, 1.29927352e-01f,
  -8.03491175e-02f, 5.00851013e-02f, 2.21702948e-01f, 1.17864557e-01f, -9.39507633e-02f, -9.35306624e-02f, -2.31510916e-04f, 2.26259604e-02f, -8.05342123e-02f, 1.08024694e-01f,
  7.92211387e-04f, 2.84006093e-02f, -1.34094477e-01f, 9.97729301e-02f, -1.91613678e-02f, 6.79405853e-02f, 4.47526667e-03f, 1.38924951e-02f, 1.51018709e-01f, 1.82640240e-01f,
  8.46285224e-02f, 1.14226088e-01f, 5.17446399e-02f, 5.91741502e-02f, 5.81472218e-02f, -9.69867110e-02f, 5.76889589e-02f, 6.57969117e-02f, 6.49124011e-02f, 7.67067522e-02f,
  7.11192787e-02f, -1.62081450e-01f, -7.09382817e-02f, -3.27530615e-02f, 3.38670239e-02f, 1.40220821e-01f, -8.08262825e-03f, -3.42070349e-02f, -1.23058148e-01f, -1.01927444e-01f,
  2.61256881e-02f, 1.60538778e-01f, -3.33871879e-02f, -1.56222850e-01f, -1.04358621e-01f, -1.59278866e-02f, 1.66185740e-02f, 9.99467596e-02f, -4.32927012e-02f, -4.35597077e-02f,
  2.08645854e-02f, -3.95327583e-02f, 1.18739739e-01f, -2.91964784e-02f, -9.08503309e-03f, -2.63785012e-02f, -2.12803949e-03f, 1.17434897e-01f, 5.63779473e-02f, -2.13171929e-01f,
  -5.46422601e-01f, -2.83770472e-01f, -1.20398082e-01f, 7.31211826e-02f, -8.67414922e-02f, -6.21624403e-02f, -7.85786733e-02f, -2.87452806e-02f, -2.15494469e-01f, 2.39388570e-02f,
  -6.65801391e-02f, -6.27477318e-02f, 3.22504155e-02f, -1.07277915e-01f, -2.47309189e-02f, -1.49034262e-01f, -2.51295447e-01f, -8.20234418e-02f, -1.72909394e-01f, -6.94847032e-02f,
  -6.06712140e-02f, -4.34653312e-02f, -1.08483518e-02f, -4.64322269e-02f, -6.77898154e-02f, -1.08518191e-01f, -2.91073788e-02f, 1.73535734e-01f, -1.14282802e-01f, 1.76682383e-01f,
  -6.34386659e-01f, 2.11118281e-01f, 1.69452757e-01f, -6.15971684e-01f, 3.96738201e-01f, 1.98237047e-01f, -2.14725152e-01f, 1.97734728e-01f, -2.12910250e-01f, 4.32585776e-02f,
  -1.33672636e-02f, -4.24184859e-01f, 1.26205400e-01f, -4.11566228e-01f, -4.11313087e-01f, -2.34535128e-01f, -4.43599284e-01f, -3.01868886e-01f, 5.67952879e-02f, -7.62296543e-02f,
  -1.02912098e-01f, -1.45020008e-01f, -4.56560403e-02f, 5.02968788e-01f, 1.57320917e-01f, 2.52244949e-01f, -6.26360625e-02f, 3.31960648e-01f, -7.39501640e-02f, 3.08755785e-02f,
  2.61041988e-03f, -8.65623355e-02f, 1.62163779e-01f, 1.50781378e-01f, 6.51653111e-02f, -9.72968191e-02f, -1.21878579e-01f, 7.76221380e-02f, -7.26488279e-03f, -9.93788708e-03f,
  -8.96787867e-02f, -3.15175653e-02f, -1.94187894e-01f, 1.44889295e-01f, 1.22313425e-01f, 4.12327461e-02f, -6.63650334e-02f, -2.66400278e-02f, 5.12300134e-02f, -2.41468232e-02f,
  -1.90984011e-02f, 9.36835483e-02f, 2.47286670e-02f, -1.01026312e-01f, 3.21864896e-02f, 6.55442551e-02f, -3.75211053e-02f, 2.47961655e-02f, 1.77428164e-02f, -1.32772401e-01f,
  -3.54057699e-02f, -1.51618235e-02f, 1.13073036e-01f, 9.88425538e-02f, -5.06725572e-02f, 6.03219122e-02f, -5.70268417e-03f, -9.20695737e-02f, 5.09309508e-02f, 8.29161331e-02f,
  -8.26630294e-02f, -3.86497602e-02f, 3.07967030e-02f, 1.10144749e-01f, -3.29209864e-02f, 6.39211535e-02f, 2.89701507e-03f, 8.70681740e-03f, -9.73850340e-02f, 4.47573364e-02f,
  3.71982045e-02f, -4.05856520e-02f, -7.14547932e-02f, -8.33975337e-03f, 3.28327864e-02f, 1.11859657e-01f, 5.85050806e-02f, -1.87569614e-02f, -4.33462970e-02f, -5.06924018e-02f,
  -2.03374587e-02f, 9.31551028e-03f, 8.61637592e-02f, 4.54212762e-02f, -6.89255819e-02f, -1.65383108e-02f, 8.84828344e-02f, 1.12321945e-02f, -1.04039773e-01f, -2.14441177e-02f,
  -4.44108667e-03f, -7.81377777e-02f, 1.53845837e-02f, 5.74010424e-02f, -6.34894669e-02f, 1.42080083e-01f, -9.82566923e-02f, -7.00085685e-02f, -8.42011347e-03f, 6.40618131e-02f,
  -8.56317356e-02f, 7.58597329e-02f, -9.12813544e-02f, 7.07695931e-02f, -9.11353230e-02f, -5.24669401e-02f, 1.88199524e-02f, -7.07321707e-03f, -1.81614272e-02f, 1.09642539e-02f,
  5.07169545e-01f, -3.70642185e-01f, 4.12876718e-02f, 1.94406912e-01f, -7.12919906e-02f, 1.92734376e-01f, 5.36715686e-01f, -4.00692597e-02f, 2.67338574e-01f, -1.77555159e-02f,
  6.03995845e-03f, 1.41125202e-01f, 2.66062230e-01f, -6.97635487e-02f, 4.77345288e-01f, 2.18660668e-01f, 1.07400611e-01f, 6.94789737e-02f, -3.49307097e-02f, -6.59833625e-02f,
  1.17146172e-01f, -7.04219565e-02f, 1.58988938e-01f, -3.80690932e-01f, -1.14532448e-01f, -2.28391021e-01f, -1.24283232e-01f, -4.43896726e-02f, -2.40401387e-01f, -7.15697259e-02f,
  -2.20215812e-01f, -1.69305548e-01f, -1.34115428e-01f, -1.66174814e-01f, -1.76501974e-01f, -6.04937859e-02f, 9.83053595e-02f, 1.37021467e-01f, -1.87882349e-01f, -5.13375737e-02f,
  9.41904485e-02f, 1.64828300e-01f, -7.50293806e-02f, 5.84582277e-02f, 1.65341739e-02f, 1.18465781e-01f, -1.03536688e-01f, -1.08935833e-01f, 8.25294629e-02f, 4.16763984e-02f,
  9.72404107e-02f, -2.76953448e-02f, -8.40679090e-03f, -1.69019401e-01f, -1.97840303e-01f, 9.45153355e-04f, 2.19576880e-02f, -3.44180800e-02f, -9.87463892e-02f, -1.56719275e-02f,
  7.68921245e-03f, -4.36741486e-02f, 1.02141418e-01f, 8.26235563e-02f, 9.41291004e-02f, 4.99261096e-02f, -5.61707504e-02f, -2.03898270e-02f, -1.23533253e-02f, 1.06462888e-01f,
  1.35779426e-01f, -9.65547711e-02f, -3.28060612e-02f, 5.21413125e-02f, -9.98874530e-02f, 6.87392130e-02f, 1.24010928e-02f, -1.23709366e-01f, -7.20578656e-02f, 4.65564616e-02f,
  1.29851818e-01f, 8.02582279e-02f, -1.01747997e-01f, -1.53578473e-02f, -4.46658544e-02f, -9.21216793e-03f, -9.09213722e-02f, 7.58045986e-02f, 3.81612852e-02f, 1.39925972e-01f,
  -2.59132802e-01f, -3.78240019e-01f, 8.54996615e-04f, -4.71910834e-02f, -1.58216968e-01f, -4.87122200e-02f, -3.72588672e-02f, -1.51962209e-02f, -8.86753500e-02f, 1.12747245e-01f,
  -8.24328959e-02f, -9.00119767e-02f, -1.08262606e-01f, -1.04780439e-02f, -1.13049448e-01f, 8.62383917e-02f, -8.47406760e-02f, -1.47730461e-03f, 1.85151808e-02f, -4.01384011e-02f,
  -4.58843224e-02f, 2.42015608e-02f, -2.29639113e-02f, -1.75833151e-01f, -1.66074097e-01f, 3.76532711e-02f, -9.66482833e-02f, 7.65967518e-02f, -6.41840845e-02f, -1.10732034e-01f,
  -3.81049335e-01f, 3.42562407e-01f, -2.45971993e-01f, 1.01122364e-01f, -1.57014281e-01f, 4.99597579e-01f, 3.07449818e-01f, 8.45734924e-02f, -6.20690063e-02f, 4.04588878e-01f,
  2.46835634e-01f, 1.39749551e-03f, 1.49236932e-01f, 4.25963938e-01f, -3.93453129e-02f, 4.68420476e-01f, 2.59536028e-01f, 2.48808563e-01f, 8.36534277e-02f, -3.05778105e-02f,
  -1.19313888e-01f, 2.59751499e-01f, 1.97367534e-01f, -6.20031683e-03f, -2.20967028e-02f, -2.96576232e-01f, 8.29757133e-04f, -1.92170069e-01f, 2.38574967e-01f, -5.85312163e-03f,
  2.42395848e-01f, 7.98239410e-02f, -6.88579232e-02f, 5.18142544e-02f, -6.35901280e-03f, -4.62714955e-02f, 5.93019510e-03f, -1.21370412e-01f, -8.55099559e-02f, 3.44801471e-02f,
  -1.20703084e-02f, -8.26513469e-02f, -3.55055369e-02f, -1.29803777e-01f, -2.34288394e-01f, -7.21817389e-02f, 2.77104657e-02f, 9.80835482e-02f, 2.18755230e-02f, 2.27642469e-02f,
  7.07941726e-02f, -1.64241884e-02f, 4.41147648e-02f, 1.50977988e-02f, -7.62290880e-02f, -5.60627431e-02f, 1.49437085e-01f, -5.33466637e-02f, 5.02055287e-02f, 1.04032375e-01f,
  -1.13389008e-01f, 7.33213350e-02f, 1.89344175e-02f, 1.11669578e-01f, -3.09562385e-02f, 7.36846402e-02f, 6.63407370e-02f, 2.36314721e-02f, -1.72622725e-01f, 1.40970126e-01f,
  -2.43579899e-03f, 2.08348129e-02f, 1.36534199e-01f, 6.58977479e-02f, 9.28534344e-02f, 3.77748497e-02f, -5.08741057e-03f, 1.40162095e-01f, 4.27372456e-02f, 5.00120111e-02f,
  6.67463094e-02f, -4.79485728e-02f, 3.30325142e-02f, 6.45055398e-02f, 9.43508521e-02f, -2.49830782e-01f, 7.25217238e-02f, 1.37155131e-01f, 8.38193446e-02f, 5.89714088e-02f,
  2.15554386e-01f, 1.54740959e-01f, 8.23931247e-02f, 5.73309436e-02f, -4.19745408e-03f, -2.75135841e-02f, -2.26862151e-02f, -5.87458238e-02f, 3.17767379e-03f, 2.81607918e-03f,
  -1.95198264e-02f, 6.76199868e-02f, -2.68005840e-02f, -1.12769812e-01f, -8.45586956e-02f, 1.25474393e-01f, 2.33897995e-02f, -9.37441271e-03f, -4.72093858e-02f, 5.35420626e-02f,
  1.75388250e-02f, -1.43147781e-02f, -3.13105285e-02f, -2.19925144e-03f, 3.52570810e-03f, -5.24291256e-03f, -6.40154555e-02f, -2.32065767e-02f, -8.54323059e-02f, 4.19206619e-02f,
  1.60739914e-01f, -1.48897395e-01f, -3.24194819e-01f, -1.25431895e-01f, 1.46158665e-01f, 3.90356034e-01f, -8.03021342e-02f, 1.61303077e-02f, -3.16046506e-01f, 1.19980797e-01f,
  2.58709770e-03f, -1.44472703e-01f, -2.69629598e-01f, 8.63554254e-02f, 2.43235771e-02f, -2.97239512e-01f, 1.94785923e-01f, 1.73139703e-02f, -1.90449148e-01f, 1.01670772e-01f,
  -1.49618253e-01f, 4.37109172e-01f, -3.12223613e-01f, 4.17710751e-01f, 2.11820692e-01f, -6.98807016e-02f, 3.35730731e-01f, -2.80676913e-02f, 1.71625227e-01f, 1.97674632e-01f,
  9.71951801e-03f, 8.45577475e-03f, -6.70886263e-02f, -8.30754861e-02f, 1.80049650e-02f, 2.10081577e-01f, 1.27866775e-01f, 4.27959226e-02f, -9.16413590e-02f, -8.25085863e-03f,
  1.26905814e-01f, 5.18263653e-02f, -1.57451183e-02f, 3.83180380e-02f, 1.05197810e-01f, 1.45316273e-02f, -1.79310575e-01f, 7.40001649e-02f, -1.74779788e-01f, -4.22894582e-02f,
  -1.13234863e-01f, 2.94867828e-02f, 1.54942527e-01f, -3.16258557e-02f, -1.24086060e-01f, 7.81480409e-03f, 1.24613820e-02f, 4.71450724e-02f, 1.73254848e-01f, 8.63369107e-02f,
  1.18085407e-01f, 2.39733294e-01f, 4.67852429e-02f, -3.04338858e-02f, -6.71253353e-02f, 2.46431082e-02f, 4.83907387e-02f, -1.20870456e-01f, -6.37954380e-03f, -9.66740586e-03f,
  2.12776568e-02f, -9.00464505e-02f, 3.10794301e-02f, 7.16603622e-02f, 1.04099192e-01f, -1.15443692e-02f, 3.64498496e-02f, 4.19867598e-02f, -8.05866253e-03f, -1.27977744e-01f,
  6.28536493e-02f, 4.66680564e-02f, -1.34915844e-01f, 4.73195640e-03f, 4.16850625e-03f, -6.65026009e-02f, 1.94488212e-01f, 9.27871615e-02f, -8.31533447e-02f, 8.30161944e-02f,
  1.85505096e-02f, -4.19691838e-02f, -1.66451022e-01f, -8.34127441e-02f, -1.94809362e-02f, 1.65752262e-01f, 5.93714155e-02f, -4.08951938e-02f, -7.32988641e-02f, 1.72079563e-01f,
  2.02722698e-01f, -4.32016626e-02f, 1.24259748e-01f, -2.56372057e-03f, -1.76287889e-02f, 1.07211635e-01f, -8.02708906e-04f, 3.37319970e-02f, 6.66328073e-02f, -7.40988599e-03f,
  1.21888250e-01f, -1.07674645e-02f, 9.27571803e-02f, -2.08166260e-02f, -1.40024908e-02f, 1.01472087e-01f, 3.45277302e-02f, 1.17240533e-01f, 9.12996754e-02f, -8.10290724e-02f,
  -4.09452803e-02f, 2.32995436e-01f, 3.28474104e-01f, 3.51626366e-01f, -2.73440123e-01f, -4.48514551e-01f, -4.74018812e-01f, 3.19734156e-01f, 2.94471197e-02f, -4.06144075e-02f,
  -2.23750658e-02f, -3.49001901e-04f, 6.85044527e-02f, 2.32774038e-02f, 3.77715260e-01f, -6.95394427e-02f, 2.67547160e-01f, -8.28097686e-02f, 1.24787748e-01f, 2.28857204e-01f,
  3.29640150e-01f, 1.89832166e-01f, 3.99976164e-01f, 2.04203784e-01f, 1.60524502e-01f, 3.07064712e-01f, 3.95400017e-01f, -4.64588776e-02f, 2.18581066e-01f, -8.47941488e-02f,
  -8.61493424e-02f, 7.66980574e-02f, -2.14292184e-02f, -1.03101499e-01f, 1.31321669e-01f, -1.84080005e-01f, 3.50066684e-02f, -4.86207716e-02f, -1.33954555e-01f, -5.86891025e-02f,
  -1.97296776e-02f, -1.46087073e-02f, 1.36811614e-01f, 9.08907223e-03f, -7.06321448e-02f, 9.67543349e-02f, 1.26839355e-01f, -5.95965497e-02f, -5.87269627e-02f, 4.53637764e-02f,
  -2.03152816e-03f, 8.35688040e-03f, -4.74542864e-02f, 3.92859988e-02f, 3.97612751e-02f, -8.09861794e-02f, 2.47343127e-02f, -2.61059962e-02f, 2.48566805e-03f, 1.73646566e-02f,
  4.01375592e-02f, -1.52028948e-01f, -7.58551136e-02f, -3.26075545e-03f, -5.22392280e-02f, -7.30888322e-02f, -2.20049955e-02f, -2.13239063e-02f, -3.62018123e-02f, 4.38937545e-02f,
  1.27002504e-02f, 7.94995204e-03f, -6.88838884e-02f, -5.84985428e-02f, -3.35479788e-02f, -6.68759197e-02f, -7.72767663e-02f, 4.98419702e-02f, 2.72598844e-02f, -5.97992912e-02f,
  -7.00823218e-02f, -1.71693400e-01f, -8.79637450e-02f, -4.68849540e-02f, -2.10282028e-01f, 1.00894645e-03f, 1.07060760e-01f, -7.30648264e-02f, 1.22286426e-02f, 2.11844802e-01f,
  3.52307558e-02f, 3.95363718e-01f, 2.63967495e-02f, -9.70920324e-02f, 1.92202497e-02f, -1.37403738e-02f, 3.06679327e-02f, 1.51112884e-01f, 1.11587957e-01f, 1.31121472e-01f,
  7.43798465e-02f, -7.08071217e-02f, -7.68568739e-02f, 5.16702123e-02f, -6.77855642e-05f, 2.52828032e-01f, 3.16327363e-02f, -9.04148221e-02f, 8.54716748e-02f, 1.54871777e-01f,
  6.11811727e-02f, -7.25024343e-02f, 2.01765336e-02f, -1.41332373e-01f, 1.47578688e-02f, 1.95269659e-01f, -1.44070566e-01f, 4.92548533e-02f, 1.11128926e-01f, 5.19299731e-02f,
  5.13926148e-01f, -5.40634170e-02f, -8.43681619e-02f, 3.08553934e-01f, 4.54430819e-01f, 4.15534765e-01f, 2.88059115e-01f, 4.39813465e-01f, 6.51205719e-01f, -1.13927811e-01f,
  8.17062240e-03f, -2.59810984e-01f, -4.26598161e-01f, 1.91378146e-01f, 3.16610992e-01f, -8.48597065e-02f, 3.92855406e-01f, 6.36418983e-02f, 1.44976825e-01f, 1.36437804e-01f,
  2.66222119e-01f, 1.60896659e-01f, -4.70392674e-01f, -1.11430839e-01f, 1.54505327e-01f, -1.72043681e-01f, -4.14120108e-01f, -2.10984871e-01f, -1.99430943e-01f, 3.80356088e-02f,
  2.59210891e-03f, 1.63957439e-02f, -1.35516077e-01f, -1.29120842e-01f, -5.76665765e-03f, -4.85300608e-02f, -1.19981274e-01f, -2.58223295e-01f, 1.98011342e-02f, 4.19192947e-02f,
  -6.65862337e-02f, 6.99112564e-02f, 9.53146294e-02f, -4.30079103e-02f, 1.51108205e-01f, 7.76705965e-02f, 1.33378375e-02f, 2.68467758e-02f, -1.30019754e-01f, 8.13803542e-03f,
  -8.75975937e-02f, -6.95817396e-02f, 1.87242106e-02f, 1.53235778e-01f, -5.10610901e-02f, 1.04522392e-01f, -3.31015140e-02f, -2.12471858e-02f, 1.18573971e-01f, 1.10901356e-01f,
  -9.67239868e-03f, 1.20297611e-01f, -1.35197103e-01f, -1.50009459e-02f, 6.66670501e-02f, -1.02507928e-02f, -3.10776066e-02f, -1.59128662e-02f, 2.25259721e-01f, -2.20970344e-02f,
  -4.46494622e-03f, 2.09040437e-02f, 1.03532881e-01f, -1.04212657e-01f, 6.28634766e-02f, -1.57903489e-02f, -1.04120873e-01f, -2.34402567e-02f, -9.78343282e-03f, 4.14187349e-02f,
  -7.53441080e-02f, 7.15890452e-02f, -4.82724197e-02f, -9.44109485e-02f, 1.58543102e-02f, -9.37534720e-02f, -2.70824712e-02f, 9.03503373e-02f, -5.49225602e-04f, -4.61516678e-02f,
  2.16427356e-01f, 1.78916067e-01f, -6.53760210e-02f, 3.11509706e-03f, -1.22425500e-02f, 1.40193462e-01f, -2.29276344e-03f, 8.54852051e-02f, 3.39506418e-02f, 1.28364816e-01f,
  -9.54725500e-03f, 1.36577144e-01f, -7.52981007e-02f, 3.78668830e-02f, -5.33947311e-02f, 1.56945903e-02f, -1.73283778e-02f, 3.64409946e-02f, 4.82505094e-03f, -1.80209987e-02f,
  -2.82310694e-02f, -2.16948930e-02f, -2.45849211e-02f, 7.75972679e-02f, 8.27115253e-02f, -1.69853106e-01f, 9.08109099e-02f, -7.81182721e-02f, 5.23162782e-02f, 5.06563410e-02f,
  2.05152333e-01f, -2.61916891e-02f, -4.36510034e-02f, -2.38570690e-01f, -1.16027988e-01f, -9.62806121e-02f, -2.17759106e-02f, -2.25345775e-01f, 1.23334881e-02f, -2.57284194e-01f,
  -2.55388856e-01f, 1.25707984e-01f, 7.12231472e-02f, -3.66248101e-01f, 4.79728252e-01f, 1.83531761e-01f, -2.51379043e-01f, -2.24252418e-01f, 4.55185771e-02f, -3.86107087e-01f,
  -5.87911298e-03f, -4.97873157e-01f, -9.11812931e-02f, -3.28580111e-01f, -2.54099250e-01f, -9.41490456e-02f, -1.28387868e-01f, -2.19669893e-01f, -3.64784241e-01f, -5.96199259e-02f,
  3.81955728e-02f, -4.60968129e-02f, 7.29701295e-02f, 4.00575772e-02f, -6.06228411e-02f, -5.66846691e-02f, -1.08504727e-01f, 2.29519960e-02f, 1.66443318e-01f, -1.03035700e-02f,
  -1.29753947e-01f, -7.21566081e-02f, 4.70188968e-02f, 1.40636683e-01f, -8.79233107e-02f, -4.18593735e-02f, -1.15167880e-02f, -8.08785558e-02f, -1.69343188e-01f, -5.53579777e-02f,
  2.55967490e-02f, 3.51757146e-02f, -5.16392291e-02f, -6.87054684e-03f, 1.35453865e-01f, 1.11088557e-02f, 4.76231948e-02f, 1.27628952e-01f, 1.41231224e-01f, -4.06267196e-02f,
  -1.07193314e-01f, 8.97238404e-02f, 8.17410797e-02f, -6.03890195e-02f, 4.74930033e-02f, -1.60881188e-02f, -8.57686549e-02f, -3.20754573e-02f, -4.80474299e-03f, -1.39445737e-01f,
  -1.29227201e-02f, 3.44538018e-02f, -9.46919322e-02f, -2.93744281e-02f, -1.59846306e-01f, 1.32494703e-01f, 5.53024411e-02f, -3.61189879e-02f, -5.24562337e-02f, 1.32506117e-01f,
  1.55458804e-02f, 1.06108345e-01f, 5.65847345e-02f, -1.77250002e-02f, -6.98492527e-02f, 8.47166255e-02f, -6.58492967e-02f, -1.22762859e-01f, 9.75856110e-02f, -1.46650925e-01f,
  -8.93749371e-02f, -8.26893523e-02f, 9.92381498e-02f, -3.62127200e-02f, 1.00189582e-01f, 9.91932601e-02f, 3.85428616e-03f, -1.34024126e-02f, -8.66564065e-02f, 4.29672524e-02f,
  -1.37371793e-01f, -4.60502394e-02f, 7.00432137e-02f, 5.24599818e-05f, -1.11952059e-01f, 5.88262863e-02f, -1.26572981e-01f, 1.05340824e-01f, -1.00392409e-01f, -1.73324719e-01f,
  -1.24183193e-01f, 1.04283214e-01f, 1.00605143e-02f, 2.03257482e-02f, -1.30763650e-01f, -9.32569131e-02f, 1.95866644e-01f, 3.81277166e-02f, -1.24378204e-01f, -1.13532372e-01f,
  1.74132586e-01f, 3.30581158e-01f, 4.00341958e-01f, 2.33598590e-01f, -2.99119055e-01f, -3.42323989e-01f, -1.55989602e-01f, -3.85805219e-02f, 1.52647346e-02f, 1.78369284e-01f,
  -2.51276731e-01f, 5.02642095e-01f, -1.78980753e-01f, 2.89662257e-02f, -1.50900021e-01f, -3.83014411e-01f, 1.75119460e-01f, 4.81389873e-02f, -2.14868605e-01f, 3.26848209e-01f,
  1.04027823e-01f, -2.79965401e-01f, 1.77889198e-01f, -1.27099380e-01f, 1.34376496e-01f, 2.62091845e-01f, 1.20313074e-02f, -1.38246313e-01f, 3.06465179e-01f, -1.07774779e-01f,
  -9.33912694e-02f, 7.23595098e-02f, 1.12788975e-01f, -5.42145632e-02f, -3.88743170e-02f, -7.48052672e-02f, -4.59873006e-02f, -6.59949332e-02f, -1.76058248e-01f, 7.59120705e-03f,
  1.29109174e-01f, -5.73836919e-03f, 7.58283362e-02f, -5.33211343e-02f, -3.95011203e-03f, 2.36767121e-02f, 8.24108943e-02f, 1.74641237e-01f, 6.58633783e-02f, 1.93262637e-01f,
  1.92178831e-01f, 1.00842021e-01f, 1.21085092e-01f, 1.64475471e-01f, 1.87564820e-01f, 7.07018226e-02f, -6.84875413e-04f, 1.59496188e-01f, 1.12003312e-01f, 2.23325007e-02f,
  5.20574413e-02f, -1.62304621e-02f, -1.09054178e-01f, -1.66491792e-02f, -1.91517156e-02f, -5.56538589e-02f, -1.40383631e-01f, -8.24067462e-03f, -1.36052892e-01f, 9.03259739e-02f,
  -5.01128621e-02f, 7.00255036e-02f, -2.17264891e-01f, 1.01215728e-01f, -3.67766544e-02f, 6.12655729e-02f, -5.46105728e-02f, -3.95733602e-02f, -1.29753621e-02f, 3.50115560e-02f,
  -7.22896606e-02f, -7.55567476e-02f, 5.19279987e-02f, -3.27929482e-02f, -2.67828465e-01f, -3.55108976e-02f, 2.42826641e-02f, 6.76183309e-03f, -1.16666369e-01f, -1.21289352e-02f,
  1.43204659e-01f, 2.06318378e-01f, 7.63812661e-02f, -1.61704421e-02f, -9.43902284e-02f, -3.31869051e-02f, -3.94793414e-02f, 1.06458545e-01f, 1.14717789e-01f, -1.91191733e-01f,
  1.19519040e-01f, -4.02901731e-02f, -4.99254987e-02f, -8.71290732e-03f, -1.71433818e-02f, 8.67329463e-02f, 1.34380355e-01f, 4.97831069e-02f, 6.62839487e-02f, 1.91318586e-01f,
  5.82184382e-02f, -3.81415710e-02f, 1.45404890e-01f, 1.50694894e-02f, 1.52251199e-01f, 1.14056259e-01f, 3.80131882e-04f, 1.06195480e-01f, 1.23774067e-01f, -3.19295153e-02f,
  5.62248789e-02f, 6.34103179e-01f, -2.19710469e-01f, 1.84641466e-01f, 5.25543292e-04f, 4.99669194e-01f, 5.72519243e-01f, 1.99048534e-01f, 3.71317774e-01f, 3.79622489e-01f,
  4.17134911e-02f, 3.54535311e-01f, 7.22400248e-02f, 3.60369414e-01f, 1.67926416e-01f, 1.60278127e-01f, 5.26631355e-01f, 4.07219291e-01f, 7.24488497e-02f, 2.90573806e-01f,
  9.20633078e-02f, 2.71336615e-01f, -3.34683955e-01f, -8.95099118e-02f, 4.14451584e-02f, -3.02442282e-01f, -2.84778655e-01f, -1.86727375e-01f, 8.70350972e-02f, 8.97576958e-02f,
  -2.94935908e-02f, 5.42166010e-02f, -1.73711311e-02f, 1.77259333e-02f, -1.47666652e-02f, -5.29309027e-02f, -4.89195921e-02f, -8.38230401e-02f, -9.98645276e-02f, 8.05602446e-02f,
  -5.99517720e-03f, -1.08370386e-01f, 1.48582056e-01f, -7.88245127e-02f, 5.93574978e-02f, 2.05303878e-02f, 3.44689041e-02f, -1.22411000e-02f, -2.62191948e-02f, -6.96666986e-02f,
  1.49806263e-02f, -4.49051969e-02f, 1.57523137e-02f, 1.09609954e-01f, -4.93091829e-02f, 7.58358091e-02f, 4.31279875e-02f, -9.22527630e-03f, 6.68269992e-02f, 2.04465806e-01f,
  1.55280501e-01f, -6.26606867e-02f, -7.00421855e-02f, -7.37778619e-02f, 3.58423032e-02f, -7.56858215e-02f, 3.17719020e-02f, -1.50591701e-01f, -2.17316467e-02f, -1.24396957e-01f,
  -4.31990325e-02f, -5.22961169e-02f, -9.59224161e-03f, -1.07131943e-01f, 1.18099369e-01f, -1.17934376e-01f, -4.00605425e-02f, -4.27949056e-03f, 4.79134768e-02f, -1.08898133e-01f,
  1.57228147e-03f, 1.84551105e-01f, 1.25457987e-01f, -1.17091294e-02f, -6.35957494e-02f, -3.31251621e-02f, -3.18055903e-03f, 1.99884009e-02f, -4.46935706e-02f, 1.48707718e-01f,
  1.97680503e-01f, 4.39076513e-01f, 7.31277689e-02f, 3.36329378e-02f, -2.09386274e-02f, 7.69581869e-02f, -4.75093834e-02f, 1.12870529e-01f, 1.84383065e-01f, 4.87450249e-02f,
  -4.41213474e-02f, 4.09597345e-02f, -3.38926949e-02f, -1.65308043e-01f, -2.55847201e-02f, 2.13373184e-01f, 8.26892704e-02f, 4.73778099e-02f, 9.99849662e-02f, -9.40843746e-02f,
  -1.29103452e-01f, 7.18241706e-02f, -4.40675542e-02f, -8.43500197e-02f, 1.06412157e-01f, -6.87649474e-02f, 1.30125880e-01f, -1.81555375e-01f, 1.08943939e-01f, 8.94498974e-02f,
  -3.67247872e-02f, -1.44913271e-01f, -4.57099140e-01f, 3.27626243e-02f, -3.14233243e-01f, -4.67474431e-01f, -2.15873584e-01f, -1.12339087e-01f, 1.50935248e-01f, 3.34822029e-01f,
  1.84806809e-01f, 3.18577662e-02f, 4.58197564e-01f, -5.88578507e-02f, -2.49623582e-01f, 3.12375605e-01f, -3.69690865e-01f, 3.42377461e-02f, -1.93318371e-02f, -8.15449953e-02f,
  -7.36941174e-02f, 9.25867911e-03f, -2.56103098e-01f, 2.89586037e-02f, -2.40550429e-01f, -1.25355139e-01f, -3.22458148e-02f, -3.88903049e-04f, -1.60512760e-01f, -2.01506585e-01f,
  -1.68825269e-01f, 1.91106677e-01f, -8.94394442e-02f, 4.32198122e-02f, -1.22296602e-01f, -1.62941143e-01f, -8.66599977e-02f, 6.03052415e-02f, 2.14715973e-01f, 3.05613168e-02f,
  1.14042819e-01f, 2.41117880e-01f, 8.64924863e-02f, 1.75815940e-01f, -4.37312899e-03f, -7.11493716e-02f, 5.31923436e-02f, -1.69670224e-01f, 1.27257362e-01f, -3.67863551e-02f,
  -5.81318513e-02f, -5.00403494e-02f, 7.26077612e-03f, 1.40294179e-01f, -4.64841374e-04f, -3.83569952e-03f, -3.26098092e-02f, -1.48587659e-01f, -6.88550174e-02f, -9.01987404e-02f,
  3.74628161e-03f, 2.99707446e-02f, 1.87867768e-02f, 3.46533135e-02f, 6.97713569e-02f, -7.47043863e-02f, 7.24955574e-02f, 4.74007986e-02f, 1.73687264e-02f, -1.46900918e-02f,
  8.94909054e-02f, 8.16336870e-02f, 7.66199380e-02f, 1.07150394e-02f, -3.49973142e-02f, 1.12780720e-01f, 6.12288900e-02f, -2.46923044e-02f, 1.47738820e-02f, -8.47895890e-02f,
  3.39509733e-02f, -8.12925845e-02f, -2.26194747e-02f, -1.08054698e-01f, -7.23295659e-02f, 9.68202651e-02f, -5.03504351e-02f, -3.71133313e-02f, -9.94163379e-03f, -4.89309467e-02f,
  -2.32209101e-01f, 7.27151111e-02f, 7.06940219e-02f, 1.30696803e-01f, -8.29893425e-02f, -4.54673842e-02f, -1.30855471e-01f, -6.11649565e-02f, -3.46395303e-03f, 7.20499158e-02f,
  -1.50458654e-02f, 1.64522650e-03f, -1.49466276e-01f, 1.39640430e-02f, 1.18458182e-01f, -5.67767955e-02f, 1.09678775e-01f, 1.62702486e-01f, -6.62320405e-02f, -9.69134346e-02f,
  1.06254876e-01f, 3.43292654e-02f, 2.43307024e-01f, 2.17225119e-01f, 1.79050729e-01f, -7.52240494e-02f, -8.92112255e-02f, -8.20014700e-02f, -1.07888812e-02f, 3.73105593e-02f,
  -7.01577187e-01f, 2.35729054e-01f, 3.15734535e-01f, 5.36776483e-02f, -5.14946163e-01f, 2.93631077e-01f, 4.77978915e-01f, -2.34008491e-01f, 4.11862016e-01f, 3.69157165e-01f,
  -1.29241407e-01f, 1.02504261e-01f, 3.05528641e-01f, 1.68058932e-01f, -1.46291004e-02f, 4.01880473e-01f, 1.84903547e-01f, 1.72780022e-01f, -1.88962929e-02f, -2.19427347e-01f,
  -1.93603396e-01f, -3.44961196e-01f, -4.59292382e-02f, -1.45198807e-01f, -2.67018646e-01f, 1.45083591e-02f, -2.13359177e-01f, 3.07817664e-02f, -9.50514525e-02f, -1.00948133e-01f,
  -2.70374984e-01f, -1.07267022e-01f, -2.96666086e-01f, 1.01687193e-01f, -7.48112351e-02f, 4.42175306e-02f, 3.80725525e-02f, 9.66652483e-02f, -1.86101794e-02f, 7.23457932e-02f,
  6.89888000e-02f, -3.48963924e-02f, 8.00286755e-02f, -5.35242558e-02f, 1.84442084e-02f, 7.36915879e-03f, -1.13842815e-01f, -8.47762823e-02f, -2.93740742e-02f, 5.20939082e-02f,
  4.29792963e-02f, -5.37404940e-02f, -6.05933331e-02f, 8.86692107e-02f, -7.72814527e-02f, 8.28510299e-02f, 1.46925375e-01f, -1.00151658e-01f, -9.64755416e-02f, 7.47789815e-02f,
  -1.10331766e-01f, 1.99053213e-01f, 1.60985813e-01f, -6.26590699e-02f, -2.47247349e-02f, -2.23350823e-01f, -3.32114324e-02f, 1.18230425e-01f, 1.24722414e-01f, -1.49237514e-01f,
  -4.47730720e-02f, -1.45972326e-01f, -8.49417374e-02f, 1.41540160e-02f, 3.47414240e-02f, 1.43588101e-02f, -1.07830115e-01f, -3.33596058e-02f, 2.66063605e-02f, -1.15601227e-01f,
  -1.13542611e-02f, 7.99104571e-02f, -8.17587972e-02f, -5.66457212e-02f, 7.32872039e-02f, 2.88274474e-02f, -8.45967010e-02f, 6.99032238e-03f, 2.98184296e-03f, -7.48084058e-05f,
  -5.97989485e-02f, 8.55192840e-02f, -6.22280315e-02f, -6.99832439e-02f, 7.84583017e-02f, 1.11617427e-02f, 8.96089897e-03f, -1.17347643e-01f, -1.48736397e-02f, -8.86845775e-03f,
  5.12912236e-02f, 8.44410509e-02f, -1.30436063e-01f, 1.30432978e-01f, 6.97094947e-02f, 1.26499468e-02f, 1.19602375e-01f, -3.45838778e-02f, -1.87686868e-02f, -5.22670709e-02f,
  6.46611862e-03f, 9.53609943e-02f, 6.86183423e-02f, -6.43969029e-02f, -3.00390329e-02f, -9.14003849e-02f, -1.30190670e-01f, 5.59855402e-02f, -1.20778054e-01f, 3.01665142e-02f,
  -4.56373319e-02f, 1.58872321e-01f, -3.11918348e-01f, -9.51179191e-02f, -1.92873403e-01f, -2.97069699e-01f, -2.85925359e-01f, -1.40426327e-02f, 3.12963158e-01f, 2.14784145e-01f,
  -8.84607360e-02f, 2.05815703e-01f, 2.32626349e-01f, -2.30142131e-01f, 6.61040023e-02f, 2.68391371e-01f, -3.65169942e-01f, -4.42449041e-02f, 7.95750916e-02f, -1.29466146e-01f,
  -2.81707514e-02f, -2.10990697e-01f, -1.70429751e-01f, -9.93428659e-03f, -3.76799047e-01f, -1.63903505e-01f, -3.57816815e-02f, -1.20922156e-01f, -3.23984772e-01f, -1.29970968e-01f,
  -1.36782840e-01f, 2.58977320e-02f, -2.22938240e-01f, 1.85641777e-02f, -1.57965213e-01f, -4.56216000e-02f, -4.72480059e-02f, 8.01647753e-02f, -9.74289402e-02f, -5.49297445e-02f,
  1.86693877e-01f, 7.89614171e-02f, 2.72837337e-02f, 8.55058804e-02f, 1.11149019e-02f, 2.96747740e-02f, -5.59040233e-02f, -2.21230179e-01f, 1.24062389e-01f, 2.03149449e-02f,
  8.45277403e-03f, -8.77953693e-03f, -1.59759834e-01f, 9.04765632e-03f, -1.29967317e-01f, -2.06486195e-01f, -5.74151762e-02f, -1.84355266e-02f, 1.76031888e-02f, 5.52265048e-02f,
  -9.62863415e-02f, -2.50633042e-02f, 4.12103832e-02f, -5.29377311e-02f, 1.42682316e-02f, 7.34558403e-02f, -5.51481843e-02f, 5.48331253e-02f, 9.09505319e-03f, -1.14067877e-02f,
  5.28028607e-02f, 7.55441561e-03f, -2.34422423e-02f, -8.51556510e-02f, -4.82138135e-02f, 9.85041484e-02f, -1.61260869e-02f, 8.86530355e-02f, 5.18002873e-03f, -1.28719956e-01f,
  1.11650087e-01f, -7.70376250e-02f, 8.67327452e-02f, -3.73817943e-02f, 1.24522066e-02f, 2.90171094e-02f, -2.75603365e-02f, 7.95427188e-02f, -4.33560610e-02f, -3.00647574e-03f,
  -1.83591425e-01f, -1.08344145e-01f, -6.04308210e-03f, 4.83296402e-02f, -2.45630220e-02f, 4.09918316e-02f, 6.31589582e-03f, -2.56864335e-02f, -8.44377503e-02f, 5.94395846e-02f,
  -4.65975795e-03f, 8.35003518e-03f, -3.91050737e-04f, 3.55116725e-02f, 9.12172422e-02f, -8.14553425e-02f, -8.49268809e-02f, 1.59020741e-02f, -4.08060327e-02f, -1.48640173e-02f,
  -3.27681261e-03f, 1.40451089e-01f, -7.88028166e-02f, -1.98450796e-02f, -3.58703844e-02f, -1.80793077e-01f, 1.04193360e-01f, 4.97505665e-02f, -9.07203555e-02f, 1.82469726e-01f,
  -1.64643064e-01f, -4.39371318e-02f, -2.93776900e-01f, -3.44112784e-01f, 5.98216876e-02f, -3.01912993e-01f, -2.46681854e-01f, -1.10765368e-01f, -8.61842036e-02f, 3.14621925e-01f,
  -2.39607953e-02f, -6.03602361e-03f, 1.16074726e-01f, -6.12946868e-01f, -7.35922992e-01f, -4.68935281e-01f, -3.42830420e-01f, -1.14513591e-01f, -1.66818142e-01f, 7.97650963e-02f,
  -1.03688471e-01f, -2.18568236e-01f, -3.85501564e-01f, 6.79491833e-02f, -1.04772121e-01f, 2.50865102e-01f, 2.02382609e-01f, 9.00133550e-02f, 3.35963480e-02f, -1.27820238e-01f,
  -1.73573747e-01f, -4.72222492e-02f, -6.07562624e-03f, -3.55919562e-02f, 3.15677449e-02f, 1.69264466e-01f, 6.81223124e-02f, -6.30238131e-02f, -6.28147051e-02f, -3.06336060e-02f,
  1.39316961e-01f, 1.53471483e-02f, -9.14652944e-02f, -1.49034679e-01f, 1.05687818e-02f, -4.71172296e-02f, -1.00354411e-01f, 1.52184784e-01f, -2.04971097e-02f, -2.64764242e-02f,
  -3.29720117e-02f, 1.17399720e-02f, 6.90015778e-02f, 4.66329716e-02f, -3.62308766e-03f, 1.03476562e-03f, 6.25422150e-02f, 1.26110226e-01f, 1.33566126e-01f, -5.29329069e-02f,
  6.24195412e-02f, 8.67170990e-02f, -6.34778440e-02f, -9.12441835e-02f, -5.79194129e-02f, 1.24922255e-02f, -2.50229128e-02f, 9.90881398e-02f, 7.44706094e-02f, 2.35418770e-02f,
  2.01181713e-02f, 4.19454724e-02f, -5.80825210e-02f, 2.40833331e-02f, 3.28702666e-02f, -2.73363367e-02f, -3.16844396e-02f, 7.60185346e-02f, 3.72600183e-02f, 3.67888808e-02f,
  -6.23937845e-02f, -4.14056033e-02f, -1.41408676e-02f, 1.87996700e-01f, -2.13795573e-01f, 1.54557616e-01f, 1.59612536e-01f, -8.74685794e-02f, -1.09448180e-01f, 1.53415620e-01f,
  6.97066188e-02f, 2.33797029e-01f, -3.80976647e-02f, -4.04248089e-02f, -7.00012818e-02f, -8.50717798e-02f, -1.26305774e-01f, -3.01096570e-02f, 6.09334335e-02f, -1.20819725e-01f,
  1.82418838e-01f, 1.20200075e-01f, 1.14186369e-01f, 3.03696822e-02f, -7.90445879e-03f, -1.49611443e-01f, 1.00254826e-01f, 8.87554958e-02f, 1.32766426e-01f, 1.11002587e-01f,
  1.66716397e-01f, 1.22106999e-01f, 4.13994193e-02f, 2.08419770e-01f, 1.58564597e-01f, 1.53542027e-01f, 9.18297991e-02f, 8.15823376e-02f, 1.74416199e-01f, 6.40392825e-02f,
  4.63700503e-01f, -7.86056072e-02f, -4.95909974e-02f, -1.57806620e-01f, -1.50054306e-01f, -3.51749480e-01f, -2.16059446e-01f, -2.88051337e-01f, -3.55227619e-01f, -1.22982889e-01f,
  -5.18634804e-02f, 5.13524041e-02f, 2.70304948e-01f, 2.61680167e-02f, 2.91574359e-01f, 3.40622485e-01f, -2.51156539e-01f, -8.58716518e-02f, 7.62894154e-02f, 2.69858360e-01f,
  2.17520803e-01f, 1.73262432e-01f, 2.40261421e-01f, 2.59287544e-02f, 1.44801721e-01f, 6.58837333e-02f, 2.41466165e-01f, 1.79853320e-01f, -2.18751669e-01f, -2.47854833e-02f,
  -6.06843382e-02f, 1.82554603e-01f, -7.65871853e-02f, -6.97848797e-02f, 5.57211488e-02f, 5.01488894e-02f, 7.03138486e-02f, 2.39864606e-02f, -1.34667000e-02f, -2.24286132e-02f,
  5.24911284e-03f, 2.69394871e-02f, -1.44914433e-01f, 1.63874447e-01f, 2.84557627e-03f, -8.06089789e-02f, -8.38340968e-02f, -6.87464997e-02f, -7.02458769e-02f, 2.68993527e-01f,
  5.50173596e-02f, -2.93432754e-02f, 9.95367114e-03f, -8.85628816e-03f, -7.99594074e-02f, -1.26126528e-01f, 1.08016834e-01f, 1.80838294e-02f, -2.35084556e-02f, -2.71664057e-02f,
  8.65954459e-02f, 5.14089465e-02f, 3.75020504e-02f, -6.78447485e-02f, -1.68996435e-02f, 2.56115869e-02f, -1.48334801e-01f, -1.42061219e-01f, -6.55760691e-02f, 1.65519910e-03f,
  -1.67354062e-01f, -9.36304554e-02f, 9.72363204e-02f, -1.29656959e-02f, 5.96093126e-02f, 1.61586955e-01f, 9.27558914e-02f, 5.91707826e-02f, -2.60425985e-01f, -1.91641510e-01f,
  1.74401794e-02f, 7.21089169e-02f, -7.48738870e-02f, -5.53111434e-02f, -2.55857613e-02f, -7.28715137e-02f, -6.17351979e-02f, 1.22024499e-01f, 5.38970120e-02f, 1.17289625e-01f,
  -2.59711426e-02f, 5.39380163e-02f, -1.58106059e-01f, -1.38853356e-01f, 3.06279883e-02f, 6.42052293e-02f, 2.65264641e-02f, -1.51235402e-01f, 1.76833365e-02f, 8.54476243e-02f,
  -1.70141477e-02f, -5.22213466e-02f, 5.89986295e-02f, -3.65617499e-02f, -1.17867045e-01f, -7.11819232e-02f, 1.85034499e-01f, -5.51458262e-02f, -5.36163163e-04f, -2.33783834e-02f,
  -1.08526915e-01f, 2.04753540e-02f, 2.48638429e-02f, -7.50334337e-02f, -1.02141127e-01f, -1.94248199e-01f, 1.02975994e-01f, -7.14962091e-03f, -5.50589291e-03f, -1.94203094e-01f,
  -6.21134602e-02f, -2.82899827e-01f, 4.81600463e-01f, -4.13080126e-01f, 2.90302843e-01f, 4.11674738e-01f, 3.92357141e-01f, -1.46540701e-01f, -2.68012434e-01f, -3.68657887e-01f,
  6.37582839e-02f, -1.36140510e-01f, 2.50087857e-01f, -1.78199098e-01f, 5.45261264e-01f, 1.46879956e-01f, -1.32225737e-01f, -7.60650495e-03f, -4.06285301e-02f, -1.08064696e-01f,
  -7.18774274e-02f, -3.81031245e-01f, 2.08855629e-01f, -2.28301242e-01f, -5.65574765e-02f, -1.24986015e-01f, -2.27773964e-01f, 2.40471318e-01f, -2.31304169e-01f, 2.79352337e-01f,
  -8.79350677e-02f, -1.58392668e-01f, -8.86562988e-02f, -1.82904787e-02f, -2.37905663e-02f, 1.82288000e-03f, 6.82298169e-02f, 1.87875286e-01f, -1.04066059e-02f, -7.27608949e-02f,
  1.83152743e-02f, 1.10366076e-01f, -2.50960052e-01f, 6.17025569e-02f, -8.57808292e-02f, -2.38044299e-02f, 4.01428975e-02f, 9.59216282e-02f, 4.03966801e-03f, 2.06550956e-01f,
  9.93269309e-02f, 2.98150089e-02f, -1.29952952e-02f, -1.90219209e-02f, 1.46605834e-01f, -5.10997660e-02f, 3.12567391e-02f, 2.14171916e-01f, -4.41434793e-02f, 5.34123257e-02f,
  5.58215901e-02f, 4.46703061e-02f, 8.28327015e-02f, -1.54767245e-01f, -3.68557237e-02f, -9.60402414e-02f, -1.02167226e-01f, -7.64835924e-02f, -5.48185781e-02f, 1.77303534e-02f,
  -8.69775005e-03f, -5.76924011e-02f, 1.01503529e-01f, -4.27097678e-02f, -6.21814989e-02f, -1.51143158e-02f, -2.51031648e-02f, -8.93570948e-03f, 3.98406498e-02f, -5.36262505e-02f,
  -5.58161959e-02f, 1.13756388e-01f, 1.40839696e-01f, 2.74917539e-02f, 3.21234912e-02f, 3.12689804e-02f, -1.06719278e-01f, 6.34163022e-02f, -8.96263346e-02f, 7.77792856e-02f,
  -4.23908144e-01f, -3.46616387e-01f, -5.39645813e-02f, -1.24252409e-01f, -8.96581858e-02f, -8.01742077e-02f, -5.05588623e-03f, -6.14324324e-02f, -1.24109395e-01f, -6.24661287e-03f,
  -4.22361791e-02f, 1.34286024e-02f, -3.36794294e-02f, -5.07838987e-02f, -4.06427532e-02f, -1.08651884e-01f, -5.41404672e-02f, -1.02411859e-01f, -8.46507326e-02f, -6.17541261e-02f,
  -1.14145227e-01f, -2.93501560e-02f, 6.33639321e-02f, 4.61674593e-02f, -1.65865440e-02f, -4.74430919e-02f, -2.57877558e-02f, -5.36991917e-02f, 7.27842227e-02f, 8.37276317e-03f,
  -6.91694498e-01f, 7.51104653e-02f, -3.58382940e-01f, 3.89371216e-02f, -1.74938262e-01f, -1.08073577e-02f, 1.90245986e-01f, 5.93318269e-02f, 2.22454906e-01f, 3.59669775e-01f,
  3.41943413e-01f, 8.59219860e-03f, 2.83972919e-01f, 3.97478312e-01f, -5.56702495e-01f, 1.50794432e-01f, 7.38430321e-02f, 1.39078736e-01f, -7.36539811e-02f, -5.57712615e-02f,
  -3.27681988e-01f, 2.18271583e-01f, -2.30139986e-01f, 2.88479701e-02f, -8.10555071e-02f, -1.16305843e-01f, 1.82139441e-01f, -2.61485092e-02f, 1.04600079e-01f, -3.98894623e-02f,
  -2.09010616e-01f, -8.61640945e-02f, -6.54190704e-02f, -9.75894406e-02f, -1.70247555e-01f, -1.00622773e-01f, -1.17522098e-01f, -9.05701444e-02f, 1.68965254e-02f, 4.75454107e-02f,
  -6.18313514e-02f, -8.42858478e-02f, 6.12065904e-02f, 1.19309083e-01f, -9.88662317e-02f, -1.60115123e-01f, -8.26175064e-02f, -3.55395600e-02f, 4.51974124e-02f, -1.02666639e-01f,
  -1.23433791e-01f, -1.80812344e-01f, 6.90040365e-02f, -2.06450112e-02f, 6.49535879e-02f, 3.49672921e-02f, -8.24513584e-02f, -5.57348616e-02f, -6.84372857e-02f, -1.10426493e-01f,
  -8.15872662e-03f, -5.63952252e-02f, 9.78933298e-04f, 1.86346080e-02f, 6.29116839e-04f, -7.83319026e-03f, 2.00438499e-02f, 6.70102239e-02f, -1.51252113e-02f, -1.84265282e-02f,
  1.11118056e-01f, 2.08100248e-02f, 8.79833624e-02f, -3.28977741e-02f, -2.67871153e-02f, -1.79857444e-02f, 2.94208564e-02f, -9.83604267e-02f, -5.27012423e-02f, -1.81900606e-01f,
  1.03463210e-01f, 7.01440824e-03f, 2.46421639e-02f, -2.15282962e-02f, -5.25511429e-02f, 3.28204855e-02f, 5.63678257e-02f, -1.27870545e-01f, 5.40755726e-02f, -2.00237837e-02f,
  -7.66801760e-02f, -2.13861182e-01f, 1.40294552e-01f, -1.89036522e-02f, -1.43928488e-03f, -3.11350990e-02f, 6.29740208e-02f, -9.81179029e-02f, -2.29622684e-02f, 5.71844121e-03f,
  -1.15115969e-02f, -4.73163873e-02f, -4.06594276e-02f, 3.81089784e-02f, -3.94693688e-02f, 2.86293551e-02f, 7.55315125e-02f, -6.78605749e-04f, -5.09158224e-02f, -1.51369303e-01f,
  -2.37102825e-02f, -2.78596394e-02f, 1.82500295e-02f, 1.63905046e-04f, 1.65234521e-01f, 1.08704485e-01f, 2.58458052e-02f, -6.82793260e-02f, -8.40723068e-02f, 1.74883530e-02f,
  2.81516463e-01f, -4.23791319e-01f, -2.35951215e-01f, 1.86666593e-01f, 2.02138603e-01f, 3.36486772e-02f, -9.24562737e-02f, 9.69084501e-02f, -1.83245435e-01f, -3.23513269e-01f,
  5.92459999e-02f, 4.42742510e-03f, -4.01587039e-01f, 3.33237499e-01f, 6.38480246e-01f, -2.94355482e-01f, 3.03993136e-01f, 1.29592538e-01f, 1.15920650e-02f, 1.92289457e-01f,
  3.42892855e-01f, 3.85889053e-01f, 1.53338283e-01f, 3.68538707e-01f, 1.29519477e-01f, -1.05074001e-03f, 9.17434171e-02f, 3.07770837e-02f, 3.37393850e-01f, 2.07768306e-01f,
  -1.71921551e-02f, -7.88791925e-02f, 5.09107783e-02f, -2.10605189e-02f, -6.78184777e-02f, 1.30270392e-01f, 6.26801625e-02f, -1.21783279e-01f, 1.14345901e-01f, -1.09934255e-01f,
  -1.02278151e-01f, 1.08667001e-01f, 2.90580392e-02f, 6.43608049e-02f, 1.19503483e-01f, 4.06156927e-02f, 6.37200773e-02f, -5.00873365e-02f, -1.15892500e-01f, -9.54650622e-03f,
  -4.53049205e-02f, -1.27199441e-01f, -4.61769365e-02f, -2.35555936e-02f, -5.20538576e-02f, 1.90771352e-02f, -2.13942990e-01f, -3.78388725e-02f, 8.18437710e-02f, -3.78559381e-02f,
  9.25641730e-02f, -4.42750081e-02f, -5.23033477e-02f, 3.22300941e-02f, -5.84302321e-02f, 6.94089159e-02f, 2.42761113e-02f, -1.65489549e-03f, -6.28107833e-03f, -7.29019893e-03f,
  2.92918039e-03f, 1.06252832e-02f, 4.95571010e-02f, -4.62382771e-02f, 4.14295048e-02f, -5.43692484e-02f, -7.44229322e-03f, 1.08072616e-01f, -3.55457664e-02f, 1.40620992e-02f,
  7.82885216e-03f, 7.15541467e-02f, 5.47564588e-02f, -3.49296327e-03f, 5.94814010e-02f, -2.58994792e-02f, 1.29177406e-01f, 2.68842336e-02f, -1.44007672e-02f, -5.34890071e-02f,
  -1.18179619e-01f, -1.07563443e-01f, -4.92564887e-02f, 2.87888888e-02f, -4.13743593e-02f, 3.83545533e-02f, 5.18776998e-02f, 1.13517074e-02f, -5.89248026e-03f, -8.86453018e-02f,
  7.15752095e-02f, 1.23378523e-02f, -9.73500013e-02f, 1.39820561e-01f, 6.48923293e-02f, -7.00710639e-02f, -8.36678315e-03f, -1.52343977e-02f, 2.41022371e-02f, -2.70269234e-02f,
  -7.67054856e-02f, -1.18026763e-01f, 5.84250279e-02f, 2.45976448e-02f, -3.02773085e-03f, -1.20871909e-01f, -4.36493419e-02f, -1.04301959e-01f, 3.12359221e-02f, -9.96434614e-02f,
  3.85716707e-01f, 1.84642434e-01f, 2.26899609e-01f, 3.28523964e-01f, 1.27427801e-01f, -7.41588324e-02f, -5.43031134e-02f, 2.11786762e-01f, 4.31646556e-01f, -1.26802832e-01f,
  -3.49586196e-02f, 1.98011726e-01f, -1.58171698e-01f, 1.06116883e-01f, -4.98226613e-01f, -2.24925816e-01f, -2.11848050e-01f, 1.00056127e-01f, 5.02504520e-02f, 2.39346072e-01f,
  2.52331160e-02f, -2.78456897e-01f, -2.48091340e-01f, -2.27755740e-01f, 3.91572237e-01f, 2.00468764e-01f, -3.10812891e-01f, -5.93034066e-02f, -9.80697572e-02f, -3.48136008e-01f,
  1.07973382e-01f, 1.69702575e-01f, 4.08783443e-02f, 4.67147306e-03f, 3.85814793e-02f, 3.93784009e-02f, -2.45461334e-02f, -7.90053234e-02f, 6.36203662e-02f, 5.43994009e-02f,
  5.23488633e-02f, -5.42805009e-02f, -1.17768785e-02f, -8.75357091e-02f, 6.80916384e-02f, 3.00548580e-02f, 1.39146298e-01f, 1.25874475e-01f, 5.29056601e-02f, 1.06060840e-01f,
  1.99025705e-01f, 7.29298890e-02f, 9.61221755e-02f, -9.22676548e-02f, 9.09607019e-03f, -1.04760965e-02f, -1.03257664e-01f, -1.46067828e-01f, 1.40727416e-01f, 1.80667099e-02f,
  -4.05140109e-02f, -9.33661386e-02f, -6.02842728e-03f, 5.01940846e-02f, 1.78510323e-02f, 5.14849499e-02f, 3.02033536e-02f, -6.42342940e-02f, 6.55968785e-02f, 5.17814197e-02f,
  1.33794558e-03f, 4.44112159e-02f, 3.96387428e-02f, 8.67781937e-02f, -3.41435559e-02f, 1.85380444e-01f, -1.11414641e-01f, -3.75000350e-02f, -7.42565244e-02f, -5.14347404e-02f,
  -1.37907341e-01f, 1.64404307e-02f, -3.96324843e-02f, 3.52187790e-02f, 1.89329423e-02f, 9.42250416e-02f, 1.56687751e-01f, 2.07991645e-01f, 1.61531523e-01f, -1.64685741e-01f,
  -1.69157282e-01f, -3.48741293e-01f, -4.53898162e-02f, 8.00499786e-03f, -1.62170120e-02f, 8.06479231e-02f, 4.71560247e-02f, 9.50143952e-03f, -1.29275963e-01f, -6.67593554e-02f,
  1.34503562e-02f, 2.95948330e-03f, 5.96693121e-02f, -7.90287107e-02f, -1.25649258e-01f, 1.26302570e-01f, -1.76244676e-02f, -9.11654010e-02f, -2.44021639e-01f, -1.87593505e-01f,
  1.94597878e-02f, 8.41420889e-02f, 6.15702057e-03f, -1.69029862e-01f, -2.02361688e-01f, -2.17060335e-02f, 8.50581378e-02f, -4.36745398e-02f, -1.36866674e-01f, -1.76089421e-01f,
  4.30353850e-01f, -5.77829219e-02f, 3.40907365e-01f, 3.25265676e-01f, 2.04815894e-01f, 7.88963959e-02f, 3.25123608e-01f, 2.03589257e-02f, 4.31314379e-01f, -4.57448006e-01f,
  -1.49406239e-01f, 1.29917473e-01f, 1.37784109e-01f, -2.96242267e-01f, 1.97651863e-01f, 4.03928310e-02f, 1.08947054e-01f, 2.09554974e-02f, 1.75808921e-01f, 1.81692187e-02f,
  -2.18486842e-02f, -4.32723552e-01f, -1.19870760e-01f, -4.28090423e-01f, 5.64869978e-02f, -7.02281594e-02f, -3.77813011e-01f, 5.93572445e-02f, -5.61525047e-01f, -5.10662701e-03f,
  6.59035891e-02f, 4.92700599e-02f, -6.13071807e-02f, -1.01521492e-01f, 1.43820476e-02f, 4.10201307e-03f, 1.54760433e-02f, -3.52546647e-02f, 2.13647291e-01f, -1.18909106e-01f,
  -9.90526006e-02f, -6.62711635e-02f, -9.46400911e-02f, -8.07488430e-03f, 1.51503816e-01f, -1.19312078e-01f, 5.78737818e-02f, -1.30573034e-01f, -1.03194728e-01f, -1.51497694e-02f,
  7.42964596e-02f, 6.16117306e-02f, 1.22243285e-01f, 3.99011075e-02f, 4.65223603e-02f, 3.36598493e-02f, -9.76141393e-02f, 1.09042794e-01f, -6.53614849e-02f, 4.53862511e-02f,
  7.89522156e-02f, 4.69683530e-03f, -8.62932429e-02f, -3.06112051e-01f, -2.13418648e-01f, 4.66420799e-02f, -5.28382175e-02f, -1.59480385e-02f, -2.37251185e-02f, -9.82967019e-02f,
  1.13765802e-02f, -1.63395796e-02f, 2.80020069e-02f, 2.01196466e-02f, 4.33278307e-02f, -2.92082369e-01f, -1.89705263e-03f, -9.15177763e-02f, 3.48584689e-02f, -4.11931314e-02f,
  5.31898625e-02f, 5.88380583e-02f, 4.61929105e-02f, 7.35589489e-02f, 2.58386042e-02f, -1.11534903e-02f, -7.81131834e-02f, -2.23216508e-02f, -4.12028022e-02f, -9.79245733e-03f,
  1.66162774e-01f, -7.68676475e-02f, 5.24219647e-02f, -1.11090332e-01f, 4.48576547e-02f, -1.57140374e-01f, 3.34223360e-02f, 1.01133861e-01f, 2.46309251e-01f, -1.23792589e-01f,
  -6.00112863e-02f, 2.33030301e-02f, -1.92166250e-02f, 4.27059866e-02f, 3.52154821e-02f, -7.17782378e-02f, -3.50097716e-02f, -7.49051496e-02f, 9.05726403e-02f, -1.10682145e-01f,
  -1.11787386e-01f, 1.47256449e-01f, 2.24731844e-02f, -8.11554864e-02f, -1.34552903e-02f, 4.96992096e-02f, 8.88348594e-02f, -6.84401393e-02f, -3.60987447e-02f, 5.95326759e-02f,
  1.83646709e-01f, -1.91572055e-01f, -4.74828362e-01f, -9.43697710e-03f, 1.06752463e-01f, 4.85676378e-01f, -5.40929846e-02f, -4.13138978e-02f, -3.32773715e-01f, 1.50802374e-01f,
  1.36999011e-01f, -1.22926146e-01f, -3.40917677e-01f, 5.09495854e-01f, 3.03450197e-01f, -1.02476493e-01f, 2.91837752e-01f, 2.73832023e-01f, -1.48760602e-01f, 4.05703522e-02f,
  8.54515098e-03f, 6.16940856e-01f, -1.38157725e-01f, 3.48805577e-01f, 9.72417891e-02f, -1.01719536e-01f, 1.47576556e-01f, -2.52216399e-01f, 4.40650910e-01f, 1.55824170e-01f,
  7.43422732e-02f, -1.04305737e-01f, -8.74765068e-02f, -6.66851401e-02f, -3.40510271e-02f, 6.23973086e-02f, 4.24511544e-02f, 1.57771595e-02f, -7.72660822e-02f, -3.22197825e-02f,
  2.17326824e-03f, 1.09607074e-02f, -6.56478945e-03f, -1.58135872e-02f, 3.98240313e-02f, -4.06601503e-02f, -8.93735439e-02f, -1.60195217e-01f, -9.59527642e-02f, -1.05358489e-01f,
  -1.90535232e-01f, -5.68568930e-02f, -9.45244655e-02f, -1.12444341e-01f, -1.74522609e-01f, -7.13958144e-02f, 5.27926423e-02f, -1.64701268e-02f, -3.94928232e-02f, 3.16599868e-02f,
  7.30910823e-02f, 1.09344320e-02f, 5.43520115e-02f, 3.71319731e-03f, 8.78724605e-02f, 5.52438162e-02f, 1.07131749e-01f, -6.48502167e-03f, -6.85688183e-02f, 5.13170958e-02f,
  -5.74270077e-02f, 8.78396705e-02f, 1.90706141e-02f, 8.83782879e-02f, 1.45062685e-01f, 5.35008404e-03f, 9.11828056e-02f, -2.24784147e-02f, -1.57369316e-01f, 3.78341675e-02f,
  -1.77183934e-02f, -5.71215339e-02f, 9.72006917e-02f, -5.57050705e-02f, 2.37860158e-02f, -4.85965684e-02f, 2.26371251e-02f, 9.32663959e-03f, -9.77326632e-02f, 9.54691991e-02f,
  2.90200952e-02f, -1.53635457e-01f, -1.14552435e-02f, 1.64811686e-02f, 2.75210515e-02f, 1.18914582e-01f, -3.41489501e-02f, 3.35969515e-02f, -6.01381660e-02f, 3.92606631e-02f,
  1.17201321e-01f, -9.89035219e-02f, 3.83948684e-02f, 2.91376561e-02f, -4.32390533e-02f, 3.33348964e-03f, 1.46227367e-02f, -6.19112477e-02f, -2.09840573e-02f, 1.57645702e-01f,
  -4.24683802e-02f, -4.54436764e-02f, -3.34046781e-02f, -3.42497192e-02f, -4.49163519e-04f, -1.18222609e-01f, 9.52894092e-02f, 1.12282881e-03f, 6.25133514e-04f, -3.60366702e-02f,
  -1.99828044e-01f, 4.42524612e-01f, 1.50569901e-01f, -1.97958648e-01f, 1.70752600e-01f, -1.14484191e-01f, -2.42070466e-01f, 7.52471536e-02f, 2.85385340e-01f, -1.17130354e-02f,
  -1.82741806e-01f, 3.40405762e-01f, 1.20352387e-01f, -1.80878446e-01f, -5.26917391e-02f, 8.94460827e-02f, -2.74342179e-01f, -1.06388465e-01f, 3.89002442e-01f, -9.87837687e-02f,
  -1.11691236e-01f, -1.95076659e-01f, -2.78022528e-01f, -2.32578404e-02f, -1.86600283e-01f, 6.96537420e-02f, -4.05010760e-01f, 1.28662184e-01f, -2.21245065e-01f, 1.95568368e-01f,
  -2.32084110e-01f, -1.07095623e-02f, -4.84901220e-02f, 1.65206734e-02f, -8.30379277e-02f, 4.98173237e-02f, -2.76317060e-01f, 1.28726035e-01f, 1.31794348e-01f, 6.47075921e-02f,
  1.27586499e-01f, -3.84983793e-02f, -3.88433561e-02f, 1.00773141e-01f, 3.29753868e-02f, -2.59593897e-03f, 4.28257361e-02f, -4.31112796e-02f, 2.33282581e-01f, 4.58108597e-02f,
  6.22643456e-02f, 7.57989958e-02f, -2.24193603e-01f, -6.32545203e-02f, -2.33089477e-02f, 7.68663287e-02f, -1.82627086e-02f, -4.56147641e-02f, -1.43067613e-02f, 1.05723433e-01f,
  5.90138584e-02f, 5.56663573e-02f, 6.42896816e-02f, 5.84953763e-02f, 9.06834453e-02f, 4.13721241e-02f, -3.25467810e-02f, -1.62698269e-01f, 3.08949370e-02f, -3.11901122e-02f,
  -1.02036282e-01f, 6.42494485e-02f, -9.44049358e-02f, -6.23149574e-02f, -1.25776187e-01f, 4.74617109e-02f, -2.97332313e-02f, -3.06808352e-02f, -7.53002092e-02f, -8.43513012e-02f,
  -2.91933883e-02f, -8.52648094e-02f, 2.54895687e-02f, -1.85407430e-01f, 1.12264842e-01f, 1.00197732e-01f, -1.10505424e-01f, 1.05053440e-01f, -7.98666403e-02f, -1.13940910e-01f,
  -1.66105092e-01f, -2.21617565e-01f, 4.14267518e-02f, 9.41183791e-02f, -9.64426156e-03f, -8.66189376e-02f, 7.53425658e-02f, 4.43932451e-02f, 1.34493232e-01f, 6.48450330e-02f,
  9.46168900e-02f, -2.20340058e-01f, -9.70954150e-02f, 5.85756376e-02f, 4.50271145e-02f, -1.68007404e-01f, -1.50741756e-01f, 4.53842394e-02f, -5.36226593e-02f, 9.25728753e-02f,
  -8.01435784e-02f, -3.02058198e-02f, 1.92399544e-03f, -1.34652346e-01f, -1.91884026e-01f, -1.09121673e-01f, -3.09764538e-02f, 6.24272451e-02f, 5.70012890e-02f, -3.90869193e-02f,
  -8.27653170e-01f, 5.43276429e-01f, 9.01697129e-02f, -3.13478976e-01f, 6.75515607e-02f, 2.06828311e-01f, -5.79700582e-02f, 5.52210733e-02f, -1.83445215e-01f, 6.05427623e-02f,
  -7.94578344e-02f, -3.00679594e-01f, 3.05633005e-02f, 1.97415248e-01f, -5.52725643e-02f, 2.48968333e-01f, 1.25710880e-02f, -1.38798967e-01f, 1.16628610e-01f, 3.06150187e-02f,
  5.17682321e-02f, 1.04908086e-01f, 1.71957508e-01f, 3.60359311e-01f, -3.45546417e-02f, -1.56212956e-01f, -2.03866810e-01f, 8.55390206e-02f, -9.46321525e-03f, 3.21702063e-02f,
  -1.40703037e-01f, -3.78660858e-01f, -2.28460982e-01f, -1.06966347e-01f, -1.34877875e-01f, -7.91107863e-02f, -1.60241872e-01f, -1.31494999e-01f, -8.38065818e-02f, 8.75632465e-03f,
  -1.01001658e-01f, 5.95992990e-02f, -2.94555556e-02f, -1.81141272e-02f, -9.56450626e-02f, -6.55263886e-02f, 2.00517356e-01f, 7.90767148e-02f, 3.45741212e-02f, 2.07317889e-01f,
  1.63715526e-01f, 8.28873888e-02f, 2.98148543e-02f, 9.16112736e-02f, 1.59548238e-01f, -4.89897430e-02f, 6.19514938e-03f, 6.15831092e-02f, 2.88507203e-04f, 4.67598811e-02f,
  4.92311381e-02f, 8.19801912e-03f, -1.10403247e-01f, -1.71734452e-01f, -8.69702250e-02f, -9.69186500e-02f, -7.24457279e-02f, -8.89194310e-02f, -7.91083649e-02f, 4.74088863e-02f,
  -1.59926675e-02f, -1.05066873e-01f, -9.58217308e-02f, -5.28295375e-02f, 4.58852714e-03f, -9.87615585e-02f, -1.02947049e-01f, -4.04159501e-02f, 7.73532018e-02f, -1.76409781e-02f,
  -1.24276336e-02f, 1.11365102e-01f, 6.77377731e-03f, 5.65154012e-03f, -9.91492122e-02f, -3.21799703e-03f, 4.45499755e-02f, 1.41604394e-01f, 3.09127253e-02f, 3.05689387e-02f,
  -2.47573182e-01f, -2.15201572e-01f, -1.41064703e-01f, -1.74120277e-01f, -9.68525559e-02f, 2.62823584e-03f, 5.14941178e-02f, -6.91588446e-02f, -2.80824117e-02f, -8.85142758e-03f,
  -5.93441445e-03f, -4.64735776e-02f, 7.68411607e-02f, -3.98893841e-02f, 1.03314660e-01f, -4.05727774e-02f, -1.27922133e-01f, -1.31168012e-02f, -1.76244929e-01f, -3.35406214e-02f,
  -2.06495643e-01f, -7.67875165e-02f, 1.62575379e-01f, 9.07820910e-02f, -3.07910480e-02f, -2.04770014e-01f, -8.78556669e-02f, -2.75154933e-02f, -1.41894780e-02f, 1.01912111e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 26)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 26;
const float L0_fan_Bp_bar_data[] = {
  2.78900146e-01f, 2.72075117e-01f, 4.25917000e-01f, 2.84446388e-01f, 4.82967794e-01f, 4.68145758e-01f, 2.31112987e-01f, 2.92821497e-01f, 9.99461487e-02f, 3.56292874e-01f,
  3.61305028e-01f, 2.78437316e-01f, 2.73392707e-01f, 2.05078483e-01f, 4.35282707e-01f, 5.82978874e-02f, 3.14120144e-01f, 1.69933066e-01f, 3.49776268e-01f, 2.73297429e-01f,
  2.21494570e-01f, 2.52449125e-01f, 4.41821903e-01f, 1.53747678e-01f, 3.93156707e-01f, 2.49302134e-01f
};

// L1_fan_Wp (Shape: 3 x 32)
const int L1_fan_Wp_rows = 3;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  -1.50202140e-01f, 2.34954692e-02f, -2.72618700e-02f, -3.29372473e-02f, 3.64679247e-02f, -2.67375171e-01f, 3.95841636e-02f, -3.02623492e-02f, 1.51272520e-01f, -2.04620257e-01f,
  -1.12349302e-01f, 1.81318700e-01f, 2.45701909e-01f, 9.34695899e-02f, -2.01438636e-01f, 2.87756383e-01f, -2.36877501e-01f, -6.01510182e-02f, 1.33942991e-01f, -3.33476216e-02f,
  1.31642058e-01f, -1.59528151e-01f, -5.11012338e-02f, -3.21566820e-01f, -2.47384861e-01f, 1.08697541e-01f, -1.15271196e-01f, -1.52435407e-01f, -4.15075868e-02f, 2.82627702e-01f,
  -1.57300457e-01f, -1.40458986e-01f, -3.08769405e-01f, -1.35156244e-01f, 6.68858439e-02f, 3.18403572e-01f, 5.65491244e-02f, -3.42502929e-02f, 4.66066338e-02f, 1.93252899e-02f,
  -1.88232124e-01f, -2.25241765e-01f, -2.87402511e-01f, 2.06358761e-01f, 7.36936554e-02f, -1.81584731e-02f, 1.07764885e-01f, -1.31622866e-01f, 1.75141305e-01f, 7.85876065e-02f,
  1.01082847e-01f, 7.11549446e-02f, -3.28002907e-02f, 1.50178403e-01f, -9.24589932e-02f, 3.15654278e-01f, 7.11820498e-02f, 1.15892939e-01f, 2.69778967e-02f, -3.15928161e-01f,
  4.36524600e-02f, 3.69603783e-01f, -1.29983768e-01f, -3.10021937e-01f, -2.79060043e-02f, 2.71065682e-01f, 1.71952248e-01f, 9.26631987e-02f, 1.38667598e-01f, -2.80910045e-01f,
  -1.54652193e-01f, -1.23854086e-01f, 1.99865833e-01f, -2.68476337e-01f, -2.56292075e-01f, 2.13360444e-01f, -8.63261446e-02f, -1.20936111e-02f, 1.71072641e-03f, 2.60090530e-01f,
  1.29977867e-01f, 2.45208800e-01f, 3.57789636e-01f, -1.37823913e-02f, -1.26131445e-01f, -1.96459107e-02f, -1.74168855e-01f, -1.81762382e-01f, 1.79057978e-02f, -1.43733427e-01f,
  -2.15390086e-01f, 9.11638886e-02f, 1.77379802e-01f, -1.80115223e-01f, -5.80388047e-02f, -7.67763108e-02f
};

// L1_fan_Wp_bar (Shape: 26 x 32)
const int L1_fan_Wp_bar_rows = 26;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  3.20101827e-01f, 5.31443916e-02f, 1.50304094e-01f, 4.74722296e-01f, -4.28558052e-01f, 3.11082482e-01f, -1.79723516e-01f, -4.30777937e-01f, -1.40831947e-01f, -7.93501213e-02f,
  3.19569886e-01f, -1.90603614e-01f, 1.18385658e-01f, 2.75520653e-01f, 1.53546870e-01f, 2.04504550e-01f, -6.05420545e-02f, 1.93087369e-01f, 6.13147855e-01f, 4.91453230e-01f,
  -1.44189838e-02f, 3.17071110e-01f, 6.08044684e-01f, 1.45123139e-01f, -3.66820335e-01f, 2.68714160e-01f, -1.77795485e-01f, 2.75386777e-02f, 2.15631593e-02f, 4.82672565e-02f,
  2.60255247e-01f, -6.50160667e-03f, -3.56560051e-02f, -1.08541474e-01f, 1.82702437e-01f, -2.48661250e-01f, 1.44262686e-01f, -1.69186704e-02f, 4.16258633e-01f, 2.06659511e-01f,
  -4.41235930e-01f, 4.59519476e-01f, 1.30956271e-03f, 3.86051714e-01f, 3.34679723e-01f, -3.29061598e-01f, -2.84771454e-02f, -4.10861164e-01f, 2.80115217e-01f, -1.26017123e-01f,
  -2.01755017e-01f, 4.07620490e-01f, 6.35357797e-01f, 2.96414256e-01f, -9.47046056e-02f, 2.97189742e-01f, 5.15319943e-01f, 2.45027184e-01f, -2.46889532e-01f, -3.80411953e-01f,
  1.29594177e-01f, -1.93010867e-01f, 2.94399053e-01f, 3.02606225e-01f, 4.19607818e-01f, 6.40483201e-02f, 1.92025498e-01f, -7.36127272e-02f, 2.33230174e-01f, -5.69133043e-01f,
  -4.40613151e-01f, 1.24571584e-01f, 6.11891150e-01f, -7.66524300e-02f, -1.62271351e-01f, 3.54316264e-01f, -2.90349156e-01f, -9.10977200e-02f, 1.52040139e-01f, 2.97157288e-01f,
  2.15633422e-01f, 5.93380034e-01f, 5.50175495e-02f, 1.33310959e-01f, 2.62413681e-01f, 7.38124624e-02f, 3.72414917e-01f, -2.36450896e-01f, 9.61456224e-02f, -3.29424888e-01f,
  3.31081301e-01f, 2.57239580e-01f, 6.71061039e-01f, -9.17523429e-02f, 1.09056629e-01f, -3.30666840e-01f, 5.84641099e-02f, 3.25683594e-01f, 1.16654120e-01f, -4.13194835e-01f,
  3.69272321e-01f, -4.52132560e-02f, 1.81692898e-01f, 4.38398629e-01f, 4.91164386e-01f, 3.57382894e-02f, 4.81425166e-01f, 3.07021677e-01f, -1.76732242e-01f, 1.10742606e-01f,
  -3.20326149e-01f, 6.21610701e-01f, 3.89679670e-01f, -3.64644885e-01f, -5.21064699e-02f, -3.71242672e-01f, -2.37345800e-01f, -3.31354320e-01f, -4.90228295e-01f, 1.13957010e-01f,
  4.29328620e-01f, -2.25449488e-01f, 4.82465684e-01f, 2.63391972e-01f, 2.20130220e-01f, 4.44851100e-01f, 2.08609775e-01f, 3.39853078e-01f, 3.72051150e-02f, 9.85649154e-02f,
  2.32245997e-01f, -1.60406992e-01f, 1.65315449e-01f, 4.35485005e-01f, 1.39342934e-01f, 3.34249496e-01f, -1.77657962e-01f, 3.98225397e-01f, 4.42103177e-01f, -3.57931033e-02f,
  -2.01471210e-01f, 1.55179366e-01f, -1.67110085e-01f, -1.90985486e-01f, 5.64381540e-01f, 6.67607561e-02f, -1.97263956e-01f, -1.67449787e-01f, -7.91226700e-02f, 1.00433186e-01f,
  3.32662642e-01f, 3.62160921e-01f, 5.79701900e-01f, -2.19919652e-01f, -2.13609431e-02f, 2.45966122e-01f, 2.31091142e-01f, -1.39416367e-01f, 3.70854616e-01f, 4.56821099e-02f,
  1.69903919e-01f, 2.17416242e-01f, 1.54737100e-01f, 1.79376200e-01f, -1.59781948e-01f, 1.24634154e-01f, 1.16116136e-01f, -7.40001053e-02f, 8.19658712e-02f, 4.03749615e-01f,
  3.93048167e-01f, -3.24446559e-01f, 2.12037489e-01f, -2.79661447e-01f, 5.69091260e-01f, -1.99549124e-01f, -2.13225737e-01f, 1.75088719e-01f, 1.04218960e-01f, -1.13102511e-01f,
  3.46223682e-01f, -1.06845267e-01f, -1.52851149e-01f, 5.58998510e-02f, 1.17415816e-01f, 3.78934354e-01f, 7.43878409e-02f, 9.32099372e-02f, 5.66475242e-02f, -3.06752175e-01f,
  8.25599581e-02f, 5.62790036e-01f, 1.75261959e-01f, 8.92131999e-02f, 2.29365841e-01f, -2.89130628e-01f, 1.19934998e-01f, -3.40941399e-01f, 1.58962220e-01f, 3.69382083e-01f,
  1.46504849e-01f, -2.11185962e-01f, -3.54843348e-01f, 5.74629664e-01f, 1.35226846e-01f, 9.61023793e-02f, -1.56399757e-01f, 3.50702196e-01f, 1.94154456e-01f, -2.62288511e-01f,
  2.04219341e-01f, 1.57656938e-01f, 4.28559393e-01f, -3.58360223e-02f, -2.02698231e-01f, -1.39547482e-01f, 5.22496283e-01f, 2.32022554e-02f, 1.91867828e-01f, -1.44635171e-01f,
  5.48569560e-01f, -6.25175834e-02f, 3.74120995e-02f, -2.00098157e-01f, 1.22286685e-01f, 1.76811382e-01f, 1.29793314e-02f, -9.86383483e-02f, -1.98732406e-01f, 2.21549928e-01f,
  -3.33788544e-02f, -1.84833556e-01f, 1.64922297e-01f, -3.83813411e-01f, 1.61410451e-01f, 1.79111451e-01f, 3.54617327e-01f, 1.64438203e-01f, -3.06743115e-01f, 5.27782202e-01f,
  -7.99487904e-02f, -1.72662288e-01f, 3.85770530e-01f, 5.92712820e-01f, 1.30883694e-01f, 8.88736993e-02f, 4.83924389e-01f, -4.91819829e-02f, -2.83681929e-01f, 5.03561556e-01f,
  -3.04825991e-01f, 1.49310350e-01f, 1.51051000e-01f, 6.76883832e-02f, -8.09654593e-02f, -1.30521487e-02f, 2.52026051e-01f, 1.36575833e-01f, 1.17252916e-01f, -2.71327853e-01f,
  3.18825275e-01f, -2.30319872e-01f, 3.96272808e-01f, 4.77763563e-01f, 2.85890520e-01f, -3.72797856e-03f, 9.57804546e-02f, 2.07781032e-01f, 1.96763545e-01f, 8.06391090e-02f,
  -1.77247971e-01f, 2.62583017e-01f, 1.67854458e-01f, -3.24265778e-01f, -1.73285589e-01f, -8.46851766e-02f, 2.93171048e-01f, -1.56505421e-01f, -2.45019555e-01f, -1.96609512e-01f,
  3.21165949e-01f, 1.69909045e-01f, 4.25631732e-01f, -8.23406428e-02f, 3.98190282e-02f, 2.84727842e-01f, -8.27950165e-02f, 1.85939491e-01f, -1.05931610e-01f, 9.26562324e-02f,
  2.53011674e-01f, 6.97382241e-02f, -2.97544505e-02f, 4.25151400e-02f, 2.37308621e-01f, -5.49682342e-02f, 1.15875207e-01f, -3.14205587e-01f, -1.97470114e-01f, -5.59041742e-04f,
  1.71324998e-01f, 2.39684388e-01f, 4.44480240e-01f, 4.10761625e-01f, 3.69949996e-01f, -8.06365982e-02f, 2.22817197e-01f, 7.54044205e-02f, 1.13033049e-01f, 2.15333104e-01f,
  -3.67809772e-01f, 2.37043932e-01f, 4.49660160e-02f, -1.36003852e-01f, 4.71275777e-01f, -2.30241179e-01f, 6.85095564e-02f, 2.10882366e-01f, 2.24811941e-01f, 2.43593112e-01f,
  -1.22311786e-01f, 4.81232442e-02f, -1.17383733e-01f, -2.51892209e-01f, 1.84221044e-01f, -4.67262000e-01f, -3.35762680e-01f, -4.81278539e-01f, 6.48744702e-01f, 1.93699196e-01f,
  7.40910172e-02f, 1.94066718e-01f, -1.77390948e-01f, -2.12600514e-01f, 5.33385754e-01f, 4.12380636e-01f, 3.20019126e-01f, 2.40544096e-01f, 1.43755525e-01f, 4.70764101e-01f,
  -4.77963947e-02f, 3.98224115e-01f, 1.06371783e-01f, 2.22055435e-01f, -1.47985131e-01f, -1.09894015e-01f, -1.43905565e-01f, 5.55357218e-01f, 3.90934497e-01f, -4.72427607e-01f,
  3.74264240e-01f, 9.33325738e-02f, 1.09304778e-01f, 1.40178904e-01f, 2.34776065e-01f, -3.17010373e-01f, 6.03155941e-02f, -3.14150423e-01f, -1.97851524e-01f, -3.94844275e-04f,
  2.05278099e-01f, -4.14177716e-01f, -3.44599664e-01f, 4.54586774e-01f, -1.76602408e-01f, -1.71218172e-01f, -3.19338255e-02f, 2.87021101e-01f, 4.26901579e-01f, 5.25601842e-02f,
  1.63105488e-01f, 1.85222670e-01f, 2.34269038e-01f, 5.26253045e-01f, 8.63358453e-02f, 7.14836782e-03f, 4.26064759e-01f, -1.27114624e-01f, -1.05709277e-01f, -8.55535418e-02f,
  6.52573526e-01f, -4.98161942e-01f, 2.84210622e-01f, -1.52000025e-01f, 1.17688574e-01f, 1.66929618e-01f, -1.71758205e-01f, 4.20733206e-02f, -2.43085623e-01f, 2.94018775e-01f,
  1.61700144e-01f, 2.08055213e-01f, 1.14343822e-01f, 5.38452923e-01f, 8.69552791e-01f, -3.64670843e-01f, 1.21963806e-01f, 1.57077968e-01f, -2.22275198e-01f, -3.15755874e-01f,
  -1.32727832e-01f, 2.25792095e-01f, -2.78472960e-01f, 2.39994660e-01f, 1.64943740e-01f, 1.95932910e-01f, 6.66130483e-01f, -3.26298505e-01f, -1.30378120e-02f, 5.34905851e-01f,
  -1.25581160e-01f, 3.25368851e-01f, -1.95600986e-01f, 1.23723604e-01f, 2.39443079e-01f, 3.67639512e-01f, 1.08833969e-01f, 2.28340223e-01f, 2.57664770e-01f, 2.33125404e-01f,
  1.94862545e-01f, -3.38439673e-01f, 2.46769756e-01f, -2.86678523e-01f, 1.59728304e-01f, 4.81684744e-01f, -2.34854728e-01f, -1.21550806e-01f, 3.79954934e-01f, 1.83247346e-02f,
  -3.83450031e-01f, 2.63167232e-01f, 3.17159854e-02f, 3.16094726e-01f, 5.53410828e-01f, -1.88135937e-01f, 4.55771983e-01f, 4.76035774e-02f, -5.26427887e-02f, -2.55453169e-01f,
  -2.25424990e-01f, 1.07268177e-01f, -9.96647403e-02f, 2.87176877e-01f, -1.83479544e-02f, 2.56051153e-01f, 2.07477227e-01f, 2.62537330e-01f, 2.13120490e-01f, 2.43963644e-01f,
  4.71580893e-01f, 4.38206673e-01f, 2.85128981e-01f, -3.33876580e-01f, -1.90727592e-01f, 1.23790488e-01f, 1.09998539e-01f, 2.36887753e-01f, -5.32269239e-01f, 2.08829641e-01f,
  -1.77384421e-01f, 2.20536917e-01f, 4.60644633e-01f, 2.55016655e-01f, -4.43801582e-02f, 6.13814771e-01f, 3.58434647e-01f, -3.65023240e-02f, 1.74031965e-02f, -1.62796766e-01f,
  -4.97461595e-02f, 2.82742441e-01f, 5.29954880e-02f, -3.04660410e-01f, 5.88850677e-01f, 1.50943354e-01f, 4.93102700e-01f, 2.46679112e-01f, 1.91181168e-01f, -2.30009675e-01f,
  8.31292644e-02f, 1.88984275e-01f, 1.99560705e-03f, 1.19451329e-01f, -2.84376647e-02f, -2.87558377e-01f, 1.01126499e-01f, -4.57539231e-01f, 2.26499230e-01f, 4.33106363e-01f,
  -1.26054510e-01f, 2.61993296e-02f, 5.16946912e-01f, -2.30909541e-01f, 5.99301383e-02f, 4.53445941e-01f, -1.00072455e-02f, 3.11366528e-01f, 6.44630790e-01f, 3.69691700e-01f,
  3.85774702e-01f, 1.36304826e-01f, -2.34490722e-01f, 1.00569492e-02f, -2.97385752e-01f, 3.02619994e-01f, -1.97031021e-01f, 4.61840004e-01f, 1.24033585e-01f, -1.69332668e-01f,
  3.80288064e-01f, 4.53134596e-01f, 1.86530784e-01f, 1.01795539e-01f, 1.31193057e-01f, 3.07782382e-01f, -2.63049334e-01f, 3.38925213e-01f, 2.39393249e-01f, 5.61560154e-01f,
  -2.16215730e-01f, -2.57898629e-01f, 1.28883928e-01f, 3.97083610e-01f, -1.83415262e-03f, 3.95149976e-01f, 4.14495587e-01f, -2.44373437e-02f, -5.56609556e-02f, 1.73869833e-01f,
  -1.98604599e-01f, -2.09151044e-01f, -3.40713024e-01f, -3.30972135e-01f, 2.57325351e-01f, 4.45364714e-01f, 3.91916752e-01f, 6.41023442e-02f, 1.08184502e-01f, -1.93507206e-02f,
  2.59716183e-01f, -1.05709359e-02f, -3.02431613e-01f, -1.98452637e-01f, -4.57017906e-02f, 1.27701178e-01f, 7.69029409e-02f, -4.48988438e-01f, 2.41929114e-01f, 1.88436899e-02f,
  1.03228658e-01f, 1.71426192e-01f, 5.55623882e-02f, 8.05767700e-02f, 2.49897718e-01f, 2.39723086e-01f, 2.83405304e-01f, -3.01404297e-01f, 6.43701673e-01f, -1.03648864e-01f,
  4.21886176e-01f, -3.89802866e-02f, -1.85214326e-01f, -1.20777585e-01f, 4.30065006e-01f, 3.56748819e-01f, -1.72930285e-01f, 1.65807619e-03f, 4.87937719e-01f, -5.43666333e-02f,
  -6.93574622e-02f, -1.12129688e-01f, 1.99913085e-01f, -2.97989875e-01f, 3.08173627e-01f, 3.06140006e-01f, 2.62465417e-01f, 3.13053310e-01f, 8.45298544e-02f, 4.06309932e-01f,
  -2.42945880e-01f, 3.68796110e-01f, 1.36337578e-02f, 1.36150032e-01f, 3.26760262e-01f, -5.43293834e-01f, 2.89678723e-01f, -1.78684201e-02f, -1.06473953e-01f, 5.24973333e-01f,
  3.41413230e-01f, 4.38484728e-01f, -7.30680227e-02f, 1.54776022e-01f, 2.70407438e-01f, -1.39477521e-01f, -6.15164578e-01f, -3.28393757e-01f, 3.03842932e-01f, -5.64604215e-02f,
  -2.55066246e-01f, -3.84175740e-02f, 5.22183299e-01f, -6.33569956e-02f, -1.68870822e-01f, 4.04291213e-01f, -2.38016725e-01f, -1.28403202e-01f, 4.62250203e-01f, 2.21556604e-01f,
  -5.45788407e-02f, -2.08426472e-02f, -9.12126526e-02f, -9.79506597e-02f, -1.49562791e-01f, -7.35811330e-03f, 5.31002462e-01f, 4.00893509e-01f, 5.47657073e-01f, -2.20374793e-01f,
  -1.93882912e-01f, 1.37311697e-01f, 3.13859940e-01f, 1.50772840e-01f, -9.71982479e-02f, 4.54966128e-01f, -9.97726694e-02f, 1.01513848e-01f, -3.70379118e-03f, 1.87560216e-01f,
  4.22723144e-01f, -3.20726126e-01f, -3.18917595e-02f, 6.44146372e-03f, 2.42913350e-01f, 4.77322727e-01f, 2.70973325e-01f, 2.76529863e-02f, 4.87548143e-01f, 1.55857921e-01f,
  -3.92772928e-02f, -4.37790640e-02f, -8.23838785e-02f, -4.25169826e-01f, 1.84799835e-01f, -6.23426288e-02f, -2.93244105e-02f, 1.18588477e-01f, 3.41095954e-01f, 4.35452700e-01f,
  2.91635185e-01f, 1.40905693e-01f, -2.99659997e-01f, -1.52196720e-01f, -1.76688462e-01f, -1.75059475e-02f, 3.81642878e-01f, 9.18250356e-04f, -3.08519602e-01f, 2.86146492e-01f,
  -2.19383106e-01f, 1.95501119e-01f, -5.09582274e-03f, 3.19909930e-01f, 2.82996953e-01f, -3.31481956e-02f, -1.20363459e-01f, 3.88137400e-01f, 2.01713160e-01f, -4.48248208e-01f,
  4.84496117e-01f, 1.27024710e-01f, -7.70601183e-02f, 1.65705457e-01f, 1.08137690e-01f, 2.89210707e-01f, -1.74912825e-01f, -9.66047123e-02f, 4.22641754e-01f, 2.33112555e-02f,
  2.99749315e-01f, -1.86515540e-01f, 1.49235046e-02f, 6.17793687e-02f, 5.51657200e-01f, 4.79079664e-01f, 3.97479683e-01f, 3.10921669e-01f, -3.44905742e-02f, 7.11766630e-02f,
  3.07839721e-01f, -5.86387850e-02f, 1.77537836e-02f, -2.47853026e-01f, -1.66196555e-01f, 1.40219331e-01f, -3.56260210e-01f, 2.05503166e-01f, 4.51999605e-01f, -1.13128297e-01f,
  -3.23461384e-01f, 5.76385319e-01f, -2.75966376e-01f, 2.73948044e-01f, 5.08304238e-02f, 1.59321323e-01f, 6.29339218e-02f, 4.86174561e-02f, -1.67006135e-01f, 1.07986569e-01f,
  4.14405763e-01f, 4.81774844e-02f, -3.54994178e-01f, 3.68619710e-01f, 3.41176689e-01f, -3.74058448e-02f, 3.97114784e-01f, -1.21145144e-01f, -3.86042967e-02f, -1.04995437e-01f,
  1.64363146e-01f, -1.31634817e-01f, 3.50579679e-01f, 3.59006137e-01f, 5.50491869e-01f, 2.84787625e-01f, -1.67748518e-02f, 3.94268125e-01f, 8.24034065e-02f, 5.01428723e-01f,
  -2.20713377e-01f, -1.52239963e-01f, -1.92682445e-01f, 1.22284129e-01f, 2.18742520e-01f, 3.77128571e-01f, 4.32176560e-01f, 3.22764397e-01f, 2.44559929e-01f, -8.70907083e-02f,
  -1.34257525e-01f, 6.00433089e-02f, -1.22302338e-01f, 1.99814856e-01f, 2.21868902e-01f, -9.84792635e-02f, 1.47757873e-01f, 4.83101070e-01f, -9.91368443e-02f, -1.30229034e-02f,
  2.35368669e-01f, 3.09889764e-01f, 1.38735339e-01f, 2.70062149e-01f, 2.10534304e-01f, -3.65072310e-01f, 2.88774252e-01f, -2.37921417e-01f, 4.13448572e-01f, -1.09583795e-01f,
  5.26354015e-01f, -2.28469953e-01f, -1.80547297e-01f, 4.01865631e-01f, 6.47496283e-01f, -4.05996799e-01f, -1.60692975e-01f, 2.90556829e-02f, -1.42489120e-01f, 1.27657577e-01f,
  2.14974478e-01f, 2.34481648e-01f, -6.63142800e-02f, 1.38418436e-01f, 5.82795858e-01f, 1.72093108e-01f, -3.30756962e-01f, 6.65870681e-02f, -2.87600011e-01f, 1.91556424e-01f,
  6.48498416e-01f, 3.00780684e-01f, -2.29861677e-01f, 9.42081660e-02f, 1.98324263e-01f, -2.24573851e-01f, 4.31984603e-01f, -5.56003414e-02f, 2.84547180e-01f, -2.06823692e-01f,
  -2.32506871e-01f, 3.35077524e-01f, 1.16347320e-01f, 3.98506790e-01f, 1.77176565e-01f, -1.92513481e-01f, -2.35341161e-01f, 3.72889012e-01f, -2.17506185e-01f, 2.43148014e-01f,
  1.01502784e-01f, 1.41630009e-01f, 2.39882767e-01f, 2.27744788e-01f, -3.76193494e-01f, 3.75337303e-01f, 2.86098011e-02f, -2.73345709e-01f, -1.97236046e-01f, -2.52081513e-01f,
  -3.35627072e-03f, -1.69441432e-01f, -1.00966133e-01f, 2.84551322e-01f, -1.99435622e-01f, 3.32278132e-01f, 1.80740550e-01f, -1.43953025e-01f, 5.62107205e-01f, 3.27384174e-01f,
  7.58915320e-02f, 3.45217615e-01f, 1.52699605e-01f, 2.86266625e-01f, -4.05650735e-02f, 2.79507041e-01f, -8.30256343e-02f, -2.90261358e-01f, 1.74676672e-01f, 1.15697674e-01f,
  3.65649611e-01f, -1.10439602e-02f
};

// L1_fan_Bp_bar (Shape: 1 x 26)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 26;
const float L1_fan_Bp_bar_data[] = {
  1.10032685e-01f, 2.22853675e-01f, 1.49208158e-01f, 1.09755479e-01f, 1.40180439e-01f, 5.69485873e-02f, 2.45937198e-01f, 2.31736615e-01f, 1.06657766e-01f, 1.64758965e-01f,
  9.88648273e-03f, 3.58837307e-04f, 1.80757865e-01f, 6.48376271e-02f, 1.29218295e-01f, 4.60724756e-02f, 3.01001191e-01f, 1.17114648e-01f, 1.38017818e-01f, 1.61844209e-01f,
  -3.08896918e-02f, 2.18781933e-01f, 6.70531318e-02f, 2.80178636e-01f, 1.64789170e-01f, 7.95007348e-02f
};

// L2_linear_W (Shape: 12 x 32)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 32;
const float L2_linear_W_data[] = {
  -1.47622347e-01f, 1.31526247e-01f, 1.65648654e-01f, 4.49908644e-01f, 3.63628030e-01f, -4.46833074e-01f, -1.85420334e-01f, 4.10611302e-01f, -5.79170346e-01f, -7.09531963e-01f,
  -6.92984581e-01f, 8.07946324e-02f, 2.31900762e-04f, 3.08439553e-01f, 1.66310519e-01f, -6.49412721e-02f, -5.03713310e-01f, -4.95513082e-01f, 1.87417418e-01f, 2.21039191e-01f,
  -7.30661809e-01f, 2.36669302e-01f, -2.91852951e-01f, -5.48530221e-02f, -5.73832154e-01f, -6.17774665e-01f, -4.81336474e-01f, 3.30502152e-01f, 3.72262418e-01f, -4.62570757e-01f,
  5.15057981e-01f, -1.87693581e-01f, -2.47069392e-02f, -3.25144410e-01f, 2.67309742e-03f, -7.69166276e-02f, 1.97603345e-01f, 2.64878511e-01f, 1.39197126e-01f, -4.57718641e-01f,
  -7.24142849e-01f, 1.92547888e-02f, 1.65173024e-01f, -2.98749328e-01f, -9.60916057e-02f, 2.02145800e-01f, -7.76653141e-02f, 3.13674957e-01f, -4.25260514e-01f, -6.72785044e-01f,
  -6.76489711e-01f, 2.47291893e-01f, 1.07105210e-01f, 2.63652727e-02f, 1.20430619e-01f, -9.08496022e-01f, 4.19328839e-01f, -6.56838655e-01f, -9.49990153e-02f, 4.43896443e-01f,
  -8.56907014e-03f, -4.12794739e-01f, 5.43950617e-01f, 4.73578572e-01f, -1.73232947e-02f, 1.12026244e-01f, 1.17130853e-01f, 2.87436187e-01f, 1.90147310e-01f, -4.64831382e-01f,
  -6.53473079e-01f, -2.74572760e-01f, 3.10704619e-01f, 4.55365270e-01f, -4.53073680e-01f, -4.46447134e-01f, 2.29690284e-01f, -3.48346949e-01f, 5.16287982e-01f, 1.92477837e-01f,
  -5.43589175e-01f, -5.89530945e-01f, 2.77328659e-02f, 9.37941372e-02f, 2.57447511e-01f, -7.35447824e-01f, -2.36169979e-01f, -4.11343247e-01f, 2.72472113e-01f, 2.12943152e-01f,
  -5.01029193e-01f, 3.46509218e-01f, -7.09878147e-01f, -4.51815575e-01f, -9.95408446e-02f, -3.19721788e-01f, -3.52325648e-01f, 4.00073314e-03f, -3.06396157e-01f, -1.17000490e-01f,
  -7.73525909e-02f, -2.44600214e-02f, 2.74408996e-01f, 1.99882820e-01f, -6.42106891e-01f, -3.68104488e-01f, 2.60599088e-02f, 3.13013792e-01f, -7.24834025e-01f, 1.67725310e-01f,
  -1.85115471e-01f, -6.34934843e-01f, 9.98763368e-02f, -6.92671478e-01f, 4.86893833e-01f, -1.89585969e-01f, -5.42836547e-01f, 1.84987292e-01f, -3.57387811e-01f, -1.60011649e-01f,
  -5.98451912e-01f, 3.13146144e-01f, 3.06355715e-01f, -6.61024332e-01f, 3.48492384e-01f, -6.50692344e-01f, -6.63954437e-01f, 1.75737962e-01f, -1.03796080e-01f, -8.33903551e-02f,
  1.92941368e-01f, -5.76755106e-01f, -6.19832277e-01f, -4.64106321e-01f, -5.04593372e-01f, 2.97038734e-01f, -6.26116931e-01f, 4.48566347e-01f, 3.34533155e-01f, 4.18985575e-01f,
  -2.52201557e-01f, -4.91566986e-01f, 2.33713955e-01f, 1.61433518e-01f, -1.52962714e-01f, -3.94257993e-01f, 9.02984068e-02f, 1.91132315e-02f, -4.61496055e-01f, -1.10338191e-02f,
  -3.63533385e-02f, 4.71584529e-01f, -2.23749354e-01f, 6.56154603e-02f, 1.08671747e-01f, -9.57593918e-02f, 1.23348974e-01f, 1.11652054e-01f, 3.24795283e-02f, -1.41875952e-01f,
  1.08153984e-01f, 1.95220605e-01f, -3.62407595e-01f, 4.97882485e-01f, -1.21767782e-01f, 3.55316490e-01f, 1.33249596e-01f, 8.75392482e-02f, 2.80858845e-01f, -3.96821409e-01f,
  -7.36657917e-01f, -4.60144430e-02f, 2.53612816e-01f, 2.99311697e-01f, -1.04438737e-01f, 1.10438935e-01f, 6.88595772e-02f, 3.08910578e-01f, -5.51120877e-01f, 2.36116022e-01f,
  1.89495996e-01f, 3.58911335e-01f, -5.74600518e-01f, -1.59213185e-01f, -3.25183153e-01f, -4.27663289e-02f, -4.82716471e-01f, -2.07409263e-01f, 3.76135507e-03f, 1.60642177e-01f,
  -1.54188514e-01f, 4.28775579e-01f, 9.83209312e-02f, 1.71531305e-01f, -2.40251601e-01f, 4.86109734e-01f, -4.51991677e-01f, 1.43393070e-01f, -8.13549936e-01f, -4.91847068e-01f,
  4.07054245e-01f, 4.68971521e-01f, -2.76339740e-01f, -6.22458994e-01f, 3.09141308e-01f, 2.87019640e-01f, 1.46261156e-01f, -1.14181377e-01f, 5.11264205e-01f, 1.39663354e-01f,
  -4.34793293e-01f, -2.90426821e-01f, -1.30282119e-01f, -6.09747022e-02f, -1.61622792e-01f, -8.82290080e-02f, -1.06283858e-01f, 9.03966352e-02f, 2.90529758e-01f, -2.18332335e-01f,
  -8.52035999e-01f, 3.87894869e-01f, -4.82917637e-01f, -4.02656257e-01f, -2.12679580e-01f, -1.52343541e-01f, 7.17701837e-02f, 1.95901811e-01f, 2.22208828e-01f, 9.68708917e-02f,
  8.41602162e-02f, 2.88297296e-01f, -9.23233014e-03f, -4.26689327e-01f, 2.46223986e-01f, -4.95429784e-01f, -2.32672095e-01f, -1.29472166e-01f, -3.93044144e-01f, 1.81329161e-01f,
  4.38480049e-01f, 4.65698212e-01f, -2.01175943e-01f, -5.87020278e-01f, -2.63927609e-01f, -2.34503493e-01f, -2.43451223e-01f, 3.58194888e-01f, -3.13492000e-01f, -1.08227387e-01f,
  3.56643826e-01f, -5.40527344e-01f, 8.55516121e-02f, -3.89829427e-01f, -4.13015574e-01f, 2.52369404e-01f, -3.82909402e-02f, -4.82547693e-02f, 1.02757536e-01f, -2.74146855e-01f,
  2.75769055e-01f, -5.65676391e-02f, 5.13980389e-02f, -3.33949924e-01f, 2.77465820e-01f, -5.28295755e-01f, -3.52368116e-01f, 4.81228173e-01f, -3.34628582e-01f, -4.81454521e-01f,
  -4.16536927e-01f, 1.71009704e-01f, 3.42018932e-01f, -2.60564983e-01f, -4.58497316e-01f, -4.02221262e-01f, 3.52393359e-01f, -7.15636462e-02f, 3.65908027e-01f, 1.94719508e-01f,
  3.28918070e-01f, 1.83478475e-01f, -1.77594647e-01f, 2.93089300e-01f, -4.48063046e-01f, 6.00613169e-02f, -3.51927578e-01f, -3.35474759e-01f, 2.08236799e-01f, 1.25685841e-01f,
  3.07728797e-01f, -3.28695953e-01f, 5.08706093e-01f, 1.85955927e-01f, -3.90159190e-01f, 4.90059495e-01f, 1.02656595e-01f, 1.39836162e-01f, 2.89686859e-01f, -2.95915008e-01f,
  5.38554072e-01f, -4.68617558e-01f, 2.11955547e-01f, -1.56507492e-01f, -6.55523360e-01f, 1.48222774e-01f, -8.29808772e-01f, -5.88624001e-01f, 1.47001162e-01f, -8.29720497e-01f,
  5.70622861e-01f, 1.76462039e-01f, -4.51419204e-01f, -6.17727280e-01f, -3.40810418e-02f, -5.28806448e-01f, -2.17075035e-01f, 3.20568621e-01f, 8.43252242e-02f, -1.43892214e-01f,
  4.17656079e-02f, 2.34425306e-01f, 1.81075037e-02f, -2.78475564e-02f, -3.84358883e-01f, -3.21991831e-01f, 4.38066632e-01f, -6.74407482e-01f, -1.38007747e-02f, -4.02453691e-01f,
  1.68045804e-01f, -1.06275477e-01f, -2.47221574e-01f, 4.04832035e-01f, -2.34215900e-01f, -4.82964844e-01f, -5.75703084e-01f, -1.60920233e-01f, 4.65027332e-01f, -3.10267895e-01f,
  -4.99081194e-01f, -5.90078115e-01f, 4.01597112e-01f, -4.35917884e-01f, 5.31966388e-01f, 3.59689981e-01f, -2.78124213e-01f, -1.58421516e-01f, -2.31481969e-01f, 4.22264218e-01f,
  -2.57075995e-01f, 8.92904997e-02f, -4.27679643e-02f, -4.30670977e-02f, -2.96935625e-02f, -2.38618881e-01f, -2.87313581e-01f, 3.46328855e-01f, -1.73557624e-01f, -2.20893949e-01f,
  4.53889906e-01f, -2.23094285e-01f, 1.83438823e-01f, -6.07143268e-02f, -5.15209019e-01f, -5.04573762e-01f, -4.09834027e-01f, -7.25041449e-01f, 3.35623085e-01f, -3.66400510e-01f,
  1.68860734e-01f, 5.96786678e-01f, 4.36908007e-01f, 2.73348182e-01f, -2.33815074e-01f, -3.81098419e-01f, -5.21221161e-01f, 4.64998454e-01f, 2.84533411e-01f, -3.71315747e-01f,
  -3.51088256e-01f, 2.01886281e-01f, -3.06688428e-01f, -5.48611820e-01f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  -1.39045402e-01f, -1.27694964e-01f, 1.19651794e-01f, -7.13978857e-02f, 1.49034590e-01f, -1.71428919e-01f, -1.44334167e-01f, -1.03845745e-02f, -6.18081093e-02f, -9.80683044e-02f,
  2.16846839e-01f, 1.08256727e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 3, 26
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 3, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        32, 12
    );
    }
    