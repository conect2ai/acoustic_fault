/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -1.12266988e-01f, -1.45053223e-01f, 3.38569939e-01f, -2.89831460e-01f, 1.02878809e-01f, 1.37123376e-01f, 3.40068787e-01f, -7.48900250e-02f, -2.93599367e-01f, 1.63199872e-01f,
  -3.09958886e-02f, -6.64894432e-02f, -4.07680012e-02f, 3.25716622e-02f, -7.66574964e-02f, 1.03440605e-01f, 8.75524282e-02f, 7.56932274e-02f, 1.60560593e-01f, 3.50236669e-02f,
  2.87679266e-02f, -1.14073858e-01f, -6.87511638e-02f, -3.13625187e-02f, 9.28972289e-02f, 2.43896805e-02f, 5.32747209e-02f, -6.37190193e-02f, -7.77119724e-03f, 2.37839550e-01f,
  4.74517256e-01f, -2.37839788e-01f, 1.27416760e-01f, -1.56411663e-01f, 3.84808443e-02f, 4.64192219e-02f, 1.07854813e-01f, 2.79353093e-02f, -4.47779112e-02f, 5.74231967e-02f,
  -1.09647743e-01f, -4.16219421e-02f, 1.01032387e-03f, -2.58452678e-03f, -3.32652479e-02f, 7.59291425e-02f, -4.77690771e-02f, -4.40496951e-02f, -9.11352783e-03f, 9.01354849e-02f,
  -2.56955368e-03f, -9.07808393e-02f, 5.35293967e-02f, 8.08899626e-02f, -3.50538641e-02f, -8.45338684e-03f, 4.55314629e-02f, 3.66606377e-02f, -7.42225200e-02f, 7.30747133e-02f,
  7.39570614e-03f, 6.28434494e-02f, 5.88102415e-02f, 2.44956631e-02f, -4.37220559e-02f, 3.52262706e-02f, 3.41072492e-02f, 4.35315371e-02f, -2.32191291e-02f, 6.93874084e-04f,
  -2.22925078e-02f, -3.99152488e-02f, 1.21899219e-02f, 8.67110211e-04f, 3.50047983e-02f, 4.69382480e-03f, -4.42742445e-02f, 5.29336147e-02f, -4.31310944e-02f, 1.19290557e-02f,
  3.25402878e-02f, -1.43416617e-02f, 4.10816744e-02f, -1.15348980e-01f, -1.13067543e-02f, 2.51037744e-03f, 8.45540501e-03f, 4.65188082e-03f, 1.17530534e-02f, -8.25554430e-02f,
  -6.24132268e-02f, -1.17571190e-01f, 9.64747567e-04f, -5.98636717e-02f, -2.34174393e-02f, -9.45185646e-02f, 2.86304727e-02f, 6.56025112e-02f, -9.56659392e-02f, 3.73246036e-02f,
  8.28676391e-03f, 9.44184884e-03f, 2.86148582e-02f, -5.53033361e-03f, 7.26019889e-02f, 1.24394698e-02f, -1.85509454e-02f, 3.61953373e-03f, -1.37217388e-01f, -1.17015876e-02f,
  -7.26854876e-02f, 9.47757363e-02f, 1.76277786e-01f, 9.19848774e-03f, 3.74559779e-03f, -6.53003389e-03f, 2.33014748e-01f, 1.41115636e-01f, 3.46733220e-02f, 2.65942723e-01f,
  2.19974354e-01f, -2.00984672e-01f, 2.72774845e-01f, 3.27331424e-01f, 6.11095689e-02f, 1.20836888e-02f, 9.21036527e-02f, 9.61075500e-02f, 6.41579926e-02f, 7.87080750e-02f,
  -1.75539836e-01f, -9.81963798e-02f, 4.71960194e-02f, -6.83585042e-03f, -9.88378972e-02f, 9.47394520e-02f, 2.74740130e-01f, 1.59636617e-01f, 4.66910340e-02f, -1.82810321e-01f,
  -9.09095481e-02f, -4.17320095e-02f, 8.93650278e-02f, 3.29544256e-03f, -4.50882427e-02f, 2.22024824e-02f, 6.89339489e-02f, -1.24983892e-01f, -2.74063110e-01f, 2.80523092e-01f,
  -2.01109797e-01f, -8.06080550e-02f, 7.87673667e-02f, 3.83328572e-02f, -4.95719491e-03f, 7.18121007e-02f, -6.50480688e-02f, -5.25414795e-02f, 5.95391244e-02f, 6.53866976e-02f,
  6.24147765e-02f, -3.19105424e-02f, 6.82707131e-02f, 2.72947662e-02f, -2.56751734e-03f, -1.42414961e-02f, 3.51562463e-02f, 1.55354142e-02f, 6.46737367e-02f, -2.93147229e-02f,
  1.46640767e-03f, -1.08829908e-01f, 1.13507761e-02f, -1.45737017e-02f, 1.53567374e-01f, 8.60134736e-02f, -2.52361055e-02f, 4.40757684e-02f, 7.81538859e-02f, -3.04315984e-02f,
  5.55249378e-02f, -9.19703320e-02f, -1.40215950e-02f, -6.36357581e-03f, -4.47567552e-02f, -1.62558947e-02f, 2.18943451e-02f, -4.17566672e-02f, 1.02779968e-02f, -4.66209464e-02f,
  6.54115481e-03f, 4.07800041e-02f, -1.75106749e-02f, 2.05702125e-03f, -2.93196477e-02f, 4.34325263e-02f, 2.71860994e-02f, -1.60154980e-02f, -8.61150329e-06f, 4.89550605e-02f,
  -3.84961665e-02f, 2.10902430e-02f, 7.90877491e-02f, -5.03449775e-02f, 3.72994645e-03f, 1.52666019e-02f, -1.01779364e-02f, -4.96769957e-02f, -6.64062276e-02f, 5.60539924e-02f,
  -4.14172336e-02f, 1.88868806e-01f, 4.99067754e-02f, 2.45236512e-03f, -1.02265170e-04f, 1.03073735e-02f, 5.87571263e-02f, -2.85455280e-05f, 3.00643239e-02f, -1.41106127e-02f,
  2.12916285e-02f, 3.14345583e-02f, -1.82248801e-02f, -1.30242966e-02f, -1.43830653e-03f, -4.04852303e-03f, 3.72954295e-03f, 1.98719800e-02f, 1.14632159e-01f, 3.12182028e-02f,
  8.36340562e-02f, 3.59517373e-02f, -7.07751885e-02f, 4.91983518e-02f, -3.65029126e-02f, 5.77415973e-02f, -1.37507111e-01f, -8.07878003e-02f, 6.60369406e-03f, -7.24050403e-02f,
  4.18554366e-01f, -4.58740294e-01f, -1.42544895e-01f, 4.18324828e-01f, -2.35571593e-01f, 6.22921512e-02f, -9.11741853e-02f, 2.54933517e-02f, 1.63359344e-01f, -1.79813892e-01f,
  -8.25704187e-02f, 6.56387284e-02f, 8.18738341e-02f, -1.15389447e-03f, 5.42678684e-02f, -9.65656415e-02f, -8.26590508e-02f, 9.72749889e-02f, 3.72608721e-01f, 1.31728664e-01f,
  3.87670062e-02f, 5.68224303e-02f, 1.61288202e-01f, 1.81075692e-01f, -3.25344652e-01f, 2.93545932e-01f, -2.79906332e-01f, -1.47123128e-01f, -1.49217188e-01f, -6.67624176e-01f,
  -9.22131166e-03f, -1.94886804e-01f, 8.74877125e-02f, 5.72554432e-02f, -5.05455807e-02f, 4.07564417e-02f, 1.94488242e-02f, -7.52368802e-03f, -4.20552120e-02f, 7.73228183e-02f,
  -4.43370268e-02f, -1.26881832e-02f, -2.50712149e-02f, 1.51206774e-03f, -8.05935636e-02f, -2.62218080e-02f, -1.89119689e-02f, -6.78511485e-02f, -3.42803970e-02f, -1.32149477e-02f,
  -1.66597769e-01f, -1.46564230e-01f, -1.07422881e-01f, -3.11193746e-02f, -4.74396385e-02f, 5.46597280e-02f, -8.84280130e-02f, -1.14316963e-01f, -1.49447903e-01f, -1.12442352e-01f,
  -1.40969204e-02f, 1.69599280e-02f, -3.24110016e-02f, 4.77888808e-03f, -1.05822170e-02f, 2.57881433e-02f, -1.79103743e-02f, 1.00628622e-01f, -4.77035111e-03f, -1.47212241e-02f,
  -2.94701997e-02f, -5.60999401e-02f, 4.81620468e-02f, -3.54315480e-03f, 4.10676748e-03f, -1.36739211e-02f, -4.80553275e-03f, -4.20721062e-03f, -1.56420246e-02f, 7.31353695e-03f,
  1.58123896e-02f, -3.68397608e-02f, 3.22442092e-02f, -4.98180613e-02f, -2.82343663e-02f, -1.73610710e-02f, 1.03693614e-02f, 6.78061857e-04f, 4.12811711e-02f, 6.43188553e-03f,
  2.07468674e-01f, -5.17744347e-02f, 3.70532498e-02f, -7.63531849e-02f, -1.82968914e-03f, 2.91251205e-03f, 1.41841331e-02f, 4.97253472e-03f, -4.55334187e-02f, -2.38908809e-02f,
  -5.01878932e-03f, 3.53123993e-02f, -1.30582023e-02f, -3.48001048e-02f, 6.70274049e-02f, 3.41989957e-02f, -1.26533685e-02f, 1.14693291e-01f, -5.88341802e-02f, 5.44035509e-02f,
  -1.72007701e-03f, 9.18417946e-02f, 1.94494739e-01f, 1.00760758e-01f, 3.17494571e-02f, 9.57835000e-03f, 1.64003551e-01f, 1.54204056e-01f, 7.24677742e-02f, 3.34161490e-01f,
  -4.05383170e-01f, -3.23591918e-01f, 1.94927052e-01f, -3.13423485e-01f, -1.40054956e-01f, 1.97949067e-01f, 7.79071078e-02f, 1.86572582e-01f, 4.21058610e-02f, -2.49175075e-02f,
  -8.92397687e-02f, -1.60308287e-01f, 4.01915684e-02f, 8.52179751e-02f, -3.76023538e-02f, 7.02010989e-02f, -1.73390642e-01f, -1.52802646e-01f, 6.91471174e-02f, 7.72846714e-02f,
  -1.94281507e-02f, -3.88023585e-01f, -2.73237109e-01f, 2.65852869e-01f, -1.19092509e-01f, 5.11917099e-02f, 2.99939588e-02f, -2.68556952e-01f, 9.89873037e-02f, -4.52432215e-01f,
  -7.30221719e-02f, -3.33240395e-03f, 5.98058552e-02f, -1.16190054e-01f, -1.54808350e-02f, 1.02732785e-01f, -2.50787027e-02f, -8.25185254e-02f, 3.69438529e-02f, 6.08021952e-02f,
  -1.12892546e-01f, 1.60723310e-02f, -1.38328791e-01f, -1.59655884e-02f, -1.07571989e-01f, 1.72980838e-02f, 3.29734758e-02f, 1.67884585e-02f, 4.58615981e-02f, 1.51828110e-01f,
  -7.78592676e-02f, -1.53807223e-01f, 2.87792124e-02f, 1.55977845e-01f, 2.36847803e-01f, -1.27999038e-01f, 8.66653025e-02f, 1.33257657e-01f, 5.06299697e-02f, -5.21059483e-02f,
  -9.48286988e-03f, 3.09791155e-02f, 2.96973879e-03f, 4.12301207e-03f, -6.33106427e-03f, 3.66083831e-02f, -3.00961826e-02f, 1.38092302e-02f, 1.58486119e-03f, -5.94715774e-02f,
  4.11746427e-02f, -4.20090519e-02f, 1.50404451e-02f, -2.52579339e-02f, 1.08861597e-02f, -1.39805013e-02f, -4.19842936e-02f, 2.62130816e-02f, -2.57893093e-02f, 9.54665957e-05f,
  1.40379518e-02f, 5.16755767e-02f, -7.03916624e-02f, 6.64488822e-02f, -5.60583621e-02f, -3.46809230e-03f, -3.58102992e-02f, 6.97806329e-02f, 1.49667468e-02f, -7.06719095e-03f,
  -2.46041473e-02f, 8.10658261e-02f, -1.05558172e-01f, 6.48737103e-02f, -6.49001896e-02f, -1.86153315e-02f, -4.88786027e-02f, 3.99246179e-02f, -7.04283267e-02f, -1.46171888e-02f,
  2.15411708e-02f, 2.24962793e-02f, -3.69863138e-02f, 3.55053693e-02f, 2.36809091e-03f, 2.99219936e-02f, -1.03123784e-01f, 8.53983499e-03f, 3.66588682e-02f, 1.27528571e-02f,
  2.06788946e-02f, 5.49882539e-02f, -5.20140603e-02f, -4.35474254e-02f, -9.90600660e-02f, -8.15689564e-02f, 2.99110543e-02f, -2.83608288e-02f, -9.45934933e-03f, 1.05863877e-01f,
  -5.46051800e-01f, 2.60699451e-01f, -2.49988183e-01f, 1.25204861e-01f, 2.64717817e-01f, 8.11748281e-02f, 3.55133712e-01f, 1.56505451e-01f, 3.18311676e-02f, 4.29296046e-02f,
  -2.21374147e-02f, 9.51374695e-02f, -8.25168658e-03f, -5.44800162e-02f, -1.24477744e-01f, 1.00466445e-01f, 1.11253254e-01f, -2.28036702e-01f, -2.21317455e-01f, 1.08010523e-01f,
  2.49991849e-01f, 8.66714865e-02f, -3.10712516e-01f, -7.77466595e-02f, 3.45778197e-01f, 1.31791914e-02f, -1.31298169e-01f, 1.53087324e-03f, -2.85060197e-01f, 2.20873192e-01f,
  -1.44447759e-01f, -1.25696570e-01f, 4.02912647e-02f, -8.11401010e-02f, 4.81247623e-03f, -1.79836210e-02f, 4.34126006e-03f, -5.76449856e-02f, 2.19730772e-02f, -4.44111638e-02f,
  7.11125806e-02f, -5.92869744e-02f, -8.10203515e-03f, 4.12828699e-02f, -5.38289659e-02f, -1.75103992e-02f, -1.12714559e-01f, -1.37192905e-01f, -3.01325005e-02f, -3.48424120e-03f,
  2.39813626e-01f, -1.15706295e-01f, -6.16812818e-02f, 2.23693829e-02f, -7.24218041e-02f, 3.18666957e-02f, -1.40163291e-03f, -1.71357989e-02f, -1.91930562e-01f, 9.90381390e-02f,
  3.51990052e-02f, -3.84531654e-02f, 2.35426072e-02f, -2.66160746e-03f, 2.95866374e-02f, 2.27099601e-02f, 3.80033371e-03f, 1.81091914e-03f, 1.46382535e-02f, -1.90478843e-02f,
  -1.23623870e-02f, 1.49063375e-02f, 2.29746709e-03f, -2.09148582e-02f, 4.86613810e-03f, -2.51135137e-02f, 1.28392503e-02f, -5.84943919e-04f, 1.58111397e-02f, 2.41322089e-02f,
  2.48932862e-03f, -6.73583755e-03f, 7.38038942e-02f, 1.34110842e-02f, 2.42871828e-02f, -4.54780869e-02f, -3.10728569e-02f, -1.40315611e-02f, 2.44298019e-02f, -3.16578038e-02f,
  1.46480709e-01f, -6.65277317e-02f, 4.67385426e-02f, 3.26629840e-02f, -3.21941264e-02f, -4.17623110e-02f, 3.16192098e-02f, 2.64544431e-02f, -5.02343960e-02f, 3.46390419e-02f,
  2.38700919e-02f, -4.43708897e-02f, 1.24587258e-02f, 2.56920210e-03f, 2.13861298e-02f, -1.25214765e-02f, 3.64399105e-02f, 5.30010834e-02f, -3.01081929e-02f, 8.12302753e-02f,
  5.36723342e-03f, 3.77955809e-02f, 1.48819229e-02f, 4.59024906e-02f, 1.27890483e-01f, -6.52952269e-02f, 3.34347226e-02f, 6.53161705e-02f, -2.76373215e-02f, 1.33600801e-01f,
  4.12167236e-02f, -2.13467912e-03f, 2.42875189e-01f, -3.34386081e-01f, 7.19825029e-02f, 5.61074093e-02f, 2.63146043e-01f, -1.20866500e-01f, -1.96569994e-01f, 1.23986304e-01f,
  -2.33454946e-02f, 6.54643103e-02f, 1.10709466e-01f, 6.06576167e-02f, 2.22085491e-01f, 2.54791200e-01f, 1.39808148e-01f, 1.46780983e-01f, 2.26071358e-01f, -1.93099663e-01f,
  -9.59385261e-02f, 8.62229764e-02f, -1.61303744e-01f, -1.46676034e-01f, -5.49186282e-02f, 4.20027524e-01f, 9.94679630e-02f, -1.89399734e-01f, 1.46358982e-02f, 1.92934182e-02f,
  1.90229893e-01f, -1.41408548e-01f, -3.69311459e-02f, -5.17958738e-02f, -8.94270092e-02f, -6.38027713e-02f, 1.26015842e-02f, -6.59916773e-02f, -1.06510833e-01f, -6.03822991e-02f,
  1.89263397e-03f, -9.73237529e-02f, 2.40277275e-02f, -1.10515524e-02f, 2.09432095e-03f, -2.68768687e-02f, -2.27948129e-02f, -3.15852389e-02f, 6.54999241e-02f, -9.76101533e-02f,
  2.02309564e-02f, -7.89858773e-02f, -4.37747687e-02f, -4.67815772e-02f, -1.68414153e-02f, -2.99006999e-02f, -1.68669283e-01f, -7.64294863e-02f, -3.15229259e-02f, -1.32131755e-01f,
  -4.28719111e-02f, 3.66878845e-02f, 4.12724027e-03f, -3.54845845e-03f, 1.92149505e-02f, 3.67327631e-02f, -2.59525348e-02f, 4.35998244e-03f, 3.93296927e-02f, 7.82203954e-03f,
  -1.88983623e-02f, 8.31127167e-03f, -2.61854450e-03f, 4.49733605e-04f, 3.52045894e-02f, -1.52547825e-02f, -4.57301103e-02f, 6.86734170e-02f, -7.06488937e-02f, 2.59795263e-02f,
  -5.89216091e-02f, -2.11543683e-02f, -3.07541750e-02f, 7.53771439e-02f, 1.92492642e-02f, -1.85840819e-02f, -8.90711509e-03f, -1.66867170e-02f, 3.72668020e-02f, -8.51059631e-02f,
  3.02018467e-02f, 8.63437261e-03f, 2.82840617e-02f, 8.67840424e-02f, 5.65202581e-03f, -3.34197916e-02f, 2.07010061e-02f, -3.94719951e-02f, -1.59705952e-02f, -1.01913270e-02f,
  -4.07152586e-02f, 4.96070385e-02f, 3.18744369e-02f, 6.92970306e-03f, -3.14005725e-02f, -6.29183426e-02f, 2.24378575e-02f, 5.91137409e-02f, -6.85624704e-02f, -1.58623401e-02f,
  -5.32911047e-02f, 3.07198204e-02f, 1.29584178e-01f, -1.19456025e-02f, 5.36545701e-02f, 5.36376201e-02f, 2.72433758e-01f, -1.20855542e-02f, 1.60493135e-01f, 1.36455163e-01f
};

// L0_fan_Wp_bar (Shape: 4 x 120)
const int L0_fan_Wp_bar_rows = 4;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  2.04323754e-01f, 2.39039287e-02f, -3.08013018e-02f, 1.41716242e-01f, 1.69265077e-01f, 6.56778663e-02f, -7.81014115e-02f, -1.43283367e-01f, -9.68045965e-02f, 8.50849971e-03f,
  6.09329678e-02f, 4.33850512e-02f, -2.07362399e-02f, -1.07079037e-01f, -1.82337388e-01f, -4.59901355e-02f, -1.35011539e-01f, -9.15304720e-02f, -1.48964718e-01f, 5.27772717e-02f,
  -1.21041097e-01f, 3.69531550e-02f, -1.15714306e-02f, -2.01956220e-02f, -2.50666756e-02f, 8.92259926e-02f, 8.93036425e-02f, 4.47743200e-03f, 2.42519863e-02f, 7.69394338e-02f,
  1.26357421e-01f, 9.46600586e-02f, -1.60952732e-02f, 7.51174763e-02f, 6.76941946e-02f, -5.03436327e-02f, -1.03003547e-01f, -1.49092391e-01f, -6.28476292e-02f, 1.67948790e-02f,
  1.13104537e-01f, -2.04841830e-02f, 1.23622157e-02f, -4.43073250e-02f, -5.75550422e-02f, -1.50683627e-01f, -1.53650008e-02f, 1.94906369e-02f, -4.73913252e-02f, -6.96086232e-03f,
  -7.79590905e-02f, 7.28471484e-03f, 5.00453301e-02f, -2.16917098e-02f, -7.72029907e-02f, -5.72467111e-02f, 7.33415484e-02f, 2.26383880e-02f, 3.20085324e-02f, 7.61047602e-02f,
  -2.10962575e-02f, 5.25865443e-02f, -1.58125218e-02f, 2.63811518e-02f, -8.21954571e-03f, 5.42057902e-02f, -2.50545647e-02f, 4.20398563e-02f, -3.68119515e-02f, -2.39018109e-02f,
  2.02785768e-02f, -4.10009362e-02f, -2.87821386e-02f, -8.95920210e-03f, 5.36526404e-02f, 3.11037414e-02f, 2.97278650e-02f, -6.89339340e-02f, -2.25230288e-02f, -2.38414053e-02f,
  -4.47410643e-02f, -5.00547402e-02f, -7.03551546e-02f, -8.92184377e-02f, 4.06938903e-02f, -1.92696024e-02f, 6.34830154e-04f, 9.47025567e-02f, -1.31561607e-02f, 8.38482529e-02f,
  1.94416773e-02f, 6.82728812e-02f, -3.95471752e-02f, -4.86131012e-02f, -3.48786488e-02f, 7.00989068e-02f, -1.08192610e-02f, -4.51599108e-03f, 2.22686902e-02f, -1.52725980e-01f,
  -1.48546547e-01f, 2.84234211e-02f, -2.16513257e-02f, 4.26956937e-02f, -1.17858097e-01f, 6.86000660e-02f, -4.84185927e-02f, 2.20603496e-02f, 3.33053879e-02f, -2.20672917e-02f,
  -1.03231110e-01f, -1.02719486e-01f, 1.23095221e-03f, -1.04700424e-01f, -4.27744277e-02f, 2.90504983e-03f, -6.16977038e-03f, -2.43287720e-02f, -5.29203117e-02f, -9.52350274e-02f,
  1.07976213e-01f, 6.32726923e-02f, -3.34707707e-01f, 3.15209240e-01f, -1.00601330e-01f, -3.46123934e-01f, -1.44478217e-01f, -3.69680375e-02f, -4.97851670e-02f, 2.07070764e-02f,
  -3.04456770e-01f, 1.02343656e-01f, -4.54764254e-02f, 1.33488357e-01f, 9.89584252e-02f, 1.00905634e-01f, 3.38392198e-01f, 2.49996513e-01f, -5.61269931e-02f, -1.00396708e-01f,
  2.34770596e-01f, 2.26249546e-01f, 4.94837426e-02f, -3.33943665e-02f, 1.96037024e-01f, -1.09208912e-01f, -2.65471756e-01f, -7.97919184e-02f, -1.43976659e-01f, 6.90670371e-01f,
  -1.22537389e-01f, 1.02824457e-01f, -8.70346949e-02f, 5.53995594e-02f, -4.66707051e-02f, 9.07805562e-02f, -3.76802571e-02f, -5.20506315e-02f, -2.51165703e-02f, 5.36070131e-02f,
  -5.39830327e-02f, -1.39419092e-02f, -6.69510514e-02f, 3.48219983e-02f, -7.07754046e-02f, -1.70432078e-03f, 5.50912470e-02f, 1.27332166e-01f, 8.31497647e-03f, -3.49967778e-02f,
  7.05916667e-03f, -5.86261302e-02f, -6.06373921e-02f, -1.28265709e-01f, 2.36101961e-03f, -6.03017956e-02f, -6.91339821e-02f, 4.68275361e-02f, -1.19192764e-01f, 2.61702269e-01f,
  1.43042607e-02f, -1.19978411e-03f, -3.59385163e-02f, -2.19891667e-02f, 3.67018022e-02f, 3.31409238e-02f, -1.23696467e-02f, 3.26528586e-02f, 2.31509074e-03f, 5.85265718e-02f,
  -1.04491971e-02f, -8.83532166e-02f, 3.15620713e-02f, -4.08292487e-02f, -7.38067552e-02f, 8.04294366e-03f, -8.56868271e-03f, -9.67932865e-03f, -5.85542247e-02f, 2.51028035e-03f,
  -3.46129499e-02f, -1.21216923e-02f, -3.12190410e-02f, 1.07866779e-01f, 2.28460245e-02f, -3.76708545e-02f, 7.21775070e-02f, 1.31671038e-02f, -1.57505982e-02f, -9.11223330e-03f,
  5.08395992e-02f, -2.51978129e-01f, 1.37638703e-01f, 3.86592075e-02f, -2.66867485e-02f, -7.58790085e-03f, -4.10642289e-02f, 7.22351717e-03f, 1.11902575e-03f, 6.02958538e-03f,
  4.36486900e-02f, -1.39810005e-02f, -7.15310723e-02f, 3.53260040e-02f, -1.98229663e-02f, -2.52125189e-02f, 2.70987861e-02f, 5.43261878e-03f, -5.90058975e-02f, 2.18487140e-02f,
  4.84607294e-02f, -4.90247980e-02f, -8.14150572e-02f, 5.51642664e-02f, 1.08637270e-02f, -1.47693679e-01f, -2.24133246e-02f, -3.42569500e-02f, -1.81314498e-01f, 3.74245159e-02f,
  2.46927097e-01f, 6.27833232e-02f, 1.75598994e-01f, 2.46463809e-02f, -3.58811989e-02f, -2.90416982e-02f, -6.50133714e-02f, 2.21037641e-02f, -1.63035076e-02f, 1.26902843e-02f,
  -2.67707370e-02f, 8.18229765e-02f, 1.82406843e-01f, 9.78663042e-02f, 1.54520735e-01f, -4.17669229e-02f, 5.10034040e-02f, 2.21521586e-01f, 1.52709797e-01f, -5.46928756e-02f,
  -1.09662600e-01f, 8.31222162e-02f, 1.96439907e-01f, 9.11138952e-02f, -1.98267341e-01f, -1.17620649e-02f, -1.88706890e-02f, -1.98362023e-02f, 3.74769629e-03f, -9.74767283e-02f,
  3.62833627e-02f, 1.68121651e-01f, 1.76194683e-01f, 5.78082446e-03f, 9.12377983e-02f, 3.31530869e-02f, 2.15389151e-02f, 5.85231297e-02f, 3.38120610e-02f, 3.65174599e-02f,
  -1.61596760e-02f, -5.20728119e-02f, -7.55010992e-02f, 3.17850709e-02f, 1.94359012e-02f, -9.01480615e-02f, 2.67779361e-02f, 6.17036931e-02f, 3.50490548e-02f, -3.45096178e-02f,
  -6.65109679e-02f, 1.15846284e-02f, 4.73404564e-02f, -5.15117086e-02f, -1.29887089e-03f, -6.73896354e-03f, 7.45149851e-02f, 3.26878168e-02f, 8.23993757e-02f, -1.09267116e-01f,
  -7.73436427e-02f, 4.19332758e-02f, -8.17888882e-03f, -4.81381677e-02f, 3.81420623e-03f, -6.28492087e-02f, 1.21785356e-02f, 6.94194287e-02f, -7.25743920e-03f, -2.63351761e-02f,
  -3.08693927e-02f, 4.02715057e-02f, 8.89099985e-02f, 1.64989848e-02f, -4.09415253e-02f, 2.84325499e-02f, -3.79804336e-02f, 3.05329077e-02f, 5.06198406e-02f, 5.46475351e-02f,
  1.25769665e-02f, 3.95796262e-02f, 1.20746670e-02f, 3.02054752e-02f, 1.20891733e-02f, 1.11513957e-01f, -6.34018481e-02f, 2.79254001e-02f, -3.09263840e-02f, -8.28114375e-02f,
  5.93036367e-03f, 3.34928870e-01f, -7.46185854e-02f, 1.36695758e-01f, -7.84339383e-03f, 1.01055115e-01f, -1.85775477e-02f, 3.68099660e-02f, -2.25324295e-02f, 4.70950315e-03f,
  3.05843726e-02f, 7.96652492e-03f, 1.27527028e-01f, -1.98314060e-02f, 6.37440830e-02f, 3.16834450e-02f, -3.82679951e-04f, 3.89486365e-02f, 1.85605228e-01f, 1.55842602e-02f,
  9.13206488e-03f, -1.07637249e-01f, -5.31277806e-02f, -3.48558761e-02f, 3.68334576e-02f, 2.46351236e-03f, -9.46593061e-02f, 1.60544235e-02f, 7.82920122e-02f, -1.94561571e-01f,
  3.37271512e-01f, -3.84000212e-01f, 1.98785827e-01f, 2.50011623e-01f, 4.40606982e-01f, 2.34187886e-01f, 5.37372604e-02f, -5.38005456e-02f, 8.60439092e-02f, -9.96174011e-03f,
  -9.92515236e-02f, -2.61013154e-02f, -1.81661054e-01f, -7.20100701e-02f, -1.15410127e-01f, 1.86839074e-01f, 1.37710169e-01f, 5.27305417e-02f, 1.33977324e-01f, 3.43637764e-01f,
  3.11198607e-02f, -9.57657844e-02f, -2.32785210e-01f, -6.93796277e-02f, 4.86229211e-02f, 3.04377109e-01f, -1.47664491e-02f, -9.84276384e-02f, -2.90496144e-02f, 1.60690695e-02f,
  -5.62958345e-02f, -6.69981763e-02f, 2.73632079e-01f, -3.88718992e-02f, 3.29562761e-02f, 5.45614175e-02f, -4.35581617e-02f, -7.85381198e-02f, 7.08579794e-02f, -2.72860993e-02f,
  -4.61967960e-02f, -1.10521846e-01f, -7.02855363e-02f, 3.61405089e-02f, 2.24685539e-02f, 1.73630789e-01f, -1.13094911e-01f, -3.20182517e-02f, -6.41634688e-02f, 1.45229530e-02f,
  -7.65402466e-02f, 8.44457746e-02f, 3.21017876e-02f, 3.04670166e-02f, -3.80963422e-02f, 9.43845976e-03f, -9.03145745e-02f, 5.31758219e-02f, 3.62356827e-02f, 6.41277358e-02f,
  4.43192869e-02f, -1.74631085e-02f, -6.12119725e-03f, 1.55012980e-02f, -7.58643597e-02f, 1.01894857e-02f, 3.93601172e-02f, -6.43717274e-02f, 2.87991185e-02f, -1.51736587e-02f,
  8.63960013e-04f, 5.00257462e-02f, -3.04133501e-02f, 3.31098363e-02f, -1.21020131e-01f, 2.50209905e-02f, 2.71711200e-02f, -8.09728652e-02f, 1.69948544e-02f, 5.33770258e-03f,
  1.71442924e-03f, -1.47224758e-02f, -2.65572276e-02f, -8.62349272e-02f, -2.22358163e-02f, 8.71555135e-02f, 1.15845151e-01f, -5.70682064e-03f, -8.66374001e-02f, 3.16780694e-02f,
  -1.11874603e-01f, -1.31787900e-02f, 9.54997391e-02f, -9.26385000e-02f, 4.18458208e-02f, -4.39462364e-02f, -2.42613684e-02f, -5.03793173e-02f, 5.22780647e-05f, 2.62959152e-02f,
  -1.65452808e-02f, -4.53517139e-02f, -2.00200267e-02f, -1.35058826e-02f, 8.20475444e-02f, 7.09215924e-02f, -6.62408918e-02f, 6.00415356e-02f, -8.16965774e-02f, -1.22947246e-01f,
  -8.90292451e-02f, 8.44468996e-02f, 1.21488027e-01f, 3.28276083e-02f, -2.74568936e-03f, 1.23345554e-01f, -9.06320103e-03f, 7.28873163e-02f, 3.03712077e-02f, 1.06062494e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 4)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 4;
const float L0_fan_Bp_bar_data[] = {
  -6.98601780e-03f, 1.04136229e-01f, 1.37867004e-01f, -3.18157166e-01f
};

// L1_fan_Wp (Shape: 6 x 16)
const int L1_fan_Wp_rows = 6;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  -3.11502777e-02f, 2.93002903e-01f, -1.69559911e-01f, -2.29110017e-01f, 6.41760170e-01f, 4.34130698e-01f, -3.74639571e-01f, -5.22726536e-01f, 3.67701828e-01f, 6.97548628e-01f,
  -2.49276996e-01f, 1.36993662e-01f, -1.03648014e-01f, -4.85541582e-01f, -2.44251922e-01f, 4.94892821e-02f, 1.95103139e-01f, -1.99973106e-01f, -2.72776842e-01f, 6.92352295e-01f,
  -5.49204051e-01f, 2.37363875e-01f, 3.40147279e-02f, 5.15087366e-01f, -1.26001105e-01f, -7.27415755e-02f, -4.33965683e-01f, 3.27326417e-01f, -2.37963513e-01f, -1.51701316e-01f,
  3.49933356e-01f, 1.84639648e-01f, 6.63092434e-02f, -1.62789524e-01f, -4.11274694e-02f, 1.57419771e-01f, -4.99093562e-01f, 2.58130044e-01f, -4.29579727e-02f, 1.77235112e-01f,
  3.97107512e-01f, -1.46862594e-02f, -2.80791074e-01f, 3.45472068e-01f, -3.75246555e-01f, 4.71680798e-02f, 1.91127267e-02f, 7.49555528e-02f, -3.51959437e-01f, -3.75998288e-01f,
  1.13795199e-01f, 4.11324054e-01f, -5.03554523e-01f, -5.10163121e-02f, -1.42514007e-02f, 6.28627092e-02f, 3.81657660e-01f, 9.62492228e-02f, -4.48805690e-02f, 2.66230166e-01f,
  -2.94627756e-01f, 2.48783678e-02f, -3.10477644e-01f, 4.31720048e-01f, -1.76679507e-01f, -2.74240941e-01f, -1.42730817e-01f, 2.84673244e-01f, 5.28823674e-01f, -4.22253996e-01f,
  -1.73976839e-01f, -3.41061279e-02f, 6.83024168e-01f, 3.18731099e-01f, -1.08785070e-01f, -5.34694158e-02f, -7.23319650e-02f, -3.03377718e-01f, 4.41867560e-02f, 1.40592456e-01f,
  -9.04330835e-02f, 3.11003745e-01f, -3.81880522e-01f, 3.67421359e-01f, 1.24011278e-01f, 1.36748061e-01f, -2.75383472e-01f, 3.83887626e-02f, 5.44128835e-01f, 2.65300691e-01f,
  -5.59460700e-01f, -5.23482263e-02f, 1.78108051e-01f, -7.84991145e-01f, 4.18009996e-01f, 8.86597931e-02f
};

// L1_fan_Wp_bar (Shape: 4 x 16)
const int L1_fan_Wp_bar_rows = 4;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  -1.72505397e-02f, -3.75402756e-02f, -1.63902834e-01f, 3.68742767e-04f, -2.33042330e-01f, -2.64681041e-01f, -1.91292927e-01f, 1.01660587e-01f, -8.17402080e-02f, -1.59997493e-01f,
  2.28504583e-01f, 2.24297732e-01f, -3.29097733e-02f, -4.80075702e-02f, 1.26799241e-01f, 2.45070368e-01f, -3.91682655e-01f, -5.10699227e-02f, 1.44732371e-01f, -1.09746464e-01f,
  -2.15211301e-03f, -2.85964727e-01f, 3.59227568e-01f, -3.06412876e-01f, -5.74423559e-02f, 6.16168864e-02f, 1.13696352e-01f, 3.71305078e-01f, 2.04604834e-01f, -9.18117464e-02f,
  -1.96931824e-01f, -7.11848587e-02f, -2.13481113e-01f, 1.71425760e-01f, -8.82997513e-02f, 4.84701842e-02f, -2.92848740e-02f, 8.36158395e-02f, 1.49596900e-01f, 1.15595058e-01f,
  1.79982141e-01f, 6.58224970e-02f, -6.13530315e-02f, -1.59638137e-01f, -9.26325321e-02f, -2.58828662e-02f, -1.50331289e-01f, -1.88637257e-01f, 6.01180673e-01f, 2.21363097e-01f,
  2.74238855e-01f, 2.46624067e-01f, -8.57327506e-02f, 6.29347205e-01f, 8.06654766e-02f, 2.85613239e-01f, -6.10396802e-01f, -3.06904525e-01f, -2.46659800e-01f, -1.99555814e-01f,
  4.38718461e-02f, 4.52521324e-01f, 1.89281516e-02f, -7.18005121e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 4)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 4;
const float L1_fan_Bp_bar_data[] = {
  2.13487610e-01f, 9.03482363e-02f, -2.06532374e-01f, 5.34347653e-01f
};

// L2_fan_Wp (Shape: 6 x 16)
const int L2_fan_Wp_rows = 6;
const int L2_fan_Wp_cols = 16;
const float L2_fan_Wp_data[] = {
  5.02885520e-01f, -3.09230149e-01f, -9.61618125e-02f, -3.97840470e-01f, 1.00351527e-01f, -8.35043099e-03f, 2.19594225e-01f, -5.34802556e-01f, -4.72229332e-01f, 1.56401321e-01f,
  9.95178819e-02f, 3.13746393e-01f, -1.36272848e-01f, 1.09690964e-01f, -2.55415663e-02f, -4.02776927e-01f, -7.48587549e-02f, -2.09098216e-02f, -8.97485018e-03f, 1.65171519e-01f,
  3.25834751e-01f, 5.31470418e-01f, 3.91586155e-01f, -2.26487190e-01f, 6.03701994e-02f, 1.53829470e-01f, 2.72128910e-01f, -3.94278169e-02f, 7.79373348e-02f, 3.47445875e-01f,
  -1.65365003e-02f, -4.43085402e-01f, 4.72700000e-02f, 1.44789621e-01f, -3.27263586e-02f, 2.77445316e-01f, -7.66778216e-02f, -3.68312389e-01f, -1.18575282e-01f, 7.16065407e-01f,
  5.65395832e-01f, 5.15487373e-01f, -6.12666421e-02f, 1.16735965e-01f, 2.91199565e-01f, 6.93368763e-02f, 8.80275369e-02f, 2.88915038e-01f, -5.02114475e-01f, 3.05201504e-02f,
  3.89850773e-02f, 4.40256864e-01f, 1.11523636e-01f, -2.36973614e-01f, -2.49993116e-01f, 2.90238738e-01f, 5.96051633e-01f, 4.09372926e-01f, 2.72443503e-01f, -2.32753754e-01f,
  2.14308668e-02f, -1.84324741e-01f, -4.99123596e-02f, -2.15852171e-01f, -3.94304842e-01f, 5.98066784e-02f, -4.15645868e-01f, -2.25093067e-01f, -2.22732931e-01f, 1.30311698e-01f,
  1.11949518e-01f, -3.31052929e-01f, -3.38282913e-01f, -2.27433950e-01f, 5.86172305e-02f, -4.39136654e-01f, -2.78865159e-01f, 1.45265430e-01f, 5.87546732e-03f, -5.03351241e-02f,
  7.89765596e-01f, -2.50906479e-02f, 8.84559155e-02f, -1.42807037e-01f, 5.50862312e-01f, -1.50720924e-01f, 6.69959426e-01f, 1.50969550e-01f, 7.64207914e-02f, -9.68244150e-02f,
  1.33243337e-01f, 9.02295113e-01f, -3.19052130e-01f, -9.00147036e-02f, -1.88242182e-01f, -2.07859084e-01f
};

// L2_fan_Wp_bar (Shape: 4 x 16)
const int L2_fan_Wp_bar_rows = 4;
const int L2_fan_Wp_bar_cols = 16;
const float L2_fan_Wp_bar_data[] = {
  2.98347414e-01f, 9.62857008e-02f, -1.74899474e-01f, -1.32066280e-01f, 2.65639067e-01f, 2.71152049e-01f, 2.77795583e-01f, -4.74754035e-01f, -2.23487034e-01f, -2.55553484e-01f,
  -1.58755556e-01f, 8.42982829e-02f, -2.19556674e-01f, 1.46840334e-01f, 1.37194201e-01f, 3.83958608e-01f, 6.33324206e-01f, 4.32088375e-01f, 2.40043566e-01f, 3.68584394e-01f,
  5.15393853e-01f, 6.55634046e-01f, 4.19399977e-01f, 6.58554792e-01f, 3.45160604e-01f, 8.24507535e-01f, 3.24545324e-01f, 2.46622369e-01f, -1.44727647e-01f, 3.86854082e-01f,
  8.55306350e-03f, 5.61926700e-03f, 2.29269102e-01f, 2.08686382e-01f, 4.28620763e-02f, -5.81449419e-02f, -1.12597853e-01f, -1.17866881e-01f, 1.03568047e-01f, 4.28907692e-01f,
  2.57416189e-01f, 2.76633620e-01f, -1.94741473e-01f, 1.98491082e-01f, -1.90448478e-01f, 2.48009879e-02f, -2.33181760e-01f, 3.15533400e-01f, 3.63061279e-01f, 4.05818790e-01f,
  4.37968880e-01f, -1.42650679e-01f, 1.39620692e-01f, 3.04794610e-01f, -3.81922364e-01f, 1.35565832e-01f, -2.34968364e-01f, -4.65131968e-01f, -6.19766891e-01f, -1.24889120e-01f,
  -2.03857988e-01f, -3.95170063e-01f, -8.39535967e-02f, 1.37927425e+00f
};

// L2_fan_Bp_bar (Shape: 1 x 4)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 4;
const float L2_fan_Bp_bar_data[] = {
  2.27820694e-01f, 4.99041885e-01f, -1.43232092e-01f, 2.91877329e-01f
};

// L3_fan_Wp (Shape: 6 x 16)
const int L3_fan_Wp_rows = 6;
const int L3_fan_Wp_cols = 16;
const float L3_fan_Wp_data[] = {
  1.26071543e-01f, 2.95360714e-01f, 1.35917678e-01f, -3.01401347e-01f, -1.70374781e-01f, 3.74033809e-01f, -3.60237896e-01f, -5.74138641e-01f, -2.81255960e-01f, -1.28762037e-01f,
  3.02212328e-01f, 7.01185269e-03f, 1.47731781e-01f, -7.09195495e-01f, -1.13402512e-02f, 3.24777186e-01f, 6.90415680e-01f, -9.06577036e-02f, 3.57929260e-01f, 3.56086254e-01f,
  4.90769356e-01f, 6.08722806e-01f, 6.24699146e-02f, 6.27272069e-01f, 1.15065426e-01f, 5.95112592e-02f, -1.44348562e-01f, 2.58933246e-01f, 6.89960197e-02f, 6.64306939e-01f,
  -2.08194003e-01f, -3.63747716e-01f, 2.50558019e-01f, -2.26309095e-02f, -2.64979806e-02f, 5.42245246e-02f, -1.49404302e-01f, -1.26739711e-01f, 4.94655550e-01f, 1.34660169e-01f,
  2.39311129e-01f, -1.25926249e-02f, -3.94635260e-01f, 5.17221093e-01f, 2.21561745e-01f, 6.43093467e-01f, 2.02553779e-01f, -5.67469060e-01f, 2.29016274e-01f, -4.13837969e-01f,
  -2.42403261e-02f, 1.62869513e-01f, 2.42886990e-01f, 2.23244708e-02f, -8.34066644e-02f, 4.04389381e-01f, -5.21737933e-01f, -2.91824371e-01f, 3.56699735e-01f, 6.88154638e-01f,
  3.86165917e-01f, 2.26848930e-01f, -1.46151036e-01f, -4.55147445e-01f, -3.11575681e-01f, -1.27856180e-01f, -1.34755209e-01f, -2.44095340e-01f, -4.24726576e-01f, -2.48040676e-01f,
  -1.52024060e-01f, -4.19598222e-01f, 2.00588122e-01f, -3.59662384e-01f, 2.03110576e-01f, -2.84998894e-01f, 1.00644544e-01f, -6.11779839e-02f, -1.96556151e-01f, 4.84852642e-01f,
  -5.48361778e-01f, 2.98722070e-02f, -3.95421028e-01f, -4.22976948e-02f, -1.53601080e-01f, -5.00856996e-01f, -3.32911491e-01f, -3.95998895e-01f, 3.49050522e-01f, 2.44886816e-01f,
  1.51303351e-01f, -6.85684025e-01f, -8.84706154e-02f, -6.95348606e-02f, -6.37801960e-02f, 1.27694607e-01f
};

// L3_fan_Wp_bar (Shape: 4 x 16)
const int L3_fan_Wp_bar_rows = 4;
const int L3_fan_Wp_bar_cols = 16;
const float L3_fan_Wp_bar_data[] = {
  4.64844167e-01f, -2.15880126e-02f, 5.10364711e-01f, -5.89386344e-01f, 5.49804449e-01f, 4.96474057e-01f, 1.64793119e-01f, 7.82547146e-02f, -5.76882899e-01f, -1.05259538e+00f,
  1.84313044e-01f, -1.89238917e-02f, 6.62059844e-01f, -3.75940353e-02f, 1.81567911e-02f, 1.36651611e+00f, -1.73118547e-01f, 9.46862698e-02f, -8.79887640e-02f, -1.62482634e-01f,
  -2.41380647e-01f, 9.72771198e-02f, 4.90877964e-02f, -8.40732977e-02f, -1.84122995e-01f, -1.29979281e-02f, -1.04270592e-01f, -7.79104829e-02f, -8.82060900e-02f, 2.33181380e-03f,
  -4.01509963e-02f, 5.98694235e-02f, 6.75735891e-01f, 9.32787657e-02f, 6.38219774e-01f, -2.06925869e-01f, 7.95276314e-02f, 5.52969456e-01f, -2.62589574e-01f, 1.13964371e-01f,
  -5.16458899e-02f, -1.53133020e-01f, -1.59841821e-01f, 7.66683936e-01f, 2.65852302e-01f, 6.18321717e-01f, -1.35717496e-01f, 2.11391300e-01f, -3.22441012e-01f, 3.09303969e-01f,
  3.59331593e-02f, 8.87740076e-01f, -2.21887931e-01f, -6.74055874e-01f, -3.63575786e-01f, 9.94605869e-02f, 1.18649530e+00f, 7.62293935e-01f, -7.37983167e-01f, 2.53762484e-01f,
  -3.35523933e-01f, 1.25213182e+00f, 5.81756651e-01f, 7.53745794e-01f
};

// L3_fan_Bp_bar (Shape: 1 x 4)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 4;
const float L3_fan_Bp_bar_data[] = {
  2.45625675e-01f, -7.77006708e-03f, 3.92707646e-01f, 5.49551964e-01f
};

// L4_linear_W (Shape: 12 x 16)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 16;
const float L4_linear_W_data[] = {
  9.88229156e-01f, -6.86120689e-01f, 9.87467468e-01f, -2.58449912e-01f, 2.02650100e-01f, -4.86138493e-01f, -4.98023361e-01f, 9.95680928e-01f, 5.34738898e-01f, 9.14870024e-01f,
  -1.17626131e+00f, -5.04797399e-01f, 1.02786511e-01f, 2.29477897e-01f, 3.43144625e-01f, -9.24633086e-01f, 3.14294785e-01f, -3.17162126e-01f, 1.65984780e-01f, 5.40600657e-01f,
  5.20909250e-01f, 4.78585484e-03f, -9.26881373e-01f, 5.41687071e-01f, 1.07446551e+00f, -2.85879731e-01f, -3.76073956e-01f, 1.38295799e-01f, -1.19981825e+00f, 2.42137447e-01f,
  1.61449000e-01f, 7.91553974e-01f, 4.01868433e-01f, 7.53248394e-01f, 3.20573539e-01f, 1.49302781e-01f, -6.30442202e-01f, 3.15225542e-01f, 1.96695492e-01f, -2.35471115e-01f,
  -1.93225712e-01f, -7.52126813e-01f, 4.26703632e-01f, 1.28265649e-01f, -1.50519267e-01f, -7.09003955e-02f, 2.51736622e-02f, 6.11104608e-01f, -2.94770449e-01f, 1.05806112e+00f,
  -1.95283979e-01f, 1.26321244e+00f, 2.29095951e-01f, 3.23252231e-01f, 3.79357964e-01f, 4.02120739e-01f, -8.39855850e-01f, -8.13498721e-02f, 5.56245029e-01f, -1.77799612e-01f,
  7.45980620e-01f, -1.69099227e-01f, 1.38889685e-01f, -1.07561600e+00f, 5.64186633e-01f, 6.12416565e-01f, 8.13419580e-01f, 3.23027700e-01f, 1.14159060e+00f, -2.25642428e-01f,
  5.16714931e-01f, 8.46835434e-01f, -8.27882532e-03f, 5.65055907e-01f, 3.33421916e-01f, -2.85168856e-01f, 5.94237208e-01f, -8.53619277e-02f, 3.61433476e-01f, -8.72455895e-01f,
  2.55103379e-01f, -6.56166792e-01f, 3.94904613e-01f, 4.64956671e-01f, 6.27962649e-01f, -2.44875431e-01f, -7.62216926e-01f, 4.18240905e-01f, 7.11387277e-01f, 4.55080688e-01f,
  4.59071919e-02f, -2.95178711e-01f, 8.87641534e-02f, 1.14374220e-01f, 3.71995360e-01f, 2.16318429e-01f, -3.98406416e-01f, -6.57077789e-01f, -3.38417292e-01f, -5.54423571e-01f,
  -2.87610888e-01f, -3.81431401e-01f, 3.18666726e-01f, -3.65024835e-01f, 2.09671468e-01f, 2.00801209e-01f, -1.91801637e-01f, 9.55305874e-01f, 5.11717021e-01f, -4.65320125e-02f,
  -5.54667115e-01f, 9.20476243e-02f, 3.96839917e-01f, -5.31210780e-01f, -5.19255161e-01f, -7.36909866e-01f, -4.33498025e-01f, -4.94839132e-01f, 2.69234329e-01f, -2.51596868e-01f,
  -4.94835198e-01f, -1.43532589e-01f, 1.22707672e-01f, 7.24472702e-01f, -4.98108715e-01f, -1.63844284e-02f, -1.08315206e+00f, 1.02552390e+00f, -7.85261333e-01f, -3.44277263e-01f,
  -4.78443772e-01f, 3.31118226e-01f, -5.27969450e-02f, -1.67831838e-01f, 2.93066800e-01f, 3.77018936e-03f, -6.31580830e-01f, -7.34492615e-02f, -3.92977953e-01f, -2.69090295e-01f,
  -1.11176312e+00f, 3.75264995e-02f, -2.56393492e-01f, 1.04608619e+00f, -4.84095097e-01f, -2.26744503e-01f, -6.90123379e-01f, -5.86695254e-01f, -7.87210464e-01f, 6.48631573e-01f,
  -4.87725064e-02f, -1.04322720e+00f, 2.86088198e-01f, -6.74757898e-01f, 1.14925161e-01f, 5.40324509e-01f, 7.91242421e-01f, 1.93099380e-01f, -1.74635313e-02f, -9.46933210e-01f,
  -9.46859658e-01f, 8.58974736e-03f, -4.57574755e-01f, -9.18392897e-01f, 8.01332593e-02f, -7.17940748e-01f, -6.51764512e-01f, -6.34478211e-01f, 2.30313510e-01f, 5.28522313e-01f,
  -7.50607133e-01f, -1.60380110e-01f, -2.98911095e-01f, 7.30274841e-02f, 6.74925983e-01f, 1.47945881e-01f, -4.68271762e-01f, 6.92522645e-01f, -4.81189281e-01f, -1.67602494e-01f,
  -4.37865436e-01f, 6.77551270e-01f, 6.94660187e-01f, -6.81726933e-01f, -8.95315588e-01f, -1.06184340e+00f, 5.81246495e-01f, -1.91059619e-01f, 3.89806777e-01f, -2.07644224e-01f,
  3.53937119e-01f, -1.77758500e-01f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  4.16325897e-01f, 7.25754444e-03f, -3.25743049e-01f, 8.06152225e-02f, 1.25931188e-01f, -1.41667100e-02f, -4.11980860e-02f, 2.50649422e-01f, -2.80219495e-01f, -1.99134186e-01f,
  -5.01663350e-02f, -1.95016325e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 4
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 6, 4
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        16, 6, 4
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        16, 6, 4
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        16, 12
    );
    }
    