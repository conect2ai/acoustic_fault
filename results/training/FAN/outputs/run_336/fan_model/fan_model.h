/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 128 (x1)
    * Saída: 12
    * Buffer Máx: 128
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 128;
    const int FAN_MAX_BUFFER_SIZE = 128;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 12 x 120)
const int L0_fan_Wp_rows = 12;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  2.53904432e-01f, -9.59036276e-02f, -5.85362955e-04f, 1.60085216e-01f, 1.44991465e-02f, -2.98990943e-02f, 2.94899225e-01f, 3.19702580e-04f, 2.43088201e-01f, -9.80311856e-02f,
  1.23337701e-01f, -4.66279350e-02f, 2.06569478e-01f, 6.29768148e-02f, 2.87320971e-01f, 2.73108065e-01f, 4.93961908e-02f, -3.01616043e-02f, 1.76959001e-02f, 6.78310543e-02f,
  -6.26868894e-03f, 9.14046541e-02f, 9.69317742e-03f, -1.45208925e-01f, -7.69602060e-02f, -2.09061429e-01f, -7.49357045e-02f, 6.61635473e-02f, -1.96727961e-01f, -2.96285432e-02f,
  -7.96945542e-02f, 1.31145388e-01f, -3.99771379e-03f, 1.57431280e-03f, -6.75469339e-02f, -1.01834111e-01f, -1.09852944e-02f, -2.17672866e-02f, 6.66567013e-02f, -4.67438512e-02f,
  7.58904684e-03f, 8.98791775e-02f, -3.47590111e-02f, 3.70043293e-02f, -5.18510230e-02f, -1.00531029e-02f, -3.05715669e-02f, -5.89209981e-03f, -9.62922722e-03f, 4.83942181e-02f,
  -5.37518561e-02f, -5.62190153e-02f, -2.28350330e-02f, -3.69458608e-02f, 1.17242355e-02f, -4.20083813e-02f, -1.47668971e-02f, -9.43559483e-02f, -1.38818100e-02f, -4.64755893e-02f,
  4.16811071e-02f, 3.13126780e-02f, 5.22757322e-02f, -4.13401686e-02f, -2.47604214e-02f, -5.37366718e-02f, -2.70668082e-02f, -3.60129997e-02f, 3.27584632e-02f, -8.07511061e-03f,
  -6.61791414e-02f, 3.66921611e-02f, -3.03581706e-03f, -4.07295041e-02f, 7.56008625e-02f, -2.92371046e-02f, -4.05558012e-03f, -8.45666677e-02f, 1.72318295e-02f, -5.89303635e-02f,
  4.61352579e-02f, 5.48956208e-02f, -1.29628060e-02f, 3.64311188e-02f, -1.99106876e-02f, 3.89286876e-03f, -1.43650658e-02f, 3.56536172e-02f, 3.28922682e-02f, 5.75981475e-02f,
  8.16633701e-02f, 2.35780813e-02f, -1.91970449e-02f, 3.99895478e-03f, 3.56039219e-03f, 4.30989563e-02f, 2.04108097e-02f, 6.45577833e-02f, -4.58136620e-03f, 7.37716854e-02f,
  -7.74806663e-02f, 3.51357419e-04f, -4.96956743e-02f, 4.48229089e-02f, -2.32280958e-02f, 4.49846648e-02f, 4.74633798e-02f, 2.90515553e-02f, -8.95722508e-02f, -9.67841819e-02f,
  6.11664057e-02f, -1.53821977e-02f, 2.06372365e-02f, -5.36846668e-02f, -5.39429076e-02f, 4.20770533e-02f, -4.34788363e-03f, 1.88564789e-02f, -6.10615946e-02f, 1.42781306e-02f,
  5.39723188e-02f, 3.19287807e-01f, 1.51255175e-01f, -7.97159374e-02f, 7.88357928e-02f, 2.98941545e-02f, -1.74817786e-01f, 1.75496206e-01f, -4.38709706e-02f, -4.92147245e-02f,
  3.02347261e-02f, 1.49356306e-01f, 4.42903936e-02f, 9.76891145e-02f, -3.60458121e-02f, -3.15150060e-02f, -1.16544880e-01f, -8.42140168e-02f, -4.73211855e-02f, 2.97615156e-02f,
  3.16651687e-02f, 5.04763909e-02f, 1.27088606e-01f, 2.04764232e-01f, 1.55171171e-01f, 9.45653394e-02f, -2.19191015e-02f, 2.66802516e-02f, -1.23927826e-02f, 5.61465789e-03f,
  9.60071683e-02f, 1.62449721e-02f, 9.28757787e-02f, 2.36075837e-02f, 4.63942625e-02f, -6.24823160e-02f, -3.81674804e-03f, -1.90313607e-02f, 6.50193766e-02f, 4.78891842e-02f,
  -2.33073924e-02f, 9.84279905e-03f, 9.20088962e-03f, 1.14380950e-02f, 6.32034764e-02f, -2.14527715e-02f, 5.62296808e-02f, -7.21479161e-03f, -1.46018350e-02f, 5.73347956e-02f,
  4.95598316e-02f, -1.76025387e-02f, -4.69161719e-02f, -3.15396897e-02f, -3.63936685e-02f, -3.80163547e-03f, -1.27803132e-01f, 1.28766047e-02f, -2.29718853e-02f, 2.67052185e-02f,
  -5.53073995e-02f, -3.48287225e-02f, -6.29881844e-02f, 5.55747300e-02f, 3.30014825e-02f, -5.95074184e-02f, 6.55923458e-03f, 2.31201155e-03f, 9.98301897e-04f, 5.30201830e-02f,
  1.98674500e-02f, -1.76846460e-02f, 2.07283199e-02f, -2.41313279e-02f, -1.66824239e-03f, -1.74354594e-02f, -6.92431033e-02f, -6.34073988e-02f, -1.36297457e-02f, 4.18323949e-02f,
  -1.93893276e-02f, -5.95885441e-02f, 5.95663562e-02f, 7.07026292e-03f, 5.69468699e-02f, 8.14311877e-02f, 7.68169994e-03f, 4.79386263e-02f, -6.38880581e-02f, -4.21606340e-02f,
  1.68190002e-01f, 1.59203455e-01f, 3.05680558e-02f, 3.52131985e-02f, -8.43875110e-03f, 3.16256732e-02f, -7.51030743e-02f, 4.80399914e-02f, 7.20336363e-02f, -5.55730723e-02f,
  -1.29755139e-02f, -7.47337863e-02f, 2.37479955e-02f, -3.54094692e-02f, -4.29420844e-02f, 1.66431051e-02f, 2.78641712e-02f, -1.22368811e-02f, 3.13099511e-02f, 4.08483949e-03f,
  -4.27121408e-02f, -2.53620967e-02f, 3.43134324e-03f, 3.26956213e-02f, -6.97022909e-03f, -5.30213341e-02f, 4.04840568e-03f, -3.31570790e-03f, 3.22105624e-02f, -2.65277363e-03f,
  -2.28239387e-01f, 1.45290524e-01f, -7.48229250e-02f, 1.65919196e-02f, -2.02665124e-02f, 2.50611961e-01f, 2.00770214e-01f, 7.49491081e-02f, 1.11565836e-01f, 7.74455741e-02f,
  -1.15502765e-02f, 1.04336724e-01f, 9.08494219e-02f, 1.39351040e-01f, 7.59055316e-02f, 1.81974880e-02f, 1.65263712e-01f, 1.39510930e-01f, 1.27142593e-01f, -6.68627843e-02f,
  -7.35520199e-02f, -1.04335428e-03f, -3.37801315e-02f, -1.39015494e-02f, 5.27594946e-02f, -1.09198257e-01f, -2.29783192e-01f, 6.71080081e-03f, 2.55564172e-02f, 1.35189388e-02f,
  1.18524104e-01f, -1.62263606e-02f, -1.49530582e-02f, 1.16193853e-01f, -6.26631826e-02f, -1.04777291e-01f, -5.82611822e-02f, -3.05668060e-02f, -2.61939075e-02f, -1.70265846e-02f,
  8.09111595e-02f, -4.35270928e-02f, 2.30636280e-02f, 8.45052004e-02f, -5.11110611e-02f, 3.19925509e-02f, -2.75287908e-02f, -5.32383807e-02f, 1.02010675e-01f, -4.79783826e-02f,
  -5.39653227e-02f, -6.99388012e-02f, -1.06186248e-01f, 3.07030380e-02f, 2.61701364e-02f, 2.12291982e-02f, -5.00870720e-02f, 5.08438051e-02f, 1.30502135e-02f, 4.51798812e-02f,
  -5.30245937e-02f, 2.01383810e-02f, -4.37246636e-03f, -5.50879501e-02f, -3.21105532e-02f, 8.63070041e-02f, -4.62328121e-02f, 3.67602743e-02f, -2.01929044e-02f, -6.31558672e-02f,
  5.74701093e-02f, -8.71116482e-03f, -2.44682599e-02f, -8.37593377e-02f, -6.80930689e-02f, 1.14091113e-03f, -7.09973574e-02f, -3.07596847e-02f, -2.79970504e-02f, -3.34808044e-03f,
  4.78902832e-03f, 4.76590507e-02f, -7.43674561e-02f, -6.56748340e-02f, 7.74085373e-02f, 3.53610329e-02f, 1.07390760e-02f, -3.68300040e-04f, -1.38304010e-02f, -1.84744615e-02f,
  1.11766336e-02f, -1.34435473e-02f, 1.02770567e-01f, -8.20537563e-03f, 1.12320982e-01f, 8.80682915e-02f, 5.19483499e-02f, 5.51615991e-02f, 2.59978138e-02f, -2.85618696e-02f,
  -8.19677338e-02f, -2.78600561e-03f, -2.15190649e-02f, -7.36653209e-02f, 5.39760888e-02f, -6.73707649e-02f, -4.16648760e-02f, 4.13585408e-03f, 2.10922509e-02f, 3.62809822e-02f,
  -1.05167449e-01f, -8.64972100e-02f, -4.03281348e-03f, 3.76614113e-03f, 5.14769964e-02f, 1.03206271e-02f, 3.68347131e-02f, -8.07568729e-02f, 1.85627230e-02f, -9.74615104e-04f,
  -8.60059038e-02f, 1.88583821e-01f, 3.02786678e-01f, 7.62252957e-02f, -2.41963491e-01f, -2.53162295e-01f, -9.51931179e-02f, 2.33607087e-02f, 2.20683962e-01f, 6.92518800e-02f,
  -1.94086820e-01f, 1.55545548e-01f, 1.74461395e-01f, -1.04189314e-01f, 4.21081670e-02f, 6.69722185e-02f, -1.07213542e-01f, -2.63041537e-02f, 1.15177706e-01f, 6.11082278e-02f,
  5.97364940e-02f, -2.36746594e-01f, 7.32497647e-02f, -3.87982056e-02f, -1.67749330e-01f, 7.00356886e-02f, -9.99933779e-02f, 4.44410881e-03f, -9.80222672e-02f, -4.66049276e-02f,
  6.27224706e-03f, 4.44581211e-02f, 6.27817884e-02f, 7.26053072e-03f, -9.32895020e-02f, -1.14530712e-01f, 1.97197720e-02f, -2.37097256e-02f, -2.65538860e-02f, -8.44686758e-03f,
  -2.11393908e-02f, -3.97479124e-02f, 1.93354080e-03f, -2.82201581e-02f, 2.16257945e-02f, -2.18807869e-02f, 7.02623352e-02f, -5.74543104e-02f, 5.45269661e-02f, 1.32101653e-02f,
  5.42569309e-02f, -2.43524276e-02f, -5.25327846e-02f, 5.46519551e-03f, 4.76852432e-02f, 4.13469970e-02f, -3.35334241e-02f, -1.04527678e-02f, 1.85215920e-02f, 1.10414021e-01f,
  6.17314614e-02f, 6.01297878e-02f, -3.01910844e-02f, -5.95794842e-02f, 4.03304286e-02f, -5.30998781e-02f, -4.94717360e-02f, -5.52520901e-02f, 8.40073451e-02f, 4.48614433e-02f,
  2.60110442e-02f, 8.58403072e-02f, 1.71195921e-02f, 1.02668966e-03f, -8.72152671e-03f, 2.02500783e-02f, -5.81611097e-02f, 2.51400210e-02f, 5.89182340e-02f, -3.59246731e-02f,
  4.72127199e-02f, 1.78118628e-02f, -1.64880082e-02f, -6.57406524e-02f, 1.68942399e-02f, -5.28530125e-03f, -5.73706720e-03f, -3.04682907e-02f, 2.29303502e-02f, 2.29218025e-02f,
  2.89120171e-02f, 2.54558444e-01f, -6.34435157e-04f, 3.59372981e-02f, 8.71455893e-02f, -3.52546647e-02f, 4.78469394e-02f, 4.13571149e-02f, 1.72943063e-03f, 3.62638570e-02f,
  -4.83848304e-02f, -4.29465920e-02f, 4.95465994e-02f, -4.62827925e-03f, 4.07645032e-02f, 9.54360701e-03f, -6.74609514e-03f, 5.89757301e-02f, -3.78870182e-02f, 1.61328502e-02f,
  -1.07888412e-02f, -6.68533519e-03f, 6.04283102e-02f, -3.63226756e-02f, -8.25662911e-02f, 5.73732592e-02f, -3.58622670e-02f, -3.15742828e-02f, -2.53969245e-02f, -4.52928431e-03f,
  1.42475665e-01f, -3.93189520e-01f, -3.50992754e-02f, 3.26267183e-02f, -8.39071199e-02f, -1.49728447e-01f, -5.66311404e-02f, -1.53339669e-01f, -5.54561168e-02f, -1.33533239e-01f,
  3.99374403e-02f, -8.06626901e-02f, 1.38514079e-02f, -7.69640459e-03f, 2.28011906e-01f, 1.18794180e-01f, -1.09189235e-01f, 2.26107407e-02f, 5.63417515e-03f, -1.23356365e-01f,
  9.58305746e-02f, 3.04228663e-02f, 1.02619700e-01f, -1.25475571e-01f, 3.76124159e-02f, 2.31922455e-02f, 3.50297168e-02f, -2.59753335e-02f, -3.31261568e-02f, 3.78758051e-02f,
  -1.83475192e-03f, 4.49143574e-02f, -5.95289730e-02f, -5.58152720e-02f, -2.75429841e-02f, -9.38266516e-02f, 4.05590609e-02f, 8.45271423e-02f, 4.59667370e-02f, -4.15247083e-02f,
  -6.03704490e-02f, 5.82211930e-03f, -7.45073706e-02f, -3.83929126e-02f, -2.39209309e-02f, -1.27454519e-01f, -8.48332122e-02f, -7.07110167e-02f, 5.66849345e-03f, -7.15469271e-02f,
  -4.45474610e-02f, -7.15986788e-02f, 4.45601046e-02f, -7.56713748e-02f, 8.93810466e-02f, 2.00350024e-02f, 4.71865982e-02f, 2.25390890e-03f, -7.58557245e-02f, -4.22389135e-02f,
  -6.28331453e-02f, 8.25303122e-02f, -2.58315951e-02f, 1.75595321e-02f, -7.87425861e-02f, 7.06088468e-02f, 1.31922727e-02f, -6.88245054e-03f, -1.57484803e-02f, -5.87903410e-02f,
  -1.93122663e-02f, 5.92773519e-02f, 3.35216857e-02f, 5.04387766e-02f, 6.67901849e-03f, 4.94667143e-02f, 4.44819890e-02f, 2.25826707e-02f, 4.17530835e-02f, -1.53823700e-02f,
  5.06261252e-02f, -3.82159762e-02f, -7.16269063e-03f, 1.22458814e-02f, 6.09687492e-02f, 4.31547165e-02f, 1.33801801e-02f, -3.65993194e-02f, -1.44875310e-02f, -4.93827164e-02f,
  -2.69043110e-02f, -2.28296638e-01f, -3.47288884e-02f, -5.77045139e-03f, -2.86219362e-02f, -2.70083360e-02f, -2.30076872e-02f, -2.47573648e-02f, -2.97429226e-03f, -9.01869610e-02f,
  -1.89161592e-03f, 3.95793878e-02f, -1.91022586e-02f, 6.79066032e-02f, 6.73762634e-02f, -1.42912408e-02f, 7.61938691e-02f, 1.89505927e-02f, -4.41722050e-02f, -1.12602608e-02f,
  2.81856451e-02f, -8.05387869e-02f, 7.12380633e-02f, -3.83605026e-02f, -4.43783402e-02f, 7.90661201e-02f, -5.80890104e-02f, -3.53107154e-02f, -1.35739036e-02f, -7.63512999e-02f,
  -2.39329808e-03f, -9.38440338e-02f, -6.34545684e-02f, -7.36366808e-02f, -2.61898845e-01f, -2.67877907e-01f, -1.41094685e-01f, -1.64751187e-01f, -8.51041526e-02f, 5.07064462e-02f,
  8.83048698e-02f, 5.57388999e-02f, 1.43269330e-01f, -9.65522677e-02f, 6.47452548e-02f, 4.69125025e-02f, -2.02309132e-01f, -9.22778845e-02f, -8.11339095e-02f, 1.57447476e-02f,
  4.32573408e-02f, 1.20904706e-01f, 1.21003285e-01f, -5.57480045e-02f, -1.25302836e-01f, -4.94556166e-02f, 2.22376838e-01f, 1.02995314e-01f, 9.60388780e-02f, 1.32103339e-02f,
  -5.04595973e-02f, -5.56896999e-02f, -4.09582891e-02f, 8.58971197e-03f, -5.75599074e-02f, -1.56570133e-02f, 5.32895029e-02f, 5.93775474e-02f, -5.85293397e-02f, -4.03225608e-03f,
  7.53522888e-02f, -5.07407151e-02f, -4.30510826e-02f, -4.37123477e-02f, -9.22685191e-02f, 5.25879301e-02f, 3.99749465e-02f, -1.08463101e-01f, 3.79988551e-02f, -1.60983372e-02f,
  -5.27376123e-02f, -4.85237986e-02f, -2.40713805e-02f, 2.80642901e-02f, 8.60331580e-03f, 2.16388479e-02f, -3.05174794e-02f, -4.45809849e-02f, 1.87435523e-02f, -8.80903825e-02f,
  5.70659116e-02f, -1.98195037e-02f, -2.75010485e-02f, 7.30666667e-02f, 3.48212793e-02f, 4.62352447e-02f, -6.63543642e-02f, 9.68076214e-02f, -5.91557473e-02f, 3.28035317e-02f,
  -1.46725513e-02f, -1.76481309e-03f, -3.23313661e-02f, 2.50581894e-02f, -6.45675361e-02f, -3.36461067e-02f, -2.43547950e-02f, 4.42975126e-02f, -2.07328647e-02f, 4.46209796e-02f,
  -3.98055390e-02f, 2.34877430e-02f, -1.71677489e-03f, 2.25231554e-02f, -2.59605367e-02f, -2.31892467e-02f, 4.47757654e-02f, 3.66172865e-02f, 3.45658548e-02f, 5.62792011e-02f,
  -1.02352828e-01f, 1.15055189e-01f, -2.81270724e-02f, -1.11096771e-02f, 1.95015129e-02f, -8.83556902e-02f, 1.53034590e-02f, 6.91771274e-03f, 7.88010880e-02f, 1.32172443e-02f,
  -2.06648055e-02f, -4.63254303e-02f, 3.71813849e-02f, 4.36301064e-03f, 4.43991683e-02f, -2.46951953e-02f, -1.34878876e-02f, 2.96280589e-02f, -6.81316946e-03f, 1.29218958e-02f,
  -3.06681148e-04f, -2.86895335e-02f, -5.96066862e-02f, 1.62770934e-02f, -7.08731636e-02f, 3.33535336e-02f, -8.31817165e-02f, 2.73955259e-02f, 7.73079246e-02f, 4.78158742e-02f,
  -3.67097437e-01f, -2.23312322e-02f, 2.82600652e-02f, -1.18340708e-01f, 2.08562566e-03f, -2.59078760e-03f, 1.56933013e-02f, 8.02088715e-03f, -3.31185281e-01f, 1.41846016e-01f,
  3.10527347e-02f, -5.99571541e-02f, 1.43209711e-01f, -1.37318954e-01f, -2.25481600e-01f, -1.21408015e-01f, -1.47510141e-01f, -5.29604666e-02f, -1.69303805e-01f, -1.66836511e-02f,
  -1.39528885e-01f, 2.66637467e-02f, -4.84852642e-02f, 1.64422279e-04f, 1.11813143e-01f, -4.87178098e-04f, 1.96834713e-01f, 1.88493356e-01f, 8.81259143e-02f, 2.94362195e-02f,
  -7.33656362e-02f, -1.25840604e-01f, 9.87312663e-03f, -5.76055758e-02f, 2.33799499e-02f, 4.43692654e-02f, 1.17288664e-01f, 9.38427076e-03f, -2.30153222e-02f, -1.93068851e-02f,
  -1.98954418e-02f, -3.86730507e-02f, -4.09158580e-02f, 2.24244893e-02f, -3.89760584e-02f, -6.24670312e-02f, 9.32839606e-03f, -5.66475792e-03f, 3.45648564e-02f, 9.84469429e-03f,
  -3.81698337e-04f, 8.86662165e-04f, -7.58920424e-03f, 9.76291951e-04f, -2.91283540e-02f, 4.30335812e-02f, 2.93591991e-02f, 6.70653954e-02f, -2.39968132e-02f, -4.46965061e-02f,
  1.72160603e-02f, 4.31385674e-02f, 2.82182060e-02f, -4.95398603e-02f, -5.96351456e-03f, 4.04257104e-02f, 4.86187860e-02f, -1.97444782e-02f, 5.76067641e-02f, 5.81438690e-02f,
  -7.42524629e-03f, -6.32550344e-02f, 2.59442385e-02f, -7.91170821e-02f, 3.84406559e-02f, -1.68664306e-02f, 9.31922626e-03f, 8.86822045e-02f, -1.82240773e-02f, 4.89346907e-02f,
  -2.98919473e-02f, 2.85300594e-02f, 1.14205545e-02f, 7.13661090e-02f, 6.48339652e-03f, -5.95241375e-02f, 1.79684926e-02f, -5.77099901e-03f, 5.79955615e-02f, 9.92755592e-02f,
  1.52768075e-01f, 8.86989161e-02f, -1.41070494e-02f, 2.97769569e-02f, -1.29732164e-02f, -5.57512268e-02f, -3.59944925e-02f, -2.93559209e-02f, 3.66323628e-02f, -3.36845331e-02f,
  1.11905463e-01f, 3.49888168e-02f, 7.98964649e-02f, -3.41895968e-02f, 2.73256432e-02f, -3.26006562e-02f, 1.00906059e-01f, 2.89194621e-02f, -2.62959721e-03f, -3.95535864e-02f,
  -5.80170238e-03f, -5.02349623e-03f, -1.45194456e-02f, -6.07826822e-02f, 5.85948974e-02f, 5.58751784e-02f, -4.75352444e-02f, 8.62256344e-03f, 6.56438293e-04f, -8.37704819e-03f,
  1.96106181e-01f, -1.43656358e-01f, 6.02723286e-02f, -9.50902402e-02f, 2.89612450e-02f, -3.78193289e-01f, -1.80675223e-01f, -5.31750694e-02f, 1.17719509e-01f, -8.37183595e-02f,
  -6.83270544e-02f, 1.66644052e-01f, 1.30913230e-02f, -3.21396858e-01f, -3.04105252e-01f, -1.11937448e-01f, -3.37948650e-01f, -1.36207014e-01f, 6.14418983e-02f, -1.74211845e-01f,
  -5.35292104e-02f, -1.78385884e-01f, -1.34137616e-01f, -1.00150749e-01f, -4.64891158e-02f, 1.29431173e-01f, 4.08340665e-03f, 1.03881836e-01f, -1.93054285e-02f, -4.99383826e-03f,
  1.00343861e-02f, 7.46886805e-02f, 5.99726997e-02f, 9.35328156e-02f, -6.64093718e-02f, 1.21482667e-02f, -2.45249644e-02f, 1.73153952e-02f, 6.78398386e-02f, 3.24996002e-02f,
  1.83793250e-02f, 5.82910217e-02f, -2.08664760e-02f, 7.46354610e-02f, 3.26666422e-03f, 6.57315999e-02f, 2.84145977e-02f, -5.38191380e-05f, 6.34636357e-02f, -8.44585802e-03f,
  -2.81185694e-02f, 1.61140726e-03f, -4.65791635e-02f, 1.21885492e-02f, 5.07433936e-02f, 1.54111544e-02f, -1.72993336e-02f, 4.06755507e-02f, -1.38831595e-02f, -3.69780138e-02f,
  3.45573723e-02f, -3.89446318e-02f, 2.94936486e-02f, 4.28280272e-02f, -5.37483860e-03f, -1.35714076e-02f, 4.57059499e-03f, 7.15755718e-03f, 4.18541096e-02f, -6.30812347e-02f,
  -2.51322761e-02f, 6.82140365e-02f, 4.47132774e-02f, -3.40562835e-02f, 1.55071616e-02f, -4.57780669e-03f, 5.71782794e-03f, -1.92732289e-02f, -2.18088757e-02f, 9.15179215e-03f,
  -2.06839647e-02f, -3.27772684e-02f, 2.02916865e-03f, 1.36772748e-02f, 3.84790037e-04f, 4.12924699e-02f, 3.22432034e-02f, 3.77555490e-02f, -9.95768327e-03f, -2.28439849e-02f,
  -2.08863929e-01f, -2.11172059e-01f, 2.17506122e-02f, 5.98529056e-02f, -5.01054749e-02f, -4.08496819e-02f, 4.33981866e-02f, -7.80206406e-03f, -6.95385784e-02f, -3.52925137e-02f,
  -5.66881187e-02f, -2.77388301e-02f, -4.41546738e-02f, 2.34514475e-03f, -4.49051708e-02f, -6.18060008e-02f, -4.81164679e-02f, -1.15498528e-02f, -1.03542522e-01f, -3.60872336e-02f,
  1.47378091e-02f, -6.08509295e-02f, 4.62787040e-03f, -7.84104168e-02f, -8.67931694e-02f, -2.78351572e-03f, -1.96427032e-02f, 1.26854228e-02f, -3.55638973e-02f, 2.62054522e-02f,
  -3.24939132e-01f, 3.37479323e-01f, 2.90789723e-01f, 1.98705886e-02f, -1.86568424e-01f, 2.22966298e-01f, 2.19332665e-01f, 1.65775102e-02f, -6.98170578e-03f, 2.38662481e-01f,
  -9.71937999e-02f, 7.78357387e-02f, 1.53028041e-01f, 7.81103447e-02f, -9.71742943e-02f, 2.27780551e-01f, 1.09949358e-01f, 5.27053289e-02f, -6.49480075e-02f, -4.24524350e-03f,
  -1.03054076e-01f, -1.84312880e-01f, 4.87811267e-02f, -1.37700230e-01f, -5.51730879e-02f, -5.56807369e-02f, -1.47109702e-01f, 9.59415212e-02f, -7.28487149e-02f, -6.04829676e-02f,
  -1.01286769e-01f, -1.01048298e-01f, -1.00939065e-01f, 1.33370562e-02f, 3.91485430e-02f, 4.88922745e-02f, 6.44388124e-02f, 5.57864048e-02f, -3.01045645e-02f, -4.86464836e-02f,
  1.30755184e-02f, 1.05884625e-02f, -3.99971344e-02f, -2.18236148e-02f, 3.69616300e-02f, -1.07536502e-02f, 1.31453658e-02f, 9.89110116e-03f, -1.89694166e-02f, -4.84620109e-02f,
  4.74369973e-02f, -2.93401536e-02f, 1.65097546e-02f, -1.60530936e-02f, -6.00193925e-02f, 3.57040279e-02f, 3.09385005e-02f, 1.35904383e-02f, 6.06047772e-02f, -4.28645797e-02f,
  2.51790117e-02f, 3.77948172e-02f, -8.07013921e-03f, 2.11640391e-02f, -4.64885123e-02f, -8.04535300e-02f, 2.63907686e-02f, -9.00686160e-03f, -7.71611463e-04f, -6.25436381e-02f,
  -1.92614365e-02f, -7.64538199e-02f, 2.05750037e-02f, -5.72243189e-05f, 1.67320222e-02f, -2.35031378e-02f, 2.84358691e-02f, -3.04528642e-02f, 1.68914553e-02f, -5.55089898e-02f,
  6.48890287e-02f, -4.33787927e-02f, 4.40079197e-02f, -5.43543100e-02f, -8.03080015e-03f, -1.05992751e-02f, 2.07687393e-02f, 7.68456841e-03f, -3.47960629e-02f, -8.48611370e-02f,
  -1.13730151e-02f, 1.34838998e-01f, -8.75476631e-04f, -8.67078081e-02f, -5.08329123e-02f, -7.63572473e-03f, -4.91808392e-02f, -5.43620735e-02f, 7.37504736e-02f, 9.08154296e-04f,
  1.43027762e-02f, -1.38631826e-02f, 5.57499714e-02f, 3.47294775e-03f, 8.61335769e-02f, -9.09850746e-03f, 5.74514605e-02f, 5.09256730e-03f, 2.01785918e-02f, -4.09442075e-02f,
  -6.58922270e-02f, 4.53959443e-02f, -2.16989703e-02f, -1.96101498e-02f, 4.22844850e-02f, 9.43563227e-03f, -6.11274093e-02f, -9.97649226e-03f, 2.00722441e-02f, 6.38148468e-03f,
  2.73200572e-01f, -1.07021602e-02f, 1.93476394e-01f, 3.50414157e-01f, 9.96534154e-03f, -1.15527483e-02f, -1.17936268e-01f, 8.48803446e-02f, 1.56846642e-01f, -1.89970091e-01f,
  -2.15066224e-01f, 2.32649803e-01f, -3.31001490e-01f, -9.27264392e-02f, -1.12032071e-01f, -2.43407041e-01f, 4.72744741e-02f, -5.94008677e-02f, 3.03822272e-02f, 1.32432759e-01f,
  1.09125890e-01f, -1.39074489e-01f, 1.16107948e-01f, -1.20480858e-01f, 1.15983076e-01f, 2.30691239e-01f, -1.23191863e-01f, 1.59852847e-03f, -1.25570549e-02f, -9.17833522e-02f,
  -1.15490027e-01f, 9.81092677e-02f, 5.25787100e-03f, 9.50867906e-02f, 1.30056748e-02f, -2.95488238e-02f, 1.47617161e-02f, -2.04655603e-02f, 4.87394221e-02f, 2.17970144e-02f,
  -2.18169186e-02f, -4.76202136e-03f, -8.07666779e-03f, -7.58935213e-02f, 1.03497766e-01f, 1.67938303e-02f, -6.36422774e-03f, 7.03611746e-02f, 5.86862192e-02f, -3.66173796e-02f,
  3.94662693e-02f, 2.45913714e-02f, 9.82570946e-02f, -6.32762909e-02f, 4.73934524e-02f, 2.74961665e-02f, 2.17497963e-02f, 2.87813954e-02f, 1.54062733e-02f, 4.07373160e-02f,
  -8.89483094e-02f, 2.48729624e-02f, 1.72658246e-02f, 3.66617441e-02f, 1.68065645e-03f, 3.46670821e-02f, -3.75966281e-02f, -2.03683879e-02f, -1.03372391e-02f, -2.40039229e-02f,
  2.43068840e-02f, -6.03243103e-03f, 8.25930852e-03f, 1.25576474e-03f, 1.67006459e-02f, 3.08567956e-02f, 3.95305753e-02f, -2.62642261e-02f, 5.20369112e-02f, 4.15950567e-02f,
  -3.03057414e-02f, 3.82126831e-02f, -7.75814727e-02f, -3.22908685e-02f, 8.70437920e-03f, 4.55170497e-02f, -2.89817597e-03f, 5.19469865e-02f, 5.10345995e-02f, -6.58886973e-03f,
  -1.35479569e-01f, -6.63417354e-02f, 6.26225099e-02f, 2.40953229e-02f, -4.80881659e-03f, -5.15936725e-02f, -4.67145070e-02f, -3.28729227e-02f, 3.41216214e-02f, -2.09774968e-04f,
  3.49793490e-03f, 6.53802156e-02f, -5.67308851e-02f, 2.10679267e-02f, 1.22722378e-02f, -4.29353565e-02f, 4.86699790e-02f, 6.27620295e-02f, -2.55844509e-03f, -2.67517995e-02f,
  -3.92351486e-02f, -6.10300638e-02f, 4.97277603e-02f, -1.49139734e-02f, 2.26163659e-02f, 1.09420111e-03f, 2.21161339e-02f, -2.08787546e-02f, -5.80983646e-02f, -3.36259231e-02f,
  2.38555849e-01f, -1.45278618e-01f, 1.72329351e-01f, 2.08729774e-01f, -6.41682968e-02f, -1.44508690e-01f, 1.32317066e-01f, -8.57333392e-02f, 1.48242980e-01f, -2.31729195e-01f,
  -2.82720830e-02f, 1.01966158e-01f, 5.23396470e-02f, 6.75587803e-02f, 8.81323144e-02f, 3.20737995e-02f, -4.12480049e-02f, 4.04598005e-02f, 5.34666702e-02f, -5.13624549e-02f,
  1.14261605e-01f, -1.79927289e-01f, 8.71308371e-02f, -2.12717503e-01f, 8.90380666e-02f, 8.62764716e-02f, -1.41712189e-01f, -5.17257974e-02f, -9.90371704e-02f, -5.09989485e-02f,
  -1.01894848e-01f, 1.26145305e-02f, 7.88021609e-02f, -3.25207111e-05f, 2.80489549e-02f, 6.19407222e-02f, -3.05262301e-02f, 4.61049676e-02f, 4.85313544e-03f, 5.34817800e-02f,
  4.61613759e-02f, 2.87503805e-02f, 6.85899183e-02f, 2.15965342e-02f, -2.07791221e-03f, -3.71620394e-02f, 7.89396837e-03f, 5.17633781e-02f, 4.90104035e-02f, 3.23849246e-02f,
  2.26048026e-02f, -3.22581008e-02f, 7.26473331e-02f, 6.39246823e-03f, 5.10136038e-02f, -6.54916987e-02f, -2.46342979e-02f, 5.25997542e-02f, -4.89228684e-03f, -2.97227334e-02f,
  8.92100930e-02f, 4.19784710e-02f, 1.30709698e-02f, -8.22456367e-03f, -1.34090602e-03f, 4.01853994e-02f, -7.47120604e-02f, 1.02194101e-02f, -1.26907015e-02f, -2.61468887e-02f,
  2.16308255e-02f, 2.47690026e-02f, 4.67949025e-02f, 9.01144056e-04f, -3.93234938e-02f, 5.70663111e-03f, -4.16806228e-02f, -4.23121937e-02f, 1.81389451e-02f, 4.59724665e-02f,
  -3.65657806e-02f, -1.83904357e-03f, -4.03902978e-02f, -1.23685310e-02f, -4.69047651e-02f, 4.85171787e-02f, 6.86396379e-03f, 3.54706347e-02f, 2.71902680e-02f, -2.67134485e-04f,
  -3.11324030e-01f, -2.36445650e-01f, 1.15179233e-02f, -8.33654404e-02f, -1.03459381e-01f, -6.98576197e-02f, -3.83384824e-02f, 4.01466759e-03f, -2.69498024e-02f, -8.81398767e-02f,
  -8.33984390e-02f, 4.42223810e-02f, -9.20594260e-02f, -2.54221056e-02f, -3.19439098e-02f, 2.06367951e-02f, -5.97668961e-02f, 1.69976652e-02f, -7.00846240e-02f, -8.90653804e-02f,
  -5.11229634e-02f, -7.26993755e-02f, 6.97833998e-03f, 1.48814293e-02f, -3.07109449e-02f, 2.89836135e-02f, 5.02558425e-02f, 6.70518726e-02f, -4.62947451e-02f, -1.83803309e-02f,
  2.99408406e-01f, -2.23389924e-01f, 9.10772309e-02f, 1.91940501e-01f, -2.48592831e-02f, 2.20439762e-01f, 1.57359272e-01f, -2.00799823e-01f, 8.56263377e-03f, -5.92075624e-02f,
  -1.17162399e-01f, 1.99176326e-01f, -2.37523526e-01f, 1.21086933e-01f, 1.90791219e-01f, -6.50555044e-02f, 9.55366120e-02f, 1.95805043e-01f, -6.92221150e-02f, -7.70087689e-02f,
  1.64317451e-02f, -7.09783286e-02f, -9.92829427e-02f, -1.07857011e-01f, 7.74189681e-02f, -1.53463781e-02f, -1.85425654e-01f, -6.64032102e-02f, 8.38275254e-02f, 2.75854394e-02f,
  8.80926624e-02f, -1.59588262e-01f, 8.15636739e-02f, 1.62819922e-02f, -2.38911081e-02f, 6.99647218e-02f, 1.24789022e-01f, 3.77194174e-02f, 5.08203357e-02f, -6.18067756e-02f,
  4.44174409e-02f, -1.30494293e-02f, 3.55165228e-02f, -3.27354949e-03f, 9.44035652e-04f, 3.90749089e-02f, 6.66794404e-02f, -8.70549586e-03f, -4.63274680e-02f, 4.48726788e-02f,
  3.97601612e-02f, -5.97853474e-02f, 7.63697131e-03f, 5.30192032e-02f, 5.85292131e-02f, 2.13238448e-02f, 3.87235731e-02f, 9.61835030e-03f, 5.88709153e-02f, 1.89597253e-02f,
  -5.56697976e-03f, -3.59704196e-02f, -3.45761888e-02f, -9.11280792e-03f, 2.85859555e-02f, -6.38667047e-02f, 1.34656327e-02f, -3.48837823e-02f, 8.96696672e-02f, 6.29069703e-03f,
  -4.82648285e-03f, 4.27338742e-02f, -1.94352046e-02f, 3.01603917e-02f, 4.33877446e-02f, 5.90747334e-02f, 8.25050287e-03f, 1.74829662e-02f, 4.95113395e-02f, -3.16187814e-02f,
  3.10247368e-03f, 6.08011633e-02f, -4.55746129e-02f, -3.36276516e-02f, 5.74697815e-02f, -1.47200776e-02f, -6.80650547e-02f, 8.91835541e-02f, -1.52679356e-02f, 4.56936657e-02f,
  1.60568641e-04f, -1.49625182e-01f, -8.88570249e-02f, -1.75316948e-02f, 8.52235500e-03f, -6.82982653e-02f, 5.98879680e-02f, 4.10009250e-02f, -3.29293758e-02f, -4.88026179e-02f,
  -6.87475204e-02f, -2.30616471e-03f, -4.17571217e-02f, -2.47264374e-02f, 7.05515221e-02f, -9.90080088e-02f, -2.04455499e-02f, 4.37347479e-02f, 2.54161190e-02f, -4.32893708e-02f,
  -5.37113473e-02f, 6.05501570e-02f, -1.90643892e-02f, 1.39827160e-02f, 3.26145552e-02f, 5.39136343e-02f, -2.98525561e-02f, 6.90340623e-02f, 3.72549379e-03f, 3.10473852e-02f
};

// L0_fan_Wp_bar (Shape: 104 x 120)
const int L0_fan_Wp_bar_rows = 104;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  1.76098645e-01f, -2.35891253e-01f, 1.56827375e-01f, 1.92428858e-03f, 1.66477740e-01f, 2.31328495e-02f, 1.21259071e-01f, -6.24240339e-02f, 9.77231190e-02f, -2.77918607e-01f,
  -3.35891545e-02f, 6.02484271e-02f, 1.04682989e-01f, -1.58629060e-01f, 1.56236529e-01f, -1.89098548e-02f, 4.53446788e-04f, -2.55619455e-02f, 1.37764633e-01f, -1.11930735e-01f,
  5.08517139e-02f, -1.66222394e-01f, 1.48993097e-02f, -2.24129423e-01f, -8.76204595e-02f, -9.22279432e-02f, -6.36947975e-02f, 1.02445893e-01f, -2.14913949e-01f, 1.75922699e-02f,
  2.57623885e-02f, 3.30670178e-02f, -7.62507543e-02f, -9.13980752e-02f, -4.57056686e-02f, -7.96969160e-02f, 5.17220888e-03f, -1.08736632e-02f, 9.62415412e-02f, -6.58891723e-02f,
  -2.56852456e-03f, -1.19331768e-02f, -6.13697730e-02f, -3.44282947e-02f, -2.71098800e-02f, -1.06911287e-01f, -2.56980974e-02f, 6.48035556e-02f, -5.87593094e-02f, -3.93487997e-02f,
  -4.78846207e-02f, -2.49093678e-02f, 2.25627515e-02f, 6.98923739e-03f, 6.19178973e-02f, -1.17915748e-02f, -1.10485014e-02f, 1.67393517e-02f, -7.01482669e-02f, 4.42716554e-02f,
  -9.29152071e-02f, -4.36870530e-02f, -4.91342833e-03f, 5.97972609e-03f, 1.49318343e-03f, 1.57102644e-02f, 5.01613058e-02f, -1.90021582e-02f, 3.02137720e-04f, -7.50785917e-02f,
  8.44476447e-02f, -7.35152094e-03f, 8.02033208e-03f, -1.07584515e-06f, -9.33670090e-04f, -2.79690661e-02f, 2.02389620e-02f, -9.21595618e-02f, -4.21265289e-02f, 1.57094989e-02f,
  6.92940084e-03f, -2.44784318e-02f, 6.03171699e-02f, 9.42261051e-03f, 1.03897341e-02f, -4.69677821e-02f, -5.36161549e-02f, -8.36252198e-02f, 3.57032120e-02f, 5.72048090e-02f,
  1.14528779e-02f, -9.67776179e-02f, 7.25054964e-02f, -6.55819252e-02f, 3.43807153e-02f, 1.47878155e-02f, 1.01890147e-03f, -1.24014565e-04f, 6.07688576e-02f, 4.63244319e-02f,
  -2.85782036e-03f, -6.97124153e-02f, -8.52699950e-02f, 1.67807415e-02f, 7.45680474e-04f, -3.75707708e-02f, -6.87652752e-02f, -1.11496709e-01f, -2.32184827e-02f, -1.03749342e-01f,
  -7.82394856e-02f, -2.41681859e-02f, -1.31223002e-03f, 2.74389535e-02f, 2.57929750e-02f, 5.55672795e-02f, 5.47935143e-02f, -5.14616333e-02f, -4.81027700e-02f, -5.21737114e-02f,
  -6.98037744e-02f, 1.30643919e-02f, 9.62404255e-03f, 1.32548764e-01f, -7.98519999e-02f, -1.21812336e-01f, -1.42649204e-01f, 3.31082121e-02f, 1.15151312e-02f, -1.23727452e-02f,
  6.91867396e-02f, 2.28003878e-02f, -4.10639420e-02f, 7.06196427e-02f, -8.78045633e-02f, 2.72551794e-02f, -1.55493440e-02f, -4.18845229e-02f, 3.75922807e-02f, 8.66858363e-02f,
  -4.02649157e-02f, 8.61367285e-02f, 1.36574090e-01f, 8.46355483e-02f, -2.41056290e-02f, 1.51495397e-01f, 1.97145119e-02f, 2.15377640e-02f, 1.53657451e-01f, 5.25593832e-02f,
  3.16238962e-02f, 4.96059947e-04f, -2.80483942e-02f, -4.08531912e-02f, 6.33735815e-03f, 5.18843085e-02f, -3.00209653e-02f, 1.65311024e-02f, -5.03595965e-03f, 5.91412745e-02f,
  -2.46841386e-02f, -3.89800072e-02f, -1.06105395e-02f, -1.06719992e-04f, -1.29786786e-02f, -4.44905199e-02f, 8.96530896e-02f, -4.54056934e-02f, 6.66417480e-02f, -4.00779322e-02f,
  1.62369218e-02f, 7.09996819e-02f, -6.03080317e-02f, -4.62522283e-02f, 9.39948782e-02f, -6.15628734e-02f, -9.31512471e-03f, -7.66825452e-02f, -4.96343076e-02f, 4.68325838e-02f,
  -3.57875526e-02f, -5.08495932e-03f, -4.52900305e-02f, 2.59827729e-02f, -1.06219076e-01f, 8.93338174e-02f, 2.78178900e-02f, -5.27595393e-02f, 6.00610673e-03f, 9.27242637e-02f,
  4.65127900e-02f, 8.96244198e-02f, -8.48508477e-02f, 8.10888931e-02f, -3.09685022e-02f, 7.99856633e-02f, 3.31840813e-02f, -5.96190691e-02f, -3.16958167e-02f, 6.64416328e-02f,
  1.12965712e-02f, -8.34318027e-02f, -1.24132885e-02f, 6.20137937e-02f, -5.62453121e-02f, -5.52921072e-02f, -6.24192357e-02f, -2.63168383e-02f, -9.08233225e-02f, -7.06803277e-02f,
  1.17617697e-01f, 1.25300314e-03f, 1.98166501e-02f, 8.07240903e-02f, -2.81577501e-02f, 2.81555038e-02f, 5.45510240e-02f, 7.96829015e-02f, 7.20510483e-02f, 1.78946592e-02f,
  5.74196391e-02f, -3.69578525e-02f, -2.39899140e-02f, -4.21476439e-02f, -2.57853437e-02f, -6.98895156e-02f, -7.49560772e-04f, 2.42558587e-02f, -5.51563278e-02f, -5.82941696e-02f,
  -6.95048831e-03f, -4.81194817e-02f, -7.02986196e-02f, 4.18001637e-02f, 6.53139129e-02f, 6.59274533e-02f, 5.31943142e-02f, -1.72517411e-02f, 2.49151476e-02f, 8.76328256e-03f,
  1.68645792e-02f, -1.04483947e-01f, 9.02383924e-02f, 5.71468621e-02f, -2.31260341e-02f, -1.35508329e-01f, -9.51528326e-02f, 5.30801751e-02f, 2.97134053e-02f, -4.76860851e-02f,
  1.05508640e-01f, 2.22342042e-03f, 5.87344542e-02f, 5.33833578e-02f, 1.40497193e-01f, 1.08544156e-01f, 5.70954047e-02f, 8.28162804e-02f, 8.12462643e-02f, -2.45240796e-02f,
  1.29128143e-01f, 3.44786830e-02f, 1.61488414e-01f, 1.00222630e-02f, -8.76059383e-03f, 4.14954685e-02f, 1.20007813e-01f, 1.12034857e-01f, -1.48940170e-02f, 2.43367087e-02f,
  -9.83820185e-02f, 6.45904914e-02f, 7.04093426e-02f, -6.07173098e-03f, 4.59145308e-02f, -9.51339751e-02f, -1.82887726e-02f, -5.20245172e-02f, -4.77016792e-02f, 1.17149204e-02f,
  -9.91899148e-02f, 7.65570253e-02f, -9.94707458e-03f, 3.07438616e-02f, -1.06533170e-01f, -2.89070606e-02f, -8.48579183e-02f, -2.04923246e-02f, -5.65389097e-02f, 5.32220602e-02f,
  1.01930387e-01f, -7.59989470e-02f, 8.42759684e-02f, 4.88041574e-03f, 4.15424956e-03f, -3.08670774e-02f, 5.89210950e-02f, 1.64028648e-02f, -6.50950968e-02f, 6.64414018e-02f,
  3.95924272e-03f, 7.41534829e-02f, 9.00838301e-02f, -3.95931350e-03f, 7.86110014e-02f, 2.77303606e-02f, 5.85597865e-02f, 3.91473845e-02f, -8.08963925e-03f, 5.46143502e-02f,
  2.82652918e-02f, 9.88420621e-02f, -3.16216424e-02f, 5.23686083e-03f, 6.28528520e-02f, 3.40527184e-02f, 6.86907843e-02f, 2.90350039e-02f, 6.71238825e-02f, -9.73539893e-03f,
  -5.83916977e-02f, 7.90518597e-02f, 6.02887720e-02f, 9.14676413e-02f, 7.99707770e-02f, -2.90576858e-03f, -3.95845361e-02f, -2.43627764e-02f, -2.00352632e-02f, 7.93985128e-02f,
  -1.38452202e-01f, 1.97722707e-02f, 2.57531889e-02f, 1.74529236e-02f, 6.89279959e-02f, -1.36202378e-02f, 3.77150998e-02f, -9.05182511e-02f, -9.28997342e-03f, 5.59608079e-02f,
  -9.55469906e-02f, -2.79479194e-02f, -4.98928390e-02f, 6.67453632e-02f, 2.43412275e-02f, 6.50813654e-02f, -2.54716109e-02f, 4.10755724e-02f, -5.21908142e-03f, 4.80347164e-02f,
  -6.74034730e-02f, -1.20427012e-02f, 3.45249660e-02f, 5.06034642e-02f, 7.57780150e-02f, -1.30373240e-02f, 2.79235542e-02f, 6.65643718e-03f, 3.14152539e-02f, -1.71360001e-02f,
  1.02602854e-01f, -2.85650808e-02f, 8.04473236e-02f, 1.02332070e-01f, 1.90287940e-02f, -1.42525017e-01f, 4.58276160e-02f, 9.05332938e-02f, 1.10515885e-01f, -1.32591560e-01f,
  -2.41728220e-02f, -1.46756740e-02f, -8.04385245e-02f, -5.72310835e-02f, 8.55252966e-02f, -8.92524645e-02f, -3.28280963e-02f, -8.50529075e-02f, 2.22528316e-02f, -1.05245803e-02f,
  1.13338478e-01f, 5.48458025e-02f, -3.48279104e-02f, 7.58777708e-02f, -1.46043925e-02f, 1.46988809e-01f, 4.88897189e-02f, -1.22365290e-02f, -3.50506380e-02f, -5.57367839e-02f,
  -8.91265795e-02f, 1.33392408e-01f, 9.44374651e-02f, -4.70234603e-02f, 2.82927249e-02f, -5.95707223e-02f, 1.75616778e-02f, -3.29284221e-02f, 1.61713995e-02f, -8.33838363e-04f,
  5.23854531e-02f, 2.11815583e-03f, 4.76535819e-02f, 1.74984951e-02f, -5.72263114e-02f, 7.98894837e-02f, -5.28338924e-02f, 4.97230841e-03f, 4.17165197e-02f, 5.81784658e-02f,
  -1.75351519e-02f, 1.66899525e-02f, 5.98600358e-02f, -9.39655825e-02f, -1.96311865e-02f, 3.56450565e-02f, -8.53454992e-02f, -3.70411873e-02f, -3.08882203e-02f, 1.82505790e-02f,
  9.67289507e-02f, -5.95546477e-02f, -2.62262598e-02f, -7.78984427e-02f, -4.24139947e-02f, 8.56696218e-02f, 6.88465685e-02f, 2.76231412e-02f, 4.72955070e-02f, -8.30897130e-03f,
  5.67082316e-02f, -2.27439683e-02f, -4.35052365e-02f, 3.08027081e-02f, 9.15653929e-02f, 1.46460328e-02f, 2.06535198e-02f, 2.04702057e-02f, -2.07183883e-02f, 6.29913211e-02f,
  -5.12515903e-02f, 4.23343964e-02f, -8.05353448e-02f, -9.65422858e-03f, -7.46088400e-02f, -3.14842612e-02f, -7.39560425e-02f, -6.55011758e-02f, -8.80583469e-03f, -7.18233436e-02f,
  -1.93422772e-02f, 3.58533151e-02f, -1.09378891e-02f, -8.53652433e-02f, 6.86639026e-02f, 1.13644227e-02f, -3.27509232e-02f, -1.78158376e-02f, 1.66039839e-02f, 2.80187149e-02f,
  1.22167757e-02f, 6.64381832e-02f, -1.06615514e-01f, 2.40147440e-03f, -1.75811015e-02f, 8.09921250e-02f, 3.14082503e-02f, 7.27072265e-03f, 5.21426462e-02f, 3.88325676e-02f,
  -5.97765148e-02f, 8.03540200e-02f, 5.30390032e-02f, 2.06587221e-02f, 8.74995312e-04f, -3.29226777e-02f, -7.90793896e-02f, 8.51886198e-02f, 7.61810690e-02f, -2.97697391e-02f,
  2.75713116e-01f, -1.20264195e-01f, 3.02911783e-03f, 5.04379794e-02f, 1.61634326e-01f, -2.59211920e-02f, 3.80082056e-02f, -2.71355938e-02f, -5.50173670e-02f, -5.64012378e-02f,
  -5.76290628e-03f, -1.15265839e-01f, -6.45093992e-02f, 4.32812981e-02f, 6.45840317e-02f, -1.49468957e-02f, 3.36022787e-02f, 1.09322052e-02f, 2.44218409e-02f, 8.11249241e-02f,
  4.77973968e-02f, 1.90711822e-02f, -8.52657855e-03f, -1.29729763e-01f, 1.46547869e-01f, -6.73614368e-02f, -2.67602112e-02f, -7.72206709e-02f, 6.99308515e-02f, -1.52098546e-02f,
  8.15297589e-02f, 6.03353940e-02f, 3.99786159e-02f, -4.97528426e-02f, -5.54545224e-02f, 6.21100217e-02f, -4.88847145e-04f, -5.15426658e-02f, 7.88252577e-02f, 9.61511210e-02f,
  -8.79265554e-03f, -2.79307868e-02f, -5.66734970e-02f, 5.42262802e-03f, 8.34991783e-02f, -3.31493989e-02f, 1.01515457e-01f, 1.36732506e-02f, -1.06359273e-02f, -2.50659715e-02f,
  -4.01663929e-02f, 5.42732514e-02f, -1.29572896e-03f, -1.19156078e-01f, -5.28179072e-02f, -3.66743989e-02f, -4.95067798e-02f, -2.29372047e-02f, 2.71058269e-02f, 1.41214123e-02f,
  -1.11435605e-02f, -6.32590801e-02f, 5.43170162e-02f, -3.42679769e-02f, 7.04567507e-02f, 3.62145454e-02f, 5.84483296e-02f, -6.83560744e-02f, -6.78204894e-02f, 6.53020339e-04f,
  3.33254971e-02f, -3.31840664e-02f, 7.32452646e-02f, -6.48538619e-02f, -1.68051217e-02f, -6.74129501e-02f, -2.06851810e-02f, 2.02038065e-02f, -1.62511598e-02f, 5.31559289e-02f,
  3.85386199e-02f, -2.93916557e-02f, 5.45939878e-02f, 4.93288711e-02f, -6.85812533e-02f, 1.00857712e-01f, 3.71344239e-02f, 7.11944476e-02f, -2.26497576e-02f, -6.58191890e-02f,
  3.05094626e-02f, -1.72622651e-02f, -5.73337749e-02f, -2.35841107e-02f, -5.38974665e-02f, 1.86023489e-02f, -7.71033838e-02f, 3.29733305e-02f, 5.00102006e-02f, 7.65763894e-02f,
  6.00951910e-02f, -3.94852720e-02f, -7.13823587e-02f, -6.87541440e-02f, 5.44549488e-02f, 6.79311454e-02f, -7.95984417e-02f, 4.19406854e-02f, 5.63536882e-02f, 6.13324828e-02f,
  8.34645424e-03f, -4.74155694e-02f, 2.62880363e-02f, -7.16886222e-02f, -6.93646120e-03f, -1.06073022e-02f, -2.37153843e-02f, -8.22215304e-02f, -7.40448162e-02f, -2.55767573e-02f,
  2.24824756e-01f, 1.92342382e-02f, -1.64605334e-01f, 7.72640780e-02f, -1.78247895e-02f, 1.09580100e-01f, -6.70050411e-03f, -2.89660804e-02f, -1.38088483e-02f, -7.31853861e-03f,
  9.53395590e-02f, -9.00943801e-02f, -1.47182718e-01f, 1.10728234e-01f, 8.25809911e-02f, -3.99232469e-02f, 1.10953055e-01f, 1.60792135e-02f, -5.68541288e-02f, 7.99708162e-03f,
  1.15649458e-02f, 2.32955515e-01f, -9.88339782e-02f, 1.12693906e-01f, 1.07654534e-01f, -1.08958013e-01f, 1.05677955e-01f, -1.40843511e-01f, 1.03822373e-01f, 7.65199140e-02f,
  7.27412477e-02f, 1.18578203e-01f, -2.13023443e-02f, 5.18593006e-03f, -2.44416725e-02f, 3.44490167e-03f, -1.00877564e-02f, -6.60248660e-03f, -2.67075449e-02f, 4.76922244e-02f,
  -1.25426808e-02f, -3.51020470e-02f, -1.26907825e-02f, -5.83677813e-02f, 9.57861692e-02f, -4.14670557e-02f, 1.84567994e-03f, -6.09858707e-03f, -9.95633379e-03f, -5.29405661e-02f,
  -9.66476724e-02f, -3.06708422e-02f, -5.98486699e-02f, -6.80959374e-02f, -5.18963300e-02f, -7.06638172e-02f, -6.35110661e-02f, 6.00851723e-04f, 2.06495337e-02f, 4.47653756e-02f,
  1.07451349e-01f, -1.87418330e-02f, 5.55318668e-02f, -5.19867800e-02f, -6.18299656e-02f, -2.15757731e-02f, 6.36244193e-02f, 3.88092436e-02f, 1.93880778e-02f, 7.07380250e-02f,
  4.55711596e-02f, 6.65982440e-02f, 4.12630960e-02f, -1.01681976e-02f, 7.64176026e-02f, -4.27897125e-02f, -2.48366389e-02f, 4.48391922e-02f, -2.04526559e-02f, 2.92622522e-02f,
  -7.43919685e-02f, -3.63791324e-02f, -3.80739942e-02f, -2.04637796e-02f, -3.58525589e-02f, 6.19071685e-02f, 8.55059102e-02f, 5.07209189e-02f, -3.98160703e-02f, 2.19851881e-02f,
  7.11449087e-02f, -6.47852123e-02f, -1.17632225e-02f, -3.46877463e-02f, 3.73985693e-02f, 3.34824286e-02f, -8.96427333e-02f, -8.47919583e-02f, -8.37386493e-03f, 3.17238644e-02f,
  8.27567372e-03f, -2.37195250e-02f, 4.43766452e-02f, 5.37319407e-02f, 6.64799735e-02f, 9.23548043e-02f, -5.42171299e-02f, -9.58679337e-03f, -1.33996215e-02f, 9.91913229e-02f,
  7.83372764e-03f, -1.12741173e-03f, 6.40392676e-02f, -6.12053685e-02f, 4.29394916e-02f, -7.83982053e-02f, -6.09671064e-02f, -1.67422462e-02f, 2.81491969e-02f, -7.40440413e-02f,
  -1.01574501e-02f, 1.26361668e-01f, 1.28644342e-02f, 2.38584336e-02f, -3.21126124e-03f, -2.91381687e-01f, -1.71179250e-01f, 4.70812470e-02f, 9.01353657e-02f, 1.01034857e-01f,
  3.53809027e-03f, 1.61267340e-01f, 1.21709593e-01f, -1.27525017e-01f, -1.64107561e-01f, 3.92834432e-02f, -2.50680447e-01f, -1.55273020e-01f, 1.14823766e-01f, -1.16236851e-01f,
  -4.04348932e-02f, 4.60725762e-02f, 2.03924533e-02f, 9.99419987e-02f, -5.73057011e-02f, 7.09314570e-02f, 5.32393306e-02f, 1.39030337e-01f, -1.44611135e-01f, 3.44479717e-02f,
  -9.92889181e-02f, -2.70674787e-02f, -1.22065227e-02f, 1.00041032e-02f, -8.10488388e-02f, 1.85559336e-02f, -7.81271160e-02f, -4.46256846e-02f, -5.73506951e-03f, 1.98712870e-02f,
  -2.41503119e-02f, -3.33766197e-03f, -1.43589079e-02f, -9.04634828e-04f, 4.28349003e-02f, 7.90338218e-02f, -5.71973212e-02f, -9.65950042e-02f, -3.05394605e-02f, -2.65371613e-02f,
  -5.49611934e-02f, -1.82431191e-04f, -1.19269937e-02f, -2.35694833e-02f, -5.92578873e-02f, -4.76860516e-02f, -5.92291318e-02f, 8.31004083e-02f, 4.56282794e-02f, -7.35360831e-02f,
  2.03767922e-02f, 4.94467393e-02f, 6.94553629e-02f, 9.62192342e-02f, -2.89488416e-02f, -3.21411318e-03f, 4.13312949e-02f, 1.06867617e-02f, 3.03160474e-02f, -5.03586680e-02f,
  -8.34781304e-02f, 1.67962871e-02f, 9.01553333e-02f, -1.07239574e-01f, -3.79961766e-02f, -6.89590499e-02f, -8.84780362e-02f, -3.10980361e-02f, -6.84362277e-02f, 9.43929947e-04f,
  1.20769460e-02f, -7.35187978e-02f, 5.14030270e-02f, 5.45823015e-02f, -9.59026534e-03f, -4.44234796e-02f, 7.41212592e-02f, -2.26000976e-02f, 9.63717047e-03f, -2.87886187e-02f,
  -7.24169463e-02f, 6.46015108e-02f, 1.83028914e-02f, 3.72406170e-02f, -4.85226102e-02f, -3.66019867e-02f, 4.97054532e-02f, 8.60778522e-03f, -1.61428731e-02f, 1.43794846e-02f,
  2.25038491e-02f, -1.96196698e-03f, -5.14972247e-02f, 3.56310979e-02f, -5.96763790e-02f, -3.41836698e-02f, 6.35066330e-02f, 5.59135303e-02f, 3.72924581e-02f, 4.57210131e-02f,
  4.58226427e-02f, -7.87839934e-04f, -7.64328837e-02f, 1.49106076e-02f, -9.51985642e-03f, -6.75826296e-02f, -4.24806364e-02f, -5.96197993e-02f, -4.68042083e-02f, -3.87643538e-02f,
  2.04623863e-02f, -1.13930916e-02f, 4.90029901e-03f, -7.03710318e-02f, -8.88836235e-02f, -7.02680424e-02f, 5.17270677e-02f, -1.04144014e-01f, -9.26798880e-02f, 9.53594223e-02f,
  9.82624516e-02f, 9.76574942e-02f, 1.02528989e-01f, 9.32162330e-02f, -6.26509562e-02f, -9.67517309e-03f, 4.39318046e-02f, 7.32100382e-02f, -5.72483242e-02f, 3.26523557e-04f,
  -1.21417478e-01f, 4.68354076e-02f, -2.55446695e-02f, 2.02357732e-02f, -7.89749101e-02f, -7.50019401e-03f, 3.90815400e-02f, 8.16460103e-02f, 4.61798124e-02f, 1.12134703e-02f,
  -1.54881198e-02f, -9.32150111e-02f, -2.55435072e-02f, -3.09343021e-02f, 5.30436411e-02f, 2.42471276e-03f, -4.11512330e-03f, 2.37742439e-02f, -7.79032782e-02f, -3.69455889e-02f,
  -3.74912806e-02f, 4.39987369e-02f, -3.48630846e-02f, 6.43905178e-02f, 6.21952862e-02f, -2.35128887e-02f, -6.74024671e-02f, 6.72094375e-02f, -8.15908760e-02f, -4.64851595e-02f,
  8.35787058e-02f, 7.29295760e-02f, -6.56571388e-02f, -3.45015824e-02f, 4.09661382e-02f, 4.26961705e-02f, 3.00520081e-02f, 6.37645721e-02f, -5.50059490e-02f, 4.80806828e-02f,
  -7.50387013e-02f, -3.43807600e-02f, -7.94031993e-02f, 8.84771999e-03f, 2.01681461e-02f, -5.31229414e-02f, -6.28089830e-02f, -5.66420071e-02f, -4.03569117e-02f, 3.99841294e-02f,
  -5.51209487e-02f, -6.55074269e-02f, -5.04066050e-02f, 2.65144557e-02f, -2.34610215e-02f, 9.46769416e-02f, 1.91269796e-02f, -5.48004545e-02f, 7.10862577e-02f, 4.15863059e-02f,
  -4.46091108e-02f, -5.78719787e-02f, 8.08743462e-02f, 3.01804543e-02f, -2.12980006e-02f, 2.43596341e-02f, 4.28331178e-03f, 5.26700206e-02f, -6.32943809e-02f, -4.33541760e-02f,
  5.10827713e-02f, -9.41118822e-02f, 6.37670457e-02f, 6.50456697e-02f, 8.87016654e-02f, -1.01832956e-01f, -7.20271170e-02f, -1.64013579e-02f, 6.16634488e-02f, 1.47654088e-02f,
  2.99200658e-02f, 8.76905993e-02f, -4.33641076e-02f, -8.90180096e-02f, 2.42509339e-02f, 4.21465486e-02f, 5.46139851e-02f, -4.26212363e-02f, -4.25141230e-02f, -5.62357903e-02f,
  3.97579893e-02f, 8.08104575e-02f, 6.26365542e-02f, 8.86621177e-02f, 7.75116831e-02f, 5.67186624e-02f, 6.75983354e-02f, -6.73281252e-02f, -9.66705158e-02f, 2.65963301e-02f,
  1.67418152e-01f, -7.44535923e-02f, -2.63105750e-01f, -4.21362668e-02f, 1.09075652e-02f, -1.58407670e-02f, -1.43010497e-01f, 7.30553642e-02f, -1.22973420e-01f, 4.59926063e-03f,
  1.11098982e-01f, -1.04089536e-01f, -6.17216267e-02f, -7.00584799e-02f, 6.03695735e-02f, -3.03060282e-02f, -3.73926833e-02f, 8.27020332e-02f, -9.63665098e-02f, 4.58445698e-02f,
  -7.96066746e-02f, 9.30517167e-02f, -9.17745829e-02f, 8.59812051e-02f, 5.85478507e-02f, -1.11550741e-01f, 4.83062975e-02f, -5.20047918e-02f, -1.38632916e-02f, 8.99089277e-02f,
  -4.31107730e-02f, -4.64447998e-02f, -6.33871481e-02f, -9.49735641e-02f, -6.23814724e-02f, 1.08387567e-01f, -5.25628850e-02f, 8.07105228e-02f, 1.87895428e-02f, -3.45201790e-02f,
  -2.44237594e-02f, -3.96954976e-02f, -2.85489559e-02f, 1.60127319e-02f, -5.04986569e-03f, 1.60315800e-02f, -1.02236360e-01f, -1.29350675e-02f, 4.25221771e-02f, -4.98722047e-02f,
  2.23156065e-02f, 5.97023405e-02f, 2.46463586e-02f, 1.34887425e-02f, 4.48071994e-02f, -1.41289774e-02f, 3.09983883e-02f, -6.88635334e-02f, 4.25580256e-02f, -2.31929924e-02f,
  4.59126495e-02f, -1.20540718e-02f, 5.59929796e-02f, -3.34661938e-02f, -2.03726199e-02f, 6.94427490e-02f, 2.52955649e-02f, -2.46498287e-02f, 2.98344251e-02f, 2.88759563e-02f,
  -2.40772627e-02f, -3.48402485e-02f, 2.36661118e-02f, 7.43201375e-02f, 5.04041612e-02f, 3.80728394e-02f, -2.72576623e-02f, -1.73257161e-02f, -1.18558304e-02f, -6.78584352e-02f,
  4.16421816e-02f, 6.77157938e-02f, -9.11702663e-02f, -8.43535289e-02f, 5.49211763e-02f, 2.71459930e-02f, -6.70669153e-02f, -1.51008517e-02f, -7.88599253e-02f, 1.79792121e-02f,
  7.77318478e-02f, -1.59557089e-02f, 3.89020257e-02f, -1.63507846e-03f, 6.91689104e-02f, -2.86526997e-02f, 8.61416161e-02f, 1.77617185e-02f, 6.15894310e-02f, -1.14640407e-02f,
  2.02717353e-02f, 1.32788969e-02f, 3.64980809e-02f, 6.27533793e-02f, 3.97817716e-02f, -1.42020117e-02f, -5.53177111e-02f, -6.24137484e-02f, -2.32670251e-02f, -1.81625690e-02f,
  -6.45902455e-02f, -6.15665093e-02f, -3.67298275e-02f, -9.59460437e-02f, -7.01360265e-03f, -2.59711072e-02f, -1.24566033e-02f, -9.20636579e-02f, 5.79246543e-02f, -7.71973953e-02f,
  2.88710631e-02f, -1.28902439e-02f, 1.56673864e-01f, 1.70509797e-02f, 6.66600466e-02f, 2.14137211e-02f, -1.16990730e-01f, -5.64253256e-02f, -2.20129400e-01f, -2.23635584e-01f,
  4.39470857e-02f, -3.73378694e-02f, 8.74514505e-02f, 9.54240859e-02f, 1.36970758e-01f, 4.22185212e-02f, 7.78492168e-02f, 4.85945083e-02f, 1.04283191e-01f, 1.33262143e-01f,
  1.58254772e-01f, 6.35202751e-02f, 1.65207714e-01f, 1.11171968e-01f, 1.38193324e-01f, 1.24448955e-01f, 1.49071515e-01f, 6.37427941e-02f, 1.06233850e-01f, -4.34903689e-02f,
  -2.94154771e-02f, 4.65095267e-02f, -2.21084915e-02f, -1.17141135e-01f, 3.53434542e-03f, -3.86300646e-02f, -9.37994104e-03f, -1.99554246e-02f, -7.68273845e-02f, 5.00105806e-02f,
  1.56714916e-02f, 9.09652635e-02f, 1.54286874e-02f, -9.92144551e-03f, -3.51452380e-02f, -4.34545763e-02f, -3.41043398e-02f, -1.28030209e-02f, 9.30978358e-02f, 8.00634772e-02f,
  7.31227398e-02f, -4.79778312e-02f, 2.66960375e-02f, 6.47036210e-02f, 2.66913674e-03f, 3.40441540e-02f, -3.69705968e-02f, 5.23778535e-02f, -5.78430332e-02f, 3.76900546e-02f,
  -4.01024893e-02f, -6.27292767e-02f, -2.51131225e-02f, 4.77957018e-02f, 3.28733586e-03f, -2.43060254e-02f, -2.68313661e-02f, 4.74154018e-02f, 6.31354377e-02f, -1.00335395e-02f,
  -4.42925580e-02f, 8.99975598e-02f, -1.38761066e-02f, -7.90376514e-02f, 3.40186097e-02f, -3.25347669e-02f, 7.29782060e-02f, -7.43076354e-02f, -4.99338768e-02f, -4.52220067e-02f,
  5.68643175e-02f, -9.58484188e-02f, -6.64484361e-03f, -6.27731606e-02f, 5.90838306e-02f, 2.44312920e-02f, -6.42677248e-02f, 7.16529861e-02f, 2.40963288e-02f, -2.04515830e-02f,
  -9.79381651e-02f, 3.63432355e-02f, -6.10559620e-02f, -1.07194901e-01f, 3.77511326e-03f, 1.46725178e-02f, 2.62985956e-02f, -3.89226340e-02f, 9.12238285e-02f, -3.55189405e-02f,
  -7.03280941e-02f, -1.75020359e-02f, -3.63671370e-02f, -3.07206623e-03f, 9.14567262e-02f, -3.11795231e-02f, 3.73886302e-02f, -7.29009882e-02f, -7.28336275e-02f, 5.50236292e-02f,
  7.38117397e-02f, -7.46104047e-02f, 8.60587284e-02f, -9.59608995e-04f, -9.68584965e-04f, -5.08541577e-02f, -4.06195931e-02f, 6.81357235e-02f, 9.32434425e-02f, -1.47052640e-02f,
  -2.00652674e-01f, -1.29171774e-01f, -4.57167886e-02f, 1.38952643e-01f, -6.48942217e-03f, -3.07248216e-02f, -1.93350255e-01f, -3.21961120e-02f, -2.43415624e-01f, -6.17192350e-02f,
  1.13739423e-01f, -5.29805608e-02f, -1.51092708e-01f, 6.06913399e-03f, 6.60623536e-02f, -2.57281691e-01f, 9.43371430e-02f, 3.03923413e-02f, -6.49137869e-02f, 2.08812073e-01f,
  1.27034366e-01f, 2.33514130e-01f, 9.03037116e-02f, 2.18254730e-01f, 1.32619962e-01f, 2.94593394e-01f, 4.08053875e-01f, 1.10810801e-01f, 3.97452772e-01f, 3.75866261e-03f,
  -4.06112969e-02f, -9.87943634e-02f, -4.51093912e-02f, -8.05290490e-02f, 8.57636482e-02f, 1.65939238e-02f, 8.00087675e-02f, -3.66280414e-02f, 4.22751382e-02f, 4.32815216e-02f,
  -4.23079394e-02f, 5.98648563e-02f, 5.38558029e-02f, 2.02003084e-02f, -1.43670188e-02f, 3.95677704e-03f, -6.50620162e-02f, -3.31645906e-02f, -4.62666750e-02f, -1.13015175e-01f,
  -1.09123640e-01f, 3.27829085e-02f, -6.10844083e-02f, 6.07830174e-02f, 7.93399941e-03f, 1.02170752e-02f, 3.38735469e-02f, 3.35838385e-02f, 9.52207893e-02f, -4.98741418e-02f,
  1.02283865e-01f, 1.19828284e-02f, -1.59158912e-02f, -1.34699363e-02f, -6.14371821e-02f, 2.29798164e-02f, 2.97144670e-02f, -8.32315236e-02f, -1.88301504e-02f, -3.70758325e-02f,
  -2.59107631e-02f, -1.66048724e-02f, 3.00550507e-03f, -2.45645409e-03f, -3.31143215e-02f, -1.24167822e-01f, -3.27425487e-02f, -4.71082842e-03f, 2.24980321e-02f, 4.45301160e-02f,
  -5.88325113e-02f, 5.57011459e-03f, -2.15031821e-02f, -3.81388539e-03f, -3.07657500e-03f, 4.56956849e-02f, 1.89592484e-02f, -3.68574299e-02f, 3.34002897e-02f, -3.18185762e-02f,
  1.48159206e-01f, 2.37262055e-01f, 2.92762928e-02f, -5.88110089e-02f, -1.28508974e-02f, 1.72773898e-02f, 1.95245855e-02f, -1.38334231e-02f, 9.88786966e-02f, -8.59991759e-02f,
  1.41511023e-01f, 2.57521980e-02f, -2.60665286e-02f, 6.58665551e-03f, 3.75808664e-02f, 8.94246474e-02f, 8.96191373e-02f, 3.98066156e-02f, 1.08922735e-01f, 5.71899675e-02f,
  1.54271558e-01f, 2.92442907e-02f, 7.10855648e-02f, -6.60699010e-02f, 1.05122343e-01f, 5.40179312e-02f, 9.08117741e-02f, -3.12917382e-02f, -4.67369929e-02f, 3.08456551e-02f,
  -4.25092988e-02f, -6.83573335e-02f, -1.28559902e-01f, -6.19820580e-02f, 1.14645753e-02f, 1.01011783e-01f, -6.00742549e-02f, 4.23486792e-02f, -7.60927051e-02f, 7.02913553e-02f,
  -6.66685924e-02f, 7.08186359e-04f, -9.59304273e-02f, 1.16219833e-01f, 1.06029950e-01f, 6.79493882e-03f, 1.37943998e-01f, 4.07646075e-02f, 7.20248967e-02f, -5.88409640e-02f,
  -5.30329458e-02f, 1.44160628e-01f, -2.25244239e-02f, 9.12041366e-02f, -5.86476624e-02f, -1.14957541e-02f, -4.73826975e-02f, 2.03022733e-02f, 1.04579620e-01f, 1.27470240e-01f,
  9.39356089e-02f, 5.43722846e-02f, -7.65150785e-02f, 4.37323079e-02f, 6.09400310e-02f, -1.78852566e-02f, -3.44171040e-02f, 8.46474338e-03f, 2.52220407e-02f, -4.67549749e-02f,
  -4.70989756e-02f, 9.91930589e-02f, -3.88058349e-02f, 6.06414899e-02f, 5.80558144e-02f, 1.89942773e-02f, 3.57021354e-02f, 4.70438227e-02f, -5.58087975e-02f, -4.23869351e-04f,
  -6.48204982e-02f, -1.28430058e-03f, -2.39862949e-02f, 4.15376108e-03f, 6.23960681e-02f, -8.68375301e-02f, -2.01090928e-02f, 4.89483476e-02f, 1.00752160e-01f, 1.35558406e-02f,
  5.83407246e-02f, 5.79367168e-02f, -4.23534997e-02f, 2.70436723e-02f, 4.29551341e-02f, 3.48491445e-02f, -3.20462994e-02f, -8.82448815e-03f, -5.97803853e-02f, -3.56235839e-02f,
  6.75607324e-02f, -1.60887670e-02f, 7.07784742e-02f, -5.15849851e-02f, 2.15348718e-03f, 2.47943420e-02f, -3.57260741e-02f, -9.57953837e-03f, -6.95721358e-02f, 8.69596601e-02f,
  3.95912863e-02f, 1.02490872e-01f, -7.02865496e-02f, 8.49496052e-02f, 8.07859153e-02f, -8.48857090e-02f, -4.58327457e-02f, 6.68127164e-02f, 3.36247943e-02f, -5.28203929e-03f,
  -3.51985730e-02f, -5.62080853e-02f, 3.21851484e-03f, 8.72088894e-02f, -2.08711959e-02f, -2.80988961e-02f, 8.39892551e-02f, 6.86513036e-02f, 5.22316247e-02f, -7.83290341e-02f,
  -8.44773948e-02f, -5.38177900e-02f, -6.83173686e-02f, -2.43716016e-02f, -4.19616401e-02f, -3.35082188e-02f, -7.73017481e-02f, 1.98636688e-02f, -7.51595274e-02f, 7.01164752e-02f,
  1.47577869e-02f, 5.13528399e-02f, -1.63087044e-02f, 1.65210515e-02f, 4.62127253e-02f, -3.18659544e-02f, 9.09129381e-02f, -8.29126239e-02f, 4.20963466e-02f, -6.68160841e-02f,
  -4.15127605e-01f, 2.56853878e-01f, 2.04867516e-02f, -1.67766690e-01f, 1.66495621e-01f, 9.36475545e-02f, -7.40637481e-02f, 1.38523534e-01f, -6.76333234e-02f, -1.68094456e-01f,
  -1.78517461e-01f, -1.95993617e-01f, -1.42784910e-02f, -1.40230075e-01f, -8.50079805e-02f, 1.89246640e-01f, -1.05357587e-01f, -2.03360587e-01f, 1.54164359e-01f, -1.05406456e-01f,
  -2.30906904e-02f, -1.09760351e-01f, 1.32482089e-02f, 2.52673775e-01f, -1.44834742e-01f, -1.22918002e-03f, -2.00195879e-01f, 1.57677144e-01f, -2.56893802e-02f, 4.91481498e-02f,
  -1.75225914e-01f, -1.95392460e-01f, -2.37928554e-01f, -1.61490589e-01f, -6.02946281e-02f, -1.04251131e-01f, -4.94599380e-02f, -2.69795116e-02f, -5.01382723e-03f, 3.12512554e-03f,
  -4.16512862e-02f, 9.22664031e-02f, -3.76909971e-02f, -4.81098667e-02f, 4.91817296e-02f, 4.18104790e-02f, 1.04325749e-01f, 1.70051623e-02f, -2.56229453e-02f, 8.48213509e-02f,
  7.13910908e-02f, 6.18421547e-02f, -2.76345331e-02f, -1.00071572e-01f, 5.03096096e-02f, 4.41753343e-02f, 3.53655443e-02f, -7.52003072e-03f, 3.24031059e-03f, 4.45622765e-02f,
  6.63677529e-02f, -3.98920476e-02f, 3.21381614e-02f, -3.90719064e-02f, 3.56132281e-03f, 2.69277394e-02f, 6.28393050e-03f, 2.23728549e-03f, -1.03290752e-02f, -3.37680839e-02f,
  -7.75847398e-03f, -4.53743301e-02f, 3.02874465e-02f, -3.52839716e-02f, -5.22871502e-02f, -3.87276970e-02f, 5.94958104e-03f, 3.52447070e-02f, -4.97723231e-03f, 1.14356112e-02f,
  -7.76818544e-02f, -5.26543371e-02f, 2.36980580e-02f, -4.97468561e-02f, -8.27359855e-02f, -3.16174328e-03f, -8.88640508e-02f, 1.26426414e-01f, -4.54232804e-02f, 4.23213728e-02f,
  -1.63369000e-01f, -3.92951488e-01f, -1.53341547e-01f, -4.91540693e-02f, -9.65870544e-02f, -3.31208520e-02f, 2.07163338e-02f, 5.82766756e-02f, 7.29974592e-03f, -6.14025556e-02f,
  -1.41702006e-02f, -2.11681817e-02f, -5.25445305e-02f, -4.73237503e-03f, -1.21079683e-02f, 2.86541060e-02f, -3.77210155e-02f, -1.07880600e-01f, -1.12314165e-01f, 7.61643937e-03f,
  -1.89506896e-02f, -6.19526133e-02f, -8.98591504e-02f, 3.81024118e-04f, -5.28874109e-03f, -1.02723077e-01f, -2.21229475e-02f, 5.04618250e-02f, 6.67269528e-02f, -3.79479170e-04f,
  -1.42653221e-02f, -1.01404116e-01f, -6.77590072e-02f, -1.44996941e-01f, -1.85422637e-02f, 1.14816673e-01f, -4.62925769e-02f, -7.72008002e-02f, -1.47002980e-01f, 1.34727433e-01f,
  -4.47083712e-02f, 3.50907594e-02f, 1.71300676e-02f, -2.21503869e-01f, -1.06870070e-01f, -1.38007641e-01f, -1.82301268e-01f, -8.75538141e-02f, -1.50056094e-01f, 7.57450089e-02f,
  2.09764182e-03f, -4.85064127e-02f, -1.65603444e-01f, 2.38383375e-02f, 3.39355902e-03f, 1.08440638e-01f, 8.15068111e-02f, 5.05221216e-03f, -1.78709477e-02f, -4.82307263e-02f,
  -1.61086351e-01f, 1.57316327e-02f, -7.40136281e-02f, -1.19458325e-01f, 8.74195173e-02f, 1.16704765e-03f, 1.21511839e-01f, -1.81780942e-02f, 1.62901320e-02f, 6.80662543e-02f,
  1.16880976e-01f, 3.38821299e-02f, -2.00106073e-02f, -2.52935081e-03f, -5.51323406e-02f, 6.59393072e-02f, -5.19158207e-02f, -6.63242256e-03f, 7.52328336e-02f, -5.35963140e-02f,
  2.65135858e-02f, -5.08791767e-02f, 5.96382581e-02f, -9.11538526e-02f, -8.88481960e-02f, -8.31612423e-02f, 7.51438609e-04f, -4.91965190e-03f, 1.02440521e-01f, 6.87180925e-03f,
  5.47660254e-02f, 4.36799601e-02f, -1.38446726e-02f, -6.20376877e-03f, -3.32980119e-02f, -7.71676283e-03f, -5.53649552e-02f, -5.30611612e-02f, -2.24760026e-02f, -2.66423039e-02f,
  6.22462220e-02f, 2.29934957e-02f, 3.31410728e-02f, 5.90225421e-02f, -9.96745005e-03f, 6.49775267e-02f, -3.21953297e-02f, -4.15499583e-02f, -6.47909418e-02f, 3.68593670e-02f,
  -5.90680167e-02f, -1.88225713e-02f, -6.47439808e-02f, 5.21853492e-02f, 2.44886447e-02f, -2.12304927e-02f, -3.48948836e-02f, 2.33510956e-02f, -4.03899476e-02f, 6.28987607e-03f,
  3.44564766e-02f, 1.37713522e-01f, -2.92663425e-02f, 7.46485665e-02f, 1.55735121e-03f, -7.09527638e-03f, -7.06696361e-02f, -6.37914464e-02f, -1.06651768e-01f, 7.31126890e-02f,
  1.14991494e-01f, 8.43028948e-02f, 9.48731005e-02f, 3.92442904e-02f, 1.34808188e-02f, 5.14027886e-02f, 9.07215625e-02f, 1.11092165e-01f, 6.81383461e-02f, 9.54663381e-02f,
  4.45360644e-03f, -4.03524935e-02f, 3.04907877e-02f, -2.38862317e-02f, -1.10997651e-02f, 2.01090705e-02f, 1.49508500e-02f, -6.19268119e-02f, 5.34220897e-02f, -6.15474693e-02f,
  1.16450757e-01f, -2.37198055e-01f, 3.94128338e-02f, 1.70247838e-01f, 8.29238072e-02f, 2.33200807e-02f, 1.80909187e-01f, -6.80392906e-02f, 6.53518364e-02f, -2.37498865e-01f,
  -5.70285060e-02f, -4.17689569e-02f, 1.90278869e-02f, -9.69736725e-02f, 2.52447724e-01f, 1.23088576e-01f, -2.91367080e-02f, -3.50316241e-02f, -4.05630581e-02f, 6.99990764e-02f,
  4.60567251e-02f, -1.26673073e-01f, 1.07149817e-01f, -1.72039106e-01f, -3.76855731e-02f, -1.32470593e-01f, 2.45912410e-02f, -6.35055900e-02f, -1.98281512e-01f, -7.32123181e-02f,
  -4.06128205e-02f, 4.40346487e-02f, 6.96058711e-03f, -7.33309984e-02f, 6.63313717e-02f, -9.37735215e-02f, 1.82646904e-02f, 5.61826630e-03f, 1.18316129e-01f, 9.32356194e-02f,
  -4.26199548e-02f, -8.88536572e-02f, -1.08100615e-01f, 7.49266595e-02f, -8.06782171e-02f, -5.80721796e-02f, -5.13714589e-02f, -1.40137384e-02f, 6.27105758e-02f, 5.70535176e-02f,
  1.23766251e-02f, -1.34542715e-02f, 1.02743424e-01f, -1.38740567e-02f, -3.10442522e-02f, 2.54597012e-02f, -1.55052515e-02f, 1.04296356e-01f, -5.89376017e-02f, 4.87517938e-02f,
  -7.20732957e-02f, -1.63238887e-02f, 4.74835746e-02f, -1.68430209e-02f, -3.84560712e-02f, 2.31134202e-02f, 6.11347929e-02f, 6.13820627e-02f, 1.62945944e-04f, 4.01499011e-02f,
  -1.14519184e-03f, -3.06683052e-02f, -7.26553053e-02f, -1.64931584e-02f, -1.33834695e-02f, 8.87017697e-02f, 1.98930800e-02f, 7.45057734e-03f, -1.76988747e-02f, -4.20287661e-02f,
  6.57867864e-02f, 5.89773878e-02f, 1.39012828e-03f, -9.68398079e-02f, 2.21019890e-02f, 2.55002119e-02f, -1.94500554e-02f, -1.12310946e-02f, -6.59734476e-03f, 8.10787175e-03f,
  2.70295851e-02f, -1.32309705e-01f, -4.33872156e-02f, -8.72683153e-02f, 3.15974914e-02f, -4.10176814e-02f, -3.87000367e-02f, 2.10759621e-02f, 8.63622054e-02f, -2.49889866e-02f,
  1.84426587e-02f, -7.45420828e-02f, -8.32379311e-02f, -7.09960908e-02f, 2.30760244e-03f, -8.07409957e-02f, -7.36885890e-02f, -1.40353460e-02f, 4.20615934e-02f, 4.24448103e-02f,
  6.92185620e-03f, 1.13451537e-02f, -7.99330547e-02f, -9.95535627e-02f, -5.79283759e-02f, -2.14850940e-02f, 7.21228868e-02f, -6.15284555e-02f, -3.24433744e-02f, 1.41297271e-02f,
  1.86389182e-02f, 1.94525853e-01f, 2.18986258e-01f, -6.96339309e-02f, -1.73851324e-03f, 1.40736103e-01f, -2.09327098e-02f, 2.62229312e-02f, -1.17361985e-01f, 9.16781276e-02f,
  -1.45164371e-01f, 1.33138657e-01f, -3.96699756e-02f, -6.73676133e-02f, -2.01347455e-01f, -1.28391936e-01f, -9.61823016e-02f, -1.24661364e-01f, -1.21537738e-01f, -1.29643464e-02f,
  -1.18317924e-01f, -1.87846541e-01f, 3.31722461e-02f, -5.57659939e-02f, 7.69676417e-02f, 8.75477126e-05f, -1.28849640e-01f, 3.20395385e-03f, 8.50945041e-02f, -6.28599972e-02f,
  -7.10468888e-02f, -8.88440106e-03f, 4.83057462e-02f, 5.95461950e-02f, -4.82457727e-02f, 7.16420189e-02f, 5.91651946e-02f, 6.81505054e-02f, -8.35967585e-02f, -2.49628201e-02f,
  -1.91100538e-02f, -5.17819673e-02f, 3.45506668e-02f, -1.14427179e-01f, -8.73598084e-02f, -4.72363010e-02f, -1.49539877e-02f, 7.39001259e-02f, 4.85508181e-02f, 7.54331276e-02f,
  9.94920358e-02f, 1.32677816e-02f, 3.35820615e-02f, -4.24665064e-02f, -1.25973085e-02f, -5.98171428e-02f, 4.59191240e-02f, 4.48057726e-02f, 5.42330258e-02f, 8.40958804e-02f,
  -9.63783562e-02f, 5.46039678e-02f, -8.20048824e-02f, -3.11365239e-02f, 2.50727423e-02f, 1.17398789e-02f, -6.97222278e-02f, 4.94253747e-02f, 3.59731317e-02f, -6.53936937e-02f,
  -1.07451463e-02f, 9.50761233e-03f, -6.59349933e-02f, -6.81600571e-02f, 4.40424122e-02f, -6.30490929e-02f, 1.47444755e-02f, -4.61480021e-02f, 4.45794836e-02f, 1.62965171e-02f,
  -8.33856612e-02f, -4.35502641e-03f, 7.42264614e-02f, 3.47901583e-02f, -8.49184841e-02f, -6.72894493e-02f, 3.63725461e-02f, 7.12199807e-02f, -3.05354837e-02f, -1.77321602e-02f,
  1.58512332e-02f, 4.63892706e-02f, 8.45052227e-02f, 5.54829910e-02f, 9.73918438e-02f, -6.08124323e-02f, 2.27299575e-02f, 2.39327084e-03f, -3.03395502e-02f, -7.13975281e-02f,
  4.35712896e-02f, -2.96716373e-02f, 5.77316508e-02f, -4.39980701e-02f, -2.68194415e-02f, 5.25612496e-02f, -9.20365378e-02f, 9.16016661e-03f, 1.82891432e-02f, -5.12843840e-02f,
  -7.15274140e-02f, 8.91482364e-03f, -6.88861609e-02f, 5.58214709e-02f, -6.76827207e-02f, 9.24076512e-03f, -6.83606192e-02f, -3.35220434e-02f, 4.53925785e-03f, 4.22042161e-02f,
  1.43867001e-01f, 2.37410814e-01f, 1.34729788e-01f, 1.26823425e-01f, -1.46856755e-01f, -1.08034559e-01f, -3.30798212e-03f, -5.16705364e-02f, 1.83778018e-01f, -2.77324431e-02f,
  -1.04345279e-02f, 1.25773281e-01f, -1.04270115e-01f, 2.09833644e-02f, -1.68114826e-01f, -1.28226668e-01f, 1.98462587e-02f, -8.24764185e-03f, 4.02976945e-02f, 1.61643878e-01f,
  -7.21175894e-02f, -1.78595662e-01f, -1.51015604e-02f, -1.13951556e-01f, 1.26188919e-01f, 5.17800152e-02f, -1.40071034e-01f, 5.44966832e-02f, 1.19092967e-02f, -4.45160381e-02f,
  8.52666125e-02f, 2.26159627e-03f, 8.27637911e-02f, 1.09688006e-01f, -1.33264922e-02f, 1.80234276e-02f, 1.45024676e-02f, 5.76345110e-03f, 2.28739493e-02f, -3.91809866e-02f,
  1.08045816e-01f, -2.99065895e-02f, 8.83624703e-02f, -2.06846297e-02f, -4.71947268e-02f, 3.19072567e-02f, 8.68178084e-02f, 1.12246998e-01f, -5.32440506e-02f, -4.10288759e-02f,
  1.21350586e-02f, 1.16762035e-01f, -6.44226074e-02f, 6.13304302e-02f, 3.77177410e-02f, 3.41218710e-02f, -2.87904255e-02f, -1.31315179e-02f, 6.73635211e-03f, 7.69486055e-02f,
  7.84444734e-02f, -5.75915091e-02f, 8.51406679e-02f, -2.51720157e-02f, 1.36249857e-02f, 4.57853973e-02f, 2.35695075e-02f, -8.09374377e-02f, 2.62725092e-02f, -9.11539793e-02f,
  -8.07468668e-02f, 5.03582433e-02f, 2.33420562e-02f, 6.09636120e-02f, -3.30671147e-02f, -4.35292162e-02f, -6.29617274e-02f, -4.51800153e-02f, 1.24773267e-03f, -1.65417679e-02f,
  -1.02057215e-02f, -8.19112882e-02f, -4.79937065e-03f, -6.31797388e-02f, 6.08953536e-02f, -2.75878776e-02f, -7.20804706e-02f, -2.95054186e-02f, 6.12614676e-02f, -1.14877351e-01f,
  -8.63152519e-02f, 1.06830262e-01f, -6.84178621e-02f, -3.30680981e-02f, -8.76898095e-02f, -5.28565561e-03f, -1.79479085e-02f, 2.19003744e-02f, 1.77188721e-02f, -2.17882805e-02f,
  -3.82752381e-02f, 8.80571529e-02f, 3.24609168e-02f, 6.97491989e-02f, 2.24786066e-02f, -9.33934674e-02f, -2.37429142e-02f, -6.16235882e-02f, -6.16645701e-02f, 1.37373144e-02f,
  7.61786029e-02f, 2.79534589e-02f, 4.52083498e-02f, -7.37890182e-03f, -8.44218880e-02f, -5.29234856e-03f, 4.74659838e-02f, -5.56781851e-02f, 3.40938047e-02f, -8.62297416e-03f,
  6.13632649e-02f, -7.21129552e-02f, 5.77227920e-02f, 1.06380612e-01f, -5.66456616e-02f, 1.98522210e-02f, 7.18756989e-02f, -3.85994241e-02f, 1.63870573e-01f, -7.38403350e-02f,
  1.32669313e-02f, 4.80168834e-02f, 9.50274393e-02f, 9.63464677e-02f, -3.59281786e-02f, 8.59074444e-02f, 1.10738970e-01f, 6.98665306e-02f, -3.52574922e-02f, 3.20821516e-02f,
  -7.91862980e-02f, -1.04943164e-01f, 5.58667220e-02f, -1.23349763e-01f, 2.21011695e-02f, 3.64512280e-02f, -1.43721133e-01f, -1.76205356e-02f, 9.23858862e-03f, -9.30698588e-02f,
  7.18665421e-02f, -5.31100407e-02f, -5.60880266e-02f, 5.34829237e-02f, 3.63341309e-02f, 5.90376481e-02f, -8.03092867e-02f, 7.35185742e-02f, -4.21267934e-02f, -3.13414633e-02f,
  2.74686199e-02f, 8.72830972e-02f, 5.71598560e-02f, -6.73046857e-02f, 1.11074466e-02f, 5.26398569e-02f, -7.27080777e-02f, 2.78848372e-02f, 4.90299948e-02f, 3.82139273e-02f,
  -6.72646910e-02f, 8.79250765e-02f, 2.44155284e-02f, -6.15844317e-02f, 3.78725044e-02f, -9.01361629e-02f, 4.68354858e-02f, -2.47146599e-02f, 6.60447180e-02f, 5.41658923e-02f,
  1.46046728e-02f, -7.41902441e-02f, 4.86261025e-03f, -5.30354260e-03f, 5.02920300e-02f, -4.90317605e-02f, 2.58228593e-02f, 6.21139482e-02f, 9.87174734e-02f, 3.99345532e-02f,
  7.38916099e-02f, 4.71291915e-02f, 2.08859779e-02f, 6.82792664e-02f, -3.61271054e-02f, 3.48099172e-02f, -3.51418629e-02f, 6.09157123e-02f, -5.51074967e-02f, 8.62729922e-02f,
  -2.60280836e-02f, -4.19673771e-02f, 6.37250096e-02f, 8.39890316e-02f, -7.65204877e-02f, 6.61683753e-02f, 1.27606222e-03f, -2.47423649e-02f, -3.34403152e-03f, -1.11818891e-02f,
  6.67497069e-02f, -8.50705281e-02f, 3.06458082e-02f, -7.84936920e-02f, 6.07997179e-02f, 9.24366340e-03f, 8.56128857e-02f, 4.49130218e-03f, 2.55815387e-02f, -5.21397777e-02f,
  -1.07034773e-01f, 7.94502813e-03f, 5.60353659e-02f, 2.48419717e-02f, -5.38947247e-02f, -5.43488674e-02f, -7.09204525e-02f, -2.72370744e-02f, -3.18503454e-02f, -1.21060893e-01f,
  -8.42654109e-02f, 3.29432189e-02f, -4.71507236e-02f, 3.75195481e-02f, -7.49235507e-03f, -8.34514648e-02f, 3.72583605e-02f, 6.41090721e-02f, 4.21385048e-03f, 3.87750268e-02f,
  -2.85118297e-02f, -7.06775039e-02f, 1.31022677e-01f, -9.09011811e-02f, 3.49647738e-02f, 3.57848257e-02f, 5.75735904e-02f, -5.62390834e-02f, -4.26947623e-02f, -8.92755315e-02f,
  3.29429917e-02f, 7.21468404e-02f, -7.23122954e-02f, -1.24341086e-01f, 2.82439142e-02f, -1.77907467e-01f, -2.17661075e-03f, -5.53930476e-02f, -1.01312630e-01f, 2.64502466e-02f,
  -8.93474743e-02f, -4.25604098e-02f, 7.07800984e-02f, -5.51497228e-02f, -5.95536502e-03f, 7.56347254e-02f, 5.73030822e-02f, 1.14473045e-01f, -1.35497488e-02f, 8.87204483e-02f,
  -4.60431278e-02f, -9.81892869e-02f, 9.94793400e-02f, 9.59691182e-02f, -1.39899328e-02f, 2.61177216e-02f, 6.77046031e-02f, -6.10415302e-02f, -6.91961646e-02f, -4.44766656e-02f,
  2.84404382e-02f, -8.73412564e-02f, -2.30467040e-02f, 8.77830982e-02f, 6.81479946e-02f, -8.16940665e-02f, -4.06951495e-02f, 7.52273202e-02f, -4.58128750e-03f, 7.81799406e-02f,
  2.44815499e-02f, -2.06867531e-02f, 3.71414237e-02f, 2.06200201e-02f, -6.09114356e-02f, 3.04881819e-02f, -1.23402700e-02f, -3.34497057e-02f, -3.24171148e-02f, 7.91305006e-02f,
  -3.90700512e-02f, 7.05360547e-02f, -1.46769192e-02f, -6.71842396e-02f, -4.11342569e-02f, 2.22755522e-02f, -3.06810867e-02f, 4.82354686e-02f, 8.13044012e-02f, 3.95200327e-02f,
  -4.34049740e-02f, 1.25227431e-02f, 3.37002128e-02f, -8.40057135e-02f, 7.69898221e-02f, 5.18808551e-02f, -5.54826409e-02f, -3.68475541e-02f, -2.80500809e-03f, -6.50018901e-02f,
  3.42263877e-02f, -3.82542126e-02f, -1.43473148e-02f, 2.00212020e-02f, -2.31924169e-02f, 2.77446005e-02f, 1.53017966e-02f, -2.00115219e-02f, 4.89782616e-02f, 3.80862807e-03f,
  1.97787154e-02f, -9.45528746e-02f, -5.24973720e-02f, -1.19705349e-02f, 5.35112955e-02f, 8.24344531e-02f, -1.16233034e-02f, -8.37688074e-02f, 3.96794174e-03f, -1.69506315e-02f,
  4.89574894e-02f, 1.23793958e-02f, -4.22722362e-02f, 6.58974051e-02f, -6.63260818e-02f, 6.26479536e-02f, -3.65761258e-02f, -4.87902500e-02f, 9.49704722e-02f, -7.13471994e-02f,
  9.57464725e-02f, 6.65529445e-02f, 5.67489155e-02f, 9.68412533e-02f, 9.40640736e-03f, 6.68855906e-02f, -6.78190961e-02f, -2.31426414e-02f, 1.13975890e-01f, -4.53681499e-02f,
  4.39620093e-02f, -1.88956767e-01f, 1.53813347e-01f, 3.68366726e-02f, 2.80949473e-01f, 2.92614587e-02f, -2.20462377e-03f, 1.57102838e-01f, 2.39073053e-01f, -2.43859470e-01f,
  -1.43241351e-02f, -2.55580097e-01f, 1.55467922e-02f, -1.39090210e-01f, -5.58010004e-02f, -9.16970521e-02f, -1.51062101e-01f, -1.84463486e-01f, 7.06011131e-02f, -1.01402588e-02f,
  -2.80441400e-02f, -1.21726573e-01f, -1.74675160e-03f, 6.07650261e-03f, -4.82067540e-02f, -2.02357695e-02f, -1.30573168e-01f, -1.75842978e-02f, -1.76136479e-01f, 4.32190448e-02f,
  -9.62690413e-02f, -7.58708045e-02f, 5.92135563e-02f, -5.36125861e-02f, -1.11490719e-01f, -1.05971649e-01f, -3.75871919e-02f, 4.57862318e-02f, 4.35562059e-03f, 6.88350350e-02f,
  -5.28518595e-02f, -4.99108136e-02f, 7.08638951e-02f, 2.63007637e-02f, 6.22057170e-02f, -6.34037107e-02f, 3.84446457e-02f, 5.81482947e-02f, -4.28987332e-02f, 5.60607091e-02f,
  5.50654158e-02f, -2.61478219e-02f, -4.70992774e-02f, -9.37990695e-02f, -4.69973348e-02f, 7.16930702e-02f, 2.97206268e-02f, -3.19134779e-02f, -4.99886312e-02f, -2.95500718e-02f,
  -3.25354077e-02f, -3.92953977e-02f, -3.28890048e-02f, 9.64197367e-02f, -4.99627506e-03f, 1.13569714e-01f, -6.08710349e-02f, -6.05308376e-02f, 1.76084805e-02f, 2.52777506e-02f,
  -3.10919322e-02f, -5.38659543e-02f, -4.16872799e-02f, -2.54796613e-02f, -7.30047524e-02f, 4.18900475e-02f, 4.02175598e-02f, 1.55466236e-02f, -2.35458855e-02f, 3.52603793e-02f,
  4.79183532e-02f, 4.98562604e-02f, 2.10008975e-02f, -3.45257297e-02f, 2.07934063e-02f, 9.56934690e-02f, -1.85918454e-02f, 8.71826336e-02f, 7.27741271e-02f, -2.01551151e-02f,
  -2.85919338e-01f, -1.67526126e-01f, 5.12593286e-03f, 5.17583005e-02f, -6.29125237e-02f, -4.10868190e-02f, -3.03227212e-02f, -6.60723969e-02f, -5.37910163e-02f, 5.40824700e-03f,
  -1.10807046e-01f, -7.95741901e-02f, 3.00782118e-02f, 2.74270773e-02f, -5.31889945e-02f, -2.01462284e-02f, -1.37310565e-01f, -7.79277161e-02f, 2.09776852e-02f, -8.24050754e-02f,
  -3.16106901e-02f, -8.30582082e-02f, 5.66638187e-02f, 6.40525892e-02f, 1.74021292e-02f, -7.35364482e-02f, -7.73864537e-02f, -1.68256611e-02f, -8.86666402e-02f, 4.25633788e-02f,
  6.18305765e-02f, -4.71810438e-02f, -1.34474993e-01f, 7.33759478e-02f, 6.65513948e-02f, -9.58323032e-02f, -4.01373990e-02f, 1.75174102e-01f, 1.87378347e-01f, 3.24021503e-02f,
  -8.49363580e-02f, -1.76267326e-01f, 1.15648657e-01f, -1.18922517e-01f, -1.94429979e-01f, 2.32599601e-02f, -2.36338377e-01f, -1.25482127e-01f, 2.93862056e-02f, -9.51545984e-02f,
  -5.23378067e-02f, 1.12683102e-02f, -1.27136096e-01f, 1.10290870e-01f, -7.53142163e-02f, 9.60731730e-02f, -3.59017998e-02f, 6.33005872e-02f, -1.85191348e-01f, 1.10567622e-02f,
  6.02110885e-02f, 6.12738505e-02f, 8.13040584e-02f, -5.64753003e-02f, -1.70446672e-02f, 6.57930821e-02f, -1.08839631e-01f, -3.90632525e-02f, -4.38202508e-02f, -1.69282779e-02f,
  -7.77225196e-02f, -6.03687428e-02f, 5.59741482e-02f, 1.07713625e-01f, 3.57105248e-02f, -1.12138605e-02f, 2.01681051e-02f, -3.86803038e-02f, 2.60734428e-02f, -1.15317307e-01f,
  8.30002055e-02f, -7.67046288e-02f, -7.67740011e-02f, 5.30506223e-02f, -1.90215409e-02f, -4.12419066e-02f, -3.97564918e-02f, -7.80823827e-02f, 2.78779063e-02f, 2.16182396e-02f,
  -9.94021073e-03f, 3.91311422e-02f, -2.76948158e-02f, -2.73297224e-02f, 8.48748982e-02f, -6.47395253e-02f, 3.60316001e-02f, 2.24483665e-02f, 6.79942369e-02f, 1.41808959e-02f,
  9.48856547e-02f, -7.54836947e-04f, 9.80219468e-02f, -8.07565004e-02f, -2.76926830e-02f, 2.87250876e-02f, -6.17482662e-02f, 6.15456104e-02f, 3.81024927e-02f, -5.47352945e-04f,
  5.91671932e-03f, -5.84953576e-02f, 1.76974833e-02f, 3.83703299e-02f, 2.34141648e-02f, 2.31162440e-02f, -4.10084389e-02f, 2.93054786e-02f, 8.20826739e-02f, 6.00620033e-03f,
  -1.02709495e-02f, -8.86265934e-02f, 5.14477119e-02f, -3.62862423e-02f, -4.03854847e-02f, 1.24086309e-02f, -9.84487012e-02f, -6.76285997e-02f, -7.99194202e-02f, -2.39422116e-02f,
  3.59897502e-02f, 8.69066939e-02f, -4.24620472e-02f, -8.68479311e-02f, 6.22036122e-02f, -9.11423862e-02f, 3.34972665e-02f, -1.68833137e-02f, -5.04470291e-03f, -1.83944334e-03f,
  -2.91003175e-02f, 5.04553802e-02f, 1.57937128e-02f, 3.46366242e-02f, 8.05579573e-02f, -9.79963224e-03f, -7.62803247e-03f, 4.55704927e-02f, 3.30596194e-02f, 5.82238957e-02f,
  2.30246708e-02f, 3.11112031e-02f, -2.52238312e-03f, 1.25419935e-02f, -8.34276453e-02f, -1.99541584e-01f, -2.06034556e-01f, -6.21157996e-02f, 1.33671805e-01f, -4.37050834e-02f,
  -6.01980016e-02f, 9.55257192e-02f, -7.62596130e-02f, -1.31031096e-01f, -9.38918516e-02f, -2.26862654e-02f, 1.18247773e-02f, 7.57145211e-02f, 1.30459554e-02f, -4.00766656e-02f,
  5.09553328e-02f, -1.37787074e-01f, -1.01672210e-01f, -1.04803517e-01f, -4.55199480e-02f, 8.41985196e-02f, 4.83183749e-02f, -1.11416377e-01f, -1.04831822e-01f, 5.64433374e-02f,
  -7.29306713e-02f, -5.09443656e-02f, -6.94399923e-02f, -7.35065788e-02f, -1.07127272e-01f, -6.47185594e-02f, 7.47097954e-02f, -6.72538728e-02f, 1.41583970e-02f, -2.36994047e-02f,
  -3.15986462e-02f, -5.00362255e-02f, 6.76274523e-02f, -7.19032213e-02f, 2.33753789e-02f, 7.16298679e-03f, 1.23600001e-02f, 5.60036562e-02f, -8.80472660e-02f, 4.95805107e-02f,
  3.38325799e-02f, 6.23352267e-02f, -6.20148815e-02f, 2.40508392e-02f, -6.33536354e-02f, 4.59105074e-02f, -3.22432406e-02f, -7.65082762e-02f, -6.36850819e-02f, -2.91857142e-02f,
  6.00443128e-03f, 6.61425367e-02f, 5.90306409e-02f, 2.63972096e-02f, -2.97668036e-02f, -8.66431370e-02f, 5.85105307e-02f, -4.27103899e-02f, -3.15698236e-02f, 5.96785732e-02f,
  7.44088590e-02f, 6.27128482e-02f, 8.22406858e-02f, 3.63628604e-02f, 5.17910272e-02f, 6.27219304e-02f, 2.50528287e-02f, -3.05502228e-02f, 3.82988318e-03f, 3.20967361e-02f,
  -1.89057607e-02f, -8.32691863e-02f, -9.41767246e-02f, 4.30522822e-02f, 2.30319109e-02f, 5.85367195e-02f, -7.23599792e-02f, -1.04515804e-02f, 4.77235205e-02f, 2.92341132e-02f,
  -5.81840910e-02f, -1.67269986e-02f, 6.31345809e-02f, 6.12575300e-02f, 6.88602701e-02f, 4.01664115e-02f, 7.00855181e-02f, 4.02988009e-02f, -6.81220368e-02f, -2.50714179e-02f,
  6.40250593e-02f, 7.59153664e-02f, -3.60116363e-02f, -5.14858728e-03f, 3.96045186e-02f, 5.40273078e-02f, 7.36072063e-02f, 5.70405200e-02f, 1.61294043e-02f, 1.75885204e-02f,
  7.65395761e-02f, 5.18166684e-02f, 9.82117131e-02f, 2.24762987e-02f, 8.53807107e-02f, 5.44760302e-02f, 8.76433626e-02f, -2.95937643e-03f, 7.05589876e-02f, -3.30144167e-02f,
  -8.88686329e-02f, 2.67314482e-02f, -2.39149798e-02f, -2.52417643e-02f, 3.74870300e-02f, -1.45255728e-02f, -3.69541682e-02f, 1.27621070e-01f, -1.16629072e-01f, -3.18326615e-02f,
  6.23223186e-02f, -7.12733120e-02f, 2.52016149e-02f, -9.83885452e-02f, -2.52755489e-02f, -3.36662084e-02f, 9.75702927e-02f, 5.63242920e-02f, -6.25233874e-02f, 1.31239429e-01f,
  1.01393409e-01f, 1.16977036e-01f, 4.77512963e-02f, 1.77158713e-01f, -2.26780418e-02f, 5.44271208e-02f, 1.30889177e-01f, 9.41733122e-02f, 4.61492948e-02f, 5.56360148e-02f,
  -2.59586331e-02f, -5.76916710e-02f, -7.66922608e-02f, -4.57744859e-02f, 1.02511026e-01f, 2.15446390e-03f, -4.97144163e-02f, 2.94886474e-02f, 6.56501800e-02f, 3.84576693e-02f,
  4.40389998e-02f, -3.00307944e-02f, -6.40444234e-02f, 5.15245721e-02f, 8.22973251e-02f, -4.47669066e-02f, -2.51227673e-02f, -2.35046446e-02f, -5.07025830e-02f, 7.01002851e-02f,
  -1.80071630e-02f, 2.93051489e-02f, 1.48130422e-02f, -5.53142391e-02f, 7.13765696e-02f, 3.08980923e-02f, 3.60374572e-03f, -1.60996858e-02f, -1.29014617e-02f, 3.49534536e-03f,
  1.01791129e-01f, 3.50145921e-02f, 4.02036682e-02f, -2.25534625e-02f, -3.96429673e-02f, -5.67143001e-02f, 1.34150898e-02f, 4.14822437e-02f, -4.08878438e-02f, -2.80506350e-02f,
  1.65853351e-02f, 6.70986697e-02f, -5.82418405e-02f, 4.86315507e-03f, 2.86305621e-02f, -3.77803147e-02f, 5.45903575e-03f, -1.35115562e-02f, 9.01404619e-02f, -9.54942182e-02f,
  -1.62400864e-02f, 8.96147192e-02f, -1.02895454e-01f, -6.77063912e-02f, -4.64886092e-02f, 9.75310430e-02f, 4.52891737e-02f, 4.78950702e-02f, -2.49723624e-02f, -1.80238076e-02f,
  1.18636802e-01f, 1.79814115e-01f, -3.94680873e-02f, -5.61882779e-02f, -5.45122623e-02f, 3.28020044e-02f, -6.09370470e-02f, 2.79179085e-02f, 8.34675804e-02f, 4.13953438e-02f,
  6.33705333e-02f, 8.15338418e-02f, 9.44413617e-02f, -7.99945965e-02f, 5.12999929e-02f, -1.66162401e-02f, -1.66851263e-02f, 9.16442871e-02f, 4.98804301e-02f, 1.02288052e-02f,
  1.12184271e-01f, 9.99123007e-02f, -8.73180032e-02f, 6.63442612e-02f, -4.18079905e-02f, 6.82486296e-02f, 2.97252107e-02f, -4.83507253e-02f, 1.09849460e-01f, 6.26974553e-02f,
  2.56503314e-01f, 4.74729873e-02f, -2.53952384e-01f, -2.01392964e-01f, 4.34660539e-02f, 2.40041226e-01f, 5.63596897e-02f, -7.41722360e-02f, -1.42315954e-01f, 1.55484408e-01f,
  9.38076898e-02f, 3.00918818e-02f, -1.24984309e-01f, -7.42138103e-02f, -8.32442641e-02f, -1.53067246e-01f, 1.61339819e-01f, 6.76703006e-02f, -1.05584793e-01f, 1.91383287e-01f,
  -1.20858505e-01f, 1.86566755e-01f, -2.22055808e-01f, 2.84506045e-02f, 1.59557462e-01f, 6.95778579e-02f, 7.97486380e-02f, -1.81855962e-01f, 1.53583452e-01f, -8.60884599e-03f,
  1.09528909e-02f, -2.08317135e-02f, -5.53200170e-02f, -1.05796352e-01f, -8.52517691e-03f, 9.19998884e-02f, 2.99552642e-02f, -4.69501056e-02f, -5.68539575e-02f, -4.52326536e-02f,
  2.64590774e-02f, 4.92405258e-02f, -6.71234503e-02f, -1.15074694e-01f, 6.23358861e-02f, -4.21116017e-02f, -4.56288010e-02f, -7.14741573e-02f, -1.21866517e-01f, -7.12429136e-02f,
  -2.79244687e-02f, 6.27378523e-02f, -3.96663956e-02f, 1.98996495e-02f, 1.29575953e-02f, 2.95456219e-02f, 9.21545848e-02f, 3.71234901e-02f, 8.97414237e-02f, 5.34816273e-02f,
  2.98435502e-02f, 7.41460919e-02f, 2.62615923e-02f, -7.00660646e-02f, 3.60114351e-02f, -2.29604803e-02f, 7.62955993e-02f, -3.24051902e-02f, -1.05409965e-01f, 5.13611995e-02f,
  -5.60243838e-02f, 5.14667295e-02f, -8.28195959e-02f, -6.22183131e-03f, 1.01927549e-01f, 4.24447060e-02f, -2.46603433e-02f, 8.06426816e-03f, -4.31453437e-02f, -5.82828335e-02f,
  3.47367278e-03f, 2.29390040e-02f, 3.51959243e-02f, 5.18856533e-02f, -4.10429873e-02f, -1.58193484e-02f, 1.00953333e-01f, 4.95762900e-02f, -3.39891091e-02f, 1.12820834e-01f,
  1.01606078e-01f, 1.68792948e-01f, 5.89482486e-03f, -4.64993604e-02f, 1.63949039e-02f, 7.63200149e-02f, -1.35278944e-02f, -4.60802168e-02f, 5.12211956e-02f, 3.43528949e-02f,
  7.14989007e-02f, 6.31390885e-02f, -1.09707601e-02f, -3.88316512e-02f, -1.11647071e-02f, 8.51944089e-02f, 8.28795414e-03f, 1.46871544e-02f, -1.93080120e-02f, 4.26929668e-02f,
  2.40184683e-02f, -5.79118170e-03f, 7.16667622e-02f, -4.11758684e-02f, 8.75410661e-02f, 1.34294912e-01f, 1.04818620e-01f, 6.93800375e-02f, 3.57373618e-02f, 3.54139842e-02f,
  7.76939541e-02f, -2.97035307e-01f, -6.43482879e-02f, 1.14219412e-01f, 1.11526936e-01f, 1.58427730e-01f, -8.42750520e-02f, 1.39385834e-01f, 2.59882323e-02f, -1.88560292e-01f,
  1.42249968e-02f, -1.53361812e-01f, -2.47393742e-01f, 1.38150096e-01f, 2.30818503e-02f, -1.27474874e-01f, 1.76032260e-01f, -9.59406141e-03f, -3.65008935e-02f, 2.55537312e-02f,
  5.38040325e-03f, 1.18380509e-01f, -9.70668793e-02f, 1.49381414e-01f, 2.27234345e-02f, 4.55594920e-02f, 5.65044098e-02f, -4.90100719e-02f, 4.24460694e-02f, 5.10052685e-03f,
  5.32553112e-03f, -1.07604917e-02f, -6.88563883e-02f, -7.26305321e-02f, -2.14470346e-02f, -1.08766463e-02f, -2.55337190e-02f, 1.96544528e-02f, -2.47072559e-02f, 8.30454901e-02f,
  -1.33020550e-01f, 1.97337387e-04f, 1.50721490e-01f, 3.23923887e-03f, 9.49489623e-02f, 5.97488694e-02f, -2.71651391e-02f, -5.31733260e-02f, 5.97455166e-02f, -6.69239610e-02f,
  -2.55959276e-02f, 8.53400528e-02f, 6.31668419e-02f, -1.91182401e-02f, -3.19953039e-02f, 6.25195950e-02f, 2.16617044e-02f, -1.07324228e-01f, -5.15457094e-02f, 7.53398910e-02f,
  7.05303922e-02f, -3.14874388e-03f, -5.21398224e-02f, -8.40844661e-02f, 5.23332544e-02f, 2.89918128e-02f, -5.46016097e-02f, 3.06823701e-02f, 5.26567048e-04f, -3.65952440e-02f,
  -1.18832150e-02f, 5.59626594e-02f, 3.20585519e-02f, -6.14343882e-02f, 1.92407556e-02f, -2.23615784e-02f, 5.47125787e-02f, 8.78843367e-02f, -1.87597945e-02f, 3.33126029e-03f,
  -1.05104342e-01f, 3.15560400e-02f, 1.98096000e-02f, 9.36579481e-02f, 6.31613284e-02f, 3.12729590e-02f, 1.80678647e-02f, -3.19777913e-02f, -1.80888723e-03f, 4.64673080e-02f,
  -1.28584981e-01f, -1.03586569e-01f, -8.85296911e-02f, 5.52990772e-02f, 1.71883013e-02f, -4.21730541e-02f, -6.38514832e-02f, 2.86249314e-02f, -1.03353761e-01f, 1.32022910e-02f,
  1.27757965e-02f, -4.90301996e-02f, 7.35545978e-02f, 7.86455870e-02f, 2.19451208e-02f, 6.99309483e-02f, 4.21861140e-03f, -1.29313041e-02f, 8.15628394e-02f, -7.53665566e-02f,
  -2.61296215e-03f, -1.41619546e-02f, 1.57202464e-02f, 6.92128986e-02f, 5.05270809e-02f, -1.29954715e-03f, -2.09037345e-02f, 3.09397727e-02f, 5.56646176e-02f, 1.04351174e-02f,
  -1.83826789e-01f, 3.19356881e-02f, 6.13303706e-02f, -2.99046449e-02f, 1.03159240e-02f, 4.62545082e-02f, -8.64509419e-02f, 1.02954052e-01f, -1.11745596e-01f, 5.95977576e-03f,
  9.33096185e-02f, -1.26986533e-01f, 1.94684435e-02f, -1.27975360e-01f, -1.99815974e-01f, -5.22316806e-02f, -3.53974029e-02f, -2.25571226e-02f, -4.08929139e-02f, 7.46599138e-02f,
  -3.93803371e-03f, -1.03186764e-01f, 9.16108042e-02f, 1.22681178e-01f, 6.57007769e-02f, 1.23313002e-01f, -2.01491974e-02f, 1.47990193e-02f, 1.35466665e-01f, -2.55877189e-02f,
  -2.82360823e-03f, -6.60996214e-02f, 1.21985480e-01f, 6.67921379e-02f, 7.23677650e-02f, -4.65541380e-03f, 8.02445188e-02f, -3.51670235e-02f, 5.53056374e-02f, 5.46008348e-02f,
  1.44352010e-02f, -1.62548181e-02f, -7.24214017e-02f, -2.80123334e-02f, 8.18309337e-02f, -2.45667230e-02f, 5.04966406e-03f, 6.98170736e-02f, -9.62982979e-03f, 5.62029965e-02f,
  6.87368065e-02f, -3.69003415e-02f, 3.41091491e-02f, -3.37895490e-02f, -7.74693489e-02f, 1.30922040e-02f, 7.84579664e-02f, -8.31234604e-02f, 6.21813163e-02f, 3.35493721e-02f,
  -8.10913742e-02f, 7.97434449e-02f, 6.27004430e-02f, -2.17864122e-02f, 3.65508050e-02f, -3.26080061e-02f, -7.58086741e-02f, 4.60014530e-02f, 6.37622327e-02f, -4.12896015e-02f,
  -5.50040137e-03f, -6.29136851e-03f, 3.19247432e-02f, 4.95596007e-02f, -8.75965431e-02f, -4.07245867e-02f, 1.11356914e-01f, -5.88116497e-02f, 1.78888626e-02f, 7.09232166e-02f,
  1.01123206e-01f, 6.54402701e-03f, -4.72922176e-02f, 9.20702443e-02f, -2.55683381e-02f, 3.33979242e-02f, 4.40269001e-02f, 7.54603976e-03f, -4.53966856e-02f, -8.82003009e-02f,
  9.83681679e-02f, -4.05791849e-02f, 3.20568494e-02f, -5.53397648e-03f, 3.83950174e-02f, -6.10911697e-02f, -7.45495856e-02f, -5.21895736e-02f, 6.02182373e-02f, -9.38527361e-02f,
  4.02092468e-03f, 1.77694522e-02f, -2.98624653e-02f, 6.16865279e-03f, 3.90824489e-02f, -1.48440769e-03f, 3.63770202e-02f, 6.03961647e-02f, 5.15192449e-02f, -8.36957339e-03f,
  2.54288618e-03f, 3.62729132e-02f, -4.42823693e-02f, 5.25953397e-02f, -2.88748052e-02f, 5.74239679e-02f, -6.35025650e-02f, -1.39301335e-02f, -4.35009897e-02f, 3.01005989e-02f,
  2.77671982e-02f, -1.47467270e-01f, -1.09544881e-01f, -7.91112855e-02f, 2.02907026e-02f, 6.53116731e-03f, 3.25138792e-02f, -1.15304582e-01f, -1.30312666e-01f, -4.45648842e-02f,
  -5.00338972e-02f, -7.27058575e-02f, -2.08300591e-01f, 2.71965545e-02f, 1.09173052e-01f, 4.80218232e-03f, 1.02047920e-01f, -5.45318760e-02f, -5.07331528e-02f, -1.05938055e-01f,
  -2.66310549e-03f, 9.36757028e-02f, -9.56595913e-02f, 8.49981010e-02f, 4.35255878e-02f, 9.88724232e-02f, -4.78975549e-02f, 3.95929627e-02f, 2.76457854e-02f, 1.32361278e-01f,
  7.17477500e-02f, 2.63601616e-02f, -4.48462479e-02f, -5.10675497e-02f, 4.19143364e-02f, -5.10089751e-03f, -3.47480699e-02f, -2.49000937e-02f, 7.99036995e-02f, 4.74977642e-02f,
  1.78244058e-02f, 6.22538850e-03f, 1.17093377e-01f, -8.07164758e-02f, 7.91715235e-02f, -4.17777561e-02f, -6.85638934e-02f, 3.61070819e-02f, -4.32795025e-02f, 4.09066305e-02f,
  -3.16558965e-02f, 7.13665783e-02f, 7.81546533e-02f, 4.65517454e-02f, -1.00917064e-01f, -7.85160288e-02f, -4.78818023e-04f, -9.10030380e-02f, 1.70788765e-02f, 5.98255843e-02f,
  3.26530896e-02f, 2.89937295e-02f, 3.89350355e-02f, 6.97950423e-02f, 6.13782322e-03f, 7.53620490e-02f, 2.67704893e-02f, -2.08429750e-02f, 1.05770975e-02f, -5.58600500e-02f,
  3.88067625e-02f, 4.22217362e-02f, 1.79846976e-02f, 3.66624594e-02f, 8.27474371e-02f, 1.10229114e-02f, 4.19838950e-02f, 4.59211925e-03f, -2.68890010e-03f, -3.79807912e-02f,
  7.51207620e-02f, -7.22017661e-02f, 7.05095455e-02f, 2.77714804e-02f, 8.70242491e-02f, -9.97212231e-02f, -5.70173971e-02f, 8.33180267e-03f, 7.05611780e-02f, 3.51633728e-02f,
  -5.80139309e-02f, -6.67163804e-02f, 1.09912241e-02f, -5.18193506e-02f, 1.97857134e-02f, -4.83284146e-02f, 3.35306339e-02f, 2.02038623e-02f, -1.84155907e-03f, -6.48782309e-03f,
  -8.04679990e-02f, 1.67478658e-02f, 4.08042930e-02f, -7.26761222e-02f, -6.29039062e-03f, -6.13985658e-02f, 3.89315747e-02f, 5.74859679e-02f, -4.54459824e-02f, 7.71970674e-02f,
  6.59662709e-02f, -4.64142971e-02f, -1.54455509e-02f, 1.59734264e-02f, -3.21080871e-02f, 3.27788554e-02f, 5.89269251e-02f, -2.28300411e-02f, -3.50712910e-02f, -4.98790331e-02f,
  -4.28251803e-01f, 8.01254958e-02f, -1.06133841e-01f, 3.54037504e-03f, -1.82519451e-01f, 2.10276335e-01f, 3.43524873e-01f, -1.10165916e-01f, -2.48427340e-03f, 3.27739835e-01f,
  2.36685455e-01f, -1.33009672e-01f, 2.47454435e-01f, 2.52716929e-01f, -5.47070578e-02f, 2.87040979e-01f, 2.98638403e-01f, 2.32837975e-01f, -1.00380920e-01f, -8.32935795e-02f,
  -3.68694924e-02f, 1.75062358e-01f, 8.56144801e-02f, -1.02646671e-01f, -3.80682833e-02f, -2.30031073e-01f, 2.33430206e-03f, -1.30092934e-01f, -7.10172132e-02f, -1.98101103e-02f,
  -5.54448776e-02f, -1.75857514e-01f, -2.28069536e-02f, -7.51169920e-02f, -7.99348280e-02f, -6.81806728e-02f, -7.93549512e-03f, -4.14919443e-02f, -5.42412251e-02f, 2.36448031e-02f,
  6.91886842e-02f, -1.00857690e-01f, -1.28817642e-02f, -9.79479253e-02f, -4.22466248e-02f, -7.30740279e-02f, 6.39674738e-02f, 1.48521671e-02f, 4.06806953e-02f, -6.12908415e-02f,
  7.31066838e-02f, 1.05237486e-02f, 1.31247565e-02f, 1.58594772e-02f, -1.49973128e-02f, -3.74889337e-02f, 9.01347771e-02f, 2.54075229e-02f, 2.52946783e-02f, -3.91385471e-03f,
  5.60733303e-02f, -1.60389822e-02f, 9.67467874e-02f, 4.94105332e-02f, -5.02894297e-02f, -1.60940327e-02f, 1.03794262e-02f, -2.08631903e-02f, 1.28493714e-03f, 9.95868444e-03f,
  -6.29579723e-02f, -4.92141135e-02f, -1.25322878e-01f, 5.42301983e-02f, 6.05109632e-02f, -6.23790957e-02f, 2.00029947e-02f, -7.86366910e-02f, 4.47882824e-02f, -2.48069037e-02f,
  -3.08426358e-02f, -3.80569361e-02f, -1.36197926e-02f, -3.00251991e-02f, 6.69766292e-02f, -3.40943113e-02f, 3.06797829e-02f, 9.82266571e-03f, 7.69990385e-02f, 5.07660955e-03f,
  -1.77131277e-02f, -1.81709453e-01f, -3.49811651e-02f, 1.17762676e-02f, 4.73101716e-03f, -4.41120118e-02f, -2.57012323e-02f, 6.59262156e-03f, 3.15413401e-02f, 4.14082408e-02f,
  -8.49134251e-02f, 2.97078717e-04f, -3.35995443e-02f, 3.63295972e-02f, -5.62974736e-02f, 5.49928322e-02f, -6.30863160e-02f, -3.47109623e-02f, 1.10757323e-02f, -6.06476553e-02f,
  -4.15454730e-02f, 1.66012309e-02f, -3.14440876e-02f, -5.58304451e-02f, -6.04249239e-02f, 2.95328815e-02f, -5.42743020e-02f, -1.07938625e-01f, 2.55496167e-02f, 9.41351801e-02f,
  -2.94113100e-01f, 9.00472552e-02f, -1.31537810e-01f, -2.76379824e-01f, 7.36028478e-02f, -1.71362758e-01f, -2.83727627e-02f, 2.91324370e-02f, -6.07931204e-02f, 1.99311599e-01f,
  1.07037574e-01f, -1.44288421e-01f, -2.27855183e-02f, -1.51445493e-01f, -5.50937891e-01f, -1.54695451e-01f, -2.75792122e-01f, -1.46651298e-01f, -1.33939877e-01f, -8.11940059e-03f,
  -1.78639367e-01f, -8.58011395e-02f, -1.82302579e-01f, 1.97608232e-01f, 9.57090110e-02f, 2.74840742e-02f, 1.24568112e-01f, 2.16996551e-01f, 4.60220836e-02f, 1.23874806e-02f,
  2.88226851e-03f, 7.55284876e-02f, -9.31523740e-02f, -8.74724910e-02f, -2.16561090e-02f, 2.26614415e-03f, 2.05899831e-02f, -7.59637803e-02f, 1.22822393e-02f, -6.02918155e-02f,
  1.79377683e-02f, -4.57748026e-02f, -9.64011475e-02f, 4.55764607e-02f, 3.37501317e-02f, 6.37294678e-03f, -2.95942668e-02f, 4.90337461e-02f, -4.19608243e-02f, -1.05857201e-01f,
  -9.32549983e-02f, -4.43704501e-02f, -8.62882286e-02f, 4.54731584e-02f, -3.39566581e-02f, 2.65379529e-02f, -6.91230670e-02f, -4.21674177e-02f, -7.91371092e-02f, -4.82416339e-02f,
  -4.26222943e-02f, 4.84473305e-03f, -5.80377951e-02f, -6.74173310e-02f, 3.49854827e-02f, -1.63681414e-02f, -5.36337979e-02f, -2.79733203e-02f, 6.39172643e-02f, 2.03942377e-02f,
  -4.95775416e-02f, 8.18876550e-03f, -1.95488315e-02f, -5.61109334e-02f, 1.96951814e-02f, 3.32639702e-02f, 1.85155049e-02f, 4.75537479e-02f, 8.12923629e-03f, -4.77438197e-02f,
  1.14571042e-01f, -7.35599846e-02f, 2.87927426e-02f, 1.57103203e-02f, -3.20409238e-02f, 3.83690074e-02f, 1.99695155e-02f, 1.90743841e-02f, 3.43827866e-02f, 8.21350887e-03f,
  5.58174960e-02f, 2.12140325e-02f, 1.02593012e-01f, 1.14898577e-01f, 3.55345868e-02f, -1.24824103e-02f, -5.19096293e-02f, -8.04402009e-02f, 1.91682894e-02f, 1.40899215e-02f,
  -6.41753525e-02f, -3.99239287e-02f, 3.32623087e-02f, -2.32820027e-03f, -4.43104245e-02f, -1.02012949e-02f, 6.61508739e-02f, -1.32016381e-02f, 8.63873586e-02f, 6.37663826e-02f,
  1.42192140e-01f, 6.58615977e-02f, 1.29622985e-02f, 3.74655239e-02f, 8.64428505e-02f, 4.17120419e-02f, -3.16978153e-03f, 1.04140099e-02f, 7.70709962e-02f, -6.24204837e-02f,
  2.14657083e-01f, -2.75320798e-01f, -4.04640054e-03f, 1.97493166e-01f, 1.25823990e-01f, 2.24223156e-02f, 4.17970903e-02f, 6.87354207e-02f, 1.23382799e-01f, -1.52701810e-01f,
  6.03794977e-02f, -8.69977921e-02f, -5.75519055e-02f, 1.09007984e-01f, 4.58041802e-02f, -9.81338099e-02f, 3.32017764e-02f, -1.18176788e-02f, 7.51281977e-02f, 8.56520981e-02f,
  6.42070919e-02f, 1.11358210e-01f, -1.26124129e-01f, -6.77350834e-02f, 1.40374914e-01f, -6.12691103e-04f, -3.70054096e-02f, -9.19971094e-02f, -2.76530185e-03f, -7.43558332e-02f,
  2.58215610e-02f, 1.01873092e-01f, -1.49090001e-02f, -7.31592774e-02f, 9.27231014e-02f, 5.36859930e-02f, 4.40377519e-02f, -2.77303904e-02f, 5.89429140e-02f, 4.67922054e-02f,
  3.64483893e-02f, 2.66658608e-02f, 6.10377789e-02f, -6.78926557e-02f, 4.95928191e-02f, 6.21161163e-02f, 3.95552069e-02f, 4.16267663e-02f, -3.77966203e-02f, -8.30977187e-02f,
  2.30909456e-02f, -3.56961451e-02f, 6.22177161e-02f, 1.30793806e-02f, -8.58411379e-03f, 2.82409089e-03f, -9.24489424e-02f, -7.81660974e-02f, -6.47314265e-02f, -3.29087041e-02f,
  -1.40423728e-02f, 5.17454445e-02f, -5.08415736e-02f, 9.57106873e-02f, -3.97133268e-02f, -2.61572096e-02f, -3.96796986e-02f, -8.97560716e-02f, 2.54445486e-02f, -3.89931863e-03f,
  7.25893676e-02f, -1.99508369e-02f, -8.59135203e-03f, -8.25673528e-03f, 3.03108450e-02f, -1.36679849e-02f, -3.83511893e-02f, -3.22884470e-02f, 5.31798117e-02f, 5.80333583e-02f,
  1.02272592e-02f, 7.22137392e-02f, 3.30570415e-02f, 5.28939217e-02f, -6.42739907e-02f, -9.48827863e-02f, -5.28420396e-02f, -6.10267231e-03f, 4.63526957e-02f, 3.85739468e-02f,
  2.53845509e-02f, -1.97820738e-01f, 3.27313691e-02f, -7.13811889e-02f, -3.65088172e-02f, 4.35263403e-02f, 5.79463784e-03f, -3.26771252e-02f, -4.45802622e-02f, -4.19642925e-02f,
  -7.29220808e-02f, -6.00525402e-02f, 5.59978075e-02f, -7.13218153e-02f, -3.31531540e-02f, 4.42103073e-02f, 3.87601592e-02f, -1.60001256e-02f, -1.02365520e-02f, -4.07130904e-02f,
  2.49667522e-02f, 2.92403847e-02f, 8.46280307e-02f, 8.91774818e-02f, -8.10092762e-02f, 3.42029743e-02f, 2.00168565e-02f, -8.57501850e-02f, 6.41531572e-02f, -8.43344107e-02f,
  -1.66238546e-01f, 1.34549364e-01f, -1.18928850e-01f, 3.65945101e-02f, -6.64152727e-02f, 1.38894171e-01f, 1.19755067e-01f, -1.44566530e-02f, 5.47553934e-02f, 5.20105138e-02f,
  2.43222527e-02f, -1.60666600e-01f, -1.13435220e-02f, 5.81387244e-02f, 9.21449065e-03f, 7.45207220e-02f, 1.32731453e-01f, -3.59592177e-02f, 1.14779659e-02f, -3.28424796e-02f,
  6.14437042e-04f, -7.41654336e-02f, -6.96978495e-02f, -9.87071469e-02f, -8.38597640e-02f, 2.14865115e-02f, -1.83913969e-02f, -9.11854431e-02f, 6.63243830e-02f, -6.62829876e-02f,
  -2.12788433e-02f, -8.13609734e-02f, -2.32420210e-03f, -6.18686453e-02f, 6.10728450e-02f, -5.39251380e-02f, 1.78171620e-02f, 6.59310585e-03f, -9.42858532e-02f, 1.51266353e-02f,
  -1.04648747e-01f, -3.23106907e-02f, 5.07201888e-02f, 6.67850003e-02f, 1.41884368e-02f, -5.97912706e-02f, -7.45012537e-02f, -5.80125600e-02f, -4.77940477e-02f, 2.24041659e-02f,
  -6.30032562e-04f, -2.37451196e-02f, -6.66329190e-02f, 6.56675035e-03f, -3.90546992e-02f, -6.02450781e-02f, 6.24886788e-02f, 4.76527115e-04f, 2.51264833e-02f, 7.86219724e-04f,
  9.12143737e-02f, 7.61552081e-02f, 3.08394842e-02f, 7.79870749e-02f, 5.73586784e-02f, 1.19810039e-02f, 7.48882722e-03f, -6.32245615e-02f, 4.85176146e-02f, -4.52661514e-03f,
  3.48210000e-02f, -3.48907821e-02f, 7.91874528e-02f, -2.29136199e-02f, 8.67534801e-02f, 2.10645702e-02f, 3.85961123e-02f, 6.07420132e-02f, 6.52378947e-02f, 3.46513465e-02f,
  2.75814929e-03f, -4.76488434e-02f, -3.99704650e-02f, 6.97109615e-03f, -2.28165854e-02f, 6.51284233e-02f, -7.00496510e-02f, -4.89967577e-02f, -3.85053717e-02f, 2.71723643e-02f,
  5.70292287e-02f, 9.97619256e-02f, -3.85117829e-02f, 4.17628027e-02f, 6.21808246e-02f, 5.37532531e-02f, 4.67797518e-02f, -1.33377574e-02f, -3.78715061e-02f, -1.81165747e-02f,
  -7.70585164e-02f, -9.51353088e-02f, -5.78290485e-02f, 1.60862580e-02f, -4.54099756e-03f, -4.91232313e-02f, 6.80012554e-02f, 2.98692863e-02f, -7.66360536e-02f, -9.78147313e-02f,
  -6.19322434e-02f, -1.61265265e-02f, -6.61608055e-02f, 5.44107594e-02f, 2.56396588e-02f, 4.45125997e-03f, 3.38996835e-02f, 5.46352975e-02f, 4.24719565e-02f, -2.28216983e-02f,
  -1.46459267e-01f, 1.18938103e-01f, -1.44866228e-01f, -3.24885175e-02f, 8.51751305e-04f, -1.23982266e-01f, -1.00281596e-01f, -8.97071734e-02f, 6.83442056e-02f, 1.51951417e-01f,
  1.33476883e-01f, 1.67214368e-02f, 1.43751711e-01f, 1.06852129e-01f, -1.31596789e-01f, 7.66622126e-02f, -9.57295820e-02f, 7.51801729e-02f, -5.60154878e-02f, -2.75406260e-02f,
  -6.89245835e-02f, 1.29253194e-01f, -1.03284091e-01f, 6.96567819e-02f, -8.79825652e-02f, 3.63288634e-02f, 3.89473885e-02f, -2.94104628e-02f, -1.00247234e-01f, -9.03101191e-02f,
  -7.63673112e-02f, -6.25088960e-02f, -1.09792345e-04f, -4.91966680e-02f, -3.66876572e-02f, -8.64438266e-02f, -6.25897571e-02f, -6.89822286e-02f, -5.18980362e-02f, -3.03250290e-02f,
  7.80213028e-02f, -4.25499901e-02f, 7.34084696e-02f, -5.52594438e-02f, 4.75600250e-02f, -4.58344743e-02f, -9.04822070e-03f, 2.46719010e-02f, -9.42722857e-02f, 2.77725304e-03f,
  -5.43566383e-02f, -7.11882710e-02f, -9.89572406e-02f, -3.19517143e-02f, -4.26154397e-02f, -8.83331597e-02f, -3.11997719e-02f, -2.33165734e-02f, 3.74739505e-02f, 7.98739586e-03f,
  4.71849144e-02f, 3.28932665e-02f, 6.51418641e-02f, -5.20664118e-02f, -8.36822614e-02f, 4.22186330e-02f, 5.64759895e-02f, -6.16821945e-02f, 9.91694746e-04f, 5.37939519e-02f,
  -9.26259905e-02f, 7.00910911e-02f, -1.42586092e-02f, 2.82892771e-02f, -1.00676632e-02f, 7.29226246e-02f, -6.61232546e-02f, -3.40694450e-02f, -5.81108071e-02f, -2.70220302e-02f,
  8.80084261e-02f, -1.20726060e-02f, 2.04744060e-02f, 2.87579242e-02f, 1.50590558e-02f, -2.24234387e-02f, 1.66048501e-02f, 6.60830140e-02f, -7.04236850e-02f, -6.42846972e-02f,
  -4.30370979e-02f, -3.38241123e-02f, 7.61582628e-02f, 1.86511632e-02f, 7.19588324e-02f, -2.02281922e-02f, -8.54988396e-02f, 5.60208149e-02f, 4.65703234e-02f, -5.62696196e-02f,
  -4.36276495e-02f, -7.82512426e-02f, -7.89698958e-02f, 6.84498101e-02f, -5.68376295e-02f, 6.41440898e-02f, 3.84038240e-02f, 3.06657366e-02f, 2.41027921e-02f, 2.36931127e-02f,
  1.07453868e-01f, 8.69710147e-02f, 5.40901870e-02f, -9.71859097e-02f, -9.35696810e-02f, 7.82624856e-02f, -2.79352851e-02f, -3.66716273e-02f, -1.12859040e-01f, -7.54735023e-02f,
  -8.14053863e-02f, 5.53345133e-04f, 9.87413526e-03f, -3.90014313e-02f, -1.01204319e-02f, -1.08007997e-01f, -8.86739790e-02f, -7.66891707e-03f, 4.46541645e-02f, -1.63147122e-01f,
  -5.60211111e-03f, -6.94344565e-02f, -6.19843565e-02f, 1.44800125e-02f, 2.64652446e-02f, 1.43905103e-01f, -7.45087489e-02f, -1.33614585e-01f, 6.38746843e-02f, -3.75661701e-02f,
  1.01751219e-02f, -2.93793194e-02f, 1.34537965e-01f, 1.15593143e-01f, -9.69249979e-02f, 1.18384324e-02f, -2.56431289e-02f, 1.16366394e-01f, -8.63561630e-02f, -1.72986239e-02f,
  -1.38255700e-01f, -5.34588052e-03f, 4.84903343e-03f, 3.59854475e-02f, -9.57657024e-02f, -1.10935509e-01f, -5.18929325e-02f, 2.35287901e-02f, -9.72705428e-03f, -6.53562322e-02f,
  3.64331603e-02f, 8.80173668e-02f, -5.69355227e-02f, -3.41352150e-02f, 2.29367148e-02f, 2.82648616e-02f, 8.17806553e-03f, -4.47809398e-02f, 9.43115819e-03f, 8.23998749e-02f,
  5.97079508e-02f, -8.37099701e-02f, 3.64685841e-02f, -4.78160195e-02f, 5.44887446e-02f, 9.13386047e-03f, 7.09527731e-02f, -2.09407639e-02f, -9.45249647e-02f, -2.84998287e-02f,
  5.22553660e-02f, 7.99492002e-03f, -2.41414700e-02f, 7.97612534e-04f, -7.03053623e-02f, 7.01404288e-02f, -7.78834298e-02f, -7.57358372e-02f, -4.91052866e-02f, -6.66984692e-02f,
  -6.15742467e-02f, 2.37517543e-02f, 9.76198390e-02f, 3.55581529e-02f, 1.82431284e-02f, 1.72750112e-02f, 2.83844229e-02f, -6.35605305e-03f, 9.30071548e-02f, -1.78783527e-03f,
  8.74195322e-02f, 9.24382731e-03f, -1.80158243e-02f, 7.84055367e-02f, -5.97547218e-02f, 8.88033584e-02f, 4.37146127e-02f, 7.20995441e-02f, -5.70596270e-02f, 5.28327003e-02f,
  -1.19424462e-01f, -7.47449845e-02f, -4.57883254e-02f, 4.04216237e-02f, -5.30283675e-02f, 6.79088384e-02f, 1.91021729e-02f, -7.08759651e-02f, -6.12094179e-02f, 8.99430737e-02f,
  -5.77236759e-03f, 4.88051586e-02f, 3.85255292e-02f, 1.33497445e-02f, -1.23614119e-02f, -6.13098033e-02f, 5.02200574e-02f, 5.55495471e-02f, -4.89762798e-02f, 7.57005736e-02f,
  9.81898606e-03f, 5.78281768e-02f, -6.93996772e-02f, -6.20036386e-03f, 6.85133561e-02f, 7.86072202e-03f, 7.69605860e-02f, 8.55036974e-02f, 2.57660542e-02f, 3.08313388e-02f,
  3.08814663e-02f, 1.79140151e-01f, 8.59163180e-02f, 1.83407478e-02f, -2.87824608e-02f, -1.32799447e-01f, -4.01956625e-02f, -6.77747605e-03f, 6.84224293e-02f, 1.22811824e-01f,
  3.78728993e-02f, 1.56709626e-01f, -2.45495550e-02f, 1.16998535e-02f, -4.09054756e-03f, -3.71512435e-02f, 1.69946644e-02f, 1.18739046e-01f, -9.92064457e-03f, 2.12162118e-02f,
  -1.22126071e-02f, 3.25341821e-02f, 1.32548846e-02f, 9.68759432e-02f, 6.74996227e-02f, 1.33565694e-01f, 7.66251795e-03f, -1.04889125e-01f, -3.84333320e-02f, -3.15904506e-02f,
  -3.19316871e-02f, 4.35993746e-02f, -2.10297834e-02f, 2.92644296e-02f, -2.81349700e-02f, 5.26936986e-02f, 2.13345811e-02f, -1.50129516e-02f, -2.05344167e-02f, -7.30781034e-02f,
  6.45470759e-03f, 4.83893789e-02f, -4.56109736e-03f, -1.74857434e-02f, 2.46261936e-02f, -2.25933660e-02f, 5.07657304e-02f, 9.47512761e-02f, 1.75451189e-02f, 6.81630597e-02f,
  2.17411891e-02f, -5.40037192e-02f, 5.55828772e-02f, -2.73856358e-03f, -3.21036652e-02f, 2.63309386e-02f, 2.59837825e-02f, 2.82361847e-03f, 7.07791001e-02f, -3.79871664e-04f,
  1.04013458e-03f, 8.63811895e-02f, 2.54911352e-02f, -8.39791913e-03f, 3.23779508e-03f, 4.97124866e-02f, -6.75640549e-05f, -8.19476321e-02f, 4.03214153e-03f, 1.04570827e-02f,
  4.90737483e-02f, 6.40194267e-02f, 6.57185912e-02f, 5.50713874e-02f, 6.94826171e-02f, -3.73580344e-02f, -3.28977592e-02f, 1.12577304e-02f, 7.38241822e-02f, -4.97320071e-02f,
  -5.95234521e-02f, 1.86126549e-02f, -6.70489073e-02f, 8.36942047e-02f, 6.06003664e-02f, -3.45802121e-02f, 6.18328005e-02f, 1.72717124e-02f, -2.10533347e-02f, 5.32579683e-02f,
  5.06174676e-02f, 8.70411694e-02f, -7.64908120e-02f, 2.78703701e-02f, -1.98760889e-02f, 5.70782423e-02f, -5.11200130e-02f, 3.83860344e-04f, 7.86866248e-02f, 5.78310713e-02f,
  -8.40390250e-02f, -8.65929350e-02f, 2.77922843e-02f, -1.57045554e-02f, -7.35220835e-02f, -2.05679443e-02f, 6.51401654e-02f, 1.23823630e-02f, 9.10905451e-02f, 1.07768476e-01f,
  6.78496286e-02f, -4.31536175e-02f, 6.69345558e-02f, -5.37308455e-02f, -5.56633249e-02f, -4.59801257e-02f, -4.31451341e-03f, 4.00176793e-02f, 1.79910809e-02f, 5.84320864e-04f,
  -2.27652952e-01f, 2.23847076e-01f, -1.38676554e-01f, -3.99143174e-02f, -1.15300320e-01f, -7.69683123e-02f, -3.80493440e-02f, -9.62260887e-02f, -2.99285837e-02f, 2.72707343e-01f,
  1.79508179e-01f, 9.34538543e-02f, 1.96663246e-01f, 1.35316163e-01f, -3.19162309e-01f, 1.00772567e-01f, 7.92149082e-02f, 1.52531788e-01f, -1.10340759e-01f, -3.67798819e-03f,
  -1.34677529e-01f, -1.64353978e-02f, -7.54486350e-03f, 1.34919174e-02f, -5.78651987e-02f, -9.47576463e-02f, -1.17418349e-01f, -1.11428201e-01f, -7.67761990e-02f, 6.33585174e-03f,
  -1.48573667e-01f, -1.43550858e-01f, -4.95986193e-02f, -5.22837937e-02f, -9.66274887e-02f, -1.98851917e-02f, -1.01762503e-01f, 4.64575253e-02f, 1.41412700e-02f, -2.27855593e-02f,
  3.66654084e-03f, 3.25223207e-02f, -5.48327938e-02f, 6.16805255e-02f, 4.33236174e-02f, 2.00183354e-02f, -5.52131683e-02f, 7.26380646e-02f, -3.23680118e-02f, 2.25959308e-02f,
  9.10648182e-02f, -6.04959987e-02f, 1.20231742e-02f, 9.19098184e-02f, 1.61880758e-02f, -4.90583740e-02f, 4.05306332e-02f, 3.43819452e-03f, -3.15379282e-03f, -1.33348843e-02f,
  2.72077192e-02f, -5.02707362e-02f, 9.93027631e-03f, 5.33023588e-02f, 4.23701443e-02f, 8.92497376e-02f, 1.54592115e-02f, 4.43769842e-02f, 2.02192515e-02f, 4.08348553e-02f,
  5.38816154e-02f, 6.06197864e-02f, -8.41577724e-03f, 1.17435325e-02f, -3.34433243e-02f, 1.62448604e-02f, 4.67977785e-02f, 4.84295078e-02f, 2.76341811e-02f, -3.27607356e-02f,
  1.57758687e-02f, 6.40396541e-03f, 2.30294019e-02f, 8.29753280e-02f, 4.75501120e-02f, -8.69192928e-03f, 7.72257522e-02f, 5.21856919e-02f, 6.21660836e-02f, 1.87428799e-02f,
  -2.11610228e-01f, -2.38157287e-01f, -1.87071897e-02f, -8.55186656e-02f, -1.33114727e-02f, -2.34062783e-02f, 8.08464140e-02f, 3.48986639e-03f, -1.15770109e-01f, 2.91411579e-03f,
  4.68464606e-02f, 1.09486431e-01f, -9.13707614e-02f, 7.08971471e-02f, 9.53202043e-03f, 9.17476788e-03f, 4.10686210e-02f, 3.11809704e-02f, -1.13279380e-01f, -5.81359193e-02f,
  -3.07139121e-02f, -6.74356446e-02f, -4.29377593e-02f, -8.40918794e-02f, 5.63593097e-02f, -1.42316818e-02f, -6.22792281e-02f, 2.40584649e-02f, -8.83634463e-02f, 1.41739268e-02f,
  -9.52397436e-02f, 3.22474949e-02f, 7.87623003e-02f, 3.84374820e-02f, -7.04472438e-02f, 7.52147734e-02f, -4.56920406e-03f, 6.60493299e-02f, -8.04227442e-02f, 5.54995872e-02f,
  -1.42809078e-01f, 5.05993180e-02f, -4.15412299e-02f, 4.97107990e-02f, -4.77289408e-02f, 1.01884186e-01f, 2.94030854e-03f, -6.22956567e-02f, 6.28332198e-02f, 6.35931492e-02f,
  -2.19170600e-02f, 4.78798784e-02f, 3.10498495e-02f, 2.62649022e-02f, -3.03574968e-02f, -4.66291532e-02f, -1.27240300e-01f, 3.80619429e-02f, -5.82706928e-02f, 5.85663393e-02f,
  -7.86747262e-02f, -1.61307439e-01f, -8.02094191e-02f, 2.94207465e-02f, 1.57877766e-02f, -4.13350798e-02f, -5.65077178e-02f, -6.67692050e-02f, -6.69479668e-02f, 6.04762137e-02f,
  3.19629014e-02f, 5.79351466e-03f, -6.77866787e-02f, -4.81860247e-03f, -7.53050447e-02f, 2.19193590e-03f, 1.16892103e-02f, 7.01348856e-02f, 4.67065908e-02f, 3.89508568e-02f,
  2.88148299e-02f, 2.54276954e-02f, -4.99134101e-02f, -3.84923145e-02f, -6.95075914e-02f, -6.96189404e-02f, -7.40464032e-02f, 2.18938366e-02f, 7.70647973e-02f, 8.58572796e-02f,
  1.69463493e-02f, -8.14333335e-02f, 4.59825918e-02f, -8.40653628e-02f, 6.51715696e-02f, -7.24554285e-02f, 3.20434384e-02f, -4.19756062e-02f, 4.31730077e-02f, 1.14295539e-02f,
  -5.97498491e-02f, -4.87848110e-02f, 1.48588018e-02f, 3.79802883e-02f, 8.12639073e-02f, 4.36103567e-02f, -5.58858104e-02f, 3.84182222e-02f, 7.63433054e-02f, 9.88138169e-02f,
  4.90838662e-02f, -3.83058302e-02f, -3.82483974e-02f, 3.62758785e-02f, 4.62894812e-02f, -4.73668799e-02f, 8.61654356e-02f, 1.74927842e-02f, 2.67322529e-02f, -5.58329374e-02f,
  -1.18770279e-01f, -3.76317948e-02f, 3.25604714e-02f, -6.13011941e-02f, 3.36681977e-02f, -3.25885378e-02f, -8.38915557e-02f, -8.77109692e-02f, -6.31921589e-02f, -9.22226929e-04f,
  -3.51438560e-02f, -4.78401147e-02f, -5.44247366e-02f, 7.63931498e-02f, 7.23093823e-02f, 7.32999668e-02f, 2.27498580e-02f, 2.89150942e-02f, -7.05685467e-02f, -7.28147924e-02f,
  -7.31723234e-02f, -1.00328483e-01f, -4.94433986e-03f, 5.45442179e-02f, 1.25781465e-02f, 6.03843667e-02f, -5.64988256e-02f, -9.80471671e-02f, -6.88602403e-02f, 5.26432730e-02f,
  1.48667201e-01f, -1.17485583e-01f, -1.55046433e-01f, 1.29633024e-01f, 2.44365558e-01f, -1.87136587e-02f, 7.99296051e-02f, 7.34934583e-02f, -2.96476074e-02f, 3.18125226e-02f,
  1.64297551e-01f, -1.11728057e-01f, -1.80763349e-01f, -9.67092440e-02f, -3.82140055e-02f, -2.49826670e-01f, 5.20236976e-02f, 1.27627677e-03f, -5.23268916e-02f, 1.68666363e-01f,
  5.60945682e-02f, 9.08478722e-02f, -3.17193493e-02f, -1.66879576e-02f, 1.25902504e-01f, 1.18060276e-01f, 1.58667013e-01f, -1.25196919e-01f, 1.25031307e-01f, -4.96566705e-02f,
  -3.65724377e-02f, -6.35666400e-02f, -6.74754679e-02f, -4.23741415e-02f, 8.39793980e-02f, 1.16538629e-01f, -7.24398866e-02f, -8.88916925e-02f, -6.85406774e-02f, -9.81549546e-02f,
  1.74419861e-02f, -2.76846793e-02f, -2.10626628e-02f, 2.11889874e-02f, -3.26980688e-02f, 2.40858067e-02f, -6.86441660e-02f, 3.54773626e-02f, 6.47631055e-03f, 3.55339795e-02f,
  5.80240041e-02f, 1.32000120e-03f, -1.90011766e-02f, 1.57938618e-02f, -3.60668860e-02f, -2.91784611e-02f, -3.66536528e-02f, 8.43097940e-02f, -3.21934968e-02f, 8.92535970e-03f,
  2.67295334e-02f, 6.90688714e-02f, -9.13115367e-02f, 4.23397161e-02f, -1.73812434e-02f, -3.42646092e-02f, 8.79573822e-03f, 1.00088054e-02f, 8.98750219e-03f, -3.46846804e-02f,
  6.94997190e-03f, 4.39503454e-02f, -6.77126944e-02f, 9.25781727e-02f, 1.00595944e-01f, 9.58150811e-03f, -4.11218517e-02f, -1.62088368e-02f, 2.45321468e-02f, -5.49281053e-02f,
  -1.22758355e-02f, -4.21871729e-02f, 1.09879971e-02f, 3.86769697e-02f, -9.36459750e-02f, 4.34070034e-03f, 9.95139182e-02f, 1.01135923e-02f, 2.37604398e-02f, 8.78165886e-02f,
  7.16317892e-02f, 6.12844974e-02f, -7.27373234e-04f, -6.93746516e-03f, 4.71693575e-02f, 1.40580952e-01f, 2.48054545e-02f, -7.75619643e-03f, 2.88156532e-02f, -1.50348945e-02f,
  1.49211600e-01f, 4.04542796e-02f, 8.14644843e-02f, -7.51689449e-02f, 9.67124198e-03f, 9.65643674e-02f, 7.47984648e-02f, -2.50475225e-03f, -2.06666104e-02f, 5.16221412e-02f,
  4.14468497e-02f, 3.47094014e-02f, 2.22807340e-02f, 1.26166239e-01f, 1.90667436e-02f, 1.24835186e-01f, 8.79144222e-02f, 2.45593321e-02f, 8.90106857e-02f, -8.05569068e-02f,
  2.20266461e-01f, -8.37753713e-02f, -4.30504307e-02f, 3.21281999e-02f, 1.61544994e-01f, 6.77287877e-02f, -4.29188907e-02f, 5.14301434e-02f, 3.55693884e-02f, -7.72097474e-03f,
  -6.41683117e-02f, 1.08862147e-02f, -1.94358885e-01f, 3.29650119e-02f, 7.34856054e-02f, -5.54772466e-03f, 6.47438318e-02f, 6.23800419e-02f, 7.99602792e-02f, -4.20503579e-02f,
  1.28799200e-01f, -3.31284590e-02f, -9.98325199e-02f, -5.29804863e-02f, 3.50160375e-02f, 5.50645515e-02f, 8.31407122e-03f, -7.27376435e-03f, -9.04181600e-02f, -1.02320984e-01f,
  5.21267252e-03f, -1.07132178e-02f, 8.64044856e-03f, -1.67197883e-02f, -1.83375701e-02f, -1.75141003e-02f, -2.39638332e-02f, -1.06968254e-01f, -3.57635729e-02f, 6.61813691e-02f,
  -4.02900726e-02f, 3.98491807e-02f, 1.78241299e-03f, -4.02546637e-02f, 6.85396418e-03f, -6.50063753e-02f, 6.63444996e-02f, 2.97650192e-02f, -9.94865373e-02f, -7.92101119e-03f,
  -1.65280737e-02f, -1.45029614e-03f, -1.16298767e-02f, -3.41972616e-03f, -3.02274227e-02f, 6.06309325e-02f, -1.20865576e-01f, -6.81609986e-03f, 6.70323148e-02f, 7.89003372e-02f,
  9.22374334e-03f, -4.44424599e-02f, -7.97271505e-02f, 3.49514298e-02f, 3.72241959e-02f, 6.19889982e-03f, 4.03597131e-02f, -3.04980539e-02f, 6.52505085e-02f, 7.73475468e-02f,
  8.31907466e-02f, -7.31103271e-02f, -9.47806425e-03f, -6.81385174e-02f, -4.53221016e-02f, 8.99348930e-02f, -7.13974014e-02f, 2.76440922e-02f, -3.89331691e-02f, -3.93601395e-02f,
  -8.85384977e-02f, 6.83259917e-04f, -3.19146663e-02f, -2.88860314e-02f, -4.24966924e-02f, -8.00359249e-02f, -7.49932602e-02f, 1.22518640e-03f, -5.92245199e-02f, -4.03337069e-02f,
  -2.19694450e-02f, -2.67599337e-02f, -3.73942629e-02f, 8.80059898e-02f, 6.59551620e-02f, 4.50534113e-02f, 1.61698796e-02f, -3.94726582e-02f, -9.19296965e-02f, -9.72756892e-02f,
  6.38673678e-02f, -5.42614944e-02f, -4.80189957e-02f, -7.85112660e-03f, -7.67649114e-02f, 1.08864963e-01f, -7.78027549e-02f, -1.45523027e-02f, 2.26453897e-02f, 2.81425081e-02f,
  -2.89964247e-02f, 8.34321305e-02f, -6.83785304e-02f, -2.07384210e-02f, -3.28452103e-02f, -2.15838049e-02f, 1.27820102e-02f, -1.15569636e-01f, -8.70547667e-02f, -5.00352075e-03f,
  8.16519241e-05f, -1.65955201e-01f, -1.99896768e-01f, -1.03371732e-01f, -1.95712969e-02f, -5.48051372e-02f, -6.91461414e-02f, -9.70300362e-02f, -1.11420311e-01f, -6.60557151e-02f,
  -5.52575961e-02f, -9.14912522e-02f, -1.51711358e-02f, -9.61745605e-02f, 6.47325292e-02f, -1.17916033e-01f, -2.66938433e-02f, 2.96042953e-02f, -5.03033847e-02f, -2.75878236e-02f,
  -6.69930056e-02f, -7.64432782e-03f, -1.82479754e-01f, 1.13100141e-01f, -7.31492266e-02f, 2.90425476e-02f, 1.30720511e-01f, 2.94042379e-02f, 9.84130874e-02f, -6.78683538e-03f,
  -3.05571314e-02f, 1.52480705e-02f, -1.70653481e-02f, -5.46760410e-02f, 2.45610550e-02f, 6.01460226e-03f, 3.63793150e-02f, 6.64656311e-02f, 3.60663608e-02f, -8.27547312e-02f,
  1.05622947e-01f, 9.87191568e-04f, 2.01452821e-02f, 3.61480340e-02f, -9.27715749e-03f, -1.29292430e-02f, 5.74624650e-02f, -4.90801223e-02f, 6.75560087e-02f, 6.52304664e-02f,
  -1.19726531e-01f, -9.95640457e-02f, -3.96251604e-02f, -5.60692279e-03f, 2.34248433e-02f, 3.65084969e-02f, 5.70048727e-02f, 2.99765281e-02f, -7.56154507e-02f, 6.67639896e-02f,
  -1.74374189e-02f, 8.82988423e-02f, 2.55252942e-02f, -2.66081002e-02f, -3.63315083e-02f, -1.18762497e-02f, 7.98027217e-03f, 5.47613502e-02f, -5.40298894e-02f, 2.93106213e-02f,
  -1.76372435e-02f, 7.14882836e-02f, 6.91962093e-02f, 2.17171069e-02f, 5.84689192e-02f, -3.95491831e-02f, 7.47793540e-02f, -6.76999837e-02f, -1.38890306e-02f, 2.08622403e-02f,
  -3.35774980e-02f, 1.03964999e-01f, 7.23774880e-02f, -1.56636946e-02f, 1.94650479e-02f, 6.18630312e-02f, 9.99419671e-03f, 1.45281646e-02f, -5.40782176e-02f, -1.13789318e-02f,
  -6.59960508e-02f, -3.44465999e-03f, -4.18795012e-02f, 9.82266292e-02f, 1.02943648e-02f, 4.24349904e-02f, -3.12883034e-02f, 5.44007346e-02f, -6.24772906e-02f, 7.91076869e-02f,
  2.68118922e-04f, 8.08580518e-02f, 1.10349961e-01f, 3.38970982e-02f, 5.45365624e-02f, -5.98546751e-02f, 6.02885261e-02f, -3.83900180e-02f, -2.47544348e-02f, 2.60642227e-02f,
  2.28302740e-03f, 5.58485165e-02f, 5.97311445e-02f, -4.20472696e-02f, -4.13462613e-03f, 1.08153988e-02f, -5.53945126e-03f, -4.48917188e-02f, 1.95920449e-02f, -5.45588508e-03f,
  -2.16803998e-02f, 1.67531773e-01f, -8.15976113e-02f, -9.78043862e-03f, 1.46554494e-02f, -1.45573318e-01f, -9.79803428e-02f, -1.31005151e-02f, -4.41271067e-03f, -3.70930582e-02f,
  -1.13343664e-01f, 6.82343021e-02f, 1.20985694e-01f, -4.10025939e-02f, -6.82190433e-02f, 1.35072008e-01f, -1.29988387e-01f, -7.86761791e-02f, 9.55072939e-02f, -7.35574588e-03f,
  1.20755741e-02f, 2.40195319e-02f, -9.39134285e-02f, 5.47541976e-02f, -1.37805685e-01f, -4.99322042e-02f, 1.55157782e-02f, -1.29370717e-02f, -1.13904700e-01f, -8.40916261e-02f,
  -7.21173361e-02f, -8.60878751e-02f, 3.43856327e-02f, -7.50973150e-02f, -1.34012597e-02f, -7.66815469e-02f, -2.12770998e-02f, 3.30076478e-02f, -4.51592132e-02f, 6.64783120e-02f,
  5.03187850e-02f, 6.46132156e-02f, -2.75464691e-02f, 7.00396672e-02f, 5.98209873e-02f, 5.22892959e-02f, -4.41515818e-02f, 7.85376132e-02f, 2.86274962e-02f, -1.06592756e-02f,
  -4.87488694e-02f, -5.49068525e-02f, -2.58458257e-02f, 1.37195792e-02f, -2.16472987e-03f, 2.93367691e-02f, -5.33438697e-02f, -1.09537607e-02f, -1.27740810e-03f, -7.35886320e-02f,
  7.20208287e-02f, 2.60498896e-02f, -7.17169344e-02f, 4.64514922e-03f, 4.36307192e-02f, -3.42064654e-03f, -7.87184611e-02f, 1.80262676e-03f, -1.74095351e-02f, 5.16338572e-02f,
  -6.81408942e-02f, -3.32819894e-02f, 6.69851676e-02f, -3.13553982e-03f, 4.37787510e-02f, -2.97542885e-02f, -2.57399678e-02f, 6.68132156e-02f, 1.85224582e-02f, 3.51179987e-02f,
  -7.65275061e-02f, -8.64618346e-02f, -8.11001956e-02f, 2.22261297e-03f, -8.61432180e-02f, -4.68437374e-02f, 5.25556616e-02f, -6.03406727e-02f, 8.61752331e-02f, 5.41571192e-02f,
  -6.20686449e-02f, -1.03763960e-01f, -3.36136743e-02f, 2.30830051e-02f, -4.73917611e-02f, -1.60622392e-02f, -3.74232680e-02f, 1.45201217e-02f, -4.07658741e-02f, 1.90254953e-02f,
  1.77540234e-03f, -1.27737699e-02f, 5.52632250e-02f, -9.00189579e-03f, -4.89291437e-02f, 4.66719232e-02f, 4.25673835e-02f, 5.54740056e-02f, 4.49461350e-03f, -3.66247110e-02f,
  3.68580148e-02f, 5.43484725e-02f, -4.86110896e-02f, -4.34961841e-02f, -6.24280870e-02f, -1.78261288e-02f, 7.87732080e-02f, 1.01666197e-01f, 4.66058142e-02f, -2.33970359e-02f,
  1.28550351e-01f, 1.15161940e-01f, 7.64892772e-02f, 1.54795945e-01f, -9.34061855e-02f, -1.47483289e-01f, -4.72206585e-02f, 2.32173167e-02f, 1.03434995e-01f, 5.22214063e-02f,
  -9.98160765e-02f, 7.54372925e-02f, 6.52357638e-02f, 1.08397312e-01f, 7.10115244e-04f, -1.08379312e-01f, 1.43841952e-01f, 1.05874099e-01f, -1.28907580e-02f, 1.92470655e-01f,
  -7.99543038e-02f, 1.99240763e-02f, -1.55498064e-03f, -8.00231751e-03f, -4.37158067e-03f, 6.36063069e-02f, -2.43723160e-03f, -5.90110384e-02f, 1.73132583e-01f, -6.68655261e-02f,
  1.26224104e-02f, 1.10802904e-01f, 2.15170607e-02f, 4.21037758e-03f, 1.74068976e-02f, 1.14409635e-02f, -3.01627279e-03f, -1.01940215e-01f, -7.29528517e-02f, 4.89996411e-02f,
  -3.92000340e-02f, -2.46532578e-02f, -4.67363261e-02f, 3.85692567e-02f, 1.23099852e-02f, 1.34411044e-02f, 5.24256378e-02f, 2.55393200e-02f, 1.56133212e-02f, 5.53659126e-02f,
  1.95245794e-03f, 9.71536413e-02f, 4.61928286e-02f, -6.67152256e-02f, -8.27631429e-02f, -3.46167721e-02f, 7.18877390e-02f, 1.08911932e-01f, 1.42792268e-02f, -5.29476628e-02f,
  4.84910458e-02f, -7.00443685e-02f, 4.71176056e-04f, -3.54639478e-02f, -1.26893241e-02f, 6.27864599e-02f, -4.47421595e-02f, -8.74670595e-02f, -4.82644923e-02f, 1.96287781e-02f,
  5.13061993e-02f, 2.68377196e-02f, -8.40580314e-02f, 6.33574128e-02f, 5.73089495e-02f, 3.61789539e-02f, -2.70349979e-02f, 9.53635350e-02f, -6.84723556e-02f, 1.95703879e-02f,
  -2.10517459e-02f, 8.23465139e-02f, 4.73845843e-03f, 2.67851893e-02f, -5.43859489e-02f, 5.45243435e-02f, 5.41238375e-02f, 1.72213409e-02f, -5.35769202e-03f, -4.70148027e-03f,
  1.56977493e-02f, 1.22166060e-01f, -4.27557044e-02f, -1.02653839e-01f, 4.59124930e-02f, -3.74428630e-02f, -3.37854624e-02f, -2.57894397e-02f, 4.29965854e-02f, -2.62354072e-02f,
  1.03642978e-02f, 3.79181728e-02f, 5.72569519e-02f, -8.52854401e-02f, 2.44049355e-02f, -1.83654241e-02f, 1.12937756e-01f, -3.40464301e-02f, 7.61640072e-02f, -8.71476438e-03f,
  -2.63189450e-02f, 5.12039997e-02f, 9.02324021e-02f, -2.48191655e-02f, 2.19327137e-02f, 1.96778029e-02f, 5.56618981e-02f, -4.02835608e-02f, 8.26258883e-02f, -3.09195202e-02f,
  -1.19045652e-01f, 7.88128451e-02f, -6.29726425e-02f, -1.03109665e-01f, -1.08894952e-01f, -2.34882161e-01f, -1.47082478e-01f, -3.96899022e-02f, 5.74932918e-02f, 6.61566630e-02f,
  5.73835000e-02f, 3.20503935e-02f, 1.63400888e-01f, -2.20304742e-01f, -5.89985549e-02f, -4.21274304e-02f, -1.18170895e-01f, -1.84654593e-01f, -9.86350924e-02f, -1.21490866e-01f,
  -8.10501203e-02f, -1.74049474e-02f, -1.60612687e-01f, -9.88990907e-03f, -1.06745899e-01f, 7.03564286e-02f, 1.34338796e-01f, -5.40337935e-02f, -1.57532409e-01f, -6.95399120e-02f,
  -4.54758666e-02f, 1.06678379e-03f, -8.78750067e-03f, -3.25644836e-02f, -1.48909260e-02f, -8.73583406e-02f, -4.35156077e-02f, -2.18701065e-02f, -2.50606332e-03f, 3.32288146e-02f,
  -5.42701110e-02f, -2.21006013e-02f, -2.34040581e-02f, -7.51999989e-02f, -3.66082676e-02f, -2.02361830e-02f, 2.13574748e-02f, -5.10403737e-02f, -3.29450425e-03f, -1.19676054e-01f,
  -3.69955190e-02f, -4.34822263e-03f, 3.93579155e-02f, 8.55333135e-02f, 4.84427176e-02f, 4.52537611e-02f, -4.76440266e-02f, -5.26124500e-02f, -4.34379280e-02f, 3.05144228e-02f,
  -1.14737907e-02f, -1.03987306e-01f, 4.04885486e-02f, -1.42680202e-02f, -3.04269511e-02f, 5.73881529e-02f, -2.62020156e-03f, 6.83709830e-02f, 6.26995414e-02f, -6.68785870e-02f,
  8.32084939e-02f, -9.81186703e-03f, -3.17921340e-02f, -1.81864027e-03f, -2.07723398e-02f, 5.56768700e-02f, -4.55251150e-02f, 5.11870421e-02f, -2.18640473e-02f, -6.33646846e-02f,
  8.80902112e-02f, -4.04700562e-02f, 2.47795526e-02f, -7.86443353e-02f, 7.55285621e-02f, 8.23761895e-02f, -2.33080611e-02f, -1.01826370e-01f, -3.39029245e-02f, 6.89456090e-02f,
  6.28410429e-02f, 1.63659722e-01f, 7.55955130e-02f, -8.32539648e-02f, 2.71867663e-02f, 2.96054482e-02f, 4.82206978e-02f, -4.89273854e-02f, 2.80115567e-03f, -1.81165431e-02f,
  1.69604905e-02f, -3.83900441e-02f, -2.31400412e-02f, -4.07371372e-02f, 1.02279909e-01f, 8.92892778e-02f, 9.06253532e-02f, 6.57623410e-02f, -5.32848686e-02f, 1.97226442e-02f,
  -3.34191369e-03f, 1.07264169e-01f, 5.96087463e-02f, -5.89191914e-02f, 1.05321081e-02f, -3.81661654e-02f, 8.59128013e-02f, -1.73595380e-02f, 6.39033467e-02f, 1.24827392e-01f,
  -2.09144726e-01f, -4.83675748e-02f, 2.54282188e-02f, -8.11557546e-02f, -1.15270466e-01f, 1.29910931e-01f, 9.56156626e-02f, -4.37242631e-03f, -3.90005223e-02f, 1.56872436e-01f,
  6.50280640e-02f, -1.04342684e-01f, 1.31000251e-01f, -3.89054343e-02f, -1.61204562e-02f, 1.12991221e-01f, 9.82552990e-02f, 5.86754642e-02f, 7.78275281e-02f, -1.10136665e-01f,
  -1.42886966e-01f, 2.88686641e-02f, 8.18976462e-02f, 7.46280178e-02f, -1.26958564e-01f, -1.12610683e-01f, -1.17948249e-01f, -7.91480169e-02f, 5.70162851e-03f, -5.25322035e-02f,
  1.25748768e-01f, 7.12634847e-02f, 5.49224578e-02f, 8.09902847e-02f, 5.67140914e-02f, -7.89961070e-02f, 6.28742278e-02f, 8.09624512e-03f, -7.57568628e-02f, 2.65510064e-02f,
  -7.96653479e-02f, -5.40651903e-02f, -6.58041164e-02f, -1.96246505e-02f, 6.17660582e-02f, 4.47966829e-02f, -9.72267985e-02f, 4.81624603e-02f, 7.06356466e-02f, -1.08724020e-01f,
  -5.93012795e-02f, 8.93629864e-02f, 3.02761905e-02f, -5.26175573e-02f, -6.27302825e-02f, 5.51722804e-03f, 1.15130194e-01f, -1.90487981e-03f, 8.23015347e-02f, 1.44267231e-02f,
  -4.57559600e-02f, 1.66481116e-03f, -4.17658910e-02f, -3.57274935e-02f, -7.38527179e-02f, 2.18639839e-02f, 6.64920406e-03f, 5.89923374e-02f, -4.71703224e-02f, -7.08270222e-02f,
  8.98987055e-02f, -7.14135915e-02f, 7.42719099e-02f, 6.36693388e-02f, 6.44671395e-02f, -3.33000720e-02f, 1.20204687e-02f, -2.57233754e-02f, -1.92563124e-02f, 8.86500180e-02f,
  3.69627029e-02f, 9.86132100e-02f, -2.03915015e-02f, 9.41785574e-02f, -5.13243936e-02f, 3.21293809e-02f, -5.54744527e-02f, -3.26183508e-03f, 3.76507118e-02f, -8.11256394e-02f,
  1.10368177e-01f, 9.84337106e-02f, 7.31251575e-03f, 1.02840200e-01f, 4.67047421e-03f, -1.43084479e-02f, 3.29923593e-02f, 1.18048387e-02f, 8.99942890e-02f, -7.54183158e-02f,
  7.07803071e-02f, 7.32301995e-02f, -4.01945971e-02f, 3.43431719e-02f, 3.56546938e-02f, -2.73818392e-02f, 2.76312921e-02f, -6.90947920e-02f, 2.65331306e-02f, -8.12670887e-02f,
  -7.87730590e-02f, 1.03453323e-01f, -5.47499880e-02f, 3.90352495e-02f, 3.68441530e-02f, 8.52906629e-02f, -7.41867796e-02f, 5.54873534e-02f, -4.27818038e-02f, 4.12214547e-02f,
  -4.04866226e-02f, -3.04518752e-02f, 1.70594025e-02f, 1.51765272e-01f, -1.13272950e-01f, -7.59543851e-02f, -1.27797529e-01f, -4.65301163e-02f, -1.07056335e-01f, -2.06966586e-02f,
  3.12635228e-02f, -4.67130914e-03f, -5.47010079e-03f, -4.16345224e-02f, 1.50633663e-01f, -8.68151262e-02f, 9.42188352e-02f, 1.94356963e-02f, 2.02873778e-02f, 6.12966605e-02f,
  1.15121119e-02f, 4.24702652e-03f, 1.50782540e-01f, 3.96494754e-02f, -2.24379711e-02f, 1.26924038e-01f, 2.48919562e-01f, -3.67700085e-02f, 1.56620443e-01f, -2.96779834e-02f,
  -1.53467149e-01f, 5.95461801e-02f, 4.87794764e-02f, -5.28177917e-02f, -1.16481436e-02f, -4.23211791e-02f, -5.92602082e-02f, 1.59620438e-02f, 7.41521418e-02f, -3.32146585e-02f,
  4.95957509e-02f, 5.34679852e-02f, 8.14110935e-02f, 4.07215208e-03f, -2.69349702e-02f, 1.06284089e-01f, -1.38637498e-02f, 1.34675251e-02f, -4.06967886e-02f, -6.82563558e-02f,
  -5.15014119e-03f, -4.49296460e-02f, 7.53431618e-02f, 8.29479545e-02f, 6.97032660e-02f, 4.59519448e-03f, -7.38846958e-02f, 1.15690023e-01f, 7.44295567e-02f, -1.52581008e-02f,
  -5.47281886e-03f, -8.42825398e-02f, -8.72576684e-02f, -4.58803177e-02f, -4.99712070e-03f, 1.57734603e-02f, -3.10881287e-02f, 5.60678765e-02f, -1.83048379e-02f, 5.49097359e-02f,
  6.24870416e-03f, 7.72085367e-03f, 1.74698178e-02f, 1.08347349e-02f, -8.34941678e-03f, 4.81350683e-02f, 1.88290179e-02f, 3.09194326e-02f, -4.71946038e-02f, -8.62072110e-02f,
  5.78546384e-03f, 3.66272107e-02f, 6.74349815e-02f, 3.51993069e-02f, 5.84935863e-03f, -2.35265940e-02f, 9.36058685e-02f, -6.30264133e-02f, -7.38621280e-02f, 4.98413704e-02f,
  1.21308170e-01f, 2.16171101e-01f, -4.56247777e-02f, -4.97534722e-02f, 8.75170231e-02f, -7.26795718e-02f, -1.29338512e-02f, -1.64545737e-02f, 5.05092852e-02f, -1.57985594e-02f,
  6.15506433e-02f, -5.36226034e-02f, 6.72372878e-02f, 2.00981796e-02f, -7.80059258e-04f, 3.76580544e-02f, 8.60113129e-02f, 3.12541835e-02f, 1.07525729e-01f, 2.75070332e-02f,
  -9.14498139e-03f, 5.60695603e-02f, 1.79800279e-02f, -2.41791103e-02f, -3.22282463e-02f, -5.22769056e-02f, 1.88774504e-02f, 7.72800371e-02f, 5.46104461e-03f, 4.01975680e-03f,
  -7.38354633e-03f, 2.68863887e-01f, 1.05678260e-01f, -6.16970398e-02f, -2.26892240e-04f, -1.59530416e-01f, -1.34527534e-01f, -1.22880396e-02f, -3.37041654e-02f, 2.08958358e-01f,
  5.90721071e-02f, 4.62611653e-02f, 4.74686213e-02f, -1.50611922e-02f, -3.89057010e-01f, -1.01406291e-01f, -9.77225974e-02f, -7.02035725e-02f, -6.12742603e-02f, 3.97248827e-02f,
  -1.72877789e-01f, -1.63825825e-02f, -1.06407486e-01f, 9.11398008e-02f, 1.11058116e-01f, 8.13031420e-02f, -1.24860048e-01f, 5.64993806e-02f, -3.82749800e-04f, -6.98874891e-02f,
  -8.42663720e-02f, 3.36167738e-02f, 5.68989292e-02f, -1.80579280e-03f, -5.05245812e-02f, -4.93461117e-02f, 1.17368586e-02f, -5.45918643e-02f, -3.40434141e-04f, -4.83447053e-02f,
  6.08359203e-02f, -1.62568185e-02f, -1.72859877e-02f, -8.23287964e-02f, 1.06119096e-01f, 8.88618827e-02f, -5.36559485e-02f, -1.92498546e-02f, 5.65745942e-02f, 9.37392637e-02f,
  7.49699399e-02f, -2.84060985e-02f, 1.31135704e-02f, 5.40483631e-02f, -7.81688914e-02f, 4.94646505e-02f, -8.27730820e-02f, -2.63090921e-03f, 7.28929713e-02f, -9.61519554e-02f,
  6.35178685e-02f, -7.65090436e-02f, 5.08014821e-02f, 4.75854166e-02f, -5.41538894e-02f, -6.84405584e-03f, 2.54520606e-02f, 1.04317516e-02f, 8.64770170e-03f, 2.12767776e-02f,
  -6.92857727e-02f, 6.22900538e-02f, 1.73050631e-02f, 3.80229279e-02f, -8.00830275e-02f, -3.22954245e-02f, 7.62935951e-02f, 7.97867402e-03f, -6.77252486e-02f, 1.02423900e-03f,
  8.32163841e-02f, 5.27386833e-03f, 4.20073420e-03f, -4.17855978e-02f, -7.25284666e-02f, 6.43377975e-02f, -8.11587181e-03f, -4.88710403e-02f, -5.99154644e-02f, -4.71881144e-02f,
  -8.76972452e-02f, 1.04970289e-02f, 7.76573643e-02f, 4.27214056e-02f, -4.67312448e-02f, 3.18977088e-02f, 6.51740357e-02f, 6.63131997e-02f, 1.42725091e-03f, -4.06370051e-02f,
  7.62223825e-02f, -7.60273635e-02f, -7.00262263e-02f, 6.08186573e-02f, -6.81367368e-02f, -1.85082797e-02f, -9.81980860e-02f, -3.58443111e-02f, -7.08620250e-02f, 7.39117414e-02f,
  5.18878177e-02f, 4.04405370e-02f, -6.99538505e-03f, 6.42638132e-02f, -6.16613738e-02f, -9.65589657e-03f, 8.93373638e-02f, -4.52296669e-03f, 4.15493846e-02f, 6.97755963e-02f,
  9.32757109e-02f, 1.91359594e-01f, 1.41495824e-01f, 1.18594719e-02f, 5.03205657e-02f, 1.64743625e-02f, 9.06035155e-02f, 5.43166175e-02f, 5.29978275e-02f, 1.09724514e-02f,
  -4.45755534e-02f, 2.36864433e-01f, 2.58044880e-02f, -6.30308734e-03f, -1.33387059e-01f, -2.22854897e-01f, -1.13582350e-01f, -6.13964610e-02f, 7.35202059e-02f, -5.87900169e-02f,
  -5.66882715e-02f, -1.01343244e-01f, -1.07574686e-01f, 1.06432810e-02f, 8.62961039e-02f, 1.76150724e-01f, -9.02596414e-02f, 5.46246804e-02f, -3.09923887e-02f, 5.12168743e-04f,
  -2.04844475e-02f, 2.13143323e-02f, 3.96813527e-02f, 7.60566890e-02f, -3.66669670e-02f, -6.47530928e-02f, -1.55386059e-02f, 7.71739781e-02f, 4.08855779e-03f, 5.79633266e-02f,
  7.59640485e-02f, 8.30713734e-02f, -5.40692657e-02f, 6.32695630e-02f, 8.52547437e-02f, 7.16906115e-02f, 5.66779822e-02f, 2.05832766e-03f, 1.23278730e-01f, 1.11820795e-01f,
  -3.06320246e-02f, 6.23824075e-02f, -7.95542598e-02f, -1.03386519e-02f, 5.01185730e-02f, -3.33203375e-02f, -8.92500803e-02f, -4.29242179e-02f, -7.13925883e-02f, 3.24354880e-02f,
  1.46314176e-02f, -6.17237436e-03f, 9.35790241e-02f, 5.02906889e-02f, -6.68592704e-03f, -7.21629290e-03f, 1.92653053e-02f, 6.98163034e-03f, 2.68740207e-02f, -4.27110903e-02f,
  -8.62680096e-03f, 1.07579045e-02f, 1.51779260e-02f, -5.14047854e-02f, -4.24729567e-03f, 6.52638078e-02f, -4.95177954e-02f, 7.65318274e-02f, -3.88611108e-03f, -2.18157712e-02f,
  -5.30196019e-02f, 2.18268689e-02f, 1.57712344e-02f, 6.14783987e-02f, 8.34455341e-03f, -1.72966048e-02f, 2.47562118e-02f, 9.23412293e-02f, 6.39470592e-02f, 1.36542721e-02f,
  -1.81827188e-01f, -1.95411161e-01f, 6.40731025e-03f, -6.16279915e-02f, 8.38160589e-02f, -4.87422459e-02f, -3.07924356e-02f, 3.30699645e-02f, -1.07983306e-01f, 5.83385900e-02f,
  -2.02204399e-02f, -1.82730295e-02f, -4.53201197e-02f, 3.57564352e-02f, 3.53259556e-02f, -4.21946235e-02f, -4.04834263e-02f, -7.12113082e-03f, -1.28185958e-01f, -6.22098055e-03f,
  5.66096082e-02f, 2.04227399e-03f, 3.27111743e-02f, -1.33950897e-02f, -5.87150790e-02f, 3.21093313e-02f, -1.19368592e-02f, -2.84235552e-02f, 2.84489281e-02f, 6.81147771e-03f,
  1.07473746e-01f, -4.77627963e-02f, -2.68019766e-01f, -3.58020775e-02f, -4.39925715e-02f, 2.39288458e-03f, -1.90449636e-02f, -1.75666586e-02f, -1.42502815e-01f, 1.24847218e-01f,
  9.10663083e-02f, -9.63847898e-03f, -1.40020102e-01f, 3.76394987e-01f, 1.86125517e-01f, 4.34960350e-02f, 2.58844286e-01f, 2.20891103e-01f, -1.82411586e-05f, -2.08169725e-02f,
  4.03463505e-02f, 3.41611832e-01f, 9.15566534e-02f, 1.80253118e-01f, 1.64604113e-01f, -2.73177233e-02f, 1.86148033e-01f, -2.24381983e-01f, 2.59631932e-01f, 1.22154608e-01f,
  1.34807685e-02f, 4.52561602e-02f, 4.47140075e-03f, -8.49149525e-02f, 3.14788558e-02f, 1.69106163e-02f, -6.19618110e-02f, -6.63688034e-02f, -8.92647658e-04f, -1.28091229e-02f,
  1.38272699e-02f, -5.02917022e-02f, 5.04240952e-02f, 4.56931144e-02f, -1.96537431e-02f, 6.47846144e-03f, 2.62589473e-02f, -1.42767122e-02f, -3.26393098e-02f, 2.08047330e-02f,
  -8.87026340e-02f, -2.96021290e-02f, -6.27444834e-02f, 8.82676337e-03f, 3.30842175e-02f, 3.98319960e-02f, -5.45168929e-02f, -4.35050373e-04f, 1.61721576e-02f, 6.08251132e-02f,
  -4.14679497e-02f, 4.25935239e-02f, -5.26514873e-02f, -2.34620702e-02f, -2.21061260e-02f, -3.52158584e-02f, -2.12489267e-05f, 2.71171890e-02f, 4.99802530e-02f, 8.17156583e-03f,
  -1.06482767e-02f, -5.68947308e-02f, 8.22822899e-02f, -3.57546993e-02f, -1.45848468e-02f, 3.53872590e-02f, -2.17346381e-02f, 5.23546897e-02f, -3.93791497e-03f, 7.62931630e-02f,
  5.86330406e-02f, -3.37357935e-03f, 7.53221139e-02f, -1.71390604e-02f, -5.85203699e-04f, 6.39072955e-02f, -1.28267100e-04f, -3.99548560e-02f, 5.68134449e-02f, -6.08358160e-02f,
  1.49991112e-02f, 3.26004922e-02f, -9.56030041e-02f, -4.84574363e-02f, -4.37631644e-02f, -4.02610563e-02f, 6.45636097e-02f, 7.97273666e-02f, -3.88414785e-02f, 3.32735060e-03f,
  -1.10236462e-02f, -5.47135696e-02f, 3.56398970e-02f, 4.48692925e-02f, -7.51387421e-03f, 2.42840983e-02f, 4.51544486e-02f, -7.22749606e-02f, 8.85018408e-02f, 2.54119597e-02f,
  1.24907205e-02f, 1.32602267e-03f, -2.86630429e-02f, -8.11867602e-03f, 1.52700916e-02f, -5.86653268e-03f, 1.10681467e-02f, 2.30898596e-02f, 7.37363473e-02f, 4.67381068e-02f,
  -9.61701870e-02f, 6.21290542e-02f, -6.03707172e-02f, 8.32864046e-02f, -3.52364816e-02f, 1.37563422e-01f, 1.94878146e-01f, -3.81055959e-02f, -2.15679891e-02f, 1.34402588e-01f,
  1.14213407e-01f, -4.26686220e-02f, 1.42742261e-01f, 1.95719481e-01f, 2.03441277e-01f, 1.34845451e-01f, 1.34075359e-01f, 2.39564665e-02f, -5.13017625e-02f, -7.30658919e-02f,
  1.98158193e-02f, 9.63895768e-02f, 8.31618235e-02f, -9.17259008e-02f, 9.28921029e-02f, -3.01226769e-02f, 2.07318459e-02f, -4.48212847e-02f, 6.48046210e-02f, 8.57967511e-02f,
  -2.78577749e-02f, -7.92582892e-03f, -1.01022914e-01f, -5.09890318e-02f, 6.12024106e-02f, -1.73270162e-02f, 4.50922213e-02f, -6.77133873e-02f, -4.32128981e-02f, 5.22153527e-02f,
  -5.26504852e-02f, 2.79775336e-02f, -7.24289343e-02f, -2.52833087e-02f, -3.11090760e-02f, 1.46470219e-02f, -1.55432206e-02f, 9.32905972e-02f, -7.48752803e-02f, 1.53020518e-02f,
  3.09064370e-02f, -3.28578539e-02f, -3.20919603e-02f, 1.02616347e-01f, 1.06526241e-01f, 6.20140582e-02f, 3.32474560e-02f, -8.40013940e-03f, 2.38996744e-02f, 8.06981847e-02f,
  1.86840072e-02f, 3.55883799e-02f, -8.60513598e-02f, -6.02972917e-02f, -2.59627751e-03f, 3.20344009e-02f, 2.88838223e-02f, -7.75568262e-02f, -6.69372082e-02f, 4.07371409e-02f,
  1.48431696e-02f, -3.90136167e-02f, -3.33783105e-02f, -5.07737398e-02f, -3.03961746e-02f, 8.90589356e-02f, -7.04661235e-02f, -3.55709866e-02f, -4.06570151e-04f, 3.52530461e-03f,
  -5.47452830e-02f, -3.49889733e-02f, 3.45526412e-02f, 8.17115530e-02f, -1.29260998e-02f, 4.36383039e-02f, -6.92435130e-02f, -6.33201599e-02f, -8.82780626e-02f, 3.56640704e-02f,
  -1.94556266e-02f, -8.33882391e-02f, -6.25209361e-02f, -9.36441720e-02f, -1.87303293e-02f, -2.75260918e-02f, 3.35837975e-02f, -5.54417111e-02f, -1.28513621e-02f, -3.45503390e-02f,
  5.95568381e-02f, 6.57373890e-02f, 4.17879708e-02f, -2.19669770e-02f, -4.61046025e-02f, -2.95102000e-02f, -3.34528903e-03f, 4.72515449e-03f, 1.36134652e-02f, 5.55993654e-02f,
  5.27025610e-02f, -7.60415718e-02f, -3.10760457e-02f, -3.32430713e-02f, 9.78526175e-02f, -3.51323560e-02f, -6.43647164e-02f, -6.38200110e-03f, 9.12714750e-02f, -7.06203654e-03f,
  2.35117245e-02f, -2.12830007e-01f, -1.70519620e-01f, 2.24113613e-01f, 1.51621893e-01f, -1.29530570e-02f, -4.00737068e-03f, 3.50061245e-02f, -3.81784104e-02f, -1.00432351e-01f,
  1.00738749e-01f, 1.43024395e-03f, -2.09544748e-01f, 2.39275679e-01f, 1.60582781e-01f, -1.38446808e-01f, 2.15857089e-01f, -4.92553599e-02f, -4.68813702e-02f, -1.14757251e-02f,
  1.87815920e-01f, 1.47987679e-01f, 1.21482730e-01f, 1.25047982e-01f, 1.68891788e-01f, 1.05715305e-01f, 5.37016653e-02f, -3.16751450e-02f, 2.34543070e-01f, 1.85496002e-01f,
  2.33139116e-02f, 5.79980686e-02f, -1.50446258e-02f, -5.86951002e-02f, -6.31088465e-02f, -3.02272029e-02f, 4.16873619e-02f, -2.42693555e-02f, 3.15894894e-02f, 5.27471080e-02f,
  6.74092248e-02f, 2.76527517e-02f, 8.86643119e-03f, -4.67601418e-02f, 1.52195254e-02f, 8.36986583e-03f, -6.82159662e-02f, 4.45459671e-02f, -7.89986700e-02f, -1.44868493e-02f,
  -1.09547183e-01f, -4.78269868e-02f, 2.51594055e-02f, 6.03637146e-03f, 2.36371215e-02f, 3.96297760e-02f, -2.08557514e-03f, -4.84352931e-02f, -2.39785388e-02f, 7.83957615e-02f,
  6.13214336e-02f, -8.14119540e-03f, 1.87128689e-02f, -2.35773399e-02f, 4.86203581e-02f, 2.50516739e-02f, 1.30218137e-02f, 6.32212311e-02f, -4.32722457e-02f, 4.02984116e-03f,
  1.46329030e-02f, -5.27254678e-02f, -2.79140435e-02f, 3.19977887e-02f, 4.85470034e-02f, -5.09413555e-02f, 5.11856861e-02f, -3.32438797e-02f, 3.42155397e-02f, -7.97291771e-02f,
  -4.31646965e-02f, 1.00284321e-02f, -8.20606872e-02f, 5.54042682e-02f, -3.58191095e-02f, -7.14256838e-02f, 8.07542726e-02f, -6.46515861e-02f, 1.59950741e-02f, 7.63153732e-02f,
  6.93142414e-02f, -2.42674090e-02f, 4.65418287e-02f, 3.79931591e-02f, -4.59057130e-02f, 6.03813976e-02f, 3.41211557e-02f, 6.34937808e-02f, -2.32124832e-02f, -3.59709165e-03f,
  7.38951191e-02f, -2.39157211e-03f, 6.16327450e-02f, -2.48334929e-02f, -2.97691915e-02f, -7.82418251e-03f, -5.40691474e-03f, 5.73853701e-02f, 6.27542194e-03f, 4.58090678e-02f,
  -5.67231476e-02f, -4.27183062e-02f, -1.52456909e-02f, 4.65437360e-02f, -3.97776216e-02f, 4.89202142e-02f, 5.74462637e-02f, -6.85553849e-02f, -2.33601872e-02f, -7.81786814e-02f,
  4.22239006e-02f, -1.31733343e-01f, -1.18282214e-02f, 3.38579118e-01f, 1.96036294e-01f, 6.02630563e-02f, 1.60554014e-02f, 5.72538525e-02f, 1.65000156e-01f, -2.22573310e-01f,
  -7.98216909e-02f, -1.27640948e-01f, -2.82669336e-01f, 2.41469935e-01f, 2.62675583e-01f, -1.66113883e-01f, 1.03917167e-01f, 7.34139308e-02f, 5.46818860e-02f, 1.22260064e-01f,
  1.42765731e-01f, 2.02454612e-01f, -5.33152223e-02f, 6.71628937e-02f, 1.21674418e-01f, 1.51079912e-02f, 9.97399092e-02f, -1.24628738e-01f, 7.76188374e-02f, 1.37208179e-01f,
  9.01592430e-03f, 1.29574642e-01f, -7.62654692e-02f, -3.82942073e-02f, 7.83683360e-02f, -7.67044052e-02f, -8.73130262e-02f, 2.25855522e-02f, 8.54287073e-02f, -4.41480204e-02f,
  -1.07623376e-01f, -3.23389135e-02f, 4.58455309e-02f, 6.53734570e-03f, 5.19531555e-02f, 1.80106200e-02f, 2.31498349e-02f, 5.60427792e-02f, -9.90859717e-02f, 3.35982181e-02f,
  -2.79420353e-02f, 3.57891396e-02f, -2.78025866e-02f, 2.65435278e-02f, -3.91953764e-03f, -5.37906885e-02f, -4.66189720e-02f, 9.08800925e-04f, 7.89256021e-02f, -7.25318911e-04f,
  7.24521801e-02f, 1.81643721e-02f, 9.21731722e-03f, 5.45289926e-02f, 1.57786906e-02f, 1.05089825e-02f, -2.31607701e-03f, -4.23668288e-02f, -3.59641612e-02f, -1.70790181e-02f,
  2.56901756e-02f, 4.02416252e-02f, 3.49490568e-02f, -4.29697260e-02f, -6.59265593e-02f, 2.68380810e-02f, -7.83925653e-02f, -7.24361166e-02f, 4.55705859e-02f, -1.81189030e-02f,
  -3.33251916e-02f, -3.75373773e-02f, -1.33574323e-03f, -6.52912632e-02f, 6.71190619e-02f, -7.15151727e-02f, 2.44092997e-02f, -5.17108999e-02f, 7.98145086e-02f, 5.44915255e-03f,
  -2.53703836e-02f, 1.30064502e-01f, -1.83746293e-02f, 5.52390404e-02f, 4.29568961e-02f, -3.73510346e-02f, 4.06934991e-02f, 9.44736078e-02f, -1.09095899e-02f, 3.51801887e-02f,
  3.85479555e-02f, 7.27806091e-02f, 1.97394434e-02f, -4.49391827e-02f, -6.61061704e-02f, 7.66528398e-02f, -6.36064187e-02f, -7.05394223e-02f, 3.81857231e-02f, -8.30929652e-02f,
  4.26994935e-02f, 3.56375463e-02f, 3.37714925e-02f, 4.38373117e-03f, 4.92904373e-02f, 3.05238254e-02f, -7.68662617e-02f, -5.51395118e-02f, -6.05915487e-02f, -2.73413528e-02f,
  -4.13442627e-02f, -2.35915780e-01f, -5.34601286e-02f, 8.59010145e-02f, 1.88948423e-01f, 1.04554124e-01f, 4.36901413e-02f, -1.82000436e-02f, -1.95774697e-02f, -8.29282403e-02f,
  -6.23134635e-02f, -2.12990209e-01f, -1.73098385e-01f, -3.64539027e-03f, -2.47667842e-02f, -8.07535499e-02f, 1.03489593e-01f, -8.43360946e-02f, 1.95489656e-02f, -9.96784121e-02f,
  1.25834391e-01f, 1.30620018e-01f, 3.12882289e-03f, 6.64690137e-02f, 1.06653102e-01f, -4.53407913e-02f, 7.37216845e-02f, -8.60428363e-02f, 1.21838480e-01f, 6.37978017e-02f,
  -3.58332060e-02f, -1.36017442e-01f, 1.09475730e-02f, 7.81701654e-02f, -7.44068762e-03f, -6.26129285e-02f, -3.03490516e-02f, -2.86911707e-02f, -1.31204305e-02f, -3.47321667e-02f,
  -1.20454244e-01f, -7.27793085e-04f, 2.40079947e-02f, 2.87083555e-02f, 6.02436513e-02f, 8.63947272e-02f, 8.51094499e-02f, -1.02847756e-03f, -2.62950603e-02f, -5.76782273e-03f,
  2.91958675e-02f, -7.80447796e-02f, 2.73484644e-02f, 3.57986130e-02f, 5.27272932e-02f, 4.25968021e-02f, 3.45182307e-02f, -5.92790172e-02f, 4.16275039e-02f, 7.14136213e-02f,
  -4.81047779e-02f, -2.99209096e-02f, 6.22185282e-02f, 8.05581361e-02f, -6.16360493e-02f, 1.35311177e-02f, 3.51599418e-02f, 1.20311137e-02f, -3.28546353e-02f, -5.68956956e-02f,
  5.74742630e-02f, -1.11219762e-02f, 8.34835246e-02f, 3.62941138e-02f, 5.82466554e-03f, 3.37951211e-03f, -5.02409376e-02f, -6.70596808e-02f, 4.96665761e-02f, 3.17562371e-02f,
  -1.56085484e-03f, -6.63304701e-04f, -6.02891929e-02f, 6.76442385e-02f, -8.28899518e-02f, 4.12437059e-02f, 4.68091946e-03f, -3.71949077e-02f, -3.89519967e-02f, -4.94387150e-02f,
  -1.92863643e-01f, -1.33003756e-01f, 4.03864235e-02f, -5.46216816e-02f, 6.07743375e-02f, -9.86743439e-03f, -2.57001705e-02f, 3.72735001e-02f, -6.68770224e-02f, 7.44863302e-02f,
  1.80802923e-02f, 9.69226360e-02f, 3.75635773e-02f, 1.64760202e-02f, -4.56036329e-02f, -1.41927004e-02f, -5.64837083e-02f, -2.97399350e-02f, -2.83444393e-02f, -4.86007556e-02f,
  -7.63858035e-02f, 7.41952956e-02f, 4.18774262e-02f, -3.29293422e-02f, -5.83832115e-02f, -2.25418359e-02f, -6.53974935e-02f, -9.01893992e-03f, -9.39813070e-03f, -2.20883358e-02f,
  -1.14770979e-01f, -7.29101375e-02f, -4.21566702e-02f, -1.02312505e-01f, -5.46266558e-03f, 7.25675449e-02f, 1.15373908e-02f, -8.83591082e-03f, 1.16453402e-01f, -2.74583176e-02f,
  3.54137272e-02f, -2.12411612e-01f, -7.45245218e-02f, -8.54645446e-02f, -1.61043316e-01f, -5.79753779e-02f, -1.35300964e-01f, -1.22229494e-01f, -3.97273116e-02f, 2.23209728e-02f,
  7.44766043e-03f, -1.06500000e-01f, -4.83276695e-02f, -6.02187216e-03f, -7.95097128e-02f, 3.99413034e-02f, -1.86097566e-02f, 4.61988635e-02f, -3.80153488e-03f, -1.29640356e-01f,
  -1.31240701e-02f, 7.44586363e-02f, -1.11122616e-01f, 3.47463861e-02f, -2.92761307e-02f, 1.69547014e-02f, -6.42190203e-02f, -8.50242376e-02f, -7.91649818e-02f, -2.17828411e-03f,
  3.00196763e-02f, -6.91375509e-02f, -4.19588313e-02f, -7.62768015e-02f, 1.15061455e-04f, 4.41510752e-02f, -5.81426620e-02f, 9.10921916e-02f, -5.02370261e-02f, -2.44782791e-02f,
  8.88536277e-04f, 8.44173580e-02f, 8.33990872e-02f, 1.84895552e-03f, 8.55499953e-02f, 2.25810315e-02f, 2.41526831e-02f, 1.19704343e-02f, 1.14238244e-02f, -7.12986663e-02f,
  8.55977833e-02f, -5.61660565e-02f, -7.31560588e-02f, 1.29996091e-02f, -4.07477729e-02f, 1.02704465e-01f, -6.50261790e-02f, 6.57183379e-02f, -3.91029269e-02f, -4.72008586e-02f,
  -1.15125207e-02f, -1.90130044e-02f, -5.22634499e-02f, -4.16822731e-02f, -5.39343767e-02f, 7.40626305e-02f, -9.31046605e-02f, 8.20942968e-02f, 5.29026911e-02f, 1.26118015e-03f,
  3.30739506e-02f, 5.21611683e-02f, 4.97420281e-02f, -7.43546635e-02f, 4.40487713e-02f, -3.08174025e-02f, -2.90768575e-02f, 1.05650604e-01f, 2.31112540e-02f, 2.81899665e-02f,
  -1.13896281e-01f, -1.09126240e-01f, -6.55167326e-02f, 9.08608735e-02f, -1.95504259e-03f, -4.37287614e-02f, -1.00512721e-01f, 7.17526004e-02f, 3.39320451e-02f, 9.30075441e-03f,
  2.70111598e-02f, 7.62428194e-02f, -1.98049583e-02f, -9.65173822e-03f, 5.80486730e-02f, -6.88581914e-03f, -9.75954253e-03f, -1.07832197e-02f, -1.18468665e-02f, 8.03136230e-02f,
  7.50205293e-02f, 7.26220310e-02f, 1.51413390e-02f, 8.84404927e-02f, 7.67482594e-02f, 1.31684579e-02f, -8.29498246e-02f, 7.07883686e-02f, -3.66416276e-02f, -1.00241356e-01f,
  -2.20590960e-02f, -1.14930198e-02f, -1.40747458e-01f, 1.91394973e-03f, -1.76519006e-01f, -2.04444990e-01f, -2.36208797e-01f, -1.15644909e-01f, 1.86536387e-01f, -2.26490153e-03f,
  -9.82593819e-02f, 1.00837335e-01f, -2.16980949e-02f, -7.14919642e-02f, 2.54808962e-02f, 1.22837767e-01f, -1.38717115e-01f, -5.04409783e-02f, -4.18508872e-02f, -1.22464389e-01f,
  3.76301631e-02f, -2.07898423e-01f, -4.72743660e-02f, -1.47952422e-01f, -1.84675992e-01f, -8.47208202e-02f, -2.73464955e-02f, -1.64310023e-01f, -1.36377528e-01f, -9.81865078e-02f,
  4.10650894e-02f, -6.14190325e-02f, -6.09073341e-02f, 5.61937876e-02f, -3.04192211e-02f, -6.86752200e-02f, -7.95383155e-02f, -6.08683862e-02f, 6.14006706e-02f, -2.21364181e-02f,
  2.47513480e-03f, -4.98254709e-02f, -2.39257980e-02f, 2.27237772e-02f, 2.78352592e-02f, 5.77597693e-02f, 4.68801335e-02f, -7.76921362e-02f, 1.63874459e-02f, 7.68484771e-02f,
  -5.80845354e-03f, 6.41760901e-02f, -4.10903618e-02f, -1.05247060e-02f, 3.27212326e-02f, 3.69453393e-02f, 4.54102457e-02f, -6.32184744e-02f, 5.95835038e-02f, 6.41064793e-02f,
  -5.41771315e-02f, 6.47230521e-02f, 4.31609191e-02f, -4.07904834e-02f, -5.24287708e-02f, -9.63623226e-02f, 6.83288905e-04f, 6.86889589e-02f, 8.96251798e-02f, -5.04897609e-02f,
  -8.22935849e-02f, -7.42838904e-02f, -7.38165304e-02f, 2.10001189e-02f, 2.57436503e-02f, 7.87965655e-02f, -6.99939281e-02f, 3.12879831e-02f, -6.94162324e-02f, -7.82143176e-02f,
  1.74436364e-02f, -3.68977115e-02f, 3.85423377e-02f, -9.44606867e-03f, 4.17022631e-02f, -4.32866365e-02f, 4.85614315e-02f, 6.53036982e-02f, 5.96422404e-02f, -2.37496365e-02f,
  -1.86546315e-02f, 4.96025011e-02f, 2.66877133e-02f, 2.04440439e-03f, 5.68690300e-02f, -1.66563522e-02f, -3.06190457e-02f, -7.77186453e-02f, 2.62657925e-02f, -8.93895631e-04f,
  3.97186261e-03f, -3.20980214e-02f, 4.88495314e-03f, -1.64971910e-02f, 7.92705640e-02f, -1.03235207e-01f, 9.94808786e-03f, 3.38469967e-02f, 1.66273322e-02f, -1.09074521e-04f,
  3.66450436e-02f, 5.07976599e-02f, 8.16105753e-02f, -1.11746378e-02f, 1.06599778e-01f, -2.41914056e-02f, -2.88908798e-02f, 9.96356085e-02f, -8.09752122e-02f, 6.35881559e-04f,
  9.01059434e-02f, -1.04468532e-01f, -9.48060155e-02f, 1.82611465e-01f, 7.92147815e-02f, 1.83258742e-01f, -5.67187890e-02f, -2.25093327e-02f, 5.06178774e-02f, -7.96118975e-02f,
  -8.28589499e-02f, 1.28839061e-01f, -2.17307895e-01f, 1.25612885e-01f, 1.68320701e-01f, 6.11825986e-03f, 1.72910377e-01f, 8.56973603e-03f, -4.59606871e-02f, 1.01026416e-01f,
  5.99236749e-02f, 1.62497744e-01f, -1.02510616e-01f, 5.96802905e-02f, 9.92286727e-02f, 1.94563600e-03f, -2.04118006e-02f, -1.58510566e-01f, 1.71143979e-01f, 1.82148129e-01f,
  8.91369730e-02f, 2.58224029e-02f, -8.80072080e-03f, 6.39564022e-02f, -1.18101895e-01f, -2.31107101e-02f, -1.12045566e-02f, 7.19527975e-02f, -2.02162303e-02f, -8.98230523e-02f,
  1.88852288e-02f, 1.12990625e-02f, 2.69663259e-02f, -4.75584380e-02f, 4.46899310e-02f, -9.63333622e-03f, -3.60113904e-02f, -4.56042103e-02f, 5.91346323e-02f, -1.13862500e-01f,
  -8.09152573e-02f, -6.22750632e-02f, 5.53709790e-02f, -7.44941458e-02f, -9.03258622e-02f, 8.08010548e-02f, 8.10307339e-02f, 3.54580209e-02f, 4.41732034e-02f, 1.09934092e-01f,
  -3.40177529e-02f, -6.11459697e-03f, -3.01703662e-02f, -6.52785040e-03f, -8.23663101e-02f, 4.17862572e-02f, -4.13562395e-02f, -1.34070087e-02f, -8.40765908e-02f, -1.72683373e-02f,
  -9.99027514e-04f, 5.86485080e-02f, 3.56618576e-02f, 9.49613750e-02f, 2.75830179e-02f, -2.00022943e-02f, 1.26549962e-03f, 3.82830687e-02f, -7.60614946e-02f, -8.19212571e-02f,
  5.82822924e-03f, -1.14473766e-02f, 7.01504573e-02f, 6.30203402e-03f, -5.09916693e-02f, -9.65362638e-02f, -1.11600175e-03f, 1.59799382e-02f, -1.09718218e-01f, 2.69742832e-02f,
  -3.42190079e-03f, -1.19919414e-02f, 5.54507636e-02f, -2.59953663e-02f, -9.14003402e-02f, -2.84626018e-02f, -1.67173743e-02f, 3.77327092e-02f, 1.08076543e-01f, 1.68202128e-02f,
  -2.07597297e-02f, 2.50443500e-02f, 8.12406167e-02f, 7.49350861e-02f, 9.89772901e-02f, -1.88381597e-02f, -2.89354417e-02f, -3.54006104e-02f, -1.08193066e-02f, -7.47271180e-02f,
  6.12324588e-02f, 1.21066393e-02f, -2.32491028e-02f, 1.63696404e-03f, -3.34418193e-02f, 1.92338554e-03f, 9.07557309e-02f, 1.00355772e-02f, 2.41587479e-02f, -6.68571144e-02f,
  -1.02305962e-02f, -1.22220412e-01f, -4.68664691e-02f, -8.32256898e-02f, -1.73109218e-01f, -1.06453612e-01f, -1.38464287e-01f, -1.18962437e-01f, -9.09442604e-02f, 3.03480006e-03f,
  -1.27301738e-01f, 9.13806781e-02f, -5.52928150e-02f, -3.37212645e-02f, 1.49747372e-01f, 1.53991967e-01f, -3.72623764e-02f, -8.46854374e-02f, -3.42138037e-02f, -1.11329578e-01f,
  4.29322235e-02f, -1.43594041e-01f, -4.42543924e-02f, -4.15436365e-02f, -1.12253428e-01f, -8.90418887e-02f, -2.42838226e-02f, -1.50964379e-01f, -1.30284905e-01f, -9.02865604e-02f,
  -4.17228751e-02f, -1.00911386e-01f, -2.58910544e-02f, 8.90613273e-02f, 5.82235083e-02f, -5.98994642e-02f, 5.55339567e-02f, -7.89254755e-02f, -3.55325341e-02f, 5.22847548e-02f,
  4.83980030e-02f, 6.03449829e-02f, 6.63281903e-02f, 4.85793725e-02f, -6.82157204e-02f, -8.09503570e-02f, 4.61404659e-02f, -2.19084155e-02f, 1.08891251e-02f, -8.70954897e-03f,
  -4.79423963e-02f, -9.16311219e-02f, 4.32059057e-02f, -4.11261618e-03f, 5.49270585e-02f, 3.36127952e-02f, -5.17995134e-02f, 3.05082928e-02f, -1.09101906e-02f, -2.89879534e-02f,
  -4.46140990e-02f, -5.00148274e-02f, -8.93147811e-02f, 1.56604368e-02f, 6.20503491e-03f, -2.00930685e-02f, -2.40594577e-02f, -4.08263914e-02f, -2.88458019e-02f, 7.42367208e-02f,
  5.81780076e-02f, -5.79327457e-02f, -8.98644179e-02f, 4.61675785e-02f, -1.84018817e-02f, 6.12396076e-02f, 8.55769776e-03f, -1.08122909e-02f, 5.19915000e-02f, 1.81328207e-02f,
  2.88369972e-03f, 2.58030910e-02f, 1.15342243e-02f, 6.77387640e-02f, -6.89715967e-02f, 1.23693962e-02f, 6.38361797e-02f, -2.27644872e-02f, -5.45096118e-03f, 9.43820700e-02f,
  -1.62315313e-02f, -2.72942148e-02f, 6.83823451e-02f, 5.28731607e-02f, 5.21469228e-02f, -2.22020559e-02f, 6.74615726e-02f, 4.13203128e-02f, -6.79825768e-02f, 4.32752408e-02f,
  -9.52161569e-03f, 7.46222585e-02f, 5.63545004e-02f, -6.15926348e-02f, 5.06330188e-03f, -6.29806146e-02f, -5.80373853e-02f, 6.73136860e-02f, -1.04599409e-02f, 1.73231773e-02f,
  -6.07200712e-02f, 6.10604845e-02f, 7.70119876e-02f, 3.08992043e-02f, -6.18127128e-03f, -3.47339883e-02f, -1.95700228e-02f, 5.13994806e-02f, -1.64584648e-02f, -3.75007764e-02f,
  6.59468770e-03f, 1.36521131e-01f, 6.46155328e-02f, -5.63772619e-02f, 6.22406951e-04f, 5.49581200e-02f, -2.45821327e-02f, -7.86514357e-02f, 5.98837584e-02f, 1.55573219e-01f,
  -1.17155209e-01f, 1.38647482e-01f, -4.15157638e-02f, 6.53844401e-02f, -1.32572114e-01f, -2.76440778e-03f, 4.70419861e-02f, 5.72380237e-02f, -3.90414633e-02f, 2.71910671e-02f,
  -6.15385100e-02f, -1.48389176e-01f, 8.65954608e-02f, 4.07924922e-03f, -2.02969145e-02f, -1.70077384e-02f, -5.94831444e-02f, 5.73340654e-02f, -1.00977145e-01f, 5.93270222e-03f,
  1.07386805e-01f, -5.15131000e-03f, 1.90656241e-02f, 3.61876823e-02f, -4.09213752e-02f, 3.68554331e-02f, 8.82898718e-02f, -8.45203623e-02f, -4.11127275e-03f, -3.52411121e-02f,
  6.08105026e-02f, -4.71451543e-02f, -8.26623663e-02f, -1.15855616e-02f, -6.57561868e-02f, -2.23774798e-02f, 1.45043228e-02f, 1.70946643e-02f, 9.60939080e-02f, -9.99492407e-02f,
  5.88735230e-02f, 7.32688829e-02f, 2.49126237e-02f, 2.72415914e-02f, 7.66935246e-03f, -2.10259445e-02f, -5.43034784e-02f, -6.13972209e-02f, -3.57397576e-03f, -3.25393640e-02f,
  -1.19031660e-01f, 5.30405808e-03f, 3.80742475e-02f, -1.09239205e-04f, 6.46781996e-02f, -4.01753746e-02f, 1.78043135e-02f, 5.50740473e-02f, 6.22076727e-02f, -9.41538885e-02f,
  -3.74299800e-03f, -2.01814603e-02f, 5.94724268e-02f, 8.38369802e-02f, -6.76592514e-02f, 4.64156307e-02f, -3.43384296e-02f, 7.02428073e-02f, -4.58786488e-02f, 4.41681920e-03f,
  4.40036207e-02f, 4.70025502e-02f, 3.69083397e-02f, 1.25390179e-02f, -2.82063093e-02f, 5.71618862e-02f, 1.72605049e-02f, 8.34105313e-02f, 3.83373983e-02f, 5.61894439e-02f,
  9.03906077e-02f, -6.39774725e-02f, -2.20842417e-02f, -7.40817636e-02f, 1.73731502e-02f, -8.11524391e-02f, 3.72179411e-02f, 2.13987883e-02f, 5.43196090e-02f, 2.12117489e-02f,
  6.71534892e-03f, -1.10263238e-02f, 6.84859008e-02f, -9.56680551e-02f, 1.58149211e-04f, -2.34503672e-02f, 9.48862880e-02f, -1.81446318e-02f, 1.50253652e-02f, 4.34243605e-02f,
  1.08414419e-01f, 5.95079213e-02f, -2.51878519e-02f, 2.28461567e-02f, 2.16917768e-02f, 8.62546042e-02f, -5.64766116e-02f, -7.08273575e-02f, 8.19528126e-04f, -6.65588081e-02f,
  5.66550605e-02f, 1.95465341e-01f, 2.24414676e-01f, 2.64701694e-01f, -1.11017935e-01f, 1.03817821e-01f, 1.22058742e-01f, 1.93297751e-02f, 1.70280918e-01f, 5.89883849e-02f,
  -2.26764575e-01f, 1.90123200e-01f, -9.99001414e-02f, 7.55225793e-02f, -2.23565735e-02f, 2.44690999e-02f, 5.12653105e-02f, 1.02895238e-02f, 9.38648507e-02f, 1.40865490e-01f,
  1.42754421e-01f, -1.40334040e-01f, -2.07302421e-02f, -1.51290998e-01f, 8.11783746e-02f, 5.72966896e-02f, -2.15282395e-01f, 4.91353311e-03f, -4.54670228e-02f, -7.03204423e-02f,
  -1.92872565e-02f, 1.47203105e-02f, -2.02998314e-02f, 1.81261599e-02f, 5.67175262e-02f, 3.39529365e-02f, 2.64356304e-02f, -6.15588725e-02f, -2.01547779e-02f, 6.18050769e-02f,
  1.17655247e-01f, -8.63184258e-02f, 2.44187359e-02f, 1.27131343e-02f, -3.15932534e-03f, 4.15665321e-02f, 6.30354090e-03f, -1.56236561e-02f, 8.28662664e-02f, 1.08757563e-01f,
  1.12443656e-01f, 1.03147209e-01f, 9.11821276e-02f, -2.65227817e-02f, -6.49885982e-02f, -3.10225822e-02f, -4.20898572e-02f, 4.86413315e-02f, 7.92719573e-02f, 7.25695714e-02f,
  -2.24239603e-02f, -4.85071540e-02f, -8.94641057e-02f, 3.67575027e-02f, -6.81514889e-02f, -8.88898820e-02f, -6.56512678e-02f, 3.62969153e-02f, -5.69201773e-04f, 2.41733011e-04f,
  -7.84192160e-02f, 4.86774892e-02f, -8.00146759e-02f, -5.25386333e-02f, -4.23744582e-02f, 9.17755812e-02f, 4.19171713e-02f, -2.55606771e-02f, 1.83083918e-02f, 4.76310998e-02f,
  -5.34232669e-02f, 3.16090472e-02f, 6.71880171e-02f, -6.48202226e-02f, 4.70840447e-02f, -2.62325555e-02f, 7.77788274e-03f, 5.38810268e-02f, -3.64290737e-02f, -3.37149985e-02f,
  3.85508239e-02f, 8.28569010e-02f, -6.88087270e-02f, -3.09831891e-02f, 4.18822616e-02f, -8.15961137e-02f, -5.74982166e-02f, -1.78906657e-02f, 1.05811313e-01f, -4.15051356e-02f,
  -6.98010698e-02f, -9.14980378e-03f, 4.95623164e-02f, -4.94961031e-02f, -9.74191204e-02f, 1.36411004e-02f, 9.75107551e-02f, 6.10436872e-02f, -3.74070555e-02f, 1.33440839e-02f,
  6.15464896e-02f, 3.57852057e-02f, -3.30666825e-02f, 2.28704456e-02f, -8.73631434e-05f, -3.63990059e-03f, 4.43580281e-03f, 7.82295093e-02f, 6.11987291e-03f, 4.23654988e-02f,
  -3.16130698e-01f, 4.17837538e-02f, 2.41224393e-01f, -3.13412160e-01f, 4.26780172e-02f, 3.31909090e-01f, 7.82090724e-02f, 1.43424394e-02f, -1.14714548e-01f, -1.23866484e-01f,
  -1.30390123e-01f, -1.53171346e-01f, 9.12658349e-02f, -1.10575013e-01f, 2.66510576e-01f, 1.35467052e-01f, -3.55943255e-02f, 2.93916948e-02f, -4.77498323e-02f, -9.27271619e-02f,
  -1.24976389e-01f, -2.01247349e-01f, 9.16317105e-02f, -1.13271981e-01f, -1.49895668e-01f, -9.41017345e-02f, -2.08601281e-01f, 8.29148665e-02f, -1.45875394e-01f, 8.33304301e-02f,
  -2.70190015e-02f, -1.90502107e-01f, -6.38903156e-02f, -7.20092445e-04f, -3.72318104e-02f, -5.11769839e-02f, -3.39659564e-02f, -3.50226685e-02f, 1.31196408e-02f, -1.50464545e-03f,
  -4.11932841e-02f, -2.91923769e-02f, -6.10704683e-02f, -6.83731958e-03f, -5.66202216e-02f, 7.29156584e-02f, 7.36748651e-02f, 9.03231278e-02f, -5.86555563e-02f, 9.38340724e-02f,
  7.12891370e-02f, 9.03651565e-02f, 6.68002367e-02f, 1.53865777e-02f, -6.17340533e-03f, 4.32502329e-02f, 1.85766276e-02f, 9.71131027e-02f, 7.38710314e-02f, -5.57847135e-02f,
  -6.62380904e-02f, -5.50126545e-02f, 5.10935485e-02f, 2.65927166e-02f, -7.02247694e-02f, -3.97490226e-02f, -7.98142180e-02f, -7.94490948e-02f, 7.45401857e-03f, 8.09700936e-02f,
  -5.66997565e-02f, -4.11287695e-02f, 8.75259563e-03f, 2.39024162e-02f, -9.55211967e-02f, -6.27919510e-02f, 2.22506411e-02f, -4.83407713e-02f, -5.20925187e-02f, -2.75766570e-02f,
  -1.18543897e-02f, 4.49033342e-02f, 3.95180508e-02f, 1.37901455e-02f, 1.05131976e-01f, 5.49828373e-02f, 5.74384518e-02f, -1.87464932e-03f, 3.28855328e-02f, 3.94844711e-02f,
  -9.71755609e-02f, -1.04045972e-01f, 5.25602438e-02f, 1.78123806e-02f, -5.15350737e-02f, 8.89524221e-02f, -2.63257585e-02f, 2.65094768e-02f, -3.39918188e-03f, -2.93561462e-02f,
  -3.67187932e-02f, 8.59433319e-03f, -8.22896138e-03f, -6.81554601e-02f, -2.54319678e-03f, -3.18802297e-02f, -7.64226764e-02f, -2.02373229e-02f, 5.10846153e-02f, 2.80004852e-02f,
  3.09544280e-02f, -3.26222228e-03f, 9.63552222e-02f, 5.63824875e-03f, -6.10098280e-02f, 6.95394678e-03f, -4.65968922e-02f, 1.36128981e-02f, -5.55590540e-02f, 3.82309258e-02f,
  4.46400791e-02f, 1.71837851e-01f, 7.10660964e-02f, 7.89072290e-02f, 1.40059695e-01f, 1.87088966e-01f, 1.79811314e-01f, 1.59526393e-01f, 2.74589598e-01f, 9.77115631e-02f,
  -2.71625686e-02f, 1.86591700e-01f, -8.22519138e-02f, 5.75458556e-02f, 7.02046975e-02f, -6.41852021e-02f, 1.81017086e-01f, 4.42310013e-02f, 1.35414422e-01f, -2.50851121e-02f,
  5.58221377e-02f, 3.51425074e-02f, -2.45488465e-01f, -1.98603747e-03f, 2.89936736e-02f, -5.17563000e-02f, -2.10195273e-01f, -1.70022592e-01f, -2.59214453e-02f, 9.88065228e-02f,
  -3.57256047e-02f, 6.32074475e-02f, -3.82381491e-02f, -8.22515860e-02f, -7.73686767e-02f, 6.89577088e-02f, 2.06047203e-02f, -6.91501424e-02f, 3.76752391e-02f, 8.71753022e-02f,
  1.12492621e-01f, 5.46126207e-03f, 7.93503374e-02f, -1.06569584e-02f, 9.72510055e-02f, 1.95969474e-02f, -4.14920487e-02f, 1.09798545e-02f, -1.47238160e-02f, -4.45373468e-02f,
  6.57723472e-02f, 3.50326896e-02f, -5.13888299e-02f, -4.34398465e-02f, 1.02184769e-02f, -2.91213728e-02f, 1.03038335e-02f, -1.25476513e-02f, -5.80906868e-02f, -2.42977440e-02f,
  -1.56813897e-02f, -3.82256620e-02f, -4.14849119e-03f, -7.58242933e-03f, 4.91662957e-02f, -8.39629862e-03f, -5.05077988e-02f, -5.51529303e-02f, -5.88797852e-02f, -4.35235277e-02f,
  -4.21485640e-02f, -1.61221363e-02f, -6.24514185e-03f, -8.30787141e-03f, -1.81119964e-02f, 7.20840394e-02f, 4.28205542e-02f, 1.95593648e-02f, 1.10938840e-01f, 4.75537591e-03f,
  -7.09173083e-03f, -3.87388580e-02f, -9.20174420e-02f, -9.84321535e-03f, 4.76990938e-02f, -2.00597513e-02f, -9.31073576e-02f, 4.99920398e-02f, -6.12410679e-02f, -7.15636536e-02f,
  1.06777370e-01f, 1.74728215e-01f, 5.95854362e-03f, 4.71073873e-02f, 2.45064124e-02f, -6.89836964e-02f, 3.63780484e-02f, 8.49244297e-02f, -2.09213477e-02f, 4.71701324e-02f,
  7.09647462e-02f, -1.33121507e-02f, -5.22474162e-02f, -3.92734446e-02f, -4.72829305e-02f, 6.06428199e-02f, -7.52741471e-02f, 6.15953915e-02f, 8.67061391e-02f, 1.69843696e-02f,
  -2.55365614e-02f, -8.01823102e-03f, -1.13869598e-03f, 3.10907681e-02f, -5.33807091e-02f, -5.81229776e-02f, 9.60669369e-02f, 3.31192277e-02f, 3.47382613e-02f, 5.67011125e-02f,
  9.48323160e-02f, -3.48482542e-02f, -1.81452900e-01f, -1.96062133e-01f, -6.92720115e-02f, -1.45727366e-01f, -1.28454685e-01f, 3.76869598e-03f, 7.64211044e-02f, 1.03986897e-01f,
  -1.01887077e-01f, 4.86173555e-02f, 7.24467561e-02f, -1.36764884e-01f, -9.60042924e-02f, 7.11296722e-02f, -1.14758700e-01f, -1.33756593e-01f, -4.57158647e-02f, -1.52274594e-02f,
  -1.24131195e-01f, 1.79990791e-02f, -1.49889097e-01f, 3.44595313e-02f, -1.85338765e-01f, -6.75820112e-02f, 8.37524887e-03f, 3.21299508e-02f, -1.24842199e-02f, -7.21407011e-02f,
  -5.79893328e-02f, 1.52064022e-02f, -7.76716918e-02f, 3.75947766e-02f, -8.74396861e-02f, -4.61093197e-03f, -7.70517439e-02f, 1.95954051e-02f, 4.83169109e-02f, -2.87572145e-02f,
  -4.46625752e-03f, 7.64506385e-02f, -2.00803597e-02f, -5.07673211e-02f, -6.69368654e-02f, -5.01667485e-02f, 2.50120070e-02f, -6.05567135e-02f, -4.42317501e-02f, 3.49128433e-02f,
  -2.08371561e-02f, 3.31273042e-02f, 1.15100965e-02f, -2.03476986e-03f, -2.02710312e-02f, -3.85911837e-02f, 3.83668318e-02f, -8.89845714e-02f, 6.52750358e-02f, 2.24350337e-02f,
  -4.04549725e-02f, 3.47785950e-02f, 4.81249802e-02f, -4.94568609e-02f, -2.73028649e-02f, -8.22244436e-02f, -5.29569760e-03f, -9.30137746e-03f, 4.58325818e-03f, 8.89269710e-02f,
  -1.15896873e-02f, 3.13818119e-02f, -6.45238906e-03f, -4.82916534e-02f, -5.98630458e-02f, 6.96656406e-02f, 1.42946960e-02f, -4.10038419e-02f, 1.05167711e-02f, 4.30387780e-02f,
  -1.95836392e-03f, 1.07702734e-02f, 1.97486524e-02f, -3.94136719e-02f, -6.62623793e-02f, -7.18409345e-02f, -4.69524488e-02f, 4.56921756e-02f, 6.52166009e-02f, -8.57318863e-02f,
  -1.25072924e-02f, 5.65732829e-02f, -5.07974364e-02f, 5.67777976e-02f, -7.51245022e-02f, 3.57120186e-02f, -7.52416998e-02f, -1.07697388e-02f, -3.11164348e-03f, 6.43481780e-03f,
  -4.76351082e-02f, -3.47439349e-02f, 2.54399929e-04f, 1.60037763e-02f, -1.72493123e-02f, 6.40582889e-02f, 2.89625991e-02f, 3.21470276e-02f, -9.06564742e-02f, -5.38300462e-02f,
  -6.61852956e-02f, 4.36651334e-02f, 6.06642365e-02f, 2.13243905e-02f, -6.08947687e-02f, -4.26881053e-02f, 5.96491620e-02f, 4.90245782e-02f, 4.77627059e-03f, 6.26069605e-02f,
  -4.35434803e-02f, -5.34202754e-02f, 1.37870401e-01f, 1.33133918e-01f, -1.25390723e-01f, -5.36510497e-02f, 8.49290341e-02f, -8.75558183e-02f, -8.08752924e-02f, -8.24249312e-02f,
  -2.59693321e-02f, -1.66331902e-02f, 4.05764207e-02f, -1.34419678e-02f, 2.60228932e-01f, 6.59614205e-02f, 4.06445637e-02f, 7.45805204e-02f, -4.31096889e-02f, -3.08996644e-02f,
  4.74497117e-02f, -7.31074512e-02f, 9.81441066e-02f, -2.83823442e-02f, 3.64168920e-02f, 7.94832408e-02f, 8.83323476e-02f, 8.81470442e-02f, 4.70841713e-02f, 1.00943983e-01f,
  -1.20815150e-01f, 1.29866845e-03f, -8.39379430e-02f, -6.90777451e-02f, -6.68992028e-02f, 1.59334438e-03f, 4.71442044e-02f, 9.74449739e-02f, 1.22166751e-02f, 6.58479845e-03f,
  -2.49991808e-02f, 1.05862599e-02f, -4.19470556e-02f, -4.21824306e-02f, 6.72281981e-02f, 7.08984807e-02f, -2.21582875e-02f, -3.12985554e-02f, -3.86060961e-02f, -9.54502970e-02f,
  -7.08900169e-02f, -7.19178170e-02f, 1.71101931e-03f, -2.17306875e-02f, 9.53973159e-02f, -9.85462442e-02f, -1.76116789e-03f, 5.83654977e-02f, -2.40393840e-02f, -5.07146120e-02f,
  6.36704192e-02f, 7.58032128e-02f, -2.85505448e-02f, -8.58611241e-02f, 4.41845432e-02f, 9.98478383e-03f, 5.59428819e-02f, 1.20749595e-02f, 5.29671535e-02f, -7.43015260e-02f,
  -5.76214641e-02f, 4.44763489e-02f, 6.17087856e-02f, 4.86559905e-02f, 4.35502082e-02f, -3.78134213e-02f, -1.64269730e-02f, 5.95018938e-02f, 8.45951214e-03f, 6.48347214e-02f,
  5.77483475e-02f, -7.78658316e-02f, 3.99800651e-02f, -4.31332067e-02f, -2.48044338e-02f, 6.46864846e-02f, -2.92684380e-02f, -2.89159734e-02f, -7.93326795e-02f, -8.46718252e-03f,
  -1.21796250e-01f, 7.19221011e-02f, 5.62244356e-02f, -9.27794948e-02f, -5.38765453e-02f, -1.96022410e-02f, 3.04185990e-02f, -7.64093027e-02f, 9.81684104e-02f, -7.89986923e-02f,
  -6.08862378e-02f, -7.58065209e-02f, -7.81018510e-02f, -3.09315193e-02f, -3.69931720e-02f, -3.59177813e-02f, -4.33155894e-02f, -8.31123739e-02f, -7.92829767e-02f, 5.46412542e-02f,
  5.61264064e-03f, -9.24307853e-03f, -2.12685149e-02f, -9.54304487e-02f, 7.04808086e-02f, -4.00204472e-02f, 2.44150683e-02f, -2.39063539e-02f, -8.29715002e-03f, 1.34442002e-03f,
  1.19122406e-02f, 1.99776422e-02f, -9.46118124e-03f, -9.45268199e-02f, -1.27224684e-01f, 6.03875658e-03f, 7.01424181e-02f, 2.36824099e-02f, 1.28012514e-02f, -6.20508082e-02f,
  -4.88008708e-02f, 8.67565796e-02f, 2.93885339e-02f, -1.26613632e-01f, 1.85281977e-01f, 1.32454082e-01f, -1.21794576e-02f, 6.79464918e-03f, -1.11329444e-02f, 5.45505658e-02f,
  -3.22305709e-02f, 3.26606371e-02f, -1.55124754e-01f, -1.19945616e-01f, -1.76130235e-01f, 2.07167268e-02f, -8.63694623e-02f, -1.15153477e-01f, -1.21114977e-01f, -6.89465255e-02f,
  -6.41717166e-02f, -7.85915554e-02f, -4.87921014e-02f, -1.26505888e-03f, 3.39019522e-02f, -4.15150523e-02f, -4.21787240e-02f, -8.56893957e-02f, -4.50500892e-03f, 1.64831243e-02f,
  4.22020331e-02f, -6.07811436e-02f, -2.99424324e-02f, 7.93179423e-02f, -3.38189933e-03f, -3.53538687e-03f, -1.05844662e-01f, 6.58871606e-02f, 6.37678280e-02f, -4.80788201e-02f,
  -2.69812904e-02f, 1.23031521e-02f, -1.70666948e-02f, 7.79046938e-02f, -2.90702395e-02f, 5.30545749e-02f, -6.07725121e-02f, -8.32650512e-02f, -3.25246155e-02f, 4.61089984e-02f,
  4.33704369e-02f, -7.81010687e-02f, 9.49742552e-03f, -7.32900500e-02f, -1.63243301e-02f, 6.57930672e-02f, 6.98613450e-02f, 8.16208944e-02f, -5.12009598e-02f, 4.70972881e-02f,
  2.89417431e-02f, -3.05267219e-02f, 5.56247346e-02f, 8.29892457e-02f, 8.42200294e-02f, 7.28641152e-02f, 5.76107353e-02f, -1.67142565e-03f, 4.91115004e-02f, 4.10067290e-02f,
  5.49747143e-03f, -4.19679098e-02f, -3.76420841e-02f, 2.11975165e-03f, 1.27330869e-02f, -1.01278633e-01f, -8.15275833e-02f, 7.13030761e-03f, 2.14802437e-02f, 7.49081224e-02f,
  1.07009389e-01f, 1.06164806e-01f, 5.68585619e-02f, -8.35401416e-02f, 6.46458417e-02f, 4.85949144e-02f, -1.63217336e-02f, -3.12295347e-03f, 1.13771714e-01f, 7.40040019e-02f,
  -5.32343099e-03f, 8.13688412e-02f, -1.33927753e-02f, 5.81060350e-02f, 4.91588786e-02f, 9.21879411e-02f, 9.47366059e-02f, -1.03070000e-02f, 1.97289400e-02f, -9.92362276e-02f,
  3.63818109e-02f, 9.38154478e-03f, 4.36786115e-02f, 4.69393246e-02f, 1.09870695e-01f, 6.54304400e-03f, 8.89919102e-02f, 6.79654703e-02f, -1.08903870e-02f, -1.47236008e-02f,
  2.11066961e-01f, -2.76011616e-01f, 5.77506237e-03f, -3.76936644e-02f, 2.22561266e-02f, 5.72293140e-02f, 4.76460494e-02f, -1.65584251e-01f, -1.24277845e-01f, -3.00782084e-01f,
  -9.08018202e-02f, -1.04489010e-02f, 1.91127381e-03f, -6.82661310e-02f, 1.62951395e-01f, 6.77269772e-02f, -9.32914168e-02f, 3.47829796e-02f, 3.50841917e-02f, -3.98815796e-02f,
  1.00552104e-01f, -2.05347911e-02f, 1.13680623e-02f, -2.61303663e-01f, -8.91440660e-02f, -1.82040289e-01f, -7.65567645e-02f, 7.16198385e-02f, -1.67809665e-01f, 6.99739084e-02f,
  -6.02559894e-02f, -6.00231588e-02f, -6.97886292e-03f, -2.14450508e-02f, -6.86099902e-02f, 3.53371426e-02f, 6.63927495e-02f, 7.76955411e-02f, -1.07583087e-02f, 3.86794433e-02f,
  -1.06117511e-02f, -1.39942793e-02f, 4.21224721e-02f, -2.56576878e-03f, 5.89652639e-03f, -8.16577766e-03f, -1.04643945e-02f, -4.26658913e-02f, 2.19414644e-02f, -5.04633486e-02f,
  6.82684928e-02f, -1.28063262e-02f, -1.09110055e-02f, -1.01637289e-01f, -7.30890408e-02f, -2.73399483e-02f, 4.48054336e-02f, -6.15976118e-02f, 3.97041962e-02f, -7.73946494e-02f,
  -1.96855776e-02f, 7.50848725e-02f, -1.35427080e-02f, 7.38001019e-02f, 7.07797930e-02f, 8.36225040e-03f, -6.76780790e-02f, -7.96953291e-02f, -4.21956815e-02f, -2.56525334e-02f,
  4.21127230e-02f, -4.80803335e-03f, 9.75980684e-02f, 4.93754521e-02f, -1.32654030e-02f, -3.95632125e-02f, 7.36367255e-02f, 7.00845616e-03f, -4.91685718e-02f, -3.63628380e-02f,
  6.35558516e-02f, -3.16880941e-02f, -8.09241533e-02f, 1.32033285e-02f, -6.68553934e-02f, 2.53322534e-02f, -5.29009812e-02f, 8.01808462e-02f, -4.38936688e-02f, 7.15356991e-02f,
  -4.50015403e-02f, -3.26642245e-02f, 2.79665552e-02f, 8.27856287e-02f, -8.16764310e-02f, -6.28023082e-03f, -2.74192821e-02f, -9.53261703e-02f, -2.08179466e-02f, 3.35730352e-02f,
  1.90327037e-02f, -4.08662446e-02f, 1.45484526e-02f, 5.19930236e-02f, 3.50536481e-02f, -7.09244236e-02f, 5.43461405e-02f, -8.25422406e-02f, -7.56016076e-02f, -3.71483713e-02f,
  -2.13210378e-02f, -2.90405899e-02f, 7.35259503e-02f, 2.50064470e-02f, 2.23003756e-02f, 4.33109775e-02f, 1.62314493e-02f, -3.45769152e-02f, 1.59837436e-02f, -6.28026947e-02f,
  1.03131920e-01f, -9.72253457e-03f, -1.20852984e-01f, -8.96365196e-02f, -1.47478199e-02f, 1.48953244e-01f, 3.28017883e-02f, 1.49742523e-02f, 7.89147317e-02f, 9.89302099e-02f,
  6.61332253e-03f, -6.94412738e-02f, -1.45127196e-02f, -9.33402032e-02f, 2.53741089e-02f, -7.52057880e-02f, -6.29641190e-02f, -2.44108178e-02f, 9.45196226e-02f, 1.92350131e-02f,
  5.10858484e-02f, -3.98890711e-02f, -6.07783049e-02f, 9.99882445e-02f, 3.23185027e-02f, -2.88200378e-02f, 6.75444752e-02f, 7.16165379e-02f, 2.20555626e-02f, 6.40680343e-02f,
  7.42887333e-02f, 8.28402191e-02f, 1.10651478e-01f, 7.78462067e-02f, 1.45871043e-01f, 3.32785808e-02f, -2.09955908e-02f, -2.80869752e-02f, -5.15934676e-02f, 2.74130292e-02f,
  4.37322371e-02f, 2.52292100e-02f, -3.97791304e-02f, -2.82832962e-02f, 6.71504512e-02f, -9.02108178e-02f, 4.70155999e-02f, -8.32658708e-02f, 4.83536609e-02f, 2.83570364e-02f,
  -8.13782066e-02f, -7.21815526e-02f, -9.87663865e-02f, -1.07787866e-02f, -1.08350478e-01f, 8.19492862e-02f, 1.34236999e-02f, -2.87463499e-05f, -9.41372737e-02f, 6.54069781e-02f,
  -7.08666593e-02f, -6.48080558e-02f, 3.79169360e-02f, 3.22104357e-02f, 7.96202756e-03f, -7.70535097e-02f, -7.83854872e-02f, -6.50237948e-02f, 7.52001777e-02f, 5.06111979e-02f,
  -3.95703837e-02f, -6.98240101e-02f, 2.38202815e-03f, -2.44960170e-02f, 6.90018460e-02f, -9.09869373e-02f, -7.80987293e-02f, -4.10670042e-02f, -7.07490295e-02f, -7.37199336e-02f,
  -2.29705088e-02f, 4.28378321e-02f, -3.04001663e-02f, 3.29603292e-02f, 3.98754366e-02f, -8.67466256e-02f, -6.92086592e-02f, 2.21257471e-02f, 2.49247812e-02f, 9.07720253e-02f,
  9.59838703e-02f, -4.18664664e-02f, 1.17133461e-01f, 2.34660935e-02f, -3.61605138e-02f, 1.09991811e-01f, 2.20845044e-02f, -8.58414918e-02f, -4.38383482e-02f, 6.00466644e-03f,
  3.48616503e-02f, 9.59751830e-02f, -7.69709870e-02f, 3.07524623e-03f, -6.70622066e-02f, 7.41110295e-02f, 4.33027521e-02f, -1.80175193e-02f, 1.31814135e-02f, -9.98145342e-02f,
  -5.16427830e-02f, 2.42538247e-02f, -7.20445514e-02f, 6.45081475e-02f, -9.80957970e-02f, -6.85600191e-02f, 4.00254317e-02f, -5.31725287e-02f, 2.66751088e-03f, -6.84166625e-02f,
  -1.52060818e-02f, 3.79230380e-02f, 3.90330926e-02f, -4.19605436e-04f, -5.04261404e-02f, -1.02524772e-01f, -1.68714002e-02f, 2.97911018e-02f, 5.89537397e-02f, 3.40701975e-02f,
  7.33570289e-03f, -3.63313295e-02f, -7.93933943e-02f, -2.84520295e-02f, 4.65808958e-02f, -9.63143706e-02f, 3.27090062e-02f, -5.48408739e-02f, -8.51453617e-02f, -5.41210826e-03f,
  7.82346353e-02f, 6.06553704e-02f, -2.07866151e-02f, 5.88360280e-02f, 1.89253241e-02f, 4.13775519e-02f, 1.35101169e-01f, 6.00768030e-02f, 8.17923062e-03f, 3.82690690e-02f,
  -1.54075816e-01f, 1.91407371e-02f, -5.71338600e-03f, 4.54400554e-02f, 4.58994247e-02f, -6.71979189e-02f, 1.72001906e-02f, 8.71471465e-02f, 7.50697479e-02f, -5.01339100e-02f,
  1.02930620e-01f, -4.54111956e-02f, -3.35757136e-02f, -7.09372684e-02f, 9.20815393e-02f, 3.93492095e-02f, 2.88252085e-02f, 2.26171035e-02f, 7.28791431e-02f, -6.16307035e-02f,
  -6.16338365e-02f, 7.51159266e-02f, -6.29676357e-02f, 1.17918625e-01f, -3.40718217e-02f, -3.94786112e-02f, 1.01475619e-01f, 3.77255231e-02f, 8.53589773e-02f, 1.07229352e-01f,
  2.38634050e-02f, 3.10907383e-02f, -2.26588603e-02f, 1.53548270e-02f, -1.66683253e-02f, -5.43592013e-02f, -2.70088036e-02f, 2.88430937e-02f, -2.59862747e-02f, -1.56858994e-03f,
  7.21996874e-02f, -4.80346084e-02f, 5.35887405e-02f, -1.34649174e-03f, -6.92367256e-02f, -7.23477378e-02f, 1.79189479e-03f, 3.30491401e-02f, 2.05621682e-02f, -9.90747958e-02f,
  -5.34863696e-02f, 3.74194756e-02f, -1.33264270e-02f, -3.02681457e-02f, -8.95589292e-02f, -2.36570705e-02f, 7.78167620e-02f, 7.41776899e-02f, 1.55300461e-02f, 5.78837981e-03f,
  9.96273756e-02f, 1.85581729e-01f, 5.59953824e-02f, -7.34521030e-03f, 7.12174773e-02f, 1.66961290e-02f, 7.86593780e-02f, -5.27824536e-02f, 2.54650991e-02f, 6.02828972e-02f,
  6.26699254e-02f, -2.03418918e-02f, -3.93296964e-02f, 4.02431153e-02f, 1.58371404e-02f, -4.17140387e-02f, -2.49150712e-02f, -4.28075567e-02f, 1.47509556e-02f, -5.83218858e-02f,
  5.59088513e-02f, -4.72763106e-02f, 6.42851591e-02f, 9.60105807e-02f, -8.36830437e-02f, -6.21024035e-02f, -3.07144802e-02f, 1.08611390e-01f, -2.62256749e-02f, 4.02825288e-02f,
  -6.01527132e-02f, -9.52545330e-02f, 1.48050293e-01f, 5.31107113e-02f, 8.78605247e-02f, 7.16740638e-02f, -3.35455919e-03f, -1.23706043e-01f, -1.26536295e-01f, -1.90207392e-01f,
  8.43591094e-02f, 9.93579552e-02f, 8.50756885e-04f, -5.94833270e-02f, 9.17635188e-02f, 4.40246519e-03f, -6.01278581e-02f, -6.50515780e-02f, -2.09204368e-02f, 2.68124435e-02f,
  -4.93937405e-03f, -1.82824116e-02f, 1.41134903e-01f, -7.22587854e-02f, 3.01924869e-02f, -8.36762786e-02f, -8.75360668e-02f, 1.39699191e-01f, 1.17020914e-02f, 4.17336151e-02f,
  7.08846794e-03f, -6.25888556e-02f, 5.11072017e-02f, 7.61799165e-04f, -8.80600959e-02f, 1.24802813e-02f, 3.45692784e-02f, 6.09652176e-02f, -4.48204502e-02f, 4.53008451e-02f,
  8.86508599e-02f, 7.50740469e-02f, -3.36024202e-02f, 9.31515694e-02f, 6.42155558e-02f, -4.15496416e-02f, -2.13969965e-02f, -2.69644596e-02f, -5.99663332e-02f, -5.36087267e-02f,
  9.33435410e-02f, 6.68598637e-02f, -8.63623619e-02f, -1.28333876e-02f, 5.42480163e-02f, -2.68022381e-02f, -2.79424470e-02f, -5.44518307e-02f, -1.01256035e-01f, 6.95484132e-02f,
  9.11178440e-02f, 5.33285225e-03f, 2.84188557e-02f, 5.73380738e-02f, -7.47307390e-02f, -5.87393194e-02f, -4.88793030e-02f, 8.50695819e-02f, -8.09393674e-02f, 6.07043616e-02f,
  3.84251028e-02f, 7.50646964e-02f, -6.37123361e-02f, -1.38924681e-02f, -9.31762904e-02f, 4.76939492e-02f, 7.80994967e-02f, -6.17936030e-02f, 6.82416409e-02f, 7.80375078e-02f,
  8.29551443e-02f, -8.24666023e-02f, 7.91414231e-02f, 3.99103239e-02f, 5.26844375e-02f, -3.31604406e-02f, 5.76677993e-02f, 8.82742647e-03f, 4.35394906e-02f, 4.54313792e-02f,
  -1.23698652e-01f, -2.36317422e-02f, -2.40516686e-03f, -9.68417004e-02f, 5.06960936e-02f, 8.52007698e-03f, 3.01011559e-02f, 4.60055284e-02f, -7.30768815e-02f, -5.31838611e-02f,
  -9.33916718e-02f, 5.93558103e-02f, 2.16511562e-02f, 4.80161160e-02f, 2.23213714e-02f, 2.45211385e-02f, 4.99366922e-03f, -2.03176890e-03f, 2.79706400e-02f, 3.56532470e-03f,
  6.90719998e-03f, -4.96948464e-03f, -7.08311191e-03f, -8.70762914e-02f, 4.15229425e-02f, 2.51362342e-02f, -2.86895111e-02f, -6.26419624e-03f, 2.83543430e-02f, -8.84693000e-04f,
  -1.40920043e-01f, 2.26891544e-02f, -1.38411801e-02f, -9.57666859e-02f, 2.68182606e-02f, 9.83272716e-02f, 8.78782719e-02f, -1.96899306e-02f, 2.66430657e-02f, -1.49304913e-02f,
  -1.28269219e-03f, -8.49010830e-04f, 1.60991866e-02f, 1.76266283e-02f, -7.30439648e-02f, 9.49885026e-02f, -1.01360515e-01f, 1.10453330e-02f, 4.50668745e-02f, -7.46286437e-02f,
  -1.10490911e-01f, -5.98508418e-02f, 8.54363739e-02f, 8.52662250e-02f, 7.35700876e-02f, -6.75366968e-02f, -6.53994158e-02f, 5.53727262e-02f, -4.51238453e-02f, 7.11802691e-02f,
  9.41049382e-02f, -7.76689053e-02f, 1.54893780e-02f, 1.04977405e-02f, 1.02747075e-01f, 6.80509731e-02f, 7.56938756e-03f, 4.58033942e-02f, 7.79490694e-02f, -5.47525985e-03f,
  3.40515673e-02f, 4.00999375e-02f, -2.36456338e-02f, -5.29245986e-03f, -5.95083758e-02f, -1.51041802e-02f, 8.70169103e-02f, 6.94545954e-02f, 4.16262075e-02f, -6.86424449e-02f,
  -6.89492300e-02f, 3.43447477e-02f, -1.48576349e-02f, -9.76541191e-02f, 2.80438922e-02f, -4.01907191e-02f, 5.25153184e-04f, 3.60949151e-02f, -8.00621510e-02f, -9.40481052e-02f,
  -8.55035186e-02f, -4.85766232e-02f, -6.14879578e-02f, 5.78736737e-02f, 4.49356437e-02f, -7.94685259e-02f, 1.27832289e-03f, 3.65479216e-02f, -2.51099337e-02f, -8.00393969e-02f,
  8.93613994e-02f, 1.19576964e-03f, -9.12837014e-02f, -9.51767415e-02f, 1.47284772e-02f, -3.60078476e-02f, -2.68550497e-02f, 5.68995923e-02f, 5.11452854e-02f, -8.14197734e-02f,
  -5.55594899e-02f, -3.86866406e-02f, 1.92980561e-02f, -4.07928489e-02f, 4.26490530e-02f, 1.08378660e-02f, -3.62370536e-02f, -7.77212977e-02f, -5.86987287e-02f, -9.30200443e-02f,
  4.97218743e-02f, -7.94046670e-02f, 1.02481827e-01f, -1.54523300e-02f, 1.00466542e-01f, 6.28274754e-02f, -3.43379602e-02f, 6.92055598e-02f, 7.40522072e-02f, -3.62612195e-02f,
  7.73312803e-03f, -8.38443488e-02f, 4.60127182e-02f, -9.76236984e-02f, -7.90392905e-02f, 6.98400382e-03f, 5.71008725e-03f, -7.00699240e-02f, 1.64455101e-02f, -2.00955588e-02f,
  -2.61823311e-02f, -1.37365446e-03f, -2.07718723e-02f, -1.19926423e-01f, 2.63100509e-02f, -5.07866740e-02f, -9.09354538e-02f, 3.55913229e-02f, -2.77751070e-02f, -3.98285873e-02f,
  -3.57590541e-02f, 1.87708780e-01f, 6.36224151e-02f, 7.00818151e-02f, 5.78162111e-02f, 7.32053444e-02f, 1.84317827e-01f, 1.20564230e-01f, 2.79551148e-01f, 5.24421642e-03f,
  -1.54804096e-01f, 1.75824240e-01f, 4.69563194e-02f, 3.69825475e-02f, -5.01964707e-03f, 9.91503596e-02f, 1.86685428e-01f, 1.31317109e-01f, 1.23196438e-01f, 8.56512878e-03f,
  -1.67192928e-02f, 3.38867418e-02f, -1.63434952e-01f, -5.02807759e-02f, -9.75207686e-02f, -5.95493093e-02f, -1.60093382e-01f, -7.66818970e-02f, -7.90411010e-02f, 2.87371166e-02f,
  -1.12643084e-02f, 3.17117497e-02f, -8.75825882e-02f, -4.50720638e-02f, 1.11159552e-02f, -1.00248501e-01f, -6.53751940e-02f, 5.53667322e-02f, -2.36125384e-03f, 3.57601121e-02f,
  1.05072692e-01f, -8.11414197e-02f, 4.97525856e-02f, 2.78714541e-02f, -5.39877266e-02f, -2.20298599e-02f, 4.48897108e-02f, -8.21769685e-02f, -3.03959828e-02f, -7.95902610e-02f,
  -8.22089836e-02f, -2.89069228e-02f, 1.37982483e-04f, 8.08910877e-02f, 2.32969830e-03f, -1.56341996e-02f, -3.38426256e-03f, 6.50391504e-02f, 7.96528161e-03f, 5.94363585e-02f,
  -6.72945753e-03f, 1.76967832e-03f, -2.55467225e-04f, 2.45672129e-02f, 3.93570326e-02f, -6.35153428e-02f, -4.53925952e-02f, -5.28140254e-02f, 1.52195822e-02f, 3.33968215e-02f,
  1.78697370e-02f, -8.49547759e-02f, 5.07330224e-02f, -8.77755359e-02f, -6.37901723e-02f, 7.61793647e-03f, -2.19422411e-02f, -3.39963734e-02f, -4.51760329e-02f, -1.13746695e-01f,
  8.03462192e-02f, -1.64518497e-04f, -5.04534729e-02f, 2.47144382e-02f, 2.22848952e-02f, 6.28074408e-02f, 2.72204587e-03f, 1.44423160e-03f, -8.74125063e-02f, 9.49911028e-02f,
  1.39179602e-01f, 2.87487417e-01f, 8.07377398e-02f, -8.89056325e-02f, 6.38244897e-02f, 2.01388597e-02f, 8.60896707e-02f, -4.43249308e-02f, 4.42612777e-03f, 6.51622713e-02f,
  9.26316157e-02f, 3.20221297e-02f, 5.36563050e-04f, -1.95311084e-02f, 7.31582101e-03f, -3.57515998e-02f, -1.23565430e-02f, -2.30801944e-02f, -3.27983429e-03f, 3.37794088e-02f,
  1.25344666e-02f, -5.52295893e-02f, -7.78775662e-03f, 1.96810421e-02f, -4.83253822e-02f, -7.26606846e-02f, -1.03074387e-02f, -4.12016921e-02f, 4.38470989e-02f, -2.57613696e-02f,
  1.97477937e-01f, 8.41864347e-02f, -2.58859128e-01f, -1.58733167e-02f, 7.48380274e-02f, 6.39111921e-02f, 8.93367678e-02f, 3.38330455e-02f, -1.29609287e-01f, 1.80783600e-01f,
  2.41589814e-01f, 2.75229961e-02f, 2.37101633e-02f, 2.09563017e-01f, 2.72807921e-03f, 8.84401128e-02f, 1.47324041e-01f, 1.68910146e-01f, -4.54885773e-02f, 8.66164863e-02f,
  7.99434185e-02f, 1.33400917e-01f, -2.42830385e-02f, 7.54525065e-02f, 1.71280205e-01f, -1.65874258e-01f, 6.71253959e-03f, -1.80927679e-01f, 1.06673345e-01f, 6.90591708e-02f,
  1.01166829e-01f, 3.86600681e-02f, -1.58677541e-03f, -1.67251043e-02f, 3.52438726e-03f, 3.39429043e-02f, -7.49223772e-03f, -5.94302863e-02f, -1.08321905e-01f, 2.52559073e-02f,
  -2.05171833e-04f, -5.73814735e-02f, 4.93035279e-02f, -8.33479166e-02f, 1.39618842e-02f, 6.85521867e-03f, 5.79185039e-03f, -9.37996581e-02f, -3.62743065e-02f, 1.23785259e-02f,
  -2.41626631e-02f, -4.86063212e-02f, 5.64787053e-02f, -2.87925750e-02f, -5.88763542e-02f, 3.36962305e-02f, -7.89839923e-02f, -6.29899725e-02f, -5.15739024e-02f, 1.01480708e-02f,
  8.83614123e-02f, -6.90772608e-02f, 1.16736330e-01f, -5.20249605e-02f, 8.13479647e-02f, 2.79392917e-02f, -1.19488416e-02f, 2.44385544e-02f, -7.55798966e-02f, -2.19406784e-02f,
  -6.72222674e-02f, -4.36661281e-02f, 8.56643543e-02f, -7.81335682e-03f, -2.61645876e-02f, 5.44766560e-02f, 6.97490852e-03f, 4.99493442e-02f, -9.54677537e-02f, 4.34387326e-02f,
  1.06692147e-02f, -3.68434303e-02f, 3.23335677e-02f, -5.98097891e-02f, 1.21441716e-02f, -4.28917706e-02f, 1.08302563e-01f, -3.94141227e-02f, -6.39606491e-02f, 7.76256109e-03f,
  8.28743279e-02f, 3.84469405e-02f, -7.47669712e-02f, 8.61017220e-03f, -3.63372341e-02f, 1.01152867e-01f, 3.41040753e-02f, 3.77997495e-02f, -2.11962848e-03f, 6.44236803e-02f,
  -3.33371870e-02f, -7.09831044e-02f, -7.03919977e-02f, 1.84135828e-02f, -9.68241040e-03f, 3.11817080e-02f, 6.06356747e-02f, -4.05037366e-02f, 5.00554778e-02f, 1.50059564e-02f,
  -7.97967911e-02f, 3.59335765e-02f, 3.56057137e-02f, -2.24161474e-03f, -3.54948416e-02f, 5.91324605e-02f, -6.30235523e-02f, -7.94390216e-02f, 5.87044954e-02f, -4.97981720e-02f,
  2.08106399e-01f, -2.44660713e-02f, 1.88791100e-02f, 3.34210366e-01f, 1.89276174e-01f, 7.62964934e-02f, 2.41048634e-01f, 1.84038877e-01f, 4.65046287e-01f, -9.37893167e-02f,
  2.35549863e-02f, 6.43143954e-04f, -1.03631087e-01f, -1.63034594e-03f, 1.36941910e-01f, 1.27928555e-01f, 2.29836315e-01f, 1.17855780e-01f, 1.80646420e-01f, 1.25379264e-02f,
  1.67116806e-01f, -4.13087383e-02f, -6.11699522e-02f, -1.11557573e-01f, 7.11131543e-02f, -2.81804800e-02f, -2.09572881e-01f, 1.85959544e-02f, -1.89993486e-01f, 4.39435430e-02f,
  5.21015525e-02f, 1.09169990e-01f, -3.50111127e-02f, -7.04203844e-02f, 2.85524763e-02f, -1.95529964e-02f, 2.25399830e-03f, -9.98115912e-02f, -1.84113365e-02f, 2.19432600e-02f,
  -4.80147339e-02f, -1.42666735e-02f, -5.41334823e-02f, 1.61425918e-02f, 8.68488997e-02f, -5.10386415e-02f, 1.27088570e-03f, -9.75323841e-03f, -1.77242570e-02f, 1.47364894e-02f,
  -2.21833829e-02f, -5.02423793e-02f, 4.81936410e-02f, -5.79137541e-02f, 1.31873181e-02f, 1.22325264e-01f, 5.98491579e-02f, -1.16861850e-01f, -1.36818574e-03f, 8.83398727e-02f,
  -3.75298336e-02f, 9.25365984e-02f, 4.68918793e-02f, 1.00027835e-02f, 2.65205000e-02f, 7.13415071e-02f, -5.69362454e-02f, -9.83585604e-03f, 3.54570672e-02f, -2.12980472e-02f,
  4.30896431e-02f, 5.76254949e-02f, 9.64467376e-02f, 8.46176594e-02f, 6.86380416e-02f, 1.48069663e-02f, -6.00143075e-02f, -4.74657603e-02f, 4.81394678e-02f, 5.80840372e-02f,
  -5.63759319e-02f, 2.26219203e-02f, -3.23076583e-02f, 2.33231094e-02f, -6.47727959e-03f, 3.13144624e-02f, 5.01762629e-02f, -1.94629487e-02f, 1.72253791e-02f, -5.40145673e-02f,
  3.46377008e-02f, 2.26121604e-01f, -5.78098968e-02f, -4.97116409e-02f, -8.28629956e-02f, -3.19376495e-03f, 6.96847141e-02f, 5.69317900e-02f, 1.44682825e-01f, 7.26572424e-02f,
  1.01825679e-02f, -1.17317988e-02f, 1.96602177e-02f, -4.95724864e-02f, 3.41102295e-02f, 2.38432665e-03f, 4.76615271e-03f, -1.53651340e-02f, 9.35977772e-02f, -7.22147673e-02f,
  -7.93244168e-02f, -1.66298877e-02f, -7.58586004e-02f, 3.94807644e-02f, -7.46660382e-02f, -4.97496650e-02f, -1.23572238e-02f, 1.89366564e-02f, -6.00116812e-02f, 5.13060465e-02f,
  -6.98848888e-02f, 5.21944724e-02f, -1.90728709e-01f, -8.92636552e-02f, -7.06114098e-02f, -1.29661933e-01f, -1.47993624e-01f, 1.67978648e-02f, 8.87887999e-02f, 2.05043145e-02f,
  -2.01421902e-02f, -6.76293746e-02f, 7.26973936e-02f, -4.37852629e-02f, -1.29761145e-01f, 2.84145866e-02f, -7.95983896e-02f, -4.37155664e-02f, 4.22899872e-02f, -1.23988809e-02f,
  -1.26655027e-01f, -1.01868927e-01f, -1.51394427e-01f, 6.28693700e-02f, -1.52515158e-01f, 4.38408181e-02f, -7.18682557e-02f, 6.72997385e-02f, -4.40898724e-03f, 1.55286409e-03f,
  7.63320457e-03f, -4.62124646e-02f, -1.30287111e-01f, -6.18852209e-03f, -7.95829520e-02f, -1.04174666e-01f, -2.28650812e-02f, 5.49141690e-02f, -1.44736962e-02f, 2.21284684e-02f,
  -2.03252751e-02f, 3.01623624e-02f, 2.99588703e-02f, 1.01636767e-01f, 6.18394464e-02f, -4.89991307e-02f, -8.48370269e-02f, 8.38064775e-03f, -1.27928406e-02f, -7.64088519e-03f,
  -6.75902814e-02f, -2.39710007e-02f, -9.95995030e-02f, -1.14447720e-01f, 4.94638234e-02f, -2.56641507e-02f, 5.40784269e-04f, -4.27393354e-02f, -3.84904183e-02f, -1.93613488e-02f,
  1.04344755e-01f, -1.14605511e-02f, -5.93588222e-03f, 5.53891324e-02f, -3.34561132e-02f, -8.60013440e-02f, 6.36689514e-02f, -7.95486420e-02f, -1.38899339e-02f, 2.21517100e-03f,
  -1.06578162e-02f, 1.63403172e-02f, -2.05484033e-03f, 5.75297549e-02f, -7.45755211e-02f, 8.07054415e-02f, 4.30101380e-02f, 5.26004992e-02f, -2.89978385e-02f, 1.60304364e-03f,
  7.70693198e-02f, 5.32115474e-02f, 5.37310168e-03f, 2.29940545e-02f, -4.48317453e-02f, 6.67594522e-02f, 2.89932732e-02f, -5.20499423e-02f, -2.76174992e-02f, -6.22540079e-02f,
  1.92777556e-03f, -3.92585620e-02f, 3.21176797e-02f, 4.79107238e-02f, -9.12940223e-03f, -5.34621358e-04f, -6.04030490e-02f, 5.88096231e-02f, -3.82868834e-02f, 3.31540368e-02f,
  4.53523621e-02f, 5.97061776e-02f, -3.85609381e-02f, 6.38146739e-05f, -1.37806889e-02f, 4.31565475e-03f, -7.33382776e-02f, 3.92605667e-04f, -8.60175863e-02f, -4.48529795e-02f,
  3.28903347e-02f, 8.52518305e-02f, -7.84148648e-02f, -7.42109269e-02f, -7.47028366e-02f, 7.91693330e-02f, 4.96531166e-02f, 2.13765539e-02f, 6.36289045e-02f, 3.49157937e-02f,
  -1.68789048e-02f, 6.49007112e-02f, 1.80199578e-01f, 6.45329943e-03f, 6.05490953e-02f, -2.61999555e-02f, 6.45876303e-02f, 1.29244952e-02f, -2.03568731e-02f, -4.54735160e-02f,
  -7.82944039e-02f, -6.57385141e-02f, 5.81574067e-02f, -4.32993062e-02f, -8.94866139e-02f, -5.94694428e-02f, -6.67509958e-02f, -7.57346898e-02f, -8.87093917e-02f, -1.18331008e-01f,
  3.44754383e-02f, -9.08762589e-02f, 2.66308634e-04f, 1.13929786e-01f, 7.74708390e-02f, 7.65963793e-02f, -7.74253756e-02f, 7.21755698e-02f, 3.08278129e-02f, 4.96282130e-02f,
  7.66316652e-02f, -5.41506708e-03f, 9.34154466e-02f, -7.04380944e-02f, 3.37524973e-02f, -4.17482071e-02f, 8.46079811e-02f, 5.67050911e-02f, -8.16372186e-02f, -2.30796337e-02f,
  4.34143320e-02f, -5.50013073e-02f, 3.63435270e-03f, -1.20824017e-02f, 5.42020239e-02f, -2.86379047e-02f, -1.34394374e-02f, 7.03998953e-02f, 9.71304551e-02f, -2.37378497e-02f,
  1.16332896e-01f, -3.40526067e-02f, 8.67197569e-03f, -1.87624304e-03f, 3.12503800e-02f, 1.07863158e-01f, -5.59682027e-02f, -5.72556816e-02f, -6.32722601e-02f, -9.29694176e-02f,
  -8.89725536e-02f, 2.53085494e-02f, 2.84840018e-02f, 9.91695076e-02f, -4.94070388e-02f, 9.88759324e-02f, 5.13022058e-02f, -6.36990517e-02f, 2.75993184e-03f, 2.32176501e-02f,
  3.30958702e-02f, 9.67434794e-02f, -8.45452175e-02f, 1.02995023e-01f, 3.96161266e-02f, -6.19586445e-02f, 1.69535410e-02f, -8.01468641e-02f, 9.44785476e-02f, -4.86084446e-02f,
  9.82389152e-02f, -1.06246077e-01f, -5.32545783e-02f, -4.45345826e-02f, 4.67239767e-02f, 4.54132119e-03f, 8.76484588e-02f, 9.24609751e-02f, -3.40287574e-02f, 4.05601524e-02f,
  -8.26725811e-02f, -9.30263326e-02f, 1.13747321e-01f, -3.32025765e-03f, 2.57874914e-02f, -9.40115005e-02f, -5.59703819e-02f, -1.35682672e-02f, -1.05277024e-01f, 7.71957636e-02f,
  2.13048737e-02f, -1.72568914e-02f, 4.96274754e-02f, -5.92362322e-02f, -4.65157162e-03f, 7.03638718e-02f, -6.33047447e-02f, -4.97502908e-02f, 4.48711589e-02f, 9.52080935e-02f,
  -6.58571124e-02f, 5.34964055e-02f, -8.59650522e-02f, 4.54192646e-02f, -6.36345744e-02f, -6.46383241e-02f, -3.64128649e-02f, 1.02025524e-01f, 2.80178338e-02f, -6.11770619e-03f,
  -6.10876530e-02f, 4.10156436e-02f, -8.03931206e-02f, 6.81518391e-02f, -1.44194644e-02f, 4.94111814e-02f, 1.59166723e-01f, 2.87051015e-02f, 2.59637952e-01f, 6.45377189e-02f,
  1.27596319e-01f, 6.95175454e-02f, -2.97098141e-02f, 2.40423560e-01f, 7.02387094e-02f, 4.61324081e-02f, 2.80194968e-01f, 9.51283202e-02f, 1.66384634e-02f, 1.93054248e-02f,
  4.01348136e-02f, 2.09324330e-01f, -1.50656998e-01f, -1.35364532e-01f, -1.02992639e-01f, -1.43120900e-01f, -8.14996213e-02f, -2.07554355e-01f, -1.87161639e-02f, -1.32494268e-03f,
  3.22083756e-02f, 1.10708989e-01f, -6.65859431e-02f, -3.00410427e-02f, 1.27798291e-02f, -3.12458500e-02f, -1.11782968e-01f, -8.06242451e-02f, -5.13991341e-02f, 7.98778683e-02f,
  -2.91138720e-02f, 4.51855808e-02f, 7.58216083e-02f, -8.59739482e-02f, -2.29815952e-02f, 4.81251292e-02f, 2.69385371e-02f, 2.66353022e-02f, 1.78289320e-02f, -1.02334162e-02f,
  -3.11643351e-02f, 3.39356773e-02f, 6.38274252e-02f, -1.00144232e-02f, -1.05486149e-02f, 7.21438527e-02f, -5.07874824e-02f, -2.69822516e-02f, -5.08538261e-02f, -4.10982817e-02f,
  -2.81731840e-02f, 6.55286834e-02f, -1.72981098e-02f, 5.09406924e-02f, -5.64882867e-02f, -9.50380415e-02f, -1.74235192e-03f, 1.13938870e-02f, 8.24642405e-02f, -5.22017479e-02f,
  -5.65514676e-02f, 3.59109901e-02f, 3.16439867e-02f, 6.17098473e-02f, 1.42501632e-03f, 5.93799837e-02f, -6.77439477e-03f, 2.38169227e-02f, 1.03629500e-01f, -2.57296357e-02f,
  -6.66508004e-02f, 9.81763154e-02f, 7.65279755e-02f, -9.69389081e-02f, -1.11883727e-03f, -8.35295692e-02f, -4.13808599e-02f, -7.22124726e-02f, -1.62782110e-02f, 3.50236222e-02f,
  7.21460059e-02f, 2.00250044e-01f, -1.03204418e-02f, 7.54133165e-02f, -8.16961750e-02f, 2.09318195e-02f, -5.04692793e-02f, 8.39438941e-03f, 7.26290122e-02f, 1.57041028e-02f,
  -6.07063100e-02f, -4.60846312e-02f, 2.02449523e-02f, -8.27023461e-02f, 2.48344988e-02f, 1.24502972e-01f, 9.52649042e-02f, -7.18697160e-03f, -3.73539217e-02f, 1.56448677e-03f,
  3.48347947e-02f, -1.35493220e-03f, -8.55600312e-02f, 7.57281259e-02f, 3.37798186e-02f, -5.13979346e-02f, 4.03370857e-02f, -4.62120287e-02f, -4.09188122e-02f, 9.62734893e-02f,
  -1.38462186e-01f, 5.56569435e-02f, -5.88438734e-02f, 2.47954447e-02f, -2.57849228e-02f, -3.38426344e-02f, 8.52058977e-02f, -5.03497422e-02f, -1.28414575e-03f, 2.62958586e-01f,
  6.55234531e-02f, -4.51328829e-02f, 8.90421346e-02f, 9.64795724e-02f, -2.18468204e-01f, 8.78686979e-02f, 9.54272822e-02f, -5.12366928e-03f, 3.71194147e-02f, -1.45801276e-01f,
  -1.37917101e-01f, 7.54530579e-02f, -6.16433732e-02f, -2.15260591e-02f, 5.66244870e-02f, -1.47394026e-02f, 2.64446922e-02f, -8.43254477e-02f, -5.92633374e-02f, -9.62752476e-03f,
  -1.33841693e-01f, -4.12318856e-02f, -1.09557793e-01f, 2.55559962e-02f, -4.85574752e-02f, -5.65678962e-02f, -3.07201538e-02f, -9.09274295e-02f, -2.70709079e-02f, -3.44608724e-02f,
  -1.00388199e-01f, -6.93108439e-02f, 7.91636184e-02f, 2.43895333e-02f, 5.07386699e-02f, -4.78812493e-02f, -7.59703573e-03f, 6.97620064e-02f, 4.81195562e-02f, -5.39482646e-02f,
  -1.41366618e-02f, 2.93887332e-02f, -9.88772884e-03f, 3.82544361e-02f, -7.60690421e-02f, -7.26976544e-02f, 6.06931448e-02f, 1.02449888e-02f, -8.49494562e-02f, 3.23512256e-02f,
  1.11686606e-02f, 6.10462800e-02f, -2.25776415e-02f, 7.55192991e-03f, 2.98605394e-02f, -6.07678071e-02f, 2.88315397e-02f, -1.49475355e-02f, -4.31522764e-02f, -3.16162058e-03f,
  -2.55198237e-02f, -9.89413038e-02f, 2.73058005e-02f, -2.72169095e-02f, -2.43997611e-02f, 7.50343651e-02f, 2.05484778e-02f, 3.97434719e-02f, 3.91076691e-02f, 4.16112831e-03f,
  -6.05289303e-02f, -5.02536297e-02f, -1.34878531e-02f, -3.39200683e-02f, 3.89636196e-02f, 6.41813055e-02f, -2.85254028e-02f, 2.88241776e-03f, 5.22777028e-02f, 2.57419385e-02f,
  -1.03937881e-02f, -1.81152429e-02f, -9.03343856e-02f, 2.08447054e-02f, 1.82705112e-02f, -4.63696234e-02f, 7.14146718e-02f, -6.61796629e-02f, 2.43111998e-02f, 6.11811094e-02f,
  4.50581536e-02f, -4.44147065e-02f, -1.65567398e-02f, -2.32236739e-03f, -2.01143529e-02f, 6.08047694e-02f, 5.13077341e-02f, 8.82959664e-02f, -6.09153919e-02f, 8.86170492e-02f,
  7.77284335e-03f, -3.23045813e-02f, 2.57593812e-03f, 8.06395784e-02f, -6.57423362e-02f, -2.68376507e-02f, -2.55817603e-02f, 5.38550168e-02f, -3.59055735e-02f, -2.00254321e-02f,
  8.27689245e-02f, -2.81665057e-01f, 1.53440014e-01f, -5.10942452e-02f, -4.25227219e-03f, 4.37797010e-02f, 1.15541138e-01f, -1.48747638e-01f, -1.80119768e-01f, -3.38778108e-01f,
  3.32708061e-02f, 3.42292935e-02f, 1.37718081e-01f, -1.60485089e-01f, 3.59387130e-01f, 1.13962725e-01f, -1.42550515e-02f, -1.84047986e-02f, -3.63172144e-02f, -1.83080032e-01f,
  -8.20997581e-02f, -1.21032968e-01f, 1.04116082e-01f, -1.41314104e-01f, -7.29243234e-02f, -1.89330533e-01f, 1.06677547e-01f, 4.99216393e-02f, 2.70628044e-03f, 1.24005817e-01f,
  -1.31122932e-01f, -1.17169254e-01f, -1.29585732e-02f, 2.16235165e-02f, -7.63077214e-02f, -4.29741405e-02f, 5.62161654e-02f, 1.27833948e-01f, 8.36120322e-02f, -2.26013754e-02f,
  4.67670746e-02f, 4.53416305e-03f, -1.09279260e-01f, -2.90523861e-02f, -1.07297048e-01f, -1.20699927e-01f, -3.28490101e-02f, -2.07482055e-02f, -5.03566042e-02f, 1.00520588e-01f,
  5.88408820e-02f, 4.21361104e-02f, -5.06966189e-02f, -6.50449097e-03f, 2.10178029e-02f, 2.95095164e-02f, -2.10824888e-02f, 6.35715947e-02f, 3.33320320e-04f, 3.95294875e-02f,
  -8.09509531e-02f, 2.80847084e-02f, -5.37543967e-02f, 2.89909355e-02f, 6.62809834e-02f, 1.95847247e-02f, 5.00879660e-02f, 5.05942218e-02f, 4.96964604e-02f, -4.70504798e-02f,
  3.19685997e-03f, -3.83015350e-02f, -4.09302637e-02f, -3.69567610e-02f, 4.28423993e-02f, 3.74011137e-02f, 1.18129216e-01f, 3.50774489e-02f, -6.52309582e-02f, -5.30601181e-02f,
  5.54040931e-02f, 4.02179360e-02f, -2.13790424e-02f, 6.07572012e-02f, 3.37506868e-02f, 8.79918635e-02f, -3.43453663e-04f, -5.04839458e-02f, 5.93069531e-02f, 6.60687536e-02f,
  -1.19801164e-01f, -2.61907220e-01f, -8.65482166e-02f, -1.19982730e-03f, 2.73788460e-02f, -1.98715013e-02f, -5.76474965e-02f, 2.72596329e-02f, -8.99040848e-02f, -1.04675449e-01f,
  6.60578981e-02f, 2.05073133e-02f, -2.64935419e-02f, -4.89010252e-02f, 7.31715560e-02f, -1.87703278e-02f, -8.94102268e-03f, 3.10629252e-02f, 5.49802668e-02f, -9.75774899e-02f,
  -6.36231825e-02f, 1.22614559e-02f, 1.04134209e-01f, -1.43775716e-02f, -3.29154097e-02f, 1.68303761e-03f, -7.92574584e-02f, 6.89223185e-02f, 4.51071672e-02f, -4.45093773e-02f,
  -2.53724921e-02f, 1.49907991e-01f, -1.05576031e-01f, 2.98771821e-02f, 1.24479294e-01f, 1.66473284e-01f, 6.23558909e-02f, -2.42037885e-02f, 4.65977602e-02f, 2.00231254e-01f,
  1.94213033e-01f, 3.55738588e-02f, 6.43626228e-02f, 1.03975289e-01f, -2.26669554e-02f, 1.71647593e-02f, 8.39975923e-02f, 1.19552843e-01f, -7.50568584e-02f, 1.13442644e-01f,
  -4.13254835e-02f, 1.91005185e-01f, -1.48633212e-01f, 1.28684118e-02f, 1.02815636e-01f, -5.22467941e-02f, 6.55127689e-03f, -9.06760544e-02f, -4.90192622e-02f, 6.21354021e-02f,
  1.08237118e-01f, 7.43658841e-02f, 3.00551280e-02f, -3.34148854e-02f, -8.78082737e-02f, -1.39508331e-02f, -7.96449184e-02f, -8.97528380e-02f, -2.30934601e-02f, -3.54343206e-02f,
  2.61346325e-02f, -3.72262904e-03f, -1.04290089e-02f, 6.60915002e-02f, -5.87361678e-02f, -6.54254854e-02f, -6.26511946e-02f, 8.25292692e-02f, -8.54576752e-02f, -2.99823042e-02f,
  -1.09653845e-01f, -4.02254127e-02f, 1.71265844e-02f, -8.03905819e-03f, 6.95982054e-02f, 1.35316150e-02f, -2.78815422e-02f, 3.67187820e-02f, 6.17761835e-02f, -9.74986851e-02f,
  -6.76520988e-02f, 6.14613853e-02f, -7.61235282e-02f, -6.96374625e-02f, 1.03545211e-01f, 4.28829007e-02f, 2.83929072e-02f, 4.56001274e-02f, -9.19158384e-02f, -3.41190398e-02f,
  4.41849940e-02f, 8.28696322e-03f, -7.00144563e-03f, -5.83632924e-02f, 9.31224525e-02f, -9.19310749e-02f, -4.98383399e-03f, 5.72024658e-03f, 7.24630952e-02f, -6.95339069e-02f,
  -4.25975770e-02f, 8.15557875e-03f, -3.37560922e-02f, 1.61983892e-02f, 6.15054294e-02f, 5.41452803e-02f, 5.28530180e-02f, 4.53431904e-02f, -4.66563255e-02f, -1.27403822e-03f,
  6.24461360e-02f, 9.14608985e-02f, -2.91076154e-02f, -6.21640608e-02f, 5.04962839e-02f, -6.02548346e-02f, -6.73820525e-02f, -8.00932124e-02f, -7.97202885e-02f, 2.05440950e-02f,
  -1.12304534e-03f, -2.75569037e-02f, -3.36052254e-02f, 4.88238297e-02f, 5.59720024e-02f, 4.22017090e-02f, 3.74183357e-02f, -6.03724532e-02f, -2.46782377e-02f, -3.12679633e-02f,
  3.80965434e-02f, 7.76401609e-02f, 6.68459758e-02f, 5.54723106e-02f, 8.25908706e-02f, -5.06128967e-02f, -4.45083864e-02f, -6.95340186e-02f, 6.99139312e-02f, -4.79148738e-02f,
  -1.16084114e-01f, 7.45565668e-02f, -1.06152728e-01f, -2.80892346e-02f, -1.85413845e-02f, 1.37420660e-02f, 3.41020860e-02f, 1.79496873e-02f, -3.52539122e-02f, 7.46756718e-02f,
  1.34747401e-01f, 4.00251336e-02f, 3.61106880e-02f, -4.84988950e-02f, -9.60988700e-02f, 3.64010893e-02f, 2.21728887e-02f, -4.38519642e-02f, 3.78957242e-02f, 3.84856574e-02f,
  -3.81551310e-02f, 3.98881137e-02f, -1.16553098e-01f, 4.21510898e-02f, 4.78297472e-02f, 2.16774046e-02f, -8.16451386e-03f, 1.22916199e-01f, 1.90155748e-02f, -4.22486989e-03f,
  6.99882768e-03f, -7.31356889e-02f, 1.46016916e-02f, 5.28363958e-02f, 4.61471342e-02f, 1.73781104e-02f, -4.52695321e-03f, 2.22805403e-02f, 4.70212586e-02f, -8.42645094e-02f,
  2.50425097e-02f, 7.46862367e-02f, 5.83069734e-02f, 2.69738045e-02f, 2.92085372e-02f, -4.67194095e-02f, -7.93617871e-03f, -3.24017629e-02f, 6.27744868e-02f, 2.41928976e-02f,
  -7.12275431e-02f, -3.21948007e-02f, 8.90819728e-02f, -6.43775985e-02f, -1.68793593e-02f, 5.39097227e-02f, -7.01083392e-02f, -2.87215654e-02f, 6.39588684e-02f, 1.06823286e-02f,
  8.09598863e-02f, 2.14559790e-02f, 5.12193777e-02f, -2.10403353e-02f, -7.63124526e-02f, 9.01172534e-02f, -3.26888785e-02f, -1.49131957e-02f, -4.47499529e-02f, -7.04285353e-02f,
  -3.39331143e-02f, 4.94798180e-03f, -3.54099534e-02f, 6.98494688e-02f, -2.59225816e-02f, -6.62708133e-02f, 2.31879428e-02f, -1.94216184e-02f, -7.08360896e-02f, -9.21398625e-02f,
  -2.64640972e-02f, 9.21953022e-02f, 1.35124312e-03f, -4.67282608e-02f, -2.57958975e-02f, 3.59815359e-02f, -1.44737149e-02f, -3.83437946e-02f, 5.25389612e-02f, 8.10568184e-02f,
  -6.39144937e-03f, 1.03484198e-01f, 6.69380873e-02f, -2.26635230e-03f, 5.39334193e-02f, 6.34777779e-03f, 1.86013058e-02f, -6.22579567e-02f, -3.15713286e-02f, -8.50183219e-02f,
  -7.26341531e-02f, -2.33848337e-02f, 5.70310615e-02f, 1.44345714e-02f, -5.79105280e-02f, 6.76951408e-02f, 8.18913057e-02f, 1.62682608e-02f, 9.26576613e-04f, -1.92567781e-02f,
  8.04695189e-02f, 4.68986556e-02f, -5.73622845e-02f, 1.14635220e-02f, 2.47113090e-02f, -4.79022488e-02f, 7.25991325e-04f, 5.89724705e-02f, 1.98753290e-02f, -9.62292254e-02f,
  -7.53728598e-02f, 9.38598514e-02f, -2.03550104e-02f, 1.21592507e-01f, 1.76822916e-02f, -5.31540718e-03f, -3.63733321e-02f, -9.64692142e-03f, -9.02293772e-02f, -1.15370162e-01f,
  7.62332464e-03f, 1.70470867e-02f, -1.19165711e-01f, 5.68208098e-02f, -5.98918051e-02f, -1.47902016e-02f, 8.33411738e-02f, 7.79986754e-02f, 1.40098929e-01f, -8.28958750e-02f,
  2.26039886e-02f, -2.45375792e-04f, 5.50695919e-02f, 1.06494151e-01f, -7.61408955e-02f, 2.48996280e-02f, 6.85288757e-02f, 3.02923005e-02f, 1.08427539e-01f, 2.10838411e-02f,
  -1.03327990e-01f, -4.79749124e-03f, -9.51828584e-02f, -7.73256794e-02f, 2.50982847e-02f, -1.05475001e-01f, 7.13302195e-02f, -5.58762737e-02f, -5.74902743e-02f, 1.25650112e-02f,
  -2.27228943e-02f, -6.80952286e-03f, -2.43273526e-02f, -3.65514196e-02f, -6.85397675e-03f, 5.98819181e-02f, -3.66843902e-02f, 3.32868025e-02f, -9.59953386e-03f, 1.05977664e-03f,
  -2.19223443e-02f, -2.93977931e-02f, 3.17913927e-02f, 2.99657807e-02f, 5.19036502e-02f, 2.90693603e-02f, -5.06606512e-02f, -8.51193070e-02f, -8.49807113e-02f, 2.21574362e-02f,
  -4.49164920e-02f, 1.81722511e-02f, -1.04267716e-01f, -5.39639108e-02f, 3.68463323e-02f, 6.48417398e-02f, 3.51509489e-02f, -1.08711245e-02f, -7.51407668e-02f, -6.48922846e-02f,
  1.45621840e-02f, -8.31603780e-02f, -6.01207502e-02f, 2.20260974e-02f, 2.02945480e-03f, -8.47613364e-02f, -2.02102624e-02f, 5.42009063e-02f, 2.45319009e-02f, 1.29863517e-02f,
  9.44371372e-02f, 6.64574057e-02f, -2.76032034e-02f, -5.96954562e-02f, -8.10314715e-02f, -4.15927870e-03f, -1.27704283e-02f, 3.48037705e-02f, 6.95458800e-02f, -4.51447405e-02f,
  -1.23625360e-01f, -7.06858411e-02f, -1.75175592e-02f, -7.93390349e-02f, 7.71491304e-02f, -9.00906324e-02f, 6.68641031e-02f, -9.38115716e-02f, -3.06732468e-02f, 1.34447357e-02f,
  -5.28403446e-02f, -5.04626855e-02f, -4.90117595e-02f, 8.04264173e-02f, 2.16270387e-02f, -1.75364837e-02f, 4.73096259e-02f, 1.03023963e-03f, -7.01494962e-02f, 3.66993695e-02f,
  -3.80180068e-02f, 5.36945090e-02f, -1.58034526e-02f, 5.91554195e-02f, 4.82267216e-02f, 3.09599820e-03f, 5.85534237e-02f, -3.98134440e-02f, 4.45077458e-05f, 3.08720134e-02f,
  -8.63250270e-02f, 1.39375687e-01f, -1.42414704e-01f, -4.60107671e-03f, 1.23251952e-01f, 2.11013913e-01f, 1.03834748e-01f, 1.56588227e-01f, 1.46711230e-01f, 7.28803277e-02f,
  9.27132070e-02f, -4.08069417e-02f, -3.81261855e-02f, 1.86579768e-02f, 1.04716592e-01f, 4.22014520e-02f, 1.15756541e-01f, 5.92176393e-02f, 1.22521736e-01f, 7.55667163e-04f,
  -8.43566097e-03f, 1.58686474e-01f, -1.04065150e-01f, -3.83846201e-02f, 5.91426715e-02f, -8.83640125e-02f, -1.02345131e-01f, -1.00986734e-01f, -4.64499891e-02f, 6.96776882e-02f,
  -3.36035714e-02f, -2.30415910e-02f, -2.07103416e-03f, 3.87778692e-02f, -7.23716512e-04f, -7.93914124e-02f, -4.38106284e-02f, -9.55484435e-02f, -7.82230869e-02f, 7.38827651e-03f,
  -7.19407387e-03f, 3.60740647e-02f, -4.06956337e-02f, -2.56877132e-02f, -8.62428546e-03f, 3.99718806e-02f, -5.83495088e-02f, 4.18602601e-02f, -7.70541951e-02f, -2.58436613e-02f,
  2.98174303e-02f, 4.20653820e-02f, -5.02729192e-02f, 4.35662828e-02f, 3.12212631e-02f, 6.78460207e-03f, 6.57453984e-02f, -5.07308915e-02f, -2.10753735e-02f, 8.28508064e-02f,
  -6.14371896e-03f, -5.70810400e-02f, 4.81347628e-02f, -4.98134643e-02f, -5.80436923e-02f, -6.39311224e-02f, 3.98465209e-02f, -1.70199256e-02f, 6.04383126e-02f, 9.09361169e-02f,
  -4.63621169e-02f, -2.02724636e-02f, -4.06051166e-02f, 5.81864156e-02f, 2.66193971e-02f, 4.73948568e-02f, -9.71042812e-02f, 2.15859269e-03f, 1.97605435e-02f, -5.52557260e-02f,
  -6.33208156e-02f, -6.54481957e-03f, -6.07586391e-02f, -7.82138035e-02f, 9.67704803e-02f, -6.68250173e-02f, 8.19158480e-02f, 1.83722861e-02f, 7.12041482e-02f, 7.16700032e-02f,
  1.15633219e-01f, 5.71950898e-02f, -5.45988269e-02f, 2.89165452e-02f, 1.66875292e-02f, 1.72805674e-02f, 6.54234439e-02f, 5.59263267e-02f, 9.66753140e-02f, 5.12697026e-02f,
  -3.85805592e-02f, -3.23576145e-02f, 5.92319816e-02f, 1.85605809e-02f, 7.60321915e-02f, -3.07088904e-02f, -4.01089974e-02f, -4.72268602e-03f, 3.01356148e-02f, 2.05957890e-03f,
  -2.60034669e-02f, -2.01391354e-02f, 1.61458477e-02f, 7.11638927e-02f, 8.81844163e-02f, 1.15087442e-02f, 9.13795978e-02f, 2.38590483e-02f, 2.44699605e-02f, -8.14874470e-02f,
  2.05459669e-01f, 7.76198730e-02f, 5.97135387e-02f, -9.83323082e-02f, -4.00729068e-02f, 5.43883480e-02f, -3.90934013e-02f, 9.55295116e-02f, -7.45479390e-02f, -1.18131734e-01f,
  -1.37558624e-01f, -1.38303176e-01f, 7.51170292e-02f, -5.20480238e-02f, 8.07768926e-02f, 7.40715265e-02f, 1.10311911e-01f, -1.23380460e-01f, 6.51526675e-02f, 3.86521555e-02f,
  1.29058331e-01f, 5.82701378e-02f, 5.70798665e-02f, 8.52575824e-02f, 1.31846848e-03f, 1.31420996e-02f, -6.70828670e-02f, -1.35818804e-02f, 7.70046981e-03f, 4.34790505e-03f,
  3.07777189e-02f, 1.03801474e-01f, 4.52786572e-02f, 9.44974571e-02f, 9.95878801e-02f, -6.83124587e-02f, 7.44430581e-04f, -8.20427667e-03f, -8.25335607e-02f, 3.79662029e-02f,
  -2.75114775e-02f, 1.53611591e-02f, -1.59740560e-02f, 4.07318398e-02f, 1.14778904e-02f, 2.90950797e-02f, -2.33148616e-02f, -3.78624573e-02f, -4.69955802e-02f, 5.77004217e-02f,
  7.56422291e-03f, -2.90212389e-02f, -6.68463260e-02f, 2.74373684e-02f, 2.14539468e-02f, -1.52220950e-02f, -6.64434135e-02f, 4.55605946e-02f, 5.20034432e-02f, -2.52720229e-02f,
  -5.73039846e-03f, -7.90471137e-02f, -4.58919210e-03f, -4.64712605e-02f, -3.85400541e-02f, -1.45902787e-03f, -5.30263036e-02f, -1.96636561e-02f, 2.57319268e-02f, 3.65181779e-03f,
  5.00801361e-05f, 4.39160829e-03f, 6.71799928e-02f, -2.40611210e-02f, 8.88926834e-02f, -2.94797979e-02f, -9.22388881e-02f, -2.54477523e-02f, -2.11058129e-02f, 9.75593105e-02f,
  4.03067395e-02f, 4.62242067e-02f, -8.90415609e-02f, -3.30209285e-02f, 5.97017147e-02f, -3.51913497e-02f, 6.99216500e-02f, 5.13727926e-02f, 1.00104406e-01f, -6.59812316e-02f,
  -7.25148395e-02f, 1.28102556e-01f, 6.89533949e-02f, -3.48993503e-02f, 3.82597297e-02f, -4.60843816e-02f, 1.12619542e-03f, 6.11180700e-02f, 3.24695781e-02f, -6.68372065e-02f,
  2.40269545e-02f, 2.42788773e-02f, -5.91992363e-02f, 1.01004414e-01f, 2.63610724e-02f, -1.11264698e-02f, -6.60453513e-02f, -7.29987398e-02f, -8.59785825e-02f, 6.69952556e-02f,
  -6.19072691e-02f, 1.38336057e-02f, -3.64558473e-02f, -8.02345648e-02f, -1.11017659e-01f, -1.03447801e-02f, 5.12972511e-02f, -1.09164052e-01f, -6.51284531e-02f, 2.29446664e-02f,
  8.63107517e-02f, 1.39981568e-01f, -2.88326174e-01f, -5.57688326e-02f, -1.26049504e-01f, 4.84188721e-02f, 7.29508772e-02f, -4.30951975e-02f, -5.28295934e-02f, 2.16132894e-01f,
  2.13941157e-01f, -8.99329111e-02f, 1.58901792e-02f, 2.69165576e-01f, 6.89709606e-03f, 8.91749486e-02f, 2.44588986e-01f, 1.50994822e-01f, -6.07972294e-02f, -5.53457402e-02f,
  4.77983318e-02f, 2.15010852e-01f, 3.94728445e-02f, 4.43954803e-02f, 1.00538284e-02f, -3.98079902e-02f, 1.41070992e-01f, -2.27697819e-01f, 6.61514476e-02f, -5.48746772e-02f,
  -1.18366107e-02f, 8.69808570e-02f, -1.00640625e-01f, 2.28833091e-02f, 8.31844509e-02f, -3.69650312e-02f, 6.65026456e-02f, -8.20358619e-02f, -3.78320813e-02f, -2.31743641e-02f,
  1.35886054e-02f, -3.69120874e-02f, 3.99000421e-02f, 6.70831697e-03f, -7.95428678e-02f, -3.56894433e-02f, -2.00479757e-02f, 3.52957100e-03f, -5.55318072e-02f, -5.75122945e-02f,
  1.76355094e-02f, 2.99479831e-02f, 3.17802355e-02f, 5.96423894e-02f, -1.01578593e-01f, -1.89532060e-02f, 3.32591310e-02f, -2.51650531e-02f, 6.54408056e-03f, -1.69405080e-02f,
  -3.83948833e-02f, 3.06742359e-02f, 8.06703717e-02f, 6.69449493e-02f, 6.52337000e-02f, 1.37864286e-02f, -2.28858069e-02f, 6.35852888e-02f, 2.51738168e-02f, 5.90883642e-02f,
  5.64642064e-03f, 5.07502668e-02f, 5.41529991e-02f, -3.26509103e-02f, -3.77972983e-02f, 4.26756181e-02f, 2.33562067e-02f, -2.57126652e-02f, -1.05050653e-01f, 7.20600877e-03f,
  -1.19143464e-02f, 6.61796480e-02f, -4.68691476e-02f, 4.27016467e-02f, -2.49827653e-02f, -2.60247812e-02f, -2.39852760e-02f, 7.28287697e-02f, 7.06508942e-03f, 3.63399684e-02f,
  -1.03956480e-02f, 1.54150249e-02f, 4.71046828e-02f, -4.34455425e-02f, -3.98707725e-02f, 7.60448575e-02f, 1.69358570e-02f, 4.61493544e-02f, 1.32909594e-02f, -2.53686719e-02f,
  3.11862994e-02f, -4.19046097e-02f, 3.42029445e-02f, -1.93383470e-02f, 2.08381731e-02f, 1.00858450e-01f, -4.51087542e-02f, 5.60485525e-04f, 6.37203306e-02f, 6.20493256e-02f,
  -1.14223445e-02f, -3.07082310e-02f, -3.53536606e-02f, -4.81642894e-02f, 1.12297889e-02f, 3.77567299e-02f, -5.27876280e-02f, -3.27547528e-02f, 6.92057833e-02f, 3.44522633e-02f,
  -1.54950246e-01f, 2.16002136e-01f, -2.32595131e-02f, -6.62003532e-02f, -8.83662999e-02f, 6.30526617e-02f, 1.60867721e-01f, 1.11132182e-01f, 2.83163358e-02f, 2.32394591e-01f,
  -1.60722770e-02f, -2.25220695e-02f, 1.34912282e-02f, 1.71502709e-01f, -1.41023681e-01f, 9.51962098e-02f, 3.61196920e-02f, 1.22710310e-01f, 7.34018311e-02f, -4.90104854e-02f,
  -1.05198666e-01f, 7.76423961e-02f, -5.56598492e-02f, -6.51880354e-02f, -5.81590123e-02f, 2.82182414e-02f, -1.51984781e-01f, -1.11579224e-01f, -2.66619511e-02f, -1.23827770e-01f,
  1.17105730e-01f, -3.47613283e-02f, -4.36898880e-02f, 1.09482810e-01f, 7.83349648e-02f, 6.05293326e-02f, 4.85935695e-02f, -2.22356077e-02f, 3.11856698e-02f, 8.28415081e-02f,
  -3.06290779e-02f, -5.79168871e-02f, -1.69718801e-03f, -2.00686902e-02f, 8.32372997e-03f, -6.67499825e-02f, -4.59814630e-02f, -3.98925878e-02f, -3.91257480e-02f, -3.54405195e-02f,
  5.40795848e-02f, -6.11722842e-02f, -7.24884197e-02f, 8.00305419e-03f, 6.77730739e-02f, -8.02125782e-02f, 5.96199520e-02f, -7.82856941e-02f, -3.49876657e-02f, 3.26245651e-02f,
  -1.72657091e-02f, -2.60322131e-02f, 5.40996194e-02f, 1.04984872e-01f, -8.84024948e-02f, -5.41654900e-02f, 7.15776607e-02f, -5.01279943e-02f, -5.47147915e-02f, -9.35598910e-02f,
  3.68402936e-02f, 2.89490223e-02f, -5.86481988e-02f, -6.56395853e-02f, 8.53390321e-02f, 2.96497513e-02f, 3.00725866e-02f, -7.46673392e-03f, -1.73696559e-02f, 1.90672409e-02f,
  -1.50504000e-02f, -6.20199591e-02f, -3.42533104e-02f, 4.18025665e-02f, 2.88632605e-02f, 9.60577279e-03f, 1.66902738e-03f, 4.48872037e-02f, -2.13427618e-02f, -8.19792524e-02f,
  7.95379505e-02f, -6.89998269e-02f, 4.20060903e-02f, 3.79724614e-02f, 8.33519027e-02f, 5.21957502e-02f, -2.36844327e-02f, 2.55186833e-03f, 5.29408306e-02f, 6.56331889e-03f,
  -1.32810483e-02f, 1.05580362e-02f, -7.08361119e-02f, -5.54744415e-02f, 6.33528903e-02f, -4.80464436e-02f, 7.70372972e-02f, -6.96584433e-02f, 1.41634943e-03f, 1.07704420e-02f,
  -9.17523950e-02f, -5.13800047e-02f, 7.06277192e-02f, 4.46505211e-02f, -7.79794529e-02f, 7.91510493e-02f, -5.04636504e-02f, 5.19292466e-02f, 1.59910340e-02f, 8.97412896e-02f,
  -6.24395646e-02f, 3.89219783e-02f, -1.10209130e-01f, 8.06693826e-03f, -1.75096199e-01f, -1.30433112e-01f, -9.05604139e-02f, 3.46149653e-02f, -4.54475638e-03f, 2.52163243e-02f,
  -9.53782350e-02f, 1.07399419e-01f, 1.09236255e-01f, -1.44027427e-01f, -2.47027930e-02f, 1.06950283e-01f, 1.45901497e-02f, 5.08146435e-02f, 1.67829767e-02f, -6.96550980e-02f,
  -3.51315900e-03f, -5.85308522e-02f, -8.63083676e-02f, -9.04811025e-02f, -1.57931730e-01f, -7.86281750e-03f, 1.03607150e-02f, -9.09935385e-02f, 3.29380780e-02f, -1.27750054e-01f,
  -1.09951347e-01f, 7.09083229e-02f, -5.21608554e-02f, 6.26583546e-02f, 3.97183932e-02f, 5.32147214e-02f, -7.58273154e-02f, 2.87634656e-02f, -1.89159662e-02f, -7.58740529e-02f,
  7.32483417e-02f, -7.07019940e-02f, 7.36981630e-02f, -8.30588043e-02f, -9.63134170e-02f, 1.50003778e-02f, -5.85431941e-02f, -5.73777370e-02f, -4.81951125e-02f, -1.78049244e-02f,
  -7.45097129e-03f, 3.49629819e-02f, -6.38146326e-02f, 9.09510329e-02f, 1.00627333e-01f, -4.88027819e-02f, 5.28380200e-02f, 1.21802734e-02f, -2.30352432e-02f, 7.35524595e-02f,
  2.39161812e-02f, 6.66421503e-02f, 1.03858681e-02f, -6.77321553e-02f, -1.01883098e-01f, -1.74063642e-03f, -4.61522713e-02f, -6.91348761e-02f, -1.69415260e-03f, -4.26747464e-02f,
  -1.69069357e-02f, -5.20566329e-02f, 3.91095988e-02f, 2.35441402e-02f, 8.20553079e-02f, 3.24056931e-02f, -5.39962649e-02f, 8.21209773e-02f, -1.54677238e-02f, -1.73511282e-02f,
  -2.00714730e-02f, 3.79973128e-02f, 5.57605699e-02f, -7.97569752e-02f, -9.99030992e-02f, 7.63078630e-02f, -3.22494023e-02f, 4.72764634e-02f, -2.42603272e-02f, 6.71591461e-02f,
  6.16207197e-02f, 1.18596166e-01f, -1.76749639e-02f, 9.60598439e-02f, 2.29861699e-02f, 3.32921222e-02f, 7.84070641e-02f, 9.89314243e-02f, -3.85267176e-02f, 6.76168427e-02f,
  5.04378937e-02f, 1.74255334e-02f, -3.43797021e-02f, 1.30223166e-02f, 8.32897201e-02f, -5.50298169e-02f, 6.36227205e-02f, 3.46985273e-02f, 6.95726275e-02f, 1.58889852e-02f,
  -3.53523083e-02f, 7.32215354e-03f, 3.48892659e-02f, -5.48431762e-02f, -1.11355186e-02f, -6.49277642e-02f, 4.37915092e-03f, 8.10886850e-04f, 8.70981291e-02f, -3.77968140e-02f,
  8.35801959e-02f, 1.28163502e-01f, -1.20597547e-02f, 1.19468264e-01f, -8.65181908e-02f, -2.19818000e-02f, -9.12466124e-02f, -8.30266923e-02f, 4.54218872e-02f, -4.49594595e-02f,
  -6.12585917e-02f, 2.15713471e-01f, 9.01781768e-02f, -8.59257653e-02f, -7.97737464e-02f, -6.99603036e-02f, 5.28074130e-02f, 3.27790715e-03f, 1.46860201e-02f, 5.26781604e-02f,
  5.40402159e-02f, -1.31916001e-01f, 4.77897897e-02f, -1.37419015e-01f, -3.82614769e-02f, 4.61237356e-02f, 2.14856714e-02f, -1.13832802e-01f, -2.46751085e-02f, -1.07664533e-01f,
  -4.69944961e-02f, 8.30257684e-03f, 1.13757029e-01f, 9.74958837e-02f, -6.43012463e-04f, -2.64431108e-02f, -6.50017112e-02f, 2.69778799e-02f, 7.46359676e-02f, 8.15535262e-02f,
  1.23869888e-01f, 7.05632120e-02f, 4.08745036e-02f, 4.07358967e-02f, 2.96777897e-02f, -3.11171059e-02f, -5.26656173e-02f, -3.06395232e-03f, 6.16209162e-03f, 9.33325291e-02f,
  1.00680761e-01f, -5.62169887e-02f, 2.75304895e-02f, 3.12339794e-02f, 4.41803858e-02f, 5.22579886e-02f, 5.83463646e-02f, -4.26702791e-05f, 1.07981451e-01f, 1.74518768e-02f,
  7.48033375e-02f, 4.93889116e-02f, 7.61500522e-02f, -8.20051655e-02f, -6.52529895e-02f, 7.27463886e-03f, -4.41262685e-02f, -6.33891812e-03f, 1.06090968e-02f, -7.85541162e-02f,
  6.45316616e-02f, 2.10613403e-02f, -1.05401902e-02f, -7.35226646e-02f, 8.27325284e-02f, -7.22000822e-02f, 1.53499646e-02f, 7.47149140e-02f, 8.50940645e-02f, 7.18881786e-02f,
  -4.34324369e-02f, 5.14972545e-02f, -5.36443740e-02f, -8.40942934e-02f, 1.17792720e-02f, -4.26204056e-02f, -6.11536317e-02f, 7.78252780e-02f, 4.42646779e-02f, 1.04936427e-02f,
  1.09796086e-02f, -3.48989405e-02f, 2.18291990e-02f, 3.78227383e-02f, 1.74861792e-02f, 2.15099240e-03f, 2.23502535e-02f, -5.17149419e-02f, 5.55732809e-02f, -3.52758542e-02f,
  -2.65519675e-02f, -4.44474928e-02f, 4.33471389e-02f, 6.99698478e-02f, -1.75361931e-02f, 9.20278206e-03f, -8.21541622e-02f, -1.22964066e-02f, 4.31972295e-02f, 1.45615675e-02f,
  5.92390597e-02f, -7.87014887e-02f, 2.11920124e-02f, 3.70780900e-02f, 6.56007184e-03f, 7.16306493e-02f, 1.70006733e-02f, 6.00084849e-03f, 7.69688785e-02f, 4.68883775e-02f,
  7.50657022e-02f, -1.26029193e-01f, -4.97120507e-02f, -1.88020140e-01f, 3.29173319e-02f, 1.21533342e-01f, 2.33855084e-01f, -6.12695143e-02f, -2.84989297e-01f, -1.31394401e-01f,
  1.01297677e-01f, 6.57313364e-03f, 3.23990621e-02f, -1.43126072e-02f, 1.53955445e-01f, -1.62317064e-02f, -5.52934892e-02f, 1.11900710e-01f, -1.12427458e-01f, -2.25171000e-02f,
  -3.54862474e-02f, 9.26844031e-02f, 8.17774311e-02f, -1.15271218e-01f, 1.92006007e-02f, -2.28981916e-02f, 5.72438836e-02f, 1.69914186e-01f, 6.64265975e-02f, 2.05166936e-02f,
  5.63892610e-02f, -5.02249040e-02f, 2.05549086e-03f, -1.43161686e-02f, 5.03016748e-02f, 5.02256304e-02f, 4.47797589e-02f, 2.74566356e-02f, -7.18950778e-02f, -5.65063506e-02f,
  8.05702209e-02f, -4.18597683e-02f, -7.99964368e-02f, -7.70596936e-02f, -7.77836516e-02f, -1.03908300e-01f, -2.25579832e-02f, -7.24669695e-02f, 5.76135740e-02f, 1.89108774e-02f,
  -2.59043705e-02f, 1.71676613e-02f, -5.73262759e-03f, -2.13097055e-02f, -9.53101441e-02f, -9.45367366e-02f, -2.01408118e-02f, 1.34455159e-01f, -1.16708554e-01f, -1.03619531e-01f,
  4.22159135e-02f, 7.01001938e-03f, 5.19842058e-02f, 7.79668894e-03f, -3.09814923e-02f, -4.54902425e-02f, 2.45240256e-02f, -5.61600477e-02f, -4.99650054e-02f, -6.14404306e-02f,
  1.58142205e-02f, -7.94841945e-02f, 4.37235534e-02f, 1.57480873e-03f, 1.32372975e-02f, -6.40244260e-02f, -1.56286415e-02f, 1.93190563e-03f, -3.19184288e-02f, -8.15536007e-02f,
  -5.55382222e-02f, -3.66491228e-02f, 2.04402767e-02f, -4.82922159e-02f, 5.77807873e-02f, -4.55263145e-02f, -1.16871461e-01f, 5.96626177e-02f, -1.20937735e-01f, 4.49180184e-03f,
  5.52730709e-02f, -2.57136170e-02f, -3.93288024e-03f, -5.24123758e-02f, 1.09275617e-01f, 3.88435982e-02f, -2.92114285e-03f, -5.74599542e-02f, -5.05582355e-02f, 8.23582932e-02f,
  -5.64689562e-03f, -1.82954818e-02f, 7.75150582e-02f, 3.95572968e-02f, -6.21675849e-02f, 4.65857647e-02f, 5.33993682e-03f, 5.69155179e-02f, -7.09298179e-02f, 5.15234992e-02f,
  1.30678434e-02f, 5.15767559e-02f, -6.07112274e-02f, -5.10074571e-02f, -3.96794118e-02f, 1.68065317e-02f, -2.96954028e-02f, 3.45946513e-02f, 8.49765092e-02f, 3.85820679e-02f,
  -2.22797960e-01f, 1.59575403e-01f, 1.64657578e-01f, -2.40748525e-01f, 1.30423710e-01f, 1.53986722e-01f, -7.02674612e-02f, 2.08365694e-01f, -8.11695680e-02f, -1.67234596e-02f,
  -2.79871672e-02f, 5.67459222e-03f, 6.13253340e-02f, -1.10445924e-01f, -6.92280233e-02f, 6.57756105e-02f, -3.92685905e-02f, -1.26863765e-02f, 5.03079556e-02f, 2.82473024e-02f,
  6.35298714e-02f, 5.49300434e-03f, 8.40261281e-02f, 1.56850368e-01f, -4.26934846e-02f, 1.61580008e-03f, -1.63376644e-01f, 1.32122844e-01f, -7.82183334e-02f, -4.09436524e-02f,
  1.91729441e-02f, -3.86143476e-02f, 5.17693013e-02f, 8.60263035e-02f, 9.42462385e-02f, -5.86541295e-02f, -1.93470027e-02f, 4.63868789e-02f, 7.24445805e-02f, 9.24566314e-02f,
  -7.89576024e-02f, 4.63101268e-02f, -7.31987059e-02f, 8.22551847e-02f, 8.37789103e-03f, 2.87002511e-02f, 7.21128955e-02f, -2.40849666e-02f, 8.07883739e-02f, 1.17449969e-01f,
  1.10352233e-01f, 5.09388105e-04f, 9.50494111e-02f, 3.90960611e-02f, 2.18110699e-02f, 1.99158415e-02f, -6.11223541e-02f, -7.80460313e-02f, 4.33114963e-03f, -4.33145911e-02f,
  1.76453050e-02f, 1.37338061e-02f, -1.96944103e-02f, 5.87933548e-02f, -4.99154553e-02f, -4.50541973e-02f, -5.27966805e-02f, -7.32788667e-02f, -1.93474106e-02f, 4.22489308e-02f,
  -3.38714533e-02f, -3.52187268e-02f, -7.48197585e-02f, 9.49312672e-02f, -8.75276253e-02f, -1.46512333e-02f, -3.27952020e-02f, -1.51929175e-02f, -5.53130582e-02f, 4.48936485e-02f,
  -9.44895446e-02f, 3.81440036e-02f, -6.22982252e-03f, 6.72290549e-02f, 7.63639947e-03f, 2.19027307e-02f, 1.02425925e-02f, -2.88812555e-02f, 4.72848527e-02f, 4.88185994e-02f,
  -2.89174914e-02f, -8.85768309e-02f, -7.47257248e-02f, -9.02910382e-02f, -2.00679805e-02f, -3.02474760e-03f, -4.98112775e-02f, 6.60285428e-02f, -7.13610798e-02f, -7.90906139e-03f,
  1.78287122e-02f, 1.58270355e-04f, 3.72945108e-02f, -7.02167600e-02f, 2.93532144e-02f, 6.45771101e-02f, -1.04330674e-01f, -9.85157788e-02f, -1.52756795e-02f, -1.60008371e-02f,
  6.25176132e-02f, 5.72196469e-02f, -8.47955421e-02f, 7.94534106e-03f, -3.29656377e-02f, -3.78849171e-02f, -5.70643432e-02f, -3.63137797e-02f, 3.83506566e-02f, -2.11271904e-02f,
  8.30222815e-02f, -3.33244890e-01f, 3.70209292e-02f, 1.40019760e-01f, -5.64207844e-02f, 1.35425121e-01f, 2.38742039e-01f, -1.43031806e-01f, -1.81055441e-01f, -2.01594263e-01f,
  -6.80122375e-02f, 6.52720183e-02f, 3.79401706e-02f, 5.87999523e-02f, 2.37526670e-01f, -5.95597774e-02f, -1.28115024e-02f, 4.64783646e-02f, -1.10592701e-01f, -6.38277233e-02f,
  3.32829542e-02f, -4.14429940e-02f, 1.07644521e-01f, -4.99426313e-02f, -1.82646252e-02f, -1.09906532e-01f, -3.96673866e-02f, 1.19050452e-02f, -6.58712387e-02f, 1.85303032e-01f,
  -7.69150704e-02f, -9.84946713e-02f, -7.67111555e-02f, -8.44917726e-03f, -1.06674835e-01f, 4.43477780e-02f, 3.59749049e-02f, 1.56937227e-01f, 6.89589903e-02f, 3.93437929e-02f,
  8.96388888e-02f, 2.62590330e-02f, -9.30909738e-02f, 1.96986441e-02f, -1.12520523e-01f, 1.82514600e-02f, 2.21243110e-02f, 2.89666634e-02f, -2.90724672e-02f, -4.84010428e-02f,
  -2.73923553e-03f, -1.18922871e-02f, -1.10541787e-02f, 4.07669274e-03f, -1.42871914e-02f, -6.66483343e-02f, 1.16431877e-01f, 9.20606256e-02f, 7.24759176e-02f, -4.91283685e-02f,
  2.98227761e-02f, -5.30147962e-02f, -4.10129353e-02f, -8.32010508e-02f, -6.25913218e-03f, -1.57238357e-02f, 1.17027005e-02f, 1.48686562e-02f, -2.43026707e-02f, -9.18109063e-03f,
  3.42710130e-02f, -2.90027051e-03f, -4.50176671e-02f, -5.19983582e-02f, 5.01229754e-03f, 2.50147004e-02f, -1.25808902e-02f, -9.60280746e-02f, 2.24461257e-02f, -2.73307338e-02f,
  -4.54551876e-02f, 7.31127113e-02f, -7.40370825e-02f, 9.95930401e-04f, -4.74254973e-02f, 3.17892805e-02f, -2.35421006e-02f, -7.50174895e-02f, -1.60314161e-02f, 8.54325853e-03f,
  -1.45543128e-01f, -7.52464309e-02f, -7.88862556e-02f, 5.06496429e-02f, 1.72759090e-02f, -1.42269954e-02f, 4.94440943e-02f, 1.76343545e-02f, -4.02578153e-02f, 5.64489886e-02f,
  -8.85825381e-02f, 3.81518677e-02f, -8.01405311e-02f, 5.91639578e-02f, 7.91702792e-02f, 3.00340122e-03f, 6.78411424e-02f, 5.74237704e-02f, -8.44617654e-03f, -3.87849696e-02f,
  -1.32696396e-02f, 6.39240667e-02f, -4.02287133e-02f, -2.99878810e-02f, -2.67948397e-02f, 7.98044503e-02f, 7.86818266e-02f, -4.43894863e-02f, -5.67871407e-02f, 6.45789132e-02f,
  5.71948513e-02f, -5.29654436e-02f, 1.43370684e-02f, -5.48132928e-03f, -1.17700651e-01f, -8.58833715e-02f, -1.00905433e-01f, -3.53871919e-02f, 2.48545632e-01f, -9.16591063e-02f,
  -7.62130395e-02f, -3.99228595e-02f, -5.11893518e-02f, -5.93154766e-02f, 5.39889112e-02f, 1.99686676e-01f, 1.09015383e-01f, -2.40966156e-02f, 1.22338742e-01f, -3.78238522e-02f,
  7.54462322e-03f, -9.92636234e-02f, -1.83210522e-01f, -5.25915064e-02f, -2.17648089e-01f, -1.20652325e-01f, -8.43463913e-02f, -1.54390305e-01f, -1.77030072e-01f, -5.15644848e-02f,
  9.52954516e-02f, 8.32299441e-02f, -1.19265974e-01f, -1.40238088e-02f, 4.46487479e-02f, -8.36753994e-02f, 2.18043439e-02f, -2.75764950e-02f, 8.58379900e-02f, 8.46734047e-02f,
  2.77516898e-02f, -3.31053995e-02f, -5.40568270e-02f, -1.23226200e-03f, -7.36383572e-02f, 3.19856592e-02f, 7.34122097e-02f, -2.59356759e-02f, 2.99498159e-02f, 2.99475733e-02f,
  -2.55817901e-02f, 5.95917255e-02f, 7.77590722e-02f, 4.12063412e-02f, -4.32748422e-02f, 8.44367445e-02f, -7.84744993e-02f, -1.98338479e-02f, -2.69684009e-02f, 4.40385044e-02f,
  -8.68084282e-02f, 8.10223296e-02f, -6.54686838e-02f, 1.94474868e-02f, -5.39582036e-03f, 7.83729628e-02f, -5.75819351e-02f, 8.67786035e-02f, 8.18102434e-02f, 4.33161631e-02f,
  1.89043041e-02f, -7.36884549e-02f, 1.46954637e-02f, -4.61119339e-02f, 8.19390416e-02f, 6.45016087e-03f, -4.72031012e-02f, 7.40598142e-02f, -6.38872990e-03f, 7.22834188e-03f,
  -7.32453167e-02f, -6.69125691e-02f, 3.62176672e-02f, 7.55515462e-03f, -6.01401143e-02f, 5.84245101e-02f, 2.06763903e-03f, -1.62941869e-02f, 3.24178636e-02f, -5.59542105e-02f,
  4.84209992e-02f, 5.89977801e-02f, 3.74243855e-02f, -4.93353866e-02f, 4.16606490e-05f, -9.64840353e-02f, -4.31454070e-02f, -4.91178632e-02f, 7.83392712e-02f, -8.21655467e-02f,
  -5.62812388e-03f, 8.08328167e-02f, -1.80011578e-02f, -3.06034125e-02f, -5.13357781e-02f, 4.18760851e-02f, -6.54887334e-02f, 8.50144774e-02f, 3.84605192e-02f, -3.69243845e-02f,
  1.61959752e-02f, 4.22296152e-02f, -2.01398022e-02f, 8.71937126e-02f, 7.87902251e-02f, -6.32941648e-02f, 2.49531604e-02f, 6.00811355e-02f, -6.74458966e-03f, 7.87099823e-02f,
  -2.22719446e-01f, 5.60274087e-02f, -1.52241692e-01f, -1.49232773e-02f, -6.83399290e-02f, -2.30914280e-02f, 4.19704877e-02f, -9.21711773e-02f, -7.49608651e-02f, 1.45253584e-01f,
  1.93659797e-01f, -1.48626447e-01f, 1.53263239e-02f, 1.02699421e-01f, 7.70116597e-02f, 5.79314120e-02f, 1.90822199e-01f, 1.66026503e-01f, 3.77811827e-02f, -9.68290791e-02f,
  -1.69540457e-02f, 1.23774841e-01f, -1.28841419e-02f, -1.14049777e-01f, -9.86399949e-02f, -5.27160652e-02f, -6.12691008e-02f, -4.69084866e-02f, 9.47859660e-02f, 2.15359367e-02f,
  -7.25160837e-02f, 1.88294295e-02f, 1.23575181e-02f, 2.14249976e-02f, -8.88052955e-02f, -2.61753220e-02f, 2.89152842e-02f, -4.53650877e-02f, 3.06456350e-02f, -4.10806723e-02f,
  -3.74130607e-02f, 9.05924849e-03f, -5.79094216e-02f, -7.36281369e-03f, -4.38258909e-02f, 6.53968006e-02f, -3.56221944e-02f, 4.13580146e-03f, -8.91397968e-02f, -1.17853750e-02f,
  6.64228126e-02f, 6.84026778e-02f, 1.05689846e-01f, 8.34950507e-02f, -2.28622574e-02f, 6.35763854e-02f, -9.73792374e-03f, -5.10447696e-02f, -6.19652160e-02f, 2.68379822e-02f,
  2.14305869e-03f, -5.26591875e-02f, 3.49473879e-02f, -6.57959059e-02f, 4.92004957e-03f, 4.79496196e-02f, 7.71305114e-02f, 8.88826102e-02f, 2.70191021e-02f, 6.08707480e-02f,
  9.72634554e-03f, 3.16654332e-02f, 1.55275734e-02f, 6.53434098e-02f, 7.83787742e-02f, 8.83560553e-02f, 4.32144292e-02f, -7.48192295e-02f, -3.69186653e-03f, 3.96575704e-02f,
  -5.83077483e-02f, 5.83004430e-02f, -2.01725774e-02f, 4.80395593e-02f, 3.97835337e-02f, 5.45235835e-02f, 3.61260660e-02f, 4.51627821e-02f, 7.21566305e-02f, 2.75077671e-02f,
  -1.55100659e-01f, -1.38291389e-01f, -6.14404418e-02f, -9.48017836e-02f, -2.98402179e-03f, 8.18973184e-02f, -6.18664771e-02f, -8.45631808e-02f, -2.46765353e-02f, -4.44202907e-02f,
  3.21155787e-02f, -2.67242035e-03f, -8.35119933e-02f, -8.85687675e-03f, 8.16860199e-02f, -2.81195547e-02f, -2.71203965e-02f, -3.14040855e-02f, -2.12586783e-02f, -2.86846813e-02f,
  7.17798024e-02f, -5.32918312e-02f, 1.27545604e-02f, 2.45778426e-03f, -6.57221675e-02f, 1.38292154e-02f, -8.28690752e-02f, -8.52811038e-02f, -9.31554586e-02f, -7.92997330e-02f,
  -4.42995168e-02f, 1.53697934e-03f, 8.86230320e-02f, -1.04232207e-01f, -3.49518731e-02f, 5.02477400e-02f, -4.81117927e-02f, -1.66557163e-01f, -1.31517136e-02f, -8.27304646e-03f,
  -2.51012109e-02f, -1.97673719e-02f, 1.78415239e-01f, 1.17209954e-02f, 1.32194161e-01f, 2.61046410e-01f, -9.55364015e-03f, 3.01722493e-02f, -7.84200877e-02f, -1.20706484e-01f,
  -6.00168072e-02f, -1.38721570e-01f, 1.46577746e-01f, -6.62775338e-02f, -1.37363717e-01f, -2.15357058e-02f, 2.48257164e-02f, 3.75129543e-02f, -3.19009833e-02f, 3.19396593e-02f,
  -1.39142424e-01f, -1.19652972e-01f, -7.12532252e-02f, -5.07857790e-03f, -3.70717607e-03f, 1.31658968e-02f, 5.95078357e-02f, -5.71438558e-02f, -2.69943271e-02f, -1.87088866e-02f,
  4.77732234e-02f, -8.56153294e-02f, -9.90006328e-02f, 7.51579031e-02f, -1.13808895e-02f, 3.03350240e-02f, -9.65517312e-02f, 3.48838568e-02f, -1.05335400e-01f, -7.76189417e-02f,
  4.23455350e-02f, 4.19602245e-02f, 5.26402704e-02f, 9.89925936e-02f, -6.34147450e-02f, -2.39468645e-03f, -2.41957512e-02f, 3.57412323e-02f, -1.25282243e-01f, -8.17640871e-02f,
  2.61121299e-02f, -8.89016502e-03f, 5.73542388e-03f, -6.59426302e-02f, 3.38866599e-02f, 3.02958190e-02f, -1.30331973e-02f, 5.77056892e-02f, 1.82012655e-02f, -7.64872581e-02f,
  -5.06522097e-02f, -1.60247684e-02f, 6.01266474e-02f, 5.88269085e-02f, -6.74339756e-02f, 4.18436229e-02f, 5.62576987e-02f, -9.65244472e-02f, 7.11772218e-02f, 7.17575327e-02f,
  -1.47359725e-02f, 4.80041876e-02f, 1.80055189e-03f, 7.30755031e-02f, 3.15164290e-02f, 3.87918837e-02f, -2.18239613e-03f, -8.51270370e-03f, -6.25586361e-02f, 5.04850410e-02f,
  -2.25112125e-01f, -1.57909393e-01f, -4.58478145e-02f, -4.40241545e-02f, -9.81817022e-02f, -1.92538109e-02f, -3.02517768e-02f, 2.96115968e-02f, -7.81561360e-02f, 7.98928142e-02f,
  -3.51040321e-03f, -1.71459243e-02f, -1.21583436e-02f, 1.78851988e-02f, -2.61299219e-03f, -2.03490350e-02f, 4.27180640e-02f, -6.64885119e-02f, -7.63660148e-02f, -3.20156775e-02f,
  -2.99882181e-02f, -3.02747153e-02f, -3.36267985e-02f, 6.11894540e-02f, 7.21957982e-02f, -7.89546296e-02f, -3.99367698e-02f, 5.92463501e-02f, 5.97714856e-02f, -2.41356082e-02f,
  7.75051564e-02f, 4.40394133e-02f, -2.78597255e-03f, -6.15168102e-02f, -7.22142011e-02f, 1.46404922e-01f, 1.03261709e-01f, 7.17775896e-02f, 1.33240685e-01f, -4.53868173e-02f,
  -1.07425928e-01f, 8.54700804e-02f, 1.05425067e-01f, 7.24288672e-02f, 1.48519009e-01f, 1.85571853e-02f, 1.21980742e-01f, 6.60733581e-02f, 1.69671420e-02f, 3.60539816e-02f,
  -8.51995721e-02f, -1.04162715e-01f, -9.06261951e-02f, -8.42983201e-02f, -1.70151591e-01f, -7.54165426e-02f, -1.14193916e-01f, -2.58776639e-02f, 1.47396291e-04f, 1.21693268e-01f,
  7.96819702e-02f, 2.01065391e-02f, -1.18574975e-02f, -2.54466552e-02f, -4.85700145e-02f, -9.34227556e-02f, 8.58772174e-02f, 3.16697769e-02f, -2.01229602e-02f, -3.09552997e-02f,
  9.36494172e-02f, -4.47588041e-02f, -4.95234169e-02f, 5.07777147e-02f, -7.83956051e-02f, -9.86214355e-02f, -3.58700044e-02f, -1.25782922e-01f, 3.03978827e-02f, 2.06624232e-02f,
  3.08173113e-02f, 1.58993551e-03f, -7.24136317e-03f, 9.08762589e-02f, 7.24922046e-02f, -3.86824012e-02f, 3.52615826e-02f, -5.34854122e-02f, -3.15571651e-02f, -7.16471970e-02f,
  4.32668254e-02f, 9.55240503e-02f, 3.07122841e-02f, -2.12946422e-02f, 5.36561161e-02f, 6.89277425e-02f, 9.29367635e-03f, -5.39046600e-02f, 1.84383709e-02f, 5.36339916e-02f,
  -5.59789687e-02f, -3.46131325e-02f, -9.29308310e-02f, -9.45302844e-03f, -1.52565921e-02f, -7.41726980e-02f, 1.05764205e-02f, 4.17333655e-02f, -6.88024759e-02f, -1.28352240e-01f,
  9.79573652e-02f, 8.63250494e-02f, 2.96484660e-02f, -1.82901397e-02f, -6.81203604e-02f, 1.67959798e-02f, 4.75715287e-02f, 8.22775364e-02f, -8.65701437e-02f, -6.99107796e-02f,
  8.69392604e-02f, 6.84820209e-03f, 1.97970066e-02f, 8.82365406e-02f, -7.01856092e-02f, -3.74659561e-02f, -4.44214195e-02f, 4.63887006e-02f, 8.35503265e-02f, 3.75876799e-02f,
  -2.34395433e-02f, -1.38241369e-02f, -6.80418685e-02f, -5.09041883e-02f, 3.81070469e-03f, 3.37671977e-03f, -3.32919620e-02f, -1.61475397e-03f, 7.91489929e-02f, 4.08960655e-02f,
  -2.27529581e-05f, 5.48075512e-02f, 2.40647178e-02f, 2.09143516e-02f, -2.90001892e-02f, 3.14107016e-02f, 7.14904740e-02f, -9.28056464e-02f, -1.28877712e-02f, 2.74595642e-03f,
  9.00422782e-03f, 3.07403300e-02f, -1.34976074e-01f, 5.00074290e-02f, 2.36764885e-02f, -6.68690726e-02f, -2.78065260e-02f, 1.21733159e-01f, 9.40781906e-02f, 1.29127353e-01f,
  -7.77755976e-02f, 5.16887233e-02f, 3.43511030e-02f, -1.59700751e-01f, -2.54267991e-01f, -2.33545646e-01f, 2.12061238e-02f, 5.89691335e-03f, -7.61389434e-02f, -3.35617699e-02f,
  -3.98067683e-02f, -8.88141338e-03f, -6.34955913e-02f, 1.63115174e-01f, 2.83513274e-02f, 6.66996557e-03f, -6.58186600e-02f, 1.02639504e-01f, 3.29392776e-02f, -5.63993864e-03f,
  -4.98606488e-02f, 9.30911228e-02f, 2.47439146e-02f, -1.25299452e-03f, -6.41415790e-02f, 7.07107857e-02f, 1.98328793e-02f, 4.86833230e-02f, -7.15962872e-02f, 5.28761558e-02f,
  7.90208280e-02f, 5.20842038e-02f, 7.82012790e-02f, 2.58539170e-02f, 1.04719289e-01f, -1.41894761e-02f, 8.71723425e-03f, -8.58830363e-02f, -4.04043542e-03f, -1.26417296e-03f,
  7.81675652e-02f, -7.02725649e-02f, 5.35841696e-02f, 3.91951576e-03f, 1.85203440e-02f, 7.79471546e-02f, -2.45978050e-02f, -5.00416532e-02f, 5.44080101e-02f, -4.40563299e-02f,
  6.40559196e-02f, 9.27191004e-02f, -7.02754874e-03f, -7.21990988e-02f, -9.38087516e-03f, -2.64638532e-02f, -2.14098524e-02f, 7.44487792e-02f, -2.59666797e-02f, -5.04272245e-02f,
  8.77647772e-02f, -8.84178802e-02f, -2.84725241e-02f, 5.58384657e-02f, 5.65293729e-02f, -7.48145953e-02f, 5.13291694e-02f, 8.87025371e-02f, 2.91933585e-03f, -5.08289076e-02f,
  6.97313473e-02f, -8.84616449e-02f, 9.00374874e-02f, 6.95340708e-02f, -5.83758801e-02f, -6.48983121e-02f, -1.63062278e-03f, 1.48831559e-02f, -7.60287121e-02f, -2.65587028e-02f,
  -2.63065496e-03f, 9.50784534e-02f, 1.14989299e-02f, 7.60730952e-02f, -3.29157151e-02f, 5.35081066e-02f, 7.54498765e-02f, -4.94510718e-02f, 1.17926309e-02f, -6.98788092e-02f,
  9.11505520e-02f, 1.05690315e-01f, 4.48291413e-02f, 2.56160498e-02f, 5.22330031e-02f, -7.99298286e-02f, -6.75499886e-02f, -1.36969835e-02f, 1.20470494e-01f, 1.00605702e-02f,
  -9.91553254e-03f, 8.26445296e-02f, 1.73167083e-02f, -3.11677381e-02f, -4.43501100e-02f, -3.49447802e-02f, -4.06203466e-03f, -1.18584577e-02f, 6.29358292e-02f, -2.58997213e-02f,
  1.63282424e-01f, -1.24028139e-01f, 1.52567893e-01f, 2.50083029e-01f, 9.43226069e-02f, 1.24441413e-02f, 1.25341311e-01f, -7.19703510e-02f, 5.51720783e-02f, -6.66127130e-02f,
  -1.33265808e-01f, 1.18578471e-01f, -3.65398899e-02f, -4.25508209e-02f, -1.42173201e-01f, -2.25142464e-01f, -1.33049279e-01f, 1.54275345e-02f, -4.59866636e-02f, 1.55753624e-02f,
  7.54979327e-02f, -1.24129564e-01f, -2.45846864e-02f, -1.60417899e-01f, 1.53260604e-01f, 1.08070485e-01f, -9.31448564e-02f, 2.53272895e-02f, 8.53966027e-02f, -9.74233150e-02f,
  3.79882157e-02f, 4.02099863e-02f, -1.48038128e-02f, -6.51095510e-02f, 6.27454370e-03f, 7.52417371e-02f, 4.87633161e-02f, 7.46948719e-02f, 1.02899913e-02f, -4.89458628e-02f,
  9.23777893e-02f, -7.99674690e-02f, -2.19769459e-02f, 1.81615800e-02f, 4.90461066e-02f, 6.27220050e-02f, 1.15320601e-01f, 5.11078909e-02f, -1.18244886e-02f, 4.09823842e-02f,
  -1.33210085e-02f, 1.01768449e-01f, -4.38516736e-02f, 6.37094304e-02f, 7.82819539e-02f, 8.88886526e-02f, 3.90900392e-03f, 4.15313840e-02f, 9.09752473e-02f, -7.50744268e-02f,
  1.95079716e-03f, -8.00087154e-02f, -5.64685687e-02f, -1.61301326e-02f, -3.85012142e-02f, 5.43301329e-02f, 6.93056583e-02f, 2.39348561e-02f, -1.77987479e-03f, 6.34812862e-02f,
  -4.83812764e-02f, -5.43284882e-03f, -6.10647425e-02f, -6.61475118e-03f, 5.81027456e-02f, -1.74528565e-02f, 4.62461784e-02f, -6.28181687e-03f, 6.71143308e-02f, -2.80591603e-02f,
  -2.88952608e-02f, 5.38818911e-02f, -6.12531453e-02f, 6.00567386e-02f, 5.31089641e-02f, -8.14129338e-02f, 2.33667996e-02f, 2.34237849e-03f, -6.78944364e-02f, 2.73162383e-03f,
  -1.06428668e-01f, -1.73052460e-01f, 3.69335227e-02f, 4.23300564e-02f, -3.85756753e-02f, 7.85897952e-03f, -2.40417663e-02f, -5.64895337e-03f, 2.32007224e-02f, -4.67111506e-02f,
  1.57474577e-02f, -4.74383269e-04f, -1.08162183e-02f, -7.62143433e-02f, 7.88022019e-03f, -1.17806949e-01f, 3.02675199e-02f, 4.38789167e-02f, 3.16400491e-02f, 2.55919248e-02f,
  2.45360229e-02f, -5.20577133e-02f, -8.22309107e-02f, 2.59427563e-03f, 5.17332852e-02f, 5.13315871e-02f, -5.78904189e-02f, -5.49144335e-02f, 9.49910879e-02f, -4.78644148e-02f,
  2.64880676e-02f, 1.55840339e-02f, 2.80817542e-02f, 1.00362040e-01f, 2.74863839e-02f, 5.47182783e-02f, -9.76345316e-02f, -9.66407508e-02f, -1.28415391e-01f, -9.80071053e-02f,
  6.60993978e-02f, 5.17080836e-02f, -7.52673298e-02f, -2.53309458e-02f, 2.88166311e-02f, -8.57291669e-02f, -3.46347317e-02f, 1.44633919e-03f, -3.22253667e-02f, 6.24543726e-02f,
  1.86662059e-02f, 2.91603226e-02f, 1.73468702e-02f, -1.98592152e-02f, 7.32556581e-02f, 1.64315738e-02f, 7.04815760e-02f, 1.41055174e-02f, 3.28322574e-02f, 9.38251764e-02f,
  -3.33945975e-02f, -5.24499938e-02f, 5.39185070e-02f, -7.77199268e-02f, -5.52244298e-02f, -3.76043171e-02f, 8.56111646e-02f, 3.66032943e-02f, 7.81628117e-02f, -5.17807528e-02f,
  9.00134444e-02f, 5.55649288e-02f, 4.98360842e-02f, -6.08954951e-02f, 8.52034092e-02f, 2.17536241e-02f, -4.68065143e-02f, -8.36815033e-03f, 8.00051764e-02f, 6.16238154e-02f,
  -4.65783738e-02f, 1.01323789e-02f, 6.59001768e-02f, -1.98552888e-02f, 6.81126192e-02f, -8.34743381e-02f, -6.45193383e-02f, 7.02276602e-02f, -7.14460481e-03f, 3.79841514e-02f,
  -1.88725777e-02f, -3.55949923e-02f, 2.42600124e-02f, 5.73485121e-02f, 2.23933905e-02f, -6.74155727e-02f, -6.04657233e-02f, 4.82998192e-02f, -6.16355799e-02f, 1.90625321e-02f,
  9.97667946e-03f, 5.87490946e-03f, -7.04113096e-02f, 3.19627598e-02f, 1.06801267e-03f, -7.96383694e-02f, -1.88566605e-03f, -2.62857229e-02f, 5.42033054e-02f, 2.01178007e-02f,
  1.15070455e-02f, -1.28645934e-02f, 6.80406839e-02f, -5.53736165e-02f, -8.08388367e-02f, -2.63729747e-02f, -5.40408716e-02f, -8.27637464e-02f, 7.01046437e-02f, 9.39803720e-02f,
  8.56915936e-02f, 4.96907299e-03f, -9.57435817e-02f, -5.84844733e-03f, -6.67733923e-02f, 3.31302583e-02f, 6.56638527e-03f, -5.39723672e-02f, -2.95980200e-02f, -9.39251110e-03f,
  -5.86751103e-02f, 7.87942335e-02f, 6.98968321e-02f, -4.50952444e-03f, 6.58129901e-02f, 3.08592748e-02f, 8.28230307e-02f, -5.83088165e-03f, -4.04120497e-02f, -5.82926348e-02f,
  -1.14986515e-02f, 8.12387988e-02f, 6.48705065e-02f, 5.43702208e-02f, 6.01658225e-02f, 3.19833569e-02f, 8.03019777e-02f, -1.47159426e-02f, 1.07601315e-01f, -9.63733643e-02f,
  3.33039075e-01f, 1.46149278e-01f, 1.74425155e-01f, 3.62432808e-01f, -2.83229984e-02f, -1.38076797e-01f, -5.86162433e-02f, 1.06796615e-01f, 2.07625031e-01f, -9.29772556e-02f,
  -5.65455593e-02f, 1.96111739e-01f, -1.92633733e-01f, 1.11759581e-01f, -2.02389002e-01f, -1.69732586e-01f, 4.02558893e-02f, 4.37596552e-02f, 4.97922301e-02f, 1.49457678e-01f,
  3.76183391e-02f, -9.16048735e-02f, -8.06043018e-03f, -1.47484004e-01f, 2.04163700e-01f, 2.53125161e-01f, -7.21382946e-02f, -1.49549589e-01f, 7.37165511e-02f, -1.03881001e-01f,
  4.03790660e-02f, 3.04592736e-02f, 6.57170117e-02f, 4.53041494e-02f, -1.07989972e-02f, 9.45053343e-03f, 4.73201126e-02f, -6.88460395e-02f, 7.26924231e-03f, 7.06356913e-02f,
  6.62100539e-02f, 6.21805862e-02f, 3.00115142e-02f, -1.96434967e-02f, 4.51853126e-02f, 1.28562018e-01f, 7.72415996e-02f, 1.41372189e-01f, 3.32650691e-02f, 3.38182636e-02f,
  1.53941795e-01f, 7.29874820e-02f, 9.92389768e-02f, -3.91969047e-02f, 1.03693992e-01f, 3.37179862e-02f, 8.65094662e-02f, 7.28917792e-02f, 9.96631533e-02f, 3.58515792e-02f,
  -2.72668544e-02f, 1.13991937e-02f, -8.71894509e-02f, -4.25303588e-03f, -9.22735408e-02f, 2.52665449e-02f, -2.87579168e-02f, -1.22484360e-02f, -3.90348732e-02f, 5.19064926e-02f,
  2.72826161e-02f, 8.90295655e-02f, -4.79259714e-02f, -2.63204128e-02f, -2.55357940e-02f, 3.08928583e-02f, 6.42307219e-04f, 1.51096061e-02f, -7.52715161e-03f, 2.75293496e-02f,
  -5.92877902e-02f, -8.39094352e-03f, 3.46845984e-02f, 4.59314510e-03f, -2.66300607e-03f, -2.91135032e-02f, 4.74314839e-02f, 8.85651112e-02f, 5.15935384e-02f, 8.77843425e-03f,
  -1.27232701e-01f, -3.37134581e-03f, -1.23155890e-02f, -3.58886421e-02f, -3.80066447e-02f, 3.09795011e-02f, -4.29297984e-02f, -2.94610374e-02f, -1.16554141e-01f, 5.86601906e-04f,
  6.43792376e-02f, 4.39144038e-02f, 1.43897878e-02f, 1.27725694e-02f, 9.36367782e-04f, 3.98766575e-03f, -3.07668131e-02f, -5.82861789e-02f, 2.65168026e-02f, 6.44617528e-02f,
  5.54810949e-02f, 6.12867102e-02f, -5.33071999e-03f, -3.20306458e-02f, -3.15016918e-02f, -3.79899852e-02f, 4.87506092e-02f, 7.98436254e-02f, -2.57606711e-02f, 1.59597974e-02f,
  1.04017155e-02f, -1.58379480e-01f, -4.08380739e-02f, 1.72951128e-02f, 6.56727329e-02f, 7.81339128e-03f, -2.40547787e-02f, 3.85337099e-02f, 3.01855206e-02f, -1.02187410e-01f,
  8.63917451e-03f, 1.84183381e-02f, 8.35300535e-02f, -9.89803970e-02f, 4.59917672e-02f, 9.66975763e-02f, -1.23186134e-01f, 4.80587333e-02f, -4.82155085e-02f, 1.63969379e-02f,
  3.98568735e-02f, -1.12463892e-01f, -2.89816260e-02f, -1.16405308e-01f, -8.53320137e-02f, -5.34282699e-02f, 1.73829794e-02f, 8.88994783e-02f, -2.94615719e-02f, 6.32338375e-02f,
  -3.03419642e-02f, -1.03909567e-01f, 5.21847531e-02f, -6.93298951e-02f, 5.73923141e-02f, -3.59643204e-03f, -4.34850976e-02f, 8.69765058e-02f, 7.19507337e-02f, 4.24674489e-02f,
  -1.97691713e-02f, -2.06119325e-02f, -7.70906955e-02f, 6.49470165e-02f, -5.50055914e-02f, -1.52538707e-02f, -6.44252673e-02f, 2.29790602e-02f, -6.33466393e-02f, 5.37069626e-02f,
  6.10030396e-03f, 2.04869434e-02f, 1.01764752e-02f, -5.69757074e-02f, 4.38372493e-02f, 2.15443075e-02f, 6.51708525e-03f, -9.17255040e-03f, -5.79487756e-02f, -8.29086080e-03f,
  9.40456837e-02f, -4.10746038e-02f, -1.18692182e-02f, 5.72028644e-02f, 4.89816107e-02f, -2.60479329e-03f, 4.62034158e-02f, 1.66538134e-02f, 9.31960065e-03f, 5.62035628e-02f,
  -8.71901587e-02f, 3.75556834e-02f, -4.10708450e-02f, -3.86584848e-02f, 3.87955979e-02f, 7.45845214e-02f, 4.42330465e-02f, 6.80340976e-02f, -1.36213312e-02f, -2.21320186e-02f,
  -1.53228808e-02f, -8.40182975e-02f, 6.36549480e-03f, -6.12656996e-02f, 4.24467102e-02f, 8.96512121e-02f, -2.94956621e-02f, -4.54331227e-02f, 2.40001585e-02f, 6.37093410e-02f,
  -8.66386592e-02f, -5.95110767e-02f, 2.48282515e-02f, 5.29573224e-02f, -5.23639619e-02f, 2.00185291e-02f, -1.34352464e-02f, -3.70553806e-02f, 5.34719825e-02f, 4.70260764e-03f,
  3.15112956e-02f, -8.34754333e-02f, 2.99950819e-02f, -3.50472443e-02f, 8.75003785e-02f, -1.71333905e-02f, -1.87175330e-02f, -5.73572703e-02f, -4.15272675e-02f, -4.62874360e-02f,
  -2.72177868e-02f, -8.54215249e-02f, 5.93414456e-02f, 6.06666431e-02f, -4.67955135e-02f, -9.45580155e-02f, -3.95751074e-02f, 5.06254770e-02f, 1.04410741e-02f, -1.79488510e-02f,
  -1.56201109e-01f, 1.00998357e-01f, 6.63997978e-02f, -6.66583627e-02f, 4.57825996e-02f, -1.45356759e-01f, -1.31114393e-01f, -5.42637287e-03f, -1.06587484e-01f, 1.35680065e-01f,
  -2.76712999e-02f, -4.50792396e-03f, 8.16040300e-03f, -1.13120355e-01f, -1.03309304e-01f, -3.47715383e-03f, -4.17092592e-02f, -9.28498507e-02f, -2.37517823e-02f, 1.41666621e-01f,
  -2.17051934e-02f, -4.43169400e-02f, 1.26350746e-02f, 5.20313792e-02f, 4.06788066e-02f, -5.84875001e-03f, 2.28350759e-01f, 4.38363664e-02f, -5.35769723e-02f, 4.84549478e-02f,
  1.19399792e-02f, 5.32932505e-02f, -5.41252876e-03f, -4.28807922e-02f, 7.13432282e-02f, 2.48404332e-02f, -5.92916552e-03f, -7.47484267e-02f, 5.72566465e-02f, 4.95443605e-02f,
  5.97424060e-02f, -4.29559723e-02f, 5.86521402e-02f, -8.15687999e-02f, -5.34155630e-02f, -2.91637555e-02f, 5.10735298e-03f, -4.08271775e-02f, -5.98269664e-02f, 1.56375952e-02f,
  -7.46615455e-02f, -8.19986314e-02f, 6.98595820e-03f, -3.87487886e-03f, -2.08433215e-02f, 4.68172766e-02f, -1.91647485e-02f, 1.98529102e-02f, 2.12497264e-02f, -1.14538083e-02f,
  -9.19684581e-03f, -7.49312937e-02f, 4.55135591e-02f, -8.83108079e-02f, -4.57850546e-02f, 7.89112523e-02f, 2.85154041e-02f, 7.90327638e-02f, 3.78023945e-02f, -2.30385289e-02f,
  -3.59968804e-02f, 5.93888797e-02f, -4.41435352e-02f, 2.15384997e-02f, -1.52215932e-03f, -9.71004367e-02f, 4.69433777e-02f, 2.47948687e-03f, 9.14878324e-02f, -6.15848880e-03f,
  -3.69284116e-02f, 6.96158316e-03f, -2.02721693e-02f, 5.16912490e-02f, -1.15836104e-02f, 6.90452829e-02f, 5.99009991e-02f, 5.95730580e-02f, 8.30546916e-02f, -3.02129686e-02f,
  5.63000292e-02f, 1.67432055e-01f, 9.21935737e-02f, -2.73022894e-02f, -4.07590121e-02f, -7.55764470e-02f, 5.82291791e-03f, -4.84111570e-02f, 1.84284858e-02f, 3.86800356e-02f,
  -2.48719174e-02f, 4.37694527e-02f, -6.29245862e-02f, -3.15923691e-02f, 7.01235384e-02f, 8.95137936e-02f, -2.83982940e-02f, 8.18101168e-02f, 7.04940632e-02f, 8.02426338e-02f,
  -2.47508404e-03f, 6.92104548e-02f, -4.34272103e-02f, -4.54839319e-02f, 5.34936506e-03f, 6.78507192e-03f, 6.42250925e-02f, 7.31005967e-02f, -8.08349773e-02f, 8.94593727e-03f,
  -2.73295522e-01f, 2.99894065e-01f, 1.38484955e-01f, -4.58311364e-02f, -1.16934873e-01f, -1.35441124e-01f, 1.35883233e-02f, 1.14855036e-01f, 1.29349083e-01f, 1.79895982e-01f,
  1.15850724e-01f, 8.61182958e-02f, 1.78158626e-01f, 9.21934173e-02f, -1.61965892e-01f, 6.05986118e-02f, -3.99040282e-02f, -9.50778946e-02f, 7.66292512e-02f, 7.76776895e-02f,
  8.24016854e-02f, 3.02658323e-02f, 7.45275468e-02f, 5.12803197e-02f, -5.48917288e-03f, 1.05634173e-02f, -2.53871568e-02f, 7.27128759e-02f, -1.25435367e-02f, 7.37247616e-02f,
  2.45542601e-02f, 1.73368573e-01f, -9.86028016e-02f, -8.28016028e-02f, -1.48249388e-01f, -6.25097230e-02f, -5.20411842e-02f, -9.26802754e-02f, 6.25374541e-02f, -4.11856286e-02f,
  -7.70458058e-02f, -7.29315728e-02f, 1.00811152e-02f, 2.92079756e-03f, -2.57867010e-04f, 7.60782585e-02f, 1.98741313e-02f, -9.10679922e-02f, -2.38439403e-02f, -7.58129582e-02f,
  2.18590908e-02f, 6.00787699e-02f, -1.60339158e-02f, 4.73113284e-02f, -8.64292830e-02f, 7.19241202e-02f, -3.40881795e-02f, -1.04829855e-02f, -5.73678277e-02f, 1.01823267e-02f,
  -4.86299992e-02f, -7.36118406e-02f, 2.05640728e-03f, -6.94570877e-03f, 9.71398056e-02f, 5.24758734e-02f, 4.73210067e-02f, 4.64720502e-02f, -5.86700663e-02f, 9.59756598e-03f,
  -2.83810105e-02f, -4.41578291e-02f, 6.24013171e-02f, -6.95785582e-02f, 6.63921088e-02f, 3.11663970e-02f, -4.96329367e-02f, -1.07535675e-01f, 7.25190341e-02f, -9.09868106e-02f,
  1.08156197e-01f, -7.67699331e-02f, 6.96307197e-02f, -6.14793934e-02f, 2.28327443e-03f, 1.71457529e-02f, -1.62058249e-02f, -2.69033876e-03f, -4.86380374e-03f, 5.15455380e-02f,
  -1.11057408e-01f, 7.84636289e-02f, 1.20150158e-02f, -5.32392561e-02f, 7.69408746e-03f, -7.37364590e-02f, 3.81074008e-03f, 4.66008894e-02f, 5.31289866e-03f, 4.99247611e-02f,
  -1.82931572e-02f, -7.02057779e-02f, -3.21414620e-02f, -5.46735805e-03f, 3.43297701e-03f, 6.49306402e-02f, -5.95313124e-02f, -7.36587867e-02f, -3.93096916e-02f, -8.04917235e-03f,
  -6.26206398e-02f, 9.89023969e-02f, 7.66502395e-02f, -3.17632407e-02f, -2.51493440e-03f, 5.83149903e-02f, -1.20713310e-02f, 9.88614094e-03f, 4.94785681e-02f, -5.07388189e-02f,
  1.04978770e-01f, -1.35712519e-01f, -1.21910334e-01f, 4.22721356e-02f, 1.03301696e-01f, -6.32264614e-02f, 8.89992192e-02f, 9.41503718e-02f, 1.21006727e-01f, -5.34761958e-02f,
  1.01474514e-02f, -1.52387023e-01f, -1.50744140e-01f, 3.33911441e-02f, 2.03343425e-02f, -1.44006357e-01f, 4.07789424e-02f, -4.87791710e-02f, -4.74943817e-02f, 9.60904658e-02f,
  -2.76484247e-03f, 4.36246209e-02f, -1.69108640e-02f, 1.15753263e-01f, 3.41387652e-02f, -3.48923504e-02f, 1.85012762e-02f, 5.40637039e-02f, 9.44524556e-02f, -1.75098479e-02f,
  4.43786308e-02f, -1.82059277e-02f, -2.22084578e-02f, 3.56928855e-02f, -5.16973175e-02f, -3.77223417e-02f, 7.78507367e-02f, 6.69944808e-02f, 9.05183405e-02f, 6.67307153e-02f,
  -1.70487817e-02f, 4.62597087e-02f, -5.17420806e-02f, -6.07777871e-02f, 7.50465840e-02f, 5.17062470e-02f, 4.19690423e-02f, -8.73932913e-02f, -3.19889337e-02f, 1.03360219e-02f,
  -4.83332910e-02f, -5.52078038e-02f, 8.58021006e-02f, 1.55459958e-04f, -3.52402218e-02f, 2.69876849e-02f, -7.24174604e-02f, -9.60104391e-02f, 7.51323551e-02f, -3.54209431e-02f,
  2.22188942e-02f, -2.29605995e-02f, -6.31413683e-02f, 7.71718994e-02f, -8.74840543e-02f, 2.24937890e-02f, -4.73903678e-02f, -3.29673812e-02f, -4.49961126e-02f, -5.50243221e-02f,
  4.72960956e-02f, 4.57430072e-02f, 4.84492742e-02f, 1.05247498e-02f, 6.54068068e-02f, 2.45161727e-02f, -5.14070243e-02f, -5.27023859e-02f, 3.54036805e-03f, 5.72957247e-02f,
  4.30742465e-02f, 2.21721306e-02f, -8.26649293e-02f, -6.14479855e-02f, 9.56546608e-03f, 7.29714008e-03f, 5.00053205e-02f, -3.68439145e-02f, -1.56462402e-03f, 3.23329493e-02f,
  -7.06123486e-02f, 5.70115149e-02f, 1.36057073e-02f, 8.16473886e-02f, -7.50852525e-02f, 9.61892214e-03f, -8.09988827e-02f, -2.48794537e-02f, -6.94780424e-03f, 1.83649603e-02f,
  3.40083279e-02f, -3.82799990e-02f, -5.31468093e-02f, 6.75641447e-02f, -1.00719212e-02f, -2.95919683e-02f, -7.02984035e-02f, 5.89381419e-02f, -1.85482984e-03f, -6.38227016e-02f,
  -4.29428071e-02f, -8.96963403e-02f, 4.29014638e-02f, 1.61368661e-02f, -5.89838326e-02f, 7.91615695e-02f, -2.12679226e-02f, 2.20229365e-02f, -8.83458108e-02f, -6.33253679e-02f,
  4.35329005e-02f, -2.64234599e-02f, -9.06708986e-02f, 1.58280451e-02f, -3.16013992e-02f, -8.06342959e-02f, -2.03228936e-01f, -4.37675975e-02f, 1.30120348e-02f, -1.41758323e-01f,
  -1.26328170e-01f, 7.68024325e-02f, -2.55567282e-01f, 1.57447830e-01f, 1.83379278e-01f, -5.15438206e-02f, 1.51442334e-01f, 8.01541880e-02f, 4.01830971e-02f, -2.63695251e-02f,
  -8.81402753e-03f, 6.62685111e-02f, 3.67593206e-02f, 1.14073224e-01f, 4.72057564e-03f, 1.12636141e-01f, 9.94824097e-02f, -9.82860550e-02f, 1.66758686e-01f, 1.40022427e-01f,
  1.07448451e-01f, 2.48714741e-02f, -8.03812519e-02f, 8.22554678e-02f, 9.05572250e-03f, -2.41549965e-02f, 2.50987485e-02f, -5.34356013e-02f, -4.92098592e-02f, 5.62496670e-03f,
  -7.97586888e-02f, 5.10389656e-02f, 1.17320381e-01f, 7.40982443e-02f, -5.06782299e-03f, 3.57424952e-02f, -2.01242417e-02f, -4.79206480e-02f, -5.53760491e-02f, 3.83425094e-02f,
  -9.68582183e-02f, 8.56647491e-02f, -8.33916366e-02f, -5.01849391e-02f, 7.45744705e-02f, 5.95646650e-02f, -3.88517161e-03f, 1.87650286e-02f, 9.86526161e-02f, 3.56293842e-02f,
  2.17991602e-02f, -4.16140482e-02f, -6.52675107e-02f, 1.37094129e-02f, -6.57070279e-02f, -4.38937210e-02f, 8.01609457e-02f, -3.88296917e-02f, 4.03484236e-03f, -6.69978112e-02f,
  -3.30014080e-02f, -1.01496158e-02f, -1.80944744e-02f, -2.86094546e-02f, -2.17530206e-02f, -7.88624808e-02f, 1.02200340e-02f, -4.96634804e-02f, -9.85516310e-02f, -2.30582599e-02f,
  6.44243881e-02f, 6.85634390e-02f, -7.30265528e-02f, -7.61388019e-02f, -2.98080985e-02f, -5.57955354e-05f, 5.07035106e-02f, 2.61659157e-02f, -1.00291260e-02f, -3.79797406e-02f,
  -3.37917842e-02f, 1.73809696e-02f, -1.98804885e-02f, 5.67613617e-02f, 7.16707855e-02f, 4.72714268e-02f, 2.51366831e-02f, 9.40482169e-02f, 7.50026181e-02f, 3.96550307e-03f,
  7.42546171e-02f, 3.19148712e-02f, -7.62369558e-02f, 2.13432796e-02f, 1.11877851e-01f, 1.84519142e-02f, 7.58526847e-02f, 2.10580193e-02f, -8.06339271e-03f, 9.61691737e-02f,
  2.21805610e-02f, -3.13237980e-02f, 1.33518726e-02f, 4.68154922e-02f, 4.35824580e-02f, 9.89711657e-03f, 1.10429591e-02f, 5.40306009e-02f, 6.14368878e-02f, 6.01738831e-03f,
  7.92654157e-02f, 1.39541045e-01f, 1.95702180e-01f, 2.42464021e-02f, -8.89414027e-02f, -1.46604016e-01f, -1.86117098e-01f, -2.48672031e-02f, -1.91860676e-01f, -5.14101498e-02f,
  -1.02091171e-02f, -1.97919905e-02f, 1.13143921e-01f, 1.86114177e-01f, 2.05058455e-01f, 8.35373774e-02f, 1.47340313e-01f, 6.28867075e-02f, 7.93971121e-02f, 1.96459651e-01f,
  1.10004321e-01f, 6.68803006e-02f, 2.62095749e-01f, 1.52817324e-01f, 9.49082747e-02f, 1.28249213e-01f, 8.02539885e-02f, 4.72944453e-02f, 9.83735323e-02f, 3.54299992e-02f,
  8.06002021e-02f, 1.86292946e-01f, 6.19285330e-02f, -2.52930522e-02f, -4.97310422e-02f, -7.25988597e-02f, -7.71504783e-05f, 5.24615087e-02f, -3.39499675e-02f, 5.27573042e-02f,
  -2.24571079e-02f, 3.98514867e-02f, -1.52306724e-02f, 1.01688048e-02f, -6.03984222e-02f, 1.85134318e-02f, 7.55065531e-02f, -9.95240360e-02f, 2.84422375e-02f, 8.25293735e-02f,
  9.51975882e-02f, 2.49884427e-02f, -8.91272277e-02f, 4.82018618e-03f, 4.54426743e-02f, 1.60690937e-02f, -4.10578176e-02f, 5.04384702e-03f, -7.52502754e-02f, 1.95391979e-02f,
  4.45667160e-04f, 3.12609859e-02f, -3.69103625e-02f, 6.34734109e-02f, -5.51472902e-02f, 6.09483719e-02f, 5.58201261e-02f, 3.99027169e-02f, -2.45848503e-02f, 4.20351662e-02f,
  -4.25290093e-02f, 7.01689199e-02f, -1.08986862e-01f, 3.66577320e-02f, 5.22058792e-02f, 6.09723181e-02f, -2.64485856e-03f, 3.12596783e-02f, 4.77629118e-02f, 1.06431805e-02f,
  2.14268807e-02f, 4.15641703e-02f, 3.93985361e-02f, 1.85010314e-03f, -1.71673968e-02f, -5.06637692e-02f, -5.84214069e-02f, 1.75219197e-02f, 4.10890728e-02f, 8.11875761e-02f,
  1.13481253e-01f, 2.89931327e-01f, 6.65110350e-02f, -3.49836685e-02f, 1.97502561e-02f, 2.73741521e-02f, 3.05581093e-03f, 9.55672413e-02f, -3.75688262e-02f, -1.61890909e-02f,
  -5.74913956e-02f, -2.64744405e-02f, -6.01011841e-03f, -6.94794282e-02f, 6.13658801e-02f, -1.73595157e-02f, 1.35017242e-02f, 5.30465273e-03f, 2.44609676e-02f, 7.66666979e-02f,
  6.91291690e-02f, -8.74897167e-02f, 7.84228295e-02f, -4.49501202e-02f, 1.33053595e-02f, -7.23569393e-02f, -8.57764259e-02f, 3.51791307e-02f, 5.01420274e-02f, 3.40070017e-02f,
  8.96233320e-02f, 1.78362101e-01f, 8.29370841e-02f, -4.57623862e-02f, -1.55362591e-01f, 3.95701267e-02f, -1.12160504e-01f, -5.86700672e-03f, 1.25052586e-01f, 8.01591501e-02f,
  -8.81119743e-02f, 2.30139285e-01f, 7.08749667e-02f, -1.76440030e-01f, 3.73872370e-02f, 5.49670421e-02f, -4.43739220e-02f, -1.15219139e-01f, 6.85438439e-02f, -1.66563809e-01f,
  -1.20059019e-02f, -3.09184521e-01f, -1.13822512e-01f, -1.98202774e-01f, -1.73581794e-01f, -1.02975413e-01f, -1.93839788e-01f, -1.75536707e-01f, -9.96406972e-02f, -8.20190907e-02f,
  -3.12243067e-02f, 6.14240952e-02f, 6.52575344e-02f, 3.47052440e-02f, 3.59623581e-02f, -4.36833799e-02f, -1.03375996e-02f, -9.98470485e-02f, -6.39102310e-02f, 2.06279270e-02f,
  3.14840004e-02f, 3.44426222e-02f, 7.59727741e-03f, -2.11230908e-02f, 5.83566613e-02f, -6.51959404e-02f, -5.98955937e-02f, 1.17297158e-01f, 7.68451914e-02f, 7.09469691e-02f,
  -3.30052860e-02f, -3.89610566e-02f, -9.36621949e-02f, -5.23251221e-02f, -2.24740785e-02f, 2.21317168e-02f, 1.04285829e-01f, 3.70759703e-02f, -7.14457547e-03f, 5.85447773e-02f,
  5.64744994e-02f, -7.75672588e-03f, -4.90666404e-02f, -1.01999752e-01f, 4.50439118e-02f, -7.42073283e-02f, 7.36430138e-02f, -8.33134577e-02f, -5.44879884e-02f, -8.73593092e-02f,
  8.87743849e-03f, 1.19886464e-02f, -1.11228384e-01f, 1.53190717e-02f, -8.99124593e-02f, 7.06878901e-02f, 7.83670787e-03f, 1.98606085e-02f, -3.12509052e-02f, 3.94451208e-02f,
  -8.50544572e-02f, -9.00089275e-03f, -7.13482499e-02f, -7.43770152e-02f, 2.90138833e-03f, -8.61485824e-02f, -1.02274239e-01f, -7.81221315e-03f, -2.69025117e-02f, -3.83245870e-02f,
  1.00406118e-01f, -3.93233402e-03f, 6.38596117e-02f, 6.61832392e-02f, -6.53316528e-02f, -1.01676596e-04f, 3.11393086e-02f, 2.74979584e-02f, 1.57414358e-02f, 2.68869512e-02f,
  1.37271304e-02f, -2.24362910e-02f, 3.15973163e-02f, 6.87632188e-02f, 4.60809395e-02f, -3.18170898e-02f, -1.04131520e-01f, -2.33221557e-02f, -3.84213366e-02f, 7.24581331e-02f,
  -1.10776447e-01f, -4.87517789e-02f, 2.42990833e-02f, -3.31097655e-02f, -2.67376620e-02f, -7.20949546e-02f, 3.90707366e-02f, 2.28193845e-03f, -2.70807892e-02f, -4.81411293e-02f,
  -4.35419604e-02f, 1.84923172e-01f, -8.71852040e-02f, -1.40644222e-01f, -3.08877639e-02f, -1.05634481e-01f, -7.41232932e-02f, 4.78853509e-02f, 4.28393279e-04f, 1.64235130e-01f,
  -6.08465336e-02f, 1.19469278e-01f, 1.05886184e-01f, -2.86636055e-02f, -2.43530780e-01f, 1.26827434e-01f, -8.98785517e-02f, 3.11066192e-02f, 9.79649872e-02f, 4.16769870e-02f,
  -1.38140783e-01f, 2.76637431e-02f, -1.52409123e-02f, 5.86780682e-02f, -8.83081928e-02f, 8.95984918e-02f, -1.56494007e-02f, 2.50876378e-02f, -6.45043626e-02f, 3.94148566e-02f,
  -6.94770738e-02f, 9.72424820e-02f, 9.03076902e-02f, -4.48734984e-02f, -7.28917420e-02f, 3.84289958e-02f, -1.63428094e-02f, -8.66676420e-02f, -2.61209942e-02f, -1.69501007e-02f,
  -5.81229441e-02f, 2.40023695e-02f, 6.40215725e-03f, -3.51919718e-02f, -6.08026013e-02f, 3.31251509e-02f, -7.61098638e-02f, 5.26193820e-04f, 3.75960930e-03f, -3.43957394e-02f,
  2.32185107e-02f, -2.10696273e-02f, -3.21240048e-03f, -6.11310033e-03f, -6.27916977e-02f, -4.17646728e-02f, 1.77226067e-02f, 3.30069065e-02f, -8.49212855e-02f, 1.36140585e-02f,
  -2.80074235e-02f, -5.20081818e-02f, -7.35805603e-03f, -1.83667280e-02f, -1.61672831e-02f, -8.00672395e-04f, 9.23615228e-03f, 5.29417060e-02f, 3.10073048e-02f, 7.91395903e-02f,
  -2.94619054e-02f, -3.79227251e-02f, -5.82374297e-02f, 5.90943620e-02f, -8.08161944e-02f, -4.57140021e-02f, -8.84196609e-02f, -8.79847184e-02f, -2.21367851e-02f, -5.84738180e-02f,
  1.77645013e-02f, 4.02065180e-02f, -3.15501727e-02f, -3.03232446e-02f, -1.17646554e-03f, 8.21287632e-02f, 7.77772218e-02f, 2.86519639e-02f, -2.15614289e-02f, -8.39513466e-02f,
  4.68033999e-02f, 4.55794297e-02f, 2.66450364e-02f, -3.54848430e-02f, 1.49291232e-02f, -2.61193956e-03f, -7.06509203e-02f, 3.02640349e-02f, -5.30784130e-02f, 9.46450396e-04f,
  -8.07792321e-02f, 5.26074134e-02f, -5.79713956e-02f, -5.65591604e-02f, -6.76190481e-02f, -5.40509596e-02f, 6.50156438e-02f, 1.05001722e-02f, -3.81480716e-02f, -1.96568109e-02f,
  -5.00410385e-02f, 2.03130767e-02f, 4.69520390e-02f, 5.45668118e-02f, 2.24928055e-02f, 4.08894904e-02f, -6.20924458e-02f, 5.34638576e-02f, 1.99575312e-02f, 6.16240501e-02f,
  3.97773907e-02f, -2.89622750e-02f, 3.07806097e-02f, -1.26584396e-01f, 4.09628032e-03f, -6.01232424e-02f, -9.97353941e-02f, 1.02951914e-01f, 7.85450116e-02f, 5.31626716e-02f,
  4.97268103e-02f, 5.29020606e-03f, -6.35138080e-02f, -8.76124352e-02f, -6.33766577e-02f, -4.44006734e-02f, -5.05665280e-02f, -9.56817344e-02f, 6.91950507e-03f, 8.64502192e-02f,
  -5.38424514e-02f, -9.74753499e-02f, -3.68966050e-02f, 3.17506865e-02f, 6.52019083e-02f, 8.13039839e-02f, 3.44535857e-02f, 6.80140853e-02f, -4.63751219e-02f, -8.56191106e-03f,
  4.47145738e-02f, -1.86829008e-02f, 3.76697220e-02f, -5.92032298e-02f, 3.83502841e-02f, 2.70220824e-02f, -6.13022372e-02f, -9.81146097e-02f, 7.41549656e-02f, 4.57032137e-02f,
  4.12621833e-02f, 5.83017804e-02f, 6.21536896e-02f, -8.66933018e-02f, -2.34540403e-02f, -1.77151226e-02f, -6.26718700e-02f, -5.41112460e-02f, -3.81573588e-02f, 7.44017512e-02f,
  3.11956350e-02f, -5.56103028e-02f, 5.53810336e-02f, -6.90596700e-02f, -1.00505557e-02f, -3.74915376e-02f, 7.34607205e-02f, -4.83159535e-02f, -3.82257588e-02f, -6.46889806e-02f,
  7.57983029e-02f, -4.77331243e-02f, -6.69219866e-02f, -8.40790421e-02f, -6.08842261e-02f, 7.10135847e-02f, 9.83959343e-03f, 7.75196329e-02f, -1.42320655e-02f, -4.59691882e-02f,
  5.73446266e-02f, 1.41990616e-03f, 1.07630910e-02f, -8.45066011e-02f, -1.02431802e-02f, -8.69413000e-03f, 3.04503308e-04f, -1.88083500e-02f, 3.85298431e-02f, 1.23377051e-02f,
  -7.55206421e-02f, -6.09119311e-02f, 5.63919172e-02f, -5.45615405e-02f, 7.41790310e-02f, -1.10279303e-02f, -6.02996312e-02f, -3.98440994e-02f, -2.93049421e-02f, -5.68007678e-02f,
  4.42902967e-02f, -4.97089326e-02f, 2.67226920e-02f, -7.26751536e-02f, 2.72197183e-02f, -1.37029300e-02f, -7.19010085e-02f, 8.10958967e-02f, 6.68163747e-02f, 5.40916510e-02f,
  8.00151601e-02f, -9.86943990e-02f, -5.57049066e-02f, 6.73265010e-02f, -9.25745666e-02f, 2.23012380e-02f, -6.97811022e-02f, 1.65053606e-02f, -1.73821133e-02f, -8.41015875e-02f,
  1.53597435e-02f, -1.40045397e-02f, 7.40754232e-02f, 6.79870546e-02f, 6.66137785e-02f, 9.56464857e-02f, 6.62386268e-02f, -7.52504468e-02f, -1.74675696e-02f, 8.34748149e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 104)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 104;
const float L0_fan_Bp_bar_data[] = {
  2.28851274e-01f, -1.71768782e-03f, -2.54162923e-02f, 2.89341845e-02f, 8.08455050e-02f, 4.97589596e-02f, 1.58692196e-01f, 7.01798126e-02f, 2.03517508e-02f, 1.59492224e-01f,
  2.62714416e-01f, 2.95513477e-02f, 2.44490370e-01f, 1.84888780e-01f, 1.23046935e-01f, 1.69282034e-01f, 7.20339417e-02f, 1.15554761e-02f, 6.03762083e-02f, 2.61865050e-01f,
  9.70805585e-02f, 1.31581381e-01f, 8.22738186e-02f, 2.55219281e-01f, 7.59915933e-02f, 1.09907456e-01f, 1.13479033e-01f, 1.38632536e-01f, 2.37643898e-01f, 1.54014394e-01f,
  6.40963688e-02f, 1.30635440e-01f, 1.41587332e-01f, -2.38790084e-02f, 6.04535937e-02f, 2.06673547e-04f, 2.62247711e-01f, 7.87459239e-02f, 1.28140286e-01f, 9.94808972e-03f,
  1.45373955e-01f, 1.51929155e-01f, 1.05675176e-01f, 1.38317823e-01f, 1.97119504e-01f, 3.61301377e-02f, 1.35041595e-01f, 1.71263427e-01f, 7.89479017e-02f, 1.21983871e-01f,
  6.72156289e-02f, 1.41082332e-01f, 4.44859713e-02f, 9.04405639e-02f, 8.99325237e-02f, -3.61611359e-02f, 2.60671675e-01f, 1.85287043e-01f, 1.97616577e-01f, 3.65963839e-02f,
  6.05465993e-02f, 2.29862090e-02f, 5.25318198e-02f, -3.80332358e-02f, -2.58232001e-02f, 9.84500423e-02f, -1.71938092e-02f, 2.36109868e-02f, 6.31125271e-02f, 2.48271748e-01f,
  2.31794287e-02f, 1.30811095e-01f, 1.24306247e-01f, -3.83168086e-02f, 1.51294813e-01f, 1.36547297e-01f, 4.88226004e-02f, 3.38560040e-03f, 9.46068838e-02f, 8.49844143e-02f,
  2.12104768e-01f, 4.31656241e-02f, 1.26742981e-02f, 8.72372836e-02f, 1.84733957e-01f, 7.58702978e-02f, 9.07177106e-02f, 4.51425053e-02f, -2.40675043e-02f, 1.41095757e-01f,
  1.32164031e-01f, 3.03600822e-02f, 1.42119378e-01f, 8.85876268e-02f, 2.47189492e-01f, 5.94981462e-02f, 5.63620180e-02f, 2.38697678e-01f, 4.94805202e-02f, 2.55885106e-02f,
  1.00899739e-02f, 2.05669791e-01f, 1.71185389e-01f, 2.94166580e-02f
};

// L1_linear_W (Shape: 12 x 128)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 128;
const float L1_linear_W_data[] = {
  3.21354941e-02f, -2.15529472e-01f, -3.74134369e-02f, 4.29589190e-02f, -2.63826605e-02f, 5.05754724e-02f, 2.86621414e-02f, -1.31010830e-01f, -2.75491536e-01f, -3.01644117e-01f,
  -2.18578372e-02f, 3.39090191e-02f, 4.42200266e-02f, -2.36995324e-01f, 2.14769855e-01f, -1.34095281e-01f, 8.26191679e-02f, 6.10313900e-02f, 1.40908763e-01f, -3.15750122e-01f,
  2.62216896e-01f, -2.30130866e-01f, 7.33415559e-02f, -8.80477130e-02f, -2.37486348e-01f, 1.12521596e-01f, 8.48861411e-02f, -9.39953551e-02f, -1.08400963e-01f, -2.79402863e-02f,
  -7.92568773e-02f, 1.28071442e-01f, -8.22617561e-02f, -1.29643634e-01f, -1.02180161e-01f, 1.18462462e-02f, -1.31820679e-01f, -2.44971365e-01f, -8.06172087e-04f, -1.06733739e-01f,
  -5.14044091e-02f, 1.26296356e-01f, -9.26895365e-02f, -2.46224642e-01f, -1.18724808e-01f, -5.78106642e-02f, -1.06162637e-01f, -4.16047201e-02f, -1.15928553e-01f, 1.12088598e-01f,
  -2.98171062e-02f, 8.87599468e-01f, 3.83489616e-02f, -3.67874019e-02f, 2.13064834e-01f, 2.26003528e-01f, -7.06158504e-02f, 4.53535095e-02f, 5.33617437e-01f, -3.72770079e-03f,
  -1.79017872e-01f, -1.78001031e-01f, -1.67372227e-01f, -3.28507647e-02f, 1.38832862e-02f, -1.95454042e-02f, 3.09994519e-01f, -4.66323942e-02f, 6.92468807e-02f, -1.52553871e-01f,
  1.58298776e-01f, 2.88161814e-01f, -1.94572166e-01f, -2.62535632e-01f, 4.07181680e-02f, 4.26548645e-02f, -2.61840131e-02f, -2.06245959e-01f, -1.36220967e-03f, 1.44796938e-01f,
  -1.50491759e-01f, 4.58845347e-02f, -1.34281054e-01f, -1.29945010e-01f, 1.88954789e-02f, -8.35017189e-02f, -1.46660343e-01f, -8.84205010e-03f, -1.10837363e-01f, -1.40678927e-01f,
  4.27054614e-02f, -7.94408470e-02f, 1.67312339e-01f, -1.81899950e-01f, -8.12469125e-02f, -1.29998960e-02f, 1.50706351e-01f, 3.17677259e-01f, -7.19738901e-02f, 2.06823364e-01f,
  6.32483363e-02f, 6.04506470e-02f, -1.47055704e-02f, -1.37762219e-01f, 3.88798922e-01f, 3.24179024e-01f, 1.26748355e-02f, -2.93746907e-02f, 2.72755809e-02f, -1.11351930e-01f,
  -3.09668370e-02f, 2.06272490e-02f, 4.31689769e-01f, 1.57532081e-01f, -3.02208513e-02f, -9.87466797e-02f, -1.76093161e-01f, -7.99599662e-02f, -1.98908880e-01f, -7.50218779e-02f,
  -2.72159204e-02f, 1.74779996e-01f, -9.94669497e-02f, -2.11878598e-01f, 7.65900016e-02f, -2.22122326e-01f, 1.19409040e-01f, -1.62313759e-01f, -1.18198292e-03f, 1.48185492e-01f,
  -1.62864536e-01f, -8.27682093e-02f, -1.08878568e-01f, -6.85988367e-02f, 3.98753881e-02f, -3.40189129e-01f, 6.40754625e-02f, 9.84972529e-03f, 4.55033742e-02f, 6.95234165e-02f,
  1.55334145e-01f, 2.92344958e-01f, 8.51042848e-03f, -4.81491297e-01f, -1.49100631e-01f, -1.15006201e-01f, -1.82534441e-01f, -2.84082234e-01f, -1.33223981e-01f, -4.14066851e-01f,
  -3.96671236e-01f, 2.89224628e-02f, -1.63875923e-01f, -1.16618365e-01f, -7.94952661e-02f, -1.34665325e-01f, 1.56905428e-01f, 3.76829743e-01f, -1.46515176e-01f, -1.37433149e-02f,
  2.71155655e-01f, 5.75321820e-03f, -2.72829421e-02f, 1.05347127e-01f, -2.30726168e-01f, -3.52386534e-02f, -1.29483670e-01f, -1.06600717e-01f, -5.70613667e-02f, -6.77484795e-02f,
  -3.86735089e-02f, -1.83612511e-01f, -1.75814584e-01f, -1.09154709e-01f, 1.19183779e-01f, 5.41216612e-01f, 4.53856401e-02f, -2.18990356e-01f, 1.19339228e-01f, 1.98299065e-01f,
  -1.40566811e-01f, 2.72194669e-02f, 5.35927638e-02f, 4.16504703e-02f, -1.70052886e-01f, 4.39494103e-02f, -1.27290800e-01f, -7.04152957e-02f, 2.07758978e-01f, 1.10961348e-01f,
  4.91803549e-02f, -1.22075617e-01f, 8.45889151e-02f, -2.08032280e-01f, -1.22591123e-01f, -8.73648822e-02f, -2.48399917e-02f, -6.88853338e-02f, 4.21738803e-01f, 1.83307573e-01f,
  1.64972037e-01f, 1.12752333e-01f, -1.04174554e-01f, -1.66293144e-01f, -1.64158538e-01f, 2.00746819e-01f, -5.45192882e-02f, -1.69537604e-01f, -1.09398983e-01f, -1.46546945e-01f,
  3.01222056e-01f, 7.40482062e-02f, -2.60919243e-01f, -5.09540588e-02f, 9.18139052e-03f, 6.02875017e-02f, -6.31797537e-02f, -1.49666980e-01f, -6.01603128e-02f, 7.73122683e-02f,
  5.58733463e-01f, 8.45048204e-02f, 5.58142290e-02f, -2.01020688e-01f, 3.20639163e-01f, -7.72084892e-02f, -7.58028403e-02f, 3.80229086e-01f, 8.59724879e-02f, -1.56807944e-01f,
  3.30606103e-01f, 1.59076035e-01f, 4.14511174e-01f, -8.70360881e-02f, -1.18168660e-01f, -1.31695732e-01f, 2.17046872e-01f, -1.43722473e-02f, -1.18877992e-01f, -1.82671338e-01f,
  -7.44732609e-03f, -2.84927934e-01f, 4.15516235e-02f, -1.30903963e-02f, -2.03998610e-01f, 4.77776676e-02f, -6.01045564e-02f, -6.63216561e-02f, -1.73458576e-01f, -1.08443044e-01f,
  1.99526716e-02f, -3.76437679e-02f, 4.37093452e-02f, -1.73922256e-01f, -9.23617855e-02f, -1.06961196e-02f, -8.46147612e-02f, -7.46566281e-02f, -5.63006029e-02f, -2.36235633e-01f,
  -6.78731576e-02f, 6.13499992e-02f, -7.40393996e-02f, -4.05635312e-02f, -2.97070444e-01f, -4.35457975e-02f, 6.85265660e-02f, -1.13231629e-01f, -3.04177523e-01f, -1.28777921e-01f,
  -1.98383629e-02f, -3.33219796e-01f, 2.25739703e-01f, 1.52813336e-02f, -6.81355000e-02f, -6.71730712e-02f, -3.29755694e-01f, 1.21193960e-01f, 2.70588119e-02f, 4.30616885e-01f,
  -1.89751923e-01f, 1.17159471e-01f, 6.62275627e-02f, -3.45117897e-02f, 2.94141565e-02f, 1.87702835e-01f, -1.92601517e-01f, -9.58649144e-02f, 7.04632923e-02f, 1.51641667e-01f,
  4.15327698e-01f, 2.31447890e-01f, 4.19565057e-03f, -1.57901958e-01f, -1.34625599e-01f, 3.29469424e-03f, -1.83712855e-01f, -8.25522542e-02f, 3.96150313e-02f, 3.48272338e-03f,
  -1.65286288e-01f, -2.68274229e-02f, -6.40555471e-02f, -9.96175855e-02f, 4.24751371e-01f, 4.52634878e-02f, 2.73958534e-01f, -2.43093252e-01f, 1.40874013e-02f, 1.07819296e-01f,
  2.95147896e-02f, -1.74839571e-01f, 2.59009432e-02f, -8.59124884e-02f, -9.79970545e-02f, 3.16677243e-02f, 7.26512522e-02f, 3.70501801e-02f, 1.48051471e-01f, -9.35990140e-02f,
  -8.97276103e-02f, -1.80739135e-01f, 1.64047237e-02f, 5.91317192e-02f, -1.79472134e-01f, 1.74573739e-03f, 3.82767528e-01f, 2.68978048e-02f, 5.06419122e-01f, 4.04283643e-01f,
  3.60155106e-01f, -6.79903701e-02f, -1.21303104e-01f, 4.14922386e-01f, 3.41323428e-02f, -6.54937327e-02f, -2.18269870e-01f, -1.12570778e-01f, -6.59910515e-02f, -1.14547245e-01f,
  2.79403552e-02f, 1.45616746e-02f, 2.13988014e-02f, -8.13385621e-02f, -5.58470841e-03f, 1.50582204e-02f, -6.84062541e-02f, -1.46124423e-01f, -6.31999001e-02f, -1.46074221e-01f,
  -6.15401268e-02f, 3.45690106e-03f, -3.80655266e-02f, 7.88159668e-03f, 1.10984907e-01f, -1.49570197e-01f, -7.65022337e-02f, 1.98280454e-01f, -2.40473524e-02f, -1.21201336e-01f,
  -3.02594490e-02f, -1.43867195e-01f, -1.50202900e-01f, -1.15805030e-01f, -2.91356035e-02f, -1.54293135e-01f, 1.87040567e-01f, -1.38671631e-02f, 6.23176210e-02f, -7.69363046e-02f,
  6.55730814e-03f, 1.66409556e-02f, 1.82397552e-02f, 1.48018852e-01f, -3.83379944e-02f, -1.05902560e-01f, -2.04555526e-01f, -2.60076165e-01f, 1.89951345e-01f, 3.57949644e-01f,
  -1.10820876e-02f, -1.31960377e-01f, -2.30921760e-01f, -4.08382341e-02f, 5.57826087e-02f, 3.96635421e-02f, 3.63574401e-02f, -6.75881878e-02f, -1.13010406e-01f, 5.72256185e-02f,
  2.28373799e-02f, -2.68460274e-01f, 1.45086586e-01f, -5.46548851e-02f, -8.29517958e-04f, -2.44713888e-01f, -1.18653104e-02f, 1.26747265e-01f, 7.30116665e-02f, 5.94778769e-02f,
  -7.59972259e-02f, 1.50255367e-01f, 2.48309985e-01f, 4.98330772e-01f, -1.03554735e-02f, -1.33440644e-01f, -1.83891326e-01f, -4.40680504e-01f, -5.97977675e-02f, 3.17054018e-02f,
  -9.85278515e-04f, 1.46888718e-02f, -1.43514991e-01f, -3.20405066e-02f, 4.03221875e-01f, 1.72770545e-02f, -3.34558524e-02f, -1.25209600e-01f, -3.47203642e-01f, -1.70709677e-02f,
  3.36367935e-01f, 3.97111811e-02f, -1.71759844e-01f, 1.15648098e-03f, 9.29144677e-03f, -7.42256865e-02f, -2.13158987e-02f, 2.36411393e-01f, 2.92834282e-01f, -3.85853350e-02f,
  -1.18392363e-01f, -2.73269594e-01f, -1.34113327e-01f, 7.50965104e-02f, -3.85113508e-02f, -1.08613767e-01f, 6.28074348e-01f, -9.73802581e-02f, -7.89173245e-02f, 3.08672756e-01f,
  1.68287441e-01f, 1.59445070e-02f, 3.10104311e-01f, 8.40995088e-03f, -2.83092141e-01f, -1.48637891e-01f, -3.55959423e-02f, 2.18536556e-01f, -1.04095712e-02f, 2.38746956e-01f,
  3.16022383e-03f, -1.68102428e-01f, 3.99330944e-01f, 2.58570820e-01f, -1.79005727e-01f, -2.41303340e-01f, -1.80744976e-01f, -1.47096470e-01f, -4.97363415e-03f, 1.18270293e-01f,
  6.56523602e-03f, -1.13822192e-01f, -1.93627045e-01f, 1.45055307e-02f, -2.84978122e-01f, -2.36438453e-01f, -5.39351776e-02f, 1.63087070e-01f, -1.46555200e-01f, -9.49122459e-02f,
  -1.73108980e-01f, -5.80424443e-03f, 1.54547980e-02f, 6.91125616e-02f, 8.88343379e-02f, -3.55408937e-02f, -1.09656774e-01f, -1.79770559e-01f, 2.76295692e-01f, 5.78410961e-02f,
  -3.66108045e-02f, 1.50343210e-01f, -2.05654010e-01f, 7.59043023e-02f, 1.60419509e-01f, 8.03496167e-02f, -6.06501251e-02f, -1.26202673e-01f, -9.26707536e-02f, 5.95537499e-02f,
  -5.05738594e-02f, -1.23293020e-01f, -1.32955730e-01f, 1.59148797e-01f, -1.87260509e-01f, -1.49493307e-01f, -5.62234148e-02f, -5.07130176e-02f, -5.55253252e-02f, 2.63456106e-01f,
  -1.68484151e-01f, -6.45492226e-02f, -1.53053954e-01f, -7.31945550e-03f, 1.12551361e-01f, 3.26402903e-01f, 5.09878546e-02f, -1.33781552e-01f, -3.74374725e-02f, -1.25918567e-01f,
  2.98838913e-01f, 1.16924219e-01f, 3.26786757e-01f, 1.71089768e-01f, 1.52832136e-01f, 1.89576894e-01f, 1.60424531e-01f, 9.71783400e-02f, 2.00091347e-01f, 2.05634445e-01f,
  -1.08348124e-01f, 1.56268582e-01f, 1.32442325e-01f, 3.24202895e-01f, -7.08144531e-02f, 2.42181376e-01f, 1.91718459e-01f, 8.87549073e-02f, -2.30437696e-01f, -1.74626410e-01f,
  7.78471082e-02f, -1.52273178e-01f, 2.86429316e-01f, -1.21402457e-01f, -4.69516702e-02f, -2.87793845e-01f, 7.79532688e-03f, -3.76194865e-02f, 1.03959911e-01f, -1.29518911e-01f,
  -6.41840696e-02f, -1.53019086e-01f, -1.65668681e-01f, -1.12765066e-01f, -8.97583067e-02f, 2.29873091e-01f, -9.68432575e-02f, 4.80196886e-02f, 7.95529723e-01f, -4.86705601e-02f,
  -7.71692172e-02f, 2.86396503e-01f, -7.94684365e-02f, -1.33459945e-03f, 8.71892348e-02f, 2.53177345e-01f, -1.17171951e-01f, -1.91608578e-01f, 1.16677091e-01f, -1.01778746e-01f,
  -2.95606032e-02f, 1.59369960e-01f, 3.04437988e-03f, 7.42689222e-02f, -1.23813003e-01f, -2.33551696e-01f, 8.95685107e-02f, -1.66973233e-01f, 1.67205065e-01f, -7.01812878e-02f,
  -2.29877885e-02f, 2.06397519e-01f, -2.88430303e-01f, -7.67067075e-02f, -1.19380042e-01f, 2.22915113e-02f, -2.42597565e-01f, -7.01791048e-02f, 1.40557379e-01f, -1.41071260e-01f,
  -5.92854396e-02f, 4.08359952e-02f, -1.98301569e-01f, 4.63377275e-02f, -1.78169593e-01f, -2.38884628e-01f, 6.41860962e-02f, 1.07503735e-01f, -5.72464131e-02f, -2.30362967e-01f,
  7.39160925e-03f, 5.76942861e-02f, 6.47666818e-03f, 6.65495098e-01f, -2.96179708e-02f, -5.23322076e-02f, -2.67192237e-02f, -9.40373633e-03f, -8.07517543e-02f, 1.09431706e-01f,
  -4.40670662e-02f, 1.02455772e-01f, 2.56377429e-01f, -1.14410080e-01f, -1.00081585e-01f, -2.95791119e-01f, -2.53788121e-02f, 1.70634896e-01f, -2.67095208e-01f, -1.73340738e-02f,
  6.18293136e-02f, -8.64524096e-02f, 1.39819281e-02f, 1.00334480e-01f, 3.23635601e-02f, 2.59365678e-01f, -1.90862566e-01f, 4.47170213e-02f, -1.72520727e-01f, -1.14952512e-01f,
  1.44988567e-01f, 4.88110483e-01f, -1.56486169e-01f, -7.10688829e-02f, -5.64014819e-03f, 1.57321885e-01f, 2.20072325e-02f, -1.98457122e-01f, -2.00817838e-01f, -7.08883554e-02f,
  -1.96111664e-01f, 2.62313038e-02f, -1.73757765e-02f, 1.38927281e-01f, -1.31314799e-01f, -2.58661918e-02f, 2.01502711e-01f, 2.63664007e-01f, -4.28008139e-02f, 5.80133982e-02f,
  -2.06172969e-02f, 1.67721644e-01f, -2.37344056e-02f, 1.29842713e-01f, 1.79927051e-01f, -1.75764263e-02f, 1.18225724e-01f, 1.53058738e-01f, -1.13068357e-01f, 3.16913605e-01f,
  3.42532933e-01f, 8.53734091e-03f, 2.92004108e-01f, -1.10746197e-01f, 3.44476104e-01f, 3.93700093e-01f, -2.48594612e-01f, -1.61950946e-01f, -3.33864212e-01f, -4.21188235e-01f,
  3.84781778e-01f, 1.26395315e-01f, -4.35310788e-02f, 1.75662369e-01f, -2.60471348e-02f, -1.21077470e-01f, -1.05700515e-01f, -5.92335202e-02f, -1.88986748e-01f, -1.42462194e-01f,
  -1.41453907e-01f, 5.37218377e-02f, -1.12594537e-01f, -1.86094612e-01f, -7.77880624e-02f, -2.74361428e-02f, -2.52953142e-01f, 7.85351917e-02f, -3.67462635e-02f, -3.77572775e-02f,
  1.21221840e-01f, 1.27846941e-01f, -1.23775452e-01f, -2.04122677e-01f, -6.54912516e-02f, 7.60320062e-03f, -4.06834446e-02f, 6.51402846e-02f, -1.22043476e-01f, -1.91829324e-01f,
  -8.21885318e-02f, 7.78988525e-02f, -2.69179910e-01f, -1.87224731e-01f, 2.01634914e-01f, -2.88213193e-02f, -8.42333511e-02f, 8.54163319e-02f, -1.41132679e-02f, 7.85676166e-02f,
  -1.68505251e-01f, -6.12488240e-02f, 7.89732393e-03f, 6.96392581e-02f, 1.64088026e-01f, 5.83340190e-02f, 1.67152539e-01f, 5.47308773e-02f, -1.84704870e-01f, -1.61135450e-01f,
  -2.21724585e-01f, -2.13243291e-02f, -1.00897238e-01f, 1.02115534e-01f, -1.63517773e-01f, -1.21672861e-01f, 1.39766037e-01f, 1.38732791e-01f, 1.14134848e-01f, 1.02432646e-01f,
  3.48241448e-01f, 5.91517352e-02f, 4.13867295e-01f, 1.16011821e-01f, 3.28676254e-02f, 3.35801542e-01f, -1.13678306e-01f, -2.60091312e-02f, 1.31145999e-01f, -9.48526263e-02f,
  -7.28343502e-02f, 5.23699045e-01f, -1.12766303e-01f, 5.16633213e-01f, 6.29167259e-02f, -2.27145225e-01f, 2.98396260e-01f, -1.23420758e-02f, -2.78073102e-01f, 6.55310601e-02f,
  4.97457348e-02f, 4.14122827e-02f, 2.41090223e-01f, 2.24739816e-02f, -4.75686006e-02f, 1.80156559e-01f, 1.44958287e-01f, 1.20435536e-01f, -1.29162729e-01f, 3.37783783e-03f,
  2.34984793e-02f, 2.13681772e-01f, -1.43508911e-01f, -1.16090655e-01f, 3.51416111e-01f, 6.16643913e-02f, -1.66717947e-01f, -5.18285856e-02f, -2.01156586e-02f, -6.89012036e-02f,
  -8.62889960e-02f, 1.05690576e-01f, 4.87036398e-03f, 2.05869898e-02f, -5.79004698e-02f, 2.84620941e-01f, -4.15450102e-03f, -1.63059197e-02f, -5.88137843e-02f, -1.02321491e-01f,
  7.06412718e-02f, 7.94246867e-02f, 1.06205463e-01f, -4.57555093e-02f, -1.94293544e-01f, 1.54774621e-01f, 9.82408747e-02f, -1.27609938e-01f, -2.14939386e-01f, -2.85717398e-02f,
  3.13258588e-01f, -1.20228946e-01f, -5.59085049e-02f, -1.06833249e-01f, 1.90129846e-01f, -3.57457340e-01f, -3.52509290e-01f, 6.89322427e-02f, -3.58409971e-01f, 5.01159489e-01f,
  3.97436351e-01f, 1.00752607e-01f, 2.99877971e-01f, -8.40088427e-02f, 3.39676403e-02f, 2.29190260e-01f, 2.66385347e-01f, 5.26645593e-02f, -2.84830462e-02f, -1.78037822e-01f,
  -5.97851984e-02f, -5.06637618e-02f, -2.97785848e-01f, -1.31369829e-01f, 1.24033563e-01f, -1.29943609e-01f, 2.89478213e-01f, -1.75069198e-01f, 5.21555692e-02f, 1.69623345e-01f,
  4.00775298e-02f, 5.22991419e-01f, 2.49943599e-01f, -4.91959751e-02f, -8.19828510e-02f, -1.78538024e-01f, 2.76542395e-01f, -1.08199948e-02f, 2.76972018e-02f, -1.57988608e-01f,
  -1.63255244e-01f, 4.47611153e-01f, -3.66062559e-02f, -6.03757165e-02f, 6.46516830e-02f, -1.48679510e-01f, -1.37195095e-01f, -4.35845293e-02f, 2.11634517e-01f, 2.46192679e-01f,
  -1.49845019e-01f, -8.80056098e-02f, -4.72872145e-02f, -1.60712928e-01f, -1.43484235e-01f, -1.77926540e-01f, -2.37609789e-01f, 1.08787581e-01f, -2.15035990e-01f, -6.65109754e-02f,
  7.75144920e-02f, 3.09169620e-01f, 2.50685990e-01f, 1.77792341e-01f, -3.16889435e-02f, 6.78956807e-02f, -1.00654289e-01f, -4.05556262e-02f, 1.20440803e-01f, -2.32894540e-01f,
  1.22100905e-01f, -1.67002946e-01f, -5.27782589e-02f, -1.82052013e-02f, 1.09539576e-01f, 1.37002721e-01f, -7.89867789e-02f, -2.40120627e-02f, -7.54688159e-02f, -5.84068522e-02f,
  -3.15113254e-02f, 4.95068014e-01f, -8.24454352e-02f, 1.21388137e-01f, 1.70207217e-01f, -1.68790489e-01f, -1.27265155e-01f, 3.17643248e-02f, -1.42839611e-01f, -3.99463400e-02f,
  -4.32469957e-02f, 1.26463130e-01f, -1.37130842e-01f, -6.77870214e-02f, -6.78607747e-02f, -1.33837219e-02f, -2.34568834e-01f, 2.31848918e-02f, -1.51961548e-02f, 1.96055114e-01f,
  -6.87011238e-03f, -1.53324366e-01f, -1.68612935e-02f, 4.61373627e-02f, 2.24294052e-01f, -4.89959680e-02f, 3.04351687e-01f, 1.53887654e-02f, -1.04893334e-01f, -1.19804770e-01f,
  2.35925466e-01f, -1.57422617e-01f, -2.07899079e-01f, -6.28543049e-02f, -1.83291748e-01f, 4.59975824e-02f, -1.65062651e-01f, -1.05613068e-01f, -4.82860282e-02f, -1.29166510e-04f,
  -1.19066171e-01f, -6.97336346e-02f, -9.97543260e-02f, -3.36842209e-01f, -1.60981312e-01f, -6.65696189e-02f, -1.15960121e-01f, -1.14634112e-01f, 3.26379873e-02f, -1.25191167e-01f,
  -1.95645243e-01f, 1.81751683e-01f, 1.79476157e-01f, 3.03213716e-01f, -1.60153672e-01f, 2.69129455e-01f, -2.29666993e-01f, -6.07292876e-02f, 1.71231493e-01f, -4.64488566e-02f,
  1.65885195e-01f, 1.43866977e-02f, 7.07858950e-02f, -1.58419982e-02f, -9.01113972e-02f, -7.00680465e-02f, 2.43538931e-01f, -6.14035279e-02f, 9.41123217e-02f, -2.78441217e-02f,
  -1.58583269e-01f, -1.43963480e-02f, 1.52388275e-01f, 3.66384499e-02f, 1.00629300e-01f, -5.17689511e-02f, -2.59893145e-02f, -2.59169806e-02f, -3.46762910e-02f, 1.54079109e-01f,
  2.06827715e-01f, 2.62543112e-01f, -1.15985811e-01f, -1.11213833e-01f, -1.24204688e-01f, -1.02437116e-01f, 9.74924397e-03f, -1.83977827e-01f, -4.10169102e-02f, -1.78472355e-01f,
  5.23766056e-02f, 1.03294514e-01f, 1.76977009e-01f, 3.33262309e-02f, 2.23798659e-02f, -4.37232368e-02f, -9.89462733e-02f, 3.47470716e-02f, 1.08301692e-01f, 2.41355225e-01f,
  -1.00497775e-01f, 3.68441910e-01f, -6.92726597e-02f, 1.70784537e-02f, -8.37104470e-02f, -8.46932083e-02f, 6.81888238e-02f, -1.44632548e-01f, -4.34385352e-02f, -1.29426420e-01f,
  -6.10945299e-02f, 1.41929716e-01f, 5.16019821e-01f, -3.40599418e-02f, 3.60901117e-01f, 1.20714223e-02f, -1.81059510e-01f, 8.52346942e-02f, -1.08110137e-01f, 3.16939324e-01f,
  9.37149581e-03f, 1.86303854e-01f, 1.43654361e-01f, -9.56570581e-02f, 1.94261055e-02f, -9.72777233e-02f, -1.27485126e-01f, -6.51328266e-02f, -1.01342008e-01f, -1.37270570e-01f,
  1.99925169e-01f, -1.10427946e-01f, -1.40076876e-01f, -1.00736208e-01f, 1.96659088e-01f, -1.49977893e-01f, -1.14541218e-01f, -8.48274603e-02f, -9.61986706e-02f, 2.07108855e-02f,
  2.12794617e-02f, -1.49662659e-01f, 2.44969070e-01f, 1.20080769e-01f, -1.34542912e-01f, -8.23648125e-02f, 1.69741027e-02f, 3.00925195e-01f, 3.17122042e-02f, 2.38560081e-01f,
  5.63328452e-02f, -1.36051387e-01f, -5.85183594e-03f, -2.96181906e-03f, -4.44546714e-02f, 1.24182038e-01f, 1.94122624e-02f, -1.95019126e-01f, -1.47489518e-01f, 1.29153877e-01f,
  -6.67630732e-02f, 3.77261907e-01f, 1.35079265e-01f, 4.44890223e-02f, -3.36065553e-02f, -1.81332499e-01f, -1.21000811e-01f, -1.37114376e-01f, -6.44427389e-02f, -1.41525626e-01f,
  4.76784771e-03f, -9.51684788e-02f, -5.13140000e-02f, -5.27805053e-02f, -1.06861636e-01f, -1.03042580e-01f, 1.39918579e-02f, 2.01863915e-01f, -2.71304995e-01f, 2.51998991e-01f,
  2.85766069e-02f, 3.05017173e-01f, 5.61515428e-02f, -2.43238449e-01f, -1.15948863e-01f, 1.43133029e-01f, -4.39693369e-02f, -2.63597816e-01f, -1.34227574e-01f, 2.40579292e-01f,
  2.71344423e-01f, 2.05347478e-01f, 5.64542692e-03f, 4.80260178e-02f, 1.15332909e-01f, -9.74953920e-02f, -1.19134359e-01f, 3.58441472e-01f, 5.89556932e-01f, -5.86833432e-02f,
  -1.70571432e-01f, -7.90782869e-02f, 5.70690148e-02f, -3.77247818e-02f, 4.68106791e-02f, -5.80691583e-02f, -2.37227399e-02f, -1.72472909e-01f, -4.68886308e-02f, -4.13697213e-02f,
  2.19523817e-01f, -8.95008445e-02f, -1.44750968e-01f, 8.32812041e-02f, -1.85771078e-01f, -1.93082243e-01f, -1.04040354e-01f, -5.03993519e-02f, -4.58578877e-02f, -3.85786742e-02f,
  1.06241800e-01f, 1.53284252e-01f, -2.46855319e-01f, -5.54893874e-02f, 1.51274011e-01f, -1.34311378e-01f, -1.51674494e-01f, 2.40840251e-03f, 2.76576549e-01f, 1.10277995e-01f,
  -1.45949915e-01f, 4.10954833e-01f, -6.48158863e-02f, -1.36421889e-01f, 1.83583230e-01f, 6.75053746e-02f, 2.26938322e-01f, 2.31797978e-01f, -2.12421507e-01f, -1.18905246e-01f,
  -3.81899811e-02f, -2.42833863e-03f, -1.16114104e-02f, -3.91113125e-02f, 1.27651557e-01f, -1.67500064e-01f, -1.23843625e-01f, -1.31483302e-01f, 1.87542617e-01f, 2.79357098e-02f,
  -1.83367014e-01f, -2.09723428e-01f, 2.41399482e-01f, 3.57399695e-02f, -1.21161297e-01f, 4.73732427e-02f, -3.52648622e-03f, 4.22709137e-02f, -1.96081940e-02f, -8.79417136e-02f,
  4.15089242e-02f, -1.00210041e-01f, -1.05380431e-01f, -9.06042382e-02f, -3.15918960e-02f, 9.03208330e-02f, -1.09426759e-01f, 1.28968135e-01f, 6.51054308e-02f, -4.75032292e-02f,
  3.70251723e-02f, 9.13278386e-02f, -9.50341895e-02f, -7.76999742e-02f, -9.92222503e-02f, -8.59622657e-02f, -9.94979665e-02f, -3.49370204e-02f, -1.81761593e-01f, -8.89017619e-03f,
  -1.51651680e-01f, 9.81590673e-02f, 2.36462697e-01f, -2.58961562e-02f, 1.86364233e-01f, 2.15115845e-01f, 2.30526291e-02f, 1.17608421e-01f, 5.74747682e-01f, -1.22326531e-01f,
  3.62927443e-03f, 4.21182886e-02f, 3.66777107e-02f, 3.65248173e-02f, 1.39464572e-01f, 9.51127484e-02f, -1.02015316e-01f, 1.45945594e-01f, 1.05645820e-01f, 2.67552882e-01f,
  1.53097868e-01f, 2.54842073e-01f, -7.22763538e-02f, 1.54952426e-02f, 4.04500157e-01f, -2.01182514e-01f, -3.75890061e-02f, -1.38025939e-01f, 3.10877740e-01f, 1.28945902e-01f,
  1.35703608e-01f, -3.20572406e-03f, 5.77159114e-02f, -3.77923511e-02f, 3.31502855e-01f, 3.66736025e-01f, 3.74198973e-01f, -3.44595537e-02f, 1.37173206e-01f, 1.69186424e-02f,
  9.35948715e-02f, -1.32591113e-01f, -9.57801342e-02f, 5.04837260e-02f, -8.02920833e-02f, 1.72259897e-01f, -1.57419160e-01f, -7.60887265e-02f, -1.55721471e-01f, 3.17226574e-02f,
  4.53716040e-01f, -3.48858051e-02f, -1.30771548e-01f, 7.26800635e-02f, 2.03984395e-01f, 1.03427656e-01f, -1.65312439e-01f, -1.70630202e-01f, -9.57536772e-02f, -1.86902374e-01f,
  -1.82309598e-01f, -9.85673517e-02f, 1.64056588e-02f, 8.48950893e-02f, -1.70150861e-01f, -5.55083808e-03f, -1.09357350e-01f, -1.22488923e-01f, 2.21717525e-02f, -8.70371312e-02f,
  -1.34779558e-01f, -7.17383251e-02f, -1.31728560e-01f, -1.25168428e-01f, 1.84599310e-02f, -4.95559759e-02f, -7.92739838e-02f, -1.77157208e-01f, -8.00337717e-02f, 1.02947373e-02f,
  -1.80915609e-01f, 7.21683502e-02f, -1.81825206e-01f, 1.51183084e-01f, -5.02130315e-02f, -1.55480519e-01f, -4.76081856e-02f, -1.15849555e-01f, -8.77123401e-02f, -8.21934342e-02f,
  4.80598360e-02f, -3.27250399e-02f, -1.04545448e-02f, 2.50455886e-01f, -1.96594343e-01f, -1.36158109e-01f, 2.51772791e-01f, 4.33364511e-02f, 4.71921027e-01f, -1.30419388e-01f,
  -1.70340557e-02f, 3.15764725e-01f, 5.04782237e-02f, -1.46969140e-01f, -1.87919870e-01f, -1.19852088e-01f, -1.92745984e-01f, -7.19993841e-03f, -2.38006413e-01f, -1.51306674e-01f,
  6.51227415e-01f, -8.73293057e-02f, 7.47823296e-03f, -7.07592443e-02f, -1.88611984e-01f, -9.21749398e-02f, -2.32605338e-01f, -1.99483201e-01f, -1.37745887e-01f, 3.16228047e-02f,
  3.93246144e-01f, -1.12476349e-01f, 5.34688413e-01f, -1.57268330e-01f, -3.26412432e-02f, 2.12008759e-01f, 9.76015702e-02f, -1.54900908e-01f, 1.46937385e-01f, 1.21149570e-01f,
  -2.51008540e-01f, 2.25912109e-01f, -1.17876127e-01f, -1.65284261e-01f, -7.35141411e-02f, -1.69525519e-01f, 1.21372389e-02f, -6.81471303e-02f, -1.14627175e-01f, -9.52114761e-02f,
  -8.35924968e-02f, 1.36661366e-01f, 6.22782158e-03f, 5.14998622e-02f, 1.37415845e-02f, 1.82496682e-01f, -2.62051761e-01f, 2.63172477e-01f, 1.19517475e-01f, 1.43341869e-01f,
  -8.41747448e-02f, 4.71574590e-02f, -4.26344097e-01f, -1.01420023e-01f, -2.80009359e-01f, -2.71720022e-01f, -1.48769766e-01f, 2.43707821e-02f, 4.99267012e-01f, 1.26343742e-01f,
  -9.57874805e-02f, -5.41421399e-02f, -4.53623503e-01f, -2.14518622e-01f, -1.62036359e-01f, 3.01104374e-02f, -1.08206116e-01f, -2.22320599e-03f, -1.82181485e-02f, -3.93208973e-02f,
  -7.80115798e-02f, 4.45989035e-02f, 1.11493051e-01f, -7.31821433e-02f, 4.54266280e-01f, -1.00892097e-01f, -1.78518593e-01f, 4.37552780e-01f, -8.20888057e-02f, 1.43231601e-01f,
  -1.00064412e-01f, -1.34935185e-01f, 1.86397463e-01f, -9.54790264e-02f, 9.52855796e-02f, 3.86608131e-02f, 2.48709738e-01f, 3.56078297e-01f, 3.40834633e-02f, 2.61616588e-01f,
  2.97159422e-02f, -2.26299167e-01f, 5.93369544e-01f, 3.69679630e-02f, 3.79272401e-02f, -3.66929062e-02f, -1.04677506e-01f, -3.10514518e-03f, -2.43803367e-01f, -1.85412347e-01f,
  3.36329520e-01f, 2.41618184e-03f, 2.00510576e-01f, -2.45552901e-02f, -1.82843134e-02f, 2.04571396e-01f, 8.04035552e-03f, 1.07425526e-01f, 1.10451020e-01f, -1.98252827e-01f,
  -1.87695146e-01f, -1.67436451e-01f, -4.36967015e-02f, -2.28026703e-01f, -7.63075193e-03f, 2.20129117e-01f, -5.06938212e-02f, -1.83545649e-01f, -8.27941000e-02f, 6.22611195e-02f,
  -9.11946893e-02f, -3.63888890e-02f, -9.06401351e-02f, 3.16178687e-02f, -1.16529509e-01f, -1.32635878e-02f, -1.70267403e-01f, 4.73042019e-02f, 1.54349014e-01f, -7.99680054e-02f,
  -6.16213679e-03f, -1.48190022e-01f, -3.28425653e-02f, -2.31945962e-01f, 6.92564920e-02f, 3.48240323e-02f, -1.75816745e-01f, 5.88644631e-02f, -8.76102522e-02f, 7.20205456e-02f,
  1.50491059e-01f, -1.02034122e-01f, -5.78832552e-02f, -1.56606272e-01f, 2.97393203e-02f, -1.26392528e-01f, 1.01240557e-02f, -8.12334418e-02f, 1.21149205e-01f, 4.90730815e-03f,
  -1.06891550e-01f, -1.51031986e-01f, -8.26399773e-02f, -1.73440933e-01f, -1.83998868e-01f, 2.17714891e-01f, 1.10150695e-01f, 9.45322439e-02f, -5.89806363e-02f, -4.53302227e-02f,
  2.17004448e-01f, -2.93133974e-01f, 9.30622220e-02f, -1.89160287e-01f, -3.19802284e-01f, -2.09989801e-01f, -1.57964062e-02f, 1.08029865e-01f, 1.66519880e-02f, 1.76910535e-02f,
  1.44467339e-01f, -4.04437035e-02f, 4.33566645e-02f, 7.23241121e-02f, 1.79625690e-01f, -4.76013906e-02f, 9.95956361e-02f, -2.33480722e-01f, 9.11822915e-02f, 1.25612900e-01f,
  -3.64243060e-01f, 1.61098972e-01f, -3.63746248e-02f, 1.18641838e-01f, -2.80438691e-01f, -1.48306742e-01f, -7.35257939e-02f, 3.32996339e-01f, 1.79730251e-01f, 4.59459424e-01f,
  2.81294614e-01f, 2.86359966e-01f, -1.08767226e-01f, 7.47804120e-02f, -1.08221374e-01f, 1.18473619e-02f, 6.58253254e-03f, -2.44682189e-02f, 5.22479452e-02f, 2.45640706e-02f,
  -1.35618195e-01f, -2.32334975e-02f, -1.74928218e-01f, -9.42911431e-02f, -1.25661269e-01f, 5.04607428e-03f, -1.65723085e-01f, 3.90176743e-01f, 4.45045501e-01f, 8.72335210e-02f,
  1.33876652e-01f, -1.53801233e-01f, -1.33844227e-01f, 1.42163441e-01f, -1.31280094e-01f, 5.79449162e-02f, -1.39170274e-01f, 1.14182353e-01f, -3.77432592e-02f, -2.71196604e-01f,
  -2.53507886e-02f, -6.14839122e-02f, -1.15505882e-01f, -2.64174696e-02f, -6.38452545e-02f, 2.10501909e-01f, 1.04675211e-01f, 5.35130792e-04f, -4.46437895e-02f, -2.47699092e-04f,
  -1.28806129e-01f, 2.12544948e-02f, 2.24156007e-01f, -1.24695040e-01f, -1.69958323e-01f, -1.04596980e-01f, 3.38662475e-01f, 3.55900496e-01f, -1.36001498e-01f, -1.39688522e-01f,
  -1.64928004e-01f, -1.86487436e-01f, -1.49397925e-01f, -1.39972083e-02f, 1.02204479e-01f, -1.32137779e-02f, 3.95371765e-03f, 2.13060364e-01f, 4.21472013e-01f, -1.76014990e-01f,
  1.83049873e-01f, -5.96822575e-02f, -2.51754690e-02f, -1.55631498e-01f, -1.29291624e-01f, -1.44280702e-01f, 2.26141308e-02f, -6.22889725e-03f, -6.66017979e-02f, -1.52890477e-02f,
  -6.83641732e-02f, -1.57656491e-01f, -1.17865138e-01f, 1.57733917e-01f, -1.31148621e-01f, 5.44593530e-03f, -1.94684476e-01f, -5.40762469e-02f, -3.48148897e-04f, 2.72174813e-02f,
  -1.92924663e-01f, -9.04042274e-02f, -8.33377242e-02f, 5.86904474e-02f, -2.18613427e-02f, 2.56932497e-01f, -1.02723509e-01f, 2.33203620e-02f, -8.33521783e-02f, -8.64874125e-02f,
  -1.32012293e-01f, -1.06341198e-01f, -5.16008213e-02f, 1.29552081e-01f, 3.48224699e-01f, 8.68302211e-02f, 6.85789287e-01f, -1.41779259e-01f, -8.48544762e-02f, 1.61190368e-02f,
  -1.36447370e-01f, 9.79505293e-03f, -1.83593458e-03f, 2.71067023e-01f, 7.86961839e-02f, 8.88747126e-02f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -1.23655871e-01f, -2.17107069e-02f, -1.55984327e-01f, -6.88749924e-02f, 1.06638782e-01f, 3.50830844e-04f, 1.25328258e-01f, -1.64714202e-01f, -5.63692451e-02f, -2.14080326e-02f,
  4.73192781e-02f, 3.42592667e-03f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 12, 104
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        128, 12
    );
    }
    