/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  3.07670712e-01f, -5.25158405e-01f, 3.29844028e-01f, -3.52038354e-01f, 1.01291120e-01f, -2.99692303e-01f, 4.44087833e-02f, -4.93904911e-02f, 3.08532789e-02f, -2.67329991e-01f,
  -3.40613276e-02f, 6.18514828e-02f, 8.62124637e-02f, -3.73197109e-01f, 1.79493099e-01f, -9.59207416e-02f, -2.41904959e-01f, -1.06971182e-01f, 4.70748767e-02f, -1.44263387e-01f,
  5.38581349e-02f, -2.81308711e-01f, 7.37745166e-02f, -1.56428248e-01f, -3.36236618e-02f, 4.05370407e-02f, 4.48926091e-02f, 1.20773554e-01f, -1.35686442e-01f, 3.23459283e-02f,
  -5.26054986e-02f, -5.09171411e-02f, 3.30150016e-02f, 3.50407586e-02f, 9.91764665e-03f, 9.42125544e-03f, -9.32179298e-03f, 7.32114613e-02f, 3.44166122e-02f, 4.22781147e-03f,
  -1.95309874e-02f, 6.86167702e-02f, -1.29214115e-02f, 3.27831320e-03f, 4.09790017e-02f, -1.55420145e-02f, 3.05192787e-02f, -1.47624528e-02f, 6.21921942e-03f, 1.85534768e-02f,
  -8.69842805e-03f, 2.89291162e-02f, -3.88868041e-02f, -1.42666698e-02f, 4.63512614e-02f, -2.72551924e-02f, -1.63795594e-02f, 9.00441185e-02f, -2.59710732e-03f, -5.69535978e-03f,
  -5.35911545e-02f, 5.77916391e-02f, -2.39062291e-02f, 1.18570421e-02f, -4.47512530e-02f, -2.14596223e-02f, -5.27983494e-02f, 1.34398108e-02f, 4.77137081e-02f, -6.06617182e-02f,
  -3.14655639e-02f, -4.40662242e-02f, -1.20036630e-03f, -1.10896714e-02f, -1.36771183e-02f, -4.29496467e-02f, 2.09077261e-02f, 1.75390218e-03f, 2.50914227e-02f, -1.95716731e-02f,
  -2.27401424e-02f, -1.14554390e-02f, 1.04234498e-02f, -6.10450134e-02f, -3.18168825e-03f, 5.43278456e-02f, 7.90300034e-03f, 1.43290067e-03f, 2.30061114e-02f, 2.03984957e-02f,
  -1.72085911e-01f, -1.59961402e-01f, 1.62962284e-02f, -8.41143914e-03f, -9.06665530e-03f, -4.27072868e-02f, -3.00599523e-02f, -2.62611248e-02f, -1.42367976e-02f, 2.42028069e-02f,
  -1.22660939e-02f, 5.87302726e-03f, -1.98606420e-02f, -1.87189393e-02f, -6.96793757e-03f, -2.40438506e-02f, -5.56182973e-02f, -6.84401602e-04f, -3.56309279e-03f, 5.92353148e-03f,
  -2.05370989e-02f, -9.45675001e-03f, 6.63351789e-02f, -1.13540916e-02f, -3.74941118e-02f, 4.38951747e-03f, -3.47746245e-04f, -1.95398480e-02f, 9.01403197e-04f, 3.71670276e-02f,
  -7.06841111e-01f, -1.91505075e-01f, -2.37437651e-01f, -3.91738653e-01f, 4.18153815e-02f, -1.35685727e-01f, -1.78174257e-01f, -1.31196320e-01f, -3.29423547e-01f, -7.94200525e-02f,
  7.22068101e-02f, -1.23059876e-01f, 1.92704815e-02f, -2.81596798e-02f, -4.26404141e-02f, 4.93245237e-02f, -2.04728410e-01f, -6.61386549e-02f, 8.65921378e-03f, -1.11773267e-01f,
  -6.70048222e-02f, 1.20040573e-01f, -3.89585420e-02f, 1.43209711e-01f, -7.04076439e-02f, -6.57646507e-02f, 1.01595730e-01f, 8.40864107e-02f, 5.88739999e-02f, 4.62181419e-02f,
  1.24980710e-01f, 6.05051517e-02f, -4.34632301e-02f, -1.51344072e-02f, -2.58363634e-02f, -9.99001972e-03f, -3.72676887e-02f, 3.53515409e-02f, 1.95826944e-02f, -1.60449427e-02f,
  -3.72318202e-04f, 6.10138848e-03f, 1.74368210e-02f, 3.47112902e-02f, -5.52429669e-02f, -3.32751013e-02f, 2.02327557e-02f, -1.78892184e-02f, -3.49797914e-03f, 1.48394424e-02f,
  -1.88074112e-02f, -6.33520959e-03f, -4.90123481e-02f, 3.69677646e-03f, -1.81649514e-02f, -6.14474528e-02f, 8.77151825e-03f, -3.13778855e-02f, -1.31630199e-02f, -4.51113693e-02f,
  1.72071829e-02f, 1.07574933e-05f, 1.92063302e-02f, 2.55987849e-02f, -3.73448431e-02f, 1.49695957e-02f, 5.98533265e-03f, 1.71877202e-02f, -2.79752612e-02f, 1.90414358e-02f,
  -9.87140089e-03f, -2.34380917e-04f, 7.96411652e-03f, -3.98092940e-02f, 2.24545430e-02f, -6.48289314e-03f, 1.80519391e-02f, 3.31693813e-02f, -4.57198955e-02f, -3.94527912e-02f,
  4.00656201e-02f, -3.40018868e-02f, 1.90617461e-02f, 3.30495574e-02f, -6.55931747e-03f, -1.06685353e-03f, -1.35973860e-02f, -3.12886387e-02f, 5.38019370e-03f, 4.49209809e-02f,
  -1.48678929e-01f, -2.03747138e-01f, 9.45062318e-04f, -1.09051596e-02f, 8.55659880e-03f, -3.85407684e-03f, 2.87242085e-02f, -4.26657386e-02f, -2.86965016e-02f, -1.13564190e-02f,
  -4.48338576e-02f, 7.45054707e-03f, 1.04734115e-02f, 1.75503809e-02f, -3.97433247e-03f, -8.79507791e-03f, -2.05607750e-02f, -2.75639426e-02f, -3.80890407e-02f, -3.31232287e-02f,
  1.57326721e-02f, 1.48230074e-02f, 2.54532378e-02f, 5.05670160e-03f, 4.27368609e-03f, 3.01403012e-02f, -3.54813561e-02f, -1.90832447e-02f, 2.30459757e-02f, 2.36733630e-02f,
  6.35633945e-01f, 1.92549944e-01f, 2.38003463e-01f, 2.86705911e-01f, 1.32214665e-01f, 5.33251651e-02f, 1.18052498e-01f, 4.65929583e-02f, 1.55585870e-01f, -1.11669667e-01f,
  6.83664307e-02f, 2.47040346e-01f, -5.21623380e-02f, 2.77748257e-01f, 3.60033184e-01f, 7.13433996e-02f, 1.06508203e-01f, 6.94455355e-02f, 7.54097328e-02f, 5.21518737e-02f,
  8.36906880e-02f, 1.39545113e-01f, 1.41579613e-01f, 6.45429716e-02f, 5.62073030e-02f, 3.15412804e-02f, -2.32090037e-02f, 2.60097552e-02f, 4.64516319e-02f, 8.65159109e-02f,
  -1.25846863e-01f, 5.22863157e-02f, 7.87872225e-02f, -8.21914151e-03f, 9.05188918e-03f, -1.95820201e-02f, -3.55535522e-02f, 3.15572098e-02f, 9.03437659e-02f, 1.80114228e-02f,
  3.66074741e-02f, 6.15508668e-02f, 8.83940011e-02f, 8.11345782e-03f, 1.68635957e-02f, 2.10917313e-02f, 4.89463024e-02f, -2.49824636e-02f, 1.22147482e-02f, 2.84361504e-02f,
  -1.83316169e-03f, -3.38055752e-02f, 3.87716037e-03f, -3.94197330e-02f, 1.92811887e-03f, -4.49843481e-02f, -3.09021566e-02f, -1.59247573e-02f, 1.54109588e-02f, 2.46231053e-02f,
  -3.87696810e-02f, 4.11358196e-03f, 1.36565240e-02f, -1.39659774e-02f, 1.78864524e-02f, -5.81568806e-04f, 3.84304253e-03f, -8.45935754e-03f, 4.51626144e-02f, 2.25628912e-02f,
  -2.63134893e-02f, 2.07159445e-02f, 1.18485512e-02f, -1.70901965e-03f, 1.60074793e-02f, -5.93556389e-02f, 1.40450289e-02f, 1.12326723e-02f, -1.89667922e-02f, 1.90623607e-02f,
  -1.64646599e-02f, -6.40027039e-03f, 7.32562970e-03f, -3.40907760e-02f, -2.62131132e-02f, 7.74937333e-04f, -1.77156311e-02f, 2.51057534e-03f, -2.09455155e-02f, 2.37891525e-02f,
  -8.38832408e-02f, 3.31000648e-02f, -1.57033708e-02f, 2.05008946e-02f, -6.69301546e-04f, -7.12282397e-03f, 3.46251316e-02f, 9.72488243e-03f, -2.84051877e-02f, -1.59858391e-02f,
  -4.30964753e-02f, -1.56818572e-02f, -5.03603555e-02f, -1.22240372e-02f, -3.99925783e-02f, 1.96679961e-03f, -5.18821664e-02f, -4.93266247e-03f, -2.85095926e-02f, -1.97897758e-02f,
  -1.90954022e-02f, 4.83100861e-03f, 2.45608687e-02f, -2.24163532e-02f, -1.20724803e-02f, 1.29077006e-02f, -2.28444822e-02f, 3.01809888e-02f, -2.35948116e-02f, 2.95475945e-02f,
  6.52189910e-01f, 6.26275986e-02f, -1.54323965e-01f, -1.04379073e-01f, 1.90752279e-02f, -1.65010199e-01f, -1.93273053e-01f, -3.25399972e-02f, -9.41911712e-02f, -6.02360144e-02f,
  -1.93889029e-02f, -8.48166570e-02f, 7.86841586e-02f, -1.50336191e-01f, 1.25017241e-01f, 3.45880426e-02f, -3.56250443e-02f, 1.69750862e-02f, 4.80575897e-02f, 8.27302262e-02f,
  6.45951927e-02f, -6.81702197e-02f, -5.29875532e-02f, -4.36530896e-02f, 1.27420640e-02f, 1.16663426e-02f, 3.44308987e-02f, -3.27225029e-02f, -5.06439395e-02f, -5.42198345e-02f,
  -4.09377180e-02f, 2.27564555e-02f, -8.01545531e-02f, 2.72863749e-02f, -1.55700892e-02f, -7.49936476e-02f, 5.41025735e-02f, -5.32847680e-02f, -1.01945223e-02f, -2.22800206e-02f,
  5.39649650e-02f, -1.45251406e-02f, -7.02850148e-02f, -3.69213521e-02f, 7.46728554e-02f, -2.85335481e-02f, -1.61620099e-02f, -1.04368227e-02f, -4.81371954e-02f, -1.64865386e-02f,
  -5.68116195e-02f, 4.59929695e-03f, -1.19597241e-02f, 1.95253035e-03f, -2.61261612e-02f, 3.47752648e-04f, -2.72498447e-02f, -2.24943124e-02f, 3.64171825e-02f, -1.66081600e-02f,
  5.30697741e-02f, 6.50289431e-02f, 5.64799383e-02f, 2.87834904e-04f, 5.63042909e-02f, 3.15054622e-03f, 5.46978675e-02f, -6.77093049e-04f, -2.74741687e-02f, 5.92685044e-02f,
  5.20153902e-03f, 2.00942513e-02f, 4.78002727e-02f, -2.66506989e-02f, 1.99531205e-02f, 5.69644663e-03f, 3.32128257e-02f, -5.84294414e-03f, 8.44174065e-03f, -4.07267250e-02f,
  -2.14729216e-02f, 4.12651002e-02f, -2.20010057e-02f, 1.71162169e-02f, 4.65697572e-02f, 1.13581037e-02f, -2.85160989e-02f, -2.42844559e-02f, 1.12648094e-02f, 2.97193639e-02f,
  2.08057776e-01f, 1.80472523e-01f, -4.94064763e-02f, -3.27928998e-02f, 6.02356531e-02f, 5.98674454e-02f, -9.55392420e-03f, -2.69428398e-02f, 2.70258933e-02f, 4.37409803e-02f,
  -1.68225039e-02f, 2.14172024e-02f, 6.40309602e-02f, 7.25084841e-02f, -1.41312145e-02f, -2.75394712e-02f, 7.28525594e-02f, 3.68663408e-02f, -1.04263024e-02f, -3.61535558e-03f,
  -4.52834787e-03f, 3.13102938e-02f, 9.41861514e-03f, -2.33135186e-03f, 2.66495533e-02f, 3.83763015e-02f, 2.60045622e-02f, 6.78407087e-04f, 5.34867216e-03f, -1.46206906e-02f,
  1.26464501e-01f, -4.63987812e-02f, -5.49207032e-02f, -1.55599803e-01f, 6.23661317e-02f, 3.74685675e-01f, 2.59061754e-01f, -1.36894703e-01f, 6.65139705e-02f, 2.21563373e-02f,
  5.45574278e-02f, 8.65277946e-02f, 2.02080131e-01f, -4.85273711e-02f, 4.44355637e-01f, 3.77045125e-01f, -2.26688338e-03f, 8.62710476e-02f, 1.77520141e-02f, 1.07854605e-02f,
  -1.65990628e-02f, 4.54361690e-03f, 1.41412178e-02f, -1.20518573e-01f, -1.31095678e-01f, -2.14029193e-01f, -1.36241212e-01f, -1.88176017e-02f, -2.45000184e-01f, 9.92971472e-03f,
  1.34107083e-01f, 9.45377871e-02f, -1.30210012e-01f, 2.98985951e-02f, -2.40479987e-02f, -3.41611020e-02f, 4.35985578e-03f, 2.77622156e-02f, 2.67191343e-02f, 2.68175974e-02f,
  4.73140441e-02f, -2.93580219e-02f, -8.29766393e-02f, 5.14689274e-03f, 1.15908412e-02f, -7.26631880e-02f, -2.25240388e-03f, 3.84891257e-02f, -5.34670390e-02f, 1.55152967e-02f,
  -4.07125466e-02f, 1.24528585e-02f, -2.40527932e-02f, 1.03880130e-02f, -1.66512784e-02f, 1.16447906e-03f, -4.66993731e-03f, 5.14510495e-04f, 1.45878866e-02f, -3.65365595e-02f,
  1.99911254e-03f, 1.73604395e-02f, 8.84235278e-02f, -8.08240008e-03f, 5.98801821e-02f, -6.14044815e-03f, 3.72958444e-02f, -4.08396833e-02f, -2.46791057e-02f, 1.72028039e-02f,
  -1.12507101e-02f, -2.15339288e-02f, 4.83415164e-02f, 3.92027246e-03f, 1.25841275e-02f, 9.76954028e-03f, 1.95703153e-02f, 2.21016631e-02f, -2.48959512e-02f, -6.08994551e-02f,
  -3.11747901e-02f, 2.78892349e-02f, -4.62933909e-03f, -3.39554176e-02f, 6.58825710e-02f, 2.34831236e-02f, -1.16064190e-03f, -2.38682870e-02f, -5.50393993e-03f, 8.40673689e-03f,
  -3.74277984e-03f, -1.53819636e-01f, 9.21003055e-03f, 8.26997962e-03f, 7.96838403e-02f, 4.85446863e-02f, 4.77758460e-02f, -7.51690641e-02f, -1.55492034e-02f, -1.52125617e-03f,
  -3.97020467e-02f, 1.82264228e-03f, 5.03833331e-02f, 2.11155545e-02f, 4.86130230e-02f, 4.43130881e-02f, -5.40741161e-03f, -2.91546620e-02f, -4.18851264e-02f, -8.81504938e-02f,
  -7.97298178e-02f, 6.27136528e-02f, -1.20053987e-03f, -2.31034439e-02f, -2.68505737e-02f, 2.37815641e-02f, -3.03999172e-03f, -5.70162013e-03f, -8.60932190e-03f, 5.47315255e-02f,
  -3.40107158e-02f, -2.55915105e-01f, -1.68983549e-01f, 6.80409046e-03f, -5.78069799e-02f, -1.23267852e-01f, 5.32270260e-02f, -1.53268725e-01f, -2.65928000e-01f, 2.98231058e-02f,
  5.79394512e-02f, 4.87369066e-03f, -7.60748535e-02f, -8.39318708e-02f, 2.98556149e-01f, -7.42300302e-02f, 1.19067110e-01f, 1.75773278e-02f, -1.65627465e-01f, 7.14582652e-02f,
  -9.45560820e-03f, 9.93336365e-02f, 4.95582893e-02f, -3.06267068e-02f, 6.61434233e-03f, -7.79493079e-02f, 4.11792278e-01f, -4.64069732e-02f, 1.52239382e-01f, 1.15917288e-02f,
  -1.51355043e-01f, -2.34812692e-01f, -5.85514717e-02f, -4.01980877e-02f, 1.52388951e-02f, 1.40013443e-02f, 7.56276324e-02f, 3.92167903e-02f, -5.62282093e-02f, -3.34214158e-02f,
  2.58760732e-02f, 1.81186758e-02f, -1.11718103e-02f, -4.16324511e-02f, -6.32435232e-02f, -3.08646522e-02f, 6.09353790e-03f, -6.11814728e-04f, -6.19949363e-02f, -3.70954052e-02f,
  -6.97699040e-02f, -3.05846464e-02f, 6.42260769e-03f, 2.12421007e-02f, -3.44524346e-02f, -2.84764562e-02f, 2.01997198e-02f, 4.38609011e-02f, -2.36007548e-03f, -8.21766909e-03f,
  4.36658263e-02f, 1.45104239e-02f, 3.69311194e-03f, 7.14041851e-03f, -2.79448573e-02f, 3.58411856e-03f, -2.47632619e-02f, 3.57305706e-02f, -2.41333712e-02f, 1.65822469e-02f,
  -1.30740656e-02f, 3.31031643e-02f, -3.96469384e-02f, 6.55414723e-03f, 1.63297709e-02f, -3.27348635e-02f, 4.15583514e-02f, -7.30649522e-03f, -2.96745002e-02f, 2.66007017e-02f,
  -1.40666049e-02f, 3.65659483e-02f, -1.79818291e-02f, 6.63771480e-02f, -3.48912552e-02f, -5.91522921e-03f, 4.15273570e-02f, -2.96798628e-02f, 3.60197276e-02f, 3.29650082e-02f,
  1.65544420e-01f, 1.86108589e-01f, -1.83271077e-02f, -1.99470595e-02f, 6.17528055e-03f, 2.79593784e-02f, -2.38347817e-02f, 2.32636672e-03f, 1.07648291e-01f, 1.68205798e-02f,
  2.78441384e-02f, -3.58241610e-03f, 3.16684358e-02f, 1.86224375e-02f, 1.92415901e-02f, 3.67183164e-02f, 5.29094823e-02f, 4.02161367e-02f, 7.32055157e-02f, 5.74974120e-02f,
  3.85110714e-02f, -1.53091941e-02f, -1.34424167e-02f, -9.72502586e-03f, 2.31670458e-02f, 8.48660544e-02f, -8.16996768e-03f, -4.94388603e-02f, 5.40659763e-02f, 1.35819996e-02f
};

// L0_fan_Wp_bar (Shape: 4 x 120)
const int L0_fan_Wp_bar_rows = 4;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  8.77483487e-02f, -1.97944120e-01f, 5.12703806e-02f, 5.70125729e-02f, 3.36031653e-02f, -8.47432390e-02f, 1.01189487e-01f, -3.63905728e-02f, 8.69380608e-02f, -2.69869745e-01f,
  -1.37489855e-01f, -1.73915982e-01f, -8.19352791e-02f, -2.25189641e-01f, 3.27521302e-02f, -6.29220530e-02f, -7.53487647e-02f, -1.59641847e-01f, 3.90828364e-02f, -4.40399498e-02f,
  3.31894681e-02f, -5.21525778e-02f, 7.37008601e-02f, -2.40145639e-01f, -8.58690441e-02f, 4.28897440e-02f, -3.03994380e-02f, -1.17881425e-01f, -2.20058665e-01f, -1.76103592e-01f,
  -1.06223887e-02f, -2.04564538e-02f, 4.36836295e-02f, -1.21284267e-02f, 6.26759604e-02f, -2.06236821e-03f, -8.72171894e-02f, -5.25220335e-02f, 8.92389100e-03f, 2.95422110e-03f,
  -9.49440245e-03f, -2.22400595e-02f, -4.72465828e-02f, 2.71762814e-02f, 9.35445055e-02f, -2.34078486e-02f, -3.20808068e-02f, 5.43716066e-02f, -4.75561135e-02f, 1.62134524e-02f,
  -1.80882122e-03f, -2.08758228e-02f, 2.63727233e-02f, 3.43416929e-02f, 2.68262438e-02f, 1.95375234e-02f, 1.65634472e-02f, 3.74834426e-02f, 2.03963127e-02f, 1.53718796e-02f,
  -1.22146659e-01f, -1.45480139e-02f, -1.90634467e-02f, 2.70453207e-02f, 1.83378048e-02f, -3.27529153e-03f, -3.01423129e-02f, -6.46041632e-02f, -4.78210114e-03f, -2.86327172e-02f,
  1.90114062e-02f, -4.00676169e-02f, 1.28351282e-02f, 2.49350220e-02f, 1.07473629e-02f, -2.38749236e-02f, -6.60523847e-02f, -1.27589917e-02f, -2.25332063e-02f, 1.62953455e-02f,
  -6.62685484e-02f, -3.41456570e-02f, 2.03631595e-02f, -5.60396053e-02f, -5.49260639e-02f, -3.75270434e-02f, -3.34752388e-02f, 9.03785229e-03f, 6.53052479e-02f, -4.19009030e-02f,
  -3.15945633e-02f, -2.49365672e-01f, 6.09908439e-02f, -6.87985122e-02f, -3.53455842e-02f, -3.36888134e-02f, 3.42795327e-02f, -5.97171485e-02f, 2.40962077e-02f, 7.54220039e-02f,
  -1.14179980e-02f, 2.79306434e-03f, 3.00847599e-03f, 7.83099269e-04f, -3.26169506e-02f, -4.58186120e-02f, 2.25012992e-02f, -9.30260643e-02f, 4.62586097e-02f, 3.76116410e-02f,
  -5.80694005e-02f, 1.45853097e-02f, -6.66727051e-02f, 3.28434445e-02f, -7.07575455e-02f, -3.86188887e-02f, -2.01443713e-02f, -2.01961566e-02f, -3.87929715e-02f, -3.70387658e-02f,
  4.84882414e-01f, 1.09443188e-01f, -1.26001731e-01f, 1.81514472e-02f, 1.60333753e-01f, 3.34028184e-01f, 2.34767899e-01f, 1.53715909e-01f, 1.14642419e-01f, 1.72598548e-02f,
  9.79934484e-02f, -1.89938731e-02f, 9.16313455e-02f, 5.47510795e-02f, 2.24592239e-02f, 6.00235462e-02f, 1.31112859e-01f, 7.15031773e-02f, 7.17782900e-02f, 8.88119712e-02f,
  8.99027064e-02f, 1.64417684e-01f, -1.22936264e-01f, -5.11708334e-02f, 1.19730465e-01f, -4.11832631e-02f, -6.30405396e-02f, -1.33947060e-01f, -1.02280341e-01f, -7.24373013e-02f,
  5.30814156e-02f, -2.37367675e-02f, -2.26378534e-02f, -4.10093786e-03f, 3.90382409e-02f, -2.24112384e-02f, -3.65912952e-02f, -6.25273809e-02f, -4.14294899e-02f, 8.87908600e-03f,
  -2.79179942e-02f, -6.73919916e-02f, 4.94497418e-02f, -7.80465035e-03f, 1.03071570e-01f, -3.02848443e-02f, -5.01309410e-02f, -1.98687389e-02f, -5.93110584e-02f, 8.14529322e-03f,
  -2.64639277e-02f, -2.59253226e-04f, 1.12090232e-02f, -1.86944881e-03f, -4.49717306e-02f, 6.75823027e-03f, -5.03196474e-03f, 2.58087013e-02f, 4.20769565e-02f, -8.38740915e-03f,
  5.50262034e-02f, 6.19863346e-02f, -4.27704630e-03f, -1.34460749e-02f, -1.49971684e-02f, -2.92029176e-02f, 3.57235931e-02f, -5.21563441e-02f, 3.02409846e-02f, 1.41132390e-02f,
  -2.20029298e-02f, 2.63705403e-02f, -4.48204949e-02f, 1.82911083e-02f, 5.83816469e-02f, 2.82713845e-02f, 2.75658406e-02f, 2.42743511e-02f, -5.82202338e-02f, -3.96574810e-02f,
  -5.73850051e-02f, -9.89760179e-03f, -5.61154298e-02f, -3.68440524e-02f, 2.85512712e-02f, 5.46775432e-03f, -9.01516248e-03f, 3.30061316e-02f, 6.66281357e-02f, 3.08144763e-02f,
  2.31146678e-01f, 9.49466825e-02f, 8.96164402e-03f, 1.76181700e-02f, -8.54524821e-02f, 1.78727489e-02f, 1.66695658e-02f, 3.01491059e-02f, -3.08146011e-02f, 1.10712528e-01f,
  6.74770027e-02f, 4.27479409e-02f, 2.40267646e-02f, 2.19482114e-03f, -4.28194739e-02f, 6.10561483e-03f, 7.91118480e-03f, 2.50136144e-02f, 3.42240147e-02f, -1.29821943e-02f,
  -8.36135633e-03f, 4.62473109e-02f, 5.43978531e-03f, -1.85268335e-02f, 5.94360828e-02f, -4.79022078e-02f, 5.41903935e-02f, -3.39338444e-02f, -4.06008363e-02f, -4.58219275e-03f,
  2.78749675e-01f, -2.70651996e-01f, 2.12927401e-01f, 1.41042426e-01f, 3.72670054e-01f, 1.94684163e-01f, 4.63855892e-01f, -1.17435150e-01f, -8.29893500e-02f, -2.29572892e-01f,
  1.49225608e-01f, 7.25208819e-02f, 1.32479683e-01f, -4.16618176e-02f, 1.34407908e-01f, 4.36602384e-02f, -5.78793846e-02f, 6.15912266e-02f, -3.39845531e-02f, 4.02835682e-02f,
  7.27371648e-02f, 1.25573983e-03f, 1.26740217e-01f, -1.07900091e-01f, 2.03337744e-01f, -1.46791697e-01f, -8.18348601e-02f, 1.69066310e-01f, -1.59883469e-01f, 8.02637935e-02f,
  -7.22593814e-02f, 1.60681400e-02f, 2.50952356e-02f, -8.19825307e-02f, 6.19290536e-03f, 6.95026293e-02f, 2.76425052e-02f, 1.26180872e-01f, 4.25908528e-02f, 3.63086746e-03f,
  1.03860376e-02f, -1.11104455e-02f, -1.50846047e-02f, 6.87439293e-02f, -9.74398553e-02f, -3.97866033e-02f, 3.03875119e-03f, 4.76993853e-03f, 2.81484630e-02f, 6.78425506e-02f,
  7.47494027e-02f, -4.82269712e-02f, 2.32266746e-02f, -1.21621117e-02f, 6.39062980e-03f, -6.49487413e-03f, 2.12344807e-02f, 5.97301982e-02f, -4.34683375e-02f, -7.76137933e-02f,
  -2.43346542e-02f, -4.00821604e-02f, 1.45273712e-02f, -4.15443853e-02f, -3.28730457e-02f, 6.53917044e-02f, -5.60187884e-02f, 3.86188254e-02f, 7.07420101e-03f, -6.97106449e-03f,
  -3.27881351e-02f, 6.13137707e-02f, -3.32889184e-02f, -3.82273155e-03f, -2.53783236e-03f, 3.03582642e-02f, 1.35522150e-02f, -2.72946786e-02f, -9.58031596e-05f, 1.84106622e-02f,
  5.91789186e-02f, -1.57158859e-02f, 3.81501019e-02f, 9.24014822e-02f, 4.86307871e-03f, 2.87765432e-02f, 7.09979329e-03f, -1.42014893e-02f, 2.97815423e-03f, 2.01726910e-02f,
  -3.72683108e-02f, -3.63121539e-01f, -4.12487313e-02f, 5.68297878e-02f, -7.03383908e-02f, -2.38609612e-02f, -1.66746974e-02f, -7.72519782e-02f, -1.24103472e-01f, -3.61723602e-02f,
  -3.68417464e-02f, -2.77909078e-02f, 1.67993084e-02f, -1.86429471e-02f, -2.82521863e-02f, 5.71096987e-02f, -1.42985303e-02f, -9.36921164e-02f, -3.59016210e-02f, -7.31345788e-02f,
  3.22057400e-03f, -6.38598902e-03f, 2.80680950e-03f, 1.53744798e-02f, 1.11301169e-02f, 1.14405295e-02f, 1.33021744e-02f, -6.54474944e-02f, -3.77495848e-02f, -2.11273357e-02f,
  4.36709970e-02f, 2.52310485e-01f, 2.77369380e-01f, 3.62984799e-02f, -2.29999819e-03f, -1.42513290e-01f, -1.96173877e-01f, 5.95254190e-02f, -7.49696493e-02f, 1.43048823e-01f,
  -2.67579649e-02f, 2.26586357e-01f, 1.00140966e-01f, -7.64769167e-02f, -4.13908452e-01f, -2.23493174e-01f, -1.56615302e-01f, 9.74543691e-02f, -7.02008158e-02f, 1.57985583e-01f,
  -1.26156509e-01f, -1.64990246e-01f, -4.83338088e-02f, -8.40722620e-02f, 1.71309873e-01f, 2.25109220e-01f, 5.13346680e-02f, 3.43099833e-02f, 1.61597490e-01f, -7.28027821e-02f,
  -1.17847184e-02f, 1.22450322e-01f, 2.02897936e-01f, 1.43416682e-02f, 2.55771191e-03f, 7.38444477e-02f, 2.39372700e-02f, 1.53384637e-02f, 2.15371232e-02f, -1.32368887e-02f,
  4.51482497e-02f, -5.02911694e-02f, 1.03924295e-03f, -4.56673242e-02f, 4.01153155e-02f, 1.85089037e-02f, 3.47888395e-02f, 1.02550603e-01f, -7.72950649e-02f, -4.00407910e-02f,
  3.85749228e-02f, 7.59584010e-02f, 8.50363821e-03f, 3.47321294e-03f, -3.02257854e-03f, -5.46682552e-02f, -2.58997865e-02f, 3.39756347e-02f, 1.52814519e-02f, -4.38864268e-02f,
  -4.81857397e-02f, -8.18610489e-02f, -6.66902959e-02f, 4.79606763e-02f, 7.67125166e-04f, 2.06394680e-02f, -5.26249297e-02f, -1.17613375e-02f, 7.49967545e-02f, -2.86248643e-02f,
  3.17312479e-02f, 7.35763162e-02f, -1.62780297e-03f, 6.82785138e-02f, 3.37655954e-02f, 4.43373322e-02f, 5.77587774e-03f, 6.93366081e-02f, -9.72380415e-02f, -2.75483020e-02f,
  2.92922948e-02f, -2.63725836e-02f, 7.58298114e-03f, -5.71282431e-02f, -5.96320294e-02f, -2.22802199e-02f, 3.01274471e-02f, 3.00242417e-02f, 1.58443600e-02f, -2.06484031e-02f,
  1.28468588e-01f, 5.09344377e-02f, 1.10617932e-02f, 5.32339066e-02f, 3.85488570e-02f, 2.59423628e-02f, -9.88147184e-02f, -1.37261702e-02f, -1.32631892e-02f, 4.71740356e-03f,
  6.35628849e-02f, 6.74752053e-03f, 2.48856042e-02f, 7.80477896e-02f, -3.88970897e-02f, -8.44425410e-02f, -3.35667431e-02f, 4.85161040e-03f, 9.11462903e-02f, 2.14833748e-02f,
  5.76355793e-02f, -8.06594326e-04f, -5.48562221e-02f, -2.69249324e-02f, -2.32639983e-02f, 5.44661889e-03f, -5.25848940e-02f, 1.45779625e-02f, 6.38293847e-02f, 7.33077079e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 4)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 4;
const float L0_fan_Bp_bar_data[] = {
  1.32006526e-01f, -4.83279349e-03f, 1.39179632e-01f, 5.98653592e-02f
};

// L1_fan_Wp (Shape: 6 x 16)
const int L1_fan_Wp_rows = 6;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  1.40095487e-01f, -2.77539492e-01f, 4.98233706e-01f, 2.19709158e-01f, 9.41409264e-03f, -2.94975489e-01f, 2.61981934e-01f, -3.62802684e-01f, -2.62273967e-01f, -1.11904167e-01f,
  2.17680961e-01f, -7.39291251e-01f, 1.06964529e-01f, -1.00313142e-01f, 2.85594732e-01f, 4.21645604e-02f, -4.65715080e-02f, 7.99686313e-02f, -6.00043058e-01f, -1.35257453e-01f,
  -3.45470995e-01f, -6.43707365e-02f, 5.49127936e-01f, 1.66240275e-01f, -2.71258712e-01f, 7.23364592e-01f, -5.17375290e-01f, 2.57092059e-01f, 1.74741186e-02f, -5.25005043e-01f,
  2.05173120e-01f, 3.40607584e-01f, 2.69116640e-01f, 8.68323520e-02f, -1.83822840e-01f, 2.76582658e-01f, 2.24443227e-01f, 9.39716175e-02f, -4.70209792e-02f, 5.92349648e-01f,
  -8.09167802e-01f, -5.35906017e-01f, 9.65981781e-02f, -2.99522895e-02f, 5.90234697e-02f, -4.12531316e-01f, -1.85967341e-01f, 1.56521618e-01f, 2.43052751e-01f, -2.78187513e-01f,
  -2.38873467e-01f, 3.23134631e-01f, -2.10949361e-01f, -2.55717278e-01f, -3.91064852e-01f, -7.30821714e-02f, -4.93358135e-01f, 1.04863703e-01f, -5.12803078e-01f, -2.57893533e-01f,
  -5.34516692e-01f, -2.32211083e-01f, -3.62567037e-01f, 4.52250928e-01f, 6.24668002e-01f, -3.57175171e-01f, -3.83045152e-02f, 4.96374518e-01f, -4.61942181e-02f, -3.52983475e-02f,
  3.82374637e-02f, -2.73756325e-01f, 2.13256106e-01f, 1.11951351e-01f, -3.31966341e-01f, -2.58287728e-01f, -1.04760237e-01f, -2.45997012e-01f, 7.51167908e-02f, 1.89457759e-01f,
  5.94596863e-01f, -4.42294478e-01f, 1.29526779e-01f, 2.79398143e-01f, -1.35407224e-01f, -2.39946052e-01f, -4.13507700e-01f, -7.65291095e-01f, 5.26633918e-01f, 2.36384526e-01f,
  -4.66160804e-01f, -5.51883698e-01f, -3.08504820e-01f, 4.85820323e-02f, -1.39137164e-01f, -7.78420791e-02f
};

// L1_fan_Wp_bar (Shape: 4 x 16)
const int L1_fan_Wp_bar_rows = 4;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  -2.22181305e-01f, 3.21424603e-01f, 2.75133967e-01f, 1.06338948e-01f, 1.20294578e-02f, 8.78990069e-02f, 2.05367640e-01f, -9.13969800e-02f, 4.84914519e-02f, -5.09465575e-01f,
  4.49338108e-02f, -4.37861569e-02f, -4.29713540e-02f, 2.20046610e-01f, 4.89179105e-01f, -2.32723773e-01f, -1.80354580e-01f, -1.50616076e-02f, -9.44547137e-05f, -6.92826360e-02f,
  6.89378679e-02f, 1.43476322e-01f, -9.02096406e-02f, 7.72914439e-02f, 2.45578632e-01f, 1.48862123e-01f, -8.69214833e-02f, -2.68194787e-02f, -4.31374349e-02f, -8.77875313e-02f,
  -2.07910568e-01f, -5.99214733e-02f, 6.03331923e-01f, -7.26352111e-02f, 2.47357343e-03f, 5.25840759e-01f, 3.42050672e-01f, 6.51931688e-02f, 4.39831167e-01f, 9.32694823e-02f,
  -6.39571100e-02f, -7.84125403e-02f, -4.53490049e-01f, -3.69938046e-01f, 2.20258787e-01f, -1.12872586e-01f, 3.19679767e-01f, 4.78458166e-01f, 1.75017551e-01f, 5.59069812e-01f,
  2.09157541e-02f, 3.62092972e-01f, -1.51040986e-01f, 2.10929394e-01f, 3.53789479e-01f, -3.07152897e-01f, 5.93946874e-01f, 6.39033616e-01f, -6.22205257e-01f, 8.40165496e-01f,
  1.13292664e-01f, -7.01187849e-02f, 6.25154376e-01f, 2.84530342e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 4)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 4;
const float L1_fan_Bp_bar_data[] = {
  3.10819805e-01f, -2.27489233e-01f, 1.59507081e-01f, 5.53356588e-01f
};

// L2_fan_Wp (Shape: 6 x 16)
const int L2_fan_Wp_rows = 6;
const int L2_fan_Wp_cols = 16;
const float L2_fan_Wp_data[] = {
  1.92315713e-01f, 8.85566175e-02f, -6.33449331e-02f, -2.67307699e-01f, 7.31420740e-02f, 2.12227494e-01f, 6.61104202e-01f, -1.00280631e+00f, 2.87696183e-01f, -2.49107361e-01f,
  2.51594931e-01f, -5.88479973e-02f, 3.16062003e-01f, 4.28409539e-02f, 4.30681527e-01f, -5.06388783e-01f, -2.79962569e-01f, 1.78668410e-01f, -1.12404555e-01f, -6.63649380e-01f,
  4.37678657e-02f, -1.13372363e-01f, 9.39282775e-01f, -2.66513407e-01f, -6.23558283e-01f, 2.41197452e-01f, 5.03052235e-01f, 6.75066888e-01f, -6.08240925e-02f, 1.78416669e-02f,
  1.56749591e-01f, -2.31169537e-02f, 9.25679207e-02f, 1.10512674e-01f, 2.70275399e-02f, 3.59923869e-01f, 2.76494652e-01f, 2.88698554e-01f, 1.12909265e-01f, -1.55292414e-02f,
  1.27094305e+00f, 1.82242632e-01f, 1.57667339e-01f, -4.03772503e-01f, -2.33385116e-01f, -8.95314366e-02f, 4.20759797e-01f, -4.36460167e-01f, -3.02677959e-01f, -1.04054930e-02f,
  8.05815980e-02f, 4.86106277e-01f, -2.32925534e-01f, 6.43480122e-02f, 3.47440839e-01f, -3.04434121e-01f, 2.61721998e-01f, 3.02716106e-01f, 6.48718297e-01f, 8.48265409e-01f,
  -2.52949923e-01f, 1.07636243e-01f, 2.83510208e-01f, -3.03190947e-01f, 3.23645353e-01f, -5.68924785e-01f, -2.12413102e-01f, 3.44408125e-01f, 1.63305745e-01f, 8.09530318e-01f,
  -2.79920012e-01f, -8.46747220e-01f, -2.19558049e-02f, -2.27148607e-01f, -9.32861194e-02f, -6.25848630e-03f, 2.57156402e-01f, -1.10014886e-01f, 9.59905311e-02f, -6.27060831e-01f,
  -2.76191860e-01f, -3.99181038e-01f, 1.82700187e-01f, -8.97923186e-02f, -1.57387882e-01f, 1.14732131e-01f, 4.21416044e-01f, -7.86571622e-01f, -7.50823319e-01f, -5.39959371e-01f,
  3.65176648e-01f, 5.49899578e-01f, -5.31275682e-02f, -7.00231642e-02f, 1.17418528e-01f, -7.86226764e-02f
};

// L2_fan_Wp_bar (Shape: 4 x 16)
const int L2_fan_Wp_bar_rows = 4;
const int L2_fan_Wp_bar_cols = 16;
const float L2_fan_Wp_bar_data[] = {
  4.63642061e-01f, 4.19828862e-01f, 3.00847918e-01f, -3.87786657e-01f, 2.55467743e-01f, -3.20439070e-01f, -9.95044224e-03f, 3.36618185e-01f, -3.68963748e-01f, -9.64625120e-01f,
  -5.68891644e-01f, -1.31672502e+00f, 1.88072234e-01f, -9.06803533e-02f, -5.31498976e-02f, 2.41276592e-01f, 3.27204734e-01f, -2.84134001e-01f, 3.74452293e-01f, 2.63805762e-02f,
  7.65815735e-01f, 6.92310095e-01f, -3.26377451e-02f, -1.14120626e+00f, -6.37982011e-01f, -8.21171403e-01f, -3.08001190e-01f, -4.87687230e-01f, 6.12946808e-01f, 1.31225765e-01f,
  -2.08381757e-01f, 2.94768035e-01f, 9.39749405e-02f, 1.08410871e+00f, -4.28392291e-01f, -4.82563078e-01f, 3.49887311e-02f, 6.26530468e-01f, 2.54731566e-01f, 4.28321719e-01f,
  4.73141164e-01f, 8.30851972e-01f, 8.77074122e-01f, -6.34359792e-02f, 3.02128434e-01f, -5.96880727e-02f, 1.05250359e+00f, 9.66645896e-01f, 1.29249364e-01f, 3.66552733e-02f,
  6.02053344e-01f, 4.53031927e-01f, 3.22087467e-01f, 3.42449546e-01f, -5.36747575e-01f, 3.23822081e-01f, -7.17516780e-01f, -6.10747337e-01f, 3.39676917e-01f, 6.45263493e-01f,
  -7.61676356e-02f, -2.18010187e-01f, 3.97166004e-03f, 1.13686609e+00f
};

// L2_fan_Bp_bar (Shape: 1 x 4)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 4;
const float L2_fan_Bp_bar_data[] = {
  5.71765482e-01f, 6.34517848e-01f, 4.70153362e-01f, 4.26899850e-01f
};

// L3_linear_W (Shape: 12 x 16)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 16;
const float L3_linear_W_data[] = {
  -1.75672248e-01f, -6.58430338e-01f, 2.49364465e-01f, -4.50360738e-02f, -2.08290070e-01f, 4.68259901e-01f, 8.81363630e-01f, -6.46209717e-01f, 9.68079805e-01f, -7.59512186e-01f,
  9.91582513e-01f, -2.59876221e-01f, 6.26186788e-01f, 7.56584048e-01f, -1.04495120e+00f, -8.42532873e-01f, 1.99130282e-01f, 2.50205427e-01f, -1.75501332e-01f, -7.97774851e-01f,
  -1.39667347e-01f, -4.67460491e-02f, 6.51439950e-02f, -3.17496896e-01f, -1.03245759e+00f, -5.79123974e-01f, 8.06835532e-01f, 5.25012672e-01f, 4.01851952e-01f, 8.99941921e-01f,
  -1.10526586e+00f, 2.17673644e-01f, 8.42288733e-01f, 2.05012292e-01f, 8.53081882e-01f, 1.37687713e-01f, 5.67838132e-01f, 4.84574527e-01f, -1.23748720e-01f, -7.90885508e-01f,
  3.02833617e-01f, -5.77381216e-02f, 2.18997344e-01f, -1.24747586e-02f, -8.88820216e-02f, 1.71538055e-01f, -3.39363888e-02f, 6.05119526e-01f, 1.46991700e-01f, 1.88823819e-01f,
  -3.46765876e-01f, 4.63069752e-02f, 7.07381725e-01f, 2.62518495e-01f, 5.16073227e-01f, 5.13104200e-01f, 5.05068421e-01f, 5.83137572e-01f, 3.99365783e-01f, -1.10664427e+00f,
  -6.08939886e-01f, -7.86260188e-01f, 9.50938821e-01f, -1.11927271e+00f, -7.83253074e-01f, 6.85372353e-01f, -7.18004346e-01f, 5.07928252e-01f, 3.54636073e-01f, 6.55654669e-01f,
  3.12175989e-01f, -3.09530795e-01f, 9.32860136e-01f, 3.10484290e-01f, 9.05388951e-01f, 9.44596436e-03f, -4.47604693e-02f, 5.77491820e-01f, 2.14132562e-01f, -5.68887115e-01f,
  2.81129181e-01f, 3.24623734e-01f, 4.44155812e-01f, 5.83119452e-01f, -3.95418294e-02f, -5.31197608e-01f, 6.29345357e-01f, 9.60053682e-01f, -1.62744388e-01f, 8.64271700e-01f,
  9.80041206e-01f, 1.06750906e+00f, -6.76671445e-01f, 6.74879849e-01f, -1.02431452e+00f, 7.05292225e-01f, -5.07991254e-01f, -9.70929742e-01f, 1.98577985e-01f, 6.82083905e-01f,
  3.41600358e-01f, -9.38175678e-01f, 6.06482685e-01f, 8.23372304e-01f, -5.09863198e-01f, -6.66094795e-02f, -2.41040923e-02f, 7.15586066e-01f, 5.17305657e-02f, 1.61464214e-01f,
  2.73263425e-01f, 2.26581439e-01f, 8.61656666e-02f, -3.20274591e-01f, 4.01539654e-01f, -4.33017224e-01f, 1.48645505e-01f, -2.60546237e-01f, -6.49898052e-01f, -5.99303424e-01f,
  1.72313347e-01f, -7.25355744e-01f, -7.61544883e-01f, -8.32724929e-01f, 1.37153518e+00f, -2.47860178e-01f, -7.09786892e-01f, 2.51643002e-01f, -8.00518990e-01f, 4.26694602e-01f,
  -3.46331567e-01f, 4.87566702e-02f, -6.87846243e-01f, 1.69759810e-01f, -9.14364576e-01f, -7.11502880e-02f, -8.97229910e-01f, 1.75312549e-01f, -5.53548038e-01f, -6.78367019e-02f,
  -6.20989501e-01f, -4.44289804e-01f, 7.02367574e-02f, 8.22016776e-01f, 2.90522933e-01f, 1.23298526e-01f, -3.88723403e-01f, -9.86976564e-01f, -5.18015325e-01f, -3.87516432e-02f,
  3.35121006e-02f, 8.74507666e-01f, -7.02649713e-01f, -4.08951133e-01f, -4.62593913e-01f, -9.37370285e-02f, 7.81113446e-01f, 2.20526487e-01f, 2.95001954e-01f, -2.78267980e-01f,
  4.88385022e-01f, 5.19149425e-03f, -3.70749801e-01f, 9.80529934e-02f, 2.45272815e-01f, -6.46639585e-01f, -8.07932794e-01f, -6.34280503e-01f, 6.14173174e-01f, -2.58020908e-01f,
  -4.25165087e-01f, -7.64729261e-01f, -3.66844594e-01f, -8.56624544e-01f, 7.85710573e-01f, -7.71577656e-02f, 4.24676985e-01f, -7.22553551e-01f, 7.56744504e-01f, -4.90986168e-01f,
  -6.21030986e-01f, 4.48354810e-01f, 1.88949853e-01f, 7.79119492e-01f, 1.12259254e-01f, 7.85531342e-01f, -5.89620411e-01f, 5.22820354e-01f, -2.99697697e-01f, -9.85548079e-01f,
  7.36814141e-01f, -6.53477162e-02f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  1.25587001e-01f, -1.21819749e-01f, -7.33246431e-02f, 1.54724702e-01f, 5.17162740e-01f, 3.84918660e-01f, -2.63665229e-01f, 5.80860227e-02f, 1.86206043e-01f, -4.08512622e-01f,
  -9.41474363e-02f, 2.32784033e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 4
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 6, 4
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        16, 6, 4
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        16, 12
    );
    }
    