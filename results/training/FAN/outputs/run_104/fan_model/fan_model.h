/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 19 x 120)
const int L0_fan_Wp_rows = 19;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  1.96150258e-01f, 1.56402498e-01f, 3.71869743e-01f, 2.39496306e-01f, 8.79918784e-02f, -2.37012595e-01f, -8.87318924e-02f, 1.70528680e-01f, 1.31335974e-01f, -2.01268286e-01f,
  -9.15855989e-02f, 2.30740637e-01f, -1.62351608e-01f, 9.96184722e-02f, -8.49661231e-02f, -2.73627371e-01f, 5.81188090e-02f, -9.53368992e-02f, 1.06457196e-01f, 1.85080171e-01f,
  1.45607874e-01f, -1.73637807e-01f, 1.77521482e-01f, 1.49228796e-01f, 1.50068074e-01f, 1.40268221e-01f, -2.60534674e-01f, 6.04120381e-02f, -1.85052622e-02f, -8.78728405e-02f,
  -3.20062563e-02f, 2.34272689e-01f, 1.42221585e-01f, 6.43717963e-03f, -1.84321422e-02f, -7.61623457e-02f, -1.02458395e-01f, -4.40286808e-02f, 8.05694610e-02f, 8.64761323e-02f,
  -8.00372362e-02f, -1.55073954e-02f, 4.66242097e-02f, -1.52711272e-02f, 7.88304582e-02f, 1.93597391e-01f, 2.53312122e-02f, 5.92735549e-03f, 1.13267183e-01f, 5.13751172e-02f,
  1.30582109e-01f, 4.66080084e-02f, 2.40782350e-02f, -6.83093593e-02f, 1.45379966e-03f, 1.02353126e-01f, 8.77333048e-04f, -3.84384021e-02f, -7.38770887e-02f, 1.34822965e-01f,
  5.88239431e-02f, -7.88516700e-02f, 3.80432643e-02f, 1.75394043e-02f, 6.02829922e-03f, -1.35536641e-02f, -5.07366320e-04f, -8.65272433e-03f, -6.32456839e-02f, 1.80495940e-02f,
  -5.11374436e-02f, 1.46312290e-03f, -4.32582498e-02f, -1.87238175e-02f, -1.88433807e-02f, 1.18754050e-02f, -2.27155127e-02f, -4.65233289e-02f, 3.41298021e-02f, -4.04878110e-02f,
  9.39803012e-03f, 1.78735945e-02f, -6.48461236e-03f, -2.89056785e-02f, 3.19014527e-02f, -5.60877286e-02f, 2.29018107e-02f, 3.82270180e-02f, -2.26632692e-02f, -2.47305501e-02f,
  -3.47006559e-01f, -7.43073598e-02f, -4.30102684e-02f, -6.72512874e-02f, -3.52499411e-02f, -6.86387047e-02f, 4.48810719e-02f, -1.41089763e-02f, -2.60605849e-02f, -3.25291865e-02f,
  -2.16003079e-02f, 9.28977155e-04f, -8.69481079e-03f, -5.26710078e-02f, -2.05351710e-02f, -8.94019231e-02f, 1.42455418e-02f, -5.34906350e-02f, -8.57634023e-02f, -4.50025015e-02f,
  -2.79741343e-02f, -2.72817519e-02f, 5.21830730e-02f, -7.67237390e-04f, -1.09622955e-01f, 3.35267968e-02f, -2.27629347e-03f, 5.71463704e-02f, -2.70429086e-02f, 6.33811206e-03f,
  -4.56057861e-02f, -4.93865870e-02f, 3.39948714e-01f, 9.37320516e-02f, -4.79876786e-01f, 9.66808200e-02f, 1.27210036e-01f, -2.46649042e-01f, 2.38342464e-01f, -1.03232823e-01f,
  -1.68856233e-01f, 1.90533757e-01f, 4.56825197e-02f, 1.06909394e-01f, 2.53585070e-01f, 3.41170222e-01f, 2.22001314e-01f, 1.49692968e-01f, 6.62562996e-02f, -9.26344618e-02f,
  1.46203607e-01f, -3.11403573e-01f, 5.95010109e-02f, -2.70326495e-01f, -2.24391326e-01f, -4.69952114e-02f, -2.89157033e-01f, -1.09468326e-02f, -1.75621182e-01f, -4.05775234e-02f,
  -4.36897799e-02f, -1.56959910e-02f, 1.50724044e-02f, 5.34691066e-02f, -3.26321051e-02f, -3.52551229e-02f, 3.81372496e-02f, 3.36308703e-02f, 6.83531016e-02f, 1.97249092e-02f,
  5.08274585e-02f, -3.21785882e-02f, 3.07716685e-03f, 2.60769273e-03f, -1.91264190e-02f, 4.36219797e-02f, 2.75881570e-02f, 4.52410765e-02f, -5.09613678e-02f, 8.08505192e-02f,
  1.37476414e-01f, 7.00192451e-02f, 7.82756805e-02f, 1.17250523e-02f, 8.16702768e-02f, 6.09030835e-02f, 7.71783963e-02f, -9.96613409e-03f, 4.84346040e-02f, -1.78041030e-02f,
  4.04052101e-02f, 4.30271104e-02f, 1.64842773e-02f, 7.94393010e-03f, 1.93287041e-02f, -3.21959704e-02f, 6.69044480e-02f, -6.38931394e-02f, 1.71076395e-02f, -7.48225376e-02f,
  -8.86070635e-03f, -3.86364907e-02f, -2.58252583e-02f, -6.12482196e-03f, -1.44956643e-02f, -1.02543877e-02f, 7.51892105e-02f, -3.50172408e-02f, 4.41335216e-02f, -3.59234447e-03f,
  -3.02322805e-02f, 3.98956127e-02f, -3.97782400e-02f, 2.14220025e-02f, 3.85023244e-02f, -3.68559472e-02f, 1.37374941e-02f, 4.41060401e-02f, 5.11525432e-03f, -2.03011464e-02f,
  -1.59314230e-01f, -7.29884878e-02f, -3.70749310e-02f, -5.91938458e-02f, -1.28347883e-02f, -6.22576177e-02f, 7.04108849e-02f, -2.70886533e-02f, -3.95715982e-02f, 2.85591129e-02f,
  2.54852604e-02f, -3.87712866e-02f, 1.60617381e-02f, 4.41424083e-03f, -2.37513855e-02f, -4.25576568e-02f, 3.01757846e-02f, -2.56989785e-02f, -1.30928531e-01f, -7.89381191e-02f,
  -5.05453832e-02f, -8.65296833e-03f, -6.80271583e-03f, -1.89149231e-02f, -5.07299677e-02f, -1.44965099e-02f, -1.04394034e-02f, 1.44389225e-03f, -5.43046296e-02f, 2.66807657e-02f,
  -4.91145611e-01f, -1.19117391e-03f, 1.50504753e-01f, -2.86642075e-01f, -2.66610444e-01f, -1.73015129e-02f, -2.23241210e-01f, -1.73844442e-01f, -1.10932477e-01f, 2.87518688e-02f,
  -1.38305157e-01f, 1.40410811e-01f, 1.10408634e-01f, 5.92097687e-03f, 5.80298491e-02f, 2.77933270e-01f, -1.27900377e-01f, 1.02694770e-02f, 7.95276985e-02f, -2.09605843e-01f,
  -3.49647216e-02f, -2.40484551e-01f, 1.12462275e-01f, -3.85608003e-02f, -3.00517052e-01f, -2.35253721e-02f, -1.70575008e-01f, 3.89109701e-02f, -3.64065841e-02f, 5.12148626e-02f,
  -7.95025155e-02f, -6.89115375e-02f, 5.11051007e-02f, 5.49832843e-02f, -9.56939384e-02f, 2.29357672e-03f, -4.67358306e-02f, 9.75629762e-02f, 7.00040534e-02f, 6.55746460e-02f,
  -1.12117967e-02f, 1.66736543e-02f, 7.28918910e-02f, 4.56255749e-02f, -2.80731916e-02f, 3.55479084e-02f, 1.14420258e-01f, 1.10419597e-02f, 4.57721166e-02f, 7.11148307e-02f,
  3.37083749e-02f, 5.62814474e-02f, -3.80941778e-02f, 2.75663827e-02f, 6.51169242e-03f, 4.34852764e-02f, 2.91997809e-02f, -3.56205017e-03f, 1.01112081e-02f, -2.08099671e-02f,
  -4.24134023e-02f, -6.44339342e-03f, 7.13539198e-02f, 3.87490168e-02f, -6.34767786e-02f, -1.10436352e-02f, 5.46318889e-02f, 2.00242735e-02f, 4.93993163e-02f, -5.50120398e-02f,
  -1.83026735e-02f, -4.71887514e-02f, -3.51037160e-02f, 2.43794341e-02f, 1.04822572e-02f, -6.40023947e-02f, 3.01567856e-02f, -4.32141609e-02f, -8.14884380e-02f, 1.94996670e-02f,
  -1.51637765e-02f, -4.16409224e-02f, -1.51515426e-02f, -2.03207377e-02f, 3.77800763e-02f, 1.11888023e-02f, -3.40242609e-02f, 2.09725983e-02f, 1.94471236e-02f, -2.44050063e-02f,
  -1.82815135e-01f, -2.35804036e-01f, -2.28425190e-02f, -4.08542641e-02f, 3.24354768e-02f, 6.06630817e-02f, 7.08155781e-02f, 1.09357927e-02f, 5.40389083e-02f, -6.74242005e-02f,
  5.64423501e-02f, -1.20528638e-02f, -1.32093027e-01f, -2.77353078e-02f, -3.53897810e-02f, -2.03906372e-02f, -7.40583614e-02f, -5.46273291e-02f, -9.09745917e-02f, -8.40879753e-02f,
  -8.17661136e-02f, -8.60697925e-02f, 4.99254540e-02f, -7.71977827e-02f, -5.93120083e-02f, -6.50912821e-02f, -5.66987097e-02f, 5.89302517e-02f, 2.02340689e-02f, 5.64899929e-02f,
  -1.68232113e-01f, 3.68705392e-01f, -2.70414352e-01f, -1.38714775e-01f, 4.05465886e-02f, 3.51794928e-01f, 1.03003159e-02f, 9.69191641e-02f, -1.25123039e-01f, 4.09380883e-01f,
  1.06862009e-01f, -1.45168111e-01f, 3.89883923e-03f, 2.92377532e-01f, -2.08600894e-01f, -2.92729139e-02f, 2.51438200e-01f, 1.29695997e-01f, -1.45285085e-01f, 1.88920096e-01f,
  -6.90409914e-02f, 1.94555864e-01f, -1.49725750e-02f, 7.25904182e-02f, 1.01215005e-01f, -1.69138476e-01f, 1.01807535e-01f, -1.79440245e-01f, 1.87000409e-01f, -4.22907174e-02f,
  1.97132632e-01f, -1.18342429e-01f, -2.55023595e-02f, -2.82115098e-02f, 1.33701816e-01f, 4.43264954e-02f, 2.31906045e-02f, -1.22698478e-01f, -9.33285207e-02f, 1.44130886e-02f,
  -3.17104720e-02f, -4.90263365e-02f, 1.91429369e-02f, -3.78319249e-02f, 3.16811912e-02f, -1.90751776e-02f, -3.21936980e-02f, 9.74505395e-03f, -5.04545793e-02f, -5.60767800e-02f,
  -4.21550460e-02f, 4.33649030e-03f, 2.25671418e-02f, 3.06646153e-02f, -1.42663911e-01f, -2.49662567e-02f, -1.82134137e-02f, -3.04576773e-02f, 5.85920587e-02f, 8.16847105e-03f,
  -9.21659321e-02f, 1.84089392e-02f, -7.70723373e-02f, 4.29403335e-02f, -8.54012743e-02f, -2.12659333e-02f, 4.39792797e-02f, 1.76699981e-02f, -4.53644358e-02f, -1.99784581e-02f,
  5.67588881e-02f, -7.83163756e-02f, -5.29461031e-05f, 2.69153789e-02f, 1.33603206e-02f, -3.15885758e-03f, -5.13118319e-02f, 5.98291755e-02f, 2.36414392e-02f, -1.44301718e-02f,
  -3.18378061e-02f, 7.16105551e-02f, 5.44880405e-02f, 4.45936471e-02f, 2.02979855e-02f, -6.76929206e-02f, 5.58681935e-02f, -1.40908621e-02f, -9.77923535e-03f, -4.39132676e-02f,
  3.93708527e-01f, 2.86824852e-01f, 3.98727842e-02f, 4.82366569e-02f, 1.40028531e-02f, 8.22094604e-02f, -5.42235561e-03f, 6.06902279e-02f, 1.30658476e-02f, -1.54401287e-02f,
  9.19753537e-02f, 1.20144337e-01f, 1.17934998e-02f, 1.76592749e-02f, -4.72265035e-02f, 1.10920295e-02f, 6.63851649e-02f, 7.53403232e-02f, 5.98761477e-02f, 1.05709642e-01f,
  2.39193067e-02f, -1.60252359e-02f, -8.45516287e-03f, -9.04116035e-03f, 3.27527709e-02f, -1.97491441e-02f, 3.13807391e-02f, -5.87075986e-02f, 2.75126398e-02f, 2.60880198e-02f,
  6.29846096e-01f, 3.28610092e-01f, 7.57727325e-02f, 3.51429790e-01f, -9.32145678e-03f, 2.49833614e-01f, -5.58165126e-02f, 2.74395347e-01f, 1.97987020e-01f, 8.79345238e-02f,
  -9.46582556e-02f, 1.80620611e-01f, -2.16454610e-01f, 2.00630561e-01f, 1.80316970e-01f, -6.45640120e-02f, 2.65577376e-01f, 1.08192861e-01f, -2.31201481e-03f, 2.21011817e-01f,
  1.30792320e-01f, 8.63612592e-02f, 1.43758971e-02f, 6.86596185e-02f, 1.27017945e-01f, 9.42135975e-02f, -9.24916789e-02f, -1.41981721e-01f, 1.10115781e-01f, -4.18974496e-02f,
  1.03696965e-01f, 1.42064765e-01f, -2.14897301e-02f, 2.93848366e-02f, 3.57696302e-02f, -9.50698480e-02f, -1.00095589e-02f, -1.34429649e-01f, -7.63036609e-02f, 3.42573896e-02f,
  -5.64088523e-02f, 1.36715155e-02f, 4.49056923e-02f, 6.08841842e-03f, 7.05136508e-02f, 5.68996705e-02f, 1.92102212e-02f, -2.37575360e-03f, -9.13562346e-03f, 3.06597613e-05f,
  -4.05262726e-05f, 2.94454563e-02f, 3.40065807e-02f, 5.21419756e-03f, 8.04397557e-03f, 4.36688699e-02f, -1.01715615e-02f, -4.42936048e-02f, 6.77402020e-02f, 6.75192922e-02f,
  -2.36020368e-02f, -2.39402838e-02f, -9.61480103e-03f, -6.52765529e-03f, 2.14214008e-02f, -4.79554199e-02f, 1.03600118e-02f, -6.13893420e-02f, 4.30116504e-02f, 1.75126530e-02f,
  6.45123096e-03f, 6.21001162e-02f, 2.33316887e-02f, 6.22349512e-03f, -1.40243834e-02f, 7.98811484e-03f, -3.69802676e-02f, 2.19158176e-02f, 5.25735542e-02f, 3.41401696e-02f,
  -4.59383503e-02f, 5.19866943e-02f, 1.06692417e-02f, -7.46043250e-02f, 9.80989891e-04f, -4.05913126e-03f, 4.09426056e-02f, 7.23460987e-02f, -3.10041588e-02f, -2.35011261e-02f,
  3.31947297e-01f, 3.16519767e-01f, -2.97247879e-02f, -3.07895932e-02f, -6.32337760e-03f, 4.69751917e-02f, 1.53104467e-02f, 5.65828048e-02f, 6.78292364e-02f, 2.40464266e-02f,
  3.62994485e-02f, -1.27716344e-02f, -4.72858623e-02f, -5.84444255e-02f, -2.47302502e-02f, -9.05993953e-03f, -4.59165759e-02f, 1.08270848e-03f, 3.27932611e-02f, 9.19713229e-02f,
  -1.22916494e-02f, -4.81882272e-03f, -7.51041323e-02f, 1.80013850e-02f, -5.21413311e-02f, -3.77380326e-02f, 6.67206347e-02f, 7.22154928e-03f, -1.17129944e-02f, 6.62564486e-03f,
  -5.65196536e-02f, -1.74086288e-01f, -1.59064487e-01f, 6.22355454e-02f, 2.66759753e-01f, 2.13555265e-02f, 1.05633609e-01f, 2.23370075e-01f, 1.51696667e-01f, -8.34935233e-02f,
  2.99856663e-01f, 8.66678953e-02f, 1.66392446e-01f, 3.17458868e-01f, 2.70622730e-01f, 4.22374718e-02f, -1.33358330e-01f, -2.37799183e-01f, 5.34352697e-02f, -3.87359895e-02f,
  1.81756485e-02f, 2.41480544e-01f, 1.29393905e-01f, 6.66479990e-02f, 1.16477847e-01f, -1.17416307e-01f, 1.41672924e-01f, 1.43061042e-01f, -8.05352777e-02f, 1.47282988e-01f,
  1.23515822e-01f, 2.08104238e-01f, -5.36726713e-02f, -1.05542116e-01f, -2.31955433e-03f, -1.16701983e-01f, -1.79874927e-01f, 1.56270579e-01f, 1.39681816e-01f, -4.40675952e-03f,
  3.55449319e-02f, 1.35297298e-01f, -3.17161866e-02f, -6.13342896e-02f, -1.33190528e-01f, 7.35734552e-02f, 5.62171601e-02f, -7.24842772e-02f, 2.78416816e-02f, 4.82570343e-02f,
  -3.64791416e-03f, -1.11905888e-01f, -4.88692801e-03f, -1.01348117e-01f, 8.93136263e-02f, 5.98530890e-03f, -6.11418113e-02f, -1.71332449e-01f, -9.97879058e-02f, -1.18366063e-01f,
  6.18261956e-02f, -8.50573257e-02f, 2.07044072e-02f, -3.18780378e-03f, 7.85876140e-02f, 4.58611809e-02f, 6.10176884e-02f, 8.92838463e-02f, -7.62186898e-03f, 5.93547858e-02f,
  2.29100175e-02f, 5.70849422e-03f, 1.13331415e-02f, -1.80590432e-02f, 4.33177650e-02f, 1.30129745e-02f, 4.22363840e-02f, 8.58947635e-02f, -8.33536461e-02f, 8.81947801e-02f,
  6.37557730e-02f, -3.40842977e-02f, -4.96349297e-02f, -1.67881530e-02f, -2.30707731e-02f, -1.03797158e-02f, -1.56858272e-03f, -5.54850362e-02f, 9.95938927e-02f, -4.25692238e-02f,
  -2.14553177e-01f, -1.28029794e-01f, 1.18261784e-01f, 6.28887638e-02f, -9.92951468e-02f, -5.07382676e-02f, -2.64185164e-02f, 4.08123992e-02f, -2.28575082e-03f, 2.66103093e-02f,
  -5.22239320e-02f, -7.21143261e-02f, -1.17868818e-01f, 2.65575685e-02f, 1.76971816e-02f, -5.63040040e-02f, -2.78488005e-04f, -1.28156289e-01f, -2.98314349e-04f, -4.77937385e-02f,
  4.85563464e-02f, 3.74528617e-02f, 2.54181270e-02f, 7.24548325e-02f, -3.87406498e-02f, -4.86004073e-03f, -5.14220931e-02f, 1.80508494e-02f, 1.04219317e-02f, 1.75350141e-02f,
  3.83810371e-01f, -3.84204656e-01f, -5.38141541e-02f, 8.07504803e-02f, 1.53541178e-01f, -2.23387301e-01f, -3.56147557e-01f, 9.86683294e-02f, 7.13645816e-02f, -2.87891656e-01f,
  -2.29514837e-02f, -2.23485604e-01f, -2.30493113e-01f, -3.11594784e-01f, 8.84472653e-02f, -3.18677455e-01f, -8.96767825e-02f, -1.66653261e-01f, -3.79936099e-02f, 4.97965142e-02f,
  1.15586974e-01f, -5.17335581e-03f, -8.84690136e-02f, 1.17621489e-01f, 1.61067378e-02f, 1.98600352e-01f, 2.19660968e-01f, 3.53754833e-02f, -3.09348814e-02f, -6.29499406e-02f,
  -4.80020195e-02f, 1.15901999e-01f, -4.89380350e-03f, 3.45928781e-02f, 1.05439194e-01f, 2.46511251e-02f, 3.47618386e-02f, -2.13038903e-02f, -1.29800998e-02f, -2.73992438e-02f,
  -6.90160617e-02f, 5.39477058e-02f, -2.88300705e-03f, 4.90631396e-03f, 2.94179935e-02f, 9.46922507e-03f, -6.61786124e-02f, -6.25131875e-02f, -6.40885904e-02f, -1.88351255e-02f,
  -1.19330600e-01f, -1.29026249e-02f, 2.63523366e-02f, -4.59890440e-02f, 1.85435563e-02f, -4.78894077e-02f, 3.04377340e-02f, -2.26468984e-02f, -3.39658968e-02f, 6.93878606e-02f,
  9.80054885e-02f, 5.47060929e-02f, -3.53734940e-02f, 2.37484090e-02f, 1.23815788e-02f, 9.88854244e-02f, -7.60085806e-02f, 4.40733023e-02f, 2.57498100e-02f, 3.77394743e-02f,
  5.92667945e-02f, -9.52524366e-04f, 7.50986487e-02f, -1.80564187e-02f, -1.27227767e-03f, 3.27041596e-02f, -2.10616104e-02f, 8.45849141e-03f, 2.74521783e-02f, 3.88564281e-02f,
  1.86900329e-02f, -1.30243693e-02f, -5.33397235e-02f, 2.94327606e-02f, -5.61207533e-02f, -3.22256833e-02f, 2.07208730e-02f, 4.96436725e-04f, 2.96284482e-02f, 5.89576252e-02f,
  3.67443338e-02f, 3.34994286e-01f, -5.54456608e-03f, 3.61145437e-02f, -1.12101352e-02f, 3.24024893e-02f, 2.32857876e-02f, 6.95795100e-03f, -8.09291005e-02f, 2.34651677e-02f,
  3.76129597e-02f, -9.30813700e-03f, 9.56099108e-02f, -4.63214740e-02f, -1.42951850e-02f, -1.35711813e-02f, -3.91342416e-02f, 4.25822660e-02f, 1.60379186e-02f, 4.44585569e-02f,
  1.19784363e-01f, -8.18885223e-04f, -1.96890980e-02f, 9.50933248e-02f, 2.84678768e-02f, -2.80800723e-02f, 6.11014813e-02f, 3.59440707e-02f, 8.89370590e-03f, -4.40500043e-02f,
  -2.14870051e-01f, -5.16804993e-01f, -1.06843404e-01f, 1.35249883e-01f, 2.98063960e-02f, -1.18260607e-01f, 1.81286752e-01f, -2.89816320e-01f, -4.55718338e-02f, 3.68448012e-02f,
  2.33532414e-01f, -2.80914128e-01f, -1.31958753e-01f, 2.38870457e-01f, -1.40370667e-01f, 6.86160699e-02f, -5.01031317e-02f, 5.82409166e-02f, -2.44582489e-01f, -1.77615080e-02f,
  -1.28385216e-01f, 2.32048288e-01f, -4.70597995e-03f, -7.84018934e-02f, -7.85551369e-02f, -2.45232061e-02f, 6.45207167e-02f, -3.98714021e-02f, 1.61356911e-01f, -2.22457815e-02f,
  -7.54170939e-02f, -4.94211316e-02f, -1.11077260e-02f, -1.55468965e-02f, 9.03923251e-03f, 5.23159020e-02f, 5.97375892e-02f, 4.96710427e-02f, 8.20530206e-03f, -2.24779416e-02f,
  -3.48685421e-02f, 5.86605519e-02f, -3.98475677e-02f, 4.17202450e-02f, 3.77173908e-02f, 9.92780738e-03f, 4.49061058e-02f, 4.77813855e-02f, -4.62202504e-02f, 2.31251586e-02f,
  -3.18100080e-02f, 2.29744222e-02f, 3.04120034e-02f, 1.66374873e-02f, -2.82942262e-02f, 8.67340937e-02f, 6.17941581e-02f, 2.04192251e-02f, -1.25273969e-02f, -1.35445446e-02f,
  4.19777781e-02f, 1.76903363e-02f, 1.91059746e-02f, 4.08578105e-02f, -7.08410330e-03f, -6.45985678e-02f, 6.09881319e-02f, 3.19146961e-02f, -2.70373225e-02f, -1.44021977e-02f,
  5.75531051e-02f, 8.12378004e-02f, 8.35478157e-02f, 7.83637166e-02f, 3.16345948e-03f, 1.09656416e-02f, 9.81801283e-03f, 7.98319578e-02f, -6.68771863e-02f, 4.24421951e-02f,
  -4.30961475e-02f, 4.95453849e-02f, -1.35457441e-01f, -1.10220322e-02f, 4.49050814e-02f, -1.03905484e-04f, -1.23891663e-02f, -1.75579917e-02f, 6.84617460e-02f, -6.73165768e-02f,
  -3.30607146e-01f, -3.26834559e-01f, -9.39479843e-02f, -1.30424940e-03f, -3.74373794e-02f, 8.49381555e-03f, 6.49717376e-02f, -8.98169950e-02f, -1.38917863e-01f, -1.24052521e-02f,
  1.42441737e-02f, 2.28759777e-02f, 6.82507828e-02f, 4.83244993e-02f, -3.16901729e-02f, -1.26799541e-02f, 1.07121870e-01f, -4.81264256e-02f, 6.83296286e-03f, -7.81240985e-02f,
  8.45686197e-02f, 3.61920968e-02f, 2.18665544e-02f, -3.03547848e-02f, -3.20795402e-02f, 2.79224105e-02f, -4.26516160e-02f, 3.23785692e-02f, 4.92429920e-02f, -3.84809896e-02f,
  -5.77090457e-02f, -1.50575623e-01f, -1.79455459e-01f, -2.14910612e-01f, 2.51834214e-01f, -3.40077937e-01f, -3.62412333e-01f, 9.06546116e-02f, -1.52696222e-01f, -1.09178317e-03f,
  -2.53494263e-01f, 4.16074805e-02f, -2.90303946e-01f, -3.31321090e-01f, -1.50585786e-01f, -4.29536074e-01f, -1.37078449e-01f, -2.21057802e-01f, -7.66236894e-03f, 2.69632377e-02f,
  -2.39563771e-02f, 8.27422887e-02f, -2.73538362e-02f, 3.02256197e-01f, -2.78098099e-02f, 2.80125320e-01f, 2.53793150e-01f, 1.05896801e-01f, 6.48190230e-02f, 8.54578018e-02f,
  -1.25428692e-01f, -9.55625921e-02f, 7.99336210e-02f, 3.28296944e-02f, 8.06612801e-03f, 2.80152056e-02f, 7.85809476e-03f, -7.84774125e-03f, 9.42586994e-05f, 9.31143202e-03f,
  -8.30511302e-02f, 2.44408529e-02f, 2.23598890e-02f, 1.97193995e-02f, 2.50420533e-02f, 1.34152081e-02f, -4.27059084e-02f, -6.02941168e-03f, 3.19924355e-02f, -9.39116105e-02f,
  -1.10684499e-01f, 1.58423663e-03f, 2.80656442e-02f, 2.01091655e-02f, -1.34400011e-03f, -2.32342258e-02f, 1.15535716e-02f, 1.94503882e-04f, 7.45417830e-03f, -1.73273049e-02f,
  2.21880656e-02f, 1.35868613e-03f, -4.80866991e-03f, 4.09240425e-02f, -4.70662192e-02f, -1.90150030e-02f, -2.67045863e-04f, -1.88214704e-03f, 2.30130963e-02f, -8.04063007e-02f,
  3.05338539e-02f, -1.89590864e-02f, -8.29879753e-03f, -8.55758786e-03f, 5.63419098e-03f, 4.16409113e-02f, 3.91241089e-02f, 6.33775815e-03f, -9.38918255e-03f, -4.04622257e-02f,
  -2.99016479e-03f, -3.65345888e-02f, 1.56083368e-02f, 1.79349054e-02f, 6.21966599e-03f, -9.25877411e-03f, -2.06248071e-02f, -1.13310320e-02f, -1.37911597e-02f, -2.67070476e-02f,
  -6.66684285e-02f, 6.85046017e-02f, -2.50689778e-02f, 3.40757072e-02f, -4.36980091e-02f, 1.38212787e-02f, -4.47501875e-02f, 2.32779272e-02f, 8.42595845e-02f, -1.15951532e-02f,
  9.97362584e-02f, -1.30889779e-02f, 1.59548283e-01f, 3.87770049e-02f, -8.39203969e-03f, -3.38263321e-03f, -1.47579359e-02f, 5.31876497e-02f, 1.22258849e-01f, 5.10058599e-03f,
  4.96838465e-02f, -4.05913405e-02f, 7.93882459e-02f, 9.69898030e-02f, 8.00344255e-03f, 2.05198508e-02f, 5.94527982e-02f, 3.16374823e-02f, 1.23582100e-02f, -3.23637463e-02f,
  -2.89430171e-01f, 3.70535962e-02f, -1.37899131e-01f, -3.80030930e-01f, -3.37615013e-02f, 2.31035173e-01f, 1.45402089e-01f, 1.13099389e-01f, -1.37897670e-01f, 2.49291077e-01f,
  1.61300853e-01f, -2.01337263e-01f, 4.33963835e-01f, -2.37019077e-01f, -2.67088443e-01f, 2.82518953e-01f, -6.53798878e-02f, 8.76112804e-02f, -4.20853011e-02f, -4.52311970e-02f,
  -5.32382317e-02f, -5.44952489e-02f, 5.00023514e-02f, 5.84811484e-03f, -2.30064973e-01f, -1.26119420e-01f, -2.63843656e-01f, -2.97402702e-02f, -2.97267973e-01f, -1.58760771e-01f,
  8.89892429e-02f, -4.83303554e-02f, -5.85331470e-02f, -4.56355279e-03f, -3.37708667e-02f, 7.11964890e-02f, 1.13528268e-02f, 1.35840066e-02f, -1.19575020e-02f, -1.18407207e-02f,
  5.91125078e-02f, -3.55856679e-02f, -7.69728795e-02f, 3.80240497e-04f, -5.66188768e-02f, -1.35408953e-01f, -7.39812404e-02f, 6.78009242e-02f, -6.25200123e-02f, -5.33138029e-02f,
  -1.52123859e-02f, -1.99110340e-02f, -5.19409999e-02f, -3.59305888e-02f, -7.59426430e-02f, -2.70223375e-02f, -5.50974943e-02f, -5.58180399e-02f, -9.04225186e-02f, -1.07312717e-01f,
  -1.16002830e-02f, 2.09546164e-02f, -4.79821786e-02f, -8.50206334e-03f, 3.26188542e-02f, 1.60074364e-02f, -4.33649775e-03f, -8.58706236e-03f, -7.44330063e-02f, -7.75461725e-04f,
  3.49653289e-02f, 5.42214327e-02f, 1.73951162e-03f, 6.01907745e-02f, -2.44838335e-02f, -9.82779893e-04f, 1.39193088e-01f, -2.33586300e-02f, 1.96641404e-02f, 1.73454881e-02f,
  8.69852770e-03f, 2.65670009e-02f, -1.18277818e-02f, -2.80905347e-02f, 5.96980937e-02f, -3.13250199e-02f, -8.24563354e-02f, -3.29020582e-02f, 1.04411587e-01f, 4.46244441e-02f,
  -3.96203920e-02f, -2.95066386e-01f, 4.87454832e-02f, 5.93705475e-02f, 9.45661869e-03f, 3.65269445e-02f, 1.96756218e-02f, -5.94362058e-02f, -1.42256141e-01f, 2.42159888e-02f,
  7.44896904e-02f, -2.12894231e-02f, 1.97984669e-02f, -8.00595731e-02f, 3.44203487e-02f, 4.04306240e-02f, 6.16720617e-02f, 1.07304258e-02f, -1.02314949e-01f, -6.21469729e-02f,
  3.01440340e-02f, 1.02545910e-01f, 4.09513041e-02f, 1.89635418e-02f, 6.42834529e-02f, 3.39944176e-02f, -9.64101870e-03f, 2.09721085e-02f, -6.34828210e-02f, 4.73220572e-02f,
  -4.64157164e-01f, -5.60109280e-02f, -1.37616679e-01f, -2.82747149e-01f, -8.36321637e-02f, -7.18050897e-02f, -1.56315342e-01f, -1.53290793e-01f, -2.67295629e-01f, -1.53900102e-01f,
  -1.40027821e-01f, -3.13131586e-02f, -3.27072069e-02f, -1.70184560e-02f, 2.16264486e-01f, 9.72438455e-02f, -1.77424848e-01f, -1.34411901e-01f, -2.25740522e-02f, -1.79877743e-01f,
  -2.71802787e-02f, 3.01587749e-02f, -3.33345053e-03f, 9.95742232e-02f, -1.76233768e-01f, -7.80683383e-02f, -5.22314906e-02f, 5.44964559e-02f, 4.26079854e-02f, 1.77134335e-01f,
  -6.28602356e-02f, -3.70417476e-01f, -1.18150115e-01f, -7.50598237e-02f, -1.18961200e-01f, -2.22717803e-02f, -2.19690707e-02f, 9.94034410e-02f, 3.74032184e-02f, -2.47798245e-02f,
  2.38663405e-02f, -1.69156287e-02f, 4.34236191e-02f, 3.82372290e-02f, -8.26354250e-02f, -1.32580176e-01f, -1.00333326e-01f, -8.85216966e-02f, -8.01332891e-02f, 8.16069730e-03f,
  -1.60729270e-02f, 1.02253491e-02f, -1.40270621e-01f, 7.30744470e-03f, 9.35417879e-03f, -4.30302247e-02f, 3.04785669e-02f, -1.36760632e-02f, -8.84217769e-02f, -7.64917806e-02f,
  4.76689301e-02f, -5.26372045e-02f, -4.44532074e-02f, -4.75681610e-02f, -1.58502813e-02f, 4.39334251e-02f, -6.16314746e-02f, 6.41029105e-02f, -3.71698965e-03f, -5.77324107e-02f,
  2.96474118e-02f, -5.58427013e-02f, -9.10781547e-02f, -2.44465228e-02f, 9.47079714e-03f, -7.93202743e-02f, 2.67835036e-02f, -7.23310560e-02f, 3.77115160e-02f, -4.81528565e-02f,
  -2.24964246e-02f, 6.14750609e-02f, -4.11414392e-02f, 3.71737815e-02f, -6.34224936e-02f, 5.72773591e-02f, -1.51769742e-02f, -1.23304399e-02f, 1.71893202e-02f, 8.88703540e-02f,
  -2.74881423e-01f, -2.79763818e-01f, -2.03035045e-02f, -1.32458627e-01f, 1.56721473e-02f, 1.08517837e-02f, 8.65419134e-02f, -2.30206773e-02f, -1.05590604e-01f, -5.00774160e-02f,
  -7.16529191e-02f, -1.73621997e-02f, -1.52077246e-03f, -2.95657180e-02f, 6.57001436e-02f, 5.66077903e-02f, 7.17217429e-03f, 2.07703970e-02f, -6.40185550e-02f, 6.26945111e-04f,
  -6.67592511e-02f, -6.92839175e-02f, 3.83764915e-02f, -8.03297237e-02f, 2.60965656e-02f, -2.93358266e-02f, -1.81427710e-02f, 5.76125160e-02f, -1.00183375e-02f, 4.91214022e-02f,
  4.24708992e-01f, -1.51662618e-01f, -2.52241105e-01f, 2.30840161e-01f, 8.07823166e-02f, 1.88125759e-01f, 4.52259593e-02f, 1.06473982e-01f, 4.55616089e-03f, 8.26220736e-02f,
  1.29528090e-01f, -2.30019629e-01f, -2.62379378e-01f, 2.93147981e-01f, -1.70416776e-02f, -2.65010297e-01f, 3.97627681e-01f, 1.14311904e-01f, -4.89168540e-02f, 1.28131241e-01f,
  3.10310367e-02f, 2.94923991e-01f, -1.07977487e-01f, 4.26906832e-02f, 1.89837828e-01f, -8.16562027e-02f, 1.61039069e-01f, -2.87567914e-01f, 2.71638960e-01f, 1.19862361e-02f,
  -1.62404947e-04f, -3.42565239e-03f, 1.43955350e-02f, -6.04296885e-02f, 5.59231341e-02f, 2.67106872e-02f, 8.26737359e-02f, -9.71708149e-02f, -9.10170600e-02f, -8.41197148e-02f,
  -4.19954397e-02f, -1.09644271e-02f, 1.70523338e-02f, -9.73933414e-02f, 6.76962063e-02f, -3.88652980e-02f, -1.38731971e-02f, 8.11351836e-02f, -5.99964894e-02f, -4.68214080e-02f,
  -5.10364026e-02f, 4.44976874e-02f, 1.22522049e-01f, 1.66737121e-02f, -3.25314701e-02f, -8.24092794e-03f, 3.29207350e-03f, -4.15811054e-02f, 4.54766713e-02f, 6.91727176e-02f,
  5.70219271e-02f, -1.52321439e-02f, -4.38231863e-02f, -4.85306829e-02f, -8.54100436e-02f, -3.31016537e-03f, 6.98225247e-03f, -1.03486627e-02f, -4.27696435e-03f, -1.90634187e-02f,
  7.11455243e-04f, -1.80650800e-02f, 4.82328683e-02f, 6.12546504e-03f, 7.31365606e-02f, 9.36382916e-03f, 6.28214050e-03f, -1.13501912e-02f, 2.54508983e-02f, 1.30055491e-02f,
  -5.94789125e-02f, -1.65778995e-02f, -6.05618842e-02f, 5.99081479e-02f, 1.73968244e-02f, 1.33696273e-02f, 3.48223001e-02f, 2.21734037e-04f, 8.68816301e-03f, 1.62303671e-02f,
  9.64689404e-02f, 1.72639154e-02f, -5.17542586e-02f, -5.94216457e-04f, -1.03561185e-01f, 2.20176242e-02f, -6.82425126e-02f, 4.45043780e-02f, 7.52144121e-03f, -1.24664661e-02f,
  9.11856443e-02f, 7.22404644e-02f, 2.92996727e-02f, 3.53641361e-02f, -5.67879304e-02f, 3.63405906e-02f, 9.47486982e-03f, -9.20145679e-03f, 8.79847482e-02f, 8.38410780e-02f,
  -1.21559883e-02f, -2.58765905e-03f, -4.86642569e-02f, 7.86650255e-02f, 7.32407421e-02f, 2.60740258e-02f, 2.55120937e-02f, 2.76839361e-04f, 4.80261929e-02f, -4.07813080e-02f,
  -6.30377084e-02f, -1.39136286e-02f, -2.61350006e-01f, -3.51446092e-01f, 2.51531720e-01f, -6.97564110e-02f, -3.22245568e-01f, 5.15437126e-02f, -3.58650796e-02f, 1.13718547e-01f,
  1.73070803e-01f, -1.67137563e-01f, -2.45706625e-02f, -4.39247116e-02f, -3.77419293e-01f, -1.12513058e-01f, -2.78162897e-01f, -1.12852966e-02f, 3.99845429e-02f, -1.08930804e-01f,
  -2.67998148e-02f, 1.40107945e-01f, -1.58898190e-01f, 1.57985583e-01f, 1.70187727e-01f, -1.57736361e-01f, 2.95071267e-02f, -2.15095654e-02f, 1.11918509e-01f, 6.92346171e-02f,
  1.21048830e-01f, -6.25240281e-02f, -3.22693191e-03f, -4.90336120e-02f, -1.19694369e-02f, 3.12043075e-02f, -1.09360898e-02f, -7.24252537e-02f, -6.17409199e-02f, -5.02357334e-02f,
  -2.33498979e-02f, -2.28303149e-02f, -2.72615068e-02f, 6.34706542e-02f, 8.29696581e-02f, 3.17694508e-02f, 2.90840659e-02f, 1.12031154e-01f, 4.33794558e-02f, 1.73197291e-03f,
  -1.87071953e-02f, 4.18994799e-02f, -8.51193070e-02f, -1.29597886e-02f, -5.58014959e-02f, -4.42271680e-02f, -5.08785956e-02f, -4.42574359e-02f, -2.36631315e-02f, -5.87222073e-03f,
  -4.76385094e-02f, 1.89811867e-02f, -2.64037047e-02f, 3.05279512e-02f, -3.70830335e-02f, 1.03696011e-01f, -2.53574401e-02f, 8.05572793e-02f, -9.88070369e-02f, -2.61738859e-02f,
  -1.00113014e-02f, -5.96774444e-02f, -6.76934328e-03f, -1.68934762e-02f, -2.17705220e-02f, -5.20820469e-02f, -1.06732897e-03f, -2.29551941e-02f, 5.67714311e-02f, 5.68289682e-03f,
  -3.90767269e-02f, -1.30886445e-02f, -3.69755737e-02f, -4.92895627e-03f, -2.80409958e-02f, 1.55654857e-02f, 1.04779966e-01f, 4.15110178e-02f, 7.97007605e-03f, -1.53257493e-02f,
  -6.80304691e-02f, -3.30546111e-01f, -6.39909729e-02f, -9.37694162e-02f, -1.85838733e-02f, 5.74580841e-02f, 5.90697862e-02f, -1.41164456e-02f, -7.07648098e-02f, 5.16033359e-03f,
  -7.07625691e-03f, 7.37295672e-02f, 2.62665022e-02f, 5.40122576e-02f, -3.64013724e-02f, 6.67503029e-02f, -6.69898391e-02f, -2.93231960e-02f, -1.66514412e-01f, 3.36172841e-02f,
  -4.00543120e-03f, -1.53924087e-02f, -7.23373592e-02f, 2.21986752e-02f, 3.23372111e-02f, -5.00928573e-02f, 1.40573243e-02f, 5.12560457e-02f, -2.90773734e-02f, 8.58393777e-03f,
  -9.12478417e-02f, -2.06778854e-01f, 1.40775844e-01f, -3.01183313e-01f, -2.68227488e-01f, -3.36742848e-01f, 2.90046744e-02f, -2.23926008e-01f, -2.66930819e-01f, 2.14933261e-01f,
  -6.44192174e-02f, 1.35782048e-01f, 1.86227903e-01f, -2.32195079e-01f, -2.05990508e-01f, 1.39824763e-01f, -1.62541211e-01f, 5.35641015e-02f, -2.02641577e-01f, -9.30212215e-02f,
  -1.75151065e-01f, -1.92340478e-01f, 1.17972255e-01f, -2.30478331e-01f, -8.64477083e-02f, -4.26878035e-02f, 1.37929022e-01f, 5.44035435e-02f, -1.79098677e-02f, -1.22322075e-01f,
  -1.17986619e-01f, -6.57896027e-02f, 6.42126948e-02f, 1.23851635e-02f, 3.70968282e-02f, 2.28474587e-02f, 8.83832350e-02f, -1.33097153e-02f, -5.54375872e-02f, 7.65881781e-03f,
  4.98223267e-02f, -6.65023103e-02f, -9.69278589e-02f, -3.14177722e-02f, -2.21621450e-02f, 1.52430590e-02f, -4.27812971e-02f, 2.15370171e-02f, 1.19845327e-02f, -8.76470096e-03f,
  1.42008218e-03f, -3.77787626e-03f, 5.61279692e-02f, 4.98912446e-02f, 3.22352513e-03f, -5.99715523e-02f, -5.22012496e-03f, 2.85041537e-02f, -5.07190712e-02f, -6.45798817e-02f,
  -6.49058297e-02f, -1.01232519e-02f, 3.46180536e-02f, 4.30261903e-03f, -8.58437344e-02f, -1.21975444e-01f, 3.81584428e-02f, 1.18680503e-02f, -1.06807444e-02f, 6.82527050e-02f,
  4.99119982e-02f, -1.46857146e-02f, -3.06926351e-02f, -3.83314341e-02f, -1.24117518e-02f, -3.91785577e-02f, 6.75041303e-02f, -1.71217031e-03f, -8.01347941e-03f, 6.92322701e-02f,
  -4.33863066e-02f, -1.51253104e-01f, 6.03707694e-02f, 1.04902595e-01f, -5.43217249e-02f, 2.06183325e-02f, 5.04616909e-02f, 6.53740540e-02f, -2.06095562e-03f, 8.51642713e-02f,
  -1.16462663e-01f, -6.99678138e-02f, -2.80447807e-02f, -4.24958169e-02f, 6.80904910e-02f, -4.17478941e-02f, -4.23233919e-02f, -9.44087431e-02f, 9.22114216e-03f, -1.01248264e-01f,
  -5.04063629e-02f, 4.30562794e-02f, 1.12807818e-01f, -3.00198626e-02f, 1.17882546e-02f, 1.56054078e-02f, 5.11212740e-03f, 5.37804365e-02f, 3.36675905e-02f, 3.93866748e-03f,
  6.90520033e-02f, 1.54850530e-02f, 7.87429791e-03f, -7.64991716e-02f, -3.91084282e-03f, 8.87024626e-02f, -5.04028015e-02f, -3.82007062e-02f, -1.45811299e-02f, 6.78917170e-02f,
  1.82566181e-01f, -2.08732754e-01f, -2.14662105e-02f, 8.43929779e-03f, -2.02670097e-01f, 1.41694933e-01f, 8.84614587e-02f, -3.40087414e-01f, 1.48533955e-01f, -1.25802204e-01f,
  2.36750077e-02f, 3.80911529e-01f, 6.98392019e-02f, 7.53469169e-02f, 4.39616323e-01f, 2.58991867e-01f, 2.29397565e-01f, 1.97730839e-01f, 9.65360031e-02f, -8.63859504e-02f,
  7.04593584e-02f, -1.60278946e-01f, -8.22871253e-02f, -3.24733764e-01f, -2.81406760e-01f, -1.93089262e-01f, -2.10715353e-01f, -1.28163949e-01f, -1.30699620e-01f, 1.11675091e-01f,
  5.95830604e-02f, -5.73024750e-02f, -6.90612122e-02f, 7.56508438e-04f, -2.94034183e-02f, -4.00587432e-02f, 6.44428730e-02f, 4.69399914e-02f, 8.08355361e-02f, 2.16812938e-02f,
  7.56972134e-02f, -1.60625186e-02f, -3.79510634e-02f, -6.83853999e-02f, -8.52141250e-03f, 4.84086992e-03f, 1.37602938e-02f, 3.93528715e-02f, -2.11252477e-02f, 3.21318060e-02f,
  4.61201407e-02f, 3.33845429e-02f, 9.73119065e-02f, 4.91911769e-02f, 4.96911369e-02f, 8.22167248e-02f, -5.88858454e-03f, 8.18815082e-02f, 1.09109245e-02f, 1.17110172e-02f,
  -6.66216612e-02f, 1.55580733e-02f, 2.22502146e-02f, -3.98355071e-03f, 1.49251344e-02f, -1.90175306e-02f, 6.45279698e-03f, 2.14168131e-02f, 6.33771345e-02f, -1.80974007e-02f,
  1.07434858e-02f, -5.33224754e-02f, -6.04283772e-02f, -4.19095978e-02f, 1.49826203e-02f, -8.04886669e-02f, 4.12950777e-02f, -4.19288576e-02f, -4.34262082e-02f, 5.86764561e-03f,
  -1.46253752e-02f, 1.75715145e-02f, 7.18915137e-03f, -5.50545789e-02f, 2.93608829e-02f, -1.36630153e-02f, -4.44114469e-02f, -8.86487067e-02f, 2.75850445e-02f, -7.29469163e-03f,
  1.67968180e-02f, -1.38516039e-01f, -2.49556024e-02f, 7.24924379e-04f, 9.61166471e-02f, 1.53742423e-02f, 2.21040081e-02f, -3.64040211e-02f, -1.54762631e-02f, -4.43476439e-02f,
  -2.29407866e-02f, -4.87763882e-02f, -3.76704074e-02f, 2.25116927e-02f, 1.12448810e-02f, -2.88150236e-02f, 2.86090355e-02f, 3.36887799e-02f, -1.91376675e-02f, -5.25832213e-02f,
  -7.41366223e-02f, -1.52781950e-02f, 3.82998846e-02f, -5.69053665e-02f, -2.41211168e-02f, 6.47712173e-03f, 3.61212641e-02f, -2.63658129e-02f, -2.42687296e-02f, 6.34107366e-03f,
  -1.18215929e-03f, 2.76291706e-02f, 1.68746859e-01f, -6.55130967e-02f, 1.59458995e-01f, 2.45956481e-01f, 2.74684012e-01f, -1.12842198e-03f, 2.54503846e-01f, -2.42253110e-01f,
  -1.46501223e-02f, -2.46473536e-01f, 2.14197040e-01f, -9.01076123e-02f, -4.35502306e-02f, 2.85047382e-01f, -7.88669288e-02f, -2.02741418e-02f, 1.47995263e-01f, -8.80727321e-02f,
  6.61506504e-02f, -2.19083339e-01f, 5.18568605e-03f, -1.20104142e-01f, -9.10913944e-02f, -2.61196382e-02f, -3.06315303e-01f, 1.23091668e-01f, -2.00894058e-01f, 2.87064873e-02f,
  1.02699161e-01f, 7.80252591e-02f, 1.11742197e-02f, 4.18550931e-02f, -7.99636617e-02f, -6.45059953e-03f, -6.99737156e-03f, 6.28062934e-02f, 8.91327113e-02f, 1.98853798e-02f,
  -7.93664008e-02f, -9.81141254e-02f, -1.22136690e-01f, 3.50007527e-02f, 1.11764953e-01f, -5.46546876e-02f, 3.36539745e-02f, -4.63050278e-03f, -3.93681824e-02f, 3.16633768e-02f,
  4.42833779e-03f, 4.86432537e-02f, -6.54617250e-02f, -3.94893400e-02f, 1.05701666e-02f, 8.45523477e-02f, 3.77145857e-02f, -1.73351169e-02f, -4.94448319e-02f, -2.48614270e-02f,
  -3.02042370e-03f, 9.17565748e-02f, -1.92169547e-02f, 4.33742814e-02f, -3.05006374e-02f, 4.46568541e-02f, -4.41960990e-02f, -2.04584189e-02f, 2.70825569e-02f, -2.62829252e-02f,
  -7.48764724e-02f, 2.13405886e-03f, -4.68881382e-03f, 4.61820588e-02f, -9.68776643e-03f, -4.12481977e-03f, -2.68017780e-03f, -3.27514522e-02f, -1.53430551e-02f, -2.35137790e-02f,
  8.99862591e-03f, 6.88601285e-02f, -3.90924774e-02f, -1.79065634e-02f, 5.15552871e-02f, 3.44604477e-02f, -4.55901176e-02f, 8.53271747e-04f, 9.73362476e-02f, -4.80388552e-02f,
  -6.96824268e-02f, -1.04651898e-01f, -8.78915004e-03f, 2.11527143e-02f, 2.62661129e-02f, -8.36560205e-02f, 1.36186751e-02f, -3.00550163e-02f, -1.11766551e-02f, -4.12746519e-02f,
  -3.58848795e-02f, 8.48134863e-04f, -4.25617173e-02f, 4.01127413e-02f, -3.76979262e-02f, -1.59250516e-02f, -3.12987156e-02f, 6.77145422e-02f, -1.00281104e-01f, -4.87053096e-02f,
  -4.78347503e-02f, 4.47145626e-02f, -5.64026646e-02f, -1.18276536e-01f, -3.46745439e-02f, -5.36775626e-02f, -5.72137907e-02f, 4.47151661e-02f, -5.52187711e-02f, 1.61544457e-02f,
  3.36245656e-01f, -7.94674978e-02f, -1.36236802e-01f, 1.12645917e-01f, -5.82632609e-02f, -7.58953243e-02f, -2.77389698e-02f, -4.90577966e-02f, -1.50761157e-01f, 8.49219486e-02f,
  -1.09725721e-01f, 1.97870091e-01f, -2.53844768e-01f, 6.91056475e-02f, 1.12590417e-01f, -3.03419709e-01f, 2.14105561e-01f, 1.69347629e-01f, -1.07348286e-01f, 1.01645134e-01f,
  8.06926116e-02f, 1.81413352e-01f, -8.43055248e-02f, -4.79547307e-02f, 1.14013307e-01f, 4.93167415e-02f, 3.33857149e-01f, -1.65409103e-01f, 2.32060194e-01f, 2.45580971e-02f,
  -1.22080877e-01f, -8.40993971e-02f, -5.46018519e-02f, 3.31059545e-02f, -2.07002312e-02f, -8.95527564e-03f, 4.22109477e-02f, -2.07813606e-02f, -5.79405092e-02f, -5.54438159e-02f,
  4.65058349e-02f, 8.77312571e-02f, 7.12237805e-02f, -1.48631213e-02f, 3.64184491e-02f, -3.04338746e-02f, -4.92651649e-02f, -7.95478653e-03f, -5.27835079e-02f, -3.65769826e-02f,
  -5.63924126e-02f, -9.47119016e-03f, 9.47315842e-02f, 6.23840727e-02f, 1.42115410e-02f, -3.38939913e-02f, 3.76166031e-02f, 4.63682003e-02f, 6.59959689e-02f, 1.96835436e-02f,
  6.47090077e-02f, 3.77344228e-02f, -1.95204988e-02f, -1.55946724e-02f, -6.32970631e-02f, -1.60320196e-02f, 1.87451579e-02f, 2.71317139e-02f, -1.29900342e-02f, -2.67238691e-02f,
  5.61920851e-02f, 5.41122742e-02f, 7.36699300e-03f, 1.57772042e-02f, 5.89434206e-02f, 2.79184133e-02f, 9.65977982e-02f, -2.08556908e-03f, 5.14083402e-03f, -5.51833436e-02f,
  2.39072293e-02f, -3.54259671e-03f, -6.58215359e-02f, 5.02995495e-03f, -6.67706691e-03f, -2.79146079e-02f, 6.13891035e-02f, -5.83445877e-02f, -5.64919449e-02f, 5.16332164e-02f,
  6.41165748e-02f, 3.21711212e-01f, -4.39114086e-02f, 2.10788362e-02f, -2.81392708e-02f, 2.00942326e-02f, 1.76814850e-02f, 4.41238135e-02f, 2.23252736e-02f, -3.10081411e-02f,
  7.50770494e-02f, -8.96691531e-03f, 1.00390047e-01f, -1.11389151e-02f, 3.81040573e-02f, -3.58379036e-02f, 5.73626533e-02f, 9.63826999e-02f, 1.55248106e-01f, 1.11979134e-02f,
  9.31589976e-02f, 7.08141401e-02f, 9.08283517e-02f, -3.39893028e-02f, 7.40376338e-02f, 6.09050244e-02f, 5.43843210e-02f, -8.86818767e-03f, 1.57400016e-02f, 5.10121603e-03f,
  3.22505474e-01f, -2.32834071e-01f, 1.79042995e-01f, 4.08108026e-01f, -1.71174631e-02f, -7.16044158e-02f, 1.16828794e-03f, 2.80195381e-02f, 4.61630553e-01f, -1.85564920e-01f,
  -2.57668465e-01f, 2.29207892e-02f, -2.94896573e-01f, -2.54465323e-02f, -4.83291373e-02f, -1.72134880e-02f, 2.29578931e-02f, 1.54532969e-01f, 9.79267731e-02f, -2.40797754e-02f,
  9.98391509e-02f, -2.40969121e-01f, -1.09617405e-01f, -2.06374913e-01f, -1.76914230e-01f, 1.84648991e-01f, -2.32827827e-01f, 2.55309921e-02f, -6.66610524e-02f, -2.76708156e-02f,
  -2.02730652e-02f, 1.34841189e-01f, -6.91649988e-02f, -4.60285917e-02f, 2.46586632e-02f, 3.42864096e-02f, -2.96814702e-02f, -5.77253066e-02f, 2.15012580e-02f, -2.63297441e-03f,
  3.33379768e-02f, -2.35417709e-02f, 9.96057987e-02f, 4.85248119e-02f, 1.08564913e-01f, 1.89425945e-02f, -4.44910256e-03f, 1.84901375e-02f, -9.00086686e-02f, 9.42246839e-02f,
  5.20734349e-03f, -2.28475407e-03f, 8.65788385e-03f, -5.67433722e-02f, -4.60747182e-02f, 7.89932609e-02f, 4.66694823e-03f, 7.98002779e-02f, -1.79933198e-03f, 1.21443480e-01f,
  -3.31182941e-03f, 9.42092165e-02f, 7.26487562e-02f, -3.30127194e-03f, -4.61194012e-03f, -6.12106035e-03f, 2.26664962e-03f, -1.54570099e-02f, 3.75263393e-02f, -3.48931812e-02f,
  -1.13099124e-02f, 4.34069559e-02f, 6.32514432e-02f, 8.35574493e-02f, 5.34822755e-02f, 7.27216378e-02f, 1.34892175e-02f, 3.55761237e-02f, 7.50746951e-02f, -2.89807981e-03f,
  -6.16726913e-02f, 5.98984845e-02f, -1.08792216e-01f, 4.87562120e-02f, 8.06693360e-03f, 2.36240216e-02f, 4.26723436e-03f, 9.41004157e-02f, 3.74020934e-02f, -1.50984079e-01f,
  -2.56602943e-01f, -1.31426781e-01f, -3.46038342e-02f, -9.29684415e-02f, 9.42705665e-03f, -6.29412085e-02f, 3.52798291e-02f, -3.71863693e-02f, -7.99904466e-02f, -7.97713771e-02f,
  1.08963802e-01f, 2.36204732e-02f, -7.21798390e-02f, 8.62008184e-02f, -1.01492390e-01f, -1.10599920e-01f, 4.33522277e-02f, -1.00201853e-01f, -6.93981797e-02f, -1.45906499e-02f,
  -1.24863751e-01f, -8.50744769e-02f, -1.98772941e-02f, -5.62068000e-02f, 1.66151803e-02f, -1.05224140e-01f, 5.90990484e-02f, 9.48407650e-02f, -1.78844556e-02f, -7.92025030e-02f,
  -3.32354754e-01f, 3.89524728e-01f, -3.42027158e-01f, -2.97362860e-02f, 6.05558939e-02f, 2.97105014e-01f, -6.39518872e-02f, 8.42748657e-02f, -2.42719073e-02f, 3.16020966e-01f,
  1.47532895e-01f, -6.47876710e-02f, -1.07002251e-01f, 3.21532011e-01f, 3.65949906e-02f, 1.72194354e-02f, 2.81232864e-01f, 1.65413767e-01f, -2.55535394e-02f, 6.47885576e-02f,
  -6.80749491e-02f, 4.63894337e-01f, -1.94114298e-01f, 3.09223384e-01f, -9.76625457e-02f, -1.53696194e-01f, 2.02388912e-02f, -1.48818299e-01f, 1.80765718e-01f, 4.34011519e-02f,
  3.52791580e-03f, -1.32290274e-02f, -7.91457295e-02f, -6.12721071e-02f, -1.84569098e-02f, -9.65728387e-02f, -1.09826528e-01f, -6.12983927e-02f, -8.97598043e-02f, 8.02260712e-02f,
  -4.38514575e-02f, 5.79364896e-02f, 7.18468204e-02f, 6.60641938e-02f, -2.50991061e-02f, 1.44625865e-02f, -5.02239205e-02f, -6.30780831e-02f, 4.17267233e-02f, -9.55717787e-02f,
  -7.02996552e-02f, -8.63098204e-02f, -8.93366411e-02f, -1.38931088e-02f, -6.89763203e-02f, 1.53080355e-02f, -6.16473444e-02f, -1.70705840e-02f, 9.10063684e-02f, 9.67442542e-02f,
  2.66968813e-02f, -8.25732481e-03f, -8.06320645e-03f, 1.83443027e-03f, 7.63908327e-02f, -4.85788584e-02f, 7.75874928e-02f, -1.25995800e-02f, -9.69570130e-02f, 6.47767857e-02f,
  -1.35535933e-02f, -1.39906667e-02f, 7.70871900e-03f, -5.33859842e-02f, -2.26645842e-02f, -9.62747410e-02f, -8.69188309e-02f, 1.33412248e-02f, -5.79532310e-02f, -3.46958861e-02f,
  -7.15206712e-02f, 7.13044032e-03f, 4.75394819e-03f, -6.84993342e-02f, 8.20703283e-02f, 1.75765306e-02f, 6.22898452e-02f, -4.80436571e-02f, -3.05422465e-03f, -5.39291948e-02f,
  2.15031207e-01f, 3.26867163e-01f, -6.31468892e-02f, 7.68709630e-02f, 1.01820566e-01f, 4.55844998e-02f, -3.82876908e-03f, 8.14822838e-02f, 6.47055134e-02f, 2.09502187e-02f,
  -1.51022477e-02f, -9.22133923e-02f, -6.89233541e-02f, 3.02616358e-02f, 1.19211428e-01f, 1.62963308e-02f, 1.28991939e-02f, 1.17260953e-02f, 4.58770315e-04f, 6.60562292e-02f,
  2.27020308e-02f, 1.45776430e-02f, -2.50401124e-02f, 1.01636127e-01f, 1.11873373e-01f, -2.84584593e-02f, 4.83242497e-02f, -1.60748772e-02f, -4.07966785e-02f, 4.36250158e-02f
};

// L0_fan_Wp_bar (Shape: 26 x 120)
const int L0_fan_Wp_bar_rows = 26;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -4.97144252e-01f, 5.64459085e-01f, -2.28271201e-01f, 6.66427091e-02f, -2.56483078e-01f, 7.03231037e-01f, 5.53301871e-01f, 4.37937900e-02f, 1.83472559e-01f, 4.51056719e-01f,
  9.90741029e-02f, 2.13484280e-02f, 2.12866202e-01f, 4.40149307e-01f, 6.17753109e-03f, 4.29529667e-01f, 4.38393325e-01f, 2.80772865e-01f, -2.50399671e-02f, -2.21787505e-02f,
  -1.36002362e-01f, 3.14902276e-01f, -1.25928357e-01f, -1.02602422e-01f, -1.63684919e-01f, -3.03558499e-01f, -1.93137258e-01f, -2.99208015e-01f, 3.14821191e-02f, -2.52427310e-02f,
  1.47878289e-01f, -2.22226784e-01f, -1.53859094e-01f, -3.45834382e-02f, -8.36655274e-02f, -1.43005610e-01f, -1.10162355e-01f, -8.99475515e-02f, -1.32547572e-01f, -1.39307678e-02f,
  2.49269716e-02f, -3.72431949e-02f, 3.74849066e-02f, -3.47416624e-02f, -7.61799738e-02f, -6.50715604e-02f, 2.99776737e-02f, -5.01600169e-02f, 9.23276618e-02f, -7.26998374e-02f,
  -3.11093708e-03f, -8.51273444e-03f, -2.79098805e-02f, 1.05435573e-01f, -9.39500108e-02f, 3.93143184e-02f, 1.00220650e-01f, -5.18543199e-02f, 1.25547111e-01f, 4.90133278e-02f,
  -5.24802543e-02f, -2.93019461e-03f, 7.87815079e-02f, -3.35706435e-02f, 1.10070733e-02f, -9.33658928e-02f, 5.65817542e-02f, -5.27228042e-02f, 1.28636882e-02f, 2.61510685e-02f,
  -5.01835952e-03f, -2.14927904e-02f, -2.24131178e-02f, 7.15605021e-02f, 6.74089715e-02f, -3.41825187e-02f, -7.51047656e-02f, -8.98107886e-03f, 1.66495256e-02f, -2.62507275e-02f,
  -5.49653433e-02f, 8.88859332e-02f, 7.55126327e-02f, 2.00918075e-02f, 4.36729528e-02f, -9.81282517e-02f, 5.53996954e-03f, 2.40660477e-02f, -2.19073370e-02f, -1.02941513e-01f,
  3.48264545e-01f, 2.36224249e-01f, 1.09320626e-01f, 2.42388546e-02f, -5.05477712e-02f, -8.21507573e-02f, 4.99365181e-02f, -5.51015185e-03f, 1.38528883e-01f, 1.42099280e-02f,
  -4.04247604e-02f, 5.41654713e-02f, 1.17062004e-02f, -4.25656922e-02f, 2.67055687e-02f, 1.91242069e-01f, 4.73961383e-02f, -6.57141879e-02f, 2.67017893e-02f, -4.92587574e-02f,
  -2.39336397e-02f, -5.24386838e-02f, -3.46144475e-02f, 4.36077379e-02f, 1.81156602e-02f, 4.89017926e-02f, 1.02254041e-02f, -3.75030935e-02f, -5.89227751e-02f, 8.45399573e-02f,
  -7.51097322e-01f, 2.96218365e-01f, 1.64445698e-01f, -4.41755980e-01f, 3.11900616e-01f, 4.21929300e-01f, -4.00382504e-02f, 1.56908289e-01f, 1.76249340e-01f, 8.90412033e-02f,
  -1.25293285e-02f, -3.63308229e-02f, 4.84864935e-02f, -1.78132042e-01f, -4.94959474e-01f, -1.76066533e-01f, -1.68758884e-01f, -9.53006595e-02f, 1.94658235e-01f, -1.71477031e-02f,
  -8.15056860e-02f, -2.20141277e-01f, -3.59563768e-01f, 2.47369081e-01f, -1.67877097e-02f, 1.25228837e-01f, -1.56208247e-01f, 3.97478521e-01f, -7.47867301e-02f, 7.01768324e-02f,
  -8.25777128e-02f, 5.41066471e-03f, -3.50757129e-02f, 7.87104815e-02f, 5.39072268e-02f, 4.34224568e-02f, 9.44409519e-02f, -4.87931743e-02f, -7.74482777e-03f, 1.32110687e-02f,
  -4.81950752e-02f, 1.27149656e-01f, -3.24202813e-02f, -2.18071993e-02f, 1.73875034e-01f, 6.19711578e-02f, 7.18210936e-02f, -9.51545499e-03f, 1.09676003e-01f, -4.95462194e-02f,
  -1.58221677e-01f, 8.85381028e-02f, 6.40439466e-02f, 6.57660738e-02f, 4.75600436e-02f, 9.87946019e-02f, 5.48076406e-02f, 2.37402059e-02f, 8.94051883e-03f, 4.36598361e-02f,
  -4.15733363e-03f, 9.92200226e-02f, 2.97441352e-02f, 3.97152500e-03f, 1.76913477e-02f, -2.05324329e-02f, 5.11581684e-03f, -1.45497516e-01f, 7.33379573e-02f, -5.21934545e-03f,
  2.11826358e-02f, 1.02578111e-01f, -1.82548407e-02f, 1.88676873e-03f, -3.68076302e-02f, -1.45564839e-01f, -2.69753281e-02f, 1.54878814e-02f, 1.17035210e-03f, -1.14483267e-01f,
  -8.37344453e-02f, -1.69332847e-02f, -7.71662816e-02f, -5.34514077e-02f, -3.07664257e-02f, -2.08065547e-02f, 1.68296903e-01f, -4.14884090e-02f, -5.45983911e-02f, 6.82383925e-02f,
  2.51074910e-01f, 4.54986095e-01f, 6.31340593e-02f, 1.35835838e-02f, 6.62109703e-02f, -2.95119006e-02f, 7.37226829e-02f, -2.19104486e-03f, 4.77268286e-02f, 5.75639270e-02f,
  -3.37196290e-02f, 4.94874567e-02f, 1.48790866e-01f, -9.89728719e-02f, -9.89427418e-02f, -5.04213497e-02f, 9.97115672e-03f, 9.47748050e-02f, 6.84783757e-02f, 5.59958108e-02f,
  2.18046885e-02f, 7.68779665e-02f, 1.15646643e-03f, 5.33994399e-02f, -2.62516253e-02f, -2.25647371e-02f, -2.76507847e-02f, -2.54464205e-02f, -1.63255744e-02f, 6.24608248e-02f,
  3.36781889e-01f, 2.43135571e-01f, -2.50846416e-01f, -3.06488007e-01f, -2.30956227e-01f, 4.78968382e-01f, 2.70769179e-01f, -9.06050801e-02f, -2.32751176e-01f, 1.64382100e-01f,
  6.91931248e-02f, -2.42765155e-02f, 2.36197576e-01f, 2.58560121e-01f, 1.65804610e-01f, 3.99269611e-01f, 2.23337546e-01f, 8.07538033e-02f, -3.55960019e-02f, 1.68544114e-01f,
  -5.28454483e-02f, 2.99671739e-01f, 1.68024711e-02f, -2.10655760e-02f, 1.96090952e-01f, -3.06509435e-01f, -2.52591252e-01f, -1.04293376e-01f, -1.59334809e-01f, -3.26299928e-02f,
  1.84202850e-01f, 8.16731006e-02f, 4.63316999e-02f, 4.54586595e-02f, 1.26765579e-01f, 8.43982026e-02f, -3.15226465e-02f, -1.23123536e-02f, -9.20874327e-02f, -5.68103865e-02f,
  4.97477204e-02f, -2.11575604e-03f, 1.63173787e-02f, -5.99156991e-02f, 2.85068024e-02f, -6.75667599e-02f, -3.84923890e-02f, -4.81963977e-02f, -2.82372092e-03f, 1.28504962e-01f,
  2.99889520e-02f, 5.70766581e-03f, -3.40568870e-02f, -3.66875194e-02f, -1.19111404e-01f, -4.57693562e-02f, 5.96937388e-02f, 2.22718529e-02f, 4.97017205e-02f, -4.01396118e-02f,
  -2.37906771e-03f, 6.96425140e-02f, 1.26387596e-01f, 5.27797714e-02f, 8.56909752e-02f, -8.56010467e-02f, -2.08574310e-02f, 5.99950925e-03f, -7.08498210e-02f, 9.87321138e-02f,
  -9.09674764e-02f, -3.87792923e-02f, 1.20892085e-01f, -2.39185710e-02f, -4.88409661e-02f, 4.47414592e-02f, -3.07874251e-02f, 2.01755064e-03f, -3.75811644e-02f, -1.63969576e-01f,
  -6.07600808e-02f, -4.86917421e-03f, 1.17214687e-01f, -1.18439466e-01f, 9.40716937e-02f, 5.84699539e-03f, 4.35122922e-02f, 6.61953464e-02f, -3.73767167e-02f, 1.00746052e-02f,
  1.30753815e-01f, 7.74461627e-02f, 3.10606416e-02f, -6.17978983e-02f, -1.10699050e-02f, 1.40521765e-01f, 5.66732436e-02f, -6.48256317e-02f, -5.04540280e-02f, 1.22325368e-01f,
  -9.78527665e-02f, -8.21266770e-02f, -1.03911243e-01f, -6.52935281e-02f, -1.65034369e-01f, 5.21146841e-02f, 1.94630120e-02f, -8.85055885e-02f, -1.04958996e-01f, -1.03668697e-01f,
  -7.45347738e-02f, 4.99738380e-02f, 1.20086130e-02f, -2.11827364e-02f, -1.00084260e-01f, 1.92955714e-02f, 3.62714417e-02f, 2.09829193e-02f, -1.28327971e-02f, -1.68871865e-01f,
  -5.36831506e-02f, 3.72953206e-01f, 2.32083917e-01f, 4.97253627e-01f, -3.58368456e-01f, -5.34153640e-01f, -1.52012944e-01f, -5.48530258e-02f, 1.93489552e-01f, 2.60190219e-01f,
  1.78925991e-01f, 2.44867712e-01f, -4.37103622e-02f, 3.93909872e-01f, -5.28961062e-01f, 1.56323433e-01f, 4.00530994e-02f, 2.02909052e-01f, -4.65045460e-02f, -1.84185375e-02f,
  7.52696991e-02f, -3.84690538e-02f, 1.46596313e-01f, -1.95133731e-01f, -8.40540975e-03f, 2.25861594e-01f, -4.32183295e-02f, -1.04391456e-01f, 4.28972691e-02f, -1.77375346e-01f,
  -2.10241660e-01f, 2.80849576e-01f, 1.79061666e-01f, -4.02362943e-02f, -6.57891110e-02f, -9.54498276e-02f, 9.44975913e-02f, -8.98668841e-02f, 4.22187522e-02f, 2.29555424e-02f,
  -2.25433726e-02f, -6.17684014e-02f, -6.14497326e-02f, -5.63947111e-02f, 4.80858982e-02f, 4.10439521e-02f, -1.25730513e-02f, 4.05116379e-02f, 6.04390949e-02f, 8.84799063e-02f,
  1.26453236e-01f, 9.22732428e-02f, -1.69924423e-02f, 5.30327745e-02f, -3.06199379e-02f, -3.62742394e-02f, -3.16457823e-02f, -1.51374396e-02f, 2.38187984e-02f, 8.82891845e-03f,
  8.52651596e-02f, -3.45448814e-02f, 5.33324778e-02f, 2.34600692e-03f, -1.85926799e-02f, 8.44486058e-02f, 2.52666380e-02f, -7.14172646e-02f, 6.13275077e-03f, -8.29897299e-02f,
  -1.21943839e-01f, 1.10616699e-01f, -1.21442787e-01f, -3.35526466e-03f, 5.96195497e-02f, 7.56758898e-02f, -4.39073220e-02f, -2.95226779e-02f, 4.79967194e-03f, -3.54862511e-02f,
  2.50811204e-02f, -1.29574105e-01f, 5.70493490e-02f, -2.82761622e-02f, -6.28108755e-02f, -1.48445787e-02f, 1.16870262e-01f, 1.36941776e-01f, -3.90564129e-02f, -2.73190081e-01f,
  -3.81045789e-01f, -4.03838940e-02f, -2.25983206e-02f, -1.16807066e-01f, 4.52561155e-02f, -1.37512296e-01f, 6.23923019e-02f, 3.60621838e-03f, -1.56148449e-01f, -1.18193500e-01f,
  1.76874995e-02f, -2.10016361e-03f, -1.60808921e-01f, 1.93047505e-02f, -1.99313089e-02f, -6.22504838e-02f, 5.11328503e-02f, -3.12415734e-02f, -1.00803196e-01f, -7.35867918e-02f,
  2.85393354e-02f, -2.09518224e-02f, -1.91875082e-02f, -8.27541128e-02f, 1.54949185e-02f, -2.31039524e-02f, 2.14271825e-02f, 5.67860790e-02f, -7.94184431e-02f, 3.79372761e-02f,
  1.77476063e-01f, -7.25281239e-01f, -3.70401829e-01f, 1.78317949e-01f, 5.07739246e-01f, 3.37520033e-01f, 2.94625401e-01f, 6.09417893e-02f, -1.47749275e-01f, -2.40019351e-01f,
  1.75331846e-01f, -3.61342162e-01f, -4.21846628e-01f, -2.81036019e-01f, 2.01165244e-01f, -4.76337492e-01f, 3.48394886e-02f, -3.64037976e-02f, -3.19452494e-01f, 1.99396573e-02f,
  1.06605284e-01f, 1.44673094e-01f, -3.24646421e-02f, 2.40322258e-02f, 6.22718409e-02f, 7.73539469e-02f, 3.02957833e-01f, -4.58457880e-03f, 1.73322588e-01f, 1.58416718e-01f,
  9.29812714e-03f, -1.26646549e-01f, 3.14706238e-03f, -6.28495663e-02f, 2.03437760e-01f, 1.17911711e-01f, 6.30020499e-02f, 5.22203147e-02f, 2.05654755e-01f, 2.33613029e-02f,
  4.23147455e-02f, -2.19521318e-02f, -1.40089905e-02f, 7.01727020e-03f, -1.28904898e-02f, 6.86276658e-03f, -1.27021909e-01f, -3.43342386e-02f, -5.49838208e-02f, -1.57878920e-01f,
  -1.26397371e-01f, -1.11514954e-02f, 7.27282651e-03f, -3.86567973e-02f, -2.88476553e-02f, 4.18315567e-02f, -2.70573585e-03f, 2.96260417e-02f, -2.40400881e-02f, 1.29776075e-01f,
  -2.56054439e-02f, -3.81154604e-02f, -1.98513847e-02f, -8.14181268e-02f, 1.44013194e-02f, 1.00182578e-01f, -5.95533773e-02f, -6.98672906e-02f, -2.62628626e-02f, -3.42861265e-02f,
  8.92483443e-02f, 2.44641788e-02f, -1.85258724e-02f, 7.76672810e-02f, 1.85022522e-02f, -4.19113301e-02f, 1.75454293e-03f, -2.60026492e-02f, 5.75617142e-02f, 3.50064337e-02f,
  -6.57583773e-02f, 4.31599803e-02f, 6.69791177e-02f, 8.17292195e-04f, -9.67174545e-02f, 9.77221727e-02f, 2.73839422e-02f, -1.17882947e-02f, 6.85849413e-03f, -1.42554741e-03f,
  -4.68348898e-02f, -3.33379775e-01f, -7.73485526e-02f, 9.22455266e-02f, -1.08985096e-01f, 6.29957579e-03f, -8.73370916e-02f, -7.72578269e-02f, -8.15643221e-02f, -3.95810278e-03f,
  1.22896619e-01f, 5.07956892e-02f, -2.03134436e-02f, -5.42312069e-03f, 7.48550296e-02f, 8.32852796e-02f, 5.42887440e-03f, 9.30085927e-02f, 3.67333293e-02f, -3.57866846e-02f,
  1.38044894e-01f, 7.81676769e-02f, 5.98979518e-02f, 5.71558848e-02f, 8.96899924e-02f, 5.30926138e-02f, 3.23981680e-02f, 7.47988075e-02f, 4.24279980e-02f, -2.82332487e-02f,
  3.18993300e-01f, 5.31577587e-01f, 1.43373519e-01f, 9.60455909e-02f, -2.01237053e-01f, -4.59485382e-01f, -1.12767980e-01f, -1.10715711e-02f, 2.37975866e-01f, 2.72958815e-01f,
  -2.96509534e-01f, 5.40274739e-01f, -8.77040327e-02f, -1.53061738e-02f, -4.52039570e-01f, -3.09068680e-01f, -3.28548104e-01f, 6.11588322e-02f, 8.96820202e-02f, -4.90238182e-02f,
  -1.28607869e-01f, -4.05806452e-01f, -2.09953323e-01f, -1.81218371e-01f, 1.01880707e-01f, 2.76357353e-01f, -3.06459010e-01f, 6.60621598e-02f, -3.75925303e-02f, -7.18710572e-03f,
  3.74344327e-02f, 2.78969049e-01f, 1.47195935e-01f, 5.27448356e-02f, -1.37137949e-01f, -2.02444885e-02f, 2.63175312e-02f, -1.91797335e-02f, -2.51348708e-02f, 1.60451293e-01f,
  8.01960230e-02f, 1.26673141e-03f, 5.06904125e-02f, -1.19700888e-03f, 1.58491433e-01f, 1.45612851e-01f, 9.01818871e-02f, -4.61850725e-02f, 1.27557889e-01f, 1.33681446e-01f,
  1.06015682e-01f, 6.05438687e-02f, -7.90129229e-02f, -2.02747490e-02f, -3.67038907e-03f, 3.05245426e-02f, -5.83080687e-02f, 8.10816512e-02f, 4.32353504e-02f, 6.21029064e-02f,
  7.02278223e-04f, -1.06134243e-01f, 2.69632135e-02f, 9.11673978e-02f, -2.87567936e-02f, 7.60731250e-02f, 2.47611180e-02f, 1.54873915e-02f, 5.08324504e-02f, -7.96845853e-02f,
  -6.62935898e-02f, 1.72593236e-01f, -3.42025571e-02f, -1.52607355e-02f, -2.67027266e-04f, 1.27051905e-01f, -5.96886128e-02f, 7.97259714e-03f, -4.48786281e-02f, -2.97552980e-02f,
  6.17607646e-02f, -1.57032296e-01f, 3.13386284e-02f, -4.13348190e-02f, -6.07425757e-02f, 5.89223951e-02f, -1.50694055e-02f, 1.27294481e-01f, -2.07422357e-02f, -1.29556105e-01f,
  -3.37556481e-01f, -3.29535484e-01f, -6.88504707e-03f, 1.51679620e-01f, 8.62572119e-02f, 5.14950743e-03f, -1.46332057e-02f, 1.42478839e-01f, -2.03348733e-02f, -1.04586430e-01f,
  -1.69398816e-04f, -2.63026673e-02f, -1.42941535e-01f, -5.60322404e-02f, -5.77087142e-02f, -1.02999754e-01f, -4.82584499e-02f, -1.09245203e-01f, -1.38554513e-01f, 7.83264711e-02f,
  1.82744805e-02f, -5.54277785e-02f, -2.92511601e-02f, -3.26258279e-02f, -3.67318690e-02f, 4.03130427e-02f, 2.17748117e-02f, 1.59071997e-01f, -6.35929778e-02f, -1.77719276e-02f,
  -5.63970566e-01f, 3.32589239e-01f, -2.15702102e-01f, 1.49019599e-01f, -1.20229796e-01f, -1.22117996e-02f, -2.75857504e-02f, 4.60525826e-02f, -2.92038828e-01f, 3.53797585e-01f,
  4.24620330e-01f, -2.21937060e-01f, 2.97574162e-01f, 5.20369649e-01f, 7.84397572e-02f, 4.02901590e-01f, 4.11043942e-01f, 2.30012938e-01f, 7.65590519e-02f, 7.05490336e-02f,
  1.18658505e-01f, 3.83790046e-01f, 4.26185668e-01f, 3.05888634e-02f, 5.37787788e-02f, -1.77271605e-01f, 2.38158777e-01f, -9.86900255e-02f, 2.49297366e-01f, -5.80954663e-02f,
  1.37396380e-01f, 4.32128273e-02f, -1.30720571e-01f, -1.62299499e-01f, -1.61180254e-02f, -1.38030037e-01f, -1.08409174e-01f, -9.37654451e-02f, -9.70406979e-02f, -2.31725425e-02f,
  -1.75661311e-01f, -8.40955749e-02f, 3.71695525e-04f, -1.10608272e-01f, -9.94855016e-02f, -1.06828071e-01f, 6.40697181e-02f, 2.86314208e-02f, -4.12546881e-02f, 1.12685457e-01f,
  2.43132524e-02f, 9.79735628e-02f, 3.25463526e-02f, 1.43518209e-01f, 3.31369322e-03f, -1.51367402e-02f, -2.98661273e-02f, -9.77157727e-02f, 7.52125829e-02f, -4.86627072e-02f,
  -4.72483896e-02f, 1.40001029e-02f, 4.30329330e-02f, 3.86853889e-02f, 8.32415465e-03f, 1.11030512e-01f, 3.04755177e-02f, 3.16983350e-02f, -8.29056725e-02f, 1.05487473e-01f,
  1.10213943e-02f, -5.35267591e-02f, -8.76751542e-02f, -8.79916474e-02f, 1.27505660e-02f, -3.22062671e-02f, -4.30497490e-02f, 4.15060446e-02f, -8.99338722e-03f, 1.99936572e-02f,
  -7.37872198e-02f, -4.25500199e-02f, 3.50393653e-02f, 6.66873008e-02f, 6.50962256e-03f, 2.21729185e-02f, 9.19039920e-02f, 3.17272320e-02f, -4.40495741e-03f, -2.38841982e-03f,
  1.95019826e-01f, 9.87533480e-02f, -5.04798032e-02f, -2.37760004e-02f, 1.27417892e-02f, 3.41244377e-02f, -8.09909496e-03f, -2.50483453e-02f, 4.36160527e-02f, -4.65945192e-02f,
  -1.04065463e-01f, -7.12362602e-02f, 4.57129329e-02f, -4.36434299e-02f, 7.72309899e-02f, 6.77991882e-02f, 5.62555864e-02f, -1.18322544e-01f, -6.16778247e-02f, 9.93865728e-02f,
  1.95562374e-02f, -1.52228838e-02f, -7.75917470e-02f, 4.31271754e-02f, 3.89036015e-02f, 4.56915312e-02f, -9.75400731e-02f, -6.97604194e-02f, 5.20945266e-02f, 5.57498559e-02f,
  4.72796001e-02f, 1.97708949e-01f, 3.42586339e-01f, -3.04149657e-01f, 1.02718972e-01f, 2.48287335e-01f, -2.72865206e-01f, 4.25683320e-01f, 3.48111808e-01f, -1.14284009e-01f,
  -2.36091197e-01f, -3.52883220e-01f, -3.64074185e-02f, -1.01028100e-01f, 3.30672860e-02f, 3.60890701e-02f, -1.90270811e-01f, -3.89004230e-01f, 1.23283220e-02f, -3.06846172e-01f,
  -1.16857231e-01f, -4.51608390e-01f, -6.03251569e-02f, -1.94714561e-01f, -1.14986017e-01f, 9.98145267e-02f, -2.38353506e-01f, -3.58568206e-02f, -1.17592700e-01f, -1.12769775e-01f,
  1.45210892e-01f, 5.75683936e-02f, 2.44561255e-01f, 1.74355403e-01f, 2.06649005e-01f, -1.03733301e-01f, -8.67576525e-02f, -2.36922503e-02f, 7.42431963e-03f, 4.45513800e-02f,
  -5.16228527e-02f, -4.04559560e-02f, -7.68504217e-02f, -6.21222705e-02f, 4.79851328e-02f, 3.37262894e-03f, 6.17229529e-02f, 2.34074295e-01f, 3.92794274e-02f, -1.64119657e-02f,
  -3.94878872e-02f, 9.40164402e-02f, 9.49333087e-02f, -2.87094302e-02f, 1.11081833e-02f, 1.01275563e-01f, -4.54661511e-02f, -1.13873079e-01f, 2.27092486e-02f, 1.01210214e-01f,
  -1.11269258e-01f, 2.04677060e-02f, -6.62853941e-02f, 6.82069436e-02f, 4.89904210e-02f, 1.20819546e-01f, 2.32345192e-03f, -3.24562080e-02f, 1.14165343e-01f, 3.39601152e-02f,
  9.71042663e-02f, 4.58720252e-02f, -9.53654572e-02f, -7.46577904e-02f, -1.36766061e-01f, 8.85620043e-02f, -8.98204744e-02f, -8.23966563e-02f, -2.96149030e-02f, 2.03291588e-02f,
  -1.88169107e-01f, -1.34053960e-01f, -5.44368364e-02f, -9.39788371e-02f, 1.07167952e-01f, 3.09791472e-02f, -9.38263461e-02f, 7.08831251e-02f, 9.97968465e-02f, -2.45807350e-01f,
  8.93206596e-02f, -1.09822385e-01f, 1.64076105e-01f, 5.21060117e-02f, 3.11972480e-02f, 1.04554340e-01f, -6.28500730e-02f, 9.13186651e-03f, -7.48907253e-02f, 1.00605972e-02f,
  4.64723557e-02f, -7.56126866e-02f, -5.06427884e-03f, -9.01794285e-02f, -3.55285034e-02f, 3.46409157e-02f, -1.56887978e-01f, 8.30587447e-02f, -1.37884706e-01f, -1.62605215e-02f,
  -1.60092473e-01f, -1.15801148e-01f, 9.25989524e-02f, -7.75374798e-03f, -1.87388122e-01f, -5.53184422e-04f, -7.16353282e-02f, 4.83565889e-02f, -1.05047263e-01f, -1.19498000e-02f,
  4.61127937e-01f, -6.19578242e-01f, 1.69017330e-01f, 5.45559600e-02f, 5.20741045e-01f, 2.21616656e-01f, 3.88604730e-01f, -1.49398848e-01f, -2.42507875e-01f, -5.56410968e-01f,
  4.98668738e-02f, -2.65866488e-01f, 6.71203211e-02f, -5.02572954e-02f, 5.80673575e-01f, 1.50826247e-02f, -1.52578335e-02f, -1.93991795e-01f, 3.01100075e-01f, 1.86182216e-01f,
  2.11646110e-01f, 4.75543849e-02f, 3.09571385e-01f, -1.98336273e-01f, 2.37914369e-01f, -1.77374825e-01f, -1.24851651e-01f, -4.52164840e-03f, -2.79483616e-01f, 2.32779607e-02f,
  1.31919473e-01f, 3.19871232e-02f, 2.29123726e-01f, -1.07232213e-01f, 1.18835092e-01f, 7.16486871e-02f, 2.77359895e-02f, 8.44691396e-02f, 3.29752825e-02f, 9.51884594e-03f,
  -3.78564410e-02f, -5.93688115e-02f, -1.04100935e-01f, 4.07998897e-02f, 7.24398866e-02f, -3.85304466e-02f, 1.02271169e-01f, 6.32987916e-02f, -1.28372936e-02f, 5.92160076e-02f,
  1.34494916e-01f, -9.76568237e-02f, 1.25345126e-01f, -1.34387627e-01f, 6.47427365e-02f, -3.11232563e-02f, -9.58005711e-03f, 3.90976071e-02f, -1.40377685e-01f, -1.26254708e-01f,
  -1.43217370e-01f, 1.34728989e-02f, 4.18693721e-02f, 3.47379856e-02f, 1.59146320e-02f, 2.69670077e-02f, -3.49967927e-02f, -2.42226180e-02f, 2.09340267e-02f, 1.00943735e-02f,
  -7.55905313e-03f, 2.84496564e-02f, 5.50654344e-02f, -4.24915440e-02f, 1.79749243e-02f, -4.65098349e-03f, 1.26517281e-01f, -7.13840574e-02f, 6.36170506e-02f, 1.72025278e-01f,
  -4.60251719e-02f, 1.76759958e-02f, 5.14944158e-02f, -1.00922743e-02f, -1.03259459e-01f, 3.73054966e-02f, -1.37635022e-01f, 4.93871421e-03f, 1.53090050e-02f, -2.74565592e-02f,
  -1.67336687e-01f, -4.68272001e-01f, -1.53852217e-02f, -1.49340272e-01f, -7.94854984e-02f, 2.94982512e-02f, -3.19652744e-02f, -1.12562969e-01f, -1.72979400e-01f, 9.29939970e-02f,
  -1.11513823e-01f, -8.07590666e-04f, -7.94934705e-02f, 4.85355519e-02f, -1.12400256e-01f, 9.97757912e-03f, -8.95648375e-02f, -1.11095242e-01f, 7.60719925e-02f, -8.25271159e-02f,
  -1.02885611e-01f, -1.88016333e-02f, -2.23282892e-02f, 2.92001385e-02f, -1.38445988e-01f, -5.46168201e-02f, -1.43830916e-02f, -1.57880664e-01f, 2.45669181e-03f, -1.35724053e-01f,
  1.07450694e-01f, -5.18343449e-01f, -2.19035402e-01f, -3.71663481e-01f, 8.67680982e-02f, 2.31579393e-01f, 1.93384904e-02f, -3.30702305e-01f, -5.99447012e-01f, -3.34593862e-01f,
  -9.66762155e-02f, 4.90515977e-02f, -5.60492985e-02f, -5.89263625e-02f, 5.94244003e-01f, 1.51861627e-02f, 1.10541470e-01f, 2.15880454e-01f, -7.91089013e-02f, 1.19810261e-01f,
  1.36835143e-01f, 3.41326952e-01f, 2.71066070e-01f, 1.84898585e-01f, 1.09039031e-01f, -3.89966182e-02f, 2.75057077e-01f, 2.50716954e-01f, 3.30723673e-01f, 3.49414021e-01f,
  -5.09765781e-02f, -1.91432267e-01f, -9.19718072e-02f, -2.21642349e-02f, 7.58300945e-02f, -1.45411557e-02f, 1.43067822e-01f, 2.10853502e-01f, -2.97237691e-02f, 4.15367894e-02f,
  6.89960644e-02f, 8.36931840e-02f, -7.25045651e-02f, 1.41482785e-01f, -9.41554233e-02f, -1.22087322e-01f, -2.34257542e-02f, -1.30559176e-01f, -3.11768875e-02f, 7.88301136e-03f,
  -1.13434181e-01f, -1.72671646e-01f, -1.32902607e-01f, -4.33840826e-02f, -8.10647756e-02f, -1.20958306e-01f, -1.16693683e-01f, 2.94079003e-03f, -4.86830361e-02f, -1.37943523e-02f,
  5.93171678e-02f, 3.37228067e-02f, 5.00618853e-02f, -1.01816110e-01f, 1.96704715e-02f, -5.08906506e-02f, 4.85897101e-02f, 9.05803405e-03f, -2.92877909e-02f, 1.01433262e-01f,
  -1.04026362e-01f, -3.02833132e-02f, -8.41879323e-02f, -6.24598935e-02f, 6.91988096e-02f, -4.25547920e-02f, 1.53238505e-01f, 5.31401597e-02f, -1.25436172e-01f, -1.06097259e-01f,
  -1.04158960e-01f, 1.56990923e-02f, 6.66441210e-03f, -3.92148532e-02f, -4.40093949e-02f, 2.78537571e-02f, -3.58841345e-02f, 1.59793328e-02f, -8.26841593e-02f, 1.34485155e-01f,
  9.19987857e-02f, 9.93131399e-02f, -3.20576392e-02f, 3.17139216e-02f, 7.14264587e-02f, 3.68622541e-02f, 7.28053786e-03f, -2.09887084e-02f, -1.22340051e-02f, -2.74026431e-02f,
  -2.43930072e-02f, -2.40930114e-02f, -6.35967180e-02f, -2.45579686e-02f, 9.09516066e-02f, -8.43202844e-02f, 1.08355537e-01f, -3.21765128e-03f, 8.93525705e-02f, 4.07016883e-03f,
  -3.28883231e-02f, -1.08933812e-02f, 6.28595948e-02f, -2.92197932e-02f, -1.17378905e-01f, -1.91766769e-02f, 1.63989328e-02f, -6.32224679e-02f, 5.59308082e-02f, -6.54695258e-02f,
  4.78573501e-01f, -6.35287642e-01f, -4.99819964e-01f, 4.15098846e-01f, 2.31545851e-01f, 3.22154373e-01f, 1.60656184e-01f, 9.67759863e-02f, 2.03399628e-01f, 4.05839761e-04f,
  4.05971736e-01f, -3.25791985e-01f, -3.91824782e-01f, 5.81875682e-01f, 3.03788185e-01f, -1.86913997e-01f, 5.37554801e-01f, 3.24138880e-01f, 5.36691360e-02f, -4.71895598e-02f,
  1.80455700e-01f, 5.18432379e-01f, -1.47247285e-01f, -2.41638292e-02f, 1.15886405e-01f, -1.78348035e-01f, -1.05095901e-01f, -3.85737240e-01f, 2.70146251e-01f, 1.36029065e-01f,
  1.93074688e-01f, 8.62537622e-02f, -3.04349624e-02f, -2.47347578e-02f, -4.02626097e-02f, 1.86995079e-03f, -7.26923719e-02f, -1.30094767e-01f, 3.88634875e-02f, -1.04986569e-02f,
  -1.70955151e-01f, 2.05974020e-02f, 1.50329202e-01f, -5.90343215e-02f, 8.51170048e-02f, 2.99094822e-02f, 2.81401537e-02f, 4.10012715e-03f, -3.78418751e-02f, -8.10742155e-02f,
  -1.03301086e-01f, -2.43085646e-03f, 6.51584119e-02f, 6.21919520e-02f, -5.72498515e-02f, 1.15734324e-01f, -5.64148836e-02f, -1.52720764e-01f, -4.57663052e-02f, 4.62593324e-03f,
  -1.15598522e-01f, -7.56282061e-02f, -5.60388640e-02f, 8.13250318e-02f, -4.19368036e-02f, 4.30042557e-02f, 7.28229731e-02f, 2.05162447e-02f, -2.77206954e-02f, -7.02325329e-02f,
  1.45624176e-01f, 2.69495957e-02f, 5.34339175e-02f, -8.04937445e-03f, 8.04975033e-02f, 9.96066537e-03f, -2.85117477e-02f, -2.24581752e-02f, 3.50378156e-02f, 2.90980935e-02f,
  -4.40754928e-02f, 6.85404092e-02f, -5.50606288e-02f, 3.59761342e-02f, 6.81638867e-02f, -1.41727403e-01f, -1.16856610e-02f, -5.87777086e-02f, -2.04943735e-02f, -6.26325160e-02f,
  -1.15929164e-01f, -4.73419726e-01f, -4.32933532e-02f, 6.16299696e-02f, -5.06184623e-02f, 3.68584022e-02f, 4.08355854e-02f, 1.78011786e-02f, -4.54392936e-03f, 4.64077368e-02f,
  -1.53881516e-02f, -2.62874481e-03f, -7.10182125e-03f, 7.86446184e-02f, -4.93607633e-02f, 1.68372747e-02f, -8.72043595e-02f, 4.12886217e-03f, 4.84755747e-02f, -5.03394306e-02f,
  -6.52764812e-02f, -9.25825257e-03f, -4.63483967e-02f, 4.86259870e-02f, 6.76604733e-02f, -3.96470614e-02f, -4.11989056e-02f, -1.64304785e-02f, -4.13633958e-02f, -2.16978472e-02f,
  6.49167597e-01f, 3.25663686e-01f, -4.77867346e-04f, 3.10386300e-01f, 1.63921863e-01f, 2.60657251e-01f, 2.67866939e-01f, 3.46394554e-02f, 5.10139048e-01f, 4.81388606e-02f,
  -2.04064548e-01f, 4.40963566e-01f, -3.82319480e-01f, 1.70027643e-01f, -3.15825313e-01f, -2.82170326e-01f, 2.83850312e-01f, 2.57855833e-01f, 1.07745841e-01f, 3.43759626e-01f,
  5.88603877e-02f, -5.06049059e-02f, -3.19585621e-01f, -9.62996408e-02f, 1.81984976e-01f, 2.37963706e-01f, -4.24936771e-01f, -2.41163284e-01f, -1.36927227e-02f, -1.95161626e-01f,
  -9.24167907e-05f, 1.53758898e-01f, 7.06606060e-02f, -7.12092146e-02f, 5.71520515e-02f, 6.72900453e-02f, 1.88776124e-02f, -1.21203817e-01f, -9.32099968e-02f, -1.67546477e-02f,
  1.61656395e-01f, -3.97260301e-02f, 5.82434470e-03f, -1.45720616e-01f, 2.23167360e-01f, 7.12156445e-02f, 1.06801249e-01f, 2.87732687e-02f, 5.76331131e-02f, -6.75863549e-02f,
  9.12754536e-02f, 1.08039752e-01f, 1.81053847e-01f, 4.33299989e-02f, 6.20204620e-02f, 1.20694399e-01f, 7.45503306e-02f, -5.75552844e-02f, 6.28923923e-02f, 1.42919451e-01f,
  -7.08345845e-02f, 9.78548750e-02f, 1.96131710e-02f, -7.18968511e-02f, 4.41215895e-02f, -1.38405934e-02f, 2.03482946e-03f, -5.07923551e-02f, 2.21222416e-02f, 2.36603338e-02f,
  2.47256774e-02f, 1.78170521e-02f, -6.11273665e-03f, 3.64722274e-02f, 5.61514571e-02f, 1.38416573e-01f, -1.44436657e-02f, -3.37747927e-03f, 1.89480651e-02f, -3.92321358e-03f,
  -9.97501537e-02f, 1.51100773e-02f, -6.16034493e-02f, -5.57686351e-02f, -7.27690384e-02f, -1.10592708e-01f, -3.66154010e-03f, 8.88001099e-02f, -3.72656132e-03f, -1.00068435e-01f,
  6.76883757e-02f, 4.55850959e-02f, -1.06826192e-03f, 7.95400366e-02f, 3.59574109e-02f, 8.13307911e-02f, -4.44396324e-02f, 1.41658053e-01f, 8.17098282e-03f, 1.67111133e-03f,
  1.14935189e-01f, 1.90683156e-02f, 1.20665364e-01f, -5.37447147e-02f, -5.84535189e-02f, 2.39268430e-02f, -9.91295837e-03f, 5.10588102e-02f, -2.06622835e-02f, -6.68242201e-02f,
  1.05227433e-01f, 1.25101462e-01f, 7.54270107e-02f, 1.34379044e-01f, 1.35973305e-01f, -1.71633158e-02f, 1.68457866e-01f, 1.24240350e-02f, -1.29178017e-01f, -6.32682303e-03f,
  5.81148006e-02f, -2.79070139e-01f, 3.76985818e-01f, 1.45628706e-01f, 5.00477850e-03f, 6.62411228e-02f, 1.02279499e-01f, -3.55898649e-01f, -5.09809256e-01f, -1.93974674e-01f,
  -1.43161714e-01f, 4.63784635e-01f, -5.46090901e-02f, -1.64680600e-01f, 7.70392865e-02f, -2.93639421e-01f, -2.16728911e-01f, 1.79855257e-01f, -2.13978544e-01f, -2.42223442e-02f,
  -5.64072877e-02f, -5.46144366e-01f, 1.77367613e-01f, -4.27583128e-01f, 1.36317700e-01f, 1.41498774e-01f, 4.95322719e-02f, 2.03296825e-01f, 1.92654073e-01f, 4.54786234e-02f,
  -7.83539191e-02f, -2.65733719e-01f, 3.67560051e-02f, 1.15070613e-02f, -1.53854201e-02f, 1.26592100e-01f, 1.25005335e-01f, 1.44165322e-01f, 3.91142443e-02f, 1.04280235e-02f,
  8.03149417e-02f, 4.90095839e-02f, -3.54194753e-02f, -2.89235804e-02f, -1.73756540e-01f, -2.76555549e-02f, -4.00550803e-03f, 9.55891609e-02f, -3.05513926e-02f, 1.38449550e-01f,
  9.46173072e-02f, 1.16090514e-01f, 6.27806336e-02f, 7.44817629e-02f, 3.03241555e-02f, -2.92395912e-02f, 3.14959437e-02f, 2.85218567e-01f, 5.39689697e-02f, -6.43816441e-02f,
  -7.69729018e-02f, -2.55570095e-02f, -5.83464876e-02f, -4.62181792e-02f, -9.63457376e-02f, -2.62369961e-02f, -6.92572147e-02f, 5.87761030e-02f, 1.06094554e-01f, -2.10106708e-02f,
  -4.24698815e-02f, 7.21072480e-02f, -1.33193225e-01f, -2.30062921e-02f, -1.17175616e-01f, -7.39175156e-02f, 2.13082522e-01f, 6.21267594e-02f, -1.14532420e-03f, 1.00120105e-01f,
  -6.67500570e-02f, -6.31248280e-02f, -2.50189491e-02f, 2.70238351e-02f, -1.41021550e-01f, 2.56284941e-02f, -8.50093886e-02f, 4.86264005e-02f, -8.37618038e-02f, 1.00525700e-01f,
  -2.15254709e-01f, -3.70629787e-01f, -8.00173208e-02f, -2.92297304e-02f, -2.58677490e-02f, 7.21738935e-02f, -8.73612538e-02f, -5.35563380e-03f, 4.49669808e-02f, -1.50854051e-01f,
  1.13967165e-01f, 1.56084940e-01f, -5.27605154e-02f, 2.23488323e-02f, -1.08418763e-01f, -8.86062011e-02f, -1.16459827e-03f, -1.59389395e-02f, 8.63954425e-02f, -1.55500080e-02f,
  9.85422507e-02f, 1.21243522e-01f, -1.09424088e-02f, 7.58581385e-02f, 4.09566648e-02f, 1.00314111e-01f, 2.22382434e-02f, -6.69457912e-02f, 9.70999822e-02f, 6.18291833e-02f,
  -9.98096466e-02f, -9.78059601e-03f, 2.98676819e-01f, 3.55914861e-01f, 1.76716328e-01f, -2.63715237e-01f, -4.15392727e-01f, 2.91431665e-01f, 8.10914189e-02f, -5.65355718e-01f,
  -2.19770193e-01f, -2.56550372e-01f, -4.02857453e-01f, 1.87694654e-01f, -1.24114631e-02f, -1.71124488e-02f, 3.29724789e-01f, -6.20101765e-02f, 4.51525331e-01f, 3.29591095e-01f,
  4.62537855e-01f, 1.75185025e-01f, 4.31702107e-01f, 4.11417693e-01f, 3.35934341e-01f, 2.72437632e-01f, -7.09569007e-02f, 7.90359750e-02f, 1.06551960e-01f, -1.38339281e-01f,
  -9.72220376e-02f, 1.81620419e-01f, 6.91592286e-04f, -1.22500934e-01f, 2.00273264e-02f, -1.75136238e-01f, -1.10923611e-01f, -6.65438846e-02f, 3.67837250e-02f, -7.16679031e-03f,
  -4.00204584e-02f, 1.58801258e-01f, 4.17788438e-02f, -1.22822877e-02f, -6.95788562e-02f, 1.70843855e-01f, 1.98632315e-01f, 5.00516109e-02f, 9.51059088e-02f, 1.45410866e-01f,
  1.41454622e-01f, 8.08516741e-02f, -2.86841989e-02f, -1.84808243e-02f, 4.74484861e-02f, -5.03970049e-02f, -9.81121045e-03f, -3.61437649e-02f, 3.16640995e-02f, 3.15842144e-02f,
  4.99746241e-02f, -8.57893676e-02f, -1.41417356e-02f, -5.52923828e-02f, -5.32265157e-02f, -4.04232703e-02f, -1.06596529e-01f, 5.67879016e-03f, 1.97897442e-02f, -8.63905773e-02f,
  1.78548489e-02f, 2.24246103e-02f, 1.70172095e-01f, 2.01295055e-02f, 1.10368058e-02f, 4.19325680e-02f, -1.63955744e-02f, 2.87724733e-02f, 7.24216104e-02f, 4.08120714e-02f,
  6.80459943e-03f, -1.34375198e-02f, -2.13714093e-02f, 7.42637292e-02f, -1.35001123e-01f, 7.91130308e-03f, 1.06579512e-01f, 3.53478529e-02f, 7.08198696e-02f, 1.32161960e-01f,
  -4.77468938e-01f, -1.36288390e-01f, -1.05670318e-01f, -1.41434297e-01f, -4.19571847e-02f, 3.62508409e-02f, 1.04390472e-01f, 1.96780160e-01f, -1.07518561e-01f, -2.82361619e-02f,
  -1.23912971e-02f, 2.32540909e-02f, -1.41534314e-01f, -1.82807017e-02f, 3.51377181e-03f, -9.29214898e-03f, -9.19163451e-02f, -1.49943516e-01f, -1.11905813e-01f, 2.86585018e-02f,
  6.63340315e-02f, -4.91099581e-02f, -3.50233354e-02f, 1.79084644e-01f, -9.91434138e-03f, -9.57717672e-02f, -3.37555781e-02f, 4.99461219e-02f, 3.07552721e-02f, -1.70794148e-02f,
  3.38920876e-02f, -1.47417337e-01f, 2.38793641e-01f, 5.42019773e-03f, 4.82892320e-02f, 8.67155343e-02f, 3.91666852e-02f, -1.58541724e-02f, 4.09996033e-01f, -3.62605423e-01f,
  -4.28482682e-01f, 2.64219865e-02f, 3.78336571e-02f, -3.48695159e-01f, 5.46311378e-01f, 3.88838589e-01f, 2.36790329e-02f, -7.58457407e-02f, 2.33357400e-01f, -2.20640495e-01f,
  5.42041026e-02f, -3.54790181e-01f, 1.14453636e-01f, -3.49525064e-01f, -3.86451751e-01f, -1.81311443e-01f, -8.25028047e-02f, 1.20111912e-01f, -3.21730316e-01f, 1.10892668e-01f,
  -1.19038701e-01f, -1.51615903e-01f, -2.53892124e-01f, -7.64840543e-02f, -7.17883632e-02f, 4.69825342e-02f, 1.05928406e-01f, 6.05149046e-02f, 9.48161855e-02f, -4.72611003e-02f,
  -1.07767969e-01f, 6.06256686e-02f, -1.18350863e-01f, 3.02163400e-02f, 3.23024988e-02f, -1.72717534e-02f, -2.75159739e-02f, -1.82120159e-01f, -5.33626787e-02f, 7.70249441e-02f,
  -2.92538870e-02f, -3.94683555e-02f, -7.39128515e-02f, 1.13589577e-01f, 1.10841868e-02f, -1.16606325e-01f, 5.87918609e-02f, 6.28340542e-02f, -3.36208902e-02f, 3.51540968e-02f,
  1.12351645e-02f, 2.00781703e-01f, -1.43257588e-01f, 4.95111793e-02f, -1.16733827e-01f, -6.69241771e-02f, 3.31698321e-02f, -6.93997443e-02f, 6.13338500e-02f, -1.50777355e-01f,
  -1.14076369e-01f, -6.32509880e-04f, 1.08126745e-01f, 1.20957112e-02f, -8.95662233e-02f, -7.28936270e-02f, 4.59925756e-02f, 2.49707215e-02f, -8.99651647e-02f, -9.49495211e-02f,
  -5.61615042e-02f, 4.79323827e-02f, -3.97420824e-02f, 5.23996800e-02f, 8.28670280e-04f, 1.01314206e-02f, -7.12707043e-02f, 9.48280394e-02f, -2.75188256e-02f, -4.21272032e-02f,
  3.17770913e-02f, 1.60854861e-01f, -1.07388407e-01f, -2.24436522e-01f, 6.29564598e-02f, -8.84234086e-02f, 1.77924126e-01f, -4.68408950e-02f, 1.05455346e-01f, -1.61124263e-02f,
  -1.32527828e-01f, -8.58692303e-02f, -4.03722934e-02f, 7.33256489e-02f, 7.23500624e-02f, 2.72592138e-02f, 4.35053855e-02f, -1.42331332e-01f, 7.97016099e-02f, 1.13266576e-02f,
  -9.39414278e-02f, 1.63363367e-02f, -1.22087011e-02f, -8.55161026e-02f, -9.39215198e-02f, -6.29908498e-03f, 2.71446090e-02f, -2.88470443e-02f, -2.33456753e-02f, 2.11208686e-02f,
  3.84100348e-01f, -1.45463049e-01f, -3.48326802e-01f, -3.03208172e-01f, 2.21176863e-01f, 1.39418304e-01f, -1.73951700e-01f, 4.51529436e-02f, -5.36132455e-01f, 7.87986144e-02f,
  2.88323075e-01f, -2.71483749e-01f, 1.51441053e-01f, -1.99467346e-01f, 2.01670915e-01f, -2.27145821e-01f, 8.50009546e-02f, -8.44767243e-02f, -1.66223377e-01f, 3.49253684e-01f,
  5.19775413e-02f, 2.24989563e-01f, 3.88023257e-02f, 1.98737636e-01f, 1.42612025e-01f, 1.84983730e-01f, 4.58034813e-01f, 5.48410118e-02f, 1.42834052e-01f, -1.60517067e-01f,
  -1.04464456e-01f, -9.21269646e-04f, -1.26011521e-01f, -1.50064677e-01f, 2.41073027e-01f, 1.05149426e-01f, -2.15622922e-03f, 5.63945472e-02f, -2.27939896e-02f, -1.08071782e-01f,
  9.42755193e-02f, -2.23966315e-02f, -5.92758209e-02f, -1.26230255e-01f, 1.12427594e-02f, -6.67136535e-02f, -5.54562220e-03f, -6.85766637e-02f, -1.17941990e-01f, 1.70830324e-01f,
  -2.59550437e-02f, 1.73937865e-02f, -1.76256653e-02f, -9.28995833e-02f, 1.22360863e-01f, 7.73098394e-02f, -4.29439992e-02f, 1.99725777e-01f, -1.60598993e-01f, 2.51831003e-02f,
  2.05378830e-01f, 1.03264898e-02f, 1.36265427e-01f, -1.54627025e-01f, -2.76514180e-02f, -4.98133563e-02f, 1.80295035e-02f, 9.62505937e-02f, -1.94036718e-02f, 6.37088269e-02f,
  3.07220835e-02f, 3.77135165e-02f, -1.46627948e-01f, -1.25487158e-02f, 1.56365022e-01f, -8.74744728e-02f, -6.06297180e-02f, 1.92165002e-02f, 5.46154529e-02f, -7.76401311e-02f,
  -1.38367623e-01f, 2.38285512e-02f, 5.76681681e-02f, 4.69810031e-02f, -6.79899901e-02f, 7.97003508e-02f, 8.14481732e-03f, -7.51715573e-03f, 8.79727770e-03f, -2.47273315e-02f,
  1.84616596e-01f, 3.94134790e-01f, -5.48957065e-02f, -2.06687108e-01f, -1.32260039e-01f, 1.23236656e-01f, -1.76766932e-01f, 1.69741716e-02f, 1.80660784e-01f, 1.65331274e-01f,
  1.44576401e-01f, -5.72597906e-02f, 1.28796488e-01f, 1.48114376e-02f, -1.48290515e-01f, 2.26866752e-01f, 1.06064551e-01f, -6.82157800e-02f, 3.17192972e-02f, 2.32603118e-01f,
  1.33574069e-01f, 9.06723738e-02f, -1.88144013e-01f, -8.24040994e-02f, 4.55324836e-02f, 1.04276225e-01f, 1.41433150e-01f, 1.99521352e-02f, 8.95152688e-02f, -9.63003635e-02f,
  -7.88847029e-01f, 5.86168408e-01f, -1.79093674e-01f, -4.67558533e-01f, -3.41958180e-03f, -2.96252370e-01f, -3.00122440e-01f, 8.91370419e-03f, -7.10353330e-02f, 2.26019323e-01f,
  -3.47052738e-02f, -5.54104224e-02f, 3.95227522e-01f, -1.81112111e-01f, -3.44544977e-01f, 3.71828079e-01f, -4.57226336e-01f, -2.58800447e-01f, 3.94032933e-02f, -3.81768942e-01f,
  -2.24313393e-01f, -2.29829237e-01f, -3.00051793e-02f, 2.21383259e-01f, -3.17234755e-01f, -2.38149613e-01f, -7.27405027e-02f, 1.99508801e-01f, -2.87772894e-01f, 1.42604724e-01f,
  -1.46861985e-01f, -3.51166800e-02f, -2.40590081e-01f, -8.71646032e-02f, -2.93110460e-01f, -1.23851024e-01f, -1.26889616e-01f, 1.11814002e-02f, -1.17625341e-01f, 8.68714135e-03f,
  -6.00436926e-02f, 1.27702519e-01f, -1.17405385e-01f, 9.17971134e-02f, -3.12015321e-02f, -5.24491211e-03f, 1.40301421e-01f, -7.19764903e-02f, 3.10486592e-02f, 1.04024313e-01f,
  6.57143295e-02f, 2.95550432e-02f, -1.16649926e-01f, 5.38095087e-02f, -9.69507918e-03f, 7.35325366e-02f, -6.00464176e-04f, 2.81710848e-02f, -1.18266791e-01f, -4.25048359e-03f,
  3.33692245e-02f, -1.16709977e-01f, 1.72584821e-02f, -2.83733290e-03f, 1.65543593e-02f, 3.13968323e-02f, 5.49666863e-03f, -2.17290130e-02f, -5.77408634e-03f, 2.63555534e-02f,
  -1.47313047e-02f, 3.83822173e-02f, 1.14846453e-02f, -1.08767450e-01f, -7.37618357e-02f, -6.15833886e-02f, -1.14224717e-01f, 1.20072253e-02f, -6.46781921e-02f, 3.74617092e-02f,
  1.98234618e-02f, 2.87174750e-02f, 7.92322084e-02f, -3.77928615e-02f, 2.10486576e-02f, 6.62233904e-02f, -2.41138022e-02f, 7.32918382e-02f, 6.31405856e-04f, -1.21373922e-01f,
  -3.30224484e-01f, -3.77107173e-01f, -1.39551863e-01f, 2.41996478e-02f, -6.99407756e-02f, -2.80734133e-02f, -6.80618286e-02f, -5.52092865e-02f, -6.29214719e-02f, -2.60534580e-03f,
  -5.55286221e-02f, -6.53071925e-02f, -1.94128618e-01f, -5.40481471e-02f, -1.18796647e-01f, -5.40806502e-02f, -1.97416946e-01f, -3.04869730e-02f, -2.16106012e-01f, -7.59122968e-02f,
  -2.67846286e-02f, -7.04025030e-02f, 6.38047233e-02f, -3.68445367e-02f, -1.37533575e-01f, -8.30243677e-02f, -1.33625418e-01f, 7.64687508e-02f, -1.06031690e-02f, 2.65470520e-02f,
  6.93455219e-01f, -4.24422860e-01f, -1.52944159e-02f, 3.88687402e-01f, 1.83322445e-01f, 2.88674742e-01f, 7.62577355e-01f, -8.30449983e-02f, 3.76097500e-01f, -2.35465273e-01f,
  -8.11219364e-02f, 1.04772963e-01f, 2.54945636e-01f, -5.73505722e-02f, 4.68592763e-01f, 2.05942973e-01f, 1.15311563e-01f, 1.79735065e-01f, -2.59554051e-02f, 1.55115962e-01f,
  1.23947993e-01f, 8.84207338e-02f, -2.36256365e-02f, -5.04002690e-01f, 7.31904283e-02f, -2.59538800e-01f, -1.98986113e-01f, -6.02600612e-02f, -3.31356376e-01f, 5.77572957e-02f,
  -1.47213629e-02f, 7.50609189e-02f, -4.66511473e-02f, -3.84018570e-02f, -5.31942621e-02f, -1.36633003e-02f, 3.77166085e-02f, 1.55529469e-01f, 1.04847178e-01f, 4.49548010e-03f,
  5.30802310e-02f, -4.18848209e-02f, -1.01105839e-01f, 9.45335701e-02f, 4.74284999e-02f, -8.08914825e-02f, -7.99733251e-02f, -1.01071641e-01f, -4.36803736e-02f, 4.51179855e-02f,
  4.32002284e-02f, -9.15779546e-02f, -1.66273676e-02f, -5.57579063e-02f, -6.66877534e-03f, -5.46734734e-03f, -6.86090579e-03f, 4.62671779e-02f, -3.54279913e-02f, 1.21920900e-02f,
  4.51010615e-02f, 6.82030693e-02f, 6.77294731e-02f, 2.24979166e-02f, 5.47318859e-03f, -6.42677173e-02f, 2.68388111e-02f, -9.86422002e-02f, -2.40812190e-02f, 2.57588048e-02f,
  1.42995482e-02f, 2.71745212e-02f, -7.91984871e-02f, 4.66297232e-02f, 6.04743659e-02f, 2.91947648e-02f, 4.42002676e-02f, 7.52713997e-04f, -3.48338820e-02f, -7.91408792e-02f,
  3.23568918e-02f, 6.59052236e-03f, -2.81200986e-02f, -1.25032468e-02f, -2.65146550e-02f, 2.78575178e-02f, -4.18419354e-02f, 6.33370206e-02f, 2.00726800e-02f, 1.13319859e-01f,
  1.91415325e-02f, 7.27163330e-02f, -3.81372608e-02f, -1.12002224e-01f, -1.26948595e-01f, -8.66024643e-02f, 1.05035529e-01f, -1.51506085e-02f, -2.75855828e-02f, 4.56027500e-02f,
  -1.13023229e-01f, 3.28078046e-02f, -8.50237831e-02f, -8.48992467e-02f, -9.53033268e-02f, -7.36750439e-02f, 2.61120293e-02f, -1.90708265e-02f, -1.62844080e-02f, -1.14620849e-01f,
  -1.60533860e-02f, 1.23689577e-01f, -2.61645634e-02f, 9.45381634e-03f, -9.95153114e-02f, 5.19145094e-02f, -1.19100837e-02f, -4.49903198e-02f, 7.75632709e-02f, -2.15463527e-02f,
  -4.68412429e-01f, 3.08219586e-02f, -4.58859205e-01f, -1.38379052e-01f, -1.15989752e-01f, -3.45753074e-01f, -1.03508674e-01f, -9.53864586e-03f, 6.54307902e-02f, 3.78181219e-01f,
  1.49618432e-01f, -1.38593823e-01f, 3.18142444e-01f, -1.58600822e-01f, -6.19282961e-01f, -1.28774568e-02f, -1.87674537e-01f, -1.83334947e-01f, 5.36586829e-02f, 1.57258034e-01f,
  -1.76243097e-01f, 2.61977971e-01f, -3.98479998e-01f, 3.11499119e-01f, -2.06375301e-01f, 4.71412763e-02f, 2.66804129e-01f, 1.43013105e-01f, -1.81625172e-01f, -7.24845231e-02f,
  -1.08180456e-01f, 3.12989533e-01f, -1.22412637e-01f, -5.78666776e-02f, -6.19852822e-03f, 3.97586590e-03f, -8.89559761e-02f, -9.02270153e-02f, -2.92365644e-02f, -2.74149738e-02f,
  -3.82531285e-02f, 3.44267897e-02f, 4.36782055e-02f, 7.31580853e-02f, -9.17527080e-02f, -8.12374055e-02f, -2.02339381e-01f, -2.09286883e-01f, -1.41784679e-02f, -2.24431038e-01f,
  -1.51166022e-01f, -1.51004925e-01f, -4.42463905e-02f, 6.90921769e-02f, -7.72606805e-02f, -4.38145697e-02f, -9.50632021e-02f, -7.26197660e-02f, -8.96421000e-02f, -5.49605042e-02f,
  2.20079161e-03f, 9.90324914e-02f, 5.32514602e-02f, -3.71817276e-02f, 2.70517450e-02f, 1.43603012e-02f, 7.03041703e-02f, 9.03271791e-03f, 7.49660879e-02f, -1.21491821e-02f,
  1.89179331e-02f, -3.69914696e-02f, 7.83747882e-02f, -1.26657858e-01f, -2.85061356e-02f, -3.53434123e-02f, 2.29980107e-02f, 4.22453545e-02f, -4.21169922e-02f, -1.17316760e-01f,
  1.55452058e-01f, -6.83348328e-02f, 4.55398783e-02f, 6.86616004e-02f, 1.21255880e-02f, -2.54049487e-02f, 1.54166147e-01f, -6.12353943e-02f, -5.19466065e-02f, -1.52925048e-02f,
  1.13921411e-01f, 3.84155422e-01f, 1.65622577e-01f, 5.12031802e-05f, -2.43632197e-02f, -7.19829276e-03f, -4.26732557e-04f, -6.77827522e-02f, 9.44537148e-02f, 1.09518796e-01f,
  8.37192982e-02f, -2.02338975e-02f, 3.34645733e-02f, 7.84159289e-04f, -1.43556083e-02f, -1.64116558e-03f, 1.05885699e-01f, 5.60801886e-02f, 1.68710768e-01f, 1.99602377e-02f,
  5.25763594e-02f, 6.65599406e-02f, 4.20742147e-02f, -9.09303955e-04f, 4.70838733e-02f, 2.17078291e-02f, 4.17080075e-02f, -1.06414109e-01f, 7.37325894e-03f, 2.31399946e-02f,
  -5.43282814e-02f, -1.65169522e-01f, -3.55786443e-01f, -8.53990614e-02f, -3.78192663e-01f, -2.87277937e-01f, -2.44601399e-01f, -8.39585885e-02f, 3.23324174e-01f, 1.91283733e-01f,
  -1.65836826e-01f, 2.60476261e-01f, 3.03458154e-01f, -3.09061974e-01f, 1.90574944e-01f, 3.48782122e-01f, -1.97921962e-01f, 1.40123084e-01f, 4.33159545e-02f, 3.93480659e-02f,
  -2.32524369e-02f, -7.17824996e-02f, -2.20355630e-01f, -1.68202892e-01f, -4.08972144e-01f, -1.91824511e-01f, -1.31146654e-01f, -3.13744694e-01f, -3.79441708e-01f, -2.80009419e-01f,
  -2.27241218e-01f, 3.84507999e-02f, -2.07242593e-01f, 1.39402142e-02f, -1.47604033e-01f, -2.53228210e-02f, -1.09987713e-01f, 1.15825692e-02f, 4.92679700e-02f, 9.04261693e-02f,
  1.11626931e-01f, 7.30341300e-02f, -2.23889332e-02f, 1.03684485e-01f, -7.88207948e-02f, -1.45790756e-01f, -1.13853671e-01f, -1.35352433e-01f, -3.84559780e-02f, -1.53198898e-01f,
  -1.52722627e-01f, -1.48777038e-01f, -1.77573159e-01f, -3.47279501e-03f, -9.03069302e-02f, -4.60022688e-02f, 6.67583644e-02f, -1.36299878e-01f, -1.39501423e-01f, -9.13269818e-02f,
  1.54422875e-02f, 1.13062374e-01f, -1.76743362e-02f, -4.80144173e-02f, -4.74091955e-02f, -1.19811468e-01f, -4.99956422e-02f, 9.18998569e-02f, 5.50610945e-03f, -1.20661505e-01f,
  -8.37041885e-02f, -9.95459333e-02f, -1.17292188e-01f, -1.05118915e-01f, 7.31322616e-02f, 1.18128188e-01f, 1.79810934e-02f, -1.05918758e-01f, 3.54123376e-02f, 1.11880177e-03f,
  1.02215521e-01f, -1.26924247e-01f, -2.19102092e-02f, 6.93651512e-02f, -9.03569683e-02f, 5.07152490e-02f, 2.47758999e-02f, -8.23678151e-02f, 3.36787328e-02f, -1.09054081e-01f,
  -4.14003432e-02f, 1.22565910e-01f, -8.57108459e-02f, 2.60155108e-02f, 5.98931015e-02f, 2.65132245e-02f, 4.41598594e-02f, 5.42703345e-02f, -4.49237302e-02f, 1.22759536e-01f,
  -6.33089393e-02f, -4.77234386e-02f, -4.24154922e-02f, 7.49786124e-02f, 9.83659104e-02f, -4.75343354e-02f, 2.59373747e-02f, 1.26857728e-01f, -8.35189503e-03f, 1.04135849e-01f,
  -4.91241477e-02f, 2.21284926e-01f, 2.04287618e-01f, 1.17614210e-01f, -8.50111321e-02f, -7.14378208e-02f, 4.16075513e-02f, -1.16125479e-01f, -1.79079220e-01f, 3.93008031e-02f,
  9.33461115e-02f, -1.40088782e-01f, 1.38951868e-01f, 3.44359130e-01f, -2.05216393e-01f, -4.61149633e-01f, -9.95005816e-02f, -2.24264935e-01f, 3.19574386e-01f, -4.94417131e-01f,
  -2.99555928e-01f, 1.40416414e-01f, -7.31658190e-02f, -1.90251112e-01f, 6.48448288e-01f, 2.79742092e-01f, 1.12937823e-01f, -9.33766961e-02f, 2.18044788e-01f, -1.13241903e-01f,
  1.39562353e-01f, -2.29977399e-01f, 1.06627710e-01f, -2.91671395e-01f, -2.77005702e-01f, 1.33843943e-01f, 3.02454829e-01f, -3.13626602e-02f, -1.92522064e-01f, 3.58881727e-02f,
  -1.03154808e-01f, 7.87898079e-02f, 4.16301154e-02f, 1.07234471e-01f, -4.48660739e-03f, -2.00223222e-01f, -5.34371436e-02f, 7.97924469e-04f, 1.67685598e-01f, 1.68991424e-02f,
  8.18389654e-03f, -3.55223520e-03f, 1.20204754e-01f, 5.65999262e-02f, -1.10347360e-01f, 2.45140065e-02f, 9.69739556e-02f, -7.87991807e-02f, 1.05603272e-02f, -1.88758314e-01f,
  1.09402165e-02f, -3.74743491e-02f, 6.42606691e-02f, 1.57338381e-01f, 2.68870056e-01f, 6.32986203e-02f, 8.14289749e-02f, 1.49184123e-01f, 6.93626106e-02f, 1.14938132e-01f,
  -8.87196064e-02f, -4.08053733e-02f, -1.30042523e-01f, -9.00433064e-02f, -2.30526999e-02f, 2.37779152e-02f, 1.06797868e-03f, -1.36551499e-01f, 1.00332804e-01f, 3.80054750e-02f,
  5.89816533e-02f, 4.27957438e-02f, -3.05348225e-02f, 1.86985526e-02f, -9.25231427e-02f, -8.84304568e-02f, 2.82660071e-02f, 5.18334769e-02f, 1.50912870e-02f, -3.57305147e-02f,
  7.33788963e-03f, -9.09297355e-03f, -1.73018873e-02f, -1.61869794e-01f, 1.06808199e-02f, 8.46802816e-02f, -1.23209901e-01f, -1.23547010e-01f, -8.03670511e-02f, 3.06254290e-02f,
  1.33411288e-01f, 1.85098261e-01f, 8.01623836e-02f, 8.51285756e-02f, 7.89844021e-02f, -9.01377723e-02f, -9.53916386e-02f, 4.16387357e-02f, 1.97861657e-01f, -1.20755471e-01f,
  -8.42958391e-02f, -2.37938892e-02f, 4.33240160e-02f, -4.24806103e-02f, 9.63472724e-02f, -5.58615364e-02f, 1.66723937e-01f, 1.86222747e-01f, 1.67147249e-01f, -4.47953567e-02f,
  -3.00861988e-02f, -7.14724958e-02f, -3.89718898e-02f, 3.34031135e-02f, 1.12804985e-02f, 6.57498762e-02f, 1.82896331e-02f, 5.26792482e-02f, 6.86897561e-02f, 7.11020678e-02f,
  -1.77172214e-01f, 6.13210678e-01f, -4.15622853e-02f, 5.26850708e-02f, 1.58351809e-01f, -5.93534589e-01f, -1.31329715e-01f, 7.90026858e-02f, 2.66399104e-02f, 2.87090778e-01f,
  -9.82149988e-02f, 3.22821349e-01f, -4.02023494e-02f, -2.00311556e-01f, -8.04870367e-01f, -4.31791455e-01f, -3.34316045e-01f, -1.53484270e-01f, -8.12180489e-02f, 1.73619166e-01f,
  -1.82994157e-01f, 2.14475915e-02f, -1.82517618e-01f, 2.81866133e-01f, 1.94463968e-01f, 3.14260662e-01f, 1.74852118e-01f, 2.16676995e-01f, 9.14478377e-02f, -4.85256910e-02f,
  -1.37629911e-01f, 2.68756807e-01f, 2.29993016e-01f, -1.23421513e-01f, -9.66353193e-02f, 2.86944415e-02f, -2.56774034e-02f, 1.99518111e-02f, 2.87416093e-02f, -6.62366748e-02f,
  6.50897026e-02f, -6.08889293e-03f, 4.54362147e-02f, 6.49413690e-02f, 7.38484338e-02f, 2.35673338e-02f, -4.40702215e-02f, -6.33343980e-02f, 2.13230979e-02f, -4.62254845e-02f,
  -7.47429859e-03f, -5.79638258e-02f, -5.21242283e-02f, 2.99460292e-02f, 7.77563406e-03f, -4.06956999e-03f, -7.66272023e-02f, 3.56887933e-03f, -1.10065872e-02f, -2.43508890e-02f,
  -2.17457302e-02f, -9.10135172e-03f, 2.61010090e-03f, 4.12816256e-02f, 5.29169850e-03f, 9.30433720e-02f, 2.01886781e-02f, -1.32471696e-03f, 9.05545354e-02f, 1.27254659e-02f,
  3.22322332e-04f, 4.78266664e-02f, 2.66678818e-02f, -4.13005473e-03f, -3.39075737e-02f, 5.47477752e-02f, -5.43564297e-02f, 1.18506320e-01f, -2.96815746e-02f, -9.42684785e-02f,
  9.07783881e-02f, -7.15739876e-02f, 7.61277750e-02f, -6.37335554e-02f, -1.20021224e-01f, 1.92238688e-02f, 1.74193606e-02f, -2.78333034e-02f, -7.56881060e-03f, -8.09530243e-02f,
  -2.14368880e-01f, 1.66955605e-01f, 9.70293432e-02f, 5.96108139e-02f, 8.36186707e-02f, -1.92135535e-02f, -7.10811168e-02f, -2.48745196e-02f, -6.85354520e-04f, 2.66664475e-02f,
  1.64205383e-03f, 2.41262298e-02f, -1.60607174e-02f, -4.49129334e-03f, 2.20281761e-02f, -9.81494859e-02f, 5.71392104e-02f, 6.47514835e-02f, 6.29808710e-05f, 4.38256860e-02f,
  9.26865414e-02f, 9.54554901e-02f, -5.37163913e-02f, -1.44541636e-02f, 2.81589571e-03f, 3.40499245e-02f, 1.97987072e-02f, 1.55920852e-02f, -2.89373379e-02f, 4.84360531e-02f,
  3.10869932e-01f, -1.68995112e-01f, -2.11664602e-01f, 2.55747318e-01f, 1.86948385e-02f, -2.39480436e-01f, -5.17030835e-01f, 4.61910106e-03f, -2.14847982e-01f, -2.14540362e-01f,
  3.99746699e-03f, 1.59048736e-01f, -4.75572407e-01f, 4.61937487e-01f, 5.23649156e-01f, -1.74027100e-01f, 4.67884600e-01f, 2.07060531e-01f, 2.41876841e-02f, 2.15746716e-01f,
  2.28447974e-01f, 5.44600189e-01f, 1.67846203e-01f, 3.19144577e-01f, 2.01900840e-01f, 7.68409669e-02f, 3.38061243e-01f, -1.87666446e-01f, 3.94999593e-01f, 3.10301095e-01f,
  5.34688123e-03f, 1.05925277e-01f, -4.50887121e-02f, 4.99345921e-02f, -5.07386997e-02f, -2.21471898e-02f, -3.29773426e-02f, 6.84501529e-02f, 1.30246282e-02f, -6.93326909e-03f,
  -1.88701488e-02f, 1.57621011e-01f, 1.47505522e-01f, 3.18107419e-02f, -3.62443179e-02f, 3.53292748e-02f, -9.13535431e-02f, -9.61548090e-02f, -1.24604762e-01f, -3.05024683e-02f,
  -1.16582103e-01f, 7.17494579e-04f, 4.75163646e-02f, 6.91645667e-02f, -4.37374935e-02f, 4.92924526e-02f, 2.95946724e-03f, -8.30203071e-02f, 5.88041320e-02f, 9.60665345e-02f,
  5.35286106e-02f, -2.79720519e-02f, 2.63081174e-02f, -7.21810246e-03f, -3.42739783e-02f, -5.46936039e-03f, 3.30337361e-02f, -3.89318168e-02f, -7.11411089e-02f, -6.39224658e-03f,
  2.03433130e-02f, 6.22693496e-03f, -1.46024330e-02f, -7.73491859e-02f, 6.43988624e-02f, 7.47797638e-02f, -2.70620305e-02f, -2.24460685e-03f, -7.07850158e-02f, -5.64097092e-02f,
  -2.47243475e-02f, 3.23181860e-02f, -1.40719965e-01f, -4.73243035e-02f, 3.87023799e-02f, -5.52596189e-02f, 3.26786041e-02f, -3.29877250e-02f, -6.82521611e-02f, 3.50984223e-02f,
  9.69135165e-02f, 2.29728073e-01f, 1.38368079e-04f, 2.55934633e-02f, 6.66387752e-03f, 8.35311711e-02f, 8.53362978e-02f, 3.93291637e-02f, 1.26112863e-01f, 5.27912788e-02f,
  4.55334410e-02f, -1.24950580e-01f, -1.62522367e-03f, -8.29007942e-03f, 1.24504246e-01f, -4.90395613e-02f, -2.68981196e-02f, 6.48504943e-02f, 8.82298723e-02f, 1.22779682e-01f,
  -2.99324188e-03f, -6.03005216e-02f, 1.41357720e-01f, -8.23169947e-02f, 6.55032182e-03f, -3.15936506e-02f, 5.12226261e-02f, 1.04254605e-02f, 1.03559867e-01f, 3.85128111e-02f,
  2.07425043e-01f, 4.43681031e-01f, 4.10305828e-01f, 1.73408657e-01f, 1.35570914e-01f, 5.80364108e-01f, 2.07823455e-01f, 3.89204025e-01f, 5.04217744e-01f, 2.12427471e-02f,
  -1.74204588e-01f, 3.47115546e-01f, -1.21469617e-01f, 3.83080691e-02f, 2.94303238e-01f, 1.90121774e-02f, 6.47577792e-02f, 1.97107513e-02f, 1.36722714e-01f, 1.61772206e-01f,
  1.13202490e-01f, -1.39969792e-02f, -1.63709685e-01f, -1.28945634e-01f, -1.02377757e-02f, -7.75613487e-02f, -5.42046905e-01f, -8.36792886e-02f, -1.20833173e-01f, 2.48649195e-02f,
  8.94305017e-03f, -6.22778460e-02f, 2.43430585e-02f, 4.76250052e-02f, 8.44643712e-02f, 3.34769068e-03f, -4.45280150e-02f, 3.97058241e-02f, -1.61076095e-02f, 9.14986134e-02f,
  -4.24648561e-02f, 1.42687634e-02f, 8.65809694e-02f, 8.70896205e-02f, 3.94525677e-02f, 9.87868607e-02f, 5.35020605e-02f, -4.09146994e-02f, 9.49305147e-02f, 1.35155633e-01f,
  8.90785307e-02f, 5.43514602e-02f, -5.90513507e-03f, -6.93316087e-02f, -2.38111354e-02f, -3.78156602e-02f, 3.85019201e-04f, -1.16985850e-02f, 4.13954593e-02f, 1.42279699e-01f,
  -3.40068154e-02f, -3.47364359e-02f, 1.58606209e-02f, -4.47257943e-02f, 1.03512973e-01f, -7.24496145e-04f, -1.93575732e-02f, -2.49897093e-02f, -1.93058793e-02f, -3.77360135e-02f,
  -1.33844018e-02f, -4.64748666e-02f, 1.44381830e-02f, 8.17199498e-02f, -8.40138737e-03f, -2.61582676e-02f, -3.30384485e-02f, 1.23725012e-02f, 5.77717461e-02f, 3.05909552e-02f,
  3.26332524e-02f, -5.82288299e-03f, 9.60055925e-03f, -8.46008658e-02f, -2.56669503e-02f, -2.25894595e-03f, 2.41484363e-02f, -8.16465169e-03f, -8.40497464e-02f, 1.97369629e-03f,
  1.57549366e-01f, 2.56148398e-01f, -4.68660221e-02f, -2.32945010e-03f, -6.72525838e-02f, 5.91199659e-02f, -3.43849212e-02f, 1.35080814e-01f, 8.54203925e-02f, 6.86575547e-02f,
  1.81797631e-02f, -7.16309622e-02f, 3.05736586e-02f, -6.81894124e-02f, -2.83792391e-02f, 1.26869485e-01f, -1.12740561e-01f, -3.75856971e-03f, -6.16124133e-03f, -3.97652313e-02f,
  -8.30070768e-03f, -5.17771058e-02f, -3.30054783e-03f, -4.83246595e-02f, 1.64659023e-02f, -9.72328484e-02f, 7.51659572e-02f, -8.14917758e-02f, -1.13783237e-02f, 9.62990373e-02f,
  5.67128003e-01f, -2.79470146e-01f, -4.07780111e-01f, 2.07414955e-01f, 3.14613372e-01f, -3.90305459e-01f, 3.74748781e-02f, 1.02572814e-01f, 6.95325673e-01f, -1.31872490e-01f,
  1.15419123e-02f, -7.53964335e-02f, 7.10437447e-02f, -1.97461143e-01f, -1.57137141e-01f, -7.11891875e-02f, -2.05131873e-01f, -6.34584576e-02f, 4.04181749e-01f, -6.28140122e-02f,
  2.03822389e-01f, -2.39255484e-02f, -3.06037217e-01f, -1.36189029e-01f, -8.59025121e-02f, -4.50120121e-02f, -1.74909294e-01f, -1.10553250e-01f, -4.64063764e-01f, -2.89092381e-02f,
  -8.31026062e-02f, 2.84172535e-01f, -2.92112809e-02f, -3.26899849e-02f, 4.06710953e-02f, -5.46320528e-02f, -2.04388335e-01f, -6.37938008e-02f, 1.14883400e-01f, 6.11315034e-02f,
  -5.52884601e-02f, -4.77698855e-02f, 8.58016834e-02f, -4.77771740e-03f, 1.02521218e-01f, -2.07120571e-02f, 6.65855631e-02f, -1.05190426e-02f, 5.33001050e-02f, -7.90580437e-02f,
  -3.17580551e-02f, -2.25931895e-03f, -1.07919979e-04f, -1.68969352e-02f, -3.15396562e-02f, 1.06228732e-01f, -1.44251347e-01f, -2.10241228e-01f, -1.12534553e-01f, 1.08549789e-01f,
  -2.62427889e-03f, 4.43516709e-02f, 1.65104829e-02f, 8.18451215e-03f, 9.63191390e-02f, 9.27815679e-03f, 2.72699036e-02f, -6.34169728e-02f, 8.31498355e-02f, -9.61166173e-02f,
  5.88895492e-02f, 6.56063184e-02f, 1.17018670e-01f, 3.87247913e-02f, 8.55839327e-02f, 7.37868026e-02f, -8.51724818e-02f, -3.01047675e-02f, 4.38549481e-02f, -6.35482818e-02f,
  -1.49861565e-02f, 3.06126289e-03f, 9.60165355e-03f, -3.52431573e-02f, -4.90887389e-02f, 1.14632733e-01f, 1.00403214e-02f, -3.79208848e-02f, -1.72799062e-02f, -1.63645037e-02f,
  -1.71781287e-01f, -7.41076842e-02f, 8.64689574e-02f, 3.39616723e-02f, -1.37514353e-01f, 2.40866654e-03f, -7.67044947e-02f, 1.05506089e-02f, -2.95192394e-02f, 4.33398560e-02f,
  -3.47273462e-02f, 9.54375267e-02f, -4.86663021e-02f, -1.01719178e-01f, -1.14226773e-01f, 3.95941809e-02f, -1.25564157e-03f, 7.15170503e-02f, -1.17226422e-01f, -8.25373977e-02f,
  -3.46128158e-02f, 1.10109515e-01f, -5.78034185e-02f, 1.00873552e-01f, -6.15645349e-02f, 1.65995955e-02f, -2.36225612e-02f, -6.98849605e-03f, 4.94824490e-03f, -4.54099104e-02f,
  -4.69932199e-01f, 3.70545119e-01f, 1.90640405e-01f, 5.79676211e-01f, -4.70254570e-01f, -2.55244553e-01f, 2.52048045e-01f, -4.19971757e-02f, 1.86881825e-01f, 3.27326953e-01f,
  1.95093423e-01f, -2.38098785e-01f, 2.51500189e-01f, 4.05825943e-01f, -1.46422908e-01f, 3.26772720e-01f, 5.12500405e-01f, 1.22420482e-01f, 1.28629245e-02f, 2.04469725e-01f,
  1.83485702e-01f, 2.15878580e-02f, 3.00455421e-01f, -7.53861964e-02f, 6.07694760e-02f, 1.09868191e-01f, 4.17824417e-01f, -1.31353602e-01f, 2.23104000e-01f, -2.87906438e-01f,
  2.47336831e-02f, -3.89960967e-02f, 1.70913171e-02f, -7.45941103e-02f, 1.33130044e-01f, 3.79912816e-02f, 2.74290852e-02f, -9.38598216e-02f, -5.59710376e-02f, 1.08911194e-01f,
  -2.52524652e-02f, -1.15681753e-01f, -2.97543891e-02f, -5.50584048e-02f, -1.94548473e-01f, -2.47712526e-02f, -2.46768650e-02f, 6.26691505e-02f, -9.91223678e-02f, -1.02640957e-01f,
  2.24602036e-02f, 1.61334854e-02f, 1.75517589e-01f, 1.65067893e-02f, 1.86195448e-02f, -1.10041481e-02f, 1.21013604e-01f, -8.56843889e-02f, 3.60396542e-02f, -1.06780060e-01f,
  -1.56617865e-01f, 6.49388134e-02f, 4.98629957e-02f, -2.06683041e-03f, 2.94805691e-02f, 1.48870736e-01f, -1.56325698e-02f, 1.14483805e-02f, -1.05050705e-01f, 8.56947154e-02f,
  8.02042037e-02f, -5.17891757e-02f, 6.47026747e-02f, -2.12741066e-02f, 4.13259566e-02f, 4.39763367e-02f, -1.96352061e-02f, -1.09753042e-01f, 1.34098068e-01f, 8.36398751e-02f,
  1.76954886e-03f, 1.53121641e-02f, 4.02134135e-02f, -4.82819751e-02f, 8.84265918e-03f, -5.62132597e-02f, 1.63336750e-02f, 5.63663654e-02f, 9.17964652e-02f, -2.99777761e-02f,
  1.70534685e-01f, 3.22196603e-01f, 9.87850800e-02f, -1.20158128e-01f, 6.40736073e-02f, 2.11677216e-02f, 1.25916377e-01f, -5.39131761e-02f, 8.88752416e-02f, 6.91193864e-02f,
  6.16144203e-02f, 1.09890006e-01f, 2.71698553e-02f, -7.42644742e-02f, 3.31443511e-02f, 1.72537744e-01f, 1.47697657e-01f, 1.13469042e-01f, 1.07988350e-01f, -2.41373889e-02f,
  1.31644621e-01f, 3.54297794e-02f, 7.94325769e-02f, 8.25422164e-03f, 3.97532992e-02f, 1.61709334e-03f, -1.41477957e-01f, -1.96954776e-02f, -5.21122739e-02f, 6.93796352e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 26)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 26;
const float L0_fan_Bp_bar_data[] = {
  4.87287790e-01f, 7.15194106e-01f, 3.35052341e-01f, 5.34743428e-01f, 5.19596994e-01f, 2.91892231e-01f, 2.76222110e-01f, 4.48655397e-01f, 4.58792359e-01f, 6.20639384e-01f,
  3.58477086e-01f, 5.81267059e-01f, 6.85687721e-01f, 5.61696529e-01f, 6.07932925e-01f, 5.59691846e-01f, 4.72998172e-01f, 4.31923181e-01f, 5.89108586e-01f, 2.11088911e-01f,
  5.10240972e-01f, 3.73692870e-01f, 2.06370637e-01f, 5.86717784e-01f, 4.85060513e-01f, 4.10585135e-01f
};

// L1_linear_W (Shape: 12 x 64)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 64;
const float L1_linear_W_data[] = {
  -2.71460801e-01f, -5.20938896e-02f, -7.46081099e-02f, -2.84149587e-01f, 1.50053084e-01f, -3.81759834e-03f, -6.02418184e-01f, -9.35830250e-02f, -3.64449739e-01f, -3.51351112e-01f,
  -2.24831346e-02f, 2.53862977e-01f, 9.69786197e-02f, 1.01853706e-01f, 4.21429202e-02f, 2.48179138e-01f, 1.90887153e-01f, -9.37718432e-03f, -1.10012725e-01f, -2.05776617e-01f,
  3.50729734e-01f, 3.91346455e-01f, 2.08004802e-01f, -5.54058492e-01f, -1.13236293e-01f, 6.10861480e-02f, 6.05593264e-01f, -2.54315495e-01f, 2.83476293e-01f, 1.60011888e-01f,
  4.07034039e-01f, -2.37711184e-02f, 3.37048739e-01f, -2.74607707e-02f, 1.13528810e-01f, -2.76147097e-01f, -2.54595429e-02f, 1.86732188e-01f, 6.33718312e-01f, -4.55436468e-01f,
  2.22303733e-01f, 4.69407260e-01f, -1.64883062e-01f, -3.00317585e-01f, 6.85666263e-01f, -3.25247824e-01f, -3.26327384e-01f, -3.57099503e-01f, 1.52508974e-01f, -4.55766916e-01f,
  -1.75421789e-01f, -4.54850495e-01f, -4.03806299e-01f, -5.30535758e-01f, 8.43858197e-02f, -2.93977082e-01f, 2.53157884e-01f, -1.21719250e-02f, -2.82092780e-01f, -1.79554373e-01f,
  -4.45661515e-01f, -6.90256417e-01f, -4.45380330e-01f, 8.14543426e-01f, -8.30482841e-02f, 1.49599642e-01f, -2.19831094e-01f, -4.74991828e-01f, -2.17315108e-01f, -8.36457908e-02f,
  8.20830837e-02f, 2.19881848e-01f, 1.76871017e-01f, 6.25188470e-01f, -7.11428970e-02f, -5.67643583e-01f, 1.85934067e-01f, -2.27882162e-01f, 1.03245795e-01f, 1.73581213e-01f,
  -1.33232430e-01f, 3.22212614e-02f, -4.32833552e-01f, -5.16278386e-01f, -7.03718543e-01f, -4.54044402e-01f, 4.00857687e-01f, 4.94244337e-01f, 2.38073945e-01f, -5.49217463e-01f,
  -1.33859262e-01f, -2.21753076e-01f, -3.53514493e-01f, -2.90916413e-01f, 2.73781568e-01f, 1.76311359e-01f, -3.64336967e-01f, -3.05515993e-02f, -4.36943054e-01f, 3.84976536e-01f,
  -6.16730690e-01f, -6.39467314e-02f, 3.93389106e-01f, -2.28720039e-01f, 5.03471732e-01f, -5.58447719e-01f, 2.10609473e-02f, -2.84675002e-01f, 3.25044066e-01f, -4.14855510e-01f,
  7.00143278e-02f, 2.83889502e-01f, 4.14360344e-01f, 1.40530497e-01f, -5.81373990e-01f, -6.44342899e-01f, -6.47524714e-01f, 5.58293641e-01f, -5.57895362e-01f, 2.20614880e-01f,
  -1.28487736e-01f, -5.25599957e-01f, -8.38000298e-01f, -4.03122783e-01f, 2.63654292e-01f, 2.39935115e-01f, 2.15694830e-02f, -1.54023603e-01f, 8.34855363e-02f, -2.14113966e-01f,
  -8.46210942e-02f, 1.81832388e-01f, 8.92350823e-02f, -1.12857427e-02f, -1.12960637e-01f, -3.22157890e-01f, -2.21863329e-01f, -2.47261077e-01f, 7.90329929e-03f, -3.71489555e-01f,
  3.68527211e-02f, -3.11524659e-01f, -7.02259839e-02f, -3.62004079e-02f, -2.06245497e-01f, 1.59054160e-01f, 1.59438193e-01f, 1.60584241e-01f, -3.13146524e-02f, 1.11097030e-01f,
  -1.78857595e-01f, 2.15852074e-02f, 2.24593922e-01f, 2.43777826e-01f, 3.54845434e-01f, 2.77371138e-01f, -2.64499485e-01f, 4.60772783e-01f, 2.08666340e-01f, 1.41523927e-01f,
  -2.64936298e-01f, 2.20349684e-01f, -1.98027417e-01f, 3.05065036e-01f, 1.50647014e-01f, 4.51212287e-01f, -4.26330507e-01f, -3.07415903e-01f, -4.47003901e-01f, -3.21788341e-01f,
  6.19157970e-01f, -2.03492776e-01f, -2.30157673e-01f, -2.45604292e-01f, -1.15557648e-02f, 4.32843179e-01f, 7.35045969e-01f, -1.87734514e-01f, 1.03878126e-01f, 2.49629200e-01f,
  -2.23596439e-01f, -2.65054941e-01f, -2.17273355e-01f, -5.27628481e-01f, -4.53890711e-01f, -2.41373345e-01f, 1.64240282e-02f, -1.48160709e-02f, 6.87362969e-01f, -2.94598401e-01f,
  -3.90644759e-01f, -5.61147928e-01f, 2.08985314e-01f, -1.35764271e-01f, 1.47105068e-01f, 2.06130579e-01f, -4.11594212e-01f, 7.76559263e-02f, 2.94130683e-01f, -2.97837764e-01f,
  1.74890310e-01f, -2.31352657e-01f, -1.18620962e-01f, -2.52816290e-01f, -3.83589417e-01f, -5.91664389e-02f, -2.51576334e-01f, 1.26399875e-01f, -2.49684408e-01f, 1.53805865e-02f,
  -3.50341946e-02f, 7.67091289e-02f, -5.02435267e-01f, 2.78553158e-01f, -1.96508497e-01f, -2.63067275e-01f, 4.73821759e-01f, -3.09131712e-01f, 1.25468925e-01f, 3.95748168e-01f,
  1.23536073e-01f, 4.13615853e-01f, -4.01896000e-01f, -8.56461935e-03f, 9.51976776e-02f, -3.20525616e-01f, 8.39429945e-02f, -4.66667771e-01f, -1.98815048e-01f, 1.95147812e-01f,
  -3.66127670e-01f, 3.67315918e-01f, -1.32282048e-01f, 3.31642687e-01f, -5.84299922e-01f, 3.43462974e-01f, -1.08297646e-01f, -1.40692592e-01f, -2.26450428e-01f, -5.32081604e-01f,
  -3.39535773e-02f, -1.40702173e-01f, -6.41184032e-01f, -7.11936057e-02f, -5.84713817e-01f, -6.05862498e-01f, 5.74688077e-01f, -1.19899668e-01f, 6.54500782e-01f, -9.32485331e-03f,
  -2.68071115e-01f, 7.05170691e-01f, -2.28025094e-01f, -5.32316864e-01f, 3.09787452e-01f, -5.04366517e-01f, 3.38786840e-01f, 3.00044686e-01f, -2.06189185e-01f, 3.91051173e-01f,
  2.79169798e-01f, 2.75119394e-01f, -3.75044644e-02f, 2.25876853e-01f, 4.02163833e-01f, 9.54000354e-02f, -2.35499516e-01f, -9.19487923e-02f, 3.87552142e-01f, 2.01069936e-01f,
  4.59769636e-01f, -1.16507567e-01f, -3.78508955e-01f, 6.79539144e-02f, 4.15713906e-01f, 1.79123670e-01f, 4.26985383e-01f, 6.02771580e-01f, -1.61555842e-01f, -4.05371517e-01f,
  3.35439947e-03f, -4.25872266e-01f, -3.17130446e-01f, -4.52225327e-01f, 6.12126291e-01f, 5.37503123e-01f, -5.47565222e-01f, 1.28756493e-01f, -9.84114408e-02f, -1.48264542e-01f,
  3.66773039e-01f, -4.79646474e-01f, -1.20608255e-01f, -9.08605307e-02f, 5.57863340e-02f, 4.30702478e-01f, 7.74225369e-02f, -3.36937338e-01f, -3.82395625e-01f, -2.00280562e-01f,
  1.58949062e-01f, 6.77383065e-01f, 2.52516627e-01f, 2.75845557e-01f, -7.57100105e-01f, -4.14230466e-01f, -2.07587052e-02f, 6.34806573e-01f, 2.38495484e-01f, 1.10743053e-01f,
  4.78924394e-01f, -8.25065494e-01f, -5.06572902e-01f, -5.06043673e-01f, -3.49368840e-01f, -7.58277237e-01f, -1.51178122e-01f, 3.07110548e-01f, -6.39895201e-01f, -3.01262558e-01f,
  3.32655907e-01f, -1.01682238e-01f, 2.70282894e-01f, 4.96907800e-01f, -4.30648774e-02f, 1.05797075e-01f, 1.81471378e-01f, -7.61076063e-02f, -5.48016280e-03f, -1.76670268e-01f,
  1.65589169e-01f, 3.47403973e-01f, -2.79266655e-01f, -8.49072542e-03f, -2.41105482e-02f, -1.01999417e-01f, 1.62137419e-01f, 4.29107919e-02f, 2.11483628e-01f, -1.18941650e-01f,
  5.45182586e-01f, -1.69867486e-01f, 3.92335057e-01f, 5.57818413e-01f, -3.55203122e-01f, -3.28019530e-01f, -4.50307578e-01f, -2.92328209e-01f, -7.85215124e-02f, -2.43969694e-01f,
  -6.61106557e-02f, -5.25624514e-01f, -3.44093561e-01f, 5.48581064e-01f, 3.21552455e-01f, 3.39683741e-02f, 5.78335941e-01f, 8.47015321e-01f, 4.10895646e-01f, 3.42113405e-01f,
  2.10136488e-01f, -2.37368256e-01f, -5.27616799e-01f, -4.08371001e-01f, -4.52888310e-01f, -1.00102775e-01f, -8.78746450e-01f, -7.41066784e-02f, -3.75626922e-01f, 4.09242570e-01f,
  -4.23608184e-01f, -4.49960649e-01f, 5.06559968e-01f, -4.52845931e-01f, -7.18809664e-01f, 2.98182279e-01f, 1.33339316e-01f, 5.30913711e-01f, 4.07378584e-01f, -4.22750771e-01f,
  -2.09867299e-01f, 5.08338571e-01f, 1.51346415e-01f, 1.65171042e-01f, -2.26273134e-01f, 1.45387249e-02f, -1.18608087e-01f, -1.61049664e-01f, 1.68418646e-01f, 1.57923549e-01f,
  -2.80258693e-02f, -1.21582583e-01f, -1.83118403e-01f, 2.86250532e-01f, -1.20230056e-02f, 7.35643357e-02f, -6.16313964e-02f, -6.71461374e-02f, -6.70504710e-03f, -1.28310293e-01f,
  1.01024427e-01f, -6.04282498e-01f, -7.46645208e-04f, 4.98549670e-01f, -1.03107259e-01f, -4.49379623e-01f, -3.74577880e-01f, 3.47367853e-01f, 5.30503333e-01f, 5.59877634e-01f,
  1.13359042e-01f, 1.37732163e-01f, -3.58978093e-01f, -5.26122212e-01f, 4.96281743e-01f, 1.51671201e-01f, -3.75643641e-01f, -3.51457298e-01f, 3.01332980e-01f, -2.26237833e-01f,
  2.43879154e-01f, -4.65270728e-01f, -5.40709317e-01f, -6.50545418e-01f, -1.94771186e-01f, -2.77030710e-02f, 4.01765317e-01f, -1.56187162e-01f, -3.95493209e-01f, 2.90271819e-01f,
  4.33064073e-01f, -8.48939121e-01f, 5.12369573e-01f, 3.54958296e-01f, -3.97047877e-01f, 4.28341717e-01f, 7.95767605e-02f, -3.51226926e-01f, -3.44332278e-01f, 3.50083739e-01f,
  -2.81370580e-01f, -1.14047281e-01f, 1.92032501e-01f, -2.90876716e-01f, -4.28605855e-01f, 1.31243452e-01f, 7.68670619e-01f, -7.93139264e-02f, -3.07853758e-01f, 8.64071101e-02f,
  -2.78865963e-01f, -3.33373904e-01f, -2.85457551e-01f, -9.26744118e-02f, -8.89277533e-02f, -4.05409411e-02f, -2.12549016e-01f, -1.37374192e-01f, -2.31831729e-01f, -5.98022230e-02f,
  5.35711199e-02f, -3.21365595e-01f, -1.63585037e-01f, -8.99734497e-02f, -1.33297041e-01f, -1.11230426e-01f, -1.62520751e-01f, -2.37248793e-01f, 1.06570154e-01f, 2.24952728e-01f,
  -2.54594415e-01f, -6.46317974e-02f, -2.74793684e-01f, 3.20481420e-01f, -2.47426294e-02f, 1.30203187e-01f, -1.81469694e-01f, 1.39167726e-01f, -1.87799245e-01f, 2.91855991e-01f,
  2.61737645e-01f, 2.85291880e-01f, -1.27899677e-01f, 2.33876541e-01f, 2.18099341e-01f, -1.22464553e-01f, -4.25909132e-01f, -4.79761630e-01f, -2.04447240e-01f, 1.19957715e-01f,
  -2.37184212e-01f, 1.01336144e-01f, -5.84894121e-02f, 3.74873847e-01f, -4.40285563e-01f, 9.46860015e-02f, -2.78288037e-01f, -2.89507002e-01f, 8.37098658e-02f, -6.77924752e-02f,
  4.68210638e-01f, -1.26258880e-01f, 3.09768945e-01f, -1.11487158e-01f, 1.50972724e-01f, 7.31145561e-01f, 6.36084080e-01f, -2.61577696e-01f, 1.47101566e-01f, -3.63833308e-01f,
  4.26469326e-01f, -3.56297612e-01f, -1.67017266e-01f, 8.30624551e-02f, -6.53088614e-02f, 7.66229862e-03f, -2.14690179e-01f, -1.26840562e-01f, -1.62976488e-01f, -1.48228645e-01f,
  -8.74539390e-02f, -4.44671959e-01f, -1.06482999e-03f, -1.48807066e-02f, -2.81344384e-01f, 1.55851960e-01f, -1.37818873e-01f, -3.38798344e-01f, -1.31453216e-01f, -8.82695392e-02f,
  -2.38791481e-02f, 3.84445250e-01f, -1.02996551e-01f, -3.24618340e-01f, -1.29392758e-01f, 2.29960158e-01f, 1.14932150e-01f, 3.54599118e-01f, -3.67500097e-01f, 1.33100897e-01f,
  -1.50607616e-01f, -3.22114050e-01f, 1.01903090e-02f, -3.68034899e-01f, -6.93731606e-02f, -3.01437795e-01f, -1.99739143e-01f, 7.79808918e-03f, -1.51682153e-01f, -2.02175714e-02f,
  -3.37278396e-01f, -4.75843817e-01f, -3.82254422e-01f, 4.62712049e-01f, -4.16668475e-01f, -1.90818101e-01f, 3.50591660e-01f, -1.83228269e-01f, -2.18977436e-01f, 1.03636615e-01f,
  -5.61443567e-01f, -3.44972968e-01f, -1.07859299e-01f, 4.97023910e-01f, -7.92040601e-02f, 3.39827031e-01f, -3.41992348e-01f, -2.43741170e-01f, 1.42787382e-01f, -1.76279560e-01f,
  4.26612824e-01f, 2.69145310e-01f, 5.14818788e-01f, -2.54800469e-02f, -2.88772583e-01f, 7.04666436e-01f, 1.30108058e-01f, -8.10769200e-02f, 3.69961172e-01f, -4.01052028e-01f,
  3.36392969e-02f, -2.75607169e-01f, 2.72954106e-01f, 4.44340780e-02f, -7.27102160e-02f, 7.80482739e-02f, 1.07737832e-01f, 1.60874993e-01f, -3.42220403e-02f, 1.31148502e-01f,
  -3.80041391e-01f, 4.14814539e-02f, 2.80568451e-01f, 2.91460335e-01f, -2.72341758e-01f, -2.07998365e-01f, 2.87662417e-01f, 1.69630021e-01f, -4.00634944e-01f, -6.04337037e-01f,
  7.65848830e-02f, -2.13241294e-01f, 3.15367579e-01f, -4.46000963e-01f, 2.47340918e-01f, 3.88881415e-01f, -4.35781747e-01f, -3.89192790e-01f, 4.01398987e-01f, 5.17427087e-01f,
  3.42325509e-01f, -1.79219633e-01f, 7.85479769e-02f, -5.57504714e-01f, -4.84275818e-01f, -4.35365081e-01f, -2.14853380e-02f, -3.71521771e-01f, 3.53276044e-01f, -4.32762921e-01f,
  -4.72628385e-01f, -4.94044840e-01f, 5.30596733e-01f, 4.30566549e-01f, -3.36448789e-01f, -7.86340535e-01f, 6.72188818e-01f, -7.00219035e-01f, 4.46129769e-01f, 1.18088812e-01f,
  -5.40928602e-01f, 6.13362610e-01f, -4.81290489e-01f, 5.67633472e-02f, 2.69147217e-01f, -2.11364329e-01f, -4.28253591e-01f, -4.78327572e-02f, -3.27899367e-01f, -2.57039279e-01f,
  9.61700338e-04f, -1.78586170e-01f, -2.21780110e-02f, 4.14668322e-02f, 2.67661422e-01f, 1.10987872e-01f, -8.51536766e-02f, 1.64124802e-01f, -2.84050077e-01f, 2.73583382e-01f,
  2.36732557e-01f, 2.98934937e-01f, 1.66356683e-01f, 1.83097750e-01f, -2.18157142e-01f, 1.36045873e-01f, 2.12371394e-01f, 6.47455826e-02f, 1.08108103e-01f, -5.12446344e-01f,
  -2.54273325e-01f, -3.85414422e-01f, 4.85998571e-01f, -4.17633772e-01f, -5.08691907e-01f, 6.05988085e-01f, 1.11475721e-01f, 3.63299131e-01f, 2.25750402e-01f, -3.55402917e-01f,
  4.15440619e-01f, 4.28906441e-01f, 4.25047368e-01f, -3.63011956e-01f, -4.66731071e-01f, 3.90068978e-01f, -4.27110314e-01f, -4.24343208e-03f, -2.63938040e-01f, 5.31051815e-01f,
  -5.36159754e-01f, -5.83200037e-01f, 5.65291643e-01f, -5.36011934e-01f, -3.43684494e-01f, -2.12281104e-02f, -3.48456115e-01f, 1.11560300e-01f, -3.09348136e-01f, 1.58885553e-01f,
  1.63851485e-01f, -5.03111422e-01f, -1.20426416e-01f, 7.43846655e-01f, -3.87086749e-01f, -2.50483960e-01f, 4.85875785e-01f, -2.95185655e-01f, -3.80463779e-01f, 2.37250417e-01f,
  -5.37414312e-01f, -4.06813473e-01f, -2.73439407e-01f, 1.39292613e-01f, -2.21048370e-01f, 7.18028024e-02f, 1.30902946e-01f, 1.77908391e-01f, 6.97611049e-02f, -1.33217365e-01f,
  2.34326303e-01f, -1.01980954e-01f, 3.46060306e-01f, 6.29609451e-02f, -1.14382431e-01f, 2.34241769e-01f, 8.72557834e-02f, 6.50621802e-02f, 1.80863827e-01f, 9.05145779e-02f,
  9.17753950e-02f, -2.84007136e-02f, -1.67136211e-02f, 3.33862007e-01f, 1.56264618e-01f, 8.15697163e-02f, -6.86630011e-02f, 4.26960647e-01f, -4.34134752e-01f, -2.50018418e-01f,
  -2.15653643e-01f, 1.55484363e-01f, -1.97207749e-01f, -3.27931583e-01f, -1.07276499e-01f, 2.04281509e-02f, 1.93799257e-01f, -6.66899830e-02f, -6.59126714e-02f, 6.98553175e-02f,
  2.86157340e-01f, -3.24283063e-01f, -4.15819436e-01f, -7.72081539e-02f, -1.32814884e-01f, 6.64589226e-01f, -4.38285083e-01f, 7.81680882e-01f, -3.21815789e-01f, 1.38039172e-01f,
  -4.04706478e-01f, -3.78748953e-01f, -3.91174883e-01f, 6.64831400e-01f, 5.53084552e-01f, 8.20804536e-02f, -4.57422048e-01f, -3.87920529e-01f, -4.07344759e-01f, -3.49111259e-01f,
  -5.95744371e-01f, -2.75577664e-01f, -3.20323735e-01f, 5.10260582e-01f, -2.77057022e-01f, 3.00420195e-01f, -8.72353241e-02f, -1.46913633e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  4.74802293e-02f, -1.23928934e-01f, -1.43904556e-02f, -1.40362442e-01f, 2.17456281e-01f, 1.25747360e-02f, -8.17203820e-02f, 2.70100236e-02f, -7.37116784e-02f, 1.10305406e-01f,
  5.28198704e-02f, -2.49316469e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 19, 26
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        64, 12
    );
    }
    