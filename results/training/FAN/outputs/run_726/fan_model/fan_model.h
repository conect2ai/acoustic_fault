/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 128 (x1)
    * Saída: 12
    * Buffer Máx: 128
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 128;
    const int FAN_MAX_BUFFER_SIZE = 128;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 38 x 120)
const int L0_fan_Wp_rows = 38;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -3.08422118e-01f, -2.14652698e-02f, 4.54270877e-02f, 8.87537077e-02f, 1.93862200e-01f, 2.31783971e-01f, 2.46036291e-01f, 5.12493365e-02f, 2.23082937e-02f, 2.95146815e-02f,
  1.82623323e-02f, 1.14668682e-01f, 1.51327789e-01f, -7.83769414e-02f, -8.45957845e-02f, 1.56753808e-01f, 1.25527069e-01f, -1.23317301e-01f, -1.34879887e-01f, -5.56337498e-02f,
  5.10018803e-02f, -5.49607389e-02f, -2.74604261e-01f, -7.88219944e-02f, 3.42832692e-02f, 1.36774257e-01f, 1.15316350e-03f, -3.85077782e-02f, -7.37405382e-03f, 3.57410982e-02f,
  1.36702983e-02f, -1.12319179e-01f, -6.80480972e-02f, -1.42885610e-01f, -2.03612335e-02f, -8.61636922e-02f, 2.41468232e-02f, -1.42101064e-01f, -1.00663751e-01f, 1.99871138e-02f,
  -3.10919154e-02f, -1.24241516e-01f, -2.22983398e-02f, -2.47471735e-06f, -8.49381089e-02f, -1.03732362e-01f, -1.16112128e-01f, -1.92089900e-01f, -1.09870747e-01f, -7.66042992e-02f,
  5.93428034e-03f, 1.67198535e-02f, 6.50475547e-02f, 2.51413621e-02f, -5.08296788e-02f, -3.71904559e-02f, 7.67540932e-02f, 5.72699262e-03f, 8.61182809e-03f, -7.21581727e-02f,
  -8.02956801e-03f, 3.00803483e-02f, 1.78109836e-02f, -4.40460928e-02f, -6.19716458e-02f, 5.67418225e-02f, -2.45291498e-02f, 1.28570795e-01f, -6.19576089e-02f, 5.57922646e-02f,
  3.15156914e-02f, -7.47237280e-02f, -1.52984103e-02f, -1.23876529e-02f, 3.35737807e-03f, -2.58859619e-03f, 2.95789856e-02f, -3.89101962e-03f, 2.65223663e-02f, 6.81613199e-03f,
  -6.19169846e-02f, -3.27318646e-02f, -4.21213768e-02f, -2.24053431e-02f, -5.58931604e-02f, 5.48682660e-02f, -1.19378073e-02f, 6.25258386e-02f, 1.00681186e-02f, 6.51825517e-02f,
  7.08141550e-02f, -1.00305937e-02f, 5.00763506e-02f, -7.41804019e-02f, 8.92770663e-02f, -1.39114544e-01f, 4.59712297e-02f, -9.33590531e-02f, -9.50918570e-02f, -6.53986260e-03f,
  -6.35121390e-02f, -9.09226164e-02f, 7.46162236e-02f, -8.40911493e-02f, 6.87514246e-02f, -2.96447705e-02f, 3.36183570e-02f, -9.00899153e-03f, 3.86491828e-02f, -8.65738560e-03f,
  -3.40472572e-02f, 1.35771051e-01f, 1.24274902e-01f, 1.10547557e-01f, 6.32887036e-02f, 1.18905984e-01f, 9.13672894e-02f, 3.34712975e-02f, 7.22173136e-03f, 1.33424327e-02f,
  -3.15649211e-01f, 1.32968634e-01f, -6.49854988e-02f, -1.81079784e-03f, 5.43639697e-02f, 6.27848059e-02f, 1.74694881e-01f, 3.60948257e-02f, -4.11178693e-02f, 6.56686947e-02f,
  -9.19210985e-02f, -5.79401515e-02f, -6.42754436e-02f, -1.58191249e-02f, -3.71736567e-03f, -3.96804325e-02f, 6.18056841e-02f, -1.86070129e-02f, -1.00546435e-01f, -6.28923550e-02f,
  1.54534485e-02f, -3.51697616e-02f, -8.78255293e-02f, 3.87304835e-02f, 6.12147003e-02f, 6.81522116e-02f, 4.46950905e-02f, -5.18429130e-02f, 1.11171100e-02f, -4.10232395e-02f,
  -2.25999534e-01f, -2.49380738e-01f, -1.78694963e-01f, 8.37546121e-03f, 3.49677895e-04f, -1.18885845e-01f, -6.26427634e-03f, -5.19302897e-02f, -1.12737678e-01f, -1.11979887e-01f,
  -7.18436614e-02f, 2.81104818e-03f, -1.38653055e-01f, -9.56839323e-02f, -5.54092601e-03f, -1.26243144e-01f, 6.21836772e-03f, -4.07112800e-02f, -3.86034548e-02f, -1.07717924e-02f,
  1.74290296e-02f, -1.15069561e-01f, 1.23930117e-02f, -7.01641589e-02f, -2.43946053e-02f, -9.47014987e-02f, -5.05274395e-03f, 3.81959192e-02f, 3.43012065e-02f, -3.87539268e-02f,
  2.29299724e-01f, 1.42736971e-01f, 1.74507037e-01f, 2.28875339e-01f, 1.90519348e-01f, 1.28239557e-01f, 1.42959744e-01f, 9.69027653e-02f, 3.61419171e-02f, 1.70425832e-01f,
  1.44176275e-01f, 6.34947345e-02f, 1.05309606e-01f, 6.04744554e-02f, 1.38357848e-01f, 1.06392667e-01f, 1.64449334e-01f, 1.09538093e-01f, 1.22807927e-01f, 6.62159473e-02f,
  9.88356993e-02f, 5.51755577e-02f, 3.24442647e-02f, 1.41072586e-01f, 3.89637798e-02f, 8.73217955e-02f, 1.98178619e-01f, 2.15863753e-02f, 2.10818991e-01f, 1.55333161e-01f,
  4.97700423e-02f, -8.03223252e-02f, -1.15937710e-01f, -1.51395276e-01f, -1.34447366e-01f, -1.62798151e-01f, -1.47554636e-01f, -4.33043726e-02f, -1.51540071e-01f, -9.16124433e-02f,
  -9.01865810e-02f, -9.43442360e-02f, -5.19058332e-02f, -1.10835046e-01f, -1.19184226e-01f, -9.20788273e-02f, 3.68274711e-02f, -5.05717807e-02f, -1.69273958e-01f, -1.37731686e-01f,
  -5.29716685e-02f, 5.19892909e-02f, -7.69353285e-02f, 2.36768611e-02f, -5.60375629e-03f, -1.42209008e-01f, -4.86796945e-02f, -7.78491572e-02f, 5.33515494e-03f, 1.02871701e-01f,
  3.20956022e-01f, 2.99577624e-01f, -8.17711204e-02f, 3.55726033e-01f, 1.87732771e-01f, -1.33897200e-01f, 1.05424508e-01f, 1.12365603e-01f, 1.56573713e-01f, 2.36593038e-01f,
  -2.24980307e-04f, -1.33831397e-01f, -1.87630624e-01f, -2.48862922e-01f, -1.04252294e-01f, 4.47265282e-02f, 1.69474095e-01f, -6.38122261e-02f, -2.70834774e-01f, -1.11062154e-01f,
  9.55285281e-02f, 2.85842776e-01f, 2.47390389e-01f, 1.77089050e-01f, 1.96419612e-01f, -1.53635545e-02f, 1.88366503e-01f, 1.07932270e-01f, 9.27470326e-02f, 3.40818167e-01f,
  -1.44376412e-01f, 1.24694616e-01f, -6.30100369e-02f, 9.28750560e-02f, 1.93447284e-02f, 5.85369654e-02f, 2.42015030e-02f, 7.63152987e-02f, 6.64672256e-02f, 3.91806737e-02f,
  5.05557135e-02f, 5.75185902e-02f, 5.56422584e-02f, -7.92825222e-03f, 8.86636302e-02f, -5.17608784e-02f, 1.44343778e-01f, 1.00162849e-01f, -8.40906333e-03f, 1.15066310e-02f,
  4.39575985e-02f, 1.65531531e-01f, 1.50508871e-02f, -7.50256777e-02f, -4.43169773e-02f, -3.33733670e-02f, -8.13703015e-02f, 5.61857456e-03f, -9.79234353e-02f, 2.20437199e-01f,
  -4.47380589e-03f, -3.08616348e-02f, -6.12422526e-02f, -5.43197915e-02f, -4.91289981e-02f, -3.81976329e-02f, -4.14238237e-02f, -6.93880096e-02f, -8.78897533e-02f, -4.02277475e-03f,
  -8.28536898e-02f, -1.04544982e-01f, -7.94873480e-03f, 6.53135590e-03f, 3.26449089e-02f, -5.18495962e-02f, 2.43415665e-02f, 1.48942415e-03f, 8.26139189e-03f, -4.07007709e-02f,
  -1.12539917e-01f, -4.34431657e-02f, -7.41349882e-04f, -1.39670730e-01f, -2.46871039e-02f, -1.17394619e-01f, -5.56019023e-02f, -9.41620246e-02f, 5.84882312e-02f, 1.06732072e-02f,
  -7.09369220e-03f, -2.14498848e-01f, 5.96884824e-02f, 4.34765816e-02f, 6.79109022e-02f, 4.85922135e-02f, -1.09883463e-02f, 5.43867685e-02f, 4.23508659e-02f, 6.71903742e-03f,
  1.91049110e-02f, 1.85369737e-02f, 7.18773007e-02f, 3.24509777e-02f, -3.56349535e-02f, 6.88797906e-02f, 7.31365159e-02f, -2.16115545e-02f, -3.31044979e-02f, 6.84488118e-02f,
  8.49118233e-02f, 4.10279520e-02f, 1.25596121e-01f, -3.40311304e-02f, -2.84425798e-03f, 4.61869240e-02f, 4.73628379e-02f, 5.05554527e-02f, -6.80847242e-02f, 1.54746309e-01f,
  -1.87308967e-01f, -1.13934577e-01f, -2.27139175e-01f, 3.39271724e-02f, -5.35456128e-02f, -5.89337535e-02f, -5.47602288e-02f, 1.70925528e-01f, 1.47920862e-01f, -5.94731756e-02f,
  -1.90472044e-02f, 1.97417706e-01f, 1.41921073e-01f, 1.97006419e-01f, 1.27915308e-01f, -1.73505947e-01f, -9.07302275e-02f, -1.12959243e-01f, 3.91017050e-02f, 6.87771365e-02f,
  -1.65252958e-03f, -2.42943279e-02f, -3.31170857e-02f, -5.60946716e-03f, 2.14371979e-02f, -6.54831380e-02f, -1.22858174e-01f, -1.32077679e-01f, -8.39540288e-02f, -2.74677753e-01f,
  -3.74314249e-01f, -2.18593150e-01f, -2.30003484e-02f, 1.99059620e-02f, -1.32421836e-01f, 2.08526365e-02f, -5.98699041e-02f, -5.26866093e-02f, -5.02687767e-02f, -2.50572525e-02f,
  -4.10728417e-02f, -2.11247709e-02f, 5.87115325e-02f, -3.43688838e-02f, -6.92469254e-02f, 6.35360852e-02f, 6.34569824e-02f, 3.51448767e-02f, 3.59618813e-02f, -5.16577214e-02f,
  -3.20818014e-02f, -1.66241646e-01f, -1.66185439e-01f, -5.54944091e-02f, 1.86751205e-02f, 5.79366013e-02f, -1.51296675e-01f, -1.07836358e-01f, -1.06195271e-01f, -5.87829016e-02f,
  -3.02070007e-03f, -3.21683846e-02f, 3.43028046e-02f, -5.78237437e-02f, 9.94556546e-02f, 7.27854595e-02f, 4.58686650e-02f, -5.55568114e-02f, -2.99139488e-02f, -9.43023637e-02f,
  5.26881963e-02f, 3.53111066e-02f, 3.87994871e-02f, 5.03020920e-02f, 8.97735655e-02f, -4.20178939e-03f, 4.63904068e-02f, 1.32178023e-01f, 8.93014297e-02f, 7.83470497e-02f,
  -3.42249405e-03f, -1.89982112e-02f, -8.09173658e-02f, 4.89901528e-02f, 1.17710466e-02f, 5.99676892e-02f, 6.12075217e-02f, 3.57142985e-02f, 7.42446780e-02f, -2.60939651e-05f,
  6.45519421e-02f, 8.22552294e-02f, -1.18117280e-01f, -1.77553706e-02f, -1.19047262e-01f, 3.03912088e-02f, -6.03222474e-02f, -1.24982763e-02f, -6.98247552e-02f, -2.18065195e-02f,
  -3.67677361e-02f, -3.78909633e-02f, -4.76952866e-02f, 4.68689483e-03f, -4.95286398e-02f, -2.55893227e-02f, -1.11938871e-01f, -1.17416613e-01f, 3.30662690e-02f, -6.99066296e-02f,
  -2.41679195e-02f, -1.40794680e-01f, -6.52092695e-02f, -8.26813355e-02f, -8.16890597e-02f, -3.10732838e-04f, -1.16436407e-01f, -2.56415103e-02f, -1.46978684e-02f, -3.74274142e-02f,
  2.12938622e-01f, -1.02848271e-02f, 4.87444066e-02f, 9.27970111e-02f, 1.85646594e-01f, 1.58000931e-01f, 1.57512471e-01f, 2.32536018e-01f, 8.96734670e-02f, 7.13315904e-02f,
  -2.41516307e-02f, -1.03667066e-01f, -8.45198110e-02f, -1.30794376e-01f, -1.98310288e-03f, -8.69404227e-02f, -6.96977675e-02f, -5.13872132e-02f, 9.85317677e-02f, 4.49749194e-02f,
  -7.33667314e-02f, -1.48038696e-02f, -1.25593647e-01f, -1.95769712e-01f, -1.74272478e-01f, -9.83569473e-02f, -2.24494770e-01f, -1.91565990e-01f, -1.64072752e-01f, -3.27746868e-01f,
  -2.94582080e-03f, -1.51006505e-02f, -2.29153503e-02f, -1.48243681e-01f, -3.75935473e-02f, 1.12915579e-02f, -7.80666173e-02f, 3.57653424e-02f, -6.56657442e-02f, 2.72980724e-02f,
  1.99534986e-02f, -8.38918164e-02f, -7.45091811e-02f, 9.39592160e-03f, -3.42703462e-02f, -8.40025097e-02f, -1.27163632e-02f, -7.06291720e-02f, 2.61522294e-03f, 2.18066797e-02f,
  -8.39225724e-02f, -1.83520429e-02f, -2.11134553e-02f, 2.46694777e-02f, -6.12172158e-03f, 3.53740193e-02f, -8.09023380e-02f, -8.51885304e-02f, 2.41943374e-02f, -2.81406436e-02f,
  -7.06637055e-02f, 7.55180940e-02f, 1.16836585e-01f, 4.60098013e-02f, 7.43674114e-02f, 1.06510557e-01f, 1.74679421e-02f, 9.04494803e-03f, 8.34409222e-02f, 2.34263465e-02f,
  1.03121132e-01f, 4.58266623e-02f, 4.76879142e-02f, 8.10815841e-02f, -2.45310944e-02f, 6.79987818e-02f, 9.42821950e-02f, 9.04089138e-02f, -2.32149251e-02f, 1.12233289e-01f,
  1.58616886e-01f, 6.27716482e-02f, 8.75957310e-02f, 4.05943841e-02f, 7.61533231e-02f, 1.46390676e-01f, 1.11970097e-01f, 1.35328472e-01f, 6.82776496e-02f, 2.12973014e-01f,
  1.37025537e-02f, 2.94566713e-02f, -1.17803896e-02f, -1.16925240e-01f, -6.41980097e-02f, -1.05187461e-01f, -6.54061958e-02f, -7.52441809e-02f, 3.74868475e-02f, 6.73132576e-03f,
  -6.61927238e-02f, -5.08735627e-02f, -1.26038464e-02f, -8.42743739e-02f, -4.37203161e-02f, 3.86078022e-02f, -1.15123391e-01f, -5.35431467e-02f, -3.30395363e-02f, 4.85469736e-02f,
  9.16504487e-03f, 9.52745602e-02f, 1.47355020e-01f, 8.97391513e-02f, -6.66690543e-02f, 9.16645154e-02f, -5.69045879e-02f, -7.88958743e-02f, -2.87393332e-02f, 2.33735312e-02f,
  -1.21273123e-01f, 2.88150031e-02f, -3.40982378e-01f, -8.32028463e-02f, -2.04165906e-01f, -3.26893806e-01f, -1.55977562e-01f, -2.69905329e-02f, -4.48906347e-02f, -6.60972297e-02f,
  5.56949563e-02f, 4.50603962e-02f, 1.00975845e-03f, 9.51226279e-02f, -3.79739106e-02f, -2.90703122e-02f, -2.24409968e-01f, -2.66116917e-01f, -2.93473721e-01f, -6.42851442e-02f,
  -1.18519738e-01f, 7.44868675e-03f, -6.42117187e-02f, -1.24769963e-01f, 2.99629197e-02f, -1.24279179e-01f, -1.64810847e-02f, -5.75887039e-02f, -8.19671750e-02f, -5.28409295e-02f,
  8.21988098e-03f, -6.32495712e-03f, -1.39235452e-01f, -1.14632294e-01f, -2.09186628e-01f, -1.68429449e-01f, -9.92907658e-02f, -2.21286371e-01f, -1.35373622e-01f, -1.61812887e-01f,
  -3.90724503e-02f, -1.05560400e-01f, -1.51454777e-01f, -3.23826447e-02f, -8.60801339e-02f, -5.97266182e-02f, -9.26971585e-02f, -3.58590782e-02f, -1.29392967e-01f, -7.39193037e-02f,
  -5.77840321e-02f, -1.98308080e-01f, -2.86612839e-01f, -1.27976105e-01f, -4.03730199e-02f, -8.51303935e-02f, -5.93100034e-04f, -1.40406772e-01f, -1.05915561e-01f, -7.35380724e-02f,
  9.98638570e-02f, -1.74357295e-02f, 8.72250460e-03f, 8.04955289e-02f, 1.49884611e-01f, 1.51104927e-01f, 1.59916744e-01f, 1.27270848e-01f, 1.72509715e-01f, 1.34444207e-01f,
  7.74324015e-02f, 1.20280713e-01f, 6.37164563e-02f, 1.67266831e-01f, 7.31659681e-02f, 4.72493134e-02f, 7.49504194e-02f, 1.31036386e-01f, 1.48667231e-01f, 5.33664748e-02f,
  1.03346586e-01f, 5.45075014e-02f, 9.25101191e-02f, 4.40310277e-02f, 4.02035154e-02f, 1.31130898e-02f, 1.77043919e-02f, -4.57622483e-03f, 1.20296672e-01f, 1.67838201e-01f,
  1.42874166e-01f, -1.14393160e-02f, -4.34219018e-02f, 4.07048687e-03f, -1.66918248e-01f, -8.01011100e-02f, -1.19720340e-01f, -1.45706460e-01f, -9.71810147e-02f, -1.31495635e-03f,
  -6.14035651e-02f, 3.42701674e-02f, -4.26406926e-03f, -1.31501421e-01f, -1.40387282e-01f, -1.61385253e-01f, 1.96167529e-02f, -4.85540107e-02f, -1.63138583e-01f, -9.49468240e-02f,
  -6.60025375e-03f, -2.31363326e-01f, -2.41868228e-01f, -1.27957985e-01f, -1.41284168e-01f, -1.18759707e-01f, -1.67142704e-01f, -1.45955980e-01f, -2.34924465e-01f, -7.23745972e-02f,
  3.61519270e-02f, 3.01829316e-02f, 9.44898501e-02f, 1.60209566e-01f, -8.34530368e-02f, -1.09312743e-01f, -2.98616558e-01f, -1.31311074e-01f, 9.17326193e-03f, -1.85236577e-02f,
  -2.07782224e-01f, -1.70743018e-01f, -1.13322265e-01f, -1.75556123e-01f, -1.11751147e-01f, 7.70365447e-02f, 2.94555724e-01f, 1.71899140e-01f, -1.08061887e-01f, -1.74176216e-01f,
  -1.24074705e-02f, 1.86783180e-01f, 1.67519674e-01f, 1.32964954e-01f, 9.02520493e-02f, 1.17761130e-02f, 2.59933889e-01f, 2.94638891e-02f, 6.45171255e-02f, 1.82221532e-01f,
  -1.10184565e-01f, -6.85740337e-02f, 7.17042619e-03f, -7.15800226e-02f, -5.38847372e-02f, -4.37147096e-02f, -1.77118421e-01f, 1.83896665e-02f, -5.70733137e-02f, 3.49578783e-02f,
  -1.16908357e-01f, 1.28512094e-02f, -3.11125573e-02f, -5.88761196e-02f, -7.43741468e-02f, 3.19794193e-02f, -2.50050565e-03f, 6.12253994e-02f, -3.66378389e-02f, -8.72891024e-02f,
  -1.23887267e-02f, -1.91639680e-02f, 1.37236472e-02f, -3.64933871e-02f, -4.62354161e-02f, 8.59741215e-03f, 3.05636581e-02f, -6.06580451e-02f, 9.21867713e-02f, -2.99703814e-02f,
  -7.73717789e-03f, -4.05042730e-02f, 1.59055348e-02f, 2.45453673e-03f, 1.88680049e-02f, -5.32069728e-02f, -1.37087395e-02f, 1.25399828e-02f, -1.11442812e-01f, -3.09426012e-03f,
  -2.79207360e-02f, -9.56129134e-02f, 7.80972280e-03f, -3.24381925e-02f, -6.44728020e-02f, 6.73934221e-02f, 3.82050965e-03f, -9.47431603e-04f, -3.84579338e-02f, 6.28459081e-02f,
  -7.49908313e-02f, -7.52250254e-02f, -6.85812458e-02f, -5.07236309e-02f, 4.42887582e-02f, 8.51964504e-02f, -7.27912113e-02f, -7.62028247e-02f, -2.74263248e-02f, 1.07806232e-02f,
  -1.44147836e-02f, 7.90647119e-02f, 4.07815911e-02f, -1.53091336e-02f, 3.37265655e-02f, 5.19065037e-02f, 3.44943106e-02f, -1.78248319e-03f, -1.92411821e-02f, 1.21816564e-02f,
  -8.99954364e-02f, -1.39767274e-01f, 3.90157253e-02f, -7.73607120e-02f, -6.16672449e-02f, -4.67064455e-02f, 4.67263050e-02f, 2.56852992e-02f, 3.41323540e-02f, 3.88158225e-02f,
  8.35041851e-02f, 2.48392373e-02f, 8.13780725e-02f, 6.27004728e-02f, 5.62718557e-03f, 7.06318840e-02f, 8.28762352e-02f, -4.45262976e-02f, 3.41327563e-02f, -3.76346596e-02f,
  2.21678972e-01f, 1.49348248e-02f, -9.74024087e-02f, -8.67352113e-02f, 2.69027978e-01f, 1.65950149e-01f, 1.51861116e-01f, 6.94211721e-02f, -2.32077073e-02f, -6.06498756e-02f,
  1.00696132e-01f, 2.79576685e-02f, -5.69728166e-02f, 4.24027853e-02f, 1.07378557e-01f, -1.71081290e-01f, -1.22573189e-01f, 9.00093317e-02f, 1.30942419e-01f, 3.42820972e-01f,
  1.91956654e-01f, 1.30889028e-01f, 1.37214661e-01f, 8.14433321e-02f, -5.10461181e-02f, -4.37166430e-02f, -1.44292369e-01f, 4.32586744e-02f, 2.04041883e-01f, -1.99997634e-01f,
  -5.63936383e-02f, 2.74132282e-01f, 6.03514686e-02f, 2.45561320e-02f, 1.23299234e-01f, -4.85710390e-02f, 4.75282110e-02f, -7.52227604e-02f, 6.50294796e-02f, -3.23503017e-02f,
  1.17441177e-01f, 3.84161472e-02f, 1.21302426e-01f, 1.35350376e-01f, 4.33703773e-02f, 1.49907559e-01f, 9.77973193e-02f, 6.77688047e-02f, 8.35740492e-02f, 2.17316821e-02f,
  9.62422118e-02f, 1.68153018e-01f, 2.14631572e-01f, 4.89653982e-02f, 1.22043788e-01f, 1.62892997e-01f, 1.59905255e-01f, 7.96771571e-02f, 1.36335224e-01f, -1.05529539e-01f,
  1.03351120e-02f, -1.11457966e-01f, -4.37919460e-02f, -1.17447257e-01f, -1.41800836e-01f, -1.05876252e-01f, -7.25695714e-02f, -8.23346153e-02f, 3.74532603e-02f, -6.98882639e-02f,
  -6.59013465e-02f, -1.64002895e-01f, -7.06780106e-02f, -2.05995977e-01f, -1.15265012e-01f, -9.12894830e-02f, -3.05407736e-02f, -8.68570060e-02f, -4.70667332e-02f, -1.35857731e-01f,
  -7.70743117e-02f, 5.53051103e-03f, -1.39104933e-01f, -5.73367961e-02f, -3.62678580e-02f, -4.88028452e-02f, -1.37016296e-01f, -5.89544736e-02f, -6.59517273e-02f, 4.83584357e-03f,
  -2.10113823e-01f, 1.90088362e-01f, -6.13181293e-02f, 6.39817938e-02f, 5.79469129e-02f, 6.70300350e-02f, 1.13948442e-01f, -3.89256738e-02f, 1.65843032e-03f, 5.33395819e-02f,
  1.56769067e-01f, 3.05673145e-02f, 6.07917719e-02f, 1.53611749e-02f, 2.18045637e-02f, -1.37581327e-03f, 5.54963201e-02f, 3.56916748e-02f, -1.81301255e-02f, 1.72285773e-02f,
  -4.81345318e-03f, 2.33246032e-02f, -1.51545247e-02f, -9.84085873e-02f, 4.65491042e-02f, -2.84210294e-02f, -4.52805497e-02f, 7.93136470e-03f, 3.84842455e-02f, -1.90508038e-01f,
  -9.27956123e-03f, 2.36788347e-01f, 1.98336586e-01f, -6.81509525e-02f, -2.11836904e-01f, -2.18011677e-01f, -2.24835068e-01f, -1.54270545e-01f, -2.30491776e-02f, -9.03467275e-03f,
  7.61818513e-02f, 8.14112928e-03f, 5.21355271e-02f, -8.51682797e-02f, -4.17703316e-02f, -3.98347899e-02f, -1.63236722e-01f, -6.34777322e-02f, -1.00801520e-01f, -1.62669703e-01f,
  -1.35395333e-01f, -9.19250548e-02f, -3.28609943e-02f, 1.90228783e-02f, -1.80471875e-02f, -4.28981595e-02f, 8.96334648e-02f, 4.44608405e-02f, 5.17165214e-02f, 1.76318884e-02f,
  1.11246549e-01f, 2.35293403e-01f, -1.08865410e-01f, -1.08553730e-01f, 1.49618238e-01f, 2.85015963e-02f, -2.10484926e-04f, -3.20474878e-02f, -7.41045922e-02f, -7.25715309e-02f,
  -1.60498340e-02f, -1.12195492e-01f, -4.84342761e-02f, -9.05376822e-02f, -7.33283237e-02f, -3.26783806e-02f, 2.68069981e-03f, 1.17998673e-02f, 5.79190366e-02f, 2.94893272e-02f,
  -5.09998947e-03f, -7.52075762e-02f, 1.78318527e-02f, -6.68077394e-02f, 1.10916398e-01f, 2.30979566e-02f, 5.04679158e-02f, 4.14095558e-02f, 4.93325628e-02f, 2.66437475e-02f,
  -2.27355473e-02f, 7.48482198e-02f, -4.88920556e-03f, -1.84829291e-02f, -1.13137159e-02f, 4.24255952e-02f, 3.43439309e-03f, 5.12603857e-02f, -4.84621944e-03f, 3.48289590e-03f,
  5.70540465e-02f, -1.10681318e-02f, 7.82505944e-02f, 4.61633466e-02f, -2.57514268e-02f, 1.19533233e-01f, -4.80009951e-02f, 3.22554782e-02f, 7.19766915e-02f, 3.00989896e-02f,
  3.39330621e-02f, -2.99112089e-02f, 4.28344123e-02f, 1.55141875e-02f, -4.41301055e-03f, -2.52572596e-02f, -2.54407730e-02f, 4.68759798e-02f, 3.60330753e-02f, 8.08117762e-02f,
  1.50901511e-01f, -5.10194525e-02f, -4.54784557e-02f, -5.99721558e-02f, -2.49049366e-02f, -3.14766541e-02f, -8.40626657e-02f, 6.00096118e-03f, -8.15383941e-02f, 1.10988226e-03f,
  -5.36445878e-05f, -2.93230154e-02f, -3.58291231e-02f, -6.27361163e-02f, -1.16438434e-01f, -1.57864153e-01f, -1.85078025e-01f, -1.52788132e-01f, -1.58042952e-01f, -8.39655250e-02f,
  -1.27942473e-01f, -1.45229161e-01f, -2.15778708e-01f, -1.26627848e-01f, -4.39749025e-02f, -1.53510392e-01f, -1.16659969e-01f, -2.02444685e-03f, -6.92270100e-02f, -1.72615144e-02f,
  1.59183554e-02f, 3.21952701e-01f, -1.51647151e-01f, 1.59800276e-01f, 2.00013608e-01f, 1.36401564e-01f, 1.60720631e-01f, 6.10263199e-02f, -3.79765294e-02f, 1.31441116e-01f,
  -6.11849092e-02f, -1.37060195e-01f, -2.92963147e-01f, -2.61748731e-01f, -2.97424644e-01f, -6.50878772e-02f, -2.02557519e-01f, -3.86676729e-01f, -3.06149125e-01f, -9.97451618e-02f,
  8.71223807e-02f, 5.25701605e-02f, -7.77320638e-02f, -3.90240364e-02f, 8.76506977e-03f, -2.25989193e-01f, 4.16649804e-02f, 4.38630022e-02f, -1.24017723e-01f, -8.25436562e-02f,
  -6.05904162e-02f, 2.09466964e-01f, -1.69554770e-01f, -1.04341626e-01f, 6.50819167e-02f, -1.04646809e-01f, 5.01460619e-02f, 4.60476726e-02f, 3.53102870e-02f, -9.88476276e-02f,
  2.69742142e-02f, -1.76848304e-02f, -7.58324265e-02f, 2.08053999e-02f, 6.06514812e-02f, 1.20484335e-02f, -2.73689274e-02f, -7.97795653e-02f, -6.07683323e-02f, 2.08475534e-03f,
  1.17833056e-01f, 1.87130403e-02f, -1.07463248e-01f, 5.21741575e-03f, -8.48457143e-02f, -9.86844376e-02f, -8.26138705e-02f, -6.11268915e-02f, -7.65634328e-02f, -1.82731748e-02f,
  6.36336878e-02f, 2.57518585e-03f, 2.59040911e-02f, -5.69842476e-03f, 8.11079890e-02f, 1.24734063e-02f, 3.24384309e-02f, -5.70991971e-02f, 4.74955924e-02f, 2.01281477e-02f,
  -2.35874299e-02f, 2.79395916e-02f, -7.54234754e-03f, 4.56934050e-02f, -5.49723543e-02f, -2.80005159e-03f, -3.81040829e-03f, -7.60930777e-02f, 5.87281398e-02f, 3.14773284e-02f,
  -1.35968206e-02f, -2.54939329e-02f, 4.57636267e-02f, -6.78087696e-02f, -3.32455127e-03f, -5.06816469e-02f, -9.28661227e-02f, -2.30693165e-02f, -6.57129139e-02f, -3.84801514e-02f,
  -4.37161587e-02f, -4.46033143e-02f, -7.38016935e-03f, -4.69304547e-02f, -5.44478046e-03f, 2.62546912e-02f, 6.36422336e-02f, 1.82773415e-02f, -3.65321897e-02f, 8.53313059e-02f,
  -7.35425949e-02f, 3.78261767e-02f, -4.32542944e-03f, 2.93640960e-02f, -7.44309695e-03f, 3.87701392e-02f, 3.74781415e-02f, 2.41936725e-02f, -1.43957762e-02f, 7.99943730e-02f,
  6.29969835e-02f, 3.92648019e-02f, -1.27055138e-01f, 4.48607095e-02f, 2.05546599e-02f, -1.53479591e-01f, -3.58416066e-02f, -9.23143029e-02f, -1.72509298e-01f, -6.75600767e-02f,
  -2.78547227e-01f, 5.79900742e-02f, -2.12839887e-01f, -1.65705979e-01f, -4.52140495e-02f, 1.08955681e-01f, 1.62904382e-01f, 4.65064608e-02f, -3.73569615e-02f, 3.65617163e-02f,
  5.05145416e-02f, -1.92452118e-01f, -5.76961860e-02f, 1.05612595e-02f, -2.27859225e-02f, 3.44393216e-02f, -6.99289236e-03f, -2.04316512e-01f, -1.59712121e-01f, -1.37894601e-01f,
  -1.01397008e-01f, -1.13004193e-01f, -1.92244992e-01f, -1.13259377e-02f, -6.44122735e-02f, -1.15490519e-01f, 3.72755490e-02f, -1.04348160e-01f, -3.33823226e-02f, -8.80588815e-02f,
  -2.34307766e-01f, -8.39743167e-02f, 9.48681775e-03f, 3.71751823e-02f, -8.13762173e-02f, 8.93229544e-02f, 1.81209296e-02f, -9.65457410e-03f, -4.39589880e-02f, -4.86993380e-02f,
  -1.89572647e-02f, 1.05382567e-02f, -7.34144971e-02f, -1.02749117e-01f, -2.81468015e-02f, -9.51191224e-03f, -5.41570894e-02f, -1.65835340e-02f, 6.24755509e-02f, -2.06805579e-02f,
  2.11703163e-02f, -1.30597770e-01f, -6.96912110e-02f, -3.68816331e-02f, -6.04044013e-02f, 2.21563992e-03f, 5.76419085e-02f, -9.43262726e-02f, 5.45283407e-02f, -1.40268905e-02f,
  -3.70431803e-02f, -4.50336300e-02f, 4.28081639e-02f, -2.04469599e-02f, -2.74849348e-02f, 1.23198785e-01f, 7.05542639e-02f, -4.03888673e-02f, -7.56293759e-02f, 6.88450336e-02f,
  8.31546821e-03f, 3.12509090e-02f, -2.44573206e-02f, 5.68137914e-02f, -2.92940736e-02f, -4.24216911e-02f, 2.91749444e-02f, 5.08836992e-02f, -4.83298227e-02f, 2.11054590e-02f,
  4.94553410e-02f, 2.33523678e-02f, -9.45829004e-02f, 7.79183656e-02f, 9.68935061e-03f, -1.67821869e-02f, -1.41014475e-02f, -2.38917302e-02f, -4.30606939e-02f, 7.03399107e-02f,
  -2.01224089e-01f, 1.92632768e-02f, -3.52449575e-03f, 3.64361741e-02f, -8.53728801e-02f, -2.35723872e-02f, -1.01738684e-01f, -8.51699524e-03f, -3.53329740e-02f, -1.61156822e-02f,
  -6.14416599e-02f, -4.34264019e-02f, -1.41209513e-01f, -4.90115024e-02f, -1.25386193e-01f, -1.13038070e-01f, 9.94134843e-02f, -1.26628608e-01f, -4.58305143e-02f, -1.84170119e-02f,
  9.45514441e-02f, 3.88862751e-02f, -2.21864581e-02f, 6.87389076e-02f, 2.73154452e-02f, -7.42856711e-02f, -4.61129919e-02f, 1.11766383e-02f, 8.64855349e-02f, 1.03823431e-01f,
  -4.29249071e-02f, -1.81375429e-01f, 3.53885032e-02f, -3.66826802e-02f, -9.11139399e-02f, 8.18612203e-02f, 2.36812294e-01f, 2.16980219e-01f, 5.10520078e-02f, -1.49756819e-01f,
  -2.79337555e-01f, -1.48717940e-01f, -1.00170672e-01f, 3.52368429e-02f, 2.63956398e-01f, 1.42241508e-01f, 2.72968382e-01f, 2.87556738e-01f, 2.42104694e-01f, 5.28014079e-02f,
  -6.56491742e-02f, 7.27551384e-03f, 5.47295494e-04f, 5.70869260e-02f, -7.05518574e-02f, -1.24631017e-01f, -7.62563273e-02f, -8.53231326e-02f, 7.24748196e-03f, -1.93239991e-02f,
  -3.11539352e-01f, -1.48423746e-01f, 6.32636845e-02f, -1.56372681e-01f, -2.19896242e-01f, -2.25775037e-02f, 1.54366316e-02f, -2.57105045e-02f, -2.08727848e-02f, 2.69850567e-02f,
  -1.05237037e-01f, -1.08157359e-01f, -6.97192177e-02f, -1.11448638e-01f, -1.61406621e-01f, 1.38606522e-02f, 1.72225740e-02f, 3.16170678e-02f, 3.59321274e-02f, -1.47696972e-01f,
  -1.61458135e-01f, -1.07471079e-01f, -1.40476465e-01f, 7.23597109e-02f, -5.78002520e-02f, -7.29663149e-02f, -8.91897921e-03f, -9.28560346e-02f, 1.11826155e-02f, -5.42798964e-03f,
  8.91910642e-02f, 5.25750220e-02f, 6.74905330e-02f, 2.24569980e-02f, 4.54134606e-02f, 2.96708336e-03f, 7.34249949e-02f, 2.62954831e-02f, 2.64650807e-02f, 4.29289080e-02f,
  -2.52274144e-03f, 1.26989424e-01f, 6.34220019e-02f, 1.45639479e-01f, 2.38034986e-02f, 9.44849476e-02f, 6.86125457e-02f, 7.09481444e-03f, 3.59574072e-02f, 3.77944894e-02f,
  5.59535250e-02f, 8.07442218e-02f, 3.91228348e-02f, 1.31018996e-01f, 5.09880669e-02f, 9.80407521e-02f, 4.18192297e-02f, -4.52127121e-02f, -2.96398792e-02f, 2.77345702e-02f,
  -1.87489703e-01f, 6.68620169e-02f, -7.42813721e-02f, -2.64532454e-02f, -1.51031896e-01f, -2.59747542e-02f, -1.73271284e-01f, -8.64149705e-02f, -1.56286046e-01f, -3.68898138e-02f,
  -1.24096274e-01f, 3.19382399e-02f, -6.07298687e-02f, -9.12167281e-02f, 2.26962157e-02f, -8.37160498e-02f, -1.01151370e-01f, -7.57197142e-02f, -2.10415237e-02f, -4.65897843e-02f,
  7.64991017e-03f, 5.13774194e-02f, 5.71933901e-03f, 3.43383104e-03f, -2.01148838e-02f, 5.93661033e-02f, -2.79683769e-02f, -5.50459996e-02f, 8.17699879e-02f, 2.72872014e-04f,
  1.16675735e-01f, 3.25632960e-01f, 3.06001604e-01f, -1.44187093e-01f, 1.81934252e-01f, 2.25438669e-01f, 1.69883698e-01f, 7.77478889e-02f, -2.44752243e-02f, 1.94897085e-01f,
  2.10587591e-01f, -1.20356590e-01f, -1.27249032e-01f, -1.07272506e-01f, -5.26509620e-02f, 3.39507833e-02f, 2.96795517e-02f, -1.92074087e-02f, -8.68686140e-02f, 8.97626057e-02f,
  -8.72647911e-02f, 2.61858609e-02f, -4.01553586e-02f, -4.88379598e-03f, 6.13854863e-02f, -1.12493848e-02f, 1.86853588e-01f, 1.24814518e-01f, 7.92606398e-02f, 1.48176169e-03f,
  2.60794461e-01f, 3.11236113e-01f, 4.51240204e-02f, 3.17351557e-02f, 1.50427252e-01f, 1.73221946e-01f, 1.60958096e-01f, 1.62737146e-01f, 1.44295290e-01f, 1.54671147e-01f,
  2.43499294e-01f, 3.21613997e-02f, 6.31283820e-02f, 1.81479231e-01f, 1.82987720e-01f, 9.07866061e-02f, 1.56592384e-01f, 4.79758866e-02f, 1.23860799e-01f, 2.73522228e-01f,
  1.58116490e-01f, 2.14780048e-01f, 2.34591886e-01f, 1.24701843e-01f, 1.05666243e-01f, 1.21441312e-01f, 3.29871297e-01f, 1.82407841e-01f, 1.80440977e-01f, 2.87704945e-01f,
  -9.66480970e-02f, 1.86611747e-03f, -7.81124011e-02f, -4.83222641e-02f, -1.03248678e-01f, -4.72263284e-02f, -8.39892849e-02f, -8.17774795e-03f, -1.26524329e-01f, -3.52595560e-02f,
  -4.94036786e-02f, -8.84464290e-03f, -1.25163179e-02f, -7.30749518e-02f, -1.15233511e-01f, -6.38258085e-02f, -1.01224668e-01f, 6.32275408e-03f, -8.59716609e-02f, -4.07333188e-02f,
  -9.58090127e-02f, -6.16468415e-02f, 3.15651670e-02f, -1.32834330e-01f, -6.93516806e-02f, -5.36940657e-02f, -5.79661801e-02f, 2.14928128e-02f, -5.07902727e-02f, -9.88537222e-02f,
  2.64815241e-02f, 8.51227939e-02f, 1.83317170e-01f, 1.66577458e-01f, 1.58898383e-01f, 1.32827163e-01f, 1.79038748e-01f, 1.74603671e-01f, 1.63177177e-01f, 2.22061083e-01f,
  1.91124171e-01f, 1.93014622e-01f, 1.27467081e-01f, 1.28748491e-01f, 1.11359373e-01f, 1.71762362e-01f, 2.17505351e-01f, 1.11492835e-01f, 1.18084490e-01f, 2.16372922e-01f,
  2.30821013e-01f, 1.20236054e-01f, 1.47597238e-01f, 2.65904516e-01f, 1.60241380e-01f, 1.43429339e-01f, 2.82311499e-01f, 2.07270473e-01f, 2.01876760e-01f, 1.95575953e-01f,
  1.21197455e-01f, -1.04076579e-01f, 3.09666783e-01f, -5.41346408e-02f, -2.21958578e-01f, -9.52739790e-02f, -2.01794147e-01f, -4.79034632e-02f, 3.31469551e-02f, 5.20320274e-02f,
  -1.32962137e-01f, -6.62535280e-02f, 1.82943523e-01f, 3.09758913e-02f, 1.67862430e-01f, 8.83114859e-02f, 1.46366090e-01f, 3.01959306e-01f, 2.31513172e-01f, -5.32737412e-02f,
  -2.08482906e-01f, -5.45729697e-02f, 4.23665680e-02f, 5.96867315e-03f, -1.06494986e-01f, 1.18319266e-01f, -9.68894549e-03f, 1.22069996e-02f, -5.36465086e-02f, 1.72575995e-01f,
  1.61813349e-01f, -1.09977923e-01f, -1.94901228e-02f, -2.11379439e-01f, -1.68266103e-01f, -5.09942658e-02f, -3.84331606e-02f, -7.80626088e-02f, -1.68984473e-01f, -1.05820887e-01f,
  -4.74875718e-02f, -1.13525398e-01f, -1.59277037e-01f, -1.36295959e-01f, -8.10047388e-02f, -8.59266222e-02f, -9.87000167e-02f, 7.08489940e-02f, 4.94704582e-02f, -2.18943227e-02f,
  -2.00967371e-01f, -2.08529338e-01f, -5.60381897e-02f, -6.00853823e-02f, 5.73947467e-03f, 8.32693744e-03f, -6.73927143e-02f, -8.16612393e-02f, 4.99675050e-02f, 5.34126014e-02f,
  1.44347414e-01f, 2.54353303e-02f, 1.41125426e-01f, 2.37500109e-02f, 1.02765620e-01f, 6.70415536e-02f, 3.96747105e-02f, -2.09366865e-02f, 1.83509309e-02f, 4.28799056e-02f,
  1.09436028e-01f, 6.05406426e-02f, -1.31980702e-03f, -1.36182494e-02f, 4.52065095e-02f, 4.95909490e-02f, 1.03882439e-01f, -1.28779365e-02f, 6.99309483e-02f, 4.03160825e-02f,
  5.96635826e-02f, 1.30637754e-02f, 8.63032788e-02f, 9.51334089e-03f, 2.69112419e-02f, 7.64018297e-02f, 8.81238356e-02f, 1.10815009e-02f, 5.53396083e-02f, -5.04236035e-02f,
  4.90171090e-02f, -3.64553705e-02f, -3.92040722e-02f, 3.08315363e-02f, -2.80091353e-02f, -1.29334778e-01f, -1.13290027e-01f, -8.95789936e-02f, -5.30243888e-02f, -5.46980724e-02f,
  -9.94311124e-02f, 2.63485219e-02f, -1.12237327e-01f, -9.72650759e-03f, -1.17221631e-01f, -1.22203551e-01f, -4.42677513e-02f, -1.01370744e-01f, -3.92713444e-03f, -1.19900338e-01f,
  -7.55669847e-02f, 2.74644028e-02f, -2.90029440e-02f, 3.92799079e-02f, -1.09429806e-01f, 3.52164172e-03f, -2.01780125e-02f, 3.35614779e-03f, -1.76730249e-02f, 5.54962344e-02f,
  -2.09506929e-01f, -3.03392142e-01f, 3.00028443e-01f, -1.49043789e-03f, 2.59270132e-01f, 8.74435827e-02f, -9.31724682e-02f, -1.34861141e-01f, 6.84492365e-02f, -1.57684445e-01f,
  -9.98854041e-02f, -6.76863790e-02f, -1.97243709e-02f, -6.58447444e-02f, -1.74288079e-01f, -5.40728383e-02f, -2.32677348e-02f, 1.66314632e-01f, 2.43853629e-01f, 1.11397289e-01f,
  2.43236125e-02f, -3.80192436e-02f, 1.13033742e-01f, 1.49628250e-02f, 6.07743114e-02f, 1.26643106e-01f, 1.93739027e-01f, 1.40684888e-01f, -3.99435684e-02f, 9.38906595e-02f,
  2.62182802e-01f, -5.68327270e-02f, 1.33357748e-01f, 6.16374575e-02f, 1.50404766e-01f, 2.37036869e-02f, -2.09244154e-02f, 1.75725386e-01f, -5.02003022e-02f, 1.41183159e-03f,
  1.19445212e-01f, -5.79370186e-02f, 8.35758969e-02f, 3.21467407e-02f, -4.62915264e-02f, -1.74388438e-02f, 4.03671106e-03f, 6.65508881e-02f, -3.05876113e-03f, -6.89167231e-02f,
  4.15555649e-02f, 1.22189857e-01f, 1.08557932e-01f, 4.71395180e-02f, 2.94839777e-02f, 7.22498447e-02f, 1.09408326e-01f, 1.14553971e-02f, 1.03035182e-01f, -7.36570135e-02f,
  5.23296930e-02f, 2.11137608e-02f, 8.43797699e-02f, 1.57400072e-02f, -1.05259813e-01f, -5.25890626e-02f, 6.10462166e-02f, 3.96534987e-02f, 3.69659550e-02f, -7.79240653e-02f,
  -6.33874983e-02f, 4.56694029e-02f, 2.26131249e-02f, -1.45360315e-02f, 2.54004057e-02f, 5.95426634e-02f, 8.50727335e-02f, -2.83480082e-02f, 2.41346322e-02f, 5.18746339e-02f,
  -4.53827195e-02f, 9.67994407e-02f, -2.19551772e-02f, 8.75891093e-03f, -1.49571849e-02f, -3.29752080e-02f, 3.66525501e-02f, -5.88452592e-02f, -2.33272510e-03f, 3.94245647e-02f,
  5.26776575e-02f, 5.47850765e-02f, -9.02260914e-02f, -1.07186772e-01f, -2.68043280e-02f, 6.88221753e-02f, 1.66562684e-02f, -2.02521030e-02f, 9.66153815e-02f, -5.87000921e-02f,
  4.39564921e-02f, -2.96458323e-02f, -8.76389593e-02f, 1.58853084e-02f, 8.52064416e-02f, 7.00610429e-02f, -1.33666158e-01f, 7.43295029e-02f, 8.75149742e-02f, 4.81189340e-02f,
  -6.05707020e-02f, 3.65855508e-02f, 3.90342139e-02f, 3.50124463e-02f, 8.71530622e-02f, -5.29388525e-02f, -4.45604883e-02f, 1.37320518e-01f, 4.54725660e-02f, -1.22746885e-01f,
  1.30899996e-01f, 7.53642693e-02f, 5.45639060e-02f, 2.11788431e-01f, 1.65867895e-01f, 7.78135285e-02f, 1.08025268e-01f, 1.36905491e-01f, 1.17659606e-01f, 9.13866609e-02f,
  -1.75825000e-01f, -1.52116567e-02f, -4.88272496e-02f, -5.97400814e-02f, -1.39986202e-01f, 1.40346125e-01f, 1.78918272e-01f, 6.67014867e-02f, -1.32570812e-03f, 7.56155625e-02f,
  1.88494056e-01f, 1.53335601e-01f, 7.84455761e-02f, 4.95568626e-02f, 2.15062514e-01f, -5.46083227e-02f, 1.53785884e-01f, 1.08084425e-01f, -5.69763705e-02f, 2.91466378e-02f,
  -1.01314299e-01f, -2.36014247e-01f, 1.58408619e-02f, -1.15481578e-01f, -2.00233087e-02f, -1.90000944e-02f, -1.06836244e-01f, -6.53658360e-02f, -7.96857700e-02f, 1.09475002e-01f,
  2.96876896e-02f, -1.26413226e-01f, -6.07709438e-02f, -5.65944649e-02f, -7.09676137e-03f, -1.01554967e-01f, -5.75964376e-02f, -2.48170551e-02f, 1.98052507e-02f, -1.01487562e-01f,
  -2.84053516e-02f, 4.32089418e-02f, -6.11381233e-02f, 4.24961299e-02f, -8.84178355e-02f, -3.78896371e-02f, -5.34459241e-02f, -1.19615398e-01f, -9.07557234e-02f, 1.48735464e-01f,
  -7.04834387e-02f, 1.39579922e-01f, 2.25544926e-02f, 1.28119625e-02f, 5.20460531e-02f, 4.96949535e-03f, 5.01054898e-02f, 1.61487401e-01f, 7.31936246e-02f, 1.35587886e-01f,
  1.25128066e-03f, -3.36681791e-02f, 6.14549890e-02f, 9.47089940e-02f, -2.16082786e-03f, 9.13746133e-02f, -1.52110383e-02f, 3.09683997e-02f, -3.50070633e-02f, 4.51533161e-02f,
  -3.00556216e-02f, 6.40607476e-02f, 1.14039004e-01f, 1.47819212e-02f, -2.76309922e-02f, -5.63078076e-02f, 5.77072315e-02f, -2.80946661e-02f, 1.13595568e-01f, 3.28539275e-02f,
  1.89938128e-01f, -3.33566815e-01f, 9.32719484e-02f, 3.96876456e-03f, 1.70980804e-02f, -2.85121594e-02f, 6.70040473e-02f, 4.66335739e-04f, -2.63950955e-02f, -6.92270249e-02f,
  2.97351852e-02f, 4.26668078e-02f, 1.02447346e-01f, -8.63517076e-03f, -2.05687117e-02f, -3.97506123e-03f, 7.65640736e-02f, -2.25056638e-03f, -6.11615293e-02f, -2.04534382e-02f,
  3.22243683e-02f, 1.37294561e-01f, 1.19227953e-01f, 1.14043400e-01f, 7.06666559e-02f, 3.16896103e-02f, 1.09840095e-01f, 1.12959102e-01f, 8.14067125e-02f, 2.71164626e-01f,
  -3.65645200e-01f, -7.31465444e-02f, -2.22003222e-01f, -4.14501950e-02f, -4.45542770e-04f, 1.24063611e-01f, 1.97350234e-02f, 2.14088827e-01f, 1.56834960e-01f, -2.61687059e-02f,
  1.13974726e-02f, -7.11338967e-03f, -4.33333702e-02f, -5.16599938e-02f, -2.03826651e-02f, -3.96475941e-02f, -4.40539559e-03f, -9.85943154e-02f, 2.34636087e-02f, 1.87175274e-01f,
  1.21680968e-01f, 2.08547059e-02f, 8.30280036e-02f, 5.83284423e-02f, 2.41291821e-02f, -2.62835417e-02f, 4.72688824e-02f, 2.82331724e-02f, 2.47337557e-02f, -1.37225213e-03f,
  -2.45416552e-01f, -1.23291217e-01f, -1.73950866e-02f, 1.75776463e-02f, 2.06083450e-02f, 6.72379322e-03f, -3.50059941e-02f, 4.28155661e-02f, 6.18169010e-02f, 4.69804369e-02f,
  2.14416552e-02f, 1.85814146e-02f, 3.40486504e-02f, -3.93991359e-02f, 5.66489948e-03f, 5.69613315e-02f, 1.23845093e-01f, -2.33865203e-03f, 2.74855457e-02f, 1.01912454e-01f,
  1.84526108e-02f, -7.06305280e-02f, -9.46708545e-02f, 9.64791328e-02f, -4.44179541e-03f, -9.10880491e-02f, 4.15319093e-02f, 6.58864677e-02f, 2.54055765e-02f, 2.84017976e-02f,
  1.14253663e-01f, -8.87578800e-02f, 4.83124442e-02f, 1.12584736e-02f, -1.88027155e-02f, -1.05785318e-01f, -5.19590266e-02f, -6.88974112e-02f, -3.79485004e-02f, -6.49827868e-02f,
  -5.89045212e-02f, -4.09104712e-02f, -4.69985791e-02f, -9.68262553e-02f, -6.20464459e-02f, -1.06822401e-02f, -8.47126991e-02f, 4.62685823e-02f, -4.09733988e-02f, 6.64522685e-03f,
  -1.08395830e-01f, -3.04630268e-02f, -1.07203297e-01f, -2.41956506e-02f, -9.18219388e-02f, -1.72125921e-02f, -4.15282212e-02f, 8.84725992e-03f, 1.70307886e-02f, -1.21624641e-01f,
  -4.25140969e-02f, 6.14620857e-02f, 3.00597586e-03f, -1.30762458e-02f, -2.36144215e-02f, 1.01058416e-01f, -6.09443076e-02f, 1.97809171e-02f, -8.02238137e-02f, -4.56280150e-02f,
  -4.16002842e-03f, 4.95781898e-02f, -9.08525065e-02f, 1.06347255e-01f, 5.15816920e-02f, -6.51336415e-03f, 8.73052329e-02f, 1.98557135e-02f, -3.79057527e-02f, 1.29105806e-01f,
  1.27163112e-01f, 2.63415016e-02f, -1.28274575e-01f, -3.33182402e-02f, -1.03037292e-02f, -3.71195935e-02f, -6.53603226e-02f, 2.81870998e-02f, -7.56751597e-02f, 1.62308902e-01f,
  -2.57753670e-01f, 3.24945867e-01f, -8.66688862e-02f, -8.11010003e-02f, 3.05440109e-02f, 2.02252343e-01f, 2.91808516e-01f, 1.42049834e-01f, -1.40914824e-02f, 2.68794578e-02f,
  -1.23728350e-01f, -1.07297294e-01f, -7.96659216e-02f, 2.43437625e-02f, -1.42430002e-02f, 2.72374302e-01f, 2.26021022e-01f, -1.12056173e-01f, -1.25866190e-01f, 1.28238738e-01f,
  7.32245296e-02f, 9.35633183e-02f, 3.02806478e-02f, 3.35620940e-02f, 1.74577147e-01f, -6.66972920e-02f, 1.55797020e-01f, 5.34482896e-02f, 1.10373028e-01f, 1.98515862e-01f,
  -1.26094580e-01f, 8.78461599e-02f, 2.94388123e-02f, -9.17509049e-02f, -3.43597196e-02f, 1.43474489e-02f, -1.98674481e-03f, -2.38228682e-02f, 5.99987479e-03f, 1.82723388e-01f,
  -6.13680929e-02f, -4.45000269e-02f, 9.29970592e-02f, 8.78464133e-02f, 1.65496886e-01f, 1.36490926e-01f, 6.98557198e-02f, 1.17187597e-01f, 2.04352848e-02f, 6.36909977e-02f,
  1.53814822e-01f, 5.37944585e-02f, 9.54141021e-02f, 7.56137669e-02f, 4.30248082e-02f, -5.28676547e-02f, 1.37371093e-01f, 1.09898299e-01f, 7.62780309e-02f, 2.88725078e-01f,
  -3.57237994e-03f, -1.49367377e-01f, -1.62576288e-01f, -6.52450845e-02f, -3.64697352e-02f, -7.43704364e-02f, -1.30358577e-01f, -7.30387494e-02f, -1.12523720e-01f, -3.91378812e-02f,
  -1.27040416e-01f, -1.01965003e-01f, -1.26648307e-01f, -8.80384892e-02f, -6.19768873e-02f, -8.62228274e-02f, -2.07963809e-02f, -4.36358945e-03f, -8.22413340e-02f, -1.48716837e-01f,
  -7.98630118e-02f, -3.83762009e-02f, -1.86611146e-01f, -7.53789768e-02f, -3.25363502e-02f, -1.08316042e-01f, -8.84777531e-02f, -6.81949109e-02f, -1.36562273e-01f, -1.19389310e-01f,
  6.89960718e-02f, -1.07178852e-01f, 5.09665646e-02f, 5.36921360e-02f, 4.80114259e-02f, -3.34659405e-02f, 2.43878318e-03f, 7.67746717e-02f, -1.34579837e-02f, 7.70160407e-02f,
  -1.05770696e-02f, 2.62953825e-02f, 1.29492581e-01f, 6.56839982e-02f, 1.29426658e-01f, 6.63517788e-03f, 5.94367161e-02f, -2.28492562e-02f, 3.79221663e-02f, 1.16594844e-01f,
  1.23623848e-01f, 6.56017885e-02f, -1.72726661e-02f, 1.67251006e-01f, 3.46135981e-02f, -1.13117278e-01f, 1.24447532e-01f, 1.32656872e-01f, 8.78539607e-02f, 2.79737741e-01f,
  3.78223032e-01f, -3.55391443e-01f, 2.49900650e-02f, 1.70539543e-01f, -9.74384248e-02f, -2.44930349e-02f, -1.15106009e-01f, 5.93593381e-02f, -4.39386107e-02f, -2.35151485e-01f,
  -2.48962358e-01f, -1.70254230e-01f, -5.95907941e-02f, -5.61096519e-02f, 2.66203787e-02f, -1.53042987e-01f, -1.07085727e-01f, 2.32490972e-01f, 1.75790086e-01f, -5.86866215e-02f,
  -1.49220914e-01f, 1.79672107e-01f, 1.88389570e-01f, 9.36773494e-02f, -1.24696024e-01f, -1.11698799e-01f, -3.40713225e-02f, 7.74101913e-02f, -1.94957718e-01f, -2.68060774e-01f,
  -1.98553607e-01f, -7.66384369e-03f, 7.67269433e-02f, -1.09592304e-01f, -1.04463980e-01f, -2.56494693e-02f, -5.62454350e-02f, 4.55650836e-02f, -7.55732283e-02f, -8.72902721e-02f,
  -9.72225592e-02f, -1.11081675e-02f, -1.16183870e-01f, -7.13225305e-02f, 3.15125249e-02f, -2.90765464e-02f, 2.45209057e-02f, 3.74037586e-02f, -6.20995574e-02f, -1.85642302e-01f,
  -1.76074132e-01f, -1.93150640e-01f, -2.31303032e-02f, -5.95183559e-02f, -1.14020273e-01f, 6.66285586e-03f, -9.60570723e-02f, 1.87937934e-02f, 6.26117289e-02f, -1.17034018e-01f,
  8.61078221e-03f, -4.02324162e-02f, 4.40963656e-02f, -6.47148024e-03f, 2.86139231e-02f, -1.97791704e-03f, 5.72245009e-03f, -1.79590862e-02f, 3.79198045e-02f, 2.88182162e-02f,
  1.87212396e-02f, -2.11051591e-02f, -2.02728552e-03f, 4.68448177e-02f, 1.87081881e-02f, 1.15500269e-02f, 7.82812946e-03f, 4.56741042e-02f, -1.31701576e-02f, 6.04422353e-02f,
  -3.61023135e-02f, 1.42649524e-02f, 9.93608683e-02f, -7.22150728e-02f, -4.36899662e-02f, 9.15862620e-02f, 8.36909935e-02f, 6.81880563e-02f, 6.70200586e-02f, 1.24166854e-01f,
  5.42652234e-02f, 6.63779974e-02f, -9.73122790e-02f, -6.22047931e-02f, -7.14103971e-03f, -5.94980903e-02f, -9.92943496e-02f, -1.10251345e-01f, -4.03817035e-02f, -3.79472710e-02f,
  -2.64552422e-03f, -4.76578996e-02f, 1.15652587e-02f, -6.84638768e-02f, 4.26179683e-03f, -1.11371316e-01f, -7.66062140e-02f, -1.11924455e-01f, -1.12259179e-01f, -1.56451553e-01f,
  -1.45982236e-01f, -5.17215766e-03f, -1.54178794e-02f, -4.04718798e-03f, 4.08540806e-03f, 5.90735190e-02f, -1.64094493e-02f, -5.26313530e-03f, 9.82911214e-02f, 1.35157155e-02f,
  -8.43378156e-02f, 8.81495774e-02f, 2.88985968e-01f, 1.25154391e-01f, 1.50105074e-01f, 1.38431728e-01f, 1.26852011e-02f, -1.29275490e-02f, -8.90789330e-02f, -1.56680017e-03f,
  -4.06876765e-02f, -1.20512165e-01f, -6.77293986e-02f, -1.30081102e-01f, -6.41262308e-02f, -2.06069425e-02f, 8.27581808e-02f, -7.36895502e-02f, -1.86004281e-01f, -1.28327683e-01f,
  -1.26085535e-01f, -2.33974960e-02f, -1.78392798e-01f, -1.48690403e-01f, -6.00267155e-03f, -1.35347173e-02f, 7.65253752e-02f, 1.97470132e-02f, 1.00816175e-01f, 1.94255725e-01f,
  3.48219536e-02f, 5.85245937e-02f, -7.64986798e-02f, -1.28081501e-01f, -1.01538934e-01f, -8.70120823e-02f, -1.27765313e-01f, -1.66718528e-01f, -7.17597529e-02f, -5.54562733e-02f,
  -4.12138551e-02f, -1.07705742e-01f, -1.30183473e-01f, -9.82741416e-02f, -1.69936419e-01f, -5.90762869e-02f, -1.91182658e-01f, -1.26140937e-01f, -8.06054473e-02f, 1.23599982e-02f,
  -2.06250884e-02f, -6.96987063e-02f, -1.56177774e-01f, -1.76162884e-01f, -1.41386256e-01f, -1.49558038e-02f, -4.77614254e-02f, -1.26883030e-01f, -1.35234565e-01f, -8.10329989e-02f,
  6.52304962e-02f, 4.04468067e-02f, 3.42428647e-02f, 1.06731348e-01f, -1.17634134e-02f, 1.20782323e-01f, 5.99506684e-02f, 4.14227694e-03f, 6.81730406e-03f, 1.19420178e-01f,
  5.50117195e-02f, 6.38440996e-02f, 1.27466246e-01f, 1.75131992e-01f, 1.52236074e-01f, 8.83204862e-02f, 5.83985560e-02f, 3.69530655e-02f, 1.28825689e-02f, 8.40897560e-02f,
  4.33725454e-02f, 1.60143897e-01f, 1.29525904e-02f, 1.06019318e-01f, 7.36068785e-02f, 9.45075825e-02f, 1.16203174e-01f, 1.33520052e-01f, 8.89309868e-02f, 8.65139365e-02f,
  -3.23277771e-01f, -1.31769493e-01f, -1.02643013e-01f, -2.20347196e-01f, -9.90898684e-02f, -1.21011652e-01f, -3.08799986e-02f, -1.91514477e-01f, -1.23812333e-01f, -1.22329175e-01f,
  -1.46679640e-01f, -1.05978690e-01f, -1.20473169e-01f, -9.55393910e-02f, -1.63868457e-01f, -1.81064397e-01f, -2.60145813e-01f, -7.88400397e-02f, -1.10575616e-01f, -6.43099174e-02f,
  -1.99596599e-01f, -1.45556718e-01f, -2.30893239e-01f, -2.10127860e-01f, -1.20306104e-01f, -1.31721944e-01f, -2.04215020e-01f, -2.31346399e-01f, -2.18261227e-01f, -3.63956362e-01f,
  2.28493605e-02f, 1.34493828e-01f, 7.64175802e-02f, 2.02016658e-04f, 2.01545283e-01f, 6.20210767e-02f, 2.36252680e-01f, 9.99216139e-02f, 7.85137191e-02f, 2.46571839e-01f,
  1.15089439e-01f, 1.42962928e-03f, 1.05756104e-01f, 3.54737118e-02f, 9.33787078e-02f, 2.75384724e-01f, 2.06820279e-01f, 8.14728513e-02f, -2.39416739e-04f, 1.40911028e-01f,
  1.93354562e-01f, -6.22871798e-03f, -5.41511700e-02f, 2.91892756e-02f, 7.74905160e-02f, 1.70238599e-01f, 1.03604458e-01f, 1.47696406e-01f, 2.38507539e-01f, 2.99926519e-01f,
  3.20890099e-01f, -2.52524484e-02f, -7.58898184e-02f, 6.35499209e-02f, 8.77931491e-02f, 4.01074514e-02f, 1.26969703e-02f, 5.13320230e-03f, -9.16736871e-02f, 3.18251736e-02f,
  4.82152365e-02f, 6.66271225e-02f, 3.70750204e-02f, -4.40659374e-02f, -1.42521942e-02f, -1.97536852e-02f, -8.70675147e-02f, -5.01585901e-02f, -3.92887853e-02f, 3.61004397e-02f,
  -1.20481325e-03f, 2.96231974e-02f, 3.53061520e-02f, -6.23050407e-02f, -1.16196729e-01f, -6.14022017e-02f, -4.55670021e-02f, 6.47377148e-02f, 5.74287102e-02f, 1.11417644e-01f,
  8.23535770e-02f, 6.71002688e-03f, -9.95699167e-02f, -1.21179119e-01f, -2.79470719e-02f, -1.28012329e-01f, 2.85613239e-02f, 4.55188565e-02f, -5.91739789e-02f, 1.11888498e-02f,
  -1.21365212e-01f, -1.24503942e-02f, -6.79534078e-02f, 5.30896001e-02f, -9.07889474e-03f, -6.55080052e-03f, -2.24804636e-02f, -5.42118065e-02f, -9.55172107e-02f, -2.90179700e-02f,
  -8.05363953e-02f, -5.54340798e-03f, -7.81120211e-02f, -1.20498603e-02f, -4.73664366e-02f, -3.24078761e-02f, -3.39854062e-02f, -6.90287799e-02f, -8.97402018e-02f, -8.19469020e-02f,
  7.85927847e-02f, -1.00608245e-01f, 6.49872720e-02f, 5.15129268e-02f, 8.51906836e-02f, 4.17147428e-02f, 5.69064096e-02f, 4.26685670e-03f, 1.00739650e-01f, 1.22416429e-01f,
  2.49695517e-02f, 6.73701987e-02f, 1.53123111e-01f, 1.12378467e-02f, -4.57855919e-03f, 1.12573631e-01f, 4.40636314e-02f, 2.66670994e-02f, -1.09474417e-02f, -7.86081515e-03f,
  4.20292057e-02f, 3.66607718e-02f, 2.54452555e-03f, 4.39272001e-02f, 1.19076818e-01f, 4.96849529e-02f, 5.11634769e-03f, 4.63468023e-02f, 5.66426814e-02f, 1.67182073e-01f,
  -1.54217348e-01f, -2.69286245e-01f, -1.25988066e-01f, 9.76152942e-02f, -3.81346233e-02f, -4.22835648e-02f, -1.92646250e-01f, 7.56311323e-03f, 1.04423456e-01f, -1.11522816e-01f,
  -1.04155101e-01f, -1.60077050e-01f, -5.52337021e-02f, -8.72188807e-02f, -1.33437723e-01f, -7.40079135e-02f, 1.05596691e-01f, 5.78337982e-02f, 6.56409338e-02f, 2.48583616e-04f,
  8.99174660e-02f, -8.66871420e-03f, 9.69312638e-02f, 9.44261625e-02f, 9.05473158e-02f, 9.41815525e-02f, -4.99925623e-03f, 3.89313549e-02f, -9.91532877e-02f, 6.81509674e-02f,
  -1.32669970e-01f, -1.19031608e-01f, -7.92235658e-02f, -4.94343489e-02f, -1.79409117e-01f, -1.86064184e-01f, -1.97952896e-01f, -9.93642807e-02f, -1.48470476e-01f, -1.62620306e-01f,
  -1.38954654e-01f, -1.10368408e-01f, -1.55637264e-01f, -9.39447880e-02f, -2.00691894e-01f, -1.56911567e-01f, -3.50628346e-02f, -9.44421366e-02f, -4.79756109e-02f, -1.23215593e-01f,
  -2.07661882e-01f, -1.67951897e-01f, -2.86301553e-01f, -1.32036984e-01f, -2.08123177e-01f, -2.61360496e-01f, -1.50711447e-01f, -1.83743864e-01f, -1.20618030e-01f, -1.30437747e-01f,
  6.40602633e-02f, 1.02255628e-01f, 1.19461738e-01f, 6.42199367e-02f, 8.95659626e-02f, 6.02347814e-02f, 2.05463052e-01f, 1.61722869e-01f, 4.82529104e-02f, 1.47982717e-01f,
  1.63552612e-01f, 1.94695562e-01f, 1.28929079e-01f, 1.75142884e-01f, 9.55785066e-02f, 1.65613994e-01f, 1.63003176e-01f, 1.94315627e-01f, 1.14539981e-01f, 1.85866177e-01f,
  1.98599637e-01f, 1.71248883e-01f, 2.39936069e-01f, 1.12469897e-01f, 1.25224799e-01f, 1.89598665e-01f, 1.50386572e-01f, 1.81190223e-01f, 1.89426526e-01f, 1.89654216e-01f,
  -1.82478011e-01f, -1.54203683e-01f, -6.56270459e-02f, -1.04956873e-01f, -1.69896960e-01f, -1.02662489e-01f, -1.84369236e-01f, -1.44118726e-01f, -3.13362703e-02f, -9.57501680e-02f,
  -1.18294209e-01f, -3.95169333e-02f, -1.39008731e-01f, -1.85806811e-01f, -1.80165693e-01f, -1.24621280e-01f, -1.34360686e-01f, -6.76508918e-02f, -1.32290125e-01f, -1.98721364e-01f,
  -1.48746863e-01f, -2.18375355e-01f, -1.87888369e-01f, -2.79162467e-01f, -1.92796797e-01f, -1.94933683e-01f, -1.56464398e-01f, -2.19435856e-01f, -1.89090639e-01f, -2.23244816e-01f,
  2.81982943e-02f, 3.25596154e-01f, -3.48439664e-02f, 6.29121885e-02f, 4.57309410e-02f, 1.37171939e-01f, 2.51080215e-01f, 1.68534175e-01f, 4.03712951e-02f, 1.54491905e-02f,
  -1.34476051e-01f, -3.29378754e-01f, -3.04788858e-01f, -2.52823204e-01f, -1.86945394e-01f, 1.73177212e-01f, 9.24221277e-02f, -8.17576498e-02f, -2.65803069e-01f, -5.52189164e-02f,
  -5.85405454e-02f, 5.84472306e-02f, -9.55058038e-02f, -4.46234830e-02f, 5.62286563e-02f, -1.24788269e-01f, 1.75327688e-01f, -2.43218951e-02f, 3.20564471e-02f, -4.94483039e-02f,
  -2.12042734e-01f, -5.66824712e-02f, -1.90758139e-01f, -5.44620417e-02f, -8.15676153e-03f, -9.06650573e-02f, -5.92068397e-02f, -1.37892291e-01f, -5.71511202e-02f, 6.74758032e-02f,
  -1.23333372e-01f, -1.25474870e-01f, -2.01135293e-01f, -1.40999109e-02f, -9.04057771e-02f, -3.34499627e-02f, -7.40352422e-02f, -1.13511764e-01f, -1.37890279e-02f, -6.45758286e-02f,
  -1.15586920e-02f, 4.59801480e-02f, -6.76413402e-02f, -9.37642679e-02f, -4.30764146e-02f, -1.80579022e-01f, -9.79488194e-02f, -1.50632709e-01f, -8.94329995e-02f, 8.69991258e-02f,
  6.24526516e-02f, 1.13491714e-01f, 7.17630982e-02f, 6.14632219e-02f, 1.03184104e-01f, 1.24962524e-01f, 1.73406780e-01f, 6.66865930e-02f, 3.21300887e-02f, 1.96789801e-02f,
  8.86663571e-02f, 3.57879512e-03f, 1.51007384e-01f, 1.00246638e-01f, 6.51723798e-03f, 1.43254966e-01f, 3.01142242e-02f, 1.39927477e-01f, 2.06041113e-02f, 1.47311404e-01f,
  2.68896632e-02f, 6.91822618e-02f, 4.56973240e-02f, 4.43103388e-02f, 7.46711418e-02f, 1.49326369e-01f, 1.41465157e-01f, 9.41020250e-02f, 1.55435890e-01f, 6.81679994e-02f,
  -2.24719301e-01f, -1.94512650e-01f, -1.71070993e-01f, -1.29208416e-01f, -4.79630847e-03f, -7.92555064e-02f, -1.15170375e-01f, -4.67128269e-02f, -3.62812541e-02f, -1.25721902e-01f,
  -6.19328581e-02f, -1.11325838e-01f, -4.54111062e-02f, -1.04621030e-01f, -1.38276368e-01f, -1.11866720e-01f, 1.48801729e-02f, -1.30903617e-01f, -7.27049932e-02f, -9.87044871e-02f,
  -1.61403175e-02f, 7.30343163e-02f, -3.78060304e-02f, -1.94661338e-02f, -4.86353738e-03f, -1.25110090e-01f, -1.37811229e-01f, -9.48802531e-02f, -9.80862603e-02f, 8.62938315e-02f,
  5.55544436e-01f, -4.40099746e-01f, -3.71568590e-01f, 4.64989729e-02f, -8.49738121e-02f, -1.20490983e-01f, -2.57726073e-01f, -1.40608475e-01f, 1.80650018e-02f, -4.82616294e-03f,
  3.67063992e-02f, 2.04360887e-01f, 1.93071842e-01f, 1.68775469e-01f, 6.10909425e-02f, -3.06630909e-01f, -1.33437425e-01f, 1.46174833e-01f, 3.17996979e-01f, 2.61442602e-01f,
  1.21756971e-01f, 1.09282523e-01f, 1.83178976e-01f, 1.00758530e-01f, -7.82206059e-02f, 1.41232073e-01f, -2.00372458e-01f, -9.59972888e-02f, -5.53233251e-02f, -2.25973710e-01f,
  5.97655699e-02f, -9.98780802e-02f, 1.55162498e-01f, 1.24207206e-01f, 1.25463409e-02f, 1.40393786e-02f, 6.16055951e-02f, 8.41437280e-03f, 9.17631984e-02f, -8.93555805e-02f,
  5.80163896e-02f, 2.30751932e-03f, -1.30823301e-02f, -1.16409492e-02f, -8.88461713e-03f, -4.18884046e-02f, -6.02926239e-02f, -5.75209334e-02f, -9.64007080e-02f, -8.89908895e-02f,
  -2.00991631e-02f, -1.87976491e-02f, -9.57777537e-03f, -1.20919729e-02f, -5.63752316e-02f, 1.20610937e-01f, -7.12105855e-02f, -2.05501309e-03f, -1.32176122e-02f, -5.22163063e-02f,
  1.39455602e-01f, -1.38594732e-01f, 2.39451299e-03f, 7.56239668e-02f, 2.67010666e-02f, -4.06828187e-02f, -7.83167686e-03f, 2.22422625e-03f, 5.59396669e-02f, -1.27965929e-02f,
  -4.56481539e-02f, -4.03728820e-02f, -4.35529985e-02f, -3.16235647e-02f, 1.98661126e-02f, -1.07820615e-01f, 1.39898704e-02f, -1.01295896e-01f, 3.81335318e-02f, -7.08371624e-02f,
  7.09868297e-02f, -2.38918886e-02f, -3.74995023e-02f, -6.49036169e-02f, -1.25392387e-02f, -2.05149222e-03f, -4.60764393e-02f, -3.08449417e-02f, -1.64886396e-02f, -3.61381695e-02f,
  1.38996795e-01f, 9.35000032e-02f, 1.56930983e-01f, 9.92200896e-02f, -1.37682101e-02f, 7.90581759e-03f, 8.00802335e-02f, 7.09404126e-02f, 5.38608879e-02f, 9.89516079e-03f,
  7.32978135e-02f, 1.16609819e-01f, 3.66777740e-02f, 2.07488541e-03f, 1.18798226e-01f, 2.57371683e-02f, 1.36841372e-01f, 8.67561921e-02f, -7.95106310e-03f, -1.38760820e-01f,
  -5.95786311e-02f, -2.42648879e-03f, 9.29237455e-02f, 6.23111725e-02f, -6.26993598e-03f, 1.73839346e-01f, 2.78978497e-02f, 9.97669771e-02f, 5.77143133e-02f, 1.19354770e-01f,
  -8.10035244e-02f, 2.18087405e-01f, 3.24412286e-01f, -7.23010451e-02f, -1.93758551e-02f, 5.04541881e-02f, 1.44064426e-01f, -5.53428791e-02f, -8.86608586e-02f, 5.23893982e-02f,
  8.99424404e-02f, -8.59663635e-02f, 3.22543569e-02f, -2.80956943e-02f, 3.40888128e-02f, 1.45362705e-01f, 5.01661226e-02f, 6.17400818e-02f, -1.35904253e-01f, -1.53898194e-01f,
  -8.45248401e-02f, -3.11747473e-02f, 6.46128133e-02f, -1.83800329e-02f, 5.51802479e-02f, -1.79238748e-02f, 1.89830482e-01f, 8.54311585e-02f, 8.44806805e-02f, 1.42351940e-01f,
  2.22904801e-01f, 1.69092849e-01f, -4.88741212e-02f, 3.12893763e-02f, 3.66129763e-02f, 5.20472005e-02f, 3.18086818e-02f, 8.08789954e-02f, 1.02232799e-01f, 1.61463693e-02f,
  6.60464615e-02f, 3.15671638e-02f, 1.91794988e-02f, 2.84994375e-02f, 1.27239913e-01f, 1.26610488e-01f, 8.08391944e-02f, 7.49109238e-02f, 1.35216951e-01f, 9.92460996e-02f,
  1.49852205e-02f, 6.84115710e-03f, 1.26605630e-01f, 1.10806845e-01f, 8.20291787e-02f, 7.64971823e-02f, 2.00447619e-01f, 1.14444032e-01f, 1.63711488e-01f, 6.83217570e-02f,
  7.45155066e-02f, -6.61979318e-02f, -1.39995828e-01f, -1.53370574e-02f, -1.24694891e-01f, -1.13667980e-01f, -1.67579740e-01f, -1.68133438e-01f, -1.39838979e-01f, -1.17990822e-02f,
  -1.39506817e-01f, -2.57223267e-02f, -1.31367892e-01f, -6.25180900e-02f, -1.00222416e-01f, -4.51027080e-02f, -8.74421448e-02f, -1.50574818e-01f, -3.78297456e-02f, -2.72776335e-02f,
  -1.66685969e-01f, -1.21478386e-01f, -1.36698395e-01f, -1.07721798e-01f, -6.15990981e-02f, -1.83080267e-02f, -7.48926103e-02f, -8.72888193e-02f, -1.04003362e-01f, -7.25630447e-02f,
  -2.12666430e-02f, 3.71824279e-02f, 8.59146565e-02f, 4.60358523e-02f, 5.67715019e-02f, 7.90819898e-02f, 9.13565829e-02f, 1.51870430e-01f, 8.84150714e-02f, 1.45401791e-01f,
  4.56181653e-02f, 1.27873033e-01f, 7.24586993e-02f, 1.13133565e-01f, 5.88027090e-02f, 3.12614404e-02f, 9.18336585e-02f, -2.75210049e-02f, -2.64434088e-02f, 1.34653926e-01f,
  7.58711919e-02f, 6.06658272e-02f, -1.65541489e-02f, 1.17835425e-01f, 9.81076285e-02f, 1.40700983e-02f, 1.97893739e-01f, 1.62317261e-01f, 7.68540949e-02f, 6.40379936e-02f,
  -1.63058728e-01f, -4.61226776e-02f, 1.74325705e-02f, 1.22678056e-01f, 8.81121978e-02f, 8.00716802e-02f, -6.52368218e-02f, 6.10352457e-02f, 2.02804565e-01f, 2.10385472e-02f,
  -4.04281588e-03f, 2.22204134e-01f, 2.15351582e-01f, 1.98594689e-01f, 3.55458707e-02f, 6.01917552e-03f, -7.51586333e-02f, -1.88153461e-02f, 4.94508408e-02f, 3.72182042e-03f,
  6.45085722e-02f, -1.72144905e-01f, -8.66426453e-02f, -8.66087824e-02f, -4.72087786e-02f, 8.88334438e-02f, -1.20011106e-01f, -2.40874991e-01f, -1.57184705e-01f, -2.00712830e-01f,
  -1.13724865e-01f, -1.24332272e-01f, 9.97168198e-02f, 8.29835311e-02f, 2.91270996e-03f, 5.85950799e-02f, -2.34443098e-02f, 1.08871073e-01f, 1.31125189e-02f, -6.11134320e-02f,
  -9.57452226e-03f, 5.31547256e-02f, -1.00662578e-02f, 6.28642738e-02f, -4.08325680e-02f, 3.08734272e-02f, 4.00011279e-02f, -5.98218180e-02f, 6.73806295e-02f, -9.60120186e-02f,
  -1.00555576e-01f, -1.70879900e-01f, -9.65336431e-03f, -3.17310542e-02f, 5.64497374e-02f, 1.28881335e-01f, -5.74741103e-02f, -1.24365211e-01f, -5.16215526e-02f, -2.34239221e-01f,
  -1.25805028e-02f, -9.77142304e-02f, -1.17028272e-03f, -1.28306784e-02f, -1.07024573e-01f, -6.78004473e-02f, -2.11046580e-02f, -5.26949614e-02f, -4.64296564e-02f, -8.33026245e-02f,
  -3.03221103e-02f, 2.63305078e-03f, -1.13401152e-01f, -1.54977113e-01f, -9.40446556e-02f, -1.72118619e-01f, -7.15501532e-02f, -5.82952350e-02f, -5.89006990e-02f, -1.28429532e-02f,
  -1.30638853e-01f, -7.06930086e-02f, -5.02461009e-02f, -8.16044658e-02f, -1.06377602e-01f, -1.13778532e-01f, -5.02232164e-02f, -5.44670857e-02f, 3.03838570e-02f, -2.09540874e-02f,
  3.12492624e-02f, 1.18897982e-01f, 1.62698776e-01f, 6.52789101e-02f, 1.08506911e-01f, 3.18692438e-02f, 5.66269532e-02f, 2.96806246e-02f, 1.00899130e-01f, -1.05161322e-02f,
  3.73745710e-02f, -2.93023721e-03f, 5.15130982e-02f, 9.87905711e-02f, 1.11877605e-01f, 7.68639073e-02f, -5.19909337e-03f, 9.93816704e-02f, 1.26314297e-01f, 5.73541448e-02f,
  -5.50066233e-02f, 4.60199453e-02f, 9.00242403e-02f, 7.80038685e-02f, 2.77597865e-04f, 1.25424221e-01f, 9.38223451e-02f, 4.12212238e-02f, 5.01301046e-03f, 2.64162552e-02f,
  -4.54819798e-01f, -4.16704535e-01f, 2.03355059e-01f, -3.06210101e-01f, -9.46457833e-02f, 2.08281502e-01f, 8.90341103e-02f, -1.29323691e-01f, -1.99846298e-01f, -2.51488775e-01f,
  -1.96556345e-01f, -1.36281163e-01f, -5.80561981e-02f, 1.73703209e-01f, 1.39193133e-01f, 9.38784853e-02f, 2.70973057e-01f, 2.18500063e-01f, 2.69401580e-01f, -2.54093278e-02f,
  -3.65212969e-02f, -2.20392421e-01f, -1.05359085e-01f, -1.32772774e-01f, -1.01601377e-01f, -5.22711352e-02f, -3.19691561e-02f, -4.52906415e-02f, 1.88159496e-02f, -1.37337193e-01f,
  8.39678496e-02f, -2.52124369e-01f, 1.13284580e-01f, -2.42928028e-01f, -9.59468633e-02f, -9.92930382e-02f, -1.11222290e-01f, -1.68851987e-01f, -1.82222083e-01f, -1.18407207e-02f,
  -8.31096247e-02f, -1.89830571e-01f, -1.68193519e-01f, -9.02995765e-02f, -7.14561716e-02f, -1.11991204e-01f, -7.44175166e-02f, 2.25545987e-02f, 5.47764674e-02f, -7.87443593e-02f,
  -4.53135557e-02f, -1.42346352e-01f, 6.44467073e-04f, -4.02335972e-02f, 7.18100071e-02f, -8.20970535e-02f, -4.95053409e-03f, -4.06309664e-02f, -6.17809780e-02f, -2.42080003e-01f,
  6.70473725e-02f, 7.06285611e-02f, 1.58704147e-01f, 9.62551218e-04f, 1.20614365e-01f, 5.74668944e-02f, 9.98429582e-02f, 7.81767741e-02f, 1.43350765e-01f, 5.77713922e-02f,
  7.34312236e-02f, 6.22928627e-02f, 1.03937075e-01f, 6.82529807e-02f, 8.80112723e-02f, 7.50994589e-03f, 4.94085252e-02f, 9.32717100e-02f, 1.83336996e-02f, -3.13840620e-02f,
  9.32535455e-02f, 1.38714284e-01f, 1.56648215e-02f, 7.20348805e-02f, 1.00572295e-01f, 9.21709090e-02f, -9.58365109e-03f, 7.34977648e-02f, 1.85266696e-02f, 4.46224958e-02f,
  -7.50569403e-02f, 9.07234754e-03f, -1.21927269e-01f, -5.12237735e-02f, -1.33164108e-01f, -7.62036890e-02f, -3.57945710e-02f, -7.41336197e-02f, -7.02025294e-02f, -6.40213937e-02f,
  -1.04459651e-01f, -2.13505086e-02f, -1.32094815e-01f, -1.11932784e-01f, 3.22822221e-02f, -1.15856349e-01f, -1.10290393e-01f, -4.84366305e-02f, -7.30117857e-02f, -5.29332124e-02f,
  -5.09947203e-02f, -1.22135073e-01f, -1.19981848e-01f, 3.80451940e-02f, -6.20029978e-02f, -5.29055968e-02f, 3.14421616e-02f, -3.98264118e-02f, 6.80508092e-02f, -1.02221832e-01f,
  -1.96636170e-02f, 2.59909630e-01f, 8.55324566e-02f, -2.29213104e-01f, -2.09698901e-01f, -5.08125825e-03f, 9.11813974e-02f, 2.65414231e-02f, -6.97032809e-02f, 3.86586711e-02f,
  3.01990169e-03f, -9.79175344e-02f, -2.44324639e-01f, -1.13850370e-01f, -8.68768990e-02f, -4.50273752e-02f, -1.25830576e-01f, -2.24662140e-01f, -1.95888802e-01f, -2.36197755e-01f,
  -2.38494590e-01f, -9.45282504e-02f, -8.18720534e-02f, -9.30124074e-02f, -5.55489361e-02f, -1.56267375e-01f, 9.38496962e-02f, -4.08061333e-02f, 3.74976620e-02f, 6.59047216e-02f,
  9.48707312e-02f, 1.50027737e-01f, -2.20966160e-01f, -6.27297396e-03f, 1.84665732e-02f, -4.73956801e-02f, 7.02146143e-02f, -3.01073566e-02f, -6.28251359e-02f, -3.30178649e-03f,
  -1.60229690e-02f, -3.92252728e-02f, -2.20130850e-02f, -4.26155552e-02f, -2.85164104e-03f, -5.75009547e-02f, -6.62709633e-03f, -1.31384358e-02f, -1.01404674e-01f, 6.77889809e-02f,
  -8.53072554e-02f, -8.60910788e-02f, -1.56328842e-01f, -8.45564902e-02f, 4.34645563e-02f, -1.27999887e-01f, 1.77084357e-02f, 8.00276324e-02f, 3.29375193e-02f, 4.66217622e-02f,
  -9.90286563e-03f, -1.57530128e-04f, 1.07291892e-01f, 6.23408891e-02f, -2.05463227e-02f, 9.84077528e-02f, 5.08556217e-02f, -4.93889526e-02f, 6.89503625e-02f, 3.77230812e-03f,
  7.14046583e-02f, 1.02586679e-01f, -6.55100448e-03f, 1.09621778e-01f, 7.29144514e-02f, 9.17881355e-02f, 5.83122671e-02f, 1.18582055e-01f, 1.48128748e-01f, 6.81316340e-03f,
  1.97254747e-04f, 7.92648867e-02f, 6.51736781e-02f, 4.66883257e-02f, 1.19123682e-02f, 1.20311528e-01f, 2.17598435e-02f, 5.45041822e-02f, 8.47724825e-02f, 1.41434357e-01f,
  -1.10050298e-01f, -1.63263939e-02f, -7.03676790e-02f, -1.34370342e-01f, -1.88775193e-02f, 3.76292900e-03f, 5.31756412e-03f, 1.87602900e-02f, 2.20635496e-02f, -1.61286015e-02f,
  6.43106028e-02f, -3.65532488e-02f, -5.57335317e-02f, -4.97701578e-02f, -5.44534884e-02f, 2.00615227e-02f, -1.11587204e-01f, -1.78522483e-01f, -9.04781595e-02f, -6.06956370e-02f,
  -5.87392747e-02f, -1.98803857e-01f, -1.72695339e-01f, -7.09150657e-02f, -4.76507917e-02f, -2.85730839e-01f, -7.54172206e-02f, -4.83229607e-02f, -7.28142858e-02f, -2.10291594e-01f,
  -6.20380938e-02f, 2.95685410e-01f, -3.12875688e-01f, 7.07306266e-02f, 5.19976392e-02f, -1.28876984e-01f, -5.30995652e-02f, 5.64800352e-02f, -3.42962034e-02f, 8.42041597e-02f,
  1.97608873e-01f, 5.66695258e-02f, -7.74292573e-02f, -4.74190824e-02f, -8.26994143e-03f, -3.43196327e-03f, -1.59662649e-01f, -2.23048449e-01f, -2.10197270e-01f, -2.34074201e-02f,
  1.08534709e-01f, 1.46946162e-01f, -5.60921766e-02f, -1.16661089e-02f, 6.52290359e-02f, -1.01243174e-02f, -9.09462422e-02f, 1.22223757e-01f, 3.54968011e-02f, 1.67047098e-01f,
  -1.20979533e-01f, -1.07046692e-02f, -1.04412094e-01f, -4.76662219e-02f, -6.83977529e-02f, -1.29311532e-02f, -1.02413833e-01f, -3.97654958e-02f, 1.09504946e-02f, -3.64903882e-02f,
  4.94753048e-02f, 7.05316663e-02f, -1.05709217e-01f, -5.28502427e-02f, -7.40216598e-02f, -1.00334205e-01f, -1.11062638e-02f, -1.38065875e-01f, -1.16612606e-01f, -6.45637810e-02f,
  4.90943016e-03f, -8.53562132e-02f, -8.27719718e-02f, -1.36642456e-01f, -8.95295367e-02f, -1.49606168e-01f, -2.00308748e-02f, -1.20628132e-02f, -3.58275771e-02f, -9.02851745e-02f,
  -3.82040106e-02f, 5.20771332e-02f, 9.44339037e-02f, 6.53465241e-02f, 1.76594839e-01f, -6.53337035e-03f, 7.63099194e-02f, 5.46953306e-02f, -2.72668619e-02f, -3.98025066e-02f,
  1.07384004e-01f, 7.41845071e-02f, 2.70541646e-02f, 8.72202665e-02f, 5.30573726e-02f, 1.00767072e-02f, 1.15780987e-01f, 1.82439461e-01f, -2.05149855e-02f, 9.26457494e-02f,
  7.40023404e-02f, -7.84798861e-02f, 6.42560422e-02f, 3.45287398e-02f, 1.32631823e-01f, 1.11715525e-01f, 9.94175598e-02f, 7.95761272e-02f, 7.99469184e-03f, 7.74318725e-02f,
  2.05491204e-02f, -8.72406065e-02f, -1.18986696e-01f, -2.91335974e-02f, -4.53108065e-02f, -1.08270034e-01f, -1.16978481e-01f, -8.46082419e-02f, -1.47993878e-01f, -7.82000422e-02f,
  6.59441762e-03f, -6.46897405e-03f, -9.56746340e-02f, -1.37909502e-01f, -1.10824265e-01f, -1.87585652e-01f, -7.88488761e-02f, -2.02525109e-01f, -1.23972856e-01f, -7.86439255e-02f,
  -5.17228767e-02f, -1.44172564e-01f, -2.39363268e-01f, -2.00304061e-01f, -5.42027690e-02f, -1.68150485e-01f, -2.11034775e-01f, -1.76690578e-01f, -1.45153210e-01f, -6.58315569e-02f,
  -9.39444825e-02f, 4.37370613e-02f, -1.36486471e-01f, -2.15493321e-01f, -1.44312516e-01f, -1.62360892e-01f, -5.67972586e-02f, -1.03681065e-01f, -1.22694939e-01f, -1.82170972e-01f,
  -1.04061039e-02f, 3.17187868e-02f, 1.10442215e-03f, 1.01019688e-01f, -3.19281965e-02f, -1.39394939e-01f, -8.82930383e-02f, -1.58592328e-01f, -6.93051815e-02f, -8.39592814e-02f,
  -1.19412296e-01f, -1.44368351e-01f, 1.32501253e-03f, -6.66149408e-02f, -1.26209289e-01f, -6.36953637e-02f, -4.35915366e-02f, 3.72462869e-02f, 4.63560037e-02f, -1.52633786e-01f,
  -1.17901742e-01f, -3.87147553e-02f, -2.33030543e-02f, 5.13171852e-02f, 4.14280780e-02f, 2.12081857e-02f, 5.90754040e-02f, -9.51320212e-03f, 5.03735133e-02f, -5.70054539e-02f,
  -4.51604165e-02f, -4.25009839e-02f, 3.75804976e-02f, 5.98883256e-02f, -4.31327485e-02f, 3.99938785e-02f, 5.60057396e-03f, 6.92580687e-03f, 4.61710803e-03f, 4.37117852e-02f,
  -7.45314825e-03f, -1.09897278e-01f, 9.85074881e-03f, 8.39210004e-02f, 1.15998521e-01f, -9.43277311e-03f, 6.58975318e-02f, 1.47870868e-01f, 5.43923527e-02f, 9.27339271e-02f,
  1.73914842e-02f, 4.59789075e-02f, -1.33174136e-02f, -6.07726444e-03f, 2.99070831e-02f, 1.65730789e-02f, -8.47898349e-02f, -1.33349419e-01f, 5.32677844e-02f, -1.10841217e-02f,
  -9.46457684e-02f, 7.99147226e-03f, -7.81465098e-02f, -2.68329103e-02f, -1.78412441e-02f, -1.11193120e-01f, -8.09553172e-03f, -7.69199505e-02f, 2.63837557e-02f, 2.55939513e-02f,
  2.07846183e-02f, -5.17541096e-02f, -3.75640579e-02f, -8.09956938e-02f, -5.50751910e-02f, -1.12534240e-01f, 2.45136674e-03f, -5.61998226e-02f, 2.04355009e-02f, 2.15169154e-02f,
  -4.82127070e-02f, 1.89297006e-01f, -9.91912652e-03f, 1.24295212e-01f, -5.79654574e-02f, 8.18812847e-02f, 3.94698866e-02f, 1.36831164e-01f, 8.00847337e-02f, -1.07191652e-02f,
  9.88061056e-02f, 3.03939953e-02f, -4.27540988e-02f, 4.70473990e-02f, -6.14846610e-02f, -3.50826420e-02f, 6.98135328e-03f, -5.48746735e-02f, 8.40787515e-02f, 7.92560950e-02f,
  6.93269968e-02f, -4.44888845e-02f, 1.31458417e-02f, 1.15594625e-01f, 1.03656039e-01f, -5.45513220e-02f, 7.81285316e-02f, 8.29097703e-02f, 6.91904686e-03f, -7.08478019e-02f,
  7.83573315e-02f, 3.11380506e-01f, 4.14916635e-01f, 2.62255937e-01f, 1.31162703e-01f, 1.13095649e-01f, 1.80291995e-01f, 1.42376617e-01f, 9.31171887e-03f, 2.01280594e-01f,
  1.10618778e-01f, 6.56462014e-02f, 1.45725384e-01f, 1.53849572e-01f, 9.54700485e-02f, 1.90173686e-01f, 2.26272956e-01f, 1.91314057e-01f, 6.16295673e-02f, 7.45482370e-02f,
  1.29875168e-01f, 1.74263954e-01f, 7.60668293e-02f, -4.00372781e-04f, 1.54053316e-01f, 4.20286646e-03f, 3.03972930e-01f, 2.40307346e-01f, 4.63131554e-02f, 1.22072972e-01f,
  3.24094474e-01f, 1.73500195e-01f, 7.88158178e-03f, -1.19249776e-01f, 8.48584771e-02f, -8.19578990e-02f, -3.96534242e-02f, -9.09522101e-02f, -1.33396983e-01f, 7.46594667e-02f,
  -1.41268792e-02f, -7.50584826e-02f, 3.10833827e-02f, -6.69479817e-02f, -2.27253865e-02f, -4.16179858e-02f, -9.45853535e-03f, 3.09134051e-02f, 5.94828539e-02f, 2.88103446e-02f,
  -3.34135182e-02f, -3.57129686e-02f, -5.54029969e-03f, -2.14966759e-02f, -9.17313620e-02f, 5.20345755e-02f, -2.74859238e-02f, 3.43184099e-02f, -6.05181567e-02f, -2.58800462e-02f,
  -1.72647879e-01f, 5.03508300e-02f, -5.12228832e-02f, -6.03578100e-03f, -6.20249398e-02f, 1.22752367e-03f, -2.10959855e-02f, 5.83298281e-02f, -1.89190023e-02f, -1.26343332e-02f,
  7.47272298e-02f, 4.84457389e-02f, 6.04736768e-02f, 8.91620889e-02f, 8.53673071e-02f, 8.84618238e-02f, 5.07904738e-02f, 1.13201119e-01f, -4.58675437e-02f, 5.78847341e-03f,
  8.99445172e-03f, 2.05738340e-02f, -1.00849206e-02f, 7.13735968e-02f, 3.12641747e-02f, 1.47765040e-01f, 1.62647981e-02f, -1.05817150e-03f, 4.92262468e-02f, -8.53551645e-03f,
  9.65796933e-02f, -2.28975173e-02f, -4.99798991e-02f, -1.90410569e-01f, -7.21392184e-02f, -8.99049416e-02f, -2.11433563e-02f, -1.07483238e-01f, -9.04652383e-03f, -1.58000831e-02f,
  -2.95871161e-02f, 1.72873847e-02f, -3.24495733e-02f, -8.03451017e-02f, -2.91033578e-03f, -1.80939436e-01f, -8.86714384e-02f, -5.93528971e-02f, -5.04012406e-02f, -9.17630717e-02f,
  1.30770681e-02f, -1.03212953e-01f, -7.76177868e-02f, -8.55025351e-02f, -1.46714360e-01f, -1.50139183e-01f, -8.85658339e-02f, -1.11525014e-01f, -5.26251607e-02f, -9.70830470e-02f,
  -1.47600234e-01f, -1.02039799e-01f, -8.09705555e-02f, -8.03947747e-02f, -6.67188838e-02f, 5.76725826e-02f, 2.82928739e-02f, -1.30963903e-02f, -5.90861291e-02f, 3.94809013e-03f,
  4.15705591e-02f, 8.57416466e-02f, 9.18729752e-02f, 1.39048204e-01f, 1.74289882e-01f, 1.45328995e-02f, -1.12126693e-02f, 6.04973063e-02f, -4.02801260e-02f, -5.76029457e-02f,
  5.28615154e-02f, -8.73874277e-02f, -1.08687431e-01f, -8.01987723e-02f, -3.71029451e-02f, -4.43913862e-02f, -8.53380561e-02f, -1.17477052e-01f, -2.47477088e-02f, 3.05219740e-02f,
  5.40913604e-02f, -1.62149251e-01f, 8.80009234e-02f, 2.26221848e-02f, -7.84521997e-02f, 6.33926243e-02f, 4.00031218e-04f, -8.01677406e-02f, -4.43754382e-02f, -6.08164445e-02f,
  4.33620922e-02f, -3.66368294e-02f, 3.60600613e-02f, -7.39566907e-02f, -5.43830059e-02f, 5.35184667e-02f, 5.14960755e-03f, 6.00550603e-03f, -9.48400274e-02f, 2.01655664e-02f,
  7.10680410e-02f, 2.10430846e-02f, -8.86171386e-02f, -9.12882090e-02f, -1.12882189e-01f, -4.48281989e-02f, -1.56815454e-01f, -1.63091451e-01f, -1.55001298e-01f, -1.45143360e-01f,
  6.09696954e-02f, 4.36967462e-02f, 1.73531957e-02f, -8.26238990e-02f, 5.60220256e-02f, 1.94268711e-02f, 1.08502105e-01f, 6.64251521e-02f, -5.74653037e-03f, -4.40255180e-03f,
  4.46935222e-02f, -1.59872528e-02f, -9.03877616e-02f, 6.93473518e-02f, -1.71150174e-02f, -9.27889347e-03f, -4.04607467e-02f, -1.24896476e-02f, 2.59831008e-02f, -6.68691024e-02f,
  3.76466140e-02f, 6.65342659e-02f, 1.77237764e-02f, -2.27610264e-02f, 7.07634613e-02f, 6.66420311e-02f, -1.10104000e-02f, -5.55329993e-02f, 7.44238198e-02f, 2.77521964e-02f,
  5.75006455e-02f, -2.95999143e-02f, 9.98895764e-02f, 3.52915190e-02f, -6.70269802e-02f, -6.98363641e-03f, 1.09447408e-02f, -7.55969509e-02f, -1.17666665e-02f, 8.23563412e-02f,
  -5.95282065e-03f, -4.10831533e-02f, -5.43052740e-02f, 1.00433789e-02f, -6.72474736e-03f, -7.95534551e-02f, 5.35781607e-02f, 2.53387615e-02f, -3.42757851e-02f, -5.23370579e-02f,
  -9.80162807e-03f, 1.27284184e-01f, 8.22728500e-02f, 4.77046743e-02f, -4.70400266e-02f, 1.28067493e-01f, 9.98647586e-02f, 8.20248872e-02f, 9.89528149e-02f, 5.14993295e-02f,
  -3.01941544e-01f, -3.20497483e-01f, -2.05613021e-02f, -6.15271665e-02f, 8.41538310e-02f, -2.84179505e-02f, -2.82477796e-01f, -2.79470235e-01f, -1.10744573e-01f, -2.01241195e-01f,
  7.14054629e-02f, 1.35811195e-02f, 1.68312769e-02f, 3.37142423e-02f, -2.17938453e-01f, -2.14281142e-01f, -8.64767190e-03f, -2.40726024e-02f, -9.30789560e-02f, 5.06264332e-04f,
  5.64251691e-02f, -3.72258611e-02f, -1.74230680e-01f, -1.14231214e-01f, 2.82152779e-02f, 3.22642438e-02f, 3.46585433e-03f, -2.52731256e-02f, 7.53777195e-03f, 7.52795786e-02f,
  -3.87488939e-02f, -2.25430250e-01f, -1.30389199e-01f, 5.79964928e-02f, 4.24508564e-02f, -7.28400275e-02f, -1.16468579e-01f, -1.09497413e-01f, -6.68767989e-02f, -1.07802406e-01f,
  8.19814727e-02f, -8.54459107e-02f, 2.06874516e-02f, -5.87084256e-02f, -8.13810006e-02f, -8.51998851e-03f, -9.57271531e-02f, -1.28675818e-01f, -5.34187518e-02f, 6.63137529e-03f,
  2.46120640e-03f, -2.49662194e-02f, -9.76973996e-02f, -9.60223749e-02f, -4.74635400e-02f, 4.71048318e-02f, -1.39057394e-02f, -1.17069483e-01f, -6.18769117e-02f, -1.88631058e-01f,
  1.01703413e-01f, -1.01928962e-02f, 2.11774167e-02f, 7.49884918e-02f, 5.63566275e-02f, 7.80873299e-02f, -4.72401045e-02f, 3.82184312e-02f, 1.49512906e-02f, 2.36659218e-02f,
  -5.32903373e-02f, 1.28021920e-02f, -4.52474020e-02f, 2.90889293e-03f, 6.26041964e-02f, 3.85630876e-02f, 5.39276283e-03f, -7.07810745e-02f, 4.30019274e-02f, -2.54369769e-02f,
  -2.29169964e-03f, 6.77344576e-02f, 1.00448951e-01f, 7.47527406e-02f, 1.02622598e-01f, 7.09211007e-02f, 8.66597220e-02f, 4.84110340e-02f, 4.43057381e-02f, -5.56237577e-03f,
  -1.98979273e-01f, 3.94845344e-02f, -1.97795048e-01f, -1.32273391e-01f, -1.69247040e-03f, -5.36238141e-02f, -2.77429670e-02f, 2.58967262e-02f, -8.73322189e-02f, -4.68436554e-02f,
  -4.55305018e-02f, -8.86919275e-02f, -9.97739360e-02f, -5.62001094e-02f, -8.76392275e-02f, -7.11298659e-02f, -1.21202007e-01f, -1.28032804e-01f, -4.86291125e-02f, -3.79093997e-02f,
  -6.32345527e-02f, -1.65768474e-01f, -2.15300873e-01f, -9.51605886e-02f, -1.21031806e-01f, -5.90803102e-02f, -1.94986016e-01f, -5.69570623e-02f, -2.17586398e-01f, -2.75506347e-01f,
  -2.95382589e-01f, -4.23304468e-01f, -8.14273395e-03f, -1.76866099e-01f, -1.69206073e-03f, 1.15373634e-01f, -1.37245387e-01f, -6.69525415e-02f, -6.45766556e-02f, -1.98764518e-01f,
  -7.76373073e-02f, -1.29788974e-02f, -8.18486959e-02f, -5.39238155e-02f, -6.21630326e-02f, -2.13894024e-01f, -7.34295771e-02f, 2.56001707e-02f, 1.22139528e-01f, 4.13824513e-04f,
  -1.87114015e-01f, -1.54701591e-01f, -1.23497404e-01f, -1.65914208e-01f, -1.27810910e-01f, -3.31191570e-02f, -1.17430866e-01f, -5.04319519e-02f, -2.02627312e-02f, -1.75694123e-01f,
  1.04707099e-01f, -8.60328302e-02f, 3.62056680e-02f, -1.36702970e-01f, -1.83377359e-02f, -1.73026890e-01f, -7.77936578e-02f, -1.99942723e-01f, -1.04023002e-01f, -1.11234985e-01f,
  -8.26571584e-02f, -3.40307504e-02f, -1.60504058e-01f, -6.08972199e-02f, -1.57573223e-01f, -2.32675821e-02f, -1.61752626e-01f, -2.26194412e-01f, -1.88968286e-01f, -1.30775183e-01f,
  -1.60755321e-01f, -2.03754574e-01f, -1.19582310e-01f, -9.14631188e-02f, -4.29640152e-02f, -8.09854362e-03f, -1.84739202e-01f, -1.68446392e-01f, -1.37428448e-01f, -2.02304468e-01f,
  -3.27967405e-02f, 1.96626335e-01f, 1.97574198e-01f, 2.82285959e-02f, 8.87015313e-02f, 1.46565482e-01f, 7.02012032e-02f, 4.13699560e-02f, 9.42290500e-02f, 1.07303888e-01f,
  1.25977218e-01f, 1.54004574e-01f, 3.11308801e-02f, 8.95942897e-02f, 1.54627725e-01f, 3.23049463e-02f, 1.34386316e-01f, 5.45819178e-02f, 8.68038163e-02f, 1.36234254e-01f,
  2.74133570e-02f, 1.25387713e-01f, 2.40238644e-02f, 1.05112687e-01f, 4.08432446e-02f, 2.68002730e-02f, 4.29899199e-03f, 1.68142974e-01f, 9.10777748e-02f, 1.30354604e-02f,
  9.76805389e-02f, 1.41779602e-01f, -6.04668111e-02f, -8.14655572e-02f, -1.71538398e-01f, -1.15398236e-01f, -1.30191997e-01f, -5.82749248e-02f, -2.55690180e-02f, -4.54752333e-02f,
  -1.21012151e-01f, -1.36239976e-01f, -1.09768271e-01f, -8.48200768e-02f, -6.67553991e-02f, -1.93711799e-02f, -1.63603380e-01f, -7.83694685e-02f, -6.22459128e-02f, -1.31846502e-01f,
  -2.31363311e-01f, -4.40753996e-02f, 5.83316162e-02f, -3.42102796e-02f, -7.55598024e-02f, -6.65430771e-03f, -1.43707963e-02f, -4.07850668e-02f, 5.44362441e-02f, -2.13611856e-01f,
  3.34939770e-02f, -6.76729158e-02f, -1.57973155e-01f, 1.26182631e-01f, -1.16520129e-01f, -1.52746305e-01f, -2.30895892e-01f, -1.45264998e-01f, -8.37031826e-02f, -4.50101979e-02f,
  -1.48687378e-01f, -4.08318788e-02f, -8.32190886e-02f, 6.69900775e-02f, 5.41613288e-02f, -9.93946642e-02f, -2.10795198e-02f, 1.39551386e-01f, -7.61251897e-02f, 6.20220117e-02f,
  -7.45593989e-03f, 1.50702611e-01f, 1.25527069e-01f, 1.61249176e-01f, 1.62359595e-01f, -3.76041643e-02f, 5.69286384e-02f, 2.17061918e-02f, 4.09653634e-02f, 1.32187739e-01f,
  -2.56965190e-01f, 2.88342070e-02f, -1.26025245e-01f, -2.98272558e-02f, -4.67774837e-04f, -1.52880801e-02f, 1.04409941e-02f, 8.51913095e-02f, 9.66689065e-02f, -6.40979856e-02f,
  6.44731522e-02f, 6.88796639e-02f, 4.99382094e-02f, -1.19200805e-02f, 3.46595747e-03f, -4.69350889e-02f, 1.57665573e-02f, 2.47586775e-03f, -6.58017322e-02f, -2.32993979e-02f,
  1.58430979e-01f, 4.13392335e-02f, -8.02783221e-02f, 4.89128083e-02f, 1.03519075e-02f, -4.37336341e-02f, -8.64567384e-02f, -6.06954843e-02f, -8.26403275e-02f, 2.58988626e-02f,
  9.56220701e-02f, 6.99534938e-02f, -6.25531599e-02f, 8.28698874e-02f, -6.01736903e-02f, 9.95745882e-02f, -2.56167725e-02f, 7.30313286e-02f, 4.51949351e-02f, 3.58583815e-02f,
  -1.69851594e-02f, -4.44751941e-02f, 2.03874316e-02f, -7.35574365e-02f, -6.33472502e-02f, 4.87241298e-02f, -3.04908063e-02f, -2.83718742e-02f, 1.29377721e-02f, -6.71453774e-02f,
  1.32052787e-02f, -4.94234897e-02f, 8.52892525e-04f, -5.87549470e-02f, -7.27992281e-02f, -2.69862451e-02f, -3.97923961e-02f, -2.44809762e-02f, 1.00567602e-02f, -5.43375127e-02f,
  -1.80907682e-01f, -7.26695433e-02f, -1.69134766e-01f, -3.76328714e-02f, -1.50011061e-02f, -7.48638809e-02f, -1.01627253e-01f, -6.09810129e-02f, -6.52236864e-02f, -9.18678269e-02f,
  -1.21784650e-01f, -5.12422621e-02f, -5.44342697e-02f, -3.04131061e-02f, -6.52408227e-02f, -5.25667742e-02f, 5.11492826e-02f, -4.74521443e-02f, -4.91944961e-02f, 4.43162844e-02f,
  -6.25156686e-02f, -1.02087773e-01f, -2.16449648e-01f, -1.62752181e-01f, -5.22296280e-02f, -8.19603279e-02f, -2.12871313e-01f, -1.45714670e-01f, -2.66392171e-01f, -2.62679994e-01f,
  2.14254912e-02f, 2.04359926e-02f, 1.22498289e-01f, 1.35717049e-01f, 6.52906075e-02f, 9.76807252e-02f, 2.11439863e-01f, 8.75086784e-02f, 8.98647085e-02f, -2.03863392e-03f,
  -2.43583903e-01f, -2.10289314e-01f, -2.14086071e-01f, -1.49158135e-01f, -9.46635008e-02f, 3.91367152e-02f, 1.87468216e-01f, 1.02646723e-01f, 1.43381879e-02f, -5.71344569e-02f,
  -1.09590732e-01f, 8.78208950e-02f, 1.72044173e-01f, 7.90093169e-02f, 6.23929128e-02f, -5.65131009e-02f, 2.05555215e-01f, 5.60723469e-02f, -9.85899493e-02f, -5.57364747e-02f,
  -3.40302944e-01f, 1.32687226e-01f, -5.87618686e-02f, -8.13535526e-02f, -5.12593761e-02f, -9.01939534e-03f, 4.67356248e-03f, 7.56111592e-02f, 8.27106833e-02f, 6.79505095e-02f,
  5.56544997e-02f, -8.05843994e-02f, 1.96486432e-02f, -6.44291518e-04f, 6.26498163e-02f, 1.06015593e-01f, 1.08925372e-01f, 1.53856888e-01f, 2.28801072e-02f, -8.70577469e-02f,
  -1.27941325e-01f, -7.19061261e-03f, 1.36290699e-01f, 1.47970319e-01f, 6.06477223e-02f, -1.11198932e-01f, 7.36960918e-02f, 1.55959159e-01f, 1.42619923e-01f, 3.76343764e-02f,
  -1.16187714e-01f, -6.11348636e-02f, 2.49568727e-02f, -7.30728582e-02f, -4.21425141e-02f, -5.77773526e-02f, 5.93067557e-02f, -8.37503001e-02f, 1.89442746e-02f, 6.75515011e-02f,
  -3.84930857e-02f, -4.14075376e-03f, -6.18572086e-02f, 7.41965398e-02f, -3.77918147e-02f, 1.80723891e-03f, -1.19106239e-02f, -5.53289689e-02f, -8.03204328e-02f, 1.86677482e-02f,
  -6.22748472e-02f, -2.03306656e-02f, -2.34568259e-03f, 1.12549327e-02f, -8.35146476e-03f, 4.26693410e-02f, -8.39712620e-02f, -5.30237481e-02f, -1.67199560e-02f, -6.02700375e-02f,
  -1.07846387e-01f, 4.53827903e-02f, -3.99266109e-02f, -6.93470687e-02f, 1.23946801e-01f, -2.45725736e-02f, -4.30269875e-02f, 5.28850965e-02f, 1.46549642e-02f, 3.24945673e-02f,
  -9.15094018e-02f, 4.92919572e-02f, 4.95103840e-03f, -9.50105954e-03f, 6.57556430e-02f, 4.97176684e-02f, -8.29253346e-02f, 1.11611169e-02f, 5.63084297e-02f, -7.76000246e-02f,
  1.04747918e-02f, -4.62875031e-02f, -7.77082965e-02f, -1.10557131e-01f, 4.80859280e-02f, -1.46621361e-01f, -1.10630900e-01f, 5.86693883e-02f, -3.07368785e-02f, 3.77847590e-02f,
  3.51149172e-01f, 4.76664037e-01f, -4.42145765e-02f, 2.03591391e-01f, -3.09682768e-02f, 9.81167657e-04f, 1.68593392e-01f, -2.90497225e-02f, 9.52328593e-02f, 1.36282161e-01f,
  7.13355988e-02f, -2.56882787e-01f, -2.27946728e-01f, -1.81428388e-01f, -1.33862048e-01f, 4.30594869e-02f, 6.58905283e-02f, -2.17719972e-01f, -3.74230474e-01f, -2.71093622e-02f,
  -1.37801403e-02f, 5.87037802e-02f, 6.79708794e-02f, 9.17778462e-02f, 2.10240915e-01f, -3.82129452e-04f, 6.34452477e-02f, 1.11572109e-01f, 1.21598281e-01f, 2.57873714e-01f,
  -1.00370012e-01f, 2.89018661e-01f, -1.56041682e-01f, -3.38456780e-02f, -3.44657712e-02f, -3.46644111e-02f, 6.40491843e-02f, -3.80123481e-02f, 8.10472369e-02f, 5.61308712e-02f,
  1.84992943e-02f, 9.48824957e-02f, 8.88034329e-02f, 8.46341997e-02f, 1.37166932e-01f, -1.47817684e-02f, 1.07253350e-01f, -4.16876702e-03f, -2.62233149e-02f, 6.57402650e-02f,
  8.76864139e-03f, 1.25730664e-01f, -4.26471792e-02f, 6.01888075e-02f, 9.05110687e-03f, -7.80929253e-02f, 1.05988029e-02f, 1.47727458e-02f, -1.84820648e-02f, 2.06548423e-01f,
  -3.74372192e-02f, 7.73347691e-02f, 5.59051260e-02f, 7.44759012e-03f, 2.82137319e-02f, 2.86337454e-02f, 5.69464825e-02f, -2.20029652e-02f, 1.52226212e-02f, 7.23538548e-02f,
  -2.14304458e-02f, 4.47208285e-02f, -6.38096780e-02f, 8.49068388e-02f, 2.88214330e-02f, 9.40367654e-02f, 4.69451845e-02f, 3.54795121e-02f, -8.09719227e-03f, 7.21872970e-02f,
  -1.42874774e-02f, 1.04127591e-02f, 4.00395356e-02f, 9.24892724e-02f, 1.55538991e-02f, -4.84436937e-03f, 5.80865107e-02f, 3.64550878e-03f, 3.59360166e-02f, 4.88822237e-02f,
  -1.05017841e-01f, -1.13624133e-01f, 4.73226309e-02f, 8.56018811e-02f, 8.99807960e-02f, 5.99785484e-02f, 3.42029408e-02f, 7.72840157e-02f, 8.47800542e-03f, 8.34172219e-02f,
  -1.52656091e-02f, -6.45451173e-02f, -7.98770711e-02f, 2.43976973e-02f, -7.16896653e-02f, 1.24559365e-02f, 6.78552389e-02f, 6.10346645e-02f, 1.55937858e-02f, -1.97223909e-02f,
  1.08606711e-01f, 3.85409519e-02f, -6.06971495e-02f, -1.36261955e-01f, -5.23741636e-03f, -1.19320922e-01f, -1.48965552e-01f, -1.02486312e-01f, -1.59763053e-01f, -1.29789347e-02f,
  5.06960392e-01f, -2.24050269e-01f, -2.02073947e-01f, 1.54907167e-01f, -9.82186198e-02f, -2.56893337e-01f, -3.09307933e-01f, -5.35263009e-02f, 1.26134709e-01f, -1.33221120e-01f,
  2.42094422e-04f, 1.54392987e-01f, 6.19674996e-02f, 3.54130305e-02f, -1.21279741e-02f, -2.75539309e-01f, -8.96353275e-02f, -1.86387338e-02f, 5.08591719e-02f, -1.57185227e-01f,
  -7.43689388e-02f, 9.57616139e-03f, 1.61481440e-01f, -7.70945987e-03f, -3.45001258e-02f, 7.43069649e-02f, -7.89045915e-03f, 2.85981316e-02f, -4.71554063e-02f, -6.04843944e-02f,
  -7.39227682e-02f, 1.87421530e-01f, -3.18847448e-02f, -6.17153235e-02f, -1.18610626e-02f, -1.45149797e-01f, -1.22304574e-01f, -1.09608211e-01f, 1.41030382e-02f, -1.09009586e-01f,
  1.55195547e-02f, -1.18138567e-01f, -4.24960777e-02f, -1.39165465e-02f, -1.03129953e-01f, -1.32180110e-01f, -1.23320244e-01f, -1.42504703e-02f, -1.14244081e-01f, -1.01894923e-01f,
  -1.76019877e-01f, 1.09294942e-02f, -5.75355887e-02f, -3.36084701e-02f, -1.03538007e-01f, 5.01381494e-02f, -1.36153132e-01f, -2.86994595e-02f, -4.59252149e-02f, -3.35458331e-02f,
  -5.79287075e-02f, -2.80853938e-02f, -8.45645741e-02f, 7.10294992e-02f, -2.16377787e-02f, -7.78749958e-02f, -5.36422990e-02f, 4.57079075e-02f, -4.56327908e-02f, -3.52431275e-02f,
  6.59363419e-02f, 5.52575570e-03f, 4.95934533e-03f, -7.69995451e-02f, -7.26051442e-03f, -1.14451401e-01f, -4.40514944e-02f, -1.11206472e-01f, 1.19898720e-02f, -1.42504759e-02f,
  -8.18165988e-02f, 2.48150844e-02f, 1.47947827e-02f, -9.75210518e-02f, -1.68934986e-02f, 2.09663473e-02f, -1.02863587e-01f, -1.39285401e-02f, 3.61840986e-02f, -4.18676287e-02f,
  -6.49404824e-02f, -1.44374501e-02f, -1.74744055e-02f, 3.23558636e-02f, -3.84446187e-03f, -8.45952183e-02f, -2.36320775e-02f, -3.71083133e-02f, 4.27333266e-02f, -1.09157339e-03f,
  9.47976951e-03f, -8.29503760e-02f, -3.63747180e-02f, -7.23874420e-02f, -1.20359883e-01f, -1.17853224e-01f, 2.62643751e-02f, -7.53016993e-02f, -1.33005142e-01f, -5.75912185e-02f,
  -8.93748626e-02f, -3.58839408e-02f, -3.51773947e-02f, -4.70343381e-02f, -1.05193026e-01f, -2.59526772e-03f, -1.80149928e-01f, -1.46788791e-01f, -6.84899166e-02f, -1.98854893e-01f
};

// L0_fan_Wp_bar (Shape: 52 x 120)
const int L0_fan_Wp_bar_rows = 52;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -3.80578160e-01f, -1.78958386e-01f, 4.08272147e-01f, -4.30204213e-01f, -3.66781503e-01f, -2.36998186e-01f, -4.74318743e-01f, -3.82675529e-01f, -2.33218849e-01f, -2.82244056e-01f,
  -2.96838116e-02f, 2.78890699e-01f, 6.04044616e-01f, 2.59991854e-01f, 1.82747900e-01f, -1.11255884e-01f, -1.11303329e-02f, 2.34383881e-01f, -3.72170135e-02f, -5.94308734e-01f,
  -3.88287157e-01f, -1.99734539e-01f, -5.30007072e-02f, -9.71375480e-02f, -2.19519705e-01f, 1.31021947e-01f, 2.52212495e-01f, -1.69922207e-02f, 1.23051316e-01f, 6.47828653e-02f,
  2.00535253e-01f, -2.30852872e-01f, 1.33973733e-01f, -6.79749548e-02f, -7.32076690e-02f, -4.77781780e-02f, -5.76206036e-02f, 1.61495581e-01f, -5.52395843e-02f, -2.53938474e-02f,
  -7.12479129e-02f, -1.94835231e-01f, 2.29239520e-02f, -1.42422438e-01f, -2.60001451e-01f, -1.80252150e-01f, -4.77903076e-02f, 1.56763885e-02f, 1.12595469e-01f, -5.21175899e-02f,
  -1.16853505e-01f, -1.15101032e-01f, 2.15739772e-01f, 1.68009356e-01f, -5.15336767e-02f, 1.51030734e-01f, 2.72363164e-02f, -5.25757410e-02f, 2.42660865e-01f, -9.56803709e-02f,
  -7.31585920e-02f, 2.58065552e-01f, 1.02389440e-01f, -4.48660105e-02f, 4.77075502e-02f, 1.09090701e-01f, -5.59044629e-02f, -1.37300164e-01f, 1.49735752e-02f, 9.05544981e-02f,
  -3.86439711e-02f, 1.92792974e-02f, -4.97245528e-02f, 3.09321098e-02f, 3.00914180e-02f, -6.12888206e-03f, 1.23737343e-01f, 1.01114335e-02f, -2.62566842e-02f, -2.54132245e-02f,
  5.28595336e-02f, 1.58834923e-02f, 2.12325323e-02f, 2.66698785e-02f, -1.86277591e-02f, -1.21051677e-01f, 7.91276246e-03f, -4.23817337e-02f, -8.14057142e-02f, -1.10643491e-01f,
  2.22642288e-01f, 2.72837073e-01f, 4.02942821e-02f, -4.54122908e-02f, -8.92501473e-02f, 1.03223454e-02f, 7.85219520e-02f, 5.74109377e-03f, 4.45463955e-02f, -2.95075271e-02f,
  -3.64007950e-02f, -1.09139487e-01f, 1.18914120e-01f, 2.14460609e-03f, -6.92408085e-02f, -1.53646290e-01f, -1.90662324e-01f, -8.43674019e-02f, -8.25698301e-03f, -1.20367184e-01f,
  -1.36107862e-01f, -1.73954427e-01f, 1.07210018e-01f, 2.27080986e-01f, -9.29303914e-02f, 1.31150767e-01f, 2.01492608e-01f, 9.88319889e-02f, 2.58790135e-01f, -1.23148739e-01f,
  2.88284183e-01f, -4.03007150e-01f, 5.83211370e-02f, 2.45832726e-01f, 1.35512114e-01f, 1.92433909e-01f, 2.55938262e-01f, 1.84280515e-01f, 2.38432825e-01f, 6.40265420e-02f,
  -1.49820402e-01f, -2.45519608e-01f, -1.47563636e-01f, -2.21817553e-01f, -6.59349710e-02f, 2.94123530e-01f, 1.76658511e-01f, 7.42662698e-02f, -5.75937442e-02f, -3.61529645e-03f,
  -7.11692870e-02f, 5.25524206e-02f, -1.05246909e-01f, -1.03231058e-01f, 7.90027305e-02f, -5.24444394e-02f, 9.97360349e-02f, -1.33293107e-01f, -9.62035656e-02f, 6.38311803e-02f,
  -1.09542243e-01f, -3.36613685e-01f, 1.20385373e-02f, -3.39589119e-01f, -1.27177477e-01f, 8.41502920e-02f, 5.03202006e-02f, -3.97962146e-02f, -1.41820787e-02f, 1.48210958e-01f,
  -1.85980976e-01f, -1.20053433e-01f, 8.31798371e-03f, -9.07563046e-02f, 1.61528718e-02f, 5.92101961e-02f, -1.32093608e-01f, -7.00340569e-02f, -1.11784965e-01f, -1.85557321e-01f,
  -1.93554655e-01f, -1.64147377e-01f, -4.26254347e-02f, -1.09854110e-01f, -1.43353775e-01f, -7.68151283e-02f, -2.11941898e-01f, -1.30390659e-01f, -2.02129245e-01f, 5.86672388e-02f,
  7.70860165e-02f, 1.31572872e-01f, -1.05158187e-01f, 2.23760083e-02f, -1.24204028e-02f, -9.54198092e-02f, 5.60891442e-02f, -1.17068410e-01f, 6.85166195e-02f, 6.34004250e-02f,
  -3.62131186e-02f, 1.15783572e-01f, 1.25106961e-01f, 1.38040006e-01f, 6.32171258e-02f, -1.48530565e-02f, 8.61760601e-02f, -7.68842548e-02f, -1.74167231e-02f, 9.89209116e-02f,
  -4.01306152e-02f, 1.12635650e-01f, -4.41687033e-02f, 7.48217478e-02f, 7.22921491e-02f, 3.32712643e-02f, 2.24843889e-01f, 3.84431146e-03f, 6.58976957e-02f, 1.69331506e-01f,
  2.13757783e-01f, -4.02091034e-02f, 3.24444085e-01f, -2.79809590e-02f, 8.08643177e-02f, -8.69623572e-02f, 9.91133600e-02f, -1.15552898e-02f, -3.05348709e-02f, 4.48723994e-02f,
  -2.23655924e-02f, 2.08997494e-03f, 5.17901368e-02f, 1.23305462e-01f, 2.42400929e-01f, 1.45969227e-01f, -1.78353384e-01f, -3.90240215e-02f, -1.36078238e-01f, 2.34841555e-02f,
  -3.52547097e-04f, 1.93937331e-01f, 2.39303336e-01f, 1.04679808e-01f, 3.12602334e-02f, -7.33557157e-03f, 4.46903743e-02f, 4.89912890e-02f, 6.17375746e-02f, 4.00763422e-01f,
  6.04356766e-01f, -1.77558094e-01f, 1.90738067e-01f, 2.59888351e-01f, 3.64116311e-01f, 4.51651841e-01f, 4.47142154e-01f, 1.43122822e-01f, 1.41892448e-01f, -4.86285724e-02f,
  -1.09537035e-01f, -2.62568861e-01f, -1.35991201e-01f, -1.84600264e-01f, -1.08388169e-02f, 5.04720323e-02f, 1.95594549e-01f, 2.84414850e-02f, 1.85196728e-01f, 1.03433244e-01f,
  -1.08144693e-02f, 1.66111141e-01f, 6.80299401e-02f, -3.16548496e-02f, -2.69008547e-01f, -1.00395873e-01f, 8.82058125e-03f, 9.66654569e-02f, -2.45662078e-01f, -3.37785989e-01f,
  -5.27843654e-01f, 1.01821780e-01f, -3.26429866e-02f, -1.26126722e-01f, -1.68952465e-01f, -1.20820880e-01f, -1.50552318e-01f, -1.70918688e-01f, -3.44187282e-02f, 7.96986818e-02f,
  1.12815760e-02f, -1.22111984e-01f, -1.06702916e-01f, -5.99964261e-02f, 1.03848809e-02f, -2.88923271e-02f, -3.11300531e-02f, -1.32583454e-01f, -1.89536259e-01f, -2.22545326e-01f,
  -1.72964141e-01f, 7.31310621e-02f, 1.13936797e-01f, 7.10172299e-03f, -6.40164167e-02f, 2.71985587e-02f, -1.34465331e-02f, -6.90894648e-02f, 8.31966251e-02f, 4.13204692e-02f,
  -1.90731123e-01f, -1.69125497e-01f, -1.95256665e-01f, -6.38849884e-02f, 8.98250714e-02f, 4.29339148e-02f, 3.54136378e-02f, -1.67465173e-02f, 2.33837515e-02f, -4.84704264e-02f,
  -6.19163327e-02f, -1.23677976e-01f, -1.83926031e-01f, -5.81122711e-02f, -2.06538871e-01f, -1.83877945e-01f, -1.06506377e-01f, -1.37887821e-01f, -3.90493423e-02f, -1.06144801e-01f,
  -6.06900491e-02f, -6.63996562e-02f, -1.36246055e-01f, -2.35616639e-01f, -2.20241293e-01f, -6.72094524e-02f, -1.49147734e-01f, -1.20670117e-01f, -3.67858931e-02f, -1.01978367e-03f,
  -5.91509044e-01f, -2.36175656e-02f, -9.24142376e-02f, -1.38250396e-01f, -6.16209693e-02f, -1.82687402e-01f, -1.65771499e-01f, -5.56590743e-02f, 5.76211549e-02f, -5.76061271e-02f,
  -8.80315900e-02f, -4.27967720e-02f, -2.05878019e-01f, -7.28665143e-02f, 1.21199168e-01f, 1.10594079e-01f, -1.21867724e-01f, 1.89539208e-03f, -1.54835984e-01f, -1.07804865e-01f,
  -1.46001697e-01f, 1.06666669e-01f, 1.98600948e-01f, 9.52029303e-02f, 1.08124293e-01f, 1.66283384e-01f, 1.19339779e-01f, 9.82462689e-02f, 2.05892444e-01f, 3.30378264e-01f,
  -5.03175080e-01f, 1.86472461e-01f, 3.07942063e-01f, -1.57912940e-01f, 2.39560872e-01f, 2.20118061e-01f, 1.32298693e-01f, -8.26032534e-02f, 4.20036837e-02f, 8.87152106e-02f,
  1.35075539e-01f, -3.84563059e-02f, 2.36860029e-02f, -1.29486784e-01f, -3.45075250e-01f, 2.47247219e-02f, 3.81935388e-02f, -2.28267223e-01f, -3.57789189e-01f, -2.14114785e-01f,
  -3.21249887e-02f, -1.12866141e-01f, -3.24819595e-01f, -2.16236860e-01f, 6.95885811e-03f, -2.07284875e-02f, 1.14437453e-01f, -6.57918751e-02f, -1.68260876e-02f, 5.55092618e-02f,
  -2.50969201e-01f, -4.12606187e-02f, 1.40321404e-01f, -6.86891675e-02f, 1.17475174e-01f, -1.27090916e-01f, -7.94744566e-02f, 1.46436561e-02f, 2.41909306e-02f, -2.01582704e-02f,
  6.64989743e-03f, -7.70380720e-02f, 6.47611404e-03f, -2.10303403e-02f, -7.25689158e-02f, -1.28491938e-01f, -3.74404974e-02f, -1.22080229e-01f, -2.70960927e-02f, 3.82738374e-02f,
  3.94703746e-02f, -2.21259780e-02f, -9.20263901e-02f, 3.77644738e-03f, -9.17230025e-02f, -1.49288177e-01f, -8.47299695e-02f, -1.73693046e-01f, -1.79494172e-01f, -2.53900081e-01f,
  -2.91675385e-02f, 1.02889501e-01f, 9.02446657e-02f, 2.46805754e-02f, -5.89754283e-02f, 4.55741584e-02f, 1.46136647e-02f, -4.37026583e-02f, 1.81152336e-02f, -1.28395602e-01f,
  -7.61722215e-04f, 4.30979654e-02f, 1.62527151e-02f, -1.66276451e-02f, -1.01546220e-01f, -1.11878384e-02f, -1.21996269e-01f, -1.30013943e-01f, -9.77671742e-02f, -4.12979610e-02f,
  -1.15163259e-01f, -1.45653123e-02f, 4.65789363e-02f, -5.22971451e-02f, -4.22326960e-02f, -8.37351531e-02f, -1.67608950e-02f, -6.07506260e-02f, -4.81703915e-02f, -1.14967488e-01f,
  -3.14658850e-01f, 1.00332931e-01f, -9.79068205e-02f, -6.20833039e-02f, 3.44882309e-02f, 5.62749282e-02f, 3.81520204e-02f, 2.22739633e-02f, 6.16888963e-02f, -8.04560557e-02f,
  -6.47997558e-02f, -9.08977315e-02f, 6.39489368e-02f, 9.21207741e-02f, -9.20840576e-02f, 1.24229863e-02f, -5.89800514e-02f, 5.82985990e-02f, 1.06146514e-01f, 3.52234356e-02f,
  -6.22321740e-02f, -2.56200075e-01f, -3.84129137e-01f, -1.03868559e-01f, -1.40980333e-01f, -2.28573322e-01f, -2.45803356e-01f, -2.42124498e-01f, -2.20307276e-01f, -4.45431858e-01f,
  -1.28488779e-01f, 1.95209198e-02f, -1.59699116e-02f, 9.11257416e-02f, 2.33113796e-01f, -1.47532418e-01f, -4.72313493e-01f, -4.78215843e-01f, 2.54208427e-02f, 1.04787849e-01f,
  3.07935208e-01f, 2.84410149e-01f, 6.20687641e-02f, -2.03154400e-01f, -6.96033776e-01f, -4.43357199e-01f, -3.78803343e-01f, -4.97492611e-01f, -4.69064325e-01f, -3.05071920e-01f,
  7.14761913e-02f, 3.09404964e-03f, -3.00148219e-01f, -1.95416167e-01f, 5.03639162e-01f, 2.86316812e-01f, 1.82830140e-01f, 1.91443995e-01f, 1.20723937e-02f, 3.21896970e-01f,
  3.95044088e-01f, -4.30616699e-02f, -6.90032765e-02f, -8.93222243e-02f, 2.39375889e-01f, 1.95933562e-02f, 2.71215569e-02f, -1.40799838e-03f, 6.00899607e-02f, 9.30574760e-02f,
  1.71411887e-01f, 3.23980115e-02f, -5.49135124e-03f, 4.73630168e-02f, 1.69507675e-02f, 3.63573879e-02f, -9.83326882e-02f, -1.75753817e-01f, -4.36286889e-02f, 1.50643051e-01f,
  1.95241705e-01f, 1.01800330e-01f, -3.31141800e-03f, -1.48382694e-01f, -8.36379677e-02f, 7.18633458e-02f, 8.33711848e-02f, 1.11835010e-01f, -1.21679530e-01f, 1.19409665e-01f,
  -3.97864282e-02f, 8.25338662e-02f, 4.35817130e-02f, 2.82965880e-02f, 6.77902475e-02f, 4.05962355e-02f, 4.10595685e-02f, 7.06997365e-02f, -5.75791709e-02f, -2.36714911e-02f,
  -6.30555749e-02f, 5.02439588e-03f, 2.91097686e-02f, 6.50025345e-03f, 7.67238960e-02f, 5.34906564e-03f, 1.08067766e-01f, 8.00704807e-02f, 3.60836834e-02f, 1.31825879e-01f,
  7.26384670e-02f, 5.00464402e-02f, 1.44124106e-01f, 2.79559381e-02f, 2.88006361e-03f, 8.32520574e-02f, 9.18821245e-02f, 1.82464182e-01f, 1.42894521e-01f, 8.16895366e-02f,
  1.35466576e-01f, -2.07847327e-01f, 6.21835329e-02f, -1.57975242e-01f, 6.45999759e-02f, 8.55419859e-02f, 1.15240365e-01f, -3.57736498e-02f, 1.95904106e-01f, 1.68729514e-01f,
  6.78674653e-02f, 2.10104957e-02f, 2.78749559e-02f, 2.12143511e-02f, -6.30056038e-02f, 6.88034445e-02f, -9.13166776e-02f, 1.31914556e-01f, -1.42782763e-01f, 1.95883051e-01f,
  -1.42284468e-01f, -2.13494852e-01f, -2.00792372e-01f, -1.43530756e-01f, 2.91389879e-02f, 1.85658876e-02f, 9.74126086e-02f, 6.84951395e-02f, -9.18687508e-02f, -1.03337459e-01f,
  2.84765244e-01f, -2.65623003e-01f, 2.07885489e-01f, -3.93464714e-02f, -8.90407413e-02f, -5.76483943e-02f, -2.63691366e-01f, -1.57847375e-01f, -7.95801878e-02f, -1.19144328e-01f,
  3.82425170e-03f, 8.29389170e-02f, 6.30388632e-02f, 1.70859713e-02f, 2.10651830e-02f, -2.78361976e-01f, -1.94359109e-01f, 8.30944702e-02f, 1.79659501e-01f, -9.81195420e-02f,
  -1.20300584e-01f, 6.80845752e-02f, 1.64193437e-01f, 8.93419683e-02f, -3.92909534e-02f, -3.36981080e-02f, 4.19515977e-03f, -9.42212716e-02f, -8.62717032e-02f, -3.32594126e-01f,
  -4.96398518e-03f, 1.98260710e-01f, -9.36366431e-03f, 1.74012288e-01f, 1.09133273e-01f, 1.10196769e-01f, 9.77384448e-02f, -3.88769843e-02f, -5.95783480e-02f, -1.28888488e-01f,
  9.71753001e-02f, 1.30481899e-01f, 1.65052563e-01f, 1.43299580e-01f, 9.75382701e-02f, 1.88566402e-01f, 5.35705239e-02f, -2.39084624e-02f, 4.72421050e-02f, 2.33757533e-02f,
  7.20116645e-02f, 3.11802011e-02f, 7.33341724e-02f, 9.37725380e-02f, 1.35821134e-01f, 1.61575392e-01f, 1.23401627e-01f, 1.79324627e-01f, 8.91124681e-02f, -1.40087260e-03f,
  1.50259495e-01f, -1.51521921e-01f, 1.08801574e-01f, 2.04458997e-01f, 6.26768619e-02f, 3.35471258e-02f, -1.43637910e-01f, -1.21541709e-01f, 5.61120771e-02f, 6.32620007e-02f,
  -1.66869342e-01f, 2.05013249e-02f, 1.09573126e-01f, 2.92975027e-02f, 1.60511091e-01f, 9.34150442e-03f, -4.21260484e-02f, 3.32318731e-02f, 2.90953964e-01f, 1.05801120e-01f,
  9.67621654e-02f, -1.98550984e-01f, 1.28172666e-01f, -1.04078185e-02f, -4.65449244e-02f, 9.21335220e-02f, -2.96568535e-02f, 1.14252917e-01f, -4.45128717e-02f, -9.28252339e-02f,
  -2.05868959e-01f, 5.76519966e-01f, -1.36051372e-01f, -5.13617182e-03f, 4.35413830e-02f, 7.22063631e-02f, 1.06833935e-01f, -5.27255796e-02f, -7.58887827e-02f, 1.24232089e-02f,
  3.57387252e-02f, -1.27709343e-03f, 4.75501977e-02f, -8.05395190e-03f, 1.06200986e-01f, 1.90504983e-01f, 7.86289200e-03f, -1.63214862e-01f, 1.92870910e-03f, 3.00899390e-02f,
  2.71947887e-02f, -5.07772230e-02f, -6.61756322e-02f, 1.14811763e-01f, 4.38556969e-02f, -1.83980092e-02f, 4.63220924e-02f, 2.67856717e-02f, 1.97735518e-01f, -6.21532016e-02f,
  -7.66021550e-01f, 4.04914588e-01f, -2.59408444e-01f, -5.26968956e-01f, -4.72224802e-01f, -8.98448452e-02f, 3.36104214e-01f, -1.15618452e-01f, -4.39877391e-01f, 8.56226981e-02f,
  7.19145834e-02f, -1.61072716e-01f, -1.16174236e-01f, 1.68144152e-01f, 1.20745726e-01f, 1.58523083e-01f, -3.85832936e-01f, -4.21102166e-01f, -3.62680346e-01f, 5.27602546e-02f,
  4.40257899e-02f, -4.57223356e-01f, -4.88213629e-01f, -3.79070789e-01f, -1.12969674e-01f, -3.03438932e-01f, -3.08832884e-01f, -4.03616518e-01f, -1.74570635e-01f, -3.80537152e-01f,
  3.54986042e-01f, -4.99017537e-01f, -4.20713611e-02f, -1.24422945e-01f, -3.38621549e-02f, -6.52265698e-02f, -2.82217246e-02f, -1.98639452e-01f, -1.62167998e-03f, 7.26561323e-02f,
  -1.04865700e-01f, -4.03221324e-02f, -1.26936153e-01f, 1.24522611e-01f, -9.61368680e-02f, 1.18963614e-01f, 4.35706303e-02f, -5.13837971e-02f, 1.41195029e-01f, 3.20845574e-01f,
  3.30256969e-01f, -6.33438677e-02f, 8.73337165e-02f, 1.56573713e-01f, 1.26369089e-01f, -1.61291748e-01f, 1.42832592e-01f, -4.68295105e-02f, -1.16019398e-01f, 6.80629909e-02f,
  5.27438596e-02f, 5.59991337e-02f, -4.67666015e-02f, -4.85705175e-02f, 1.09538615e-01f, -1.22025862e-01f, -1.46860071e-02f, 6.19721562e-02f, -4.47254963e-02f, 1.49972394e-01f,
  8.32979456e-02f, 2.32056715e-02f, -9.77815837e-02f, -8.84890109e-02f, -7.72833154e-02f, -5.15520200e-02f, -3.46151479e-02f, 1.41929552e-01f, 6.43264502e-02f, -1.07726477e-01f,
  -1.31213516e-01f, -3.25397849e-02f, -8.14356506e-02f, 9.30674449e-02f, -4.40996587e-02f, -1.04631400e-02f, 1.88534614e-02f, 1.32531568e-01f, 2.69929990e-02f, -2.38327291e-02f,
  1.90539464e-01f, -1.88370302e-01f, -9.94601287e-04f, 5.55504598e-02f, -1.79624811e-01f, -9.96153918e-04f, -1.10871762e-01f, -1.30315900e-01f, -8.28004703e-02f, 1.30827036e-02f,
  3.07563208e-02f, 3.59304361e-02f, 2.72204597e-02f, 1.95868850e-01f, -5.45895398e-02f, 1.81361102e-05f, 9.00971740e-02f, -1.57339890e-02f, 6.69749528e-02f, 1.75640643e-01f,
  2.99323976e-01f, 1.42882228e-01f, 1.65558323e-01f, 1.93681329e-01f, 6.47363514e-02f, -1.41399577e-01f, 2.18968883e-01f, 2.09243849e-01f, -6.67088479e-02f, 2.12245360e-01f,
  -3.16247731e-01f, -3.99840295e-01f, -2.20957741e-01f, -1.18919630e-02f, 1.33910850e-01f, -2.16648072e-01f, -4.36841458e-01f, -3.65970522e-01f, -1.47533044e-01f, -2.87124097e-01f,
  -2.53265072e-02f, 2.62920886e-01f, -3.03534344e-02f, 1.29439026e-01f, -2.67148837e-02f, -2.75290340e-01f, 6.91325739e-02f, 2.70699650e-01f, 2.91223377e-01f, 3.43944579e-01f,
  2.30778337e-01f, 2.89708167e-01f, 2.20703632e-01f, 2.38015398e-01f, 2.30254769e-01f, 1.55137166e-01f, -8.05595070e-02f, 1.48319006e-01f, -1.60184652e-02f, 1.87966317e-01f,
  -2.57610857e-01f, -2.49570936e-01f, -2.99342070e-03f, 1.68651313e-01f, 1.70390353e-01f, 1.93872545e-02f, 1.33426309e-01f, 1.67807862e-01f, 1.21125072e-01f, 6.92324201e-03f,
  1.63753793e-01f, 2.95221712e-02f, 1.05627984e-01f, -1.05633140e-02f, -2.05326527e-02f, -1.15907118e-01f, 6.41797781e-02f, -1.13181278e-01f, -1.01125814e-01f, 2.14256532e-02f,
  2.73954600e-01f, 2.14535609e-01f, -1.29664838e-01f, -8.81937444e-02f, -7.22474009e-02f, 1.96662039e-01f, -7.96058401e-03f, 4.48914506e-02f, -1.90960512e-01f, -7.81799704e-02f,
  7.68446624e-02f, 1.52005136e-01f, -9.24514458e-02f, -1.03529990e-01f, 4.80990857e-02f, 3.54200229e-02f, 9.10563022e-03f, -2.90905815e-02f, -1.17433868e-01f, -1.69222243e-02f,
  -1.80367939e-02f, -4.26616408e-02f, 4.12007496e-02f, -5.65478206e-02f, 4.64603379e-02f, 1.87850352e-02f, 5.95928356e-02f, 8.07854906e-02f, 2.73548514e-02f, -5.39645851e-02f,
  -1.23108111e-01f, -1.71323568e-01f, -1.97324418e-02f, -4.80771661e-02f, -9.26829278e-02f, -4.16583233e-02f, 2.78963372e-02f, 5.16873971e-02f, 1.40305445e-01f, -6.74931109e-02f,
  -1.36851683e-01f, 9.20203403e-02f, -2.10164443e-01f, 1.06680179e-02f, -9.68713239e-02f, 8.59012008e-02f, 5.48480414e-02f, -1.27184074e-02f, -9.74453166e-02f, -4.45512719e-02f,
  -6.44285455e-02f, -1.74687847e-01f, -7.25219771e-02f, 5.57511626e-03f, -4.95682880e-02f, -2.58920401e-01f, -1.22661993e-01f, -1.03135802e-01f, -1.06934264e-01f, 2.46507693e-02f,
  -1.40211955e-01f, -1.27248466e-01f, -2.57612199e-01f, -3.11569721e-01f, -1.31779537e-01f, -1.34362057e-01f, -6.23393469e-02f, -1.15585156e-01f, -2.86568612e-01f, -3.14548880e-01f,
  7.61701941e-01f, -2.81995884e-03f, -4.90385413e-01f, 2.04256311e-01f, -1.95533246e-01f, -1.11464493e-01f, -1.80456877e-01f, 1.33802786e-01f, 2.50292450e-01f, 1.66917536e-02f,
  1.42888986e-02f, 3.03017735e-01f, 5.25351763e-02f, -4.19324171e-03f, -1.83918253e-01f, -4.41160083e-01f, -3.99365216e-01f, -3.22806537e-01f, -1.49023056e-01f, 6.28068820e-02f,
  -2.01369892e-03f, -2.04995321e-03f, -6.84668347e-02f, -1.84897985e-02f, -1.80544764e-01f, -1.35614619e-01f, -2.68688589e-01f, -1.74091622e-01f, -4.17735010e-01f, -4.37465638e-01f,
  -5.96318901e-01f, -5.48866056e-02f, -1.80190927e-05f, -1.29590072e-02f, 7.62826111e-03f, 1.42348379e-01f, 4.69532236e-02f, 6.59347400e-02f, 1.36930034e-01f, 1.15500838e-01f,
  -6.29226491e-02f, -6.27637058e-02f, -1.02170981e-01f, -3.81369963e-02f, 1.19137745e-02f, 1.09339528e-01f, 2.30452314e-01f, 1.84157372e-01f, -1.47259189e-02f, -4.14263681e-02f,
  1.26324315e-02f, -1.77776311e-02f, 1.35805190e-01f, 1.92764476e-01f, 7.88932964e-02f, 7.42751360e-02f, -2.33621821e-02f, 1.34157494e-01f, -6.28027245e-02f, 1.72437921e-01f,
  -1.78558588e-01f, 2.10576817e-01f, -1.37099084e-02f, 9.08234566e-02f, 7.60770738e-02f, 1.49142548e-01f, 5.28681912e-02f, 5.30223958e-02f, 6.07868284e-02f, 1.87283382e-01f,
  2.19548284e-03f, -8.58619958e-02f, 7.43508860e-02f, 3.55939046e-02f, -8.88269171e-02f, -7.45137781e-02f, 1.83654241e-02f, 2.21962892e-02f, -1.74483031e-01f, -9.32154581e-02f,
  -6.78585544e-02f, -1.05303995e-01f, -5.53042814e-02f, -1.76066071e-01f, -3.19180191e-02f, 6.65346980e-02f, -1.24365143e-01f, -3.31503451e-02f, -3.92441032e-03f, 1.12216258e-02f,
  1.35188252e-01f, -2.69395739e-01f, -3.07959951e-02f, 4.19802666e-02f, -9.32691842e-02f, 6.19616546e-02f, -9.12346095e-02f, -7.10606575e-02f, -1.10361964e-01f, -3.33985388e-02f,
  -1.23048864e-01f, 4.77152318e-02f, -4.56495285e-02f, -4.26916853e-02f, 9.77625325e-02f, -7.88808055e-03f, 1.78119093e-01f, 1.10365264e-01f, -3.71163227e-02f, -3.95379774e-02f,
  5.94138205e-02f, 2.45973453e-01f, 3.05418372e-01f, 1.73499689e-01f, 6.96680769e-02f, 1.06441878e-01f, 4.02406901e-02f, 2.11355332e-02f, -1.21604204e-01f, 3.11201870e-01f,
  -3.16379666e-01f, -1.28056649e-02f, 5.29677123e-02f, 1.29197434e-01f, 3.01299512e-01f, 2.46658176e-01f, 2.76188493e-01f, 2.69184142e-01f, 1.91220328e-01f, 3.99449915e-02f,
  9.31478571e-03f, -5.36662489e-02f, -5.83851486e-02f, 7.89301563e-03f, -2.86885723e-02f, 1.97201416e-01f, 2.87139446e-01f, 7.74134248e-02f, 6.77934065e-02f, 1.70598906e-02f,
  1.00770764e-01f, 1.83374092e-01f, -4.07628492e-02f, 1.54822901e-01f, 1.79394215e-01f, 1.40007511e-01f, 1.96290821e-01f, 1.35250688e-01f, 1.55242383e-01f, 1.65190399e-02f,
  -2.76052564e-01f, -2.23271009e-02f, -5.65071478e-02f, -7.17865070e-03f, 6.37459904e-02f, 1.64521988e-02f, 6.79378361e-02f, 9.36743468e-02f, 5.31985983e-02f, 3.26955281e-02f,
  1.15592331e-01f, 9.25223455e-02f, -3.44743095e-02f, 1.11438215e-01f, 1.96439520e-01f, 2.47864588e-03f, -1.03595927e-01f, 9.22212005e-02f, 1.01448275e-01f, -9.29755159e-04f,
  7.66619435e-03f, 1.38936937e-02f, 1.56858146e-01f, -3.78701650e-02f, -1.74598750e-02f, 9.17387456e-02f, 3.53161618e-02f, -2.48548221e-02f, 8.65630582e-02f, -4.87948842e-02f,
  1.36899903e-01f, -8.23259354e-02f, -8.39389339e-02f, -2.12445725e-02f, -1.53567776e-01f, -1.67334396e-02f, 9.63501111e-02f, 1.31756783e-01f, 5.31237572e-02f, 1.08564198e-01f,
  1.47602350e-01f, 1.07452273e-02f, 4.54177894e-02f, 1.12232059e-01f, 7.22759813e-02f, 8.84741396e-02f, 6.49516284e-02f, -9.06087831e-02f, 9.24862027e-02f, 2.50333603e-02f,
  -3.02990768e-02f, 1.16968691e-01f, 2.02427134e-01f, -1.90013051e-02f, 1.65196270e-01f, 1.59032211e-01f, 5.40225767e-02f, 7.14198127e-02f, 1.63142070e-01f, 1.60927624e-01f,
  1.46103904e-01f, -9.52698886e-02f, -3.16532493e-01f, -1.60438552e-01f, -2.82099992e-02f, -1.38467243e-02f, -1.29684359e-01f, -3.99082266e-02f, 1.04614653e-01f, 8.96247774e-02f,
  3.99943218e-02f, -1.24822170e-01f, -5.64798303e-02f, 5.29613998e-03f, 7.55396811e-03f, -5.15115112e-02f, -1.92551687e-01f, -7.26972446e-02f, 8.42728168e-02f, 8.88390392e-02f,
  -7.91512206e-02f, 8.70766491e-02f, -2.43384857e-02f, -3.11141964e-02f, 2.44044326e-02f, 5.49099669e-02f, 1.86931470e-03f, -6.38744049e-03f, 1.01978378e-03f, 1.00689732e-01f,
  -4.45978820e-01f, 4.89897996e-01f, 1.80596679e-01f, -3.58721852e-01f, 1.52463824e-01f, 4.16976631e-01f, 6.40923560e-01f, 1.05577223e-01f, -2.36934245e-01f, 8.01902264e-02f,
  6.08035177e-02f, -3.14876676e-01f, -1.89631999e-01f, -8.76927823e-02f, -1.04324874e-02f, 3.77874643e-01f, 1.84548542e-01f, -1.42933890e-01f, -1.99643418e-01f, 3.37653735e-04f,
  2.83341948e-02f, -1.31427616e-01f, -2.69003630e-01f, -1.05482996e-01f, 2.84463875e-02f, -2.08586425e-01f, 1.71270296e-01f, 3.69057432e-02f, 3.14412534e-01f, 5.97465672e-02f,
  -2.60291904e-01f, 1.65863991e-01f, -2.85038382e-01f, -2.14394793e-01f, 7.29198754e-02f, -2.03730568e-01f, -2.39354018e-02f, -1.64862990e-01f, -7.56048597e-03f, -1.97635777e-02f,
  3.91558446e-02f, -7.49593377e-02f, -4.36654463e-02f, -1.10910805e-02f, -4.47134636e-02f, 2.18457039e-02f, 3.69797312e-02f, -4.25361805e-02f, -1.11795820e-01f, 1.14867941e-01f,
  1.55731782e-01f, 2.00038716e-01f, 1.26165777e-01f, 1.79035738e-01f, 1.69894651e-01f, -1.93427712e-01f, 2.10049823e-01f, 1.59059659e-01f, 8.33925307e-02f, -9.03069675e-02f,
  -1.39147371e-01f, 1.43916264e-01f, 2.03111559e-01f, -2.43910681e-03f, 1.25974089e-01f, 1.30900085e-01f, -6.75691478e-03f, -4.31182906e-02f, -4.92684497e-03f, -2.84847077e-02f,
  -1.10271670e-01f, -4.17216979e-02f, -8.53515938e-02f, -1.98694412e-03f, -1.59387097e-01f, 2.17864532e-02f, 1.24653112e-02f, -5.57357967e-02f, 8.06956515e-02f, 8.31366032e-02f,
  -8.01213756e-02f, 2.30084136e-02f, 2.05841986e-03f, -5.93142174e-02f, 1.18581332e-01f, 2.01526862e-02f, -1.76489383e-01f, -5.27214967e-02f, -9.74183343e-03f, 9.46234539e-02f,
  -4.41105604e-01f, 2.56784081e-01f, -2.97225803e-01f, 2.26202663e-02f, 1.91381928e-02f, 7.90655315e-02f, -1.07918605e-01f, -1.67880114e-02f, -2.80460878e-03f, -8.47456455e-02f,
  1.37150809e-01f, -7.03463182e-02f, 1.02076605e-02f, -1.78810377e-02f, -1.73451826e-01f, -4.77910303e-02f, 4.05527055e-02f, -1.43502697e-01f, -5.97572178e-02f, 3.38012315e-02f,
  1.71568960e-01f, -8.50471109e-02f, -3.80515635e-01f, -1.65071175e-01f, -1.41976640e-01f, -2.60316163e-01f, -6.51883930e-02f, 2.84675546e-02f, 9.30532813e-02f, -4.20214161e-02f,
  -1.02845863e-01f, -2.21962795e-01f, -2.26378709e-01f, 1.63823530e-01f, 3.03696781e-01f, 2.13789999e-01f, 1.82662278e-01f, 2.03983843e-01f, 2.88829446e-01f, 1.60472572e-01f,
  9.79733318e-02f, 3.64776552e-01f, 3.24302614e-01f, 1.94099754e-01f, 2.96852767e-01f, 2.18115523e-01f, 2.85202116e-01f, 8.82020444e-02f, 1.02851756e-01f, 1.37856945e-01f,
  1.85692221e-01f, 4.21322249e-02f, -2.02903390e-01f, -4.72410917e-02f, 4.94346805e-02f, 1.78286031e-01f, 1.80795547e-02f, -8.94898176e-02f, -4.17570537e-03f, -2.96936333e-02f,
  -7.08407983e-02f, -1.59646213e-01f, 3.06556243e-02f, 2.35241000e-02f, -2.20723793e-01f, -1.85417444e-01f, -1.78705119e-02f, -1.59173042e-01f, -1.86592981e-01f, -1.27608899e-03f,
  -1.57491356e-01f, -1.58487946e-01f, 8.59919377e-03f, -7.49030784e-02f, -1.77197054e-01f, -1.92175910e-01f, -1.47357836e-01f, -1.71354637e-02f, 6.92821816e-02f, -5.39503209e-02f,
  9.75568406e-03f, 1.88828688e-02f, 8.88046026e-02f, 1.82044774e-01f, 1.87219054e-01f, 1.15056567e-01f, -9.09265578e-02f, -3.87710780e-02f, 7.25836605e-02f, -6.18582070e-02f,
  1.18176699e-01f, 8.04394484e-02f, 5.33269383e-02f, 1.72421053e-01f, 1.85208797e-01f, -6.18395768e-02f, 4.72046956e-02f, 1.32437050e-01f, 1.68268666e-01f, 1.16035007e-02f,
  -3.93908657e-02f, 1.93871453e-01f, 6.64930642e-02f, 6.37773871e-02f, 5.16626947e-02f, -1.23257279e-01f, -1.22299239e-01f, 3.44244540e-02f, -8.87213275e-02f, -3.66217550e-03f,
  1.90870855e-02f, -9.23970193e-02f, -2.49518678e-01f, -4.66830581e-02f, -3.44946943e-02f, 8.46496299e-02f, 4.18628901e-02f, 5.76233454e-02f, -9.84075852e-03f, -1.63728490e-01f,
  2.38275364e-01f, 3.32688510e-01f, 1.40197769e-01f, -6.57846685e-03f, -1.64683908e-01f, -1.57767370e-01f, 1.94392598e-03f, -1.51093394e-01f, -1.47202700e-01f, -5.15760891e-02f,
  -1.43181751e-04f, -2.08696306e-01f, -8.96560401e-02f, -3.71583290e-02f, -6.04806542e-02f, -6.94807200e-03f, -8.67434889e-02f, 1.03787780e-02f, -4.46772436e-03f, -5.78471983e-04f,
  -2.67161373e-02f, 2.31039122e-01f, 1.55716434e-01f, 2.43998826e-01f, 2.62792587e-01f, 2.03575954e-01f, 6.38329685e-02f, 5.89089245e-02f, 1.21977188e-01f, 3.48138474e-02f,
  -1.12668246e-01f, -6.85751438e-01f, -5.01583405e-02f, -3.49784017e-01f, -2.16829643e-01f, -1.47891760e-01f, -5.37918270e-01f, -9.46109593e-02f, -2.83055007e-02f, -5.47405541e-01f,
  -1.30667105e-01f, 4.03983444e-01f, 2.88847804e-01f, 3.08316320e-01f, 3.19520086e-01f, -5.64640641e-01f, -3.04967135e-01f, 3.30400765e-01f, 5.95945656e-01f, 1.17893271e-01f,
  -2.62967169e-01f, -1.26769140e-01f, 2.65493035e-01f, 3.48664336e-02f, -5.28899670e-01f, -3.40277068e-02f, -3.68384600e-01f, -2.20532700e-01f, -2.46452168e-01f, -6.18698299e-01f,
  -2.35816106e-01f, -3.78806330e-02f, 3.24356407e-01f, 3.01159263e-01f, -1.51612282e-01f, 9.45089832e-02f, -3.84468623e-02f, 2.88260430e-02f, 1.13598175e-01f, -5.35691455e-02f,
  -4.84118871e-02f, 2.24481195e-01f, 2.14786232e-02f, -1.59127563e-02f, -1.98694393e-01f, 6.22776411e-02f, -2.71545779e-02f, 1.79104790e-01f, 7.17136934e-02f, -9.33232158e-02f,
  -2.49883607e-01f, -1.38986349e-01f, 4.55509350e-02f, -1.40507758e-01f, 1.49135247e-01f, 1.26733139e-01f, -9.24444795e-02f, -3.94471362e-02f, 8.92217159e-02f, -5.99910140e-01f,
  -1.70270130e-01f, -3.93975824e-02f, -1.39888946e-03f, 7.10325539e-02f, 3.12615521e-02f, -8.01426321e-02f, 9.19547956e-03f, -3.01534142e-02f, 1.35025084e-01f, -7.95836449e-02f,
  5.74998148e-02f, -3.60319428e-02f, 1.38880163e-01f, -1.20778851e-01f, 4.38861437e-02f, -7.07005188e-02f, -1.43353045e-01f, -1.89671487e-01f, -1.14227226e-03f, 3.61048952e-02f,
  1.00200802e-01f, -1.45943016e-02f, -1.54547608e-02f, 4.14926745e-02f, 6.47168383e-02f, 8.24433472e-03f, 1.43175572e-02f, 6.46141693e-02f, -4.15440612e-02f, -5.94757646e-02f,
  4.96890843e-02f, 3.64332199e-01f, -2.63050109e-01f, 9.50634554e-02f, -8.36641267e-02f, 2.47761738e-02f, -4.96242121e-02f, 9.47737619e-02f, 1.01617336e-01f, -3.16791497e-02f,
  -2.37929774e-03f, -6.11054748e-02f, -1.58707395e-01f, -1.76057070e-02f, -7.68303080e-03f, 1.82638779e-01f, -1.35449946e-01f, -7.15789124e-02f, 1.39640331e-01f, -1.37793362e-01f,
  -9.63088647e-02f, -8.62654373e-02f, 2.72529712e-03f, -4.26992252e-02f, -1.00106083e-01f, 1.10524528e-01f, -1.49523690e-01f, -2.39230439e-01f, 9.87589508e-02f, -6.18204057e-01f,
  1.72609672e-01f, -4.10757810e-02f, -2.80770123e-01f, -3.99055704e-03f, 2.02730931e-02f, -1.71673372e-01f, -3.61198306e-01f, -2.79547453e-01f, 3.50820087e-02f, -3.55307274e-02f,
  2.17165858e-01f, 3.95805597e-01f, 1.00174919e-01f, -2.96885967e-02f, -4.12535846e-01f, -5.76847434e-01f, -6.03455484e-01f, -3.89734983e-01f, -1.06057540e-01f, 1.29842937e-01f,
  2.24069595e-01f, -1.80304907e-02f, -1.54671699e-01f, -1.05687767e-01f, 1.95366919e-01f, 2.26467863e-01f, -1.31001219e-01f, 5.47126010e-02f, -6.62835538e-02f, 3.41385491e-02f,
  1.38000652e-01f, -3.63647453e-02f, -4.32088971e-02f, -1.37137398e-02f, 1.69906300e-02f, 2.77222432e-02f, -7.49501735e-02f, -2.08704993e-01f, 8.17984110e-04f, -1.36872068e-01f,
  1.26747638e-01f, 1.39245605e-02f, 1.44962268e-03f, 3.51370238e-02f, -1.63333297e-01f, -8.14000443e-02f, -2.45111883e-01f, -2.18100265e-01f, -2.36836165e-01f, -6.10452704e-02f,
  2.94019636e-02f, 4.14771736e-02f, -1.12534836e-01f, -1.12857491e-01f, -1.83700472e-01f, 4.34418395e-02f, 2.39289869e-02f, 6.14552870e-02f, -1.33735865e-01f, 6.10710606e-02f,
  -2.76377611e-02f, -1.32449819e-02f, 6.77239196e-03f, 9.53680370e-03f, 6.29933625e-02f, -3.93194444e-02f, 3.00864540e-02f, -8.43798518e-02f, 9.56597831e-03f, -1.65226646e-02f,
  4.38960921e-03f, -5.16003892e-02f, 3.34499665e-02f, -1.25213131e-01f, -3.13995369e-02f, -4.40313108e-02f, -3.39814648e-02f, -1.09259993e-01f, -5.90900220e-02f, -7.23321512e-02f,
  -4.69136909e-02f, -4.35172096e-02f, -1.38261542e-03f, -5.26837483e-02f, -1.29565969e-01f, -8.38095248e-02f, -8.20674282e-03f, 7.41971284e-02f, 9.92406532e-02f, -7.86979571e-02f,
  2.52458453e-01f, -1.42206639e-01f, 1.47018015e-01f, -9.93727818e-02f, -8.89444202e-02f, 5.18740565e-02f, 8.09693262e-02f, -2.02417806e-01f, 5.44823371e-02f, 1.23276427e-01f,
  -1.72719527e-02f, 5.94546013e-02f, -5.14832735e-02f, -9.19093378e-03f, -5.81760220e-02f, 3.39005366e-02f, -9.34011340e-02f, 6.10676501e-03f, -1.77652910e-01f, 2.85682604e-02f,
  -2.74175644e-01f, -2.63341129e-01f, 3.01099624e-02f, 7.08052376e-03f, -5.29907607e-02f, 1.13094896e-01f, 6.11822382e-02f, 1.53505847e-01f, -8.88008326e-02f, -2.63251923e-03f,
  6.29365221e-02f, -4.48755994e-02f, -6.86528534e-03f, -1.45287350e-01f, -1.73504710e-01f, -2.40550309e-01f, -3.83512139e-01f, -2.24793702e-01f, -1.94844216e-01f, -1.50602713e-01f,
  1.17534928e-01f, 3.30073565e-01f, 8.03336427e-02f, -2.23784268e-01f, -2.87179291e-01f, -4.77695316e-01f, -4.86376286e-01f, -3.90035570e-01f, -2.99101353e-01f, -3.76178324e-01f,
  -3.59451801e-01f, -4.43993866e-01f, -3.89247835e-01f, -2.12142721e-01f, -1.52138546e-01f, -4.11227979e-02f, -1.43136218e-01f, -1.95485458e-01f, -2.12569728e-01f, -1.14114970e-01f,
  1.67365506e-01f, 2.47907147e-01f, -2.94783525e-03f, -7.47568980e-02f, 2.15993263e-02f, 5.29743209e-02f, -5.78342052e-03f, -5.61078154e-02f, 4.14332226e-02f, 7.91287348e-02f,
  7.91853666e-02f, 9.02135596e-02f, 6.03220761e-02f, 1.12917908e-01f, -1.04978815e-01f, -3.33006382e-02f, -1.58769295e-01f, -1.40443876e-01f, -1.51732102e-01f, -1.60793457e-02f,
  6.85345335e-03f, -1.41654909e-02f, 1.43114433e-01f, 8.23151618e-02f, 1.06974885e-01f, 4.13653553e-02f, 6.54769167e-02f, 8.21471363e-02f, 2.60821003e-02f, 4.35970165e-03f,
  -2.59869367e-01f, 1.27598777e-01f, -1.59595832e-02f, -8.85516312e-03f, -6.70481622e-02f, -1.92133188e-02f, -1.46999070e-02f, -4.72121835e-02f, 4.81343307e-02f, -1.51833147e-01f,
  -6.12017997e-02f, 1.16234250e-01f, 6.60037398e-02f, -1.05886914e-01f, -4.48795082e-03f, -4.69130054e-02f, -2.06156950e-02f, 2.14192327e-02f, 1.00583345e-01f, -5.68080172e-02f,
  -1.23848999e-02f, -3.51351388e-02f, 2.52734870e-02f, -1.09921224e-01f, 5.08326590e-02f, 7.57519379e-02f, 1.05693199e-01f, 1.00825578e-02f, 1.03522412e-01f, 4.28108796e-02f,
  2.34778933e-02f, -4.12352290e-03f, -2.74357907e-02f, 6.99244887e-02f, -2.55406890e-02f, -2.42980104e-02f, 1.05058409e-01f, -2.92919688e-02f, 3.28502394e-02f, 1.11212485e-01f,
  1.04801238e-01f, 7.96823576e-02f, -3.89526002e-02f, -8.63367468e-02f, 9.38244909e-03f, -7.03603327e-02f, -1.92149490e-01f, -7.84612074e-02f, 7.59224743e-02f, 8.72031972e-02f,
  -1.04579747e-01f, 1.40064787e-02f, 6.10780977e-02f, 6.48597674e-03f, -2.67754998e-02f, -1.13471982e-03f, 9.69109684e-02f, 7.98936337e-02f, 8.07465613e-02f, -2.12282032e-01f,
  6.91654563e-01f, 8.93800035e-02f, 3.06822686e-03f, 2.19473720e-01f, -3.06230873e-01f, -3.40107173e-01f, -3.44084352e-01f, -1.31701171e-01f, 2.16786057e-01f, 2.30451852e-01f,
  -4.00274694e-02f, 1.91235662e-01f, 9.97969508e-02f, 1.69101879e-01f, 1.82808623e-01f, 1.27075866e-01f, 1.16874933e-01f, 2.84341365e-01f, 1.22857049e-01f, 1.55698329e-01f,
  2.28650898e-01f, 2.62395978e-01f, 3.40037972e-01f, 2.17524454e-01f, 2.33476609e-01f, 1.79516748e-01f, 7.04070479e-02f, 2.86603868e-02f, 3.55484523e-02f, 3.93294096e-01f,
  2.70727605e-01f, 4.10972275e-02f, -1.64695993e-01f, -7.81464204e-02f, -1.19177945e-01f, 1.90184563e-01f, 1.18017374e-02f, 2.44533364e-02f, -2.82460488e-02f, 2.09380686e-01f,
  -9.06063318e-02f, 2.45086681e-02f, -4.10855077e-02f, -3.11614387e-02f, 5.58637418e-02f, -3.22048031e-02f, 3.35412323e-02f, 9.37761068e-02f, 4.72511351e-02f, 6.25458267e-03f,
  -9.83760506e-02f, -1.60012439e-01f, -2.18602702e-01f, -2.87914455e-01f, 9.72000789e-03f, -2.90766358e-02f, -3.07634696e-02f, 7.61706829e-02f, -6.01447560e-02f, 1.85864240e-01f,
  -1.03169046e-01f, -1.16460975e-02f, 9.78854392e-03f, 5.21031283e-02f, 1.77450627e-01f, 3.78406383e-02f, 7.83769712e-02f, 7.45682493e-02f, 9.52079892e-02f, 6.28912672e-02f,
  5.49111748e-03f, 1.13258287e-01f, -1.65968295e-02f, 2.81780446e-03f, 6.69396818e-02f, 3.67491134e-02f, -8.91916570e-05f, 1.29021332e-01f, -9.79995076e-03f, -2.80844364e-02f,
  1.74164567e-02f, -1.16532117e-01f, 6.12051859e-02f, -1.31512955e-02f, 1.64634399e-02f, 1.09802261e-02f, 8.88852179e-02f, 9.30595100e-02f, -3.84603888e-02f, 8.11858848e-02f,
  -1.28986403e-01f, -2.93711394e-01f, 2.19334796e-01f, 3.42114940e-02f, -3.43130566e-02f, -6.42628074e-02f, 2.43130140e-02f, -1.27850398e-02f, -6.51676804e-02f, 9.14799646e-02f,
  -1.21083148e-01f, 6.38781814e-04f, -6.37356788e-02f, -5.35066910e-02f, -5.19934520e-02f, -2.45272312e-02f, -8.30079895e-03f, -1.04495808e-01f, -2.73764078e-02f, -1.74548358e-01f,
  -1.22343719e-01f, -2.10419163e-01f, -2.32046247e-01f, -2.76531219e-01f, -1.69782564e-01f, -3.79947275e-02f, -1.87763110e-01f, -1.03059106e-01f, -1.39353067e-01f, -4.24957797e-02f,
  2.61695236e-01f, 3.24024260e-01f, 2.33737841e-01f, 1.70362979e-01f, 1.61216799e-02f, 7.43202195e-02f, 2.15468422e-01f, 2.22717583e-01f, 2.82811433e-01f, 1.47139624e-01f,
  1.01220220e-01f, 2.23104417e-01f, 2.77348250e-01f, 1.97370499e-01f, 2.86072552e-01f, 2.16569752e-01f, 2.10735366e-01f, 2.12307394e-01f, 5.53241670e-02f, 1.01468727e-01f,
  3.75721902e-02f, 6.17058761e-02f, 1.19215228e-01f, 2.24242255e-01f, 1.48851871e-01f, 6.42327070e-02f, 1.07207626e-01f, -3.06618139e-02f, 3.85841988e-02f, 2.54060268e-01f,
  -1.37891889e-01f, 4.49492745e-02f, 1.11145332e-01f, -8.75300728e-03f, -7.62650669e-02f, 6.05460033e-02f, 3.76545340e-02f, -1.10011287e-01f, -2.92143263e-02f, 4.61560301e-03f,
  -3.74587886e-02f, 1.89595409e-02f, 2.45420225e-02f, -1.20513543e-01f, -1.89888671e-01f, -2.24480063e-01f, -1.32388528e-02f, 5.96920550e-02f, 1.11726321e-01f, 4.11360897e-02f,
  4.70218509e-02f, -8.32762197e-02f, -1.56021327e-01f, -9.69373658e-02f, 8.33697170e-02f, -8.37495923e-02f, -3.46345529e-02f, -1.19272806e-01f, -1.13534786e-01f, -7.63291270e-02f,
  1.80188268e-01f, 1.58357799e-01f, 5.16866483e-02f, -1.34378612e-01f, -5.23979664e-02f, -1.35390013e-01f, -1.38146564e-01f, 2.81908158e-02f, 3.85210128e-03f, -1.02117784e-01f,
  -8.76430124e-02f, -6.21629469e-02f, 6.29621744e-02f, -1.00228876e-01f, 1.00596622e-01f, 1.24364309e-02f, 6.27664253e-02f, -8.48280191e-02f, -2.11994760e-02f, -4.89127496e-03f,
  -4.64996584e-02f, 4.24201190e-02f, -6.78908778e-03f, -1.72037520e-02f, -1.34295911e-01f, -4.30670334e-04f, 2.46449579e-02f, 1.43006416e-02f, 1.49690127e-02f, 7.37956837e-02f,
  7.00847134e-02f, 1.99365392e-02f, 1.28333241e-01f, 2.84869879e-01f, -4.12188433e-02f, -4.28927504e-02f, 4.02883291e-02f, -2.13382207e-02f, -1.15739152e-01f, -2.67584343e-02f,
  -1.03714682e-01f, 1.25400335e-01f, -5.70480712e-02f, -7.44710416e-02f, -2.48238832e-01f, -2.00185329e-01f, -1.61873475e-02f, 1.18113197e-01f, 1.74647480e-01f, 8.46261904e-02f,
  1.20994307e-01f, -1.19713917e-01f, -1.64790880e-02f, 4.54620160e-02f, 6.98475689e-02f, 4.66380604e-02f, -8.69369060e-02f, -1.00632302e-01f, -1.16254024e-01f, -2.01977775e-01f,
  -5.99034071e-01f, -2.06512362e-01f, 1.30842507e-01f, 3.02229971e-01f, 1.86256617e-01f, -3.73077160e-03f, -8.04473162e-02f, -7.63505278e-03f, 1.06088437e-01f, -5.02022803e-02f,
  -1.90147176e-01f, -3.61815169e-02f, 1.58009261e-01f, 3.61656509e-02f, 5.25908824e-03f, 2.18005359e-01f, 4.92006302e-01f, 2.22175002e-01f, -6.94505721e-02f, -2.02418655e-01f,
  1.19542919e-01f, 1.75808743e-01f, 1.40066736e-03f, 1.48342207e-01f, 1.78098641e-02f, 2.42637351e-01f, 3.26535493e-01f, 7.32199699e-02f, -4.13693860e-02f, -6.31688535e-02f,
  -6.03834391e-01f, -4.53604281e-01f, 2.65689462e-01f, 7.18598487e-04f, -1.66350365e-01f, -1.55965105e-01f, -1.39976636e-01f, -4.08699736e-02f, -1.13783509e-01f, -1.30542591e-01f,
  -4.35004309e-02f, -1.13693655e-01f, -2.10761931e-02f, 6.44630194e-02f, 5.68031967e-02f, -1.30383864e-01f, 1.18681639e-01f, -1.69495847e-02f, -6.35361820e-02f, -3.25117081e-01f,
  -2.56880950e-02f, -2.40182683e-01f, -3.49356890e-01f, 2.68806051e-02f, -1.14788689e-01f, 1.47630259e-01f, -2.00459540e-01f, -2.72303104e-01f, -1.64666802e-01f, -3.28636020e-01f,
  -1.93364531e-01f, -2.78673861e-02f, 1.14919227e-02f, 8.75912160e-02f, 8.08410794e-02f, 3.12369112e-02f, -8.60328600e-02f, -3.45893465e-02f, 6.21084310e-02f, -2.26301737e-02f,
  -4.56450880e-03f, -5.91493491e-03f, -7.46507570e-02f, -1.40304074e-01f, 7.77153894e-02f, -4.45217155e-02f, -7.85370916e-02f, 9.22946483e-02f, -2.93565020e-02f, -3.99325080e-02f,
  -2.24893820e-02f, -1.23329833e-02f, 1.60269320e-01f, -3.11945789e-02f, -5.46905175e-02f, 5.58927208e-02f, 5.43505512e-02f, 1.86977293e-02f, 1.38359405e-02f, -1.19742945e-01f,
  1.84809357e-01f, 3.02243680e-01f, -2.23417789e-01f, -4.65571620e-02f, -1.40612870e-01f, 1.09442860e-01f, 1.66972131e-02f, -9.62187722e-02f, -4.06115726e-02f, -1.97473422e-01f,
  -7.64249116e-02f, -4.00542207e-02f, 1.14420347e-01f, 8.05429220e-02f, -2.21960302e-02f, -1.82284485e-03f, 7.98202399e-03f, 5.81858158e-02f, 1.64974764e-01f, -1.26882643e-01f,
  2.73139358e-01f, -7.50437602e-02f, -2.08138078e-01f, -2.44576856e-02f, -1.03273705e-01f, 8.91477391e-02f, -2.17550360e-02f, -6.30460456e-02f, -4.83271256e-02f, -1.57318726e-01f,
  6.51213944e-01f, 7.68666342e-02f, 4.60699767e-01f, 1.27237216e-01f, 3.99581790e-02f, 1.68938324e-01f, 1.76330596e-01f, 9.65264812e-02f, -1.66981846e-01f, -1.11984581e-01f,
  -8.24102759e-02f, -1.23095006e-01f, -1.13071494e-01f, -8.26923177e-02f, 2.22232014e-01f, -3.12768068e-04f, -3.84410471e-02f, 1.86004028e-01f, 2.39730299e-01f, 8.75185058e-02f,
  -3.32055986e-01f, 3.56614329e-02f, 1.55201241e-01f, 8.24471861e-02f, -1.70657486e-01f, -1.23355173e-01f, 4.31625731e-02f, 4.92350571e-02f, -4.69492860e-02f, -2.48424008e-01f,
  1.06573358e-01f, 2.78350562e-01f, -2.79363304e-01f, -1.64000824e-01f, 5.35419323e-02f, -7.50615001e-02f, 2.67828088e-02f, -2.91256029e-02f, -6.47272095e-02f, -1.28238450e-03f,
  -8.88579264e-02f, 5.30232377e-02f, 1.22953244e-01f, 4.08329703e-02f, 9.33974907e-02f, -5.78834750e-02f, -3.39416950e-03f, 1.50695756e-01f, 1.51805282e-01f, -2.83328295e-02f,
  -2.06652865e-01f, 1.14237824e-02f, 2.60111034e-01f, 2.62521338e-02f, 6.73747957e-02f, 3.93488258e-02f, -1.44956326e-02f, 8.92811790e-02f, 1.27586305e-01f, -5.14269099e-02f,
  -5.95619865e-02f, 2.25107372e-02f, 1.19040482e-01f, -3.54083553e-02f, 1.67603660e-02f, 2.91705430e-02f, 4.91768979e-02f, 7.44398534e-02f, 5.71596697e-02f, 6.15765415e-02f,
  2.38650277e-01f, 1.88534111e-01f, 7.29188919e-02f, 4.87958603e-02f, -1.09730124e-01f, 9.06053483e-02f, 6.93203509e-02f, -3.95513102e-02f, 2.58175042e-02f, 3.31217200e-02f,
  4.43121083e-02f, -3.17906886e-02f, 1.13422118e-01f, 2.10898504e-01f, 3.05532701e-02f, 1.43516570e-01f, 1.99383441e-02f, 1.71893998e-03f, 6.02519177e-02f, -7.23986924e-02f,
  -1.48575455e-01f, 2.49607980e-01f, -9.03709754e-02f, -9.15053263e-02f, -1.44059258e-02f, -1.48554053e-02f, -6.14952482e-02f, -1.29978269e-01f, -2.00346321e-01f, -1.76381454e-01f,
  1.71917565e-02f, 4.86677475e-02f, 9.41037908e-02f, -5.33124395e-02f, -5.74479252e-02f, -1.19975619e-01f, -3.29320543e-02f, -1.34413624e-02f, -1.00506097e-01f, -1.14415571e-01f,
  -8.92627835e-02f, -3.68800946e-02f, 8.00288469e-02f, -6.85099736e-02f, -1.62252188e-01f, -8.95970687e-02f, -1.09955043e-01f, -8.79472718e-02f, 1.23214282e-01f, -1.74867958e-01f,
  -2.68660069e-01f, 8.49818885e-02f, -3.86458933e-02f, 1.62049249e-01f, 4.26762968e-01f, 4.36466262e-02f, -1.37185469e-01f, -2.74605066e-01f, 1.10834263e-01f, 1.75200686e-01f,
  1.23820618e-01f, 1.17602341e-01f, 1.87633723e-01f, -8.23176280e-02f, -3.15902144e-01f, 8.39548633e-02f, 1.93202183e-01f, -1.46135598e-01f, -4.80353981e-01f, -2.70182908e-01f,
  1.02929048e-01f, 1.57646090e-03f, -3.45975280e-01f, -2.04961643e-01f, 2.27319375e-01f, 1.16457023e-01f, 1.51606873e-01f, 1.85204700e-01f, 1.41308084e-01f, 3.80314022e-01f,
  1.15887508e-01f, -1.11123525e-01f, -4.22986187e-02f, 8.61236155e-02f, 2.53170162e-01f, -1.59876019e-01f, -1.68830395e-01f, -4.08371212e-03f, 3.80455852e-02f, -1.18081890e-01f,
  1.19694188e-01f, -1.02084912e-01f, 1.67767182e-01f, -8.54684636e-02f, -7.41228983e-02f, -2.24343315e-01f, -2.33838677e-01f, -3.93080533e-01f, -2.46155143e-01f, -1.73259735e-01f,
  1.55000195e-01f, 5.32539785e-02f, -9.90584716e-02f, -1.43928230e-01f, -1.75838336e-01f, -9.60633531e-02f, -2.14105576e-01f, -2.12073192e-01f, -3.91211599e-01f, -1.47453904e-01f,
  6.29198924e-03f, -6.45158291e-02f, -4.85231372e-04f, -8.45052004e-02f, -7.63610452e-02f, 1.38026819e-01f, 1.60649002e-01f, -4.52074362e-03f, 5.54549210e-02f, 7.16430927e-03f,
  1.62639446e-03f, 1.51860882e-02f, -8.97701904e-02f, 1.59003902e-02f, -4.00086157e-02f, -3.61963082e-03f, 3.87768000e-02f, -5.02747893e-02f, -5.17827384e-02f, -4.06722091e-02f,
  9.87958722e-03f, 6.63579849e-05f, -7.17525184e-03f, -1.63232833e-01f, 5.02084568e-03f, -3.27763297e-02f, 3.47714052e-02f, -3.21846195e-02f, -9.93245840e-02f, -4.14990596e-02f,
  -6.57979250e-02f, -1.48288563e-01f, 1.27515122e-01f, -1.63037151e-01f, 1.15278937e-01f, 4.60713506e-02f, 7.96173960e-02f, 2.40903161e-02f, 5.69261014e-02f, -1.32953942e-01f,
  -1.70469999e-01f, -1.17797419e-01f, 1.25055015e-01f, -8.76834691e-02f, -3.41531932e-02f, 2.90433783e-02f, 1.38355896e-01f, 5.22405095e-02f, -3.60570736e-02f, 8.46771821e-02f,
  9.61899683e-02f, -2.20675126e-01f, -2.84456518e-02f, -3.13934684e-02f, 1.15629941e-01f, -1.22157345e-02f, -5.51608801e-02f, -8.20979849e-02f, -1.94553673e-01f, -2.83067524e-01f,
  3.52791518e-01f, 2.10405096e-01f, -6.35248244e-01f, 5.20063460e-01f, 9.24279243e-02f, -3.35946292e-01f, -2.87726164e-01f, -1.94135368e-01f, 2.89487362e-01f, 2.39595845e-01f,
  2.14066699e-01f, 2.04418421e-01f, 2.45879456e-01f, 6.71798885e-02f, -2.42981404e-01f, -6.73561404e-03f, 7.41860494e-02f, -3.21778983e-01f, -5.28725803e-01f, -3.47335458e-01f,
  2.74364412e-01f, 2.05337152e-01f, 4.14606184e-02f, -1.69205174e-01f, 2.16427982e-01f, 1.01148352e-01f, 1.73525885e-02f, 8.65830556e-02f, -1.21993981e-01f, 9.38271955e-02f,
  -3.52058530e-01f, -3.45825136e-01f, -3.32169592e-01f, 1.82916090e-01f, 5.69438748e-02f, -1.15156457e-01f, -2.03711376e-01f, -2.19277874e-01f, -3.58027667e-02f, -3.88371982e-02f,
  1.00910880e-01f, 1.57801639e-02f, 1.80640027e-01f, -4.98387665e-02f, -3.19044739e-02f, -1.49768144e-01f, -1.23451255e-01f, -3.53110105e-01f, -1.72972143e-01f, -2.82412857e-01f,
  2.47286156e-01f, -1.01130918e-01f, -3.94512266e-01f, -1.97393060e-01f, -3.94075304e-01f, -7.47576132e-02f, -4.12074149e-01f, -4.66176450e-01f, -4.18998241e-01f, -1.26438096e-01f,
  5.78736067e-02f, 1.03843555e-01f, 1.32170901e-01f, -4.74928096e-02f, 8.48563164e-02f, -2.07876842e-02f, -2.51771100e-02f, 4.45825085e-02f, -5.21567767e-04f, -5.33541590e-02f,
  7.31176734e-02f, 4.88912761e-02f, -7.64081255e-02f, 3.01859267e-02f, 1.58121243e-01f, -9.44271535e-02f, -5.28475195e-02f, -7.38110617e-02f, -1.35548458e-01f, -3.43287513e-02f,
  1.83930285e-02f, 2.38267425e-02f, 1.47785798e-01f, -7.16029182e-02f, -2.42387988e-02f, -6.22544698e-02f, -5.01512997e-02f, -7.20078200e-02f, 3.59387919e-02f, 7.82704055e-02f,
  3.70864362e-01f, -6.13743477e-02f, 1.05370961e-01f, -5.70650883e-02f, 3.93486582e-02f, -6.39344081e-02f, 1.65705696e-01f, 2.21744310e-02f, 9.96179879e-02f, -7.70865828e-02f,
  -2.85373867e-01f, 3.46077979e-02f, 9.85094905e-02f, -2.18316149e-02f, -5.60531206e-02f, 7.09321871e-02f, 2.51826704e-01f, 3.32332328e-02f, -3.01727150e-02f, 1.88859217e-02f,
  2.27874666e-01f, 6.61320835e-02f, 1.12768732e-01f, 1.08513482e-01f, 9.26981121e-02f, 1.72819808e-01f, -3.23040225e-02f, -1.02362491e-01f, -8.98887813e-02f, 3.19393903e-01f,
  1.87682122e-01f, 1.24967180e-01f, -3.13651234e-01f, 1.14196427e-01f, 2.04783589e-01f, 5.93495741e-02f, 2.11968049e-01f, 2.38984495e-01f, 2.01984599e-01f, 2.39229515e-01f,
  2.60635674e-01f, 2.35376641e-01f, 7.47438371e-02f, 7.75107765e-05f, 2.29445044e-02f, -1.60290655e-02f, 6.93626329e-03f, -6.70883730e-02f, -6.11804239e-02f, 7.38893896e-02f,
  1.22445926e-01f, 1.33730635e-01f, 8.59999433e-02f, 1.22314980e-02f, -8.30422863e-02f, 4.50711548e-02f, 2.52315085e-02f, 5.01963496e-03f, -6.83749747e-03f, -3.91272247e-01f,
  -4.36021507e-01f, -9.56621096e-02f, -1.93896443e-02f, 6.28251582e-02f, -2.66177729e-02f, 1.70080572e-01f, 7.43870437e-02f, 1.37618735e-01f, 2.11608574e-01f, 1.62538104e-02f,
  -9.73536670e-02f, -1.54254939e-02f, 1.51046768e-01f, 7.11063892e-02f, -3.80452652e-03f, -2.79107485e-02f, 9.02245939e-02f, 5.28024472e-02f, 6.05945438e-02f, 6.09530509e-03f,
  1.54721122e-02f, -3.62603515e-02f, -8.35251585e-02f, 2.93970127e-02f, 3.35089415e-02f, -2.09004451e-02f, -8.22633952e-02f, -1.22768775e-01f, -3.95209640e-02f, -1.78460956e-01f,
  1.11304475e-02f, 5.82088605e-02f, 3.02484110e-02f, 9.29659456e-02f, 1.58579290e-01f, 5.73614500e-02f, 5.72072994e-03f, -1.50965378e-02f, 8.51792749e-03f, 5.30661009e-02f,
  -7.89663717e-02f, -4.20139171e-03f, -1.41496509e-02f, 9.87491682e-02f, 1.40752286e-01f, 7.50678629e-02f, -6.21514879e-02f, 2.11834963e-02f, 6.43013716e-02f, 1.33592695e-01f,
  4.37309593e-03f, -3.95471156e-02f, 1.05878554e-01f, 5.47463037e-02f, 6.16493896e-02f, -3.70874405e-02f, -4.84752655e-02f, 1.12827130e-01f, 1.54688939e-01f, 8.48016441e-02f,
  9.35509056e-02f, 8.06297213e-02f, -1.34869963e-01f, -1.38810843e-01f, -7.48019442e-02f, 2.66546272e-02f, 6.24673674e-03f, -5.53382374e-02f, 5.65338321e-02f, 3.61928791e-02f,
  -7.56938905e-02f, -1.32025152e-01f, -3.13723572e-02f, 4.35438976e-02f, 5.89492917e-02f, 6.47339970e-02f, 4.97965291e-02f, -1.07056640e-01f, -1.11723468e-01f, -1.67406976e-01f,
  2.15896331e-02f, 6.22738190e-02f, -7.52907991e-02f, -7.22807832e-03f, -5.36708497e-02f, -2.25615483e-02f, -2.62938011e-02f, -7.88505673e-02f, -2.98020951e-02f, 1.30738258e-01f,
  -3.74075770e-01f, 3.54377449e-01f, -1.92912236e-01f, -2.89016902e-01f, -1.72939479e-01f, 1.35132566e-01f, 4.15180027e-01f, 7.07298294e-02f, -1.47162080e-01f, 2.53492773e-01f,
  -5.57316542e-02f, -1.83262855e-01f, -1.90854724e-02f, 5.76206744e-02f, 2.30285496e-01f, 4.20018852e-01f, 3.05885643e-01f, -9.60728750e-02f, -2.62674093e-01f, -4.85667363e-02f,
  1.84270337e-01f, -1.72288597e-01f, -2.80248791e-01f, -1.52004346e-01f, -7.02067539e-02f, -1.79934606e-01f, -3.01348831e-04f, -1.41224578e-01f, 1.60334483e-01f, 1.64861917e-01f,
  -4.97125983e-02f, -4.13662195e-01f, -2.29607016e-01f, -3.23859870e-01f, -8.45685776e-04f, -3.76716107e-02f, 1.23042300e-01f, -7.04154149e-02f, 5.12412516e-04f, 3.12460121e-02f,
  -9.63959247e-02f, 6.29522139e-03f, -9.70957801e-02f, -3.65901217e-02f, -1.49015561e-01f, -1.22624956e-01f, -8.32573920e-02f, -8.05185214e-02f, 1.25573799e-02f, -6.59044385e-02f,
  2.38978907e-01f, -1.31936356e-01f, -2.85112798e-01f, -1.68336846e-03f, -4.28756103e-02f, -8.28684196e-02f, -1.22862503e-01f, -1.38093859e-01f, -5.83335795e-02f, -3.84438634e-02f,
  3.23867612e-02f, 8.66366364e-03f, 6.71390817e-02f, -4.17561783e-03f, 9.60074663e-02f, 1.02414578e-01f, 1.77585147e-02f, 6.49805367e-02f, -6.93788007e-02f, -6.76769763e-02f,
  -2.33132578e-02f, 2.40429360e-02f, -5.40476143e-02f, -5.46368957e-02f, -5.69639355e-02f, -9.45169479e-02f, 9.73524079e-02f, 6.44743219e-02f, 2.65517402e-02f, 7.10790381e-02f,
  -7.26486221e-02f, -3.13891955e-02f, -1.31093115e-01f, 5.26082143e-02f, 1.23415515e-01f, 8.90530050e-02f, 2.04939824e-02f, -5.23063913e-02f, -1.80067673e-01f, -1.07163168e-01f,
  -1.80955648e-01f, 2.61390861e-03f, -2.95586996e-02f, 7.36943781e-02f, -6.66482523e-02f, -6.03386797e-02f, 6.67057261e-02f, 2.04539746e-02f, -3.44646275e-02f, 2.58579142e-02f,
  1.87179130e-02f, 1.31173000e-01f, 3.00761033e-02f, -4.40999269e-02f, -1.08152285e-01f, -8.37334432e-03f, 2.50558317e-01f, -1.43551512e-03f, 9.80935544e-02f, 2.87456661e-02f,
  1.53044954e-01f, 7.95630440e-02f, -1.00325122e-01f, 1.21631920e-01f, 1.12829253e-01f, 6.31183968e-04f, -1.25048772e-01f, -7.18122572e-02f, 7.59105086e-02f, 2.43860424e-01f,
  -2.55827218e-01f, 2.75775760e-01f, -5.86930141e-02f, -2.09177047e-01f, 2.61898845e-01f, 4.23081964e-01f, 6.22421741e-01f, 1.48076028e-01f, -9.73308608e-02f, 1.89555913e-01f,
  3.92904222e-01f, 1.10811457e-01f, 6.93910122e-02f, 6.42248392e-02f, 1.96526200e-01f, 1.85228631e-01f, 2.99378708e-02f, -1.45571232e-01f, -6.88653290e-02f, 2.42575631e-01f,
  1.64081782e-01f, -7.47722760e-02f, -1.03589207e-01f, -1.57361358e-01f, -2.62487859e-01f, -7.62594417e-02f, -7.63538182e-02f, 3.91460471e-02f, 2.47258753e-01f, -2.63228387e-01f,
  5.21145873e-02f, 1.60989851e-01f, -3.26640457e-02f, -9.56948474e-03f, 2.41160132e-02f, -1.54969603e-01f, 1.55553333e-02f, -9.46842059e-02f, 3.33418362e-02f, -8.64677429e-02f,
  3.32075842e-02f, 4.62299474e-02f, 9.67293456e-02f, 1.01893879e-01f, 1.98518168e-02f, 1.31396458e-01f, -2.69436967e-02f, -2.12889448e-01f, -3.92406210e-02f, 5.63964322e-02f,
  1.29549474e-01f, 1.37055218e-01f, -5.50147705e-02f, -2.09126482e-03f, -3.78690398e-04f, -5.90475611e-02f, -2.64804170e-04f, -1.54801428e-01f, -5.19101918e-02f, -2.34415650e-01f,
  -5.98400980e-02f, -6.03589565e-02f, -6.51951805e-02f, -5.92611693e-02f, 7.52234757e-02f, -1.57548726e-01f, -6.37941435e-02f, 6.94403350e-02f, 5.91737032e-02f, -4.95094918e-02f,
  4.49572243e-02f, 1.83901973e-02f, -7.79734850e-02f, -8.56762305e-02f, 1.25672733e-02f, 8.11679214e-02f, 6.20665327e-02f, -9.53683443e-03f, 1.03985280e-01f, 9.37843472e-02f,
  -9.94282402e-03f, -9.66409668e-02f, -1.36159971e-01f, -2.93814316e-02f, -3.01432721e-02f, -4.99810055e-02f, -1.17000639e-01f, -5.24181463e-02f, -4.22085710e-02f, 5.81122003e-02f,
  -8.21063519e-02f, 6.07308745e-01f, -7.36783743e-02f, 3.39487265e-03f, -3.72739621e-02f, 7.38125108e-03f, -1.36932911e-04f, -1.68435518e-02f, 1.29176900e-02f, -3.49872112e-02f,
  6.24758340e-02f, -1.32675767e-01f, 9.62427780e-02f, -5.75350821e-02f, -9.67816040e-02f, -1.71912741e-02f, 4.12249342e-02f, -6.44971877e-02f, -9.09404904e-02f, -1.75233498e-01f,
  -1.26481488e-01f, -7.82377198e-02f, -2.08346352e-01f, -2.63771176e-01f, -1.92575738e-01f, -1.37720406e-01f, -2.24667251e-01f, -2.14752212e-01f, -7.20530599e-02f, -2.50976413e-01f,
  -4.61227387e-01f, -4.76664603e-01f, 4.01525795e-01f, -4.69335355e-02f, 3.49657208e-01f, 3.92512858e-01f, 1.11928277e-01f, 1.83269568e-02f, -1.25919217e-02f, -1.21140726e-01f,
  -1.91865861e-01f, -3.41126919e-01f, -3.09765160e-01f, -1.75967455e-01f, -9.07908976e-02f, 2.44172141e-01f, 2.62399554e-01f, 2.00011477e-01f, 2.33803868e-01f, 4.16372903e-02f,
  -1.42150009e-02f, -1.32376820e-01f, -1.57419831e-01f, 7.80016650e-03f, -1.10930666e-01f, -1.78176053e-02f, 9.24111232e-02f, 2.70722434e-02f, 7.08940998e-02f, -7.58603886e-02f,
  4.90776077e-02f, -4.30962622e-01f, 8.06123167e-02f, -2.45298773e-01f, -8.61342549e-02f, -5.65208532e-02f, -8.93696770e-02f, -1.70670435e-01f, -2.10633844e-01f, -1.10772803e-01f,
  -2.14536861e-01f, -1.06302917e-01f, -1.31289661e-01f, -3.91381606e-02f, 2.53604609e-03f, -2.56517567e-02f, -9.33086798e-02f, 8.71054176e-03f, 6.43324992e-03f, -3.08956541e-02f,
  -2.83837188e-02f, 6.14945889e-02f, 1.21136293e-01f, 7.78488368e-02f, 3.05498466e-02f, 6.49721473e-02f, -5.26979528e-02f, -7.92899281e-02f, 8.63154903e-02f, -8.94995108e-02f,
  -3.90140265e-02f, 1.13184646e-01f, -1.01134237e-02f, 1.16471872e-01f, 9.76788178e-02f, 1.44298196e-01f, 1.24172978e-01f, 4.92613157e-03f, 2.51356792e-02f, 1.30617440e-01f,
  1.20489754e-01f, 1.77352071e-01f, 6.46100864e-02f, 2.99718715e-02f, 2.26522200e-02f, 2.77728476e-02f, 4.40969355e-02f, -1.03691533e-01f, -6.87414315e-03f, 2.14598011e-02f,
  7.63523728e-02f, 5.30837737e-02f, 5.44816768e-03f, -4.68790578e-03f, 8.78112465e-02f, 5.30323312e-02f, 1.04594775e-01f, -3.71900313e-02f, 7.91414231e-02f, 5.87555394e-02f,
  1.35830296e-02f, 6.40475005e-02f, 2.93266680e-02f, -6.03832304e-02f, 9.61630326e-03f, -1.20353336e-02f, -6.26118556e-02f, -3.02491756e-03f, -2.68929489e-02f, 5.16668931e-02f,
  7.78587162e-02f, 3.73625359e-03f, 6.61501884e-02f, 1.16451748e-01f, 8.88316333e-02f, 3.38544175e-02f, -6.93181679e-02f, -6.00847527e-02f, 6.31578192e-02f, 1.31911665e-01f,
  1.02936484e-01f, 1.38026938e-01f, 1.91503763e-01f, 1.25426173e-01f, 4.69529144e-02f, 2.04100937e-01f, 1.40478209e-01f, 7.76891112e-02f, 1.81196392e-01f, 9.90241915e-02f,
  -1.79906264e-01f, -4.57900092e-02f, 6.15948439e-01f, -3.88718933e-01f, -1.46213949e-01f, -2.33624220e-01f, -4.35262829e-01f, -4.17565048e-01f, -2.71021754e-01f, 6.66445540e-03f,
  -7.17814732e-03f, -2.52977073e-01f, -5.59262708e-02f, -3.98926102e-02f, -2.15378553e-02f, 2.30484754e-01f, 3.03285927e-01f, 3.40440542e-01f, 4.80481423e-03f, -2.11881116e-01f,
  -2.29544163e-01f, -1.26302004e-01f, 1.88274816e-01f, 8.94963220e-02f, -5.10990396e-02f, -4.87084053e-02f, 2.79938936e-01f, 1.73710927e-01f, 1.76624700e-01f, 3.57588738e-01f,
  3.26523483e-01f, 6.52492570e-04f, 3.89784984e-02f, 7.82722309e-02f, 1.31706670e-01f, 2.53439676e-02f, 2.00053547e-02f, 1.31051004e-01f, -1.67587437e-02f, 1.46562099e-01f,
  -4.18776050e-02f, 4.80285287e-02f, -1.29079849e-01f, 2.30185259e-02f, -1.30957961e-01f, -9.87897962e-02f, 6.16502911e-02f, 9.05480683e-02f, 9.36549380e-02f, -7.15826778e-03f,
  -1.83181226e-01f, -9.66901183e-02f, -7.22680613e-02f, -8.75785202e-02f, -5.82512021e-02f, 7.65157724e-03f, -2.38144193e-02f, -1.38920676e-02f, 1.04918554e-01f, 6.13609329e-02f,
  6.95986953e-03f, 8.62358958e-02f, 4.91045006e-02f, -9.66365915e-03f, -1.10293433e-01f, -1.35773746e-02f, 2.74020024e-02f, -6.88228607e-02f, 1.01954993e-02f, -1.20184384e-01f,
  -1.15499482e-01f, 4.05872501e-02f, 2.31035184e-02f, -7.86959485e-04f, -5.86334765e-02f, 1.23846694e-03f, -2.41572503e-02f, 4.41380627e-02f, 7.59052336e-02f, 4.07937262e-03f,
  -7.02723041e-02f, 2.31038257e-02f, 1.01036891e-01f, 4.75862063e-02f, 1.33807436e-01f, 1.32042676e-01f, 6.56153485e-02f, 3.88538614e-02f, 5.89224547e-02f, 6.44589290e-02f,
  -3.66655439e-01f, 2.33235553e-01f, 1.70323858e-03f, -9.41667426e-03f, -3.92418467e-02f, 2.27086768e-02f, -3.63070052e-03f, 9.02546272e-02f, -7.60819390e-02f, 8.68179370e-03f,
  -2.22595241e-02f, -5.91934212e-02f, -9.57712308e-02f, 5.98625094e-02f, -1.56474188e-01f, -1.68296918e-02f, -1.09810419e-02f, -1.66573137e-01f, -1.35077968e-01f, -1.47864789e-01f,
  -1.71307534e-01f, -3.40382993e-01f, -4.16174352e-01f, -3.23862165e-01f, -2.16825739e-01f, -2.16355100e-01f, -1.05964638e-01f, -1.74260393e-01f, -2.48382181e-01f, -4.31877077e-01f,
  1.89936943e-02f, -3.30484331e-01f, -4.22437489e-01f, -4.77848142e-01f, -3.03264230e-01f, 2.09098700e-02f, -1.82960242e-01f, -9.24772918e-02f, -1.87302813e-01f, -3.32582235e-01f,
  -1.00434691e-01f, 1.10658512e-01f, -1.54553697e-01f, 1.28223374e-01f, 2.10865647e-01f, -3.22530806e-01f, -2.76604265e-01f, 2.24929415e-02f, 3.29394102e-01f, 2.57346243e-01f,
  -2.31333431e-02f, -2.45440438e-01f, -6.03202172e-02f, -2.20940486e-02f, -4.29901212e-01f, -1.19296074e-01f, -4.26988751e-01f, -2.58837372e-01f, -3.63797061e-02f, -4.08017933e-01f,
  -4.53739852e-01f, -2.00638965e-01f, 1.49490848e-01f, 1.95826650e-01f, -2.68041849e-01f, 3.21212485e-02f, -7.63700604e-02f, -1.95603341e-01f, -1.09075354e-02f, -1.84291556e-01f,
  -9.37597007e-02f, 6.27053231e-02f, 3.64278592e-02f, -1.76248863e-01f, -1.39007285e-01f, -3.32068792e-03f, -1.23276688e-01f, -9.87718347e-03f, 8.93798470e-02f, -5.72929308e-02f,
  3.15469727e-02f, 1.97946057e-01f, 2.75906269e-02f, 6.61176890e-02f, 3.75249274e-02f, 1.98119342e-01f, -1.37384340e-01f, 7.96798021e-02f, 2.08167523e-01f, -2.73731291e-01f,
  7.59435296e-02f, -1.12912543e-01f, -3.88465030e-03f, -1.75922681e-02f, -2.54620723e-02f, 6.49176389e-02f, -1.18770577e-01f, 1.76730044e-02f, 9.48355794e-02f, 8.67548138e-02f,
  7.12008700e-02f, 1.60865989e-02f, -5.43025061e-02f, -2.35008113e-02f, -9.46114808e-02f, 5.11391796e-02f, 5.14133163e-02f, 4.92617898e-02f, -1.08556924e-02f, 1.13570504e-02f,
  8.76021609e-02f, 9.36488509e-02f, 4.13966514e-02f, -3.41525711e-02f, 6.10508025e-02f, -3.12078302e-03f, 5.47066852e-02f, 2.02413023e-01f, 2.97496878e-02f, 1.50828615e-01f,
  -3.10047984e-01f, 2.92272866e-01f, -2.44900122e-01f, 6.73693493e-02f, -6.40115291e-02f, -9.65272728e-03f, -4.81439941e-02f, -7.08456039e-02f, -2.08795696e-01f, -1.41316935e-01f,
  7.33958483e-02f, 1.68368369e-02f, 4.57895882e-02f, -5.88937365e-02f, 4.07251641e-02f, 1.87570319e-01f, 8.89505818e-02f, -7.40283877e-02f, 1.27782211e-01f, 1.72113869e-02f,
  8.71681198e-02f, 2.23127648e-01f, 1.34583309e-01f, -2.66293306e-02f, 2.34968603e-01f, 1.62136987e-01f, -2.70329905e-03f, 1.42775267e-01f, 2.82309741e-01f, -1.94352567e-01f,
  -2.54167140e-01f, -6.46001995e-02f, 3.23297918e-01f, 1.93307415e-01f, -1.14555843e-01f, -2.25274026e-01f, -4.94312614e-01f, -1.20858714e-01f, 2.50668675e-01f, 1.09325245e-01f,
  -1.24226458e-01f, 2.62743477e-02f, 1.24894850e-01f, 5.51821440e-02f, -2.21628159e-01f, 1.45500153e-01f, 2.64468640e-01f, 1.41460076e-01f, -2.23897889e-01f, -3.34231675e-01f,
  -5.76765276e-02f, 1.30323386e-02f, -8.17942470e-02f, -1.66644063e-02f, 3.77708763e-01f, 1.01347432e-01f, 2.47432545e-01f, 1.66831657e-01f, -5.58210798e-02f, 4.33936805e-01f,
  2.83238232e-01f, 7.93699101e-02f, -2.34513849e-01f, -6.38315380e-02f, 1.90109387e-02f, 3.92189734e-02f, -5.63165843e-02f, 2.16301769e-01f, -5.39149530e-02f, 1.95041507e-01f,
  7.48189390e-02f, 2.76794732e-02f, 6.71132356e-02f, 1.23901330e-01f, -5.01913093e-02f, -3.30998078e-02f, 2.20702246e-01f, 1.21652685e-01f, 1.24937475e-01f, 9.88444090e-02f,
  6.30237237e-02f, -3.51961516e-02f, 7.55597744e-03f, -6.35762438e-02f, -2.38351561e-02f, -1.37332588e-01f, -1.09511487e-01f, -1.13793895e-01f, -2.68199235e-01f, 1.10254660e-01f,
  1.14714369e-01f, -7.93850236e-03f, -3.54876630e-02f, 1.27154782e-01f, 8.74717254e-03f, 2.08721370e-01f, 2.80395657e-01f, -4.63867709e-02f, -4.70345132e-02f, 1.57595098e-01f,
  4.41153869e-02f, -5.72965406e-02f, -9.42440331e-02f, 3.43555920e-02f, 4.78737988e-02f, 3.35276537e-02f, -3.19684595e-02f, -1.05774544e-01f, 4.69383411e-02f, 1.22930110e-01f,
  3.88302766e-02f, 7.04688728e-02f, 1.10081784e-01f, 8.96757022e-02f, 5.42777441e-02f, 6.23454945e-03f, 6.04978763e-02f, -1.53815269e-01f, -8.19850266e-02f, -6.05607778e-02f,
  -1.46184251e-01f, -2.81886905e-01f, 1.56831220e-01f, 1.01521127e-01f, 2.03101307e-01f, 8.61585289e-02f, -3.89554761e-02f, -1.10069275e-01f, -6.54351637e-02f, -1.86526433e-01f,
  -2.04044402e-01f, -8.48681703e-02f, 5.78765161e-02f, 1.24735981e-01f, -1.16644040e-01f, 1.24651626e-01f, 1.16154365e-01f, -8.57195929e-02f, -1.65057182e-01f, 1.61408231e-01f,
  6.23895973e-02f, -2.69552976e-01f, -2.94240147e-01f, -1.73526987e-01f, -1.01285525e-01f, -3.53378832e-01f, -2.25786552e-01f, -2.63084292e-01f, -4.28278714e-01f, -4.90672052e-01f,
  -8.47401500e-01f, -1.54561818e-01f, 8.81570056e-02f, -1.12219542e-01f, 1.90410718e-01f, -3.49173434e-02f, -2.27234550e-02f, -1.92556500e-01f, -2.32110888e-01f, -1.12470416e-02f,
  4.15836312e-02f, -2.82090586e-02f, 3.30683589e-02f, 1.30522847e-02f, -2.76832078e-02f, 8.79578814e-02f, 1.75760955e-01f, -4.38835546e-02f, 1.92619279e-01f, 2.25147441e-01f,
  2.19866991e-01f, 1.90911874e-01f, -4.56586964e-02f, -8.10511261e-02f, 2.17241004e-01f, 2.54565448e-01f, 1.27809420e-01f, 1.55779198e-01f, 1.05552845e-01f, 2.40209445e-01f,
  4.21349794e-01f, -2.42248192e-01f, 2.23095845e-02f, -2.08707884e-01f, -3.70308384e-02f, -3.13988358e-01f, -1.41901344e-01f, -5.12670241e-02f, -1.04996815e-01f, 1.23692982e-01f,
  -8.18973780e-02f, -1.40730277e-01f, -2.72708293e-02f, 3.80431488e-02f, 1.69265151e-01f, -6.40986953e-03f, -2.08895877e-01f, -1.07761465e-01f, -7.54787475e-02f, 4.04959137e-04f,
  -5.03386296e-02f, -3.15005407e-02f, 6.57490641e-02f, -2.07008809e-01f, -2.01710477e-01f, -5.64146899e-02f, -5.87576739e-02f, -2.06341580e-01f, -1.55663058e-01f, -3.22796553e-02f,
  -1.51513159e-01f, -8.38718489e-02f, -1.09609991e-01f, -8.34666193e-02f, -1.61785170e-01f, 2.43484564e-02f, 4.27360870e-02f, 6.41559437e-02f, -1.38905704e-01f, -2.92452555e-02f,
  6.47706389e-02f, -5.84154343e-03f, -3.68489791e-03f, 5.52608483e-02f, -6.90843314e-02f, -1.62968695e-01f, -1.10776700e-01f, -7.81361610e-02f, -1.40852481e-01f, -1.83143079e-01f,
  -6.63228855e-02f, 1.10646918e-01f, 1.94451138e-02f, 1.01172952e-02f, -3.94499414e-02f, -1.41104504e-01f, -2.47347187e-02f, -1.34675831e-01f, -1.10091589e-01f, -1.79196261e-02f,
  5.31135440e-01f, -2.64338613e-01f, 1.36975303e-01f, -1.26436532e-01f, 1.75400469e-02f, -2.01966822e-01f, -6.01974875e-02f, 1.39917538e-03f, -2.22661812e-02f, 4.10190225e-02f,
  -9.39425733e-03f, -4.01498973e-02f, 1.41364247e-01f, -1.21113602e-02f, 2.47698814e-01f, 8.82738233e-02f, -1.02159582e-01f, 1.48375019e-01f, -8.17080215e-03f, 7.15854764e-02f,
  -1.58605322e-01f, -4.50264104e-02f, 2.20367983e-01f, 5.85958138e-02f, 4.28132936e-02f, 9.61190835e-02f, 2.99302816e-01f, 2.26812452e-01f, 1.80807948e-01f, 2.80172318e-01f,
  5.88930190e-01f, 5.70100725e-01f, -6.73281789e-01f, 4.89981532e-01f, -2.63470769e-01f, -4.90208626e-01f, -3.00212428e-02f, 3.54357213e-01f, 3.99162203e-01f, 3.53932917e-01f,
  -1.70904160e-01f, -5.14979064e-01f, -2.32825845e-01f, -2.17179254e-01f, -3.03823411e-01f, 1.60455003e-01f, 4.63690720e-02f, -4.54065949e-01f, -5.81116199e-01f, -2.64276654e-01f,
  3.50653566e-02f, 2.33479857e-01f, 1.66456059e-01f, 9.00887847e-02f, 4.07384545e-01f, -3.83829512e-02f, 2.13659987e-01f, 8.49527866e-02f, -1.27009958e-01f, 3.27775478e-01f,
  -2.69212306e-01f, 2.20416948e-01f, -4.20591623e-01f, -3.86124849e-02f, -1.70489326e-01f, -6.20853975e-02f, -7.82609135e-02f, -6.69022426e-02f, -9.68019962e-02f, 4.91318516e-02f,
  -3.02963734e-01f, -1.58789948e-01f, -1.97876826e-01f, -5.81859276e-02f, -2.73878705e-02f, -1.34798378e-01f, 1.28107265e-01f, -3.30178365e-02f, -2.41583921e-02f, -1.07978217e-01f,
  -1.23994775e-01f, -2.77812392e-01f, -3.79059970e-01f, 6.70157596e-02f, -2.62111658e-03f, -3.31521451e-01f, -4.80026193e-02f, 1.18248705e-02f, -7.84180537e-02f, 5.31808317e-01f,
  1.02111191e-01f, -4.49423380e-02f, -4.53461558e-02f, 1.35121495e-01f, 9.66661274e-02f, -7.79391155e-02f, 4.37596627e-02f, 1.11754034e-02f, -7.10982084e-02f, 6.29411489e-02f,
  -5.20156883e-02f, 6.30309656e-02f, -4.89885136e-02f, 5.62970899e-02f, 2.06663422e-02f, -4.85884771e-02f, -6.41924664e-02f, 1.35923818e-01f, -6.23435453e-02f, 1.79641077e-03f,
  -6.02202117e-02f, -5.08638471e-02f, -6.09229803e-02f, 3.56878266e-02f, -3.85462530e-02f, -4.18342613e-02f, 3.68165486e-02f, -7.03932345e-02f, 6.02971837e-02f, 2.67655868e-03f,
  2.21856758e-01f, -3.44832420e-01f, 1.35426536e-01f, -5.25844172e-02f, 1.99386328e-02f, -1.35321096e-01f, 6.40953854e-02f, 8.35471600e-03f, 1.53112560e-04f, -2.77321115e-02f,
  -1.34632215e-01f, -3.59987095e-02f, -4.01531272e-02f, 7.00312555e-02f, -1.51262060e-01f, -3.95034216e-02f, 4.98984978e-02f, -9.21936557e-02f, -6.49902001e-02f, 1.96568780e-02f,
  2.43478715e-01f, 2.35272087e-02f, -9.85452011e-02f, -6.62660375e-02f, 1.22279804e-02f, -2.59832054e-01f, -3.99118438e-02f, 6.56345859e-02f, -2.59171367e-01f, 5.38809657e-01f,
  -4.37110066e-01f, 8.50880593e-02f, -2.70626724e-01f, -1.72115758e-01f, -2.54741848e-01f, -1.60244614e-01f, 6.39593378e-02f, 2.15153992e-01f, 9.00257081e-02f, 9.71690789e-02f,
  5.38591668e-02f, -1.39447808e-01f, -1.76359460e-01f, -1.03207484e-01f, -1.46097586e-01f, -2.54275650e-02f, -1.89013317e-01f, -3.62004966e-01f, -2.30536863e-01f, -5.03351912e-02f,
  -1.87860020e-02f, -1.43645167e-01f, -1.69885308e-01f, -4.84238788e-02f, 8.94124582e-02f, -7.15247467e-02f, 5.59969991e-02f, -1.27125248e-01f, -1.72185391e-01f, -2.07760498e-01f,
  2.39388525e-01f, -1.42120421e-01f, 1.44536756e-02f, -1.66590422e-01f, 1.32666931e-01f, 1.21215515e-01f, 9.00576040e-02f, 7.63310790e-02f, -8.23875144e-02f, 9.13907066e-02f,
  -9.59628150e-02f, 7.61146769e-02f, 3.60488519e-03f, -5.40216453e-02f, -3.09086926e-02f, -1.39216080e-01f, -1.09980166e-01f, -1.07654870e-01f, -6.79846630e-02f, 6.35916367e-02f,
  -1.34343550e-01f, -3.40689212e-01f, -2.02227995e-01f, 1.35500669e-01f, 9.28233042e-02f, -2.09452763e-01f, 1.47220910e-01f, 5.87874986e-02f, -5.25205024e-02f, 2.27822512e-01f,
  1.37365744e-01f, 1.66967977e-02f, -4.28621061e-02f, 9.48616043e-02f, 1.95638567e-01f, 3.89591902e-02f, 4.49895076e-02f, 4.15612943e-02f, 6.27806559e-02f, 5.43318838e-02f,
  6.76663443e-02f, 8.40648413e-02f, 1.33982524e-01f, -3.66534777e-02f, -8.00178945e-02f, -8.48884732e-02f, -7.38503039e-02f, 1.76469222e-01f, 9.83168632e-02f, 5.55511564e-04f,
  -8.80450681e-02f, 7.59336501e-02f, -1.56721920e-02f, 2.17482850e-01f, -8.37020669e-03f, -8.05649236e-02f, -1.13919221e-01f, -1.25679644e-02f, 2.30854545e-02f, -1.87792554e-01f,
  2.68368512e-01f, -2.70821393e-01f, 7.19418228e-02f, -6.16419613e-02f, 1.15200870e-01f, 5.58290929e-02f, -4.94360626e-02f, 1.31980002e-01f, 2.22935304e-02f, 1.10843368e-01f,
  -4.63759676e-02f, 2.13375568e-01f, 4.96294051e-02f, 1.76798403e-02f, 3.56650259e-03f, -1.23004474e-01f, -1.13618173e-01f, -1.03241600e-01f, -4.67125848e-02f, 9.28395912e-02f,
  1.46580429e-03f, -6.27101138e-02f, -6.04766160e-02f, 8.31020251e-02f, 8.62721503e-02f, -1.82905510e-01f, 8.32969025e-02f, 1.37430847e-01f, -1.04889974e-01f, 3.44587564e-01f,
  3.47600102e-01f, -3.46177928e-02f, 3.23740900e-01f, -1.18944548e-01f, -4.71491426e-01f, -4.65502560e-01f, -4.56835270e-01f, -2.52779782e-01f, -6.68965727e-02f, -1.02909952e-01f,
  -3.99684817e-01f, -1.27439186e-01f, -3.97144817e-02f, 5.27726077e-02f, 5.72583377e-02f, 4.94569577e-02f, 9.13494825e-02f, 2.76374251e-01f, -7.65824690e-02f, -3.98385912e-01f,
  -4.04856354e-01f, -4.43768390e-02f, 6.42295554e-02f, 1.29047558e-01f, 1.02606858e-03f, -1.31469950e-01f, 1.38837934e-01f, -4.30475511e-02f, -9.44171399e-02f, 3.11498374e-01f,
  3.78717519e-02f, 9.25338045e-02f, -6.99334145e-02f, 1.25434045e-02f, -3.96967828e-02f, 7.08416663e-03f, 3.89534459e-02f, 8.54753107e-02f, -1.39567807e-01f, -5.73562831e-02f,
  6.67705387e-03f, -1.04227550e-01f, 2.81076692e-03f, -1.48330349e-02f, -7.63065666e-02f, -3.28138797e-03f, 3.56982499e-02f, 6.70446008e-02f, 5.58426268e-02f, -5.00219651e-02f,
  -1.59251451e-01f, -1.44619942e-01f, -1.79254234e-01f, -2.54151300e-02f, 1.36522613e-02f, -3.83943133e-02f, -1.69937655e-01f, 1.70035753e-02f, 1.10570563e-03f, 1.47161201e-01f,
  -1.84348956e-01f, -7.49077089e-03f, -1.45949274e-01f, -2.11200699e-01f, -2.35571861e-01f, -1.45436406e-01f, -2.05605596e-01f, -6.77743107e-02f, -3.37622613e-02f, -2.21084878e-01f,
  -1.49974391e-01f, -1.44515589e-01f, -7.82648027e-02f, -1.16293296e-01f, 1.58897191e-02f, 3.55372950e-02f, -1.46854907e-01f, -4.55786847e-02f, -1.80260763e-01f, -4.05026460e-03f,
  -1.52283981e-01f, -5.13966605e-02f, -1.27387241e-01f, -1.94484685e-02f, -7.19501898e-02f, -9.40483510e-02f, 4.76397313e-02f, -7.77938291e-02f, -7.24427849e-02f, 1.68667361e-02f,
  -1.82630733e-01f, -1.18929453e-01f, 1.02565013e-01f, 2.28972763e-01f, 9.78973433e-02f, 1.25463352e-01f, 1.81002110e-01f, 7.48171518e-03f, -7.97925964e-02f, -4.19491567e-02f,
  1.11326300e-01f, 1.21441171e-01f, -2.66768336e-02f, 5.08322902e-02f, -1.96939453e-01f, -4.18346561e-02f, -4.91491146e-02f, -1.23607703e-01f, 7.30591416e-02f, -2.51205545e-02f,
  -3.65939066e-02f, -1.00444183e-01f, -1.52360663e-01f, -1.30870089e-01f, -1.59430634e-02f, -2.76467600e-03f, -4.65897424e-03f, 2.16803998e-02f, -5.26687540e-02f, -1.27199456e-01f,
  4.44544643e-01f, -7.13653922e-01f, -1.89245835e-01f, 2.08464295e-01f, 1.01947524e-01f, 1.61754400e-01f, -1.46089733e-01f, 1.08189374e-01f, 2.88998097e-01f, -3.60036820e-01f,
  -4.71147090e-01f, -9.01272595e-02f, -2.64718294e-01f, -1.13703363e-01f, -7.81512037e-02f, -3.27657998e-01f, -1.01827703e-01f, 1.50503203e-01f, 6.38558328e-01f, 5.65128863e-01f,
  1.18281767e-01f, 1.32262975e-01f, 1.79251239e-01f, 1.88878313e-01f, -9.50456038e-02f, 5.90775199e-02f, -3.82060289e-01f, -1.52793169e-01f, -3.11746180e-01f, -5.12129307e-01f,
  -2.40033150e-01f, -1.69522479e-01f, 6.86957240e-02f, -1.17362700e-02f, -1.07919946e-01f, -4.21412699e-02f, 2.44458504e-02f, -8.97226706e-02f, -6.58103153e-02f, 6.46047806e-03f,
  -2.35203747e-02f, 6.17390424e-02f, 9.43599939e-02f, -1.29633084e-01f, 1.02195702e-01f, 8.03390071e-02f, -3.23858187e-02f, -3.08236126e-02f, -7.21478686e-02f, -6.11995086e-02f,
  -2.13485405e-01f, -7.08839148e-02f, -9.36385989e-02f, 9.05789342e-03f, -7.73955211e-02f, -3.65421697e-02f, -1.12921512e-02f, 4.39391024e-02f, -3.32993940e-02f, -7.05636665e-02f,
  1.40612334e-01f, -2.04740204e-02f, -3.81642133e-02f, 1.56714842e-01f, 1.93485226e-02f, 9.47477594e-02f, 7.38284290e-02f, -6.07090853e-02f, -7.00332830e-03f, -1.23114154e-01f,
  -9.74196717e-02f, -9.49804336e-02f, 9.31747183e-02f, -5.78042753e-02f, -1.15880504e-01f, -6.30483404e-02f, -6.97315261e-02f, -7.24458462e-03f, -2.91192867e-02f, 4.42029126e-02f,
  5.03623784e-02f, -4.16052192e-02f, -5.60664162e-02f, 3.99682596e-02f, -1.14335954e-01f, 4.96541373e-02f, 6.46929666e-02f, -1.12173207e-01f, -4.31407727e-02f, -5.50500080e-02f,
  -4.39139791e-02f, 1.26038685e-01f, 2.10060552e-02f, -1.06328636e-01f, -1.12786014e-02f, -1.01925634e-01f, -2.12129317e-02f, 1.08289093e-01f, 8.98859128e-02f, 7.22863227e-02f,
  6.63730204e-02f, 3.69260721e-02f, -1.23713061e-01f, -1.38914015e-03f, 2.01838329e-01f, 1.34686172e-01f, 1.38662318e-02f, 1.27336727e-02f, -1.57960989e-02f, -6.05784953e-02f,
  -1.57982811e-01f, 1.16616473e-01f, 1.34256437e-01f, -4.79524136e-02f, 1.23916298e-01f, 2.85235852e-01f, 8.83563533e-02f, 4.67565209e-02f, 8.73639360e-02f, 2.21635886e-02f,
  -2.77872831e-01f, -1.33947343e-01f, -1.53779119e-01f, -4.79048267e-02f, -5.28887175e-02f, -1.97945186e-03f, -8.68280232e-02f, 1.20173723e-01f, 1.50326103e-01f, -7.05070049e-02f,
  -3.47970761e-02f, -1.15260445e-01f, -1.99405670e-01f, -1.70360446e-01f, -2.20343068e-01f, -1.73042506e-01f, -2.70898819e-01f, -3.38838011e-01f, -1.58370793e-01f, -3.52954715e-02f,
  -9.25194174e-02f, -2.03950837e-01f, -2.39316925e-01f, -1.14716664e-01f, -1.12103321e-01f, -2.70031869e-01f, -2.46208817e-01f, -2.26671979e-01f, -2.83235073e-01f, -3.64161164e-01f,
  -8.20593536e-02f, 2.16656029e-02f, 1.20901577e-01f, -1.29552647e-01f, -1.71957221e-02f, -5.65118017e-03f, 4.34782170e-03f, 2.15499755e-02f, 9.99146141e-03f, 3.35525572e-02f,
  -8.51177145e-03f, 9.02665704e-02f, 3.18078790e-03f, -6.81567565e-02f, 2.78082527e-02f, 2.09082812e-02f, -3.81969251e-02f, -4.38063964e-02f, 4.04238002e-03f, 1.23681575e-01f,
  -6.99306577e-02f, -1.33854240e-01f, -1.40417859e-01f, 3.06134168e-02f, 1.37109771e-01f, -1.46124870e-01f, -2.30983905e-02f, -2.10804902e-02f, -1.07551120e-01f, -2.71655411e-01f,
  8.57383087e-02f, 1.22095779e-01f, 1.57914758e-01f, 6.81148693e-02f, -2.59019509e-02f, 7.83061832e-02f, 8.36420991e-03f, -4.92629372e-02f, 1.77060142e-02f, 3.48383971e-02f,
  8.68202746e-02f, -3.89326811e-02f, -3.38463055e-04f, -2.77643502e-02f, -1.46103486e-01f, -7.21915858e-03f, -5.62447980e-02f, -1.07085809e-01f, -1.19695097e-01f, -1.27570584e-01f,
  -9.15995613e-02f, -1.60470940e-02f, 1.33368755e-02f, -2.71901041e-02f, -3.99772786e-02f, -4.10605483e-02f, 2.97705326e-02f, 5.59570501e-03f, 2.67536640e-02f, -2.63754055e-02f,
  -1.01618394e-02f, -1.53463818e-02f, -1.18076533e-01f, -7.44903386e-02f, 1.22354729e-02f, 4.72228713e-02f, -7.52340332e-02f, 1.90158226e-02f, 6.02602493e-03f, 9.03717354e-02f,
  1.01307943e-01f, 1.82028525e-02f, 3.93088572e-02f, 4.81068566e-02f, 5.49731962e-02f, 6.20932356e-02f, -4.59136590e-02f, -1.82919592e-01f, -1.87671903e-04f, 1.03770770e-01f,
  -1.74284801e-02f, -1.90927342e-01f, -3.42174917e-01f, -1.55521795e-01f, -4.71131541e-02f, -3.03183854e-01f, -2.67109483e-01f, -1.75828561e-01f, -2.56523758e-01f, -3.69867802e-01f,
  -2.60535747e-01f, 2.06153303e-01f, 3.19609463e-01f, 1.66077361e-01f, 3.21031213e-01f, 3.50548029e-01f, 4.08992022e-01f, 2.70258784e-01f, 1.24426529e-01f, 2.50115275e-01f,
  1.05768949e-01f, 1.30020604e-01f, 5.08611836e-02f, 1.10288493e-01f, 7.67822117e-02f, 2.69748509e-01f, 2.96313703e-01f, -1.82213634e-02f, 8.84936564e-03f, 5.97472452e-02f,
  3.64986770e-02f, 7.46887252e-02f, -1.86329320e-01f, -4.76437584e-02f, 1.89965159e-01f, 6.52218759e-02f, 1.27440348e-01f, 7.21324980e-02f, 1.70684427e-01f, -3.78039852e-02f,
  2.87692957e-02f, 1.06661193e-01f, -1.05224259e-01f, -2.08578527e-01f, -4.84486967e-02f, -2.65772015e-01f, 9.75875743e-03f, -6.17966987e-02f, -1.74503013e-01f, -8.31594318e-02f,
  4.40575927e-02f, 2.51339208e-02f, 7.61698037e-02f, 1.37717910e-02f, 7.29357451e-02f, -1.25514194e-01f, -5.43561727e-02f, 1.62348822e-02f, 1.08219206e-01f, 8.48218724e-02f,
  3.18105072e-02f, 2.55457252e-01f, 3.10648292e-01f, 1.64268613e-01f, 2.67915148e-03f, -1.07228182e-01f, -3.32729928e-02f, -1.03530481e-01f, 5.05073555e-03f, 2.75455113e-03f,
  1.42189115e-01f, -1.38294213e-02f, 2.57325899e-02f, 1.52798653e-01f, 3.97349410e-02f, 1.35153264e-01f, 1.16662281e-02f, 1.21523105e-01f, 6.00544252e-02f, 8.23063552e-02f,
  9.03771222e-02f, 1.37544498e-01f, 2.25326225e-01f, -1.11019641e-01f, -1.01466209e-01f, 9.72251594e-02f, 1.02293827e-01f, 1.10515123e-02f, 1.11220390e-01f, 4.16371375e-02f,
  1.06519796e-01f, -6.71002865e-02f, -9.61083844e-02f, -6.38138354e-02f, 6.26643077e-02f, -2.71942765e-02f, 2.54058782e-02f, 3.15816924e-02f, 3.85805815e-02f, -1.26601249e-01f,
  2.24563748e-01f, 1.69323593e-01f, -1.51979312e-01f, 9.86417904e-02f, -8.89899433e-02f, -9.83149186e-02f, 8.17414969e-02f, -9.22523290e-02f, -4.42887135e-02f, -1.28360823e-01f,
  -4.80374880e-02f, -7.80268312e-02f, 3.90834808e-02f, 5.01482151e-02f, -1.14568904e-01f, -1.61867533e-02f, 4.60798964e-02f, 4.55778539e-02f, -1.33462325e-02f, 3.50908078e-02f,
  -1.14394091e-01f, 1.49248272e-01f, 1.59247249e-01f, 5.65348528e-02f, -3.34721245e-02f, -1.38221569e-02f, 7.26481993e-03f, -1.33466095e-01f, -2.89826095e-02f, -2.41307139e-01f,
  6.51626885e-01f, -5.30861281e-02f, -8.69244277e-01f, 2.55819023e-01f, -7.41042867e-02f, -1.70156389e-01f, 5.62596321e-02f, 1.73189133e-01f, 1.71775699e-01f, -7.50292242e-02f,
  -3.14136505e-01f, -2.88418055e-01f, -3.72064531e-01f, -2.28566200e-01f, -1.69846952e-01f, -2.23196164e-01f, -2.33630940e-01f, -3.90057206e-01f, -1.62763610e-01f, 2.96032012e-01f,
  3.73563945e-01f, 4.72186565e-01f, 3.18647623e-01f, 1.32422140e-02f, 3.39094587e-02f, -5.89189120e-02f, -3.14969420e-01f, -5.13189472e-02f, -2.52216846e-01f, -4.07870620e-01f,
  -2.98210740e-01f, -2.42860511e-01f, -1.48382947e-01f, 6.63246736e-02f, 1.57206692e-02f, 1.57464698e-01f, 5.24442717e-02f, -3.97687741e-02f, -1.16344579e-01f, -1.43952921e-01f,
  -1.37641370e-01f, -5.63173778e-02f, -3.36200684e-01f, -1.60166889e-01f, 3.94747294e-02f, 7.92820845e-03f, -1.94494762e-02f, -1.00380540e-01f, -1.56928778e-01f, -1.76056162e-01f,
  -1.06745087e-01f, -1.89520836e-01f, -3.04821044e-01f, -1.34016559e-01f, -2.15733632e-01f, -3.06678772e-01f, -2.54982054e-01f, -1.85113668e-01f, -3.08932811e-01f, 1.46381855e-01f,
  -1.43109336e-02f, -1.42249120e-02f, 6.89140856e-02f, 2.69115362e-02f, 2.66319960e-01f, -2.53194403e-02f, 9.46300011e-03f, 2.06238106e-02f, -1.04883779e-02f, 4.17283513e-02f,
  -1.20122731e-01f, -4.84732911e-02f, -6.54787570e-02f, -6.91510364e-03f, -1.19436733e-01f, -9.17373896e-02f, -8.23529065e-02f, 5.05027361e-02f, -5.64129502e-02f, 9.17368606e-02f,
  7.26748407e-02f, -1.14933103e-01f, 5.66693619e-02f, 7.50928819e-02f, -8.74607340e-02f, -1.51187032e-01f, 8.63500610e-02f, 3.42220031e-02f, -1.45935034e-02f, 8.59082341e-02f,
  3.68250906e-01f, -2.08040833e-01f, 2.22822726e-01f, 3.59213054e-02f, 7.51903374e-03f, -6.16096407e-02f, 1.25365527e-02f, 2.17353180e-02f, -2.13780954e-01f, -8.65411907e-02f,
  -8.85305777e-02f, -1.03828624e-01f, -2.40129262e-01f, 7.00404271e-02f, 3.07683665e-02f, -4.91804220e-02f, 1.67790994e-01f, -6.57455474e-02f, 1.22448295e-01f, 1.42536014e-01f,
  2.47100502e-01f, 2.28802547e-01f, 2.77157277e-01f, 2.04703912e-01f, 1.82485074e-01f, 1.10765606e-01f, 6.59479126e-02f, 5.94420396e-02f, 5.25652915e-02f, 5.64577758e-01f,
  -5.79810143e-01f, 1.51081875e-01f, -7.06324577e-02f, -4.94550884e-01f, 7.28078336e-02f, 2.91355014e-01f, 5.28205514e-01f, 6.33905157e-02f, -3.54763627e-01f, 3.42668742e-02f,
  2.15559393e-01f, -8.84083286e-03f, -1.36725083e-01f, 4.98921610e-02f, 2.31718168e-01f, 2.40052938e-01f, 6.06523012e-04f, -1.07149631e-01f, 1.33728430e-01f, 3.21836442e-01f,
  1.08107127e-01f, -1.60800755e-01f, -2.46823803e-01f, -1.61460340e-01f, -2.24007100e-01f, -1.94634512e-01f, -1.36745855e-01f, -9.87095684e-02f, 2.58439541e-01f, -9.68865007e-02f,
  7.03389989e-03f, -3.65266837e-02f, 1.25723764e-01f, 4.38196957e-03f, -5.25056981e-02f, -2.92707253e-02f, 4.69023436e-02f, -2.48961896e-01f, -4.35360782e-02f, -6.31099343e-02f,
  -3.03320624e-02f, -2.21781526e-02f, -6.46571368e-02f, 3.85178812e-02f, -3.89371663e-02f, 6.90344945e-02f, -9.72108915e-02f, -1.95763018e-02f, -3.43966708e-02f, 2.76458599e-02f,
  1.34541109e-01f, 3.55104357e-02f, -1.39938846e-01f, 6.58039302e-02f, 2.19163354e-02f, -1.38229311e-01f, -6.62773708e-03f, 1.11877127e-02f, 8.36839229e-02f, -2.04770803e-01f,
  -1.58575475e-02f, -1.22792935e-02f, 1.29893795e-02f, -7.77658075e-02f, 6.60080016e-02f, -4.48918678e-02f, -9.91159752e-02f, 1.07172899e-01f, -2.37744842e-02f, -8.53524879e-02f,
  4.97489586e-04f, 8.30875039e-02f, -4.37658420e-03f, -2.85959225e-02f, -3.01744901e-02f, -1.87103022e-02f, 1.56318814e-01f, 1.11201040e-01f, -2.50829402e-02f, 3.61853391e-02f,
  5.63671477e-02f, -3.17622572e-02f, -1.68286651e-01f, -9.57767107e-03f, 8.35658982e-02f, -1.02015650e-02f, -4.05977778e-02f, 3.87779064e-02f, -6.64904043e-02f, 6.26311451e-02f,
  -2.98953027e-01f, 3.28651547e-01f, -1.86802343e-01f, 2.67031998e-03f, -2.21216194e-02f, 4.43989113e-02f, 6.31214119e-03f, 1.10863388e-01f, -1.16759658e-01f, -3.46593149e-02f,
  1.40410528e-01f, -3.58300321e-02f, -6.94598779e-02f, 7.63683096e-02f, 1.19047776e-01f, -2.29067747e-02f, 6.10345900e-02f, 2.41546397e-04f, 6.67695776e-02f, -6.03991151e-02f,
  -4.59091216e-02f, 6.87027648e-02f, -1.31632820e-01f, -4.61205207e-02f, 7.15728558e-04f, -1.42031834e-01f, -1.23951346e-01f, 7.97542855e-02f, 1.92741230e-02f, -1.27672255e-01f,
  7.43296564e-01f, -2.04624474e-01f, 1.35160312e-01f, 4.93982509e-02f, -3.33907098e-01f, -5.72772361e-02f, -2.62101203e-01f, 1.85374357e-02f, 2.03789100e-01f, -7.79802874e-02f,
  -2.39686877e-01f, 1.11752771e-01f, 1.52856588e-01f, 9.60897282e-02f, 2.21505389e-01f, 4.15255316e-02f, 1.40477121e-01f, 3.67806107e-01f, 2.74438262e-01f, -6.95289224e-02f,
  -3.48956399e-02f, 8.29520300e-02f, 3.28928709e-01f, 1.08584352e-01f, -1.08230382e-01f, 1.62791479e-02f, -2.11944059e-02f, -2.72344172e-01f, -1.59279481e-01f, -1.34345114e-01f,
  -3.33842754e-01f, -8.73075202e-02f, 4.15388644e-02f, -7.75952041e-02f, -8.63635466e-02f, 8.56967866e-02f, 7.89625123e-02f, -1.12052806e-01f, -2.69495770e-02f, -7.39058927e-02f,
  -3.64830457e-02f, -8.89443532e-02f, 6.61740154e-02f, -3.53398621e-02f, -1.85394868e-01f, 2.78554223e-02f, -3.36127803e-02f, -7.94661120e-02f, 1.70542244e-02f, -7.75179639e-02f,
  -9.67855826e-02f, -1.31545976e-01f, -1.61938176e-01f, 2.92395172e-03f, 1.79938272e-01f, 6.13449030e-02f, -1.81261320e-02f, -2.19513495e-02f, 8.15694481e-02f, -2.15784237e-02f,
  5.27963564e-02f, -7.33562931e-03f, 6.15886524e-02f, 7.13992268e-02f, 8.72016922e-02f, 1.73403978e-01f, 3.29935551e-02f, -4.11186926e-02f, 1.93357393e-01f, 8.23527873e-02f,
  -6.05760887e-02f, 7.76562840e-02f, -1.75471678e-02f, 4.24725382e-04f, 5.27647436e-02f, -1.07775301e-01f, -1.63010105e-01f, -3.97431143e-02f, 3.53478678e-02f, 2.13319808e-02f,
  -5.81218221e-04f, 3.71841504e-03f, -1.09707683e-01f, 2.39845621e-03f, -1.88567489e-01f, -1.35693504e-02f, -8.51674303e-02f, -1.48415267e-02f, 1.29252160e-03f, -1.08916819e-01f,
  -2.62704551e-01f, 1.19768441e-01f, 2.25695759e-01f, 1.09328039e-01f, -1.18270479e-02f, -8.46708268e-02f, 1.36062980e-01f, -5.25791347e-02f, -2.77197540e-01f, -5.84822744e-02f,
  -9.10643265e-02f, 1.11341529e-01f, 2.42380369e-02f, 1.92122422e-02f, 1.57317728e-01f, 1.08715547e-02f, -6.66724369e-02f, -1.77460499e-02f, -5.41450046e-02f, -7.22396672e-02f,
  -7.35903829e-02f, -2.18617134e-02f, 5.01868799e-02f, 1.85913399e-01f, 8.19513202e-02f, 1.29810899e-01f, 2.29718853e-02f, 9.46375206e-02f, 1.69388488e-01f, 1.94634587e-01f,
  1.05102159e-01f, -1.89766213e-01f, -4.29337054e-01f, 1.45607457e-01f, -1.30119532e-01f, -2.99669266e-01f, -4.49356169e-01f, -1.71776757e-01f, -5.69178164e-02f, -2.68925279e-01f,
  -1.72742531e-01f, 1.53058141e-01f, -2.21562326e-01f, -9.28846449e-02f, -8.45857188e-02f, -3.54812384e-01f, -2.01901674e-01f, 1.28186435e-01f, 3.11632186e-01f, 4.35939848e-01f,
  2.52199382e-01f, 3.31311792e-01f, 3.80229026e-01f, 1.70636013e-01f, 2.33539224e-01f, 1.05627932e-01f, -9.95280668e-02f, 1.86235905e-01f, -1.26860037e-01f, 1.41348287e-01f,
  -1.38805285e-01f, -8.24803412e-02f, -8.44906196e-02f, 1.67361557e-01f, -6.60822615e-02f, -1.03745006e-01f, 1.58213079e-02f, 1.62203852e-02f, -4.07746509e-02f, -8.66136402e-02f,
  8.18052366e-02f, -3.97931971e-02f, -4.50451002e-02f, 4.07681353e-02f, 2.09038910e-02f, -7.83762485e-02f, 3.06558777e-02f, -5.38693974e-03f, -8.74514729e-02f, 1.06517226e-02f,
  1.21287443e-01f, 1.57058924e-01f, -1.76008493e-01f, -1.80065989e-01f, -1.55705241e-02f, 7.04082549e-02f, -6.43756166e-02f, 2.19458982e-01f, -2.18342006e-01f, -3.88147533e-02f,
  -6.56079575e-02f, -4.40098234e-02f, -5.65369092e-02f, -1.08891271e-01f, -7.35767707e-02f, -1.27259403e-01f, -4.58253548e-02f, 1.15530309e-03f, -2.05975701e-03f, -1.23651624e-02f,
  -3.01910453e-02f, -5.05012348e-02f, 4.74836230e-02f, -1.98552776e-02f, 1.32355951e-02f, 4.44434397e-02f, 3.72692160e-02f, 1.67059034e-01f, 8.65025371e-02f, -9.68742929e-03f,
  7.21090659e-02f, -7.39213675e-02f, 5.31192198e-02f, 8.52575079e-02f, -1.07089058e-02f, 3.54723446e-02f, 1.05802581e-01f, 4.50025760e-02f, 6.53301179e-02f, -4.57793139e-02f,
  -9.64991674e-02f, -1.25083104e-01f, -2.37302676e-01f, 8.10799897e-02f, -1.54000847e-02f, 1.57433469e-02f, -4.85501103e-02f, -2.95886099e-02f, -9.25642811e-03f, -1.40728140e-02f,
  -8.30504857e-03f, -6.84918836e-02f, -9.68160033e-02f, 4.80068438e-02f, -8.34309906e-02f, -1.32753566e-01f, -5.26188985e-02f, -1.53967500e-01f, -8.06260854e-02f, 4.14333902e-02f,
  -1.56700820e-01f, -8.40162560e-02f, -3.01317900e-01f, -4.34858531e-01f, -1.32650673e-01f, -1.87437013e-01f, -2.74288714e-01f, -1.91204280e-01f, -3.69477510e-01f, -4.65833038e-01f,
  -5.79917789e-01f, -3.23293447e-01f, -2.66171217e-01f, -5.18865585e-01f, 1.13116503e-01f, 3.58918667e-01f, 6.67478919e-01f, 3.37391108e-01f, -1.88417509e-01f, -8.34379997e-03f,
  -2.11179063e-01f, -2.80681223e-01f, -5.15468478e-01f, -6.14036769e-02f, 1.28824919e-01f, 2.66745716e-01f, 4.05349396e-02f, -2.07819548e-02f, 3.55645537e-01f, 5.99960566e-01f,
  2.14607403e-01f, -2.35987514e-01f, -2.01658234e-01f, -1.62042931e-01f, -3.06056023e-01f, -2.26418823e-01f, -4.17566687e-01f, -2.86934853e-01f, -3.42268869e-02f, -3.24052334e-01f,
  2.28914231e-01f, -4.69027460e-01f, 1.11810215e-01f, -2.77222693e-01f, -1.90259486e-01f, -8.93339291e-02f, 1.18095689e-01f, -2.31080472e-01f, -1.08679190e-01f, -3.98917720e-02f,
  -2.85925746e-01f, -5.85835427e-03f, -2.34166235e-01f, -5.11650555e-02f, -2.29408480e-02f, -1.39185488e-02f, -1.60861999e-01f, -9.79603752e-02f, -1.27175316e-01f, 7.91271776e-02f,
  -2.82131396e-02f, -2.43893880e-02f, -5.43457083e-03f, 1.43873185e-01f, 8.67349431e-02f, -6.86474890e-02f, 2.38223802e-02f, 5.06196357e-02f, 3.68892550e-02f, 6.97803050e-02f,
  1.53913409e-01f, 7.91503564e-02f, 9.32081267e-02f, -5.01975380e-02f, 2.46380419e-02f, 1.06753400e-02f, -1.02096230e-01f, -5.95073998e-02f, 1.52660713e-01f, 6.62712157e-02f,
  7.74586350e-02f, 1.54908672e-02f, -1.16415729e-03f, -2.08302848e-02f, -9.06073153e-02f, -9.72343013e-02f, 4.15669158e-02f, -6.31488487e-02f, -1.40921861e-01f, -9.65950117e-02f,
  -6.35717856e-03f, -3.61092947e-02f, -1.86596155e-01f, 5.53390831e-02f, 2.98193954e-02f, -1.89183503e-01f, -4.64403294e-02f, -2.05169115e-02f, 1.51956649e-02f, -1.10435940e-01f,
  1.67420492e-01f, -5.38915172e-02f, -6.68931231e-02f, -3.24239247e-02f, -1.29979372e-01f, -1.13409489e-01f, -2.01197430e-01f, -8.39156583e-02f, -1.56892940e-01f, 7.13668987e-02f,
  -2.69858111e-02f, -5.23369201e-02f, -1.77492321e-01f, 7.58336559e-02f, 1.94754407e-01f, 1.20853662e-01f, 7.29411617e-02f, -6.77990168e-03f, 1.14299376e-02f, 3.57088447e-03f,
  3.01072076e-02f, 2.02008247e-01f, 2.80251563e-01f, 2.44944185e-01f, 1.29135042e-01f, 1.77108154e-01f, 1.63930103e-01f, 1.54940531e-01f, 2.92314380e-01f, 2.96729803e-01f,
  4.59844410e-01f, 6.24531150e-01f, 1.83653057e-01f, 2.19529495e-01f, 1.69351026e-01f, 1.10353984e-01f, 4.35974032e-01f, 3.88678908e-01f, 1.99363157e-01f, 2.13295639e-01f,
  2.92355895e-01f, 2.44930238e-01f, 2.07574829e-01f, 2.02843428e-01f, 2.95307964e-01f, 2.69944370e-01f, 2.22237274e-01f, 7.23436400e-02f, -6.91862255e-02f, 1.85753167e-01f,
  1.49420962e-01f, 2.53543615e-01f, 1.94170535e-01f, 1.73447028e-01f, 2.88246423e-01f, 1.18953593e-01f, 1.56186163e-01f, 1.04041189e-01f, 3.22619438e-01f, 3.27207893e-01f,
  -2.26623192e-01f, 2.09461793e-01f, -1.30063474e-01f, -3.37152034e-02f, -1.58277288e-01f, 7.03861043e-02f, -3.25777084e-02f, -9.74061619e-03f, -9.71442312e-02f, -3.34488899e-02f,
  -4.10601534e-02f, -9.40423906e-02f, -1.83337435e-01f, -2.97743026e-02f, -1.50975868e-01f, -1.59306616e-01f, -7.21907392e-02f, -1.06286285e-02f, 3.07397712e-02f, -1.59846902e-01f,
  -6.64647296e-02f, -1.14858270e-01f, -1.08441830e-01f, -1.92939118e-01f, -1.65891815e-02f, -5.88638484e-02f, -9.95376930e-02f, 1.30355097e-02f, -3.29641886e-02f, 4.16398905e-02f,
  -1.44362971e-01f, -4.78051528e-02f, -8.39143023e-02f, -4.48560007e-02f, -1.43211648e-01f, -8.95597935e-02f, -1.01893775e-01f, -1.26221910e-01f, -1.26954215e-02f, -2.77755801e-02f,
  -1.27975121e-01f, -8.26273561e-02f, -1.89246871e-02f, -1.00422084e-01f, -7.59865567e-02f, -5.18103093e-02f, 2.53856163e-02f, -1.42911971e-01f, -2.46587038e-01f, -1.20526470e-01f,
  -7.67212138e-02f, 7.79925520e-03f, -8.28542784e-02f, -6.83384240e-02f, -5.39889969e-02f, -2.06335813e-01f, -4.76249382e-02f, -1.11866087e-01f, 1.77581683e-02f, 1.08422756e-01f,
  -2.19714306e-02f, -2.87422359e-01f, -9.64979641e-03f, 2.32331067e-01f, -7.83841964e-03f, 2.50867754e-03f, 8.06896240e-02f, -3.32926326e-02f, 3.95858213e-02f, -2.40256116e-02f,
  -5.71719222e-02f, -7.96924438e-03f, -8.39181989e-02f, -3.30507495e-02f, -9.12611485e-02f, -3.22939791e-02f, 4.13559303e-02f, 1.39172867e-01f, 8.01183879e-02f, -9.06541571e-02f,
  -4.93027382e-02f, -6.44375458e-02f, -1.15982704e-01f, -1.44343702e-02f, -1.67794861e-02f, -1.42669156e-01f, -8.32914189e-02f, -7.62671232e-02f, -1.22611664e-01f, -2.69750301e-02f,
  5.58977723e-01f, 2.80582279e-01f, 4.96668279e-01f, 1.04526676e-01f, 1.33669958e-01f, 2.21621662e-01f, 4.35041159e-01f, 1.44633904e-01f, -6.49536476e-02f, 6.57088533e-02f,
  -2.47980639e-01f, -4.20608193e-01f, -3.37234288e-01f, -3.36503953e-01f, 8.32889378e-02f, 1.75506860e-01f, 1.18933422e-02f, 2.00502783e-01f, 1.40102118e-01f, 6.00137971e-02f,
  -7.36637115e-02f, 3.38879563e-02f, 1.15561612e-01f, 4.01569977e-02f, 1.20821223e-01f, -2.08674416e-01f, 1.09510019e-01f, 1.49471253e-01f, 8.89362916e-02f, 1.40962228e-01f,
  6.61903471e-02f, 2.10563362e-01f, -3.30906987e-01f, -2.45387852e-01f, -2.90572569e-02f, -1.60969824e-01f, 3.76130715e-02f, -5.86837903e-02f, -9.01930034e-02f, -6.48807362e-02f,
  -4.93188910e-02f, -9.59403515e-02f, 2.60152463e-02f, 2.02418547e-02f, 1.47934258e-01f, 8.06595385e-02f, -5.27377836e-02f, -7.63098150e-02f, -1.51743054e-01f, -2.18667854e-02f,
  -3.00485671e-01f, 1.24864168e-01f, 2.72290736e-01f, -6.42163157e-02f, -7.64025794e-03f, -1.49910629e-01f, 1.23517193e-01f, 6.87039737e-03f, 2.70652100e-02f, 1.78966939e-03f,
  -3.19327235e-01f, 3.10957953e-02f, 1.16694726e-01f, -4.81394343e-02f, -1.06591336e-01f, 2.33541913e-02f, -1.11724332e-01f, -7.43826032e-02f, 6.97556436e-02f, 1.04197793e-01f,
  -1.42542228e-01f, -4.92478758e-02f, -4.66979109e-02f, -8.32586586e-02f, -1.74601600e-01f, -1.79585349e-02f, 1.06152564e-01f, 5.01853740e-03f, -5.53287491e-02f, -8.78440291e-02f,
  -1.71202589e-02f, 7.80837983e-02f, 3.55898729e-03f, -4.51037772e-02f, -2.25195900e-01f, -1.00457095e-01f, -9.85476896e-02f, -1.01906657e-01f, -1.69398025e-01f, -1.12042129e-02f,
  -1.83043361e-01f, -1.24669395e-01f, -1.56633660e-01f, 8.58532339e-02f, 1.92281768e-01f, 2.18761526e-02f, 2.05503479e-02f, -8.15219283e-02f, 1.24973562e-02f, 1.34044662e-01f,
  -4.07988625e-03f, -7.84550607e-03f, -2.00711866e-03f, 5.46772126e-03f, -5.25762476e-02f, -4.86634858e-02f, -9.24157947e-02f, -3.16901542e-02f, -1.57043412e-01f, -9.29760411e-02f,
  -2.18540952e-01f, 1.15704887e-01f, -3.10814269e-02f, -2.28645504e-02f, -1.67896315e-01f, -2.48305172e-01f, -2.59723719e-02f, -9.98496823e-03f, -3.93393114e-02f, -1.19879805e-02f,
  6.36289954e-01f, 1.01900145e-01f, 1.68913797e-01f, 1.59792289e-01f, 3.97230536e-02f, -6.02666289e-02f, -3.63093689e-02f, 4.49885726e-02f, 5.73823750e-02f, 6.09029830e-02f,
  1.10440426e-01f, 1.83920294e-01f, 1.69204801e-01f, 1.33216262e-01f, 9.57515240e-02f, 8.57901797e-02f, 1.27553225e-01f, 2.25278273e-01f, 1.65597007e-01f, 1.01584174e-01f,
  9.58032534e-02f, -3.44750397e-02f, 3.92422564e-02f, 1.35177761e-01f, 1.73465580e-01f, 1.06646806e-01f, 2.25735065e-02f, 5.34429541e-03f, 1.09003358e-01f, 2.54882008e-01f,
  3.10328215e-01f, 2.54293591e-01f, -5.81496060e-02f, -4.10921685e-02f, -3.09510790e-02f, -1.18656181e-01f, -5.95255271e-02f, -7.38315880e-02f, -7.71615356e-02f, -1.29357681e-01f,
  6.01615943e-03f, 3.42934616e-02f, -1.35399580e-01f, -7.56628886e-02f, -8.11595470e-02f, -4.76930104e-02f, 2.80088857e-02f, 8.82058814e-02f, 1.63312703e-02f, 7.06964508e-02f,
  3.08688600e-02f, -3.45939286e-02f, -5.88108338e-02f, -2.33192630e-02f, 1.13562301e-01f, 8.73993114e-02f, -1.53488601e-02f, 3.91259007e-02f, 2.31577363e-02f, 6.52370751e-02f,
  -1.27567416e-02f, -2.32818071e-02f, 9.78921205e-02f, 1.90833479e-01f, 1.88779414e-01f, 1.13368697e-01f, 9.06742141e-02f, 1.65130775e-02f, -5.42418957e-02f, -6.54603913e-02f,
  7.11867437e-02f, 1.00238025e-01f, 8.36605951e-02f, 3.69302183e-02f, 6.14789985e-02f, -1.61099955e-01f, -6.52457923e-02f, -9.39330906e-02f, 2.09621377e-02f, -4.38430980e-02f,
  7.99130797e-02f, 5.69284447e-02f, -9.27086994e-02f, 1.56470705e-02f, -8.31102952e-02f, 4.92656752e-02f, -7.59797022e-02f, -6.79913759e-02f, -1.23593599e-01f, -8.38569626e-02f,
  -6.10013425e-01f, -2.82776523e-02f, 1.85212106e-01f, -7.19651300e-03f, -8.47179964e-02f, -1.69444096e-03f, 6.81647658e-02f, -9.26192701e-02f, 5.78205683e-04f, -1.13287903e-01f,
  -4.78798188e-02f, 8.57496858e-02f, -1.40003916e-02f, -2.24960092e-02f, 8.94761644e-03f, -1.95498150e-02f, 1.51087902e-02f, 2.10055467e-02f, -1.62123442e-01f, -2.16471832e-02f,
  -1.90713927e-01f, -1.97219059e-01f, -1.76347658e-01f, -1.62449419e-01f, 1.81921665e-02f, -9.62269977e-02f, -1.54483169e-01f, -2.64770314e-02f, -1.84455991e-01f, -1.31827831e-01f,
  -1.74655076e-02f, 4.81496453e-01f, 3.87393624e-01f, -2.36784354e-01f, 1.15293719e-01f, 2.77199864e-01f, 2.48733237e-01f, 1.17177688e-01f, -3.83285880e-02f, 2.12812349e-01f,
  3.02914590e-01f, -3.08312804e-01f, -1.39259577e-01f, -3.22490752e-01f, -2.32679993e-01f, 8.14186186e-02f, -3.63533869e-02f, -2.46824458e-01f, -3.92857075e-01f, -2.67896175e-01f,
  -3.17781836e-01f, -2.05367252e-01f, -2.39059031e-01f, -1.71242669e-01f, 4.80468050e-02f, -2.64130920e-01f, 2.74246246e-01f, 1.06850997e-01f, 1.25354126e-01f, -8.44825134e-02f,
  4.17497307e-02f, 4.24685270e-01f, -4.11875725e-01f, -2.98564047e-01f, 8.95767361e-02f, -1.58812016e-01f, 4.28666472e-02f, 4.25063120e-03f, -1.35738224e-01f, 9.55792237e-03f,
  -1.15754150e-01f, -1.18048687e-03f, 5.92764094e-02f, -1.77032620e-01f, -1.51023949e-02f, -7.03925937e-02f, -5.35864979e-02f, -1.68530449e-01f, -8.34266022e-02f, 1.54960737e-01f,
  -1.87463552e-01f, 1.41790658e-01f, 3.49116862e-01f, 1.90461054e-01f, 1.46963507e-01f, -1.53880477e-01f, 2.26110965e-01f, 3.22621800e-02f, 2.25230217e-01f, 2.03260630e-02f,
  -5.49905784e-02f, 7.61815952e-03f, -3.23073119e-02f, 7.98513591e-02f, -1.71802297e-01f, -7.02399611e-02f, -9.85782444e-02f, -9.20863226e-02f, -6.49488717e-02f, -1.54206529e-01f,
  5.88994622e-02f, 1.59553498e-01f, 2.13322453e-02f, 1.98767617e-01f, -1.57198519e-01f, 1.00990154e-01f, -7.83946514e-02f, 3.14945839e-02f, 1.27900481e-01f, 3.18308850e-03f,
  -6.92318901e-02f, 1.02997869e-02f, 7.19828391e-03f, -1.25684738e-01f, 1.29405141e-01f, 1.96413957e-02f, -8.89177844e-02f, -2.90085971e-02f, 5.59023209e-02f, 2.07565486e-01f,
  -4.56978649e-01f, -8.68741646e-02f, -2.07092822e-01f, -2.37139076e-01f, -2.54070293e-02f, -5.71060702e-02f, 1.00034237e-01f, 2.89194882e-02f, 7.16820359e-02f, -5.65385893e-02f,
  1.54939413e-01f, -2.01485772e-02f, 1.73730433e-01f, -1.00466341e-01f, -2.36337513e-01f, 2.02171202e-03f, -2.02065468e-01f, -2.08866745e-01f, -4.97030616e-02f, 4.48847748e-02f,
  -1.59070969e-01f, -1.39519766e-01f, -2.23438606e-01f, -1.43134147e-01f, 4.34020124e-02f, -2.20528901e-01f, -1.62532449e-01f, -2.08437040e-01f, -9.77517739e-02f, -3.09919059e-01f,
  -4.67013687e-01f, 5.01385808e-01f, 2.30385855e-01f, -2.83817261e-01f, 3.13844383e-01f, 3.27511489e-01f, 3.86707872e-01f, 1.64409690e-02f, -2.99371660e-01f, 1.30381674e-01f,
  2.11696178e-01f, -2.49155611e-01f, -1.12609103e-01f, -2.92257983e-02f, -4.43639569e-02f, 3.24022651e-01f, 2.12323159e-01f, -7.32851103e-02f, -2.91053474e-01f, -5.36699705e-02f,
  1.26285493e-01f, -1.37401178e-01f, -3.79295498e-01f, -1.41323552e-01f, 1.16955135e-02f, -6.57463893e-02f, 6.22414239e-02f, 5.20590469e-02f, 2.99024731e-01f, 2.06063345e-01f,
  -5.62406704e-02f, 1.10369779e-01f, -1.02695838e-01f, 2.68213195e-03f, 1.67270154e-01f, -1.69383302e-01f, -1.12573318e-01f, -1.15809739e-01f, 8.23430941e-02f, -8.91330093e-02f,
  1.38869300e-01f, 8.02916512e-02f, 1.14337221e-01f, -1.56661421e-02f, -2.79263537e-02f, -4.42010649e-02f, -1.36999100e-01f, -2.47748867e-01f, -2.19202891e-01f, -3.14173661e-02f,
  2.13449836e-01f, 1.08362868e-01f, 2.91717704e-03f, 2.35970486e-02f, -1.93636209e-01f, -2.13231549e-01f, -6.11846847e-03f, -6.93537742e-02f, -1.71098024e-01f, -2.18230978e-01f,
  2.22404092e-03f, 1.15291670e-01f, 7.01575205e-02f, 3.60084465e-03f, -1.16997259e-02f, 4.55062576e-02f, 7.31737316e-02f, 4.56226021e-02f, -1.25496406e-02f, -1.34890666e-02f,
  -1.16265155e-02f, 2.98896749e-02f, -1.26565741e-02f, 1.50710016e-01f, 1.38634462e-02f, -9.71250143e-03f, -1.70927402e-02f, -6.21474497e-02f, 8.92661065e-02f, -8.41863733e-03f,
  -1.23073824e-01f, -6.84306771e-02f, -4.61191088e-02f, -1.50479257e-01f, 6.59303442e-02f, 1.98832303e-02f, -4.34162617e-02f, -4.79517058e-02f, -1.12121038e-01f, 9.12092403e-02f,
  -3.82475317e-01f, 3.01569283e-01f, -1.60386786e-01f, 3.40960696e-02f, 1.10280968e-01f, 7.95626789e-02f, 5.30312359e-02f, 1.24737397e-01f, -8.27291049e-03f, -9.90619287e-02f,
  -1.64706566e-04f, 3.79211381e-02f, -2.71274429e-02f, -5.27703688e-02f, -9.74558964e-02f, -8.65032226e-02f, 1.10017955e-01f, -9.05575901e-02f, -1.01470694e-01f, -1.69691741e-02f,
  -2.54126620e-02f, -2.06180155e-01f, -3.13996702e-01f, -1.32630289e-01f, -1.48577735e-01f, -2.74139464e-01f, -1.85237378e-01f, -1.00469291e-01f, -1.69750348e-01f, -1.80562690e-01f,
  9.37402725e-01f, 8.29259008e-02f, 1.46774337e-01f, 8.71547759e-02f, -1.53978150e-02f, 1.98037788e-01f, 1.37470767e-01f, 1.49299502e-01f, 9.85960513e-02f, 1.41822293e-01f,
  2.36007556e-01f, 7.02913329e-02f, 8.12356099e-02f, 9.99870449e-02f, 1.40363008e-01f, -1.68502871e-02f, -9.06568170e-02f, 1.18614934e-01f, 1.56111211e-01f, 2.09172890e-01f,
  4.31601666e-02f, -1.38450239e-03f, 2.60870069e-01f, 1.34291947e-01f, 1.52685698e-02f, -6.18271418e-02f, 5.24092279e-02f, 9.34743136e-03f, 1.06694281e-01f, -1.34664237e-01f,
  2.41478294e-01f, 3.03103685e-01f, -9.04030576e-02f, -1.83863729e-01f, -7.16092214e-02f, -7.03351870e-02f, 8.99117589e-02f, -8.65991190e-02f, -5.39413802e-02f, -4.82818596e-02f,
  -5.49809337e-02f, -9.29959267e-02f, 5.67879528e-02f, 4.36683279e-03f, -3.46993841e-02f, -3.34268808e-03f, -1.52893802e-02f, 7.25931153e-02f, 5.59775382e-02f, -7.14867413e-02f,
  2.25091651e-02f, -5.31938784e-02f, 6.53326232e-03f, -1.18366532e-01f, 1.16047509e-01f, 2.41324157e-02f, -3.86954620e-02f, 6.47175163e-02f, 6.85882848e-03f, 7.71875158e-02f,
  2.19532102e-01f, 7.55141005e-02f, 1.57205820e-01f, 1.55294687e-01f, 2.92649508e-01f, 8.97952393e-02f, -5.36646359e-02f, -6.05863035e-02f, 6.27926588e-02f, 7.14955702e-02f,
  -8.51736814e-02f, -7.25548109e-03f, 1.41706079e-01f, 4.78257127e-02f, -3.56488414e-02f, -7.73882214e-03f, -6.46228995e-03f, -7.95450658e-02f, 1.37340918e-01f, -1.66840348e-02f,
  8.85818228e-02f, 1.19070569e-02f, 1.19983084e-01f, 1.49865493e-01f, 3.22643630e-02f, 1.12302318e-01f, 1.53787225e-01f, 9.02024209e-02f, 2.64295042e-02f, 4.98161130e-02f,
  -4.20590848e-01f, 2.09281400e-01f, 1.01456620e-01f, -6.56195953e-02f, -2.32615378e-02f, -1.88477580e-02f, 5.04324548e-02f, -1.05806820e-01f, -6.01976141e-02f, -1.86018273e-01f,
  -6.87226579e-02f, 4.18585986e-02f, -6.08225632e-03f, 1.11183539e-01f, 3.93205881e-03f, 2.49636937e-02f, 5.51666990e-02f, -1.83713213e-02f, -1.29969403e-01f, -1.34027064e-01f,
  -1.64035037e-01f, -1.29104003e-01f, -1.28573984e-01f, -9.39173698e-02f, -6.87781125e-02f, 3.43640447e-02f, -3.15183923e-02f, -9.30184796e-02f, 6.65371418e-02f, 7.23962188e-02f,
  -2.36785054e-01f, -4.90421094e-02f, -2.59617537e-01f, -4.14273702e-02f, -8.14762618e-03f, -4.77580205e-02f, -3.66176702e-02f, 1.57648474e-01f, 2.30903625e-01f, -2.49223821e-02f,
  -9.30778980e-02f, -1.64524138e-01f, -2.14995205e-01f, -1.74695134e-01f, -2.63705373e-01f, -1.19828515e-01f, -2.11671501e-01f, -3.52957785e-01f, -2.90754646e-01f, -1.01361096e-01f,
  -1.22524701e-01f, -2.11802810e-01f, -2.69716918e-01f, -6.91132024e-02f, 1.43365994e-01f, -8.61841366e-02f, -4.75301147e-02f, -9.81193185e-02f, -1.06197037e-01f, -1.36606917e-01f,
  -4.03583683e-02f, 6.17170259e-02f, 4.96238805e-02f, -7.76844025e-02f, 1.03893079e-01f, 7.33302673e-03f, 6.35151118e-02f, 4.12284806e-02f, -4.74181101e-02f, -2.26605916e-03f,
  -1.07987165e-01f, 5.26960343e-02f, -1.20289885e-02f, -1.48781538e-02f, 2.12012790e-02f, 1.83091480e-02f, -1.55955449e-01f, -1.52342811e-01f, -3.90586108e-02f, 6.63396642e-02f,
  -1.20523505e-01f, -1.56970590e-01f, -1.74786851e-01f, 5.26473261e-02f, 1.40820861e-01f, -1.33376479e-01f, 1.02264702e-01f, 1.43384084e-01f, 5.52104637e-02f, 5.54230474e-02f,
  1.68666840e-01f, -4.69598100e-02f, 1.25466632e-02f, 4.02499065e-02f, 2.85249413e-03f, 1.70522806e-04f, 7.72691285e-03f, -5.13713807e-02f, 5.63184805e-02f, 4.67955656e-02f,
  7.12809265e-02f, 3.68015207e-02f, 3.85109894e-02f, 2.61846185e-02f, -2.02062074e-02f, -5.11187911e-02f, -6.83984160e-02f, -1.76872388e-02f, -8.95117149e-02f, -5.24564572e-02f,
  -6.15226999e-02f, 4.51310463e-02f, 2.40919739e-03f, 2.05597710e-02f, -5.20330630e-02f, 3.76729071e-02f, 6.73279166e-02f, 5.56325652e-02f, 3.91895995e-02f, 4.82540987e-02f,
  8.59877560e-03f, -1.03260271e-01f, 6.02845382e-03f, -2.41634510e-02f, 1.02464363e-01f, 6.23679273e-02f, -6.04075566e-03f, -5.89493290e-02f, 1.05376085e-02f, -1.10472767e-02f,
  -6.26960471e-02f, 6.35909438e-02f, 5.80699295e-02f, 2.95457933e-02f, -3.80555242e-02f, 2.81087775e-02f, -1.53865725e-01f, -2.56469339e-01f, -1.00542553e-01f, 8.07164758e-02f,
  -8.49690363e-02f, -1.53438732e-01f, -3.25399518e-01f, -1.41789034e-01f, 1.49521694e-01f, -1.78466618e-01f, -1.43639967e-01f, 4.49758135e-02f, -9.13134664e-02f, -1.70242917e-02f,
  -3.48326355e-01f, -3.67554605e-01f, -3.88604373e-01f, -2.16434479e-01f, 2.21372545e-02f, 2.07451925e-01f, 2.37487838e-01f, 2.58963764e-01f, -1.55775547e-02f, -2.66488552e-01f,
  -9.82805900e-03f, 1.98368013e-01f, 3.84048261e-02f, 1.95031136e-01f, 2.42671937e-01f, -1.28866568e-01f, -8.89989734e-02f, 5.38840182e-02f, 4.20878649e-01f, 4.33636725e-01f,
  1.70190051e-01f, -6.57598600e-02f, -7.66678974e-02f, 1.61129162e-01f, -1.66333154e-01f, 5.11524081e-02f, -3.74149531e-01f, -1.93372235e-01f, -1.30549505e-01f, -2.77824670e-01f,
  -4.55862284e-01f, -2.03240603e-01f, 2.58861572e-01f, 1.00834705e-01f, -1.01338558e-01f, -8.18557590e-02f, -5.65776788e-02f, -2.62211382e-01f, -1.61143634e-02f, -9.86013561e-02f,
  -1.31258562e-01f, 7.36443996e-02f, -1.43570065e-01f, -2.23810337e-02f, -1.37177587e-01f, 1.36930749e-01f, -8.10038149e-02f, 1.17053002e-01f, -5.20869531e-02f, 3.41708995e-02f,
  1.47855937e-01f, -9.27192271e-02f, -2.41811976e-01f, -6.08189683e-03f, -1.61523912e-02f, -7.70101622e-02f, -5.14677949e-02f, 1.82476211e-02f, -1.05630957e-01f, -3.32799017e-01f,
  -3.40673812e-02f, -1.34623691e-01f, -4.04163860e-02f, -4.27418686e-02f, 9.84343141e-02f, -9.61619392e-02f, 8.95055849e-03f, 1.21630594e-01f, 1.66087691e-02f, -7.96364471e-02f,
  4.79524210e-02f, -5.09520099e-02f, 1.64715469e-01f, 8.92387424e-03f, 3.43592428e-02f, -1.03919208e-01f, 5.25097251e-02f, 5.56797646e-02f, 7.70514179e-03f, 1.03348102e-02f,
  3.39392833e-02f, 6.83407998e-03f, -1.53317943e-01f, 2.07764030e-01f, 4.33414206e-02f, 9.53354407e-03f, -1.06563658e-01f, 1.16664208e-01f, -1.16153046e-01f, -1.76885098e-01f,
  -1.96668506e-01f, 7.64429420e-02f, -2.03421906e-01f, 1.24692120e-01f, -1.03449680e-01f, -2.04431061e-02f, -6.95657432e-02f, 3.75339799e-02f, -1.34391502e-01f, 1.39723256e-01f,
  4.04692665e-02f, 1.51631748e-02f, -2.75256634e-01f, 1.01728894e-01f, 6.16119429e-02f, -1.97447576e-02f, 1.36543661e-02f, 1.12331666e-01f, 9.68344137e-02f, -7.59150684e-02f,
  -1.23349905e-01f, 5.24062030e-02f, -1.16402619e-01f, 1.38730425e-02f, -2.14667663e-01f, -7.75356144e-02f, -1.91721335e-01f, -6.71005026e-02f, -2.07396716e-01f, -3.29187155e-01f,
  2.36461442e-02f, 7.86337852e-02f, 1.48497492e-01f, 2.42013261e-01f, 1.90691099e-01f, -9.01420694e-03f, -8.27133656e-02f, -1.36044681e-01f, -8.19449574e-02f, -3.79179455e-02f,
  -1.49685681e-01f, -5.02900146e-02f, -9.47762579e-02f, -4.77435216e-02f, -2.01861653e-02f, 1.51126474e-01f, 3.69009376e-01f, 3.20948511e-01f, 3.47580761e-02f, 1.64834246e-01f,
  2.21855670e-01f, 6.13183863e-02f, 3.14949453e-02f, 1.35643542e-01f, 3.11255425e-01f, 1.30110338e-01f, 2.20983056e-04f, 1.70440167e-01f, 1.04312100e-01f, 6.37301385e-01f,
  1.32298078e-02f, -1.34499714e-01f, -8.95148739e-02f, -9.01243612e-02f, 1.10049751e-02f, 5.22222836e-03f, 3.51220481e-02f, 6.75965548e-02f, 4.78288159e-02f, 4.24896367e-02f,
  8.58038664e-02f, -5.19676507e-02f, 5.01334704e-02f, 7.77773932e-03f, -1.07209176e-01f, -9.79480743e-02f, -7.76773691e-03f, -2.80232280e-02f, -2.98253652e-02f, -3.96883674e-02f,
  1.99359983e-01f, 6.51066005e-02f, -8.50616693e-02f, -8.03801641e-02f, -1.32293403e-01f, -1.74077094e-01f, -1.22367226e-01f, -8.84270892e-02f, -3.54357392e-01f, 3.98960039e-02f,
  -5.56023829e-02f, -1.26966715e-01f, 1.49662914e-02f, 4.79187220e-02f, 1.75709790e-03f, 2.86206473e-02f, 3.61537002e-02f, 4.65436056e-02f, 1.54324202e-02f, 1.17223941e-01f,
  7.01204762e-02f, 5.53070903e-02f, 4.83480981e-03f, 6.30166987e-03f, -2.71241479e-02f, -3.60907195e-03f, 1.19263940e-01f, -3.31093706e-02f, -5.83691814e-04f, -1.75051153e-01f,
  -8.16123709e-02f, 1.35727867e-01f, 1.07450187e-02f, 9.18434784e-02f, -4.94110137e-02f, -3.73171531e-02f, 1.21046327e-01f, -6.28874227e-02f, -4.88020703e-02f, -5.50818406e-02f,
  -3.29588234e-01f, -3.24341983e-01f, 1.15560172e-02f, -4.78696115e-02f, -4.07803617e-02f, -9.00946259e-02f, -4.40376252e-02f, -2.24604402e-02f, -2.53005922e-02f, -4.86539491e-02f,
  -4.43007052e-02f, -2.57242937e-02f, -1.37481138e-01f, 4.55946140e-02f, -7.72403479e-02f, -1.18129306e-01f, 4.81814286e-03f, 7.02495873e-02f, -1.18168086e-01f, 2.61150580e-02f,
  1.19309634e-01f, -6.33301064e-02f, -7.46799782e-02f, -6.62155002e-02f, -1.11480579e-01f, -2.48147383e-01f, -1.29955783e-01f, -1.21474236e-01f, -3.68499815e-01f, -1.22237399e-01f,
  5.00703275e-01f, 2.30024196e-02f, -5.02119601e-01f, -4.74198535e-03f, -4.23620850e-01f, -4.44645047e-01f, -2.45676890e-01f, -5.60165010e-02f, -1.24775562e-02f, -3.28125022e-02f,
  1.34163518e-02f, 1.22209847e-01f, 1.99530706e-01f, 2.37266887e-02f, 9.56863016e-02f, -6.60000890e-02f, -1.20607823e-01f, -1.07414611e-01f, -3.12519193e-01f, -4.02885467e-01f,
  -1.85719207e-01f, -7.51476511e-02f, 2.64507122e-02f, -1.24125585e-01f, -2.69135773e-01f, -1.68131530e-01f, -2.11959451e-01f, -2.70555735e-01f, -3.23000520e-01f, -1.97447032e-01f,
  -1.92564592e-01f, -2.16735169e-01f, 3.20848301e-02f, 1.24160796e-01f, 1.48085840e-02f, 1.79898933e-01f, 7.83409085e-03f, 1.15257524e-01f, 2.09386095e-01f, 8.44880417e-02f,
  5.13844416e-02f, 4.62200753e-02f, 1.22206479e-01f, -1.17029212e-01f, -1.35794774e-01f, -1.52939856e-01f, -5.37588932e-02f, 6.48908094e-02f, 1.37390867e-01f, -6.66188300e-02f,
  -3.90819795e-02f, 1.86839849e-02f, 1.40499976e-02f, 4.49342048e-03f, -1.06792018e-01f, -7.10301772e-02f, -2.66856700e-01f, -2.74061620e-01f, -1.55643731e-01f, -7.07264468e-02f,
  -5.01576550e-02f, 8.65028352e-02f, -9.40394849e-02f, -1.83615424e-02f, 1.24970764e-01f, 9.57321897e-02f, 1.65679097e-01f, 1.29043639e-01f, -1.43209482e-02f, -1.11609876e-01f,
  2.12553740e-02f, 7.24065155e-02f, 1.06379382e-01f, 8.63701776e-02f, -7.23651871e-02f, 4.49664742e-02f, 9.01338309e-02f, -3.77908051e-02f, 6.13216013e-02f, 1.44953281e-01f,
  3.04910392e-02f, 2.89867595e-02f, 9.10441279e-02f, 6.84267208e-02f, -1.14194490e-02f, -2.43641306e-02f, -6.35877177e-02f, -7.97114149e-02f, -4.95401844e-02f, -1.73835099e-01f,
  2.12448999e-01f, -4.76133339e-02f, 1.29409596e-01f, -1.25317760e-02f, -3.98798920e-02f, -3.53197940e-02f, -3.52498665e-02f, 1.41714588e-01f, 1.70661837e-01f, -3.32082957e-02f,
  -1.39455527e-01f, 1.02526590e-01f, 5.80408936e-03f, -5.87280579e-02f, -3.92659269e-02f, -8.06133449e-02f, 5.26727960e-02f, 1.05731174e-01f, -1.79979336e-02f, -1.55798241e-01f,
  -1.65090468e-02f, 2.78953254e-01f, 3.26664567e-01f, 1.26419812e-01f, -1.50048062e-01f, 6.68121427e-02f, -8.11909884e-02f, -1.97950542e-01f, 9.48368758e-02f, 2.56867856e-01f,
  -3.33999306e-01f, -2.19912559e-01f, -1.73394568e-02f, 2.03770213e-03f, 3.80928159e-01f, -8.44545662e-02f, -4.22107160e-01f, -2.72026688e-01f, 1.60910293e-01f, -5.92432097e-02f,
  2.43599251e-01f, 3.18869859e-01f, 9.26770493e-02f, -6.79697022e-02f, -4.12819445e-01f, -3.48562300e-01f, -1.81449279e-01f, -1.71673477e-01f, -6.27393126e-02f, 6.98023587e-02f,
  1.46490648e-01f, 1.87703669e-02f, -1.36740819e-01f, -1.16862670e-01f, 1.30094051e-01f, 5.01290485e-02f, 4.54209521e-02f, 9.06624869e-02f, -6.38309047e-02f, 1.04669824e-01f,
  -1.61320008e-02f, -1.02038994e-01f, 2.74960473e-02f, 2.15176836e-01f, 1.98187590e-01f, -1.24348529e-01f, -1.55817330e-01f, -3.65372673e-02f, 1.09853745e-02f, -1.37917951e-01f,
  2.07527772e-01f, 4.48627919e-02f, 9.07432511e-02f, 2.65102815e-02f, -4.78162430e-04f, -1.73200846e-01f, -8.47046003e-02f, -2.86856681e-01f, -2.12329566e-01f, -6.19534142e-02f,
  2.17289448e-01f, 1.92398205e-01f, -1.58005014e-01f, -1.93680719e-01f, -2.81308353e-01f, -9.02224854e-02f, -1.23440303e-01f, -1.10113323e-01f, -3.25661719e-01f, -2.54659176e-01f,
  7.09641799e-02f, 5.90931177e-02f, 9.62681770e-02f, -7.51601830e-02f, -2.32285969e-02f, 5.93830571e-02f, 3.14329676e-02f, 2.09901314e-02f, 5.09560667e-02f, -2.29928121e-02f,
  -5.16851582e-02f, 2.46730912e-02f, -6.56140968e-02f, -7.19268620e-02f, 1.25048188e-02f, 7.96987116e-02f, -4.44408953e-02f, -4.29189540e-02f, -4.35924195e-02f, -3.35032158e-02f,
  3.44269723e-02f, 2.12147264e-04f, 1.42476663e-01f, -6.75729066e-02f, -3.09188720e-02f, -1.10533655e-01f, 5.11748902e-02f, 7.64032006e-02f, -4.16375622e-02f, -6.13868497e-02f,
  -6.27774820e-02f, -6.92404201e-03f, -1.06444843e-01f, 7.39609599e-02f, 7.66277164e-02f, 1.29880026e-01f, 3.31710977e-03f, 3.59103680e-02f, 2.60439496e-02f, -1.11885436e-01f,
  -7.52089918e-02f, -1.09344743e-01f, -5.64143695e-02f, -7.19670206e-02f, -8.96162242e-02f, -4.17090878e-02f, 1.88384000e-02f, -4.05830331e-03f, -6.33177683e-02f, 8.31749812e-02f,
  -9.45301428e-02f, -1.43332005e-01f, -2.14015931e-01f, -2.44047031e-01f, -1.69372931e-02f, -1.99568346e-01f, -2.31139228e-01f, -1.24409169e-01f, -3.56092125e-01f, -4.74857509e-01f,
  6.38967574e-01f, 2.91842688e-02f, -5.93078174e-02f, 2.49222606e-01f, -6.75099194e-02f, -4.87996265e-02f, -2.97690392e-01f, -5.66593856e-02f, 4.96244617e-02f, 1.16120316e-01f,
  1.97801366e-01f, 2.24580273e-01f, 1.28774181e-01f, 9.57431570e-02f, -5.54050319e-02f, -4.51562963e-02f, -1.05950749e-02f, 1.35519251e-01f, 8.88600349e-02f, 5.94926812e-02f,
  8.70084912e-02f, 3.57113294e-02f, 2.79200673e-01f, 4.45313454e-02f, 6.88817725e-02f, 7.68371811e-03f, -9.76849124e-02f, -1.60755794e-02f, -1.90822538e-02f, 3.92288417e-02f,
  -4.79324348e-02f, 1.51235327e-01f, -9.30503011e-02f, 8.80508218e-03f, -7.50363618e-02f, 5.01124747e-02f, 9.60009843e-02f, -3.62223201e-02f, -1.01833656e-01f, -9.02071446e-02f,
  -7.26600438e-02f, -7.00151026e-02f, -9.88241099e-03f, 2.47547533e-02f, -9.59427357e-02f, -5.09349965e-02f, -7.01684728e-02f, -4.66117971e-02f, 1.67788006e-02f, 3.11456937e-02f,
  -1.73248146e-02f, 9.75209773e-02f, -6.53740689e-02f, -1.12352781e-01f, 2.09126379e-02f, -6.72156864e-04f, -1.10924475e-01f, -5.68327233e-02f, 2.61704270e-02f, 1.29969537e-01f,
  2.41283983e-01f, 1.87141612e-01f, 1.12773947e-01f, -8.43439102e-02f, -5.95079213e-02f, -8.54411870e-02f, -7.57911727e-02f, -7.09302425e-02f, -3.86108346e-02f, -3.98558471e-03f,
  -1.01500750e-01f, 1.15051471e-01f, -7.61891678e-02f, 8.39847177e-02f, 1.78833410e-01f, 7.92684257e-02f, -6.56756088e-02f, -3.49888802e-02f, 3.37845720e-02f, 3.61980386e-02f,
  -1.25655718e-02f, -2.03220293e-01f, -7.36676343e-03f, -1.47107422e-01f, -1.00645535e-01f, -3.22648585e-02f, 5.94833344e-02f, 1.78855494e-01f, 1.18263058e-01f, 2.82555595e-02f,
  -3.47048789e-01f, 5.36199994e-02f, 1.37881503e-01f, -9.98464599e-02f, -1.30909011e-01f, -1.08656652e-01f, 3.53817083e-02f, -2.73931883e-02f, -2.33222514e-01f, -1.12267017e-01f,
  -1.07139736e-01f, 3.38530354e-02f, -4.62229587e-02f, -1.47448465e-01f, -3.55527624e-02f, -5.08844554e-02f, -3.71554022e-04f, -1.17229931e-01f, -5.28936796e-02f, -1.02786966e-01f,
  -1.08950019e-01f, 5.05784974e-02f, -6.22682050e-02f, -1.10318504e-01f, -6.20828792e-02f, 1.07934952e-01f, -1.37487724e-01f, 1.02693085e-02f, 5.39150741e-03f, 1.18797466e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 52)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 52;
const float L0_fan_Bp_bar_data[] = {
  4.07780647e-01f, 3.70853394e-01f, 5.31445980e-01f, 2.42262781e-01f, 3.44962299e-01f, 2.75312066e-01f, 4.13238525e-01f, 3.31313521e-01f, 1.71983048e-01f, 2.36866087e-01f,
  5.60354233e-01f, 4.45311010e-01f, 3.94043773e-01f, 4.35705215e-01f, 4.38281417e-01f, 3.36528242e-01f, 1.10501416e-01f, 4.61401910e-01f, 5.55922627e-01f, 2.45488733e-01f,
  5.33811331e-01f, 3.03530931e-01f, 3.74091446e-01f, 3.65968019e-01f, 5.71824431e-01f, 4.96946454e-01f, 1.41072288e-01f, 4.52795029e-01f, 3.52884173e-01f, 6.00408971e-01f,
  3.54589552e-01f, 4.41693991e-01f, 6.19867742e-01f, -9.20760110e-02f, 1.78048983e-01f, 4.67529625e-01f, 6.91064522e-02f, 5.60653329e-01f, 3.32948059e-01f, 4.93882835e-01f,
  1.43533364e-01f, 3.88595521e-01f, 3.58755261e-01f, 3.80055219e-01f, 3.30175102e-01f, 5.85712850e-01f, 1.58335119e-01f, 2.41108343e-01f, 2.58224726e-01f, 3.79852563e-01f,
  1.80592194e-01f, 5.59163213e-01f
};

// L1_linear_W (Shape: 12 x 128)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 128;
const float L1_linear_W_data[] = {
  -1.03767976e-01f, 6.39741644e-02f, -8.13718513e-02f, -2.71317959e-01f, -2.35644653e-01f, -1.09078987e-02f, -2.74777144e-01f, -4.65758145e-02f, 4.28715572e-02f, -1.33244723e-01f,
  6.41124649e-03f, -6.79546595e-02f, 3.31364051e-02f, -1.58380792e-02f, -2.14297660e-02f, -1.67827293e-01f, -2.45364562e-01f, 1.06893163e-02f, 2.12328229e-02f, -1.18650787e-01f,
  -1.41488567e-01f, -2.85984837e-02f, -7.21328855e-02f, -7.24570677e-02f, -2.32910201e-01f, -1.41019285e-01f, 4.19291928e-02f, 7.15790465e-02f, 1.29379297e-03f, -9.65468213e-02f,
  -1.24543205e-01f, -2.65963040e-02f, -1.92027949e-02f, -3.04382481e-02f, -2.24038959e-02f, -9.25779119e-02f, -8.02057013e-02f, -8.44829679e-02f, -5.78781106e-02f, -5.84403835e-02f,
  -1.73686847e-01f, 7.58650675e-02f, 7.98517540e-02f, -2.42614876e-02f, -1.38308808e-01f, 2.82468230e-01f, -5.82347475e-02f, 9.07169655e-02f, -3.58896367e-02f, -4.95669767e-02f,
  -1.21796876e-01f, -1.16968736e-01f, 1.80797428e-01f, -1.59156583e-02f, 4.42650318e-02f, 1.37521746e-02f, 8.99032429e-02f, -3.88172604e-02f, 1.30846277e-01f, 1.14663839e-01f,
  -2.75581360e-01f, 4.08227324e-01f, -1.71841115e-01f, 1.49061933e-01f, 4.42777015e-03f, -3.25942901e-03f, 2.24002823e-02f, -6.03580708e-03f, 1.51048318e-01f, -3.27693373e-02f,
  1.15378268e-01f, -1.22771226e-01f, 1.59262563e-04f, 3.73712890e-02f, -1.26229480e-01f, 5.98935261e-02f, -4.86625969e-01f, -5.51617384e-01f, -6.77998483e-01f, -1.04660280e-01f,
  -1.71075284e-01f, 1.81956410e-01f, -1.76687613e-01f, 5.23596942e-01f, 3.09121370e-01f, -2.07322225e-01f, -4.56430674e-01f, -3.73639762e-01f, 4.37859118e-01f, 2.59301931e-01f,
  -1.13504259e-02f, -5.77596202e-02f, -2.13280559e-01f, -1.38753623e-01f, -1.48692861e-01f, -7.33153284e-01f, -3.56090218e-01f, -1.98344931e-01f, -4.91982758e-01f, -3.29012871e-02f,
  -4.29388344e-01f, -5.63204825e-01f, 3.89017940e-01f, -5.92512548e-01f, -2.32905582e-01f, -4.45279703e-02f, 1.85656697e-01f, -4.33804035e-01f, 2.95887470e-01f, 3.66821408e-01f,
  -1.37812421e-01f, 3.50054055e-01f, 1.89968064e-01f, -1.85981199e-01f, 6.05669618e-01f, 2.35968128e-01f, -3.29162776e-01f, -8.23324174e-02f, -1.53687457e-02f, -2.44689301e-01f,
  -5.69932103e-01f, -2.48442173e-01f, 2.22169250e-01f, 7.64997661e-01f, -1.34989601e-02f, -2.28705451e-01f, 1.82489529e-01f, -8.06798041e-02f, 6.12678938e-02f, 2.40531806e-02f,
  3.97628359e-02f, 2.76547939e-01f, 4.95092720e-02f, 9.28723887e-02f, 1.96372941e-01f, 1.35041431e-01f, 1.24561109e-01f, 4.04697172e-02f, -6.21675178e-02f, 8.64828378e-02f,
  1.71866164e-01f, -6.85605183e-02f, 6.68368936e-02f, 5.99700846e-02f, -5.76815046e-02f, -2.67699398e-02f, 1.88542623e-03f, -7.80719444e-02f, -1.25200599e-01f, 1.50249933e-03f,
  -1.09037478e-02f, -4.07241017e-01f, -7.03244880e-02f, -3.61984558e-02f, 3.27614322e-02f, 5.25186630e-03f, 4.27609980e-02f, -8.52293074e-02f, -2.28630796e-01f, 7.69244554e-03f,
  -1.16603196e-01f, -1.48578942e-01f, 1.23722464e-01f, 2.25492641e-02f, 5.80913350e-02f, 5.52936085e-02f, 5.59828244e-03f, -1.20200485e-01f, -2.00507015e-01f, 2.20889837e-01f,
  1.90366432e-01f, 1.01468265e-02f, -2.33165279e-01f, -3.84608060e-02f, -1.42381713e-01f, -3.20968956e-01f, -6.86182752e-02f, 5.09921201e-02f, -2.72688195e-02f, 1.37407899e-01f,
  -7.02840984e-02f, -2.26584256e-01f, -1.22265801e-01f, -2.26944372e-01f, 1.69429779e-01f, -7.88013786e-02f, 9.42872614e-02f, 4.98683332e-03f, -1.94656998e-01f, 3.42731535e-01f,
  -1.00235634e-01f, 3.07178766e-01f, -1.63004231e-02f, -1.68855920e-01f, -1.97064161e-01f, -3.11651900e-02f, 6.53972626e-02f, 2.32744932e-01f, -7.62992427e-02f, 5.95403500e-02f,
  -1.28751799e-01f, -2.12252975e-01f, -2.16497570e-01f, 2.20961735e-01f, 6.22178376e-01f, -8.51615891e-02f, 2.43359376e-02f, -4.99595016e-01f, -5.34991682e-01f, 3.11412755e-02f,
  -4.59538251e-01f, -6.64893210e-01f, 1.84866115e-01f, -1.22270107e-01f, -5.92780948e-01f, 2.34282210e-01f, 8.37526023e-01f, 1.48142472e-01f, 1.64676696e-01f, 1.86540693e-01f,
  1.18977875e-02f, -3.36905897e-01f, 1.95745960e-01f, -6.52428269e-02f, 1.29022419e-01f, 7.41501227e-02f, -3.88245434e-01f, -1.01761892e-01f, -1.94667429e-01f, -8.55486572e-01f,
  6.36177778e-01f, -5.23560822e-01f, -2.55076796e-01f, -8.59049559e-01f, -4.14926112e-01f, 1.61452204e-01f, 9.77226198e-02f, -4.62120473e-01f, -2.00318713e-02f, -1.11068018e-01f,
  -5.67205288e-02f, 3.40648919e-01f, -6.69547081e-01f, -3.99797410e-01f, -2.13424359e-02f, -1.12592876e-01f, 3.52576196e-01f, -7.07329154e-01f, -3.36463094e-01f, 4.90332067e-01f,
  -6.17616594e-01f, 3.13365012e-01f, -1.97958618e-01f, 4.25315201e-01f, -5.50893545e-01f, 4.24917698e-01f, -8.24752152e-02f, -3.48447897e-02f, 2.02439539e-02f, -1.48201119e-02f,
  1.70255005e-01f, 1.14582814e-01f, 3.41796689e-02f, -3.32512781e-02f, 1.39094949e-01f, -1.34982198e-01f, 1.10335544e-01f, -1.07739627e-01f, -5.77415787e-02f, 9.70189497e-02f,
  -1.01277739e-01f, 1.26912877e-01f, 7.69150406e-02f, -4.56030704e-02f, -5.45332283e-02f, 1.28995672e-01f, 1.02750227e-01f, 3.13296951e-02f, 1.06376007e-01f, -4.16597910e-02f,
  7.07521662e-02f, 5.15932664e-02f, -3.00725494e-02f, 4.76946449e-03f, -5.43291606e-02f, 1.36997461e-01f, 1.16492704e-01f, 8.11062828e-02f, 2.60407422e-02f, 2.23510396e-02f,
  9.72105265e-02f, 1.24221995e-01f, 4.52549718e-02f, 2.23839730e-02f, -2.25235641e-01f, -7.84372166e-02f, -2.65951365e-01f, 1.94141656e-01f, -1.03365473e-01f, -1.02178954e-01f,
  3.39878410e-01f, 6.93861842e-02f, 1.60482079e-01f, -2.84431398e-01f, -2.12933749e-01f, 1.11193381e-01f, -2.56427884e-01f, 1.27351612e-01f, 1.75966322e-01f, -4.70316336e-02f,
  4.27859724e-02f, -2.51134098e-01f, 2.47546643e-01f, 3.55031267e-02f, -2.01872423e-01f, 7.59983741e-05f, -2.74846166e-01f, 5.12182117e-02f, -9.32174474e-02f, 1.13704607e-01f,
  3.20440382e-01f, -1.62555978e-01f, -1.21052429e-01f, 1.22016393e-01f, 1.70104980e-01f, -1.27362311e-01f, 2.07679898e-01f, 9.90481153e-02f, 3.54879439e-01f, 1.39680862e-01f,
  -2.61051267e-01f, 1.01008035e-01f, 5.65970182e-01f, -2.29000151e-01f, -6.95676059e-02f, 2.94081271e-02f, -3.43618810e-01f, 2.44703859e-01f, -3.38347852e-01f, 4.44532067e-01f,
  -2.55890816e-01f, 1.64784938e-01f, -1.16583757e-01f, -3.33766609e-01f, 6.38617277e-01f, -5.90437949e-01f, -2.99830973e-01f, -8.37011039e-02f, -4.08562757e-02f, 7.15765238e-01f,
  7.36477673e-02f, -3.93091351e-01f, -2.46960282e-01f, -2.05622166e-01f, -7.01918453e-02f, -3.11138242e-01f, 1.23239726e-01f, 6.59515619e-01f, -2.36942358e-02f, 1.32539570e-01f,
  -4.61415201e-02f, -4.47415352e-01f, -3.56583923e-01f, 9.80898142e-02f, 2.45587051e-01f, -2.12980896e-01f, -2.04629153e-01f, -6.19291067e-01f, -1.39075354e-01f, 2.24452943e-01f,
  2.23848954e-01f, -3.29105794e-01f, -3.85126591e-01f, -3.02544504e-01f, -2.14280814e-01f, -2.32479200e-01f, -2.21021518e-01f, -2.53790617e-01f, -2.61603981e-01f, 2.01860383e-01f,
  -7.18849227e-02f, -2.58056521e-01f, 7.21511170e-02f, -6.23841211e-02f, 1.03688724e-02f, 1.60134304e-02f, -1.25734597e-01f, 2.34827977e-02f, 1.13883726e-02f, 7.24515244e-02f,
  -1.50250822e-01f, 2.97560673e-02f, 7.78847113e-02f, 6.37992322e-02f, -2.58019716e-01f, -3.14588957e-02f, 4.72608022e-02f, -1.68136563e-02f, -4.00547590e-03f, -2.65419275e-01f,
  -1.29832089e-01f, 1.75006874e-02f, -6.16452359e-02f, 6.72933683e-02f, 1.45715043e-01f, -1.09287165e-01f, -8.02452117e-02f, -1.56275854e-01f, -3.67159918e-02f, -1.16456874e-01f,
  -9.67453867e-02f, -2.87996624e-02f, -3.94484587e-02f, -1.10068560e-01f, 5.02721444e-02f, -8.89382139e-02f, 2.46368125e-02f, 5.28264493e-02f, -6.75005987e-02f, 7.62843192e-02f,
  7.83039723e-03f, 1.45582855e-01f, 9.89142209e-02f, -4.81780879e-02f, -1.27631173e-01f, 8.34038779e-02f, -1.09865412e-01f, -3.81527692e-02f, -1.04478620e-01f, 2.08746240e-01f,
  -5.15836440e-02f, 1.20250955e-01f, 1.44208565e-01f, 1.22093968e-01f, 4.30237828e-03f, -1.40182629e-01f, -6.10901788e-02f, -1.11093231e-01f, 2.03346863e-01f, 2.73944765e-01f,
  -2.88386226e-01f, -5.66068552e-02f, -1.91747949e-01f, -6.22187071e-02f, 8.07162523e-02f, -4.52818274e-01f, 1.59819573e-01f, -1.20790236e-01f, 2.33980715e-01f, 7.55079463e-02f,
  -5.82864434e-02f, 1.83715686e-01f, -1.34734839e-01f, 8.63574371e-02f, 4.52259630e-02f, -4.07041721e-02f, -1.72679812e-01f, -9.66735557e-02f, -1.31255433e-01f, -1.78142473e-01f,
  2.68004369e-02f, -2.16566905e-01f, -2.44078889e-01f, 3.12865019e-01f, -3.56084168e-01f, -2.32903704e-01f, 4.20059681e-01f, -1.67016000e-01f, -4.78871047e-01f, -1.75527483e-01f,
  6.88770711e-01f, -4.87235673e-02f, -6.18028780e-03f, -2.72062510e-01f, -8.60502422e-02f, 7.03890249e-03f, -3.52964878e-01f, -1.49278536e-01f, -3.51145446e-01f, -9.51014832e-02f,
  -6.19010806e-01f, -1.88306659e-01f, 6.09323025e-01f, 5.30104876e-01f, 3.34454119e-01f, 4.80853975e-01f, 2.91973054e-01f, -3.27320009e-01f, -6.40018702e-01f, -4.14873928e-01f,
  9.35365167e-03f, -2.92942196e-01f, -6.90646768e-01f, 5.96553423e-02f, -3.74513626e-01f, -7.91162968e-01f, 8.79965544e-01f, -5.10946363e-02f, -6.57901764e-01f, 5.72467923e-01f,
  -3.76728565e-01f, -1.53869748e-01f, -1.76701695e-01f, 2.80806690e-01f, 5.98911941e-01f, -1.52487889e-01f, 1.76094603e-02f, 2.17428520e-01f, -1.79231226e-01f, -2.71461815e-01f,
  -8.70580524e-02f, -7.29548261e-02f, 9.71767232e-02f, 1.04117987e-03f, 1.38351470e-01f, 2.29560584e-02f, -7.78386518e-02f, -3.00146174e-02f, 2.24058792e-01f, -3.25214379e-02f,
  -2.11825341e-01f, -1.62933707e-01f, -3.00908647e-02f, -3.21918502e-02f, 6.31839558e-02f, -2.52216705e-03f, 1.22263081e-01f, 1.41760170e-01f, 9.61998627e-02f, -4.71324427e-03f,
  -2.31664777e-02f, 1.13722637e-01f, -1.15897648e-01f, 3.83787528e-02f, -1.23826154e-01f, 6.26189560e-02f, 3.53102162e-02f, 2.98775863e-02f, 7.43869171e-02f, -1.38814807e-01f,
  6.71365634e-02f, -2.55881120e-02f, 3.86402616e-03f, -6.74347878e-02f, 9.49282292e-03f, 6.38893545e-02f, -4.29679494e-04f, -5.25189191e-02f, -2.36646850e-02f, -4.96091284e-02f,
  1.07342780e-01f, 3.32666337e-02f, 6.57827454e-03f, 1.19953584e-02f, 1.31270783e-02f, 6.05791528e-03f, -2.59043369e-02f, -1.27811551e-01f, 1.42650694e-01f, 1.20285545e-02f,
  2.87170410e-01f, -2.10987613e-01f, 3.03849787e-03f, 5.97441494e-02f, 1.26559570e-01f, -1.90059409e-01f, 2.07379237e-01f, -2.44115982e-02f, -9.52795427e-03f, 1.09258011e-01f,
  -1.14027902e-01f, -1.20244399e-01f, -6.19769432e-02f, -4.81074989e-01f, 1.25461221e-01f, 5.07755354e-02f, -1.89225867e-01f, 7.66665936e-02f, 9.20098647e-02f, 9.03695822e-02f,
  -3.09444249e-01f, -1.08045943e-01f, 1.62061766e-01f, 5.76114319e-02f, -9.89388749e-02f, 1.37030989e-01f, 1.10103399e-01f, 2.00505733e-01f, 2.97788501e-01f, -1.43655986e-01f,
  -3.67242992e-01f, 3.23777854e-01f, 4.17258322e-01f, -7.85477385e-02f, 1.98872760e-01f, -3.80445421e-01f, 5.94863575e-03f, 7.32231587e-02f, -1.29446641e-01f, -6.27883524e-03f,
  -1.45416304e-01f, 1.39599130e-01f, 3.73232961e-01f, -3.57490212e-01f, 7.87504017e-02f, 1.16698384e-01f, -3.09142172e-01f, 3.63137394e-01f, 3.21111120e-02f, 3.10403332e-02f,
  -3.88691604e-01f, -4.30349022e-01f, -2.58921266e-01f, 1.46636590e-01f, -5.08035004e-01f, 6.57480955e-01f, -2.20783979e-01f, 3.44263673e-01f, 1.75062925e-01f, 2.23851264e-01f,
  -7.15845048e-01f, 1.70335114e-01f, 2.00574666e-01f, -4.14622992e-01f, -6.54667616e-01f, -2.06689864e-01f, -3.45482081e-01f, -8.94018292e-01f, 1.77447334e-01f, -3.32816780e-01f,
  -9.15409997e-02f, 4.09851462e-01f, -1.08253017e-01f, -2.01800361e-01f, 2.81299055e-01f, -6.09415710e-01f, -6.46563649e-01f, -1.02396488e-01f, 2.62452364e-01f, -2.25262970e-01f,
  1.04705386e-01f, 4.96864431e-02f, 6.96583167e-02f, -3.67174633e-02f, 1.71597138e-01f, -8.08207318e-02f, 1.54818678e-02f, -3.98144461e-02f, 7.57305324e-02f, 9.77065340e-02f,
  -6.82253670e-03f, 4.15682346e-02f, 8.76748376e-03f, 1.29281014e-01f, 1.76030677e-02f, -4.73695854e-03f, 5.00959568e-02f, 5.99812642e-02f, 9.04572308e-02f, -5.21518551e-02f,
  9.55751017e-02f, -2.42600869e-02f, -8.23244452e-02f, 2.89267749e-01f, 1.37137258e-02f, 3.35117616e-02f, 1.79262720e-02f, 2.23242253e-01f, 5.21113276e-02f, 1.06475934e-01f,
  1.29236362e-03f, 6.57409877e-02f, 4.68515903e-02f, 1.72383115e-01f, 9.55084786e-02f, 1.01353094e-01f, 1.51590079e-01f, 2.09706612e-02f, -1.01659201e-01f, 1.95175365e-01f,
  3.26452315e-01f, 1.91192284e-01f, -8.03996027e-02f, 1.08078599e-01f, 3.78649719e-02f, -1.40988529e-01f, 1.36699667e-02f, 3.82895529e-01f, 1.79784074e-01f, 3.26271392e-02f,
  -1.85983002e-01f, -8.44193697e-02f, -3.39637220e-01f, 2.51804352e-01f, 1.72103330e-01f, 9.51412842e-02f, 1.18045688e-01f, -3.23245488e-02f, -2.49954179e-01f, 3.38988490e-02f,
  2.16351628e-01f, 3.62401724e-01f, -8.13152567e-02f, -8.18706825e-02f, -3.58100027e-01f, 2.68833973e-02f, 2.08181977e-01f, 2.01799169e-01f, -2.08750203e-01f, -3.08670513e-02f,
  -1.60400778e-01f, -4.67002997e-03f, -1.81161374e-01f, -3.07931267e-02f, 1.94673136e-01f, 1.03355810e-01f, -4.56784159e-01f, 3.77840132e-01f, 3.72700877e-02f, -4.91388440e-01f,
  -7.11901858e-02f, -1.61491767e-01f, 5.41310422e-02f, -6.43729791e-02f, 2.85135955e-01f, 3.13217826e-02f, -5.37840068e-01f, -1.08523838e-01f, -8.44203174e-01f, -8.45794976e-02f,
  -2.70168751e-01f, 1.40046552e-01f, 2.78848205e-02f, 3.15994591e-01f, -5.17660677e-01f, -2.55701989e-02f, 7.84255087e-01f, 4.59562480e-01f, 3.90550792e-01f, 3.12863857e-01f,
  -4.91750062e-01f, -5.00307024e-01f, -2.02760100e-01f, -4.77267474e-01f, -2.33246908e-02f, 8.47923577e-01f, 3.22902173e-01f, -2.50535190e-01f, -2.06946224e-01f, 9.06952471e-03f,
  -3.85363519e-01f, 8.05305719e-01f, -1.85098261e-01f, 1.01576010e-02f, -1.07262224e-01f, 7.87898898e-03f, 1.57875374e-01f, -3.47447455e-01f, -5.19277155e-01f, -4.50327158e-01f,
  -7.62059450e-01f, -2.34300226e-01f, 8.12163725e-02f, -6.13792419e-01f, -6.16486907e-01f, 4.45813209e-01f, -3.41713071e-01f, 1.59494802e-01f, -7.61469677e-02f, 1.68418046e-02f,
  -9.29021314e-02f, 2.31198389e-02f, -6.51249886e-02f, 1.37136593e-01f, -1.25849426e-01f, 8.51716474e-02f, 4.84345295e-03f, 6.37676660e-03f, -1.03160784e-01f, 3.57839242e-02f,
  1.12057455e-01f, 2.75828559e-02f, 2.03728564e-02f, 1.54796951e-02f, 7.29619041e-02f, 2.99410918e-03f, 2.85126790e-02f, -1.15760406e-02f, 9.77051780e-02f, 2.30531748e-02f,
  1.23390287e-01f, 1.19631968e-01f, 3.01506035e-02f, -3.26752178e-02f, 1.21090382e-01f, 3.06003913e-02f, 3.17221060e-02f, -4.76750080e-03f, -1.68777704e-01f, -2.65405960e-02f,
  2.19573658e-02f, -4.61420417e-02f, -1.72967985e-01f, -1.07852109e-01f, -8.82225931e-02f, -9.43722576e-02f, -4.26512569e-01f, -2.06237152e-01f, 2.01253802e-01f, -1.20819561e-01f,
  -4.99356389e-02f, -1.02086563e-03f, 1.42814323e-01f, -7.71333501e-02f, 1.52471229e-01f, -1.26809463e-01f, -6.09552581e-03f, 3.16426940e-02f, -3.65724489e-02f, 2.01529279e-01f,
  -1.48995012e-01f, -8.57979618e-03f, -2.21532807e-01f, 7.44011924e-02f, 1.12367146e-01f, 6.44561201e-02f, 1.29069865e-01f, 1.42381459e-01f, 9.14294943e-02f, -9.14400965e-02f,
  6.06300384e-02f, -2.22621843e-01f, -1.52863815e-01f, 1.95496619e-01f, 1.02236615e-02f, -2.66445786e-01f, 9.86764655e-02f, -2.01246381e-01f, -2.29997650e-01f, -2.53565133e-01f,
  2.05721576e-02f, 8.44460428e-02f, 1.86892375e-01f, 1.19733050e-01f, -3.26311827e-01f, 2.66243126e-02f, -5.96639454e-01f, -6.63202703e-01f, -6.07467353e-01f, -9.38861072e-02f,
  -3.23185325e-01f, -9.35027227e-02f, -5.27576916e-02f, -4.30130154e-01f, -2.17824712e-01f, -6.52558208e-01f, -3.69111747e-01f, -7.13607669e-01f, -4.05356646e-01f, 5.55072188e-01f,
  2.76647061e-01f, -7.52843916e-01f, 2.57867485e-01f, -5.69495916e-01f, -8.65685821e-01f, -3.84922802e-01f, 3.05688772e-02f, -6.93275511e-01f, -2.27187231e-01f, 3.53474468e-01f,
  -1.90266848e-01f, 4.93697792e-01f, -3.09145063e-01f, 5.95485806e-01f, -8.61807838e-02f, 4.34106976e-01f, -2.67930686e-01f, -1.77665353e-01f, -3.41183931e-01f, -1.96224615e-01f,
  -2.39393502e-01f, 2.38441005e-01f, 2.63387561e-01f, -5.84167168e-02f, 3.37668061e-01f, 3.15401256e-01f, 2.49820277e-01f, 1.20942378e-02f, -3.79227430e-01f, 1.16952799e-01f,
  -1.45134881e-01f, -1.74209252e-01f, 3.71436536e-01f, -2.65442580e-01f, -8.37060690e-01f, 1.05221257e-01f, -2.49861315e-01f, -2.14290857e-01f, 2.60235257e-02f, -6.93547800e-02f,
  -7.64481872e-02f, 2.62349322e-02f, -1.65173486e-02f, -9.60432813e-02f, -1.59845933e-01f, -7.18882978e-02f, 2.17190310e-01f, -1.45573899e-01f, -1.38868138e-01f, 1.71344751e-03f,
  -2.11116359e-01f, -1.68083400e-01f, -8.27319399e-02f, -2.34089047e-03f, -1.15361325e-01f, -5.90808354e-02f, -7.90827870e-02f, -1.45178616e-01f, -1.01669654e-01f, -1.16666608e-01f,
  4.31816727e-02f, -1.43256500e-01f, -1.60215914e-01f, 2.73486762e-03f, -7.47420341e-02f, -1.81149557e-01f, 5.31659015e-02f, -8.94171298e-02f, -2.14176103e-02f, -9.04532894e-02f,
  -1.15433730e-01f, -1.72454745e-01f, -5.54380678e-02f, -6.04613908e-02f, 1.85206905e-01f, 1.05699182e-01f, -9.63875279e-03f, 1.79026797e-01f, -1.95880294e-01f, -5.59573164e-06f,
  7.14121759e-02f, -1.24647319e-01f, -1.53922409e-01f, -3.13984901e-02f, -2.48753186e-02f, 1.60521880e-01f, -1.35644495e-01f, -1.73586830e-01f, -1.17978588e-01f, 1.02493890e-01f,
  8.13816637e-02f, 3.04483831e-01f, -8.21474120e-02f, 8.67030919e-02f, 8.98087993e-02f, 9.91936699e-02f, 9.85667259e-02f, -3.18885058e-01f, -1.99076757e-01f, 1.59084871e-01f,
  5.94267920e-02f, -1.36146635e-01f, 6.06738329e-02f, -1.89551711e-02f, 1.15776449e-01f, 1.38333723e-01f, 3.35867815e-02f, -2.38584820e-02f, 9.55634937e-02f, 1.36792779e-01f,
  3.82611603e-02f, -1.76920369e-01f, -2.81006962e-01f, -8.14608186e-02f, -3.62780154e-01f, 4.31375712e-01f, -2.78572619e-01f, -1.47960111e-01f, -1.15454011e-01f, -2.54802760e-02f,
  -5.67144156e-01f, 1.42232627e-01f, 4.84535515e-01f, 3.16019803e-01f, -2.38556549e-01f, -2.67276078e-01f, -1.56847253e-01f, -4.11035031e-01f, 1.19235575e-01f, 5.13815165e-01f,
  -3.73283178e-01f, 3.92045438e-01f, 3.96056473e-01f, -7.34947771e-02f, 4.35978413e-01f, -2.31672195e-03f, 1.48699209e-01f, -4.86275882e-01f, -2.52944410e-01f, 1.44790292e-01f,
  1.06204860e-01f, 3.23869050e-01f, -2.94475496e-01f, -1.95920035e-01f, -2.46654615e-01f, -3.61735433e-01f, 2.45999679e-01f, -2.36271888e-01f, 2.07384273e-01f, -2.58844644e-01f,
  -2.43235394e-01f, 1.54604111e-02f, 3.93311195e-02f, -2.94650614e-01f, -1.69966310e-01f, -1.78504467e-01f, 3.60068947e-01f, -5.90927064e-01f, -2.33564347e-01f, 3.65235597e-01f,
  3.04714650e-01f, -1.59960523e-01f, -2.67261751e-02f, -3.31134498e-01f, -1.49615505e-03f, 1.23626776e-01f, 9.75546706e-03f, -5.03012128e-02f, 6.30294625e-03f, -1.46828562e-01f,
  1.14770085e-01f, 1.32692993e-01f, -1.29807919e-01f, 1.37237310e-01f, 2.56136023e-02f, -1.54379811e-02f, -3.16964537e-02f, 1.15892269e-01f, -3.83668169e-02f, -2.09134668e-01f,
  5.52665107e-02f, 7.07835406e-02f, 1.03830390e-01f, -1.75196081e-02f, -7.57965073e-02f, -2.00824887e-02f, 1.51427211e-02f, 1.31570652e-01f, 1.26924023e-01f, 1.79992482e-01f,
  2.02309653e-01f, 8.39036610e-03f, -1.60340846e-01f, -5.10366969e-02f, 1.43167749e-01f, 6.27823994e-02f, -1.73800904e-02f, 5.66446781e-02f, -8.45623463e-02f, -2.26945970e-02f,
  1.13200501e-01f, -1.46266028e-01f, 2.62635171e-01f, 6.30506799e-02f, 1.81926012e-01f, -3.41484308e-01f, 1.69426978e-01f, -1.89564824e-01f, 1.67846635e-01f, -1.09429136e-01f,
  -2.04734653e-01f, -1.65118426e-01f, -1.28123403e-01f, 2.93287396e-01f, 1.30896509e-01f, 1.21828519e-01f, 3.67996871e-01f, 2.78864890e-01f, -1.06772408e-01f, 6.38094991e-02f,
  1.65535301e-01f, -2.39659473e-02f, 2.32360959e-01f, 1.89166412e-01f, 9.08085704e-02f, 2.29664594e-01f, 9.79698151e-02f, 4.67186281e-03f, 1.58226267e-01f, -1.92887262e-01f,
  -1.58482328e-01f, -2.26941943e-01f, -8.23224485e-02f, 3.42839696e-02f, -1.37925044e-01f, 1.06698103e-01f, -1.64593697e-01f, 2.87204802e-01f, -4.16227952e-02f, -1.96885318e-01f,
  -3.34889263e-01f, 5.96254051e-01f, 4.35473263e-01f, -1.38362244e-01f, -1.95125669e-01f, -2.65557408e-01f, -7.62631536e-01f, -1.57124907e-01f, -2.34388217e-01f, 1.75252214e-01f,
  -9.19319093e-02f, -5.52490838e-02f, -2.75942773e-01f, -4.56082702e-01f, -3.28188360e-01f, -1.51984006e-01f, -3.29263479e-01f, 4.96641546e-02f, 9.24631730e-02f, -1.00364946e-02f,
  -7.10173786e-01f, -1.62550304e-02f, -2.39218935e-01f, -3.11837971e-01f, 4.92825300e-01f, -4.70361812e-03f, -1.32628322e-01f, -1.99799374e-01f, 9.65924263e-02f, -4.12704438e-01f,
  -1.22216955e-01f, -7.87054226e-02f, 7.05895782e-01f, -1.05398461e-01f, 7.33803287e-02f, 4.06209409e-01f, -1.08251467e-01f, 1.78295135e-01f, -1.73028916e-01f, 6.29032075e-01f,
  -3.05306286e-01f, 3.27413797e-01f, -1.63259596e-01f, -5.11118412e-01f, 3.45025174e-02f, 2.20199153e-02f, -1.15638368e-01f, -3.01917791e-01f, 2.48103067e-01f, -4.90595579e-01f,
  -7.73814470e-02f, -9.31030288e-02f, 4.15430851e-02f, -1.58632427e-01f, 3.95482071e-02f, 8.71613994e-02f, -1.41526416e-01f, -2.04775892e-02f, -1.71595197e-02f, -5.35214916e-02f,
  1.20529391e-01f, -7.93844983e-02f, -2.08279923e-01f, -1.85531363e-01f, 6.27672449e-02f, -1.34035975e-01f, 1.89986993e-02f, -8.86275619e-02f, -9.12606064e-03f, -3.85636277e-02f,
  2.85030026e-02f, -1.02147199e-02f, 6.20904937e-02f, -1.35734618e-01f, 1.13031022e-01f, 1.04511425e-01f, -3.93933207e-02f, 4.35803309e-02f, 4.73108515e-02f, 1.10356212e-02f,
  -1.64879784e-01f, 3.54710072e-02f, 9.26646367e-02f, 4.19829711e-02f, -1.82754621e-01f, 1.36986151e-01f, -2.15290546e-01f, 2.12594867e-02f, 1.05052434e-01f, -6.17762608e-03f,
  -5.86544424e-02f, -1.64250940e-01f, 2.91278005e-01f, -1.92993119e-01f, -9.88559574e-02f, -6.36475608e-02f, 1.38304289e-02f, 3.06924302e-02f, -9.03046429e-02f, 2.32927337e-01f,
  -1.33620381e-01f, -2.76941687e-01f, -1.19251356e-01f, -1.49127886e-01f, 9.72013995e-02f, -1.06176911e-02f, -1.14272304e-01f, -3.48419458e-01f, -3.60155374e-01f, 2.10584477e-01f,
  -2.17119530e-02f, -5.99891320e-02f, -8.33974853e-02f, 4.14941967e-01f, -1.63700491e-01f, -1.94246337e-01f, -2.49046519e-01f, -1.01406135e-01f, 6.26079813e-02f, 4.41853590e-02f,
  -3.98756713e-02f, -2.90021696e-03f, 3.41550827e-01f, -1.71377018e-01f, 2.74343994e-02f, -4.12775546e-01f, 2.23779008e-01f, 2.05706179e-01f, -3.27333897e-01f, -4.66869444e-01f,
  -4.12301362e-01f, 7.96562806e-03f, 8.16022992e-01f, 9.04385522e-02f, -7.51742899e-01f, 4.69082564e-01f, -2.18562186e-01f, -1.81897134e-01f, -3.40670645e-01f, -2.30155915e-01f,
  -7.14525163e-01f, 5.93678772e-01f, 3.32999718e-03f, 1.39094889e-01f, -2.80307710e-01f, -3.31683010e-01f, -3.85465860e-01f, 5.70616484e-01f, 5.30825436e-01f, -1.76983893e-01f,
  -1.87600836e-01f, -6.95199221e-02f, -1.88489363e-01f, 1.32216573e-01f, -3.09706002e-01f, 2.62777001e-01f, 4.50843692e-01f, -1.91104606e-01f, -6.14370465e-01f, 9.16207805e-02f,
  -1.61209777e-01f, -4.38096344e-01f, -8.47527683e-02f, -4.31727879e-02f, -1.05504557e-01f, -4.37406927e-01f, 4.25843179e-01f, -2.02249825e-01f, 1.63495541e-02f, -4.82144475e-01f,
  9.84623358e-02f, -2.91637361e-01f, 1.39825478e-01f, -2.37192567e-02f, -2.80063927e-01f, -2.12935776e-01f, 2.49055788e-01f, -1.84923679e-01f, 6.88629091e-01f, 2.55121380e-01f,
  1.61016490e-02f, -1.43270520e-02f, -1.36109665e-01f, 7.63961300e-02f, 3.61628719e-02f, 7.03490898e-02f, 9.56058782e-03f, -9.15227607e-02f, 5.55468611e-02f, 2.57336590e-02f,
  1.66025043e-01f, 5.55345155e-02f, -1.81248706e-05f, 1.26603216e-01f, 7.98317716e-02f, 1.02154225e-01f, 1.03151456e-01f, 8.41663480e-02f, 1.08784840e-01f, -9.37428176e-02f,
  1.10545360e-01f, -1.81390401e-02f, 4.03595483e-03f, 1.39926836e-01f, 5.63140735e-02f, -4.41753082e-02f, -7.57035464e-02f, 1.14626527e-01f, 6.79992512e-02f, 2.08172470e-01f,
  1.52509242e-01f, 5.13525046e-02f, 4.09592129e-02f, -9.14557725e-02f, -2.07687527e-01f, -1.16794579e-01f, -2.53709018e-01f, -8.45240727e-02f, 2.80649573e-01f, 2.28915904e-02f,
  -2.86843747e-01f, 8.02707486e-03f, 5.15831187e-02f, 1.16817608e-01f, -1.89627454e-01f, -2.11708173e-01f, 2.51676142e-02f, -3.42451423e-01f, -5.28736301e-02f, -1.60351858e-01f,
  9.36645567e-02f, 1.98306963e-01f, 1.89728737e-02f, 1.80401608e-01f, -2.17090711e-01f, -1.22684091e-02f, -2.55069613e-01f, -1.48142084e-01f, 1.80558905e-01f, -2.05105960e-01f,
  -1.94250464e-01f, 1.11901887e-01f, 1.24775775e-01f, 1.25466511e-01f, 2.74426043e-01f, -2.54255030e-02f, -8.25805515e-02f, 1.34652823e-01f, 1.11640498e-01f, 2.36011252e-01f,
  -6.63142502e-02f, 1.09963648e-01f, -1.05237834e-01f, -2.79931396e-01f, -2.63994187e-01f, -2.61401832e-01f, 5.79031169e-01f, -3.05690151e-02f, -2.83206791e-01f, -5.54196537e-01f,
  2.28421599e-01f, -5.34135640e-01f, 5.26125491e-01f, 6.88416436e-02f, -4.23558503e-01f, -3.44995469e-01f, -4.27171171e-01f, 6.27889410e-02f, -3.46053988e-01f, 2.32451528e-01f,
  5.56437559e-02f, -6.94051385e-02f, -3.05695891e-01f, -1.51390567e-01f, -1.07102633e-01f, 1.84177849e-02f, -2.80748248e-01f, -1.25446931e-01f, 1.71361476e-01f, -6.90759420e-02f,
  9.30267274e-02f, -1.91893369e-01f, -5.16524851e-01f, -9.34643894e-02f, 6.89903140e-01f, -5.45849085e-01f, 4.35554773e-01f, -1.69995844e-01f, -4.31281656e-01f, -7.00156093e-01f,
  -9.39130709e-02f, -1.25000671e-01f, 4.41770218e-02f, -1.57211781e-01f, -1.93058386e-01f, 5.15767694e-01f, -3.14817280e-01f, -1.34807527e-01f, -1.78837916e-04f, -3.93372834e-01f,
  -1.82271183e-01f, -1.07404329e-01f, -2.63839215e-01f, -2.35309154e-01f, -1.87471677e-02f, -1.45782322e-01f, -1.85442343e-01f, -3.09583247e-01f, 1.24182075e-01f, 6.19667582e-02f,
  -4.08404283e-02f, -1.29986510e-01f, 1.67659357e-01f, 6.37821853e-02f, 1.17419869e-01f, -6.98933378e-02f, 1.27004907e-01f, -7.01302849e-03f, 3.00964657e-02f, 1.17888860e-01f,
  -1.17723480e-01f, -1.24820899e-02f, 9.60835442e-02f, 2.68750396e-02f, 6.73196241e-02f, 8.03130791e-02f, 2.86415927e-02f, -2.88263056e-02f, -1.26434090e-02f, 4.44097221e-02f,
  -5.50686643e-02f, -5.80813177e-02f, -8.43723789e-02f, 8.96829814e-02f, -6.62625283e-02f, 4.27418476e-04f, 6.28471002e-02f, 1.15404412e-01f, -3.49226445e-02f, 1.23308543e-02f,
  1.11135557e-01f, -7.18713179e-03f, 1.58581868e-01f, -3.31236632e-03f, -1.54052496e-01f, 4.85597737e-02f, 2.53008623e-02f, 3.65522169e-02f, 1.16131634e-01f, -1.87214062e-01f,
  1.90011680e-01f, 2.01815441e-02f, -4.35837358e-02f, 3.12330961e-01f, 4.31283005e-02f, 2.97880024e-01f, -9.84533802e-02f, -1.65807605e-01f, 3.59060504e-02f, -1.81324035e-01f,
  -1.00127012e-01f, -5.19609340e-02f, -1.87703088e-01f, 6.76050335e-02f, 2.24651136e-02f, 6.42646849e-02f, -4.78137471e-02f, -1.88162744e-01f, 2.24046871e-01f, -2.84791529e-01f,
  1.36412382e-01f, -2.47811168e-01f, -2.10662335e-01f, 2.22453713e-01f, 2.77355928e-02f, -1.12511784e-01f, 1.18563965e-01f, -1.95999160e-01f, -1.47011846e-01f, -4.17742096e-02f,
  -3.21834572e-02f, 2.43043333e-01f, 1.92364097e-01f, 6.11464418e-02f, -1.91369668e-01f, -2.50087023e-01f, 1.61851570e-01f, 1.39340430e-01f, -1.74956734e-03f, -2.86795385e-02f,
  -8.76183957e-02f, -4.97480124e-01f, -4.87252861e-01f, 9.93730575e-02f, 6.20545089e-01f, -4.49224532e-01f, -1.20766759e-01f, -2.45275557e-01f, -3.68096214e-03f, -3.92267764e-01f,
  -2.70475119e-01f, -5.78834951e-01f, 6.22672856e-01f, -2.10065305e-01f, -2.43333921e-01f, 6.04260005e-02f, -1.24544762e-01f, 4.93719488e-01f, -8.31066892e-02f, -1.51554793e-01f,
  -1.79526344e-01f, -4.94619727e-01f, -2.60348856e-01f, -2.07382172e-01f, -3.08650523e-01f, -1.42507747e-01f, -4.29855555e-01f, -1.68987244e-01f, 2.91495174e-01f, -2.61115253e-01f,
  1.92087695e-01f, -4.41458106e-01f, -3.02947193e-01f, -2.82324940e-01f, 5.00488728e-02f, 6.59723878e-01f, -4.10642959e-02f, 7.84983873e-01f, 4.09389913e-01f, 3.09375554e-01f,
  -2.47941956e-01f, -3.17847759e-01f, -1.57128021e-01f, -2.91544050e-01f, -1.84506208e-01f, -1.64828822e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -6.20893128e-02f, 5.84242195e-02f, 1.15070969e-01f, -3.89566310e-02f, -1.24552712e-01f, 7.34878778e-02f, 8.30528215e-02f, -3.36971767e-02f, 1.51491817e-02f, 7.08925352e-02f,
  5.31831644e-02f, -2.39282846e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 38, 52
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        128, 12
    );
    }
    