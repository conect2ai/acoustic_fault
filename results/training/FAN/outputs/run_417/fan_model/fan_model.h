/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  8.46758366e-01f, 7.32937381e-02f, 1.41464353e-01f, 1.27175853e-01f, 5.49606495e-02f, -5.52865267e-02f, -1.00056874e-02f, -5.08183725e-02f, 1.75973460e-01f, -1.01811796e-01f,
  -1.57782331e-01f, 2.17215165e-01f, -5.58511503e-02f, -4.29241173e-02f, 1.64244950e-01f, -7.05263950e-03f, 1.53052762e-01f, 2.91337389e-02f, 2.35634707e-02f, 1.12120293e-01f,
  1.26247615e-01f, -1.19967714e-01f, 1.67673174e-02f, -2.07898512e-01f, -4.73459028e-02f, 7.40699321e-02f, -1.26070693e-01f, -5.05465791e-02f, -3.71823907e-02f, -2.54501253e-02f,
  8.74686688e-02f, -4.78648804e-02f, -2.38247905e-02f, 6.94334507e-03f, -2.61131121e-04f, 3.80642563e-02f, 1.12564182e-02f, -1.37378238e-02f, 1.54148685e-02f, -4.23800945e-02f,
  4.74092923e-02f, 5.99398427e-02f, -8.06584954e-03f, -2.63341330e-02f, -4.32177931e-02f, 3.57168028e-03f, -2.52840878e-03f, -6.80199489e-02f, -8.04889053e-02f, -2.73236185e-02f,
  -6.34150356e-02f, 2.23142821e-02f, 3.89253488e-03f, -2.93573085e-02f, -5.58869280e-02f, -3.99822854e-02f, 3.75654511e-02f, -1.58608072e-02f, 1.96100269e-02f, 5.42349219e-02f,
  4.54471260e-03f, 3.95300724e-02f, -7.60047976e-03f, -1.14720408e-02f, -3.92739773e-02f, -3.19865569e-02f, 1.09245013e-02f, -2.86889207e-02f, 5.59823848e-02f, 1.27651868e-03f,
  9.33098048e-03f, 1.28352374e-03f, 3.39673925e-03f, -3.92475687e-02f, 8.45019072e-02f, -1.90163217e-02f, 5.87556325e-02f, -8.28993767e-02f, 4.83027995e-02f, 1.42565640e-02f,
  6.10727025e-03f, 8.46989453e-03f, -8.32024291e-02f, -3.61203961e-02f, -2.90681105e-02f, -4.35332023e-02f, -2.44280733e-02f, -1.16080446e-02f, -1.02358242e-03f, 1.20491171e-02f,
  1.53537944e-01f, 1.79599389e-01f, -3.57443243e-02f, -2.45192330e-02f, 1.68462354e-03f, -6.62379991e-03f, 4.85554188e-02f, 5.17558791e-02f, 1.64210517e-02f, 2.41048448e-02f,
  3.48976208e-03f, -5.80604281e-03f, 3.38232741e-02f, 1.69218462e-02f, 2.11319812e-02f, -7.69390240e-02f, 4.88649867e-02f, 8.99277478e-02f, 2.42750105e-02f, 9.63872392e-03f,
  -9.09254514e-03f, -1.20995417e-02f, 6.77795261e-02f, 1.36805829e-02f, 5.05895317e-02f, 2.90881265e-02f, 2.52485164e-02f, -1.39800524e-02f, -5.20924181e-02f, 6.06933702e-03f,
  -1.49572298e-01f, -3.52199040e-02f, 1.90978274e-02f, -1.42528728e-01f, -2.38025072e-03f, 4.00898188e-01f, 7.38559337e-03f, 3.80357094e-02f, 1.38197258e-01f, 7.87206180e-03f,
  -8.80010948e-02f, 1.48343429e-01f, -2.21455358e-02f, -3.65142412e-02f, -1.90368548e-01f, 1.92346931e-01f, -2.18208283e-01f, 9.85547453e-02f, 7.10518584e-02f, -1.43442318e-01f,
  2.87803151e-02f, -3.40118140e-01f, -1.73689023e-01f, -1.18458994e-01f, -3.32411341e-02f, 7.37370551e-02f, -4.35847014e-01f, -2.37137210e-02f, -1.24632768e-01f, 1.58057269e-03f,
  1.22497685e-01f, 4.91161272e-02f, -7.72205591e-02f, 5.03231920e-02f, -2.88555510e-02f, 8.00317749e-02f, 4.70801480e-02f, 2.20137313e-02f, -9.53823403e-02f, 7.63601363e-02f,
  7.22452626e-02f, -3.61639750e-03f, -5.46311885e-02f, 2.86678807e-03f, 1.59946859e-01f, 1.25945024e-02f, -1.35686984e-02f, 1.29137021e-02f, 6.35535717e-02f, 1.12196848e-01f,
  8.21019188e-02f, 5.50714619e-02f, 2.32532285e-02f, 3.09105683e-03f, -8.72701854e-02f, -2.87224744e-02f, 7.20505863e-02f, 8.02971348e-02f, 6.75240010e-02f, 5.49715422e-02f,
  -1.61022376e-02f, 1.60208754e-02f, -2.67315377e-03f, -1.97016075e-02f, -2.66152769e-02f, -4.92580794e-02f, -4.71594632e-02f, 5.70699386e-02f, -6.23456389e-02f, 6.68324009e-02f,
  -2.24159695e-02f, 2.58399956e-02f, 7.51878992e-02f, 1.10644631e-01f, 3.04622240e-02f, 4.37634699e-02f, 4.02710699e-02f, 9.38348323e-02f, 2.92548793e-03f, -2.27627531e-02f,
  -8.08650535e-03f, 2.56862380e-02f, -3.41949649e-02f, -1.84754040e-02f, 5.46852732e-03f, 5.70939966e-02f, 3.87597829e-02f, 5.76727949e-02f, 1.50564294e-02f, -3.06186695e-02f,
  -1.17587432e-01f, -3.41757476e-01f, 2.36307364e-02f, 4.65001836e-02f, -5.25641032e-02f, -1.48217957e-02f, -8.29432309e-02f, 5.73251583e-02f, -4.50516604e-02f, -2.70351712e-02f,
  4.42564720e-03f, 1.15111852e-02f, 5.33939749e-02f, 1.24726966e-02f, -5.01497313e-02f, -2.89337747e-02f, 7.04208808e-03f, -4.04498726e-02f, -1.10105485e-01f, -5.17914817e-02f,
  -9.02909636e-02f, 1.26614086e-02f, -5.44754148e-04f, -5.03115915e-02f, 1.34610524e-02f, 4.45730053e-02f, 1.20662814e-02f, 4.76970784e-02f, -3.13086212e-02f, -4.23527732e-02f,
  5.89953840e-01f, 1.80963755e-01f, 3.73496383e-01f, 1.37712494e-01f, 2.04303473e-01f, 3.90937448e-01f, 6.10625781e-02f, 1.66532889e-01f, 3.62181775e-02f, -1.81024924e-01f,
  1.09456768e-02f, 1.88136217e-03f, -1.78262785e-01f, 2.00006783e-01f, 2.23266557e-01f, -1.49007320e-01f, 3.13543588e-01f, 9.52837467e-02f, 6.36854842e-02f, 1.34432197e-01f,
  1.00387655e-01f, 3.58049087e-02f, 1.83288574e-01f, 1.13697387e-01f, 2.10649863e-01f, 3.92636918e-02f, -8.16766918e-02f, -3.77187431e-02f, 4.98519763e-02f, -1.75210703e-02f,
  -6.71350062e-02f, -1.18738793e-01f, 5.31514548e-03f, 4.28812280e-02f, 1.58718273e-01f, 4.21405919e-02f, -2.73593124e-02f, -6.00361824e-03f, 1.08140968e-02f, 1.74927525e-02f,
  -1.91698931e-02f, -1.94963310e-02f, 5.59322909e-02f, -1.28973518e-02f, 3.56591158e-02f, 8.88947491e-03f, 6.13213815e-02f, -1.41559076e-02f, 1.75221674e-02f, 4.50151339e-02f,
  -4.45213467e-02f, -1.10941706e-02f, -2.04288643e-02f, 1.68252308e-02f, 4.67815958e-02f, 1.36718685e-02f, -2.28311829e-02f, -6.12976681e-03f, 2.20413301e-02f, 7.30476435e-03f,
  7.12546632e-02f, -1.17281834e-02f, 2.83418931e-02f, 1.00224875e-02f, 1.09410733e-01f, -1.18523119e-02f, 4.96051535e-02f, 3.88753563e-02f, -4.53494042e-02f, 6.21400923e-02f,
  4.61065769e-02f, 3.10732052e-02f, -1.27444379e-02f, 4.04300913e-02f, -3.25748660e-02f, -2.61522830e-02f, -1.45227918e-02f, -3.28847133e-02f, 3.86221446e-02f, 1.36087025e-02f,
  -6.65878877e-02f, 8.62485617e-02f, -5.52939363e-02f, 4.13445719e-02f, -1.45243872e-02f, -2.04000529e-02f, -1.88775938e-02f, 8.01058114e-03f, -1.06399925e-02f, 1.03004114e-03f,
  -2.02195887e-02f, 9.39706191e-02f, -3.16577293e-02f, -2.23122332e-02f, -4.34050784e-02f, 3.56241688e-02f, 4.72170711e-02f, 7.87761435e-02f, 3.18014920e-02f, 7.12743960e-04f,
  3.74447480e-02f, 6.43213615e-02f, -6.69047236e-02f, -2.32699644e-02f, 1.43021019e-02f, -1.64377447e-02f, -9.03288573e-02f, -3.25948023e-03f, 2.82884892e-02f, -2.51790304e-02f,
  4.49204519e-02f, 7.48758623e-03f, 6.42975643e-02f, 1.68382414e-02f, 3.90152708e-02f, -3.52714956e-02f, 2.56342236e-02f, -8.17689300e-02f, -1.40123349e-02f, -6.72732480e-03f,
  5.93675613e-01f, 1.36261567e-01f, -2.79294625e-02f, 3.02680403e-01f, 2.49397472e-01f, -7.72157907e-02f, 2.13888541e-01f, 1.02133825e-01f, 2.69507170e-01f, 8.51238370e-02f,
  8.03386420e-02f, 7.40916803e-02f, -1.69984385e-01f, 8.46056174e-03f, -1.09717615e-01f, -1.87157035e-01f, 1.82690278e-01f, 8.47944245e-02f, 8.67633056e-03f, 2.01964602e-01f,
  3.69244814e-02f, 1.42265141e-01f, -1.87435731e-01f, -9.77738667e-03f, 1.77023202e-01f, 9.28930640e-02f, 1.01543553e-01f, -3.81654166e-02f, 1.95155349e-02f, -9.08673927e-03f,
  4.04797606e-02f, 8.16417560e-02f, -6.42666668e-02f, -4.05700728e-02f, 6.21967390e-02f, -1.18001159e-02f, 3.53805609e-02f, -1.17529511e-01f, -3.08601372e-02f, -3.55808325e-02f,
  1.66155007e-02f, -2.37456467e-02f, 6.07687496e-02f, -7.09417760e-02f, 9.36221331e-02f, -2.40000095e-02f, -4.73116823e-02f, -6.87905727e-03f, -2.93707810e-02f, 9.39933956e-03f,
  1.33380853e-02f, -7.61704221e-02f, 5.76478429e-02f, -2.53516855e-03f, 3.80738080e-02f, -2.47293953e-02f, 5.19023696e-03f, -2.35924609e-02f, 4.00698893e-02f, 1.20446526e-01f,
  -5.26292846e-02f, -1.21552022e-02f, -5.58524430e-02f, 1.96544100e-02f, -7.42517738e-03f, 2.23717131e-02f, -4.78348844e-02f, -4.24903147e-02f, 1.06911361e-03f, 4.24757898e-02f,
  2.68392190e-02f, 5.37976101e-02f, 8.96639284e-03f, -1.38222426e-03f, 1.61337331e-02f, 2.23394651e-02f, -5.61502688e-02f, 5.76104410e-02f, 2.52075493e-02f, -1.61835421e-02f,
  3.36469859e-02f, -3.23153310e-03f, 1.98032223e-02f, 9.67207476e-02f, 2.86600105e-02f, -3.88231315e-02f, -4.38926183e-03f, -3.06615438e-02f, -2.84952577e-02f, 3.70649825e-04f,
  1.73290446e-01f, 2.99186260e-01f, 6.15557022e-02f, 2.30158698e-02f, 2.12018769e-02f, -5.53515181e-02f, -5.81266135e-02f, -3.82651128e-02f, -7.75434542e-03f, 3.36209424e-02f,
  3.29216830e-02f, 1.22530106e-02f, 3.28270383e-02f, 8.22859332e-02f, -8.62567499e-02f, 7.52326623e-02f, 4.07878831e-02f, 1.68230161e-02f, 6.65947422e-02f, 2.60811672e-02f,
  -2.72871759e-02f, 3.40404585e-02f, -2.06975006e-02f, 5.04688323e-02f, -5.45340106e-02f, 4.15880904e-02f, 4.98933643e-02f, 1.31495688e-02f, -3.47319283e-02f, -4.93487902e-02f,
  -1.23006862e-03f, -7.07356259e-02f, 5.78425936e-02f, 1.16147265e-01f, -2.66779307e-02f, 1.70584425e-01f, 1.42375097e-01f, 3.14255804e-02f, 1.37566164e-01f, -1.51289389e-01f,
  5.73400147e-02f, -5.11997193e-02f, 1.20774418e-01f, 1.66319609e-01f, 6.11806512e-01f, 2.82233089e-01f, 2.26670772e-01f, 9.33789238e-02f, 1.00029051e-01f, -6.96145296e-02f,
  3.94582488e-02f, 1.86414942e-01f, 1.26872316e-01f, -7.16699138e-02f, -1.59874037e-01f, -1.63697854e-01f, -2.29004696e-02f, -6.39237836e-02f, -1.40239686e-01f, 7.70688727e-02f,
  1.45140886e-01f, 1.11113571e-01f, -9.28406790e-02f, -3.23249288e-02f, 2.35338379e-02f, -4.74154800e-02f, -6.99982643e-02f, 4.90218401e-02f, 4.74838819e-03f, 3.46497782e-02f,
  -2.16542799e-02f, 3.22341546e-02f, 5.70008792e-02f, -6.26627579e-02f, 1.78686827e-02f, 2.96726692e-02f, 7.38393562e-03f, -4.00355905e-02f, 2.53217705e-02f, 2.05757970e-05f,
  3.17680389e-02f, -2.52538524e-03f, -8.23813304e-02f, 1.63392853e-02f, -1.52471075e-02f, 4.26213853e-02f, 5.23480326e-02f, -7.30152288e-03f, -1.12216342e-02f, -1.49297738e-03f,
  -1.34833120e-02f, 3.74273211e-02f, 2.97686048e-02f, 1.80135034e-02f, -3.25489300e-03f, -6.60064444e-03f, 1.46322977e-02f, 1.02365576e-02f, -2.01204810e-02f, 1.73570355e-03f,
  -6.21881075e-02f, 6.49014837e-04f, 2.46410966e-02f, -6.39637187e-02f, -5.93872629e-02f, -1.61827393e-02f, -2.96879504e-02f, 3.02637368e-03f, -4.07719947e-02f, 5.20804822e-02f,
  -1.21851815e-02f, 3.32484692e-02f, -4.48269695e-02f, 5.53149059e-02f, 3.89176384e-02f, 1.20630767e-02f, -3.17596346e-02f, 1.56584308e-02f, -2.42415979e-03f, -1.46625647e-02f,
  -1.09588504e-02f, -1.35313511e-01f, -1.85085200e-02f, 6.91584274e-02f, 2.43966449e-02f, -4.14252393e-02f, 1.38423383e-01f, -1.49594182e-02f, 2.41736416e-02f, -5.15520275e-02f,
  -7.87265040e-03f, 1.66947376e-02f, -1.14596989e-02f, 4.80664782e-02f, -6.54702336e-02f, -3.92249413e-02f, 3.85390818e-02f, -4.72685099e-02f, -4.29483652e-02f, -7.21041858e-02f,
  -1.18544266e-01f, -2.81248037e-02f, 3.70485038e-02f, -2.44516749e-02f, 9.06645227e-03f, -9.94144008e-02f, -4.38284092e-02f, -1.72237903e-02f, -2.48178467e-02f, -2.32897960e-02f,
  -3.75545204e-01f, 3.38475198e-01f, 2.34434813e-01f, -9.42004621e-02f, -2.57611990e-01f, -1.99165106e-01f, -8.41658912e-04f, -9.77337137e-02f, -8.55849609e-02f, 4.29067425e-02f,
  -1.33722439e-01f, 1.55501619e-01f, 2.56924361e-01f, 2.51541426e-03f, -1.06717341e-01f, 2.86123633e-01f, -1.00264534e-01f, -3.18710669e-03f, -6.39489805e-03f, 2.77014598e-02f,
  -1.35104045e-01f, -5.89046925e-02f, 1.53966090e-02f, -1.12870418e-01f, -2.63934140e-03f, -3.85228619e-02f, 5.40186791e-03f, 4.03364822e-02f, -9.92134809e-02f, -2.52425252e-03f,
  1.73256658e-02f, 2.25277934e-02f, 1.08862091e-02f, 5.47112897e-02f, -2.61259619e-02f, -4.61661965e-02f, 6.67448109e-03f, 1.20130755e-01f, -5.12804324e-03f, -3.02846986e-03f,
  4.68726307e-02f, -1.41605893e-02f, 4.10284325e-02f, -2.36723502e-03f, -7.14809299e-02f, 4.94454131e-02f, -3.44565585e-02f, -1.40597727e-02f, -1.96291376e-02f, 3.80085632e-02f,
  1.99515000e-02f, -7.25923711e-03f, -5.89069910e-02f, 8.31719022e-03f, -1.97943468e-02f, -6.07911637e-03f, -2.97822244e-02f, -2.24541500e-03f, 7.45333312e-03f, -4.24755290e-02f,
  -2.27212198e-02f, -3.25558074e-02f, 1.64518245e-02f, 3.50554585e-02f, 2.02720668e-02f, -5.50301187e-02f, -1.76518771e-03f, 2.94668972e-03f, -3.86618227e-02f, -1.16566103e-02f,
  -6.03245907e-02f, -6.09176233e-03f, -1.24441674e-02f, -4.57665473e-02f, 3.03379074e-02f, -5.92684466e-03f, -1.29515873e-02f, -1.84342917e-02f, -4.83579002e-02f, -8.45395774e-03f,
  1.81058478e-02f, -2.40963344e-02f, 6.95846369e-03f, 2.86558885e-02f, 4.27202471e-02f, -1.53047955e-02f, -7.07984939e-02f, 1.79827698e-02f, -4.34733443e-02f, -2.95062009e-02f,
  -3.37914191e-02f, 1.48157224e-01f, 2.03181710e-02f, -6.07797764e-02f, 6.54024482e-02f, 1.92295318e-03f, 4.75480705e-02f, -9.36512873e-02f, 5.62785864e-02f, -2.24916916e-02f,
  -7.44358003e-02f, -3.19077186e-02f, -5.24477772e-02f, -3.50802019e-03f, 3.28496424e-03f, -3.69401388e-02f, 2.71484423e-02f, -2.74680816e-02f, -7.49935061e-02f, 1.69395208e-02f,
  -3.21369269e-03f, -4.54637855e-02f, 1.83132403e-02f, -1.87698305e-02f, -6.74973056e-02f, -9.32997279e-03f, 5.37647232e-02f, -2.57887077e-02f, -2.78924294e-02f, 5.13244532e-02f
};

// L0_fan_Wp_bar (Shape: 4 x 120)
const int L0_fan_Wp_bar_rows = 4;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  7.09207237e-01f, -2.19602898e-01f, -6.31951764e-02f, -8.65492597e-03f, -1.65430084e-01f, 2.10132450e-01f, 6.84280455e-01f, -4.42651957e-01f, -4.35420334e-01f, -9.10265557e-03f,
  6.99004233e-02f, 6.99438229e-02f, 6.64245129e-01f, -1.85192868e-01f, 3.65967870e-01f, 2.30800465e-01f, -3.68614614e-01f, 8.27408955e-02f, -1.71034113e-01f, 1.23748027e-01f,
  -8.63324776e-02f, 1.87481239e-01f, 1.86091453e-01f, -3.59160870e-01f, 1.90028518e-01f, -1.72080487e-01f, 5.32700829e-02f, 2.27976203e-01f, -2.40899310e-01f, 1.74949273e-01f,
  -2.57834177e-02f, -1.86522063e-02f, -2.88299415e-02f, -3.50108519e-02f, 8.79562944e-02f, 8.12636018e-02f, 2.05492556e-01f, 2.76539803e-01f, 4.68361704e-03f, -2.48328391e-02f,
  1.02606237e-01f, -1.06752969e-01f, -1.39960274e-01f, 1.03419296e-01f, 3.35993618e-02f, -1.45964652e-01f, -1.14089549e-01f, -1.26369461e-01f, -4.20288965e-02f, 9.16627124e-02f,
  -1.86413173e-02f, -3.41210514e-02f, 1.41954969e-03f, -1.14502318e-01f, -6.25950992e-02f, -8.14759210e-02f, 1.01084784e-01f, 1.57531530e-01f, -5.64408861e-02f, -1.32990256e-01f,
  4.36234549e-02f, 1.61006078e-02f, 7.22608641e-02f, -7.04651400e-02f, 9.05225277e-02f, -1.34029612e-01f, 1.04065634e-01f, -1.49433538e-02f, 7.76535124e-02f, 4.27392945e-02f,
  -4.25229259e-02f, 8.08336586e-03f, 3.74880023e-02f, 3.00048161e-02f, 1.86012983e-01f, -8.48075897e-02f, 2.50890315e-01f, -5.94131183e-03f, -1.39496410e-02f, -1.27954006e-01f,
  -2.14941297e-02f, -4.61033210e-02f, 9.03689265e-02f, 1.59598235e-02f, -1.33433640e-02f, 1.12074934e-01f, -6.77634552e-02f, -9.96410325e-02f, -4.20759432e-02f, 8.99403691e-02f,
  -7.03686848e-02f, -1.17184803e-01f, -1.87355354e-02f, 4.03359160e-02f, -7.12310523e-02f, -6.04840741e-02f, -8.56867954e-02f, -5.68744913e-02f, -1.01332441e-01f, -1.26959598e-02f,
  -1.16847992e-01f, 6.63392469e-02f, 5.05609736e-02f, -7.00303959e-03f, 2.32317019e-02f, -4.69556823e-02f, 4.00196873e-02f, -3.37850936e-02f, -8.66673067e-02f, -1.78554766e-02f,
  -1.26469461e-02f, 2.07905293e-01f, -2.60734037e-02f, -5.14933504e-02f, 6.21076524e-02f, 5.97298965e-02f, 1.65775400e-02f, -4.12119776e-02f, 1.16884142e-01f, 7.05615734e-04f,
  2.11733833e-01f, -1.80201367e-01f, -2.73192693e-02f, 3.37289721e-01f, -1.34838939e-01f, -2.87958264e-01f, -7.35852361e-01f, -3.03711835e-02f, -2.25399271e-01f, -1.62549794e-01f,
  -2.84413677e-02f, -1.67643055e-02f, -2.92043626e-01f, 3.07611972e-01f, 4.97235060e-01f, -2.35498756e-01f, 2.97738612e-01f, 3.74688506e-02f, -5.51490253e-03f, 1.38084084e-01f,
  2.68339396e-01f, 4.27715361e-01f, 3.89335722e-01f, 2.98939914e-01f, 1.51378559e-02f, 1.44738108e-01f, 2.27166265e-01f, 3.08534727e-02f, 2.90145665e-01f, 8.53310302e-02f,
  1.30799532e-01f, 5.13010360e-02f, 1.29278243e-01f, 1.36657702e-02f, -8.02490786e-02f, -9.74319428e-02f, -1.11429691e-01f, 2.54422445e-02f, -1.52339889e-02f, -3.45471390e-02f,
  -1.29235059e-01f, 9.27418321e-02f, 4.92425933e-02f, 9.31224599e-02f, -7.19792917e-02f, 5.20440051e-03f, 4.62438688e-02f, -3.60883251e-02f, -1.57022893e-01f, -5.85336587e-04f,
  -2.56255157e-02f, 3.00772451e-02f, 1.46977594e-02f, -5.54316156e-02f, 3.29382941e-02f, 4.46614213e-02f, 1.12239737e-02f, -6.60370812e-02f, -1.59526933e-02f, 5.82112325e-03f,
  4.41363752e-02f, -5.46833538e-02f, -2.41363551e-02f, -4.12148871e-02f, -6.00135736e-02f, -3.95512469e-02f, 3.14563215e-02f, -5.80753833e-02f, -5.77085139e-03f, -2.29867473e-02f,
  -2.25452613e-02f, -6.31593689e-02f, 1.73064917e-02f, -7.99666345e-02f, 7.51275122e-02f, 3.14010158e-02f, 9.78396311e-02f, 1.16444631e-02f, -1.76466517e-02f, -5.05848937e-02f,
  2.70039346e-02f, 4.89870235e-02f, -1.94369722e-02f, -5.76215535e-02f, 5.82209229e-02f, 1.56825874e-03f, 3.31669264e-02f, -6.09915480e-02f, -3.21903713e-02f, -2.43504439e-03f,
  -7.37417713e-02f, 7.44988993e-02f, -9.33725238e-02f, -1.94722880e-02f, -4.89466498e-03f, 1.18113048e-01f, 9.63999629e-02f, 7.27608651e-02f, 2.28598230e-02f, -6.06906414e-03f,
  1.45398639e-02f, -1.02670282e-01f, 6.19126810e-03f, 5.22022322e-02f, 1.25257596e-01f, -4.15000282e-02f, -4.34460305e-02f, -4.76809070e-02f, 6.06096685e-02f, 1.24455959e-01f,
  -3.10929604e-02f, -2.29078140e-02f, 3.25180255e-02f, -1.57066491e-02f, -5.80569208e-02f, -8.61937776e-02f, 6.52899742e-02f, 8.93276706e-02f, 1.26979768e-01f, 4.10903506e-02f,
  -1.39561206e-01f, 4.38117445e-01f, -5.69159925e-01f, 2.74777949e-01f, -1.88778982e-01f, 6.76700473e-01f, 3.15749347e-01f, 6.13535196e-02f, -5.09993732e-02f, 3.91284913e-01f,
  2.02407986e-01f, 3.28731611e-02f, 1.63984120e-01f, 6.33969843e-01f, 2.32053712e-01f, 3.53086829e-01f, 4.12811428e-01f, 2.95374185e-01f, -5.54227754e-02f, 1.70417756e-01f,
  -4.17953767e-02f, 3.69261265e-01f, -1.67892322e-01f, -4.32844497e-02f, -1.22535914e-01f, -1.99100122e-01f, -9.01460424e-02f, -3.18442106e-01f, 1.56731531e-01f, 5.22122309e-02f,
  1.86003238e-01f, 2.29676310e-02f, -2.24481702e-01f, -8.54796767e-02f, -5.33504449e-02f, -2.11319583e-03f, 2.22393349e-02f, -2.97203939e-02f, -8.51684138e-02f, 7.38198915e-03f,
  1.13757089e-01f, 1.37654841e-02f, 9.19506028e-02f, -7.97577351e-02f, -3.02412007e-02f, -8.98619369e-02f, -3.84432450e-02f, -1.63668469e-02f, -6.37925491e-02f, 3.06447987e-02f,
  -6.18688054e-02f, 6.54674917e-02f, 1.22822216e-02f, 5.42256720e-02f, -1.32801875e-01f, 2.31550764e-02f, 5.78767471e-02f, -3.89233120e-02f, 1.23565502e-01f, 5.22156768e-02f,
  3.65587883e-03f, 1.51564199e-02f, -2.82228272e-02f, 1.45129710e-02f, -3.63480523e-02f, -6.45930097e-02f, 3.58153172e-02f, -5.26111573e-02f, -6.91024065e-02f, 2.35350281e-02f,
  -3.91076654e-02f, 6.31263806e-03f, -5.78149641e-03f, -1.39143774e-02f, 6.94164932e-02f, 6.58702552e-02f, -2.42864247e-02f, -5.06111830e-02f, -5.02852947e-02f, -5.51683754e-02f,
  2.39884090e-02f, 1.43872034e-02f, -1.14143252e-01f, -2.31893566e-02f, 6.66028336e-02f, -9.08937380e-02f, 5.36671579e-02f, -6.99635269e-03f, 9.07692965e-03f, -8.55801534e-03f,
  2.11299598e-01f, 4.20215577e-02f, 2.68752631e-02f, 4.63336445e-02f, 2.17668787e-02f, 7.89347142e-02f, 3.30882110e-02f, 2.34203208e-02f, 1.69132315e-02f, -1.68326646e-02f,
  -7.43770376e-02f, -9.64846113e-04f, -1.93114076e-02f, 5.34407198e-02f, 4.47961241e-02f, 2.74528731e-02f, 1.12697273e-01f, -4.80575226e-02f, 4.17206362e-02f, 2.68540601e-03f,
  1.44868940e-02f, -4.53648455e-02f, -4.82281484e-02f, -8.46002176e-02f, 7.16210157e-02f, -2.34381552e-03f, -2.40333588e-03f, -6.59811869e-02f, -1.00096561e-01f, 4.75347675e-02f,
  7.19575286e-01f, -5.36764145e-01f, -7.58892000e-02f, 2.72532433e-01f, 2.19882846e-01f, -6.90288424e-01f, -4.09666225e-02f, -1.40977159e-01f, 4.03070062e-01f, -3.22895348e-01f,
  1.25728054e-02f, -1.70510635e-01f, 2.17567720e-02f, -3.06007832e-01f, 2.12683409e-01f, 8.98441523e-02f, -1.90086558e-01f, -7.70723447e-02f, 1.90341815e-01f, -1.10214144e-01f,
  2.03053966e-01f, -1.52747780e-01f, -3.18352729e-02f, -2.88306355e-01f, -6.68298826e-02f, 2.52444972e-03f, 5.27014732e-02f, -1.43401399e-01f, -1.41525134e-01f, -4.20288853e-02f,
  7.34250471e-02f, 2.58922458e-01f, -2.58317478e-02f, -5.54608963e-02f, -3.06566413e-02f, -1.38695315e-01f, -1.18393630e-01f, 2.02222466e-02f, 5.29908389e-02f, -3.01465932e-02f,
  -6.33262619e-02f, 5.09572178e-02f, 3.12220510e-02f, 2.95666903e-02f, 1.51129009e-03f, 8.07747394e-02f, 8.75002965e-02f, 3.57188024e-02f, 3.42094488e-02f, 1.20246345e-02f,
  5.55877760e-03f, 4.58347611e-02f, 6.50437027e-02f, -5.50466739e-02f, 6.73123971e-02f, 4.41620126e-02f, -1.75760908e-03f, -9.94783193e-02f, -6.81299716e-03f, 1.16674425e-02f,
  -3.18048224e-02f, -6.56633126e-03f, -9.12676658e-03f, 7.43725970e-02f, -9.39942226e-02f, 6.34751096e-02f, 1.85844004e-02f, -8.48281309e-02f, 5.91103844e-02f, -5.66849709e-02f,
  5.41910203e-03f, 2.21786033e-02f, 6.57045245e-02f, 3.15086432e-02f, 1.67805310e-02f, 4.12362553e-02f, 8.03581998e-03f, 1.71923470e-02f, 1.29457396e-02f, 5.96458931e-03f,
  3.22889723e-02f, -4.25492693e-03f, -1.69949122e-02f, -4.19329330e-02f, 5.19197956e-02f, 2.67732833e-02f, 3.37347500e-02f, -2.64828652e-02f, 3.10958475e-02f, -8.67735071e-05f,
  -1.97231933e-01f, -5.59658587e-01f, -4.61164489e-02f, -9.84145515e-03f, -3.41322087e-02f, -1.30636443e-03f, 4.54389229e-02f, -6.03579618e-02f, -2.09021121e-02f, -3.36486101e-02f,
  -3.37452220e-04f, -5.01643904e-02f, 2.51208488e-02f, 8.39826539e-02f, -4.65298072e-02f, -9.42212939e-02f, -6.24416247e-02f, -4.00140360e-02f, -1.14526995e-01f, 1.43749053e-02f,
  -6.60845935e-02f, 3.93474139e-02f, -1.95860062e-02f, -2.06843913e-02f, -6.45113438e-02f, -2.50516832e-02f, -2.48942450e-02f, 7.93166533e-02f, -6.35373220e-02f, -3.78584340e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 4)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 4;
const float L0_fan_Bp_bar_data[] = {
  2.55001038e-01f, -1.67328939e-01f, 1.19141512e-01f, 2.84392267e-01f
};

// L1_fan_Wp (Shape: 6 x 16)
const int L1_fan_Wp_rows = 6;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  1.72715917e-01f, 2.49437347e-01f, 1.96171269e-01f, 1.69066757e-01f, -1.16591372e-01f, -3.12724560e-01f, 2.14470997e-01f, -3.73202980e-01f, -2.69343942e-01f, 1.78110227e-01f,
  4.73555177e-01f, -8.15742493e-01f, 4.78446424e-01f, -3.78389984e-01f, 3.59520942e-01f, -1.30757749e-01f, 1.12906754e-01f, 5.92432916e-01f, -1.75087735e-01f, 4.63634998e-01f,
  -8.23017895e-01f, -2.66183496e-01f, 1.59353286e-01f, -1.11746939e-03f, -3.25968713e-01f, 1.84201241e-01f, -9.01203215e-01f, -2.48990804e-01f, 3.46649766e-01f, -3.89506817e-01f,
  -4.11249578e-01f, 5.86011946e-01f, -5.34094274e-01f, -1.37037858e-01f, -2.56161481e-01f, -3.91727477e-01f, 6.34517491e-01f, 1.52309641e-01f, -8.47834170e-01f, 1.10975713e-01f,
  -3.51757407e-01f, -7.90309966e-01f, 3.82751524e-01f, 5.46455741e-01f, -1.67478710e-01f, -1.08817378e-02f, -3.59703042e-02f, 1.55055255e-01f, -2.14406341e-01f, 4.89515990e-01f,
  -8.86159778e-01f, -2.80410558e-01f, 2.47681171e-01f, 1.54102519e-01f, -8.27967823e-01f, 1.42618611e-01f, -2.59673238e-01f, -5.39837182e-01f, 1.84016421e-01f, 2.77478069e-01f,
  1.05491877e-02f, -1.93513513e-01f, 6.25143126e-02f, 2.76238382e-01f, -3.44419889e-02f, 3.03568006e-01f, 9.79864970e-02f, -2.04672575e-01f, -3.57223868e-01f, 3.85946900e-01f,
  -5.37562510e-03f, 1.34565830e-01f, -5.03611743e-01f, -6.03389204e-01f, -4.39768016e-01f, 1.85573712e-01f, 2.02141311e-02f, -2.17501253e-01f, -2.83285916e-01f, -1.85606241e-01f,
  -1.07837312e-01f, 5.51383533e-02f, -1.58192471e-01f, -3.30198444e-02f, -1.05108015e-01f, 2.01047227e-01f, 2.47106746e-01f, 2.64232129e-01f, -1.33770078e-01f, -3.71245325e-01f,
  1.63147822e-01f, 3.43606323e-01f, -1.09705105e-01f, -3.22854668e-01f, -3.76069099e-01f, 3.07577044e-01f
};

// L1_fan_Wp_bar (Shape: 4 x 16)
const int L1_fan_Wp_bar_rows = 4;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  5.07273614e-01f, -2.57611811e-01f, 7.96860635e-01f, -1.18709080e-01f, 2.04487771e-01f, 9.86961424e-01f, 7.68355548e-01f, 7.85961568e-01f, 4.90637541e-01f, -4.95820105e-01f,
  1.03852630e-01f, 7.70242453e-01f, 2.45440211e-02f, 3.37947816e-01f, -3.93056124e-01f, -5.39314866e-01f, 8.45336318e-01f, -3.71949136e-01f, 2.76034027e-01f, -4.40841883e-01f,
  1.17186081e+00f, 9.42211032e-01f, 3.98729205e-01f, 2.62126356e-01f, 7.54993856e-01f, 6.98553845e-02f, 8.64662766e-01f, 6.29264355e-01f, 7.75226057e-01f, 9.39123034e-01f,
  9.47954804e-02f, 7.33505189e-01f, 3.25634509e-01f, 9.78342071e-02f, 5.07499389e-02f, 1.56101137e-01f, 5.55143416e-01f, -1.87157080e-01f, -8.70745480e-01f, -1.70134827e-01f,
  4.95842993e-02f, -5.16773760e-01f, 2.20362470e-01f, 2.51875728e-01f, -1.21513151e-01f, 7.96062589e-01f, 7.91408598e-01f, -4.57297981e-01f, 1.93483591e-01f, 5.41000962e-01f,
  6.10193014e-01f, 2.06301153e-01f, 3.44571233e-01f, 8.33609164e-01f, -5.29049695e-01f, -2.50432432e-01f, -7.70891666e-01f, -5.78556716e-01f, 5.70042491e-01f, 1.67314918e-03f,
  7.68938959e-01f, -5.49115121e-01f, 7.97206998e-01f, -7.96292782e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 4)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 4;
const float L1_fan_Bp_bar_data[] = {
  8.17480087e-01f, 8.69699717e-01f, 1.80453226e-01f, 9.43065524e-01f
};

// L2_fan_Wp (Shape: 6 x 16)
const int L2_fan_Wp_rows = 6;
const int L2_fan_Wp_cols = 16;
const float L2_fan_Wp_data[] = {
  -1.16058648e-01f, -5.72165735e-02f, 3.00281733e-01f, 3.63257378e-01f, -2.49436185e-01f, -6.98216796e-01f, 5.86191773e-01f, 7.69326240e-02f, -7.38260090e-01f, -6.22855783e-01f,
  -3.47148590e-02f, 1.66408494e-01f, -3.70242447e-01f, 9.82798263e-02f, -3.18101496e-01f, 3.34721923e-01f, -5.36288202e-01f, -7.69530386e-02f, -3.11388075e-01f, -4.18370403e-02f,
  7.17574179e-01f, -2.59775907e-01f, -6.70968220e-02f, -5.58963120e-01f, 8.42956960e-01f, 4.67205554e-01f, 1.67573616e-02f, 4.06944931e-01f, -6.06240667e-02f, 2.33825266e-01f,
  -3.17285478e-01f, 3.33085477e-01f, 2.32855722e-01f, 3.24967563e-01f, -3.44317108e-01f, 2.63238937e-01f, -2.86876351e-01f, -3.28276277e-01f, -4.23033059e-01f, -4.29174095e-01f,
  5.95776379e-01f, 4.63712811e-01f, 1.86351940e-01f, 3.34547311e-02f, -5.84237933e-01f, 1.35396004e-01f, 4.06430781e-01f, -1.50958911e-01f, -2.94359803e-01f, -1.81332856e-01f,
  -1.77539531e-02f, 2.88623542e-01f, 3.94499786e-02f, 4.83379126e-01f, 2.04638034e-01f, 1.02981293e+00f, -4.09938097e-01f, -1.57476068e-01f, 2.53170997e-01f, 2.34753966e-01f,
  2.46877447e-01f, -1.76705524e-01f, -5.11018813e-01f, 1.16678022e-01f, 3.14832658e-01f, 2.38977194e-01f, -7.30463564e-02f, -4.61627156e-01f, -1.73375592e-01f, -2.32938960e-01f,
  -7.05048740e-01f, -2.70034909e-01f, 5.33663869e-01f, 5.63935697e-01f, -9.22162458e-03f, -3.57199550e-01f, -3.75292301e-01f, 1.47709429e-01f, 5.72255731e-01f, -2.78533429e-01f,
  -3.92758876e-01f, -8.46114159e-02f, -1.53389722e-01f, -2.00403497e-01f, 5.35666347e-01f, 5.83866574e-02f, -6.66752815e-01f, 2.29432181e-01f, -4.90503125e-02f, 1.14651948e-01f,
  8.34843218e-01f, -5.26756234e-02f, 6.99682593e-01f, 2.80118460e-04f, -2.20175803e-01f, -1.28000185e-01f
};

// L2_fan_Wp_bar (Shape: 4 x 16)
const int L2_fan_Wp_bar_rows = 4;
const int L2_fan_Wp_bar_cols = 16;
const float L2_fan_Wp_bar_data[] = {
  8.82090807e-01f, 5.15076756e-01f, -2.99513012e-01f, -1.45886973e-01f, 4.44297135e-01f, 2.60325581e-01f, -1.03842175e+00f, -1.49568355e+00f, 1.16103202e-01f, -1.13603437e+00f,
  -3.12648982e-01f, -4.85966980e-01f, 1.60080171e+00f, 6.95791423e-01f, 3.33317220e-01f, -6.79447293e-01f, -5.36541224e-01f, -1.04478098e-01f, 4.85679001e-01f, -6.09943330e-01f,
  9.44168448e-01f, 7.70702481e-01f, -1.56426287e+00f, 1.92370105e+00f, 3.81705701e-01f, 1.23288488e+00f, -2.76339561e-01f, 1.57485425e+00f, 3.91819924e-01f, 1.31009555e+00f,
  -5.78102887e-01f, -3.58226925e-01f, 4.63027000e-01f, -2.50084877e-01f, 2.98141450e-01f, 4.63465035e-01f, 1.22607458e+00f, 1.29055965e+00f, 6.94466591e-01f, -3.81700039e-01f,
  1.07102382e+00f, 6.94219053e-01f, 1.06904018e+00f, -1.63796067e-01f, 1.32334447e+00f, -1.58341587e-01f, 4.00489807e-01f, 1.66789365e+00f, -2.61334330e-01f, 4.11538810e-01f,
  3.64329368e-01f, 6.95904016e-01f, -1.53956425e+00f, -1.00211346e+00f, 5.71914971e-01f, -1.60663402e+00f, -8.99763107e-01f, -6.49421155e-01f, -9.18134212e-01f, -3.84581476e-01f,
  -4.49686885e-01f, 1.15607893e+00f, 9.33385074e-01f, 5.93322277e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 4)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 4;
const float L2_fan_Bp_bar_data[] = {
  2.03893632e-01f, 5.62562168e-01f, 6.41894817e-01f, -3.29183927e-03f
};

// L3_linear_W (Shape: 12 x 16)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 16;
const float L3_linear_W_data[] = {
  8.03189397e-01f, -9.46081877e-01f, 2.21108600e-01f, -6.28625453e-01f, -2.47416124e-01f, -7.35372245e-01f, -2.69666404e-01f, 2.82398254e-01f, 1.09553194e+00f, -2.46133581e-01f,
  1.00541341e+00f, -9.42376375e-01f, -1.59490621e+00f, -1.34900022e+00f, 7.24877000e-01f, -2.61546731e-01f, -8.45424831e-01f, 4.06997204e-01f, 2.09149778e-01f, -8.87056828e-01f,
  1.06479347e+00f, -5.75722575e-01f, -8.16206168e-03f, 1.02506173e+00f, 1.14344311e+00f, -7.34562933e-01f, 7.09389508e-01f, -4.80235815e-01f, -7.78521061e-01f, -1.55942127e-01f,
  -5.14406979e-01f, 8.30813587e-01f, 6.23601019e-01f, -5.09019017e-01f, -4.78685759e-02f, -4.70103800e-01f, -3.45486134e-01f, -8.51713046e-02f, 5.68715394e-01f, -1.37650466e+00f,
  1.08374846e+00f, 1.57855004e-02f, 6.23010814e-01f, -8.72165382e-01f, 6.78440988e-01f, -1.71281612e+00f, -1.54341149e+00f, 5.90005279e-01f, -4.88411307e-01f, 1.00862265e+00f,
  8.77871752e-01f, 5.27906001e-01f, 5.54963350e-01f, 7.18828142e-02f, -1.07394385e+00f, 8.04806709e-01f, 9.64795649e-01f, 7.00872064e-01f, 1.06931591e+00f, 7.93334842e-01f,
  -1.81506193e+00f, 6.34966016e-01f, 5.85704207e-01f, -1.76825464e+00f, -6.22382581e-01f, -1.27242720e+00f, 6.71100080e-01f, 3.14938188e-01f, 9.45854187e-01f, -1.65807635e-01f,
  -9.86658633e-01f, 3.25332552e-01f, 5.33185005e-01f, -8.74959111e-01f, 6.62681460e-01f, 5.85358799e-01f, 6.65268779e-01f, -6.49744391e-01f, 4.73423928e-01f, -8.27520549e-01f,
  9.93412286e-02f, -2.20295079e-02f, -9.21118438e-01f, 1.09992027e+00f, -7.15440154e-01f, 3.62373322e-01f, 9.77873862e-01f, 4.30622041e-01f, -7.95739353e-01f, -1.18723619e+00f,
  -1.34045410e+00f, -4.25582260e-01f, 5.09670734e-01f, -1.44197392e+00f, 2.05769062e-01f, 3.76857705e-02f, 3.24210376e-01f, 9.62649643e-01f, 1.09799755e+00f, 8.82473648e-01f,
  8.51198435e-01f, 2.56826818e-01f, 1.10650265e+00f, -1.46523762e+00f, -7.32329845e-01f, 9.58405375e-01f, -9.29842770e-01f, -1.34881651e+00f, -6.88008547e-01f, 5.93509078e-01f,
  -8.97192478e-01f, 1.38138905e-01f, 7.32815087e-01f, -1.05881453e+00f, 2.04374224e-01f, 1.47109181e-01f, -1.00063100e-01f, 7.14191347e-02f, -2.62846857e-01f, 4.41500485e-01f,
  1.08607697e+00f, -1.15766513e+00f, 7.51512468e-01f, 5.88051081e-01f, -3.02696079e-01f, 1.18747973e+00f, -1.02021968e+00f, -8.59886050e-01f, -1.85765270e-02f, 4.39975649e-01f,
  4.71810579e-01f, -5.47544062e-01f, -2.85990775e-01f, -4.01822776e-01f, -1.09790361e+00f, -5.23355782e-01f, -6.05559349e-01f, -7.59817600e-01f, 1.00376773e+00f, 8.12555075e-01f,
  7.24159598e-01f, -1.38800412e-01f, -8.74314427e-01f, -1.03170663e-01f, -5.52029133e-01f, -1.03197300e+00f, -1.04062045e+00f, 4.01064232e-02f, -1.07583535e+00f, 2.10261390e-01f,
  5.26013970e-01f, 1.10266376e+00f, -3.89005482e-01f, 8.92363131e-01f, -1.40586883e-01f, 6.01838052e-01f, -7.06658483e-01f, 4.25148636e-01f, 1.27234221e-01f, -1.14870377e-01f,
  3.11356634e-01f, 8.75298381e-01f, -7.88853407e-01f, -3.54148179e-01f, -9.77749407e-01f, 9.57930326e-01f, 1.31956875e+00f, -9.69335258e-01f, -1.10586596e+00f, 1.06613159e+00f,
  -7.83928216e-01f, 1.69181421e-01f, -1.04260695e+00f, -1.39974201e+00f, 1.01493084e+00f, -1.30042434e+00f, 6.23269081e-01f, 6.69815183e-01f, -9.22017217e-01f, -2.42160037e-01f,
  -6.51389837e-01f, -6.91842794e-01f, -1.01530528e+00f, -7.93109715e-01f, -2.24303260e-01f, 9.33204353e-01f, -7.80889213e-01f, 8.33157897e-01f, 9.64288831e-01f, 2.34744489e-01f,
  -2.53781259e-01f, -1.94318676e+00f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  -6.14721626e-02f, -1.42576277e-01f, 9.07577649e-02f, 3.42872024e-01f, -5.39783061e-01f, -6.21767975e-02f, 2.42918104e-01f, -1.87084809e-01f, -4.78051215e-01f, -2.52800226e-01f,
  4.83685791e-01f, 3.24971676e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 4
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 6, 4
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        16, 6, 4
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        16, 12
    );
    }
    