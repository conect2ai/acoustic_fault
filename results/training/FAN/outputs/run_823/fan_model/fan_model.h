/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 9 x 120)
const int L0_fan_Wp_rows = 9;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -1.45976394e-01f, 9.87210050e-02f, -9.36323106e-02f, 1.77811354e-01f, -4.54681041e-03f, -1.25994943e-02f, 5.68347387e-02f, -4.33374085e-02f, -2.87198890e-02f, 1.54275492e-01f,
  -9.11355838e-02f, -1.57413945e-01f, -8.25230032e-02f, -5.38727641e-02f, -1.04794219e-01f, 2.81144619e-01f, 2.82676399e-01f, 1.69728696e-01f, -5.02422564e-02f, -4.62761633e-02f,
  1.73399717e-01f, 1.06344402e-01f, -5.17976731e-02f, 8.31331238e-02f, 2.96184212e-01f, 1.78220809e-01f, 1.41056970e-01f, 1.20454796e-01f, 9.36320573e-02f, 4.97816503e-01f,
  1.12205841e-01f, -9.24331695e-02f, -5.99528849e-02f, -3.83311845e-02f, -9.84181762e-02f, 4.15424854e-02f, -8.96968227e-03f, 5.81906624e-02f, 3.23054306e-02f, 7.62312040e-02f,
  -1.04782455e-01f, -7.74609819e-02f, 4.68678363e-02f, 5.34931049e-02f, 4.76046558e-03f, 2.17884649e-02f, -1.29086636e-02f, -8.00165236e-02f, -2.64270492e-02f, -2.28074589e-03f,
  2.37215739e-02f, -1.74865332e-02f, -8.23267177e-02f, 2.09504794e-02f, 4.22334336e-02f, -2.73009762e-02f, 1.80232432e-02f, 7.30312914e-02f, 7.02582812e-03f, 3.21558625e-01f,
  -3.28061618e-02f, 2.59432551e-02f, 2.70531494e-02f, -1.11282170e-02f, -1.25426403e-03f, 5.15865982e-02f, 1.18168890e-02f, 6.14695027e-02f, 1.91909820e-02f, 3.75320800e-02f,
  -2.82342620e-02f, -4.08911109e-02f, -2.04454623e-02f, 1.40135273e-01f, 3.73880751e-02f, 6.86397552e-02f, 7.71593824e-02f, 9.30125639e-02f, 6.47577494e-02f, 7.34942907e-04f,
  -2.85916273e-02f, -2.88793072e-02f, -5.21305799e-02f, 4.78450321e-02f, -7.77670741e-02f, 6.46021292e-02f, -1.03251837e-01f, -7.91865215e-03f, -9.05255079e-02f, 7.74368178e-03f,
  -1.19843803e-01f, -2.65986681e-01f, 1.63934708e-01f, 2.55271718e-02f, 2.48652559e-05f, 1.78116001e-02f, -2.39775572e-02f, -2.80842148e-02f, -7.87300542e-02f, 3.24272551e-02f,
  -5.45416884e-02f, -4.94224913e-02f, -1.91547722e-02f, -4.78938930e-02f, -4.05070372e-02f, -4.73955675e-04f, 4.44238149e-02f, 2.51146778e-02f, 5.34655042e-02f, 5.17262407e-02f,
  -2.05353480e-02f, 1.61386922e-01f, 1.33935809e-01f, 1.23285443e-01f, 7.71517158e-02f, -9.34688840e-03f, 8.38543549e-02f, 1.33177981e-01f, 4.59244568e-03f, 3.39557767e-01f,
  2.64976501e-01f, -2.26597682e-01f, -4.29145545e-01f, -1.40817747e-01f, -1.35208383e-01f, -8.01365525e-02f, -2.14761660e-01f, 4.01372015e-02f, 4.60792407e-02f, -6.11209609e-02f,
  3.15035768e-02f, 2.89793432e-01f, 1.22585610e-01f, 1.66250572e-01f, 7.77265877e-02f, -2.66559869e-01f, -3.08570236e-01f, -1.37082441e-02f, 2.30801538e-01f, 1.68443754e-01f,
  8.43264759e-02f, 3.43037918e-02f, 2.78888904e-02f, -7.13252574e-02f, -1.21969588e-01f, 4.61342633e-02f, -1.78822532e-01f, -1.59213588e-01f, -4.79315184e-02f, -1.92406610e-01f,
  8.38419795e-02f, -1.84410557e-01f, 8.84186197e-03f, 8.34311172e-02f, -3.10137440e-02f, 1.11406401e-01f, 9.22675952e-02f, 5.68087623e-02f, -6.23263121e-02f, -9.35333446e-02f,
  -5.00681922e-02f, -3.28227542e-02f, -3.28641795e-02f, -3.75352949e-02f, 1.89320315e-02f, 7.65170157e-02f, -5.95817864e-02f, -5.97002581e-02f, 7.36417845e-02f, 4.27046381e-02f,
  2.82787029e-02f, -3.25802229e-02f, -7.02382922e-02f, 1.00480346e-02f, -4.92744260e-02f, -1.28523082e-01f, -1.11438558e-01f, -4.21124510e-02f, 4.89280261e-02f, 1.81747489e-02f,
  -6.43831724e-03f, -6.15875684e-02f, -1.64372232e-02f, -2.29817536e-02f, -1.88212050e-03f, -2.69949492e-02f, -9.83142704e-02f, -3.65801062e-03f, -7.03682378e-03f, -8.37016180e-02f,
  -1.10477339e-02f, -2.91592311e-02f, -5.38224587e-03f, -4.21228819e-02f, 5.20567261e-02f, -4.55945060e-02f, 2.67146938e-02f, -2.97663901e-02f, 6.45081326e-02f, 2.18538605e-02f,
  2.66014878e-02f, -4.36916240e-02f, -5.74057922e-02f, 7.13138143e-03f, -4.35816832e-02f, -2.05805451e-02f, 3.09544094e-02f, 2.23262776e-02f, 4.83985357e-02f, -2.75853034e-02f,
  3.63904387e-01f, -1.19322911e-02f, 1.66868985e-01f, 9.51302201e-02f, -8.25306587e-03f, -3.25977281e-02f, -6.46269247e-02f, -1.80711970e-03f, -2.96271387e-02f, 9.49427933e-02f,
  -2.95664603e-03f, 3.99821587e-02f, -2.03799903e-02f, 3.29255536e-02f, 5.75469695e-02f, 4.92006220e-05f, 6.97283521e-02f, 1.00437016e-03f, 8.44927970e-03f, 3.18548009e-02f,
  -5.08071147e-02f, 9.14949179e-02f, 2.36869559e-01f, 4.55385447e-02f, 4.45000231e-02f, 1.83956087e-01f, 1.20357402e-01f, 1.24869958e-01f, 9.66195464e-02f, 2.14124963e-01f,
  -6.32164776e-01f, 1.58919141e-01f, 2.33321041e-01f, -5.25246635e-02f, 4.95624505e-02f, 2.96026724e-03f, 2.02118754e-01f, 8.06742683e-02f, 8.60961825e-02f, 9.82893351e-03f,
  -2.02933937e-01f, -3.43261451e-01f, -2.18149483e-01f, -1.35586470e-01f, -1.56301022e-01f, 2.26670906e-01f, 3.35592806e-01f, -5.30011300e-03f, -2.74233520e-01f, -2.40550876e-01f,
  5.71530052e-02f, 1.00520492e-01f, -1.16128512e-01f, 6.02639690e-02f, 9.48448926e-02f, -4.51698713e-02f, 2.43711889e-01f, 4.83515449e-02f, 3.18828076e-02f, 1.22251466e-01f,
  -1.20090395e-01f, -7.63333291e-02f, -7.97233954e-02f, -1.18420258e-01f, 4.34811898e-02f, -5.94789237e-02f, -2.77018733e-02f, 6.97054267e-02f, -2.08625812e-02f, 8.54596198e-02f,
  -8.10253993e-02f, -7.19862059e-02f, 3.14074606e-02f, 2.89625209e-02f, 9.52671096e-02f, 1.10697560e-02f, 1.55952811e-01f, 2.37838849e-02f, 1.09775603e-01f, 3.23347971e-02f,
  7.95898680e-03f, -6.79188892e-02f, -6.25553280e-02f, 1.22834697e-01f, -2.96117049e-02f, -4.13517877e-02f, 1.75295278e-01f, -1.76578225e-03f, -3.45995314e-02f, 1.20635338e-01f,
  -1.22401984e-02f, -6.50692508e-02f, 1.18937083e-02f, -5.33451186e-03f, 2.36912891e-02f, 2.30997913e-02f, -1.18201151e-02f, 1.90931391e-02f, -3.19002159e-02f, 5.35376444e-02f,
  1.22815021e-03f, 5.51810535e-03f, 1.51675446e-02f, -5.80705553e-02f, 2.14931034e-02f, 2.42999531e-02f, -5.69317825e-02f, 1.60142798e-02f, 1.62498778e-04f, 2.71079689e-03f,
  -5.77765331e-02f, -5.97780235e-02f, 5.10403328e-02f, 3.20048556e-02f, 9.71704796e-02f, 6.18895935e-03f, -2.86861626e-03f, 6.63284562e-04f, 1.00265108e-01f, -2.55835485e-02f,
  -1.19651640e-02f, -2.29575094e-02f, -1.04429051e-01f, -1.00425713e-01f, 2.69203037e-02f, -9.42705106e-03f, 4.26543690e-03f, -3.31760496e-02f, -3.95821743e-02f, -8.49139225e-03f,
  -5.79087287e-02f, 2.49693654e-02f, -1.17946335e-03f, 7.29424208e-02f, -4.57951501e-02f, 3.46591510e-02f, 1.09781131e-01f, -9.65682641e-02f, -8.31336603e-02f, -1.83490533e-02f,
  1.30092487e-01f, 2.76172105e-02f, -2.33234122e-01f, -7.15277642e-02f, -3.15906703e-02f, -2.81126380e-01f, -7.52467066e-02f, 1.49143161e-02f, -1.58858046e-01f, 7.10499510e-02f,
  -3.05133969e-01f, -5.09514332e-01f, -1.47972897e-01f, -2.82851160e-01f, -1.20737068e-01f, -6.39905110e-02f, -2.11241215e-01f, 7.37585574e-02f, 8.66725147e-02f, -2.27951646e-01f,
  -8.36996436e-02f, -5.90147357e-03f, -2.41565495e-03f, 3.41197886e-02f, -6.50541186e-02f, -3.48538220e-01f, -2.68404007e-01f, -1.64867043e-02f, 1.67948857e-01f, 2.21001301e-02f,
  -8.91033784e-02f, -9.67403278e-02f, -4.06827033e-02f, -2.34008934e-02f, -5.45728207e-02f, 9.86007527e-02f, -9.26937386e-02f, -2.30284613e-02f, -5.82385436e-02f, -3.06150705e-01f,
  -3.52438331e-01f, -1.06828958e-01f, 1.19588397e-01f, 4.16003130e-02f, -5.29746450e-02f, 6.80944622e-02f, -6.10104278e-02f, 9.36239436e-02f, 1.04362033e-01f, -3.08779888e-02f,
  -1.84402417e-03f, 5.58706820e-02f, -4.47776075e-03f, 5.12933992e-02f, -2.40014028e-02f, 3.95797975e-02f, 5.65111935e-02f, -4.47600447e-02f, 5.27190082e-02f, -6.56726286e-02f,
  -1.48020864e-01f, -2.01638732e-02f, 1.47101190e-02f, 4.46439981e-02f, 7.55059570e-02f, 8.82114246e-02f, -6.02296479e-02f, 1.10196330e-01f, 2.38973871e-01f, -6.16509989e-02f,
  1.46602076e-02f, 2.54395697e-02f, 5.51952720e-02f, 3.71835679e-02f, 1.39947224e-03f, 5.57859661e-03f, -5.08387201e-02f, -3.07638478e-02f, -7.25078769e-03f, 1.40886120e-02f,
  -3.16866562e-02f, -8.55071619e-02f, -7.03503937e-02f, -8.22192356e-02f, -4.16812561e-02f, 4.93998900e-02f, -3.02026495e-02f, -8.94393176e-02f, -1.25254283e-03f, 2.85776444e-02f,
  -4.73284945e-02f, 6.17749020e-02f, 2.46824548e-02f, 2.80737486e-02f, -3.42860445e-02f, -4.65898849e-02f, 1.74565576e-02f, 3.62432301e-02f, 6.15725182e-02f, 1.88423526e-02f,
  1.34105667e-01f, 1.24491960e-01f, -2.06270754e-01f, -1.70728602e-02f, 2.87777837e-02f, 7.18763173e-02f, -4.10836264e-02f, 5.45091592e-02f, -3.72969210e-02f, -2.37124711e-02f,
  -5.48548773e-02f, -9.18376148e-02f, -8.90867487e-02f, -1.83467288e-02f, -3.69356051e-02f, 1.12565316e-01f, -4.91355322e-02f, -5.13542444e-02f, 2.14136206e-02f, 2.60662101e-02f,
  -8.28675628e-02f, -1.79457273e-02f, -4.67777178e-02f, 7.43347704e-02f, 6.88471720e-02f, 5.67714497e-02f, 2.94716321e-02f, 4.21903990e-02f, 8.49997923e-02f, -1.98405713e-01f,
  6.03088662e-02f, -2.03263417e-01f, -3.65590453e-01f, 1.07227668e-01f, -7.02615008e-02f, -2.76218385e-01f, -4.52489406e-01f, -1.70678459e-02f, -2.16487758e-02f, -1.38446957e-01f,
  1.11439884e-01f, 1.53186515e-01f, 1.50766656e-01f, 1.43402845e-01f, 9.19179022e-02f, -3.82730693e-01f, -3.31825078e-01f, 8.13844986e-03f, 1.22009411e-01f, 7.98542574e-02f,
  5.87993413e-02f, 3.94984484e-02f, 2.02653974e-01f, 9.34784561e-02f, -1.32326027e-02f, 4.45978753e-02f, -7.97994360e-02f, -2.06606481e-02f, -7.14179128e-02f, -5.18008657e-02f,
  -3.19355994e-01f, 3.22247967e-02f, -1.15117937e-01f, 1.39045820e-01f, 3.75039428e-02f, -9.19877663e-02f, -1.50131524e-01f, 3.00355721e-02f, 1.39650414e-02f, -4.42014001e-02f,
  9.45734605e-02f, 3.75823863e-02f, 8.65618885e-02f, 8.19791853e-02f, 3.87226976e-02f, 6.61172196e-02f, 4.15077992e-02f, 1.04827784e-01f, 7.88050443e-02f, -1.76104438e-02f,
  4.34592590e-02f, 1.61280498e-01f, 2.29725987e-02f, 2.34995540e-02f, 3.12269144e-02f, 1.02628365e-01f, -4.21158820e-02f, 1.61968485e-01f, 3.42907682e-02f, -1.64255947e-01f,
  -2.10282654e-02f, -4.65668179e-02f, 2.50204708e-02f, 5.82712404e-02f, -2.93401238e-02f, -6.78125843e-02f, -3.56887840e-02f, -3.14403325e-02f, 6.17156141e-02f, -1.59747936e-02f,
  4.80689965e-02f, -2.47043502e-02f, 1.60360839e-02f, 2.03026342e-03f, 4.47165482e-02f, 3.20113562e-02f, 2.57831649e-04f, 5.14581893e-03f, 2.27504577e-02f, 2.43357345e-02f,
  7.91651532e-02f, -6.18017316e-02f, -1.64808352e-02f, 3.71053107e-02f, 2.44691148e-02f, 7.45507469e-03f, -8.53167381e-03f, 1.16844982e-01f, -2.53288969e-02f, 3.33864130e-02f,
  -1.33057609e-01f, 1.57646164e-01f, -2.19416991e-01f, 5.43132201e-02f, -3.85114662e-02f, 6.31175637e-02f, -2.01078728e-02f, 3.69939730e-02f, 6.33036792e-02f, -7.66870156e-02f,
  3.08796614e-02f, 1.43945627e-02f, -8.65023881e-02f, 2.65035015e-02f, -4.73181717e-02f, -2.93065123e-02f, -7.77691230e-02f, -4.91660321e-03f, 1.06593091e-02f, -8.01075622e-02f,
  -9.70481634e-02f, -1.24945700e-01f, -1.09816082e-01f, -1.85149699e-01f, -3.84404883e-02f, -9.70103219e-02f, -2.05909625e-01f, -2.08954126e-01f, -9.98541936e-02f, -5.03235757e-01f,
  -1.17772244e-01f, -7.20234364e-02f, -4.60106343e-01f, 1.59516245e-01f, 1.28925085e-01f, -2.14379296e-01f, -3.13656271e-01f, -5.69727533e-02f, 2.55877048e-01f, 3.38034220e-02f,
  2.37357035e-01f, 3.34100753e-01f, 1.79249421e-01f, 1.74657777e-02f, -2.29688063e-01f, -1.90723807e-01f, -1.78993881e-01f, -2.85696894e-01f, -1.80745840e-01f, -4.42062989e-02f,
  8.89583156e-02f, 9.47822183e-02f, 7.15799117e-03f, -1.29343674e-01f, 1.53056249e-01f, 5.47494926e-02f, -1.36607006e-01f, 1.32655120e-02f, -2.38171920e-01f, -6.86866194e-02f,
  -1.83738291e-01f, -4.46053371e-02f, 5.73330298e-02f, 1.17840275e-01f, 8.19346309e-02f, -5.61324544e-02f, 8.76584649e-03f, -4.96684201e-02f, 8.37704316e-02f, 1.05310716e-02f,
  -1.64635088e-02f, 1.92817207e-02f, 5.22234552e-02f, 2.31291540e-02f, -2.16454100e-02f, -6.39260784e-02f, -5.10629229e-02f, -1.55230969e-01f, -9.08774808e-02f, 6.78080916e-02f,
  1.66050002e-01f, -7.50290155e-02f, -2.48303980e-01f, -1.31834596e-01f, -1.80092990e-01f, -1.00280754e-01f, -1.01759978e-01f, -9.82031375e-02f, -2.57950068e-01f, -2.02360362e-01f,
  -4.61058132e-02f, 4.68187593e-03f, 3.84280384e-02f, -6.58093346e-03f, 3.80599275e-02f, 2.46596610e-04f, -8.03037360e-03f, 3.92750464e-03f, 2.63454206e-02f, -5.50237708e-02f,
  3.29245664e-02f, 8.23540799e-03f, 8.45102686e-03f, 3.82804312e-02f, 7.11423308e-02f, -6.85200170e-02f, 8.86124093e-03f, 3.49749811e-02f, -2.10236814e-02f, 2.52939947e-02f,
  3.80274765e-02f, -4.35329191e-02f, 1.17115900e-02f, 2.71915868e-02f, -9.69570801e-02f, -3.96910496e-02f, -8.52289982e-03f, 4.65863459e-02f, 6.38536885e-02f, 3.03104054e-02f,
  3.25306684e-01f, -1.60192162e-01f, 5.82830645e-02f, -3.65373604e-02f, 1.25774303e-02f, -8.08647834e-03f, 7.45286345e-02f, -1.58943161e-02f, 7.28872642e-02f, -5.45448996e-02f,
  4.34288010e-02f, -1.08188197e-01f, -6.04615994e-02f, -4.67717238e-02f, 1.33905672e-02f, 4.27067392e-02f, 6.37589917e-02f, -1.24627324e-02f, 3.46782133e-02f, 5.27174473e-02f,
  4.65350673e-02f, -2.40352266e-02f, -3.21995281e-02f, -5.37327453e-02f, 1.53063191e-02f, -1.82403298e-03f, -5.37759811e-02f, 1.20385801e-02f, -1.68806717e-01f, -8.64590779e-02f,
  4.23495680e-01f, -2.77666658e-01f, -9.73619148e-02f, 1.73466802e-01f, 3.85144376e-04f, -1.93803519e-01f, -4.05212015e-01f, -1.10710077e-01f, 1.04281493e-01f, 9.38807521e-03f,
  1.07999146e-01f, 1.36919543e-01f, 1.38731360e-01f, 4.42425720e-03f, -7.90298432e-02f, -2.66086221e-01f, -2.19614223e-01f, 9.53331310e-03f, 1.69437483e-01f, 1.52817518e-01f,
  3.49545367e-02f, 9.92464796e-02f, 4.73846458e-02f, 3.80469188e-02f, 1.28264785e-01f, 1.93832964e-01f, -1.50143132e-01f, 6.33790717e-02f, -8.73187035e-02f, 7.08340295e-03f,
  3.30266356e-01f, -6.01553284e-02f, 6.87368661e-02f, 1.31945461e-01f, 7.29352683e-02f, 4.92454283e-02f, 6.60203472e-02f, 3.19947004e-02f, -2.37699747e-02f, -1.86123271e-02f,
  1.23993143e-01f, 5.84141538e-02f, -2.50144247e-02f, 3.13128047e-02f, 1.73055083e-02f, 7.34453574e-02f, -1.29379436e-01f, -1.27985459e-02f, -6.42554015e-02f, -6.08545020e-02f,
  -1.26017585e-01f, -4.10532877e-02f, -2.76466422e-02f, -2.00655386e-01f, -8.16470906e-02f, 5.05960621e-02f, -4.66139615e-02f, -5.78834377e-02f, -4.51719910e-02f, 3.37005481e-02f,
  2.39442308e-02f, 8.85505453e-02f, 3.33393598e-03f, -2.55930033e-02f, 3.16392481e-02f, 5.02093211e-02f, -2.92863473e-02f, 7.94136450e-02f, -4.94934060e-03f, 6.30735904e-02f,
  -1.06049456e-01f, 6.30743504e-02f, -9.52931680e-03f, 1.26987383e-01f, 5.18054366e-02f, -1.63864307e-02f, 3.83681757e-03f, -5.06736971e-02f, -3.02752145e-02f, -2.53454484e-02f,
  -5.16788177e-02f, -2.30661668e-02f, 1.17723206e-02f, -2.18435675e-02f, -4.77725640e-02f, -5.81722967e-02f, 7.09113851e-02f, 2.41403840e-02f, 7.88144767e-02f, 1.88957769e-02f,
  2.65371770e-01f, -3.26884300e-01f, 1.78525269e-01f, -7.95977097e-03f, -4.65512872e-02f, -3.51003284e-04f, 8.59041791e-03f, -4.26156931e-02f, 8.43059048e-02f, 2.97672339e-02f,
  1.73465796e-02f, 9.76746008e-02f, -8.62795413e-02f, -9.32243913e-02f, 1.13772228e-01f, 3.63037214e-02f, -3.84792686e-02f, 7.03970939e-02f, -1.51552232e-02f, -2.28867009e-02f,
  -1.02395810e-01f, 1.00614578e-01f, 1.66759938e-01f, 5.93617409e-02f, -2.92427763e-02f, 1.38192058e-01f, 4.46279608e-02f, 1.52069420e-01f, 1.04971416e-01f, 1.90706551e-01f,
  -1.18926302e-01f, -5.13959415e-02f, 4.83648360e-01f, -3.31877708e-01f, 7.58878067e-02f, 3.88377637e-01f, 3.27299923e-01f, 1.81409568e-02f, -2.39283502e-01f, -1.01192780e-01f,
  1.48491142e-02f, -8.17029402e-02f, 6.08821064e-02f, 8.46848264e-02f, 2.54615307e-01f, 1.71823874e-01f, 1.13491878e-01f, 1.49570972e-01f, 3.76276135e-01f, 3.29669863e-02f,
  -8.51990283e-02f, -2.22971663e-01f, -8.97179395e-02f, -7.17137754e-02f, -2.52331406e-01f, -1.75010264e-01f, -1.06297925e-01f, -1.45479769e-01f, 2.02195137e-04f, -3.15038562e-01f,
  1.21495463e-01f, -1.40198425e-03f, 1.04650401e-01f, -1.25121385e-01f, 2.89988145e-02f, 3.01030353e-02f, 1.06953979e-01f, 2.48125680e-02f, 1.61602274e-02f, -1.64209548e-02f,
  -8.65393430e-02f, -1.05908640e-01f, 3.06819919e-02f, -1.34892374e-01f, -4.01881523e-02f, 7.70862307e-03f, -8.73444825e-02f, 1.32189821e-02f, 9.86935049e-02f, -1.01138847e-02f,
  -3.74976955e-02f, 3.92420962e-02f, 2.74808854e-01f, 7.55158812e-02f, 1.04961507e-01f, 2.69170161e-02f, 8.47581401e-02f, 4.82888781e-02f, 1.49487570e-01f, -2.05415055e-01f,
  -4.07258049e-02f, 7.92064220e-02f, -4.43320088e-02f, -2.61289179e-02f, -3.54872905e-02f, -4.16004658e-02f, 7.19846273e-03f, -3.28571647e-02f, -5.84580228e-02f, -8.19995105e-02f,
  -5.31007652e-04f, 2.96797557e-03f, 2.87487283e-02f, -9.62994155e-03f, -2.58347541e-02f, -1.07954275e-02f, 1.86623484e-02f, 3.14801931e-02f, -2.45667957e-02f, -7.93401003e-02f,
  -1.78471785e-02f, 4.01157886e-02f, -4.35199104e-02f, -5.73916584e-02f, -4.35372768e-03f, -7.25460006e-03f, 4.14009579e-02f, -4.86217588e-02f, 9.86057892e-03f, 5.28230555e-02f,
  -2.04593211e-01f, 3.39939952e-01f, -1.41070530e-01f, 8.39719176e-02f, -4.43829894e-02f, -1.07596070e-01f, -4.46191318e-02f, 4.60891500e-02f, -8.01596493e-02f, 4.00048681e-02f,
  1.28994554e-01f, 1.11284025e-01f, -1.76326800e-02f, -6.30652532e-02f, 4.82064113e-02f, -1.72542185e-02f, -7.41924793e-02f, 6.27813255e-03f, 3.58580165e-02f, -6.10342100e-02f,
  -8.30313265e-02f, 8.02867711e-02f, 1.30952895e-01f, 6.50373176e-02f, -9.93075781e-03f, 1.48042351e-01f, 8.86233598e-02f, 9.08441022e-02f, 2.30986118e-01f, -1.33614123e-01f,
  -8.09381366e-01f, -4.21660632e-01f, -1.47311136e-01f, -1.81014925e-01f, 1.23387374e-01f, 1.95322990e-01f, 1.13305748e-01f, -1.94775127e-02f, -4.02978668e-03f, -1.64300635e-01f,
  -1.64490603e-02f, 1.55832946e-01f, 7.32557848e-02f, 9.70963091e-02f, 4.13577557e-02f, -6.02801964e-02f, -4.42744605e-02f, 4.59527746e-02f, 3.18407446e-01f, 2.93883413e-01f,
  2.40049407e-01f, -1.16277829e-01f, -1.55594856e-01f, 2.22546645e-02f, 2.31601112e-02f, 1.76791936e-01f, -1.42072976e-01f, -1.35969058e-01f, 3.62636261e-02f, -2.68794466e-02f,
  -1.50044886e-02f, -4.47319776e-01f, 2.97258317e-01f, -6.11105599e-02f, -1.81389861e-02f, -5.29120415e-02f, 3.96755859e-02f, -1.26451343e-01f, -5.58626130e-02f, -3.34503762e-02f,
  9.92000569e-03f, -4.22515832e-02f, 4.41873074e-02f, 8.72000456e-02f, -6.61369190e-02f, 2.22218595e-02f, -8.51699486e-02f, -8.07196051e-02f, 4.79199132e-03f, -3.53749171e-02f,
  5.26420623e-02f, 5.37641207e-03f, -1.57831728e-01f, -7.78651331e-03f, 3.85983326e-02f, 6.44972473e-02f, -4.61904481e-02f, -5.14654908e-03f, -2.83080735e-03f, -1.38226554e-01f,
  8.69484246e-02f, -2.05550455e-02f, 2.64933053e-02f, -1.40689276e-02f, 2.45649517e-02f, -2.37200363e-03f, 3.41556855e-02f, 5.01247607e-02f, 4.33402546e-02f, 1.27803981e-02f,
  -5.92811778e-03f, 1.60519332e-02f, 6.70419708e-02f, -5.89232408e-02f, 4.67781574e-02f, -2.31315028e-02f, -2.56589577e-02f, 3.63434455e-03f, -1.86987277e-02f, -1.03549361e-01f,
  5.10803936e-03f, 4.98759793e-03f, -2.19255500e-02f, 1.84838437e-02f, -1.02178762e-02f, -4.28600572e-02f, -1.76426955e-02f, 6.07740954e-02f, -5.80940172e-02f, -2.95555461e-02f,
  -1.19620841e-02f, 5.43429554e-02f, -1.14141256e-01f, 6.40817359e-02f, -3.80552150e-02f, -6.85646832e-02f, -1.85341258e-02f, 3.64947952e-02f, -4.94039431e-03f, -5.32370433e-03f,
  5.25842458e-02f, 2.07359754e-02f, -1.00018404e-01f, 1.23594487e-02f, 8.31411779e-02f, 2.38181222e-02f, -4.77960557e-02f, 7.71981850e-02f, 6.08307607e-02f, -2.65584420e-02f,
  -1.82772577e-02f, -2.33193338e-02f, 6.48326054e-02f, 6.91130161e-02f, 3.68004330e-02f, 7.01864064e-02f, 1.48057058e-01f, 4.45564874e-02f, 8.15523416e-02f, -7.62304738e-02f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -4.18010443e-01f, 2.37693503e-01f, -2.52866209e-01f, -1.88401371e-01f, -2.61712121e-03f, 9.27760303e-02f, 2.83012480e-01f, 2.12342799e-01f, 5.26446030e-02f, 1.15026437e-01f,
  8.21750332e-03f, -7.05194026e-02f, -9.97001007e-02f, 2.85379235e-02f, 1.53719708e-01f, 2.50285357e-01f, 5.87656237e-02f, -3.25513929e-02f, -1.14214569e-01f, 8.91787931e-02f,
  8.04595873e-02f, -6.12587668e-02f, -2.39832804e-01f, -1.37253121e-01f, 1.51640167e-02f, -1.05796285e-01f, -6.68141991e-02f, -4.65563163e-02f, -2.15652194e-02f, -8.89949501e-03f,
  -2.68335283e-01f, -3.57572228e-01f, 3.79262306e-03f, -3.42876501e-02f, -1.92119405e-01f, -1.63102169e-02f, -8.01867098e-02f, -1.33815110e-01f, -4.72366922e-02f, -6.89378083e-02f,
  -1.26573786e-01f, -1.12835467e-02f, -1.75658852e-01f, 2.81512644e-02f, -1.35928076e-02f, 3.46169844e-02f, 1.03487736e-02f, -2.96037868e-02f, -8.64328369e-02f, -9.08423439e-02f,
  6.36616945e-02f, -9.31418836e-02f, -2.50630051e-01f, 9.38080892e-04f, -8.53462145e-02f, -1.36721119e-01f, -1.51264563e-01f, -9.85258892e-02f, -8.95230994e-02f, 5.46863861e-03f,
  1.57001182e-01f, -1.87076982e-02f, -1.23847062e-02f, 8.42218995e-02f, 6.08043373e-02f, -9.46613103e-02f, 2.88611371e-03f, -1.79888494e-02f, -1.34906862e-02f, -3.64955440e-02f,
  -1.23359002e-01f, -4.54090424e-02f, 3.80794965e-02f, -4.70280573e-02f, 1.50797870e-02f, -5.86436316e-02f, 4.55442145e-02f, 8.14524144e-02f, -1.23010448e-03f, 4.98579852e-02f,
  -1.75781213e-02f, -2.15228624e-03f, -4.26575765e-02f, -4.52897139e-02f, 9.17039216e-02f, -7.36511052e-02f, 5.96637726e-02f, -3.65834171e-03f, 3.96196395e-02f, -7.46617094e-02f,
  -1.60898082e-03f, -8.93357769e-02f, 2.31621396e-02f, 1.71948932e-02f, -9.12192464e-02f, -4.56918217e-02f, -5.80275021e-02f, -8.73667151e-02f, -2.47365963e-02f, -6.42463658e-03f,
  1.66051239e-02f, -1.19436616e-02f, -3.81696671e-02f, 2.43433230e-02f, -7.85654709e-02f, 8.18068609e-02f, 1.36121869e-01f, -1.06701858e-01f, 5.83183281e-02f, 5.73784187e-02f,
  1.15519032e-01f, 1.17797218e-01f, -8.06022342e-03f, 7.16952980e-02f, -4.07932550e-02f, -6.16532974e-02f, 6.80935457e-02f, 9.92278755e-02f, 6.67487979e-02f, 3.12452137e-01f,
  2.27867365e-01f, 4.22550291e-02f, 1.65940285e-01f, 7.81014422e-03f, -4.27011907e-01f, -4.65489060e-01f, -3.88159066e-01f, -6.43154904e-02f, -3.75592448e-02f, -1.39412746e-01f,
  -1.87202841e-01f, -6.53858632e-02f, 3.94826606e-02f, 2.11087406e-01f, 1.71155706e-01f, 1.31195918e-01f, 2.37015381e-01f, 4.78716344e-01f, 3.42459679e-01f, 1.01152591e-01f,
  7.35952556e-02f, 1.63438395e-01f, 3.30260843e-01f, 2.80294508e-01f, 1.86615169e-01f, 5.99404462e-02f, 2.19689459e-02f, 4.68632504e-02f, -1.49959391e-02f, 3.77493471e-01f,
  8.52686912e-02f, 5.28356954e-02f, 1.05600967e-03f, -2.40852335e-03f, -8.03488791e-02f, 1.35953724e-01f, -3.09283864e-02f, -5.94467204e-03f, 7.97699299e-03f, 1.02338493e-02f,
  -8.74350220e-02f, 4.44077328e-02f, -1.16484873e-01f, -3.60744223e-02f, -6.15626611e-02f, -6.78083152e-02f, 5.58282137e-02f, 2.50763416e-01f, 6.56429231e-02f, 3.27111296e-02f,
  -4.38442007e-02f, -1.59694120e-01f, -1.94310471e-01f, -4.50936053e-03f, 3.54650505e-02f, -4.72172089e-02f, -1.01318002e-01f, 4.73709255e-02f, 2.08720677e-02f, 4.63709496e-02f,
  3.01619228e-02f, 1.79052036e-02f, -8.01594034e-02f, -1.43375769e-02f, 2.24059466e-02f, -3.24420631e-02f, -3.78199853e-02f, 1.81053753e-03f, 3.24862031e-03f, -1.07580453e-01f,
  -5.09221340e-04f, 2.40232181e-02f, 1.65008046e-02f, -1.19579036e-03f, 5.75403683e-02f, -3.51283774e-02f, -5.57521619e-02f, -9.92653519e-03f, 1.76011154e-03f, -3.79629508e-02f,
  5.98068275e-02f, -3.88673767e-02f, -6.02100324e-03f, -2.46211551e-02f, -2.02428200e-03f, 7.92445689e-02f, 2.64442433e-02f, -9.92408693e-02f, 1.71991866e-02f, -2.46012863e-02f,
  -4.37039919e-02f, -8.57670009e-02f, 1.22702539e-01f, 7.51150250e-02f, -3.85665111e-02f, 4.73317616e-02f, -2.55853590e-02f, 8.24207664e-02f, -7.92824626e-02f, 1.23202801e-01f,
  -2.12334059e-02f, 7.72668933e-03f, -3.95571627e-02f, 7.56366998e-02f, 3.06167789e-02f, -6.73598945e-02f, -8.27650502e-02f, 1.20191783e-01f, 1.20105788e-01f, 6.50235787e-02f,
  2.08109636e-02f, -1.04399279e-01f, -1.44402221e-01f, -1.31493926e-01f, 5.24286181e-03f, -1.00792252e-01f, -8.39152709e-02f, -1.16108313e-01f, -3.56748141e-02f, -1.49729759e-01f,
  2.48494912e-02f, 7.79761150e-02f, 4.25979793e-02f, 4.75766417e-03f, -2.71552056e-02f, -2.21934080e-01f, -2.16643602e-01f, -5.52754551e-02f, 1.64313912e-02f, 1.18595036e-02f,
  6.10854104e-02f, 1.05499541e-02f, 8.63330066e-02f, -8.35272744e-02f, -9.69974995e-02f, -1.18381314e-01f, -9.54449326e-02f, 2.40487768e-03f, -1.00236759e-01f, -1.53849229e-01f,
  -4.19789031e-02f, 1.10462315e-01f, -3.78669007e-03f, 2.69525386e-02f, -2.01948583e-02f, 3.14852744e-02f, 6.03887774e-02f, -6.31457195e-02f, -2.40494329e-02f, -1.77732538e-02f,
  -1.08903632e-01f, -1.76675066e-01f, 2.71692052e-02f, 8.75537246e-02f, 6.57164082e-02f, 1.63540815e-03f, 2.48972625e-02f, -4.51477244e-02f, 7.12073669e-02f, -1.05546135e-03f,
  -2.77457871e-02f, -6.13961592e-02f, 8.25469382e-03f, -6.14790134e-02f, 7.37815816e-03f, -4.39177714e-02f, 5.34977391e-03f, -2.19592685e-03f, 3.18709537e-02f, -4.92398851e-02f,
  -1.17256999e-01f, -1.22629143e-02f, -6.02342188e-02f, -1.00386478e-01f, -9.30397362e-02f, 3.20315622e-02f, 3.85955200e-02f, -4.71051037e-02f, -8.47170353e-02f, 9.36060548e-02f,
  -1.27648190e-01f, 8.52154866e-02f, -3.51599120e-02f, -2.89926305e-02f, 2.95975450e-02f, -2.30783410e-02f, 1.05347857e-02f, 4.10842560e-02f, 1.02090780e-02f, 5.53978197e-02f,
  -3.02851014e-02f, -8.61232355e-02f, -7.07777275e-04f, 2.01688111e-02f, 2.07926948e-02f, -6.77773282e-02f, -9.92995873e-02f, -4.98548299e-02f, -7.22243115e-02f, -8.23330730e-02f,
  1.21241640e-02f, -5.19351400e-02f, 9.99014229e-02f, 4.64599691e-02f, 1.21674743e-02f, -2.87751593e-02f, -1.00140087e-01f, -8.43357593e-02f, -2.83123702e-02f, -9.22749043e-02f,
  1.95413709e-01f, -9.99231786e-02f, -4.76463744e-03f, 7.97349308e-03f, -8.48730281e-02f, 4.02250178e-02f, 5.19973645e-03f, -2.61386065e-03f, 5.30642234e-02f, -4.60111424e-02f,
  -5.14661409e-02f, 1.65376682e-02f, 4.23042290e-02f, -2.00577616e-03f, -9.85350227e-04f, -9.85985100e-02f, 1.28441349e-01f, -5.82123026e-02f, -6.16226159e-02f, 2.73861140e-02f,
  1.12368032e-01f, -1.25365909e-02f, 3.52751240e-02f, 1.35543779e-01f, 5.19760139e-02f, -7.27626905e-02f, -1.45128882e-03f, 7.30483606e-02f, 4.29006331e-02f, 1.36937201e-01f,
  -2.06305981e-01f, 1.25917971e-01f, -3.85420285e-02f, -1.79923117e-01f, 5.94379455e-02f, 1.24542899e-01f, 1.22946158e-01f, 2.02581380e-02f, -4.43967283e-02f, 5.34422286e-02f,
  1.14648985e-02f, -1.49901986e-01f, -1.92089364e-01f, -5.87463304e-02f, -1.25886261e-01f, -1.26330629e-01f, -1.40416563e-01f, -3.41954440e-01f, -2.26218417e-01f, -1.70081973e-01f,
  -2.20010146e-01f, -2.37771764e-01f, -3.94957483e-01f, -1.68602690e-01f, -1.29468754e-01f, -1.81056753e-01f, -6.22494612e-03f, -4.26903665e-02f, -3.20786797e-02f, -4.87995036e-02f,
  4.93501052e-02f, 1.14164911e-01f, -2.43950840e-02f, -1.99454531e-01f, -6.28375784e-02f, -3.83156277e-02f, 2.34642124e-04f, 5.57943247e-02f, 8.37700740e-02f, -6.85758516e-02f,
  -7.51324173e-04f, 4.44492958e-02f, -3.07210325e-03f, 6.93505332e-02f, -8.11065733e-03f, -6.77679330e-02f, -1.14096403e-01f, -7.06574395e-02f, -4.29995917e-02f, 1.34056404e-01f,
  -1.62779856e-02f, -9.30933934e-03f, -5.63434213e-02f, 3.01020313e-02f, 7.96278641e-02f, -1.67486429e-01f, 1.77681986e-02f, -4.42248434e-02f, -7.01870620e-02f, -1.41268764e-02f,
  -4.41723540e-02f, 8.76995474e-02f, 7.03016520e-02f, -1.00387149e-02f, -4.16604392e-02f, 1.24477698e-02f, 6.07229322e-02f, -8.21632221e-02f, 1.63609758e-02f, 2.70992611e-02f,
  -5.89115620e-02f, 1.28433421e-01f, -6.49015680e-02f, 3.79615352e-02f, 2.21974943e-02f, -3.65872728e-03f, -7.02691497e-03f, -2.87999120e-02f, 3.81937772e-02f, -8.27742815e-02f,
  -3.49374712e-02f, 9.12668630e-02f, -5.84882759e-02f, -2.72067133e-02f, -5.51502816e-02f, -6.46993285e-03f, 8.66724029e-02f, 1.24631273e-02f, -1.66367628e-02f, -3.77633013e-02f,
  -8.83190110e-02f, -7.95316976e-03f, -1.54884364e-02f, -6.41265884e-02f, 6.32391199e-02f, -8.30242708e-02f, 7.19441026e-02f, 4.82991636e-02f, -6.83498532e-02f, -4.16671485e-02f,
  2.98545603e-02f, -6.50755316e-02f, 2.26252731e-02f, -9.30100158e-02f, -1.35752991e-01f, -7.69885033e-02f, -3.07416916e-02f, -1.33776873e-01f, -1.16231106e-01f, -1.49222859e-03f,
  -3.33198719e-02f, -1.14011817e-01f, -2.96699166e-01f, -3.65955979e-02f, -7.51209930e-02f, -1.19334206e-01f, -1.85438946e-01f, -6.25647083e-02f, -6.55191839e-02f, -1.95921585e-01f,
  -4.20926511e-01f, 7.71235377e-02f, 1.57453343e-01f, -2.62958109e-01f, -9.51097682e-02f, -1.33695453e-01f, -1.27880156e-01f, -2.57012546e-01f, -1.30007967e-01f, -5.79383895e-02f,
  2.05782935e-01f, 2.94103950e-01f, 3.04874629e-01f, 3.35147053e-01f, 2.21845716e-01f, 3.38596813e-02f, -7.84070715e-02f, 1.05592519e-01f, 6.00980483e-02f, -3.31922024e-02f,
  -2.84901541e-02f, -1.59383819e-01f, -1.37182429e-01f, -1.02119409e-01f, -7.51845613e-02f, 1.28421918e-01f, 5.07179387e-02f, -2.80568395e-02f, 6.12346418e-02f, 7.64880776e-02f,
  5.07495344e-01f, -1.45133674e-01f, 1.05625711e-01f, -4.57638428e-02f, 3.93344760e-02f, -8.41289386e-02f, -5.28644659e-02f, -7.29806498e-02f, -1.14246020e-02f, -5.32794558e-02f,
  6.28159493e-02f, -6.92751557e-02f, 5.42692281e-02f, -8.86621177e-02f, -1.03900120e-01f, -1.21670403e-01f, -4.85315658e-02f, -1.01453876e-02f, 5.99040687e-02f, 7.45504722e-02f,
  7.66253173e-02f, 4.64189872e-02f, 1.19130321e-01f, 4.37162668e-02f, 9.03465077e-02f, 1.51660681e-01f, 4.75249402e-02f, 8.74024909e-03f, 1.20367147e-01f, -4.91514243e-02f,
  -1.67537555e-02f, 1.40034139e-01f, 6.43338710e-02f, 1.10715088e-02f, 1.07358597e-01f, 3.91020253e-03f, -5.53158903e-03f, 5.26385941e-02f, -3.57187763e-02f, -3.23751718e-02f,
  1.92226004e-02f, 2.92234942e-02f, -3.14744823e-02f, 1.29228141e-02f, 1.01079129e-01f, 2.55744737e-02f, 8.04325938e-02f, -7.26083247e-03f, -2.14224402e-02f, 3.47255990e-02f,
  -2.61191092e-02f, 3.81086022e-02f, -3.20630521e-02f, -2.94961277e-02f, -4.62447554e-02f, 3.45829427e-02f, -2.32374966e-02f, 4.94639389e-02f, 2.48358231e-02f, -6.78291097e-02f,
  9.20258015e-02f, 1.61030650e-01f, 5.55660874e-02f, -6.88522384e-02f, -1.18510738e-01f, -5.69018498e-02f, 3.11250146e-02f, -7.77971148e-02f, -5.76183274e-02f, -8.30939114e-02f,
  -5.92165301e-03f, -1.74016910e-04f, -1.51330950e-02f, -3.97832878e-02f, -9.48468521e-02f, -7.58534968e-02f, -8.23695287e-02f, -1.68812238e-02f, -1.32069414e-04f, -1.25529710e-02f,
  -1.56373709e-01f, -5.51111028e-02f, 1.31002784e-01f, 5.93166910e-02f, 6.27448410e-02f, 1.24397993e-01f, 1.83301717e-01f, 1.69929210e-02f, 7.37630054e-02f, -4.34702188e-02f,
  2.73641109e-01f, -6.01880951e-04f, -5.18864572e-01f, -1.27384484e-01f, -1.61879197e-01f, -2.05099046e-01f, 2.15638950e-02f, 5.64373434e-02f, 2.12519951e-02f, -9.12470892e-02f,
  -1.07311450e-01f, -7.74445161e-02f, -2.90314411e-03f, 5.13306409e-02f, 1.89697035e-02f, -6.94607943e-02f, -1.39421716e-01f, -1.14436686e-01f, -1.47778526e-01f, -8.65333229e-02f,
  -1.26437489e-02f, -5.54055050e-02f, -3.10024712e-02f, -1.89242158e-02f, -1.78148419e-01f, -1.59515545e-01f, -1.87870562e-01f, -9.37015042e-02f, -1.27974406e-01f, -1.79827437e-01f,
  -4.24008697e-01f, -6.39810935e-02f, -4.34572399e-02f, 1.99437305e-01f, -5.85369542e-02f, 3.68981548e-02f, -1.38785047e-02f, -5.78506589e-02f, -1.26851927e-02f, 3.09913866e-02f,
  -5.82002029e-02f, 7.80132860e-02f, -5.25412746e-02f, -8.05069432e-02f, -1.03644848e-01f, 9.75256844e-04f, 2.31410135e-02f, -4.16293181e-02f, -1.97579134e-02f, -4.02519070e-02f,
  5.03709577e-02f, -1.62693206e-02f, -2.81053333e-04f, -6.10424764e-03f, -1.32029220e-01f, -1.30454838e-01f, -7.10129142e-02f, -1.57296970e-01f, -2.23853178e-02f, 6.40570074e-02f,
  2.72171255e-02f, -5.26948087e-02f, -1.74011849e-02f, 1.45218568e-02f, 1.26134560e-01f, 5.47973090e-04f, 5.72731495e-02f, 9.01412442e-02f, -1.38162309e-02f, 6.21576272e-02f,
  -7.39489635e-03f, -9.89575032e-03f, 3.40328296e-03f, 7.00666457e-02f, -4.91369627e-02f, 8.34535509e-02f, 1.23056173e-02f, 1.43471196e-01f, -3.39590870e-02f, -2.05123145e-02f,
  4.74996045e-02f, -2.20957422e-03f, 4.55494933e-02f, 3.07383258e-02f, -7.93969333e-02f, -4.14779745e-02f, 1.81100667e-02f, 3.73342335e-02f, 4.71640052e-03f, -4.38669585e-02f,
  -5.31522110e-02f, 2.43244208e-02f, -1.49723496e-02f, 7.76126012e-02f, -6.25623614e-02f, -5.50873578e-02f, 1.86816361e-02f, -3.91167169e-03f, -7.01300278e-02f, -2.07504351e-02f,
  1.32410396e-02f, 5.10848798e-02f, -8.68555903e-02f, 6.02789149e-02f, 3.45786363e-02f, -3.37668732e-02f, 1.45429313e-01f, -3.43379155e-02f, 4.09205332e-02f, 7.34006986e-02f,
  1.12650812e-01f, 1.69575602e-01f, 4.22084294e-02f, 2.90177353e-02f, -3.44469622e-02f, 4.34013680e-02f, -8.55230391e-02f, -2.39139963e-02f, 5.22281043e-02f, 2.53788352e-01f,
  5.67220867e-01f, 4.87567127e-01f, 1.93548277e-01f, 1.30281657e-01f, 1.43136829e-01f, 1.05632290e-01f, 2.21387193e-01f, -1.25483153e-02f, -1.11161927e-02f, 1.83135107e-01f,
  1.47466987e-01f, 5.57759181e-02f, -5.70884682e-02f, -8.36878642e-03f, -8.45389906e-03f, -3.03036068e-02f, 5.44528663e-02f, 9.44266841e-02f, -1.12347499e-01f, 8.97924528e-02f,
  1.13648832e-01f, 1.51247784e-01f, 5.83113171e-02f, 1.11130193e-01f, 1.17282540e-01f, -5.62820844e-02f, 9.59283933e-02f, 1.15499631e-01f, 2.23179594e-01f, 2.61245012e-01f,
  1.93135917e-01f, 4.92348641e-01f, -2.70553350e-01f, -1.76818043e-01f, 9.19876173e-02f, -9.44389626e-02f, 3.53078432e-02f, -4.79767695e-02f, -1.15589807e-02f, -4.01671827e-02f,
  4.68937680e-02f, 4.76568975e-02f, 1.47531861e-02f, -2.87832096e-02f, -3.24434303e-02f, -9.84375179e-02f, 2.46975757e-02f, -6.82228208e-02f, -1.00771450e-01f, 6.54109637e-04f,
  -4.24950942e-02f, 2.09901318e-01f, 1.24950837e-02f, -7.98887759e-02f, 2.73407064e-02f, -5.93319237e-02f, -3.49955820e-02f, 2.59457994e-02f, 2.18094699e-02f, 9.47035179e-02f,
  1.19817844e-02f, 1.88861210e-02f, 1.07019603e-01f, 2.56235455e-03f, -2.82203425e-02f, 3.17865126e-02f, -7.22384602e-02f, 5.88834379e-03f, 3.60608585e-02f, 3.48845050e-02f,
  -2.74880659e-02f, 4.10083681e-03f, -7.66452448e-03f, -6.16174266e-02f, -2.94340141e-02f, -1.14897313e-02f, -3.47543731e-02f, 2.19544210e-03f, -5.98520525e-02f, -4.93345894e-02f,
  1.05738737e-01f, -3.83406617e-02f, 3.78873385e-02f, 1.49814354e-03f, -6.07986413e-02f, 5.67225739e-02f, -8.70116577e-02f, 5.37244752e-02f, 9.33644772e-02f, -3.78067680e-02f,
  -3.07477504e-01f, -1.26004651e-01f, -7.27268308e-03f, 1.35860695e-02f, 3.91802900e-02f, 4.25692201e-02f, 7.00718239e-02f, -6.51201094e-03f, 3.58437151e-02f, 3.82586196e-02f,
  7.44669735e-02f, 3.19111869e-02f, -2.93382281e-03f, -7.71306083e-02f, -6.55684322e-02f, -3.98254506e-02f, 1.09954027e-03f, -2.12485921e-02f, -1.18649542e-01f, 3.57184857e-02f,
  -9.98531654e-02f, -1.83719501e-01f, -1.45197600e-01f, -2.60080040e-01f, -9.11366045e-02f, -1.95206702e-01f, -2.73627564e-02f, -1.55101269e-01f, -1.90244123e-01f, -2.50840515e-01f,
  4.57338423e-01f, -1.55404165e-01f, 9.78626609e-02f, 2.65898675e-01f, 5.84014058e-01f, 4.26409304e-01f, 4.31291074e-01f, 3.23351413e-01f, 2.43898705e-01f, 6.30669370e-02f,
  -6.81025162e-02f, -1.51214913e-01f, -7.77915567e-02f, -1.47995427e-01f, -1.54866189e-01f, 1.31417856e-01f, 1.62694409e-01f, 2.88783610e-02f, 8.36907104e-02f, 1.46118894e-01f,
  2.17135865e-02f, 7.39892945e-02f, 8.08973536e-02f, -2.79477276e-02f, -1.08715184e-01f, 6.55652657e-02f, -7.32909441e-02f, 5.89442626e-02f, -9.19176266e-02f, -1.16331540e-01f,
  -5.19588113e-01f, 1.93695072e-02f, 1.02518059e-01f, -1.21378958e-01f, -7.05136955e-02f, -1.43533289e-01f, 2.97940895e-02f, -1.84737697e-01f, 1.72900613e-02f, 3.68750095e-02f,
  -7.30154887e-02f, -1.14688754e-01f, 4.39040698e-02f, -3.82687971e-02f, -1.86540047e-03f, 5.28070703e-02f, -1.00723930e-01f, -5.36618978e-02f, 2.43715160e-02f, -1.51071504e-01f,
  -1.30982503e-01f, 3.67194111e-03f, 2.19251499e-01f, 9.52700600e-02f, -6.20928667e-02f, 8.73856172e-02f, -1.21694185e-01f, -1.47469997e-01f, 7.69073814e-02f, -8.28578025e-02f,
  -4.42513041e-02f, -5.76654449e-02f, 2.40238500e-03f, -2.61914693e-02f, 7.99145401e-02f, 1.90149490e-02f, 2.62766313e-02f, 5.59941418e-02f, 7.15206265e-02f, 3.14661339e-02f,
  -5.25828525e-02f, 3.09227053e-02f, 5.38202077e-02f, -8.57226923e-03f, -2.62570120e-02f, 3.61192003e-02f, -3.88501957e-02f, -1.32909685e-01f, 3.70091549e-03f, 2.59663071e-02f,
  7.01643825e-02f, 1.77583490e-02f, -4.96067815e-02f, -1.08216599e-01f, -1.65197402e-02f, 1.94420815e-02f, -3.42486873e-02f, 2.16478091e-02f, 8.21877867e-02f, 1.03256688e-01f,
  -2.12967824e-02f, 2.18766972e-01f, -7.16652349e-02f, -7.23132491e-02f, 7.71251544e-02f, -2.29167819e-01f, -6.91889673e-02f, -1.12631343e-01f, -1.15470588e-01f, -2.91657746e-02f,
  -1.02105483e-01f, -1.39663175e-01f, -1.18500091e-01f, -5.14427610e-02f, 1.60038173e-01f, -8.07105936e-03f, 1.79378092e-02f, 7.88228214e-02f, -5.55495471e-02f, -1.90148026e-01f,
  -3.88019346e-02f, 3.34900349e-01f, 2.86318421e-01f, 1.25539094e-01f, 6.68306742e-03f, 2.79062897e-01f, 7.16550425e-02f, 1.00428134e-01f, 1.71948910e-01f, 1.92856982e-01f,
  -7.63382196e-01f, 1.22091286e-02f, -1.32558331e-01f, -3.11547681e-03f, 3.33300084e-01f, 2.42914543e-01f, 4.77542132e-02f, -1.25815555e-01f, -2.78821196e-02f, -1.02389781e-02f,
  2.17691958e-01f, 1.37624770e-01f, 1.26012236e-01f, 5.63438945e-02f, -9.67475101e-02f, 6.20229207e-02f, 2.62282848e-01f, -1.06104232e-01f, -6.14164099e-02f, -8.16996545e-02f,
  2.30967626e-01f, -2.33237799e-02f, -2.85879612e-01f, -4.29394795e-03f, 1.01212963e-01f, 1.68904245e-01f, -5.74131794e-02f, 8.07421207e-02f, 2.04775393e-01f, 2.51538515e-01f,
  -7.11960495e-02f, -3.64514261e-01f, 8.13009888e-02f, 1.06237821e-01f, 1.94913253e-01f, -9.86550078e-02f, -5.18872999e-02f, -1.43134296e-01f, -1.55636705e-02f, -1.15834907e-01f,
  8.45044851e-02f, 1.75292641e-02f, 5.61777391e-02f, -4.78492565e-02f, -1.52757823e-01f, -1.40240684e-01f, -1.53181314e-01f, -2.79265434e-01f, -1.49736255e-01f, -2.86608078e-02f,
  3.28116596e-01f, 3.05466745e-02f, -1.11708418e-01f, -1.51489824e-01f, -1.46939948e-01f, -7.45549984e-03f, -2.04543546e-01f, -2.34997720e-01f, -2.37687901e-01f, -3.18926126e-01f,
  4.96419445e-02f, 5.11239022e-02f, 1.30650587e-02f, -1.00018792e-01f, 2.04203203e-02f, 4.52417172e-02f, -1.97626874e-02f, 8.75424519e-02f, 2.03513112e-02f, -2.35096775e-02f,
  3.02412398e-02f, -1.34117333e-02f, -9.38650593e-02f, -7.51555562e-02f, -1.20612448e-02f, 3.93743254e-02f, -1.23773413e-02f, -6.81412639e-03f, 8.29489343e-03f, -1.53347850e-02f,
  -4.98791859e-02f, -1.34053873e-02f, -7.59194344e-02f, 6.61222562e-02f, 4.88681942e-02f, 2.09515207e-02f, -2.17426065e-02f, -1.07775696e-01f, -5.65462522e-02f, -1.40382526e-02f,
  -1.63155600e-01f, 1.70395404e-01f, -2.67623402e-02f, -1.29619911e-01f, 3.73353213e-02f, -5.13405986e-02f, 7.73778334e-02f, 9.79090016e-03f, -4.37494032e-02f, -4.95043397e-03f,
  -8.32193438e-03f, -8.66205618e-02f, 3.76169607e-02f, -9.68943629e-03f, -4.45975969e-03f, -8.39332417e-02f, 7.21719936e-02f, 8.57278556e-02f, -2.36139297e-02f, -9.91454646e-02f,
  1.92891136e-02f, -1.61650196e-01f, -2.86662489e-01f, -9.94414836e-02f, -1.40024349e-01f, -3.23433836e-04f, -1.85961634e-01f, -2.41802260e-01f, -3.07136655e-01f, -3.06234002e-01f,
  -8.57834611e-03f, -9.85582545e-03f, 5.12590110e-02f, 1.53890818e-01f, 2.62530372e-02f, -3.00773054e-01f, -5.46442032e-01f, -3.71707171e-01f, 7.55071789e-02f, 3.96241508e-02f,
  2.54752394e-02f, 1.30599603e-01f, 5.28308600e-02f, -1.76145807e-01f, -3.83635938e-01f, -1.67231873e-01f, 4.01098058e-02f, -1.09677911e-01f, -3.34023029e-01f, -2.98022687e-01f,
  -2.23091077e-02f, 4.40494455e-02f, -2.95260604e-02f, 3.44137624e-02f, 3.29762965e-01f, 3.04897875e-01f, 2.59293199e-01f, 1.84547305e-01f, 1.37197033e-01f, 5.09667456e-01f,
  1.35032296e-01f, -6.51777014e-02f, -1.33174285e-01f, 1.05178766e-01f, 1.51608244e-01f, -1.04270186e-02f, 3.67427990e-02f, 1.06541388e-01f, -3.59244533e-02f, -4.46672887e-02f,
  1.54075563e-01f, -8.40981025e-03f, 5.37924245e-02f, -3.11694909e-02f, -1.22358762e-01f, -1.18850701e-01f, -5.15160058e-03f, -1.07363299e-01f, -3.14616524e-02f, -9.74798203e-03f,
  8.80366564e-02f, 1.13049159e-02f, -2.02572703e-01f, -1.85835287e-01f, -7.46677145e-02f, 1.25476420e-01f, -1.03072643e-01f, -1.57713648e-02f, -6.64996579e-02f, 1.13786785e-02f,
  8.59933496e-02f, 8.61483999e-03f, -5.89314736e-02f, 1.09281866e-02f, -1.11900568e-02f, 1.10153528e-02f, 6.04482926e-02f, -1.79503895e-02f, -8.96028951e-02f, -4.21653921e-03f,
  -1.18091345e-01f, 5.08275740e-02f, 4.02900018e-02f, -5.81290759e-02f, 1.84647217e-02f, -7.69992732e-03f, -1.22656859e-02f, -5.57995550e-02f, -3.34953070e-02f, 1.66487098e-02f,
  7.17704147e-02f, -1.43877454e-02f, 9.02842209e-02f, -4.84977812e-02f, 5.10808192e-02f, -1.04773520e-02f, 1.61836203e-03f, -1.24690700e-02f, 3.72078195e-02f, 3.35081993e-03f,
  2.79905293e-02f, -2.15863511e-01f, 2.87936032e-02f, -1.42634679e-02f, 5.72519377e-02f, 4.64715287e-02f, 6.48747608e-02f, 1.29658375e-02f, 2.00622939e-02f, -4.34420072e-02f,
  2.19742814e-03f, -5.27765863e-02f, 8.74722004e-03f, -4.15505320e-02f, -1.23871908e-01f, -3.67296822e-02f, -9.85055491e-02f, -7.42303804e-02f, -1.65218547e-01f, -2.28942763e-02f,
  1.39243621e-02f, -2.40982443e-01f, -2.18736425e-01f, -9.40188617e-02f, -2.52395179e-02f, -3.67576703e-02f, -1.37394339e-01f, -1.34050757e-01f, -3.20403546e-01f, -2.72431463e-01f,
  -5.41570604e-01f, -3.40044260e-01f, -2.33719245e-01f, -4.93259370e-01f, -5.30513488e-02f, 4.59909812e-02f, 6.79122284e-02f, 4.57133725e-02f, -3.20693925e-02f, -1.09154448e-01f,
  -3.35745439e-02f, -5.88993877e-02f, -2.16040477e-01f, -5.55162467e-02f, -4.29226272e-02f, -1.19670190e-01f, -1.56272277e-01f, -8.51566195e-02f, -7.58587047e-02f, 1.57738011e-02f,
  -1.10880338e-01f, -2.90430307e-01f, -3.27548474e-01f, -1.09120943e-01f, -1.75448135e-01f, -1.05668277e-01f, -3.33494306e-01f, -2.89765924e-01f, -9.70040858e-02f, -2.16845423e-01f,
  -1.61448374e-01f, -2.45603151e-03f, 6.31571412e-02f, 1.68999601e-02f, -1.28705546e-01f, 8.30685943e-02f, 5.95758595e-02f, -6.14107661e-02f, 3.59723866e-02f, -2.86874399e-02f,
  -7.11254105e-02f, 6.17313720e-02f, -1.15844429e-01f, -2.40080450e-02f, -1.25641957e-01f, 6.67654872e-02f, 1.78574976e-02f, -7.35432189e-03f, -3.93166207e-02f, 8.15000236e-02f,
  1.38316736e-01f, 6.46393895e-02f, -1.28558166e-02f, 8.23416933e-02f, 1.13166854e-01f, 9.42597091e-02f, 8.52531269e-02f, 5.63844554e-02f, 8.00204277e-02f, -1.65331870e-01f,
  -3.26805376e-02f, -7.66066927e-03f, 4.30100551e-03f, 3.70736010e-02f, -4.13029157e-02f, 8.54798853e-02f, -6.83328658e-02f, -2.29204465e-02f, -7.32343197e-02f, -4.95279208e-04f,
  1.09769432e-02f, -1.96824353e-02f, -4.41360734e-02f, -6.29157647e-02f, -6.26734346e-02f, 4.52581011e-02f, 1.48256337e-02f, -7.79905776e-03f, -1.87111106e-02f, -2.37595253e-02f,
  2.41220891e-02f, 5.49232475e-02f, -1.13955185e-01f, 5.78202307e-02f, 1.40138566e-01f, -1.67219881e-02f, 8.56388360e-03f, 1.12899527e-01f, 3.67161259e-02f, -2.34561581e-02f,
  -4.10656422e-01f, 2.24566340e-01f, -9.83216465e-02f, 2.28692591e-02f, -1.10738665e-01f, 6.93924306e-03f, -7.94261098e-02f, -3.92448045e-02f, -4.09575701e-02f, 3.81100737e-02f,
  1.22309253e-01f, -1.60319302e-02f, -1.43972859e-01f, 9.76323932e-02f, 2.89915502e-02f, 2.63969935e-02f, -4.51780893e-02f, -1.16131872e-01f, 1.34403437e-01f, 7.37692835e-03f,
  7.34388530e-02f, 2.24519037e-02f, -1.19411990e-01f, 9.14502982e-03f, 1.08795829e-01f, -1.48769864e-03f, -1.77344028e-02f, 8.26927200e-02f, 9.41529963e-03f, -2.96774417e-01f,
  5.07151008e-01f, -3.01887661e-01f, -3.97503048e-01f, 7.21032694e-02f, -2.54276663e-01f, -1.94240525e-01f, -2.60377795e-01f, 3.23601402e-02f, 1.59806281e-01f, -1.77020803e-01f,
  -9.56069455e-02f, 3.38021874e-01f, 2.30950013e-01f, 2.03736365e-01f, 2.17077002e-01f, -6.67019859e-02f, -4.44400907e-02f, 1.75706714e-01f, 2.59612054e-01f, 9.78744477e-02f,
  1.23010781e-02f, 5.13197202e-03f, 2.42332742e-01f, 8.03607702e-02f, -1.73690632e-01f, 1.16539739e-01f, -1.95195809e-01f, -7.92386308e-02f, -1.85739547e-01f, -3.52227837e-01f,
  -4.56034541e-01f, -1.09257877e-01f, 2.72543609e-01f, 2.18815967e-01f, -4.53612432e-02f, 4.59745936e-02f, 3.19591016e-02f, 1.88125186e-02f, 6.73312098e-02f, -9.96934325e-02f,
  -4.17588204e-02f, -1.15239248e-01f, 2.65786070e-02f, -1.00026622e-01f, 3.46161686e-02f, 3.50683741e-02f, 4.60458994e-02f, 1.17535628e-01f, 1.31935164e-01f, -1.53916642e-01f,
  -6.69259503e-02f, -2.33436614e-01f, -1.65732488e-01f, 8.45348164e-02f, 6.03923164e-02f, 2.03284308e-01f, -7.01758042e-02f, 9.61778313e-03f, 8.91894028e-02f, -2.58770753e-02f,
  -3.22873064e-04f, 3.99874561e-02f, 1.56704541e-02f, 6.50792867e-02f, 4.97209318e-02f, 5.38208671e-02f, -4.27233689e-02f, -3.29897436e-03f, 6.59404844e-02f, 1.22109698e-02f,
  2.27238657e-03f, -9.55488067e-03f, -6.77888617e-02f, -3.56743820e-02f, 3.18639725e-03f, -6.17237017e-02f, -8.90965536e-02f, 5.38006537e-02f, 6.55673668e-02f, -2.77386559e-03f,
  9.30782333e-02f, -8.36654007e-03f, -6.60379604e-02f, 1.14153745e-02f, -4.20450047e-03f, -1.98818929e-02f, -2.88108736e-03f, -1.87317990e-02f, 1.70171459e-03f, -7.16785192e-02f,
  4.14065942e-02f, 3.25226694e-01f, 2.84370873e-03f, 1.44755453e-01f, -1.37325510e-01f, -6.47140518e-02f, -2.97402982e-02f, -3.83064500e-03f, -1.10018633e-01f, -1.13523789e-01f,
  -1.91782676e-02f, 5.33404574e-02f, 4.80084345e-02f, 1.57079811e-03f, -1.36532392e-02f, 5.10581322e-02f, -4.22264710e-02f, 7.34644057e-03f, -4.55572531e-02f, -1.91520259e-01f,
  -4.01672982e-02f, -5.44700474e-02f, 4.91517857e-02f, 1.53966635e-01f, 6.39650002e-02f, 2.14202046e-01f, -1.08569540e-01f, -6.03458732e-02f, 6.34723008e-02f, 2.27823723e-02f,
  -3.43609691e-01f, -5.08534074e-01f, 9.11845863e-02f, -4.50347923e-02f, -1.53364912e-01f, -9.05533656e-02f, -2.60166883e-01f, -5.45708500e-02f, -1.04017302e-01f, -2.55105048e-01f,
  -2.02907503e-01f, -1.03616454e-01f, 2.20870413e-02f, 7.39711821e-02f, 3.56389806e-02f, -2.23327532e-01f, -4.02393937e-02f, 2.16357231e-01f, 3.75546008e-01f, 1.17958486e-01f,
  4.37289961e-02f, 1.56987488e-01f, 2.54178435e-01f, 7.29763731e-02f, -7.25142956e-02f, -1.68834515e-02f, -3.47302407e-02f, 3.03417593e-02f, -1.45049974e-01f, -2.71607280e-01f,
  -1.88574389e-01f, -7.55309090e-02f, 1.51484638e-01f, -7.66718686e-02f, 2.71329358e-02f, 3.97186168e-03f, -8.09084550e-02f, 1.17136873e-01f, 4.47784998e-02f, 1.72339920e-02f,
  -5.06596453e-02f, 1.45852230e-02f, -3.63425873e-02f, -5.96948192e-02f, 1.93894766e-02f, -3.52342315e-02f, 1.18791252e-01f, 1.85650498e-01f, 7.67908320e-02f, -5.87655492e-02f,
  -3.86178829e-02f, -1.84539899e-01f, -9.53912511e-02f, -3.53808217e-02f, 4.58819270e-02f, 1.03426367e-01f, -5.51206321e-02f, -5.39963357e-02f, 2.86310911e-02f, -1.07477523e-01f,
  -3.96262407e-02f, -7.43303914e-03f, 2.00521424e-02f, -7.17341676e-02f, 3.26638250e-03f, -2.00290158e-02f, 5.75344749e-02f, -3.78122553e-02f, 9.14538056e-02f, 4.24854346e-02f,
  2.55925907e-03f, 3.21071818e-02f, 1.21538492e-03f, 1.82890464e-02f, -1.29851839e-02f, 1.93380024e-02f, 3.37013751e-02f, -2.65015475e-02f, -4.75796834e-02f, 2.11344417e-02f,
  1.19317584e-02f, 5.08389622e-02f, 5.84153049e-02f, 8.29641446e-02f, -7.89358988e-02f, 3.25579457e-02f, 4.00867462e-02f, 5.60229197e-02f, 1.26699191e-02f, -2.84975953e-02f,
  4.08354327e-02f, 1.45141721e-01f, -1.63289189e-01f, -1.39145339e-02f, -1.41819283e-01f, -8.28830339e-03f, -1.09247796e-01f, -5.32370172e-02f, -9.31073725e-02f, -7.46308342e-02f,
  1.07096629e-02f, 2.16344446e-02f, -5.45099117e-02f, -4.66868505e-02f, -2.13103509e-03f, -7.97266886e-02f, -1.83924749e-01f, -7.27245435e-02f, 2.24862993e-02f, -5.56308255e-02f,
  -6.88580722e-02f, -4.47144471e-02f, -2.22812131e-01f, -5.32806963e-02f, -9.56887677e-02f, -1.64268717e-01f, -8.12364295e-02f, -1.32793859e-01f, -9.94809046e-02f, -1.10038549e-01f,
  -1.86930865e-01f, 2.39044186e-02f, -3.83137077e-01f, -6.00728393e-02f, -1.27403334e-01f, -2.43151948e-01f, -2.13418901e-01f, 3.77001055e-02f, 5.31369448e-02f, -8.07508603e-02f,
  -2.16733236e-02f, 6.48801699e-02f, -2.29289066e-02f, -7.60535747e-02f, -1.41196728e-01f, -2.50017732e-01f, -3.53952050e-01f, -3.36728811e-01f, -1.93027422e-01f, -6.03002198e-02f,
  -1.08427577e-01f, -2.01344833e-01f, -2.44104400e-01f, -2.06113145e-01f, -1.78471990e-02f, -9.20823216e-02f, -1.83589503e-01f, -2.37524316e-01f, -2.72666574e-01f, -2.02789724e-01f,
  9.08274129e-02f, -7.06850663e-02f, -1.36598945e-01f, -1.27979383e-01f, -1.09666148e-02f, -2.15034708e-02f, 2.05861349e-02f, 3.57664935e-03f, -4.51869033e-02f, 7.87508581e-03f,
  -5.82808070e-02f, -4.00962532e-02f, 5.56523120e-03f, 5.25216060e-03f, 3.11267050e-03f, -1.85054485e-02f, 1.34279989e-02f, -1.21223547e-01f, -1.01164363e-01f, -2.05271784e-02f,
  4.36889753e-02f, -2.40522251e-01f, -1.35227457e-01f, 9.38158855e-02f, -5.31064756e-02f, -1.60098225e-01f, 7.35978633e-02f, -8.33418369e-02f, -1.54205680e-01f, 6.63344264e-02f,
  1.54020749e-02f, -7.73040205e-03f, -4.92316522e-02f, -1.59019697e-02f, -1.92806944e-02f, 4.78553120e-03f, -7.70764723e-02f, -7.09119067e-02f, 4.01599742e-02f, 9.17886868e-02f,
  -7.44016981e-03f, -5.09118699e-02f, 6.53075203e-02f, -1.36552118e-02f, 1.48889795e-02f, -1.00577921e-01f, -2.02300251e-02f, 1.88109037e-02f, -8.52841511e-03f, -1.75898373e-02f,
  -3.23626697e-02f, -9.81131867e-02f, -2.62350906e-02f, 1.43014668e-02f, -5.02047269e-03f, -7.94560909e-02f, -3.57198715e-02f, -3.05277426e-02f, 9.84907001e-02f, 2.41894107e-02f,
  5.30306756e-01f, -2.88331270e-01f, 7.55981505e-02f, 6.67735413e-02f, -8.41142386e-02f, 8.72787461e-02f, 1.16037577e-03f, 1.12462898e-04f, -1.72554832e-02f, 8.53151381e-02f,
  -3.54126431e-02f, 1.19435944e-01f, 1.00270629e-01f, 7.83447698e-02f, 4.04606760e-03f, -3.71438041e-02f, -2.30592098e-02f, 4.67547961e-03f, -9.04884785e-02f, 1.27922326e-01f,
  8.41502398e-02f, -9.55583602e-02f, 1.50338590e-01f, 4.82468717e-02f, 6.57333359e-02f, -8.16043168e-02f, 4.92710918e-02f, 1.36588871e-01f, -4.79397513e-02f, 2.02807426e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  3.10288697e-01f, 3.25096399e-01f, 1.84878677e-01f, 1.86332107e-01f, 5.08671045e-01f, 1.35121524e-01f, 3.22824627e-01f, 5.47819734e-01f, 2.51872897e-01f, 2.78796196e-01f,
  1.43829718e-01f, 6.27253652e-01f, 1.10952057e-01f, 3.44316453e-01f
};

// L1_linear_W (Shape: 12 x 32)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 32;
const float L1_linear_W_data[] = {
  -5.68241119e-01f, -2.65596569e-01f, -9.40788165e-02f, -5.55878818e-01f, -6.89749479e-01f, -5.57192683e-01f, 7.46340156e-02f, -9.70425010e-02f, -4.39760864e-01f, 2.27322072e-01f,
  4.40501899e-01f, -4.23429161e-01f, -2.19333857e-01f, 1.84342697e-01f, 5.04529141e-02f, 1.72437176e-01f, -3.12515825e-01f, 4.89691943e-01f, -3.10478043e-02f, 1.78890407e-01f,
  -1.56026274e-01f, 1.79993108e-01f, -2.84380525e-01f, 2.37558201e-01f, -2.16231376e-01f, -1.97046593e-01f, -3.03942919e-01f, -2.70760596e-01f, 6.18553638e-01f, 4.22077984e-01f,
  4.77474689e-01f, 4.42632526e-01f, 1.49818018e-01f, -2.85398096e-01f, -8.11692595e-01f, -5.43193698e-01f, 3.50927770e-01f, 2.19445273e-01f, -1.10383958e-01f, 4.02303599e-02f,
  2.80361533e-01f, -5.96438527e-01f, 4.88860190e-01f, -8.56194317e-01f, 2.30357379e-01f, 3.06771100e-01f, 1.55719072e-01f, 5.45440733e-01f, 4.72350687e-01f, -8.92066509e-02f,
  -3.37510198e-01f, -4.35607992e-02f, -3.51257958e-02f, -1.99294418e-01f, 1.72386706e-01f, 4.16411072e-01f, 4.55248088e-01f, 3.71969044e-01f, -1.31022438e-01f, -5.24091780e-01f,
  2.30609626e-01f, 1.05471885e+00f, -2.84475893e-01f, 6.00920711e-03f, 1.97078496e-01f, 4.03390050e-01f, 1.53298572e-01f, 2.50595540e-01f, -2.46042535e-01f, 2.29306817e-01f,
  3.86345595e-01f, 2.61185378e-01f, 3.40681314e-01f, -4.86017257e-01f, -3.40087533e-01f, 2.89309651e-01f, 4.86286074e-01f, 6.60319746e-01f, -8.57707858e-02f, -3.68845850e-01f,
  8.21100175e-02f, 2.21676245e-01f, -1.76583037e-01f, 5.04664302e-01f, 9.25323889e-02f, -4.07853335e-01f, 2.46706381e-01f, -2.55589515e-01f, -4.97391224e-01f, -4.21128154e-01f,
  1.29567295e-01f, 8.45240876e-02f, -2.22525537e-01f, 4.91090000e-01f, 8.04009676e-01f, -4.94380236e-01f, -1.69190750e-01f, 1.63112372e-01f, -7.03661367e-02f, -5.85942492e-02f,
  4.17182773e-01f, 2.16143772e-01f, -3.48320693e-01f, -6.30605295e-02f, 5.80323897e-02f, -1.58003911e-01f, -1.10771477e-01f, 3.40390444e-01f, 4.21694815e-01f, 6.40644208e-02f,
  5.74095808e-02f, -7.32518017e-01f, 4.86404032e-01f, 5.63034773e-01f, 4.84147877e-01f, -3.05504441e-01f, -4.51285809e-01f, 4.99911398e-01f, 2.59919852e-01f, -3.12234834e-03f,
  -3.82586926e-01f, -2.62827277e-01f, 4.61853176e-01f, -3.12714458e-01f, 9.38171744e-01f, -4.99277264e-01f, -2.57625848e-01f, -2.22315431e-01f, -4.01196539e-01f, 4.82075453e-01f,
  -7.18621314e-02f, -1.67066053e-01f, 3.06795955e-01f, -6.64972067e-01f, 7.41000995e-02f, -2.63394117e-01f, 7.43145123e-02f, -4.04062867e-01f, -3.93198943e-03f, 4.15760279e-01f,
  6.43317103e-01f, 4.87277210e-01f, 2.07100630e-01f, -7.74409845e-02f, -5.42247295e-01f, -4.62306619e-01f, -4.52328950e-01f, -1.42070472e-01f, 1.01597257e-01f, 6.20109737e-01f,
  2.31219262e-01f, -2.54434615e-01f, -1.91585377e-01f, 2.21161544e-01f, -2.57164866e-01f, 7.97768354e-01f, 1.41084626e-01f, -5.53077996e-01f, -9.94827449e-02f, 4.71371353e-01f,
  5.78776658e-01f, 1.52274892e-01f, 3.99024367e-01f, 4.60888386e-01f, 5.72078049e-01f, 3.48870605e-02f, 2.89891046e-02f, 3.72592965e-03f, 2.49046788e-01f, 3.92659148e-03f,
  7.50550091e-01f, -1.96951240e-01f, -3.59643139e-02f, -4.69319403e-01f, 5.55403531e-01f, 1.62648797e-01f, -7.83255041e-01f, -5.08883119e-01f, 4.94998813e-01f, -1.41139984e-01f,
  3.05815578e-01f, -6.82249516e-02f, -5.89447320e-01f, 6.58112466e-01f, -1.05890475e-01f, 4.31107610e-01f, -3.01943153e-01f, -1.45406976e-01f, -3.85826111e-01f, 3.05724859e-01f,
  -3.93572867e-01f, 5.10991871e-01f, 6.45386055e-02f, 1.65890194e-02f, 2.34504119e-02f, -1.97947711e-01f, 8.60987231e-02f, 5.65196611e-02f, 3.19717884e-01f, 9.43117738e-02f,
  -3.76616389e-01f, 5.87247610e-01f, -4.04608250e-01f, 1.11703694e-01f, -5.94067872e-01f, 1.51568592e-01f, -5.65847456e-01f, -1.98774915e-02f, -5.89136720e-01f, -6.98477030e-01f,
  1.08954487e-02f, 9.95050013e-01f, -8.62355828e-02f, -3.39379102e-01f, -3.48278344e-01f, -1.03365056e-01f, 5.28202236e-01f, -6.57878280e-01f, -7.55884826e-01f, 1.40209630e-01f,
  -2.69369930e-01f, -1.24125600e-01f, -1.52284667e-01f, -2.92683899e-01f, -3.84011656e-01f, -6.47837520e-01f, -3.39309722e-01f, -3.46637517e-01f, -1.38344392e-02f, 3.26646343e-02f,
  -4.88062471e-01f, -7.91985318e-02f, -2.16173232e-01f, 4.38878775e-01f, -1.96009010e-01f, 3.98535937e-01f, -3.06335777e-01f, 1.12925984e-01f, 1.39369279e-01f, -4.66586441e-01f,
  -6.80503994e-02f, 4.01191562e-01f, 5.46853781e-01f, -3.82645838e-02f, -2.26354629e-01f, -1.32804319e-01f, 2.57198304e-01f, -2.07421914e-01f, -8.32037777e-02f, 4.20945823e-01f,
  1.05215883e+00f, 1.00510418e-01f, -1.73652798e-01f, 1.27667755e-01f, 3.66856940e-02f, -2.15030536e-01f, 1.50224969e-01f, 3.32528740e-01f, 2.94276118e-01f, 2.76194215e-01f,
  -5.28599203e-01f, -1.70174867e-01f, 1.39850378e-01f, -7.26049244e-02f, 4.15704906e-01f, 5.42804480e-01f, 3.44358385e-01f, -8.77403840e-02f, 9.07181203e-02f, -5.95525146e-01f,
  -7.84159899e-01f, 4.83105063e-01f, 6.81939900e-01f, 2.19203129e-01f, 2.02014185e-02f, -4.71364200e-01f, -8.49534795e-02f, -2.33662724e-01f, -5.03383458e-01f, -1.66618168e-01f,
  -3.93492937e-01f, 1.01471090e+00f, -1.37420937e-01f, -1.43455833e-01f, -1.48432940e-01f, -2.54166834e-02f, -1.68555170e-01f, -4.69327867e-01f, 2.67798007e-01f, 3.69985580e-01f,
  1.53801158e-01f, 2.65657008e-01f, -6.86004758e-03f, 7.68529028e-02f, -7.69462362e-02f, -5.10592878e-01f, 1.93896770e-01f, 3.61339822e-02f, -8.62432495e-02f, -3.24499190e-01f,
  -4.19017851e-01f, 5.25734305e-01f, 7.95636296e-01f, 4.48772848e-01f, -5.27098656e-01f, -1.71849608e-01f, -4.65964913e-01f, 9.90536362e-02f, 1.02680273e-01f, -1.71060041e-01f,
  1.80303544e-01f, 1.49777941e-02f, 3.03714305e-01f, -4.17940646e-01f, 6.05325758e-01f, 9.67059791e-01f, -3.27027619e-01f, -3.70481670e-01f, -4.21345383e-01f, -2.43991897e-01f,
  3.10147107e-01f, -3.17361355e-01f, 3.23662132e-01f, 2.93637216e-01f, -5.62804997e-01f, 3.38111252e-01f, -1.14695556e-01f, 4.56393957e-02f, -2.49701634e-01f, 1.07840769e-01f,
  4.54420358e-01f, -2.33115435e-01f, 1.26906291e-01f, -6.88954353e-01f, 1.02897868e-01f, 4.50759739e-01f, 4.31246817e-01f, 8.61993670e-01f, 1.48470178e-01f, -1.79065719e-01f,
  7.16536865e-02f, 2.31114565e-03f, 8.05375338e-01f, -3.84898514e-01f, -1.42601609e-01f, -4.74349111e-01f, -2.31175303e-01f, -3.86799537e-02f, -2.37605259e-01f, -2.02856749e-01f,
  -6.48249313e-02f, 6.18641317e-01f, 4.50412005e-01f, -3.31281990e-01f, 3.54398459e-01f, -1.60632089e-01f, 4.92958844e-01f, -1.37021348e-01f, -1.31961837e-01f, 9.91749540e-02f,
  -3.79583538e-01f, -3.60866815e-01f, -4.33004349e-01f, 1.18732251e-01f, -5.80146968e-01f, -1.31837770e-01f, -4.90191281e-01f, -5.62016666e-01f, 7.90551782e-01f, -7.30189860e-01f,
  -2.23600090e-01f, -5.44203937e-01f, -1.48835182e-01f, 2.21905723e-01f, 1.78951677e-03f, -1.25806883e-01f, 7.85620391e-01f, 3.58668298e-01f, -1.78213164e-01f, -3.53429377e-01f,
  -2.11251959e-01f, -4.01738644e-01f, -2.38427684e-01f, -3.12957019e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -3.84628698e-02f, -4.31809248e-03f, 9.93156061e-02f, -2.62975451e-02f, 9.92620811e-02f, 1.14487976e-01f, 3.02448813e-02f, -2.13489935e-01f, 2.73256332e-01f, 2.93441508e-02f,
  1.45601511e-01f, 3.41835141e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 9, 14
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        32, 12
    );
    }
    