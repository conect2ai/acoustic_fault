/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 19 x 120)
const int L0_fan_Wp_rows = 19;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -2.10333362e-01f, -3.74936312e-01f, -1.31308883e-01f, -2.77258217e-01f, 1.99501574e-01f, 5.54988198e-02f, 4.23665950e-03f, -2.52552889e-02f, -1.63911074e-01f, -6.10725768e-02f,
  8.38742256e-02f, -1.85146764e-01f, 9.49461013e-02f, -1.40186295e-01f, 1.63451374e-01f, -2.36334335e-02f, -2.09365472e-01f, -9.93802696e-02f, 3.92955467e-02f, -1.28182679e-01f,
  -1.09435640e-01f, -5.31043448e-02f, 6.34006709e-02f, 1.09598428e-01f, -9.87143666e-02f, -1.04596943e-01f, 1.72222078e-01f, 5.57368547e-02f, -1.81122068e-02f, 9.99721810e-02f,
  -1.19304754e-01f, -9.04057622e-02f, -7.58536533e-02f, 1.39106829e-02f, 2.69664172e-02f, 3.72409374e-02f, 6.15915023e-02f, 1.32197589e-01f, 3.50633785e-02f, 3.26234777e-03f,
  -6.46873191e-02f, -9.91455279e-03f, 2.68840529e-02f, 4.14052680e-02f, 6.40886044e-03f, -1.40602645e-02f, -8.68750922e-03f, -4.49868590e-02f, -1.96098182e-02f, -2.58768909e-02f,
  -3.39820161e-02f, 8.94588511e-03f, -8.41020346e-02f, -5.32595115e-03f, 8.49849638e-03f, -3.14633697e-02f, -9.26541258e-03f, 1.78721473e-02f, -2.43500993e-02f, 6.09884150e-02f,
  1.59607321e-01f, 2.21415199e-02f, -4.41235043e-02f, -3.27462815e-02f, 1.04502672e-02f, -5.19400230e-03f, 7.38365529e-03f, 3.82477492e-02f, -2.43027713e-02f, -1.34155173e-02f,
  -3.17380950e-02f, -2.99220346e-02f, -2.88358927e-02f, 3.70653681e-02f, -3.73217389e-02f, -9.84348450e-03f, -4.40715104e-02f, 2.84717120e-02f, -5.82414977e-02f, 3.66438814e-02f,
  -8.92761201e-02f, 2.42289100e-02f, -6.62724897e-02f, 7.60475844e-02f, -1.42561048e-02f, 4.94779237e-02f, -7.79573321e-02f, -4.67154048e-02f, 3.85451466e-02f, 8.47497135e-02f,
  -2.38321394e-01f, -1.73448503e-01f, -2.73111053e-02f, -4.27844897e-02f, -5.42811304e-02f, 8.46588984e-03f, 2.30048634e-02f, -7.22652227e-02f, -9.22177136e-02f, 1.02167986e-02f,
  6.50432184e-02f, 1.56241553e-02f, -4.82290424e-02f, -9.56078060e-03f, 1.27114607e-02f, 1.28484890e-02f, -1.85591786e-03f, -7.26397261e-02f, 2.25039441e-02f, 4.25983220e-02f,
  -1.78574231e-02f, 3.04973759e-02f, 7.60864466e-02f, -3.52623477e-03f, 1.32804569e-02f, 5.32725975e-02f, -3.21873860e-03f, 6.11466961e-03f, 7.06684142e-02f, -8.59569460e-02f,
  -4.64721061e-02f, -1.40981600e-01f, -1.47704214e-01f, -4.51608412e-02f, 1.32254899e-01f, -5.72517775e-02f, -1.07586935e-01f, 4.06780392e-02f, -4.21765856e-02f, -5.49214259e-02f,
  1.18542999e-01f, -2.38787368e-01f, -1.21316016e-02f, 7.61595368e-02f, -5.57604060e-02f, -1.74187332e-01f, 8.00468028e-02f, -1.72217060e-02f, -1.19330704e-01f, 9.64169651e-02f,
  1.92712818e-03f, 2.22052321e-01f, -9.99468863e-02f, 1.60121813e-01f, 1.34577975e-02f, -6.84766471e-02f, 2.07300186e-01f, -5.25291748e-02f, 6.88376874e-02f, 1.82344597e-02f,
  4.40640859e-02f, -4.18128036e-02f, 4.67883572e-02f, -8.66401270e-02f, 6.15773499e-02f, -4.63875942e-02f, -1.35506066e-02f, -1.25254495e-02f, -6.72782138e-02f, 5.22375864e-04f,
  -9.57590746e-05f, 1.35634812e-02f, 2.38738842e-02f, -1.78717151e-02f, 3.50469700e-03f, 4.11414355e-02f, -7.45259272e-03f, -2.53581647e-02f, -8.38815933e-04f, -7.20959157e-02f,
  -3.60414684e-02f, -4.91908230e-02f, -5.58726266e-02f, -6.49268553e-03f, -6.22374080e-02f, -5.92104234e-02f, -7.73524716e-02f, -1.05280941e-02f, 6.14621751e-02f, -7.81871825e-02f,
  8.09515938e-02f, -2.76518669e-02f, 1.12152044e-02f, -1.89605560e-02f, -4.57939766e-02f, 1.04353905e-01f, -6.94443425e-03f, 6.43902123e-02f, 2.29212479e-03f, 1.66842360e-02f,
  2.09269542e-02f, 1.42206382e-02f, 6.25173897e-02f, -4.46382202e-02f, 3.72622460e-02f, -6.31053969e-02f, -2.50994489e-02f, -6.79590032e-02f, 2.72196457e-02f, 2.04591546e-02f,
  4.79030833e-02f, 2.21932493e-02f, -4.01972458e-02f, -9.60426312e-03f, 8.03154521e-03f, -3.43275070e-02f, 3.12092844e-02f, -6.06641285e-02f, 1.29944002e-02f, 6.09276704e-02f,
  -1.24143250e-02f, -6.41714931e-02f, 1.24400705e-02f, 1.12879334e-03f, -3.47966515e-02f, 2.16187593e-02f, -4.56406660e-02f, -7.03404844e-02f, 5.25411330e-02f, -6.66303188e-02f,
  -7.02457875e-02f, 4.21905667e-02f, 1.30597372e-02f, 1.66373271e-02f, 8.75897259e-02f, -4.68747765e-02f, -4.86698598e-02f, 2.14645900e-02f, 5.21657895e-03f, 4.46960256e-02f,
  2.84660677e-03f, 1.34718008e-02f, 7.55323768e-02f, -1.15658948e-02f, 5.06399805e-03f, 2.76796501e-02f, 4.05473262e-02f, -1.59985255e-02f, 4.31919051e-03f, -2.11480316e-02f,
  -4.12240513e-02f, 6.76806420e-02f, -1.68117527e-02f, 4.04608389e-03f, 3.10765691e-02f, -3.01901400e-02f, -2.30573807e-02f, 4.20282632e-02f, 4.38119955e-02f, 2.57968754e-01f,
  1.76923752e-01f, 2.76928768e-02f, -6.58605397e-02f, 1.54880568e-01f, -3.54436308e-01f, -1.49841055e-01f, 4.83241379e-02f, 1.74297094e-02f, -7.70276338e-02f, -8.62674490e-02f,
  -1.74883276e-01f, 1.69116601e-01f, -1.97574779e-01f, -7.79346600e-02f, -2.91790944e-02f, -8.92987475e-02f, 2.58780383e-02f, -3.54243629e-02f, 9.58105177e-02f, -3.70943956e-02f,
  2.28066053e-02f, 1.68709978e-01f, 1.00793317e-01f, 7.47620314e-02f, -1.76505595e-02f, 5.62730059e-02f, -1.68065559e-02f, -6.56819567e-02f, -5.94852604e-02f, -1.04790712e-02f,
  -3.35684083e-02f, -6.45173341e-02f, 2.71361470e-02f, 6.63547441e-02f, -1.20572289e-02f, 5.35691865e-02f, -3.63413617e-02f, 6.99097887e-02f, -2.00634226e-02f, 1.27049703e-02f,
  -4.55378145e-02f, 4.51782271e-02f, -2.14932626e-03f, -3.14827054e-03f, -3.16855758e-02f, 4.51314375e-02f, -7.64357969e-02f, -2.62288023e-02f, 2.45367382e-02f, -2.03945767e-02f,
  -2.00461093e-02f, 1.50485039e-02f, -4.54784790e-03f, 4.81661931e-02f, 2.16612555e-02f, -3.79195027e-02f, 2.28132997e-02f, 2.86437548e-03f, 7.99944624e-03f, 3.94148864e-02f,
  -1.47331622e-03f, 3.68595980e-02f, -2.24078707e-02f, 3.10024824e-02f, -9.30381194e-03f, -3.84932458e-02f, -2.44720634e-02f, -3.00480947e-02f, 1.10435802e-02f, 4.40366082e-02f,
  5.49902804e-02f, -1.64336115e-02f, 4.79668565e-02f, 4.17577885e-02f, 2.56332140e-02f, -1.57690197e-02f, 1.00408755e-01f, -1.68326013e-02f, 1.65148061e-02f, -1.92780793e-02f,
  -6.51071668e-02f, 2.89975703e-02f, -6.07116893e-02f, -2.44114622e-02f, -3.96090113e-02f, 6.38229307e-03f, -3.12692137e-03f, 6.07130677e-02f, -4.17533405e-02f, -3.63846645e-02f,
  -3.73458453e-02f, -1.49483252e-02f, 1.86424851e-02f, -3.98912877e-02f, -1.14619415e-02f, 5.20134941e-02f, -1.35300523e-02f, -3.57766375e-02f, -5.31599633e-02f, -4.93709520e-02f,
  1.61896627e-02f, 1.44389085e-02f, -5.35458140e-02f, -4.24934551e-02f, 7.88925961e-02f, -3.38911675e-02f, -1.59529112e-02f, -3.76538970e-02f, -4.50348742e-02f, 5.21610081e-02f,
  1.96893051e-01f, -9.85418558e-02f, -2.06242532e-01f, 2.91440368e-01f, -9.25849602e-02f, -2.07103752e-02f, 3.78723629e-02f, -7.62516400e-03f, 1.43706992e-01f, 8.69779810e-02f,
  2.39223093e-01f, -1.13152921e-01f, 9.47234163e-04f, 2.42084935e-01f, 3.41338873e-01f, 2.09114134e-01f, 2.62973905e-01f, 2.46715605e-01f, 1.97067950e-02f, 2.91917566e-02f,
  1.27065584e-01f, 1.68365926e-01f, -3.03365123e-02f, -2.28282496e-01f, -1.51158243e-01f, -1.62904903e-01f, 1.62239090e-01f, -2.16190398e-01f, 5.50712906e-02f, 2.24174354e-02f,
  4.54711765e-02f, 1.17025480e-01f, -6.32366017e-02f, 2.36306735e-03f, 4.41433974e-02f, 3.22397165e-02f, -4.92687710e-02f, -8.29816759e-02f, -1.16552580e-02f, -4.53961901e-02f,
  -2.59634815e-02f, -3.47565748e-02f, 4.29259380e-03f, -2.25536954e-02f, -1.08687347e-02f, -3.62533070e-02f, -1.19455069e-01f, -5.06601743e-02f, -7.09574521e-02f, -5.17643690e-02f,
  -6.61640093e-02f, -5.66034131e-02f, 2.75568962e-02f, 7.16192590e-05f, -3.31257266e-04f, 3.44047993e-02f, -1.58343036e-02f, -5.02673201e-02f, -2.99091898e-02f, 2.51720920e-02f,
  -3.85992322e-03f, 4.04172465e-02f, -3.80970165e-03f, 3.08221336e-02f, 2.81694680e-02f, -1.07076410e-02f, -2.60453206e-02f, 3.81358191e-02f, -3.81995291e-02f, 2.21669879e-02f,
  3.16169895e-02f, 3.58339250e-02f, 1.16031980e-02f, 7.63736526e-03f, 5.78503422e-02f, 5.18156029e-02f, -1.58350859e-02f, -8.99586640e-03f, 1.79537144e-02f, 5.79182319e-02f,
  -1.37815252e-03f, 3.70174162e-02f, 9.18721128e-03f, 2.80154496e-02f, -3.23314033e-02f, -2.65161935e-02f, -2.68673506e-02f, -5.44573441e-02f, -1.78512875e-02f, 2.19636448e-02f,
  1.87911972e-01f, 3.18868071e-01f, 3.81309241e-02f, -5.41619696e-02f, 4.69422806e-03f, 1.30736111e-02f, 8.68272856e-02f, -2.52837799e-02f, 3.11536789e-02f, -2.41172910e-02f,
  -4.01623249e-02f, 3.21533391e-03f, 1.20274518e-02f, 2.94025149e-02f, 3.45611498e-02f, 2.46507004e-02f, 8.69013220e-02f, -1.52387805e-02f, 7.01274425e-02f, 5.43525293e-02f,
  1.99682489e-02f, 1.15292929e-02f, -5.46277724e-02f, 1.71637954e-03f, 1.64347962e-02f, 1.19907930e-02f, 6.71249405e-02f, 6.68145204e-03f, 9.74148698e-03f, -1.68019384e-02f,
  -2.43462816e-01f, 7.52389282e-02f, 1.20718360e-01f, -1.18475154e-01f, -7.50645921e-02f, 4.12757725e-01f, 3.21881235e-01f, -1.36372223e-02f, -1.24583311e-01f, -4.72668884e-03f,
  -1.24578699e-02f, -5.68244047e-02f, 1.43126801e-01f, 2.03915402e-01f, 2.63528466e-01f, 2.56108284e-01f, 1.55378908e-01f, 6.81675673e-02f, 3.74763794e-02f, 1.73887666e-02f,
  -7.43038058e-02f, 7.68611357e-02f, 1.64420962e-01f, -6.36598840e-02f, 4.23315652e-02f, -1.47942185e-01f, -6.04679249e-02f, -5.71586192e-02f, -1.81218460e-02f, 5.55768460e-02f,
  1.97809994e-01f, -1.46218657e-01f, -2.03831103e-02f, -4.93552629e-03f, -3.02215982e-02f, -4.62455377e-02f, 2.84011755e-02f, 6.18015453e-02f, -7.09966868e-02f, -1.02564981e-02f,
  3.02392431e-02f, -1.82555579e-02f, 3.83103639e-02f, -4.51738536e-02f, -5.85444756e-02f, -2.18105093e-02f, -7.75353909e-02f, 6.26643077e-02f, 4.80051972e-02f, 7.02713877e-02f,
  2.98625194e-02f, 3.41434404e-02f, 7.27380859e-03f, 7.54405838e-03f, 7.61383679e-03f, -4.55262996e-02f, 8.65825564e-02f, 1.10396193e-02f, -1.03843128e-02f, 1.52319309e-03f,
  3.12587358e-02f, 1.99936740e-02f, 1.04450947e-02f, 2.02394295e-02f, 3.54558118e-02f, 2.28908332e-03f, 5.56001365e-02f, -1.54724848e-02f, 1.74935982e-02f, 2.26660371e-02f,
  -9.66252107e-03f, -1.59795303e-02f, 5.43232076e-03f, 3.46563682e-02f, -2.21968647e-02f, 1.88512783e-02f, 2.94023324e-02f, 2.13613175e-03f, -1.03474818e-02f, -3.56278010e-02f,
  -4.56795283e-02f, -3.62509442e-03f, 1.94916427e-02f, 4.12454084e-03f, 2.54502259e-02f, 1.93519015e-02f, -5.24737909e-02f, 1.21298479e-02f, -4.55782749e-02f, 7.81286228e-03f,
  1.21852353e-01f, -3.47927622e-02f, 8.56240839e-03f, -7.53289759e-02f, 5.81356212e-02f, 6.40422031e-02f, -7.53697194e-03f, 9.31258127e-03f, 4.95320633e-02f, 2.30409428e-02f,
  -7.29959011e-02f, -4.18754295e-02f, -3.02009378e-02f, 5.00855688e-03f, 1.23830875e-02f, 1.13661857e-02f, 1.16192251e-02f, -1.21063739e-03f, -6.21162876e-02f, -2.66099963e-02f,
  -4.64060381e-02f, -1.96523871e-02f, -3.08881011e-02f, -1.39561100e-02f, -1.36007937e-02f, 4.56457846e-02f, -6.66829124e-02f, 5.07030524e-02f, 2.59599518e-02f, 1.99254267e-02f,
  -2.77221262e-01f, 2.50478953e-01f, 1.41400937e-02f, 8.80690068e-02f, -2.11377099e-01f, 1.12960525e-02f, 1.34167731e-01f, -1.91683799e-01f, -7.98553526e-02f, 3.72880585e-02f,
  -1.12574942e-01f, 1.04606159e-01f, 4.55849580e-02f, 2.55211517e-02f, -1.81712583e-02f, 5.86593896e-02f, -1.80321429e-02f, 4.00069989e-02f, 1.02301622e-02f, 1.85416415e-02f,
  3.79994302e-03f, -1.47246867e-01f, 1.75968081e-01f, -6.04424328e-02f, -1.89024359e-02f, 7.08936825e-02f, -4.28013541e-02f, 1.80997942e-02f, -5.08661270e-02f, 2.01184470e-02f,
  4.81788516e-02f, -9.92990192e-03f, -9.65984538e-03f, 2.19072662e-02f, -1.14020370e-01f, -1.25397928e-02f, 6.21078908e-02f, -8.51781014e-03f, -6.70675710e-02f, 1.31409550e-02f,
  -7.69018680e-02f, -3.90073210e-02f, 4.22471343e-03f, 6.50103688e-02f, -9.15836468e-02f, 6.21067397e-02f, -4.85052094e-02f, 1.13527793e-02f, 3.98994870e-02f, 7.43034016e-03f,
  -5.28763514e-03f, 1.43006844e-02f, 4.74043824e-02f, 8.42786208e-03f, -6.91537634e-02f, 3.67520414e-02f, -1.53728258e-02f, -1.09939380e-02f, 8.07489753e-02f, 5.40230796e-02f,
  -3.78757459e-03f, -3.57630774e-02f, 6.27513379e-02f, 3.93231735e-02f, -7.74281174e-02f, 2.58511771e-02f, 2.43862998e-02f, 2.30411794e-02f, 3.24029028e-02f, -6.10167831e-02f,
  4.78431806e-02f, -5.69583364e-02f, -1.04940888e-02f, -3.54696973e-03f, -2.32156720e-02f, -6.62306026e-02f, 1.16820969e-02f, -2.19285917e-02f, 2.75544543e-02f, 9.86509677e-03f,
  1.13821700e-02f, 4.46565375e-02f, -4.45495062e-02f, 2.48248642e-03f, 4.26470377e-02f, -1.49896853e-02f, -3.15829106e-02f, -4.37806472e-02f, 6.87354803e-02f, -8.70188922e-02f,
  -6.35896474e-02f, -6.08357899e-02f, 3.93128060e-02f, 1.04687661e-02f, 2.90678088e-02f, -7.88551345e-02f, -4.35114875e-02f, -8.46077651e-02f, 6.79489747e-02f, -5.83886392e-02f,
  3.03859077e-03f, 6.19836478e-03f, -1.86910108e-02f, -3.66557762e-02f, -1.62570663e-02f, -4.52612247e-03f, -1.90951601e-02f, 4.52251434e-02f, -5.33263050e-02f, -6.63084984e-02f,
  3.65909524e-02f, -2.11663749e-02f, -6.82524368e-02f, -1.03379905e-01f, -6.70036525e-02f, -5.89021854e-02f, -6.26195688e-04f, 5.37062250e-03f, -3.09917219e-02f, 6.86446056e-02f,
  -7.05424845e-02f, 5.65841943e-02f, -5.66696376e-02f, -2.18315989e-01f, 7.17219189e-02f, 1.52167052e-01f, 1.06311984e-01f, 2.74229911e-04f, -2.76980579e-01f, 1.03057250e-01f,
  1.74227789e-01f, -1.50119543e-01f, -3.11017074e-02f, 1.54217660e-01f, -1.21667609e-01f, -1.13418423e-01f, -5.91836050e-02f, 1.39659597e-02f, -5.23699448e-02f, -2.76011676e-02f,
  -5.08798845e-02f, 8.67309570e-02f, 9.87225547e-02f, 1.05857417e-01f, 1.74289495e-01f, -8.04210678e-02f, 1.65295787e-02f, 4.00201970e-04f, 7.66018480e-02f, 3.40317078e-02f,
  6.74391612e-02f, -4.21205722e-02f, 6.18977919e-02f, 1.45064266e-02f, -1.45571670e-02f, 9.91225615e-02f, -1.23983640e-02f, -7.00581595e-02f, -4.01796550e-02f, -6.66999444e-02f,
  -1.24541379e-03f, -7.16803269e-03f, -1.32806012e-02f, 4.57300395e-02f, -2.52475049e-02f, -1.65534522e-02f, 4.92300428e-02f, -1.89915486e-02f, 3.27100605e-02f, 9.87259895e-02f,
  3.37963216e-02f, 5.15344646e-03f, 2.25284975e-02f, -9.99951735e-02f, -5.02858870e-02f, 1.36332039e-03f, 3.05773336e-02f, -2.97088064e-02f, 8.18312168e-03f, 1.12391477e-02f,
  -1.32822990e-02f, -1.05489932e-01f, 1.83880087e-02f, 2.39039995e-02f, 4.86486368e-02f, 2.49980763e-02f, 4.52672057e-02f, 4.98602772e-03f, -8.42510015e-02f, 4.76517454e-02f,
  4.13972661e-02f, 3.63554507e-02f, 1.43856807e-02f, 3.06566563e-02f, 2.44810507e-02f, 6.97935373e-02f, 2.24091113e-02f, 5.12490012e-02f, 4.06098552e-03f, 1.98182859e-03f,
  -1.70101633e-03f, -1.62538737e-02f, 1.41394064e-02f, -2.23463774e-03f, 1.86091010e-02f, -3.83621710e-03f, -6.31431192e-02f, 5.04390262e-02f, -3.31006199e-02f, 2.74152681e-02f,
  -1.09520496e-03f, -2.01025382e-01f, -2.89549865e-02f, 4.42090295e-02f, -1.94504447e-02f, 5.07713854e-02f, -7.75201097e-02f, -8.66570976e-03f, -9.77322087e-02f, 3.37563036e-03f,
  3.09102423e-02f, -6.26519024e-02f, 6.55455980e-03f, -4.80747260e-02f, -2.95665003e-02f, 3.40373777e-02f, 7.51081156e-03f, -8.81093182e-03f, -1.05821751e-01f, 1.73801102e-03f,
  5.26494868e-02f, -9.12374631e-03f, -3.09623517e-02f, -1.09403748e-02f, 2.56097205e-02f, 9.68028326e-04f, -8.17864835e-02f, -1.01022758e-02f, 3.59317027e-02f, -9.75306779e-02f,
  -3.56799304e-01f, 4.09781560e-02f, 9.88377258e-02f, -1.29682094e-01f, -1.15523480e-01f, 1.81041528e-02f, 3.13704833e-02f, -6.65244162e-02f, -9.64901820e-02f, 8.22214186e-02f,
  3.88361737e-02f, -6.32025525e-02f, 4.21552025e-02f, 1.30270958e-01f, -7.26400688e-02f, 1.37718126e-01f, 5.09664416e-02f, 2.82608140e-02f, -3.17426100e-02f, -1.48601443e-01f,
  -8.14636722e-02f, 3.19326669e-02f, 2.17074286e-02f, 6.63189590e-02f, -1.06217332e-01f, -1.03850380e-01f, -4.06303778e-02f, -8.82566441e-03f, 7.63435885e-02f, 1.27215564e-01f,
  -1.19546011e-01f, -1.76620886e-01f, -1.88579746e-02f, 2.67335214e-02f, 6.07654499e-03f, 2.74436008e-02f, -5.96723109e-02f, 3.88489850e-02f, -4.14705575e-02f, 1.79029405e-02f,
  4.70608398e-02f, -1.06206592e-02f, 5.20896912e-02f, -2.22965367e-02f, -1.17040366e-01f, 2.02033892e-02f, -1.46509353e-02f, -1.46176843e-02f, -2.39529759e-02f, -4.69775498e-02f,
  3.36757414e-02f, -4.80059423e-02f, -4.05904613e-02f, 6.19695522e-03f, 2.64483895e-02f, 4.05030288e-02f, -2.70227995e-02f, -3.56932953e-02f, -8.88421610e-02f, -4.53112498e-02f,
  -6.67728037e-02f, 2.33062971e-02f, 1.20222545e-03f, 4.36534211e-02f, -3.78948636e-02f, 5.64161465e-02f, -4.28586006e-02f, 5.09058796e-02f, -5.67686856e-02f, 1.16627822e-02f,
  -3.23808081e-02f, -4.38757204e-02f, -1.09099541e-02f, -2.37088352e-02f, -1.90283395e-02f, 1.85922794e-02f, -2.12159869e-03f, -4.05339375e-02f, -2.06557196e-02f, 6.15917845e-03f,
  4.89907600e-02f, -4.54209372e-02f, 7.17729926e-02f, -1.59877203e-02f, -3.01011838e-02f, 3.34637575e-02f, 4.88224849e-02f, -5.62562160e-02f, -3.23587358e-02f, -2.56253611e-02f,
  -2.16922611e-01f, -1.90036774e-01f, -3.54159181e-03f, 3.33675696e-03f, -2.21397262e-02f, -4.12792992e-03f, 2.48123799e-02f, -1.03061423e-02f, -4.93584499e-02f, -1.28962159e-01f,
  -9.83818620e-02f, -3.39030474e-02f, 2.41662115e-02f, -3.31448168e-02f, 6.65783659e-02f, -1.64035670e-02f, 6.49755402e-03f, -3.81511711e-02f, 2.53881048e-03f, 2.24946719e-02f,
  1.14212176e-02f, -3.27860527e-02f, 2.37505920e-02f, -2.18774076e-03f, -4.35495079e-02f, -5.49208082e-04f, -5.88762909e-02f, 1.26277776e-02f, -3.20460312e-02f, -1.40620838e-03f,
  -2.36889765e-01f, -1.62315205e-01f, -8.27815663e-03f, -2.33467877e-01f, -6.08069599e-02f, -2.23607838e-01f, -7.27952570e-02f, -1.62008777e-01f, -1.54457456e-02f, -9.11454037e-02f,
  -3.97069640e-02f, 5.39322123e-02f, 1.45040184e-01f, -1.75043270e-01f, 1.21278986e-01f, 1.51826575e-01f, -3.50602090e-01f, -8.18017870e-02f, 1.01155631e-01f, -2.28761792e-01f,
  -3.46733250e-05f, -1.44698948e-01f, 2.38040984e-02f, -9.08562616e-02f, -9.69673917e-02f, -5.96066527e-02f, 1.02554029e-02f, 1.22382417e-01f, -1.14378333e-01f, 9.27415118e-02f,
  3.77746001e-02f, 1.08404830e-01f, 2.64420100e-02f, -2.35526580e-02f, -7.01836348e-02f, 1.82683934e-02f, -4.63346839e-02f, 1.34962350e-01f, 8.11005458e-02f, -2.84394827e-02f,
  4.92530093e-02f, 1.53254503e-02f, -6.97864667e-02f, 2.59911437e-02f, 1.04342038e-02f, 7.02230784e-04f, 4.49470170e-02f, -6.48916289e-02f, 6.18142895e-02f, -1.43024139e-02f,
  1.77418832e-02f, -1.37457587e-02f, -1.30713016e-01f, -4.71027307e-02f, 3.08765247e-02f, -2.99207196e-02f, -5.45757730e-03f, 5.22177033e-02f, -1.40210865e-02f, -3.16700973e-02f,
  -4.13202457e-02f, 2.55366694e-02f, 5.81448786e-02f, 1.23358294e-02f, 2.18043644e-02f, 6.12625619e-04f, -5.23715047e-03f, 6.26946390e-02f, 7.05041271e-03f, 1.36251105e-02f,
  7.91531056e-03f, 8.88538547e-03f, -6.18722141e-02f, 3.02939187e-03f, -4.10528332e-02f, -4.60680388e-02f, 6.46512548e-04f, -3.29112932e-02f, -8.61302093e-02f, -3.22719291e-02f,
  7.05471039e-02f, -2.22192276e-02f, 2.03328021e-02f, 2.73135304e-02f, 2.95435041e-02f, -4.62003499e-02f, -5.20570725e-02f, 8.55462858e-04f, 3.31858173e-02f, -3.46912593e-02f,
  -1.42098486e-01f, -1.50427803e-01f, 3.24109904e-02f, 9.52186733e-02f, -3.09027974e-02f, -5.37965931e-02f, 1.61055829e-02f, -3.35820094e-02f, -2.14044508e-02f, -5.17970733e-02f,
  -1.17876619e-01f, 5.99873904e-03f, -1.92325804e-02f, -2.99855489e-02f, -4.88636568e-02f, -1.50217572e-02f, -7.74733573e-02f, 6.90576807e-02f, -7.30251223e-02f, -7.41514117e-02f,
  -7.77981337e-03f, -4.11586314e-02f, 9.89534184e-02f, 8.59900005e-03f, 1.03011727e-02f, -2.77959788e-03f, -5.13101555e-02f, 3.57379615e-02f, 3.47811244e-02f, -1.34169310e-02f,
  4.53127444e-01f, -3.58131349e-01f, -5.38105182e-02f, 1.59529507e-01f, -1.23797972e-02f, 2.22503152e-02f, 1.31211445e-01f, -1.49774998e-01f, 1.34669006e-01f, -1.29413158e-01f,
  8.77729896e-03f, -3.87709402e-02f, -9.87986326e-02f, -1.26410827e-01f, 2.11659178e-01f, -1.69782881e-02f, 1.16583064e-01f, -5.70271127e-02f, 7.45585114e-02f, -4.70385514e-02f,
  4.58017923e-02f, -7.23822489e-02f, 2.04352699e-02f, -1.56833127e-01f, -1.15627078e-02f, -3.16491863e-03f, -6.93399832e-02f, -5.57928346e-02f, -6.44037277e-02f, -1.12098716e-01f,
  6.94340020e-02f, -6.78487495e-02f, 2.02018172e-02f, 2.92226281e-02f, 2.92743053e-02f, 3.89727317e-02f, 1.25386696e-02f, 2.36706492e-02f, 2.70821936e-02f, -1.15988078e-02f,
  -4.07666825e-02f, 1.74279250e-02f, 6.28748164e-02f, -3.49368975e-02f, -4.67169145e-03f, -8.44738819e-03f, -8.45733806e-02f, 2.91672498e-02f, -2.75866259e-02f, 7.49287009e-03f,
  -3.24314907e-02f, -3.13248262e-02f, 4.37314902e-03f, -3.20912600e-02f, 7.76814483e-03f, -2.62379739e-02f, 3.69069204e-02f, -1.55202011e-02f, 5.50365970e-02f, -1.50692714e-02f,
  -1.99527340e-03f, 2.46074912e-03f, 2.70354412e-02f, 1.38570403e-03f, -1.68778207e-02f, 2.72863708e-03f, 5.51649928e-03f, -1.06385518e-02f, 5.19360823e-04f, -3.15678678e-02f,
  -1.23078339e-02f, -1.83962248e-02f, 3.85979638e-02f, 2.61685699e-02f, 6.84284046e-02f, -1.55230723e-02f, 1.18342852e-02f, -6.48627877e-02f, 3.75034139e-02f, 2.84943003e-02f,
  -1.10570937e-02f, 1.50611287e-03f, -2.18837913e-02f, -4.69828909e-03f, -7.42539391e-03f, 2.80831866e-02f, -1.24794897e-02f, -1.95014980e-02f, 3.32634300e-02f, 5.92029765e-02f,
  -1.60764247e-01f, -1.57078803e-01f, -3.81602682e-02f, -5.61381727e-02f, -2.43643019e-02f, -2.85403393e-02f, 2.17652108e-04f, -6.40150234e-02f, -7.44771883e-02f, 8.23679566e-03f,
  -5.84009243e-03f, -1.74904224e-02f, 4.30195928e-02f, 9.84878018e-02f, 1.78492256e-02f, -3.42827179e-02f, 3.52720432e-02f, 6.20290590e-03f, -2.71645281e-02f, -3.61912474e-02f,
  4.71371738e-03f, -4.93912101e-02f, 4.81013656e-02f, -7.29856966e-03f, 2.92321965e-02f, 1.29046971e-02f, 1.23201879e-02f, 4.25620610e-03f, -1.73930116e-02f, 3.59620973e-02f,
  -3.18238139e-01f, 4.00602818e-01f, 2.09104732e-01f, -4.26476002e-02f, -1.70332700e-01f, -6.86358511e-02f, -1.47571310e-01f, 7.92722553e-02f, -1.03344545e-01f, 1.84017241e-01f,
  -2.75598164e-03f, 9.84192640e-02f, 1.19290978e-01f, 1.63697079e-01f, -3.14465374e-01f, 1.00676782e-01f, 4.19701226e-02f, 4.46672477e-02f, 3.79852578e-02f, 3.02972756e-02f,
  -1.27256159e-02f, -5.36908507e-02f, 1.34024143e-01f, 9.80335027e-02f, 6.57635778e-02f, 1.13828652e-01f, -7.95859918e-02f, 1.45773543e-02f, 1.54277548e-01f, -6.10285671e-03f,
  3.47976238e-02f, 4.01567593e-02f, 2.86356956e-02f, -5.06432541e-02f, 3.98828974e-03f, 1.86179858e-02f, 2.81522814e-02f, -1.69905499e-02f, -3.35492124e-03f, -7.49540888e-03f,
  -1.80507451e-02f, 3.61633860e-02f, -5.52414358e-02f, -4.15049419e-02f, 2.73060193e-03f, -2.10810881e-02f, 2.00764295e-02f, 2.90285004e-03f, 7.98880905e-02f, -4.97916015e-03f,
  4.38365601e-02f, 5.26169455e-03f, -1.60931163e-02f, 9.20918584e-02f, -3.76057029e-02f, -8.78477562e-03f, -5.61661366e-03f, 3.67072225e-02f, 5.58313727e-03f, -1.15057537e-02f,
  -3.08260904e-03f, -4.14417982e-02f, 8.40284117e-03f, -6.95508420e-02f, 5.97519726e-02f, -2.85803899e-02f, 1.37505708e-02f, 2.63373423e-02f, -5.13389409e-02f, 1.58190411e-02f,
  -1.36751104e-02f, -3.93628189e-03f, 3.51035930e-02f, -5.10275783e-03f, -3.90805304e-03f, 6.95034396e-03f, -5.90617657e-02f, 2.80489326e-02f, 1.03834923e-02f, 2.34900732e-02f,
  -3.87479886e-02f, -8.31269938e-03f, 1.66245550e-02f, 1.23966951e-02f, -7.74747087e-03f, -3.27548683e-02f, 1.81482770e-02f, 1.97946932e-03f, 2.74964236e-03f, -5.25359139e-02f,
  4.04412821e-02f, 1.40369177e-01f, 3.06381583e-02f, 4.98269312e-02f, 8.05753097e-02f, 1.17519917e-02f, -1.59861112e-03f, -1.24768894e-02f, 2.28130594e-02f, -9.32039227e-03f,
  -3.32642198e-02f, 4.64319764e-03f, -6.41783401e-02f, 3.79078649e-02f, 2.86621004e-02f, -4.45083082e-02f, 2.91361921e-02f, -3.58079784e-02f, -3.70845981e-02f, 4.42925058e-02f,
  4.91654873e-03f, -4.58308011e-02f, 6.04560878e-03f, -1.14311669e-02f, 2.92389840e-02f, -2.18580328e-02f, 3.87680251e-03f, -1.45418430e-02f, -7.79371290e-03f, 3.06532960e-02f,
  1.37411088e-01f, -2.78061956e-01f, 2.75694996e-01f, -1.16865255e-01f, 5.94771281e-02f, 1.71287924e-01f, 1.04385149e-02f, 2.45432314e-02f, -1.45230398e-01f, -3.11377525e-01f,
  -1.07714124e-01f, 3.93852182e-02f, -7.03127682e-02f, -8.62046108e-02f, 1.44869089e-01f, -2.06689283e-01f, -9.60453376e-02f, -7.38982931e-02f, 1.85121428e-02f, 4.28171968e-03f,
  7.02087879e-02f, -1.96998864e-01f, 1.46206141e-01f, -2.64867898e-02f, 1.79731268e-02f, 1.14942566e-01f, -1.40659632e-02f, 6.73259571e-02f, 1.44029874e-02f, 5.77547848e-02f,
  -3.87395658e-02f, -9.14186239e-02f, 1.67303979e-01f, 3.35096270e-02f, 9.78143215e-02f, 6.68015033e-02f, 7.05658048e-02f, 9.85358804e-02f, 4.15030532e-02f, 3.88947403e-04f,
  7.27887899e-02f, 3.81922461e-02f, -4.18428108e-02f, 2.01744195e-02f, 4.54839319e-03f, 1.35051701e-02f, 5.27429469e-02f, 2.76117846e-02f, -2.86235707e-04f, 2.33700443e-02f,
  2.47292202e-02f, -3.46758775e-02f, 3.27750184e-02f, -1.29514448e-02f, 2.23872978e-02f, 2.37793848e-02f, 6.92145824e-02f, 2.19880864e-02f, -7.25609735e-02f, 1.46756526e-02f,
  -4.99547645e-02f, 6.94637839e-03f, -1.43169435e-02f, -4.90021557e-02f, -5.23500033e-02f, 2.17194241e-02f, 1.08656324e-02f, -1.32098682e-02f, 4.51494418e-02f, -7.65775680e-04f,
  4.03972454e-02f, 5.72280139e-02f, -1.43578388e-02f, 6.13455437e-02f, -3.74734215e-02f, 3.87854949e-02f, 5.97913936e-02f, -2.82933768e-02f, 7.75913224e-02f, 6.28185272e-02f,
  -4.55771293e-03f, 5.65447249e-02f, -9.08715129e-02f, -9.77793802e-03f, -4.45608161e-02f, 2.86285058e-02f, 1.22893392e-03f, -5.92566952e-02f, 3.55909094e-02f, -2.38297191e-02f,
  -1.51223198e-01f, -2.25171581e-01f, -1.35407420e-02f, 3.96961682e-02f, -7.67483041e-02f, 7.42323929e-03f, -6.52737692e-02f, -3.90314087e-02f, -4.59305868e-02f, -1.74789783e-02f,
  2.18202434e-02f, -2.60637347e-02f, 5.66660874e-02f, 3.61194112e-03f, -1.73043180e-02f, -1.60286222e-02f, -2.23849025e-02f, -7.68093951e-03f, 4.60013524e-02f, -2.27336809e-02f,
  1.06511051e-02f, 4.18806868e-03f, -4.52388562e-02f, -1.44709991e-02f, -3.35569307e-02f, -4.05370966e-02f, -2.23014541e-02f, 1.74030438e-02f, 5.39059564e-02f, 1.81529820e-02f,
  -7.38407373e-02f, -3.15602347e-02f, -3.40737432e-01f, -3.96586321e-02f, 4.58015725e-02f, 1.19241618e-01f, 6.67894557e-02f, 1.38605172e-02f, -1.65402263e-01f, 1.46557525e-01f,
  9.23414901e-02f, -1.07567787e-01f, -4.78222966e-02f, 2.62714885e-02f, 1.12670317e-01f, 3.63776498e-02f, 1.63284764e-02f, 4.72017042e-02f, -1.49904191e-01f, 6.96959812e-03f,
  -9.08266306e-02f, 6.60316572e-02f, -1.38279364e-01f, 3.44671011e-02f, 1.16963778e-02f, -3.28385420e-02f, 1.16477415e-01f, -4.94449064e-02f, 5.21592274e-02f, 1.22813068e-01f,
  1.03736997e-01f, -1.39514104e-01f, -4.88509350e-02f, -2.19511073e-02f, 6.69129714e-02f, 3.71894315e-02f, 7.17995390e-02f, 3.45651992e-02f, 2.19780710e-02f, 4.18877378e-02f,
  6.39566854e-02f, -1.85227469e-02f, 9.37731192e-03f, -2.05330122e-02f, 2.63236370e-02f, -3.55983735e-03f, -5.40599413e-02f, -6.65488020e-02f, 4.20575514e-02f, -6.17138445e-02f,
  -3.05651291e-03f, 2.44518189e-04f, -3.50262336e-02f, 5.80417402e-02f, -3.00024301e-02f, -5.39434552e-02f, 1.84531286e-02f, -5.51477037e-02f, 6.05249330e-02f, -1.03173129e-01f,
  -1.60261407e-01f, 3.41525227e-02f, 3.89615893e-02f, 5.89969680e-02f, 7.06994385e-02f, -3.46996300e-02f, 2.38445234e-02f, 8.23999643e-02f, 6.76436648e-02f, -2.93538012e-02f,
  3.62075530e-02f, 1.27599174e-02f, 1.21205831e-02f, -4.31430787e-02f, -1.60991345e-02f, 2.14155912e-02f, 1.84200406e-02f, -1.34571521e-02f, -2.50335597e-02f, -2.71318015e-02f,
  -5.87061197e-02f, 1.14810718e-02f, 7.78375790e-02f, 3.71594429e-02f, -3.70250903e-02f, -2.57386323e-02f, -1.21605059e-03f, 4.01133932e-02f, -2.07957998e-02f, -7.51372846e-03f,
  1.88910097e-01f, -1.51539978e-03f, 1.79603267e-02f, 1.05437152e-02f, 8.67268518e-02f, 5.54423966e-02f, -7.13791847e-02f, 7.02871233e-02f, 3.01862285e-02f, -3.01265921e-02f,
  3.93597409e-02f, 5.30721769e-02f, 2.77167838e-02f, 3.63519974e-02f, -4.90007661e-02f, 7.26617053e-02f, -1.01223364e-02f, 6.53441921e-02f, 3.10404673e-02f, -1.58957858e-02f,
  -1.35133006e-02f, 5.27937710e-02f, -4.70317863e-02f, -7.50518218e-02f, -7.31821870e-03f, 5.79069033e-02f, 4.81674932e-02f, -5.02657034e-02f, 1.45551460e-02f, 4.52479497e-02f,
  -3.12628388e-01f, 1.87715590e-01f, 1.56888217e-01f, -4.77022231e-02f, -2.37601012e-01f, -9.98884141e-02f, 2.94815600e-02f, -9.07632634e-02f, -2.35693399e-02f, 1.62570655e-01f,
  8.24254705e-04f, -2.93456856e-02f, 2.70164549e-01f, 1.22096710e-01f, -8.50327611e-02f, 2.39830047e-01f, -6.44963980e-03f, -4.48087156e-02f, 5.66424839e-02f, -5.05108647e-02f,
  -8.64821598e-02f, -6.59400076e-02f, 1.75187558e-01f, -1.81018598e-02f, -1.20561056e-01f, -4.20587994e-02f, -1.45015687e-01f, 5.78549393e-02f, -4.37881015e-02f, -5.96061125e-02f,
  -8.01606551e-02f, -4.98757400e-02f, 1.65955536e-02f, 6.49436116e-02f, -5.10984138e-02f, -5.96098565e-02f, 1.36648053e-02f, 8.18093270e-02f, 5.79529516e-02f, 3.57379913e-02f,
  4.89918664e-02f, -3.38493176e-02f, -3.19077261e-02f, 1.04985684e-02f, 4.98409085e-02f, 3.48748304e-02f, -3.99707211e-03f, 1.86564606e-02f, 4.80624400e-02f, 4.27545868e-02f,
  7.55407438e-02f, 1.60623936e-03f, -2.96485685e-02f, 1.01081364e-01f, -2.60392856e-02f, -1.03209354e-02f, -1.69597026e-02f, -8.09864141e-03f, 2.48729866e-02f, -1.06145024e-01f,
  -3.82923409e-02f, 3.76413316e-02f, 1.61308218e-02f, -3.46574299e-02f, 1.38248373e-02f, -4.81891073e-02f, 1.99291129e-02f, -2.04429962e-02f, 9.05075744e-02f, -3.79366502e-02f,
  -4.98422831e-02f, 8.38945992e-03f, -3.39110605e-02f, 9.54646841e-02f, -5.18781645e-03f, 2.42499858e-02f, -1.65805519e-02f, -1.08448528e-02f, -2.43987385e-02f, -4.78913821e-03f,
  3.21654119e-02f, -3.19561060e-03f, -6.28044680e-02f, -2.85563339e-02f, -4.95137721e-02f, 5.91494218e-02f, -4.67353594e-03f, 2.80347057e-02f, 7.66174495e-02f, 2.40421221e-02f,
  -1.59276590e-01f, -2.62403518e-01f, 1.86242424e-02f, -7.67435655e-02f, -2.63179075e-02f, -4.42711078e-02f, 2.62736119e-02f, -5.13935387e-02f, 1.64267179e-02f, -1.60257760e-02f,
  -5.04484959e-02f, -5.99217266e-02f, -1.22792058e-01f, 9.16461349e-02f, 1.05498414e-02f, -3.04382127e-02f, -1.16085308e-02f, -7.66554091e-04f, -4.04177234e-02f, 2.41660513e-02f,
  -8.70999396e-02f, -5.89877218e-02f, -7.83225242e-03f, -1.21158198e-01f, 5.71667328e-02f, -1.24999834e-02f, -1.46719888e-02f, 8.23435262e-02f, -1.96261350e-02f, -4.86778794e-04f,
  2.66151935e-01f, 1.56012163e-01f, 7.66447000e-03f, 1.22088127e-01f, 1.47498354e-01f, 4.82736435e-03f, -1.07924290e-01f, 2.19778582e-01f, -1.26082093e-01f, 9.42162722e-02f,
  1.59344599e-02f, -2.15013266e-01f, -2.55947739e-01f, 7.55393133e-02f, -3.20357293e-01f, -2.71530837e-01f, -3.81642096e-02f, -3.43170352e-02f, -4.29238416e-02f, 9.95200053e-02f,
  1.19414538e-01f, 8.17591250e-02f, 1.90422237e-02f, 1.77400902e-01f, 2.45439976e-01f, 1.81474045e-01f, 2.65757609e-02f, -3.33971530e-02f, 1.88195944e-01f, -9.68665034e-02f,
  -3.63385119e-02f, -6.93157241e-02f, 1.05692141e-01f, -2.01365445e-02f, 7.33197480e-02f, 9.81750116e-02f, 2.07954552e-02f, -2.17345469e-02f, -1.92746483e-02f, 1.37487473e-02f,
  5.57132019e-03f, -2.43072994e-02f, 2.09771283e-02f, 3.17924060e-02f, -4.85119926e-05f, 3.10273785e-02f, 5.08113876e-02f, 3.69945429e-02f, 6.70866892e-02f, 5.91249317e-02f,
  8.27294141e-02f, 2.86151692e-02f, 5.49175330e-02f, -6.38468862e-02f, 3.61290872e-02f, -1.34688793e-02f, -1.30950436e-02f, -2.29168478e-02f, 1.63322818e-02f, 3.92784104e-02f,
  5.69972508e-02f, 4.57154922e-02f, -6.55955151e-02f, 1.57927647e-02f, -2.56993696e-02f, 8.44052136e-02f, -1.97910219e-02f, -6.94223633e-03f, -3.02915424e-02f, -6.01631356e-03f,
  -2.16756016e-02f, 4.05306220e-02f, -3.23333405e-02f, 3.73811796e-02f, 2.40709223e-02f, -1.19968876e-02f, -1.98311526e-02f, 1.59943756e-02f, 1.44769801e-02f, 4.73037958e-02f,
  -4.35894020e-02f, -6.37723878e-02f, -1.89378299e-03f, 3.40653397e-02f, -6.25951737e-02f, -4.22081305e-03f, 7.17480853e-02f, 6.27543926e-02f, 1.98861468e-03f, 6.18259935e-03f,
  -5.74902445e-02f, -2.00658515e-02f, -3.71782631e-02f, 2.21764315e-02f, -1.23405628e-01f, -4.16429415e-02f, -1.69487633e-02f, -5.37697738e-03f, -6.91124201e-02f, -5.39276935e-02f,
  1.14608407e-02f, -2.67638750e-02f, -9.40681472e-02f, 2.05304008e-02f, -1.05580881e-01f, -8.24480038e-03f, -1.08068161e-01f, -2.39989143e-02f, -2.81555448e-02f, 5.07603548e-02f,
  8.51708557e-03f, -8.03687200e-02f, -6.34946823e-02f, 2.96491534e-02f, -9.15668812e-03f, -5.77368028e-02f, 1.02125725e-03f, 3.81277427e-02f, 2.59004813e-02f, -6.73726648e-02f,
  4.36331406e-02f, -7.36454278e-02f, -6.58975961e-03f, -2.65955515e-02f, -9.19871703e-02f, 2.54917294e-01f, 3.47208977e-01f, -1.41755477e-01f, -4.76932433e-03f, 8.82202014e-02f,
  1.56634778e-01f, -3.03290822e-02f, 1.95315983e-02f, 2.56978810e-01f, 2.95503527e-01f, 7.18446001e-02f, 1.45660594e-01f, 1.35580257e-01f, -5.57676479e-02f, -1.26590893e-01f,
  1.52688818e-02f, 1.18513651e-01f, 3.79678444e-03f, -1.20882384e-01f, 8.66131708e-02f, -2.61311173e-01f, -1.62307844e-01f, -5.31555973e-02f, -2.16160547e-02f, 4.16893847e-02f,
  1.03513725e-01f, 3.72554455e-03f, -3.90400253e-02f, 2.10670922e-02f, -6.50313720e-02f, -3.54957767e-02f, -2.93214656e-02f, 1.32292500e-02f, -2.02098638e-02f, -2.81296745e-02f,
  6.72951713e-03f, -5.06162122e-02f, 3.88819352e-02f, -6.09204872e-03f, 3.13080475e-02f, 4.65409923e-03f, -7.17073795e-04f, 3.84146459e-02f, -4.35612723e-02f, 2.33909511e-03f,
  -7.20112305e-03f, 6.23488128e-02f, -1.24168452e-02f, -5.27256094e-02f, -5.30622974e-02f, 4.41014171e-02f, -3.01977135e-02f, 1.87005829e-02f, 2.23084837e-02f, -4.80649769e-02f,
  -9.18636471e-02f, -4.50811967e-05f, -2.01024842e-02f, -3.45228352e-02f, -3.05767283e-02f, -5.35443649e-02f, 7.63712376e-02f, 7.43773654e-02f, -6.97739348e-02f, 5.49912602e-02f,
  -9.95530840e-03f, 3.06793628e-03f, -5.34568876e-02f, -3.97319049e-02f, 4.16361429e-02f, -3.37552875e-02f, 2.13236883e-02f, 3.72756161e-02f, 2.21792031e-02f, -2.45785937e-02f,
  -2.07621362e-02f, 2.97092218e-02f, -3.26257311e-02f, 3.12500112e-02f, 6.22904338e-02f, 4.35134247e-02f, -2.51494311e-02f, -3.43975388e-02f, 5.03825694e-02f, -1.54535593e-02f,
  5.79573587e-03f, -1.46295667e-01f, 3.62436958e-02f, 4.26424807e-03f, 5.31678088e-02f, 1.72093080e-03f, 3.49079669e-02f, 2.07304978e-03f, 7.80948903e-03f, 2.24837158e-02f,
  -5.49189858e-02f, -2.01905034e-02f, -4.61647063e-02f, -2.59436723e-02f, -3.13262455e-02f, 3.48572284e-02f, 1.01296566e-02f, -3.70895378e-02f, -2.62268241e-02f, -1.86451208e-02f,
  -4.23823893e-02f, -9.72816944e-02f, 5.46385832e-02f, -8.52929056e-03f, 8.20281282e-02f, 3.21459398e-02f, -5.27161267e-03f, -3.28694470e-02f, -4.02208008e-02f, 9.35510397e-02f,
  5.34419045e-02f, -3.18775386e-01f, 7.25446492e-02f, 3.17255072e-02f, 2.99167544e-01f, 7.44091719e-02f, 1.11431092e-01f, -2.74463426e-02f, -1.50208071e-01f, -7.05512986e-02f,
  5.57709411e-02f, -1.05748914e-01f, -6.47852272e-02f, -3.06340382e-02f, -1.35195434e-01f, -2.49079868e-01f, -1.19951591e-01f, -7.57232308e-02f, -2.23934390e-02f, -1.80226732e-02f,
  2.69498900e-02f, 3.14170495e-02f, 1.61651522e-02f, 9.01307240e-02f, 2.26297319e-01f, 1.29149765e-01f, 5.29473424e-02f, 1.75818786e-01f, 1.01437554e-01f, 8.68215561e-02f,
  5.20527288e-02f, 1.31056160e-02f, -3.90115492e-02f, 5.85802691e-03f, 1.45488344e-02f, 6.13358943e-03f, 4.82780002e-02f, -2.69025390e-04f, 1.03713311e-01f, 2.67644264e-02f,
  2.56496333e-02f, 8.73150826e-02f, 4.19397317e-02f, -5.98622523e-02f, 4.08143438e-02f, -1.61351040e-02f, 2.57107168e-02f, 6.67276233e-02f, 7.42938071e-02f, 7.31699318e-02f,
  5.71095683e-02f, 3.14795338e-02f, 2.04575248e-02f, 2.31654365e-02f, 3.97022106e-02f, 6.00440763e-02f, 5.10638840e-02f, 9.97214094e-02f, -5.40890098e-02f, 1.97322927e-02f,
  -3.04382108e-02f, 7.07509667e-02f, 5.17996140e-02f, 3.63881513e-02f, -2.65115574e-02f, 8.40014592e-02f, -1.60680506e-02f, -1.19572751e-05f, 6.55889362e-02f, -3.81720960e-02f,
  1.54190995e-02f, -5.66694774e-02f, -5.23907319e-02f, 3.68421338e-02f, 2.18232237e-02f, -2.80654244e-02f, -4.65993682e-04f, 2.31749136e-02f, 4.52936999e-03f, -1.49837937e-02f,
  -6.02630153e-02f, -3.51566188e-02f, 3.40969972e-02f, 1.55692520e-02f, 1.25335553e-03f, 6.70191497e-02f, 4.96501438e-02f, -9.11080744e-03f, 5.02761789e-02f, -2.16417294e-02f,
  -1.92030877e-01f, -2.47481659e-01f, -5.58274612e-02f, -7.24479407e-02f, -3.10915280e-02f, -3.87982950e-02f, -2.69916784e-02f, 1.28723951e-02f, -1.20281428e-01f, -6.13162033e-02f,
  5.22997193e-02f, 7.77253881e-02f, -9.90977287e-02f, 4.53321747e-02f, -9.09238532e-02f, -3.30286175e-02f, -4.71677519e-02f, -6.59441352e-02f, -6.55026734e-02f, -4.47507948e-02f,
  5.02412580e-02f, 5.88469654e-02f, 1.49948969e-02f, 5.16149364e-02f, -4.10191074e-04f, 4.80439402e-02f, -4.83454531e-03f, 6.46060109e-02f, -2.56309155e-02f, 7.59464270e-03f,
  -3.94250499e-03f, -9.19374004e-02f, -3.71524274e-01f, -1.18274622e-01f, 1.28815966e-02f, -9.75663662e-02f, -1.49441227e-01f, -1.36497706e-01f, -2.59128869e-01f, 1.35377094e-01f,
  9.77815390e-02f, -1.70640014e-02f, 3.84831019e-02f, -7.79866055e-02f, -1.58544153e-01f, -1.50750354e-01f, -1.04118409e-02f, 6.99957237e-02f, -1.76362902e-01f, -4.12290953e-02f,
  -1.66270673e-01f, 8.51712972e-02f, -1.35297745e-01f, 1.96347192e-01f, -3.82895512e-03f, 1.95595436e-02f, 2.66446769e-01f, 4.99626622e-02f, 2.28759095e-01f, -1.87860467e-02f,
  5.64925931e-02f, -3.78699601e-02f, 6.85789362e-02f, -9.08848736e-03f, 7.62557387e-02f, 5.20722754e-02f, 3.99330184e-02f, -2.23267712e-02f, 4.25396226e-02f, -4.84213680e-02f,
  8.53991061e-02f, -5.33430986e-02f, -2.99959406e-02f, -6.03910312e-02f, -5.99075342e-03f, -1.63011719e-02f, -8.16319883e-02f, -1.08659379e-02f, -7.50057325e-02f, -7.51515999e-02f,
  -8.62897187e-02f, 4.08375598e-02f, -6.16704561e-02f, 3.58522451e-03f, -1.29989721e-03f, 2.54031457e-02f, -4.78985570e-02f, 3.98006872e-04f, 2.56252773e-02f, -4.19455953e-02f,
  -1.58487782e-02f, 3.38845141e-02f, 5.89748053e-03f, 3.70034911e-02f, -2.78556049e-02f, 1.32970242e-02f, 2.11261064e-02f, 6.30298397e-03f, -2.12639235e-02f, 2.83817649e-02f,
  1.10521195e-02f, -1.57392584e-02f, -4.13034968e-02f, -3.91579270e-02f, -1.00961123e-02f, -6.19442724e-02f, 4.43508755e-03f, -3.30056772e-02f, -1.05717704e-02f, -2.19356865e-02f,
  -4.95124944e-02f, -3.63634080e-02f, -1.12765823e-02f, 7.36118183e-02f, -4.92135473e-02f, 1.67259686e-02f, -7.04767136e-03f, -8.14814940e-02f, 2.89755668e-02f, 7.09203407e-02f,
  1.51004255e-01f, 2.64166971e-03f, 3.23573835e-02f, 7.29138404e-02f, 6.72846660e-02f, 1.93572231e-02f, -2.65641306e-02f, 3.24982544e-03f, -1.25672864e-02f, -6.03630440e-04f,
  -2.78166588e-02f, 7.56286457e-02f, 5.56660965e-02f, -1.39012551e-02f, -1.73101220e-02f, -2.03502681e-02f, -1.18749598e-02f, 5.73666766e-02f, 1.07045747e-01f, 6.48041591e-02f,
  5.99369518e-02f, 8.20276700e-03f, 6.31178394e-02f, -2.33955942e-02f, 1.10687248e-01f, 1.40896589e-02f, 7.31583983e-02f, 3.80225480e-02f, 3.01255193e-03f, -2.64616795e-02f,
  -4.45505641e-02f, -8.39520842e-02f, -2.85852343e-01f, 1.36019588e-01f, -1.01289049e-01f, 1.39596969e-01f, -1.75633784e-02f, -1.00471422e-01f, -2.93534875e-01f, 1.23303495e-01f,
  9.55843776e-02f, -1.06971793e-01f, -8.22059996e-03f, 3.03853154e-01f, 2.24280059e-01f, 1.54341713e-01f, 1.70127571e-01f, 1.25504881e-01f, -1.29937932e-01f, 2.82637365e-02f,
  4.46216483e-03f, 2.48349681e-01f, 7.75966570e-02f, 9.96850431e-02f, -4.40973379e-02f, -6.82334080e-02f, 1.91724896e-01f, -8.31549540e-02f, 2.32031509e-01f, 6.02023527e-02f,
  7.38683119e-02f, -1.68936491e-01f, -5.72521836e-02f, -3.00177895e-02f, 6.22967072e-02f, 1.31131727e-02f, -1.93077251e-02f, 2.39506010e-02f, -4.36622053e-02f, 5.77431209e-02f,
  -5.45478128e-02f, 5.54232635e-02f, -4.90143523e-02f, 2.07998008e-02f, -3.91494669e-02f, -6.17415048e-02f, -2.42816992e-02f, -4.14396413e-02f, -3.98656465e-02f, -3.47457863e-02f,
  -2.72793062e-02f, 1.90009475e-02f, -6.85979575e-02f, 2.56378856e-03f, -1.10087423e-02f, 1.51609862e-02f, 5.50477430e-02f, 3.31041956e-04f, -4.93388027e-02f, 3.00429557e-02f,
  5.69356829e-02f, -1.83222461e-02f, -3.32757309e-02f, 3.98362167e-02f, -1.26674883e-02f, 6.86300173e-03f, 2.43598074e-02f, 2.21273559e-03f, -5.77508248e-02f, 4.90625948e-02f,
  3.33464122e-03f, -1.53439064e-02f, -7.34562874e-02f, 2.68362630e-02f, 5.60450777e-02f, 5.51479235e-02f, 3.72179002e-02f, -2.09659543e-02f, -3.85484174e-02f, 1.05819050e-02f,
  4.50279117e-02f, 3.97804845e-03f, -8.91634077e-03f, -2.38174256e-02f, 3.16884145e-02f, -9.78994928e-03f, 4.83791232e-02f, -2.35710237e-02f, -1.24632390e-02f, 1.82710886e-02f,
  6.52086437e-02f, 1.46018431e-01f, -7.81079382e-02f, -3.13097797e-03f, -6.13596886e-02f, -1.41080748e-03f, 5.01110330e-02f, 2.15648208e-02f, -1.23536419e-02f, 1.76558215e-02f,
  3.61544229e-02f, -5.36185049e-04f, 5.41617908e-02f, 2.14042887e-03f, -2.55431421e-02f, 6.73421621e-02f, 6.71655312e-02f, 3.79032679e-02f, 1.04247220e-01f, 2.57271808e-02f,
  6.56408146e-02f, -4.92337486e-03f, -2.39270441e-02f, -1.12955999e-02f, 1.47352554e-02f, -3.35258082e-03f, -6.41360879e-02f, -3.52826416e-02f, 7.98883215e-02f, 1.05252704e-02f
};

// L0_fan_Wp_bar (Shape: 26 x 120)
const int L0_fan_Wp_bar_rows = 26;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  2.45654099e-02f, 6.81562871e-02f, -1.66362569e-01f, 5.33224046e-02f, -6.49453476e-02f, 8.62061977e-02f, 5.00681847e-02f, 2.05174591e-02f, -1.47962496e-01f, 1.27719626e-01f,
  1.66153669e-01f, -1.32796586e-01f, 6.19239919e-02f, 1.69102192e-01f, 4.38360078e-03f, 1.47839785e-01f, 1.14292130e-01f, 1.38255388e-01f, -3.45015228e-02f, 8.00490826e-02f,
  -2.15152986e-02f, 2.95188203e-02f, -1.40285427e-02f, 2.25856379e-02f, 2.43151262e-02f, -8.06548148e-02f, 1.00041032e-01f, -6.82012290e-02f, 1.00204483e-01f, 3.17414366e-02f,
  7.60142505e-02f, -8.39181840e-02f, -1.02437563e-01f, -8.36838386e-04f, -2.54337192e-02f, 5.37267104e-02f, -1.56883337e-02f, 2.83517838e-02f, -3.17294635e-02f, -7.94937834e-02f,
  1.30028175e-02f, 2.73630694e-02f, 4.40088026e-02f, -7.21174404e-02f, 2.88559515e-02f, -6.38281256e-02f, 3.04308347e-02f, -5.41233607e-02f, -8.14426318e-02f, -4.16256264e-02f,
  6.79560378e-02f, 7.03144893e-02f, 4.84904312e-02f, 2.98066307e-02f, -8.13506078e-03f, 1.00345686e-02f, 3.24700288e-02f, -1.18839573e-02f, -3.66828218e-02f, 2.95546334e-02f,
  -3.28102671e-02f, 6.49890006e-02f, 1.20564632e-01f, -6.37615174e-02f, -9.60752517e-02f, 6.27613114e-03f, -7.63429552e-02f, -5.28384894e-02f, -2.39078309e-02f, 8.58561918e-02f,
  -7.12534711e-02f, -3.59560438e-02f, -5.46276607e-02f, 2.09681150e-02f, 2.06958223e-02f, -2.17992347e-02f, 6.38815984e-02f, -1.35073029e-02f, -2.81651448e-02f, -4.07643951e-02f,
  -3.87101360e-02f, -1.42625244e-02f, 7.45270178e-02f, -1.01488242e-02f, -1.31778605e-02f, -1.04309842e-02f, 5.00082783e-02f, 1.18086077e-02f, -3.30075016e-03f, 3.46650928e-02f,
  6.95486814e-02f, 7.47694448e-02f, 6.10726364e-02f, -6.11284599e-02f, -8.89357254e-02f, 2.05390360e-02f, -6.07189015e-02f, 4.48581427e-02f, 6.04135320e-02f, 3.74059658e-03f,
  5.21141738e-02f, 6.35395423e-02f, 7.05771595e-02f, -1.73305459e-02f, 1.47789307e-02f, 8.79086182e-02f, 7.98745677e-02f, -6.65775165e-02f, 7.87974000e-02f, -5.84797189e-02f,
  -4.94343676e-02f, 8.18774924e-02f, -4.98278178e-02f, -1.54066831e-03f, -5.04780896e-02f, 1.38409575e-02f, -7.80572295e-02f, -1.62115153e-02f, 9.06056911e-02f, -6.39702845e-03f,
  1.47384465e-01f, -4.01838757e-02f, 5.10030538e-02f, 2.77347211e-02f, 3.03325001e-02f, -8.88680760e-03f, -2.01687030e-02f, -9.95687097e-02f, 4.85659540e-02f, -6.73599392e-02f,
  2.65039261e-02f, 8.43534619e-03f, 4.09754589e-02f, 7.77458549e-02f, 9.21295211e-02f, -3.46835926e-02f, 2.81656552e-02f, -6.47928491e-02f, 2.69050840e-02f, 4.21306826e-02f,
  -4.95649828e-03f, -5.09139858e-02f, -1.04828782e-01f, -1.60235971e-01f, 5.39799780e-02f, -2.21377648e-02f, -1.05067350e-01f, -1.12233207e-01f, -1.03210822e-01f, 7.61972442e-02f,
  7.84535408e-02f, -6.30132928e-02f, -3.72353122e-02f, -4.85749915e-02f, -4.08680327e-02f, 8.69505107e-02f, 1.90011561e-02f, -1.72126759e-03f, -3.05474512e-02f, 1.01382427e-01f,
  -7.25267455e-02f, -3.70291108e-03f, -3.72095816e-02f, 8.19023848e-02f, -6.54398426e-02f, -4.61973548e-02f, -6.25991076e-02f, 4.90846932e-02f, -8.70822817e-02f, -8.85786768e-03f,
  6.54355735e-02f, -9.51434225e-02f, -3.38720828e-02f, -2.96761207e-02f, 5.85054979e-02f, -2.94548343e-03f, 4.22904752e-02f, -2.80769691e-02f, 6.89431429e-02f, -6.27344325e-02f,
  -5.02157584e-03f, -5.87620214e-02f, 2.06344817e-02f, -3.16568464e-02f, 6.54604211e-02f, 8.50250199e-02f, -6.59413859e-02f, 3.90901677e-02f, 8.59214142e-02f, 8.16840772e-03f,
  8.19351599e-02f, 2.37136651e-02f, -4.00595851e-02f, -5.16797556e-03f, 2.86217891e-02f, -7.87815154e-02f, 5.36743291e-02f, -7.70456865e-02f, -4.92455661e-02f, 6.31268099e-02f,
  -3.02063860e-03f, 8.71665329e-02f, -8.83830115e-02f, 5.80286011e-02f, 5.07085510e-02f, -9.12268832e-02f, 1.68557819e-02f, 4.58028838e-02f, -2.48246174e-02f, 5.78469485e-02f,
  4.87177707e-02f, 5.21942712e-02f, 5.70225231e-02f, 5.79355024e-02f, 5.79242148e-02f, 4.66339178e-02f, -2.49633491e-02f, -1.55211920e-02f, -8.55347738e-02f, -2.82126367e-02f,
  -2.89288368e-02f, 5.03844693e-02f, 8.34689382e-03f, -1.11853722e-02f, -1.96256842e-02f, 6.03418052e-02f, -2.44089514e-02f, -7.31962994e-02f, 6.72457786e-03f, -7.82131627e-02f,
  -8.29640329e-02f, 5.33515252e-02f, 2.96856593e-02f, 9.23563018e-02f, -3.26805897e-02f, -3.76518220e-02f, 3.99238542e-02f, -1.16800547e-01f, 6.93307668e-02f, 6.36503473e-02f,
  1.30901575e-01f, -3.42604160e-01f, 1.79162145e-01f, 2.67318934e-01f, -1.48957428e-02f, 4.50816005e-02f, 2.96977162e-01f, -2.81640649e-01f, -7.43043721e-02f, -2.38513350e-01f,
  3.98401804e-02f, 1.56506196e-01f, 1.49838692e-02f, -2.97090691e-03f, 2.25980982e-01f, -2.66133230e-02f, -2.02962123e-02f, 7.79836029e-02f, -7.55328462e-02f, -3.72787379e-02f,
  -7.57503584e-02f, 2.47764960e-03f, 2.56074257e-02f, -2.19563648e-01f, 5.01763262e-02f, -3.16362754e-02f, -5.56288958e-02f, 7.50653744e-02f, -1.77590065e-02f, 8.85126665e-02f,
  1.28878271e-02f, -7.48512447e-02f, 5.06444946e-02f, -7.33632874e-03f, -1.11024275e-01f, 4.02593575e-02f, 8.62316415e-02f, 1.56059414e-01f, 6.20312877e-02f, 1.36947390e-02f,
  4.65957597e-02f, 1.23880990e-02f, -3.85053791e-02f, -1.83799434e-02f, -7.61128515e-02f, -1.80831775e-02f, 4.44498584e-02f, -7.33408853e-02f, -7.02060247e-03f, 3.71294506e-02f,
  6.76754415e-02f, 2.50308253e-02f, -3.07694580e-02f, 6.72457088e-03f, 8.50331858e-02f, -1.93662215e-02f, 2.74926685e-02f, 9.40808654e-02f, 7.68935531e-02f, -2.56403890e-02f,
  -6.92435959e-03f, -6.11663759e-02f, -7.99160078e-02f, -2.44021825e-02f, 4.52717133e-02f, -2.74907108e-02f, -6.49325550e-02f, -3.12503316e-02f, -4.15111519e-02f, -8.08924902e-03f,
  -7.54486620e-02f, -5.51824011e-02f, 1.89055018e-02f, -5.07997610e-02f, -5.37565502e-04f, 4.92987456e-05f, 8.60814601e-02f, -1.36934351e-02f, 1.49578331e-02f, 1.12973584e-03f,
  4.84882444e-02f, 3.38314250e-02f, 8.30713380e-03f, 6.60851225e-02f, 1.39513938e-02f, 3.63932401e-02f, -3.63591760e-02f, 3.86905186e-02f, 1.49694225e-02f, 9.34651569e-02f,
  -1.93112805e-01f, -1.44023076e-01f, 2.78641060e-02f, 3.35991420e-02f, 5.50966291e-03f, -9.64967012e-02f, -1.06682433e-02f, -6.07198812e-02f, 1.14480527e-02f, -7.50718191e-02f,
  -5.08106574e-02f, 2.93636005e-02f, -3.67835723e-02f, -1.85535997e-02f, 7.52749518e-02f, -3.39013711e-02f, 9.57385227e-02f, -3.08162663e-02f, 2.79708020e-02f, -5.21085151e-02f,
  5.59912249e-02f, 7.10620135e-02f, 7.00714961e-02f, 8.61606654e-03f, 5.50099602e-03f, 1.53888920e-02f, -7.63549358e-02f, 8.44860598e-02f, -2.73143742e-02f, -2.09492072e-02f,
  2.05154747e-01f, 1.02659717e-01f, -3.66153978e-02f, 4.09651138e-02f, -4.27209400e-02f, 2.05673531e-01f, 1.76183045e-01f, 4.91211079e-02f, 4.85327095e-02f, 1.06820412e-01f,
  -5.76689392e-02f, 1.23427436e-01f, 7.16046616e-02f, 1.27022609e-01f, 1.29568443e-01f, 3.23491953e-02f, 1.21022217e-01f, 1.37525752e-01f, -2.78895292e-02f, 1.39715904e-02f,
  -6.55985251e-02f, -6.43183589e-02f, -1.73931882e-01f, -8.24119151e-02f, -1.72161106e-02f, -1.79664999e-01f, -1.85215980e-01f, -1.14710428e-01f, -1.46234974e-01f, 1.01492768e-02f,
  1.28054634e-01f, 5.07717431e-02f, 1.60076481e-04f, -2.53850105e-03f, 4.12364230e-02f, -6.51230514e-02f, 1.11284442e-01f, 4.69548441e-03f, 9.05455183e-03f, 3.93179320e-02f,
  9.21276659e-02f, -4.90438640e-02f, 4.95669320e-02f, -2.45097075e-02f, -2.85173114e-02f, -2.47767065e-02f, 1.44667896e-02f, -3.93917672e-02f, 3.20797153e-02f, -1.13750650e-02f,
  3.45989764e-02f, -6.69831485e-02f, -8.24709311e-02f, -9.80256312e-03f, -8.20574351e-03f, -2.13210452e-02f, 1.97127350e-02f, 7.41840526e-02f, 7.39544481e-02f, 1.15527689e-01f,
  8.28560367e-02f, 6.62154779e-02f, 1.69413686e-02f, -8.15299302e-02f, 1.05275866e-02f, -8.84641148e-03f, 2.60605104e-02f, -6.58629462e-02f, -1.37974042e-03f, -6.76198751e-02f,
  -3.07802409e-02f, 2.64127254e-02f, 5.04211932e-02f, 7.54176229e-02f, 5.67088760e-02f, 1.78180095e-02f, -6.00584559e-02f, 2.12782435e-02f, 2.20514871e-02f, -4.85463738e-02f,
  -4.60082740e-02f, -2.65956428e-02f, -7.32897967e-02f, -4.83635888e-02f, 1.53397657e-02f, 6.63946494e-02f, 7.31785372e-02f, 3.31368856e-03f, 1.77469421e-02f, 3.11475042e-02f,
  9.78025328e-03f, 1.48103893e-01f, -5.31083494e-02f, 2.64827795e-02f, -2.06409544e-02f, 4.24589626e-02f, 1.25648335e-01f, 9.38468799e-02f, -4.36694585e-02f, 2.19594650e-02f,
  -9.09051858e-03f, 3.66899818e-02f, -1.00997381e-03f, -7.37371147e-02f, 3.23813520e-02f, -9.88132879e-02f, 1.55651290e-02f, -1.57193840e-02f, -9.87853110e-03f, -7.40598440e-02f,
  -9.21892971e-02f, 7.13933632e-02f, 8.23419914e-02f, 2.09356751e-02f, 5.34484461e-02f, -2.66794525e-02f, 8.95350948e-02f, 6.04500901e-03f, -1.86200906e-02f, -5.67579977e-02f,
  1.27547735e-03f, -1.17746681e-01f, 2.31199175e-01f, -4.86930050e-02f, 1.71327144e-01f, 1.41628668e-01f, 2.17113778e-01f, 4.82675880e-02f, -1.42252758e-01f, -2.33907774e-01f,
  -9.60639939e-02f, -2.33166106e-02f, 1.58377320e-01f, -1.02650383e-02f, 2.38412529e-01f, 6.02326281e-02f, -2.00512856e-02f, -8.15879181e-02f, -5.17183729e-02f, -4.42792885e-02f,
  -1.60457287e-02f, -7.03535229e-02f, 1.77352160e-01f, -6.94952384e-02f, -6.97731525e-02f, -1.29314214e-01f, -2.61449236e-02f, 8.13999847e-02f, -3.62363681e-02f, -1.60786752e-02f,
  -5.68111020e-04f, -2.59124935e-02f, 9.35582593e-02f, -5.15542179e-02f, 9.88259837e-02f, 6.18194826e-02f, -2.06509922e-02f, 1.08401850e-01f, 2.07756609e-02f, -3.12709659e-02f,
  2.44790409e-02f, -5.80780879e-02f, -1.18906453e-01f, 6.41510710e-02f, -6.18127622e-02f, -1.54997362e-02f, -2.30059470e-03f, 1.43652549e-02f, -4.47959043e-02f, 1.24276988e-01f,
  -4.09125956e-03f, 3.84755107e-03f, 1.24552287e-02f, -8.66998211e-02f, 4.30105021e-04f, -8.91613886e-02f, -4.08055559e-02f, 9.23590660e-02f, -2.85310093e-02f, -1.06089853e-01f,
  3.38579491e-02f, -6.07603369e-03f, -2.88102869e-02f, -4.32797670e-02f, 6.96182773e-02f, -1.27703220e-01f, -3.02420966e-02f, -2.64149662e-02f, 3.46950404e-02f, -2.31913459e-02f,
  6.37672171e-02f, -7.08666891e-02f, 5.24618402e-02f, 1.06096892e-02f, -8.50368664e-02f, -8.80737454e-02f, -3.17556271e-03f, 2.11472567e-02f, 2.59789284e-02f, -2.10388079e-02f,
  4.80000451e-02f, -7.11703375e-02f, 2.45889965e-02f, 4.72828038e-02f, 1.18386988e-02f, -3.96325924e-02f, 8.15720018e-03f, 1.35772806e-02f, -8.07687640e-02f, 8.91174376e-02f,
  -1.88554674e-02f, -9.18565392e-02f, -1.23316504e-01f, 1.11260684e-03f, -4.92145568e-02f, -8.41571949e-03f, 7.33936355e-02f, 2.61088610e-02f, 6.09903969e-03f, 1.92404946e-03f,
  -1.01624534e-01f, 8.62229094e-02f, -4.80303317e-02f, -5.60591333e-02f, -7.44239315e-02f, -5.66794723e-02f, -4.25951853e-02f, -6.70017675e-02f, -4.34874520e-02f, -3.29564139e-02f,
  -6.70430958e-02f, 2.21131789e-03f, 3.89969163e-02f, -1.16997324e-01f, -4.76129279e-02f, -4.32814211e-02f, 8.09962749e-02f, -6.73247501e-02f, -5.85748069e-03f, 7.44167715e-02f,
  6.67972863e-02f, -1.55648038e-01f, 5.90419136e-02f, 8.80588293e-02f, 4.16199602e-02f, -6.30688444e-02f, -4.34508026e-02f, 2.92288177e-02f, -3.12424311e-03f, -4.81700748e-02f,
  3.55864093e-02f, -1.06688105e-01f, 7.29521289e-02f, -5.79839014e-03f, 1.76004529e-01f, -3.35942321e-02f, -2.67414767e-02f, -6.27260804e-02f, -3.40304859e-02f, 1.33287266e-01f,
  1.67185560e-01f, 9.82066616e-02f, 1.51377201e-01f, 1.08967289e-01f, 2.68623456e-02f, 1.38547584e-01f, 1.54879466e-01f, 7.95404464e-02f, 1.07295677e-01f, -2.93153767e-02f,
  6.13780804e-02f, 6.06154278e-02f, 2.57388782e-02f, 2.60905940e-02f, 5.44915721e-03f, -3.84235159e-02f, -7.72407502e-02f, 1.01886699e-02f, -7.76070952e-02f, 6.93586841e-02f,
  4.64711851e-03f, -7.61990398e-02f, -7.77613819e-02f, 9.97848660e-02f, -9.35762003e-02f, -6.55483920e-03f, 5.40965609e-02f, -2.18555089e-02f, 3.92197557e-02f, 3.19151059e-02f,
  1.10937571e-02f, -2.24158019e-02f, 8.94792452e-02f, 5.85687980e-02f, 1.16974816e-01f, -5.23677506e-02f, -7.95814767e-02f, 2.85245199e-02f, 1.36831226e-02f, -6.94421381e-02f,
  1.07295811e-01f, -7.36218691e-02f, 3.23218405e-02f, 2.56612245e-02f, 3.56586953e-03f, -1.50071355e-02f, -9.19268932e-03f, 6.37034997e-02f, 8.14997032e-02f, -5.93749108e-04f,
  -6.21531792e-02f, -5.34773804e-02f, 5.62649667e-02f, -9.65881348e-02f, 7.92039186e-02f, -1.04833050e-02f, -6.10391870e-02f, -1.05174584e-02f, 9.66885984e-02f, -4.06970643e-02f,
  -8.97019058e-02f, 4.19144295e-02f, 3.66146415e-02f, 1.44007932e-02f, -3.42945904e-02f, 9.25707817e-02f, -3.21661830e-02f, -2.49721650e-02f, -2.46409886e-02f, -1.65132433e-02f,
  -3.34983654e-02f, 5.82006201e-02f, 5.34759797e-02f, -3.85210775e-02f, 3.79886255e-02f, -3.26934382e-02f, -9.15811285e-02f, -5.52105717e-02f, -3.65241915e-02f, -4.83504012e-02f,
  5.57022132e-02f, 6.16668537e-02f, 1.99725553e-02f, -3.47954668e-02f, -8.19484740e-02f, 5.77947125e-02f, -9.22633614e-03f, 3.75737213e-02f, 6.38661757e-02f, -1.49677675e-02f,
  6.08217530e-02f, -2.39389930e-02f, 1.82360671e-02f, -8.47958326e-02f, 8.81644189e-02f, 5.49683124e-02f, 6.43628761e-02f, 7.67884925e-02f, -2.50114221e-02f, -6.01611957e-02f,
  -2.80128390e-01f, 8.84818062e-02f, -3.27617228e-01f, -2.08045468e-01f, 6.22190386e-02f, -2.88096815e-01f, -2.05218494e-01f, -5.22153564e-02f, -5.37196584e-02f, 1.77492857e-01f,
  7.88945779e-02f, -1.07945636e-01f, 1.65562198e-01f, -2.14959815e-01f, -3.85711372e-01f, -2.33104546e-02f, -3.70211869e-01f, -1.56250924e-01f, 5.77300787e-02f, -1.13024965e-01f,
  -1.63563713e-01f, -1.03337616e-01f, -2.66970187e-01f, 1.52614996e-01f, -1.57151833e-01f, -1.20159509e-02f, 1.86878607e-01f, 1.47241265e-01f, -1.70895830e-01f, -2.40304675e-02f,
  -1.19038604e-01f, 2.07617637e-02f, 3.47142331e-02f, -3.15795168e-02f, -1.37204528e-01f, -1.10300094e-01f, -2.81918310e-02f, 1.85214039e-02f, -5.89055829e-02f, -9.77522284e-02f,
  -7.40494579e-02f, 6.50416911e-02f, 2.81495461e-03f, 6.59868270e-02f, -4.80045564e-02f, 6.36590570e-02f, -8.72957408e-02f, -1.35889035e-02f, -1.04234265e-02f, -6.55748993e-02f,
  -6.72594309e-02f, -1.06835648e-01f, -3.69492583e-02f, -7.15773180e-02f, -3.43147777e-02f, 2.52309488e-03f, -6.11640252e-02f, 5.19143865e-02f, -2.41816975e-02f, -3.52646112e-02f,
  1.80446508e-03f, 2.28350777e-02f, -1.90840638e-03f, 4.08473611e-02f, -7.53891543e-02f, 7.17331842e-02f, 4.78248158e-03f, 4.18332918e-03f, 4.63184677e-02f, 4.75747176e-02f,
  -3.94317023e-02f, 4.77997884e-02f, 4.49705236e-02f, -1.86488405e-02f, -1.29982345e-02f, 5.92568628e-02f, 2.66281888e-02f, 5.51773934e-03f, -6.50251210e-02f, -5.61972223e-02f,
  6.53791875e-02f, 1.10454457e-02f, 8.35865457e-03f, 3.25790956e-03f, -1.46600809e-02f, 8.44189599e-02f, -8.72771908e-03f, -6.19501865e-04f, -1.06555242e-02f, -1.98324770e-02f,
  -1.16178459e-02f, -5.07877581e-02f, -5.61380293e-03f, 6.64981008e-02f, -4.66921888e-02f, 1.73374638e-02f, 1.18932668e-02f, -2.51486730e-02f, -4.34808694e-02f, 8.26191250e-03f,
  2.35332623e-02f, -4.61861081e-02f, -8.32181796e-02f, 3.79935205e-02f, -6.80188835e-02f, -6.86917603e-02f, -4.84213047e-03f, 5.46928821e-03f, -7.23964646e-02f, 2.14749444e-02f,
  2.17512790e-02f, 5.88692501e-02f, -1.59197412e-02f, -7.15066213e-04f, -3.34193520e-02f, 6.91626072e-02f, -2.95960773e-02f, -8.61006696e-03f, 3.16962935e-02f, 7.26131201e-02f,
  1.28127903e-01f, -3.21447738e-02f, -2.01683655e-01f, 2.35415045e-02f, 6.77559078e-02f, 7.60389268e-02f, -4.66689952e-02f, -6.64011249e-03f, -1.40460402e-01f, -7.17848074e-03f,
  -1.36739369e-02f, 3.82901914e-02f, -6.86061382e-02f, 2.27595896e-01f, 2.02751577e-01f, -1.06932484e-01f, 1.95031926e-01f, 3.69030163e-02f, -3.35950591e-02f, 1.09954648e-01f,
  -3.73868421e-02f, 2.50996679e-01f, 2.01992262e-02f, 1.40697792e-01f, 6.81004897e-02f, 3.06113958e-02f, 5.04500121e-02f, -6.59934133e-02f, 1.54540002e-01f, 1.19317636e-01f,
  5.22786286e-03f, -1.93271935e-02f, -6.10699020e-02f, 2.15414073e-02f, -3.16424742e-02f, 6.64122254e-02f, 7.98561350e-02f, -7.89032355e-02f, -1.19879085e-03f, -4.70832102e-02f,
  -4.62735593e-02f, 9.52933058e-02f, 1.05823442e-01f, -6.28243992e-03f, -4.22807634e-02f, -8.51253942e-02f, -4.79141958e-02f, -2.40324205e-03f, -4.37538996e-02f, 5.27640954e-02f,
  -7.56257251e-02f, 3.26292478e-02f, 6.86904509e-03f, -4.17268500e-02f, -9.93696600e-02f, 6.96989074e-02f, 3.97540219e-02f, 5.63429557e-02f, 2.55505517e-02f, 6.62067682e-02f,
  3.34676914e-02f, -4.34870869e-02f, 8.24852884e-02f, 6.71096072e-02f, 2.10752767e-02f, -3.38789783e-02f, 2.01599207e-02f, 3.12689506e-02f, 6.93624839e-02f, -4.94820550e-02f,
  1.88235436e-02f, -6.49604127e-02f, 6.31012395e-02f, -3.16498764e-02f, 1.03365295e-02f, -3.79645936e-02f, -5.25252260e-02f, -6.34358358e-03f, -4.31420542e-02f, 1.26850922e-02f,
  7.62155652e-02f, 4.07534502e-02f, 1.90517474e-02f, -1.11806076e-02f, 6.67099282e-02f, -3.84203121e-02f, 4.53068800e-02f, -1.57235153e-02f, 2.54793204e-02f, -1.77873932e-02f,
  8.30801725e-02f, -8.41673557e-03f, 3.05682165e-03f, 3.35752741e-02f, -1.09319098e-01f, 9.62988883e-02f, 5.36191612e-02f, 3.02830897e-02f, -2.66914517e-02f, 4.75405902e-02f,
  -3.22305784e-02f, 4.11435254e-02f, -4.56858315e-02f, 3.17098573e-02f, -2.05777027e-02f, -1.32463221e-02f, -2.22827662e-02f, 1.85766183e-02f, 1.09939881e-01f, 1.43505512e-02f,
  -4.99506146e-02f, -6.03523143e-02f, 4.70638387e-02f, -1.06126191e-02f, 2.89831720e-02f, -5.85399456e-02f, -4.13677283e-03f, -6.33717701e-02f, 3.12266145e-02f, -1.21217873e-02f,
  1.05039313e-01f, -9.89155099e-02f, -1.19217731e-01f, 9.61581916e-02f, 1.19225889e-01f, 1.58716917e-01f, -5.82237579e-02f, -3.69212590e-02f, 1.07823558e-01f, -1.57946572e-02f,
  -8.90459642e-02f, -1.54689820e-02f, -1.61979884e-01f, 6.27633110e-02f, 1.83839649e-01f, -3.40630487e-02f, 1.43365517e-01f, 4.88716327e-02f, -4.30457778e-02f, -5.11090048e-02f,
  -4.09812331e-02f, 1.18867204e-01f, -1.90389007e-01f, 3.82082425e-02f, 4.88591902e-02f, -2.20625959e-02f, -1.07548624e-01f, -8.30501840e-02f, -5.31770177e-02f, 7.68158734e-02f,
  -6.17026398e-03f, -1.80222616e-02f, -7.85028487e-02f, -8.23478308e-03f, -7.77718797e-02f, 6.43259957e-02f, -8.56358707e-02f, 8.81712958e-02f, -6.12257905e-02f, -7.30004581e-03f,
  3.50731090e-02f, 3.30156386e-02f, -2.54292390e-03f, 4.96961027e-02f, -6.97308918e-03f, 3.74887772e-02f, 5.08559356e-03f, -9.12762731e-02f, -1.77535173e-02f, 1.22354981e-02f,
  -5.43542504e-02f, -7.47774541e-02f, 4.30055335e-03f, 4.24423963e-02f, -1.03800893e-02f, 3.94124910e-03f, -2.48860121e-02f, 1.25046680e-02f, -4.45625223e-02f, 1.89793184e-02f,
  2.61287391e-02f, 8.13890025e-02f, 4.23143320e-02f, 3.47126536e-02f, 1.48994327e-02f, 6.87338188e-02f, -7.70348385e-02f, -1.73826888e-02f, -4.54653092e-02f, -4.64227945e-02f,
  5.74111082e-02f, -8.18439573e-02f, -3.45614292e-02f, -1.92917723e-04f, -7.81057552e-02f, 6.06063083e-02f, -6.01904839e-02f, 5.07804118e-02f, 1.50270723e-02f, -8.25661980e-03f,
  -2.86839027e-02f, -3.89106981e-02f, -5.61991073e-02f, -6.83265924e-02f, 4.32276987e-02f, -6.49051592e-02f, 5.43687232e-02f, -6.70257434e-02f, -3.14727724e-02f, 5.69734685e-02f,
  3.13010849e-02f, 1.03448376e-01f, -3.11805261e-03f, 6.51482418e-02f, 6.02483898e-02f, -4.20384668e-02f, 4.78250980e-02f, -2.76050046e-02f, 2.08648536e-02f, 8.44857022e-02f,
  -5.20832725e-02f, -8.50533321e-02f, 7.86584392e-02f, 2.81931069e-02f, -3.52214426e-02f, 4.17804979e-02f, 6.98546460e-03f, 2.21999194e-02f, -1.68331265e-02f, -4.51057032e-02f,
  5.60423918e-03f, -4.26450856e-02f, -5.32925092e-02f, 3.07346061e-02f, -2.12419573e-02f, 7.27517158e-02f, 5.14181033e-02f, 1.02146994e-02f, 5.38269766e-02f, 6.53485805e-02f,
  1.11308508e-01f, -5.99723533e-02f, -1.05476283e-01f, 1.97775006e-01f, 1.60730705e-01f, -1.20730316e-02f, -6.61028251e-02f, 6.46574497e-02f, -1.24305397e-01f, -1.09194793e-01f,
  6.45304322e-02f, 3.20286676e-02f, -1.10091120e-01f, 1.58775896e-01f, 1.98385641e-01f, -2.11982116e-01f, 1.32960558e-01f, -1.11047504e-02f, 2.11147778e-02f, 1.44304916e-01f,
  1.12549014e-01f, 2.60216653e-01f, 1.13508090e-01f, 1.15007602e-01f, 8.61620530e-02f, 1.46805216e-02f, 2.45691575e-02f, -1.22992136e-01f, 1.80056348e-01f, 7.16786385e-02f,
  7.61821270e-02f, -5.81347421e-02f, -9.74000152e-03f, 3.13871317e-02f, -6.46635592e-02f, 4.22611833e-02f, -1.00761399e-01f, -1.25109532e-03f, 7.31707588e-02f, -5.62789477e-02f,
  -9.85384881e-02f, 3.25588696e-02f, 5.08202612e-02f, -8.07314739e-02f, 2.21938696e-02f, 7.07458109e-02f, -3.01316325e-02f, 3.90647128e-02f, 1.60267297e-02f, -3.69949527e-02f,
  -3.41993980e-02f, 5.13259321e-02f, 5.55037372e-02f, -2.48557655e-03f, 3.97130847e-02f, -5.20522110e-02f, 4.92049642e-02f, 2.39013359e-02f, -4.09914218e-02f, 1.14067815e-01f,
  -1.27470894e-02f, -2.50181872e-02f, 3.53950523e-02f, -1.89682506e-02f, 8.40703547e-02f, -2.68025883e-03f, 3.21435928e-02f, 4.42656465e-02f, -7.45986253e-02f, 2.12785434e-02f,
  -2.96637341e-02f, 9.08903554e-02f, 8.15075263e-02f, 3.38210985e-02f, 6.79891184e-02f, -4.12155464e-02f, -6.37403354e-02f, -4.42593619e-02f, -8.32073763e-02f, -8.79227668e-02f,
  -1.61612742e-02f, 4.67062779e-02f, -3.44727375e-02f, -2.65719593e-02f, 7.31590837e-02f, -1.53784482e-02f, 6.57806769e-02f, 1.21790040e-02f, 4.48638164e-02f, -9.68186483e-02f,
  -6.32892475e-02f, 1.69767011e-02f, -5.69377355e-02f, 5.10069206e-02f, 6.48092106e-02f, -1.53192943e-02f, -8.19310471e-02f, 5.19231595e-02f, 5.58673516e-02f, 8.12573135e-02f,
  -5.90816513e-03f, -7.92309195e-02f, -3.55602987e-02f, -9.48847504e-04f, 3.90513055e-03f, 4.60695336e-03f, -2.14693993e-02f, 6.81891479e-03f, -7.27824867e-02f, 1.82195625e-03f,
  -3.82155217e-02f, -9.44584087e-02f, -2.86662374e-02f, -2.95650307e-02f, 3.36362496e-02f, 8.45861807e-03f, -4.37357500e-02f, 5.45135327e-02f, -9.35033485e-02f, -9.88314226e-02f,
  2.84430683e-02f, 7.78487548e-02f, 7.00386837e-02f, 1.33641645e-01f, -9.49735269e-02f, -1.66482627e-01f, -1.44851148e-01f, 9.23716351e-02f, 2.35651955e-02f, -9.83035043e-02f,
  5.02172559e-02f, -5.98113947e-02f, -1.07650325e-01f, 2.31428631e-02f, -4.19205800e-02f, -2.77871136e-02f, 7.58372694e-02f, -4.96430919e-02f, 4.94363867e-02f, 1.09691136e-01f,
  3.26061361e-02f, -7.96519518e-02f, 1.04716457e-01f, 7.96940699e-02f, 1.17292866e-01f, 1.11661844e-01f, 2.97742821e-02f, 3.35002579e-02f, 1.56535387e-01f, -1.27769355e-02f,
  -5.80531247e-02f, 8.10233410e-03f, -1.20923845e-02f, -6.08140677e-02f, -1.30626289e-02f, 1.07699580e-01f, -4.19627950e-02f, -5.29818013e-02f, 8.83917809e-02f, -4.42591012e-02f,
  7.97052681e-02f, 1.99316684e-02f, -7.43447840e-02f, 1.71751231e-02f, -2.76007261e-02f, -1.10594099e-02f, 5.75077720e-02f, 3.83574404e-02f, -1.00022800e-01f, 5.28683141e-02f,
  7.24577010e-02f, -7.28010908e-02f, -6.09249948e-03f, 7.77919292e-02f, -7.44374376e-03f, -9.48745385e-02f, -7.45022744e-02f, 7.31418207e-02f, 9.22272280e-02f, 9.40568000e-02f,
  7.64990412e-03f, -8.31134394e-02f, 5.15246354e-02f, 6.27230853e-02f, 5.19419499e-02f, -5.36130890e-02f, 4.30860557e-02f, 6.15646057e-02f, 6.68039173e-02f, 6.28360957e-02f,
  1.30958138e-02f, 7.07629547e-02f, -1.79247279e-02f, 6.41845018e-02f, 1.32830748e-02f, 3.81471105e-02f, 4.25212644e-02f, 3.67789045e-02f, -2.08897539e-03f, -7.09005212e-03f,
  -1.44401081e-02f, -3.00647058e-02f, -8.43705311e-02f, 5.53668961e-02f, -7.31618553e-02f, -5.98529764e-02f, 4.66450080e-02f, -5.84207885e-02f, 6.67269826e-02f, 8.78139883e-02f,
  9.23754796e-02f, 1.30992919e-01f, 4.02081870e-02f, -6.68507535e-03f, 2.64069848e-02f, 5.28138839e-02f, 3.27088684e-02f, -4.12754901e-02f, -1.10827880e-02f, 8.20865259e-02f,
  3.52881546e-03f, 7.33884797e-02f, -9.92099755e-03f, 7.70007521e-02f, 3.71931866e-02f, 8.34164470e-02f, -7.65282139e-02f, -2.45024893e-03f, -1.12181678e-02f, -4.13540900e-02f,
  1.23344973e-01f, -2.33581420e-02f, 7.40533248e-02f, -2.54286211e-02f, 5.39677069e-02f, -1.55811664e-02f, 4.14836966e-02f, 5.86545207e-02f, 5.59866130e-02f, -8.78175274e-02f,
  6.97243065e-02f, -1.41505182e-01f, -6.92333281e-02f, 2.18374640e-01f, 7.00678453e-02f, -1.82173267e-01f, -2.24252105e-01f, -4.74089235e-02f, -1.39674842e-01f, -1.36118427e-01f,
  -2.11339891e-02f, 1.57847434e-01f, -3.26249033e-01f, 1.37037799e-01f, 3.30348372e-01f, -1.60633311e-01f, 2.39340991e-01f, 7.96835497e-02f, -9.18543041e-02f, 1.00075565e-01f,
  1.28866106e-01f, 1.73477292e-01f, 2.01421410e-01f, 2.55144089e-01f, 8.74707699e-02f, 1.26486197e-01f, 2.78564423e-01f, -5.80454841e-02f, 2.57929564e-01f, 2.50328690e-01f,
  -7.88912643e-03f, -8.05825293e-02f, -4.95860213e-03f, 5.72253130e-02f, -9.07689333e-02f, -1.24104721e-02f, -8.07090551e-02f, 7.82686695e-02f, -1.28105795e-02f, -7.50123933e-02f,
  -4.82393280e-02f, 6.23463728e-02f, 1.20995985e-02f, 1.05779707e-01f, 5.38685061e-02f, -8.65570456e-03f, 7.37732500e-02f, 4.26122732e-02f, 3.51261580e-03f, 2.99451686e-02f,
  -4.58619148e-02f, 2.00837813e-02f, -3.47100534e-02f, -2.47278288e-02f, 5.32646738e-02f, -4.51295190e-02f, -7.08518550e-02f, -6.21918328e-02f, 5.20618483e-02f, -1.05619505e-02f,
  -6.33364767e-02f, 1.19552361e-02f, -1.07862055e-01f, -1.68132130e-02f, 2.41979156e-02f, -2.83714514e-02f, 5.87221384e-02f, -4.81182262e-02f, 3.67505625e-02f, -1.05811432e-02f,
  8.01419318e-02f, 3.48973647e-02f, -8.58078618e-03f, 6.22573718e-02f, -4.11712006e-02f, 2.94446182e-02f, 7.36656636e-02f, 6.11695275e-02f, 1.78902801e-02f, -1.11547010e-02f,
  -5.02247736e-03f, 4.35576076e-03f, -3.39500718e-02f, -3.67184617e-02f, -1.97372194e-02f, 3.98497991e-02f, -2.83747893e-02f, -6.36315197e-02f, -8.43553692e-02f, -5.87178022e-02f,
  4.56489697e-02f, 2.01038867e-02f, -3.64903621e-02f, -4.32017669e-02f, 4.13892306e-02f, -2.96848882e-02f, 1.41884387e-02f, -1.99182555e-02f, -2.43876036e-03f, -4.15194072e-02f,
  -2.17222665e-02f, 6.60680011e-02f, -1.12685990e-02f, 5.04691452e-02f, 7.49828964e-02f, 1.26072979e-02f, -3.94050553e-02f, 5.01355752e-02f, 5.88709302e-03f, -6.48712693e-03f,
  6.41329214e-02f, 2.11390350e-02f, -4.01322581e-02f, 5.89600168e-02f, 6.84003159e-02f, -9.25664138e-03f, -4.72882055e-02f, -4.32361988e-03f, 3.22863795e-02f, 5.04239202e-02f,
  1.91390425e-01f, 3.37354988e-01f, 3.26284200e-01f, 1.24625087e-01f, -2.98510361e-02f, -1.74424410e-01f, -1.09048761e-01f, -1.07666133e-02f, 1.98197082e-01f, 1.08845249e-01f,
  -1.68148801e-01f, 3.66766810e-01f, -9.70681310e-02f, 2.15776652e-01f, -2.86801070e-01f, -1.71107113e-01f, -1.53609797e-01f, -2.54079103e-02f, 4.20520939e-02f, 9.03357789e-02f,
  -4.94261011e-02f, -2.33413354e-01f, -3.84352207e-02f, -1.22724786e-01f, 8.39884579e-02f, 1.55148044e-01f, -2.32895955e-01f, -1.26333281e-01f, 1.02550216e-01f, -1.18238665e-01f,
  6.35772273e-02f, 1.07802212e-01f, 1.36711642e-01f, 1.32767946e-01f, 4.33791131e-02f, -6.84494227e-02f, -2.62867995e-02f, 3.02868839e-02f, -3.92961428e-02f, 1.25018835e-01f,
  2.21839920e-02f, -5.52602997e-03f, 5.99139966e-02f, -5.88118955e-02f, 4.75507565e-02f, 5.00415713e-02f, 5.05009526e-03f, 5.49328979e-03f, 1.14391953e-01f, 4.01497297e-02f,
  1.23712562e-01f, 1.22311532e-01f, 8.63712057e-02f, -2.94009242e-02f, 8.57075304e-02f, -1.76253468e-02f, 6.11177087e-03f, -4.72394712e-02f, 8.11267719e-02f, 6.14187531e-02f,
  3.98792215e-02f, -7.06413239e-02f, -6.98243175e-03f, 1.12143874e-01f, 2.83162426e-02f, 1.81786213e-02f, -1.51385227e-02f, 1.56382062e-02f, 5.54842763e-02f, -3.66935059e-02f,
  -3.85132059e-02f, 3.98517773e-03f, -2.01054197e-02f, -6.02324400e-03f, -8.93747993e-03f, 8.27944949e-02f, 3.97874275e-03f, -3.32121216e-02f, -5.48160560e-02f, -2.57828943e-02f,
  -6.14433773e-02f, -6.17948063e-02f, 4.99137826e-02f, -8.30619559e-02f, 4.04469855e-03f, -2.63096727e-02f, -9.06970538e-03f, 1.03547305e-01f, -7.53515139e-02f, -2.38210093e-02f,
  -1.72120139e-01f, -9.96880904e-02f, -2.44581909e-03f, -4.20866869e-02f, 1.05832946e-02f, -4.85183783e-02f, 3.33833583e-02f, 7.75786117e-02f, -1.57109238e-02f, -8.82451907e-02f,
  -3.47513147e-02f, 4.91577983e-02f, -5.44467457e-02f, 2.08820999e-02f, -7.98001513e-02f, 3.16785611e-02f, 1.48511808e-02f, -9.01994016e-03f, 2.44868291e-03f, -5.80336452e-02f,
  -1.95524022e-02f, -6.81556901e-03f, -1.21061094e-02f, -4.24653366e-02f, -4.60824966e-02f, 4.50098142e-02f, 7.10295290e-02f, 8.78000110e-02f, -3.93605493e-02f, 1.68800447e-02f,
  -3.39738838e-02f, -9.97117534e-02f, -6.43951744e-02f, 7.42863566e-02f, 1.11670040e-01f, 3.90256234e-02f, -7.92014450e-02f, 3.78364883e-02f, 1.62468050e-02f, -2.07599550e-02f,
  -2.36153677e-02f, 2.91707423e-02f, 3.27439196e-02f, -1.73839293e-02f, -5.81405610e-02f, 1.53921163e-02f, 3.76754324e-03f, -2.44582277e-02f, 9.42679495e-02f, -5.64345904e-02f,
  1.09690197e-01f, -1.18898076e-03f, 1.29962591e-02f, -3.51551287e-02f, -7.05163404e-02f, 7.75181502e-02f, -1.19538228e-04f, -9.59563181e-02f, 6.21099360e-02f, 7.17680082e-02f,
  -5.37201576e-02f, -9.25847217e-02f, -1.40869422e-02f, -8.41777585e-03f, -5.89715280e-02f, -1.20575391e-02f, -4.85634096e-02f, -6.75419345e-02f, -1.46432379e-02f, 2.88211815e-02f,
  -1.44674517e-02f, 4.09700163e-02f, -7.99218789e-02f, -1.67714525e-02f, 1.64369065e-02f, 3.70579697e-02f, 6.51200637e-02f, -5.13947122e-02f, -1.58435516e-02f, 4.67112325e-02f,
  -8.31257328e-02f, -4.29740315e-03f, -5.53854257e-02f, 2.34209877e-02f, 3.96901555e-02f, -3.04114763e-02f, 8.14619511e-02f, 2.10785354e-03f, 3.24226283e-02f, 4.58859876e-02f,
  -8.95917118e-02f, -6.12864122e-02f, -3.94657776e-02f, 5.38045652e-02f, -7.20662475e-02f, -2.68469695e-02f, 2.96060294e-02f, 9.01183262e-02f, 1.41644180e-02f, 3.66413295e-02f,
  8.07307586e-02f, -5.74932285e-02f, 5.13983369e-02f, 9.00953487e-02f, 6.56423420e-02f, 7.32818097e-02f, 3.11407652e-02f, -4.59385151e-03f, -6.62289653e-03f, -1.01529369e-02f,
  5.39857037e-02f, 4.02368046e-02f, -9.79505032e-02f, 4.50102985e-02f, 5.74906170e-03f, 2.60973964e-02f, -2.60090791e-02f, 7.98493996e-02f, 2.20364816e-02f, 9.30349454e-02f,
  -7.43411630e-02f, -3.70285138e-02f, 3.17003988e-02f, 5.45812920e-02f, -8.11904520e-02f, -8.84020105e-02f, 7.51758739e-02f, 7.73143321e-02f, 4.68169712e-02f, 9.26221609e-02f,
  9.42537654e-03f, -4.81080078e-02f, 9.07669663e-02f, 3.78458910e-02f, -1.93020646e-02f, 9.55502093e-02f, -1.09923938e-02f, 4.00867909e-02f, 5.16331829e-02f, -2.22828519e-02f,
  4.34945687e-04f, 5.99759072e-02f, -3.71426530e-02f, 7.48354569e-02f, 9.11747590e-02f, 8.22553486e-02f, 5.51404394e-02f, -2.13583633e-02f, -4.48009036e-02f, 7.47630149e-02f,
  -1.98318198e-01f, -3.54839861e-02f, 4.18835357e-02f, -1.13584213e-01f, 3.04481220e-02f, 9.49465036e-02f, -1.17262743e-01f, 1.82132050e-02f, -1.33648738e-01f, -3.14817764e-02f,
  1.59697812e-02f, -1.29637539e-01f, 2.29763780e-02f, -1.35187864e-01f, 5.00777029e-02f, -8.83168280e-02f, -3.31139155e-02f, -6.06095381e-02f, -3.70107070e-02f, -3.11587267e-02f,
  -1.15404099e-01f, -1.39602879e-02f, -8.40096846e-02f, 1.40053451e-01f, -3.62585150e-02f, 8.40064138e-02f, -1.54990256e-02f, 6.90328702e-02f, -1.27391461e-02f, -2.72848923e-02f,
  7.70019516e-02f, -1.25593200e-01f, -2.90177148e-02f, -1.74378958e-02f, 5.33783957e-02f, 6.07739538e-02f, 4.35099145e-03f, 9.33356658e-02f, -3.05528399e-02f, -6.40915185e-02f,
  -2.56326655e-03f, -3.76822203e-02f, 4.16508131e-02f, 5.90230264e-02f, 8.46623257e-03f, 1.07912071e-01f, -6.87102899e-02f, -3.56120951e-02f, 2.37816107e-02f, -3.40410620e-02f,
  3.55778821e-02f, -2.56115198e-02f, -6.53999373e-02f, -7.42534325e-02f, 6.07162192e-02f, 7.03546777e-02f, 3.93434847e-03f, -6.37843311e-02f, 7.99249485e-02f, 8.01338553e-02f,
  -3.79487313e-02f, -8.44173133e-02f, -4.10614833e-02f, 6.97589591e-02f, 6.39451072e-02f, 3.90687138e-02f, -8.07515159e-02f, 4.83654998e-02f, -3.28844078e-02f, -5.62975369e-02f,
  -4.19043712e-02f, -1.24414377e-02f, -1.00662094e-02f, -1.76546201e-02f, -6.30321726e-02f, -1.71436388e-02f, 6.62537366e-02f, -6.30322797e-03f, -2.04992294e-02f, 4.70268354e-02f,
  1.03612775e-02f, -6.71707839e-02f, -6.90870807e-02f, 3.00967810e-03f, -5.55633642e-02f, -9.22098849e-03f, 4.84964624e-02f, 5.39139612e-03f, 2.54481044e-02f, -5.78613533e-03f,
  1.05108824e-02f, -5.49541041e-02f, 9.34331715e-02f, 7.37911016e-02f, 1.03576787e-01f, -1.93703882e-02f, 6.92197010e-02f, -7.94279873e-02f, 2.19618008e-02f, 2.95350654e-03f,
  7.51226544e-02f, 9.27307531e-02f, 1.77664943e-02f, 2.01843176e-02f, 6.20925054e-02f, -5.34623340e-02f, 3.01627871e-02f, 7.40394741e-02f, 8.14232752e-02f, 9.56723467e-02f,
  -3.21957357e-02f, -6.75023422e-02f, -5.14104851e-02f, -9.46505517e-02f, -5.88769093e-02f, -5.11077419e-02f, -7.89788589e-02f, -2.00347528e-02f, 1.77575033e-02f, 6.21565357e-02f,
  -7.62658333e-03f, 2.74485219e-02f, 1.24153029e-02f, -4.52101380e-02f, 1.27964973e-01f, -1.31565528e-02f, -7.98629522e-02f, -8.44458491e-03f, 1.04419217e-01f, -1.04738079e-01f,
  -7.22887516e-02f, -1.31966189e-01f, -1.32196769e-01f, -1.94823910e-02f, 3.08219250e-02f, -7.18488470e-02f, 9.69237089e-02f, -2.72704940e-03f, -5.01648001e-02f, -7.47214407e-02f,
  -1.58753004e-02f, 2.64942516e-02f, -1.26381010e-01f, 6.13137856e-02f, -1.03491377e-02f, -3.70480381e-02f, 5.70985265e-02f, 2.33151615e-02f, 3.73994187e-03f, 2.24072151e-02f,
  2.30884403e-02f, 8.09584334e-02f, -7.46168569e-02f, 6.44448027e-02f, 7.93127939e-02f, 4.21806313e-02f, -7.94252828e-02f, 5.54572046e-03f, 4.21672640e-03f, -3.07441372e-02f,
  -6.51052892e-02f, -8.03630427e-02f, 4.68845628e-02f, -7.34616593e-02f, 4.99936566e-02f, -8.74534696e-02f, -5.19961566e-02f, 2.06349115e-03f, -4.33507860e-02f, -4.51467047e-03f,
  3.87863927e-02f, -6.16093501e-02f, -2.40601343e-03f, -1.32723385e-02f, -4.98581156e-02f, 9.00459196e-03f, -1.03193097e-01f, -1.51602179e-02f, -7.01783299e-02f, -7.01791346e-02f,
  1.98102314e-02f, -2.55855396e-02f, -2.86486093e-02f, -6.23899624e-02f, 2.00514123e-02f, 5.79344258e-02f, -6.25219941e-02f, -9.43936706e-02f, 8.08808655e-02f, 6.96790591e-02f,
  -3.07948105e-02f, -5.21257930e-02f, -2.77086813e-02f, -7.50179887e-02f, -5.97719550e-02f, 2.22074296e-02f, -6.88738003e-02f, -8.36930275e-02f, -4.13386151e-02f, 6.26842305e-03f,
  2.01643147e-02f, -7.63143599e-02f, 1.17439535e-02f, -1.65770538e-02f, -3.09087411e-02f, -6.51308298e-02f, -2.38141585e-02f, -4.12265249e-02f, -6.20382577e-02f, 5.11583649e-02f,
  -4.25322466e-02f, 4.49342243e-02f, 8.87907520e-02f, 7.81306252e-02f, -2.15021558e-02f, 5.57850152e-02f, 6.46416396e-02f, 5.19363657e-02f, 7.86368921e-02f, -6.75018132e-02f,
  -2.11016205e-03f, 1.43342726e-02f, 7.45071471e-02f, -8.37504342e-02f, 3.31159942e-02f, -8.63766000e-02f, 6.32001273e-03f, -7.20163807e-02f, 1.10361241e-01f, -1.77525356e-03f,
  -8.44710544e-02f, -4.75411862e-02f, -6.75722882e-02f, -5.78395873e-02f, -4.78616543e-03f, 6.72684656e-03f, 6.43875748e-02f, -2.74254642e-02f, -6.10051006e-02f, 5.60853593e-02f,
  9.30479355e-03f, 4.85511385e-02f, -6.57457262e-02f, -3.55631150e-02f, 6.42803460e-02f, -1.11468442e-01f, -4.47106175e-02f, -5.38383573e-02f, -1.97592363e-01f, 1.15212299e-01f,
  -6.66666999e-02f, 1.09530583e-01f, -5.48029952e-02f, -1.94203723e-02f, -1.55106470e-01f, -2.43924081e-01f, -5.55718429e-02f, 5.65296821e-02f, -5.50555028e-02f, 4.02665883e-02f,
  -5.96777685e-02f, -6.77007735e-02f, 4.54664417e-02f, 7.64684286e-03f, 8.54670852e-02f, 2.02565044e-01f, 2.68417537e-01f, -5.02799731e-03f, 9.66826603e-02f, 6.69151694e-02f,
  -7.87723437e-02f, -2.32266262e-03f, -9.15719569e-03f, -6.37752339e-02f, 6.87365010e-02f, 1.12760000e-01f, 9.64304358e-02f, 6.60829991e-02f, -4.29630801e-02f, -5.54657914e-02f,
  3.45865376e-02f, -3.71097215e-02f, -1.04562864e-02f, -6.09112531e-02f, 5.16890287e-02f, 6.51992112e-02f, -5.50543219e-02f, -2.05620844e-02f, 5.05359191e-03f, -7.38853589e-02f,
  -6.42028898e-02f, 7.83442780e-02f, 4.21758778e-02f, 2.95749400e-02f, -6.68271706e-02f, -3.66117023e-02f, 2.57063489e-02f, 5.63590899e-02f, 9.69241783e-02f, -1.16514890e-02f,
  6.55168295e-02f, 1.00075729e-01f, -4.43897620e-02f, -1.23292999e-02f, -3.69870439e-02f, -1.75071170e-03f, -5.08683957e-02f, 3.93839851e-02f, 1.33674676e-02f, 4.82256990e-03f,
  1.01397663e-01f, -1.48287753e-03f, -1.97267178e-02f, 1.73502192e-02f, -2.35795733e-02f, 1.82755757e-02f, -3.61729637e-02f, 6.42112419e-02f, -1.77686121e-02f, 7.03400886e-03f,
  1.66185405e-02f, -7.71810636e-02f, 5.04294150e-02f, 7.02280626e-02f, -1.84292886e-02f, -7.99614191e-02f, -6.30941018e-02f, 1.68429855e-02f, -5.11944331e-02f, -2.09731720e-02f,
  -3.57617368e-03f, 1.00577876e-01f, -3.70489992e-02f, 5.59054036e-03f, 3.65593694e-02f, 2.88118571e-02f, 2.21460555e-02f, 1.81442837e-03f, 1.77638587e-02f, -6.04458451e-02f,
  2.21531559e-02f, -6.35710964e-03f, 6.65055066e-02f, 4.38941084e-02f, -4.44095507e-02f, -6.72543496e-02f, 5.00298105e-02f, 8.39652121e-02f, 9.20698568e-02f, 6.66110441e-02f,
  5.61953671e-02f, 9.45160612e-02f, 9.04260948e-02f, 4.99551184e-02f, 9.41894297e-03f, 7.86279701e-03f, -3.95619236e-02f, 9.84291434e-02f, 4.40029465e-02f, 3.99460755e-02f,
  2.84326941e-01f, -1.45295143e-01f, -7.34855945e-04f, 2.20033005e-01f, 7.99866095e-02f, -5.68590760e-02f, 8.69654790e-02f, 3.82616855e-02f, 1.79046318e-02f, -9.54399705e-02f,
  8.45356137e-02f, -1.76616274e-02f, -1.61712512e-01f, -9.55193024e-03f, 1.49620190e-01f, -1.44046709e-01f, 1.44028932e-01f, 3.86177413e-02f, 8.74144733e-02f, 1.18282862e-01f,
  1.35711744e-01f, -2.98318285e-02f, 2.03967728e-02f, -7.13038892e-02f, 9.84495804e-02f, 6.01282194e-02f, 4.14855890e-02f, -9.29069147e-02f, -7.24207014e-02f, -7.17865750e-02f,
  -3.07372436e-02f, 2.22104155e-02f, 8.64173844e-02f, -8.95008594e-02f, 7.20962361e-02f, 7.05878362e-02f, 5.38563915e-02f, 8.98213219e-03f, 6.51848987e-02f, 2.53098905e-02f,
  4.08248231e-02f, 3.44652608e-02f, -3.53458524e-02f, 1.91877922e-03f, 2.91274115e-02f, -1.91485044e-02f, 4.65879440e-02f, -6.97833374e-02f, 3.16469222e-02f, 1.45752523e-02f,
  -1.00156805e-03f, 4.95916046e-02f, 3.57577130e-02f, -5.21957278e-02f, -1.87445688e-03f, 5.30536920e-02f, -6.51037842e-02f, -4.06241193e-02f, -7.04486221e-02f, 6.44872664e-04f,
  2.25771181e-02f, -6.45172875e-03f, -3.34907621e-02f, 2.93500945e-02f, -4.86301770e-03f, 3.21444422e-02f, 2.13923436e-02f, 4.59466763e-02f, 4.10465077e-02f, 2.24726517e-02f,
  7.94690549e-02f, -9.96339973e-03f, -4.35403883e-02f, -5.50750569e-02f, 7.45620281e-02f, -1.45316981e-02f, 1.85229667e-02f, -8.76132771e-02f, 7.56044164e-02f, 6.09561540e-02f,
  4.96906415e-02f, 1.06854886e-02f, 7.38056526e-02f, 3.26695368e-02f, -3.95599147e-03f, 8.87055844e-02f, 1.96486432e-03f, -2.73272730e-02f, 5.77701591e-02f, -1.73943229e-02f,
  -1.24862053e-01f, -2.82981154e-02f, -2.46309489e-02f, -1.00159019e-01f, -8.83584023e-02f, -6.85397768e-03f, 3.98976579e-02f, -4.17768732e-02f, -7.61572272e-02f, 2.41679896e-04f,
  -8.74840766e-02f, -9.23259556e-03f, -6.40116259e-02f, 1.69174802e-02f, -6.80626854e-02f, -2.68513579e-02f, 3.41930613e-02f, -1.71108339e-02f, 9.74980146e-02f, -5.33041246e-02f,
  -7.11393952e-02f, -8.63025039e-02f, -8.39812756e-02f, -3.77565324e-02f, 4.70479876e-02f, 1.59043614e-02f, 4.01604399e-02f, -9.42797214e-02f, -1.12573706e-01f, 4.06416580e-02f,
  1.47946060e-01f, -7.63637796e-02f, 7.43466988e-02f, 9.12984312e-02f, -1.17703155e-01f, -3.25073749e-01f, -3.10459107e-01f, 5.28202653e-02f, -8.14401731e-02f, -9.35419351e-02f,
  1.14984028e-01f, -3.53173576e-02f, 4.05625850e-02f, 7.38454238e-02f, 3.61956768e-02f, -2.95856688e-02f, -4.24994901e-02f, -8.87055844e-02f, 9.39991996e-02f, 3.15721147e-02f,
  1.99605301e-01f, 1.84439451e-01f, 2.07503751e-01f, 1.43830836e-01f, 8.08716714e-02f, 1.61821604e-01f, 2.24354506e-01f, 4.79199477e-02f, 7.75806084e-02f, 3.53135243e-02f,
  -1.29745618e-01f, 1.75269544e-01f, 9.53689683e-03f, -4.22779322e-02f, 2.05145255e-02f, -1.48981839e-01f, -1.15068816e-01f, -5.86029142e-02f, -1.50906211e-02f, 1.17017142e-02f,
  -5.08901179e-02f, 2.60104518e-02f, -2.47175079e-02f, -4.63458113e-02f, -6.57066181e-02f, 5.07978536e-02f, -2.27482747e-02f, -4.74971682e-02f, 1.47502739e-02f, 3.21579315e-02f,
  5.93646131e-02f, -4.58187796e-02f, -1.02850953e-02f, -8.61309692e-02f, 4.05968241e-02f, 5.12313172e-02f, -3.72785553e-02f, 2.21686102e-02f, -4.10664715e-02f, 4.18679044e-02f,
  4.74791005e-02f, 2.19757222e-02f, -6.15980290e-02f, 4.23715040e-02f, -3.40214954e-03f, -2.46938840e-02f, 1.97086893e-02f, 1.52981449e-02f, 3.01060956e-02f, -6.30832016e-02f,
  1.14212474e-02f, 7.12404922e-02f, -5.13098314e-02f, 1.52294477e-02f, -3.32330763e-02f, -4.38672490e-02f, -6.70311565e-04f, 4.75896634e-02f, 5.60302325e-02f, 6.11706637e-02f,
  -5.42065986e-02f, 3.97819728e-02f, -4.46344353e-02f, 2.87921987e-02f, -2.30455622e-02f, 7.68676475e-02f, 1.23817839e-01f, 6.92523196e-02f, 1.77640636e-02f, 4.56705615e-02f,
  7.93434493e-03f, 2.71985978e-01f, 7.51185580e-04f, -1.08956387e-02f, 3.12643871e-02f, -5.80309182e-02f, 6.09650165e-02f, 6.38595819e-02f, 6.10903313e-04f, -3.71288508e-02f,
  7.80312419e-02f, -1.14516392e-01f, 5.89857884e-02f, -7.22501427e-02f, -3.26866135e-02f, -5.60434237e-02f, 8.47269371e-02f, -5.00784554e-02f, -2.13818345e-02f, 6.17304780e-02f,
  -2.49764752e-02f, -1.28577277e-01f, -4.19014804e-02f, -4.90703918e-02f, -6.56134123e-03f, 3.08282761e-05f, -8.25170204e-02f, 2.66362894e-02f, 3.48742753e-02f, 3.61211225e-02f,
  4.21465151e-02f, -3.80842239e-02f, -2.36143675e-02f, -1.04428306e-01f, -1.27783716e-01f, 3.92016768e-02f, -3.55925597e-02f, 1.32571114e-02f, -2.56996844e-02f, 5.50252646e-02f,
  -1.08502775e-01f, 6.68698698e-02f, 1.96128967e-03f, 3.48998830e-02f, 1.28997684e-01f, 6.01216406e-02f, 3.08720730e-02f, 5.37252761e-02f, -9.26629156e-02f, -6.70433864e-02f,
  -2.08701175e-02f, 4.38189171e-02f, 1.07616574e-01f, -6.04483299e-02f, -9.85393673e-02f, -7.56786689e-02f, 1.17703695e-02f, 2.01892499e-02f, -6.83086440e-02f, -8.51463825e-02f,
  -3.51063721e-02f, -1.40865177e-01f, -1.81139838e-02f, 1.83920097e-02f, -6.69379681e-02f, 3.45740691e-02f, 7.41471276e-02f, 4.37640445e-03f, -5.85420057e-02f, -7.96104781e-03f,
  4.67340127e-02f, -8.79730806e-02f, -8.50950778e-02f, 6.13683723e-02f, 1.05245747e-02f, -9.02037248e-02f, 1.03120469e-02f, -5.68878241e-02f, -2.37824116e-02f, 3.27706374e-02f,
  3.80339995e-02f, -5.55143096e-02f, 5.38346451e-03f, 6.55466318e-02f, -5.82556911e-02f, -1.16948392e-02f, -2.73742210e-02f, -3.80188785e-02f, -6.51905611e-02f, -1.02477714e-01f,
  -8.02974403e-02f, -3.10119521e-02f, 3.78938392e-03f, 8.57315436e-02f, -9.62051824e-02f, -5.62517252e-03f, 4.26080711e-02f, -4.65041362e-02f, -1.01339845e-02f, 2.13655159e-02f,
  -6.92661433e-03f, 4.32610437e-02f, 6.22928143e-02f, -8.33011977e-03f, -3.17192217e-03f, -2.64166873e-02f, 3.07481010e-02f, -5.15688807e-02f, -2.76399478e-02f, -9.41714086e-03f,
  -2.94744130e-02f, -7.37599805e-02f, 4.96330904e-03f, -3.56950127e-02f, 5.22682965e-02f, 9.01307091e-02f, 7.89624974e-02f, -1.63838584e-02f, 2.99238302e-02f, 1.90723240e-02f,
  -1.08666867e-01f, -7.07013234e-02f, -2.83813700e-02f, -1.04785547e-01f, 4.36536409e-02f, 2.41960045e-02f, 9.21049267e-02f, 8.81440863e-02f, -3.17502059e-02f, 1.97136998e-02f,
  -7.07380772e-02f, 5.95576093e-02f, -7.32131377e-02f, 7.26916417e-02f, 2.79234606e-03f, -1.30507154e-02f, -7.56714046e-02f, 1.59570873e-02f, -3.43886018e-02f, 5.20642474e-02f,
  -7.30929151e-02f, 1.61731672e-02f, -7.51406997e-02f, 6.43012226e-02f, -1.78280175e-02f, 3.25259380e-02f, -4.06898707e-02f, 6.72410652e-02f, -8.06979015e-02f, -9.00363550e-02f,
  3.48767042e-02f, -9.33548808e-02f, -1.60411239e-01f, -8.87336507e-02f, -6.62903413e-02f, 9.98204648e-02f, 5.49200885e-02f, -1.23746671e-01f, -2.25664511e-01f, 1.04808748e-01f,
  5.11918068e-02f, -5.77669069e-02f, 4.31142375e-02f, 1.26023680e-01f, 8.10326636e-03f, 9.59513560e-02f, 7.29674399e-02f, 2.78526321e-02f, -2.97263358e-02f, 1.37900272e-02f,
  4.00976650e-02f, 2.67586540e-02f, 2.71741971e-02f, -4.30961251e-02f, -2.39975806e-02f, 4.75588366e-02f, 7.18059838e-02f, 5.79517782e-02f, 5.44039384e-02f, 3.43045630e-02f,
  1.91510953e-02f, -2.93578487e-02f, 3.35026048e-02f, -8.65344256e-02f, -3.26225907e-02f, 7.15715662e-02f, -2.54355948e-02f, 7.61794746e-02f, 1.34326825e-02f, 6.97949305e-02f,
  -1.04905546e-01f, -1.02826143e-02f, -2.04434544e-02f, 4.12633717e-02f, -5.87235205e-02f, -2.59520561e-02f, 3.89286838e-02f, 2.70103626e-02f, -1.15692727e-01f, -1.82281658e-02f,
  -5.05738333e-02f, 5.61673343e-02f, -2.16624849e-02f, -3.31893563e-02f, -8.26887637e-02f, -6.63379878e-02f, 5.20142242e-02f, 1.04557723e-01f, -9.40828472e-02f, -3.27875419e-03f,
  1.97603162e-02f, 9.22824815e-02f, -3.18815447e-02f, 6.97537810e-02f, 5.31597808e-02f, 7.56076351e-02f, -3.63454148e-02f, -4.86856811e-02f, 6.91227093e-02f, -1.66078135e-02f,
  -4.78956625e-02f, 1.10057765e-03f, -2.88502388e-02f, 6.77678958e-02f, -2.41223350e-02f, -3.83006558e-02f, 4.81831394e-02f, -6.38824627e-02f, 4.39921580e-02f, 2.13817153e-02f,
  1.01047512e-02f, -2.47122031e-02f, 2.70377304e-02f, -1.51296332e-02f, 8.70153774e-03f, 4.86493148e-02f, 5.86651079e-02f, 7.58957863e-02f, -5.26436791e-03f, 6.83024898e-02f,
  5.15554994e-02f, -1.12875573e-01f, 1.87861677e-02f, -8.91277492e-02f, 8.78224745e-02f, 1.60551779e-02f, 1.70154031e-02f, -1.18549466e-01f, -2.09270660e-02f, -2.90121883e-02f,
  5.44679686e-02f, 4.52100374e-02f, -1.83921512e-02f, -5.91462366e-02f, -7.47265443e-02f, -3.23986933e-02f, -3.15805115e-02f, -5.86793460e-02f, 5.78193888e-02f, -8.55494142e-02f,
  -7.10836798e-02f, -9.23102498e-02f, 2.39608139e-02f, -1.79834571e-03f, 6.01085424e-02f, -1.24921445e-02f, -7.05511123e-02f, -7.32572526e-02f, -8.50912035e-02f, -6.33493215e-02f,
  -1.19476408e-01f, -5.33289684e-04f, 7.74473175e-02f, -6.04970343e-02f, 2.28595491e-02f, 2.62293909e-02f, 1.44467503e-01f, -1.17320247e-01f, -2.03037098e-01f, -1.40289981e-02f,
  7.02758739e-03f, 1.68366183e-03f, 1.48312390e-01f, -1.42969368e-02f, 1.48268193e-01f, 1.29711762e-01f, -1.71005037e-02f, 1.54143693e-02f, -9.66887996e-02f, 1.74352676e-02f,
  5.41019849e-02f, 3.80257554e-02f, 9.42514390e-02f, -3.61512159e-03f, -3.30017298e-03f, -1.09826021e-01f, -4.77552526e-02f, 1.38775826e-01f, -4.80814911e-02f, -2.70069372e-02f,
  1.16120577e-02f, -6.46084398e-02f, 1.33861542e-01f, -1.03420755e-02f, -3.91126387e-02f, -3.80736543e-03f, 4.56502549e-02f, 6.03719018e-02f, 3.87322456e-02f, 1.00234654e-02f,
  -4.94454950e-02f, 8.90528336e-02f, -1.30583689e-01f, 3.79181877e-02f, -1.35317072e-02f, -2.23435704e-02f, -1.83338057e-02f, 3.06975991e-02f, 1.89678848e-03f, -5.35144955e-02f,
  7.64669701e-02f, 5.32992510e-03f, 6.52814656e-02f, -2.75879707e-02f, 6.15375862e-03f, -3.42510603e-02f, -6.07911423e-02f, 8.42001066e-02f, 9.38741565e-02f, -4.57579158e-02f,
  -3.37449946e-02f, 3.44879925e-02f, 9.57937613e-02f, -2.53165420e-02f, -9.99154076e-02f, 6.48497716e-02f, -3.85634303e-02f, 2.35888194e-02f, -7.20187426e-02f, 7.72925168e-02f,
  1.04855439e-02f, 6.55546486e-02f, 6.88060001e-02f, 6.68396577e-02f, 4.33332063e-02f, 1.63606531e-03f, -8.17707460e-03f, -7.53522338e-03f, -1.37104020e-02f, 7.46112168e-02f,
  -1.02250770e-01f, -5.61473183e-02f, -1.89970266e-02f, -9.49847326e-03f, 3.92638855e-02f, 2.19053160e-02f, 5.08414991e-02f, 1.91307943e-02f, 7.34452605e-02f, 1.13000013e-01f,
  -1.56653956e-01f, -1.59460038e-01f, 1.05541237e-02f, 5.93041368e-02f, 4.29152474e-02f, -3.70744541e-02f, -3.30993310e-02f, -1.15556300e-01f, -7.26822838e-02f, -3.84086743e-02f,
  -5.25986031e-02f, 5.47919571e-02f, 1.37496516e-02f, 4.90042232e-02f, 4.30969298e-02f, -7.88260326e-02f, -6.72256276e-02f, -4.03126702e-02f, -7.18146190e-03f, -9.16625783e-02f,
  -6.90225139e-02f, -8.15225244e-02f, -7.22210854e-02f, 8.30574855e-02f, -8.45437646e-02f, -7.43088499e-02f, -3.63473818e-02f, -5.20424619e-02f, 1.49950283e-02f, 1.66494045e-02f,
  3.97077352e-02f, 5.41424975e-02f, 1.05038792e-01f, 2.17808068e-01f, -5.36459237e-02f, -2.29697168e-01f, -4.75802049e-02f, -7.99393803e-02f, 4.17125132e-03f, -1.18585460e-01f,
  7.64624868e-03f, 7.64458328e-02f, -1.09721951e-01f, 7.57691488e-02f, 1.53514698e-01f, 1.92222446e-02f, 6.15817830e-02f, -8.52735415e-02f, 2.27243602e-02f, 1.27661169e-01f,
  5.74284084e-02f, -3.73137295e-02f, 1.27874300e-01f, 3.16675082e-02f, 4.72382642e-02f, 1.71265081e-01f, 1.85866833e-01f, -4.95484471e-02f, 7.19797835e-02f, 1.52230589e-02f,
  -1.05031148e-01f, -2.48254426e-02f, 3.67688350e-02f, 3.43645811e-02f, -7.26592261e-03f, -3.33349258e-02f, -1.32519668e-02f, -5.28551675e-02f, 2.64659282e-02f, 6.84918091e-02f,
  -5.86787276e-02f, -2.37106849e-02f, 5.67456000e-02f, -5.55723980e-02f, -3.27103175e-02f, 1.10723495e-01f, 6.86458275e-02f, -1.30236940e-02f, 5.44704720e-02f, -5.46519868e-02f,
  -1.77245438e-02f, -6.15934990e-02f, 5.82660176e-02f, -3.60164084e-02f, -2.45180726e-02f, 5.02470173e-02f, 2.01173704e-02f, 1.34285083e-02f, -2.96783522e-02f, 1.15936324e-02f,
  -7.28298873e-02f, -1.16915489e-02f, 2.79259738e-02f, -3.05930302e-02f, -3.02313268e-02f, 2.49469802e-02f, 2.87426822e-02f, -5.55884242e-02f, -7.83796608e-02f, 2.28468087e-02f,
  1.27469739e-02f, 4.70681116e-02f, -8.22550431e-02f, -1.74709142e-03f, -5.39655127e-02f, 3.29562649e-02f, -2.36126855e-02f, -6.05509914e-02f, 1.60680544e-02f, -1.31374868e-02f,
  1.09734265e-02f, -8.08113515e-02f, 4.51167710e-02f, -1.80248264e-02f, 3.54152918e-02f, 3.73485014e-02f, -4.89764512e-02f, -3.23717631e-02f, -5.11808656e-02f, 5.23761064e-02f,
  -6.14677481e-02f, 2.10821345e-01f, -4.98128943e-02f, -1.34163843e-02f, -7.92348012e-02f, -2.25072075e-02f, 7.22870901e-02f, -4.36482280e-02f, 1.16349883e-01f, -6.56345338e-02f,
  -7.00112507e-02f, -4.93674874e-02f, -1.04028862e-02f, 7.67039359e-02f, -9.75168198e-02f, -3.23909856e-02f, 5.45388609e-02f, -2.72056926e-02f, -3.27531546e-02f, 2.37916615e-02f,
  -3.22669111e-02f, -6.05137646e-02f, -2.44936980e-02f, 5.02524711e-02f, 5.30485250e-02f, 9.33080353e-03f, -1.77130327e-02f, -1.55351115e-02f, -8.79190862e-02f, 6.77228393e-03f,
  3.59486900e-02f, -9.94963795e-02f, -3.10312241e-01f, -2.15609536e-01f, -1.70498878e-01f, -3.85423362e-01f, -1.83216587e-01f, -1.71352729e-01f, 1.16713434e-01f, 9.09868330e-02f,
  2.07233597e-02f, 1.61427830e-04f, 2.19167143e-01f, -2.55266041e-01f, 7.52118006e-02f, 1.76563501e-01f, -2.91096240e-01f, -1.13129325e-01f, 3.65947522e-02f, -1.19009070e-01f,
  4.11004759e-02f, -8.61515477e-02f, -7.03505799e-02f, -1.11443624e-01f, -2.89595217e-01f, -4.50991318e-02f, 9.85317528e-02f, -1.47504613e-01f, -2.37489596e-01f, -1.64622322e-01f,
  -7.14650527e-02f, -3.22697335e-03f, -9.93449092e-02f, 4.59346026e-02f, -1.26138598e-01f, -2.02008579e-02f, -9.19142887e-02f, -6.33699596e-02f, -1.67714749e-02f, -2.93830857e-02f,
  1.66313518e-02f, 5.40086217e-02f, 5.38668595e-02f, 9.00090709e-02f, -9.06091358e-04f, -1.20928496e-01f, 3.70411314e-02f, 5.77550381e-02f, -2.86292527e-02f, 1.05726644e-02f,
  -1.13367811e-01f, -5.51646687e-02f, -2.96233874e-03f, 4.13556211e-02f, -4.49846983e-02f, -9.98908505e-02f, 5.69602363e-02f, -4.30023149e-02f, -9.75578800e-02f, -2.20840350e-02f,
  7.16909468e-02f, 2.43293494e-02f, -1.83346439e-02f, -1.94349755e-02f, 1.10114655e-02f, 1.66536327e-02f, 1.78958348e-03f, -8.61133263e-03f, 6.88360333e-02f, -3.35843451e-02f,
  1.57080237e-02f, 1.05423313e-02f, -1.34411976e-02f, -2.71970555e-02f, -2.11974811e-02f, 2.47937115e-03f, 4.23624814e-02f, 7.07068443e-02f, 1.65761020e-02f, 2.57093310e-02f,
  -3.31746787e-02f, -2.51694303e-02f, -5.43359295e-02f, -1.69085227e-02f, -3.35193910e-02f, -3.15336920e-02f, -7.34504089e-02f, 5.21565005e-02f, 2.99612749e-02f, -7.05999807e-02f,
  -1.15327671e-01f, 3.20537426e-02f, -3.66042741e-02f, 1.35298949e-02f, 5.02879880e-02f, -1.63292373e-03f, -3.50167751e-02f, -1.06923714e-01f, -4.02688570e-02f, -3.94945294e-02f,
  1.24537442e-02f, 1.14329513e-02f, -1.04605801e-01f, -2.73391567e-02f, 4.63040769e-02f, -8.24655518e-02f, 7.38284364e-02f, -3.62484902e-02f, -6.23050332e-03f, 2.66437791e-03f,
  7.91174695e-02f, 7.26479366e-02f, 5.54323085e-02f, -2.65549440e-02f, -2.51229350e-02f, -3.77985053e-02f, 4.75824112e-03f, 9.41497181e-03f, 1.11358454e-02f, -1.72522906e-02f,
  2.40980804e-01f, -2.45520219e-01f, 1.67272881e-01f, 2.51251310e-01f, 9.54838768e-02f, -6.39380794e-03f, -1.53671112e-02f, -3.43738981e-02f, 1.13902383e-01f, -2.06283540e-01f,
  4.54158857e-02f, -5.29466793e-02f, -9.44735929e-02f, 1.63183823e-01f, 2.17673928e-01f, -8.99244566e-03f, 1.13843784e-01f, 4.61531691e-02f, 3.93889509e-02f, 6.50512893e-03f,
  1.89136848e-01f, 1.44605279e-01f, -8.28703865e-04f, -1.14207864e-01f, 9.76712033e-02f, -5.06847277e-02f, 4.15942669e-02f, -5.49535118e-02f, 1.27710044e-01f, -2.74987202e-02f,
  -3.89608964e-02f, -2.71276832e-02f, -9.61780846e-02f, 9.54404939e-03f, -1.39278336e-03f, -1.08162254e-01f, 6.39365092e-02f, 7.45595098e-02f, 5.76724596e-02f, -1.61247067e-02f,
  -4.76485528e-02f, 8.12823176e-02f, 1.20002711e-02f, 3.83381099e-02f, 2.54263580e-02f, 8.20322856e-02f, -2.43452769e-02f, 9.02083889e-03f, 9.83532052e-03f, -4.60095331e-02f,
  -1.73947997e-02f, -6.89285621e-03f, 5.26584685e-02f, 5.83145618e-02f, 2.02199556e-02f, 7.55497664e-02f, -2.07546353e-02f, 3.25322598e-02f, 3.81885399e-03f, -3.47397737e-02f,
  -4.30845954e-02f, 4.08207513e-02f, 7.36820325e-02f, -2.08684355e-02f, 5.78027330e-02f, 2.11124606e-02f, -7.94463884e-03f, -4.19536866e-02f, 4.96389419e-02f, 5.71125485e-02f,
  7.74509758e-02f, 5.44179454e-02f, 8.02886784e-02f, 1.47204138e-02f, -3.84100825e-02f, -1.49521828e-02f, 1.02145165e-01f, 8.80721062e-02f, -2.14177347e-03f, -5.88298887e-02f,
  2.49617118e-02f, 5.93661442e-02f, -7.00042769e-02f, -1.89910606e-02f, -4.50307168e-02f, -1.03750594e-01f, -6.17231522e-03f, 2.26851106e-02f, 5.08993752e-02f, 6.84504807e-02f,
  3.54525670e-02f, -2.80391295e-02f, -6.11655191e-02f, 4.83432263e-02f, -1.38245546e-03f, -6.13435963e-03f, -3.96265239e-02f, 6.46160617e-02f, -7.20665529e-02f, 6.48593009e-02f,
  -8.66988972e-02f, -2.47427244e-02f, -9.66482088e-02f, 3.16869542e-02f, 9.02674645e-02f, -5.19156195e-02f, 5.47977313e-02f, -1.96602941e-02f, 1.33213773e-02f, -4.42514345e-02f,
  -3.18132788e-02f, -1.04525581e-01f, 4.68141846e-02f, -8.80863145e-02f, -1.36222601e-01f, -6.01204820e-02f, -1.45003907e-02f, -6.55815378e-02f, 5.99548034e-03f, -2.22013518e-02f,
  2.96140779e-02f, 1.79616228e-01f, 1.76267892e-01f, 2.15259567e-02f, 7.46890754e-02f, -6.16176277e-02f, -1.10536881e-01f, 1.53893426e-01f, 1.26503650e-02f, -1.18661463e-01f,
  -8.80043805e-02f, 1.47762254e-01f, 1.45971617e-02f, -8.03641006e-02f, -1.13905994e-02f, -2.48230994e-02f, 3.16755176e-02f, 9.41810906e-02f, 1.02344736e-01f, -5.76487444e-02f,
  -4.84386012e-02f, -8.03798959e-02f, -5.41330092e-02f, 6.16814978e-02f, 7.29949959e-03f, -5.94473220e-02f, -1.93222657e-01f, 8.54144767e-02f, -1.06460147e-01f, 1.03130840e-01f,
  1.74537320e-02f, 4.09705453e-02f, 1.73729844e-02f, -3.46776955e-02f, 1.83005277e-02f, 4.99012507e-02f, -3.20777893e-02f, -6.55275583e-02f, -3.05389240e-02f, -8.47594514e-02f,
  -5.05714193e-02f, -4.36928915e-03f, 1.83495414e-02f, -1.67671219e-02f, -3.36149558e-02f, 8.78307149e-02f, 4.63702567e-02f, -4.16169800e-02f, 4.43216860e-02f, -2.76993532e-02f,
  3.77190374e-02f, 7.60527328e-02f, -8.94849077e-02f, -7.32253492e-02f, -6.56646565e-02f, 4.61816527e-02f, 8.30297843e-02f, 7.88404047e-02f, -5.93430456e-03f, 7.54906330e-03f,
  5.30330185e-03f, 1.70540612e-03f, 6.02341071e-02f, -1.12518845e-02f, 6.79331869e-02f, 2.59677619e-02f, 7.69961923e-02f, -9.12349895e-02f, -4.11047228e-02f, 2.58726515e-02f,
  1.86303649e-02f, 5.55127580e-03f, 1.47062661e-02f, 6.05936274e-02f, -2.88142227e-02f, 5.86418733e-02f, -3.36990692e-02f, -3.85709703e-02f, 8.12652037e-02f, 5.00996783e-02f,
  -2.50993110e-03f, -3.96851264e-02f, 2.07848120e-02f, 4.45853621e-02f, 8.84674639e-02f, 5.23520708e-02f, -5.41768670e-02f, -5.02261892e-02f, 1.54390289e-02f, 2.45544035e-02f,
  -8.50081742e-02f, -5.24832346e-02f, -4.24470380e-03f, 3.25739831e-02f, -5.57056591e-02f, -8.70804116e-02f, -8.31708685e-02f, -3.10636107e-02f, 3.74739990e-02f, -3.56572233e-02f,
  -9.50275287e-02f, -4.18732781e-03f, 5.68613037e-02f, -9.18267220e-02f, 5.40640950e-03f, -4.63694483e-02f, -8.54374096e-02f, -1.26560833e-02f, -6.20445609e-02f, 6.86869398e-02f,
  -6.38208240e-02f, -5.67103475e-02f, -5.07528484e-02f, -1.98251717e-02f, -7.24839792e-02f, -4.48111705e-02f, -9.15184394e-02f, -3.17093432e-02f, 3.83075960e-02f, 7.25546479e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 26)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 26;
const float L0_fan_Bp_bar_data[] = {
  1.27783678e-02f, -5.12270480e-02f, 1.95223197e-01f, 1.70829713e-01f, 1.70525983e-01f, 8.73357058e-02f, 1.51811540e-01f, 1.64908413e-02f, 1.54574722e-01f, 1.83257982e-01f,
  1.04065098e-01f, 5.90731315e-02f, 2.87185103e-01f, -3.47334333e-02f, 3.32342908e-02f, 7.95344263e-02f, 5.96793033e-02f, 1.18020989e-01f, 3.14464569e-02f, 5.11428602e-02f,
  8.10198560e-02f, 3.50585720e-03f, -2.89897807e-02f, 6.28656000e-02f, 7.51247406e-02f, 1.39783278e-01f
};

// L1_fan_Wp (Shape: 19 x 64)
const int L1_fan_Wp_rows = 19;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  -1.68397918e-01f, 3.49142216e-02f, -2.62600351e-02f, -1.27523884e-01f, 1.07212350e-01f, -1.07389711e-01f, -1.65025309e-01f, 1.02313198e-01f, -1.36506394e-01f, 1.70681179e-01f,
  9.01408046e-02f, 6.51122555e-02f, 8.76141619e-03f, 1.26740232e-01f, -1.13612205e-01f, 6.44846857e-02f, -3.31323929e-02f, 7.24371448e-02f, 9.64446813e-02f, -1.55384347e-01f,
  -1.46730497e-01f, -1.99626926e-02f, -8.08352083e-02f, -1.63313195e-01f, 1.48018479e-01f, -1.05548315e-01f, -2.09655184e-02f, 2.05261745e-02f, -1.94334969e-01f, 2.78238147e-01f,
  -1.92188039e-01f, 1.73097327e-02f, 1.87698558e-01f, 1.07416183e-01f, -2.44959041e-01f, -9.33876112e-02f, -2.82972790e-02f, -1.36832923e-01f, 5.47084659e-02f, -3.79655622e-02f,
  -2.13147923e-01f, -8.08776170e-03f, -1.05315931e-01f, -7.71287382e-02f, 5.73009402e-02f, -1.51712567e-01f, -4.70927618e-02f, -1.78377777e-01f, 9.81809646e-02f, -8.94334316e-02f,
  2.68540174e-01f, -1.17225260e-01f, 7.98919722e-02f, -1.08729325e-01f, 1.13923460e-01f, -1.05654299e-01f, -3.45862168e-03f, -1.60355549e-02f, 4.17398103e-02f, 2.35645790e-02f,
  7.74438232e-02f, 8.94193500e-02f, -2.47269988e-01f, 7.28649050e-02f, 1.55318424e-01f, -5.20773083e-02f, 2.39095222e-02f, 1.29326642e-01f, 1.38697326e-01f, -2.43970659e-02f,
  -3.45663913e-02f, 9.00325477e-02f, 1.14489049e-01f, -1.36927783e-01f, -9.95280966e-02f, 4.61874232e-02f, 4.85196114e-02f, 1.11644946e-01f, 3.74722965e-02f, 1.11945666e-01f,
  -6.15959428e-02f, -1.91363722e-01f, 7.58327991e-02f, 1.74991339e-01f, -4.67259400e-02f, -1.63160220e-01f, -2.58553594e-01f, 1.72730565e-01f, -1.54293984e-01f, 6.28143847e-02f,
  -1.41350716e-01f, 6.99861571e-02f, 2.64245063e-01f, -2.97527581e-01f, 1.57970980e-01f, 4.94226404e-02f, -2.60888010e-01f, -8.48409310e-02f, 6.70212209e-02f, 2.25008249e-01f,
  -7.82169402e-02f, -2.37666085e-01f, -3.71393412e-02f, 1.02253959e-01f, 9.97946858e-02f, 2.29733437e-03f, 1.79274887e-01f, -1.11754417e-01f, -2.83016283e-02f, -1.29780583e-02f,
  8.08023587e-02f, -3.47054079e-02f, -8.58594254e-02f, -8.12702924e-02f, -1.50835767e-01f, 1.49676800e-02f, 7.99074620e-02f, 8.89592022e-02f, -1.34654418e-01f, 2.14915094e-03f,
  -1.73839092e-01f, 6.62429780e-02f, 9.82950553e-02f, 1.32559806e-01f, -7.97433332e-02f, -1.43650725e-01f, 5.22000566e-02f, 1.13637932e-01f, 6.89201150e-03f, 6.37246519e-02f,
  9.15296227e-02f, -2.75598377e-01f, -7.91418478e-02f, -7.09667578e-02f, 1.16956390e-01f, 7.23907799e-02f, 1.58807620e-01f, -8.34229961e-02f, -1.33605629e-01f, 6.12312779e-02f,
  9.20399185e-03f, 8.05151165e-02f, 2.05810368e-01f, 4.19616774e-02f, 1.54258668e-01f, 8.36769398e-03f, -1.81317881e-01f, -2.97314554e-01f, 5.04374616e-02f, 4.81439047e-02f,
  -1.22015573e-01f, 3.36183123e-02f, -1.12595938e-01f, 1.64140046e-01f, 6.10304764e-04f, -3.49381492e-02f, 5.08664101e-02f, 2.23450810e-01f, -1.03917927e-01f, -1.29146263e-01f,
  1.89568270e-02f, 3.33431125e-01f, -9.11770388e-02f, 8.65699649e-02f, -6.53244331e-02f, -1.53528258e-01f, -9.67587084e-02f, 1.18351035e-01f, -2.36736611e-01f, -3.80061977e-02f,
  -5.11511788e-02f, -8.40169042e-02f, -1.25106782e-01f, 8.69527310e-02f, 1.22607946e-02f, 9.92255881e-02f, 1.24727540e-01f, -5.57413846e-02f, 2.93790400e-01f, 2.11742632e-02f,
  -1.25432521e-01f, 8.86564553e-02f, 2.24858127e-03f, 8.17662254e-02f, 9.80188325e-02f, -5.18856756e-02f, -7.73762241e-02f, -8.13881904e-02f, -1.30770192e-01f, -1.19478725e-01f,
  -3.09374481e-02f, 1.31963026e-02f, -3.47039327e-02f, 1.26508921e-01f, 1.83432192e-01f, 1.99335903e-01f, 4.45399806e-02f, 1.10316277e-01f, -5.01331091e-02f, 6.64893091e-02f,
  4.02471758e-02f, 1.85049161e-01f, 7.93316513e-02f, 1.90728996e-03f, 1.40555307e-01f, -1.29945368e-01f, -3.32361311e-02f, -8.96842405e-02f, -1.00091845e-01f, -3.29897664e-02f,
  8.44473094e-02f, 1.63545832e-01f, -3.60590499e-03f, -1.56325489e-01f, 1.66389704e-01f, 1.77891925e-01f, 6.27248883e-02f, 4.92433179e-03f, 4.05872948e-02f, 2.01798254e-03f,
  1.96706146e-01f, -6.38049543e-02f, -3.92975546e-02f, 1.92660764e-01f, -1.22671627e-01f, -6.04234673e-02f, 1.33523077e-01f, 6.09237067e-02f, 9.39370841e-02f, 3.08753908e-01f,
  2.94736382e-02f, 3.31763993e-03f, 8.01419616e-02f, -5.18388636e-02f, 5.45893833e-02f, 1.17827408e-01f, -1.63484216e-01f, 7.99524635e-02f, -4.62277792e-02f, 9.31905881e-02f,
  -8.16211775e-02f, 1.76918864e-01f, -2.36735359e-01f, 1.28766060e-01f, 5.55506200e-02f, -2.95426510e-02f, 1.27193362e-01f, 6.07718118e-02f, 1.17531836e-01f, 4.52871919e-02f,
  9.02367681e-02f, -6.49170950e-02f, 1.43375516e-01f, -6.80459291e-02f, 1.33554280e-01f, -1.25325888e-01f, -7.25013316e-02f, -1.24912977e-01f, -9.39899907e-02f, -2.27068633e-01f,
  2.21395101e-02f, -2.98679098e-02f, -1.71782151e-01f, -9.91500020e-02f, -1.96501881e-01f, -1.97480414e-02f, 4.39749807e-02f, -5.11581311e-03f, -3.04391216e-02f, -1.16537474e-01f,
  8.90732408e-02f, -1.92825958e-01f, 1.79602560e-02f, 1.80402920e-01f, -2.26355359e-01f, -2.19223469e-01f, 9.67712104e-02f, 1.11270465e-01f, 3.47345680e-01f, -6.66618049e-02f,
  -2.34689098e-02f, -2.91490238e-02f, -1.17196552e-01f, -2.81563610e-01f, -2.51679450e-01f, 1.99326858e-01f, -1.42987147e-01f, 4.33028266e-02f, 2.73502804e-02f, 1.38623387e-01f,
  -3.55231315e-02f, -2.36301020e-01f, 2.09606051e-01f, 2.41620064e-01f, 8.73364136e-02f, -8.85172337e-02f, -5.66552319e-02f, 6.56319708e-02f, -2.09110990e-01f, -3.02475728e-02f,
  6.75843656e-02f, 1.33923873e-01f, -7.00472593e-02f, 5.11430651e-02f, 8.78973752e-02f, 1.32853491e-02f, 1.32036477e-01f, -1.38390660e-01f, -1.21614777e-01f, -6.59636334e-02f,
  6.33743852e-02f, -5.75533621e-02f, 2.43438050e-01f, -8.61901641e-02f, -2.80698221e-02f, 5.78069575e-02f, 1.54623643e-01f, 5.15237525e-02f, 5.33420891e-02f, -1.37511911e-02f,
  -1.43356234e-01f, 1.73672140e-01f, -2.73968466e-02f, -1.55739719e-02f, -4.79618125e-02f, -3.93433608e-02f, -2.72092763e-02f, 8.17150399e-02f, 1.30595535e-01f, 6.81519955e-02f,
  1.37174144e-01f, -2.98220920e-03f, 1.79338410e-01f, 1.35315061e-02f, -4.94802790e-03f, 1.60580799e-01f, 1.49397440e-02f, 1.80996358e-01f, -3.30417193e-02f, -4.96573634e-02f,
  -2.12273717e-01f, 6.66376054e-02f, -2.39495650e-01f, -6.58979714e-02f, 6.32856712e-02f, 1.85431130e-02f, 2.62115538e-01f, 2.40042865e-01f, -1.38131425e-01f, 3.01144660e-01f,
  -2.50347536e-02f, -1.28661320e-01f, 3.33969772e-01f, -1.96916699e-01f, -1.50949135e-01f, -7.20471367e-02f, 1.01742446e-01f, -3.23373899e-02f, -1.49742156e-01f, -8.25970843e-02f,
  -9.55239460e-02f, -4.01121117e-02f, -6.43141419e-02f, 3.49568715e-03f, 1.56967044e-01f, -1.28638461e-01f, -1.56303436e-01f, -1.66851670e-01f, -4.32840660e-02f, -1.12040311e-01f,
  1.87987328e-01f, 6.10348471e-02f, 1.29433125e-01f, -7.98047110e-02f, -1.84101593e-02f, -2.43134186e-01f, -8.86521861e-02f, 1.23294234e-01f, -7.89032876e-02f, 9.64655075e-03f,
  -7.72779509e-02f, 1.62846386e-01f, -2.53753394e-01f, 1.14522614e-01f, -6.64644539e-02f, -5.55569679e-02f, -6.68717697e-02f, 7.90298134e-02f, 2.52461135e-02f, 9.14154202e-02f,
  9.54083353e-02f, 7.54463002e-02f, 8.84732697e-03f, 3.04322056e-02f, -1.62411064e-01f, -4.91741337e-02f, -3.28032896e-02f, 2.55813189e-02f, -8.12863410e-02f, 1.07050627e-01f,
  -7.78806433e-02f, -1.24234244e-01f, 4.84745577e-02f, -1.03394121e-01f, 8.55125934e-02f, -1.12316394e-02f, 6.59024492e-02f, 5.53945340e-02f, -1.61174297e-01f, 4.64592800e-02f,
  -2.25604758e-01f, -1.16099171e-01f, 1.58668533e-01f, -1.67542040e-01f, 2.45806381e-01f, 6.51761740e-02f, -1.54814154e-01f, -3.97815518e-02f, 1.34521440e-01f, -4.96579930e-02f,
  -3.96119468e-02f, 1.91160273e-02f, -6.86334819e-02f, 2.06219088e-02f, 1.27307370e-01f, 1.07174650e-01f, -6.44378364e-02f, -1.71048120e-02f, -2.78026015e-01f, 9.93536934e-02f,
  1.43939391e-01f, 1.46487802e-01f, -1.16509974e-01f, 1.50875717e-01f, -2.46638549e-03f, -9.35004279e-02f, -5.42675741e-02f, 9.31759831e-04f, -5.14606200e-02f, 1.46633044e-01f,
  -6.53553801e-03f, 8.39047432e-02f, -1.38592655e-02f, -5.33901080e-02f, 6.62603602e-02f, -2.15878665e-01f, 2.51246188e-02f, 9.05431509e-02f, 4.12611291e-02f, 3.54542048e-04f,
  6.32506907e-02f, -9.43167657e-02f, 2.78105382e-02f, 4.76472601e-02f, 9.49871913e-02f, -7.64062181e-02f, 1.11173443e-01f, 2.04641059e-01f, 1.52584448e-01f, 1.18619569e-01f,
  8.43367577e-02f, -1.35597184e-01f, -5.20135202e-02f, 9.56073999e-02f, 3.34297493e-02f, 3.25014815e-02f, -8.25446770e-02f, -1.59699917e-01f, -2.76450696e-03f, 1.15186058e-01f,
  1.95092991e-01f, 1.59472376e-01f, 1.26036912e-01f, 3.44344527e-02f, 1.25604123e-01f, -4.12941486e-01f, -1.52169064e-01f, 2.70061046e-01f, -5.74479885e-02f, 1.35187238e-01f,
  4.56525385e-02f, 1.81175098e-01f, 7.96500593e-02f, -2.13240236e-01f, -2.10619524e-01f, 2.45513111e-01f, 9.77640450e-02f, -5.28026856e-02f, -1.76113084e-01f, 6.61299899e-02f,
  -7.31780473e-03f, -6.15138412e-02f, -3.35364044e-01f, 2.17335746e-01f, 7.20699281e-02f, 2.36097008e-01f, 6.45143092e-02f, 2.11644545e-01f, 4.11980711e-02f, 9.55082029e-02f,
  -6.30116835e-02f, -9.07195173e-03f, 5.87472878e-02f, -7.89172500e-02f, 8.58745426e-02f, 4.33496945e-02f, -9.82031599e-02f, -1.31834850e-01f, -4.92581949e-02f, -1.34921521e-01f,
  -3.19788558e-03f, -6.34762123e-02f, 7.50133097e-02f, -1.43631727e-01f, 8.54262114e-02f, 1.33458304e-03f, 6.92833364e-02f, -4.76424433e-02f, -5.57654835e-02f, 2.09365085e-01f,
  1.68217242e-01f, 1.07672460e-01f, 1.10403560e-01f, 7.52019957e-02f, -5.30876964e-02f, 3.21564488e-02f, -1.03753209e-01f, 7.20681772e-02f, -1.35622993e-01f, -7.98549801e-02f,
  -3.79685462e-02f, -1.72644868e-01f, 1.31633312e-01f, 9.36904177e-02f, 6.91255601e-03f, -1.48715386e-02f, 2.49248631e-02f, 3.74729708e-02f, -8.55833292e-02f, -3.19008708e-01f,
  2.38837879e-02f, 1.41031202e-02f, 1.42283991e-01f, 2.10190117e-02f, -1.94857582e-01f, 3.25595766e-01f, -1.09935202e-01f, 1.47001341e-01f, 1.73666209e-01f, -1.31914243e-01f,
  8.55942257e-03f, -2.72571146e-02f, 1.02910578e-01f, 1.62168503e-01f, -9.50158834e-02f, -1.09556682e-01f, -2.72456855e-01f, 1.54495761e-01f, 5.28369546e-02f, 6.51060790e-02f,
  1.23966634e-01f, 5.13343699e-02f, 1.89319298e-01f, -9.87499729e-02f, 6.43049255e-02f, 9.08199027e-02f, 3.32429819e-02f, 1.57525584e-01f, -1.39387816e-01f, -5.80426753e-02f,
  -2.69988123e-02f, -3.97455320e-02f, -5.07357307e-02f, -1.67298049e-01f, 9.76638123e-02f, 4.71034683e-02f, -4.04984988e-02f, 8.88631493e-02f, 2.87918597e-02f, 1.47372425e-01f,
  -8.70526582e-02f, 2.44282130e-02f, -1.39686033e-01f, -1.41795397e-01f, -1.42977551e-01f, 1.27480179e-01f, 3.40529867e-02f, -3.07833701e-02f, 1.02359474e-01f, -1.17786996e-01f,
  1.92122441e-02f, 5.43743465e-03f, -5.19216321e-02f, -1.79165695e-02f, 3.79486196e-02f, 2.32600756e-02f, -5.41689582e-02f, -1.21372119e-01f, 9.87983868e-02f, 3.07076305e-01f,
  2.02303767e-01f, -1.64326981e-01f, 1.86572358e-01f, 2.31084526e-01f, 1.17436565e-01f, -1.43627018e-01f, 4.87815402e-03f, -7.73853064e-02f, 1.77572340e-01f, -3.25114965e-01f,
  2.27524757e-01f, -1.85387105e-01f, -2.27210317e-02f, -4.16023768e-02f, 3.37595977e-02f, -4.11943756e-02f, 1.05920278e-01f, 1.30181476e-01f, 9.53865722e-02f, -4.93608974e-02f,
  -1.23291081e-02f, -1.46340013e-01f, 2.09994502e-02f, -1.11937441e-01f, -2.19243462e-03f, -2.69326210e-01f, -1.14489429e-01f, 8.17423537e-02f, -1.00469120e-01f, 1.92083027e-02f,
  -2.00408369e-01f, -1.28879532e-01f, -1.89704090e-01f, 1.30207852e-01f, -1.74749233e-02f, 1.47507638e-01f, -1.30724981e-01f, 2.39754423e-01f, -1.12921886e-01f, -8.70707110e-02f,
  2.44105961e-02f, -1.62928831e-02f, 2.40264758e-02f, -4.11072746e-02f, 1.30559877e-01f, 3.01960260e-02f, 4.82591353e-02f, 2.10064843e-01f, 1.75605416e-01f, -2.83151846e-02f,
  1.36940062e-01f, 9.69638079e-02f, 9.82249063e-03f, 1.18894532e-01f, -6.15917109e-02f, 1.60016850e-01f, 5.53438328e-02f, 1.01345308e-01f, 9.27099958e-02f, 1.86158702e-01f,
  7.81482235e-02f, -1.54899314e-01f, -3.37907076e-01f, -2.66144007e-01f, -3.49822007e-02f, -1.88746378e-01f, -7.32647404e-02f, 6.61292076e-02f, -1.07809834e-01f, -1.19879328e-01f,
  2.31231049e-01f, -2.85522759e-01f, -8.33155364e-02f, 1.42096415e-01f, -1.81968063e-01f, 1.67561337e-01f, -6.22214843e-03f, -3.11147004e-01f, -1.56144172e-01f, -2.70594973e-02f,
  -1.01942634e-02f, -1.24991879e-01f, -2.89752334e-02f, 1.37631014e-01f, 1.93228096e-01f, -1.37759512e-03f, -1.61408722e-01f, 6.18188307e-02f, 1.02620609e-01f, 1.54967263e-01f,
  2.64117062e-01f, -1.44430287e-02f, 1.64890558e-01f, 9.59035084e-02f, 4.31363024e-02f, -4.68202010e-02f, 1.85352176e-01f, -9.50517282e-02f, -1.43833175e-01f, 1.12828359e-01f,
  1.41653329e-01f, -1.04154907e-01f, 1.69929378e-02f, 1.80415422e-01f, -1.89519763e-01f, -1.41862988e-01f, 6.76819459e-02f, 2.39970818e-01f, -1.34283891e-02f, 8.35004449e-02f,
  4.84630167e-02f, 1.29665419e-01f, 2.64413655e-02f, 2.76535582e-02f, 2.58406345e-02f, 7.75841475e-02f, -6.35519251e-02f, -7.53656551e-02f, -2.23238647e-01f, 6.07201792e-02f,
  -2.37203136e-01f, 5.79650188e-03f, 1.49953187e-01f, 2.35898465e-01f, -1.08630218e-01f, -2.68327206e-01f, -8.54501948e-02f, -1.03349671e-01f, 5.20330444e-02f, -3.03676158e-01f,
  -1.86202332e-01f, 1.81934953e-01f, 3.50159019e-01f, -3.44864130e-01f, 2.88396567e-01f, -1.04317576e-01f, -1.67871043e-01f, -2.29952946e-01f, 6.62809685e-02f, 1.33164704e-01f,
  -1.85977787e-01f, -1.25776276e-01f, 1.68174803e-02f, 4.20781225e-02f, 2.41313145e-01f, -8.48345831e-02f, 1.22785538e-01f, -2.57100575e-02f, -1.87374175e-01f, -1.19313039e-01f,
  -1.61448643e-02f, -4.67964746e-02f, 4.93336432e-02f, 3.36843915e-02f, -6.21297173e-02f, 6.59777201e-04f, -1.87560786e-02f, -6.96092844e-02f, 2.14383192e-02f, 7.53908530e-02f,
  -1.81703851e-01f, 3.58489342e-02f, -1.38272032e-01f, 9.35472921e-03f, 1.61219120e-01f, -1.36438394e-02f, 1.32460833e-01f, 9.07719787e-03f, 1.22171775e-01f, 1.28479628e-03f,
  -1.58460841e-01f, -1.14599084e-02f, -1.63569406e-01f, -8.44059233e-03f, -1.34346364e-02f, -1.13262400e-01f, -1.08158402e-01f, 1.41693940e-02f, 2.89940368e-02f, -1.56820789e-01f,
  2.13678721e-02f, -2.36028269e-01f, -4.23001982e-02f, -2.74264570e-02f, -1.17008619e-01f, 1.52498335e-01f, -6.92794994e-02f, 2.66727567e-01f, -2.99615115e-02f, -4.55020852e-02f,
  -6.90648556e-02f, 1.77467078e-01f, 1.12042553e-03f, 1.88124642e-01f, 2.86223114e-01f, 1.79458886e-01f, -2.41781380e-02f, 8.57709944e-02f, -8.13759044e-02f, 2.41860837e-01f,
  2.14024156e-01f, -2.03649029e-01f, 1.71271160e-01f, -1.37162611e-01f, 2.18017116e-01f, 3.02495092e-01f, 2.03707982e-02f, -1.26614228e-01f, 1.30809158e-01f, 2.79524326e-02f,
  1.27223179e-01f, 6.16903305e-02f, 1.97740927e-01f, 1.66711152e-01f, 4.33382653e-02f, 1.73449870e-02f, -8.64578113e-02f, 6.02352545e-02f, -2.41108209e-01f, 7.98502238e-04f,
  3.34809758e-02f, -1.28583521e-01f, 5.66523820e-02f, -1.50543600e-01f, 9.59552359e-03f, 1.12770051e-01f, 1.70370311e-01f, 1.29416853e-01f, -4.25348617e-02f, 1.89097285e-01f,
  -1.00629712e-02f, -6.12450391e-02f, -5.84868044e-02f, 4.08198163e-02f, 1.24674179e-01f, -7.09933415e-02f, 6.30408376e-02f, -3.97890061e-03f, 8.56743604e-02f, 9.00754482e-02f,
  -1.05829477e-01f, 7.68487826e-02f, 4.63119783e-02f, 1.53814569e-01f, -8.53188932e-02f, 4.79575992e-02f, -1.09447487e-01f, 2.29361821e-02f, 6.22892641e-02f, 6.30932814e-03f,
  -1.16276175e-01f, 8.59954730e-02f, 3.41031551e-02f, 2.13805854e-01f, 1.85653836e-01f, -2.41945624e-01f, -1.65390261e-02f, -9.72217992e-02f, -4.18664217e-02f, 3.13060507e-02f,
  -1.82565406e-01f, -1.04118221e-01f, -1.86089933e-01f, 1.02988593e-01f, -1.25550374e-01f, -1.01089112e-01f, -1.67260215e-01f, -4.58279299e-03f, 3.80523652e-01f, 4.22598422e-02f,
  6.29554465e-02f, -9.68989804e-02f, -1.49869755e-01f, -1.20211720e-01f, -1.83718637e-01f, 4.05956656e-02f, 2.98729956e-01f, -3.24334204e-02f, 1.64317667e-01f, 1.27513990e-01f,
  1.03556952e-02f, 5.61166778e-02f, -9.12874937e-02f, 2.94440556e-02f, 5.84294423e-02f, 5.59032559e-02f, 1.49505287e-01f, -4.94959764e-02f, 1.80504262e-01f, -1.40019819e-01f,
  -3.07054631e-02f, -8.75294283e-02f, 7.08092749e-02f, 2.87818760e-01f, 3.04074921e-02f, -1.06672414e-01f, 9.71415415e-02f, 8.59073475e-02f, -2.17780396e-02f, 9.85131040e-03f,
  -1.47626743e-01f, -3.00422497e-02f, 4.54436913e-02f, -5.99569641e-02f, 4.44058590e-02f, -1.24861725e-01f, -6.16420247e-02f, -3.41422372e-02f, 9.58017260e-02f, 2.71267164e-02f,
  3.85383354e-03f, -1.25962332e-01f, -9.42301080e-02f, -9.92487594e-02f, -6.52902499e-02f, 2.51761436e-01f, 1.96574137e-01f, 9.78454053e-02f, 2.97800433e-02f, -2.25170165e-01f,
  -4.88680368e-03f, 9.86211523e-02f, 1.31086539e-02f, 5.84806167e-02f, -4.18966189e-02f, -2.21221745e-01f, -1.97867453e-02f, 1.82876825e-01f, -1.08054914e-01f, -7.47862607e-02f,
  9.55852568e-02f, 1.57715514e-01f, 2.88390338e-01f, 1.35923102e-01f, -7.77429435e-03f, 1.16501618e-02f, -9.04955268e-02f, -1.38948187e-01f, -1.37620911e-01f, 5.61995916e-02f,
  2.81758010e-01f, 2.69169128e-03f, 1.31614581e-01f, 1.63455103e-02f, 9.70438048e-02f, 8.06504637e-02f, -2.97615021e-01f, 6.25141636e-02f, 1.71935800e-02f, 4.84890603e-02f,
  1.42873138e-01f, 1.21301293e-01f, 3.90913570e-03f, 5.35921305e-02f, 6.11917078e-02f, -1.23557806e-01f, -1.76249892e-01f, 1.20866649e-01f, 1.25950780e-02f, -7.03603029e-03f,
  -8.25077761e-03f, 7.03443736e-02f, 1.15811275e-02f, -1.95574500e-02f, -5.17398417e-02f, -2.48686373e-02f, 4.39621694e-02f, 3.71556580e-02f, -6.31444827e-02f, -2.40720585e-02f,
  7.57738501e-02f, 8.64839181e-03f, 6.98325858e-02f, -1.70263812e-01f, -9.39337164e-02f, -1.72253042e-01f, -1.12781972e-01f, -8.85671079e-02f, -1.15984365e-01f, -5.30797243e-02f,
  1.02781340e-01f, 5.08585237e-02f, 1.76916733e-01f, 4.31092754e-02f, -5.57775646e-02f, -2.77510360e-02f, 2.61212587e-01f, -1.10107012e-01f, -2.62715131e-01f, 8.65620747e-02f,
  -2.92981267e-01f, 1.94803160e-02f, 4.94015813e-02f, 1.25549212e-01f, -8.52870494e-02f, -2.50864029e-01f, 5.54257780e-02f, 2.51402080e-01f, 1.77460223e-01f, 3.61222364e-02f,
  -1.89078197e-01f, -1.65639326e-01f, -6.20445460e-02f, -8.29371139e-02f, 1.00609988e-01f, 1.49084300e-01f, -6.17977604e-02f, 5.83032668e-02f, 5.14512397e-02f, 1.86057955e-01f,
  -1.45819187e-01f, -7.13547394e-02f, 1.50691152e-01f, -9.71329510e-02f, -7.16666356e-02f, -1.15445621e-01f, 8.91204178e-02f, 1.13961667e-01f, 9.98994261e-02f, -1.15429811e-01f,
  -7.98091441e-02f, 2.06645250e-01f, -5.55754900e-02f, -9.32116285e-02f, -6.17877245e-02f, -5.34961261e-02f, 4.26231101e-02f, 5.49758896e-02f, 3.05653084e-02f, -6.24500215e-02f,
  5.76699851e-03f, 1.92733914e-01f, 1.25340894e-01f, 6.92398623e-02f, -7.63183311e-02f, 1.19581021e-01f, -1.90788470e-02f, 9.16037112e-02f, -4.08710763e-02f, 2.72833044e-03f,
  5.77321574e-02f, -2.31046379e-01f, -5.26528712e-03f, -1.59442559e-01f, -1.05342574e-01f, 3.32698552e-03f, -3.26930374e-01f, -1.42554834e-01f, -3.17345709e-02f, 5.25942631e-02f,
  -2.76259482e-01f, -1.19414203e-01f, 4.94852290e-02f, -7.95727223e-02f, 2.16523960e-01f, -7.74445385e-02f, -2.03591838e-01f, 2.88075715e-01f, -1.86381206e-01f, 1.65412411e-01f,
  2.30945125e-02f, -1.78497925e-01f, -1.46737948e-01f, -7.11236447e-02f, -7.23074451e-02f, -1.37839292e-03f, -8.11672509e-02f, -2.46490706e-02f, -1.47131979e-01f, -9.24538001e-02f,
  -9.15829539e-02f, -2.04588771e-02f, 1.22378327e-01f, -1.08314797e-01f, 1.87105030e-01f, 7.03430027e-02f, -5.92311919e-02f, -4.61055227e-02f, 1.64085448e-01f, 1.43789411e-01f,
  -1.53559700e-01f, 1.81595404e-02f, 1.42879738e-02f, -7.16509148e-02f, -9.35026035e-02f, -1.43381283e-01f, 1.10940181e-01f, 6.32545725e-02f, 2.16681343e-02f, -8.55447724e-02f,
  -8.95676762e-02f, -1.41187057e-01f, 1.30542979e-01f, 6.40172660e-02f, -2.99087800e-02f, -8.07840005e-02f, -5.11104576e-02f, 6.28912523e-02f, -3.81657034e-02f, 5.48617765e-02f,
  -7.91551918e-02f, 1.38612613e-01f, 1.65696993e-01f, 2.16559153e-02f, 1.83267936e-01f, 8.58713612e-02f, 2.56489087e-02f, 4.48347479e-02f, -3.02607082e-02f, 9.45214778e-02f,
  -2.33265147e-01f, -2.08029985e-01f, -9.95881483e-02f, 2.23435819e-01f, -5.25230020e-02f, 9.51969475e-02f, -2.47622907e-01f, 1.76184177e-01f, -6.34611696e-02f, -9.19205099e-02f,
  -4.33789827e-02f, 2.01728061e-01f, -1.17783390e-01f, 4.57720160e-02f, 1.07465647e-01f, -8.95428210e-02f, -1.13097532e-02f, -1.32470563e-01f, -2.99129605e-01f, -1.64636359e-01f,
  3.69089395e-02f, -2.06079148e-02f, 1.90389961e-01f, 4.31417301e-02f, -1.79963127e-01f, 4.76891212e-02f, 9.83543992e-02f, -1.54089421e-01f, -2.64757350e-02f, 5.85579649e-02f,
  1.71742618e-01f, 8.50068629e-02f, 5.07363526e-04f, -4.68458682e-02f, 3.65785463e-03f, -6.93262322e-04f, 1.42918050e-01f, 4.69008498e-02f, -6.82448521e-02f, 5.34025207e-03f,
  -1.46810085e-01f, 7.93112814e-02f, -1.34793431e-01f, -1.09621264e-01f, -1.27780139e-01f, 2.22499594e-02f, 8.91167670e-02f, 6.26019090e-02f, -1.31880060e-01f, 1.14266396e-01f,
  -1.71361789e-01f, 1.27930194e-01f, -1.25231873e-02f, 1.34880930e-01f, -6.67320862e-02f, 2.20042393e-02f, -1.06798396e-01f, -1.48329094e-01f, -1.79168001e-01f, -7.91039597e-03f,
  1.44526467e-01f, 1.33745782e-02f, 7.47138783e-02f, -1.40436694e-01f, 2.22673580e-01f, -1.66618764e-01f, -1.13927364e-01f, -2.64787287e-01f, -1.78534180e-01f, -1.50711000e-01f,
  2.22223774e-01f, -2.57523000e-01f, 5.47669902e-02f, -4.54163067e-02f, -2.50412285e-01f, -7.12415297e-03f, -1.93622723e-01f, -1.25432760e-01f, 1.39167517e-01f, 1.98762998e-01f,
  -1.01624757e-01f, -5.51201664e-02f, -1.50237307e-01f, 7.49530196e-02f, -1.14665963e-01f, 1.06821559e-01f, -1.35775551e-01f, 1.79789498e-01f, 1.26965791e-01f, 1.21144205e-01f,
  1.20593995e-01f, 3.53181809e-01f, -4.71637286e-02f, 8.93428400e-02f, 2.04723403e-02f, 9.52631310e-02f, 1.61151096e-01f, -2.78448928e-02f, 6.29307851e-02f, -1.64298192e-02f,
  -8.08172002e-02f, -8.88368711e-02f, 9.00171101e-02f, 1.67082861e-01f, 1.02886409e-01f, 1.23028457e-02f
};

// L1_fan_Wp_bar (Shape: 26 x 64)
const int L1_fan_Wp_bar_rows = 26;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  1.28583647e-02f, 1.25480145e-01f, 1.34012476e-01f, 1.15400232e-01f, -2.31785271e-02f, 1.28151014e-01f, 2.13145345e-01f, -3.41090374e-03f, 2.00674646e-02f, 5.16966991e-02f,
  1.77400231e-01f, 4.14995700e-02f, 2.02034891e-01f, 8.23764279e-02f, 1.47472709e-01f, 3.05282231e-02f, 1.65574268e-01f, 2.14968994e-01f, 1.03854246e-01f, 9.35063064e-02f,
  7.61962146e-04f, 7.15573579e-02f, -1.03440300e-01f, 9.05881971e-02f, 1.67122647e-01f, -1.11627005e-01f, 1.09498776e-01f, 2.04509258e-01f, -2.39529461e-01f, 2.16472268e-01f,
  -1.20844610e-01f, -7.43269920e-02f, 2.87327975e-01f, -1.64433882e-01f, -1.27944708e-01f, 5.70013449e-02f, 1.27824955e-02f, -1.24166496e-01f, -1.21521421e-01f, -1.32529125e-01f,
  -4.25257115e-03f, 4.39695455e-03f, 1.48610026e-01f, 1.16683029e-01f, 1.21557541e-01f, -9.87806991e-02f, 2.62876740e-03f, -1.53906986e-01f, -4.41681705e-02f, 4.18467373e-02f,
  8.70122090e-02f, -2.61932444e-02f, 1.19115531e-01f, 1.50659271e-02f, -2.74248719e-02f, 2.20088586e-02f, 1.40696123e-01f, 1.15428530e-01f, 2.91518085e-02f, -1.68840457e-02f,
  -3.12636644e-02f, 2.75984257e-02f, 6.73206225e-02f, -3.34942825e-02f, 2.54379869e-01f, 7.44703338e-02f, 1.19735696e-03f, 6.56634048e-02f, 1.01097845e-01f, 9.83298011e-03f,
  2.00709552e-01f, 5.90541027e-02f, 2.28491992e-01f, -5.57918614e-03f, 1.40663192e-01f, 1.27704456e-01f, 1.92971900e-01f, -6.58878535e-02f, 2.80250907e-01f, 2.09290192e-01f,
  1.89302698e-01f, 1.04385205e-01f, 1.08543411e-01f, 2.57960647e-01f, 5.14233597e-02f, -1.69692546e-01f, -9.74645391e-02f, 3.23576719e-01f, 4.97518759e-03f, 1.81728601e-01f,
  8.68295357e-02f, -1.42024802e-02f, 1.52140364e-01f, -1.16120607e-01f, 2.28812069e-01f, 7.08319768e-02f, 2.27486435e-03f, -6.37162477e-02f, 2.90920138e-01f, 8.98506194e-02f,
  -1.19404189e-01f, 8.68620351e-02f, 7.86876772e-03f, 1.54041752e-01f, 1.68094039e-01f, 3.85232009e-02f, 2.64763296e-01f, 6.00547045e-02f, -1.76021010e-01f, 1.33700073e-01f,
  -7.42834359e-02f, 1.09055780e-01f, 5.58854975e-02f, -1.41442820e-01f, -2.15095252e-01f, 2.89529227e-02f, 1.16711847e-01f, -5.18425778e-02f, -1.27517179e-01f, 1.21984482e-01f,
  -8.16172212e-02f, 1.06669985e-01f, 1.96872681e-01f, 1.82311788e-01f, -3.21116783e-02f, -1.79853007e-01f, 9.47278664e-02f, -3.11081205e-02f, 1.11756220e-01f, 1.68469951e-01f,
  1.56119451e-01f, 1.87636744e-02f, 1.90807670e-01f, 4.35034893e-02f, 1.27791744e-02f, 7.97675699e-02f, -1.03953622e-01f, 8.82559866e-02f, 2.05676600e-01f, 1.64098218e-01f,
  1.72006920e-01f, 2.58217186e-01f, 1.25821412e-01f, 7.85872042e-02f, 1.25267741e-03f, 6.04280829e-03f, 1.86922774e-01f, -1.53364629e-01f, 3.39760706e-02f, -1.43476501e-01f,
  4.03566390e-01f, -9.15252492e-02f, -1.22474089e-01f, -2.75743634e-01f, -3.50244373e-01f, -2.92823553e-01f, 3.78082953e-02f, -2.25631729e-01f, -1.16919197e-01f, 1.65251032e-01f,
  -3.65239173e-01f, 9.18032695e-03f, -1.43122181e-01f, -1.53944597e-01f, -3.51534560e-02f, 1.97832793e-01f, 1.22551925e-01f, 6.07553497e-02f, -1.44564182e-01f, 2.59424210e-01f,
  1.30516738e-02f, 1.87688664e-01f, -5.05242348e-02f, 1.09281398e-01f, 2.32479677e-01f, 7.24181309e-02f, 1.42778590e-01f, 2.00175285e-01f, -2.50059336e-01f, 1.29256368e-01f,
  3.54932286e-02f, 9.22567397e-03f, 1.18170723e-01f, 1.71209887e-01f, 3.17824394e-01f, -1.33009866e-01f, -1.60289645e-01f, -1.48617163e-01f, 1.33015335e-01f, 1.23901784e-01f,
  2.50399917e-01f, 6.24157637e-02f, 9.76748243e-02f, 8.82664323e-02f, 1.89800277e-01f, 2.42877170e-01f, 1.02885552e-01f, 2.88676582e-02f, 2.29581054e-02f, 2.47875780e-01f,
  2.04969272e-02f, 1.77113228e-02f, -7.65150459e-03f, 1.67161658e-01f, 1.97469182e-02f, 3.38663757e-02f, -8.48835260e-02f, 6.93051368e-02f, -3.51606719e-02f, -5.00110537e-02f,
  5.22292256e-02f, 2.23689117e-02f, -1.12192228e-01f, -1.79518647e-02f, 1.53756097e-01f, 1.17682945e-02f, -1.94741618e-02f, -8.92005265e-02f, -2.73062922e-02f, 6.75124526e-02f,
  2.63978630e-01f, -1.98182732e-01f, 5.11470363e-02f, 1.97526813e-02f, -1.47557974e-01f, -9.17801112e-02f, 6.08646274e-02f, 1.03021294e-01f, 7.47632086e-02f, -2.06894353e-01f,
  -1.11741528e-01f, -1.85614321e-02f, 1.80375114e-01f, 1.21066697e-01f, 1.41276523e-01f, -8.92758146e-02f, -1.50692135e-01f, -7.52325282e-02f, 4.73775119e-02f, 1.49433181e-01f,
  3.75638008e-02f, 1.69240132e-01f, 1.51565015e-01f, 8.76598954e-02f, 2.22347621e-02f, 7.47984797e-02f, 8.54339153e-02f, 4.12893854e-03f, -1.08611993e-01f, 1.26081944e-01f,
  -1.98558476e-02f, -1.14526726e-01f, -7.62558281e-02f, 2.71345247e-02f, 2.17423635e-03f, 2.53374670e-02f, 7.94178843e-02f, 3.12643312e-03f, 1.72703594e-01f, 3.20944749e-02f,
  1.55592918e-01f, -3.35764810e-02f, 1.40878037e-01f, 1.29968151e-01f, -1.01638526e-01f, 5.32983653e-02f, -6.30160570e-02f, -2.69486606e-02f, 2.28714906e-02f, 1.55904338e-01f,
  -1.18196411e-02f, 2.02176534e-02f, 3.86303626e-02f, -5.33833960e-03f, -9.95357707e-03f, 8.83847699e-02f, 1.17006563e-01f, -1.64852619e-01f, 3.29504604e-03f, -2.22831503e-01f,
  -9.37926769e-02f, 2.93386336e-02f, -1.52016789e-01f, -1.72169268e-01f, 1.42501548e-01f, -1.71024203e-01f, 2.79571544e-02f, 3.28483097e-02f, -2.23788083e-01f, -7.50172362e-02f,
  5.19356094e-02f, 1.94045436e-02f, 1.84911132e-01f, 1.69972166e-01f, -8.41515488e-04f, -6.20311946e-02f, 1.00792255e-02f, 4.04975303e-02f, -4.59288508e-02f, 3.51708420e-02f,
  1.73241243e-01f, 9.10109282e-02f, 8.85711014e-02f, 2.15393901e-01f, 1.73657715e-01f, 3.89341593e-01f, -2.18143225e-01f, -4.02291156e-02f, 1.10089034e-02f, 3.37384120e-02f,
  2.49549851e-01f, 1.53816342e-01f, 2.14435503e-01f, 4.92421503e-04f, 1.22132145e-01f, 5.88851329e-03f, 1.61482170e-01f, 2.41086707e-01f, 1.38922393e-01f, -1.39762461e-01f,
  -5.38250953e-02f, 5.19219693e-03f, 7.79444799e-02f, 1.29277483e-01f, 1.82401285e-01f, 1.08798712e-01f, 1.29491761e-02f, 2.04031870e-01f, 4.05628383e-02f, 4.07285430e-02f,
  -3.93603332e-02f, 7.47988969e-02f, -7.43056908e-02f, 1.23677902e-01f, -3.53412889e-02f, -2.17115553e-03f, -2.61094216e-02f, 2.01058477e-01f, 1.29740253e-01f, -1.38401091e-01f,
  -1.47947133e-01f, -1.20044306e-01f, 5.68050891e-02f, -6.71513081e-02f, -2.35276818e-02f, -2.10479811e-01f, -1.24042563e-01f, -7.18267336e-02f, 1.24677382e-01f, 1.58064328e-02f,
  9.04797111e-03f, -6.39960393e-02f, -1.60523593e-01f, 1.33165747e-01f, 8.33203197e-02f, -1.68702938e-02f, -1.69151336e-01f, -1.22949861e-01f, -1.44709190e-02f, 1.60394281e-01f,
  1.17408507e-01f, 1.43379375e-01f, 1.52651310e-01f, 1.75718367e-01f, -2.18505591e-01f, 1.44557178e-01f, -1.83162931e-02f, 1.98555782e-01f, 1.81612849e-01f, 2.50505328e-01f,
  2.56756723e-01f, -8.94297063e-02f, -3.27967368e-02f, -6.32196814e-02f, -7.98733830e-02f, 3.30557600e-02f, 9.76851285e-02f, 1.16036370e-01f, -1.78011954e-02f, 9.11337286e-02f,
  1.86337054e-01f, 2.65882537e-02f, 1.64074883e-01f, 1.53347492e-01f, 6.38844594e-02f, -8.54348764e-02f, 3.02704535e-02f, 3.17994580e-02f, 5.64397406e-03f, -3.14736180e-02f,
  8.23811814e-03f, 8.26919544e-03f, 2.08879393e-02f, -2.25328114e-02f, -5.07455654e-02f, 9.39738229e-02f, -7.73401037e-02f, 1.01681799e-01f, -1.06694929e-01f, -7.80918226e-02f,
  -6.22224174e-02f, 1.37179986e-01f, -5.24463877e-02f, -3.71285714e-02f, 8.51474004e-04f, -9.75312814e-02f, -6.97419420e-02f, -7.90067241e-02f, 1.20249428e-01f, -1.40165240e-01f,
  -1.16860263e-01f, -3.13211903e-02f, 1.07935861e-01f, 2.88779754e-02f, 9.95207205e-02f, -2.95264889e-02f, 1.44570218e-02f, -3.73769812e-02f, -1.55415675e-02f, 6.57890365e-02f,
  2.10737195e-02f, 5.42406514e-02f, 7.23262727e-02f, 3.22730541e-02f, 3.62204090e-02f, 7.55993947e-02f, 4.38636215e-03f, -4.50854599e-02f, -3.62078808e-02f, 6.88458458e-02f,
  5.00651151e-02f, 2.57667038e-04f, 3.24727856e-02f, 8.55001137e-02f, 1.15156569e-01f, 8.93981457e-02f, -1.07500471e-01f, -8.50756019e-02f, 8.98860842e-02f, 6.27889782e-02f,
  5.29720541e-03f, -1.11912645e-01f, 1.09630162e-02f, -2.30876617e-02f, -5.24040721e-02f, 2.44066902e-02f, 6.03343062e-02f, 1.68765672e-02f, 2.29115542e-02f, 1.03778303e-01f,
  -5.72873317e-02f, -7.53612965e-02f, 1.59922168e-02f, -2.52474025e-02f, 2.04157203e-01f, 8.75584260e-02f, 1.96863543e-02f, -4.36913036e-02f, 8.43388587e-02f, 1.28997728e-01f,
  2.52451468e-03f, 3.71756107e-02f, 1.72192782e-01f, -4.15375689e-03f, 1.19062297e-01f, 1.18681192e-01f, -1.31436855e-01f, 1.76091075e-01f, 1.97840810e-01f, 1.76211402e-01f,
  3.48028205e-02f, -3.02396975e-02f, -1.46011025e-01f, 2.03998953e-01f, -2.75078658e-02f, -1.11718506e-01f, -1.16580389e-01f, -1.22145072e-01f, -6.67168424e-02f, 1.54494360e-01f,
  -2.69469284e-02f, 4.03894633e-02f, -1.09935001e-01f, 1.93294808e-02f, 2.50550091e-01f, 1.81380972e-01f, 4.83112708e-02f, -3.08021922e-02f, -1.80867445e-02f, 9.76896062e-02f,
  -8.86705071e-02f, 8.52355286e-02f, 2.31951594e-01f, 2.48122334e-01f, 6.29159138e-02f, 2.18444660e-01f, -3.95952277e-02f, 1.44454315e-01f, -9.05547664e-03f, 7.62529746e-02f,
  2.53681447e-02f, 8.70820209e-02f, -5.02112657e-02f, -1.00142337e-01f, -5.72641157e-02f, 8.74763802e-02f, 2.97861956e-02f, -3.72665077e-02f, -1.08454868e-01f, -8.14675994e-04f,
  -6.84107319e-02f, 4.81433719e-02f, -7.75177926e-02f, 7.30506927e-02f, -4.00485322e-02f, 1.56640131e-02f, 6.17343970e-02f, 1.68007001e-01f, 4.54392731e-02f, -3.55490819e-02f,
  -3.71608287e-02f, 4.51311171e-02f, -3.35930921e-02f, 1.03623681e-01f, 2.28125751e-02f, 1.03602149e-01f, -4.29713689e-02f, -4.58616316e-02f, 4.79153320e-02f, 1.95103630e-01f,
  -1.07268706e-01f, 4.18837480e-02f, -9.23570395e-02f, 4.35171723e-02f, 4.09098715e-02f, -1.17298886e-01f, 6.65254220e-02f, -6.27246127e-02f, 1.70521796e-01f, -5.04092239e-02f,
  -1.05715774e-01f, 1.21046059e-01f, -4.37591523e-02f, -3.26498672e-02f, -2.16114875e-02f, -7.35329241e-02f, 5.12381345e-02f, 6.53041303e-02f, -3.07658613e-02f, 4.84822839e-02f,
  -7.01576546e-02f, -4.16406170e-02f, -1.19458191e-01f, 1.85447931e-02f, -1.34029284e-01f, -1.36825353e-01f, 2.42085122e-02f, 3.49995010e-02f, 1.02874406e-01f, 1.06056683e-01f,
  4.62981910e-02f, 4.92443778e-02f, 1.65111318e-01f, -5.50293401e-02f, -3.07301041e-02f, 8.57351497e-02f, -2.61015445e-02f, -9.12205204e-02f, -8.26751366e-02f, 2.70000789e-02f,
  9.17583480e-02f, 8.65435302e-02f, 1.18970044e-01f, 1.89660102e-01f, -1.02246795e-02f, 1.55149713e-01f, 1.50046706e-01f, 2.97141075e-02f, -2.58444194e-02f, 1.80932492e-01f,
  -1.97421871e-02f, 2.59827748e-02f, -5.44947162e-02f, 1.12861589e-01f, 8.10119435e-02f, 1.12842657e-01f, 8.41689333e-02f, -4.24298719e-02f, 1.06982276e-01f, -2.44506486e-02f,
  1.46275207e-01f, 2.03162000e-01f, -6.88372850e-02f, 1.40926510e-01f, 6.28179163e-02f, 1.39476240e-01f, -1.38569206e-01f, -1.18672349e-01f, -5.26339859e-02f, 9.29625854e-02f,
  5.33147752e-02f, -3.59567069e-02f, -5.23133483e-03f, 1.51276037e-01f, -1.53679794e-04f, -1.02418728e-01f, -1.05532154e-01f, 9.56662893e-02f, 1.96905613e-01f, -2.95951396e-01f,
  1.54130578e-01f, -1.80317119e-01f, -1.36818111e-01f, 8.57159644e-02f, 9.01944712e-02f, 4.69787382e-02f, -1.23516601e-02f, 8.12123939e-02f, 1.51030689e-01f, 6.69486672e-02f,
  8.38615224e-02f, 3.62161244e-03f, 7.30780661e-02f, 1.02760158e-02f, -1.40193757e-02f, 1.06866300e-01f, -1.19887833e-02f, -5.39947338e-02f, -3.29844980e-03f, 9.83220339e-02f,
  -7.17939213e-02f, -1.44923195e-01f, -8.04044902e-02f, 5.40399691e-03f, 2.06649583e-02f, -2.79594660e-02f, -1.09889537e-01f, 2.61109412e-01f, -1.58393502e-01f, 6.10993430e-02f,
  6.23069964e-02f, 1.21081308e-01f, 9.37183574e-02f, -1.28499344e-02f, -3.24865170e-02f, 8.13459381e-02f, -1.03408275e-02f, -8.27712193e-02f, 2.09720582e-02f, 4.91681360e-02f,
  2.66510826e-02f, -1.30407289e-01f, 5.09357192e-02f, 5.59990741e-02f, 6.75301477e-02f, -8.47033262e-02f, 1.04258820e-01f, 7.40095004e-02f, -3.62484604e-02f, 1.63704723e-01f,
  -3.76807414e-02f, 5.69399185e-02f, 1.07934661e-01f, 4.90722358e-02f, 1.04663976e-01f, 3.92300300e-02f, 1.10305898e-01f, 7.82409385e-02f, -1.30561711e-02f, 4.32668999e-02f,
  -7.44407326e-02f, -5.82624935e-02f, 1.17846638e-01f, 1.13468235e-02f, 1.46730974e-01f, 9.18505788e-02f, -3.42936404e-02f, 2.95081139e-02f, 1.20293915e-01f, -6.47122785e-02f,
  1.78625450e-01f, 7.14885145e-02f, 9.63074118e-02f, 9.43465829e-02f, -1.21336980e-02f, 3.19167599e-02f, -1.46340609e-01f, 3.24415974e-02f, -5.26122041e-02f, -3.99799123e-02f,
  -7.79330656e-02f, 5.67792132e-02f, -1.07711181e-01f, -9.85200256e-02f, -3.34243104e-02f, -5.89785613e-02f, 1.74561273e-02f, -7.38592148e-02f, 2.93504149e-02f, 1.95259914e-01f,
  -9.69056785e-02f, -4.94954586e-02f, 1.52885979e-02f, -8.95918235e-02f, 1.17261307e-02f, 2.22244456e-01f, -2.09414458e-04f, -2.37419140e-02f, 1.05964206e-02f, 4.54034321e-02f,
  9.81357843e-02f, 6.06270097e-02f, 2.13797361e-01f, 2.73481071e-01f, 1.30597785e-01f, 1.72904283e-02f, 7.88271278e-02f, -1.83852687e-02f, 4.48185466e-02f, 2.11250916e-01f,
  2.24292934e-01f, 3.52010638e-01f, 1.70696929e-01f, -1.33476872e-02f, -1.01729766e-01f, 3.55609646e-03f, -8.92665014e-02f, 2.20543072e-01f, 2.54400104e-01f, 2.16926754e-01f,
  2.88819790e-01f, -4.57053557e-02f, 5.51399949e-04f, 1.47567034e-01f, 1.36299402e-01f, -1.05790794e-01f, 3.48051280e-01f, -2.12241009e-01f, 2.02553108e-01f, -1.06532753e-01f,
  -1.64403424e-01f, 2.18993425e-01f, 1.89149737e-01f, -9.32186469e-02f, 9.59908441e-02f, -2.31491309e-02f, 1.06810004e-01f, -1.13979161e-01f, -1.92361116e-01f, 3.17833163e-02f,
  -6.06730022e-02f, -3.28160040e-02f, 1.25843445e-02f, -3.37442830e-02f, 2.54919589e-01f, -1.09648434e-02f, -4.25440781e-02f, -2.87479628e-02f, 9.42483172e-02f, -1.02194928e-01f,
  -1.13730155e-01f, 3.40189040e-02f, 1.02359019e-01f, 2.29819357e-01f, -1.14762798e-01f, -6.82279691e-02f, 1.55108059e-02f, 8.09023082e-02f, 3.19112763e-02f, 8.97618532e-02f,
  1.72098741e-01f, 1.09804146e-01f, 1.56118438e-01f, 8.28193650e-02f, 8.65831226e-03f, 1.43134385e-01f, 5.59661277e-02f, 1.29196316e-01f, 8.99448842e-02f, 5.31575046e-02f,
  1.58936352e-01f, -9.30114239e-02f, 4.27492745e-02f, -7.76463142e-03f, -2.52684113e-02f, 6.91129714e-02f, 1.10434353e-01f, -1.72255039e-01f, -2.62548756e-02f, 5.65815009e-02f,
  1.48276880e-01f, 1.28587395e-01f, 1.89482018e-01f, -9.69339535e-02f, 1.71396676e-02f, 3.98857780e-02f, -4.98311268e-03f, 7.69534260e-02f, -9.93339792e-02f, 4.35019433e-02f,
  1.95410252e-01f, -2.29488894e-01f, 1.15569070e-01f, -1.41761258e-01f, -1.48381963e-01f, -5.12733795e-02f, -7.84666836e-02f, -2.10486725e-02f, 8.78393352e-02f, 1.38452098e-01f,
  -1.33383572e-01f, -1.01941787e-01f, -3.40610817e-02f, 5.18026836e-02f, 3.60335596e-02f, 3.13855521e-02f, -1.67251471e-02f, -1.03987321e-01f, 1.23360366e-01f, -1.13426112e-01f,
  -1.17227450e-01f, -5.05484454e-02f, -9.52655226e-02f, 6.08991981e-02f, -1.36695877e-01f, 3.98691297e-02f, -1.13089554e-01f, -3.59774269e-02f, 9.69841033e-02f, 7.66478628e-02f,
  2.45479867e-02f, -1.32623743e-02f, 2.00789012e-02f, 1.87098309e-01f, 2.33030513e-01f, 2.02188820e-01f, 1.10827968e-01f, 1.30438104e-01f, 1.89103484e-02f, -3.16569395e-02f,
  1.24741331e-01f, 2.15589516e-02f, -4.40500397e-03f, 9.23945680e-02f, 1.35711715e-01f, -1.67091563e-02f, 1.10912286e-01f, -5.29786684e-02f, -1.93034075e-02f, -1.53361797e-01f,
  1.38539687e-01f, -8.63660872e-02f, 6.74633384e-02f, 1.21619083e-01f, -4.35060300e-02f, -2.01123506e-01f, -1.03921756e-01f, -3.75254303e-02f, -1.44645706e-01f, -2.53241569e-01f,
  3.23293993e-04f, 5.72146475e-02f, 1.17975146e-01f, -1.01806678e-01f, -2.41305366e-01f, 1.71667561e-01f, -1.17687516e-01f, 1.63147897e-01f, 4.98411804e-02f, -1.87833145e-01f,
  6.33355007e-02f, -7.21953949e-03f, 9.08940285e-02f, -1.15832321e-01f, -1.00556888e-01f, 1.76358238e-01f, -1.07784346e-02f, -1.08487152e-01f, -3.63716632e-02f, 8.44248980e-02f,
  8.72129872e-02f, -1.39913127e-01f, -1.61096767e-01f, 1.43640190e-02f, -3.53039801e-02f, 7.68493786e-02f, 1.49866700e-01f, 1.26963019e-01f, -3.44387703e-02f, -1.18849792e-01f,
  7.20270351e-02f, -7.65398145e-02f, -2.01642290e-02f, -4.06733565e-02f, -3.48680429e-02f, -1.57365710e-01f, 7.63719622e-03f, -9.51242968e-02f, 1.21544197e-01f, -1.01552986e-01f,
  1.70092180e-01f, 1.46408662e-01f, 5.54734059e-02f, 2.91714240e-02f, 5.56043237e-02f, -4.23191860e-02f, 3.16949300e-02f, 9.89208519e-02f, 4.86383885e-02f, -2.59526465e-02f,
  1.86643712e-02f, 4.97780591e-02f, 2.59913020e-02f, 1.00476108e-01f, 8.56133997e-02f, 1.09501287e-01f, 9.95208323e-02f, -1.81316555e-01f, -7.45479390e-02f, 2.62659770e-02f,
  -1.37793437e-01f, 6.42603263e-02f, 4.87042628e-02f, 9.19248071e-03f, 2.77727604e-01f, -2.26320505e-01f, 2.93038815e-01f, -1.34464815e-01f, -5.28692715e-02f, 1.38243064e-01f,
  2.41454151e-02f, 1.12156510e-01f, -1.02794588e-01f, 3.24959904e-02f, -7.53872544e-02f, -1.27550252e-02f, 3.37527990e-02f, -1.10441849e-01f, 1.15692288e-01f, 2.06622109e-01f,
  -1.26089275e-01f, -2.97475401e-02f, 3.86933498e-02f, 2.25237429e-01f, 1.02048852e-01f, 2.06581190e-01f, 3.83734852e-02f, 5.55760786e-02f, 1.06256939e-02f, 3.77141200e-02f,
  -1.52864039e-01f, 2.88658589e-01f, 1.91844627e-01f, 1.31133003e-02f, -4.37854743e-03f, -9.38612372e-02f, 7.16870129e-02f, -1.50023848e-01f, 2.98915595e-01f, 3.81343463e-03f,
  -7.56626129e-02f, 1.51356775e-02f, 9.08528566e-02f, 8.43538791e-02f, 4.05428298e-02f, -6.42324910e-02f, -7.83126950e-02f, -1.48343546e-02f, -1.04158493e-02f, -1.92689877e-02f,
  -1.38164654e-01f, 1.04334608e-01f, -4.74414416e-02f, -8.60803127e-02f, -1.07589252e-01f, 1.02303639e-01f, -8.81664157e-02f, -7.38137737e-02f, -9.33185145e-02f, 1.52698204e-01f,
  7.27729276e-02f, -7.00203283e-03f, 7.60013834e-02f, 1.11848481e-01f, -1.46700274e-02f, 1.42303649e-02f, 1.31781390e-02f, 1.09685823e-01f, -4.14197445e-02f, -1.28203511e-01f,
  1.36251315e-01f, -4.04074453e-02f, 8.55387822e-02f, 3.97256054e-02f, 9.82277840e-02f, 9.64984298e-02f, -1.64959487e-02f, 9.01473965e-03f, -1.25856325e-01f, 9.25524384e-02f,
  1.52137890e-01f, 3.65982577e-02f, 1.06765755e-01f, -2.91496031e-02f, 1.03585802e-01f, 7.20693776e-03f, 9.70910490e-02f, -1.31085431e-02f, -7.42628872e-02f, -8.65741894e-02f,
  1.06338330e-01f, -1.01650797e-01f, -2.06410550e-02f, -7.35762566e-02f, -3.47412713e-02f, 4.71952073e-02f, -6.62308782e-02f, 8.97243153e-03f, 1.22091196e-01f, -1.72856934e-02f,
  -1.05387792e-01f, -2.65875850e-02f, 9.87252444e-02f, -2.91794110e-02f, -1.88139901e-02f, -1.00849848e-03f, 7.77152777e-02f, 5.59264794e-02f, 1.16677284e-01f, 1.97747387e-02f,
  -1.43583948e-02f, 7.02892467e-02f, -8.69171917e-02f, 5.72189242e-02f, 7.87773877e-02f, 1.70820743e-01f, -7.52620697e-02f, 1.18901052e-01f, -1.27688348e-01f, -4.59962934e-02f,
  -4.25149575e-02f, -1.00140132e-01f, 9.70645845e-02f, 8.34902003e-02f, 3.79275046e-02f, -1.02180697e-01f, 1.81190416e-01f, -1.46182001e-01f, -1.03526339e-01f, -3.88037339e-02f,
  4.98698801e-02f, -1.43455073e-01f, 4.92103472e-02f, 1.41415047e-04f, -7.92708099e-02f, -8.35075218e-04f, 6.46013469e-02f, 8.55856538e-02f, 2.60829413e-03f, -5.56021295e-02f,
  -1.02753036e-01f, -1.43408358e-01f, 6.83725849e-02f, 2.99955788e-03f, 3.76566723e-02f, 9.28022563e-02f, -2.50849351e-02f, 8.61164704e-02f, 1.04935184e-01f, 4.95662540e-02f,
  1.42321885e-01f, -1.76039599e-02f, -8.71895999e-02f, 7.40270466e-02f, 9.24442783e-02f, 6.47861585e-02f, 3.29790488e-02f, -9.68137681e-02f, -6.90504313e-02f, -2.28225533e-02f,
  1.53962940e-01f, -1.54855312e-03f, -3.32019739e-02f, -2.31911559e-02f, 7.97952265e-02f, 2.47968584e-01f, 1.41172260e-01f, 1.11723423e-01f, -1.46793634e-01f, 5.44787496e-02f,
  1.68107510e-01f, 1.82486862e-01f, 1.65683612e-01f, 1.67211056e-01f, -2.83645038e-02f, 1.24016643e-01f, -1.43410563e-01f, 7.01223239e-02f, 1.00830279e-01f, 1.18074365e-01f,
  1.87106684e-01f, 1.87363118e-01f, -2.32894327e-02f, 5.68665192e-02f, -1.44420803e-01f, 8.25465918e-02f, 7.94915631e-02f, 1.70104161e-01f, -2.70184189e-01f, -2.81884968e-01f,
  1.30982354e-01f, 5.19950911e-02f, 7.62348175e-02f, -1.33269966e-01f, 1.47898141e-02f, 2.01913878e-01f, 2.32816353e-01f, -3.22848618e-01f, 1.52805090e-01f, -1.41268909e-01f,
  -1.26847446e-01f, -2.27006972e-01f, 8.93336162e-02f, -5.81388101e-02f, -4.76997420e-02f, 6.47320179e-03f, -1.05005756e-01f, 1.63312420e-01f, 2.77972788e-01f, 1.71853468e-01f,
  2.46318161e-01f, 7.48680579e-03f, -1.93913968e-03f, 8.01619440e-02f, -5.20950742e-02f, -7.28402585e-02f, 1.81764755e-02f, 2.07609892e-01f, -5.22375740e-02f, -9.13340598e-03f,
  5.31766154e-02f, 5.44546545e-02f, -5.68336691e-04f, 8.97946507e-02f, -6.93814605e-02f, 6.29205033e-02f, 1.26610938e-02f, 1.73725978e-01f, -1.79922450e-02f, 2.63352811e-01f,
  5.45015819e-02f, 6.01534806e-02f, 1.33711889e-01f, -5.69921993e-02f, 1.11787423e-01f, -1.24341557e-02f, 9.71919671e-02f, -3.79636027e-02f, 5.23925833e-02f, -6.94173723e-02f,
  -1.34213725e-02f, -6.36029765e-02f, 1.12354547e-01f, 3.00632920e-02f, 1.21413551e-01f, 2.21913215e-03f, 3.86300348e-02f, 1.37743071e-01f, -6.06034137e-02f, -7.02510998e-02f,
  3.45537066e-02f, -5.65201938e-02f, -6.92794546e-02f, 4.38964404e-02f, 1.77904010e-01f, 1.20593734e-01f, -9.79397893e-02f, -1.08872110e-03f, 3.11514474e-02f, -1.70902908e-01f,
  -4.92003374e-02f, 7.50381872e-02f, -1.83018506e-01f, -7.29975775e-02f, 1.40541140e-02f, -6.50167419e-03f, 2.91965762e-03f, -1.25564069e-01f, -2.11346030e-01f, 4.52630669e-02f,
  -4.33137454e-03f, 8.10360014e-02f, 4.88770455e-02f, 2.04762802e-01f, 3.60012949e-02f, 1.29984701e-02f, 1.93412639e-02f, 7.42323697e-02f, 4.37727012e-02f, 9.32237953e-02f,
  6.61360621e-02f, 2.80261002e-02f, 3.71027961e-02f, -5.30224517e-02f, 5.38938167e-03f, 1.18447125e-01f, -1.51307389e-01f, -3.12484540e-02f, 5.67026809e-02f, -1.09048724e-01f,
  -9.22673941e-02f, -1.17719196e-01f, 1.27589285e-01f, 1.77879035e-02f, 1.67278573e-01f, 5.92701510e-02f, 5.71553335e-02f, -3.95395458e-02f, 1.95739433e-01f, 9.19125602e-02f,
  1.56964034e-01f, 1.79879531e-01f, -1.38892103e-02f, 1.63201049e-01f, -5.20235859e-02f, 1.43374503e-01f, 4.66627851e-02f, 1.30090788e-01f, 1.99396074e-01f, 1.34996101e-01f,
  -1.34800509e-01f, 2.28186767e-03f, -1.07086554e-01f, 1.48307711e-01f, 2.23886549e-01f, -1.42331466e-01f, -2.05915466e-01f, 2.96639353e-02f, 1.86131135e-01f, -1.29005551e-01f,
  5.01698256e-02f, -3.05927098e-01f, -1.42774329e-01f, 4.56180200e-02f, 6.90341219e-02f, 1.19884377e-02f, -1.47542074e-01f, -1.29837185e-01f, -1.46335261e-02f, -1.78873166e-01f,
  -5.07709719e-02f, -1.59866467e-01f, -1.00061551e-01f, -8.29521716e-02f, -1.15692250e-01f, 2.67610345e-02f, 6.39974400e-02f, 1.95454672e-01f, -1.03258677e-01f, -7.93262199e-02f,
  -1.45287151e-02f, 2.49238536e-02f, 8.30375180e-02f, -1.31063178e-01f, 3.42168100e-02f, -3.81083600e-02f, 2.99221724e-01f, 1.78938191e-02f, -1.29590139e-01f, 1.51518388e-02f,
  -3.24379057e-02f, -2.70212013e-02f, 1.73249274e-01f, 1.08296148e-01f, -1.34748116e-01f, -1.72767341e-01f, 2.03351453e-01f, 1.31547228e-01f, 4.29029800e-02f, 1.86767429e-01f,
  -6.71194345e-02f, 9.12598595e-02f, -9.84725580e-02f, 4.86289039e-02f, -1.34087401e-02f, 7.78270438e-02f, 1.27728999e-01f, -7.90985078e-02f, -1.30886376e-01f, 7.87025690e-02f,
  -8.57271925e-02f, -5.84618226e-02f, -1.76590458e-02f, 2.16612443e-01f, -2.20474508e-03f, 1.41813979e-01f, -3.48561928e-02f, 6.96762279e-02f, 1.81166634e-01f, -3.04899886e-02f,
  7.03549162e-02f, -2.08124593e-01f, -4.43379134e-02f, -6.87605739e-02f, 1.59206148e-02f, -9.74799991e-02f, -6.38946239e-03f, 1.37694761e-01f, 1.06828153e-01f, 3.62100415e-02f,
  -1.10267751e-01f, -1.18826613e-01f, 1.92164015e-02f, -9.35989339e-03f, -2.16282129e-01f, -9.39326286e-02f, -1.27610967e-01f, 8.11026916e-02f, -6.69768602e-02f, -8.83505568e-02f,
  7.90702179e-02f, -1.56944141e-01f, 1.65071338e-01f, 1.82724938e-01f, -2.43508518e-02f, -6.32497072e-02f, -1.84288457e-01f, 7.48001188e-02f, 1.63223401e-01f, 9.77709740e-02f,
  -7.81068280e-02f, -6.15717024e-02f, 2.73298938e-03f, 2.44164118e-03f, 7.06885755e-02f, 4.61737104e-02f, 2.73410559e-01f, 5.58587871e-02f, -4.45629321e-02f, 6.43311962e-02f,
  1.96048379e-01f, 1.14446908e-01f, -2.09651850e-02f, -8.12422112e-02f, -1.17870308e-01f, -8.12475011e-02f, -6.44798353e-02f, -8.03750604e-02f, 1.08885378e-01f, -7.62939267e-03f,
  2.83819009e-02f, -2.42983084e-02f, 8.76126736e-02f, 2.04254985e-02f, 8.27759951e-02f, 1.07057132e-01f, 1.43903643e-01f, 1.58477008e-01f, -1.79832857e-02f, 1.01636626e-01f,
  1.54311419e-01f, 9.47670862e-02f, -6.07531257e-02f, -2.13299379e-01f, -7.44842440e-02f, 3.80028114e-02f, -7.60954991e-02f, -1.85982779e-01f, 1.45477980e-01f, -6.18966594e-02f,
  3.94771621e-02f, 1.34144127e-01f, -1.64735436e-01f, 2.44059488e-01f, 1.33806802e-02f, -1.13352388e-01f, 1.40916914e-01f, 5.23405559e-02f, -1.39677107e-01f, 7.29881153e-02f,
  5.62099218e-02f, -1.02026954e-01f, -3.36714014e-02f, 6.49026036e-02f, 1.20803043e-01f, -2.11800858e-02f, -6.81856796e-02f, 5.59557006e-02f, 2.48674080e-02f, 2.37599779e-02f,
  5.85844964e-02f, 1.06384702e-01f, 1.59037977e-01f, 4.73765060e-02f, 1.39535785e-01f, 5.73347658e-02f, 7.71964192e-02f, -6.96585625e-02f, 6.44019395e-02f, 1.05540685e-01f,
  2.04974785e-01f, -7.38944218e-04f, -1.73318945e-02f, -6.21592700e-02f, 1.21967129e-01f, 3.11104469e-02f, 8.03806931e-02f, 1.41170412e-01f, -1.97839588e-02f, 1.42746821e-01f,
  8.83570537e-02f, -9.73997042e-02f, 2.08956804e-02f, 1.15312569e-01f, 1.39191717e-01f, 8.68785530e-02f, 1.34345114e-01f, 1.12837240e-01f, 1.09653279e-01f, 1.63011774e-02f,
  7.50827193e-02f, -4.32814695e-02f, 4.57282364e-02f, 1.92358300e-01f, 5.98946325e-02f, -1.21565327e-01f, 7.12584332e-02f, 1.97461501e-01f, -9.67902616e-02f, -1.37431443e-01f,
  -1.93562612e-01f, 2.45712325e-01f, 1.08757399e-01f, 4.47718911e-02f, 2.17107981e-01f, 1.16515450e-01f, -1.47160456e-01f, -1.36198029e-02f, 8.69235303e-03f, -7.37074986e-02f,
  -2.85726916e-02f, 3.49478759e-02f, 1.89412414e-04f, 1.54655902e-02f, -2.96503305e-01f, -7.43209869e-02f, -5.61880916e-02f, -6.74353167e-02f, -2.16950119e-01f, 2.46283393e-02f,
  1.90950274e-01f, 4.53168564e-02f, -4.76665348e-02f, -1.26223952e-01f, 1.04294650e-01f, 2.10876204e-02f, -9.09142382e-03f, 4.69884463e-03f, 9.50628370e-02f, 3.27365883e-02f,
  1.48117229e-01f, 1.52700678e-01f, -1.94611713e-01f, -8.43742192e-02f, -2.65036244e-02f, -7.59555027e-03f, -9.59075913e-02f, 4.71846387e-02f, -1.57930002e-01f, 3.01069077e-02f,
  -1.42444775e-01f, 1.76685125e-01f, 6.60016239e-02f, 2.72795502e-02f, -1.10356621e-01f, -1.27165779e-01f, -6.00738935e-02f, -7.72581389e-03f, -5.14029078e-02f, -9.80673824e-03f,
  8.45593680e-03f, -6.68262690e-02f, -4.62611541e-02f, -1.93843525e-02f, 1.86413135e-02f, 2.18038913e-02f, -7.77461156e-02f, 5.20972349e-02f, -3.40726823e-02f, -1.15601849e-02f,
  -1.01674991e-02f, -6.83410987e-02f, 6.38623238e-02f, 5.56668788e-02f, 7.04444274e-02f, 1.07095771e-01f, -3.30463692e-04f, 6.37517869e-02f, 7.19487742e-02f, -5.01136295e-02f,
  3.40597257e-02f, 2.34484347e-03f, -8.03191736e-02f, 1.32761836e-01f, -1.00628205e-01f, -9.07125622e-02f, -9.10170451e-02f, -9.67604890e-02f, -8.68690461e-02f, -1.37295912e-03f,
  -1.05888896e-01f, 1.25032201e-01f, -3.49369086e-02f, 5.43959364e-02f, -9.50649083e-02f, 1.43739292e-02f, -6.86496422e-02f, -5.79021834e-02f, -2.42069960e-02f, 5.30321710e-02f,
  -8.81294236e-02f, 1.10236131e-01f, -1.26287401e-01f, -6.49417192e-02f, 1.01194970e-01f, 2.28628591e-02f, 6.15555830e-02f, 1.44319803e-01f, 1.45145422e-02f, -2.47207414e-02f,
  8.85373950e-02f, 2.25521401e-02f, 1.00600474e-01f, 5.71023114e-02f, -6.07236736e-02f, 3.41977738e-02f, 1.22849897e-01f, 1.45325094e-01f, 1.91810519e-01f, 2.12777220e-02f,
  9.52961221e-02f, 2.11452559e-01f, 9.15461853e-02f, 2.22188890e-01f, 5.97680621e-02f, -5.62863052e-02f, 6.51419535e-02f, 1.51841298e-01f, 8.23234022e-02f, -6.25674501e-02f,
  5.00618927e-02f, 1.26853332e-01f, -1.24327354e-01f, 6.45688772e-02f, 1.06048286e-01f, 3.66716027e-01f, 1.94389910e-01f, 7.31218234e-02f, -2.44660661e-01f, -3.02917838e-01f,
  -1.74783051e-01f, 3.11475098e-02f, 1.05815358e-01f, 6.24260865e-02f, 1.35166094e-01f, -1.72174007e-01f, 2.09105894e-01f, -1.59557294e-02f, -7.78768258e-03f, -3.28589454e-02f,
  -1.76309288e-01f, 2.76281625e-01f, 2.54019886e-01f, -1.24411926e-01f, -1.19776763e-01f, 9.28544775e-02f, 1.60761505e-01f, -1.22490995e-01f, 6.29805401e-02f, -7.89123699e-02f,
  4.00126338e-01f, 3.82379629e-02f, 1.22119896e-01f, 1.26147553e-01f, -7.10285380e-02f, 2.67059803e-01f, -5.56575367e-03f, 1.54349476e-01f, 1.55529544e-01f, 9.22143012e-02f,
  1.54613346e-01f, 1.42324790e-02f, 7.92695116e-03f, -5.02549745e-02f, -8.34844559e-02f, 1.15020148e-01f, -1.15562677e-01f, 8.79040733e-02f, 8.33493173e-02f, -7.25094453e-02f,
  2.12717384e-01f, 2.04514951e-01f, 1.94406226e-01f, -1.12526052e-01f, 8.69731009e-02f, 1.28011122e-01f, 1.17089778e-01f, 6.44638315e-02f, -1.84778079e-01f, 7.65382946e-02f,
  1.05235651e-02f, 1.05127089e-01f, -6.60142452e-02f, -1.16021685e-01f, 1.11514911e-01f, -1.30070761e-01f, -3.48537862e-02f, 1.62999719e-01f, -1.18663445e-01f, -1.37170941e-01f,
  1.63640059e-03f, 1.32512942e-01f, 3.00866634e-01f, 9.99145061e-02f, 1.34007190e-03f, 7.62120634e-02f, 2.73763877e-03f, -3.97456028e-02f, -1.47572691e-02f, -6.11707233e-02f,
  -3.23978275e-01f, 1.92288354e-01f, -1.72889065e-02f, -5.17266244e-02f, 1.45585254e-01f, -3.23483020e-01f, 1.57644838e-01f, 2.53937632e-01f, 1.49933144e-01f, 1.43483579e-01f,
  -8.29047784e-02f, 2.11046651e-01f, 2.31677778e-02f, 1.02808267e-01f, 5.55752479e-02f, 1.85794666e-01f, -2.03997064e-02f, -6.11304119e-02f, -9.72122625e-02f, -1.98817383e-02f,
  -1.46805599e-01f, 7.87810087e-02f, -2.20090356e-02f, -4.51048283e-04f, 6.73961714e-02f, 8.79318118e-02f, 1.45567968e-01f, 1.52628943e-01f, 1.43609226e-01f, 9.86804068e-02f,
  -1.10155515e-01f, 3.56472850e-01f, -1.13124661e-01f, -7.40885139e-02f
};

// L1_fan_Bp_bar (Shape: 1 x 26)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 26;
const float L1_fan_Bp_bar_data[] = {
  5.01728989e-02f, 2.84226656e-01f, 2.12305620e-01f, 1.65655375e-01f, 6.50786683e-02f, 1.59742460e-01f, 6.76595643e-02f, 1.16590954e-01f, 1.25411555e-01f, -1.39864758e-02f,
  1.57026470e-01f, 4.45119664e-02f, 2.20936779e-02f, 2.21611351e-01f, 1.63631365e-02f, -1.15112495e-02f, -2.17811931e-02f, 1.42721329e-02f, -3.78310047e-02f, 2.93116141e-02f,
  1.57082975e-01f, 1.29260831e-02f, 1.85099334e-01f, 5.01989163e-02f, 6.58093318e-02f, 2.90320572e-02f
};

// L2_linear_W (Shape: 12 x 64)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 64;
const float L2_linear_W_data[] = {
  7.50553757e-02f, -7.09656626e-02f, 1.43489629e-01f, -8.09765533e-02f, 2.28158250e-01f, 2.29175821e-01f, 1.91889449e-05f, -1.99297816e-01f, 1.62718654e-01f, 6.35815337e-02f,
  -7.70934671e-02f, -1.02008983e-01f, -1.95172936e-01f, 2.81975031e-01f, 1.02451891e-01f, -7.50527605e-02f, -2.65413463e-01f, 5.80586158e-02f, -6.83684796e-02f, -2.28273384e-02f,
  -3.56696516e-01f, -1.96194753e-01f, 1.84501663e-01f, 3.00310284e-01f, 2.84335613e-01f, -2.69354641e-01f, 3.33808750e-01f, -3.46957326e-01f, 3.91610086e-01f, -5.89418232e-01f,
  -3.15123558e-01f, 5.62936783e-01f, -2.63303332e-02f, 9.00863670e-03f, 3.46275568e-01f, -3.74350935e-01f, -1.03323497e-01f, -4.06390369e-01f, 1.08242348e-01f, 1.36744857e-01f,
  -3.99143517e-01f, -2.27209240e-01f, -1.93679214e-01f, -3.31186771e-01f, 9.60969832e-03f, -9.35522616e-02f, 4.51467857e-02f, 1.15674011e-01f, 2.92216480e-01f, 4.87978578e-01f,
  2.07762420e-01f, 2.54708976e-02f, -1.73367962e-01f, -8.95188451e-02f, -9.97740328e-02f, -2.76933998e-01f, 1.74777932e-03f, -1.99079573e-01f, -1.68156192e-01f, -7.25350082e-02f,
  -1.36586532e-01f, -3.12151518e-02f, -2.82169968e-01f, 3.71365070e-01f, -7.03950822e-02f, 1.12282805e-01f, -8.01114142e-02f, 4.48023975e-02f, 5.56728281e-02f, -3.04757990e-02f,
  1.30035728e-01f, -2.75491744e-01f, -2.68265861e-03f, 2.94750303e-01f, 2.40460038e-01f, -1.73889801e-01f, 2.55283952e-01f, -1.71917807e-02f, 6.92886263e-02f, 1.35918707e-01f,
  4.06176895e-02f, 1.54682577e-01f, 3.17472130e-01f, -2.66055018e-01f, -2.62855031e-02f, 1.99565277e-01f, 1.96222574e-01f, 4.24702674e-01f, -5.26521564e-01f, 3.29094470e-01f,
  1.46958053e-01f, 3.94171886e-02f, -3.73893738e-01f, -6.67531312e-01f, -5.43729186e-01f, 3.41560990e-01f, 1.80948436e-01f, 1.45263568e-01f, 2.92347401e-01f, -2.77118087e-01f,
  -2.64728498e-02f, 1.98032871e-01f, -3.91775519e-01f, 8.65343139e-02f, 4.73418236e-01f, -1.11109406e-01f, 1.56013951e-01f, -1.77565683e-02f, -3.22245993e-02f, 3.94168258e-01f,
  -7.76608288e-02f, -2.90689338e-02f, -7.63684213e-02f, -7.10292161e-02f, -1.90953180e-01f, -1.82001457e-01f, -7.20834509e-02f, 7.77820051e-02f, 4.68983464e-02f, -1.56072974e-01f,
  1.13650426e-01f, -2.60275215e-01f, -1.30471319e-01f, -2.11037397e-01f, -2.03787237e-02f, 1.41049445e-01f, -3.00344229e-01f, 5.33536255e-01f, -4.85556602e-01f, 2.05930233e-01f,
  -3.35748717e-02f, -4.24545258e-01f, 2.15967327e-01f, -2.43481651e-01f, -1.16618805e-01f, -1.51598006e-01f, -3.02348644e-01f, -3.63194138e-01f, -6.67684972e-02f, 1.22779056e-01f,
  1.48706630e-01f, 2.25922447e-02f, -1.10784829e-01f, -1.51260309e-02f, -1.34492755e-01f, -1.33687690e-01f, -5.61554670e-01f, -1.59243807e-01f, 7.89709538e-02f, -1.93694204e-01f,
  1.81285813e-02f, -4.84021306e-02f, -3.93344343e-01f, 3.52370679e-01f, 3.00193548e-01f, 1.95410609e-01f, -1.42483398e-01f, 1.25880599e-01f, 3.94491076e-01f, 1.54200122e-01f,
  1.26966849e-01f, 2.23639995e-01f, 1.33961499e-01f, -2.99697462e-02f, -2.35652745e-01f, 2.84227163e-01f, -2.81814516e-01f, -1.33499445e-03f, 1.44051373e-01f, 1.49247348e-01f,
  4.08957541e-01f, 1.02561295e-01f, 8.06155801e-02f, 1.80863142e-01f, 8.20797216e-03f, -5.45815490e-02f, -1.19116589e-01f, -1.76608562e-01f, -1.87675938e-01f, -1.24777108e-01f,
  4.18048203e-01f, -1.13043915e-02f, -1.29483659e-02f, 1.59306839e-01f, -1.06576271e-01f, -2.48026162e-01f, -1.41237408e-01f, 1.42588106e-03f, -2.02443585e-01f, 8.99888128e-02f,
  4.60351169e-01f, -2.43219569e-01f, 4.61837091e-02f, 5.33142276e-02f, 1.16162948e-01f, -6.06542751e-02f, 2.03334212e-01f, -3.83000255e-01f, -2.51605421e-01f, -3.46312523e-02f,
  5.33339567e-02f, 3.40707600e-01f, -1.64765835e-01f, -2.90290654e-01f, 2.40619242e-01f, -3.02973509e-01f, 1.85838595e-01f, 1.53223187e-01f, 2.70831019e-01f, -6.37206361e-02f,
  -1.70769602e-01f, 2.18331963e-01f, -2.31612369e-01f, 1.90335006e-01f, -4.77311254e-01f, 9.32762772e-02f, 3.08825195e-01f, -2.81115532e-01f, -4.32371914e-01f, -3.97647023e-01f,
  -1.52900040e-01f, 2.31828943e-01f, -3.00698340e-01f, 1.18699677e-01f, 3.73713225e-01f, 3.33226621e-01f, 8.68488327e-02f, -1.43532366e-01f, 2.20230386e-01f, -3.77103716e-01f,
  4.16673690e-01f, -4.60159212e-01f, -3.96556705e-01f, -2.12208599e-01f, -2.57918954e-01f, -2.90621251e-01f, -1.14122599e-01f, 2.58707285e-01f, 1.75876066e-01f, 3.07923835e-02f,
  1.74608957e-02f, -2.52463490e-01f, -5.20672388e-02f, -1.44793853e-01f, -1.13057822e-01f, 4.33724970e-02f, 1.36920074e-02f, -2.96292543e-01f, -6.78288043e-02f, 6.64567128e-02f,
  6.91569746e-02f, 2.26505905e-01f, 3.29993181e-02f, -4.87293303e-02f, 3.68086606e-01f, -5.66509888e-02f, 3.50780904e-01f, 8.04241151e-02f, 9.52275991e-02f, 1.58021376e-01f,
  -2.98509955e-01f, -1.55281365e-01f, 1.15085736e-01f, 2.50905126e-01f, 2.52607495e-01f, 3.34101856e-01f, 2.37458404e-02f, 2.07841724e-01f, 2.17431068e-01f, 3.11925828e-01f,
  -2.60979161e-02f, 2.09227696e-01f, 2.59037584e-01f, 2.66867429e-01f, -1.87657729e-01f, 1.14008352e-01f, 3.78101468e-01f, 1.84411362e-01f, -1.00538142e-01f, -4.83687431e-01f,
  4.14604038e-01f, -1.63324267e-01f, 6.30566999e-02f, -3.09934050e-01f, 2.34791547e-01f, 3.24011475e-01f, -1.65034086e-02f, 1.03532486e-02f, -3.24102640e-01f, -2.21610844e-01f,
  -1.72015980e-01f, 5.44077996e-03f, 3.69462878e-01f, -2.29411259e-01f, 2.63392240e-01f, 3.64495486e-01f, -4.17814314e-01f, -2.29271874e-01f, -3.49215001e-01f, -1.74093470e-01f,
  -9.88773778e-02f, -1.19513310e-01f, -5.53073287e-02f, 2.10847199e-01f, 1.17432268e-03f, 3.81805509e-01f, -1.03331409e-01f, -1.95130244e-01f, 6.22420274e-02f, 1.30996602e-02f,
  -1.65823802e-01f, 5.55745512e-02f, -1.13616392e-01f, -2.13365197e-01f, 1.75428212e-01f, -3.48205343e-02f, 6.63249731e-01f, -7.69228339e-02f, -6.23108223e-02f, -3.62661719e-01f,
  3.00308347e-01f, 2.30237648e-01f, 4.84808050e-02f, 1.44420475e-01f, 6.55700341e-02f, 1.94323629e-01f, 1.13673404e-01f, -5.31541370e-02f, 1.34042650e-01f, 8.33615363e-02f,
  3.75235677e-01f, 4.15738702e-01f, 3.86745892e-02f, 1.30995080e-01f, -7.46516958e-02f, 1.89304695e-01f, 2.19716415e-01f, -2.63853222e-02f, 2.39400402e-01f, 8.25811997e-02f,
  3.64621542e-02f, -1.44971088e-01f, 1.96745947e-01f, -1.11052483e-01f, 7.90691599e-02f, 1.73312902e-01f, 3.53880018e-01f, 3.66312005e-02f, 3.09135824e-01f, -3.16423416e-01f,
  2.08223984e-01f, -1.30375385e-01f, -4.69653904e-02f, -4.35887605e-01f, -1.10101812e-01f, -1.84544057e-01f, -4.19518620e-01f, 1.26545146e-01f, 3.41175944e-02f, -1.89571813e-01f,
  3.90217841e-01f, 1.97640225e-01f, -3.26394379e-01f, 9.26559046e-02f, 2.42559649e-02f, -2.85158664e-01f, 4.69707437e-02f, 2.00673342e-01f, -1.27896041e-01f, 1.69470459e-02f,
  4.17945832e-01f, -1.21631071e-01f, -3.17490578e-01f, -7.80771822e-02f, 6.29938990e-02f, 2.12406158e-01f, 2.60875672e-01f, 4.88349468e-01f, -1.82721406e-01f, -1.19246364e-01f,
  1.13597818e-01f, -1.06551107e-02f, -4.43245173e-01f, -8.56504515e-02f, -1.80166662e-01f, -3.13944161e-01f, 1.38774335e-01f, 2.52144903e-01f, -2.13596314e-01f, -8.08764324e-02f,
  1.58455074e-02f, 3.42511207e-01f, -1.56928450e-02f, 2.53058285e-01f, -5.76798096e-02f, -1.80676639e-01f, -3.64668876e-01f, 2.09510356e-01f, 4.57987897e-02f, -3.06814581e-01f,
  -8.69525895e-02f, -8.87403488e-02f, 2.17962936e-01f, -2.76772797e-01f, 3.81025404e-01f, 2.21514136e-01f, 1.27992868e-01f, -3.52276921e-01f, -4.84916300e-01f, 2.49740720e-01f,
  -2.45187640e-01f, 2.44024664e-01f, -1.10844806e-01f, 1.64966673e-01f, 5.76206267e-01f, -6.28597081e-01f, -2.70803213e-01f, -1.34046013e-02f, -3.04796249e-01f, 3.91802967e-01f,
  -1.26071915e-01f, 1.18557483e-01f, -2.43384808e-01f, 2.02873409e-01f, 1.49473444e-01f, 2.79894322e-01f, -8.57784674e-02f, 1.87468022e-01f, 2.06249189e-02f, -2.13454321e-01f,
  -1.85622439e-01f, -3.13922971e-01f, -1.44871557e-02f, -3.97586375e-01f, -6.77891672e-02f, 3.01096231e-01f, 4.51645702e-01f, 2.68074870e-02f, 8.44843686e-02f, 1.29645646e-01f,
  1.09541833e-01f, 1.17209338e-01f, 4.33016522e-03f, -1.19528159e-01f, 2.60067750e-02f, -2.12855916e-02f, 1.33099303e-01f, -2.51764894e-01f, -2.17922833e-02f, -7.50650140e-03f,
  -2.60445654e-01f, -1.20065615e-01f, 2.01622527e-02f, -6.55439273e-02f, -1.53502356e-02f, -3.00045833e-02f, -2.82673389e-01f, -1.98620096e-01f, 1.23019502e-01f, 1.01702631e-01f,
  2.92935576e-02f, -4.66936857e-01f, -5.24637774e-02f, -4.80210595e-02f, -1.53678581e-01f, 2.19563618e-02f, -1.97442994e-01f, 1.81273296e-01f, -1.13424510e-01f, -3.71783853e-01f,
  -6.89626392e-03f, 9.02365800e-03f, 3.06454569e-01f, -1.99477136e-01f, -4.66665775e-01f, -3.88146996e-01f, 3.72470528e-01f, -4.59968969e-02f, 2.63801038e-01f, 3.47351998e-01f,
  2.56769419e-01f, 2.07966328e-01f, 2.13552669e-01f, -2.10392877e-01f, -7.75754154e-02f, 2.40906358e-01f, -1.03025280e-01f, -4.81244862e-01f, 1.71954304e-01f, 1.46510363e-01f,
  2.56320357e-01f, -3.03872488e-02f, 7.37378225e-02f, -5.07752299e-02f, 4.80013415e-02f, 2.86677510e-01f, -1.65298894e-01f, -2.18215615e-01f, -3.31059583e-02f, -1.70281976e-01f,
  -2.20783323e-01f, 2.80680321e-02f, 2.80207157e-01f, 5.11188626e-01f, -7.87682459e-02f, 3.32774788e-01f, 1.94068640e-01f, -6.27835616e-02f, -1.38538316e-01f, 4.64638462e-03f,
  1.90110505e-01f, 2.61195689e-01f, 1.91385373e-02f, -2.79564172e-01f, -1.04387023e-01f, -9.23788399e-02f, -3.55865717e-01f, 3.25837382e-03f, 1.55157549e-02f, -2.27705047e-01f,
  -9.34891626e-02f, -4.37079877e-01f, -1.39611378e-01f, 8.00003633e-02f, -2.23742928e-02f, -1.89932421e-01f, -2.23879069e-02f, -1.15187742e-01f, -4.33829799e-03f, -9.91371870e-02f,
  -3.73674840e-01f, 6.87047318e-02f, -4.30694193e-01f, 1.06291629e-01f, 6.74323440e-02f, 4.11855936e-01f, -3.41396570e-01f, 6.70682937e-02f, 2.22859830e-01f, -1.16993383e-01f,
  -4.59089875e-02f, 1.96910769e-01f, -7.08621517e-02f, -3.10957640e-01f, -8.23638216e-02f, -1.53821126e-01f, 1.74263641e-01f, 5.68724563e-03f, 8.15230608e-02f, 2.28964493e-01f,
  4.67485301e-02f, -3.87901515e-01f, 5.99609017e-01f, -2.77028769e-01f, 3.10849428e-01f, 3.26586127e-01f, 1.21347725e-01f, -1.03652179e-01f, -4.58693989e-02f, -7.71863312e-02f,
  8.43160506e-03f, -1.91958442e-01f, -1.52558908e-01f, 1.06662124e-01f, 1.86273605e-01f, 5.40709533e-02f, 8.00529122e-02f, -8.39893445e-02f, 9.06371996e-02f, 1.70525372e-01f,
  4.70021605e-01f, 2.75309920e-01f, -1.83162153e-01f, 4.46259193e-02f, -3.41798007e-01f, -5.79411462e-02f, -2.68344998e-01f, -3.27362061e-01f, -2.20386922e-01f, -2.76517272e-01f,
  -2.92961329e-01f, 3.26069474e-01f, 1.33165747e-01f, 1.26979902e-01f, 5.39758727e-02f, 2.51875594e-02f, 1.27525538e-01f, -4.46700335e-01f, 2.26867646e-01f, -1.26249209e-01f,
  7.33526871e-02f, -3.42516154e-01f, 1.60701752e-01f, -6.95175827e-02f, -6.20994978e-02f, -3.03041637e-01f, 3.36512655e-01f, -4.29207563e-01f, 5.73631749e-02f, -3.94083709e-02f,
  -2.62858719e-01f, 2.15952516e-01f, -5.45025647e-01f, -2.44481608e-01f, 4.24806744e-01f, 3.57242785e-02f, 3.62959594e-01f, 2.42290989e-01f, -1.11318067e-01f, -2.30013300e-03f,
  -3.36933732e-01f, -1.15152717e-01f, -2.94865787e-01f, -1.83952942e-01f, 1.12532131e-01f, 4.02890742e-01f, -2.78153449e-01f, 2.29058698e-01f, 3.67722027e-02f, 8.24931785e-02f,
  4.04758677e-02f, 2.21439943e-04f, -1.35710448e-01f, 1.57967597e-01f, 1.95025399e-01f, 1.79409564e-01f, -5.42512909e-02f, -1.76832736e-01f, 7.33039305e-02f, 1.69889972e-01f,
  -2.78367430e-01f, 5.42966247e-01f, -2.02147886e-01f, -1.72667503e-01f, 1.57825485e-01f, -2.10175086e-02f, -9.31302011e-02f, 4.02319618e-02f, 8.33069235e-02f, -2.09907025e-01f,
  3.18810821e-01f, 1.77014992e-01f, 2.78774500e-01f, 2.98988998e-01f, 1.19527787e-01f, 3.82462293e-01f, 1.77046180e-01f, 2.57195055e-01f, 9.50565115e-02f, -1.36307269e-01f,
  -8.49260464e-02f, 1.76345006e-01f, 1.88741386e-01f, -1.79820493e-01f, -4.90177562e-03f, 1.40412986e-01f, -1.98483039e-02f, 1.40665909e-02f, 3.59854013e-01f, 1.82391018e-01f,
  1.21559091e-01f, -1.21568711e-02f, 1.45840466e-01f, -2.07135499e-01f, 2.32129857e-01f, -2.18916923e-01f, -1.00300282e-01f, 3.17712426e-01f, -3.35476071e-01f, 1.48451820e-01f,
  -1.86953783e-01f, -2.07545504e-01f, 4.33602691e-01f, 4.61233079e-01f, 4.64148223e-02f, 3.79539371e-01f, 4.25709426e-01f, 1.34536460e-01f, -3.63489799e-02f, -1.55870304e-01f,
  1.56152114e-01f, 3.16723660e-02f, 2.27384597e-01f, -3.33277583e-01f, -1.26858622e-01f, 1.84375688e-01f, -2.01208428e-01f, -8.20012689e-02f, -1.40234426e-01f, -4.00305927e-01f,
  -2.60042518e-01f, 5.00584722e-01f, -2.43919030e-01f, -8.99432302e-02f, -4.45503891e-02f, -2.89538175e-01f, -1.86877564e-01f, -2.62562305e-01f, -5.22718690e-02f, -9.97129306e-02f,
  -1.36616051e-01f, -1.39898136e-01f, 4.36387300e-01f, -1.66739717e-01f, -8.43967423e-02f, 1.40112221e-01f, -3.37300390e-01f, 1.18381076e-01f, 1.68292835e-01f, -1.12788610e-01f,
  8.49417821e-02f, 1.48911983e-01f, -2.23977402e-01f, -3.96044888e-02f, -1.87748015e-01f, 2.26109236e-01f, -2.42736369e-01f, 2.03074843e-01f, -9.79481563e-02f, -6.06972761e-02f,
  -3.01485211e-01f, 1.69173926e-01f, 2.40456760e-01f, 4.85761404e-01f, -1.90340355e-01f, 4.71730441e-01f, -4.11181271e-01f, 4.89001907e-03f, 4.39651936e-01f, 6.09316193e-02f,
  2.37112865e-01f, 4.12504792e-01f, -4.34844494e-01f, 9.60597470e-02f, -7.96303153e-02f, -3.38747859e-01f, -1.59925431e-01f, -4.51738685e-01f, -2.77382821e-01f, 6.01025462e-01f,
  1.87694296e-01f, -2.81136036e-01f, 2.08666511e-02f, -2.75689602e-01f, -4.12327111e-01f, 1.99759468e-01f, -1.52652115e-01f, 3.05095375e-01f, 1.74562588e-01f, -6.49200678e-02f,
  9.10169408e-02f, -2.62630135e-01f, -1.54459223e-01f, 3.08851302e-01f, 2.41209622e-02f, -3.73474397e-02f, -3.38218436e-02f, -6.71914546e-03f, -6.86184391e-02f, -4.07648124e-02f,
  -1.53656170e-01f, 2.30232134e-01f, -6.89595863e-02f, 3.74311239e-01f, -5.29270247e-02f, 7.13409297e-03f, -7.99966827e-02f, -2.48256341e-01f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  6.77736625e-02f, -5.20827211e-02f, -9.33752581e-02f, 1.24910422e-01f, -6.00914322e-02f, -1.12274520e-01f, -1.03680439e-01f, 7.64921233e-02f, -2.34363209e-02f, -1.02625072e-01f,
  7.50900134e-02f, 6.63144663e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 19, 26
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 19, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        64, 12
    );
    }
    