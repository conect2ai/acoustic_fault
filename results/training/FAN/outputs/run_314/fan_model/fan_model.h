/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  3.09290588e-01f, 3.75820473e-02f, 1.21672854e-01f, -4.92774770e-02f, -6.06102906e-02f, 4.00921226e-01f, 2.56107986e-01f, -5.71917892e-02f, 4.44814041e-02f, -2.03211293e-01f,
  -1.26271084e-01f, 1.83405797e-03f, -1.45786986e-01f, -2.47518569e-02f, 3.52174699e-01f, 9.33532938e-02f, 2.52720803e-01f, -1.13111483e-02f, 1.49785383e-02f, 1.21064782e-02f,
  7.04876781e-02f, 2.23790724e-02f, 9.12882984e-02f, -4.75307852e-02f, 1.16670325e-01f, 2.79368497e-02f, -5.48923984e-02f, -2.67646704e-02f, -1.05774671e-01f, 9.50596388e-03f,
  5.12347482e-02f, -1.26360193e-01f, -1.47558562e-02f, -4.10512686e-02f, -3.98441553e-02f, 4.55104895e-02f, -4.33823168e-02f, 1.37873646e-02f, 2.00769249e-02f, -7.89711997e-02f,
  -2.72781011e-02f, 3.06013785e-02f, 6.78247362e-02f, 4.57058363e-02f, -4.01783213e-02f, 2.89152609e-03f, 3.22613232e-02f, 2.50894241e-02f, -6.67606592e-02f, -6.97528711e-03f,
  1.96325909e-02f, 1.48397414e-02f, -2.62663215e-02f, 3.20367962e-02f, 4.32929024e-03f, 1.14587769e-02f, 1.02896476e-02f, 3.45913284e-02f, -2.65383366e-02f, 8.28763768e-02f,
  -3.55353318e-02f, 2.65064593e-02f, -2.94216536e-02f, -3.15608233e-02f, -2.74379086e-03f, -8.77903104e-02f, 5.58646256e-03f, -8.91616121e-02f, 1.25082899e-02f, -2.18052361e-02f,
  1.40505964e-02f, -2.24373713e-02f, 1.94531679e-02f, 4.78220917e-02f, 1.20843609e-03f, -2.26044878e-02f, 5.52489981e-03f, -6.86385259e-02f, 3.83769386e-02f, 7.62980198e-03f,
  -8.75758603e-02f, 2.29545645e-02f, -3.71514373e-02f, -9.64902458e-04f, -2.77336333e-02f, -1.89378895e-02f, -3.10902055e-02f, 2.51623224e-02f, -4.01237942e-02f, 4.33254577e-02f,
  -1.37547245e-02f, -1.32650048e-01f, -4.90926113e-03f, -2.08032485e-02f, -6.70189690e-03f, 7.35338032e-03f, 5.83580025e-02f, 5.72305433e-02f, -2.40810048e-02f, 6.25877082e-02f,
  -4.01482210e-02f, -1.91035550e-04f, 2.97992164e-03f, -2.36087441e-02f, 3.35305966e-02f, 2.63000913e-02f, -8.77754688e-02f, 3.35633308e-02f, 6.28833752e-03f, -2.76114270e-02f,
  -6.76605478e-02f, -9.54288233e-04f, 1.44407107e-02f, 1.42858212e-03f, -3.72868478e-02f, -4.41771671e-02f, 6.35659099e-02f, -5.52379824e-02f, -6.28399029e-02f, -9.90440021e-04f,
  5.14318645e-01f, 1.12462156e-02f, -4.07373533e-02f, 2.06719816e-01f, 1.66283056e-01f, 3.80762406e-02f, -6.34876266e-02f, 1.68538377e-01f, 1.77387401e-01f, -3.02733146e-02f,
  -2.27915067e-02f, 2.93790381e-02f, -1.14620849e-01f, 6.27814233e-02f, 1.17962532e-01f, -1.13388352e-01f, 1.91711292e-01f, 3.60993668e-02f, 2.44987104e-03f, 9.61709023e-02f,
  1.14389747e-01f, 1.90865099e-01f, -1.28495723e-01f, 5.05762212e-02f, 5.71474507e-02f, -7.91982487e-02f, 5.00336364e-02f, -1.01010017e-01f, 2.91597284e-02f, 3.42848860e-02f,
  -1.19094830e-02f, -3.79581414e-02f, 4.85765859e-02f, -1.04164938e-02f, 3.92429009e-02f, 7.28068687e-03f, -6.81536496e-02f, -6.41240999e-02f, 5.00293635e-02f, -2.70392615e-02f,
  3.53749911e-03f, 3.40052992e-02f, 6.83714449e-02f, -2.65688840e-02f, 1.29417190e-02f, -2.24285349e-02f, 1.83468536e-02f, -1.73160471e-02f, 5.05014323e-02f, 2.85086557e-02f,
  -1.17293052e-01f, -3.06926691e-03f, 6.60047913e-03f, -4.70027998e-02f, -4.89011174e-03f, 1.61370318e-02f, 1.62329972e-02f, -9.30635482e-02f, -3.34169995e-03f, 6.13518581e-02f,
  2.92593166e-02f, -1.49618173e-02f, 2.94196438e-02f, 1.33884754e-02f, 4.98704165e-02f, 3.45594026e-02f, 5.39234988e-02f, -2.48627365e-02f, 7.83011317e-03f, 3.40084694e-02f,
  3.90515402e-02f, -3.68795521e-03f, -1.70967355e-02f, -1.51312007e-02f, -6.79229246e-03f, 1.15526384e-02f, -3.10588125e-02f, 3.09646130e-02f, 9.02837142e-03f, 4.45304997e-03f,
  2.28872783e-02f, 6.87156841e-02f, -8.48151520e-02f, -3.26952823e-02f, 2.07540840e-02f, -2.07600271e-04f, 1.80761144e-02f, 3.89021239e-03f, 3.44238579e-02f, -4.41418812e-02f,
  1.59977954e-02f, 3.55830789e-02f, -3.57243121e-02f, -6.76175952e-02f, -7.43567571e-02f, 8.01029615e-03f, -1.77662112e-02f, -7.88418460e-04f, -3.37445885e-02f, 7.00310022e-02f,
  1.03687979e-02f, -1.09269703e-02f, 4.36436683e-02f, 4.66628708e-02f, 6.72904914e-03f, -1.53739154e-02f, -1.46737741e-02f, 2.64957100e-02f, 6.37772232e-02f, -1.32405590e-02f,
  4.13769521e-02f, 4.92005013e-02f, 7.73213245e-03f, 2.86478717e-02f, -5.00239022e-02f, -3.20205055e-02f, 4.50290419e-04f, -1.23953996e-02f, 1.59631986e-02f, -1.30293733e-02f,
  -1.23585276e-01f, 2.05098748e-01f, -1.19304307e-01f, 8.14773142e-02f, 1.97391108e-01f, -1.19997792e-01f, -5.56322113e-02f, 1.70791581e-01f, -5.64159825e-02f, 1.47906825e-01f,
  -1.09579094e-01f, -2.66984235e-02f, -1.45642728e-01f, -5.35311736e-02f, -2.86542177e-01f, -1.58181846e-01f, 9.37157050e-02f, 1.05140582e-02f, -6.45999461e-02f, 1.02150716e-01f,
  -9.16192755e-02f, 9.15698931e-02f, -3.59195657e-02f, 1.11509264e-01f, 1.31876096e-01f, 1.85215343e-02f, 1.94861010e-01f, -6.00614473e-02f, 1.18613683e-01f, -6.10905997e-02f,
  -8.09496865e-02f, -1.38524070e-01f, -9.69275925e-03f, -3.64126405e-03f, 8.10393784e-03f, 4.13111225e-02f, -1.47063006e-02f, -5.85109554e-03f, -7.35702664e-02f, -4.32154611e-02f,
  -9.39213261e-02f, 2.08521858e-02f, -4.78143208e-02f, -2.73178983e-02f, 3.68342474e-02f, -7.11263344e-02f, -7.74061978e-02f, -4.75009754e-02f, 2.82608047e-02f, -7.63325244e-02f,
  -9.62674618e-02f, 4.90956157e-02f, 9.97976139e-02f, -7.19579160e-02f, -9.13227126e-02f, -5.52402027e-02f, -1.33246658e-02f, -4.89481017e-02f, 1.73947588e-02f, 4.07609195e-02f,
  -1.97295612e-03f, -2.98799351e-02f, -1.18941581e-02f, -4.37101349e-02f, -4.68633287e-02f, -4.03925851e-02f, 5.43046817e-02f, 5.49143702e-02f, -8.19430426e-02f, -1.68273207e-02f,
  1.83010586e-02f, 9.70227364e-03f, -2.39619650e-02f, 7.31565133e-02f, -3.75534571e-03f, 3.50443982e-02f, -1.58015415e-02f, 3.65165398e-02f, 4.13067453e-02f, -7.11966529e-02f,
  1.97155289e-02f, 5.85778505e-02f, -3.82326506e-02f, 4.03613830e-03f, 3.48399021e-02f, -5.89698404e-02f, 1.76244397e-02f, 1.61081962e-02f, 6.68705674e-03f, -1.13383597e-02f,
  1.83649257e-01f, 2.68089265e-01f, -6.14229664e-02f, 3.89305390e-02f, -1.05303004e-01f, -2.82576773e-02f, -4.23031151e-02f, -2.79827993e-02f, -7.91205466e-03f, 3.55221666e-02f,
  3.09725404e-02f, 2.46845968e-02f, 5.86671382e-02f, 3.77517119e-02f, 3.74494605e-02f, 6.59067836e-03f, 1.01943109e-02f, -4.73804884e-02f, 1.18365493e-02f, -3.57311964e-02f,
  1.56879425e-01f, -1.50941452e-03f, -5.20103537e-02f, -9.11317952e-03f, 9.03414860e-02f, 2.59180162e-02f, 2.52760090e-02f, 6.39276430e-02f, 1.99510884e-02f, 6.93980092e-03f,
  -2.61884958e-01f, 2.40330189e-01f, 2.09764197e-01f, -1.48981735e-01f, -1.66382104e-01f, -2.78750937e-02f, -6.50244355e-02f, -3.17609422e-02f, -5.75405583e-02f, -6.69116229e-02f,
  -1.77756831e-01f, 4.91981804e-02f, 2.79656760e-02f, -1.08383633e-01f, -1.11833781e-01f, 4.85089682e-02f, -7.81876296e-02f, -3.32795419e-02f, -1.27847428e-02f, 2.26081293e-02f,
  1.78167801e-02f, -1.46443099e-01f, 2.35999376e-02f, 1.03371665e-01f, -3.00712287e-02f, 1.77912518e-01f, 4.49498370e-02f, 1.21770926e-01f, -8.77222139e-03f, -1.04900308e-01f,
  -6.33274764e-03f, 1.63175046e-01f, -7.54468217e-02f, 1.07793681e-01f, 3.72465700e-02f, 3.64113003e-02f, 1.96207967e-03f, 1.12139896e-01f, -1.94280036e-03f, -5.07406751e-03f,
  -8.15428421e-03f, -3.66852656e-02f, -7.09515736e-02f, -1.52510703e-02f, -1.43583827e-02f, 2.92958561e-02f, 4.35045781e-03f, -4.11644951e-02f, 3.07194199e-02f, 8.86612851e-03f,
  3.49286497e-02f, -9.86730028e-03f, -7.43137626e-03f, 1.75270010e-02f, -1.33749768e-02f, -5.17896265e-02f, 4.15364802e-02f, 7.06948563e-02f, -4.96075936e-02f, 2.61703562e-02f,
  -3.72708440e-02f, 4.62751910e-02f, 2.69599957e-03f, 5.83360996e-03f, 2.53922096e-03f, -5.52774258e-02f, 5.04762791e-02f, -8.07459876e-02f, 3.87726575e-02f, -7.25163985e-03f,
  -4.63749915e-02f, 8.78929533e-03f, -5.52958176e-02f, -4.37990716e-03f, 1.01529900e-02f, -6.21778928e-02f, 2.33883560e-02f, -1.86565090e-02f, 4.31942269e-02f, 2.00839043e-02f,
  -1.17806261e-02f, 1.41660599e-02f, 1.15042413e-02f, -1.85962748e-02f, -2.19717138e-02f, 2.85062809e-02f, 5.54745412e-03f, -4.33760136e-03f, 5.76794194e-03f, 1.98427751e-03f,
  1.13120563e-01f, 2.74395961e-02f, 3.84434052e-02f, -3.80475372e-02f, 9.83981490e-02f, 5.43955751e-02f, 1.95973795e-02f, 9.43243690e-03f, 5.34433872e-02f, 7.27405623e-02f,
  1.15428790e-02f, 1.44447172e-02f, 9.22696665e-02f, -5.11502177e-02f, 2.75435150e-02f, 2.80187577e-02f, 5.38951857e-03f, 8.43768881e-04f, -1.01728603e-01f, -4.05024402e-02f,
  -8.02691132e-02f, -4.14875075e-02f, 7.73677900e-02f, -5.40829115e-02f, -3.69918393e-03f, 2.28815265e-02f, 1.71614927e-03f, -5.61067574e-02f, 3.07971947e-02f, 1.57151883e-03f,
  -1.85423970e-01f, 1.09126702e-01f, 1.80313528e-01f, -1.63866296e-01f, 2.94240518e-03f, -9.85267982e-02f, -7.69041032e-02f, 1.83575239e-03f, -5.75491972e-02f, 7.75039010e-03f,
  -7.38498643e-02f, 5.57420254e-02f, 5.33209741e-02f, -4.29213718e-02f, -1.07070394e-01f, -3.17396410e-02f, -1.39847338e-01f, -1.07489906e-01f, 5.01201600e-02f, 2.43641399e-02f,
  -1.28404036e-01f, -1.85072228e-01f, 1.00478455e-01f, 3.34123746e-02f, 1.05502516e-01f, 1.36296839e-01f, -6.33450300e-02f, 4.37287539e-02f, -4.62656468e-02f, 2.69924477e-02f,
  3.13574001e-02f, -5.33167273e-02f, 8.64536390e-02f, -2.21192613e-02f, 5.43040596e-03f, 6.42578769e-03f, 2.45237108e-02f, 3.91090997e-02f, 2.88329832e-02f, 5.12675159e-02f,
  -3.28799561e-02f, 1.52143510e-02f, -7.94333071e-02f, -3.53189148e-02f, -1.64344665e-02f, 7.04719573e-02f, 4.73758951e-03f, 2.92311199e-02f, -2.35717595e-02f, 2.60578003e-02f,
  9.33646485e-02f, -2.11114436e-02f, 2.66432371e-02f, -3.59104611e-02f, -1.78675912e-03f, 3.56726199e-02f, -4.13111113e-02f, 5.05153500e-02f, -1.43095627e-02f, -1.13027897e-02f,
  4.45276685e-02f, -9.06539485e-02f, -2.61200089e-02f, -1.64635461e-02f, -6.31622039e-03f, 3.87211591e-02f, -7.97928870e-02f, -7.19209574e-03f, 9.11273807e-03f, -3.78571870e-03f,
  -3.76751646e-02f, -1.47159016e-02f, 4.65195160e-03f, 1.38730425e-02f, -4.33124900e-02f, -2.70206165e-02f, -2.53701583e-03f, 3.31016001e-03f, 6.97519556e-02f, -3.35550420e-02f,
  -1.41302589e-02f, 3.66890356e-02f, 3.93458791e-02f, 1.71055794e-02f, -6.57073334e-02f, 5.39754517e-02f, -6.98213130e-02f, 7.65147209e-02f, -3.95709462e-02f, -8.25428441e-02f,
  2.54166815e-02f, -9.02502518e-03f, 2.51680780e-02f, -3.20679955e-02f, -4.92913127e-02f, -3.44611444e-02f, -6.66329935e-02f, -2.35735904e-02f, -3.79798338e-02f, -3.50985788e-02f,
  -7.77124334e-03f, -6.96568117e-02f, 4.68859961e-03f, 2.21853815e-02f, -2.77381875e-02f, 2.02084612e-02f, -9.16093737e-02f, -8.81019309e-02f, 3.90207907e-03f, 1.91205796e-02f,
  -3.93011048e-02f, -2.62786578e-02f, -5.46903126e-02f, 2.22401582e-02f, 2.29953062e-02f, -4.38843668e-02f, -1.27710421e-02f, 2.15727482e-02f, 2.28938833e-02f, -1.63637456e-02f,
  -4.25585955e-01f, 3.48048955e-01f, 2.42308021e-01f, -4.63716388e-02f, -1.83913976e-01f, 3.00905742e-02f, 1.49388894e-01f, -1.12645857e-01f, -1.08843796e-01f, 1.51522785e-01f,
  1.15250073e-01f, 1.34101018e-01f, 2.07972556e-01f, 1.19544528e-01f, -7.49808028e-02f, 1.91036716e-01f, 3.62096727e-02f, 6.59478530e-02f, 2.78130244e-03f, -1.63295977e-02f,
  -1.09759010e-01f, 3.34054083e-02f, 7.26798996e-02f, -5.40860221e-02f, -3.48308571e-02f, -8.41224864e-02f, -6.58593029e-02f, 1.30315557e-01f, 1.21013056e-02f, 1.09449327e-01f,
  1.46899726e-02f, 2.84190048e-02f, -2.85752360e-02f, 1.15297690e-01f, -2.86365170e-02f, -2.74325274e-02f, 8.18790942e-02f, 7.03091323e-02f, 9.92036052e-03f, 1.75909437e-02f,
  4.78424430e-02f, 1.53431937e-03f, 1.27679752e-02f, -9.81946662e-03f, 3.43209356e-02f, 3.06939669e-02f, -3.19782011e-02f, 2.84166411e-02f, 2.29729377e-02f, 4.33763303e-02f,
  5.74895069e-02f, 8.50407630e-02f, 1.08634285e-03f, 1.76351666e-02f, -4.19937037e-02f, -8.43698438e-03f, 4.01319377e-02f, 3.46453078e-02f, 2.07045749e-02f, -2.34183911e-02f,
  9.92693123e-04f, 1.19919982e-02f, 1.65606569e-02f, -6.16094507e-02f, -9.71308537e-03f, -3.01384348e-02f, 4.53011468e-02f, 7.70266056e-02f, 2.41808742e-02f, 4.93732430e-02f,
  -4.59414069e-03f, -4.65114601e-03f, 7.78172389e-02f, -2.07502190e-02f, -4.35678959e-02f, 1.18406331e-02f, -5.19813895e-02f, 3.09330840e-02f, -5.32626472e-02f, -8.81719962e-03f,
  4.73872700e-04f, -4.07874770e-02f, -1.02568192e-04f, 1.15466173e-04f, 7.67269582e-02f, -5.69079705e-02f, 5.97792454e-02f, -3.56533052e-03f, 3.31639349e-02f, 3.78743117e-03f,
  1.77251790e-02f, 1.49021879e-01f, 2.51057297e-02f, 1.45761333e-02f, 6.01381697e-02f, -3.41388397e-02f, 3.91523689e-02f, 1.11036850e-02f, 4.74929903e-03f, -5.78638911e-02f,
  1.97355151e-02f, -2.14649737e-02f, -2.56367549e-02f, -2.42493302e-02f, -2.28422713e-02f, -4.88753803e-02f, 3.72111239e-02f, -4.51981016e-02f, -2.74873991e-03f, 4.24084589e-02f,
  -1.59579236e-02f, -8.98677856e-03f, -1.16428006e-02f, -4.73817363e-02f, -4.54788702e-03f, 2.13268809e-02f, -6.51717559e-02f, 3.83089334e-02f, 5.40718473e-02f, 1.54390780e-03f
};

// L0_fan_Wp_bar (Shape: 52 x 120)
const int L0_fan_Wp_bar_rows = 52;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  7.76641890e-02f, -1.49145611e-02f, 1.84410095e-01f, 8.59710574e-02f, 5.12294620e-02f, 1.09210819e-01f, 1.50327682e-01f, 2.44024699e-03f, 1.57955840e-01f, -5.55783920e-02f,
  -4.33948152e-02f, -5.64458296e-02f, 8.17902163e-02f, -5.84916621e-02f, 1.77790597e-01f, -1.67282093e-02f, -8.84691998e-03f, -1.20431734e-02f, -3.76962647e-02f, -3.70512679e-02f,
  -2.68990733e-02f, -1.20440893e-01f, 3.01797930e-02f, 1.06365858e-02f, 2.85656843e-02f, -1.01864643e-01f, -1.53506860e-01f, 9.41352695e-02f, -4.94427010e-02f, -1.81503557e-02f,
  2.08728877e-03f, 3.43258530e-02f, -2.87241507e-02f, -3.91878411e-02f, 5.82075641e-02f, -4.98202890e-02f, 3.12356036e-02f, 3.85352522e-02f, -4.83088978e-02f, 3.07017751e-02f,
  -6.03180332e-03f, -5.35351969e-03f, 1.20131960e-02f, -1.01551764e-01f, 6.45139292e-02f, -1.03572095e-02f, 2.64823064e-02f, -1.40159465e-02f, -4.07978799e-03f, 2.98643205e-02f,
  -2.76276488e-02f, 7.26509690e-02f, -2.93788388e-02f, -6.37519062e-02f, 6.14570342e-02f, 1.47863096e-02f, 5.90620823e-02f, 5.25941513e-03f, 8.27545021e-03f, 6.15919493e-02f,
  1.08787850e-01f, 4.25265618e-02f, 3.25196311e-02f, 2.31412314e-02f, 3.89493629e-02f, 5.61206043e-02f, -2.44885124e-02f, -4.13742661e-02f, -6.16979226e-02f, -5.22677451e-02f,
  -3.28574367e-02f, -1.62848469e-03f, 7.83922151e-02f, -1.55803729e-02f, 7.64396936e-02f, 2.18521040e-02f, -5.33896573e-02f, -4.49863356e-03f, -3.55370855e-03f, -5.02309725e-02f,
  6.97362721e-02f, 7.98443556e-02f, 8.48410130e-02f, 7.71094486e-02f, -7.84470364e-02f, -4.71995473e-02f, -8.92909691e-02f, -6.76286519e-02f, 3.55875604e-02f, 6.95039332e-02f,
  -6.96853772e-02f, -4.78688553e-02f, -6.76466450e-02f, -6.87926635e-02f, -5.47117181e-02f, 7.80850798e-02f, 3.47254947e-02f, -5.12032546e-02f, 1.02136627e-01f, -4.40710085e-03f,
  -2.89813187e-02f, -2.43290160e-02f, 8.40825215e-02f, 2.42281966e-02f, 5.20173833e-02f, 3.23366411e-02f, 8.73921067e-03f, 8.04239213e-02f, 6.93086386e-02f, -8.71445313e-02f,
  6.47794455e-03f, -1.45334331e-02f, 2.57053245e-02f, 8.35453451e-04f, -5.03086811e-03f, -4.09858041e-02f, -5.82651757e-02f, -8.72764587e-02f, 2.35145465e-02f, 3.08268126e-02f,
  1.96568847e-01f, -4.47669812e-03f, -2.32870638e-01f, -1.15226075e-01f, -2.42449250e-02f, 3.34771276e-02f, 3.64871398e-02f, -2.80541237e-02f, -2.10983559e-01f, 4.23899144e-02f,
  1.70580119e-01f, -1.32144958e-01f, -8.76734555e-02f, 3.45039777e-02f, 8.58644843e-02f, -1.02657989e-01f, 1.02797508e-01f, 1.17320821e-01f, 3.93693112e-02f, 1.47622123e-01f,
  -2.18087882e-02f, 1.55896008e-01f, 7.32555520e-03f, 4.78381775e-02f, 1.07214637e-01f, -3.05285845e-02f, 1.59622177e-01f, -5.69279715e-02f, 1.48893595e-01f, -3.35515253e-02f,
  1.15084564e-02f, 3.83748524e-02f, -4.58880840e-03f, -7.70521909e-02f, 1.29974008e-01f, 1.30236909e-01f, 2.39315126e-02f, 4.37102839e-02f, -3.63694876e-02f, -3.15392353e-02f,
  7.35579953e-02f, -7.36762956e-02f, -7.91748762e-02f, -3.80622484e-02f, -2.24239868e-03f, 3.59957181e-02f, -4.83522983e-03f, -5.32159433e-02f, -9.09206793e-02f, 2.20841225e-02f,
  2.90146898e-02f, 3.75264920e-02f, -7.87330121e-02f, -7.82238618e-02f, -5.14402613e-03f, 5.29059255e-03f, 4.58371937e-02f, 8.63727033e-02f, 4.59097698e-02f, -4.76973504e-02f,
  1.43121466e-01f, -4.33579385e-02f, 1.02427565e-01f, -1.32920397e-02f, -4.91103455e-02f, 6.21260237e-03f, 3.44745070e-02f, -2.38383822e-02f, 3.09558623e-02f, -1.22239441e-02f,
  2.82501150e-02f, -2.97318157e-02f, 5.84460907e-02f, -7.41661713e-02f, 1.53270159e-02f, -6.71724603e-02f, -6.85795099e-02f, 5.40098809e-02f, -8.37363154e-02f, -1.90664493e-02f,
  -9.93810520e-02f, 1.08387358e-01f, 1.26982608e-03f, 9.07722022e-03f, -2.08210666e-02f, -8.63224044e-02f, 1.46066785e-01f, 6.03633150e-02f, -2.19030268e-02f, 3.96514572e-02f,
  1.19343445e-01f, 4.65113260e-02f, -5.90191521e-02f, -9.76395234e-02f, 3.95184606e-02f, 1.03675812e-01f, -3.38494889e-02f, -4.79595214e-02f, 6.65289611e-02f, -5.70464833e-03f,
  1.30407110e-01f, -4.61312011e-02f, 8.24018344e-02f, -4.72085550e-02f, -6.71168789e-02f, 5.66907600e-03f, -1.51852882e-02f, -1.27974814e-02f, -5.99163696e-02f, -8.57638847e-03f,
  9.16323683e-04f, 1.24193408e-01f, -2.97519509e-02f, -1.02436002e-02f, 5.41136265e-02f, 4.62808609e-02f, -8.57573375e-03f, -2.47527026e-02f, 1.24862514e-01f, -3.21360864e-02f,
  -2.04170793e-01f, -5.73578328e-02f, -2.19414055e-01f, -1.99775249e-01f, 2.31554471e-02f, -3.12261134e-01f, -1.77226648e-01f, -8.67405087e-02f, 7.82989711e-02f, -1.36513021e-02f,
  -9.19373408e-02f, 1.11541465e-01f, 2.73794997e-02f, -9.27868858e-02f, -6.09947704e-02f, 9.46365744e-02f, -3.14454317e-01f, -4.66078706e-02f, 8.51184130e-02f, -2.91828066e-01f,
  2.62845997e-02f, -1.46099985e-01f, 1.61794014e-02f, 8.42677876e-02f, -2.17604309e-01f, -1.45341173e-01f, -6.15252368e-02f, 1.05859138e-01f, -9.77549255e-02f, 9.40829441e-02f,
  -1.89553469e-01f, -8.78159106e-02f, -1.40420184e-01f, -5.13328006e-03f, -1.77824438e-01f, -8.32934231e-02f, -8.33650604e-02f, 3.97465937e-02f, 7.65576260e-03f, -1.77503079e-02f,
  -1.43169444e-02f, 2.04632748e-02f, 2.57438608e-03f, 6.15954697e-02f, -4.20135300e-04f, 3.22534852e-02f, 8.75014439e-02f, -2.73509379e-02f, 4.40039597e-02f, 2.82152314e-02f,
  2.27547809e-02f, -5.73577033e-03f, -1.15089320e-01f, -6.46970272e-02f, 4.30109771e-03f, 1.38565879e-02f, -3.26676033e-02f, -3.83071974e-02f, -6.87201247e-02f, -1.29739316e-02f,
  1.09229144e-03f, 2.95341145e-02f, 3.12540196e-02f, 4.80414517e-02f, 6.19080663e-02f, -4.22232645e-03f, -5.36903366e-02f, 6.58617020e-02f, -6.10539876e-02f, -5.36577664e-02f,
  2.46693566e-02f, -1.18962368e-02f, -5.27621061e-02f, -1.04841754e-01f, -9.01467651e-02f, -4.21109609e-02f, 2.53787506e-02f, 2.30825376e-02f, -5.45704551e-03f, 3.97553146e-02f,
  9.81224105e-02f, 2.78111547e-04f, -2.65342463e-02f, -1.12051070e-01f, 9.55678988e-03f, -2.14577485e-02f, -4.39887755e-02f, -3.89277861e-02f, 5.75098358e-02f, -8.27756226e-02f,
  -2.17530996e-01f, -5.06417751e-02f, -2.88057998e-02f, -2.41184141e-02f, -5.04167378e-03f, 1.23893945e-02f, -2.50960272e-02f, -3.68516259e-02f, -1.12836696e-02f, -3.25127989e-02f,
  -1.16966620e-01f, -5.20994030e-02f, -4.25884165e-02f, 6.73217624e-02f, -3.18307653e-02f, -5.59039973e-02f, -5.70858978e-02f, -1.56200901e-02f, -1.97630897e-02f, -2.40810253e-02f,
  -8.17894191e-03f, 6.84472620e-02f, -4.97571118e-02f, -4.06373059e-03f, -3.43751498e-02f, -3.61563340e-02f, -1.25227375e-02f, -3.30281593e-02f, -2.57497672e-02f, 1.60963815e-02f,
  -2.23439392e-02f, 6.78402092e-03f, 4.75268699e-02f, 1.48981929e-01f, -1.20816328e-01f, -1.66852167e-03f, -3.63464393e-02f, -2.32169162e-02f, -2.31789481e-02f, -2.63884310e-02f,
  -4.50926349e-02f, 4.69211955e-03f, 3.00695971e-02f, 1.08738191e-01f, 1.78289756e-01f, -8.23023096e-02f, -1.29728415e-03f, -4.76484047e-03f, -1.59344375e-02f, 1.29460990e-01f,
  1.74350411e-01f, 8.21509063e-02f, 2.24134952e-01f, 8.06102157e-02f, 1.57171693e-02f, 7.62817338e-02f, 1.49699032e-01f, 1.07897688e-02f, 8.55524391e-02f, 8.17641020e-02f,
  -5.46025634e-02f, 3.82952206e-02f, 9.03790146e-02f, -4.65227179e-02f, 1.20392971e-01f, -1.18363194e-01f, -6.24042703e-04f, -4.69126329e-02f, -5.32387421e-02f, 8.39135572e-02f,
  -2.00561602e-02f, 9.69322491e-03f, -1.80066414e-02f, 9.41123348e-03f, -6.20772541e-02f, -7.67230392e-02f, -2.24821232e-02f, 7.98192918e-02f, -1.92450471e-02f, -4.80680354e-02f,
  -2.00915411e-02f, 3.95295955e-03f, -2.10321862e-02f, -4.50216830e-02f, -3.49304937e-02f, -2.59396955e-02f, 4.27552573e-02f, 5.17358370e-02f, 3.64492205e-03f, -8.05032812e-03f,
  -6.36015534e-02f, 5.24133183e-02f, 8.19782317e-02f, -3.84041108e-02f, 5.77964634e-02f, -2.46104859e-02f, -5.58032393e-02f, 6.23281561e-02f, 6.70210868e-02f, 7.01123327e-02f,
  2.06909478e-02f, 5.29277027e-02f, 7.63489529e-02f, -4.76901466e-03f, -3.10120825e-02f, -3.67944315e-02f, 9.31630936e-03f, -8.86485800e-02f, -4.51955162e-02f, 3.89710441e-02f,
  5.77919371e-03f, 8.78378674e-02f, 1.09116314e-03f, 1.32408105e-02f, -4.31593359e-02f, -1.16135590e-02f, 5.29289469e-02f, 6.41422346e-02f, -5.63601442e-02f, 5.57289608e-02f,
  7.16761574e-02f, 1.52465194e-01f, -7.10169226e-02f, -1.18573099e-01f, -4.82349377e-03f, -8.54405984e-02f, 1.26943775e-02f, 1.29717374e-02f, 2.55581271e-02f, 9.81341302e-02f,
  1.78057794e-02f, -3.38924415e-02f, -7.98901245e-02f, 7.52700344e-02f, -7.17056096e-02f, 4.93195541e-02f, 8.36939141e-02f, -7.80258253e-02f, -2.65837349e-02f, 6.24780282e-02f,
  8.78203586e-02f, 2.82997321e-02f, -6.20600693e-02f, -8.90758857e-02f, 2.84675583e-02f, 3.89758199e-02f, -3.32471281e-02f, 6.89076185e-02f, 3.56441177e-02f, 1.32532045e-02f,
  1.63511455e-01f, -2.12501913e-01f, 1.56746849e-01f, 2.44282007e-01f, 2.45074958e-01f, 1.78114399e-01f, 1.42122477e-01f, -1.11634247e-01f, 8.12756121e-02f, -2.06195936e-01f,
  4.01407368e-02f, 5.46839125e-02f, -7.11304173e-02f, 2.43474152e-02f, 5.04426323e-02f, -1.00459732e-01f, 7.22744688e-02f, 9.93791893e-02f, -5.28537035e-02f, -3.35321166e-02f,
  -3.42220217e-02f, -7.21518099e-02f, -2.11839136e-02f, -2.10784748e-02f, 6.34585842e-02f, 1.39206219e-02f, -9.78239626e-02f, 5.85161150e-02f, -1.81409884e-02f, 3.44641646e-03f,
  1.32318959e-01f, -2.94942986e-02f, -8.26448277e-02f, -6.27863482e-02f, 3.37442458e-02f, -2.52253227e-02f, 9.33868662e-02f, 9.96468142e-02f, 8.18537474e-02f, -2.64881644e-02f,
  8.24239403e-02f, 4.36490811e-02f, -8.62472206e-02f, 9.62437242e-02f, 6.50001466e-02f, 1.40956296e-02f, -3.81798781e-02f, 2.12212317e-02f, -1.16310947e-01f, -5.97242154e-02f,
  -4.26155180e-02f, -3.89039293e-02f, 6.95830062e-02f, -1.03075914e-01f, -3.36352326e-02f, 7.52218906e-03f, 7.17479736e-02f, 6.11801520e-02f, 6.41619414e-02f, 5.54421134e-02f,
  -1.17602915e-01f, 5.88318855e-02f, 3.12616117e-02f, -4.34452221e-02f, -5.65959001e-03f, -2.78081913e-02f, -3.23421024e-02f, -4.48430851e-02f, 5.98873757e-02f, -7.86380023e-02f,
  6.06203824e-02f, -2.80385092e-02f, -2.27048658e-02f, 1.81324352e-02f, -1.25561459e-02f, 4.23116088e-02f, 1.02369614e-01f, 6.01864345e-02f, -2.12913509e-02f, -8.59939978e-02f,
  2.15428397e-02f, -3.77929509e-02f, -5.60240895e-02f, -2.66379807e-02f, 5.47603555e-02f, 5.16153872e-02f, 1.08129606e-02f, -6.08046912e-02f, -3.59175205e-02f, 3.72533649e-02f,
  3.77980173e-02f, 1.35278543e-02f, -9.78009328e-02f, -1.31598702e-02f, 7.76956752e-02f, -2.73808911e-02f, 2.19474244e-03f, -3.56344283e-02f, -2.77068764e-02f, -4.60366979e-02f,
  -4.46840748e-02f, 7.59107396e-02f, -1.03619888e-01f, -5.22631556e-02f, -4.95882109e-02f, -2.35483237e-03f, 5.20270132e-02f, -3.09770573e-02f, -2.96073910e-02f, -8.15432072e-02f,
  -2.73190495e-02f, -5.64338118e-02f, -2.47288495e-02f, 4.43643853e-02f, 1.15508446e-02f, 3.03069260e-02f, 3.05008795e-02f, -5.47427509e-04f, -1.34121284e-01f, -1.00165308e-01f,
  2.43283331e-01f, 1.65356219e-01f, 8.94588605e-02f, 1.58447891e-01f, -2.40469605e-01f, -2.89567679e-01f, -1.57933697e-01f, 8.27344283e-02f, -5.91760874e-02f, -1.14218101e-01f,
  -9.39957649e-02f, 2.13403746e-01f, -1.34592503e-01f, 9.01398510e-02f, 1.61458123e-02f, -1.13407969e-01f, 1.42817020e-01f, 4.26999666e-02f, 2.81402152e-02f, 1.49471074e-01f,
  1.63686737e-01f, 1.73114333e-02f, 2.05303863e-01f, 8.78124163e-02f, 9.89779383e-02f, 1.39144778e-01f, 2.07863867e-01f, -8.12012237e-03f, 1.91074654e-01f, 3.98905240e-02f,
  3.40353288e-02f, 1.17076375e-01f, -3.70416004e-04f, 4.90516014e-02f, 6.40167966e-02f, -4.11596000e-02f, 4.77754250e-02f, -3.43073346e-02f, 4.00967747e-02f, 9.14634243e-02f,
  -6.83399215e-02f, -1.31470943e-02f, 8.56009591e-03f, -1.80396028e-02f, 1.00454926e-01f, 1.00067556e-01f, 7.56940767e-02f, -8.69651809e-02f, -2.37831008e-02f, 3.61968689e-02f,
  9.15895104e-02f, 8.89709161e-04f, -3.20120566e-02f, -1.22018652e-02f, 6.18375801e-02f, -3.81754711e-02f, 8.30304697e-02f, 1.82474107e-02f, 2.36522052e-02f, 7.55501464e-02f,
  -5.52488584e-03f, -2.32701432e-02f, 4.17572446e-02f, 6.43979460e-02f, 2.41623800e-02f, -8.49403143e-02f, -2.11737342e-02f, 8.06974340e-03f, 4.40468453e-02f, 2.10147612e-02f,
  3.99067620e-04f, 8.05453584e-03f, -2.63672369e-03f, -4.91769686e-02f, -4.40009236e-02f, 4.60067056e-02f, 1.05576711e-02f, -2.31752787e-02f, 5.84289655e-02f, 6.97118342e-02f,
  -1.02531672e-01f, 5.82530200e-02f, 5.96834496e-02f, 2.85867807e-02f, -5.70340343e-02f, -1.00458555e-01f, -4.08798009e-02f, -3.32692685e-03f, -5.15870675e-02f, 4.50295471e-02f,
  1.53152822e-02f, 1.40296057e-01f, 1.00853771e-01f, 3.30496347e-03f, -2.92318501e-02f, -2.81416979e-02f, -6.41686004e-03f, 8.01371485e-02f, 9.13912579e-02f, 2.49999505e-03f,
  -3.71043980e-02f, -3.20127048e-02f, -8.86197835e-02f, -2.09131166e-02f, 9.78103355e-02f, -6.05807491e-02f, -6.46045879e-02f, 7.50230402e-02f, 1.25030890e-01f, 9.99037325e-02f,
  5.63607588e-02f, -4.79427427e-02f, 1.41421825e-01f, -1.69221163e-02f, -5.05003445e-02f, 2.41106376e-03f, 1.18736185e-01f, -5.82024492e-02f, 5.84178865e-02f, 3.29778083e-02f,
  6.51987493e-02f, -1.09886773e-01f, -1.00921445e-01f, -1.05612893e-02f, 6.02791272e-02f, -6.60735071e-02f, -5.57452999e-02f, -1.50485784e-01f, -1.35117590e-01f, -2.04227477e-01f,
  -1.11860611e-01f, -2.45435052e-02f, 2.49362662e-02f, -1.27967149e-01f, 1.69893041e-01f, 8.59748758e-03f, -1.49666145e-01f, -1.09330900e-01f, 6.84624538e-02f, -1.43781573e-01f,
  4.64797812e-03f, 8.61674268e-03f, 2.24317540e-03f, -6.97892085e-02f, -1.18231915e-01f, -7.22266454e-03f, -2.37233359e-02f, -4.38875370e-02f, -7.98179358e-02f, 1.30212411e-01f,
  -2.60460172e-02f, -1.71983149e-02f, 5.90027720e-02f, -6.98460862e-02f, -1.00534514e-01f, 2.51177866e-02f, 8.47995952e-02f, -9.99892596e-03f, -5.71751930e-02f, -9.02027860e-02f,
  -7.27204978e-02f, -8.70836154e-03f, -6.10877387e-02f, 6.72891065e-02f, -8.60827789e-02f, 1.31607894e-02f, 2.46039480e-02f, -1.80337355e-02f, -7.84035698e-02f, 7.13582560e-02f,
  -1.38063058e-02f, 7.56084546e-02f, -6.77378029e-02f, 3.70322950e-02f, -3.38253826e-02f, -1.04089566e-01f, -4.49225605e-02f, 6.79597408e-02f, -4.98436801e-02f, 6.31096661e-02f,
  -2.08799709e-02f, 1.32781593e-02f, -1.00543901e-01f, 8.84804204e-02f, -9.36364383e-02f, 1.79526322e-02f, -2.40432806e-02f, -2.80569773e-02f, 1.15605583e-02f, 2.62534972e-02f,
  -3.48527096e-02f, -5.68371713e-02f, 6.02875324e-03f, 6.56683072e-02f, -7.22578764e-02f, 5.76039590e-02f, 8.55120495e-02f, 5.90368360e-02f, -2.89676040e-02f, 5.20687923e-02f,
  -1.35915652e-02f, -9.38505027e-03f, -2.92692464e-02f, -3.01945955e-02f, -5.14711626e-02f, 1.38216093e-02f, 2.34688129e-02f, 1.63383223e-02f, -4.05979343e-02f, -9.33491683e-04f,
  -8.46643448e-02f, -1.77251399e-01f, -1.92023497e-02f, -7.57749528e-02f, -2.94942856e-02f, -9.61177796e-02f, 4.88385819e-02f, -3.78134698e-02f, -1.05188591e-02f, -4.70725559e-02f,
  -7.64130503e-02f, -9.33473837e-03f, -4.99518067e-02f, -4.98687895e-03f, 7.24703446e-02f, 1.46385385e-02f, -1.02639847e-01f, -5.90589494e-02f, -2.08622552e-02f, 4.96027134e-02f,
  3.09771802e-02f, 3.80907394e-03f, 8.26571733e-02f, 6.76576942e-02f, -3.44076799e-03f, -5.91892451e-02f, -7.78576080e-03f, 9.45812911e-02f, -1.81427822e-02f, -6.68129995e-02f,
  1.14895031e-01f, -1.90707058e-01f, -2.49260157e-01f, -2.16304362e-01f, -6.43311739e-02f, -9.25258175e-02f, -3.72008942e-02f, -8.24343786e-02f, 7.00196326e-02f, -1.22123901e-02f,
  3.79815549e-02f, -8.25700238e-02f, -7.75304660e-02f, -3.18725020e-01f, -7.57849291e-02f, -1.24295764e-01f, -2.23786429e-01f, -1.61657035e-01f, -8.27553943e-02f, -6.83459863e-02f,
  -1.64441876e-02f, -1.83450460e-01f, -2.46155396e-01f, -1.29499391e-01f, -1.06333375e-01f, 5.97800016e-02f, 1.57661855e-01f, -2.34357528e-02f, -1.51356056e-01f, -7.33526275e-02f,
  4.88138013e-02f, 4.97851484e-02f, 4.67415154e-02f, 3.26873884e-02f, 1.24744624e-01f, 9.24674124e-02f, 7.35177621e-02f, 3.56216952e-02f, 2.09550019e-02f, 2.26118378e-02f,
  5.99915795e-02f, 6.53666407e-02f, -1.70463622e-02f, -6.00374900e-02f, -4.86778095e-02f, 2.99526881e-02f, 3.47918682e-02f, -6.90851957e-02f, -5.51980324e-02f, -1.02209516e-01f,
  -5.08753257e-03f, 4.32694368e-02f, 2.42164936e-02f, -1.07972408e-02f, 1.34265171e-02f, 8.72307196e-02f, -3.24934348e-03f, 1.77422632e-02f, 9.88114327e-02f, -6.78523332e-02f,
  -8.22026655e-02f, 7.77278701e-03f, 2.99110040e-02f, -8.36482719e-02f, -3.36517231e-03f, -1.67935751e-02f, 9.81083736e-02f, 4.72994708e-03f, -1.76886059e-02f, 1.03821762e-01f,
  9.17626247e-02f, -1.88162625e-02f, -5.07841632e-02f, -8.52330104e-02f, -2.60694418e-02f, -4.75917980e-02f, -3.42774875e-02f, -3.95188108e-03f, 4.27596346e-02f, -9.35954321e-03f,
  6.52269125e-02f, -1.07226521e-02f, -6.75623789e-02f, 2.05247514e-02f, -7.26479739e-02f, 2.18318007e-03f, 7.42848068e-02f, 6.35375679e-02f, -1.48083577e-02f, 3.46461050e-02f,
  1.06578946e-01f, 8.06080550e-02f, 1.14777192e-01f, 4.16850224e-02f, 4.95772287e-02f, 5.47262467e-02f, -4.16376516e-02f, -1.66487005e-02f, -4.96547204e-03f, 4.75168079e-02f,
  1.22764297e-01f, 4.27113380e-03f, 9.06671584e-02f, 4.95465137e-02f, -5.87081015e-02f, 3.45935076e-02f, 3.01518328e-02f, 2.05887016e-02f, 7.10772052e-02f, -3.73637453e-02f,
  -4.17174622e-02f, 6.98748231e-02f, -1.94198415e-02f, 8.78652185e-03f, -4.79895025e-02f, 1.89381111e-02f, 3.08218505e-02f, 4.94300723e-02f, 3.79466452e-02f, -4.07876633e-02f,
  1.38823718e-01f, -8.29038098e-02f, -2.92098552e-01f, -1.18449815e-01f, -9.45767388e-02f, -9.54627320e-02f, -1.35415465e-01f, -9.67380404e-02f, 8.13419521e-02f, 9.60881114e-02f,
  -3.11812051e-02f, 2.06505973e-02f, 8.93205553e-02f, -2.81101111e-02f, 5.22261411e-02f, 1.85894355e-01f, -1.38396382e-01f, 6.95046335e-02f, -7.78174922e-02f, -8.01781639e-02f,
  3.22417393e-02f, 3.45201455e-02f, -9.40668806e-02f, 4.23047394e-02f, -1.63448408e-01f, -1.04472272e-01f, -2.65520904e-02f, -1.10604521e-02f, -1.57370761e-01f, -9.27290320e-02f,
  5.69865927e-02f, 1.35302320e-01f, -2.61819689e-03f, -4.89274226e-02f, 7.05563799e-02f, 1.00708501e-02f, -6.13398962e-02f, 4.79754247e-02f, -5.91106862e-02f, -7.63714835e-02f,
  5.41242622e-02f, 7.99408928e-02f, -2.01825593e-02f, 1.70631278e-02f, -1.05540678e-01f, -7.45376274e-02f, -7.84949288e-02f, -5.87525405e-02f, -8.14750642e-02f, -8.23948756e-02f,
  -7.78399706e-02f, -1.01807527e-01f, -5.93679696e-02f, 6.74280971e-02f, -1.31048458e-02f, -7.68549144e-02f, -3.50757763e-02f, -8.73773396e-02f, -5.38948253e-02f, -8.62687677e-02f,
  -1.00689620e-01f, -2.28559915e-02f, 3.15434299e-02f, -2.63405945e-02f, 1.01757571e-01f, 6.96280450e-02f, -2.18906216e-02f, 4.74076793e-02f, -4.07781415e-02f, -5.24333902e-02f,
  -1.90241670e-03f, -3.34511790e-03f, 5.77547103e-02f, 1.27676586e-02f, 7.13434890e-02f, 8.85258541e-02f, 3.04795634e-02f, -7.52389489e-04f, -3.86108682e-02f, 7.87024945e-03f,
  4.88217687e-03f, -3.95214111e-02f, 7.72637576e-02f, -1.08073102e-02f, -7.40328282e-02f, -1.53652104e-02f, 6.14830442e-02f, -6.11582808e-02f, -8.64679664e-02f, -1.55119961e-02f,
  -3.98109034e-02f, -5.66702783e-02f, -4.50236760e-02f, 1.13607146e-01f, -4.45013121e-02f, -7.66698942e-02f, -5.12047298e-02f, -1.15249731e-01f, -3.71221006e-02f, -5.96455811e-03f,
  -7.58590400e-02f, 1.17693515e-03f, -7.28621408e-02f, -7.54659250e-02f, 1.42630488e-02f, 5.50048798e-02f, 5.10394834e-02f, -1.05954995e-02f, -6.76634982e-02f, 3.20255719e-02f,
  5.27564585e-02f, 2.06879359e-02f, -5.14123887e-02f, 1.58942081e-02f, -4.48351316e-02f, -7.95010403e-02f, 1.43474331e-02f, -5.22068180e-02f, -7.11904019e-02f, -5.75805567e-02f,
  6.13358095e-02f, -4.14233804e-02f, 1.38395354e-01f, -5.97155653e-02f, -3.65640074e-02f, -4.10474055e-02f, -6.77900687e-02f, 5.45581691e-02f, 3.72050740e-02f, -1.85445204e-01f,
  -7.56316483e-02f, 1.00339584e-01f, -8.23834687e-02f, -1.00726128e-01f, 3.42616923e-02f, -4.23706323e-03f, -8.70004743e-02f, -5.66790737e-02f, -1.61441155e-02f, -1.52764916e-02f,
  -3.25660482e-02f, -1.55188158e-01f, 1.02146991e-01f, -9.11657140e-02f, -2.26900745e-02f, -4.94498238e-02f, -2.15826947e-02f, 1.63438041e-02f, -5.52334217e-03f, 5.16289063e-02f,
  1.28721654e-01f, -9.45629776e-02f, -5.12684435e-02f, -8.77635647e-03f, -5.01139723e-02f, -6.43425509e-02f, -1.55618740e-02f, -2.10268125e-02f, -1.10573927e-02f, -5.70375659e-03f,
  -1.61424447e-02f, 3.82549465e-02f, 1.33631695e-02f, 9.18871909e-03f, -4.82867006e-03f, 4.16235700e-02f, 7.96670094e-02f, 1.03716835e-01f, 5.19469976e-02f, 1.21279813e-01f,
  9.03175864e-03f, -6.97685629e-02f, 2.12155338e-02f, 7.01852441e-02f, 9.30997133e-02f, -7.04712793e-02f, -8.42342677e-04f, -4.95581068e-02f, 3.85584123e-02f, 1.38015803e-02f,
  -7.83830434e-02f, 1.31876254e-02f, -9.66230594e-03f, 3.67811657e-02f, -4.20627855e-02f, -2.68486273e-02f, 3.26861814e-02f, 2.90993378e-02f, 9.48581323e-02f, -2.21761651e-02f,
  6.59592226e-02f, -6.42493889e-02f, 4.67618667e-02f, -5.47986627e-02f, 1.33713940e-03f, 7.07199872e-02f, 1.18920319e-02f, 5.44143729e-02f, -2.10379101e-02f, 1.13431714e-01f,
  1.09080188e-02f, -7.12022334e-02f, 6.73230216e-02f, 7.45465560e-03f, 2.12095138e-02f, -4.28879336e-02f, 3.25606391e-02f, 2.35451870e-02f, 1.20107802e-02f, 5.39300516e-02f,
  7.93911219e-02f, -1.76653549e-01f, -7.94199333e-02f, -4.15238515e-02f, -7.12727979e-02f, -4.82693426e-02f, -3.87984701e-02f, 9.52501148e-02f, 6.09957352e-02f, -7.00038597e-02f,
  3.25403474e-02f, -8.80088005e-03f, -6.00516163e-02f, 5.72843701e-02f, 3.82043570e-02f, 3.70216966e-02f, 4.38033529e-02f, 5.54094091e-02f, 6.17889725e-02f, 4.60842513e-02f,
  -4.99801226e-02f, 6.42377734e-02f, -8.22106823e-02f, -7.01002181e-02f, 1.41899404e-03f, -2.19341926e-02f, 6.63843751e-02f, -4.49630991e-02f, -1.98066700e-03f, -2.65968293e-02f,
  7.61864558e-02f, -3.53298895e-02f, -1.33341420e-02f, 1.33190393e-01f, -3.65340523e-03f, -4.28809300e-02f, 1.90474838e-02f, 3.11968718e-02f, -4.18768898e-02f, 4.34021018e-02f,
  -7.79028237e-02f, 7.79775456e-02f, -8.50915015e-02f, -2.22653896e-02f, 5.03097475e-02f, -1.28320143e-01f, -2.75277793e-02f, -2.84523256e-02f, -6.20547533e-02f, 1.15711369e-01f,
  7.81895891e-02f, -4.22248915e-02f, 8.62883106e-02f, 6.42221868e-02f, 2.82478463e-02f, 1.75237395e-02f, -4.25722227e-02f, -9.09534991e-02f, 1.05027519e-01f, -5.20126931e-02f,
  -2.49453764e-02f, -4.23810557e-02f, -2.72251144e-02f, -3.87809053e-02f, 8.99317563e-02f, 7.69004673e-02f, 1.00617051e-01f, -8.82309750e-02f, 1.23031102e-02f, -8.85056779e-02f,
  3.17138201e-03f, 7.57209361e-02f, 5.75568527e-02f, -4.58241291e-02f, -4.88993078e-02f, 8.55991840e-02f, -8.04240163e-03f, 9.59142298e-03f, 1.57208126e-02f, -4.08003554e-02f,
  -1.85932051e-02f, -3.75360847e-02f, 2.44747717e-02f, 1.01754464e-01f, 9.87324566e-02f, -4.83395495e-02f, -9.76377726e-02f, 5.57574928e-02f, 5.24820350e-02f, 1.63383409e-02f,
  5.96198179e-02f, -1.03649415e-01f, 5.38275531e-03f, 6.99375793e-02f, 3.32588353e-03f, 3.44337374e-02f, 3.98005582e-02f, 3.98114845e-02f, -7.94449821e-02f, 3.32416110e-02f,
  3.09213325e-02f, -1.32753113e-02f, 4.58657369e-02f, 1.19233867e-02f, -2.31521856e-02f, 2.09361669e-02f, -8.62585828e-02f, -6.11225106e-02f, -2.89503448e-02f, 5.44987805e-02f,
  1.74682979e-02f, -4.39448543e-02f, -7.22461343e-02f, -6.02254719e-02f, -8.65647644e-02f, 5.17669283e-02f, 5.23309782e-02f, 1.09293975e-03f, -2.15453058e-02f, -2.91721392e-02f,
  -2.70798635e-02f, 9.90329906e-02f, -1.74440220e-02f, 1.63280126e-02f, 9.07232165e-02f, 4.52663228e-02f, 1.84434187e-02f, 1.53705608e-02f, -3.98266176e-03f, 9.71022993e-02f,
  8.49146917e-02f, -4.85549495e-02f, 5.80853447e-02f, 7.36222044e-02f, 5.95228039e-02f, -2.11231858e-02f, -8.17245096e-02f, 8.98460448e-02f, 4.29617241e-02f, 7.14281981e-04f,
  -3.42722274e-02f, -1.33995311e-02f, -3.44534777e-02f, 1.17071852e-01f, 2.60872301e-02f, 6.06081299e-02f, -5.72020449e-02f, -3.79286781e-02f, -7.73375854e-02f, 6.84666708e-02f,
  1.41811103e-01f, -1.97632164e-01f, -3.22586931e-02f, 2.81328827e-01f, 1.26973107e-01f, 8.24440867e-02f, -2.36064736e-02f, -6.57433122e-02f, 4.74191196e-02f, -1.90824658e-01f,
  5.71847223e-02f, -1.01133557e-02f, -2.54847229e-01f, 1.79644719e-01f, 1.44769907e-01f, -1.03959501e-01f, 9.71559361e-02f, -2.87037082e-02f, 3.03572286e-02f, -1.78217776e-02f,
  3.04833450e-03f, 9.95516852e-02f, 4.53863405e-02f, 1.06128819e-01f, 1.90130621e-02f, -3.21036263e-04f, 9.56884101e-02f, -7.55559132e-02f, 1.10896051e-01f, 1.10134102e-01f,
  7.62787014e-02f, -4.99370247e-02f, 4.05323394e-02f, 7.42907375e-02f, -3.41211818e-03f, -1.80234853e-02f, 5.53250834e-02f, 9.18971524e-02f, 1.16110638e-01f, -1.19114041e-01f,
  -1.21462733e-01f, 8.28969181e-02f, 6.17539249e-02f, -3.70952748e-02f, 5.19765541e-02f, 1.07337341e-01f, -4.80999015e-02f, 5.87968789e-02f, -7.91084096e-02f, -3.64816040e-02f,
  7.78816547e-03f, -1.09965615e-01f, -1.35208564e-02f, -5.72558902e-02f, 4.58665285e-03f, 1.48203159e-02f, -1.15983732e-01f, -3.14603560e-02f, -1.28114698e-02f, -5.45267984e-02f,
  -5.72640225e-02f, -4.09658663e-02f, -2.96147130e-02f, 1.23046950e-01f, -1.39780715e-02f, 8.60676318e-02f, -3.32616605e-02f, -2.32183225e-02f, 1.45385331e-02f, 1.91391315e-02f,
  2.43917219e-02f, 3.49216610e-02f, 9.84561518e-02f, 2.38021780e-02f, -5.77838952e-03f, -4.16609272e-02f, -1.51454378e-02f, 6.24782369e-02f, -2.49045417e-02f, -3.59845869e-02f,
  5.08190989e-02f, 2.23990381e-02f, -1.76002793e-02f, -2.05831677e-02f, -2.51571126e-02f, 3.65594216e-02f, 7.54820481e-02f, 4.60536554e-02f, 2.34811590e-03f, 4.21003141e-02f,
  -4.76132557e-02f, -2.35177681e-01f, -1.09398797e-01f, 5.62952757e-02f, -5.22929840e-02f, 4.85372543e-02f, 5.53226622e-04f, 4.08447199e-02f, 3.29537429e-02f, -8.69079214e-03f,
  -4.14773412e-02f, 4.91140485e-02f, -7.00850338e-02f, 9.26412717e-02f, 9.59660485e-02f, -5.47274388e-02f, -4.82897721e-02f, -5.55582419e-02f, -2.40191892e-02f, -9.15013403e-02f,
  -8.53294432e-02f, -9.19240266e-02f, -3.35382111e-02f, 4.88044098e-02f, 9.49143618e-02f, 3.91762331e-02f, 1.44000771e-02f, -3.05955186e-02f, -1.03001781e-02f, -6.60614446e-02f,
  1.39251158e-01f, -1.80353262e-02f, -2.53945649e-01f, 5.52471913e-02f, -1.32728331e-02f, 1.08376481e-01f, 3.97963226e-02f, 8.96013379e-02f, -2.85984818e-02f, 4.39960659e-02f,
  1.61061972e-01f, -1.07976332e-01f, -1.34254575e-01f, 3.57786596e-01f, 2.93885112e-01f, 1.40909767e-02f, 2.06955448e-01f, 1.40125200e-01f, -6.44731447e-02f, 1.32448792e-01f,
  8.15318078e-02f, 3.96770269e-01f, 5.37937367e-03f, 9.76413786e-02f, 1.44368276e-01f, -1.18028671e-01f, 9.87046957e-02f, -9.27535072e-02f, 1.30244955e-01f, 1.04655541e-01f,
  1.36611536e-01f, 2.51241755e-02f, -8.70436728e-02f, 1.52602314e-03f, -1.07159615e-02f, 2.91669779e-02f, -4.15863954e-02f, 5.52691184e-02f, 1.79274138e-02f, -6.70518056e-02f,
  -4.74995896e-02f, -4.09016572e-02f, -6.40185364e-03f, 2.45292243e-02f, -9.47832912e-02f, 6.01677336e-02f, -2.41244752e-02f, -1.77994315e-02f, -4.74235825e-02f, -2.05712765e-02f,
  -1.57636739e-02f, 5.44046685e-02f, -2.97935717e-02f, 2.78871935e-02f, -8.88959505e-04f, -2.26145051e-02f, 4.14187796e-02f, -2.07088962e-02f, -8.12645480e-02f, 6.50284365e-02f,
  5.60538247e-02f, -6.23234771e-02f, -3.34061161e-02f, 2.54132375e-02f, 3.42246443e-02f, -3.06832585e-02f, -9.52230915e-02f, -7.14359581e-02f, -3.27432677e-02f, 7.20087141e-02f,
  -3.86525691e-02f, -4.50151898e-02f, 2.84917597e-02f, 8.91612023e-02f, 7.54894912e-02f, -2.68114004e-02f, 5.01096807e-02f, 1.00623667e-01f, -3.18080187e-02f, -2.40172781e-02f,
  2.09339820e-02f, -1.00732632e-02f, 8.08275342e-02f, -4.49621528e-02f, -2.34411359e-02f, -1.38462996e-02f, 3.07208858e-02f, 6.99953316e-03f, -1.23143665e-01f, -8.43503326e-02f,
  8.79487246e-02f, 1.37307361e-01f, -2.99243480e-02f, 8.14257339e-02f, -8.84159207e-02f, 6.23231642e-02f, -3.86138819e-02f, 5.33941053e-02f, 4.17976379e-02f, -6.50703767e-03f,
  5.92734367e-02f, -2.79301703e-02f, 1.59690529e-02f, 2.50017829e-02f, -1.56486239e-02f, 9.80423018e-02f, 1.92631222e-02f, -2.37040315e-02f, 1.02747940e-02f, 1.28898844e-01f,
  -4.11825813e-02f, -5.78560308e-02f, 5.08058025e-03f, -5.13051301e-02f, -1.54385800e-02f, -1.04244255e-01f, -3.48365656e-03f, -5.67641780e-02f, -1.12605067e-02f, 3.03879920e-02f,
  2.56012648e-01f, 3.07043213e-02f, 2.24841475e-01f, 3.19216549e-01f, 5.84065579e-02f, -1.42732263e-01f, -6.76787347e-02f, 7.61699006e-02f, 3.12340837e-02f, -1.03150815e-01f,
  -9.26155224e-02f, 2.76400238e-01f, -1.67912871e-01f, 6.17742501e-02f, -1.19418226e-01f, -2.49367759e-01f, 6.48021773e-02f, 8.00863001e-03f, 1.55782531e-04f, 6.03103600e-02f,
  6.55195490e-02f, -1.77126676e-01f, 1.35628447e-01f, -3.79726030e-02f, 2.03403786e-01f, 1.41390353e-01f, -8.20809975e-02f, 5.44157438e-03f, 1.34262308e-01f, -7.50839245e-03f,
  -6.98396713e-02f, -3.75118963e-02f, -2.01818552e-02f, 7.18004107e-02f, 6.27250556e-05f, 6.80424422e-02f, 4.45625260e-02f, -2.52508768e-03f, -1.25440303e-02f, 7.05858320e-02f,
  8.72801915e-02f, 1.00822523e-01f, 6.66966513e-02f, -3.54343243e-02f, 8.13054442e-02f, 2.80452594e-02f, 4.84874286e-03f, 1.24958523e-01f, 8.89034793e-02f, 8.06706250e-02f,
  9.91906971e-02f, 1.49454132e-01f, 9.48311687e-02f, -1.93172712e-02f, 1.20462850e-03f, 3.28506082e-02f, 6.46755099e-02f, 1.51137188e-02f, -6.62861466e-02f, -3.04801725e-02f,
  -5.18569537e-02f, 2.30213664e-02f, -8.07249546e-02f, -7.31685236e-02f, -1.99840311e-02f, 4.92349491e-02f, 2.19892785e-02f, -2.44662687e-02f, 3.31425294e-02f, -6.69074506e-02f,
  7.20211938e-02f, -4.72085923e-02f, -6.90800771e-02f, -8.63637589e-03f, -2.47918093e-03f, -6.39777854e-02f, 9.26532224e-02f, 1.32140266e-02f, 9.29983184e-02f, 3.99896912e-02f,
  -5.58137372e-02f, -1.16897968e-03f, 7.07167462e-02f, -1.61477807e-03f, 2.75224857e-02f, 1.42423566e-02f, -8.78902078e-02f, -1.91445579e-03f, -1.78190172e-02f, -2.65942197e-02f,
  -8.92354921e-02f, -1.66274905e-01f, 4.97487932e-02f, -1.31246857e-02f, -2.28188150e-02f, 3.74727622e-02f, 1.29596889e-02f, -7.47603411e-03f, -1.04276977e-01f, -4.75684479e-02f,
  2.94946656e-02f, 1.13052174e-01f, -7.98443109e-02f, -4.84277196e-02f, -4.77965437e-02f, 3.20558399e-02f, -2.28465721e-03f, -1.68288704e-02f, -3.18181887e-02f, 3.10185421e-02f,
  -8.02435167e-03f, -3.92494202e-02f, 4.79136780e-02f, 8.93104970e-02f, -3.32894698e-02f, 1.18939476e-02f, -5.14286980e-02f, -6.06218772e-03f, -2.45034825e-02f, -1.33775230e-02f,
  7.55235478e-02f, 9.63041559e-02f, 3.24318737e-01f, 2.07387835e-01f, 2.14550212e-01f, 1.22807711e-01f, 1.82018980e-01f, 1.66033924e-01f, 4.30592716e-01f, -2.14685813e-01f,
  -1.60613298e-01f, 1.77045297e-02f, -2.19360799e-01f, 2.13097781e-02f, -1.22303635e-01f, 5.19006439e-02f, 4.56401482e-02f, -5.32221049e-02f, 1.58432320e-01f, 5.11376224e-02f,
  1.29236072e-01f, -1.45509943e-01f, -7.03382939e-02f, -1.20888501e-01f, 5.65248094e-02f, 1.82401195e-01f, -2.45602757e-01f, -5.04734106e-02f, -9.23095047e-02f, -2.16940674e-03f,
  -6.98691159e-02f, 1.27752692e-01f, -6.76637366e-02f, -2.01492924e-02f, -5.86898662e-02f, -2.43093120e-03f, -8.19986984e-02f, -6.13964349e-02f, -2.24605929e-02f, -3.37627195e-02f,
  -6.10264204e-03f, -9.16428268e-02f, -5.15512638e-02f, -4.30380972e-03f, 4.38898616e-02f, 3.23770419e-02f, 1.30036652e-01f, 8.82622376e-02f, 9.03902948e-02f, -4.18787124e-04f,
  7.15167448e-02f, -3.65371779e-02f, 1.76834483e-02f, -3.36058848e-02f, -2.79301703e-02f, 7.74930343e-02f, -7.60428905e-02f, 5.16725965e-02f, -2.70881206e-02f, 5.11565758e-03f,
  -7.55484961e-03f, 6.05458282e-02f, -1.68277919e-02f, -2.70970035e-02f, 3.98035906e-02f, -2.38753762e-02f, -1.55759379e-02f, -9.13087204e-02f, 1.09665997e-01f, -3.91751602e-02f,
  -2.01706216e-02f, 1.85606033e-02f, 9.28604007e-02f, 8.21088329e-02f, -1.09423604e-02f, 3.75764212e-04f, 5.46223186e-02f, -7.53720552e-02f, 4.33025099e-02f, -2.44335784e-03f,
  4.04056348e-02f, 2.52548549e-02f, -5.71839213e-02f, 5.73933721e-02f, 3.37011665e-02f, 9.02683023e-05f, 1.30526861e-02f, 6.40503392e-02f, -4.50754538e-02f, 3.36122960e-02f,
  2.21689697e-02f, -5.11669032e-02f, -8.10379535e-03f, -5.49685210e-02f, 1.17982011e-02f, -1.04400404e-01f, -2.52592396e-02f, -6.94960281e-02f, 1.37779489e-02f, -4.43780832e-02f,
  -2.53108963e-02f, -1.19563356e-01f, 1.80207863e-02f, -2.84304731e-02f, -4.40014564e-02f, -8.02589655e-02f, -4.26140688e-02f, -2.15468314e-02f, -1.28015265e-01f, 4.59427163e-02f,
  -6.33739829e-02f, -5.05009070e-02f, -4.25377265e-02f, -1.21248797e-01f, 1.63869821e-02f, -7.49532431e-02f, 1.70693528e-02f, 6.40490055e-02f, 1.54552748e-03f, 5.20719960e-02f,
  2.12088779e-01f, 2.28714682e-02f, -1.68766677e-02f, 1.58608556e-02f, -3.29255871e-02f, 1.05991974e-01f, 9.33299884e-02f, -1.18768690e-02f, 1.93915114e-01f, -5.26350886e-02f,
  -3.43031771e-02f, -5.34139834e-02f, -1.04654483e-01f, 1.41217131e-02f, 9.42840204e-02f, 4.87006940e-02f, -2.88605317e-02f, -6.32307604e-02f, 2.29667854e-02f, -5.35531575e-03f,
  1.35534987e-01f, -3.22545134e-02f, -7.32435659e-02f, -1.44810945e-01f, -8.98865014e-02f, -6.97163194e-02f, -1.31334096e-01f, -7.62112513e-02f, -1.92112967e-01f, -1.23784177e-01f,
  -3.59915979e-02f, 1.02638714e-01f, 8.73016417e-02f, 1.45623777e-02f, -6.67576715e-02f, -5.43023497e-02f, -1.27353191e-01f, -8.37443322e-02f, 8.94738436e-02f, 5.34427874e-02f,
  1.75539199e-02f, -7.26027489e-02f, -1.39411408e-02f, 3.36708054e-02f, 7.22944960e-02f, 4.88714837e-02f, 2.20905319e-02f, -3.41531448e-02f, -4.77920584e-02f, 2.76784915e-02f,
  4.42329496e-02f, 5.26101552e-02f, 1.10863760e-01f, -1.05708331e-01f, -1.52232600e-02f, -2.57805679e-02f, -4.09264900e-02f, 4.44143526e-02f, 3.03369910e-02f, 4.20560017e-02f,
  2.26165392e-02f, 6.55426085e-02f, -4.29560989e-02f, 8.09378922e-03f, -7.02550635e-02f, 3.58555466e-02f, 4.84257862e-02f, -1.85345411e-02f, 8.38347301e-02f, -5.42828105e-02f,
  5.81259280e-02f, 1.10331886e-01f, 7.71753956e-03f, 5.84687479e-02f, 6.04883321e-02f, -8.19056667e-03f, -9.83766690e-02f, 5.47654778e-02f, 5.28137535e-02f, 8.38524327e-02f,
  -5.26015572e-02f, 2.93636415e-02f, 1.41981617e-02f, -5.82899079e-02f, 3.28800492e-02f, 3.86106558e-02f, 3.56106125e-02f, -6.47353455e-02f, 4.80902195e-02f, 2.00462267e-02f,
  2.34572273e-02f, 1.12413429e-01f, 2.70620007e-02f, 7.12416545e-02f, -2.19925512e-02f, 3.24899107e-02f, 1.00212641e-01f, -2.35490240e-02f, 4.21083234e-02f, -3.08835860e-02f,
  -8.91869515e-02f, -8.58437195e-02f, -7.15789273e-02f, -1.61733571e-03f, 3.20483111e-02f, 6.54343590e-02f, -2.58918256e-02f, -5.53305708e-02f, 9.56100225e-03f, -9.15588215e-02f,
  -5.89868389e-02f, 5.19192358e-03f, 3.58255468e-02f, 9.88548901e-03f, -2.27825902e-02f, 9.69034992e-03f, -2.33269315e-02f, 3.90913226e-02f, -2.28802375e-02f, 3.49080563e-02f,
  -1.63927004e-01f, 6.86004236e-02f, -2.22505122e-01f, -2.15843573e-01f, -9.19137374e-02f, -2.04087771e-03f, -1.32736564e-01f, 3.63936052e-02f, 6.19121194e-02f, 1.85107887e-01f,
  3.31878960e-02f, -2.91475188e-03f, 1.39172077e-01f, 2.31887586e-02f, -9.93274450e-02f, 1.52974322e-01f, 6.25442415e-02f, -2.46081557e-02f, 7.92417452e-02f, -2.69497931e-02f,
  -5.30287921e-02f, -5.66849820e-02f, 5.98253310e-02f, 4.47313748e-02f, -1.47723615e-01f, -9.07810181e-02f, -8.50481838e-02f, -1.01461746e-01f, -1.50082573e-01f, -8.86091292e-02f,
  1.71473343e-02f, -1.28478080e-01f, -2.14070212e-02f, -6.36172667e-02f, -9.13710296e-02f, -1.41000357e-02f, -8.14468041e-02f, -8.48132521e-02f, 3.59737203e-02f, -3.99287380e-02f,
  -4.23278026e-02f, -6.63681328e-02f, -3.34312469e-02f, 9.43818539e-02f, -8.52085352e-02f, -8.21189210e-02f, 3.67860645e-02f, -1.94579680e-02f, -8.82441700e-02f, 2.17529815e-02f,
  3.54871317e-03f, -3.37430388e-02f, -3.89060229e-02f, 7.23171141e-03f, 8.74080416e-03f, -4.06777561e-02f, -5.07800616e-02f, -3.88488434e-02f, -1.00252017e-01f, 6.68529747e-03f,
  -5.04929125e-02f, -5.31740375e-02f, -1.49227325e-02f, -7.18486086e-02f, -8.04370344e-02f, -6.47914484e-02f, -5.58891669e-02f, -3.17584090e-02f, 7.70266876e-02f, -2.36271955e-02f,
  -1.86992120e-02f, -1.27921943e-02f, 4.42043971e-03f, 1.13619655e-01f, 1.82918627e-02f, -1.38870941e-03f, -2.23543448e-03f, -2.47664168e-03f, -2.09429469e-02f, -7.34724998e-02f,
  8.42750892e-02f, 2.42303368e-02f, -7.79450610e-02f, 8.42243582e-02f, -8.44956636e-02f, -4.23354879e-02f, 6.85733110e-02f, 6.88547641e-02f, 6.37263656e-02f, -1.73168257e-02f,
  -3.24327461e-02f, -8.99108574e-02f, -5.15986346e-02f, -3.19778733e-02f, -8.36511999e-02f, -3.29467058e-02f, -6.75845072e-02f, -6.07916825e-02f, -2.93252859e-02f, -8.74050986e-03f,
  -1.12559982e-01f, 1.47029227e-02f, -1.13897070e-01f, 4.33235206e-02f, -1.01917665e-02f, -7.80480877e-02f, -8.96709412e-02f, -1.14251263e-02f, 5.23472987e-02f, -4.62810434e-02f,
  -4.58638817e-02f, -7.42522925e-02f, 5.23170978e-02f, 2.81089097e-02f, -5.52539565e-02f, 2.27081105e-02f, -1.91931408e-02f, -1.24364056e-01f, -4.81437929e-02f, 9.68545079e-02f,
  -1.60763618e-02f, 6.17502183e-02f, -3.60773243e-02f, -6.05658814e-02f, 1.37925923e-01f, -4.77262661e-02f, -1.28843198e-02f, -7.21604303e-02f, -8.98345560e-02f, 4.15078364e-02f,
  9.11550131e-03f, -3.20095345e-02f, -4.51484509e-02f, -5.99550232e-02f, -1.21640250e-01f, -1.42727718e-01f, -6.27769530e-02f, 1.76220238e-02f, -1.02416076e-01f, -2.62765270e-02f,
  -6.96053682e-03f, 4.69073653e-02f, -1.42146617e-01f, 6.13521188e-02f, -5.05444817e-02f, 1.01363525e-01f, -4.75527085e-02f, -3.66338901e-02f, -5.29024825e-02f, 5.24862669e-02f,
  -8.53964984e-02f, -9.37203541e-02f, -6.99825063e-02f, -5.05591109e-02f, 5.55736898e-03f, -7.37770647e-02f, -1.60367284e-02f, 4.47745323e-02f, -2.39386577e-02f, 4.34982888e-02f,
  -7.35416040e-02f, 2.41903923e-02f, -2.88319755e-02f, 7.92308375e-02f, 2.59547844e-03f, -3.97212245e-02f, 1.77071281e-02f, 9.68076885e-02f, -1.38332779e-02f, -7.47062638e-02f,
  -1.34580259e-04f, 6.46940991e-02f, 6.79027662e-02f, -4.68097590e-02f, 4.49830852e-03f, 4.76525463e-02f, -4.34284993e-02f, 7.67358914e-02f, -2.64538638e-03f, 3.30917840e-03f,
  7.87311196e-02f, 9.04029086e-02f, -7.39837959e-02f, -1.74636375e-02f, -4.58131842e-02f, 8.92284364e-02f, 5.78390434e-02f, -5.45795970e-02f, 9.49406698e-02f, -6.20125867e-02f,
  -3.34844040e-03f, 8.12895373e-02f, 5.38532101e-02f, -5.14088534e-02f, -6.98582605e-02f, -9.21557192e-03f, 3.87933962e-02f, 2.48320177e-02f, -6.29806742e-02f, -1.65875852e-02f,
  5.43077439e-02f, -6.18854649e-02f, 7.03143999e-02f, 8.03839997e-04f, 7.32699186e-02f, -8.90514776e-02f, 2.28063148e-02f, 1.38917342e-02f, 5.42625971e-02f, 7.97386542e-02f,
  4.27014530e-02f, -9.46951210e-02f, -6.28579035e-02f, -3.63121331e-02f, -7.66639337e-02f, -2.12145280e-02f, -5.30326329e-02f, 5.34746274e-02f, -6.15221523e-02f, 6.24170378e-02f,
  -5.99331036e-02f, -4.99693491e-02f, 3.00272368e-02f, -5.84384426e-02f, 3.89894173e-02f, -2.92697940e-02f, 3.86837567e-03f, 7.66917244e-02f, 3.61260474e-02f, -7.15702102e-02f,
  2.16361992e-02f, 5.75916469e-02f, -4.57653143e-02f, -1.41114555e-02f, 8.16274807e-02f, 1.07192785e-01f, 9.11529586e-02f, -7.04066455e-02f, -3.63112502e-02f, 6.36814758e-02f,
  -2.30063926e-02f, 1.67736206e-02f, 9.48229730e-02f, -9.64610185e-03f, -4.91741337e-02f, 1.16749436e-01f, 1.53200984e-01f, 3.41835991e-02f, 1.63812652e-01f, -7.92420208e-02f,
  -1.25412285e-01f, -8.25307444e-02f, 2.34488938e-02f, -2.52143424e-02f, 1.03388622e-01f, 8.63720924e-02f, 8.24734122e-02f, -4.49154247e-03f, 3.97399440e-02f, 1.40402401e-02f,
  4.74574007e-02f, -4.77730036e-02f, -3.96711752e-03f, 5.77983595e-02f, 1.31749604e-02f, 7.54732499e-03f, -1.00011677e-01f, -3.21710482e-02f, -1.59677356e-01f, -7.84616247e-02f,
  3.77983227e-02f, 8.99810567e-02f, 8.91750678e-03f, 9.21731815e-02f, -9.73162577e-02f, 9.02391225e-02f, -4.72251847e-02f, 7.46627003e-02f, 2.75808908e-02f, 3.83656509e-02f,
  -8.74779969e-02f, 4.26583886e-02f, -7.07295313e-02f, 8.61062482e-02f, 8.75548199e-02f, 6.09725453e-02f, -6.41219392e-02f, -7.99914226e-02f, -1.09297615e-02f, -1.10463202e-02f,
  6.60480186e-02f, -1.08139003e-02f, 8.37780908e-02f, 9.85381156e-02f, -7.90750608e-02f, 8.63482803e-02f, 3.74024138e-02f, -6.04745783e-02f, -3.80405821e-02f, -7.39836395e-02f,
  -2.48492416e-02f, -2.79166903e-02f, -5.20373732e-02f, 7.84722622e-03f, -5.96740842e-02f, -7.55684972e-02f, -3.01713217e-02f, -2.08988935e-02f, -9.25694108e-02f, -6.53994903e-02f,
  6.50473312e-02f, 9.56372172e-02f, -6.24940470e-02f, 3.64953242e-02f, -8.64722803e-02f, 3.22379395e-02f, -4.78018373e-02f, 5.29047064e-02f, 3.64447036e-03f, -3.55812497e-02f,
  3.27102877e-02f, -1.90238543e-02f, 3.09543014e-02f, -2.68663354e-02f, -3.18399630e-02f, -8.07391629e-02f, 2.95877159e-02f, 1.01751395e-01f, -5.06188944e-02f, -1.15196697e-01f,
  -7.82771856e-02f, -4.15370017e-02f, 2.55518109e-02f, -2.36039162e-02f, -5.73421223e-03f, -8.39950070e-02f, -4.21130396e-02f, -3.92130092e-02f, -8.01688954e-02f, -3.91059853e-02f,
  -3.23346220e-02f, -6.15353510e-02f, 2.39027943e-02f, 5.55802137e-02f, -1.55954147e-02f, 1.09142661e-01f, -9.62019060e-03f, -2.37318873e-02f, 7.15672737e-03f, -8.93547311e-02f,
  -9.45022702e-03f, 5.55211399e-03f, 5.88931516e-02f, 7.62502626e-02f, 3.88800204e-02f, 1.86869327e-03f, -6.64673671e-02f, -1.91953927e-02f, -8.15801471e-02f, 1.49065647e-02f,
  1.27752036e-01f, -2.87953436e-01f, 1.92848504e-01f, 1.98257510e-02f, 1.81718081e-01f, 1.87861100e-01f, 2.95454174e-01f, -5.82630979e-04f, -1.00214519e-01f, -3.35819811e-01f,
  1.24508317e-03f, 1.28406649e-02f, -8.32827687e-02f, -1.33073986e-01f, 2.34888449e-01f, -5.75950556e-02f, -3.21329907e-02f, -4.32362296e-02f, -4.43004891e-02f, 1.73990789e-03f,
  4.58858535e-02f, 6.14395700e-02f, 1.41095787e-01f, -1.11624084e-01f, 8.88303481e-03f, -9.25595388e-02f, -6.86893687e-02f, 1.55266732e-01f, -1.09990768e-01f, 8.14620480e-02f,
  -8.87454897e-02f, -4.30950597e-02f, -1.15418613e-01f, -1.26168907e-01f, 2.36203708e-03f, 6.94665760e-02f, -2.52961162e-02f, 1.61183238e-01f, 9.86022651e-02f, 2.78820693e-02f,
  2.45472100e-02f, -9.07713026e-02f, -8.98028985e-02f, 5.77007867e-02f, -6.42730519e-02f, -3.99870276e-02f, 4.49424610e-02f, -9.57345441e-02f, -3.89386863e-02f, 2.98718251e-02f,
  2.56658271e-02f, -7.61739314e-02f, -9.01850089e-02f, 3.68540129e-03f, 8.25630501e-02f, 2.15234011e-02f, -5.04410006e-02f, 3.87340598e-02f, -6.45818487e-02f, -5.02172187e-02f,
  7.56303594e-02f, 1.07748812e-04f, -2.76081096e-02f, -8.24151635e-02f, -2.26758216e-02f, -9.60007403e-03f, 4.75311689e-02f, -1.69380438e-02f, -8.07576478e-02f, -1.39545277e-02f,
  4.37946664e-03f, -5.03131822e-02f, -9.48326513e-02f, 3.90838692e-03f, 2.81348303e-02f, -6.43244162e-02f, -1.04130581e-02f, -3.54779847e-02f, -3.52196838e-03f, -1.57717578e-02f,
  9.08995718e-02f, -9.41402745e-03f, 4.02147025e-02f, 2.60363203e-02f, 4.29961272e-02f, -4.26648743e-02f, -6.97512999e-02f, -5.79192489e-02f, -1.27425566e-02f, 9.76764485e-02f,
  -1.71413392e-01f, -2.18561947e-01f, -8.63643885e-02f, -3.16114202e-02f, -8.13349485e-02f, -5.86235300e-02f, -4.15921124e-04f, -7.84682333e-02f, -3.25743817e-02f, 7.55981058e-02f,
  -4.12855111e-02f, 4.45929542e-02f, 2.97088698e-02f, 4.04310897e-02f, -2.82862559e-02f, -3.84102836e-02f, 4.54173647e-02f, -3.58941033e-02f, -3.39780487e-02f, -8.55007917e-02f,
  -9.10000876e-02f, -5.83853312e-02f, 5.41517809e-02f, -7.45129911e-03f, -9.08310413e-02f, -6.23730849e-03f, 6.08429275e-02f, -4.26962823e-02f, 8.31900761e-02f, 8.48804563e-02f,
  -5.40243983e-02f, 9.70643982e-02f, 4.21788432e-02f, 9.38314106e-03f, -1.14588469e-01f, -1.31762043e-01f, -3.58036533e-02f, -2.58450173e-02f, 9.28900391e-02f, 1.10802703e-01f,
  -4.23488840e-02f, 1.52579453e-02f, 6.99515566e-02f, 9.03406218e-02f, 1.55028785e-02f, 1.00502819e-01f, -3.47682908e-02f, 7.35041872e-02f, -1.84900425e-02f, -9.25523043e-02f,
  -1.22873373e-01f, -1.05159573e-01f, -4.31882776e-02f, -1.50148928e-01f, -3.23103219e-02f, -1.47869671e-03f, -5.69249764e-02f, -2.66388319e-02f, -1.05489388e-01f, -1.40559688e-01f,
  -3.80192790e-03f, -7.32566044e-02f, 2.43021548e-03f, -2.24457309e-02f, 2.98542576e-03f, 9.36497748e-02f, -8.82532522e-02f, 7.00038597e-02f, -5.85892089e-02f, -1.54100098e-02f,
  3.92295979e-02f, -7.79726058e-02f, 6.06159717e-02f, -1.11179734e-02f, 5.96087426e-03f, -3.65811377e-03f, 3.25121135e-02f, 1.71956792e-02f, 6.94744438e-02f, -7.17914989e-03f,
  3.16597745e-02f, 6.27508759e-02f, -1.65410750e-02f, -5.11169210e-02f, -9.96738598e-02f, 3.81926298e-02f, -3.07017937e-02f, -2.66778432e-02f, -1.01559587e-01f, -3.51092219e-02f,
  -2.90953498e-02f, -7.32930005e-02f, -4.14924584e-02f, 7.36258328e-02f, -8.93148035e-02f, -8.12957287e-02f, 6.98824376e-02f, -8.66588205e-02f, -1.84981041e-02f, 7.19888881e-02f,
  -4.15383093e-02f, 3.11515238e-02f, 4.47591301e-03f, 7.63978809e-02f, -6.59060553e-02f, 1.10793978e-01f, -5.39567769e-02f, 6.55250326e-02f, -7.35890344e-02f, 4.34923422e-04f,
  3.57083641e-02f, 6.29110262e-02f, -4.29598130e-02f, -3.85608943e-03f, -1.85037293e-02f, 5.63901998e-02f, -1.69476550e-02f, -1.80086028e-02f, -5.36585525e-02f, 4.93031889e-02f,
  -9.81589481e-02f, -1.69707686e-01f, -3.30982246e-02f, 2.30273921e-02f, 1.43316546e-02f, -4.94384319e-02f, 7.50829875e-02f, 8.89553502e-02f, -3.91874611e-02f, -8.43291283e-02f,
  2.49095261e-02f, 7.47240633e-02f, -1.02755092e-01f, -1.45368231e-03f, -8.25278237e-02f, 6.36626706e-02f, -9.70306899e-03f, 2.47626123e-03f, -3.61584872e-02f, 6.54119998e-02f,
  -3.00508048e-02f, -1.74828749e-02f, 9.77654383e-02f, -1.70175824e-02f, -6.91472813e-02f, 2.44662836e-02f, -8.81775394e-02f, 7.68781230e-02f, -4.90482301e-02f, 6.58106580e-02f,
  -4.83401157e-02f, -8.42743739e-02f, 8.23664758e-03f, -1.21777998e-02f, 4.07013111e-02f, -8.00522193e-02f, -1.21467570e-02f, 5.31927533e-02f, -1.06023356e-01f, 9.47208959e-04f,
  5.29398993e-02f, 7.98355713e-02f, -1.31885573e-01f, -1.34735793e-01f, -1.22486986e-02f, -1.69023558e-01f, -1.41778141e-02f, -1.74306873e-02f, -7.65655339e-02f, -2.54697558e-02f,
  -7.61012211e-02f, -1.09253310e-01f, -9.40414071e-02f, -6.70067593e-02f, 4.98567708e-04f, -3.63386758e-02f, 9.90700559e-04f, 1.16590708e-01f, -2.94833705e-02f, -8.44459385e-02f,
  -5.14576323e-02f, -3.11352964e-02f, 2.65398026e-02f, 4.98966202e-02f, 4.07513604e-02f, 8.32465515e-02f, 3.13881636e-02f, 2.28971895e-02f, -2.57136766e-02f, -1.04069933e-01f,
  7.24820271e-02f, -1.30159575e-02f, -5.83058968e-02f, 4.79218177e-02f, -2.25109123e-02f, 4.59271558e-02f, 2.09953282e-02f, 1.89092197e-02f, -5.92322461e-02f, 6.59357756e-02f,
  5.97611666e-02f, -3.67283188e-02f, -4.02098708e-02f, 8.50313008e-02f, -7.89183751e-02f, 9.70131252e-04f, 7.87531957e-02f, -8.26631859e-02f, -5.25354743e-02f, -6.42041564e-02f,
  -8.26531053e-02f, -5.15646972e-02f, -6.49678856e-02f, 3.06014046e-02f, 6.68287352e-02f, -3.11753433e-03f, -1.79671459e-02f, -3.73293795e-02f, 6.43904880e-02f, -7.51970708e-02f,
  8.86531472e-02f, -6.65850053e-03f, -1.37496032e-02f, -2.26153173e-02f, 6.38434514e-02f, 4.53693140e-03f, 5.66298626e-02f, -5.02259955e-02f, 3.62885296e-02f, 2.65022293e-02f,
  8.33237823e-03f, 6.66659921e-02f, -8.84395763e-02f, -8.16309005e-02f, 4.31779660e-02f, -3.86663452e-02f, -5.17492034e-02f, -5.60512878e-02f, 4.03175950e-02f, -7.16802990e-03f,
  8.33154842e-02f, -6.67527989e-02f, 7.74369165e-02f, 6.03183284e-02f, 6.68194443e-02f, -6.45313784e-02f, -4.88331541e-03f, -2.80664153e-02f, 7.87347406e-02f, -4.28227633e-02f,
  -2.31325198e-02f, 1.23739894e-02f, 5.09076118e-02f, -1.73420422e-02f, -1.59323141e-02f, -4.02462482e-03f, 6.95641339e-02f, 7.23796710e-02f, -1.95734724e-02f, 7.10321814e-02f,
  6.35627583e-02f, -8.20581391e-02f, 3.59634287e-03f, -2.85081174e-02f, 5.69402948e-02f, 1.03405369e-02f, 4.05050479e-02f, -7.94970915e-02f, 6.27787411e-02f, -6.31614402e-02f,
  2.75943372e-02f, -1.34532988e-01f, 1.29026771e-01f, 2.59828586e-02f, -4.87956554e-02f, -1.61422074e-01f, -1.45083308e-01f, -1.67839020e-01f, 6.92147538e-02f, -1.18587434e-01f,
  -7.31053576e-02f, 4.40909900e-02f, -1.72175504e-02f, -1.00744694e-01f, 1.02473624e-01f, 8.49093795e-02f, -1.35286272e-01f, -6.46540225e-02f, 6.41660318e-02f, -5.87230176e-02f,
  1.34338513e-01f, -4.23231125e-02f, 1.44398762e-02f, -1.80673644e-01f, -7.21259564e-02f, -9.18496773e-02f, -4.94216271e-02f, -1.05636314e-01f, -2.11285036e-02f, -4.06061821e-02f,
  -4.55522723e-02f, -5.59044555e-02f, 1.26701996e-01f, 1.01242401e-01f, -6.79036081e-02f, 2.89099123e-02f, 7.73555413e-02f, 2.54420284e-02f, -3.94753702e-02f, -1.77977569e-02f,
  -5.43094091e-02f, -8.31030309e-02f, 7.45187625e-02f, -5.17070666e-02f, -4.98458147e-02f, 2.19551567e-02f, 3.75924632e-02f, 8.86699781e-02f, -1.82203650e-02f, -1.36136049e-02f,
  -7.89851788e-03f, 7.21695647e-02f, 4.65767533e-02f, -2.15033628e-02f, -3.66060808e-02f, 3.10216323e-02f, 1.15840286e-01f, -4.04430702e-02f, 2.50602365e-02f, -6.85660765e-02f,
  2.86559258e-02f, 1.43482853e-02f, -2.69579906e-02f, -1.11862317e-01f, 2.00952888e-02f, -3.90591845e-02f, 3.33798267e-02f, -7.65237063e-02f, -4.32010815e-02f, -1.38569837e-02f,
  3.87757756e-02f, -7.98789710e-02f, -7.06562586e-03f, 7.30966628e-02f, 7.41836727e-02f, -7.88982585e-02f, 7.00238794e-02f, -8.20056796e-02f, 2.20873393e-03f, 1.81229543e-02f,
  8.93749949e-03f, 9.81283560e-02f, -8.79096910e-02f, -8.97507817e-02f, 7.39054978e-02f, -4.11415147e-03f, -4.95580845e-02f, -2.89274827e-02f, 4.17074747e-02f, -4.34395261e-02f,
  -4.79643084e-02f, -3.70128229e-02f, 4.68211845e-02f, 9.64337960e-02f, -4.39161547e-02f, -4.39338535e-02f, 3.95070054e-02f, -7.48066753e-02f, -9.13709998e-02f, 4.94333096e-02f,
  -4.87865657e-02f, 2.51980387e-02f, 1.84346866e-02f, -2.41999403e-02f, -3.20079066e-02f, -2.81864163e-02f, -7.43401349e-02f, 6.82900846e-02f, 5.30205332e-02f, -8.69926885e-02f,
  9.92106460e-03f, -2.69533228e-02f, 1.34817669e-02f, 3.08741275e-02f, -8.00767317e-02f, -9.30154696e-02f, 6.00938313e-02f, 5.50749525e-02f, -7.29430765e-02f, 4.12037149e-02f,
  -6.38017133e-02f, 4.83581983e-02f, 1.88556761e-01f, -9.79903266e-02f, 6.99383765e-02f, 1.70750841e-01f, 6.83283284e-02f, 5.04607037e-02f, -2.20749155e-02f, -8.57030600e-02f,
  -1.51104897e-01f, 3.23770642e-02f, 4.77115698e-02f, 5.47444411e-02f, -8.53370503e-03f, -6.65213391e-02f, -5.28597496e-02f, 1.04057901e-01f, 2.47810371e-02f, 1.05039850e-01f,
  -1.96504891e-02f, -6.53365850e-02f, -7.06701493e-03f, 5.72833829e-02f, -4.76685055e-02f, -5.20300642e-02f, -8.84311795e-02f, 1.93333458e-02f, -1.12515572e-03f, 2.34904047e-03f,
  1.29920334e-01f, 4.63470817e-02f, 1.16581082e-01f, 4.57455330e-02f, 3.15084704e-04f, 7.74251297e-02f, -8.14771354e-02f, -8.02926719e-02f, 3.88344266e-02f, 4.48113121e-02f,
  -2.78342515e-02f, 3.73163410e-02f, -8.61173943e-02f, 4.38929796e-02f, -9.68041196e-02f, -2.75202226e-02f, 9.70479175e-02f, -9.09080636e-03f, -2.67102569e-02f, 7.82869160e-02f,
  4.69415123e-03f, -1.26989922e-02f, -1.45502053e-02f, -1.15435421e-01f, 6.81878924e-02f, -7.78853595e-02f, -7.74566084e-02f, -4.72476669e-02f, 7.06996024e-02f, 8.68611503e-03f,
  -7.26522431e-02f, -4.77199703e-02f, -6.58227969e-03f, 9.94244963e-02f, -1.16633838e-02f, 6.37644827e-02f, -2.67901178e-02f, 5.52391708e-02f, -2.24171728e-02f, -7.08614588e-02f,
  -2.45613884e-03f, -6.19360693e-02f, -5.11334687e-02f, -6.60999566e-02f, 6.48219511e-02f, 6.13693707e-02f, 1.45629905e-02f, -1.91572383e-02f, -9.11500528e-02f, 1.03596345e-01f,
  -1.23751061e-02f, 1.31993741e-02f, -5.19494899e-02f, -9.16180238e-02f, -2.41622161e-02f, -5.17651513e-02f, 1.46634737e-02f, 3.21568400e-02f, 4.03163992e-02f, 6.12069629e-02f,
  1.44336492e-01f, 4.03607525e-02f, 6.15654476e-02f, 5.63283972e-02f, 9.74765420e-02f, -8.17412212e-02f, 5.18850610e-03f, -9.74426395e-04f, 9.20541286e-02f, -4.19302098e-02f,
  -5.75722307e-02f, 1.22559071e-02f, -2.70785037e-02f, -4.48445007e-02f, 3.31356898e-02f, 2.15930808e-02f, -3.00238114e-02f, -6.52677147e-04f, -5.84744103e-02f, -6.47996068e-02f,
  5.70957437e-02f, -2.52897833e-02f, 8.14587548e-02f, -8.77073500e-03f, -4.00494672e-02f, -8.79646763e-02f, -2.69824248e-02f, 4.26324159e-02f, -8.39709640e-02f, 4.15596217e-02f,
  -1.15733609e-01f, 1.52608112e-01f, 2.59846002e-02f, 2.92841326e-02f, 2.03143898e-02f, -2.95231547e-02f, 4.73421812e-02f, 2.07078569e-02f, 1.07690126e-01f, -1.42966742e-02f,
  -4.18917611e-02f, 5.33627123e-02f, 2.71817092e-02f, 2.94440389e-02f, -1.58522695e-01f, -8.44447315e-02f, 2.06740685e-02f, 1.14388272e-01f, 6.33817613e-02f, -4.35429253e-02f,
  -6.29343539e-02f, -4.34912704e-02f, 1.39333950e-02f, -6.48552179e-02f, 5.76814599e-02f, -7.73805007e-03f, -2.71765087e-02f, -6.33174032e-02f, -7.51063973e-02f, -7.63272420e-02f,
  4.98355925e-02f, 1.42525777e-01f, 6.03865795e-02f, 3.81595567e-02f, -4.72153127e-02f, -8.02334491e-03f, -6.01300970e-02f, -7.42729753e-02f, -4.46912833e-03f, 4.85258736e-02f,
  -6.33466616e-02f, 3.69116217e-02f, -9.45874769e-03f, 3.44666466e-02f, -1.07766287e-02f, 4.86677177e-02f, -3.00716292e-02f, -7.05265477e-02f, 8.52577388e-02f, 6.41713664e-02f,
  -3.33822146e-02f, 8.94067585e-02f, 1.74195378e-03f, 8.77055340e-03f, -1.50288688e-02f, -7.29882740e-05f, 8.29729214e-02f, -3.41113796e-03f, 8.47174898e-02f, 3.26745352e-03f,
  -1.17928289e-01f, 3.82516086e-02f, 2.03273352e-03f, 3.67384702e-02f, 2.05869161e-04f, 9.47426930e-02f, -6.70469403e-02f, -5.94402514e-02f, -3.60758081e-02f, -2.45619025e-02f,
  -2.04272140e-02f, -4.00922783e-02f, 7.25458488e-02f, 3.49270292e-02f, -9.83473565e-03f, -6.04344718e-02f, -7.06377700e-02f, 4.95540574e-02f, 6.20001704e-02f, -1.96828581e-02f,
  3.71814296e-02f, 5.81648238e-02f, -5.35782687e-02f, -6.50832802e-02f, -1.77054182e-02f, 5.96045516e-02f, -4.72393259e-02f, -9.42818820e-02f, -9.36570093e-02f, -6.81848731e-04f,
  1.07554860e-01f, 8.28874186e-02f, 9.23914611e-02f, 3.78036425e-02f, 3.93034294e-02f, -9.26919952e-02f, -6.46207184e-02f, 5.81130162e-02f, -1.20998016e-02f, 1.30375307e-02f,
  6.07959777e-02f, 4.36874889e-02f, -6.18825629e-02f, -5.75077459e-02f, -6.21517468e-03f, -4.84692194e-02f, 5.77316135e-02f, -2.44061630e-02f, 9.09966305e-02f, -7.51728565e-02f,
  6.15713149e-02f, 2.27338355e-02f, -1.43161137e-02f, -2.52471138e-02f, 6.78341165e-02f, 8.00430253e-02f, 2.30261777e-02f, 5.28126536e-03f, -1.90048441e-02f, -4.79495227e-02f,
  -4.78726067e-03f, 5.92819117e-02f, -3.97322848e-02f, -2.75445934e-02f, 6.08568713e-02f, -1.29230678e-01f, -1.99000575e-02f, -6.92960992e-02f, 8.77741724e-02f, 1.39704421e-01f,
  7.48600252e-03f, -2.83262748e-02f, 7.78665692e-02f, -6.99523836e-02f, -8.71742889e-02f, 3.06887310e-02f, 5.29856645e-02f, -7.88358897e-02f, 4.32241820e-02f, -1.12168446e-01f,
  8.07633996e-02f, -1.02924883e-01f, -1.62240714e-01f, -3.73846479e-02f, 3.17774073e-04f, -5.77020720e-02f, 6.46087527e-02f, 5.30987754e-02f, 1.42819611e-02f, -3.90158929e-02f,
  2.87534967e-02f, 3.03850882e-02f, -9.63698030e-02f, 2.80924253e-02f, -2.54989751e-02f, -9.06683281e-02f, 3.44635658e-02f, -1.24381915e-01f, 1.50496932e-02f, -4.20590676e-02f,
  9.38246101e-02f, -7.00528690e-05f, 6.42954279e-03f, -4.91611063e-02f, -4.49581072e-02f, -2.10970570e-03f, -1.06517322e-01f, 2.34405361e-02f, -3.84303331e-02f, -7.31091872e-02f,
  1.21395895e-02f, -8.28837901e-02f, -8.37868825e-03f, -6.22969791e-02f, 1.45481974e-02f, -3.75725180e-02f, 7.32045546e-02f, -7.89592937e-02f, 7.87172988e-02f, -1.13784447e-02f,
  7.91374519e-02f, -6.09430932e-02f, 8.90241656e-03f, -1.49886049e-02f, -2.83368751e-02f, -6.83838204e-02f, 6.10744655e-02f, -5.85484505e-02f, 9.71740019e-03f, 8.16313550e-02f,
  8.67398232e-02f, 4.84335748e-03f, -7.20020309e-02f, 4.46567088e-02f, 3.55885141e-02f, 4.99861389e-02f, 2.82706469e-02f, -4.70712632e-02f, 5.34783378e-02f, -6.14876039e-02f,
  -6.40840158e-02f, -8.60370100e-02f, -4.49041091e-02f, 3.10655069e-02f, 3.26137058e-02f, 6.64347038e-02f, -9.44885761e-02f, 7.18517974e-02f, -2.68345885e-02f, -3.51407938e-02f,
  1.12438947e-02f, 7.32344761e-02f, 8.11992064e-02f, -4.62059751e-02f, -9.46592614e-02f, 6.24073483e-02f, 6.76736161e-02f, -1.04047351e-01f, -3.60174142e-02f, 9.24955308e-02f,
  -2.00956110e-02f, -7.91866630e-02f, 7.66890272e-02f, 4.19010743e-02f, -1.53369000e-02f, 9.17712152e-02f, 5.71167981e-03f, 6.53600991e-02f, 6.54790774e-02f, 2.31256746e-02f,
  6.66919500e-02f, 6.82415739e-02f, -6.35201186e-02f, 1.09284326e-01f, 8.26948509e-02f, 5.21259755e-02f, 8.92249271e-02f, -1.65286493e-02f, -8.41832682e-02f, 7.75466785e-02f,
  -4.77332361e-02f, 5.81265427e-02f, 8.78350362e-02f, 1.06097303e-01f, 2.09706277e-03f, 6.70931563e-02f, -6.28192201e-02f, 6.28370419e-02f, 1.50289282e-01f, 3.28490091e-03f,
  3.32926959e-02f, -2.07509995e-02f, -6.26183674e-03f, 7.65371621e-02f, -4.60315347e-02f, 1.04887165e-01f, 3.94190010e-03f, 8.66256952e-02f, 3.60971014e-03f, 1.13921858e-01f,
  4.29036990e-02f, 7.66808614e-02f, -6.70580044e-02f, -7.70371705e-02f, 3.24339315e-04f, 3.32768895e-02f, -1.55975912e-02f, -4.32323739e-02f, 7.47598782e-02f, 6.35087816e-03f,
  1.25479847e-02f, -7.80086741e-02f, -4.89240848e-02f, -1.48348128e-02f, 6.27712384e-02f, -1.06765844e-01f, -3.05588711e-02f, -6.59752870e-03f, -9.57431197e-02f, 6.81881905e-02f,
  3.76047455e-02f, -3.74173708e-02f, 1.99889042e-03f, -8.37090537e-02f, 9.70582962e-02f, -4.62337993e-02f, 4.53946441e-02f, -8.53404701e-02f, 1.06655046e-01f, 1.07045911e-01f,
  7.03269914e-02f, 4.78464179e-02f, -7.24754930e-02f, 4.85818163e-02f, 6.53407574e-02f, 8.17793980e-02f, 1.24548329e-02f, 7.25870207e-02f, 4.56579290e-02f, 2.40211356e-02f,
  3.60812657e-02f, -6.59656525e-02f, -4.90385592e-02f, -6.56294003e-02f, -8.46681148e-02f, -1.94695089e-02f, 7.14668259e-03f, 4.01402973e-02f, -6.86301664e-02f, 7.70378634e-02f,
  -1.03279483e-02f, -5.90411238e-02f, -3.54820886e-03f, 8.02558810e-02f, 6.86375350e-02f, 1.89570095e-02f, 2.92951819e-02f, -5.03632836e-02f, 4.53582145e-02f, 5.90590797e-02f,
  1.92654543e-02f, 4.51873764e-02f, -9.20882747e-02f, 2.40074769e-02f, 7.52718672e-02f, -8.06185231e-02f, -1.68408453e-02f, 7.72756804e-03f, 4.65249941e-02f, -4.09654118e-02f,
  6.41717613e-02f, -4.92733382e-02f, -8.21105689e-02f, 7.86580667e-02f, -6.48799166e-02f, 5.38959093e-02f, -1.12533262e-02f, 7.87850991e-02f, 2.49800589e-02f, 1.63302273e-02f,
  -1.50710754e-02f, -7.88012818e-02f, -2.52113547e-02f, 1.83704570e-02f, -4.39088382e-02f, 1.55113665e-02f, -4.40439070e-03f, 7.98987895e-02f, 3.43718217e-03f, 5.40594161e-02f,
  -6.32425472e-02f, 5.20127118e-02f, -3.04387026e-02f, 6.46280497e-02f, 3.27528752e-02f, 2.12246850e-02f, 9.05038510e-03f, -5.92268491e-03f, -5.49955443e-02f, 2.53403597e-02f,
  -1.04202174e-01f, 1.52809024e-01f, -6.08362108e-02f, -7.74854347e-02f, 2.89824922e-02f, -1.61791176e-01f, -1.49561808e-01f, -4.37932685e-02f, 3.90816405e-02f, -2.44376808e-02f,
  2.49370933e-02f, -1.40873715e-01f, 1.26790836e-01f, -1.73989356e-01f, -2.72453725e-01f, -5.47578186e-02f, -1.74307570e-01f, -7.28864074e-02f, 6.92601874e-02f, -3.86020318e-02f,
  -3.62023227e-02f, 1.86956730e-02f, -1.75802350e-01f, 1.71316296e-01f, -4.99443859e-02f, 8.53197053e-02f, -7.98911378e-02f, 1.37209803e-01f, -7.91478828e-02f, -8.40344876e-02f,
  -1.06798038e-01f, -1.22474529e-01f, -7.75456848e-03f, -1.29013270e-01f, -1.28381968e-01f, 1.57807786e-02f, -1.09248251e-01f, 1.18930114e-03f, -1.97293255e-02f, -2.93634571e-02f,
  2.67360285e-02f, -8.04972183e-03f, -5.61332852e-02f, -3.22625153e-02f, -1.08546559e-02f, 3.02559733e-02f, -1.39217144e-02f, 9.83559787e-02f, -1.38578536e-02f, 7.64784366e-02f,
  -8.50071087e-02f, -6.14105389e-02f, -9.66438651e-02f, 4.28469712e-03f, -4.48794756e-03f, -4.17899452e-02f, -1.64196938e-02f, -7.42982328e-02f, 3.52532184e-03f, 3.40447295e-03f,
  3.00252289e-02f, 1.52041502e-02f, 2.40643825e-02f, -8.48238170e-02f, 6.94197267e-02f, 4.31771949e-03f, -5.46330102e-02f, -2.29309648e-02f, -2.89692134e-02f, -4.72471677e-03f,
  6.24332651e-02f, -8.70813429e-02f, 8.13392997e-02f, -6.16266876e-02f, 5.40711060e-02f, -4.63782139e-02f, -4.11132500e-02f, -5.67231216e-02f, -7.97361732e-02f, 7.64446631e-02f,
  5.87442294e-02f, 1.86715536e-02f, 7.56190345e-02f, 5.13892360e-02f, 2.82024946e-02f, 3.29513624e-02f, -6.49907589e-02f, -3.69016826e-02f, -2.47846115e-02f, 7.33149946e-02f,
  -6.20067902e-02f, -1.26611307e-01f, 4.69756536e-02f, -9.75180194e-02f, 1.15729608e-02f, 4.55662534e-02f, 1.54295536e-02f, 5.24733365e-02f, -6.94982409e-02f, -7.54523650e-02f,
  -3.58978286e-02f, 6.56172354e-03f, 5.36942780e-02f, 5.97778149e-02f, 2.68400684e-02f, -4.61689755e-02f, 2.03415621e-02f, -3.25234979e-02f, -7.33962804e-02f, -5.22860624e-02f,
  3.98906730e-02f, 1.02611043e-01f, 2.14501340e-02f, 8.76695737e-02f, -5.75162694e-02f, -9.72837135e-02f, 2.62628291e-02f, 6.63713589e-02f, -6.63223639e-02f, -4.89561744e-02f,
  -8.96156207e-02f, -9.03125331e-02f, -3.33074629e-02f, 4.25716378e-02f, -8.91176518e-03f, -2.40295529e-02f, -2.03794856e-02f, -6.65306970e-02f, -9.54463333e-02f, -1.68742612e-03f,
  4.77993302e-02f, -5.77256642e-02f, 1.06079224e-02f, -6.66121542e-02f, 4.50818986e-02f, 2.28559854e-03f, -1.20113790e-01f, -2.16008779e-02f, 4.02182229e-02f, -7.54708797e-02f,
  2.01839563e-02f, 6.73336089e-02f, 3.02083641e-02f, -7.76321143e-02f, 1.32879829e-02f, -3.96047868e-02f, 9.56127271e-02f, -2.70187091e-02f, 6.38919473e-02f, 5.49891442e-02f,
  9.20131207e-02f, -9.92673934e-02f, 3.93129158e-04f, 1.33483158e-02f, 3.69995534e-02f, -9.85261519e-03f, 2.89137438e-02f, 8.78144652e-02f, 5.94013892e-02f, 3.55782062e-02f,
  8.28932449e-02f, -5.82213029e-02f, -3.20702568e-02f, -8.21158383e-03f, 4.34199013e-02f, -2.84506232e-02f, -7.32554421e-02f, 1.66371744e-02f, 3.66377532e-02f, -4.13554301e-03f,
  1.37712453e-02f, 4.43229377e-02f, 7.17605185e-03f, 1.64966825e-02f, -8.21832716e-02f, -6.49958923e-02f, 4.05150615e-02f, -2.48782169e-02f, -9.34061334e-02f, -6.08750246e-02f,
  -9.59429443e-02f, 5.65263815e-02f, 2.71596182e-02f, 1.84115544e-02f, -8.80743563e-02f, 1.25500755e-02f, -4.60066646e-02f, -3.23211029e-02f, 4.28715870e-02f, 2.31429525e-02f,
  -5.32036833e-03f, -8.18216056e-02f, 1.00681342e-01f, 7.34329894e-02f, -4.64746207e-02f, 1.12663629e-03f, -4.62695062e-02f, -2.96903588e-02f, -5.52105950e-03f, -7.35109299e-02f,
  7.89086074e-02f, 5.23726568e-02f, -5.73470742e-02f, -3.30662797e-03f, 6.87256828e-03f, -1.06931385e-02f, 6.99966326e-02f, 7.04766288e-02f, 6.52113035e-02f, 3.00876684e-02f,
  -2.48467922e-02f, -1.56512946e-01f, 5.92894433e-03f, 3.47214937e-02f, 3.24869975e-02f, 4.15850542e-02f, -4.98336693e-03f, -2.83721033e-02f, 8.66724644e-03f, -2.46513598e-02f,
  9.65310447e-03f, -4.56912406e-02f, -7.80929476e-02f, 2.02054083e-02f, 8.24349448e-02f, -1.00228548e-01f, -2.44951720e-04f, 8.89240429e-02f, 3.09483260e-02f, -6.30550086e-02f,
  3.08661982e-02f, -1.48772262e-02f, -6.62746206e-02f, -3.22688669e-02f, -3.99226695e-02f, 3.92256491e-02f, -2.31061783e-02f, 8.11908916e-02f, -6.34557009e-02f, -1.50910337e-02f,
  -7.60002434e-02f, 1.71690598e-01f, 2.05573607e-02f, 1.24953903e-01f, 1.02892779e-02f, 2.34951571e-01f, 1.84666976e-01f, 1.34200707e-01f, 4.24191833e-01f, 1.68828100e-01f,
  -5.64039610e-02f, 1.03879876e-01f, 9.65436324e-02f, 1.10077299e-01f, 9.43052843e-02f, 1.77182496e-01f, 2.27112055e-01f, 5.14411815e-02f, 1.86447203e-01f, 3.49155776e-02f,
  -1.96019895e-02f, -9.59161576e-03f, -1.61334768e-01f, -1.23101436e-02f, -5.12527637e-02f, -5.52095361e-02f, -2.09351793e-01f, -4.95347045e-02f, -3.60139944e-02f, 7.46623874e-02f,
  1.13321859e-02f, 1.65238410e-01f, -1.43440768e-01f, 8.06239098e-02f, -2.36701686e-02f, -1.15235060e-01f, -4.63013574e-02f, -7.29101375e-02f, -1.05211185e-02f, 6.97973045e-03f,
  -1.41232079e-02f, 5.29563874e-02f, 5.86550310e-02f, -5.68413250e-02f, 1.30471215e-02f, -1.10602621e-02f, -4.20906805e-02f, 2.76585612e-02f, -3.19115026e-03f, -6.47197366e-02f,
  7.54778907e-02f, -4.38582674e-02f, -4.80754822e-02f, -5.01295887e-02f, 6.76367357e-02f, 7.62454793e-02f, 7.01915473e-02f, 1.21185295e-02f, 5.82270771e-02f, 1.37251809e-01f,
  -3.49756777e-02f, -1.30316177e-02f, -6.29075170e-02f, -6.76924810e-02f, -2.79296059e-02f, -7.24104121e-02f, -7.05842003e-02f, -1.19068429e-01f, 1.45114481e-03f, -8.54492411e-02f,
  -8.65023024e-03f, -6.21947683e-02f, 1.58925224e-02f, 4.61304188e-02f, -3.82637568e-02f, 3.26430611e-02f, 1.38690919e-02f, -4.90834638e-02f, 5.15503474e-02f, -8.90813470e-02f,
  9.74640921e-02f, 2.94024614e-03f, 5.30675575e-02f, 1.35234948e-02f, -4.80068959e-02f, -1.06334209e-01f, -1.14660092e-01f, -6.17291732e-03f, 3.59367803e-02f, -1.24242529e-01f,
  1.24627896e-01f, 2.28901699e-01f, 4.98967953e-02f, 8.30666944e-02f, -1.92785189e-02f, 2.18023751e-02f, 3.21836472e-02f, 8.36039111e-02f, 8.79392624e-02f, 1.20294482e-01f,
  -2.71292198e-02f, 4.61668074e-02f, -1.91327445e-02f, -9.99123696e-03f, -1.19949207e-02f, 2.01759879e-02f, -1.29969576e-02f, 8.35936293e-02f, 5.19156754e-02f, -5.91188995e-03f,
  3.21799926e-02f, 9.20548066e-02f, 7.04463571e-02f, 4.18914445e-02f, -8.39698464e-02f, 8.60254688e-04f, 9.47217047e-02f, 5.16356155e-02f, 2.28109248e-02f, 2.39909384e-02f,
  1.43358648e-01f, 2.95555666e-02f, 3.90176140e-02f, 3.68603393e-02f, -6.37371466e-02f, -1.40211597e-01f, -2.69827675e-02f, -6.33657649e-02f, 4.31504613e-03f, -6.28276542e-02f,
  -1.18568026e-01f, 1.96190640e-01f, -1.27638191e-01f, 6.79403245e-02f, 7.87625611e-02f, -1.21114902e-01f, -5.58239780e-03f, 2.39694980e-03f, -2.90931109e-02f, 7.09979907e-02f,
  8.56433064e-02f, -6.42340183e-02f, 4.04759273e-02f, -1.14985161e-01f, 9.31944102e-02f, 1.45622678e-02f, 2.94069331e-02f, -5.09225279e-02f, 3.32890893e-03f, -4.65904251e-02f,
  -5.35411574e-02f, 1.93448830e-02f, 1.06594913e-01f, -2.68505178e-02f, -6.54811114e-02f, 6.73762783e-02f, -5.51538430e-02f, -6.29732385e-02f, -1.07442260e-01f, 7.47455508e-02f,
  2.10779477e-02f, -6.22611418e-02f, 1.21251099e-01f, 7.46866514e-04f, -3.04179676e-02f, -2.12470330e-02f, 9.44268405e-02f, -3.99341322e-02f, 2.07539331e-02f, 3.37162055e-02f,
  -1.81890782e-02f, 3.19551788e-02f, 3.98502797e-02f, 2.04243697e-02f, 6.69462904e-02f, -2.36173198e-02f, -4.74496782e-02f, 1.03007101e-01f, 2.80188341e-02f, 3.56734693e-02f,
  -2.88947392e-02f, -8.93170573e-03f, -2.91026779e-03f, -7.62580112e-02f, 1.83107443e-02f, 7.16655254e-02f, 7.89222270e-02f, 4.70313877e-02f, -5.95311867e-03f, -2.71294024e-02f,
  2.86932085e-02f, 8.89954343e-02f, 4.14044000e-02f, -8.03778246e-02f, 1.01791643e-01f, 2.73760408e-03f, -7.89274275e-02f, -1.90622378e-02f, 7.35987052e-02f, 1.47033269e-02f,
  -2.94681415e-02f, 6.32012933e-02f, 1.19192256e-02f, -6.06256239e-02f, -8.91176686e-02f, -5.92567846e-02f, 3.93523350e-02f, -2.24104319e-02f, -7.25186095e-02f, -7.95117542e-02f,
  -1.31196827e-01f, -5.10983020e-02f, -9.05513484e-03f, -4.54589352e-02f, 4.71233167e-02f, 8.20852518e-02f, 4.35019471e-02f, -8.08312465e-03f, -7.79252918e-03f, 7.56144151e-02f,
  -3.36780888e-03f, 4.45703752e-02f, 9.11509246e-02f, -6.79032728e-02f, -4.43313979e-02f, -3.55297774e-02f, 7.95023574e-04f, -2.32799836e-02f, 1.00504279e-01f, -7.77320564e-02f,
  6.90949932e-02f, 3.09853759e-02f, 1.04437932e-01f, 5.10388799e-02f, 3.00367549e-02f, 1.17671266e-02f, -7.48265609e-02f, 5.95047362e-02f, -5.41142095e-03f, -1.96632836e-02f,
  -6.77322224e-03f, -6.33450896e-02f, 1.27746686e-01f, 1.22207910e-01f, 1.45887151e-01f, 3.18904081e-03f, 8.03228393e-02f, 8.03246796e-02f, 2.11913809e-01f, -1.18087577e-02f,
  -6.60940930e-02f, 3.73978890e-03f, 4.46788706e-02f, -1.28242329e-01f, -1.49945483e-01f, -1.26287863e-01f, 4.97468002e-02f, -3.46152633e-02f, 1.54416993e-01f, 6.93301484e-02f,
  7.61546046e-02f, -1.13228977e-01f, -1.42525032e-01f, 5.35296164e-02f, -6.15954883e-02f, -3.87906469e-02f, -1.36873946e-01f, 2.69944146e-02f, 2.53382437e-02f, -4.14225981e-02f,
  2.62201298e-02f, -4.96114939e-02f, -5.61834760e-02f, 3.45067307e-02f, 6.47413507e-02f, -7.25839287e-02f, 5.18776774e-02f, 3.08671650e-02f, 8.59803557e-02f, 6.58160597e-02f,
  1.00116991e-01f, -7.11750388e-02f, -4.96070348e-02f, 4.05141190e-02f, 3.61491293e-02f, 5.56424409e-02f, 6.60099387e-02f, -4.43199314e-02f, 4.70924377e-03f, 9.86951962e-02f,
  7.02723339e-02f, -2.63526030e-02f, -2.14362387e-02f, 3.86401303e-02f, 3.41853462e-02f, -6.82076514e-02f, 9.96112749e-02f, -5.67492917e-02f, -1.30898925e-02f, 1.06443474e-02f,
  1.15277637e-02f, -2.61952262e-02f, 2.64178310e-02f, 9.84817743e-03f, -4.32448015e-02f, 7.79855205e-03f, 2.30072960e-02f, 3.66077498e-02f, 9.82838422e-02f, 4.07025851e-02f,
  -7.07254633e-02f, -2.81875003e-02f, 6.23264797e-02f, -1.17254090e-02f, 3.64408083e-02f, -6.58963853e-03f, -1.00462639e-03f, 7.13979006e-02f, 3.16301063e-02f, -8.95206109e-02f,
  -6.03481904e-02f, -1.41113652e-02f, -4.40017730e-02f, 1.95872262e-02f, 2.47772746e-02f, -4.44825441e-02f, 1.04830395e-02f, 8.17111060e-02f, -4.75765429e-02f, -1.40908621e-02f,
  5.23196720e-03f, 3.27258520e-02f, 5.55809736e-02f, -4.96165529e-02f, 4.66577010e-03f, -4.51521724e-02f, 9.89369825e-02f, -7.70740211e-02f, 3.57583491e-03f, 5.21642156e-02f,
  5.40311774e-03f, 4.96464185e-02f, 1.58903450e-02f, -4.19448353e-02f, -1.95219426e-03f, 6.16483465e-02f, 3.66422348e-02f, -7.54760951e-02f, -5.70091531e-02f, 6.48546591e-02f,
  -2.90604252e-02f, 9.51373056e-02f, -3.72760370e-02f, 2.34979708e-02f, -3.60436440e-02f, -6.81969523e-02f, 5.13897724e-02f, 8.34073499e-03f, -2.95778010e-02f, 2.93690041e-02f,
  3.96756195e-02f, -3.48173678e-02f, 1.09395543e-02f, -1.13649964e-01f, -1.26649591e-03f, 5.71969673e-02f, 9.34767202e-02f, -5.36826514e-02f, -6.55879900e-02f, 8.02244246e-03f,
  7.04143420e-02f, 9.86315086e-02f, 8.62220228e-02f, -5.55260554e-02f, 1.01634942e-01f, 1.13607012e-01f, 3.99710312e-02f, 4.96693142e-02f, 2.36441090e-04f, -4.47030063e-04f,
  -3.21743563e-02f, 2.37040985e-02f, 7.95504600e-02f, -4.78126816e-02f, 5.51747419e-02f, -3.46049666e-02f, -8.11402593e-03f, 8.30538198e-03f, 5.08161597e-02f, 1.09162271e-01f,
  -5.14670461e-02f, -1.04115605e-01f, -2.69799517e-03f, -6.30698279e-02f, 4.45599332e-02f, 3.51915509e-02f, 6.15586154e-02f, 1.67903583e-03f, 5.15609095e-03f, -5.20599494e-03f,
  -5.29780751e-03f, -4.36117798e-02f, -5.27688600e-02f, -2.36970466e-03f, 2.95314081e-02f, 5.56632224e-03f, 7.07513234e-03f, 2.79083420e-02f, 3.87868695e-02f, 9.26439837e-03f,
  -2.77009420e-02f, 6.04030453e-02f, 1.73422173e-02f, 7.07238466e-02f, 5.77751249e-02f, 4.18451019e-02f, -7.70833194e-02f, 3.55484933e-02f, 9.05849189e-02f, -2.06130650e-02f,
  3.07791401e-02f, 5.16899454e-04f, -7.70098865e-02f, 7.58953169e-02f, -5.70843928e-02f, 1.16873188e-02f, -6.86810464e-02f, -3.26633416e-02f, -3.30440030e-02f, 9.64568034e-02f,
  7.77696967e-02f, -5.38976490e-02f, 8.53523314e-02f, -5.57641909e-02f, 3.53231728e-02f, 5.64203858e-02f, -2.62467135e-02f, -8.02442804e-02f, 5.85486740e-03f, 7.72378966e-02f,
  -1.05404533e-01f, -3.93981710e-02f, -5.47169745e-02f, 3.25308666e-02f, 1.02156676e-01f, -2.48354510e-03f, -8.47716182e-02f, 7.71873444e-02f, -7.33353719e-02f, -1.55130606e-02f,
  -2.40233149e-02f, -1.17648691e-02f, 6.94299191e-02f, -5.57257049e-03f, 1.58039741e-02f, -6.16382360e-02f, -3.74914333e-02f, -4.31252420e-02f, -4.94538322e-02f, -8.74528214e-02f,
  9.21326950e-02f, 3.87390666e-02f, -6.14131894e-03f, 4.55476111e-03f, 9.07862410e-02f, -2.13476066e-02f, -9.09550488e-02f, 9.43702906e-02f, 6.57443404e-02f, 1.33697875e-02f,
  9.99451876e-02f, -4.96976897e-02f, 2.69751940e-02f, -7.68149868e-02f, -4.28770781e-02f, 5.06549552e-02f, -4.66576815e-02f, -8.63702297e-02f, 8.14299360e-02f, -7.85328224e-02f,
  2.28236541e-02f, 2.35751010e-02f, -5.47259860e-02f, 4.26414497e-02f, -9.10415426e-02f, -8.94886032e-02f, -6.50835261e-02f, -7.82966763e-02f, 1.91137895e-01f, 3.04672699e-02f,
  -3.29642333e-02f, -4.72332314e-02f, -2.86329798e-02f, -1.72039941e-01f, 5.71114980e-02f, 1.81955379e-03f, -2.15152232e-03f, -1.07819319e-01f, 2.21160594e-02f, -1.55913338e-01f,
  9.77087244e-02f, 9.18787345e-03f, 6.22000266e-03f, -1.21461779e-01f, -1.07655764e-01f, -8.70960951e-02f, -1.49020121e-01f, -5.50320335e-02f, -2.01603070e-01f, -5.13687283e-02f,
  6.22825027e-02f, -1.59935970e-02f, -5.68925112e-04f, 8.93787853e-03f, 8.26965943e-02f, -5.00550792e-02f, -8.33130851e-02f, -8.94680247e-02f, -4.51889448e-02f, 1.05909079e-01f,
  9.34413914e-03f, -6.00369722e-02f, 9.18163434e-02f, 7.05311121e-03f, 6.91668019e-02f, 7.38949105e-02f, -1.79552881e-03f, -2.52674501e-02f, 1.59903634e-02f, -4.28576022e-02f,
  8.39450508e-02f, 6.42826185e-02f, -5.47547005e-02f, -9.82170179e-02f, -1.00170895e-01f, -1.12509087e-01f, 4.15591933e-02f, -6.72223270e-02f, 7.06992447e-02f, -8.04535858e-03f,
  5.60435117e-04f, -8.62894058e-02f, 7.41715506e-02f, 1.03056364e-01f, -2.98356768e-02f, 1.04622975e-01f, 1.99896879e-02f, -2.52755918e-02f, 5.04764207e-02f, -8.80977139e-03f,
  -3.34965502e-04f, -9.79407728e-02f, -9.03407931e-02f, -5.20260930e-02f, 5.49501693e-03f, 6.59239963e-02f, 1.95068996e-02f, 3.55511867e-02f, -3.77685926e-03f, -1.32019594e-02f,
  4.77723666e-02f, 3.69778164e-02f, -3.50889564e-02f, 1.39328297e-02f, 6.96019679e-02f, 4.76807654e-02f, -1.02801777e-01f, -1.98998339e-02f, 6.96222559e-02f, -5.12999520e-02f,
  -6.69387728e-02f, -1.54439546e-02f, 7.19036683e-02f, 5.30251153e-02f, 5.76364137e-02f, 1.65168149e-03f, -1.58411805e-02f, 3.74136977e-02f, 1.74169634e-02f, 3.59207876e-02f,
  5.21012992e-02f, -9.38718393e-02f, 4.05161045e-02f, -1.09397732e-01f, -7.82404914e-02f, -5.80819547e-02f, -3.01227369e-03f, 1.75836235e-02f, -1.18241824e-01f, -1.20312057e-01f,
  6.50529191e-02f, -3.90667804e-02f, 5.80330268e-02f, 6.16373420e-02f, -4.51915115e-02f, -8.80443603e-02f, -6.09276630e-02f, -5.25234714e-02f, -8.79869312e-02f, 4.54354063e-02f,
  1.10020153e-01f, -1.96104825e-01f, -6.97731823e-02f, -6.57090172e-02f, -6.81340992e-02f, -2.89888889e-01f, -2.91981488e-01f, 5.13322279e-03f, -2.88122203e-02f, -1.37054443e-01f,
  -9.16755721e-02f, -1.39760161e-02f, -7.81224146e-02f, -8.29034224e-02f, 5.85444272e-02f, 8.95455703e-02f, -4.54684980e-02f, -8.13654065e-02f, 6.37860820e-02f, -1.41866043e-01f,
  2.31602695e-02f, -1.42754130e-02f, -6.23127371e-02f, 3.61959226e-02f, -1.32626370e-01f, 1.13964215e-01f, 1.17286302e-01f, 3.91752366e-03f, -4.74891765e-03f, 7.90853053e-02f,
  -1.02729388e-01f, 1.99437123e-02f, -1.00479051e-02f, 6.74859583e-02f, -1.87684894e-02f, -1.29014975e-03f, -7.94778764e-02f, 5.37362024e-02f, -4.76164371e-02f, 2.46904436e-02f,
  5.48991561e-02f, 5.27116843e-02f, 2.20286064e-02f, -2.16165110e-02f, -5.84928580e-02f, 1.72802415e-02f, -1.90064609e-02f, 4.60383147e-02f, -5.44112697e-02f, 2.35551763e-02f,
  -3.03111449e-02f, -7.87146091e-02f, -3.66658457e-02f, 9.55248475e-02f, 7.73749650e-02f, -3.49186100e-02f, -9.56307631e-03f, 2.51295697e-02f, 5.21357208e-02f, -1.46438153e-02f,
  4.07707058e-02f, -8.09418410e-02f, -3.88296234e-04f, 4.51557860e-02f, -4.96055782e-02f, 4.05050721e-03f, -6.37491792e-02f, 7.57205412e-02f, 2.95902602e-02f, -1.04028694e-01f,
  6.14915378e-02f, 1.24167623e-02f, 6.07408546e-02f, -2.95058824e-02f, 6.95482269e-02f, -6.58506304e-02f, -9.09927562e-02f, 6.23497590e-02f, 2.85215732e-02f, 2.98007093e-02f,
  7.57139996e-02f, -6.77012354e-02f, -7.83500969e-02f, -6.95284978e-02f, -9.19879824e-02f, 2.31753313e-03f, 7.40213916e-02f, -4.28046137e-02f, 5.50516993e-02f, 1.11895250e-02f,
  -9.61350463e-03f, -2.47483701e-02f, -7.94806927e-02f, -7.76137738e-03f, 4.66167927e-02f, -3.85077745e-02f, -3.57315987e-02f, 8.77145454e-02f, -2.37933695e-02f, -3.10795624e-02f,
  3.55373025e-02f, -1.39186205e-02f, 7.24153295e-02f, 1.18689977e-01f, -3.94690447e-02f, -3.94809917e-02f, -2.27161832e-02f, 1.29114278e-02f, -5.56317829e-02f, -1.28163239e-02f,
  2.81573478e-02f, -5.92692792e-02f, 9.07857418e-02f, 1.81357358e-02f, 5.88828214e-02f, -1.63985528e-02f, 1.53650735e-02f, 6.34534657e-02f, -2.68544201e-02f, 1.10369828e-03f,
  -2.09047250e-03f, 1.03989258e-01f, 1.35902762e-01f, -5.58620989e-02f, 5.91691099e-02f, -1.34639427e-01f, -1.70470521e-01f, 2.38012951e-02f, 3.04743238e-02f, 1.42311826e-01f,
  -1.75721738e-02f, 5.20909438e-03f, 6.06683455e-02f, -1.92832649e-01f, -2.40763530e-01f, -1.98098093e-01f, -1.88795194e-01f, -6.65573105e-02f, 5.09933680e-02f, 6.95157843e-03f,
  -1.14821196e-01f, -7.19531476e-02f, -5.53845614e-02f, -3.69146019e-02f, 3.30470130e-02f, 1.40503883e-01f, 4.86208647e-02f, -3.88712920e-02f, -5.78885302e-02f, -3.35710309e-02f,
  -1.51454483e-03f, 8.72835144e-02f, 1.34350017e-01f, -2.19421219e-02f, 3.88607532e-02f, 9.33489501e-02f, 8.64604264e-02f, -7.46598840e-03f, 4.96004820e-02f, -7.88440779e-02f,
  9.25260261e-02f, -1.16145670e-01f, 3.89573276e-02f, -9.90543887e-02f, -4.67072800e-02f, -1.38652483e-02f, 7.73471296e-02f, 1.04955651e-01f, -5.42700961e-02f, 5.83721586e-02f,
  5.35077378e-02f, 1.05748437e-01f, -3.14092934e-02f, -2.69188620e-02f, 1.93830729e-02f, -3.21603157e-02f, -2.76929177e-02f, -1.50854485e-02f, 6.62829429e-02f, -4.48813215e-02f,
  7.83218220e-02f, 7.43281543e-02f, -2.45236307e-02f, -2.90561467e-02f, -3.41956839e-02f, 8.47522318e-02f, -4.86949086e-02f, 3.26480204e-03f, 1.81333590e-02f, -5.59429312e-03f,
  -1.47886639e-02f, 4.25223894e-02f, -3.41036078e-03f, -1.48366485e-02f, 7.84361884e-02f, -4.75300103e-02f, 7.22330660e-02f, 1.25102937e-01f, -1.93896741e-02f, 2.75604259e-02f,
  4.97986004e-02f, -2.43914016e-02f, -2.60162018e-02f, 3.06753702e-02f, -8.22067112e-02f, -7.58379474e-02f, 6.76739365e-02f, 1.63659900e-02f, -6.66298047e-02f, -1.26947984e-02f,
  2.06810096e-03f, 1.50376335e-01f, 4.72497717e-02f, -9.07398239e-02f, 7.90123716e-02f, -5.98619506e-02f, -1.02090441e-01f, 6.97236434e-02f, 8.45736712e-02f, -6.44794628e-02f,
  -1.56580191e-02f, 1.70205883e-03f, 4.40505296e-02f, -9.06179175e-02f, -6.36841729e-02f, 2.61073224e-02f, -2.83026602e-02f, 9.13218409e-02f, -1.91989690e-02f, -6.38289750e-02f,
  1.15513735e-01f, 2.79301498e-02f, 9.25911497e-03f, 4.91272621e-02f, -2.21775044e-05f, 1.29133940e-01f, -2.96177287e-02f, 7.84624461e-03f, -4.17487286e-02f, -4.08498431e-03f,
  -2.31681347e-01f, 4.69770245e-02f, -1.52152237e-02f, 2.02951655e-02f, -2.26000905e-01f, 1.30462497e-01f, 2.24120840e-01f, -1.25891134e-01f, 1.25247585e-02f, 2.26757973e-01f,
  1.72410458e-01f, 1.82589535e-02f, 2.42870003e-01f, 2.63586581e-01f, 6.86479509e-02f, 2.90337175e-01f, 2.65599340e-01f, 2.36366406e-01f, -1.39579982e-01f, -1.11294284e-01f,
  -5.22477962e-02f, 7.80263469e-02f, 5.13131991e-02f, -5.44760302e-02f, -5.17890528e-02f, -2.12073714e-01f, -4.86957747e-03f, -1.37667879e-01f, 7.64940009e-02f, 5.81318662e-02f,
  -7.21287206e-02f, -2.09304899e-01f, -1.01020135e-01f, -6.20153174e-03f, -2.67598033e-02f, -2.56051831e-02f, -4.17769104e-02f, -5.28873270e-03f, 2.23707538e-02f, -3.29843238e-02f,
  3.68384346e-02f, -1.62631758e-02f, 2.17272565e-02f, -3.06992680e-02f, -1.26611948e-01f, -3.37651148e-02f, -6.54415460e-03f, 2.07827892e-02f, 3.44507806e-02f, -2.89499126e-02f,
  -7.44182095e-02f, -1.58180837e-02f, 5.97449914e-02f, 7.49435648e-02f, 1.08415559e-02f, 9.88767222e-02f, 1.27521455e-02f, 1.05889607e-02f, -4.72440347e-02f, -4.71762344e-02f,
  1.97986793e-03f, 4.10528369e-02f, -4.23594341e-02f, 6.61790669e-02f, -2.53832731e-02f, 6.41789511e-02f, 4.82868142e-02f, 4.53056321e-02f, -9.99153405e-03f, 1.88069362e-02f,
  -6.33855388e-02f, 2.41299402e-02f, -1.20163159e-02f, -1.31238783e-02f, -5.47995195e-02f, -1.77377202e-02f, -3.14525068e-02f, -2.50228401e-02f, 9.64138061e-02f, -1.53345251e-02f,
  8.67359620e-03f, -2.84548178e-02f, 4.98688556e-02f, 4.40637954e-03f, 5.12488931e-02f, -5.64681320e-03f, -4.82863672e-02f, -9.07139406e-02f, 6.99458644e-02f, -2.78484635e-02f,
  -1.58192180e-02f, -1.24852940e-01f, -4.21103649e-02f, -1.14680551e-01f, -4.71623801e-02f, -2.80116927e-02f, 2.31464654e-02f, -6.16387501e-02f, 7.72019252e-02f, -8.11190829e-02f,
  -6.75639361e-02f, -5.20929284e-02f, -8.36589187e-02f, -3.06237824e-02f, 3.18961665e-02f, 6.11577705e-02f, 2.49719322e-02f, 5.17575890e-02f, -2.60532014e-02f, -1.07760139e-01f,
  1.26122842e-02f, 5.01179025e-02f, 5.65640675e-03f, -7.57496431e-02f, -1.21819861e-02f, 4.87489030e-02f, 1.99022219e-02f, 2.74035465e-02f, -6.54002503e-02f, 5.74090108e-02f,
  9.95669514e-02f, 3.52945514e-02f, 5.87699674e-02f, 6.56392798e-02f, -7.80675933e-02f, 4.24731113e-02f, 1.57003552e-02f, 6.58405246e-03f, 4.10773531e-02f, 7.66559765e-02f,
  -4.68541458e-02f, 3.89087684e-02f, 5.95003664e-02f, 1.09488547e-01f, -4.59469818e-02f, -1.90566934e-03f, 8.35409090e-02f, -1.78258382e-02f, -4.43157218e-02f, 2.93398350e-02f,
  -8.74953195e-02f, -4.87934835e-02f, -2.85228342e-02f, 1.20545961e-02f, 4.85698134e-03f, -1.80650987e-02f, -3.62077430e-02f, -2.42950357e-02f, -1.36848211e-01f, -6.19639829e-02f,
  -3.77992094e-02f, -6.99466914e-02f, 3.29639502e-02f, -4.27271016e-02f, 3.62598710e-02f, 6.58158511e-02f, -6.32434012e-03f, -2.46015601e-02f, -4.49081473e-02f, 8.89960900e-02f,
  5.90655096e-02f, -3.17475013e-02f, -5.33605032e-02f, 2.70688832e-02f, -7.94716850e-02f, -4.35375720e-02f, -7.89897442e-02f, -1.08406276e-01f, 7.57256225e-02f, -6.90093711e-02f,
  -6.30829558e-02f, -5.54247051e-02f, -5.91057092e-02f, 8.27324688e-02f, -7.88855180e-02f, -2.54435651e-02f, 2.33055018e-02f, 1.74976699e-02f, -7.84843415e-02f, 1.32450815e-02f,
  -3.52765583e-02f, 7.16419891e-02f, -5.52801117e-02f, -5.68020791e-02f, 9.83355269e-02f, -8.30478966e-02f, -1.11586852e-02f, 8.32887590e-02f, -8.38608742e-02f, -1.94570161e-02f,
  7.64823183e-02f, -4.31884117e-02f, -1.81048736e-02f, -3.49001326e-02f, 5.84165193e-02f, -4.60740067e-02f, 7.74022490e-02f, -2.01319484e-03f, 1.11783426e-02f, -7.37410337e-02f,
  7.78968856e-02f, 5.46761677e-02f, -1.61930919e-02f, -6.48286268e-02f, 5.21249771e-02f, -8.39573666e-02f, 4.38191965e-02f, -2.58363262e-02f, -8.53591561e-02f, -2.65584644e-02f,
  -2.88644582e-02f, -9.88322031e-03f, 5.57148177e-03f, 6.31604120e-02f, -6.68977425e-02f, 1.21749137e-02f, -2.53000353e-02f, -2.97905207e-02f, 6.61991015e-02f, -5.23654632e-02f,
  -7.69077167e-02f, 2.23395806e-02f, -4.88034822e-02f, -1.07800819e-01f, -9.17756036e-02f, 1.22378049e-02f, 9.20427442e-02f, -1.35036628e-03f, 3.20094004e-02f, -1.11239232e-01f,
  3.99713665e-02f, 8.23351294e-02f, -5.51952980e-02f, -4.04720195e-03f, 7.01501817e-02f, -8.21222886e-02f, -4.94968183e-02f, -7.42980018e-02f, -3.98918279e-02f, 1.33701665e-02f,
  1.78998746e-02f, -1.02168515e-01f, 1.48398727e-01f, 3.32080089e-02f, -7.28262647e-04f, 8.28830376e-02f, 2.45215017e-02f, 3.87884071e-03f, 1.04480065e-01f, -1.74087033e-01f,
  -7.02056959e-02f, -5.21594062e-02f, 6.66762888e-02f, -6.69007003e-02f, 1.12821206e-01f, 6.89556822e-02f, 5.20923957e-02f, 2.95131449e-02f, 6.82485774e-02f, 6.43710420e-02f,
  5.92642240e-02f, -1.16668586e-02f, 1.22091331e-01f, -1.87318176e-02f, -9.41244587e-02f, -2.61559151e-02f, -1.26758158e-01f, -3.22565064e-02f, -1.17286585e-01f, 8.03546458e-02f,
  -7.32739493e-02f, 4.46992740e-02f, 6.24132417e-02f, 7.23216906e-02f, -7.68580586e-02f, -8.97678733e-02f, 6.86026812e-02f, 5.85090518e-02f, -4.40538973e-02f, 6.04860187e-02f,
  -1.63100269e-02f, -9.83619615e-02f, -2.77354307e-02f, -5.22194058e-02f, 7.83196390e-02f, -4.96800765e-02f, 5.37252575e-02f, -6.55610263e-02f, 8.72873887e-02f, 5.16896024e-02f,
  4.58215289e-02f, -1.98435821e-02f, -9.40655395e-02f, 1.59144960e-02f, -3.08880303e-02f, -4.11413796e-02f, 9.77704599e-02f, -3.40696089e-02f, 6.83371276e-02f, -1.17035219e-02f,
  9.06242207e-02f, -3.11025530e-02f, -3.95295955e-02f, -6.16019368e-02f, -6.48865253e-02f, -5.88184334e-02f, -2.71059833e-02f, 5.56126609e-02f, -7.60885999e-02f, 2.11015996e-02f,
  3.49542908e-02f, -6.99884668e-02f, -4.90522943e-02f, -1.01425335e-01f, -6.29790947e-02f, -5.73136061e-02f, -6.00863509e-02f, -7.57859414e-03f, -4.25519422e-02f, -3.76609191e-02f,
  9.30705145e-02f, 1.30582243e-01f, -6.98545724e-02f, -1.05081402e-01f, -5.35070151e-02f, -1.33969737e-02f, 6.54306039e-02f, 3.40065584e-02f, -2.70881802e-02f, 7.48399422e-02f,
  5.83887994e-02f, 2.78790947e-04f, 3.43360789e-02f, 2.09486438e-03f, -2.15197727e-02f, -8.37689042e-02f, 9.74876583e-02f, 2.98981108e-02f, 2.35576164e-02f, 5.07411584e-02f,
  -1.11380070e-02f, 5.57316877e-02f, -4.49800231e-02f, 2.86994334e-02f, -1.50641389e-02f, -6.96288869e-02f, -4.93558720e-02f, -5.19939698e-03f, -3.32280993e-02f, -1.35031594e-02f,
  1.61223803e-02f, 6.57876655e-02f, 6.72009587e-02f, -5.36383223e-03f, 5.97375855e-02f, -4.66558263e-02f, 1.83661077e-02f, 9.87133533e-02f, -9.57980603e-02f, -7.50862015e-03f,
  -2.29732409e-01f, 1.20063901e-01f, -1.40864611e-01f, -5.90683371e-02f, 4.70437808e-03f, 9.01423171e-02f, 1.29096985e-01f, 9.33074728e-02f, 1.35221675e-01f, 2.00974390e-01f,
  1.75584078e-01f, -6.37502894e-02f, 6.02391846e-02f, 5.76624013e-02f, -1.20653540e-01f, -6.65796036e-03f, 1.55591235e-01f, 1.26906514e-01f, -4.95522842e-02f, 4.47624251e-02f,
  3.92886847e-02f, 1.28748313e-01f, -8.44505727e-02f, 8.61765060e-04f, -8.54074061e-02f, -1.21301495e-01f, -1.08561791e-01f, -6.36459887e-02f, -1.26102874e-02f, -3.26312594e-02f,
  5.33401445e-02f, -3.10534444e-02f, -1.25161514e-01f, -6.75911978e-02f, 6.19762242e-02f, -2.07302496e-02f, -1.35192629e-02f, -1.11225052e-02f, -5.97707964e-02f, 8.54003802e-02f,
  -1.85678117e-02f, -8.29285085e-02f, 8.83026794e-02f, -7.38919005e-02f, 6.45827875e-02f, 4.50711418e-03f, 1.84865985e-02f, -9.76927280e-02f, -1.38964877e-02f, -4.47598323e-02f,
  -1.14771597e-01f, -6.11305535e-02f, 9.08869952e-02f, 8.53844583e-02f, 4.78344522e-02f, -3.28250788e-02f, -3.90405394e-02f, -4.31541586e-03f, -1.03652114e-02f, -4.49730940e-02f,
  -2.98712645e-02f, 5.68999983e-02f, -2.52572587e-03f, 4.81227450e-02f, -5.28947301e-02f, 7.86005333e-02f, -1.12990132e-02f, -4.02179956e-02f, 5.96363246e-02f, -1.51013890e-02f,
  2.54237428e-02f, -7.38409162e-02f, -1.04579714e-03f, 6.44871891e-02f, 9.22955349e-02f, -3.03705893e-02f, 6.79527521e-02f, -1.16006099e-02f, -1.63748637e-02f, 5.44958487e-02f,
  3.29016857e-02f, 3.74008045e-02f, 3.72862443e-02f, -3.97763774e-02f, -2.71227490e-02f, -1.36006093e-02f, 1.12048298e-01f, -3.59171778e-02f, -9.34645999e-03f, -9.62493382e-03f,
  1.12017252e-01f, 1.65344477e-01f, 4.70838286e-02f, 6.10268116e-02f, 5.35871200e-02f, -1.07569685e-02f, 9.82400477e-02f, -1.08297616e-01f, 3.14047821e-02f, 6.52466863e-02f,
  -7.63481949e-03f, -8.90939981e-02f, -1.92242730e-02f, -4.38394956e-02f, 2.17006411e-02f, 5.10722324e-02f, 7.11570978e-02f, 6.00075312e-02f, 1.91895440e-02f, 6.46046847e-02f,
  -5.25558926e-03f, 1.23268783e-01f, -7.73777366e-02f, 7.63715431e-02f, -2.51355842e-02f, -4.68929000e-02f, 1.85022764e-02f, -1.02524191e-01f, 2.27519497e-02f, -1.43424729e-02f,
  2.17282802e-01f, 7.87553415e-02f, 2.64703855e-02f, 2.13310838e-01f, -6.84486404e-02f, 1.46570839e-02f, 1.85785383e-01f, 4.70732637e-02f, 2.57498950e-01f, 5.09387963e-02f,
  -7.81098828e-02f, 9.58513767e-02f, -5.66862822e-02f, 1.00845583e-01f, 8.80777463e-02f, 1.28397364e-02f, 1.72599047e-01f, 1.23288624e-01f, 1.58829749e-01f, -4.81052808e-02f,
  -5.75653575e-02f, -1.19819827e-01f, -1.20915413e-01f, -1.26086727e-01f, -1.77427996e-02f, 1.96736362e-02f, -1.55228466e-01f, -1.92574382e-01f, -6.06976002e-02f, 1.66058335e-02f,
  1.15200795e-01f, 5.36877476e-02f, -3.58798876e-02f, 7.71016851e-02f, 3.24795768e-02f, 2.84245121e-03f, -2.44949330e-02f, 7.50985928e-03f, 9.21072736e-02f, 1.02152340e-01f,
  -5.21502756e-02f, -5.68479784e-02f, 9.07629356e-02f, 8.60457942e-02f, 1.08994775e-01f, 2.46539693e-02f, -1.73250195e-02f, 4.29772697e-02f, 2.65621278e-03f, -9.34388302e-03f,
  5.23731075e-02f, 8.96421745e-02f, 6.04897216e-02f, 2.86482982e-02f, 3.82380188e-02f, 4.85377684e-02f, 7.88463727e-02f, 4.92823347e-02f, 1.37340939e-02f, -2.02099215e-02f,
  1.47242947e-02f, 5.51837347e-02f, 7.45006725e-02f, 5.06785996e-02f, 1.16767595e-02f, -9.67060775e-02f, -9.18118283e-02f, -3.02716321e-03f, 4.60935272e-02f, 4.30896655e-02f,
  6.43713176e-02f, 1.22429952e-01f, 1.04743861e-01f, 6.62803054e-02f, -3.57295461e-02f, -4.40522656e-02f, -9.05319005e-02f, 5.16281389e-02f, 4.30777222e-02f, -3.60606471e-03f,
  -7.53536075e-02f, 2.87060589e-02f, -8.81678313e-02f, 1.70300957e-02f, 3.27903293e-02f, 3.80875282e-02f, 4.34575789e-02f, -5.58153279e-02f, 6.19539954e-02f, 7.56126735e-03f,
  -9.62382928e-03f, 8.73230398e-02f, -4.76995371e-02f, -7.55431727e-02f, -2.58002281e-02f, -7.41366297e-02f, -2.80879494e-02f, 1.21121280e-01f, 8.56840424e-03f, -2.85909907e-03f,
  2.19296254e-02f, 1.37714371e-02f, 2.17935233e-03f, 3.30316015e-02f, -6.85435236e-02f, -6.41830713e-02f, -1.29502703e-04f, -6.79926872e-02f, 6.65523037e-02f, -2.22503264e-02f,
  -5.05948588e-02f, -3.08708120e-02f, -9.12361294e-02f, -6.47679940e-02f, 7.52464086e-02f, 1.26962345e-02f, -1.49828466e-02f, 3.16801555e-02f, 4.53258865e-02f, -3.96311134e-02f,
  2.16695890e-01f, 3.35285179e-02f, 7.83505738e-02f, -1.13909077e-02f, -6.82569221e-02f, 1.30122557e-01f, 1.30283639e-01f, 3.57452817e-02f, 1.69986069e-01f, 1.12891637e-01f,
  -2.93693668e-03f, 1.32071063e-01f, 1.34466439e-02f, 1.67297691e-01f, 2.61128023e-02f, 4.09688465e-02f, 1.19372822e-01f, 4.43447419e-02f, 1.04890049e-01f, 2.29239929e-02f,
  -4.15309668e-02f, 6.33909553e-02f, -1.06693283e-01f, -1.06354304e-01f, -1.38723934e-02f, 6.55724406e-02f, -1.69492006e-01f, -8.63671452e-02f, -4.39498201e-02f, -1.03281707e-01f,
  4.87480350e-02f, 1.19972154e-01f, 9.30993930e-02f, -4.82203476e-02f, -6.54046685e-02f, -1.04489729e-01f, -5.17557524e-02f, -4.57426719e-03f, -1.58756841e-02f, 3.73324044e-02f,
  2.82844040e-03f, 1.16547430e-02f, 3.77416797e-02f, -1.10387988e-01f, -1.32107288e-02f, -7.88792968e-02f, -2.86854040e-02f, -8.14782158e-02f, -1.88428387e-02f, -2.70645488e-02f,
  -4.35009971e-02f, -3.56789827e-02f, 9.58761945e-02f, 6.72680885e-02f, 3.79893184e-02f, -4.23918664e-02f, 1.67014096e-02f, -9.17387009e-02f, -3.74928638e-02f, 4.61514154e-03f,
  4.33734320e-02f, -1.68349631e-02f, -6.60983473e-02f, -1.00560166e-01f, 8.92123803e-02f, -6.40957579e-02f, 3.66405174e-02f, 5.04628941e-02f, -7.50548691e-02f, 8.95169601e-02f,
  4.70917560e-02f, -6.19813874e-02f, -5.45020401e-03f, -5.93250692e-02f, 2.18267739e-03f, 2.53354516e-02f, 2.33996231e-02f, -5.87792322e-02f, -3.15248556e-02f, 4.41644564e-02f,
  3.83635648e-02f, -3.14544812e-02f, 6.03321791e-02f, -5.56722768e-02f, 4.71482873e-02f, 4.75314818e-02f, 2.40702275e-02f, 1.13961689e-01f, -7.56518468e-02f, 1.72816124e-02f,
  3.78225930e-02f, 7.08398521e-02f, 1.03171632e-01f, -3.77777666e-02f, 2.44204216e-02f, 9.16104838e-02f, 7.01581091e-02f, 3.81186232e-03f, -2.21504979e-02f, 2.94940993e-02f,
  8.75655487e-02f, 1.29741775e-02f, 8.72614607e-02f, -5.63267134e-02f, 6.15097657e-02f, -2.94293854e-02f, 4.72610630e-02f, -4.54415046e-02f, -4.80128974e-02f, -9.16293040e-02f,
  -1.20772375e-02f, -2.17420701e-02f, 1.09370902e-01f, -4.71141301e-02f, 7.74893388e-02f, 2.74993423e-02f, 4.33481596e-02f, 1.48032364e-02f, -2.12195748e-03f, -1.18772676e-02f,
  1.14589885e-01f, -7.72197619e-02f, -1.34196505e-01f, 1.78656951e-02f, -1.59210160e-01f, -6.76706433e-02f, 8.18192139e-02f, -1.60580948e-02f, -9.51008592e-03f, 1.49912208e-01f,
  1.39222786e-01f, -1.17461421e-01f, 1.21114738e-01f, 9.94101837e-02f, 4.70142551e-02f, 1.48242414e-01f, 9.97327492e-02f, 1.03336707e-01f, 1.05540138e-02f, 5.75397909e-02f,
  1.04456954e-01f, 1.09036490e-01f, 1.25878155e-01f, -6.06534723e-03f, -5.70781603e-02f, 5.41426130e-02f, -2.05280036e-02f, -3.16464938e-02f, 1.25618413e-01f, -1.48555413e-02f,
  -1.31844701e-02f, -7.92162940e-02f, 7.73971826e-02f, -3.28856073e-02f, -2.34069750e-02f, 4.24386337e-02f, -7.86344614e-03f, 2.49323547e-02f, 2.38625910e-02f, 4.26292829e-02f,
  2.77344137e-02f, 1.55428043e-02f, -1.00267075e-01f, 2.48737242e-02f, 3.24209407e-02f, -1.63913593e-02f, -1.24127558e-02f, -3.48604769e-02f, 4.82543260e-02f, -4.04644432e-03f,
  1.41095640e-02f, 4.48997272e-03f, 1.57943089e-02f, -6.69728145e-02f, 3.91531512e-02f, -2.86482684e-02f, 6.61897361e-02f, 5.25127649e-02f, 5.43774366e-02f, -5.94425090e-02f,
  -5.00920974e-02f, 7.29090571e-02f, 7.90841952e-02f, -8.61746594e-02f, -1.08144581e-01f, 1.35523509e-02f, 1.04915068e-01f, -6.46048933e-02f, -3.88511196e-02f, 4.37770225e-02f,
  5.39785661e-02f, 4.19966673e-04f, 1.11317290e-02f, 7.64139593e-02f, 6.82884678e-02f, -5.36115952e-02f, -1.65576283e-02f, 5.94209693e-02f, -1.90066956e-02f, 2.21210662e-02f,
  9.09704790e-02f, 7.91696308e-04f, -8.11984688e-02f, 6.24467283e-02f, 3.92387472e-02f, 4.09839824e-02f, -1.84332635e-02f, -3.72357145e-02f, 6.30225390e-02f, 3.11547127e-02f,
  5.14670694e-03f, -1.79985985e-02f, -2.33654259e-03f, -2.52361391e-02f, 8.74103457e-02f, -8.22443441e-02f, 3.60303260e-02f, -2.49302704e-02f, 1.64929479e-02f, 6.51696175e-02f,
  -1.82098914e-02f, 6.29303828e-02f, -4.55587320e-02f, -2.06220802e-03f, -3.53911594e-02f, -7.57272989e-02f, 6.87762201e-02f, -1.94110293e-02f, 1.38809932e-02f, -3.60165276e-02f,
  9.17659549e-04f, -9.35976729e-02f, 3.98191586e-02f, -3.78567949e-02f, 1.78433675e-02f, 2.55722068e-02f, -5.13920113e-02f, 8.70510563e-03f, -8.95622373e-02f, 5.57476059e-02f,
  -1.94151625e-01f, 1.36281908e-01f, -1.53081924e-01f, -1.80556491e-01f, 2.72650942e-02f, 4.85257134e-02f, -1.44688729e-02f, -9.66755971e-02f, -4.04303744e-02f, -6.26290664e-02f,
  -1.39864266e-01f, -4.39602248e-02f, 4.67397533e-02f, 5.18874712e-02f, 4.01614346e-02f, 1.55432537e-01f, -2.06656139e-02f, -7.29136467e-02f, 9.89466608e-02f, -1.57664344e-02f,
  7.66356885e-02f, 1.57592893e-02f, 2.89506800e-02f, 1.37732804e-01f, -8.54436159e-02f, -1.01579763e-01f, 2.48079002e-03f, 7.46633187e-02f, -6.14354834e-02f, -6.75962716e-02f,
  -5.71941882e-02f, -1.60505444e-01f, -9.00241137e-02f, -1.35806695e-01f, -1.98135991e-02f, -7.70843551e-02f, 3.82758044e-02f, -2.12472994e-02f, -3.84467505e-02f, 5.23876920e-02f,
  8.31142664e-02f, 8.38791132e-02f, -6.40504584e-02f, 7.05663338e-02f, 3.41301784e-02f, -6.37218803e-02f, -4.35303152e-02f, -8.73897341e-04f, 1.53288813e-02f, -1.07012810e-02f,
  5.69079146e-02f, 3.22629847e-02f, -3.94605473e-02f, -1.63149275e-02f, 8.25868547e-02f, -5.12648560e-03f, 5.41173369e-02f, 8.33738875e-03f, -5.61786629e-02f, -8.71448144e-02f,
  2.06142459e-02f, -4.03677411e-02f, 4.94791828e-02f, -6.31929561e-02f, -1.09327668e-02f, -7.44999722e-02f, 3.55670042e-02f, -4.01241742e-02f, -3.63338855e-03f, 8.43000114e-02f,
  7.51585439e-02f, -1.06729437e-02f, -7.02994913e-02f, 8.38265494e-02f, 2.82813213e-03f, -4.41850424e-02f, 6.95025399e-02f, -8.93464983e-02f, 3.22785340e-02f, -5.95539808e-02f,
  -3.78312916e-02f, -3.49684507e-02f, -2.19906401e-02f, -6.58926442e-02f, 4.35280725e-02f, -3.57416272e-02f, 3.79228741e-02f, 7.67872110e-02f, 5.27651161e-02f, 9.50537436e-03f,
  -4.38002311e-02f, -2.09299728e-01f, 5.97665682e-02f, -6.52992502e-02f, -2.27238052e-03f, -9.31844711e-02f, -1.81011278e-02f, -4.28587832e-02f, -2.80789323e-02f, -6.01132065e-02f,
  -1.24625959e-01f, -7.82594755e-02f, -4.48963307e-02f, 3.40130180e-02f, 7.34450296e-02f, -7.90569112e-02f, -1.26950818e-05f, -3.84410508e-02f, -1.97238326e-02f, -5.73364757e-02f,
  -4.18331400e-02f, 1.43800967e-03f, -4.72822925e-03f, -1.80018116e-02f, -6.53767735e-02f, -6.55921176e-02f, -8.96868259e-02f, 4.49132249e-02f, -2.12468784e-02f, -2.25555506e-02f,
  -2.30203047e-01f, 1.23211935e-01f, -6.78466409e-02f, -7.92121515e-02f, -4.43301462e-02f, -1.38519257e-01f, -1.48411393e-01f, 5.98523654e-02f, 1.18938321e-03f, -9.32911038e-02f,
  -1.62107930e-01f, -3.02326251e-02f, 1.09327935e-01f, -4.13961187e-02f, -1.48374334e-01f, 9.66794565e-02f, -1.19741196e-02f, 3.90969813e-02f, 1.52855769e-01f, 5.62971793e-02f,
  -2.99748499e-02f, 1.96329579e-02f, -6.83924332e-02f, 1.18797615e-01f, -4.11027148e-02f, -7.00776950e-02f, -1.43186167e-01f, -1.64463706e-02f, -1.43060267e-01f, -9.33196321e-02f,
  -1.14938669e-01f, -1.19277537e-01f, -9.07909274e-02f, -1.29519418e-01f, -1.43509567e-01f, -8.68548304e-02f, -1.10973820e-01f, -3.45843248e-02f, 8.01879764e-02f, -2.87071019e-02f,
  -7.61036342e-03f, 1.24021256e-02f, 7.57317692e-02f, 5.23180328e-02f, -3.45716067e-02f, -7.02782050e-02f, 7.70306867e-03f, -6.15089014e-02f, 6.67925132e-03f, 4.30983081e-02f,
  -4.62505855e-02f, -8.72703195e-02f, -8.94209556e-03f, 9.63821821e-03f, -6.86455891e-02f, -1.09847061e-01f, 1.35896364e-02f, -5.38554378e-02f, -7.37802759e-02f, 4.40279655e-02f,
  7.48526454e-02f, -2.64504887e-02f, -4.70486544e-02f, -7.21460357e-02f, 3.20308357e-02f, -6.25652596e-02f, 5.94995283e-02f, 3.35771665e-02f, 2.82025356e-02f, -4.75283824e-02f,
  -5.92753552e-02f, 1.88560579e-02f, 3.34779546e-02f, -6.24777935e-02f, -4.68983762e-02f, 5.27383499e-02f, -8.10494050e-02f, 1.69005096e-02f, -1.02734948e-02f, -4.95907255e-02f,
  5.74473329e-02f, 4.93062660e-02f, 7.63491914e-02f, -7.53599927e-02f, -4.79324460e-02f, 7.05770031e-02f, -8.48775133e-02f, 7.94212967e-02f, 1.56096295e-02f, 7.25602806e-02f,
  -1.13400720e-01f, -1.04495943e-01f, -4.78361547e-02f, 1.52157899e-03f, -6.23112805e-02f, 6.47007897e-02f, -3.36542279e-02f, -2.47965148e-03f, -5.77278323e-02f, 4.00690436e-02f,
  1.15872793e-01f, 6.51682764e-02f, -3.21423193e-03f, 6.09308593e-02f, 5.12061045e-02f, 2.69219130e-02f, -7.34413341e-02f, -5.90486042e-02f, 2.86864676e-03f, -5.82286157e-02f,
  -7.95935690e-02f, 4.41448912e-02f, 3.77159081e-02f, 4.90206555e-02f, 1.06140580e-02f, 3.02955583e-02f, -7.28439391e-02f, 1.03797903e-02f, 1.15212938e-02f, 1.92674436e-02f,
  -1.69615239e-01f, 4.29895259e-02f, -8.44062865e-02f, -1.30610913e-01f, 6.58262819e-02f, 8.31236243e-02f, 1.21019877e-01f, 1.25537589e-01f, -8.81489739e-03f, 1.63582250e-01f,
  6.63514808e-02f, 3.48309241e-02f, -4.31745090e-02f, -1.06801108e-01f, -9.12965238e-02f, -6.83311224e-02f, 5.49310297e-02f, -1.71693955e-02f, 5.07772043e-02f, 5.73161431e-02f,
  -1.10970616e-01f, -1.65911522e-02f, -1.31015748e-01f, 4.05358039e-02f, 1.77883226e-02f, -6.83443481e-03f, 8.90723392e-02f, -8.88294820e-03f, 3.80805768e-02f, 4.08439711e-02f,
  6.04184577e-03f, 1.63722932e-01f, 2.27518566e-02f, -8.90850499e-02f, 6.57116324e-02f, 7.70928934e-02f, 6.42120093e-02f, -1.19353049e-01f, -2.88678538e-02f, 1.06345236e-01f,
  -4.43213917e-02f, -8.13128147e-03f, -5.68192974e-02f, 4.87546027e-02f, 2.13046502e-02f, 4.81635332e-02f, -4.71652336e-02f, -1.11161880e-01f, -4.38801013e-03f, -4.04215194e-02f,
  2.55972818e-02f, -1.09251877e-02f, -4.60118577e-02f, 3.80522497e-02f, 1.04586426e-02f, 4.80135381e-02f, -6.37328392e-03f, 2.81677991e-02f, -5.26569039e-02f, 8.34631324e-02f,
  9.72821377e-03f, 8.63354802e-02f, 4.03351262e-02f, 3.00128702e-02f, -3.97903249e-02f, -7.98822381e-03f, -6.47997186e-02f, -5.70474798e-03f, 2.48061251e-02f, -3.14021707e-02f,
  5.42181432e-02f, -5.71740083e-02f, 8.86870772e-02f, 7.91442394e-02f, 9.03993938e-03f, 1.03844687e-01f, -2.68252846e-03f, 5.65399341e-02f, 5.14555015e-02f, -9.68166888e-02f,
  -2.81117875e-02f, 2.71747131e-02f, 1.20085860e-02f, -6.60207449e-03f, -1.23369554e-03f, 2.87206098e-02f, -6.13599271e-02f, -8.75755996e-02f, -5.66216595e-02f, 2.28782464e-02f,
  1.51239917e-01f, 2.58667856e-01f, -7.64806941e-02f, 7.37068132e-02f, 1.23831034e-02f, 2.79847234e-02f, 4.37076911e-02f, 5.44159748e-02f, -8.75868835e-03f, 5.44557460e-02f,
  -2.96856463e-02f, 5.24714664e-02f, 4.34477776e-02f, -7.72220343e-02f, 1.77320112e-02f, 5.63904345e-02f, 2.05797572e-02f, 3.18197254e-03f, 5.40138707e-02f, 2.16666684e-02f,
  -1.23806251e-02f, 3.50049548e-02f, 5.34351021e-02f, -1.88637450e-02f, -7.20187351e-02f, 9.46816653e-02f, -5.52980192e-02f, 3.17066256e-03f, 3.25018279e-02f, 8.15654919e-03f,
  -1.17550656e-01f, 8.18918943e-02f, -4.56825793e-02f, -1.89539805e-01f, -2.11847182e-02f, -1.85042799e-01f, -1.88789532e-01f, -8.40127561e-03f, 1.48092672e-01f, 1.26359195e-01f,
  -8.46417993e-03f, 7.97556788e-02f, -2.14516167e-02f, -1.28122211e-01f, -6.93010390e-02f, 1.75309312e-02f, -2.56931722e-01f, -2.08024606e-01f, 4.77227047e-02f, -1.43493429e-01f,
  -9.75925475e-02f, -2.13394061e-01f, -9.05853957e-02f, -5.63015826e-02f, -1.76439196e-01f, 1.76815856e-02f, -7.56441653e-02f, -1.23047024e-01f, -1.05421647e-01f, 5.73704727e-02f,
  9.73735936e-03f, -4.49826643e-02f, -8.08670819e-02f, 6.59223124e-02f, -1.17911799e-02f, -2.44727754e-03f, -6.77231178e-02f, 6.94134980e-02f, -6.81417584e-02f, 3.92101370e-02f,
  1.67382304e-02f, 9.04891547e-03f, 3.02225854e-02f, 1.19728979e-03f, -5.39830029e-02f, 1.11799724e-01f, -4.04233672e-02f, 6.06518723e-02f, 1.90017633e-02f, 7.60000125e-02f,
  2.37285588e-02f, -3.01928669e-02f, -5.00543639e-02f, 4.50887270e-02f, 5.80544360e-02f, 7.68617094e-02f, -7.77101293e-02f, 9.27398354e-02f, 6.82942793e-02f, -4.08012979e-03f,
  5.99058857e-03f, -1.15794959e-02f, 2.88090892e-02f, 9.32814702e-02f, 6.89750612e-02f, 8.24263506e-03f, -8.92936368e-04f, -4.31233197e-02f, -9.30602942e-03f, 4.10191491e-02f,
  -1.38699319e-02f, 6.13636384e-03f, -3.35260332e-02f, -3.46983150e-02f, -8.68432820e-02f, 8.67351610e-03f, 8.47299024e-02f, 3.72377299e-02f, -8.56522936e-03f, -4.19314858e-03f,
  -7.51859993e-02f, 3.02183274e-02f, 6.03978597e-02f, 5.41939586e-02f, 8.58234093e-02f, 1.40242912e-02f, 1.15578637e-01f, 1.19612224e-01f, -6.69706687e-02f, -6.92695454e-02f,
  -1.63650692e-01f, -8.48823711e-02f, -4.52979058e-02f, -3.66788357e-02f, 6.69279769e-02f, -3.37815359e-02f, -1.06167030e-02f, -3.75704207e-02f, -4.98490222e-02f, 3.20952870e-02f,
  -4.57262658e-02f, 2.01441068e-02f, -7.72636607e-02f, -1.80389620e-02f, 7.30474070e-02f, -4.56677750e-02f, -5.21147400e-02f, -9.37352180e-02f, -8.83777067e-02f, 5.39162979e-02f,
  -5.39080724e-02f, 2.95441318e-02f, 5.48477694e-02f, 4.85276105e-03f, -3.10401879e-02f, 2.59093828e-02f, -7.01576192e-03f, 7.49290809e-02f, 6.15576794e-03f, -4.30961847e-02f,
  2.17273757e-01f, -6.40413910e-02f, 6.57628849e-02f, 2.52686944e-02f, 3.17400880e-02f, -6.54579923e-02f, 1.90225020e-02f, 2.91462466e-02f, -2.45825816e-02f, 4.05136943e-02f,
  -6.47549406e-02f, 6.53515905e-02f, 1.69929918e-02f, -4.11246903e-02f, 5.72277382e-02f, -3.88690718e-02f, 1.94949303e-02f, -1.05450101e-01f, -1.18654212e-02f, 1.77747086e-01f,
  5.39690331e-02f, 5.88560365e-02f, -5.90187870e-02f, 3.78215984e-02f, -1.33276209e-02f, 7.49412328e-02f, 9.75594372e-02f, 7.76824206e-02f, 8.54195002e-03f, -9.21567008e-02f,
  -1.77158397e-02f, 5.78432195e-02f, 8.78992453e-02f, 3.40127051e-02f, -4.57675308e-02f, 1.08463362e-01f, -5.38974442e-02f, -6.29266426e-02f, 8.47361460e-02f, -7.60024115e-02f,
  -4.54211012e-02f, 4.41967659e-02f, -4.14805338e-02f, 3.34164649e-02f, 9.79868323e-02f, 3.95891890e-02f, 1.21716922e-02f, 1.59323998e-02f, 8.19030851e-02f, -9.34164152e-02f,
  -8.72933567e-02f, -8.71957559e-03f, 4.27401066e-02f, 4.41807620e-02f, -9.30531472e-02f, -9.67830233e-03f, -7.25279525e-02f, 5.93661889e-02f, 3.44090015e-02f, -1.43776545e-02f,
  1.61955148e-01f, -9.47889313e-02f, -8.23956877e-02f, 4.06819358e-02f, -6.05430305e-02f, -9.47690383e-02f, -3.90286967e-02f, 6.32912386e-04f, 6.62104934e-02f, -3.21952999e-02f,
  4.26760614e-02f, -3.20010036e-02f, -5.88970818e-02f, -2.86072064e-02f, 1.81407146e-02f, 7.19516873e-02f, 8.79809111e-02f, -3.82558033e-02f, 4.80654016e-02f, -6.64244872e-03f,
  5.09071462e-02f, -5.70606999e-02f, -7.56527036e-02f, -9.79085490e-02f, 2.84153093e-02f, 1.17098854e-04f, -3.07749398e-02f, -7.37427324e-02f, 6.35412782e-02f, 7.72404298e-03f,
  5.91225214e-02f, 2.66027581e-02f, 4.92354445e-02f, 1.84462629e-02f, -4.30191718e-02f, 8.86250883e-02f, 7.14936703e-02f, 8.35794732e-02f, -7.51000689e-03f, -5.60452119e-02f,
  8.14858600e-02f, 9.21411812e-02f, 5.95877245e-02f, -7.06304908e-02f, 9.44238603e-02f, 1.99130792e-02f, 5.94160073e-02f, -2.79007852e-02f, -4.93241772e-02f, -3.69807519e-02f,
  -3.95882279e-02f, 6.43861592e-02f, -3.59873823e-03f, -2.38150358e-03f, -9.95648503e-02f, 5.12209944e-02f, -1.73247773e-02f, -4.45112623e-02f, -6.99677989e-02f, 1.62196383e-02f,
  8.70545432e-02f, -2.67064214e-01f, 1.48793831e-01f, 8.51112697e-03f, 7.64839500e-02f, 4.21483144e-02f, -2.79715285e-02f, -1.08483836e-01f, 4.56637517e-02f, -1.68809623e-01f,
  -1.67883933e-01f, 1.01828858e-01f, 1.62065655e-01f, -2.21963495e-01f, 3.28920454e-01f, 1.68084577e-01f, -4.83416691e-02f, 7.21927956e-02f, 3.51870656e-02f, -6.17754161e-02f,
  -3.95402275e-02f, -2.20079094e-01f, 4.25419211e-02f, -1.93330050e-01f, -2.84351669e-02f, -1.34460062e-01f, -9.67325494e-02f, 1.15094118e-01f, -2.23873660e-01f, 4.14697155e-02f,
  -1.55656934e-01f, -1.58048153e-01f, -1.19698733e-01f, 3.03159971e-02f, 3.78366075e-02f, -5.33410423e-02f, 9.11234692e-02f, 9.48301107e-02f, -1.64873730e-02f, 3.40912715e-02f,
  1.08939838e-02f, 2.40661874e-02f, -7.38852024e-02f, -5.88230044e-02f, -5.93477190e-02f, -7.24804848e-02f, -4.15298156e-02f, -3.52775455e-02f, -5.85017912e-03f, 1.45068411e-02f,
  -4.65318980e-03f, 8.28292444e-02f, 8.25982615e-02f, -6.74985573e-02f, 9.96622816e-02f, -3.32900994e-02f, 8.51425156e-02f, 7.98766539e-02f, -3.50156575e-02f, -2.44883038e-02f,
  -4.13292870e-02f, 1.81757212e-02f, -1.62932891e-02f, -1.65077411e-02f, -6.66051824e-03f, 2.99135633e-02f, 2.60510594e-02f, 2.14831457e-02f, -6.87427726e-03f, 4.53012474e-02f,
  -1.81189552e-02f, 5.96485958e-02f, 5.68221286e-02f, 7.38278404e-03f, 1.41517734e-02f, -6.97323605e-02f, 3.14270221e-02f, 6.87699765e-02f, -4.77735139e-02f, -7.46387616e-02f,
  -2.59505846e-02f, -6.44764602e-02f, 1.77540034e-02f, 6.39619976e-02f, 4.38649394e-02f, 4.21070419e-02f, -1.30056128e-01f, -8.25648010e-03f, 3.28795202e-02f, 1.38448188e-02f,
  -1.31851822e-01f, -2.19956681e-01f, -3.36418077e-02f, -8.32191110e-02f, -3.79228443e-02f, -1.70772690e-02f, -4.26237434e-02f, 3.40454914e-02f, -4.95904312e-02f, -1.54237859e-02f,
  -1.06171053e-03f, -1.33093866e-02f, 2.38362551e-02f, -2.70140730e-02f, 7.22724199e-03f, -7.83657283e-02f, -7.51874968e-02f, -1.94397122e-02f, -8.11087191e-02f, 5.31491190e-02f,
  2.52454225e-02f, 3.99100482e-02f, 7.71356225e-02f, -6.58349171e-02f, -3.58790495e-02f, -1.29751116e-03f, -2.32798234e-02f, 1.00898184e-01f, 6.20124228e-02f, -3.07094511e-02f,
  1.26773685e-01f, 1.71055585e-01f, 1.75230935e-01f, 8.72995183e-02f, 4.95329238e-02f, 1.54265448e-01f, 2.87896264e-02f, 1.10149540e-01f, 3.10331732e-01f, 1.11477308e-01f,
  -5.21073192e-02f, 2.19029114e-01f, -1.17437497e-01f, 1.23714395e-01f, -9.80016217e-02f, -5.98852858e-02f, -3.89602855e-02f, 1.94693508e-03f, 1.61713049e-01f, 1.15440786e-01f,
  -3.30369994e-02f, -1.45646641e-02f, -5.41783385e-02f, -1.01627655e-01f, -8.14104155e-02f, -3.12482119e-02f, -1.27536416e-01f, -1.20543778e-01f, -1.00748561e-01f, -5.09365909e-02f,
  -1.74869988e-02f, 7.57030118e-03f, -7.14085549e-02f, -4.68435846e-02f, -8.34857896e-02f, 1.13161005e-01f, 7.20257238e-02f, -2.76435260e-02f, 9.15068239e-02f, -4.16638814e-02f,
  1.27580270e-01f, 5.36258854e-02f, 5.48980571e-02f, -2.41431780e-02f, -6.50380459e-03f, 1.17554404e-01f, -4.51981612e-02f, 9.35764313e-02f, 2.61938255e-02f, 1.11651979e-01f,
  1.08309940e-01f, -1.82971475e-03f, -6.91308081e-02f, -1.52653735e-02f, -2.28140270e-03f, 1.41432434e-02f, -3.59139517e-02f, -4.74108048e-02f, 8.02059695e-02f, 2.74315961e-02f,
  -2.35376637e-02f, 3.48202768e-03f, 2.60168929e-02f, 2.83657480e-02f, -9.39185172e-02f, 5.89704774e-02f, 1.32218804e-02f, -7.63604268e-02f, -4.96006496e-02f, 2.43503749e-02f,
  -7.56318271e-02f, 2.87871044e-02f, -1.15609765e-01f, -4.30281460e-02f, 8.26244727e-02f, 3.79603519e-03f, -7.10101351e-02f, 4.60272320e-02f, -6.63815737e-02f, 5.67815527e-02f,
  -2.05785353e-02f, -2.41781096e-03f, -6.01386987e-02f, -1.11206034e-02f, 9.15150717e-02f, -8.93407837e-02f, 6.94653764e-02f, 1.13301568e-01f, -1.66890603e-02f, 4.66119461e-02f,
  -9.35456306e-02f, 7.85708874e-02f, -1.03286259e-01f, 1.49009365e-03f, 2.59297974e-02f, -3.53512876e-02f, 3.76231745e-02f, -4.24148850e-02f, 4.19686548e-02f, -3.51437069e-02f,
  -2.15964112e-02f, -7.32160211e-02f, 1.14523191e-02f, 6.42556921e-02f, -2.77276174e-03f, -2.73730829e-02f, 4.31943126e-02f, 9.84991807e-03f, 6.28044605e-02f, 5.09738475e-02f,
  -9.22969133e-02f, -2.26229317e-02f, 3.31045464e-02f, 4.20380272e-02f, -1.04996311e-02f, -1.51448753e-02f, 3.08100414e-02f, 1.40144704e-02f, 8.46760068e-03f, 7.85597134e-03f,
  5.60379550e-02f, 3.99450392e-01f, 4.44690704e-01f, 2.85308063e-01f, -1.73244119e-01f, -3.50210667e-01f, -2.63281018e-01f, 5.63668422e-02f, 1.25437722e-01f, -1.15963956e-02f,
  -1.63289487e-01f, 2.48932973e-01f, -9.18523669e-02f, 1.16641961e-01f, -6.86989427e-02f, -4.37510014e-02f, -4.37630825e-02f, -1.00478947e-01f, 6.95576593e-02f, 2.26256341e-01f,
  9.45831686e-02f, -1.74596176e-01f, 1.70659572e-01f, -1.60855614e-02f, 1.21836402e-01f, 1.60759479e-01f, -4.44282591e-02f, 5.64816892e-02f, 1.38505444e-01f, -1.04471542e-01f,
  -1.77092612e-01f, 1.05150633e-01f, 8.28890800e-02f, -2.57037533e-03f, -3.66677083e-02f, -1.18504524e-01f, -5.24718605e-04f, -1.11756153e-01f, 3.24270800e-02f, -9.34777316e-03f,
  -2.56393421e-02f, 8.81476700e-03f, -3.36140096e-02f, -3.34752887e-03f, -2.87797712e-02f, 5.03736399e-02f, 5.65171428e-02f, 6.65616691e-02f, 2.03409325e-02f, 5.53292483e-02f,
  1.56160936e-01f, -3.60046253e-02f, 1.15583204e-02f, 7.83685688e-03f, 8.47300068e-02f, 2.60809418e-02f, -7.95263040e-04f, 1.81937907e-02f, 2.43490953e-02f, -2.57779378e-02f,
  -7.09206006e-03f, -1.78782623e-02f, 4.14079800e-02f, 2.57734191e-02f, 3.56397852e-02f, -2.68110391e-02f, 5.10619767e-03f, -1.00352764e-01f, -7.83059299e-02f, 2.59695090e-02f,
  1.35075729e-02f, 7.05748647e-02f, 1.11630410e-02f, 3.70996073e-02f, 3.68657298e-02f, -4.32307497e-02f, 2.71043926e-02f, -3.07651632e-03f, -5.38769737e-03f, 4.99070156e-03f,
  4.92201652e-03f, -3.30333374e-02f, 2.89294031e-03f, 1.24898069e-02f, -3.13916914e-02f, 5.66045456e-02f, 4.33090851e-02f, -1.57573968e-02f, 5.10787666e-02f, 8.52762070e-03f,
  -3.55650783e-02f, 1.87539995e-01f, -6.10565245e-02f, -3.53162014e-03f, -5.91109367e-03f, -1.17166005e-01f, 1.14524784e-03f, 7.42997229e-03f, 1.02754883e-01f, -2.67352834e-02f,
  1.51843438e-02f, -1.75326690e-02f, 6.53752536e-02f, 1.07322158e-02f, -2.20444016e-02f, -6.45039510e-03f, 7.65072107e-02f, -4.23043817e-02f, 1.49471601e-02f, 5.74841201e-02f,
  5.40961623e-02f, -2.45417971e-02f, -5.54369017e-02f, 1.48369996e-02f, -2.04486549e-02f, -4.76185493e-02f, -3.33652040e-03f, 6.58575296e-02f, -1.38580427e-02f, -2.39602979e-02f,
  1.09258659e-01f, -1.38637468e-01f, -2.64679670e-01f, -3.46325077e-02f, 6.17451333e-02f, -1.36162508e-02f, -3.49024348e-02f, -6.03233762e-02f, -3.62184383e-02f, 3.74440998e-02f,
  8.68395790e-02f, -5.07261790e-02f, 5.64604588e-02f, -1.19592831e-01f, -1.00335494e-01f, -5.73251471e-02f, -1.08338997e-01f, 1.48847550e-02f, -7.96522349e-02f, 2.95776483e-02f,
  -7.24684820e-02f, -5.14940806e-02f, -2.20365338e-02f, 4.64381054e-02f, -3.45967188e-02f, 1.46480380e-02f, 2.25744564e-02f, 4.49699676e-03f, 2.47043744e-02f, -9.89544950e-03f,
  1.00789949e-01f, 2.19348986e-02f, 1.79406154e-04f, 2.45312229e-02f, 7.73088485e-02f, -3.20348814e-02f, -2.21409611e-02f, -9.18169990e-02f, 1.79583058e-02f, -1.05650596e-01f,
  4.60413136e-02f, 7.11871265e-03f, -5.75994030e-02f, -4.15087193e-02f, 3.57777514e-02f, -1.06935993e-01f, -2.80069672e-02f, -2.58015487e-02f, -6.35655746e-02f, -6.86615333e-02f,
  -1.10990524e-01f, -1.09215789e-01f, 7.24400133e-02f, -5.92726795e-03f, -9.58339423e-02f, 4.74568531e-02f, -1.02620805e-02f, 2.94302218e-02f, -6.67102784e-02f, 4.89318296e-02f,
  -5.57976104e-02f, 1.15641929e-01f, -7.04498067e-02f, -3.61290649e-02f, 3.12559754e-02f, 4.40124497e-02f, -8.35773349e-02f, -4.25666161e-02f, -5.57671487e-02f, 7.24382102e-02f,
  -6.69133142e-02f, -3.78227867e-02f, 5.80982864e-02f, -4.27454151e-02f, 8.31523985e-02f, 7.18638226e-02f, -1.99806001e-02f, 4.70256247e-02f, -1.29294461e-02f, -1.01861626e-01f,
  7.32665062e-02f, -4.80173640e-02f, 7.95111135e-02f, 2.51540765e-02f, 1.08311335e-02f, 2.45902967e-02f, -5.63466959e-02f, -6.72390386e-02f, -1.62855629e-02f, 1.89100150e-02f,
  6.33841380e-02f, -5.31192198e-02f, -7.12710097e-02f, -6.06192164e-02f, 5.78827038e-02f, -3.99488471e-02f, -1.05858799e-02f, -2.21909378e-02f, -2.83566266e-02f, -3.29607545e-04f,
  6.27813414e-02f, -1.29017346e-02f, 5.32062538e-02f, 1.67567227e-02f, -1.06795587e-01f, -3.59587604e-03f, 2.46338546e-02f, 2.19569076e-02f, 7.54859671e-02f, 1.10007241e-01f,
  -4.82835472e-02f, 1.85998585e-02f, 1.11292098e-02f, 2.74393521e-03f, 7.03055635e-02f, -5.13512082e-02f, -3.29319276e-02f, 8.43945146e-02f, 6.65622652e-02f, -6.45939261e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 52)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 52;
const float L0_fan_Bp_bar_data[] = {
  1.10399388e-01f, 1.42032161e-01f, 1.26308590e-01f, 1.05419286e-01f, 2.08929881e-01f, 6.02751076e-02f, 6.17044372e-03f, 2.15356737e-01f, 1.35133892e-01f, 6.69757500e-02f,
  6.94427788e-02f, -2.65763476e-02f, 1.84191450e-01f, 2.79084086e-01f, 1.91284224e-01f, 2.15822250e-01f, 1.92406341e-01f, 1.92308705e-02f, 1.24888636e-01f, 1.19286634e-01f,
  1.15632586e-01f, 2.07168907e-02f, 1.70308366e-01f, 5.67022245e-03f, -4.78577130e-02f, 9.01647434e-02f, -4.34648339e-03f, -3.00719384e-02f, -2.12274771e-02f, 2.22314358e-01f,
  1.71413496e-01f, 3.45078371e-02f, -3.31340507e-02f, 3.84563841e-02f, 5.78914098e-02f, 2.76661627e-02f, 1.41452864e-01f, 7.25943595e-02f, 3.41679044e-02f, 1.69424370e-01f,
  2.61281282e-01f, 7.77134746e-02f, -2.56060641e-02f, 1.00736797e-01f, 1.38264954e-01f, -1.10056773e-02f, 1.70762569e-01f, 9.57267359e-02f, 2.83157229e-01f, 9.91755128e-02f,
  1.13940895e-01f, 3.00372802e-02f
};

// L1_fan_Wp (Shape: 6 x 64)
const int L1_fan_Wp_rows = 6;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  1.15906544e-01f, 2.69901585e-02f, -1.98831670e-02f, -5.60097769e-02f, 1.09440550e-01f, -2.15782225e-01f, 2.50763953e-01f, 2.87221260e-02f, -2.49926075e-01f, 2.73979120e-02f,
  -8.00287575e-02f, -1.59339935e-01f, 5.67565672e-02f, -2.20017433e-02f, -6.31189868e-02f, -3.22667025e-02f, 8.22798759e-02f, -1.21730298e-01f, 1.41873181e-01f, 6.44309586e-03f,
  1.78546067e-02f, 1.62716180e-01f, 1.91623457e-02f, 1.36920586e-01f, -9.14592147e-02f, -1.29944086e-03f, 2.06365690e-01f, 1.12600468e-01f, -3.96855138e-02f, -7.45663568e-02f,
  8.06599259e-02f, 1.61263004e-01f, -7.90519547e-03f, -4.61350754e-02f, 1.76816732e-01f, 8.81019756e-02f, 6.89934567e-03f, -1.99630875e-02f, 8.76078829e-02f, -6.15772791e-02f,
  4.12455760e-02f, -5.71128167e-02f, -1.03727810e-01f, -4.65122871e-02f, 7.16414899e-02f, 7.06782341e-02f, -6.14897124e-02f, -1.65642619e-01f, -1.23388149e-01f, -4.56098607e-03f,
  -2.33144853e-02f, -1.12586185e-01f, 9.93530303e-02f, -7.97707215e-02f, -1.33436516e-01f, -5.81022687e-02f, -9.99778509e-02f, -1.48402289e-01f, 1.40992716e-01f, 9.16389097e-03f,
  1.44387767e-01f, 5.01683913e-02f, -1.36476770e-01f, -3.46347913e-02f, -8.03320389e-03f, 7.99133033e-02f, -8.87617394e-02f, -1.03417419e-01f, -1.40541762e-01f, -4.11962606e-02f,
  6.81392252e-02f, -2.51558907e-02f, -3.81852500e-02f, -1.59598514e-02f, -3.49411368e-02f, 1.39828056e-01f, 7.44097121e-03f, 3.26897502e-02f, -1.93040833e-01f, 8.05043206e-02f,
  8.82747397e-02f, 1.18864939e-01f, -5.61312325e-02f, -1.12312734e-01f, -5.08928895e-02f, -8.72231126e-02f, 1.91840697e-02f, 2.64956541e-02f, 1.91283688e-01f, 4.66849543e-02f,
  -8.88604224e-02f, -9.46777910e-02f, 5.59580959e-02f, -5.41946106e-02f, -2.06877161e-02f, 4.02245075e-02f, 2.92066243e-02f, -1.02187507e-01f, -5.04682213e-02f, 2.92397868e-02f,
  5.49252555e-02f, -1.12568185e-01f, 1.05502941e-01f, -7.32544959e-02f, 1.05620369e-01f, -9.61115286e-02f, 8.33112225e-02f, -1.59524649e-01f, -7.61331618e-02f, 1.56468432e-03f,
  1.71264913e-02f, -1.80845894e-02f, 1.62800640e-01f, -3.67347337e-02f, -6.76340163e-02f, -2.75576068e-03f, -3.24820653e-02f, 3.24530564e-02f, -2.03121658e-02f, -8.16193894e-02f,
  -1.53231993e-01f, -1.03912167e-01f, -3.74106131e-02f, -8.86844620e-02f, -8.93283635e-02f, 1.56400166e-02f, -5.69942258e-02f, -8.67577121e-02f, 1.15047619e-01f, -2.26387437e-02f,
  -1.84081659e-01f, -1.54511079e-01f, 2.60382127e-02f, 3.14576700e-02f, -2.17080101e-01f, 5.43945096e-02f, 3.18214707e-02f, -1.50846228e-01f, -1.89160645e-01f, 2.50512771e-02f,
  -1.06149472e-01f, 6.25820309e-02f, -9.62683558e-02f, -6.45319000e-02f, -9.36545506e-02f, 1.50729850e-01f, 1.70802072e-01f, -1.45481974e-01f, 1.19393766e-02f, 1.08730905e-01f,
  9.47663859e-02f, 1.90537825e-01f, 2.46669441e-01f, -3.40293795e-02f, -1.11880079e-01f, -5.66676781e-02f, 9.43335816e-02f, -4.15340327e-02f, -6.36646003e-02f, -2.06145830e-02f,
  7.46949613e-02f, 9.43326205e-02f, 4.84888330e-02f, -1.37332216e-01f, -1.47035733e-01f, -8.33838060e-02f, -4.53756303e-02f, -1.56822354e-01f, 1.23517476e-01f, -8.29707012e-02f,
  1.20982662e-01f, -9.50652808e-02f, 8.49990845e-02f, -3.88561971e-02f, 1.76280752e-01f, -4.35176156e-02f, 1.41649038e-01f, -6.18233532e-02f, -8.43393505e-02f, -8.96114409e-02f,
  1.17162310e-01f, -5.20165451e-02f, 1.72279283e-01f, -1.12983853e-01f, -2.05940053e-01f, -1.05884135e-01f, -4.34117690e-02f, -5.75644523e-02f, 1.04232445e-01f, -1.55666649e-01f,
  7.51541853e-02f, 1.92180332e-02f, -1.90316349e-01f, -2.06898063e-01f, -3.57424617e-02f, -2.02913091e-01f, -1.99037418e-01f, -2.11100191e-01f, 2.21640587e-01f, 3.31129760e-01f,
  -8.68404508e-02f, -2.48348221e-01f, -9.19153243e-02f, -2.34144524e-01f, -7.89951459e-02f, -4.60026488e-02f, -3.83263938e-02f, -1.44397005e-01f, 7.33807757e-02f, 2.54821889e-02f,
  2.66588721e-02f, -2.05234706e-01f, -3.25302668e-02f, -7.94686154e-02f, -6.88493550e-02f, 2.21493497e-01f, 1.13402516e-01f, 3.41662243e-02f, 1.71917737e-01f, 1.06669672e-01f,
  -1.48432821e-01f, 3.20787309e-03f, 1.11586899e-01f, 9.48599055e-02f, -1.21721223e-01f, 3.07978597e-02f, -1.02955252e-01f, 2.14664415e-02f, -6.53515831e-02f, -1.10722400e-01f,
  2.75918692e-02f, 5.49526280e-03f, 7.40842000e-02f, 3.87840830e-02f, 6.40272349e-02f, 5.82422838e-02f, -1.28729607e-03f, 5.44394106e-02f, -1.78242952e-01f, -1.19077623e-01f,
  -1.42437816e-01f, -7.31709674e-02f, 6.90407082e-02f, 4.17327136e-02f, 5.20775542e-02f, 1.85884722e-02f, 8.01721811e-02f, -2.30879799e-01f, -1.25747338e-01f, -1.32157892e-01f,
  -6.04707673e-02f, 2.64854059e-02f, 2.63481401e-02f, -6.69333851e-03f, -2.46516094e-01f, 8.95550549e-02f, -1.04838118e-01f, 1.27278641e-01f, -8.07952359e-02f, 8.63206461e-02f,
  3.11858561e-02f, 1.79461673e-01f, -1.33192599e-01f, -2.67347813e-01f, -5.65293618e-02f, 2.73576111e-01f, 3.67963011e-03f, 3.02982807e-01f, -1.60091966e-02f, 5.25191659e-03f,
  2.33084768e-01f, -8.83965641e-02f, -2.32183188e-01f, 5.60021177e-02f, 8.93083960e-02f, 1.11084012e-02f, 1.72175631e-01f, -2.09287722e-02f, -7.88898095e-02f, -1.77194804e-01f,
  -3.85243148e-02f, -1.56300277e-01f, 2.45187636e-02f, -9.65807289e-02f, 9.66443717e-02f, 2.44786423e-02f, -1.11316592e-02f, -1.09239399e-01f, -6.95615262e-02f, -1.13118865e-01f,
  1.11093424e-01f, 1.26009211e-01f, 5.54693602e-02f, -1.40203968e-01f, 3.09625044e-02f, -1.76879903e-03f, -1.04125872e-01f, 1.43333182e-01f, -8.16724170e-03f, -3.57537009e-02f,
  -2.31491048e-02f, -5.78583889e-02f, -3.70227024e-02f, 1.20979115e-01f, 9.34972167e-02f, -3.34429182e-03f, -9.90637392e-02f, -2.34709848e-02f, -9.49667580e-03f, -3.24919149e-02f,
  -8.95047262e-02f, 1.45106748e-01f, 2.04321623e-01f, 8.32104608e-02f, 1.51712954e-01f, 2.94028651e-02f, -5.54670431e-02f, 1.04985029e-01f, 1.35169566e-01f, 3.45550179e-02f,
  1.28908470e-01f, 1.01004645e-01f, -3.90992016e-02f, -1.12922184e-01f, 4.20776121e-02f, 1.02266230e-01f, -1.82628334e-01f, 3.69193941e-01f, 4.17898893e-01f, -1.12231515e-01f,
  -1.35474890e-01f, -3.78432512e-01f, -1.28078565e-01f, 9.90262851e-02f, -2.59806216e-01f, 1.02491893e-01f, 2.60943938e-02f, 2.36962408e-01f, -8.99541080e-02f, 1.59062624e-01f,
  2.50280946e-02f, -1.05359340e-02f, 1.48392379e-01f, 4.23617139e-02f, 2.21269533e-01f, 1.13813937e-01f, 1.19798101e-01f, -4.81105559e-02f, -1.86563060e-02f, 8.92461836e-02f,
  -1.54526785e-01f, -1.51983082e-01f, -2.16166034e-01f, 1.32710367e-01f, -8.83121639e-02f, 7.66581371e-02f, 1.21654667e-01f, 8.31607059e-02f, 1.25231802e-01f, -7.72026228e-03f,
  -1.13552645e-01f, 4.35401164e-02f, -9.77573246e-02f, 4.48300168e-02f, -9.76804867e-02f, 2.53601838e-02f, 4.65738550e-02f, 7.36648887e-02f, -2.12191552e-01f, -5.74870929e-02f,
  -1.02870703e-01f, 3.50735150e-02f, 3.86175103e-02f, -2.91192625e-02f, -8.07600468e-02f, -1.73723996e-01f, -3.74833196e-02f, 1.86639473e-01f, -8.93959776e-02f, -1.88514199e-02f,
  -1.59164593e-01f, 7.23783150e-02f, 1.46439180e-01f, 1.00939907e-01f
};

// L1_fan_Wp_bar (Shape: 52 x 64)
const int L1_fan_Wp_bar_rows = 52;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  4.20111716e-02f, 5.34509271e-02f, -8.63547251e-02f, 9.62533616e-03f, 4.70471717e-02f, 7.50331804e-02f, -9.45726410e-02f, -4.54665981e-02f, 1.38468027e-01f, 4.52278629e-02f,
  -1.71996988e-02f, -2.41229907e-02f, 8.53952095e-02f, 1.39332190e-01f, -9.93772820e-02f, 6.83572590e-02f, -6.30005896e-02f, -6.12131096e-02f, -2.05789581e-02f, 7.94520453e-02f,
  2.44542509e-02f, -4.93735708e-02f, 2.51220469e-03f, -5.37300147e-02f, -7.30412304e-02f, -1.78636089e-02f, -9.32135209e-02f, -8.66452977e-02f, -2.90029738e-02f, 1.34856641e-01f,
  -1.14837795e-01f, -1.16050474e-01f, -8.53378475e-02f, 6.58516735e-02f, 9.52540711e-02f, -6.98250998e-03f, 1.02234103e-01f, 1.00257233e-01f, -1.08195551e-01f, -3.48922834e-02f,
  2.64483355e-02f, -9.02729481e-02f, -5.81399240e-02f, 1.88190409e-03f, 1.16328076e-01f, 5.38227223e-02f, -1.75220668e-02f, 8.10233876e-02f, 1.38065547e-01f, 6.05312698e-02f,
  5.88700809e-02f, -1.36746289e-02f, -2.87901089e-02f, 6.20387271e-02f, 9.42305196e-03f, -3.25537436e-02f, 1.18379034e-02f, 3.28866132e-02f, 1.45102376e-02f, -4.93896566e-02f,
  1.01406805e-01f, 6.21607490e-02f, -1.33033693e-01f, -5.46556674e-02f, -5.84478416e-02f, 1.19831413e-01f, 9.97130498e-02f, 1.21091589e-01f, 8.45377445e-02f, 1.14249453e-01f,
  1.87366549e-02f, -1.50905952e-01f, -6.89583691e-03f, -9.69289616e-02f, -1.80997401e-01f, 2.25770921e-01f, -1.16378047e-01f, 1.17983721e-01f, 6.00877553e-02f, -1.02488086e-01f,
  5.65821258e-03f, -4.65720966e-02f, -5.29586487e-02f, 9.36537236e-02f, 1.75446808e-01f, -1.44853279e-01f, -4.70454469e-02f, -1.46183059e-01f, 6.74290061e-02f, -1.27915800e-01f,
  -1.10003971e-01f, 7.08281472e-02f, 1.89393461e-01f, 1.99199505e-02f, -6.66743293e-02f, -1.88400924e-01f, 1.71626776e-01f, -8.37230608e-02f, -2.57563218e-02f, -5.17060198e-02f,
  8.61135349e-02f, 1.51052698e-01f, -6.79507107e-02f, 1.26709104e-01f, 7.33753592e-02f, 8.40618908e-02f, 8.30417201e-02f, -1.10586695e-01f, -1.35129234e-02f, 1.07642464e-01f,
  1.56764165e-01f, -7.31335133e-02f, 2.91038752e-01f, 3.24492827e-02f, -9.51667726e-02f, 2.05556363e-01f, 1.21099196e-01f, 9.71182883e-02f, 1.73475161e-01f, -2.52211355e-02f,
  9.32738855e-02f, 1.37304723e-01f, 1.05660535e-01f, 3.20011098e-03f, -1.19918756e-01f, 1.55418754e-01f, -1.42843425e-01f, 5.51169515e-02f, -3.56164649e-02f, -9.75757912e-02f,
  7.65310675e-02f, 8.19636807e-02f, -6.96003586e-02f, 1.58471733e-01f, -2.20544860e-01f, -6.09762296e-02f, 2.06305400e-01f, 2.41275225e-02f, 7.83116929e-03f, -4.62985598e-02f,
  1.11298151e-01f, -4.16445024e-02f, -3.11983116e-02f, 5.49566410e-02f, -1.07760541e-01f, -1.04202263e-01f, 6.17008656e-02f, 1.30730614e-01f, -8.79587457e-02f, -7.83425793e-02f,
  -4.24893349e-02f, -1.28719211e-01f, -1.93492174e-02f, 5.16272038e-02f, 1.18707441e-01f, -4.62549068e-02f, -2.11649183e-02f, 1.35251477e-01f, 4.43828069e-02f, -5.62024070e-03f,
  1.09340390e-02f, 3.28941420e-02f, -1.07265964e-01f, 4.32150885e-02f, -3.96844633e-02f, -1.08508840e-02f, -8.07630084e-03f, 1.44733608e-01f, 9.87314209e-02f, -9.30108279e-02f,
  5.29328957e-02f, 1.37357458e-01f, -2.74162812e-05f, -1.14985071e-02f, 1.58182651e-01f, 1.54146016e-01f, -7.48250335e-02f, 2.95375884e-02f, -6.33375868e-02f, 6.42298609e-02f,
  -1.06617860e-01f, -9.15217996e-02f, 4.20271568e-02f, 6.86947405e-02f, 4.61815186e-02f, -4.81622033e-02f, 1.79563671e-01f, 4.54717427e-02f, 4.01799977e-02f, 1.85173210e-02f,
  3.29701342e-02f, -8.19876976e-03f, 3.05752188e-01f, 2.20250577e-01f, 1.86966836e-01f, 1.59084663e-01f, 1.83688834e-01f, 2.31486216e-01f, -2.81730462e-02f, 2.42647931e-01f,
  2.73255736e-01f, -1.68684155e-01f, -5.60888760e-02f, -2.74911702e-01f, 1.69156212e-02f, 1.41778320e-01f, -2.77951032e-01f, 2.07815289e-01f, 7.38669708e-02f, 4.32562143e-01f,
  -4.37812619e-02f, -6.19424172e-02f, -2.36943424e-01f, 1.45024911e-01f, 2.22157463e-01f, 9.41016003e-02f, 2.02074617e-01f, 4.15402889e-01f, 2.70757884e-01f, 1.30176216e-01f,
  -1.91959426e-01f, 9.99846980e-02f, 4.94551249e-02f, -1.43792033e-01f, 2.37106420e-02f, 5.60427420e-02f, 7.23347515e-02f, 5.72415590e-02f, -7.31034204e-02f, -1.36457756e-02f,
  3.01386099e-02f, 6.96538528e-03f, -1.38267234e-01f, 6.61356095e-03f, 2.86654413e-01f, -1.81251373e-02f, -5.83332665e-02f, -1.33273918e-02f, -4.27714549e-02f, 1.32810354e-01f,
  2.02439371e-02f, 1.33954287e-01f, 2.16391422e-02f, -1.56311095e-01f, 1.86171487e-01f, 5.05666584e-02f, -5.03807440e-02f, -1.36968702e-01f, -1.24252968e-01f, -1.08047105e-01f,
  -1.33785129e-01f, 1.49633735e-01f, -1.16032600e-01f, 2.00664893e-01f, 5.07235289e-01f, -1.56745777e-01f, 3.24567035e-02f, -1.95317306e-02f, -1.15742655e-02f, 1.09450392e-01f,
  7.18341917e-02f, -7.34762177e-02f, 3.24305668e-02f, -1.00482432e-02f, 1.83690861e-02f, -9.59944203e-02f, -1.11920603e-01f, 5.18719889e-02f, -5.70890115e-05f, 1.22136272e-01f,
  -4.47218716e-02f, 1.16353355e-01f, -2.64581125e-02f, -1.78606175e-02f, 4.50800033e-03f, -1.34483129e-01f, -6.31276220e-02f, -1.09772533e-01f, 5.97413518e-02f, -6.60861135e-02f,
  1.55275762e-01f, 5.73566975e-03f, -4.63639945e-02f, 7.24966303e-02f, 6.08267449e-02f, 2.73998138e-02f, -8.40834156e-02f, 3.42983492e-02f, -1.28304198e-01f, -1.34641647e-01f,
  -2.29336992e-02f, -9.02798623e-02f, 1.03134751e-01f, -2.42397282e-02f, 1.12127244e-01f, -1.34918526e-01f, 2.31797006e-02f, -9.13207158e-02f, -9.42602307e-02f, -1.08088404e-01f,
  -8.58193338e-02f, 3.72905992e-02f, 6.88674524e-02f, -2.85892654e-02f, 2.10759997e-01f, 8.63341168e-02f, 4.66427021e-02f, 3.54920663e-02f, 1.09109826e-01f, -8.88115168e-02f,
  6.14914149e-02f, 1.05075136e-01f, -7.44096413e-02f, 1.10171549e-01f, -1.67307839e-01f, 3.47813964e-02f, -2.33322196e-02f, 4.55051661e-02f, 7.73577690e-02f, 4.32032123e-02f,
  7.41298273e-02f, 1.07503697e-01f, 2.69248605e-01f, 1.57991275e-01f, 1.39747918e-01f, 9.06130597e-02f, 1.67045131e-01f, 8.77384469e-02f, 7.36557543e-02f, 1.63603112e-01f,
  5.48534915e-02f, -7.57887885e-02f, 1.68595314e-01f, 1.11910198e-02f, 2.40357384e-01f, -1.09892778e-01f, -4.15062122e-02f, 1.13974877e-01f, 5.90041541e-02f, 1.26145989e-01f,
  2.03619331e-01f, 1.40144989e-01f, -1.52412560e-02f, -8.44386369e-02f, 8.48358944e-02f, -9.12609994e-02f, 3.09419632e-01f, 1.34025425e-01f, 2.17889220e-01f, -5.83502278e-02f,
  1.62491128e-01f, -3.47759016e-02f, -8.89961421e-03f, -2.27591209e-02f, 1.27771252e-03f, 8.82855791e-04f, 4.09803400e-03f, 1.22286461e-01f, 9.67869535e-02f, 7.59771690e-02f,
  -1.43381312e-01f, 2.75953919e-01f, 2.57037394e-02f, 1.16044067e-01f, 7.04837814e-02f, 1.99888185e-01f, 6.80587441e-02f, 7.34472871e-02f, -1.62710771e-01f, -6.32781610e-02f,
  1.41099766e-01f, 1.31188124e-01f, 1.98942229e-01f, 1.86371028e-01f, -1.52885810e-01f, 2.52229664e-02f, 1.35358945e-01f, -1.98437795e-02f, 2.02208415e-01f, 1.23953134e-01f,
  -6.01066761e-02f, 1.13589033e-01f, 1.03622183e-01f, -6.73406571e-02f, 1.75995439e-01f, 2.38454625e-01f, -6.30898923e-02f, 2.02996612e-01f, 2.28079349e-01f, 2.64917493e-01f,
  -3.47989380e-01f, -7.56029934e-02f, 2.93621898e-01f, 1.69893056e-01f, 2.33302087e-01f, 3.66635397e-02f, -2.03053821e-02f, -3.82193550e-02f, -8.62732008e-02f, 1.56683754e-02f,
  -4.20200415e-02f, 6.59691468e-02f, -1.42376304e-01f, 1.71228752e-01f, -1.26924545e-01f, -4.26763594e-02f, -6.00595959e-03f, -1.89792052e-01f, -7.38130212e-02f, 6.69762790e-02f,
  -1.89699475e-02f, -3.27539630e-02f, -8.87581408e-02f, -3.14993411e-02f, -1.52290449e-01f, -1.82282984e-01f, -8.32134411e-02f, 1.31013408e-01f, -9.61152390e-02f, -7.82301500e-02f,
  1.19816117e-01f, 1.22804895e-01f, -3.00449468e-02f, 7.34501332e-02f, -1.15780294e-01f, -1.45997241e-01f, 9.15685482e-03f, 7.21659511e-02f, -9.66658965e-02f, -1.23528436e-01f,
  -3.11468672e-02f, 2.82752037e-01f, -1.75567940e-01f, -4.17063050e-02f, 7.36061018e-03f, 8.26176181e-02f, -1.00366332e-01f, -1.59136206e-01f, 8.22065324e-02f, -4.62530889e-02f,
  4.66040447e-02f, -2.06917413e-02f, 7.18251392e-02f, 1.45288259e-01f, -2.80382689e-02f, 1.35941226e-02f, 2.02507168e-01f, 8.94558951e-02f, 2.59924054e-01f, 3.44144732e-01f,
  1.79818854e-01f, 1.52060226e-01f, 2.36991897e-01f, 4.95762266e-02f, 3.33786666e-01f, -8.31525177e-02f, -2.97326028e-01f, 1.38309062e-01f, 1.36443213e-01f, 1.61867544e-01f,
  1.85018569e-01f, 2.12549674e-03f, 4.70835045e-02f, -9.88090783e-03f, 2.08740786e-01f, -1.13267735e-01f, 8.28400627e-02f, 8.23199749e-03f, -1.40738562e-01f, 9.58934426e-02f,
  -8.81866068e-02f, -4.78857532e-02f, -2.83347052e-02f, 1.21867709e-01f, 2.20017582e-01f, 1.03794269e-01f, -6.55713081e-02f, -1.69104002e-02f, -1.18689621e-02f, 3.71548444e-01f,
  -5.06332424e-03f, 8.94582495e-02f, 2.49978472e-02f, 1.83250889e-01f, 2.98751215e-03f, -7.37960041e-02f, 5.63595034e-02f, -3.35862972e-02f, 1.28380775e-01f, 5.51959127e-02f,
  -9.84448381e-03f, 8.85567740e-02f, 1.38710439e-01f, 3.67663130e-02f, -2.03108728e-01f, -1.01589501e-01f, 1.07226141e-01f, 6.54870495e-02f, 1.46293625e-01f, -9.60772187e-02f,
  -7.68184662e-02f, -9.54566523e-02f, -1.15795687e-01f, 3.61478887e-02f, -1.42914932e-02f, -4.63097133e-02f, 1.61207933e-02f, 6.09116144e-02f, 1.56684160e-01f, 1.44752964e-01f,
  -9.64541286e-02f, -8.78703520e-02f, 9.59530622e-02f, -8.42317417e-02f, 1.09248482e-01f, 8.08387436e-03f, -5.69899045e-02f, 1.31691366e-01f, 1.05375968e-01f, -8.87773782e-02f,
  -7.06512406e-02f, 1.58262610e-01f, 1.53799320e-03f, 8.33723396e-02f, -3.89047130e-03f, -3.50346752e-02f, 1.26515046e-01f, 3.14267948e-02f, -5.78193031e-02f, -4.12461571e-02f,
  4.45875227e-02f, -2.59131230e-02f, -5.28992563e-02f, 1.34503186e-01f, -8.63435268e-02f, 2.63629458e-03f, -1.16705932e-01f, -1.22144304e-01f, -2.44080126e-02f, -1.14329256e-01f,
  9.67157111e-02f, 1.17891476e-01f, -8.30756649e-02f, 1.17339693e-01f, -6.81519210e-02f, 1.37346741e-02f, 3.66322584e-02f, -6.48534745e-02f, 1.68134551e-02f, 1.02673851e-01f,
  -4.35020663e-02f, -7.33886734e-02f, 1.29263457e-02f, 6.27866387e-02f, -2.25623287e-02f, -2.16018762e-02f, -1.05531737e-02f, 7.75461271e-02f, 1.09986082e-01f, -1.61728133e-02f,
  -7.28945583e-02f, -4.67130467e-02f, 7.08934963e-02f, -2.07091682e-02f, -1.35046497e-01f, -4.43038605e-02f, -1.02909498e-01f, -3.95105891e-02f, 1.27718836e-01f, 7.51601085e-02f,
  1.48866087e-01f, 3.51222754e-02f, -2.36271713e-02f, 1.03709593e-01f, -1.36808962e-01f, -1.18843734e-01f, 5.52236699e-02f, 3.60463448e-02f, 1.27019912e-01f, 4.18726914e-02f,
  5.56998886e-02f, 1.60622261e-02f, 1.14975460e-01f, 1.83519781e-01f, 1.34640664e-01f, -2.03655481e-01f, -2.12626800e-01f, -2.05957249e-01f, 2.34939046e-02f, 1.13003686e-01f,
  2.61583962e-02f, -1.81114692e-02f, 7.97204450e-02f, -5.78979356e-03f, -8.61190930e-02f, 6.70670643e-02f, 6.61613867e-02f, -3.42079327e-02f, 5.63197955e-02f, 1.35833666e-01f,
  1.13062738e-02f, 1.46243140e-01f, -1.53748249e-03f, 8.22056755e-02f, -1.23956792e-01f, 5.50030209e-02f, -7.55462795e-02f, -2.06369460e-02f, 1.02005713e-01f, -2.33312603e-02f,
  -6.26664385e-02f, -3.72939520e-02f, 9.14291665e-03f, 3.28418277e-02f, 4.51402478e-02f, -1.31876335e-01f, -2.96571739e-02f, -7.67131522e-02f, 8.84198919e-02f, 8.74879807e-02f,
  -6.56757057e-02f, 1.88740939e-02f, -1.56844761e-02f, -1.30457401e-01f, -7.45497644e-02f, -8.94282758e-02f, -7.97681734e-02f, 1.80780888e-02f, 1.40341863e-01f, -8.49995539e-02f,
  -1.58765784e-03f, 2.06021145e-02f, -1.38652753e-02f, -1.17841162e-01f, -1.36636719e-01f, 4.21589352e-02f, 6.46259822e-03f, 6.11356385e-02f, -2.00881466e-01f, -6.34940388e-03f,
  -3.53459083e-02f, -4.91668545e-02f, -5.32378666e-02f, -6.93696365e-03f, -8.40870440e-02f, -7.34592155e-02f, 1.10079601e-01f, 1.17368929e-01f, -1.23752497e-01f, -1.94508687e-01f,
  -6.02617487e-02f, -2.12349981e-01f, 7.01259077e-02f, 2.66555673e-03f, 1.00047871e-01f, 7.08533525e-02f, 9.63217095e-02f, 7.32368380e-02f, 3.66805419e-02f, -2.68797297e-02f,
  -6.34666383e-02f, 8.68474878e-03f, 5.46784289e-02f, 1.94744900e-01f, 5.94704188e-02f, 1.22625761e-01f, -2.12701224e-02f, 1.02967568e-01f, 1.01110414e-01f, 9.73688737e-02f,
  3.41378860e-02f, 7.32645169e-02f, 2.98009142e-02f, -2.46295072e-02f, 2.09722985e-02f, -9.86416172e-03f, 9.09331441e-02f, 1.07434899e-01f, -9.69620887e-03f, -7.50478683e-03f,
  4.14321870e-02f, -9.08125564e-02f, 7.91508332e-02f, -7.55126998e-02f, 6.25751214e-03f, 3.77602316e-02f, 1.18397981e-01f, -7.24744648e-02f, -1.22178383e-01f, -6.44455850e-02f,
  2.74803452e-02f, -1.52650014e-01f, 7.77282193e-02f, 4.93332893e-02f, 3.45771015e-02f, 9.08729713e-03f, -1.35940284e-01f, 3.56848463e-02f, -1.13983266e-01f, -5.24410345e-02f,
  3.38413119e-02f, -6.19519949e-02f, 6.55109212e-02f, -3.34025882e-02f, 4.89285998e-02f, -1.05725877e-01f, 1.93398502e-02f, -7.63982832e-02f, 6.33509606e-02f, -4.67630327e-02f,
  6.77083433e-02f, -1.69783104e-02f, -6.01650514e-02f, -1.24540515e-01f, -7.79430047e-02f, -7.94929489e-02f, 1.32615462e-01f, -5.44441789e-02f, 4.93110605e-02f, -2.39003766e-02f,
  6.75035641e-02f, 1.56103447e-01f, -1.10339988e-02f, -1.47505207e-02f, 1.64775625e-01f, -4.51623909e-02f, -4.64119352e-02f, 1.17956236e-01f, 1.94064572e-01f, 1.09215096e-01f,
  -1.11342389e-02f, 1.38466120e-01f, 2.59471033e-02f, -9.82666016e-02f, 2.53336206e-02f, 1.08003169e-01f, 1.13955371e-01f, -9.81911197e-02f, 3.05060875e-02f, 6.06697612e-02f,
  2.56865267e-02f, 6.45507351e-02f, -5.64787164e-03f, -1.94577947e-02f, 5.19526303e-02f, 5.91966584e-02f, 2.91018561e-02f, 4.55361307e-02f, -8.76913369e-02f, 1.48338899e-01f,
  5.43606728e-02f, -1.19834214e-01f, 1.96465831e-02f, -2.82048751e-02f, -7.49028772e-02f, 5.01474589e-02f, -2.63949148e-02f, -6.91249222e-02f, -1.25053292e-02f, -2.39488371e-02f,
  6.59062117e-02f, -1.41382441e-01f, 1.18738540e-01f, -6.08045384e-02f, -3.05632465e-02f, 1.69925671e-02f, -1.37309119e-01f, -4.00049649e-02f, 1.19693488e-01f, 3.64872217e-02f,
  1.21182106e-01f, 1.18417427e-01f, 1.13420270e-01f, -5.65293916e-02f, 1.11620799e-01f, 1.53074086e-01f, -1.48020968e-01f, -1.85957447e-01f, 4.16093282e-02f, 1.39685228e-01f,
  1.21423937e-01f, 1.81240916e-01f, -8.05633366e-02f, 1.77785251e-02f, -7.97746256e-02f, 1.39828712e-01f, -1.06977113e-01f, -7.50377923e-02f, 1.85442213e-02f, -1.17182620e-01f,
  5.15137948e-02f, 9.71240029e-02f, 1.77932322e-01f, -8.58675018e-02f, -4.93839271e-02f, 1.43950850e-01f, -6.26356225e-04f, -2.49568205e-02f, 1.15336776e-02f, -1.41324356e-01f,
  -6.05671108e-02f, -2.44025532e-02f, 2.20458899e-02f, -3.24199651e-03f, 8.29893276e-02f, -5.83703257e-02f, -4.25955504e-02f, -1.22141011e-01f, -7.94327706e-02f, 2.04653800e-01f,
  -7.97856301e-02f, -3.18168700e-02f, -5.19299805e-02f, 8.96042585e-02f, 6.26057088e-02f, -2.01278199e-02f, 1.39037892e-01f, -3.69907133e-02f, 6.03965968e-02f, 7.05073848e-02f,
  1.19142450e-01f, -2.25171503e-02f, 3.31419259e-02f, -7.26112351e-02f, -2.97372192e-02f, 1.24554344e-01f, 4.10830341e-02f, 1.29415005e-01f, 2.17717625e-02f, 8.45123380e-02f,
  -2.93170605e-02f, 1.00978687e-01f, -3.15679908e-02f, 5.52833825e-02f, -1.26255691e-01f, 5.57250865e-02f, 9.27874371e-02f, 2.19276194e-02f, -1.33340776e-01f, 6.10409528e-02f,
  3.90379913e-02f, 1.28723904e-01f, 3.15594636e-02f, -4.58831564e-02f, -6.16083927e-02f, 1.29585098e-02f, 1.32528096e-01f, 1.65360510e-01f, 9.70674492e-03f, 1.52935922e-01f,
  1.21586971e-01f, 2.74287090e-02f, -1.47935683e-02f, 5.24519794e-02f, 1.01937994e-01f, 4.41726260e-02f, 1.46448523e-01f, -4.09972630e-02f, 4.61261570e-02f, -1.93532333e-02f,
  2.62169857e-02f, 6.51574135e-02f, 1.07103057e-01f, 1.62675172e-01f, 5.78969456e-02f, -2.23800335e-02f, 6.40276670e-02f, -4.17729802e-02f, -4.96088974e-02f, -2.59445254e-02f,
  3.65153961e-02f, 2.15201918e-02f, 1.41649451e-02f, -1.43482953e-01f, 9.19956192e-02f, 3.91430520e-02f, 1.05543420e-01f, 3.33059281e-02f, 1.25258744e-01f, -7.02468902e-02f,
  -1.23423062e-01f, -9.09453630e-02f, 1.37848318e-01f, 9.36403796e-02f, -9.44813713e-02f, 9.25368145e-02f, 5.11249295e-03f, -6.00708984e-02f, 1.17153801e-01f, -8.64161626e-02f,
  -1.07626893e-01f, 7.06668794e-02f, 1.41693234e-01f, -8.89375210e-02f, 1.59672171e-01f, 4.52414379e-02f, -7.97043741e-03f, -1.38314310e-02f, 9.29869637e-02f, 5.62959984e-02f,
  5.25292605e-02f, -5.73606938e-02f, -9.39824581e-02f, 3.73723246e-02f, 2.46979184e-02f, 8.21592472e-03f, 1.07792035e-01f, 1.25357077e-01f, 7.63640553e-02f, -1.49234220e-01f,
  4.03685272e-02f, -1.14789642e-02f, -1.07038826e-01f, -2.89569944e-02f, -5.23243658e-02f, -1.10856734e-01f, 4.58385572e-02f, -1.29172191e-01f, -7.98182562e-03f, -4.20479383e-03f,
  -3.33177485e-02f, -1.49452433e-01f, -9.08710435e-03f, -7.46060610e-02f, 1.78911798e-02f, 8.07778910e-02f, 2.43628956e-02f, 5.18864579e-02f, 8.31936523e-02f, -7.92010352e-02f,
  2.63955817e-02f, -6.10515475e-02f, -9.34520215e-02f, 1.15217105e-01f, 3.34679522e-02f, 5.81237376e-02f, -2.65863035e-02f, 7.00377673e-02f, 6.25618845e-02f, -1.11565240e-01f,
  -7.65556172e-02f, 7.33579844e-02f, 1.78648904e-02f, -9.22653303e-02f, 2.49066520e-02f, 7.71751478e-02f, 1.07227355e-01f, 6.12627380e-02f, 8.30409750e-02f, -4.19403054e-02f,
  -1.09837830e-01f, 1.29452035e-01f, 7.43072331e-02f, 6.09783642e-02f, 3.74934413e-02f, -9.30856839e-02f, -6.24436103e-02f, -1.39889438e-02f, 1.37589663e-01f, -4.35490534e-02f,
  9.55167487e-02f, 2.13800669e-01f, 1.08297266e-01f, 2.12145761e-01f, 8.80298689e-02f, 2.43010268e-01f, -9.42582116e-02f, 2.47846678e-01f, 1.97575644e-01f, -5.18984236e-02f,
  -1.22790881e-01f, -2.40440145e-02f, 2.01121531e-02f, 8.90567899e-02f, -1.90819725e-01f, 3.68511714e-02f, 9.30408761e-02f, 7.42449313e-02f, -4.61227521e-02f, 8.51791054e-02f,
  -4.41792682e-02f, -8.32540840e-02f, 6.33444116e-02f, 6.88672215e-02f, -4.62657399e-02f, 1.22660799e-02f, 8.85237977e-02f, -2.82248314e-02f, 9.93849337e-02f, 6.01279326e-02f,
  7.42443129e-02f, -7.21621811e-02f, 9.09533873e-02f, -4.44278494e-02f, 5.89225031e-02f, -7.46129230e-02f, -2.80921981e-02f, 5.41066518e-03f, 6.87825754e-02f, -1.21246122e-01f,
  -6.65131137e-02f, -1.16536422e-02f, 1.26496777e-01f, -6.38573319e-02f, 7.96690062e-02f, -4.25288267e-02f, -4.60752696e-02f, 1.11202411e-01f, -8.64356458e-02f, 1.16896264e-01f,
  -8.34734216e-02f, 9.74346101e-02f, 2.34006509e-01f, 1.78223819e-01f, -3.80859710e-02f, -1.75737321e-01f, -1.64578389e-02f, 4.78052311e-02f, -1.24568962e-01f, 6.25528470e-02f,
  -1.06130891e-01f, 1.58505842e-01f, 1.34393856e-01f, 5.08006141e-02f, 4.00864257e-04f, -4.41715345e-02f, 1.32059623e-02f, -5.51086701e-02f, 1.50021957e-03f, -4.90877889e-02f,
  -1.26464099e-01f, 7.34731182e-02f, -9.14556980e-02f, 5.86860022e-03f, 7.61221498e-02f, -5.28726131e-02f, -2.28066500e-02f, 6.13824464e-02f, 7.64660612e-02f, 3.10760234e-02f,
  8.26874524e-02f, 4.53565530e-02f, -5.88406203e-03f, -8.19710344e-02f, -6.50156885e-02f, 3.64110433e-02f, 1.05375350e-01f, -1.25627413e-01f, -1.15482710e-01f, 1.66993752e-01f,
  1.00501083e-01f, -1.02389857e-01f, 5.27559966e-02f, 4.16498195e-04f, -1.84370205e-02f, -8.70618150e-02f, -6.94589168e-02f, -5.14054708e-02f, 9.06317383e-02f, -5.07666729e-02f,
  7.24792704e-02f, 2.25636736e-02f, -1.51689060e-03f, -7.96122774e-02f, -1.09585062e-01f, 8.38502571e-02f, -1.09538054e-02f, 8.48514736e-02f, 6.12486787e-02f, -6.57138228e-02f,
  -4.44425941e-02f, 1.11794583e-02f, 3.31765972e-02f, -2.59920880e-02f, 9.44774747e-02f, -8.93922448e-02f, -3.93901914e-02f, 6.01758398e-02f, 6.68263286e-02f, -3.32633033e-02f,
  -6.02937378e-02f, -1.30887255e-01f, 8.51509646e-02f, 8.33298340e-02f, 5.85624091e-02f, 1.15801848e-01f, 1.94712088e-01f, -4.69969139e-02f, 5.78894466e-02f, 1.41644046e-01f,
  3.14821973e-02f, 1.40909001e-01f, 7.57990703e-02f, 1.41090631e-01f, 4.34955722e-03f, -1.76033244e-01f, 6.91933706e-02f, 1.30308177e-02f, -7.81402737e-03f, 2.02173993e-01f,
  6.04266068e-03f, -1.30764648e-01f, 1.47296432e-02f, 1.00522660e-01f, -1.28152221e-01f, -3.18595655e-02f, 4.82373387e-02f, -2.25235298e-01f, 2.86864256e-03f, -1.15793534e-01f,
  -6.23203851e-02f, 1.18324749e-01f, 5.01168631e-02f, 9.62491147e-03f, 3.71483229e-02f, -3.12782861e-02f, 1.78343356e-01f, 1.05973832e-01f, 9.12218392e-02f, -1.09365337e-01f,
  1.78208426e-01f, 5.31293787e-02f, -1.51870986e-02f, 1.18301205e-01f, 4.52119224e-02f, 2.15213858e-02f, -4.37692292e-02f, 2.80101243e-02f, -5.37046045e-03f, 6.10231198e-02f,
  1.08356215e-01f, -8.97813961e-02f, 7.91925862e-02f, -1.98628120e-02f, 6.19634474e-03f, -9.37463194e-02f, 2.00912833e-01f, -9.40431654e-02f, 1.20463431e-01f, 1.15685657e-01f,
  1.90178934e-03f, 8.81787017e-02f, 1.89332426e-01f, 2.55218353e-02f, 1.10309780e-01f, -1.28740296e-01f, 6.10049106e-02f, -1.50004759e-01f, 5.27065359e-02f, -6.95544034e-02f,
  1.37857616e-01f, -1.50985509e-01f, 1.46873638e-01f, 1.40860379e-01f, 1.07670046e-01f, -2.05088481e-02f, 1.01633541e-01f, -3.11377067e-02f, 1.79453477e-01f, 2.52389163e-01f,
  -1.64633706e-01f, -5.85782342e-02f, -1.65103301e-01f, -6.98546171e-02f, 3.08601465e-02f, -1.59732014e-01f, -7.13721067e-02f, 6.85160458e-02f, 2.09060803e-01f, -7.61210695e-02f,
  -7.04794303e-02f, -2.32186560e-02f, -7.04763904e-02f, -7.79926106e-02f, -9.25971568e-03f, 1.16526976e-01f, -8.49817097e-02f, 1.23708718e-01f, 1.07307985e-01f, 1.65955335e-01f,
  6.91415742e-02f, 7.79125094e-02f, 9.40553006e-03f, 9.65453088e-02f, 1.44776419e-01f, -1.04843661e-01f, 1.55400947e-01f, -3.86395976e-02f, -1.25626335e-02f, 6.75932467e-02f,
  -9.68029276e-02f, -1.11859031e-01f, -1.24477737e-01f, 1.98553115e-01f, 1.77686159e-02f, 1.48359567e-01f, -1.19354956e-01f, 8.53997748e-03f, 1.41367167e-02f, 1.18009951e-02f,
  -1.51632339e-01f, 4.50122729e-02f, 2.27613896e-02f, 5.20053245e-02f, 2.15165064e-01f, 1.83259755e-01f, -1.13720998e-01f, -1.14512652e-01f, -2.63911462e-03f, -1.19265094e-01f,
  -1.40378460e-01f, -7.07056299e-02f, 1.68583289e-01f, 1.70446470e-01f, 3.43291014e-02f, 1.02599025e-01f, 1.34533778e-01f, -5.29791377e-02f, 9.32402350e-03f, -1.11814691e-02f,
  3.64755467e-02f, 4.57834313e-03f, -1.32836804e-01f, -5.18960282e-02f, 3.38608883e-02f, 5.25300913e-02f, 1.15283276e-03f, 7.03758076e-02f, -8.78391713e-02f, 6.84493333e-02f,
  3.62190604e-02f, 2.32563610e-03f, 2.42668036e-02f, -1.04491241e-01f, 1.06577300e-01f, -1.05310738e-01f, -8.67434591e-02f, -1.06802890e-02f, 1.04427906e-02f, 1.37359127e-01f,
  -7.11216554e-02f, 8.61840770e-02f, -9.90120322e-02f, 6.11895248e-02f, -1.33088008e-02f, -6.51281103e-02f, -1.14876823e-02f, -6.70416513e-03f, 1.08874235e-02f, -1.35302795e-02f,
  -4.03320901e-02f, 7.22854361e-02f, -1.23417526e-01f, -2.02927385e-02f, 8.40569064e-02f, 1.17831610e-01f, 1.14423700e-01f, 6.58987835e-02f, 5.36528490e-02f, 2.62134173e-03f,
  8.06065574e-02f, -1.47999069e-02f, -4.50706966e-02f, -6.09236918e-02f, 1.59315951e-02f, -2.03454234e-02f, -9.77102816e-02f, -1.29651772e-02f, -8.24196637e-02f, -5.16087748e-02f,
  -8.50982666e-02f, 7.95890763e-02f, 9.21471417e-02f, -5.49591146e-02f, 2.97495089e-02f, -9.70673487e-02f, 3.06674186e-02f, 4.65271212e-02f, -4.51084599e-02f, 1.02289826e-01f,
  1.58719271e-01f, 1.85575619e-01f, 2.31624648e-01f, 2.39667416e-01f, 1.95707664e-01f, 9.66482610e-02f, 1.42590970e-01f, 8.62324238e-02f, 8.74669105e-02f, -4.44158204e-02f,
  -2.90891707e-01f, 2.61419624e-01f, 3.93031817e-03f, 2.35415891e-01f, -8.71164501e-02f, 1.00873701e-01f, 6.97907954e-02f, -1.75902639e-02f, -1.21324807e-01f, -7.00609060e-03f,
  1.16885193e-01f, -9.72484425e-02f, -1.14912866e-02f, -4.32479344e-02f, 2.81655371e-01f, -2.45705679e-01f, -3.38784792e-02f, 1.18255697e-01f, 1.99893221e-01f, -1.12355657e-01f,
  3.65801752e-02f, -1.09848334e-02f, 1.03148483e-01f, -9.00918022e-02f, -4.17456627e-02f, -1.15570940e-01f, 5.44314124e-02f, 1.64003998e-01f, 7.80400634e-02f, -1.38227075e-01f,
  -1.03384070e-01f, 4.12331104e-01f, -9.68092084e-02f, -2.73150522e-02f, 9.00116712e-02f, -6.41814023e-02f, -1.80753380e-01f, -2.53359154e-02f, 3.01237106e-01f, 1.75660372e-01f,
  -8.58381912e-02f, 2.92828023e-01f, 2.09138021e-01f, 1.66179761e-01f, 1.09325059e-01f, 8.36156830e-02f, -3.88508700e-02f, 1.39596373e-01f, -1.90930009e-01f, -9.98800248e-02f,
  -3.14351171e-02f, 1.73274502e-01f, -1.32152066e-01f, 2.10313760e-02f, 8.80473256e-02f, 1.58990428e-01f, 1.98986679e-01f, 4.84281145e-02f, 1.87742785e-01f, -6.69526085e-02f,
  -1.45969614e-02f, -1.28384903e-01f, -1.39976293e-01f, -2.26866212e-02f, -1.42523646e-01f, 1.96499974e-01f, 4.94651916e-03f, -4.73255711e-03f, -3.07298452e-02f, -1.31321826e-03f,
  5.32723330e-02f, -6.61042519e-03f, -1.57635823e-01f, 5.67734838e-02f, 7.31703192e-02f, -6.12561498e-03f, -1.71438642e-02f, -8.28923509e-02f, 8.89732130e-03f, -1.50152117e-01f,
  1.84172839e-02f, 1.49571076e-01f, 6.96922988e-02f, 1.65050738e-02f, 1.88740402e-01f, -1.04475982e-01f, -1.89803529e-03f, -7.06332400e-02f, 6.01002946e-02f, 1.26983542e-02f,
  1.21823601e-01f, 6.22492330e-03f, 3.19706798e-02f, -4.04096507e-02f, -7.83706531e-02f, 6.49334118e-02f, 2.76156347e-02f, 6.33934736e-02f, -6.82621226e-02f, 4.50226627e-02f,
  -1.47884622e-01f, 1.96073437e-03f, 2.39334479e-01f, 6.44299015e-02f, 1.38766065e-01f, 1.29732415e-01f, 1.88468233e-01f, 5.80470711e-02f, 2.92886309e-02f, 1.81953356e-01f,
  1.29033208e-01f, -3.77681740e-02f, 7.89552256e-02f, -7.82165676e-02f, -7.86745995e-02f, -7.46647874e-03f, 8.66355821e-02f, 4.72365580e-02f, 1.35426328e-01f, 1.13794291e-02f,
  2.40035072e-01f, 3.24798785e-02f, 1.27034694e-01f, 1.26622394e-01f, 4.67325449e-02f, -9.09337252e-02f, -5.10629863e-02f, 1.32730350e-01f, 6.35809600e-02f, -1.28240839e-01f,
  -5.52599728e-02f, -2.21707821e-02f, 1.02172010e-01f, 1.27310632e-02f, -1.11965425e-01f, 1.93471074e-01f, 5.83673567e-02f, 1.78934589e-01f, 6.77579790e-02f, 7.74019361e-02f,
  9.57434550e-02f, 2.32996196e-02f, -5.89384846e-02f, 2.75254697e-01f, 2.19323143e-01f, 2.04504445e-01f, 7.75227696e-02f, -5.31218573e-02f, -3.13999094e-02f, 9.73885730e-02f,
  1.65079936e-01f, 9.00299251e-02f, 1.47364333e-01f, -1.03657104e-01f, 1.17618516e-01f, 5.81441782e-02f, -7.27356551e-03f, -4.60854126e-03f, 6.65168837e-02f, 9.77013186e-02f,
  2.26975694e-01f, 1.65317044e-01f, -1.37335986e-01f, 3.54847114e-04f, 1.59565479e-01f, 1.49262980e-01f, -1.53702512e-01f, 9.82815921e-02f, -2.70315744e-02f, -1.92966849e-01f,
  7.09834248e-02f, 1.13432445e-01f, -1.53244868e-01f, -5.57875931e-02f, 1.55711800e-01f, 4.89402860e-02f, 2.34399319e-01f, 9.89578068e-02f, 2.30542794e-01f, 1.32170483e-01f,
  2.88923115e-01f, 7.56456330e-02f, 5.51529340e-02f, 3.23040336e-02f, -1.51103213e-02f, 8.44215378e-02f, 3.02541386e-02f, -2.38454118e-02f, 1.15167946e-01f, 3.07254214e-02f,
  -2.63093024e-01f, 6.09172173e-02f, 1.51231334e-01f, -1.53847426e-01f, 6.94963038e-02f, 7.76453018e-02f, 9.48868170e-02f, 8.59793127e-02f, 1.41447216e-01f, 7.17605874e-02f,
  6.96341321e-02f, 1.35929838e-01f, 1.27742544e-01f, 1.85872570e-01f, 1.19380774e-02f, 2.95495726e-02f, -7.94256702e-02f, 1.75249785e-01f, -7.17278942e-02f, 4.83859777e-02f,
  6.88635707e-02f, -5.51220868e-03f, -9.23302472e-02f, 1.79863244e-01f, 1.09614156e-01f, -1.82523038e-02f, 1.37949809e-01f, 3.52227502e-02f, -1.33676097e-01f, -4.14981209e-02f,
  -1.42200351e-01f, 1.05725452e-01f, 8.88043828e-03f, 3.64764221e-02f, -4.26123701e-02f, -3.08565539e-03f, 9.12074819e-02f, 1.18796147e-01f, -1.65614523e-02f, 4.17536795e-02f,
  4.29959446e-02f, -1.29240170e-01f, 1.58863738e-01f, -1.48549587e-01f, 1.17445834e-01f, -1.31970152e-01f, -1.46495223e-01f, 1.46617100e-01f, 6.34644032e-02f, -1.19563594e-01f,
  1.15418613e-01f, -5.34338318e-02f, 2.47870952e-01f, -1.38923660e-01f, -1.59140810e-01f, -8.78366753e-02f, -6.54353717e-05f, -5.17511927e-02f, 8.39768574e-02f, -1.46275777e-02f,
  -1.61604118e-02f, -1.25329718e-01f, 1.03092007e-01f, 5.08432612e-02f, 8.41379464e-02f, 2.17820536e-02f, -5.38916513e-02f, -8.59406069e-02f, 8.20712373e-02f, 1.15557909e-02f,
  -8.93925354e-02f, 2.41463799e-02f, -6.87505752e-02f, -1.06153756e-01f, -5.66920005e-02f, -4.91901785e-02f, -6.77321153e-03f, -6.24155924e-02f, 7.57869259e-02f, 7.74660483e-02f,
  2.85747629e-02f, -7.21896961e-02f, -7.35285357e-02f, -4.28639306e-03f, -1.10800736e-01f, -6.95217028e-02f, -1.20683694e-02f, 1.16553739e-01f, 6.72701970e-02f, 7.70620927e-02f,
  1.24279931e-02f, 7.29206502e-02f, -6.28117099e-02f, -1.22571208e-01f, 1.14780881e-01f, 1.28691513e-02f, -3.44276726e-02f, 2.97011677e-02f, -7.69630820e-02f, 3.46121602e-02f,
  2.22114637e-03f, -4.51046750e-02f, 4.22223024e-02f, -1.19639985e-01f, 7.47475252e-02f, 9.60777178e-02f, 6.07515462e-02f, -8.76366273e-02f, -3.15089040e-02f, 1.28325701e-01f,
  -6.41683713e-02f, 1.06125750e-01f, 2.98471171e-02f, 1.06261201e-01f, 2.97401026e-02f, 4.50920053e-02f, -7.46390820e-02f, 4.98606190e-02f, 4.20465209e-02f, -7.04837367e-02f,
  4.16422933e-02f, 1.28686413e-01f, 6.79459423e-02f, 1.92054838e-01f, 5.15359603e-02f, 6.59601167e-02f, 1.63157791e-01f, 4.49891053e-02f, 1.17871603e-02f, -1.50026664e-01f,
  -1.81239262e-01f, -1.03678793e-01f, -1.42077997e-03f, 4.88097295e-02f, -9.04583186e-02f, -1.07851001e-02f, 2.18730330e-01f, -8.39778334e-02f, 1.57803848e-01f, 9.14516076e-02f,
  6.12736568e-02f, 2.98343338e-02f, -4.42540199e-02f, 1.98182583e-01f, 7.75117241e-03f, -5.48880771e-02f, -1.50736445e-03f, -5.47453836e-02f, 2.37031523e-02f, -1.03660770e-01f,
  1.44366965e-01f, 1.67741477e-01f, -1.81340948e-02f, 2.37420648e-02f, -1.90462451e-02f, -1.27970623e-02f, 7.66900331e-02f, -5.19172996e-02f, -1.09276019e-01f, -9.27489251e-02f,
  2.71730814e-02f, 9.83924791e-02f, 1.17346354e-01f, -5.90186827e-02f, -3.02586984e-02f, -4.75834031e-03f, -3.87969078e-04f, -7.48697221e-02f, 3.27106640e-02f, -5.70937768e-02f,
  -1.60352569e-02f, 7.14230118e-04f, -2.06097160e-02f, 1.31598443e-01f, -5.90596581e-03f, 1.57139860e-02f, 8.67041498e-02f, -1.20633304e-01f, -1.16957590e-01f, 7.43394792e-02f,
  1.84951380e-01f, -7.12777451e-02f, -1.56352639e-01f, -6.61240816e-02f, 1.71381623e-01f, 9.48923081e-02f, -2.68779881e-03f, 2.71754086e-01f, 2.33254328e-01f, 6.63328692e-02f,
  3.17633718e-01f, 6.26397356e-02f, -2.61914611e-01f, -1.27777606e-01f, -7.59632066e-02f, -1.13236360e-01f, 1.15483314e-01f, 1.08251989e-01f, -8.88222754e-02f, 9.45367888e-02f,
  9.10564810e-02f, -2.11585928e-02f, 1.86213672e-01f, 2.30148777e-01f, 1.82378590e-01f, -4.13972363e-02f, -4.25894894e-02f, -2.56027430e-02f, -2.76615750e-02f, -4.66208123e-02f,
  3.46523114e-02f, 1.66449517e-01f, -8.09067413e-02f, 1.03503123e-01f, 5.30560762e-02f, 3.16077709e-01f, -8.05056840e-02f, 9.61124599e-02f, 1.59728646e-01f, 1.08055495e-01f,
  -1.54499218e-01f, -6.69506565e-02f, 1.02227665e-01f, -1.19789638e-01f, -5.88039085e-02f, 5.77977784e-02f, 1.31978020e-01f, 9.09440815e-02f, 1.60556853e-01f, 1.39530167e-01f,
  -4.76806015e-02f, -1.18567087e-01f, 4.01137061e-02f, 1.36225328e-01f, 1.26733527e-01f, -1.06051236e-01f, 3.34708542e-02f, 1.15351163e-01f, 8.38089641e-03f, -6.18812330e-02f,
  -6.98983669e-02f, -4.63298857e-02f, 9.65721384e-02f, 1.71614930e-01f, 2.69233197e-01f, 5.55838495e-02f, -1.92238346e-01f, 1.52039483e-01f, -8.79959166e-02f, 1.57445848e-01f,
  1.01437069e-01f, 1.93892717e-01f, 7.99834952e-02f, -4.71324548e-02f, 1.55338466e-01f, 6.12091906e-02f, 1.53269561e-03f, -1.15113482e-01f, -1.54228330e-01f, -6.76035210e-02f,
  -4.29367311e-02f, -1.50303632e-01f, 2.38664611e-03f, -6.00977242e-02f, 3.78851383e-03f, 7.10453540e-02f, -1.49524465e-01f, 3.29299569e-02f, 1.11032344e-01f, 4.49479138e-03f,
  1.40890807e-01f, 2.53186356e-02f, -5.93014574e-03f, -5.58366999e-02f, 2.17034101e-01f, 7.83340037e-02f, -1.53810112e-02f, -1.41047001e-01f, -1.72253679e-02f, 2.90243626e-02f,
  2.16452833e-02f, -5.13865948e-02f, -2.55995393e-02f, -2.45493874e-02f, 1.24139197e-01f, 1.22275971e-01f, 5.38015030e-02f, -8.89585689e-02f, -7.00589716e-02f, 2.79627949e-01f,
  -1.80329941e-02f, 1.53958842e-01f, -2.51226649e-02f, 1.76386982e-01f, 2.32533775e-02f, -4.27502766e-02f, -6.87676668e-02f, -1.64998751e-02f, 7.03275502e-02f, -9.10690129e-02f,
  1.89509600e-01f, 2.98875403e-02f, -9.81656685e-02f, 4.82041063e-03f, 1.26103669e-01f, 1.22451171e-01f, 1.26987174e-01f, 1.46302562e-02f, 1.21749096e-01f, 2.35048905e-01f,
  1.81998741e-02f, -1.47044107e-01f, 2.82380190e-02f, 8.90710652e-02f, 1.41587973e-01f, 1.30425796e-01f, 1.90083474e-01f, -2.83945594e-02f, 3.96621302e-02f, -1.64182913e-02f,
  -2.95164257e-01f, -2.72316206e-02f, -6.32673874e-02f, -1.00823686e-01f, 1.80255547e-01f, -4.71090451e-02f, 2.20583394e-01f, -1.12027023e-02f, -5.17901331e-02f, -2.20747330e-04f,
  2.04108045e-01f, 1.41045451e-01f, 1.16249537e-02f, 1.01837896e-01f, 4.61239964e-02f, -4.58496325e-02f, -5.68122938e-02f, -9.46749821e-02f, -8.94548744e-02f, -5.87263517e-02f,
  1.19439989e-01f, 7.56099895e-02f, 5.21292463e-02f, 2.30240345e-01f, -5.98080903e-02f, -4.02074046e-02f, 1.75730318e-01f, 4.79999073e-02f, -1.02182120e-01f, 7.76215419e-02f,
  8.78283530e-02f, -1.91115942e-02f, -3.61923873e-02f, -1.53962001e-01f, 9.73808840e-02f, -9.64142755e-02f, 8.07394534e-02f, 5.63190468e-02f, 1.51615202e-01f, -8.32617879e-02f,
  1.79030076e-01f, 1.99160520e-02f, 5.22476174e-02f, -2.84936782e-02f, 6.25023171e-02f, -6.58316538e-02f, 5.27768731e-02f, 5.35364784e-02f, 5.47674624e-03f, 5.52813597e-02f,
  2.19579116e-01f, -1.05527230e-01f, 3.07030499e-01f, -1.33687854e-01f, -1.28333643e-01f, 1.28663495e-01f, -6.08663261e-03f, 1.13637652e-03f, 1.20934516e-01f, 2.54222155e-01f,
  1.70278102e-01f, 3.14521819e-01f, -2.96902299e-01f, -2.98722565e-01f, 6.96546882e-02f, 3.00186817e-02f, -2.32663359e-02f, -4.45760712e-02f, -1.13571577e-01f, 1.67148918e-01f,
  3.70839268e-01f, -1.43553287e-01f, -6.63886964e-02f, -6.21177554e-02f, 1.52025372e-01f, 3.27013582e-01f, 1.08546227e-01f, 9.67673212e-03f, 4.97490242e-02f, -7.89112076e-02f,
  9.01948214e-02f, -1.55337090e-02f, -1.55560076e-01f, -1.46887796e-02f, 2.23793119e-01f, 2.38582984e-01f, -2.45392136e-02f, 9.60966051e-02f, 4.57438529e-02f, 1.65613607e-01f,
  5.11751808e-02f, -1.10056020e-01f, -8.50446001e-02f, 1.58672079e-01f, -1.33176208e-01f, 2.97723800e-01f, 9.88879800e-02f, -1.38529718e-01f, 2.79993843e-02f, 9.33884010e-02f,
  -5.93444146e-02f, 7.00019822e-02f, 1.27627760e-01f, 2.30584800e-01f, -8.09220597e-02f, 1.60977356e-02f, -7.84778371e-02f, -1.74862314e-02f, -1.50828376e-01f, -1.83655411e-01f,
  -8.72658864e-02f, 1.52080849e-01f, 9.47813317e-02f, 2.46105313e-01f, 2.90539742e-01f, -5.52817211e-02f, 1.43042067e-02f, -1.09459415e-01f, 1.74271297e-02f, 2.02672392e-01f,
  -3.82827148e-02f, -2.89661996e-02f, 1.59553066e-01f, 1.89738229e-01f, 1.81984752e-01f, 3.57143804e-02f, 9.77634266e-02f, -6.20456412e-02f, -4.32189628e-02f, -8.57509822e-02f,
  -7.55074322e-02f, 2.00640574e-01f, 3.62789817e-02f, 7.92551264e-02f, -1.28608579e-02f, -8.49621817e-02f, -2.81046797e-02f, 3.46460491e-02f, -8.16779211e-02f, -1.50513634e-01f,
  -7.66350375e-03f, -1.46358684e-02f, -3.16898775e-04f, -1.25593049e-02f, 1.49221912e-01f, 1.01295616e-02f, 1.13914125e-01f, -5.51252700e-02f, 5.76612391e-02f, 1.12071395e-01f,
  1.35349901e-02f, -6.99745119e-02f, 3.04874852e-02f, 9.64665338e-02f, -9.63326916e-02f, 2.79979967e-02f, 3.59281674e-02f, 4.47823927e-02f, 5.96918277e-02f, -8.76837373e-02f,
  -1.08818777e-01f, 2.12611690e-01f, -5.40998243e-02f, -7.59758567e-03f, -5.54450005e-02f, -3.77375744e-02f, -1.28963083e-01f, -1.00673184e-01f, 2.03995720e-01f, 1.48588657e-01f,
  -4.92521822e-02f, 8.09454024e-02f, -2.37753568e-03f, -5.26358839e-03f, 9.03999582e-02f, -6.21224195e-02f, -5.23221344e-02f, 4.73542772e-02f, 4.09076065e-02f, 6.00265861e-02f,
  9.48311761e-04f, 1.10337250e-01f, -1.09270491e-01f, -7.55569488e-02f, 1.22386061e-01f, -4.18061092e-02f, -4.02291901e-02f, -1.36937527e-02f, -3.13282311e-02f, -1.13365419e-01f,
  6.52505532e-02f, 1.63286284e-01f, -1.14303716e-01f, -1.35644805e-02f, 2.40804218e-02f, -2.15179846e-01f, 7.22855181e-02f, -8.42653215e-02f, 1.29886359e-01f, 1.48478011e-02f,
  -1.78355854e-02f, 1.09785318e-01f, 1.40543640e-01f, 6.17044121e-02f, 7.66257942e-02f, 1.02173537e-02f, -5.96353784e-02f, 3.89742739e-02f, -2.70312130e-02f, 1.33679122e-01f,
  1.79944649e-01f, 1.61031678e-01f, 1.40941143e-01f, 7.09950365e-03f, 7.38041922e-02f, 1.08446680e-01f, 7.07625821e-02f, -6.94583282e-02f, 7.91661963e-02f, 3.37708741e-02f,
  -1.10817134e-01f, 1.08684428e-01f, 6.71643987e-02f, -2.62433593e-03f, -1.38677489e-02f, -2.34990567e-02f, 3.48292999e-02f, -4.58987802e-02f, -8.17799643e-02f, 1.53178200e-01f,
  1.71836659e-01f, -5.28723709e-02f, 6.36637285e-02f, 9.55399424e-02f, 9.84678939e-02f, -7.85188004e-02f, 7.31548518e-02f, -5.35168238e-02f, 1.72541570e-02f, -1.21090636e-01f,
  -1.01806097e-01f, -3.84225547e-02f, 4.74714078e-02f, 1.01727456e-01f, 7.91531876e-02f, 5.53179495e-02f, -6.01125173e-02f, 9.92051363e-02f, 7.31372312e-02f, -1.04578370e-02f,
  1.47666201e-01f, 1.21962838e-01f, -8.33192989e-02f, 9.11011919e-02f, 9.19515193e-02f, -5.45645505e-03f, -1.02702370e-02f, 5.27840108e-02f, 1.66686535e-01f, 1.27872691e-01f,
  1.26892805e-01f, -8.07523131e-02f, -3.56977619e-02f, -1.49835095e-01f, 1.99155081e-02f, 1.38024002e-01f, -1.04483940e-01f, -4.58963588e-02f, 6.81874099e-06f, 1.37595102e-01f,
  9.10842977e-03f, -2.28070095e-02f, -5.98422401e-02f, 2.31624827e-01f, 1.17098354e-01f, -9.91386995e-02f, -4.56526130e-02f, 9.26987901e-02f, 4.07278538e-02f, -1.38018429e-01f,
  7.94029832e-02f, -6.08764328e-02f, 1.35803267e-01f, -5.65304868e-02f, 1.45864844e-01f, -1.01278782e-01f, 5.06574661e-02f, 6.88369665e-03f, 2.54478846e-02f, -2.27676015e-02f,
  3.39725949e-02f, 1.50568023e-01f, 5.89748248e-02f, -4.45314422e-02f, 2.81002037e-02f, 2.48587709e-02f, -1.04648978e-01f, -1.82431545e-02f, -6.54630959e-02f, -1.19250730e-01f,
  1.08479083e-01f, 9.51170847e-02f, -1.34810746e-01f, -1.13206781e-01f, 1.68905556e-02f, 2.80923415e-02f, 1.23108216e-01f, 4.90995832e-02f, -2.51348168e-02f, 1.56034440e-01f,
  1.95315778e-01f, -1.53573453e-01f, 6.62234873e-02f, -1.38121456e-01f, -1.58524349e-01f, 1.09743111e-01f, -6.92626163e-02f, -7.45197386e-02f, -7.28132725e-02f, -5.64501202e-03f,
  3.96955647e-02f, -2.45694350e-02f, 5.44875227e-02f, 9.76743400e-02f, 7.29775503e-02f, -7.62903923e-03f, 1.37733355e-01f, -4.68794182e-02f, -7.07430616e-02f, 5.49302325e-02f,
  1.69688165e-01f, 1.26082480e-01f, 1.30449366e-02f, -7.26132691e-02f, 8.38186443e-02f, -1.20155856e-01f, -1.28480390e-01f, 5.83969476e-03f, -9.72222611e-02f, -1.60679128e-02f,
  4.87757958e-02f, -2.13680975e-03f, 8.82751793e-02f, 8.25006366e-02f, 9.71358791e-02f, 1.19127639e-01f, 9.10644233e-02f, 2.57313605e-02f, 7.22149611e-02f, 3.54730375e-02f,
  -1.33896559e-01f, 1.15779914e-01f, 1.35708779e-01f, -1.48262039e-01f, 8.65921006e-02f, 1.25127053e-02f, 3.28386128e-02f, 7.28596225e-02f, 1.54439732e-01f, -4.88034040e-02f,
  -8.33584964e-02f, 1.10857688e-01f, 1.11011811e-01f, 3.33248526e-02f, -1.22688174e-01f, 8.43922123e-02f, 7.43981674e-02f, -3.94403413e-02f, 2.79338341e-02f, -7.60624791e-03f,
  6.87725022e-02f, 7.52317011e-02f, 1.99669138e-01f, 1.05136290e-01f, 3.03790960e-02f, 1.54530080e-02f, 1.06234513e-02f, 6.13613315e-02f, 1.13578789e-01f, 7.64349848e-02f,
  3.59615199e-02f, 6.88476041e-02f, 7.31393322e-02f, -1.71717107e-02f, 5.44542149e-02f, -8.45909398e-03f, 1.70400709e-01f, 4.41626739e-03f, 2.25092918e-02f, -5.23194969e-02f,
  1.08141210e-02f, -1.13700338e-01f, -1.12857059e-01f, -9.57762823e-02f, 1.16324738e-01f, -9.79502574e-02f, -1.86229143e-02f, -3.44279525e-03f, 1.00482762e-01f, -1.02567218e-01f,
  -1.11443289e-01f, -1.55650973e-02f, -2.48007104e-03f, -3.20422947e-02f, 1.48284450e-01f, -4.05121893e-02f, 1.23920679e-01f, -1.49482423e-02f, 1.31434083e-01f, 3.73930633e-02f,
  -2.67789476e-02f, -8.22198167e-02f, -3.27397548e-02f, -6.46566376e-02f, 1.13003373e-01f, 1.80187002e-01f, 1.88998003e-02f, 4.58807833e-02f, -1.02244847e-01f, 4.00146767e-02f,
  7.27191269e-02f, 1.40245557e-01f, -9.24873874e-02f, 8.90543610e-02f, 1.43719781e-02f, 9.22643691e-02f, 1.28598958e-01f, -2.66880207e-02f, 5.67955012e-03f, -8.85410160e-02f,
  -1.09638534e-02f, -4.89854719e-03f, 8.22833478e-02f, 7.67105967e-02f, 5.88884540e-02f, 9.35169086e-02f, 5.51641509e-02f, -6.93357438e-02f, 9.90469605e-02f, -1.35511979e-01f,
  -5.54684363e-02f, -1.10919990e-01f, -1.16774458e-02f, -3.92812155e-02f, -3.89133804e-02f, -3.60488631e-02f, 4.11740281e-02f, 1.77085251e-01f, 4.20282297e-02f, -1.20092936e-01f,
  2.88026184e-02f, -4.56253178e-02f, -1.10541694e-01f, 1.12021014e-01f, -1.12184279e-01f, 2.52890438e-02f, 4.79881577e-02f, -6.91425577e-02f, -9.08334851e-02f, -2.70265862e-02f,
  4.69467677e-02f, 7.32851848e-02f, -7.04428256e-02f, 5.54239675e-02f, 7.49551505e-02f, 8.85737985e-02f, -2.96455752e-02f, -1.04183018e-01f, -1.45225763e-01f, 1.07665002e-01f,
  6.09127507e-02f, -5.70701621e-02f, -1.20291822e-01f, 9.34686065e-02f, -1.03326708e-01f, -1.21140085e-01f, -3.80534418e-02f, -3.11969034e-02f, 1.18264981e-01f, -5.74153382e-03f,
  1.22780867e-01f, -1.22007854e-01f, -6.08003400e-02f, -1.44268617e-01f, 1.03193028e-02f, -1.19859673e-01f, 1.46570923e-02f, -1.17506862e-01f, -8.39726925e-02f, -6.80516958e-02f,
  -2.75503267e-02f, 1.03113383e-01f, 8.16758722e-02f, 1.06994256e-01f, -4.00896557e-02f, 7.42260069e-02f, -7.54697695e-02f, -1.40797645e-01f, -1.58317432e-01f, -1.26581222e-01f,
  -1.39490336e-01f, -8.19758475e-02f, 2.34296527e-02f, 4.70874645e-02f, 7.91839734e-02f, 3.98653559e-02f, 1.81068107e-01f, 1.92385539e-01f, 1.80747926e-01f, 1.49105385e-01f,
  2.48618461e-02f, -1.31872341e-01f, 5.43833934e-02f, 2.10042283e-01f, 2.54570022e-02f, 3.65595147e-02f, -8.56231973e-02f, -1.89882927e-02f, 2.88580172e-02f, -3.21855545e-02f,
  -3.26166637e-02f, -7.09461644e-02f, -1.01108879e-01f, 3.56026404e-02f, -4.94079366e-02f, -1.70497335e-02f, -1.10978551e-01f, -5.05519025e-02f, -5.20533919e-02f, -5.28095029e-02f,
  -6.52130991e-02f, -1.02187708e-01f, 1.75137654e-01f, 9.58011523e-02f, 1.20282315e-01f, -7.28699714e-02f, 1.40717298e-01f, 5.34022786e-02f, -1.72045510e-02f, 1.61798060e-01f,
  2.29594242e-02f, 3.82951722e-02f, 1.29681572e-01f, 3.44637297e-02f, 1.11240841e-01f, 3.86337675e-02f, -8.49665329e-02f, 6.05110265e-02f, 1.03893884e-01f, 1.33095890e-01f,
  9.11143199e-02f, -3.73807885e-02f, -4.61156145e-02f, -9.36432853e-02f, -9.51635018e-02f, 2.92644296e-02f, -3.14648822e-02f, 8.32973607e-03f, -6.62368983e-02f, 1.62290648e-01f,
  1.99586079e-01f, -1.95968663e-03f, 3.34413610e-02f, 8.14535189e-03f, 1.42686173e-01f, 5.98445535e-02f, -4.12255302e-02f, -3.87927778e-02f, 8.54601935e-02f, 1.06376797e-01f,
  1.24363899e-01f, 6.81615854e-03f, 6.68004155e-02f, 2.93705761e-02f, 3.63078415e-02f, 1.03499234e-01f, -1.35409728e-01f, -2.13541597e-01f, -6.79356605e-02f, -9.94068459e-02f,
  7.11314678e-02f, 1.09179191e-01f, 1.43010676e-01f, -4.58757728e-02f, 1.04687348e-01f, 5.16815633e-02f, 4.53125797e-02f, 1.53335959e-01f, 1.74508646e-01f, 7.56471530e-02f,
  1.05500105e-03f, 8.43036026e-02f, 7.08567724e-02f, -6.09271526e-02f, -1.13325462e-01f, 6.86756670e-02f, 1.35800121e-02f, -7.79828615e-03f, 1.04852393e-01f, 7.33019710e-02f,
  6.82648495e-02f, 2.98714582e-02f, 1.17473856e-01f, -1.33196160e-01f, -1.35858580e-01f, 3.50764357e-02f, -3.99808548e-02f, -7.18360990e-02f, 8.12406242e-02f, -8.11736751e-03f,
  -3.92125659e-02f, 1.26532996e-02f, -1.51375448e-02f, 1.49774581e-01f, 1.91771731e-01f, -1.50887951e-01f, 4.31257524e-02f, -6.26668856e-02f, 7.26901293e-02f, 3.38841341e-02f,
  7.46046230e-02f, -9.56153274e-02f, 1.43560782e-01f, -3.32015306e-02f, -5.44656515e-02f, -1.47978351e-01f, 9.43439081e-03f, 1.70695297e-02f, 1.95956469e-01f, -5.56487590e-02f,
  -1.82194367e-01f, 1.01660624e-01f, 2.24735916e-01f, 2.59963013e-02f, 1.73912898e-01f, 1.32794812e-01f, 1.83383957e-01f, 2.30868738e-02f, -7.46213133e-04f, 1.99924514e-01f,
  1.96541950e-01f, -1.93761513e-01f, -5.69189563e-02f, -4.46392819e-02f, 4.45341580e-02f, 2.93714285e-01f, -1.79740310e-01f, 1.30989626e-01f, 1.16654292e-01f, 4.60019633e-02f,
  -3.58968251e-03f, 1.18655883e-01f, 3.43546905e-02f, -2.03738138e-01f, 1.25016302e-01f, 3.89482863e-02f, 2.53997058e-01f, 9.75945126e-03f, -1.18000351e-01f, -5.57777286e-02f,
  1.32840097e-01f, 1.18645988e-02f, -8.09623078e-02f, -9.67595056e-02f, 3.62230428e-02f, -4.89942096e-02f, -1.23203970e-01f, 5.50932959e-02f, -6.95924014e-02f, 4.78742719e-02f,
  3.53636034e-02f, 6.70641195e-04f, -4.64701280e-02f, 1.89978644e-01f, 1.16239022e-02f, 3.37835215e-02f, 1.09879792e-01f, -1.01616271e-01f, -1.01924151e-01f, -2.51378305e-02f,
  2.11560830e-01f, 6.80894330e-02f, -5.06150462e-02f, 2.29190126e-01f, -7.58682862e-02f, 1.53223008e-01f, 1.36240870e-01f, -9.86164883e-02f, 5.70808798e-02f, 1.34163037e-01f,
  -8.64689797e-02f, 1.43201903e-01f, -9.70192626e-02f, -2.81068273e-02f, -1.53067335e-01f, 1.73672035e-01f, 1.41988257e-02f, 1.10683978e-01f, 6.41736686e-02f, 1.84229925e-01f,
  -2.20623054e-02f, 4.85874824e-02f, -6.66061565e-02f, -7.88275301e-02f, 2.72177197e-02f, 1.34821802e-01f, -5.57455532e-02f, 2.02569708e-01f, -7.34338760e-02f, -4.57044281e-02f,
  1.22935019e-01f, -6.11745082e-02f, -1.07048415e-01f, 1.66036427e-01f, 2.76261009e-03f, 4.29733135e-02f, 2.28761271e-01f, 9.20896009e-02f, -1.12870738e-01f, -8.84825885e-02f,
  1.57741889e-01f, -1.14288572e-02f, -5.05249873e-02f, 2.21013688e-02f, 1.65259048e-01f, -3.73509005e-02f, 4.68478054e-02f, -1.46221042e-01f, 4.72081862e-02f, 8.29644203e-02f,
  8.80735591e-02f, 4.49371412e-02f, 1.09868869e-01f, 8.19879025e-02f, 1.47707731e-01f, 1.82964653e-01f, -3.26122306e-02f, 1.85008839e-01f, -4.45188172e-02f, -1.10864379e-01f,
  -8.66835285e-03f, 5.71351051e-02f, -1.41472218e-03f, -4.03034501e-02f, 1.86847504e-02f, 1.11232027e-01f, 9.46677290e-03f, 1.19826905e-01f, 3.56469229e-02f, 1.39506340e-01f,
  -3.81541513e-02f, -2.81756818e-02f, 1.24612421e-01f, 1.40612662e-01f, 7.60036781e-02f, -1.14035159e-01f, -6.88210875e-02f, 3.26234363e-02f, 1.12039335e-01f, 2.10655630e-02f,
  -9.98749658e-02f, 6.02988005e-02f, -1.36085507e-02f, -8.63658115e-02f, -2.78653074e-02f, 4.58399430e-02f, 1.72354981e-01f, 2.92677861e-02f, 1.01275638e-01f, -2.19138134e-02f,
  -4.73310426e-02f, 8.70243013e-02f, 2.51284637e-03f, -1.18650556e-01f, 1.27283828e-02f, 1.02068715e-01f, -5.84043711e-02f, -6.28776178e-02f, -6.09542392e-02f, -5.75255305e-02f,
  -3.43734473e-02f, -9.43688750e-02f, 5.89321554e-02f, -1.86150502e-02f, -9.39769000e-02f, -1.84131842e-02f, 6.66769892e-02f, -5.80272414e-02f, 6.13994524e-02f, -6.48356974e-02f,
  1.01637401e-01f, 2.14212127e-02f, 3.70279560e-03f, -4.04541902e-02f, -2.59007923e-02f, -4.90663834e-02f, 1.39374863e-02f, 4.35946956e-02f, -4.66994271e-02f, 3.48349921e-02f,
  -9.99892782e-03f, 1.48205146e-01f, 9.34101343e-02f, -4.30679023e-02f, 1.27767861e-01f, -3.94675061e-02f, -2.22265832e-02f, -9.54964161e-02f, 2.04596817e-02f, 1.11611299e-01f,
  1.22228386e-02f, 4.21991833e-02f, 5.09042013e-03f, -7.06794187e-02f, 7.53230080e-02f, -8.30282867e-02f, 1.11411475e-01f, -9.86075997e-02f, 1.43769272e-02f, 2.21683010e-02f,
  -4.12259437e-02f, 8.26294906e-03f, 4.36256826e-02f, 9.59451571e-02f, 8.48447904e-02f, -1.85417216e-02f, -3.19870794e-03f, -1.52064916e-02f, 5.40364999e-03f, -5.09417206e-02f,
  8.53999183e-02f, 6.30451739e-02f, -7.12695569e-02f, 1.77641302e-01f, 1.13720395e-01f, 2.32201125e-02f, -6.65619969e-02f, -1.11708410e-01f, 4.86872010e-02f, -3.39547768e-02f,
  -2.46822368e-02f, -9.59533304e-02f, 1.33534791e-02f, -1.13849498e-01f, 3.55971977e-02f, 1.53372616e-01f, 4.25699428e-02f, -7.28943348e-02f, -6.70289323e-02f, 1.91400811e-01f,
  1.88806698e-01f, 1.14584714e-01f, 9.80008766e-02f, 8.71292800e-02f, 1.25646740e-01f, 6.29737824e-02f, -1.06859848e-01f, 4.46470641e-02f, 9.38561559e-02f, 1.21482156e-01f,
  -4.69828174e-02f, 4.96535860e-02f, 6.79251775e-02f, 3.96766588e-02f, -2.20123678e-04f, 1.10018738e-01f, 1.05901502e-01f, 1.48829788e-01f, 9.06285942e-02f, 2.74866782e-02f,
  -5.71758226e-02f, 1.45456512e-02f, -1.16836771e-01f, 1.41404597e-02f, 1.18773818e-01f, -2.18082275e-02f, 8.90751258e-02f, 1.26630634e-01f, -5.73179871e-02f, 1.15519173e-01f,
  -6.30287305e-02f, 1.01054546e-04f, -1.78780649e-02f, 8.55480060e-02f, 5.47645241e-02f, 6.28125817e-02f, 9.06534940e-02f, -1.20742679e-01f, -6.58754557e-02f, 5.95031716e-02f,
  1.37165025e-01f, 1.48681641e-01f, -2.52946988e-02f, -5.78080788e-02f, 2.68622011e-01f, 2.75096148e-01f, -1.54701188e-01f, 1.33518549e-02f, -1.79024369e-01f, -2.36752912e-01f,
  1.12183027e-01f, -1.21594660e-01f, -1.36531070e-01f, -7.63671175e-02f, 1.71230346e-01f, -7.40173087e-02f, 9.10047442e-02f, -2.35318299e-03f, -8.14507753e-02f, -5.68487681e-02f,
  -4.56024259e-02f, 1.69932246e-02f, 1.20777734e-01f, -4.91893739e-02f, 2.27152050e-01f, 1.77543581e-01f, -3.50860821e-04f, -6.45664558e-02f, 1.37998834e-01f, 4.21932302e-02f,
  -5.70179559e-02f, -5.59392534e-02f, 5.80957048e-02f, 8.09200034e-02f, -8.84300098e-02f, -2.83666905e-02f, 4.28237021e-02f, -3.88480574e-02f, 2.51030363e-02f, 1.97554842e-01f,
  8.82622972e-02f, 1.15561090e-01f, 6.83537126e-02f, 8.62980932e-02f, 1.38799269e-02f, -1.30389720e-01f, -1.68556675e-01f, 6.22544345e-03f, 1.56943962e-01f, 1.24374188e-01f,
  1.13277540e-01f, 1.94454581e-01f, 9.58882086e-03f, 3.73998135e-02f, 3.11815701e-02f, 4.75791469e-02f, 7.61786327e-02f, -3.63081023e-02f, -1.11658894e-01f, 1.26480281e-01f,
  6.31588027e-02f, -6.33213520e-02f, 1.27555043e-01f, 6.64920062e-02f, -1.17688306e-01f, 1.45091385e-01f, 1.62559077e-01f, -1.08445033e-01f, -3.97689119e-02f, 7.49102682e-02f,
  -7.73639753e-02f, -3.90333645e-02f, -1.18879177e-01f, -2.17824683e-01f, -5.62907681e-02f, -6.28742650e-02f, 1.17952593e-01f, -3.00107952e-02f, 1.30056605e-01f, 1.10724553e-01f,
  3.36522050e-02f, -8.03995430e-02f, 3.36708222e-03f, -2.42163055e-02f, -1.00911215e-01f, 1.82446629e-01f, -2.52931081e-02f, 7.53732547e-02f, 1.21093482e-01f, -5.64960465e-02f,
  -1.54721886e-01f, -3.22018713e-02f, -7.93259684e-03f, 4.75750603e-02f, 1.13800831e-01f, -2.07242873e-02f, 1.61059901e-01f, -1.56519450e-02f, -5.28056324e-02f, -8.74413177e-02f,
  -1.04082294e-01f, -1.24027595e-01f, 6.21679015e-02f, -6.74159899e-02f, 7.34593943e-02f, -9.08150524e-02f, -6.04520645e-03f, 8.69966447e-02f, 6.31972849e-02f, 1.12939976e-01f,
  -9.20297131e-02f, -5.78952730e-02f, 1.33449540e-01f, -1.04023345e-01f, 5.81349013e-03f, -1.28145874e-01f, -5.85043803e-02f, -7.71538243e-02f, -6.74118400e-02f, 6.42753094e-02f,
  1.55311795e-02f, -3.03269234e-02f, 2.29218185e-01f, 2.28559561e-02f, -6.02350049e-02f, -8.89606215e-03f, 9.23364535e-02f, 6.24928400e-02f, 3.88259627e-02f, 5.77840842e-02f,
  -4.95520085e-02f, -5.82892783e-02f, -1.33219287e-01f, 1.07693769e-01f, -2.23109908e-02f, 6.39542043e-02f, -8.79695490e-02f, -4.67268005e-02f, -2.88980249e-02f, 2.15075523e-01f,
  -8.70387852e-02f, 2.47579902e-01f, -1.49444953e-01f, 3.45983088e-01f, 2.38988716e-02f, -9.11880806e-02f, 3.72064076e-02f, -4.96121496e-02f, -5.19871898e-02f, 3.45047883e-04f,
  2.67029703e-01f, -1.85421463e-02f, 1.42855635e-02f, 9.77516174e-02f, 4.46859598e-02f, -1.58262148e-01f, -1.23832881e-01f, -1.29248992e-01f, -8.65841210e-02f, -1.42646223e-01f,
  9.48990062e-02f, -1.59739256e-01f, -1.18509933e-01f, 5.29930778e-02f, 7.47706741e-02f, -8.92796069e-02f, -8.10453519e-02f, 1.38671473e-02f, -2.14762744e-02f, 1.32945478e-02f,
  9.62427258e-02f, -1.00326411e-01f, 1.42147720e-01f, -1.56722646e-02f, 1.21947867e-03f, -3.21790297e-03f, 2.23690234e-02f, -1.17736787e-01f, -3.19360942e-02f, 2.56945305e-02f,
  1.51333511e-01f, -2.54575070e-02f, -1.47294536e-01f, -3.02937184e-03f, -1.60047524e-02f, 1.69189766e-01f, -6.70277849e-02f, -1.89116597e-01f, 2.50780106e-01f, -3.73652987e-02f,
  1.51552200e-01f, -2.38555390e-02f, 3.02265156e-02f, 1.12994671e-01f, 1.84720475e-03f, 1.31858468e-01f, 8.42048228e-02f, 7.02944770e-02f, 8.10830519e-02f, -8.19947347e-02f,
  -4.77545746e-02f, 8.54671448e-02f, -5.35588004e-02f, -1.40294954e-01f, 2.70395074e-02f, 4.88301404e-02f, 4.40588631e-02f, 1.24096379e-01f, 7.87207112e-02f, -1.24934234e-01f,
  -2.63753776e-02f, -1.03859127e-01f, -4.83833812e-02f, 1.83301151e-01f, -9.69992206e-02f, 1.09520636e-01f, -8.91928524e-02f, 2.23125909e-02f, 4.09584157e-02f, -1.39725190e-02f,
  -1.16328441e-01f, -9.27822143e-02f, 9.81660113e-02f, -6.27199188e-02f, -6.70304000e-02f, -1.27690667e-02f, -9.46893468e-02f, 5.77590875e-02f, 5.30688800e-02f, -4.67430428e-02f,
  5.68005852e-02f, -5.26207425e-02f, 1.45079195e-01f, 8.08939745e-04f, 8.65622535e-02f, 1.08937044e-02f, 1.59869611e-01f, -6.69535771e-02f, -1.35935005e-03f, -3.81707237e-03f,
  -3.85520160e-02f, -1.45639867e-01f, 9.77002531e-02f, 5.67907095e-02f, 5.19532822e-02f, 2.03119740e-02f, -5.06532863e-02f, -1.05862580e-01f, 1.64872583e-03f, -7.12231845e-02f,
  4.14016359e-02f, 1.18172944e-01f, 1.86543971e-01f, -1.20192826e-01f, -1.09849289e-01f, -5.67533225e-02f, -6.92304969e-02f, 3.26065458e-02f, -1.23227440e-01f, -9.15632769e-02f,
  -1.27400830e-01f, 1.46213949e-01f, 4.27920604e-03f, 3.19979643e-03f, -1.37410343e-01f, 1.60348054e-03f, 5.51487459e-03f, -5.12399338e-02f, -1.93862021e-02f, 1.65096223e-01f,
  -1.91955585e-02f, 8.53691995e-02f, -8.77065659e-02f, -1.11401297e-01f, -1.25613347e-01f, -3.22413221e-02f, 7.93967843e-02f, -1.33107696e-02f, 3.81505094e-03f, -8.76714364e-02f,
  6.42961636e-02f, 1.08654737e-01f, -9.76997986e-02f, -1.53914196e-02f, -1.97709929e-02f, 4.64519486e-03f, 7.11531863e-02f, -4.29899767e-02f, 6.98553622e-02f, 8.91831070e-02f,
  -6.86896816e-02f, 4.64919619e-02f, 5.62762767e-02f, -5.36163636e-02f, 9.49885026e-02f, 5.24966046e-02f, 1.91396121e-02f, -8.54880512e-02f, 2.32390482e-02f, -1.28780693e-01f,
  -1.17052190e-01f, 4.86346893e-02f, -1.53939100e-02f, 2.33362764e-02f, 3.76442224e-02f, -9.09980386e-02f, -1.05783053e-01f, -8.81787688e-02f, -5.00260293e-02f, -9.35562178e-02f,
  9.59551111e-02f, 7.23033249e-02f, -9.87319648e-02f, 7.15793222e-02f, -8.16806331e-02f, 6.53789565e-02f, -2.71973256e-02f, -9.74836126e-02f, -7.32686594e-02f, -5.97710721e-02f,
  -1.16878435e-01f, -5.17123416e-02f, -1.38611466e-01f, -1.15011871e-01f, -1.27505139e-02f, 8.07527918e-04f, -7.66281933e-02f, -1.08660810e-01f, -1.28075257e-01f, -7.82746170e-03f,
  6.56865090e-02f, -6.53738668e-03f, -3.70985456e-02f, -2.85196938e-02f, 4.33322825e-02f, -5.99665791e-02f, 7.61429267e-03f, -3.68678868e-02f, -9.08958763e-02f, 8.28126296e-02f,
  -8.30938965e-02f, 5.60940150e-03f, -8.34594667e-03f, -6.97820336e-02f, 5.93048558e-02f, -2.42120344e-02f, -1.26290351e-01f, -1.16011761e-01f, 8.25641975e-02f, -1.22954972e-01f,
  3.34355123e-02f, 1.68666393e-02f, 5.19904308e-02f, 6.12780340e-02f, 2.98679098e-02f, 4.95652631e-02f, -6.00612238e-02f, -3.94413434e-02f, -9.31355059e-02f, -4.98746932e-02f,
  -7.81903118e-02f, -1.09559521e-01f, -4.42077965e-02f, -2.93960832e-02f, 1.65905617e-02f, 2.03873534e-02f, -1.16880186e-01f, -1.47412037e-02f, 8.23646411e-02f, -1.49667123e-02f,
  6.46285294e-03f, -1.26225710e-01f, -2.04002205e-02f, -1.22334100e-01f, -1.16634771e-01f, 9.00750235e-02f, -8.84948820e-02f, -3.56298424e-02f, -1.33728981e-01f, -3.85430153e-03f,
  -3.01743229e-03f, -8.23730454e-02f, 8.61983523e-02f, 2.00107440e-01f, 3.84679347e-01f, 3.32544357e-01f, 1.12948231e-01f, 1.87834531e-01f, 3.71543437e-01f, -6.83461055e-02f,
  -1.68717176e-01f, 1.83095291e-01f, 2.21057832e-01f, 3.83091718e-02f, 2.38151401e-01f, -8.18905532e-02f, 1.24603353e-01f, 2.50811167e-02f, 1.28059715e-01f, 1.31482169e-01f,
  3.10368631e-02f, 1.68565854e-01f, 5.58547787e-02f, 1.83897495e-01f, 6.95721135e-02f, -1.31607860e-01f, -2.80346036e-01f, 2.38768816e-01f, 3.42357963e-01f, 2.09917337e-01f,
  1.15721717e-01f, -1.72706515e-01f, 2.16542497e-01f, 1.04508400e-01f, 1.72709256e-01f, 3.72933298e-02f, 1.08969130e-01f, 2.26260468e-01f, 3.04780062e-02f, 8.90863091e-02f,
  1.88206639e-02f, -1.23481579e-01f, -1.51562139e-01f, 1.22406319e-01f, 1.61020368e-01f, 1.86424002e-01f, 5.06542511e-02f, 2.09107786e-01f, -9.96749625e-02f, 1.06944814e-02f,
  -1.92481764e-02f, 6.68994114e-02f, 1.73930347e-01f, 3.59303281e-02f, 2.58902550e-01f, 2.36996874e-01f, 4.73832823e-02f, 6.32851571e-02f, 1.50004536e-01f, -1.49085835e-01f,
  1.93125755e-02f, 3.51243541e-02f, 3.14201117e-01f, 1.79608166e-01f, -1.35084158e-02f, -7.51093701e-02f, -2.84339767e-02f, -1.18182071e-01f, -1.03622228e-01f, -4.06738371e-02f,
  -1.36301488e-01f, -1.24191165e-01f, -1.08935507e-02f, 1.67992577e-01f, 3.18062194e-02f, -7.43032200e-03f, -1.18255444e-01f, -6.12806641e-02f, 7.25849706e-04f, 9.87303108e-02f,
  3.60815786e-02f, -1.02165960e-01f, 1.97195821e-03f, 4.18227054e-02f, 1.16633877e-01f, 2.44863853e-02f, 9.37140658e-02f, -1.10749096e-01f, 1.07314423e-01f, -8.93303379e-02f,
  -9.07215327e-02f, 6.08052723e-02f, -7.89950266e-02f, 2.08914708e-02f, -8.67638737e-02f, 4.71268594e-03f, 2.24500243e-02f, 1.09258011e-01f, 8.24632589e-03f, 8.69077891e-02f,
  -6.96493909e-02f, -6.27523437e-02f, 6.09579012e-02f, 1.39462519e-02f, 4.07568626e-02f, -3.30352150e-02f, -2.96358187e-02f, 5.03987297e-02f, 8.47197920e-02f, -7.79938325e-02f,
  -6.79480061e-02f, 5.54695390e-02f, 3.46311852e-02f, -8.48104656e-02f, -6.76812381e-02f, 3.84731926e-02f, 5.97234704e-02f, 8.45441818e-02f, -4.93187793e-02f, 1.03304908e-01f,
  -1.37789715e-02f, 4.95009534e-02f, 3.89480256e-02f, -1.44372702e-01f, -9.08521712e-02f, -4.89863902e-02f, -4.86607030e-02f, -9.49662849e-02f, -9.48259383e-02f, 1.26084788e-02f,
  5.10477275e-02f, 2.90614981e-02f, -4.41226102e-02f, -6.92753529e-04f, 4.19055261e-02f, -1.85026247e-02f, 1.73856080e-01f, -2.80052181e-02f, 4.94908355e-03f, -6.60825297e-02f,
  -9.39810053e-02f, -5.87126128e-02f, 9.11416486e-03f, -5.50740249e-02f, -9.25535262e-02f, 7.92132393e-02f, 1.52791098e-01f, -4.49929498e-02f, 2.68086256e-03f, -1.56698629e-01f,
  -6.55095354e-02f, -1.78448241e-02f, 3.42560783e-02f, 2.56280541e-01f, 1.10855684e-01f, -6.28517196e-02f, -3.02828196e-02f, -5.20443507e-02f, -4.48217355e-02f, -5.49571179e-02f,
  4.52178754e-02f, 1.41134471e-01f, -8.46588314e-02f, 1.10492386e-01f, 9.63191539e-02f, -7.65826032e-02f, -7.58065730e-02f, -6.61639720e-02f, -7.54019767e-02f, -9.72238705e-02f,
  6.13984056e-02f, -1.51289135e-01f, -6.14070073e-02f, 1.64144076e-02f, -4.56899181e-02f, 1.58815254e-02f, -1.32458350e-02f, -1.94801409e-02f, 1.77453294e-01f, -3.39086689e-02f,
  -7.67823756e-02f, -1.80902192e-04f, -7.77963996e-02f, -1.47465035e-01f, -8.66548195e-02f, 4.45305109e-02f, -6.29667863e-02f, -1.71937183e-01f, -1.33081749e-01f, -3.54153779e-03f,
  -1.94664411e-02f, 7.40864202e-02f, 4.86933365e-02f, -3.07321753e-02f, 1.74251422e-02f, 3.15143652e-02f, 3.85663398e-02f, 5.92174828e-02f, 6.86604902e-03f, 1.88393325e-01f,
  5.77413440e-02f, 1.90828532e-01f, 7.23031685e-02f, -2.91510113e-02f, -1.36580572e-01f, 5.87757351e-03f, -7.27976188e-02f, 6.80585578e-03f, -1.39473841e-01f, 9.78405848e-02f,
  1.30967602e-01f, 6.39586849e-03f, -2.21423656e-02f, -2.45327353e-02f, 6.61597401e-02f, -1.16797760e-02f, 8.43354017e-02f, 4.20639291e-02f, 2.58125693e-01f, 9.52484012e-02f,
  -1.30516738e-01f, -7.90279582e-02f, -9.15295333e-02f, -1.04944296e-01f, -1.16378829e-01f, 2.03569517e-01f, -1.02287911e-01f, -1.12999482e-02f, 2.71709636e-02f, 1.13842497e-02f,
  -1.13035612e-01f, -1.36849493e-01f, -2.54956149e-02f, 2.41018776e-02f, -5.60989119e-02f, -2.39980761e-02f, -7.27389604e-02f, -6.18906179e-03f, 1.36063278e-01f, -1.46156818e-01f,
  1.42436489e-01f, -1.33048058e-01f, -4.22795415e-02f, -1.20431885e-01f, 5.39450422e-02f, -1.05575927e-01f, -1.06233068e-01f, -1.29917488e-01f, -3.41158882e-02f, 1.35591906e-03f,
  -1.37960628e-01f, -1.32058552e-02f, -8.99898708e-02f, 1.42847076e-01f, 9.36275199e-02f, -1.31223291e-01f, -4.45025973e-02f, -7.05525205e-02f
};

// L1_fan_Bp_bar (Shape: 1 x 52)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 52;
const float L1_fan_Bp_bar_data[] = {
  -5.28660566e-02f, 1.68212473e-01f, 1.22918459e-02f, 3.14536333e-01f, -1.08622395e-01f, 2.76182950e-01f, 9.95181650e-02f, 1.78454995e-01f, -1.65040176e-02f, 1.45864844e-01f,
  2.22191978e-02f, 9.36308727e-02f, -1.28092542e-02f, -5.01559302e-02f, 5.50968945e-03f, 2.94332635e-02f, 6.74822330e-02f, 1.79275259e-01f, 7.03073069e-02f, -3.83527465e-02f,
  1.09140418e-01f, 5.35618924e-02f, 2.10034683e-01f, 1.71543226e-01f, -1.08257212e-01f, 4.36472967e-02f, 1.31288767e-01f, 2.59043891e-02f, 2.33165950e-01f, 2.64227718e-01f,
  -8.91154539e-03f, 1.73314720e-01f, 3.19868512e-02f, 4.17233892e-02f, 1.71136931e-02f, 1.38591602e-01f, 7.41899386e-02f, 7.60550797e-02f, 1.84043810e-01f, 2.69418240e-01f,
  -1.17678553e-01f, 1.26879856e-01f, 1.75035372e-01f, 1.26294374e-01f, 1.03914455e-01f, 1.08712614e-01f, -7.51471967e-02f, 2.70427577e-02f, 3.13229173e-01f, -1.28177896e-01f,
  1.64430693e-01f, 1.79054528e-01f
};

// L2_fan_Wp (Shape: 6 x 64)
const int L2_fan_Wp_rows = 6;
const int L2_fan_Wp_cols = 64;
const float L2_fan_Wp_data[] = {
  6.38145134e-02f, 1.05124012e-01f, 1.04767092e-01f, 5.63080199e-02f, 2.17627123e-01f, 4.84998189e-02f, -1.75792560e-01f, 1.18815109e-01f, 1.80782169e-01f, -1.31516755e-01f,
  -1.56900734e-02f, 1.38418227e-01f, 1.02446318e-01f, -1.26276746e-01f, -3.10792513e-02f, 2.86833495e-01f, 9.25602540e-02f, -3.77187366e-03f, 1.28196239e-01f, -1.31339412e-02f,
  5.30255102e-02f, -1.46517411e-01f, -1.20722018e-01f, -6.64573684e-02f, 7.85248131e-02f, 7.01054409e-02f, -4.95772548e-02f, 1.88628688e-01f, 1.15889080e-01f, 7.54761696e-03f,
  -5.34653887e-02f, -1.40788807e-02f, 8.87948275e-02f, -9.20101926e-02f, 1.70874614e-02f, -1.27876177e-01f, 6.72111958e-02f, -1.01654418e-01f, -1.24700092e-01f, -1.81387603e-01f,
  -8.87628421e-02f, -1.02830827e-01f, 2.91968323e-03f, -3.57357934e-02f, 1.17989711e-01f, 4.03527804e-02f, 7.92046562e-02f, 2.98027452e-02f, -2.90524848e-02f, -2.75365077e-02f,
  4.65519466e-02f, -8.02306235e-02f, -8.06574747e-02f, -6.94498047e-02f, 9.14961845e-03f, -3.36357541e-02f, -3.96478511e-02f, -7.50643313e-02f, 7.92772099e-02f, -1.17038384e-01f,
  -1.04998484e-01f, -2.03518253e-02f, 2.10611057e-02f, 1.44587681e-01f, -7.51068220e-02f, -1.72608688e-01f, -7.44973943e-02f, -2.20252752e-01f, 2.09693573e-02f, 4.01590299e-03f,
  3.20574618e-03f, 1.06566946e-03f, 2.81485230e-01f, 1.61206275e-01f, -3.06319296e-01f, 3.81349534e-01f, -7.07858577e-02f, -1.18550800e-01f, 4.54230420e-02f, 2.19173506e-01f,
  -4.76486608e-03f, 6.11995310e-02f, 1.00226067e-01f, -1.00344256e-01f, 6.53246567e-02f, -3.79809458e-03f, 1.03181936e-01f, 8.27038661e-02f, 5.89694530e-02f, 5.35456650e-02f,
  4.89100404e-02f, -4.81712446e-02f, 5.48789427e-02f, -1.06462598e-01f, -1.27496019e-01f, -3.96039784e-02f, -1.77663386e-01f, -1.43001243e-01f, 1.39659777e-01f, -1.18024042e-02f,
  5.18140011e-02f, -1.12151109e-01f, -9.77078676e-02f, -1.01306044e-01f, -5.70683368e-02f, -3.24735940e-02f, -1.45676717e-01f, 1.70927998e-02f, 7.07342476e-02f, -5.95436133e-02f,
  -9.79037285e-02f, 1.87694207e-02f, -7.85957128e-02f, 6.54999167e-02f, 2.60493252e-02f, -1.32848218e-01f, 2.00554412e-02f, -3.19163338e-03f, -4.89723915e-03f, -2.62056943e-02f,
  2.05065414e-01f, -1.35900192e-02f, 4.49974462e-02f, -1.20073380e-02f, -6.91058999e-03f, 2.80506648e-02f, -3.02389450e-03f, 4.66651060e-02f, 1.77938089e-01f, 1.47740915e-01f,
  5.22957854e-02f, 2.09321622e-02f, -1.37935176e-01f, 1.02374330e-01f, -2.62610763e-02f, 9.18283220e-03f, -3.06563944e-01f, -3.13242137e-01f, 4.37746167e-01f, -5.14918625e-01f,
  -1.54502422e-01f, 7.68649429e-02f, -3.88656855e-02f, -2.18071714e-01f, 9.72682610e-02f, 4.75547984e-02f, -2.20358111e-02f, 2.74302989e-01f, 7.62146115e-02f, -1.64248392e-01f,
  -6.32800311e-02f, -9.24697220e-02f, 7.48788565e-02f, -3.80494371e-02f, 1.29322603e-01f, -1.91167533e-01f, -7.03438930e-03f, 1.65396348e-01f, 1.77070126e-02f, 2.80131511e-02f,
  1.59423575e-01f, 2.02045202e-01f, -1.15795873e-01f, -3.05036120e-02f, -1.16390131e-01f, -6.79924116e-02f, -1.87818676e-01f, -1.37597527e-02f, -9.55786407e-02f, -9.24340561e-02f,
  1.63611516e-01f, -2.06985816e-01f, 3.03254575e-02f, -1.41113505e-01f, 1.61400437e-01f, 1.12780621e-02f, 1.32514656e-01f, -1.00672886e-01f, -1.59251556e-01f, -3.96639295e-02f,
  1.31949186e-01f, 3.03042512e-02f, 7.97009692e-02f, -1.84984699e-01f, -2.11302280e-01f, 6.43532798e-02f, -1.47691816e-01f, 7.39939213e-02f, 1.34641796e-01f, -1.61920533e-01f,
  7.79264197e-02f, -3.23082171e-02f, 6.99212402e-02f, -1.62941851e-02f, 1.53492512e-02f, 1.54683545e-01f, 2.57647987e-02f, 1.56018764e-01f, 1.36825606e-01f, 4.31789048e-02f,
  -3.40664029e-01f, -9.45428610e-02f, 1.02949403e-01f, -2.34073922e-01f, 6.26338348e-02f, -2.84785330e-02f, -6.75912946e-02f, -1.90369248e-01f, -1.26192361e-01f, 6.08486943e-02f,
  -5.54552488e-02f, 1.27921388e-01f, -1.16429739e-01f, -8.01002905e-02f, -8.12252611e-02f, 7.46371821e-02f, 1.34599462e-01f, -1.59425497e-01f, 6.31057471e-02f, -7.60275126e-02f,
  -4.07955498e-02f, 8.01293105e-02f, -1.49329994e-02f, 7.68297166e-02f, 2.66754121e-01f, 1.40474945e-01f, -1.46347940e-01f, -7.25046471e-02f, 2.87346952e-02f, 6.99185941e-04f,
  3.94533649e-02f, 1.60275862e-01f, -1.34139940e-01f, -1.39620200e-01f, 1.69488832e-01f, 2.10382007e-02f, 1.07051409e-03f, -1.56235874e-01f, 7.31474385e-02f, -6.77247718e-02f,
  1.37867630e-01f, -1.47262365e-01f, 1.24020651e-01f, 5.25431447e-02f, -1.54772419e-02f, 5.11633866e-02f, 1.06948845e-01f, -2.01438025e-01f, -1.51488423e-01f, -1.33643210e-01f,
  2.89342925e-02f, -6.93070665e-02f, 9.56732500e-03f, -9.63167772e-02f, -1.04335941e-01f, -4.98357899e-02f, -1.51683733e-01f, -1.66257724e-01f, 9.26318914e-02f, 5.39570488e-02f,
  -1.53500557e-01f, 5.82261942e-02f, 2.07518965e-01f, -2.29114413e-01f, -3.12411040e-01f, 5.27250506e-02f, -1.97488610e-02f, -2.57178038e-01f, -3.59410867e-02f, -3.26210447e-02f,
  -6.53389394e-02f, -1.99656263e-01f, -9.04715881e-02f, 1.54101029e-01f, -1.07545234e-01f, 1.68780714e-01f, 1.42094880e-01f, 5.70202507e-02f, 8.51711631e-02f, -4.38344590e-02f,
  6.67473227e-02f, 5.95804825e-02f, -8.74971375e-02f, -6.53881207e-02f, -2.42343470e-02f, -1.90678611e-01f, 6.24513365e-02f, 7.12763146e-02f, -5.27039990e-02f, -4.63863388e-02f,
  5.96735515e-02f, -2.34246664e-02f, -5.55163324e-02f, -7.54396170e-02f, 2.29657799e-01f, 1.20453000e-01f, 2.58246288e-02f, -9.96927097e-02f, 6.93980083e-02f, 2.08701845e-02f,
  1.01533078e-01f, 1.59949899e-01f, 8.67212936e-02f, -4.22722399e-02f, 1.10770740e-01f, 8.30178708e-02f, -5.35115972e-02f, -8.97019282e-02f, -7.00143725e-02f, 8.44000652e-02f,
  1.37633711e-01f, -1.66736785e-02f, -1.21387929e-01f, -2.14655429e-01f, 6.61229156e-03f, -1.02810241e-01f, 1.96768686e-01f, 3.40114981e-02f, -1.44615784e-01f, -7.78334811e-02f,
  5.69367185e-02f, -1.55439854e-01f, 6.89205229e-02f, 7.87329599e-02f, 2.84617282e-02f, 4.32608835e-02f, 2.35039458e-01f, 3.94806303e-02f, -1.39348403e-01f, 2.60807604e-01f,
  -6.78772852e-02f, -1.94541402e-02f, 9.72262621e-02f, 7.58724436e-02f, 4.31507118e-02f, -5.93306608e-02f, 8.31465945e-02f, 1.15362071e-01f, -2.34766915e-01f, -5.57042994e-02f,
  9.31445882e-02f, 1.75401136e-01f, -2.98512485e-02f, 1.33631468e-01f, 6.07371666e-02f, -1.75236106e-01f, -1.31505057e-01f, 9.39858854e-02f, -1.01111695e-01f, -1.46776572e-01f,
  1.92469254e-01f, -1.25738740e-01f, -5.51213883e-02f, 6.35275170e-02f, 1.45497486e-01f, 6.69205710e-02f, 3.93886678e-02f, 8.45026523e-02f, -3.26665640e-02f, 1.75189316e-01f,
  -1.88262220e-02f, -2.21317500e-01f, 5.97926155e-02f, 3.75534743e-02f, 1.33937538e-01f, 1.03280239e-01f, 3.71455289e-02f, 1.08730823e-01f, 5.08808568e-02f, 2.17171405e-02f,
  -1.41477838e-01f, -8.59582648e-02f, 9.45689678e-02f, 1.38175920e-01f, 4.04141881e-02f, 8.84715542e-02f, -1.37142435e-01f, 8.61104876e-02f, -3.81992850e-03f, 7.14279059e-03f,
  1.74463719e-01f, 1.50358811e-01f, -4.44990490e-03f, -8.52826610e-02f
};

// L2_fan_Wp_bar (Shape: 52 x 64)
const int L2_fan_Wp_bar_rows = 52;
const int L2_fan_Wp_bar_cols = 64;
const float L2_fan_Wp_bar_data[] = {
  1.97488457e-01f, 1.38292909e-01f, 4.45072092e-02f, -1.54814079e-01f, -2.61366814e-01f, 2.30183393e-01f, -2.06792578e-01f, -2.57257402e-01f, -1.26703501e-01f, -3.65172893e-01f,
  4.95554715e-01f, -5.17402709e-01f, 3.72468606e-02f, 3.40642750e-01f, -8.97530233e-04f, -3.60693514e-01f, -9.58495364e-02f, 3.13042819e-01f, -1.41089022e-01f, -5.64517416e-02f,
  1.43144280e-01f, -2.13987812e-01f, -5.93445562e-02f, 1.47234276e-01f, 9.49293561e-03f, -1.22388545e-02f, 1.96398184e-01f, -2.51923829e-01f, -7.87022486e-02f, 2.20412046e-01f,
  -1.67341799e-01f, 1.14541955e-01f, 3.84606346e-02f, 2.01403335e-01f, 2.05437347e-01f, 3.88107039e-02f, -3.40886377e-02f, -5.20795174e-02f, -1.37110054e-01f, -6.72891736e-02f,
  2.59252518e-01f, 4.12502170e-01f, -6.53532073e-02f, 1.24809265e-01f, -3.03519778e-02f, 6.40351102e-02f, 1.35410711e-01f, -8.89712945e-02f, 2.29278460e-01f, 8.53874758e-02f,
  -1.34605482e-01f, 3.66747171e-01f, -6.63577393e-02f, -1.09619799e-03f, -1.76201165e-01f, -1.72757283e-01f, -1.27009928e-01f, 8.03755671e-02f, -1.70415983e-01f, -1.56446174e-01f,
  1.71083480e-01f, -1.55003041e-01f, 4.03960347e-02f, -5.49162477e-02f, -6.47124723e-02f, 1.92909967e-02f, -7.06893206e-02f, 8.24132338e-02f, 6.08442724e-02f, 2.89220903e-02f,
  -1.37342503e-02f, 8.91575739e-02f, -1.07276253e-01f, 1.13792932e-02f, 1.50940493e-01f, 4.51844968e-02f, -5.39470427e-02f, 8.82334821e-03f, -6.80578798e-02f, 2.33220938e-03f,
  5.76684177e-02f, 1.65886998e-01f, -5.54007590e-02f, -1.56633817e-02f, 1.25982940e-01f, -8.58862773e-02f, 6.06801175e-03f, 1.85256135e-02f, 3.55196595e-02f, 5.91115616e-02f,
  -9.87219587e-02f, -8.80092084e-02f, 9.15345848e-02f, -1.18816525e-01f, -1.21350162e-01f, -7.06429314e-03f, 3.85221541e-02f, 5.23699448e-02f, 1.48277953e-01f, -2.73163281e-02f,
  1.97885521e-02f, 3.25549319e-02f, 4.48307022e-02f, 2.37111282e-02f, -2.02460680e-02f, -5.44368699e-02f, -3.97050604e-02f, 1.27301976e-01f, -1.13112070e-01f, -7.87535217e-03f,
  1.08049408e-01f, 4.89398725e-02f, -2.12352965e-02f, 1.17978349e-01f, -1.24002263e-01f, 6.01938460e-03f, -9.30101797e-02f, -5.67930005e-02f, 1.35180101e-01f, 6.72529042e-02f,
  -4.12990227e-02f, -2.68915985e-02f, 1.05407611e-01f, -8.33273008e-02f, -8.63236710e-02f, -3.63166854e-02f, -1.00212745e-01f, 6.20070100e-03f, -4.56522852e-02f, -2.75842305e-02f,
  4.97050863e-03f, -1.58750117e-02f, -1.49526700e-01f, 6.25428185e-02f, -1.59759134e-01f, -5.41175827e-02f, 8.65781959e-03f, -2.89410092e-02f, 1.68509781e-01f, -7.94885904e-02f,
  1.16451442e-01f, 1.52737394e-01f, 3.33328284e-02f, -1.29021168e-01f, -3.44375968e-02f, 1.84150115e-01f, -7.53272548e-02f, -8.35858211e-02f, -1.35159157e-02f, -2.17322446e-02f,
  4.97659408e-02f, 1.57981422e-02f, 3.97017151e-02f, -2.84724813e-02f, 5.42630516e-02f, 1.82582960e-02f, 2.25984282e-03f, 4.00793068e-02f, -6.22016005e-02f, -1.06375031e-02f,
  -3.94866578e-02f, 8.85397121e-02f, 4.18735035e-02f, 5.57659529e-02f, 3.08518000e-02f, 1.10818893e-02f, -1.14836805e-01f, 7.99780525e-03f, 7.86622763e-02f, -1.23327039e-02f,
  1.24696076e-01f, -1.28509442e-03f, 1.28285617e-01f, 9.78844017e-02f, 1.05564073e-01f, -1.31240860e-01f, 1.07404739e-01f, -9.35708638e-03f, -1.20772302e-01f, 1.85290296e-02f,
  7.79439136e-02f, 1.33974059e-03f, 7.81924203e-02f, -4.47697617e-04f, -8.70283246e-02f, -7.49730021e-02f, -4.52140272e-02f, -5.52896261e-02f, 4.01891246e-02f, -5.70653342e-02f,
  -1.48921332e-03f, -1.30917773e-01f, 1.36126444e-01f, 2.61360407e-01f, 1.78566292e-01f, 3.03776145e-01f, 6.06480092e-02f, 9.55323577e-02f, 2.68498838e-01f, 9.36403722e-02f,
  1.72437385e-01f, 1.47293076e-01f, -3.00124556e-01f, -3.35490018e-01f, 5.27937599e-02f, 1.02121666e-01f, -1.43077016e-01f, 7.57305697e-02f, -2.83652227e-02f, -7.85365142e-03f,
  -2.89380550e-01f, 3.39009315e-01f, 3.53373028e-02f, 1.46848947e-01f, 1.48800492e-01f, 1.24647841e-01f, 1.56947151e-01f, 6.05699159e-02f, -1.41426831e-01f, 4.96760011e-02f,
  -1.28199667e-01f, 1.02392118e-02f, 1.01354703e-01f, 1.59661397e-02f, 9.73282829e-02f, -1.10498099e-02f, 1.51804477e-01f, 2.52323329e-01f, -4.09460291e-02f, 2.50343412e-01f,
  4.39421326e-01f, 2.42429916e-02f, 2.57959813e-01f, -1.68444961e-02f, 7.31126145e-02f, 1.63201690e-01f, -1.40119672e-01f, -7.45280311e-02f, 4.33164164e-02f, -3.23186256e-02f,
  3.58682834e-02f, 2.45629817e-01f, -2.08115857e-02f, -1.24220520e-01f, 6.94444822e-03f, -6.14508986e-02f, 1.43398568e-01f, 1.58964232e-01f, -8.25085640e-02f, 6.24024644e-02f,
  3.27223688e-02f, -6.20877370e-02f, 2.06916973e-01f, 8.03473815e-02f, 1.99631587e-01f, 2.13799998e-01f, 8.98409188e-02f, -7.05273151e-02f, 1.19914450e-01f, -9.09843817e-02f,
  1.55759165e-02f, 1.17479220e-01f, -2.39963531e-01f, -1.60984039e-01f, -9.12630260e-02f, -1.71581239e-01f, 6.51579276e-02f, 1.75248459e-01f, 9.94714275e-02f, 1.15375571e-01f,
  1.00142874e-01f, 1.22261360e-01f, -5.19716628e-02f, 1.16676301e-01f, 4.73504849e-02f, -2.63927616e-02f, -9.73013490e-02f, 2.69392841e-02f, -3.30460779e-02f, 4.63321665e-03f,
  -3.20037790e-02f, 1.10997027e-02f, 8.96522552e-02f, 1.44644037e-01f, -5.31260595e-02f, 1.01221852e-01f, -4.66473550e-02f, -7.43900687e-02f, -6.19106926e-02f, -4.18776311e-02f,
  1.65624887e-01f, -7.88891241e-02f, 4.05192655e-03f, -3.55295911e-02f, -1.59743696e-01f, 8.68023485e-02f, -3.70027162e-02f, 2.49431551e-01f, 1.08634062e-01f, -2.99166199e-02f,
  -9.70607653e-05f, -8.59516412e-02f, 1.42715022e-01f, 3.96379419e-02f, 2.64132284e-02f, -1.16421226e-02f, -9.00198519e-02f, 2.11587951e-01f, 3.82434726e-02f, -1.15980236e-02f,
  1.16877398e-02f, -8.64939541e-02f, 4.17959169e-02f, 9.78715643e-02f, 1.59378443e-02f, -5.81939630e-02f, -6.92610443e-02f, 5.07668965e-02f, -8.82444009e-02f, -4.03054804e-02f,
  1.62130237e-01f, 1.41319975e-01f, 4.97263344e-03f, -5.42137437e-02f, -2.30380856e-02f, 2.16935739e-01f, -2.22665682e-01f, -9.00597349e-02f, -1.39567807e-01f, -1.32297590e-01f,
  1.50076613e-01f, 2.13588893e-01f, -2.91419793e-02f, 6.39163256e-02f, 6.64740801e-02f, 1.28977627e-01f, -1.97179466e-01f, 2.03624204e-01f, 1.02777109e-01f, 1.58088937e-01f,
  7.19875284e-03f, -8.95569399e-02f, 6.56226054e-02f, -1.00457087e-01f, -1.51723757e-01f, -6.72145709e-02f, -3.89933996e-02f, 9.45429280e-02f, 3.83220129e-02f, -8.01415965e-02f,
  4.65550489e-04f, 1.15682572e-01f, -1.73317865e-01f, -6.08808249e-02f, 1.35209873e-01f, -6.42385781e-02f, 1.08748246e-02f, -1.19199626e-01f, -1.53306022e-01f, 3.49749811e-02f,
  -1.49573192e-01f, 1.37157694e-01f, 4.60514389e-02f, 3.53675857e-02f, 2.24954382e-01f, -7.72982985e-02f, 9.82251540e-02f, -1.24784790e-01f, 4.52908464e-02f, -1.85947716e-01f,
  -9.74928401e-03f, 2.26662643e-02f, -4.29208949e-02f, -4.42043180e-03f, 3.15532871e-02f, 3.27302516e-02f, -1.68493330e-01f, -2.59590112e-02f, -5.10097630e-02f, -7.11308643e-02f,
  2.13824302e-01f, -2.87496876e-02f, 4.59861793e-02f, -1.51643544e-01f, 3.26787643e-02f, 1.52997762e-01f, 1.02861695e-01f, 1.81169454e-02f, 1.86479554e-01f, 8.63981992e-02f,
  -1.88758835e-01f, 3.85879725e-02f, 2.16862619e-01f, -6.31407723e-02f, -1.95074677e-02f, 2.43963435e-01f, -3.15165333e-03f, -8.35313946e-02f, -3.01280133e-02f, 4.35811251e-01f,
  -4.60383063e-03f, 5.61793111e-02f, 4.86386009e-02f, -4.37691137e-02f, -1.43818542e-01f, 9.78326350e-02f, 7.75256231e-02f, 9.63421315e-02f, 9.19251516e-03f, 6.83947876e-02f,
  -7.42954835e-02f, 1.97936192e-01f, 1.11506008e-01f, 1.48600996e-01f, 8.89111683e-02f, 1.14329256e-01f, 8.59711319e-02f, -1.24844864e-01f, 1.12046286e-01f, -6.06869869e-02f,
  -5.34669235e-02f, -2.26837071e-03f, -1.04052976e-01f, -1.02111399e-01f, -6.90445013e-04f, -1.06657587e-01f, -2.74473976e-04f, 2.68658567e-02f, 1.68171108e-01f, 8.35090354e-02f,
  -7.62161762e-02f, 1.31387845e-01f, -6.66062310e-02f, 3.86230834e-02f, 8.46749991e-02f, 9.02853459e-02f, 4.68483791e-02f, -9.83502939e-02f, -1.07550628e-01f, 1.48536623e-01f,
  1.34147421e-01f, 1.65468678e-01f, 8.51801932e-02f, -8.99956524e-02f, -9.86276716e-02f, -1.30831134e-02f, 6.64256588e-02f, 1.44600302e-01f, -8.75914376e-03f, 5.66608906e-02f,
  7.75535405e-02f, 1.84447691e-01f, 8.32318887e-02f, -3.46505754e-02f, 1.01634085e-01f, 4.57503200e-02f, -9.18482393e-02f, -1.18259996e-01f, 1.76130265e-01f, -2.28543162e-01f,
  -1.19910292e-01f, -2.59918440e-02f, 3.01735802e-03f, 1.56825617e-01f, -1.00579575e-01f, -4.57758270e-02f, 7.39085898e-02f, 3.36719453e-01f, -5.42760268e-02f, -9.61714312e-02f,
  -1.26900867e-01f, -1.22008629e-01f, -1.32166967e-01f, -8.97732675e-02f, -1.51116047e-02f, -5.61505780e-02f, 3.32002230e-02f, -6.06682077e-02f, 6.74843416e-02f, -7.83647224e-03f,
  -1.45935133e-01f, 6.22573681e-02f, 2.29011834e-01f, 2.06849635e-01f, -6.16782010e-02f, 3.87511142e-02f, 1.91148788e-01f, -4.57926765e-02f, 1.26926377e-01f, 1.45920906e-02f,
  3.86336595e-02f, -9.52172652e-02f, 1.29055679e-01f, 5.11716604e-02f, 5.31330369e-02f, -9.23312306e-02f, 1.11824468e-01f, -1.31322995e-01f, -8.93020555e-02f, 1.27579898e-01f,
  -1.05740122e-01f, 2.10248560e-01f, -1.09013088e-01f, 1.04673140e-01f, -1.98121861e-01f, 5.07451035e-02f, -1.11323986e-02f, 5.09132668e-02f, 3.22337121e-01f, -1.62285077e-03f,
  -7.53797665e-02f, -1.31062597e-01f, 3.04173172e-01f, 2.45310932e-01f, 2.19881073e-01f, 2.73227990e-01f, 3.06897134e-01f, 9.87887681e-02f, 3.03558290e-01f, -1.82171881e-01f,
  -2.94695795e-01f, -3.90525341e-01f, 3.00681144e-01f, -6.58851922e-01f, -1.06083028e-01f, -9.43996459e-02f, -6.92076758e-02f, -2.06394106e-01f, -1.42572328e-01f, 1.12484828e-01f,
  -1.42193541e-01f, 4.51027691e-01f, 1.83376342e-01f, -1.81136295e-01f, -1.80521265e-01f, 1.58867761e-02f, -1.10330760e-01f, 3.48506756e-02f, 2.48193257e-02f, -1.03078447e-01f,
  7.79151767e-02f, 1.81584612e-01f, 5.16912527e-02f, 1.75310560e-02f, 4.72975662e-03f, 2.04399839e-01f, 2.95996424e-02f, 2.13709891e-01f, 6.01172745e-02f, 1.45555334e-02f,
  2.09455520e-01f, 3.94199751e-02f, 2.39584178e-01f, 6.44336343e-02f, 3.46968211e-02f, -1.35202333e-02f, 1.04997031e-01f, -2.89102066e-02f, 1.18075103e-01f, -1.36619255e-01f,
  2.01353312e-01f, -5.31088747e-02f, -1.47326395e-01f, 4.08928134e-02f, -2.30363626e-02f, 1.83093175e-01f, -5.11466376e-02f, 1.07652768e-01f, -1.30083933e-01f, -6.58972561e-02f,
  -1.78356975e-01f, -1.83843151e-01f, 5.25665641e-01f, -6.96928501e-02f, 1.19127724e-02f, 2.05500759e-02f, -3.04203574e-02f, -7.79154748e-02f, -6.75924122e-02f, 7.55116642e-02f,
  7.68638402e-02f, 8.14946145e-02f, 1.33558852e-03f, 1.07354999e-01f, 9.38219577e-02f, 3.88408313e-03f, -1.84998423e-01f, 4.04711589e-02f, 7.42632598e-02f, 1.18576154e-01f,
  4.15552109e-02f, 2.31352970e-01f, -3.26375701e-02f, 1.45530134e-01f, -1.06394857e-01f, -9.67590022e-04f, -9.60521121e-03f, -1.67091249e-03f, -8.44481811e-02f, -4.76696417e-02f,
  -6.81098476e-02f, -3.22796032e-02f, 8.20310339e-02f, 1.10722475e-01f, 1.01430314e-02f, -5.90902418e-02f, 1.73126049e-02f, -1.09064512e-01f, 3.95648591e-02f, 1.31953180e-01f,
  1.65993989e-01f, 9.04054418e-02f, -7.27893040e-02f, 8.18987284e-03f, 1.21082827e-01f, 1.15212552e-01f, -1.73159968e-02f, -4.18336391e-02f, 7.02216029e-02f, 1.64125696e-01f,
  2.78083608e-02f, -1.20816335e-01f, 2.38030106e-02f, 3.09697799e-02f, -7.96637982e-02f, 1.08649336e-01f, -1.31157367e-02f, 7.67249763e-02f, -1.58413071e-02f, 1.18308850e-01f,
  2.03799382e-01f, -6.76988959e-02f, -1.15434937e-01f, 8.25537071e-02f, 5.74491313e-03f, 4.23448682e-02f, 5.18015027e-02f, 8.90569091e-02f, -6.41986206e-02f, -1.12132400e-01f,
  3.03381562e-01f, 2.67875612e-01f, 2.49703780e-01f, 2.98208922e-01f, 3.69211763e-01f, 1.69595871e-02f, -1.26076117e-01f, 2.92258739e-01f, 2.83616990e-01f, -1.46038830e-01f,
  1.54928062e-02f, 3.00670434e-02f, 9.67081860e-02f, 3.60780805e-01f, -1.98348388e-01f, -2.32546739e-02f, 2.09617063e-01f, -1.77046120e-01f, -1.34620503e-01f, 2.63050813e-02f,
  -1.24926664e-01f, 3.15018743e-02f, -4.26104702e-02f, 9.43692848e-02f, 1.62380055e-01f, -1.31073132e-01f, -4.92046885e-02f, 5.66874295e-02f, 3.47759128e-02f, 2.70847827e-01f,
  -4.00313027e-02f, 2.58027134e-03f, 5.88124037e-01f, 2.55367786e-01f, -2.33793199e-01f, 2.85318904e-02f, -5.20717017e-02f, 1.58659101e-01f, 1.66651681e-01f, -1.10965744e-01f,
  6.75192922e-02f, -5.00015765e-02f, 2.68888175e-01f, -7.09494799e-02f, -1.26431227e-01f, 5.85616603e-02f, 3.53771746e-02f, -8.69976580e-02f, -5.88223189e-02f, 1.35550097e-01f,
  3.72760952e-01f, 1.80546284e-01f, 6.50395155e-02f, -2.14377269e-01f, -1.62070000e-03f, -7.23007023e-02f, 1.70543641e-01f, 1.11646898e-01f, 4.95061763e-02f, -1.22778431e-01f,
  1.13844229e-02f, -1.35619134e-01f, 7.50679374e-02f, 3.93319800e-02f, 9.92827192e-02f, -7.35334232e-02f, -1.55326203e-02f, 1.85694415e-02f, 1.00155920e-01f, 1.43875539e-01f,
  4.03966270e-02f, -1.32188033e-02f, -1.15281463e-01f, 4.96176928e-02f, -5.22940606e-02f, 1.29242808e-01f, -1.21650230e-02f, -6.92719314e-03f, -8.13739002e-02f, 5.79973683e-02f,
  -1.24867767e-01f, 1.72835812e-01f, -5.86785302e-02f, 1.84883159e-02f, -3.92033672e-03f, 4.27975040e-03f, -1.30417362e-01f, -8.70823786e-02f, 3.48227955e-02f, -1.11352332e-01f,
  -6.57547191e-02f, 2.75544841e-02f, 2.11708304e-02f, 5.60247339e-02f, 1.11390226e-01f, 1.13274470e-01f, -3.70899886e-02f, 2.98167877e-02f, -5.22011928e-02f, 3.28869894e-02f,
  8.67550969e-02f, -1.10784657e-01f, -2.11589946e-03f, -3.92579623e-02f, -1.55567462e-02f, -1.01949023e-02f, 1.20250829e-01f, 3.59490402e-02f, 1.43241882e-01f, 4.39116508e-02f,
  5.19884974e-02f, -1.29311725e-01f, -1.39853265e-02f, 2.25022621e-02f, 1.74594019e-02f, 1.28777608e-01f, 6.44703582e-02f, 1.50444493e-01f, 1.22762464e-01f, -1.30569205e-01f,
  1.07591502e-01f, -6.20593540e-02f, 5.15427142e-02f, -1.22576974e-01f, 4.86849323e-02f, 9.85411704e-02f, -4.29880731e-02f, 3.25951204e-02f, -6.42854720e-02f, 5.57570010e-02f,
  2.43651401e-02f, -1.30561059e-02f, 1.49501830e-01f, 1.77724026e-02f, -1.59842178e-01f, -1.73155621e-01f, -1.50050521e-01f, 1.08963139e-02f, -4.29368392e-03f, 1.89919174e-01f,
  1.27999425e-01f, 1.48552731e-01f, 9.12031233e-02f, 1.13417529e-01f, 1.38414083e-02f, 8.46600235e-02f, 1.58561140e-01f, -4.74999361e-02f, -5.21009080e-02f, -6.59567267e-02f,
  -1.53753147e-01f, -7.78743103e-02f, 7.75548667e-02f, -8.26270208e-02f, -3.45133878e-02f, 1.43660381e-01f, -1.31024942e-01f, -1.32588193e-01f, -1.17937200e-01f, -3.42731886e-02f,
  8.20296556e-02f, 2.47537121e-02f, -6.17277697e-02f, -1.44103870e-01f, -1.23410814e-01f, 8.28718618e-02f, -8.41551870e-02f, 9.25274342e-02f, -1.21818513e-01f, 7.88350478e-02f,
  -1.06561057e-01f, -8.07188898e-02f, -1.12519801e-01f, -1.18038051e-01f, -2.98584811e-02f, -1.26607388e-01f, 5.60970083e-02f, 8.11205134e-02f, 4.48182179e-03f, -5.40027395e-02f,
  -8.15939158e-02f, -1.12587243e-01f, -1.27097040e-01f, -1.27187520e-01f, -4.96228151e-02f, -7.27691203e-02f, 3.10595687e-02f, 1.05231561e-01f, 6.00638390e-02f, -7.51617625e-02f,
  -1.07012160e-01f, 8.47629011e-02f, 6.71762004e-02f, 1.04716413e-01f, 6.63690874e-03f, 6.84910193e-02f, 7.01678768e-02f, 2.77521368e-03f, 5.20180166e-03f, -6.75901920e-02f,
  -1.52474329e-01f, 1.62898488e-02f, 1.77285030e-01f, 7.95642287e-02f, 4.87309322e-03f, 1.98152065e-02f, 2.10854672e-02f, -1.09481830e-02f, -4.84134145e-02f, 2.30010133e-03f,
  -1.61658507e-02f, -4.75838706e-02f, -6.58446476e-02f, -9.17120427e-02f, -1.26147524e-01f, 3.88874114e-02f, -1.78974960e-02f, -2.18186397e-02f, 1.00811101e-01f, 4.29139696e-02f,
  -1.14586338e-01f, 3.40378210e-02f, -3.85264270e-02f, -1.05094723e-03f, 1.76384374e-01f, -1.11816272e-01f, 1.32216476e-02f, -2.05338039e-02f, -4.69828025e-02f, 2.05602702e-02f,
  7.08885342e-02f, 9.82717946e-02f, 6.90045431e-02f, 1.66574210e-01f, -3.73070128e-02f, -1.24690257e-01f, 1.03219375e-02f, 7.00073689e-02f, -1.52355693e-02f, 3.25725563e-02f,
  -5.09899557e-02f, -2.40059923e-02f, 2.03842655e-01f, 6.90593719e-02f, -2.65373918e-03f, -7.23666511e-03f, -6.41234368e-02f, 5.76841459e-02f, -1.37456460e-02f, -9.44979712e-02f,
  -3.29248719e-02f, 2.76567135e-02f, -1.55513793e-01f, 1.04126334e-01f, -1.27018824e-01f, 6.34334460e-02f, 2.93826498e-02f, 1.49251506e-01f, 9.81990620e-02f, 3.72764319e-02f,
  1.78844988e-01f, 5.01701869e-02f, 4.97809760e-02f, 1.13824099e-01f, -1.76585857e-02f, -1.48906186e-01f, -4.96090464e-02f, -1.16792418e-01f, 9.53567028e-02f, 7.08474666e-02f,
  -1.49157092e-01f, -9.91687253e-02f, 1.10681109e-01f, -5.91565259e-02f, -1.01652242e-01f, 9.39314216e-02f, 8.66985694e-02f, -7.05937892e-02f, -6.08439818e-02f, 5.46814781e-03f,
  1.53339356e-01f, 9.38973427e-02f, 5.84586598e-02f, 9.93785858e-02f, 6.81914836e-02f, 1.65193185e-01f, -5.73024387e-03f, -9.89041850e-02f, 2.86138356e-01f, -3.18119042e-02f,
  -1.12545580e-01f, -3.14159086e-03f, 1.13706738e-01f, -1.50418403e-02f, -3.30037884e-02f, 8.56960006e-03f, 1.23361588e-01f, -9.25198197e-02f, 6.19260855e-02f, -1.10203922e-01f,
  -1.05871499e-01f, 9.50219110e-02f, -1.08496547e-01f, 5.63406534e-02f, -2.64989305e-02f, 1.74550922e-03f, 1.11379214e-01f, 1.12007014e-01f, 1.16255336e-01f, 9.85292494e-02f,
  -6.25213534e-02f, -8.55405405e-02f, 5.58617115e-02f, -5.68495803e-02f, 8.19649249e-02f, 8.17199238e-03f, 5.66331744e-02f, 7.44028017e-02f, 9.58306622e-03f, -9.02138874e-02f,
  1.25710085e-01f, 1.72041729e-02f, 1.45972595e-01f, 1.99686021e-01f, 2.66448498e-01f, 2.35776111e-01f, -1.36383429e-01f, -1.40789002e-01f, -1.10574253e-01f, -1.59900934e-01f,
  2.11347610e-01f, 2.34981135e-01f, 1.41979173e-01f, -2.35949121e-02f, 1.30466849e-01f, 1.61905408e-01f, -1.58000842e-01f, 1.22502521e-01f, 2.47993797e-01f, 1.76659040e-02f,
  -2.24488005e-02f, 1.41914830e-01f, -6.64851442e-02f, -4.79701869e-02f, 1.01434097e-01f, -1.86286807e-01f, -1.35656655e-01f, 3.67327332e-02f, 3.23915817e-02f, -9.67729315e-02f,
  -2.13487931e-02f, 4.49662562e-03f, 2.16321617e-01f, -5.23753203e-02f, 6.36731684e-02f, -1.73207045e-01f, 1.00411233e-02f, 4.34224419e-02f, 1.22976564e-02f, 1.39748221e-02f,
  -1.73112690e-01f, 1.73447609e-01f, -3.59336138e-02f, -1.82930410e-01f, -5.16139045e-02f, 7.66480714e-02f, 1.22794518e-02f, -2.87360549e-02f, 1.56473219e-01f, -3.98207009e-02f,
  1.10707745e-01f, 3.88042629e-02f, 2.70107742e-02f, 2.18571052e-02f, 6.01076558e-02f, -1.32034525e-01f, -9.12451297e-02f, -2.27668229e-03f, -1.39013723e-01f, -7.27878511e-02f,
  2.99224742e-02f, -1.98841002e-02f, -8.56429413e-02f, -2.99244244e-02f, 1.29770100e-01f, -4.77885269e-02f, -8.51285979e-02f, -6.85035735e-02f, 5.05640097e-02f, 2.30792403e-01f,
  3.31637561e-02f, -9.29469317e-02f, 3.43743339e-02f, -1.36535419e-02f, 1.51451811e-01f, -1.33594215e-01f, -6.19802400e-02f, 1.06266879e-01f, 2.43916586e-02f, 1.41599134e-01f,
  -3.58282439e-02f, 1.78311735e-01f, -9.04693380e-02f, -9.74119008e-02f, -5.41073121e-02f, 7.55169615e-02f, -1.23890355e-01f, 3.21766622e-02f, 7.55198002e-02f, -1.41679691e-02f,
  1.51251748e-01f, 1.15348563e-01f, 1.20755091e-01f, 1.84160843e-02f, 1.41216800e-01f, -1.29017845e-01f, 2.62213111e-01f, 2.48472840e-01f, -2.96834819e-02f, -1.67562917e-01f,
  -1.19270593e-01f, 8.03381503e-02f, -6.83833435e-02f, 2.27796853e-01f, -9.04947296e-02f, -1.77404601e-02f, -3.57931443e-02f, -3.81521173e-02f, 1.59550458e-02f, -1.28749430e-01f,
  3.15166786e-02f, -1.21385381e-01f, 5.06479386e-03f, -8.79913494e-02f, 6.20702989e-02f, 1.86739519e-01f, -5.63271940e-02f, 3.27852666e-02f, -1.85598936e-02f, -4.99307439e-02f,
  -9.97366905e-02f, -1.23572499e-02f, -1.31845735e-02f, 9.42194760e-02f, 1.00947522e-01f, -8.71156603e-02f, 8.36649165e-02f, -1.84954569e-01f, -2.10415944e-02f, -2.97489837e-02f,
  3.17272432e-02f, 1.47123426e-01f, 1.50496349e-01f, 1.80806473e-01f, 2.83862978e-01f, 4.89687212e-02f, -1.79740749e-02f, 2.11010203e-01f, -7.11036474e-02f, -2.35436037e-02f,
  -1.38263717e-01f, -1.64647661e-02f, -3.94647866e-02f, 4.07521427e-02f, 6.70051128e-02f, 7.28949159e-02f, -1.23451337e-01f, 1.64183185e-01f, -1.92539897e-02f, 1.85228258e-01f,
  -8.21053889e-03f, -1.45832868e-02f, 5.88463545e-02f, 1.05532911e-02f, -4.74853814e-02f, -4.37720753e-02f, -2.55933199e-02f, -1.07103679e-02f, 2.30798438e-01f, -1.54732659e-01f,
  6.32054433e-02f, 1.45989824e-02f, 8.27823207e-02f, 1.56345159e-01f, -9.13371071e-02f, 1.47870496e-01f, 2.77778357e-01f, 1.36640996e-01f, 1.71751916e-01f, -8.79156962e-02f,
  3.34176347e-02f, 1.16475955e-01f, 8.01309478e-03f, -1.26927830e-02f, -1.04702465e-01f, -9.33301374e-02f, -1.31859764e-01f, 1.09644294e-01f, -8.56181514e-03f, -1.42887443e-01f,
  3.00778728e-02f, -3.95515449e-02f, 2.24231392e-01f, 1.65855773e-02f, 1.18007265e-01f, 6.17684498e-02f, -1.07588723e-01f, 8.61470625e-02f, 8.77584666e-02f, -5.29705249e-02f,
  -7.59297088e-02f, 1.10057890e-01f, 7.50608295e-02f, -6.90455064e-02f, 1.34622410e-01f, -1.54983670e-01f, -1.64812624e-01f, 1.41738921e-01f, 1.38595104e-01f, 3.01366895e-02f,
  4.44051586e-02f, 1.50086418e-01f, 8.89696460e-03f, 1.26600772e-01f, 2.01213509e-02f, -1.44106761e-01f, 2.09979769e-02f, 2.54555851e-01f, -1.50838792e-01f, 8.60633180e-02f,
  1.14240363e-01f, -3.39418724e-02f, 9.32655856e-02f, 3.90213169e-02f, 1.62238106e-01f, 8.35111588e-02f, -5.57639822e-02f, 4.30238731e-02f, 4.14148858e-03f, 7.51901418e-02f,
  3.99791822e-02f, 2.34030411e-02f, 2.29249045e-01f, 1.15793748e-02f, -2.46776417e-01f, 7.83964321e-02f, 3.18633467e-01f, 2.04827130e-01f, -1.13510162e-01f, 1.08503833e-01f,
  -5.40898405e-02f, 1.93347000e-02f, 1.63176596e-01f, 1.23868391e-01f, -3.78950350e-02f, 1.15930222e-01f, 8.48185122e-02f, 9.75997299e-02f, 1.08667105e-01f, -1.24669150e-01f,
  8.28305036e-02f, 3.27301212e-02f, -6.15929104e-02f, 1.65404670e-03f, 6.56123608e-02f, 1.96920127e-01f, 1.96274236e-01f, 2.28705838e-01f, -8.17411095e-02f, 5.55199981e-02f,
  -9.74328890e-02f, -1.06197119e-01f, 2.80587852e-01f, -1.43260658e-02f, 1.00097485e-01f, 7.53776208e-02f, -6.59949034e-02f, 1.10234141e-01f, -8.12742263e-02f, 1.47674400e-02f,
  1.51785105e-01f, 1.31933942e-01f, -3.30162048e-02f, 3.03452881e-03f, -1.20169789e-01f, -1.24493845e-01f, 1.29703656e-01f, 1.55480117e-01f, -9.00325738e-03f, 1.10511683e-01f,
  9.73073468e-02f, 3.44204932e-01f, 1.62304267e-02f, 9.95018855e-02f, 1.23986080e-01f, -3.98694351e-02f, -9.84883308e-02f, 3.33521850e-02f, -4.15420113e-03f, 7.42454827e-02f,
  3.98869626e-02f, 7.48248026e-02f, -4.81029749e-02f, 1.88735783e-01f, -1.49447834e-02f, 1.17303491e-01f, 1.04851030e-01f, 6.88358992e-02f, 5.23226075e-02f, -6.07516542e-02f,
  1.72760844e-01f, -1.36028752e-01f, 2.77564954e-02f, -1.08457081e-01f, 1.02807134e-01f, 8.70416313e-02f, 2.74701845e-02f, -1.33409724e-01f, -8.91001821e-02f, 2.17990577e-02f,
  1.34173483e-01f, -1.71569195e-02f, 8.76218528e-02f, 3.98425497e-02f, -1.16056114e-01f, -2.95353606e-02f, -5.24279289e-02f, 7.68345594e-02f, -9.08379778e-02f, 3.26202363e-02f,
  1.54904038e-01f, -8.82841721e-02f, 2.46648952e-01f, -6.38788268e-02f, 1.26292408e-01f, 5.46841435e-02f, 2.02801883e-01f, -6.81028515e-02f, 4.59881276e-02f, -3.46695669e-02f,
  1.09947100e-02f, -1.92550085e-02f, 2.83448789e-02f, 8.48584846e-02f, 7.22135156e-02f, -1.12859253e-02f, 1.62863240e-01f, 5.91913797e-02f, -5.49681038e-02f, 8.57756566e-03f,
  -1.57477017e-02f, 4.67885248e-02f, 9.28413868e-02f, -1.09558001e-01f, -6.08628169e-02f, -4.02167905e-03f, -3.55259329e-02f, 1.94423795e-01f, 1.15398586e-01f, 1.43075854e-01f,
  -1.41091300e-02f, -1.75134987e-02f, -3.41825485e-02f, 1.20677380e-02f, 8.02975222e-02f, 1.58877403e-01f, -7.97502548e-02f, -5.23494221e-02f, -9.68312919e-02f, -1.22825608e-01f,
  -9.75078866e-02f, 3.68966833e-02f, -1.37620926e-01f, -3.57220396e-02f, 1.70424223e-01f, 1.60297930e-01f, 1.01766773e-01f, 6.94691017e-02f, 2.14811876e-01f, -2.83727013e-02f,
  6.30742311e-02f, 6.07124902e-02f, -7.60068521e-02f, -6.67441869e-03f, -5.21457084e-02f, 2.88881231e-02f, 7.83972442e-02f, -1.04559273e-01f, 3.59759852e-02f, -5.40333726e-02f,
  -1.21681519e-01f, 1.22441605e-01f, -7.22145140e-02f, -3.69999111e-02f, 1.42770261e-01f, 7.54776821e-02f, 1.58377215e-01f, 1.50587671e-02f, 9.04868320e-02f, -2.57932441e-03f,
  2.36201227e-01f, -3.00829597e-02f, -1.37573004e-01f, -2.05017179e-02f, 4.95923199e-02f, 5.26686125e-02f, 9.03763156e-03f, -7.32575133e-02f, 1.75232649e-01f, 2.66707074e-02f,
  -7.26547390e-02f, 8.58429447e-02f, 9.88602415e-02f, -1.67752743e-01f, -5.15447669e-02f, 1.08863622e-01f, 1.49155399e-02f, 5.64389490e-02f, -2.74498481e-02f, 2.23889835e-02f,
  2.01815646e-02f, -4.27008271e-02f, 4.26495783e-02f, 1.05480626e-01f, -1.17944583e-01f, 5.28686345e-02f, 7.18778148e-02f, 2.33993568e-02f, -8.06672424e-02f, -1.12893373e-01f,
  -1.26139358e-01f, 1.07372455e-01f, -7.78154060e-02f, 2.31686141e-02f, -1.32260203e-01f, 6.66392744e-02f, 3.46640907e-02f, 5.08534126e-02f, -1.22743351e-02f, -8.00887719e-02f,
  -1.02445595e-02f, 8.14199746e-02f, -7.55263418e-02f, -6.42245337e-02f, 1.07100584e-01f, 1.16677962e-01f, 3.72064225e-02f, -1.04623325e-01f, -1.03809237e-01f, 5.63101023e-02f,
  -3.18655595e-02f, -6.41513765e-02f, 8.87908489e-02f, 1.23006515e-01f, 1.87689885e-01f, -1.15614720e-01f, -1.08239043e-03f, 3.28570530e-02f, -7.13008121e-02f, -1.21286116e-03f,
  -8.42188746e-02f, 5.63373379e-02f, 2.20258744e-03f, -1.21235453e-01f, -2.32864395e-02f, -5.58271222e-02f, -7.98407272e-02f, -9.01539177e-02f, 2.76253879e-01f, 9.34248343e-02f,
  1.10705085e-01f, 1.19970627e-02f, 7.00270981e-02f, 5.16760200e-02f, -1.23143360e-01f, -1.38835728e-01f, -8.22190568e-02f, -2.72270024e-01f, 1.96952194e-01f, 2.59587616e-01f,
  4.68282104e-02f, 2.41251007e-01f, 2.14105114e-01f, -1.41406819e-01f, -1.08210124e-01f, 1.71342924e-01f, 1.78399935e-01f, -4.10326272e-02f, 1.09836727e-01f, 3.10089644e-02f,
  -1.52007177e-01f, 1.16210885e-01f, 5.17661497e-02f, 9.90226641e-02f, -1.00644961e-01f, 7.64420405e-02f, -1.74142689e-01f, -7.86409229e-02f, -1.05886720e-01f, -3.15208212e-02f,
  2.36832872e-01f, 8.32209662e-02f, -9.09593999e-02f, 1.20012211e-02f, -5.03628440e-02f, 5.76409884e-03f, -1.66262910e-02f, -5.05710319e-02f, 3.22700329e-02f, 4.35490757e-01f,
  8.44165385e-02f, -4.22937013e-02f, -7.20771477e-02f, 6.20868616e-02f, 3.79854143e-02f, -4.63752672e-02f, 2.13010401e-01f, 2.99871881e-02f, 2.69750148e-01f, 9.41444710e-02f,
  -8.45046043e-02f, -1.05127603e-01f, -1.23673595e-01f, -1.51476607e-01f, -1.76382083e-02f, -1.90242872e-01f, -1.54558718e-01f, -1.49594292e-01f, -1.59829542e-01f, -9.66679603e-02f,
  -7.80179212e-03f, -1.02512904e-01f, -7.98618272e-02f, -9.40459892e-02f, -1.52062029e-01f, -5.49081117e-02f, -1.49396896e-01f, -2.79167779e-02f, 5.63803781e-03f, -6.17814735e-02f,
  -8.40970650e-02f, -9.55669284e-02f, 1.37268156e-01f, 2.12706141e-02f, -1.85877886e-02f, 1.26080990e-01f, 8.88315812e-02f, -3.51827070e-02f, -5.69780022e-02f, 2.25264385e-01f,
  -5.29722683e-02f, -1.24437764e-01f, 1.20271020e-01f, -8.77093598e-02f, 6.48427829e-02f, -3.36403400e-02f, 1.00136466e-01f, 7.34795481e-02f, 6.93440577e-03f, -3.32406163e-02f,
  7.16115832e-02f, 1.18069440e-01f, 1.18652910e-01f, 4.36557131e-03f, 1.29232928e-01f, 1.02149874e-01f, 6.65812269e-02f, 1.49191633e-01f, 1.09640241e-01f, 9.65939462e-02f,
  -1.38776954e-02f, 1.78447887e-01f, 2.73316447e-02f, 1.41226664e-01f, 5.32770418e-02f, 1.24118000e-01f, 3.75380404e-02f, 6.00239858e-02f, -3.46868932e-02f, -1.38418049e-01f,
  -3.55986245e-02f, 6.80598468e-02f, -1.64707094e-01f, 1.71246845e-02f, 2.77360734e-02f, -1.08695859e-02f, 1.02624677e-01f, 1.00995325e-01f, -8.29066411e-02f, -2.67321873e-03f,
  -6.94551086e-03f, 8.73349905e-02f, 1.47717580e-01f, -8.71012285e-02f, -3.28953490e-02f, -9.99785066e-02f, 1.89895615e-01f, -4.92287278e-02f, -7.17109477e-04f, 1.06461287e-01f,
  1.18782595e-01f, 7.68377706e-02f, -7.29061291e-02f, 1.06252268e-01f, 9.99847203e-02f, -3.34458165e-02f, 1.39585480e-01f, 2.26564199e-01f, 5.85122295e-02f, 9.76606905e-02f,
  8.48181173e-02f, 3.47882733e-02f, 6.74045756e-02f, 1.62645325e-01f, -4.01215702e-02f, -8.49926025e-02f, -5.76789752e-02f, 1.36528268e-01f, -7.78331459e-02f, -8.74123944e-05f,
  1.44935355e-01f, -5.74566461e-02f, 9.52310394e-03f, 9.50461403e-02f, 4.63042669e-02f, 2.91308034e-02f, 3.22139487e-02f, -6.65675923e-02f, 1.78552046e-01f, -8.57459605e-02f,
  3.97398062e-02f, 7.72903785e-02f, 2.59148572e-02f, -1.24164470e-01f, -1.22385249e-02f, 1.79624006e-01f, 6.94384873e-02f, -1.68441497e-02f, 8.50903168e-02f, 1.06807567e-01f,
  -5.11958487e-02f, -1.73998252e-02f, -2.09981631e-02f, 1.00298069e-01f, 1.25519261e-01f, 3.42519172e-02f, 6.74084434e-03f, 2.56382804e-02f, -4.15088907e-02f, 6.19016550e-02f,
  1.35785386e-01f, -1.00561254e-01f, -6.08275086e-03f, 9.24919993e-02f, 5.11358790e-02f, 1.35999527e-02f, 4.56601903e-02f, -4.29823771e-02f, -4.13822383e-02f, 4.69115973e-02f,
  -9.62713137e-02f, -6.72111101e-03f, 5.59438244e-02f, -1.27869233e-01f, -7.93207437e-02f, 1.31902725e-01f, -1.35461032e-01f, 1.14403563e-02f, -4.92491722e-02f, -5.59464656e-03f,
  -2.77901795e-02f, -1.50738871e-02f, -1.83271971e-02f, -2.09699478e-02f, 1.36798203e-01f, -1.36522770e-01f, -3.30554545e-02f, 6.18729107e-02f, 1.23828322e-01f, 4.74827066e-02f,
  -8.94838348e-02f, 4.91017289e-02f, 1.50338141e-02f, -8.88312934e-04f, -8.61484744e-03f, 1.22719668e-01f, 9.20711830e-02f, 5.82227893e-02f, 5.47449104e-02f, -7.04036430e-02f,
  6.61034286e-02f, 1.81969870e-02f, -1.53339311e-01f, 1.63057458e-03f, 5.43194897e-02f, -5.60352914e-02f, -1.49332546e-02f, -1.28266618e-01f, 1.06938817e-01f, 5.39114848e-02f,
  3.53362598e-02f, 1.25111237e-01f, -1.23269856e-01f, -1.31262140e-02f, -1.24530226e-01f, 1.15442678e-01f, -9.64536220e-02f, -8.66849646e-02f, 1.21452250e-01f, 8.75169262e-02f,
  -8.58786181e-02f, 4.96287979e-02f, 2.65113879e-02f, -1.26045018e-01f, -1.79462820e-01f, -5.36892563e-02f, -5.03558554e-02f, -3.42085771e-02f, -1.06391953e-02f, -1.23033501e-01f,
  -1.60734747e-02f, 5.29682152e-02f, 1.44853648e-02f, -1.38401181e-01f, 1.69675425e-01f, 1.61646381e-01f, 5.84287532e-02f, -4.50659096e-02f, 1.83927178e-01f, 6.40429854e-02f,
  -1.67183340e-01f, -2.20252331e-02f, -1.64956099e-03f, -1.59689918e-01f, 8.35512057e-02f, 2.42742300e-02f, -1.27757527e-02f, 2.35193878e-01f, 5.67746833e-02f, 6.39162585e-02f,
  9.25002098e-02f, 1.50256574e-01f, 6.36557043e-02f, -9.12863016e-02f, -1.09803878e-01f, -4.61143330e-02f, -1.56319022e-01f, -1.25032753e-01f, 7.57247731e-02f, 1.20891720e-01f,
  -8.22033435e-02f, 1.30453676e-01f, -6.71887025e-02f, 2.02080861e-01f, -4.14021872e-02f, 2.04754528e-02f, 1.80175096e-01f, 1.94745436e-01f, 4.26852293e-02f, -1.29776329e-01f,
  -7.49497041e-02f, -1.16220117e-01f, 3.11745685e-02f, -4.64299098e-02f, 6.66257367e-02f, 1.75175983e-02f, 6.41165152e-02f, 2.67089028e-02f, 1.02460153e-01f, -7.81170577e-02f,
  -5.02712838e-02f, -3.40588987e-02f, -3.20316516e-02f, -4.88807783e-02f, 2.37607360e-01f, 1.04608327e-01f, 1.13754548e-01f, -5.35539836e-02f, -1.38993010e-01f, -9.64583084e-02f,
  1.10125700e-02f, -7.31796175e-02f, -7.00050145e-02f, -7.94535428e-02f, 5.46747781e-02f, -1.01163901e-01f, -8.96042585e-02f, 1.55171119e-02f, -1.04169235e-01f, 1.09039314e-01f,
  -6.93995059e-02f, 1.18918315e-01f, -9.11055654e-02f, 1.07495174e-01f, -7.08309188e-02f, 2.49504447e-02f, 1.79220480e-03f, -5.92151331e-03f, -7.81833678e-02f, 8.41226950e-02f,
  4.26669605e-02f, -1.81996487e-02f, 2.21342649e-02f, 2.89867789e-01f, -4.81242239e-02f, -4.48733680e-02f, 1.40330568e-02f, -1.02779791e-01f, -7.72818103e-02f, 5.16989082e-02f,
  -9.57205966e-02f, -1.55180503e-04f, -6.03926554e-02f, 7.60477558e-02f, 2.47025844e-02f, 3.61832902e-02f, 2.33193077e-02f, 3.49251330e-02f, 2.40470693e-02f, -5.02386726e-02f,
  4.55357991e-02f, 2.56966706e-02f, 1.37429565e-01f, -1.48002654e-02f, -3.72196324e-02f, -6.52592406e-02f, -1.10905960e-01f, 5.09868003e-02f, -2.24918453e-03f, -5.00644855e-02f,
  -4.84112446e-04f, -2.52386741e-02f, 9.09776762e-02f, -1.08109117e-02f, 1.08016860e-02f, 1.26427919e-01f, 2.70810481e-02f, -8.71219933e-02f, -9.97789800e-02f, -9.38664451e-02f,
  9.29498672e-03f, -2.19901837e-03f, -3.66669297e-02f, 2.99327821e-02f, 8.24718475e-02f, 2.62904316e-02f, 9.94103309e-03f, -3.71926092e-02f, -1.07478887e-01f, 9.53750610e-02f,
  -2.48734616e-02f, 4.14606407e-02f, -3.11055481e-02f, -5.82805388e-02f, 4.56219353e-03f, -2.24979762e-02f, 5.38559398e-03f, 8.31278861e-02f, 3.19754481e-02f, -2.27458235e-02f,
  7.84122720e-02f, -9.71497595e-02f, -4.91468050e-02f, -1.34331003e-01f, -2.78261621e-02f, -1.17865130e-01f, -5.67609631e-02f, 2.93345805e-02f, -5.54254837e-02f, 9.10111144e-02f,
  -2.32653674e-02f, 9.17308331e-02f, 7.55812898e-02f, -5.37402108e-02f, 1.06323466e-01f, -5.93966134e-02f, -1.80346109e-02f, 2.17714370e-03f, 4.33266088e-02f, -9.81798992e-02f,
  9.43217650e-02f, 4.40416746e-02f, -6.62011206e-02f, 1.77394189e-02f, -1.61952704e-01f, -6.51038438e-02f, 1.93935052e-01f, 1.82570249e-01f, -8.55003819e-02f, -5.68741634e-02f,
  6.87138587e-02f, 9.97625366e-02f, 6.83418438e-02f, 4.60773408e-02f, 2.96759326e-02f, 1.37349993e-01f, -6.52287006e-02f, 1.60493821e-01f, -2.45268587e-02f, -1.18466489e-01f,
  -6.82048351e-02f, 6.47238269e-02f, -1.48962960e-01f, 8.43411833e-02f, -1.15086995e-01f, 1.62463292e-01f, -1.36875108e-01f, -5.90280071e-02f, 2.98079196e-02f, -5.00751622e-02f,
  -1.44048497e-01f, 8.35080724e-03f, 2.57202059e-01f, 2.89006718e-02f, 2.13506110e-02f, -2.16607172e-02f, -7.05549121e-02f, 1.66256994e-01f, 1.72886088e-01f, -8.64839926e-02f,
  -5.88462427e-02f, -4.56799194e-02f, 8.41191933e-02f, 1.29293175e-02f, -1.20804027e-01f, -1.92176685e-01f, 2.33781680e-01f, -2.56644338e-01f, 3.98207754e-02f, 5.91950305e-02f,
  6.37662783e-02f, 3.59053276e-02f, -1.05572857e-01f, -2.91601978e-02f, 9.32466052e-03f, 1.95695296e-01f, -1.03444740e-01f, -5.68583012e-02f, 7.85285681e-02f, 7.45842904e-02f,
  7.79619440e-02f, -9.15095508e-02f, -5.88839762e-02f, -6.17581829e-02f, 7.95258135e-02f, -2.28225981e-04f, -4.57709841e-02f, -4.01254743e-02f, 4.40361612e-02f, 1.06876284e-01f,
  -9.26390011e-03f, -6.09279349e-02f, 6.52298033e-02f, -4.93970923e-02f, 4.97632287e-02f, 6.23568967e-02f, 1.39826566e-01f, -1.31144747e-01f, 3.59520800e-02f, -5.38595095e-02f,
  -4.30484712e-02f, -1.27214603e-02f, 8.60493556e-02f, 7.82290027e-02f, 4.88990620e-02f, 8.89594555e-02f, -9.11365598e-02f, 8.17176029e-02f, -2.07491145e-02f, -3.74982581e-02f,
  -1.80098098e-02f, 3.28752548e-02f, 5.96914850e-02f, 3.14023793e-02f, 6.68902695e-02f, 8.67859274e-02f, 1.89379781e-01f, 8.10929313e-02f, -5.58630330e-03f, -1.35995612e-01f,
  9.04099718e-02f, -8.35939217e-03f, -1.48836924e-02f, -8.87264311e-03f, 5.30772582e-02f, 1.02182344e-01f, 1.22919522e-01f, 7.14857643e-03f, 9.84196179e-03f, 1.90883830e-01f,
  -1.35063156e-01f, 2.81141512e-02f, -1.08399857e-02f, 6.16761819e-02f, -1.06124826e-01f, -3.28638107e-02f, -5.60938492e-02f, 3.77693772e-02f, -3.87725458e-02f, 1.46671638e-01f,
  -1.05904557e-01f, -2.25619301e-02f, 8.78925771e-02f, 5.05195744e-02f, 3.02168522e-02f, -1.01703450e-01f, -7.43651856e-03f, 7.30828270e-02f, 4.79288474e-02f, -2.98087467e-02f,
  2.48470932e-01f, -1.24707110e-01f, 2.52879620e-01f, 1.55417800e-01f, -4.26683091e-02f, -1.65920496e-01f, 1.11818612e-01f, 1.21648185e-01f, 3.56394611e-02f, 2.13854253e-01f,
  3.55821662e-02f, -2.92175740e-01f, 1.50157541e-01f, 9.86832753e-02f, 7.54664391e-02f, -1.72106549e-01f, 7.70568773e-02f, 6.03180155e-02f, 8.90872031e-02f, 1.44493043e-01f,
  1.57443032e-01f, -8.01177099e-02f, 3.38760167e-02f, -9.55954939e-02f, 2.76666313e-01f, 9.81279835e-02f, 9.65922847e-02f, -6.96845502e-02f, -1.01466589e-01f, -8.83989483e-02f,
  2.64672190e-01f, 1.01533242e-01f, -5.85080497e-02f, 1.84710964e-03f, 2.38742549e-02f, 1.61565274e-01f, 6.71913847e-02f, 3.59321721e-02f, 9.09262002e-02f, -2.07670629e-02f,
  6.49443194e-02f, 1.68934897e-01f, 2.39733353e-01f, -1.54821686e-02f, -1.57546893e-01f, 9.89562869e-02f, 7.35801086e-02f, -1.27476111e-01f, -5.90221398e-02f, 4.52641964e-01f,
  1.19383708e-02f, 9.68872160e-02f, 6.00269064e-02f, 8.42954218e-02f, -1.22717477e-01f, 1.33420518e-02f, 1.25201955e-01f, 1.11003987e-01f, 1.58068776e-01f, -5.14416434e-02f,
  7.37145841e-02f, -6.39580488e-02f, -7.71895573e-02f, 1.14324495e-01f, -8.72623846e-02f, 9.01668519e-02f, -8.88893753e-02f, -6.39674738e-02f, 1.53738841e-01f, -1.21743329e-01f,
  -7.61481235e-03f, -4.85245790e-03f, 8.55166116e-04f, 1.18907653e-01f, -9.33644176e-02f, -1.48136288e-01f, -1.36736035e-02f, 6.08503185e-02f, 1.39473379e-01f, -6.64994940e-02f,
  7.20374137e-02f, -3.69762518e-02f, -6.37366846e-02f, 1.64779853e-02f, 3.49701941e-02f, 6.41012564e-02f, -5.86168393e-02f, 2.69746967e-02f, 7.11595789e-02f, -3.33535634e-02f,
  2.72535503e-01f, 9.65907872e-02f, 6.00677729e-02f, 6.45276457e-02f, -4.13123481e-02f, 6.55252784e-02f, 9.28851813e-02f, 1.00318372e-01f, 6.12043291e-02f, 1.45702884e-01f,
  -5.39689809e-02f, 8.25468227e-02f, 2.57684123e-02f, 2.53465474e-01f, 1.16861373e-01f, 7.43157696e-03f, -2.24979281e-01f, -1.13950506e-01f, 6.54439852e-02f, -1.35353893e-01f,
  -8.48636851e-02f, -4.43194993e-02f, 1.11607783e-01f, 1.52418301e-01f, -1.46545973e-02f, 2.71499157e-01f, 8.52174312e-02f, 2.14769199e-01f, 5.56254089e-02f, 1.15914039e-01f,
  -6.28651157e-02f, -8.59014913e-02f, 6.93830475e-02f, 3.52052376e-02f, 1.43995762e-01f, 1.43357515e-01f, 9.88125950e-02f, 3.48818153e-02f, 1.61456652e-02f, -1.04341500e-01f,
  7.15730339e-02f, 5.35580553e-02f, 1.49369270e-01f, -1.11182682e-01f, 1.22730911e-01f, 5.39439805e-02f, -3.42471451e-02f, 1.81074768e-01f, -1.37192741e-01f, -1.23807386e-01f,
  1.88518483e-02f, -1.12142175e-01f, 1.68459639e-01f, -4.38144431e-02f, 1.63826659e-01f, -1.76197976e-01f, 4.82869744e-02f, -1.76029757e-01f, -9.47034657e-02f, 1.04391053e-02f,
  8.74572843e-02f, 1.32975549e-01f, 3.88515927e-03f, -7.32553005e-02f, -5.97273894e-02f, -8.09170827e-02f, 1.64841823e-02f, 7.50798441e-04f, 3.25313985e-01f, 2.34173238e-02f,
  -4.28965017e-02f, -1.86742440e-01f, 2.47613899e-03f, 7.41122141e-02f, -2.83750575e-02f, 3.17026898e-02f, -1.44225713e-02f, 2.41024494e-01f, -2.19245534e-02f, -1.45940587e-01f,
  -2.31789231e-01f, 1.36072174e-01f, -7.85061568e-02f, 1.71453834e-01f, -1.07592836e-01f, -1.18759565e-01f, -2.74980590e-02f, 1.35770902e-01f, -1.20920978e-01f, 2.09640577e-01f,
  2.12003514e-02f, 1.54055674e-02f, 1.06434174e-01f, 1.48719270e-02f, 1.47947501e-02f, 3.12402137e-02f, 1.34203181e-01f, -3.69362868e-02f, -6.07696213e-02f, 1.55616589e-02f,
  -3.25052887e-02f, -5.55259511e-02f, 1.79252967e-01f, -3.05652451e-02f, 1.27939999e-01f, 3.50396931e-02f, 1.05492193e-02f, -1.22753270e-02f, -9.88961682e-02f, -5.86799905e-02f,
  7.54719526e-02f, 1.74281389e-01f, -3.33816558e-02f, -1.49032354e-01f, -6.43691560e-03f, 1.16362922e-01f, 7.23300949e-02f, -1.68963850e-01f, -3.60814221e-02f, 9.69739109e-02f,
  1.03141412e-01f, -1.37555793e-01f, -1.32127134e-02f, 6.02547415e-02f, 1.25163257e-01f, 1.51623532e-01f, 9.25844982e-02f, -1.05179183e-01f, -1.36633605e-01f, -1.05161533e-01f,
  -2.73446981e-02f, -1.13567755e-01f, 2.26942509e-01f, -1.10476851e-01f, -1.44589886e-01f, -4.57611494e-02f, 1.25054315e-01f, -1.11426719e-01f, -9.83081013e-02f, -8.20527747e-02f,
  -5.72040044e-02f, 6.67929500e-02f, 1.32404208e-01f, -3.64783891e-02f, 8.94128829e-02f, -2.51863338e-02f, 8.90630484e-02f, -5.09097837e-02f, -4.44192439e-02f, 8.53083208e-02f,
  7.27392659e-02f, -3.17282565e-02f, 6.10876344e-02f, 1.11951388e-01f, 4.87356186e-02f, -3.50290048e-03f, -5.59832081e-02f, 1.83443781e-02f, 5.70398457e-02f, 1.02739640e-01f,
  -1.27853528e-01f, -7.96098560e-02f, -1.96131393e-02f, 8.00992027e-02f, 3.32289562e-02f, 6.70111477e-02f, -6.83342144e-02f, 5.13819605e-02f, 6.95099682e-02f, -3.75654884e-02f,
  2.15798005e-01f, 1.55894672e-02f, -5.40220216e-02f, -3.25802118e-02f, 7.06321672e-02f, 1.67337105e-01f, 1.87079310e-01f, 1.87760547e-01f, -1.43187329e-01f, -4.62419167e-02f,
  5.80833182e-02f, 8.06714222e-02f, -8.10884088e-02f, -1.24603733e-01f, -7.04600736e-02f, -3.37334685e-02f, 1.84536185e-02f, 2.63744015e-02f, 1.63933113e-02f, 1.42062828e-01f,
  5.22350222e-02f, 4.29983549e-02f, -1.27328590e-01f, -8.06515738e-02f, 7.79475272e-02f, 8.36762488e-02f, 2.37718537e-01f, -2.90094800e-02f, -1.44190505e-01f, -8.23877528e-02f,
  9.45096537e-02f, 1.09198704e-01f, -6.92579299e-02f, -5.49584888e-02f, 3.71692292e-02f, 3.67364436e-02f, -3.33711021e-02f, 9.86849051e-03f, 1.52491257e-01f, 7.64949471e-02f,
  1.00005105e-01f, 2.57337783e-02f, 9.92462710e-02f, 8.17606971e-03f, 5.02361953e-02f, -1.31446950e-03f, 2.66874135e-02f, 1.11450024e-01f, -5.73619343e-02f, 5.74632399e-02f,
  -8.63198377e-03f, -2.87376381e-02f, -2.19770777e-03f, 1.45262644e-01f, -7.46702030e-02f, 1.03290141e-01f, -1.31033897e-01f, -1.47503704e-01f, -7.59103820e-02f, 8.98051858e-02f,
  -7.08793402e-02f, 1.16735846e-01f, -8.18376020e-02f, -1.10603139e-01f, 7.00791739e-03f, 1.21634752e-01f, -2.73488760e-02f, 1.41713530e-01f, -1.04358494e-02f, -9.81299952e-02f,
  9.17830244e-02f, 7.70258233e-02f, -7.05071762e-02f, -4.08352762e-02f, -4.34301719e-02f, 2.61805058e-02f, 9.97857228e-02f, 1.23912804e-01f, 1.10291712e-01f, 1.25843883e-01f,
  -1.11444399e-01f, -8.91996399e-02f, -8.58939514e-02f, -3.72147076e-02f, -8.99036508e-03f, -2.68111452e-02f, 8.28923881e-02f, 1.12594508e-01f, -1.30498320e-01f, -1.00196786e-01f,
  9.67666283e-02f, -1.02082565e-01f, 1.35594428e-01f, -7.88013637e-02f, 3.59244645e-02f, 1.85732974e-03f, -5.75201213e-02f, -8.70246142e-02f, 6.15803935e-02f, -8.66009817e-02f,
  5.27985990e-02f, 3.13826278e-02f, 3.58393155e-02f, -9.37313512e-02f, -3.81567031e-02f, -6.67870715e-02f, -1.02784790e-01f, -1.14936739e-01f, -6.31716475e-03f, 3.20971832e-02f,
  1.14411958e-01f, 1.93433985e-02f, 8.36074203e-02f, 1.01074696e-01f, -2.48397011e-02f, 5.57265952e-02f, 6.25930056e-02f, 1.03072770e-01f, -8.04903209e-02f, 6.85354024e-02f,
  -1.18629858e-02f, 8.11976660e-03f, -5.00146113e-02f, -4.58448716e-02f, -5.86782135e-02f, -1.00310281e-01f, 1.23061985e-01f, -1.33275781e-02f, -6.94805682e-02f, -1.12968527e-01f,
  1.23424217e-01f, 9.44558457e-02f, -1.03197351e-01f, 6.56335056e-02f, -1.04818873e-01f, 9.82525479e-03f, 6.84230626e-02f, -1.05484568e-01f, -7.88900480e-02f, -7.87344649e-02f,
  -9.89725366e-02f, -2.75270492e-02f, -1.78693943e-02f, -3.73021625e-02f, -7.39670321e-02f, 1.07197583e-01f, -7.75395632e-02f, 1.07766032e-01f, -8.79126117e-02f, -1.49043836e-02f,
  3.73855531e-02f, -2.67498544e-03f, 4.51147258e-02f, -1.15826130e-01f, 1.73590519e-02f, -3.90781090e-02f, -3.93853001e-02f, -8.73926654e-02f, 9.34967250e-02f, -1.37012508e-02f,
  1.40522523e-02f, -4.16208506e-02f, 9.15144682e-02f, -4.38683741e-02f, 8.41035619e-02f, -1.32159084e-01f, -8.64613131e-02f, -4.59960364e-02f, -4.12180535e-02f, 5.77833168e-02f,
  3.51966806e-02f, 1.52450074e-02f, 2.25595708e-04f, 4.83309068e-02f, 4.62448932e-02f, -2.53802836e-02f, 7.16519654e-02f, 1.06786959e-01f, 7.71412067e-03f, -7.11532086e-02f,
  -6.68215379e-03f, 2.08864734e-02f, 1.61846504e-02f, 3.76083180e-02f, 1.25686541e-01f, 1.26273129e-02f, 8.11458677e-02f, -1.37555450e-02f, -1.49561204e-02f, -5.91866262e-02f,
  -4.80876192e-02f, 7.78774545e-02f, 1.07059725e-01f, -9.25964490e-02f, -9.10760239e-02f, -9.97027606e-02f, 7.44302571e-02f, 1.53171932e-02f, -1.54209882e-01f, -7.04768172e-04f,
  1.27946481e-01f, -4.39798869e-02f, 6.22932017e-02f, -7.40207324e-04f, -6.94012493e-02f, -1.29181832e-01f, -4.14046273e-03f, -1.27022713e-01f, 1.06036894e-01f, -1.23370893e-01f,
  1.05711080e-01f, 1.42993182e-01f, -8.81146698e-04f, -7.45421275e-02f, -4.72966544e-02f, 1.30698308e-01f, 9.41583887e-03f, -7.69291446e-02f, 2.76204705e-01f, 8.96324366e-02f,
  8.56501088e-02f, 1.72152817e-02f, 1.11634649e-01f, -7.14287013e-02f, 1.52003944e-01f, -3.01877167e-02f, -8.26768130e-02f, -3.39715369e-02f, -5.22703454e-02f, -2.00046152e-01f,
  -7.71010295e-02f, -1.23480119e-01f, 1.04424819e-01f, 1.60490409e-01f, 9.65345651e-02f, 7.15007186e-02f, 3.36384699e-02f, -1.26824647e-01f, -1.99242216e-02f, 9.22038257e-02f,
  1.31110206e-01f, -1.71145126e-01f, -9.86504182e-03f, 3.08417939e-02f, 2.81298831e-02f, 1.09587230e-01f, -1.98613647e-02f, 5.40562309e-02f, 8.39287043e-02f, 1.74532924e-02f,
  4.90325503e-02f, -7.09647685e-02f, -4.44374569e-02f, 3.98933850e-02f, -1.96612310e-02f, -5.19003682e-02f, 1.95549622e-01f, 1.65260598e-01f, -3.64010371e-02f, 5.82224615e-02f,
  9.95041057e-02f, -1.21728003e-01f, 1.98535293e-01f, 3.42833698e-01f, -8.09952058e-03f, 7.84467757e-02f, 2.11473648e-02f, 4.38252091e-02f, 5.89700565e-02f, -1.10045098e-01f,
  -4.57787551e-02f, 9.90056396e-02f, -3.71002592e-02f, -8.42465609e-02f, -4.56542820e-02f, -1.21722206e-01f, -1.36873037e-01f, 9.07569230e-02f, -4.73288670e-02f, -7.29717463e-02f,
  -1.13008253e-01f, -2.36614235e-02f, -3.83715369e-02f, 2.85169333e-02f, -1.49815962e-01f, 9.69347060e-02f, 1.69976339e-01f, 7.59830028e-02f, 1.64494529e-01f, 1.37329504e-01f,
  2.73001313e-01f, -1.08191617e-01f, -1.07376687e-01f, -7.16732740e-02f, -4.64160368e-02f, -9.73311365e-02f, 1.26762450e-01f, 1.79038629e-01f, -9.95966271e-02f, 1.65333208e-02f,
  -1.08561583e-01f, 2.15287372e-01f, 3.01445331e-02f, 1.70292407e-01f, -3.37413587e-02f, -7.65803009e-02f, -1.13462210e-01f, -1.14764906e-01f, -1.70043837e-02f, 2.23642010e-02f,
  7.32909888e-02f, -5.73016368e-02f, -5.14428653e-02f, 2.09839806e-01f, 6.76413029e-02f, -7.28505775e-02f, -6.67168945e-02f, 1.95548590e-03f, 6.64043054e-02f, 1.75336435e-01f,
  5.06462120e-02f, 4.49718013e-02f, -4.33061011e-02f, -3.05514000e-02f, -8.35796893e-02f, 4.92288806e-02f, -1.37583390e-01f, 3.26520689e-02f, 7.64037892e-02f, -9.13630351e-02f,
  7.84069970e-02f, -1.24684699e-01f, 1.14108950e-01f, 1.00903949e-02f, 8.33837390e-02f, 1.02008171e-02f, 1.41181186e-01f, 1.35130018e-01f, -3.49196643e-02f, -7.59989917e-02f,
  1.71921100e-03f, -1.20790750e-01f, 1.56146675e-01f, -1.67919241e-03f, 5.20182624e-02f, -6.61127716e-02f, 2.06962109e-01f, -5.55945970e-02f, -1.29561394e-01f, -9.22322944e-02f,
  2.04016954e-01f, 1.02455430e-01f, 1.57953724e-01f, 1.67738810e-01f, 1.68013826e-01f, 1.12881273e-01f, 1.97604019e-02f, -1.28780872e-01f, -1.88853830e-01f, -6.88122660e-02f,
  1.12130865e-01f, -3.10390681e-01f, -3.52329388e-02f, -6.18490838e-02f, 4.74021621e-02f, -6.76524863e-02f, -1.20410454e-02f, 1.32048294e-01f, -1.82343230e-01f, 2.98671007e-01f,
  -2.07604598e-02f, 4.02065068e-02f, -1.12937994e-01f, 5.71126752e-02f, -6.16586320e-02f, -6.10228702e-02f, 2.10072603e-02f, -5.63618094e-02f, -9.54915136e-02f, -1.56837031e-02f,
  1.38579816e-01f, -3.70558426e-02f, 1.24811120e-01f, -4.12629396e-02f, -2.33706646e-02f, -3.10584046e-02f, 1.05623297e-01f, 1.45737410e-01f, 2.49801829e-01f, 1.24300215e-02f,
  -2.59509310e-02f, -1.18625969e-01f, 5.01454249e-02f, -9.04068276e-02f, -3.48262861e-02f, -1.24387681e-01f, -2.46496610e-02f, -1.48750097e-01f, -6.49915542e-03f, 1.13693506e-01f,
  -6.89868033e-02f, -1.81494784e-02f, 8.21338594e-02f, 4.89757732e-02f, 1.75032422e-01f, -5.79185598e-02f, -1.13767341e-01f, 8.11457857e-02f, -1.21153034e-01f, -8.76925290e-02f,
  2.34022751e-01f, -5.90354353e-02f, 1.23969093e-02f, -2.13687196e-02f, -7.29854405e-02f, -4.97588292e-02f, -9.35933962e-02f, 1.42538780e-02f, 9.37076509e-02f, 2.82411985e-02f,
  1.20249636e-01f, 1.64543614e-02f, -9.80893299e-02f, -6.13530353e-02f, -9.57648605e-02f, -4.48645018e-02f, -2.82138074e-03f, 2.42797807e-02f, -7.98849165e-02f, -1.30059391e-01f,
  1.74266677e-02f, 3.10944375e-02f, 7.93929398e-03f, -2.26231273e-02f, -1.02681421e-01f, -9.46576670e-02f, 1.02211721e-01f, 3.49392183e-02f, -8.13934430e-02f, -1.57385003e-02f,
  -8.83713812e-02f, -6.52385969e-03f, 4.63136472e-02f, 4.90613915e-02f, -9.78909880e-02f, -8.53366312e-03f, -4.54421379e-02f, -9.58853588e-02f, -1.84765346e-02f, 4.67465445e-02f,
  2.82777455e-02f, -7.24410340e-02f, -3.98216359e-02f, 9.56486315e-02f, -4.69075441e-02f, -6.43474460e-02f, -1.28090188e-01f, -5.14347628e-02f, 1.19983606e-01f, 1.04530632e-01f,
  -5.54884039e-02f, -3.01444679e-02f, 2.73449067e-02f, 1.05690353e-01f, 1.50169507e-02f, -9.46478769e-02f, -3.95909511e-03f, -9.38079059e-02f, 3.67866531e-02f, -1.14928894e-01f,
  7.85146803e-02f, 3.42903137e-02f, 9.61480886e-02f, 5.27727837e-03f, 1.15250498e-01f, -7.98203275e-02f, 9.53752100e-02f, -1.13964856e-01f, -8.21855813e-02f, -5.76067232e-02f,
  1.22568831e-02f, 2.04037521e-02f, 1.33147568e-01f, -7.13147875e-03f, -7.84116834e-02f, -2.33095251e-02f, 6.49573654e-02f, -1.21382184e-01f, 5.35232127e-02f, 1.05708567e-02f,
  -4.18006517e-02f, -9.82481912e-02f, 6.04220368e-02f, 4.08309907e-01f, -3.54937501e-02f, 1.54443577e-01f, 1.84109911e-01f, -2.33616363e-02f, 9.88870934e-02f, -1.37309313e-01f,
  2.91359853e-02f, 6.84143975e-02f, 7.30623975e-02f, -7.90996626e-02f, -3.87830026e-02f, 1.31278783e-01f, 1.05439380e-01f, -5.43743670e-02f, 1.26791224e-01f, -3.65597308e-02f,
  -1.18779913e-01f, -8.41653496e-02f, 2.93606281e-01f, 5.45513593e-02f, -2.27181185e-02f, -1.10700965e-01f, -7.21332654e-02f, 1.61105230e-01f, 6.39525279e-02f, -9.72642899e-02f,
  -5.84183037e-02f, 1.60002857e-01f, 1.45448312e-01f, -3.81443948e-02f, -8.61536432e-03f, -1.30942151e-01f, -1.18825093e-01f, -6.36400729e-02f, -1.96968168e-02f, -5.38885966e-02f,
  -1.05990976e-01f, -2.70544589e-02f, 9.73802134e-02f, -6.14618398e-02f, 1.16592444e-01f, 1.63864538e-01f, 1.25360638e-02f, -2.80137770e-02f, 1.89881250e-01f, -3.13485204e-03f,
  -9.26542804e-02f, -2.53069550e-02f, -2.35840473e-02f, 1.28142253e-01f, 1.28040835e-01f, 3.64956893e-02f, 1.48532644e-01f, 1.02371134e-01f, 9.46463645e-02f, 5.31164072e-02f,
  7.72024766e-02f, 1.97314218e-01f, -2.23409086e-01f, 9.60022137e-02f, -3.88979539e-02f, 1.16130389e-01f, -8.09151605e-02f, 2.21295595e-01f, 1.52556151e-01f, 2.30550498e-01f,
  -1.64723888e-01f, -2.62699705e-02f, -1.53089732e-01f, 9.68285576e-02f, -2.48727258e-02f, 7.15251043e-02f, 2.13601008e-01f, 9.61013231e-03f, 9.63703617e-02f, 1.05771892e-01f,
  5.27661890e-02f, -8.68183523e-02f, 2.09246889e-01f, -4.45722118e-02f, 1.41703665e-01f, 1.81561306e-01f, -5.68929538e-02f, -3.06776445e-02f, -3.54859456e-02f, 7.24912211e-02f,
  7.57819116e-02f, 6.26303703e-02f, -1.06670938e-01f, -1.47035979e-02f, 1.77038372e-01f, 1.45992950e-01f, -1.07297517e-01f, -5.29516600e-02f, 9.23275203e-03f, 7.47873485e-02f,
  -8.72350037e-02f, 1.61552966e-01f, 2.04475552e-01f, -7.14163706e-02f, 9.69816744e-02f, -7.69054517e-02f, 2.05367491e-01f, 9.05906931e-02f, 1.85889438e-01f, -7.63686001e-02f,
  -7.57578611e-02f, -1.46582006e-02f, 6.67157546e-02f, -3.78071964e-02f, -8.26919079e-02f, -1.21281020e-01f, 5.79564087e-02f, 2.34610006e-01f, 2.56693125e-01f, -2.45870128e-02f,
  9.76174846e-02f, 7.35998973e-02f, -7.58412704e-02f, -9.75091755e-02f, -1.34247795e-01f, -3.37332010e-01f, 2.36969203e-01f, 1.69757590e-01f, -2.24835239e-02f, -3.16614285e-02f,
  1.32072881e-01f, 1.49326652e-01f, -6.87816963e-02f, -6.93438426e-02f, 3.15672934e-01f, -3.80146392e-02f, -1.13664337e-01f, 4.35642824e-02f, -1.49992436e-01f, -1.00053638e-01f,
  -1.15846857e-01f, -6.51297048e-02f, -4.71176393e-02f, 1.38212800e-01f, 1.44452244e-01f, 1.54472634e-01f, -7.21623823e-02f, 1.19482487e-01f, -9.71610248e-02f, 5.48928678e-02f,
  2.22061723e-01f, 9.92163122e-02f, 4.90580648e-02f, -1.83142692e-01f, -5.74822053e-02f, 6.34507164e-02f, -5.58641180e-02f, 2.05372021e-01f, -5.52288294e-02f, 2.62266379e-02f,
  1.93436459e-01f, 1.54117271e-01f, -7.68389553e-02f, -3.62773947e-02f, 1.29099846e-01f, -1.94822893e-01f, -9.34379250e-02f, 1.07275374e-01f, 3.12680472e-03f, -6.19718283e-02f,
  -1.71299294e-01f, 9.96911526e-02f, -2.47728787e-02f, 9.22074839e-02f, -6.57605082e-02f, -1.61376640e-01f, 5.62573634e-02f, -1.76016375e-01f, -1.20933503e-01f, -4.40742373e-02f,
  1.94390073e-01f, 7.32209161e-02f, 5.30097373e-02f, 7.36928508e-02f, -7.12126866e-02f, 3.08576412e-02f, 2.47049242e-01f, 5.32179363e-02f, 2.58113682e-01f, 9.92837995e-02f,
  -2.84098804e-01f, 9.16910451e-03f, 5.99530898e-03f, -1.76794350e-01f, 3.18503566e-02f, 1.37334287e-01f, -5.05775400e-02f, -1.38122499e-01f, -1.80401281e-01f, 1.48093954e-01f,
  -1.10300563e-01f, 2.11682603e-01f, 6.03797194e-03f, 6.26816452e-02f, 2.39285622e-02f, 1.06560849e-01f, 1.48061872e-03f, 5.40596060e-02f, 7.74260983e-02f, -7.09040603e-03f,
  -3.22540663e-02f, 1.04133740e-01f, -1.43925235e-01f, -7.14832023e-02f, -2.53870729e-02f, 1.68370306e-01f, -7.38425553e-02f, 2.15043873e-01f, 2.18249187e-01f, -5.99453971e-02f,
  2.02018932e-01f, 8.39758366e-02f, -1.30871952e-01f, 7.69916400e-02f, 7.08060041e-02f, -8.55686441e-02f, 3.74569558e-02f, 1.31145701e-01f, 3.55817117e-02f, 1.48384660e-01f,
  1.02205969e-01f, -3.75842340e-02f, -5.07249720e-02f, -4.84034456e-02f, 2.33750418e-02f, 2.95422133e-02f, -1.54428314e-02f, 7.94470962e-03f, -7.10204244e-02f, -1.10996909e-01f,
  4.09844890e-02f, -1.33262724e-01f, 1.88067451e-01f, 1.49024948e-01f, -3.95615995e-02f, -7.82182217e-02f, 9.50770974e-02f, 5.23358211e-02f, -5.03742732e-02f, -1.10213928e-01f,
  1.61361352e-01f, -1.86753049e-02f, 4.19900343e-02f, 1.43964753e-01f, 8.39676410e-02f, -8.80810916e-02f, 3.19446363e-02f, 3.26305963e-02f, -4.22773845e-02f, -2.38545192e-03f,
  -2.49827411e-02f, 1.15337083e-02f, -1.23245381e-01f, 6.82953745e-02f, 6.42466545e-02f, 1.95466597e-02f, -5.74936830e-02f, 9.29833427e-02f, 1.12342369e-02f, -8.91145915e-02f,
  -3.19849364e-02f, -2.18174551e-02f, 1.14014812e-01f, -9.58607495e-02f, -1.24456145e-01f, -2.19560316e-04f, 1.86352190e-02f, -5.07581383e-02f, 6.98309541e-02f, 1.40306830e-01f,
  1.32700810e-02f, -9.62569341e-02f, 5.79615384e-02f, 5.88883087e-02f, 7.47008920e-02f, -8.35261196e-02f, -9.82688740e-02f, 9.36814696e-02f, 2.73498800e-02f, 1.18150666e-01f,
  1.23119112e-02f, -7.37177804e-02f, 5.52373938e-03f, -9.47990566e-02f, -5.31715415e-02f, 8.18564594e-02f, -4.41050008e-02f, -4.84132729e-02f, 1.29335642e-01f, 4.60462682e-02f,
  -2.50002835e-02f, -6.50695115e-02f, 3.10361963e-02f, -5.71420118e-02f, -7.04585388e-02f, -7.63501215e-04f, -9.98363942e-02f, 1.46427616e-01f, -9.04169083e-02f, -7.89106339e-02f,
  1.02074213e-01f, -9.26277339e-02f, -9.57305133e-02f, -5.18946983e-02f, -9.37930793e-02f, -1.14135854e-01f, -2.48196945e-02f, -8.43599066e-02f, 2.57698516e-03f, 9.21125561e-02f,
  1.11469477e-01f, -2.32738573e-02f, 3.51529084e-02f, -3.22434381e-02f, 3.33041735e-02f, -8.48898217e-02f, 4.31926772e-02f, 1.16645806e-01f, 2.83539779e-02f, -3.64583433e-02f,
  -9.81478542e-02f, -2.26405337e-02f, -3.08406763e-02f, -9.47496369e-02f, -6.05140291e-02f, -9.53707397e-02f, -4.67401296e-02f, 1.85223427e-02f, 9.83528271e-02f, -2.52325013e-02f,
  1.12558557e-02f, -8.05962086e-02f, -4.57543768e-02f, 1.10717984e-02f, -1.40301157e-02f, 6.37951866e-02f, -8.39588270e-02f, 2.47167749e-03f, -4.06236276e-02f, 4.09938134e-02f,
  3.75741608e-02f, -7.00161979e-02f, 6.12809844e-02f, -1.71004646e-02f, -9.45851132e-02f, 9.48865339e-02f, -8.81354138e-02f, 7.00465143e-02f, 2.70039192e-03f, -1.03613652e-01f,
  -6.93608895e-02f, -1.16933309e-01f, -6.45983741e-02f, -8.27147663e-02f, -1.09405294e-01f, 3.24854031e-02f, -1.26395047e-01f, 1.01169147e-01f, -1.19326785e-01f, -8.43355358e-02f,
  -1.01912573e-01f, -3.64661664e-02f, 2.27354944e-01f, 1.45554855e-01f, 1.32768035e-01f, 2.75861681e-01f, 1.49852768e-01f, 2.52041429e-01f, 2.18313485e-01f, -2.51832493e-02f,
  1.49877563e-01f, 3.08278769e-01f, -4.78487968e-01f, 2.27788523e-01f, -6.11199215e-02f, -1.51437625e-01f, -1.07065089e-01f, 2.91216165e-01f, -2.50045992e-02f, 6.82540834e-02f,
  -1.38919681e-01f, 4.95844781e-02f, -1.15655556e-01f, 1.05519667e-01f, 2.24679396e-01f, 1.25293180e-01f, 6.88926317e-04f, 4.47807871e-02f, -1.68106670e-03f, 1.83377698e-01f,
  2.21405346e-02f, -1.28200963e-01f, 2.73989737e-01f, 1.62835531e-02f, 1.68639287e-01f, 3.54761723e-03f, -7.21153989e-02f, -6.22067079e-02f, 1.31846741e-01f, 1.13644518e-01f,
  3.19173366e-01f, 1.13051198e-01f, 4.75746654e-02f, 8.33468791e-03f, 5.54051995e-02f, 1.04993463e-01f, -1.45736918e-01f, -1.24475341e-02f, -1.31205723e-01f, 1.61106229e-01f,
  -1.59181625e-01f, 3.50927375e-02f, 1.92083791e-01f, -5.12363017e-02f, -6.34785816e-02f, -7.16402242e-03f, 9.98597220e-02f, 7.40440562e-02f, -8.47013742e-02f, -2.98390407e-02f,
  -7.54085109e-02f, 1.10944013e-04f, -1.69590395e-02f, 1.03814863e-02f, 8.52561966e-02f, 1.50526136e-01f, 1.62165850e-01f, 2.30757177e-01f, 1.68236837e-01f, -4.55147633e-03f,
  5.69902845e-02f, -6.73356652e-02f, -2.40570098e-01f, -7.09871128e-02f, -1.29283443e-01f, -2.97655463e-01f, 2.34189913e-01f, 2.64722049e-01f, 1.00507654e-01f, -1.57795995e-02f,
  7.30668828e-02f, -3.25854607e-02f, 4.67742272e-02f, 7.88439438e-02f, 3.42701972e-01f, -9.20866206e-02f, 2.75961850e-02f, 1.56764667e-02f, -9.69274715e-02f, -5.44109456e-02f,
  -1.02438793e-01f, 1.63651295e-02f, 6.55762628e-02f, 6.07061461e-02f, 1.62640363e-02f, -1.25650927e-01f, -5.59235029e-02f, -1.15614347e-01f, 1.42846227e-01f, 4.35800757e-03f,
  -5.61654521e-03f, -3.96046825e-02f, -1.37169346e-01f, 3.04817781e-03f, 8.07039160e-03f, 4.67670262e-02f, 2.50413809e-02f, 4.09894675e-01f, -7.49152154e-02f, -1.74568985e-02f,
  -1.92137480e-01f, -9.35313106e-02f, 3.23120244e-02f, -2.32509375e-02f, 1.05831206e-01f, -8.79944414e-02f, 1.69270933e-01f, 1.41144797e-01f, -1.49767399e-01f, 1.86117161e-02f,
  -4.43207771e-02f, 3.15763280e-02f, 1.51936963e-01f, -7.11058527e-02f, 1.70804076e-02f, 2.02950407e-02f, -1.14190698e-01f, -5.96017130e-02f, -1.09645903e-01f, 1.39645889e-01f,
  -1.14429533e-01f, -1.71883646e-02f, -5.93834035e-02f, 1.04324341e-01f, 1.49334937e-01f, -8.25443789e-02f, 1.44517208e-02f, -3.49875279e-02f, -8.74216333e-02f, -1.73532784e-01f,
  6.68065324e-02f, -6.22320771e-02f, 2.56089587e-02f, -2.51682680e-02f, -6.97081313e-02f, 1.77723557e-01f, 4.99521941e-02f, -4.65128571e-02f, 2.80061308e-02f, -5.34457453e-02f,
  -7.71906376e-02f, -1.23559929e-01f, -6.58110976e-02f, -1.38514921e-01f, -8.03692415e-02f, 1.15659602e-01f, 9.13037136e-02f, -4.60818410e-04f, 8.42126459e-02f, 8.41136351e-02f,
  -1.04485881e-02f, -3.22878994e-02f, -4.75212261e-02f, 3.91088314e-02f, 9.75712538e-02f, -6.71796128e-02f, -1.35351717e-01f, 3.68906632e-02f, -8.56311917e-02f, -8.58936086e-02f,
  3.37696709e-02f, 3.84887867e-02f, -4.60461527e-02f, 9.88154411e-02f, -1.23693414e-01f, 2.11338308e-02f, -1.60393976e-02f, -1.13861002e-01f, 1.13635855e-02f, -6.05893023e-02f,
  1.04614839e-01f, 1.84492599e-02f, 1.15356825e-01f, -3.31104882e-02f, 5.54447100e-02f, 1.11705646e-01f, 1.23796657e-01f, -4.03285511e-02f, -1.13108188e-01f, -9.68198627e-02f,
  -1.02808833e-01f, -1.05614580e-01f, -3.70279253e-02f, -4.17430177e-02f, -9.29342806e-02f, -9.13500488e-02f, -5.38096800e-02f, 5.65558262e-02f, -8.27172324e-02f, 5.23566864e-02f,
  1.29040852e-01f, 8.51443037e-03f, -1.86902471e-02f, 5.20662684e-03f, -9.11250934e-02f, 9.54256132e-02f, 1.88175794e-02f, 4.49907146e-02f, -9.66104418e-02f, -2.00451259e-02f,
  -6.34551570e-02f, -7.20970780e-02f, 1.03395745e-01f, -5.74142206e-03f, -1.28291041e-01f, 4.06291150e-02f, -6.42578602e-02f, -1.03396498e-01f, 6.17825501e-02f, 2.86045838e-02f,
  1.02516763e-01f, 1.13440514e-01f, 1.19516626e-01f, -4.31793509e-03f, -6.88952506e-02f, -6.42883703e-02f, -7.93812200e-02f, -5.43134101e-02f, -3.78359295e-02f, -4.93393727e-02f,
  1.16109088e-01f, -1.06292561e-01f, -1.02905393e-01f, -2.32719444e-02f, -1.15484849e-01f, -8.29324499e-02f, 3.98310721e-02f, 1.07669748e-01f, -1.09911852e-01f, -3.29287238e-02f,
  -2.28435993e-02f, 2.98762694e-02f, 4.61655855e-02f, -2.53650453e-02f, 1.50741059e-02f, -8.54978263e-02f, -1.21438213e-01f, -9.63014886e-02f, -4.51664906e-03f, 3.13641392e-02f,
  5.82875013e-02f, 3.52240466e-02f, 7.85275847e-02f, -1.24976085e-02f, -5.00557907e-02f, -4.12403531e-02f, 8.96598399e-02f, 1.45569995e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 52)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 52;
const float L2_fan_Bp_bar_data[] = {
  1.39895976e-01f, -5.58838584e-02f, 6.12462834e-02f, 2.96216875e-01f, 1.42339587e-01f, 1.95376113e-01f, 7.73762390e-02f, 6.40697703e-02f, 1.45106971e-01f, 3.91827477e-03f,
  1.05352394e-01f, 1.29099429e-01f, 1.35973558e-01f, -2.74217017e-02f, 1.40632734e-01f, 1.88493341e-01f, 7.50435665e-02f, 1.44927502e-01f, 1.48355007e-01f, 1.23453535e-01f,
  3.04517727e-02f, 1.02448881e-01f, 3.18270773e-01f, -6.51397109e-02f, -4.40724008e-02f, 1.34141281e-01f, 1.62648693e-01f, 5.25223557e-03f, 9.65332910e-02f, 1.67285338e-01f,
  1.29833698e-01f, 8.99067521e-02f, 4.04413752e-02f, -3.88609767e-02f, -8.93855616e-02f, 1.13169581e-01f, 8.65029916e-02f, 1.13285892e-01f, -4.30657379e-02f, -4.56927344e-02f,
  1.09152542e-02f, -3.65061648e-02f, 6.45215809e-02f, 8.12147744e-03f, 2.23415360e-01f, 5.93097992e-02f, 1.13714477e-02f, -4.29043472e-02f, 2.83158064e-01f, 2.17573225e-01f,
  4.82451776e-03f, 1.00628659e-01f
};

// L3_linear_W (Shape: 12 x 64)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 64;
const float L3_linear_W_data[] = {
  2.09349573e-01f, -4.10054296e-01f, -4.54689890e-01f, -6.49038181e-02f, 1.30441993e-01f, 1.12006836e-01f, -3.34963351e-02f, -3.22580457e-01f, 3.98127049e-01f, 3.49189222e-01f,
  -2.08870128e-01f, -1.55714408e-01f, 3.87707770e-01f, -1.13992222e-01f, 1.35571942e-01f, 3.03271459e-03f, 5.50523326e-02f, -2.01545790e-01f, -5.33233620e-02f, -2.23703638e-01f,
  7.79535547e-02f, -3.66970524e-02f, 7.45233178e-01f, -2.03021675e-01f, -2.73847505e-02f, -4.02128436e-02f, 3.23580146e-01f, -1.58564076e-01f, 2.40981832e-01f, -2.66053289e-01f,
  -2.93394923e-01f, -1.83543012e-01f, -3.07343870e-01f, 1.60280526e-01f, 2.02880800e-01f, -9.08055827e-02f, -4.24728207e-02f, -1.41830677e-02f, 2.85993814e-01f, -7.41477534e-02f,
  -6.71505332e-02f, 1.92879587e-01f, 1.40549198e-01f, -3.24689746e-02f, -1.09511249e-01f, -1.33099511e-01f, -9.40901935e-02f, -6.80580661e-02f, -1.49210328e-02f, -1.09939761e-01f,
  -9.35976356e-02f, 2.49078814e-02f, 3.60094011e-02f, -1.28402114e-01f, -2.75753796e-01f, 9.78477672e-03f, 2.17879098e-02f, -2.11994708e-01f, -1.49830714e-01f, 7.42836343e-03f,
  -2.69339979e-01f, -2.20289454e-02f, -7.47825131e-02f, -6.65996298e-02f, -5.90071343e-02f, 1.61159307e-01f, 3.35811377e-01f, 8.44655037e-02f, 2.13303611e-01f, 1.74650922e-01f,
  1.17827438e-01f, -9.81487110e-02f, -1.61431164e-01f, 9.87212583e-02f, -8.51479769e-02f, 3.15270312e-02f, -3.65498513e-01f, 2.96117887e-02f, -1.10612884e-01f, 1.81346223e-01f,
  4.36923206e-02f, -2.08661616e-01f, 1.09714247e-01f, -3.14973325e-01f, -5.68830073e-01f, 8.04929808e-02f, 6.70932889e-01f, 1.55565843e-01f, 1.07595779e-01f, 1.62620276e-01f,
  1.18877321e-01f, 2.43640870e-01f, -8.59280452e-02f, 1.70848221e-01f, -3.56384993e-01f, -2.76349653e-02f, 3.06662042e-02f, 1.38921767e-01f, 2.28525862e-01f, -1.38467662e-02f,
  2.38828808e-01f, 1.27057103e-03f, 1.33802861e-01f, -1.21763900e-01f, -1.58099979e-01f, -1.85836762e-01f, 8.89896601e-02f, 3.48671190e-02f, -1.83464035e-01f, -2.35237721e-02f,
  -8.45760331e-02f, -1.58768445e-01f, -7.94443861e-02f, -1.55830383e-01f, -1.18265282e-02f, 1.40474573e-01f, -1.64685491e-02f, -7.39263296e-02f, -2.21453518e-01f, 2.94934779e-01f,
  -3.64356667e-01f, -8.87603536e-02f, 5.25297523e-02f, -7.38814771e-02f, 3.73218834e-01f, 7.24687204e-02f, -1.50607482e-01f, -5.69180809e-02f, 7.46922195e-02f, 1.15056388e-01f,
  -1.89235017e-01f, 5.74322864e-02f, 9.83250365e-02f, 2.46403873e-01f, 1.63430810e-01f, 4.08003181e-01f, -5.69420815e-01f, -5.28291583e-01f, -4.07658517e-01f, 1.10878102e-01f,
  -3.11417162e-01f, -5.84130809e-02f, -1.60702452e-01f, 4.76320654e-01f, -1.08850360e-01f, -1.23334400e-01f, 3.08368921e-01f, -2.17895046e-01f, -5.42512715e-01f, 8.50829855e-02f,
  1.10263832e-01f, -2.81185582e-02f, -1.90415680e-01f, -1.77325532e-01f, -6.37995377e-02f, -3.06415647e-01f, -1.32872805e-01f, 1.89883173e-01f, 1.94251612e-01f, -1.90519527e-01f,
  -1.54836237e-01f, 1.81388035e-02f, -1.96531028e-01f, -9.59661677e-02f, -5.86083159e-03f, -1.35917321e-01f, -3.28523546e-01f, 1.60441950e-01f, -1.10157683e-01f, -2.06622884e-01f,
  1.49975764e-02f, 3.85955870e-01f, -2.69520402e-01f, -7.29517192e-02f, -1.48371145e-01f, 1.32416219e-01f, 9.40367132e-02f, -1.41109973e-01f, -2.15289757e-01f, -2.84866899e-01f,
  -1.62263885e-01f, -8.25157389e-02f, -6.04026355e-02f, 9.00510326e-02f, -2.35205814e-01f, 5.17021835e-01f, 1.03437684e-01f, -2.97849663e-02f, 6.27645195e-01f, -3.09405744e-01f,
  -2.03042284e-01f, 5.70625141e-02f, 1.01954639e-01f, -6.38637319e-02f, -2.69614846e-01f, 1.45012826e-01f, 1.78896978e-01f, 2.01505143e-02f, -2.79965639e-01f, -3.44006270e-01f,
  6.03460908e-01f, 6.11463152e-02f, 1.50297955e-01f, -2.63229191e-01f, 8.62659693e-01f, 3.56161371e-02f, 2.28784680e-01f, -5.56988597e-01f, 3.34684640e-01f, 3.25788885e-01f,
  -1.50457874e-01f, 3.87331210e-02f, -4.43049148e-02f, -2.09777668e-01f, -5.26200354e-01f, 4.11974713e-02f, 9.26864520e-02f, 1.16178341e-01f, -1.66348204e-01f, 5.90600185e-02f,
  6.86284676e-02f, -2.00858265e-01f, 1.94954704e-02f, -1.12364881e-01f, -1.40417144e-01f, -1.34748250e-01f, 3.58935446e-01f, 1.38793394e-01f, -7.30773062e-02f, 1.85203001e-01f,
  -6.80109486e-02f, 8.62228945e-02f, 3.26736718e-02f, -6.22404856e-04f, -2.02430114e-01f, -1.45238698e-01f, 5.58131263e-02f, 6.17895601e-03f, 4.56641838e-02f, -7.26490244e-02f,
  -1.89783629e-02f, -1.37167990e-01f, 7.16921017e-02f, -1.44801393e-01f, -1.15310140e-01f, 5.88034205e-02f, -7.44519115e-04f, -3.20259273e-01f, 1.60733208e-01f, -2.33704239e-01f,
  -1.60718802e-02f, 5.28810322e-02f, -3.40874314e-01f, 2.09786952e-01f, 6.34792969e-02f, -3.25631760e-02f, 1.50363207e-01f, -1.09746270e-01f, -5.58794200e-01f, 3.20660770e-02f,
  -8.52110386e-02f, 2.27109626e-01f, -1.94069058e-01f, -3.90540779e-01f, 4.19315100e-01f, 5.13983727e-01f, 3.46890211e-01f, -2.81523746e-02f, 4.15475249e-01f, 7.40236938e-02f,
  1.88237727e-02f, 3.85779068e-02f, -1.78037494e-01f, 2.90762577e-02f, -2.04066351e-01f, 3.14182729e-01f, 8.56009483e-01f, -1.94447622e-01f, -1.72923848e-01f, 9.86320227e-02f,
  -1.19603723e-01f, -2.81582563e-03f, 5.07914573e-02f, -2.02703308e-02f, -1.50339678e-01f, -4.73185740e-02f, -6.33312911e-02f, 5.32362564e-03f, 1.35937497e-01f, 5.23314998e-02f,
  6.31948933e-02f, -4.79594246e-02f, -5.90656437e-02f, -1.75775424e-01f, 3.24644819e-02f, -9.80051607e-02f, 1.39833286e-01f, 2.38222748e-01f, -2.41088346e-01f, -2.33422648e-02f,
  2.24277511e-01f, 8.97907242e-02f, -3.16039696e-02f, 4.91453893e-02f, 1.21752165e-01f, 1.47755757e-01f, -1.71863869e-01f, 3.46636325e-02f, 3.39967221e-01f, 6.02515601e-02f,
  1.50938006e-03f, -2.64696091e-01f, -3.12323924e-02f, -6.31248802e-02f, 1.36312768e-01f, -1.13012128e-01f, -4.04651731e-01f, 6.42129183e-02f, -1.26299895e-02f, -1.42527983e-01f,
  -1.14317067e-01f, -2.52409518e-01f, -9.72983241e-02f, -2.90099978e-01f, -3.42726819e-02f, -2.73959458e-01f, -2.57318616e-02f, -5.81795536e-02f, 2.88902372e-01f, 8.97556469e-02f,
  2.46559381e-01f, 2.74779111e-01f, -1.88536108e-01f, 6.53180033e-02f, 3.89350802e-02f, 3.51333208e-02f, -4.58493680e-02f, -2.09845267e-02f, -1.08378425e-01f, -5.67065589e-02f,
  1.77260578e-01f, 1.98973179e-01f, 1.27047613e-01f, 1.62248075e-01f, 7.70239756e-02f, 2.26904149e-03f, 1.47171140e-01f, 2.08571613e-01f, 3.06231946e-01f, 1.54882699e-01f,
  -1.77509934e-01f, 2.14978933e-01f, -5.59971184e-02f, -6.81065470e-02f, -1.27368525e-01f, 2.10088760e-01f, 2.20216244e-01f, -1.32237092e-01f, 2.62017585e-02f, -3.57866064e-02f,
  -1.84046894e-01f, 6.75253421e-02f, 3.58851463e-01f, 8.92947763e-02f, 3.56418490e-01f, 3.03207934e-01f, 1.17249012e-01f, -1.99890420e-01f, 1.46122098e-01f, 1.60243571e-01f,
  -2.32664824e-01f, 2.53506184e-01f, 3.31057578e-01f, 7.27541652e-03f, 1.36075253e-02f, 1.02814242e-01f, -9.26472247e-02f, -2.23885030e-01f, -2.93292310e-02f, -1.21060669e-01f,
  5.43915778e-02f, -4.50576022e-02f, -2.28717178e-03f, -9.82778519e-03f, -3.37948613e-02f, 2.79809177e-01f, 1.28687978e-01f, -9.39756166e-03f, -2.32163608e-01f, -3.06093216e-01f,
  -2.59556681e-01f, 3.86657976e-02f, -4.35525715e-01f, 4.16394733e-02f, 3.49049717e-01f, 2.53933161e-01f, -4.59137857e-01f, 2.88678724e-02f, 1.47469239e-02f, 3.04301232e-01f,
  -7.75693953e-02f, -2.97182036e-04f, -1.24226362e-01f, -6.91384673e-02f, -1.68847367e-01f, 2.17076689e-01f, -4.43733841e-01f, -4.02373215e-03f, -7.30936974e-02f, -1.73840031e-01f,
  -1.53496489e-01f, -1.71940982e-01f, 7.31553696e-03f, 3.65295738e-01f, 3.50307763e-01f, 1.38233140e-01f, 1.52270526e-01f, -3.30429040e-02f, -2.78046578e-01f, -2.78579593e-02f,
  -1.53688371e-01f, -8.63735899e-02f, -2.50830859e-01f, -8.82652495e-03f, 1.42381247e-02f, 1.76930577e-02f, 4.27830637e-01f, 7.82424863e-03f, 1.73462316e-01f, 3.94739181e-01f,
  1.06823809e-01f, -1.79482311e-01f, -1.05719753e-01f, 7.96203986e-02f, 1.29562672e-02f, -1.00139603e-01f, 1.91865027e-01f, 4.44440097e-02f, 1.58508748e-01f, 3.47544342e-01f,
  -3.14818501e-01f, 1.66089647e-02f, 2.12396514e-02f, -2.05066819e-02f, 3.47542107e-01f, -2.14467883e-01f, -1.49209410e-01f, 7.17226937e-02f, -3.15968692e-01f, 3.32398666e-03f,
  2.26681843e-01f, -5.20997941e-02f, -2.67759860e-01f, -7.44466186e-02f, -1.70515269e-01f, -3.68391536e-02f, -1.75510496e-01f, -2.99062759e-01f, 2.76235677e-02f, 1.34201586e-01f,
  5.37891686e-01f, 1.17009260e-01f, 1.38201609e-01f, 9.38123837e-02f, 2.71575302e-02f, -1.58723548e-01f, -1.01215295e-01f, 4.56263088e-02f, 1.33729577e-01f, 1.37305990e-01f,
  -2.74832219e-01f, -7.20931068e-02f, -1.71584129e-01f, -1.06253959e-01f, -3.63710932e-02f, -2.17207059e-01f, -1.82868525e-01f, -2.75139045e-02f, 3.44192982e-01f, -5.89619726e-02f,
  1.90431818e-01f, 4.27268296e-02f, 1.06139876e-01f, 3.07031423e-01f, 6.35387748e-02f, 1.54056326e-01f, -9.36104953e-02f, -1.19005695e-01f, 3.12305421e-01f, 3.50961462e-02f,
  -2.24976212e-01f, -8.58671516e-02f, -2.15640649e-01f, -1.42493919e-01f, 3.78615320e-01f, 1.85444728e-01f, -1.40255347e-01f, -1.56928316e-01f, 3.70335966e-01f, -7.47985691e-02f,
  -8.39590877e-02f, -4.02044058e-02f, 2.46005394e-02f, -1.79103732e-01f, 3.84105928e-02f, 3.84164862e-02f, 6.89532533e-02f, 2.74765529e-02f, -2.60627091e-01f, 2.46499403e-04f,
  -9.98399332e-02f, -8.25560540e-02f, -3.44242305e-01f, -7.98564106e-02f, -9.84299555e-02f, -2.99074143e-01f, -4.33122814e-01f, -9.77204740e-02f, 2.02889726e-01f, 4.58353460e-01f,
  -4.15289611e-01f, -3.72409135e-01f, -3.37463528e-01f, -4.47470903e-01f, -2.84714967e-01f, 9.07597691e-02f, -7.66891912e-02f, -2.39608273e-01f, 1.81937337e-01f, -5.98037541e-02f,
  4.57118303e-01f, -1.00062251e-01f, -4.26534504e-01f, -5.03268931e-03f, 1.21047154e-01f, -9.60821733e-02f, 7.38984123e-02f, -5.00371978e-02f, 2.55852174e-02f, -7.27205724e-02f,
  -1.36844218e-02f, -1.26163051e-01f, 5.17697409e-02f, 3.70508105e-01f, 1.73905924e-01f, 4.47555445e-02f, -1.27522022e-01f, 7.27746338e-02f, -4.50314395e-02f, -2.22656764e-02f,
  1.83672681e-01f, 2.58611500e-01f, 5.11037558e-02f, -3.30618545e-02f, -1.27188444e-01f, 4.51429009e-01f, -1.05140209e-01f, -5.76191992e-02f, -1.32003903e-01f, -8.70949328e-02f,
  1.03423849e-01f, 3.91205028e-02f, -1.07862249e-01f, 2.76799291e-01f, -3.56026351e-01f, -5.93891218e-02f, 4.08075631e-01f, 6.69287459e-04f, 1.58268422e-01f, -1.04459919e-01f,
  -1.22599982e-01f, 3.50009799e-02f, -8.31684396e-02f, 1.80029362e-01f, 2.25046337e-01f, 1.30133405e-01f, 5.61524166e-06f, -1.61963597e-01f, 2.88379431e-01f, 1.25279695e-01f,
  -5.40283732e-02f, 1.24335531e-02f, -1.18734516e-01f, -2.92600363e-01f, 1.55209929e-01f, 2.78300755e-02f, 2.77478427e-01f, 1.22912452e-01f, -3.08840811e-01f, -6.88857213e-02f,
  -1.63358450e-01f, 7.09321201e-01f, -3.18158686e-01f, -2.39360094e-01f, -2.41534948e-01f, 3.34738612e-01f, 6.08056664e-01f, -1.61157966e-01f, 1.10135138e-01f, -1.59368590e-01f,
  1.46426782e-02f, -1.14774019e-01f, 1.47554398e-01f, -2.98974127e-01f, -2.98994720e-01f, 3.48050505e-01f, -2.28977371e-02f, -3.11395496e-01f, 1.50793433e-01f, 2.74430700e-02f,
  -3.79328877e-01f, -1.00893214e-01f, -3.17415744e-01f, 2.96599772e-02f, -2.38557756e-01f, -2.26204954e-02f, 1.91203117e-01f, 1.35346651e-01f, 6.71362579e-02f, -1.91587154e-02f,
  -2.00541437e-01f, -2.47080415e-01f, -5.31850047e-02f, -1.55565199e-02f, -6.12046272e-02f, -2.52342094e-02f, -8.56262669e-02f, -1.78314969e-01f, 2.97260493e-01f, 5.78850731e-02f,
  -1.53451294e-01f, -1.93957433e-01f, -1.06378868e-01f, 3.19941431e-01f, 8.71327445e-02f, 9.03415680e-02f, 1.34365037e-01f, -2.60744900e-01f, 2.15912443e-02f, 8.66104141e-02f,
  1.52536973e-01f, 3.29194039e-01f, 4.06444609e-01f, 2.57059872e-01f, 3.97438854e-02f, 1.14368238e-01f, 3.12873930e-01f, -5.56890778e-02f, -3.46206516e-01f, -2.74636298e-01f,
  -2.05044568e-01f, -3.92010778e-01f, -2.67807215e-01f, -6.85875043e-02f, -1.45768851e-01f, -4.00075823e-01f, 1.72363475e-01f, 2.81372666e-01f, 1.39111793e-02f, -1.63939789e-01f,
  -3.43220174e-01f, 5.90738491e-04f, -7.63903633e-02f, -1.03487425e-01f, 3.60105276e-01f, 1.55945808e-01f, -7.10136369e-02f, 4.53020155e-01f, -2.06355050e-01f, -2.29938507e-01f,
  -4.86244634e-03f, -6.62146062e-02f, 2.92257918e-03f, 2.89327085e-01f, 6.04539156e-01f, -2.31931910e-01f, -2.15298422e-02f, 9.69896987e-02f, 9.21964124e-02f, 8.72115046e-02f,
  -7.74370953e-02f, -1.48856252e-01f, -2.24654213e-01f, -2.48550639e-01f, -2.39826024e-01f, 2.00385284e-02f, 3.16754654e-02f, -1.49212312e-02f, 5.21782897e-02f, -3.94045934e-03f,
  2.75272578e-01f, 8.33394974e-02f, -1.43644065e-01f, -1.22484505e-01f, -9.10098553e-02f, -2.53328711e-01f, 4.39989269e-01f, -7.84865841e-02f, -2.45130993e-02f, 9.52066705e-02f,
  -4.97042723e-02f, 6.20426774e-01f, 5.96368611e-02f, -7.10903928e-02f, -7.44623244e-02f, 1.42442763e-01f, 3.49828333e-01f, 1.27749652e-01f, 1.79488480e-01f, 1.88522249e-01f,
  3.20261955e-01f, 3.96180190e-02f, 3.01451739e-02f, -1.38956979e-01f, -1.67704031e-01f, 8.77491087e-02f, -2.24507660e-01f, -1.00310147e-01f, 1.12614688e-02f, -1.27622932e-01f,
  1.64480880e-01f, 4.51714337e-01f, 1.84899837e-01f, 4.04343426e-01f, 4.20466289e-02f, 1.65101647e-01f, -1.50578901e-01f, 1.56539500e-01f, -4.10834327e-04f, -1.82547599e-01f,
  -1.19747780e-01f, 1.73658341e-01f, 1.10596806e-01f, -1.13900803e-01f, 3.27799767e-01f, 6.61486089e-02f, 3.90475243e-02f, 1.07350215e-01f, -2.61356622e-01f, 5.81134930e-02f,
  9.30408910e-02f, -1.28992591e-02f, 1.75067261e-02f, 7.18197078e-02f, 1.29783198e-01f, 1.30558446e-01f, -6.59260303e-02f, 1.06808223e-01f, 2.75093496e-01f, 1.50860012e-01f,
  3.25260982e-02f, -7.70111904e-02f, -6.14422634e-02f, 1.40330106e-01f, -8.57135206e-02f, 1.37797549e-01f, -1.02254100e-01f, 3.59081328e-02f, 3.15746814e-01f, -2.07750663e-01f,
  4.26956892e-01f, -7.19091818e-02f, -1.30335212e-01f, 3.58710103e-02f, -8.48037228e-02f, -2.58900374e-01f, -9.40080211e-02f, -1.01114720e-01f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  6.31413609e-02f, 2.64193621e-02f, 1.01399973e-01f, -1.02615841e-01f, -1.81613229e-02f, -8.80731866e-02f, 3.79900299e-02f, -2.36768648e-01f, -2.14566998e-02f, -1.06040277e-02f,
  2.16516256e-01f, -5.76431789e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 52
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 6, 52
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        64, 6, 52
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        64, 12
    );
    }
    