/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 128 (x1)
    * Saída: 12
    * Buffer Máx: 128
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 128;
    const int FAN_MAX_BUFFER_SIZE = 128;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 12 x 120)
const int L0_fan_Wp_rows = 12;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  3.40746373e-01f, -9.35928449e-02f, 5.83061688e-02f, -3.24065611e-02f, -1.57325014e-01f, 3.49569544e-02f, 1.06545292e-01f, -2.80115604e-01f, -5.94638847e-02f, -2.00142413e-01f,
  -5.92984371e-02f, 1.92322776e-01f, 3.95786725e-02f, 3.22453380e-02f, 4.26451653e-01f, 1.96451098e-01f, 1.19831853e-01f, 6.23135827e-02f, 2.62777787e-02f, -1.21105343e-01f,
  -2.44544949e-02f, -1.57256797e-01f, 2.89530884e-02f, -3.33951473e-01f, -2.76443455e-02f, -1.18502714e-01f, -1.89367503e-01f, -1.87489018e-02f, -4.75065596e-02f, 4.50479798e-02f,
  7.44413286e-02f, -7.01731220e-02f, 2.88252234e-02f, 6.43692389e-02f, -1.31082516e-02f, -3.01907621e-02f, 8.77158642e-02f, 7.73777217e-02f, 4.53309789e-02f, 3.69676575e-02f,
  8.68872255e-02f, 1.81905665e-02f, -2.24382523e-02f, -2.31213626e-02f, 1.87032316e-02f, -9.40014198e-02f, -1.84752699e-02f, -1.86119927e-03f, -3.90484594e-02f, 7.04206824e-02f,
  1.37415724e-02f, 4.65551428e-02f, -6.63870052e-02f, 9.09797326e-02f, 1.65309869e-02f, -2.22279727e-02f, -2.79914197e-02f, 8.64042267e-02f, 2.47686785e-02f, -1.90685354e-02f,
  -4.80008908e-02f, -2.99560223e-02f, -2.91585433e-03f, -3.23571637e-02f, -4.25243191e-02f, -1.58555117e-02f, -4.01816890e-02f, -2.66770292e-02f, -4.58605168e-03f, -1.44007970e-02f,
  -5.99975623e-02f, -3.03698573e-02f, -5.15984707e-02f, -3.89893465e-02f, 2.32080519e-02f, 1.88537538e-02f, 5.33007598e-03f, -4.56161909e-02f, -5.40968999e-02f, 2.01707222e-02f,
  -1.20584471e-02f, -1.67219248e-02f, -1.14897694e-02f, -3.61829437e-02f, -3.36267278e-02f, -7.94183929e-04f, -7.80212358e-02f, 4.32535522e-02f, -3.02291103e-02f, -1.07680960e-03f,
  -9.77084860e-02f, -8.15396160e-02f, -1.04399405e-01f, -2.90093701e-02f, -9.37153120e-03f, -8.97316262e-02f, 1.25038093e-02f, 2.08819117e-02f, -2.38198899e-02f, -6.91357180e-02f,
  -4.08842042e-02f, -2.24431865e-02f, -5.99513017e-02f, 1.79180894e-02f, -1.67345703e-02f, 1.39543656e-02f, -1.06595131e-02f, -5.04750349e-02f, -1.02312332e-02f, -4.86123376e-02f,
  -5.52496873e-02f, -3.31468061e-02f, 6.51621744e-02f, -9.87908542e-02f, -3.14239878e-04f, 2.19548531e-02f, 4.04731231e-03f, 3.12440563e-02f, -2.03377008e-02f, 5.57191335e-02f,
  1.43255323e-01f, 2.42530495e-01f, 1.76490285e-02f, 1.47586569e-01f, -1.05944589e-01f, -1.89942896e-01f, -1.89719409e-01f, 2.31888741e-02f, 1.83015093e-01f, 1.69865340e-01f,
  -2.54531056e-01f, 3.36541027e-01f, -1.51414499e-01f, -5.84132746e-02f, -1.82791412e-01f, -1.94332480e-01f, -1.07530087e-01f, 2.96639260e-02f, 1.05244584e-01f, 1.24927156e-01f,
  -4.57354188e-02f, -7.43113533e-02f, -2.00598538e-01f, 1.04450583e-02f, -1.49171799e-02f, 1.35266408e-01f, 1.39803011e-02f, 4.81036752e-02f, -1.16501292e-02f, -9.93387494e-03f,
  -1.12638131e-01f, 1.66508153e-01f, -8.27788468e-03f, -3.10603995e-02f, -6.79988340e-02f, 1.21994140e-02f, -3.03952359e-02f, -8.67545754e-02f, -1.75408162e-02f, 4.81458269e-02f,
  2.20162142e-02f, -4.54808436e-02f, 4.15116958e-02f, 9.08275321e-02f, 6.41869556e-04f, 4.17097472e-02f, 3.82562913e-02f, -1.10891964e-02f, -1.70986392e-02f, 2.09196424e-03f,
  2.06922134e-03f, -6.37195781e-02f, -1.39332032e-02f, 2.86755022e-02f, 4.29293560e-03f, 6.32693395e-02f, -3.62565406e-02f, -5.57350107e-02f, 1.00060161e-02f, 8.20976272e-02f,
  1.39431003e-02f, -5.87679446e-03f, -5.73089272e-02f, -6.79337084e-02f, -4.74114157e-02f, -1.49981277e-02f, 2.91906968e-02f, -3.41997072e-02f, 2.62596104e-02f, -1.27204508e-02f,
  6.25541992e-03f, 2.99241710e-02f, -4.75774817e-02f, 5.80043346e-02f, -3.29243466e-02f, -2.15809233e-02f, -1.53266601e-02f, -3.70251536e-02f, -2.55045984e-02f, -5.50201721e-02f,
  -4.99084080e-03f, 1.19877484e-04f, -2.88991872e-02f, -2.65180133e-02f, -8.03046152e-02f, -2.59734225e-02f, -1.18140923e-02f, -1.18483454e-02f, 1.98719334e-02f, -1.73817261e-03f,
  -2.29185205e-02f, 2.90373296e-01f, 2.60342937e-02f, 9.11651924e-02f, 1.25025576e-02f, -3.72064374e-02f, 1.15372371e-02f, 4.90761101e-02f, -2.37124078e-02f, -1.64073203e-02f,
  5.35675213e-02f, 4.07596901e-02f, 6.61432147e-02f, -3.96865681e-02f, 4.25225534e-02f, -6.72280136e-03f, 5.73206842e-02f, 1.68631412e-02f, 4.94739041e-02f, 1.65168140e-02f,
  -3.39675024e-02f, -1.11180339e-02f, -6.17049215e-03f, 6.16235612e-03f, -4.30892669e-02f, -2.51362454e-02f, 1.03573635e-01f, 2.73458436e-02f, 9.39315651e-03f, 5.42938225e-02f,
  -2.37627447e-01f, 4.65485416e-02f, -9.63798165e-02f, -1.39169753e-01f, -8.81501511e-02f, -1.18613847e-01f, 5.14779873e-02f, 7.27892146e-02f, 1.44460917e-01f, 1.62456691e-01f,
  3.75400484e-03f, -8.74276981e-02f, 2.34614789e-01f, -1.32042840e-01f, -3.03609580e-01f, 2.53982097e-01f, -1.25310257e-01f, -4.32320349e-02f, 1.20964080e-01f, -3.56821828e-02f,
  -7.10237399e-02f, -6.60040379e-02f, -7.65797347e-02f, -8.58424157e-02f, -9.07391086e-02f, -1.50910303e-01f, -2.38118306e-01f, -8.37540533e-03f, -3.53130996e-01f, -9.67822671e-02f,
  3.69820036e-02f, 7.91946501e-02f, -5.67153208e-02f, 5.86627088e-02f, -5.66024147e-02f, -2.05618218e-02f, -1.47429302e-01f, -6.60203621e-02f, -1.43289603e-02f, 2.40088850e-02f,
  3.30918133e-02f, -5.43610081e-02f, 2.72311419e-02f, 1.98991988e-02f, 4.76509668e-02f, -5.59184477e-02f, -3.74783240e-02f, 5.44733815e-02f, 2.85513978e-02f, -2.83166096e-02f,
  2.39222907e-02f, -4.60278541e-02f, -5.72733879e-02f, -3.71498875e-02f, -7.75782764e-02f, 2.18947176e-02f, 2.67067403e-02f, -6.20818511e-02f, 2.18819659e-02f, -3.84313539e-02f,
  -8.80999491e-02f, 1.42418956e-02f, 8.23296420e-03f, 4.35778946e-02f, -6.30620718e-02f, -4.00934145e-02f, -4.31776643e-02f, -2.88231000e-02f, -6.26458693e-03f, 2.40874058e-03f,
  -4.64397445e-02f, 1.48925753e-02f, -1.37531254e-02f, 1.17914136e-02f, -4.25777771e-02f, 4.34012823e-02f, -2.24979091e-02f, 2.88073858e-03f, -1.74935199e-02f, -9.33482312e-03f,
  4.10414822e-02f, -4.12569866e-02f, -2.66871462e-03f, -5.17365783e-02f, 6.34587696e-03f, -3.69625981e-03f, 6.36792043e-03f, -3.62152122e-02f, 1.41990837e-02f, -1.42335230e-02f,
  -6.21240102e-02f, -4.28397879e-02f, 1.09416522e-01f, 2.13601887e-02f, 2.22596601e-02f, -2.52399649e-02f, 6.13911562e-02f, -1.23376427e-02f, -8.81193131e-02f, 3.72928493e-02f,
  -8.42262134e-02f, 2.80563999e-02f, -2.66278498e-02f, -1.50995543e-02f, -7.64732137e-02f, -1.87738165e-02f, -1.91707897e-03f, -8.18090886e-02f, -1.03635840e-01f, -6.22207299e-02f,
  -7.23086996e-03f, 7.88511634e-02f, 1.81550421e-02f, 6.01087883e-02f, 1.88010894e-02f, -5.59078418e-02f, -6.35164902e-02f, 5.62824383e-02f, -6.69407919e-02f, 2.52494905e-02f,
  -2.59782165e-01f, 6.87610358e-02f, 1.72663316e-01f, -1.35537401e-01f, -1.22053720e-01f, -1.96488768e-01f, -1.53207332e-01f, -1.29037261e-01f, -1.63678214e-01f, 5.04591577e-02f,
  -3.29251811e-02f, 4.62706313e-02f, 6.57464117e-02f, 2.49712821e-02f, -3.82958978e-01f, 2.12438479e-02f, -2.31233686e-01f, -2.44158711e-02f, 2.20794342e-02f, -1.75537005e-01f,
  -7.31796771e-02f, -1.51740670e-01f, 2.80682575e-02f, 6.58299401e-02f, -3.48297544e-02f, 5.51534928e-02f, -1.22866705e-02f, 1.66089609e-01f, -1.92718841e-02f, 4.96736877e-02f,
  -1.29925042e-01f, 4.46572481e-03f, 8.95018224e-03f, 4.15277220e-02f, -1.16245061e-01f, -8.31301045e-03f, 1.47876013e-02f, 1.37786806e-01f, 6.60545528e-02f, 1.56901218e-02f,
  8.88152122e-02f, -6.78662881e-02f, 2.41220593e-02f, 2.86268704e-02f, -2.56009437e-02f, 1.42849302e-02f, 5.26008643e-02f, -1.58437958e-03f, 5.84246852e-02f, -2.90503912e-03f,
  6.53666109e-02f, 1.00999000e-02f, 2.26848610e-02f, 7.69829974e-02f, 4.59702080e-03f, -2.93277428e-02f, -1.07089756e-02f, 2.00467631e-02f, -3.46205272e-02f, -5.24534695e-02f,
  5.02594709e-02f, -7.51128271e-02f, 3.96836409e-03f, 2.34659240e-02f, -4.57393415e-02f, 1.09076323e-02f, 1.00516053e-02f, 4.17062221e-03f, 2.06000898e-02f, -2.87801512e-02f,
  -9.78785902e-02f, 3.64882722e-02f, -2.41401754e-02f, -2.31927186e-02f, -3.01880948e-02f, -2.10035499e-02f, -4.83105890e-03f, -5.02577459e-04f, -1.15711438e-02f, 6.42570807e-03f,
  5.88289136e-03f, -5.55394031e-02f, 1.28234383e-02f, 7.04545295e-03f, -6.85100332e-02f, 3.40491347e-02f, -2.63289232e-02f, -3.62281054e-02f, 7.92215765e-03f, -5.86124957e-02f,
  -3.07649881e-01f, -3.28341872e-01f, -1.37375593e-02f, 3.34337503e-02f, 4.71073994e-03f, -2.68082321e-02f, 1.01769185e-02f, -6.31544217e-02f, -5.85503764e-02f, -5.89741245e-02f,
  -6.06205091e-02f, -7.64760096e-03f, -6.00451194e-02f, 2.22589821e-02f, 4.77724476e-03f, -4.16400135e-02f, -3.75992469e-02f, 3.27733308e-02f, -1.26825064e-01f, -2.18493864e-02f,
  -5.57563268e-02f, -4.93884198e-02f, -3.64799425e-02f, -7.92517811e-02f, 5.85746020e-03f, 8.71466193e-03f, -5.86063862e-02f, 1.99458282e-02f, 4.41178754e-02f, -5.89892082e-03f,
  1.51282921e-01f, 2.81249195e-01f, 3.33869249e-01f, 1.76050544e-01f, -2.93652304e-02f, -9.67819095e-02f, -2.48003215e-01f, 1.28638312e-01f, 1.27849028e-01f, -2.19306245e-01f,
  -2.31571838e-01f, 1.63115948e-01f, -1.85184509e-01f, -7.12190643e-02f, -1.50996804e-01f, -1.15202799e-01f, 3.04669980e-02f, -8.34232718e-02f, 7.42906556e-02f, 1.65780902e-01f,
  4.74775583e-02f, -2.64718104e-02f, 5.16842380e-02f, 1.31623358e-01f, 1.36369169e-02f, 1.63634852e-01f, -1.49287537e-01f, -7.27609769e-02f, -2.29035430e-02f, -8.16939771e-02f,
  -2.95057446e-02f, 1.04517065e-01f, 7.77798891e-02f, 7.34034404e-02f, 8.32315348e-03f, -4.42456678e-02f, -5.68188075e-03f, -2.23627836e-02f, 1.87114365e-02f, 1.63797718e-02f,
  4.03371006e-02f, -3.03377192e-02f, 5.95157258e-02f, -6.32301718e-02f, 4.11157906e-02f, 1.14584975e-01f, -5.99687127e-03f, -3.91128957e-02f, 3.81843336e-02f, 6.09439202e-02f,
  9.16543824e-04f, 5.46836993e-03f, 4.04229462e-02f, -1.01738766e-01f, 5.58006503e-02f, 6.55671507e-02f, 1.73749309e-02f, 3.77750322e-02f, 1.94663424e-02f, 8.35360885e-02f,
  1.51120685e-03f, -2.22713761e-02f, -8.92778561e-02f, 3.31972204e-02f, 7.75295198e-02f, -1.26461294e-02f, 2.33795354e-03f, -2.17935368e-02f, 3.18440497e-02f, -1.75752193e-02f,
  1.66020778e-04f, 4.95907664e-02f, -4.28310446e-02f, -1.11853564e-02f, -3.54477726e-02f, 3.94721553e-02f, -8.98433663e-03f, -1.77428557e-03f, -1.41365202e-02f, 3.77609730e-02f,
  -4.92915288e-02f, -3.64809530e-03f, -1.30642727e-02f, 3.07459617e-03f, -2.98635736e-02f, -1.14771500e-02f, -1.54328281e-02f, 2.71597560e-02f, -2.56480258e-02f, 2.76127476e-02f,
  -8.03994574e-03f, 1.39030386e-02f, -6.19401075e-02f, 7.76628256e-02f, -3.22009134e-03f, -2.19965056e-02f, -4.51872405e-03f, 3.01688965e-02f, 4.21238355e-02f, 2.11212020e-02f,
  -1.83078535e-02f, -3.64629515e-02f, 3.06725334e-02f, 3.02334856e-02f, 5.83959918e-04f, -8.64607990e-02f, -5.85906059e-02f, 1.86149813e-02f, -5.48236072e-02f, -3.61813279e-03f,
  -1.60363968e-02f, 5.99944824e-03f, -7.31663592e-03f, 2.54329685e-02f, -8.12797397e-02f, -1.02427611e-02f, 8.00893009e-02f, 6.97456151e-02f, -6.30812198e-02f, 4.31916825e-02f,
  4.12382036e-01f, -2.49620646e-01f, -1.66779175e-01f, 1.37625679e-01f, 1.83400258e-01f, 3.14634025e-01f, 1.57032177e-01f, 2.60695722e-02f, 1.39905974e-01f, -3.66707705e-02f,
  6.21770509e-02f, -8.91573057e-02f, -3.17765027e-01f, 1.09093927e-01f, 7.52699822e-02f, -2.07582012e-01f, 2.72297233e-01f, 1.42316312e-01f, -2.89515983e-02f, 6.79894611e-02f,
  9.98680070e-02f, 9.23599973e-02f, -1.19652763e-01f, -3.80438790e-02f, 1.97704077e-01f, 1.68254506e-02f, -1.14136510e-01f, -1.51644394e-01f, 8.60307738e-02f, -4.85186353e-02f,
  1.06428482e-01f, -7.22663477e-02f, -5.73846232e-03f, -6.76994845e-02f, 7.44479373e-02f, 7.50768259e-02f, 7.61897420e-04f, 3.04222689e-04f, -7.01880641e-03f, -1.68222084e-03f,
  -6.23036288e-02f, -1.94288250e-02f, 6.32087365e-02f, -8.23625624e-02f, 6.72884062e-02f, -1.01387175e-02f, 1.70566700e-02f, 4.98746485e-02f, -2.50440389e-02f, 2.21583024e-02f,
  -4.18069847e-02f, -2.28635296e-02f, 6.00308701e-02f, -6.17378056e-02f, -2.45894510e-02f, 3.20281386e-02f, 4.14140709e-02f, -4.78374995e-02f, 2.06451658e-02f, 5.25942743e-02f,
  3.95304933e-02f, 3.35821472e-02f, -1.43985534e-02f, 3.66050303e-02f, 3.67362872e-02f, 2.46143099e-02f, 1.08193746e-02f, -8.39811191e-03f, 1.18023753e-02f, 2.38918904e-02f,
  3.71844019e-03f, 4.79467176e-02f, 6.15644865e-02f, 3.12499758e-02f, 3.44783328e-02f, -3.18150362e-03f, 1.32829743e-02f, -1.22155147e-02f, 6.06451854e-02f, 3.17710713e-02f,
  -6.85689822e-02f, 6.84907958e-02f, -6.83153048e-02f, 4.30635735e-02f, -1.36972098e-02f, 1.93236098e-02f, -2.94783115e-02f, -4.34836186e-02f, 1.91565976e-02f, 5.86157013e-03f,
  -6.94057792e-02f, -2.08978653e-01f, -4.34420407e-02f, 1.73042975e-02f, -4.57384288e-02f, 9.05479211e-03f, -3.93230580e-02f, -1.67334266e-02f, -4.95067537e-02f, 2.40195878e-02f,
  2.11701691e-02f, 9.06350464e-02f, -1.04137638e-03f, -3.04626743e-03f, 3.02604269e-02f, 4.89178002e-02f, -4.06133458e-02f, 6.30154135e-03f, 5.99562116e-02f, -3.48271616e-02f,
  -4.56606643e-03f, 5.52452952e-02f, -2.31464170e-02f, 1.01658322e-01f, -2.45097186e-03f, 1.43271973e-02f, -7.07041658e-03f, -2.05690283e-02f, -4.57030013e-02f, -2.32458171e-02f,
  -5.24069250e-01f, -7.92578682e-02f, -2.68468976e-01f, -3.40647817e-01f, 5.35803251e-02f, 1.32918924e-01f, -8.83801877e-02f, -1.43868914e-02f, -3.19121987e-01f, 1.79811254e-01f,
  2.20716536e-01f, -3.76917571e-01f, -4.71682381e-03f, 1.90175161e-01f, -9.50783491e-02f, 1.33942395e-01f, 1.20750563e-02f, -4.75994572e-02f, -8.99031758e-02f, -1.42548516e-01f,
  -1.43140465e-01f, 2.90926039e-01f, 5.24750054e-02f, 2.50396729e-01f, -5.60486168e-02f, -1.02785066e-01f, 3.37445699e-02f, -7.12525174e-02f, 2.00683147e-01f, 1.68019742e-01f,
  1.06136218e-01f, -9.62546617e-02f, -3.50262076e-02f, -7.92690844e-04f, 4.03570831e-02f, 7.49250234e-04f, 2.57584397e-02f, -4.19185776e-03f, -2.48176679e-02f, 4.83213700e-02f,
  -9.60326716e-02f, -2.42742826e-03f, -5.54800630e-02f, 2.69209836e-02f, 7.58467754e-03f, -3.27551626e-02f, -2.76945420e-02f, 3.93548347e-02f, -9.63489637e-02f, -2.92496495e-02f,
  -6.42098039e-02f, 5.72501644e-02f, -4.06749249e-02f, 5.56132495e-02f, -4.31038626e-02f, 2.29835100e-02f, 2.37517022e-02f, -1.60500556e-02f, 1.94417350e-02f, -2.92442203e-03f,
  -8.60594586e-03f, 2.86651007e-03f, 3.27854753e-02f, 7.17805624e-02f, -1.60830207e-02f, 5.45217432e-02f, -1.33325625e-02f, 5.00883125e-02f, -5.82316006e-03f, 3.96112911e-02f,
  3.71907614e-02f, -5.06922789e-03f, 1.06145591e-02f, -1.52118085e-02f, 1.92523282e-02f, 1.25324270e-02f, 2.81740203e-02f, 1.09616555e-02f, -1.62706710e-02f, 1.86394416e-02f,
  2.04356713e-03f, 1.18072135e-02f, 1.25283347e-02f, 1.47197209e-02f, 3.52003053e-03f, -4.19513211e-02f, 1.26148546e-02f, 4.76253629e-02f, -2.29612677e-04f, -3.26143503e-02f,
  7.48618320e-02f, -1.44373924e-01f, -6.95856735e-02f, 5.16596250e-02f, 3.10993399e-02f, 3.04963365e-02f, 2.20945273e-02f, 2.07671188e-02f, -1.21144401e-02f, -5.49348369e-02f,
  7.15151131e-02f, -2.13872641e-02f, 4.89425734e-02f, -1.48670478e-02f, 1.38956448e-02f, 4.14050631e-02f, -5.41399652e-03f, -4.14224453e-02f, 1.84535719e-02f, 5.11463769e-02f,
  4.96567711e-02f, -2.97464225e-02f, 1.62532597e-05f, 9.94129851e-03f, -2.23232005e-02f, 2.00008433e-02f, -5.55661805e-02f, -8.74888524e-03f, 1.54879680e-02f, -2.78765634e-02f,
  -2.19339684e-01f, -1.36532754e-01f, -3.75707895e-01f, -1.61126256e-01f, 6.52434304e-02f, 3.24127227e-02f, -5.03223762e-02f, -9.28869098e-02f, -2.63629973e-01f, 2.40238175e-01f,
  1.37412846e-01f, -1.26276523e-01f, 3.38438936e-02f, -5.29793687e-02f, -1.19582355e-01f, 1.01076728e-02f, -9.99799296e-02f, 4.28578816e-02f, -1.50371894e-01f, -8.08095858e-02f,
  -1.63781017e-01f, 1.41652912e-01f, -8.39977115e-02f, 7.15607181e-02f, 5.34758791e-02f, -9.31795761e-02f, 2.52809525e-01f, -3.91192324e-02f, 1.64768308e-01f, 5.59120923e-02f,
  -9.81722400e-02f, -1.12319030e-01f, -8.60119388e-02f, 2.55761612e-02f, -7.69843459e-02f, 3.96702215e-02f, 8.43706131e-02f, 4.34697792e-02f, -8.69399011e-02f, -1.95645541e-02f,
  -1.29737789e-02f, -4.58672382e-02f, 9.24385898e-03f, 3.47945727e-02f, -3.71266939e-02f, -4.20272164e-02f, -6.22619204e-02f, -2.24952921e-02f, -5.23389615e-02f, -7.14265704e-02f,
  -1.04966976e-01f, -2.76346914e-02f, -2.35454515e-02f, -8.54511338e-04f, 2.18373351e-02f, -5.58868870e-02f, -6.50067329e-02f, 1.05929514e-02f, -1.15676818e-03f, -3.27162594e-02f,
  1.95665415e-02f, -2.82868533e-03f, -4.67618443e-02f, -2.22697984e-02f, -2.30484772e-02f, 8.52294043e-02f, -5.24666607e-02f, 6.75400421e-02f, -2.85318848e-02f, 5.97084984e-02f,
  2.81957351e-02f, -2.29628440e-02f, -3.70344035e-02f, 2.00000908e-02f, -4.10311967e-02f, 2.08242889e-02f, -1.29114911e-02f, 6.73420876e-02f, -1.61049180e-02f, 1.30286170e-02f,
  5.02105057e-02f, 3.89372557e-02f, 3.96104865e-02f, 5.40697724e-02f, -2.47182809e-02f, 4.83262017e-02f, 2.52823643e-02f, -9.43417922e-02f, 2.46352190e-03f, 4.60117087e-02f,
  -4.99426313e-02f, -6.15861900e-02f, 2.80774734e-03f, 5.61447479e-02f, 6.39660284e-02f, 7.66931400e-02f, -9.18853655e-02f, 2.90569402e-02f, 2.24202052e-02f, 1.34087878e-03f,
  -3.50108044e-03f, -1.00543415e-02f, -1.30652497e-02f, 5.57737462e-02f, 1.09826000e-02f, 5.06413309e-03f, 3.80432680e-02f, -6.32791035e-03f, 2.52445657e-02f, 6.60452098e-02f,
  4.01017703e-02f, 8.02379474e-02f, -1.05918478e-03f, -9.37179476e-03f, 5.93708120e-02f, 7.50702396e-02f, 3.24567640e-03f, -7.06651062e-02f, 4.68063802e-02f, 5.77556826e-02f,
  1.13581397e-01f, -1.17048055e-01f, -1.95483431e-01f, 5.87773882e-02f, -7.15233535e-02f, -7.80977905e-02f, 4.66635339e-02f, -1.25943735e-01f, -8.46261680e-02f, 1.17128141e-01f,
  8.32973048e-02f, 2.54331291e-01f, -1.13732971e-01f, 1.78183720e-01f, 1.09056160e-01f, 2.71323975e-03f, 1.45539105e-01f, 2.54164308e-01f, 1.56309195e-02f, -3.87053601e-02f,
  9.52431858e-02f, 2.48586655e-01f, -3.97839993e-02f, -8.87765214e-02f, 2.50791386e-02f, -1.78443655e-01f, 1.60490155e-01f, -7.00446963e-02f, 2.15942692e-02f, 1.53884023e-01f,
  3.20668109e-02f, 7.66734928e-02f, 5.34352139e-02f, -1.29774129e-02f, -1.07945003e-01f, 3.55818011e-02f, 4.08720709e-02f, 1.41080813e-02f, -4.37841937e-02f, 7.12897778e-02f,
  1.63448732e-02f, 1.75142102e-02f, 6.36659339e-02f, 2.95578386e-03f, -6.32889941e-02f, -8.89086500e-02f, -5.66489697e-02f, 2.87632272e-02f, 1.07112981e-01f, 3.38619240e-02f,
  -8.87800902e-02f, -1.24217765e-02f, 1.10411393e-02f, 6.88730404e-02f, 2.45912354e-02f, 1.73613131e-02f, 4.00976054e-02f, -1.56116253e-02f, 3.43382619e-02f, -5.22722900e-02f,
  3.37199047e-02f, -9.90599673e-03f, -4.56738099e-02f, 3.20634022e-02f, -7.56064206e-02f, -9.50255431e-03f, 6.84726164e-02f, 6.56295642e-02f, -6.57466501e-02f, -4.49572802e-02f,
  1.23971170e-02f, -1.43826026e-02f, 6.42778575e-02f, 5.21072894e-02f, -1.13079697e-02f, 4.38367315e-02f, 1.76816098e-02f, 9.42779407e-02f, 8.81353579e-03f, 3.15121263e-02f,
  2.44569778e-02f, -1.76697168e-02f, 7.23706186e-02f, 7.09700808e-02f, -1.02244681e-02f, 1.27786696e-02f, -2.72705946e-02f, 3.73362973e-02f, -5.44374585e-02f, 2.09352951e-02f,
  -3.11926324e-02f, -9.13397148e-02f, -8.85061473e-02f, -1.14741670e-02f, -2.66167540e-02f, 2.34859972e-03f, 1.17017934e-03f, -3.32746729e-02f, -4.99943458e-02f, -6.69315234e-02f,
  -6.16292506e-02f, -2.98769902e-02f, 7.17501640e-02f, -1.46329058e-02f, -3.76509763e-02f, -1.81142464e-02f, 9.61948857e-02f, -1.70529895e-02f, 6.37461245e-02f, 5.18467166e-02f,
  -1.91820394e-02f, 3.96395214e-02f, -4.83032279e-02f, -7.16899931e-02f, 1.57116596e-02f, 4.19756845e-02f, -4.59025614e-02f, -3.78695317e-02f, -1.68749108e-03f, 5.04129566e-02f,
  -1.75530970e-01f, 2.40382865e-01f, 4.97375091e-04f, -7.49118030e-02f, -1.86010197e-01f, -8.95759463e-02f, -1.16210636e-02f, 7.74135515e-02f, -1.46189287e-01f, 2.27746934e-01f,
  1.57578420e-02f, 7.38019962e-03f, 1.04184367e-01f, -4.11739275e-02f, -2.10019369e-02f, 1.09532610e-01f, 9.88650247e-02f, -7.94502627e-03f, 2.18327120e-02f, 1.09974537e-02f,
  -6.16838783e-02f, 8.31066370e-02f, 3.97873372e-02f, 1.04526341e-01f, -3.49325426e-02f, 1.10703677e-01f, 9.19550210e-02f, 6.77501708e-02f, 8.47369879e-02f, -7.04060644e-02f,
  7.54478797e-02f, 7.76349530e-02f, 5.60980178e-02f, -8.19908455e-02f, -1.16802249e-02f, 2.99824178e-02f, 3.64753865e-02f, -2.40931250e-02f, -9.39507559e-02f, -3.58853936e-02f,
  2.17427351e-02f, -1.10724039e-01f, 2.94782594e-02f, -8.08388889e-02f, -1.60973240e-02f, -9.95488558e-03f, -1.15178309e-01f, -2.72647012e-02f, -5.26421377e-03f, 1.51978724e-03f,
  -5.85534982e-02f, 3.60161550e-02f, -2.35955566e-02f, -4.22097258e-02f, -4.08437513e-02f, -7.32042491e-02f, 5.79127222e-02f, 2.02539330e-03f, 5.45572713e-02f, -2.75422204e-02f,
  -4.73335013e-02f, 6.48545101e-02f, 2.88230143e-02f, -3.85961980e-02f, -3.01533155e-02f, -2.53802724e-02f, -6.51569143e-02f, 6.15956709e-02f, -7.78011531e-02f, 9.09583792e-02f,
  -3.51396836e-02f, -3.41339111e-02f, 4.94777262e-02f, -6.46733493e-02f, -1.58235878e-02f, 1.69997010e-02f, -2.42325943e-02f, -1.14778709e-02f, 5.41647077e-02f, -1.15124909e-02f,
  -4.79251705e-02f, -1.67369861e-02f, 8.09971914e-02f, -2.91436799e-02f, -5.87151684e-02f, 1.27234990e-02f, 6.06155694e-02f, 3.52670550e-02f, -1.21172722e-02f, -4.27952930e-02f,
  8.82651806e-02f, 3.45272422e-01f, 9.59603563e-02f, -9.46945697e-02f, 9.38079506e-02f, 5.15661277e-02f, 4.91505116e-02f, 3.27215195e-02f, 2.35583745e-02f, 2.82343160e-02f,
  3.07536200e-02f, -7.68230185e-02f, 2.48517301e-02f, 5.05153835e-03f, 2.64983270e-02f, 1.01503134e-02f, 8.14047605e-02f, 3.73539254e-02f, 8.76165368e-03f, 8.35537836e-02f,
  7.07039014e-02f, -5.27420454e-02f, 5.38675785e-02f, -1.84026081e-02f, 8.64355564e-02f, 1.27754528e-02f, 4.51891236e-02f, -3.07619991e-03f, -5.52402176e-02f, 7.37944171e-02f,
  -2.80521303e-01f, 2.08810195e-01f, -6.62423000e-02f, -9.26948190e-02f, -2.40252376e-01f, -1.63814262e-01f, -5.77590726e-02f, -2.90211886e-02f, 8.80172625e-02f, 2.57099152e-01f,
  -3.43037881e-02f, -6.27500117e-02f, 1.79910883e-01f, 1.07669145e-01f, -2.66676992e-01f, 3.03680480e-01f, 1.18863611e-02f, 5.12669906e-02f, -2.30962803e-04f, -1.25891045e-01f,
  -5.30387424e-02f, 3.68354656e-02f, -1.85258724e-02f, 1.03973582e-01f, -2.14178398e-01f, -4.73907366e-02f, 1.19631961e-02f, 2.40672529e-02f, -1.92413572e-02f, -1.49072304e-01f,
  -1.95398629e-01f, 2.23766584e-02f, -2.19656546e-02f, 1.52069088e-02f, -4.33374643e-02f, 2.83542497e-04f, -8.82913396e-02f, 3.76481302e-02f, -5.90057932e-02f, -3.80586907e-02f,
  -5.13429381e-02f, -6.05527461e-02f, -6.55725300e-02f, -5.53232012e-03f, -7.72829354e-02f, -3.18622366e-02f, 5.62308729e-02f, -5.27884401e-02f, -3.71689238e-02f, 1.72022525e-02f,
  -4.16368134e-02f, 6.36920892e-03f, 5.13155349e-02f, -3.86455841e-02f, 2.76142545e-02f, -5.97696453e-02f, 2.05267165e-02f, -2.87112184e-02f, -1.56042753e-02f, -7.74256140e-02f,
  -1.15342857e-02f, 5.01625938e-03f, -7.61900190e-03f, -1.69300474e-02f, -8.39003641e-03f, -4.25951071e-02f, 1.11929625e-02f, -4.14027236e-02f, -4.06944230e-02f, -3.64018865e-02f,
  -6.87554553e-02f, 7.84674659e-03f, 4.67782877e-02f, 2.39330959e-02f, 5.30110076e-02f, -1.20435003e-02f, 4.22188565e-02f, -1.79708991e-02f, -4.39474359e-02f, -4.48926017e-02f,
  5.71430027e-02f, -7.52303982e-03f, -3.07962135e-03f, -5.41381873e-02f, 3.77287753e-02f, -2.21257564e-02f, 7.13262782e-02f, -3.70194465e-02f, -1.81438494e-02f, -9.18807611e-02f,
  -6.19126596e-02f, 4.84245643e-02f, -1.32627301e-02f, -8.96720365e-02f, 3.26555548e-03f, 4.32337523e-02f, 1.08959176e-01f, 3.35641131e-02f, 8.17034394e-02f, -4.46544662e-02f,
  -1.64245367e-02f, 2.41737161e-02f, 2.41479222e-02f, 5.07896394e-02f, 4.48514000e-02f, -4.67440896e-02f, -6.28127679e-02f, 3.76932435e-02f, -2.30409838e-02f, 5.04711308e-02f,
  -5.66616729e-02f, -4.05861326e-02f, 6.35722354e-02f, 5.51931225e-02f, 1.01295142e-02f, 3.24675255e-02f, -6.98376894e-02f, 4.18066382e-02f, 1.80552080e-02f, 5.00052050e-02f,
  -1.35533512e-01f, 3.83299619e-01f, -7.20034540e-02f, 1.20250896e-01f, -1.06240392e-01f, -1.22907482e-01f, -1.47215322e-01f, 1.15149967e-01f, -2.70609148e-02f, 2.17938125e-01f,
  1.14073679e-01f, -5.21307141e-02f, 3.77125144e-02f, 3.14631015e-01f, -2.88772374e-01f, 9.55233537e-03f, 1.32198632e-01f, 8.72736424e-02f, 7.69448280e-02f, 5.63074239e-02f,
  3.71036790e-02f, 1.72772929e-01f, 4.43226472e-02f, 1.90763235e-01f, 9.19627175e-02f, 1.13460645e-01f, 1.03402831e-01f, -8.66734535e-02f, 9.28966627e-02f, -9.36228856e-02f,
  -5.58146499e-02f, 1.46885648e-01f, 2.94733085e-02f, -7.41070956e-02f, -6.88212141e-02f, -1.47728035e-02f, -8.10615420e-02f, -1.54462615e-02f, -4.17460920e-03f, -3.12803965e-03f,
  -5.54667860e-02f, 4.52340692e-02f, 2.59623714e-02f, -9.15115420e-03f, -5.78090511e-02f, -4.33762372e-03f, 1.23462612e-02f, -2.46147159e-02f, -1.33776630e-04f, 2.61929389e-02f,
  -1.71756893e-02f, -3.17537412e-03f, -3.91005501e-02f, -2.41696909e-02f, -1.01588313e-02f, 2.69775540e-02f, -5.35913035e-02f, -3.18575539e-02f, 3.73862758e-02f, 3.45669361e-03f,
  -7.10140914e-02f, 2.34670956e-02f, 2.52959263e-02f, -9.26059019e-03f, 5.26677817e-03f, 6.75925687e-02f, 3.96383777e-02f, 3.86992446e-03f, 8.03872291e-03f, 2.19232719e-02f,
  -6.11905307e-02f, 7.28890225e-02f, -2.23818757e-02f, -4.41508070e-02f, -1.86007172e-02f, 1.28806278e-03f, -4.45030257e-02f, 3.39760147e-02f, -5.05071580e-02f, 2.59844400e-02f,
  2.37265304e-02f, -2.72735283e-02f, 4.41475771e-03f, 4.85107973e-02f, -4.54444699e-02f, -2.85619237e-02f, 4.55116890e-02f, -3.41016501e-02f, -6.08028052e-03f, -4.85685095e-02f,
  -5.73550835e-02f, 3.06847822e-02f, 3.40071321e-02f, -1.49269933e-02f, 4.28169817e-02f, -8.94854590e-03f, 5.80509342e-02f, -4.87838052e-02f, -3.93573865e-02f, 1.70330890e-02f,
  -8.20191279e-02f, 3.02769374e-02f, -3.28884423e-02f, 5.45592979e-02f, 1.93832796e-02f, 4.05969471e-02f, 2.11012550e-03f, 1.81595627e-02f, -7.48774484e-02f, 1.48363854e-03f,
  2.84618754e-02f, -5.50031178e-02f, -2.47976724e-02f, -9.52707045e-03f, 3.06583922e-02f, -2.11075181e-03f, -1.00373877e-02f, 3.90351303e-02f, 5.63435536e-03f, -4.49532755e-02f
};

// L0_fan_Wp_bar (Shape: 104 x 120)
const int L0_fan_Wp_bar_rows = 104;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  3.79906408e-02f, -2.38720793e-02f, -2.68959217e-02f, -9.49786082e-02f, -1.71253048e-02f, 1.20401822e-01f, 1.24651089e-01f, 8.75330437e-03f, -7.71919340e-02f, 4.98262569e-02f,
  1.30960613e-01f, -1.52224815e-02f, 8.71165842e-02f, 1.10308856e-01f, -6.48393929e-02f, 4.34738621e-02f, 1.50452867e-01f, 9.41287503e-02f, -3.65361571e-02f, -1.03091531e-01f,
  1.60394367e-02f, 6.58447370e-02f, -3.58424522e-02f, 5.23413979e-02f, 4.65446599e-02f, -2.36873254e-02f, 2.22086273e-02f, 2.59480476e-02f, 1.01627558e-01f, 8.61972868e-02f,
  -3.56485359e-02f, -2.97251064e-03f, -1.36793768e-02f, -1.15760297e-01f, -1.80056561e-02f, -7.60254264e-02f, 5.21169901e-02f, 6.75115958e-02f, -5.33936406e-03f, -4.82055321e-02f,
  -1.08776977e-02f, -5.70885018e-02f, -2.80359536e-02f, -9.24907997e-02f, 2.73844991e-02f, 5.39966207e-03f, 6.41371682e-02f, 8.64839330e-02f, 6.10878319e-02f, -4.96240146e-02f,
  3.84542458e-02f, 9.81458798e-02f, 8.16590935e-02f, 1.95660423e-02f, 3.74411456e-02f, -5.07358611e-02f, -7.34367743e-02f, -5.43619087e-03f, 6.66137785e-02f, 3.85098085e-02f,
  -9.18666199e-02f, 4.11668196e-02f, 9.04971883e-02f, -1.91243999e-02f, -7.50514492e-02f, -7.03752413e-02f, 1.13928467e-02f, 6.00898527e-02f, -5.19128032e-02f, -2.65207570e-02f,
  -5.23947813e-02f, 6.19290881e-02f, 2.33772732e-02f, 5.40722869e-02f, 2.20806878e-02f, 6.58044070e-02f, -8.08907766e-03f, -2.34510843e-02f, -2.08841283e-02f, 6.38851002e-02f,
  6.19097101e-03f, 1.55158257e-02f, 3.82634848e-02f, 9.67511833e-02f, 7.57121667e-02f, 2.95030884e-02f, -6.34342283e-02f, 1.61470193e-02f, -8.09439179e-03f, 4.36757356e-02f,
  -1.11764684e-01f, -8.30691382e-02f, -5.35871461e-02f, -7.05948845e-02f, 3.16922814e-02f, 3.72944660e-02f, -4.15249132e-02f, -4.93334942e-02f, -3.88779342e-02f, 4.12570201e-02f,
  -9.15158987e-02f, 2.29303949e-02f, -7.89518282e-02f, 2.90368050e-02f, -6.25639260e-02f, -1.75312534e-02f, -5.04542626e-02f, -1.47560174e-02f, 8.66986290e-02f, 1.56160081e-02f,
  -2.55599320e-02f, 2.83580162e-02f, 3.08885369e-02f, 6.71758354e-02f, 6.97019547e-02f, -2.62290351e-02f, -3.48950475e-02f, -6.09421022e-02f, 1.51751060e-02f, -5.40076047e-02f,
  1.48535043e-01f, -6.07176982e-02f, -9.66342166e-02f, -1.09908052e-01f, -9.55281854e-02f, -1.36897922e-01f, -1.35598674e-01f, -3.71320546e-03f, -4.77755331e-02f, -1.72020646e-03f,
  -2.88366210e-02f, 1.60239842e-02f, 2.04079431e-02f, -3.66741866e-02f, 6.98135793e-02f, 1.55039638e-01f, 3.69379260e-02f, 4.88635004e-02f, 9.02268440e-02f, -9.48113129e-02f,
  6.81423247e-02f, -5.63554876e-02f, 1.09626185e-02f, -1.55847147e-03f, -5.53935282e-02f, -7.82075971e-02f, -1.16159534e-02f, 3.53064686e-02f, -5.23621328e-02f, -6.00207783e-02f,
  -5.52002043e-02f, 1.10525757e-01f, 1.46948043e-02f, 4.16509807e-02f, -4.03696932e-02f, 7.30977282e-02f, -4.63509299e-02f, -6.72003180e-02f, -6.71012979e-03f, 8.32639635e-02f,
  9.48979519e-03f, -1.64140109e-02f, 4.06678654e-02f, -3.72486413e-02f, -9.24950764e-02f, 4.59768400e-02f, -5.19971969e-03f, 3.52862384e-03f, 2.88266018e-02f, -5.59858000e-03f,
  -7.09266886e-02f, 7.07056746e-02f, -2.42471360e-02f, 6.25290200e-02f, -6.52850419e-02f, 1.61992572e-02f, -8.53921324e-02f, -1.19568529e-02f, -8.39920416e-02f, 3.81448679e-02f,
  7.21940398e-02f, -4.65631895e-02f, -7.14703649e-02f, 4.44524065e-02f, -6.14844151e-02f, 2.94130798e-02f, -7.25137517e-02f, 4.33966815e-02f, 9.53725502e-02f, -3.68143730e-02f,
  -1.22461645e-02f, 4.33724821e-02f, 3.86283919e-02f, -7.51287490e-02f, 7.15060206e-03f, 1.67111252e-02f, -2.30716094e-02f, 7.04665668e-03f, -8.50603804e-02f, -7.83252493e-02f,
  7.20598400e-02f, -2.96352394e-02f, -1.78510807e-02f, 2.05189828e-02f, 6.00522086e-02f, 4.26994497e-03f, 7.23113716e-02f, -2.07322072e-02f, -7.60976151e-02f, -9.00688116e-03f,
  -5.22952266e-02f, -3.02671231e-02f, -4.73347716e-02f, -2.08921712e-02f, 9.13708135e-02f, -2.95588113e-02f, 2.91660875e-02f, 3.28083150e-02f, 1.62020884e-02f, -6.73938841e-02f,
  -7.79063553e-02f, 3.05012148e-02f, 5.78730255e-02f, 4.75364216e-02f, -1.94305331e-02f, -4.77327779e-03f, -2.05756444e-02f, -7.80131295e-02f, -5.13221435e-02f, 6.36265054e-02f,
  5.91838136e-02f, 7.23249093e-02f, -6.10486045e-02f, 6.12121522e-02f, 2.00167466e-02f, -1.04215451e-01f, 4.48078066e-02f, -7.21339434e-02f, -4.22222987e-02f, 2.98612975e-02f,
  1.98267594e-01f, -1.75994709e-02f, -1.93587050e-01f, -1.64855793e-01f, 3.60889062e-02f, 2.87207551e-02f, -4.72011752e-02f, 2.61767441e-03f, -9.21210572e-02f, 2.61023678e-02f,
  7.56912082e-02f, -8.01436882e-03f, 4.13532145e-02f, -3.66696157e-02f, 7.10296556e-02f, 4.72304039e-02f, 1.66752696e-01f, 5.33763831e-03f, -1.22291334e-01f, 9.31519717e-02f,
  -5.34077995e-02f, 1.21281959e-01f, -1.51268095e-01f, -1.03513571e-02f, 1.39728725e-01f, -8.96864906e-02f, 7.25054070e-02f, -8.87118429e-02f, 9.87043977e-02f, 4.01726575e-04f,
  2.42695939e-02f, -9.08913016e-02f, -5.62498309e-02f, 1.02230068e-02f, 9.13696438e-02f, 1.12213708e-01f, 1.24095250e-02f, -4.64339592e-02f, 4.66520973e-02f, -1.63203031e-02f,
  9.57843363e-02f, 3.05071454e-02f, 3.61104608e-02f, -5.31515963e-02f, 3.07370760e-02f, -3.11729498e-02f, -1.44521832e-01f, -6.36872277e-02f, -1.01227686e-01f, 2.42820214e-02f,
  -8.02243724e-02f, 7.87996650e-02f, 1.88109558e-02f, -9.35844332e-02f, -5.67149818e-02f, 3.18826437e-02f, -4.21217177e-03f, -2.02797037e-02f, -1.37787517e-02f, 2.35087965e-02f,
  6.13974854e-02f, -3.79588604e-02f, 1.07164025e-01f, -4.63799573e-02f, -9.13212448e-02f, -4.47369516e-02f, -5.41018359e-02f, -7.20852166e-02f, 3.60640399e-02f, 5.02529368e-02f,
  -3.87094468e-02f, -1.10533484e-03f, 3.96288000e-02f, 4.87587526e-02f, 5.27735427e-02f, -8.59656855e-02f, 3.83768380e-02f, -3.11183296e-02f, 4.76692943e-03f, -8.47898498e-02f,
  5.68443723e-02f, -3.42774130e-02f, 7.01163635e-02f, -8.07003584e-03f, -2.07936205e-02f, -3.25260148e-03f, -2.15944499e-02f, -3.57040204e-02f, 4.27082218e-02f, -5.45180738e-02f,
  5.82693145e-02f, 2.01070532e-01f, -1.31632760e-01f, -3.34716961e-02f, -6.06772304e-02f, 7.92216733e-02f, 4.38332185e-02f, 7.40619600e-02f, -1.52386315e-02f, -1.11783883e-02f,
  1.06816277e-01f, 7.74564967e-03f, 1.06507219e-01f, 7.64555112e-02f, -3.46760936e-02f, 3.06192264e-02f, -5.07546999e-02f, -3.52372974e-02f, -3.18197198e-02f, -5.87768480e-02f,
  2.53398623e-02f, -6.89301714e-02f, 8.04333389e-02f, 1.07519701e-03f, 3.15959863e-02f, -2.82842368e-02f, 8.84820521e-02f, 4.17494476e-02f, 3.60065587e-02f, -7.68890306e-02f,
  -4.99897748e-02f, 2.82013118e-02f, -3.34594920e-02f, 1.18398909e-02f, -7.55247325e-02f, -1.53398037e-01f, -1.53513834e-01f, -5.71198994e-03f, 6.32391078e-03f, 3.78114730e-03f,
  -3.21642719e-02f, -6.93762228e-02f, -9.09277052e-02f, -1.19353719e-01f, 2.28999183e-02f, -1.31121323e-01f, -5.17609902e-03f, -1.03258632e-01f, 3.96408662e-02f, 1.57042921e-01f,
  8.76433477e-02f, 5.06197214e-02f, 1.22529618e-01f, 1.96994871e-01f, 5.86954206e-02f, 1.31480977e-01f, 2.26569876e-01f, 6.13076473e-03f, 9.16789025e-02f, -9.43161082e-03f,
  -9.88169238e-02f, -4.06484120e-02f, -5.50923496e-02f, -6.59711212e-02f, 9.85409692e-02f, -4.06355299e-02f, -3.38616297e-02f, 8.02770182e-02f, 6.51595742e-02f, -5.59750348e-02f,
  -5.10239154e-02f, 2.85723917e-02f, -2.45214328e-02f, -2.50247810e-02f, -7.31020048e-02f, 4.42960858e-02f, -2.26884000e-02f, -6.03760891e-02f, 1.05123790e-02f, -9.96256769e-02f,
  -1.42018106e-02f, 5.67512549e-02f, 9.73610133e-02f, 5.23026772e-02f, 9.06373560e-02f, 1.39362942e-02f, -3.36320698e-02f, 1.11788981e-01f, -8.26371834e-02f, 9.80575606e-02f,
  -1.46365501e-02f, 6.80054398e-03f, 7.15110963e-03f, -6.12242660e-03f, -6.38677701e-02f, 4.63641211e-02f, 5.86868497e-03f, 7.21264482e-02f, -5.96741177e-02f, 1.88921373e-02f,
  -6.09023422e-02f, 4.73685861e-02f, -8.53886455e-02f, 1.78947616e-02f, 8.72527137e-02f, -9.29506570e-02f, 3.76761071e-02f, 2.83344444e-02f, -2.14520618e-02f, -5.25578000e-02f,
  2.84046633e-03f, -9.96212214e-02f, -5.03053628e-02f, -6.06040880e-02f, -1.06749989e-01f, 5.29873595e-02f, 7.92190284e-02f, -6.65048361e-02f, 7.20663220e-02f, 8.95890594e-02f,
  7.45642409e-02f, 2.10222438e-01f, 3.23607512e-02f, 4.20960449e-02f, -5.44908158e-02f, -6.70476854e-02f, -3.14285085e-02f, -1.85341798e-02f, 5.32821286e-03f, -8.18958208e-02f,
  1.26006052e-01f, -1.11769456e-02f, -1.10299187e-02f, 8.07315856e-03f, -1.94512382e-02f, 2.72178929e-02f, -1.37365342e-03f, 1.34860864e-02f, 1.25076041e-01f, 6.55408427e-02f,
  -2.27293856e-02f, 7.36427531e-02f, 1.34463822e-02f, -4.60338630e-02f, 8.74928311e-02f, 6.07330538e-02f, -1.24399513e-02f, 4.96177077e-02f, -2.33382881e-02f, -4.76387218e-02f,
  2.97632903e-01f, 2.14476418e-02f, -1.34817675e-01f, 9.59349573e-02f, -1.04438089e-01f, -1.38488859e-01f, -1.63576677e-01f, 1.08746015e-01f, 1.02175795e-03f, 1.67545769e-02f,
  1.43229976e-01f, -6.47452995e-02f, 6.30410165e-02f, 1.94076180e-01f, 1.63725495e-01f, -2.72848662e-02f, 2.03839600e-01f, 3.60496007e-02f, -1.10441342e-03f, 1.92159921e-01f,
  1.33224070e-01f, 2.30854452e-01f, 1.11866377e-01f, 1.52701601e-01f, 3.72916460e-02f, -8.59809667e-03f, 4.54714410e-02f, -4.84284423e-02f, -4.52726334e-03f, -1.74715277e-02f,
  1.33892046e-02f, 1.34618893e-01f, 4.49122190e-02f, -1.03131756e-01f, 1.02076121e-01f, -6.46415725e-02f, -7.58233815e-02f, -6.33387268e-02f, -1.07105330e-01f, 9.28699002e-02f,
  -3.69859561e-02f, -3.49841267e-02f, 6.86984509e-02f, -7.31641203e-02f, -4.05690074e-02f, 5.46207316e-02f, 3.06587992e-03f, -3.29529718e-02f, -1.14306842e-03f, 5.64163476e-02f,
  1.44195650e-02f, 3.39595675e-02f, 2.75022760e-02f, -3.73728424e-02f, 3.81856151e-02f, 5.51413558e-02f, -9.79443938e-02f, -2.93363463e-02f, 4.03232239e-02f, 3.03303991e-02f,
  1.21882074e-01f, 4.52879909e-03f, 4.39204611e-02f, -4.82021309e-02f, 8.19130626e-04f, -6.27913922e-02f, -5.97466268e-02f, -8.25147629e-02f, -2.94695105e-02f, -3.17451209e-02f,
  1.00071775e-02f, -5.24285026e-02f, 4.27563954e-03f, -3.73088680e-02f, -2.54170168e-02f, 5.88141894e-03f, -1.17390580e-01f, 4.07486632e-02f, -2.85681728e-02f, -3.42423916e-02f,
  -1.89440197e-03f, -1.98234022e-02f, -3.58556658e-02f, -5.75311854e-02f, -3.81153598e-02f, -6.98184893e-02f, 4.36932780e-02f, -2.84676198e-02f, -1.93119794e-02f, 6.33584112e-02f,
  1.05851583e-01f, 2.56580144e-01f, -1.11614345e-02f, -1.02492757e-01f, 6.83496520e-03f, -1.30671803e-02f, 1.59482602e-02f, 8.80243331e-02f, 1.28341123e-01f, 1.01654761e-01f,
  1.15003623e-03f, 3.80662531e-02f, -1.53190196e-02f, 5.29155172e-02f, -5.61300069e-02f, 1.07069768e-01f, 9.87997204e-02f, 2.07463987e-02f, -3.97894531e-02f, 4.55227271e-02f,
  5.86327445e-03f, 2.70019509e-02f, -5.58848754e-02f, 1.69303771e-02f, 5.67793362e-02f, 8.15153867e-03f, -5.94291054e-02f, -9.16383415e-02f, -2.85855308e-02f, -4.32401486e-02f,
  -1.26760706e-01f, 1.80179417e-01f, 7.01190680e-02f, -6.01847582e-02f, 7.64921755e-02f, -1.39916778e-01f, -5.14688343e-02f, 6.50149807e-02f, -5.87613024e-02f, 1.58328027e-01f,
  1.28878713e-01f, 1.76622719e-02f, 1.29799873e-01f, 5.29164262e-02f, -2.06745103e-01f, -3.61600891e-02f, -7.84805939e-02f, -6.39747456e-02f, 4.95658182e-02f, 5.73150180e-02f,
  -5.91672324e-02f, 5.68636879e-02f, -3.14898752e-02f, 1.38016358e-01f, 5.22517338e-02f, 8.19925591e-03f, 4.55802120e-02f, 8.52724537e-02f, -6.17825463e-02f, -1.33862533e-02f,
  -2.47432906e-02f, -6.17826283e-02f, 6.51604757e-02f, -1.12958565e-01f, -6.93896636e-02f, 2.93196030e-02f, -1.50520764e-02f, -3.13485526e-02f, -2.90563852e-02f, 3.78782265e-02f,
  5.63154370e-02f, -6.62864745e-02f, 7.56306723e-02f, 4.04743515e-02f, -7.89005384e-02f, 8.26420411e-02f, -1.20280059e-02f, 4.88102883e-02f, 3.74458581e-02f, 5.34515157e-02f,
  1.89423170e-02f, -8.75512809e-02f, -8.76036882e-02f, 5.23004099e-04f, 2.56742705e-02f, 2.19003912e-02f, -6.83871135e-02f, -5.25128208e-02f, -2.55975891e-02f, 6.10231049e-02f,
  2.31209043e-02f, 4.30255532e-02f, 4.14963923e-02f, -1.70082264e-02f, 7.30211064e-02f, 7.63702467e-02f, 5.26763275e-02f, -8.60515311e-02f, 5.15820570e-02f, 1.64547116e-02f,
  1.89569965e-02f, 7.98171459e-05f, 9.38856006e-02f, 5.00095598e-02f, -4.93808649e-03f, 4.12385073e-03f, -7.47940987e-02f, 3.39393057e-02f, -4.42896053e-05f, 5.92214130e-02f,
  2.08186656e-02f, 5.18944785e-02f, -1.48032978e-02f, 3.08484659e-02f, -8.32437649e-02f, -6.78582340e-02f, 3.45909037e-02f, -5.04173897e-03f, 5.94092123e-02f, 1.56896822e-02f,
  4.34497297e-02f, 5.29517829e-02f, 7.23734051e-02f, -6.39765114e-02f, -4.27383147e-02f, 1.73022784e-02f, -7.45900199e-02f, 8.42206851e-02f, -8.36688355e-02f, -8.62705037e-02f,
  -9.84286591e-02f, -9.01650637e-02f, -4.78007011e-02f, 8.74001607e-02f, 5.26790507e-02f, 8.95091053e-03f, -3.89408767e-02f, 6.61004409e-02f, 1.48816565e-02f, -1.71726812e-02f,
  1.01854466e-01f, 9.37873647e-02f, -9.85733345e-02f, 4.61482890e-02f, 2.48074718e-02f, 4.46274169e-02f, 1.79579724e-02f, -5.43458983e-02f, -1.73479598e-02f, 1.61414817e-02f,
  1.50753647e-01f, -2.87150472e-01f, -5.51289953e-02f, 2.38612980e-01f, 1.53713956e-01f, -7.22520649e-02f, -1.54778749e-01f, 1.29557967e-01f, 2.79197078e-02f, -1.70094699e-01f,
  -5.26578687e-02f, -6.44810051e-02f, -2.76784122e-01f, 5.65202422e-02f, 8.84366557e-02f, -2.03025892e-01f, 3.45103703e-02f, 1.06372945e-02f, -5.76150045e-02f, 1.44684091e-01f,
  2.09914416e-01f, 2.08766356e-01f, -2.05727369e-02f, 1.34448916e-01f, 1.59767166e-01f, 1.22988410e-01f, 2.41840199e-01f, -2.70826090e-03f, 1.05610095e-01f, 5.66787347e-02f,
  -9.66293365e-02f, 9.31818858e-02f, 1.69701688e-02f, -1.09172225e-01f, 8.55932087e-02f, 6.20423965e-02f, -6.37884662e-02f, -3.09491232e-02f, 6.92804605e-02f, -1.10740215e-02f,
  -8.05855691e-02f, -6.20963573e-02f, 1.68975804e-03f, -3.66358347e-02f, 9.92056057e-02f, 8.34760964e-02f, 7.39502385e-02f, -9.08266660e-03f, -4.07655276e-02f, -7.26769194e-02f,
  8.67334604e-02f, -9.70462263e-02f, 1.24653280e-02f, -1.41773745e-02f, 7.88542554e-02f, 2.92529527e-04f, 7.27670416e-02f, 2.95690186e-02f, 6.40433142e-03f, 9.53167304e-02f,
  3.71870473e-02f, -1.95094328e-02f, -2.59220582e-02f, 1.66772362e-02f, 1.55759864e-02f, -4.21800241e-02f, -5.66364601e-02f, 2.87778378e-02f, 9.09756217e-03f, 1.44605096e-02f,
  -3.36496271e-02f, -3.31997834e-02f, 5.14734946e-02f, 4.06353623e-02f, 4.42119595e-03f, -5.23922667e-02f, 5.02776653e-02f, -3.96125950e-02f, 1.05991773e-01f, 4.43157032e-02f,
  -7.42593110e-02f, 7.17399865e-02f, -8.54466856e-02f, -7.34093562e-02f, -6.60939440e-02f, -6.67756423e-02f, 5.73043339e-02f, 3.11200097e-02f, 8.25058296e-02f, -7.08994176e-03f,
  -4.71148193e-02f, -4.18467559e-02f, -1.06552346e-02f, -9.55796801e-03f, 6.56512529e-02f, 2.17167959e-02f, -2.17026821e-03f, -6.53214529e-02f, -7.89297223e-02f, 2.45360211e-02f,
  -2.17046682e-02f, 1.11941043e-02f, -6.12128712e-02f, -6.45625889e-02f, -3.86070972e-03f, -2.63099428e-02f, -4.67950031e-02f, -1.90891009e-02f, 9.76115316e-02f, 1.05321422e-01f,
  1.48222391e-02f, -2.69494131e-02f, 4.10521962e-02f, 1.09598987e-01f, 6.72533885e-02f, 1.13060302e-03f, -8.95444956e-03f, 8.30456689e-02f, -4.25315872e-02f, -1.07851485e-03f,
  -3.80703926e-01f, 2.42443487e-01f, -5.77328391e-02f, -1.29412040e-01f, -1.72060709e-02f, -4.36885282e-02f, -6.57149851e-02f, 7.25574791e-02f, -3.45047154e-02f, 2.44812161e-01f,
  1.97111353e-01f, -5.93906604e-02f, 8.47216323e-02f, 1.60983607e-01f, -3.24504584e-01f, 1.13405928e-01f, -4.92012734e-03f, -2.72520073e-03f, -1.09204583e-01f, 6.38793111e-02f,
  -1.69344813e-01f, 5.80003262e-02f, -2.80446541e-02f, 1.68356910e-01f, 4.53780107e-02f, -1.51455160e-02f, 5.49716316e-02f, 6.80709537e-03f, 3.10689844e-02f, -6.60476610e-02f,
  -5.15442528e-02f, 2.08226871e-02f, -4.91583608e-02f, 2.87372768e-02f, -1.02759615e-01f, -2.56386846e-02f, -4.76520285e-02f, -6.08818717e-02f, 4.27058861e-02f, -7.68430680e-02f,
  -7.84920231e-02f, 7.41447369e-03f, 9.21563338e-03f, -6.22800551e-02f, 8.49997327e-02f, 4.29410264e-02f, 3.63280326e-02f, -8.17876682e-02f, 1.83107760e-02f, -5.95889390e-02f,
  -2.03325674e-02f, 6.01714887e-02f, -1.12904105e-02f, -2.21182052e-02f, -1.21647522e-01f, -4.89620492e-02f, -3.10879368e-02f, 2.66740490e-02f, -1.07551133e-02f, 1.69879431e-03f,
  5.84777966e-02f, 5.65967001e-02f, -4.34020162e-02f, -3.60736214e-02f, 6.05123155e-02f, 1.29312777e-03f, 6.16696663e-02f, 3.62727940e-02f, -8.20285678e-02f, -1.89188924e-02f,
  -6.66251481e-02f, -5.67503162e-02f, 2.60711070e-02f, -3.51120383e-02f, -8.05035532e-02f, 4.78644893e-02f, -6.80379197e-03f, -5.05106263e-02f, 3.85755859e-02f, 4.03927919e-03f,
  5.30129336e-02f, 4.43450734e-02f, 3.60693745e-02f, -1.36578735e-02f, 7.61880428e-02f, -4.87749614e-02f, -3.39847654e-02f, 5.02641350e-02f, 1.48712331e-02f, 4.20947513e-03f,
  -1.19106151e-01f, -9.49035361e-02f, -9.18126330e-02f, 1.90215521e-02f, -2.83604786e-02f, -9.32068527e-02f, -4.52979244e-02f, -3.78682539e-02f, -1.12460293e-01f, 1.92159135e-02f,
  -5.73126115e-02f, 6.71148077e-02f, -1.31994216e-02f, 6.25951365e-02f, -8.85561258e-02f, -3.04988828e-02f, -6.52285665e-02f, -8.36744383e-02f, 4.55442704e-02f, -2.52616405e-02f,
  -3.72280739e-02f, 3.76366377e-02f, 1.73788462e-02f, 3.36325206e-02f, 5.43644167e-02f, -7.56838620e-02f, 6.31357878e-02f, -5.59741929e-02f, -9.60212275e-02f, -1.93498936e-02f,
  2.17745438e-01f, 1.89061284e-01f, 4.26034518e-02f, 2.09456354e-01f, 1.32062053e-02f, 4.21301574e-02f, 8.69059935e-02f, 6.84839562e-02f, 3.00426126e-01f, 4.44838330e-02f,
  -1.52620986e-01f, 2.77864933e-01f, -9.03579742e-02f, 9.77507979e-03f, -1.84375572e-03f, -2.89767999e-02f, 9.58089978e-02f, 6.00473247e-02f, 3.78176272e-02f, 1.26754165e-01f,
  2.21884623e-03f, 2.95667462e-02f, -1.71674967e-01f, -1.36006221e-01f, 5.16700968e-02f, 8.44941139e-02f, -1.83416322e-01f, -1.84099033e-01f, 3.83631550e-02f, -5.43426350e-02f,
  -1.23139303e-02f, 1.23418821e-02f, 1.32962316e-02f, 9.92912427e-02f, -7.76553452e-02f, 6.28091916e-02f, -7.56216422e-02f, -3.95231822e-04f, 2.32634060e-02f, 5.30906096e-02f,
  1.34765999e-02f, -4.97957245e-02f, 1.00226551e-01f, 8.18942674e-03f, 1.32466301e-01f, 4.24250402e-02f, -2.74940822e-02f, 4.80791926e-02f, -2.90390234e-02f, -4.67334911e-02f,
  2.36546118e-02f, -4.25181240e-02f, 5.67185581e-02f, 8.54440257e-02f, -6.34527281e-02f, -3.37287970e-02f, 3.39169018e-02f, 7.75643364e-02f, -2.63802800e-02f, 1.03390418e-01f,
  3.19180600e-02f, 1.59650184e-02f, 2.37475317e-02f, -1.46029529e-03f, -7.86507875e-02f, -8.91765580e-02f, -6.20456822e-02f, -7.91527852e-02f, 1.33997621e-02f, 4.34053615e-02f,
  -4.58433889e-02f, 5.97111061e-02f, -5.44910207e-02f, -2.70524230e-02f, 6.44501597e-02f, 9.32474956e-02f, 1.67028531e-02f, -4.20879722e-02f, 6.77819178e-02f, 5.05879102e-03f,
  1.74422506e-02f, 3.57689485e-02f, -1.91153232e-02f, 1.06804436e-02f, 4.95332293e-02f, -2.64342166e-02f, 7.55345523e-02f, -3.67734209e-03f, -1.91322435e-02f, -8.94693360e-02f,
  4.47178222e-02f, 1.83226272e-01f, 9.67199281e-02f, 4.84348573e-02f, 8.78456011e-02f, -3.77514847e-02f, -4.60876524e-02f, 5.07794470e-02f, 5.05435914e-02f, 9.03425813e-02f,
  -4.60838042e-02f, -6.51175082e-02f, 8.07149336e-02f, -7.47426897e-02f, -9.06340927e-02f, 2.79256441e-02f, -6.17277212e-02f, -2.99958307e-02f, -5.92410602e-02f, -3.65081653e-02f,
  7.96499997e-02f, -3.94755788e-02f, 6.03102483e-02f, -1.85442884e-02f, 3.63984108e-02f, 4.94017303e-02f, 7.89948273e-03f, 5.45851551e-02f, 2.93235946e-02f, -8.73595104e-02f,
  -1.56546757e-02f, 5.46958856e-02f, -7.70407915e-02f, -2.54491508e-01f, -5.17692789e-03f, 6.06337935e-02f, -1.15414344e-01f, 6.70472831e-02f, -1.79747328e-01f, 6.64675236e-02f,
  2.92995665e-02f, -8.40871781e-02f, 5.34912087e-02f, -1.91008940e-01f, -3.64036351e-01f, -1.85612157e-01f, -1.73652634e-01f, -6.90414831e-02f, -7.33168572e-02f, 7.12748468e-02f,
  -9.53297690e-02f, -1.27997950e-01f, -4.59038317e-02f, 2.96767224e-02f, -6.60681874e-02f, 1.36541650e-01f, 9.87292305e-02f, 1.57367721e-01f, 3.44147161e-02f, -5.42677641e-02f,
  3.20472680e-02f, 1.50525188e-02f, 6.55840412e-02f, 6.73406050e-02f, -5.40166162e-03f, 1.54609516e-01f, 9.69565660e-03f, -6.66963533e-02f, -3.17866937e-03f, 5.05898334e-02f,
  6.57145381e-02f, 3.38689424e-02f, 1.58394091e-02f, -2.21232269e-02f, -4.37324718e-02f, 8.76078755e-02f, 6.91555962e-02f, -9.22058225e-02f, -3.99908163e-02f, -1.81460176e-02f,
  5.66922761e-02f, 2.60027330e-02f, -7.06751645e-02f, 1.00003707e-03f, -9.98606384e-02f, -5.18511869e-02f, 3.54635604e-02f, -3.57430801e-02f, 3.52057256e-02f, -4.53879964e-03f,
  3.39802098e-03f, -4.42433991e-02f, 6.71987608e-02f, -5.83698787e-02f, 1.97335146e-03f, 6.93932548e-02f, -9.57615823e-02f, -2.18971334e-02f, 2.63996329e-02f, 2.69360072e-03f,
  6.65253215e-03f, 3.57290357e-03f, 3.35880183e-02f, -6.13470115e-02f, 2.33262256e-02f, 4.79771420e-02f, 1.69571210e-02f, 3.26864645e-02f, -3.17880288e-02f, -7.55387843e-02f,
  7.18881488e-02f, -8.43699574e-02f, 6.43656552e-02f, -3.55579033e-02f, 8.80154141e-04f, -7.21090212e-02f, -4.18146327e-02f, 9.07604918e-02f, -9.02981088e-02f, 2.59951651e-02f,
  1.66350864e-02f, 1.00876890e-01f, -7.65025094e-02f, 3.03547401e-02f, -3.10489628e-03f, 6.60571828e-02f, -5.59973856e-03f, 5.11453375e-02f, -7.25934729e-02f, -2.32784096e-02f,
  8.98266286e-02f, -8.03252608e-02f, -4.82460819e-02f, -8.09221864e-02f, -4.60995845e-02f, -5.88459969e-02f, 1.70214362e-02f, -9.08120200e-02f, 1.04594242e-03f, 5.09230047e-03f,
  6.69653574e-03f, -2.44249776e-02f, -2.52911244e-02f, 7.42396864e-04f, -6.64314302e-03f, 2.34314776e-03f, -9.46173444e-03f, 8.46592709e-02f, 1.76832627e-03f, -2.75226701e-02f,
  -5.77800013e-02f, 2.59878635e-01f, 7.64342248e-02f, -7.15000108e-02f, -1.69180274e-01f, -7.89707750e-02f, -1.34074483e-02f, 3.21126767e-02f, 2.65817523e-01f, 1.67715192e-01f,
  -1.66885406e-01f, 2.25738347e-01f, 7.81225637e-02f, 5.48918471e-02f, -2.01772183e-01f, 7.48653114e-02f, 5.20287156e-02f, 6.70793653e-02f, 5.26325442e-02f, -1.45930322e-02f,
  -4.05005030e-02f, -3.79127488e-02f, -7.36611336e-02f, -1.50994778e-01f, -1.67554036e-01f, 6.95333481e-02f, -1.94783092e-01f, 3.88490558e-02f, -4.33833785e-02f, -6.73358515e-02f,
  2.64019761e-02f, 1.45352453e-01f, 5.09275533e-02f, 1.51718944e-01f, 2.59244647e-02f, -1.25707239e-01f, 1.03628226e-01f, -6.15202002e-02f, 6.50846362e-02f, 4.46503460e-02f,
  -2.30739918e-02f, 8.52216035e-02f, 3.70071642e-02f, -6.23962246e-02f, 1.15968492e-02f, 6.55312315e-02f, 2.65521090e-02f, -4.46549580e-02f, -2.78984383e-02f, -8.25931970e-03f,
  -5.87519817e-02f, 4.66581099e-02f, -1.02131613e-01f, 1.17846563e-01f, 5.25034219e-02f, 2.31749322e-02f, 5.11646904e-02f, 1.49124097e-02f, -8.20661038e-02f, 2.67185774e-02f,
  -3.40061560e-02f, 2.35391427e-02f, 2.43995301e-02f, -1.83979720e-02f, -5.03164530e-02f, 9.48837474e-02f, -1.39221037e-02f, -1.39250216e-04f, -2.70194896e-02f, -2.45166142e-02f,
  9.24787074e-02f, -1.80195179e-02f, -3.59230749e-02f, -8.04453194e-02f, -2.54840590e-02f, -3.72713171e-02f, -9.53823701e-02f, 5.17443977e-02f, 4.00404744e-02f, 1.35470205e-03f,
  6.75766692e-02f, 4.14176993e-02f, -4.33085449e-02f, 1.20461369e-02f, -3.81623246e-02f, -5.25453947e-02f, -1.66200511e-02f, 4.86966036e-02f, 2.06931904e-02f, -5.47377467e-02f,
  1.31360386e-02f, 1.99091226e-01f, -1.89227257e-02f, 1.03068903e-01f, 1.04708411e-01f, -1.52153755e-02f, 1.01941428e-03f, 2.20326688e-02f, 7.78545290e-02f, 3.42836082e-02f,
  -6.71422258e-02f, 5.00261560e-02f, -7.61362836e-02f, 5.08462451e-02f, 7.42565095e-02f, -2.73379534e-02f, -1.24626374e-02f, 7.19021633e-02f, 6.78060949e-02f, -7.93472975e-02f,
  -1.38997473e-02f, -5.04487567e-02f, -5.25128990e-02f, 2.05794964e-02f, 5.41210026e-02f, -4.32772115e-02f, -7.19057098e-02f, -6.02707490e-02f, -3.70253585e-02f, 2.97926385e-02f,
  -2.78072059e-02f, -1.37073532e-01f, 1.52197983e-02f, -8.24497119e-02f, 1.02774359e-01f, 1.87886462e-01f, 1.80266857e-01f, -1.24343418e-01f, -2.47228190e-01f, -2.66924724e-02f,
  1.27490357e-01f, -1.73202169e-03f, 6.28822995e-03f, 2.60393042e-02f, 1.66758522e-01f, -5.97352386e-02f, -5.96468896e-02f, 5.70904799e-02f, 1.40436115e-02f, -2.76142024e-02f,
  7.45790824e-02f, 3.37448679e-02f, -7.14868605e-02f, -3.02062798e-02f, 7.43699595e-02f, -7.83966184e-02f, 1.80218145e-01f, 8.13005492e-02f, 1.17479332e-01f, 1.64363161e-01f,
  6.58415258e-02f, 3.25474404e-02f, -4.36785035e-02f, -1.11395299e-01f, 5.62579604e-03f, 1.25952408e-01f, 4.51633744e-02f, 1.33537337e-01f, -4.60319966e-02f, 5.68961687e-02f,
  9.94332880e-02f, 4.87488545e-02f, 2.56958883e-02f, 8.86389464e-02f, -7.96127245e-02f, -2.76505463e-02f, -1.95160359e-02f, -1.10657342e-01f, 4.86433320e-02f, -5.02336696e-02f,
  -9.06799659e-02f, -3.76248062e-02f, 2.55273934e-02f, -3.49096172e-02f, -4.93344367e-02f, -1.04570411e-01f, -3.76660042e-02f, 9.48863104e-02f, 6.12076446e-02f, 1.62100680e-02f,
  -7.38273608e-03f, -1.49654578e-02f, 1.01496838e-01f, 6.83732703e-02f, -5.55217601e-02f, 3.83667974e-03f, 2.33565122e-02f, 8.56025517e-02f, -2.96707861e-02f, 6.25738082e-03f,
  -9.76386964e-02f, 5.17418683e-02f, 5.91078214e-02f, -8.86912867e-02f, 1.85146928e-02f, -9.79686826e-02f, 8.84490088e-02f, -8.50675069e-03f, 4.12327386e-02f, 4.23353538e-02f,
  -4.99777570e-02f, 7.69400969e-02f, 2.87182964e-02f, -9.30155888e-02f, 8.37775040e-03f, -6.69744089e-02f, 6.96840286e-02f, -3.94752361e-02f, -1.08117014e-01f, -3.52705456e-02f,
  -3.12562436e-02f, 3.78607139e-02f, 4.99946922e-02f, 9.18993828e-05f, 6.61533000e-03f, 1.09542109e-01f, -5.44951335e-02f, 5.26347868e-02f, 1.11264633e-02f, -1.02974521e-02f,
  -3.78877223e-02f, -7.56933764e-02f, 6.87770993e-02f, -5.91133274e-02f, 2.69137397e-02f, -2.97128092e-02f, -5.90617545e-02f, -1.05546035e-01f, -5.61146475e-02f, -5.56024238e-02f,
  1.41107263e-02f, -3.63685116e-02f, 7.18840882e-02f, -2.17373054e-02f, 7.33399913e-02f, 2.26573693e-03f, 5.26534170e-02f, 6.42357692e-02f, -3.63358594e-02f, -2.49364544e-02f,
  1.01687551e-01f, -1.87840149e-01f, 1.10696301e-01f, 1.46007985e-01f, -2.96882950e-02f, -7.25376830e-02f, 1.37200341e-01f, 1.46622071e-02f, -3.83228436e-03f, -1.69820175e-01f,
  8.27855151e-03f, -1.46146700e-01f, -3.33837904e-02f, 1.20271184e-01f, 2.18997940e-01f, 8.70152190e-02f, 5.88460416e-02f, -6.47311285e-02f, -4.19802172e-03f, 4.42027673e-03f,
  1.34474963e-01f, -2.78899688e-02f, 1.15698330e-01f, -7.14720264e-02f, 1.00320727e-01f, -1.03653800e-02f, -4.73472141e-02f, 4.92941365e-02f, -4.48752679e-02f, 7.76388273e-02f,
  3.59299220e-02f, 4.16653715e-02f, -2.75538526e-02f, -2.78274231e-02f, 2.02228371e-02f, 7.85296857e-02f, 1.04566505e-02f, -1.69520006e-02f, 1.12389475e-01f, 4.20284830e-02f,
  6.42774925e-02f, -4.47831191e-02f, 2.44907029e-02f, -4.25774120e-02f, 2.39943434e-02f, -8.62434506e-03f, -3.73426941e-04f, -7.35110492e-02f, 7.15508312e-02f, -1.03917912e-01f,
  6.87358305e-02f, -7.98123144e-03f, 5.25035970e-02f, -7.12238550e-02f, 2.14788504e-02f, 2.50196699e-02f, -5.21963090e-02f, 3.55132967e-02f, 5.04596680e-02f, -4.29826491e-02f,
  -7.26308376e-02f, -3.23856063e-02f, 7.00067729e-02f, 1.09799258e-01f, -3.29578258e-02f, 2.36580465e-02f, 7.03379959e-02f, -1.84438727e-03f, 2.97472924e-02f, -6.46706438e-03f,
  3.52358408e-02f, -5.40093072e-02f, -2.61184806e-03f, -8.25963095e-02f, -3.62814851e-02f, 2.85791028e-02f, 3.01132519e-02f, 2.95959357e-02f, 9.66987163e-02f, -4.19512531e-03f,
  -8.15302040e-03f, 5.19083217e-02f, 6.50546178e-02f, -2.06461827e-05f, 1.23292096e-02f, 4.40564053e-03f, -3.87277529e-02f, 2.05865223e-02f, 8.96714777e-02f, 4.10038717e-02f,
  2.99931075e-02f, -6.11140169e-02f, 2.62735710e-02f, -2.48936359e-02f, -7.44199241e-03f, 7.63242831e-03f, 1.89623646e-02f, 7.18298880e-03f, 1.41091598e-02f, -3.36357467e-02f,
  -8.68687332e-02f, 6.39391616e-02f, 3.62095088e-02f, -5.63490801e-02f, 6.04181886e-02f, -6.95966855e-02f, 4.71299216e-02f, -7.58615732e-02f, 4.90150414e-02f, -5.82080595e-02f,
  -5.40184155e-02f, -1.04992375e-01f, 5.09774610e-02f, 8.31875801e-02f, -1.17109388e-01f, 2.35178266e-02f, -4.01291102e-02f, -8.27657282e-02f, -3.82796749e-02f, 2.37047765e-02f,
  1.12673059e-01f, 9.40631405e-02f, 5.30138984e-02f, 1.38398232e-02f, -7.25724474e-02f, -1.09167591e-01f, -1.17436789e-01f, -8.90457481e-02f, 1.32630989e-01f, -4.01944406e-02f,
  -2.41633393e-02f, 1.03565931e-01f, -4.22380455e-02f, -7.92899281e-02f, -5.37302494e-02f, -5.68528064e-02f, -8.73837247e-02f, 3.69206257e-02f, 1.00796402e-01f, 2.00575199e-02f,
  -6.45550862e-02f, -1.92796290e-01f, 9.76269916e-02f, -4.24734317e-02f, -6.44994527e-02f, 1.39646810e-02f, -1.16752498e-01f, 5.90020716e-02f, -6.73748329e-02f, -7.45752826e-02f,
  -2.36126166e-02f, 5.32748997e-02f, -6.17268831e-02f, -7.79473782e-02f, -6.24845363e-02f, -4.45598699e-02f, 8.73167068e-02f, 6.35765344e-02f, -8.93537607e-03f, -5.79865016e-02f,
  8.90775621e-02f, -3.71605791e-02f, -4.64237779e-02f, -9.03943274e-03f, 1.30011467e-02f, 9.06033218e-02f, 7.14347512e-02f, -2.95013003e-02f, -1.95355210e-02f, 4.90215346e-02f,
  1.51990512e-02f, 8.69575739e-02f, 9.37672406e-02f, 6.65608272e-02f, 8.69358405e-02f, -4.15176451e-02f, 2.30446365e-02f, -2.69430783e-02f, 7.51548037e-02f, -5.08653447e-02f,
  8.89267493e-03f, -5.41090108e-02f, -5.42508326e-02f, 2.60389764e-02f, -7.25461170e-02f, -4.64357100e-02f, -7.80554935e-02f, -1.66110173e-02f, 7.51408190e-02f, 2.45614704e-02f,
  -5.96857667e-02f, -3.13713998e-02f, -4.22734581e-02f, -3.84775661e-02f, 1.22054173e-02f, 2.13435814e-02f, 8.49612802e-02f, 1.14255184e-02f, 7.67882094e-02f, -8.29532892e-02f,
  4.40640142e-03f, -7.50722364e-02f, -3.50805582e-03f, -1.33714676e-02f, 4.61730994e-02f, -7.66132846e-02f, -9.99281276e-03f, -4.80720624e-02f, 6.42222315e-02f, -8.00079256e-02f,
  -9.96370539e-02f, -7.54548609e-02f, 8.42474476e-02f, 1.16472663e-02f, -1.24051087e-02f, 5.99383526e-02f, -6.34935126e-02f, 1.53055601e-02f, -7.12766349e-02f, -8.89733210e-02f,
  -4.25937586e-02f, 4.75609116e-02f, 5.80746569e-02f, -1.60646606e-02f, 3.86662781e-02f, -6.16414435e-02f, -4.26803976e-02f, -5.41987654e-04f, -4.99136895e-02f, 1.72351617e-02f,
  -5.49741499e-02f, 7.60661513e-02f, -8.27227458e-02f, 1.69832055e-02f, 5.65842092e-02f, 2.53263693e-02f, -2.23040711e-02f, 1.08889602e-01f, -7.85622224e-02f, -6.82652518e-02f,
  -3.86066958e-02f, -5.67650720e-02f, 9.88580287e-02f, -1.08109221e-01f, 1.20376609e-02f, 8.07099342e-02f, 1.62709221e-01f, -2.40753721e-02f, 6.19004369e-02f, 1.60859991e-02f,
  -8.91117528e-02f, -1.58404484e-02f, 1.22770250e-01f, -9.73275304e-02f, 2.32487962e-01f, 1.27094463e-01f, 4.14916985e-02f, 5.75643331e-02f, -7.63490126e-02f, -4.80543636e-02f,
  -1.46671981e-02f, -1.97150305e-01f, -3.02112792e-02f, -1.70499757e-01f, -1.76307708e-01f, -5.33334836e-02f, -9.57074463e-02f, 6.60129711e-02f, -8.50252733e-02f, -4.71175835e-02f,
  -1.55572459e-01f, -4.66805436e-02f, -5.14628887e-02f, -8.24983269e-02f, 6.00537173e-02f, 2.72337385e-02f, 1.58680547e-02f, -2.91007534e-02f, -6.56703487e-02f, -3.29297446e-02f,
  -4.07759324e-02f, 5.65154245e-03f, -2.01277491e-02f, 1.56097040e-02f, -8.96795318e-02f, 6.96810409e-02f, -3.13606448e-02f, -2.18358468e-02f, -7.04390854e-02f, -5.22235408e-03f,
  6.20051026e-02f, -7.97922090e-02f, 4.03251201e-02f, 5.33322059e-02f, 4.91266064e-02f, 3.15920562e-02f, 2.49381680e-02f, 4.22858167e-04f, -5.67783304e-02f, -6.52756318e-02f,
  1.03868835e-01f, 7.47464076e-02f, 4.77670366e-03f, -2.24003419e-02f, -9.65354070e-02f, 3.99270803e-02f, 6.81144297e-02f, -3.63690071e-02f, -3.93179655e-02f, 5.33483922e-03f,
  -6.11705445e-02f, -4.40165624e-02f, 8.44571069e-02f, 8.47628117e-02f, -7.62953758e-02f, -1.41121838e-02f, -6.85680062e-02f, -7.55343214e-02f, 2.88651362e-02f, -5.05833402e-02f,
  1.14965253e-02f, -7.90086389e-02f, -9.62498412e-02f, 6.08154908e-02f, -5.27769551e-02f, -5.69248050e-02f, -1.07374415e-01f, 3.29434574e-02f, 6.49869218e-02f, 2.44658859e-03f,
  -1.62415177e-01f, -1.45517498e-01f, 1.64553188e-02f, -7.55526647e-02f, 3.76137346e-02f, -6.57644868e-02f, -4.70156893e-02f, -1.00975789e-01f, 6.10243157e-03f, -1.55354256e-03f,
  -2.09186692e-02f, -6.63826242e-02f, -7.76900128e-02f, 3.57425399e-02f, 1.00281462e-01f, -2.72086933e-02f, 1.79352071e-02f, -7.91299939e-02f, -2.49258857e-02f, -5.61643690e-02f,
  5.94236655e-04f, 1.88405961e-02f, -1.38960332e-02f, -9.67287458e-03f, 6.73765540e-02f, -2.15142705e-02f, -7.56191090e-02f, -6.06545135e-02f, -2.88624614e-02f, -5.87627925e-02f,
  1.49544358e-01f, 6.13602139e-02f, -1.25346512e-01f, 9.52568129e-02f, 1.08785992e-02f, 1.10715307e-01f, 4.41517979e-02f, 6.76982626e-02f, 1.58897445e-01f, 1.08283602e-01f,
  1.29064582e-02f, 1.28340840e-01f, -1.74236912e-02f, 1.90379381e-01f, 9.32874531e-03f, -1.62391993e-03f, 1.38288110e-01f, 1.70363218e-01f, -8.80303755e-02f, 3.90424840e-02f,
  -4.99989316e-02f, 5.44056781e-02f, -2.12597847e-01f, 6.16411865e-03f, 1.24154821e-01f, -1.23069599e-01f, -1.51920110e-01f, -2.05522344e-01f, -1.84775088e-02f, -2.42915154e-02f,
  9.06205401e-02f, -9.33938026e-02f, -3.20456773e-02f, -4.17748131e-02f, 8.04160610e-02f, 8.41424614e-02f, 2.16254443e-02f, -6.32356107e-02f, -4.04073857e-02f, -7.32208416e-02f,
  -1.20926583e-02f, -4.59887423e-02f, -2.12291144e-02f, 2.96122096e-02f, 9.63601246e-02f, -5.80959655e-02f, -8.47406834e-02f, 3.69153265e-03f, -7.99709111e-02f, 7.38641992e-02f,
  -1.77952163e-02f, 6.09331354e-02f, 3.18841562e-02f, 4.90317978e-02f, 6.80206269e-02f, -7.01475665e-02f, 1.10187456e-02f, 1.83626171e-02f, 7.71082379e-03f, -4.70653065e-02f,
  9.70248058e-02f, -2.95202918e-02f, 1.18332561e-02f, 2.92621851e-02f, -2.94751283e-02f, -7.90783465e-02f, -5.42730018e-02f, -5.13547193e-03f, 7.72697106e-02f, -4.53564227e-02f,
  -6.56229481e-02f, 3.42357270e-02f, 2.96757389e-02f, 3.59365810e-03f, -3.11748572e-02f, 2.34867018e-02f, 2.39736121e-02f, 5.98860718e-02f, -7.56620988e-02f, -2.52867267e-02f,
  -8.05822760e-02f, 4.92138639e-02f, -8.56333598e-02f, -3.91692296e-02f, -7.92372674e-02f, -9.58647728e-02f, 3.13967206e-02f, 4.72709686e-02f, -3.43294851e-02f, 9.01706889e-03f,
  8.54123533e-02f, 1.57098532e-01f, -2.77121849e-02f, -4.96121794e-02f, 1.15199247e-02f, 1.05561554e-01f, 5.72092384e-02f, 3.47375162e-02f, 2.64175497e-02f, 2.69044172e-02f,
  -2.33680792e-02f, -7.48234093e-02f, 3.62689123e-02f, 1.08013554e-02f, -2.78566517e-02f, 6.47156537e-02f, 9.02286544e-02f, 8.31300840e-02f, 5.15526533e-02f, -5.34324422e-02f,
  -3.87989543e-02f, 6.62690625e-02f, 3.13572995e-02f, 5.23307510e-02f, 8.47708657e-02f, 1.04827940e-01f, 4.15701568e-02f, 1.41345933e-02f, 1.60979591e-02f, 7.65664726e-02f,
  2.39050630e-02f, 1.25287145e-01f, -3.86767499e-02f, -1.81654897e-02f, -1.94732264e-01f, -1.89600691e-01f, -1.96622178e-01f, 2.50134747e-02f, 1.86541621e-02f, 3.13330218e-02f,
  -6.77917749e-02f, 1.28351688e-01f, 5.80737852e-02f, -2.09847512e-03f, -6.14778660e-02f, 1.75274834e-01f, 4.35223803e-02f, 2.76279310e-03f, 1.14567205e-01f, -6.53567910e-02f,
  -2.12831069e-02f, 8.52397585e-04f, -2.89578661e-02f, 1.51659744e-02f, -9.85028967e-02f, -5.94319403e-02f, 9.85283479e-02f, -7.04044774e-02f, 3.77718471e-02f, -9.05063674e-02f,
  1.14695132e-02f, 5.07086553e-02f, 9.79335047e-03f, 8.96519199e-02f, -1.73076906e-03f, -1.00388199e-01f, -9.95854437e-02f, -8.78954977e-02f, -6.74415678e-02f, -5.85008562e-02f,
  8.47948343e-02f, -2.05917489e-02f, -1.16721401e-02f, -2.24409495e-02f, -3.95441912e-02f, 9.01197568e-02f, -3.58232297e-02f, 5.22562377e-02f, -2.38815751e-02f, 1.98662002e-02f,
  -2.12281067e-02f, -1.08577255e-02f, -1.14746485e-02f, 1.11075014e-01f, -2.57313084e-02f, 6.55697510e-02f, -2.38290671e-02f, 5.83912469e-02f, -2.08865013e-02f, 9.02060196e-02f,
  -6.07945211e-02f, 1.09465728e-02f, 2.87531130e-02f, 1.47941541e-02f, 8.17942545e-02f, 3.59093323e-02f, -1.71870477e-02f, -5.92032373e-02f, -4.26923968e-02f, 3.78065705e-02f,
  2.27574203e-02f, -6.88434392e-02f, -3.04020420e-02f, -4.58055735e-03f, 8.00014734e-02f, -5.75225763e-02f, -8.04361552e-02f, 6.40244856e-02f, 6.97423741e-02f, 5.86662553e-02f,
  5.59123345e-02f, -7.27611333e-02f, 5.06441221e-02f, 6.05311431e-02f, -2.24511549e-02f, 4.08371799e-02f, -1.17647769e-02f, -1.76070426e-02f, -7.83147737e-02f, 1.91181749e-02f,
  1.26867080e-02f, 4.97584268e-02f, 4.84559871e-02f, 5.91726378e-02f, -2.83388663e-02f, 6.57963902e-02f, 5.07634096e-02f, -5.28371297e-02f, 3.58953401e-02f, -8.02291036e-02f,
  7.04984143e-02f, 1.15169687e-02f, 2.03438383e-03f, 5.44602275e-02f, 7.33316243e-02f, -7.27418736e-02f, 6.41398430e-02f, 3.65874395e-02f, -6.49817809e-02f, 6.90085888e-02f,
  9.23005026e-03f, -7.54293948e-02f, -8.47028419e-02f, 6.74221218e-02f, -6.60182238e-02f, -4.80508506e-02f, -1.49989512e-03f, -5.03940098e-02f, 8.34414884e-02f, -1.01952087e-02f,
  -9.72170234e-02f, 2.48164535e-01f, 4.88095870e-03f, 5.11305854e-02f, 6.28134832e-02f, 8.95654112e-02f, 5.57913594e-02f, 8.29930678e-02f, 2.30332226e-01f, 1.00817055e-01f,
  1.49311917e-02f, -8.90227854e-02f, 3.26945409e-02f, 8.34001601e-02f, -1.30484238e-01f, 9.81661081e-02f, 4.70425524e-02f, -2.90045980e-02f, 1.06953934e-01f, -2.51294822e-02f,
  -4.63333614e-02f, -2.16852129e-02f, -1.38971627e-01f, 4.44140993e-02f, -1.26999363e-01f, -7.21970722e-02f, -2.02607021e-01f, -6.14386238e-02f, -1.70155853e-01f, -7.79161900e-02f,
  8.05732459e-02f, 4.44638766e-02f, -5.33657707e-02f, 2.94469707e-02f, 6.21304885e-02f, -1.19055219e-01f, 4.65727709e-02f, 4.11539748e-02f, 2.74781436e-02f, -1.66149251e-02f,
  -5.05389608e-02f, -2.37376243e-02f, -3.18581574e-02f, -6.92333579e-02f, 2.95241959e-02f, 5.73603250e-02f, -4.08508666e-02f, -1.38920383e-03f, -2.75892504e-02f, -3.30289304e-02f,
  -6.92593604e-02f, -3.78682837e-02f, 5.17980829e-02f, 1.03331193e-01f, 2.27645808e-03f, -5.25819771e-02f, -2.27427520e-02f, -5.71089908e-02f, -2.63601523e-02f, -5.09327166e-02f,
  -6.88275248e-02f, 7.91840181e-02f, 1.06586091e-01f, 9.57064033e-02f, 9.51937288e-02f, -3.67601998e-02f, -1.48672387e-02f, 5.00775967e-03f, -5.23888320e-02f, 6.80141710e-03f,
  -1.58245414e-02f, 4.70415950e-02f, 1.12417310e-01f, 2.34703515e-02f, 5.57569563e-02f, 7.54595026e-02f, -1.05471201e-01f, 1.81302521e-02f, -4.51144017e-02f, -8.26879665e-02f,
  -6.97226897e-02f, 1.65601987e-02f, 5.43544255e-03f, -2.64012218e-02f, 1.24827074e-02f, 4.90937904e-02f, 3.92484665e-03f, -9.56040472e-02f, 3.63192819e-02f, -8.50118846e-02f,
  1.36103377e-01f, 6.49670586e-02f, 1.00999810e-01f, 7.94504657e-02f, 9.66305733e-02f, -1.14430875e-01f, -2.43219752e-02f, -3.68230194e-02f, 5.81154041e-03f, -2.41680127e-02f,
  -9.52748209e-02f, -2.16372497e-02f, -4.96217832e-02f, -3.42137851e-02f, -5.99249005e-02f, 2.32415199e-02f, -3.06775104e-02f, 5.20959795e-02f, 7.38923624e-02f, -5.29924370e-02f,
  8.63513350e-03f, -2.51884703e-02f, -5.68259843e-02f, -1.46115217e-02f, 5.87210543e-02f, 2.45833434e-02f, 5.61704561e-02f, 8.15876052e-02f, -8.33306927e-03f, 7.67618194e-02f,
  -1.14907362e-01f, 1.80637687e-01f, 9.79962647e-02f, 4.69582267e-02f, -1.94676861e-01f, -1.26178592e-01f, -3.38287018e-02f, -9.68767852e-02f, 1.17456138e-01f, 1.90437958e-01f,
  -2.87480075e-02f, 1.62043005e-01f, 1.14883423e-01f, 4.87460308e-02f, -2.43834913e-01f, 2.73640156e-02f, -3.83026376e-02f, 6.43624812e-02f, 9.51769855e-03f, 5.34158871e-02f,
  -7.36362860e-02f, -1.30172491e-01f, 4.01702076e-02f, -1.21770926e-01f, 3.15461084e-02f, 1.72569994e-02f, -1.08626299e-01f, -5.06414101e-02f, 6.55566603e-02f, -1.00313812e-01f,
  -1.02367386e-01f, -8.63512903e-02f, 5.82450330e-02f, 9.78385191e-03f, -9.68320072e-02f, 2.68553328e-02f, 6.38662800e-02f, -8.45695883e-02f, 3.47472392e-02f, 7.13850930e-02f,
  -4.77038510e-02f, 1.24019962e-02f, 5.04456274e-02f, -2.57473588e-02f, 8.13212898e-03f, 6.69767186e-02f, -4.53650504e-02f, -3.49015072e-02f, 4.27055582e-02f, -9.68236774e-02f,
  1.01510465e-01f, 2.70726513e-02f, -3.12848738e-03f, 1.17184609e-01f, -9.02028829e-02f, -9.98988654e-03f, -6.84746355e-02f, -5.70023209e-02f, -8.10231194e-02f, -4.36073504e-02f,
  6.46853969e-02f, -5.07326387e-02f, -5.66132553e-02f, -3.52124944e-02f, -4.98092920e-02f, 6.68193325e-02f, -6.54816329e-02f, 1.30086141e-02f, -4.35342379e-02f, -1.08343258e-03f,
  -6.92401305e-02f, 7.37301409e-02f, -5.39348349e-02f, 9.60059557e-03f, -3.93354595e-02f, 1.13486879e-01f, 1.43763423e-02f, 2.46532056e-02f, 1.55126099e-02f, 3.11958045e-02f,
  4.32288535e-02f, -2.34415550e-02f, -5.50841503e-02f, -2.50805262e-02f, -7.85733834e-02f, 4.17446531e-02f, -4.37823534e-02f, -3.41165438e-02f, 5.40721370e-03f, -4.29590158e-02f,
  -1.36084437e-01f, -8.15416500e-02f, -6.74860105e-02f, 5.01320623e-02f, 8.78677592e-02f, -3.15085799e-03f, 2.92072687e-02f, -3.93907614e-02f, -6.50876760e-02f, 2.86516584e-02f,
  -6.56749401e-03f, 2.42607966e-02f, -2.87909675e-02f, 6.30635321e-02f, 6.23057447e-02f, 5.07419407e-02f, 1.55988270e-02f, 4.89400998e-02f, -3.74865904e-03f, -3.46550271e-02f,
  3.82496417e-02f, -4.95771579e-02f, 8.93770158e-02f, -4.49718200e-02f, 6.00626245e-02f, 2.53961701e-02f, 4.87004779e-02f, 6.11768924e-02f, -8.89983848e-02f, -1.82557441e-02f,
  3.76479961e-02f, 2.06606928e-02f, 1.10088415e-01f, 2.29967266e-01f, 4.37036939e-02f, -1.60646617e-01f, -8.68035182e-02f, -6.52541146e-02f, -5.50392903e-02f, -2.16727052e-03f,
  -5.69903702e-02f, 9.06750932e-02f, -4.81228642e-02f, -3.64261530e-02f, -1.82987884e-01f, -1.72338173e-01f, -1.28899813e-02f, -9.00851097e-03f, -3.34984949e-03f, -1.74961556e-02f,
  3.23630199e-02f, -1.54555708e-01f, -4.80954461e-02f, -1.26829743e-01f, 1.21350214e-01f, 9.47833285e-02f, 7.79889375e-02f, -7.26594916e-03f, 8.21004435e-02f, -9.52566322e-03f,
  6.52485564e-02f, 1.09976530e-02f, 7.87384212e-02f, -4.87706289e-02f, 5.65899126e-02f, 3.12242825e-02f, -3.50941084e-02f, -4.08956921e-03f, 3.76584269e-02f, 3.07187457e-02f,
  7.65208825e-02f, -1.44984974e-02f, 6.05206341e-02f, -3.81505378e-02f, 9.36718732e-02f, 4.42249328e-02f, -2.16799080e-02f, 4.40710485e-02f, -1.20369429e-02f, 3.63737829e-02f,
  6.01250418e-02f, -1.96089819e-02f, -2.89273895e-02f, 5.88991530e-02f, 2.02096235e-02f, 3.51568721e-02f, 2.88276207e-02f, -5.69643527e-02f, 7.58587494e-02f, -7.04583526e-02f,
  2.33021638e-04f, -1.44174201e-02f, 1.99893340e-02f, -6.21467046e-02f, -2.47568432e-02f, -5.81133775e-02f, 4.05730754e-02f, 2.47725714e-02f, 5.52132614e-02f, -7.35642835e-02f,
  6.67933375e-03f, 9.07060504e-02f, -8.31603259e-03f, -1.21105742e-02f, -3.11277118e-02f, -5.59428930e-02f, 7.18108416e-02f, -5.63250706e-02f, -6.41735941e-02f, 8.38906169e-02f,
  4.28968749e-04f, -2.31308769e-03f, -9.06870663e-02f, -5.73711954e-02f, 2.72106193e-02f, 7.65171945e-02f, 2.59655919e-02f, 2.49266997e-02f, 4.35140394e-02f, -2.24475260e-03f,
  9.79692861e-03f, -1.50409833e-01f, 4.71766368e-02f, 2.54617929e-02f, 4.23552655e-02f, -1.01253651e-01f, -4.79561202e-02f, -3.00989468e-02f, 5.86637929e-02f, -3.09113842e-02f,
  -4.23329398e-02f, 1.05657419e-02f, 6.18048646e-02f, 9.83257368e-02f, -5.38753383e-02f, -2.67443396e-02f, 1.44953933e-02f, 3.67095396e-02f, -3.54076102e-02f, -6.29833862e-02f,
  8.45907629e-02f, 5.90558723e-02f, 5.00597619e-02f, 2.12795902e-02f, -1.06113469e-02f, -2.96476521e-02f, -4.14112210e-02f, 7.94544443e-02f, 4.01117373e-03f, -5.11317886e-03f,
  8.71919915e-02f, 8.84325430e-02f, -1.13995180e-01f, -9.01425853e-02f, -1.62986830e-01f, -3.27981859e-02f, -3.61701138e-02f, -8.28327164e-02f, 1.06192574e-01f, 1.15182899e-01f,
  -1.42044380e-01f, 1.79578480e-03f, 6.66488782e-02f, -1.13970846e-01f, 9.55259427e-02f, 1.70603260e-01f, -5.88829704e-02f, 2.18277313e-02f, -6.24309257e-02f, -9.34628844e-02f,
  -5.58961257e-02f, -9.96132642e-02f, -1.14760689e-01f, -1.50714248e-01f, -1.33837163e-01f, -5.35146631e-02f, -5.13647869e-03f, -1.26630992e-01f, -9.48279873e-02f, -1.12524867e-01f,
  -8.05874243e-02f, -7.21653923e-02f, 1.70647400e-03f, -3.06916498e-02f, -3.09134759e-02f, 2.91312877e-02f, 3.83244120e-02f, 2.67529059e-02f, -2.21772976e-02f, -4.90871780e-02f,
  8.21980387e-02f, 5.74686611e-03f, -8.46083388e-02f, 7.60015100e-02f, -8.90160426e-02f, 5.31242788e-02f, 4.64012548e-02f, -9.28224716e-03f, 1.16297910e-02f, 3.12633775e-02f,
  -6.83529228e-02f, -5.70115121e-03f, -9.28050354e-02f, -1.41970832e-02f, 5.69560528e-02f, 1.13654258e-02f, -7.07323328e-02f, 1.02776699e-01f, 7.44740888e-02f, 9.81432050e-02f,
  -3.50610614e-02f, 5.27278632e-02f, 9.08664390e-02f, 5.93961403e-02f, -7.12687150e-02f, -5.95697016e-02f, -2.11173017e-02f, 4.19548042e-02f, -6.40846938e-02f, -4.86422144e-02f,
  -6.61155581e-02f, 6.41433522e-02f, -8.18499923e-02f, -6.94180503e-02f, -4.18199832e-03f, 1.00526191e-01f, 9.55526158e-02f, 3.29440348e-02f, 1.60571411e-02f, 7.48843551e-02f,
  4.36028242e-02f, 1.03251100e-01f, 4.08709049e-02f, -2.34474782e-02f, 6.88466728e-02f, 6.64971322e-02f, -5.38585931e-02f, 6.97181895e-02f, -9.25919637e-02f, 8.40144381e-02f,
  -5.17874323e-02f, -8.54326878e-03f, 1.00170895e-02f, 5.35501651e-02f, -2.52069663e-02f, 8.22982192e-02f, -9.11508035e-03f, 2.28324160e-02f, -4.48653474e-02f, -3.83799226e-04f,
  -2.81043276e-02f, -4.33981903e-02f, -1.18613364e-02f, -8.14899206e-02f, 7.06045628e-02f, 3.88226584e-02f, -2.92278919e-02f, -3.60873751e-02f, -7.34020472e-02f, -1.83898658e-02f,
  -4.13968600e-02f, 6.54171174e-03f, -2.36987621e-02f, 9.49990228e-02f, 8.47789049e-02f, 6.58062994e-02f, 8.10392126e-02f, 4.62280288e-02f, 2.44789058e-03f, 8.77029169e-03f,
  -1.07653856e-01f, 8.70227963e-02f, 3.28579471e-02f, -1.92586169e-01f, 8.38275477e-02f, -1.73377898e-02f, -7.32876407e-03f, 5.30846603e-02f, -4.44149897e-02f, 1.12159632e-01f,
  -6.08250638e-03f, 7.76624773e-03f, 8.19829628e-02f, -1.26430675e-01f, -3.53468835e-01f, 1.26427477e-02f, -1.98280826e-01f, -1.53365701e-01f, 3.63863911e-03f, -3.39913815e-02f,
  -8.74264315e-02f, -2.75191367e-02f, -9.80480760e-02f, 7.42037967e-03f, 6.70382306e-02f, 1.06405191e-01f, -2.86101121e-02f, 1.29183352e-01f, -6.69818148e-02f, 1.95232481e-02f,
  -8.50588232e-02f, -5.17656319e-02f, 1.57635119e-02f, -7.18778595e-02f, -2.79855877e-02f, -6.46604896e-02f, -7.01935887e-02f, -1.65189765e-02f, -8.14998969e-02f, -5.91955408e-02f,
  1.52718173e-02f, -4.94925724e-03f, -1.02837868e-02f, 3.06726266e-02f, 4.28567156e-02f, 6.84873164e-02f, -9.24246013e-03f, -1.65681336e-02f, -6.84014186e-02f, 3.06876618e-02f,
  -4.90638725e-02f, 1.46972865e-03f, 3.29609239e-03f, 2.50114761e-02f, 7.27852508e-02f, 3.52160372e-02f, 4.14972194e-02f, 2.66074091e-02f, -8.49596038e-02f, 4.67640422e-02f,
  -8.89791623e-02f, -3.73695558e-03f, -2.02159844e-02f, -6.40858561e-02f, 2.54158508e-02f, -3.22955474e-02f, 2.81478502e-02f, 3.57596925e-03f, -2.80930437e-02f, -7.12201670e-02f,
  -6.42572492e-02f, 2.92850994e-02f, 2.70351246e-02f, -7.77849630e-02f, 6.58206036e-03f, -3.28905359e-02f, 1.98074570e-03f, -6.10315204e-02f, 6.22374453e-02f, -3.93837579e-02f,
  7.28764292e-03f, -8.16657245e-02f, 2.52096746e-02f, -5.81891462e-02f, -1.43841270e-03f, 4.82636876e-03f, -1.54609131e-02f, 4.20764051e-02f, -4.91401739e-02f, -6.84678331e-02f,
  -1.61399283e-02f, -1.35921180e-01f, -2.93455756e-04f, -3.62740015e-03f, 8.72195978e-03f, -1.66716892e-03f, -3.40869017e-02f, 7.10758904e-04f, -4.14200909e-02f, -7.78956339e-02f,
  2.93748379e-02f, 8.08415636e-02f, -6.18602522e-02f, -5.59334531e-02f, 3.43215466e-02f, 2.01025177e-02f, -1.68847479e-02f, 7.97748752e-03f, -6.58273771e-02f, 1.18396692e-02f,
  2.18035039e-02f, 8.54991153e-02f, -1.80684701e-02f, -7.10141659e-02f, -8.03393126e-02f, -8.48784205e-03f, 4.35395800e-02f, -7.26843476e-02f, -9.36576128e-02f, 6.53671995e-02f,
  -1.56102180e-02f, -3.08000995e-03f, -6.72456101e-02f, 1.59118697e-01f, -5.15038446e-02f, -6.54475540e-02f, -1.63059365e-02f, -9.86507460e-02f, 1.02329187e-01f, -3.95177826e-02f,
  9.26930904e-02f, -8.14288408e-02f, 1.23406842e-01f, -6.88890219e-02f, 3.67077850e-02f, 1.92746893e-01f, -3.50151099e-02f, -8.54201242e-02f, 7.89182261e-02f, -3.81288938e-02f,
  1.88921597e-02f, -1.02334723e-01f, 2.32127383e-02f, -5.31484559e-02f, -1.10830113e-01f, 5.52963465e-02f, 3.58619653e-02f, -5.92900254e-02f, -1.46675572e-01f, -1.29579470e-01f,
  4.09038514e-02f, 5.29243425e-02f, 4.52943780e-02f, 2.43627690e-02f, 1.59260090e-02f, -8.13448057e-03f, -3.77982855e-02f, 7.09204078e-02f, 5.62076494e-02f, 6.76453859e-02f,
  -2.83099059e-02f, -2.58619897e-02f, 2.98259258e-02f, 5.81279397e-02f, -7.74158239e-02f, -8.47920105e-02f, -7.25497529e-02f, 2.14373227e-02f, -6.64886013e-02f, -6.89880699e-02f,
  8.12480003e-02f, 3.42310662e-03f, 6.33072779e-02f, -2.08743308e-02f, 2.75889374e-02f, 6.59044832e-02f, -7.82721937e-02f, -8.41319934e-02f, -1.43015198e-02f, -6.22659773e-02f,
  -9.98373628e-02f, 5.45846969e-02f, 9.34114233e-02f, -6.69729784e-02f, -4.03803922e-02f, 3.23828310e-02f, -6.45032804e-03f, -8.58192146e-02f, 3.85911725e-02f, 5.47959954e-02f,
  1.19831020e-04f, 3.79904695e-02f, -1.68970376e-02f, -3.52375284e-02f, -1.56465806e-02f, -8.76778886e-02f, 2.65742764e-02f, 2.91906390e-02f, 9.22384188e-02f, 3.53451772e-03f,
  -3.09932437e-02f, -6.37525544e-02f, -6.51588887e-02f, -4.38597548e-04f, -2.25155260e-02f, -5.15390821e-02f, -8.07544962e-02f, -5.40880067e-03f, -3.11746486e-02f, -4.32289615e-02f,
  -4.98880222e-02f, 2.58737453e-03f, -4.40726280e-02f, -7.50166699e-02f, 4.05928642e-02f, -8.50527361e-02f, 4.44180630e-02f, -4.12788354e-02f, 2.29448490e-02f, 2.75545567e-02f,
  -5.24175204e-02f, 5.21810586e-03f, 3.77667584e-02f, 1.78331006e-02f, -7.27872103e-02f, -7.03314021e-02f, 4.79179174e-02f, -4.28829901e-02f, -6.17946573e-02f, 5.95361404e-02f,
  -3.41996700e-02f, 2.51644775e-02f, 9.27098319e-02f, -2.91308500e-02f, 4.26895767e-02f, -6.72945613e-03f, -6.34422600e-02f, 5.65226190e-02f, -7.41670802e-02f, 2.36415882e-02f,
  1.13111911e-02f, 1.91234052e-02f, -1.25329778e-01f, -5.06738238e-02f, 7.78243318e-02f, 1.11896098e-01f, -3.73023897e-02f, -7.83955753e-02f, -7.75690377e-02f, 2.23125875e-01f,
  9.93333086e-02f, 8.68109763e-02f, -8.29223245e-02f, -4.64550219e-02f, -2.07245216e-01f, -1.58281505e-01f, 1.93775855e-02f, 9.30171087e-02f, -1.10723071e-01f, 1.06967121e-01f,
  -1.09585702e-01f, -3.75298969e-02f, -5.95598295e-02f, 5.24605922e-02f, 1.36346504e-01f, 1.55922979e-01f, 2.92535163e-02f, -1.08602196e-02f, 1.68746755e-01f, -1.18460342e-01f,
  2.65220720e-02f, -2.27739546e-03f, -4.27768156e-02f, 3.87541093e-02f, 7.91710243e-02f, 1.31374553e-01f, 1.07611619e-01f, -8.56857970e-02f, 3.84811796e-02f, 6.36904687e-02f,
  8.07892755e-02f, 4.23950851e-02f, -1.05794100e-02f, 1.45606967e-02f, 2.48654955e-03f, -6.67687282e-02f, -4.29844111e-02f, 6.62709400e-02f, 8.56761560e-02f, -5.86376265e-02f,
  -3.14846709e-02f, 2.83227414e-02f, -2.77211126e-02f, 2.20280979e-02f, -2.92194430e-02f, 4.27228622e-02f, 1.08006015e-01f, 1.47437174e-02f, -2.64047068e-02f, 8.47364366e-02f,
  8.18051025e-02f, 3.89085859e-02f, -5.74847050e-02f, -1.10379504e-02f, 7.48992264e-02f, -4.65705134e-02f, 2.83473115e-02f, -3.40639763e-02f, -2.58652344e-02f, -4.39986633e-03f,
  2.97097955e-03f, -6.65655434e-02f, -8.63146931e-02f, -4.64305002e-03f, 5.13076298e-02f, 4.47156355e-02f, 5.97330891e-02f, 9.29467678e-02f, 6.57153204e-02f, -5.97786978e-02f,
  -3.56177203e-02f, 4.26808670e-02f, 7.48820081e-02f, -4.93711643e-02f, -7.35752732e-02f, -3.63058634e-02f, 9.10770446e-02f, 6.33470416e-02f, -6.02342188e-02f, 7.05386773e-02f,
  1.08010218e-01f, 8.57881904e-02f, 4.78560515e-02f, -6.61394186e-03f, -2.30688229e-02f, 5.40940538e-02f, 9.04114395e-02f, 3.93573157e-02f, -7.51635656e-02f, 3.68460938e-02f,
  1.48887172e-01f, 8.70459378e-02f, -1.06875114e-02f, -1.43550895e-02f, -1.06088500e-02f, -1.70369577e-02f, 7.91426748e-03f, -5.08233979e-02f, 7.02116033e-03f, 7.90145844e-02f,
  8.79418477e-02f, 1.09642394e-01f, 8.23721569e-03f, 1.79096479e-02f, 2.58646924e-02f, 1.39990002e-01f, 8.22033850e-04f, -1.26041053e-02f, -3.90359648e-02f, 5.51854260e-02f,
  -1.89374223e-01f, 1.77170500e-01f, 2.82451902e-02f, -1.39505833e-01f, 9.43932086e-02f, -1.62747428e-01f, -1.26835465e-01f, 7.16613755e-02f, -5.17502688e-02f, 1.84580475e-01f,
  1.05002210e-01f, -1.55747131e-01f, 2.00110544e-02f, 6.87033450e-03f, -1.42624006e-01f, -3.74388248e-02f, -1.61280632e-01f, -6.31792992e-02f, -1.07605401e-02f, -5.53441793e-02f,
  -5.85396215e-02f, 9.82845053e-02f, 5.44669852e-02f, 1.98807642e-01f, 2.88470741e-02f, -1.06333047e-02f, -2.38601863e-02f, 1.57979071e-01f, 1.74371507e-02f, -5.48318774e-02f,
  -3.34622599e-02f, 3.03188320e-02f, 2.32821424e-02f, -7.20754117e-02f, -8.40652436e-02f, 3.83434780e-02f, 3.01980395e-02f, -3.75226419e-03f, -3.97859886e-03f, -7.01257810e-02f,
  -4.11594063e-02f, -5.49861183e-03f, -1.17811551e-02f, -4.81162071e-02f, -5.39785391e-03f, 1.02426887e-01f, -1.23174172e-02f, 3.48064899e-02f, -1.56657137e-02f, 1.41181899e-02f,
  -3.19911353e-02f, -6.33977577e-02f, -4.56995778e-02f, -6.66457415e-02f, 2.66804527e-02f, 4.41311002e-02f, 4.31486182e-02f, 2.74356883e-02f, -8.42307732e-02f, -2.82127038e-02f,
  -7.91324601e-02f, -3.22659165e-02f, 9.40363333e-02f, -1.57259982e-02f, 7.82459751e-02f, 2.24998174e-03f, -6.78730905e-02f, 2.39360984e-02f, 4.68060523e-02f, -5.15641645e-04f,
  4.87088300e-02f, 4.38007200e-03f, -2.82436945e-02f, 6.36811629e-02f, -5.57229035e-02f, 6.32610396e-02f, 2.21402738e-02f, 8.42476487e-02f, 6.20017797e-02f, 8.49911496e-02f,
  8.03378448e-02f, -6.21382929e-02f, -2.79704649e-02f, 5.05235642e-02f, -7.58195445e-02f, -4.92177438e-03f, 1.57946218e-02f, 8.45205486e-02f, -5.31823784e-02f, 2.58677173e-03f,
  -6.09132573e-02f, 6.69319406e-02f, 9.29986387e-02f, 7.88064525e-02f, 5.56545854e-02f, -6.58023804e-02f, -4.99201193e-02f, -6.12742603e-02f, -9.25393589e-03f, -7.89097771e-02f,
  -3.57540846e-02f, 9.11974981e-02f, 3.73562127e-02f, -6.29162714e-02f, -1.68184955e-02f, -2.17315480e-02f, 8.79587159e-02f, -4.70968522e-02f, -3.69450599e-02f, 3.05321999e-02f,
  5.67833036e-02f, -1.51037518e-02f, -2.44730562e-02f, 2.30859555e-02f, -7.85570145e-02f, 5.20472638e-02f, -9.04057473e-02f, 6.25014305e-02f, -1.46203144e-02f, -5.76498359e-02f,
  -2.15391666e-02f, 3.52797955e-02f, 5.10970242e-02f, 2.78152209e-02f, -3.66391726e-02f, 7.35544637e-02f, -3.34988087e-02f, 7.73606673e-02f, -7.09603503e-02f, -1.41972899e-02f,
  -1.27464041e-01f, 2.90313847e-02f, -6.07744092e-03f, -1.05501734e-01f, -1.40366018e-01f, 3.62562351e-02f, -1.29580900e-01f, -7.27976859e-02f, 2.31457930e-02f, -7.05142394e-02f,
  -4.34706993e-02f, -1.15540989e-01f, -4.62182350e-02f, -5.60144475e-03f, -7.98531622e-02f, 5.35471737e-02f, 4.60757166e-02f, -3.73283103e-02f, -7.98985139e-02f, -5.49785979e-02f,
  9.73167792e-02f, -2.49997601e-02f, 9.74031687e-02f, -5.78609556e-02f, -6.72721490e-02f, 7.10045397e-02f, -7.16863722e-02f, -2.75953338e-02f, -6.14535389e-03f, -9.96094756e-03f,
  -3.69151048e-02f, 1.09233717e-02f, 7.92555511e-02f, 3.48589160e-02f, 4.71488908e-02f, 7.85055608e-02f, 1.20485701e-01f, 3.67635153e-02f, 1.62885319e-02f, 4.23081852e-02f,
  1.21110706e-02f, 4.36623283e-02f, -7.25762993e-02f, 1.83267076e-03f, 6.35171682e-02f, 5.16304299e-02f, 6.25325739e-02f, 3.39808762e-02f, 7.70503422e-03f, 1.89465228e-02f,
  -3.05355527e-02f, 2.85635982e-02f, -7.11629242e-02f, -7.63623938e-02f, -3.53653240e-03f, 3.90361287e-02f, -2.76523829e-02f, 2.95162331e-02f, 1.97983701e-02f, 7.62126991e-04f,
  -1.61116235e-02f, -1.01971077e-02f, -6.29691556e-02f, 5.86402714e-02f, 7.27172717e-02f, -5.95831163e-02f, 4.11470793e-02f, 7.59817734e-02f, 8.13761726e-02f, 2.80590486e-02f,
  4.20011617e-02f, 2.45504342e-02f, -5.88826798e-02f, 2.79273633e-02f, 2.98091043e-02f, 7.97868744e-02f, 9.22352001e-02f, 1.00551724e-01f, 8.76312330e-02f, -4.94865999e-02f,
  7.07089156e-02f, -9.08425823e-02f, 1.85889285e-02f, 4.59373519e-02f, 6.79075122e-02f, -7.17045516e-02f, -1.60829779e-02f, 1.57106854e-02f, -3.90147814e-03f, -3.52325626e-02f,
  -1.83604620e-02f, 4.31082919e-02f, -5.33265173e-02f, -4.26195972e-02f, -5.99670596e-02f, 9.33968648e-02f, -5.70893809e-02f, -4.55882996e-02f, -2.76691727e-02f, -7.87375793e-02f,
  -6.13583587e-02f, -9.62248966e-02f, 2.51811091e-03f, -1.55341132e-02f, 5.74786142e-02f, -5.14290705e-02f, 6.71557188e-02f, -5.14734276e-02f, 8.16420317e-02f, -4.81924973e-02f,
  1.35430247e-01f, -2.23981977e-01f, 1.44060597e-01f, 9.64066610e-02f, 1.21517424e-02f, 1.33302346e-01f, 2.07348481e-01f, -3.02426238e-02f, -3.27444449e-02f, -2.28760436e-01f,
  1.37671903e-02f, 6.94585731e-03f, 1.58735693e-01f, -3.86688206e-03f, 1.43237293e-01f, 2.78278142e-02f, -1.85807177e-03f, 1.24333747e-01f, -6.93354234e-02f, -4.79661906e-03f,
  4.94790338e-02f, -1.92549266e-02f, 1.68442681e-01f, -1.47744626e-01f, 7.11239055e-02f, -1.14441887e-01f, -1.02353469e-01f, 2.27124840e-02f, -2.92779226e-02f, -3.24812941e-02f,
  -6.46631643e-02f, -6.45594224e-02f, 2.41892692e-02f, 3.24709415e-02f, 1.29636629e-02f, 3.17351446e-02f, -5.14031686e-02f, 1.09321445e-01f, 3.79244685e-02f, -3.21016610e-02f,
  -2.86908206e-02f, -6.55728653e-02f, -6.09670505e-02f, -3.60569241e-03f, 4.76485342e-02f, -1.52538046e-02f, 8.08097199e-02f, 5.67176985e-03f, -3.01220752e-02f, 2.67322455e-02f,
  -3.81923057e-02f, -2.45974623e-02f, 6.16070963e-02f, -8.65244716e-02f, -2.61431988e-02f, -1.91264823e-02f, 2.97172870e-02f, -3.03048529e-02f, -7.59886652e-02f, -6.45089746e-02f,
  -5.49203195e-02f, -2.32728664e-03f, -3.39628793e-02f, 1.10083118e-01f, 9.41683948e-02f, -4.58488055e-03f, 1.88143477e-02f, 1.31697319e-02f, -4.34720926e-02f, -7.88953155e-02f,
  -1.89610850e-02f, 5.72790392e-02f, 2.82210093e-02f, -3.63396183e-02f, 7.20947981e-02f, 5.25908954e-02f, 2.68730782e-02f, -7.96925053e-02f, -4.91072759e-02f, 2.40197312e-02f,
  7.34573528e-02f, 3.95196863e-03f, -7.03609176e-03f, 6.36935756e-02f, -9.51370075e-02f, -1.55381747e-02f, -7.01157600e-02f, -4.41364087e-02f, 3.64072411e-03f, 4.53278758e-02f,
  -1.48293719e-01f, -2.07358032e-01f, -1.02387622e-01f, 4.62402180e-02f, -1.17182113e-01f, -7.61865601e-02f, -1.00642769e-02f, 6.50847983e-03f, 8.54346976e-02f, 7.17825294e-02f,
  -4.15007584e-02f, 4.73532937e-02f, 3.74356471e-02f, 2.60369238e-02f, 5.41680977e-02f, -7.31177405e-02f, -3.33864801e-02f, 6.23882487e-02f, -6.01279587e-02f, 1.29132299e-02f,
  -7.60920197e-02f, -9.41817686e-02f, -5.65313995e-02f, 5.04828058e-02f, 3.19988206e-02f, -7.43063986e-02f, 9.82133299e-03f, -3.48393396e-02f, -4.89756428e-02f, -7.97446817e-03f,
  -2.75313288e-01f, 2.38797218e-01f, -1.72846615e-01f, -8.81197117e-03f, -1.36169016e-01f, 2.91797280e-01f, 3.26025516e-01f, 3.91881280e-02f, 1.27435058e-01f, 4.28054780e-01f,
  2.33794123e-01f, -1.14887595e-01f, 2.14182690e-01f, 3.59530896e-01f, 6.30526841e-02f, 2.83374667e-01f, 3.92711222e-01f, 2.60631442e-01f, -1.37576018e-03f, 1.06142223e-01f,
  -7.12688416e-02f, 1.27022058e-01f, -7.63650686e-02f, -3.53916585e-02f, -1.13782495e-01f, -1.77405417e-01f, -3.28340307e-02f, -2.50052005e-01f, -3.03650182e-02f, 1.62258409e-02f,
  -2.83506401e-02f, -3.29247713e-02f, -1.30493447e-01f, 1.79569349e-02f, 3.04310862e-03f, -8.96649957e-02f, -7.62214810e-02f, -1.10643528e-01f, -2.10134555e-02f, -3.77691574e-02f,
  1.58782192e-02f, -1.39436126e-01f, 4.90283780e-02f, -6.51990324e-02f, 5.34912804e-03f, -8.72805808e-03f, -3.78543511e-02f, -3.99483368e-02f, -3.70099396e-03f, -1.85085405e-02f,
  5.33975288e-02f, 8.57985765e-02f, -1.79488491e-02f, 1.94932315e-02f, 2.94224527e-02f, 5.51013350e-02f, 2.20750943e-02f, -7.54905120e-02f, 8.05234388e-02f, 1.03918333e-02f,
  1.78251471e-02f, 7.82718211e-02f, -2.90056039e-02f, -7.72494972e-02f, 1.90856978e-02f, 2.93239746e-02f, -7.99727961e-02f, 5.82665727e-02f, 1.17405783e-02f, -7.31222332e-03f,
  -1.84893981e-02f, -6.82822838e-02f, -8.31039548e-02f, 7.30192810e-02f, -3.75600718e-02f, -6.78319260e-02f, 1.52684003e-02f, -1.38041442e-02f, 3.83228697e-02f, -5.39246239e-02f,
  6.98910207e-02f, -2.15489864e-02f, 8.44039395e-03f, -4.06408198e-02f, 2.42224038e-02f, -4.09656614e-02f, 7.72338361e-02f, -4.05168049e-02f, 3.39221843e-02f, 1.10644931e-02f,
  2.13775918e-01f, 1.16002604e-01f, 6.14921041e-02f, 1.01357801e-02f, 3.74590904e-02f, -3.53627675e-03f, -1.58671718e-02f, 5.07975742e-02f, 2.03061644e-02f, 6.79541901e-02f,
  5.13722412e-02f, 4.37003933e-03f, -6.24704063e-02f, -7.55147561e-02f, 1.38386143e-02f, 9.45737138e-02f, -2.97977552e-02f, 4.23377613e-03f, 9.36331879e-03f, -3.20695080e-02f,
  9.20530036e-03f, 4.10851948e-02f, -1.77971590e-02f, -6.76638335e-02f, 4.57818285e-02f, 7.14793950e-02f, -1.01320008e-02f, -6.33767098e-02f, -3.01561579e-02f, 4.80351746e-02f,
  -8.56792778e-02f, 1.46739736e-01f, 2.22819392e-02f, -9.40877944e-02f, -4.68861461e-02f, -4.19745445e-02f, 3.99562530e-02f, -2.36873701e-02f, -4.85050455e-02f, 1.94805488e-02f,
  6.34334385e-02f, -5.21194898e-02f, 6.85722828e-02f, -1.04117408e-01f, -1.14440285e-01f, -3.40044089e-02f, -6.11050688e-02f, 4.29649986e-02f, 3.98464948e-02f, -2.41099093e-02f,
  -9.12511069e-03f, 3.67176570e-02f, -8.75372589e-02f, -6.83717057e-02f, -1.04576305e-01f, 6.87759137e-03f, 7.85013810e-02f, 5.80273047e-02f, -8.97360127e-03f, 5.88960275e-02f,
  9.73297807e-04f, 1.09435976e-01f, 6.28078803e-02f, -7.15787932e-02f, -5.41284401e-03f, -9.34012085e-02f, -6.66966364e-02f, 1.42558208e-02f, -7.62119442e-02f, 4.10663225e-02f,
  -8.46809819e-02f, -5.91038875e-02f, -6.13775477e-02f, 8.99048895e-02f, -4.31238636e-02f, 4.13514003e-02f, -4.83341217e-02f, -1.70277655e-02f, 7.13744685e-02f, 5.63500077e-02f,
  1.94357187e-02f, 7.64842182e-02f, -3.62957828e-02f, 8.86799768e-02f, 8.29943419e-02f, 4.73668762e-02f, 4.58961725e-02f, 2.17264052e-02f, -3.97779681e-02f, -5.15058339e-02f,
  1.52891101e-02f, 2.58856062e-02f, -8.17600731e-03f, -9.37843174e-02f, -1.09093757e-02f, -4.13948894e-02f, -6.64998079e-03f, 3.49493884e-02f, 4.51876642e-03f, 8.07379335e-02f,
  3.44629958e-02f, 8.41645524e-02f, -6.45638332e-02f, 5.94694987e-02f, -4.58020680e-02f, -5.77308014e-02f, -4.63896357e-02f, -5.54962642e-02f, -6.56397194e-02f, -5.48698613e-03f,
  6.17935173e-02f, 6.53601140e-02f, -3.96475270e-02f, -3.12671401e-02f, 4.58094254e-02f, -2.97176205e-02f, 3.34386192e-02f, -7.95661509e-02f, -6.59304112e-02f, -4.24774252e-02f,
  8.28306228e-02f, 1.30598515e-01f, -3.11241485e-02f, 5.42932041e-02f, 9.95179638e-03f, 1.94168724e-02f, 2.55069248e-02f, 3.14597860e-02f, 6.30860254e-02f, -1.06683923e-02f,
  -2.66100150e-02f, 6.27575591e-02f, -4.97146919e-02f, -3.63746844e-02f, -6.61842944e-03f, -8.32434297e-02f, 8.51424560e-02f, 8.21564794e-02f, 8.31165016e-02f, -4.10846174e-02f,
  5.01964912e-02f, 1.05993068e-02f, 4.78681587e-02f, 2.64358055e-02f, -1.53623112e-02f, 3.78485024e-02f, -6.94667101e-02f, 4.10056207e-03f, -1.17741730e-02f, -1.52003178e-02f,
  5.71504422e-02f, -2.65040457e-01f, 5.24948686e-02f, 1.10863768e-01f, 4.68706675e-02f, 1.08414665e-02f, 1.51147991e-01f, -1.03484347e-01f, -4.31574695e-02f, -1.84209883e-01f,
  -6.19368367e-02f, 1.37211025e-01f, -8.47542658e-03f, -4.20379033e-03f, 2.41442397e-01f, 5.07301744e-03f, -1.01556614e-01f, 1.05739394e-02f, 4.88585196e-02f, -6.45824373e-02f,
  5.99052235e-02f, -1.46822140e-01f, -8.89701396e-03f, -1.01405397e-01f, -1.22648403e-01f, 1.35457178e-03f, 8.27931538e-02f, -4.29702224e-03f, -1.21447273e-01f, 2.50558816e-02f,
  1.81126259e-02f, -1.00760892e-01f, 6.26022443e-02f, -3.95651236e-02f, -3.46857868e-02f, 5.74175045e-02f, 1.18114464e-01f, 8.25908557e-02f, -3.84347960e-02f, 2.39927713e-02f,
  5.52158020e-02f, 6.04281723e-02f, 1.43290665e-02f, -5.60460947e-02f, 5.08739613e-02f, 2.36847065e-02f, 4.25569117e-02f, 7.08538666e-02f, 6.18322901e-02f, -6.66542873e-02f,
  -4.02558083e-03f, 2.23930981e-02f, -5.16725481e-02f, -7.78027698e-02f, -3.94667573e-02f, 5.31615643e-03f, -6.17116168e-02f, 7.44948089e-02f, -6.16665557e-02f, -3.04534845e-02f,
  2.00955961e-02f, 5.90203069e-02f, 4.90631759e-02f, 2.88458113e-02f, 2.52606682e-02f, -6.37395978e-02f, 2.44922880e-02f, 7.93259963e-02f, 6.56908303e-02f, 2.32084394e-02f,
  -6.54805601e-02f, -4.78401557e-02f, 9.16281566e-02f, 2.75003631e-02f, -1.02077015e-01f, -3.24886963e-02f, -5.12051471e-02f, 5.24999313e-02f, 3.99956480e-02f, 6.79111481e-02f,
  2.87004150e-02f, -5.03356159e-02f, -4.18762602e-02f, -7.74168447e-02f, -6.69767633e-02f, 8.80206078e-02f, -2.78487597e-02f, -7.23671019e-02f, -6.13283888e-02f, 6.26269402e-03f,
  5.11152223e-02f, -1.58214688e-01f, -7.35857338e-02f, 7.87467416e-03f, -8.47367048e-02f, -8.29538852e-02f, -1.10956244e-02f, -4.31914479e-02f, -7.45558515e-02f, -5.60448542e-02f,
  -9.61151347e-02f, -9.06244852e-03f, -6.76637366e-02f, 3.21785100e-02f, 5.10237133e-03f, -1.08089104e-01f, -7.28052333e-02f, 4.08204459e-02f, -4.87794168e-03f, -6.07969798e-02f,
  -9.92931500e-02f, 4.73935418e-02f, 5.83061539e-02f, 8.00180510e-02f, 6.28865510e-03f, -1.20661557e-02f, -7.58421645e-02f, -1.08913155e-02f, 3.62332389e-02f, -1.08517870e-01f,
  -1.62382871e-01f, 6.81456700e-02f, 2.67034210e-02f, 1.49134204e-01f, -1.17630713e-01f, -2.49820575e-01f, -1.30768120e-01f, -2.41469592e-02f, -3.15412208e-02f, 1.17307037e-01f,
  1.45955801e-01f, -1.43936232e-01f, 8.80131871e-02f, -9.95618179e-02f, -9.54661444e-02f, -6.08444540e-03f, -5.13156131e-02f, -1.44055769e-01f, 2.29179300e-02f, 1.01779155e-01f,
  7.27708116e-02f, 9.84222218e-02f, 1.23213887e-01f, 1.30076557e-01f, -7.96145499e-02f, 7.38088191e-02f, 2.51344353e-01f, 1.25724658e-01f, 5.11829033e-02f, -3.68782282e-02f,
  -7.35992119e-02f, 1.64967582e-01f, -2.90577989e-02f, 1.75776929e-02f, 7.92607889e-02f, -9.03119072e-02f, 1.07502649e-02f, 3.67213115e-02f, 5.89657798e-02f, 5.33686532e-03f,
  -7.27667585e-02f, 8.75099748e-02f, 3.68368551e-02f, 6.85789809e-02f, -6.30345568e-02f, 8.49231333e-02f, -7.97955617e-02f, 4.19655927e-02f, -6.30334765e-02f, 5.11068031e-02f,
  1.77327618e-02f, -2.02244762e-02f, 5.18472306e-03f, 6.45723492e-02f, -2.27481220e-02f, -6.33693784e-02f, -4.94387075e-02f, -5.47298929e-04f, 2.09886692e-02f, -8.62570554e-02f,
  -5.16474061e-02f, -2.81036515e-02f, -2.01469883e-02f, -3.73765081e-02f, -9.37822834e-02f, 8.88437591e-03f, -9.48034003e-02f, -1.31179746e-02f, 6.61483556e-02f, 5.98345846e-02f,
  -3.17270053e-03f, 6.41685501e-02f, -9.13828462e-02f, 3.86548787e-03f, 9.70075056e-02f, 3.36145684e-02f, -6.46811500e-02f, 7.50566348e-02f, 8.13299119e-02f, -7.36165345e-02f,
  8.02778751e-02f, 9.10114683e-03f, -5.01841642e-02f, 4.73057888e-02f, 2.19380464e-02f, 5.10020517e-02f, 2.08218079e-02f, -5.55190258e-02f, -1.40169999e-02f, -5.56556769e-02f,
  1.07637361e-01f, 1.53720945e-01f, 4.89326976e-02f, 3.78312683e-03f, 4.33986671e-02f, -6.96607530e-02f, 5.76197729e-02f, -5.43795116e-02f, 1.15148574e-01f, -5.59104085e-02f,
  6.72129914e-02f, -4.27757129e-02f, -6.33491129e-02f, 4.09182757e-02f, 4.17892113e-02f, 3.94336991e-02f, -1.22170262e-02f, -7.50846043e-02f, 9.92898047e-02f, -4.77011949e-02f,
  9.83744860e-02f, 6.04459345e-02f, 6.83112070e-02f, -4.91157807e-02f, -5.60108982e-02f, 2.67163268e-03f, 1.38487527e-02f, 8.15017223e-02f, 6.12116493e-02f, 6.98363334e-02f,
  -1.19700484e-01f, -5.74666858e-02f, 1.43528255e-02f, -5.28463647e-02f, 4.10483778e-02f, -5.86517341e-02f, -7.55216479e-02f, 2.02144142e-02f, -1.14284523e-01f, 5.14697358e-02f,
  -5.85604310e-02f, 1.01584001e-02f, 1.48212507e-01f, -1.10844351e-01f, -4.56508901e-03f, 2.46245470e-02f, -1.60699174e-01f, -1.74151249e-02f, -6.96880817e-02f, -6.57938793e-02f,
  -1.05667517e-01f, -1.27200812e-01f, 9.41726416e-02f, 9.82931852e-02f, 3.22592370e-02f, -8.57984945e-02f, 4.68052216e-02f, 1.14299290e-01f, -2.59679127e-02f, 5.91401346e-02f,
  -1.07586250e-01f, -1.57118868e-02f, 1.74252149e-02f, 4.62387651e-02f, 5.13170063e-02f, -3.10078990e-02f, -6.53575957e-02f, -2.45418251e-02f, 1.54536683e-02f, -6.70709163e-02f,
  -2.98594171e-03f, -7.69281387e-02f, -9.05319154e-02f, 1.18841864e-02f, 7.14260042e-02f, 2.07138453e-02f, -4.92952280e-02f, 2.30780989e-02f, -1.10250711e-02f, -5.46773709e-02f,
  3.14536430e-02f, 4.16896529e-02f, 3.29044722e-02f, -7.49785453e-03f, -4.29467559e-02f, -4.91075777e-02f, -6.88388869e-02f, 2.77394336e-02f, 7.70211816e-02f, -8.30055773e-02f,
  -8.00232515e-02f, 2.15667952e-02f, -6.37374148e-02f, -4.85153385e-02f, -4.41273451e-02f, 2.30223816e-02f, 7.95607194e-02f, -7.20699877e-02f, -4.82069515e-02f, 1.78024005e-02f,
  -7.03753904e-02f, 3.72069329e-02f, -4.80549634e-02f, -1.41391922e-02f, -5.80344237e-02f, 4.05141897e-02f, -7.40293134e-03f, 1.08194863e-02f, -5.23312092e-02f, 6.89942613e-02f,
  -5.40175177e-02f, 6.59960210e-02f, 5.43764196e-02f, -4.94313091e-02f, 2.32946854e-02f, 6.03517182e-02f, -6.80595860e-02f, 7.18256086e-02f, 4.75792326e-02f, -5.63991778e-02f,
  -7.28954375e-02f, -3.34205218e-02f, -1.25427861e-02f, -6.30360842e-02f, -5.62507808e-02f, 6.65611178e-02f, -3.61632258e-02f, -5.16774803e-02f, -2.01614182e-02f, 6.93561733e-02f,
  5.81435412e-02f, 4.97436076e-02f, -3.89852785e-02f, -1.01026408e-02f, 7.28906319e-02f, -9.71974730e-02f, 6.84115961e-02f, 1.93274207e-02f, -7.32107013e-02f, -5.64592592e-02f,
  -6.97174072e-02f, -4.95706266e-03f, -5.06787151e-02f, -1.09275188e-02f, 7.47299567e-02f, 1.67457629e-02f, 7.60240555e-02f, 1.83963533e-02f, -7.14952946e-02f, 2.25130245e-02f,
  8.91490057e-02f, -2.01240748e-01f, -1.51489954e-02f, 1.69094160e-01f, 8.44016392e-03f, 4.01133001e-02f, 8.11959803e-02f, 3.88164036e-02f, 1.68671101e-01f, -9.92167294e-02f,
  -4.08756696e-02f, -1.53884307e-01f, 2.70327255e-02f, 1.32054359e-01f, 1.60451457e-01f, 3.58936988e-04f, 1.06482208e-01f, 1.63325835e-02f, 1.03934951e-01f, 9.29086581e-02f,
  7.77496770e-02f, 1.04571775e-01f, -9.34576616e-03f, -5.32620251e-02f, 1.93019714e-02f, -1.07685484e-01f, -7.52859339e-02f, -5.65379560e-02f, -1.10007301e-01f, -4.28991467e-02f,
  3.57991755e-02f, 6.81443363e-02f, 8.00264552e-02f, 6.30936623e-02f, -8.63779932e-02f, 5.56341372e-02f, -5.03473356e-02f, 3.35450731e-02f, 1.05094053e-01f, 6.61546784e-03f,
  -7.50556141e-02f, 7.24770501e-02f, 9.46013853e-02f, 5.52112758e-02f, -4.93892245e-02f, 4.10148054e-02f, 6.19505681e-02f, 4.99670245e-02f, -6.07334599e-02f, -3.58113907e-02f,
  -3.81646305e-02f, -3.12941037e-02f, 4.32858132e-02f, -8.67194161e-02f, -7.42483065e-02f, -7.56368740e-03f, -9.19129327e-02f, -8.93595163e-03f, -3.18933800e-02f, 6.02029599e-02f,
  3.82033885e-02f, 2.99797598e-02f, -8.06730315e-02f, 9.56756547e-02f, -2.31688432e-02f, -1.67882070e-02f, -8.00959170e-02f, -4.43971679e-02f, -5.36770150e-02f, 4.44107410e-03f,
  7.08361641e-02f, 8.28079358e-02f, -4.16559577e-02f, 7.45030120e-02f, -3.93404402e-02f, 6.19710274e-02f, -7.58858919e-02f, 3.74400206e-02f, -4.47225198e-02f, 2.49787979e-03f,
  6.39903471e-02f, 8.67742226e-02f, 2.62377528e-03f, 3.23515125e-02f, 4.22306694e-02f, 4.09085117e-02f, 1.26506239e-02f, 5.94795607e-02f, -4.73875925e-02f, -5.10693006e-02f,
  -2.84150988e-02f, -4.38575353e-03f, -5.68988584e-02f, -2.00043209e-02f, 2.02261917e-02f, -3.41398492e-02f, -5.61983399e-02f, -6.06250539e-02f, 7.85093978e-02f, -5.84449284e-02f,
  3.52798179e-02f, 5.19820079e-02f, 5.35900854e-02f, -2.40215492e-02f, -9.31330845e-02f, -6.38201311e-02f, 5.23142815e-02f, -2.31153686e-02f, -1.99710224e-02f, -4.77421470e-02f,
  -1.07997552e-01f, -4.71501332e-03f, -7.98155069e-02f, 2.20796792e-03f, -5.34972511e-02f, -6.19029552e-02f, -8.37512463e-02f, -4.69959117e-02f, -2.57447492e-02f, 6.52191415e-02f,
  -1.44709572e-01f, 2.01333329e-01f, 4.86692972e-02f, -4.20605615e-02f, 1.51576087e-01f, 1.98537737e-01f, -2.05148049e-02f, 1.20829396e-01f, -9.46785510e-02f, -1.82328112e-02f,
  -1.37091443e-01f, -3.81632298e-02f, 6.39236197e-02f, 2.18081437e-02f, 7.60949254e-02f, 3.23307589e-02f, 9.31201056e-02f, -9.73136276e-02f, 8.16985667e-02f, 4.70061824e-02f,
  1.14704907e-01f, -5.47114983e-02f, 1.88734069e-01f, 9.00330022e-03f, 2.26296335e-02f, -1.08180605e-01f, -7.90895000e-02f, 8.73541757e-02f, -3.53000909e-02f, -3.22181806e-02f,
  -1.33353285e-02f, -1.37854710e-01f, -1.79945067e-01f, -1.17009073e-01f, -9.59960669e-02f, -8.73103663e-02f, -1.09110370e-01f, -8.49275291e-02f, -2.37520952e-02f, 3.92645178e-03f,
  -1.26006410e-01f, -7.34218583e-02f, -4.21688184e-02f, 1.42729282e-03f, 3.37866805e-02f, -5.99926412e-02f, 6.00107526e-03f, 1.02710620e-01f, -8.27126876e-02f, 1.38416067e-01f,
  1.23100266e-01f, -2.06298404e-03f, 1.12363361e-02f, 1.72737110e-02f, 4.87914607e-02f, 6.10329993e-02f, 4.55819629e-02f, -4.61847708e-02f, 8.68851170e-02f, 2.85813678e-02f,
  -5.41718304e-02f, 1.93004981e-02f, -9.02704895e-02f, -1.00816913e-01f, 5.45968413e-02f, 6.19035251e-02f, -4.09411527e-02f, -3.05819493e-02f, -3.59120183e-02f, -3.23895440e-02f,
  6.58082888e-02f, -7.78920725e-02f, -6.90002292e-02f, 4.82251262e-03f, 2.87034102e-02f, -3.80552746e-02f, 1.47864595e-02f, -4.79980670e-02f, -2.61840448e-02f, -4.00441177e-02f,
  -5.36418632e-02f, 5.22535257e-02f, -5.22862785e-02f, 6.45144237e-03f, -6.29767179e-02f, 5.32617979e-02f, 5.08020371e-02f, 8.97891670e-02f, -5.92301004e-02f, -3.50122117e-02f,
  -1.47948548e-01f, -1.92556486e-01f, -4.21146303e-02f, -4.48804982e-02f, -6.47865757e-02f, -7.36175478e-02f, -2.31072307e-02f, -4.59756516e-02f, -1.04211286e-01f, -5.04254103e-02f,
  4.16639633e-02f, 3.03111821e-02f, 1.86244352e-03f, -4.89030592e-02f, 5.28352149e-02f, 3.70968990e-02f, -6.50764108e-02f, -3.73259969e-02f, -7.91747496e-02f, -1.81520786e-02f,
  -9.43031237e-02f, 4.52118181e-02f, -5.35037071e-02f, 4.60430272e-02f, -2.51430757e-02f, -8.59783962e-02f, -6.03223629e-02f, 1.39743034e-02f, 6.33077025e-02f, -6.60787290e-03f,
  -3.84730957e-02f, -6.86439648e-02f, -1.37039870e-01f, -7.93194994e-02f, -8.41469690e-02f, -7.38175819e-03f, -6.73487186e-02f, 4.06207293e-02f, 8.67081732e-02f, -1.98497009e-02f,
  1.69711944e-03f, -4.78728674e-02f, 2.95283590e-02f, -1.16739653e-01f, 4.12880490e-03f, 9.74226296e-02f, -8.70964080e-02f, -4.00983281e-02f, 6.75473735e-02f, -1.58124790e-01f,
  -1.83732621e-02f, -2.56873537e-02f, -1.06620662e-01f, -2.71304548e-02f, -1.47790626e-01f, -2.74558086e-02f, 4.77136075e-02f, 3.99803445e-02f, -5.74191287e-02f, -1.87164005e-02f,
  -6.23664856e-02f, 5.81696741e-02f, -3.20062228e-02f, 7.15580210e-02f, -1.17148556e-01f, 7.81404600e-03f, 5.39088696e-02f, -3.28609794e-02f, -7.99781755e-02f, 1.19454470e-02f,
  -5.16017117e-02f, -7.53578469e-02f, -6.71030730e-02f, 6.24765060e-04f, 4.47913595e-02f, -9.36354771e-02f, 1.45649735e-03f, -2.83926819e-02f, -7.77795762e-02f, -5.50631583e-02f,
  7.17944726e-02f, -8.53398740e-02f, -6.55585006e-02f, 6.98612928e-02f, -9.07824636e-02f, -2.70510279e-02f, -4.54177931e-02f, 6.72099590e-02f, 6.34857118e-02f, 6.21473826e-02f,
  8.64601694e-04f, 4.71551158e-02f, -6.55148476e-02f, -1.67275723e-02f, 6.29560128e-02f, -8.53513256e-02f, -4.62719537e-02f, 6.60940483e-02f, -5.03545888e-02f, 4.81615327e-02f,
  -3.91720049e-02f, 8.60972255e-02f, 8.39508176e-02f, -3.95680666e-02f, -4.67791148e-02f, -1.69597915e-03f, 3.92464213e-02f, 1.09241186e-02f, -5.86591735e-02f, 1.98611105e-03f,
  -7.85227269e-02f, 4.10052128e-02f, 3.85468453e-02f, -4.78774533e-02f, -5.31804785e-02f, -2.14454141e-02f, 7.64927492e-02f, -3.51357944e-02f, -7.73236305e-02f, -2.18562018e-02f,
  -7.69328624e-02f, 8.60409439e-03f, -8.68091583e-02f, -5.16916178e-02f, -1.25957085e-02f, -9.33665335e-02f, -6.60319701e-02f, 4.30424474e-02f, 5.81521690e-02f, -4.63460162e-02f,
  -1.53662935e-02f, -7.89727196e-02f, 1.25319669e-02f, 7.91803524e-02f, -8.58303681e-02f, 5.55303916e-02f, -8.33553895e-02f, 5.21430373e-02f, -3.04113831e-02f, 2.37886328e-02f,
  6.13681860e-02f, 8.57958663e-03f, 3.25003192e-02f, -1.42583065e-02f, 8.46611783e-02f, 2.32187975e-02f, 7.31351525e-02f, 6.52806461e-02f, -5.56537509e-02f, -1.89421827e-03f,
  4.56222892e-02f, 6.73779845e-02f, 1.65685683e-01f, 1.34018913e-01f, -1.48937315e-01f, -7.22547323e-02f, -3.61457802e-02f, -1.44080579e-01f, 1.66977812e-02f, -4.12715897e-02f,
  -6.22118004e-02f, 2.36091599e-01f, 4.64548096e-02f, -3.83330546e-02f, -5.05615473e-02f, 6.08423948e-02f, -1.56059384e-01f, 1.03915902e-02f, -4.70724981e-03f, 1.20552052e-02f,
  -3.15924324e-02f, -1.61223784e-01f, 5.27218468e-02f, -1.85571253e-01f, -4.77326475e-02f, -8.19670632e-02f, -1.32373512e-01f, 6.15728572e-02f, -1.17670083e-02f, 2.63114721e-02f,
  3.73151451e-02f, -2.35223081e-02f, 3.29023898e-02f, -5.32451905e-02f, -9.34556648e-02f, 3.46003138e-02f, 5.48258089e-02f, 1.08468473e-01f, -5.64868897e-02f, -2.95101460e-02f,
  6.90678731e-02f, -8.01811693e-04f, 5.66781610e-02f, -5.11916727e-03f, -2.14883406e-03f, 5.89739047e-02f, 1.12003656e-02f, 9.48411897e-02f, -4.50237691e-02f, 5.34279794e-02f,
  4.21343222e-02f, -2.40222476e-02f, -4.31917422e-02f, -6.23569079e-02f, 8.74711648e-02f, -1.19229441e-03f, 3.78544256e-02f, -8.30288976e-03f, -4.24189195e-02f, 3.97216121e-04f,
  -4.72965427e-02f, 5.40655591e-02f, 8.95268936e-03f, 6.19190820e-02f, -4.62313765e-04f, -1.96196581e-03f, -2.94327922e-02f, 7.41702840e-02f, 2.71816775e-02f, 4.95055728e-02f,
  5.79738803e-02f, -5.29616140e-02f, 7.14425594e-02f, 3.20256241e-02f, 3.31795812e-02f, -6.82975277e-02f, -1.25645986e-02f, 1.64756235e-02f, -7.32011274e-02f, -1.77937690e-02f,
  1.43746929e-02f, -1.81936938e-02f, 4.22046073e-02f, -1.20596159e-02f, -1.00320272e-01f, -2.47168019e-02f, -8.42956007e-02f, -2.10807044e-02f, 5.02372794e-02f, 3.06068938e-02f,
  1.02942693e-03f, 3.24157476e-02f, -3.76994275e-02f, 7.30189830e-02f, 5.05042225e-02f, 7.03344569e-02f, 4.07137722e-02f, 3.67110632e-02f, 8.02553967e-02f, -4.80979308e-03f,
  -1.52382031e-02f, 1.12284329e-02f, 4.67825681e-02f, 3.44439014e-03f, -1.47933187e-02f, 1.39822159e-02f, -5.60741089e-02f, -2.06526201e-02f, -6.94122340e-04f, -6.05982170e-02f,
  7.26289079e-02f, -5.42757176e-02f, 9.51887965e-02f, -7.62298629e-02f, -3.42076644e-02f, 5.92194796e-02f, 4.03197780e-02f, 4.02500294e-02f, 2.21572258e-02f, -7.21439719e-02f,
  -9.07099769e-02f, 1.10278847e-02f, -1.09459214e-01f, -1.17215803e-02f, 9.29449350e-02f, -1.02082893e-01f, -7.39375651e-02f, 8.19052160e-02f, 3.69835272e-02f, 1.76774517e-01f,
  5.52300131e-03f, 6.05093949e-02f, 7.81859010e-02f, -4.10598610e-03f, -1.04249693e-01f, -1.04175983e-02f, -8.11919421e-02f, 4.95241806e-02f, -7.00587258e-02f, 3.30117084e-02f,
  1.90566033e-02f, -3.22502851e-02f, -2.32454836e-01f, 3.68408896e-02f, -2.06215214e-02f, 1.49643645e-02f, -4.64265123e-02f, -4.47601303e-02f, -8.58518705e-02f, -9.85432193e-02f,
  -6.92510381e-02f, 4.18887809e-02f, -8.79856125e-02f, 4.91687022e-02f, 5.66656422e-03f, -2.02457104e-02f, 7.69246295e-02f, 5.37096485e-02f, -2.31864359e-02f, -2.69631688e-02f,
  -1.64294858e-02f, -9.27192196e-02f, -8.59977771e-03f, -4.89708744e-02f, 5.42224012e-03f, 6.82728738e-02f, 5.28348349e-02f, -1.15000851e-01f, 8.81472901e-02f, -4.62187678e-02f,
  -9.58015770e-02f, -1.02359883e-01f, 2.22022198e-02f, 4.25359681e-02f, -4.79186699e-02f, 3.84167619e-02f, 3.02958768e-03f, 3.38741839e-02f, -3.15500945e-02f, -8.28510597e-02f,
  3.18931118e-02f, -2.66473331e-02f, -4.45275716e-02f, -9.62400958e-02f, -6.17616139e-02f, -8.19075480e-02f, 4.18647118e-02f, -3.66318077e-02f, 4.75931801e-02f, 4.65210639e-02f,
  6.02039397e-02f, 4.35940996e-02f, 8.31552520e-02f, -4.40409370e-02f, -4.90478501e-02f, 8.10586810e-02f, -2.83098295e-02f, 6.28944440e-03f, -6.23006746e-02f, -1.94158629e-02f,
  4.14786562e-02f, -3.85350622e-02f, -6.78581446e-02f, -5.72165623e-02f, 7.00658858e-02f, -4.73296456e-03f, 5.76957576e-02f, -2.88422108e-02f, 1.27421375e-02f, 7.77758658e-02f,
  1.01790383e-01f, 3.72826532e-02f, -4.58043516e-02f, -8.32153764e-03f, 6.95447847e-02f, -7.22183362e-02f, 5.05543128e-02f, 7.35031115e-03f, 3.13960277e-02f, 9.13547724e-02f,
  -5.13909906e-02f, -5.53613789e-02f, -2.28763167e-02f, 6.02721237e-02f, -3.32662761e-02f, 1.90130398e-02f, 5.54362312e-02f, 4.81299497e-02f, 5.65532669e-02f, 8.20011497e-02f,
  -5.17125018e-02f, 3.85199138e-03f, 5.82986213e-02f, 6.30279817e-03f, 1.05498470e-02f, 1.15442229e-02f, -3.74524109e-02f, -1.65925864e-02f, 6.45176023e-02f, -5.51868491e-02f,
  -2.18328796e-02f, -2.39876285e-01f, -1.10861532e-01f, -2.49477429e-03f, -2.70665661e-02f, -1.69066526e-02f, 6.45988733e-02f, -7.42974505e-02f, -5.94328903e-02f, -1.19075939e-01f,
  -4.31024544e-02f, -8.86237994e-02f, -7.78148845e-02f, 1.32119372e-01f, 1.15747258e-01f, 6.04089610e-02f, 1.15740694e-01f, 4.86068763e-02f, -7.35706910e-02f, -9.85135585e-02f,
  7.86942020e-02f, 7.00497404e-02f, 1.57118574e-01f, -1.67782474e-02f, 3.00233345e-02f, -9.74927768e-02f, 7.57976174e-02f, -8.40632915e-02f, 1.31741390e-01f, 1.10530905e-01f,
  -9.87098962e-02f, -1.34559616e-01f, -7.52248764e-02f, 3.00970338e-02f, -5.86833321e-02f, -3.07520162e-02f, 3.30386497e-02f, 3.10470667e-02f, 6.83633834e-02f, -2.39048861e-02f,
  -9.14079025e-02f, 4.11504321e-02f, -4.04659994e-02f, -5.13137281e-02f, -2.25147083e-02f, 1.61575563e-02f, -4.75904793e-02f, -3.23588997e-02f, -6.29460067e-02f, 5.15467525e-02f,
  -3.02261431e-02f, 6.63675442e-02f, -6.58902973e-02f, 7.41082355e-02f, 6.96987286e-02f, -3.44853441e-04f, 7.72890225e-02f, -4.65593524e-02f, -4.67346013e-02f, -7.72130340e-02f,
  2.25050431e-02f, 7.29296654e-02f, 6.12584129e-02f, -4.63316031e-02f, -3.07381898e-02f, -5.73270675e-03f, 2.93467492e-02f, -8.55531171e-02f, -9.02220979e-02f, -4.80351299e-02f,
  -7.87240788e-02f, -8.28281417e-02f, 2.27436144e-02f, 1.02843146e-03f, -4.93224058e-03f, -5.18640950e-02f, 7.71657303e-02f, -5.16581722e-02f, -7.85089657e-02f, 5.53752743e-02f,
  -9.34970751e-02f, 9.16973501e-03f, -3.05258706e-02f, 2.91623380e-02f, 6.96615502e-02f, 6.78410679e-02f, -7.04449415e-02f, 4.58478928e-02f, -8.76322314e-02f, -4.68278416e-02f,
  -1.31063759e-01f, -1.46091238e-01f, -6.88906983e-02f, -1.11693457e-01f, 4.05881181e-02f, -1.41483359e-02f, 5.56860082e-02f, -4.44179960e-02f, -3.95813920e-02f, 2.00665724e-02f,
  6.50541438e-03f, -3.98605913e-02f, -1.90526582e-02f, 9.90930106e-03f, 2.79354304e-02f, -8.20542872e-03f, -5.37514649e-02f, 6.80816993e-02f, 1.00155091e-02f, -8.78135115e-02f,
  -4.21978980e-02f, -4.46237251e-02f, 5.81467971e-02f, -6.82073161e-02f, 1.81348564e-03f, 2.63548438e-02f, 2.61281859e-02f, -8.60406272e-03f, 6.72651008e-02f, 1.49522275e-02f,
  -9.97385010e-02f, 1.69897720e-01f, -1.68480739e-01f, 7.98262935e-03f, 5.81027940e-02f, -1.05381280e-01f, -6.90200329e-02f, -1.16460033e-01f, 2.76801344e-02f, 1.46628916e-01f,
  1.03826277e-01f, 8.12119171e-02f, -6.27455041e-02f, 6.83694184e-02f, -1.99742138e-01f, -1.30949497e-01f, -8.62140954e-02f, 7.11797774e-02f, 3.34571339e-02f, -5.35859838e-02f,
  -1.83835953e-01f, -2.50715986e-02f, -9.88735706e-02f, 9.04099494e-02f, 3.98327690e-03f, -5.25391400e-02f, 6.61400184e-02f, 5.81633858e-02f, -6.46872330e-04f, -1.62050705e-02f,
  -1.06671773e-01f, 9.87519161e-04f, 6.27209470e-02f, -4.68650833e-02f, -6.58151805e-02f, -1.85966268e-02f, 6.71565672e-03f, -1.95360593e-02f, -4.98692878e-02f, -4.85752001e-02f,
  4.97863740e-02f, 4.57255840e-02f, -3.00744027e-02f, -2.74303686e-02f, -6.58580214e-02f, 8.19785967e-02f, -6.95397779e-02f, 6.24165535e-02f, 1.53265595e-02f, -7.71179199e-02f,
  -9.25206691e-02f, 4.86971438e-02f, -4.87435348e-02f, -2.51711011e-02f, -8.49642232e-02f, 9.28432569e-02f, 2.12850645e-02f, -5.33392094e-02f, 1.75969787e-02f, -4.62911874e-02f,
  7.20367953e-02f, -7.63518438e-02f, -4.87527028e-02f, 4.55736406e-02f, -7.57328933e-03f, -5.80702722e-02f, -1.20312348e-02f, 3.94046158e-02f, 7.06810802e-02f, 7.07834139e-02f,
  -6.41348884e-02f, -9.62489657e-03f, 6.64626509e-02f, -2.21989769e-02f, -3.10712308e-02f, 4.64898311e-02f, -5.89379668e-02f, 3.63456756e-02f, 8.29142332e-03f, -7.98951909e-02f,
  1.62908528e-02f, -1.51005248e-02f, 6.68617934e-02f, -4.92988974e-02f, 2.96936035e-02f, 3.86350900e-02f, -3.34881209e-02f, -3.03948987e-02f, -5.94896488e-02f, 4.03545350e-02f,
  3.87587361e-02f, -2.08342839e-02f, 4.54035960e-02f, -2.36335322e-02f, -3.39631103e-02f, 1.50670540e-02f, -3.59725729e-02f, 6.98110610e-02f, -7.48020485e-02f, 7.98954144e-02f,
  9.55484658e-02f, 7.76212066e-02f, 7.83250183e-02f, -2.90471409e-02f, 2.53063273e-02f, -7.08383396e-02f, -3.91924419e-02f, 7.65300095e-02f, -4.20575589e-03f, 6.27133995e-02f,
  -2.04925775e-03f, 1.64513458e-02f, -1.00758411e-01f, -4.28955220e-02f, -5.26354127e-02f, 2.24071797e-02f, -3.57854925e-02f, 7.63458014e-02f, 5.57697341e-02f, 8.59057717e-03f,
  5.55608841e-03f, -8.32918882e-02f, 3.25087160e-01f, 5.52698337e-02f, -2.34806109e-02f, 5.97835705e-02f, 1.67944789e-01f, 4.20920253e-02f, -1.80303827e-02f, -1.18464708e-01f,
  -9.70913917e-02f, -3.77402082e-02f, 7.02108815e-02f, 9.48277935e-02f, 8.29241872e-02f, 5.64283095e-02f, -4.87560444e-02f, -1.27861835e-02f, 4.80660461e-02f, 5.02603129e-02f,
  3.18990499e-02f, -1.64092973e-01f, 1.36435971e-01f, -2.28655040e-01f, -6.28719032e-02f, -3.29796486e-02f, -8.80508721e-02f, 7.89469928e-02f, 6.45639980e-03f, -3.83685157e-02f,
  1.85642578e-02f, 3.77697945e-02f, -3.95392952e-03f, 2.62979586e-02f, 2.58708186e-02f, -3.03692147e-02f, 3.25383618e-03f, -3.29905115e-02f, 4.24515903e-02f, -3.41989845e-02f,
  2.95611192e-02f, -7.95210525e-02f, 5.97245544e-02f, -8.02789405e-02f, -6.93034753e-02f, -6.34679943e-02f, -1.30625218e-02f, 1.28818333e-01f, -9.45966225e-03f, 1.00289956e-01f,
  2.99693458e-02f, 1.06457822e-01f, 7.26283714e-02f, 6.46518469e-02f, 1.16986796e-01f, 3.63517180e-02f, 5.07269762e-02f, 3.96549031e-02f, -3.80862318e-02f, -9.35405400e-03f,
  1.66235864e-02f, 3.75443548e-02f, 7.22006187e-02f, 3.85419056e-02f, 7.70108402e-02f, -3.14543468e-05f, 1.85816512e-02f, 6.38689995e-02f, 2.18750834e-02f, 6.24849200e-02f,
  4.47467007e-02f, -1.03693279e-02f, -3.56183723e-02f, 1.20475898e-02f, -5.16321696e-02f, -5.70039377e-02f, -4.92826365e-02f, 6.11706777e-03f, -6.63382374e-03f, 2.39008479e-02f,
  -4.33739368e-03f, 8.04618597e-02f, -5.13126291e-02f, 6.26644567e-02f, -9.07166228e-02f, 8.63905400e-02f, 7.85987526e-02f, -3.23512740e-02f, -3.37250270e-02f, 3.52685936e-02f,
  -9.35695618e-02f, -1.80429935e-01f, -4.11442183e-02f, -8.15803781e-02f, -9.49387476e-02f, -1.63933157e-03f, -6.85598478e-02f, 2.99352184e-02f, 4.20396402e-02f, -1.90577544e-02f,
  4.03535888e-02f, -6.52998835e-02f, -3.14338952e-02f, 7.75032341e-02f, -6.11600094e-03f, -1.88558903e-02f, 3.39128152e-02f, -4.88032252e-02f, -1.10602137e-02f, -6.73198402e-02f,
  -2.17942242e-02f, -7.12620616e-02f, 8.03136751e-02f, -7.89449885e-02f, 4.21855180e-03f, -6.75108805e-02f, -8.24065581e-02f, 5.63334674e-02f, -8.82677361e-02f, -3.41249518e-02f,
  2.22234726e-01f, 3.46070305e-02f, 5.88210635e-02f, 1.36691332e-01f, -6.98349923e-02f, -2.18895048e-01f, -2.24564761e-01f, 1.85142364e-02f, 1.75991729e-01f, -1.02652781e-01f,
  -1.44865826e-01f, 2.25571051e-01f, -1.56459972e-01f, -3.57038043e-02f, 9.70262196e-03f, -4.24301736e-02f, -2.60852631e-02f, 3.85292955e-02f, 1.42729998e-01f, -1.33506447e-01f,
  1.87123306e-02f, -2.26744726e-01f, -1.92151237e-02f, -2.06868231e-01f, 4.76615364e-03f, 3.07218321e-02f, -1.33919686e-01f, -1.66594401e-01f, -9.93818343e-02f, 3.50907110e-02f,
  -1.38646871e-01f, -3.27672660e-02f, -6.55074650e-03f, 7.35553168e-03f, -1.62986685e-02f, 7.92868510e-02f, -6.50416240e-02f, 2.12501176e-02f, 6.47171959e-03f, -3.50149572e-02f,
  -3.12211346e-02f, 6.08285293e-02f, -7.83074088e-03f, -7.00819120e-02f, -1.77750345e-02f, 2.09246706e-02f, 8.24298263e-02f, 1.04065932e-01f, -1.40378540e-02f, 5.20206764e-02f,
  5.07462621e-02f, -4.33983691e-02f, 6.37201294e-02f, 7.29604959e-02f, 9.47456583e-02f, -4.09521498e-02f, 1.04218587e-01f, 7.78867826e-02f, 6.04049303e-02f, -4.72465046e-02f,
  -3.79557461e-02f, -2.61094216e-02f, -9.94781703e-02f, 3.27184759e-02f, -3.93039323e-02f, 3.44312238e-03f, -3.15533653e-02f, 6.80669257e-03f, 3.03476527e-02f, -6.59600869e-02f,
  3.06748990e-02f, 3.71647179e-02f, -2.31585596e-02f, -1.92047711e-02f, 6.12482131e-02f, 4.94931154e-02f, -3.19867544e-02f, 7.11311325e-02f, -4.46154997e-02f, 9.80397165e-02f,
  2.09088456e-02f, -5.56355827e-02f, 7.41126537e-02f, -9.43191499e-02f, 1.17662875e-02f, 1.87112466e-02f, 1.96395256e-02f, 7.92311877e-02f, -1.56296045e-02f, -8.54805112e-02f,
  -1.97949618e-01f, -5.56196161e-02f, -1.20126851e-01f, -4.19819430e-02f, -4.82170358e-02f, -3.72801311e-02f, 2.47715712e-02f, 7.99159259e-02f, -2.41704416e-02f, -7.17609748e-02f,
  -1.81225128e-02f, 6.18021414e-02f, -6.23298399e-02f, -6.45710249e-03f, -9.13913921e-02f, 5.22338487e-02f, -7.50465840e-02f, -5.84790669e-02f, 3.07510514e-02f, 4.45255116e-02f,
  -6.07730635e-02f, 5.36410399e-02f, -3.98243554e-02f, -4.31022234e-02f, 2.56082555e-03f, -6.51735738e-02f, -1.13415178e-02f, 1.39756752e-02f, -6.74390569e-02f, 7.65043423e-02f,
  -7.97003210e-02f, -8.88715126e-03f, 1.70738965e-01f, -8.98682512e-03f, -5.90811782e-02f, 1.90925092e-01f, 9.27667543e-02f, -4.68420088e-02f, -9.14773121e-02f, -1.03072301e-01f,
  -8.61508399e-02f, 6.79520071e-02f, 1.68930203e-01f, -1.06868364e-01f, 1.90769345e-01f, 2.18852878e-01f, 5.59110232e-02f, 8.68058130e-02f, -2.79715452e-02f, -4.34998907e-02f,
  -6.13390394e-02f, -2.91292984e-02f, 3.30368802e-02f, -5.35224415e-02f, -1.49682560e-03f, -1.68544486e-01f, -7.72613138e-02f, 1.29366457e-01f, -1.66242197e-02f, -4.73824255e-02f,
  -3.49941030e-02f, -1.51020646e-01f, 8.92096609e-02f, 1.09701529e-01f, 3.13252327e-03f, -4.98813689e-02f, 7.32834637e-02f, 8.38602185e-02f, -5.06099612e-02f, -8.71757343e-02f,
  -3.32850032e-02f, -6.31671175e-02f, -5.78878075e-02f, -2.51222327e-02f, 2.95666680e-02f, -3.98713015e-02f, -5.60561307e-02f, -1.07133865e-01f, -3.41838114e-02f, 4.36771289e-02f,
  9.05864537e-02f, -7.00706095e-02f, 7.76320547e-02f, 3.88671793e-02f, -4.12536971e-02f, -5.29781589e-03f, 1.70580344e-03f, 1.94774214e-02f, -2.42181476e-02f, -3.98527505e-03f,
  5.32633364e-02f, 3.46924029e-02f, -4.62860726e-02f, -1.25382440e-02f, -4.42973450e-02f, -2.55174134e-02f, 7.91938230e-02f, -5.62894084e-02f, -4.14176397e-02f, 2.49833092e-02f,
  6.39374852e-02f, 2.81766560e-02f, 1.35802832e-02f, 5.28837070e-02f, 7.57534849e-03f, -9.38008875e-02f, 6.76648170e-02f, -9.48553681e-02f, -6.03887998e-02f, -4.67451196e-03f,
  3.02609522e-03f, -6.00072257e-02f, -5.02802953e-02f, -2.59310380e-02f, 8.67836103e-02f, 5.22661209e-02f, -3.93181480e-02f, 4.67453152e-02f, 7.36422241e-02f, -5.44813238e-02f,
  -1.86160505e-02f, 7.94093031e-03f, 8.51291791e-02f, -5.44102266e-02f, 5.87599017e-02f, -6.01680316e-02f, 1.03526585e-01f, 4.51036766e-02f, -6.75242469e-02f, 3.67209390e-02f,
  -4.02216502e-02f, 5.08348979e-02f, -1.09688072e-02f, 3.90927978e-02f, 1.18994936e-02f, -8.85389820e-02f, -2.17871405e-02f, -1.09843453e-02f, -4.49656360e-02f, -1.17367404e-02f,
  -7.48382835e-03f, 8.05892646e-02f, -8.17125365e-02f, -6.57861754e-02f, -2.56721079e-02f, 5.42474426e-02f, 4.37331088e-02f, 4.85273497e-03f, -6.98391497e-02f, 1.12194277e-01f,
  4.44299802e-02f, -1.31519243e-01f, 1.39390334e-01f, -5.65470569e-02f, -6.51883334e-02f, -8.73768106e-02f, -9.81646329e-02f, -6.01908239e-03f, -8.14296529e-02f, -1.85405955e-01f,
  -8.97396505e-02f, 1.48916706e-01f, 2.03114022e-02f, -1.43847778e-01f, 8.36437419e-02f, 7.70597532e-02f, -1.86154261e-01f, -1.09002605e-01f, -8.63506198e-02f, -7.02324510e-02f,
  -4.38012891e-02f, -1.55948162e-01f, -2.90963612e-02f, -1.49529785e-01f, -1.38089970e-01f, -1.17400497e-01f, 2.05163974e-02f, 2.37103887e-02f, -4.90709022e-02f, 8.79801661e-02f,
  3.36349085e-02f, 1.43097909e-02f, -1.78338494e-02f, 3.45771573e-02f, -4.89520207e-02f, -5.00194728e-02f, 3.89309265e-02f, -1.08238254e-02f, 7.33181536e-02f, -1.32313315e-02f,
  -4.95409546e-03f, 4.83490974e-02f, -1.01188608e-01f, -4.35046144e-02f, -2.20923666e-02f, -3.80123816e-02f, -1.06769754e-02f, -4.15734239e-02f, -2.94754654e-02f, -1.78321004e-02f,
  5.52955724e-04f, -8.85637943e-03f, 1.88943353e-02f, 4.54209708e-02f, -2.34140735e-02f, 8.30308814e-03f, 7.11673647e-02f, -4.07528393e-02f, -2.80314195e-03f, 2.38616485e-02f,
  3.80339958e-02f, -2.69528367e-02f, -1.00050531e-01f, -5.03384916e-04f, -5.82633261e-03f, 3.50210480e-02f, 5.90745099e-02f, 4.08889937e-05f, -1.43659674e-02f, 6.56789020e-02f,
  2.46122982e-02f, -3.44650149e-02f, -6.31039888e-02f, -5.76964356e-02f, 6.67426661e-02f, 7.42266476e-02f, -5.25615811e-02f, 7.76429549e-02f, 4.09029126e-02f, 5.58803382e-04f,
  7.68228695e-02f, -6.38538087e-03f, 5.96026257e-02f, 6.07729554e-02f, 4.18029055e-02f, -6.90498799e-02f, -4.10510972e-02f, -6.95124567e-02f, -8.54118075e-03f, 4.35274187e-03f,
  -4.19317596e-02f, -1.06419943e-01f, 3.25824693e-02f, -8.84522945e-02f, -1.25311678e-02f, -5.05707040e-02f, -7.77973235e-03f, -9.43705663e-02f, -9.16722044e-02f, -6.86199963e-02f,
  -2.69087274e-02f, 4.98269461e-02f, -6.10164553e-02f, -4.90809269e-02f, 7.24099576e-02f, -6.82998970e-02f, 4.18469347e-02f, 7.51411617e-02f, 4.39113528e-02f, 3.55624855e-02f,
  5.02836183e-02f, -8.69611353e-02f, 9.28680971e-02f, -1.12221893e-02f, 3.70619968e-02f, -2.91971508e-02f, 4.51450236e-02f, 2.73770373e-02f, 4.04471122e-02f, 5.21212481e-02f,
  -1.00334413e-01f, 1.06603868e-01f, -1.11863181e-01f, 1.43810853e-01f, -1.88738838e-01f, 1.75711274e-01f, 2.34849676e-01f, 2.93677188e-02f, 2.73582041e-02f, 2.85054743e-01f,
  1.17612906e-01f, -5.09269349e-02f, 1.50331497e-01f, 3.07387054e-01f, 3.85200903e-02f, 2.23468944e-01f, 2.95337021e-01f, 1.86626837e-01f, -8.12368467e-02f, 4.96541942e-03f,
  -7.30998367e-02f, 1.72733590e-01f, 8.35653841e-02f, 2.86476072e-02f, -6.22836165e-02f, -1.05718501e-01f, 2.12304690e-03f, -1.56831414e-01f, -2.56984904e-02f, -9.39832628e-03f,
  6.56546876e-02f, 1.14330566e-02f, 5.76371923e-02f, -9.38191041e-02f, -2.45997813e-02f, 3.57221104e-02f, -2.05420461e-02f, -1.16313927e-01f, -7.21330494e-02f, 1.26210069e-02f,
  5.75239509e-02f, 5.92256077e-02f, 5.89472838e-02f, 4.03571920e-03f, -6.56715967e-03f, -8.37253407e-02f, 1.00077521e-02f, 5.97306415e-02f, 5.75966202e-02f, -1.08910099e-01f,
  -4.74707186e-02f, -5.47545329e-02f, 4.30928655e-02f, 3.00207157e-02f, -1.17128961e-01f, 2.10127700e-02f, 1.03921004e-01f, 5.40145207e-03f, -5.59188798e-02f, -5.29187955e-02f,
  1.78088229e-02f, -5.66246659e-02f, -7.13401381e-03f, 8.24203193e-02f, 4.61521558e-02f, 3.70499454e-02f, 9.22504067e-02f, 8.02495554e-02f, 2.54645124e-02f, 8.66024494e-02f,
  -2.81594079e-02f, 2.25143544e-02f, 4.02391031e-02f, 2.46507451e-02f, 1.02390528e-01f, 3.72646451e-02f, -8.41374323e-02f, -7.68658072e-02f, -4.04729834e-03f, -3.72041687e-02f,
  -8.53030980e-02f, 2.69256923e-02f, 8.08449741e-03f, -3.09802517e-02f, 2.69504637e-02f, -1.46998456e-02f, 7.55116343e-02f, 6.70477450e-02f, 1.07618392e-01f, -6.67140335e-02f,
  4.18690518e-02f, -9.78803262e-04f, 1.79826263e-02f, -5.52993007e-02f, 1.30362157e-02f, -8.13064426e-02f, -3.91812213e-02f, -8.33107457e-02f, 2.89062932e-02f, -3.10175903e-02f,
  -4.06771945e-03f, -6.58501387e-02f, 5.24553731e-02f, -3.19156125e-02f, -4.00481708e-02f, 1.03283055e-01f, 1.29875034e-01f, 3.37401815e-02f, -3.38162817e-02f, 4.26888540e-02f,
  -6.45241886e-02f, -4.55935448e-02f, -2.51658056e-02f, 1.40927862e-02f, 4.77025807e-02f, 7.57555366e-02f, 5.92493862e-02f, -6.32071942e-02f, -2.37040669e-02f, -4.30343933e-02f,
  -1.64969712e-02f, -1.28337562e-01f, -5.84532041e-04f, 1.89429611e-01f, 2.48399377e-02f, 6.57186210e-02f, -8.05121064e-02f, -4.84677106e-02f, 1.22282907e-01f, -6.63029999e-02f,
  -4.02759202e-02f, -1.03258826e-01f, -2.37092018e-01f, 1.19773418e-01f, 1.33232415e-01f, -9.22941193e-02f, 1.48449376e-01f, 6.67995811e-02f, 1.06327720e-01f, 1.54022314e-02f,
  -3.17483582e-03f, 6.61883950e-02f, -7.37868026e-02f, -1.47577785e-02f, 5.11271246e-02f, 7.83703923e-02f, 5.92932515e-02f, 3.30582708e-02f, 8.07773396e-02f, 3.51545140e-02f,
  -2.70758551e-02f, 7.82751665e-02f, 7.20788985e-02f, 1.32657296e-04f, -6.06434830e-02f, -1.61260180e-02f, -8.84529576e-02f, 4.06276509e-02f, -3.54343839e-02f, 1.52586484e-02f,
  2.27084700e-02f, 3.83744761e-02f, -2.23178342e-02f, 6.15061745e-02f, 5.06399870e-02f, -2.13674679e-02f, -4.01898809e-02f, -5.37749641e-02f, -3.84953432e-02f, -5.08826673e-02f,
  -3.88670643e-03f, -3.90163921e-02f, 8.25915858e-03f, -5.14380448e-02f, -1.63256992e-02f, -5.37080951e-02f, 6.49302974e-02f, -6.04901016e-02f, 8.93862695e-02f, 5.56493513e-02f,
  3.98707725e-02f, 4.33234572e-02f, -2.71163043e-03f, -9.48173180e-03f, -5.41258976e-02f, -4.73068245e-02f, -7.35484883e-02f, 7.51814172e-02f, 1.88557431e-02f, 5.77811822e-02f,
  9.65721086e-02f, -5.40482812e-02f, -3.54524106e-02f, -1.98049936e-02f, -6.47772104e-02f, 4.21571024e-02f, -4.18634303e-02f, 8.22170824e-02f, 6.07913099e-02f, -2.62010004e-02f,
  4.37752604e-02f, 7.97537267e-02f, 7.56203905e-02f, -6.95874840e-02f, 4.99998145e-02f, -8.48185271e-02f, -3.05696763e-02f, -5.21883294e-02f, -3.19927745e-02f, 8.36175028e-03f,
  -5.74316382e-02f, -1.52094692e-01f, 4.74423841e-02f, -9.00287703e-02f, -9.80509445e-02f, -2.89987624e-02f, 7.77223781e-02f, 3.28624956e-02f, -1.08112551e-01f, 2.03198772e-02f,
  -3.14879268e-02f, -1.44385435e-02f, 2.03405377e-02f, 7.48944208e-02f, -4.96258587e-02f, -1.92032158e-02f, 1.29596777e-02f, -5.33815175e-02f, -1.56655423e-02f, -1.00936167e-01f,
  3.19410004e-02f, -2.62315664e-02f, -2.53666770e-02f, 3.57780494e-02f, 6.63392022e-02f, -1.73782706e-02f, 8.28118399e-02f, -5.12575582e-02f, -6.65756986e-02f, 1.83406044e-02f,
  -1.13164067e-01f, -5.76930903e-02f, 1.04556076e-01f, -6.20595403e-02f, 1.43542036e-01f, 2.55476311e-02f, -1.07928447e-01f, 1.02548636e-01f, -1.11726023e-01f, -1.11745656e-01f,
  -6.21703006e-02f, -1.02301098e-01f, 5.65327853e-02f, -1.08246654e-01f, 2.38931384e-02f, 3.45567688e-02f, -5.61974645e-02f, -8.02632645e-02f, 1.15366578e-01f, -4.37414870e-02f,
  1.50132060e-01f, -7.08928481e-02f, 1.10572882e-01f, 9.67634618e-02f, -4.79265936e-02f, 8.91476274e-02f, 1.53761720e-02f, 1.45995021e-01f, -5.67789786e-02f, 6.71391487e-02f,
  9.94281843e-02f, -3.83864567e-02f, -2.99778562e-02f, 1.98402666e-02f, 6.37038574e-02f, 6.55947998e-02f, -3.31851467e-02f, -2.44935304e-02f, 9.23755113e-03f, -1.65740550e-02f,
  -6.34775311e-02f, -7.05279224e-03f, -1.85443033e-02f, -2.60894727e-02f, -2.68490743e-02f, -2.86926534e-02f, 6.03174008e-02f, 9.93700176e-02f, 3.50636207e-02f, 6.76078200e-02f,
  9.54449549e-02f, -9.91138145e-02f, 9.18776691e-02f, 2.52501424e-02f, 9.06653926e-02f, 2.26865741e-05f, -5.54393306e-02f, -9.98859033e-02f, 1.03088152e-02f, 5.01992814e-02f,
  3.52634788e-02f, -8.48748684e-02f, -1.36433467e-01f, 6.42296597e-02f, -1.03425376e-01f, -4.94793877e-02f, -6.05513044e-02f, -6.07684664e-02f, -6.69814497e-02f, -7.89482221e-02f,
  -6.80751801e-02f, -1.32536869e-02f, 1.56897139e-02f, -5.40978871e-02f, 6.25105202e-02f, -7.17572346e-02f, -7.24547962e-03f, 7.45556056e-02f, -1.37553802e-02f, 7.90146738e-02f,
  -7.89178237e-02f, 2.11669095e-02f, -1.00246994e-02f, -6.08415306e-02f, -4.56352979e-02f, -9.16934758e-02f, -9.95317325e-02f, -8.87096748e-02f, -4.40003574e-02f, 6.36697635e-02f,
  7.74917901e-02f, -4.16488610e-02f, -7.07825646e-02f, 3.70942988e-02f, -2.48820428e-02f, 4.25504632e-02f, 4.61214148e-02f, 9.23109800e-02f, -8.54483768e-02f, -9.23801288e-02f,
  -4.79746945e-02f, -9.09449905e-02f, -8.23620483e-02f, 2.52910447e-03f, -2.03189868e-02f, -3.02959494e-02f, -1.11600216e-02f, -8.54478851e-02f, 6.39485121e-02f, -2.23371349e-02f,
  -1.04874082e-01f, -7.91822150e-02f, -2.50305887e-02f, 3.87879685e-02f, 5.20576574e-02f, -3.74557711e-02f, -4.83557023e-02f, -8.19855928e-02f, -7.83852860e-03f, 2.73429137e-03f,
  4.78511676e-02f, 1.49655938e-01f, 6.36265241e-03f, 1.27208186e-03f, 6.70280308e-02f, -2.29383960e-01f, -1.50755331e-01f, 8.12316164e-02f, 4.70894091e-02f, 3.35175283e-02f,
  1.59498230e-01f, 1.89449172e-02f, 9.86689702e-02f, -7.41972253e-02f, -1.10317625e-01f, -3.80876809e-02f, -8.03733021e-02f, -6.52404651e-02f, -8.01802278e-02f, 5.80829382e-02f,
  -1.48971640e-02f, 1.94551170e-01f, -6.90542683e-02f, 2.44931746e-02f, -6.41217036e-03f, 1.11129321e-01f, 1.09603062e-01f, 9.82021466e-02f, -1.99965313e-02f, 3.70186418e-02f,
  -3.99427116e-02f, 4.98061962e-02f, 5.98954558e-02f, 2.66451649e-02f, -8.14664364e-02f, -9.71863940e-02f, -9.47734118e-02f, -5.82592338e-02f, 6.55432865e-02f, -5.76259345e-02f,
  -3.93544473e-02f, 7.34439772e-03f, 3.55030783e-02f, -5.45412190e-02f, 2.51745172e-02f, -8.32268521e-02f, -2.44952627e-02f, 6.02896977e-03f, -1.50662325e-02f, -6.98033422e-02f,
  6.27218857e-02f, -3.77217643e-02f, 2.00333241e-02f, -6.40099049e-02f, 8.40210244e-02f, 3.81913520e-02f, 1.79684088e-02f, -1.90273672e-02f, 7.39659071e-02f, 6.63945377e-02f,
  1.33063599e-01f, -1.12878352e-01f, -3.41039635e-02f, 5.10612465e-02f, 3.75635363e-02f, -4.31377180e-02f, 7.86041468e-02f, -7.94648007e-03f, -1.15244826e-02f, 2.69499514e-02f,
  -3.52172479e-02f, 3.93471494e-02f, 7.67340362e-02f, -7.40320161e-02f, -1.24669401e-02f, -5.62806726e-02f, -3.06655746e-02f, -4.30959202e-02f, 2.76737730e-03f, 5.38517199e-02f,
  -4.45995964e-02f, 7.78629035e-02f, 3.75529081e-02f, 3.34584750e-02f, -1.20684206e-02f, 8.26950520e-02f, 4.24410291e-02f, 5.95709607e-02f, 7.32506439e-02f, -5.08061610e-02f,
  -1.52205983e-02f, 2.15407163e-01f, -2.15375256e-02f, 3.51639986e-02f, -3.35051417e-02f, -3.38552929e-02f, -7.27548674e-02f, 8.73842463e-02f, -5.45144081e-02f, 8.10875818e-02f,
  4.06845426e-03f, -5.57734352e-03f, -4.10344601e-02f, 8.36759806e-03f, 3.87306185e-03f, 1.08633809e-01f, 1.15602672e-01f, 2.98555233e-02f, 8.31228942e-02f, 2.51994357e-02f,
  6.84281513e-02f, 1.52210733e-02f, -6.34589344e-02f, 9.17446911e-02f, -7.47311264e-02f, 6.66503534e-02f, 3.23900767e-02f, -1.62860379e-02f, 5.48441820e-02f, 4.44338955e-02f,
  -4.47785705e-02f, 1.44066498e-01f, 2.18063146e-01f, -1.83067381e-01f, 5.46994759e-03f, 1.18451327e-01f, 4.51997900e-03f, 1.40138611e-01f, 5.38872816e-02f, 1.63257252e-02f,
  7.22505851e-03f, -1.61269486e-01f, 5.44690751e-02f, -4.44051586e-02f, 5.78069054e-02f, -3.28007936e-02f, 4.10658456e-02f, -2.78244726e-02f, 3.32866274e-02f, -1.60016537e-01f,
  -5.89890890e-02f, -1.85210273e-01f, 8.72980654e-02f, 7.60014262e-03f, -2.72751618e-02f, 1.11889718e-02f, -1.41658992e-01f, 1.20993489e-02f, -1.12503089e-01f, -3.19267176e-02f,
  2.93952711e-02f, 7.04782009e-02f, 8.49359334e-02f, 1.08871840e-01f, -1.15164500e-02f, 9.45767481e-03f, 3.52138840e-02f, -1.83913205e-02f, 5.30544892e-02f, -2.88172578e-03f,
  1.36985546e-02f, -8.33434463e-02f, -8.13734829e-02f, 6.80961087e-02f, 2.98530702e-02f, -7.89170805e-03f, -3.90360132e-02f, 9.20299143e-02f, 8.41147825e-02f, 1.11484639e-01f,
  1.07466228e-01f, 2.83962861e-02f, -8.12285021e-02f, -1.21949203e-01f, -5.08031622e-02f, 2.03718580e-02f, -1.62582602e-02f, 6.22712635e-02f, -4.77901436e-02f, -6.34537563e-02f,
  -2.42589936e-02f, -1.19545003e-02f, -1.26838293e-02f, 5.35426736e-02f, -2.33062226e-02f, -4.06369613e-03f, -6.97350129e-02f, 8.81983712e-02f, 1.88969523e-02f, -3.56142707e-02f,
  3.77939604e-02f, 2.70069949e-02f, -3.16353142e-03f, 1.15635758e-02f, -5.91051802e-02f, 3.38543802e-02f, -5.83144017e-02f, -2.67714821e-02f, 4.69894446e-02f, 1.60160493e-02f,
  1.76546313e-02f, 5.22964709e-02f, 8.21544304e-02f, 3.10475174e-02f, 3.82402213e-03f, -1.11351227e-02f, -8.95755067e-02f, 8.08743834e-02f, 9.06781182e-02f, -8.66977647e-02f,
  1.12499744e-01f, -1.40051007e-01f, 6.90329671e-02f, 9.95019078e-02f, 3.44382636e-02f, 5.99326231e-02f, -7.76438192e-02f, 4.06590477e-02f, -2.84915213e-02f, -2.50572916e-02f,
  -8.74755234e-02f, -6.42171428e-02f, -7.35081546e-03f, -1.03104509e-01f, -3.68745923e-02f, 9.90259089e-03f, 1.12243937e-02f, -1.98397459e-03f, -3.02262008e-02f, -1.14292437e-02f,
  3.25282328e-02f, 4.13613170e-02f, -2.88721807e-02f, 1.59590840e-02f, -1.56586654e-02f, 3.45764086e-02f, -1.21193072e-02f, 8.42129588e-02f, -9.81746316e-02f, -9.02134459e-03f,
  1.50271878e-01f, 5.67858219e-02f, 6.91984743e-02f, 7.14422762e-02f, -1.23084836e-01f, -3.87294255e-02f, 5.24487644e-02f, 2.41221767e-02f, -1.58096388e-01f, -7.23460573e-04f,
  -3.70483622e-02f, 8.08427036e-02f, -1.66590065e-01f, 8.38388279e-02f, -7.26749897e-02f, -3.03629078e-02f, 7.37307370e-02f, 1.20896839e-01f, -1.19881615e-01f, 9.01774094e-02f,
  6.65697530e-02f, -7.13782758e-02f, -8.27857479e-02f, 6.80093840e-02f, 7.46322516e-03f, 1.71173647e-01f, 2.40496937e-02f, -4.31668386e-02f, 1.90250292e-01f, 6.15889579e-02f,
  8.37119818e-02f, -3.40716131e-02f, -1.54653555e-02f, -2.70840991e-02f, 4.44768965e-02f, -2.72853449e-02f, -1.30907837e-02f, -7.78954178e-02f, 9.46657211e-02f, 3.54295713e-04f,
  5.21375500e-02f, 4.95894440e-02f, -9.10240971e-03f, -1.11384936e-01f, 9.15294886e-02f, 4.26678695e-02f, -5.97998388e-02f, -6.96239248e-02f, 9.55017656e-02f, 7.14513063e-02f,
  9.82559249e-02f, 7.99622536e-02f, -1.96505636e-02f, -2.19077263e-02f, 7.37044215e-02f, -8.00192058e-02f, -1.04855914e-02f, 1.12723343e-01f, 6.05410449e-02f, 3.90127413e-02f,
  -1.34129860e-02f, -7.19124153e-02f, -6.51050964e-03f, -5.81114367e-02f, -9.65713561e-02f, -4.94772866e-02f, 5.55478074e-02f, -3.16090919e-02f, 3.64515781e-02f, -6.72986582e-02f,
  1.00181162e-01f, 6.52724355e-02f, 1.38407033e-02f, -1.96550577e-03f, -1.01238973e-02f, 5.48280701e-02f, 7.35346153e-02f, 6.28138985e-03f, -7.94404820e-02f, -4.97226976e-02f,
  3.34232599e-02f, -3.57668884e-02f, 6.14017108e-03f, 7.46360496e-02f, -5.10830432e-03f, 4.95906211e-02f, 2.07772125e-02f, 4.55801338e-02f, -1.71296801e-02f, -6.52973726e-02f,
  -1.97691489e-02f, 7.40864407e-03f, -5.20699695e-02f, -5.50281592e-02f, 9.12903994e-02f, 1.40941655e-02f, -1.30167017e-02f, 8.29380378e-02f, 1.04812108e-01f, -2.73616128e-02f,
  -2.08385047e-02f, 3.71598415e-02f, 2.18853587e-03f, 6.90600425e-02f, 5.47264740e-02f, 6.30906224e-02f, -5.23742996e-02f, -7.17615709e-02f, -2.80138515e-02f, 8.62870365e-02f,
  -6.57087192e-02f, -6.68958127e-02f, -4.70438600e-02f, 1.89663321e-02f, -6.55662045e-02f, -6.58872128e-02f, 1.04687653e-01f, -5.67312464e-02f, 4.32124585e-02f, 4.33786064e-02f,
  2.05918014e-01f, -2.03133866e-01f, -8.17063972e-02f, 1.51163623e-01f, 2.04680935e-01f, -2.48875767e-02f, -2.92139165e-02f, 1.33413374e-01f, 2.68977255e-01f, 9.16911568e-03f,
  -3.38765644e-02f, -2.21536998e-02f, -2.53235340e-01f, -4.45064157e-02f, -1.33335590e-01f, -2.22578764e-01f, -1.63926091e-02f, -4.54554968e-02f, 1.03567228e-01f, -8.52625519e-02f,
  1.21561654e-01f, 4.34877537e-02f, -9.33976024e-02f, -3.72482417e-03f, 8.81482475e-03f, 3.82436812e-02f, -4.58364524e-02f, -1.33295193e-01f, 6.41804636e-02f, -1.20225899e-01f,
  -3.61572355e-02f, 1.27507731e-01f, 1.11695930e-01f, -3.11555676e-02f, -7.45324790e-03f, 1.00323856e-01f, -1.18150574e-03f, -2.95279939e-02f, -3.62662971e-02f, -6.15790337e-02f,
  2.68567279e-02f, 6.39195144e-02f, -2.83970367e-02f, -8.37116167e-02f, -7.45002227e-03f, -2.47473344e-02f, -2.63539348e-02f, -3.32172960e-02f, 9.80140269e-02f, 1.69408806e-02f,
  7.82665163e-02f, -3.10384445e-02f, 1.25034720e-01f, -9.61069539e-02f, 7.71395266e-02f, 5.37411533e-02f, -7.72329494e-02f, -1.14366263e-01f, -6.85473233e-02f, 2.21761838e-02f,
  3.22108343e-02f, 1.98818371e-02f, -1.96163263e-02f, -3.72585468e-02f, -2.65335236e-02f, 6.24718778e-02f, 6.67606574e-03f, -2.75770389e-02f, -6.60792813e-02f, -6.52428791e-02f,
  6.85376441e-03f, 8.49908590e-02f, 8.51274505e-02f, -1.53156975e-02f, 4.85319346e-02f, 1.25985801e-01f, 2.00957414e-02f, -5.96003905e-02f, 1.36303958e-02f, 3.15161049e-02f,
  -7.06998035e-02f, 4.49232310e-02f, 6.82459921e-02f, 7.00406656e-02f, -9.54790786e-02f, 2.40267590e-02f, 7.16844201e-02f, -5.76849356e-02f, 8.34938139e-02f, -3.70952226e-02f,
  -2.70033590e-02f, -1.71148136e-01f, 1.04474844e-02f, 4.72402126e-02f, -1.00383237e-01f, -1.20831849e-02f, 1.46199921e-02f, -1.63337905e-02f, -5.62672168e-02f, -1.44434022e-02f,
  -7.24060237e-02f, -2.64587589e-02f, -4.69939671e-02f, 3.44239213e-02f, -6.53703213e-02f, 5.22151589e-03f, -7.06996992e-02f, 3.29629369e-02f, 2.54268423e-02f, -6.60633594e-02f,
  6.02877699e-03f, 4.09113476e-03f, 4.97223772e-02f, 3.05906963e-02f, 5.71291596e-02f, -2.78461929e-02f, 3.29742245e-02f, -8.46054479e-02f, -3.21584865e-02f, -8.02197978e-02f,
  1.33447230e-01f, -2.90620513e-02f, 1.24155253e-01f, -2.47100857e-03f, -1.20833479e-02f, 1.11167379e-01f, -3.13150436e-02f, 3.55444998e-02f, 8.52517709e-02f, -1.45432577e-01f,
  -7.85180181e-02f, -2.38208403e-03f, -1.79728016e-01f, 2.25252956e-02f, 4.63881791e-02f, -6.08423911e-02f, 7.25638866e-02f, -1.07381701e-01f, -1.07799368e-02f, 4.21604738e-02f,
  1.67799965e-02f, -1.28945056e-02f, 2.05980078e-03f, -2.64560264e-02f, -1.26246577e-02f, 4.60013747e-02f, -9.25848857e-02f, -8.25833436e-03f, -8.08357000e-02f, 4.75377142e-02f,
  -8.63566902e-03f, 7.57164955e-02f, 1.06973603e-01f, -4.43001464e-02f, 1.98730659e-02f, -3.78866717e-02f, -6.58060657e-03f, -2.40941066e-03f, -6.53832406e-02f, 4.52788696e-02f,
  -4.27821837e-02f, -7.94473365e-02f, 1.16445921e-01f, -6.84747025e-02f, 6.94829002e-02f, -8.36437661e-03f, 3.61954048e-02f, -4.31857742e-02f, -4.02896106e-02f, 7.09777847e-02f,
  -4.78308275e-02f, 3.08081452e-02f, 3.38618010e-02f, -5.41757196e-02f, -5.15124649e-02f, 1.99120678e-02f, 5.25712073e-02f, -8.64219368e-02f, -1.49183325e-03f, 2.91320365e-02f,
  -7.91791305e-02f, 6.37362003e-02f, 6.35820329e-02f, 6.16227230e-03f, -6.06329329e-02f, -8.24406892e-02f, 7.23779425e-02f, -6.62098778e-03f, 4.60348092e-02f, -5.93054108e-02f,
  -1.43628335e-02f, -2.38373713e-03f, 2.17902716e-02f, -7.10882843e-02f, -6.71535805e-02f, -7.10915476e-02f, 6.38747662e-02f, 1.79650355e-02f, -3.53290737e-02f, 1.04543984e-01f,
  6.00714162e-02f, 8.36939141e-02f, -3.87509055e-02f, -9.82186198e-02f, 2.05975771e-02f, -2.35985313e-02f, -8.91321898e-02f, -6.31198213e-02f, -8.82726833e-02f, 3.06753051e-02f,
  8.76833033e-03f, 1.71989091e-02f, 1.36914030e-02f, -5.61863557e-02f, -6.92134723e-02f, 3.52079310e-02f, -5.06321453e-02f, -5.71736023e-02f, -4.15881090e-02f, 2.10040435e-02f,
  -3.62419114e-02f, -7.91879296e-02f, 5.67027442e-02f, 7.02840760e-02f, -6.82660118e-02f, 5.07642468e-03f, 1.99886970e-02f, -9.09604412e-03f, 3.38072293e-02f, -1.18306000e-02f,
  -1.10509679e-01f, -9.23746303e-02f, -9.43537131e-02f, 1.14662610e-02f, 5.39696515e-02f, 4.54427786e-02f, 7.91557208e-02f, -5.33159897e-02f, 1.16216559e-02f, 4.35271002e-02f,
  -4.31587584e-02f, -8.50653574e-02f, -1.10803768e-01f, 2.92457752e-02f, 1.32395118e-01f, -1.63015038e-01f, 7.86679685e-02f, 8.32245722e-02f, 1.41924545e-01f, 7.06199482e-02f,
  1.16685942e-01f, -2.00087517e-01f, -5.40081561e-02f, -1.84083611e-01f, -3.49777848e-01f, -6.80627525e-02f, -1.75405875e-01f, -1.87709674e-01f, -8.95332769e-02f, 6.13799971e-03f,
  -2.31661759e-02f, -9.68649685e-02f, -1.93476260e-01f, 1.18713059e-01f, 9.11197737e-02f, 9.51018706e-02f, -3.41322236e-02f, 1.12410359e-01f, -2.50991601e-02f, -1.12577960e-01f,
  1.80024235e-03f, 7.85740372e-03f, -8.59322026e-03f, 7.29617774e-02f, -2.00691707e-02f, 1.13314077e-01f, -3.73379863e-03f, -1.01534747e-01f, -7.18712434e-02f, 4.02555019e-02f,
  1.70391649e-02f, -6.92502633e-02f, 3.59052755e-02f, 8.32630396e-02f, 5.24332263e-02f, -6.46005720e-02f, -1.86342769e-03f, 3.85076031e-02f, -1.01775806e-02f, -5.55008575e-02f,
  -2.39314120e-02f, -2.61910050e-03f, -3.04027740e-02f, -4.82770354e-02f, -6.21967502e-02f, -1.45526370e-02f, 2.15231720e-02f, -1.28342554e-01f, 6.92775100e-03f, -2.82339249e-02f,
  -8.23051259e-02f, 5.47653697e-02f, -6.97506294e-02f, -1.12623824e-02f, -1.73493684e-03f, 9.88015719e-03f, 6.40346408e-02f, -3.25049721e-02f, 9.04345065e-02f, -5.96005516e-03f,
  -4.09025550e-02f, 1.27036804e-02f, 5.75889573e-02f, -2.49364171e-02f, 3.50910611e-02f, -8.42546746e-02f, 5.65816415e-03f, -2.26510577e-02f, 5.01938984e-02f, -3.92712541e-02f,
  2.22812966e-02f, -3.92095409e-02f, -3.22801359e-02f, -2.30553225e-02f, -7.92808384e-02f, -6.27297387e-02f, 3.59913930e-02f, 5.36274128e-02f, 3.79248261e-02f, -7.55284727e-02f,
  7.25455359e-02f, -3.20876203e-02f, -1.99075770e-02f, 2.03310419e-02f, 5.64485230e-02f, -2.51405369e-02f, -6.63922429e-02f, -5.10779954e-03f, 1.19527904e-02f, -4.86335494e-02f,
  6.60234317e-03f, 1.71551649e-02f, 3.90151329e-02f, -3.50169055e-02f, 6.47842661e-02f, -5.07929400e-02f, 2.63231155e-02f, 6.19296208e-02f, -6.50328025e-02f, -2.27682497e-02f,
  -3.97566706e-02f, -1.68967005e-02f, 6.39827177e-02f, -2.19075568e-02f, 3.43119912e-02f, 2.13356726e-02f, 5.53755909e-02f, 4.27826075e-03f, 1.31774852e-02f, -8.84740129e-02f,
  -6.32098019e-02f, 8.97386577e-03f, -2.22181529e-01f, -1.59526139e-01f, -1.80740923e-01f, -1.79200396e-01f, -2.59426594e-01f, 4.65597659e-02f, -6.42330619e-03f, 5.99888451e-02f,
  -6.05062693e-02f, -2.77125966e-02f, 1.34407073e-01f, -1.63354635e-01f, -2.17439793e-02f, 1.87010601e-01f, -7.84294903e-02f, 1.69173069e-02f, 1.57510545e-02f, -1.10872835e-01f,
  -5.04008792e-02f, -8.38932469e-02f, -1.70289297e-02f, -2.27861609e-02f, -2.00630575e-01f, -3.28250066e-03f, 4.70958650e-03f, -4.94042560e-02f, -2.03953478e-02f, -2.04871297e-02f,
  4.19951640e-02f, 7.88083114e-03f, 2.32403213e-03f, 5.25128543e-02f, 1.34915225e-02f, -8.92025530e-02f, -8.81001130e-02f, -1.92779843e-02f, -8.11816826e-02f, -2.83440389e-02f,
  7.91190714e-02f, -1.16176410e-02f, -9.87314805e-02f, 4.69147507e-03f, -2.55877301e-02f, -6.23046421e-02f, -5.74215949e-02f, -3.27859074e-02f, -4.07428332e-02f, 1.34439766e-02f,
  -2.00286806e-02f, -3.19342539e-02f, 4.30637710e-02f, 1.06659167e-01f, -2.18792986e-02f, -3.46151218e-02f, 3.26381885e-02f, -4.56073917e-02f, 8.17691721e-03f, 2.29530204e-02f,
  -4.15746272e-02f, -6.93858564e-02f, -8.29451978e-02f, 5.48391864e-02f, 9.19539772e-04f, 9.90151148e-03f, 8.77423361e-02f, 1.84865501e-02f, 5.25897667e-02f, -7.72879422e-02f,
  4.82955612e-02f, -3.72624882e-02f, 9.93112847e-02f, -6.87140375e-02f, -7.44549036e-02f, 6.56877756e-02f, -9.82223079e-02f, -7.50159174e-02f, -4.54872586e-02f, 7.14548379e-02f,
  7.28745610e-02f, 2.72798333e-02f, -9.46463272e-03f, 9.01817977e-02f, 3.66398543e-02f, -5.85604757e-02f, -2.57913396e-02f, 3.18576135e-02f, -6.89592287e-02f, -4.68300506e-02f,
  -6.20298088e-02f, 1.32353783e-01f, 3.43515240e-02f, -8.22232962e-02f, -8.00298676e-02f, 1.00150369e-02f, -9.58655179e-02f, 5.70052415e-02f, 3.09275873e-02f, 3.46523374e-02f,
  -6.05407096e-02f, -1.76141672e-02f, 8.58101696e-02f, -6.76091984e-02f, -2.54714731e-02f, 6.21577306e-03f, 3.03207096e-02f, 8.95790979e-02f, 2.04043463e-02f, 5.07670939e-02f,
  -4.04408108e-03f, -7.26818740e-02f, 4.93400283e-02f, -2.00428721e-02f, -1.75743252e-02f, -2.50641187e-03f, 7.70790353e-02f, 8.08305889e-02f, 1.07082790e-02f, -2.02386808e-02f,
  -1.32632121e-01f, -1.73093840e-01f, -1.10830769e-01f, 4.39527519e-02f, 4.05274890e-03f, 1.14292808e-01f, 4.26463298e-02f, 9.92891437e-05f, -2.05817401e-01f, 1.42378584e-01f,
  -1.19382953e-02f, -9.87672210e-02f, -6.61526397e-02f, -7.27503076e-02f, -1.04361780e-01f, -1.45866305e-01f, -6.06580898e-02f, 4.72903289e-02f, -3.47157046e-02f, -8.03057328e-02f,
  -1.82175357e-02f, 8.82733017e-02f, -9.66997296e-02f, 1.17490940e-01f, 1.16035625e-01f, 1.56435013e-01f, 1.37798876e-01f, 6.59239441e-02f, 9.18520465e-02f, -2.71842908e-02f,
  1.05478965e-01f, -9.38226357e-02f, -1.23671312e-02f, -5.94937615e-02f, 9.60609987e-02f, 5.08890525e-02f, 7.89851472e-02f, -8.31695721e-02f, 3.01124267e-02f, 4.15753713e-03f,
  4.95330617e-02f, 4.40092571e-02f, 6.63173432e-03f, -9.98180881e-02f, -1.76625606e-02f, -7.17465999e-03f, -1.13247419e-02f, 6.73375428e-02f, 4.86887470e-02f, -9.03770793e-03f,
  -5.66430278e-02f, -9.23829712e-03f, 7.80330598e-02f, 3.60313654e-02f, 1.29247578e-02f, 3.98680940e-02f, -6.99359849e-02f, 5.73999360e-02f, -1.12563921e-02f, -9.88468677e-02f,
  -3.62258255e-02f, 4.23391461e-02f, 5.06081507e-02f, -3.54381092e-02f, -8.03368166e-02f, 3.27990465e-02f, -5.27973399e-02f, 7.28918463e-02f, -9.63993669e-02f, 1.42383212e-02f,
  -8.84619262e-03f, 1.55966477e-02f, 2.98034735e-02f, 6.21095039e-02f, -6.82745725e-02f, -2.38206214e-03f, 5.29841695e-04f, 3.05829737e-02f, 8.76862928e-02f, -3.17367502e-02f,
  -7.27291554e-02f, 4.44432870e-02f, 6.47750720e-02f, 8.27095956e-02f, -9.21299607e-02f, -5.04539441e-03f, 3.45947109e-02f, -3.48838158e-02f, -1.66572016e-02f, -2.51546036e-02f,
  -2.65794862e-02f, -6.85029849e-02f, -1.90199818e-02f, 7.56130666e-02f, 3.19651775e-02f, 6.68206587e-02f, -6.67673023e-03f, -7.37521425e-02f, -3.14687714e-02f, -1.10593520e-01f,
  6.71153516e-02f, 4.97739986e-02f, 9.65172201e-02f, -4.58005518e-02f, 2.94026788e-02f, -5.54016829e-02f, 5.96138127e-02f, -1.25892479e-02f, 3.48308459e-02f, 1.04308866e-01f,
  5.30486703e-02f, 9.61581767e-02f, 2.27890927e-02f, 3.60530838e-02f, 1.83482505e-02f, -3.97897959e-02f, 8.58860016e-02f, 6.86056614e-02f, -9.01180785e-03f, -8.58185254e-03f,
  2.28775349e-02f, -1.97768256e-01f, -1.44659325e-01f, -1.14336982e-01f, -3.85057069e-02f, -6.10035956e-02f, -4.96288724e-02f, -2.16656283e-01f, -1.01660623e-03f, -1.78190574e-01f,
  -1.09594733e-01f, -2.46624090e-02f, 5.29880114e-02f, -1.66037247e-01f, 9.72233191e-02f, 1.19245693e-01f, -1.65031463e-01f, -4.63786870e-02f, 5.75836748e-03f, -5.79339974e-02f,
  2.05180049e-02f, -9.27004367e-02f, -7.34694153e-02f, -1.01964347e-01f, -1.67348742e-01f, -1.01216316e-01f, 3.23578678e-02f, -4.95739952e-02f, -1.75293326e-01f, 3.86499353e-02f,
  4.69211489e-02f, 2.14442778e-02f, -2.70487275e-02f, -6.94450550e-03f, 3.05266101e-02f, 6.07885867e-02f, 9.48972907e-03f, 5.57161793e-02f, 5.14315329e-02f, 9.79318563e-03f,
  2.85080634e-02f, -6.79162610e-03f, -9.06838626e-02f, 3.12742852e-02f, -1.01227388e-01f, -7.77096972e-02f, -4.94519547e-02f, -9.23256427e-02f, 5.79897426e-02f, -2.11595464e-03f,
  2.78294203e-03f, -7.35039860e-02f, 4.54350933e-02f, -5.98843843e-02f, -4.57770899e-02f, 2.04899516e-02f, -6.29290789e-02f, -4.71858345e-02f, -8.23134370e-03f, -4.25183512e-02f,
  5.54690696e-02f, 5.71121573e-02f, 2.45196633e-02f, 8.37916434e-02f, 3.22498344e-02f, -3.22867222e-02f, -7.19050020e-02f, 1.53383007e-02f, -4.00525369e-02f, -5.37736937e-02f,
  6.30837772e-03f, 7.50378370e-02f, -5.72597906e-02f, 5.86477108e-02f, -2.85972785e-02f, -5.12172468e-02f, -1.11185294e-02f, 6.69830572e-03f, -3.82110737e-02f, -1.19425155e-01f,
  2.05763076e-02f, -1.10711418e-02f, -7.60915428e-02f, 2.63930876e-02f, 6.70515373e-02f, -4.58548442e-02f, -3.91909108e-02f, -3.57151292e-02f, -4.09521861e-03f, -3.85759175e-02f,
  -7.01365098e-02f, -1.06573686e-01f, -1.01064362e-01f, 4.38815281e-02f, -7.29124993e-02f, -1.06164701e-01f, -4.88289855e-02f, 5.18047176e-02f, 2.05168743e-02f, 6.73776492e-02f,
  -9.26614273e-03f, 7.25593045e-02f, -3.54913659e-02f, 6.36166260e-02f, 2.65878439e-03f, 3.99101675e-02f, -5.78414872e-02f, 6.65470362e-02f, -9.02117323e-03f, 4.62969206e-03f,
  3.72879021e-02f, -2.62183975e-02f, -8.70947074e-03f, 7.38587901e-02f, -2.32505333e-02f, -4.28208038e-02f, 3.28449532e-02f, 9.14303139e-02f, -1.17722386e-02f, -1.31643927e-02f,
  6.93262219e-02f, -5.74362166e-02f, -3.81776132e-02f, 1.57299966e-01f, 8.41001347e-02f, 4.14746217e-02f, 4.20160592e-02f, 1.55272976e-01f, 1.29380003e-01f, -3.30267400e-02f,
  9.03945342e-02f, -6.03889935e-02f, -1.75779238e-01f, 1.44045427e-01f, 1.97437584e-01f, 1.03409804e-01f, 1.13246776e-01f, -4.16684747e-02f, 1.07625559e-01f, 2.16991454e-02f,
  8.72586593e-02f, 5.91430515e-02f, -8.39984193e-02f, -6.94914013e-02f, 3.17744240e-02f, 1.40603185e-02f, -7.17566628e-03f, -1.17486238e-01f, -3.00958585e-02f, 6.60651252e-02f,
  -1.37655204e-02f, 7.64345303e-02f, -7.01264441e-02f, 3.28004919e-03f, -4.86929342e-02f, -7.93941841e-02f, 1.85729712e-02f, -1.12313546e-01f, -1.59378834e-02f, 1.44921215e-02f,
  3.43245529e-02f, -5.29541075e-03f, 7.16907084e-02f, 6.72297552e-02f, 2.27206256e-02f, -7.54631385e-02f, -6.62285611e-02f, 2.57447120e-02f, -6.39258791e-03f, 4.00646962e-02f,
  -9.77041200e-02f, -3.72095555e-02f, 5.94826974e-02f, -5.99959008e-02f, 6.93043917e-02f, 7.27670193e-02f, -4.49313745e-02f, -8.15328881e-02f, 3.05513609e-02f, 9.42403451e-02f,
  5.81609532e-02f, 1.69954234e-04f, -1.66740939e-02f, -6.88270405e-02f, -1.98694728e-02f, -5.85477278e-02f, 1.79067664e-02f, -6.69097677e-02f, 7.48305768e-02f, 6.80156052e-02f,
  -4.21316177e-02f, -4.32649218e-02f, -2.56877276e-03f, -1.07339269e-03f, -6.13238700e-02f, 2.71304771e-02f, 2.30468288e-02f, 4.28130738e-02f, 7.37259313e-02f, 6.03366904e-02f,
  2.98769362e-02f, 1.94883086e-02f, 3.98022495e-02f, -1.71126444e-02f, 8.99975300e-02f, -7.71136209e-02f, 3.58394869e-02f, -4.37865667e-02f, 3.59475799e-02f, -4.52683419e-02f,
  1.10652111e-01f, 3.62342484e-02f, -3.46981585e-02f, -7.23543540e-02f, -9.30419415e-02f, 2.78751645e-02f, -4.64846427e-03f, -2.22787149e-02f, 5.51481918e-02f, 2.38162596e-02f,
  1.51220709e-02f, -4.46856618e-02f, -4.17220965e-02f, 4.29825112e-02f, 1.44688543e-02f, 3.99569087e-02f, 6.69198483e-02f, -4.10840213e-02f, 5.64474873e-02f, 6.85149431e-02f,
  -1.05653048e-01f, 7.42610395e-02f, -6.37081414e-02f, 3.11871641e-03f, 2.56152060e-02f, -2.05849279e-02f, 2.69879922e-02f, 1.18906386e-02f, -4.36979644e-02f, 5.84542267e-02f,
  -5.00422493e-02f, 6.31307438e-02f, 3.03393193e-02f, 6.14133961e-02f, -9.06932503e-02f, -2.01575607e-01f, -9.48479548e-02f, 3.03483568e-02f, -4.15375680e-02f, -3.40810157e-02f,
  -1.83277708e-02f, 3.77298817e-02f, 7.56987510e-03f, 7.80384317e-02f, 1.62061099e-02f, 3.95690389e-02f, 2.59800479e-02f, -1.30958036e-01f, -1.69219598e-02f, 6.92222416e-02f,
  -8.20545293e-03f, -2.30203010e-02f, 1.27429187e-01f, -9.54225101e-03f, -1.84541326e-02f, -1.98137648e-02f, 7.59852380e-02f, 9.28218588e-02f, 8.62423331e-02f, -8.90372023e-02f,
  -9.56804901e-02f, 1.17397904e-01f, 2.87586264e-02f, -4.21468616e-02f, -3.51406969e-02f, 2.99012307e-02f, -9.02518183e-02f, -7.46887475e-02f, -2.71632504e-02f, -1.82347745e-02f,
  -2.55982038e-02f, 1.38812847e-02f, 4.48032320e-02f, -3.72293629e-02f, -4.68803234e-02f, -2.80475873e-03f, -2.57472675e-02f, -6.36245459e-02f, -4.33037095e-02f, 3.48178148e-02f,
  -7.35239685e-02f, 4.55296002e-02f, 6.93494529e-02f, -4.47410829e-02f, -1.87867228e-02f, -8.88381675e-02f, -7.18399882e-02f, -1.89817813e-03f, 4.18418124e-02f, -5.99045418e-02f,
  7.70792365e-02f, -2.40801480e-02f, -6.48218095e-02f, 1.29791172e-02f, -4.24718373e-02f, 3.52076255e-02f, -8.55506882e-02f, 3.81086976e-03f, -2.28931233e-02f, 7.05534741e-02f,
  -8.34254175e-02f, -1.19025372e-02f, -5.64761013e-02f, 3.17025520e-02f, 4.42532599e-02f, 6.52795061e-02f, -4.43748105e-03f, 3.97886112e-02f, 8.89078435e-03f, 8.59007537e-02f,
  -7.19216466e-02f, -9.23983902e-02f, -5.86894117e-02f, 5.86476475e-02f, -9.42675620e-02f, 6.06522970e-02f, -4.76261415e-03f, -4.70981449e-02f, -3.66985574e-02f, 4.24995609e-02f,
  1.13590039e-01f, 1.02121919e-01f, 8.48722234e-02f, 3.91130894e-02f, -5.70294037e-02f, -3.94104160e-02f, -6.49595633e-02f, -7.02953935e-02f, 8.95060375e-02f, 4.28030789e-02f,
  -6.08615018e-02f, -5.14108948e-02f, -5.74459657e-02f, -2.31907275e-02f, 8.42299834e-02f, 1.95667353e-02f, -3.06229629e-02f, 7.97659829e-02f, -1.11497939e-02f, 3.65796126e-02f,
  4.68403921e-02f, -2.19200123e-02f, 7.02083390e-03f, 4.76364791e-02f, -7.96097592e-02f, 2.52539925e-02f, 6.66078404e-02f, 5.67917153e-02f, 1.94254834e-02f, 9.48068127e-02f,
  -6.84666261e-02f, -4.42790017e-02f, 1.05341613e-01f, 1.69281736e-02f, 2.15775128e-02f, 4.96533364e-02f, -6.47915825e-02f, 1.58633217e-01f, 1.11174136e-01f, -1.66189939e-01f,
  -2.23632064e-02f, -1.07651189e-01f, -4.94335108e-02f, 1.37405440e-01f, 1.50340259e-01f, 3.49121392e-02f, 1.74865931e-01f, 7.76367635e-02f, 1.26259014e-01f, 8.31627175e-02f,
  6.58037886e-02f, -2.85211615e-02f, 1.44145384e-01f, 1.00460857e-01f, -3.64475623e-02f, 7.01597631e-02f, 1.50714582e-02f, -1.14445210e-01f, 1.01197340e-01f, -7.30656162e-02f,
  5.19558974e-02f, -5.01354262e-02f, -5.31313419e-02f, -4.70353924e-02f, 4.29058298e-02f, 4.99431007e-02f, -4.28669266e-02f, 2.38908157e-02f, 8.51170644e-02f, 3.25986110e-02f,
  -1.21021783e-03f, 6.73806593e-02f, 3.80593352e-02f, -4.22635116e-02f, 8.87123272e-02f, -2.83938032e-02f, -1.57360137e-02f, 3.54952887e-02f, 4.83200215e-02f, 5.10997996e-02f,
  -1.46063659e-02f, -5.77531159e-02f, 1.01583570e-01f, 6.60090819e-02f, 2.48774141e-02f, 3.31023112e-02f, 6.60582557e-02f, 2.07941681e-02f, 5.10207154e-02f, -2.73641907e-02f,
  -9.76532989e-04f, 4.39845808e-02f, -4.34465753e-03f, -4.12543602e-02f, -8.79177451e-02f, 1.27666974e-02f, 5.08844182e-02f, 4.40185927e-02f, -4.68872674e-02f, 5.45818359e-02f,
  4.09738682e-02f, -6.71822205e-02f, 7.83470273e-02f, -8.68603066e-02f, -7.72686303e-02f, -8.79309028e-02f, 2.93595921e-02f, -8.77109841e-02f, 1.03144068e-02f, 5.67635745e-02f,
  -7.91413710e-02f, 4.22705226e-02f, -6.27276599e-02f, 5.35697304e-02f, 1.09440312e-02f, -5.49568459e-02f, 5.45519441e-02f, 3.73388901e-02f, 3.36151272e-02f, -7.95267597e-02f,
  -7.70122483e-02f, 7.02370107e-02f, -6.89856037e-02f, 3.55568156e-02f, 1.32977432e-02f, 8.11071717e-04f, -3.62254656e-03f, -5.71845844e-02f, 1.29986405e-02f, -6.09222874e-02f,
  -4.86026332e-02f, -6.59382418e-02f, -9.01963189e-02f, -8.23498070e-02f, 7.79217705e-02f, 5.87457865e-02f, 1.70136094e-02f, 1.83459837e-02f, 1.71841178e-02f, 1.11844512e-02f,
  -1.24410279e-02f, 2.60878750e-03f, 5.18193543e-02f, -7.58357067e-03f, 4.68759723e-02f, -7.84778036e-03f, -9.63523984e-02f, -8.73590931e-02f, -6.64972758e-04f, -1.67161487e-02f,
  1.97554007e-01f, -1.11371934e-01f, -1.94814444e-01f, -9.58487466e-02f, -8.96288306e-02f, -2.16636792e-01f, -1.72230616e-01f, -2.05750465e-01f, -5.42442054e-02f, -3.36982636e-03f,
  -9.04923975e-02f, 1.35937901e-02f, 1.51995167e-01f, -2.57181495e-01f, 1.21678971e-02f, 5.28487936e-02f, -2.57646888e-01f, -2.65438389e-02f, -1.73051152e-02f, -1.14695519e-01f,
  -5.05624153e-02f, -1.37828648e-01f, -1.10011049e-01f, -7.48596415e-02f, -1.96209565e-01f, -1.39655918e-02f, 1.36994287e-01f, 3.61300893e-02f, -1.10113449e-01f, -4.82998937e-02f,
  -2.47054677e-02f, 7.12155225e-03f, 7.42236339e-03f, -9.13032517e-02f, -3.31792943e-02f, -4.32949029e-02f, 4.10385653e-02f, 4.10910659e-02f, 2.83486098e-02f, -8.00044686e-02f,
  6.32573217e-02f, -5.42607345e-02f, -1.07437164e-01f, 8.95302556e-03f, 7.61738643e-02f, 2.07982119e-02f, -7.04341456e-02f, -1.82968825e-02f, -5.71283326e-02f, 8.73157755e-02f,
  -1.78682618e-02f, -3.00700683e-02f, -8.81835073e-02f, 5.31244464e-02f, 3.91857550e-02f, 1.62359362e-03f, 6.86595514e-02f, 1.95146948e-02f, -5.19062765e-02f, -6.90867603e-02f,
  7.87506476e-02f, 9.58206132e-02f, 3.07767559e-03f, -7.21119419e-02f, 6.75111264e-02f, 1.80101562e-02f, 3.83651070e-02f, 7.71231130e-02f, -1.76819619e-02f, 2.76311934e-02f,
  -8.09806734e-02f, 6.49643540e-02f, 2.08711671e-03f, -1.23699591e-03f, 5.07823378e-02f, 4.80296277e-02f, 8.83399919e-02f, 7.06423596e-02f, -8.42048079e-02f, -8.16982463e-02f,
  -6.48431927e-02f, 7.69026228e-05f, -3.27977724e-02f, 7.42924884e-02f, 1.77417863e-02f, 3.14253569e-02f, 5.64616472e-02f, -1.08806789e-02f, 7.38231018e-02f, -3.64559554e-02f,
  -7.65849277e-02f, 6.60096109e-02f, -3.65191437e-02f, 5.17553836e-02f, -5.42502813e-02f, 2.35285778e-02f, -5.99594042e-02f, -1.14798360e-01f, -3.22738290e-02f, -6.02425039e-02f,
  1.77811086e-02f, -6.24716915e-02f, -6.91507831e-02f, 6.10432215e-02f, -8.67769718e-02f, -9.00092870e-02f, -4.25521322e-02f, -2.13261098e-02f, -2.42816079e-02f, -2.26039886e-02f,
  7.12712109e-02f, 5.52641079e-02f, 4.21638899e-02f, -7.11915568e-02f, -3.93862166e-02f, 3.76001699e-03f, -6.12087455e-03f, -1.62807002e-03f, 5.03652878e-02f, -5.48857003e-02f,
  1.21518992e-01f, 3.81866038e-01f, 3.10444534e-01f, 1.60269678e-01f, -2.00598657e-01f, -7.13881254e-02f, 2.50795092e-02f, -4.60909121e-02f, 1.09689303e-01f, 1.15221441e-01f,
  -9.00587961e-02f, 3.25116307e-01f, 3.78486216e-02f, 1.16305314e-01f, -1.42032251e-01f, -8.45068172e-02f, 9.22257081e-03f, 1.30313933e-01f, -5.30672073e-03f, 6.34564236e-02f,
  5.39244935e-02f, -2.14030907e-01f, 1.51988402e-01f, -8.60015005e-02f, 1.26210824e-01f, 2.04003289e-01f, -3.84891964e-02f, -1.00580655e-01f, 1.36590019e-01f, -1.04816854e-01f,
  -2.01958604e-02f, -5.32302714e-04f, 1.96497403e-02f, 9.51439291e-02f, 5.80286756e-02f, 6.45112544e-02f, 4.05469630e-03f, -7.85608143e-02f, -3.91803653e-04f, -2.10036095e-02f,
  7.08875507e-02f, -5.76228127e-02f, -3.35393026e-02f, -7.39881471e-02f, -6.49120882e-02f, 9.31611583e-02f, -3.26809697e-02f, -2.19949484e-02f, 1.14977129e-01f, 7.90297464e-02f,
  9.81402248e-02f, 5.85575309e-03f, 3.55272517e-02f, 6.92135096e-02f, -6.83800131e-02f, -2.26609614e-02f, 6.36676848e-02f, 4.43369476e-03f, 1.56074241e-01f, 2.14171354e-02f,
  -1.54029414e-01f, 4.34223562e-02f, -5.08117154e-02f, 8.31263810e-02f, -6.38747960e-02f, 3.34892534e-02f, 2.63807587e-02f, 1.18912179e-02f, -3.50173749e-02f, -3.37650925e-02f,
  -7.52205402e-02f, 3.20027545e-02f, -1.30589819e-02f, 9.49094668e-02f, -5.93665093e-02f, 7.69885778e-02f, -8.44322667e-02f, 3.49189304e-02f, 8.08824077e-02f, -5.95038310e-02f,
  -5.05657233e-02f, 5.68598732e-02f, 3.09220292e-02f, 4.26621661e-02f, 3.51524875e-02f, -3.37626375e-02f, -2.13142484e-02f, 4.91546392e-02f, -4.95526288e-03f, -5.46120331e-02f,
  -4.42729257e-02f, 1.20283723e-01f, 1.24166854e-01f, -4.84989062e-02f, -5.68210296e-02f, -4.68160622e-02f, -3.88991013e-02f, 2.47801226e-02f, 6.59316629e-02f, -3.98510322e-02f,
  5.58943897e-02f, 6.05629347e-02f, 4.40968201e-02f, 5.26559800e-02f, -5.48204035e-02f, -4.35649790e-02f, 2.88460981e-02f, -6.48800135e-02f, 7.04611167e-02f, -1.37128914e-02f,
  8.14194307e-02f, 5.45553267e-02f, -6.56279176e-03f, 1.28108142e-02f, 1.68657694e-02f, -5.27898967e-02f, -5.54699600e-02f, 9.36885551e-02f, -3.89913358e-02f, 1.10920548e-01f,
  -2.13208020e-01f, 1.78622268e-02f, 1.92437723e-01f, -5.26166782e-02f, -2.27350488e-01f, 7.74912164e-02f, 2.41332054e-01f, -2.09225252e-01f, -7.27114901e-02f, 7.86637738e-02f,
  2.82137264e-02f, -3.72989774e-02f, 1.65988430e-01f, 2.51243841e-02f, 1.04680970e-01f, 2.34632894e-01f, 7.56914914e-02f, 1.58611760e-01f, -1.01479217e-01f, 6.37183664e-03f,
  -1.01976665e-02f, -7.62742981e-02f, 9.63734835e-02f, -1.29974365e-01f, -1.05063230e-01f, -3.83778587e-02f, -1.44885033e-01f, -7.01682866e-02f, 5.29439701e-03f, -7.92938098e-02f,
  -1.64696530e-01f, -1.66747138e-01f, -1.90912839e-02f, -3.84573936e-02f, -2.20199693e-02f, -2.84566116e-02f, -5.16563701e-03f, -3.57292928e-02f, -7.14785606e-02f, -3.22248787e-02f,
  6.65419921e-02f, -5.82003035e-02f, -8.01021904e-02f, 4.65479940e-02f, -1.24714740e-01f, -5.07511348e-02f, -4.99987230e-03f, -6.64215302e-03f, -7.57095665e-02f, 7.28457933e-03f,
  -1.52298100e-02f, -2.41839625e-02f, -3.60200815e-02f, -5.74239762e-03f, 7.26323649e-02f, 5.96244149e-02f, 9.60964859e-02f, 3.85284051e-02f, -8.79629552e-02f, 1.41974008e-02f,
  -5.49561158e-02f, 1.62715744e-02f, -7.82119110e-02f, -2.19055228e-02f, 5.59561402e-02f, 7.24283084e-02f, 2.92795012e-03f, 4.74763326e-02f, 4.34504226e-02f, 6.61560595e-02f,
  -1.11556705e-03f, -6.71789274e-02f, 4.80514504e-02f, -3.01000010e-02f, -2.30321828e-02f, 9.72980335e-02f, 1.35734845e-02f, -4.07611169e-02f, -5.39133698e-02f, 1.87087189e-02f,
  -1.74001139e-02f, 2.17985641e-02f, 6.01827279e-02f, 5.26904687e-02f, -5.35507761e-02f, 3.05132382e-02f, 5.09109721e-02f, 6.50797337e-02f, 2.63289525e-03f, -1.26312941e-03f,
  -2.11259082e-01f, -1.78806141e-01f, 5.29681817e-02f, -7.39518926e-03f, 1.26005672e-02f, -9.50251967e-02f, -6.49408400e-02f, -3.31308581e-02f, 6.89552724e-03f, -1.61481276e-02f,
  -5.39270183e-03f, 6.18330091e-02f, 2.62702331e-02f, -7.36622661e-02f, -4.16568257e-02f, 4.75096777e-02f, 3.30277085e-02f, -6.17538057e-02f, -5.79915382e-03f, -1.28816247e-01f,
  4.78678271e-02f, -4.41519842e-02f, 2.72741020e-02f, -4.35392745e-03f, -9.25523266e-02f, -7.79820159e-02f, -4.94131222e-02f, -1.24771278e-02f, -6.58033565e-02f, -1.61605254e-02f,
  -1.06173903e-01f, 6.79041520e-02f, -1.06263913e-01f, 1.84788406e-02f, 3.02726701e-02f, 1.42305821e-01f, 3.19573134e-02f, 1.15461022e-01f, 4.07439396e-02f, 8.88902321e-02f,
  1.63071543e-01f, 8.47576708e-02f, 7.49665778e-03f, 4.13422100e-02f, -2.57905833e-02f, 7.73222595e-02f, 1.42626822e-01f, -2.24528890e-02f, 1.02554739e-01f, -6.18734770e-02f,
  -6.55454248e-02f, 1.66220441e-01f, -1.22320116e-01f, 2.75900010e-02f, 3.57229859e-02f, -1.07500821e-01f, -1.80994552e-02f, 9.03251842e-02f, -8.81785154e-02f, 7.34608173e-02f,
  -1.85268054e-05f, 6.75946921e-02f, -7.76924714e-02f, -2.35813204e-02f, -9.81062651e-02f, -1.02533311e-01f, 4.51022759e-02f, 4.41491138e-03f, -1.92615017e-02f, -9.44788940e-03f,
  -1.75559334e-02f, -6.56359037e-03f, 1.82170607e-02f, -3.97323929e-02f, -3.59989405e-02f, -9.77868736e-02f, -1.24807674e-02f, 5.25286607e-02f, 4.97679338e-02f, 6.20427541e-02f,
  1.41392583e-02f, -1.07730158e-01f, -8.60353485e-02f, 1.57710612e-02f, 8.23081583e-02f, -7.50169605e-02f, -6.82003722e-02f, -8.37188885e-02f, -5.97175546e-02f, 5.87637611e-02f,
  -4.20086123e-02f, 5.15151061e-02f, 1.12733096e-01f, -1.16556454e-02f, 1.90116614e-02f, -4.66469750e-02f, -1.46778906e-02f, -5.19124195e-02f, -4.83603925e-02f, -2.78849695e-02f,
  -5.32229990e-02f, -9.39188749e-02f, 6.39136881e-02f, -2.83496287e-02f, -6.41435534e-02f, -2.99157798e-02f, 6.20687194e-02f, -6.98264921e-03f, -6.59779161e-02f, 9.14146844e-03f,
  -6.45755231e-02f, -3.05778570e-02f, 6.91152960e-02f, 3.76529098e-02f, 9.30473655e-02f, 8.10500234e-02f, 3.25165279e-02f, 5.10611311e-02f, 6.81925938e-02f, -6.69592246e-02f,
  6.61358535e-02f, 5.18590063e-02f, 1.06629968e-01f, -4.49266359e-02f, 7.20980987e-02f, 6.15775511e-02f, 2.19585337e-02f, -3.12847160e-02f, 7.63930902e-02f, 2.15093922e-02f,
  -5.99039458e-02f, -8.01805500e-03f, -3.69779840e-02f, 1.34080241e-03f, -2.93747205e-02f, 9.02411044e-02f, -3.33864498e-03f, 4.86970097e-02f, -4.73624580e-02f, -2.45211143e-02f,
  -3.44695784e-02f, -1.74691919e-02f, -5.00937253e-02f, -5.05219027e-02f, 5.58191836e-02f, -1.00856021e-01f, -7.86161274e-02f, 4.10287641e-02f, 1.30952504e-02f, -9.07253474e-02f,
  -1.08725309e-01f, 1.63279772e-01f, -6.36428595e-03f, -1.52041435e-01f, -1.89792383e-02f, -1.04910888e-01f, -5.30205593e-02f, 1.13917544e-01f, 8.31826106e-02f, 9.33298916e-02f,
  -2.98291128e-02f, -9.11071151e-02f, 3.73678468e-02f, -1.94858655e-01f, -2.24801600e-01f, -1.24523185e-01f, -4.60098274e-02f, -3.72103602e-02f, -2.70089153e-02f, 3.23243178e-02f,
  -1.16753198e-01f, -1.20496249e-03f, -3.11997104e-02f, 1.55884221e-01f, 8.76248032e-02f, 1.29551187e-01f, 1.60211593e-01f, 1.51644051e-01f, 5.81078902e-02f, -1.65734999e-02f,
  -8.39089230e-02f, 5.13078645e-02f, -4.42216098e-02f, 3.39540914e-02f, -1.96762960e-02f, 5.35522364e-02f, -1.07703209e-02f, -3.13043594e-02f, -2.61271801e-02f, 7.45361745e-02f,
  -1.81140974e-02f, 8.80387127e-02f, -1.06609896e-01f, 6.91641048e-02f, 9.20065418e-02f, 9.34977755e-02f, 6.79772794e-02f, 2.74970885e-02f, -5.28614363e-03f, -6.54499158e-02f,
  5.50097004e-02f, -2.59593502e-02f, -7.01204091e-02f, -6.40925020e-02f, 7.72441924e-02f, -1.84388191e-03f, -6.26229048e-02f, 1.02732554e-02f, 2.02432070e-02f, -6.09608628e-02f,
  -4.70801853e-02f, -6.60931915e-02f, 4.98877391e-02f, 7.52348006e-02f, -6.41040597e-03f, 8.91911909e-02f, 1.59702990e-02f, 5.36867008e-02f, -7.52102509e-02f, 7.05470741e-02f,
  2.68054996e-02f, -5.92955761e-02f, 6.22304045e-02f, -8.63848429e-04f, 3.21937427e-02f, -2.60385126e-02f, 6.34434000e-02f, 6.80123968e-03f, -9.25485566e-02f, -2.46681534e-02f,
  -5.53409457e-02f, -3.34761702e-02f, 8.20156634e-02f, 7.96263441e-02f, -1.19356345e-02f, -5.44385873e-02f, -1.89850461e-02f, 1.05398493e-02f, 2.46340334e-02f, 4.24476247e-03f,
  -3.67321558e-02f, 1.63194701e-01f, 4.91424426e-02f, -2.00134106e-02f, 7.08963722e-03f, 9.35351029e-02f, 3.75866592e-02f, -6.99281842e-02f, -5.74568808e-02f, -4.41157594e-02f,
  2.54043099e-02f, 4.80695963e-02f, -4.91204150e-02f, -8.37799534e-02f, -3.23083661e-02f, -6.21295050e-02f, -6.02794485e-03f, -7.96224251e-02f, -6.12323964e-03f, 2.07903053e-04f,
  1.10127646e-02f, -2.48147622e-02f, -2.89044864e-02f, 1.52749261e-02f, 3.83341126e-02f, -4.89200577e-02f, -8.06337073e-02f, -4.31523062e-02f, 5.93644828e-02f, 5.50925173e-03f,
  -4.64836620e-02f, -1.04793690e-01f, 7.94244483e-02f, 2.98705790e-02f, 1.94263458e-02f, 1.23760588e-02f, -3.02174184e-02f, 4.73963805e-02f, -6.59771115e-02f, -1.00762539e-01f,
  -7.30116963e-02f, -9.53143537e-02f, 5.88231348e-02f, -1.33068888e-02f, 2.97198165e-02f, 2.76335403e-02f, 6.53857514e-02f, -1.30392984e-01f, -6.40107468e-02f, -1.21195251e-02f,
  9.86861065e-02f, -6.94325864e-02f, 7.21065849e-02f, 1.48138478e-02f, 4.80457321e-02f, 1.22408923e-02f, -3.53497341e-02f, -5.84492311e-02f, 1.87005475e-02f, 7.18966350e-02f,
  -1.09953180e-01f, 5.99150956e-02f, -4.94564697e-03f, 3.35294418e-02f, 7.51321614e-02f, -1.00057855e-01f, -4.73166816e-02f, -6.38211444e-02f, -8.56034905e-02f, 6.26119226e-02f,
  2.78888345e-02f, -9.03171953e-03f, 1.45924082e-02f, 4.02484424e-02f, -1.23755746e-02f, 9.45580825e-02f, -1.14370987e-03f, -4.74037826e-02f, 7.40292147e-02f, -2.81456560e-02f,
  7.03122020e-02f, -2.85010431e-02f, 4.43351194e-02f, 8.12712535e-02f, 3.91334072e-02f, -5.13638519e-02f, -4.51919660e-02f, 1.69701339e-03f, -4.25944105e-02f, 5.06372796e-03f,
  1.09466061e-01f, -1.42973755e-03f, -3.78666595e-02f, -9.94587094e-02f, -2.95606768e-03f, -8.24658722e-02f, 6.59376197e-03f, 3.49848568e-02f, -3.70605774e-02f, -9.43995193e-02f,
  -3.19463983e-02f, -4.16935422e-02f, 6.42188638e-02f, -7.13827461e-02f, -7.90925771e-02f, -9.27809328e-02f, 7.84811452e-02f, -4.78678457e-02f, 6.34169206e-02f, -6.72513386e-03f,
  -2.09844634e-02f, -3.18270326e-02f, 4.71390113e-02f, 9.83229578e-02f, -2.83360444e-02f, -7.88916349e-02f, -5.59368506e-02f, -6.51616901e-02f, 6.45102337e-02f, -2.23048180e-02f,
  -2.56613586e-02f, -8.93367082e-02f, -2.78379247e-02f, -7.18201920e-02f, -7.47553557e-02f, -3.62961553e-03f, 5.89320585e-02f, 3.13493200e-02f, 1.41170314e-02f, -8.04339945e-02f,
  -6.33738637e-02f, -6.74491574e-04f, 6.92275092e-02f, 6.42463416e-02f, 3.11218388e-02f, 7.00515462e-03f, 5.04566617e-02f, 6.82895491e-03f, -2.09095031e-02f, -8.63993913e-02f,
  -3.52060497e-02f, 2.93404516e-02f, 7.49219209e-02f, -1.68103520e-02f, 5.10093942e-02f, 7.91451056e-03f, -1.55137014e-02f, 6.48862273e-02f, 3.99184860e-02f, 8.22034776e-02f,
  -1.31292596e-01f, 3.74892950e-02f, 1.12531662e-01f, 4.44187522e-02f, -1.48827389e-01f, 1.22203290e-01f, 2.99098846e-02f, -9.74177793e-02f, 6.59637526e-02f, -1.11058682e-01f,
  -1.32284015e-01f, 2.39163376e-02f, -4.60526720e-02f, 1.00378506e-01f, 1.78316608e-01f, 1.14219137e-01f, 1.26307264e-01f, 1.17517889e-01f, 1.21070974e-01f, 9.76121984e-03f,
  1.06954820e-01f, -4.71731387e-02f, 2.00325269e-02f, 1.58642661e-02f, -1.25707358e-01f, -3.30074094e-02f, -9.25326720e-02f, -5.91022670e-02f, 4.40688208e-02f, -5.04635833e-02f,
  -1.21272720e-01f, 1.30392024e-02f, -2.63422318e-02f, -4.47802916e-02f, -8.10499415e-02f, 3.62802371e-02f, -9.69024971e-02f, 2.47811005e-02f, 1.02036959e-02f, -3.31478417e-02f,
  -2.71975193e-02f, -2.73726694e-02f, 5.52704260e-02f, 7.17243105e-02f, 6.28491789e-02f, 1.11674918e-02f, -7.15967864e-02f, -6.95088506e-02f, 3.29623297e-02f, -4.54798006e-02f,
  9.21929181e-02f, 7.77373498e-05f, -2.92925462e-02f, -6.70667831e-03f, 7.14405719e-03f, -2.45401226e-02f, 2.85952389e-02f, -5.96562997e-02f, -5.29777072e-02f, 8.23645815e-02f,
  -5.25503792e-02f, -3.64525653e-02f, 1.31525015e-02f, -6.77193552e-02f, -1.48271827e-03f, 6.83482587e-02f, -7.19872639e-02f, 1.62354559e-02f, 8.97598714e-02f, -9.40911099e-02f,
  -3.60907754e-03f, 2.47378293e-02f, 7.28200823e-02f, -3.88302319e-02f, -3.44996527e-02f, -3.29210598e-04f, 9.59128607e-03f, -7.11335987e-02f, -6.86339885e-02f, -2.11695302e-02f,
  -2.55121291e-02f, -3.53239402e-02f, 4.22241539e-02f, -8.26637223e-02f, 7.93406814e-02f, -5.31059355e-02f, 4.94844168e-02f, -8.44222214e-03f, -3.88092510e-02f, -4.02877852e-02f,
  -6.05073161e-02f, -7.21101165e-02f, -1.46241840e-02f, -3.18968408e-02f, 2.65071373e-02f, -5.00352271e-02f, -6.06530672e-03f, 3.99169102e-02f, 3.84376361e-03f, 5.20155057e-02f,
  -5.85027747e-02f, -4.05853577e-02f, -7.69697130e-02f, 1.97139066e-02f, 8.44961591e-03f, -2.56111082e-02f, 1.93459988e-02f, -7.62712061e-02f, 2.22871136e-02f, 1.52690513e-02f,
  5.46821207e-02f, -6.74412325e-02f, 1.98339056e-02f, -5.64990677e-02f, 7.54098147e-02f, 7.13027269e-02f, -5.76788075e-02f, 3.51924933e-02f, 6.35876507e-02f, 6.34730160e-02f,
  1.58199891e-01f, -1.59224465e-01f, 3.48135710e-01f, 1.52561083e-01f, -1.41272936e-02f, 7.25748911e-02f, 2.34177381e-01f, -3.29137743e-02f, 3.97027023e-02f, -3.10837239e-01f,
  -2.96243653e-02f, 1.53375119e-01f, 2.86793876e-02f, -8.30532163e-02f, 1.87367857e-01f, 6.37606904e-02f, 2.15044916e-02f, -7.22872540e-02f, 4.09903750e-02f, 5.92106283e-02f,
  1.35020912e-01f, -2.59942245e-02f, 1.65113688e-01f, -1.02425829e-01f, 1.21899903e-01f, -2.47610305e-02f, -1.12277806e-01f, 3.06961890e-02f, -1.43123180e-01f, -6.62145764e-02f,
  -1.08793519e-01f, -4.40894328e-02f, -4.48357090e-02f, 1.63773932e-02f, 4.37492281e-02f, 5.01179928e-03f, -6.74310955e-04f, 7.16445148e-02f, -1.54069373e-02f, 9.73470509e-02f,
  5.76838367e-02f, -5.80764329e-03f, -1.04914330e-01f, 3.31970453e-02f, -9.27918330e-02f, 7.41055608e-02f, -7.31907040e-02f, 2.37371530e-02f, 7.61895441e-03f, 7.17569068e-02f,
  1.04286917e-01f, -1.27862468e-02f, 3.10033318e-02f, -2.30764766e-04f, 3.41300183e-04f, -4.60955724e-02f, 9.94889513e-02f, 6.56936467e-02f, 3.99790108e-02f, -3.26956436e-02f,
  6.58200756e-02f, -4.00843751e-03f, -8.20823200e-03f, -8.04810449e-02f, 2.35543470e-03f, 7.35508949e-02f, -6.41466258e-03f, -4.52388823e-02f, 1.01594783e-01f, 1.44854300e-02f,
  -2.89763771e-02f, -1.54673615e-02f, -2.09369436e-02f, 6.87751397e-02f, -3.20415571e-02f, 6.93332106e-02f, -2.88749915e-02f, -4.80422638e-02f, 4.26646993e-02f, 2.98950146e-03f,
  1.00832302e-02f, 8.42384323e-02f, -2.06051208e-02f, 4.03159782e-02f, -6.74076676e-02f, -2.00129002e-02f, -2.34367121e-02f, -6.93592206e-02f, 2.85461843e-02f, 1.15036227e-01f,
  -7.22096264e-02f, -1.29202306e-01f, -6.96253628e-02f, -2.96056084e-02f, -1.61781088e-02f, -1.20503185e-02f, 6.28144220e-02f, -7.92152211e-02f, 3.43429707e-02f, 6.98092803e-02f,
  -9.94172692e-02f, -1.26093812e-02f, -1.01261005e-01f, -4.86884313e-03f, 6.89931121e-03f, -2.43890123e-03f, 6.99830875e-02f, -8.58058631e-02f, -8.59296098e-02f, -7.83011690e-02f,
  7.64820427e-02f, -7.15049058e-02f, -6.21290924e-03f, -3.10826628e-03f, -1.05060905e-01f, 6.04807250e-02f, -5.31783774e-02f, -3.04008145e-02f, -6.17051385e-02f, 2.21624225e-02f,
  1.21319011e-01f, -3.45220305e-02f, -8.37430060e-02f, 4.72710393e-02f, 1.07449815e-01f, -1.13940686e-01f, -6.12249002e-02f, -5.50604844e-03f, -3.84499170e-02f, 4.12457213e-02f,
  8.98246691e-02f, 1.21601589e-01f, -2.07935497e-02f, 2.23956615e-01f, 2.22632959e-01f, 6.30458817e-02f, 2.32619211e-01f, 1.19114108e-01f, -1.21656030e-01f, 4.86535244e-02f,
  1.12687178e-01f, 2.67064989e-01f, 2.50349808e-02f, 1.65077709e-02f, 1.73195422e-01f, -1.02312095e-01f, 2.18584612e-01f, -1.58090577e-01f, 2.19212860e-01f, 1.09298430e-01f,
  2.87065096e-02f, 1.40058817e-02f, -3.81904421e-03f, -7.32435286e-02f, 8.36264789e-02f, -6.17013872e-03f, -2.08854694e-02f, -5.11600710e-02f, -4.72094975e-02f, -7.01583996e-02f,
  -7.06967935e-02f, -2.13557808e-03f, 6.36242628e-02f, -3.71753126e-02f, -6.45887405e-02f, 1.18005006e-02f, 6.18632603e-03f, 5.69581520e-03f, -7.74708465e-02f, 5.29348850e-02f,
  -4.17580381e-02f, 3.13705318e-02f, 8.18368886e-03f, 5.52406674e-03f, -3.38955075e-02f, -6.29555807e-02f, -2.29343399e-02f, 5.08357808e-02f, -1.93484183e-02f, -1.44577231e-02f,
  -2.57964749e-02f, 6.03463612e-02f, -6.91137537e-02f, -1.79265179e-02f, 5.36835529e-02f, -5.43901138e-02f, -4.84166332e-02f, 1.88007094e-02f, -7.20194727e-02f, 3.96937430e-02f,
  -2.92902701e-02f, 2.34529022e-02f, 8.02645832e-02f, -2.77295541e-02f, 4.62015122e-02f, 1.79503299e-02f, 2.70026941e-02f, -6.66416064e-02f, -1.21004865e-01f, -8.93793106e-02f,
  -5.49073964e-02f, -4.31617051e-02f, 9.11801904e-02f, -5.13983630e-02f, -2.47846358e-02f, 5.04074395e-02f, 4.15437631e-02f, -5.63789643e-02f, -9.28375572e-02f, -3.23457979e-02f,
  9.70241651e-02f, 1.10217087e-01f, -7.56586641e-02f, 3.89152169e-02f, -8.04508403e-02f, 4.52805795e-02f, -3.92595939e-02f, 1.79349631e-02f, 8.10422748e-03f, -6.01731241e-03f,
  6.77806586e-02f, 3.15311109e-03f, -3.93631980e-02f, 9.35356542e-02f, -4.40996438e-02f, 6.74602166e-02f, 9.56606790e-02f, 3.32531407e-02f, -1.57898106e-02f, 1.28964419e-02f,
  2.99434103e-02f, -7.72420783e-03f, 5.78279980e-02f, 7.57008838e-03f, -6.84352452e-03f, -1.13115581e-02f, 2.40333588e-03f, 2.46363301e-02f, -5.29867038e-02f, -1.27296839e-02f,
  1.83053136e-01f, -1.93914935e-01f, -4.52328436e-02f, -6.83475658e-02f, 1.31605104e-01f, -1.81841978e-03f, 1.21165372e-01f, 5.87764494e-02f, 9.17861164e-02f, 9.67047736e-03f,
  1.82278112e-01f, -3.60715832e-03f, 4.74629477e-02f, 1.08965307e-01f, 6.22542985e-02f, -9.23057571e-02f, -4.29551001e-04f, 1.09280430e-01f, -5.75444251e-02f, 5.64704873e-02f,
  4.59845401e-02f, 5.94642526e-03f, -1.25462204e-01f, -1.03053086e-01f, 3.28995846e-02f, 3.68838534e-02f, -9.21844169e-02f, -2.80972775e-02f, -1.08494610e-01f, -1.15664952e-01f,
  -2.22997945e-02f, 1.31292298e-01f, 2.66441572e-02f, 3.23485062e-02f, 5.34968153e-02f, 4.22322601e-02f, -1.35775402e-01f, -1.89899746e-02f, 1.74614657e-02f, 1.59890372e-02f,
  -5.07709309e-02f, -8.18997696e-02f, -1.04243517e-01f, 6.58473745e-02f, 3.86277027e-02f, 2.26421338e-02f, 5.50077893e-02f, 7.61294067e-02f, -1.46888942e-01f, 4.57102284e-02f,
  5.40642068e-02f, 3.70351411e-02f, -6.28088564e-02f, 3.35494913e-02f, -4.54153754e-02f, 7.10723847e-02f, 2.16963682e-02f, -5.09601459e-02f, -8.74355137e-02f, -3.77916284e-02f,
  -1.12789586e-01f, 6.24070615e-02f, 4.42825146e-02f, -1.73023120e-02f, -4.99854647e-02f, 7.63919428e-02f, -4.16442603e-02f, 4.70120944e-02f, -2.53245793e-02f, -1.14472704e-02f,
  8.05013031e-02f, -4.74463366e-02f, -4.40082103e-02f, -4.51289676e-02f, 4.01602965e-03f, 4.76814657e-02f, -7.62834251e-02f, -3.72166969e-02f, 9.01867822e-02f, -4.62155342e-02f,
  5.10846823e-02f, -7.47508854e-02f, -4.46212925e-02f, 6.42874464e-02f, 2.21122196e-03f, 2.91696433e-02f, 3.38599831e-02f, 4.98405248e-02f, 6.35111108e-02f, -6.73125312e-02f,
  3.16463970e-02f, -7.66726881e-02f, 7.05314502e-02f, -5.58881760e-02f, 7.28061646e-02f, -1.29448855e-02f, 4.30365838e-02f, 4.10760194e-02f, -6.57669753e-02f, -3.52591984e-02f,
  5.99683262e-02f, -4.24482301e-03f, -5.19287735e-02f, -7.34880120e-02f, 1.12162158e-02f, 7.08942860e-02f, -5.04038408e-02f, -1.07198469e-01f, -1.04811907e-01f, -1.10478491e-01f,
  4.95423973e-02f, -5.15096113e-02f, -6.37944192e-02f, -4.20354158e-02f, -8.77066180e-02f, 5.25759123e-02f, 6.38556015e-03f, 5.17724976e-02f, -6.75669238e-02f, -4.14921530e-02f,
  4.81747501e-02f, 2.28243068e-01f, -4.41504754e-02f, -1.63026974e-01f, -5.79314753e-02f, 2.52313465e-01f, 1.34556741e-02f, -5.64878732e-02f, -2.20666602e-01f, 1.08235758e-02f,
  -6.25374541e-02f, -1.24815233e-01f, 7.61996657e-02f, 1.33127883e-01f, 2.01112181e-02f, 1.55344069e-01f, 1.52512282e-01f, 1.21519655e-01f, -3.76254693e-02f, 4.84766550e-02f,
  -1.86160635e-02f, 2.36304868e-02f, 7.88145736e-02f, 6.25011101e-02f, 8.81441534e-02f, 1.67462043e-02f, -8.90994519e-02f, 7.29434118e-02f, -2.06790473e-02f, 2.34469734e-02f,
  2.08945930e-01f, -1.11295655e-01f, -3.22429612e-02f, -3.50562781e-02f, -2.30311602e-02f, 5.71222790e-02f, 4.44320105e-02f, -5.86060807e-02f, -3.54908034e-02f, -9.18726474e-02f,
  -7.32386410e-02f, 1.99604612e-02f, 2.08872203e-02f, -8.66021365e-02f, -5.44692501e-02f, 3.06447744e-02f, -6.69804960e-03f, 4.56093960e-02f, 4.35213856e-02f, 6.12430312e-02f,
  7.88831785e-02f, -4.47805300e-02f, 7.45206848e-02f, 4.60512973e-02f, 2.38965880e-02f, -1.25439912e-01f, -4.07701619e-02f, 6.48376346e-02f, 5.23443632e-02f, 2.28679944e-02f,
  -1.21602610e-01f, -5.50300255e-02f, -2.99791638e-02f, 9.31850001e-02f, -5.66520728e-02f, -6.90647736e-02f, 7.61398524e-02f, 3.75264734e-02f, 5.01198433e-02f, 1.04960687e-01f,
  -1.22291222e-01f, -8.28666687e-02f, -4.10330743e-02f, -6.81596026e-02f, 1.09163798e-01f, -1.67045165e-02f, 5.29556386e-02f, -2.88489144e-02f, 3.17377932e-02f, -6.72127977e-02f,
  -5.12095541e-02f, -2.59559229e-02f, -4.38100137e-02f, 3.75571810e-02f, 6.20954670e-02f, 9.47990082e-03f, -4.86292802e-02f, -3.46640013e-02f, 2.85771433e-02f, 5.40727414e-02f,
  1.19672641e-01f, -1.17334232e-01f, -2.87498236e-02f, 4.07443605e-02f, 2.62713861e-02f, 4.51414585e-02f, 1.80717185e-02f, -2.66771000e-02f, -5.50215244e-02f, -1.17265023e-02f,
  -2.90791243e-02f, -8.00076798e-02f, 4.72136773e-02f, 6.64355084e-02f, -6.69480562e-02f, 5.75991422e-02f, -1.25814214e-01f, -6.45426288e-02f, -1.07551524e-02f, 1.23982374e-02f,
  -3.68835144e-02f, -5.45768812e-02f, -9.82632264e-02f, 3.36392894e-02f, -1.34274632e-01f, -4.91842590e-02f, 7.28049055e-02f, -9.55288038e-02f, -4.79636267e-02f, 2.18333537e-03f,
  7.80194253e-02f, -1.22990683e-01f, 2.77380124e-02f, -2.97422428e-02f, 1.26512945e-01f, 2.89329756e-02f, 2.08512954e-02f, -1.20775446e-01f, -5.58152199e-02f, -1.79662421e-01f,
  -4.85414118e-02f, 3.01701128e-02f, 1.14314020e-01f, 1.27631538e-02f, 7.01125190e-02f, -1.36198720e-03f, -2.33646389e-02f, 2.58276556e-02f, 2.81292479e-02f, -6.52986839e-02f,
  -4.26690206e-02f, 7.40428045e-02f, 4.95942682e-02f, -1.14559166e-01f, -6.72198683e-02f, -5.03494106e-02f, -6.13710172e-02f, 8.54080394e-02f, -1.10971101e-01f, 8.81377161e-02f,
  2.58746911e-02f, 1.23516265e-02f, -6.17775507e-02f, -1.12444526e-02f, 2.25243010e-02f, -1.82445459e-02f, -4.10343753e-03f, 3.32577191e-02f, -3.77854109e-02f, 6.16986826e-02f,
  6.86274841e-02f, 5.45362495e-02f, 3.62504423e-02f, -6.72266399e-03f, -6.62662089e-02f, -3.98985855e-03f, -7.04838708e-02f, 5.60423620e-02f, 4.23436314e-02f, 8.44645575e-02f,
  -4.49003913e-02f, -3.87767963e-02f, 3.43136303e-02f, 5.54308742e-02f, -6.94823340e-02f, -3.77529599e-02f, 9.89393890e-02f, 1.33834714e-02f, -5.59335984e-02f, -7.63636306e-02f,
  -4.69219498e-02f, 1.47322938e-02f, -5.97669408e-02f, 8.07800516e-02f, 1.54332463e-02f, -6.70644343e-02f, 4.19158116e-02f, 1.56454439e-03f, 6.90889284e-02f, 4.24571000e-02f,
  -3.73342484e-02f, 1.87368505e-02f, -2.84301210e-02f, 1.77102312e-02f, 6.75016120e-02f, 3.53294611e-02f, 3.72764058e-02f, -2.93235239e-02f, 4.42039929e-02f, -5.42538799e-02f,
  -1.49750728e-02f, -4.82369475e-02f, -6.36554584e-02f, -6.48535788e-03f, 4.64080367e-03f, -4.04029241e-04f, 7.14503974e-02f, -1.17427576e-03f, -3.74135114e-02f, 1.02552079e-01f,
  -5.81704155e-02f, -1.30627081e-01f, 5.92756420e-02f, 5.92973568e-02f, 7.44696185e-02f, 2.78543085e-02f, -5.39935380e-02f, -4.66113873e-02f, -6.93637952e-02f, -5.30406274e-02f,
  -1.46583524e-02f, -5.04260175e-02f, -2.40174751e-03f, -2.02209000e-02f, -8.97481851e-03f, -5.11406735e-02f, -4.34881002e-02f, -3.52849290e-02f, 4.86226194e-02f, 2.22034715e-02f,
  2.78295539e-02f, -6.96392357e-02f, -3.78035270e-02f, -8.57714787e-02f, -2.52245199e-02f, -5.02753891e-02f, 4.61265817e-02f, -7.81347752e-02f, -7.66673386e-02f, -9.11789164e-02f,
  -1.74364880e-01f, 1.91228092e-01f, -1.26297638e-01f, -1.53538674e-01f, -2.20825616e-02f, -9.50438231e-02f, -8.02103132e-02f, -2.69851666e-02f, -3.58823407e-03f, 4.79642823e-02f,
  -4.84527880e-03f, 1.95238180e-02f, 4.61771935e-02f, -9.74344984e-02f, -2.58174837e-01f, -2.82718968e-02f, -1.37204695e-02f, 4.41948362e-02f, -8.84151235e-02f, -2.27863993e-02f,
  -3.11306212e-02f, 5.41984476e-02f, -1.34608403e-01f, 2.18064673e-02f, -3.98363136e-02f, -7.98286498e-02f, -1.54449008e-02f, 2.88369623e-03f, -2.75931647e-03f, 6.80332631e-02f,
  -1.10868543e-01f, -9.54509601e-02f, -1.24203958e-01f, -9.83952805e-02f, -3.03638969e-02f, -7.19195455e-02f, -6.92826556e-03f, 4.08053352e-03f, -1.65687129e-02f, -2.24616826e-02f,
  8.82355720e-02f, -6.01401925e-02f, 4.18456458e-02f, -5.12945801e-02f, -7.99059961e-03f, -5.40257134e-02f, 3.18375081e-02f, -9.56444889e-02f, -7.54298344e-02f, -7.97640905e-02f,
  3.72146890e-02f, 4.02120464e-02f, -8.43486413e-02f, -7.48864748e-03f, -8.00418332e-02f, -4.83029708e-02f, -4.12695706e-02f, -4.46672589e-02f, 8.19739550e-02f, 5.00336103e-03f,
  8.53793919e-02f, 9.85082537e-02f, -1.55575043e-02f, 7.44192302e-02f, 7.47213811e-02f, 4.39360887e-02f, 1.71102565e-02f, 2.22517624e-02f, 8.01771581e-02f, -6.76743463e-02f,
  -3.19042206e-02f, -4.27450500e-02f, -2.50687227e-02f, 6.58762082e-02f, 4.61518504e-02f, -4.76769619e-02f, -9.04406086e-02f, 5.13271056e-02f, -5.49291968e-02f, 3.27524613e-03f,
  -4.19652238e-02f, 2.11313721e-02f, 5.80332354e-02f, 1.12749415e-03f, -4.22001928e-02f, 5.66382483e-02f, -2.79776677e-02f, 6.41072690e-02f, 5.79615086e-02f, -9.31738615e-02f,
  2.23755725e-02f, 1.44603942e-02f, -3.31094116e-02f, -6.91189151e-03f, 8.46036151e-02f, -5.23080938e-02f, 7.98439458e-02f, 5.34500815e-02f, -7.50765577e-02f, 3.50957885e-02f,
  6.07990921e-02f, -9.31397732e-03f, -8.56664777e-02f, -4.50718217e-02f, 4.79295738e-02f, -9.57433321e-03f, 3.52560566e-03f, -5.99985570e-02f, 8.89294446e-02f, 1.49450963e-02f,
  -3.74613293e-02f, 9.86509994e-02f, 1.52861215e-02f, 3.79848741e-02f, -1.64526794e-02f, 7.96006471e-02f, -7.58699998e-02f, -5.23946583e-02f, -7.77211934e-02f, 3.15670483e-02f,
  5.37962131e-02f, -1.61345810e-01f, 3.20817530e-02f, 1.88702643e-01f, 7.93772116e-02f, 8.41491576e-03f, 2.12511167e-01f, -1.00787632e-01f, 2.94420868e-01f, -4.87891287e-02f,
  -7.57434815e-02f, -5.82364574e-02f, 1.09824073e-02f, -6.19771779e-02f, 7.39093274e-02f, 1.31703347e-01f, 7.52552645e-03f, 9.08414181e-03f, 5.47774062e-02f, 1.24988165e-02f,
  1.32019669e-01f, -8.49849135e-02f, -1.37853846e-01f, -1.30149409e-01f, -5.00707068e-02f, -1.44453973e-01f, -1.03713647e-01f, -1.17346421e-01f, -9.47122276e-02f, 3.78695726e-02f,
  7.11239800e-02f, -3.41927707e-02f, -2.71550603e-02f, -2.28109676e-02f, 1.87061857e-02f, -3.18678236e-03f, -3.80786955e-02f, -8.47712979e-02f, 6.33371025e-02f, 2.59853713e-02f,
  9.23486799e-02f, 5.59965484e-02f, -1.16834650e-02f, -3.54047865e-02f, -9.21736732e-02f, -3.67951132e-02f, -9.36995726e-03f, -5.11122085e-02f, 2.96067521e-02f, -3.61974761e-02f,
  5.23560494e-02f, 4.18924615e-02f, 8.45220163e-02f, -5.01169823e-02f, -5.74213192e-02f, -4.86935629e-03f, -6.27053156e-02f, 3.36643532e-02f, 7.02575371e-02f, -2.06885282e-02f,
  -8.43767971e-02f, -4.06032205e-02f, -5.63674569e-02f, 1.94945429e-02f, 2.57887337e-02f, -1.86594985e-02f, -2.20159199e-02f, 1.93343945e-02f, 1.25106752e-01f, -5.10807075e-02f,
  1.01008959e-01f, 3.37038562e-02f, 3.53479711e-03f, -4.08560336e-02f, 6.67093620e-02f, 8.39641467e-02f, 7.67825469e-02f, 3.20327729e-02f, 4.23284434e-02f, -3.60047370e-02f,
  -3.02580521e-02f, 9.37900394e-02f, -1.89769156e-02f, -4.73704375e-02f, 3.25020812e-02f, -6.09634537e-03f, 2.52419412e-02f, -5.31667918e-02f, 1.56816076e-02f, -3.80368195e-02f,
  9.27222669e-02f, 1.22167349e-01f, -6.92362040e-02f, 3.83190587e-02f, -4.23405655e-02f, -2.60976795e-02f, 1.88813154e-02f, -1.86374225e-02f, -6.95688948e-02f, -3.56392115e-02f,
  1.04287639e-02f, 6.40475899e-02f, 2.60146689e-02f, -7.18572810e-02f, 2.95863524e-02f, 2.01550574e-04f, -2.95577422e-02f, 9.23919976e-02f, -1.10677658e-02f, -1.80456396e-02f,
  2.61305049e-02f, 2.02576146e-02f, 8.92275572e-03f, 4.13990766e-02f, 2.12257672e-02f, 5.99483307e-03f, 6.55373260e-02f, -1.07248358e-01f, -8.63390192e-02f, 7.32064545e-02f,
  1.32178918e-01f, -2.58595627e-02f, -1.38471588e-01f, -7.57780448e-02f, -1.17252074e-01f, 1.94139391e-01f, 2.58873075e-01f, -6.69995397e-02f, -7.74221644e-02f, 1.65387601e-01f,
  6.43442348e-02f, -9.06669721e-02f, 1.39832303e-01f, 2.52829313e-01f, 8.70541483e-02f, 1.63935408e-01f, 1.98292881e-01f, 9.26600620e-02f, -9.08103064e-02f, 6.97113723e-02f,
  -6.28900826e-02f, 2.28239551e-01f, -1.04698382e-01f, -1.43657088e-01f, 3.44604589e-02f, -1.68040097e-01f, 3.91203240e-02f, -1.98026821e-01f, 5.59977591e-02f, 8.80136639e-02f,
  1.19305916e-01f, 5.29770069e-02f, -1.22078881e-01f, -4.59948890e-02f, 4.92399558e-02f, -6.39201999e-02f, -8.27398002e-02f, -6.14733901e-03f, -6.61852583e-02f, -5.22836447e-02f,
  2.08180062e-02f, -1.78073477e-02f, 5.50352074e-02f, -2.05529272e-03f, -1.06996810e-03f, -6.81364387e-02f, 2.57234760e-02f, -8.51489455e-02f, -1.00888498e-01f, -7.12086484e-02f,
  5.31816818e-02f, -5.31522408e-02f, -7.38102347e-02f, 3.63567621e-02f, 8.05750024e-03f, -2.40605045e-02f, 7.39973783e-02f, -8.72302949e-02f, -3.05590145e-02f, 1.73726659e-02f,
  8.47088918e-02f, 2.52668187e-03f, -2.61477870e-03f, -2.40540691e-02f, 6.60447255e-02f, -3.22727486e-02f, 3.71124223e-02f, -6.16440699e-02f, -7.98507035e-02f, -2.40710117e-02f,
  4.78180423e-02f, -3.88135985e-02f, -7.34564736e-02f, 7.37304911e-02f, 9.04539824e-02f, 3.32754068e-02f, -7.62500763e-02f, 3.41576822e-02f, 5.30788861e-02f, -2.88655758e-02f,
  1.16671706e-02f, 3.21865809e-04f, -6.48267716e-02f, -5.17223217e-02f, -1.42807858e-02f, 2.30747480e-02f, -5.43733425e-02f, -4.27889600e-02f, -5.16342036e-02f, 7.25262836e-02f,
  1.22176170e-01f, -1.83534287e-02f, 5.56530878e-02f, 6.59035668e-02f, 2.44835950e-03f, 6.26071393e-02f, -1.51734194e-02f, 4.83310111e-02f, 3.76437791e-02f, -5.08471057e-02f,
  6.05372787e-02f, -2.28342367e-03f, 2.35452615e-02f, -5.62175959e-02f, -3.26257274e-02f, 7.80148283e-02f, 8.91985465e-03f, -3.42942961e-02f, 6.49269596e-02f, 3.96299176e-03f,
  -4.61679772e-02f, -2.46217474e-02f, 5.68259135e-02f, -7.18761235e-02f, -8.47177953e-02f, -3.18026915e-02f, -5.84228523e-02f, -1.81968492e-02f, 2.36710217e-02f, 5.03877290e-02f,
  5.06245205e-03f, 6.69625849e-02f, 4.38540429e-02f, -5.34030348e-02f, 6.51188046e-02f, -2.16335713e-04f, 3.21055874e-02f, 1.51387036e-01f, 2.33018473e-02f, -4.69716936e-02f,
  3.43742259e-02f, 8.12837761e-03f, -1.03704214e-01f, -1.52408155e-02f, -5.82452444e-03f, -5.70283830e-02f, 4.02477756e-02f, -9.88751948e-02f, -5.37282601e-02f, 1.00557834e-01f,
  4.98869382e-02f, 3.34570836e-03f, -5.92404939e-02f, 1.41909197e-01f, -2.88038682e-02f, -3.63638960e-02f, 1.88935492e-02f, -8.99165031e-03f, 9.79172625e-03f, -9.17815696e-03f,
  -8.14041495e-02f, -2.65419800e-02f, -7.81054469e-03f, -7.68931657e-02f, 1.16699710e-01f, 8.65407884e-02f, 2.93400083e-02f, 5.03362017e-03f, -7.59989619e-02f, 7.71823600e-02f,
  4.59928922e-02f, -8.61542299e-02f, 8.27904865e-02f, 6.25371560e-02f, 5.67065775e-02f, 7.12007433e-02f, -7.07900301e-02f, -6.36805966e-02f, 9.74901319e-02f, -2.78819576e-02f,
  -5.22629581e-02f, -6.43925816e-02f, -1.59454588e-02f, 3.50081660e-02f, -7.38059578e-04f, 9.45140570e-02f, 4.57436480e-02f, 4.22049202e-02f, 9.31948051e-02f, 8.74950215e-02f,
  1.80762392e-02f, -4.18753596e-03f, -7.37217963e-02f, -7.09952191e-02f, -9.56296027e-02f, 9.47209224e-02f, 4.07375097e-02f, 2.98996400e-02f, -4.65892851e-02f, 7.49382824e-02f,
  6.92231022e-03f, -1.62917320e-02f, 6.43970910e-03f, -7.54373744e-02f, -5.93303330e-02f, 5.97011903e-03f, -6.71174973e-02f, -5.21695539e-02f, -5.82596138e-02f, -5.94842099e-02f,
  3.35030295e-02f, -7.33578950e-02f, -9.47324485e-02f, -2.42100190e-02f, 3.72673944e-02f, -2.63297502e-02f, -7.34337717e-02f, -7.44687989e-02f, 1.44122941e-02f, -2.72926409e-02f,
  1.08091481e-01f, 9.84937251e-02f, -6.53819516e-02f, 4.94961292e-02f, 6.44534603e-02f, 5.59313037e-02f, 3.00250622e-03f, -1.89293660e-02f, 2.37931795e-02f, -1.97580587e-02f,
  8.39457586e-02f, -6.33306205e-02f, 7.00920597e-02f, -1.00464568e-01f, 3.84989232e-02f, 1.02515206e-01f, 5.44844195e-02f, -1.50045976e-02f, 1.42493816e-02f, 3.56634147e-02f,
  -5.68914339e-02f, 2.74610315e-02f, -2.81039663e-02f, -6.24945797e-02f, 1.19162835e-02f, 2.48308070e-02f, 2.20455769e-02f, 5.55278850e-04f, 2.49856226e-02f, 3.44115607e-02f,
  1.11713611e-01f, -1.19011417e-01f, -1.32500440e-01f, 2.36581508e-02f, -2.38747019e-02f, -2.91503239e-02f, -1.19759664e-01f, -7.97069818e-02f, -7.96074644e-02f, 4.69110198e-02f,
  1.40158355e-01f, -2.45067365e-02f, -6.02812655e-02f, 1.17387190e-01f, 1.72177613e-01f, 9.07738432e-02f, 1.35913081e-02f, 7.54369497e-02f, -8.42767283e-02f, 1.97023116e-02f,
  1.16148680e-01f, 1.80365711e-01f, 1.39016256e-01f, 3.75479087e-02f, 4.42883931e-02f, -6.03852756e-02f, 5.65416031e-02f, -3.17380503e-02f, 1.54179543e-01f, 1.58309340e-01f,
  -2.55300160e-02f, -1.49412602e-02f, -1.97663857e-03f, -1.13610029e-02f, -5.95133118e-02f, -1.69268157e-02f, -3.73586006e-02f, 5.23619689e-02f, 2.74273232e-02f, -5.20636290e-02f,
  -4.19402607e-02f, -1.91616137e-02f, -2.38520429e-02f, -3.70114110e-02f, 1.10911978e-02f, -3.23506854e-02f, -6.15316220e-02f, -8.19427054e-03f, -1.05836056e-01f, 7.51975700e-02f,
  3.21723707e-02f, 2.94311484e-03f, -7.11009353e-02f, -1.43462457e-02f, -2.22138334e-02f, 7.30112642e-02f, -7.32195079e-02f, 6.02671467e-02f, -3.19122821e-02f, 2.01970674e-02f,
  -1.02186054e-01f, 7.72031769e-02f, -3.30481529e-02f, 1.05319768e-01f, -4.98435907e-02f, -6.77137300e-02f, -4.30653952e-02f, 3.74069884e-02f, -3.03935669e-02f, -9.71658677e-02f,
  7.88226128e-02f, -6.20324463e-02f, -1.73653159e-02f, 6.95159510e-02f, 9.52682346e-02f, 5.34835346e-02f, 8.31175670e-02f, 4.97220531e-02f, -5.75191639e-02f, -3.59999947e-02f,
  2.63060331e-02f, -6.80510327e-02f, -5.60214324e-03f, 8.43079984e-02f, 5.28068021e-02f, -9.13425833e-02f, -7.15562329e-02f, -5.19816354e-02f, 6.77716807e-02f, -2.90293545e-02f,
  -6.03959151e-02f, 6.44129841e-03f, 3.15009542e-02f, 6.07896820e-02f, -6.95036948e-02f, 6.31991103e-02f, 6.83580488e-02f, 7.30768517e-02f, 2.98540425e-02f, 3.94963333e-03f,
  4.20059673e-02f, -5.01926802e-02f, 5.78121543e-02f, 2.00915243e-02f, 8.36727023e-02f, -6.09373040e-02f, 6.22570328e-02f, -7.92330876e-02f, -8.10307562e-02f, -7.28348419e-02f,
  -5.81192300e-02f, -5.56892492e-02f, -1.85205252e-03f, -6.37856871e-02f, -4.82653640e-02f, -7.30188712e-02f, -2.21547429e-02f, -7.00304508e-02f, -4.88914698e-02f, -2.25646663e-02f,
  1.40478238e-01f, -1.93741545e-02f, 4.25259657e-02f, 7.27933496e-02f, 1.00709938e-01f, 5.49505278e-02f, 1.52492970e-02f, 9.90970507e-02f, 9.13676806e-03f, -7.75468275e-02f,
  -9.43206549e-02f, -1.21445969e-01f, -8.52427930e-02f, -6.28011525e-02f, 4.33917716e-02f, -1.99224707e-02f, -2.03298051e-02f, -4.97884676e-02f, 4.70166616e-02f, -2.62152739e-02f,
  -2.74911430e-02f, 9.79923364e-03f, 3.74021605e-02f, -1.88147482e-02f, -2.69464087e-02f, 3.96304764e-02f, -7.17952028e-02f, -5.52032404e-02f, -1.23644605e-01f, -3.19623686e-02f,
  1.79434363e-02f, 6.24704137e-02f, 7.84934387e-02f, 1.70655679e-02f, 9.20565352e-02f, -6.80193603e-02f, 4.05846946e-02f, -3.54056358e-02f, 8.23589712e-02f, 1.03282861e-01f,
  -3.04532908e-02f, -3.34469154e-02f, -6.61221370e-02f, 2.66735516e-02f, 1.07372940e-01f, 1.05344892e-01f, -2.21075602e-02f, -3.80481929e-02f, -2.10321089e-03f, 1.04305372e-01f,
  -1.87724903e-02f, 6.94593787e-02f, 1.02782827e-02f, -3.96230556e-02f, -5.46868183e-02f, -7.00321570e-02f, -1.04727812e-01f, -5.36031127e-02f, -7.46739879e-02f, -1.19222915e-02f,
  1.94022469e-02f, 7.08984733e-02f, 2.10179072e-02f, -3.14407386e-02f, 9.05910730e-02f, 8.66313130e-02f, 5.00808656e-02f, -1.84716154e-02f, 2.75559463e-02f, -7.07641691e-02f,
  8.17401856e-02f, -4.43399362e-02f, 1.20666130e-02f, 2.26904638e-02f, 2.32027210e-02f, -4.30870382e-03f, -2.32233126e-02f, 6.61499202e-02f, -1.23077659e-02f, 2.66908831e-03f,
  -6.76283240e-02f, 6.93375766e-02f, 6.30962178e-02f, -6.78885803e-02f, -6.00555912e-02f, 8.87395814e-03f, 3.27757979e-03f, 2.27295533e-02f, -3.97729799e-02f, -2.24274658e-02f,
  -9.40542016e-03f, -1.57382160e-01f, 3.62250209e-02f, 1.70665216e-02f, 4.24488820e-02f, 1.91178713e-02f, -3.95744666e-02f, 1.10607125e-01f, -1.64824128e-02f, 7.60957524e-02f,
  -1.40060820e-02f, -7.98734128e-02f, 4.34731096e-02f, -7.92433545e-02f, -3.38112898e-02f, 9.61321220e-02f, -2.76820846e-02f, -9.19266492e-02f, -1.58503726e-02f, 3.99949625e-02f,
  -1.96755473e-02f, -7.98749924e-02f, 4.56799604e-02f, 8.29219520e-02f, 9.58744623e-03f, -3.37150507e-02f, 6.98728561e-02f, -6.00079857e-02f, 3.48148681e-02f, -3.67270000e-02f,
  8.54988396e-02f, -3.07910480e-02f, 1.96329072e-01f, 8.86360183e-02f, 4.15557437e-02f, -1.16689011e-01f, 4.94549684e-02f, -1.01646349e-01f, -7.04144984e-02f, -1.05335228e-01f,
  -1.79496482e-02f, 1.05373971e-01f, 6.47739321e-03f, -1.04392238e-01f, 7.02644587e-02f, -2.90868357e-02f, -1.29736081e-01f, -4.63321693e-02f, 8.58300552e-02f, 5.74781410e-02f,
  -5.55012561e-03f, -1.07707910e-01f, -1.18109221e-02f, -1.00480318e-02f, -1.80262551e-02f, 7.93498009e-02f, 5.31779118e-02f, -1.52466092e-02f, -1.02220394e-01f, 3.39625701e-02f,
  -4.65311110e-02f, 7.63297454e-02f, 7.81400427e-02f, -5.59190474e-02f, 7.03670979e-02f, -7.16301724e-02f, 2.03020647e-02f, -6.20382242e-02f, 5.67370579e-02f, 1.25497179e-02f,
  7.31984898e-02f, 5.40580712e-02f, -3.30398120e-02f, 4.26403806e-02f, -2.81013586e-02f, -5.12545109e-02f, -3.82053368e-02f, -1.34697212e-02f, 3.19412313e-02f, 7.39634931e-02f,
  1.11089393e-01f, -3.50630656e-02f, 2.84615550e-02f, -9.70309693e-03f, 3.35459039e-02f, -7.87260607e-02f, 4.97164652e-02f, -6.67046476e-03f, 5.16369380e-03f, 6.29528426e-03f,
  1.09710768e-01f, -3.42913270e-02f, 5.66661283e-02f, 2.98976786e-02f, -4.61768694e-02f, -1.99334957e-02f, 3.72158661e-02f, 2.39755381e-02f, -4.40989342e-03f, 7.22041205e-02f,
  -6.21579662e-02f, 8.05076808e-02f, -8.42607990e-02f, 6.86034840e-03f, -8.32665861e-02f, 1.47694051e-02f, -1.04243020e-02f, -6.57503083e-02f, -6.26819804e-02f, -8.56658742e-02f,
  7.84905404e-02f, 3.93119786e-04f, 7.29766935e-02f, 4.46661003e-02f, -8.33357349e-02f, 3.04699130e-02f, -5.35565354e-02f, -6.73866868e-02f, -9.45243705e-03f, -7.26286471e-02f,
  4.52138260e-02f, -8.98606032e-02f, -3.91515642e-02f, 2.51846984e-02f, -3.25195640e-02f, -6.54997453e-02f, 3.65856588e-02f, 3.87078039e-02f, -9.69031155e-02f, -9.74854901e-02f,
  6.26479089e-02f, -4.04714569e-02f, 4.44495566e-02f, 4.87687178e-02f, -7.00151771e-02f, 3.11092939e-02f, 2.93147098e-03f, 1.17018735e-02f, -1.70984324e-02f, 4.18228582e-02f,
  -1.95120263e-03f, 2.43059499e-03f, 5.13617620e-02f, -5.34559414e-02f, -5.05029857e-02f, -6.68405369e-03f, -4.75354642e-02f, -7.88571835e-02f, 3.95182595e-02f, 3.21049690e-02f,
  -1.36171669e-01f, -9.49662458e-03f, -1.15501121e-01f, -1.85694307e-01f, -4.90594283e-02f, -1.13854460e-01f, -3.33210528e-02f, -1.24931321e-01f, -9.13933441e-02f, 1.80411395e-02f,
  2.49845069e-02f, -1.29415439e-02f, 1.09337114e-01f, -2.32832640e-01f, -6.44200444e-02f, 3.72140529e-03f, -1.13717362e-01f, -1.03399895e-01f, -7.35336989e-02f, -1.69405863e-01f,
  -1.09359339e-01f, -1.64922178e-01f, -1.56566218e-01f, -8.64273757e-02f, -8.32113028e-02f, -3.68272327e-02f, 1.66661531e-01f, -8.54544640e-02f, -1.38805792e-01f, 2.34858450e-02f,
  3.75516191e-02f, 1.63394026e-02f, 1.08388355e-02f, 1.71991643e-02f, -2.84004472e-02f, -1.45486165e-02f, -4.91622239e-02f, 6.16854057e-02f, -2.51958128e-02f, -2.06811242e-02f,
  6.14960007e-02f, 5.29547781e-02f, -4.43983003e-02f, -8.16003457e-02f, 1.26993395e-02f, 1.04138674e-02f, -5.47685660e-02f, -9.84719489e-03f, 4.59837317e-02f, 1.90612935e-02f,
  -6.89188689e-02f, -4.16185474e-03f, 8.58475417e-02f, -2.63370313e-02f, -5.39198741e-02f, -9.20088813e-02f, 9.43247005e-02f, -2.02041119e-02f, -5.35307601e-02f, 4.64516357e-02f,
  1.56377722e-02f, 4.22668755e-02f, 1.12935039e-03f, -7.14599192e-02f, 4.63287905e-02f, -7.61869922e-03f, 2.19141599e-02f, 8.66926983e-02f, -8.86585936e-03f, 8.45020786e-02f,
  -2.54297294e-02f, -1.02574527e-01f, -5.66402078e-03f, -6.87562861e-04f, 6.67836890e-02f, -3.20971273e-02f, 2.12581619e-03f, 8.94795954e-02f, 5.05776145e-02f, 5.07596657e-02f,
  8.21923837e-02f, -5.31983078e-02f, -3.10218055e-02f, 5.38273714e-02f, 6.25621453e-02f, 9.11666304e-02f, -7.69620091e-02f, -8.92483741e-02f, 8.59305114e-02f, -8.32292438e-03f,
  7.74941593e-02f, -8.18646550e-02f, 3.58390696e-02f, -8.22546259e-02f, -4.00151387e-02f, -2.65839957e-02f, -2.55350191e-02f, -8.35372433e-02f, 9.11020767e-03f, 1.69967599e-02f,
  -4.05153222e-02f, 1.92960054e-02f, 4.07220237e-02f, 8.94945711e-02f, -2.75562070e-02f, 2.52856594e-03f, 6.38327897e-02f, -2.41029505e-02f, 7.94721544e-02f, 6.39023036e-02f,
  -3.56608182e-02f, 9.57040638e-02f, 5.54587655e-02f, 2.83927917e-02f, 1.43629331e-02f, 6.30870387e-02f, -1.16318790e-02f, 6.98979422e-02f, -4.32641432e-02f, 1.05486978e-02f,
  -4.29074541e-02f, 2.06313282e-02f, -1.49082076e-02f, -1.84709416e-03f, 9.16795433e-02f, 2.26381555e-01f, 1.03726983e-01f, 4.99836579e-02f, 1.41716495e-01f, -3.35266218e-02f,
  5.02787866e-02f, -1.35689393e-01f, -2.36241028e-01f, 1.17560692e-01f, 4.61220481e-02f, 9.82297286e-02f, 2.48801827e-01f, 6.05093390e-02f, 5.30806370e-02f, 6.84831813e-02f,
  1.01873010e-01f, 1.30486041e-01f, -1.36190474e-01f, -2.42623333e-02f, 3.44568901e-02f, -1.23525495e-02f, -6.51925281e-02f, -1.56883091e-01f, 1.09360501e-01f, 7.26418048e-02f,
  6.19754493e-02f, 1.39926989e-02f, -1.08998604e-01f, -1.65725853e-02f, 2.18070000e-02f, -1.11331798e-01f, -3.58524802e-03f, 4.17566486e-02f, -2.53761262e-02f, 1.16857756e-02f,
  1.93091352e-02f, 5.32247908e-02f, 4.17539775e-02f, 5.79735525e-02f, 9.86845195e-02f, -9.15291309e-02f, -5.77203445e-02f, 2.41205692e-02f, -3.99024133e-03f, -8.80301595e-02f,
  -1.08511776e-01f, 7.80419633e-02f, -6.39645159e-02f, 5.14112823e-02f, 5.16803078e-02f, 4.30117967e-03f, 3.46974060e-02f, -4.86602373e-02f, 3.88864838e-02f, -5.75178564e-02f,
  -5.55807091e-02f, 1.34096760e-02f, -1.16661668e-01f, -3.89364772e-02f, 3.41793895e-02f, 1.87920462e-02f, -6.24437304e-03f, -5.82745336e-02f, -2.85235280e-03f, -1.56994462e-02f,
  1.16335899e-02f, -4.47110720e-02f, 2.02850923e-02f, 1.09028816e-01f, -6.91346526e-02f, 5.75238653e-02f, -5.31501621e-02f, 8.37338716e-02f, -9.84549820e-02f, -3.81958149e-02f,
  -3.10283881e-02f, -6.20998107e-02f, -7.60987997e-02f, 2.11281125e-02f, -1.48502004e-04f, -9.08499211e-02f, -8.13143104e-02f, -8.80267099e-02f, -7.87514299e-02f, -5.36623225e-02f,
  1.24957114e-02f, 5.41797876e-02f, -3.51746418e-02f, -1.92384813e-02f, 2.80700438e-02f, 8.68711844e-02f, -2.64288634e-02f, 7.53988475e-02f, -2.18541343e-02f, 8.38497505e-02f,
  4.62806858e-02f, 1.98578127e-02f, 5.65999895e-02f, 2.83593987e-03f, 8.16358179e-02f, 1.82975531e-02f, 4.64319177e-02f, -5.55279069e-02f, 1.24858634e-03f, 4.42455560e-02f,
  -3.65185291e-02f, -3.62791754e-02f, -1.77475940e-02f, -6.87847380e-03f, 1.54279405e-02f, 5.23897409e-02f, 4.36285362e-02f, -1.18140387e-03f, -6.40393747e-03f, -2.99667604e-02f,
  1.41276062e-01f, -9.56782326e-02f, -1.25839353e-01f, 1.18525252e-01f, 5.69616109e-02f, 1.08633555e-01f, -1.19551755e-01f, -3.13651450e-02f, -4.15221639e-02f, 2.60809492e-02f,
  -3.69009413e-02f, 3.06395907e-02f, -2.41447657e-01f, 1.96206167e-01f, 1.78505871e-02f, -1.58000201e-01f, 2.11460531e-01f, 1.71704948e-01f, -2.59665418e-02f, -5.68944290e-02f,
  1.08609654e-01f, 7.45481104e-02f, 7.88608342e-02f, 4.48759571e-02f, 1.19049460e-01f, -5.10341823e-02f, -3.44748385e-02f, -1.56545937e-01f, 2.30908707e-01f, 2.60617714e-02f,
  1.45902053e-01f, -4.96214582e-03f, 1.68282737e-03f, 1.36653244e-01f, -1.13424420e-01f, 3.90853733e-03f, 7.71012381e-02f, 5.14741912e-02f, 4.20764498e-02f, -8.63315836e-02f,
  -3.97154167e-02f, 2.69380659e-02f, 1.63380295e-01f, -3.96184996e-02f, 7.19954595e-02f, 9.92278084e-02f, 6.95007890e-02f, -8.58306363e-02f, -5.94950281e-02f, -2.19486579e-02f,
  -7.30122551e-02f, 6.06805552e-03f, -5.84089532e-02f, 9.74124372e-02f, -5.74552491e-02f, 6.75958246e-02f, 5.12379147e-02f, -6.14268631e-02f, -6.55293465e-02f, -4.55471426e-02f,
  -1.04980394e-01f, 1.57744940e-02f, -8.86373743e-02f, 1.90927386e-02f, -7.11012185e-02f, 9.70730931e-02f, -5.09926379e-02f, -4.61891033e-02f, -1.70909185e-02f, -9.26274341e-03f,
  -3.82490084e-02f, 3.54876965e-02f, -3.33863087e-02f, -2.83748135e-02f, 2.56860070e-02f, -5.29007390e-02f, -6.48292005e-02f, -2.97397338e-02f, 7.16924220e-02f, 9.27124731e-03f,
  3.18291411e-02f, -2.51014903e-02f, -3.79605517e-02f, -4.20638211e-02f, -3.24852876e-02f, -6.50817305e-02f, 8.77208933e-02f, 5.82484417e-02f, -8.52381214e-02f, -9.24734548e-02f,
  -7.65075162e-03f, -1.29987031e-01f, -6.40635490e-02f, 7.57464543e-02f, 6.12103529e-02f, -6.34042844e-02f, 8.33185688e-02f, 1.05480604e-01f, -3.03911846e-02f, 2.62877941e-02f,
  6.87601343e-02f, -1.44095821e-02f, 5.94255961e-02f, 9.92062762e-02f, 2.91103013e-02f, 5.96086122e-03f, -2.17535477e-02f, 3.26298289e-02f, 5.86271472e-03f, -1.88784115e-02f,
  -9.84502733e-02f, -7.65760988e-02f, 6.43791631e-02f, 4.75536697e-02f, 7.56802857e-02f, -1.13890637e-02f, -1.92301422e-02f, -5.31154312e-02f, 1.24871843e-02f, 8.79615769e-02f,
  4.15344797e-02f, -1.82665050e-01f, 1.50899902e-01f, 1.96113899e-01f, 3.55363674e-02f, -1.44842073e-01f, 4.41280156e-02f, 7.37891421e-02f, -2.36253858e-01f, -2.59156853e-01f,
  1.73478693e-01f, -6.55977651e-02f, 3.66759934e-02f, 1.27937719e-01f, 2.16677025e-01f, 8.36004317e-02f, 6.56463429e-02f, -5.16525581e-02f, 2.62664575e-02f, 6.54587001e-02f,
  8.53855386e-02f, 1.43098339e-01f, 2.78057098e-01f, 7.97595829e-02f, 1.21336944e-01f, 5.40242866e-02f, 1.76790103e-01f, 9.21125337e-03f, 2.62745237e-03f, 2.52793934e-02f,
  -3.66176069e-02f, 3.55599262e-02f, 3.91762406e-02f, 1.13044411e-03f, -4.90738777e-03f, -4.65202145e-02f, -4.14190516e-02f, 4.30043675e-02f, 5.64837977e-02f, 3.94636318e-02f,
  -1.92974340e-02f, -2.13747974e-02f, -1.06155694e-01f, 6.41219467e-02f, -9.93053094e-02f, 9.26454028e-04f, 4.55580615e-02f, -1.07831120e-01f, 5.12977242e-02f, 5.39196990e-02f,
  9.05028135e-02f, 1.86419971e-02f, -7.54287243e-02f, -6.56561255e-02f, 1.11117005e-01f, -8.92921314e-02f, -5.34935407e-02f, 3.71761322e-02f, -1.25840842e-03f, -1.80615839e-02f,
  8.96479413e-02f, -8.78187343e-02f, -6.77061453e-02f, -3.47132832e-02f, -7.41170272e-02f, 9.63486172e-03f, -6.36251122e-02f, -5.75791784e-02f, -7.33074453e-03f, -6.41915668e-03f,
  8.28034356e-02f, 5.97153045e-02f, 2.05864143e-02f, -1.06266037e-01f, -4.39436138e-02f, -3.27605009e-02f, -3.35472785e-02f, 2.40527578e-02f, -7.67354295e-02f, 5.53021692e-02f,
  -7.35641941e-02f, -1.51299126e-02f, 3.59928422e-02f, 3.49174142e-02f, -8.52980614e-02f, 7.66880363e-02f, 4.61872555e-02f, -8.83580372e-03f, -4.20896709e-02f, -2.67278366e-02f,
  1.66933537e-02f, 4.28445898e-02f, 6.25211895e-02f, -3.00529674e-02f, 6.72284886e-02f, -6.62802253e-03f, -4.99738678e-02f, 6.91009536e-02f, 7.58325402e-03f, -4.38202359e-02f,
  -1.36444289e-02f, -2.28276681e-02f, 3.19725201e-02f, -6.59069270e-02f, -7.83165395e-02f, 2.58258358e-02f, 3.23897414e-02f, -8.72576311e-02f, -3.28235179e-02f, 3.19534242e-02f,
  -4.41782326e-02f, -4.23257276e-02f, -4.34242226e-02f, -7.31342584e-02f, -3.70899215e-02f, 8.51884559e-02f, -2.76427027e-02f, -6.85989335e-02f, 7.56328404e-02f, 4.97064143e-02f,
  2.18553305e-01f, 8.78551304e-02f, 1.04675867e-01f, 1.40405685e-01f, -3.95065621e-02f, -7.29663670e-02f, 1.40376523e-01f, 3.26665379e-02f, 1.56083614e-01f, 8.47968683e-02f,
  -1.34433746e-01f, 2.20603019e-01f, -1.13152057e-01f, 1.10279080e-02f, -7.22271204e-02f, -1.80769220e-01f, -2.00122781e-02f, 4.69012698e-03f, 8.50126445e-02f, -5.20402275e-04f,
  -2.96449754e-02f, -1.59058526e-01f, -8.62989277e-02f, -8.44515767e-03f, 1.29116010e-02f, 1.23965599e-01f, -1.62427604e-01f, -8.30599964e-02f, 9.99720171e-02f, 3.64446989e-03f,
  6.91897329e-03f, 3.82695720e-02f, 1.55644536e-01f, -7.59629486e-03f, 7.68433437e-02f, -2.40900693e-03f, 8.70322585e-02f, -1.05554767e-01f, -6.97384551e-02f, 1.84167046e-02f,
  -1.21516110e-02f, 4.12599295e-02f, 1.90068763e-02f, -3.87505367e-02f, 2.63872594e-02f, 4.58706729e-02f, 7.48555213e-02f, 2.04962604e-02f, 8.71676803e-02f, 8.43066052e-02f,
  1.41729146e-01f, 9.63387638e-02f, 8.22477639e-02f, 1.51748303e-02f, -1.36389316e-03f, -4.16541845e-02f, -2.10455284e-02f, 5.52097745e-02f, -2.01177001e-02f, -1.17486063e-03f,
  -7.90015608e-03f, 4.49565016e-02f, -2.55893208e-02f, 8.38708505e-02f, -4.23235260e-02f, -4.31622267e-02f, -6.43669516e-02f, -9.61730406e-02f, -2.96623521e-02f, 2.74149235e-02f,
  -5.53321093e-02f, 6.78134933e-02f, -6.02282472e-02f, -4.81940154e-03f, 4.02943976e-03f, 6.52346089e-02f, -3.11487839e-02f, -4.93192561e-02f, 3.65246013e-02f, 8.54057968e-02f,
  2.72297617e-02f, -3.69111188e-02f, 3.84549238e-02f, 7.90494159e-02f, 3.76288928e-02f, -8.19440410e-02f, -8.22435096e-02f, 1.76271647e-02f, -3.42012383e-02f, 2.53239907e-02f,
  -3.38235833e-02f, -1.48238674e-01f, 8.11626986e-02f, -5.83358034e-02f, -1.95488874e-02f, 6.12853728e-02f, 8.82770494e-03f, 3.48284096e-02f, -8.11525807e-02f, -5.00798710e-02f,
  -5.40576950e-02f, -1.81827471e-02f, -6.43819124e-02f, -9.17977095e-02f, -5.86916246e-02f, -1.04727954e-01f, 2.92917190e-04f, 9.56349075e-02f, 8.51047263e-02f, 3.18088271e-02f,
  6.60134181e-02f, 5.02714850e-02f, 5.23062386e-02f, -3.37353908e-02f, 4.26217914e-02f, -2.02145744e-02f, 8.53701532e-02f, -2.73383949e-02f, 1.18734278e-02f, -6.64340109e-02f,
  -1.92231461e-02f, 1.11497166e-02f, 4.02661115e-02f, -1.26676068e-01f, 1.62331417e-01f, 1.47711605e-01f, -1.33899212e-01f, 6.75448328e-02f, -1.36228755e-01f, -1.15413992e-02f,
  -8.24510232e-02f, 4.43608221e-03f, 2.58257482e-02f, -1.32142618e-01f, 3.38287908e-03f, -7.68955201e-02f, -8.93800631e-02f, -1.12855755e-01f, -6.69062287e-02f, -4.39737700e-02f,
  -1.21652089e-01f, -1.76106334e-01f, 4.27513905e-02f, 1.24185728e-02f, -2.46486031e-02f, -1.23497583e-02f, 9.22929216e-03f, 1.28269821e-01f, -1.07588246e-02f, -9.11175832e-02f,
  -7.97013566e-02f, -4.41811718e-02f, -1.66389588e-02f, -6.09501190e-02f, -5.25270775e-02f, -7.30943531e-02f, -3.39465663e-02f, -3.94266173e-02f, -1.36923073e-02f, -7.73012787e-02f,
  1.91387795e-02f, 6.34289458e-02f, 4.32937443e-02f, -9.78513360e-02f, -1.14659639e-02f, -3.89301591e-02f, 4.92031351e-02f, 5.62463552e-02f, -7.44392052e-02f, -3.07762455e-02f,
  -8.12980086e-02f, 6.64913133e-02f, -2.46479027e-02f, 5.45185655e-02f, -2.47360542e-02f, 1.50704021e-02f, 1.01392413e-03f, -3.91503982e-02f, 1.09641194e-01f, 3.42792496e-02f,
  -4.74725413e-04f, -3.81497219e-02f, -3.39380093e-02f, 4.61005326e-03f, -5.97392954e-02f, -4.28770073e-02f, -6.89866990e-02f, -3.21788862e-02f, 1.88619960e-02f, 3.76490504e-02f,
  -2.68626828e-02f, -7.54280612e-02f, 1.44646717e-02f, -2.30646599e-02f, 9.83431702e-04f, 1.33238891e-02f, 1.53961014e-02f, 8.66141170e-02f, 7.48207718e-02f, -1.27853537e-02f,
  -8.67654756e-02f, -1.04819983e-01f, -4.78018783e-02f, -3.62428129e-02f, 2.56453380e-02f, 1.95587589e-03f, -3.96016985e-02f, -1.77032519e-02f, -6.93723932e-02f, -6.81441873e-02f,
  8.98356065e-02f, 6.06982447e-02f, 6.36214614e-02f, -8.06882977e-02f, -5.71632385e-02f, 1.33952415e-02f, -2.08938066e-02f, -1.32834734e-02f, 5.13877161e-02f, 1.11316992e-02f,
  -8.52643326e-03f, 5.82767986e-02f, 7.76012838e-02f, -7.32053891e-02f, -4.09453437e-02f, 7.02933073e-02f, 3.46436948e-02f, -2.28211544e-02f, 3.44525203e-02f, -1.44641660e-02f,
  9.65075120e-02f, -7.37306401e-02f, 1.50489202e-02f, 9.94563326e-02f, -3.11276577e-02f, 6.28517568e-02f, 9.69947353e-02f, 4.21503820e-02f, 6.11341670e-02f, -5.54412752e-02f,
  4.90327030e-02f, 7.25335674e-03f, 1.32706836e-01f, 1.08619429e-01f, 5.52817807e-03f, 1.43132895e-01f, 1.67125300e-01f, 1.83828026e-01f, 2.71758229e-01f, -2.09739916e-02f,
  5.09813093e-02f, 2.57298108e-02f, 8.50530118e-02f, 8.24483931e-02f, 7.07499534e-02f, 6.96825609e-02f, 1.37939425e-02f, 4.23738398e-02f, 2.06203535e-01f, 5.24323946e-03f,
  3.09609678e-02f, 1.60888620e-02f, -7.50159994e-02f, -1.02803618e-01f, -9.91776139e-02f, 2.96855252e-02f, -1.38502359e-01f, -7.84040093e-02f, -1.68141797e-01f, -4.41093184e-02f,
  -8.55394229e-02f, 2.87392810e-02f, -4.41605002e-02f, 3.52334939e-02f, 5.78799890e-03f, 1.31031349e-02f, 3.91050242e-02f, 4.69816923e-02f, 4.33436595e-02f, 4.27863449e-02f,
  -4.65555415e-02f, -8.76140594e-03f, -3.77477556e-02f, 2.39096861e-03f, -2.04081573e-02f, -4.15439829e-02f, -1.06155369e-02f, -8.05724971e-03f, 2.17585335e-03f, -1.89855602e-02f,
  -1.36900283e-02f, 8.56231302e-02f, -1.73977986e-02f, -3.35330330e-02f, 7.44404048e-02f, 7.21634850e-02f, -6.51070289e-03f, -2.25193170e-03f, 1.96369700e-02f, 6.99424744e-02f,
  2.17672102e-02f, 1.03786811e-01f, -6.85403645e-02f, 8.84396397e-03f, -3.74058560e-02f, -4.83152419e-02f, 2.45566331e-02f, -7.44997934e-02f, -9.60072223e-03f, 7.02408925e-02f,
  6.84607923e-02f, 4.84787561e-02f, 1.14310496e-01f, 4.57465425e-02f, 5.48921674e-02f, 7.40997493e-02f, -1.18923880e-01f, 8.70200694e-02f, 8.38613734e-02f, -9.03714448e-02f,
  -8.20610225e-02f, -6.17059283e-02f, -2.16216799e-02f, 5.37637016e-03f, -4.76045422e-02f, 2.60388609e-02f, 6.87234625e-02f, -3.16067822e-02f, -1.80198364e-02f, -5.82488999e-02f,
  6.61765784e-02f, 1.49879232e-01f, -1.00335874e-01f, -8.43554586e-02f, -9.05642286e-02f, -1.08932033e-01f, 7.76866972e-02f, 4.86606434e-02f, 1.01531103e-01f, 8.63150135e-02f,
  -3.51244919e-02f, 3.98561396e-02f, -1.89723466e-02f, -8.72446746e-02f, 4.73894887e-02f, 5.87650836e-02f, 9.02215764e-02f, -1.20732225e-02f, 7.54869208e-02f, -3.70746432e-03f,
  -7.36038238e-02f, 4.49973829e-02f, -2.72425264e-02f, -4.84665819e-02f, -4.07726988e-02f, -1.08388804e-01f, 3.11762542e-02f, -3.63376178e-02f, 4.29054871e-02f, -3.90074588e-02f,
  -1.43440336e-01f, -1.96776599e-01f, 8.00677985e-02f, 3.94596569e-02f, -1.28081040e-02f, -9.81064420e-03f, 2.32528612e-01f, -1.39261872e-01f, -1.01417981e-01f, -2.27181148e-02f,
  1.09957367e-01f, -2.00587995e-02f, 7.55859986e-02f, 4.42381512e-04f, 4.07330357e-02f, -3.11561916e-02f, -3.65251526e-02f, 1.11969218e-01f, -2.77993828e-02f, -4.81819734e-03f,
  -1.31514460e-01f, -3.52926552e-02f, 4.94143665e-02f, -1.70881152e-01f, 4.08973433e-02f, 2.77225245e-02f, -2.25520451e-02f, 6.18018955e-02f, -7.38257915e-02f, -6.66506141e-02f,
  5.68419360e-02f, -5.85508756e-02f, -5.69062345e-02f, -3.39143090e-02f, 8.31206981e-03f, 4.01522107e-02f, 1.63517911e-02f, 1.32574394e-01f, 2.35612243e-02f, -8.94992501e-02f,
  -7.18481839e-02f, 4.33538994e-03f, -9.69455913e-02f, 6.31615072e-02f, 2.28837524e-02f, -8.96842629e-02f, 1.30090890e-02f, -1.13872276e-03f, -2.51178164e-03f, -7.30907097e-02f,
  -1.63136534e-02f, -8.65388736e-02f, 7.48327523e-02f, -1.86077636e-02f, 8.95366892e-02f, -2.08532512e-02f, 6.23856373e-02f, -3.12423464e-02f, -4.43572626e-02f, -1.75121427e-02f,
  1.82670150e-02f, -2.23127585e-02f, -1.75565872e-02f, -3.38223875e-02f, -2.50475220e-02f, -4.10091020e-02f, -5.16567752e-02f, 4.59695496e-02f, 9.03103575e-02f, 7.17037767e-02f,
  2.81502958e-03f, 4.57007363e-02f, 4.24993783e-03f, -6.71663433e-02f, 7.47173652e-02f, -4.78201099e-02f, 1.21275820e-01f, -3.87823991e-02f, 4.43699770e-02f, -8.41215998e-02f,
  8.37251991e-02f, -5.21388501e-02f, 6.64329007e-02f, 3.76730748e-02f, 2.91861650e-02f, -1.43631157e-02f, 2.36686021e-02f, -3.30587439e-02f, 3.03481389e-02f, 1.77922044e-02f,
  -1.05680399e-01f, -1.66797727e-01f, 1.59030147e-02f, 5.03754281e-02f, 4.78722341e-02f, -2.92230174e-02f, 7.63651729e-02f, -6.29823953e-02f, 6.09230101e-02f, -2.45113634e-02f,
  2.12121662e-02f, 4.48769145e-02f, -4.15303223e-02f, 1.00817136e-01f, 4.30756509e-02f, -9.36190635e-02f, 5.84567450e-02f, 7.51988739e-02f, -3.97190005e-02f, 3.12967338e-02f,
  -1.92845557e-02f, 3.60795036e-02f, 5.85509203e-02f, -6.09126948e-02f, 2.76673157e-02f, 4.12824079e-02f, -8.79255757e-02f, 4.99447398e-02f, 2.04774830e-02f, -9.45922062e-02f,
  -1.79727972e-01f, 1.91653952e-01f, -1.28682733e-01f, -1.70712426e-01f, -4.90150750e-02f, -7.22929761e-02f, -1.89486980e-01f, 1.32113293e-01f, 1.02685295e-01f, -2.55089835e-03f,
  -1.81267098e-01f, 1.00326784e-01f, 1.73696101e-01f, -2.07498416e-01f, -9.41260979e-02f, 1.32560357e-01f, -1.58293009e-01f, -1.85165688e-01f, 3.05421595e-02f, -2.63847820e-02f,
  -3.17240469e-02f, -1.70411497e-01f, -2.51773540e-02f, 2.76608262e-02f, -2.09134638e-01f, -4.36629429e-02f, -1.14327095e-01f, -7.70446062e-02f, -2.26733044e-01f, -2.95405462e-02f,
  -9.92188156e-02f, -6.51304722e-02f, -1.72417015e-01f, -4.21752706e-02f, -1.57199278e-01f, -9.23568979e-02f, -1.65294129e-02f, -6.19675517e-02f, 3.75135578e-02f, 5.97171597e-02f,
  7.84695745e-02f, 3.75926830e-02f, 2.77794860e-02f, 3.32212746e-02f, 9.61737894e-03f, -5.86080477e-02f, 6.08179756e-02f, -6.71690553e-02f, 1.06613636e-02f, 1.99404899e-02f,
  4.53750789e-02f, -3.94876860e-02f, -1.28568545e-01f, -4.68790792e-02f, -7.20559061e-02f, -1.22269593e-01f, 3.02709397e-02f, -1.00110471e-01f, -1.12040445e-01f, -7.67918304e-02f,
  -2.65527964e-02f, -9.32397097e-02f, 1.30995493e-02f, 1.73729341e-02f, -2.91737150e-02f, -2.52301749e-02f, 6.14456274e-02f, -5.55225695e-03f, 3.63118798e-02f, 3.28183286e-02f,
  -2.07161512e-02f, -8.32054541e-02f, 1.38191506e-02f, -7.55252913e-02f, -5.44317327e-02f, 2.64973901e-02f, -8.02080333e-03f, 4.82363813e-02f, 6.27922937e-02f, -3.08890305e-02f,
  -3.06685306e-02f, -6.88546151e-03f, 3.06218187e-03f, 1.28000965e-02f, -4.59873639e-02f, -5.20479456e-02f, 5.95137551e-02f, -2.36333273e-02f, 2.92995833e-02f, -6.82121292e-02f,
  -1.46808848e-01f, -1.65737331e-01f, 4.08981927e-02f, -8.62622857e-02f, 5.53086139e-02f, -7.85692632e-02f, -4.94018476e-03f, -6.65916428e-02f, 2.03019511e-02f, 7.59144872e-02f,
  4.23005261e-02f, -8.86343122e-02f, 3.72962691e-02f, 4.09827754e-02f, 7.32716620e-02f, 8.29088166e-02f, -6.95204213e-02f, -8.80656764e-02f, -6.61255643e-02f, -3.90305854e-02f,
  -5.33300191e-02f, -5.18478341e-02f, 7.92802498e-02f, -7.25862607e-02f, -4.32363227e-02f, -1.09453678e-01f, 4.83552180e-02f, -7.39753917e-02f, 2.77547049e-03f, -1.39586683e-02f,
  -2.82272607e-01f, 7.02257901e-02f, 1.03459276e-01f, -1.69960439e-01f, 7.21914973e-03f, 2.37111047e-01f, 2.29843166e-02f, 1.52462423e-01f, 7.55874515e-02f, -4.72899340e-02f,
  3.01309768e-02f, 6.37967438e-02f, 1.14584014e-01f, -1.05958499e-01f, 1.31748304e-01f, 1.36271209e-01f, 2.55758371e-02f, 6.52607158e-02f, 1.14880212e-01f, -1.50697241e-02f,
  -1.00096337e-01f, -6.83172122e-02f, -4.27268706e-02f, -2.22758017e-02f, 2.14766967e-03f, -1.00324526e-01f, -1.56146616e-01f, 9.92765352e-02f, -8.74444544e-02f, 2.95315888e-02f,
  -6.13473989e-02f, -8.67950991e-02f, 4.76377197e-02f, 3.81453410e-02f, -6.35453686e-02f, -2.88114361e-02f, -1.55885015e-02f, -5.06305397e-02f, 1.55913634e-02f, 5.25079817e-02f,
  -1.73062645e-02f, 8.62578824e-02f, 4.77452837e-02f, 9.25096273e-02f, 4.57901619e-02f, 6.82407171e-02f, -5.61595075e-02f, -7.17053935e-02f, 2.66851187e-02f, -1.74799133e-02f,
  3.15045491e-02f, -1.71471741e-02f, 3.47945020e-02f, -2.33327858e-02f, 5.87951727e-02f, 6.92173466e-02f, 5.09908125e-02f, -1.30833946e-02f, 1.16329528e-02f, -1.58565175e-02f,
  2.44221892e-02f, -1.23311738e-02f, -3.76263484e-02f, -4.37358953e-02f, -6.05013855e-02f, 4.59671803e-02f, -1.83756854e-02f, -6.29550889e-02f, 4.30077827e-03f, -6.52525946e-02f,
  -8.89316350e-02f, -7.00264201e-02f, -2.53211241e-02f, 1.21711157e-02f, -9.36664492e-02f, 1.64731834e-02f, -5.36660738e-02f, -3.31490971e-02f, 5.33501916e-02f, -9.53016430e-02f,
  -2.30020303e-02f, 1.79332849e-02f, 6.97876960e-02f, -1.52720390e-02f, -2.87443101e-02f, 3.08371708e-02f, -8.80862027e-02f, 6.66922629e-02f, -7.45309964e-02f, -6.02921881e-02f,
  2.00517047e-02f, -2.98325978e-02f, -8.73482728e-04f, -6.80393726e-02f, -1.58370528e-02f, 8.13639630e-03f, 6.72433227e-02f, 9.13401023e-02f, -2.82120015e-02f, 2.39602774e-02f,
  -9.20817405e-02f, 5.30184358e-02f, 1.37393987e-02f, 3.30734509e-03f, 1.22887604e-02f, 4.13250513e-02f, 2.65895911e-02f, -8.54061618e-02f, 5.45592979e-02f, 2.93047205e-02f,
  -2.68782973e-02f, 5.82526848e-02f, 1.71204098e-02f, -2.13973951e-02f, -3.79674993e-02f, -1.14099711e-01f, -1.02324717e-01f, 6.52703419e-02f, -5.53600267e-02f, -3.51349153e-02f,
  3.27516980e-02f, -2.55929213e-02f, 1.32706791e-01f, 2.85728611e-02f, -1.39414426e-02f, 1.20746009e-01f, 1.67439908e-01f, -7.75125772e-02f, -1.32264732e-03f, -1.61683410e-01f,
  2.09031031e-02f, 5.27990162e-02f, 1.20876409e-01f, 9.08111185e-02f, -3.17727402e-02f, 7.82571882e-02f, 4.72497335e-03f, 2.51393076e-02f, 3.08775273e-03f, 1.39531940e-02f,
  6.07751980e-02f, -3.54677066e-02f, -1.28340367e-02f, -1.40340775e-01f, 8.07526559e-02f, -5.24471588e-02f, -9.02830530e-03f, -2.01441310e-02f, 3.40401269e-02f, -1.01407185e-01f,
  6.18410669e-02f, -6.16189577e-02f, 4.47710454e-02f, 4.77783345e-02f, -9.19476748e-02f, -6.30024374e-02f, 6.11498505e-02f, 6.85031638e-02f, 5.68538322e-04f, 1.05965175e-02f,
  -7.68668652e-02f, -4.26219814e-02f, -7.47296261e-03f, 2.60177124e-02f, 3.06877233e-02f, 4.71949577e-02f, 6.87063336e-02f, -2.60502975e-02f, 2.17256788e-02f, 2.18189359e-02f,
  8.55005383e-02f, -3.41651551e-02f, 1.15958527e-01f, -4.96970713e-02f, 6.13602996e-03f, 7.82740861e-02f, 6.25423864e-02f, -8.19467939e-03f, -6.68679699e-02f, 8.04161951e-02f,
  -7.54278302e-02f, -5.83866937e-03f, -6.95577962e-03f, -6.25423938e-02f, 9.35090110e-02f, 5.69927171e-02f, 3.31520960e-02f, -1.30585264e-02f, -1.14538362e-02f, 3.82334739e-02f,
  4.31754254e-02f, -1.31348213e-02f, 4.99722548e-02f, -9.18142870e-02f, 5.15931174e-02f, 3.88195515e-02f, 9.65112075e-02f, 8.72798339e-02f, -4.74988520e-02f, 1.45457005e-02f,
  -1.87116861e-02f, -7.15780109e-02f, -4.97352891e-02f, 7.27571454e-03f, -8.78055468e-02f, 6.31169230e-02f, -5.73278114e-04f, 9.67089385e-02f, 7.55337179e-02f, 4.06214967e-02f,
  -1.10978685e-01f, -1.78757533e-01f, -7.86639899e-02f, -1.10731088e-01f, 4.52990569e-02f, 1.47115598e-02f, 2.67192675e-03f, -1.11852800e-02f, 9.50935949e-03f, -7.87968189e-02f,
  2.32871622e-02f, 6.26644939e-02f, -8.34020749e-02f, 7.43316934e-02f, -9.97694060e-02f, 4.97214273e-02f, -1.37081426e-02f, -4.01986241e-02f, 6.46518543e-02f, 1.19762837e-04f,
  2.05188897e-02f, -5.56356423e-02f, -7.84722194e-02f, -1.54304169e-02f, -5.76583156e-03f, 2.69019324e-02f, -1.66994836e-02f, 6.95976391e-02f, -6.87310752e-03f, -5.88553026e-02f,
  1.03897125e-01f, 3.22834738e-02f, -1.37391984e-01f, -3.73721980e-02f, 2.37136316e-02f, 1.52317122e-01f, 2.62452178e-02f, -2.54916605e-02f, -3.80293950e-02f, 7.75326192e-02f,
  -2.86397543e-02f, -5.09423092e-02f, -8.32270607e-02f, -4.69760709e-02f, 8.29825364e-03f, -8.10429826e-03f, 2.96304822e-02f, 1.06254295e-01f, -1.02855496e-01f, -4.08784188e-02f,
  4.26082313e-02f, -1.49655174e-02f, -9.53953266e-02f, 1.18093723e-02f, 5.92684262e-02f, 1.74756460e-02f, -2.93485913e-02f, -3.29457745e-02f, 4.79687117e-02f, -6.49066120e-02f,
  3.07789128e-02f, 2.32479554e-02f, -3.03759482e-02f, 3.40242907e-02f, -4.01335880e-02f, -6.97057471e-02f, 4.85750586e-02f, -8.45676139e-02f, -4.29106094e-02f, -9.01569575e-02f,
  4.75380942e-02f, 6.73630387e-02f, 4.90118563e-02f, 5.67187369e-02f, -2.86374222e-02f, -9.60327871e-03f, 1.05210058e-02f, -2.14777570e-02f, -6.54939786e-02f, -4.76910807e-02f,
  -1.31872273e-03f, 1.52824186e-02f, -3.30166072e-02f, -4.10527885e-02f, 2.76737250e-02f, 8.72366279e-02f, 2.71019433e-02f, 1.40168499e-02f, 8.28505382e-02f, -1.27198128e-02f,
  -7.76044950e-02f, 5.98420836e-02f, -6.78032041e-02f, -1.49417641e-02f, -4.88426536e-02f, -8.79826397e-02f, 3.21829394e-02f, 5.11813425e-02f, 1.34580648e-02f, -5.76842166e-02f,
  -6.10023141e-02f, 9.70564317e-03f, 3.52731347e-02f, -4.58722152e-02f, -1.61684714e-02f, 6.43100515e-02f, 9.78641957e-03f, -8.90223309e-02f, -8.61268491e-02f, -6.71659559e-02f,
  -6.75747916e-02f, 3.64267528e-02f, -3.90711576e-02f, 5.36304750e-02f, -2.69220751e-02f, 6.95357546e-02f, 1.99723858e-02f, 5.65613359e-02f, -9.24988240e-02f, 1.67446863e-02f,
  6.08652718e-02f, -3.94160151e-02f, -2.87708454e-03f, -4.21742648e-02f, -5.53239230e-03f, 7.02675804e-02f, -3.63484845e-02f, -9.47735831e-02f, 1.42585170e-02f, 2.16747541e-02f,
  9.46882460e-03f, 9.90534052e-02f, 1.03679135e-01f, -1.92245399e-03f, -5.92625104e-02f, 8.14830232e-03f, -3.37656066e-02f, -2.60966644e-02f, -2.79331510e-03f, -2.16505583e-02f,
  4.68555912e-02f, 1.05950609e-02f, 2.56753787e-02f, 2.38618813e-02f, 6.66674450e-02f, -3.38042304e-02f, 3.13875154e-02f, -1.10520786e-02f, -2.38233642e-03f, 1.63320042e-02f,
  5.36839552e-02f, -6.28662929e-02f, 2.01003756e-02f, 5.84765663e-03f, 8.21289569e-02f, 5.67544065e-02f, 3.64004634e-02f, 5.95194362e-02f, -1.78047955e-01f, -2.16472998e-01f,
  8.69088918e-02f, 8.29338748e-03f, 2.27056276e-02f, -6.88756704e-02f, 3.48351561e-02f, -5.49741648e-02f, -9.96776596e-02f, -4.96525839e-02f, 8.29465240e-02f, 1.21411614e-01f,
  6.14852197e-02f, 4.35898975e-02f, 2.17951208e-01f, 1.57825589e-01f, -2.48002000e-02f, 1.94387250e-02f, 1.17931426e-01f, 3.57286260e-02f, -1.70832351e-02f, 7.71280751e-02f,
  7.26721575e-03f, -9.75024402e-02f, 6.08424656e-03f, -1.07090570e-01f, 1.08595984e-02f, 1.68709829e-02f, -3.86381932e-02f, -6.95282221e-03f, 6.57488629e-02f, -7.09272474e-02f,
  -8.81644785e-02f, 9.28103402e-02f, -4.86166328e-02f, 9.94180609e-03f, 7.06689060e-02f, -2.53380351e-02f, 5.36180735e-02f, 6.12888895e-02f, -6.94587454e-02f, 8.00983906e-02f,
  4.92815971e-02f, -1.56184863e-02f, -4.32089530e-02f, -1.16401367e-01f, 8.56774524e-02f, -1.13416845e-02f, -6.19380809e-02f, -4.92524868e-03f, -2.46397275e-02f, 1.70524754e-02f,
  5.66934682e-02f, -9.50595066e-02f, -7.25528300e-02f, 2.08608173e-02f, 2.57221628e-02f, 3.41136418e-02f, -8.74317586e-02f, 4.53694072e-03f, -7.80512914e-02f, -5.53905554e-02f,
  -5.72340488e-02f, 2.49049347e-02f, -3.22903809e-03f, -4.71606739e-02f, -4.86093424e-02f, -7.35963657e-02f, -7.80564621e-02f, -4.45732586e-02f, -2.39950349e-03f, 5.77589497e-02f,
  9.03600827e-02f, -2.50293664e-03f, -6.50669187e-02f, -7.50653520e-02f, 4.97963242e-02f, -1.54533423e-02f, -5.59732169e-02f, 5.42882718e-02f, -4.45272066e-02f, 8.18387941e-02f,
  8.74245986e-02f, 9.81455669e-02f, -2.97526941e-02f, -1.88020654e-02f, 6.74236789e-02f, 5.13287820e-02f, 3.21863666e-02f, -3.61526124e-02f, -3.32968007e-03f, -7.17356578e-02f,
  -3.01720817e-02f, 2.30542794e-02f, 6.56155944e-02f, -4.04221043e-02f, 6.21191822e-02f, -6.54117018e-02f, -4.28617038e-02f, 1.28019759e-02f, 6.36756718e-02f, 9.97209102e-02f,
  -7.35884905e-02f, -9.48682427e-02f, 5.17305173e-02f, 5.82756363e-02f, -3.82108279e-02f, 2.02386752e-02f, -5.46882823e-02f, -3.16160843e-02f, -5.02861813e-02f, -8.66441336e-03f,
  -3.11993528e-02f, 2.65828401e-01f, -1.32910669e-01f, 1.33993432e-01f, -2.01096740e-02f, 1.82355344e-01f, 5.92143871e-02f, 4.98652160e-02f, 1.05067030e-01f, 1.81137502e-01f,
  1.17771961e-01f, 1.29199922e-01f, -3.34884971e-02f, 2.14448586e-01f, -9.54731032e-02f, 8.36612284e-02f, 2.85503328e-01f, 2.01254889e-01f, -2.08982471e-02f, 2.15236709e-01f,
  4.03613821e-02f, 6.21373765e-02f, 4.97444021e-03f, -9.50419754e-02f, 1.89997613e-01f, -1.46707833e-01f, 7.47817084e-02f, -2.41067275e-01f, -1.77577045e-02f, 1.54368337e-02f,
  6.67629614e-02f, 1.13212481e-01f, 1.84300449e-02f, 1.34106996e-02f, 3.69489938e-02f, 1.26734197e-01f, -6.18668981e-02f, -1.28759712e-01f, -1.00606866e-01f, -5.20328097e-02f,
  2.93837152e-02f, 1.33830691e-02f, 4.29045130e-03f, -6.25528619e-02f, 6.18411927e-03f, 4.50754203e-02f, 8.53574127e-02f, -6.23996742e-02f, -5.77973500e-02f, -4.84263003e-02f,
  -1.07139191e-02f, 5.59645593e-02f, 9.68084335e-02f, -1.92168877e-02f, -7.08972439e-02f, -9.37507898e-02f, -6.90305084e-02f, -5.29416725e-02f, 5.22551537e-02f, 2.02169977e-02f,
  -2.16915887e-02f, -6.17348365e-02f, 1.41760603e-01f, 9.27179754e-02f, -2.73693614e-02f, 5.70394695e-02f, 6.84907809e-02f, 5.06570898e-02f, -7.63910189e-02f, 7.38962218e-02f,
  -9.63330194e-02f, -6.11995235e-02f, -4.83563356e-03f, -4.52423766e-02f, -3.98453735e-02f, -8.34851433e-03f, -4.41839918e-02f, -7.43571296e-03f, 8.06604251e-02f, 5.34126200e-02f,
  -5.48690595e-02f, 3.36872297e-03f, 7.64275938e-02f, -3.24740447e-02f, -2.20423425e-03f, -3.82664017e-02f, 7.43936654e-03f, -5.90993538e-02f, 3.83803882e-02f, -1.09341005e-02f,
  5.04751951e-02f, 1.38008595e-01f, -2.09299829e-02f, -8.20267797e-02f, -7.14952946e-02f, 1.24494486e-01f, 3.16314660e-02f, 4.10239659e-02f, 1.80925541e-02f, 6.83801994e-02f,
  -6.44872189e-02f, -9.60463360e-02f, -5.84465191e-02f, 3.86659503e-02f, 3.71267945e-02f, 1.53477088e-01f, -3.39872539e-02f, -7.09926849e-03f, -4.14178148e-02f, -4.80001830e-02f,
  8.56178775e-02f, -1.74070075e-02f, -5.07830158e-02f, 4.98841442e-02f, -8.15948173e-02f, -5.69677688e-02f, 7.37491474e-02f, -6.08652644e-02f, 2.94128004e-02f, 3.15218046e-02f,
  -4.00571898e-02f, -1.26605229e-02f, -1.00383297e-01f, -1.98422316e-02f, 3.27338837e-02f, -9.04461220e-02f, -1.15999080e-01f, -4.54903580e-02f, -7.45874420e-02f, 6.79770932e-02f,
  2.91985106e-02f, -2.15043798e-02f, -1.13183647e-01f, -8.76050293e-02f, -1.20086186e-01f, -2.26863161e-01f, -4.90990132e-02f, -9.48116705e-02f, -7.90489838e-02f, 1.09438449e-01f,
  7.61624947e-02f, -2.73510274e-02f, 6.61129691e-03f, 6.57400489e-02f, -3.17663350e-03f, 8.41795206e-02f, 1.70966163e-01f, -1.70929842e-02f, -8.78853258e-03f, 7.02934563e-02f,
  -4.17003036e-02f, -1.93604436e-02f, -2.64052078e-02f, 1.47784976e-02f, 7.54314512e-02f, 6.07959032e-02f, 2.97313202e-02f, -1.64193716e-02f, 3.24842483e-02f, -6.53388873e-02f,
  8.46943930e-02f, -6.75212443e-02f, -5.62796295e-02f, -3.35457386e-03f, 6.96495846e-02f, 5.66731431e-02f, -8.81779343e-02f, 5.69315301e-03f, 8.54916405e-03f, 3.93443145e-02f,
  3.87056917e-02f, 4.64939848e-02f, -1.99240129e-02f, -6.47417307e-02f, -5.58398515e-02f, 6.57275096e-02f, 3.00359223e-02f, -5.24124503e-03f, 9.06526670e-02f, 3.10225021e-02f,
  4.67408337e-02f, 1.80567000e-02f, -1.51105528e-03f, -1.85438003e-02f, 4.60674949e-02f, 9.04070735e-02f, 7.75048956e-02f, -3.14045735e-02f, 7.23813251e-02f, 2.59997770e-02f,
  9.70981419e-02f, 3.18001993e-02f, 8.43267292e-02f, 8.91546311e-04f, 5.44230528e-02f, -7.09818304e-02f, -4.81558852e-02f, -6.50089011e-02f, -3.62816788e-02f, -6.03997707e-02f,
  -9.45622742e-04f, -6.53178990e-03f, -5.13661047e-03f, 4.94327992e-02f, -5.49913906e-02f, -4.17478979e-02f, -5.83021715e-02f, -5.94771281e-02f, 3.66128832e-02f, 2.34225467e-02f,
  -6.33583814e-02f, 8.23839754e-02f, 1.69383381e-02f, -1.07933253e-01f, -4.64502722e-02f, 2.43377816e-02f, 4.59093824e-02f, -4.31861579e-02f, -6.08100668e-02f, 3.00620515e-02f,
  -6.02366291e-02f, 5.87250143e-02f, 6.49966747e-02f, -3.54735963e-02f, -3.06960270e-02f, 3.14383134e-02f, 1.99680459e-02f, 1.19059123e-02f, -2.28857342e-02f, 7.02539757e-02f,
  -2.00370196e-04f, 8.38535801e-02f, 7.22263157e-02f, -3.47408205e-02f, -1.68835302e-03f, -2.70973537e-02f, -4.98787425e-02f, -8.02667141e-02f, 3.91883366e-02f, -6.05156310e-02f,
  6.27910718e-02f, -6.77583292e-02f, -6.69318140e-02f, 1.31474301e-01f, -1.00473411e-01f, -1.31253883e-01f, -5.87605089e-02f, -1.30447410e-02f, -2.48553410e-01f, -1.63210735e-01f,
  5.31722941e-02f, 5.46646193e-02f, -1.98361188e-01f, 2.38272429e-01f, 3.26678753e-01f, -1.12094693e-02f, 1.54204458e-01f, 9.14710611e-02f, -9.39140096e-03f, 1.04851596e-01f,
  1.30969480e-01f, 1.48699388e-01f, 2.43177205e-01f, 1.26490176e-01f, 1.25597417e-01f, 2.18238056e-01f, 2.75740653e-01f, 1.17096432e-01f, 2.68269867e-01f, 1.85002401e-01f,
  -1.15455389e-02f, -3.14983837e-02f, -5.62842339e-02f, 9.39112995e-03f, -6.69968128e-02f, -7.65634477e-02f, 1.88860018e-02f, 2.25501265e-02f, 6.13958053e-02f, 1.74092185e-02f,
  -7.13484967e-03f, -2.29454096e-02f, 2.97281779e-02f, -3.87151018e-02f, -6.04258366e-02f, -1.99078750e-02f, -2.87306923e-02f, -5.61379939e-02f, -3.05584259e-02f, 2.45924555e-02f,
  -7.12114275e-02f, -3.17897014e-02f, 4.61782590e-02f, 4.77389805e-02f, 3.32939476e-02f, -5.07805794e-02f, 1.95493847e-02f, -2.68145725e-02f, -3.36345136e-02f, 7.25192055e-02f,
  -7.89947994e-03f, -7.23116472e-02f, -1.01073287e-01f, -3.78455184e-02f, -1.88262071e-02f, -5.28858714e-02f, 2.28198636e-02f, -3.35532688e-02f, 4.16254625e-02f, 1.81439873e-02f,
  -3.99893411e-02f, -6.73937574e-02f, -6.88527748e-02f, 5.99095896e-02f, -1.92983635e-02f, -7.05171674e-02f, 8.09319466e-02f, 9.17417780e-02f, 2.99612414e-02f, 2.94253714e-02f,
  -4.43532169e-02f, 2.76115295e-02f, -6.69125542e-02f, 1.45733198e-02f, 1.21074999e-02f, -8.13874826e-02f, 1.20969966e-01f, 2.18382124e-02f, 5.00943176e-02f, -4.82563414e-02f,
  2.49035563e-02f, 1.87622994e-01f, 1.24963280e-02f, -3.87627911e-03f, -9.28114448e-03f, 1.11193107e-02f, 4.69334796e-02f, 1.00341477e-01f, 4.02273051e-02f, -5.04396893e-02f,
  2.86377557e-02f, -2.27953754e-02f, -3.33259515e-02f, 1.63195170e-02f, 3.18989754e-02f, -1.14634549e-02f, 8.47885460e-02f, 7.74438009e-02f, 8.85646492e-02f, 4.11566682e-02f,
  7.00714812e-02f, 5.35618663e-02f, 9.36011896e-02f, -8.09618682e-02f, 5.08574722e-03f, 3.02012935e-02f, 1.49779730e-02f, 6.76359162e-02f, -1.41438553e-02f, -3.95303182e-02f,
  -1.27452582e-01f, 1.18275940e-01f, 1.49036601e-01f, -2.31754240e-02f, -1.96311600e-03f, 1.88108891e-01f, 2.65956402e-01f, -2.58623622e-02f, 2.74767846e-01f, 1.79705713e-02f,
  -1.74972519e-01f, 6.42605051e-02f, 7.75054172e-02f, 3.48826870e-02f, 1.82008341e-01f, 7.41428584e-02f, 1.67870864e-01f, 4.85291630e-02f, 1.00698777e-01f, -6.81760311e-02f,
  -3.19927223e-02f, -1.26410335e-01f, -1.38530741e-02f, -7.11429268e-02f, -1.35782301e-01f, -1.00111321e-01f, -1.85105950e-01f, 1.06576197e-01f, -1.84117034e-01f, 1.30701363e-01f,
  3.10159791e-02f, 8.34465399e-02f, -5.52414730e-02f, -2.97420137e-02f, 2.21446026e-02f, 4.02682573e-02f, -4.57912544e-03f, 1.84715341e-03f, 1.46800242e-02f, 5.39118797e-02f,
  -2.26328820e-02f, -3.38953920e-02f, -1.54526019e-02f, 1.48535473e-02f, -2.33712476e-02f, -1.30057618e-01f, -6.22235276e-02f, -7.97630027e-02f, -9.66947060e-03f, 1.03353104e-02f,
  -8.26327801e-02f, -1.14734843e-02f, 1.51599376e-02f, 6.86535090e-02f, 5.28996289e-02f, 4.57936823e-02f, -1.84822753e-02f, -5.16013615e-02f, -3.80501524e-02f, 5.19253500e-02f,
  3.32972407e-03f, -2.77617741e-02f, -2.77936682e-02f, -3.48750241e-02f, -4.59913239e-02f, -1.02263071e-01f, 1.35217384e-02f, 4.05232375e-03f, -2.03536972e-02f, -1.14834338e-01f,
  6.24006428e-03f, 8.03774572e-04f, -3.62858586e-02f, 5.60555793e-02f, 8.57491046e-02f, -8.56214017e-02f, -8.25865846e-03f, 4.81515937e-02f, 6.10449202e-02f, 4.57714796e-02f,
  4.59519066e-02f, 8.65817666e-02f, 6.39732415e-03f, 1.28696291e-02f, -1.42311249e-02f, 3.49495821e-02f, -5.51831573e-02f, 2.16858983e-02f, -3.31706107e-02f, 5.39434142e-02f,
  1.21352062e-01f, 1.77606821e-01f, -6.40559271e-02f, -3.95507971e-03f, -5.24985651e-03f, 4.64656018e-02f, 4.76630889e-02f, -4.70448844e-02f, 1.26748517e-01f, -1.34086972e-02f,
  -3.15307043e-02f, 1.59071963e-02f, -5.29122576e-02f, -5.57604693e-02f, 7.01041799e-03f, 3.49633917e-02f, 6.55569062e-02f, 8.56691077e-02f, 2.68193595e-02f, -3.08459252e-02f,
  -1.18918374e-01f, 3.38459872e-02f, -3.88869084e-02f, -2.73943804e-02f, -8.96363035e-02f, -5.98146692e-02f, 9.64588597e-02f, 8.75015557e-03f, -7.42563009e-02f, 9.49249044e-02f,
  -1.65308401e-01f, 8.93338323e-02f, 2.62478858e-01f, -9.16159600e-02f, -1.22368105e-01f, 1.06652491e-01f, 1.05440982e-01f, -7.07370937e-02f, 2.68104300e-02f, 4.36670296e-02f,
  -3.45599651e-02f, 3.53171490e-03f, 9.92809907e-02f, -9.29110423e-02f, 1.38450908e-02f, 1.16203733e-01f, 6.49878904e-02f, 2.01292373e-02f, -7.29888529e-02f, -9.05278325e-02f,
  -9.42183658e-02f, -2.29583815e-01f, 2.94458051e-03f, -1.07830606e-01f, -1.08644292e-01f, -1.58236533e-01f, -3.52998786e-02f, 1.03188120e-01f, -7.45958462e-02f, -2.22433284e-02f,
  -1.28665119e-01f, -1.36168212e-01f, -1.74781829e-02f, 6.98492005e-02f, -9.72540770e-03f, 1.21707357e-02f, -2.93213967e-02f, 3.12616825e-02f, -9.80972350e-02f, 5.60490936e-02f,
  -2.01107338e-02f, 9.47313532e-02f, -4.00904231e-02f, -2.09952836e-04f, -1.00392416e-01f, -1.52514344e-02f, 6.15356639e-02f, 1.06967874e-01f, 6.75940439e-02f, 1.05911188e-01f,
  1.39382426e-02f, -2.50893310e-02f, -6.57619014e-02f, -6.10423870e-02f, -4.03821431e-02f, 1.89294387e-02f, -4.38266695e-02f, 9.52129513e-02f, 2.01333687e-02f, 1.56064974e-02f,
  5.60718589e-02f, -1.98534299e-02f, 6.61519170e-02f, -2.33476739e-02f, 4.84129339e-02f, -2.08769590e-02f, -9.70624164e-02f, -8.25277716e-02f, 6.16573021e-02f, -4.14350592e-02f,
  -3.74683924e-02f, -6.96533080e-03f, -8.75194296e-02f, 5.05896807e-02f, -8.85335878e-02f, 7.21980929e-02f, 6.59143627e-02f, -3.04702744e-02f, 2.05174573e-02f, 3.78151680e-03f,
  3.22520062e-02f, -5.17157651e-02f, -7.61739984e-02f, 2.90298909e-02f, 7.15702549e-02f, -6.20352067e-02f, 7.69298337e-03f, -1.75071333e-03f, 6.84981719e-02f, -5.34564219e-02f,
  -4.30426560e-02f, -5.87031133e-02f, 2.12084092e-02f, -6.10417165e-02f, -7.05699399e-02f, 7.50637650e-02f, 4.09034602e-02f, -6.96096569e-02f, 2.51531624e-03f, 6.22401424e-02f,
  -3.24317552e-02f, 1.85821615e-02f, 8.02680384e-03f, -3.48348208e-02f, -3.20729613e-02f, -5.75802214e-02f, -1.08055636e-01f, 6.05049729e-02f, 3.80835682e-03f, 8.73271190e-03f,
  -6.38915366e-03f, -8.94027725e-02f, -3.24627534e-02f, -2.02554148e-02f, 8.49052798e-03f, 5.79820462e-02f, 4.85711582e-02f, 7.38509446e-02f, 1.46859176e-02f, -3.62511799e-02f,
  4.78770249e-02f, -2.33256184e-02f, 1.32431621e-02f, -1.41831309e-01f, -6.87373132e-02f, 1.26136944e-01f, -1.23297952e-01f, 5.90518443e-03f, -1.41707212e-01f, 6.50430843e-03f,
  -3.34376320e-02f, 1.98709298e-04f, -4.78555039e-02f, -7.87956789e-02f, 1.34583469e-02f, 3.37943360e-02f, -8.26899409e-02f, -5.30333370e-02f, 3.16852219e-02f, -7.69490525e-02f,
  -4.89881933e-02f, 3.79540101e-02f, 3.78012918e-02f, 3.28635536e-02f, -8.86123627e-03f, 2.29636133e-02f, 1.60139557e-02f, -3.32932398e-02f, -3.64585221e-02f, -2.39397325e-02f,
  1.10581644e-01f, 5.37017826e-03f, 6.25809208e-02f, 1.20041341e-01f, 3.98261324e-02f, 9.55429450e-02f, 3.08090486e-02f, -2.53018574e-03f, 9.94567946e-03f, 8.82218108e-02f,
  -1.13576716e-02f, 3.54678594e-02f, -2.58265226e-03f, -1.17691699e-02f, -3.38103734e-02f, 3.49213257e-02f, -4.73377295e-02f, -1.39670176e-02f, -6.15276955e-02f, 1.12942442e-01f,
  -5.08008264e-02f, -9.76738427e-03f, 2.40910100e-03f, 4.45785224e-02f, 2.10665353e-02f, -2.27350462e-03f, 4.88354899e-02f, -9.04985145e-02f, -2.68266276e-02f, 2.04310231e-02f,
  7.74777867e-03f, 4.14750986e-02f, 4.66584191e-02f, 7.77647123e-02f, 9.75189134e-02f, -8.13186467e-02f, -8.77350122e-02f, 6.95163012e-02f, -9.45869684e-02f, 6.55803904e-02f,
  5.15219867e-02f, -7.01402198e-04f, 6.34244829e-02f, 6.66677803e-02f, -3.36812693e-03f, 5.70859388e-02f, -8.66375864e-03f, -7.23461360e-02f, -2.58398242e-02f, 4.17063832e-02f,
  6.27311543e-02f, 6.65145461e-03f, -8.86043459e-02f, 1.00341036e-04f, -1.68388616e-02f, 3.33106071e-02f, -7.30997836e-03f, -1.98466759e-02f, 7.39433765e-02f, -8.04634839e-02f,
  4.67869528e-02f, 3.32141183e-02f, 6.09864946e-03f, -6.44788295e-02f, -1.52576342e-02f, 1.32598579e-01f, -3.69225927e-02f, -1.44744115e-02f, -2.89443997e-04f, 5.80313392e-02f,
  -7.46631622e-02f, 5.16945822e-03f, -3.54763716e-02f, 5.72411828e-02f, 1.41739063e-02f, -9.36374515e-02f, -9.31962654e-02f, -9.00188982e-02f, -5.23552373e-02f, -4.07761820e-02f,
  -3.50969583e-02f, 6.16136799e-03f, -1.83193963e-02f, 3.33827436e-02f, 1.94136165e-02f, -8.21821764e-02f, -2.30151098e-02f, 2.53650825e-02f, 8.39603767e-02f, 2.16007158e-02f,
  1.43579423e-01f, -3.30946036e-02f, 8.98361579e-03f, -1.36646843e-02f, 1.75828524e-02f, 4.63799424e-02f, -9.72638465e-03f, 2.82130279e-02f, -9.25808549e-02f, 8.39098766e-02f,
  7.48736858e-02f, -1.10636048e-01f, -1.06839687e-02f, 4.54809964e-02f, -2.85271853e-02f, -1.50457561e-01f, 5.31907566e-02f, 8.05371776e-02f, 3.40380482e-02f, 3.27835828e-02f,
  -4.60937805e-02f, 6.35030419e-02f, -7.33562037e-02f, 8.38853195e-02f, 1.79937720e-01f, 3.04150977e-03f, 1.76325869e-02f, -5.01904190e-02f, 5.93724176e-02f, 9.90023389e-02f,
  4.36572172e-02f, 3.39614339e-02f, -7.22314641e-02f, 6.79778084e-02f, 5.35053723e-02f, 5.59697254e-03f, -5.81842996e-02f, -9.33714136e-02f, 8.31130967e-02f, -8.11167434e-03f,
  1.44548789e-02f, -3.58477011e-02f, 6.94407597e-02f, -3.48305590e-02f, -1.16778947e-02f, 7.80798718e-02f, 8.08570385e-02f, 2.63321158e-02f, 1.19959447e-03f, 5.95100038e-02f,
  -5.01313768e-02f, 4.43001352e-02f, -7.78509453e-02f, -3.53149623e-02f, -2.93564070e-02f, 1.48737524e-02f, -1.13658920e-01f, 4.90993261e-03f, -2.19715443e-02f, -1.03668921e-01f,
  -5.90566210e-02f, -6.08543530e-02f, 8.19840804e-02f, -6.96020201e-02f, -5.30832298e-02f, -6.24085702e-02f, 5.73219880e-02f, 2.62778047e-02f, 3.29351835e-02f, 2.01015733e-02f,
  3.64026837e-02f, 9.90471542e-02f, -7.98824728e-02f, 8.39635879e-02f, -1.45098055e-02f, 5.52980937e-02f, -7.08462596e-02f, -2.13063136e-02f, -5.64016663e-02f, 2.57720482e-02f,
  7.04514533e-02f, 2.85358708e-02f, -3.17279133e-03f, -2.52421331e-02f, -1.17175812e-02f, -1.18154881e-03f, 5.60496226e-02f, -4.99736629e-02f, 7.83292875e-02f, -4.52778414e-02f,
  -6.78703934e-02f, -8.67226943e-02f, 2.21067294e-02f, -9.24377237e-04f, -1.58546530e-02f, -1.46755604e-02f, 2.04063263e-02f, 4.90638614e-02f, 2.61084866e-02f, -2.99608782e-02f,
  2.74437424e-02f, 3.04575451e-03f, 2.12245230e-02f, -4.56040166e-02f, 4.55538630e-02f, 9.88324583e-02f, -2.97871213e-02f, -9.93093848e-02f, -1.07661793e-02f, -1.55368662e-02f,
  -2.69076619e-02f, -3.75980698e-02f, -6.46638274e-02f, -3.53834033e-02f, 5.68066258e-03f, -5.26622869e-02f, 4.80624102e-02f, -2.09922269e-02f, -8.62736851e-02f, -1.02531917e-01f,
  -9.98961478e-02f, 6.18455075e-02f, -1.04796603e-01f, -5.34278946e-03f, 3.74872386e-02f, -2.58332014e-01f, -2.24648520e-01f, -7.99303204e-02f, -2.18468215e-02f, 1.26960963e-01f,
  1.22120949e-02f, 2.68228669e-02f, -6.33856729e-02f, -1.83668047e-01f, -2.17312023e-01f, -1.06980890e-01f, -1.21167518e-01f, -1.24470621e-01f, -1.18641272e-01f, 1.24614630e-02f,
  -1.60997198e-03f, 3.99402268e-02f, -6.06038645e-02f, 1.55274011e-02f, 2.00978294e-02f, 1.02227032e-01f, 2.59211093e-01f, 1.41345382e-01f, 1.48569550e-02f, 8.46305564e-02f,
  1.45576978e-02f, 7.70258605e-02f, -4.96290065e-02f, -8.43835697e-02f, 8.55970606e-02f, -4.54055524e-04f, 4.83597303e-03f, -1.18746804e-02f, -8.13177973e-02f, -1.34552633e-02f,
  1.13505479e-02f, 1.61890443e-02f, 6.52061030e-02f, 2.72658304e-03f, 1.62106398e-02f, 6.36302531e-02f, -3.23357061e-02f, -2.03613471e-02f, 1.53203905e-02f, -1.11425616e-01f,
  -2.18381882e-02f, -8.61893892e-02f, -2.25702189e-02f, 1.06124980e-02f, -4.24114540e-02f, 8.03892314e-03f, 2.00966857e-02f, 5.03070354e-02f, -4.14357968e-02f, 5.19274473e-02f,
  4.55630757e-02f, 5.35055771e-02f, -4.81292047e-02f, -3.15861516e-02f, -2.39176508e-02f, -4.74349000e-02f, 2.77853124e-02f, 6.36715665e-02f, 4.01482433e-02f, -9.14112851e-02f,
  3.61107066e-02f, -5.59974946e-02f, 6.42380863e-02f, 8.76538754e-02f, -3.06974985e-02f, 7.74445906e-02f, -8.73062238e-02f, 3.89290377e-02f, -1.00991972e-01f, -2.25376952e-02f,
  -7.14320736e-03f, -6.43309355e-02f, -7.75463656e-02f, -5.10563925e-02f, -8.64023566e-02f, -9.59732663e-03f, -2.23946590e-02f, -3.95772196e-02f, 3.26769948e-02f, 8.37531090e-02f,
  3.02153104e-03f, 3.56719010e-02f, -4.01046947e-02f, 7.13707283e-02f, -6.86659440e-02f, 5.28293336e-03f, -5.25970291e-03f, -4.94278185e-02f, -6.64844438e-02f, 2.64346432e-02f,
  -6.96353987e-02f, -2.31833868e-02f, 2.90458445e-02f, 1.02563456e-01f, 8.13185051e-02f, -2.02521663e-02f, 2.33836845e-02f, 1.21692056e-02f, 4.32636738e-02f, -1.94497425e-02f,
  7.23325536e-02f, 2.27723625e-02f, 2.15260368e-02f, 6.48730323e-02f, -3.73537168e-02f, 4.49061319e-02f, -4.14085984e-02f, 1.23435240e-02f, 6.47261664e-02f, 5.95518714e-03f,
  -6.85872734e-02f, 1.40426293e-01f, 1.02489434e-01f, 1.02295484e-02f, -4.47359234e-02f, -6.13731854e-02f, -7.85933957e-02f, 4.40911244e-04f, -1.55851603e-01f, 3.53519432e-02f,
  2.63352096e-02f, -2.72775423e-02f, -1.33942366e-01f, -1.32780761e-01f, -4.13758159e-01f, -3.52904111e-01f, -1.79307029e-01f, -8.03398862e-02f, -1.35345966e-01f, 2.10106492e-01f,
  -7.24997967e-02f, -1.76651284e-01f, -9.24002901e-02f, 3.92683744e-02f, 1.50122598e-01f, 3.01071197e-01f, 1.68624371e-01f, 1.45616129e-01f, 1.92926943e-01f, -1.56909421e-01f,
  -1.63599670e-01f, -9.39702690e-02f, 9.14483815e-02f, 5.07825101e-03f, 2.70311926e-02f, 1.48184463e-01f, 2.09846869e-02f, -4.95144390e-02f, 3.63021623e-04f, 2.70521939e-02f,
  7.86752440e-03f, -4.38432470e-02f, 1.15526957e-03f, -1.02017917e-01f, 8.49213749e-02f, 5.85836321e-02f, 3.95568684e-02f, 9.43715423e-02f, 3.59063856e-02f, -2.70535192e-03f,
  -5.97501686e-03f, 7.63437152e-02f, 3.80194224e-02f, -8.70868214e-04f, 9.31633860e-02f, -1.16108805e-02f, -4.14589308e-02f, 1.37319695e-02f, -3.92347090e-02f, -4.72932272e-02f,
  -1.84547678e-02f, 1.50213987e-02f, -4.60202321e-02f, 1.36535903e-02f, -3.88844591e-03f, 1.10754808e-02f, 5.81517033e-02f, -5.74684404e-02f, -2.33403668e-02f, -6.06946498e-02f,
  6.45923913e-02f, -1.55999176e-02f, -1.23301325e-02f, 6.03444465e-02f, 5.70807531e-02f, 1.47417765e-02f, -4.80178893e-02f, -6.57451674e-02f, 5.22788055e-03f, 1.05496012e-02f,
  -7.19497725e-02f, 7.64755206e-03f, 2.83000357e-02f, 1.05327033e-01f, 1.93096965e-03f, -2.77653430e-02f, 5.21787405e-02f, -4.12809178e-02f, -6.78969175e-02f, -5.65067753e-02f,
  1.95195563e-02f, 1.26905397e-01f, -8.43175873e-03f, -1.98219661e-02f, 6.36799037e-02f, -4.78464775e-02f, -1.10134773e-01f, -5.47481067e-02f, 4.49500494e-02f, 1.08734015e-02f,
  4.65485901e-02f, 8.46919715e-02f, 2.98539381e-02f, -5.29225729e-02f, -3.52535173e-02f, 4.38406840e-02f, 7.08727837e-02f, 9.65858400e-02f, -3.33949551e-02f, 9.97170731e-02f,
  1.29112676e-01f, 7.06319809e-02f, -9.05013680e-02f, -1.97556000e-02f, -1.24137243e-02f, 2.11556107e-02f, 6.62738085e-02f, 7.24155381e-02f, -9.45043284e-03f, -2.77942307e-02f,
  2.11502593e-02f, -1.35957524e-02f, -3.73647399e-02f, 7.53881112e-02f, -1.01562612e-01f, -1.79972664e-01f, -8.56806338e-02f, -1.32988602e-01f, 3.08276545e-02f, 8.79637301e-02f,
  4.93542776e-02f, 1.52492166e-01f, 1.40634375e-02f, 6.22256845e-02f, 5.34828305e-02f, 1.04983762e-01f, -9.29687694e-02f, 1.04970120e-01f, -4.24590595e-02f, -1.11853406e-01f,
  6.41886564e-03f, -1.65419146e-01f, 5.65859079e-02f, -1.45108357e-01f, -5.59483580e-02f, 6.92212433e-02f, 2.72687594e-03f, -9.51419324e-02f, -1.25613615e-01f, -1.16563298e-01f,
  -1.54429570e-01f, -1.15032904e-01f, 4.90249172e-02f, 5.74214906e-02f, -4.67941388e-02f, -1.46562811e-02f, 9.13305115e-03f, -3.99994291e-02f, -2.18769256e-02f, -3.45728099e-02f,
  9.23624486e-02f, 1.01062804e-02f, 3.08125168e-02f, -3.18306051e-02f, -3.02382186e-03f, -1.26717212e-02f, -6.54578069e-03f, -3.95094156e-02f, -5.93103804e-02f, -1.76316537e-02f,
  6.43185601e-02f, 9.08224583e-02f, 6.27196506e-02f, 3.97818312e-02f, 6.05269969e-02f, -9.27277952e-02f, -4.81767431e-02f, 8.94150957e-02f, -2.49770959e-03f, -5.72724231e-02f,
  6.45929277e-02f, 1.88651253e-02f, 5.26872650e-02f, -6.26462922e-02f, 3.09821721e-02f, -4.36531492e-02f, -5.83202057e-02f, -8.08175132e-02f, -4.58512530e-02f, 4.11202721e-02f,
  -8.70477408e-02f, 1.01911701e-01f, -5.87712340e-02f, 4.08871919e-02f, 5.83571382e-02f, -1.88565571e-02f, 1.22054443e-02f, 7.85079878e-03f, 7.25903288e-02f, 8.24998096e-02f,
  -2.19787471e-02f, -7.45561393e-03f, -9.16077867e-02f, 7.07894913e-04f, -7.63758197e-02f, -1.00484928e-02f, 1.38094521e-03f, -8.43719989e-02f, -1.71558205e-02f, -2.88983658e-02f,
  -6.05270527e-02f, -1.71489611e-01f, -6.28992319e-02f, 3.72932330e-02f, -5.65889217e-02f, 6.86254725e-02f, -1.59772113e-02f, 2.23635565e-02f, -1.24868304e-01f, 8.43051937e-04f,
  4.70517315e-02f, -5.20048775e-02f, -8.79438594e-02f, -4.84196618e-02f, 6.29080310e-02f, -5.54215312e-02f, 2.52049211e-02f, 4.23619635e-02f, -2.26709004e-02f, 1.68820992e-02f,
  3.30679230e-02f, -1.79582015e-02f, -5.27188294e-02f, 3.12935226e-02f, 2.34554093e-02f, 1.11173559e-02f, 2.78526433e-02f, -4.34485301e-02f, -5.04553365e-03f, -4.58103940e-02f,
  -2.63589442e-01f, 5.01251996e-01f, 3.02170545e-01f, -2.10834414e-01f, 1.39603496e-01f, -3.18838321e-02f, -1.60662040e-01f, 9.57690775e-02f, 9.67203751e-02f, 1.19601108e-01f,
  -9.14654359e-02f, 1.95335880e-01f, 1.78293541e-01f, -4.87640090e-02f, -3.92383903e-01f, -7.57300034e-02f, -1.93551347e-01f, -1.90538481e-01f, 8.49588811e-02f, -2.56925877e-02f,
  -1.58349633e-01f, -2.18536004e-01f, -5.51359840e-02f, 1.68718487e-01f, -5.49303740e-03f, 1.06699102e-01f, -3.58779132e-01f, 2.46264428e-01f, -5.92959449e-02f, 1.28262907e-01f,
  -1.57367840e-01f, -4.69190851e-02f, 6.64629191e-02f, 1.04797818e-01f, -5.76105602e-02f, -9.24345329e-02f, -1.29558757e-01f, 6.38721138e-02f, -2.48391051e-02f, 1.73043553e-02f,
  -6.87061176e-02f, 6.97827339e-02f, 6.58404306e-02f, 1.10463925e-01f, 2.87800725e-03f, 6.98420480e-02f, 7.45081604e-02f, -2.35691410e-03f, 1.45843223e-01f, 8.68044868e-02f,
  1.03166096e-01f, 7.38080293e-02f, -4.42622863e-02f, -8.02291632e-02f, -1.73223019e-02f, 3.68568487e-02f, -9.41349790e-02f, -2.61761178e-03f, 2.46672500e-02f, -1.96860507e-02f,
  6.81984723e-02f, -7.28676096e-02f, -2.54846029e-02f, 2.84356419e-02f, 1.35344621e-02f, -3.79881635e-02f, -4.42049140e-03f, 3.67094725e-02f, 3.72726955e-02f, -1.94803588e-02f,
  2.49544941e-02f, 6.67553721e-03f, 3.39422636e-02f, -1.87549312e-02f, -3.49014066e-02f, -7.81983510e-02f, 3.03470977e-02f, -3.80830951e-02f, -3.12382318e-02f, 3.76518490e-03f,
  5.84394298e-03f, -3.73490788e-02f, 3.76008712e-02f, -2.63323691e-02f, 5.25856689e-02f, 4.33634520e-02f, 5.71376085e-02f, -7.15558464e-03f, 9.62184626e-04f, -5.64742610e-02f,
  -3.09755176e-01f, -2.73378611e-01f, 8.17250693e-04f, -3.13202105e-02f, -4.33525443e-02f, -8.80158320e-02f, -4.65101115e-02f, -2.26239804e-02f, -1.07856706e-01f, 1.72568504e-02f,
  7.31653953e-03f, -7.68324640e-03f, -1.13848232e-01f, -1.00280106e-01f, -6.65180385e-02f, -4.42623496e-02f, -6.99402690e-02f, -6.41958788e-02f, -1.28306687e-01f, 4.62931730e-02f,
  -4.65627052e-02f, -1.44476760e-02f, 4.68170755e-02f, -4.97706607e-02f, -1.15476422e-01f, -2.01005992e-02f, -1.28009617e-01f, 1.84205379e-02f, -7.04312176e-02f, 5.98851331e-02f,
  1.18063733e-01f, -5.04382737e-02f, -3.31611075e-02f, 9.75298807e-02f, 1.72553450e-01f, 9.20683891e-02f, 1.16209812e-01f, 1.65511802e-01f, 2.21078187e-01f, -1.37444735e-01f,
  -4.61659171e-02f, -2.08902285e-01f, -3.11973039e-02f, -3.74667421e-02f, -2.20546871e-02f, -2.36703288e-02f, -1.13064937e-01f, -3.54189589e-03f, 1.63576156e-01f, 1.70930829e-02f,
  6.31253980e-03f, -3.06502003e-02f, 3.03928871e-02f, 3.18974741e-02f, -3.83522026e-02f, -9.41146165e-02f, -1.00784026e-01f, 7.67703056e-02f, -1.10256895e-01f, -9.31033716e-02f,
  1.71240550e-02f, 1.18400596e-01f, -4.02034931e-02f, -6.52634213e-03f, 9.04114358e-03f, 8.57467577e-02f, -4.25478593e-02f, 5.94280250e-02f, 9.91346240e-02f, 7.41107389e-02f,
  -3.66750732e-02f, -1.18986376e-01f, -5.14596365e-02f, 5.63467033e-02f, 9.42721218e-02f, 4.75231372e-02f, -1.34972166e-02f, -3.67438383e-02f, 3.15469224e-03f, 6.80031702e-02f,
  -4.79985364e-02f, -3.03109493e-02f, 1.62382070e-02f, -1.18845753e-01f, 6.05856217e-02f, 3.67856584e-02f, -5.39511442e-02f, -7.83299934e-03f, -1.14098057e-01f, 5.46197928e-02f,
  -7.96129107e-02f, -4.19815704e-02f, 5.79155311e-02f, 7.32305050e-02f, -2.11101249e-02f, 4.73379046e-02f, 4.20332700e-02f, -5.34368046e-02f, -2.33911183e-02f, -7.79437125e-02f,
  -3.85720953e-02f, -4.34279107e-02f, 1.55404245e-03f, 1.18621076e-02f, -5.29028708e-03f, -1.20784212e-02f, -1.13139516e-02f, -8.29233006e-02f, -5.62601089e-02f, 7.39377588e-02f,
  4.17498387e-02f, -7.40579441e-02f, 6.13262802e-02f, -6.67187348e-02f, -3.55293117e-02f, -3.92346941e-02f, -2.58009676e-02f, -2.51636840e-02f, -4.55115587e-02f, -5.80047211e-03f,
  -2.33118311e-02f, -8.22893754e-02f, -2.56356075e-02f, -7.90519565e-02f, -4.40284275e-02f, 1.98877119e-02f, -7.07524316e-03f, -7.10013732e-02f, -7.52511621e-02f, -3.69475558e-02f,
  4.16277006e-04f, -9.62715745e-02f, 5.12250885e-02f, -2.02676700e-03f, 4.95033413e-02f, -4.38999198e-02f, -1.11944482e-01f, 2.79834140e-02f, -7.56773129e-02f, 2.59304903e-02f,
  -6.96548074e-02f, -1.36934500e-02f, -6.95474520e-02f, 6.60391748e-02f, 4.26866263e-02f, -8.84104967e-02f, -1.57557502e-02f, -1.09812049e-02f, -7.40587041e-02f, 3.69881019e-02f,
  1.92754254e-01f, -2.67707855e-01f, -3.97676304e-02f, 3.23261172e-01f, 2.83519894e-01f, 8.96178652e-03f, -9.40603763e-02f, 2.00620800e-01f, 3.07095468e-01f, -2.25499690e-01f,
  3.18490528e-02f, -6.16478845e-02f, -2.67302603e-01f, 1.54115632e-01f, 4.08760980e-02f, -1.68506742e-01f, 8.27423409e-02f, -9.84517559e-02f, 5.23473509e-02f, 1.83595717e-02f,
  1.67329982e-01f, 1.37112634e-02f, 7.85583723e-03f, 6.08965866e-02f, 1.27300963e-01f, 1.01571947e-01f, -1.52966201e-01f, -9.68991816e-02f, -4.84474897e-02f, 1.35603687e-02f,
  -3.20940441e-03f, 9.11199600e-02f, -2.71249637e-02f, 4.03846502e-02f, -8.42247680e-02f, -6.92725703e-02f, -8.31342414e-02f, -2.46120915e-02f, -3.32847089e-02f, 1.21953599e-02f,
  -2.78485138e-02f, 8.15931857e-02f, 1.05392627e-01f, 3.20324413e-02f, 4.13604267e-03f, 3.97847109e-02f, 1.86862163e-02f, -1.80192348e-02f, 4.46055494e-02f, -4.23560478e-02f,
  -4.39258572e-03f, -1.47038884e-02f, 3.82424728e-03f, 9.21241287e-03f, 3.94394174e-02f, 7.29236156e-02f, -4.12264727e-02f, -2.70089116e-02f, 3.36771453e-04f, 9.63352248e-02f,
  7.37570748e-02f, 1.71615612e-02f, 3.65266837e-02f, -2.01526824e-02f, 1.19692963e-02f, 3.40989716e-02f, -5.86771257e-02f, 1.16206128e-02f, -4.44139205e-02f, -3.32078226e-02f,
  -6.17343374e-02f, 4.57471330e-03f, 3.24799567e-02f, 3.22956778e-02f, 8.07224680e-03f, -4.59483862e-02f, -1.01740740e-01f, 2.04321742e-02f, 9.95165184e-02f, -5.09142317e-02f,
  1.21716717e-02f, -8.80962014e-02f, -2.98618078e-02f, 3.12289577e-02f, -5.78670725e-02f, 1.90831209e-03f, 5.29403649e-02f, 6.15136549e-02f, 2.36204211e-02f, -4.77287322e-02f,
  -1.93504155e-01f, -1.68760583e-01f, -2.83153094e-02f, -5.93845397e-02f, -1.20728143e-01f, -8.67548361e-02f, 1.55848078e-02f, 1.07062899e-03f, -6.11442849e-02f, 8.67981911e-02f,
  3.16677392e-02f, -4.12168214e-03f, -5.19917607e-02f, 5.44706248e-02f, -7.00034350e-02f, 2.77045630e-02f, -9.55357477e-02f, -9.31055173e-02f, -5.48251346e-02f, -2.22068578e-02f,
  3.55960988e-02f, -3.96756120e-02f, -7.37542659e-02f, -3.20114605e-02f, 1.10092545e-02f, 9.81369428e-03f, -6.71987161e-02f, -2.55330987e-02f, -6.78951442e-02f, -3.69881764e-02f,
  -1.02865510e-02f, -2.37935305e-01f, -4.52587716e-02f, 2.36042291e-01f, 1.55878380e-01f, 7.78655894e-03f, -7.17962086e-02f, -8.66686031e-02f, 1.15245819e-01f, -2.02870443e-01f,
  -1.09691903e-01f, -9.26658213e-02f, -3.65428776e-01f, 1.53316364e-01f, 1.38885260e-01f, -2.27487877e-01f, 1.56231821e-01f, -6.16128892e-02f, 9.80150625e-02f, 5.05367890e-02f,
  1.04386307e-01f, 1.32876828e-01f, 9.39558446e-02f, 8.66916850e-02f, 7.79948756e-02f, 1.82369962e-01f, 1.73487753e-01f, 7.28677511e-02f, 1.50255650e-01f, 1.20649479e-01f,
  1.81397591e-02f, -5.56125976e-02f, 4.62621190e-02f, 6.03056094e-03f, -3.96194570e-02f, 1.30013879e-02f, 2.61227097e-02f, 1.80840828e-02f, 1.43306345e-01f, -1.57432500e-02f,
  -5.95644899e-02f, 1.05913937e-01f, 6.38322383e-02f, 3.87235582e-02f, 1.08483918e-01f, 1.18658744e-01f, -6.09451123e-02f, 1.95004810e-02f, -6.35761693e-02f, -1.42667234e-01f,
  -9.55634713e-02f, -4.08640429e-02f, -7.49055967e-02f, 8.05496946e-02f, 7.14492574e-02f, -2.18307022e-02f, 6.77976683e-02f, -6.94934092e-03f, 6.90149441e-02f, 1.20937929e-03f,
  -4.94356267e-02f, -3.73432226e-02f, -1.00629978e-01f, 9.62037370e-02f, 6.48152828e-02f, 7.98164904e-02f, -1.63361784e-02f, 3.08533832e-02f, 1.77429933e-02f, -5.37203401e-02f,
  7.22312927e-02f, 1.84419677e-02f, 2.75627337e-03f, -3.68950106e-02f, 6.29845858e-02f, 3.13250460e-02f, 5.20095341e-02f, -2.78043635e-02f, 1.57435462e-02f, -5.40159270e-02f,
  2.48386022e-02f, -2.06029397e-02f, -1.82967205e-02f, 2.38843765e-02f, -5.03672846e-02f, 2.23112591e-02f, -5.27622215e-02f, -1.23506069e-01f, 8.76961872e-02f, 4.93676811e-02f,
  -1.47062894e-02f, -1.46131031e-02f, 4.56483625e-02f, 3.96842808e-02f, -7.01211467e-02f, -1.61851309e-02f, -2.71136854e-02f, 9.65645630e-03f, 2.64249910e-02f, 4.91615236e-02f,
  -5.78322783e-02f, 1.03505462e-01f, 3.28943459e-03f, 8.39329958e-02f, 1.09879449e-01f, -3.30400355e-02f, 8.93547758e-02f, 4.67821062e-02f, 1.17526762e-02f, 8.86278134e-03f,
  3.13447639e-02f, -4.15073745e-02f, 3.60941738e-02f, -9.33252799e-04f, 8.26891959e-02f, -3.50077301e-02f, -3.12635601e-02f, 2.13905424e-03f, -6.97040409e-02f, -4.74730730e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 104)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 104;
const float L0_fan_Bp_bar_data[] = {
  -1.94011386e-02f, -6.58583194e-02f, -1.14472269e-03f, 1.05161622e-01f, 6.82040304e-02f, 5.39818630e-02f, 1.86851323e-01f, 7.68516064e-02f, 1.98600516e-01f, 6.51976839e-02f,
  7.16450661e-02f, 3.26061584e-02f, 3.77078429e-02f, 2.27674097e-02f, 8.94823298e-02f, 1.08660661e-01f, 9.01614279e-02f, 7.52240568e-02f, 1.49490699e-01f, 3.86596518e-03f,
  4.14922535e-02f, 1.47137726e-02f, 7.36082420e-02f, 1.35594741e-01f, 2.55964193e-02f, 5.72117306e-02f, 5.55355810e-02f, 1.36451766e-01f, 3.80114615e-02f, 2.87213046e-02f,
  8.28958955e-03f, -3.19127180e-02f, 2.75472719e-02f, 1.49194589e-02f, -3.45107876e-02f, 1.06395982e-01f, 2.92098429e-02f, 3.87831926e-02f, 8.98369551e-02f, 1.89661920e-01f,
  1.25358269e-01f, 1.20612562e-01f, -1.31678311e-02f, 3.16838957e-02f, 2.61247493e-02f, 1.67703807e-01f, 1.48065388e-01f, 1.49942160e-01f, -2.64427625e-02f, 1.78645745e-01f,
  3.11168302e-02f, 6.20568246e-02f, 2.60752235e-02f, 8.69215727e-02f, 2.92753670e-02f, 5.58446497e-02f, 6.34124950e-02f, 4.19286866e-04f, 1.45890459e-01f, 1.77506924e-01f,
  4.31589186e-02f, 4.29705642e-02f, 2.93608643e-02f, 3.09558045e-02f, 1.64017811e-01f, 9.05608833e-02f, 1.44188255e-01f, 1.31932050e-01f, 1.51658356e-01f, -2.48579085e-02f,
  6.53760657e-02f, 1.61723316e-01f, 1.45495459e-01f, 6.32079616e-02f, 6.06299425e-03f, 6.01243079e-02f, 1.84932202e-02f, 1.31227478e-01f, 1.80679351e-01f, 7.97611922e-02f,
  1.91121474e-01f, 2.06901468e-02f, 1.54841453e-01f, 8.60330760e-02f, 6.13930169e-04f, 1.59327194e-01f, 1.07595190e-01f, 1.40202135e-01f, 1.04446635e-02f, 1.12755336e-01f,
  7.93716833e-02f, 2.73127370e-02f, 8.69917199e-02f, 1.71052635e-01f, 1.08183935e-01f, -4.13507074e-02f, -3.77026498e-02f, -3.60120932e-04f, 1.92099139e-01f, 8.60427544e-02f,
  2.21093714e-01f, 5.81313623e-03f, 1.92766428e-01f, 6.05356097e-02f
};

// L1_linear_W (Shape: 12 x 128)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 128;
const float L1_linear_W_data[] = {
  6.00297973e-02f, -1.20446071e-01f, 5.34713604e-02f, 7.36728460e-02f, -3.08228880e-01f, 6.16056472e-02f, -3.25286448e-01f, -3.55016515e-02f, 2.07824726e-02f, -1.77645579e-01f,
  -4.21011269e-01f, -8.24204534e-02f, 2.96120010e-02f, -2.73162216e-01f, 3.69349509e-01f, 2.66338259e-01f, -3.31934959e-01f, -5.93762212e-02f, 4.30996150e-01f, 2.57407367e-01f,
  2.22514212e-01f, 1.38606071e-01f, 4.14585054e-01f, 3.00347507e-01f, 2.25474343e-01f, -6.35521067e-03f, -6.98063225e-02f, -8.42225030e-02f, -4.62431312e-02f, 7.25612342e-02f,
  -3.09240043e-01f, 3.92253995e-01f, -2.20492303e-01f, -3.36115472e-02f, 1.26458257e-01f, -7.44607598e-02f, 6.03892244e-02f, -6.21138960e-02f, 1.10106997e-01f, 1.12046022e-02f,
  1.12782255e-01f, 1.51480123e-01f, 2.38263130e-01f, -4.84958440e-02f, 5.34823202e-02f, 1.42439771e-02f, 9.01208892e-02f, 2.99892351e-02f, 9.17133316e-02f, -3.87213528e-02f,
  8.93862844e-02f, 6.75935686e-01f, 7.46844932e-02f, -1.46834001e-01f, 7.41325989e-02f, -1.18494397e-02f, 3.85971591e-02f, 1.84206348e-02f, -1.90124996e-02f, -4.83781546e-02f,
  -4.21282183e-03f, 1.76739708e-01f, 1.37387708e-01f, 1.95371713e-02f, -1.54291436e-01f, 5.45979924e-02f, -8.97915512e-02f, 5.20717442e-01f, 3.35890870e-03f, -1.92385152e-01f,
  -1.07658781e-01f, 6.05428368e-02f, -3.03730424e-02f, -1.32338896e-01f, -2.12821782e-01f, -3.89189087e-02f, 5.63988797e-02f, 1.39605045e-01f, -1.28459051e-01f, -1.16113268e-01f,
  -1.07808094e-02f, 4.57958244e-02f, -1.27367318e-01f, 8.10738057e-02f, 3.73503387e-01f, 1.13899946e-01f, -7.28297904e-02f, 2.96105854e-02f, 9.62832645e-02f, -1.54854491e-01f,
  1.13760668e-03f, 5.79573028e-02f, 1.83120057e-01f, -7.32622668e-02f, 8.62155482e-02f, -5.14543848e-03f, 2.94153571e-01f, -1.06710516e-01f, 1.15130968e-01f, -1.49892196e-01f,
  -1.58156067e-01f, 5.16290404e-02f, 3.51357274e-02f, 5.97462431e-02f, -1.43915877e-01f, -1.52062252e-02f, -2.35351413e-01f, -2.17157640e-02f, 1.69130549e-01f, -1.64104700e-01f,
  4.10249978e-02f, 8.57671723e-02f, -4.69330139e-02f, -2.32944667e-01f, 2.61967331e-01f, -4.13867198e-02f, -1.53503254e-01f, 4.81305784e-03f, 1.00254305e-01f, -2.30613556e-02f,
  -6.44276012e-03f, -4.88537885e-02f, -1.92400485e-01f, 1.73980206e-01f, -1.49926886e-01f, -1.41708106e-01f, -2.48764321e-01f, -1.90045655e-01f, -2.74307653e-02f, 2.03777060e-01f,
  2.05268487e-01f, -3.02756310e-01f, -7.43783340e-02f, -8.89148042e-02f, 9.41747278e-02f, 7.26599172e-02f, -1.22160986e-01f, 1.27874985e-01f, 2.76944786e-01f, 5.93744740e-02f,
  -2.69154878e-03f, -1.58280149e-01f, -3.00383955e-01f, -4.27819729e-01f, -2.27722660e-01f, 4.83268231e-01f, 3.45409304e-01f, 2.64018923e-01f, 3.18218142e-01f, 1.18844852e-01f,
  -1.44369677e-01f, 1.65039122e-01f, 1.22588471e-01f, 9.96187329e-02f, 3.98299396e-01f, -1.53976068e-01f, 4.00490254e-01f, -4.25072648e-02f, -6.17412068e-02f, -9.60883312e-03f,
  9.51577052e-02f, 9.66066942e-02f, -2.72440881e-01f, 2.55818278e-01f, -5.42307794e-02f, -1.32210925e-01f, -2.72104353e-01f, 3.56934935e-01f, -8.69218260e-02f, -5.93845956e-02f,
  -3.06860000e-01f, -1.85683295e-01f, -1.87783800e-02f, -1.95811599e-01f, -1.59738839e-01f, 1.10820003e-01f, -1.27239317e-01f, -1.32799298e-01f, -9.07749757e-02f, 4.45964873e-01f,
  -6.23608418e-02f, -1.37400761e-01f, -1.35970443e-01f, -1.37023240e-01f, 6.45636469e-02f, 8.47866014e-03f, -6.16528392e-02f, -1.25300050e-01f, 2.67271008e-02f, -1.77996475e-02f,
  5.80562316e-02f, -2.61345059e-01f, -2.53760129e-01f, -1.43675625e-01f, -1.40480325e-01f, 2.63124734e-01f, -4.51558977e-02f, -2.34453052e-01f, 1.44822136e-01f, -1.79091796e-01f,
  4.87691052e-02f, 2.10775947e-03f, -1.17916586e-02f, -1.62578508e-01f, -2.10405588e-02f, -4.00929004e-02f, 3.04711610e-02f, 1.72946677e-01f, -3.01822778e-02f, -1.45119219e-03f,
  1.82331562e-01f, -1.86473787e-01f, -3.10529828e-01f, 2.38687769e-01f, -1.11547701e-01f, -1.97923452e-01f, -1.55076280e-01f, -2.17760995e-01f, 4.05373126e-01f, 1.75725549e-01f,
  2.07465395e-01f, 1.89650804e-02f, -1.45704988e-02f, -8.34411010e-02f, 3.91504943e-01f, 7.18596056e-02f, 2.16212198e-01f, 6.82900399e-02f, -2.99370997e-02f, -1.17287897e-01f,
  2.73220092e-01f, 1.00183554e-01f, 4.51763486e-03f, -3.13117430e-02f, -1.03573792e-01f, 2.19824724e-02f, -2.34277949e-01f, -2.58949012e-01f, 4.16164808e-02f, -2.68878490e-02f,
  1.24646410e-01f, -5.84309287e-02f, 4.40165758e-01f, -3.80314514e-02f, 9.27360430e-02f, -1.05423532e-01f, -2.94690579e-01f, 1.49630263e-01f, 1.94020435e-01f, -8.36822465e-02f,
  -1.37728378e-01f, -2.16106623e-01f, -2.81317621e-01f, -2.17919126e-02f, -3.63966078e-02f, -2.42802590e-01f, -3.09919771e-02f, -1.08216424e-02f, -4.83732700e-01f, 1.87756382e-02f,
  -6.67122528e-02f, -1.86907455e-01f, 4.22847793e-02f, -2.10436285e-02f, -1.42377913e-01f, 9.21304002e-02f, -1.22438408e-01f, -8.56300001e-04f, 9.14777443e-02f, -7.56874830e-02f,
  -3.96762341e-01f, 3.64279337e-02f, 3.50499935e-02f, 3.81405681e-01f, 3.72220844e-01f, 2.48455390e-01f, 2.48341113e-01f, -2.01372102e-01f, -1.81581631e-01f, -2.13272646e-02f,
  5.19783944e-02f, 8.25142581e-03f, -1.14030771e-01f, 5.59480786e-02f, -5.10373376e-02f, -1.45500973e-01f, 4.35157657e-01f, 3.23837344e-03f, -8.75372291e-02f, -1.65754184e-01f,
  -1.10371776e-01f, 1.11042425e-01f, 9.15234461e-02f, -7.77951181e-02f, -1.19674809e-01f, -8.65070820e-02f, -6.14125691e-02f, -1.14977069e-01f, -1.58277333e-01f, 5.80224432e-02f,
  -1.93780676e-01f, -8.24187696e-02f, -1.54716328e-01f, -8.75959694e-02f, -5.94294444e-02f, -3.56102027e-02f, -5.35352081e-02f, -2.78447926e-01f, -1.59095392e-01f, 1.03212409e-01f,
  -1.67980388e-01f, -7.04926252e-02f, 1.21631272e-01f, -5.60821146e-02f, -3.97719722e-03f, -1.63469851e-01f, -1.25918807e-02f, 3.43450546e-01f, 4.89042327e-02f, -1.92680046e-01f,
  -1.53837316e-02f, -9.25577506e-02f, 1.02544029e-03f, -5.22643924e-02f, 3.41692835e-01f, 3.68887628e-03f, -1.45696938e-01f, -2.07392856e-01f, 1.45716712e-01f, 1.44338608e-01f,
  7.09703565e-02f, -1.11635290e-01f, -1.37498215e-01f, 2.10755438e-01f, 3.87975648e-02f, 9.58097354e-02f, -5.91110066e-02f, 1.91004336e-01f, -2.17815280e-01f, -1.88919216e-01f,
  -1.69650406e-01f, -6.33224100e-02f, -1.23795837e-01f, 8.83403495e-02f, 1.44933268e-01f, -4.68115285e-02f, 2.09644943e-01f, -1.54119387e-01f, -9.12834555e-02f, 4.21422608e-02f,
  -7.98989460e-02f, -1.29485458e-01f, -7.55278617e-02f, -1.00591900e-02f, 2.56071240e-01f, -5.35361990e-02f, -7.62112960e-02f, -1.64197862e-01f, 2.39211261e-01f, 4.85802859e-01f,
  1.17499873e-01f, -5.70938848e-02f, -1.94631461e-02f, -2.19380751e-01f, -2.56573725e-02f, -1.59733608e-01f, -5.78968674e-02f, -8.12329203e-02f, 1.58561636e-02f, 4.80700508e-02f,
  -2.19279543e-01f, 6.79348931e-02f, 3.83376747e-01f, -1.46090403e-01f, -1.67409375e-01f, 1.68730374e-02f, 1.05945326e-01f, 6.70716241e-02f, -5.25709130e-02f, -4.96095493e-02f,
  -9.61547047e-02f, -1.43023357e-01f, 3.09632927e-01f, 5.92984557e-01f, -1.31687105e-01f, -1.64081335e-01f, -2.56365120e-01f, -3.28477621e-01f, -9.58893299e-02f, -2.99175709e-01f,
  5.36716729e-02f, -1.54629657e-02f, 3.56007293e-02f, -1.60556920e-02f, -1.52876973e-01f, 2.55506230e-03f, -3.26919168e-01f, 2.06842288e-01f, 4.67294902e-01f, 2.61408061e-01f,
  6.77295029e-02f, -3.60494822e-01f, 1.50718063e-01f, 2.01061338e-01f, -1.13712035e-01f, 4.37586568e-02f, 2.78535903e-01f, 3.04579914e-01f, 1.66206528e-02f, 1.07484683e-02f,
  -1.61674723e-01f, -3.93234380e-03f, -1.05947452e-02f, 2.90818959e-01f, -1.12996481e-01f, 3.98549706e-01f, -2.92830188e-02f, 2.67708033e-01f, 2.34893888e-01f, -5.48818968e-02f,
  -1.15388289e-01f, 2.80192271e-02f, -1.61445946e-01f, -1.83914676e-01f, 5.08953221e-02f, 1.73489079e-01f, 1.62045762e-01f, -5.52243739e-03f, -6.35925159e-02f, 3.87296259e-01f,
  -1.94227118e-02f, -1.31958589e-01f, 3.55146289e-01f, 5.58974547e-03f, -1.56017631e-01f, -2.34202370e-01f, 1.70089290e-01f, -1.37770176e-01f, 2.25083306e-01f, 1.25495389e-01f,
  -1.46652266e-01f, -3.70984301e-02f, 1.30848512e-01f, -5.42798871e-03f, 1.99145973e-01f, -6.10714518e-02f, 2.67625570e-01f, -2.17249200e-01f, -1.90724030e-01f, -8.50136951e-02f,
  -4.71445061e-02f, -1.11308701e-01f, -5.86634725e-02f, -2.61334572e-02f, 3.13711256e-01f, 2.58556064e-02f, -1.84921682e-01f, 9.75775644e-02f, -7.62398094e-02f, 2.94124216e-01f,
  5.42911775e-02f, -5.01192473e-02f, -1.20854629e-02f, -7.94449821e-02f, 1.09089531e-01f, -1.98481932e-01f, 5.08771650e-02f, -1.53141662e-01f, -1.56133592e-01f, 1.74150154e-01f,
  3.51187050e-01f, -5.04805855e-02f, -2.01116368e-01f, -2.12537199e-01f, -1.22401945e-01f, -2.44509373e-02f, -1.92228258e-01f, 2.20743529e-02f, 2.35867038e-01f, -1.52083099e-01f,
  -2.08751604e-01f, -2.13730261e-02f, 2.46331636e-02f, -4.76524495e-02f, -8.14797636e-03f, 3.95318195e-02f, -1.58758834e-01f, -1.50479138e-01f, -3.57444026e-02f, -8.68779495e-02f,
  -2.83007901e-02f, -5.40346913e-02f, 7.44802654e-02f, 3.16976994e-01f, 9.92060155e-02f, -1.19434722e-01f, -1.15230650e-01f, -6.14701658e-02f, -1.48441821e-01f, 2.27933004e-02f,
  -2.24241689e-01f, -6.33277744e-02f, -8.36183205e-02f, -3.33942585e-02f, 3.21754850e-02f, 2.66817480e-01f, 4.58260104e-02f, -9.90151539e-02f, 6.68887496e-01f, 1.04789421e-01f,
  -6.56390004e-03f, -1.35082841e-01f, 4.66226995e-01f, 2.10330039e-02f, 2.41624355e-01f, 2.46839583e-01f, 3.16174179e-01f, 2.60100633e-01f, 1.96838930e-01f, 2.08834365e-01f,
  -4.04048339e-02f, 2.04662666e-01f, 1.27174020e-01f, 1.60202622e-01f, 5.76911382e-02f, -3.49387914e-01f, 2.96824634e-01f, 3.98767799e-01f, 9.69332606e-02f, -4.10136551e-01f,
  5.08433104e-01f, -1.98508248e-01f, -3.57268423e-01f, -1.87484566e-02f, 2.06701726e-01f, -1.16275825e-01f, 2.23918166e-02f, 1.33031653e-02f, -1.41673952e-01f, -6.82498217e-02f,
  -7.61902481e-02f, -7.47587951e-03f, -1.85355976e-01f, 3.39104608e-02f, -2.16224864e-01f, 1.01191044e-01f, -1.06900297e-02f, -1.83120407e-02f, -3.59464958e-02f, 1.79025400e-02f,
  1.66847333e-01f, -2.11349800e-01f, -5.97568341e-02f, 1.46311611e-01f, -8.14845785e-02f, -2.13241696e-01f, -6.99001253e-02f, 9.59825441e-02f, -9.51442122e-02f, -1.62119120e-01f,
  1.18621752e-01f, 1.79158375e-01f, 7.54424045e-03f, -1.12184033e-01f, 5.52629530e-02f, -6.45923838e-02f, -9.45490003e-02f, 8.94439444e-02f, -3.53520326e-02f, 5.07929444e-01f,
  -1.50456186e-02f, -2.63198614e-02f, -1.73312306e-01f, 3.68634723e-02f, -9.13433805e-02f, 1.51513785e-01f, -6.29320964e-02f, 2.15599224e-01f, 9.73090250e-03f, -2.00857505e-01f,
  -9.98988450e-02f, 3.18841577e-01f, -1.72032490e-01f, 4.23303545e-01f, -1.40572235e-01f, -2.28035778e-01f, 1.09103672e-01f, -1.30739868e-01f, -6.50107488e-02f, -7.04377443e-02f,
  -1.08887836e-01f, -9.56659243e-02f, 4.77668494e-02f, 1.79438919e-01f, -2.64523149e-01f, -2.89961360e-02f, 1.14938468e-01f, 2.64384449e-02f, -4.33648936e-03f, 1.42287016e-01f,
  1.44921154e-01f, 6.42128810e-02f, -2.18065247e-01f, -2.85743214e-02f, 3.76341820e-01f, 3.29831988e-02f, 1.97447743e-03f, -1.84284151e-01f, -1.81945384e-01f, 4.19855826e-02f,
  -1.05375508e-02f, 1.13070510e-01f, -2.73769442e-02f, -2.83999164e-02f, 9.14614741e-03f, -1.82910874e-01f, 5.74550033e-02f, -9.24376249e-02f, 2.20764816e-01f, 2.94645596e-02f,
  -1.36528626e-01f, 2.09797621e-01f, 4.10046607e-01f, 4.22148444e-02f, -6.75689504e-02f, 1.76494718e-01f, -1.79855049e-01f, -1.95932373e-01f, -7.93985575e-02f, 8.31774697e-02f,
  3.39513391e-01f, 2.32458398e-01f, -3.57345082e-02f, -2.43513823e-01f, -1.52930215e-01f, -1.34102866e-01f, 5.44924319e-01f, 7.13384673e-02f, -6.89653903e-02f, -1.51216030e-01f,
  1.01857305e-01f, 1.95252731e-01f, -1.12015478e-01f, 6.46226853e-02f, 2.66398519e-01f, 2.33435214e-01f, 1.85671672e-01f, 9.79748592e-02f, 3.08257520e-01f, 1.80576503e-01f,
  2.01830775e-01f, 2.88875937e-01f, 2.64500499e-01f, 4.50290740e-01f, 1.20242946e-01f, -4.51515406e-01f, 1.46792263e-01f, 6.47328719e-02f, -5.13486147e-01f, -3.94668788e-01f,
  -3.38167064e-02f, 1.43569291e-01f, 1.49618626e-01f, -2.34559372e-01f, -1.65579975e-01f, 7.82502443e-03f, -3.63978706e-02f, -1.16884582e-01f, 1.48262028e-02f, -1.32853553e-01f,
  -2.04932034e-01f, -1.04099348e-01f, 4.19210225e-01f, -1.90382317e-01f, 3.64487499e-01f, -1.12265669e-01f, -8.27827305e-02f, -5.12399375e-02f, 1.00969866e-01f, 2.52384335e-01f,
  5.80873527e-02f, 3.27176899e-01f, 6.42462522e-02f, -1.58570677e-01f, 1.88351393e-01f, -1.95559829e-01f, -2.15562154e-02f, 1.36043867e-02f, -2.12906405e-01f, -8.64317492e-02f,
  -1.91630229e-01f, 3.52083057e-01f, 1.20698929e-01f, -2.92715058e-02f, -1.43143445e-01f, -2.18448684e-01f, 6.46456107e-02f, -6.17781542e-02f, 5.04373349e-02f, 9.64723006e-02f,
  1.66060582e-01f, -1.35486171e-01f, 1.45546626e-02f, -1.09304890e-01f, -5.07922098e-02f, 1.88778847e-01f, -1.32488355e-01f, 1.79589063e-01f, 8.08112398e-02f, -1.83032215e-01f,
  -7.35712796e-02f, -3.78712416e-02f, 6.26770854e-02f, -1.05303131e-01f, 7.07546100e-02f, -1.27621040e-01f, -7.32552400e-03f, -1.87747151e-01f, -1.13175891e-01f, 1.59967259e-01f,
  3.90755432e-03f, 6.89039007e-02f, -1.09024361e-01f, 1.94182947e-01f, 4.76929732e-02f, 1.36682272e-01f, -1.12949483e-01f, -7.42934197e-02f, 2.22292572e-01f, 2.93102656e-02f,
  -1.17933691e-01f, -9.48347449e-02f, -9.91149619e-02f, -9.00280252e-02f, 3.92886102e-02f, 2.63325959e-01f, 1.41473860e-01f, 6.51674196e-02f, -1.84230670e-01f, -8.35839361e-02f,
  -1.11049309e-01f, -8.99027959e-02f, 2.30109274e-01f, 4.23600385e-03f, -2.87105739e-01f, 5.13322726e-02f, -4.60634269e-02f, 4.02052641e-01f, -1.11810178e-01f, 1.74462453e-01f,
  2.78493434e-01f, -1.41205162e-01f, 8.96109194e-02f, -1.98127970e-01f, 8.88916254e-02f, -1.66903332e-01f, -4.69027981e-02f, 5.54801285e-01f, 1.13451429e-01f, -2.59509236e-02f,
  -1.82225108e-01f, -8.66865590e-02f, -2.59324491e-01f, -5.67732379e-02f, -2.06691921e-01f, -1.40153430e-02f, -1.28413603e-01f, 9.29570422e-02f, 8.06740746e-02f, 8.80591795e-02f,
  2.48684272e-01f, 8.00910890e-02f, 8.61458331e-02f, -3.03607404e-01f, -5.39677739e-02f, -1.85498551e-01f, -5.65391816e-02f, -2.49388427e-01f, -9.69809741e-02f, 8.95311460e-02f,
  1.71326268e-02f, -8.19045752e-02f, 1.05472937e-01f, -2.77738333e-01f, 2.30586380e-01f, 5.05361021e-01f, -3.78805161e-01f, -3.12069654e-01f, -1.76358566e-01f, -2.48375922e-01f,
  -1.91140875e-01f, -2.99238473e-01f, -2.86897570e-02f, -1.49165848e-02f, -1.56681940e-01f, -6.01442307e-02f, 2.84156669e-02f, -1.85303152e-01f, 3.01233858e-01f, -2.09847540e-01f,
  1.62710696e-01f, -1.53052360e-01f, -1.61262006e-01f, -2.54986823e-01f, 2.68541515e-01f, 8.25483650e-02f, 1.51618849e-02f, 2.35062744e-02f, -1.57058582e-01f, 5.71967661e-02f,
  -1.12879544e-01f, 9.64465514e-02f, -1.33845791e-01f, -5.67844883e-02f, 1.29201412e-01f, -2.11243570e-01f, -4.93055657e-02f, 4.60728370e-02f, 2.27211744e-01f, -1.61734849e-01f,
  -9.36738178e-02f, 1.24294683e-01f, -2.45768353e-02f, -1.38529271e-01f, 3.54308695e-01f, 6.57411888e-02f, -2.83934474e-02f, -4.78112660e-02f, -8.03603753e-02f, -4.30730060e-02f,
  -2.21866518e-01f, 1.59387633e-01f, 2.22623736e-01f, -1.74848422e-01f, -5.94871044e-02f, -9.58007723e-02f, 1.85918927e-01f, 6.58328980e-02f, -2.47164117e-03f, 9.82662365e-02f,
  -1.43509597e-01f, 4.97233570e-01f, 2.23550484e-01f, 2.48010263e-01f, -1.66786298e-01f, -4.37004976e-02f, -5.77208847e-02f, 2.02568039e-01f, -3.76753397e-02f, 1.58086732e-01f,
  -1.79157481e-01f, -1.66675657e-01f, -1.36760950e-01f, -2.02357471e-02f, -1.38027929e-02f, 1.05602965e-01f, 6.10333355e-03f, 2.92770058e-01f, -1.15299374e-01f, 3.17490131e-01f,
  -1.29091933e-01f, 1.65286176e-02f, -2.43037820e-01f, 3.18333030e-01f, -4.88645360e-02f, 2.24771444e-02f, -8.01110566e-02f, 2.68749207e-01f, 5.09121940e-02f, -1.08285397e-01f,
  1.27472460e-01f, -2.76664272e-02f, 1.96672808e-02f, 2.03472435e-01f, -5.32588437e-02f, 2.23784298e-01f, -1.30439773e-02f, -9.95958149e-02f, -7.96723366e-02f, 1.48854688e-01f,
  -3.28689590e-02f, 3.13007981e-02f, 3.74075435e-02f, -2.49159266e-03f, -3.82652402e-01f, -2.34775711e-02f, -1.64666340e-01f, -5.67439944e-02f, 7.20943063e-02f, -1.29891858e-01f,
  -5.59409894e-02f, 5.23426682e-02f, -1.32800877e-01f, 3.83987129e-01f, 6.29347205e-01f, 1.94614664e-01f, -6.80298656e-02f, -1.90463096e-01f, -2.12395683e-01f, 1.36465253e-03f,
  -3.64076085e-02f, -1.41520217e-01f, -3.48650478e-02f, -7.85668865e-02f, -2.62553334e-01f, -7.07803965e-02f, -5.80965132e-02f, -1.20971449e-01f, 3.25667918e-01f, 1.41811892e-01f,
  1.75761208e-01f, 1.72319129e-01f, -6.08431585e-02f, -3.03754538e-01f, -1.12266339e-01f, 1.01613156e-01f, 1.64136350e-01f, -1.75016355e-02f, 1.64522469e-01f, -1.11603253e-01f,
  -1.50015801e-01f, 2.07713991e-01f, -1.52033828e-02f, 3.09109744e-02f, -3.50690559e-02f, -1.72991276e-01f, -1.31584872e-02f, -2.25949869e-01f, -2.42891926e-02f, 5.44202654e-03f,
  9.62037891e-02f, -1.12571239e-01f, -1.09746791e-01f, 2.09171772e-01f, 1.88380241e-01f, -4.16435525e-02f, 2.24699184e-01f, -1.00576850e-02f, 7.49702752e-03f, -1.40997432e-02f,
  3.49835277e-01f, 2.04369836e-02f, 2.14026302e-01f, -1.26611337e-01f, -1.37338921e-01f, 1.25933409e-01f, -8.70388672e-02f, -7.28982016e-02f, 7.14949742e-02f, 1.47320822e-01f,
  6.16185553e-02f, 8.21550712e-02f, -9.09606144e-02f, -9.55044106e-02f, 2.54469633e-01f, 1.82517424e-01f, 5.06404527e-02f, 7.46485293e-02f, 6.80566877e-02f, -9.37517062e-02f,
  3.56138498e-01f, -1.33529687e-02f, 3.41975480e-01f, -2.02690497e-01f, -2.45087016e-02f, -3.33067253e-02f, 1.64203849e-02f, 3.55238817e-03f, -1.33988336e-01f, 2.45207828e-02f,
  -7.78919011e-02f, 2.54850686e-02f, 4.10148621e-01f, -6.54370114e-02f, 3.60540301e-01f, -3.38078402e-02f, 1.06280997e-01f, -2.56208200e-02f, 4.60588008e-01f, -6.06148280e-02f,
  1.82441890e-03f, -1.40736178e-01f, -1.22065090e-01f, 3.96610573e-02f, -4.40379698e-03f, -6.37132302e-02f, 1.05794609e-01f, -2.60027032e-02f, -1.93815008e-01f, 3.78781110e-02f,
  7.28486180e-02f, 8.22016224e-02f, -8.72513503e-02f, -1.46277338e-01f, 2.49112081e-02f, -3.80182173e-03f, 9.32303369e-02f, 3.65409821e-01f, -1.46299496e-01f, -9.62074995e-02f,
  -1.74977437e-01f, -7.89217800e-02f, 4.98558767e-02f, -9.90199894e-02f, -1.19952239e-01f, 4.05698240e-01f, 3.95968817e-02f, -9.00775120e-02f, 5.41537674e-03f, -8.65953788e-02f,
  -1.00799434e-01f, 7.45816529e-03f, -3.94093804e-02f, -7.87711740e-02f, 1.13292277e-01f, 9.29616168e-02f, -1.91054970e-01f, 1.98519170e-01f, -1.48658782e-01f, 2.99614310e-01f,
  -4.55013886e-02f, 8.27695336e-03f, -2.11610254e-02f, -6.88089207e-02f, -3.37043740e-02f, -1.77975982e-01f, -2.19793171e-01f, -7.14606568e-02f, -7.70529881e-02f, -5.91685809e-02f,
  -4.31182161e-02f, 2.00888999e-02f, -8.52530524e-02f, -1.81035027e-01f, -8.16191956e-02f, -2.22527772e-01f, -1.07317887e-01f, 1.89504802e-01f, -3.48540664e-01f, -1.47582024e-01f,
  3.16079706e-01f, -4.38989729e-01f, -2.59243250e-01f, -2.29490176e-01f, -1.09883375e-03f, 3.06170613e-01f, 9.73867849e-02f, 2.76186407e-01f, -7.35629201e-02f, -6.99688308e-03f,
  3.57149355e-02f, 3.76107723e-01f, 4.48669016e-01f, 7.85478428e-02f, 2.85683721e-01f, -2.32456159e-03f, 4.64927517e-02f, -1.10618211e-01f, -2.67620310e-02f, -2.91173253e-02f,
  1.53406739e-01f, 2.30347868e-02f, -1.85377121e-01f, -9.30365920e-02f, 9.55454186e-02f, -1.21514753e-01f, -1.06914258e-02f, 4.62260768e-02f, -5.92849962e-02f, -8.36273879e-02f,
  7.23722428e-02f, -9.77091491e-02f, 1.31693736e-01f, -5.38344756e-02f, 1.13781001e-02f, -4.68328297e-02f, 8.07098225e-02f, -1.03877246e-01f, 4.03960317e-01f, -2.21337546e-02f,
  3.81238572e-02f, -5.57119437e-02f, -9.25955251e-02f, 3.57594490e-02f, -7.56842270e-02f, -2.41820347e-02f, -6.09566793e-02f, 4.02607173e-02f, -1.81754213e-02f, -8.96760356e-03f,
  3.53013240e-02f, 1.90672800e-02f, -3.45657356e-02f, 4.63097841e-02f, 2.54306585e-01f, -1.35379493e-01f, 1.02967702e-01f, -1.88809499e-01f, -3.60308103e-02f, -1.35727838e-01f,
  3.23343389e-02f, -9.61335525e-02f, -1.91644073e-01f, 8.58047828e-02f, 2.84155518e-01f, 1.97640374e-01f, -6.78790584e-02f, 2.33766451e-01f, -9.22765061e-02f, -2.13804338e-02f,
  1.35326371e-01f, 1.06221572e-01f, 1.43489111e-02f, 1.54617622e-01f, 3.15527111e-01f, -1.69637293e-01f, -1.80202246e-01f, -1.44758731e-01f, -1.38088301e-01f, -9.12427008e-02f,
  -6.11611567e-02f, 7.85840452e-02f, 1.41061395e-01f, -9.67249051e-02f, 1.20651737e-01f, -1.92370251e-01f, -8.04647952e-02f, -9.17964950e-02f, 4.52748954e-01f, -1.10416614e-01f,
  -8.26636106e-02f, 2.38170885e-02f, -1.37377009e-01f, -8.10776353e-02f, -7.41523281e-02f, -2.60322448e-02f, -1.92572370e-01f, 1.95305541e-01f, 1.21703148e-01f, 1.20736472e-01f,
  4.90847945e-01f, -1.13704719e-01f, -1.52500391e-01f, -9.33885351e-02f, 8.63295340e-04f, 1.79052278e-01f, 1.70592681e-01f, -2.15321742e-02f, -1.65565163e-01f, -9.75116417e-02f,
  -4.10544276e-02f, 1.53049827e-01f, -2.84888208e-01f, -6.88326582e-02f, 9.05459672e-02f, 1.52106881e-01f, 1.66270568e-03f, 2.43031770e-01f, 2.25532293e-01f, 1.56874597e-01f,
  2.49560833e-01f, 5.69622964e-02f, 7.36772493e-02f, -2.25626975e-01f, 5.18503070e-01f, -3.00253659e-01f, -1.33362666e-01f, 3.95761244e-02f, -2.99594045e-01f, 3.13772820e-02f,
  -3.04391563e-01f, -1.73620749e-02f, 1.60064727e-01f, -2.31653407e-01f, -3.71381462e-01f, -4.56518680e-01f, 9.53278244e-02f, -4.61520031e-02f, -3.39684673e-02f, -1.86079845e-01f,
  -2.69450665e-01f, -1.47595137e-01f, -1.44697666e-01f, -2.49691784e-01f, -2.35167235e-01f, -1.93686038e-01f, -2.08811939e-01f, 3.14707518e-01f, 2.43478402e-01f, 6.39023632e-02f,
  2.33185217e-01f, -1.40495077e-01f, -2.59122372e-01f, -3.15435171e-01f, -3.93595770e-02f, 1.75420269e-02f, 3.02542094e-02f, -5.90507910e-02f, 2.88566370e-02f, -1.51990011e-01f,
  -1.62499756e-01f, -6.87867105e-02f, 4.47355241e-01f, -2.31293872e-01f, -6.26011984e-03f, 4.02755558e-01f, -7.69315213e-02f, 3.42413560e-02f, 3.60252708e-02f, -1.47714256e-03f,
  7.14463042e-03f, 1.88405946e-01f, -1.56111956e-01f, 2.12282479e-01f, -8.46306235e-02f, 2.80839503e-01f, -8.35076645e-02f, 3.00520808e-01f, 2.65467405e-01f, -9.11024436e-02f,
  -6.07085824e-02f, -5.00780717e-02f, -1.05517782e-01f, -4.17662486e-02f, 2.32237391e-03f, -2.26963997e-01f, -2.12411080e-02f, -2.14613602e-01f, -2.39087552e-01f, 3.23264040e-02f,
  2.32837945e-01f, -1.46388277e-01f, -4.38537337e-02f, -1.29919887e-01f, 1.05221510e-01f, -1.05913460e-01f, 2.64970571e-01f, -3.69989723e-02f, -1.61272988e-01f, 2.02512015e-02f,
  2.14805100e-02f, 4.83217329e-01f, 1.09454757e-03f, 9.25293565e-03f, -4.24379148e-02f, 2.91645885e-01f, -2.18307495e-01f, 1.10163078e-01f, 3.18509266e-02f, -1.61566570e-01f,
  8.04787651e-02f, 3.49738542e-03f, 2.06698492e-01f, 4.77653928e-02f, -2.03217909e-01f, -1.88469201e-01f, 2.22956836e-01f, -7.50710666e-02f, 9.13571846e-03f, -2.71905884e-02f,
  3.38767648e-01f, -2.15532467e-01f, 1.02888033e-01f, 2.35571742e-01f, -3.07880249e-02f, 1.06726669e-01f, -2.98628300e-01f, -1.25500277e-01f, 6.84577227e-02f, 8.52666348e-02f,
  1.73903093e-01f, -6.45882487e-02f, -5.12069911e-02f, -9.37427580e-02f, -1.16578825e-01f, 5.55422083e-02f, -2.13015035e-01f, -1.20194359e-02f, -2.11286411e-01f, -8.17521662e-02f,
  -9.95125175e-02f, 1.66133195e-01f, 2.96190888e-01f, 2.32080266e-01f, 8.94735232e-02f, 2.87481040e-01f, 1.00964420e-01f, -8.79693031e-02f, -8.12142622e-04f, 9.50299129e-02f,
  1.85115859e-01f, 5.95397651e-02f, -4.27861869e-01f, 1.50198817e-01f, -1.72349215e-01f, -9.08805579e-02f, -1.93502352e-01f, 2.98255011e-02f, 1.92833275e-01f, 4.07875597e-01f,
  -1.29599646e-01f, 2.20650256e-01f, -1.01150334e-01f, -1.23317517e-01f, -4.88022342e-02f, -1.91006675e-01f, 9.63661224e-02f, 2.34565601e-01f, -1.44071952e-01f, 3.75670567e-02f,
  1.08281761e-01f, 5.60915023e-02f, -9.27556455e-02f, 4.02888149e-01f, -2.31457993e-01f, 9.83249024e-02f, -1.75749719e-01f, -3.66570838e-02f, -7.88400099e-02f, 6.45535290e-02f,
  -1.56246424e-01f, -8.64815786e-02f, -1.33253440e-01f, 6.75836876e-02f, -7.91106373e-02f, 1.66959941e-01f, -1.31492764e-01f, 3.77215415e-01f, 1.63959280e-01f, 7.45539516e-02f,
  -1.15622386e-01f, -1.01656638e-01f, 1.21850207e-01f, -9.23619941e-02f, 1.38038397e-01f, 7.02253878e-02f, -1.65149629e-01f, -1.48247972e-01f, -3.29265930e-03f, -1.77086964e-01f,
  1.58077180e-01f, -1.68264881e-01f, 1.75476626e-01f, -2.14880481e-01f, -2.58298695e-01f, -1.42465621e-01f, -1.67983994e-02f, -1.88095436e-01f, -9.02472585e-02f, 6.27441099e-03f,
  9.61937830e-02f, -1.05380863e-01f, 3.58582363e-02f, 1.02251396e-01f, -7.16717467e-02f, 3.13290089e-01f, 2.39251647e-03f, 4.05803412e-01f, -8.96731466e-02f, -1.75706670e-01f,
  -1.16637666e-02f, -1.30595058e-01f, 8.04485232e-02f, -1.40819952e-01f, -2.28634492e-01f, -1.45912990e-01f, 2.67435879e-01f, -1.45871583e-02f, -2.86476672e-01f, -1.93598509e-01f,
  -1.28686935e-01f, 1.59830656e-02f, -1.13873646e-01f, -1.48759350e-01f, 1.55568495e-01f, -7.38626495e-02f, -1.51168302e-01f, 1.83064997e-01f, -1.68680608e-01f, -6.68281764e-02f,
  -1.27454251e-02f, 2.20198601e-01f, -1.26546239e-02f, -1.58896282e-01f, -1.69808015e-01f, -4.39627133e-02f, 2.68877298e-01f, -1.86387658e-01f, 4.42623533e-02f, -1.89093798e-01f,
  -7.65465647e-02f, -1.46835834e-01f, 1.07007615e-01f, 6.13223016e-02f, -8.15562978e-02f, 2.71386743e-01f, -1.34304047e-01f, -1.90913454e-01f, -1.76342428e-02f, 1.43210299e-03f,
  7.15795010e-02f, 2.86865771e-01f, 5.71694553e-01f, -7.61332810e-02f, -3.16936731e-01f, -1.14653438e-01f, -2.36988917e-01f, -1.54355476e-02f, 1.80457592e-01f, -1.66827902e-01f,
  2.08259389e-01f, 6.27272204e-02f, -1.88785896e-01f, 1.28690183e-01f, -2.02174142e-01f, -2.30775457e-02f, 1.01459756e-01f, 1.18410006e-01f, 3.20688486e-02f, 5.81130013e-02f,
  9.38184261e-02f, 4.08365607e-01f, -4.72741276e-02f, 3.48421156e-01f, 4.65631127e-01f, -1.92123074e-02f, -4.82786059e-01f, -2.70119637e-01f, 3.50593254e-02f, -3.23027465e-03f,
  -8.70967060e-02f, 1.04981966e-01f, 4.78490107e-02f, -1.48595218e-02f, -1.57537818e-01f, -1.38182625e-01f, -1.57919705e-01f, 4.73739143e-04f, -7.45162889e-02f, -4.36897129e-02f,
  3.44904870e-01f, 1.26420036e-01f, 2.57685721e-01f, -1.36874840e-01f, -1.33547708e-01f, 2.81408638e-01f, -1.47072911e-01f, 1.40716836e-01f, 2.16199420e-02f, -1.40056228e-02f,
  3.18002075e-01f, 3.24922353e-01f, -8.20798334e-03f, 9.14166123e-02f, -1.20523483e-01f, 2.07883835e-01f, -6.45878389e-02f, 1.32962897e-01f, -7.06538558e-03f, -2.83523560e-01f,
  -9.99929104e-03f, -2.66615376e-02f, -2.02191368e-01f, -2.42771469e-02f, -1.84432447e-01f, 1.75190326e-02f, -1.26395300e-01f, 2.63663322e-01f, -2.93495250e-03f, -1.56830013e-01f,
  1.52664602e-01f, 8.58486444e-02f, 3.11152011e-01f, -1.00429676e-01f, 8.90216902e-02f, -1.75299436e-01f, 1.05156433e-02f, -1.44659564e-01f, 2.52907835e-02f, 6.07858188e-02f,
  2.79165119e-01f, 1.60512984e-01f, 7.23297223e-02f, 1.93489343e-02f, -1.63212538e-01f, 2.59225368e-02f, -1.89596340e-01f, -1.68511808e-01f, 2.59890500e-02f, -1.84649080e-02f,
  -1.01498626e-01f, 6.08999550e-01f, -5.66279516e-02f, -1.38498098e-01f, 4.42247698e-03f, -3.53891402e-02f, -5.28612062e-02f, 9.21342969e-02f, -9.14516672e-02f, -4.57197949e-02f,
  4.00675200e-02f, -8.38030279e-02f, -1.42013244e-02f, -1.33086994e-01f, -2.24686623e-01f, -6.24473579e-03f, -1.38403609e-01f, 2.85326652e-02f, 1.67603105e-01f, -1.12200670e-01f,
  -1.82683304e-01f, 1.08263113e-01f, -2.06485197e-01f, 4.84153301e-01f, 1.89055037e-02f, -5.13942912e-02f, -9.30707604e-02f, -8.33077505e-02f, -1.14593454e-01f, 1.41654342e-01f,
  -1.17540564e-02f, -1.37638539e-01f, 1.33538082e-01f, 6.91019231e-03f, -1.44573808e-01f, -1.80127025e-01f, 8.37495029e-02f, -1.27968835e-02f, 6.70038909e-02f, -5.81556000e-02f,
  4.04945046e-01f, 1.70982435e-01f, 4.50543821e-01f, -1.76093057e-01f, 6.68390542e-02f, -9.81256813e-02f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  2.44283341e-02f, -3.41073759e-02f, -2.37532388e-02f, -5.87564856e-02f, 6.46849722e-02f, -6.44104509e-03f, 7.81842694e-02f, -2.95724068e-02f, -5.28194532e-02f, 9.38766077e-02f,
  9.66136903e-02f, -8.56304541e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 12, 104
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        128, 12
    );
    }
    