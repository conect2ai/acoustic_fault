/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 128 (x2)
    * Saída: 12
    * Buffer Máx: 128
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 128;
    const int FAN_MAX_BUFFER_SIZE = 128;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 51 x 120)
const int L0_fan_Wp_rows = 51;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -5.30261219e-01f, -9.04156864e-02f, 1.14888601e-01f, -2.13663459e-01f, 2.60610342e-01f, 3.91955465e-01f, 3.52623105e-01f, 1.20556697e-01f, -1.09975852e-01f, 1.30775079e-01f,
  1.82057902e-01f, 1.30172849e-01f, 6.38577715e-02f, 1.25532091e-01f, 6.53193966e-02f, 1.64033607e-01f, 5.94752170e-02f, 9.70657393e-02f, 2.11124480e-01f, 9.59900618e-02f,
  1.76418014e-02f, -1.69963375e-01f, -1.27064690e-01f, -1.19293474e-01f, 2.83839479e-02f, -6.98612034e-02f, -6.16779290e-02f, 5.63069023e-02f, 7.17206895e-02f, -8.48841742e-02f,
  2.72355139e-01f, -5.42772673e-02f, 1.01252258e-01f, -7.25724315e-03f, 1.47299185e-01f, -8.02327618e-02f, 1.29893750e-01f, -8.18053782e-02f, 3.94704863e-02f, -8.25658813e-03f,
  1.22880816e-01f, 5.51634729e-02f, 7.46675208e-02f, -7.24326149e-02f, -3.89046036e-02f, 2.50215456e-03f, -1.55128330e-01f, -2.95655765e-02f, 9.36030131e-03f, -1.00689949e-02f,
  -1.94402598e-02f, 1.17734767e-01f, 9.74255055e-02f, -5.08557521e-02f, -1.08074881e-01f, 3.84250656e-02f, 2.19026897e-02f, -6.29840493e-02f, -5.54715469e-02f, -7.58779868e-02f,
  1.13269754e-01f, 9.19626355e-02f, -6.66617369e-03f, 6.54813275e-02f, 9.14570540e-02f, 1.37102250e-02f, 5.18464558e-02f, -2.90481485e-02f, 4.45720628e-02f, 6.90320507e-02f,
  -3.74641791e-02f, 5.18316664e-02f, 6.96854219e-02f, -2.23038923e-02f, 4.64009717e-02f, 4.05759811e-02f, 1.60987116e-02f, -3.04692145e-02f, -4.33652699e-02f, -7.62986578e-03f,
  2.96907946e-02f, -2.08654739e-02f, 4.80059683e-02f, -2.16440875e-02f, 2.60512345e-02f, -4.55405191e-02f, 1.84862558e-02f, -2.36028749e-02f, -2.93236431e-02f, 5.34075201e-02f,
  1.03821605e-01f, 1.51264325e-01f, 9.49739292e-02f, 2.81398203e-02f, 9.01524536e-03f, -9.04002786e-02f, 1.11845851e-01f, 1.77294333e-02f, 1.72226094e-02f, -1.03121530e-02f,
  2.96087060e-02f, -5.56304492e-02f, 1.71676558e-02f, -1.02924351e-02f, 8.84461179e-02f, 9.37324315e-02f, -7.04701841e-02f, 2.18066350e-02f, 7.14460239e-02f, 2.30713189e-02f,
  -6.06221147e-02f, -3.79929617e-02f, 4.60087846e-04f, 5.87438457e-02f, 5.77348098e-02f, 1.27389014e-01f, 1.16374411e-01f, 1.16829902e-01f, 2.35173628e-02f, -8.20322633e-02f,
  2.35548347e-01f, 1.90134436e-01f, -3.58335406e-01f, 7.70007819e-02f, -2.79086456e-02f, -1.97724536e-01f, -2.96639413e-01f, 1.32196397e-02f, 8.31264332e-02f, -5.50755523e-02f,
  2.73211207e-03f, 1.03815608e-01f, 1.41166523e-01f, 5.34838773e-02f, -4.92827594e-02f, -2.01227784e-01f, -2.02133402e-01f, -1.81974083e-01f, -2.04604670e-01f, -1.24521740e-01f,
  7.62111992e-02f, 1.36794642e-01f, 1.85224742e-01f, 1.63445622e-01f, 9.98013616e-02f, -2.07050722e-02f, 3.89868692e-02f, -1.97474584e-02f, -4.65384759e-02f, -6.33019209e-02f,
  -5.15110418e-02f, 6.17382564e-02f, -1.73679274e-02f, 1.03698649e-01f, -2.17564274e-02f, 1.07323907e-01f, 6.33588657e-02f, 7.51406476e-02f, 3.63709568e-03f, 5.97496629e-02f,
  6.10705814e-04f, 1.39197186e-01f, 9.67308506e-03f, -5.56754414e-03f, 9.72079579e-03f, 3.82032134e-02f, 8.81422758e-02f, 1.36684060e-01f, 3.43580730e-02f, 1.15970820e-01f,
  -1.94784217e-02f, 6.06916398e-02f, 1.57684125e-02f, 5.34935035e-02f, -1.61133390e-02f, 4.80630286e-02f, 1.07974812e-01f, -2.49351673e-02f, -4.00009528e-02f, 3.70682925e-02f,
  2.45168339e-02f, -4.92971465e-02f, -6.70623332e-02f, 3.29616368e-02f, -2.87786927e-02f, 4.90704328e-02f, 2.44919248e-02f, 1.63774733e-02f, 3.10631245e-02f, 5.83179556e-02f,
  2.02512499e-02f, -6.50002360e-02f, -1.21655734e-02f, -2.43133251e-02f, -9.12986845e-02f, 4.70677353e-02f, 3.48110348e-02f, 6.60828725e-02f, -4.45332006e-02f, 2.36926544e-02f,
  -7.30059203e-03f, -4.58462201e-02f, 9.74034891e-02f, 3.16412337e-02f, 6.30732551e-02f, 2.07671281e-02f, -4.47329544e-02f, 6.43870756e-02f, 6.45161569e-02f, -5.08709475e-02f,
  2.22218797e-01f, -4.46378589e-02f, -1.35114938e-02f, 9.33785290e-02f, -7.99045153e-03f, 2.53113080e-02f, 6.87956512e-02f, 2.25370061e-02f, 1.15672410e-01f, 5.47036976e-02f,
  -2.72178669e-02f, 5.78263327e-02f, 1.18049622e-01f, 1.43040922e-02f, -4.55942787e-02f, 7.01623484e-02f, 6.76681474e-02f, 1.72528699e-02f, -3.36472131e-02f, 1.46050051e-01f,
  2.68499069e-02f, 1.57849267e-02f, -1.05752587e-01f, -5.86434156e-02f, 8.15354809e-02f, 3.23335305e-02f, -3.56769376e-02f, 2.44367449e-03f, -7.24525526e-02f, 6.61660433e-02f,
  -2.70824999e-01f, 2.51606405e-01f, 1.47616133e-01f, -2.12326297e-03f, 7.00326413e-02f, 1.70130245e-02f, -3.31520452e-03f, -1.47840768e-01f, -5.65376393e-02f, 1.07523389e-01f,
  5.95069230e-02f, -9.82806161e-02f, -1.40038580e-02f, -1.84110656e-01f, -1.82841718e-01f, 8.96952488e-03f, 9.92765129e-02f, -1.21961340e-01f, -3.87735516e-01f, -2.08034500e-01f,
  -2.71807164e-02f, -3.63449007e-02f, -2.31167361e-01f, -1.02169678e-01f, 1.31171286e-01f, 2.91394372e-03f, 2.46796384e-01f, 1.67723209e-01f, 1.61724344e-01f, 2.33514339e-01f,
  1.56060576e-01f, 2.52222478e-01f, -6.83352500e-02f, 1.71932299e-02f, 9.35540721e-02f, -6.84024990e-02f, 1.61334295e-02f, 4.85328920e-02f, 1.19250687e-02f, 4.22069132e-02f,
  5.04076630e-02f, 1.18183102e-02f, -7.88491312e-03f, -2.36958098e-02f, 6.98061660e-02f, -4.38042209e-02f, 3.34815122e-02f, -1.33153358e-02f, 3.43082137e-02f, 1.52331099e-01f,
  3.34475264e-02f, 8.71132836e-02f, 1.00103848e-01f, 6.86074644e-02f, 1.10192046e-01f, 1.68679506e-02f, 3.01891472e-02f, 1.05703324e-01f, -9.16750636e-03f, 7.41713643e-02f,
  -6.50607273e-02f, -5.52056134e-02f, 1.77491195e-02f, 1.66597329e-02f, -9.46629792e-03f, 1.28537901e-02f, 6.62201494e-02f, -3.54631282e-02f, 3.89998257e-02f, 1.43121695e-02f,
  1.10126339e-01f, -3.70883755e-02f, -7.38346130e-02f, 3.20293605e-02f, -2.18583830e-02f, -3.75206061e-02f, -3.76293547e-02f, -4.07333486e-02f, 1.23283483e-01f, -7.28773624e-02f,
  5.68683073e-02f, 5.06698824e-02f, 6.95097595e-02f, 1.08308205e-02f, 4.67513055e-02f, -3.52313779e-02f, 1.08826093e-01f, -7.91571960e-02f, 3.69592719e-02f, 1.75175704e-02f,
  -5.51066548e-02f, -1.53290063e-01f, 5.50030544e-03f, -5.31758219e-02f, 8.61463845e-02f, -4.12221141e-02f, 8.14693607e-03f, 4.72381450e-02f, -3.84629294e-02f, 2.62898915e-02f,
  -1.41925912e-03f, -1.02456128e-02f, 4.79805954e-02f, 2.65970509e-02f, -2.63241958e-02f, 1.58080440e-02f, 8.91751349e-02f, -5.22165634e-02f, -5.29748388e-02f, 4.31126691e-02f,
  1.81246530e-02f, -1.37586385e-01f, -6.76705539e-02f, -3.16487369e-03f, 6.82463497e-02f, -8.71343762e-02f, 3.76399420e-02f, -7.22744763e-02f, -1.72563225e-01f, -8.16275552e-02f,
  -2.77201474e-01f, 3.50149535e-02f, 4.25823256e-02f, 3.98548581e-02f, 2.23665461e-01f, 1.96357980e-01f, 1.83408245e-01f, 1.00475950e-02f, 8.83013755e-02f, 1.02745041e-01f,
  7.90759400e-02f, -8.70144963e-02f, -1.50342649e-02f, -6.53727576e-02f, -9.58051682e-02f, 1.08444922e-01f, 2.57708691e-02f, -9.60259512e-02f, -1.37173114e-02f, -1.20457308e-02f,
  1.49030924e-01f, 2.68317275e-02f, -1.31537035e-01f, -5.80203906e-02f, 1.70622602e-01f, 7.55009651e-02f, 2.54081469e-02f, 2.60575619e-02f, 5.67209981e-02f, 1.01593651e-01f,
  1.24543309e-01f, -2.32394766e-02f, 1.93551555e-01f, 1.36286721e-01f, 5.20493574e-02f, 8.67518038e-03f, 1.54926330e-01f, -8.03359039e-03f, 1.27571657e-01f, -3.05938795e-02f,
  7.60593265e-02f, 9.36658680e-02f, 1.06335290e-01f, -5.81240142e-03f, 4.66166288e-02f, -3.03295832e-02f, -6.82743341e-02f, -1.37337297e-02f, 4.60321680e-02f, -1.07357176e-02f,
  8.64217281e-02f, -2.18047621e-03f, -1.59339663e-02f, -6.69373386e-03f, 6.83190972e-02f, 8.85244384e-02f, 4.99675497e-02f, 9.48380902e-02f, -6.41998872e-02f, 1.66235138e-02f,
  -7.60420114e-02f, -6.50260448e-02f, -1.05278082e-01f, -2.09747374e-01f, -8.21728855e-02f, -4.41039354e-02f, -9.60146263e-02f, -2.27332003e-02f, -9.47213843e-02f, -1.54106185e-01f,
  -9.34385508e-02f, -1.27930447e-01f, -7.81428590e-02f, -8.78427699e-02f, -1.10490330e-01f, -1.56204477e-01f, -1.60471752e-01f, -6.95509017e-02f, -1.36235386e-01f, -1.76672786e-01f,
  -1.46478444e-01f, -5.51160574e-02f, -4.25803848e-02f, -4.01621908e-02f, -2.85604112e-02f, -1.07963704e-01f, -6.12533651e-02f, -1.56300783e-01f, -1.00147672e-01f, -5.11228628e-02f,
  1.42014444e-01f, -9.94922817e-02f, 7.68524110e-02f, 1.64046466e-01f, 1.84520796e-01f, 1.83965057e-01f, 4.60005403e-02f, 7.29104364e-03f, 2.42799595e-02f, 1.11215353e-01f,
  1.43517792e-01f, -3.72667164e-02f, 5.52298874e-02f, 4.95055281e-02f, 1.93233956e-02f, 4.76439297e-02f, 1.43678889e-01f, 8.24687257e-03f, 8.22689384e-02f, 1.34254590e-01f,
  -4.41406853e-02f, 1.29580259e-01f, 9.50798541e-02f, 9.57857221e-02f, 1.06368214e-01f, 1.64947554e-01f, 1.10306449e-01f, 4.95975427e-02f, 3.17699499e-02f, 2.12359428e-01f,
  -3.19757998e-01f, -1.21123217e-01f, 1.72024313e-02f, 8.28384012e-02f, 1.05527535e-01f, -1.53378183e-02f, -1.87214851e-01f, -2.17624336e-01f, 7.08202422e-02f, -5.19715585e-02f,
  2.31247172e-01f, 2.58199304e-01f, 3.28788698e-01f, 2.78661698e-01f, 3.87653299e-02f, -1.38926998e-01f, 4.24595512e-02f, 4.70483825e-02f, 1.62760764e-02f, -7.67073706e-02f,
  -1.74897499e-02f, -1.16037637e-01f, -5.47027290e-02f, 2.11585611e-02f, 5.39256074e-02f, 1.65074706e-01f, 6.30532727e-02f, 1.10743595e-02f, 1.26667365e-01f, 3.59116867e-02f,
  2.12552488e-01f, -5.38665988e-02f, 1.37364760e-01f, 1.40291780e-01f, -5.93185285e-03f, -4.83313501e-02f, -6.87842742e-02f, 3.44867818e-03f, 3.42567936e-02f, 3.24160531e-02f,
  7.36080706e-02f, -2.93091834e-02f, 5.92694245e-02f, -2.69656535e-02f, -7.64222294e-02f, -4.64263074e-02f, -2.86820456e-02f, -4.05186005e-02f, 6.86531067e-02f, 8.95793736e-02f,
  1.93873152e-01f, 4.69922088e-03f, -8.67468026e-03f, 1.14742041e-01f, 9.44548920e-02f, 1.61381468e-01f, 9.80049185e-03f, 1.30842075e-01f, -2.24670209e-02f, 2.64978614e-02f,
  6.88636526e-02f, -5.35615347e-02f, 3.06522641e-02f, -6.78201839e-02f, 2.71463804e-02f, 5.68573922e-02f, -4.07941900e-02f, 2.78805941e-02f, -5.17315306e-02f, -9.81756449e-02f,
  6.49624085e-03f, 2.44794935e-02f, -9.44792405e-02f, -5.04020564e-02f, 1.70490646e-03f, -7.08434684e-03f, -2.26168316e-02f, -4.90641221e-02f, 6.86108619e-02f, -5.67165948e-02f,
  8.72590467e-02f, -4.71124016e-02f, 2.19883751e-02f, 1.68961827e-02f, -2.66337860e-02f, -3.69942078e-04f, 5.61301522e-02f, -2.81587802e-02f, -3.10614891e-02f, 8.42528138e-03f,
  -9.18234289e-02f, 2.46002153e-01f, 8.93737078e-02f, 1.09083720e-01f, 3.50917578e-02f, 5.08469809e-03f, 6.95762783e-02f, 5.63403107e-02f, 8.34379420e-02f, 5.58062792e-02f,
  1.11011729e-01f, 2.54504159e-02f, 1.05768945e-02f, -8.72427784e-03f, -3.07884645e-02f, 1.06235612e-02f, 3.31191458e-02f, 1.21943764e-01f, 5.12047186e-02f, 1.51968850e-02f,
  -2.38439105e-02f, 7.33548775e-02f, 9.37746614e-02f, 8.87920633e-02f, 3.88299152e-02f, 1.26651257e-01f, 5.18384054e-02f, -4.90096100e-02f, -1.41674941e-02f, -8.18157569e-02f,
  3.50740254e-01f, 1.72874555e-01f, 1.87049687e-01f, 1.59173757e-01f, 1.53170288e-01f, 1.01990364e-01f, 2.72811890e-01f, 6.56203702e-02f, -1.02093078e-01f, 1.74504772e-01f,
  -5.19849584e-02f, -2.39744961e-01f, -9.24466774e-02f, -2.17095673e-01f, -1.39143597e-02f, 2.83580691e-01f, 1.58249617e-01f, -3.09682768e-02f, -8.42980146e-02f, -1.16366498e-01f,
  -6.38928190e-02f, 4.34479900e-02f, -3.36599760e-02f, -2.27920841e-02f, 1.29378542e-01f, -8.51669312e-02f, 2.57134791e-02f, 9.59068090e-02f, 2.21392009e-02f, 1.79570839e-01f,
  2.08142951e-01f, 2.12867185e-02f, -1.01179101e-01f, -1.44348562e-01f, 6.58800527e-02f, 2.77683977e-02f, -5.93781359e-02f, -6.94798455e-02f, -4.44709845e-02f, 8.36166367e-02f,
  -6.57009408e-02f, 1.05984404e-03f, -4.52018864e-02f, -1.08224317e-01f, -7.02450471e-03f, 3.99235114e-02f, -6.68772534e-02f, -1.21317944e-02f, 2.97001880e-02f, -5.70282675e-02f,
  -8.85414891e-03f, -8.78737643e-02f, 5.66517450e-02f, -9.94654670e-02f, -6.04622811e-02f, -3.16412151e-02f, -1.93545278e-02f, -7.89109543e-02f, -1.02771707e-01f, -4.01998349e-02f,
  2.20468212e-02f, 3.06377746e-02f, 9.83055681e-02f, 3.92374489e-03f, -1.03877503e-02f, -1.33003108e-03f, 5.81581630e-02f, 7.84941297e-03f, 3.12343966e-02f, 1.37426890e-02f,
  -4.99875359e-02f, 7.33331740e-02f, -7.20596388e-02f, -2.47755926e-02f, 7.80458227e-02f, -5.52070029e-02f, 5.18903024e-02f, -8.34490657e-02f, -1.34995393e-02f, 1.80786904e-02f,
  2.76802219e-02f, -8.10356112e-04f, -8.48517641e-02f, 1.71166323e-02f, 5.48197562e-03f, 4.16924842e-02f, -7.13961422e-02f, -5.30058555e-02f, -1.10412929e-02f, -6.70752004e-02f,
  6.47838563e-02f, -1.61343679e-01f, 1.31421715e-01f, -3.35461982e-02f, 8.75023305e-02f, -1.86770726e-02f, 1.12408744e-02f, 4.64131758e-02f, 4.22453918e-02f, -5.18553145e-02f,
  4.26019430e-02f, -3.30841877e-02f, -2.34436393e-02f, -9.26354900e-02f, 4.41913307e-02f, -1.20749161e-01f, -5.28703742e-02f, 1.04269609e-02f, -5.20537421e-02f, 3.10598616e-03f,
  -1.27876829e-02f, 3.03992839e-03f, -8.72220565e-03f, -6.86477274e-02f, -1.23235255e-01f, 4.61409651e-02f, 6.79120272e-02f, -2.95728743e-02f, -6.11998439e-02f, 9.77186188e-02f,
  8.95153731e-03f, -2.45403185e-01f, 3.67587954e-02f, 8.15447420e-02f, -2.59398043e-01f, -2.75151044e-01f, -3.55528295e-01f, -3.11927378e-01f, -3.73825692e-02f, -4.92203832e-02f,
  -9.96016636e-02f, -8.62678289e-02f, 1.29091680e-01f, 5.59199266e-02f, -5.09035587e-03f, -8.33054185e-02f, -8.64047185e-03f, 1.49135455e-01f, 3.47689204e-02f, -1.26800746e-01f,
  -1.84604786e-02f, 4.34263162e-02f, 3.93168628e-02f, 8.90982822e-02f, 3.08921300e-02f, 9.82418358e-02f, 6.80689840e-03f, 1.05254713e-03f, -1.21597603e-01f, 1.28467545e-01f,
  1.34249985e-01f, -9.04409513e-02f, -1.03142299e-01f, -8.79532769e-02f, -6.32634610e-02f, -7.40535781e-02f, -3.08421198e-02f, -7.80436397e-02f, -7.99148530e-02f, -5.86721413e-02f,
  -1.62938032e-02f, -1.03197046e-01f, -9.30543989e-02f, -4.83609177e-02f, -1.16568923e-01f, -2.97010913e-02f, -7.02065527e-02f, -6.34709746e-02f, 2.76613012e-02f, -1.29041433e-01f,
  -1.12918749e-01f, -6.47047386e-02f, -1.40788123e-01f, -1.40358120e-01f, -1.63100138e-01f, -3.33301984e-02f, -1.50201231e-01f, -1.38655558e-01f, -7.52449930e-02f, -1.11449011e-01f,
  -4.76716496e-02f, -7.87446799e-04f, 2.82390658e-02f, -7.65629392e-03f, 5.86006604e-02f, -5.64716244e-03f, 6.17266782e-02f, -1.79131441e-02f, 6.36414662e-02f, 6.31447509e-02f,
  -3.62840518e-02f, 1.63391847e-02f, 9.63140726e-02f, 2.51968950e-02f, 8.77050161e-02f, 2.25987379e-03f, 3.10727041e-02f, 4.21287827e-02f, 8.32817629e-02f, 1.88048109e-02f,
  2.47816741e-02f, -1.23773925e-02f, 5.70640787e-02f, 8.48285854e-02f, -2.19173282e-02f, 5.57601862e-02f, 9.48586315e-02f, -3.64809521e-02f, 1.81774050e-02f, 6.20761625e-02f,
  1.36263192e-01f, -1.96300939e-01f, 1.67099759e-01f, -4.52654473e-02f, 5.74063603e-03f, 2.29489524e-03f, -2.39528231e-02f, -5.12995124e-02f, -5.06433472e-02f, 4.72049192e-02f,
  -6.04668558e-02f, 3.52433859e-03f, -9.15383473e-02f, 2.84789992e-03f, -4.65169512e-02f, -1.09606311e-01f, -9.55227390e-02f, 3.16868909e-02f, 2.39471868e-02f, -3.56644392e-02f,
  2.24000774e-02f, -1.58518016e-01f, 6.41677389e-03f, -8.13416317e-02f, -1.64838254e-01f, -1.00878030e-01f, 2.35442892e-02f, 2.55915243e-02f, -1.27863139e-01f, -2.52626427e-02f,
  4.13166016e-01f, -1.24788426e-01f, -1.05725579e-01f, 2.19869629e-01f, -6.86054304e-02f, -7.48928189e-02f, -2.17314348e-01f, 1.60678834e-01f, 8.83230343e-02f, -6.72901794e-02f,
  -1.04124337e-01f, 1.50145024e-01f, 1.82548866e-01f, 3.54659110e-02f, 2.38058232e-02f, -1.35372937e-01f, -1.58531889e-01f, 5.35182767e-02f, 9.33982953e-02f, -2.39977390e-02f,
  -1.08924031e-01f, 1.32497177e-02f, 1.92836210e-01f, 7.47166853e-03f, 1.22682033e-02f, 7.38489479e-02f, -8.91631097e-02f, -8.70272145e-02f, -1.60596400e-01f, -5.88068217e-02f,
  4.60157208e-02f, -4.33149189e-02f, 1.33471265e-01f, 4.63073738e-02f, 4.37208228e-02f, 4.92224321e-02f, 9.15382057e-03f, -7.02130646e-02f, 5.34720384e-02f, 6.00017756e-02f,
  -4.85980399e-02f, -2.75948215e-02f, 1.09701850e-01f, -3.41840112e-03f, -4.55445386e-02f, 6.26756698e-02f, -1.05846943e-02f, 1.26228398e-02f, 9.14036483e-02f, -1.23660028e-01f,
  -3.93422469e-02f, -1.23077266e-01f, 1.93996809e-03f, 1.07326265e-03f, 8.25043246e-02f, 5.14245518e-02f, -1.98510122e-02f, 4.76020277e-02f, 1.28814816e-01f, 5.39497286e-02f,
  2.41672937e-02f, -4.95733619e-02f, 1.79628655e-02f, -8.38591978e-02f, 3.49753839e-03f, -6.75735483e-03f, -7.06123114e-02f, 1.98953766e-02f, -9.35046747e-02f, -1.12338193e-01f,
  2.44271830e-02f, 1.40986424e-02f, -4.96372255e-03f, 6.78883516e-04f, 1.11482330e-02f, -1.49839865e-02f, -1.45514514e-02f, -5.17654791e-02f, -2.98939086e-02f, -4.99791130e-02f,
  2.93076988e-02f, -2.42808051e-02f, 2.14693509e-02f, -9.33822319e-02f, -1.05499737e-01f, 3.36319543e-02f, -9.31077674e-02f, 2.48908438e-02f, 4.85084690e-02f, -2.84089111e-02f,
  1.78175554e-01f, 1.25018917e-02f, 1.24637268e-01f, 9.67925135e-03f, 2.44877823e-02f, 1.37794241e-01f, 9.34673473e-02f, 4.27102111e-02f, 1.14951162e-02f, -1.55148106e-02f,
  3.67492475e-02f, 8.35495666e-02f, 1.99797209e-02f, 6.77201450e-02f, -9.27684922e-03f, 2.66417246e-02f, 8.02943334e-02f, 9.86759216e-02f, 6.48007616e-02f, 2.51833238e-02f,
  7.03302398e-02f, 1.29645437e-01f, 1.08326331e-01f, 1.42136127e-01f, 5.40762618e-02f, 2.20293179e-01f, -8.84022471e-03f, 1.07109025e-01f, 1.51553810e-01f, 1.53090626e-01f,
  -4.02406976e-02f, 3.68582644e-02f, 1.44392058e-01f, -1.26946969e-02f, -1.63971558e-01f, -2.09416717e-01f, -1.91318974e-01f, -1.58056080e-01f, -8.53836983e-02f, -1.41481355e-01f,
  7.10658133e-02f, 7.08682239e-02f, 1.51501283e-01f, 2.03712299e-01f, 1.44569501e-01f, -9.51922536e-02f, 4.91006002e-02f, 1.59386814e-01f, 8.48515555e-02f, -6.33974448e-02f,
  -2.73888148e-02f, 3.14437039e-02f, 2.24539470e-02f, 1.34417275e-02f, -6.94835745e-03f, -1.58288889e-02f, -1.53952017e-01f, -7.44536743e-02f, -1.23015396e-01f, 1.35823891e-01f,
  2.14761749e-01f, 4.84228171e-02f, 6.39719516e-02f, 4.52795662e-02f, -4.84544056e-04f, 7.72297457e-02f, -2.57745944e-02f, 1.44439429e-01f, -5.17716222e-02f, 8.09850097e-02f,
  -6.43995265e-03f, 4.49426658e-02f, 5.67221418e-02f, 3.30483206e-02f, 1.49147864e-02f, -6.67912215e-02f, -1.03302514e-02f, 9.01530683e-02f, 9.00190994e-02f, 3.76138687e-02f,
  2.85379048e-02f, -5.61646484e-02f, -1.44203193e-02f, -5.15427515e-02f, 4.05794382e-02f, 9.73611549e-02f, 1.49704264e-02f, 7.35781789e-02f, 8.70179664e-03f, -7.11234584e-02f,
  -1.11926988e-01f, 3.79127301e-02f, -1.99284758e-02f, -7.49381678e-03f, -2.33587585e-02f, -4.56925891e-02f, 3.17442603e-02f, 1.05750551e-02f, 2.42520813e-02f, -4.97262701e-02f,
  -2.77416948e-02f, 1.56952552e-02f, -3.16975899e-02f, -7.38533735e-02f, -1.42973037e-02f, 5.19021973e-02f, 3.64416018e-02f, 3.47244926e-02f, -1.98046491e-02f, -4.34667990e-02f,
  7.05677196e-02f, -9.64036025e-03f, -5.56953214e-02f, 1.03532441e-01f, -7.23438486e-02f, 8.80285650e-02f, 2.21344028e-02f, 1.80724990e-02f, 6.35262877e-02f, -1.52966045e-02f,
  -1.96430981e-01f, 5.24854809e-02f, 3.79787534e-02f, 1.45251900e-01f, -5.70425615e-02f, -1.98351350e-02f, -3.92378680e-02f, 1.84592698e-02f, 2.55833194e-02f, 9.74701345e-03f,
  6.01924248e-02f, 5.63908666e-02f, 7.63003007e-02f, -5.31400070e-02f, -5.32640666e-02f, -2.30480311e-03f, -1.40626245e-04f, -4.78063412e-02f, 1.15320832e-01f, 4.70753796e-02f,
  -2.02781968e-02f, -1.24781840e-01f, -1.36039808e-01f, -1.36596873e-01f, -1.20061412e-01f, -5.15781865e-02f, -9.63455737e-02f, -1.47939384e-01f, -1.53873712e-01f, -2.60081142e-01f,
  3.33802342e-01f, -2.24293377e-02f, -1.75500184e-01f, 1.34447888e-01f, -2.31383350e-02f, 9.50167999e-02f, 2.67538399e-01f, 1.36027902e-01f, 1.53310806e-01f, 1.03266269e-01f,
  8.05786625e-02f, 1.76168662e-02f, 6.32515624e-02f, -6.71290457e-02f, 1.50955632e-01f, -6.82023540e-02f, -1.66906103e-01f, -4.12016138e-02f, 1.10969864e-01f, 1.47058174e-01f,
  2.21886747e-02f, 4.28073145e-02f, -3.16701233e-02f, -2.82746088e-02f, -1.27269909e-01f, 2.95278393e-02f, -2.15522483e-01f, -4.54250053e-02f, -1.91897869e-01f, -3.46286833e-01f,
  -1.57748938e-01f, 8.71516857e-03f, 1.34400934e-01f, 4.73853387e-03f, -2.99260356e-02f, -2.64375061e-02f, 5.62972426e-02f, -2.60290243e-02f, 2.49919202e-03f, 9.76941064e-02f,
  3.03074736e-02f, 1.29421830e-01f, 5.95259778e-02f, -5.37847690e-02f, 5.63204661e-02f, 1.53563946e-01f, 3.17142494e-02f, -1.10734096e-02f, -1.01790000e-02f, -1.68545339e-02f,
  4.45657112e-02f, 1.01518065e-01f, 6.64034337e-02f, 7.73521662e-02f, 3.82493585e-02f, 9.05372128e-02f, 3.75502408e-02f, -2.83637047e-02f, 9.45647433e-02f, -4.73601967e-02f,
  5.10299727e-02f, -6.43916279e-02f, -4.00477014e-02f, 5.12491018e-02f, 3.88753153e-02f, -8.47453326e-02f, -2.11984795e-02f, -1.23528481e-01f, -8.94061523e-04f, 1.97149832e-02f,
  1.13646640e-02f, -5.20016402e-02f, -5.18454053e-02f, -3.40829194e-02f, -9.43346918e-02f, -8.73513147e-02f, -3.26713622e-02f, -6.41342998e-02f, -3.06948703e-02f, -7.42797181e-02f,
  -1.21854626e-01f, -6.32659718e-02f, -1.89692974e-01f, -4.53177132e-02f, -1.62649512e-01f, -9.40415859e-02f, 2.10192408e-02f, -2.00298745e-02f, 8.97189230e-03f, -6.40379190e-02f,
  2.68951923e-01f, 1.18094422e-01f, 1.35187760e-01f, 5.23763895e-02f, -8.75684340e-03f, 4.58133556e-02f, 5.52255996e-02f, -1.82613544e-02f, 1.26132831e-01f, 1.84073836e-01f,
  1.25732929e-01f, 3.55732925e-02f, 2.13295296e-02f, 9.48564112e-02f, 1.39666826e-01f, 1.43382594e-01f, 3.54075097e-02f, 5.45067489e-02f, 1.04255766e-01f, 3.58899012e-02f,
  2.12583374e-02f, 1.43256068e-01f, 1.03366479e-01f, 1.56375483e-01f, 1.25216067e-01f, 1.10964902e-01f, 1.18182994e-01f, 1.20247237e-01f, 1.14510953e-01f, 3.05115014e-01f,
  1.96399853e-01f, -7.41419271e-02f, 3.38292122e-01f, 1.51857391e-01f, 9.06150714e-02f, 9.45020542e-02f, 2.27727257e-02f, 7.28928819e-02f, -3.32938656e-02f, -8.17737579e-02f,
  -6.86552376e-02f, -6.99268514e-03f, 1.15427831e-02f, 3.56026739e-02f, 1.25236750e-01f, -8.12449232e-02f, -6.73040226e-02f, 2.59009242e-01f, 1.15116343e-01f, -7.28425384e-02f,
  -1.40245244e-01f, -4.65810895e-02f, 1.85491920e-01f, 4.24769484e-02f, -2.33803783e-03f, 5.68205230e-02f, 9.70906243e-02f, -9.39320959e-03f, 1.96091644e-02f, -1.67868391e-01f,
  4.28770855e-02f, 1.74342483e-01f, 1.01733580e-02f, -5.72087709e-03f, 1.52461175e-02f, 6.41454309e-02f, 3.93802784e-02f, 9.23422426e-02f, 1.24558009e-01f, 7.27046235e-03f,
  -5.57043962e-03f, 2.82447785e-02f, -2.28603166e-02f, -1.33764982e-01f, 4.64617908e-02f, -4.17720117e-02f, -6.74951598e-02f, 1.25843421e-01f, 1.05878234e-01f, 4.21551503e-02f,
  -2.77833007e-02f, 9.82626751e-02f, 2.25404888e-01f, 7.53758252e-02f, 1.28493905e-01f, 1.63106382e-01f, 6.18352480e-02f, 3.01081389e-02f, 2.08736196e-01f, -8.92192274e-02f,
  -7.29573816e-02f, 2.58142389e-02f, 3.33813652e-02f, -8.90069827e-02f, -7.41833076e-02f, -8.67232755e-02f, -5.76664098e-02f, -8.33121911e-02f, -1.61802899e-02f, -1.51760527e-03f,
  7.52294250e-03f, -7.40871727e-02f, -1.66910980e-02f, -4.29257751e-03f, -5.31045720e-02f, 4.49382626e-02f, 6.06886223e-02f, -9.30752158e-02f, -4.58210707e-02f, 2.66065672e-02f,
  1.11700008e-02f, -5.10099009e-02f, -2.10898444e-02f, -1.96908358e-02f, 2.78390236e-02f, 9.02135577e-03f, 1.24655869e-02f, 1.96703132e-02f, 3.46994144e-03f, 6.19709976e-02f,
  -9.83163640e-02f, 1.48832202e-01f, -2.08791718e-02f, 8.07365030e-03f, 1.00697219e-01f, -8.06850474e-03f, 6.65942952e-02f, -2.61077676e-02f, 8.01839754e-02f, 2.49240249e-02f,
  3.05734761e-02f, 1.01566747e-01f, -3.07993814e-02f, -9.90737528e-02f, 8.37981999e-02f, -2.98480038e-02f, -1.24693718e-02f, 2.34633014e-02f, 1.05687343e-01f, 9.85710397e-02f,
  -4.57989536e-02f, 1.02627419e-01f, 1.08490795e-01f, 1.13950990e-01f, 4.38911691e-02f, 1.71615392e-01f, 6.01298809e-02f, 1.00546695e-01f, 1.88663721e-01f, -7.76988193e-02f,
  3.21987607e-02f, 3.53520513e-02f, -2.19751541e-02f, 1.13310993e-01f, 2.59251177e-01f, 3.82203996e-01f, 4.36681598e-01f, 2.09782481e-01f, 4.23265100e-02f, 1.21607311e-01f,
  2.46672109e-01f, -4.54358123e-02f, -1.51886167e-02f, 6.97260424e-02f, 4.67534028e-02f, 6.06823973e-02f, 9.03812125e-02f, 2.36834958e-02f, 3.94059643e-02f, 2.39425734e-01f,
  1.48860380e-01f, 4.71075773e-02f, -1.39461711e-01f, 5.20179980e-02f, -1.01125591e-01f, -6.96197748e-02f, -6.29677474e-02f, 1.63745537e-01f, 2.01100335e-01f, -1.09753534e-02f,
  -9.50324908e-02f, 8.50817934e-02f, 4.91942316e-02f, 8.42616260e-02f, 6.09479211e-02f, -5.07651307e-02f, -1.59030169e-04f, -1.12564377e-01f, 9.56854969e-02f, -1.61616632e-03f,
  1.48363709e-01f, 1.30883202e-01f, 3.29236104e-03f, -2.18380056e-02f, 7.17313811e-02f, 1.10790156e-01f, -3.81036126e-03f, -4.89383303e-02f, -1.06712719e-02f, 1.31819472e-01f,
  1.03305615e-02f, 1.20991759e-01f, 1.68536395e-01f, 1.31041273e-01f, 1.26267001e-01f, 1.04665712e-01f, 1.14096411e-01f, 8.64297524e-03f, -9.15705506e-03f, -1.59851313e-01f,
  -1.16123203e-02f, -7.13244900e-02f, -4.51318286e-02f, -1.82825942e-02f, 3.94939221e-02f, 9.24668647e-03f, -2.58769579e-02f, 8.97074118e-02f, -6.48827553e-02f, -4.47454490e-02f,
  -7.14569837e-02f, -9.88011584e-02f, -2.81578284e-02f, -1.05561107e-01f, -1.75005212e-01f, -3.79250124e-02f, -4.64412794e-02f, -1.37679026e-01f, -4.63326126e-02f, -6.30902499e-02f,
  6.03557471e-03f, -4.24788333e-02f, -6.52263984e-02f, -1.41228482e-01f, -1.15979895e-01f, -6.37648851e-02f, -4.09012288e-02f, -1.00050122e-02f, -1.46422237e-01f, -1.30471559e-02f,
  -1.48472205e-01f, 2.03432381e-01f, -1.24386027e-02f, 6.65878281e-02f, 5.83811998e-02f, -4.00093906e-02f, 1.24478281e-01f, 1.36477455e-01f, 1.49820223e-01f, 8.57853442e-02f,
  1.17142811e-01f, 9.03934911e-02f, 1.07023187e-01f, 4.53758128e-02f, 4.65471298e-02f, 4.15532403e-02f, 8.67968947e-02f, 8.42286274e-02f, 1.60420135e-01f, 2.82452479e-02f,
  1.14588737e-01f, 1.74042672e-01f, 4.82119061e-02f, 9.86371636e-02f, 9.62510109e-02f, 2.27594897e-01f, 2.17989851e-02f, 1.08727649e-01f, 1.06325559e-01f, 6.43796474e-02f,
  -1.64996937e-01f, 2.07442455e-02f, -1.51867002e-01f, 6.22009113e-02f, 1.15827404e-01f, 2.88154855e-02f, 3.86456698e-02f, -9.99803618e-02f, -8.07803273e-02f, -8.26322362e-02f,
  -1.24361441e-02f, 3.97378393e-02f, -8.15068334e-02f, -2.55418904e-02f, -5.25617599e-02f, -4.44888398e-02f, 9.64701874e-04f, 1.04099317e-02f, -4.63684322e-03f, 1.58795193e-01f,
  9.91299823e-02f, 1.70166582e-01f, 2.41619907e-02f, 2.36331038e-02f, 1.72380596e-01f, 5.68044744e-02f, 3.90082262e-02f, 5.97580113e-02f, 1.14169404e-01f, 2.39975333e-01f,
  -8.82061720e-02f, -5.62297292e-02f, -1.37256205e-01f, -6.86423555e-02f, -8.28642398e-02f, -9.94112790e-02f, -9.61818453e-03f, -3.35861705e-02f, -3.32776159e-02f, -7.58899972e-02f,
  5.93726616e-03f, 6.57117506e-03f, -4.60225418e-02f, 7.71235079e-02f, -8.82219300e-02f, 2.54263054e-03f, -7.62385353e-02f, 1.28932334e-02f, -1.07877634e-01f, -8.29346329e-02f,
  1.78897846e-02f, -5.17289760e-03f, -1.42224997e-01f, -1.66080054e-02f, -6.09116852e-02f, 4.43455689e-02f, -9.26928669e-02f, -8.74232054e-02f, -5.68114184e-02f, -1.01697549e-01f,
  6.72679096e-02f, -2.78499369e-02f, -2.01545842e-02f, -6.50691194e-03f, 9.09285694e-02f, -3.62767801e-02f, 4.24316749e-02f, 2.63003632e-02f, -4.63308999e-03f, 7.65180681e-03f,
  -3.98890935e-02f, -4.61933464e-02f, 5.57962731e-02f, -6.03597127e-02f, -2.88356077e-02f, -8.18646029e-02f, 6.32923767e-02f, -1.55110797e-02f, -1.13585375e-01f, 3.90303358e-02f,
  -2.02347934e-02f, -4.83272374e-02f, -1.46178856e-01f, 2.93600913e-02f, -6.53774217e-02f, 4.63510901e-02f, -2.04726439e-02f, 1.31208450e-02f, -7.68010318e-02f, -4.52101193e-02f,
  -1.15463667e-01f, -1.70963034e-01f, 3.75622534e-03f, -7.77803501e-03f, -4.70831767e-02f, -4.76225205e-02f, 5.83762825e-02f, -8.98014158e-02f, -4.65176962e-02f, -8.56965184e-02f,
  -2.86158137e-02f, 9.93377995e-03f, -1.32759213e-01f, 5.38392179e-03f, -3.82938534e-02f, -3.64175579e-03f, -1.79961268e-02f, -2.62550507e-02f, 9.26232059e-03f, -4.64272760e-02f,
  -1.14618681e-01f, -1.69613302e-01f, -1.87142849e-01f, -1.24125697e-01f, -1.19861819e-01f, -2.02151582e-01f, -1.38806716e-01f, -1.45100102e-01f, -1.27537191e-01f, -1.86284557e-01f,
  1.70737073e-01f, 1.81351811e-01f, -6.80434778e-02f, 1.41935304e-01f, 1.06115840e-01f, 9.87190083e-02f, -1.13538072e-01f, 1.33188412e-01f, 1.52642757e-01f, 7.09336177e-02f,
  2.51616687e-01f, 2.82087445e-01f, 1.64175585e-01f, 1.88716441e-01f, -2.52880272e-03f, -1.31655619e-01f, -1.31893486e-01f, 2.23129187e-02f, 9.15473029e-02f, 2.08585605e-01f,
  1.90198004e-01f, 1.23403504e-01f, 1.70344412e-01f, 2.44349480e-01f, 1.34863049e-01f, 7.84253627e-02f, 1.98072508e-01f, 2.18989134e-01f, 1.28678948e-01f, 1.02245606e-01f,
  1.11548491e-01f, 1.67631462e-01f, 1.79714531e-01f, 2.74586439e-01f, 1.79793626e-01f, 1.29964441e-01f, 2.18241051e-01f, 2.61305988e-01f, 2.66544074e-01f, 1.09356768e-01f,
  1.98105291e-01f, 2.59803116e-01f, 1.04369618e-01f, 2.37070650e-01f, 2.48542890e-01f, 2.03336954e-01f, 2.28862509e-01f, 2.15040013e-01f, 1.47756875e-01f, 2.09729373e-01f,
  2.68199831e-01f, 1.91169456e-01f, 1.00706212e-01f, 1.16360262e-01f, 1.90373093e-01f, 1.59235075e-01f, 3.09492826e-01f, 2.05686674e-01f, 2.01368585e-01f, 1.32077366e-01f,
  -7.37148598e-02f, -1.02412812e-01f, -7.04742149e-02f, -1.61990061e-01f, -1.17654167e-01f, -1.15301095e-01f, -1.42846793e-01f, -1.51427299e-01f, -5.64226732e-02f, -1.94102749e-01f,
  -1.66629061e-01f, -2.54667968e-01f, -1.55507490e-01f, -1.42934442e-01f, -8.01145509e-02f, -1.69654965e-01f, -2.14579746e-01f, -2.03746930e-01f, -7.88228363e-02f, -1.38558730e-01f,
  -2.42051363e-01f, -1.51253700e-01f, -1.58527493e-01f, -1.82567522e-01f, -1.78913772e-01f, -1.68727458e-01f, -1.95724100e-01f, -1.30210087e-01f, -1.39349982e-01f, -2.17058823e-01f,
  2.15012342e-01f, 1.82976350e-01f, 1.23498058e-02f, 3.98851037e-02f, 1.69354931e-01f, 1.37130499e-01f, 1.80671260e-01f, 1.74973369e-01f, 1.01136602e-01f, 1.51530147e-01f,
  2.49155343e-01f, 1.78917661e-01f, 1.64648518e-01f, 1.18362479e-01f, 7.01347664e-02f, 2.44004369e-01f, 1.13745727e-01f, 1.63481489e-01f, 1.92682356e-01f, 1.47691607e-01f,
  1.03729211e-01f, 1.71998844e-01f, 6.98478967e-02f, 4.97565344e-02f, 2.14213148e-01f, 6.25999793e-02f, 5.34746386e-02f, 1.38409734e-01f, 1.41786426e-01f, 6.11262955e-02f,
  1.65164754e-01f, 1.61776453e-01f, 2.77024031e-01f, 1.37574181e-01f, 2.05244124e-01f, 2.21470788e-01f, 4.46067750e-01f, 2.18365476e-01f, 1.10286094e-01f, 2.27120176e-01f,
  9.33958441e-02f, -4.27793227e-02f, -4.39497679e-02f, -4.65826243e-02f, 1.60352349e-01f, 2.92194426e-01f, 8.75377581e-02f, 8.74209478e-02f, 1.16008818e-01f, 2.96978243e-02f,
  7.12897703e-02f, 1.21770069e-01f, 1.68791804e-02f, 1.37851527e-02f, 5.57816662e-02f, 5.55989109e-02f, 9.40175578e-02f, 1.28392711e-01f, -4.80454229e-02f, -3.23113501e-02f,
  -7.36595839e-02f, 1.02152504e-01f, -7.70071074e-02f, 3.83858606e-02f, -8.29221457e-02f, -7.81632140e-02f, 2.28450261e-02f, 4.83827591e-02f, -4.84345779e-02f, -3.52642052e-02f,
  3.12367715e-02f, -3.99999768e-02f, -2.54216846e-02f, 9.37495828e-02f, 3.42195258e-02f, 1.36954993e-01f, 4.08887006e-02f, 1.50152430e-01f, 3.93944643e-02f, -1.16951056e-02f,
  4.73981984e-02f, 3.79159525e-02f, 1.90914556e-01f, 7.53926188e-02f, 1.49889886e-01f, 7.96415508e-02f, 1.30121574e-01f, 1.14636561e-02f, 8.40210244e-02f, 1.15373470e-01f,
  -1.35909617e-01f, -2.02798862e-02f, -1.24983534e-01f, -4.80409898e-02f, -6.28721341e-02f, -1.01120092e-01f, -3.21697704e-02f, -4.58974801e-02f, -1.40574307e-03f, -7.13038316e-04f,
  -3.38607933e-03f, 2.15287437e-03f, -1.27428964e-01f, 5.21709584e-03f, -1.70227557e-01f, -1.65750142e-02f, 1.76356342e-02f, -5.67780808e-02f, -1.51350230e-01f, -6.55965358e-02f,
  -7.23153800e-02f, -1.34242838e-02f, -2.80620493e-02f, -6.62370548e-02f, -1.59713119e-01f, -6.05494343e-02f, -1.28125533e-01f, -1.16268277e-01f, -3.61613147e-02f, -1.22866094e-01f,
  2.25828528e-01f, 6.49382621e-02f, -6.82541505e-02f, 3.20429839e-02f, -3.88781144e-03f, 4.96180654e-02f, -1.02830276e-01f, -1.00003779e-01f, 3.25934887e-02f, 1.85659546e-02f,
  1.83469728e-02f, 1.14183925e-01f, 1.33192673e-01f, 6.27434626e-02f, 1.84763260e-02f, 1.39488298e-02f, 8.74368474e-02f, 5.13675623e-02f, 1.16535649e-01f, 9.63467062e-02f,
  1.13796949e-01f, 1.24914564e-01f, 1.11941330e-01f, 1.81567222e-01f, 9.89350453e-02f, -2.58173142e-02f, 1.13708623e-01f, 1.60550475e-02f, 1.15557656e-01f, 1.91303417e-01f,
  -2.90136963e-01f, 2.26144105e-01f, 1.18195891e-01f, -1.37029383e-02f, 2.36472502e-01f, 7.83315524e-02f, 2.82479256e-01f, -9.51441191e-03f, -1.52579099e-01f, 9.83327925e-02f,
  6.67609721e-02f, -1.28073528e-01f, -1.29161850e-01f, -2.27092206e-02f, -2.54899375e-02f, 1.27121195e-01f, 2.48166159e-01f, 1.34629067e-02f, -1.58796415e-01f, -2.83372495e-02f,
  2.23434456e-02f, -1.55536905e-01f, -2.19045728e-01f, -1.60863370e-01f, 1.45629734e-01f, -1.04957528e-01f, 1.43546999e-01f, 7.23105371e-02f, 1.29346088e-01f, 2.43948832e-01f,
  8.22637882e-03f, 5.96340522e-02f, -1.53056696e-01f, -4.17399928e-02f, -3.28558721e-02f, -1.25690117e-01f, -1.61682263e-01f, -1.20010987e-01f, -1.19138390e-01f, -5.91381229e-02f,
  -1.51723363e-02f, -1.16313081e-02f, -2.71259025e-02f, -2.60665286e-02f, 1.54807828e-02f, -2.17616837e-02f, -1.02046750e-01f, -1.14613816e-01f, 5.98544367e-02f, 4.82114702e-02f,
  2.96678636e-02f, 6.87219873e-02f, -7.43511273e-03f, 4.30177748e-02f, -7.70738795e-02f, -1.17229238e-01f, -8.69971812e-02f, -1.37050048e-01f, 1.09772142e-02f, -7.56799728e-02f,
  4.48156707e-02f, 4.33002971e-02f, 8.16553608e-02f, 2.70024724e-02f, 3.04386504e-02f, -3.35448384e-02f, 1.90538093e-02f, 3.98977548e-02f, -9.17340536e-03f, 6.73611760e-02f,
  1.55407432e-02f, 9.44201648e-02f, -1.38252536e-02f, 1.04894368e-02f, 7.54542649e-02f, 6.95790201e-02f, 1.06314920e-01f, 1.48356512e-01f, 8.50722343e-02f, 1.31107345e-01f,
  2.10258234e-02f, 9.73185226e-02f, 1.47930707e-03f, 5.32793999e-02f, 1.14041127e-01f, 1.25206128e-01f, 1.21317878e-01f, 5.12951128e-02f, 7.23512396e-02f, 5.53415045e-02f,
  -1.96238115e-01f, 5.37604056e-02f, -1.34778004e-02f, -1.99940335e-02f, -4.16045971e-02f, -4.42334041e-02f, -3.85023169e-02f, -1.05411850e-01f, -1.59370191e-02f, -8.46630260e-02f,
  3.71706183e-03f, -1.80691898e-01f, -1.14014558e-01f, -7.91417062e-03f, -7.68804774e-02f, -1.11642301e-01f, -3.73882949e-02f, -1.09327354e-01f, -6.19327500e-02f, -3.50559801e-02f,
  2.04703938e-02f, -7.47751445e-02f, -1.02738500e-01f, -1.68237209e-01f, -1.11106941e-02f, -1.26819938e-01f, -9.84845087e-02f, -1.59428477e-01f, -9.57822129e-02f, -2.46662974e-01f,
  -1.51302248e-01f, -7.43631879e-03f, -1.35131508e-01f, 1.34703174e-01f, 1.18480809e-01f, 5.68918511e-02f, 1.45631909e-01f, 1.59034714e-01f, 1.39605597e-01f, 1.40794665e-01f,
  2.43728817e-01f, 1.72763973e-01f, 2.38448516e-01f, 2.40380928e-01f, 1.21134102e-01f, -3.95706221e-02f, 5.31196035e-02f, -1.16266325e-01f, -4.13296856e-02f, 1.23006940e-01f,
  1.75701335e-01f, 6.82001412e-02f, -1.14367008e-01f, 5.73366731e-02f, -9.62427109e-02f, 8.06771517e-02f, -1.24178842e-01f, -1.78543285e-01f, -4.82209474e-02f, -2.09228307e-01f,
  7.11926143e-04f, -7.27418363e-02f, 2.95080710e-02f, 1.98717698e-01f, 7.66212419e-02f, 5.58099821e-02f, 4.37351950e-02f, -2.92278044e-02f, 8.89938623e-02f, 5.03622973e-03f,
  1.57519251e-01f, 5.81012480e-02f, 1.39691070e-01f, 1.18566945e-01f, 1.11133777e-01f, -4.16973897e-04f, -2.13817731e-02f, -1.86285991e-02f, -5.25656641e-02f, 1.28818288e-01f,
  2.54733413e-01f, -8.78788531e-03f, -5.30659370e-02f, 5.95720410e-02f, -5.01221456e-02f, -6.79834222e-04f, -5.61297424e-02f, -5.25770485e-02f, -6.58474192e-02f, -1.27514184e-01f,
  6.72772946e-03f, -7.83153549e-02f, -1.24326423e-01f, -6.00024872e-02f, 1.32498413e-03f, -4.21516448e-02f, -4.67669629e-02f, -1.66768278e-03f, -2.87838690e-02f, -8.26592296e-02f,
  -2.10624691e-02f, 3.37792933e-02f, -1.50915179e-02f, -5.17238788e-02f, -6.02532327e-02f, -4.08252887e-02f, 2.61417665e-02f, -5.73182926e-02f, -6.96900412e-02f, -1.29231617e-01f,
  8.04977864e-03f, -7.42332079e-03f, -1.01478353e-01f, -9.76362303e-02f, -1.11416370e-01f, -7.72861019e-02f, 2.98500117e-02f, 3.51491221e-03f, 9.82182100e-03f, -1.30157135e-02f,
  1.05002254e-01f, 2.58486513e-02f, 5.86649515e-02f, 1.97099820e-02f, 1.10990345e-01f, 7.80990720e-02f, 1.16365358e-01f, 1.05955362e-01f, 6.81687295e-02f, 6.17993213e-02f,
  4.33914065e-02f, 1.43071786e-01f, 3.88066806e-02f, 7.63349012e-02f, 9.08853784e-02f, 1.12683848e-01f, 9.39942375e-02f, 8.31076801e-02f, 1.16082029e-02f, 7.99902454e-02f,
  1.11379080e-01f, 6.68165758e-02f, 1.11489229e-01f, 6.07694983e-02f, 7.12966323e-02f, 6.97094649e-02f, 1.24467656e-01f, 1.26487151e-01f, 4.53077033e-02f, 3.77473198e-02f,
  -2.35122204e-01f, -1.40257895e-01f, 1.59954086e-01f, -9.53908265e-02f, 1.16345890e-01f, 1.57913744e-01f, -1.24234408e-01f, -1.10557238e-02f, 3.21032070e-02f, -1.26829192e-01f,
  2.09907204e-01f, 1.25120059e-01f, 3.40590887e-02f, 1.15121275e-01f, 6.71703964e-02f, -1.67183772e-01f, -2.53285486e-02f, 7.74439424e-02f, 1.14403814e-01f, 2.55700145e-02f,
  -4.03780304e-03f, -4.66786772e-02f, 1.96501426e-02f, -9.31889564e-02f, -1.32244572e-01f, -1.14810407e-01f, -1.47390038e-01f, -7.86739737e-02f, -6.93069845e-02f, -3.05512786e-01f,
  4.08875644e-02f, -5.74227283e-03f, 5.94304204e-02f, -8.92595276e-02f, 8.05065334e-02f, -1.11982077e-01f, -1.50045967e-02f, -1.07237212e-01f, -6.07520603e-02f, -1.56817902e-02f,
  7.86049291e-02f, 5.57879433e-02f, -2.76154466e-02f, -1.73352938e-02f, 1.68463180e-03f, -2.21070480e-02f, 2.18165033e-02f, -6.00998178e-02f, -5.46139665e-02f, 2.49634515e-02f,
  9.62541550e-02f, 6.11988902e-02f, 1.21428296e-01f, 9.19003710e-02f, -5.57335727e-02f, 7.99304098e-02f, 1.38520810e-03f, -1.45653754e-01f, -7.83078521e-02f, -2.26866752e-01f,
  -2.73443181e-02f, -5.25140837e-02f, 1.28002360e-01f, -1.27270650e-02f, 6.86728880e-02f, 1.14000089e-01f, 5.01299351e-02f, 4.32219990e-02f, -2.20670030e-02f, -1.39082801e-02f,
  1.03632949e-01f, 7.16584027e-02f, 9.22819600e-03f, -1.16515443e-01f, -5.25662675e-02f, -2.35776640e-02f, -3.34999873e-04f, -1.30736548e-02f, 8.39890614e-02f, -6.49752989e-02f,
  1.02067642e-01f, 2.96303239e-02f, -6.70546070e-02f, -2.43309699e-02f, 5.38200140e-02f, -5.37384376e-02f, -4.21130843e-03f, 4.55226563e-02f, 1.01544797e-01f, 5.05605005e-02f,
  -1.06171317e-01f, 2.45655671e-01f, -4.81714532e-02f, -4.73792069e-02f, -9.24882945e-03f, 1.30416360e-02f, -7.79378861e-02f, 2.90342793e-02f, 9.88182425e-02f, -4.84456681e-02f,
  4.31671925e-02f, 3.09123639e-02f, 2.07263436e-02f, -6.29247203e-02f, 3.92638519e-02f, -2.00652964e-02f, 8.07553977e-02f, -8.07831138e-02f, 1.76755339e-02f, -7.19138682e-02f,
  -4.29045707e-02f, -1.66670922e-02f, 8.62649381e-02f, -1.01244919e-01f, -1.04174562e-01f, -4.50299941e-02f, -1.24946229e-01f, -1.76999062e-01f, -1.16271853e-01f, -3.17247063e-01f,
  -1.48791984e-01f, -3.26624304e-01f, 1.82473153e-01f, -1.19209349e-01f, -6.71998337e-02f, 1.01785712e-01f, -5.94206452e-02f, -4.19004671e-02f, -8.27612653e-02f, -4.72114095e-03f,
  -8.87367055e-02f, -5.50546162e-02f, 1.23320613e-02f, -6.64018914e-02f, 7.84403235e-02f, 3.58981523e-03f, 1.13625191e-02f, 6.50573298e-02f, 2.78090000e-01f, 1.21927388e-01f,
  -2.03349199e-02f, -1.70087144e-01f, -1.37721211e-01f, 8.30055401e-03f, -1.06784068e-01f, 2.61091720e-02f, -9.85451788e-02f, -1.85148511e-03f, 3.18296673e-03f, -3.25077958e-02f,
  1.42033607e-01f, -1.74650922e-01f, 4.06039394e-02f, -3.81227322e-02f, 9.79381502e-02f, 1.29205734e-02f, 9.25964937e-02f, -3.36625017e-02f, 7.16902837e-02f, 5.24989404e-02f,
  -2.51740543e-03f, -3.72051238e-03f, -5.99112138e-02f, 4.99382988e-02f, -5.09851426e-02f, 4.02896702e-02f, 1.57914050e-02f, -5.57802357e-02f, 5.66044636e-02f, 1.56701785e-02f,
  -1.23344198e-01f, 5.34063056e-02f, 3.32246087e-02f, 1.26957789e-01f, 3.78280096e-02f, -2.91686337e-02f, 1.19839691e-01f, 7.96788186e-02f, -6.87604118e-03f, -2.82335002e-02f,
  6.25254884e-02f, -5.98752610e-02f, -1.56416278e-02f, -4.08426262e-02f, -6.59101531e-02f, -5.22540733e-02f, -2.83560082e-02f, 9.06686708e-02f, -6.84388867e-03f, -8.69336654e-04f,
  -6.46936661e-03f, 2.55633630e-02f, 2.40795277e-02f, -4.94462112e-03f, 2.32365448e-02f, 2.46576276e-02f, 1.11555979e-01f, 9.55221131e-02f, 7.81981722e-02f, 8.35683122e-02f,
  3.22239101e-02f, -1.76834278e-02f, 2.83002332e-02f, 5.48489019e-02f, 2.31232159e-02f, 7.83532858e-02f, 2.90766042e-02f, 3.58447209e-02f, -4.84590158e-02f, -7.18521699e-02f,
  8.96435007e-02f, -2.42597014e-02f, -1.04999607e-02f, 1.09371118e-01f, 1.35993645e-01f, 8.78898427e-02f, 1.71236414e-02f, 1.23264343e-01f, 3.30400616e-02f, 4.68417145e-02f,
  -8.35509691e-03f, -8.32549259e-02f, -2.84064244e-02f, -4.03361395e-02f, 5.86676188e-02f, 7.02055171e-02f, 1.11760583e-03f, 6.63593858e-02f, 1.22319780e-01f, 5.54084172e-03f,
  8.30196366e-02f, 1.27661288e-01f, 1.48310423e-01f, 9.78783593e-02f, 4.05765325e-03f, 1.28172442e-01f, 1.27096385e-01f, 1.81857139e-01f, 4.79791462e-02f, 1.59242779e-01f,
  9.42823365e-02f, 2.25754946e-01f, 1.84314802e-01f, 1.90445539e-02f, 5.76747209e-02f, 2.45696366e-01f, 2.57137656e-01f, 3.08714807e-01f, 3.44584174e-02f, 1.63250163e-01f,
  -1.62657887e-01f, -7.27727786e-02f, -6.04556240e-02f, -4.03905623e-02f, 2.10906520e-01f, 3.66611779e-01f, 3.07475626e-01f, 1.11850359e-01f, 1.99183822e-01f, 7.58699626e-02f,
  9.69292223e-02f, 1.14395611e-01f, 1.23321921e-01f, 7.58882016e-02f, -9.94384848e-03f, 5.03652245e-02f, 2.10386664e-01f, 1.00411445e-01f, 3.93656492e-02f, 1.07272662e-01f,
  -9.78899226e-02f, 8.68343413e-02f, 1.04718886e-01f, -6.28525913e-02f, -5.61963357e-02f, 1.24787666e-01f, 7.77953640e-02f, 3.91410068e-02f, 7.47471005e-02f, 5.11157736e-02f,
  -7.21114203e-02f, -2.13967320e-02f, 4.86948527e-02f, -3.90312523e-02f, 1.15549713e-01f, 8.01505372e-02f, 4.78606187e-02f, 1.69528589e-01f, 1.57974407e-01f, 3.63338739e-02f,
  -5.64283766e-02f, -3.10027096e-02f, 1.21620767e-01f, 1.79177403e-01f, 8.62675235e-02f, 1.06823422e-01f, 7.16579631e-02f, 6.90862462e-02f, 5.07850461e-02f, 1.79975525e-01f,
  -7.02902377e-02f, -7.84107074e-02f, -9.03147161e-02f, -5.88060953e-02f, -7.17647821e-02f, -1.68709904e-01f, -5.31570241e-02f, -1.16552629e-01f, -1.36169344e-01f, -1.56726073e-02f,
  -1.57913923e-01f, -1.57926828e-01f, -4.93111871e-02f, -8.81405100e-02f, -1.50879458e-01f, -9.00907665e-02f, -6.05112240e-02f, -1.14064768e-01f, -8.39148536e-02f, -1.55754924e-01f,
  -1.52713984e-01f, -8.82423222e-02f, -4.07866463e-02f, -1.20347194e-01f, -7.49405771e-02f, -5.69775887e-02f, -1.19458325e-01f, -6.69434518e-02f, -1.27712294e-01f, -1.20797008e-01f,
  1.12991840e-01f, 4.23083603e-02f, 5.19558452e-02f, 7.86662474e-02f, 9.58937258e-02f, 1.12599656e-01f, 2.14836448e-02f, 7.12890998e-02f, 4.56589274e-02f, 1.22117057e-01f,
  1.26645222e-01f, 1.13161266e-01f, 4.03604694e-02f, 7.87322894e-02f, 1.05929479e-01f, 8.06329101e-02f, 2.79877689e-02f, 4.11418974e-02f, 7.61024132e-02f, 5.96194081e-02f,
  1.72126517e-01f, 2.02933744e-01f, 1.76446661e-01f, 1.78663969e-01f, 1.54588148e-01f, 2.18518507e-02f, 1.62764758e-01f, 2.21334293e-01f, 1.45770088e-01f, 3.07892472e-01f,
  4.23689872e-01f, 2.02678248e-01f, 1.36998340e-01f, 1.17320158e-01f, 9.06098168e-03f, -6.27540946e-02f, -1.26717672e-01f, -1.17698297e-01f, 1.57623868e-02f, -2.87587717e-02f,
  1.57859385e-01f, 1.93336029e-02f, 2.63655540e-02f, 3.68743464e-02f, -1.21876173e-01f, -7.93305561e-02f, -6.37411177e-02f, 8.23102798e-03f, -1.49016097e-01f, -1.96131408e-01f,
  -1.73127390e-02f, 9.70948413e-02f, 1.08269438e-01f, -5.02444468e-02f, 1.48072422e-01f, 7.10958540e-02f, 2.03264907e-01f, 2.10093528e-01f, 1.21931449e-01f, 1.88220203e-01f,
  9.94267017e-02f, 3.00175011e-01f, -1.08145669e-01f, 1.09458290e-01f, 1.07415177e-01f, 6.04309663e-02f, 1.88861862e-02f, 1.61859319e-01f, 2.11565085e-02f, 1.04555696e-01f,
  1.27716854e-01f, 4.17103693e-02f, 1.29153579e-01f, 1.25454059e-02f, 9.47138518e-02f, -3.82330231e-02f, 3.92609574e-02f, -4.57060384e-03f, 1.24727003e-01f, 2.81001385e-02f,
  3.64473797e-02f, 1.65734872e-01f, 1.12799712e-01f, 5.81046492e-02f, -3.21442559e-02f, 2.68026628e-02f, 8.45867693e-02f, 8.79979208e-02f, -1.28152864e-02f, 4.40635793e-02f,
  -7.07697943e-02f, 1.27477199e-01f, -1.21614067e-02f, -8.90041795e-03f, -5.53931184e-02f, 2.08447371e-02f, 3.33136469e-02f, -7.11641908e-02f, 5.45816403e-03f, -4.08266559e-02f,
  -4.31225561e-02f, -9.21546891e-02f, -2.99082287e-02f, -6.25551045e-02f, -9.06451121e-02f, 3.22751403e-02f, -4.07773145e-02f, -6.58287331e-02f, -1.04325086e-01f, 6.09426480e-03f,
  -9.01229158e-02f, -7.67445490e-02f, 6.12479113e-02f, -1.52369346e-02f, -7.74916634e-02f, -4.15035747e-02f, -6.45770729e-02f, 8.32450017e-03f, -3.15963775e-02f, -5.28819412e-02f,
  1.27128251e-02f, -8.43152553e-02f, 3.80437449e-02f, 6.96925372e-02f, 6.07370660e-02f, 5.10114990e-02f, 1.13934420e-01f, 9.70179439e-02f, 9.71130356e-02f, -3.98118570e-02f,
  5.09230830e-02f, 1.64530687e-02f, 7.69915357e-02f, 9.70445797e-02f, -7.93719888e-02f, -4.56279740e-02f, -2.07137000e-02f, 4.19933349e-02f, -9.88238528e-02f, 5.46714813e-02f,
  4.03136062e-03f, -6.85176179e-02f, -9.66523588e-02f, -6.51360005e-02f, -3.72944251e-02f, -5.48190698e-02f, 3.34984474e-02f, -1.98268034e-02f, -6.49700910e-02f, -5.59767298e-02f,
  -1.90244332e-01f, -1.36672482e-01f, -8.44999179e-02f, 7.03702420e-02f, 2.30386872e-02f, -1.17046513e-01f, -2.04130813e-01f, -2.06729472e-02f, 1.01087995e-01f, -1.30602466e-02f,
  -2.38577664e-01f, -4.35104892e-02f, -9.34588537e-02f, 7.35678226e-02f, -9.28316265e-03f, 1.06812911e-02f, 1.93767637e-01f, 1.33916393e-01f, 5.41370399e-02f, -1.35749653e-01f,
  1.09803349e-01f, 5.02976552e-02f, 1.53495530e-02f, 1.29175082e-01f, -3.38423550e-02f, 3.32062915e-02f, 3.83985904e-03f, -4.83970270e-02f, -7.91586528e-04f, 1.18875496e-01f,
  -1.95257068e-01f, -1.83558345e-01f, -1.22165427e-01f, -5.43273576e-02f, -2.02487502e-02f, -9.81698781e-02f, -1.92860797e-01f, -8.38794038e-02f, -6.68067560e-02f, -8.58013406e-02f,
  -9.71947536e-02f, -4.37299907e-02f, -1.09607287e-01f, -6.93332404e-02f, -1.39743865e-01f, -9.87527668e-02f, 3.01336050e-02f, 7.23228557e-03f, -3.59864123e-02f, -1.54165253e-01f,
  -1.38874631e-03f, -6.27682805e-02f, -1.33940220e-01f, -5.74053116e-02f, -1.52414739e-01f, -1.06940761e-01f, -1.76265866e-01f, -5.17653078e-02f, -1.94210276e-01f, -5.82368337e-02f,
  4.93905433e-02f, 6.67327940e-02f, 1.00589059e-01f, 8.98253545e-02f, 1.06471650e-01f, 6.83462992e-02f, 4.94317226e-02f, 1.65205643e-01f, 1.52747139e-01f, 1.27365693e-01f,
  3.52449082e-02f, 1.45225957e-01f, 1.17784232e-01f, 9.84684676e-02f, 1.10862449e-01f, 1.47106037e-01f, 1.03707924e-01f, 2.80713420e-02f, 1.80426389e-01f, 7.11532310e-02f,
  1.68138787e-01f, 4.04805653e-02f, 1.96087584e-02f, 1.05754666e-01f, 1.28400465e-02f, 1.60368592e-01f, 1.66715384e-01f, 1.40705466e-01f, 6.23630658e-02f, 5.56292124e-02f,
  -7.43775591e-02f, -1.78226158e-01f, -1.47431612e-01f, -1.33894414e-01f, -8.33686218e-02f, -4.12153751e-02f, -1.65576980e-01f, -2.95239668e-02f, -4.77694087e-02f, -1.00994892e-01f,
  -1.43192738e-01f, -9.30519700e-02f, -1.04042485e-01f, -6.64088577e-02f, -9.07700658e-02f, -4.85151447e-02f, 5.23982719e-02f, -2.33504344e-02f, -6.63328636e-03f, -4.86874059e-02f,
  1.10266253e-01f, -4.76481132e-02f, -6.09444790e-02f, 1.66229885e-02f, -1.41566545e-01f, -1.19032256e-01f, -1.57258600e-01f, -1.86233506e-01f, -2.53529042e-01f, 2.31557526e-02f,
  -1.68213382e-01f, 5.58490157e-02f, 1.32852197e-02f, -2.42214695e-01f, -3.79126519e-02f, -3.64106856e-02f, 6.31513596e-02f, -3.26799154e-02f, -1.55687794e-01f, -1.25093013e-01f,
  -7.25974143e-02f, -9.71729215e-03f, -1.75292909e-01f, -1.39333054e-01f, -1.89378783e-01f, -3.82028446e-02f, -2.24974304e-01f, -8.41093808e-02f, -1.36189431e-01f, -1.76780224e-01f,
  -2.26154402e-01f, -1.03012070e-01f, -1.38186470e-01f, -1.30872846e-01f, -1.36591151e-01f, -5.34612685e-03f, -9.63096097e-02f, -1.52004972e-01f, 2.23443564e-02f, -1.05034061e-01f,
  1.52804088e-02f, 1.32015916e-02f, -1.21121503e-01f, -1.69865027e-01f, 1.99156851e-02f, -4.46713902e-02f, -1.36913851e-01f, -5.76094016e-02f, -9.55249742e-02f, -2.00429559e-02f,
  -4.37384285e-03f, -8.10330510e-02f, -1.29996702e-01f, -1.00551523e-01f, -1.55749604e-01f, -1.63095891e-01f, -2.02595234e-01f, -1.31112829e-01f, -7.70428032e-02f, -5.11596585e-03f,
  -8.35146308e-02f, 1.60125643e-02f, -2.56814249e-02f, -1.43963657e-03f, -1.26727521e-01f, -4.46533365e-03f, -4.73353043e-02f, 3.10532972e-02f, 7.78190643e-02f, 3.18352617e-02f,
  -2.36212146e-02f, 7.63553157e-02f, 8.85045454e-02f, -1.69065986e-02f, 6.14309832e-02f, 1.20798178e-01f, -1.30360825e-02f, 3.14088278e-02f, -4.81152274e-02f, 7.51611441e-02f,
  6.46704733e-02f, 4.22442071e-02f, 5.35056479e-02f, 1.30167931e-01f, 5.28080314e-02f, 1.20455734e-01f, 1.01375066e-01f, 5.55839799e-02f, 3.49930003e-02f, 2.51039546e-02f,
  1.23980545e-01f, 4.97126020e-02f, 1.31009653e-01f, 1.03268191e-01f, 1.00856535e-01f, 1.66333914e-01f, 1.93055235e-02f, 1.83101639e-01f, 9.75356624e-02f, 6.71077296e-02f,
  -1.90910883e-02f, -8.25532153e-02f, -1.24756992e-01f, -1.45689353e-01f, -9.18303579e-02f, -1.31249264e-01f, -1.86803192e-01f, -7.18300566e-02f, -6.03467114e-02f, -8.50265846e-02f,
  -4.82304990e-02f, -5.98897561e-02f, -3.06342635e-02f, -1.11121744e-01f, -4.83511947e-02f, -1.16374843e-01f, -1.93913355e-01f, -7.88570866e-02f, -1.34593382e-01f, -1.00618847e-01f,
  -2.24067956e-01f, -1.23008050e-01f, -3.56538743e-02f, -3.96339223e-02f, -2.27154442e-03f, -1.34162111e-02f, 6.25789836e-02f, 7.88885504e-02f, -1.32163549e-02f, -1.05929717e-01f,
  -8.89913458e-03f, -1.50524259e-01f, 1.02491610e-01f, 6.99990392e-02f, 1.12540968e-01f, 9.66988429e-02f, -7.10806549e-02f, -9.99992117e-02f, -8.61316770e-02f, -6.78889304e-02f,
  -2.48243347e-01f, -2.17179075e-01f, -1.71261862e-01f, -1.27545655e-01f, -6.83464203e-03f, 5.86763099e-02f, 7.52099007e-02f, -1.85866971e-02f, 6.10239841e-02f, -5.41778728e-02f,
  -8.09190646e-02f, 8.74003163e-04f, -2.51010507e-02f, -7.54940510e-02f, 5.40544800e-02f, -9.45278928e-02f, -1.62124820e-02f, 8.42609629e-02f, -2.53005661e-02f, 6.96047917e-02f,
  -8.90882760e-02f, -1.10304080e-01f, -2.40175217e-01f, -1.71428233e-01f, -6.82859793e-02f, -1.77932411e-01f, -1.56486124e-01f, -1.74098253e-01f, -1.03918821e-01f, -1.15203336e-01f,
  -2.23283097e-01f, -1.87957704e-01f, -1.34775102e-01f, -1.32699296e-01f, -2.09756359e-01f, -1.51697516e-01f, -1.67592123e-01f, -3.34221013e-02f, -2.21639529e-01f, -1.27413750e-01f,
  -2.13868186e-01f, -5.39120734e-02f, -4.54705209e-02f, -1.18299872e-01f, -8.76810700e-02f, -1.35303140e-01f, -7.88426101e-02f, -3.72935981e-02f, -7.43323490e-02f, -1.88396677e-01f,
  3.58200669e-02f, 1.57911867e-01f, 1.48882285e-01f, 3.45239136e-03f, 1.95376053e-02f, 3.47140171e-02f, 3.98402326e-02f, 1.39344275e-01f, 1.11914553e-01f, 8.28928649e-02f,
  6.56502992e-02f, 1.37684569e-01f, -1.63841043e-02f, 6.54965173e-03f, 1.49675757e-01f, 9.77317616e-02f, 2.13701185e-02f, 8.80889669e-02f, 3.21498439e-02f, 4.73800376e-02f,
  4.94289547e-02f, 5.21147102e-02f, 9.59363505e-02f, 1.17822587e-01f, 1.12787299e-01f, 5.25965244e-02f, 1.15186942e-03f, 4.89922911e-02f, 4.25462686e-02f, 1.36201963e-01f,
  -1.73530415e-01f, -1.99180916e-01f, -1.27760321e-01f, -1.27946034e-01f, -1.13432877e-01f, -2.44038627e-01f, -1.33247271e-01f, -1.47965685e-01f, -2.23224625e-01f, -1.29961759e-01f,
  -2.08411813e-01f, -1.80099830e-01f, -1.37625113e-01f, -2.20711097e-01f, -7.97907859e-02f, -1.11553006e-01f, -1.97172135e-01f, -7.59684667e-02f, -1.97989702e-01f, -2.64547646e-01f,
  -1.72611520e-01f, -1.27890250e-02f, -1.77092493e-01f, -1.16973534e-01f, -3.31481174e-02f, -9.93203968e-02f, -1.70021549e-01f, -2.86045689e-02f, -5.69594949e-02f, -1.74273878e-01f,
  -3.23558688e-01f, 1.16182357e-01f, 5.80060668e-02f, -2.42410794e-01f, 7.68999234e-02f, -2.37739664e-02f, 1.45105915e-02f, -2.22137436e-01f, -1.84656128e-01f, 7.86345154e-02f,
  9.34467372e-03f, -9.69778374e-02f, -3.89393941e-02f, 3.31884958e-02f, -1.99540317e-01f, 9.99115035e-02f, 3.93317752e-02f, -9.12766755e-02f, -2.42996871e-01f, -1.30780309e-01f,
  -3.13156769e-02f, -2.09994420e-01f, -1.69320136e-01f, -7.43638352e-02f, 1.42739147e-01f, 1.60000641e-02f, 2.22766533e-01f, 6.61284924e-02f, 1.75758675e-01f, 3.09669614e-01f,
  1.97040260e-01f, -2.31273491e-02f, -2.14968398e-02f, -6.67713732e-02f, 1.28601417e-01f, 3.75656150e-02f, -6.13520965e-02f, 3.10975797e-02f, 4.65430506e-02f, 5.17275892e-02f,
  4.14383039e-02f, 6.59800554e-03f, -4.40817103e-02f, 4.27295603e-02f, -2.55277026e-02f, 4.30837981e-02f, -1.46665247e-02f, 2.58194674e-02f, 5.60573228e-02f, 5.47254384e-02f,
  2.70012859e-02f, 7.57472962e-02f, -6.47119107e-03f, 1.35148680e-02f, 4.50522127e-03f, 5.09547405e-02f, 3.55540812e-02f, 1.10353008e-01f, 5.32310270e-02f, 1.53360114e-01f,
  3.61763053e-02f, 2.34387647e-02f, 1.49303414e-02f, -6.31558448e-02f, 8.34033638e-02f, -3.38299982e-02f, 1.20993881e-02f, 5.90014048e-02f, -2.82963421e-02f, -7.98247904e-02f,
  -3.30109335e-02f, -9.78860538e-03f, 2.83498354e-02f, -4.07761745e-02f, 2.96075754e-02f, -4.45984825e-02f, -1.45817906e-01f, 7.13283755e-03f, -1.48073270e-03f, -6.99476376e-02f,
  3.06642638e-03f, 4.84814011e-02f, -5.63270785e-03f, -6.55187145e-02f, -2.04202402e-02f, 2.04811934e-02f, 4.18067118e-03f, -4.14863080e-02f, -1.58781394e-01f, -3.31564844e-02f,
  -1.56057358e-01f, 7.37918988e-02f, 1.16987519e-01f, -1.59323774e-02f, 1.27314791e-01f, 4.02542017e-02f, 8.48733932e-02f, 4.80922237e-02f, 6.54189065e-02f, 8.54477286e-02f,
  7.06644133e-02f, 2.06788629e-02f, -4.90998887e-02f, 7.59153888e-02f, 6.03984110e-02f, -2.76266672e-02f, 6.21921048e-02f, -5.70565313e-02f, 6.22470677e-02f, 3.14439572e-02f,
  4.39752936e-02f, -9.03107375e-02f, 5.24461530e-02f, 8.76643062e-02f, 1.15232699e-01f, -7.69233406e-02f, 3.26439664e-02f, 9.72349420e-02f, 1.03253443e-02f, 1.68774631e-02f,
  3.37049812e-01f, -1.57985054e-02f, 2.75962800e-01f, 2.97619700e-02f, -3.74883115e-02f, 1.96314260e-01f, 2.31991827e-01f, 2.28904411e-01f, 5.36467992e-02f, 1.26828983e-01f,
  -1.70219257e-01f, -1.29768560e-02f, 1.21940458e-02f, 1.02701150e-01f, 3.39872509e-01f, 3.19490433e-01f, 2.08083853e-01f, 2.79160678e-01f, 1.47665784e-01f, 1.39894476e-02f,
  -2.34748386e-02f, 1.28873840e-01f, 1.29125252e-01f, 1.77092656e-01f, -5.60144521e-02f, 4.73778844e-02f, 1.91752352e-02f, -2.59658713e-02f, -7.91269913e-02f, -3.05314753e-02f,
  6.67477548e-02f, 8.00627097e-02f, 1.24617517e-01f, -3.80615704e-02f, -6.55563101e-02f, 2.05048382e-01f, 7.15128556e-02f, 5.14039360e-02f, 8.19425359e-02f, 1.05394334e-01f,
  2.78578773e-02f, 1.05352430e-02f, 4.86570075e-02f, -2.83530746e-02f, 6.30600974e-02f, 1.33322880e-01f, 5.69181964e-02f, 1.16461523e-01f, 2.08966553e-01f, 1.60557061e-01f,
  -9.30616632e-03f, 7.45125562e-02f, 1.06159262e-01f, 9.24079865e-02f, 1.03641525e-01f, 3.66175175e-02f, -1.42553980e-02f, 1.29858583e-01f, 4.40360568e-02f, 6.28394783e-02f,
  6.42208084e-02f, 1.80610493e-02f, -1.83349401e-02f, -7.73348287e-02f, -5.79308122e-02f, -5.85693046e-02f, -5.72781600e-02f, -6.88949898e-02f, 2.44363640e-02f, -3.40586938e-02f,
  -9.56991166e-02f, -2.64119059e-02f, -3.66145372e-02f, 8.41277838e-02f, -1.17552429e-01f, -1.92097183e-02f, 8.56139045e-03f, -5.50697409e-02f, -2.70813587e-03f, -5.85796982e-02f,
  -8.60639289e-02f, -5.25761321e-02f, -9.89768803e-02f, -5.35078831e-02f, 5.79365110e-03f, -5.31824119e-02f, -1.75673440e-02f, -8.32387581e-02f, -4.68023419e-02f, 1.01746395e-02f,
  -9.38841552e-02f, 2.19661057e-01f, 9.25187394e-02f, 1.00458018e-01f, -2.11155694e-02f, 7.06514269e-02f, 6.38755634e-02f, -1.62598137e-02f, 7.48600485e-03f, 1.56742007e-01f,
  9.08378065e-02f, 1.02430031e-01f, 8.01180899e-02f, 1.27974506e-02f, 2.49552205e-02f, 1.54633299e-01f, -5.13211265e-02f, 3.57376076e-02f, 8.42271596e-02f, -1.92898940e-02f,
  1.24642342e-01f, 2.37230863e-02f, 1.25339225e-01f, 6.63390160e-02f, 1.37780234e-01f, 1.20658472e-01f, -1.08809099e-02f, 1.18557140e-01f, 2.32666031e-01f, 1.29076570e-01f,
  -4.86319512e-02f, -8.14805105e-02f, 2.19067767e-01f, 7.51856267e-02f, -3.27828829e-03f, 9.69160944e-02f, 1.83873355e-01f, 1.97076220e-02f, -8.25587660e-02f, 1.26909733e-01f,
  -2.15152040e-01f, -2.10675165e-01f, -8.16258639e-02f, -1.00814685e-01f, 4.72859330e-02f, 1.93439454e-01f, 2.30191305e-01f, 1.60462961e-01f, 1.12279028e-01f, -9.68913659e-02f,
  2.12923042e-03f, -6.73433095e-02f, -9.60544869e-02f, -5.81642687e-02f, 1.54072605e-02f, 2.20177379e-02f, 1.80545524e-01f, -5.35669401e-02f, 1.70752946e-02f, 9.41897631e-02f,
  1.25072494e-01f, -3.58969420e-02f, 1.68052467e-03f, -1.33240953e-01f, -1.64959282e-02f, -5.63955270e-02f, 2.29735877e-02f, 4.31367271e-02f, 1.54220974e-02f, 5.42404316e-03f,
  -1.30887374e-01f, 2.61468589e-02f, -3.96966077e-02f, -1.12532482e-01f, -2.50869710e-02f, -2.43232548e-02f, -4.81200702e-02f, 2.99240388e-02f, -6.82085007e-02f, 8.37934110e-03f,
  -1.06977478e-01f, -1.09486163e-01f, 4.23877649e-02f, -3.49402241e-02f, 3.86655331e-02f, -1.13197990e-01f, 6.01028726e-02f, -7.36769885e-02f, 1.92836355e-02f, 1.00082658e-01f,
  1.72765665e-02f, -9.61165801e-02f, -3.08672804e-02f, -2.27301456e-02f, -6.41847402e-02f, -4.48918827e-02f, -5.74916564e-02f, 1.45569099e-02f, 2.62921080e-02f, -7.28369281e-02f,
  -3.15546058e-03f, -9.48780775e-02f, -2.11790316e-02f, 1.59816295e-02f, -2.79889517e-02f, -5.03582065e-04f, -6.18486628e-02f, -6.14319704e-02f, -5.72904572e-02f, -3.87940370e-02f,
  -2.44538635e-02f, -6.81928620e-02f, 8.90021622e-02f, -3.46408854e-03f, 2.05349997e-02f, -8.78108293e-02f, -3.69877145e-02f, -1.15142129e-01f, 1.02230012e-02f, -6.91454783e-02f,
  -1.21452771e-02f, -1.23402365e-01f, 8.11116174e-02f, -1.74668636e-02f, 3.99038680e-02f, -4.47845273e-02f, 4.22906727e-02f, 6.77617341e-02f, 8.04958120e-03f, 1.39706200e-02f,
  -1.25232086e-01f, 8.13479722e-03f, -4.52011488e-02f, 2.40102038e-02f, 5.43076880e-02f, -3.44444253e-02f, -1.13270327e-01f, 1.10915966e-01f, -2.71085482e-02f, 5.59538305e-02f,
  -3.69249545e-02f, 3.88592319e-03f, 9.25167128e-02f, 3.84513699e-02f, 3.72519046e-02f, 6.55461997e-02f, 2.47736983e-02f, 1.13177150e-01f, 1.16914622e-01f, 2.27425247e-01f,
  2.12898508e-01f, -3.98041099e-01f, 2.72973955e-01f, -6.16201609e-02f, -1.26249716e-01f, -5.39325029e-02f, -2.32127503e-01f, -8.76343176e-02f, -9.68609825e-02f, -1.59022093e-01f,
  -1.27551809e-01f, 1.47546515e-01f, 1.74747244e-01f, 3.64074260e-02f, 1.26402959e-01f, -8.36741850e-02f, 2.93497313e-02f, 2.35252261e-01f, 3.41456801e-01f, 1.43591270e-01f,
  -1.98226124e-01f, -3.82266603e-02f, 1.37487516e-01f, 6.14217762e-03f, -1.71830252e-01f, 5.06347492e-02f, 1.12561546e-02f, -1.12203598e-01f, -3.11984052e-03f, -1.49544179e-01f,
  8.36526453e-02f, -4.35875617e-02f, 1.15496427e-01f, -3.59873846e-02f, -2.16134228e-02f, 1.02417090e-03f, -8.24228004e-02f, -9.22521651e-02f, 3.40839215e-02f, -6.01747185e-02f,
  -1.13050984e-02f, -3.61822871e-03f, 1.30465850e-02f, -6.26366213e-02f, 9.08389408e-03f, 4.83242795e-02f, 9.47096944e-03f, 1.58850268e-01f, 9.74986255e-02f, 1.98957045e-02f,
  -8.96762013e-02f, -1.15612179e-01f, 9.91954878e-02f, 1.42950956e-02f, 6.28184751e-02f, 8.94899145e-02f, -3.76160927e-02f, 2.95798667e-02f, 1.15566261e-01f, -2.14850098e-01f,
  -2.31126277e-03f, 2.89037321e-02f, 1.21227957e-01f, 1.59780476e-02f, -3.06263510e-02f, 3.41148861e-02f, 4.41330373e-02f, 5.55365235e-02f, 1.09912707e-02f, -6.29266426e-02f,
  1.27909044e-02f, -4.24858443e-02f, -2.55262740e-02f, -1.26146004e-02f, -8.53118747e-02f, -3.22291963e-02f, 5.24226427e-02f, -3.82001512e-02f, -2.77071893e-02f, -3.81159298e-02f,
  2.13137325e-02f, 1.08779520e-01f, -1.14690447e-02f, 5.09842718e-03f, -1.95040479e-02f, 8.72374028e-02f, 9.02377516e-02f, -6.71149492e-02f, -6.36379002e-03f, -6.52150426e-04f,
  -4.48084325e-02f, 9.60157886e-02f, -4.79517356e-02f, -8.88585001e-02f, 1.55188274e-02f, 4.95188721e-02f, 1.21252537e-02f, -4.17653285e-02f, -4.72747907e-02f, -6.07378818e-02f,
  -4.46349457e-02f, 3.92822139e-02f, -1.06900789e-01f, 3.31395562e-03f, 5.80440694e-03f, -5.36756553e-02f, -1.04710005e-01f, 3.30624171e-03f, 3.19690444e-02f, -9.16983560e-02f,
  -7.59107471e-02f, 6.57052547e-03f, 1.90064423e-02f, -2.74081696e-02f, -4.21712287e-02f, 6.88284338e-02f, -9.60471109e-02f, 1.84803922e-02f, 1.20765887e-01f, -1.80210084e-01f,
  1.56379845e-02f, -9.49356630e-02f, -5.21382764e-02f, -2.88351160e-02f, 2.67998036e-02f, 1.86182782e-01f, 1.22481376e-01f, 2.37256624e-02f, 1.17425017e-01f, 7.36698136e-02f,
  1.54701933e-01f, 5.85922487e-02f, -3.57650444e-02f, -1.34937853e-01f, -9.91002694e-02f, -9.69399288e-02f, -1.76627830e-01f, -2.14701295e-01f, -7.67152458e-02f, 5.77542484e-02f,
  2.84640417e-02f, -9.76306647e-02f, -1.27146006e-01f, -1.14098944e-01f, 3.25875208e-02f, -4.77890708e-02f, 2.63642352e-02f, 2.44892966e-02f, 9.03754160e-02f, -1.48335695e-01f,
  6.90849051e-02f, -5.70468046e-02f, 8.80332198e-03f, -2.91072745e-02f, -4.83744331e-02f, 3.56686339e-02f, 7.69502521e-02f, -1.11091487e-01f, -5.30579127e-02f, -9.08348560e-02f,
  8.32544174e-03f, 1.05267921e-02f, -6.26423955e-02f, -1.09936958e-02f, -3.67545299e-02f, 1.65582467e-02f, -4.44705822e-02f, -1.03071697e-01f, -4.65260074e-02f, 5.33904769e-02f,
  -1.40916616e-01f, -4.28924058e-03f, -3.83233577e-02f, 5.77581041e-02f, -9.63765681e-02f, -7.17834756e-02f, -2.83533279e-02f, -8.90718400e-02f, 6.31738156e-02f, 1.71310659e-02f,
  -2.45425794e-02f, 3.67589071e-02f, 5.00305034e-02f, 5.24807759e-02f, 7.80756697e-02f, -3.26521844e-02f, 9.91765689e-03f, 2.28431001e-02f, -6.11076877e-03f, -2.67983545e-02f,
  -2.01026257e-02f, 7.28699937e-02f, 1.69838108e-02f, 4.60313149e-02f, -5.41514680e-02f, -1.80844124e-02f, 1.25961918e-02f, 2.53032707e-02f, -7.67286262e-03f, -8.34797043e-03f,
  -3.38466056e-02f, -2.75578280e-03f, -3.75657342e-02f, -1.68016534e-02f, -8.78921747e-02f, 1.63281485e-02f, 4.73558530e-02f, -7.62696341e-02f, -6.41952902e-02f, -7.20831677e-02f,
  1.52791515e-01f, 9.48244855e-02f, -8.58770590e-03f, -4.04419079e-02f, -5.59997139e-03f, 3.01324073e-02f, -7.35705495e-02f, 9.33882445e-02f, -7.25793093e-02f, 4.88855653e-02f,
  -1.92096327e-02f, 2.19621342e-02f, -6.40660673e-02f, -3.43742184e-02f, -4.16551083e-02f, 2.54520196e-02f, 1.01261027e-01f, 6.79597855e-02f, 4.66627590e-02f, 6.62192926e-02f,
  -5.23044281e-02f, 1.17274694e-01f, 1.31364837e-01f, -4.53809947e-02f, 8.79917294e-02f, 1.44360289e-01f, 1.05632804e-01f, 6.12118989e-02f, 8.61116648e-02f, 1.30674332e-01f,
  1.16172120e-01f, 3.04705590e-01f, 1.00703388e-01f, 2.51986086e-01f, 1.47978785e-02f, -7.02964067e-02f, -8.74033719e-02f, 1.64432809e-01f, 2.45126218e-01f, 1.35643452e-01f,
  6.24804236e-02f, 7.10099787e-02f, 2.34288067e-01f, 1.65419251e-01f, 6.27375320e-02f, 8.32141414e-02f, 2.47660019e-02f, -1.09984372e-02f, 1.68156605e-02f, -7.88515899e-03f,
  6.56552240e-02f, 1.51715919e-01f, 1.74157560e-01f, 1.57745987e-01f, 1.70684844e-01f, 4.24754359e-02f, 1.34804651e-01f, 9.31161717e-02f, 3.37046236e-02f, 3.03693503e-01f,
  9.36297178e-02f, 1.38992578e-01f, 2.28766669e-02f, 1.56397656e-01f, 1.36212409e-01f, 5.16075976e-02f, -7.08333729e-03f, 1.15336515e-01f, 1.06385127e-02f, 9.09256116e-02f,
  1.16272725e-01f, 7.02374130e-02f, 1.67730793e-01f, 4.73699197e-02f, 5.46754636e-02f, 6.89017922e-02f, 1.36061370e-01f, 9.59244221e-02f, 1.85732201e-01f, 5.27460277e-02f,
  1.27446055e-01f, 1.97666809e-01f, 6.77249581e-02f, 1.16488468e-02f, 1.08064771e-01f, 8.22008401e-02f, 9.83907729e-02f, 4.53784578e-02f, 9.88985300e-02f, 1.57514855e-01f,
  7.20600635e-02f, -1.48573056e-01f, -1.58288166e-01f, -5.17313704e-02f, -6.44579083e-02f, -1.51844040e-01f, 4.95085306e-03f, -6.05803542e-02f, -1.86742067e-01f, 2.51489528e-03f,
  -6.44564182e-02f, -2.84796879e-02f, -6.02480471e-02f, 3.03832125e-02f, -2.77905706e-02f, -9.40336958e-02f, -1.23634137e-01f, 3.48712690e-02f, -8.47987738e-03f, -3.10054291e-02f,
  -8.18687454e-02f, -7.57891834e-02f, -1.00119017e-01f, -1.17234111e-01f, 1.17724519e-02f, -1.73246991e-02f, -3.91383767e-02f, -1.36232272e-01f, 7.40567828e-03f, -4.34244536e-02f,
  2.33956337e-01f, 5.12126721e-02f, 1.78654686e-01f, 1.82963405e-02f, 8.56585875e-02f, -2.47983038e-02f, -1.16477078e-02f, -1.50842518e-02f, 1.01859458e-01f, 9.37922075e-02f,
  2.52578277e-02f, 4.29727659e-02f, 3.30572613e-02f, 1.06020831e-01f, 6.00321703e-02f, -4.87706810e-02f, 6.89886957e-02f, 8.66200253e-02f, 1.31861076e-01f, 1.45647481e-01f,
  1.19206719e-01f, -2.83560716e-03f, 3.54156196e-02f, 6.08881265e-02f, 5.64869046e-02f, -3.57623249e-02f, -4.18417417e-02f, -4.36417535e-02f, -9.62410644e-02f, -7.13127553e-02f,
  -2.73781449e-01f, 2.86472112e-01f, 7.18523636e-02f, -1.20416097e-01f, 1.57011282e-02f, -2.85146032e-02f, 8.69437158e-02f, -9.77478623e-02f, -1.32270917e-01f, 2.11340547e-01f,
  2.58455485e-01f, -6.04333133e-02f, -1.24926463e-01f, -6.23103492e-02f, -1.08722620e-01f, -6.62759319e-02f, -9.66954231e-02f, -2.75235534e-01f, -3.81667286e-01f, -1.42470196e-01f,
  -1.16627820e-01f, -1.77858382e-01f, -2.11787030e-01f, -9.40016732e-02f, -5.47117516e-02f, -1.44260928e-01f, 1.46990702e-01f, -8.87936205e-02f, 6.54870123e-02f, -7.58641288e-02f,
  -1.55868202e-01f, 5.28165326e-02f, -9.10933465e-02f, 6.67869486e-03f, 4.77034822e-02f, -4.59405147e-02f, 3.43046598e-02f, -3.68097089e-02f, 7.30319694e-02f, -7.48537630e-02f,
  7.34789064e-03f, 4.40053791e-02f, -5.03648296e-02f, -4.66591455e-02f, -1.11475468e-01f, 2.87345122e-03f, 8.49731416e-02f, 3.09333019e-02f, -8.28139856e-02f, 1.08316965e-01f,
  7.79135898e-02f, 7.71655962e-02f, 2.42949817e-02f, 7.66034722e-02f, -2.35457812e-02f, -4.12266999e-02f, 1.60204515e-01f, -5.34345992e-02f, -3.25077623e-02f, 7.39647495e-03f,
  4.87397574e-02f, 8.63314942e-02f, 4.63821292e-02f, 3.00779324e-02f, 8.60369727e-02f, 9.39428061e-02f, -2.03433894e-02f, 1.18844062e-01f, -4.61901017e-02f, 1.43310905e-01f,
  1.54836372e-01f, 5.79766259e-02f, 8.45155567e-02f, 8.52517635e-02f, 7.94007629e-02f, 6.02276577e-03f, 9.37349126e-02f, 1.01391405e-01f, 1.37851238e-01f, 9.63619575e-02f,
  1.00823186e-01f, 4.40120660e-02f, 4.08506133e-02f, 5.37666604e-02f, 8.14199671e-02f, -5.16993739e-03f, 6.22151420e-03f, 1.01259962e-01f, 7.08048791e-02f, 1.84295606e-02f,
  1.55126834e-02f, -3.59650180e-02f, -8.99838060e-02f, -1.67461097e-01f, -5.67571074e-02f, 1.21500213e-02f, 4.99088578e-02f, 5.25417961e-02f, 4.80386764e-02f, -5.19344024e-02f,
  -7.75162689e-03f, -8.52034315e-02f, 5.26788644e-02f, -9.43398976e-04f, -9.33443941e-03f, 4.55012918e-02f, 7.16818310e-03f, -2.35246383e-02f, -3.46364379e-02f, 3.46463174e-02f,
  8.01489428e-02f, 1.31697748e-02f, -1.95277389e-02f, 8.11048076e-02f, -8.50883797e-02f, -1.09044939e-01f, -1.77298468e-02f, -1.92137323e-02f, -1.31869823e-01f, 9.75634754e-02f,
  3.62642258e-01f, -4.39712480e-02f, 1.34622321e-01f, -7.35515580e-02f, 1.27135038e-01f, 1.76819712e-01f, 1.20812967e-01f, -7.80120343e-02f, -7.10252002e-02f, 2.41622124e-02f,
  6.94907680e-02f, -8.42982009e-02f, 4.92629642e-03f, 8.95226896e-02f, 8.45029950e-02f, -6.03338927e-02f, 3.71857285e-02f, 1.61919609e-01f, 9.67706218e-02f, -6.69970065e-02f,
  -1.45841306e-02f, -1.21427350e-01f, 6.55474588e-02f, -5.76307140e-02f, -1.21459797e-01f, -9.95501727e-02f, -8.99928585e-02f, 2.86303461e-02f, 1.05894499e-01f, -8.01592842e-02f,
  2.06173345e-01f, 1.89627752e-01f, 1.35384165e-02f, 1.05591223e-01f, 3.63144614e-02f, -7.75283948e-02f, -3.06827482e-02f, -1.53209046e-01f, -1.23654209e-01f, -1.11793820e-02f,
  -1.96640193e-02f, 9.51294973e-02f, -3.81578319e-03f, -1.38884867e-02f, -4.73397300e-02f, -5.38575016e-02f, -1.26831618e-03f, 6.17808849e-03f, -1.78029910e-02f, -1.96655057e-02f,
  -5.65799773e-02f, 1.81395233e-01f, 2.12387413e-01f, 4.85018939e-02f, 5.49919754e-02f, 1.46169022e-01f, 5.97366318e-02f, 5.64231537e-02f, 5.45585267e-02f, -1.21820368e-01f,
  -1.25387698e-01f, 1.40618375e-02f, -1.76981220e-03f, -1.41293015e-02f, 1.21537615e-02f, -6.00766018e-02f, 2.05202252e-02f, 3.47153395e-02f, 3.14858221e-02f, -4.22764570e-02f,
  4.54250462e-02f, -5.44045456e-02f, 4.84296381e-02f, -3.32210697e-02f, 4.59701149e-03f, 5.03837317e-02f, -1.81026403e-02f, 2.14748215e-02f, 5.80302924e-02f, -9.31024775e-02f,
  3.38167325e-02f, 6.71192184e-02f, 3.58155482e-02f, 1.42231060e-03f, 5.52630015e-02f, 7.27853365e-03f, 1.78018101e-02f, -5.91573678e-02f, -1.18792646e-01f, -4.83404212e-02f,
  -3.03156495e-01f, 2.11085394e-01f, -9.30245072e-02f, -7.36302957e-02f, -4.30619903e-02f, 1.51484422e-02f, 6.59557581e-02f, 2.52936892e-02f, 1.00964559e-02f, 3.01881577e-04f,
  7.51588270e-02f, -1.23774400e-02f, 1.32626598e-03f, 7.17949297e-04f, 1.11854915e-02f, -5.74354781e-05f, 6.50186930e-03f, 1.02442011e-01f, 2.66192425e-02f, -7.49895945e-02f,
  -1.19498931e-01f, 1.10039979e-01f, 1.20625384e-01f, 6.61405250e-02f, -8.60583484e-02f, 5.88829909e-03f, 1.05162924e-02f, 2.41005532e-02f, 2.45574415e-02f, -4.97696698e-02f,
  4.80450913e-02f, -8.26685354e-02f, -1.23201916e-02f, 5.51398657e-02f, -5.77762276e-02f, -8.30408707e-02f, 4.29086164e-02f, 3.66335288e-02f, 1.13439426e-01f, -1.13649510e-01f,
  -9.64341462e-02f, 1.51580319e-01f, 9.33095962e-02f, 5.46918102e-02f, 1.05919264e-01f, -1.01346813e-01f, -9.56780910e-02f, 9.34425443e-02f, 1.99877232e-01f, -4.84250340e-04f,
  -1.17162243e-01f, -1.74976718e-02f, -3.35582308e-02f, 9.39988121e-02f, -1.17044874e-01f, -1.01759611e-02f, -3.04036103e-02f, -8.56512189e-02f, -7.48542920e-02f, -1.34612203e-01f,
  -1.80603154e-02f, -1.24137469e-01f, 3.85313220e-02f, 1.07867643e-02f, 5.02577946e-02f, 1.09249242e-01f, 6.81430101e-02f, 1.06975809e-01f, 1.33639649e-01f, 9.83093977e-02f,
  7.23085133e-04f, 2.46844981e-02f, 2.93414779e-02f, 9.58329588e-02f, -2.30376273e-02f, -1.67852081e-02f, 7.42563605e-02f, 1.35532871e-01f, 1.63847193e-01f, -1.24327680e-02f,
  -4.39897738e-02f, -1.10464454e-01f, 5.07206656e-02f, -2.17549931e-02f, -3.53553966e-02f, -5.56782112e-02f, -3.45512037e-03f, -8.89417604e-02f, 2.83711031e-02f, 1.10146115e-02f,
  -8.12425315e-02f, -5.01485653e-02f, -5.41695617e-02f, -7.81873893e-03f, 2.05568317e-02f, 6.13766499e-02f, 4.77443524e-02f, 3.23918052e-02f, -3.06774955e-03f, 8.05036277e-02f,
  5.47279119e-02f, 2.24080216e-02f, -4.65416014e-02f, 2.40171161e-02f, 5.14631383e-02f, -5.16847894e-02f, 3.22474237e-03f, 4.13021185e-02f, 8.37875083e-02f, -3.07087060e-02f,
  4.74465787e-02f, -2.98681716e-03f, 1.06758140e-01f, 6.72258884e-02f, 3.09619792e-02f, 2.48950496e-02f, 1.17523111e-02f, 6.77842821e-04f, -9.07994881e-02f, -1.52822047e-01f,
  2.37439781e-01f, 7.71041811e-02f, 1.20430231e-01f, 6.75817532e-03f, 4.62872349e-02f, 1.20239608e-01f, 2.52381694e-02f, 4.97674942e-03f, -3.48287374e-02f, -1.84253715e-02f,
  -1.06303170e-02f, 1.04991175e-01f, 6.57820478e-02f, 1.29959270e-01f, 1.31268054e-01f, 3.23080905e-02f, -4.84399833e-02f, 1.05380245e-01f, 9.54433009e-02f, -4.15672846e-02f,
  1.23181097e-01f, 9.61763635e-02f, 4.41512093e-02f, 6.49328455e-02f, -4.13299017e-02f, 1.15610525e-01f, 8.44665244e-03f, 6.16359450e-02f, 1.52638450e-01f, 8.79855230e-02f,
  3.03018838e-01f, 1.55563071e-01f, 1.14677800e-02f, 1.56811401e-01f, 4.64667641e-02f, -9.88783315e-02f, -1.17648780e-01f, -1.88950449e-02f, 2.40391735e-02f, 3.21838595e-02f,
  1.64930284e-01f, 3.84227931e-02f, 5.66483811e-02f, -3.53322667e-03f, -2.13079512e-01f, -6.53418899e-02f, -3.35291028e-02f, -1.91314995e-01f, -4.07918207e-02f, -3.66423465e-02f,
  -8.22186023e-02f, -6.13192469e-02f, -7.76856542e-02f, -2.12080292e-02f, -1.39634497e-02f, 4.38092723e-02f, -6.15157522e-02f, 2.12245490e-02f, -3.70569937e-02f, -6.73537627e-02f,
  8.17059800e-02f, 9.28256288e-02f, -1.24341175e-01f, -3.44444290e-02f, -9.75460038e-02f, 4.14102636e-02f, -8.58883467e-03f, -6.47845268e-02f, -9.74523500e-02f, -1.31077573e-01f,
  -3.88988219e-02f, -1.09033890e-01f, -3.21890935e-02f, -1.57267392e-01f, -4.64278460e-02f, -9.39435735e-02f, -1.48683071e-01f, -2.17842296e-01f, -1.18297651e-01f, -9.87841263e-02f,
  -1.33967847e-01f, 6.75030658e-03f, -7.18966266e-03f, -1.05298571e-01f, -1.45981282e-01f, -3.41111757e-02f, -1.16018288e-01f, -5.91032878e-02f, -8.46922919e-02f, 8.54421407e-02f,
  1.70697659e-01f, 3.63322124e-02f, 9.31642950e-02f, 6.79609030e-02f, 5.43680191e-02f, 3.76487225e-02f, -4.35891412e-02f, 4.20084521e-02f, -3.77198867e-02f, 1.39138952e-01f,
  1.32626500e-02f, 9.09497775e-03f, 4.85590026e-02f, 7.12872073e-02f, 1.00717880e-01f, -3.59855518e-02f, 5.30952290e-02f, -1.73531659e-02f, 1.14438431e-02f, -8.23188049e-04f,
  1.15317121e-01f, 3.19095299e-04f, 6.10663220e-02f, -3.53952311e-02f, -5.23205101e-03f, 1.13813961e-02f, 1.28299013e-01f, 1.20914437e-01f, 5.46897464e-02f, 1.41034452e-02f,
  1.37899309e-01f, -2.41492540e-01f, 7.05944970e-02f, -1.65330961e-01f, -4.62564044e-02f, -1.47134826e-01f, -7.79665783e-02f, -1.81155920e-01f, -3.86595093e-02f, -6.90889433e-02f,
  -6.30715936e-02f, -6.28861040e-02f, -1.47557333e-01f, -1.19737424e-01f, -8.90975073e-02f, -1.28676727e-01f, -1.45579919e-01f, -8.39104727e-02f, -1.41721055e-01f, -1.42820984e-01f,
  -1.12394989e-01f, -3.25519741e-02f, 2.87031587e-02f, -8.05858523e-02f, -1.00634195e-01f, -1.24130853e-01f, -2.38979198e-02f, -4.83756065e-02f, -1.53356031e-01f, 2.09264308e-02f,
  -1.81552961e-01f, -2.78847069e-01f, -1.67697147e-01f, -5.83402403e-02f, 1.01902805e-01f, 8.10211003e-02f, -2.04875678e-01f, 2.57453751e-02f, -1.53741464e-02f, -8.59659761e-02f,
  5.93223842e-03f, 1.80896595e-01f, 4.79558669e-02f, 1.91494212e-01f, 1.49989113e-01f, -1.69458255e-01f, -7.91949183e-02f, -2.11509205e-02f, 1.56122506e-01f, 2.12567180e-01f,
  7.20241964e-02f, -3.72060463e-02f, -9.18191969e-02f, 7.55972937e-02f, -1.76974356e-01f, 9.55890119e-02f, -1.27870783e-01f, -1.60079166e-01f, -8.60267356e-02f, -3.03229272e-01f,
  -1.78504542e-01f, -2.49200270e-01f, 1.05853073e-01f, 7.11866319e-02f, 9.28959772e-02f, -4.65487689e-02f, -6.63841143e-02f, -3.68853398e-02f, -4.41668257e-02f, -3.34241129e-02f,
  7.89270997e-02f, -1.15152709e-01f, -3.33707477e-03f, -8.92686564e-03f, -1.13399133e-01f, -1.52628782e-05f, -8.95343497e-02f, -1.33898884e-01f, -9.98822525e-02f, -1.03752278e-01f,
  1.14580967e-01f, 3.09280232e-02f, -7.03647658e-02f, -4.50625792e-02f, 7.05403090e-02f, 4.43173721e-02f, -1.24710813e-01f, -3.68368216e-02f, -1.18292116e-01f, -2.21544206e-01f,
  -7.95262307e-02f, 4.35775891e-02f, 8.61292183e-02f, -3.52742411e-02f, -1.22707905e-02f, 6.36905059e-03f, -3.32050957e-02f, -4.91219684e-02f, 1.27675980e-01f, -4.13126834e-02f,
  8.00524130e-02f, -7.62995780e-02f, 5.20104952e-02f, -8.05422366e-02f, 5.80334365e-02f, -3.46361548e-02f, -8.06765165e-03f, 7.61128440e-02f, 1.95835624e-02f, -3.49791721e-02f,
  -1.56090027e-02f, 6.91100731e-02f, -2.00143531e-02f, 2.50009540e-02f, 6.93002045e-02f, -6.70244172e-03f, -8.62198137e-03f, -2.93679163e-03f, 4.60718237e-02f, -5.02362773e-02f,
  4.81148846e-02f, 6.35827258e-02f, -1.41948968e-01f, -1.43594518e-02f, -4.69573811e-02f, -4.46958132e-02f, -2.42738929e-02f, 3.72766098e-03f, -4.83568795e-02f, -3.78042348e-02f,
  -6.30610585e-02f, 3.16430740e-02f, -9.00029689e-02f, 4.60874438e-02f, 5.72538488e-02f, -4.19455692e-02f, -9.66294110e-03f, -7.01237703e-03f, 6.32178970e-03f, -5.08374013e-02f,
  -4.79285605e-02f, -9.10727978e-02f, -3.61924618e-02f, -1.23188838e-01f, 1.75189488e-02f, 4.04009894e-02f, -1.24145709e-01f, -2.55291350e-02f, 3.84854786e-02f, -1.90632015e-01f,
  -5.47132373e-01f, -2.89063931e-01f, -4.03675325e-02f, -2.05395326e-01f, -5.07864030e-03f, 2.42254853e-01f, 2.65609115e-01f, 1.44655660e-01f, 1.44851757e-02f, -1.31601334e-01f,
  -3.69733013e-02f, 4.27035317e-02f, -3.96391004e-03f, 2.20297240e-02f, 7.27811679e-02f, 1.97168216e-01f, 2.94453744e-02f, -3.53822000e-02f, 1.95356637e-01f, 1.51557311e-01f,
  1.84758127e-01f, -8.17114189e-02f, -1.14108175e-01f, -2.47561615e-02f, -8.03304464e-02f, 3.27548943e-02f, -1.69624269e-01f, -2.13238508e-01f, -1.12785488e-01f, -1.83649078e-01f,
  -1.05859421e-01f, -2.92672604e-01f, 1.72565013e-01f, -5.67627065e-02f, -1.01243317e-01f, 6.07927749e-03f, 5.00359684e-02f, -3.74454483e-02f, 5.91149628e-02f, 6.62283972e-02f,
  -4.85476032e-02f, -6.45957515e-02f, -1.27341377e-03f, -5.04523590e-02f, 4.09893431e-02f, -2.92872973e-02f, -2.30985750e-02f, -6.74801245e-02f, 4.35321070e-02f, 3.94186052e-03f,
  1.01530373e-01f, -2.24496536e-02f, -1.02258310e-01f, 4.99094985e-02f, 4.58376147e-02f, -2.15184130e-02f, 1.44579913e-02f, 4.17989306e-02f, -6.31945133e-02f, -1.42338455e-01f,
  1.22043259e-01f, -1.08060293e-01f, -8.70379955e-02f, -5.22542233e-03f, -4.68655266e-02f, 1.04344599e-02f, 3.24335042e-03f, 1.61514934e-02f, 7.53326714e-02f, 2.97785178e-02f,
  -2.38002297e-02f, -3.36708762e-02f, 5.80603927e-02f, -8.32306072e-02f, 3.94866653e-02f, -6.18414395e-02f, -1.69464238e-02f, -4.04311158e-02f, -8.75101015e-02f, -4.33022864e-02f,
  -4.35548387e-02f, 2.34852321e-02f, -7.33312145e-02f, -4.55376208e-02f, 3.19898338e-03f, 3.78057484e-05f, -2.15568487e-02f, -5.75329475e-02f, 6.01888783e-02f, -2.30906885e-02f,
  7.78326839e-02f, 4.92722616e-02f, 2.94907019e-02f, 9.74793807e-02f, -6.97073936e-02f, -1.02104498e-02f, -4.11321409e-02f, 2.42875759e-02f, -2.05193907e-02f, 8.84871408e-02f,
  1.02984928e-01f, -4.04139683e-02f, -4.68978807e-02f, 5.34156635e-02f, 9.30930376e-02f, 9.07922015e-02f, 9.30519477e-02f, 3.95698585e-02f, 8.87313485e-02f, 9.81066655e-03f,
  -1.99899636e-02f, 2.21212447e-01f, 1.24816768e-01f, 5.73082939e-02f, 5.26858540e-03f, 7.33327866e-02f, 1.77861556e-01f, 1.83827341e-01f, 1.11200042e-01f, 7.13841617e-02f,
  -3.63730669e-01f, 1.20611526e-01f, -2.86543995e-01f, -1.58973113e-01f, 2.20666602e-01f, 1.19556881e-01f, 7.87434578e-02f, 1.83574911e-02f, 1.91029925e-02f, 1.93186238e-01f,
  1.86028108e-01f, 1.87770009e-01f, 1.27854094e-01f, -3.27705145e-02f, -1.12671636e-01f, 8.89897048e-02f, -2.32534949e-04f, -3.27433139e-01f, -2.59843498e-01f, -2.55847331e-02f,
  1.88901469e-01f, -1.33653179e-01f, -1.75338104e-01f, -1.62838340e-01f, 1.39316544e-01f, 8.86589810e-02f, 2.71912422e-02f, 2.99240313e-02f, 1.71206575e-02f, 1.94228694e-01f,
  1.34581685e-01f, -1.36287794e-01f, 5.67566454e-02f, 4.60725762e-02f, -4.10789996e-02f, -2.80464496e-02f, 8.05472489e-03f, -1.56209946e-01f, -3.59688662e-02f, -4.30134311e-02f,
  1.02154240e-02f, 1.23457545e-02f, 7.44313523e-02f, 1.86152980e-02f, 4.22085896e-02f, 5.03500551e-02f, -1.35560764e-03f, -1.97746858e-01f, -3.24518047e-02f, 4.78802100e-02f,
  6.85804859e-02f, -5.35463216e-04f, -1.21323578e-01f, -1.01238042e-01f, -1.17911018e-01f, -5.43198735e-02f, -2.46134382e-02f, -1.51754413e-02f, -1.31692052e-01f, -7.00837001e-02f,
  1.90315004e-02f, -1.04669832e-01f, 4.85216565e-02f, -2.52700131e-02f, 7.64851400e-04f, -1.02978028e-01f, -5.78910392e-03f, 2.40249746e-02f, -3.81625071e-02f, -7.11399019e-02f,
  -9.78636928e-03f, 5.37775643e-02f, 2.33873329e-03f, 7.19323233e-02f, 9.06413049e-02f, -2.94244080e-03f, 1.80222522e-02f, 6.57461733e-02f, -2.64222119e-02f, 2.28691138e-02f,
  -1.28656337e-02f, -3.26704010e-02f, 3.97364683e-02f, 2.75769439e-02f, 6.89036995e-02f, 5.98512664e-02f, 1.01722265e-02f, -1.12982383e-02f, 4.70025651e-02f, 7.43021164e-03f,
  1.73888490e-01f, 3.56146656e-02f, 8.00402388e-02f, 2.37466022e-02f, -4.90073301e-02f, -4.69951570e-04f, 9.66881029e-03f, -1.69985334e-03f, 7.90180266e-02f, 7.95388892e-02f,
  2.12659575e-02f, 1.89667251e-02f, 6.41326606e-02f, 3.67518864e-03f, -4.18711826e-02f, 6.28741682e-02f, 1.12730362e-01f, 3.56486589e-02f, -2.52489001e-02f, 6.58210218e-02f,
  6.07404672e-03f, -1.06838904e-01f, -6.81000873e-02f, 3.70574556e-02f, -3.31356600e-02f, 7.21046627e-02f, 8.23516457e-04f, 9.05743241e-02f, -8.47161785e-02f, 1.54155437e-02f,
  2.24396572e-01f, -2.92761087e-01f, 1.75886095e-01f, -1.05581984e-01f, -1.37649119e-01f, -9.68023017e-02f, -2.61063486e-01f, 2.66549569e-02f, -1.01147495e-01f, -1.23126447e-01f,
  -5.09873927e-02f, 9.27855298e-02f, 1.60086125e-01f, 1.59543440e-01f, 2.53280610e-01f, -2.13945583e-01f, -6.36998117e-02f, 2.25170806e-01f, 3.89673263e-01f, 1.88835502e-01f,
  -1.13250762e-01f, -7.19901174e-02f, 9.91786271e-02f, 5.40594123e-02f, -1.91435799e-01f, 5.79912961e-02f, -9.95969698e-02f, -1.96107244e-03f, -1.31920790e-02f, -1.58223569e-01f,
  2.05720335e-01f, 1.68793723e-01f, 1.55650407e-01f, 1.11821435e-01f, -6.11103922e-02f, 1.08600982e-01f, 7.54534677e-02f, -3.92490961e-02f, 1.21868029e-02f, 1.69059504e-02f,
  4.68147360e-02f, 6.75956234e-02f, 9.55933705e-02f, -2.45177653e-02f, 3.80537026e-02f, 7.00431690e-02f, 1.30360257e-02f, 2.23979838e-02f, 7.35057592e-02f, -4.23704237e-02f,
  -8.28177556e-02f, 4.58635911e-02f, 1.31358758e-01f, -3.37915048e-02f, 1.21567413e-01f, 1.47824615e-01f, -7.30761066e-02f, 5.40988892e-02f, 6.33483976e-02f, -4.53539155e-02f,
  2.30513513e-02f, 1.00678615e-02f, -5.22476844e-02f, -4.42932174e-02f, 4.95823519e-03f, -3.56825814e-02f, -1.91152766e-02f, -9.20700580e-02f, 5.55948578e-02f, -1.11900464e-01f,
  4.17885557e-02f, -1.43723665e-02f, -2.93148849e-02f, -7.23021198e-03f, -7.71995038e-02f, 3.73241752e-02f, 9.73784998e-02f, 1.66482152e-03f, 4.36779261e-02f, 4.59817145e-03f,
  2.90554445e-02f, -1.97614934e-02f, -1.95863638e-02f, 1.53312571e-02f, -2.43747607e-03f, 3.40295769e-02f, 2.50196997e-02f, -5.98990731e-03f, -7.20539391e-02f, -4.44101542e-02f,
  -3.76561992e-02f, 3.31635214e-02f, -9.38670803e-03f, 6.59943745e-02f, 3.50281596e-02f, -2.97401734e-02f, 2.04398818e-02f, 5.10140206e-04f, 1.24490988e-02f, 9.00425091e-02f,
  2.87491661e-02f, 7.55901635e-02f, 3.13087329e-02f, 2.40359269e-02f, 1.31012782e-01f, 5.61123888e-04f, -9.21769887e-02f, 7.21767396e-02f, -6.11667261e-02f, 2.31632534e-02f,
  -9.12698433e-02f, -5.53753078e-02f, 3.63550708e-02f, -9.43988040e-02f, 2.75385473e-03f, 1.31000981e-01f, -9.05714743e-03f, -8.22524168e-03f, 6.36029765e-02f, -2.59978950e-01f,
  -2.53309995e-01f, 3.41645420e-01f, 3.03495139e-01f, -2.19473362e-01f, -4.49839495e-02f, -2.31880881e-02f, 8.84811506e-02f, -1.49492742e-02f, -1.74970910e-01f, 1.35600492e-02f,
  1.04100309e-01f, -4.97328416e-02f, 5.93007766e-02f, 1.27125114e-01f, 2.78736390e-02f, 7.33598694e-02f, 3.37744653e-02f, 2.33209040e-02f, -5.80629446e-02f, -1.53869346e-01f,
  -9.51970816e-02f, -5.08247651e-02f, -4.70492318e-02f, 4.04443257e-02f, 4.41788621e-02f, -1.33677796e-01f, 5.94995432e-02f, 7.10996464e-02f, 1.72582328e-01f, 9.20646042e-02f,
  2.33182102e-01f, 2.47336581e-01f, -6.34437203e-02f, -4.41073850e-02f, 8.55341628e-02f, -5.01723588e-02f, 4.48575331e-04f, 1.36559224e-02f, -6.54616430e-02f, 3.28721106e-02f,
  8.68261606e-02f, 7.28621185e-02f, 5.64813130e-02f, -1.79486349e-02f, 5.60301207e-02f, -6.86294958e-02f, 1.44249082e-01f, -2.89298296e-02f, 8.00328329e-02f, -1.19610140e-02f,
  1.94421969e-02f, 8.77615213e-02f, 2.23775338e-02f, -1.69723239e-02f, 7.50211254e-02f, -6.14425801e-02f, 6.54302537e-02f, 1.07824236e-01f, 9.76027027e-02f, -5.70551194e-02f,
  -3.57001685e-02f, 1.24949170e-02f, 5.02035208e-02f, 4.90585305e-02f, -9.40391123e-02f, 2.29901052e-03f, -9.93987342e-05f, -3.98964286e-02f, -6.31989017e-02f, -7.37222433e-02f,
  1.15471266e-01f, -8.59277248e-02f, 8.87064636e-02f, -3.63555066e-02f, 3.66384648e-02f, 4.59119380e-02f, 3.64590362e-02f, 2.43790802e-02f, 6.83227554e-02f, -4.85133119e-02f,
  3.57314851e-03f, -3.01014893e-02f, -9.63321608e-03f, 2.57233363e-02f, -3.95445060e-03f, 5.35501130e-02f, -2.41101999e-02f, 4.99662571e-02f, -7.58249611e-02f, -6.07873313e-02f,
  -1.56650901e-01f, 6.44527003e-02f, -3.07623087e-03f, 2.23313142e-02f, 4.07301150e-02f, 3.53862792e-02f, 2.25474816e-02f, -2.34531425e-02f, 8.79516080e-02f, 2.30500251e-02f,
  -1.42137818e-02f, 5.30708507e-02f, 3.75849567e-02f, 2.62546837e-02f, -6.43806979e-02f, -4.54280116e-02f, 9.88797918e-02f, 7.81582817e-02f, 6.47761077e-02f, 6.70847371e-02f,
  2.80866176e-02f, -1.20191745e-01f, -1.20183527e-01f, -2.05449909e-02f, 5.61758988e-02f, -1.68887064e-01f, -1.75297204e-02f, -4.44056354e-02f, -1.59307495e-01f, -2.42449656e-01f,
  2.00573623e-01f, -5.22501916e-02f, 2.00482503e-01f, 3.07869643e-01f, 2.88739383e-01f, 2.21037865e-01f, 4.08906303e-02f, 6.86269403e-02f, 1.00080334e-01f, 4.95858528e-02f,
  2.54101232e-02f, 1.56816635e-02f, 1.50941923e-01f, -3.75187397e-02f, 7.32276216e-02f, 1.18815191e-01f, 2.24394783e-01f, 1.66518256e-01f, 1.84170604e-01f, 2.81962693e-01f,
  4.64502759e-02f, 2.53083318e-01f, 2.48019293e-01f, 1.70380354e-01f, 5.22570424e-02f, 7.18342289e-02f, 1.33040026e-01f, 2.46152416e-01f, 1.46181703e-01f, 9.15361419e-02f,
  2.43825659e-01f, 1.22099027e-01f, 3.99994606e-04f, -6.72273636e-02f, 6.55548973e-03f, 7.67281605e-03f, 1.91303696e-02f, 2.33040489e-02f, 4.19191159e-02f, -3.41755780e-03f,
  8.06533992e-02f, 6.64561167e-02f, 1.19634017e-01f, 7.58461654e-02f, 4.76347655e-02f, 1.65630892e-01f, -3.73455137e-02f, 1.28348365e-01f, 3.90798077e-02f, 4.53748666e-02f,
  6.25635758e-02f, 3.62315811e-02f, 2.22879842e-01f, -2.14198567e-02f, 1.46514907e-01f, 1.20243102e-01f, 4.13251445e-02f, 9.45890695e-02f, 4.56654839e-02f, 5.72978035e-02f,
  4.15856242e-02f, -9.84018967e-02f, -7.56977051e-02f, -2.78658196e-02f, -9.07697007e-02f, -2.52651311e-02f, -1.02382101e-01f, -5.04890643e-02f, -5.26676793e-03f, -1.61788955e-01f,
  -8.24551210e-02f, -4.73754182e-02f, -7.36902282e-02f, 2.05590501e-02f, -2.91572325e-02f, 9.48786642e-03f, -1.51369229e-01f, -1.26793668e-01f, -9.18680578e-02f, -5.22871092e-02f,
  1.10189449e-02f, -8.08979571e-02f, -5.55963591e-02f, -1.36962235e-01f, -3.92153375e-02f, -8.57046023e-02f, -1.77023020e-02f, -6.78733140e-02f, -5.37464730e-02f, -7.49147162e-02f,
  2.03064129e-01f, 4.96525764e-02f, -2.50000414e-03f, -3.70304510e-02f, 6.41065277e-03f, -3.83360423e-02f, -2.86254119e-02f, 7.50719709e-03f, 9.74768996e-02f, 1.60456479e-01f,
  4.97127064e-02f, -4.74032015e-03f, 1.03209473e-01f, 3.01796943e-02f, 1.66991025e-01f, 4.39561643e-02f, 6.57750666e-02f, 2.19503064e-02f, -8.89762938e-02f, 3.12112235e-02f,
  -4.22157869e-02f, 6.74674362e-02f, 8.06740373e-02f, 2.22625621e-02f, -2.42656898e-02f, 6.17970526e-02f, 8.78995210e-02f, 9.30025429e-02f, -7.24420324e-02f, -1.25836423e-02f,
  1.16201997e-01f, -2.58037955e-01f, -1.29598930e-01f, -1.36893436e-01f, -1.23161778e-01f, -5.56690581e-02f, -1.43399090e-01f, 2.45140195e-02f, 2.41691303e-02f, -1.96482912e-01f,
  -1.23602726e-01f, -9.92041528e-02f, 6.63797706e-02f, 4.90795122e-03f, 8.00065175e-02f, -5.01726121e-02f, -6.67084614e-03f, 1.74801290e-01f, 2.23865286e-01f, 1.57165766e-01f,
  -8.46124589e-02f, -5.55376299e-02f, 8.19582492e-02f, 4.95269485e-02f, -1.73187688e-01f, -1.59844667e-01f, -1.71530619e-01f, -1.98883846e-01f, -2.24859700e-01f, -1.72278941e-01f,
  4.02385034e-02f, -1.73244387e-01f, -5.58151193e-02f, -2.03277290e-01f, -1.74924210e-01f, -6.75773397e-02f, -4.77057472e-02f, -7.90296122e-02f, -2.06833959e-01f, -1.46256059e-01f,
  -2.59612858e-01f, -7.16581717e-02f, -1.63105696e-01f, -1.82880908e-01f, -9.95166674e-02f, -1.85954332e-01f, -1.71555221e-01f, -1.45066017e-02f, -4.73044477e-02f, -8.11326206e-02f,
  -1.72097817e-01f, -2.73472309e-01f, -2.41946623e-01f, -2.47810528e-01f, -7.01465234e-02f, -1.40310034e-01f, -1.36915907e-01f, -1.88667849e-01f, -1.47801369e-01f, -2.50065595e-01f,
  9.98641327e-02f, 5.33204228e-02f, 4.01839912e-02f, 1.57595463e-02f, 1.31197929e-01f, 1.80613939e-02f, 1.21728323e-01f, 6.58295080e-02f, 4.05861996e-02f, 7.97292292e-02f,
  9.41380560e-02f, 1.50905252e-01f, 6.75091147e-02f, 1.29081756e-01f, 8.44095424e-02f, 4.58188541e-02f, 3.98981161e-02f, 1.12347096e-01f, 1.16532110e-01f, 6.72383606e-02f,
  1.06887802e-01f, 4.52550612e-02f, 2.90592220e-02f, 1.61314741e-01f, 3.26435044e-02f, 9.84844267e-02f, 7.31674805e-02f, 1.16402112e-01f, 5.01305349e-02f, 8.19266494e-03f,
  -1.72605664e-01f, -1.26158772e-02f, -8.48398730e-02f, -3.20761725e-02f, -1.16351165e-01f, -2.26799428e-01f, -1.92840278e-01f, -1.45003155e-01f, -1.21791676e-01f, -1.85084313e-01f,
  -1.01603925e-01f, -1.82656609e-02f, -1.30916417e-01f, -1.93052992e-01f, -1.59640193e-01f, -8.07952732e-02f, -1.65626079e-01f, -7.24681839e-02f, -2.41633669e-01f, -2.27737367e-01f,
  -2.13719130e-01f, -1.96236745e-02f, -1.04529627e-01f, -8.68025646e-02f, -1.25880331e-01f, 8.37148726e-03f, -9.30174887e-02f, -2.06861600e-01f, -5.67774139e-02f, -1.18007548e-01f,
  2.86753833e-01f, -1.38198927e-01f, -2.30329916e-01f, 2.01653112e-02f, -2.13695332e-01f, -1.82597890e-01f, -9.09065530e-02f, -2.51276661e-02f, -4.11022305e-02f, -2.80625205e-02f,
  -1.00491248e-01f, 3.19755711e-02f, -1.51445642e-01f, -1.00210749e-01f, -1.34652834e-02f, -1.60356238e-01f, -2.33834922e-01f, -6.74501285e-02f, 1.31893028e-02f, -6.92020953e-02f,
  -8.82539451e-02f, 3.44821773e-02f, 1.58256292e-01f, 1.00013101e-02f, -5.87703250e-02f, -3.12162396e-02f, -1.68723702e-01f, -2.70720236e-02f, -1.71153083e-01f, -6.51780590e-02f,
  -1.21128649e-01f, 2.70252489e-02f, -1.80979043e-01f, 2.67818216e-02f, -3.67728956e-02f, 5.15532196e-02f, -2.35061236e-02f, -6.46188855e-02f, 4.83217686e-02f, -4.03861627e-02f,
  -6.01246133e-02f, -3.94948199e-02f, -4.71976586e-02f, -3.64158191e-02f, 5.38700633e-02f, 2.76835989e-02f, -6.22759238e-02f, -1.82947039e-03f, -1.28326997e-01f, 4.60212044e-02f,
  -1.33820862e-01f, -2.00683717e-02f, 6.07250165e-03f, -1.31588146e-01f, -8.57396871e-02f, -1.35230631e-01f, 1.38976369e-02f, 5.80602102e-02f, -1.09394051e-01f, 6.80763125e-02f,
  1.01423599e-01f, 8.50188285e-02f, 8.54127482e-02f, 9.91846845e-02f, 1.62418738e-01f, 9.15080830e-02f, 5.79360276e-02f, 1.87888462e-02f, 1.26339749e-01f, 1.67413384e-01f,
  1.80566162e-01f, 1.04568833e-02f, 1.18248783e-01f, 4.94704116e-03f, 4.39766049e-02f, -1.10815773e-02f, 1.92763824e-02f, 7.31373131e-02f, 7.69889355e-02f, 1.13207430e-01f,
  7.19612986e-02f, 1.29905030e-01f, 4.70220335e-02f, 7.80857280e-02f, -2.13678330e-02f, 8.27889075e-04f, 9.79103521e-02f, 5.51481843e-02f, 1.25805840e-01f, 3.74192148e-02f,
  3.14298272e-02f, -1.88950464e-01f, 1.33948810e-02f, -4.43314835e-02f, -6.95625544e-02f, -3.30771916e-02f, -4.72533740e-02f, -3.97585742e-02f, -8.85175467e-02f, -8.41757501e-05f,
  -3.47001068e-02f, 4.76641506e-02f, -3.59066837e-02f, -6.59533516e-02f, -3.65640000e-02f, -8.68008584e-02f, -5.29115051e-02f, -1.70659140e-01f, -1.12440109e-01f, -7.91095272e-02f,
  6.73180865e-03f, -1.73737202e-02f, -2.25195698e-02f, -4.59629670e-02f, -1.96892448e-04f, -1.42026410e-01f, -3.32284942e-02f, -9.60199311e-02f, -3.60741615e-02f, -9.18252859e-03f,
  -3.48093808e-01f, -9.98656675e-02f, -4.06402871e-02f, 6.51157871e-02f, 1.33985803e-01f, 2.20341310e-02f, -2.23507300e-01f, -4.84694280e-02f, 1.25906453e-01f, 1.02795564e-01f,
  2.81190902e-01f, 2.19486639e-01f, 2.01122493e-01f, 4.89860401e-02f, -1.12676643e-01f, -1.53382599e-01f, -9.47421566e-02f, 1.87805183e-02f, 9.05228555e-02f, 7.12834299e-02f,
  2.37442389e-01f, 1.30459309e-01f, -2.04273500e-02f, 1.24107853e-01f, 6.28701523e-02f, 2.77504832e-01f, 7.17295185e-02f, 1.22057185e-01f, 1.92232415e-01f, 5.57199828e-02f,
  1.17807634e-01f, -1.26346871e-01f, 8.33213478e-02f, 5.52715361e-02f, 1.82147354e-01f, -4.24428697e-04f, 1.16038069e-01f, 4.54765558e-02f, 7.21612722e-02f, 1.89656630e-01f,
  1.23243131e-01f, 1.43875644e-01f, 1.55715525e-01f, 1.24822639e-01f, 5.50787263e-02f, 1.85230076e-02f, 6.99417070e-02f, -8.69428646e-03f, 7.95840919e-02f, 9.32767093e-02f,
  2.30275989e-01f, 9.40118358e-02f, 8.61674324e-02f, 1.15735412e-01f, 9.07009747e-03f, 1.71782732e-01f, 1.74413934e-01f, 1.80188805e-01f, 1.75391227e-01f, -1.32294269e-02f,
  -2.61766948e-02f, 1.68041587e-02f, -1.11788698e-01f, -1.18110999e-01f, -6.39347881e-02f, -6.99731410e-02f, -8.00939053e-02f, -9.90829095e-02f, -6.85586734e-03f, -2.71880589e-02f,
  -6.35942146e-02f, -8.12903792e-02f, -3.34559344e-02f, 5.79695068e-02f, -9.54935253e-02f, 1.40740313e-02f, -4.37580078e-04f, -2.62022726e-02f, -9.86789819e-03f, -7.48581439e-02f,
  1.49174798e-02f, -9.00542289e-02f, -1.14256265e-02f, -4.42329654e-03f, -7.94905126e-02f, -9.12863687e-02f, -5.21973781e-02f, -6.29017651e-02f, -5.68386689e-02f, -1.29449209e-02f,
  1.52349606e-01f, 2.27498993e-01f, 7.71679208e-02f, -5.13595976e-02f, 4.59349118e-02f, 9.30979773e-02f, 4.71717305e-02f, -1.60624254e-02f, 7.86356926e-02f, -2.79756244e-02f,
  1.34744216e-02f, -1.08705133e-01f, 9.62122157e-02f, 2.63486747e-02f, 7.53485411e-02f, 2.15586298e-03f, -2.89655086e-02f, -6.70761093e-02f, 1.19211070e-01f, -1.75391568e-03f,
  8.59212503e-02f, -1.62842013e-02f, -8.08306038e-02f, -1.16499841e-01f, 2.96280291e-02f, -6.07892759e-02f, 3.99948061e-02f, 3.17632891e-02f, -9.04051308e-03f, -3.85597646e-02f,
  1.68219328e-01f, 3.77158187e-02f, -3.05475891e-01f, 2.26135664e-02f, -2.45839655e-02f, 4.88944128e-02f, 2.31032539e-02f, 2.36550644e-02f, -6.14799149e-02f, -1.00108450e-02f,
  -2.50651300e-01f, -3.74130607e-01f, -2.36632258e-01f, -2.52469718e-01f, -1.95212945e-01f, 1.77488327e-02f, 6.60711946e-03f, -6.55235797e-02f, -1.65980294e-01f, -1.57117605e-01f,
  -9.59354360e-03f, 1.08595461e-01f, 1.05943814e-01f, -1.14711812e-02f, 1.93006862e-02f, -2.08527505e-01f, -1.57851070e-01f, -1.28965765e-01f, -1.38243288e-01f, -5.61461337e-02f,
  -3.37891132e-01f, -9.09579024e-02f, -1.33465052e-01f, -9.82457027e-02f, -1.77763373e-01f, -7.19740614e-02f, -1.73448265e-01f, 1.64364353e-02f, -1.45697087e-01f, 1.52589916e-03f,
  -1.75133020e-01f, -3.57325524e-02f, -1.38093144e-01f, -8.45403522e-02f, 3.59025784e-02f, -3.78875062e-02f, 3.48470197e-03f, -9.03753042e-02f, -7.45589137e-02f, -2.01264173e-01f,
  -1.49241954e-01f, -8.65195170e-02f, -2.03743786e-01f, -1.66229978e-01f, -3.88538167e-02f, -1.82441518e-01f, -1.80984616e-01f, -1.56004444e-01f, -4.62308824e-02f, 1.84615739e-02f,
  -1.39126666e-02f, -9.37597752e-02f, 9.30118561e-03f, 6.21951781e-02f, -3.18172202e-02f, 2.13829204e-02f, 3.52082849e-02f, -2.04893705e-02f, -2.31841691e-02f, 1.10933021e-01f,
  -3.04194237e-03f, -6.49964884e-02f, 4.73503694e-02f, 5.39795458e-02f, 1.06874621e-02f, -1.48977302e-02f, 2.44539678e-02f, 5.10610603e-02f, 6.60202354e-02f, 5.23689091e-02f,
  4.40074988e-02f, -1.84238236e-02f, 1.03346214e-01f, -9.36015695e-03f, 1.01371214e-01f, -3.47456075e-02f, -2.08851639e-02f, -3.68128642e-02f, 6.32029995e-02f, -3.18467640e-03f,
  -2.28264239e-02f, -1.54211372e-01f, -9.83998477e-02f, 2.77810190e-02f, 7.26417033e-03f, -6.71144575e-03f, 1.66350920e-02f, 3.90657195e-04f, 2.31078360e-02f, -8.60047061e-03f,
  -1.08932264e-01f, 3.31614129e-02f, 1.57815982e-02f, -6.32816106e-02f, -9.97691974e-02f, -9.99337286e-02f, 6.82667419e-02f, -6.19808547e-02f, -6.20514378e-02f, -9.58462805e-02f,
  2.87268572e-02f, -5.67806177e-02f, 5.07273618e-03f, -1.21238850e-01f, -6.34015501e-02f, -3.10063083e-02f, -8.37583095e-02f, -1.25214651e-01f, -9.63420793e-03f, 2.98899207e-02f,
  2.50519276e-01f, 1.84742976e-02f, 1.47186637e-01f, 6.42112568e-02f, -2.34963521e-01f, -2.73276031e-01f, -2.84099489e-01f, -7.29527622e-02f, -1.06954761e-01f, -1.51994890e-02f,
  -1.45989191e-02f, 6.47924021e-02f, 1.53870404e-01f, 1.21213213e-01f, 1.54278263e-01f, -4.59942035e-02f, -2.39219284e-03f, 1.39496535e-01f, 4.46407450e-03f, -2.36724019e-01f,
  -1.93762794e-01f, 3.03022396e-02f, 1.46383241e-01f, -1.65335219e-02f, -1.17754057e-01f, 2.71374322e-02f, 4.06290293e-02f, 3.81218493e-02f, -1.82383940e-01f, 6.85241669e-02f,
  1.59237459e-01f, 6.99138045e-02f, -3.58626619e-03f, 9.56225861e-03f, -7.00345784e-02f, 2.19291970e-02f, -4.43604663e-02f, 6.95457160e-02f, -1.11604676e-01f, -6.26388425e-03f,
  -3.78326662e-02f, -9.49933901e-02f, 5.07571883e-02f, -3.43283266e-03f, -2.83308644e-02f, 7.60435034e-03f, 3.24863344e-02f, 2.01962423e-02f, 5.77514544e-02f, 3.89611423e-02f,
  -1.65916211e-03f, -1.71347126e-01f, -9.83257368e-02f, -1.46179467e-01f, -4.03850749e-02f, -7.46867657e-02f, -4.55963686e-02f, -4.61309217e-02f, 6.57488927e-02f, -1.88890267e-02f,
  -6.01735078e-02f, 3.12977433e-02f, 2.44343933e-02f, 1.48501927e-02f, -1.54609233e-03f, -3.05503700e-02f, 7.88828656e-02f, 5.74621512e-03f, -2.46338714e-02f, 1.11713558e-01f,
  6.48479834e-02f, -4.84756157e-02f, -1.48257772e-02f, 5.01944683e-02f, 5.63165657e-02f, -6.68709651e-02f, 5.83370663e-02f, -1.29617034e-02f, 9.24132317e-02f, 8.87733474e-02f,
  -9.75423586e-03f, 7.53340051e-02f, 6.27427921e-02f, 2.05272436e-02f, 8.44513327e-02f, -5.85146472e-02f, -2.91818976e-02f, 3.00591886e-02f, -2.75613321e-03f, -5.18888310e-02f,
  9.99953449e-02f, 6.76943660e-02f, 4.46774922e-02f, 2.95943264e-02f, -5.29578291e-02f, 6.84610754e-02f, 1.54296327e-02f, 3.36052701e-02f, 3.07286792e-02f, -6.91184253e-02f,
  -1.43765109e-02f, -7.27124512e-02f, 5.66628948e-02f, -6.65612519e-02f, -1.04222380e-01f, -1.03564456e-01f, -1.28997136e-02f, 2.05947226e-03f, -7.91426748e-02f, -9.48355123e-02f,
  -4.39020246e-02f, -1.32435128e-01f, -1.19183287e-02f, -9.61014477e-04f, -4.57207039e-02f, -1.80299990e-02f, -2.12602243e-02f, 3.82835791e-03f, -4.27094754e-03f, -5.51171340e-02f,
  -3.65711033e-01f, -2.48010516e-01f, -1.43670365e-01f, -1.88047707e-01f, -1.41435847e-01f, 1.91298071e-02f, -1.32644102e-01f, 3.39383967e-02f, 8.37496966e-02f, -1.89217180e-01f,
  -1.28057823e-01f, 3.10757104e-02f, 2.16214254e-01f, 9.33774114e-02f, 1.15686260e-01f, -8.60395208e-02f, -9.14013609e-02f, -3.13912258e-02f, 6.15918078e-02f, -8.85665268e-02f,
  -1.53929099e-01f, -4.49121222e-02f, 5.78152016e-02f, 3.50134335e-02f, -4.70065996e-02f, -6.36441959e-03f, -1.39594935e-02f, -1.25498295e-01f, 1.21102482e-02f, -2.65214771e-01f,
  -1.86946929e-01f, -2.22843423e-01f, 1.25638664e-01f, -5.29390834e-02f, -2.58825589e-02f, 1.32216975e-01f, -1.23694586e-02f, -7.41649279e-03f, 3.86453122e-02f, -6.14778176e-02f,
  -1.26415268e-01f, 1.93696897e-02f, 3.25261950e-02f, 4.03120518e-02f, -2.60774642e-02f, -2.85164714e-02f, -3.24503630e-02f, 5.59025183e-02f, 4.89404425e-02f, -3.44057456e-02f,
  -1.00499801e-01f, -1.96872756e-01f, -1.38417721e-01f, 3.56016420e-02f, 8.07273313e-02f, 5.64300381e-02f, 1.11552561e-02f, 2.71812063e-02f, 1.22635767e-01f, -1.67462438e-01f,
  1.52504323e-02f, 4.14789058e-02f, 1.02163643e-01f, 4.80462313e-02f, 8.00277740e-02f, 1.88673884e-02f, 8.68064165e-02f, -6.99721947e-02f, -2.45321803e-02f, 6.59768358e-02f,
  1.21123284e-01f, -6.43321255e-04f, 2.46559698e-02f, -5.73056936e-02f, 6.89901486e-02f, -7.90175349e-02f, -1.91138443e-02f, -2.45278385e-02f, 3.99833992e-02f, 1.03709653e-01f,
  3.73176709e-02f, 5.73901795e-02f, -6.77309185e-02f, 9.83940437e-02f, -1.25599103e-02f, 7.46094733e-02f, -3.78600284e-02f, 2.75928481e-03f, 7.60065615e-02f, -3.73033397e-02f,
  1.03657156e-01f, 1.51370898e-01f, -6.02625273e-02f, -7.58542940e-02f, -8.43717754e-02f, -4.25193198e-02f, -9.09424275e-02f, 1.14707127e-02f, -6.00796975e-02f, -4.34519462e-02f,
  -7.81667009e-02f, -1.27057180e-01f, 1.29727824e-02f, -1.49910664e-02f, -4.14851978e-02f, -1.13765039e-02f, -1.09887466e-01f, -5.73079288e-03f, -5.08552343e-02f, -1.08201608e-01f,
  9.37404782e-02f, -1.07267924e-01f, -1.34345844e-01f, 1.16718439e-02f, 1.11153387e-02f, -2.94592362e-02f, 3.20231803e-02f, -1.09329307e-02f, 3.45026180e-02f, 5.04996255e-02f,
  2.89874434e-01f, -1.28593415e-01f, 9.06821713e-02f, 1.75591946e-01f, 2.45249957e-01f, 2.05073804e-01f, 9.39291418e-02f, 1.58981994e-01f, 1.59205765e-01f, 6.13588393e-02f,
  -1.53535828e-01f, -1.75503016e-01f, -1.43833145e-01f, -9.16691720e-02f, 1.46064654e-01f, 1.12335131e-01f, 1.26739666e-01f, 2.11741239e-01f, 2.17332825e-01f, 2.04025611e-01f,
  -3.04635870e-03f, 7.85316601e-02f, 8.29406381e-02f, 8.93980637e-02f, -2.78004706e-02f, 5.02151474e-02f, -5.92056662e-02f, -4.59522940e-02f, 3.96828912e-02f, -3.06933019e-02f,
  -3.99723984e-02f, 8.36533234e-02f, -9.29276273e-02f, -3.03326212e-02f, -1.36477113e-01f, -8.86176899e-02f, -1.01852842e-01f, -8.54443908e-02f, -3.93202007e-02f, -1.15370490e-01f,
  -6.78507611e-02f, -1.12829342e-01f, -8.69570449e-02f, -2.08459254e-02f, 6.66115135e-02f, -3.72941419e-02f, -3.56244966e-02f, 3.38044344e-03f, 3.25953681e-03f, -6.45989329e-02f,
  -1.67177245e-01f, 1.11286461e-01f, -9.67754889e-03f, -4.98096608e-02f, -9.47930887e-02f, 9.55637079e-03f, -1.62315577e-01f, -1.36260819e-02f, -4.77546751e-02f, -3.92797813e-02f,
  3.58229466e-02f, 1.16839046e-02f, 4.57755066e-02f, 2.80379504e-02f, -1.39784254e-02f, -4.64156456e-03f, 2.11727875e-03f, -6.10741749e-02f, 1.32960990e-01f, -5.69014391e-03f,
  4.28198911e-02f, 6.31361529e-02f, -1.30908843e-02f, 1.75557751e-02f, 4.93329465e-02f, 6.73877746e-02f, 4.88513000e-02f, 4.28325050e-02f, 1.08976085e-02f, 6.37914389e-02f,
  -2.84695551e-02f, 1.77268945e-02f, -2.65799351e-02f, -2.72572436e-03f, 4.82339486e-02f, 1.10416859e-01f, 1.16431281e-01f, 7.14250561e-03f, 8.00016522e-02f, 4.38188426e-02f,
  -1.12437993e-01f, -1.28763005e-01f, 6.51578009e-02f, -4.26845513e-02f, -3.55908982e-02f, -9.91013795e-02f, -1.77276373e-01f, -2.74590030e-02f, -1.18093364e-01f, -3.98745723e-02f,
  -9.73951668e-02f, -1.17241308e-01f, -1.59191504e-01f, -1.64329395e-01f, -3.58233266e-02f, -2.39227880e-02f, -1.64435714e-01f, -9.79222879e-02f, -4.98150624e-02f, -9.68936086e-02f,
  -9.34851989e-02f, -5.06532751e-03f, -5.00380434e-02f, -6.58148155e-02f, -4.83685099e-02f, 1.78190563e-02f, -1.23004563e-01f, -8.99014771e-02f, -1.08343415e-01f, -6.45021275e-02f,
  -9.19570625e-02f, -2.02508885e-02f, -6.14963695e-02f, 1.26287922e-01f, -5.65009862e-02f, -1.45216033e-01f, -1.55132294e-01f, -1.45513669e-01f, 3.59631591e-02f, -4.71247174e-03f,
  -1.36307731e-01f, 3.71051803e-02f, -9.85128526e-03f, 4.27455269e-02f, -1.73839360e-01f, -8.16170797e-02f, 1.57413244e-01f, -2.58711958e-03f, -2.75287591e-03f, -1.37055188e-01f,
  1.21337384e-01f, 2.10086748e-01f, 1.32819831e-01f, 1.49305046e-01f, 1.70156702e-01f, 9.47329402e-02f, 1.21195212e-01f, 1.71314925e-01f, 1.25482921e-02f, 1.23988844e-01f,
  -2.66769409e-01f, -2.09443927e-01f, 1.38727820e-03f, -1.30131990e-01f, -1.00864843e-01f, -1.58325538e-01f, -1.96593374e-01f, 4.24129441e-02f, -4.29241322e-02f, -7.87221342e-02f,
  -7.07466751e-02f, -8.15845579e-02f, -5.50536672e-03f, -4.15252596e-02f, -5.06338701e-02f, -1.51992589e-01f, -5.78956120e-02f, -3.55098620e-02f, -1.43067420e-01f, -1.55132353e-01f,
  -8.62958431e-02f, -5.61301596e-02f, -1.39345765e-01f, -6.91231042e-02f, -1.29467443e-01f, 1.93987638e-02f, -1.95993051e-01f, -1.68773547e-01f, -2.02714190e-01f, -8.45303684e-02f,
  8.44909400e-02f, 1.12262696e-01f, 1.08441852e-01f, 1.01216353e-01f, 9.89371985e-02f, 1.17142193e-01f, 1.27928674e-01f, 2.52859201e-02f, 1.85276512e-02f, 1.53085709e-01f,
  5.53253554e-02f, 2.46792287e-02f, 9.43683907e-02f, 1.00932024e-01f, -3.71243395e-02f, -4.80367541e-02f, 6.91861510e-02f, -3.78413461e-02f, -2.20687352e-02f, 8.35186988e-02f,
  9.51727256e-02f, 2.21090633e-02f, 7.97786340e-02f, 4.09580730e-02f, 6.70134053e-02f, 1.40923578e-02f, -7.01371988e-04f, 6.57407790e-02f, 4.22099046e-02f, 9.70962569e-02f,
  -1.94506258e-01f, -1.57587528e-01f, -9.20776576e-02f, -1.64954066e-01f, -1.14599884e-01f, -4.38176952e-02f, -1.15674295e-01f, -1.32639989e-01f, -1.28454968e-01f, -7.96027556e-02f,
  -1.03982419e-01f, -6.85960054e-03f, -1.47217542e-01f, -9.37095061e-02f, -1.01650678e-01f, -6.84929192e-02f, -1.29005998e-01f, 9.40320548e-03f, -3.89681458e-02f, -6.69486672e-02f,
  -6.52983114e-02f, -1.80640087e-01f, -2.02454567e-01f, -1.48376793e-01f, -1.54068656e-02f, -1.53450742e-01f, -7.89171830e-02f, -6.92790225e-02f, -2.89693564e-01f, -1.64268509e-01f,
  -1.00026801e-01f, 1.77912191e-01f, 9.21407267e-02f, -6.37857392e-02f, -9.99318063e-02f, -5.84367327e-02f, -2.37194300e-01f, -2.04132870e-01f, -4.18709181e-02f, -1.32760499e-03f,
  1.79990530e-01f, 1.34201571e-01f, 1.23561040e-01f, 7.58320000e-03f, -1.71454936e-01f, -6.58086389e-02f, -1.64773554e-01f, -6.94344118e-02f, -2.29271039e-01f, -1.82465896e-01f,
  -1.13520436e-01f, 2.56277490e-02f, -4.25882004e-02f, -3.26013900e-02f, 9.02329087e-02f, -1.20289795e-01f, 1.29294991e-01f, 1.09641068e-01f, 3.97189371e-02f, 9.18668434e-02f,
  1.82562336e-01f, 5.53449169e-02f, -1.89266443e-01f, -5.02836006e-03f, -1.30772805e-02f, -2.96377838e-02f, -1.00798391e-01f, -4.11706045e-02f, -3.12437583e-02f, 4.09892872e-02f,
  9.76656601e-02f, -3.08727231e-02f, 7.70097151e-02f, -3.85232158e-02f, -1.35922804e-01f, -5.98008074e-02f, -3.02411504e-02f, 4.35978472e-02f, 3.67843099e-02f, -6.61342666e-02f,
  1.01110086e-01f, 8.57558474e-02f, 7.47726262e-02f, -1.17279463e-01f, -8.69369507e-02f, -7.00002909e-03f, -8.98306072e-03f, -5.04304422e-04f, -4.59253080e-02f, -2.80299112e-02f,
  -4.59557176e-02f, 6.61825985e-02f, -5.15127480e-02f, -5.50639406e-02f, -2.45645177e-02f, 2.44915416e-03f, -6.48157392e-03f, 2.49207709e-02f, -3.67535986e-02f, -2.49682348e-02f,
  4.44689132e-02f, 1.77255739e-02f, 8.16262364e-02f, 4.61826324e-02f, 5.63783525e-03f, 2.49121711e-02f, -1.75132006e-02f, 9.40553248e-02f, -6.49263430e-03f, -2.75850128e-02f,
  -2.94060837e-02f, -3.66645455e-02f, 1.12925172e-02f, 4.27855141e-02f, 4.75998446e-02f, -7.04402924e-02f, 2.09738724e-02f, -3.38941626e-02f, 3.24486159e-02f, -1.03288591e-01f,
  -1.30281106e-01f, 1.23392351e-01f, -4.87773754e-02f, -3.94077338e-02f, -2.38791276e-02f, 6.83184117e-02f, 5.02452739e-02f, -2.71212421e-02f, 9.23163723e-03f, -2.69245040e-02f,
  -5.83684556e-02f, -2.11560279e-02f, 5.09736054e-02f, 2.31498089e-02f, -1.11644864e-01f, -2.21443810e-02f, -7.60069937e-02f, 2.43290924e-02f, -5.58009408e-02f, 6.74158633e-02f,
  -9.21659321e-02f, -1.52932033e-01f, -1.35711968e-01f, -7.93058425e-02f, -9.17665288e-02f, -1.78313464e-01f, -5.77569157e-02f, -1.56326205e-01f, -4.20609601e-02f, -2.20624000e-01f,
  2.53042370e-01f, -4.15038913e-02f, 2.88373083e-01f, 2.70548090e-02f, -3.51808034e-02f, 4.84675355e-02f, 2.64877491e-02f, 2.48599518e-03f, -2.70722210e-02f, 1.43468836e-02f,
  -1.65673882e-01f, -3.88021171e-01f, -1.61146164e-01f, -2.24036932e-01f, -1.41085058e-01f, 1.20097093e-01f, 3.40380222e-02f, 8.18693787e-02f, 1.24436408e-01f, -6.71615032e-03f,
  -1.57688096e-01f, -5.15021607e-02f, -4.44847196e-02f, 5.51979765e-02f, -8.31794832e-03f, -4.08578292e-02f, 7.99723864e-02f, 5.38265370e-02f, 2.01424323e-02f, 7.37500284e-03f,
  1.73507690e-01f, 1.67340323e-01f, -1.07913435e-01f, -1.74451366e-01f, -1.56020835e-01f, 6.26575574e-02f, -6.86073629e-03f, 6.40428625e-03f, -1.10497735e-01f, -3.28087471e-02f,
  -2.02704826e-03f, -1.13333605e-01f, -1.61595449e-01f, -7.24574998e-02f, -2.04889979e-02f, -3.02382354e-02f, -2.54643857e-02f, -8.72416347e-02f, 5.10885306e-02f, 2.86573041e-02f,
  -1.16597824e-01f, -8.01847801e-02f, -5.48536330e-03f, -3.18075940e-02f, -7.82541931e-03f, -2.41309404e-02f, 7.48395771e-02f, 2.43403558e-02f, -1.59348792e-03f, 9.27227437e-02f,
  -5.52845711e-04f, 4.80177775e-02f, -2.72100233e-02f, 2.10882854e-02f, 1.82446670e-02f, -3.18098324e-03f, 4.39202152e-02f, 2.37112120e-03f, -4.46070626e-04f, 9.43374485e-02f,
  1.21219652e-02f, 6.89878389e-02f, 1.05041414e-01f, 7.01933950e-02f, 4.44865562e-02f, 4.74707559e-02f, 4.69864830e-02f, 7.80528877e-03f, 8.61343890e-02f, 3.01110670e-02f,
  1.25326872e-01f, 6.77080229e-02f, 4.65674922e-02f, 8.55413526e-02f, 9.11801979e-02f, 4.77066822e-02f, 4.67263199e-02f, -5.84933981e-02f, 1.19248047e-01f, 1.08354110e-02f,
  -1.66595459e-01f, -2.05782373e-02f, 1.25863314e-01f, 2.02804338e-02f, -2.89666961e-04f, -1.31817892e-01f, -3.46444473e-02f, 1.60407815e-02f, -1.09768160e-01f, -1.78513315e-03f,
  -5.27700186e-02f, 7.83466324e-02f, -1.05780959e-01f, -3.49002797e-03f, -1.18609786e-01f, -8.53305236e-02f, -5.73884845e-02f, -1.05507962e-01f, -8.19062665e-02f, -4.37163897e-02f,
  -4.52718772e-02f, -6.47476986e-02f, -3.49773988e-02f, 3.16854641e-02f, -1.14332289e-01f, -7.62950778e-02f, -7.13196909e-03f, -3.78581025e-02f, 5.66559657e-03f, 1.19037844e-01f,
  -4.07323271e-01f, 2.53208518e-01f, 2.41457105e-01f, -2.30411157e-01f, 1.65173844e-01f, 1.41543850e-01f, 1.88786551e-01f, 1.78615302e-02f, -1.48968637e-01f, 2.08471473e-02f,
  2.80886274e-02f, -3.30159843e-01f, -2.57339269e-01f, -1.46640927e-01f, -2.60363612e-03f, 1.12479687e-01f, 1.76265910e-01f, 1.16484636e-03f, -2.85904229e-01f, -1.36823878e-01f,
  -1.25133693e-01f, -1.21276811e-01f, -2.64558285e-01f, -8.34335089e-02f, -5.10365553e-02f, -1.70873851e-01f, 1.82253256e-01f, 6.47725761e-02f, 1.52033150e-01f, 6.75779060e-02f,
  7.28302598e-02f, 2.65385583e-02f, -8.91440138e-02f, -1.64940834e-01f, -8.04635808e-02f, -1.92827523e-01f, -3.86601575e-02f, -1.07547000e-01f, -5.33658564e-02f, -8.78524333e-02f,
  6.38077967e-03f, -1.35340631e-01f, -1.55972078e-01f, 1.75137911e-02f, -1.34424850e-01f, -3.61406878e-02f, -2.86741853e-02f, -2.85972096e-02f, -9.85225514e-02f, -1.02463579e-02f,
  -1.87792871e-02f, -4.29730257e-03f, 7.79878944e-02f, 3.15159373e-02f, -1.36028165e-02f, -6.29989356e-02f, 1.08108543e-01f, -1.13216296e-01f, 2.33792141e-02f, 5.05472161e-02f,
  -2.44555455e-02f, 2.01585740e-02f, 8.26856643e-02f, 4.51247953e-02f, 7.33791962e-02f, 1.55305779e-02f, 9.02475882e-03f, 1.02709115e-01f, 2.78179646e-02f, 5.58723435e-02f,
  2.12959200e-02f, 3.19255404e-02f, 1.00702718e-02f, 5.80129400e-02f, 5.36327213e-02f, 9.71089900e-02f, 6.31514788e-02f, 3.07576526e-02f, 3.70652527e-02f, -1.68204866e-03f,
  4.19206247e-02f, 5.46223186e-02f, 7.35558849e-03f, 5.01978993e-02f, 1.24207232e-02f, 6.39428943e-02f, 2.99686119e-02f, -6.55670790e-03f, 8.44454020e-02f, 8.48691240e-02f,
  -1.92483649e-01f, -4.26244028e-02f, -1.04315981e-01f, -1.25126868e-01f, 5.44051789e-02f, -7.55255669e-02f, -1.20946363e-01f, -9.13391188e-02f, -1.06444340e-02f, -1.27600422e-02f,
  -7.96809494e-02f, -1.24556802e-01f, -2.59512588e-02f, -1.11357458e-01f, -8.27232823e-02f, -5.93685657e-02f, -4.94365804e-02f, -1.38573870e-01f, -3.31086032e-02f, -4.00807224e-02f,
  -3.22500952e-02f, -4.92284335e-02f, -8.24815556e-02f, -1.07444696e-01f, -5.02990792e-03f, -1.60578191e-01f, -2.35041827e-02f, -1.64021738e-02f, -1.20213732e-01f, -2.06621047e-02f
};

// L0_fan_Wp_bar (Shape: 26 x 120)
const int L0_fan_Wp_bar_rows = 26;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  1.64502370e-03f, -4.56404805e-01f, -2.68112689e-01f, 2.95336656e-02f, 9.22778621e-02f, -1.44270718e-01f, -4.81910497e-01f, -1.62568569e-01f, 1.43119907e-02f, -3.12271386e-01f,
  7.99996108e-02f, 3.28592002e-01f, -1.66161102e-04f, 7.19192699e-02f, 1.49842268e-02f, -2.77677685e-01f, -1.98966891e-01f, 2.51838565e-01f, 4.43724602e-01f, 2.22967148e-01f,
  4.50053215e-02f, 2.44674832e-01f, 3.14893097e-01f, 2.43069425e-01f, -1.78527068e-02f, 1.54961556e-01f, -2.01126903e-01f, 5.92892468e-02f, -1.49783060e-01f, -1.87467560e-01f,
  -3.82557213e-02f, -2.80885845e-01f, 5.65211400e-02f, 1.82358131e-01f, 1.47306457e-01f, -7.07593560e-02f, -1.61592469e-01f, 8.95399600e-02f, 4.43456769e-02f, -1.36261761e-01f,
  7.07296133e-02f, 4.26322669e-02f, 1.87682167e-01f, 9.37409922e-02f, 2.96758991e-02f, -3.78916971e-02f, 6.55137375e-02f, 1.19017877e-01f, -5.57974763e-02f, -6.50428608e-02f,
  4.73805182e-02f, 3.50977518e-02f, 8.27604979e-02f, -2.33772904e-01f, -3.43192935e-01f, 7.79724270e-02f, -6.90249279e-02f, -4.13989909e-02f, -1.24636792e-01f, -2.95307130e-01f,
  5.92211485e-02f, 6.27371445e-02f, -6.28941432e-02f, -1.58414781e-01f, -5.61662833e-04f, -9.96398032e-02f, 6.21718094e-02f, 2.45153364e-02f, 5.02004996e-02f, 2.04408448e-02f,
  5.43702692e-02f, -1.26616163e-02f, 6.21313788e-02f, -1.00688795e-02f, 1.00145280e-01f, 1.14300467e-01f, -9.25653428e-02f, 4.22508456e-02f, 1.00104049e-01f, -4.83309813e-02f,
  1.25582144e-01f, 3.67541844e-03f, 1.22968676e-02f, 6.43670559e-02f, -8.10303092e-02f, 5.00430651e-02f, -6.25963882e-02f, 1.58539005e-02f, -4.22174856e-03f, -6.69531152e-02f,
  1.43326987e-02f, 1.13620460e-01f, -1.43547967e-01f, 1.30529240e-01f, -7.83405006e-02f, -1.06058419e-01f, -1.27053529e-01f, 1.76909193e-01f, 5.08048572e-02f, -1.50204360e-01f,
  -1.05232991e-01f, -4.37981039e-02f, -2.14138791e-01f, -5.68329506e-02f, -1.04653053e-01f, -1.03281494e-02f, -8.74570832e-02f, 4.01500519e-03f, 2.11269576e-02f, 6.08886182e-02f,
  -3.87877971e-02f, -1.66474488e-02f, 3.81444325e-03f, -2.36408114e-01f, -3.15432325e-02f, 1.97329167e-02f, -4.44844775e-02f, -1.50191486e-01f, -2.31084302e-01f, -5.01707554e-01f,
  -2.55622208e-01f, 2.06814110e-01f, -2.78321683e-01f, 1.30516589e-01f, 1.98645875e-01f, 2.86769047e-02f, 4.55083027e-02f, 3.36441658e-02f, -7.05722347e-02f, 6.96418136e-02f,
  4.07342613e-02f, -1.02039367e-01f, 2.22398788e-02f, -9.99662206e-02f, 3.10939085e-02f, 1.58616945e-01f, 2.47395843e-01f, -1.59129456e-01f, -1.65131673e-01f, 4.82921340e-02f,
  3.30694348e-01f, 2.66917914e-01f, 6.57225475e-02f, 3.56332846e-02f, 9.83978063e-02f, 1.03365794e-01f, 1.24126896e-02f, 1.40176043e-01f, 3.05502489e-02f, 1.26071274e-01f,
  -3.67233664e-01f, -1.04239307e-01f, -2.38626413e-02f, 2.04548314e-01f, -1.17616981e-01f, -9.40609127e-02f, -1.30781665e-01f, -1.40372440e-01f, -1.59488525e-02f, 4.84866537e-02f,
  1.52256444e-01f, 4.85841231e-03f, 1.22775294e-01f, 3.37469466e-02f, 5.04324138e-02f, -1.27940029e-01f, 3.79446931e-02f, -8.97622630e-02f, -2.35768259e-01f, -3.19488277e-03f,
  3.27212811e-01f, 1.34036154e-01f, 4.01722342e-02f, -6.78930385e-03f, -1.45442590e-01f, 8.18184391e-03f, -1.01911135e-01f, -1.16709486e-01f, -1.52369604e-01f, 1.07390853e-02f,
  -4.01938818e-02f, 1.20119201e-02f, -5.61747216e-02f, 1.17404364e-01f, 4.88718487e-02f, 4.08824533e-02f, -8.76440406e-02f, -1.50428399e-01f, -8.78212973e-02f, -1.63478218e-02f,
  -6.15500100e-02f, -7.33544752e-02f, -1.14754759e-01f, -1.26790941e-01f, -1.08058698e-01f, 4.93173935e-02f, -4.44819927e-02f, 3.86709273e-02f, -8.12595338e-03f, -2.95322891e-02f,
  -4.36104313e-02f, -1.39314666e-01f, -4.75339852e-02f, -4.55920361e-02f, -1.83953885e-02f, -1.70908645e-01f, -2.35208571e-02f, -7.67275468e-02f, 4.24893014e-02f, -2.04371056e-03f,
  2.01136455e-01f, -9.07831267e-02f, -1.94293812e-01f, 2.66962890e-02f, 6.09929813e-03f, -9.29499567e-02f, -1.68638438e-01f, -2.38516077e-01f, -1.59170747e-01f, -1.71902642e-01f,
  -4.37021367e-02f, -3.19984078e-01f, -2.14492559e-01f, -4.21670899e-02f, -6.92959651e-02f, -1.30835146e-01f, 1.37961343e-01f, 6.38035163e-02f, 1.61533672e-02f, -1.05991274e-01f,
  5.55089153e-02f, 1.83556303e-02f, 1.00644432e-01f, -1.01469412e-01f, -1.17071085e-01f, -1.85801804e-01f, -1.07683032e-03f, -5.90082482e-02f, -1.82864085e-01f, 1.82476535e-01f,
  5.27282715e-01f, 3.14629525e-01f, 2.85433412e-01f, 1.10337958e-01f, 1.25241563e-01f, 2.95456529e-01f, 2.55583942e-01f, 2.05341533e-01f, 1.30627170e-01f, 1.90491423e-01f,
  2.58816153e-01f, 6.27223849e-02f, 1.98034957e-01f, 1.56936124e-01f, 1.50949508e-01f, 6.70717657e-03f, -8.15248117e-02f, 6.60961401e-03f, 1.17730685e-01f, 1.39785841e-01f,
  4.94975410e-03f, 3.37218717e-02f, -4.07314375e-02f, -3.87144298e-03f, 2.87794285e-02f, 5.78344092e-02f, 1.38527870e-01f, 1.16082348e-01f, 1.34291738e-01f, -3.19535211e-02f,
  -7.20647275e-02f, 2.22732097e-01f, -1.39464706e-01f, -1.11523002e-01f, -6.61375597e-02f, -2.06719473e-01f, -9.13141891e-02f, -1.27258673e-01f, -5.63151874e-02f, -1.92880630e-01f,
  -6.17503785e-02f, -1.07721791e-01f, -5.93032837e-02f, -9.96421948e-02f, -6.54379129e-02f, -1.17201880e-01f, -1.98495090e-02f, 6.18502451e-03f, 1.34737219e-03f, -7.89298192e-02f,
  -7.68402517e-02f, 8.36921036e-02f, -6.62708422e-03f, 3.88173647e-02f, 1.35451913e-01f, 3.35763022e-02f, 9.77446213e-02f, 9.46482364e-03f, 4.66937274e-02f, 3.49780396e-02f,
  5.72200082e-02f, 2.59770870e-01f, 1.44151002e-01f, 1.95381511e-02f, -8.66443366e-02f, 2.41477694e-03f, -1.63192805e-02f, 5.04383296e-02f, 1.65788069e-01f, 6.35911524e-02f,
  -8.08883980e-02f, -3.33954208e-03f, 2.87591722e-02f, -5.30315004e-02f, -7.37725273e-02f, 3.96272428e-02f, -1.41908348e-01f, -9.75466296e-02f, -4.72230688e-02f, -1.20044621e-02f,
  1.62403155e-02f, -1.12198656e-02f, -6.00353107e-02f, -3.38608213e-02f, -1.14330463e-01f, -6.54424876e-02f, -8.57938230e-02f, -1.09585613e-01f, -1.12652600e-01f, -1.18659571e-01f,
  -2.49175057e-01f, 2.04806075e-01f, -1.73700035e-01f, -2.05196217e-02f, -2.22468600e-02f, 5.13031185e-02f, 7.86037594e-02f, 6.11916035e-02f, -1.03601798e-01f, -1.17290191e-01f,
  7.47708604e-02f, 3.84048894e-02f, -1.08681023e-02f, 2.01755366e-03f, -1.41536549e-01f, -8.58070031e-02f, 7.71668330e-02f, 1.05009280e-01f, 4.95563494e-03f, -4.91179004e-02f,
  -4.39948887e-02f, 4.96819280e-02f, 2.74288431e-02f, 7.58468062e-02f, 1.15335487e-01f, -5.28889373e-02f, 4.89240550e-02f, -3.77633907e-02f, 4.89947945e-02f, -1.03135511e-01f,
  3.77024800e-01f, -1.26460895e-01f, 1.07346579e-01f, 2.97187865e-01f, 1.28072366e-01f, 2.28786111e-01f, -1.79198235e-02f, 8.01630393e-02f, 1.07130982e-01f, 1.01621918e-01f,
  1.61883220e-01f, 2.49999344e-01f, 2.33684137e-01f, 1.00857720e-01f, 1.61395103e-01f, -2.16431450e-03f, -3.90305333e-02f, 5.99304922e-02f, 2.11098835e-01f, 4.73594805e-03f,
  6.05211928e-02f, -4.01505977e-02f, -7.20338821e-02f, 7.22801760e-02f, 5.33586591e-02f, 1.14699550e-01f, -1.72717813e-02f, -1.80813540e-02f, 4.42233719e-02f, -1.15545556e-01f,
  2.54859105e-02f, 1.63442895e-01f, 1.62522480e-01f, 7.62554705e-02f, -1.44099668e-01f, -8.32497180e-02f, 3.68734747e-02f, -1.00299112e-01f, -1.24795929e-01f, -8.38194489e-02f,
  -6.76485449e-02f, -7.53285810e-02f, 6.30246326e-02f, -9.46020484e-02f, -1.67482212e-01f, -6.56983480e-02f, -1.82798445e-01f, -2.58332305e-02f, -1.30276559e-02f, -7.32596070e-02f,
  -8.53579193e-02f, 1.07859507e-01f, 6.49431124e-02f, 1.24928921e-01f, 4.50752415e-02f, 9.12028477e-02f, -6.56835362e-03f, -8.14945996e-03f, 1.35164589e-01f, -4.08441685e-02f,
  9.13890749e-02f, 3.76887210e-02f, 1.19028747e-01f, 7.47999623e-02f, 6.78317994e-02f, 3.20583917e-02f, 9.26247686e-02f, -3.87390815e-02f, 1.34041920e-01f, -1.01024494e-01f,
  -5.09141907e-02f, 4.05694917e-02f, 1.09464340e-01f, 5.80705702e-02f, 5.91879413e-02f, -1.46580189e-02f, -8.97814799e-03f, -1.08808326e-02f, 1.30073905e-01f, -8.93577747e-03f,
  7.85856545e-02f, -8.16982016e-02f, -2.48638280e-02f, 6.60567880e-02f, 2.18984205e-02f, 6.97286427e-02f, 1.90649256e-02f, 4.93330434e-02f, 6.62331656e-02f, -1.14338230e-02f,
  -2.12373614e-01f, 3.63232046e-01f, 1.99149027e-01f, -4.56722789e-02f, -1.21428065e-01f, -5.49507886e-02f, 1.28155053e-01f, -8.63946378e-02f, -1.95510045e-01f, -5.95634989e-03f,
  6.97781518e-03f, 8.14957358e-03f, -6.40519410e-02f, -6.26635402e-02f, 2.87178196e-02f, -1.21955708e-01f, -7.66505301e-02f, 4.68206331e-02f, 2.95325164e-02f, 1.75447650e-02f,
  -4.10787538e-02f, 1.38362169e-01f, 1.71164751e-01f, 8.40260237e-02f, 9.45598446e-03f, 7.05795959e-02f, -6.57466054e-02f, -4.04276047e-03f, 7.08656982e-02f, -6.15890604e-03f,
  -2.39089027e-01f, -7.68918991e-02f, 1.02043182e-01f, 2.66516358e-02f, -2.36111297e-03f, 2.76416708e-02f, 3.89347225e-02f, -1.18186092e-02f, 1.50676388e-02f, 1.29606307e-01f,
  2.15813935e-01f, 2.56730616e-01f, 2.45579034e-01f, 1.67478830e-01f, 7.24435449e-02f, 1.60546884e-01f, 9.91956070e-02f, 1.74479425e-01f, 9.86549854e-02f, 5.19561954e-02f,
  1.05635405e-01f, -1.53958887e-01f, -1.20892480e-01f, 5.63751124e-02f, 4.83879112e-02f, 1.84888557e-01f, -3.80721539e-02f, -4.35999371e-02f, 2.15679053e-02f, -3.79712507e-02f,
  5.39125383e-01f, 5.76767735e-02f, 1.02523908e-01f, 2.56726984e-02f, -3.19271460e-02f, -7.46690109e-02f, 4.97656912e-02f, -7.91155472e-02f, -5.09378053e-02f, 2.67275516e-03f,
  -7.00701552e-04f, -2.25666165e-02f, -1.08363159e-01f, -1.71867094e-03f, -2.61818003e-02f, 3.65652284e-03f, -4.31204494e-03f, -3.27783674e-02f, 9.56040919e-02f, 1.79705113e-01f,
  9.79338959e-02f, -4.70909216e-02f, 1.47884011e-01f, -3.46398447e-03f, 6.78156167e-02f, 8.01114067e-02f, 7.17714578e-02f, -5.48521690e-02f, 6.86051548e-02f, -7.03832135e-02f,
  8.29327852e-02f, 1.79764554e-01f, 1.65877044e-01f, 4.74013910e-02f, 2.12384723e-02f, 5.54607771e-02f, -4.31080461e-02f, -9.04382765e-03f, -1.41254589e-02f, -5.69846220e-02f,
  -1.86701342e-02f, 1.14934288e-01f, 7.82000050e-02f, 1.42512126e-02f, 1.74628168e-01f, 1.81573927e-01f, -2.84572020e-02f, 1.06725536e-01f, 2.62206327e-03f, 2.66739633e-02f,
  1.39947631e-03f, 7.87887275e-02f, -1.86348259e-02f, 2.31407657e-02f, -4.88056354e-02f, 5.86818010e-02f, 4.22156453e-02f, -1.74850486e-02f, 8.28096922e-03f, -5.33889756e-02f,
  4.00744259e-01f, 5.15927859e-02f, 1.60109222e-01f, 6.42534271e-02f, -9.57835913e-02f, -5.98413162e-02f, 7.47924596e-02f, -1.60705894e-02f, -2.25573853e-02f, 9.62572768e-02f,
  -8.53908285e-02f, -1.52995223e-02f, -1.26677319e-01f, -7.54271448e-02f, -8.41418728e-02f, -4.81998734e-02f, -9.21016186e-02f, 4.15270105e-02f, 1.21064477e-01f, 3.30857337e-02f,
  -8.80044233e-03f, 4.44831885e-02f, 1.07457407e-01f, 1.60267651e-01f, -3.41815241e-02f, 6.51689917e-02f, 6.56803921e-02f, -3.32479514e-02f, 6.12792820e-02f, -6.22667484e-02f,
  -8.99328351e-01f, 6.75325543e-02f, 7.49036064e-03f, -4.35849190e-01f, -8.94692689e-02f, -4.30897772e-02f, 1.84559733e-01f, 4.33009118e-03f, -1.90144092e-01f, 1.63995966e-01f,
  7.19067603e-02f, -2.53210545e-01f, -1.28714889e-01f, -1.10963061e-01f, -6.60754833e-03f, 9.86184850e-02f, -2.06627905e-01f, -4.28164929e-01f, -5.25012136e-01f, -1.03520170e-01f,
  -2.00822964e-01f, -4.02680963e-01f, -5.27267098e-01f, -2.92303085e-01f, -6.30785599e-02f, -3.05603206e-01f, -1.43125698e-01f, -1.66033372e-01f, -3.68364528e-02f, -8.81702155e-02f,
  4.03598636e-01f, -1.27692401e-01f, -1.27426401e-01f, -1.83542654e-01f, 2.28215344e-02f, 4.69424762e-02f, -1.91978533e-02f, -5.11945924e-03f, -5.98954372e-02f, -4.95035425e-02f,
  1.20112568e-03f, 4.64337654e-02f, -1.41644388e-01f, 8.41747373e-02f, -6.95210993e-02f, 1.40351569e-02f, 6.09163940e-02f, -7.07293348e-03f, 6.15089722e-02f, 3.58062446e-01f,
  1.62630454e-01f, -3.32312472e-02f, 4.47673112e-04f, 4.16689068e-02f, 1.65305540e-01f, -1.07810475e-01f, 7.88102448e-02f, 1.62801519e-01f, 1.46241680e-01f, 6.79564923e-02f,
  6.61815181e-02f, 5.72624952e-02f, 8.34213477e-03f, -1.14028014e-01f, 3.48775536e-02f, -1.02464087e-01f, -9.11049172e-02f, 1.78066306e-02f, -1.02311112e-02f, -2.82089356e-02f,
  7.19925612e-02f, -1.24470415e-02f, 1.45749692e-02f, -1.52872607e-01f, -4.48840968e-02f, -1.43228933e-01f, -4.06850055e-02f, 1.64068397e-02f, 1.33243293e-01f, 1.48218288e-03f,
  -6.99052289e-02f, 1.01040363e-01f, 7.89763406e-02f, -2.49133985e-02f, 1.12660713e-01f, 7.45064616e-02f, 3.87410671e-02f, 8.67021084e-02f, -4.68690880e-02f, -8.83918405e-02f,
  -9.95878354e-02f, -1.96899146e-01f, -1.07344180e-01f, 8.94502155e-04f, 3.56577337e-02f, 6.21614568e-02f, 4.08636183e-02f, -1.19228568e-02f, -8.05625692e-02f, 4.67018777e-04f,
  2.01348718e-02f, 1.06591485e-01f, -6.07909597e-02f, 2.21671790e-01f, -9.41169783e-02f, 1.88312810e-02f, 1.49299815e-01f, -8.43252614e-02f, 6.16894476e-02f, 1.36810124e-01f,
  1.16374865e-01f, -7.60150552e-02f, 3.99242267e-02f, 4.44928333e-02f, 1.78068541e-02f, -6.23133071e-02f, -1.03570260e-02f, 1.04929313e-01f, -7.50049502e-02f, 4.41009887e-02f,
  -6.90784216e-01f, -2.00900406e-01f, 3.57270688e-01f, -2.60041863e-01f, -5.33958226e-02f, 1.44043773e-01f, -8.80979151e-02f, -1.88255385e-01f, -1.98422864e-01f, -1.67232051e-01f,
  1.23207435e-01f, -2.52322163e-02f, 1.55324079e-02f, 1.03673063e-01f, 2.06429347e-01f, -9.28408727e-02f, -9.38300714e-02f, 9.85632911e-02f, 3.04229707e-01f, 1.56602636e-01f,
  -7.10991677e-03f, -9.31283366e-03f, -2.40286365e-02f, 1.08200684e-02f, -3.57213765e-01f, -9.47210938e-02f, -1.32874757e-01f, -2.26399720e-01f, -8.24497566e-02f, -4.03525978e-01f,
  -1.35141596e-01f, -4.18205619e-01f, 2.26272792e-01f, -1.26416892e-01f, 5.90751693e-02f, -1.45100594e-01f, -8.53644833e-02f, -1.08758554e-01f, -2.33006421e-02f, 5.78862764e-02f,
  -6.55003488e-02f, 1.84228197e-01f, -9.48832333e-02f, 9.58682820e-02f, -1.43831968e-01f, -2.19378583e-02f, 2.49498293e-01f, 1.36199832e-01f, 4.87890728e-02f, -2.58365422e-02f,
  -1.82309702e-01f, -8.50423276e-02f, -1.89302921e-01f, 1.56973571e-01f, -4.12390232e-02f, 1.73236523e-02f, 3.36279981e-02f, -1.48687601e-01f, 6.80371001e-02f, -4.90109652e-01f,
  4.68673371e-02f, 9.72204730e-02f, 1.73052192e-01f, 2.49673743e-02f, -1.49904955e-02f, 6.08067475e-02f, -6.69863597e-02f, -4.89114337e-02f, 1.60015803e-02f, -3.44046578e-03f,
  3.94085124e-02f, 6.07356103e-03f, 3.92236672e-02f, -5.04031330e-02f, -4.45426144e-02f, -9.70914215e-02f, -3.70016620e-02f, -1.04621507e-01f, -7.66665414e-02f, -8.85827243e-02f,
  -8.72722566e-02f, -2.57607717e-02f, -5.92871197e-02f, -8.16192180e-02f, 4.90691997e-02f, -4.14575003e-02f, -8.28834623e-02f, 1.21382140e-01f, -1.40387267e-02f, -1.35869876e-01f,
  -1.01922691e-01f, 4.27863538e-01f, -3.43342602e-01f, -2.15706062e-02f, -8.38963464e-02f, 5.61762154e-02f, -4.18727808e-02f, 2.21602157e-01f, -6.11756258e-02f, 5.44558913e-02f,
  5.41825639e-03f, -4.06798311e-02f, -7.56951794e-02f, 9.21456590e-02f, 1.63830034e-02f, -1.25221327e-01f, -1.07263714e-01f, 6.68646842e-02f, 1.49410442e-02f, -3.94307710e-02f,
  -2.10556146e-02f, -2.05787435e-01f, -2.68960625e-01f, -2.20765501e-01f, -2.70151049e-01f, -2.19194010e-01f, -1.26852512e-01f, -2.23532945e-01f, -6.10054024e-02f, -5.28919220e-01f,
  3.53346132e-02f, -2.19479144e-01f, -3.59581202e-01f, -2.23071754e-01f, -1.45505965e-01f, -4.41302434e-02f, 1.78387836e-02f, 1.38370305e-01f, -2.79299002e-02f, -2.42544413e-01f,
  -5.45660481e-02f, 6.58955723e-02f, -1.76045895e-01f, -1.61166057e-01f, -7.61086047e-02f, -3.18474621e-01f, -3.56527537e-01f, -1.07069619e-01f, 1.39214724e-01f, 1.83490321e-01f,
  -1.12336218e-01f, -1.49430484e-01f, -3.80788669e-02f, -7.73163736e-02f, -2.86155790e-01f, -2.13782653e-01f, -1.97201177e-01f, -1.59910768e-01f, -1.80254251e-01f, -5.03401935e-01f,
  -3.31821084e-01f, 5.61140515e-02f, -1.44690939e-03f, -4.76882085e-02f, -3.98740619e-02f, 7.67548978e-02f, 4.74365056e-02f, 8.22916720e-03f, -2.86435764e-02f, -5.44956140e-02f,
  2.68096626e-02f, 1.43044204e-01f, 9.44351852e-02f, 9.92861837e-02f, 2.57068896e-03f, 4.57430743e-02f, 1.32440239e-01f, 1.22498035e-01f, 2.41851974e-02f, -1.82439145e-02f,
  9.15396214e-02f, 2.45738804e-01f, 8.62602219e-02f, 1.86494753e-01f, 2.18696311e-01f, 1.90914050e-01f, 1.87778790e-02f, 1.05721414e-01f, 6.61289468e-02f, -1.07462681e-03f,
  -2.76434477e-02f, -1.62739590e-01f, 7.29910471e-03f, 9.61873531e-02f, 1.99115694e-01f, 1.08482704e-01f, 4.30486128e-02f, -2.94127055e-02f, 1.38998166e-01f, 1.10398056e-02f,
  -2.30283663e-03f, 6.28366182e-03f, 6.80645853e-02f, -1.70517620e-02f, -6.41887411e-02f, -5.66643476e-02f, 7.83636123e-02f, -5.62369004e-02f, 2.39817910e-02f, 1.00317575e-01f,
  2.02764288e-01f, -7.56203569e-03f, -5.68779148e-02f, -6.76314831e-02f, -6.38686344e-02f, -5.84926121e-02f, -1.15867674e-01f, 6.52035698e-02f, 3.84337753e-02f, -9.42404941e-02f,
  -1.71539068e-01f, 1.55034423e-01f, -1.56817615e-01f, 5.99284917e-02f, 3.14199664e-02f, 2.54241209e-02f, -7.75181577e-02f, -5.35868779e-02f, -2.02367082e-01f, -9.27330330e-02f,
  1.25164121e-01f, -3.35097336e-03f, 1.15136169e-02f, 4.09462564e-02f, 1.08588599e-01f, 1.06565960e-01f, 1.29962876e-01f, -2.82799043e-02f, 3.63659486e-02f, -1.65298238e-01f,
  -2.93926001e-02f, 1.61839128e-01f, 1.47201255e-01f, 1.36838853e-01f, 1.58688605e-01f, 1.46415278e-01f, -7.07173198e-02f, 7.63500482e-02f, 5.50251976e-02f, -2.66568437e-02f,
  -6.37810826e-01f, -1.65239841e-01f, 1.87343657e-01f, -6.77282587e-02f, -1.61985364e-02f, 7.50880986e-02f, 1.50946900e-01f, 1.37617420e-02f, -3.63671668e-02f, -2.76968665e-02f,
  -6.26104996e-02f, 2.11913198e-01f, 2.29989886e-01f, 8.17891210e-02f, 1.94104120e-01f, 2.73261875e-01f, 1.03284359e-01f, 1.88596606e-01f, 1.00295171e-01f, 1.08909257e-01f,
  6.01001307e-02f, -1.04384385e-01f, -1.59643292e-01f, 7.52585903e-02f, 1.94855388e-02f, 2.15803623e-01f, 2.46456619e-02f, 3.27598676e-02f, 1.28076509e-01f, 6.19639009e-02f,
  4.20561969e-01f, -2.42666870e-01f, 1.19878836e-02f, -1.67129308e-01f, -1.13190472e-01f, -2.10464388e-01f, -4.97229509e-02f, -5.20628057e-02f, -1.75198123e-01f, -7.79214501e-02f,
  -6.46328107e-02f, -1.31281957e-01f, -1.30289048e-01f, -1.35337353e-01f, -8.89339820e-02f, -1.15388557e-01f, -1.29312932e-01f, 7.72148222e-02f, 1.89735755e-01f, 2.57165655e-02f,
  5.13809845e-02f, 4.16412437e-03f, 9.75043476e-02f, 6.28048480e-02f, 5.70157990e-02f, -7.67353103e-02f, 5.83348200e-02f, -6.63992688e-02f, -1.43286251e-02f, -1.65676344e-02f,
  5.49173951e-02f, 9.51760039e-02f, -2.37159897e-03f, 2.94469316e-02f, 1.37042056e-03f, 8.11259970e-02f, 6.24180771e-02f, -8.43076929e-02f, 1.82994809e-02f, -4.14583422e-02f,
  3.30733880e-02f, 1.88304633e-01f, 4.97139283e-02f, 6.00074194e-02f, -1.07504064e-02f, 1.73804145e-02f, -1.04644760e-01f, -3.45258340e-02f, -2.48892102e-02f, -2.88958326e-02f,
  3.12228426e-02f, -4.79953028e-02f, -5.13476655e-02f, 7.92647377e-02f, 3.06124496e-03f, 3.52832675e-02f, -9.09315944e-02f, -9.17845517e-02f, -3.38780545e-02f, -8.13235864e-02f,
  4.34819132e-01f, 2.35147625e-02f, 7.05357715e-02f, 1.02913946e-01f, -1.65864646e-01f, -1.18425176e-01f, 2.94520706e-02f, 5.04383221e-02f, 9.70376283e-02f, 1.06606055e-02f,
  -9.12034959e-02f, -2.16605235e-02f, -1.64621100e-02f, -7.72786662e-02f, -3.15794498e-02f, -2.98913755e-02f, -2.80461386e-02f, 5.36621772e-02f, 1.36864334e-01f, 2.79420074e-02f,
  1.76566318e-02f, 8.85570142e-03f, 1.07224539e-01f, 1.60807908e-01f, 4.80612274e-03f, 8.11775699e-02f, 1.00148439e-01f, 9.00308043e-02f, 1.08549716e-02f, 5.38652651e-02f,
  3.62090647e-01f, -2.62959599e-01f, -2.43220016e-01f, 9.37413599e-04f, -7.26166070e-02f, -1.24542221e-01f, -3.65188748e-01f, 3.90106365e-02f, 1.86227307e-01f, -2.93593019e-01f,
  -1.24658756e-01f, 3.50135118e-01f, 1.78528190e-01f, 1.12689137e-01f, 2.93169208e-02f, -3.61066163e-01f, -3.04654658e-01f, 4.54208776e-02f, 3.29778820e-01f, 6.89841956e-02f,
  -1.50508970e-01f, -3.97256948e-02f, 1.05237916e-01f, 5.35496026e-02f, -2.10222840e-01f, 1.00898203e-02f, -2.48302177e-01f, -9.25002992e-02f, -1.16870336e-01f, -3.79752517e-01f,
  -1.66253135e-01f, 1.77860275e-01f, -3.10550444e-02f, 8.80739763e-02f, -1.58382326e-01f, 8.20175782e-02f, 1.11639183e-02f, -4.36282009e-02f, -1.05105564e-01f, -1.59197420e-01f,
  5.25858887e-02f, 1.15875155e-01f, 2.17644051e-01f, -5.85919851e-03f, -5.32703474e-02f, -1.50501225e-02f, -2.50981599e-02f, 1.14035886e-02f, -1.04693640e-02f, -1.83065221e-01f,
  -7.54199997e-02f, -9.02167261e-02f, -9.42901801e-03f, -1.48148194e-01f, 8.28905776e-02f, 4.58002975e-03f, -1.01751387e-01f, -6.10275492e-02f, 4.24523978e-03f, -2.72541106e-01f,
  -1.29759341e-01f, -1.44460380e-01f, 1.56392914e-03f, -3.95569168e-02f, -7.90092647e-02f, -5.58198877e-02f, 4.78115454e-02f, 1.02326095e-01f, -1.05514415e-02f, -1.13729443e-02f,
  -5.18802181e-03f, -5.57548329e-02f, 7.04760253e-02f, -3.17420959e-02f, -7.90436286e-03f, 1.70374084e-02f, -1.11171082e-01f, -1.13739826e-01f, -1.00937553e-01f, 1.49337749e-03f,
  6.59285262e-02f, -5.62546998e-02f, -9.62036569e-03f, 1.67225283e-02f, -4.53176796e-02f, -1.74511187e-02f, -1.25802876e-02f, 1.53288633e-01f, 1.49494275e-01f, -6.13849834e-02f,
  1.66249618e-01f, 1.55566022e-01f, -7.22180828e-02f, 7.02163354e-02f, -6.60916567e-02f, -1.10893399e-01f, -9.24546495e-02f, -1.04559854e-01f, 1.01700366e-01f, -7.12986290e-03f,
  -1.23997610e-02f, 3.37062478e-02f, -8.67794640e-03f, -1.26172071e-02f, -1.08107794e-02f, 7.09882081e-02f, 1.88054517e-02f, -6.49502501e-02f, -4.00581770e-02f, -1.32753938e-01f,
  -7.35235363e-02f, -1.25429794e-01f, 9.69822854e-02f, 9.87170190e-02f, 3.48864198e-02f, 1.00106090e-01f, -4.69444841e-02f, -1.42201260e-01f, 6.21579438e-02f, -1.85900912e-01f,
  1.47615755e-02f, 1.88666433e-01f, 2.85601057e-02f, 1.63087457e-01f, 1.59235056e-02f, 1.02711149e-01f, 2.31119499e-01f, 1.99776649e-01f, 1.34651825e-01f, 5.07529825e-02f,
  -1.23368679e-02f, -1.80745590e-02f, 1.62829742e-01f, 1.73510224e-01f, 1.88242465e-01f, 2.11173177e-01f, 3.17089200e-01f, 1.96661294e-01f, 5.08896038e-02f, 1.64089471e-01f,
  2.10358307e-01f, 1.28859058e-02f, -9.93211269e-02f, 1.77370552e-02f, 1.92878917e-01f, 2.10702177e-02f, 2.58349124e-02f, 1.80773363e-01f, 2.00813144e-01f, 4.68988687e-01f,
  4.58189426e-03f, 1.34777874e-01f, -1.04659468e-01f, -8.82997587e-02f, 1.86744314e-02f, -2.94650681e-02f, 5.28883152e-02f, -9.61478800e-02f, -9.35684144e-02f, -3.23222764e-02f,
  4.67887595e-02f, 7.32541010e-02f, 6.62112013e-02f, 1.97236519e-02f, 7.42233992e-02f, 5.73880784e-03f, 8.48504826e-02f, 1.46148931e-02f, -3.42138521e-02f, -4.25947607e-02f,
  1.15267105e-01f, -1.40037574e-02f, -1.37810543e-01f, -9.92799550e-02f, 1.41967917e-02f, -1.54569671e-01f, -3.53404656e-02f, 1.79200340e-02f, -2.51126975e-01f, -7.91263580e-02f,
  4.15397547e-02f, 3.19043510e-02f, 1.78242847e-02f, 1.78033262e-01f, 1.09384976e-01f, 9.38367397e-02f, 1.07925862e-01f, 1.29830867e-01f, 2.34426325e-03f, 1.27231151e-01f,
  1.52904898e-01f, -6.02067076e-02f, 3.67764272e-02f, -5.01779616e-02f, -4.65231314e-02f, -1.09522477e-01f, 3.91149335e-02f, -4.75996919e-02f, -8.06082636e-02f, -1.05957247e-01f,
  -2.35418193e-02f, 3.28279957e-02f, -7.49921873e-02f, 2.58844823e-01f, 4.49947361e-03f, -3.86750773e-02f, 1.25569617e-03f, -4.96690907e-02f, -1.33462489e-01f, -1.55060545e-01f,
  -3.47197652e-01f, -1.32125691e-01f, -2.49598436e-02f, 1.98715821e-01f, -6.19723499e-02f, -8.46599415e-02f, -4.56694281e-03f, -2.54649844e-04f, -4.32163626e-02f, -1.07901677e-01f,
  -1.28580943e-01f, 6.81654289e-02f, -9.67798978e-02f, 7.20972046e-02f, -1.11592956e-01f, -2.45799571e-02f, 5.83493002e-02f, 1.83970079e-01f, 7.77551159e-02f, -7.65051544e-02f,
  7.90158585e-02f, -2.65724510e-01f, -2.93710947e-01f, -6.07516915e-02f, -1.80794701e-01f, -1.55547425e-01f, -2.57056892e-01f, -1.53462425e-01f, -3.17624450e-01f, -2.72027820e-01f,
  -1.79008111e-01f, 5.31157963e-02f, -6.29055947e-02f, 1.92372188e-01f, 2.02580333e-01f, -2.06052497e-01f, -2.52627492e-01f, -3.56455326e-01f, 1.14678883e-03f, 1.00532174e-01f,
  1.55728668e-01f, 5.19080348e-02f, 1.79058149e-01f, 2.39668544e-02f, -3.15236747e-01f, 1.22076683e-01f, 1.32595152e-01f, -1.98503047e-01f, -3.30974698e-01f, -3.10402423e-01f,
  1.68249682e-01f, -5.60487546e-02f, -2.37852544e-01f, -1.25080109e-01f, 2.72534221e-01f, 1.52274340e-01f, 1.56153649e-01f, 2.16300100e-01f, 2.00555831e-01f, 4.08158511e-01f,
  2.49449998e-01f, -3.99843268e-02f, -2.26477757e-02f, -6.71369433e-02f, 1.09127931e-01f, -3.65343019e-02f, -1.23691276e-01f, -7.35317692e-02f, -9.04631540e-02f, -1.33155033e-01f,
  1.68323085e-01f, -9.87616926e-02f, 6.62494227e-02f, 1.38536215e-01f, 3.19053382e-02f, -1.31100312e-01f, -7.09822401e-02f, -1.76303431e-01f, -2.13022798e-01f, -2.04961225e-01f,
  1.93798646e-01f, 4.56228741e-02f, -9.80279595e-02f, -2.76029594e-02f, -4.13888171e-02f, 5.80525212e-02f, -1.36803225e-01f, -1.48416892e-01f, -3.04894269e-01f, 8.16975255e-03f,
  -8.97205435e-03f, -4.94247004e-02f, 6.24048784e-02f, 2.11305525e-02f, -3.30265164e-02f, -3.72309089e-02f, 1.11851178e-01f, 9.90011618e-02f, 6.93409815e-02f, 2.50328388e-02f,
  -1.32613868e-01f, -8.98953229e-02f, -8.06381404e-02f, -5.98140410e-04f, 2.80482583e-02f, 1.32917976e-02f, 6.59143180e-02f, -3.57693732e-02f, -3.01918387e-02f, -6.19852841e-02f,
  -4.49836217e-02f, 7.41121769e-02f, -5.57245780e-03f, -1.00575708e-01f, 1.17912620e-01f, 8.11152831e-02f, 3.61932144e-02f, 6.65246462e-03f, -1.47763163e-01f, 5.25600053e-02f,
  -1.32592127e-01f, -1.38197869e-01f, 2.37998009e-01f, -3.51035036e-02f, 2.15787590e-02f, 1.68088693e-02f, 3.24096791e-02f, 1.87629778e-02f, 9.38165374e-03f, -1.92873076e-01f,
  -1.74553961e-01f, 4.78696786e-02f, 8.27020109e-02f, 3.99265997e-02f, -1.77433919e-02f, -3.58017832e-02f, 7.47077838e-02f, 1.67350657e-02f, 7.16779614e-03f, 2.09732652e-02f,
  3.63755636e-02f, -1.60161212e-01f, -1.05309211e-01f, -5.62879816e-02f, 6.81938380e-02f, 7.05964193e-02f, -2.50054430e-02f, -1.07473442e-02f, -2.06772536e-01f, -1.81088790e-01f,
  -4.21212643e-01f, -2.37219110e-01f, -2.23781839e-01f, -4.11858410e-01f, -1.26945913e-01f, 5.76806068e-02f, 6.77266344e-02f, 1.03652775e-01f, -2.06708103e-01f, -3.05092841e-01f,
  -2.95359064e-02f, 7.86291994e-03f, -1.81731105e-01f, 1.60332154e-02f, 2.54759435e-02f, -1.64615557e-01f, -2.85891443e-01f, -2.83442400e-02f, 1.82753220e-01f, 2.28407204e-01f,
  6.23762161e-02f, -6.66221231e-02f, 1.41254058e-02f, 8.01706314e-02f, -8.23981389e-02f, -9.88912582e-02f, -2.45245948e-01f, -1.50019884e-01f, -2.83610448e-02f, -3.00588489e-01f,
  -1.98943496e-01f, -6.07639402e-02f, 9.02713239e-02f, 6.77965730e-02f, -1.24014445e-01f, 4.63884324e-02f, -3.56488233e-03f, -1.11338891e-01f, -6.16593249e-02f, -6.13556579e-02f,
  -6.58760816e-02f, 9.90062878e-02f, 2.90094432e-03f, 6.58842875e-03f, -1.17434449e-01f, 9.39414576e-02f, -3.30468416e-02f, -6.64722696e-02f, -4.04768711e-04f, 9.96264294e-02f,
  2.99006905e-02f, 7.18803853e-02f, 2.59339605e-02f, 1.37035683e-01f, 1.32713452e-01f, 5.11682741e-02f, 6.41622394e-02f, 1.32318810e-01f, 1.06782123e-01f, -2.06949368e-01f,
  6.78803632e-03f, -7.09085315e-02f, -3.57115790e-02f, -2.50224210e-02f, 1.17168352e-02f, -3.81034911e-02f, -8.91160977e-04f, 6.80486411e-02f, -1.69380810e-02f, 4.34780344e-02f,
  -2.61180177e-02f, 7.92625695e-02f, -8.43327492e-02f, -4.55608107e-02f, -7.43792057e-02f, 2.77081896e-02f, 4.10481021e-02f, -2.97664683e-02f, 3.90619300e-02f, 8.57508779e-02f,
  2.79588439e-03f, 9.23293233e-02f, -1.27622038e-01f, 6.68843836e-02f, 2.67407447e-02f, -1.46883756e-01f, -2.73506884e-02f, 3.50975618e-02f, -7.16784298e-02f, -1.22358110e-02f,
  -2.63846904e-01f, 6.32086918e-02f, -1.21382296e-01f, -1.85433570e-02f, -9.99914259e-02f, -5.84161766e-02f, -7.63004869e-02f, -5.15795089e-02f, -3.38047743e-02f, -1.82213373e-02f,
  1.38383284e-01f, -1.55938929e-03f, -9.48120058e-02f, -1.72052979e-02f, 2.79954094e-02f, -2.16895808e-02f, -4.33240570e-02f, -3.45082246e-02f, 1.07506402e-01f, 6.98907897e-02f,
  9.12714675e-02f, 4.53982875e-02f, 2.33737733e-02f, -5.71562834e-02f, 5.78959137e-02f, -4.21191119e-02f, -6.66168239e-03f, -3.51779982e-02f, 6.49598986e-02f, -1.54940531e-01f,
  -5.79416394e-01f, -3.10957074e-01f, 6.12234846e-02f, -1.88059822e-01f, 1.89751178e-01f, 2.25670263e-01f, 1.78852364e-01f, 6.47324920e-02f, -1.07424788e-01f, 1.05345622e-04f,
  -2.91190952e-01f, -6.79060817e-02f, -2.05008429e-03f, 1.21122450e-02f, 7.84964412e-02f, 1.47071406e-01f, 2.58920729e-01f, 2.05329005e-02f, 1.44679651e-01f, 2.26198286e-01f,
  1.52953193e-01f, 2.98345890e-02f, -2.80647904e-01f, -6.45233393e-02f, -1.81422047e-02f, 5.00092655e-02f, 7.37871751e-02f, -1.08016306e-03f, 3.48783098e-02f, 5.25698736e-02f,
  1.57021567e-01f, -3.97099257e-01f, 3.11764684e-02f, -1.94764018e-01f, -2.24659175e-01f, -1.86584517e-01f, -1.01462500e-02f, -6.16841726e-02f, -8.42776895e-02f, -1.87868103e-02f,
  -1.76382557e-01f, -1.75228983e-01f, 3.82217169e-02f, 1.60056222e-02f, 8.48562270e-02f, -6.15368299e-02f, -1.63110971e-01f, -8.63326788e-02f, -6.28368780e-02f, 5.68579417e-03f,
  9.85117555e-02f, -1.24544837e-02f, -9.40315798e-02f, 8.04560408e-02f, 7.89592862e-02f, 1.34670651e-02f, -8.66436213e-02f, -1.30995005e-01f, -1.12948336e-01f, -3.96237858e-02f,
  8.09545368e-02f, 1.03600234e-01f, -8.91616568e-02f, -7.02915713e-02f, 9.74975228e-02f, 8.97936076e-02f, 6.40717521e-02f, 1.23677373e-01f, 5.08544296e-02f, 1.04284905e-01f,
  -3.24213579e-02f, -4.96280454e-02f, -5.14860153e-02f, -6.59915060e-02f, -8.09062421e-02f, -1.01209417e-01f, -2.01503206e-02f, -4.68965769e-02f, -7.41012916e-02f, -1.23177148e-01f,
  -8.46316963e-02f, 3.58838625e-02f, -1.63045302e-01f, 8.00284371e-02f, -5.65633252e-02f, -1.55458301e-01f, 3.58734354e-02f, -9.82360318e-02f, 7.76828378e-02f, -1.05855009e-02f,
  1.21036686e-01f, -1.92725658e-01f, 5.52616827e-02f, 3.33151431e-03f, -6.04512095e-02f, -1.16824120e-01f, -1.37883171e-01f, -1.58075154e-01f, -6.87136352e-02f, 1.08858459e-01f,
  -1.18515208e-01f, 1.18464135e-01f, 9.67202708e-02f, 6.61396012e-02f, 2.18426853e-01f, 8.72489437e-02f, -4.72212136e-02f, 9.42915604e-02f, -1.30416891e-02f, -4.13649948e-04f,
  8.14532563e-02f, 1.41979113e-01f, 2.33141273e-01f, 2.20747739e-01f, 1.65887207e-01f, 1.45117700e-01f, 2.62796313e-01f, 1.79825529e-01f, 1.44770175e-01f, 2.77060717e-01f,
  2.50913221e-02f, 1.45742983e-01f, 9.56425220e-02f, 4.54427861e-02f, -2.42749050e-01f, -2.50261933e-01f, -2.34198809e-01f, -2.21232221e-01f, -1.09581336e-01f, -9.35003012e-02f,
  1.12435617e-01f, 2.00174734e-01f, 2.59452611e-01f, 1.70902848e-01f, 7.64238611e-02f, -6.39149323e-02f, -1.09503530e-01f, 2.60402709e-02f, 7.48030245e-02f, -1.79169863e-01f,
  -1.42653152e-01f, -5.29887900e-02f, 1.02181897e-01f, -9.67444032e-02f, -5.75116277e-02f, 7.37270340e-02f, -4.26404253e-02f, -1.08587563e-01f, -9.26633701e-02f, 2.42919624e-02f,
  2.80630916e-01f, -5.13005210e-03f, 1.97596624e-01f, 1.33355722e-01f, 3.96955423e-02f, 7.75646493e-02f, 1.22080557e-01f, 1.09562919e-01f, 3.39654237e-02f, 9.91117954e-02f,
  8.28282982e-02f, -1.71263274e-02f, -3.94239910e-02f, -4.42632735e-02f, -1.45056576e-01f, -6.00101091e-02f, -5.43808285e-03f, -1.13834828e-01f, -4.91496772e-02f, 1.00375168e-01f,
  -8.17067027e-02f, -1.05369896e-01f, -3.55554968e-02f, -1.26784578e-01f, -1.44008815e-01f, 7.63370246e-02f, -1.03683807e-01f, -1.13502972e-01f, -7.27642402e-02f, -8.87711048e-02f,
  9.92262214e-02f, -2.01124996e-02f, -1.32897841e-02f, -5.78440726e-02f, -3.64394151e-02f, -2.58264672e-02f, 3.33208032e-02f, -1.11440621e-01f, -9.84108150e-02f, -8.40007067e-02f,
  -1.13322236e-01f, -1.45639032e-02f, -8.93095583e-02f, -4.56347540e-02f, 2.00290158e-02f, -9.96758938e-02f, -5.35593778e-02f, 7.02641755e-02f, -4.24427092e-02f, -2.21440997e-02f,
  -1.35737911e-01f, 9.36803129e-03f, -8.04145187e-02f, -1.04688704e-01f, -1.56702906e-01f, -4.55309562e-02f, -1.44434318e-01f, 3.61214764e-02f, -1.51343476e-02f, -1.16939344e-01f,
  2.15810969e-01f, 1.62541062e-01f, 1.40984386e-01f, 1.15290120e-01f, 3.55631039e-02f, 2.33054385e-02f, 5.10043576e-02f, 1.57406718e-01f, 1.73209712e-01f, 1.20336577e-01f,
  1.18217833e-01f, 1.91231892e-01f, -2.74747908e-02f, -8.48635957e-02f, -8.01185593e-02f, -3.22715044e-02f, -1.28569743e-02f, 1.12396561e-01f, 8.99345800e-02f, 2.04544943e-02f,
  7.61416927e-02f, 6.07581623e-02f, 1.72494829e-01f, 1.30278066e-01f, 1.00981995e-01f, 1.65606722e-01f, 1.08857946e-02f, -2.82858927e-02f, 8.69384110e-02f, -4.04333584e-02f,
  4.19360787e-01f, 1.71711564e-01f, 1.97938308e-01f, 1.12868048e-01f, 1.31888896e-01f, 2.70815670e-01f, 4.44729805e-01f, 2.18338102e-01f, 7.84397200e-02f, 1.73809007e-02f,
  2.29219750e-01f, -8.87635723e-02f, 1.17129497e-02f, -1.07193574e-01f, 7.30746165e-02f, -1.66567974e-02f, -2.15220898e-01f, 2.63747806e-03f, 9.17605218e-03f, 5.24982810e-02f,
  -1.27118006e-01f, 1.11707792e-01f, 4.07262221e-02f, 8.08805227e-02f, -2.16410995e-01f, -1.80069178e-01f, 3.36917788e-02f, 3.15974876e-02f, 1.05713978e-01f, -2.75496930e-01f,
  -1.42499134e-01f, 1.60216093e-01f, -1.54712066e-01f, -2.93376613e-02f, 8.79389141e-03f, -1.30911898e-02f, -1.09410040e-01f, -2.92358380e-02f, -4.16126661e-03f, -1.01437315e-01f,
  -1.05822355e-01f, -3.56378406e-02f, 7.33454525e-02f, 1.03307739e-01f, 1.33907884e-01f, 4.61701155e-02f, 6.43550158e-02f, -7.72948042e-02f, 2.76513975e-02f, -8.06799978e-02f,
  -1.12200774e-01f, 1.64028183e-01f, 1.66986153e-01f, 4.81454283e-02f, 9.55701433e-03f, -2.69861668e-02f, 2.72367448e-02f, 3.75564732e-02f, -2.97718421e-02f, -1.21148497e-01f,
  -1.01547092e-01f, 1.77480392e-02f, -1.57385692e-02f, -1.76611900e-01f, -2.40752716e-02f, -7.41409659e-02f, -8.05429667e-02f, 9.17525664e-02f, -5.76232793e-03f, 1.35445014e-01f,
  2.14746711e-03f, 8.87367874e-04f, -3.60547309e-03f, 8.37253481e-02f, -2.05632821e-02f, 3.82715426e-02f, -3.35144848e-02f, 7.17264935e-02f, 5.22221103e-02f, 1.20846890e-01f,
  4.78030331e-02f, -5.83752524e-03f, 5.06331325e-02f, -3.07528093e-03f, 3.06108166e-02f, 3.30174789e-02f, 5.42929173e-02f, 9.55020562e-02f, 1.21664040e-01f, 1.66674376e-01f,
  -1.58716366e-02f, 3.47231597e-01f, -1.27949491e-01f, -7.48094842e-02f, -5.00179036e-03f, 1.33719482e-02f, 8.94171819e-02f, -3.97540405e-02f, -1.41833290e-01f, -1.54348359e-01f,
  5.42270914e-02f, 1.27730193e-02f, 1.79557562e-01f, 9.20946524e-02f, 1.30989151e-02f, 6.53082803e-02f, -3.69234979e-02f, -1.87378619e-02f, -7.44347721e-02f, -2.03299925e-01f,
  -5.61592802e-02f, -9.22959577e-03f, -1.23134144e-02f, -4.09975066e-04f, -1.16135769e-01f, -9.19079706e-02f, -2.25795601e-02f, 2.42563225e-02f, 3.27992961e-02f, 2.86840610e-02f,
  -3.98510665e-01f, -1.52212262e-01f, -2.53494471e-01f, -3.44798833e-01f, -1.74677312e-01f, 9.37461108e-02f, -6.68466389e-02f, 9.52272415e-02f, -7.21543003e-03f, -3.05659026e-01f,
  -1.18282773e-01f, -8.35924968e-02f, -2.46681228e-01f, 1.97614003e-02f, -1.67828128e-02f, -1.96011156e-01f, -2.84112245e-01f, -2.06859231e-01f, 6.37173373e-03f, 1.51008695e-01f,
  1.06875330e-01f, -1.29744500e-01f, -8.60720277e-02f, 5.14038242e-02f, 4.04567178e-03f, 9.39981174e-03f, -2.78056651e-01f, -3.33792120e-02f, 1.45050824e-01f, -1.70353100e-01f,
  -2.14776725e-01f, 7.88052082e-02f, 7.00041950e-02f, -5.77152669e-02f, -2.39506707e-01f, 2.43757367e-02f, -1.24916201e-03f, -1.03337176e-01f, 2.75330208e-02f, -5.08937091e-02f,
  -7.55919442e-02f, 3.73485796e-02f, -1.14903733e-01f, 1.03641294e-04f, -6.03915937e-02f, 1.04748383e-01f, -4.83277477e-02f, -1.59080010e-02f, -1.22391224e-01f, -8.91431794e-03f,
  3.48008126e-02f, -7.12733045e-02f, -6.19685017e-02f, 4.71584201e-02f, 7.79323503e-02f, 3.46214399e-02f, 5.12823425e-02f, 1.40793487e-01f, 2.31901094e-01f, -7.35692903e-02f,
  -2.81501636e-02f, 3.43977250e-02f, 5.95058352e-02f, 8.41820017e-02f, -2.29695961e-02f, -2.31340937e-02f, -1.43009856e-01f, -2.64464673e-02f, 6.31336197e-02f, 8.90442822e-03f,
  -4.72677052e-02f, -5.25161736e-02f, 2.53424738e-02f, -3.93763445e-02f, -6.34596646e-02f, -1.26135692e-01f, 2.37695519e-02f, -7.65490383e-02f, 2.65055541e-02f, -3.20245959e-02f,
  3.09269112e-02f, -2.62929033e-02f, -2.72103902e-02f, 1.34903580e-01f, -4.47587706e-02f, -7.96953402e-03f, -4.77634594e-02f, 3.27107534e-02f, 1.43391890e-02f, 4.99233082e-02f,
  -2.72030443e-01f, 5.44096753e-02f, -1.37950003e-01f, 2.30034143e-02f, -1.33399040e-01f, -1.37660028e-02f, -4.26226109e-02f, -9.21700969e-02f, -3.69060896e-02f, 1.35748254e-04f,
  1.34422660e-01f, -3.97598706e-02f, -1.66202486e-01f, 6.55157790e-02f, -1.24276720e-03f, 4.93782340e-03f, -7.50443637e-02f, -9.05981101e-03f, -3.92605364e-02f, 5.48863672e-02f,
  -2.56353635e-02f, -4.81033064e-02f, -1.68882042e-01f, -4.43880726e-03f, 5.16870767e-02f, -1.07790586e-02f, 6.80203289e-02f, 4.71526794e-02f, 1.05801232e-01f, -5.94804771e-02f,
  6.56029284e-01f, 1.40815794e-01f, -4.42389876e-01f, 1.93903148e-01f, -4.61486667e-01f, -5.17305315e-01f, -4.81585473e-01f, 8.92360881e-02f, 3.06186169e-01f, -1.14563338e-01f,
  -1.40108705e-01f, 2.88637877e-01f, 1.37155324e-01f, 1.31124118e-02f, 2.40867883e-02f, -2.58930266e-01f, -2.76196659e-01f, -7.69068152e-02f, -1.78069785e-01f, -3.20213497e-01f,
  -1.43495798e-01f, -4.25771403e-04f, 5.09881377e-02f, -2.99484916e-02f, -1.64426282e-01f, -1.32150427e-01f, -2.27339715e-01f, -1.03149049e-01f, -2.29047179e-01f, -2.60717034e-01f,
  -2.25537077e-01f, -1.44919798e-01f, -2.19024867e-01f, -1.17706945e-02f, -1.38709813e-01f, -2.78084688e-02f, -2.09788293e-01f, -1.14510953e-02f, 5.68231903e-02f, -9.89609510e-02f,
  3.36946473e-02f, -2.15182379e-02f, 7.81966597e-02f, -1.38133168e-01f, -7.29201064e-02f, -8.25503320e-02f, 3.84260267e-02f, -8.44387934e-02f, 1.61503807e-01f, -4.20914069e-02f,
  -1.33621534e-02f, -1.56198010e-01f, 1.60321463e-02f, -7.98986182e-02f, -2.05800563e-01f, -1.46253435e-02f, -2.78239816e-01f, -1.17302515e-01f, -1.85254812e-01f, -2.22300850e-02f,
  3.41149047e-02f, 2.11311597e-02f, -5.14636263e-02f, 1.17805630e-01f, 8.86981860e-02f, 4.78343181e-02f, 2.67954003e-02f, 5.94040565e-02f, -5.60036749e-02f, 1.48153365e-01f,
  2.00592428e-02f, 6.12485805e-04f, -4.89126705e-02f, -2.45920587e-02f, -7.15024099e-02f, 1.46006914e-02f, -3.11529450e-02f, 6.44386783e-02f, -1.21305259e-02f, 6.85432106e-02f,
  3.86269428e-02f, -5.73841901e-03f, -1.13542611e-02f, 1.89884193e-03f, -1.09635554e-01f, 2.65744384e-02f, 1.75151695e-02f, -9.63951647e-02f, 1.01609513e-01f, 6.19346462e-03f,
  3.33044857e-01f, -1.92436948e-01f, 2.04899400e-01f, 6.80250078e-02f, -1.13634942e-02f, -6.65713176e-02f, 3.98741588e-02f, -4.39364836e-02f, 3.00610298e-03f, -1.77180243e-03f,
  -1.08505175e-01f, 8.04920867e-03f, 4.14515808e-02f, 4.19578739e-02f, -9.87529829e-02f, 5.73870763e-02f, -7.10730553e-02f, -9.30532515e-02f, 3.47327143e-02f, -4.05264273e-02f,
  8.71701464e-02f, 7.30892345e-02f, 2.87247092e-01f, 1.59596026e-01f, 1.53443858e-01f, 1.22630097e-01f, -5.77968284e-02f, -1.05790664e-02f, -2.68511311e-03f, 3.09293270e-01f,
  3.78674150e-01f, -2.98526502e-05f, 2.31579289e-01f, 1.89902976e-01f, 2.58957773e-01f, 2.11386889e-01f, 2.68153161e-01f, 1.62059054e-01f, 5.16333319e-02f, 3.66352499e-02f,
  1.50045365e-01f, 1.96305923e-02f, 2.94933245e-02f, -4.54247408e-02f, -5.71233779e-02f, -7.31714740e-02f, -1.46978218e-02f, 1.00750484e-01f, 1.55978829e-01f, -2.95903888e-02f,
  1.00905793e-02f, -1.46668600e-02f, -9.08205435e-02f, 8.52319077e-02f, -1.00340351e-01f, -1.24433644e-01f, 4.85477708e-02f, -1.18777551e-01f, 8.44268221e-03f, -3.21793288e-01f,
  -1.60148114e-01f, 2.40534380e-01f, -9.64878201e-02f, -1.16468959e-01f, 2.35377885e-02f, -4.95257042e-02f, 4.29294258e-02f, 4.21323441e-02f, 4.32330929e-02f, -2.51182560e-02f,
  -7.86601081e-02f, 5.44482321e-02f, 6.31705225e-02f, 8.44906196e-02f, -4.40976284e-02f, 8.48396569e-02f, -1.09156102e-01f, -7.06940293e-02f, 6.62672371e-02f, -8.36292356e-02f,
  4.97902930e-02f, 1.12357274e-01f, 1.61357269e-01f, 1.35833353e-01f, 1.87167320e-02f, 1.31682321e-01f, 7.94736668e-02f, 6.65111169e-02f, 4.34124433e-02f, 3.18600945e-02f,
  3.83392684e-02f, -4.85884733e-02f, -2.92994715e-02f, 1.26859024e-01f, 2.51430310e-02f, 5.95093109e-02f, -8.99788365e-02f, -2.43693101e-03f, 1.55871818e-02f, 3.32077667e-02f,
  -9.20248032e-02f, 4.39922735e-02f, 7.43542910e-02f, -6.20337985e-02f, 8.42327625e-02f, 1.20029915e-02f, 4.15848605e-02f, -9.75821465e-02f, 6.23932481e-02f, 1.68353356e-02f,
  -8.67620781e-02f, -6.60636052e-02f, -5.69121167e-03f, -3.28983627e-02f, -7.75310174e-02f, 9.07739718e-03f, -8.89842119e-03f, 6.17767265e-03f, -5.99009395e-02f, -1.17151700e-01f,
  -1.91946045e-01f, 1.78946614e-01f, -1.78200036e-01f, -1.96333632e-01f, -1.22830696e-01f, -1.53754428e-01f, -3.78171317e-02f, -1.75098345e-01f, -9.40345526e-02f, -1.64869800e-02f,
  -9.79641527e-02f, -7.95483962e-02f, 1.06613562e-02f, -3.45630012e-02f, 3.54679897e-02f, -1.10197533e-02f, -2.19440013e-02f, -4.17160280e-02f, -1.32770747e-01f, 1.60839483e-02f,
  -5.74653968e-02f, 9.80086438e-03f, 4.87326011e-02f, 1.01158485e-01f, -9.88084227e-02f, -6.29755780e-02f, 2.29516551e-02f, 1.51117314e-02f, 7.66778365e-02f, 6.76194578e-02f,
  2.09584817e-01f, -2.10361391e-01f, -2.82745093e-01f, 3.08956027e-01f, 3.33399206e-01f, -5.45006879e-02f, -3.93263012e-01f, -6.13666140e-02f, 4.90907937e-01f, -6.91247918e-03f,
  1.58324748e-01f, 2.58683652e-01f, 1.34521618e-01f, -3.84982228e-02f, -5.94394386e-01f, -4.75086689e-01f, -2.35654294e-01f, -3.59564185e-01f, -1.86004177e-01f, 9.81006101e-02f,
  2.02394530e-01f, 1.99801967e-01f, 9.10467729e-02f, 5.80766723e-02f, 3.00484449e-01f, 9.50227752e-02f, 8.01361129e-02f, -2.60631982e-02f, -2.48477474e-01f, -2.21467212e-01f,
  -7.19316825e-02f, 7.69727156e-02f, -7.64038563e-02f, 1.23390742e-01f, -9.59049389e-02f, -9.08634067e-02f, -4.10466827e-02f, -1.29295528e-01f, 1.00897796e-01f, 5.70482574e-02f,
  4.98811230e-02f, 4.22780514e-02f, 4.45935838e-02f, -8.78846087e-03f, 1.71018764e-01f, -1.01271547e-01f, -1.70305725e-02f, -2.08638996e-01f, -2.19527915e-01f, -2.42465988e-01f,
  -1.42703190e-01f, 1.34251311e-01f, -1.89818487e-01f, -2.10193709e-01f, -2.87717342e-01f, -5.63182384e-02f, -2.31566042e-01f, -3.03691421e-02f, -3.55346054e-01f, -1.76509395e-01f,
  7.85628781e-02f, 9.61688682e-02f, 4.21810560e-02f, -8.14866368e-03f, 1.37665391e-01f, -5.82571723e-04f, 5.20912260e-02f, 1.19517751e-01f, 7.13698342e-02f, -1.03364274e-01f,
  2.42139716e-02f, 2.81108543e-02f, -1.84191465e-02f, -5.58750331e-02f, -2.69841757e-02f, 2.83835623e-02f, -6.31260946e-02f, -1.10946678e-01f, -1.46357030e-01f, 8.08334537e-03f,
  7.66281635e-02f, 8.85121617e-03f, 1.02912977e-01f, 5.30703850e-02f, -6.60477504e-02f, -1.87668189e-01f, 7.50391856e-02f, -2.67249700e-02f, -4.18341113e-03f, 1.04189970e-01f,
  1.83773398e-01f, -2.82780409e-01f, 5.49283549e-02f, -3.99153233e-02f, -2.28935573e-03f, 6.06928430e-02f, 1.10541001e-01f, -3.52845415e-02f, 1.64138526e-01f, 8.17224011e-02f,
  -3.00605688e-02f, 3.08889393e-02f, 4.58898805e-02f, -5.91892637e-02f, 1.85537543e-02f, 8.68190639e-03f, -9.49419811e-02f, -2.59806658e-03f, 2.60113124e-02f, 1.90916076e-01f,
  -9.43082199e-03f, -7.42056072e-02f, -5.17192855e-02f, -2.80488729e-01f, 1.34311274e-01f, -4.47649732e-02f, -1.90274179e-01f, -1.15841731e-01f, -2.65328526e-01f, -3.66984129e-01f,
  -2.97848612e-01f, 1.23562418e-01f, 2.66165912e-01f, 1.18144885e-01f, 2.60209888e-01f, -1.97540283e-01f, -3.38410556e-01f, -3.89542341e-01f, -1.04512855e-01f, 9.67640802e-03f,
  1.92064270e-01f, 8.41181651e-02f, 1.79596320e-01f, -1.56337339e-02f, -5.43298960e-01f, -1.07507311e-01f, -1.10091850e-01f, -2.11555228e-01f, -3.25930536e-01f, -2.91195869e-01f,
  7.49875838e-03f, -4.30276617e-02f, -2.00057149e-01f, -1.93292618e-01f, 2.04528376e-01f, 1.65501684e-01f, 1.90939605e-01f, 1.42195240e-01f, 3.63477208e-02f, 2.69037753e-01f,
  2.22548902e-01f, 4.30039763e-02f, -1.07689492e-01f, -8.79915059e-02f, 1.72135144e-01f, 1.36607839e-03f, -1.40013739e-01f, -4.41441201e-02f, -3.83205935e-02f, -3.83609235e-02f,
  2.28159994e-01f, -8.65271389e-02f, 9.23841521e-02f, 5.00287227e-02f, -7.39274994e-02f, -2.30899647e-01f, -2.05038041e-01f, -1.27808928e-01f, -1.51106477e-01f, -3.04169375e-02f,
  2.92345416e-02f, 4.30811532e-02f, -4.98539209e-02f, -2.83720214e-02f, -1.03903338e-02f, 1.66389018e-01f, 1.17140941e-01f, -1.65425260e-02f, -1.89398348e-01f, 2.68393545e-03f,
  -3.17003652e-02f, 3.02729607e-02f, -2.98867766e-02f, 5.00040650e-02f, -4.91408296e-02f, 1.18086241e-01f, 3.06387786e-02f, -5.68996780e-02f, -5.53407073e-02f, 2.03223638e-02f,
  -1.51405456e-02f, 7.58368969e-02f, 3.54549624e-02f, 6.22600503e-03f, 7.36842975e-02f, -2.06355955e-02f, -6.54006675e-02f, -3.77580859e-02f, -7.39830360e-02f, -2.79039945e-02f,
  -2.18939278e-02f, -7.38605335e-02f, 8.29105303e-02f, -1.21152818e-01f, -5.02765514e-02f, -1.06570929e-01f, 6.50817156e-02f, -6.40513822e-02f, 1.74150616e-02f, -2.94306763e-02f,
  1.09349348e-01f, -1.76110700e-01f, 1.31478816e-01f, -2.16882840e-01f, 6.13397285e-02f, 1.36803135e-01f, 1.83265775e-01f, -4.99603935e-02f, 7.28529915e-02f, -1.32388502e-01f,
  -8.99193510e-02f, 1.87380258e-02f, 2.82583814e-02f, 3.33207697e-02f, -1.12634994e-01f, 4.24567349e-02f, -1.74800038e-01f, -4.80212038e-03f, -1.45609885e-01f, -5.85775375e-02f,
  -1.60520867e-01f, -1.89961836e-01f, -1.31240681e-01f, 5.84902056e-02f, -9.45739746e-02f, 1.57879312e-02f, 7.06473365e-02f, 1.86249450e-01f, -2.64668576e-02f, 2.80868337e-02f,
  -4.24361259e-01f, 5.15653268e-02f, -1.99538857e-01f, -2.59996444e-01f, -3.67303342e-01f, -2.78261244e-01f, -1.99146673e-01f, -7.50910193e-02f, -1.71608195e-01f, -2.74927527e-01f,
  3.81062143e-02f, 2.67568648e-01f, 2.48264268e-01f, 5.86581300e-04f, 1.16212133e-04f, -2.26330727e-01f, -3.02376211e-01f, -1.82830155e-01f, 7.52960220e-02f, 6.04316173e-03f,
  -1.34318203e-01f, -1.51653802e-02f, -1.41153168e-02f, -1.04126960e-01f, 7.54303019e-03f, 8.31439421e-02f, -4.23659720e-02f, -1.58390611e-01f, -1.44365147e-01f, -2.16614127e-01f,
  4.00964409e-01f, -1.14933059e-01f, -1.13656141e-01f, -6.02943264e-02f, 1.70565993e-02f, -8.28028172e-02f, -2.83910185e-02f, -1.41449288e-01f, -1.24027589e-02f, -9.10179242e-02f,
  -2.48497408e-02f, -3.17213871e-02f, 1.50957420e-01f, 9.94496271e-02f, -1.10973674e-03f, -5.89210503e-02f, 2.08744593e-02f, -1.03390083e-01f, -1.38422415e-01f, 3.86723094e-02f,
  7.67158046e-02f, -1.42959356e-01f, 1.25868604e-01f, 6.86948448e-02f, 5.53545263e-03f, 1.28975818e-02f, 6.59700036e-02f, 6.56573847e-02f, 3.43535212e-03f, -8.19577742e-03f,
  -8.37967843e-02f, 8.51560459e-02f, -5.34786545e-02f, 1.11960890e-02f, -5.22810826e-03f, -5.42436652e-02f, 8.34208131e-02f, -5.38170058e-03f, 1.10216476e-01f, 9.56129506e-02f,
  -5.54707609e-02f, -5.68795875e-02f, 8.22653696e-02f, -2.32260972e-02f, -2.09982600e-02f, -9.11904126e-02f, 6.46016747e-02f, 3.03596668e-02f, -4.67929207e-02f, -7.52689168e-02f,
  -8.76138136e-02f, -1.06151916e-01f, -6.75353035e-02f, 3.24316062e-02f, -6.72913343e-02f, -1.73784071e-03f, -7.55514801e-02f, 8.21235254e-02f, 3.79636623e-02f, -1.04628861e-01f,
  3.97571027e-01f, -1.49807483e-01f, 5.45312762e-02f, 2.04553660e-02f, -6.05314448e-02f, -1.91370100e-01f, 1.78428479e-02f, -9.52471420e-02f, -4.76871133e-02f, -2.41368506e-02f,
  -4.81138639e-02f, -9.22727734e-02f, 3.14805433e-02f, 8.84503424e-02f, 7.17253378e-03f, -6.67014420e-02f, -1.42178774e-01f, 1.60338171e-02f, -9.42970440e-02f, -7.84422979e-02f,
  -4.88898531e-02f, -1.13390706e-01f, 1.50417015e-01f, 8.71628970e-02f, 5.10129072e-02f, 8.76113325e-02f, 1.62083685e-01f, 1.52876914e-01f, 1.15485482e-01f, 9.58974138e-02f,
  -5.30244350e-01f, 4.21178550e-01f, -9.16728675e-02f, -1.24173880e-01f, 2.22684011e-01f, 1.54634073e-01f, 3.58604163e-01f, 6.22709095e-02f, -1.02345303e-01f, 2.09158361e-01f,
  1.01003692e-01f, -8.65942314e-02f, 1.45191848e-01f, 1.17691413e-01f, -6.26087785e-02f, 2.98647910e-01f, 2.74268419e-01f, -9.89233032e-02f, -2.98644334e-01f, -1.52289033e-01f,
  3.60450372e-02f, -2.41160303e-01f, -3.51006716e-01f, -1.64301947e-01f, 1.97089165e-02f, -8.55536237e-02f, 1.29524902e-01f, -5.05356118e-02f, 2.16008276e-01f, 1.42893165e-01f,
  -1.31975830e-01f, -1.52660117e-01f, 2.39427105e-01f, -2.61190739e-02f, -1.33277819e-01f, -1.52357638e-01f, -3.51340324e-02f, -3.85180465e-03f, 4.65619937e-02f, -1.22795820e-01f,
  6.44726157e-02f, -3.86555195e-02f, 1.33365840e-01f, 1.76046547e-02f, -9.76280198e-02f, -1.25983283e-02f, -6.72013983e-02f, -1.30347908e-01f, -1.93095669e-01f, -2.26433381e-01f,
  2.83125997e-01f, 8.34399611e-02f, -1.68073803e-01f, 1.57832593e-01f, -1.17224596e-01f, -7.97588453e-02f, -3.59379984e-02f, -2.12340206e-01f, -1.52648836e-01f, -2.63758093e-01f,
  -8.35161433e-02f, -6.87450469e-02f, 6.93510547e-02f, -5.96073493e-02f, -1.05669804e-01f, 7.40035027e-02f, 1.34571746e-01f, 1.36270761e-01f, 3.79564054e-02f, 9.42048337e-03f,
  5.36019355e-02f, -3.73090655e-02f, -1.40084803e-01f, -7.60219097e-02f, -5.43086380e-02f, 7.12023899e-02f, -2.04847138e-02f, 1.09731033e-01f, 4.70683947e-02f, 1.97438318e-02f,
  -3.02516744e-02f, -5.35358675e-03f, -1.38323251e-02f, -5.67364413e-03f, 3.79293337e-02f, 8.49080179e-03f, -4.30282392e-02f, 5.36150020e-03f, -1.25406727e-01f, 6.80941865e-02f,
  -9.94300023e-02f, 1.96253225e-01f, -9.07157883e-02f, 1.07490622e-01f, 1.54935298e-02f, -2.72032507e-02f, 4.97590713e-02f, 5.71312383e-02f, 1.25489071e-01f, -1.37516290e-01f,
  -1.02760326e-02f, -6.07704893e-02f, 8.18476975e-02f, 7.71570280e-02f, -1.46688834e-01f, -1.07234875e-02f, -1.13407029e-02f, 3.14886533e-02f, 1.58275347e-02f, -4.47323248e-02f,
  4.85041514e-02f, -8.35911185e-02f, -1.55863717e-01f, 1.13335259e-01f, -7.18619153e-02f, -1.64051980e-01f, -2.32315972e-01f, -2.63471082e-02f, -7.13109374e-02f, -8.29445049e-02f,
  -2.13875830e-01f, -2.48331204e-01f, -6.76049814e-02f, 1.49036884e-01f, -2.82457769e-02f, -6.56761304e-02f, -2.47615933e-01f, 6.02941215e-02f, 1.15873031e-01f, -3.26546878e-01f,
  -9.03456509e-02f, -7.10949078e-02f, -6.13665208e-02f, -4.93992306e-02f, -3.95007342e-01f, -4.47813481e-01f, -2.89618820e-01f, -2.34698728e-01f, -1.16899256e-02f, 2.90386584e-02f,
  3.28474888e-03f, 6.24101348e-02f, 4.46812510e-02f, 1.61742434e-01f, 3.27318162e-02f, 4.84958515e-02f, 9.97151583e-02f, 1.46105364e-01f, -5.05351042e-03f, -7.15277763e-03f,
  -2.45698079e-01f, 1.80169269e-02f, 7.42796957e-02f, -1.26661137e-01f, -3.17624547e-02f, -4.17394117e-02f, -6.18359596e-02f, 1.06375210e-01f, 9.50887725e-02f, 2.32497393e-03f,
  -1.47483731e-02f, -5.07470109e-02f, 4.00600173e-02f, 7.88934156e-02f, 1.97775625e-02f, -4.36526835e-02f, -1.53124444e-02f, -4.15908992e-02f, -5.79536557e-02f, -1.20892450e-01f,
  -8.67682323e-02f, -3.62258479e-02f, 2.96335574e-02f, 1.68637946e-01f, -7.85619840e-02f, -1.02121502e-01f, 1.41955212e-01f, 1.44196868e-01f, 1.25603825e-01f, 1.12870760e-01f,
  -8.26750174e-02f, -3.12631950e-02f, 5.80497012e-02f, 4.07955758e-02f, -1.44376859e-01f, -2.15572193e-02f, 1.10101337e-02f, -9.48354416e-03f, 8.33417028e-02f, -7.59994909e-02f,
  -7.58968294e-02f, -1.47298560e-01f, -2.25430215e-03f, -6.66965023e-02f, -4.75755893e-02f, 9.79099199e-02f, -1.11470319e-01f, -1.14024030e-02f, 5.79534061e-02f, -2.33158879e-02f,
  -1.07592799e-01f, 2.45752931e-02f, 2.08116602e-02f, 1.44678220e-01f, -1.46980183e-02f, -8.81145000e-02f, 2.05721483e-02f, 1.06859304e-01f, -9.43602473e-02f, 5.74342255e-03f,
  9.87099707e-02f, 5.22147678e-02f, -1.55820921e-01f, -8.65570270e-03f, 5.19801397e-03f, 4.84489463e-03f, -3.12298331e-02f, 2.46226061e-02f, -1.07144117e-02f, 6.14869595e-02f,
  2.75363550e-02f, -1.16211995e-01f, -1.49650564e-02f, 1.02253549e-01f, -4.36247773e-02f, 1.51846278e-02f, -1.68797299e-01f, -1.51351420e-02f, -3.08999177e-02f, 1.32802486e-01f,
  -6.15838803e-02f, -2.75628030e-01f, -2.17447773e-01f, -5.46150170e-02f, 6.83113262e-02f, -1.05532438e-01f, -4.35822494e-02f, 1.16609901e-01f, -7.44587509e-03f, -2.37900257e-01f,
  -2.17142478e-01f, 3.28701019e-01f, 2.18131825e-01f, -2.79812396e-01f, 1.89134583e-01f, 3.70326966e-01f, 3.54207814e-01f, 4.58531678e-02f, 4.52327654e-02f, 8.06558207e-02f,
  2.56599247e-01f, -2.28136882e-01f, -2.46475801e-01f, -2.60366291e-01f, -3.17043602e-01f, -1.71783324e-02f, -1.80708334e-01f, -2.39364490e-01f, -2.14417025e-01f, -1.47346035e-01f,
  -1.98498324e-01f, -3.03603142e-01f, -3.69480580e-01f, -2.57243633e-01f, -5.21514714e-02f, -2.62816131e-01f, -5.58420010e-02f, -9.32238474e-02f, 7.16004372e-02f, -1.86590984e-01f,
  1.03384487e-01f, 3.49935412e-01f, 4.17180322e-02f, -1.67660132e-01f, 6.31715804e-02f, -1.37778103e-01f, 1.09221585e-01f, -5.32564633e-02f, 1.32884622e-01f, 6.52749836e-02f,
  7.76608428e-03f, 7.70702884e-02f, -1.94363743e-02f, -7.91612267e-02f, 5.39425462e-02f, 3.64070907e-02f, -1.73313528e-01f, 1.57768710e-03f, -8.67309608e-03f, 8.96246545e-03f,
  -1.80032015e-01f, 1.65923715e-01f, 7.92105645e-02f, 3.06282770e-02f, 1.92747563e-01f, -9.14430246e-02f, 2.41161853e-01f, 7.35793114e-02f, 1.02501303e-01f, -1.24012396e-01f,
  -4.00475971e-02f, 5.86301051e-02f, -1.20996200e-02f, 1.87093429e-02f, -1.36950642e-01f, 5.46500348e-02f, -8.86407048e-02f, -1.01655453e-01f, 4.79767844e-02f, -2.06422303e-02f,
  2.82166223e-03f, 6.62240610e-02f, -9.20216367e-03f, 5.80687709e-02f, -1.59263797e-02f, -1.30657330e-01f, -7.19240680e-02f, -1.55461758e-01f, -8.61862525e-02f, 4.07113656e-02f,
  -7.17622265e-02f, 1.20699488e-01f, -3.29019725e-02f, -9.67744458e-03f, 9.05263871e-02f, 2.07654107e-02f, 1.07719310e-01f, -3.10515682e-03f, -5.55495284e-02f, -7.97982961e-02f,
  -2.70229548e-01f, 1.24130003e-01f, -1.08277693e-01f, -1.65211633e-01f, 7.18582571e-02f, -6.76191002e-02f, 1.02919556e-01f, 4.84522879e-02f, 1.96290374e-01f, -1.04461484e-01f,
  2.20846877e-01f, -9.52728540e-02f, -8.05481672e-02f, -1.02450684e-01f, 9.01023857e-03f, -2.83867884e-02f, -2.14802340e-01f, -2.31882215e-01f, -3.44600566e-02f, 2.44081151e-02f,
  -1.80583671e-01f, -1.48590490e-01f, -2.90887892e-01f, -2.32507169e-01f, 2.33459063e-02f, -1.89589337e-01f, -2.98328459e-01f, -1.37182266e-01f, -1.51502684e-01f, -2.85784125e-01f,
  1.42518058e-01f, 2.11476430e-01f, 2.11944595e-01f, 2.40864083e-01f, 2.71410674e-01f, 2.35679120e-01f, 2.72601128e-01f, 9.30740088e-02f, 3.69208939e-02f, 2.59683616e-02f,
  2.07238272e-01f, -5.15540875e-02f, -8.51611719e-02f, -8.71991217e-02f, -7.74458200e-02f, -1.34457782e-01f, -1.96777821e-01f, -1.00694690e-02f, -9.98915732e-02f, 7.68499523e-02f,
  -1.34151310e-01f, -1.15875706e-01f, -7.91305304e-02f, -6.20629452e-02f, -7.70447999e-02f, -7.47290179e-02f, -6.17674738e-02f, 4.12602611e-02f, -7.27779493e-02f, -1.84971839e-01f,
  1.42229646e-01f, 2.53844410e-01f, -6.28079250e-02f, -9.90771353e-02f, 4.34498601e-02f, -6.48610592e-02f, -4.59019952e-02f, 4.46026735e-02f, 4.93757352e-02f, 1.17015108e-01f,
  -7.34340250e-02f, 4.91675436e-02f, -2.81906873e-02f, 7.94661939e-02f, 1.22874796e-01f, 3.49056497e-02f, -5.35598397e-02f, 3.66877988e-02f, 9.46076363e-02f, 2.05948018e-03f,
  -5.45685878e-03f, 1.53750792e-01f, 1.62617728e-01f, 1.49359473e-03f, -2.21990459e-02f, 5.20122536e-02f, 9.98515561e-02f, 5.80698177e-02f, 4.25384939e-02f, 3.07367872e-02f,
  -1.11383468e-01f, -6.15234077e-02f, 9.64863077e-02f, 1.28514826e-01f, -1.50554744e-03f, -5.02906851e-02f, 1.16988897e-01f, 3.39948689e-03f, -1.12180226e-01f, -1.74093973e-02f,
  1.18258394e-01f, -1.79791339e-02f, -4.69429372e-03f, 2.10495684e-02f, -3.15924101e-02f, 1.21609665e-01f, 8.88369605e-02f, 6.75479248e-02f, 8.87806416e-02f, 2.32330710e-02f,
  4.09255177e-02f, -4.23831940e-02f, -5.36063537e-02f, -2.18251441e-02f, -3.08438223e-02f, -1.33007746e-02f, -1.82748679e-02f, 8.59783404e-03f, -1.37184635e-01f, -3.71394195e-02f,
  1.07511684e-01f, 1.94429874e-01f, -6.99222162e-02f, -1.43317431e-01f, -9.49192420e-02f, 1.24619165e-02f, 3.61629203e-02f, -3.59509587e-02f, 5.49433529e-02f, 1.22569308e-01f,
  1.49314463e-01f, -7.41271162e-03f, -1.59872714e-02f, 1.74673945e-02f, 3.63412499e-02f, -2.09106896e-02f, -9.75570921e-03f, 4.74190526e-02f, -6.61786869e-02f, 8.32649246e-02f,
  -8.18125755e-02f, 1.23674415e-01f, 1.13720059e-01f, -3.80527638e-02f, -3.33309881e-02f, -7.85788372e-02f, 9.36698765e-02f, 1.20865833e-02f, -4.85292077e-03f, -1.49980620e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 26)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 26;
const float L0_fan_Bp_bar_data[] = {
  1.05977662e-01f, 2.65560597e-01f, 1.18718214e-01f, 1.83600739e-01f, -2.57043745e-02f, 3.80080968e-01f, 1.91527486e-01f, 1.15516849e-01f, 2.38266587e-01f, 1.61438122e-01f,
  1.85454458e-01f, 2.12107703e-01f, -3.81880365e-02f, 4.02713120e-01f, 3.43950950e-02f, 8.40960965e-02f, 3.47432978e-02f, 2.72619039e-01f, 1.53847694e-01f, -3.04881129e-02f,
  1.23990439e-01f, 1.02968968e-01f, 1.12906210e-01f, -5.25642484e-02f, 1.08499564e-01f, -1.22765101e-01f
};

// L1_fan_Wp (Shape: 51 x 128)
const int L1_fan_Wp_rows = 51;
const int L1_fan_Wp_cols = 128;
const float L1_fan_Wp_data[] = {
  4.50298972e-02f, 4.95405495e-02f, 5.98521382e-02f, -6.71211481e-02f, -1.72420014e-02f, -1.30897611e-01f, -5.10639586e-02f, -2.44793501e-02f, -5.75432181e-03f, 2.11605728e-02f,
  1.96782649e-01f, -1.23927765e-01f, -2.63243467e-02f, 6.46651164e-02f, 1.15378790e-01f, 9.45673976e-03f, -7.81125054e-02f, 5.77775761e-02f, 1.62837192e-01f, -1.24233300e-02f,
  -3.25365625e-02f, -1.01819728e-02f, 1.10716885e-02f, 3.11102555e-03f, -9.51669142e-02f, 7.75711909e-02f, 1.35293484e-01f, -7.66206086e-02f, -1.95415258e-01f, -1.53772291e-02f,
  -7.02417409e-03f, -1.38711859e-03f, -5.50288670e-02f, 3.33486907e-02f, -1.28507897e-01f, -8.98905024e-02f, -1.12286113e-01f, 2.52311840e-03f, -5.42439595e-02f, -2.57851444e-02f,
  -2.77913660e-02f, 1.87876597e-02f, 5.36695570e-02f, 4.17099334e-03f, -2.21712124e-02f, -1.69369444e-01f, -7.27690607e-02f, 1.51327075e-02f, 1.89425528e-01f, 5.28747216e-02f,
  -8.65818560e-03f, -2.51988798e-01f, 1.63183734e-01f, -1.32445753e-01f, -1.57373231e-02f, -8.93161669e-02f, -1.80645194e-02f, 2.01285374e-03f, 5.42782731e-02f, 7.27156028e-02f,
  -1.07083591e-02f, 8.63483623e-02f, -1.31463245e-01f, 3.80690545e-02f, -4.58157212e-02f, -6.09122701e-02f, -1.24028757e-01f, -4.60965931e-02f, -8.23616236e-02f, -6.46525174e-02f,
  3.01059037e-02f, -4.71657701e-02f, 8.18156898e-02f, 5.23436889e-02f, -1.14476241e-01f, -1.99842513e-01f, 1.11941494e-01f, 5.95700555e-02f, 9.62473974e-02f, -1.71498746e-01f,
  5.33492342e-02f, -5.79704456e-02f, -2.31116235e-01f, 9.15683340e-03f, -8.32746401e-02f, -9.35335159e-02f, -1.12442873e-01f, -2.86081344e-01f, 1.06975734e-01f, 7.03821108e-02f,
  -6.06244020e-02f, -2.69419681e-02f, 1.00512914e-01f, -1.96677476e-01f, 2.67954282e-02f, 3.56678776e-02f, 1.14078313e-01f, -2.67555192e-02f, 2.70968750e-02f, 1.53429229e-02f,
  -7.44083477e-03f, -4.14691679e-02f, 7.73441195e-02f, -1.03969283e-01f, -1.36965156e-01f, -2.11568207e-01f, -3.82694714e-02f, -1.08677566e-01f, -3.13467644e-02f, 9.48157683e-02f,
  -1.49748296e-01f, 2.81427801e-01f, 1.31345466e-01f, -1.99546218e-01f, -5.29522216e-03f, -2.57349521e-01f, 1.73908249e-01f, -4.59773093e-02f, 6.17259257e-02f, 2.95601934e-01f,
  -3.13542262e-02f, -3.29598971e-02f, -2.04980925e-01f, 7.19241947e-02f, -3.64885539e-01f, 1.25150457e-01f, -1.98938340e-01f, -7.30267838e-02f, 1.06483132e-01f, 7.14760795e-02f,
  3.71710956e-02f, 7.76834413e-02f, 2.09336672e-02f, 3.35230306e-02f, 6.32256866e-02f, -6.50319606e-02f, 6.48410544e-02f, -1.27732337e-01f, -1.24284113e-02f, -1.33436307e-01f,
  -6.20609075e-02f, 4.10426557e-02f, 3.72689031e-02f, 1.29775135e-02f, 5.51386513e-02f, 4.33165058e-02f, -8.14190283e-02f, 3.95476855e-02f, 2.60917321e-02f, 3.02126352e-02f,
  9.90426540e-02f, -3.65025662e-02f, 1.44066423e-01f, 3.94522771e-02f, 1.24048166e-01f, 5.53988591e-02f, 3.45081203e-02f, -8.85520726e-02f, 4.11038660e-02f, -3.38674448e-02f,
  -1.03111058e-01f, 8.04407347e-04f, 3.43079455e-02f, -4.92656492e-02f, 9.66145250e-04f, -1.27963554e-02f, -4.94841393e-03f, 4.06584982e-03f, 6.74029738e-02f, 1.06047839e-01f,
  -9.28782448e-02f, -7.10994303e-02f, 4.38657366e-02f, -3.03374231e-02f, 1.66030321e-02f, 6.43246025e-02f, 8.91058147e-03f, 6.09449148e-02f, 4.66957539e-02f, 4.27160636e-02f,
  3.12961750e-02f, 3.11639905e-01f, -7.55746737e-02f, 7.42576122e-02f, 1.86706465e-02f, 5.16674072e-02f, -6.70817075e-03f, -8.24992433e-02f, 2.52626501e-02f, -3.01396009e-02f,
  4.52601574e-02f, 3.31413560e-02f, 5.80410510e-02f, 1.01879716e-01f, 7.35104606e-02f, -8.65393281e-02f, 1.28133640e-01f, -2.48615444e-03f, -1.38160259e-01f, 2.23017544e-01f,
  -1.99383214e-01f, 6.89886734e-02f, -1.83756694e-01f, 2.23127063e-02f, 8.97659585e-02f, -2.80493889e-02f, -9.99781936e-02f, 3.05156745e-02f, -8.49027708e-02f, 7.00724572e-02f,
  6.01401143e-02f, -4.18132544e-02f, 1.26906529e-01f, -1.46215543e-01f, -1.63462356e-01f, 7.08184689e-02f, 6.62131533e-02f, 2.98161775e-01f, -1.73105821e-01f, 1.98819563e-02f,
  -2.00102497e-02f, -1.42636731e-01f, -1.55331478e-01f, 1.64574564e-01f, -2.80355904e-02f, -2.10704267e-01f, -9.25463587e-02f, 2.65034974e-01f, 4.80026715e-02f, 6.22681230e-02f,
  -2.43978128e-01f, -9.93873253e-02f, 1.60487860e-01f, -2.26767529e-02f, 1.11326359e-01f, 5.64011224e-02f, -1.69019371e-01f, -1.01435155e-01f, 1.01327486e-01f, -5.48282787e-02f,
  -9.44830850e-02f, 1.68313265e-01f, -8.66512805e-02f, 2.59661302e-02f, 1.57775536e-01f, 9.88378376e-02f, 2.22299080e-02f, 7.56906569e-02f, 6.56471178e-02f, 1.56155042e-02f,
  1.75487533e-01f, -1.80997755e-02f, -2.85785925e-03f, -2.00167149e-02f, 1.05952077e-01f, 1.38285801e-01f, -2.06551179e-02f, 4.96413857e-02f, -1.04856297e-01f, 5.22342473e-02f,
  -5.50027937e-02f, 1.38914632e-02f, -1.85245052e-02f, -5.13981096e-02f, 2.05225125e-03f, -1.32843018e-01f, -6.22749254e-02f, -8.23007058e-03f, -5.65751679e-02f, 4.60162535e-02f,
  -1.76785603e-01f, -3.29376347e-02f, 1.24318913e-01f, -1.24948144e-01f, -1.64160520e-01f, -2.53901035e-02f, -8.54906291e-02f, -6.06302842e-02f, 6.63615018e-02f, -8.11704993e-02f,
  1.20718129e-01f, 7.01651024e-03f, -4.42895517e-02f, -9.65063870e-02f, 2.75898185e-02f, 7.33394828e-03f, 2.95723118e-02f, -1.43402517e-01f, -5.92307560e-02f, -2.72074565e-02f,
  -2.26045195e-02f, -1.31846443e-02f, 4.19509336e-02f, -1.24723211e-01f, 1.59896035e-02f, 4.53210920e-02f, 1.18264928e-01f, 9.34670791e-02f, -8.75968859e-03f, 4.96571744e-03f,
  5.13156317e-02f, -2.41278671e-03f, -5.41287102e-03f, -5.60612492e-02f, -9.02689472e-02f, -3.91271338e-02f, 9.13710073e-02f, 4.27575149e-02f, 2.86615714e-02f, 3.96090746e-01f,
  1.60458371e-01f, 8.85394812e-02f, -6.36679381e-02f, 2.82064155e-02f, -2.44384080e-01f, -8.16468000e-02f, -1.70320541e-01f, -1.52171686e-01f, 2.17916612e-02f, -4.83129472e-02f,
  4.49090078e-02f, 1.23385694e-02f, 1.42399445e-01f, -4.03986536e-02f, 9.60119441e-02f, 2.10306831e-02f, 4.04609777e-02f, 5.56434132e-02f, 5.19034304e-02f, 2.22568605e-02f,
  -2.21118871e-02f, 1.81014687e-01f, -2.44817615e-01f, -3.99548076e-02f, -1.66869834e-01f, 5.95744513e-02f, -9.13351104e-02f, 3.34205888e-02f, -4.68149409e-02f, -9.67896804e-02f,
  -3.71585079e-02f, -6.91178581e-03f, -8.14297050e-02f, 1.52922496e-01f, -1.92014262e-01f, -1.50196012e-02f, -1.02079257e-01f, 3.69444638e-02f, -6.30985424e-02f, 2.37153322e-02f,
  1.25613362e-01f, -1.35284528e-01f, 9.28581227e-03f, -3.00549734e-02f, 7.90886134e-02f, 4.62522320e-02f, -2.23324820e-02f, 1.69340864e-01f, -1.18467964e-01f, 4.00863867e-03f,
  1.10646389e-01f, 1.59894768e-02f, 6.72740340e-02f, 2.81273991e-01f, 3.98019999e-02f, -5.22954799e-02f, 1.66426405e-01f, -1.48328513e-01f, -6.12785183e-02f, 2.79748172e-01f,
  -1.03888690e-01f, 2.06789315e-01f, -1.02720939e-01f, 2.75701638e-02f, -1.74378008e-02f, -2.08494365e-01f, 6.26298040e-02f, 4.89536896e-02f, 3.24219108e-01f, -7.67076239e-02f,
  3.04928988e-01f, 1.96670052e-02f, 2.26117462e-01f, 3.89400944e-02f, 7.95418993e-02f, 3.38080935e-02f, 3.24130431e-02f, -4.89768386e-02f, -7.21839210e-03f, -1.17686152e-01f,
  -7.35718906e-02f, 3.98518145e-02f, -5.63115180e-02f, 9.16807652e-02f, -8.63876119e-02f, -2.29834653e-02f, 4.54094000e-02f, 5.96706429e-03f, 4.53882180e-02f, -1.07404411e-01f,
  4.13555801e-02f, -1.45548686e-01f, -8.09322298e-02f, 1.59791186e-02f, 1.12969838e-01f, 9.64549854e-02f, 7.84165040e-02f, -3.29593904e-02f, 1.79247446e-02f, -5.51976524e-02f,
  1.68395266e-02f, -1.27957731e-01f, 1.22354910e-01f, 6.35831207e-02f, 3.02696098e-02f, -1.17530964e-01f, 7.45536685e-02f, -4.71847616e-02f, 1.60075538e-02f, -1.19621314e-01f,
  -9.56257712e-03f, 2.45539062e-02f, -5.62338904e-02f, 6.08467124e-02f, 9.07453336e-03f, -1.71883166e-01f, 5.21647446e-02f, -3.83578874e-02f, -1.83809840e-03f, 1.05144434e-01f,
  1.03008173e-01f, -1.19370386e-01f, 7.50595331e-02f, 1.42228315e-02f, -1.28914163e-01f, 6.96507562e-03f, -7.58021027e-02f, -1.85125768e-01f, 6.67019635e-02f, 1.76879670e-02f,
  -9.87173617e-02f, 9.19782668e-02f, 1.00863655e-03f, -2.83572893e-03f, -1.64244659e-02f, 1.93609104e-01f, 3.30514610e-02f, -1.27351740e-02f, -1.92204397e-02f, 3.34652625e-02f,
  -6.70471936e-02f, 9.55931321e-02f, 3.03916276e-01f, 1.73084393e-01f, 1.48720235e-01f, -2.63726473e-01f, 1.90117750e-02f, 7.92307407e-02f, 8.06789026e-02f, -1.20344080e-01f,
  1.05163902e-01f, 1.70783177e-02f, 2.64581084e-01f, 1.07991233e-01f, -7.89569616e-02f, -1.07186243e-01f, 1.34201854e-01f, 1.41064048e-01f, -1.51837200e-01f, 1.85851723e-01f,
  1.43326998e-01f, -1.04840428e-01f, 3.45036507e-01f, -6.20651431e-02f, 9.03852731e-02f, -1.43353119e-02f, 5.44226356e-02f, -1.17272399e-02f, -1.83897227e-01f, -4.45638448e-02f,
  1.59682110e-01f, 2.42351778e-02f, 1.01650050e-02f, -2.94250220e-01f, 1.89385191e-02f, 1.62025690e-02f, 6.01104274e-02f, -1.89970344e-01f, -8.09921473e-02f, 1.02090992e-01f,
  3.03395055e-02f, -1.72020793e-02f, 2.42627189e-01f, 2.85073698e-01f, -5.31046800e-02f, 1.31045610e-01f, 1.73072908e-02f, -3.34291458e-01f, 1.32243052e-01f, -1.21306796e-02f,
  -6.31790310e-02f, 1.42160177e-01f, -1.10644009e-02f, -2.41511732e-01f, -4.31470275e-02f, -9.99655724e-02f, -2.18316197e-01f, 1.89126916e-02f, -2.67704427e-02f, 2.70959493e-02f,
  -7.52090812e-02f, -3.56340297e-02f, -3.22682001e-02f, 6.82357922e-02f, 3.42617068e-03f, -1.23786449e-01f, 1.55735105e-01f, -9.30222049e-02f, 1.63650289e-02f, 6.15179576e-02f,
  6.78436384e-02f, -6.70533720e-03f, 8.91069043e-03f, 3.68570238e-02f, -1.79270096e-02f, -4.23094779e-02f, 1.61614064e-02f, 4.64521050e-02f, 1.48703074e-02f, 2.18965020e-02f,
  2.01044962e-01f, 3.23662162e-02f, -2.09993124e-02f, -2.95898560e-02f, 4.27438840e-02f, 9.81954634e-02f, 3.36445011e-02f, 7.89602324e-02f, 1.44091606e-01f, 9.76317376e-02f,
  -5.20418808e-02f, -1.80355459e-02f, -4.38928530e-02f, 1.05113201e-01f, 4.01851572e-02f, -1.56019498e-02f, -8.38514194e-02f, 1.07873693e-01f, 1.58755574e-02f, 1.68514624e-01f,
  5.38663454e-02f, -4.91417758e-02f, -8.04674476e-02f, 9.73094255e-02f, -6.01225346e-02f, 1.59314856e-01f, -2.69227643e-02f, 3.17275748e-02f, -4.82426444e-03f, 4.49282527e-02f,
  1.58812270e-01f, -2.78939325e-02f, 7.22013190e-02f, 7.70141482e-02f, -8.07934031e-02f, -2.65152544e-01f, -3.24691944e-02f, -2.15597674e-02f, -6.83891773e-02f, 5.62694743e-02f,
  4.48926128e-02f, 1.30522475e-01f, -1.69240370e-01f, 1.02487460e-01f, -1.65853158e-01f, 9.88744944e-02f, 7.55064115e-02f, -2.93486882e-02f, -3.96946818e-02f, -3.13336179e-02f,
  -5.68618160e-03f, 1.77447684e-03f, 7.74066299e-02f, -5.08540496e-02f, -2.18127351e-02f, -1.66720469e-02f, 2.14579441e-02f, -6.46679923e-02f, 4.42225039e-02f, 1.98484324e-02f,
  1.84662908e-01f, -1.50700569e-01f, 6.92134723e-02f, -1.74249530e-01f, 7.43260607e-02f, 3.09277363e-02f, -8.95389542e-02f, 1.51371397e-02f, 5.55373132e-02f, -1.92689151e-01f,
  3.20370764e-01f, 7.06312805e-02f, 6.39414936e-02f, -3.72098647e-02f, 1.29698947e-01f, 7.19503760e-02f, -1.10409714e-01f, 1.82579949e-01f, 7.37828687e-02f, 1.29589155e-01f,
  -2.35356800e-02f, -7.92567581e-02f, 8.68385583e-02f, -1.80577978e-01f, 3.04515630e-01f, -6.53619841e-02f, -1.64171234e-01f, -7.26164579e-02f, -4.88043278e-02f, 5.90765439e-02f,
  2.66797423e-01f, 1.31593749e-01f, -6.46333396e-02f, 2.09252104e-01f, 3.79993841e-02f, -3.60727191e-01f, 1.30411968e-01f, -8.40583518e-02f, -1.09769888e-01f, -8.47006515e-02f,
  1.59090325e-01f, -1.34363338e-01f, -9.05238912e-02f, -1.28013581e-01f, -2.93732077e-01f, 8.33944082e-02f, -2.16648906e-01f, -5.50117791e-02f, -3.01225279e-02f, -1.38644889e-01f,
  8.18787739e-02f, -7.15985894e-02f, -1.30643025e-01f, 5.14449850e-02f, 1.96629707e-02f, 9.12681520e-02f, -1.72120389e-02f, -9.46252346e-02f, 3.08662653e-02f, -1.24870844e-01f,
  -2.52367575e-02f, -4.81291581e-03f, -2.73250788e-03f, 7.01102093e-02f, -6.53788224e-02f, -4.40846384e-02f, 4.39029373e-02f, 4.49807905e-02f, -4.51967446e-03f, -9.45428479e-03f,
  2.37966166e-03f, -6.13098871e-03f, 2.68507060e-02f, -1.59808267e-02f, 1.25916272e-01f, 4.09944542e-02f, 5.65040438e-03f, 8.11086595e-02f, 3.76609005e-02f, 2.62624938e-02f,
  7.13583082e-03f, -3.82097624e-02f, -2.58279257e-02f, -6.96566701e-02f, 2.98693255e-02f, 4.44347672e-02f, 1.10248022e-01f, 1.12338988e-02f, -9.60460224e-04f, 8.14362466e-02f,
  -5.57741849e-03f, 2.06053238e-02f, -2.35733800e-02f, -2.57693399e-02f, 1.00664161e-01f, 4.74766269e-02f, 3.87009718e-02f, 9.70559195e-02f, 9.88757759e-02f, 1.69634312e-01f,
  -2.90670376e-02f, 5.81393810e-03f, 7.19873607e-02f, 2.25272700e-01f, -6.30741119e-02f, -1.26470730e-01f, -3.54812294e-02f, -4.49817888e-02f, -9.37791169e-02f, -3.85664664e-02f,
  -1.15526328e-02f, -1.29254937e-01f, -6.15769401e-02f, -5.45265805e-03f, -1.00216672e-01f, -4.10229750e-02f, 1.38626367e-01f, 1.15245089e-01f, -7.36022592e-02f, -2.62158155e-01f,
  2.92044431e-02f, 5.90294308e-04f, -2.88569805e-04f, 1.15404208e-03f, -2.66015064e-02f, 8.97861570e-02f, -1.29100516e-01f, 4.02848683e-02f, -3.92623454e-01f, -1.90629009e-02f,
  -2.16076914e-02f, 1.05406307e-01f, -1.43626809e-01f, -2.18704753e-02f, 1.04187168e-02f, -1.08589239e-01f, -2.06176683e-01f, 2.14740276e-01f, -3.73391241e-01f, 1.99567736e-03f,
  -1.41340822e-01f, 2.30008848e-02f, 7.90031068e-03f, -7.26489127e-02f, 1.25438482e-01f, 4.46402747e-03f, -8.67054090e-02f, -3.28383446e-02f, -6.56071976e-02f, 1.26734087e-02f,
  -4.13251594e-02f, 1.29958704e-01f, -3.03975880e-01f, 2.79557109e-01f, 7.71452785e-02f, -1.18496530e-01f, -1.54196039e-01f, 4.01310287e-02f, 5.12215048e-02f, -8.48984346e-02f,
  -2.07227349e-01f, -1.50383532e-01f, 1.12627763e-02f, 2.05844432e-01f, -5.23353294e-02f, -2.04841614e-01f, -8.94477591e-02f, 1.33545935e-01f, 2.44458355e-02f, 7.22223073e-02f,
  3.86006646e-02f, 1.01337880e-01f, 3.00683618e-01f, 2.07032058e-02f, 2.30246007e-01f, -2.16497481e-02f, 1.55236170e-01f, -6.76252171e-02f, -1.42030790e-01f, -1.71529409e-03f,
  6.61148876e-02f, 1.07001573e-01f, -1.76172052e-02f, 2.22956359e-01f, -1.26765534e-01f, 3.63428742e-02f, 4.16079955e-03f, 1.78151000e-02f, -1.75550934e-02f, -9.44730546e-03f,
  -5.85860340e-03f, 8.98130015e-02f, 3.22462688e-03f, 8.20916742e-02f, -8.32171589e-02f, 7.27671012e-03f, -2.69875713e-02f, 3.87908742e-02f, 7.77802840e-02f, 5.42401932e-02f,
  9.03257802e-02f, 7.22433999e-02f, 5.75528219e-02f, 1.07622445e-01f, -6.83961494e-04f, -1.31171010e-02f, 8.21473822e-02f, 7.78036416e-02f, -4.83011492e-02f, -6.40210658e-02f,
  -8.93154517e-02f, 1.73222777e-02f, 3.83928567e-02f, 6.18107915e-02f, -1.51017299e-02f, -1.76803432e-02f, -1.15737207e-01f, 4.39845175e-02f, 5.36437146e-03f, 1.46255568e-02f,
  -4.79941629e-02f, 1.49060925e-02f, -1.08985059e-01f, -3.92596759e-02f, -7.71945491e-02f, 1.10473931e-01f, 1.99010130e-02f, 1.22096479e-01f, 8.41773599e-02f, -2.69202911e-03f,
  -6.29646629e-02f, 1.37803495e-01f, 8.04059729e-02f, -1.06998533e-01f, 1.76813945e-01f, 2.12212708e-02f, -5.48032597e-02f, -1.31014362e-01f, 1.69252619e-01f, -2.76213679e-02f,
  -3.83587517e-02f, -1.06404357e-01f, -1.07058607e-01f, 1.93603728e-02f, 2.10885704e-02f, 9.64521198e-04f, -1.41297743e-01f, -4.37958129e-02f, -4.76918146e-02f, 9.05923769e-02f,
  -7.93376192e-02f, -5.59844449e-02f, -1.01512924e-01f, 1.25184432e-01f, 7.04140309e-03f, 1.02227040e-01f, -2.95284480e-01f, 1.57988444e-01f, -7.35454932e-02f, 2.39636879e-02f,
  -1.48104817e-01f, -2.33855415e-02f, 1.19584143e-01f, -2.47137278e-01f, -1.14579260e-01f, 1.79619238e-01f, -2.03490242e-01f, 1.09267812e-02f, -1.03674799e-01f, -1.36669353e-01f,
  -1.33989319e-01f, -1.49786815e-01f, 6.03431500e-02f, 1.95610598e-02f, -1.59560755e-01f, -3.76009569e-02f, -1.44993132e-02f, 2.84622703e-02f, 7.02427700e-02f, 1.80257633e-01f,
  -3.33953261e-01f, 1.58891335e-01f, -5.75607158e-02f, -1.05959073e-01f, -6.85895309e-02f, 2.83417702e-01f, -1.00891881e-01f, 4.25881557e-02f, -5.78710549e-02f, -2.78437525e-01f,
  -5.39375916e-02f, 2.23017558e-01f, -2.95306109e-02f, 6.96343929e-02f, -2.08525429e-03f, 4.09510285e-02f, -7.14933872e-02f, -1.13514110e-01f, -8.15688074e-02f, 1.23473175e-01f,
  2.92127311e-01f, 9.12419856e-02f, 4.92069051e-02f, -1.58238515e-01f, 9.47674736e-02f, -3.86618115e-02f, 4.11242247e-02f, 1.23243734e-01f, 6.21930733e-02f, 6.64406829e-03f,
  1.36014819e-01f, -7.29375035e-02f, -1.54637173e-01f, 6.63472638e-02f, 3.23651582e-02f, 1.67021364e-01f, -1.21312685e-01f, 4.85901199e-02f, 2.28339732e-02f, 1.83035627e-01f,
  3.03700212e-02f, 4.78411876e-02f, 8.18456933e-02f, -6.21980391e-02f, 3.96316033e-03f, 3.92571427e-02f, -7.61759132e-02f, 1.43947825e-01f, -6.21731207e-03f, -8.84270892e-02f,
  6.75076544e-02f, -1.84673704e-02f, -3.91497351e-02f, 4.60652187e-02f, 2.45263092e-02f, 7.76697230e-03f, -8.72692913e-02f, -1.50849417e-01f, -7.02836514e-02f, 3.25840302e-02f,
  1.02861308e-01f, -4.85715419e-02f, -3.88385877e-02f, 1.72835663e-01f, -9.93148759e-02f, -3.30872834e-02f, -3.73711810e-02f, 2.85892114e-02f, 3.12617719e-02f, -5.60089527e-03f,
  -1.12392227e-04f, -1.92988709e-01f, -1.92433998e-01f, 5.36844134e-02f, -9.61070731e-02f, -9.95099321e-02f, -1.82011761e-02f, -1.27974153e-01f, 2.82909293e-02f, 7.48078898e-03f,
  -2.35688593e-02f, -3.96904349e-01f, 1.67693421e-01f, -7.52095878e-02f, -5.69837540e-03f, -1.39687480e-02f, -1.12675242e-01f, 1.00517385e-02f, 8.32264051e-02f, 6.51590433e-03f,
  -3.06697953e-02f, -8.43122080e-02f, -3.14969942e-02f, -9.39374194e-02f, -1.95247591e-01f, 2.17072181e-02f, 2.82342099e-02f, -1.09642586e-02f, 1.12361619e-02f, 3.86314541e-02f,
  9.18210484e-03f, -4.78236154e-02f, 1.73371747e-01f, 1.72508825e-02f, -1.03428930e-01f, 1.64282024e-01f, 2.37451792e-02f, -7.10075498e-02f, 1.89203061e-02f, -1.15408108e-01f,
  4.64440398e-02f, -1.87108517e-01f, 9.52172354e-02f, -7.82099217e-02f, -2.56947279e-02f, 3.59836072e-02f, 5.02443463e-02f, -3.46940868e-02f, 1.09832166e-02f, -1.74701154e-01f,
  -4.10260968e-02f, -1.72558397e-01f, -2.80479014e-01f, 7.08666742e-02f, -8.15114900e-02f, -1.68482542e-01f, 1.27230391e-01f, 1.59729555e-01f, -1.69856146e-01f, -1.02511518e-01f,
  3.10909953e-02f, -2.57857293e-02f, -1.28828749e-01f, 9.81533527e-02f, 3.96571830e-02f, 7.46517256e-02f, -1.64193995e-02f, -1.21780314e-01f, 1.39632225e-01f, -6.81467727e-02f,
  2.03236729e-01f, 4.60137315e-02f, -1.99194953e-01f, 1.74175709e-01f, 1.40989080e-01f, -1.76807165e-01f, 1.67986173e-02f, -1.48453310e-01f, -2.58305639e-01f, -1.47554636e-01f,
  6.49413988e-02f, -4.31852639e-02f, 1.45280048e-01f, 2.26645768e-02f, -8.06051046e-02f, 1.75136283e-01f, 4.03615683e-02f, -4.29982878e-02f, 1.31813735e-01f, 6.77707344e-02f,
  1.52157387e-02f, 1.16003320e-01f, 5.27646951e-02f, 1.40058935e-01f, 6.66564181e-02f, -1.36058763e-01f, 1.19678542e-01f, -4.00278531e-02f, 8.11171532e-02f, 2.56353170e-02f,
  3.44285406e-02f, 6.34343103e-02f, 1.81292333e-02f, -5.94093390e-02f, 8.01923946e-02f, 2.06950363e-02f, 4.91410904e-02f, 2.01143119e-02f, 5.21110445e-02f, -4.38700542e-02f,
  1.02386236e-01f, -2.78734453e-02f, 1.06098108e-01f, -1.29310433e-02f, 4.78218831e-02f, 8.63820761e-02f, -1.75191031e-03f, 1.58244550e-01f, 1.79008916e-02f, 5.32162152e-02f,
  -1.46786189e-02f, 1.40437707e-01f, 3.32293659e-02f, -1.25466645e-01f, -1.49268368e-02f, 8.74648243e-02f, -3.29361893e-02f, 1.53241102e-02f, 1.55667305e-01f, 4.23315763e-02f,
  -5.21878786e-02f, 7.07618892e-02f, 5.09325154e-02f, -2.29723547e-02f, 1.28243119e-01f, 8.85667950e-02f, 1.05662895e-02f, 1.47753343e-01f, 3.65891457e-02f, 4.72915061e-02f,
  -3.64257246e-02f, -2.22897343e-02f, 6.19333237e-02f, 3.47155263e-03f, -6.36140704e-02f, 2.42133722e-01f, -9.35948491e-02f, -2.00083375e-01f, -1.01387054e-01f, 4.65730540e-02f,
  2.56061181e-02f, -5.23981862e-02f, 7.21586794e-02f, 1.88253507e-01f, 1.39500812e-01f, -3.22352350e-02f, 1.33152287e-02f, 1.27809882e-01f, 6.25242144e-02f, -1.14257462e-01f,
  1.57048941e-01f, 1.56612068e-01f, 1.55210719e-01f, 6.01909310e-03f, -2.85378899e-02f, -1.81584712e-03f, 1.14865862e-01f, 1.77413881e-01f, -1.82890203e-02f, -1.90087751e-01f,
  -2.44037732e-02f, -2.17752710e-01f, 8.86489265e-03f, 1.51113987e-01f, -1.21227756e-01f, -4.27283198e-02f, -2.44634971e-02f, -1.18040539e-01f, 1.11959673e-01f, 1.23508632e-01f,
  2.44693998e-02f, -6.98420182e-02f, 1.14721313e-01f, -5.24887070e-02f, 1.64376274e-01f, 9.07713771e-02f, -1.64819330e-01f, -2.43109420e-01f, 1.76073566e-01f, -4.80446257e-02f,
  -9.01617706e-02f, 5.83390519e-02f, -3.89346108e-02f, -9.42950845e-02f, -9.50461552e-02f, 8.12211782e-02f, -6.53383695e-03f, -1.00673705e-01f, -1.90028906e-01f, -1.19513124e-01f,
  6.00509420e-02f, -4.25945297e-02f, -1.26370534e-01f, 7.43048415e-02f, 1.89279560e-02f, -1.17549129e-01f, -3.30634005e-02f, 3.13289054e-02f, -2.65133470e-01f, 1.45614631e-02f,
  -5.40700704e-02f, -9.18809175e-02f, 1.30247563e-01f, -7.82791525e-02f, -4.60513197e-02f, -5.59618995e-02f, 1.02324910e-01f, 1.35636136e-01f, -6.00792235e-03f, 9.03336108e-02f,
  -1.32649215e-02f, 3.63577791e-02f, 2.39218865e-02f, 7.98995718e-02f, 3.68527547e-02f, -8.53601564e-03f, 2.60856077e-02f, 5.80155961e-02f, -6.25062063e-02f, -5.19753769e-02f,
  9.19564441e-02f, -1.02699986e-02f, -3.94717790e-02f, -7.46426284e-02f, -1.11431070e-01f, 9.49486159e-03f, -6.23794533e-02f, 5.29669300e-02f, -6.28313869e-02f, -6.35078996e-02f,
  -7.94962123e-02f, 7.29291365e-02f, -4.14576568e-02f, 1.58587955e-02f, -5.84268011e-02f, 1.09309807e-01f, 1.17040195e-01f, 8.02059993e-02f, -2.58949883e-02f, -1.50233954e-01f,
  2.67434381e-02f, -5.17908633e-02f, -5.80256851e-03f, 4.82209120e-03f, 1.97637938e-02f, -1.16283208e-01f, 4.74979281e-02f, 2.34697927e-02f, 9.61308777e-02f, -1.25112474e-01f,
  4.81865481e-02f, 1.59527421e-01f, 2.25722305e-02f, -1.43708624e-02f, -1.58090159e-01f, 6.31989539e-02f, 2.71034357e-03f, 2.86218584e-01f, -9.35886577e-02f, 3.55489403e-02f,
  -1.68641016e-01f, 1.73694551e-01f, -9.05627981e-02f, -1.30277619e-01f, -6.09115362e-02f, 9.25044864e-02f, 3.19777280e-02f, -1.00358695e-01f, 7.06104115e-02f, -3.37149426e-02f,
  1.35819212e-01f, -7.61571899e-02f, -1.57878652e-01f, 5.20949587e-02f, 3.10657099e-02f, -7.30418786e-02f, -1.37964748e-02f, 9.67625454e-02f, -6.72719181e-02f, -3.69607247e-02f,
  -1.68604963e-02f, -9.16036293e-02f, -3.69188301e-02f, 4.60309498e-02f, -1.77993793e-02f, -3.71613540e-02f, -1.00914679e-01f, 1.25292897e-01f, -4.78804955e-04f, 3.22062671e-02f,
  -5.48713952e-02f, 1.12179317e-01f, -1.35471836e-01f, 1.14485085e-01f, -1.16582654e-01f, 1.76378667e-01f, -3.69397737e-02f, -3.07021532e-02f, 9.75739285e-02f, -1.28276885e-01f,
  1.31131887e-01f, 1.98130414e-01f, -1.99004248e-01f, 8.57651085e-02f, 9.95902345e-02f, 1.37697652e-01f, -2.11640149e-01f, -3.20978537e-02f, -1.27094209e-01f, -9.18743014e-03f,
  1.85360432e-01f, -1.64820835e-01f, -1.49348423e-01f, -2.63577104e-01f, 8.62393752e-02f, 3.18209797e-01f, -6.98784143e-02f, -2.71027088e-02f, -9.11684036e-02f, 1.43402778e-02f,
  -6.26965687e-02f, -7.75379762e-02f, -1.44970655e-01f, -3.75943556e-02f, 2.97961861e-01f, 6.92036794e-03f, 2.57617205e-01f, -1.44746024e-02f, -3.37989889e-02f, -1.31181791e-01f,
  -3.61892791e-03f, -5.61053790e-02f, -1.05311073e-01f, 2.99088378e-02f, -3.46138049e-03f, 9.39870998e-02f, 2.50321832e-02f, -1.29967313e-02f, -3.72499079e-02f, -8.35982785e-02f,
  2.09244546e-02f, 6.71612620e-02f, -8.93875733e-02f, -7.97601193e-02f, 6.32317783e-03f, -6.63984288e-03f, -5.31458519e-02f, -1.33541241e-01f, 1.43038422e-01f, -7.77496472e-02f,
  6.33800030e-02f, 6.26059398e-02f, -1.72420982e-02f, 2.39420459e-02f, -7.38763884e-02f, -1.11434929e-01f, -5.47183566e-02f, -1.47748534e-02f, -1.10456608e-01f, 2.33625360e-02f,
  3.58896554e-02f, -4.76544574e-02f, 4.01936285e-02f, 5.80896176e-02f, 4.84175161e-02f, 1.09448489e-02f, 9.29807574e-02f, -2.70147920e-02f, 3.97875160e-02f, 1.92691386e-02f,
  8.91553164e-02f, -1.79010555e-02f, -1.79740749e-02f, -9.43624377e-02f, 5.31857945e-02f, 2.22997263e-01f, 4.70173080e-03f, -9.44605544e-02f, -3.37548517e-02f, 7.14714602e-02f,
  4.72492278e-02f, -4.80999686e-02f, -3.01148128e-02f, -1.10371731e-01f, -9.01231766e-02f, 1.63990166e-02f, -7.22127631e-02f, -9.69782099e-02f, 7.73978047e-03f, -1.35719255e-01f,
  1.26088575e-01f, -2.11942017e-01f, 5.86046614e-02f, -7.65783712e-02f, 9.03931484e-02f, 4.94519845e-02f, -2.35377923e-01f, 1.95714965e-01f, -9.68610942e-02f, -1.78103477e-01f,
  3.89549844e-02f, 4.42954246e-03f, -3.53439413e-02f, -1.65923014e-01f, 6.72428086e-02f, -9.03878435e-02f, -1.96110204e-01f, -1.20369360e-01f, -3.08687449e-01f, 1.49721444e-01f,
  4.26635109e-02f, 7.99650326e-02f, -2.60990262e-01f, -3.59498523e-03f, 1.48647085e-01f, 2.63712667e-02f, 1.09871052e-01f, 2.36050040e-01f, -2.19240189e-01f, -1.00265421e-01f,
  -2.26133853e-01f, -6.24487288e-02f, -2.02455781e-02f, 1.39174059e-01f, 4.22949791e-02f, -1.34933636e-01f, 1.28590718e-01f, -3.28106210e-02f, -3.46669927e-04f, -1.64776534e-01f,
  -1.17625758e-01f, -8.97579491e-02f, -4.50958908e-02f, 1.29079863e-01f, -2.01159015e-01f, 1.90649882e-01f, -2.99059264e-02f, 1.35807320e-01f, -1.26211762e-01f, -1.15239352e-04f,
  -1.49567667e-02f, -1.65570602e-02f, -1.11522980e-01f, 1.45931676e-01f, 1.07217595e-01f, -6.13495782e-02f, -2.81187650e-02f, -1.46495495e-02f, 4.60633710e-02f, 7.47820809e-02f,
  -6.00448139e-02f, 4.21930730e-01f, 1.87772423e-01f, 9.61295441e-02f, 4.10370640e-02f, 1.45710111e-01f, 3.72196473e-02f, -7.71846622e-02f, 7.15173036e-03f, 1.34328127e-01f,
  3.26960757e-02f, -3.31810191e-02f, -1.58461612e-02f, 7.45244464e-03f, 8.36566389e-02f, -1.00812756e-01f, -5.89127727e-02f, -2.23050043e-02f, -1.34135678e-01f, -9.30465236e-02f,
  1.12705149e-01f, -1.23866536e-02f, -6.00171415e-03f, 5.34898490e-02f, 1.23538204e-01f, -2.27131769e-02f, -7.48081133e-02f, 1.16250612e-01f, -6.18596412e-02f, 8.28434974e-02f,
  1.46529926e-02f, -1.36479795e-01f, 6.75069019e-02f, -6.23763800e-02f, 5.78478118e-03f, -3.88058536e-02f, 5.20522371e-02f, -1.00076579e-01f, 3.27790640e-02f, -7.08537325e-02f,
  -5.26464805e-02f, -1.04339533e-02f, -5.68636358e-02f, 2.74734199e-02f, -4.11212035e-02f, 7.63820484e-02f, -6.96649775e-02f, -8.20180103e-02f, -1.18548153e-02f, -8.49291608e-02f,
  -4.49315831e-02f, 5.39515764e-02f, 2.33627278e-02f, 8.49137604e-02f, -6.91661090e-02f, 1.29188960e-02f, -1.03386141e-01f, -1.24537513e-01f, -6.58888519e-02f, 1.72053482e-02f,
  -2.59720922e-01f, 1.38083799e-02f, 8.03603381e-02f, -2.11753786e-01f, 1.02220168e-02f, -8.62729102e-02f, -5.77634387e-02f, -1.15793504e-01f, 5.51485494e-02f, -8.55894685e-02f,
  1.12379767e-01f, -1.60394087e-02f, -4.87482771e-02f, 8.11839104e-02f, 1.34985983e-01f, -3.36698294e-02f, 4.98513095e-02f, 1.68586358e-01f, 7.08822906e-02f, -3.81697863e-02f,
  2.95668114e-02f, -1.40504213e-04f, 1.80802997e-02f, 1.19745247e-01f, 7.68286288e-02f, 6.10905811e-02f, -1.32806942e-01f, 7.22493157e-02f, -1.32759631e-01f, 5.72085641e-02f,
  1.20514236e-01f, -4.63123135e-02f, 6.84030801e-02f, -7.78863356e-02f, 4.32430618e-02f, 4.51811366e-02f, -1.85060035e-03f, 5.68765029e-02f, -1.54573414e-02f, -4.16673757e-02f,
  -4.45204861e-02f, -4.85010184e-02f, -6.69265911e-02f, -1.17767006e-01f, 9.08232033e-02f, -6.27318397e-02f, -6.61426336e-02f, -1.21858753e-01f, 7.38853216e-02f, 2.15575490e-02f,
  -4.08916682e-01f, -1.63019463e-01f, 9.81618538e-02f, -1.37620028e-02f, 1.42918378e-01f, 7.59203136e-02f, 8.95180181e-02f, -1.07945397e-01f, 1.93879575e-01f, -1.64930671e-01f,
  -1.06961146e-01f, -1.66804880e-01f, 5.29811643e-02f, 1.06327698e-01f, 7.95071721e-02f, 6.52395003e-03f, -1.70412101e-02f, -1.73176482e-01f, 1.31959066e-01f, -2.36150742e-01f,
  -2.23601356e-01f, 6.30866662e-02f, 1.03552215e-01f, -1.69197470e-01f, 8.83644000e-02f, 1.82074443e-01f, -1.13866692e-02f, 1.47922039e-01f, 7.92251602e-02f, 1.28800675e-01f,
  1.06770352e-01f, -7.90055096e-02f, 4.60361950e-02f, -2.89366413e-02f, 4.17229757e-02f, -1.44551164e-02f, -3.65636945e-02f, -5.67232110e-02f, 4.64072600e-02f, 7.18123019e-02f,
  6.02581305e-03f, 1.16722845e-01f, 1.75817832e-02f, -9.18608159e-03f, -2.98506618e-02f, 2.87027545e-02f, 4.96532694e-02f, 1.82120558e-02f, -7.79533312e-02f, -7.53669813e-02f,
  -2.32897475e-02f, 7.35530332e-02f, -4.13459614e-02f, -1.56394374e-02f, -2.10700519e-02f, -9.48889256e-02f, 4.21499386e-02f, -6.24478273e-02f, -2.56748241e-03f, -3.08540501e-02f,
  -4.72072214e-02f, -1.19166769e-01f, -5.46192005e-02f, 9.71253589e-02f, -1.23553947e-01f, 4.77868393e-02f, 2.03957371e-02f, 1.13110635e-02f, 1.67474523e-01f, 7.59289488e-02f,
  -5.42893223e-02f, -1.50372639e-01f, -1.34141326e-01f, 3.91961299e-02f, -5.98980486e-02f, -1.47267163e-01f, -2.89275199e-02f, -1.25636041e-01f, 5.49915954e-02f, -1.07857116e-01f,
  5.03481179e-02f, -1.29630715e-01f, 1.32195383e-01f, 9.78685096e-02f, 4.68494780e-02f, 6.86813444e-02f, -8.23414251e-02f, 3.07798892e-01f, -2.83047333e-02f, 7.00631216e-02f,
  4.15837541e-02f, -4.17976193e-02f, -1.18284106e-01f, -2.20032960e-01f, -1.32201895e-01f, 7.31265694e-02f, 5.25038354e-02f, -4.79440019e-02f, 1.19458705e-01f, 4.95751649e-02f,
  -9.53795481e-03f, -5.82397245e-02f, 2.15521514e-01f, 1.18555546e-01f, 3.17350298e-01f, -1.01343267e-01f, -1.92083523e-01f, -1.77760422e-02f, 1.23228572e-01f, 1.49091944e-01f,
  -2.24415530e-02f, -9.79513898e-02f, -1.99223068e-02f, -3.40151399e-01f, 1.90076217e-01f, -1.51213286e-02f, 2.20781222e-01f, -2.79548913e-02f, 1.24997951e-01f, -2.89599169e-02f,
  2.50757873e-01f, 8.45900476e-02f, -3.83918025e-02f, 1.06506974e-01f, 5.59727326e-02f, -9.89218727e-02f, 1.72200218e-01f, -9.04951803e-03f, -3.01227625e-02f, -9.88333002e-02f,
  -2.89618913e-02f, 6.21538498e-02f, 4.05937061e-02f, -1.81104720e-01f, -5.10899760e-02f, 4.49919812e-02f, -8.94321036e-03f, 1.68245733e-01f, 1.13461934e-01f, -1.51528716e-01f,
  6.02364913e-02f, -1.84122428e-01f, 3.91898192e-02f, -1.25788525e-01f, -5.52639971e-03f, 2.44777892e-02f, 7.01792389e-02f, -2.01063171e-01f, -3.53629529e-01f, -3.43643241e-02f,
  -3.24573547e-01f, -1.94818512e-01f, -2.72105545e-01f, 8.06937739e-02f, 2.42333971e-02f, 9.90343839e-03f, 8.22212920e-02f, -4.77288514e-02f, -3.08249146e-04f, -2.18887404e-02f,
  -2.18178742e-02f, -1.35927483e-01f, -8.95261317e-02f, 1.05195120e-01f, 1.16063105e-02f, -4.92897741e-02f, 1.15448644e-03f, -7.02071711e-02f, 3.54149640e-02f, -1.12867728e-01f,
  3.39710563e-02f, -9.10257548e-02f, 8.89334455e-02f, -7.41389021e-03f, -5.19589894e-02f, 2.10981835e-02f, 3.76943983e-02f, -2.52976678e-02f, -2.39029210e-02f, 4.76848409e-02f,
  -3.96672823e-02f, 1.10387571e-01f, -7.80125186e-02f, 8.60560462e-02f, 1.53150678e-01f, 4.08541225e-03f, -6.32788166e-02f, 5.87443672e-02f, 8.75407085e-02f, 1.62336707e-01f,
  -1.00315027e-01f, 7.66085014e-02f, -9.06176195e-02f, 4.85831089e-02f, 2.59232260e-02f, -5.13843708e-02f, 5.61451726e-02f, -5.29859588e-03f, -4.77585308e-02f, -9.20123234e-02f,
  5.70207648e-02f, 4.83911037e-02f, -1.10456079e-01f, 4.53789458e-02f, -1.01932861e-01f, -9.97755006e-02f, -1.12735055e-01f, -3.08868110e-01f, -7.73418322e-02f, 1.63702257e-02f,
  6.77400529e-02f, -7.48805478e-02f, -5.56506701e-02f, -1.53700054e-01f, 1.06991343e-02f, -5.02875596e-02f, 4.26783152e-02f, 1.27942294e-01f, -8.54654983e-03f, -1.00835063e-01f,
  -6.04586713e-02f, 9.15769190e-02f, -1.52313352e-01f, 1.08518831e-01f, -4.75865640e-02f, -1.48306265e-01f, 5.77600785e-02f, -3.87010649e-02f, 3.84538881e-02f, -1.41941756e-01f,
  5.46863824e-02f, -1.12282671e-02f, -1.08799096e-02f, 2.14749165e-02f, -4.67336401e-02f, -1.07042193e-02f, -1.53979763e-01f, -1.20159030e-01f, -1.00246400e-01f, 1.55709431e-01f,
  1.52627051e-01f, -3.84111255e-02f, 4.23057377e-02f, -1.62946135e-01f, 4.79684658e-02f, -1.46162165e-02f, -8.73234123e-02f, 1.86899677e-02f, 1.43852428e-01f, -1.10971995e-01f,
  5.64495400e-02f, 1.74664170e-01f, 7.66140670e-02f, -1.77866399e-01f, -1.61313936e-01f, -1.86378788e-02f, 5.40692769e-02f, 1.99380845e-01f, 1.81629416e-02f, -2.61645354e-02f,
  -1.03679083e-01f, -1.09281532e-01f, 1.27904668e-01f, 2.14874595e-01f, -1.30886421e-01f, -4.37108837e-02f, 2.66219415e-02f, -1.57206699e-01f, 1.58879206e-01f, 2.32922286e-01f,
  -7.42702186e-02f, 4.76945704e-03f, 1.60297289e-01f, -3.99105027e-02f, 7.69134611e-03f, -6.03634678e-02f, -2.21101701e-01f, -8.83012488e-02f, 2.77616143e-01f, -5.19030690e-02f,
  -2.77561005e-02f, 4.52407710e-02f, 1.86878532e-01f, 1.46451697e-01f, -5.00832964e-03f, -7.74434116e-03f, 1.01914100e-01f, -8.55008662e-02f, -8.97071809e-02f, -3.25001590e-02f,
  1.20034009e-01f, 5.17348573e-02f, -1.45215496e-01f, -8.34413990e-03f, 4.12031822e-02f, -3.89533527e-02f, 1.97065081e-02f, 9.80292931e-02f, 3.13335620e-02f, -1.12354390e-01f,
  5.46095707e-02f, 1.34121567e-01f, -7.20928311e-02f, 2.40307916e-02f, -4.32448648e-03f, 2.94892360e-02f, -9.14019793e-02f, 3.17449383e-02f, -1.17872164e-01f, 3.46178561e-02f,
  1.79386765e-01f, 4.62676100e-02f, 8.85106325e-02f, -8.13350230e-02f, 5.94831929e-02f, 5.26872426e-02f, -4.25212383e-02f, -4.70597595e-02f, -8.74125212e-02f, 5.36826216e-02f,
  6.63807541e-02f, -8.30728386e-04f, -1.34472519e-01f, 6.53372481e-02f, 4.57408950e-02f, 9.78691578e-02f, 1.54610875e-03f, -7.87981898e-02f, 1.66249573e-02f, 2.74251262e-03f,
  1.90158524e-02f, -8.16513300e-02f, -6.31182222e-03f, -4.18575555e-02f, -1.00684568e-01f, -1.00854941e-01f, -7.03197345e-02f, 5.46375811e-02f, -9.21486765e-02f, 7.16759041e-02f,
  5.33920527e-02f, 1.21937590e-02f, -8.87603848e-04f, 6.28543273e-02f, 7.85664618e-02f, -1.93204321e-02f, 1.21490723e-02f, -6.19813688e-02f, -5.72555922e-02f, 2.83250259e-03f,
  1.37362024e-02f, 1.44608572e-01f, -7.64678717e-02f, 9.65649113e-02f, 8.24953094e-02f, 6.39476860e-03f, 8.65846053e-02f, -9.08472836e-02f, 1.01016223e-01f, -3.19952667e-02f,
  2.61193037e-01f, 1.68145075e-02f, 3.21745574e-02f, -1.08137466e-01f, 2.78533310e-01f, -1.83049531e-03f, -1.56019509e-01f, 2.06782043e-01f, 1.36084929e-01f, -2.48661965e-01f,
  2.86266834e-01f, -2.18420886e-02f, -1.15396604e-02f, 1.51735455e-01f, 5.35753332e-02f, 6.75447658e-02f, 8.34733341e-03f, 1.62393842e-02f, 1.69442464e-02f, 8.75952318e-02f,
  3.82338156e-04f, -2.71654483e-02f, 2.20786873e-02f, -6.34756088e-02f, 2.34563738e-01f, -1.87688947e-01f, 2.17154369e-01f, 6.74142763e-02f, -9.44912210e-02f, 3.04926764e-02f,
  1.54269651e-01f, -5.91702666e-03f, -5.13325855e-02f, 1.48230597e-01f, -4.06425744e-02f, -3.74864608e-01f, 1.00957446e-01f, -1.03916742e-01f, -1.17734969e-01f, 5.68940155e-02f,
  1.82544068e-01f, -2.23869130e-01f, 3.01438421e-02f, -5.98627850e-02f, -1.91169411e-01f, -4.63396385e-02f, -5.04311994e-02f, 1.25796944e-01f, 1.44413799e-01f, -5.14977500e-02f,
  -6.70590401e-02f, 5.40518500e-02f, 1.98886424e-01f, -3.02149002e-02f, 5.81022836e-02f, 1.91122424e-02f, -5.08328602e-02f, -8.25716779e-02f, -1.34989932e-01f, 1.68867752e-01f,
  -7.23678395e-02f, 9.62841958e-02f, -4.43730988e-02f, 1.46509465e-02f, -9.64071825e-02f, -1.59094911e-02f, 5.64020723e-02f, 1.11326957e-02f, -1.36867561e-03f, -1.90398060e-02f,
  -9.60279331e-02f, -7.55508542e-02f, -1.98769495e-02f, -6.08580001e-03f, 1.13702565e-01f, 4.72464487e-02f, 1.34476945e-02f, 2.11233441e-02f, 1.06585221e-02f, -6.75183609e-02f,
  6.45205006e-02f, 1.25794366e-01f, 6.50367960e-02f, -1.13982998e-01f, 4.73395623e-02f, -3.83210666e-02f, -2.46653445e-02f, -6.34291694e-02f, 4.57936227e-02f, -1.09271541e-01f,
  -3.44224125e-02f, 8.67864639e-02f, 1.48625553e-01f, -2.22358340e-03f, -8.65383223e-02f, -1.29953939e-02f, -1.27913551e-02f, 2.12677126e-03f, -6.75587403e-03f, -4.35867049e-02f,
  -3.76921594e-02f, 4.18048352e-02f, -2.91775167e-01f, -1.75875440e-01f, 2.21997052e-02f, -5.76835126e-02f, -1.22772843e-01f, 4.52116914e-02f, -1.70619145e-01f, 1.03895128e-01f,
  -1.11857787e-01f, 5.76243773e-02f, -2.70390324e-02f, 2.32160911e-02f, 1.06317542e-01f, -1.67625293e-01f, -3.66518553e-03f, -1.50943741e-01f, -1.84356272e-02f, 1.57768846e-01f,
  -4.42630462e-02f, -1.00661330e-01f, 3.69504318e-02f, 2.02881079e-02f, -4.05432656e-02f, 1.30756527e-01f, 1.20721847e-01f, 1.01043895e-01f, 1.31952241e-01f, -8.15818533e-02f,
  -1.01999924e-01f, -1.38886988e-01f, -2.94566825e-02f, -8.84830020e-03f, -1.74382403e-01f, 7.39583233e-03f, 1.00467212e-01f, -1.25284016e-01f, 1.32895559e-01f, -9.87703949e-02f,
  1.10921338e-01f, -3.35952863e-02f, -5.98606765e-02f, 6.80797398e-02f, -2.07498968e-01f, -1.03340847e-02f, 1.67624161e-01f, 6.69819769e-03f, 4.01661880e-02f, -5.98765276e-02f,
  5.35838716e-02f, 8.88847262e-02f, -5.69959693e-02f, -1.09656252e-01f, -7.66459256e-02f, 1.24645166e-01f, -6.16392046e-02f, -1.31011099e-01f, 3.07184130e-01f, -1.51293548e-02f,
  8.88038427e-02f, -1.40672609e-01f, 1.41390547e-01f, 6.98775752e-03f, 8.54292661e-02f, 2.37880081e-01f, 6.26070872e-02f, -1.69543281e-01f, -1.04613916e-03f, -1.85039923e-01f,
  -2.50941031e-02f, -2.86641330e-01f, -1.62513629e-01f, -5.97321913e-02f, 1.74652785e-01f, -2.01873824e-01f, -1.62910044e-01f, -1.78398088e-01f, 6.68986663e-02f, 1.08143188e-01f,
  -3.82507443e-02f, 4.56550112e-03f, 1.38569966e-01f, 7.87855312e-02f, 9.86791477e-02f, 2.16283184e-02f, 3.35041657e-02f, 5.09585962e-02f, -7.57391602e-02f, 1.09107252e-02f,
  -3.78192179e-02f, 4.63109910e-02f, 2.27799155e-02f, 2.14116853e-02f, -1.32696228e-02f, 8.06350540e-03f, -9.90800336e-02f, 3.16583477e-02f, 2.88720839e-02f, -2.49603447e-02f,
  2.79750396e-02f, -8.35106969e-02f, -6.36608154e-02f, -4.66117337e-02f, 6.50983825e-02f, 6.59000054e-02f, 7.78123364e-02f, -2.21987423e-02f, 3.36519256e-02f, -5.45247123e-02f,
  5.28818145e-02f, -8.82503316e-02f, 3.50398794e-02f, 8.04506615e-02f, 6.26448244e-02f, 1.29387872e-02f, 4.47328761e-02f, -7.23595470e-02f, -1.06501684e-01f, 4.09488901e-02f,
  4.90016527e-02f, 5.19350022e-02f, -1.89231690e-02f, -8.99568200e-02f, -9.80770737e-02f, 9.12869871e-02f, -3.89462635e-02f, 4.18521017e-02f, 4.49914299e-02f, 1.34018213e-01f,
  -1.53742447e-01f, -2.48455126e-02f, 2.62607113e-02f, 1.24494188e-01f, 8.42823461e-02f, 1.28708571e-01f, -1.13935303e-02f, -2.97507308e-02f, -1.13264091e-01f, 7.77489692e-02f,
  7.35773593e-02f, 1.66407675e-02f, 6.01233505e-02f, 6.92851543e-02f, 1.45437971e-01f, -4.50263582e-02f, 1.56561464e-01f, 1.76417798e-01f, -1.23282552e-01f, -7.73013290e-03f,
  -4.20979708e-02f, 1.20220214e-01f, -6.72531426e-02f, -1.72932278e-02f, -9.41019319e-03f, 7.96460062e-02f, 1.56866580e-01f, -3.59468758e-02f, -2.54730955e-02f, -2.16203704e-02f,
  2.60429084e-01f, 1.54728636e-01f, 5.54727390e-02f, 8.32576901e-02f, -2.47529452e-03f, -1.16766617e-01f, 2.44549215e-01f, -2.95925383e-02f, 7.00173900e-02f, -3.45909819e-02f,
  -2.59961989e-02f, 7.93085620e-02f, -1.34455889e-01f, 1.17982246e-01f, 4.43116650e-02f, 8.04195460e-03f, -1.13628849e-01f, 2.00263765e-02f, -3.02893277e-02f, 6.85161352e-02f,
  5.99206798e-02f, -1.36567920e-01f, 1.34877294e-01f, -2.11566500e-02f, 3.17714550e-02f, -9.75157022e-02f, -1.62020057e-01f, -1.95138916e-01f, 1.09380066e-01f, 1.72037527e-01f,
  -6.37786910e-02f, -1.79880038e-01f, -3.74363437e-02f, -3.63745578e-02f, 1.68153241e-01f, 1.03268493e-02f, -5.97017668e-02f, 4.12562117e-02f, 2.96454672e-02f, -2.37718672e-01f,
  4.97143483e-03f, 1.66239128e-01f, -1.60934523e-01f, -1.98978767e-01f, -1.04322687e-01f, 5.06847873e-02f, -5.80276102e-02f, -1.15923593e-02f, 9.32840779e-02f, 2.86447387e-02f,
  1.20558932e-01f, -1.16976947e-01f, 1.02595761e-01f, 1.31290033e-01f, -4.78495285e-02f, 6.75678253e-02f, 7.67148659e-02f, 7.94270411e-02f, -6.21338747e-02f, -4.42170911e-02f,
  1.17390610e-01f, 5.63095473e-02f, -9.40922424e-02f, 1.04897425e-01f, 3.37810554e-02f, -3.91306169e-02f, -3.21081020e-02f, -1.13035673e-02f, -1.02909371e-01f, -8.32414478e-02f,
  -1.03133537e-01f, 6.92094713e-02f, 6.62641823e-02f, 2.14783549e-01f, 4.48019281e-02f, -1.28674377e-02f, 8.11222717e-02f, 1.91955101e-02f, 8.77314508e-02f, 1.15341628e-02f,
  -4.50955220e-02f, 1.03354186e-01f, 3.40077542e-02f, 5.69275916e-02f, 4.22427617e-03f, -5.24062291e-02f, -8.07337984e-02f, 5.38548827e-02f, 6.73911050e-02f, 5.62833510e-02f,
  7.96163827e-02f, 1.29909813e-01f, -4.13663201e-02f, -2.48088501e-02f, 4.49551176e-03f, -1.11012273e-01f, 3.57863083e-02f, -3.90448682e-02f, 1.27784014e-01f, -3.17958891e-01f,
  -5.09916581e-02f, -1.17018625e-01f, -8.74074250e-02f, 7.51409605e-02f, 1.19619824e-01f, -6.23647347e-02f, 1.63989276e-01f, 2.61635403e-03f, -4.76588532e-02f, -8.23137611e-02f,
  -2.96685342e-02f, 9.16387513e-02f, -1.74863473e-01f, 8.53993446e-02f, -6.10935502e-02f, 2.94699911e-02f, 2.11039763e-02f, -6.20467700e-02f, 1.60417452e-01f, -1.43133849e-01f,
  3.36401425e-02f, -2.55170017e-02f, 4.69949581e-02f, -7.22280070e-02f, -1.04873173e-01f, 4.46476601e-02f, 4.27206308e-02f, -1.70116723e-01f, -2.09623992e-01f, 4.94525544e-02f,
  1.56362280e-02f, 1.06299873e-02f, 8.44679251e-02f, -9.99198761e-03f, -9.72687230e-02f, -2.15814039e-01f, 3.43684852e-02f, 3.70935984e-02f, 2.07702518e-01f, -8.47476348e-02f,
  1.83053851e-01f, -2.44296920e-02f, -8.57360065e-02f, 2.54407488e-02f, 1.24602571e-01f, -2.07203656e-01f, 3.42828617e-03f, -1.54379234e-01f, 8.53828713e-02f, 6.19215444e-02f,
  -1.43597405e-02f, -1.35283232e-01f, -9.95109975e-02f, 7.89100230e-02f, -1.81455031e-01f, 1.52475098e-02f, -5.96375093e-02f, 1.32626146e-01f, 1.75458953e-01f, -8.95103142e-02f,
  9.58870575e-02f, 1.61894903e-01f, 6.21033600e-03f, -6.02753162e-02f, 2.74751484e-02f, 3.44689697e-01f, -1.70867518e-01f, 1.20858774e-01f, -2.34764948e-01f, 1.58418462e-01f,
  -1.71414956e-01f, -7.78704360e-02f, -1.74255610e-01f, -1.99526608e-01f, -1.40766576e-01f, -1.76536515e-02f, 1.24083459e-01f, -1.55750625e-02f, 9.64294523e-02f, -3.03740837e-02f,
  -5.65347902e-04f, -3.32957171e-02f, -9.41228122e-02f, 9.97105315e-02f, -1.70238037e-02f, 4.17239219e-02f, -5.40390126e-02f, 3.72392200e-02f, -1.53102726e-02f, 9.03683454e-02f,
  -5.11977263e-02f, -6.62748329e-03f, -1.75164863e-01f, -7.75797889e-02f, -8.58217180e-02f, 2.99616195e-02f, -4.38089408e-02f, -5.75593673e-02f, -7.83493519e-02f, -2.96382569e-02f,
  -1.49035677e-02f, -3.56587879e-02f, 2.55147703e-02f, -9.59128607e-03f, -4.07634713e-02f, -1.11520931e-01f, -9.39023122e-02f, -6.08455800e-02f, -1.25064939e-01f, -4.38285805e-02f,
  -1.88951625e-03f, -7.69111002e-03f, 8.03573406e-04f, -1.30695969e-01f, 1.02791535e-02f, 1.01367198e-01f, 9.02430415e-02f, -8.26356560e-02f, -5.38279302e-02f, 1.27333552e-02f,
  3.17828581e-02f, -2.08797455e-02f, -1.38321921e-01f, -2.14203537e-01f, 2.72157863e-02f, -4.91026938e-02f, -1.70754828e-02f, 1.79647684e-01f, 7.84620568e-02f, -1.78290054e-01f,
  1.82294622e-01f, 5.66759929e-02f, -4.23889235e-02f, 2.00412404e-02f, -5.04777543e-02f, -3.03580314e-02f, 4.64697331e-02f, 2.14377463e-01f, 7.00925244e-03f, 4.83266562e-02f,
  3.79086984e-03f, -3.57609689e-02f, -1.37055442e-01f, -4.99994196e-02f, -1.38059422e-01f, 4.25213762e-02f, 1.22828819e-01f, 6.82344884e-02f, -6.11736253e-02f, 1.80255160e-01f,
  6.86401650e-02f, 2.13459566e-01f, -1.17298633e-01f, -1.25860915e-01f, -6.91274256e-02f, 1.37401223e-02f, 8.95555019e-02f, 2.53102323e-03f, 8.51271749e-02f, -9.07067657e-02f,
  1.52376771e-01f, -1.50801800e-02f, -7.97110889e-03f, -8.18248540e-02f, 1.88869238e-01f, 4.89789695e-02f, 5.96708693e-02f, -8.02356303e-02f, 9.15149823e-02f, -4.88778576e-02f,
  -1.57282427e-01f, 1.66934446e-01f, 1.27422241e-02f, 6.71103224e-02f, 3.32791544e-02f, 2.94247605e-02f, -2.93271393e-01f, -4.08279411e-02f, 5.51327541e-02f, 1.76254451e-01f,
  -6.88889325e-02f, 1.71033189e-01f, -2.37508342e-01f, -2.87637502e-01f, 1.89539529e-02f, -1.64125100e-01f, 9.65121612e-02f, 2.06379816e-02f, -1.13059096e-01f, 6.76041320e-02f,
  -4.09376584e-02f, -1.29762605e-01f, -6.38386756e-02f, -1.45258054e-01f, -2.60307677e-02f, -6.63407743e-02f, -2.76487529e-01f, -1.37259901e-01f, 1.29092187e-01f, -3.28269571e-01f,
  -9.63682905e-02f, -5.09924702e-02f, -1.27365932e-01f, -1.13552427e-02f, -3.32668498e-02f, 1.24545835e-01f, -2.13760175e-02f, -1.47145791e-02f, -3.88466902e-02f, 6.54416755e-02f,
  8.30558240e-02f, 7.41547048e-02f, 1.04569286e-01f, 5.85251860e-02f, -1.30086914e-01f, -1.27786666e-01f, -4.31142822e-02f, 1.55577391e-01f, -9.10410956e-02f, -1.97479010e-01f,
  -9.15667936e-02f, -4.07742858e-02f, -5.44011258e-02f, 8.69073123e-02f, 1.62000749e-02f, -9.69647954e-04f, -3.16984877e-02f, -1.65658653e-01f, -7.35481642e-03f, -2.35072710e-03f,
  -1.96788572e-02f, 2.95798164e-02f, 2.01821662e-02f, 3.51540260e-02f, 5.07506356e-02f, 4.78623398e-02f, -1.52825862e-01f, -3.33625637e-02f, -5.09231277e-02f, 1.37106314e-01f,
  -4.05567400e-02f, 1.14639401e-02f, 5.58975451e-02f, -2.24837624e-02f, 1.41647626e-02f, -1.26246680e-02f, 6.08308651e-02f, -1.23201035e-01f, -7.35541200e-03f, 5.34531735e-02f,
  -6.15589507e-02f, -1.48394808e-01f, -8.94251242e-02f, -3.85989882e-02f, 9.16816145e-02f, -7.39384890e-02f, 3.39861214e-02f, -3.22139800e-01f, 1.54392436e-01f, 1.28123481e-02f,
  1.21318989e-01f, -2.84922775e-02f, 8.41422305e-02f, -5.42659350e-02f, -3.78098362e-03f, -4.38656695e-02f, 6.59727603e-02f, -1.11229070e-01f, -8.25300813e-02f, 8.59274354e-04f,
  -1.44059598e-01f, -1.57332227e-01f, 6.71665892e-02f, -4.72648591e-02f, 7.24421665e-02f, -2.08488666e-02f, 1.46922290e-01f, -8.97124037e-02f, 1.33268237e-01f, 1.12881981e-01f,
  4.83548716e-02f, -2.15450786e-02f, 2.68927850e-02f, -2.57866848e-02f, -1.40789375e-01f, -8.17610472e-02f, 1.72871888e-01f, -1.18571624e-01f, 7.80376121e-02f, -2.10260060e-02f,
  3.00516430e-02f, -2.61672944e-01f, -5.11869602e-02f, -2.01321803e-02f, 1.19351618e-01f, -3.71223167e-02f, 7.45390654e-02f, -8.64797831e-02f, -1.13978826e-01f, 1.27003670e-01f,
  -1.74271818e-02f, -1.49523214e-01f, 2.04774871e-01f, -1.64551899e-01f, -7.32093379e-02f, -3.48355435e-02f, -1.27079859e-01f, 8.16544294e-02f, -8.39235336e-02f, 1.12496652e-01f,
  -1.72927201e-01f, 4.16250527e-02f, -2.84195766e-02f, 1.03007682e-01f, -5.92707656e-02f, 1.73376575e-02f, 6.64251000e-02f, -1.09586297e-02f, -1.26014531e-01f, -1.29506141e-01f,
  2.72027170e-03f, 7.32767507e-02f, 1.83742102e-02f, 3.01488847e-01f, -1.25489220e-01f, -7.16312230e-02f, -3.49778652e-01f, 1.76367208e-01f, 1.42880091e-02f, -5.67993261e-02f,
  -6.31619096e-02f, -3.72312143e-02f, 2.64940057e-02f, 3.77758145e-02f, 1.20812096e-02f, -1.26762301e-01f, -1.32037988e-02f, -1.39791146e-03f, 5.52044846e-02f, 8.35964531e-02f,
  8.42334479e-02f, -6.22422844e-02f, -1.04044288e-01f, -2.22603157e-02f, -2.88831182e-02f, -4.01315615e-02f, -7.39255995e-02f, -7.55299255e-02f, 1.09061845e-01f, 2.61483639e-02f,
  3.68216559e-02f, -1.63806990e-01f, -9.19096395e-02f, -3.20254848e-03f, -2.18869641e-01f, 7.11009949e-02f, -5.40481284e-02f, -5.75444438e-02f, 2.27651931e-02f, 6.00978769e-02f,
  -1.89453270e-02f, -7.61641539e-04f, 4.59186807e-02f, -1.02984756e-01f, -4.99081388e-02f, -4.69430834e-02f, -2.40754206e-02f, -1.44557014e-01f, 4.49772514e-02f, -2.22455710e-02f,
  -1.24694742e-01f, 1.47609424e-03f, 8.40702951e-02f, 2.88472902e-02f, -9.15746540e-02f, -4.71906411e-03f, -2.64076162e-02f, -1.31072598e-02f, -7.64591470e-02f, -1.08427279e-01f,
  -1.31003454e-01f, -1.20350383e-01f, 2.77741458e-02f, -1.94035530e-01f, -8.12952407e-03f, 8.17002952e-02f, 4.98830341e-03f, -5.30481599e-02f, 1.01085953e-01f, -4.51115929e-02f,
  7.42700472e-02f, 1.04459621e-01f, 1.05909377e-01f, 1.67882308e-01f, -2.26109531e-02f, -4.74207923e-02f, 3.27122062e-02f, 4.87367585e-02f, -1.41056284e-01f, -7.78872147e-02f,
  -8.76606330e-02f, -6.16584010e-02f, 7.57281482e-02f, -1.18607186e-01f, 4.37950157e-02f, -5.04626855e-02f, -5.38967252e-02f, -1.67912334e-01f, 1.66002572e-01f, -1.38134420e-01f,
  5.88125214e-02f, -6.71144053e-02f, -5.09224311e-02f, -4.70450297e-02f, 2.31030043e-02f, 8.36849436e-02f, -1.40798092e-02f, -2.87274439e-02f, 1.22245595e-01f, -1.51548445e-01f,
  1.99587108e-03f, -4.87973690e-02f, 1.15726650e-01f, 3.79415303e-02f, 7.47144520e-02f, 3.69290970e-02f, 2.46634483e-02f, -1.24879636e-01f, -6.43498600e-02f, -8.63495767e-02f,
  -1.25903226e-02f, -1.70284733e-01f, 2.28726879e-01f, -1.69017628e-01f, -3.72816175e-02f, 1.87488645e-01f, 5.34389652e-02f, -2.41230801e-01f, -5.90404384e-02f, 2.02269748e-01f,
  -3.74539346e-02f, 2.75465399e-01f, 5.29871183e-03f, -1.21269278e-01f, 1.36651233e-01f, -1.49648190e-01f, -3.75416018e-02f, -1.20427102e-01f, 4.12627868e-02f, 6.75599575e-02f,
  6.63789082e-03f, 2.06001788e-01f, -2.58722901e-01f, 1.70737728e-02f, -1.80601180e-01f, 5.04372194e-02f, -6.58660606e-02f, -4.78071310e-02f, -7.10118040e-02f, -7.84492120e-03f,
  6.49218336e-02f, 4.26385328e-02f, -8.38932320e-02f, 9.75478068e-02f, 1.42098695e-01f, -1.65691767e-02f, -8.51686969e-02f, -6.11614957e-02f, -2.68284567e-02f, 1.61483303e-01f,
  -3.28427739e-02f, 6.96773455e-02f, -2.89333893e-05f, 1.43829718e-01f, 4.73036394e-02f, 1.42177552e-01f, 7.52288774e-02f, -2.67184842e-02f, 9.79644731e-02f, 7.50682279e-02f,
  -1.68273356e-02f, -6.84357202e-03f, 1.34493023e-01f, 4.75650728e-02f, 1.29240844e-02f, 9.50613394e-02f, 5.42909689e-02f, -1.09460346e-01f, -4.46049459e-02f, 8.95981863e-02f,
  2.06955266e-03f, 1.77536141e-02f, 3.92104089e-02f, -6.66449517e-02f, -3.70890424e-02f, 1.00139335e-01f, 8.78391042e-02f, -1.25665456e-01f, 1.42056733e-01f, -8.26111734e-02f,
  2.31391657e-02f, 7.41349608e-02f, 8.54582433e-03f, 3.83921079e-02f, -1.18023641e-01f, 5.02549186e-02f, -4.73943241e-02f, 5.82444631e-02f, 1.53722614e-01f, -6.59817532e-02f,
  -1.41106769e-02f, 1.16070965e-02f, 6.75622225e-02f, -1.09609634e-01f, 1.33178651e-01f, 1.30733117e-01f, 1.46162555e-01f, 8.56110454e-02f, 7.72715360e-02f, 1.74198858e-02f,
  -1.55844763e-01f, -1.07481614e-01f, 6.00939095e-02f, 5.90721555e-02f, -6.72072917e-02f, -1.75909236e-01f, -2.02617705e-01f, -1.05648683e-02f, 8.09677690e-02f, 1.70794994e-01f,
  -1.09325424e-02f, -1.44439697e-01f, 2.40108818e-02f, -1.67733021e-02f, 1.21453561e-01f, 1.48332417e-01f, -1.10045820e-01f, -1.13403857e-01f, 9.79723409e-02f, 2.36895699e-02f,
  -2.41793953e-02f, -1.34219602e-03f, 1.62181467e-01f, -2.27363512e-01f, -1.79150179e-01f, -1.20872520e-01f, 1.77022722e-02f, -2.31049079e-02f, -4.54231817e-03f, 8.82752612e-02f,
  -2.34534265e-03f, -4.27022241e-02f, 1.22741267e-01f, 7.81798661e-02f, -2.44217381e-01f, 5.74473813e-02f, 2.00679107e-03f, 4.14859727e-02f, 1.65825769e-01f, -5.04347533e-02f,
  -1.34811118e-01f, 1.71561942e-01f, -1.34532884e-01f, 2.37163812e-01f, 1.07272230e-01f, -1.34705633e-01f, -2.23874062e-01f, -6.54097414e-03f, 1.99482441e-02f, 3.83725278e-02f,
  2.64490023e-02f, 2.98534364e-01f, -1.48022398e-01f, 1.29623339e-02f, 1.26778916e-01f, -1.01724595e-01f, -1.73951238e-01f, 2.91277915e-01f, 9.97087955e-02f, 9.64496210e-02f,
  8.23340565e-02f, -7.02811703e-02f, -2.78233215e-02f, -1.36235252e-01f, -1.81831382e-02f, 5.74486330e-02f, 6.85042664e-02f, -1.84613448e-02f, 1.01941098e-02f, 9.63941123e-03f,
  5.62003488e-03f, -4.82243672e-02f, -3.76751162e-02f, -1.73981823e-02f, 2.48689912e-02f, 2.11425610e-02f, 5.31197898e-03f, -6.62331507e-02f, 5.94872795e-02f, -4.45782021e-02f,
  7.08079785e-02f, -1.19636074e-01f, 8.74856934e-02f, -9.36695039e-02f, 5.92590049e-02f, 8.24349448e-02f, 4.98717204e-02f, -9.22987312e-02f, -1.83563512e-02f, -4.31437232e-02f,
  -1.08345091e-01f, -7.68935354e-03f, -6.60135597e-02f, -1.39553919e-01f, 8.58441666e-02f, 4.46592830e-02f, -9.98645183e-03f, -1.50435716e-02f, 2.62728333e-02f, -5.64210676e-02f,
  -1.58323569e-03f, 4.38932776e-02f, 5.71618862e-02f, -9.93888825e-02f, 1.58541687e-02f, 6.42787889e-02f, -5.65778231e-03f, 9.07909274e-02f, 5.35080731e-02f, -7.04499707e-02f,
  5.49260825e-02f, 7.32098380e-03f, -8.30421131e-03f, -2.38275249e-02f, 5.54058440e-02f, 3.13237831e-02f, -4.60918695e-02f, 6.73788413e-02f, -1.01325832e-01f, -1.74839720e-01f,
  -1.58353820e-02f, -5.61165623e-03f, 2.92601474e-02f, -8.03809240e-02f, -3.37210260e-02f, -1.04406722e-01f, 4.74764109e-02f, 7.31638446e-02f, 1.82716474e-01f, 4.88962755e-02f,
  2.91884039e-02f, 5.75074106e-02f, 8.35737586e-02f, 2.20700316e-02f, 1.90749317e-01f, 1.69667751e-02f, 1.19649414e-02f, -2.89298832e-01f, -1.55291501e-02f, -1.19327148e-02f,
  1.41128391e-01f, -1.83174498e-02f, 6.05933880e-03f, 3.47168967e-02f, -9.67376605e-02f, 5.76390699e-02f, -1.36182472e-01f, -2.25728899e-02f, 7.01330155e-02f, -1.47666167e-02f,
  -1.59453630e-01f, 1.08598508e-01f, 3.46683830e-01f, -4.10328507e-02f, -1.14415092e-02f, -1.40872791e-01f, 3.64661813e-02f, 2.63934431e-04f, -1.22261859e-01f, 6.86365366e-02f,
  7.53838494e-02f, -9.88785475e-02f, 1.32370219e-01f, 9.04582292e-02f, -7.88621306e-02f, -2.11295635e-02f, -4.67834696e-02f, 3.72898839e-02f, 5.53522222e-02f, 2.68920928e-01f,
  6.18043579e-02f, -9.55561996e-02f, -1.91826954e-01f, 1.33199925e-02f, 2.40976766e-01f, 1.98490158e-01f, -1.54984325e-01f, 2.73009185e-02f, -7.69811645e-02f, -2.27070823e-01f,
  1.36712611e-01f, -1.11838780e-01f, -2.26437435e-01f, 2.50027925e-01f, 1.42550066e-01f, -1.90745488e-01f, 5.24718277e-02f, -1.06447138e-01f, -2.12634787e-01f, -1.11580260e-01f,
  2.43461564e-01f, -8.16736519e-02f, -1.53467688e-03f, -2.50089262e-02f, -1.89852834e-01f, 1.07378718e-02f, 2.12337021e-02f, 5.98697402e-02f, 2.52452735e-02f, 5.37998788e-02f,
  -2.42171902e-02f, -3.97350751e-02f, -6.03980245e-03f, -1.81932822e-02f, -3.70410644e-02f, -9.22296010e-03f, -1.50608737e-02f, -1.05996914e-01f, 1.19380385e-01f, 1.91965736e-02f,
  -5.44284359e-02f, -5.13419658e-02f, -1.31807387e-01f, 3.23107950e-02f, 1.53948471e-03f, 2.39501204e-02f, 3.05125415e-02f, 7.72757679e-02f, 1.58605680e-01f, 6.52185231e-02f,
  5.47721013e-02f, -1.06737226e-01f, 2.12667640e-02f, 4.90850732e-02f, 4.19439897e-02f, 2.24730864e-01f, 1.25403211e-01f, -4.45234589e-02f, 4.26266864e-02f, -1.24466829e-01f,
  7.27958418e-03f, -3.28426696e-02f, 1.31911384e-02f, 1.29329771e-01f, -1.01805618e-02f, -5.02176136e-02f, 4.11983132e-02f, -6.07904466e-03f, -8.14836100e-02f, 2.10497901e-02f,
  6.74266443e-02f, -1.31327793e-01f, -1.23063512e-01f, -4.16266322e-02f, -1.96925327e-02f, -7.72074386e-02f, -1.33420527e-01f, 5.81907965e-02f, -2.10218187e-02f, -9.29759145e-02f,
  -2.32910402e-02f, -2.44867299e-02f, -8.67008269e-02f, 1.30488992e-01f, 2.35689548e-03f, -9.19609889e-02f, 6.63343892e-02f, 7.92975947e-02f, -1.01880558e-01f, -4.99702208e-02f,
  1.17153516e-02f, -2.28275910e-01f, -2.03145236e-01f, -3.25994268e-02f, 2.85084713e-02f, 1.85160175e-01f, 2.84315161e-02f, -1.06651656e-01f, 1.09885961e-01f, 7.19955489e-02f,
  8.66663158e-02f, 1.43819913e-01f, -3.61212492e-02f, -1.03185609e-01f, -2.04185285e-02f, -9.17591676e-02f, 1.43635094e-01f, -9.17061344e-02f, -1.20725028e-01f, -2.69326776e-01f,
  2.29752325e-02f, -9.30796266e-02f, 9.18606222e-02f, 3.63349803e-02f, 1.82683781e-01f, -7.42042586e-02f, 1.77260730e-02f, -3.93311344e-02f, 1.34818867e-01f, 2.21335385e-02f,
  -1.98836684e-01f, 8.46338496e-02f, 1.07956238e-01f, -5.14593422e-02f, 1.24393903e-01f, 1.30065590e-01f, 7.61657953e-02f, 7.30861947e-02f, 3.40590365e-02f, 4.38769087e-02f,
  -8.95277113e-02f, -5.25282212e-02f, 7.48852864e-02f, -7.48971030e-02f, -7.40066990e-02f, -1.33204758e-01f, 7.15961829e-02f, 3.74338962e-02f, -1.22535927e-02f, 5.08174002e-02f,
  -3.22037488e-01f, -5.20102940e-02f, -1.46249756e-01f, -8.95774066e-02f, 7.26837590e-02f, -1.72492683e-01f, -6.77173911e-03f, -1.69517010e-01f, 1.99376181e-01f, -1.85473412e-01f,
  -9.81439464e-03f, -1.40288591e-01f, 1.77609287e-02f, -1.55913785e-01f, -8.13340396e-02f, 1.16508277e-02f, 7.92769343e-02f, 2.55437940e-02f, -6.21801130e-02f, -1.19011693e-01f,
  -6.82317093e-02f, -1.83642260e-03f, 3.39002423e-02f, -2.74433917e-03f, 1.85491685e-02f, -8.16082954e-02f, 4.69074696e-02f, -4.01666425e-02f, 9.12635177e-02f, -3.26613709e-02f,
  1.02571838e-01f, -5.65215498e-02f, 1.03558496e-01f, -6.96976334e-02f, 8.14545974e-02f, -1.33878812e-01f, 1.23986728e-01f, -1.39154634e-02f, -4.51773591e-02f, -1.80264469e-02f,
  3.00799422e-02f, -6.39339397e-03f, -3.76522392e-02f, -4.93282788e-02f, 4.86204117e-05f, 8.36061612e-02f, -3.12697105e-02f, 1.19470865e-01f, -8.72038528e-02f, 4.07181215e-03f,
  5.90507016e-02f, 1.25144154e-01f, -4.11012881e-02f, -5.78244973e-04f, -1.61187649e-01f, 9.14480910e-02f, -4.30993177e-02f, 2.53109057e-02f, 9.79841724e-02f, 6.84319511e-02f,
  6.33933544e-02f, 2.50964426e-02f, -3.26205306e-02f, -1.69412326e-03f, 1.48770168e-01f, -2.61237949e-01f, -1.86023831e-01f, 2.42106486e-02f, -1.97936848e-01f, -3.68352644e-02f,
  1.68879241e-01f, -3.58903520e-02f, 7.00774118e-02f, 3.59579884e-02f, -5.15013561e-02f, 1.27709359e-02f, -8.13328251e-02f, -5.94945587e-02f, -1.29921377e-01f, 4.53532003e-02f,
  -1.09975904e-01f, 1.53110892e-01f, -4.21772599e-02f, -7.29894042e-02f, 4.44111750e-02f, 8.18975121e-02f, -7.62852132e-02f, 1.95257850e-02f, 8.54702815e-02f, -1.29773051e-01f,
  9.66993794e-02f, 1.07841566e-02f, -7.61368647e-02f, 2.99222469e-02f, 8.71222094e-02f, 6.93887770e-02f, -7.74904862e-02f, 2.09328875e-01f, 1.36062801e-01f, -4.49157022e-02f,
  1.47773027e-01f, -1.84939221e-01f, -9.68019515e-02f, 1.38112620e-01f, 5.89917041e-02f, 3.01288236e-02f, 1.27182409e-01f, 9.74850915e-03f, 1.36190280e-01f, -1.01838835e-01f,
  -6.96350336e-02f, -1.77275002e-01f, 7.07059575e-04f, -1.12335362e-01f, 1.57285973e-01f, 5.72244152e-02f, -2.24125609e-01f, -1.78445756e-01f, -9.01316777e-02f, 3.77619043e-02f,
  6.62563667e-02f, 2.40895033e-01f, -2.05894962e-01f, 1.44970462e-01f, 8.21769983e-03f, -3.23538512e-01f, 1.29082561e-01f, -1.78584412e-01f, 4.07647379e-02f, -5.09335250e-02f,
  1.03378944e-01f, 2.21980378e-01f, -5.35376519e-02f, -9.37822089e-02f, -3.29386652e-01f, 1.66388061e-02f, -1.18550397e-01f, -3.99541035e-02f, -1.73544753e-02f, 8.62034969e-03f,
  -4.14853878e-02f, 5.75171635e-02f, 1.92892596e-01f, -5.93189476e-03f, 6.92325160e-02f, 4.74597182e-04f, -1.49154551e-02f, 9.59910154e-02f, 2.86157466e-02f, -3.73670720e-02f,
  1.20818108e-01f, -1.41517147e-01f, 7.54085854e-02f, 7.07886741e-02f, -4.48440425e-02f, 5.67516759e-02f, -7.99755449e-04f, 2.98171975e-02f, 2.37550195e-02f, 9.06032175e-02f,
  7.06150979e-02f, 1.47375753e-02f, -2.81580258e-02f, -4.92878631e-02f, 5.76383844e-02f, 1.78505722e-02f, -8.03245977e-02f, -9.54330042e-02f, -8.76869783e-02f, 8.60120207e-02f,
  9.40762181e-03f, -1.24900108e-02f, 2.58392096e-02f, -4.29739505e-02f, 5.61041906e-02f, -1.51550034e-02f, -4.42797281e-02f, -8.49762559e-03f, -1.61509737e-01f, -1.04484886e-01f,
  5.40880002e-02f, -1.47229508e-01f, 1.68878421e-01f, -6.82845041e-02f, -3.75558913e-04f, 5.74438535e-02f, -5.15634157e-02f, 1.06986351e-01f, -9.20435414e-02f, -9.38954949e-02f,
  1.03244565e-01f, -1.95731129e-02f, 4.50101186e-04f, -2.46516153e-01f, 1.52262207e-02f, -2.58250803e-01f, 1.46839425e-01f, 6.03470914e-02f, -2.74611767e-02f, -1.86585039e-01f,
  7.35443383e-02f, 8.44368115e-02f, 4.82368693e-02f, -7.33595639e-02f, -6.05708249e-02f, 6.79211095e-02f, -1.02854699e-01f, -1.56145766e-01f, -2.27978766e-01f, 8.30304623e-02f,
  2.15469506e-02f, -3.30235846e-02f, 1.21227004e-01f, -4.47145477e-02f, -4.11205664e-02f, -1.33311823e-01f, 3.26067698e-03f, 1.82022363e-01f, -2.64445250e-03f, 1.04020536e-01f,
  -4.26794812e-02f, -7.63253570e-02f, -1.15111418e-01f, 2.72810720e-02f, 9.51018259e-02f, -4.22051847e-02f, 1.97782397e-01f, -2.27081448e-01f, 9.96504165e-03f, -2.26219833e-01f,
  8.43883231e-02f, -2.93595763e-03f, -2.72653382e-02f, 4.53711413e-02f, 1.74754351e-01f, -3.94877978e-03f, 5.16585298e-02f, 8.63022879e-02f, 4.40187305e-02f, -1.11185171e-01f,
  1.42541816e-02f, -9.25286636e-02f, -2.83713758e-01f, 1.31092489e-01f, -1.49195343e-01f, -9.42455903e-02f, -6.30260929e-02f, -2.92267561e-01f, -5.09507507e-02f, -6.86940029e-02f,
  1.36198327e-01f, 8.04696530e-02f, 8.41841325e-02f, -1.10720672e-01f, 2.84125563e-02f, 8.79947469e-02f, 1.00523405e-01f, -7.97877312e-02f, -1.65047884e-01f, 2.45737657e-01f,
  6.72907233e-02f, -1.37602270e-01f, -3.52793097e-01f, -1.62216593e-02f, 1.29167184e-01f, -3.13297331e-01f, -2.74416268e-01f, 1.23268567e-01f, -3.93953621e-02f, -1.58855051e-01f,
  -6.18610233e-02f, 4.52479236e-02f, -8.95294324e-02f, -3.36557068e-02f, -5.34274690e-02f, -3.39116678e-02f, 5.16931675e-02f, 2.88249087e-03f, -2.28491277e-02f, -2.38211621e-02f,
  -9.36462637e-03f, 5.29861748e-02f, -2.20314227e-02f, -1.11558966e-01f, -5.50836511e-03f, 7.79925361e-02f, 1.19679742e-01f, -5.50055578e-02f, 4.87205908e-02f, 1.39596820e-01f,
  3.43470015e-02f, 1.19120248e-01f, 4.44190577e-02f, -4.85594943e-02f, -1.31943628e-01f, -1.15812337e-02f, 4.56213392e-02f, 7.86588043e-02f, 1.14917107e-01f, -6.58171698e-02f,
  -2.78471727e-02f, 8.26935545e-02f, 6.30735382e-02f, 1.77436471e-02f, 9.71068367e-02f, 4.96440157e-02f, -1.26810893e-01f, -2.06862781e-02f, 1.09223556e-02f, -8.64782184e-02f,
  -7.95876980e-02f, 7.04582082e-03f, -2.56604087e-02f, -2.36497987e-02f, 4.41722572e-02f, 2.10489542e-03f, -1.62896633e-01f, 7.87017196e-02f, -1.15231827e-01f, -2.19016410e-02f,
  2.72557717e-02f, -1.39887407e-01f, 9.85818654e-02f, -1.21681958e-01f, -6.73328266e-02f, -1.16915345e-01f, 1.43385649e-01f, -1.89295426e-01f, 1.62387028e-01f, 6.14825711e-02f,
  1.16347708e-01f, -6.25211895e-02f, 1.58514515e-01f, 2.79614590e-02f, -1.45429477e-01f, 1.69892848e-01f, -6.53401464e-02f, 9.33006108e-02f, -9.58427694e-03f, 2.53353734e-02f,
  6.03743941e-02f, -1.65382862e-01f, 1.83452949e-01f, -1.96041346e-01f, -1.11050934e-01f, -9.12754163e-02f, -1.18071958e-01f, 1.20527059e-01f, 1.57311916e-01f, -7.19428733e-02f,
  -1.30846709e-01f, -9.06195715e-02f, 2.01741353e-01f, 7.32882768e-02f, 7.24251345e-02f, -2.78981663e-02f, 2.97801606e-02f, -2.80373514e-01f, -2.07305416e-01f, -3.11069172e-02f,
  7.90194198e-02f, -2.12517101e-02f, 1.83022395e-01f, 2.58686617e-02f, 6.55869916e-02f, 1.57913137e-02f, -1.07418761e-01f, -1.73664674e-01f, 1.64999757e-02f, -2.28462979e-01f,
  7.96767995e-02f, -1.76371392e-02f, 1.02159558e-02f, 9.44805220e-02f, -3.90295871e-02f, -1.03804499e-01f, -6.62414208e-02f, 2.65648931e-01f, -9.46362168e-02f, 8.84253681e-02f,
  -2.86865383e-01f, -1.24193698e-01f, 3.60555500e-02f, -1.72426984e-01f, -9.58397463e-02f, 1.71354204e-01f, 4.63375486e-02f, 2.14166358e-01f, 1.28703371e-01f, 2.40677804e-01f,
  -2.12136745e-01f, -4.18754220e-02f, -2.63120443e-01f, 1.33599520e-01f, -5.62077500e-02f, -3.44588161e-02f, -1.71738490e-01f, 5.37866987e-02f, 5.52171506e-02f, -6.79851547e-02f,
  6.90712333e-02f, 1.27948955e-01f, 6.48096353e-02f, 5.37156761e-02f, -1.95468351e-01f, -2.11374164e-01f, 8.49296898e-02f, -6.41214103e-02f, 2.11432315e-02f, 1.33857802e-02f,
  7.35687613e-02f, 1.86504587e-03f, -1.27939612e-01f, 4.93997820e-02f, -5.54487705e-02f, 1.95058793e-01f, -7.51457587e-02f, 1.54791757e-01f, -1.19127318e-01f, 4.25945781e-02f,
  1.52669936e-01f, -6.88270479e-03f, 6.69411272e-02f, 6.57462552e-02f, -1.36979327e-01f, -2.65084933e-02f, -3.96853872e-02f, -1.23132030e-02f, 9.81621593e-02f, 1.98898613e-02f,
  2.06766967e-02f, 6.84628487e-02f, -3.08062900e-02f, 3.07501685e-02f, -4.92996245e-04f, 1.11360565e-01f, 6.26349449e-02f, 9.44684520e-02f, 8.72366577e-02f, 3.24960314e-02f,
  2.80770287e-02f, 1.19871505e-01f, -8.78392905e-02f, 1.15833230e-01f, 1.29852176e-01f, -2.10161135e-02f, 1.40184850e-01f, -8.37568268e-02f, -9.05594453e-02f, 1.01385109e-01f,
  -3.73970345e-02f, -1.28270924e-01f, 6.40076920e-02f, 1.65518507e-01f, 1.08420337e-03f, -1.08891524e-01f, -8.07443783e-02f, 2.88352892e-02f, -1.43159688e-01f, -7.47541487e-02f,
  -1.08094864e-01f, 5.96220642e-02f, 2.90647428e-02f, -1.61854476e-01f, -2.37377197e-01f, 4.78642359e-02f, 1.45364851e-01f, 3.28224003e-02f, 1.81850806e-01f, 5.59169911e-02f,
  -3.65727246e-02f, 1.01835266e-01f, 4.72497791e-02f, 1.78499386e-01f, 3.18271178e-03f, -1.17939770e-01f, 9.09244642e-02f, -6.73964480e-03f, -2.42771894e-01f, -8.91769584e-03f,
  1.21983901e-01f, -2.58999109e-01f, -7.11922646e-02f, 3.18577327e-02f, -4.12338525e-02f, 1.74106762e-01f, 3.36967148e-02f, 5.05511872e-02f, -5.49402041e-03f, -2.63049938e-02f,
  1.54204860e-01f, 3.09909675e-02f, -1.81229994e-01f, 1.90098584e-01f, 1.82259909e-03f, 4.67968695e-02f, 1.37680337e-01f, 2.49234065e-01f, -2.10253671e-01f, 2.85895735e-01f,
  -9.85737741e-02f, -2.56214421e-02f, -1.03339285e-01f, 1.17657017e-02f, -1.08918630e-01f, -6.58086091e-02f, 5.82355894e-02f, -1.34615928e-01f, 1.49198443e-01f, 1.21774480e-01f,
  -1.77490443e-01f, 3.19225580e-01f, 9.74007882e-03f, -1.03828900e-01f, -6.28722087e-02f, 1.08200110e-01f, -2.29853857e-02f, 1.16269607e-02f, 4.21193987e-02f, 1.06077686e-01f,
  4.80184369e-02f, -1.50136471e-01f, -3.79957259e-02f, -9.97932106e-02f, 7.11268261e-02f, 8.22256655e-02f, 2.73289904e-02f, -2.24195663e-02f, -4.52876687e-02f, 2.97516156e-02f,
  8.14341158e-02f, 5.83116822e-02f, -5.58805317e-02f, 5.54340109e-02f, 3.63155007e-02f, -5.02032414e-02f, -2.03717481e-02f, -6.10092282e-02f, -4.52807872e-03f, -1.45864204e-01f,
  3.84933129e-02f, -1.29856557e-01f, 8.45944434e-02f, 5.24831079e-02f, 8.45467895e-02f, -1.93997510e-02f, -1.11915525e-02f, 5.92315644e-02f, -7.80748427e-02f, -1.40905634e-01f,
  4.91103455e-02f, -1.10431962e-01f, 3.14242281e-02f, -4.35248949e-03f, 1.60622880e-01f, 7.84076750e-02f, 4.66701128e-02f, 7.36099109e-02f, 4.25014608e-02f, 4.69371006e-02f,
  8.02568942e-02f, 1.30341232e-01f, 1.06594741e-01f, 1.67425603e-01f, 1.80384681e-01f, -1.58778746e-02f, 1.29892543e-01f, 5.14275320e-02f, 1.76735029e-01f, 6.77659810e-02f,
  6.93603233e-02f, -1.06282778e-01f, -1.01083055e-01f, 4.87067290e-02f, -4.56578098e-02f, 5.88321760e-02f, -9.64162052e-02f, -2.08471417e-01f, 1.24834336e-01f, 9.50409025e-02f,
  -2.09687963e-01f, 1.50563195e-03f, 5.44532575e-02f, -1.11976124e-01f, 1.02447703e-01f, -1.42333269e-01f, 6.54247478e-02f, 4.10917681e-03f, -5.02595007e-02f, -1.02587581e-01f,
  9.34179220e-03f, 9.40565988e-02f, 8.45122263e-02f, 9.46532935e-02f, 3.98114463e-03f, -1.87768817e-01f, 4.16362509e-02f, 2.43338048e-02f, -1.63486242e-04f, -1.74738705e-01f,
  -7.65618011e-02f, -3.55714969e-02f, 1.13350302e-01f, 1.30866291e-02f, 4.76271436e-02f, -2.75613982e-02f, -8.23523011e-03f, 2.64882352e-02f, -3.77573725e-03f, 1.75492927e-01f,
  1.49977610e-01f, 1.10538244e-01f, 6.03166223e-02f, -2.21557230e-01f, -6.22170679e-02f, -2.00041737e-02f, -7.82944113e-02f, 2.91682422e-01f, -9.39164236e-02f, -1.30950406e-01f,
  2.28228062e-01f, -8.02664924e-03f, 9.53851864e-02f, -6.26420081e-02f, -1.57622829e-01f, -1.91148482e-02f, 2.79350936e-01f, -2.67217122e-02f, 3.39563354e-03f, 2.08648341e-03f,
  1.17712118e-01f, -7.46782422e-02f, 2.47558892e-01f, -1.19382158e-01f, 1.26149401e-01f, 3.44603732e-02f, -1.75155595e-01f, 1.20268680e-01f, 5.98142855e-02f, 1.15051076e-01f,
  1.29208043e-01f, -1.53770372e-01f, 8.71671364e-02f, -7.56316036e-02f, 1.47113934e-01f, 1.11741841e-01f, 1.51489839e-01f, 1.56210288e-01f, 3.14513177e-01f, 6.22672848e-02f,
  -3.32584493e-02f, -2.34772507e-02f, 1.78344343e-02f, 6.89569861e-02f, -9.74346325e-02f, 7.05731660e-03f, -1.49466703e-02f, 1.03007264e-01f, -2.46373098e-02f, -8.90560225e-02f,
  -6.67345524e-02f, -3.40975486e-02f, -7.70561621e-02f, -3.46951857e-02f, 1.23757213e-01f, -9.84728150e-03f, 7.75814354e-02f, 1.99970063e-02f, -7.82848969e-02f, -6.67610914e-02f,
  -1.12917900e-01f, -1.36208925e-02f, -9.05939415e-02f, -1.19769633e-01f, 4.28009406e-02f, 2.69235671e-02f, 3.27118449e-02f, 4.02408838e-02f, -6.08443283e-02f, -5.24823219e-02f,
  2.18751151e-02f, 8.03585947e-02f, -5.48618622e-02f, -1.65630966e-01f, 5.17216362e-02f, -1.38740502e-02f, -1.18425479e-02f, -1.11463256e-01f, -5.92905357e-02f, -7.11593926e-02f,
  2.78364308e-02f, -1.14405323e-02f, 1.29850144e-02f, 1.00873575e-01f, 4.21598963e-02f, -3.72948614e-03f, -3.60397063e-02f, 7.57115632e-02f, -9.23772156e-02f, 4.39859070e-02f,
  -2.02456191e-02f, -1.07201993e-01f, 1.33054182e-01f, -3.58287767e-02f, -5.22149280e-02f, 2.30550021e-01f, -2.23143920e-02f, -7.49541745e-02f, 1.53261244e-01f, -1.18791424e-01f,
  -7.46481307e-03f, 4.61743660e-02f, -2.44779646e-01f, -1.77795410e-01f, 5.49210496e-02f, 6.32239804e-02f, -4.22511585e-02f, 3.17325518e-02f, 5.93859889e-02f, -1.84905883e-02f,
  2.14413051e-02f, -7.73861930e-02f, -3.50529589e-02f, 5.90478070e-02f, -7.44875427e-03f, 8.40331241e-02f, 1.48363024e-01f, 1.19063430e-01f, 5.90668665e-03f, 1.26071006e-01f,
  -5.52149825e-02f, -2.11120099e-02f, 2.94512641e-02f, 2.04287879e-02f, 5.13281673e-02f, -1.08241014e-01f, -3.97236943e-02f, -1.89711787e-02f, 4.51967977e-02f, -6.55172467e-02f,
  -1.73954546e-01f, 1.56801388e-01f, 4.25794013e-02f, 3.04454267e-02f, -7.71003067e-02f, -9.42624435e-02f, -3.63106802e-02f, 2.05989685e-02f, -4.19370532e-02f, 6.22556582e-02f,
  -2.12794561e-02f, 8.55216309e-02f, -1.29018009e-01f, 1.54654413e-01f, -1.18720487e-01f, -3.86434309e-02f, 8.29074010e-02f, 6.82789385e-02f, 3.75003964e-02f, 1.93197370e-01f,
  7.82222673e-02f, -1.87831730e-01f, 1.51246265e-02f, -3.18100482e-01f, -1.13632470e-01f, 1.02711529e-01f, -7.17687905e-02f, -1.13140307e-01f, -1.99609056e-01f, 1.04506254e-01f,
  -1.14344984e-01f, -2.54891664e-01f, 5.70570752e-02f, -1.82617068e-01f, -8.78095999e-03f, -2.05087215e-01f, 6.00725077e-02f, -1.46097377e-01f, 1.83826208e-01f, 1.04741417e-01f,
  1.24497078e-02f, -1.15154743e-01f, -3.81566547e-02f, 2.74095014e-02f, -5.23160696e-02f, -1.00903779e-01f, -5.48776016e-02f, -1.17131539e-01f, -9.88231301e-02f, 2.20474731e-02f,
  -1.27730146e-01f, -1.44314393e-01f, -1.53643191e-01f, -4.68755290e-02f, -2.64139171e-03f, -2.10624132e-02f, 4.66694944e-02f, -1.66216552e-01f, -8.13948810e-02f, -2.42860299e-02f,
  -1.77320093e-01f, 2.68712807e-02f, 6.61968142e-02f, -2.19393745e-02f, 1.03930220e-01f, 4.62136045e-02f, -2.92078443e-02f, -6.07915930e-02f, 6.43097684e-02f, -2.30058096e-02f,
  -9.75205656e-03f, 1.03480309e-01f, -1.34153117e-03f, 9.51391160e-02f, 1.00636601e-01f, -7.07388893e-02f, -1.07761107e-01f, -7.57081360e-02f, 5.07127345e-02f, -6.56947568e-02f,
  2.14117002e-02f, -8.15812051e-02f, -1.11879623e-02f, -6.01263568e-02f, 1.31443813e-02f, -9.05394852e-02f, -1.99218132e-02f, -5.62978238e-02f, 1.22124795e-02f, -1.29348934e-01f,
  -3.41715738e-02f, 2.33260468e-01f, -1.58469766e-01f, -1.08476952e-01f, 1.31814227e-01f, 1.86657593e-01f, -8.10077041e-02f, -6.67280108e-02f, -5.08067235e-02f, 1.12874813e-01f,
  -7.97388777e-02f, -9.80723202e-02f, 2.15607077e-01f, 8.85221083e-03f, -9.67416987e-02f, -1.52107403e-02f, -4.86530922e-02f, 8.87828413e-03f, 3.74905579e-02f, 7.86935613e-02f,
  -1.32557884e-01f, -5.77767678e-02f, 4.75781895e-02f, 1.24610633e-01f, 5.90911023e-02f, 2.57170890e-02f, 3.83749418e-03f, 1.04996644e-01f, 1.88822970e-01f, 1.97554324e-02f,
  -1.56555362e-02f, 4.41126116e-02f, 1.88212112e-01f, -1.12127297e-01f, 1.31691605e-01f, 6.20514415e-02f, -2.40565203e-02f, -8.29335898e-02f, 1.05333403e-01f, -5.37977777e-02f,
  1.98380008e-01f, -7.02189207e-02f, -3.82768698e-02f, 1.10463135e-01f, -1.14509545e-01f, -6.48433194e-02f, -1.92146637e-02f, 1.92805827e-01f, -1.77807808e-02f, -4.84376475e-02f,
  -7.23267049e-02f, 9.38076824e-02f, -6.06699884e-02f, -7.86564350e-02f, 7.03984872e-02f, 1.18154902e-02f, 1.12049960e-01f, -1.97901968e-02f, -5.20258024e-03f, 2.26438910e-01f,
  1.49050227e-03f, 3.39640044e-02f, 2.54084412e-02f, 8.71961564e-02f, 8.87907073e-02f, 1.43551379e-01f, 1.33427745e-02f, -8.62375870e-02f, 4.65234667e-02f, -3.30276579e-01f,
  -6.77392399e-03f, -1.31088734e-01f, -7.02842250e-02f, -2.50045300e-01f, 2.53991991e-01f, -1.43859223e-01f, -8.30224752e-02f, 7.91306570e-02f, 5.43208197e-02f, -3.64427380e-02f,
  -2.77194940e-03f, 2.06543896e-02f, 3.16044465e-02f, 5.94992526e-02f, 1.00878544e-01f, 1.00477047e-01f, 9.38181803e-02f, -4.21201736e-02f, -6.16503833e-03f, 8.85367319e-02f,
  -2.12448444e-02f, -6.53201640e-02f, 1.98984817e-02f, -6.35237843e-02f, 4.13891301e-02f, -3.73105854e-02f, -1.57142319e-02f, 2.41976995e-02f, -4.74342704e-03f, -3.70602086e-02f,
  -6.81413859e-02f, -8.04176629e-02f, 3.84838395e-02f, -1.61416337e-01f, -1.26381069e-01f, -1.71504661e-01f, 8.99352878e-02f, 1.17158227e-01f, -2.16598492e-02f, 1.83425266e-02f,
  1.53515143e-02f, -3.13593708e-02f, 2.90745981e-02f, -2.78281905e-02f, -5.25900302e-03f, 8.35799202e-02f, 2.61972658e-02f, -1.32157821e-02f, -5.71482517e-02f, -4.53417301e-02f,
  4.77861650e-02f, -7.11547583e-02f, 6.64047301e-02f, 2.11682338e-02f, 3.28677632e-02f, 5.24201468e-02f, -7.97409341e-02f, -1.73288837e-01f, -2.14175992e-02f, 5.85006550e-02f,
  -1.69383720e-01f, -5.69613166e-02f, -8.03541839e-02f, -1.41796410e-01f, 1.09715629e-02f, -9.68408212e-02f, -1.12570375e-01f, -8.36693719e-02f, 1.03757173e-01f, 1.19799329e-03f,
  -1.94249153e-02f, -1.57778293e-01f, -7.92148858e-02f, 8.05413872e-02f, 3.43176275e-02f, 2.48419940e-02f, -6.55037835e-02f, 7.28169084e-02f, 7.71665797e-02f, -2.92761862e-01f,
  3.18492614e-02f, 8.86550695e-02f, 1.11833680e-02f, -1.71778314e-02f, -2.41805278e-02f, 1.71961039e-01f, -1.04474239e-01f, 1.98213816e-01f, 2.89707184e-02f, -1.74352005e-02f,
  2.26106364e-02f, -5.10246642e-02f, 9.67618525e-02f, 7.01925159e-03f, 2.62793601e-01f, 8.09131712e-02f, -1.76464200e-01f, -1.58679992e-01f, 1.41048888e-02f, -7.56440610e-02f,
  -1.16726980e-01f, -1.33170420e-02f, 2.91857813e-02f, -1.23291425e-01f, 1.42674726e-02f, -2.60307714e-02f, -3.53798643e-02f, -2.16637403e-01f, 1.12443537e-01f, 8.86707380e-03f,
  -4.96067941e-01f, 4.94730957e-02f, -1.19812272e-01f, -3.69884260e-03f, -8.76589119e-02f, 2.12946862e-01f, 1.63580701e-02f, 5.03134727e-02f, -5.82196154e-02f, -1.04112506e-01f,
  1.30702481e-01f, 5.40269762e-02f, 8.35203845e-03f, 1.23589687e-01f, -1.52327791e-01f, -4.26879115e-02f, 4.86202985e-02f, -1.01450823e-01f, 2.14245357e-02f, -1.67302459e-01f,
  -1.35855049e-01f, 1.26476914e-01f, 2.38663122e-01f, -1.88382357e-01f, 6.82674348e-02f, -1.14049762e-01f, -8.41496512e-02f, 8.30916613e-02f, 5.86516149e-02f, 2.22822782e-02f,
  4.65844758e-03f, -3.37039381e-02f, -4.13445160e-02f, 5.20606078e-02f, -3.81960794e-02f, 2.35904548e-02f, 1.66197959e-02f, 4.56350809e-03f, -7.09019527e-02f, -6.82124868e-02f,
  5.97303137e-02f, -5.92940897e-02f, 4.07432802e-02f, 3.05785742e-02f, -1.49116561e-01f, -8.33691731e-02f, 8.24402366e-03f, -1.90566722e-02f, -7.65197203e-02f, 6.14776649e-02f,
  -2.31801979e-02f, 1.87636778e-01f, 5.47037013e-02f, 4.56113406e-02f, 6.12757504e-02f, 2.87520383e-02f, 2.93047372e-02f, -4.29048464e-02f, -8.97070616e-02f, -5.47409430e-02f,
  1.92881841e-02f, -4.58206460e-02f, -7.95120448e-02f, 6.63708337e-03f, -9.08718258e-02f, -3.34159546e-02f, 4.62448709e-02f, -1.48729607e-02f, -4.42470573e-02f, -5.85527085e-02f,
  8.52627009e-02f, -4.12204899e-02f, 8.90417174e-02f, -1.34999277e-02f, -7.74387866e-02f, -7.63282925e-02f, 8.23663175e-02f, -1.46143828e-02f, -7.94481635e-02f, 2.06677411e-02f,
  1.05256471e-03f, -9.99073163e-02f, 2.44795196e-02f, -1.57239243e-01f, -1.16088852e-01f, 2.42446270e-02f, 1.09469583e-02f, 6.82047084e-02f, 2.68569309e-02f, -3.58002000e-02f,
  -9.03981552e-02f, 8.43954757e-02f, 6.86248094e-02f, -6.32639006e-02f, -2.21006200e-01f, -2.44939085e-02f, 7.32196495e-02f, -3.47746499e-02f, 1.32919559e-02f, -7.65929138e-03f,
  1.12309754e-01f, 5.09289838e-02f, -8.46188236e-03f, 3.46123017e-02f, -1.24630883e-01f, -9.31468904e-02f, -8.12530220e-02f, 6.25506649e-03f, 1.10512815e-01f, 4.18641753e-02f,
  1.62339490e-02f, -1.22245446e-01f, 1.48876607e-01f, 5.47307692e-02f, -2.41955712e-01f, 8.60549882e-02f, 7.67228454e-02f, -1.26724854e-01f, -1.01404347e-01f, -9.30163562e-02f,
  2.22845048e-01f, -5.12409508e-02f, -2.23873720e-01f, 5.00566587e-02f, 2.54991800e-02f, -4.02015150e-02f, 1.30387947e-01f, 1.56358987e-01f, -4.18317884e-01f, 1.10156000e-01f,
  7.40924431e-03f, -1.36904538e-01f, -1.01679072e-01f, 2.49228999e-02f, -6.60901517e-02f, -1.02027640e-01f, -2.67929137e-02f, -1.84218615e-01f, 2.18751431e-01f, -9.53220427e-02f,
  -6.00687303e-02f, 2.53943413e-01f, -1.82249863e-02f, 2.98270490e-02f, -4.64963801e-02f, -2.22000442e-02f, -4.40676324e-02f, -1.74490988e-01f, -2.61130661e-01f, -3.12533043e-02f,
  3.15866351e-01f, -3.27257067e-01f, 1.74533669e-02f, -1.22421652e-01f, -2.62694377e-02f, 1.07402809e-01f, -9.98408869e-02f, 1.32748991e-01f, -8.13249946e-02f, -7.34618530e-02f,
  2.42396723e-02f, 7.54506886e-02f, 1.36788309e-01f, -2.85674352e-02f, 8.98940936e-02f, 2.96450127e-02f, 4.96895760e-02f, 3.37448418e-02f, 5.48449047e-02f, -2.99318861e-02f,
  -1.17343687e-01f, -2.19003414e-03f, 9.21032280e-02f, -1.49437292e-02f, 3.79172266e-02f, 2.46076081e-02f, -8.05144981e-02f, 2.40408499e-02f, -6.25178069e-02f, -8.75563696e-02f,
  2.24386901e-02f, -6.24266788e-02f, 1.18362948e-01f, 2.12774761e-02f, 4.95693162e-02f, -6.86614513e-02f, -5.61180674e-02f, 5.02709970e-02f, -2.01934227e-03f, -1.30272657e-01f,
  7.51244351e-02f, -6.81253001e-02f, 2.94266455e-02f, -4.11215350e-02f, -6.54893667e-02f, -3.73649076e-02f, 3.66347879e-02f, 1.15743138e-01f, -3.52725014e-02f, 7.12162182e-02f,
  -1.03498444e-01f, 6.99878410e-02f, 3.89829744e-03f, 6.88799918e-02f, 1.74293239e-02f, 3.67900580e-02f, 8.31875280e-02f, -6.67676851e-02f, 2.51047569e-03f, -3.70268710e-02f,
  4.35949117e-02f, 4.65358198e-02f, 1.85727164e-01f, 1.16846241e-01f, -2.66628712e-02f, 1.19806439e-01f, -1.79455414e-01f, -3.87093872e-02f, 6.44652098e-02f, 6.84678704e-02f,
  -1.62119925e-01f, 4.90227481e-03f, 2.06841305e-01f, 1.14099629e-01f, 2.51390431e-02f, 1.32152840e-01f, -8.09596665e-03f, 1.15570158e-01f, 2.88463011e-02f, 3.68072093e-02f,
  3.01990174e-02f, -7.42248520e-02f, 3.49504985e-02f, -2.30965894e-02f, -4.05478813e-02f, 5.73392399e-03f, 8.05989839e-03f, 1.58188820e-01f, 4.64196131e-02f, -2.96705458e-02f,
  -1.80232853e-01f, 4.41251732e-02f, 8.09807330e-02f, 4.71737757e-02f, -7.18784193e-03f, 6.91360831e-02f, 1.45723233e-02f, 5.79644069e-02f, -2.03762457e-01f, 4.24940810e-02f,
  1.35316312e-01f, -1.69855595e-01f, -1.03852637e-01f, 4.69970033e-02f, 2.06057858e-02f, -2.23943114e-01f, 1.94577768e-01f, -2.14717716e-01f, 8.18633661e-02f, 1.65958956e-01f,
  7.91677833e-02f, 4.48293574e-02f, -6.64634779e-02f, 5.98900095e-02f, 5.12699150e-02f, 2.77025610e-01f, -1.01399437e-01f, -2.09827408e-01f, 4.11328673e-02f, -2.62643635e-01f,
  6.80535063e-02f, 8.73574838e-02f, -5.03816232e-02f, 7.17636868e-02f, 3.03027537e-02f, 5.47376014e-02f, 5.09863831e-02f, 3.31973374e-01f, -3.14871758e-01f, 2.15941191e-01f,
  1.31950364e-01f, 5.12968823e-02f, -7.50415921e-02f, 1.68122888e-01f, -4.79511730e-02f, 1.82961784e-02f, 1.75748784e-02f, -5.59404232e-02f, 4.87234630e-03f, 5.41099645e-02f,
  6.19234145e-02f, 8.32306221e-02f, -4.81182747e-02f, -3.20912488e-02f, 3.81960114e-03f, 1.90194938e-02f, -8.17307830e-03f, -9.94018167e-02f, -1.76770911e-01f, -1.90644488e-02f,
  -2.38742214e-02f, -1.81721617e-03f, 4.90958020e-02f, -9.55534875e-02f, -8.67344961e-02f, 6.40979782e-02f, -1.98264495e-01f, 6.59159496e-02f, 2.57553309e-02f, 8.74952786e-03f,
  5.89752011e-02f, -5.98344533e-03f, 5.50887315e-03f, -1.22743854e-02f, -3.74993645e-02f, 2.04016957e-02f, -2.39745043e-02f, 1.02788351e-01f, 3.47807743e-02f, -2.67051291e-02f,
  1.88940585e-01f, 2.02107541e-02f, -3.68871093e-02f, 3.06547265e-02f, 1.92794800e-02f, 3.80925275e-02f, 8.87299851e-02f, -3.01584997e-03f, 1.06207497e-01f, -2.87528932e-02f,
  -4.76634093e-02f, -7.36712217e-02f, -5.38936742e-02f, -4.77141375e-03f, 1.45475045e-01f, -1.77337900e-01f, -4.20128405e-02f, 8.04605111e-02f, -1.83390290e-01f, -8.37876275e-02f,
  5.00197783e-02f, -9.86521617e-02f, 1.17876671e-01f, -6.97574541e-02f, -4.09057662e-02f, -1.77206650e-01f, 5.18878102e-02f, 3.17117646e-02f, 9.95827988e-02f, 9.01860073e-02f,
  1.53842837e-01f, 1.98603973e-01f, 4.33310606e-02f, -6.90084249e-02f, -8.31701383e-02f, 5.00000678e-02f, -7.79187530e-02f, 6.26738518e-02f, -1.90706044e-01f, -9.46206525e-02f,
  -1.19365938e-01f, 1.90238938e-01f, -1.29912317e-01f, 1.54962912e-01f, -1.29656466e-02f, 9.98675302e-02f, 4.86327372e-02f, 2.43667383e-02f, 1.14787668e-01f, 2.07451820e-01f,
  -1.84365436e-02f, -1.88358784e-01f, -7.03633353e-02f, -8.64136443e-02f, 1.17782444e-01f, 1.01920128e-01f, -9.36371386e-02f, -1.64690465e-01f, 2.05433220e-01f, -7.95483142e-02f,
  -2.06195742e-01f, -1.77622259e-01f, -1.33357018e-01f, -8.17815661e-02f, -1.66583713e-02f, -5.97184785e-02f, -1.71271220e-01f, -3.75422500e-02f, -9.72998142e-02f, 1.12254523e-01f,
  -1.89452097e-02f, 2.11306453e-01f, -1.60855621e-01f, 5.62448204e-02f, -2.79713631e-01f, 2.69367844e-02f, 9.35072750e-02f, 3.74620780e-02f, 8.85684863e-02f, -1.06863961e-01f,
  1.10233530e-01f, 2.26012185e-01f, -1.77901268e-01f, -4.26665395e-02f, -1.91709176e-02f, 1.63145155e-01f, 2.99710985e-02f, 7.40971491e-02f, 5.53429052e-02f, -1.13577917e-01f,
  -7.19360486e-02f, 4.91228327e-02f, 4.40696180e-02f, 2.57075345e-03f, -1.96110290e-02f, 1.29751682e-01f, -9.97853726e-02f, 4.51025227e-03f, -4.26559411e-02f, 5.65632582e-02f,
  7.80820549e-02f, -2.02608621e-03f, -4.73204441e-02f, -7.19460379e-03f, 2.52702553e-02f, 5.53947873e-02f, -8.38353261e-02f, 1.15379937e-01f, -7.02629834e-02f, -1.25411740e-02f,
  -5.03459834e-02f, -7.49817770e-03f, 4.17001732e-02f, -4.17470746e-03f, 8.50697160e-02f, -1.20756842e-01f, 3.84897701e-02f, 1.71270203e-02f, -7.96369538e-02f, 1.35920718e-01f,
  -1.49748595e-02f, -1.49260703e-02f, -1.65430568e-02f, -5.58513217e-02f, 1.42005399e-01f, -1.67938378e-02f, 1.52307391e-01f, -3.08563653e-02f, 1.01897299e-01f, -1.92098394e-02f,
  -1.99635159e-02f, 4.38322835e-02f, -6.33723382e-03f, -1.03082396e-01f, 1.42417178e-02f, -1.61023624e-02f, -6.59598559e-02f, 5.59893288e-02f, 2.49180924e-02f, 1.94589466e-01f,
  1.94166437e-01f, 5.99979274e-02f, -6.11705147e-03f, 1.82690665e-01f, -5.48166921e-03f, 4.65625711e-02f, -1.24592096e-01f, 1.09065399e-01f, -1.85312748e-01f, 1.63650200e-01f,
  -1.34893790e-01f, 2.19914168e-01f, -2.12036878e-01f, -3.87177207e-02f, 9.70001146e-02f, 1.03757679e-01f, 3.89495157e-02f, -7.63597861e-02f, 8.41742456e-02f, 1.03904590e-01f,
  1.14121296e-01f, 2.69532859e-01f, -1.15628354e-01f, 6.72877282e-02f, -1.31719559e-01f, 2.26754457e-01f, -7.29919821e-02f, 2.31435392e-02f, 4.79201414e-02f, -1.88036874e-01f,
  -5.13525605e-02f, -1.84555743e-02f, 6.83215111e-02f, 1.05184224e-02f, -2.03533117e-02f, -2.29527637e-01f, -2.77759045e-01f, -8.92100930e-02f, 4.90337685e-02f, 2.03964368e-01f,
  4.67669666e-02f, -1.39167354e-01f, -6.06931895e-02f, 1.22263050e-02f, -5.46311885e-02f, 1.10284142e-01f, 1.37570038e-01f, -2.05153868e-01f, 5.46671934e-02f, 6.89703077e-02f,
  9.57175270e-02f, 2.05624193e-01f, -4.09828201e-02f, -2.10888982e-01f, -3.00600547e-02f, -9.22778472e-02f, -9.16559771e-02f, 1.35947213e-01f, 6.18215092e-02f, -1.26868546e-01f,
  -1.69376079e-02f, -9.72175226e-02f, -2.61013452e-02f, 6.99546421e-03f, -1.84859142e-01f, 9.83761251e-03f, 7.43551180e-02f, -5.20313755e-02f, -1.41731262e-01f, -1.21954106e-01f,
  -1.77926227e-01f, -1.83018640e-01f, 2.38268986e-01f, 8.43298733e-02f, -1.26507044e-01f, -6.74426183e-03f, -8.36357176e-02f, -1.36686653e-01f, -5.51419258e-02f, 3.02429590e-02f,
  3.67234387e-02f, 2.33535450e-02f, -5.69481263e-03f, -3.36147211e-02f, 1.92646962e-02f, 7.12692216e-02f, 8.15481842e-02f, 4.90712747e-02f, 5.87290563e-02f, -8.14902131e-03f,
  5.47587685e-03f, 1.23902848e-02f, -1.83747131e-02f, -6.99200341e-03f, -5.27775437e-02f, -1.06584027e-01f, -6.33282140e-02f, 8.96259099e-02f, -2.38715801e-02f, -6.46168515e-02f,
  -1.13692686e-01f, 9.06839594e-03f, 8.01116321e-03f, 8.69453475e-02f, -6.18401803e-02f, 8.00467506e-02f, -7.20851049e-02f, 1.08855299e-03f, 1.28554069e-02f, -5.45281768e-02f,
  5.63104227e-02f, -9.66757461e-02f, -9.99063924e-02f, -5.53358607e-02f, 2.78047528e-02f, -9.22203064e-02f, -1.44269448e-02f, -4.17307690e-02f, -7.34104589e-02f, 1.30208373e-01f,
  1.23919301e-01f, -3.00963260e-02f, -3.94342057e-02f, -9.15748253e-02f, -1.07971057e-01f, 3.38125676e-02f, -5.81870824e-02f, -7.05342442e-02f, 3.32626961e-02f, 4.30918150e-02f,
  -1.49114221e-01f, 6.74758628e-02f, -1.09387478e-02f, 1.37209132e-01f, 1.73950762e-01f, 1.23338543e-01f, -1.50771067e-01f, 1.76118768e-03f, -4.82694730e-02f, -9.58752632e-02f,
  -4.65138741e-02f, 1.04051366e-01f, 2.68166382e-02f, 8.95866901e-02f, 4.02183421e-02f, 5.75083792e-02f, -7.11996779e-02f, 1.74792290e-01f, 4.35308777e-02f, -7.25151524e-02f,
  -3.10946479e-02f, -3.62862945e-02f, 5.78079261e-02f, 3.27356867e-02f, 1.21615894e-01f, 1.45594060e-01f, -1.16814628e-01f, -4.73795421e-02f, -1.12150691e-01f, -1.14352629e-01f,
  -1.87992156e-02f, -3.73104028e-02f, -4.96733077e-02f, -6.40960932e-02f, 1.21608987e-01f, 3.52042019e-02f, 1.70704886e-01f, 1.61343724e-01f, 7.43514895e-02f, 5.14538214e-02f,
  1.68542136e-02f, -9.48386714e-02f, -1.37684979e-02f, 4.11526598e-02f, -1.15385994e-01f, 7.27210417e-02f, 2.33301148e-03f, 6.39146268e-02f, 1.14148520e-01f, 1.67202547e-01f,
  1.33571997e-02f, -5.94499819e-02f, 2.13950321e-01f, 9.73028615e-02f, 1.61759064e-01f, 3.71588096e-02f, -3.68640572e-02f, -1.59851924e-01f, 1.44660369e-01f, -2.62922406e-01f,
  7.15195090e-02f, -2.71207895e-02f, -5.81756942e-02f, 2.34078705e-01f, -4.36819047e-02f, -1.27876639e-01f, -5.16554862e-02f, -2.92893976e-01f, -4.63556312e-02f, -2.47422770e-01f,
  -3.70651066e-01f, 3.45050320e-02f, 1.86122417e-01f, -7.94105157e-02f, -3.24992202e-02f, -4.77773547e-02f, -3.38773094e-02f, -9.19363869e-04f, -1.03908695e-01f, 5.23162633e-02f,
  -4.21464704e-02f, -2.12807029e-01f, 3.47606279e-02f, 1.08625725e-01f, -5.81405126e-02f, 4.60855616e-03f, 1.22386049e-02f, 9.68686864e-02f, -8.77854303e-02f, -1.06769182e-01f,
  -1.29743796e-02f, 1.14171751e-01f, 7.18094185e-02f, 4.59044948e-02f, -5.09532653e-02f, 6.65894593e-04f, -1.04082013e-02f, 4.27067950e-02f, 3.05533353e-02f, -1.22857146e-01f,
  -3.56776267e-02f, -2.86462791e-02f, -1.31434649e-02f, 5.94541766e-02f, -4.85527255e-02f, -6.42700717e-02f, -4.60168533e-02f, -1.31581221e-02f, -4.28103395e-02f, -3.04325894e-02f,
  -9.43578109e-02f, 5.59711941e-02f, 8.00160915e-02f, 4.62180488e-02f, 7.68956775e-03f, 4.56552953e-02f, -3.50622507e-03f, -7.57551193e-02f, -1.17311835e-01f, 4.99800779e-02f,
  3.44234966e-02f, -1.39056727e-01f, -5.44653274e-02f, -4.78269607e-02f, 1.19619749e-01f, -7.20324367e-02f, 2.19564103e-02f, -1.54271290e-01f, 2.06485584e-01f, 1.18611626e-01f,
  5.24495505e-02f, -4.26816419e-02f, -6.13795891e-02f, 9.55895893e-03f, -3.55159789e-02f, 1.85684741e-01f, -4.69512753e-02f, 2.16338690e-02f, -1.06372401e-01f, 1.16465330e-01f,
  -1.72062982e-02f, -5.44251837e-02f, 3.55618335e-02f, -2.64204256e-02f, -7.53513072e-03f, -1.04497761e-01f, -9.77101997e-02f, 1.45958006e-01f, 1.34072334e-01f, 1.95030849e-02f,
  -1.35901589e-02f, 7.82705694e-02f, -3.04098986e-02f, -8.18162784e-02f, 3.91903557e-02f, -1.26974061e-01f, 7.80372322e-02f, -5.24355993e-02f, -8.46290886e-02f, -1.16748318e-01f,
  1.61478985e-02f, 7.01223910e-02f, -1.82319954e-01f, -3.33796907e-03f, 8.96351412e-02f, 1.12830870e-01f, 4.52652387e-02f, -2.55123712e-02f, 5.64895049e-02f, -1.51253194e-02f,
  5.14471158e-02f, 6.79909959e-02f, -2.53059834e-01f, 9.42130461e-02f, 1.16728306e-01f, 1.22908793e-01f, -1.82311051e-02f, -2.76894215e-02f, 2.78374583e-01f, 1.01458549e-01f,
  -1.60968974e-01f, -9.26750004e-02f, 5.71371764e-02f, 6.06160797e-02f, -2.00203836e-01f, -1.07149959e-01f, -1.68935396e-02f, -4.00185063e-02f, 2.43959084e-01f, 2.48799339e-01f,
  -1.72201067e-01f, -2.04370558e-01f, 1.18452109e-01f, -2.90378667e-02f, -8.81558880e-02f, -3.88497412e-02f, -6.05546460e-02f, 1.34047970e-01f, 2.19816700e-01f, -6.91387057e-02f,
  -1.85139611e-01f, 1.10410541e-01f, -4.42201234e-02f, 7.38245472e-02f, 5.14459498e-02f, -1.84533987e-02f, 1.12680800e-01f, -7.00270012e-02f, 5.46401516e-02f, -4.95566754e-04f,
  1.29467668e-02f, 4.40317020e-02f, -8.39508995e-02f, 1.05977975e-01f, -9.21337306e-02f, -5.25268652e-02f, -7.05967620e-02f, 4.36572917e-02f, 7.63906687e-02f, 6.57880828e-02f,
  -6.45962954e-02f, -2.05535698e-03f, -1.89481616e-01f, -9.67371613e-02f, -2.15541366e-02f, 3.96241918e-02f, 1.74672413e-03f, 6.48136437e-02f, 1.06736824e-01f, 4.06554118e-02f,
  -5.99278882e-02f, -4.44348790e-02f, -7.09489509e-02f, -4.63636406e-02f, 1.03273299e-02f, -3.07662617e-02f, 9.21689719e-02f, -5.51315621e-02f, 4.97999191e-02f, -1.30110160e-01f,
  -1.17261536e-01f, 1.23267546e-02f, 4.58197780e-02f, 3.35233100e-02f, 8.16874057e-02f, -2.72201505e-02f, 1.99515909e-01f, 1.24325072e-02f, 1.75972041e-02f, -1.39403164e-01f,
  -1.86524801e-02f, -7.61731490e-02f, -1.09378593e-02f, 3.42444852e-02f, 1.20624624e-01f, 1.33192301e-01f, -1.77086517e-01f, -1.03505537e-01f, -9.28593278e-02f, -1.41123876e-01f,
  7.77302533e-02f, -1.49992239e-02f, -7.83599615e-02f, -1.27377078e-01f, -9.55613777e-02f, 4.29600999e-02f, -2.02832874e-02f, 3.68163437e-02f, -9.09851938e-02f, 8.35868120e-02f,
  -9.62415859e-02f, -5.45347258e-02f, -1.66523129e-01f, 1.84256047e-01f, -7.17657581e-02f, -1.52112087e-02f, 2.69375276e-04f, 3.21948901e-02f, -9.32741852e-04f, -5.35844378e-02f,
  2.28075646e-02f, 6.57987297e-02f, 6.19265586e-02f, -1.25356270e-02f, -8.12999308e-02f, -4.59835678e-02f, -1.47446528e-01f, 4.66244556e-02f, -2.13633906e-02f, -1.74072795e-02f,
  2.10205033e-01f, -1.77287504e-01f, -5.64475637e-03f, -2.65084952e-03f, 2.92403027e-02f, -5.20087965e-02f, 1.00347534e-01f, 8.61026067e-03f, -1.35448426e-01f, -7.27801621e-02f,
  -8.57651681e-02f, 1.81609280e-02f, 2.13523414e-02f, 2.97944900e-02f, 1.21600524e-01f, 2.01098248e-01f, -3.79828423e-01f, 9.46575589e-03f, -1.26937032e-01f, -5.03377542e-02f,
  -3.31551507e-02f, -1.50018916e-01f, 8.98661017e-02f, -8.21002349e-02f, 3.39083076e-02f, -2.31066734e-01f, 9.20342356e-02f, -4.68786210e-02f, -1.06482930e-01f, 3.17688406e-01f,
  -5.38080931e-02f, -4.34372947e-02f, -1.23063065e-01f, -1.45088151e-01f, -3.21062729e-02f, -3.87750894e-01f, -2.32098326e-01f, 3.01194787e-01f, 2.49699786e-01f, -2.39605621e-01f,
  -1.80139676e-01f, -1.85039341e-01f, 1.25303388e-01f, -9.32421088e-02f, -1.62493706e-01f, 9.04321447e-02f, -5.95158190e-02f, -1.11340597e-01f, 5.95639460e-02f, -7.78531432e-02f,
  2.16780435e-02f, 1.18281640e-01f, -3.43494788e-02f, 5.67285307e-02f, -1.90649807e-01f, -5.76236434e-02f, 9.33776647e-02f, -1.45577088e-01f, 6.97662681e-03f, -1.05577826e-01f,
  -6.85111657e-02f, -2.45766770e-02f, -1.32545754e-01f, -4.65347320e-02f, -2.61651538e-02f, -6.64994633e-03f, -7.44425878e-02f, 3.07193641e-02f, -6.69060871e-02f, -7.88317248e-02f,
  5.79615571e-02f, 3.37220989e-02f, -2.59739235e-02f, 6.56268150e-02f, -1.35527030e-02f, -3.90632823e-02f, -3.09954658e-02f, -4.19421121e-02f, -8.99133235e-02f, -1.00591509e-02f,
  3.96075584e-02f, 4.90803644e-02f, 8.69815610e-03f, 1.08268030e-01f, -5.31516150e-02f, -4.83975299e-02f, 7.50173256e-02f, -1.14866875e-01f, 5.29424287e-02f, 5.88520989e-03f,
  -5.90406312e-03f, -4.36540693e-02f, -8.65679085e-02f, 7.11379573e-02f, 1.33022536e-02f, -8.45242739e-02f, -4.32793833e-02f, 7.07762614e-02f, -6.43801093e-02f, -9.00117457e-02f,
  -8.03057551e-02f, 1.60177439e-01f, -6.90477043e-02f, -1.38396040e-01f, 1.45480737e-01f, 1.56355307e-01f, -2.64773797e-02f, 5.90282790e-02f, 6.93558827e-02f, 2.54814982e-01f,
  7.18072951e-02f, -1.06473714e-01f, -8.72255117e-02f, -4.71265055e-02f, -3.33797261e-02f, -1.20504402e-01f, 9.42283776e-03f, 1.63838379e-02f, -9.62676704e-02f, -3.80911641e-02f,
  -1.73445895e-01f, 9.93662048e-03f, -9.31476653e-02f, 5.15293293e-02f, -8.88740271e-02f, -7.54219294e-02f, -9.39484760e-02f, 2.45471269e-01f, 1.06295608e-02f, 1.93391055e-01f,
  -7.50605436e-03f, -5.41313726e-04f, -4.03971523e-02f, 5.79269417e-02f, 4.44185957e-02f, 1.19188968e-02f, -7.09599257e-02f, 1.60211977e-02f, -1.02674559e-01f, -5.12403101e-02f,
  6.44637421e-02f, -2.79226657e-02f, -1.40428528e-01f, 3.07757407e-02f, -2.64353268e-02f, 2.18348667e-01f, 3.73839005e-03f, -1.20199490e-02f, -1.02750078e-01f, 2.15216488e-01f,
  5.73036298e-02f, 1.30658612e-01f, -1.16582617e-01f, 2.74675004e-02f, 9.96018797e-02f, -2.42982469e-02f, 1.52290061e-01f, -2.32388638e-03f, -1.98510259e-01f, 1.46321245e-02f,
  1.72979370e-01f, -1.94234103e-01f, -6.16810247e-02f, 1.14423379e-01f, 4.40741815e-02f, -8.67793262e-02f, 2.30817705e-01f, -6.53226152e-02f, 1.07443221e-01f, -3.35624330e-02f,
  1.54927447e-02f, -3.63368839e-02f, 6.46719933e-02f, -5.34331910e-02f, 2.38152016e-02f, -1.05644297e-02f, 1.00044608e-02f, -1.49878440e-02f, -7.15921223e-02f, -8.36821645e-02f,
  -1.80150926e-01f, -8.16848204e-02f, -8.05082321e-02f, 5.09665981e-02f, 7.19874650e-02f, -4.74399561e-03f, 2.38810647e-02f, 1.19173102e-01f, -5.28090410e-02f, -1.76198542e-01f,
  3.77469733e-02f, -3.25143263e-02f, 2.33833250e-02f, 2.44586449e-02f, 2.22085431e-01f, 1.71957329e-01f, 5.25047556e-02f, -7.38472268e-02f, -1.56641454e-02f, -8.35831463e-03f,
  -7.16983527e-02f, -9.55155194e-02f, -2.63021309e-02f, 7.40008652e-02f, 2.21643094e-02f, -7.66101032e-02f, -2.46522166e-02f, -5.59476539e-02f, 1.40107647e-02f, -3.56775969e-02f,
  6.91165449e-03f, 1.06318481e-01f, -2.97989435e-02f, 1.19419396e-02f, 1.76125411e-02f, 5.50505258e-02f, 2.45321505e-02f, -2.00372543e-02f, -5.38845472e-02f, 4.10427526e-02f,
  1.54406920e-01f, -1.24176137e-01f, -3.42992544e-02f, 2.96177268e-01f, -9.76230800e-02f, -8.51264596e-02f, 1.04524665e-01f, 1.39529765e-01f, -1.89486109e-02f, 1.43279135e-01f,
  -2.92047113e-01f, -4.57749553e-02f, -1.65344015e-01f, -3.38438191e-02f, 4.60166484e-02f, -1.21850193e-01f, 7.74884745e-02f, -1.70881733e-01f, -7.47114792e-02f, -4.20757197e-02f,
  -2.70330478e-02f, 7.41785243e-02f, 8.74871537e-02f, -1.23489864e-01f, -7.41973817e-02f, 1.39493182e-01f, -2.26536617e-02f, -6.77770190e-03f, -1.76488504e-01f, -2.56542079e-02f,
  2.26141326e-02f, -9.40091384e-04f, 1.20083287e-01f, -2.32772958e-02f, -9.63219926e-02f, -1.87356859e-01f, -1.07087955e-01f, -5.70010133e-02f, -1.00597337e-01f, 6.06069453e-02f,
  -8.28689560e-02f, -3.52597795e-02f, -7.65386000e-02f, -9.64953378e-02f, 9.59960744e-02f, 1.54015958e-01f, -1.59268662e-01f, -2.21111961e-02f, 5.02495840e-02f, 1.02888949e-01f,
  -3.82774416e-03f, 9.79031697e-02f, 1.83780864e-01f, 2.23249450e-01f, -7.46225715e-02f, -4.23957035e-03f, -1.63221210e-01f, 1.15513884e-01f, 1.45654604e-02f, 2.92432588e-02f,
  -1.46332309e-01f, -2.23146558e-01f, 1.70441821e-01f, 3.12368721e-01f, -2.20415652e-01f, -5.48938066e-02f, -1.64879978e-01f, 3.55365463e-02f, -2.16183186e-01f, -9.64443237e-02f,
  -9.18458179e-02f, -2.62976787e-03f, 2.17271313e-01f, -3.08758557e-01f, 1.73371077e-01f, -1.14792027e-01f, -9.75025669e-02f, -8.67313743e-02f, 5.70185743e-02f, 1.42533546e-02f,
  8.40671062e-02f, 1.32744178e-01f, 1.20076753e-01f, 2.01568510e-02f, 3.76765616e-02f, 6.29794435e-04f, 5.19615319e-03f, 1.02267921e-01f, -1.68394111e-02f, -6.47067875e-02f,
  -5.57179302e-02f, -3.53590585e-02f, 4.72549610e-02f, -9.78577808e-02f, 5.84884249e-02f, 8.69224721e-04f, 9.68552679e-02f, 5.50044642e-04f, -4.67850827e-02f, 6.19750209e-02f,
  -8.46400559e-02f, -5.45310676e-02f, -9.22515169e-02f, -1.00089144e-02f, -3.54757644e-02f, 5.40640801e-02f, 1.42478896e-02f, 4.07274216e-02f, 7.52703920e-02f, -8.10683742e-02f,
  -7.86080360e-02f, -1.90175828e-02f, -9.11770016e-02f, -7.67288357e-02f, 3.17231491e-02f, -8.48952234e-02f, 8.57023150e-02f, -5.55265658e-02f, -1.06173813e-01f, 4.33579274e-02f,
  5.92120970e-03f, 6.82844594e-02f, 2.06936002e-02f, -1.05024539e-01f, 6.41395897e-02f, 7.77717903e-02f, 1.26096472e-01f, 6.18715771e-04f, -5.65200113e-02f, 1.12997584e-01f,
  -5.38981482e-02f, -5.62186874e-02f, -1.81387216e-02f, 3.08749992e-02f, -1.37717128e-01f, -1.53346499e-02f, -1.67172059e-01f, -1.25246197e-01f, 8.68290141e-02f, 1.94270477e-01f,
  -4.60110530e-02f, -1.75905004e-01f, 4.58787642e-02f, 1.79148227e-01f, -1.90222293e-01f, 1.25556126e-01f, 1.92504779e-01f, 1.65599689e-01f, 9.32206362e-02f, -6.52552471e-02f,
  -9.46170613e-02f, 1.07381299e-01f, -4.39353995e-02f, -1.81941409e-02f, 5.85573800e-02f, 1.41100839e-01f, 1.08780675e-01f, 1.20067447e-01f, -1.39894217e-01f, 8.09192210e-02f,
  4.12259102e-02f, 1.44053940e-02f, 1.30791962e-01f, 3.63935158e-02f, 4.74638604e-02f, 1.47187203e-01f, 1.67864725e-01f, 4.29733768e-02f, -1.38182610e-01f, 7.09667010e-03f,
  3.02407332e-02f, -7.52989901e-03f, -5.14397845e-02f, -8.13895240e-02f, 1.37205184e-01f, -7.62747973e-02f, -1.73297465e-01f, 1.66535052e-03f, 1.42148137e-01f, -5.32668121e-02f,
  -5.78404330e-02f, -1.03752531e-01f, 1.01588815e-01f, -1.33355752e-01f, -1.87610343e-01f, 4.81613912e-02f, -5.33724315e-02f, 1.70644805e-01f, -7.13394210e-02f, 1.70404345e-01f,
  -8.11847597e-02f, -2.48987243e-01f, 2.31382355e-01f, 5.14604412e-02f, 6.09347448e-02f, -1.83230285e-02f, 8.46424103e-02f, 1.07592300e-01f, -6.36904780e-03f, -1.02485225e-01f,
  -1.64400667e-01f, 2.47077405e-01f, -1.96365684e-01f, 4.55219336e-02f, -3.66803515e-03f, 2.69296411e-02f, 1.24629131e-02f, -8.34721103e-02f, -8.03828984e-02f, 7.67354816e-02f,
  5.33319116e-02f, -9.63868126e-02f, -6.07241765e-02f, 2.13787165e-02f, -6.65523717e-03f, -7.59739103e-03f, 2.46669482e-02f, -4.34561446e-02f, -1.40116259e-01f, -3.94107737e-02f,
  -9.79468152e-02f, -1.98307231e-01f, -2.34621745e-02f, -1.21722750e-01f, 4.78576832e-02f, -1.21596962e-01f, -1.40230760e-01f, -1.01611376e-01f, -6.44587055e-02f, 1.47275865e-01f,
  -5.29096089e-02f, 8.21028799e-02f, -7.31388181e-02f, -1.77195016e-02f, -4.28105928e-02f, 3.53502892e-02f, -1.17967864e-02f, 3.12556550e-02f, -3.73978503e-02f, -5.01632169e-02f,
  6.77634925e-02f, 1.26351207e-01f, 5.43756336e-02f, 1.51806623e-02f, -2.59718448e-02f, 4.94320132e-02f, -5.33429869e-02f, -8.35109036e-03f, -5.79251815e-03f, -3.94078493e-02f,
  -3.34968301e-03f, -2.01982051e-01f, 1.02286704e-01f, -1.05887100e-01f, -3.84170599e-02f, 7.88490325e-02f, -5.21233045e-02f, 2.13304222e-01f, -5.37514733e-03f, 8.13684762e-02f,
  -8.73524770e-02f, 1.55664518e-01f, -2.63088524e-01f, -7.75814941e-03f, -1.61804944e-01f, 2.02651098e-01f, -6.48492947e-02f, -1.21069074e-01f, 8.85294601e-02f, 9.77877080e-02f,
  -1.16778994e-02f, -1.06363147e-01f, 7.52426758e-02f, 1.80616751e-01f, 9.29010287e-02f, -2.44896091e-03f, -1.11181088e-01f, 1.05953760e-01f, -1.51729658e-01f, 4.54073399e-03f,
  -4.08124216e-02f, 1.40416771e-01f, -2.82223344e-01f, -2.31710508e-01f, -5.10214828e-02f, -1.14711076e-01f, -6.57217950e-02f, 4.04330418e-02f, 1.04319185e-01f, -4.94395196e-02f,
  8.09720717e-03f, 1.88735560e-01f, -1.45366997e-01f, -1.45363044e-02f, 1.49461642e-01f, 7.49240890e-02f, -2.97361929e-02f, -2.26740912e-02f, -7.37561211e-02f, 1.98661968e-01f,
  -1.78815365e-01f, -1.58096999e-02f, -1.27080185e-02f, -8.59849676e-02f, 3.50868766e-04f, 1.47399828e-01f, -5.88999763e-02f, -6.55745864e-02f, 2.92853743e-01f, -5.31208664e-02f,
  -1.01436168e-01f, -2.32150294e-02f, 4.51779664e-02f, -1.11302927e-01f, 2.61120766e-01f, 1.80982068e-01f, -4.53561582e-02f, 5.84635623e-02f, -2.82631547e-04f, 8.00000727e-02f,
  1.07710302e-01f, 1.10304087e-01f, 1.46391079e-01f, -2.04971343e-01f, 9.10984203e-02f, -2.69825488e-01f, -4.30956446e-02f, 2.64194310e-02f, 2.63140500e-01f, -1.17807902e-01f,
  2.99924076e-01f, 1.75313950e-01f, 1.05414584e-01f, 7.36010000e-02f, 6.64212480e-02f, -1.03024021e-02f, 6.01187684e-02f, 1.70847669e-01f, 1.26978625e-02f, 1.11751743e-02f,
  1.08026624e-01f, 8.03420972e-03f, -3.72590274e-02f, -2.85506807e-02f, -4.85150702e-02f, 1.84809685e-01f, -2.31475709e-03f, -3.33750201e-03f, 1.98342418e-03f, -2.36486625e-02f,
  -1.91745721e-02f, 1.71983838e-02f, 1.84183326e-02f, 9.17828362e-03f, -5.18387407e-02f, -3.76510248e-02f, -5.51486313e-02f, -7.33456612e-02f, 3.46706584e-02f, 4.18447480e-02f,
  2.04841544e-05f, -6.97786286e-02f, 9.84557196e-02f, -1.02132298e-01f, 6.77003413e-02f, -4.19083349e-02f, 8.01908448e-02f, 4.01741415e-02f, -6.20192029e-02f, -1.20723240e-01f,
  4.26238822e-03f, 1.50094191e-02f, 9.34808627e-02f, -7.12076128e-02f, -8.44627470e-02f, 8.81853048e-03f, -7.02526942e-02f, 4.54076454e-02f, -5.93601074e-03f, -1.40300110e-01f,
  6.46774545e-02f, -3.11224721e-02f, -6.11709058e-02f, -6.34367689e-02f, 7.81610534e-02f, -8.00419226e-02f, 6.83488548e-02f, -2.39219666e-02f, -4.13542725e-02f, -1.10529745e-02f,
  -7.54946545e-02f, 1.09651752e-01f, 9.04863700e-02f, 1.21646427e-01f, -1.14944346e-01f, 2.33206108e-01f, 3.49240899e-02f, 2.67927926e-02f, 6.63551092e-02f, -1.47370920e-01f,
  1.07131489e-01f, -1.31537184e-01f, 1.58306845e-02f, -2.40855813e-02f, -7.91694149e-02f, -1.29618067e-02f, -8.84045474e-03f, -1.60343274e-02f, 3.14007327e-02f, 3.64665911e-02f,
  8.35025590e-03f, -4.82470579e-02f, 2.40259111e-01f, -8.53192881e-02f, -5.59698083e-02f, -1.06460571e-01f, 2.38381013e-01f, 3.65819782e-02f, -9.32837054e-02f, 1.97664369e-02f,
  -1.66576147e-01f, -1.44996092e-01f, 1.17639832e-01f, 6.92987517e-02f, 7.49270618e-02f, 8.89368542e-03f, 2.10772343e-02f, -4.48270701e-03f, 4.02435884e-02f, 7.43243918e-02f,
  -5.91354854e-02f, 2.73474213e-02f, 9.03342501e-04f, 7.88550824e-02f, 5.44858677e-03f, -1.66066051e-01f, 3.98428351e-01f, -1.60645768e-01f, 2.71271300e-02f, 8.00227895e-02f,
  1.10595450e-01f, -3.80437791e-01f, -2.14338116e-02f, 4.49092723e-02f, -1.01506896e-01f, 2.32735083e-01f, 1.42652139e-01f, 1.20222978e-01f, 8.85664895e-02f, -2.85821795e-01f,
  4.40377295e-02f, 4.31184657e-02f, 3.93718202e-03f, -1.12338196e-02f, -1.35324085e-02f, -8.70489627e-02f, -3.77677917e-03f, -6.42254129e-02f, -2.39547968e-01f, 2.10924353e-02f,
  -1.15215033e-01f, 7.22535104e-02f, -6.65096641e-02f, -3.93454581e-02f, -9.41458195e-02f, -7.31479377e-02f, -4.50914428e-02f, 1.99160084e-01f, -6.96291104e-02f, -5.43907359e-02f,
  -3.34566459e-02f, -1.51499107e-01f, 1.18249580e-01f, -1.56605560e-02f, 1.48798572e-02f, 6.09539151e-02f, -4.66670431e-02f, 2.82043498e-03f, -1.14723053e-02f, 8.66611227e-02f,
  -6.42758682e-02f, 9.15947091e-03f, 1.05844162e-01f, 5.42254001e-03f, -3.66172604e-02f, -5.67180067e-02f, 1.11006267e-01f, 6.98359609e-02f, -2.93789096e-02f, -1.68486089e-01f,
  -1.51096985e-01f, 1.75550557e-03f, 7.06517845e-02f, 4.47920151e-02f, -3.64267230e-02f, 1.05760716e-01f, 1.57785282e-01f, 2.07184069e-02f, 6.93883300e-02f, -4.57874909e-02f,
  1.98690221e-02f, 1.00517653e-01f, 2.08527967e-02f, -4.58120294e-02f, -6.03117631e-04f, -1.66659933e-02f, 1.03804268e-01f, 1.72475606e-01f, -1.39332199e-02f, -8.09271261e-02f,
  1.24521457e-01f, 1.31705642e-01f, 9.61143896e-02f, 3.79158999e-03f, -3.81117384e-03f, 3.43348235e-02f, -2.58337148e-02f, 1.41370371e-01f, -2.41114914e-01f, 7.90837631e-02f,
  1.01955645e-02f, 5.55531401e-03f, -1.24967903e-01f, -6.08060621e-02f, -1.25946021e-02f, 1.50317580e-01f, 1.93952192e-02f, -4.78856936e-02f, 1.84699416e-03f, -6.94641918e-02f,
  1.72294363e-01f, -1.75286159e-01f, 1.32060990e-01f, 4.04043533e-02f, 2.68196594e-02f, -6.35027140e-02f, -1.25545084e-01f, 7.35118706e-03f, -1.67483822e-01f, -7.02076852e-02f,
  -4.28804755e-02f, -9.95096415e-02f, 1.10067710e-01f, 3.44207212e-02f, -1.60607100e-01f, 5.25709316e-02f, -4.25961912e-02f, -9.02959481e-02f, -8.09116289e-02f, 8.78518373e-02f,
  -2.21746117e-01f, 9.64341462e-02f, -6.77353069e-02f, -9.13020596e-02f, -1.81561515e-01f, 1.23802610e-01f, 1.29740639e-02f, 9.21919718e-02f, 1.97775066e-01f, -5.36823161e-02f,
  2.40956381e-01f, 7.54178166e-02f, -1.89360350e-01f, 1.70630291e-01f, -2.08291411e-02f, -2.24652030e-02f, -1.40950084e-01f, -5.96726388e-02f, 1.38185158e-01f, -8.78057778e-02f,
  -9.10334010e-03f, -7.25078806e-02f, 1.52318910e-01f, -6.25075074e-03f, -5.36926202e-02f, 1.80572063e-01f, -2.70633399e-01f, 1.52333945e-01f, 1.18896790e-01f, -8.30565169e-02f,
  -1.87251121e-01f, 1.24198608e-01f, -1.31454557e-01f, 2.36792937e-02f, 2.99178690e-01f, -6.61948398e-02f, -8.16077963e-02f, 4.33239453e-02f, -1.66138947e-01f, -2.29888689e-03f,
  1.05937004e-01f, 6.45446479e-02f, -7.27280080e-02f, -1.76498890e-02f, 1.75326429e-02f, 1.02454480e-02f, 7.37892538e-02f, -4.37259451e-02f, -3.49261947e-02f, -1.00924913e-02f,
  -1.28580481e-01f, 2.88312547e-02f, -1.88513175e-01f, 6.86399937e-02f, 2.41227038e-02f, -1.29646629e-01f, 5.54760471e-02f, -1.16093040e-01f, -4.56028469e-02f, 1.13852888e-01f,
  -1.25765592e-01f, -2.26785745e-02f, 2.08141934e-02f, 3.38539258e-02f, 1.30930677e-01f, 9.68679488e-02f, 2.42703836e-02f, 1.83341160e-01f, 4.58361357e-02f, -1.08390242e-01f,
  6.86628371e-02f, -4.90104547e-03f, 6.47944734e-02f, -1.02366388e-01f, 1.15827329e-01f, 9.22403857e-02f, -1.11164913e-01f, -1.95988156e-02f, -3.88686769e-02f, -8.29161927e-02f,
  -5.21101616e-02f, -2.38820165e-02f, -6.37482926e-02f, -4.13596928e-02f, -3.71708497e-02f, -7.27121811e-03f, -9.92070287e-02f, -1.55345559e-01f, -3.60029117e-05f, -1.99398533e-01f,
  -8.21034461e-02f, 1.11090012e-01f, -1.58382222e-01f, -2.44991593e-02f, 7.53581226e-02f, 1.98674992e-01f, 1.33175865e-01f, 7.17284307e-02f, -8.73156488e-02f, 3.55903171e-02f,
  -1.40945008e-02f, -2.03545783e-02f, 1.22385800e-01f, -2.97305174e-02f, 2.05826648e-02f, 1.25150785e-01f, 1.78060353e-01f, -2.54907012e-02f, -6.51518703e-02f, 7.41768032e-02f,
  -1.21387532e-02f, -5.75610287e-02f, -9.14365351e-02f, 5.71328849e-02f, 3.00353728e-02f, 1.15223259e-01f, 3.49536240e-02f, 9.52223241e-02f, 9.72401723e-02f, -1.27926230e-01f,
  1.22738637e-01f, -1.11968666e-01f, 2.19233811e-01f, -6.09867163e-02f, -1.11278817e-01f, -1.59340519e-02f, 1.38231635e-01f, -8.81740917e-03f, -6.46698996e-02f, 1.05834492e-01f,
  1.31629333e-01f, 7.78911039e-02f, -3.09716742e-02f, 1.54194981e-01f, -9.82733890e-02f, 4.57496569e-02f, -2.35357098e-02f, 5.88466600e-02f, -1.12356275e-01f, 7.52527043e-02f,
  5.67893162e-02f, 7.27003217e-02f, -2.82678366e-01f, 5.25191091e-02f, -6.80739805e-02f, -5.42991795e-02f, 5.27252369e-02f, -1.09669209e-01f, -4.95016798e-02f, -4.58712466e-02f,
  1.07042035e-02f, -1.49469646e-02f, 1.75083786e-01f, 9.23318192e-02f, 7.06653446e-02f, 7.90590513e-03f, 1.79019019e-01f, 2.23060790e-02f, 6.07247315e-02f, -6.74134567e-02f,
  1.30924089e-02f, -2.35687703e-01f, -1.01572171e-01f, -1.98136866e-01f, 2.37804875e-01f, -1.50143221e-01f, -1.21357381e-01f, 6.84861094e-02f, -6.11467138e-02f, 1.84930526e-02f,
  -2.28848785e-01f, 1.02003537e-01f, -2.12775450e-02f, 8.52702856e-02f, 5.51808588e-02f, 9.47023034e-02f, -5.32420650e-02f, -1.42179400e-01f, -1.21324444e-02f, 4.17762399e-02f,
  -3.89827713e-02f, 4.65334505e-02f, -5.29129952e-02f, 6.87384233e-02f, -1.92923229e-02f, 3.38996798e-02f, -3.65796909e-02f, -7.19169900e-02f, -1.38488784e-01f, 4.34408747e-02f,
  -7.43805710e-03f, -4.86242166e-03f, 7.55017018e-03f, -1.05023019e-01f, -6.37035295e-02f, -5.25979362e-02f, 7.32948482e-02f, 1.91819146e-02f, -2.66516604e-03f, 2.34417641e-03f,
  2.42334548e-02f, -7.38292560e-02f, 9.13296938e-02f, 6.28200825e-03f, 9.62654576e-02f, 2.94331163e-02f, 1.10255396e-02f, 1.05196446e-01f, -7.69781098e-02f, -4.16965745e-02f,
  -8.95852074e-02f, -4.41212356e-02f, 1.01957005e-02f, -2.49125878e-03f, 5.96644618e-02f, 6.12807795e-02f, -7.56432563e-02f, 4.36306782e-02f, 9.06226337e-02f, 1.06977396e-01f,
  -7.29106367e-02f, 2.75973678e-01f, 1.14259161e-01f, 7.29126334e-02f, -1.58851743e-02f, 1.01189129e-01f, 7.08357152e-03f, 2.53197141e-02f, -1.47584826e-01f, -3.18434089e-02f,
  -2.80301012e-02f, 1.05833046e-01f, -1.72436852e-02f, -1.18152872e-01f, 1.14982128e-01f, -6.81670979e-02f, 7.90650174e-02f, 1.87731944e-02f, 3.15295085e-02f, 6.96403980e-02f,
  5.80141917e-02f, -2.66026706e-02f, -1.00639157e-01f, 2.79974073e-01f, -2.43607193e-01f, 2.46907491e-02f, -9.67393517e-02f, -1.25334725e-01f, -2.77506262e-02f, 1.22166276e-02f,
  -1.91870004e-01f, -9.94364172e-02f, -5.93824871e-03f, -7.32416809e-02f, -1.70977548e-01f, 1.05183378e-01f, -5.27541302e-02f, 3.58869955e-02f, -1.19505741e-01f, -3.26969400e-02f,
  -1.63463563e-01f, 7.07046613e-02f, -1.35387689e-01f, 7.95676839e-03f, -9.22762901e-02f, -9.16257873e-02f, 1.26180227e-03f, 1.85871907e-02f, -6.49597868e-02f, 7.23747015e-02f,
  -4.94761541e-02f, -4.77460586e-02f, -2.61693984e-01f, -7.19515681e-02f, -5.79064935e-02f, 2.14754581e-01f, -1.27689585e-01f, -7.67560080e-02f, -4.46538553e-02f, -1.15487576e-01f,
  -1.61084644e-02f, 2.74091095e-01f, -1.51884720e-01f, -6.50373250e-02f, 9.94765759e-02f, -9.28808898e-02f, -9.60181355e-02f, -1.40129238e-01f, -1.49190649e-01f, 1.07404709e-01f,
  3.79710525e-01f, 2.79773436e-02f, -2.35450659e-02f, 4.59391996e-02f, 3.92832011e-02f, -1.70982070e-02f, 3.81813943e-02f, 6.55446947e-02f, -4.39264365e-02f, -3.68656814e-02f,
  1.68587565e-01f, -1.44202337e-01f, 3.50692756e-02f, 3.57576907e-02f, 7.07684085e-02f, -7.10615888e-02f, -2.09617633e-02f, 6.88061467e-04f, 2.63096206e-02f, -4.60695066e-02f,
  7.64025524e-02f, -2.88709756e-02f, -6.49157614e-02f, -9.00835842e-02f, 7.18060061e-02f, -9.96651351e-02f, -2.64927913e-02f, 3.69688030e-03f, 7.03061887e-05f, 7.16965869e-02f,
  -9.33565423e-02f, 1.06863499e-01f, 9.83444080e-02f, 2.32430920e-02f, 9.34148058e-02f, 4.28488888e-02f, -2.81791277e-02f, -7.22715557e-02f, -1.12856114e-02f, 3.18595544e-02f,
  1.46554774e-02f, 3.55385877e-02f, -1.00361317e-01f, 5.82296541e-03f, 2.42828485e-03f, 1.68780815e-02f, 3.17709856e-02f, 1.82459168e-02f, -6.29118457e-02f, -4.57025878e-02f,
  1.36636674e-01f, 5.30995487e-04f, 3.10744848e-02f, 4.20915484e-02f, 8.00511241e-02f, -1.94646809e-02f, -1.12086132e-01f, -6.19333312e-02f, 1.17382087e-01f, 3.09267826e-02f,
  -1.64192412e-02f, -7.98327476e-03f, -8.25812519e-02f, -1.16035640e-01f, -5.53577095e-02f, -5.58236949e-02f, 7.42501020e-02f, 9.72890779e-02f, 7.87133351e-02f, -5.80296889e-02f,
  -4.22089845e-02f, 5.84978098e-03f, 1.74890220e-01f, 7.59228766e-02f, 9.59340781e-02f, -1.78590208e-01f, 2.90490575e-02f, -1.21749910e-02f, -1.46478772e-01f, 1.29733130e-01f,
  5.12373522e-02f, 7.04740435e-02f, 5.12079149e-02f, -1.23694479e-01f, -2.20866874e-01f, 2.45124232e-02f, 5.63373677e-02f, 1.72357187e-01f, 4.95194122e-02f, -2.51452141e-02f,
  7.39018321e-02f, 7.80347884e-02f, 1.43875435e-01f, -8.62341300e-02f, -1.41378582e-01f, 1.40555665e-01f, -1.42464265e-01f, 2.49078330e-02f, -7.09701851e-02f, -3.57331894e-02f,
  8.32946002e-02f, -6.13662004e-02f, 2.26699784e-01f, 1.00615872e-02f, -1.65361643e-01f, -1.59594161e-03f, -1.11352302e-01f, 1.29656680e-02f, -1.43749580e-01f, 7.98746124e-02f,
  9.89287794e-02f, 2.12483183e-02f, 4.10902575e-02f, 1.17345937e-01f, 6.46317378e-02f, 2.97399163e-01f, -6.10565059e-02f, 1.73368424e-01f, -1.62956581e-01f, -3.40435833e-01f,
  1.16852827e-01f, -2.46010825e-01f, -1.11842968e-01f, 1.51427031e-01f, 1.08951427e-01f, 6.87666610e-02f, 1.43754557e-01f, 4.26162481e-02f, -1.92384198e-01f, -1.73559263e-01f,
  7.73571879e-02f, 1.05235726e-01f, 1.33887425e-01f, 2.08530910e-02f, 2.15878412e-01f, 4.78068367e-02f, -6.17559738e-02f, 5.00988327e-02f, 6.03805622e-03f, -1.69222448e-02f,
  -1.46207005e-01f, 8.73314515e-02f, 4.67371494e-02f, 5.22872768e-02f, 5.47537468e-02f, -5.63917346e-02f, 9.29810628e-02f, -1.90703347e-02f, 4.82754083e-03f, -1.10860504e-01f,
  3.37926000e-02f, -3.79617475e-02f, 9.30624232e-02f, -4.88612391e-02f, 2.77138930e-02f, 5.29545806e-02f, -1.17545165e-01f, 9.31051597e-02f, 8.64562765e-03f, 2.94012669e-02f,
  1.28395811e-01f, -9.89873707e-02f, 1.54502675e-01f, -1.27273619e-01f, 4.33698855e-02f, 7.44980797e-02f, 1.10921524e-02f, 1.10649981e-01f, -6.55591190e-02f, -1.51607376e-02f,
  2.25551035e-02f, 8.13206192e-03f, 6.67981505e-02f, 8.92310664e-02f, -2.50816476e-02f, 7.52464309e-02f, -8.21658969e-03f, -4.25753444e-02f, -2.52728164e-02f, 2.35208999e-02f,
  1.09716073e-01f, -3.80267687e-02f, 1.79443315e-01f, -8.11738223e-02f, -1.05536073e-01f, 6.27636760e-02f, -8.89293924e-02f, -2.04206795e-01f, 3.91490348e-02f, 7.36234561e-02f,
  -1.10346720e-01f, 8.00539404e-02f, -2.63022538e-02f, 1.16653023e-02f, 1.21947005e-02f, -3.10573773e-03f, -1.36485338e-01f, 8.28870088e-02f, 1.58953816e-02f, -6.66358992e-02f,
  -1.66308910e-01f, 2.41026565e-01f, 1.59726426e-01f, 1.65136769e-01f, -1.23008959e-01f, -2.02495754e-01f, -1.58268109e-01f, 6.01560511e-02f, -1.07634835e-01f, -7.85614625e-02f,
  -5.03902249e-02f, 3.27257067e-03f, 5.96117079e-02f, 1.12559929e-01f, -1.22289248e-01f, 2.28959415e-02f, 6.67252466e-02f, 6.78855106e-02f, 3.57124731e-02f, 2.44187519e-01f,
  1.24350481e-01f, 1.85819566e-01f, 2.46058907e-02f, 9.77215320e-02f, -1.40426699e-02f, -6.43944591e-02f, -8.99953917e-02f, 1.73537105e-01f, -1.40330359e-01f, 1.77796949e-02f,
  1.53857902e-01f, -8.29090178e-02f, -3.75945233e-02f, -1.98369827e-02f, -7.67425597e-02f, 3.87627147e-02f, 5.39694279e-02f, -1.47296757e-01f, -6.18105493e-02f, -1.04724064e-01f,
  -4.48759235e-02f, 1.22408465e-01f, 2.12356538e-01f, 7.97426924e-02f, 9.26378071e-02f, 2.64868736e-02f, -2.40431800e-01f, -1.94208518e-01f, 1.80145949e-01f, 7.59154558e-02f,
  -1.06689684e-01f, 2.29184665e-02f, 1.29335016e-01f, -7.03656152e-02f, 1.21636884e-02f, -6.55309781e-02f, -1.18048728e-01f, 1.81448624e-01f, -9.96950492e-02f, 6.20396920e-02f,
  9.93677601e-02f, -1.25158906e-01f, -8.02120194e-02f, -1.29191075e-02f, -1.48693472e-02f, 4.52131312e-03f, -6.54441565e-02f, 2.73410138e-02f, 1.59076955e-02f, 7.40105212e-02f,
  1.05434647e-02f, -9.37449262e-02f, 5.87460883e-02f, -5.01870438e-02f, -4.39291336e-02f, -1.19495932e-02f, -4.97943908e-02f, 8.83382000e-03f, -8.17152262e-02f, 1.09988168e-01f,
  7.14534952e-04f, -1.19649291e-01f, -1.27608515e-02f, -1.49360718e-02f, 3.26593965e-02f, 3.19855027e-02f, -1.10469423e-01f, 9.14242268e-02f, -4.72989716e-02f, 4.40344661e-02f,
  2.86959019e-02f, -3.70296948e-02f, 5.29128425e-02f, -2.29108892e-02f, -7.40676150e-02f, 2.47491468e-02f, -4.21337932e-02f, -1.96939446e-02f, 1.16710871e-01f, 6.75229952e-02f,
  4.96345945e-02f, -3.56955454e-02f, -4.85146381e-02f, 5.12794778e-02f, -5.59785664e-02f, 2.87177563e-02f, -1.11286975e-02f, 5.01624169e-03f, -2.54298579e-02f, -2.07544211e-02f,
  3.46228890e-02f, -5.34182265e-02f, -1.23701662e-01f, 1.08541939e-02f, 1.21840961e-01f, -4.08159941e-03f, -7.38469809e-02f, 3.41622323e-01f, -6.44531101e-02f, 4.65505496e-02f,
  8.25607255e-02f, 5.45911454e-02f, -8.37773308e-02f, -7.91383460e-02f, -1.73666701e-01f, 4.80254628e-02f, 1.15391418e-01f, 3.34378853e-02f, 1.13841554e-03f, 7.97261670e-02f,
  5.68536781e-02f, -1.00400098e-01f, -9.10534710e-02f, 1.28148600e-01f, -1.71179995e-02f, -1.21754445e-02f, -3.30638029e-02f, -3.47373076e-02f, -4.76506799e-02f, -1.26140282e-01f,
  -4.30705361e-02f, -8.59738290e-02f, 1.50360137e-01f, 1.38807911e-02f, -4.84659709e-02f, -1.29209548e-01f, 7.05100968e-02f, 9.41854492e-02f, -1.35483623e-01f, 3.11198439e-02f,
  7.98509791e-02f, 1.39090449e-01f, -1.65276006e-02f, -9.85603780e-02f, 1.06422201e-01f, 1.39723778e-01f, -1.10725082e-01f, 1.08890735e-01f, 1.46938208e-02f, -2.82109492e-02f,
  -1.62144806e-02f, 2.31437221e-01f, -4.92287911e-02f, -1.04854323e-01f, 2.48996466e-01f, -3.30541521e-01f, -2.46428885e-02f, 4.83599305e-02f, 1.31722137e-01f, -1.37270674e-01f,
  -2.44681001e-01f, -1.44847348e-01f, 5.87899610e-02f, 2.38506496e-01f, -2.08828365e-03f, 1.39400318e-01f, -8.76957476e-02f, -1.74598210e-02f, 2.42238656e-01f, -2.13686787e-02f,
  -7.22855479e-02f, 3.00186127e-01f, -7.21795484e-02f, 3.20218831e-01f, 1.12140737e-01f, 1.68641359e-01f, -2.33397320e-01f, 1.52946651e-01f, -1.07405663e-01f, 5.61694652e-02f,
  2.45141201e-02f, 3.19810808e-02f, 6.14761114e-02f, -1.05953820e-01f, 4.78934646e-02f, 7.74777532e-02f, 7.13735148e-02f, -5.38331270e-02f, 1.40824094e-01f, -4.69663851e-02f,
  -1.49597168e-01f, -2.13065855e-02f, -2.71074325e-02f, -2.94694547e-02f, -1.88563205e-02f, 7.73157626e-02f, -2.67951824e-02f, 1.04358224e-02f, 7.90266842e-02f, -4.63536456e-02f,
  5.56476740e-03f, -7.94257820e-02f, 3.61132696e-02f, 1.47428736e-01f, 1.26038909e-01f, 9.45707858e-02f, 2.17410535e-01f, 3.34366970e-02f, -9.52684134e-02f, -9.58768837e-03f,
  4.17409576e-02f, 1.05584539e-01f, 4.09879275e-02f, -9.71182436e-03f, 5.23826182e-02f, 4.56021726e-02f, -8.76132920e-02f, -1.61813587e-01f, 2.13022500e-01f, 9.11495984e-02f,
  -5.38484147e-03f, 2.87619084e-02f, -6.96936771e-02f, -6.29676282e-02f, -1.21288568e-01f, 8.89656320e-03f, 2.33848058e-02f, 8.62334594e-02f, 1.23097301e-01f, 5.62958568e-02f,
  3.85862105e-02f, -1.84981152e-02f, -5.11711724e-02f, 1.31788298e-01f, -9.30803567e-02f, 1.29919380e-01f, -2.32365299e-02f, 3.93070141e-03f, -9.30526480e-02f, 1.83517620e-01f,
  -1.12298824e-01f, 3.13813202e-02f, -1.11172304e-01f, 1.06422685e-01f, 1.03037812e-01f, -8.02596956e-02f, 3.99067923e-02f, 4.13333159e-03f, -1.05338559e-01f, -1.95741858e-02f,
  -4.56224233e-02f, 1.59247652e-01f, -2.48977039e-02f, -3.33658159e-02f, 9.35310125e-02f, 5.39123341e-02f, 4.20936905e-02f, -4.97237742e-02f, 8.62306058e-02f, -2.07701877e-01f,
  4.66037020e-02f, -1.56955332e-01f, 2.45874226e-01f, 6.32364769e-03f, -6.47698855e-03f, 2.99871154e-02f, -1.28003448e-01f, -8.89451951e-02f, 1.71344995e-01f, 3.04080307e-01f,
  1.04472227e-01f, 3.03359013e-02f, -5.57128079e-02f, 4.24879715e-02f, -1.46333361e-02f, 2.16212973e-01f, -5.26389405e-02f, 1.36909276e-01f, 5.95432743e-02f, 1.54034570e-01f,
  -5.02206869e-02f, 3.75639647e-02f, -3.48216742e-02f, -8.40563234e-03f, 5.44852428e-02f, -9.85393859e-03f, 3.97971049e-02f, -4.46181037e-02f, -9.34094563e-02f, -5.53388037e-02f,
  -1.88259542e-01f, -6.39865696e-02f, 2.99408555e-01f, 2.08520994e-01f, 5.04318215e-02f, -6.56410903e-02f, -1.20300651e-01f, -4.79393192e-02f, -1.89085513e-01f, 7.04818126e-03f,
  6.09500036e-02f, -2.89682806e-01f, 6.70269802e-02f, -5.99729568e-02f, 1.73057169e-01f, -2.42100462e-01f, -1.25957444e-01f, -5.57470471e-02f
};

// L1_fan_Wp_bar (Shape: 26 x 128)
const int L1_fan_Wp_bar_rows = 26;
const int L1_fan_Wp_bar_cols = 128;
const float L1_fan_Wp_bar_data[] = {
  1.51542872e-01f, 1.45876065e-01f, 4.16908935e-02f, 5.08550927e-02f, 1.53035074e-01f, -9.66418013e-02f, -7.85579681e-02f, 1.44379541e-01f, 5.73372431e-02f, 7.86046833e-02f,
  3.24543901e-02f, 1.06703252e-01f, 2.64517516e-01f, 1.81770343e-02f, 9.14240405e-02f, 1.99693352e-01f, -1.80556171e-03f, 1.28590494e-01f, 6.26942366e-02f, 1.13627099e-01f,
  4.09573242e-02f, 6.89599738e-02f, 5.24996333e-02f, -1.10287055e-01f, 1.82111159e-01f, 2.36907646e-01f, 1.59829870e-01f, 1.28482163e-01f, 2.11896170e-02f, 2.00266540e-01f,
  6.30145445e-02f, 3.44005711e-02f, 1.10165499e-01f, -3.69950421e-02f, 8.85144323e-02f, 7.90496767e-02f, 1.27637804e-01f, 1.04806833e-01f, -4.89687035e-03f, 1.73335627e-01f,
  -4.73415628e-02f, 1.51068479e-01f, 2.52743415e-03f, 4.90051694e-02f, 2.46293340e-02f, -1.07382677e-01f, 1.32713258e-01f, 7.68565387e-02f, 8.39719325e-02f, 9.13336203e-02f,
  4.15876657e-02f, -2.66206533e-01f, 1.48496926e-01f, 2.95284480e-01f, -2.25220323e-01f, -1.45494640e-01f, 1.07208021e-01f, -2.17584625e-01f, -2.50070542e-01f, 4.84547652e-02f,
  -1.07216112e-01f, -1.03411555e-01f, 9.25968681e-03f, 8.28418285e-02f, 1.76968351e-01f, 3.35556604e-02f, 1.46340340e-01f, -7.34152347e-02f, 9.07723010e-02f, -7.26284236e-02f,
  -6.18210509e-02f, 1.31441787e-01f, -5.51982559e-02f, -9.06197578e-02f, -3.34701613e-02f, 2.13836968e-01f, -4.43008207e-02f, -4.06354346e-04f, -1.39306948e-01f, -9.19912010e-02f,
  7.53630558e-03f, 7.86879137e-02f, -2.33525597e-02f, -1.57805949e-01f, -1.25411496e-01f, -1.35456011e-01f, -1.54324388e-02f, -7.94797018e-02f, -2.16010287e-01f, 3.50223362e-01f,
  3.63832037e-03f, -3.68066668e-03f, 3.18950564e-02f, 9.21859592e-02f, 8.09641853e-02f, -1.59961201e-04f, -1.10636495e-01f, 1.29413292e-01f, 1.24962002e-01f, 9.36761871e-02f,
  9.04126093e-03f, 2.09814891e-01f, 4.31796819e-01f, 5.95038906e-02f, 7.42935240e-02f, -2.62045294e-01f, -3.18225808e-02f, 4.07373965e-01f, 6.17568970e-01f, 2.08508804e-01f,
  -1.98695943e-01f, -3.90413627e-02f, 7.08400011e-02f, -1.17459424e-01f, 2.72738487e-01f, -2.92028040e-01f, -2.18943998e-01f, 2.29581326e-01f, 3.91800016e-01f, -1.75264776e-01f,
  -2.10914370e-02f, 2.27751538e-01f, -2.53419131e-02f, -1.21450193e-01f, 3.09429556e-01f, 2.76872277e-01f, 6.53158486e-01f, 5.87449484e-02f, 1.17622934e-01f, 1.48265347e-01f,
  2.44274080e-01f, -1.25528798e-01f, 1.74129710e-01f, -1.08002557e-03f, 1.05269440e-01f, 1.42953709e-01f, 8.27626288e-02f, -4.14240621e-02f, 1.11524060e-01f, -1.27247469e-02f,
  1.77066147e-01f, -1.10238396e-01f, 6.72897324e-02f, 2.23367229e-01f, -5.13355434e-02f, -4.64278944e-02f, 2.18522444e-01f, 1.10730186e-01f, 1.42322183e-01f, -2.41943561e-02f,
  6.16456605e-02f, 3.69675234e-02f, -7.01301964e-03f, -9.44807231e-02f, 1.02448910e-01f, 1.05477050e-01f, 2.33926316e-04f, -6.84739947e-02f, 1.31787002e-01f, 1.55275077e-01f,
  1.84516788e-01f, -2.91620241e-03f, -1.31457716e-01f, 6.72146082e-02f, -7.88369309e-03f, 1.61061004e-01f, 1.68749943e-01f, 6.50440017e-03f, 1.35996174e-02f, 8.80095214e-02f,
  8.47880095e-02f, 2.39659443e-01f, -5.60779162e-02f, -6.12128228e-02f, -1.04024932e-02f, -2.07106024e-02f, 7.87594914e-02f, -3.27716172e-02f, 1.00765899e-01f, -5.95094673e-02f,
  8.14106092e-02f, -3.76724482e-01f, 4.48981412e-02f, 1.55401332e-02f, -1.78944953e-02f, 1.74991578e-01f, -1.57511830e-02f, 2.09979177e-01f, -1.76649526e-01f, 2.72951156e-01f,
  -2.49597386e-01f, 2.48753116e-01f, 1.86707422e-01f, -5.94521165e-02f, -3.23151737e-01f, -2.09943250e-01f, -8.49331766e-02f, 1.33617878e-01f, 9.38590169e-02f, 5.31953089e-02f,
  2.00486064e-01f, -7.32157379e-02f, -3.82838473e-02f, -1.38439313e-01f, 1.65850282e-01f, 3.48415822e-02f, 7.63427913e-01f, -4.14890975e-01f, -3.82630602e-02f, -2.23897576e-01f,
  4.45598699e-02f, 2.65623569e-01f, -1.89830229e-01f, 8.48122016e-02f, 1.38681039e-01f, -5.06029069e-01f, 6.38273001e-01f, 1.39199495e-01f, 2.54963875e-01f, -2.34977268e-02f,
  1.41962215e-01f, 9.96971428e-02f, -1.54816404e-01f, 2.30414450e-01f, 1.89745307e-01f, 1.29685909e-01f, 1.68747559e-01f, -5.23355603e-02f, 3.08841944e-01f, -2.60658503e-01f,
  4.35387284e-01f, -1.67909846e-01f, 3.27926166e-02f, 1.80801049e-01f, 6.49207737e-04f, -1.28770992e-01f, 4.13710743e-01f, 7.99831152e-02f, 9.57865342e-02f, 3.22178125e-01f,
  2.47988567e-01f, -3.85392696e-01f, 1.88594133e-01f, -1.67505860e-01f, -2.16370486e-02f, -3.08407068e-01f, 1.54220685e-01f, -1.00594647e-01f, -1.35993227e-01f, -4.51415069e-02f,
  -3.02072793e-01f, -1.36808828e-02f, -3.62867922e-01f, 1.42047286e-01f, -7.41938204e-02f, -2.36245871e-01f, 3.89181860e-02f, 5.11683431e-03f, 2.37977400e-01f, -3.00606247e-02f,
  5.93221225e-02f, 2.74074525e-01f, 1.36402011e-01f, 2.20772758e-01f, 3.74904610e-02f, 1.17256390e-02f, 3.56478393e-01f, 1.34608433e-01f, 4.06769291e-02f, 6.59468323e-02f,
  -3.37178782e-02f, 1.51240408e-01f, 1.75057665e-01f, 1.49088755e-01f, 3.61404091e-01f, -1.06142402e-01f, 8.92881379e-02f, 3.12701873e-02f, -3.86722535e-02f, 9.73428488e-02f,
  2.11057946e-01f, 1.67267442e-01f, 6.46937266e-02f, 1.18829221e-01f, 2.91080941e-02f, -1.03001021e-01f, 6.76153898e-02f, 2.18278170e-01f, 3.87091413e-02f, -8.76062661e-02f,
  9.38389748e-02f, 2.01197892e-01f, 1.94494843e-01f, 2.09265083e-01f, 1.51261836e-01f, 1.01633415e-01f, 1.28174797e-01f, 7.26348683e-02f, -2.87853032e-02f, 1.19626202e-01f,
  8.96166116e-02f, 1.21569388e-01f, 5.39332181e-02f, 2.09488384e-02f, 1.90745026e-01f, 2.78389841e-01f, 1.28966257e-01f, -2.46216878e-01f, 1.57830581e-01f, -2.10350946e-01f,
  -1.63516834e-01f, 1.01402819e-01f, -8.21623057e-02f, 1.07474647e-01f, 3.41018856e-01f, 2.25005537e-01f, -9.20220464e-02f, -1.05357729e-01f, -1.38075218e-01f, 2.78799105e-02f,
  -4.03095149e-02f, -1.16816118e-01f, -8.02903846e-02f, -5.13513684e-02f, -1.96243718e-01f, -1.32161275e-01f, -8.51993933e-02f, 1.54640660e-01f, 1.49858490e-01f, -2.38632604e-01f,
  -1.64777562e-01f, -9.63630304e-02f, 3.50498818e-02f, -1.46758944e-01f, -6.04830906e-02f, -1.73281565e-01f, 3.32213968e-01f, -1.01398900e-01f, -7.53685310e-02f, -4.15948406e-02f,
  7.89708868e-02f, -1.40059873e-01f, -1.59515843e-01f, 6.18005507e-02f, -1.42892795e-02f, -1.70826107e-01f, -5.27813397e-02f, 1.51608631e-01f, 1.91893309e-01f, 2.46906113e-02f,
  1.99921265e-01f, 3.55504721e-01f, -1.66885648e-02f, -1.51090361e-02f, 1.78357020e-01f, 2.25702990e-02f, -1.97236747e-01f, -2.75293052e-01f, 4.80489820e-01f, 2.52612233e-01f,
  -5.02228998e-02f, 6.22401424e-02f, 4.05913368e-02f, -5.65210357e-02f, -4.17603433e-01f, -1.18914105e-01f, 1.67715847e-01f, -1.20259188e-01f, 9.04003233e-02f, 2.25846171e-01f,
  -1.64072409e-01f, -1.28259748e-01f, 7.02654419e-04f, -1.54928327e-01f, -3.07301164e-01f, 4.67325419e-01f, -3.72174472e-01f, 6.52917149e-03f, 1.29842848e-01f, 1.12336643e-01f,
  -3.40392441e-01f, -3.29077244e-01f, -6.43855751e-01f, -2.60372341e-01f, -6.53497949e-02f, -3.94763276e-02f, 2.48512954e-01f, -2.42586546e-02f, 1.64335430e-01f, 1.83085307e-01f,
  -6.25952333e-02f, 8.48388001e-02f, -4.44372324e-03f, 1.49717972e-01f, 4.28921692e-02f, 1.51638672e-01f, -1.43341087e-02f, 1.33464023e-01f, 1.03862341e-02f, 1.43230408e-01f,
  6.62179366e-02f, 1.55181825e-01f, 8.78638476e-02f, -1.06252059e-01f, 7.71698579e-02f, 1.26604781e-01f, 4.43271175e-02f, 8.02673921e-02f, 8.29966888e-02f, -3.08658555e-02f,
  -8.14490579e-03f, 2.25400716e-01f, 8.37158505e-03f, 5.43918572e-02f, 1.25934735e-01f, 1.26970142e-01f, 8.77037272e-02f, 7.02159777e-02f, 1.72797278e-01f, 1.39851898e-01f,
  6.54357225e-02f, 1.94754377e-01f, 5.89741208e-02f, -1.16301842e-01f, -3.11813224e-02f, -7.44160414e-02f, -2.73291976e-03f, -8.76384154e-02f, 8.47834870e-02f, 1.97636727e-02f,
  5.86351454e-02f, 9.31556076e-02f, -9.09745544e-02f, 8.06490332e-02f, 2.29682177e-01f, 1.91539265e-02f, 1.12051703e-01f, -3.27325672e-01f, 5.18090650e-02f, -2.80264169e-01f,
  1.70748487e-01f, 2.08759889e-01f, 3.27841230e-02f, -5.19703999e-02f, 2.48729154e-01f, -3.52496877e-02f, -1.53962955e-01f, -1.38378501e-01f, -9.80530828e-02f, -1.02468409e-01f,
  -3.13552260e-01f, -5.09474799e-02f, -4.55451608e-01f, 9.99663845e-02f, -5.61882555e-02f, -2.18985587e-01f, -1.43595226e-02f, -9.21098515e-02f, -6.51401430e-02f, 3.34078912e-03f,
  2.23552249e-02f, 1.17432058e-01f, -9.39702336e-03f, -1.32597080e-02f, 2.55807973e-02f, -1.87229663e-01f, -1.05720408e-01f, -4.39772941e-02f, 2.19596311e-01f, -2.90047467e-01f,
  5.92075251e-02f, 5.77448905e-02f, 6.82734177e-02f, -3.47342938e-01f, 8.33985955e-03f, 1.09210908e-01f, 1.86233163e-01f, -1.69496238e-01f, 2.12328121e-01f, -9.32263676e-03f,
  -2.45777398e-01f, 7.73612084e-03f, 1.08181208e-01f, -1.12179697e-01f, 2.04706654e-01f, -1.74324587e-01f, -1.44735994e-02f, -1.00630475e-02f, -8.87975395e-02f, -8.65980908e-02f,
  -5.06423935e-02f, -1.00573033e-01f, -4.33763266e-01f, 6.66049402e-03f, -8.64525735e-02f, 1.05697334e-01f, 7.37362802e-02f, 1.82436109e-01f, -9.33377594e-02f, 2.65238345e-01f,
  1.29494801e-01f, -6.92207664e-02f, -1.17962718e-01f, 4.49170291e-01f, -4.04791348e-02f, 1.50716111e-01f, -2.94663817e-01f, 3.01445335e-01f, -2.83169687e-01f, -2.34172672e-01f,
  -1.22160926e-01f, 3.12601440e-02f, 1.28188327e-01f, 4.88806739e-02f, 3.15417171e-01f, 8.83666575e-02f, 2.10289091e-01f, -8.91943742e-03f, 1.11763015e-01f, 7.08768964e-02f,
  -7.78580201e-04f, -1.18324012e-02f, -2.54335906e-02f, 1.26466215e-01f, 5.33365039e-03f, -7.41313323e-02f, 1.18989982e-01f, -1.52118402e-02f, 5.98719381e-02f, 6.02045357e-02f,
  1.54961839e-01f, -8.78050029e-02f, 9.01455246e-03f, -4.96918485e-02f, 3.02591883e-02f, 4.09920365e-02f, 1.68332413e-01f, 1.21517487e-01f, 1.25767455e-01f, 5.78691773e-02f,
  -1.12158485e-01f, 6.26745373e-02f, 8.10174420e-02f, 1.58411443e-01f, 8.84314328e-02f, -3.94619294e-02f, 1.36835799e-01f, 7.45384768e-02f, -1.34277761e-01f, -3.20088156e-02f,
  9.35427472e-02f, 6.76831901e-02f, -7.63997883e-02f, 5.98918013e-02f, 8.06052834e-02f, 1.02506857e-02f, 3.46248671e-02f, 7.68024325e-02f, -6.76679462e-02f, 1.79106444e-02f,
  8.63544717e-02f, 3.22370455e-02f, 1.31482050e-01f, 1.85158059e-01f, -4.06844229e-01f, 5.59471101e-02f, 5.18437140e-02f, 1.24816753e-01f, 3.36354822e-02f, 7.10026324e-02f,
  -1.33486643e-01f, -8.47718585e-03f, -2.13846639e-02f, -1.48056611e-01f, -2.50056386e-02f, -2.89214961e-02f, -1.46524191e-01f, -1.03703723e-03f, 1.27040908e-01f, 8.04287419e-02f,
  -1.52681336e-01f, -6.07054355e-03f, 4.31511700e-02f, -1.56804606e-01f, -8.67574587e-02f, 1.79799832e-02f, 8.93616900e-02f, 6.84178397e-02f, 1.92507356e-01f, 1.46431699e-01f,
  -1.07219433e-02f, -1.73349872e-01f, -1.94633063e-02f, 2.70612314e-02f, 4.44391854e-02f, -8.66935849e-02f, -3.50862831e-01f, -3.56407575e-02f, 2.96806782e-01f, 1.45366136e-02f,
  -1.45923451e-01f, 1.05415747e-01f, 7.19075799e-02f, -1.03190348e-01f, -2.24797741e-01f, 8.41312110e-02f, -7.83506706e-02f, -1.09989896e-01f, -7.01248124e-02f, 6.93349987e-02f,
  -7.89596699e-03f, -7.66802728e-02f, 7.60284960e-02f, 2.42234662e-01f, -2.17654109e-01f, 1.11997090e-01f, -1.65309072e-01f, 1.08113512e-02f, 3.96431349e-02f, 2.10919216e-01f,
  3.03175956e-01f, -1.98608488e-01f, 3.61033291e-01f, -2.17921376e-01f, 1.50396898e-01f, -1.67143962e-03f, 2.58191645e-01f, 3.39301944e-01f, -1.12325817e-01f, -3.46099913e-01f,
  1.79245010e-01f, -4.62652385e-01f, -8.62008780e-02f, -4.24133182e-01f, -9.86155346e-02f, 1.82073519e-01f, 5.64564526e-01f, -2.38691941e-01f, 9.58756730e-02f, -1.85219318e-01f,
  3.75935510e-02f, -3.32725234e-02f, 1.89144179e-01f, 8.22182521e-02f, 2.48911101e-02f, 8.03353786e-02f, 7.52540454e-02f, 1.17491812e-01f, 1.33790672e-01f, 1.85331449e-01f,
  2.18039066e-01f, 1.95216030e-01f, 5.35171479e-02f, -4.73150192e-03f, 9.64852795e-02f, 1.73715591e-01f, -4.51340415e-02f, 8.68651643e-02f, 8.30238760e-02f, -7.58347362e-02f,
  8.90693665e-02f, -7.55329209e-04f, 2.69994438e-02f, 6.53969869e-02f, -2.48859380e-03f, 3.14587317e-02f, 2.39962861e-01f, 9.04229209e-02f, 7.97174573e-02f, -2.07560975e-02f,
  -6.43137544e-02f, 5.12335263e-02f, 4.54731211e-02f, 1.14510067e-01f, 1.35823235e-01f, -1.78777538e-02f, 1.27341254e-02f, 2.02492550e-02f, 1.05196580e-01f, -8.76844153e-02f,
  -3.63491327e-02f, 4.37119678e-02f, 7.16762990e-02f, -3.45076323e-02f, -3.73674161e-03f, 8.75183940e-02f, -5.37727848e-02f, 5.30904382e-02f, 2.11482063e-01f, -7.51837492e-02f,
  5.66132478e-02f, -7.68505558e-02f, 2.67251700e-01f, -5.76784052e-02f, -9.89623070e-02f, -1.04299098e-01f, -1.09464107e-02f, 1.11218482e-01f, 2.37963170e-01f, 1.74483523e-01f,
  -6.08324781e-02f, -4.54586893e-02f, -3.57444316e-01f, 2.34865807e-02f, -7.87366554e-03f, 5.63023686e-02f, -1.84531525e-01f, -8.22598562e-02f, -9.33174938e-02f, -4.89346907e-02f,
  3.90725518e-06f, 1.99537594e-02f, 4.54519913e-02f, 1.02886558e-02f, -6.02482148e-02f, 9.53826495e-03f, 1.51421398e-01f, 3.30662340e-01f, 9.08207055e-03f, -1.01519816e-01f,
  1.11217655e-01f, 5.37905879e-02f, -1.23041123e-01f, 2.58734375e-01f, 4.41183671e-02f, -3.42063427e-01f, -4.08558212e-02f, 3.81344706e-02f, -3.04157250e-02f, 6.92710979e-03f,
  -3.24314125e-02f, 1.18208311e-01f, 6.71425760e-02f, -1.55340031e-01f, -3.37622198e-03f, 1.37418941e-01f, 1.81527078e-01f, -2.40377814e-01f, -3.03018820e-02f, 4.21157070e-02f,
  1.79319412e-01f, -6.68930858e-02f, -3.14853817e-01f, -2.06593677e-01f, 1.10870019e-01f, -2.98156068e-02f, 6.67263120e-02f, 3.02044246e-02f, -1.08261809e-01f, -1.14222102e-01f,
  4.64409888e-02f, 3.17745209e-02f, 2.71986187e-01f, -3.14378031e-02f, -2.23727524e-01f, 7.19924420e-02f, 2.39070684e-01f, -2.01172292e-01f, -5.18378839e-02f, 4.91005063e-01f,
  -1.58154666e-01f, -1.34365290e-01f, 2.83682700e-02f, 4.12245482e-01f, -1.43813163e-01f, -4.18778211e-02f, -2.17617452e-01f, -2.28790984e-01f, -1.00684501e-01f, -6.14765659e-02f,
  2.14739606e-01f, 1.69572636e-01f, -1.11546982e-02f, 2.85788417e-01f, 4.96833622e-02f, 7.09533989e-02f, 6.42448068e-02f, -7.01775216e-03f, 2.38997728e-01f, 8.51401836e-02f,
  1.87657028e-01f, 4.87557128e-02f, 1.81988463e-01f, 1.72180519e-01f, 5.57711907e-02f, 3.42327833e-01f, 1.03834204e-01f, 5.21843173e-02f, 2.98802227e-01f, 1.08317949e-01f,
  2.13535234e-01f, 8.60813558e-02f, 2.57693797e-01f, 1.86443552e-01f, 7.09148571e-02f, 6.20495938e-02f, 1.68471143e-01f, 2.30196625e-01f, 1.05247058e-01f, 1.66530833e-01f,
  6.24901839e-02f, 6.12103753e-02f, 1.92371696e-01f, 2.33362556e-01f, -1.65613033e-02f, 1.74916953e-01f, 1.01161696e-01f, 8.40434805e-02f, 2.44581088e-01f, 5.36904745e-02f,
  -4.77819191e-03f, 2.31579598e-02f, 1.06002286e-01f, 2.06112280e-01f, 4.98945303e-02f, 1.60760924e-01f, 1.47920147e-01f, 1.44775093e-01f, 7.11769685e-02f, -2.44211882e-01f,
  2.41492122e-01f, -6.29121512e-02f, -1.31982282e-01f, -3.80563408e-01f, 1.43846914e-01f, -4.50673625e-02f, 1.89200982e-01f, -1.85706839e-01f, 1.81123137e-01f, -4.86645475e-02f,
  1.74062625e-01f, -1.64905846e-01f, -1.31533563e-01f, 8.64994451e-02f, 2.86497120e-02f, -1.46957397e-01f, -1.12002008e-01f, -2.04402000e-01f, 7.81985298e-02f, 7.58500546e-02f,
  5.47071658e-02f, -1.59313962e-01f, 1.42976701e-01f, -1.09981202e-01f, 1.17568530e-01f, 1.55939654e-01f, -3.63422722e-01f, -1.39103636e-01f, 1.52406514e-01f, -1.15761586e-01f,
  -1.44792628e-03f, 9.45354477e-02f, 9.78027433e-02f, -3.20737034e-01f, -2.00477079e-01f, -6.05164468e-02f, -4.82999533e-01f, -2.64859855e-01f, -3.63342389e-02f, -1.03700440e-02f,
  1.33906202e-02f, -2.36757994e-01f, 2.74344057e-01f, 1.14953041e-01f, -6.80293739e-02f, 1.30073264e-01f, -6.92419894e-03f, -9.36829597e-02f, 5.68488277e-02f, 2.91147502e-03f,
  -6.85911477e-02f, 4.69603062e-01f, 6.15212806e-02f, -9.00630653e-02f, -2.83128381e-01f, 4.62545305e-02f, -1.65762007e-01f, 9.88732055e-02f, -2.62767971e-01f, -3.15027940e-03f,
  1.80916548e-01f, 8.46631825e-02f, -2.55226910e-01f, -4.79257666e-02f, -1.70082256e-01f, 4.67235386e-01f, -2.02363059e-01f, 3.45093906e-01f, 1.41303897e-01f, 8.42290372e-02f,
  -1.20978951e-01f, -1.46805272e-01f, 5.00040352e-02f, -2.16753721e-01f, -4.95911464e-02f, 1.14633486e-01f, -1.25566587e-01f, 1.65373847e-01f, 2.59848595e-01f, 3.95825058e-02f,
  1.66456327e-01f, 1.94499120e-02f, 1.07617140e-01f, 1.48939803e-01f, 1.13996364e-01f, 1.63795844e-01f, 4.82392870e-02f, 1.94254890e-01f, -1.45506725e-01f, -1.11002579e-01f,
  -3.92229073e-02f, 2.10654497e-01f, -6.32305443e-02f, 7.99926370e-02f, -3.12440451e-02f, -1.01212204e-01f, 2.83159185e-02f, -1.46084681e-01f, 4.78414372e-02f, -8.60377550e-02f,
  3.43046099e-01f, -3.20064090e-02f, 9.49436501e-02f, 2.00164780e-01f, 1.66297719e-01f, -3.22935432e-02f, 1.74588084e-01f, 1.58456750e-02f, 1.22479707e-01f, -7.09341094e-03f,
  1.49990335e-01f, -1.47965670e-01f, 1.30657973e-02f, 1.25128910e-01f, 1.31542191e-01f, -1.04413040e-01f, 2.22550184e-02f, 6.11378513e-02f, 1.54396653e-01f, -2.78872307e-02f,
  -2.81166099e-03f, -9.11721811e-02f, 3.62610887e-03f, -5.33388667e-02f, -5.08622713e-02f, -7.84174427e-02f, 1.80539310e-01f, -2.69718897e-02f, 6.15920918e-03f, 2.17652902e-01f,
  4.21875417e-02f, -1.23862237e-01f, 3.35240245e-01f, 1.60650179e-01f, -2.38323927e-01f, 1.24881677e-01f, -1.70796692e-01f, -4.91758920e-02f, 3.78769599e-02f, 1.30091190e-01f,
  -1.26178458e-01f, -6.84060156e-02f, 1.57801941e-01f, -1.47314221e-01f, -1.79068893e-01f, -9.83267576e-02f, 9.58201364e-02f, 1.87070802e-01f, 1.17496744e-01f, -1.39694795e-01f,
  -1.06795587e-01f, 1.25288308e-01f, 2.99717635e-02f, 1.44090131e-01f, -2.66263396e-01f, -2.34885201e-01f, 1.23748682e-01f, -1.31707802e-01f, 4.59355600e-02f, -2.24485189e-01f,
  -5.10711819e-02f, -8.02934617e-02f, -2.29032397e-01f, -4.39250097e-02f, -2.06813887e-01f, 2.47497126e-01f, 2.40351036e-01f, -1.27610117e-01f, 1.45346642e-01f, -1.28955916e-01f,
  8.70143920e-02f, -1.01599626e-01f, -4.73417848e-01f, 1.21142954e-01f, -3.06043308e-02f, 2.04944327e-01f, 3.36663842e-01f, 7.79011473e-02f, -1.34782165e-01f, 2.55521029e-01f,
  2.36263573e-02f, -1.37103647e-01f, -9.49096158e-02f, -5.22697210e-01f, -3.60376596e-01f, -2.16757536e-01f, -8.55390728e-02f, -3.13412070e-01f, 3.78671050e-01f, 4.16358411e-01f,
  -2.91695207e-01f, 4.01319340e-02f, 1.93414558e-02f, -2.04601347e-01f, -3.10274303e-01f, -2.81216443e-01f, -5.95141016e-02f, 1.48823205e-02f, 4.26546410e-02f, -2.91877329e-01f,
  4.82504457e-01f, -3.70677173e-01f, 2.82626692e-02f, -1.32530862e-02f, -5.62342815e-02f, 5.57641499e-02f, 6.41262457e-02f, -7.21799284e-02f, 9.66974571e-02f, 2.62190700e-01f,
  1.48771167e-01f, -1.10503294e-01f, 8.85942504e-02f, 5.09428903e-02f, 1.83607056e-03f, -3.89488973e-02f, -9.55454260e-02f, 9.39199850e-02f, 1.38639286e-01f, 4.70036045e-02f,
  1.59207955e-01f, 1.03615031e-01f, -6.10928051e-02f, -9.79915634e-02f, 1.40591681e-01f, 1.61386624e-01f, 9.79653522e-02f, 1.68327138e-01f, 1.89132959e-01f, -9.15238187e-02f,
  7.41591826e-02f, 1.33385792e-01f, 1.30313173e-01f, 5.79251423e-02f, 1.19911693e-01f, 1.12546906e-01f, 1.78701490e-01f, -4.60444577e-03f, 2.16268897e-02f, -8.63986742e-03f,
  -7.27435201e-02f, 6.92229569e-02f, 1.12935692e-01f, -7.16053229e-03f, 9.79504809e-02f, -6.13084901e-03f, 2.39584133e-01f, 1.79617018e-01f, -1.58794895e-02f, 1.77981481e-01f,
  -6.09475449e-02f, 6.79188669e-02f, 3.50229256e-02f, 5.71628474e-02f, 1.47379637e-01f, -3.59586999e-02f, -2.65169498e-02f, -2.83762157e-01f, -8.39520842e-02f, -2.08741874e-01f,
  1.47474498e-01f, -2.00043004e-02f, 6.89443350e-02f, -1.61550865e-01f, 4.89279404e-02f, -1.48317674e-02f, -4.99140844e-03f, -6.90016970e-02f, -1.48622453e-01f, -6.80947676e-02f,
  -3.80804658e-01f, -1.58194061e-02f, -3.28905970e-01f, 1.64011046e-01f, 2.90059466e-02f, -2.44018257e-01f, -3.66447903e-02f, 1.87251866e-02f, 2.81602982e-02f, -1.57483950e-01f,
  3.50548364e-02f, 5.44841029e-02f, -2.94197612e-02f, 3.49599123e-02f, -1.10625783e-02f, -1.37817875e-01f, -1.52632847e-01f, 2.47052442e-02f, 8.88834149e-02f, -1.15972534e-02f,
  2.93507397e-01f, 6.32034615e-02f, -3.31486277e-02f, -2.87887543e-01f, -1.22907972e-02f, -4.09893878e-02f, 1.17021939e-02f, -1.45688236e-01f, 1.00664794e-01f, -9.73210558e-02f,
  -1.86003461e-01f, 6.44735694e-02f, 1.20956469e-02f, -2.75853962e-01f, 1.02406502e-01f, 3.89453098e-02f, -5.11114180e-01f, -2.38215532e-02f, 4.05051298e-02f, 1.64744481e-01f,
  7.96938837e-02f, -8.58780220e-02f, -1.56682596e-01f, -1.80652946e-01f, 2.89962023e-01f, 9.23482925e-02f, 4.39846255e-02f, -2.27140319e-02f, -1.79361939e-01f, 7.33790100e-01f,
  -9.67700481e-02f, 3.66273448e-02f, -9.80719849e-02f, 4.54338938e-01f, 1.22980021e-01f, -4.59605046e-02f, -3.38737041e-01f, 3.40366125e-01f, 3.66139740e-01f, -4.73245889e-01f,
  -3.08344692e-01f, 2.27684863e-02f, -2.54428145e-02f, 1.08160004e-02f, 2.15723328e-02f, 5.44582084e-02f, 1.91141404e-02f, 8.11657161e-02f, 1.23210490e-01f, -8.90190597e-04f,
  2.45184213e-01f, -1.28107190e-01f, 4.37227301e-02f, 1.96776837e-02f, 9.94220097e-03f, 3.32842432e-02f, 1.75283596e-01f, 2.65928581e-02f, 2.48551499e-02f, 4.26548608e-02f,
  -5.47473729e-02f, 8.38681385e-02f, 3.29249240e-02f, 5.37018888e-02f, 1.87898222e-02f, -6.12275256e-03f, -5.96706606e-02f, 5.18980920e-02f, -3.98852527e-02f, 1.29841510e-02f,
  1.70884654e-01f, 1.04501665e-01f, -9.85796843e-03f, 8.10437575e-02f, 8.12063739e-02f, 1.70448888e-02f, -3.49281542e-02f, 5.06335832e-02f, 2.49099471e-02f, -2.63387673e-02f,
  1.59301221e-01f, -1.23905987e-02f, 1.79427546e-02f, 1.63032085e-01f, -7.73069635e-02f, 2.22408056e-01f, 5.45343123e-02f, 2.71166533e-01f, -7.31168240e-02f, -1.66224912e-02f,
  2.71097928e-01f, 2.18532875e-01f, -7.28375232e-03f, 3.39734778e-02f, 1.48895606e-01f, 7.15055764e-02f, 8.17429796e-02f, 2.08001629e-01f, -1.82671502e-01f, -1.98744804e-01f,
  3.53200547e-02f, -1.59368172e-01f, 6.64326102e-02f, -1.53736725e-01f, 7.49959648e-02f, -6.84590451e-03f, -6.83253165e-03f, 5.93679622e-02f, 1.21381998e-01f, 2.09983453e-01f,
  2.23929211e-01f, -6.23085909e-02f, -9.21823382e-02f, 1.75680257e-02f, 4.70072813e-02f, 1.98140331e-02f, -7.99627528e-02f, -6.52830005e-02f, -1.71648398e-01f, -9.30392593e-02f,
  -1.98232770e-01f, 5.89501932e-02f, 9.21178833e-02f, 5.81370369e-02f, -1.98428214e-01f, 2.53953170e-02f, 1.06873564e-01f, 9.70334858e-02f, 1.06835820e-01f, 3.64363283e-01f,
  -1.52594730e-01f, -6.48530200e-02f, -2.19902828e-01f, -4.21285396e-03f, -1.16941370e-01f, 7.68715963e-02f, 7.15377182e-02f, -1.38919488e-01f, -3.23132016e-02f, -1.32434547e-01f,
  6.27553463e-02f, 9.93595868e-02f, -2.98039287e-01f, -2.62958258e-02f, -8.91656950e-02f, 3.92155983e-02f, 1.89310133e-01f, 1.00638263e-01f, 1.41012236e-01f, 5.36293328e-01f,
  -2.92834500e-03f, 1.20335724e-02f, 2.86599636e-01f, 1.70330808e-01f, 8.74136984e-02f, 4.00163770e-01f, 1.32268608e-01f, 1.59833923e-01f, -8.19353908e-02f, -1.36136830e-01f,
  2.68702626e-01f, 2.94642687e-01f, 7.86303654e-02f, 4.99705642e-01f, 4.22340900e-01f, 1.54875100e-01f, 4.07337904e-01f, 2.02455610e-01f, 2.36176655e-01f, 4.98814285e-02f,
  1.67934939e-01f, 2.88526446e-01f, 9.41154361e-02f, 3.49900834e-02f, 2.18681768e-01f, 7.34809265e-02f, 1.83290299e-02f, 4.61256653e-02f, 1.59716651e-01f, 6.01741709e-02f,
  -4.89090160e-02f, 1.34747118e-01f, 3.81687023e-02f, 1.21483438e-01f, 5.78529574e-02f, 9.44933221e-02f, 1.27104104e-01f, 8.22838470e-02f, -5.19088916e-02f, 1.01852052e-01f,
  1.06353804e-01f, -2.31936220e-02f, -9.05056484e-03f, 5.50344177e-02f, 4.35291417e-02f, 8.74506906e-02f, 1.50650531e-01f, 4.34324034e-02f, 2.18069986e-01f, -4.98254597e-02f,
  -1.04496339e-02f, 5.85327595e-02f, 9.00053829e-02f, 1.09769320e-02f, 1.85230151e-01f, -1.79388206e-02f, 6.61692098e-02f, 5.52715696e-02f, 4.48771641e-02f, -1.65035591e-01f,
  7.89970011e-02f, 1.53919160e-01f, 1.42667919e-01f, 3.11424322e-02f, 7.17370138e-02f, 1.85501538e-02f, -8.36979896e-02f, -5.33241034e-03f, -2.63573006e-02f, 1.15162879e-02f,
  4.38431799e-02f, 3.68319631e-01f, -2.07455993e-01f, -2.02212721e-01f, -4.77006892e-03f, 6.13911785e-02f, 8.67298767e-02f, -8.73465985e-02f, 5.59677407e-02f, -1.63263753e-01f,
  5.45226336e-02f, 1.76256895e-01f, 1.69610113e-01f, -1.10701069e-01f, 1.47188092e-02f, 3.68067548e-02f, -1.46862105e-01f, 1.02222189e-01f, -3.71990763e-02f, 2.23665968e-01f,
  -5.49689867e-02f, -1.46328047e-01f, -1.12149574e-01f, 1.97521240e-01f, 1.70096382e-02f, 1.43665344e-01f, 9.41666216e-02f, 6.63788244e-02f, 2.48432592e-01f, 1.94957465e-01f,
  -1.08584642e-01f, 9.89380628e-02f, 4.42650348e-01f, 2.45500967e-01f, 1.31087303e-01f, 3.78413536e-02f, 2.00662091e-01f, 2.62385253e-02f, 2.23734707e-01f, -1.61466449e-01f,
  1.67876426e-02f, 4.28279787e-02f, -1.03694223e-01f, -5.12532257e-02f, -2.68547118e-01f, -1.81116492e-01f, -6.81007048e-03f, -1.42122973e-02f, -2.69819200e-01f, -7.42655545e-02f,
  1.57700911e-01f, 1.87409282e-01f, -3.10784519e-01f, -6.27130345e-02f, 1.66833282e-01f, 2.12367445e-01f, -8.18163976e-02f, 1.17384590e-01f, -1.88707754e-01f, 2.22207561e-01f,
  7.10095605e-03f, 2.99399078e-01f, 1.29186362e-01f, -4.06668425e-01f, 1.95031330e-01f, 6.90607205e-02f, -2.47816041e-01f, 2.32789502e-01f, 2.16260701e-02f, 2.85469647e-02f,
  3.00621204e-02f, -1.76248550e-01f, -1.29482493e-01f, 4.00299132e-01f, -1.30986154e-01f, -2.79848784e-01f, 1.14604689e-01f, -1.38571216e-02f, 1.73980370e-01f, 2.11806983e-01f,
  7.57318288e-02f, 1.38226956e-01f, 1.01650007e-01f, -4.53062579e-02f, 9.43928733e-02f, 6.68227151e-02f, 5.75855747e-02f, 2.37375125e-02f, -4.41573933e-02f, 1.75219670e-01f,
  1.17202990e-01f, 1.55634493e-01f, -3.91359627e-02f, 1.68605931e-02f, 8.38162005e-02f, 9.74158496e-02f, -1.76104847e-02f, 1.01084977e-01f, 1.06406689e-01f, -1.00626044e-01f,
  -3.37742199e-03f, 5.65384850e-02f, 6.97268695e-02f, 1.81939498e-01f, 4.49466258e-02f, 3.51652056e-02f, 1.18555479e-01f, -1.03470318e-01f, 1.19342446e-01f, 6.46160468e-02f,
  5.07638603e-02f, 1.00568958e-01f, 4.09879163e-02f, -5.45044653e-02f, 4.80664074e-02f, -9.59837623e-03f, 1.52849346e-01f, -5.64816259e-02f, -3.65823507e-02f, -1.74822249e-02f,
  -2.01848615e-02f, 1.43147185e-02f, 1.09461686e-02f, -5.39856143e-02f, 1.98977645e-02f, 9.51717794e-02f, 9.51262340e-02f, -3.51280347e-02f, 6.44398332e-02f, -4.44248132e-02f,
  -5.20198420e-02f, -4.20654118e-02f, -1.79312542e-01f, 1.31980022e-02f, 7.05066249e-02f, -5.99779375e-02f, 8.98166671e-02f, 1.72836632e-01f, -7.31439292e-02f, 2.92711526e-01f,
  7.97657296e-03f, -3.00374953e-03f, 7.48382090e-03f, -7.02787042e-02f, -3.52297872e-02f, -5.75332418e-02f, 3.09962630e-01f, 2.70822961e-02f, -1.62018880e-01f, 1.49748176e-02f,
  9.84212384e-03f, 5.64125404e-02f, 4.46719266e-02f, 1.56792533e-02f, 1.89055473e-01f, -5.79516329e-02f, 1.91726968e-01f, -1.39061376e-01f, -9.62604024e-03f, -6.23965599e-02f,
  2.76042074e-01f, 7.04586282e-02f, 6.58329874e-02f, -7.13711530e-02f, -3.14028978e-01f, -2.12549165e-01f, 2.96320021e-01f, 1.03437953e-01f, 2.08180964e-01f, -8.73373076e-03f,
  1.12690121e-01f, -1.56007007e-01f, -9.59882289e-02f, 1.23772070e-01f, 6.16704822e-02f, 3.85975577e-02f, -9.48965177e-02f, 1.86653763e-01f, 1.58167630e-01f, -6.73819110e-02f,
  1.19648196e-01f, -1.35558724e-01f, 2.85881996e-01f, 1.94606736e-01f, -1.61377285e-02f, -1.50400266e-01f, 1.10554555e-02f, 3.12271714e-01f, -1.84871823e-01f, 3.47114295e-01f,
  2.32426018e-01f, -4.23055917e-01f, 8.77313241e-02f, -2.48096913e-01f, 5.75576723e-02f, 1.61098614e-01f, -8.11524093e-02f, 8.83702114e-02f, 9.76458490e-02f, -3.74687284e-01f,
  -2.30730459e-01f, -4.00944948e-02f, -3.46841037e-01f, -9.39378049e-03f, -1.22822724e-01f, 3.89661663e-03f, -4.18415368e-02f, 7.19565600e-02f, 1.62005082e-01f, 6.13859594e-02f,
  9.63602215e-02f, 1.18121102e-01f, 4.66336049e-02f, 1.50139898e-01f, 1.46676665e-02f, 6.45139515e-02f, 1.56051084e-01f, 8.77156556e-02f, 6.70252293e-02f, -1.46879870e-02f,
  8.27210248e-02f, 1.55756101e-01f, 1.46381736e-01f, 1.11621313e-01f, 1.54225588e-01f, -6.28063157e-02f, -1.56234764e-02f, 4.28720824e-02f, 9.19268131e-02f, 4.22214270e-02f,
  4.00472879e-02f, 9.93119106e-02f, 2.01595783e-01f, 2.03605264e-01f, -2.50885542e-02f, 1.20269917e-01f, 9.22544003e-02f, 1.98196247e-01f, 5.05378935e-03f, 3.26030366e-02f,
  9.28431675e-02f, 7.50780702e-02f, 9.50168520e-02f, 8.16449821e-02f, 3.02880518e-02f, -4.05594632e-02f, 1.27718793e-02f, -2.99464678e-03f, -7.94088468e-02f, -1.28781488e-02f,
  1.58522904e-01f, -2.93734460e-03f, 3.46603729e-02f, 6.27951175e-02f, 6.16947412e-02f, 2.60714650e-01f, 1.24429151e-01f, 5.97247034e-02f, 1.68650672e-01f, -3.53176668e-02f,
  -7.00618774e-02f, -1.66649714e-01f, 7.96827301e-02f, 2.18199492e-01f, 3.06502059e-02f, 2.16970921e-01f, 1.13467872e-01f, -2.12370679e-01f, -2.32579589e-01f, 4.54924144e-02f,
  7.41265267e-02f, -4.74751480e-02f, -2.04978198e-01f, -1.22463346e-01f, -1.99616194e-01f, -7.43717849e-02f, 1.15833515e-02f, 8.48804042e-02f, -1.17894663e-02f, 4.55907807e-02f,
  -1.51559114e-01f, -6.19748933e-03f, -2.22996682e-01f, 1.66168734e-01f, -1.16002150e-01f, -8.62859190e-02f, 5.36244959e-02f, 8.57289732e-02f, -2.17595100e-01f, 1.60246007e-02f,
  6.42710254e-02f, -2.62855262e-01f, -3.22491229e-02f, 1.08233936e-01f, -1.84008274e-02f, 8.74854401e-02f, -3.76381315e-02f, 4.83578071e-02f, 2.08206102e-01f, -1.51616678e-01f,
  9.33197439e-02f, 1.26566574e-01f, 6.85941847e-03f, -1.63038731e-01f, 9.32012796e-02f, 1.20045759e-01f, -4.15641479e-02f, 2.37599723e-02f, -4.56377165e-03f, 1.62163332e-01f,
  -5.27073592e-02f, -3.05867404e-01f, 4.76426557e-02f, 9.65098217e-02f, -7.49389708e-01f, -3.31229299e-01f, 4.46945392e-02f, -1.68407202e-01f, 1.20881028e-01f, 2.77118176e-01f,
  -2.05996454e-01f, 2.41607130e-02f, 1.39069065e-01f, -6.16659708e-02f, -2.02619836e-01f, 4.29634571e-01f, -4.64945771e-02f, 9.53339338e-02f, 2.12103844e-01f, 4.96451050e-01f,
  -3.80757034e-01f, -4.84133869e-01f, -5.18207848e-01f, -6.12855516e-02f, 9.53546017e-02f, -5.88593632e-02f, 1.10020489e-01f, 6.36010170e-02f, 3.75103876e-02f, 9.60118100e-02f,
  1.39952227e-01f, -2.53142361e-02f, 6.11450002e-02f, -5.10471389e-02f, 1.29057288e-01f, 9.40541700e-02f, 1.04736961e-01f, 1.08280703e-02f, 2.04702956e-03f, -1.06390193e-01f,
  -3.51954922e-02f, -1.01162396e-01f, 1.64638106e-02f, 1.30861223e-01f, 7.41599426e-02f, 2.03029104e-02f, -2.67074676e-03f, 4.73067872e-02f, -1.37229939e-03f, -6.86240271e-02f,
  1.29896179e-01f, -9.68718529e-02f, 1.54684171e-01f, 8.60631373e-03f, 6.01348467e-02f, -1.37281613e-02f, -3.52645032e-02f, 3.05244140e-02f, -6.19294606e-02f, 1.52290568e-01f,
  6.34263381e-02f, -6.21145889e-02f, 1.11485265e-01f, 5.44765815e-02f, 1.63903564e-01f, -7.40708262e-02f, -8.86919275e-02f, 1.58235461e-01f, 2.50809398e-02f, 1.95265621e-01f,
  2.54579727e-02f, 5.75301722e-02f, 1.70643046e-01f, -8.75118468e-03f, -1.72283482e-02f, -3.22545350e-01f, 1.30000398e-01f, -1.49853095e-01f, 7.35990480e-02f, 1.33407474e-01f,
  -2.35200226e-01f, -3.36505249e-02f, 2.16456935e-01f, -1.67616792e-02f, 7.34123364e-02f, 8.02255794e-02f, 4.64220122e-02f, -7.78193399e-02f, -3.04480130e-03f, 4.55211801e-03f,
  -1.01779308e-02f, 7.21755400e-02f, 2.32747495e-01f, -1.23331644e-01f, -1.60986826e-01f, 1.81433056e-02f, 1.64294839e-01f, -1.07393213e-01f, -4.90351729e-02f, -1.88907743e-01f,
  2.11066264e-03f, 1.80290043e-02f, 9.10269693e-02f, -1.56934008e-01f, 6.55620918e-02f, -2.34538969e-02f, -1.16746359e-01f, 1.15126461e-01f, -1.48946688e-01f, 1.11484647e-01f,
  -8.29658657e-02f, 7.49120936e-02f, -6.06430508e-02f, -7.24615976e-02f, -8.80536139e-02f, 3.89487706e-02f, -2.42033657e-02f, -7.44135305e-03f, 2.00623080e-01f, 1.35404930e-01f,
  2.97975868e-01f, -4.58433665e-03f, 7.74924234e-02f, 8.47602487e-02f, -1.78767696e-01f, -2.13693932e-01f, 2.69097567e-01f, 2.33062804e-02f, 2.78459489e-01f, 5.13031939e-03f,
  5.81583986e-03f, 2.15538442e-01f, 2.03888491e-01f, 4.06625234e-02f, -5.19580208e-02f, 2.77610660e-01f, 1.94638744e-01f, 2.63413280e-01f, -2.70846393e-02f, -1.33698195e-01f,
  1.94716990e-01f, -4.18929346e-02f, 7.75888488e-02f, 4.52593654e-01f, 2.32194766e-01f, 2.85029382e-01f, 9.87186059e-02f, -3.16954374e-01f, 8.22319612e-02f, 2.71631122e-01f,
  -1.74529016e-01f, 1.12771578e-01f, 1.15172997e-01f, 1.33133560e-01f, 1.63865387e-01f, -3.34090814e-02f, 7.11691827e-02f, 1.23458542e-01f, 3.06237694e-02f, 1.15949042e-01f,
  -8.15040618e-02f, 7.22121596e-02f, -2.92619951e-02f, 6.04601651e-02f, 9.47403908e-02f, 1.22610502e-01f, 5.10218814e-02f, -1.63417440e-02f, 2.15837210e-01f, 1.32710725e-01f,
  4.22897004e-03f, -4.22087424e-02f, 1.73608646e-01f, 1.10759266e-01f, 1.16287647e-02f, 9.23186019e-02f, 5.20257726e-02f, 1.41710803e-01f, 1.37495652e-01f, 1.20984055e-01f,
  6.59872144e-02f, 2.95038819e-02f, 1.20569564e-01f, 3.91334035e-02f, 9.04084891e-02f, 1.02584578e-01f, 1.10334150e-01f, 8.08548331e-02f, 2.26527136e-02f, 2.14777276e-01f,
  1.26073703e-01f, -1.10883489e-01f, 1.90703571e-01f, 3.52259502e-02f, 1.09678537e-01f, 5.49681038e-02f, 1.01568934e-03f, 3.06265932e-02f, 4.23628790e-03f, 9.43462458e-03f,
  -1.98354777e-02f, 4.74138446e-02f, 6.53190836e-02f, 1.46735892e-01f, -1.93670671e-02f, -2.24075109e-01f, -7.86060467e-02f, -2.77502269e-01f, 7.66875744e-02f, -2.31600791e-01f,
  -1.25002533e-01f, -2.03785598e-01f, 1.06890954e-01f, 1.17109478e-01f, 1.57362193e-01f, -1.68959990e-01f, -6.96568415e-02f, 6.88269436e-02f, -1.87530983e-02f, 1.95963159e-01f,
  -1.70444608e-01f, 8.43674392e-02f, 2.19875071e-02f, -2.22329289e-01f, -1.76429331e-01f, -1.55331846e-02f, 8.16030577e-02f, -1.33055508e-01f, 1.48116108e-02f, 4.00670953e-02f,
  -1.53505996e-01f, 2.54424214e-01f, -5.38665242e-03f, 1.54306605e-01f, 1.11587562e-01f, -8.20888393e-03f, 1.35120586e-01f, -5.37664779e-02f, 2.39773214e-01f, 2.91940197e-02f,
  -1.61934435e-01f, -2.69647270e-01f, -8.30853134e-02f, 1.23339690e-01f, 2.58710776e-02f, -1.90943629e-01f, 9.62593034e-02f, -1.39996484e-01f, -3.51422951e-02f, 7.06582367e-02f,
  -6.86533526e-02f, -2.54968226e-01f, 1.92827750e-02f, 3.64115909e-02f, -1.72281384e-01f, 1.40744105e-01f, 1.10746406e-01f, -1.21536963e-02f, -1.23888299e-01f, 1.10854715e-01f,
  7.11919293e-02f, 4.85371023e-01f, -1.01576425e-01f, 9.75312963e-02f, -5.88117242e-02f, -3.38015318e-01f, 1.82437167e-01f, 3.37788224e-01f, -7.14075267e-02f, 3.46680909e-01f,
  1.26004651e-01f, 5.01602255e-02f, 1.38634875e-01f, 2.24310577e-01f, -1.66001931e-01f, 3.89022306e-02f, 1.42862096e-01f, 3.21229268e-03f, 2.38143072e-01f, 8.84234831e-02f,
  8.98838788e-02f, 1.71172708e-01f, 2.58027352e-02f, 6.54882863e-02f, 1.26715243e-01f, 1.03862234e-03f, 1.11231074e-01f, -5.27788699e-02f, 2.56582022e-01f, 5.02292402e-02f,
  1.11112319e-01f, 7.96099901e-02f, -2.04574578e-02f, 1.11387938e-01f, -5.18201701e-02f, -3.91257070e-02f, 6.41900599e-02f, -6.14025146e-02f, 7.27905135e-04f, 1.48462728e-01f,
  8.28375891e-02f, -3.06666568e-02f, -1.40577118e-04f, 7.26062730e-02f, -3.49909142e-02f, 7.92552233e-02f, 1.67044207e-01f, 3.42540368e-02f, 2.49310851e-01f, -2.31689978e-02f,
  1.09238580e-01f, -5.16694412e-03f, 1.30930081e-01f, 5.53617068e-02f, 1.18200332e-01f, 2.22544428e-02f, 6.76776022e-02f, 1.32885396e-01f, 2.00293913e-01f, 8.95583536e-03f,
  5.70585132e-02f, 5.89658618e-02f, 6.42362759e-02f, 1.26557335e-01f, 1.35651246e-01f, 9.22423899e-02f, 1.23854861e-01f, -7.17622936e-02f, 2.26966113e-01f, 5.13443118e-03f,
  -7.40419105e-02f, 1.45280913e-01f, -1.18077137e-01f, -3.08853298e-01f, -9.32908952e-02f, 3.43433052e-01f, -2.51630783e-01f, -2.40543783e-02f, -6.64178049e-03f, 1.03496410e-01f,
  2.45208815e-02f, 2.77835294e-03f, 1.60659966e-03f, 4.23002243e-03f, -6.46533519e-02f, -1.85842738e-01f, 1.04443775e-02f, 2.21195854e-02f, 1.71949476e-01f, 1.72293380e-01f,
  -1.83281660e-01f, -1.81628063e-01f, 3.55776586e-02f, -2.63256244e-02f, 1.44873932e-02f, -8.31038803e-02f, -1.38674662e-01f, -8.69628191e-02f, 2.79212236e-01f, 4.95728366e-02f,
  -3.45273279e-02f, 4.54506129e-02f, 1.44871205e-01f, 1.82836711e-01f, 1.10134728e-01f, 2.44647458e-01f, 1.16010189e-01f, 2.21943647e-01f, 2.21139744e-01f, -1.23777678e-02f,
  -7.28433812e-03f, 1.38892204e-01f, 3.63689736e-02f, 2.08677556e-02f, -1.98947281e-01f, -4.44017388e-02f, 2.23686233e-01f, -1.34431243e-01f, -6.72226325e-02f, -7.60612078e-03f,
  -1.87707469e-01f, -1.21654175e-01f, 4.25453246e-01f, -5.96087314e-02f, 3.77516113e-02f, 8.36477280e-02f, -2.64537912e-02f, 2.43624792e-01f, 2.38248616e-01f, 2.44471207e-01f,
  3.08114104e-02f, 3.18253338e-01f, 7.03717694e-02f, -6.68452084e-02f, 3.09448630e-01f, 3.45341377e-02f, -1.18310312e-02f, -1.32809922e-01f, 2.56708026e-01f, -1.55690731e-02f,
  1.72005259e-02f, 1.04142681e-01f, 3.33288498e-02f, 3.96153271e-01f, -4.94411252e-02f, 1.62989452e-01f, 1.48800150e-01f, -1.09273694e-01f, 1.57912910e-01f, 9.77304727e-02f,
  1.19758323e-01f, 2.03265995e-02f, 1.45067707e-01f, -6.35917485e-02f, -5.99919930e-02f, 3.44677195e-02f, -3.34263071e-02f, 1.60559282e-01f, -2.44289320e-02f, 7.11150914e-02f,
  7.06791738e-03f, 8.37376639e-02f, 1.63940907e-01f, 1.25053391e-01f, 1.51292726e-01f, 1.41192958e-01f, 5.53329550e-02f, 1.12474360e-01f, 1.80538222e-02f, 1.83832556e-01f,
  1.67295009e-01f, 1.86366625e-02f, 2.18600303e-01f, 4.39378023e-02f, 2.12790463e-02f, 4.24462222e-02f, 1.83226928e-01f, 1.05805844e-01f, 4.18772399e-02f, 1.18042141e-01f,
  1.72062621e-01f, -1.35617619e-02f, 9.55203846e-02f, 8.30890015e-02f, -1.13768443e-01f, -4.78844531e-02f, 4.16069366e-02f, 1.29963085e-01f, 7.11568967e-02f, 6.09426573e-02f,
  1.49493143e-01f, 1.81204468e-01f, 2.19422087e-01f, 1.74066827e-01f, 6.18796907e-02f, 7.79661387e-02f, 9.76057574e-02f, 1.74019024e-01f, 4.72605526e-02f, -1.50381580e-01f,
  -1.95714846e-01f, 1.89807452e-02f, -1.18020795e-01f, -2.07376033e-01f, 4.29351367e-02f, -1.44601092e-01f, -1.73776522e-01f, 3.09031270e-02f, -1.49989322e-01f, 5.27511276e-02f,
  1.65354207e-01f, 7.80355632e-02f, -1.75596744e-01f, 1.90667793e-01f, 1.08085409e-01f, -1.38145864e-01f, -1.29385993e-01f, 7.90527612e-02f, 3.21389943e-01f, -2.66255997e-02f,
  -6.19829185e-02f, 2.22366694e-02f, 6.95804954e-02f, -2.51717158e-02f, 2.56854296e-01f, -1.53018329e-02f, -9.28868800e-02f, -1.28618315e-01f, -1.07790388e-01f, -7.47643411e-02f,
  1.03091765e-02f, -9.12198499e-02f, -1.57035366e-01f, -1.88306093e-01f, 2.41217673e-01f, -1.52905449e-01f, 2.55601224e-03f, 1.60532802e-01f, 8.34755301e-02f, -1.00696206e-01f,
  -1.94933087e-01f, -1.36497766e-01f, -1.09655686e-01f, -2.40855813e-02f, -3.18966247e-02f, 2.10251763e-01f, -3.35196070e-02f, -2.16488570e-01f, 6.07112655e-03f, 2.98059851e-01f,
  -2.23799512e-01f, 1.24136828e-01f, -1.91259794e-02f, -8.61224234e-02f, 1.09855898e-01f, 9.44967493e-02f, 3.24057370e-01f, -6.98918849e-02f, 2.25425646e-01f, -2.47661471e-01f,
  -6.68656006e-02f, -7.96042755e-02f, 3.91744971e-02f, 1.79416224e-01f, -1.17188275e-01f, -6.58273324e-02f, 3.02862208e-02f, -2.92558163e-01f, -3.61623019e-02f, -3.29359978e-01f,
  -2.51204431e-01f, -1.49318621e-01f, 4.64867294e-01f, -8.34567770e-02f, 2.09523216e-01f, -4.22287956e-02f, 2.98518762e-02f, -1.29566342e-01f, 7.90557414e-02f, 3.61202098e-02f,
  1.16650403e-01f, -3.24925184e-02f, 6.51400760e-02f, -2.20235940e-02f, 3.15717369e-01f, 3.12556736e-02f, 1.00382008e-01f, 8.53119269e-02f, -1.03826476e-02f, 4.39588688e-02f,
  1.80801866e-03f, -1.77546561e-01f, -2.66465005e-02f, 5.79030067e-03f, 8.50235969e-02f, 9.48377773e-02f, -6.70190454e-02f, 9.66017768e-02f, -8.04610401e-02f, 1.20255336e-01f,
  -1.94418430e-01f, -3.55948843e-02f, 5.74087538e-02f, 5.22222109e-02f, 2.35153168e-01f, -6.69220611e-02f, 2.78364364e-02f, -8.61241147e-02f, -1.06850855e-01f, 2.34542266e-02f,
  -7.79486895e-02f, 6.91996291e-02f, -1.38228061e-02f, -1.60052016e-01f, 8.34727734e-02f, -1.17715053e-01f, -5.41171096e-02f, -1.41346931e-01f, 3.48257199e-02f, 8.58495757e-02f,
  -1.58619255e-01f, 1.43162936e-01f, -4.47892360e-02f, -1.03274778e-01f, 1.85195684e-01f, 2.37712590e-03f, -2.24639297e-01f, 3.17183286e-02f, 2.96416253e-01f, -5.28854787e-01f,
  -1.84146956e-01f, 1.71518162e-01f, -1.50164708e-01f, 6.70030415e-02f, 1.90541863e-01f, -2.58541964e-02f, 2.60439962e-01f, 1.39880180e-01f, 2.00842451e-02f, -9.69370157e-02f,
  1.21664912e-01f, -8.21697153e-03f, -2.36304536e-01f, 1.42239884e-01f, 6.49729893e-02f, 4.39357385e-02f, -2.83188131e-02f, -1.74939498e-01f, -1.35376230e-02f, -3.60605796e-03f,
  -9.33538303e-02f, -3.14368844e-01f, 8.64831060e-02f, -2.27571666e-01f, 7.55534396e-02f, -6.60491642e-03f, 1.10610211e-02f, -2.95871515e-02f, -6.31528869e-02f, 2.88632870e-01f,
  2.56419510e-01f, 2.20667452e-01f, 6.94265440e-02f, 3.07124872e-02f, 3.35915864e-01f, -2.79514521e-01f, -6.49889037e-02f, -2.25146376e-02f, 2.88723111e-01f, -6.86934143e-02f,
  -4.06229757e-02f, 2.67197541e-03f, 1.69087201e-01f, 6.07926138e-02f, -1.88839436e-01f, -1.74563266e-02f, -2.49418199e-01f, -2.74715066e-01f, 1.05183557e-01f, -3.74490321e-02f,
  2.26142034e-01f, 1.11690447e-01f, -1.94358919e-02f, -1.45689517e-01f, -6.81095198e-02f, 3.14071588e-02f, -8.50834399e-02f, 4.96609002e-01f, 1.43456802e-01f, -2.97004402e-01f,
  2.38031030e-01f, -2.18941852e-01f, -1.10995278e-01f, 6.84935600e-02f, 2.05922291e-01f, 2.33365983e-01f, 1.02145672e-01f, 9.99010578e-02f, -1.98351935e-01f, 1.96020946e-01f,
  -1.89632103e-01f, 8.41147453e-02f, -1.07290916e-01f, -5.78202643e-02f, 1.02437288e-01f, 1.98263451e-01f, 7.85256997e-02f, 3.51679511e-02f, 1.33044511e-01f, 4.87674884e-02f,
  6.75418228e-02f, 1.22386269e-01f, 5.54251708e-02f, -7.28014531e-03f, 1.01264670e-01f, -1.03980333e-01f, 2.54009575e-01f, 1.26056731e-01f, -4.10995744e-02f, 1.05131999e-01f,
  4.58249785e-02f, -6.17931597e-02f, 9.95262042e-02f, 1.51985213e-01f, -4.40836214e-02f, 2.02463105e-01f, 1.62625998e-01f, -1.18267521e-01f, 1.18434519e-01f, 2.08471090e-01f,
  1.03695586e-01f, 1.73368618e-01f, 9.01897550e-02f, 1.06301956e-01f, 8.19231197e-02f, 8.26960877e-02f, 1.01184770e-01f, 1.40784025e-01f, 4.38959822e-02f, 1.54547557e-01f,
  1.96255073e-01f, 2.96796739e-01f, -5.65637834e-02f, 3.36011648e-02f, 1.28527939e-01f, 2.83952475e-01f, 2.38091662e-03f, 9.00569782e-02f, 1.27799228e-01f, 7.85312653e-02f,
  4.78897318e-02f, 2.30000585e-01f, 5.76231182e-02f, 7.85036162e-02f, 2.06208751e-01f, -1.73533306e-01f, 9.95132327e-02f, 3.13439369e-01f, 5.97101003e-02f, -3.24443243e-02f,
  -7.37935826e-02f, -4.39867266e-02f, -2.40738541e-01f, 1.14356890e-01f, -1.31194994e-01f, -1.23958163e-01f, 4.57477681e-02f, 7.02219605e-02f, 2.39607900e-01f, 9.87266004e-03f,
  1.51073709e-01f, -1.04131326e-01f, 1.16929762e-01f, -1.69214547e-01f, 7.62989894e-02f, 2.80297428e-01f, -1.62161049e-02f, -1.88887626e-01f, -5.27011044e-02f, 1.29995495e-01f,
  -1.05473928e-01f, -1.69398889e-01f, -1.84713900e-01f, 7.46905506e-02f, 6.14858530e-02f, 2.07902566e-02f, -2.26427130e-02f, -2.09020853e-01f, 8.82993191e-02f, -2.85280962e-02f,
  -1.65299878e-01f, -9.71686766e-02f, -1.14730075e-01f, 2.66413957e-01f, -1.92227550e-02f, -3.93298976e-02f, 1.21812038e-01f, 1.31148487e-01f, -2.06141807e-02f, -4.12297994e-02f,
  7.97359087e-03f, 4.15192218e-03f, 1.09083407e-01f, 2.23036677e-01f, 1.51148066e-01f, -6.07697852e-02f, 5.06479442e-01f, 1.41011581e-01f, -5.60556501e-02f, -1.96896836e-01f,
  7.91045129e-02f, 3.60489368e-01f, 2.64851630e-01f, 2.78808981e-01f, -1.82600826e-01f, 8.34923834e-02f, -1.62252307e-01f, 2.06039742e-01f, 1.69953197e-01f, -2.45485306e-01f,
  -1.14911295e-01f, 3.64262536e-02f, 2.37628013e-01f, -2.09189519e-01f, 1.42950371e-01f, 5.43910265e-01f, 5.42236745e-01f, -1.15195110e-01f, -2.54711717e-01f, 4.62437421e-01f,
  3.95768344e-01f, 2.19030529e-01f, 8.14078096e-03f, 1.04378618e-01f, 1.63888797e-01f, 1.56212563e-03f, 2.66328435e-02f, 4.25768718e-02f, -4.15199362e-02f, 1.83845714e-01f,
  1.37121618e-01f, 5.64028211e-02f, 5.29611185e-02f, 6.03231899e-02f, 1.33439898e-01f, -1.92045476e-02f, 1.93882585e-02f, 7.48877004e-02f, 1.05044164e-01f, -8.38801917e-03f,
  1.02606870e-01f, 7.87153691e-02f, 1.69258893e-01f, -7.00381249e-02f, 4.54501808e-02f, 5.33230975e-02f, -3.50894742e-02f, 1.60874426e-01f, 2.17317522e-01f, 7.69352168e-02f,
  9.17592868e-02f, 5.46108894e-02f, 2.02948183e-01f, -2.56866850e-02f, 2.11038794e-02f, 1.35307088e-01f, 5.02023622e-02f, 1.69839710e-01f, -5.47335446e-02f, 1.28327191e-01f,
  4.67423685e-02f, -1.14015199e-01f, 1.62329197e-01f, 4.87653799e-02f, -6.96235001e-02f, -4.98342440e-02f, 5.04708067e-02f, 1.34635255e-01f, 5.84070273e-02f, 3.59139480e-02f,
  1.99567333e-01f, -2.01230403e-02f, -4.34757285e-02f, -2.46801496e-01f, 1.38884649e-01f, -2.22855851e-01f, -1.15107633e-01f, -1.76980630e-01f, 7.52388537e-02f, -1.22525886e-01f,
  1.17150225e-01f, 1.63974557e-02f, 7.81830475e-02f, 1.14807874e-01f, 8.44014883e-02f, -4.78175059e-02f, -4.73939367e-02f, 8.93850550e-02f, -1.09125234e-01f, -2.61045899e-02f,
  2.10791677e-01f, -1.01444855e-01f, -5.45032583e-02f, 1.83177173e-01f, -3.35466638e-02f, -5.38033992e-02f, -5.31354398e-02f, -1.80294618e-01f, 1.56345680e-01f, -3.36326994e-02f,
  4.77454485e-03f, -1.61282778e-01f, 9.28702876e-02f, 2.53306273e-02f, 6.45776317e-02f, 2.62009036e-02f, -4.13000360e-02f, -2.45233830e-02f, -1.10697731e-01f, -1.11940213e-01f,
  7.56948143e-02f, 1.72197837e-02f, 1.31019741e-01f, 4.29947227e-02f, 1.32492542e-01f, -1.67820722e-01f, 1.84461951e-01f, 5.15912622e-02f, 3.60584408e-02f, -2.12560613e-02f,
  3.25443200e-03f, 2.58409958e-02f, -1.72310788e-03f, -2.01609239e-01f, 3.04580241e-01f, 1.50489405e-01f, 2.72657484e-01f, 1.13363616e-01f, -6.80704191e-02f, -1.80822477e-01f,
  6.73874840e-02f, 3.79363298e-01f, -2.01223150e-01f, 2.94902354e-01f, 2.12746739e-01f, -7.76812583e-02f, -7.45979249e-02f, -1.70887351e-01f, 1.71557367e-01f, 1.26399219e-01f,
  6.57889247e-02f, 5.36489725e-01f, 1.23703189e-01f, 2.18895540e-01f, -1.40902385e-01f, -1.33513724e-02f, -2.03109086e-01f, 1.77256003e-01f, -1.11653931e-01f, 1.42341942e-01f,
  4.54920232e-02f, 8.72328058e-02f, 4.48055193e-02f, 3.40245366e-02f, 1.51666373e-01f, 1.49277672e-01f, 1.32951245e-01f, 1.76445711e-02f, 8.32069069e-02f, 2.42520720e-02f,
  -9.87289357e-04f, 1.69436291e-01f, -5.40854298e-02f, 7.73975402e-02f, -1.25626791e-02f, 1.20430492e-01f, 1.38760060e-01f, 6.02640808e-02f, 4.67601158e-02f, 5.08600520e-03f,
  1.47559568e-01f, 1.33855760e-01f, 6.69309497e-02f, 2.68422626e-02f, 1.13563448e-01f, -1.72815528e-02f, 5.02504930e-02f, 1.96321219e-01f, 1.23585291e-01f, 1.15504920e-01f,
  8.89707804e-02f, 2.96284467e-01f, 6.30239844e-02f, 2.77295243e-03f, 2.86939889e-01f, 1.06958263e-01f, 2.23650128e-01f, 1.50353283e-01f, 1.07438661e-01f, 1.12449311e-01f,
  9.34467018e-02f, 1.65535808e-01f, -4.03063297e-02f, 5.44098392e-02f, 9.22420248e-02f, 1.50561705e-01f, 2.14286540e-02f, -1.10146068e-02f, 1.37873277e-01f, 9.62030515e-02f,
  7.34752119e-02f, 9.46058109e-02f, 6.46811649e-02f, 2.34173357e-01f, 1.15796588e-01f, 3.75907302e-01f, -1.48789108e-01f, 2.18816996e-02f, -1.20960213e-01f, -1.50249284e-02f,
  -1.02352597e-01f, -3.23124468e-01f, -8.62092897e-02f, -4.23352942e-02f, 9.12596509e-02f, -8.82296041e-02f, 2.06674892e-03f, 2.78017700e-01f, 2.13144496e-01f, 3.38344947e-02f,
  -9.83396471e-02f, -1.07124913e-02f, 2.22740695e-02f, 4.09984328e-02f, -1.17102554e-02f, 1.00306019e-01f, -3.18281442e-01f, -1.55791953e-01f, -2.71093905e-01f, 8.25662687e-02f,
  9.90638509e-02f, 2.71338820e-01f, -2.51133740e-01f, -1.58955857e-01f, 1.99636817e-02f, 2.43698925e-01f, 4.07105051e-02f, 3.11487824e-01f, -2.98690438e-01f, -6.55344054e-02f,
  -2.16012776e-01f, -1.83037929e-02f, -8.78206193e-02f, 8.92628729e-02f, -1.91103935e-01f, -7.82616362e-02f, 1.53597385e-01f, -2.65285254e-01f, 4.79184836e-02f, 8.37643519e-02f,
  -3.01926404e-01f, -1.11797927e-02f, 3.41883898e-01f, 2.75157839e-01f, -2.20581338e-01f, -9.32827145e-02f, 1.05060972e-01f, 5.42759180e-01f, 2.03905046e-01f, 1.41968206e-01f,
  1.90300733e-01f, 4.04997878e-02f, 2.24603061e-02f, 5.39509296e-01f, 1.82249174e-01f, 1.21910639e-01f, -5.05857542e-02f, -3.51911604e-01f, 1.61698714e-01f, -2.95142792e-02f,
  -3.38425606e-01f, 4.39603537e-01f, 6.15592301e-01f, 3.14370602e-01f, 4.86322910e-01f, 3.71396005e-01f, 2.80990809e-01f, -1.33990049e-01f, 2.83393353e-01f, 3.28350604e-01f,
  4.03961428e-02f, 1.17008984e-01f, 1.48350820e-01f, 1.90978512e-01f, 8.99410844e-02f, -1.24764154e-02f, -9.53162462e-02f, -3.65956128e-02f, 1.62807852e-02f, 1.24662807e-02f,
  3.31737325e-02f, 1.67347297e-01f, 3.50223593e-02f, 3.15493383e-02f, 2.14771163e-02f, -2.35610958e-02f, 8.08018595e-02f, -5.28944209e-02f, 1.28923535e-01f, 1.40680239e-01f,
  1.20102711e-01f, 3.80723327e-02f, 1.69507936e-01f, -3.85301793e-03f, 1.92766860e-01f, -1.47086203e-01f, 4.20546122e-02f, -2.15770647e-01f, -8.21132660e-02f, 1.23720631e-01f,
  2.67059486e-02f, 4.50930558e-02f, 1.01359300e-01f, 6.35371730e-02f, 8.49862620e-02f, 2.25794718e-01f, 8.09728801e-02f, 2.09165458e-02f, -7.56955519e-03f, 6.28664792e-02f,
  1.60424575e-01f, 1.08001269e-01f, 1.06724836e-01f, 5.32436259e-02f, 1.26785472e-01f, 5.96828982e-02f, -1.52414653e-03f, -9.40024331e-02f, 7.66193792e-02f, 5.80766983e-02f,
  -3.33490133e-01f, -1.41124725e-01f, -9.39602628e-02f, 3.13046128e-01f, -1.11357309e-01f, 8.22625235e-02f, 7.84861073e-02f, 3.21260765e-02f, -1.77522644e-01f, 1.91582084e-01f,
  -1.75025061e-01f, -1.30808158e-02f, 6.77437782e-02f, -1.36006728e-01f, 3.41714770e-02f, -1.90831378e-01f, 1.58034414e-01f, 3.24972183e-01f, 8.65351036e-02f, -1.88436598e-01f,
  1.40676543e-01f, -9.61778015e-02f, 1.26255471e-02f, 8.96018445e-02f, 1.13742530e-01f, 1.78520426e-01f, 3.88588756e-01f, 2.30476330e-03f, -1.20746925e-01f, -8.63720700e-02f,
  8.22748914e-02f, 1.77396685e-01f, -4.41448390e-03f, -8.21300372e-02f, 3.60853076e-02f, -3.20055187e-01f, 2.41943657e-01f, -1.90886874e-02f, -6.30156556e-03f, 7.22745284e-02f,
  -1.47315517e-01f, 1.55903190e-01f, -1.54595315e-01f, -9.02828388e-03f, 2.30364904e-01f, -7.83440918e-02f, -3.81198153e-02f, -2.26583648e-02f, 1.73322156e-01f, -1.45935733e-03f,
  1.89382564e-02f, -2.22672731e-01f, -8.62837136e-02f, 2.94048488e-01f, 4.74003814e-02f, 6.39953688e-02f, 3.24629247e-01f, 5.20143956e-02f, 3.11899073e-02f, -3.46290949e-03f,
  -9.18379128e-02f, -7.83163980e-02f, 9.35582295e-02f, 1.64212033e-01f, -2.68909167e-02f, 4.16075513e-02f, -5.22531010e-03f, -1.28755748e-01f, 7.57075399e-02f, -2.44573891e-01f,
  5.95517643e-02f, -8.50175172e-02f, -7.52857924e-02f, -1.17418095e-02f, 6.56956807e-02f, 4.94134314e-02f, 8.79162028e-02f, 5.08538634e-02f, 8.53964239e-02f, 1.37310371e-01f,
  8.20868835e-02f, -7.04090996e-03f, 4.71966676e-02f, -1.04356427e-02f, 1.58987775e-01f, -9.08838585e-02f, -1.21365930e-03f, 1.11904815e-01f, -6.95171580e-02f, 7.47490227e-02f,
  1.51729034e-02f, 1.72721725e-02f, 1.94827132e-02f, 5.67919463e-02f, -1.41077740e-02f, 7.62872100e-02f, 4.76945341e-02f, -4.91161272e-02f, 6.39472157e-02f, 4.38790061e-02f,
  1.21634804e-01f, 1.50895845e-02f, -6.24420978e-02f, 3.03332005e-02f, 6.86152205e-02f, 8.41779411e-02f, -1.14927575e-01f, 1.90388888e-01f, -3.83576453e-02f, 9.78506450e-03f,
  1.64446369e-01f, 2.24210788e-03f, 1.99799433e-01f, 4.69103418e-02f, 1.33666933e-01f, 7.19956979e-02f, -5.82630821e-02f, 6.20550364e-02f, 3.27754952e-02f, 1.17967449e-01f,
  -4.93119583e-02f, 1.34101182e-01f, -1.15524180e-01f, -4.67597134e-02f, 1.05088241e-01f, 1.17506020e-01f, 6.47532791e-02f, 1.40263408e-01f, -6.64753765e-02f, 3.08949709e-01f,
  1.81564346e-01f, 2.07845598e-01f, 1.73716024e-01f, 3.60477753e-02f, -1.25888288e-01f, 7.14172274e-02f, -1.20125510e-01f, -2.37602547e-01f, 6.07154286e-03f, 1.62048694e-02f,
  -7.82932788e-02f, -1.09334037e-01f, 3.07114542e-01f, 9.89510715e-02f, -2.11393982e-02f, -4.38355375e-03f, -1.74984168e-02f, 1.67097654e-02f, 5.03056012e-02f, -5.45619801e-02f,
  -7.10110068e-02f, 2.81181633e-01f, -6.33230656e-02f, 3.45064253e-02f, -1.19228296e-01f, -1.13008052e-01f, -2.75124609e-02f, 2.75426004e-02f, -1.35656133e-01f, -9.25230756e-02f,
  -7.19080865e-02f, 3.06988461e-03f, -9.44015607e-02f, 2.22527280e-01f, -7.73483813e-02f, 1.86479390e-01f, 1.13932058e-01f, -1.60664707e-01f, -1.82076544e-01f, -1.30191341e-01f,
  -1.61554947e-01f, 1.54379020e-02f, -1.65057793e-01f, 4.48893458e-02f, 1.74726490e-02f, 3.24414909e-01f, -1.05629824e-01f, 1.25090003e-01f, -3.14185649e-01f, -1.57403632e-03f,
  2.11053953e-01f, 6.77125677e-02f, 1.81756437e-01f, 2.14399740e-01f, -5.61003864e-04f, -4.04045731e-01f, 3.53263885e-01f, -1.43562287e-01f, 2.96880007e-01f, 5.23150742e-01f,
  9.52460840e-02f, 6.03688844e-02f, 1.41440034e-01f, -2.54569739e-01f, 1.08081393e-01f, -1.14104584e-01f, -8.85884762e-02f, 4.27275896e-02f, 3.80173802e-01f, 1.39659971e-01f,
  3.33747476e-01f, -7.74095729e-02f, 1.22878529e-01f, -1.06983125e-01f, 2.26946816e-01f, 2.50259459e-01f, 9.04472098e-02f, 3.59128825e-02f, 1.21053196e-01f, -3.24493460e-02f,
  -1.34429261e-02f, 2.06089497e-01f, -5.08527718e-02f, 3.14633586e-02f, -1.28131226e-01f, -5.91925904e-02f, 1.98414654e-01f, 7.95761347e-02f, 1.31659880e-01f, 1.90929323e-01f,
  -3.90388593e-02f, -5.74259646e-02f, 7.73173720e-02f, 1.17548987e-01f, 3.54899056e-02f, 4.26067933e-02f, 5.12524880e-02f, 7.40096858e-03f, 1.50745541e-01f, 7.09821936e-03f,
  1.69590861e-01f, 9.43918750e-02f, 1.78996161e-01f, 1.52144104e-01f, -6.04721121e-02f, 8.68635625e-02f, 1.17011510e-01f, -3.62172723e-02f, -4.94456366e-02f, -5.21220528e-02f,
  4.52101864e-02f, 1.23769708e-01f, 2.30396509e-01f, 1.51395366e-01f, 4.49347384e-02f, 1.99500054e-01f, 6.99556917e-02f, 1.18976183e-01f, 6.46937266e-02f, -1.68247655e-01f,
  2.47030810e-01f, 1.94684327e-01f, 2.51034737e-01f, 2.54370645e-02f, 7.20623210e-02f, -4.80449572e-02f, 2.98460051e-02f, 4.19346005e-01f, -5.56470314e-03f, 9.42876115e-02f,
  -1.03894591e-01f, -1.13103874e-01f, -2.03369468e-01f, 2.86073118e-01f, -3.46340895e-01f, 7.00655673e-03f, -1.39576033e-01f, -5.63994003e-03f, 9.26203802e-02f, -2.06120312e-01f,
  2.80261844e-01f, -1.90393776e-01f, 1.28460974e-01f, -2.74601635e-02f, -5.91898002e-02f, 1.87806144e-01f, -9.74227041e-02f, 1.16759650e-01f, 4.37314473e-02f, 4.47306216e-01f,
  3.12170815e-02f, -4.75680269e-02f, -2.51891967e-02f, -1.96659654e-01f, -6.59078583e-02f, 1.10916801e-01f, 2.08750337e-01f, -2.50097692e-01f, -3.05169910e-01f, 1.81099158e-02f,
  -8.70767459e-02f, -1.40340596e-01f, 1.51793599e-01f, 5.88953912e-01f, -9.19406712e-02f, 7.28492066e-02f, -1.64297104e-01f, 2.08366334e-01f, -2.22027645e-01f, -8.43145140e-03f,
  5.21193817e-02f, -2.93864105e-02f, 1.15879085e-02f, 3.16398978e-01f, 5.33833653e-02f, 2.10337535e-01f, 4.43217963e-01f, 6.98529482e-02f, 1.45757392e-01f, -1.64192647e-01f,
  -1.89488903e-01f, 2.39159271e-01f, 4.71734166e-01f, 1.28473043e-01f, -2.13588506e-01f, 3.38082458e-03f, 1.73300609e-01f, 1.16639353e-01f, 2.26378545e-01f, -2.61872739e-01f,
  -3.99301976e-01f, 2.54473329e-01f, 1.37105271e-01f, -4.41134900e-01f, -5.21563329e-02f, -2.93356217e-02f, 3.74016374e-01f, -9.31765661e-02f, 2.31245637e-01f, 2.76101887e-01f,
  4.04427797e-01f, 1.24349944e-01f, -1.76595032e-01f, -8.89285207e-02f, 1.26545548e-01f, -2.66134609e-02f, 1.40572518e-01f, 8.83079842e-02f, -1.71626313e-03f, 4.93360497e-02f,
  1.50894955e-01f, 1.51769698e-01f, 1.83608364e-02f, 2.83457994e-01f, -1.47399619e-01f, -8.54688957e-02f, 2.78147496e-03f, 1.62214860e-01f, 1.11629233e-01f, 2.67821819e-01f,
  1.27798989e-01f, -3.17548104e-02f, 4.36597213e-04f, 9.74713415e-02f, 6.81331567e-03f, -1.19611934e-01f, 4.66406532e-02f, 3.36340033e-02f, -2.55369139e-03f, 2.23695830e-01f,
  1.64201688e-02f, -1.10791139e-01f, 4.91379090e-02f, 2.07881227e-01f, -1.26694471e-01f, 2.02720240e-02f, 1.18983507e-01f, 4.07244861e-02f, 2.05835313e-01f, 1.65585324e-01f,
  8.42024088e-02f, -1.39434770e-01f, -8.22506994e-02f, -1.49243116e-01f, -5.97046316e-02f, 1.03185296e-01f, -3.62321436e-02f, -1.17595494e-02f, -4.04152758e-02f, 3.21169533e-02f,
  -3.22308242e-02f, 1.48576751e-01f, 5.65773733e-02f, -1.51502296e-01f, 1.27673402e-01f, -1.19129524e-01f, 1.17962874e-01f, 8.59577805e-02f, 9.97472703e-02f, 3.54327798e-01f,
  7.47698545e-02f, 2.29463786e-01f, -4.49977703e-02f, -2.13447794e-01f, -8.64789486e-02f, 2.29159016e-02f, 9.82978716e-02f, -2.25380197e-01f, -1.28873229e-01f, -6.48800060e-02f,
  -5.58829546e-01f, -2.10040033e-01f, -1.71161532e-01f, 1.17620826e-01f, 4.19396386e-02f, -1.01795934e-01f, -2.71377936e-02f, 7.39762783e-02f, -2.08575949e-01f, -1.28089994e-01f,
  -1.75175697e-01f, -7.22716898e-02f, 2.24555805e-01f, -2.21741080e-01f, -4.32880111e-02f, -1.72158390e-01f, 2.36789331e-01f, -1.64373666e-01f, -2.52969891e-01f, 2.84652770e-01f,
  9.57886353e-02f, -1.61445007e-01f, -1.01441145e-01f, -3.67307737e-02f, 1.21659964e-01f, 4.88011613e-02f, 5.45140021e-02f, 1.14201903e-02f, -4.57208127e-01f, 6.46246523e-02f,
  2.60360897e-01f, 1.05869070e-01f, -5.66886216e-02f, -3.01453143e-01f, 2.50849962e-01f, 2.11441919e-01f, -1.31162405e-01f, 1.71983521e-02f, 2.36726925e-02f, -2.48194650e-01f,
  -6.65141046e-01f, -1.20674580e-01f, -3.54746880e-04f, -5.75685757e-04f, 4.15075809e-01f, 4.81016219e-01f, -1.79038808e-01f, -1.98396489e-01f, 1.10270888e-01f, -2.98966765e-01f,
  2.04532724e-02f, 3.73316288e-01f, -2.76434600e-01f, 5.41125059e-01f, 2.58037299e-01f, -1.73850119e-01f, -2.43588686e-01f, -2.92032987e-01f, -4.44822937e-01f, 5.48805073e-02f,
  1.95771590e-01f, 6.22218810e-02f, 1.51863201e-02f, 4.45004739e-02f, 6.68767616e-02f, -9.14019123e-02f, 2.32034996e-02f, -1.33954287e-01f, 1.43595144e-01f, 8.75567272e-02f,
  -5.62582016e-02f, 1.16198964e-01f, -9.05751949e-04f, 8.70578811e-02f, -4.98301908e-02f, 4.12173383e-02f, -2.85525769e-02f, -6.79928586e-02f, -9.38270763e-02f, 8.72785896e-02f,
  -1.22819692e-02f, -6.75871596e-02f, 3.05340029e-02f, 2.00141054e-02f, 1.44716278e-01f, 1.27549931e-01f, 2.04645433e-02f, -1.16522849e-01f, 5.43778129e-02f, -5.29091153e-03f,
  5.76083213e-02f, 3.86735015e-02f, -6.76420629e-02f, 8.78789946e-02f, 1.07121512e-01f, -2.18330156e-02f, 2.73677912e-02f, -1.38906449e-01f, 1.51598630e-02f, 9.04034171e-03f,
  -3.19093764e-02f, 3.16556692e-02f, 1.71015933e-01f, 5.13424799e-02f, -1.72472280e-02f, 6.35343567e-02f, -9.44599956e-02f, 1.18887201e-01f, 1.00523598e-01f, -7.61545599e-02f,
  -9.11746398e-02f, 1.83308683e-02f, -1.25186220e-01f, 2.00191751e-01f, -8.09690505e-02f, -8.37002248e-02f, 1.49278119e-01f, -2.30601221e-01f, -2.60679454e-01f, -4.85704141e-03f,
  -9.51504037e-02f, -1.23397440e-01f, 1.62620351e-01f, -2.22121775e-02f, -5.61752580e-02f, -3.34461704e-02f, 3.17131132e-01f, 7.96194002e-02f, 1.17009751e-01f, -2.90447921e-02f,
  -5.93735576e-02f, -6.17078692e-02f, -4.25453298e-02f, 1.12465955e-03f, 1.08221695e-01f, 9.25544798e-02f, 1.10052943e-01f, -4.79632802e-02f, -2.40810186e-01f, -6.53681010e-02f,
  4.22155969e-02f, 1.15237504e-01f, 2.82384574e-01f, -8.41483995e-02f, -6.25846907e-02f, -2.79553868e-02f, -4.09867130e-02f, 2.27409415e-02f, -9.52182785e-02f, 1.23007543e-01f,
  -3.97430360e-02f, -7.44644329e-02f, -7.49180838e-02f, -1.74195960e-01f, 4.68396209e-02f, 4.68143402e-03f, -2.04918072e-01f, 1.70391709e-01f, -1.68362856e-01f, 7.91502297e-02f,
  -6.31240830e-02f, 1.02366053e-01f, -2.22857580e-01f, 3.13514173e-02f, 3.10525507e-01f, 1.09539233e-01f, 2.85402965e-02f, 5.48419207e-02f, 2.08533809e-01f, 1.07582927e-01f,
  9.43645909e-02f, -2.02210080e-02f, 3.25895935e-01f, -1.22167088e-01f, 1.10206269e-01f, 7.53519237e-02f, -7.79137462e-02f, 1.31285086e-01f, 2.13416025e-01f, -3.40554923e-01f,
  1.14183143e-01f, -1.02188393e-01f, -1.99816868e-01f, -1.90954849e-01f, 4.17004466e-01f, -1.60230249e-01f, 1.25742465e-01f, -3.25832814e-02f
};

// L1_fan_Bp_bar (Shape: 1 x 26)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 26;
const float L1_fan_Bp_bar_data[] = {
  2.54925281e-01f, 1.73354506e-01f, 1.19517803e-01f, 1.06111668e-01f, 8.97744671e-02f, 1.49685413e-01f, 3.49585682e-01f, 2.43911088e-01f, 2.35932186e-01f, 9.83179435e-02f,
  2.08627075e-01f, 8.34389031e-02f, 2.77251154e-01f, 1.13857903e-01f, 1.52578712e-01f, -1.08808100e-01f, 1.62647513e-03f, 7.26577491e-02f, 2.09681168e-01f, 2.12390691e-01f,
  2.63474286e-02f, 9.87906232e-02f, 7.95392469e-02f, 3.04311633e-01f, 2.24362850e-01f, 1.72800124e-01f
};

// L2_linear_W (Shape: 12 x 128)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 128;
const float L2_linear_W_data[] = {
  -6.56332374e-02f, 1.01779640e-01f, 1.78161427e-01f, -9.86553207e-02f, -3.62228841e-01f, 2.69498914e-01f, 4.65989336e-02f, 5.98284453e-02f, -4.96510118e-02f, 1.92282849e-03f,
  -2.41470993e-01f, -3.45584527e-02f, -1.11151099e-01f, -9.64472890e-02f, -1.20420933e-01f, -1.79438397e-01f, -7.37911463e-02f, -3.64846289e-01f, 1.11114971e-01f, -8.85590240e-02f,
  -9.98031870e-02f, -1.77382633e-01f, -5.90404756e-02f, -2.27897152e-01f, -3.93348038e-01f, -1.48598909e-01f, -1.89239502e-01f, -1.50478378e-01f, -9.54726413e-02f, -1.65077463e-01f,
  5.02680056e-02f, -1.57933831e-02f, -1.79490417e-01f, -1.17920659e-01f, 1.79456407e-03f, -2.18088195e-01f, -4.37589772e-02f, -1.24165393e-01f, 1.21984467e-01f, -1.49842158e-01f,
  -9.70000923e-02f, -1.39395177e-01f, 1.20579503e-01f, 5.03552407e-02f, -8.17869529e-02f, -1.52145490e-01f, 7.58683160e-02f, -2.03600541e-01f, -9.33159217e-02f, 3.92346084e-02f,
  -2.31974751e-01f, 2.34177589e-01f, -4.12192374e-01f, -1.09062299e-01f, 2.33497560e-01f, -1.29143270e-02f, 2.21105199e-02f, -2.80997187e-01f, 8.10849890e-02f, -1.09322868e-01f,
  -2.88494349e-01f, 1.28812939e-02f, -1.85181305e-01f, -2.37293124e-01f, 2.45338872e-01f, 3.54927599e-01f, -5.80860600e-02f, -1.21625528e-01f, 1.42648056e-01f, 2.04277784e-01f,
  2.51900047e-01f, 3.08623642e-01f, -2.91728407e-01f, 1.60414562e-01f, -7.08533823e-02f, 1.20194063e-01f, -1.93996325e-01f, 2.55069971e-01f, -1.29570588e-01f, 5.67160882e-02f,
  3.08815688e-01f, -1.45997852e-01f, 2.71073878e-02f, 9.31005999e-02f, 7.48250261e-02f, 1.17206722e-02f, -8.55409727e-02f, -8.27248618e-02f, -6.44400194e-02f, 3.16287838e-02f,
  2.34395400e-01f, 4.71634977e-02f, 1.42998576e-01f, 1.18486904e-01f, -1.33305490e-01f, -3.11003834e-01f, -1.02023862e-01f, -2.32531175e-01f, 5.15160151e-02f, 2.53361296e-02f,
  2.89901048e-02f, 9.39024612e-02f, 9.38455239e-02f, 1.43905371e-01f, -2.70724803e-01f, -2.67158565e-03f, -3.14596534e-01f, -1.91265479e-01f, -3.28306288e-01f, 1.83424745e-02f,
  -2.97654927e-01f, 1.69183686e-02f, -1.85537055e-01f, -1.78588144e-02f, -1.94261447e-01f, 7.64506236e-02f, 9.69815329e-02f, 1.21369563e-01f, -2.04455853e-01f, 1.85049400e-01f,
  1.92218229e-01f, 8.57757255e-02f, 8.96482468e-02f, -7.54691660e-02f, -5.26811481e-01f, 3.22902538e-02f, -3.60643566e-02f, -2.27358893e-01f, -1.08157009e-01f, -1.43144459e-01f,
  -3.30754638e-01f, 8.88384655e-02f, -3.08768183e-01f, -3.30068246e-02f, -1.85711816e-01f, -5.22107296e-02f, -1.32200867e-01f, -1.14659891e-01f, 1.43286899e-01f, -3.28785144e-02f,
  1.65851444e-01f, 2.10357279e-01f, 1.09069072e-01f, 1.55243173e-01f, -1.50244266e-01f, -2.36821115e-01f, -1.25923857e-01f, 2.32177284e-02f, -9.59546566e-02f, -8.46376270e-03f,
  -1.57881398e-02f, -1.83650047e-01f, -1.98069856e-01f, 2.56384194e-01f, -5.49493078e-03f, 8.88695270e-02f, 5.96709829e-03f, -8.49823728e-02f, 6.16263971e-02f, 2.95642274e-03f,
  -2.07878903e-01f, -4.46261019e-01f, -3.06362152e-01f, -1.52408734e-01f, -3.12041491e-01f, 1.80223271e-01f, -7.25087002e-02f, -5.12031838e-02f, -3.09025019e-01f, -1.81349054e-01f,
  1.84126601e-01f, 1.01098970e-01f, 1.67960554e-01f, 1.65232614e-01f, -3.09044123e-01f, -7.54484758e-02f, -3.13435607e-02f, -1.97154954e-01f, 7.14037642e-02f, -8.26516971e-02f,
  -2.15482429e-01f, -9.72581878e-02f, 3.06485236e-01f, 1.62459835e-01f, -3.60024691e-01f, -2.84269929e-01f, -1.38791516e-01f, 2.08252054e-02f, 1.44080172e-04f, -3.58231366e-02f,
  -1.35677397e-01f, 2.74673492e-01f, 4.89373691e-02f, 2.73589581e-01f, -9.38140228e-02f, 3.63140643e-01f, 9.49901063e-03f, 2.33385786e-01f, -1.63600579e-01f, 3.85394722e-01f,
  1.58201367e-01f, -6.97737858e-02f, -9.61258337e-02f, -2.82719731e-01f, 8.64191726e-02f, 1.21055461e-01f, -3.87624085e-01f, 2.50047266e-01f, 3.23427826e-01f, 2.77430918e-02f,
  -3.10275465e-01f, -3.56922567e-01f, 2.08707675e-01f, -1.21743135e-01f, -9.19581726e-02f, 9.79312137e-02f, -3.44357818e-01f, -1.55247673e-01f, -2.63256699e-01f, -8.36972892e-02f,
  1.03760343e-02f, -1.43270865e-01f, 3.42857242e-01f, -1.18134968e-01f, 6.10980093e-02f, 4.54419572e-03f, 1.80801019e-01f, 1.59546360e-01f, 4.82054502e-01f, 1.72915637e-01f,
  -5.19835532e-01f, 1.79004550e-01f, -2.32362449e-02f, -3.21566612e-02f, -1.69636667e-01f, 6.74769729e-02f, -6.24403916e-02f, -1.39203385e-01f, 1.44822907e-03f, 4.53998819e-02f,
  2.36310080e-01f, 2.36072928e-01f, -1.69651523e-01f, 1.42780855e-01f, 9.20326728e-03f, 2.18832746e-01f, -2.02337891e-01f, 5.01114488e-01f, -2.93158710e-01f, 1.24742337e-01f,
  -2.58238375e-01f, 2.81605367e-02f, -3.62577699e-02f, -6.11830115e-01f, -9.52625349e-02f, 1.49057627e-01f, -1.41157908e-02f, -4.28331830e-02f, 3.53856534e-02f, 1.44087955e-01f,
  -3.73400986e-01f, 2.85896268e-02f, -2.15612829e-01f, -1.96344718e-01f, -4.45442945e-02f, -8.54053721e-02f, 1.69191748e-01f, -2.36939490e-01f, 1.02059819e-01f, 3.34961675e-02f,
  -1.31827280e-01f, -1.10541031e-01f, -3.36885713e-02f, 2.81599835e-02f, -4.72172797e-01f, -6.68740869e-02f, 4.76766117e-02f, 1.16925471e-01f, 7.46221393e-02f, 2.58884251e-01f,
  6.06624708e-02f, -3.69011657e-03f, 1.05923414e-01f, 9.50071886e-02f, -2.27590173e-01f, -3.99883166e-02f, -1.53567091e-01f, -1.88435614e-01f, -1.15102984e-01f, 1.18400194e-02f,
  2.08545148e-01f, -3.88938598e-02f, 9.91552696e-02f, 7.06323013e-02f, -8.28674510e-02f, -9.16257948e-02f, -9.49076843e-03f, 1.43476069e-01f, -3.48127745e-02f, -7.60171860e-02f,
  -1.78136751e-01f, -1.53943583e-01f, 8.58486444e-02f, 6.97656348e-02f, 1.43823117e-01f, -1.29531650e-02f, 6.20990545e-02f, 2.29968786e-01f, -4.51500744e-01f, -2.12993652e-01f,
  2.01144829e-01f, -1.26919731e-01f, 1.58388168e-02f, -2.01749280e-01f, -2.26940408e-01f, -8.94853249e-02f, 4.50242370e-01f, -3.36753786e-01f, -1.86469719e-01f, 8.23370889e-02f,
  1.12641588e-01f, 2.30859637e-01f, 4.08194870e-01f, 9.29549187e-02f, 1.10860236e-01f, 3.01204342e-03f, -2.38948360e-01f, 7.21232640e-03f, -1.06565356e-01f, 1.26802132e-01f,
  1.20224074e-01f, 3.38837653e-01f, 2.80515999e-02f, -1.55386880e-01f, 3.64964008e-02f, 9.70179364e-02f, -2.89829165e-01f, -1.30997881e-01f, -2.53521025e-01f, -9.02091637e-02f,
  3.49545293e-02f, -3.21896464e-01f, 2.04290837e-01f, -2.05920532e-01f, 1.31048948e-01f, -9.88720432e-02f, -6.68582022e-02f, 3.04137588e-01f, -2.76757628e-01f, 6.62474632e-02f,
  4.73752059e-02f, 3.06637585e-01f, -2.52086252e-01f, -8.81722048e-02f, -8.70094299e-02f, 1.47245094e-01f, 6.31557032e-02f, 2.66889483e-01f, 5.48686944e-02f, 3.83984327e-01f,
  2.22980633e-01f, -1.44388661e-01f, 1.05897993e-01f, 3.34586948e-02f, 2.71013603e-02f, -3.78902733e-01f, -3.73307377e-01f, -2.51435071e-01f, -5.28137386e-01f, 1.45601586e-01f,
  -8.70620608e-02f, 1.46933496e-01f, -1.99885204e-01f, 6.33760616e-02f, 9.64827910e-02f, -3.24370325e-01f, 3.25139351e-02f, 1.40488416e-01f, -5.38285598e-02f, 2.85604298e-01f,
  -3.55020970e-01f, 2.05534309e-01f, -2.10945278e-01f, -2.09156498e-01f, -1.06257811e-01f, 6.82432652e-02f, -6.07114471e-03f, -3.26508433e-02f, -1.48977578e-01f, -2.38518208e-01f,
  -5.19604720e-02f, -5.29260524e-02f, -3.10790390e-02f, -2.71521658e-02f, -1.19524961e-03f, 7.79752582e-02f, -7.33435079e-02f, -2.20743176e-02f, 1.07796155e-01f, 1.67676702e-01f,
  -3.92561452e-03f, 1.03643164e-01f, -8.13928545e-02f, 9.18955058e-02f, -1.47028059e-01f, -2.63821989e-01f, -1.75324485e-01f, 5.04584797e-02f, 8.63278732e-02f, -1.41952068e-01f,
  4.83624451e-02f, 3.66557799e-02f, -6.04219399e-02f, 1.40589014e-01f, 2.28093848e-01f, -2.79131979e-01f, 2.16555566e-01f, 1.55994058e-01f, -5.89838764e-03f, 1.45877227e-01f,
  2.84996271e-01f, -2.14394122e-01f, 1.99347824e-01f, -1.95778385e-01f, -1.44295478e-02f, 1.13497805e-02f, -4.46602032e-02f, -1.30028322e-01f, -2.61326637e-02f, 2.72581339e-01f,
  4.60569113e-02f, -2.69382089e-01f, -2.49077529e-01f, -1.95557415e-01f, 1.19373597e-01f, -2.07141578e-01f, 1.18504547e-01f, 5.73802926e-02f, 1.34635255e-01f, 2.15270013e-01f,
  9.04529840e-02f, 1.02070265e-01f, 4.76495922e-01f, -1.55621007e-01f, 1.94418937e-01f, 2.12835267e-01f, 2.81665176e-01f, -5.20849414e-02f, 3.77129465e-01f, 2.81777829e-01f,
  1.81608856e-01f, -1.20262302e-01f, -1.80160820e-01f, -1.37881607e-01f, -2.22763628e-01f, -7.50407651e-02f, -2.97109812e-01f, 3.60871792e-01f, -1.32891387e-01f, 2.00888574e-01f,
  -6.76518157e-02f, -2.81858653e-01f, -2.06008807e-01f, 5.86747490e-02f, 1.06387399e-01f, -1.54813513e-01f, 1.73255354e-01f, 3.33397314e-02f, -3.39694858e-01f, 1.85198545e-01f,
  -1.47032663e-01f, -1.16915502e-01f, -3.52018714e-01f, -1.07121281e-01f, 1.48477316e-01f, -3.68585028e-02f, 6.13198504e-02f, 1.42990664e-01f, 1.52872846e-01f, -2.69933671e-01f,
  -2.47424275e-01f, 7.66489357e-02f, 1.70942441e-01f, 2.55881180e-03f, -5.37806869e-01f, -1.12783313e-01f, 1.39046848e-01f, -1.49213299e-01f, -2.65309453e-01f, -3.35723430e-01f,
  3.09341341e-01f, -3.84547949e-01f, -4.28948581e-01f, -5.34749568e-01f, -3.03401172e-01f, 3.37195881e-02f, 6.76450878e-02f, -3.76397252e-01f, -3.26403797e-01f, -1.07655905e-01f,
  8.77405405e-02f, 8.98412392e-02f, 2.88474977e-01f, -2.54865080e-01f, 5.01623675e-02f, -6.17383301e-01f, 1.06950924e-01f, 1.34091794e-01f, -1.36911729e-02f, 2.04630464e-01f,
  -2.99525797e-01f, 2.15390906e-01f, 1.50232539e-01f, -1.55678138e-01f, -3.05576712e-01f, -1.09828040e-01f, 2.31597766e-01f, -1.36335239e-01f, -5.42991087e-02f, 8.61823279e-03f,
  1.69672459e-01f, -3.26781981e-02f, -1.23190947e-01f, -1.34713780e-02f, -1.97688282e-01f, -1.64335221e-01f, 1.89971238e-01f, -3.16336960e-01f, 3.69821601e-02f, 4.33585197e-01f,
  -1.19977305e-02f, 1.25701800e-01f, 4.92189899e-02f, 2.78548181e-01f, 1.38691142e-01f, -2.67387647e-02f, 2.12762445e-01f, -1.95428386e-01f, 2.06660524e-01f, 2.92917546e-02f,
  1.41680732e-01f, 3.80626544e-02f, -2.62223750e-01f, 3.13283652e-01f, -1.61824957e-01f, -5.76882325e-02f, 4.25370783e-02f, 1.31106675e-01f, -1.82123750e-01f, 1.29513368e-01f,
  3.04241236e-02f, 3.02363068e-01f, 2.44306192e-01f, 1.03370063e-01f, 1.13274790e-01f, -7.13932887e-02f, 1.52675658e-01f, -1.49852023e-01f, -2.58696258e-01f, 2.39429753e-02f,
  1.66212112e-01f, 1.31271645e-01f, 3.35802436e-02f, -1.10927708e-01f, 3.77147049e-01f, 2.91021466e-01f, -2.24467441e-01f, 7.53025059e-03f, 8.51576626e-02f, 3.32326621e-01f,
  -1.30741566e-01f, 1.52946025e-01f, -1.34927854e-02f, 8.84674489e-02f, -1.00736506e-01f, 6.73798546e-02f, -3.98621589e-01f, -1.94369778e-01f, -1.09223709e-01f, -1.96175665e-01f,
  2.39506468e-01f, 3.04281656e-02f, 1.81486726e-01f, -3.57009619e-01f, -5.58168031e-02f, -3.36287707e-01f, -6.87387511e-02f, 1.14107676e-01f, -1.18166417e-01f, -1.37540579e-01f,
  1.07560098e-01f, -1.07874565e-01f, -1.87704027e-01f, -7.09240660e-02f, 9.33454707e-02f, 5.27864397e-02f, 2.80208271e-02f, 3.41401577e-01f, 3.03921223e-01f, -6.91370666e-02f,
  2.81545967e-01f, -4.75873426e-03f, 2.58697033e-01f, -9.26011652e-02f, 1.01158887e-01f, 2.23681867e-01f, -3.19902539e-01f, 2.40510687e-01f, -1.11548893e-01f, 3.78693372e-01f,
  1.74529627e-01f, 2.77580827e-01f, 2.46041536e-01f, -2.44087234e-01f, 8.78097340e-02f, -1.60819411e-01f, -3.64166200e-01f, -3.46133471e-01f, -5.84014714e-01f, -5.66666499e-02f,
  -1.02373801e-01f, -4.07297790e-01f, -1.49885818e-01f, 1.80513978e-01f, -2.42369607e-01f, 9.46097728e-03f, -1.83900476e-01f, 1.46469340e-01f, -1.40570477e-01f, -3.94382402e-02f,
  -2.15418264e-01f, -2.98088402e-01f, 1.69208825e-01f, -4.49999161e-02f, 2.07253948e-01f, 9.87333283e-02f, 5.04915603e-02f, 1.21198311e-01f, -3.95717323e-01f, -3.03151105e-02f,
  2.14280337e-01f, 1.38919741e-01f, 1.53232753e-01f, 1.75157085e-01f, 2.42232680e-01f, 1.58257514e-01f, 1.66666850e-01f, 1.50200620e-01f, 1.30180150e-01f, 1.20075040e-01f,
  -1.95168987e-01f, 2.49171838e-01f, 2.10358426e-01f, 1.20187048e-02f, 6.37685210e-02f, 1.97631717e-02f, 2.48506844e-01f, -2.99641222e-01f, -1.11054190e-01f, 9.73744318e-02f,
  1.12740457e-01f, -4.83460166e-02f, 1.55317247e-01f, 3.67795341e-02f, -7.81653672e-02f, 1.20948374e-01f, -6.42898083e-02f, 7.76156709e-02f, 9.61632133e-02f, -3.65043432e-01f,
  -3.45840007e-01f, 1.10289872e-01f, 3.08746010e-01f, 2.96233773e-01f, -1.52052969e-01f, 3.04787382e-02f, -8.95974264e-02f, 1.70697272e-01f, 1.71512559e-01f, 2.29512766e-01f,
  2.28436843e-01f, 1.47017390e-01f, -2.97562420e-01f, 1.09308906e-01f, 3.36576775e-02f, -5.34661077e-02f, 8.88558477e-02f, 9.14682634e-03f, 1.46054730e-01f, 1.16778836e-01f,
  -5.37957065e-02f, 2.79064715e-01f, 1.54571220e-01f, -2.05206200e-01f, -2.60925949e-01f, 1.94409378e-02f, 4.05541599e-01f, 2.40961671e-01f, 4.00498696e-02f, 6.90446943e-02f,
  -9.77288783e-02f, 2.31333196e-01f, -1.58562049e-01f, -2.21362665e-01f, 1.63174614e-01f, -4.02482033e-01f, -2.87213027e-01f, -3.33752245e-01f, -2.34324396e-01f, -3.49244893e-01f,
  2.85261363e-01f, -7.09089413e-02f, 1.74324185e-01f, 2.59550810e-02f, -2.10215092e-01f, 2.02443987e-01f, 1.84471726e-01f, 3.86650860e-01f, 9.57969800e-02f, -1.99394375e-02f,
  -1.31998315e-01f, -8.18030387e-02f, 1.10768288e-01f, -2.99191047e-02f, 1.29375786e-01f, -1.62321832e-02f, -3.54796350e-01f, -2.82640666e-01f, -5.78221567e-02f, -3.44940245e-01f,
  -5.45282587e-02f, -2.42017731e-01f, 1.41280308e-01f, -3.42720419e-01f, -2.73440123e-01f, 6.43161451e-03f, -1.56026915e-01f, -2.51007378e-01f, 1.94007099e-01f, 8.69901553e-02f,
  -7.64055252e-02f, -1.98071659e-01f, -5.89469150e-02f, -5.79861581e-01f, 3.04898709e-01f, 1.56559542e-01f, -2.65668213e-01f, 1.18205383e-01f, 3.55542809e-01f, -3.70144874e-01f,
  9.52539444e-02f, 4.58354736e-03f, -2.09950179e-01f, -1.82072580e-01f, 1.71264932e-01f, 8.36144164e-02f, 1.16377510e-01f, -1.42505959e-01f, -3.76551114e-02f, -2.55958140e-02f,
  -5.06979041e-02f, 5.62151410e-02f, -2.76738107e-02f, -1.75180957e-01f, -1.64290160e-01f, -4.70715821e-01f, 1.14785014e-02f, -7.63294920e-02f, 5.02757216e-03f, 1.09593719e-01f,
  1.39777750e-01f, -5.07361330e-02f, 5.09280451e-02f, 2.02282563e-01f, 9.97115597e-02f, 5.99341579e-02f, 3.75779010e-02f, 3.28729272e-01f, -1.13065049e-01f, 1.41473368e-01f,
  1.67773943e-02f, -1.93841998e-02f, 3.40289040e-03f, 1.79155707e-01f, 1.87860429e-01f, 1.52030572e-01f, 1.87940493e-01f, 8.64414647e-02f, 8.73459950e-02f, -1.39551684e-02f,
  -1.26552746e-01f, -3.53390157e-01f, 1.74856260e-01f, 2.19540879e-01f, -1.17093801e-01f, -2.09245399e-01f, 1.51738217e-02f, 3.55698317e-02f, 1.68792635e-01f, 9.76051092e-02f,
  1.76205918e-01f, 7.05838576e-02f, -1.30920738e-01f, 1.35646686e-01f, 1.07933559e-01f, -1.83207601e-01f, 3.21084946e-01f, 1.16173707e-01f, 5.53094074e-02f, -3.67577039e-02f,
  8.32554325e-02f, -1.07675232e-01f, 1.71647668e-01f, 1.06132135e-01f, 2.42221743e-01f, 9.59404632e-02f, -2.16485001e-02f, 1.01578766e-02f, -8.71561915e-02f, 5.16230106e-01f,
  2.13427097e-01f, -3.99116933e-01f, -1.74207941e-01f, 1.91374689e-01f, -2.26437207e-02f, -5.38347848e-02f, 1.61708429e-01f, 3.65866661e-01f, -1.55049816e-01f, -2.98255175e-01f,
  -1.07757501e-01f, 4.76210326e-01f, -2.52392024e-01f, -7.73200765e-02f, 1.28486648e-01f, 9.08816233e-03f, 1.84083194e-01f, 1.93722755e-01f, 1.03066482e-01f, -2.78370753e-02f,
  7.14048818e-02f, -4.39747095e-01f, -5.24554402e-02f, -8.38027969e-02f, 1.20656081e-01f, -1.96940899e-01f, -1.83219492e-01f, -4.42673266e-01f, 4.39892374e-02f, -8.82540420e-02f,
  -1.47080734e-01f, 2.51539707e-01f, -1.30393971e-02f, -4.05106321e-02f, 1.85310438e-01f, 2.79023767e-01f, 1.35834783e-01f, 4.49921861e-02f, -2.68218517e-01f, 1.91765912e-02f,
  -6.10922463e-02f, -2.07243130e-01f, 2.78305650e-01f, -1.30386561e-01f, 1.95971802e-01f, -7.59102553e-02f, -2.81743199e-01f, -1.84688419e-01f, 2.06061900e-01f, -5.65007515e-03f,
  2.45070923e-02f, 2.88249254e-01f, 1.56556576e-01f, 1.14245862e-01f, -3.67183611e-02f, 2.33026654e-01f, 1.42168012e-02f, 2.72187591e-01f, -2.51922101e-01f, -4.34532940e-01f,
  -1.88609004e-01f, 1.34622619e-01f, 2.45549724e-01f, -4.66561653e-02f, -5.79437673e-01f, -5.38643301e-01f, 5.19211181e-02f, -1.37395173e-01f, -1.24773137e-01f, 8.12814906e-02f,
  -6.38590038e-01f, -1.91754714e-01f, 5.28393276e-02f, 3.31634544e-02f, 2.39877209e-01f, 1.14694433e-02f, -1.28578832e-02f, -9.12428126e-02f, -1.19370520e-01f, 5.74555397e-02f,
  -6.85118735e-02f, -1.99870601e-01f, -5.22505939e-02f, 5.82071915e-02f, -1.74204707e-01f, -1.23861171e-01f, 2.88100541e-03f, -5.40456548e-02f, -6.42272681e-02f, -1.85573116e-01f,
  4.33638841e-02f, -1.13164142e-01f, -3.91313136e-02f, 2.13733837e-02f, 2.08669469e-01f, -1.48503944e-01f, -1.05837565e-02f, 5.12484424e-02f, -1.32554471e-01f, -9.93500948e-02f,
  -1.47111341e-01f, -3.12131047e-02f, -1.52821973e-01f, -7.61168152e-02f, -2.24950239e-01f, 2.67188460e-01f, -3.31566148e-02f, 9.10245255e-02f, -2.15594709e-01f, -2.28437364e-01f,
  -7.99061134e-02f, -5.23199998e-02f, -1.65297672e-01f, 1.44733489e-01f, -2.03342307e-02f, -1.79202408e-01f, -9.93857533e-02f, -3.50531429e-01f, -2.67540496e-02f, 1.31381094e-01f,
  6.01165965e-02f, -3.21893245e-01f, 9.06372368e-02f, 1.62415922e-01f, 7.56665692e-02f, -1.25500932e-01f, -3.28572420e-03f, -2.32769519e-01f, -1.46305025e-01f, 7.75090456e-02f,
  -9.76894200e-02f, -7.11546838e-02f, 1.28694743e-01f, 3.59938666e-02f, -8.06144029e-02f, -1.89591676e-01f, 1.12385519e-01f, -9.26439278e-03f, -1.68243945e-01f, 2.76382044e-02f,
  -1.10372622e-03f, -3.74407560e-01f, 6.01984672e-02f, -2.89630115e-01f, 1.29294276e-01f, 1.04840733e-01f, 1.38258673e-02f, 1.94056615e-01f, 3.57425585e-02f, 1.06927276e-01f,
  2.18931079e-01f, -2.18075722e-01f, 1.84757337e-01f, -9.17085484e-02f, 3.73172835e-02f, 9.10030007e-02f, -1.79679915e-02f, 1.95301056e-01f, 3.80236357e-01f, 1.33346990e-01f,
  -1.18063465e-01f, -1.86270401e-01f, -3.76394652e-02f, 1.93694070e-01f, 1.15401395e-01f, 1.56528950e-01f, 1.93047374e-01f, 2.31139157e-02f, -1.70214325e-01f, 2.97577024e-01f,
  -1.29621953e-01f, 1.94801062e-01f, 3.08718920e-01f, -1.43317193e-01f, -1.44698694e-01f, -1.12749003e-01f, -2.86010414e-01f, -3.94226052e-02f, -5.90708815e-02f, -2.86003262e-01f,
  -2.88135350e-01f, -2.55962282e-01f, 3.52085203e-01f, -4.43871766e-02f, -2.98099108e-02f, 2.18672380e-01f, 1.25347063e-01f, 2.02154398e-01f, -2.85387218e-01f, -1.98095158e-01f,
  -1.74207419e-01f, 4.46297452e-02f, -2.12362111e-01f, -1.93629369e-01f, 2.85082638e-01f, -3.45818251e-02f, -5.09900868e-01f, -6.76429346e-02f, 8.35745856e-02f, -8.28010887e-02f,
  2.31195912e-01f, -4.76998426e-02f, -1.22464709e-02f, 1.09878868e-01f, -1.21590704e-01f, 1.33160979e-01f, 2.59366512e-01f, 4.21368191e-03f, 1.14453211e-01f, -1.40148895e-02f,
  2.56461084e-01f, -2.49367170e-02f, -1.19208116e-02f, -1.95591792e-01f, 1.63853541e-01f, -1.87891740e-02f, 4.72633727e-02f, 3.29855494e-02f, 9.78768524e-03f, -6.50942400e-02f,
  3.28500904e-02f, 1.74345687e-01f, 1.21382982e-01f, -5.43928444e-02f, 3.08601018e-02f, -7.94457793e-02f, -2.37416402e-02f, 7.76158646e-02f, 1.20105296e-01f, -9.84579772e-02f,
  5.94583973e-02f, -4.63640839e-02f, -8.06101337e-02f, 8.54804739e-02f, 2.22718090e-01f, 4.88349870e-02f, 1.68484643e-01f, 3.32975149e-01f, 2.86330491e-01f, 1.14613242e-01f,
  2.20729247e-01f, -1.21513717e-01f, 1.74633875e-01f, -1.55539662e-01f, 7.76763335e-02f, 1.56800270e-01f, -1.92267999e-01f, 2.64343619e-01f, -7.24426284e-02f, -4.05931696e-02f,
  3.57796880e-03f, 1.35122374e-01f, 4.53091897e-02f, -1.92486733e-01f, 1.40382543e-01f, -2.36115441e-01f, -1.43956795e-01f, -9.68753248e-02f, 1.74616650e-01f, -6.84287697e-02f,
  -3.51563364e-01f, 6.29773457e-03f, 2.54969865e-01f, 1.15987435e-01f, -2.77871847e-01f, -2.38583088e-01f, 4.61198658e-01f, 1.84489846e-01f, 3.23342294e-01f, 1.36149690e-01f,
  5.35228372e-01f, 3.19728613e-01f, 2.04533041e-01f, 1.34562790e-01f, 1.54189825e-01f, -1.35152906e-01f, 1.38271049e-01f, 1.92023620e-01f, 3.52704167e-01f, -4.58122268e-02f,
  3.80494207e-01f, -5.55288605e-03f, 2.07102895e-01f, 2.24323153e-01f, 1.45658909e-03f, 4.29094225e-01f, 3.32767546e-01f, 3.63282919e-01f, -2.45095715e-01f, -6.69575781e-02f,
  -2.03553811e-01f, 3.07806909e-01f, -7.68167302e-02f, 4.78025675e-01f, -2.16158137e-01f, -1.81205586e-01f, 1.92672297e-01f, -1.53222978e-01f, -1.91539049e-01f, -1.76743492e-01f,
  1.41842932e-01f, -1.45014450e-01f, -3.58129591e-01f, -1.42753404e-02f, -3.85755479e-01f, -2.54600942e-01f, -3.60780209e-01f, 5.26397824e-02f, -2.97057211e-01f, 2.42580101e-01f,
  1.02095753e-01f, -9.56839174e-02f, 4.84839119e-02f, 1.22022904e-01f, 2.93755710e-01f, -2.36656964e-01f, 3.02461147e-01f, -5.64950891e-02f, -3.95819247e-02f, -3.12016159e-01f,
  2.48161644e-01f, -8.17919299e-02f, 2.08449066e-01f, -3.02645266e-01f, -3.82253349e-01f, -9.08401906e-02f, -4.10570204e-01f, 2.46324435e-01f, -3.00905317e-01f, -4.42357868e-01f,
  9.81406793e-02f, 1.19138733e-02f, 5.32371253e-02f, -1.04114763e-01f, 1.70470208e-01f, -2.58642405e-01f, 7.55864158e-02f, -7.51685873e-02f, -1.12924329e-03f, 5.26372157e-02f,
  2.67733783e-02f, -1.83205768e-01f, 2.04197928e-01f, -3.31605285e-01f, 4.66850065e-02f, 2.70419642e-02f, 3.37222703e-02f, -2.11178400e-02f, 2.26516905e-03f, 7.18199909e-02f,
  2.13592514e-01f, -5.76507859e-02f, 3.10532171e-02f, -2.11370811e-01f, -1.80158675e-01f, 3.55626792e-01f, 1.06845237e-01f, -3.39866936e-01f, 8.56417231e-03f, 1.75439820e-01f,
  1.46248192e-01f, 9.38422419e-03f, 1.23288453e-01f, -2.30801836e-01f, 1.34562984e-01f, 1.50556862e-01f, 2.52693594e-01f, 2.11665556e-01f, -8.91351253e-02f, -3.81793886e-01f,
  -2.51640886e-01f, 1.06264800e-01f, -2.28898257e-01f, -2.07033306e-01f, 5.60598113e-02f, 2.36598719e-02f, -3.97035554e-02f, -3.51752043e-02f, -3.86292413e-02f, -1.07091494e-01f,
  5.65279685e-02f, -2.02640623e-01f, -8.26721713e-02f, -2.76051342e-01f, -2.74420325e-02f, 1.65487289e-01f, -1.97328016e-01f, -6.69590337e-03f, 3.86267900e-02f, -7.56049454e-02f,
  -3.45059991e-01f, -3.50404561e-01f, 2.45061591e-01f, 1.43454969e-01f, 6.86529055e-02f, -3.65089506e-01f, -2.46035770e-01f, -1.34361416e-01f, -1.77017495e-01f, -1.05804829e-02f,
  -1.50731280e-01f, -2.65194178e-01f, -1.34443089e-01f, 8.32029432e-02f, 2.50888973e-01f, -4.26899903e-02f, 2.26924330e-01f, -1.04242131e-01f, -3.21640402e-01f, -5.18276915e-02f,
  1.31526470e-01f, 1.32623866e-01f, -1.33733705e-01f, 1.85909286e-01f, -2.29330987e-01f, -4.38926488e-01f, -4.27669138e-02f, -3.24899226e-01f, -1.14962980e-01f, -1.52109310e-01f,
  1.09604923e-02f, -2.34380752e-01f, 3.20286810e-01f, 2.01126888e-01f, -9.14449468e-02f, 4.84797925e-01f, 3.62367839e-01f, 1.97831333e-01f, -1.12635270e-02f, 2.78557420e-01f,
  -2.64837831e-01f, -3.88860375e-01f, 1.30670324e-01f, 1.82664528e-01f, -6.01755269e-02f, -2.27404654e-01f, 2.90339381e-01f, 4.98479083e-02f, -5.71095385e-02f, -1.28309771e-01f,
  -9.36196893e-02f, 7.96779916e-02f, -4.89441901e-01f, -3.13835405e-02f, -2.58784950e-01f, -2.03521907e-01f, 1.76282331e-01f, -7.82234687e-03f, -5.67889333e-01f, -1.86750054e-01f,
  -3.35320324e-01f, -2.02124119e-01f, 9.53825414e-02f, -8.65918249e-02f, 1.62616476e-01f, -2.04171211e-01f, 1.10438444e-01f, 1.93296764e-02f, 4.80649412e-01f, -1.29926950e-01f,
  2.78091058e-02f, -1.73559606e-01f, 3.97578292e-02f, 2.42780279e-02f, 1.06825434e-01f, 7.73153454e-02f, -9.76534262e-02f, -7.56203309e-02f, -2.60207392e-02f, 1.99054092e-01f,
  4.61463444e-03f, 5.52986711e-02f, -1.97119698e-01f, -6.14596382e-02f, -7.23659620e-02f, 6.35953471e-02f, -7.60356709e-02f, -9.03545097e-02f, -9.48962662e-03f, 2.74585560e-02f,
  -2.66680062e-01f, 1.84329018e-01f, -1.36301294e-01f, -1.40599787e-01f, 5.47697805e-02f, 1.01202406e-01f, -1.10926472e-01f, -1.95332408e-01f, -2.44273603e-01f, -1.80413723e-01f,
  9.83266905e-02f, -6.04492761e-02f, 3.87450382e-02f, -1.53882265e-01f, -2.01370358e-01f, -2.80854609e-02f, 1.05948925e-01f, 2.99892556e-02f, -9.36364289e-03f, 6.63112998e-02f,
  -1.79051086e-01f, -1.46021545e-01f, 1.76800758e-01f, -3.84931266e-01f, -4.21321169e-02f, 6.68482035e-02f, 6.03517517e-02f, 4.55413722e-02f, -2.92828232e-01f, 3.74002233e-02f,
  -8.32342450e-03f, -2.48991698e-01f, 1.70365691e-01f, -1.78098902e-02f, 2.39719339e-02f, 1.03773102e-01f, -2.50977397e-01f, 2.51057625e-01f, -2.46502146e-01f, 1.41596526e-01f,
  -3.94227728e-02f, 2.72438109e-01f, 1.95341736e-01f, -2.65708834e-01f, -2.85413295e-01f, -2.57047653e-01f, 8.10590684e-02f, 2.17785999e-01f, 2.02329203e-01f, -1.52592391e-01f,
  -9.37835351e-02f, -2.02386111e-01f, -7.04186910e-04f, -2.25238666e-01f, -1.91467091e-01f, -8.30472261e-02f, -1.48967296e-01f, -2.89551616e-01f, 1.62811533e-01f, 2.75274385e-02f,
  -3.73725337e-03f, -2.93756843e-01f, 3.07859182e-01f, 8.38699862e-02f, 1.47338733e-01f, 1.00810550e-01f, 4.00563508e-01f, 3.39073181e-01f, -1.50950611e-01f, 4.07900989e-01f,
  -6.86131716e-02f, 4.80066091e-02f, 1.97501510e-01f, -1.10622451e-01f, -1.28445879e-01f, 3.35105002e-01f, -3.98853809e-01f, 2.82253563e-01f, -2.36430094e-01f, 9.42503586e-02f,
  2.19954699e-01f, -2.13209614e-02f, -4.96188939e-01f, -2.68071026e-01f, 1.66224644e-01f, 7.32302368e-02f, 3.06042135e-01f, 1.92739725e-01f, -2.51588196e-01f, -2.47468308e-01f,
  9.90123674e-02f, 1.22331111e-02f, 2.43120551e-01f, -2.86093086e-01f, 3.58381599e-01f, -5.32902658e-01f, -8.47903937e-02f, 2.63184190e-01f, -1.03069441e-02f, -2.77745202e-02f,
  -3.10080707e-01f, -6.11134648e-01f, 2.60926396e-01f, 3.11831688e-03f, 1.34776592e-01f, -3.39211702e-01f, -3.90573353e-01f, -4.90026534e-01f, -3.87178361e-02f, -1.86711788e-01f,
  7.60254487e-02f, -1.44587040e-01f, 1.33904204e-01f, -7.14708120e-02f, 1.09415725e-01f, -1.71542615e-01f, -1.38055650e-03f, 3.58411036e-02f, -8.80204737e-02f, 1.91015288e-01f,
  1.74068391e-01f, -5.79235330e-02f, 5.38160391e-02f, -7.73544535e-02f, 9.42238420e-02f, 3.51331122e-02f, 1.20783448e-01f, 1.76888742e-02f, -1.20257705e-01f, 1.46748111e-01f,
  8.86472836e-02f, 5.23679219e-02f, 1.15189694e-01f, 2.29424518e-02f, -5.62073365e-02f, 1.30876796e-02f, 9.35337096e-02f, 8.10283795e-02f, 9.70811546e-02f, 2.17507720e-01f,
  1.16032520e-02f, 1.22019105e-01f, -7.16854110e-02f, 1.32338481e-03f, 1.66123509e-01f, 1.65053785e-01f, 5.19694276e-02f, 2.47631639e-01f, 1.65610850e-01f, 1.16142385e-01f,
  9.04050544e-02f, 4.74328101e-02f, -1.32173553e-01f, 1.08296752e-01f, -1.45198286e-01f, -7.39488453e-02f, 2.12762859e-02f, 5.51308617e-02f, 7.17027336e-02f, -3.96868795e-01f,
  3.18172991e-01f, 2.03225061e-01f, -4.90638390e-02f, -2.72216946e-01f, 3.47338051e-01f, 1.04164243e-01f, 2.13595271e-01f, 1.33837521e-01f, -2.91878313e-01f, -2.00473651e-01f,
  3.11171204e-01f, -3.42483483e-02f, 5.62701114e-02f, 3.88862401e-01f, -4.13872331e-01f, 1.94936588e-01f, -3.37852567e-01f, -6.81127533e-02f, -3.31716061e-01f, -2.41034269e-01f,
  -5.08739129e-02f, 4.12088037e-01f, 4.94018719e-02f, -2.07884178e-01f, -1.76567584e-01f, -5.57738617e-02f, 3.80749553e-02f, -4.82703418e-01f, 3.97673607e-01f, -1.56838801e-02f,
  -2.83641279e-01f, 2.03326195e-01f, 9.82997641e-02f, -2.35979781e-01f, 2.18253285e-02f, 2.62207299e-01f, -7.82130808e-02f, -2.66293049e-01f, 6.35099784e-02f, 9.20450836e-02f,
  9.53965355e-03f, -1.69121847e-01f, 1.51009783e-01f, -3.09666395e-01f, 1.60486668e-01f, -1.83866397e-01f, 2.21368343e-01f, -6.76822215e-02f, -3.35341632e-01f, 3.28375250e-01f,
  3.49874437e-01f, -5.49190521e-01f, -4.18471515e-01f, -3.04066807e-01f, -2.68716604e-01f, -5.27479231e-01f, 2.26107314e-01f, 1.50155813e-01f, -3.11098129e-01f, -2.28923321e-01f,
  2.47460052e-01f, 1.61404938e-01f, -1.18386775e-01f, -1.85763165e-01f, 1.12038672e-01f, -2.10273609e-01f, 1.46568090e-01f, -2.88464837e-02f, 2.12090656e-01f, 9.42076668e-02f,
  -4.07885998e-01f, -2.45321915e-01f, -1.92705467e-01f, 3.60439152e-01f, -3.41544837e-01f, 2.34107092e-01f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  2.88225655e-02f, -8.71708840e-02f, -1.94879789e-02f, -1.55094579e-01f, 8.90626684e-02f, 2.08954476e-02f, 1.87740545e-03f, -8.07330236e-02f, 3.84972021e-02f, -2.31335517e-02f,
  -3.63378301e-02f, -3.11173461e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 51, 26
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        128, 51, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        128, 12
    );
    }
    