/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 3 x 120)
const int L0_fan_Wp_rows = 3;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  7.40477145e-01f, -1.67665273e-01f, -8.42353255e-02f, 3.96034718e-02f, 7.15783387e-02f, 6.18760996e-02f, 1.71859905e-01f, -1.62226379e-01f, 5.80294654e-02f, -1.59605309e-01f,
  -9.11605284e-02f, 9.65247601e-02f, -2.00783953e-01f, -2.38216102e-01f, 2.10525513e-01f, 1.26213836e-03f, 8.07828307e-02f, 8.55547786e-02f, -4.46435548e-02f, -6.83802296e-04f,
  6.73944950e-02f, -7.41180554e-02f, -1.70152679e-01f, -1.69268623e-01f, -1.35528237e-01f, 7.38251582e-02f, 7.17635825e-02f, -7.40052983e-02f, -1.37336493e-01f, -9.71766096e-03f,
  5.14173731e-02f, -1.00628749e-01f, -5.88695258e-02f, -2.99150273e-02f, -5.81136486e-03f, -2.70990245e-02f, 1.16473213e-01f, -4.27724309e-02f, -5.83240688e-02f, 3.81354243e-02f,
  5.29868901e-02f, -9.97217968e-02f, 8.79170559e-03f, 1.67618133e-02f, 5.55677451e-02f, -9.70997587e-02f, -2.85280179e-02f, -5.94914332e-02f, -2.35907659e-02f, 1.78212598e-02f,
  -1.82037838e-02f, -2.52532233e-02f, -3.99487503e-02f, 3.41348574e-02f, 1.74942315e-02f, -4.34255153e-02f, 8.28268826e-02f, 6.68517873e-02f, 7.53049776e-02f, 8.94483998e-02f,
  1.33961245e-01f, -2.29218975e-02f, 2.63042618e-02f, -5.72650731e-02f, -2.59297043e-02f, -1.69194899e-02f, -7.51228305e-04f, 4.56023961e-02f, 2.82568932e-02f, -9.82378423e-02f,
  1.46886948e-02f, -4.51763831e-02f, 1.45202959e-02f, 6.39032647e-02f, -4.58827317e-02f, 4.09440845e-02f, -7.23597920e-03f, 1.75337996e-02f, 1.22453809e-01f, 9.98995453e-03f,
  -3.51336487e-02f, 9.59855169e-02f, -5.37901632e-02f, 5.78924268e-02f, -4.57765814e-03f, 7.82206208e-02f, -5.36727943e-02f, -6.07102476e-02f, -5.15897907e-02f, -2.56849378e-02f,
  3.56988907e-02f, 3.77847478e-02f, -4.38435189e-02f, -4.92563322e-02f, 2.09771190e-02f, -4.72212695e-02f, 4.98155691e-02f, 8.57364237e-02f, 2.30093766e-03f, -1.17620043e-02f,
  4.45651729e-03f, -1.22548698e-03f, 5.16496561e-02f, 1.37492288e-02f, -3.25532369e-02f, -3.31259929e-02f, 1.81012403e-03f, 9.51949805e-02f, 1.55209363e-01f, -5.17132459e-03f,
  -5.32090515e-02f, 4.48340289e-02f, -3.07331011e-02f, 5.08485548e-02f, 5.15890680e-03f, 4.10680063e-02f, 7.90990517e-02f, 6.13420829e-02f, -2.67812852e-02f, 7.04232752e-02f,
  -4.21027899e-01f, 2.32827112e-01f, -1.70774832e-01f, 1.32611901e-01f, -2.62055248e-01f, 3.69982868e-02f, 3.29978578e-02f, -5.66388443e-02f, 4.52829227e-02f, 3.22622597e-01f,
  -8.94444808e-02f, 2.05921248e-01f, 1.84867997e-03f, 5.36080077e-02f, -1.73559099e-01f, 8.50562006e-03f, -1.46106526e-01f, 1.11709185e-01f, 8.35812911e-02f, -2.59344745e-02f,
  -4.50362451e-02f, 4.31878045e-02f, -1.30558640e-01f, -8.91403407e-02f, -1.85678359e-02f, 1.18538223e-01f, -4.69756126e-03f, 1.30681962e-01f, 6.23491332e-02f, 7.52863735e-02f,
  7.51410192e-03f, 7.00790435e-02f, -1.06248982e-01f, 6.14412315e-02f, -1.00747958e-01f, -7.89212470e-04f, 8.26101284e-03f, 1.70560256e-02f, 4.43348959e-02f, 8.34611803e-03f,
  -3.31064058e-03f, -7.44626746e-02f, 1.38881188e-02f, 8.31275135e-02f, 5.43218665e-02f, -6.65347800e-02f, -1.79569293e-02f, -6.93047121e-02f, -2.96353530e-02f, -6.29276186e-02f,
  -8.42722040e-03f, 1.07670240e-01f, -3.64677422e-02f, -7.88326934e-03f, -2.99429279e-02f, -4.09265375e-03f, 9.96262059e-02f, 7.40381628e-02f, 6.15271181e-02f, -4.82855886e-02f,
  4.46867533e-02f, -6.21393509e-02f, -7.55068883e-02f, -2.93662568e-04f, 3.12098544e-02f, -2.90680323e-02f, -1.19164726e-03f, -1.03731386e-01f, -6.19920082e-02f, -1.21894635e-01f,
  -5.02860732e-02f, 2.31019743e-02f, -4.94859507e-03f, 4.87337299e-02f, -4.76041399e-02f, 2.84829531e-02f, 4.42728214e-02f, -7.64649287e-02f, -3.62697057e-02f, -4.86285836e-02f,
  -6.87497482e-02f, 3.51021960e-02f, -3.30261923e-02f, 6.46944717e-02f, -8.63042921e-02f, 5.92444316e-02f, 1.99333671e-02f, -4.20460254e-02f, -2.11208928e-02f, 4.37216014e-02f,
  1.00118816e-01f, 1.70277148e-01f, -3.04042641e-02f, -2.03944538e-02f, 5.74208163e-02f, -1.34289369e-01f, 1.19308745e-02f, 2.08379049e-02f, 5.46753407e-03f, -8.26253444e-02f,
  4.30725403e-02f, -1.47258081e-02f, 1.11592568e-01f, 1.04788810e-01f, 2.24486608e-02f, 4.71164323e-02f, 1.03170477e-01f, 4.50146273e-02f, 6.25833198e-02f, -6.34923577e-02f,
  6.25110604e-03f, -1.17783666e-01f, 4.77798991e-02f, 1.92910329e-01f, -2.04361770e-02f, -1.01159988e-02f, 5.92619628e-02f, 8.78741443e-02f, -3.61118950e-02f, 1.50511470e-02f,
  1.08771197e-01f, -1.48435339e-01f, -1.42905712e-01f, -1.15147522e-02f, 8.56411755e-02f, 2.29303703e-01f, 3.39175105e-01f, -1.29668176e-01f, 4.38285768e-02f, 1.43175244e-01f,
  1.79304481e-01f, 1.75202638e-01f, 4.59951013e-02f, 8.66430700e-02f, 1.29795223e-01f, -9.10555571e-02f, -4.54986244e-02f, 8.10049176e-02f, 2.08878964e-02f, 6.47924542e-02f,
  -2.89915763e-02f, 1.05362602e-01f, -3.84251811e-02f, 4.99956831e-02f, 6.06044978e-02f, -1.13071932e-03f, -1.35190070e-01f, 1.30689979e-01f, 7.15297088e-02f, 9.75976959e-02f,
  8.07219669e-02f, -3.09516769e-02f, -1.68918326e-01f, -5.37180435e-03f, -7.27867484e-02f, -2.20600516e-02f, 3.29766534e-02f, 6.58826381e-02f, 1.16883084e-01f, -4.87045869e-02f,
  -9.14502889e-02f, -1.36931275e-03f, -7.99057633e-02f, -9.48187783e-02f, 3.36174318e-03f, -7.43496343e-02f, -4.41633537e-02f, -1.24268159e-01f, -2.45476291e-02f, 1.33195668e-02f,
  6.32683048e-03f, -7.40295872e-02f, -2.63706669e-02f, 6.36051148e-02f, -7.74477571e-02f, -1.24332033e-01f, 1.28452631e-03f, -2.37618089e-02f, -3.62954214e-02f, -3.90987396e-02f,
  -6.43295124e-02f, 8.54252726e-02f, 6.30103983e-03f, 3.06511857e-02f, 1.05754942e-01f, 2.40812581e-02f, -3.06305587e-02f, 1.51057253e-02f, 3.20899859e-02f, 5.50254956e-02f,
  3.29580866e-02f, -6.94105774e-02f, 5.76138012e-02f, 7.38952160e-02f, -1.86846708e-04f, -3.07336636e-02f, -5.84110338e-03f, 9.78385732e-02f, 4.23923098e-02f, 4.14562933e-02f,
  -1.09409131e-02f, 4.11589444e-02f, 2.64501795e-02f, -6.71665594e-02f, 8.85921493e-02f, -1.24845607e-03f, -4.22186330e-02f, 7.15094618e-03f, 5.73569126e-02f, -4.10417691e-02f,
  1.33584719e-02f, 7.24118501e-02f, 6.37973547e-02f, 1.86746642e-02f, 7.60590285e-02f, 6.47027344e-02f, 2.43847407e-02f, -9.22483578e-02f, -3.79286557e-02f, 1.60016548e-02f,
  -1.18274568e-02f, -3.13662626e-02f, -6.91992417e-02f, -8.56576487e-02f, -5.27565973e-03f, 3.60435583e-02f, 1.20531179e-01f, 6.76512942e-02f, -3.25314999e-02f, -2.92592105e-02f,
  4.30182293e-02f, -3.31182331e-02f, 5.99397719e-02f, -9.06029195e-02f, 9.05980915e-03f, 4.34347838e-02f, 4.42031585e-03f, -1.98855158e-02f, 1.95828266e-02f, -5.08013703e-02f
};

// L0_fan_Wp_bar (Shape: 10 x 120)
const int L0_fan_Wp_bar_rows = 10;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -1.16830274e-01f, -5.94810843e-02f, -5.70577264e-01f, 1.71749145e-01f, 1.14585117e-01f, 2.23896988e-02f, 1.83515120e-02f, 6.61385059e-02f, -3.65355045e-01f, 2.84727693e-01f,
  2.58700490e-01f, -1.83858141e-01f, -1.42805785e-01f, 4.67216790e-01f, 2.26037547e-01f, -1.39393106e-01f, 4.19552684e-01f, 1.42574549e-01f, -1.05346583e-01f, 4.67399172e-02f,
  -3.15003619e-02f, 4.69423801e-01f, -1.05913514e-02f, 2.15509355e-01f, 6.89017102e-02f, -1.61848068e-01f, 4.16805238e-01f, -2.10541576e-01f, 5.02688587e-01f, 1.42054036e-01f,
  1.37754641e-02f, -1.40961006e-01f, 3.28641683e-02f, -1.61679849e-01f, 1.30557390e-02f, -4.45630737e-02f, -1.89060662e-02f, 3.18286289e-03f, -7.40686506e-02f, 4.89744805e-02f,
  -6.01331517e-02f, 2.68086940e-02f, -6.09075055e-02f, 1.72252301e-03f, 2.59372704e-02f, 4.12572399e-02f, -2.83453427e-02f, -9.65538472e-02f, -7.54317120e-02f, 3.40114720e-02f,
  -1.03186972e-01f, 3.20790820e-02f, -7.51260994e-03f, -1.71917602e-02f, -3.85026820e-02f, 3.00341379e-02f, -8.30678456e-03f, 4.51307162e-04f, 6.03554845e-02f, -1.52417980e-02f,
  6.33953512e-02f, -2.10912362e-01f, 4.56556231e-02f, 2.98570637e-02f, 2.37660613e-02f, 1.13072850e-01f, 4.13389727e-02f, 1.33929074e-01f, -2.63653899e-04f, 1.72950268e-01f,
  -4.40378487e-03f, 3.02082263e-02f, 1.93094146e-02f, -1.26942433e-02f, -5.36957942e-02f, -2.90988758e-02f, -2.06046715e-01f, 1.39589965e-01f, -5.21031953e-02f, 1.32454678e-01f,
  3.75603698e-02f, -5.88531792e-02f, -1.55983334e-02f, 7.25032464e-02f, 3.70909348e-02f, -2.46906225e-02f, 9.69977975e-02f, -1.05926268e-01f, 3.19174603e-02f, -2.92889006e-03f,
  1.07248425e-01f, -6.19913824e-03f, -6.64422661e-02f, 3.35570946e-02f, 7.50035420e-02f, 2.25890111e-02f, -4.83934879e-02f, 1.39715429e-02f, -6.40138239e-02f, -1.22836329e-01f,
  -7.14957193e-02f, -2.53886580e-02f, -3.71899828e-02f, 2.91825868e-02f, 1.50126591e-02f, 1.99872646e-02f, -6.06447924e-03f, 1.54172452e-02f, 1.05629668e-01f, 9.00597051e-02f,
  6.24227375e-02f, 4.76737656e-02f, -2.13522427e-02f, -4.24694124e-04f, 1.36993617e-01f, -4.91286218e-02f, 9.60819125e-02f, -8.14157203e-02f, 9.80522111e-02f, -3.51373889e-02f,
  1.87161103e-01f, 4.02645797e-01f, 3.29464465e-01f, 7.31439069e-02f, -1.90711513e-01f, -2.31901735e-01f, -1.83769390e-01f, 2.02696159e-01f, -3.10524911e-01f, 2.82806456e-01f,
  -1.61843762e-01f, 3.94924819e-01f, -5.19726314e-02f, -9.47683975e-02f, -4.62444365e-01f, -3.94984901e-01f, -2.15817451e-01f, 2.81634480e-02f, -2.70722657e-01f, 2.15939432e-01f,
  2.32929504e-03f, -2.87398487e-01f, 1.42555565e-01f, -2.83594951e-02f, 2.75779426e-01f, 3.64853024e-01f, 1.96405441e-01f, 9.48385000e-02f, 3.45662922e-01f, -1.61124602e-01f,
  -2.52944201e-01f, -2.71922704e-02f, 2.13232011e-01f, -6.74446598e-02f, 7.06158504e-02f, 6.54808506e-02f, 2.01352879e-01f, -4.05450501e-02f, -4.38824180e-04f, -4.52805944e-02f,
  4.04224033e-03f, -5.39343692e-02f, -6.35392889e-02f, -1.66836664e-01f, 7.67412558e-02f, 1.43709719e-01f, -4.02100524e-03f, 1.21973142e-01f, 9.88094956e-02f, 1.24124661e-02f,
  7.82893598e-02f, 1.09921530e-01f, 3.11118420e-02f, 3.74245234e-02f, 5.57063445e-02f, 3.31597514e-02f, -5.72469160e-02f, 8.55372176e-02f, 1.31629333e-01f, 1.50380703e-02f,
  -6.89573959e-02f, 3.62251177e-02f, -3.04673184e-02f, 1.02817222e-01f, -1.39050372e-03f, -3.32226045e-02f, 3.52245122e-02f, -2.13757027e-02f, 8.57373327e-03f, 1.00296587e-02f,
  -1.20310104e-02f, 1.97084285e-02f, -1.08025379e-01f, 1.53972492e-01f, -7.27750435e-02f, 2.38679014e-02f, -3.14210868e-03f, 8.18922818e-02f, 3.61238644e-02f, 6.75031021e-02f,
  -8.49260613e-02f, 2.31378581e-02f, 1.29796162e-01f, -3.72257046e-02f, 1.40632838e-02f, 4.72789556e-02f, 2.10813936e-02f, 2.17744764e-02f, 1.24857835e-01f, 9.06239264e-03f,
  7.95819983e-02f, 1.40880302e-01f, -4.88475105e-03f, -1.34656742e-01f, -4.83532473e-02f, -8.76439735e-02f, -1.75219893e-01f, 3.25077437e-02f, 5.49234711e-02f, 5.85868349e-03f,
  5.95086180e-02f, -2.63144560e-02f, 2.44946871e-02f, -4.79057841e-02f, -9.85568687e-02f, -2.63576210e-02f, -1.57993753e-02f, 2.54575498e-02f, 1.06706470e-01f, 1.08313665e-01f,
  1.93360761e-01f, -3.58443782e-02f, -1.06048897e-01f, -1.22516491e-02f, -1.65889524e-02f, -1.42591763e-02f, -2.50746235e-02f, 6.15868047e-02f, -5.83645590e-02f, -6.67882413e-02f,
  5.66777438e-02f, -3.30162108e-01f, 1.93781164e-02f, -2.02453673e-01f, -5.05106449e-02f, -3.24321181e-01f, 5.22692613e-02f, -4.09123302e-01f, -2.95279026e-01f, -2.62530863e-01f,
  -1.71855446e-02f, 1.28010422e-01f, 2.98685193e-01f, -4.87690300e-01f, 6.97731376e-01f, 2.43401587e-01f, -3.72925550e-01f, -6.05332702e-02f, -9.72127169e-02f, -2.97972351e-01f,
  -3.90042216e-02f, -3.21451306e-01f, 2.23505542e-01f, -3.47245604e-01f, -1.67858586e-01f, -2.98023224e-01f, 3.36058795e-01f, 2.27090865e-02f, -1.29469022e-01f, 4.44736332e-02f,
  -4.77632023e-02f, 1.31035326e-02f, -5.94666740e-03f, 4.42131311e-02f, -7.09917322e-02f, 3.07074981e-03f, 5.21540865e-02f, 3.05971861e-01f, 3.31288390e-02f, -5.64764775e-02f,
  9.90722775e-02f, 8.08758289e-02f, -1.45210564e-01f, 4.38432060e-02f, -1.11637764e-01f, -6.85390458e-02f, -2.99707819e-02f, -1.25419684e-02f, -5.07288203e-02f, 1.20981611e-01f,
  -5.68374917e-02f, 1.12151511e-01f, -3.54732424e-02f, 1.04751974e-01f, -5.01775090e-03f, -1.00476757e-01f, -1.48766125e-02f, 1.11544840e-01f, 4.53761928e-02f, -1.73397154e-01f,
  -3.26633677e-02f, -6.23113960e-02f, 1.37734497e-02f, -4.27018851e-02f, -1.35213047e-01f, -6.97330981e-02f, 1.83000583e-02f, -5.05880117e-02f, -5.43732150e-03f, 4.51639704e-02f,
  -3.68969701e-02f, 2.68505514e-03f, -8.65067914e-02f, 7.14143040e-03f, -1.05035119e-01f, 6.15037046e-02f, 4.64581810e-02f, -1.89575888e-02f, -5.43087907e-02f, -3.50765255e-03f,
  7.39778280e-02f, -1.11907553e-02f, -2.77152434e-02f, 1.53096348e-01f, -3.72766443e-02f, 9.02773589e-02f, 1.26110332e-03f, -1.44345567e-01f, -6.77410141e-02f, 1.13011770e-01f,
  2.29938142e-02f, -7.55283535e-02f, -7.47590140e-02f, -4.11606021e-03f, 5.44314124e-02f, -7.24115893e-02f, -7.51172425e-03f, -2.18709037e-01f, 6.51740506e-02f, -3.17430981e-02f,
  -5.50591350e-02f, 4.09469008e-02f, 2.96079796e-02f, -5.46122603e-02f, 5.69806062e-02f, -1.37969404e-01f, 8.33993629e-02f, 7.57410750e-02f, -5.30280173e-02f, -3.20491642e-02f,
  6.69412315e-02f, 2.10518520e-02f, 1.80465296e-01f, -1.03564374e-01f, 7.38600641e-02f, 1.83237731e-01f, -6.80334494e-02f, 1.03312269e-01f, 8.52871686e-02f, 4.48142141e-02f,
  -5.85213937e-02f, 1.35936052e-01f, -3.67420733e-01f, 2.79727969e-02f, -4.61928099e-01f, 3.45686883e-01f, 4.99616623e-01f, -1.50887549e-01f, -5.43036200e-02f, 3.33543003e-01f,
  1.78112075e-01f, -8.70241001e-02f, 2.81053334e-01f, 4.29261327e-01f, -8.41705576e-02f, 5.14323592e-01f, 3.90400290e-01f, 3.59221995e-01f, -4.14709300e-02f, -1.16616841e-02f,
  -9.30048302e-02f, 3.36958319e-01f, 6.82156235e-02f, -1.44313112e-01f, -3.79239321e-02f, -2.21453279e-01f, -5.22146598e-02f, -1.25474453e-01f, -2.93640196e-02f, -3.00440583e-02f,
  8.54349732e-02f, -1.14343964e-01f, -9.79874283e-02f, -1.23153450e-02f, 1.85531117e-02f, -8.89868475e-03f, 2.07844302e-02f, 4.15505841e-02f, 1.05904229e-02f, 1.39255568e-01f,
  5.33631593e-02f, 1.30541688e-02f, 9.66676772e-02f, -1.62465468e-01f, -1.39811411e-01f, -8.06011856e-02f, -7.13650659e-02f, -4.98759039e-02f, -1.65502615e-02f, -8.42941552e-03f,
  -9.38052461e-02f, -9.09267664e-02f, -8.28412175e-02f, 1.12843281e-02f, -2.93318424e-02f, -6.61885217e-02f, -9.28194672e-02f, -1.08269632e-01f, -6.53790236e-02f, -1.36136487e-02f,
  8.28348193e-03f, -1.40510099e-02f, 6.85931817e-02f, -8.74959230e-02f, -1.13019027e-01f, -2.51764990e-02f, 7.95268193e-02f, 5.88641800e-02f, -5.80774527e-03f, 5.96433766e-02f,
  -4.47683083e-03f, -4.76307534e-02f, 3.98210585e-02f, -2.52591502e-02f, 9.25247073e-02f, -5.42432554e-02f, -8.14501895e-04f, 6.81603402e-02f, 3.46761197e-02f, -5.20604365e-02f,
  1.23714149e-01f, 6.65364787e-03f, 8.08123872e-02f, 9.50456336e-02f, 8.33161641e-04f, -8.80824775e-02f, 9.45934206e-02f, -1.46225179e-02f, 3.77188325e-02f, 3.64386365e-02f,
  1.39708936e-01f, -1.02891818e-01f, 4.89729494e-02f, -7.05425814e-02f, -5.58514334e-02f, -4.51842621e-02f, 3.26330997e-02f, 1.65319294e-02f, 1.61845647e-02f, 4.83675301e-02f,
  8.28788355e-02f, -2.27140542e-02f, -1.98800564e-02f, 3.83749083e-02f, -9.63479653e-02f, 5.68448938e-02f, 4.15840298e-02f, -8.11749995e-02f, 7.52861276e-02f, -8.52615684e-02f,
  -2.91040987e-02f, 2.74893418e-02f, 1.08703814e-01f, -6.43872917e-02f, -5.02237268e-02f, 4.06965502e-02f, -1.17222302e-01f, -6.16602541e-04f, 3.26440949e-03f, 1.38151810e-01f,
  -6.71346545e-01f, -3.17442277e-03f, -3.50088984e-01f, -3.14580977e-01f, 1.57259479e-01f, -3.93137425e-01f, -1.25449643e-01f, -3.42640420e-03f, -2.75179714e-01f, 1.78178519e-01f,
  1.20003700e-01f, -2.89676130e-01f, 2.40455374e-01f, -3.49923283e-01f, -4.83514011e-01f, -3.92566323e-02f, -4.86924261e-01f, -1.53413430e-01f, -1.80817530e-01f, 7.24633923e-04f,
  -2.38608241e-01f, 2.05336642e-02f, -3.40374321e-01f, 3.82242113e-01f, -1.47779092e-01f, 1.25632389e-02f, 3.59450638e-01f, 1.84142113e-01f, -1.00401305e-01f, -1.61723003e-01f,
  -6.21544570e-02f, 1.55126885e-01f, 3.58297043e-02f, -7.65449032e-02f, -7.95310084e-03f, 2.64479704e-02f, 2.70435140e-02f, -1.97745170e-02f, -4.87790350e-03f, 4.92008552e-02f,
  1.40614323e-02f, 7.69318342e-02f, -9.36320946e-02f, -4.85642850e-02f, -3.34235430e-02f, -1.88833028e-02f, -5.01528233e-02f, -8.75711739e-02f, -4.76618111e-02f, -6.41529560e-02f,
  -1.16924413e-01f, -1.14255130e-01f, 4.36930023e-02f, -1.81359481e-02f, -1.41588777e-01f, 9.93933063e-03f, -1.67213902e-02f, 4.64104163e-03f, -4.60677635e-04f, -1.15773246e-01f,
  -5.13328798e-02f, 2.39951443e-02f, 3.85824405e-03f, 4.35187891e-02f, -6.60201861e-03f, 1.90690625e-02f, -2.99248006e-02f, -5.24750678e-03f, -1.70830376e-02f, 6.25337660e-02f,
  -4.16920297e-02f, -9.91269201e-02f, 9.10377726e-02f, -4.26081792e-02f, -5.60538284e-02f, 3.46846953e-02f, -3.02663241e-02f, 1.46755263e-01f, -3.51579450e-02f, -7.07032308e-02f,
  2.10405458e-02f, -3.54389884e-02f, 1.02604769e-01f, 6.79955930e-02f, 5.77298813e-02f, -6.71422184e-02f, -4.87346016e-02f, -7.29125962e-02f, 4.59258119e-03f, 3.47896330e-02f,
  6.72247335e-02f, -9.51496698e-03f, -1.73789989e-02f, 5.36363944e-02f, -5.56140989e-02f, -5.30118309e-02f, -2.61545647e-02f, -1.51857838e-01f, -5.28353592e-03f, 6.85101524e-02f,
  -4.15061833e-03f, 1.93147529e-02f, -3.00531704e-02f, -5.03017269e-02f, -3.26496437e-02f, -2.35057306e-02f, 1.44480526e-01f, 3.90016176e-02f, -2.62285583e-02f, 3.12744975e-02f,
  5.05552664e-02f, -1.83736794e-02f, -1.30523965e-01f, 8.89082327e-02f, 2.58925110e-02f, 1.75930243e-02f, -2.59984247e-02f, 5.58048971e-02f, 4.67881709e-02f, -2.25991048e-02f,
  1.86952263e-01f, -4.77510989e-01f, 3.80786598e-01f, -2.89590750e-03f, 3.31235796e-01f, 2.36840501e-01f, 4.70340341e-01f, 1.41414125e-02f, -1.75306216e-01f, -3.06827396e-01f,
  1.18937781e-02f, -7.99453482e-02f, 1.39919668e-01f, -1.70296982e-01f, 3.99667710e-01f, 6.45378325e-03f, -1.10272706e-01f, -1.93556845e-01f, -5.70885688e-02f, -6.81262687e-02f,
  4.77687083e-02f, -1.27626762e-01f, 1.62638366e-01f, -1.21787839e-01f, 1.54221803e-01f, -4.56047878e-02f, 9.53517035e-02f, 1.84025526e-01f, -1.12623405e-02f, 4.12449799e-02f,
  -1.56659529e-01f, -1.39583096e-01f, -1.13367699e-01f, -1.25716373e-01f, -7.34647876e-03f, 8.92555043e-02f, 5.68155237e-02f, 4.82895076e-02f, -4.34658900e-02f, 1.44170031e-01f,
  4.74434458e-02f, -3.43567133e-02f, -7.46111497e-02f, 8.72537643e-02f, 1.05355652e-02f, 1.77299324e-02f, -3.08905542e-03f, 3.32869217e-02f, 1.29059739e-02f, -5.75978449e-03f,
  7.71398097e-02f, -1.11300580e-01f, 3.53273079e-02f, -3.59343514e-02f, -5.75792789e-02f, -4.10240591e-02f, 5.17257769e-03f, 7.93922134e-03f, 7.63497828e-03f, -1.03678152e-01f,
  -7.36081824e-02f, -9.04562511e-03f, 3.86385806e-02f, -3.42750140e-02f, -1.46457432e-02f, 1.05117206e-02f, 2.21574195e-02f, -4.72512767e-02f, -8.67121443e-02f, 4.15116362e-02f,
  -4.01986344e-03f, -3.38159055e-02f, 3.30550876e-03f, 2.31404267e-02f, -7.30683357e-02f, -1.19642250e-01f, -2.44773235e-02f, -2.27439264e-03f, 4.10157070e-03f, -3.35159041e-02f,
  1.29073888e-01f, -8.94558281e-02f, 1.52972899e-02f, 1.48316994e-01f, 5.97049668e-02f, 8.78646318e-03f, 5.85514754e-02f, -8.47697034e-02f, 5.82436360e-02f, 1.17329352e-01f,
  -4.40032721e-01f, -5.21978259e-01f, -3.29438336e-02f, -7.85568580e-02f, -5.29396161e-02f, -4.68884669e-02f, 9.10406709e-02f, -3.61942425e-02f, -4.59167287e-02f, 5.26035056e-02f,
  3.32011729e-02f, 1.10021576e-01f, 5.59838675e-03f, 6.71548322e-02f, -9.01146010e-02f, 4.68294434e-02f, -8.06002170e-02f, -1.30573586e-01f, -1.42436162e-01f, -8.34838375e-02f,
  -6.99927509e-02f, 5.18874042e-02f, 1.27740741e-01f, 1.56003023e-02f, -1.20544821e-01f, 1.88186206e-02f, 4.21068370e-02f, -1.16769724e-01f, 5.94426729e-02f, 4.54592556e-02f,
  -3.63739252e-01f, 1.36569748e-02f, -1.44944578e-01f, -5.79089224e-01f, -2.15680357e-02f, 8.21370408e-02f, -1.72120392e-01f, 2.17431393e-02f, -1.78659201e-01f, -7.98420161e-02f,
  -3.60583477e-02f, -7.43397772e-02f, 1.55678838e-01f, -7.99307302e-02f, 5.34280054e-02f, 1.53570473e-01f, -1.76369563e-01f, -1.02388702e-01f, 1.72987729e-01f, -2.64600635e-01f,
  -3.61418575e-02f, -2.65190035e-01f, 7.26771653e-02f, 3.34387682e-02f, -1.03722528e-01f, -1.47943899e-01f, -8.23824555e-02f, 9.62228328e-02f, -1.02862895e-01f, 2.07723677e-01f,
  -2.18848348e-01f, -4.65989381e-01f, -1.05033077e-01f, -7.01863021e-02f, -8.51195827e-02f, 1.58062547e-01f, -3.65065038e-02f, 1.75653026e-01f, -7.79341161e-02f, -1.18200397e-02f,
  1.27257621e-02f, -4.40073013e-02f, -6.54180124e-02f, 4.67223115e-02f, -1.95742599e-04f, -3.45981494e-02f, 2.08928045e-02f, -7.19796866e-02f, -4.26538400e-02f, 3.26700471e-02f,
  1.25709444e-01f, 2.53031999e-02f, -1.67228177e-01f, 7.59420311e-03f, 7.55434716e-03f, -3.65995429e-02f, 3.90452472e-03f, 4.70163301e-04f, -7.35302195e-02f, -2.79781893e-02f,
  1.51793510e-01f, 1.58862084e-01f, -4.31654640e-02f, 6.63587749e-02f, -5.23288874e-03f, -3.73351052e-02f, 2.84470264e-02f, 2.52839159e-02f, -8.92723054e-02f, -1.43590331e-01f,
  -1.51790366e-01f, -3.92552279e-02f, -8.76386911e-02f, -1.07176766e-01f, -8.20697844e-02f, -1.67025834e-01f, -1.85028603e-03f, -7.61748627e-02f, 2.82351319e-02f, 1.04295705e-02f,
  -2.94291582e-02f, 6.89773038e-02f, 2.69234218e-02f, -1.29713237e-01f, 1.96017865e-02f, 4.53311540e-02f, 1.13033362e-01f, 2.10916027e-02f, -5.51100299e-02f, -9.92842242e-02f,
  -4.01654869e-01f, -3.87046754e-01f, -5.78981489e-02f, -1.56481877e-01f, 2.65595410e-02f, 2.79237311e-02f, 1.85118705e-01f, 6.73548058e-02f, -4.24198136e-02f, -6.74479827e-02f,
  -5.76110519e-02f, -1.52249947e-01f, 5.39430827e-02f, 9.90552530e-02f, -5.63712008e-02f, 5.72993010e-02f, -4.65546735e-02f, 9.12275689e-04f, -9.47503299e-02f, -2.34140586e-02f,
  -9.23027694e-02f, -1.77275166e-02f, -2.78370921e-02f, -9.55104455e-02f, -1.90015193e-02f, -1.23243056e-01f, -3.85011248e-02f, 8.04895461e-02f, -6.46420270e-02f, 1.53970495e-02f,
  1.47782475e-01f, -3.27809751e-01f, -4.36926156e-01f, -7.06315041e-02f, 1.41285017e-01f, 2.09678188e-01f, -3.13145071e-02f, -5.66540509e-02f, -4.51637149e-01f, 4.38843183e-02f,
  1.16374739e-01f, -2.91837394e-01f, -3.02529752e-01f, -1.28463835e-01f, -2.03490362e-01f, -4.37585175e-01f, 7.75399432e-02f, -5.18849790e-02f, -2.50180840e-01f, 3.29475664e-02f,
  6.46101404e-03f, 2.45223746e-01f, -3.03765327e-01f, 2.64140725e-01f, 1.08372368e-01f, 4.09063734e-02f, 3.54054302e-01f, 8.63713492e-03f, 2.46385768e-01f, 1.53103650e-01f,
  -6.17353572e-03f, -1.31525934e-01f, -1.35816634e-01f, -6.43761978e-02f, 1.31770641e-01f, 2.81415462e-01f, 1.75566956e-01f, -3.92792094e-03f, -1.17091179e-01f, -1.09037630e-01f,
  -3.15870531e-03f, 1.15107894e-02f, 3.64992656e-02f, -4.66483124e-02f, 1.01079280e-02f, -7.77230412e-02f, -1.08073160e-01f, -1.14533314e-02f, -1.25763044e-01f, 4.57680710e-02f,
  -1.29910231e-01f, -5.04059866e-02f, 2.74170972e-02f, 4.28396724e-02f, -3.87843028e-02f, -7.47195184e-02f, 6.41272403e-03f, -4.14740294e-02f, 8.95867944e-02f, 1.58064067e-02f,
  1.51592791e-01f, 1.03763834e-01f, -1.34879023e-01f, -1.04072876e-01f, -9.65749398e-02f, 4.38169169e-04f, -2.49762461e-02f, 7.99569711e-02f, -1.04462020e-01f, -5.30529246e-02f,
  -7.06882961e-03f, -3.55602391e-02f, 3.35546993e-02f, 3.93604152e-02f, -2.52106506e-02f, 2.22298782e-02f, -2.60733422e-02f, 9.15167737e-04f, 4.03766073e-02f, -1.50072649e-01f,
  7.03065917e-02f, 2.04013418e-02f, -5.20013496e-02f, 9.16835666e-02f, 6.58521289e-03f, 1.74033716e-02f, 8.56328830e-02f, -2.54686512e-02f, -1.88978463e-01f, 1.16231985e-01f,
  6.92414306e-03f, 5.93212768e-02f, -8.20285603e-02f, -7.61489011e-03f, -6.21042103e-02f, 8.27317983e-02f, -6.14311658e-02f, 6.26089275e-02f, 7.45582059e-02f, -1.05502391e-02f,
  1.97296500e-01f, -5.08609274e-03f, 1.04965352e-01f, -2.10855249e-02f, -1.05986912e-02f, 1.17924161e-01f, 2.92180479e-02f, -1.52639216e-02f, 9.82122645e-02f, -1.21151647e-02f,
  1.11912966e-01f, 5.39511219e-02f, 8.59469026e-02f, -4.05272022e-02f, 7.24409744e-02f, 1.59690171e-01f, 2.16172151e-02f, 1.33835018e-01f, 1.19527251e-01f, -5.65538593e-02f,
  4.30909581e-02f, 1.33334428e-01f, 1.56709284e-01f, 4.54824686e-01f, -6.98890463e-02f, -5.80111504e-01f, -5.72993219e-01f, 2.02939957e-01f, -2.36689568e-01f, -8.23863000e-02f,
  2.01661214e-02f, -1.67656504e-02f, -8.68910775e-02f, 1.86980277e-01f, 3.42351288e-01f, -7.14726374e-02f, 1.61891013e-01f, -1.15290187e-01f, 2.18679532e-01f, 2.45902866e-01f,
  2.06086561e-01f, 3.24272275e-01f, 4.46216792e-01f, 2.81804919e-01f, 1.20868199e-01f, 2.79751122e-01f, 4.45141166e-01f, 2.86325184e-03f, 2.15402037e-01f, 8.82190093e-02f,
  -3.36628407e-01f, 6.95320740e-02f, 2.96574701e-02f, -1.21071629e-01f, -3.16089182e-03f, -1.59722447e-01f, -7.13395551e-02f, 2.97782663e-03f, -2.50996053e-02f, -6.42628297e-02f,
  1.56472102e-02f, -3.44212241e-02f, 1.21360406e-01f, -3.40503827e-02f, -9.92539451e-02f, 1.18406881e-02f, 6.98412582e-02f, -1.08166359e-01f, -3.97220850e-02f, -1.42088449e-02f,
  3.93899903e-03f, -2.66815014e-02f, -1.56669885e-01f, -4.82314937e-02f, -1.21156238e-02f, -1.75232112e-01f, -6.29581213e-02f, 1.24663949e-01f, -3.27231027e-02f, 1.11528650e-01f,
  5.42884953e-02f, -6.35364503e-02f, -5.75213619e-02f, 7.49685392e-02f, -1.47348896e-01f, -1.57334194e-01f, -5.67143373e-02f, 1.12490710e-02f, 3.90205570e-02f, 2.61493195e-02f,
  -5.32558858e-02f, 1.01062924e-01f, -2.69513857e-02f, -2.37766001e-02f, -2.87831854e-02f, -3.06321643e-02f, 1.14640445e-01f, -3.78442928e-02f, -6.86814338e-02f, 8.03208873e-02f,
  -7.28224218e-02f, 2.86393072e-02f, 2.00852100e-02f, -4.96578077e-03f, -4.32166979e-02f, 1.75378527e-02f, -1.54994950e-02f, -9.87389982e-02f, 8.38458464e-02f, 6.29489124e-02f,
  -1.74828604e-01f, 2.02990651e-01f, -2.17426717e-02f, -7.94459879e-02f, -4.30180086e-03f, 2.52448693e-02f, 2.57261191e-02f, 5.16727008e-02f, 1.72312949e-02f, -1.74183547e-02f,
  -8.22544694e-02f, -1.08681968e-03f, -3.53640281e-02f, -2.12774742e-02f, 5.81490248e-02f, -1.17665328e-01f, 5.43590039e-02f, 1.71812326e-02f, 2.43887696e-02f, 1.10804901e-01f,
  1.49064399e-02f, -4.77328040e-02f, -5.71134780e-03f, 6.27869517e-02f, 3.89604606e-02f, 1.28747814e-03f, 3.91147612e-03f, -1.16093278e-01f, 1.63954347e-01f, 4.38954197e-02f,
  1.87513590e-01f, -5.71354270e-01f, -3.82886231e-01f, 1.71162084e-01f, 2.26263583e-01f, 3.72702926e-02f, -1.53853327e-01f, 1.37552634e-01f, -1.45025536e-01f, -2.41559923e-01f,
  1.33254305e-01f, 9.80845839e-02f, -2.39731103e-01f, 2.66260713e-01f, 4.93201256e-01f, -5.44323444e-01f, 1.34130105e-01f, -3.17827910e-02f, -1.99064776e-01f, 9.11974907e-02f,
  2.23565504e-01f, 3.92624289e-01f, 4.68737781e-02f, 2.10339367e-01f, 2.33643368e-01f, -3.11415028e-02f, 1.29765317e-01f, 8.42915662e-03f, 4.36516017e-01f, 2.18450174e-01f,
  5.75603992e-02f, -8.01426023e-02f, -3.34598981e-02f, 1.58952460e-01f, -8.15163478e-02f, 2.33387426e-02f, -7.79136792e-02f, 1.24934077e-01f, 5.25348112e-02f, -6.04662858e-02f,
  -1.48449000e-02f, 1.05360366e-01f, 1.15451992e-01f, 8.03384334e-02f, 6.00729398e-02f, 6.63431883e-02f, -8.40974450e-02f, 4.96580191e-02f, -1.61371991e-01f, -1.02125697e-01f,
  -2.01513812e-01f, -8.29330459e-02f, -4.11431156e-02f, 6.80040743e-04f, -4.60141376e-02f, -7.68069252e-02f, -7.23024365e-03f, -5.53449541e-02f, -1.08838357e-01f, 5.55185750e-02f,
  3.72887924e-02f, 7.65156150e-02f, 2.60453559e-02f, 1.62538409e-01f, -3.48188961e-03f, -5.79796173e-02f, 5.58029190e-02f, -1.17173396e-01f, -8.98570642e-02f, 2.66080573e-02f,
  -1.19911447e-01f, 9.20613110e-02f, 6.11087009e-02f, 1.92302614e-02f, 3.40583250e-02f, -9.39785913e-02f, 6.63955212e-02f, 1.87590066e-02f, -6.23691380e-02f, -1.61379740e-01f,
  -1.63561665e-02f, 2.70001516e-02f, -7.72403367e-03f, -3.19615565e-02f, -4.29052301e-02f, 5.99776581e-02f, 4.37672921e-02f, -2.67391384e-04f, -5.22288643e-02f, 1.07897036e-02f,
  3.37380394e-02f, -1.07950300e-01f, -3.84927988e-02f, 3.30102332e-02f, -2.65649498e-01f, 3.09925340e-02f, -1.49467081e-01f, 2.24195682e-02f, -2.25400385e-02f, 4.25135531e-03f,
  9.55614820e-02f, 3.11148185e-02f, -7.87296891e-03f, 1.28196910e-01f, 4.40495871e-02f, -1.29137188e-01f, 1.05981909e-01f, -2.62244754e-02f, 5.97828701e-02f, -5.89078441e-02f,
  -6.16228208e-02f, -2.12180033e-01f, -9.15163606e-02f, 2.61545349e-02f, 3.59682702e-02f, -1.14182800e-01f, -6.09094091e-02f, -6.53284928e-03f, -1.18620023e-01f, -7.91809186e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 10)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 10;
const float L0_fan_Bp_bar_data[] = {
  2.19241381e-01f, 1.31399885e-01f, 3.79699878e-02f, 3.79336346e-03f, 3.66744846e-01f, 3.16728115e-01f, 2.55430549e-01f, -1.07255653e-02f, -2.82558296e-02f, 1.72649696e-01f
};

// L1_fan_Wp (Shape: 3 x 16)
const int L1_fan_Wp_rows = 3;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  -2.75147110e-01f, -1.84356168e-01f, -1.58226803e-01f, -5.93319893e-01f, 2.88057864e-01f, -4.23522770e-01f, -1.02807716e-01f, 8.98258910e-02f, -4.35516573e-02f, -6.57484680e-02f,
  -1.49383424e-02f, 1.56869348e-02f, 1.28377274e-01f, -4.23362017e-01f, 3.40284258e-01f, -1.29550099e-01f, -1.86172575e-01f, -1.51758064e-02f, 8.97526518e-02f, 1.34596482e-01f,
  -9.19843763e-02f, 5.22659943e-02f, -4.34562981e-01f, 2.36419171e-01f, 2.77372263e-02f, -3.02926630e-01f, -4.05614108e-01f, 2.87351549e-01f, -5.13875596e-02f, -4.55724835e-01f,
  1.24191649e-01f, -1.37366086e-01f, -1.81262329e-01f, -1.53430566e-01f, -6.29922077e-02f, -1.35697693e-01f, 1.20989382e-01f, -2.62924522e-01f, -7.94387087e-02f, 1.11653559e-01f,
  4.68522757e-02f, -4.70702618e-01f, 4.31615442e-01f, -3.32822949e-01f, 2.25102186e-01f, -3.73793185e-01f, 3.35258961e-01f, -1.57999303e-02f
};

// L1_fan_Wp_bar (Shape: 10 x 16)
const int L1_fan_Wp_bar_rows = 10;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  3.75301540e-01f, 2.50663102e-01f, 9.00934219e-01f, -5.05377769e-01f, 6.16089106e-01f, -1.87656105e-01f, 2.81291008e-01f, 4.49366868e-01f, -3.17057401e-01f, 4.15472209e-01f,
  5.07824957e-01f, -3.48969400e-02f, 2.42805883e-01f, 1.36115685e-01f, -3.75288457e-01f, -2.23865181e-01f, 5.44865668e-01f, 3.23899388e-01f, -3.27742398e-02f, 6.92547159e-03f,
  -3.44233185e-01f, -1.96519345e-01f, 4.58289266e-01f, 3.36174607e-01f, -3.24186355e-01f, -4.79905665e-01f, 1.19227141e-01f, -8.77127424e-02f, -4.35847223e-01f, 3.30115676e-01f,
  5.20890594e-01f, 6.12513065e-01f, 1.95814177e-01f, 2.72011280e-01f, -1.29772589e-01f, 7.62773097e-01f, -6.06858850e-01f, 2.63289958e-01f, 3.87151062e-01f, -1.20059341e-01f,
  7.02606499e-01f, -2.01090798e-01f, -4.16832805e-01f, 5.84151089e-01f, 2.37362146e-01f, 7.34190196e-02f, 4.09304500e-01f, 4.25589740e-01f, 4.05501187e-01f, 5.60586452e-01f,
  7.40223706e-01f, 6.79911375e-02f, 6.79261088e-01f, -2.21473947e-02f, 2.91829348e-01f, 4.15102273e-01f, -5.19724011e-01f, 4.37858492e-01f, 6.07700229e-01f, -6.53988346e-02f,
  2.42017969e-01f, 1.09330937e-02f, -4.94197428e-01f, -4.65344936e-01f, -8.73123631e-02f, 3.48815620e-01f, 1.70731112e-01f, -4.94605869e-01f, -1.98707178e-01f, 8.75499099e-02f,
  7.66297758e-01f, -1.25584304e-01f, 3.94615948e-01f, 2.41442874e-01f, 5.98333657e-01f, -2.02479035e-01f, 2.64017612e-01f, 2.47200459e-01f, 2.88697928e-01f, 3.26203167e-01f,
  4.23112035e-01f, 4.20861959e-01f, 3.75380218e-01f, 3.68694246e-01f, -2.72786319e-01f, 1.27345286e-02f, -3.30094457e-01f, -6.22429669e-01f, 4.49106216e-01f, -1.72179386e-01f,
  -9.14136767e-02f, 6.28063381e-01f, 2.94180781e-01f, -3.61487150e-01f, 9.49573889e-03f, 2.31831074e-02f, 3.41837823e-01f, 2.36420721e-01f, 5.00694513e-01f, -2.66217589e-01f,
  -3.87078792e-01f, -6.64954066e-01f, 1.05868571e-01f, 7.56821752e-01f, -5.63502550e-01f, -5.17902493e-01f, -2.56536245e-01f, 5.59125781e-01f, 4.16504592e-03f, 4.25082929e-02f,
  5.28839171e-01f, 1.53972536e-01f, 5.75806141e-01f, 1.83267310e-01f, 3.54437679e-01f, 1.71763346e-01f, 2.67434400e-02f, -1.14569001e-01f, 4.82282400e-01f, 3.43674541e-01f,
  -9.04423520e-02f, -1.71237707e-01f, 1.69728726e-01f, -4.42755729e-01f, -3.65057379e-01f, 6.62942767e-01f, -7.84683898e-02f, 7.05124080e-01f, 4.59263474e-01f, 5.71403205e-01f,
  5.04678011e-01f, 4.94504094e-01f, -1.10667288e-01f, 7.43135571e-01f, 1.31925032e-01f, -1.31010786e-01f, 7.11471215e-02f, 4.30295765e-01f, -3.56875241e-01f, 3.17298770e-01f,
  -2.71690302e-02f, -2.30574846e-01f, 1.08814180e-01f, 3.83318216e-01f, 6.87608644e-02f, 5.54873087e-02f, 3.20222646e-01f, -4.52829212e-01f, -1.20580733e-01f, 1.32210508e-01f,
  -1.21565526e-02f, -1.65692925e-01f, 4.74040508e-01f, -4.47079778e-01f, 2.91801542e-01f, 1.64172620e-01f, 7.50564456e-01f, -4.94298160e-01f, 4.88789022e-01f, 1.38588309e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 10)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 10;
const float L1_fan_Bp_bar_data[] = {
  6.53056681e-01f, 2.58625180e-01f, 3.66519570e-01f, 5.45555234e-01f, 1.02975212e-01f, 1.43365607e-01f, 3.45311254e-01f, -7.82906190e-02f, 5.95173240e-01f, 1.71125293e-01f
};

// L2_fan_Wp (Shape: 3 x 16)
const int L2_fan_Wp_rows = 3;
const int L2_fan_Wp_cols = 16;
const float L2_fan_Wp_data[] = {
  3.59127492e-01f, 3.10377002e-01f, 3.30647647e-01f, -3.51673849e-02f, 1.86901912e-01f, 1.89967260e-01f, -1.40277103e-01f, -2.03167871e-01f, 4.56290990e-02f, 6.16241479e-04f,
  -1.21073723e-01f, 2.76534647e-01f, -1.42669111e-01f, -4.90161553e-02f, 1.98510885e-01f, 2.86194921e-01f, 1.23071671e-01f, 1.89042643e-01f, 2.26737455e-01f, 4.99713458e-02f,
  -1.53265476e-01f, -1.19492881e-01f, -1.72911674e-01f, 8.15549642e-02f, 2.23670796e-01f, -2.95291036e-01f, 2.53809303e-01f, 2.94910520e-01f, 2.00205386e-01f, -3.74907613e-01f,
  4.87010591e-02f, 1.74661621e-01f, 2.45230317e-01f, -9.39822942e-02f, -3.25043827e-01f, 3.87638927e-01f, 2.38400102e-02f, 4.43430841e-01f, 2.35517304e-02f, -2.15150014e-01f,
  3.32959071e-02f, -2.10828573e-01f, 5.12829542e-01f, -5.13004251e-02f, -2.29120567e-01f, -3.86813790e-01f, -1.02358647e-01f, 4.07194704e-01f
};

// L2_fan_Wp_bar (Shape: 10 x 16)
const int L2_fan_Wp_bar_rows = 10;
const int L2_fan_Wp_bar_cols = 16;
const float L2_fan_Wp_bar_data[] = {
  -1.33124977e-01f, 1.55333921e-01f, 5.86467326e-01f, 7.58589685e-01f, 5.22983134e-01f, 4.53289747e-01f, 1.96360245e-01f, 1.51653379e-01f, -9.00433511e-02f, 4.20434251e-02f,
  -8.25866535e-02f, 6.80293217e-02f, 9.75946724e-01f, 2.77366012e-01f, -1.47987366e-01f, 2.39491891e-02f, 5.42933941e-01f, 4.30467427e-01f, 8.07908475e-01f, 4.44559127e-01f,
  2.17609137e-01f, 4.67145652e-01f, 8.16508114e-01f, 1.48219958e-01f, -3.12397033e-01f, 7.41010368e-01f, -2.80109793e-01f, 8.25167298e-02f, 6.15800202e-01f, -1.33124247e-01f,
  -2.00393736e-01f, 1.72174931e-01f, 1.58584073e-01f, 2.64201283e-01f, 3.32351327e-01f, -2.16720149e-01f, 3.35951485e-02f, 2.70930231e-01f, -1.54599220e-01f, 4.32024539e-01f,
  6.93181038e-01f, -2.07485855e-01f, -1.98000684e-01f, 7.31445074e-01f, 3.07838023e-01f, -7.82356262e-02f, 6.08776927e-01f, 5.13955116e-01f, 3.36679578e-01f, -1.95846841e-01f,
  -1.08836405e-01f, -8.89087796e-01f, -4.57272112e-01f, -7.81174302e-01f, 9.24386322e-01f, 2.22408175e-02f, -3.19881625e-02f, 8.46196175e-01f, 4.07618850e-01f, -1.23175032e-01f,
  -2.44858429e-01f, 5.42050064e-01f, 5.66621721e-01f, -6.09449625e-01f, 6.57576203e-01f, 6.62491977e-01f, 5.05973577e-01f, -3.53909701e-01f, 1.84257478e-01f, -4.31652784e-01f,
  2.54237622e-01f, -4.46706235e-01f, 5.86064994e-01f, 1.58169031e-01f, -1.94551319e-01f, 9.58055198e-01f, 2.56954521e-01f, -3.79870892e-01f, 7.10618794e-01f, 1.90093219e-01f,
  -2.72538126e-01f, -6.29285693e-01f, -1.38052821e-01f, -2.22342983e-01f, -1.68927014e-01f, 1.74723893e-01f, 4.02327597e-01f, 6.71597362e-01f, 2.11607050e-02f, 1.36136413e-01f,
  1.77359179e-01f, -6.63143992e-01f, 8.21484327e-02f, 5.69728792e-01f, -1.24767087e-01f, -1.20456509e-01f, 3.03929687e-01f, 2.45594054e-01f, -5.81301153e-01f, 5.54649949e-01f,
  -1.52871937e-01f, 8.39825809e-01f, 2.29097307e-01f, -3.36735360e-02f, 3.53208631e-01f, 3.39429289e-01f, 4.49381351e-01f, 2.74575561e-01f, -3.21817577e-01f, 1.48537248e-01f,
  -3.12204152e-01f, 5.86963892e-01f, 6.79689646e-02f, 3.15160573e-01f, -4.57566231e-01f, 6.01217091e-01f, -2.96210676e-01f, 7.40144789e-01f, 3.48665208e-01f, -1.94589674e-01f,
  1.50155768e-01f, 1.75454706e-01f, 7.56970167e-01f, 4.17762876e-01f, -2.75081009e-01f, -2.46312916e-01f, -1.82859704e-01f, 1.06839371e+00f, -3.65610383e-02f, -1.95710912e-01f,
  -5.62366903e-01f, -2.05872744e-01f, -2.08127126e-01f, 2.34589785e-01f, -3.90461981e-01f, -2.41105378e-01f, 2.15383530e-01f, -6.63754940e-02f, 2.15245560e-01f, 2.80696064e-01f,
  -5.82069993e-01f, 6.02852646e-03f, 5.24865985e-02f, 4.51798528e-01f, -2.65664816e-01f, -1.70973048e-01f, -3.12945731e-02f, 4.72549833e-02f, -3.89791161e-01f, -1.21631153e-01f,
  -3.77309561e-01f, 7.85842538e-01f, 8.48548293e-01f, -4.55556571e-01f, 3.31851989e-01f, 9.63406116e-02f, 7.00289905e-01f, 4.96853232e-01f, 4.42406446e-01f, 4.92137522e-02f
};

// L2_fan_Bp_bar (Shape: 1 x 10)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 10;
const float L2_fan_Bp_bar_data[] = {
  1.18822508e-01f, 5.82338691e-01f, 2.02106550e-01f, 6.62726641e-01f, 4.11823094e-01f, 4.93793823e-02f, 2.12328043e-02f, -1.05283760e-01f, 1.54124871e-01f, 1.36998460e-01f
};

// L3_fan_Wp (Shape: 3 x 16)
const int L3_fan_Wp_rows = 3;
const int L3_fan_Wp_cols = 16;
const float L3_fan_Wp_data[] = {
  3.16239893e-01f, -8.66843481e-03f, -2.98146755e-01f, -2.41678697e-03f, -1.55075833e-01f, -2.36238584e-01f, 1.01265118e-01f, 2.52892911e-01f, -4.87048179e-02f, -1.65600747e-01f,
  3.37115943e-01f, -4.61831689e-02f, -2.15415850e-01f, -2.21969649e-01f, 4.05914485e-02f, -1.24715731e-01f, 8.54342580e-02f, -2.12659433e-01f, -2.77864486e-01f, 1.49120465e-01f,
  9.68774185e-02f, 1.64207771e-01f, 8.73708501e-02f, 2.67144740e-01f, -1.86548010e-01f, 1.74369335e-01f, -6.29291460e-02f, 1.61506832e-01f, -2.88438916e-01f, 2.62887720e-02f,
  6.10484788e-03f, -6.95096403e-02f, 3.15010250e-01f, 5.32326363e-02f, 3.71410608e-01f, -2.61511207e-01f, 2.00812280e-01f, 3.95065099e-02f, -9.67610478e-02f, -1.96074650e-01f,
  -1.90047175e-02f, 1.42301679e-01f, -4.05338667e-02f, -1.11503182e-02f, -2.51694709e-01f, 1.90988287e-01f, -2.48069227e-01f, 2.80712277e-01f
};

// L3_fan_Wp_bar (Shape: 10 x 16)
const int L3_fan_Wp_bar_rows = 10;
const int L3_fan_Wp_bar_cols = 16;
const float L3_fan_Wp_bar_data[] = {
  2.04161610e-02f, -1.74462758e-02f, 1.04467385e-01f, 1.41646445e-01f, 2.65965313e-01f, 6.21279836e-01f, 6.02890611e-01f, 4.45808351e-01f, 4.72617537e-01f, -8.23877990e-01f,
  5.34435749e-01f, -1.14814736e-01f, 3.68879139e-01f, 3.98228556e-01f, 3.28767598e-01f, 3.19238119e-02f, 2.55652741e-02f, 3.04082721e-01f, 4.04388666e-01f, -6.72786891e-01f,
  -6.47970974e-01f, -4.38504219e-01f, -3.68099272e-01f, 3.27428073e-01f, -5.94285011e-01f, 1.01850367e+00f, 9.22717303e-02f, 3.66004109e-01f, 1.13636710e-01f, -4.33673859e-02f,
  4.91008647e-02f, -2.07797378e-01f, 2.35257864e-01f, 4.50284719e-01f, 1.47108331e-01f, 3.05823594e-01f, 3.92851442e-01f, -1.60853803e-01f, -6.76964760e-01f, -5.05234838e-01f,
  3.45174640e-01f, 5.97644925e-01f, 6.69707119e-01f, -5.86850233e-02f, -1.87215552e-01f, 1.47860363e-01f, -2.25584850e-01f, 3.85983169e-01f, -1.19480751e-01f, -4.82879877e-01f,
  6.42698258e-02f, 3.67543519e-01f, 2.77876288e-01f, -1.98654771e-01f, -5.49103796e-01f, -5.39038301e-01f, 5.53888857e-01f, -4.03376311e-01f, 6.49312675e-01f, -1.99560851e-01f,
  1.81586653e-01f, -3.71099524e-02f, 6.32513583e-01f, 1.21778674e-01f, 6.99456632e-01f, 4.00847077e-01f, 9.36876610e-02f, 5.68758011e-01f, 5.12635112e-01f, -1.20786153e-01f,
  5.50937474e-01f, 5.33857763e-01f, 7.14141309e-01f, -2.01005340e-01f, 7.47171402e-01f, -4.67892259e-01f, -3.83195788e-01f, -3.49396080e-01f, -4.28724438e-01f, 4.88075495e-01f,
  4.63477135e-01f, 4.01554197e-01f, -2.31006742e-01f, 3.60360146e-01f, 2.85553128e-01f, -7.12855399e-01f, 3.42963308e-01f, 8.41630995e-01f, -1.70561322e-03f, 6.38020992e-01f,
  5.17907381e-01f, -1.02782704e-01f, -7.37569809e-01f, -8.08576167e-01f, -5.82914531e-01f, -3.49509478e-01f, -3.21730852e-01f, -3.54505777e-01f, -4.05048639e-01f, 2.68327389e-02f,
  2.62247473e-01f, -6.30537868e-01f, 3.05530149e-02f, -1.71754640e-02f, 4.15140212e-01f, 9.63809267e-02f, -6.88814104e-01f, 5.14673471e-01f, 2.85552710e-01f, 1.32440791e-01f,
  6.69385612e-01f, 7.43569493e-01f, -4.46542427e-02f, -2.76798129e-01f, -1.65423080e-01f, 9.90027841e-03f, 2.71845788e-01f, -5.90079427e-01f, 8.07854891e-01f, 1.44909471e-01f,
  1.61271304e-01f, 1.62983999e-01f, -3.13053161e-01f, 6.01971924e-01f, -3.43621910e-01f, -8.04630935e-01f, -6.41735867e-02f, 8.00800085e-01f, -1.14165038e-01f, 1.11775629e-01f,
  -2.38734320e-01f, -1.70089379e-01f, 1.47765234e-01f, -7.19691932e-01f, 4.99565363e-01f, -1.03381217e-01f, 4.28191125e-01f, 4.90224421e-01f, 3.25978518e-01f, 2.23717943e-01f,
  -4.64433402e-01f, -8.35601151e-01f, -2.55964786e-01f, 6.65070534e-01f, 2.24766120e-01f, 2.84258407e-02f, 8.34732801e-02f, -4.31805968e-01f, -3.63047361e-01f, 4.56492722e-01f,
  6.31625891e-01f, 9.23161149e-01f, -2.20400617e-01f, 2.99448729e-01f, -1.85409591e-01f, 2.90085375e-01f, 1.02550936e+00f, 1.02485037e+00f, -2.13469759e-01f, 1.34053389e-02f
};

// L3_fan_Bp_bar (Shape: 1 x 10)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 10;
const float L3_fan_Bp_bar_data[] = {
  5.57666868e-02f, 4.97354329e-01f, 4.37194914e-01f, -7.96437934e-02f, 4.40433383e-01f, 4.98984963e-01f, -1.23874620e-01f, 3.44974138e-02f, 2.45061934e-01f, 3.85852396e-01f
};

// L4_linear_W (Shape: 12 x 16)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 16;
const float L4_linear_W_data[] = {
  -1.12731932e-02f, -1.26580060e-01f, 4.21702601e-02f, -4.46568042e-01f, 3.10728133e-01f, 5.26378870e-01f, -4.14471298e-01f, 4.66885418e-01f, 1.60156071e-01f, -1.24642991e-01f,
  -9.84414041e-01f, 2.86152601e-01f, -9.36827004e-01f, -6.60325348e-01f, -1.49389030e-03f, 1.91999093e-01f, -2.41821960e-01f, 4.98338550e-01f, -5.37404180e-01f, -4.51988488e-01f,
  -9.83343944e-02f, 1.18967734e-01f, -3.98047388e-01f, 5.12438178e-01f, 3.82068366e-01f, -1.82275578e-01f, -4.18890148e-01f, -2.92061806e-01f, 2.06704080e-01f, 1.67980269e-01f,
  3.16460997e-01f, -4.00540918e-01f, -1.48208097e-01f, -1.61235407e-01f, 2.01121211e-01f, -6.02887720e-02f, 3.21041077e-01f, 1.05284359e-02f, -6.39054179e-01f, -6.91122472e-01f,
  1.27404943e-01f, 2.21239537e-01f, 1.12869799e-01f, -8.32417130e-01f, 4.43854898e-01f, 3.66708636e-01f, 3.22384536e-01f, -4.04037684e-01f, -3.21870781e-02f, 3.73567581e-01f,
  1.24837980e-01f, 1.36597380e-01f, 1.97095275e-01f, -1.83432221e-01f, -1.10814638e-01f, 2.16937631e-01f, -8.59126985e-01f, -2.29829535e-01f, -6.48489058e-01f, -5.15398800e-01f,
  -2.66644150e-01f, -4.43633914e-01f, -5.94807982e-01f, 6.43948913e-01f, 2.93809861e-01f, 2.74422079e-01f, 2.48673931e-01f, 1.81297019e-01f, -4.51933220e-02f, -3.46311694e-03f,
  5.60719728e-01f, -3.23228598e-01f, -1.05142400e-01f, -4.98020053e-01f, 7.04600632e-01f, -7.48031288e-02f, -6.40482903e-01f, -3.32215667e-01f, -5.85387051e-01f, 3.74972463e-01f,
  1.57206565e-01f, 2.07513094e-01f, 3.67612511e-01f, 6.50112510e-01f, -1.01536229e-01f, -1.66125044e-01f, -7.04817832e-01f, 1.81189001e-01f, 3.88420761e-01f, -6.58326209e-01f,
  4.51453984e-01f, 6.42764032e-01f, -4.74487156e-01f, -6.71803653e-01f, 1.49841040e-01f, -4.63532865e-01f, -1.94900423e-01f, 2.61462957e-01f, 4.10683185e-01f, 2.90882856e-01f,
  -7.19969571e-01f, 1.25555456e-01f, -1.85701661e-02f, -1.05056441e+00f, 1.07313149e-01f, 1.72663212e-01f, 3.03175300e-01f, 5.42514265e-01f, -3.68358552e-01f, 2.89172322e-01f,
  2.82780439e-01f, -9.12701070e-01f, -7.21014962e-02f, -1.37002900e-01f, -1.97905704e-01f, -6.90084934e-01f, 9.34078172e-02f, -1.46064954e-02f, 3.73004317e-01f, -1.84945107e-01f,
  1.25286698e-01f, 3.50007355e-01f, -2.01111972e-01f, -5.45524597e-01f, 4.49468791e-01f, -3.80140431e-02f, -9.89350140e-01f, -4.13029678e-02f, 1.79789647e-01f, -1.60182163e-01f,
  -3.68032277e-01f, -9.10740420e-02f, 1.63322926e-01f, 3.83579254e-01f, 1.34367123e-01f, -4.16176349e-01f, -5.76736987e-01f, -4.57275420e-01f, 2.48024076e-01f, -5.20622194e-01f,
  4.00056213e-01f, 2.42594153e-01f, 1.38052911e-01f, 1.74918279e-01f, 2.79849142e-01f, -1.46842122e-01f, 1.05851889e-01f, 2.63956003e-02f, 4.03424427e-02f, -5.11663437e-01f,
  3.11489612e-01f, -4.70239818e-01f, 4.35293943e-01f, 5.79936326e-01f, 1.93617553e-01f, -4.09638703e-01f, -6.77057728e-02f, -5.51644683e-01f, -1.39554948e-01f, -8.12110841e-01f,
  8.64548460e-02f, -4.29811269e-01f, 3.21510255e-01f, -2.05533937e-01f, -1.03945799e-01f, -9.72345248e-02f, -7.58442879e-01f, 3.31343591e-01f, -1.04549527e+00f, 8.78102332e-03f,
  -8.73519659e-01f, 2.55219221e-01f, 4.24362212e-01f, 4.03436661e-01f, -1.73548255e-02f, 1.97355866e-01f, -4.48431790e-01f, -4.04093623e-01f, -1.52285429e-04f, 3.06466609e-01f,
  2.13574454e-01f, -1.67106688e-01f, 1.25474185e-01f, -4.12741154e-02f, -9.20800447e-01f, -2.05126062e-01f, 1.58724219e-01f, 3.33819538e-01f, -3.63909841e-01f, 3.26726764e-01f,
  2.08936036e-01f, 9.66806412e-02f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  -2.93070432e-02f, 2.34342158e-01f, -2.71372199e-01f, -4.25048098e-02f, 2.87226796e-01f, -9.26686153e-02f, -5.56416586e-02f, 1.21560946e-01f, -2.91238815e-01f, -2.75258183e-01f,
  -3.23821604e-01f, 7.81422406e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 3, 10
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 3, 10
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        16, 3, 10
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        16, 3, 10
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        16, 12
    );
    }
    