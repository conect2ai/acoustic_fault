/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 3 x 120)
const int L0_fan_Wp_rows = 3;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -7.25932345e-02f, 3.42271179e-01f, -1.49134919e-01f, -1.27198070e-01f, -1.51298061e-01f, 8.60547349e-02f, -3.47122177e-02f, 2.20777206e-02f, 6.32564053e-02f, 2.77363807e-01f,
  -4.55120616e-02f, 2.96010403e-03f, 1.12027623e-01f, 2.56061200e-02f, 9.31005366e-03f, 1.14699744e-01f, 6.70127496e-02f, 8.53137746e-02f, -3.40153426e-02f, 1.56356040e-02f,
  -8.45419541e-02f, 2.48249248e-02f, -1.28041118e-01f, -1.89528242e-02f, -1.21995233e-01f, -1.23611696e-01f, 4.14776281e-02f, -1.32790342e-01f, 4.24734838e-02f, -1.45138904e-01f,
  1.69890299e-02f, -9.35797244e-02f, -7.58946463e-02f, 4.59996499e-02f, 2.04121936e-02f, 1.64630357e-02f, 7.44754309e-03f, -8.80507156e-02f, -1.24693468e-01f, 1.78587008e-02f,
  9.30579752e-02f, -3.75382900e-02f, 1.23163033e-02f, -8.62813294e-02f, -5.05363420e-02f, -8.24314877e-02f, -3.43521405e-03f, -7.03564361e-02f, -5.14912382e-02f, -8.70592834e-04f,
  -1.82684325e-02f, -6.48395205e-03f, -6.22296184e-02f, -2.13695001e-02f, -3.43418494e-02f, -6.57784939e-02f, -2.20610891e-02f, -2.77582500e-02f, 3.92866321e-02f, -2.62424741e-02f,
  -5.34332618e-02f, 3.15613090e-03f, -5.29628200e-03f, -3.61750759e-02f, -5.90928867e-02f, -3.17883631e-03f, 2.08565481e-02f, -1.45806093e-02f, 4.83649317e-03f, 2.09347885e-02f,
  5.18563166e-02f, -2.14701872e-02f, 1.18635250e-02f, 3.02625578e-02f, 2.47787591e-02f, 5.17712459e-02f, -1.92326736e-02f, 9.77585092e-03f, 1.62846991e-03f, -9.01610255e-02f,
  1.80774461e-02f, 2.62331571e-02f, 4.86567207e-02f, -4.22135517e-02f, 1.90613773e-02f, -4.18768218e-03f, 7.28752762e-02f, 8.83395877e-03f, -4.86799069e-02f, -2.02014633e-02f,
  3.97228390e-01f, 3.55604023e-01f, -7.87953846e-03f, -3.93057428e-02f, 9.81433019e-02f, 3.36843841e-02f, 3.71800251e-02f, 6.71200082e-02f, 1.26110375e-01f, -2.54051778e-02f,
  -1.17745285e-03f, 1.61041766e-02f, 7.93538019e-02f, -4.27377000e-02f, 1.42900543e-02f, 5.69738671e-02f, 6.29885271e-02f, 1.03965878e-01f, 2.40984652e-02f, 6.24731630e-02f,
  6.81286678e-02f, 3.93584147e-02f, -3.30681503e-02f, -1.15121298e-01f, -2.00011861e-02f, 3.97702679e-02f, -2.49111652e-02f, 9.30484198e-03f, -1.53627116e-02f, 6.64853081e-02f,
  5.58552109e-02f, 1.46244675e-01f, 2.89054997e-02f, 6.86477423e-02f, 8.03591236e-02f, -3.68358582e-01f, -3.13735843e-01f, 1.49906531e-01f, 1.23273864e-01f, -1.11705042e-01f,
  -3.89842801e-02f, -4.34882455e-02f, -7.60583207e-02f, -8.85308832e-02f, -4.26606722e-02f, -1.61225453e-01f, -6.38034148e-03f, -1.38720661e-01f, 1.19627953e-01f, 8.36996734e-02f,
  8.75249729e-02f, -4.68359515e-02f, -1.19115575e-03f, 6.62051961e-02f, -3.24896872e-02f, 1.44017041e-01f, 1.47345617e-01f, -3.33982706e-02f, 1.17246531e-01f, -7.49372169e-02f,
  -2.22616389e-01f, 7.24403784e-02f, 7.70468265e-02f, -6.30735159e-02f, -1.26111379e-03f, 1.59945264e-02f, -8.63363966e-02f, -9.45341513e-02f, 9.88348667e-03f, 1.24184266e-02f,
  -2.55421083e-02f, 3.40220667e-02f, 5.09170368e-02f, -3.99940833e-02f, 5.55454800e-03f, 8.15858468e-02f, -2.05185246e-02f, -3.82022858e-02f, 4.30070758e-02f, -1.97086409e-02f,
  4.84955264e-03f, -2.32221149e-02f, 5.29402271e-02f, 2.46844497e-02f, 7.05571994e-02f, -2.86144987e-02f, 1.98464897e-02f, -5.30362092e-02f, 2.84724645e-02f, 8.33129976e-03f,
  9.67908651e-03f, -1.53813222e-02f, -5.37829399e-02f, 1.83706693e-02f, -1.40076866e-02f, 3.44231091e-02f, -3.06952745e-02f, 9.87913739e-03f, 1.53792862e-04f, -1.00125466e-02f,
  3.48761007e-02f, 7.74869928e-03f, -1.90573242e-02f, -2.09546019e-03f, -4.15878464e-03f, 3.93222757e-02f, 1.31935789e-03f, -1.01636723e-02f, 3.48470137e-02f, 8.14739540e-02f,
  -4.49696183e-02f, -1.81672405e-02f, -1.45035535e-02f, -8.66232626e-03f, -6.66483268e-02f, 1.41168106e-02f, -3.09897419e-02f, 4.52870242e-02f, -3.85048054e-02f, 1.08270776e-02f,
  3.85212861e-02f, 1.82812303e-01f, -1.11090662e-02f, 8.16485379e-04f, -8.76612589e-03f, -3.85024622e-02f, -8.73160362e-03f, 7.00844750e-02f, 5.84192872e-02f, 1.56144276e-02f,
  1.22958273e-02f, -4.54603657e-02f, 1.51188169e-02f, 4.79985662e-02f, -2.60939952e-02f, -6.18093694e-03f, -1.28452200e-02f, 3.66675518e-02f, 3.52519304e-02f, 3.24126892e-02f,
  2.22909767e-02f, -5.75973326e-03f, -3.45252119e-02f, 7.05310628e-02f, 4.86039780e-02f, -3.07810623e-02f, 3.82832102e-02f, 3.91179044e-03f, 2.22251168e-03f, 9.83832777e-03f,
  -1.57350436e-01f, 2.08429679e-01f, 2.17019007e-01f, -1.18422627e-01f, -9.93499234e-02f, -6.18892014e-02f, -1.36258556e-02f, -7.80225471e-02f, 2.50044137e-01f, -4.06244099e-02f,
  -1.33577362e-01f, 1.11277692e-01f, 1.76472545e-01f, -7.48480484e-02f, -7.47165605e-02f, 3.27199489e-01f, -2.26156607e-01f, -5.25297001e-02f, 1.80683240e-01f, -1.87895715e-01f,
  -2.91560814e-02f, -2.15333059e-01f, 6.86267614e-02f, -8.11534002e-02f, -1.11972868e-01f, -3.39422422e-03f, -3.66572261e-01f, 1.43383116e-01f, -2.25032017e-01f, 4.92672324e-02f,
  1.40403137e-02f, 2.12775484e-01f, -8.93604010e-02f, 3.04730590e-02f, -6.72412962e-02f, -2.90555283e-02f, -1.12805195e-01f, 4.96917702e-02f, 4.95401025e-02f, 3.30591202e-02f,
  1.14825033e-02f, -1.51798381e-02f, 1.62140559e-02f, 5.45852371e-02f, 1.54249426e-02f, 1.32817021e-02f, 5.06421961e-02f, 1.73641101e-03f, -2.36942396e-02f, 1.92047954e-02f,
  -2.42401138e-02f, -1.36887254e-02f, -6.81506768e-02f, -1.80275720e-02f, -1.44222379e-02f, 6.76733032e-02f, 2.67384085e-03f, 8.86993203e-03f, -2.02037748e-02f, -4.61850017e-02f,
  -9.48096588e-02f, 5.70847541e-02f, -1.99448951e-02f, 2.83146221e-02f, -6.69062361e-02f, -4.18997668e-02f, -1.56460460e-02f, -4.08479609e-02f, 2.92280670e-02f, -3.43391066e-03f,
  -6.10923320e-02f, -3.20912935e-02f, -4.27926332e-03f, -4.67488132e-02f, -9.95231420e-02f, -2.05484070e-02f, -4.43585888e-02f, 2.18268652e-02f, -3.86847481e-02f, -2.75473502e-02f,
  1.53259756e-02f, 5.40543394e-03f, 3.47513929e-02f, -4.33343509e-03f, 5.27452528e-02f, -2.04652753e-02f, -3.30703007e-03f, 2.19554063e-02f, 2.94928718e-02f, -8.01018625e-02f,
  2.30570007e-02f, -9.45712402e-02f, 5.62191941e-02f, 4.33200970e-02f, 2.76909471e-02f, -4.67773303e-02f, 6.99609742e-02f, -5.04175313e-02f, 2.14094557e-02f, -2.73733623e-02f,
  -1.00161582e-01f, -2.82300115e-02f, -3.35704684e-02f, -2.87440568e-02f, -3.53671536e-02f, -4.02683541e-02f, -7.35319480e-02f, -1.15931104e-03f, -1.16163075e-01f, -5.88720404e-02f,
  -9.27325264e-02f, -2.78439019e-02f, -1.96882766e-02f, -1.35029763e-01f, -5.93973026e-02f, -8.12185481e-02f, -6.88299462e-02f, 5.42245843e-02f, -4.98283952e-02f, 4.59880829e-02f
};

// L0_fan_Wp_bar (Shape: 26 x 120)
const int L0_fan_Wp_bar_rows = 26;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  1.02897078e-01f, -1.80439487e-01f, -1.27911940e-01f, 2.39111722e-01f, 5.62922060e-02f, -6.34793267e-02f, -6.54771477e-02f, 5.71786091e-02f, -1.19940907e-01f, -2.94839963e-02f,
  -4.00603227e-02f, 1.40932992e-01f, -3.27596396e-01f, 2.74179101e-01f, 4.32579368e-01f, -9.19662714e-02f, 2.07944483e-01f, 6.52283579e-02f, 3.28366533e-02f, 1.76546589e-01f,
  1.85318977e-01f, 4.50371742e-01f, 1.13830276e-01f, 2.19569996e-01f, 2.53106177e-01f, 5.63464239e-02f, 1.65928781e-01f, -1.12304673e-01f, 3.05859238e-01f, 2.19872862e-01f,
  -5.60912350e-03f, -7.07386956e-02f, -5.57567701e-02f, 2.59632636e-02f, -6.68028544e-04f, -1.31302118e-01f, -5.99358641e-02f, 7.31017962e-02f, 4.14207466e-02f, -6.00728206e-02f,
  -5.27522080e-02f, 2.45480817e-02f, 1.07975364e-01f, -5.78636527e-02f, 2.18454860e-02f, 2.89932620e-02f, -1.49014657e-02f, -6.77279010e-02f, -1.20166413e-01f, -4.66018319e-02f,
  -1.52568132e-01f, -5.35954200e-02f, -8.88876021e-02f, 7.19406456e-03f, 1.04399920e-02f, 4.96281907e-02f, -8.13848898e-02f, 5.22457398e-02f, 6.16206741e-03f, 4.33207117e-02f,
  4.88935634e-02f, -7.02406839e-02f, -6.71306178e-02f, 1.12067908e-02f, 1.12172468e-02f, 2.39293687e-02f, 8.29493031e-02f, -9.60720479e-02f, -2.58995276e-02f, 2.37891395e-02f,
  -5.80856316e-02f, -1.30335437e-02f, 4.34518413e-04f, -3.30481194e-02f, 5.62340766e-02f, -3.44759598e-02f, -5.58359288e-02f, 7.95253590e-02f, -7.41739571e-03f, -5.33939153e-02f,
  -6.42042607e-02f, 3.59318568e-03f, -8.41035228e-03f, 2.57579982e-02f, 4.33012992e-02f, 6.72142506e-02f, 1.15570888e-01f, -9.40225273e-03f, -6.14176430e-02f, -8.03402588e-02f,
  1.01465225e-01f, 2.03753084e-01f, 7.81844333e-02f, -1.70269515e-02f, -1.99909844e-02f, 2.07657646e-02f, 2.29491778e-02f, 6.44000620e-02f, 1.08224235e-01f, 4.65832837e-02f,
  4.04841192e-02f, -4.62210588e-02f, 5.31134754e-02f, 6.29761256e-04f, 6.83247745e-02f, -2.23508640e-03f, 2.98183486e-02f, 2.36380808e-02f, 8.85720029e-02f, 1.16223752e-01f,
  2.72545069e-02f, -2.48865876e-02f, -5.84316961e-02f, -5.42798229e-02f, 3.00256722e-02f, 2.82667764e-03f, -3.07650771e-02f, -1.68799981e-02f, 3.89823765e-02f, 6.54320493e-02f,
  -2.08370630e-02f, 4.70917523e-02f, 7.78610259e-02f, 1.57519832e-01f, -2.03744873e-01f, -7.18944371e-02f, -3.28074396e-02f, -1.88783389e-02f, 1.24674886e-01f, 7.13118538e-03f,
  1.09637501e-02f, 1.11575164e-01f, 9.05378312e-02f, -2.78900880e-02f, -2.00086944e-02f, 2.21508332e-02f, 1.09193347e-01f, 1.55102506e-01f, 5.88385575e-02f, 9.28645730e-02f,
  -6.43552914e-02f, -5.10532595e-02f, 8.58931988e-03f, -1.96266279e-01f, -6.32665381e-02f, 7.33146593e-02f, -6.11594133e-02f, -1.31450206e-01f, -2.77342945e-02f, -7.98762217e-02f,
  6.25756457e-02f, 7.66783357e-02f, 6.73527792e-02f, -4.08734642e-02f, -7.72323832e-02f, -8.94933194e-02f, 9.08199251e-02f, -2.92113703e-03f, 8.59060287e-02f, -4.78802621e-02f,
  3.99258435e-02f, -2.47851703e-02f, -3.79546285e-02f, 1.83385983e-03f, -3.54531147e-02f, -5.81083670e-02f, -6.80288300e-03f, 5.68064488e-02f, 3.37879639e-03f, -1.08153597e-02f,
  -1.36974882e-02f, -5.22449762e-02f, -1.02541015e-01f, 4.56443019e-02f, 7.63632804e-02f, -6.38270378e-02f, 1.87431816e-02f, -2.89211404e-02f, 3.36767621e-02f, -7.33303279e-02f,
  -1.04889043e-01f, -7.19061727e-03f, -1.76191255e-02f, -4.66360040e-02f, 1.83858145e-02f, 4.98221442e-02f, -5.72243743e-02f, 1.36631057e-02f, 5.19171283e-02f, 4.59740683e-02f,
  7.41012022e-02f, -4.54840846e-02f, -9.44537371e-02f, -7.85564259e-02f, -3.17917243e-02f, -5.05381897e-02f, -5.27295992e-02f, -1.36125870e-02f, -6.16318360e-03f, -3.50234322e-02f,
  7.28024319e-02f, 6.41839951e-02f, 3.65820788e-02f, 8.15374702e-02f, 7.11638555e-02f, -1.23996865e-02f, -5.45459352e-02f, 9.00690537e-03f, 6.37038797e-02f, -5.31177893e-02f,
  4.50613387e-02f, 6.12420738e-02f, 8.11362490e-02f, 1.14298441e-01f, -5.13017401e-02f, -2.80618984e-02f, -5.72183216e-03f, -2.61336062e-02f, -6.32398799e-02f, 6.76419586e-02f,
  -6.06097840e-02f, 9.78258550e-02f, 3.77841704e-02f, 9.87485237e-03f, -2.29357854e-02f, -1.17772762e-02f, -7.68548325e-02f, 1.29717449e-02f, 2.43623164e-02f, -3.56701277e-02f,
  8.89666006e-03f, -4.42613326e-02f, 7.31464848e-03f, 7.31257051e-02f, 2.20516250e-02f, 4.60922532e-02f, 5.77412173e-02f, 6.00782633e-02f, 7.37438872e-02f, 1.22221792e-02f,
  5.92297554e-01f, 1.18836373e-01f, 2.89875865e-01f, 6.29440129e-01f, -5.63720688e-02f, -8.37918604e-04f, 6.32650182e-02f, 3.86061706e-02f, 4.58517402e-01f, -2.27268592e-01f,
  -2.29331374e-01f, 4.12918717e-01f, -3.42249036e-01f, 1.79186955e-01f, -2.74846125e-02f, -2.59170294e-01f, 2.02346534e-01f, 7.77590321e-03f, 1.46554247e-01f, 1.81792587e-01f,
  1.28805831e-01f, -1.70510933e-01f, -5.27530871e-02f, -2.68775225e-01f, 1.58230349e-01f, 1.71227247e-01f, -2.41846919e-01f, -2.31794477e-01f, 6.43024296e-02f, -8.50538537e-02f,
  1.94783229e-02f, 1.16475381e-01f, 1.51060209e-01f, 2.65534595e-02f, 4.03969027e-02f, -2.71735508e-02f, 2.44106911e-02f, -3.73959430e-02f, 1.39224157e-01f, 1.96278542e-02f,
  -7.08254986e-03f, -1.81288011e-02f, 8.76391456e-02f, -8.13304558e-02f, 1.29952475e-01f, 2.43463721e-02f, 7.87560642e-02f, 6.43511638e-02f, -1.70712061e-02f, 4.89386879e-02f,
  1.21208891e-01f, 1.09677196e-01f, 1.07854366e-01f, -3.84842232e-02f, 3.94735374e-02f, 2.27602199e-02f, -2.83747111e-02f, 7.14291558e-02f, 2.22096555e-02f, 5.83112948e-02f,
  -8.87884796e-02f, 4.54606190e-02f, -5.66269197e-02f, 1.46874022e-02f, -1.92784425e-02f, 1.26357432e-02f, -3.10036689e-02f, -5.94101399e-02f, 8.69218707e-02f, 2.17628153e-03f,
  8.42819959e-02f, 1.04173824e-01f, 7.02863857e-02f, 1.07427567e-01f, -3.35981026e-02f, 3.14344577e-02f, -3.01288404e-02f, -1.29101705e-02f, 3.70277762e-02f, 8.26317370e-02f,
  -9.15347412e-02f, 3.08946539e-02f, -4.06017825e-02f, -4.16628905e-02f, -4.84901257e-02f, -7.27368752e-03f, 1.35158245e-02f, 4.22111228e-02f, -2.41782293e-02f, -9.80247557e-03f,
  -7.31157362e-02f, -1.64417118e-01f, -1.96866635e-02f, -1.02803465e-02f, -9.24245417e-02f, -1.25335604e-02f, -4.48907912e-02f, 3.96498442e-02f, 3.03380005e-02f, -7.13041574e-02f,
  -8.81828070e-02f, 2.88711693e-02f, -2.64074318e-02f, -3.06074717e-03f, 1.88088825e-03f, -3.30301225e-02f, -7.59123417e-04f, 1.99576523e-02f, 7.88204279e-03f, -6.71247952e-03f,
  4.91591617e-02f, -7.62355700e-02f, 1.48329055e-02f, 9.85747725e-02f, 2.26036943e-02f, 2.88747177e-02f, 1.04057737e-01f, 3.77730615e-02f, -1.07827581e-01f, 2.71182675e-02f,
  -1.20594338e-01f, 3.91298197e-02f, 1.01463765e-01f, -1.08445376e-01f, 1.19647391e-01f, 6.18555583e-02f, -3.06648146e-02f, 1.20885586e-02f, -8.91617760e-02f, -1.47672325e-01f,
  -3.63906808e-02f, 1.49854735e-01f, 7.09272474e-02f, -3.63693386e-02f, -6.25206381e-02f, -2.03632796e-03f, -3.26974727e-02f, 2.09003873e-02f, 6.50895536e-02f, -9.02568549e-02f,
  -6.04670756e-02f, -4.32522781e-02f, 1.00421049e-01f, 8.75042677e-02f, 9.10252798e-03f, -1.14393800e-01f, -1.41634479e-01f, 1.03924274e-01f, 6.14479231e-03f, -1.71906948e-02f,
  7.05803931e-02f, 1.45646259e-02f, 6.67023733e-02f, 2.08476316e-02f, 2.78046075e-02f, 4.36650068e-02f, 8.44633672e-03f, 3.98993157e-02f, 8.07195231e-02f, 8.45957175e-02f,
  9.14031938e-02f, -4.45749052e-02f, 2.56744139e-02f, -1.15966229e-02f, 4.37093787e-02f, -7.81654641e-02f, 9.86348838e-02f, 8.10355321e-02f, 7.17671886e-02f, -2.11919900e-02f,
  1.61480263e-01f, 5.70129305e-02f, 1.29992254e-02f, -5.29592950e-03f, -2.51376652e-03f, -5.14688939e-02f, -5.14958315e-02f, 3.85466181e-02f, -1.22664319e-02f, -2.81767314e-03f,
  -5.66311777e-02f, -6.73974901e-02f, 2.88966410e-02f, 6.13987334e-02f, -1.32782012e-02f, 2.03758292e-02f, -7.29761692e-03f, 4.35003676e-02f, -5.41703999e-02f, 5.96504509e-02f,
  -8.44478756e-02f, -9.03596133e-02f, -5.15600704e-02f, -5.09210788e-02f, -4.03688028e-02f, 6.17326088e-02f, -5.99058494e-02f, 4.90758829e-02f, -2.01543830e-02f, -9.90271643e-02f,
  -5.59664629e-02f, 2.24456210e-02f, -8.09241235e-02f, -1.00878634e-01f, -5.24991266e-02f, 8.05442631e-02f, -4.59200591e-02f, 1.47171253e-02f, -6.47177249e-02f, 9.64310095e-02f,
  -4.07564379e-02f, -2.03095421e-01f, -5.64723760e-02f, 1.35138193e-02f, 3.07941269e-02f, 5.71394674e-02f, -3.42808245e-03f, 7.95868859e-02f, -1.20417727e-02f, 4.93114628e-02f,
  -5.39702848e-02f, -1.27617210e-01f, -3.13579664e-02f, -4.70857397e-02f, 4.56977785e-02f, 4.77789864e-02f, 2.00652760e-02f, -2.34119259e-02f, -8.60687047e-02f, 6.30325899e-02f,
  -5.48851490e-02f, -6.12389855e-02f, 3.02609876e-02f, -1.72582734e-03f, -3.54850814e-02f, -9.66233909e-02f, 2.28234921e-02f, 8.94214362e-02f, 2.78067514e-02f, -8.23915675e-02f,
  3.00619960e-01f, -4.88664769e-02f, -1.77162811e-01f, -7.43436739e-02f, -6.92607984e-02f, -3.40772681e-02f, -1.03116184e-01f, -1.45638257e-01f, -7.29765445e-02f, 1.70452371e-01f,
  8.68830644e-03f, 1.41674906e-01f, 1.34304836e-02f, -9.66318846e-02f, -6.82730377e-02f, -2.14667041e-02f, -6.06570914e-02f, 2.16585770e-02f, 2.73543019e-02f, 2.73152720e-02f,
  -1.00490019e-01f, -1.36311114e-01f, -1.73334256e-01f, -8.51779878e-02f, 5.82196936e-03f, -2.54021436e-02f, -1.84773654e-02f, -7.60674253e-02f, 1.11032054e-02f, 3.96869406e-02f,
  3.19048651e-02f, 6.88262582e-02f, 4.04590480e-02f, -6.00008145e-02f, 6.68617189e-02f, 1.22068282e-02f, -3.02197151e-02f, 3.58831435e-02f, -9.29684006e-03f, 4.30302583e-02f,
  1.19727477e-01f, 4.42013294e-02f, 5.13296165e-02f, -3.83501388e-02f, -5.82855605e-02f, 3.63731943e-02f, -3.00743934e-02f, 1.08966744e-03f, -1.69242511e-03f, -1.78115461e-02f,
  -8.54907334e-02f, -1.60096567e-02f, 5.24556749e-02f, -8.55217874e-02f, -1.02937557e-01f, -8.82113799e-02f, 7.01100230e-02f, 6.17515147e-02f, -3.71811874e-02f, 9.92397591e-02f,
  4.54434119e-02f, -3.00730485e-03f, -4.00629006e-02f, -7.29075074e-02f, 7.80116618e-02f, 2.01518578e-03f, -9.64130983e-02f, -2.37105321e-02f, 7.55271688e-02f, 7.06790760e-02f,
  -5.26693277e-02f, -4.01548967e-02f, -4.42076400e-02f, 7.07492977e-02f, -5.41279046e-03f, 8.72191787e-02f, 6.33812696e-02f, -9.49938074e-02f, 3.74580547e-02f, -4.94268630e-03f,
  -7.67063862e-03f, -9.17690173e-02f, -9.60606709e-03f, -9.43318084e-02f, -7.33210221e-02f, 7.37963989e-02f, -3.56437676e-02f, 9.14708599e-02f, -1.27610052e-03f, -1.65066812e-02f,
  3.43933925e-02f, -3.62471156e-02f, 3.68597284e-02f, 3.33086364e-02f, -2.20149551e-02f, 8.97108614e-02f, -3.31605249e-03f, 9.78409126e-02f, -8.64078254e-02f, -6.22776262e-02f,
  -3.97773320e-03f, 5.06009348e-02f, 1.31168619e-01f, 2.08650902e-02f, -1.14476748e-01f, -1.66121330e-02f, -7.81149790e-02f, -1.25043914e-02f, 1.17643056e-02f, -3.36902007e-03f,
  1.57505963e-02f, 8.24459270e-02f, 7.25595430e-02f, 6.33124709e-02f, 3.30968201e-02f, -5.27496375e-02f, 1.03869542e-01f, -2.01651864e-02f, 8.75288397e-02f, -1.78858992e-02f,
  8.90483856e-02f, 6.16787281e-03f, -3.03503834e-02f, -1.83606520e-01f, -5.51240370e-02f, 2.49265581e-01f, 1.14797138e-01f, 4.83739004e-02f, -9.04789269e-02f, -1.12109140e-01f,
  -1.11023277e-01f, -1.20151311e-01f, 1.76382530e-03f, -2.07521692e-02f, 1.75884962e-02f, 1.10707521e-01f, 1.75959561e-02f, 5.84576540e-02f, 1.66627049e-01f, 1.06814906e-01f,
  -4.22300622e-02f, 2.51529692e-03f, 1.08699217e-01f, 3.00683267e-02f, 1.45617500e-01f, 3.79329249e-02f, -1.96102336e-01f, 1.01298250e-01f, -1.25988901e-01f, -4.68624346e-02f,
  1.21526845e-01f, 5.13723940e-02f, 1.15671076e-01f, 1.46635666e-01f, 9.53802243e-02f, -8.38343240e-03f, 1.27004972e-02f, -8.50553885e-02f, 5.17761260e-02f, 7.17152422e-03f,
  4.12423760e-02f, 7.70354494e-02f, 8.23848248e-02f, 2.60764882e-02f, -6.25294149e-02f, -9.02518332e-02f, -5.97452112e-02f, -3.07564088e-03f, -7.33859763e-02f, 4.79037240e-02f,
  -4.54065762e-02f, 2.43088864e-02f, 2.98687629e-02f, -6.69414625e-02f, -4.52299789e-02f, -9.67526138e-02f, 3.84658165e-02f, -1.23276096e-02f, -7.87094757e-02f, -1.67936478e-02f,
  -1.46993222e-02f, 6.46292791e-02f, 6.45793304e-02f, -2.01890897e-02f, 9.52760503e-02f, -5.09682074e-02f, 3.97276916e-02f, -6.97724149e-02f, 6.40335232e-02f, 4.59562428e-02f,
  -6.77162260e-02f, -1.08890884e-01f, 6.82948306e-02f, 2.02216525e-02f, -1.59672797e-02f, -3.67906950e-02f, -2.72886418e-02f, -4.00490984e-02f, 2.02005152e-02f, 1.81093104e-02f,
  3.59303653e-02f, 3.79914008e-02f, -7.42836818e-02f, -8.42513815e-02f, -3.73442173e-02f, -5.02645932e-02f, 4.08538021e-02f, -2.93085296e-02f, 2.00579111e-02f, 1.24650924e-02f,
  5.04643247e-02f, -1.20376408e-01f, 1.11555606e-01f, 6.10007830e-02f, 1.20591350e-01f, 1.07808441e-01f, 1.20970113e-02f, 7.67110735e-02f, 9.12211165e-02f, 8.53052661e-02f,
  3.47127691e-02f, -7.93609396e-02f, 6.52853325e-02f, -9.50774699e-02f, -7.36950859e-02f, 7.46463388e-02f, -8.85050967e-02f, 6.83590099e-02f, -4.10658196e-02f, 4.01337184e-02f,
  -8.12908709e-02f, 7.22221956e-02f, -6.81605637e-02f, -3.43386009e-02f, -8.44375342e-02f, -8.29357505e-02f, -7.25431368e-02f, 5.73103838e-02f, -9.19831544e-02f, -7.57944211e-02f,
  3.25452596e-01f, 7.58397803e-02f, -4.92683426e-02f, 2.15426698e-01f, 9.82448012e-02f, 2.26087898e-01f, 2.64037549e-01f, 1.70063078e-01f, 3.56860518e-01f, -1.81364954e-01f,
  -9.98744089e-03f, -1.53579069e-02f, -1.47337005e-01f, 8.44881609e-02f, 1.51654646e-01f, 2.54247541e-04f, 1.23772345e-01f, 3.20870318e-02f, 8.51871297e-02f, -2.00135410e-02f,
  1.07711852e-01f, -7.57375807e-02f, -1.38968527e-01f, -2.42979363e-01f, -7.99280852e-02f, -1.33986035e-02f, -1.89718857e-01f, -9.90774482e-02f, -2.42284000e-01f, 1.45824011e-02f,
  4.86741588e-02f, 5.64148575e-02f, -1.41255381e-02f, 7.75026456e-02f, 6.66923970e-02f, 5.42691611e-02f, -7.75617883e-02f, -1.41389638e-01f, -1.42268594e-02f, 5.50019145e-02f,
  -7.62173608e-02f, -8.77555385e-02f, -1.39946109e-02f, 2.77773794e-02f, 8.82240310e-02f, 1.05608040e-02f, -6.63908347e-02f, 1.84917208e-02f, -8.94529521e-02f, -3.47527850e-04f,
  -9.50887501e-02f, 1.43481772e-02f, 1.05074970e-02f, -5.96148260e-02f, -1.83159038e-02f, 3.95273156e-02f, -1.14842646e-01f, -4.84057479e-02f, -1.38187443e-03f, 6.16207384e-02f,
  7.58759603e-02f, -1.63212344e-02f, 1.04711555e-01f, -2.88480911e-02f, 4.58477624e-02f, -3.71405073e-02f, 1.64564177e-02f, -1.03015266e-01f, 2.99201868e-02f, -7.62389507e-03f,
  7.65940454e-03f, 1.76031757e-02f, -3.35381861e-04f, -1.27578052e-02f, 7.76986852e-02f, 1.05317053e-03f, -2.25336999e-02f, -4.16936167e-02f, 1.67397317e-02f, -8.50577373e-03f,
  5.71427643e-02f, 5.77464327e-02f, 1.90794729e-02f, -1.97439417e-02f, 3.05404002e-03f, -2.12186482e-02f, 2.44850237e-02f, 3.56145650e-02f, -5.92070706e-02f, 7.84279183e-02f,
  2.83003468e-02f, -2.27705408e-02f, -4.08284478e-02f, -6.68300763e-02f, -1.03591263e-01f, 3.47373188e-02f, -4.32623662e-02f, 1.50199533e-02f, -9.58050787e-02f, 8.53916258e-02f,
  -3.80579801e-03f, -7.99954124e-03f, 6.37480170e-02f, -1.01766689e-02f, -1.70700327e-02f, 1.85822975e-02f, -4.58657108e-02f, 2.08679792e-02f, -1.72137152e-02f, 4.65316407e-04f,
  -1.21886931e-01f, -4.57604192e-02f, -2.39007501e-03f, -2.87947971e-02f, -1.28625140e-01f, -1.20390199e-01f, 5.70856035e-02f, -4.14867140e-02f, -9.14926007e-02f, 3.97539698e-03f,
  -9.98224318e-02f, 2.82072484e-01f, 6.34367391e-02f, -7.98101947e-02f, 3.37131345e-03f, 6.91135004e-02f, -3.06866616e-02f, 1.10567182e-01f, 4.60214773e-03f, -5.71667813e-02f,
  -7.17536658e-02f, 3.21578644e-02f, 4.03894670e-02f, -1.17823578e-01f, -1.48268804e-01f, -2.40749400e-02f, -8.89045000e-02f, -9.54663754e-02f, 1.74199030e-01f, 7.65387416e-02f,
  -4.81718406e-03f, -7.24239573e-02f, -2.68477928e-02f, 1.26289666e-01f, 7.79908674e-04f, 1.04129404e-01f, -2.14401275e-01f, 1.91248029e-01f, -7.03077689e-02f, 1.08775236e-01f,
  -1.06523201e-01f, 7.50490800e-02f, -4.95560654e-02f, -2.74217557e-02f, -7.60147646e-02f, -4.28617783e-02f, 3.56494114e-02f, -8.33389387e-02f, -5.57081476e-02f, -6.21095896e-02f,
  4.04257886e-03f, 3.89901735e-02f, 2.93593388e-02f, 5.46520390e-02f, 5.31553058e-03f, 7.87153617e-02f, -1.45012513e-02f, -8.46566539e-03f, 1.40970564e-02f, 9.35512260e-02f,
  7.75800273e-02f, -5.00934124e-02f, 5.52268289e-02f, -9.19708684e-02f, -2.16850266e-02f, 1.64983775e-02f, 3.95436399e-02f, 4.36839052e-02f, 5.27188219e-02f, 2.19819658e-02f,
  8.28775987e-02f, -1.56774353e-02f, -5.56466058e-02f, 5.06178923e-02f, -5.33767454e-02f, 1.10364310e-01f, 2.87865810e-02f, -3.38022932e-02f, -4.21192423e-02f, -5.94815500e-02f,
  -1.20046683e-01f, -4.00995370e-03f, -1.56578775e-02f, 5.90705946e-02f, 2.16464698e-02f, 3.83456945e-02f, -8.21934491e-02f, -2.76648887e-02f, -8.55972022e-02f, -3.10396366e-02f,
  -1.76639874e-02f, -7.82623589e-02f, 5.19080684e-02f, 2.01172568e-02f, 8.40555131e-02f, 5.59130386e-02f, 7.78032420e-03f, 8.87121558e-02f, 4.17690836e-02f, -7.83660077e-03f,
  -6.92870617e-02f, -1.60254445e-02f, -7.09170774e-02f, -1.51585881e-02f, -6.39560539e-03f, -2.24678330e-02f, -9.29666311e-02f, -3.84055860e-02f, -7.62771145e-02f, 5.00207208e-02f,
  -4.41781133e-02f, -8.70951191e-02f, -4.38189432e-02f, -5.15817441e-02f, -9.31439698e-02f, 2.56930310e-02f, -2.63867993e-02f, -3.74006107e-02f, 4.81560826e-03f, 6.79564197e-03f,
  -3.76827386e-03f, 1.20036574e-02f, -4.56728861e-02f, 2.08661752e-03f, -3.79581116e-02f, -5.77073246e-02f, -3.33913527e-02f, -3.94967981e-02f, 4.04030345e-02f, -3.60466838e-02f,
  -2.33003497e-01f, -7.36449510e-02f, -1.52143706e-02f, 2.99549457e-02f, 2.19493717e-01f, 3.84018481e-01f, 1.85488075e-01f, 2.23877504e-01f, 1.61150262e-01f, -1.73062254e-02f,
  2.34796368e-02f, 5.43178758e-03f, -1.90929547e-01f, 6.05003387e-02f, 1.82920620e-01f, 3.97979356e-02f, 2.16800630e-01f, -6.86735138e-02f, -5.85987233e-02f, -1.13154061e-01f,
  -5.54080121e-02f, 2.52537578e-02f, 2.03740261e-02f, -6.16935119e-02f, -8.07753578e-02f, -1.51528433e-01f, -1.26340613e-02f, 2.25661900e-02f, 1.06000222e-01f, 1.92062661e-01f,
  -2.15878263e-02f, -1.62383705e-01f, -3.03212553e-02f, -7.04070404e-02f, -1.03510737e-01f, 3.38418223e-02f, -6.99022859e-02f, 3.12884971e-02f, -3.08503639e-02f, -5.08780498e-03f,
  -4.92653921e-02f, -2.31448021e-02f, 7.25630000e-02f, 2.28293287e-03f, 3.26071642e-02f, 8.44408944e-02f, 2.75715254e-02f, 3.86584625e-02f, 2.88244970e-02f, 5.44432290e-02f,
  -9.69383772e-03f, 5.17340936e-02f, -2.96602100e-02f, 1.91662961e-03f, -9.91942175e-03f, -3.65623273e-02f, 9.71088856e-02f, -6.07298575e-02f, -2.70290356e-02f, 1.52959555e-01f,
  5.55732809e-02f, 4.28718068e-02f, -7.32166320e-02f, -9.14107636e-02f, 2.26654746e-02f, 2.34470014e-02f, 7.51348883e-02f, 6.35784715e-02f, 3.82523760e-02f, -6.34110942e-02f,
  -1.16498204e-05f, 3.42549309e-02f, 1.06688298e-03f, 2.00708788e-02f, -7.82364234e-02f, -4.19092961e-02f, -7.49964416e-02f, -5.54557294e-02f, 5.63131645e-03f, 1.15240188e-02f,
  7.34992474e-02f, -2.94169504e-02f, -4.97697964e-02f, -7.98370242e-02f, 3.84123549e-02f, -6.42362982e-03f, 8.54194723e-03f, 6.80745542e-02f, 2.51580216e-02f, -2.10656766e-02f,
  -3.21801417e-02f, -2.91660633e-02f, -2.58574374e-02f, -4.26066481e-02f, 1.43926870e-02f, -3.09105143e-02f, -5.76042421e-02f, 7.40522593e-02f, -2.23579425e-02f, -8.44051316e-03f,
  3.93439084e-02f, -3.46952491e-03f, 4.58979383e-02f, -4.19564657e-02f, 6.14179298e-02f, 6.39726967e-02f, 2.94290949e-02f, 7.50247240e-02f, 1.12943716e-01f, 3.91102433e-02f,
  9.28400829e-03f, -1.06830811e-02f, -2.53372244e-03f, 2.56261751e-02f, 3.50564532e-02f, -2.32199114e-02f, -4.29523736e-02f, -5.11078723e-02f, 6.18756860e-02f, -4.26449068e-03f,
  9.03197974e-02f, -1.07175432e-01f, -1.53758392e-01f, -2.22591776e-02f, 1.34212613e-01f, 2.10142091e-01f, 1.87219679e-01f, -3.92821692e-02f, -2.93965731e-02f, -4.52077910e-02f,
  6.57606572e-02f, -1.89147770e-01f, -9.32828039e-02f, 6.09339622e-04f, 1.21704504e-01f, -6.94697648e-02f, 2.33130023e-01f, 8.15704241e-02f, 6.06528781e-02f, -7.23422840e-02f,
  -1.78782269e-02f, 1.52841017e-01f, -8.97164550e-03f, 6.60683215e-03f, 7.15599582e-02f, -1.40490741e-01f, -7.82356411e-02f, -1.47433430e-01f, 9.55936387e-02f, 5.41995987e-02f,
  1.42587215e-01f, -3.81056815e-02f, -7.35292509e-02f, -4.57601100e-02f, 1.70169361e-02f, -3.95468883e-02f, -1.14692980e-02f, 7.79763386e-02f, 9.17777885e-03f, 4.35570329e-02f,
  4.09141532e-04f, -4.49125422e-03f, -2.73172203e-02f, 3.85042876e-02f, -1.31225176e-02f, -4.01787870e-02f, -7.35367015e-02f, -8.11981112e-02f, 1.96699575e-02f, -1.32154033e-01f,
  -6.47976100e-02f, 6.29317388e-02f, 4.95584868e-02f, 3.16503528e-03f, -1.70182548e-02f, 4.23313193e-02f, 6.97385222e-02f, -1.06941760e-02f, 6.60185441e-02f, -7.74452686e-02f,
  -3.54014039e-02f, -4.11897115e-02f, -8.51583481e-02f, 6.85538128e-02f, -1.76353697e-02f, 1.03848651e-01f, 2.75592599e-02f, 8.82589519e-02f, 8.00744630e-03f, 4.54444028e-02f,
  9.27733853e-02f, 1.27692735e-02f, 4.28649224e-02f, 9.06813741e-02f, 1.94864813e-02f, -7.25157261e-02f, 8.22449289e-03f, -3.55056413e-02f, 3.10011711e-02f, 5.95834665e-02f,
  -7.55947363e-03f, 8.04071054e-02f, 3.01559153e-03f, -3.38331498e-02f, 5.71517274e-02f, -1.22422352e-02f, 1.04664927e-02f, -4.43312898e-02f, 7.00271279e-02f, 2.30616219e-02f,
  -3.66155840e-02f, -1.36767000e-01f, 7.17544556e-02f, 3.29387151e-02f, 1.04346052e-01f, -5.22247516e-02f, 8.45314413e-02f, 2.22902838e-02f, -5.57439327e-02f, 7.15744719e-02f,
  -3.85782011e-02f, 4.93007675e-02f, 8.96837264e-02f, -4.61027473e-02f, 5.87229757e-03f, 6.51562288e-02f, -3.38550992e-02f, -1.28644165e-02f, 7.15647861e-02f, 5.57846613e-02f,
  -8.01264942e-02f, 5.81713356e-02f, 9.53677148e-02f, 8.63255188e-02f, -6.08682409e-02f, 4.14622985e-02f, 3.89328897e-02f, -7.73535967e-02f, 3.69314253e-02f, -6.30360320e-02f,
  -3.44391316e-01f, 2.00382799e-01f, 9.30556357e-02f, 2.92760760e-01f, -3.02150428e-01f, -5.21348082e-02f, 1.12055965e-01f, -1.64839864e-01f, 1.14535481e-01f, 1.96740910e-01f,
  6.89731631e-03f, 1.64887421e-02f, -6.54260395e-03f, 2.93401450e-01f, 7.86154419e-02f, 2.91178137e-01f, 2.85607398e-01f, 1.77990124e-01f, 7.27691203e-02f, -9.36290473e-02f,
  6.23200871e-02f, 4.40548696e-02f, 2.58370489e-01f, -1.05309434e-01f, -5.16562089e-02f, -9.30607039e-03f, 1.14552148e-01f, -5.17301087e-05f, 8.32400844e-02f, 4.38443795e-02f,
  -1.31129324e-01f, -1.85031630e-02f, -1.29236817e-01f, -2.38681473e-02f, -3.75540964e-02f, -6.48149997e-02f, 2.83918791e-02f, -1.44746425e-02f, -3.61042731e-02f, 3.98052633e-02f,
  -1.29787281e-01f, -1.14028916e-01f, 9.54309106e-03f, 9.74356458e-02f, 2.15164181e-02f, 3.75630260e-02f, -1.53387412e-02f, -3.97229195e-02f, 4.27342504e-02f, -1.01685449e-01f,
  -1.35480007e-02f, -4.76308577e-02f, -2.16005836e-02f, 1.30455554e-01f, -1.89669058e-02f, -2.80178655e-02f, 1.09319292e-01f, 1.32077504e-02f, -5.57030253e-02f, 6.08436055e-02f,
  7.80238807e-02f, 7.89350942e-02f, -3.56937456e-03f, -2.25806870e-02f, -5.97115513e-03f, 2.92125680e-02f, 5.05706631e-02f, -1.51470006e-02f, 1.98932253e-02f, 2.78780200e-02f,
  -6.53358400e-02f, -3.72636952e-02f, -7.97950178e-02f, 7.38293380e-02f, 2.77163051e-02f, 5.01313880e-02f, 7.33742118e-02f, 6.98884856e-03f, 2.73496844e-02f, 3.16221602e-02f,
  3.56761105e-02f, 2.97495089e-02f, 1.72680579e-02f, -4.87899855e-02f, 6.42049760e-02f, 1.12298131e-02f, -2.17178185e-02f, -4.57482645e-03f, 1.49811143e-02f, 7.29991421e-02f,
  -6.99486136e-02f, 1.94717169e-01f, -5.20194210e-02f, -1.33435369e-01f, 3.52029875e-02f, -9.99966040e-02f, 5.45891970e-02f, 9.27824154e-03f, 9.42664966e-02f, -4.48596030e-02f,
  -9.97740217e-03f, -1.26597239e-02f, -2.54004393e-02f, -4.67830561e-02f, -2.40939222e-02f, -4.04571071e-02f, 3.16976383e-02f, 2.17836071e-02f, -1.76201127e-02f, -3.70340124e-02f,
  -3.15263271e-02f, -7.30469674e-02f, 1.07689634e-01f, 3.40096792e-03f, 6.41319305e-02f, 2.85088085e-02f, 2.72359774e-02f, -3.23007144e-02f, -7.12230727e-02f, 1.32358164e-01f,
  3.86615866e-03f, -2.63643563e-01f, 3.56762797e-01f, 1.24462433e-01f, 3.51606578e-01f, 2.39478633e-01f, 1.92545757e-01f, 2.44823262e-01f, 2.66907901e-01f, -4.30536211e-01f,
  -2.18466520e-01f, -2.27588594e-01f, 4.63398546e-02f, -1.99567929e-01f, 3.03046167e-01f, 9.99301299e-02f, 2.79392693e-02f, -2.11513545e-02f, 8.17436799e-02f, 1.43904588e-03f,
  1.35865659e-01f, -1.59603089e-01f, 1.40604675e-01f, -1.68204471e-01f, 3.27720046e-02f, -1.76225886e-01f, -2.15558976e-01f, -8.16706661e-03f, -1.88142017e-01f, -1.80524420e-02f,
  -9.16863233e-02f, -1.66582406e-01f, -1.19023390e-01f, -2.08097622e-02f, 3.15082557e-02f, -3.42453979e-02f, -8.43732804e-02f, 1.83941685e-02f, -5.49463602e-03f, -3.59260440e-02f,
  -1.94957573e-02f, 1.57354109e-04f, 1.25431211e-03f, 6.10190518e-02f, 2.91973166e-02f, 4.60208617e-02f, 1.21241562e-01f, 1.09474435e-01f, -1.96525566e-02f, 1.23652659e-01f,
  5.83487563e-02f, 4.06626472e-03f, -4.19543823e-03f, 4.93370323e-03f, 4.37278040e-02f, -5.73186949e-02f, 1.39290672e-02f, -1.48663651e-02f, -1.03764224e-03f, 2.57268623e-02f,
  1.80771500e-02f, 1.76788978e-02f, 8.50513298e-03f, 1.97628736e-02f, 2.91503519e-02f, 5.12206629e-02f, 2.17659567e-02f, -4.44160365e-02f, 2.32780185e-02f, -6.34151772e-02f,
  -4.31542695e-02f, -3.67607623e-02f, -4.07170057e-02f, 1.79679375e-02f, -1.73604321e-02f, -3.05847940e-03f, 2.75846366e-02f, -3.52911614e-02f, -3.06777582e-02f, -2.61515416e-02f,
  4.24406724e-04f, -4.31251489e-02f, -6.41833171e-02f, -1.92890055e-02f, -1.68466400e-02f, -1.06623527e-02f, -5.14388457e-02f, 2.88603827e-02f, 7.97532201e-02f, -4.00750674e-02f,
  -3.91679347e-01f, -3.37975115e-01f, -7.23111257e-02f, -1.28590912e-01f, -1.41897067e-01f, -9.41521823e-02f, 3.95496078e-02f, 1.70180239e-02f, -7.42281526e-02f, 6.69973269e-02f,
  3.71793751e-04f, -4.25250083e-02f, -6.57602176e-02f, -2.84486506e-02f, -3.85009199e-02f, 4.19286638e-02f, -5.96047230e-02f, -1.37364298e-01f, -7.20799491e-02f, -9.07967538e-02f,
  -1.10395551e-01f, -1.07408606e-01f, -9.30847600e-03f, -4.51359414e-02f, -1.06417134e-01f, -6.93744496e-02f, -9.91173312e-02f, -7.77919516e-02f, -1.61942113e-02f, 3.23518962e-02f,
  2.29410026e-02f, -3.78245898e-02f, -3.27683866e-01f, -1.78803399e-01f, 1.88470900e-01f, -1.95852697e-01f, -2.93431312e-01f, -3.64657454e-02f, -2.63783306e-01f, 1.44008130e-01f,
  -1.18272370e-02f, -1.82039946e-01f, -1.29475221e-01f, -3.06919724e-01f, -3.91360581e-01f, -3.72834742e-01f, -1.94377452e-01f, -1.14145696e-01f, -1.40937999e-01f, 1.13501266e-01f,
  -1.36024833e-01f, 3.06685604e-02f, -2.01773420e-01f, 1.86976224e-01f, 3.55481505e-02f, 2.00117916e-01f, 4.12429690e-01f, 9.57602859e-02f, 2.16233030e-01f, 6.43822402e-02f,
  -1.04587391e-01f, -1.49579898e-01f, -8.19477364e-02f, -4.33064662e-02f, 1.86749024e-03f, 1.58075228e-01f, 1.00902490e-01f, -3.54889706e-02f, -1.04554377e-01f, -1.29567757e-01f,
  1.05729513e-01f, 1.83705799e-03f, 5.90955326e-03f, -5.88884689e-02f, -8.26338213e-03f, -1.46462070e-02f, -1.61566734e-02f, 3.88834812e-02f, -1.44382089e-01f, -8.32395703e-02f,
  -8.28985870e-02f, 3.81042250e-02f, 7.29842633e-02f, 2.28891708e-02f, -6.74103498e-02f, -6.91912919e-02f, 3.34327891e-02f, 1.75220277e-02f, 9.59232450e-02f, -8.39098468e-02f,
  9.14252177e-02f, 1.28668904e-01f, 2.88443565e-02f, -7.92149175e-03f, -1.10158343e-02f, 1.71675778e-03f, -6.14273548e-02f, 5.09871468e-02f, -5.63710406e-02f, 6.30792528e-02f,
  -5.78602143e-02f, -1.99838001e-02f, 1.88536160e-02f, -1.51857417e-02f, -3.25358436e-02f, -6.10109009e-02f, 3.53961810e-02f, -4.32653949e-02f, -3.42143467e-04f, -1.57985985e-01f,
  -1.30725056e-02f, 4.79048714e-02f, -3.39812487e-02f, 5.56262732e-02f, -6.42295703e-02f, 8.25557783e-02f, 3.51113565e-02f, -2.66565233e-02f, 1.91686880e-02f, 6.64998218e-02f,
  -7.83029012e-03f, 8.83765146e-02f, -9.52137634e-03f, 2.75668618e-03f, 2.12691426e-02f, 1.03793591e-02f, 3.85707943e-03f, 1.41863599e-02f, 5.04794531e-02f, 5.87200262e-02f,
  5.35934456e-02f, 1.77255571e-02f, 1.48077026e-01f, 1.76419329e-03f, 2.89135482e-02f, 7.86621720e-02f, 5.25501631e-02f, 5.73817790e-02f, 6.22276068e-02f, 7.77222142e-02f,
  1.88401461e-01f, 6.48373365e-02f, -3.97683159e-02f, -3.03878020e-02f, 5.24176471e-02f, 6.59107044e-02f, 4.40852232e-02f, 3.78830433e-02f, -3.09222843e-02f, -4.24501300e-02f,
  -1.71286047e-01f, 2.88682610e-01f, -2.84299493e-01f, -8.65899213e-03f, -1.13227561e-01f, 4.27181482e-01f, 4.58610535e-01f, 9.75568686e-03f, 2.76167244e-01f, 3.54349852e-01f,
  3.06277812e-01f, -4.34322953e-02f, 2.47554332e-01f, 4.02956963e-01f, 1.16838634e-01f, 3.71662825e-01f, 4.75565583e-01f, 3.57663900e-01f, 1.09515793e-03f, 1.09784164e-01f,
  -6.23594411e-03f, 2.10886791e-01f, -1.30013451e-01f, -1.51546866e-01f, 4.94452044e-02f, -3.87563556e-01f, -1.50604367e-01f, -3.22604030e-01f, -1.02726500e-02f, -2.22437494e-02f,
  1.61699668e-01f, -5.25414012e-02f, -9.11499932e-02f, -8.76343697e-02f, 4.18368541e-02f, -3.82386185e-02f, -8.54791999e-02f, -1.96801126e-01f, -1.11945666e-01f, -6.60844473e-03f,
  -5.03758062e-03f, 3.31192161e-03f, 4.32363749e-02f, -4.41352241e-02f, -3.97594683e-02f, -9.91539881e-02f, -4.56957631e-02f, 3.39957960e-02f, 3.49731706e-02f, 8.17342941e-03f,
  -1.01994202e-02f, 2.48411857e-02f, 6.95212409e-02f, 1.18120544e-01f, -2.05189567e-02f, -8.03367142e-03f, 2.87160706e-02f, -6.91672787e-02f, 7.66425133e-02f, 1.16916019e-02f,
  -3.15681659e-02f, -3.70372692e-03f, 3.77098881e-02f, 1.75599828e-02f, -1.14912130e-02f, 1.62301306e-02f, 4.27400619e-02f, -9.45508480e-03f, -5.70116229e-02f, 6.08249083e-02f,
  -5.22196852e-02f, -1.40977250e-02f, 5.39676137e-02f, -2.92686671e-02f, 1.00258298e-01f, -3.26620601e-02f, -7.63708651e-02f, -1.87933389e-02f, -1.56704057e-02f, 3.47368196e-02f,
  -5.80166690e-02f, -4.28677760e-02f, -6.24730401e-02f, -3.90655883e-02f, -1.62349939e-02f, -4.94608097e-02f, 1.30721945e-02f, -1.82498135e-02f, -6.01497293e-02f, -8.92527997e-02f,
  1.99067205e-01f, 1.51660681e-01f, -3.44322845e-02f, 1.05929459e-02f, -9.36756283e-03f, -1.03507759e-02f, 4.27304097e-02f, 4.72938307e-02f, -6.42425567e-03f, 6.01669997e-02f,
  -8.41187164e-02f, -7.24314377e-02f, 1.00514861e-02f, -7.28379264e-02f, 3.56494971e-02f, 1.24909781e-01f, 2.19914410e-02f, -8.33654702e-02f, 6.89666998e-03f, -1.18094616e-01f,
  -6.89556450e-02f, -2.37557665e-02f, -5.44960462e-02f, -2.89824922e-02f, 7.40060508e-02f, 4.17834669e-02f, -2.91070789e-02f, -7.91500956e-02f, -7.92662501e-02f, 4.97094803e-02f,
  3.96358401e-01f, 4.04867940e-02f, -3.11475217e-01f, -9.25850645e-02f, 2.18231201e-01f, 2.64132261e-01f, 1.58262476e-01f, 5.40738925e-03f, 1.21366479e-01f, 1.52769700e-01f,
  8.04612264e-02f, -8.28531012e-02f, -1.16346270e-01f, 7.68625066e-02f, 1.18651077e-01f, -1.09947093e-01f, 2.74797946e-01f, 1.08971499e-01f, -6.48450777e-02f, 1.43732354e-01f,
  -1.02099236e-02f, 2.59767473e-01f, -2.56927490e-01f, -6.16229489e-04f, 1.04990013e-01f, -1.30727068e-01f, -2.75816303e-02f, -1.88240916e-01f, 4.81923297e-02f, -1.72297955e-02f,
  2.43638661e-02f, 1.26637882e-02f, -4.27734703e-02f, -7.53975064e-02f, -1.00557305e-01f, 1.09570339e-01f, 5.91865443e-02f, -2.82098632e-02f, -1.49442116e-02f, -5.86036593e-03f,
  -3.11115850e-02f, -5.08748852e-02f, 1.11936405e-03f, -3.65069620e-02f, 7.23494515e-02f, -1.64872017e-02f, -4.74643633e-02f, -6.31283447e-02f, -8.87262225e-02f, 3.88969295e-02f,
  -9.07450244e-02f, -2.33751368e-02f, 3.52444407e-03f, 3.84622663e-02f, -5.90109192e-02f, -4.85918522e-02f, 2.18852106e-02f, -1.37968689e-01f, 2.35876590e-02f, -1.58328712e-02f,
  5.79613782e-02f, 1.18177846e-01f, -1.90989748e-02f, 6.74500987e-02f, -1.43120494e-02f, -5.30815013e-02f, 5.23389950e-02f, 7.04538217e-03f, -7.29231536e-02f, 7.40461349e-02f,
  -7.33932555e-02f, -7.65276030e-02f, -3.78685221e-02f, -2.95181572e-02f, 7.21385404e-02f, 7.95336589e-02f, 7.37250373e-02f, -1.00029623e-02f, 1.41042052e-02f, -2.31563877e-02f,
  -3.50992871e-03f, 6.25368357e-02f, 1.38220163e-02f, 6.29030615e-02f, 1.61265787e-02f, -8.44936296e-02f, -3.33439908e-03f, 2.17082575e-02f, -4.22572903e-03f, 9.50322449e-02f,
  1.46216890e-02f, 4.91616875e-02f, -1.22491337e-01f, 2.95103416e-02f, -1.38598785e-01f, 4.67134938e-02f, -3.62265408e-02f, 3.70305800e-03f, 1.87414587e-02f, 4.68812883e-02f,
  7.33420253e-02f, 8.52522850e-02f, -1.86048094e-02f, 5.31878397e-02f, -5.49257994e-02f, 1.19194858e-01f, -3.83376181e-02f, -7.82185962e-05f, 6.71407804e-02f, -3.66920009e-02f,
  -6.42436184e-03f, 1.13740481e-01f, 1.44505119e-02f, -6.62833303e-02f, 3.93846706e-02f, -1.22797927e-02f, -4.43114080e-02f, -4.29916680e-02f, 8.56540576e-02f, -7.48673379e-02f,
  -2.63039798e-01f, 3.29848647e-01f, 2.82798082e-01f, -1.56552300e-01f, 1.18549556e-01f, -1.59794055e-02f, -2.09875349e-02f, 9.16955993e-02f, 1.05398623e-02f, -9.64785088e-03f,
  2.81915795e-02f, 1.42423376e-01f, -2.26720306e-03f, 5.82355969e-02f, -2.72304296e-01f, -7.58036599e-02f, -8.87515247e-02f, -1.34050384e-01f, 2.91399825e-02f, -4.58117090e-02f,
  -1.83081284e-01f, -4.13699560e-02f, 9.71300900e-02f, 1.57070145e-01f, 9.95075982e-03f, -7.51028676e-03f, -2.32596859e-01f, 2.37310439e-01f, -5.24208546e-02f, 9.71690640e-02f,
  -2.81172786e-02f, -1.65156081e-01f, 1.05695628e-01f, 1.32209910e-02f, -7.55789801e-02f, -8.40841308e-02f, -3.19469236e-02f, 4.57511432e-02f, 5.02597913e-02f, 7.81650841e-02f,
  -7.16613159e-02f, -1.88813452e-02f, 4.67271097e-02f, -6.58482080e-03f, -5.69497002e-03f, 1.49708074e-02f, 6.31102696e-02f, -3.24177705e-02f, 1.69128597e-01f, 8.59089792e-02f,
  1.66261703e-01f, 2.96892077e-02f, 3.35362852e-02f, -8.03728923e-02f, 3.70607115e-02f, -1.28022796e-02f, -4.84525971e-02f, -1.08761601e-02f, -5.55000901e-02f, -3.19140889e-02f,
  9.05641471e-04f, -7.01181144e-02f, 7.22922152e-03f, 2.97196284e-02f, -7.58784264e-02f, -5.53379953e-02f, -3.53416726e-02f, -5.47706336e-03f, 4.61510830e-02f, 2.51655914e-02f,
  -1.20705128e-01f, -4.01837602e-02f, 3.72608043e-02f, -6.90163523e-02f, 2.79375333e-02f, -4.59129363e-02f, -3.64171118e-02f, -9.05650035e-02f, 6.50779083e-02f, 1.45315798e-02f,
  -3.57813500e-02f, 2.89505105e-02f, 3.43144462e-02f, -7.05046952e-02f, 4.45590355e-02f, 3.45803238e-02f, 1.71403643e-02f, 1.95221659e-02f, -4.64591421e-02f, -1.21577028e-02f,
  -2.87486941e-01f, -2.85379946e-01f, -2.19709259e-02f, 3.83642986e-02f, -5.46185225e-02f, -5.25111631e-02f, 2.47743223e-02f, -1.55274095e-02f, -4.78320457e-02f, -7.33785257e-02f,
  3.13567463e-03f, 4.12809150e-03f, 5.51290577e-03f, -4.08169776e-02f, 7.13717565e-02f, -7.05161467e-02f, -1.13433674e-01f, -4.50178385e-02f, 5.22006303e-02f, 9.24579334e-03f,
  9.76238698e-02f, 5.44641949e-02f, -3.27334553e-02f, 9.58977081e-03f, -4.59244289e-02f, 7.58468639e-03f, -4.44926731e-02f, -2.99803186e-02f, 3.96495648e-02f, 1.25160087e-02f,
  2.15045825e-01f, -3.35364163e-01f, 8.76310170e-02f, -1.09442711e-01f, 5.48922457e-02f, 3.15153122e-01f, 3.35126728e-01f, -2.99802542e-01f, -3.51094455e-01f, -1.80143282e-01f,
  1.80084869e-01f, 8.83082226e-02f, 1.64545685e-01f, 1.56894848e-01f, 5.15875936e-01f, 4.47237529e-02f, -2.48424765e-02f, 1.10118985e-01f, -3.53315994e-02f, -1.21046878e-01f,
  3.03136166e-02f, 1.18752666e-01f, 1.61922470e-01f, -1.95167407e-01f, 5.02405129e-02f, -1.62503600e-01f, 1.84005126e-02f, 1.41349703e-01f, 9.91491973e-02f, 2.28014916e-01f,
  1.54736817e-01f, -1.65503532e-01f, 3.68703865e-02f, 2.75505520e-02f, 4.01984975e-02f, 1.06008407e-02f, 2.82137971e-02f, 1.70059353e-01f, 4.87459973e-02f, -9.30699483e-02f,
  6.03007488e-02f, -1.56463273e-02f, -1.11402862e-01f, 7.02769831e-02f, -9.15539861e-02f, -1.38913170e-01f, -5.06161414e-02f, -1.13830648e-01f, -4.17642929e-02f, 7.61368051e-02f,
  -6.13206159e-03f, -4.85384874e-02f, -4.26970869e-02f, -1.24194108e-01f, -1.16685934e-01f, -1.05866574e-01f, -4.46351580e-02f, -1.00877304e-02f, -1.14400886e-01f, -5.84733374e-02f,
  2.17689369e-02f, -1.08480789e-02f, 1.58539210e-02f, -2.11070646e-02f, 9.23039019e-02f, 4.70609171e-03f, 4.26155254e-02f, 1.91981122e-02f, -9.19409748e-03f, 8.72846544e-02f,
  3.88741456e-02f, -4.39649522e-02f, 2.82091415e-03f, 3.86395259e-03f, -2.10213978e-02f, 2.24910863e-02f, 1.47805303e-01f, -6.31902963e-02f, -1.09767415e-01f, 3.68124694e-02f,
  -2.30372306e-02f, 7.33433515e-02f, -1.11370836e-03f, 1.72324181e-02f, 1.27213420e-02f, 3.41209322e-02f, -5.07745817e-02f, -6.28333241e-02f, -9.04968306e-02f, 1.28446862e-01f,
  -1.15144134e-01f, -2.36191154e-01f, -8.95525217e-02f, -1.13081010e-02f, -4.62000221e-02f, -4.40467373e-02f, -2.52199993e-02f, -8.35359618e-02f, -1.26389280e-01f, -6.72722757e-02f,
  -4.38889377e-02f, -6.02307636e-03f, 2.59537604e-02f, -5.11000715e-02f, 4.98271883e-02f, -4.12997417e-03f, -3.12051252e-02f, 1.75432973e-02f, -4.70098853e-02f, -2.06260681e-02f,
  -1.25405593e-02f, -4.62293401e-02f, 5.55100366e-02f, 6.17244327e-03f, 2.05675904e-02f, 8.46211314e-02f, -9.09442976e-02f, -7.42562674e-03f, 6.15136512e-02f, -1.72323100e-02f,
  3.02627861e-01f, -3.49441081e-01f, -1.88716173e-01f, 3.30450274e-02f, -8.18544179e-02f, -3.63607734e-01f, -3.00843269e-01f, -2.09862545e-01f, 1.16631407e-02f, -2.48811409e-01f,
  2.86253635e-02f, 1.32172093e-01f, -4.23095152e-02f, -4.69864951e-03f, 3.83000553e-01f, 1.80754855e-01f, -3.25224474e-02f, 2.79072430e-02f, 1.27171367e-01f, -5.91112114e-02f,
  1.39914393e-01f, 5.71080148e-02f, 1.49031326e-01f, -2.97927484e-03f, -1.16227433e-01f, -8.95785075e-03f, 2.42539153e-01f, -3.01370528e-02f, 3.68424170e-02f, 4.90688458e-02f,
  -5.69932535e-02f, -2.10744031e-02f, -1.89097866e-03f, -6.92206249e-02f, -5.67522608e-02f, -2.24122312e-02f, -4.50825281e-02f, 3.46533246e-02f, -2.12392937e-02f, -2.16776021e-02f,
  6.97107911e-02f, -3.90262976e-02f, -2.97996495e-02f, 6.53672963e-02f, -1.68523155e-02f, -7.00897500e-02f, -1.85153633e-02f, 1.85242966e-02f, -2.80823801e-02f, 5.15260324e-02f,
  -2.26295404e-02f, -8.45866874e-02f, 1.34448782e-02f, 7.20825121e-02f, 9.14505497e-02f, -1.20824233e-01f, 6.00027246e-03f, 5.50620258e-02f, -7.14470893e-02f, -7.27552250e-02f,
  -4.34326939e-02f, 5.53890429e-02f, -8.45181048e-02f, 3.29692364e-02f, 4.63708192e-02f, -3.05214077e-02f, -7.73903951e-02f, 3.27330008e-02f, 8.85138288e-02f, 5.54160737e-02f,
  -1.80668361e-03f, -2.22210530e-02f, -1.60519034e-02f, -4.74347994e-02f, 2.88058240e-02f, 5.51973376e-03f, -8.55550319e-02f, -4.66310196e-02f, 4.24072817e-02f, -6.94491267e-02f,
  4.23666369e-03f, 9.73124355e-02f, -4.49984223e-02f, 8.19993764e-03f, -2.93886941e-02f, 8.29959661e-02f, 1.21544138e-01f, -2.84710787e-02f, 6.13060072e-02f, -5.45395687e-02f,
  1.05799800e-02f, 5.69423544e-04f, -4.87336107e-02f, 2.98835263e-02f, 2.16668174e-02f, -6.00179564e-03f, -1.28593549e-01f, 1.92001630e-02f, 5.89074269e-02f, 6.05157390e-02f,
  -3.10636032e-02f, 5.19724600e-02f, -2.61317305e-02f, 9.67764407e-02f, 1.16571169e-02f, -7.09789693e-02f, -8.83805566e-03f, -3.09949033e-02f, 6.70330524e-02f, 1.36918174e-02f,
  -5.65023385e-02f, -5.18426225e-02f, -8.67916644e-03f, -1.42715471e-02f, -3.45565677e-02f, -6.54648617e-02f, 4.67268005e-02f, 3.77492607e-02f, -6.77162260e-02f, -5.69441244e-02f,
  -1.60294890e-01f, 2.66633686e-02f, -4.75066602e-02f, -1.63062960e-01f, 1.27369627e-01f, -7.60998651e-02f, -1.14410199e-01f, 1.52574956e-01f, 1.01201825e-01f, 1.13425471e-01f,
  8.12458172e-02f, -1.41897142e-01f, 2.63888575e-02f, -2.83065796e-01f, -3.32893789e-01f, -1.68648317e-01f, -2.56043702e-01f, -1.28661141e-01f, -9.36108008e-02f, -5.91450511e-03f,
  -1.49354681e-01f, -1.40162855e-01f, -3.04791659e-01f, 7.63223646e-03f, -8.40722695e-02f, 1.26965418e-01f, 9.07285735e-02f, -4.21251869e-03f, -9.19703171e-02f, -8.48406628e-02f,
  -3.11667398e-02f, 6.68848231e-02f, -1.41583644e-02f, -5.58182709e-02f, 8.34410861e-02f, 1.33575276e-01f, -3.65150906e-02f, -1.34931013e-01f, -7.21950680e-02f, 4.01126333e-02f,
  5.93080074e-02f, -1.00469023e-01f, -1.23900652e-01f, -2.51693837e-02f, 7.96947181e-02f, 1.28237931e-02f, -5.52357025e-02f, 4.31158096e-02f, 6.84164697e-03f, -9.12955627e-02f,
  -9.96384695e-02f, 3.67839879e-04f, -6.68491945e-02f, 1.86408162e-02f, -7.34596699e-02f, -2.48750225e-02f, -5.58848605e-02f, -3.17550898e-02f, 5.34196384e-02f, -2.62520686e-02f,
  3.41489203e-02f, 8.45211223e-02f, 4.84264269e-02f, -3.29241417e-02f, 6.24396205e-02f, 2.84081418e-02f, 6.87802732e-02f, 2.40771715e-02f, -4.41930182e-02f, 1.27012674e-02f,
  -6.53952584e-02f, -2.45190058e-02f, -6.43548220e-02f, 6.96958005e-02f, 1.62345544e-02f, -1.67916995e-02f, 2.32273489e-02f, -2.84655858e-02f, -3.75014655e-02f, 6.37263209e-02f,
  6.04336709e-02f, 4.55022976e-02f, -8.49660486e-02f, -5.07985055e-02f, 7.54203349e-02f, -8.65074471e-02f, 7.96703473e-02f, -5.67176454e-02f, -1.59752043e-03f, 2.93384977e-02f,
  8.44875872e-02f, 1.51470438e-01f, -2.55676284e-02f, -4.11156006e-02f, 1.92800686e-02f, -3.47223766e-02f, -5.29594952e-03f, 7.79476017e-02f, 2.92592607e-02f, -3.96400644e-03f,
  1.02291569e-01f, 1.36760052e-03f, -5.24965376e-02f, -5.07739484e-02f, 3.20009626e-02f, 6.11373708e-02f, -3.63255069e-02f, 9.57787260e-02f, 6.60025701e-02f, 8.14886093e-02f,
  3.96559201e-02f, 3.10019143e-02f, 3.51607124e-03f, -7.51621127e-02f, 7.18483552e-02f, 1.22375511e-01f, -1.06429495e-02f, 4.23439778e-02f, -5.24001643e-02f, 3.38237546e-02f,
  -7.85910845e-01f, 8.14457163e-02f, -1.45320997e-01f, -3.70848596e-01f, -4.11595926e-02f, -1.73110999e-02f, 4.90584001e-02f, -1.39096648e-01f, -1.96989670e-01f, 2.74846703e-01f,
  2.12290600e-01f, -3.33191365e-01f, 3.84787500e-01f, -3.81650068e-02f, -3.85645717e-01f, 1.45830020e-01f, -1.13726512e-01f, -2.68764161e-02f, -1.00702308e-01f, -1.55115351e-01f,
  -1.70426965e-01f, 1.73643660e-02f, -8.28025565e-02f, 1.70256898e-01f, -1.83509097e-01f, -1.47395894e-01f, 1.14741251e-01f, 3.07213161e-02f, 6.83694263e-04f, -6.06453121e-02f,
  -2.29330301e-01f, -2.11089209e-01f, 3.44672762e-02f, -6.11203648e-02f, -1.32670850e-01f, -3.46536525e-02f, -4.05129194e-02f, 6.36061206e-02f, -5.32160141e-02f, -9.54034105e-02f,
  -4.95136790e-02f, -7.02443272e-02f, -5.64259179e-02f, -1.12859830e-02f, -6.52789176e-02f, -4.64840308e-02f, -3.09754964e-02f, 9.43591353e-03f, -1.27915014e-02f, -1.62360761e-02f,
  4.40095440e-02f, -4.40165214e-02f, 5.26736304e-02f, -1.88121889e-02f, -3.51309441e-02f, -1.30130528e-02f, -9.30268764e-02f, -7.38456054e-03f, -2.09782310e-02f, -1.33145809e-01f,
  -4.55701202e-02f, 7.04408288e-02f, -7.99961481e-03f, 1.99126750e-02f, 7.61471242e-02f, 6.74097091e-02f, 1.55734578e-02f, 5.10806814e-02f, -2.26511192e-02f, 3.75595829e-03f,
  -1.10851400e-01f, 3.16419564e-02f, -1.48496905e-03f, 2.15302855e-02f, -1.03600649e-02f, -4.42037806e-02f, 2.68804356e-02f, -6.95811734e-02f, 2.92480569e-02f, -4.24607210e-02f,
  1.35270253e-01f, -4.67117652e-02f, 3.50042507e-02f, 3.44536044e-02f, 5.53344004e-02f, 5.99216968e-02f, 4.99065556e-02f, -6.30571460e-03f, 4.80022319e-02f, -2.40093283e-02f,
  -1.41555384e-01f, -1.98922247e-01f, -4.44163643e-02f, -1.27525441e-02f, -7.12257773e-02f, 2.02449188e-02f, -8.72971565e-02f, -1.25526404e-02f, -4.90066595e-02f, 7.84341991e-03f,
  3.06539554e-02f, 4.53183427e-02f, -6.00813031e-02f, 3.76767665e-02f, 3.99036668e-02f, 6.67575747e-02f, -1.60567854e-02f, -1.32412035e-02f, -2.24720072e-02f, 1.76339485e-02f,
  -4.70431522e-02f, -7.21238256e-02f, -1.61615107e-02f, 5.33874817e-02f, 3.25233378e-02f, 4.43114750e-02f, -6.69394657e-02f, -3.74406180e-03f, 5.59776463e-03f, 4.21464741e-02f,
  1.46719962e-01f, -3.36712599e-01f, -7.74096176e-02f, 7.09526688e-02f, 3.15655917e-01f, 1.29034758e-01f, 1.57684654e-01f, 3.76741402e-02f, 6.54387549e-02f, -8.51190090e-02f,
  1.18616275e-01f, -8.25660229e-02f, -3.07534814e-01f, 8.16920772e-02f, 5.83928563e-02f, -2.27106690e-01f, 3.54696847e-02f, -1.47723965e-02f, -9.65135023e-02f, -1.13429679e-02f,
  1.49052050e-02f, -8.87816586e-03f, -5.54614514e-03f, 7.16603398e-02f, 1.80755686e-02f, 1.24604352e-01f, 8.54380988e-03f, -5.48694544e-02f, 1.25806242e-01f, 1.98900253e-02f,
  1.39060691e-01f, -1.81613211e-02f, -2.32213307e-02f, -7.87457973e-02f, -2.61876304e-02f, 5.91365248e-02f, -4.80930060e-02f, 5.54642780e-03f, 3.91356722e-02f, -6.61786869e-02f,
  4.59248060e-03f, 3.57924141e-02f, 4.55217659e-02f, 4.93169948e-02f, -5.79053275e-02f, 5.71881719e-02f, 3.28859165e-02f, 5.43213077e-02f, 9.58442409e-03f, -1.11697085e-01f,
  -8.04796070e-02f, 4.64392118e-02f, 9.35905948e-02f, 4.39341068e-02f, 6.77169710e-02f, 1.18698962e-01f, 5.43921664e-02f, -5.71284955e-03f, 3.82956192e-02f, 7.52742514e-02f,
  -9.28800777e-02f, -5.39969057e-02f, -1.32288635e-02f, -3.47522646e-02f, -7.12351575e-02f, 5.19851334e-02f, -1.44236693e-02f, 2.02988237e-02f, -3.94394659e-02f, -9.16007161e-02f,
  -4.69038263e-03f, -2.54401956e-02f, -8.82907119e-03f, -6.31626919e-02f, 1.12286629e-02f, 7.11645707e-02f, -1.44554181e-02f, 1.09531837e-04f, 1.23225641e-03f, -2.35581975e-02f,
  -2.22006589e-02f, -3.42281233e-03f, -4.78757471e-02f, 8.95097479e-02f, 5.00388406e-02f, -7.96953663e-02f, -2.05057543e-02f, -2.51886733e-02f, -2.34058797e-02f, -8.35848376e-02f,
  -1.06230654e-01f, -2.80967444e-01f, -2.36975122e-02f, 4.44731712e-02f, 5.52190691e-02f, 2.29545888e-02f, -1.67977866e-02f, 4.16195206e-02f, -2.53256666e-03f, -7.29039535e-02f,
  1.31167293e-01f, 8.44623893e-02f, -2.64264038e-03f, -1.21741686e-02f, 9.39337420e-04f, -1.60071012e-02f, 7.18275979e-02f, -4.58634235e-02f, 6.98078657e-03f, -5.18558957e-02f,
  4.14437465e-02f, 6.47299737e-02f, -3.86076830e-02f, 5.55239916e-02f, 9.26668048e-02f, 3.61009017e-02f, 4.25892174e-02f, 2.80003585e-02f, -3.27473767e-02f, -1.28480354e-02f,
  1.11251384e-01f, -8.97693038e-02f, 8.19842294e-02f, -7.52009824e-02f, -1.15784131e-01f, 6.45945370e-02f, 3.40532750e-01f, -2.64059156e-01f, -4.91878279e-02f, -2.47064352e-01f,
  -1.59592256e-01f, 2.00545922e-01f, 3.33411723e-01f, -3.44357342e-01f, 6.11487627e-01f, 3.31173509e-01f, -3.91293876e-02f, -1.69430040e-02f, -6.98090866e-02f, -1.37365967e-01f,
  -3.11473124e-02f, -3.16611052e-01f, -3.53485793e-02f, -4.30157989e-01f, -3.93881142e-01f, -2.84335226e-01f, -9.04323533e-02f, 4.95678820e-02f, -3.77635688e-01f, -8.79513938e-03f,
  -5.57298325e-02f, -1.22151189e-01f, -8.63863677e-02f, 2.48584747e-02f, -9.89665762e-02f, 7.99361989e-02f, 5.50970063e-02f, 1.54557079e-01f, 1.46877300e-02f, -1.63805392e-02f,
  4.01448198e-02f, -3.55358273e-02f, -9.76767913e-02f, -4.48482577e-03f, -1.26792882e-02f, -1.70752183e-01f, -2.14716755e-02f, -4.86106537e-02f, -3.43427481e-03f, -4.13314141e-02f,
  -1.28974551e-02f, 4.13412042e-02f, 8.63029994e-03f, 2.51909588e-02f, 6.46639764e-02f, 2.56849583e-02f, 1.25589982e-01f, 1.79198399e-01f, 2.78132185e-02f, -4.45723459e-02f,
  6.49345368e-02f, 3.75325535e-03f, -1.10216746e-02f, -7.85029680e-02f, -1.79140382e-02f, -8.11820328e-02f, -3.23240235e-02f, 1.18362754e-04f, 1.90315978e-03f, -7.19658807e-02f,
  -5.91043979e-02f, -8.96707829e-03f, -5.47609143e-02f, 2.33062580e-02f, -2.35839617e-02f, -2.79847113e-03f, 3.47021557e-02f, -1.22842826e-02f, 2.61820909e-02f, 8.22261267e-04f,
  4.12774645e-02f, 6.24671811e-03f, -5.13583720e-02f, 2.55839527e-02f, -4.53838613e-03f, 3.77162248e-02f, -1.53638711e-02f, 3.90114412e-02f, -2.65983213e-02f, 9.54024121e-02f,
  -1.55148981e-02f, 7.26883709e-02f, -3.07144821e-02f, -6.05620584e-03f, 2.52036527e-02f, -7.22842216e-02f, 1.31432656e-02f, -6.21020272e-02f, 1.16310485e-01f, 7.84563720e-02f,
  -7.85973594e-02f, 5.52096441e-02f, -3.47577855e-02f, -1.11132406e-03f, 3.15546943e-03f, 9.42788273e-03f, 8.42485577e-02f, 5.49899153e-02f, 5.40953726e-02f, -6.23648278e-02f,
  -2.22614873e-02f, 2.02374309e-02f, 8.36439282e-02f, -4.54766229e-02f, -5.35605922e-02f, 4.50722463e-02f, 1.80297829e-02f, 2.08989270e-02f, 1.86632108e-02f, 2.04081349e-02f,
  8.03495497e-02f, 4.63202119e-01f, 2.13962644e-01f, -7.14141503e-02f, -2.57946998e-01f, 2.53699794e-02f, -8.49781260e-02f, 2.31999482e-04f, 3.48581076e-01f, 4.33584899e-01f,
  -2.78358340e-01f, 5.69801211e-01f, -7.95876384e-02f, -3.49401571e-02f, -4.01409924e-01f, -3.84832472e-02f, 3.09750754e-02f, 1.01675518e-01f, 1.92127619e-02f, -4.62943967e-03f,
  -1.97382405e-01f, -3.20110232e-01f, -2.17169300e-01f, -1.42320991e-01f, -3.77612934e-02f, 2.06539765e-01f, -2.87960052e-01f, -1.15559272e-01f, -3.06399204e-02f, 2.62787510e-02f,
  -2.92539354e-02f, 5.09534478e-02f, 3.93881239e-02f, 1.43539265e-01f, -8.94991979e-02f, -6.03392795e-02f, 6.70662075e-02f, -2.06335280e-02f, -1.32152244e-01f, 2.51151230e-02f,
  1.66349113e-01f, -6.84922785e-02f, 5.08957505e-02f, -2.48053074e-02f, 1.81214511e-02f, 1.18606277e-01f, -4.75314260e-02f, -2.99588274e-02f, 1.00609489e-01f, -3.42880376e-02f,
  4.22139131e-02f, 3.56335454e-02f, -2.07253583e-02f, 2.09490787e-02f, 1.72191113e-02f, -3.70331071e-02f, 2.03385986e-02f, -4.38035168e-02f, 3.71776521e-02f, -3.41654080e-03f,
  4.21897583e-02f, -1.49010718e-02f, -1.40969297e-02f, -3.41055711e-04f, 4.84536327e-02f, -2.79364176e-04f, 4.96328846e-02f, -1.80133451e-02f, 7.96228349e-02f, -3.59299444e-02f,
  3.93853560e-02f, -9.42191482e-03f, -6.63917931e-03f, -2.88785845e-02f, 4.06019837e-02f, 4.01704349e-02f, -2.90845092e-02f, 7.26635084e-02f, 6.72830194e-02f, -4.52280305e-02f,
  3.88570614e-02f, -6.35947799e-03f, -4.62920219e-02f, -4.05704193e-02f, -1.79750770e-02f, -3.75865363e-02f, 1.45125538e-02f, 4.33767866e-03f, -6.36271611e-02f, -1.25082433e-01f,
  -5.51334806e-02f, 1.89527899e-01f, 6.43169433e-02f, 4.76311632e-02f, 1.05892971e-01f, 1.71007272e-02f, -4.04548347e-02f, 6.53620735e-02f, 6.26357794e-02f, 1.96854211e-02f,
  7.36734793e-02f, 1.14228539e-01f, 4.30500545e-02f, -2.41032355e-02f, 9.41074714e-02f, -2.48741284e-02f, 8.97641703e-02f, -2.51433477e-02f, 2.37220265e-02f, -5.46059944e-02f,
  -3.47565152e-02f, 8.66200328e-02f, -2.18996406e-02f, 4.77157757e-02f, -6.05605729e-02f, -3.72476876e-02f, 3.69518138e-02f, 5.06038330e-02f, -2.72536883e-03f, 7.91692920e-03f,
  -2.36788973e-01f, -3.83042656e-02f, 8.71270448e-02f, -1.16627850e-01f, 1.66370778e-03f, -6.72497321e-04f, -2.85056718e-02f, 3.68463900e-03f, 1.20599911e-01f, 1.30807638e-01f,
  -4.16857041e-02f, -1.48696214e-01f, 8.67611691e-02f, 8.83583426e-02f, -8.30571353e-02f, 2.71524731e-02f, 9.52959135e-02f, -5.49986139e-02f, 7.62965232e-02f, 3.76915671e-02f,
  8.42181593e-02f, -5.56844771e-02f, 3.60582806e-02f, 1.57584190e-01f, 8.90216008e-02f, 7.28286207e-02f, -9.65344608e-02f, 2.76902691e-02f, -1.00353338e-01f, 1.72148626e-02f,
  -7.95468539e-02f, -7.16138259e-02f, -9.83475801e-03f, 9.52086970e-02f, -3.11307050e-02f, 2.40933504e-02f, 2.45223381e-02f, 3.03009767e-02f, -5.62758520e-02f, 1.04599267e-01f,
  -7.83061907e-02f, 1.33368410e-02f, -7.02288151e-02f, -9.03443620e-03f, 5.37450053e-03f, 4.22653258e-02f, 5.64103797e-02f, -8.61838181e-03f, 3.47520784e-02f, -1.13458494e-02f,
  -1.65140338e-03f, -2.04385724e-02f, -3.12827192e-02f, -1.13506317e-02f, 5.50164580e-02f, -2.46646572e-02f, -1.86989140e-02f, -2.27735229e-02f, -1.19213806e-02f, -6.88750073e-02f,
  1.00913249e-01f, 2.16225423e-02f, 1.87861621e-02f, 2.60353759e-02f, 5.99101707e-02f, 5.53231628e-04f, 3.91509682e-02f, -2.49600853e-03f, -4.31942344e-02f, 7.83719346e-02f,
  -7.66745508e-02f, 2.46873349e-02f, 1.74022671e-02f, -1.51208378e-02f, 4.82483767e-03f, -2.97145359e-02f, 2.92996299e-02f, 3.99764404e-02f, 8.13396648e-02f, 8.06209892e-02f,
  -7.66055435e-02f, -5.33777885e-02f, -2.05267873e-02f, -3.66999060e-02f, 4.33914624e-02f, 4.94944416e-02f, 6.38752207e-02f, 2.44764462e-02f, 5.19894846e-02f, -7.81673938e-02f,
  -1.97886258e-01f, -1.98289797e-01f, -4.81585115e-02f, -1.07149892e-01f, -2.50160303e-02f, 2.00275257e-02f, 6.84350654e-02f, -8.00084323e-03f, -4.68219407e-02f, -4.26023826e-02f,
  2.52477750e-02f, 6.72873780e-02f, -6.51060417e-02f, -2.33354922e-02f, -4.72765453e-02f, 6.02158271e-02f, -1.59669593e-02f, -9.25942734e-02f, -9.01696756e-02f, 6.86137080e-02f,
  -8.10660888e-03f, 1.66225843e-02f, 3.15685337e-03f, 1.66345332e-02f, -4.30362038e-02f, -2.18765959e-02f, -3.31815481e-02f, 5.29576540e-02f, -3.81079204e-02f, 7.42641985e-02f,
  -2.42195413e-01f, 1.67711556e-01f, -3.91810119e-01f, -3.72670203e-01f, -1.45226926e-01f, -3.27294260e-01f, -4.24931169e-01f, -1.85247824e-01f, -5.89069203e-02f, 5.33690490e-02f,
  -6.99797049e-02f, -9.89171341e-02f, 2.74779975e-01f, -1.43774375e-01f, -9.06686708e-02f, 3.55095088e-01f, -3.28108042e-01f, -1.63218722e-01f, 8.22505876e-02f, -3.59524876e-01f,
  -1.21902116e-01f, -1.42512158e-01f, -6.56408966e-02f, -6.10243753e-02f, -3.46793592e-01f, -2.04243332e-01f, -7.52176065e-03f, -9.62601155e-02f, -2.53207535e-01f, 2.09264327e-02f,
  1.35460617e-02f, -1.15572765e-01f, -3.93671133e-02f, -1.12756761e-02f, -1.15373604e-01f, -1.13749959e-01f, -1.18826635e-01f, -3.32019813e-02f, 2.83797197e-02f, -5.55299595e-02f,
  -5.72046973e-02f, -3.51875313e-02f, 1.52501231e-02f, 1.76602304e-02f, 3.49593088e-02f, -6.76444694e-02f, 5.12057170e-03f, -6.53444827e-02f, -1.32641736e-02f, 1.78915877e-02f,
  -8.63727555e-02f, 6.78397790e-02f, -5.99365830e-02f, 5.29492646e-02f, -3.08307204e-02f, -1.58557855e-02f, 3.35914753e-02f, -4.46981117e-02f, -4.20422517e-02f, -2.37536826e-03f,
  -3.83256488e-02f, -1.78374704e-02f, 5.67543507e-02f, 2.00033020e-02f, -6.24948065e-04f, 3.82932387e-02f, -3.62948999e-02f, 1.48928994e-02f, 1.07259187e-03f, 4.01408486e-02f,
  -9.86163132e-03f, -6.33688793e-02f, 2.15584747e-02f, -3.37881185e-02f, -3.67029011e-02f, 3.06003578e-02f, -3.67754586e-02f, 1.97692718e-02f, -1.16816185e-01f, 3.15359719e-02f,
  -3.63432616e-02f, 4.71956749e-03f, 8.07400271e-02f, 5.88212423e-02f, -7.07112029e-02f, -5.79086281e-02f, -9.19460282e-02f, 3.71179432e-02f, -2.08246987e-02f, 2.95354519e-03f,
  -1.82156637e-01f, -1.78971291e-01f, 2.04824773e-03f, 6.26848489e-02f, 2.26524845e-02f, -8.95352289e-02f, 5.26423566e-04f, -5.75508922e-02f, -1.32367849e-01f, -3.89191732e-02f,
  -1.13764510e-01f, -5.84781170e-02f, -5.16230613e-02f, 5.23916483e-02f, -5.85632548e-02f, -5.46336267e-03f, -4.32484150e-02f, -3.95784006e-02f, -1.05422571e-01f, -4.77948748e-02f,
  -3.52801196e-02f, 5.56999706e-02f, -4.34374437e-02f, -1.77503303e-02f, -5.00655435e-02f, -4.00961153e-02f, -1.86559148e-02f, -4.86100614e-02f, 8.01265799e-03f, 1.72362700e-02f,
  -5.30572534e-02f, 3.07145417e-02f, -6.47471026e-02f, 8.69039297e-02f, -1.72665596e-01f, -2.34808624e-01f, -2.77587265e-01f, 7.53024966e-02f, -1.08476430e-01f, 1.18497364e-01f,
  2.04765350e-01f, 1.89578459e-02f, 1.63629636e-01f, 5.44331549e-03f, -6.98015839e-02f, 2.27102358e-02f, -3.64665277e-02f, -4.14349958e-02f, 2.20825076e-02f, 1.92169935e-01f,
  8.90322477e-02f, 1.12266019e-01f, 1.68891862e-01f, 1.86466783e-01f, -6.77530095e-02f, 2.29788631e-01f, 3.32757443e-01f, 1.47874326e-01f, 1.11038320e-01f, -5.89306802e-02f,
  3.44809107e-02f, 1.81303084e-01f, -4.63467538e-02f, -2.48695910e-02f, 1.26967534e-01f, 3.28091462e-03f, -7.64175057e-02f, -1.07352011e-01f, 2.88138874e-02f, 3.40862907e-02f,
  -4.84430455e-02f, -1.90491378e-02f, 3.88365053e-02f, -2.32072379e-02f, -3.20419036e-02f, 2.28358693e-02f, -3.03470157e-02f, 2.29717530e-02f, 8.46979246e-02f, -5.56022339e-02f,
  -5.39916046e-02f, 2.67177708e-02f, 2.81078480e-02f, -1.79239479e-03f, -8.74232780e-03f, -8.56637768e-03f, -2.75487844e-02f, 3.82841937e-02f, 7.00767040e-02f, -3.77311893e-02f,
  1.07092932e-01f, 7.71753909e-03f, 2.73852143e-02f, -8.61002207e-02f, -6.67956099e-02f, 8.71326998e-02f, -2.12179720e-02f, 8.04321021e-02f, 4.44861352e-02f, 3.18823010e-02f,
  -4.24438007e-02f, 2.11600251e-02f, 8.30487385e-02f, 6.57683685e-02f, 8.67874622e-02f, 2.74888985e-02f, -2.79655978e-02f, 7.68643692e-02f, -7.34343473e-03f, 1.47546101e-02f,
  7.05189724e-03f, 3.35688181e-02f, -6.71492741e-02f, -5.13280183e-02f, -5.65942898e-02f, -6.36426508e-02f, 2.13084612e-02f, 3.49491648e-02f, -4.03316170e-02f, -6.59694895e-02f,
  1.33161113e-01f, 3.11871499e-01f, 3.05405017e-02f, -9.93812308e-02f, 7.95031525e-03f, 3.61624584e-02f, 3.96218225e-02f, -3.62254307e-02f, 9.27583054e-02f, 4.68947273e-03f,
  1.46370545e-01f, 4.00217623e-03f, 8.25601816e-02f, -3.87625732e-02f, -8.22662935e-02f, 6.30863905e-02f, 1.66927561e-01f, -7.37110227e-02f, 9.87840369e-02f, 2.70368103e-02f,
  4.77362797e-02f, 1.15366662e-02f, 1.81113109e-02f, -8.34195837e-02f, -6.19191956e-03f, -2.87954994e-02f, -8.21313187e-02f, 7.68927857e-02f, 3.45331058e-02f, 1.43607305e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 26)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 26;
const float L0_fan_Bp_bar_data[] = {
  1.56087562e-01f, 4.97553237e-02f, 6.43929183e-01f, 7.47591332e-02f, 6.31176457e-02f, 4.33920398e-02f, 7.80903623e-02f, 4.28340305e-03f, 1.17902085e-01f, 1.37255237e-01f,
  2.66047120e-01f, 4.79115754e-01f, 2.97107548e-01f, 4.41587269e-01f, 2.45561630e-01f, 1.78597704e-01f, 2.58622527e-01f, 2.65317202e-01f, 2.84643710e-01f, 3.77733886e-01f,
  2.54425377e-01f, 3.93321931e-01f, 6.07039452e-01f, -2.53004208e-02f, 3.29467654e-01f, 1.39815986e-01f
};

// L1_fan_Wp (Shape: 3 x 32)
const int L1_fan_Wp_rows = 3;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  1.29573988e-02f, 1.25952084e-02f, 3.11193734e-01f, -2.29766935e-01f, -2.03947559e-01f, 4.46440965e-01f, -1.88096389e-01f, 6.08681366e-02f, 3.30881417e-01f, -9.46663767e-02f,
  4.76096645e-02f, 5.84503077e-02f, 2.33047634e-01f, 8.27621445e-02f, -1.08681433e-01f, 7.56217986e-02f, 1.35596082e-01f, 1.80131868e-01f, -3.42463315e-01f, -2.91470643e-02f,
  8.48388076e-02f, -1.00845821e-01f, -1.25189230e-01f, -2.26108238e-01f, -2.26333871e-01f, -1.42507240e-01f, 2.21097305e-01f, 1.22537762e-01f, 2.82158643e-01f, 7.80843198e-02f,
  -2.90950239e-01f, -3.30578595e-01f, 1.02573827e-01f, 3.17321539e-01f, 1.52784035e-01f, -4.83175993e-01f, 1.13113783e-01f, 3.16829056e-01f, -3.19184095e-01f, -9.45491418e-02f,
  2.19870701e-01f, 2.53693074e-01f, 1.41260952e-01f, 9.64774191e-02f, -1.27195045e-01f, 3.00534695e-01f, -1.87905252e-01f, 1.25968419e-02f, -3.22796673e-01f, 1.33992791e-01f,
  -4.83424887e-02f, -3.77618939e-01f, -1.02743581e-01f, 1.12006046e-01f, 1.96195364e-01f, -1.34469092e-01f, 2.12184891e-01f, 2.41085887e-01f, 2.31746733e-01f, 2.31602103e-01f,
  1.65961727e-01f, 1.39205791e-02f, 1.49912074e-01f, -1.27378464e-01f, 9.23116207e-02f, -3.98216695e-02f, 2.42257968e-01f, 1.81728497e-01f, -1.48803055e-01f, 4.92256105e-01f,
  -1.05825908e-01f, 1.85774162e-01f, -2.40647182e-01f, 1.65233716e-01f, 1.26154199e-01f, 2.55141743e-02f, -2.86844552e-01f, 4.63176630e-02f, 1.27352336e-02f, -2.19778404e-01f,
  2.30492666e-01f, 1.52556030e-02f, -6.63008317e-02f, -1.49507429e-02f, -2.30410054e-01f, 9.04295370e-02f, 1.54293418e-01f, -1.73953306e-02f, -1.84169486e-01f, 2.19429433e-01f,
  -1.53097078e-01f, 1.95214093e-01f, 2.72423357e-01f, -6.33237930e-03f, 2.89960593e-01f, 3.88404727e-02f
};

// L1_fan_Wp_bar (Shape: 26 x 32)
const int L1_fan_Wp_bar_rows = 26;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  2.07029700e-01f, 4.28150833e-01f, 2.72049457e-01f, -2.85631657e-01f, -1.68904200e-01f, 1.13194980e-01f, 6.64155930e-02f, -3.10401991e-03f, 4.34246331e-01f, 7.57799745e-02f,
  9.13253948e-02f, 2.54975051e-01f, -8.14455003e-02f, 1.69874415e-01f, 1.96018249e-01f, -8.34257081e-02f, -1.74132600e-01f, 4.87143427e-01f, -1.89258277e-01f, -2.54051447e-01f,
  -2.18207583e-01f, 3.53730828e-01f, -4.75944690e-02f, -2.72640791e-02f, -5.64017296e-02f, -4.30622250e-02f, 2.80522645e-01f, -1.73496440e-01f, 3.31458181e-01f, 1.88940510e-01f,
  1.08040325e-01f, -2.14626640e-01f, 2.69865781e-01f, 1.94987744e-01f, 1.84906587e-01f, 2.81432539e-01f, 1.35627732e-01f, 2.49447346e-01f, 6.19108975e-02f, -3.60065959e-02f,
  3.11962008e-01f, 1.73499942e-01f, 1.80629835e-01f, 8.46141875e-02f, 2.43174043e-02f, 1.84845418e-01f, -8.30514356e-03f, -6.89258724e-02f, 1.01088785e-01f, 2.58912086e-01f,
  -6.84835538e-02f, -6.62601041e-03f, -9.31847245e-02f, 3.64031084e-02f, -1.98228210e-01f, 2.56229155e-02f, 1.83642089e-01f, -2.33428866e-01f, -2.30615556e-01f, 3.35741937e-01f,
  5.12213409e-01f, -1.39993027e-01f, 1.10991962e-01f, 6.49531186e-02f, -2.92912498e-02f, -1.81376338e-01f, 7.87610412e-02f, -9.64302719e-02f, 2.95419693e-01f, -2.11334527e-01f,
  1.74122795e-01f, -1.18711159e-01f, 1.14169523e-01f, -3.26456241e-02f, -9.75673199e-02f, -9.05314088e-02f, -9.57219526e-02f, -1.15793355e-01f, -2.13735551e-01f, -2.11896434e-01f,
  1.55895457e-01f, -2.06270069e-01f, -6.36448190e-02f, -1.10750712e-01f, -9.19878930e-02f, -9.55245122e-02f, -1.09301299e-01f, -6.31072670e-02f, -7.12345019e-02f, -4.18073907e-02f,
  2.82444954e-02f, 1.69526309e-01f, 3.43041830e-02f, -1.33113131e-01f, 7.71458149e-02f, 3.35949302e-01f, -3.74305025e-02f, 1.63459718e-01f, 1.70427963e-01f, -1.98314190e-02f,
  -3.01267833e-01f, -4.23742294e-01f, 2.70300984e-01f, -9.54325944e-02f, -9.49089453e-02f, 1.29716530e-01f, 5.09072915e-02f, 2.15329781e-01f, -1.34476172e-02f, -2.03617975e-01f,
  3.32894742e-01f, 3.73815209e-01f, -1.23168598e-03f, 3.78843307e-01f, 1.32681161e-01f, 5.50889909e-01f, 3.65462065e-01f, 1.01697937e-01f, 3.86643022e-01f, 2.18926236e-01f,
  -2.03087538e-01f, 7.40357786e-02f, 3.78861874e-01f, 1.02972090e-01f, -2.89117128e-01f, 9.20685101e-03f, 2.43715048e-01f, 1.82639211e-02f, -1.11671075e-01f, 2.69605480e-02f,
  -7.32566491e-02f, 2.04540521e-01f, 7.33794048e-02f, 2.47623295e-01f, 6.44193143e-02f, 2.23251969e-01f, 1.58743307e-01f, -5.26943617e-02f, 1.57212347e-01f, -1.77456096e-01f,
  1.02182820e-01f, 7.41595402e-02f, -1.61139101e-01f, -1.00463755e-01f, 1.91751704e-01f, 5.05616795e-03f, 2.19066426e-01f, -8.86131674e-02f, 1.20645270e-01f, -1.59995019e-01f,
  -2.84820884e-01f, 1.93630829e-01f, -6.24863468e-02f, -1.43275768e-01f, -8.95029120e-03f, 2.36445174e-01f, 3.77807975e-01f, 8.33194777e-02f, 2.42183283e-01f, 6.38673306e-02f,
  8.90913885e-03f, -1.54361263e-01f, 2.06173211e-01f, 1.42075792e-01f, 3.33573341e-01f, -8.34707990e-02f, 1.77441671e-01f, -3.60964797e-02f, -9.72990766e-02f, -5.05926758e-02f,
  5.87914363e-02f, -4.51472308e-03f, 7.69394785e-02f, 1.10917546e-01f, -1.77781448e-01f, -2.76418239e-01f, -2.01735850e-02f, -5.16707152e-02f, 1.64018497e-01f, 5.19696623e-02f,
  -1.92788109e-01f, -1.82927445e-01f, 1.31818414e-01f, 3.05750817e-01f, -2.80688833e-02f, -1.30453417e-02f, -2.47495458e-01f, 9.86506715e-02f, 4.10295418e-03f, 4.83212397e-02f,
  1.19796127e-01f, 4.66816694e-01f, 1.63546354e-01f, 4.16396528e-01f, 5.80278225e-02f, 1.84636205e-01f, 2.13951439e-01f, -2.00941376e-02f, 1.52125061e-01f, -8.05319697e-02f,
  4.09859568e-01f, -1.23457842e-01f, 1.13042951e-01f, 7.26511702e-03f, 2.49480367e-01f, -7.94311389e-02f, 2.88862199e-01f, 2.42075369e-01f, 6.80967569e-02f, -9.62800458e-02f,
  3.80365789e-01f, 3.52663428e-01f, 2.57522792e-01f, -2.33478829e-01f, -2.79399037e-01f, -2.61073172e-01f, 2.46996298e-01f, -1.90426230e-01f, 1.93015441e-01f, 1.24550663e-01f,
  3.12889069e-01f, -1.24215588e-01f, -1.87136769e-01f, -1.36329547e-01f, 3.27324390e-01f, -6.81886747e-02f, 1.33992389e-01f, -2.38504723e-01f, 3.48538667e-01f, -2.57240802e-01f,
  2.37125099e-01f, 1.16536528e-01f, 5.34282386e-01f, -2.29694135e-02f, -1.09566577e-01f, 3.95704992e-02f, -9.18494016e-02f, -8.88744891e-02f, -8.69145691e-02f, -1.64857686e-01f,
  2.74594277e-01f, -2.42201895e-01f, 2.20103219e-01f, -1.76784456e-01f, -7.76213259e-02f, 1.43553406e-01f, -2.18693376e-01f, -8.91795605e-02f, -5.18856645e-02f, -2.22726032e-01f,
  -7.72143230e-02f, -1.77999124e-01f, 2.77279824e-01f, -9.51054394e-02f, -1.65375933e-01f, 1.81681514e-01f, -2.24148724e-02f, 5.65712005e-02f, -1.56326875e-01f, 6.27364367e-02f,
  5.42388149e-02f, -2.95794513e-02f, 7.45252892e-02f, -1.52996391e-01f, -3.12646106e-02f, 4.59273122e-02f, 6.68716580e-02f, 2.00708359e-01f, 2.39610955e-01f, -9.17611644e-02f,
  2.34792069e-01f, 1.86131150e-02f, -2.18655959e-01f, 5.19007109e-02f, 6.23397231e-02f, 9.46425870e-02f, 2.72330403e-01f, -9.28978398e-02f, 2.55185276e-01f, 2.63620198e-01f,
  -3.50507051e-02f, -1.85046881e-01f, 1.44113004e-01f, 1.83004916e-01f, 1.23070277e-01f, -9.32223275e-02f, 2.68575549e-01f, -1.52944654e-01f, 2.09656686e-01f, 2.71461725e-01f,
  8.14396236e-03f, -1.70147806e-01f, -2.52655715e-01f, 8.12318847e-02f, 2.60190427e-01f, -1.52043626e-01f, 2.68325150e-01f, 1.32698521e-01f, 1.07753068e-01f, 1.20429970e-01f,
  3.58450979e-01f, -8.94985572e-02f, 1.80183232e-01f, 9.04174969e-02f, -1.79234028e-01f, 6.12222970e-01f, -5.22206202e-02f, 8.18781555e-02f, 2.40128890e-01f, 1.27925292e-01f,
  4.78194475e-01f, 2.97725409e-01f, -1.20083995e-01f, -2.67416149e-01f, 2.82256722e-01f, 3.25616062e-01f, -2.24967510e-01f, -1.29450783e-01f, 1.42948702e-01f, -2.89208800e-01f,
  5.44126406e-02f, -9.10968930e-02f, 1.48325279e-01f, -2.66004473e-01f, -2.47597154e-02f, 6.48498610e-02f, 1.86348334e-02f, 6.47292733e-02f, -8.22990909e-02f, 1.61706463e-01f,
  -1.21243425e-01f, 1.61055997e-01f, -3.84760052e-02f, -5.89399226e-02f, -5.10676503e-02f, -9.41906571e-02f, 6.92052320e-02f, 1.61749572e-01f, -8.26736838e-02f, -1.47780761e-01f,
  -1.42995730e-01f, -5.10594342e-03f, 1.49330482e-01f, 1.20496444e-01f, -9.65648070e-02f, -2.76408438e-02f, -9.12765414e-02f, 2.93075889e-01f, -1.88771576e-01f, -1.28075257e-01f,
  3.29317548e-03f, 5.47202714e-02f, 7.28724673e-02f, 1.02784269e-01f, -8.08601305e-02f, 3.79903764e-01f, -7.19464123e-02f, -1.81441039e-01f, 4.01370227e-02f, -1.68415323e-01f,
  -1.60990119e-01f, -1.91380322e-01f, 2.60477513e-01f, 1.61392596e-02f, -2.49865472e-01f, -1.95502773e-01f, -8.14708173e-02f, 1.37410969e-01f, -2.83575132e-02f, -4.39912640e-02f,
  3.00889909e-01f, 1.13236405e-01f, 1.57497182e-01f, -3.08637708e-01f, 1.48064062e-01f, 3.91855270e-01f, 1.95798457e-01f, 1.38581961e-01f, 6.06019907e-02f, 1.66052610e-01f,
  1.12334192e-02f, -1.16112232e-01f, 4.91448343e-01f, -2.65661012e-02f, -1.15519993e-01f, 3.22485156e-02f, 2.13282555e-01f, -1.11390226e-01f, 2.99961686e-01f, 4.04933393e-02f,
  -2.49575153e-01f, 2.02204496e-01f, 7.75680780e-01f, -5.07794879e-02f, 6.85198745e-03f, 5.29986620e-02f, 2.95157820e-01f, 4.77576442e-02f, -1.71504587e-01f, -1.00424737e-01f,
  -1.26683876e-01f, 4.51739609e-01f, -4.70260642e-02f, 1.70637891e-01f, 1.22664571e-01f, 4.99803014e-03f, -3.24669629e-01f, 2.61591058e-02f, 1.02264464e-01f, -2.51418829e-01f,
  1.00372367e-01f, -2.84083903e-01f, 1.32190019e-01f, 8.82345904e-03f, -2.19648734e-01f, -6.64036497e-02f, -5.50286956e-02f, 2.17626970e-02f, 1.85502142e-01f, 2.75127888e-01f,
  -8.75198469e-02f, 1.15091108e-01f, -1.01135381e-01f, 2.49426529e-01f, 5.38349986e-01f, -2.10926265e-01f, 1.81219652e-01f, -6.63215248e-03f, 3.02575380e-01f, -7.44526312e-02f,
  -1.64608121e-01f, -8.10118839e-02f, 7.35002980e-02f, 9.46620330e-02f, -1.81498185e-01f, 3.92111838e-01f, 1.58823952e-01f, 1.01272419e-01f, -8.70945677e-02f, 2.13669166e-01f,
  2.24152151e-02f, -3.08176875e-01f, -2.35186354e-03f, -2.82486528e-02f, 2.85578072e-01f, 5.02130240e-02f, -7.18396530e-02f, -5.95235564e-02f, -7.77809396e-02f, -1.58537582e-01f,
  2.47602686e-01f, -9.97072533e-02f, -3.32928807e-01f, 9.30694342e-02f, -2.50717521e-01f, 2.21132472e-01f, -2.95728371e-02f, -1.38325989e-01f, -1.47829205e-01f, -2.34159622e-02f,
  -7.06976429e-02f, -2.21248820e-01f, -2.97791138e-02f, 2.62421727e-01f, 1.81742162e-01f, 3.16514701e-01f, -2.16922894e-01f, 1.63669303e-01f, -1.38956010e-01f, -3.47330682e-02f,
  4.09729749e-01f, 1.31523028e-01f, 7.28815496e-02f, 3.25196773e-01f, 1.05124637e-01f, 6.73508108e-01f, 6.57471418e-02f, 6.66718325e-03f, 3.39082740e-02f, 8.58988389e-02f,
  9.11889412e-03f, -2.10554153e-02f, 3.65888700e-02f, 2.76240498e-01f, -1.47461787e-01f, -1.16244391e-01f, -5.33807315e-02f, 1.50882915e-01f, -2.07884967e-01f, 2.51685549e-02f,
  2.20947579e-01f, -8.06126073e-02f, 1.41061649e-01f, -5.72999269e-02f, -1.02940157e-01f, -1.60214342e-02f, 2.30899557e-01f, -5.48010133e-02f, -1.17306150e-01f, 2.85572469e-01f,
  -6.48338124e-02f, -1.81636184e-01f, 6.61609753e-04f, 1.13860093e-01f, -6.00638129e-02f, 1.46726817e-01f, 4.83246855e-02f, 3.72504234e-01f, 1.84208807e-02f, -7.41381794e-02f,
  3.07620227e-01f, 7.08218887e-02f, 4.92240995e-01f, 4.88643944e-01f, 1.22320235e-01f, -1.54362442e-02f, 1.40130371e-01f, 4.73460883e-01f, -3.77251118e-01f, 1.51052214e-02f,
  -2.22603995e-02f, 1.07617609e-01f, 1.64785683e-01f, -1.63524449e-01f, -2.75321066e-01f, 1.52680233e-01f, -2.84050107e-01f, -2.52953440e-01f, -1.44496575e-01f, -1.81474045e-01f,
  5.01180887e-01f, -3.22474420e-01f, -1.61369480e-02f, 4.87984419e-01f, -2.73190111e-01f, -1.77758932e-01f, 5.69470286e-01f, 7.12761343e-01f, 9.36133265e-02f, -3.18425447e-01f,
  6.64054215e-01f, -4.18272838e-02f, 6.21989310e-01f, 1.98190346e-01f, -1.15602486e-01f, 1.47791252e-01f, -1.75580084e-01f, 1.32157832e-01f, 1.90866366e-02f, -2.23629743e-01f,
  6.20735064e-02f, 1.01474589e-02f, -1.56131303e-02f, 7.94400573e-02f, 6.90997988e-02f, -1.40510589e-01f, 1.26761481e-01f, 2.97849793e-02f, -1.40995486e-02f, 1.72104746e-01f,
  7.18354210e-02f, -6.48373291e-02f, 1.17427580e-01f, 1.67774364e-01f, 8.32961649e-02f, 1.47718623e-01f, 1.13563307e-01f, -2.21679118e-02f, -1.25461891e-01f, -1.93842545e-01f,
  1.98208354e-02f, -1.95310861e-01f, 2.02987745e-01f, 1.54340833e-01f, -2.03932628e-01f, 1.91697031e-01f, 9.19352658e-03f, -1.18432373e-01f, 3.61439548e-02f, 2.99193770e-01f,
  1.40776962e-01f, -1.28986482e-02f, 3.10088515e-01f, 1.53391480e-01f, 8.30276310e-02f, -9.73556489e-02f, -5.06156050e-02f, -1.52811587e-01f, 6.75574690e-02f, -9.97787341e-02f,
  2.12873495e-03f, -2.05040619e-01f, 7.54890293e-02f, 2.04120606e-01f, -5.03686294e-02f, 6.24585757e-03f, 6.69488236e-02f, -1.76942945e-02f, -9.58048478e-02f, 3.26840430e-01f,
  1.79898098e-01f, 1.07389204e-02f, -1.14111215e-01f, 3.48253220e-01f, 6.14649095e-02f, -1.67491317e-01f, 3.08189273e-01f, 1.79825038e-01f, 2.69753218e-01f, 4.35152709e-01f,
  4.94931370e-01f, 3.24629307e-01f, -2.65679657e-01f, 7.43451953e-01f, -2.24453971e-01f, 4.36089560e-03f, -2.54429340e-01f, 8.44014734e-02f, -1.52272880e-01f, 3.96839201e-01f,
  -3.51123400e-02f, 1.43447846e-01f, 2.37771854e-01f, 1.15917668e-01f, 4.59172606e-01f, 4.01358932e-01f, -4.83725369e-01f, 5.17138779e-01f, -1.81770429e-01f, 3.95809084e-01f,
  -6.18260615e-02f, -1.35232359e-01f, 1.14100575e-01f, 6.06186628e-01f, -4.27178442e-02f, 5.44683933e-02f, 4.29839015e-01f, 3.32224429e-01f, 5.13642311e-01f, -8.03511962e-03f,
  -1.04768783e-01f, 2.39265170e-02f, -2.21343786e-01f, -2.38545433e-01f, 2.52987761e-02f, -1.24642611e-01f, 2.19398782e-01f, 1.55281886e-01f, 9.99471694e-02f, 7.46966451e-02f,
  9.75325983e-03f, -1.06372889e-02f, -3.97059321e-02f, 1.39582098e-01f, 5.24104573e-02f, 1.10070020e-01f, 2.90052772e-01f, 6.46348596e-02f, 1.71656050e-02f, 1.41621172e-01f,
  -4.39845361e-02f, 1.88581944e-01f, 1.06290057e-01f, -3.22190411e-02f, -2.07810067e-02f, 5.31366505e-02f, -1.09336980e-01f, 1.90084264e-01f, -8.45481679e-02f, -4.71182205e-02f,
  -9.05275121e-02f, -2.99364254e-02f, 9.66054052e-02f, -7.31995702e-02f, -7.34689683e-02f, 2.65804201e-01f, 1.51858389e-01f, -1.53788835e-01f, 1.15631558e-02f, 1.03312820e-01f,
  -4.97317463e-02f, -4.22920659e-02f, -8.05233419e-02f, -1.55858556e-03f, -4.59974483e-02f, 1.32556811e-01f, 2.86570285e-02f, -1.60004467e-01f, 1.44333050e-01f, -6.97361678e-02f,
  1.41040862e-01f, 1.63144633e-01f, 1.73243627e-01f, -2.30118826e-01f, -9.80128646e-02f, 1.76806852e-01f, 1.27340049e-01f, -1.16661759e-02f, -1.51898945e-02f, 1.43795937e-01f,
  4.45463276e-03f, 6.67116465e-03f, 4.12526615e-02f, 1.33744702e-01f, 4.66757417e-01f, 2.10088760e-01f, 2.77166665e-01f, 5.35394549e-01f, -1.51463985e-01f, -5.15436113e-01f,
  1.13095820e-01f, -1.44406572e-01f, -2.73443371e-01f, -1.79733470e-01f, 1.36463851e-01f, 1.59689691e-03f, -2.23131537e-01f, -1.31638974e-01f, 3.21348719e-02f, 1.15631379e-01f,
  2.06901506e-01f, -4.29978013e-01f, 5.51457286e-01f, 6.72573566e-01f, 4.83618170e-01f, -2.07620367e-01f, 1.17737360e-01f, -1.01277614e-02f, 2.56229043e-01f, 3.86269271e-01f,
  1.47177175e-01f, -4.11116213e-01f, 1.22448709e-02f, -1.52952120e-01f, -1.10480256e-01f, 2.68520564e-01f, 2.26389423e-01f, 1.23697266e-01f, 3.18783760e-01f, 3.70438695e-01f,
  -3.18346024e-01f, 1.56536341e-01f, 1.80554196e-01f, 1.07337654e-01f, 3.52073461e-01f, 1.59962222e-01f, 1.52414501e-01f, 8.38500336e-02f, 2.24219307e-01f, -3.86070833e-02f,
  2.42675483e-01f, 3.76833901e-02f, -4.25355649e-03f, 1.32928537e-02f, -7.41169900e-02f, 4.61490422e-01f, 3.00270706e-01f, 1.67944506e-02f, 4.44484919e-01f, -1.08688734e-01f,
  -2.57398605e-01f, -3.81983310e-01f, -2.73161288e-02f, 5.02796650e-01f, 3.81466955e-01f, -2.58241504e-01f, -1.87411547e-01f, -1.88470915e-01f, -4.75925505e-02f, 4.31997515e-03f,
  -1.28281727e-01f, -2.09070176e-01f, 1.35364488e-01f, -7.82012194e-02f, 3.99070442e-01f, 1.68974593e-01f, 1.73765674e-01f, 7.75590390e-02f, -1.71098590e-01f, 3.20582651e-03f,
  -1.33328825e-01f, -5.80466576e-02f, 4.36776988e-02f, 8.75139311e-02f, 2.68864930e-01f, -1.56621486e-01f, 4.04103436e-02f, -1.75120488e-01f, 1.12833478e-01f, 1.66791201e-01f,
  -9.35016423e-02f, 1.65780500e-01f, -3.36819654e-03f, -1.15528025e-01f, 1.68979466e-01f, -1.74875230e-01f, 1.13388494e-01f, 6.61528558e-02f, -3.32539864e-02f, 8.82392973e-02f,
  -6.87758476e-02f, -6.86101103e-03f, -1.14664555e-01f, -4.60182607e-01f, 1.27375633e-01f, -4.51246232e-01f, 4.67390001e-01f, -9.78888497e-02f, 2.24284679e-01f, -1.39952436e-01f,
  -2.34786749e-01f, -2.83807516e-01f, -1.93633050e-01f, -2.31333971e-01f, 1.82772372e-02f, 2.61927303e-02f, 2.36726835e-01f, 1.84185565e-01f, 2.05971256e-01f, -1.76065996e-01f,
  -4.71617244e-02f, -1.84467360e-02f, 4.71661925e-01f, 4.75837380e-01f, -2.28175506e-01f, -1.00034773e-01f, 2.64499098e-01f, 2.38760173e-01f, -2.48575777e-01f, -1.88226681e-02f,
  -1.42395809e-01f, 1.45230263e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 26)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 26;
const float L1_fan_Bp_bar_data[] = {
  1.54961377e-01f, 9.57099199e-02f, -6.34678081e-03f, 2.91463584e-01f, 1.68006018e-01f, 7.83061683e-02f, 2.82483459e-01f, 2.64920682e-01f, 6.42240494e-02f, 4.16805863e-01f,
  8.70642290e-02f, 8.80818069e-03f, 2.46153817e-01f, 4.77281511e-02f, -2.26418190e-02f, -9.29932222e-02f, 2.74073720e-01f, 8.12122524e-02f, 2.15105601e-02f, 3.10742974e-01f,
  2.74516791e-01f, 2.10972115e-01f, 2.24084243e-01f, 3.59749585e-01f, -4.64890227e-02f, 3.84213626e-01f
};

// L2_linear_W (Shape: 12 x 32)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 32;
const float L2_linear_W_data[] = {
  3.18647712e-01f, 1.08117163e-01f, -3.25972646e-01f, 6.75042272e-02f, -6.61917448e-01f, 4.96140331e-01f, -3.59847367e-01f, -3.85945708e-01f, -1.95418209e-01f, 3.14609557e-01f,
  -1.48417264e-01f, -3.62313837e-02f, -2.22574055e-01f, -1.83575794e-01f, -3.67451072e-01f, -4.18191254e-01f, -1.20585203e-01f, 1.24865003e-01f, -1.66668773e-01f, 7.67282620e-02f,
  3.98254901e-01f, 4.06169802e-01f, -1.37022540e-01f, -1.13856755e-01f, -1.65789440e-01f, 7.40594268e-01f, 4.95683812e-02f, 5.36609581e-03f, 5.36021471e-01f, -5.59707060e-02f,
  1.11369744e-01f, -1.85966522e-01f, -1.19204722e-01f, -2.20945045e-01f, 9.04350057e-02f, -2.20510662e-01f, -6.23404205e-01f, -2.65084743e-01f, -4.07161444e-01f, -9.97179374e-02f,
  -2.16527268e-01f, 6.69450164e-01f, -2.15532199e-01f, 1.67799026e-01f, 8.37429464e-02f, -3.84989381e-01f, 3.14912736e-01f, 2.24827364e-01f, -2.05619797e-01f, 3.39098573e-01f,
  -5.69314770e-02f, 6.70901537e-02f, -4.12733674e-01f, 1.27041996e-01f, -2.16404274e-01f, 8.14606249e-02f, -1.26344085e-01f, -4.19133365e-01f, -1.74936965e-01f, 2.08377261e-02f,
  7.38129616e-01f, 4.72135782e-01f, -2.50424325e-01f, -2.60279626e-01f, 2.30730847e-01f, 4.24660981e-01f, -2.41729394e-01f, -2.18152493e-01f, -4.79693770e-01f, -6.54955506e-01f,
  1.12457350e-01f, -4.19478327e-01f, -1.69769153e-01f, 4.48849678e-01f, -7.61435404e-02f, -3.62484664e-01f, 9.48408693e-02f, 1.26911208e-01f, 1.68707728e-01f, 4.20606732e-01f,
  1.24067282e-02f, 3.10842432e-02f, -3.51226002e-01f, -2.78074235e-01f, -1.33732900e-01f, -1.99312791e-01f, -3.68907005e-01f, 3.49157304e-02f, -2.46306852e-01f, -6.32280111e-01f,
  2.48463184e-01f, -1.73292711e-01f, -1.51141658e-01f, -8.10051709e-02f, 4.14820254e-01f, 7.98876941e-01f, 1.37387402e-02f, -2.25845188e-01f, -3.38973403e-01f, -4.76650983e-01f,
  1.03101604e-01f, 3.78251165e-01f, -3.48980576e-02f, -2.12959778e-02f, -2.15114262e-02f, -4.34284806e-01f, -2.05292180e-02f, 1.22227184e-01f, -3.55059654e-01f, -1.22036636e-01f,
  -1.17537655e-01f, -4.53918844e-01f, -3.68029624e-02f, -1.41160637e-01f, -7.41696060e-02f, -9.87869799e-02f, -2.30469674e-01f, -2.66500145e-01f, 1.20691621e+00f, -2.30399430e-01f,
  -1.32668823e-01f, 4.05499279e-01f, -2.44280875e-01f, -1.04284644e-01f, -1.71849102e-01f, -4.63409334e-01f, 2.61898972e-02f, -2.01813206e-01f, 4.30143386e-01f, -1.88465148e-01f,
  1.65257856e-01f, 2.87951559e-01f, 7.91383624e-01f, 5.53277433e-01f, 5.41212440e-01f, 1.91241100e-01f, -2.22083375e-01f, 2.74325535e-02f, -2.87508070e-01f, 3.66220810e-02f,
  -3.15620601e-01f, -2.88117498e-01f, 7.50097039e-04f, 1.95506260e-01f, 1.70241281e-01f, -1.71606302e-01f, -2.40483269e-01f, -3.18452179e-01f, -2.79979799e-02f, -1.51928097e-01f,
  1.53062031e-01f, -7.01645836e-02f, -1.34562984e-01f, 1.11315489e+00f, 1.45287529e-01f, -2.28312880e-01f, -4.34796602e-01f, -1.94810703e-01f, -5.80531210e-02f, -2.91972876e-01f,
  -3.07107925e-01f, 5.77290475e-01f, 2.36736715e-01f, 5.26970208e-01f, -4.29215103e-01f, 2.61779219e-01f, -2.54110157e-01f, 4.20791686e-01f, -1.02224916e-01f, -2.98478276e-01f,
  1.63680121e-01f, -2.05291554e-01f, 6.24755561e-01f, 4.46566343e-02f, 1.37574617e-02f, 7.42294546e-03f, -2.35544831e-01f, -1.61597580e-01f, -8.89569372e-02f, 4.95879740e-01f,
  -2.42238659e-02f, 5.61060943e-02f, -4.49434251e-01f, -1.15630381e-01f, 2.50400186e-01f, 5.18555582e-01f, -2.27407571e-02f, 1.05229415e-01f, -2.28910208e-01f, 7.00427592e-01f,
  1.26777455e-01f, -4.37383324e-01f, -3.20891887e-01f, 1.00413173e-01f, 7.18352757e-03f, 4.78552163e-01f, 5.28980374e-01f, -7.76682019e-01f, 3.56897444e-01f, -1.11034457e-02f,
  -1.59283295e-01f, 2.44393289e-01f, -6.58607334e-02f, -9.99778742e-04f, 1.50111541e-01f, -1.54787406e-01f, 1.04481414e-01f, 6.03512883e-01f, -4.29510064e-02f, -3.63206506e-01f,
  8.15404356e-01f, 3.78397584e-01f, -7.61622738e-04f, -1.26172245e-01f, -5.89277208e-01f, -8.17802846e-02f, -8.37290213e-02f, -1.47282764e-01f, -1.15111932e-01f, -1.37485534e-01f,
  -4.39827919e-01f, -2.71642134e-02f, -1.37096182e-01f, -4.93285432e-02f, -2.34157294e-01f, -2.20810890e-01f, -6.41167045e-01f, -4.24700052e-01f, -2.34350234e-01f, 1.82407364e-01f,
  -2.05488965e-01f, 2.91206867e-01f, -4.10888940e-02f, -1.91982277e-02f, 4.69035894e-01f, 3.07322890e-01f, -2.26425409e-01f, -2.30245918e-01f, 1.67514756e-01f, -5.82430810e-02f,
  5.08209430e-02f, 6.86099768e-01f, -1.28592387e-01f, 1.59565806e-01f, 2.40363583e-01f, 3.98378789e-01f, 2.84650773e-01f, -2.13845059e-01f, 4.25042480e-01f, 1.32753745e-01f,
  -1.36349946e-01f, 6.87371194e-02f, -4.12280589e-01f, -3.54618490e-01f, -1.20186366e-01f, 2.80103516e-02f, -7.67039582e-02f, -3.15908678e-02f, 2.84590751e-01f, -6.05869710e-01f,
  -7.11140811e-01f, -5.16006708e-01f, -2.03728899e-01f, 1.71882331e-01f, 4.27622288e-01f, -3.37425530e-01f, 1.08599626e-01f, 5.19059598e-01f, -5.33957444e-02f, 5.99719763e-01f,
  -2.06540376e-01f, -3.04046363e-01f, 1.21977530e-01f, -2.45178826e-02f, 5.55434637e-02f, 6.76211715e-02f, -1.24127708e-01f, -1.92121565e-02f, -3.62611443e-01f, 3.87120806e-02f,
  3.65998954e-01f, -4.75032657e-01f, 1.10206656e-01f, 3.24662507e-01f, 1.67855904e-01f, -2.43682265e-01f, 2.46752501e-01f, 5.87413430e-01f, 5.54993600e-02f, -1.59912392e-01f,
  1.28194317e-01f, 5.87167561e-01f, 4.82939124e-01f, 3.38625431e-01f, -3.10973190e-02f, -6.00771494e-02f, -1.25439689e-01f, 1.78095445e-01f, -1.78972051e-01f, 8.95484909e-03f,
  -4.81442899e-01f, -2.21428022e-01f, 6.70491681e-02f, 5.83829641e-01f, 4.04846489e-01f, -2.25959212e-01f, -3.97299230e-01f, -1.84761375e-01f, 7.37517893e-01f, 1.10163100e-01f,
  -4.83541071e-01f, -3.06027383e-01f, -3.83374915e-02f, -1.69793397e-01f, 4.40953411e-02f, -1.92865044e-01f, -5.58328986e-01f, 4.88995433e-01f, -1.89407855e-01f, 3.89408678e-01f,
  -1.00295767e-01f, 4.88890380e-01f, 3.87286454e-01f, -6.13930702e-01f, 3.47762108e-01f, -2.34665811e-01f, -2.92881876e-01f, -1.51262030e-01f, -1.25552937e-01f, -6.39914945e-02f,
  -1.70804545e-01f, 2.21839789e-02f, 4.29299533e-01f, 1.06224202e-01f, -1.51558101e-01f, -4.37022716e-01f, -1.44248053e-01f, 2.38019332e-01f, -1.93999648e-01f, -2.67627984e-01f,
  2.11262777e-02f, -1.52679607e-02f, 7.37728834e-01f, -1.32807940e-01f, -2.33020648e-01f, -4.68346149e-01f, -2.46844232e-01f, 7.59517103e-02f, 7.79153526e-01f, -4.40371662e-01f,
  2.93352269e-02f, -1.19457774e-01f, -1.57629386e-01f, -3.35180581e-01f, 1.53545782e-01f, 3.24705601e-01f, 2.34643236e-01f, 1.31732658e-01f, 3.94136786e-01f, 4.66668040e-01f,
  9.59926695e-02f, -6.54998422e-01f, 2.64404863e-01f, -1.42147422e-01f, 1.46029472e-01f, 4.89566267e-01f, -1.03762351e-01f, -1.55231968e-01f, -1.46934360e-01f, -1.95980638e-01f,
  4.53150690e-01f, 4.20937687e-01f, -3.02523255e-01f, -1.60704851e-01f, 5.19563198e-01f, 7.22942278e-02f, -2.70602196e-01f, -1.30326465e-01f, -1.65542513e-01f, -2.18814075e-01f,
  -3.39999884e-01f, 2.57401288e-01f, 5.79114370e-02f, -3.11578870e-01f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  -7.41070136e-04f, -1.12944081e-01f, -5.37435561e-02f, 5.69292046e-02f, 3.69729936e-01f, -2.62703933e-02f, 7.59460926e-02f, -1.50424600e-01f, 1.23071587e-02f, -6.26541823e-02f,
  2.28521988e-01f, -8.44511539e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 3, 26
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 3, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        32, 12
    );
    }
    