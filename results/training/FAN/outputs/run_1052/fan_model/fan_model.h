/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 9 x 120)
const int L0_fan_Wp_rows = 9;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  9.25506949e-01f, 1.48753718e-01f, 2.28040919e-01f, 4.94959652e-02f, -1.45313203e-01f, 5.95753118e-02f, 1.96776226e-01f, 9.37054381e-02f, -9.60286427e-03f, -3.16599756e-02f,
  -1.65866524e-01f, -1.90619752e-01f, -1.81803688e-01f, -8.62312168e-02f, 1.98164955e-01f, 2.52432436e-01f, 9.96165499e-02f, 2.20103219e-01f, 1.37616903e-01f, 7.31421113e-02f,
  -2.06529170e-01f, 1.40801236e-01f, 1.48568586e-01f, 3.24840844e-02f, 4.41420488e-02f, -1.34638339e-01f, -1.06080644e-01f, -8.54755491e-02f, -1.63264945e-01f, 6.13235384e-02f,
  1.87612385e-01f, 3.53817970e-01f, -4.71788868e-02f, -7.02741221e-02f, 1.28932926e-03f, 9.89814252e-02f, 6.74314499e-02f, 7.47087151e-02f, 1.09963422e-03f, 8.23385790e-02f,
  2.95867957e-02f, 3.42505649e-02f, 4.19627652e-02f, -1.16397448e-01f, 9.45788175e-02f, 1.30804092e-01f, 6.65698647e-02f, 1.57074720e-01f, 7.83874243e-02f, 1.03226177e-01f,
  -6.58443645e-02f, 9.40037426e-03f, 5.03713638e-02f, 6.50927424e-02f, 1.41318753e-01f, 1.09496936e-01f, -4.53500710e-02f, 1.96533874e-01f, 1.34655923e-01f, 2.46384010e-01f,
  -3.01085319e-02f, 5.32071590e-02f, 3.39054018e-02f, 5.18303886e-02f, 2.17091721e-02f, -6.75016046e-02f, 7.29476064e-02f, 1.47293573e-02f, -4.65708412e-02f, 5.99196069e-02f,
  1.44694075e-02f, -4.23890091e-02f, -4.17038985e-02f, 6.50562420e-02f, -5.11814840e-02f, 7.60224462e-02f, 4.45740260e-02f, 9.52283815e-02f, -4.36172932e-02f, 6.89687654e-02f,
  8.40151403e-03f, 7.99995288e-02f, -3.59770730e-02f, 8.09431151e-02f, -3.32859010e-02f, 3.88429500e-02f, 8.33197832e-02f, -2.86935680e-02f, -4.68982868e-02f, 4.17993367e-02f,
  -5.41081056e-02f, -1.10242419e-01f, 1.50562152e-01f, 1.79680109e-01f, 8.64711329e-02f, -2.14054789e-02f, 3.80210020e-02f, 2.50717364e-02f, -1.85257941e-02f, 1.17018484e-01f,
  3.39715853e-02f, 1.29939377e-01f, 6.62577972e-02f, -1.88256614e-02f, -6.68521971e-02f, 1.83196664e-02f, -5.03027849e-02f, 8.72952640e-02f, 1.95856448e-02f, 8.57024416e-02f,
  1.23924417e-02f, -6.32093623e-02f, 1.02039233e-01f, 1.25176251e-01f, -5.15778698e-02f, 6.89515769e-02f, 9.41216573e-02f, 6.94395229e-02f, 9.39743069e-04f, 3.38418894e-02f,
  5.25982022e-01f, -1.92916542e-01f, -1.20049365e-01f, 2.72725344e-01f, -2.12214679e-01f, -4.30126905e-01f, -5.83360016e-01f, -2.10239664e-01f, 7.26075172e-02f, -1.01728387e-01f,
  2.59603783e-02f, 2.92930752e-01f, 1.57515973e-01f, 8.86849165e-02f, -9.94688794e-02f, -4.12311554e-01f, -2.35555857e-01f, 6.33629262e-02f, -1.27273798e-01f, -2.13903248e-01f,
  -4.94803861e-02f, 1.77153498e-01f, 2.95360088e-01f, 8.84272382e-02f, 9.22423154e-02f, 8.13983753e-02f, 1.04122132e-01f, 8.31760839e-02f, -1.59453545e-02f, -2.97212042e-02f,
  2.84825731e-02f, -4.93304012e-03f, -6.01116903e-02f, 1.53959379e-01f, 3.30248773e-02f, -2.05758251e-02f, 4.85767350e-02f, -1.16488561e-02f, -1.22991201e-04f, 6.19533099e-02f,
  3.45213972e-02f, 2.98257917e-02f, -7.51803741e-02f, -1.74960494e-02f, 2.36085802e-03f, 4.24001366e-02f, -2.77765989e-02f, -3.02038155e-02f, -8.88826139e-03f, 8.34820420e-02f,
  -3.48745175e-02f, -8.82842243e-02f, 1.84840597e-02f, -9.41978693e-02f, -7.90484846e-02f, 1.36230364e-01f, -1.02516832e-02f, 9.75986868e-02f, -8.61757100e-02f, 1.32361501e-01f,
  4.57788967e-02f, 1.37480646e-01f, -5.06935082e-02f, 3.09832934e-02f, 5.20665646e-02f, 3.12517546e-02f, -2.43222080e-02f, 5.80806844e-02f, 5.64283226e-03f, -5.52143492e-02f,
  -7.24565163e-02f, -1.26734795e-02f, 3.20408344e-02f, -1.05357571e-02f, -4.91606370e-02f, -8.10576975e-02f, 7.20988447e-03f, 1.96001083e-02f, 8.59332234e-02f, -6.13985248e-02f,
  7.62836309e-03f, -1.02603529e-02f, 6.42157346e-02f, -4.82546017e-02f, 2.16779229e-03f, -5.97101822e-02f, 6.35957578e-03f, -8.80628452e-03f, -3.80915735e-04f, -1.02924779e-01f,
  1.97451010e-01f, -1.81474105e-01f, 3.78354006e-02f, -5.80075085e-02f, -2.18643416e-02f, 1.62103456e-02f, 4.24573161e-02f, -7.85878301e-02f, 7.87182003e-02f, 2.18613911e-02f,
  1.79696679e-02f, 4.22935188e-03f, 7.71962628e-02f, -4.56272364e-02f, 7.85495900e-03f, -7.32605392e-03f, -4.95349765e-02f, 1.53331608e-02f, -9.54336002e-02f, -3.10255624e-02f,
  2.68700961e-02f, -9.65647548e-02f, 3.67496312e-02f, 3.10451407e-02f, 1.96263772e-02f, -2.10922286e-02f, -1.75090246e-02f, -4.71685268e-02f, -1.45200357e-01f, 1.16125438e-02f,
  -6.40914142e-01f, 3.52680609e-02f, 1.25390470e-01f, -3.93078297e-01f, 1.73663031e-02f, -1.10769697e-01f, -2.82235265e-01f, -2.48838559e-01f, -2.23677337e-01f, -1.21727623e-01f,
  5.80766425e-03f, -1.11635253e-01f, -1.13334998e-01f, 5.36743663e-02f, -1.46346256e-01f, -2.34483078e-01f, -8.23351219e-02f, 4.56156349e-03f, -6.57607317e-02f, 5.65635599e-02f,
  -3.35526615e-02f, 1.29003767e-02f, -1.12131029e-01f, -2.03299224e-02f, 1.16202958e-01f, 3.97799276e-02f, 2.21603900e-01f, -2.09263209e-02f, 1.72327802e-01f, 4.13308851e-02f,
  2.45908648e-01f, -1.62000030e-01f, 9.49804783e-02f, -4.88337986e-02f, 1.32517144e-01f, 5.17886057e-02f, -1.02374531e-01f, 1.20601855e-01f, 4.41039577e-02f, 7.41052115e-03f,
  5.67087792e-02f, -2.63395570e-02f, -5.10472879e-02f, 1.46661639e-01f, -5.09596663e-03f, 6.20650351e-02f, -3.01460773e-02f, 1.54155698e-02f, 1.42657962e-02f, 4.56924438e-02f,
  1.10681228e-01f, -6.06249757e-02f, 4.75818627e-02f, 1.02303743e-01f, 9.20891389e-02f, 4.94713522e-02f, 1.20302640e-01f, 2.72263624e-02f, 1.22142784e-01f, 5.05420864e-02f,
  -3.48463580e-02f, -6.05946523e-04f, 1.24913882e-02f, 5.53517044e-02f, -2.48962268e-02f, -2.20738538e-02f, 2.42517330e-03f, -1.13192489e-02f, 3.21078449e-02f, -5.93576990e-02f,
  7.08192587e-02f, -8.44819658e-03f, 1.34032726e-01f, -5.19659892e-02f, 3.97910997e-02f, 3.61146331e-02f, -4.57816198e-02f, 1.34236738e-01f, 4.68660928e-02f, 6.46372437e-02f,
  1.74166672e-02f, -1.22039057e-02f, 3.61810476e-02f, 8.61702785e-02f, 2.61801705e-02f, -2.90371384e-02f, -6.11751713e-02f, 1.16360616e-02f, -4.38365191e-02f, -1.33157370e-03f,
  -1.23145804e-01f, -4.01847214e-02f, -8.72718990e-02f, -4.16905582e-02f, -6.37160689e-02f, -7.26379156e-02f, -3.64256129e-02f, 2.21243408e-02f, -9.79744457e-03f, 2.60773227e-02f,
  -6.03536554e-02f, -7.82105029e-02f, 7.72609375e-03f, 1.68177374e-02f, -3.07418201e-02f, -1.09693473e-02f, -1.45104185e-01f, -4.94643077e-02f, 1.64301042e-02f, 6.42260760e-02f,
  -1.21494375e-01f, -1.33309290e-01f, -8.65334123e-02f, -4.34786975e-02f, -1.88643783e-01f, -1.77794531e-01f, 5.26996516e-02f, -6.17825352e-02f, -2.39253521e-01f, -1.51609778e-01f,
  -1.10616052e+00f, 7.81426206e-02f, -1.79409102e-01f, -2.51366585e-01f, 2.98005134e-01f, 5.21859191e-02f, 1.36989653e-01f, -4.36646305e-03f, -1.03047676e-01f, 1.13478964e-02f,
  1.20013364e-01f, 1.41515926e-01f, 4.94866185e-02f, 1.67294160e-01f, -5.24908155e-02f, 6.86178431e-02f, -4.36458439e-02f, -2.15032652e-01f, -5.35890684e-02f, 1.56535730e-01f,
  1.83403879e-01f, -2.37916827e-01f, -3.18104655e-01f, -8.10718685e-02f, 1.84297964e-01f, 1.86869614e-02f, 4.46291156e-02f, -3.44264656e-02f, 5.26727065e-02f, -1.08832568e-01f,
  -7.15542585e-02f, -3.12124968e-01f, -1.57950297e-01f, -2.09448934e-01f, -9.11117569e-02f, -1.80611104e-01f, -1.54829308e-01f, -1.04183011e-01f, -1.79423168e-01f, -1.66684836e-01f,
  -1.03246763e-01f, -1.40448794e-01f, -1.57115176e-01f, 1.67080965e-02f, -8.48828703e-02f, -1.76680878e-01f, -1.51541844e-01f, -1.79201007e-01f, -1.75136521e-01f, -9.89921093e-02f,
  8.55549797e-02f, -5.22088744e-02f, -1.19958892e-01f, -3.93840577e-03f, -5.48692420e-02f, -1.37126312e-01f, -1.35649806e-02f, -1.01781584e-01f, -9.73800048e-02f, -8.70896429e-02f,
  -1.27032578e-01f, 3.17031443e-02f, 1.49125988e-02f, -1.47154210e-02f, 5.00255786e-02f, 7.12364614e-02f, -1.29789133e-02f, 7.54466653e-02f, 6.92884997e-02f, 5.63916229e-02f,
  7.08298013e-02f, 1.38713969e-02f, 5.38163632e-02f, 3.35657969e-02f, 1.36998340e-01f, 5.43129407e-02f, 4.44063656e-02f, 1.50718287e-01f, 5.17833903e-02f, 2.24557500e-02f,
  5.08548990e-02f, 8.01088810e-02f, 9.20480862e-02f, 5.02548143e-02f, 8.44842046e-02f, -2.82011414e-03f, 6.54388741e-02f, 1.36377797e-01f, 1.93245530e-01f, 2.67117061e-02f,
  1.37812227e-01f, 7.16756284e-03f, -1.16862446e-01f, -4.71791364e-02f, -8.36561024e-02f, -6.46826699e-02f, -3.14695500e-02f, -1.36381090e-01f, -1.56334788e-01f, -1.13276631e-01f,
  4.92580011e-02f, -1.06951192e-01f, 7.04250485e-02f, -1.03205942e-01f, -8.17851499e-02f, -3.76238078e-02f, 5.00546116e-03f, -1.36190653e-01f, -6.99404329e-02f, -4.12250571e-02f,
  -9.91204605e-02f, -1.11387685e-01f, -8.98663104e-02f, -4.66029793e-02f, -1.48275778e-01f, -8.69798288e-03f, 1.61505863e-02f, -1.10149264e-01f, -9.00985673e-02f, 3.35725136e-02f,
  -3.48141044e-01f, 2.82387435e-01f, 3.56549293e-01f, -1.38725907e-01f, 1.83968782e-01f, 2.13406935e-01f, 2.53227621e-01f, 1.54184163e-01f, -4.85347435e-02f, 8.40471759e-02f,
  1.40471429e-01f, 6.28705248e-02f, -2.76248157e-03f, 8.96683261e-02f, 9.92667004e-02f, 1.19720444e-01f, -4.94269766e-02f, 3.45659256e-02f, 1.73521936e-01f, 1.21126063e-01f,
  4.67900783e-02f, -6.96835071e-02f, 4.02019583e-02f, -2.45449189e-02f, -1.62376389e-01f, -1.97579223e-03f, -8.71829907e-05f, 9.68449414e-02f, 1.35173380e-01f, -3.75521809e-01f,
  2.69081108e-02f, 2.11291224e-01f, 2.66519338e-01f, 2.41209030e-01f, 2.27487147e-01f, 1.07313782e-01f, 2.06595659e-01f, 1.98735744e-01f, 1.28253609e-01f, 1.46788701e-01f,
  1.98633760e-01f, 2.29777679e-01f, 1.89042956e-01f, 1.26319885e-01f, 1.15433402e-01f, 1.46987453e-01f, 2.04784423e-01f, 1.82747200e-01f, 1.95299909e-01f, 2.75418311e-01f,
  1.04477249e-01f, 1.17341131e-01f, 1.86895579e-01f, 1.81333601e-01f, 1.66823655e-01f, 2.12439060e-01f, 3.37751418e-01f, 1.09174520e-01f, 1.47700995e-01f, -7.96439499e-02f,
  -2.60873735e-02f, -1.03444546e-01f, -1.92388877e-01f, -1.09255053e-01f, -2.04760492e-01f, -8.86053070e-02f, -1.12985864e-01f, -1.29459232e-01f, -6.90007061e-02f, -1.27619311e-01f,
  -9.00679827e-02f, -1.10488767e-02f, -4.76502348e-03f, -1.15522638e-01f, -1.09027736e-01f, -7.10840225e-02f, -9.22234431e-02f, -1.14928186e-01f, -4.74393219e-02f, -1.45776287e-01f,
  -1.05385020e-01f, -7.45745227e-02f, -7.81110004e-02f, -1.05724961e-01f, -7.03844801e-02f, -1.37444869e-01f, -4.81134541e-02f, -3.17698978e-02f, -4.70662639e-02f, -4.15102113e-03f,
  2.54572481e-01f, 4.39008743e-01f, 2.65911426e-02f, 1.05469301e-01f, 1.55109257e-01f, 1.16640069e-01f, 8.47930983e-02f, 1.48274601e-01f, 1.95003361e-01f, 1.05894417e-01f,
  3.31356943e-01f, 1.89451560e-01f, 2.41970301e-01f, 2.44954318e-01f, 2.42965356e-01f, 2.09532306e-01f, 1.92962825e-01f, 1.46567971e-01f, 2.17025787e-01f, 1.82515636e-01f,
  3.00281763e-01f, 2.86260247e-01f, 1.44677877e-01f, 2.62578219e-01f, 2.64850408e-01f, 1.35382459e-01f, 3.02810639e-01f, 2.48499662e-01f, 2.51257002e-01f, 3.02228361e-01f,
  -2.13701248e-01f, -4.15503025e-01f, -9.71866846e-02f, 1.12743221e-01f, -7.83653036e-02f, -2.56793499e-01f, -4.90811020e-01f, -2.29601160e-01f, -1.01285661e-02f, -2.47236729e-01f,
  -1.59224972e-01f, -9.67443213e-02f, -2.00065374e-01f, -1.46532878e-01f, -1.46532059e-01f, -3.41192931e-01f, -2.60962080e-02f, 6.15357608e-02f, -1.87558383e-02f, 3.38023379e-02f,
  -3.82970273e-03f, 1.38696343e-01f, 9.76658911e-02f, 1.54622719e-01f, 5.32847829e-03f, -3.20812687e-02f, -4.85053398e-02f, 3.34926578e-03f, -1.00447975e-01f, 2.53960285e-02f,
  -3.17082554e-01f, -1.55248702e-01f, -1.07718781e-02f, -6.19942211e-02f, -1.44281119e-01f, -1.11825824e-01f, -1.43795699e-01f, 1.55733218e-02f, -1.33479878e-01f, -1.07282571e-01f,
  -8.50635872e-04f, -7.79489130e-02f, -5.87073863e-02f, 6.83577657e-02f, -7.86692947e-02f, -5.35683073e-02f, 1.20473236e-01f, -6.13332242e-02f, -8.04597959e-02f, 1.50510315e-02f,
  2.40494758e-02f, 1.03379153e-01f, -1.96938425e-01f, -6.85848817e-02f, -1.08362613e-02f, 1.04388036e-01f, -2.40948536e-02f, -1.97045505e-02f, -1.19095802e-01f, -9.72610340e-02f,
  5.08912168e-02f, 5.88611513e-02f, -9.87853482e-03f, -6.66894019e-02f, -4.94162254e-02f, 1.07621467e-02f, 7.16521144e-02f, 2.14383360e-02f, 2.97997822e-03f, -1.23284191e-01f,
  -2.52440735e-03f, 4.76005338e-02f, 2.93840878e-02f, 2.41727680e-02f, 1.08502656e-02f, -3.36353555e-02f, 8.41684118e-02f, 8.99654850e-02f, 1.32416531e-01f, 5.51925860e-02f,
  6.99774697e-02f, 5.21556698e-02f, 7.71945044e-02f, -1.82980839e-02f, -1.76435690e-02f, 1.06062852e-01f, 9.46051851e-02f, 8.44083503e-02f, 2.36949697e-02f, 1.68832187e-02f,
  -3.78265709e-01f, -7.20345043e-03f, -5.52929305e-02f, -4.55064103e-02f, -5.98050319e-02f, -6.01621717e-03f, -2.27842899e-03f, -5.05345799e-02f, -2.01807581e-02f, -2.71812407e-03f,
  -9.39505324e-02f, 4.00279909e-02f, -5.12578264e-02f, -1.95549373e-02f, -8.87991637e-02f, -5.06161526e-02f, -1.06562711e-01f, -1.08827561e-01f, -6.36789715e-04f, 8.83974284e-02f,
  5.47016710e-02f, -1.47791192e-01f, -2.03303859e-01f, -1.11722097e-01f, -4.19610217e-02f, -1.22660846e-01f, -2.26600349e-01f, -1.72468007e-01f, -1.97821185e-01f, -4.00785893e-01f,
  -7.80005634e-01f, 7.19208121e-02f, -5.50313678e-04f, -3.53629500e-01f, -1.25300676e-01f, -2.60378122e-02f, 1.21508855e-02f, -1.52441293e-01f, -2.17940971e-01f, -1.19422726e-01f,
  2.45583594e-01f, 2.25406140e-01f, 1.38100058e-01f, 6.23479933e-02f, -1.62816733e-01f, -2.96475798e-01f, -3.39863300e-01f, -7.71461427e-02f, 2.10433975e-02f, -6.28769696e-02f,
  5.40412031e-02f, 9.07813609e-02f, 2.68206336e-02f, 8.13580751e-02f, -8.92191604e-02f, 1.79004461e-01f, 1.53312251e-01f, 1.12243585e-01f, 2.19659582e-01f, -1.14457518e-01f,
  7.43798492e-03f, -2.77178973e-01f, -4.48878892e-02f, -3.37907858e-02f, -6.40615076e-02f, -1.08267456e-01f, -3.90647575e-02f, -1.82907153e-02f, 6.49398118e-02f, -1.94605310e-02f,
  -1.95480380e-02f, 7.44877681e-02f, -3.41410413e-02f, 3.29884589e-02f, 2.89335698e-02f, -7.27797672e-02f, 2.48025749e-02f, -1.33745164e-01f, -3.80566716e-02f, 2.10203193e-02f,
  3.31601314e-02f, 5.65613024e-02f, -6.82178093e-03f, 9.21135321e-02f, -1.12807311e-01f, 1.92102417e-02f, 1.23712994e-01f, -1.52929723e-02f, 1.08288705e-01f, -8.03528130e-02f,
  1.36792079e-01f, -1.15439873e-02f, -5.67382351e-02f, 4.36349809e-02f, -2.61088107e-02f, 1.15781557e-02f, 4.89026122e-02f, -1.91417765e-02f, -4.01247256e-02f, 5.52633628e-02f,
  1.89257171e-02f, -9.29175317e-02f, -7.81139806e-02f, -1.61762416e-01f, 4.39164639e-02f, -5.37351668e-02f, -2.16161599e-03f, 1.04827713e-02f, -8.13328102e-02f, -2.16249023e-02f,
  3.34941335e-02f, 2.10560299e-02f, -1.04337651e-02f, 1.08521901e-01f, -7.39155412e-02f, -7.46796578e-02f, -1.17277496e-01f, 1.19779661e-01f, -4.95666973e-02f, 2.21547224e-02f,
  2.14639992e-01f, -1.59434415e-02f, -1.31957889e-01f, -7.13435486e-02f, 7.84586370e-02f, -4.74736504e-02f, 7.87008405e-02f, 9.98964980e-02f, 1.57012809e-02f, 3.46909426e-02f,
  4.24598381e-02f, 4.42042090e-02f, 5.55006899e-02f, 9.27198082e-02f, -2.28601117e-02f, 2.19508298e-02f, -9.24348086e-02f, 6.88911974e-02f, -3.62881944e-02f, -2.93766875e-02f,
  4.39319350e-02f, -7.00921118e-02f, -5.21049388e-02f, -6.28170557e-03f, -2.04672590e-02f, -1.99603774e-02f, 2.20440432e-01f, 6.70366138e-02f, 8.55090693e-02f, 1.20260388e-01f,
  -1.91800982e-01f, 2.62222320e-01f, -1.36771217e-01f, -2.59943873e-01f, -2.98837107e-02f, -5.87288328e-02f, 3.33997041e-01f, -3.41013186e-02f, -7.03638569e-02f, 1.54960737e-01f,
  -1.18748747e-01f, -2.54044652e-01f, -2.66264766e-01f, -1.37571231e-01f, -2.05809638e-01f, 1.20699853e-01f, 1.72000870e-01f, -2.31673658e-01f, -2.37181261e-01f, 3.52991372e-02f,
  -4.04169820e-02f, 1.65057667e-02f, -1.78474754e-01f, -7.91298300e-02f, 1.80314869e-01f, -1.37640417e-01f, 6.73655123e-02f, 1.02178276e-01f, 1.43393457e-01f, 4.63704795e-01f,
  2.45160103e-01f, 1.83050081e-01f, -1.60016432e-01f, -7.68393725e-02f, -2.92504695e-03f, -1.02442190e-01f, 4.24447320e-02f, 1.12612080e-02f, -7.36068264e-02f, -7.03613460e-02f,
  3.71343903e-02f, -5.89484870e-02f, -4.70054932e-02f, -3.89705747e-02f, 7.12677985e-02f, -3.61923873e-02f, 2.89358832e-02f, -3.08704954e-02f, -1.76264078e-03f, 7.63419867e-02f,
  5.15080355e-02f, 1.03430659e-01f, 8.90337005e-02f, -4.85386001e-03f, -4.16018954e-03f, -2.05617733e-02f, 6.89432770e-02f, 9.72657129e-02f, -6.52218834e-02f, 1.28837332e-01f,
  -1.81659777e-02f, -9.66322329e-03f, 6.63218647e-02f, 9.14231502e-03f, 2.87937652e-02f, 3.87061164e-02f, 7.69528225e-02f, -1.36842458e-02f, -1.04816575e-02f, 5.60431369e-02f,
  -5.50750829e-02f, -7.22175837e-02f, -1.97175406e-02f, -5.54886125e-02f, -1.34366855e-01f, 1.26959849e-02f, 1.11431539e-01f, -7.36747533e-02f, 1.18656103e-02f, -6.40807077e-02f,
  1.02790375e-03f, -9.42680892e-03f, -1.52134178e-02f, 3.59104164e-02f, 1.04662679e-01f, -8.85347463e-03f, 5.40627763e-02f, -1.37498546e-02f, -7.18360320e-02f, 8.64375103e-03f,
  1.36184720e-02f, -2.49925345e-01f, -1.05008699e-01f, 2.55503543e-02f, -4.83719483e-02f, -9.75428522e-02f, -6.09891266e-02f, -1.35215595e-01f, 6.96909800e-03f, -2.78385002e-02f,
  -2.79701054e-02f, -7.07152709e-02f, 2.61373743e-02f, 4.65212911e-02f, 1.43193323e-02f, -2.06873044e-02f, -3.75860296e-02f, 1.72640346e-02f, 2.09943186e-02f, 3.30440998e-02f,
  -1.01420723e-01f, -5.72758242e-02f, -6.81393445e-02f, -5.43635972e-02f, 6.62558377e-02f, -9.71075743e-02f, -4.77566570e-02f, -5.30936345e-02f, -1.83727313e-02f, -1.16079681e-01f,
  -2.09415946e-02f, 4.14707035e-01f, -5.24108857e-02f, 2.89353989e-02f, -1.62521633e-03f, -1.32457197e-01f, 5.01213968e-02f, -8.99558887e-02f, 6.34681731e-02f, 9.56233814e-02f,
  7.23532122e-03f, -8.56043845e-02f, -7.78204501e-02f, 6.73098117e-03f, -7.66571909e-02f, 1.70255736e-01f, 1.86315998e-01f, -2.08281994e-01f, -4.11468238e-01f, -1.47446856e-01f,
  4.81550433e-02f, 9.71893370e-02f, 5.50521165e-02f, -1.28270090e-01f, 2.66408563e-01f, -1.65068403e-01f, 6.02749828e-03f, 1.83087692e-01f, 3.04197613e-03f, 4.74421680e-01f,
  2.68932581e-02f, 2.16367051e-01f, -1.01479366e-01f, -5.40902279e-02f, -8.78880844e-02f, -2.25796420e-02f, -1.95753090e-02f, -5.59387654e-02f, 2.02784571e-03f, 7.64001906e-02f,
  8.53127837e-02f, 6.29900321e-02f, 3.03063113e-02f, -1.70260929e-02f, 1.13158815e-01f, 2.10517738e-02f, 1.21853873e-01f, 8.43440443e-02f, 3.20640020e-02f, 3.00473478e-02f,
  4.59649153e-02f, 7.16943964e-02f, 9.82777849e-02f, -3.37474272e-02f, -2.70824116e-02f, -3.97402607e-02f, 1.29836127e-01f, 2.71881819e-02f, -7.62238801e-02f, 1.67285621e-01f,
  -6.27927035e-02f, 1.32984284e-03f, -1.22706503e-01f, -8.53790939e-02f, 3.93233495e-04f, -7.33134672e-02f, -1.48557406e-02f, 7.00315535e-02f, 6.45641796e-03f, 6.99011162e-02f,
  7.43529340e-03f, -1.08080976e-01f, -5.12124822e-02f, 1.66721139e-02f, 6.41059084e-03f, 1.14716001e-01f, 8.58181566e-02f, -4.95114410e-03f, -8.48897547e-02f, 2.30933670e-02f,
  -7.09475279e-02f, -3.82748134e-02f, 2.27894564e-03f, -3.54926512e-02f, 4.29062406e-03f, -4.17484753e-02f, -2.55732778e-02f, -8.62217471e-02f, -7.11544454e-02f, -1.91224311e-02f,
  -6.35865778e-02f, -1.76662371e-01f, -2.43669748e-02f, 1.21557921e-01f, -7.85788298e-02f, -7.80135542e-02f, -2.15490162e-03f, 2.97187082e-02f, 1.22137424e-02f, 1.61516909e-02f,
  5.67759164e-02f, -1.18185189e-02f, -7.47237401e-03f, 1.62473302e-02f, -1.14137664e-01f, -5.70644960e-02f, 1.48192914e-02f, 6.14598691e-02f, -1.37390122e-02f, 2.71348059e-02f,
  1.40641272e-01f, -1.22547731e-01f, -9.56423953e-02f, -4.40435298e-02f, 6.73631951e-02f, -1.56045422e-01f, -1.04239769e-01f, -1.38046563e-01f, -2.01594591e-01f, -1.17972136e-01f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  5.17947197e-01f, 3.32235321e-02f, 4.59902257e-01f, 1.95687130e-01f, -6.15886971e-02f, 9.68995243e-02f, 3.22434157e-01f, 8.44624266e-02f, -1.49285793e-01f, 1.27194740e-03f,
  -3.68773162e-01f, -3.84256482e-01f, -3.54630768e-01f, -2.49026641e-01f, 1.18542649e-01f, 2.49762952e-01f, 3.50604177e-01f, 1.32324606e-01f, 1.42563492e-01f, 8.79848227e-02f,
  2.43958980e-02f, 3.85768339e-02f, 4.34871726e-02f, 1.41888171e-01f, 1.78951070e-01f, -1.26576155e-01f, 9.88704804e-03f, 1.33957639e-01f, -1.26612976e-01f, 1.76351845e-01f,
  -1.39569148e-01f, 4.45510680e-03f, -4.01859619e-02f, -3.01818073e-01f, -1.10416636e-01f, 1.33571863e-01f, -1.85522507e-03f, -5.28151914e-02f, 9.39394236e-02f, 1.55420080e-02f,
  -1.58625558e-01f, -1.13133006e-01f, -5.09219840e-02f, -2.06582658e-02f, 1.61948819e-02f, 3.80480811e-02f, 3.60848717e-02f, 2.92236041e-02f, 1.58273522e-02f, -1.38017004e-02f,
  -2.44826963e-03f, -3.30506325e-01f, 1.39346272e-01f, 1.17261119e-01f, 2.23486394e-01f, -1.98244959e-01f, 1.35468841e-02f, 1.02163941e-01f, -5.14814667e-02f, 2.62479298e-02f,
  -5.01759686e-02f, 1.40922278e-01f, 6.60089031e-02f, 3.77974324e-02f, 1.70618854e-02f, 8.86569694e-02f, -5.15010022e-02f, -1.79749668e-01f, -2.79334448e-02f, 6.20836094e-02f,
  1.32531738e-02f, -5.32589946e-03f, -1.03170667e-02f, 1.10231556e-01f, -4.11220901e-02f, -1.21759484e-02f, 1.36596814e-01f, 9.38779637e-02f, -2.61064861e-02f, -4.98622209e-02f,
  -4.80513498e-02f, 1.27674922e-01f, -1.52253127e-02f, 5.04551567e-02f, 1.37096886e-02f, -7.61215901e-03f, 1.04516782e-02f, -7.95850605e-02f, 3.53479162e-02f, 1.37306914e-01f,
  -5.27177274e-01f, -2.10553408e-01f, -2.31471613e-01f, -1.56727269e-01f, -8.05014223e-02f, -1.05591454e-01f, -3.19216698e-02f, -4.43334877e-02f, 2.34208461e-02f, -6.47899555e-03f,
  -2.03254987e-02f, 1.53761238e-01f, -1.60507500e-01f, 2.34029695e-01f, 1.23583525e-01f, 1.34726971e-01f, -7.84025236e-04f, -2.33477894e-02f, -4.23060730e-02f, 3.88574637e-02f,
  1.16629720e-01f, -7.20181987e-02f, -4.22271825e-02f, -5.38830869e-02f, -2.93385297e-01f, -4.21828568e-01f, -1.18412273e-02f, 1.70900360e-01f, -1.26041442e-01f, 7.46746361e-03f,
  -3.72783482e-01f, -4.72934991e-01f, 2.06905350e-01f, 2.89466590e-01f, 3.75035793e-01f, 5.80154777e-01f, 5.40778875e-01f, 2.96394944e-01f, 2.03305602e-01f, -3.57566662e-02f,
  -1.49444953e-01f, -8.86491537e-02f, 1.16267335e-02f, -3.57124843e-02f, 1.46841720e-01f, 3.86077285e-01f, 3.75963509e-01f, 3.64224464e-02f, 1.86820030e-01f, 2.39510998e-01f,
  2.14919448e-01f, -1.75849319e-01f, -5.18973351e-01f, -9.43889171e-02f, 1.01679303e-02f, 1.70521036e-01f, 1.46252364e-01f, 3.26699652e-02f, 8.23400915e-02f, 5.00981435e-02f,
  7.86659792e-02f, -4.25084770e-01f, 1.47229269e-01f, -1.93943396e-01f, -2.13063359e-01f, -2.48196065e-01f, 4.91523780e-02f, -7.05589503e-02f, 1.62650645e-02f, 1.37295127e-02f,
  -1.06532112e-01f, -1.10622019e-01f, -4.36462201e-02f, -7.08677694e-02f, -7.63836727e-02f, -8.12428445e-02f, -1.69613659e-01f, 4.00965661e-02f, 2.47532204e-01f, 6.47179456e-03f,
  8.20094422e-02f, -1.15786664e-01f, 4.53577749e-02f, 1.32811874e-01f, 1.61355004e-01f, 1.29156440e-01f, -8.82267579e-02f, -8.01012479e-03f, -4.20168275e-03f, -7.44388476e-02f,
  1.40279338e-01f, 9.19187535e-03f, -5.69166131e-02f, 5.02136573e-02f, 1.73026603e-02f, 5.01079932e-02f, 4.66210395e-02f, 1.13916181e-01f, 1.39703572e-01f, -9.90942717e-02f,
  3.21413167e-02f, 2.38590866e-01f, 1.55648187e-01f, 7.81656206e-02f, -2.98043918e-02f, -2.46901251e-02f, 7.07840100e-02f, -4.90160771e-02f, -1.01183020e-01f, -5.70285693e-02f,
  -8.76677968e-03f, 1.27638966e-01f, -1.50935814e-01f, 7.65034184e-02f, 2.87673883e-02f, 3.82060669e-02f, 5.81554696e-03f, -3.90195251e-02f, -2.11327896e-02f, -5.99326193e-02f,
  9.08173770e-02f, 9.94291380e-02f, 6.85019940e-02f, -8.21413007e-03f, -6.59725592e-02f, -2.90889204e-01f, 1.18148468e-01f, -1.43524930e-02f, -7.73717314e-02f, 1.34330824e-01f,
  -1.14912950e-01f, -4.04024087e-02f, -5.82063980e-02f, -4.62525971e-02f, 5.78911304e-02f, 3.35474089e-02f, -2.40819469e-01f, 9.87825245e-02f, 3.40775102e-02f, -1.55509189e-02f,
  7.85153657e-02f, 1.44052237e-01f, 8.66491720e-02f, 2.23580942e-01f, 3.90927270e-02f, 5.21601848e-02f, 1.25234857e-01f, 9.34359431e-02f, 1.16118953e-01f, -5.77714667e-03f,
  8.52456033e-01f, -2.64811337e-01f, 3.93452018e-01f, 2.57831812e-01f, 1.78686390e-03f, 1.97329670e-01f, 4.30809753e-03f, -4.24001329e-02f, 3.96512728e-03f, -1.04063749e-02f,
  6.93127364e-02f, 2.04083905e-01f, 1.67555019e-01f, 6.50048107e-02f, 1.36590511e-01f, -1.05471358e-01f, -1.38966009e-01f, 1.20049678e-01f, 3.52598935e-01f, 1.25261083e-01f,
  -2.09879830e-01f, -1.41746461e-01f, -1.43104568e-01f, -1.19590787e-02f, -1.64040133e-01f, 5.49617931e-02f, -1.53181478e-01f, -2.19151884e-01f, -1.23806834e-01f, -1.58789605e-01f,
  3.98405284e-01f, -2.22122874e-02f, 1.21694624e-01f, -2.23410800e-02f, -7.27088153e-02f, 9.03489515e-02f, 1.01916648e-01f, -1.11286594e-02f, 1.16591826e-01f, -1.35319168e-02f,
  -2.90889610e-02f, -6.71944246e-02f, 5.83318993e-03f, -7.20094442e-02f, -4.20007072e-02f, 4.59912345e-02f, -5.40724024e-02f, -4.17489968e-02f, 5.15787229e-02f, 5.53085692e-02f,
  -3.30285989e-02f, -4.99875173e-02f, 1.49263099e-01f, 1.74437806e-01f, 1.24996483e-01f, 1.35463879e-01f, 2.50751637e-02f, -4.98914644e-02f, 6.86305910e-02f, -6.61585927e-02f,
  -2.63870563e-02f, 1.65203437e-01f, 1.35043919e-01f, -3.39696072e-02f, 8.11410695e-02f, 4.47216444e-03f, -4.19468507e-02f, 2.00483017e-02f, 1.22109596e-02f, -1.74725965e-01f,
  -7.51866922e-02f, 1.09558636e-02f, 5.26324771e-02f, -9.60815176e-02f, 5.60903177e-03f, 6.56233579e-02f, 3.44862230e-02f, 9.10213776e-03f, 1.26742627e-02f, -4.56087217e-02f,
  -5.69549762e-02f, 1.38667420e-01f, -3.15418988e-02f, -1.66336194e-01f, -1.15194529e-01f, 3.99985202e-02f, -7.81491585e-03f, 1.36115942e-02f, -1.90314293e-01f, -2.29655746e-02f,
  4.40664776e-02f, 2.40816295e-01f, 9.98423249e-02f, -7.08260164e-02f, -9.75216832e-03f, 1.08038802e-02f, 1.42588019e-01f, 4.64651361e-02f, 1.04184799e-01f, 1.98284425e-02f,
  -4.35941145e-02f, 9.37685892e-02f, -8.25874656e-02f, -6.05114959e-02f, 4.43040654e-02f, 3.30060944e-02f, -9.54230875e-02f, 7.70544037e-02f, 1.24971986e-01f, -4.56763282e-02f,
  1.81481056e-02f, 1.48399085e-01f, 1.49757653e-01f, 1.10481836e-01f, 1.13002300e-01f, 2.77109504e-01f, 4.27346528e-02f, 2.88681723e-02f, 1.56280190e-01f, -1.54241938e-02f,
  2.22758844e-01f, -3.07569861e-01f, -3.83710355e-01f, -1.10141709e-01f, -4.18628395e-01f, -2.75945127e-01f, -6.08358860e-01f, -1.21335074e-01f, 1.10328861e-01f, -5.27183414e-01f,
  -2.95861304e-01f, 9.14090797e-02f, 2.12746903e-01f, 9.39333364e-02f, 2.52902299e-01f, -3.58795106e-01f, -2.06870168e-01f, 1.42384470e-01f, 2.28428394e-01f, -3.17433268e-01f,
  -1.51970625e-01f, 1.92533135e-01f, 3.21446478e-01f, 1.88294873e-01f, -2.65261412e-01f, 2.82174931e-03f, -2.21672162e-01f, 1.82963666e-02f, -1.58784032e-01f, -3.79523665e-01f,
  -2.96844363e-01f, -1.89505011e-01f, -7.21220896e-02f, 5.94776534e-02f, -1.55731231e-01f, 5.98836839e-02f, -2.24504501e-01f, 5.33095300e-02f, 1.00816041e-01f, -3.47877257e-02f,
  1.06430814e-01f, -1.71803590e-02f, 2.38649592e-01f, 1.64515987e-01f, 4.41852137e-02f, -4.23783585e-02f, 1.69281632e-01f, 1.83263525e-01f, 7.12221712e-02f, -1.63918152e-01f,
  -1.15126058e-01f, -7.83296227e-02f, -9.91134495e-02f, -4.50797789e-02f, -3.87231894e-02f, 1.00441813e-01f, -1.11724474e-01f, -1.13367841e-01f, -8.17359760e-02f, -2.12519020e-01f,
  -9.98279229e-02f, -6.64662495e-02f, -5.68010397e-02f, -2.66203620e-02f, -7.30049014e-02f, -4.57405206e-03f, 6.39084578e-02f, -3.56187932e-02f, 5.62372692e-02f, 9.04655233e-02f,
  -4.90595624e-02f, -7.93083385e-02f, 3.35749537e-02f, -1.10178374e-01f, 4.66235541e-02f, -3.16294730e-02f, 1.15547990e-02f, -3.40366028e-02f, 8.00104588e-02f, 9.21994522e-02f,
  6.22278824e-02f, 5.27277924e-02f, 5.20043261e-03f, 6.50224835e-02f, 5.22010848e-02f, 1.11531921e-01f, -6.01017894e-03f, -6.25644177e-02f, 9.88981724e-02f, -4.75932583e-02f,
  1.42088935e-01f, 3.96903083e-02f, -1.18876129e-01f, 4.09847358e-03f, -3.02892365e-02f, -1.19588368e-01f, -1.41111985e-01f, -5.20830937e-02f, 1.36779472e-01f, -1.46221131e-01f,
  -4.75370251e-02f, 7.69019313e-03f, 2.95109674e-02f, -1.80954169e-02f, -5.48041351e-02f, 5.32535138e-04f, -3.46588679e-02f, 3.51761132e-02f, 4.55709659e-02f, 2.17895433e-02f,
  6.09012181e-03f, -8.51380378e-02f, 4.15013991e-02f, 1.12519013e-02f, 6.40775636e-02f, 1.61066413e-01f, -7.47020841e-02f, 1.13047780e-02f, 9.40399691e-02f, -1.19913921e-01f,
  5.03883064e-01f, 2.59978235e-01f, 2.30273783e-01f, 2.68270820e-01f, 6.43150434e-02f, -7.22195953e-02f, -1.84028938e-01f, -1.30203605e-01f, -1.71439268e-03f, 1.61928475e-01f,
  -3.67287882e-02f, 2.64268368e-01f, 1.39905378e-01f, 2.20751375e-01f, 1.19109981e-01f, 7.33549818e-02f, 1.95361122e-01f, 3.25465947e-01f, 1.99528620e-01f, 2.21114397e-01f,
  2.27139339e-01f, 2.84428507e-01f, 2.36791953e-01f, -9.55956616e-03f, 2.42223099e-01f, 5.85810170e-02f, 9.55965091e-03f, 1.16873175e-01f, 1.69887647e-01f, 3.98357302e-01f,
  -7.00487345e-02f, -5.74768558e-02f, -1.92087635e-01f, 5.70124350e-02f, 3.86243835e-02f, -1.32435948e-01f, -3.36417332e-02f, 7.24617764e-02f, -2.17429265e-01f, -1.64864823e-01f,
  2.32676771e-02f, -6.81618648e-03f, -3.57066654e-02f, -9.69662983e-03f, -3.92544493e-02f, -5.17113432e-02f, 3.84641998e-02f, 7.13713691e-02f, -7.14256018e-02f, -9.93708298e-02f,
  1.46597639e-01f, 1.28964305e-01f, 5.88956587e-02f, -1.01604894e-01f, -1.10774271e-01f, 1.21059343e-01f, 4.09327773e-03f, 1.23616435e-01f, -1.36980519e-01f, 1.08059153e-01f,
  1.21964648e-01f, 6.66418001e-02f, 2.06581265e-01f, 1.64005056e-01f, 1.56249166e-01f, 5.11641093e-02f, -4.54522856e-02f, 5.35851344e-02f, 1.55365676e-01f, 1.61452934e-01f,
  -1.05412714e-01f, -8.10619146e-02f, -1.94503751e-03f, -1.75345078e-01f, 2.25112941e-02f, 1.15607455e-01f, -2.46673375e-02f, -9.42138359e-02f, -8.49196780e-03f, -2.23022755e-02f,
  5.30347861e-02f, -1.83697626e-01f, 8.53353143e-02f, 3.69248651e-02f, -5.08484617e-02f, -1.19967451e-02f, -7.32993195e-03f, -2.47544562e-03f, -2.16865167e-02f, 1.23397140e-02f,
  -2.75397539e-01f, -1.62514210e-01f, 9.90935043e-02f, 8.95840153e-02f, 5.36248311e-02f, -8.54596645e-02f, 2.55678315e-03f, -3.22742239e-02f, -7.29398429e-02f, -2.16696754e-01f,
  -2.57926937e-02f, -4.92924862e-02f, -9.56012029e-03f, 6.28807023e-02f, -5.62477522e-02f, -6.75865561e-02f, 1.24215029e-01f, -1.30434614e-02f, -8.42450410e-02f, -1.09567016e-01f,
  -4.82831299e-02f, 5.39605841e-02f, -6.91041276e-02f, -1.30723879e-01f, 5.10998592e-02f, 9.63431373e-02f, -1.76581983e-02f, -7.09644556e-02f, -1.59593433e-01f, -6.02085404e-02f,
  4.00858879e-01f, -2.03871280e-01f, -3.01675722e-02f, 7.77373910e-02f, 4.18244332e-01f, 4.85459745e-01f, 6.14227951e-01f, 1.46194384e-01f, 1.14569530e-01f, 1.35225905e-02f,
  -3.23241144e-01f, -6.69626236e-01f, -4.19889122e-01f, -4.65098739e-01f, -3.09954405e-01f, 1.47264406e-01f, 2.00848296e-01f, -1.32486865e-01f, -9.91729721e-02f, 4.21969704e-02f,
  2.15837099e-02f, 2.75555342e-01f, -5.43743148e-02f, -1.51590645e-01f, -1.62882894e-01f, -1.07464708e-01f, 9.31276605e-02f, 3.13575089e-01f, -1.72371566e-01f, -3.61107409e-01f,
  -3.60458046e-01f, 6.95239455e-02f, -7.59777129e-02f, -6.25969321e-02f, -1.24782570e-01f, -7.25858435e-02f, -7.90818557e-02f, -1.73140734e-01f, 2.73243198e-03f, -6.61403909e-02f,
  7.27399538e-07f, 1.32144419e-02f, 3.34108733e-02f, 2.28200369e-02f, 2.09872678e-01f, 6.16911389e-02f, 5.75413480e-02f, -1.53892413e-01f, -2.45507598e-01f, -2.13661417e-01f,
  -1.71283036e-01f, 1.07867293e-01f, 2.19170779e-01f, 2.98618954e-02f, -3.95189151e-02f, -2.78656948e-02f, 1.06307350e-01f, -1.87962316e-02f, -6.43638894e-02f, -4.17707711e-02f,
  8.21140129e-03f, 6.06972352e-02f, 3.84271294e-02f, 5.40229864e-02f, -1.02358088e-02f, 8.92013013e-02f, 3.72995697e-02f, 1.07631296e-01f, -8.12944304e-03f, -6.56259879e-02f,
  -7.28371814e-02f, 5.69404848e-03f, -8.33027437e-02f, -7.12462291e-02f, -1.49740323e-01f, 1.92764997e-02f, -6.27523735e-02f, 1.92127712e-02f, -8.34718719e-02f, 2.90109981e-02f,
  4.23059873e-02f, 9.38042104e-02f, 3.75597435e-03f, -9.47578698e-02f, -4.66966555e-02f, -1.59351081e-01f, -3.54913808e-02f, -1.74273670e-01f, 5.38882893e-03f, 4.00609449e-02f,
  -1.51162133e-01f, -1.02460451e-01f, -3.14263664e-02f, -5.26520088e-02f, 1.25715047e-01f, -6.61990792e-02f, -2.46634007e-01f, -7.76956156e-02f, 1.59520583e-04f, -1.50586188e-01f,
  -1.09304018e-01f, -7.55688027e-02f, -1.28684834e-01f, -8.14593658e-02f, 1.04795530e-01f, -1.89787820e-02f, -1.07818693e-01f, -1.32844165e-01f, -1.76885754e-01f, -1.49112284e-01f,
  -7.99911320e-02f, 2.35030279e-01f, 1.24366112e-01f, 5.68671525e-02f, -4.13236059e-02f, 1.43491536e-01f, 1.65772468e-01f, 8.66649523e-02f, 1.66651323e-01f, 2.77341157e-01f,
  -3.66671234e-01f, -1.06206648e-01f, -1.40289724e-01f, -4.94113266e-01f, 3.23551372e-02f, 2.71539211e-01f, 1.71639279e-01f, 1.77479431e-01f, -1.17797323e-01f, -6.36761189e-02f,
  1.73347384e-01f, -2.49739680e-02f, -9.84004065e-02f, 3.05581093e-02f, 2.95388792e-02f, -4.32150997e-02f, -2.59095430e-01f, -6.15329891e-02f, 2.74021953e-01f, 3.99521768e-01f,
  2.24173248e-01f, -1.12195201e-01f, -1.86075509e-01f, 1.08127901e-02f, -2.45370477e-01f, -6.98850229e-02f, -3.73551160e-01f, -3.58589411e-01f, -2.15949509e-02f, -3.35566610e-01f,
  -2.56830722e-01f, 3.44933122e-02f, 2.92332470e-01f, -1.70426760e-02f, -1.32471859e-01f, 6.76077371e-03f, 1.26683369e-01f, 1.42209744e-02f, 9.36079100e-02f, -4.30193730e-02f,
  -9.97480843e-03f, 1.46144882e-01f, -3.41646262e-02f, 1.76481158e-01f, -1.06445570e-02f, 1.27143368e-01f, 9.61275548e-02f, -8.91713519e-03f, -1.30254328e-01f, 9.84826237e-02f,
  -1.61394551e-02f, 5.62132373e-02f, -6.09541126e-02f, -1.12081125e-01f, 2.53416032e-01f, -6.58041537e-02f, -3.50651219e-02f, -7.72264674e-02f, 1.71616122e-01f, -2.28459567e-01f,
  3.90241444e-02f, 6.64875209e-02f, 1.24209210e-01f, 3.01317312e-02f, 9.81640164e-03f, -5.13710938e-02f, -4.78016064e-02f, 3.30050774e-02f, 7.02934787e-02f, -8.07825029e-02f,
  5.35293408e-02f, 1.39401898e-01f, 1.56375706e-01f, -5.49917221e-02f, -9.84995253e-03f, -3.49690095e-02f, -7.61310905e-02f, -1.29606664e-01f, -7.40155205e-02f, 1.69940852e-02f,
  8.63366351e-02f, -3.49945538e-02f, -2.04923190e-02f, -4.78036962e-02f, -2.83052400e-02f, -5.99989220e-02f, 5.62175363e-02f, 1.81709647e-01f, 1.23665810e-01f, 1.30264774e-01f,
  -4.90414083e-01f, 2.01567292e-01f, -1.12790339e-01f, 1.38963595e-01f, -8.57641920e-02f, 1.91300530e-02f, -3.13991100e-01f, 1.10302925e-01f, 3.65380198e-02f, -1.29812043e-02f,
  1.88899472e-01f, -1.24313951e-01f, -1.67447001e-01f, 1.00504994e-01f, 2.19220236e-01f, -1.70387968e-03f, 6.68004379e-02f, -6.15213439e-02f, 1.26178041e-01f, -6.42539188e-02f,
  -7.19829928e-04f, 8.29099417e-02f, -2.23754216e-02f, -1.48444057e-01f, -5.86032346e-02f, -2.07333639e-02f, -8.04635957e-02f, -1.05058603e-01f, 1.61518566e-02f, -2.63889194e-01f,
  -8.22024718e-02f, -1.74642816e-01f, -2.39936203e-01f, 1.98354553e-02f, 1.25883371e-01f, -1.62334532e-01f, -2.33321533e-01f, 1.73947796e-01f, 3.49282831e-01f, -3.02066594e-01f,
  -1.26961261e-01f, -2.41142154e-01f, -3.15440655e-01f, -1.45132616e-01f, -5.53850293e-01f, -6.21099353e-01f, -3.92758608e-01f, -3.29750776e-01f, -3.28055859e-01f, -1.96386307e-01f,
  -1.10242642e-01f, 3.03467805e-03f, 5.02602011e-02f, 5.33527955e-02f, 1.42075688e-01f, 8.57124776e-02f, 1.64900884e-01f, 1.12734633e-02f, -7.67500028e-02f, -1.23175427e-01f,
  -5.09862781e-01f, -1.43975457e-02f, 1.36546984e-01f, -1.46406189e-01f, -8.93326029e-02f, 4.85458188e-02f, -1.42988607e-01f, 6.54898733e-02f, 1.46589190e-01f, 5.99119104e-02f,
  -1.31022751e-01f, 5.72888702e-02f, -6.53931126e-02f, 1.44192770e-01f, -5.73304445e-02f, -1.78378046e-01f, 1.16962500e-01f, -8.81159678e-02f, -2.10898027e-01f, 1.74022429e-02f,
  -1.80777580e-01f, -3.19206119e-01f, -3.13966632e-01f, 2.16143570e-04f, 1.40493855e-01f, 1.24583758e-01f, 1.81725025e-01f, 1.85247034e-01f, 7.73925781e-02f, 2.74571311e-02f,
  1.58547133e-01f, 6.19908944e-02f, 9.08398256e-02f, 1.62914786e-02f, 6.62433952e-02f, 9.47007611e-02f, 3.45854163e-02f, -9.27661359e-02f, -7.36244991e-02f, -3.24669518e-02f,
  1.05091460e-01f, -4.36304957e-02f, 3.67388758e-03f, -1.49003670e-01f, 1.14233121e-02f, -9.91829298e-03f, -3.32211852e-02f, -6.84063509e-02f, -5.68423867e-02f, 1.16094060e-01f,
  -1.57359257e-01f, -7.52912685e-02f, -4.95044626e-02f, 1.40198708e-01f, -1.12920620e-01f, 2.27061324e-02f, -5.95178232e-02f, -4.44408953e-02f, -9.51843057e-03f, 1.29952440e-02f,
  -1.25722274e-01f, -3.85844529e-01f, 7.63174072e-02f, 4.73824590e-02f, 2.98520736e-02f, 1.53608561e-01f, 1.23365335e-01f, 1.05753183e-01f, 1.89079978e-02f, 8.49469677e-02f,
  -3.27108979e-01f, -4.61703986e-02f, -6.50565401e-02f, 1.87119078e-02f, -1.18877888e-01f, 5.31686358e-02f, 1.45239115e-01f, -2.24046782e-01f, -2.65802801e-01f, 1.24080144e-01f,
  -9.92461592e-02f, -2.24565715e-01f, -3.64345133e-01f, -2.52511781e-02f, 9.86258686e-02f, -1.85737565e-01f, -4.00767684e-01f, -1.51862249e-01f, -1.51581824e-01f, -2.10478708e-01f,
  -1.04602051e+00f, 5.64850532e-02f, -1.71260148e-01f, -5.44703662e-01f, -1.72688514e-01f, -1.72962755e-01f, -1.00298092e-01f, -6.28730804e-02f, -2.37560272e-01f, -2.42812306e-01f,
  -9.17920470e-02f, -6.80827722e-02f, -4.01521884e-02f, 1.66938622e-02f, -8.27276856e-02f, -1.85213208e-01f, -4.14834112e-01f, -3.27373832e-01f, -8.23352858e-02f, 1.49737611e-01f,
  6.53104018e-03f, -2.77751029e-01f, -3.93747538e-01f, 3.34406979e-02f, 1.35487154e-01f, -1.36856139e-02f, -1.42809182e-01f, -2.00183317e-01f, 2.18996003e-01f, -1.99049741e-01f,
  8.13174099e-02f, -3.42522949e-01f, -1.08811840e-01f, -1.92544758e-01f, -7.06395879e-02f, -1.04861639e-01f, -1.01054274e-01f, -1.14441559e-01f, -4.18175198e-02f, -6.48478195e-02f,
  -5.64966761e-02f, 2.92739645e-02f, -1.78266540e-01f, 3.06659993e-02f, -4.84502502e-02f, 4.15191725e-02f, 1.69783551e-02f, -2.00148430e-02f, 8.36365223e-02f, 2.94825345e-01f,
  1.84825465e-01f, -9.87452492e-02f, 1.58849750e-02f, 1.54491439e-01f, 1.06431484e-01f, -4.94105853e-02f, 1.76000416e-01f, 1.64328441e-01f, 2.15621948e-01f, 1.51277885e-01f,
  -9.97568760e-03f, 1.38190895e-01f, 2.99716704e-02f, 2.44875364e-02f, -2.67754942e-02f, -6.58578426e-02f, -2.19105482e-02f, -6.39864802e-02f, 9.45889577e-02f, -4.86459807e-02f,
  2.31945813e-02f, -9.55867544e-02f, -8.65047500e-02f, -2.23758388e-02f, 4.93247509e-02f, -6.40087873e-02f, -7.28468895e-02f, 5.19397259e-02f, 7.69291297e-02f, -9.50984955e-02f,
  4.98475274e-03f, 1.58617180e-02f, -1.09931910e-02f, 7.28069022e-02f, -1.41808167e-02f, -1.08750230e-02f, -1.73238683e-02f, 1.48477238e-02f, -5.98141886e-02f, -5.59287220e-02f,
  -6.82333624e-03f, -9.66425389e-02f, -2.42298007e-01f, 1.34452060e-01f, -5.33929132e-02f, -4.26933803e-02f, -6.53152764e-02f, -5.41648678e-02f, -1.66671440e-01f, -9.65413749e-02f,
  -8.27113446e-03f, 2.35292222e-02f, -4.04531211e-02f, 1.41081333e-01f, -5.94293885e-02f, 5.07252030e-02f, 1.04456834e-01f, -5.25453910e-02f, 2.38359012e-02f, 7.24748150e-02f,
  1.39294818e-01f, 8.26071352e-02f, 1.10837230e-02f, 1.47612199e-01f, 2.01117899e-02f, -1.26408190e-02f, 1.41685024e-01f, 1.61218867e-01f, 5.09272218e-02f, 8.28485116e-02f,
  1.15532428e-01f, -1.77961066e-01f, 3.06659311e-01f, 1.62072241e-01f, -2.84170181e-01f, -4.63041484e-01f, -8.07271481e-01f, -2.73428410e-01f, -4.19183113e-02f, -2.46717766e-01f,
  -2.44763836e-01f, -2.53175627e-02f, 5.26838340e-02f, 1.85613975e-01f, -6.72196001e-02f, -8.36716443e-02f, 2.70160317e-01f, 3.55412126e-01f, 5.29409349e-02f, -3.27996403e-01f,
  -1.67420506e-01f, 3.72531191e-02f, 2.06305236e-01f, -5.11739105e-02f, 5.26770093e-02f, 5.91214821e-02f, 2.09635571e-01f, 2.28778765e-01f, 1.41952991e-01f, 4.67707783e-01f,
  3.11342597e-01f, 1.16124123e-01f, 7.58187771e-02f, -1.75709873e-01f, -1.02730088e-01f, 4.27896827e-02f, -2.24387109e-01f, 1.78020597e-01f, -1.20356426e-01f, -9.93197784e-02f,
  1.54804438e-02f, -1.32625714e-01f, -2.10521355e-01f, 7.98701793e-02f, -1.09657623e-01f, -1.45511791e-01f, 1.94884360e-01f, 1.75274670e-01f, -8.91587660e-02f, -2.23242134e-01f,
  -2.15743944e-01f, -3.43159549e-02f, -7.51696974e-02f, -2.06130922e-01f, -1.00843478e-02f, 3.98391970e-02f, -2.07303371e-02f, 1.25154465e-01f, 9.62055475e-02f, 1.92982003e-01f,
  -3.58182713e-02f, -9.89843979e-02f, 7.35318139e-02f, -9.05416235e-02f, -1.23318948e-01f, -4.97053750e-03f, 2.71026380e-02f, 5.55233322e-02f, 5.86925298e-02f, -6.76282272e-02f,
  -2.54208799e-02f, 4.48440127e-02f, -1.12858914e-01f, 1.95455402e-02f, -1.60105980e-03f, -1.98736787e-02f, -6.22930564e-02f, -4.81250882e-02f, 1.33364201e-02f, -4.56521288e-02f,
  8.97156447e-02f, 2.82689165e-02f, -3.67444882e-04f, -4.47804853e-02f, 5.26618920e-02f, 9.73908752e-02f, 8.27984586e-02f, -1.57316834e-01f, 4.37687337e-02f, 4.49391231e-02f,
  -2.59298950e-01f, -9.35035869e-02f, -6.29588366e-02f, 1.71427876e-02f, 1.20931081e-01f, 4.99253571e-02f, 1.65854581e-02f, -7.50596216e-03f, -4.30663638e-02f, -1.02465950e-01f,
  -9.28430185e-02f, 8.97125900e-02f, -6.09284528e-02f, 8.66796449e-02f, -1.09046072e-01f, -1.25628293e-01f, -1.06249541e-01f, -2.09600046e-01f, -9.16216522e-02f, -1.23498820e-01f,
  -4.69700433e-02f, -4.00488317e-01f, -2.58313745e-01f, -2.61842459e-01f, -6.52875975e-02f, -1.65531695e-01f, 3.81876938e-02f, -1.18082706e-02f, -1.20835580e-01f, -3.93685549e-01f,
  -1.29227698e-01f, 2.62682080e-01f, 6.01921976e-02f, 1.57697991e-01f, 3.18914503e-01f, 5.33151552e-02f, 3.03926229e-01f, 1.92796826e-01f, -2.14063600e-02f, 2.42084101e-01f,
  2.39913300e-01f, -2.77291179e-01f, -1.70091629e-01f, -2.46228009e-01f, -2.07014441e-01f, 1.24356840e-02f, -8.11102521e-03f, -2.11574391e-01f, -6.37928367e-01f, -4.33448136e-01f,
  -3.29655856e-02f, 2.56637353e-02f, -4.26879004e-02f, -1.28277794e-01f, 1.25105292e-01f, -3.50597620e-01f, 1.11863844e-01f, 1.95175365e-01f, -3.92787158e-02f, -1.10505603e-01f,
  6.03567064e-02f, 2.43035972e-01f, -3.77181441e-01f, -1.75878592e-02f, 3.49458270e-02f, 1.33985635e-02f, 4.87451069e-02f, -3.04343496e-02f, 1.15636036e-01f, -5.82191944e-02f,
  7.93450233e-03f, 2.19391733e-02f, 3.87410335e-02f, -1.54092181e-02f, 9.61754844e-02f, -1.61426943e-02f, 9.92056802e-02f, -2.90358476e-02f, -4.59905639e-02f, -1.64693687e-03f,
  1.28680080e-01f, 1.89112842e-01f, 1.89621687e-01f, 4.79006171e-02f, -1.31688248e-02f, 7.40231248e-03f, 9.93330777e-03f, -5.32971472e-02f, -1.41917765e-01f, -1.75868273e-01f,
  -3.01883351e-02f, -2.09325060e-01f, 5.41633926e-03f, 3.74825560e-02f, 6.47489354e-02f, -1.29795551e-01f, -6.14531040e-02f, 3.32230143e-02f, -6.12913519e-02f, 2.19661742e-02f,
  1.14881113e-01f, 1.57011554e-01f, 8.54986534e-02f, 1.25611082e-01f, 1.35621130e-01f, 8.76531899e-02f, 8.99928138e-02f, -4.43774574e-02f, 6.79982156e-02f, 9.64205116e-02f,
  -6.72458708e-02f, 5.64755872e-02f, 2.01468885e-01f, -3.73641998e-02f, 6.64352179e-02f, -9.26059335e-02f, 1.34174824e-01f, 1.99100040e-02f, -2.42309384e-02f, 1.36378646e-01f,
  -2.25431267e-02f, -8.14923923e-03f, -5.80198802e-02f, -5.03305793e-02f, 1.43907955e-02f, 2.88744997e-02f, 1.73847854e-01f, 7.74186756e-03f, 1.62262216e-01f, 2.58070137e-02f,
  -1.22520104e-02f, 5.95819112e-03f, 3.96633036e-02f, -6.32141754e-02f, -1.72733486e-01f, 2.86842529e-02f, 1.25171319e-01f, -3.85293961e-02f, -2.83273980e-02f, 1.58997685e-01f,
  1.61168247e-01f, -1.78671226e-01f, -1.53253898e-01f, -5.00149205e-02f, -4.58367430e-02f, -2.86629125e-02f, -2.24065840e-01f, -3.89435142e-02f, -1.18826754e-01f, -1.00467630e-01f,
  2.26189452e-03f, -5.58411241e-01f, -3.08478743e-01f, -3.73346657e-01f, -1.37129515e-01f, 1.54049814e-01f, -1.32660687e-01f, 4.23621684e-02f, -1.09456331e-01f, -3.92283380e-01f,
  -3.25338766e-02f, 3.99226516e-01f, 2.97719780e-02f, 1.88267410e-01f, 2.29067877e-01f, -3.30700099e-01f, -3.45356077e-01f, 1.19094208e-01f, 5.57943165e-01f, 4.63999093e-01f,
  1.25552386e-01f, -1.67982832e-01f, 7.33280042e-03f, 9.38094854e-02f, -1.43714577e-01f, 8.81751999e-02f, -4.30901021e-01f, -1.56191617e-01f, -8.17125887e-02f, -4.29780602e-01f,
  9.54819694e-02f, 1.72693767e-02f, 2.67456770e-02f, -4.56554107e-02f, -1.09405875e-01f, -3.01336497e-02f, 1.11464232e-01f, -1.80140555e-01f, -3.72643173e-02f, -1.52851403e-01f,
  -1.38923422e-01f, 7.31837079e-02f, 6.14131019e-02f, 4.42229882e-02f, 6.62764236e-02f, -9.57544520e-03f, -9.85623077e-02f, -1.52095392e-01f, -3.08816601e-02f, -7.88228586e-02f,
  1.09284166e-02f, 5.15218712e-02f, -5.54182865e-02f, -6.70260265e-02f, 1.72770783e-01f, 2.32873559e-01f, -3.35664153e-02f, 1.19119428e-01f, 5.24972752e-02f, -2.74527043e-01f,
  2.78842002e-02f, -9.77895409e-02f, 1.97466668e-02f, -5.81697002e-02f, -5.30066863e-02f, -1.53095379e-01f, 3.55658121e-02f, -1.85695954e-03f, 8.06126371e-02f, 3.04313358e-02f,
  6.50595129e-02f, -1.28478706e-02f, -1.22763729e-02f, -9.38035399e-02f, -7.11453110e-02f, 2.19913223e-03f, 1.17755877e-02f, -7.30335563e-02f, 2.88485978e-02f, -5.96730821e-02f,
  6.79512993e-02f, -2.21378654e-02f, -3.44314203e-02f, 4.41109762e-02f, -4.76233549e-02f, -8.43208060e-02f, -3.91038992e-02f, 4.94739711e-02f, 8.97226669e-03f, 1.25969708e-01f,
  1.66046117e-02f, -4.53083497e-03f, -3.97455394e-02f, 1.52288839e-01f, 3.83422598e-02f, 2.50487495e-02f, -1.26706600e-01f, -1.21067420e-01f, -1.74311921e-02f, -4.60880473e-02f,
  1.05601765e-01f, 7.41135329e-02f, 6.35989010e-04f, 5.15081920e-03f, -2.29906626e-02f, 2.77672000e-02f, -3.64311859e-02f, 1.70585793e-02f, -1.72485020e-02f, -1.19381972e-01f,
  -2.00704351e-01f, -8.92375782e-03f, 1.95067704e-01f, -4.98472750e-02f, 8.72629434e-02f, 2.27487609e-01f, 4.94683497e-02f, 9.60827395e-02f, 1.11889035e-01f, -9.54369232e-02f,
  -5.06337106e-01f, 2.71803975e-01f, -2.36072525e-01f, -1.66745916e-01f, 3.53337914e-01f, 9.27220881e-02f, 2.26446658e-01f, -1.59789041e-01f, -2.93767601e-01f, -6.70681745e-02f,
  1.21406056e-01f, 1.10299572e-01f, -6.63239062e-02f, 6.56858832e-02f, 2.83141397e-02f, 3.43576819e-01f, 2.22317785e-01f, -2.25910604e-01f, -2.87665606e-01f, 5.81933297e-02f,
  2.26068869e-01f, -2.47866273e-01f, -5.46117723e-01f, -1.76728785e-01f, 2.15040356e-01f, -9.43398848e-02f, -6.08143955e-02f, 4.24122289e-02f, 2.12220579e-01f, 3.38697582e-01f,
  -3.13747860e-02f, -1.42576188e-01f, -6.16773665e-02f, 6.18037246e-02f, 6.54067472e-02f, -1.89604715e-01f, -8.23634770e-03f, 2.53303126e-02f, -2.41379160e-02f, 1.33417000e-03f,
  2.55110204e-01f, 1.43089935e-01f, 1.65787026e-01f, 1.40675483e-02f, -1.51170343e-01f, -1.27497688e-01f, -2.76109159e-01f, -2.25648865e-01f, -3.88435990e-01f, -1.44592121e-01f,
  3.62840265e-01f, 1.77677646e-01f, -8.85233805e-02f, 1.34094227e-02f, -9.74222124e-02f, -1.59699604e-01f, -4.08756323e-02f, -4.44207080e-02f, -1.06334895e-01f, -1.71240076e-01f,
  -9.61923599e-02f, 7.59061947e-02f, -6.21612044e-03f, 4.03443538e-02f, 1.63879301e-02f, 1.26911685e-01f, 6.76052198e-02f, 1.75646972e-02f, -3.86159420e-02f, -8.48195106e-02f,
  -6.77055493e-02f, -4.01493572e-02f, -8.60762596e-02f, -9.93869007e-02f, 4.68161553e-02f, -2.52528768e-02f, 4.18060385e-02f, 5.31254783e-02f, 9.18457657e-02f, -3.30680721e-02f,
  3.25898989e-03f, 6.05910383e-02f, 6.42322525e-02f, -1.05314374e-01f, 1.60361797e-01f, -9.46396142e-02f, -4.30577137e-02f, -4.82772812e-02f, -9.43741426e-02f, -1.39439061e-01f,
  -3.79448593e-01f, 2.02519625e-01f, 2.63441280e-02f, -4.62995283e-02f, 7.47849513e-03f, -1.09900311e-01f, 2.28281748e-02f, -6.70209005e-02f, 1.43949464e-01f, -1.40109748e-01f,
  1.02486029e-01f, 7.14491680e-02f, 5.15680127e-02f, 7.54117295e-02f, -2.53394574e-01f, -8.34036712e-03f, 1.87870972e-02f, -1.06115080e-01f, -3.31707448e-02f, -8.46825913e-02f,
  -5.80850504e-02f, -1.06392786e-01f, -1.88597143e-01f, -6.84785917e-02f, -8.93859044e-02f, -1.33607104e-01f, -1.06798574e-01f, -1.57375872e-01f, -4.51779179e-02f, -3.21590185e-01f,
  -4.39906001e-01f, 1.25061974e-01f, 2.13452652e-01f, -1.22557603e-01f, 2.08016038e-01f, 6.77170604e-02f, 4.44860011e-02f, 6.45623356e-02f, 9.80100185e-02f, -4.22860645e-02f,
  9.00203139e-02f, 3.47944759e-02f, -1.30963577e-02f, 5.16702421e-02f, -1.33559600e-01f, 7.26434439e-02f, -5.74529655e-02f, -1.85882196e-01f, -5.70480600e-02f, -6.32170811e-02f,
  -1.30202338e-01f, -3.41837317e-01f, -4.17569727e-01f, -1.31168962e-01f, 6.60560746e-03f, -2.05557272e-01f, -2.31207862e-01f, -2.21462160e-01f, -1.88028008e-01f, -2.16099605e-01f,
  9.01328549e-02f, 9.60436612e-02f, 1.88210666e-01f, -2.55046368e-01f, 2.18924414e-02f, -1.24247475e-02f, -6.54855296e-02f, 1.79380283e-01f, 1.59350663e-01f, -1.32983597e-02f,
  7.05234567e-03f, 2.12267801e-01f, 1.06925137e-01f, 1.34333130e-02f, -1.15882255e-01f, -9.71917883e-02f, 1.23607600e-02f, 1.08095400e-01f, 1.76718652e-01f, 1.69518277e-01f,
  4.82550934e-02f, 8.10249820e-02f, -6.13360107e-02f, -2.91586928e-02f, 1.47216767e-01f, -4.57987487e-02f, 4.17549442e-03f, 9.03446898e-02f, 5.34120984e-02f, -3.96165043e-01f,
  -3.34300399e-02f, 1.39626294e-01f, 5.37191331e-02f, -1.39746860e-01f, -1.16820090e-01f, 1.55989602e-01f, -7.13762119e-02f, -1.00438647e-01f, -1.67676043e-02f, -2.10858826e-02f,
  1.56177357e-01f, 2.25919448e-02f, -3.78622264e-02f, 4.43088444e-04f, -1.36760399e-01f, -3.18055041e-02f, -7.35663297e-03f, -1.70132861e-01f, -1.06316976e-01f, -4.73089777e-02f,
  -2.25870311e-03f, 1.38784619e-02f, -3.46253887e-02f, 3.04217376e-02f, -2.26691533e-02f, -1.26310498e-01f, 2.08440423e-01f, 2.89603211e-02f, 8.23342502e-02f, 4.06696647e-02f,
  -2.70368814e-01f, 1.82539418e-01f, -6.96075112e-02f, -8.94369781e-02f, -7.41630048e-02f, 4.41947253e-03f, -9.22948495e-02f, -2.06788614e-01f, 7.71251842e-02f, -8.27520788e-02f,
  7.88348541e-03f, -7.81840459e-02f, -4.16952409e-02f, 1.03349583e-02f, 5.39757349e-02f, -2.41721924e-02f, -1.75573796e-01f, -7.41457790e-02f, -1.24826776e-02f, -1.99985534e-01f,
  -2.06248179e-01f, -2.62988836e-01f, -2.68697083e-01f, -4.47775386e-02f, -4.62473929e-02f, -3.09557855e-01f, -2.62704462e-01f, -9.56375077e-02f, -2.02199087e-01f, -4.24178362e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  2.82731950e-01f, 1.72337189e-01f, -5.14215082e-02f, 9.84030366e-02f, 3.14593256e-01f, 5.09286165e-01f, -5.82449287e-02f, 8.95443112e-02f, 3.10505599e-01f, 7.68379346e-02f,
  3.82402688e-01f, 2.93007314e-01f, 1.48794129e-01f, -2.06835240e-01f
};

// L1_fan_Wp (Shape: 9 x 32)
const int L1_fan_Wp_rows = 9;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  -2.13221647e-02f, -1.43712878e-01f, -2.06557110e-01f, -7.98597559e-02f, -1.25527918e-01f, -1.84625536e-01f, 1.67359412e-01f, 2.81376038e-02f, -7.31976777e-02f, -1.41667366e-01f,
  9.63217840e-02f, 2.35437185e-01f, 4.53955382e-02f, 8.06828663e-02f, 1.08028119e-02f, 1.52322158e-01f, 1.68396041e-01f, -2.82815029e-03f, -2.91735321e-01f, -1.29408732e-01f,
  9.74010304e-02f, 4.65651117e-02f, -2.02742502e-01f, 1.29655585e-01f, 3.01625878e-01f, -5.03437445e-02f, 9.78890136e-02f, -1.61605272e-02f, 1.42127156e-01f, 5.25383353e-01f,
  -2.44434904e-02f, -6.09786920e-02f, 1.53799638e-01f, 2.14103892e-01f, -1.44186839e-01f, 1.45022169e-01f, 3.72931808e-02f, 5.93721345e-02f, -8.58024284e-02f, 1.47997150e-02f,
  6.79188222e-02f, 7.53134042e-02f, 1.96740046e-01f, -3.64498124e-02f, 2.79586040e-03f, 1.51346186e-02f, -1.51663810e-01f, -5.16381823e-02f, -4.15077001e-01f, -1.03652909e-01f,
  1.11124650e-01f, 6.89046979e-02f, -1.79581955e-01f, 2.30691075e-01f, -1.51324570e-01f, -2.12775636e-03f, 6.91479519e-02f, -8.83180369e-03f, 3.57164033e-02f, -1.30046591e-01f,
  -1.73879117e-01f, 2.44581729e-01f, -2.37380669e-01f, -8.32690485e-03f, 2.87683047e-02f, 2.40589138e-02f, -5.39725982e-02f, -2.00470448e-01f, -2.12747287e-02f, 1.11652846e-02f,
  -1.88876286e-01f, -9.75160897e-02f, 5.14352210e-02f, -2.03486644e-02f, -3.18754286e-01f, 1.72432974e-01f, 1.77079454e-01f, -1.42522268e-02f, -1.10663056e-01f, 6.87478408e-02f,
  1.91290438e-01f, -2.58063735e-03f, -2.72506565e-01f, 1.63755044e-01f, -1.51328266e-01f, -4.85341847e-01f, -9.13279355e-02f, -2.11356193e-01f, 4.38006260e-02f, -1.37284011e-01f,
  3.41396660e-01f, -2.79796809e-01f, -2.43886501e-01f, -2.73220748e-01f, 3.22948784e-01f, -9.58007015e-03f, -6.18518237e-03f, -1.47077188e-01f, -8.95230751e-03f, -2.33306780e-01f,
  -2.86165830e-02f, -3.71446200e-02f, -7.85823986e-02f, 9.42699388e-02f, -2.12454021e-01f, -1.00685023e-02f, 1.34090548e-02f, 2.12488294e-01f, 6.84156939e-02f, 8.43042284e-02f,
  1.22618794e-01f, -6.06720671e-02f, 2.30355293e-01f, 1.70606613e-01f, -4.47566845e-02f, -2.69020855e-01f, -1.82863325e-01f, -1.75780267e-01f, 1.99316323e-01f, -5.64464331e-02f,
  -4.82536294e-02f, 1.30039975e-01f, -1.51922077e-01f, 1.91479743e-01f, 9.73873958e-02f, -4.27542210e-01f, 2.78981894e-01f, -3.53243873e-02f, 1.15702912e-01f, 2.90620118e-01f,
  -7.09880665e-02f, 1.69036657e-01f, 9.49131232e-03f, 1.08192325e-01f, -4.80969436e-02f, 1.55070290e-01f, 7.18101114e-02f, 8.74174461e-02f, -1.81213468e-01f, -9.71371680e-02f,
  4.59689647e-03f, 6.55441061e-02f, -1.14428356e-01f, 8.28225818e-03f, -2.68657953e-01f, -2.82856692e-02f, 3.35739106e-02f, 7.53261298e-02f, 8.80324170e-02f, -2.31701098e-02f,
  1.08126253e-01f, -2.20209658e-01f, 2.77290791e-01f, -7.61989877e-02f, 3.37481111e-01f, 1.59913480e-01f, -2.15931863e-01f, 2.70007551e-01f, -1.65360361e-01f, -1.17333628e-01f,
  -5.40583469e-02f, -2.65800245e-02f, -1.21252991e-01f, -1.56540535e-02f, -6.84117572e-03f, -1.39896497e-01f, -1.71158805e-01f, 6.97171465e-02f, 1.99406017e-02f, -8.83133262e-02f,
  1.77485615e-01f, 1.33566171e-01f, 2.22629815e-01f, 1.00817382e-01f, -2.62380123e-01f, 1.77873135e-01f, 1.59959421e-01f, -4.35097842e-03f, -2.54855722e-01f, 9.15800855e-02f,
  -1.05293386e-01f, -2.79655427e-01f, -1.65552244e-01f, -1.56190852e-02f, -8.78985301e-02f, 3.21260959e-01f, 3.39078665e-01f, -2.95927644e-01f, 3.16469043e-01f, -6.30139792e-03f,
  1.68994069e-01f, 2.67062038e-01f, -1.44647107e-01f, -8.17455277e-02f, 9.84086171e-02f, 2.90406030e-02f, -1.01566330e-01f, -9.79290009e-02f, -1.33408025e-01f, -1.13041051e-01f,
  4.48593423e-02f, 1.32098556e-01f, 8.15384164e-02f, 8.73346925e-02f, -2.70843416e-01f, 1.52132558e-02f, 3.39987278e-02f, -9.40449908e-02f, 7.53053129e-02f, 5.43228500e-02f,
  1.80575490e-01f, -4.32732463e-01f, 5.13595529e-02f, -8.05349126e-02f, -1.85580691e-03f, -3.00572038e-01f, -2.21943945e-01f, -8.06596503e-03f, -8.80239308e-02f, 6.85864985e-01f,
  8.47892463e-02f, -5.42086124e-01f, -1.32645294e-01f, 2.21001744e-01f, -2.77061737e-03f, -1.45483121e-01f, 2.27199104e-02f, -2.60591600e-02f, 8.85865688e-02f, 4.35880534e-02f,
  1.07458778e-01f, 7.28584155e-02f, 1.64682046e-01f, -2.00471655e-01f, -1.34437531e-01f, -5.44930138e-02f, 1.50418818e-01f, 9.56663415e-02f, 1.19975872e-01f, 1.53726220e-01f,
  6.27070814e-02f, 1.13654315e-01f, -3.50793481e-01f, -1.18279658e-01f, -1.83371648e-01f, -2.54813164e-01f, 1.80884525e-01f, 2.12004647e-01f, -7.49765038e-02f, 4.44473252e-02f,
  1.82575405e-01f, -8.87133256e-02f, 5.61221182e-01f, -2.96840698e-01f, 3.12613219e-01f, 1.53272599e-01f, -2.37373468e-02f, 2.52531439e-01f, -1.97492749e-03f, 6.48115873e-02f,
  1.62053317e-01f, -2.87337489e-02f, -5.42280003e-02f, 5.09939380e-02f, -3.96060459e-02f, 7.95258060e-02f, 3.84170324e-01f, -8.11385736e-03f, -2.00480759e-01f, -3.94931138e-02f,
  -4.54739965e-02f, 7.72515265e-03f, -3.92673492e-01f, 1.37006305e-03f, -2.28197455e-01f, 1.30570337e-01f, 7.99954981e-02f, 3.62835795e-01f, 7.50225633e-02f, -3.31893772e-01f,
  -1.65808171e-01f, -1.37789756e-01f, 2.95733046e-02f, 1.59390956e-01f, -1.47614032e-01f, 1.24277025e-01f, -3.76415133e-01f, 4.10919525e-02f
};

// L1_fan_Wp_bar (Shape: 14 x 32)
const int L1_fan_Wp_bar_rows = 14;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  -7.90954232e-02f, -5.75428419e-02f, -9.43336636e-02f, 9.14935544e-02f, 2.42080241e-01f, 3.53455603e-01f, 2.28729710e-01f, -1.46977350e-01f, 2.64479145e-02f, 3.06481794e-02f,
  -5.67612112e-01f, 1.41512230e-01f, 1.28783941e-01f, -5.69921210e-02f, 1.75623834e-01f, -1.77292570e-01f, 4.12200540e-01f, 6.98148012e-02f, 2.72107899e-01f, 1.88415363e-01f,
  -3.11168253e-01f, -3.82438868e-01f, -1.29970849e-01f, 1.80051923e-01f, 3.08200300e-01f, -1.41955689e-01f, 3.32876176e-01f, -4.26182747e-01f, 2.97407091e-01f, 5.72325774e-02f,
  4.61270571e-01f, 2.56046444e-01f, 4.26194305e-03f, 1.48113281e-01f, 1.74708322e-01f, 1.10716581e-01f, -5.05358689e-02f, 4.12876718e-02f, -2.74355020e-02f, 4.01399791e-01f,
  8.11041296e-02f, 1.16044939e-01f, -3.00612301e-01f, -4.56024297e-02f, -2.40258910e-02f, -3.05394605e-02f, -6.27219304e-02f, -2.62107193e-01f, -1.23536475e-01f, -1.38062879e-01f,
  3.38645667e-01f, 1.06551938e-01f, -9.12599042e-02f, -1.99831044e-03f, -2.23160461e-01f, 6.21390402e-01f, 1.47370860e-01f, 1.02818280e-01f, -4.20737490e-02f, -3.79949629e-01f,
  1.57421857e-01f, 4.21870917e-01f, 2.27321938e-01f, -1.47100529e-02f, 1.52213588e-01f, 7.72667304e-03f, 1.07460551e-01f, 3.40348780e-01f, -5.68253780e-03f, -1.25608072e-01f,
  1.62006110e-01f, 5.94984181e-02f, 1.77913934e-01f, -5.41634560e-01f, 7.60530233e-02f, 4.17205095e-01f, 9.68117043e-02f, -1.29537508e-01f, 1.19444013e-01f, 2.58950274e-02f,
  -2.28443474e-01f, 4.85152528e-02f, -1.02820545e-01f, 4.41223867e-02f, -2.98483729e-01f, 4.45023365e-02f, 2.39252537e-01f, 8.37019179e-03f, 2.53372461e-01f, 2.28703901e-01f,
  3.68954271e-01f, 2.03795046e-01f, -7.58377686e-02f, -2.16420487e-01f, 3.99289757e-01f, 4.34933901e-01f, 1.97836056e-01f, 5.95136061e-02f, 2.09329590e-01f, 2.21923679e-01f,
  1.69607490e-01f, -4.05639745e-02f, 4.74057257e-01f, 3.74210179e-01f, 1.28491610e-01f, 1.48947299e-01f, 2.20206678e-01f, -4.43048328e-01f, -1.86004564e-01f, -7.70244654e-03f,
  -1.10247865e-01f, 1.66498020e-01f, 6.46060228e-01f, 4.51488912e-01f, 2.67125696e-01f, -2.63701826e-01f, -4.54239011e-01f, 6.30783811e-02f, 2.58125514e-01f, 4.51344073e-01f,
  -3.61647695e-01f, 9.37715769e-02f, -1.94820121e-01f, -1.99629113e-01f, 4.73618567e-01f, -3.35815489e-01f, 1.93773106e-01f, -1.24086235e-02f, 2.88128614e-01f, 2.27647126e-01f,
  1.81307971e-01f, 2.89512634e-01f, 6.19009435e-02f, 8.55976716e-02f, 4.66199040e-01f, 2.92974770e-01f, 1.89597517e-01f, -1.60924956e-01f, 7.24230781e-02f, -2.37758562e-01f,
  -2.95130163e-01f, -5.25299422e-02f, 2.72844285e-01f, -1.33551791e-01f, 1.69024661e-01f, 4.02793020e-01f, 1.61935300e-01f, -1.92956805e-01f, -2.06092402e-01f, -5.98436370e-02f,
  1.52896136e-01f, 5.12215734e-01f, -3.73346150e-01f, 2.66839951e-01f, -1.01283349e-01f, 5.28984964e-01f, 7.29802787e-01f, -4.14862245e-01f, 2.47194663e-01f, 7.29902473e-04f,
  1.17162555e-01f, 1.72909603e-01f, 4.13788930e-02f, 1.47211984e-01f, -1.10768015e-03f, -3.47292364e-01f, 1.93129942e-01f, -4.85911518e-02f, 1.68795243e-01f, -1.36013076e-01f,
  -9.88110304e-02f, 2.55110413e-01f, 8.93117562e-02f, 1.40011564e-01f, 2.32664100e-03f, 2.22365364e-01f, -3.58913600e-01f, -5.79178967e-02f, 2.21165288e-02f, -1.65082261e-01f,
  -2.63676852e-01f, 1.89918429e-01f, -3.62522990e-01f, 8.52874480e-04f, 5.21663129e-01f, 2.90854573e-01f, 1.66979551e-01f, 1.48106143e-01f, -2.36764133e-01f, 2.75548816e-01f,
  -2.06808537e-01f, 2.76664734e-01f, 1.36941954e-01f, -2.68757254e-01f, 6.91700280e-02f, 1.45712644e-01f, -3.47612858e-01f, 2.85287470e-01f, 2.05355570e-01f, 6.42146915e-02f,
  -1.30204529e-01f, 1.86811332e-02f, -3.29577982e-01f, 2.75140733e-01f, 7.56913156e-04f, -1.85410619e-01f, 1.64470255e-01f, -1.21210031e-01f, 2.87508190e-01f, 4.29582328e-01f,
  4.46347632e-02f, 2.41602838e-01f, -5.41520894e-01f, -2.94400435e-02f, 3.40436250e-01f, -3.23690802e-01f, 5.34970105e-01f, 2.63774812e-01f, 3.81852649e-02f, 1.00573331e-01f,
  -2.14555711e-01f, 2.96355158e-01f, 4.48814958e-01f, 2.65983850e-01f, 1.96683198e-01f, 3.95446330e-01f, 1.92235172e-01f, 2.83274382e-01f, -1.75294112e-02f, 2.47562766e-01f,
  1.23101003e-01f, 2.59774446e-01f, 1.94382519e-01f, 1.31728530e-01f, 2.38311253e-02f, -5.52732527e-01f, -2.27861702e-02f, 1.43972471e-01f, -3.16615045e-01f, 1.04678184e-01f,
  -6.79799244e-02f, -1.85256571e-01f, 3.77290733e-02f, 1.29732832e-01f, -2.87101090e-01f, 2.86288977e-01f, -3.04105461e-01f, 4.96914715e-01f, 2.39928171e-01f, 3.66332382e-01f,
  4.18439239e-01f, -5.72155237e-01f, 1.14659794e-01f, 1.89473391e-01f, -2.16917038e-01f, -1.38791472e-01f, 3.34221348e-02f, -8.86144266e-02f, 1.06578216e-01f, 3.95766692e-03f,
  2.28818282e-02f, 8.87774676e-02f, -1.41292671e-02f, -5.22008315e-02f, -1.61070898e-01f, -1.11656543e-02f, -2.49168515e-01f, -4.49862592e-02f, -2.04402164e-01f, 3.94346714e-02f,
  8.91535804e-02f, 8.79572704e-02f, 3.45612049e-01f, -2.97630448e-02f, 2.27276191e-01f, 5.23846626e-01f, -4.38063405e-02f, -2.76676834e-01f, -1.72545776e-01f, 1.81771606e-01f,
  -1.41387982e-02f, -8.43307227e-02f, -3.63605082e-01f, -2.09619790e-01f, 2.02662945e-01f, 1.22017145e-01f, 4.41743642e-01f, -3.81008126e-02f, -5.00594713e-02f, -7.05745220e-02f,
  1.24854401e-01f, -1.72302902e-01f, 2.03335704e-03f, -4.10615392e-02f, 8.70704055e-02f, -1.89970769e-02f, 6.00813963e-02f, -8.22071061e-02f, -2.92281717e-01f, 7.60329887e-02f,
  -2.49868892e-02f, -4.93293032e-02f, -1.82661757e-01f, 5.24658635e-02f, -4.39414345e-02f, -1.16481267e-01f, 2.96814770e-01f, 2.66681135e-01f, 8.57587680e-02f, 4.46780249e-02f,
  1.53798968e-01f, -1.18925802e-01f, 3.49572480e-01f, 1.35931805e-01f, 4.79880385e-02f, -6.54092968e-01f, -2.05841288e-01f, 5.52991927e-01f, 3.56917679e-01f, 1.60581917e-01f,
  -9.46291431e-04f, -9.97764766e-02f, -2.17897907e-01f, -6.14434741e-02f, 1.70141414e-01f, 2.18555138e-01f, 4.12481800e-02f, 2.42010623e-01f, 5.91404475e-02f, 2.51530670e-02f,
  -2.71717012e-01f, 7.01620206e-02f, 3.70665267e-02f, 1.30443219e-02f, 2.64882654e-01f, -1.41112149e-01f, -1.10161342e-01f, -1.65198937e-01f, -3.88776422e-01f, -5.07506549e-01f,
  1.11831538e-01f, -2.50997841e-01f, -1.74114943e-01f, -1.39871135e-01f, 9.12385359e-02f, 3.76949579e-01f, 2.55548298e-01f, 1.02954775e-01f, 4.27839875e-01f, -2.02099323e-01f,
  1.70769289e-01f, 4.28821921e-01f, 7.51861706e-02f, -1.41100362e-01f, -1.82429239e-01f, 8.40941072e-02f, -9.50419903e-03f, 3.14765684e-02f, 1.21550791e-01f, 1.64300993e-01f,
  1.81267671e-02f, -9.56472978e-02f, -9.62138623e-02f, 3.33798140e-01f, 1.91450477e-01f, 7.97780380e-02f, -1.89642701e-02f, 1.09582976e-01f, -5.09971892e-03f, 7.87885264e-02f,
  -2.79991388e-01f, -1.01176105e-01f, -1.57397360e-01f, -3.71637851e-01f, -5.40035009e-01f, 7.87728578e-02f, 4.12712470e-02f, 1.24578699e-01f, 3.36051077e-01f, 1.71065733e-01f,
  2.34060958e-01f, 1.26804590e-01f, -3.22886482e-02f, 1.50358304e-01f, -1.32643338e-03f, 1.43874899e-01f, 4.44037229e-01f, -1.29682183e-01f, 2.45530009e-02f, 9.02547315e-02f,
  1.24894947e-01f, 1.32647291e-01f, 8.18088278e-02f, 4.87295598e-01f, -1.74554855e-01f, -8.85290802e-02f, -1.88136131e-01f, -7.06741912e-03f, 2.26290300e-01f, -2.64085978e-01f,
  5.54458976e-01f, 2.71600902e-01f, 4.74873304e-01f, 2.64816612e-01f, -1.86489046e-01f, -8.49338412e-01f, 1.61896929e-01f, 2.59590954e-01f, -5.03166258e-01f, -2.21529141e-01f,
  -6.19161665e-01f, 1.35927759e-02f, 4.48402837e-02f, 2.77265728e-01f, 1.27533898e-01f, 1.27722695e-01f, 3.25676829e-01f, 5.39334655e-01f, 8.29935297e-02f, 5.27209938e-01f,
  2.40318462e-01f, 1.56836361e-02f, 4.16975528e-01f, 9.87969413e-02f, 1.91893607e-01f, -4.10809606e-01f, 7.54754066e-01f, -1.45444274e-01f, 1.76138386e-01f, 4.37121950e-02f,
  1.78330153e-01f, 1.13716654e-01f, -6.51793540e-01f, -1.43616140e-01f, -3.21909726e-01f, -2.84528911e-01f, -4.73267138e-01f, 6.35653138e-01f, 1.62794515e-02f, 1.07813235e-02f,
  -1.90602824e-01f, 3.53188843e-01f, -4.95211072e-02f, 8.38469714e-04f, 2.23452806e-01f, 2.34341417e-02f, 3.29646952e-02f, -9.32797492e-02f
};

// L1_fan_Bp_bar (Shape: 1 x 14)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 14;
const float L1_fan_Bp_bar_data[] = {
  2.71940753e-02f, 1.52546570e-01f, 3.75689268e-01f, 2.81116128e-01f, 3.68126839e-01f, 3.23808759e-01f, -8.66350904e-02f, 3.75403643e-01f, -8.76147524e-02f, -1.31103009e-01f,
  2.45035142e-02f, 4.79575358e-02f, 1.67268872e-01f, 1.33644834e-01f
};

// L2_fan_Wp (Shape: 9 x 32)
const int L2_fan_Wp_rows = 9;
const int L2_fan_Wp_cols = 32;
const float L2_fan_Wp_data[] = {
  -1.10085733e-01f, -1.00102052e-02f, -1.87453687e-01f, 1.09881416e-01f, 2.00941011e-01f, 9.53645632e-02f, 8.16780478e-02f, -2.65694201e-01f, 1.40867904e-01f, 3.70632350e-01f,
  3.99590641e-01f, -2.16034334e-02f, 7.37844706e-02f, 8.43582377e-02f, 4.63587679e-02f, -1.60091799e-02f, 4.46147382e-01f, -1.26410276e-01f, 8.97958055e-02f, 2.96068918e-02f,
  2.31588721e-01f, -2.28004500e-01f, -9.70256701e-02f, 3.94917458e-01f, 1.50909826e-01f, 3.30456764e-01f, -3.06993753e-01f, -2.11057678e-01f, 3.63207698e-01f, 6.49271980e-02f,
  -2.57686168e-01f, 4.10201371e-01f, 1.44443542e-01f, 1.86258227e-01f, 1.47065595e-01f, 8.44439783e-04f, -1.63768362e-02f, 2.71332562e-01f, -1.72903404e-01f, -3.76260318e-02f,
  -8.01708698e-02f, 7.42760897e-02f, -2.93510824e-01f, 3.74804139e-01f, 3.37442309e-01f, -2.39461541e-01f, 5.79848826e-01f, 1.77269559e-02f, 2.45610952e-01f, -4.50535230e-02f,
  -6.59435689e-02f, -1.53504759e-01f, 2.06165202e-02f, 8.23633671e-02f, -1.02090061e-01f, -1.23168103e-01f, -3.23165320e-02f, 3.05777118e-02f, 2.03351498e-01f, 9.72430483e-02f,
  -1.53883219e-01f, 1.75069690e-01f, 1.01803571e-01f, -1.89118326e-01f, -1.59540728e-01f, 1.54312894e-01f, 5.96399456e-02f, 1.75670475e-01f, -1.52921468e-01f, -5.01402356e-02f,
  -4.47940618e-01f, 2.40188271e-01f, -1.95973203e-01f, -3.33884448e-01f, -3.65484022e-02f, 1.30463671e-02f, -1.01811834e-01f, 1.48229122e-01f, 5.69348574e-01f, -4.31635171e-01f,
  -3.17821294e-01f, 2.30869532e-01f, 5.58066182e-02f, -1.56961121e-02f, -2.14010730e-01f, 1.01094671e-01f, -7.60307685e-02f, 4.30699103e-02f, 1.74720772e-02f, 5.01393497e-01f,
  1.08604036e-01f, 7.47572223e-04f, -3.66814226e-01f, 1.02001466e-01f, 2.49711365e-01f, -4.76995744e-02f, 5.63602382e-03f, 1.46292746e-01f, 3.41802567e-01f, -1.89785659e-01f,
  -3.06571601e-03f, -2.33564883e-01f, 1.71028659e-01f, 2.62461036e-01f, 3.33847761e-01f, 8.98448452e-02f, -2.31094569e-01f, 6.44029006e-02f, -3.06170166e-01f, 1.83649629e-01f,
  3.60765636e-01f, 4.01608229e-01f, -4.57280248e-01f, 2.72626996e-01f, -3.43144506e-01f, -2.05303565e-01f, 2.10329406e-02f, 8.07276592e-02f, 3.88141535e-02f, 2.78266877e-01f,
  2.13336736e-01f, -6.54796604e-03f, -2.61589974e-01f, 2.09360719e-02f, 2.22176000e-01f, 1.68811344e-02f, -1.30344890e-02f, 1.88337967e-01f, -1.36272311e-01f, -3.21418881e-01f,
  -5.93956895e-02f, -4.24829155e-01f, -2.29277909e-02f, -1.52448386e-01f, 1.19044572e-01f, -9.84481052e-02f, -2.00393796e-01f, 1.83523074e-01f, -1.84945256e-01f, -1.45874649e-01f,
  2.88879186e-01f, 1.48998603e-01f, -4.25080240e-01f, 6.41263649e-02f, -6.40472054e-01f, 2.17161760e-01f, -4.01446760e-01f, -3.53896081e-01f, -2.52150670e-02f, -1.27318069e-01f,
  -2.08872017e-02f, -3.57244699e-03f, 1.95736244e-01f, -2.67278373e-01f, -1.48278251e-01f, -1.48818031e-01f, -8.18896517e-02f, -1.90796524e-01f, 9.02570933e-02f, 1.81457952e-01f,
  -3.66934508e-01f, -1.33784013e-02f, -4.68477547e-01f, 2.43168950e-01f, -1.94691807e-01f, -4.67051536e-01f, -1.98005289e-01f, -1.12674564e-01f, -2.36143529e-01f, 1.66680589e-01f,
  3.40169579e-01f, 3.51192623e-01f, 2.65638262e-01f, -4.10887673e-02f, -1.38939738e-01f, -8.14970732e-02f, -1.67858824e-01f, 4.57024388e-02f, -7.91053846e-02f, 4.36262786e-02f,
  -3.86814699e-02f, -4.33340102e-01f, -1.95459902e-01f, 1.02252133e-01f, 1.38759434e-01f, -3.75442058e-01f, -2.53040284e-01f, -5.40145673e-02f, -1.18658438e-01f, 1.77681729e-01f,
  -1.11434013e-01f, -1.21058606e-01f, -6.93386868e-02f, 5.21178767e-02f, -1.54467657e-01f, -6.66843578e-02f, -1.00056818e-02f, -3.20448130e-01f, -3.68704237e-02f, -9.61490795e-02f,
  -2.23860756e-01f, -3.55661772e-02f, 9.39649269e-02f, -2.45022327e-01f, -4.04903620e-01f, 4.41719621e-01f, -2.17444941e-01f, -8.91116038e-02f, -4.07024622e-01f, 1.52531505e-01f,
  -4.32295978e-01f, 3.06813475e-02f, 7.05819875e-02f, -3.21713418e-01f, 1.16902031e-01f, 6.32478623e-03f, -3.55708182e-01f, -2.53471863e-02f, 1.29457172e-02f, -8.39731768e-02f,
  -1.44035235e-01f, -8.22573807e-03f, -2.15538666e-02f, -7.98200350e-03f, 7.23010004e-02f, 4.97671887e-02f, 7.00805057e-03f, 6.04610667e-02f, 9.19150561e-03f, 7.24976435e-02f,
  -6.44860566e-02f, -1.70534998e-01f, 1.23116620e-01f, -2.67660804e-02f, -2.80557692e-01f, -5.47905117e-02f, 4.30074602e-01f, -3.15603971e-01f, -9.80260000e-02f, 2.75253594e-01f,
  1.70597717e-01f, -2.98128307e-01f, 1.13274455e-01f, -2.46333480e-02f, -9.63811502e-02f, 3.73429246e-02f, 1.99845701e-01f, -1.03465207e-01f, 2.66804248e-01f, 8.28378554e-03f,
  1.23167977e-01f, 9.36335400e-02f, 2.85376813e-02f, 6.38575330e-02f, 1.21158071e-01f, -4.08534020e-01f, 1.75544351e-01f, -2.24554092e-02f, 3.16817373e-01f, -5.16415201e-03f,
  8.56747106e-02f, 8.94125104e-02f, 4.19457495e-01f, 7.62177259e-02f, 2.55520403e-01f, 2.42040548e-02f, -4.66157854e-01f, -2.37107202e-01f, 7.95092881e-02f, -7.80805796e-02f,
  1.45087019e-01f, -1.03135236e-01f, -9.77636408e-03f, -1.15802020e-01f, -3.88605334e-02f, -2.75658250e-01f, 5.57453781e-02f, 3.04239154e-01f, 2.70391852e-01f, -2.68928319e-01f,
  -7.50950212e-03f, -1.60761457e-02f, 1.34660810e-01f, -5.36695831e-02f, 2.12948136e-02f, -4.22678031e-02f, -5.75105809e-02f, 1.22584648e-01f
};

// L2_fan_Wp_bar (Shape: 14 x 32)
const int L2_fan_Wp_bar_rows = 14;
const int L2_fan_Wp_bar_cols = 32;
const float L2_fan_Wp_bar_data[] = {
  1.98003203e-02f, 3.83476585e-01f, -2.33324319e-01f, 1.55563969e-02f, 1.58963338e-01f, 5.13648689e-02f, -1.85963959e-02f, -1.27848744e-01f, -6.32866621e-02f, 6.39488399e-02f,
  -2.11106345e-01f, 7.20575988e-01f, 4.70372677e-01f, 2.36892123e-02f, 6.12111725e-02f, 2.26256270e-02f, 4.15272444e-01f, -4.91709828e-01f, 6.04430854e-01f, 1.61748976e-01f,
  2.94012547e-01f, 2.07546651e-02f, -2.23246347e-02f, 1.55736923e-01f, 3.41493934e-01f, 1.76451325e-01f, -1.88439414e-01f, -1.05847575e-01f, 4.32490826e-01f, 2.03003019e-01f,
  -2.17239648e-01f, -4.05650675e-01f, 2.54492983e-02f, 2.01758593e-01f, -1.40316024e-01f, 1.79580957e-01f, 4.08794045e-01f, 4.43734556e-01f, 1.89741209e-01f, 1.26219526e-01f,
  4.58393753e-01f, 1.02252156e-01f, -5.85242867e-01f, -5.13404012e-01f, -3.86723906e-01f, -5.07375300e-01f, 7.64399022e-02f, -3.21729273e-01f, 4.05405499e-02f, -5.57936251e-01f,
  5.09255826e-01f, 5.81924081e-01f, -3.00974607e-01f, 4.71040636e-01f, 3.07533264e-01f, -4.34268445e-01f, -5.29413581e-01f, 4.69532549e-01f, 2.94716030e-01f, -1.42230913e-01f,
  2.42314907e-03f, -4.34218884e-01f, 4.15328622e-01f, -1.61948204e-01f, 2.00780421e-01f, 1.27586097e-01f, 4.03727472e-01f, 2.16342672e-03f, 9.37521085e-02f, -2.56411750e-02f,
  -6.51620477e-02f, 1.63817674e-01f, 4.78783220e-01f, 8.57189968e-02f, 1.26258031e-01f, 3.63705575e-01f, -1.80063114e-01f, 1.42328441e-01f, 7.43340194e-01f, -2.72425413e-01f,
  7.71216899e-02f, -1.35603517e-01f, 2.86669165e-01f, 1.08471006e-01f, 3.39654058e-01f, 6.87454566e-02f, -1.37382910e-01f, 2.34136373e-01f, 2.76168436e-01f, 2.52722323e-01f,
  -2.53753334e-01f, -2.04982072e-01f, 3.97496164e-01f, 6.37068391e-01f, -3.89847606e-01f, 6.71366006e-02f, 2.73934335e-01f, 3.41216564e-01f, -3.71128917e-02f, 9.71469209e-02f,
  6.47153676e-01f, 2.36870155e-01f, -8.61570537e-02f, 1.16878927e-01f, 3.52759808e-01f, -2.93267444e-02f, -6.87277913e-01f, -5.49453676e-01f, -5.00900298e-02f, -3.29187781e-01f,
  -1.13869123e-01f, -1.55181527e-01f, 4.91061918e-02f, -2.17153504e-01f, 2.07473949e-01f, 1.79481655e-01f, -4.30219024e-01f, 4.59279031e-01f, 4.15484428e-01f, -7.22664416e-01f,
  -1.73641279e-01f, 6.30263016e-02f, 1.95214823e-01f, -1.46192297e-01f, -2.96605583e-02f, -7.72258103e-01f, 3.49634677e-01f, -2.46038407e-01f, -2.53549457e-01f, -4.84182499e-02f,
  1.83304250e-01f, -2.37019390e-01f, -5.59153892e-02f, -1.53825104e-01f, 3.07871494e-02f, 1.14999469e-02f, -1.29420623e-01f, 1.01792507e-01f, 5.17150089e-02f, 4.78271917e-02f,
  -3.37139368e-02f, 1.35933101e-01f, -1.73042491e-01f, 1.48311228e-01f, -3.89512241e-01f, 1.47079930e-01f, 9.42012817e-02f, 3.48207861e-01f, 3.77013683e-01f, -2.96395421e-01f,
  -1.19095981e-01f, 3.07775021e-01f, 6.41056657e-01f, 6.18678294e-02f, -1.14050701e-01f, 1.93815470e-01f, 2.65326679e-01f, 1.78915218e-01f, 2.70876437e-01f, -8.12065080e-02f,
  7.97107965e-02f, -5.90594951e-03f, 2.71119595e-01f, 2.84646541e-01f, 7.00976774e-02f, 5.36023855e-01f, 5.66595554e-01f, 7.27176219e-02f, -9.85365584e-02f, -7.73815811e-02f,
  1.06839001e-01f, -7.16602027e-01f, 1.21443637e-01f, -4.84414995e-01f, -4.48370099e-01f, -1.38972819e-01f, 7.04144299e-01f, -2.28059459e-02f, -1.22896381e-01f, 1.19166993e-01f,
  1.88991591e-01f, 2.39290014e-01f, 4.17810887e-01f, 4.28343564e-02f, -1.87761083e-01f, 2.18371868e-01f, -1.25204936e-01f, -3.44813615e-01f, -9.60073620e-02f, -2.96126962e-01f,
  -3.14732909e-01f, 6.50453031e-01f, -5.73382853e-03f, -2.73750812e-01f, 5.41311502e-01f, -1.85945649e-02f, -1.46247879e-01f, 3.33633013e-02f, 3.89531136e-01f, 1.26171753e-01f,
  2.74942458e-01f, 1.00891896e-01f, -9.46671516e-02f, -3.47102225e-01f, -1.21172041e-01f, -3.23709100e-02f, 1.38296634e-01f, 3.01527292e-01f, 2.50642210e-01f, 3.16847622e-01f,
  5.12289926e-02f, -2.12779036e-03f, 4.13624197e-01f, -9.45221074e-03f, 2.91509271e-01f, 4.10742342e-01f, 3.96302611e-01f, 8.40504020e-02f, -4.11982656e-01f, -1.18500546e-01f,
  4.35055196e-01f, 1.45557210e-01f, -4.29496229e-01f, 4.28954750e-01f, 4.18735981e-01f, 2.95084149e-01f, 5.82198083e-01f, 7.57338628e-02f, 5.08901536e-01f, -7.80517310e-02f,
  3.40164304e-01f, 2.63277858e-01f, 4.12044168e-01f, -2.16433272e-01f, -2.50076622e-01f, -4.10368472e-01f, 3.56696188e-01f, -8.63756761e-02f, -7.34740272e-02f, 5.67677259e-01f,
  5.08393347e-01f, 1.66989520e-01f, -2.28837684e-01f, -2.95242578e-01f, 3.20520669e-01f, 5.22542834e-01f, 5.51608145e-01f, 5.35308849e-04f, 1.73800196e-02f, -2.46910155e-01f,
  -5.05666196e-01f, -6.12105370e-01f, 1.08415999e-01f, 8.78058821e-02f, -6.33953884e-02f, 4.56610501e-01f, -2.52821028e-01f, -1.21546015e-01f, -2.80011475e-01f, -5.02444983e-01f,
  1.71107590e-01f, 1.44040525e-01f, -4.36412752e-01f, 1.58204734e-01f, -1.42690137e-01f, -8.96579623e-02f, 1.69916019e-01f, -1.39908716e-01f, -6.52536511e-01f, 1.29041269e-01f,
  -2.53623128e-02f, -5.16917288e-01f, -7.65787840e-01f, 1.29661947e-01f, -3.49071383e-01f, 3.03620875e-01f, -3.74378972e-02f, 8.91093016e-02f, 2.78557930e-02f, 1.62078604e-01f,
  -5.22486344e-02f, 4.47309911e-01f, 2.88717091e-01f, 2.54499286e-01f, -3.80746931e-01f, -2.33531639e-01f, 5.32048345e-01f, 2.56871730e-01f, 1.04193524e-01f, 8.27964693e-02f,
  3.71684104e-01f, 3.69487166e-01f, 2.09107056e-01f, 4.28867489e-01f, 8.05466771e-02f, 5.42811692e-01f, 2.53354639e-01f, -9.93221998e-02f, 4.43253547e-01f, -3.90664726e-01f,
  -5.47811866e-01f, -1.12323880e-01f, 7.28125637e-03f, -4.11107808e-01f, 5.47562718e-01f, -2.19060227e-01f, -1.66668370e-01f, 2.98228979e-01f, 3.57979052e-02f, 2.28230760e-01f,
  1.47808388e-01f, 1.33805260e-01f, -3.98661524e-01f, 4.26487327e-01f, 3.38372588e-02f, -4.31465387e-01f, -1.89208180e-01f, -9.65547264e-02f, -1.17896490e-01f, 3.17059815e-01f,
  -5.74847534e-02f, 1.91067889e-01f, 1.59426630e-01f, -4.60678637e-02f, 1.66229740e-01f, -1.91476330e-01f, 1.24331661e-01f, 4.17846471e-01f, 2.83014625e-01f, 3.19584996e-01f,
  1.43918782e-01f, 3.97304356e-01f, -2.39371970e-01f, 1.15046397e-01f, 6.49626076e-01f, -1.35493472e-01f, 2.71282226e-01f, -1.42499711e-02f, 3.00664395e-01f, 1.64367199e-01f,
  1.99044660e-01f, 7.53688812e-02f, -1.37420446e-01f, 7.59333149e-02f, 4.11356315e-02f, 1.63889721e-01f, -6.10351503e-01f, 1.09885909e-01f, 3.04379195e-01f, 4.47019517e-01f,
  -4.42173570e-01f, -1.22772725e-02f, -1.09707184e-01f, 4.54141665e-03f, 4.05698568e-01f, 1.36077076e-01f, 2.76820868e-01f, -1.40063241e-01f, 5.16974777e-02f, 1.71286970e-01f,
  1.05047181e-01f, -4.38016534e-01f, -5.08161306e-01f, -1.71522751e-01f, 3.98089051e-01f, -1.58328772e-01f, -1.24511391e-01f, -2.54221857e-01f, -4.72101197e-02f, -1.60952851e-01f,
  4.11955148e-01f, -1.24981932e-01f, 1.69852823e-01f, 5.87396204e-01f, 3.48012000e-01f, -3.18171322e-01f, 5.43785274e-01f, -5.07073402e-01f, 1.26975879e-01f, 2.15117857e-01f,
  -1.58999592e-01f, -9.30437967e-02f, 2.79339403e-01f, -1.78924635e-01f, 1.43501349e-02f, 1.18215792e-01f, 4.09298539e-01f, 7.30519667e-02f, 4.73717377e-02f, 7.26214573e-02f,
  -3.90064925e-01f, 6.74301684e-01f, 2.75349021e-01f, -2.98148334e-01f, 4.93109822e-01f, 2.61723369e-01f, -5.51765144e-01f, 3.44596207e-01f, 3.91385317e-01f, -3.07599843e-01f,
  -3.73798013e-01f, 2.18092754e-01f, -1.09538719e-01f, 2.63614684e-01f, 2.25631744e-01f, -1.85278624e-01f, 2.55722459e-02f, 8.10305849e-02f, -9.05116871e-02f, 3.23659331e-01f,
  -3.48276645e-02f, -7.21128508e-02f, -8.58534575e-02f, 1.66619554e-01f, 2.42681429e-01f, 2.30101034e-01f, -2.51800790e-02f, -5.73745072e-02f, 3.19984227e-01f, -1.26804993e-01f,
  -1.65121809e-01f, 1.00405380e-01f, 8.37851241e-02f, 1.03121556e-01f, 2.14701798e-02f, 4.00926434e-02f, 4.02284831e-01f, 1.73128963e-01f, -2.03988552e-01f, 3.20686042e-01f,
  2.03480169e-01f, -3.78619991e-02f, -2.22361520e-01f, -2.36003604e-02f, 3.71742249e-03f, 2.27818295e-01f, 2.39144385e-01f, -1.03542089e-01f, 5.96691594e-02f, 3.53525877e-01f,
  3.84037852e-01f, 4.47915792e-01f, -5.94411604e-02f, 1.53752550e-01f, 4.29294212e-03f, 1.44086361e-01f, -9.26058143e-02f, 1.20263800e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 14)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 14;
const float L2_fan_Bp_bar_data[] = {
  -1.94463640e-01f, 4.96391617e-02f, -1.60738483e-01f, 2.05177858e-01f, 1.06453240e-01f, -8.53470191e-02f, -3.53960283e-02f, 3.55515599e-01f, 1.12345800e-01f, 1.86627477e-01f,
  -1.81342685e-03f, 2.25658894e-01f, 2.41638541e-01f, 2.69671917e-01f
};

// L3_fan_Wp (Shape: 9 x 32)
const int L3_fan_Wp_rows = 9;
const int L3_fan_Wp_cols = 32;
const float L3_fan_Wp_data[] = {
  2.67948247e-02f, 7.39065334e-02f, 2.17063422e-03f, 3.29123288e-01f, -5.05933352e-02f, 5.11491373e-02f, 5.53916216e-01f, 1.19221903e-01f, 9.63957533e-02f, 2.47980267e-01f,
  -2.71262228e-01f, -2.49325931e-01f, 5.66075683e-01f, 1.82005063e-01f, 2.69065201e-01f, -4.00224552e-02f, -2.42692098e-01f, 2.82021537e-02f, -1.87796295e-01f, -3.55354697e-02f,
  3.32468897e-02f, -5.27454913e-02f, 3.44886817e-02f, -3.20344046e-02f, -2.41057456e-01f, 3.09652001e-01f, 2.64923573e-02f, 1.72323599e-01f, -8.17665532e-02f, 6.99357875e-03f,
  1.30677029e-01f, -6.56796247e-02f, -1.91175230e-02f, 1.73788965e-01f, 6.45898096e-03f, 3.44902039e-01f, 5.62649846e-01f, 3.30037266e-01f, -2.38568008e-01f, 9.15372074e-02f,
  8.90180543e-02f, -1.44576831e-02f, -2.52196401e-01f, -2.04466894e-01f, 4.53616232e-01f, 5.00413597e-01f, -1.98004484e-01f, -7.54191503e-02f, 1.84567899e-01f, -1.73660293e-01f,
  -1.16322096e-02f, -2.41595879e-01f, -1.24145418e-01f, 3.80929336e-02f, 3.13840061e-02f, 1.33226141e-01f, -1.31484896e-01f, 1.50387198e-01f, -1.04688562e-01f, -3.78851369e-02f,
  -1.38105258e-01f, 9.32025611e-02f, -6.06474206e-02f, -1.48704648e-02f, 2.47633621e-01f, -8.87299608e-03f, 2.14714818e-02f, 1.70059741e-01f, -3.06521982e-01f, 2.78709661e-02f,
  2.24942163e-01f, 2.42008850e-01f, 2.38926828e-01f, -2.37354472e-01f, -1.33418189e-02f, -1.17607908e-02f, -4.24184769e-01f, -2.92282701e-01f, 1.77398905e-01f, 8.62534195e-02f,
  1.34823889e-01f, -5.68956370e-03f, -3.03745233e-02f, 1.42161578e-01f, -8.77091140e-02f, 4.07052673e-02f, -1.60442349e-02f, 3.49132091e-01f, -1.30324826e-01f, -2.27824956e-01f,
  4.61308025e-02f, 2.90665269e-01f, -2.34226570e-01f, 4.53232229e-02f, -1.31888881e-01f, -8.30201805e-02f, 2.04700425e-01f, 2.12243840e-01f, -8.57538804e-02f, 3.99122648e-02f,
  -2.32403740e-01f, -2.08237857e-01f, -3.32660139e-01f, 6.17640885e-03f, -1.27203718e-01f, 2.49954969e-01f, 1.54481888e-01f, -3.43326807e-01f, -4.52776207e-03f, 1.36665300e-01f,
  2.90034831e-01f, -7.45802000e-02f, 3.05254549e-01f, 7.59595707e-02f, 3.11338961e-01f, 6.30765408e-02f, -3.96220461e-02f, -3.55665870e-02f, -1.34647980e-01f, 2.31714219e-01f,
  7.23460168e-02f, 9.10303518e-02f, -1.35442927e-01f, -8.26628059e-02f, -1.52529832e-02f, 5.73045313e-02f, -3.02296162e-01f, -3.52653787e-02f, -2.47594580e-01f, -1.04410850e-01f,
  1.99880436e-01f, -4.70623583e-01f, 2.19488591e-02f, -1.56543732e-01f, -1.26956940e-01f, -2.09278226e-01f, -2.97036748e-02f, -5.20466864e-02f, 2.92378664e-01f, 5.38202405e-01f,
  -2.67949343e-01f, -1.91269800e-01f, -3.55407327e-01f, 2.11643446e-02f, -2.70671248e-01f, 4.97820191e-02f, -1.82031557e-01f, -2.17889309e-01f, 1.86167404e-01f, -2.22547213e-03f,
  -5.49834892e-02f, -3.05049896e-01f, 1.41947418e-01f, -1.60674676e-01f, -2.21969299e-02f, -9.12127346e-02f, -2.49476153e-02f, 1.71111718e-01f, 2.49086529e-01f, 1.98060215e-01f,
  2.15926409e-01f, 4.24829572e-02f, -2.32231498e-01f, -5.76751493e-02f, 2.56597507e-03f, 7.29692578e-02f, -5.03458500e-01f, -1.31755963e-01f, -2.47213721e-01f, -2.19672218e-01f,
  -3.67641300e-02f, -1.34851113e-01f, -1.78456709e-01f, -7.44636953e-02f, 5.23202792e-02f, 2.24603057e-01f, -2.08033010e-01f, 3.02370805e-02f, 2.39462763e-01f, -6.83819177e-03f,
  -1.54200390e-01f, 1.81487184e-02f, 4.65632267e-02f, -1.31343736e-03f, -1.19604915e-01f, -3.05069331e-03f, -3.08241338e-01f, 3.73260714e-02f, 3.02942395e-02f, 1.98998421e-01f,
  -1.44663438e-01f, -6.81537464e-02f, -1.37234673e-01f, 3.77295762e-01f, 2.55941063e-01f, -9.68860835e-03f, 1.11136913e-01f, -1.42092317e-01f, 1.92787021e-01f, -1.19781913e-02f,
  1.98111564e-01f, -3.48325253e-01f, -3.53187323e-02f, 5.56600466e-02f, 2.31590897e-01f, 2.31982097e-01f, 7.66715705e-02f, -4.04667631e-02f, 3.99798751e-01f, 8.77227038e-02f,
  8.82755369e-02f, -1.11838855e-01f, 2.04222426e-01f, 3.18484791e-02f, -3.74396518e-02f, -2.94675976e-01f, 5.68320155e-02f, 2.00951159e-01f, -7.32335299e-02f, -4.40610796e-01f,
  1.32758394e-01f, 7.35252872e-02f, -5.82042448e-02f, -1.18756332e-01f, -1.23085886e-01f, 8.82292986e-02f, -2.88666874e-01f, 3.94534498e-01f, 3.22021723e-01f, 2.26722807e-01f,
  -1.04281483e-02f, 1.02825522e-01f, 1.33452430e-01f, 1.46471366e-01f, 2.81601045e-02f, -2.41753891e-01f, 4.52341527e-01f, 4.54829037e-01f, -1.55595969e-02f, 1.68577462e-01f,
  -1.82869703e-01f, -9.79060456e-02f, 2.11260781e-01f, -2.78149903e-01f, -1.66644081e-01f, -2.47201875e-01f, -5.70447110e-02f, 1.45773143e-01f, -2.50361562e-01f, 2.64012694e-01f,
  1.39791623e-01f, 3.41917165e-02f, -1.65198460e-01f, 4.75195795e-02f, -9.96973738e-02f, 6.91631585e-02f, -1.11247279e-01f, -2.22083688e-01f, -2.89258897e-01f, -3.18237692e-02f,
  -5.48105299e-01f, -1.47271886e-01f, -1.90568537e-01f, -2.65926033e-01f, 1.26274541e-01f, 4.49061953e-02f, 1.57078490e-01f, 3.68842781e-01f, -3.53346579e-03f, -9.53777358e-02f,
  -5.47172443e-04f, 3.43129218e-01f, -3.73642296e-01f, 3.32992435e-01f, 1.35028660e-01f, 4.73301969e-02f, 4.40795943e-02f, -8.61512311e-03f, -1.68335631e-01f, -7.18121082e-02f,
  -2.99529731e-01f, -2.60658056e-01f, 1.39764771e-01f, 1.24730684e-01f, 1.05696350e-01f, -1.33195668e-01f, 1.62498444e-01f, -1.71497658e-01f
};

// L3_fan_Wp_bar (Shape: 14 x 32)
const int L3_fan_Wp_bar_rows = 14;
const int L3_fan_Wp_bar_cols = 32;
const float L3_fan_Wp_bar_data[] = {
  5.52444160e-01f, 5.30958325e-02f, 1.19557120e-02f, 2.08181918e-01f, -4.46878612e-01f, -1.10029846e-01f, 3.81291538e-01f, -1.92605816e-02f, -9.68901142e-02f, -8.90184268e-02f,
  -5.66016674e-01f, -2.05267325e-01f, -3.36979508e-01f, -4.79475826e-01f, 2.99328387e-01f, -3.48529875e-01f, 3.37215394e-01f, 1.99975029e-01f, -4.84829932e-01f, 6.61773026e-01f,
  2.02990517e-01f, 4.39473212e-01f, -4.31450218e-01f, 3.58850718e-01f, -1.31474555e-01f, -1.13068588e-01f, 9.05868858e-02f, 5.94802499e-01f, -2.74269972e-02f, -1.22067362e-01f,
  -7.73967206e-02f, 5.80372326e-02f, -4.39810127e-01f, -1.97057072e-02f, -5.63404448e-02f, 6.27432644e-01f, -6.96310326e-02f, 2.30910569e-01f, 2.87053674e-01f, -7.03606680e-02f,
  3.30570549e-01f, 6.89234793e-01f, -2.93814033e-01f, 4.91227329e-01f, 5.35412073e-01f, -1.73661020e-02f, -2.42387772e-01f, 3.48979473e-01f, -8.27944577e-01f, 5.51475883e-02f,
  -1.98561922e-01f, -3.87157500e-01f, 4.42588478e-02f, -5.47357440e-01f, -2.39784196e-01f, 1.04991525e-01f, -1.96320459e-01f, 7.91568905e-02f, 6.84355721e-02f, 4.98827636e-01f,
  -1.30210131e-01f, -6.58647493e-02f, 5.84470391e-01f, 1.00166447e-01f, 6.48925960e-01f, 3.29292119e-01f, 9.65702720e-03f, -1.60299808e-01f, 1.44152254e-01f, -1.81175515e-01f,
  -7.26311514e-03f, 3.63946617e-01f, -2.51677543e-01f, -4.67159003e-02f, -5.31589150e-01f, -3.71465981e-01f, -4.80404384e-02f, -2.20988125e-01f, 2.07241163e-01f, -4.64287847e-01f,
  7.68626556e-02f, 2.35518277e-01f, -3.31713200e-01f, 4.38053757e-01f, -5.12109436e-02f, 2.03737855e-01f, 3.90512496e-02f, 6.74118340e-01f, 5.41877806e-01f, 4.52982545e-01f,
  3.61408740e-02f, 3.31094354e-01f, -1.24549828e-02f, -2.03689426e-01f, -1.28722325e-01f, -7.99217150e-02f, 8.67036730e-02f, 1.00174500e-02f, -1.60108954e-01f, -4.39515054e-01f,
  -5.51678300e-01f, -2.63642013e-01f, 4.91851747e-01f, 1.47044808e-01f, -7.50014558e-02f, -5.14681600e-02f, -1.59205317e-01f, -1.91523120e-01f, -2.20754266e-01f, -8.22181582e-01f,
  3.62547278e-01f, -4.28240597e-01f, -3.29767346e-01f, 3.59400302e-01f, -1.16468340e-01f, 3.66120726e-01f, 1.58573136e-01f, 2.72377580e-01f, 7.53875822e-03f, 1.24419378e-02f,
  1.62900656e-01f, 3.09581399e-01f, 2.40471195e-02f, 2.47025311e-01f, 6.34899735e-02f, -5.12067914e-01f, 3.35347921e-01f, 3.60329039e-02f, -3.35951656e-01f, 4.18080054e-02f,
  5.17411411e-01f, -6.87996298e-02f, 3.60768855e-01f, -5.96067727e-01f, 2.73938894e-01f, -2.01881072e-03f, 3.98859948e-01f, -8.18780839e-01f, -9.36194265e-04f, 5.33113480e-01f,
  -2.42444277e-01f, 8.37158635e-02f, -4.24111724e-01f, 3.22084874e-01f, 5.25851846e-02f, 4.90969658e-01f, 1.78930193e-01f, 5.50293505e-01f, -3.26483250e-01f, 5.56061745e-01f,
  9.94441956e-02f, -8.03062692e-02f, -5.37244499e-01f, -3.66511494e-01f, 6.91869557e-01f, 2.19187867e-02f, -5.41972578e-01f, 4.21998262e-01f, 3.73292387e-01f, -8.25877935e-02f,
  -8.88060778e-02f, 2.17378870e-01f, 3.98678035e-01f, 6.89174160e-02f, 4.41501021e-01f, -4.50368464e-01f, -2.24324882e-01f, -1.11727156e-01f, -3.09273452e-01f, -3.74486297e-01f,
  1.72300726e-01f, -1.22542731e-01f, 3.00324410e-01f, 5.61126709e-01f, -1.91281185e-01f, -7.15288743e-02f, 7.64562339e-02f, 5.20023048e-01f, -1.35785058e-01f, 3.82811844e-01f,
  -4.14636582e-01f, 5.66058338e-01f, -3.53318006e-01f, 3.36141795e-01f, -4.09731492e-02f, 7.31437624e-01f, -2.53986716e-01f, -1.21716782e-01f, -5.06044328e-01f, 7.14087129e-01f,
  -4.10050511e-01f, -3.91037941e-01f, -1.89972501e-02f, -5.45947075e-01f, -4.80662324e-02f, -4.72953707e-01f, -1.39291510e-01f, -6.20518252e-02f, -6.06229782e-01f, -2.00657010e-01f,
  -1.22898020e-01f, -4.16253716e-01f, 3.75748090e-02f, -8.55719090e-01f, -2.55151451e-01f, 2.45289773e-01f, -1.73003852e-01f, -1.16728775e-01f, 1.64935842e-01f, 9.06141698e-02f,
  5.07162988e-01f, -1.54371649e-01f, 3.28119129e-01f, -3.40546042e-01f, 4.02291775e-01f, 4.94880170e-01f, 4.32084113e-01f, 6.03256762e-01f, -5.35206974e-01f, -2.83809930e-01f,
  -8.71936381e-02f, -2.21629646e-02f, 8.94522443e-02f, 2.40155607e-01f, -1.20482258e-01f, -1.26727782e-02f, 6.85486048e-02f, 7.48215392e-02f, -3.68954241e-02f, 4.26492065e-01f,
  3.05049896e-01f, 2.55299807e-01f, 4.02591288e-01f, 3.01086187e-01f, -2.32376054e-01f, 9.16557461e-02f, -3.44195813e-01f, -4.13133055e-01f, 5.10331169e-02f, 1.12440456e-02f,
  -3.98357719e-01f, -4.13192958e-01f, -2.86859274e-01f, 1.01946913e-01f, 1.14623964e-01f, -3.10553044e-01f, 1.98963180e-01f, 1.57554746e-01f, 2.74298728e-01f, 9.48568657e-02f,
  5.34061790e-01f, 3.38037699e-01f, -8.05423483e-02f, -3.65071625e-01f, 3.46936077e-01f, 2.52917826e-01f, -4.63127643e-02f, -5.47138862e-02f, 7.10722283e-02f, 3.11492771e-01f,
  -2.87856460e-02f, -5.65063246e-02f, -2.11740918e-02f, -6.54707626e-02f, -1.34834707e-01f, -2.50587482e-02f, -4.49120462e-01f, 2.89809972e-01f, -8.13972950e-02f, -2.84543604e-01f,
  1.05742246e-01f, 1.94311336e-01f, -8.60361010e-02f, -4.13769931e-01f, -7.59857371e-02f, 3.29890341e-01f, -3.03825960e-02f, -1.02821318e-02f, 2.46923089e-01f, 3.33126992e-01f,
  -5.08304648e-02f, -4.26098377e-01f, 4.85086948e-01f, 3.86780262e-01f, -1.20943747e-01f, -1.12451263e-01f, 2.97926009e-01f, 3.48717183e-01f, -1.90661669e-01f, 1.48084208e-01f,
  1.58126235e-01f, -1.45616829e-01f, -5.25525883e-02f, 6.16586506e-02f, 1.19899221e-01f, 1.91340595e-01f, 9.94042680e-02f, 3.88516277e-01f, 1.25651315e-01f, -1.30396456e-01f,
  2.97940403e-01f, -5.53400934e-01f, 5.68388999e-01f, -3.18752408e-01f, -1.40428811e-01f, -4.98475492e-01f, 4.98497158e-01f, -9.17577222e-02f, 2.92660564e-01f, -1.48306832e-01f,
  1.23000242e-01f, -2.14555949e-01f, 1.15147822e-01f, -1.26408964e-01f, -1.39853671e-01f, 2.36841291e-02f, 5.35911381e-01f, -2.39423692e-01f, 3.75079244e-01f, 2.42747232e-01f,
  -2.22532928e-01f, 5.23977160e-01f, 2.41785482e-01f, -2.65722364e-01f, -5.01815081e-01f, -5.44494912e-02f, 7.13439882e-02f, 5.89521863e-02f, 1.30516350e-01f, 5.39473772e-01f,
  3.76177192e-01f, 2.39769220e-01f, 2.97207266e-01f, -6.93150163e-01f, -6.56094179e-02f, -2.31636733e-01f, 4.36550304e-02f, -2.49443263e-01f, 7.92009532e-01f, 3.90344352e-01f,
  5.13746858e-01f, -2.30656229e-02f, 1.65075228e-01f, -3.14119756e-01f, 2.04622939e-01f, 8.42180029e-02f, -2.42973775e-01f, -7.36504421e-02f, 7.01482654e-01f, 1.10701574e-02f,
  3.22032392e-01f, 2.67392725e-01f, -1.68402597e-01f, -9.54204947e-02f, 3.32144439e-01f, 5.11320271e-02f, 2.15688333e-01f, 4.73253697e-01f, -2.78665181e-02f, 1.67943865e-01f,
  1.83368653e-01f, 2.29198754e-01f, -3.57992172e-01f, -2.81348258e-01f, -4.63262461e-02f, 4.54941452e-01f, -3.86796713e-01f, 3.42986137e-01f, -4.41488892e-01f, -4.44503278e-02f,
  -3.27067375e-01f, -5.13332248e-01f, -3.00634742e-01f, -4.56911087e-01f, 3.06885093e-01f, 4.82854187e-01f, 3.68859798e-01f, 1.58268929e-01f, 3.19309741e-01f, 3.26311976e-01f,
  -2.04778552e-01f, 4.78043258e-02f, 2.04445764e-01f, 1.58682838e-01f, 3.33677322e-01f, 3.52868885e-01f, 6.42555133e-02f, -4.30822931e-02f, -1.87770769e-01f, -4.05888855e-01f,
  1.19148664e-01f, 2.08383799e-01f, 9.18818917e-03f, 6.25810206e-01f, -1.16565093e-01f, -1.88306332e-01f, 7.42706358e-01f, -3.92643690e-01f, -1.96670920e-01f, -5.75366259e-01f,
  -4.15668964e-01f, 5.55717409e-01f, -2.99709111e-01f, -1.74936563e-01f, 4.98962365e-02f, 1.62334368e-01f, -1.21199630e-01f, 3.81994814e-01f, 1.76774219e-01f, 6.97780430e-01f,
  -3.37242335e-01f, 3.36476237e-01f, 1.72802150e-01f, -3.93879674e-02f, 1.18221521e-01f, -5.70827946e-02f, -1.30633429e-01f, 7.96582922e-03f, -1.46699160e-01f, 3.07911456e-01f,
  -7.61348456e-02f, 1.45590484e-01f, -1.80899754e-01f, -3.66687775e-02f, 2.46791899e-01f, 7.61435851e-02f, -4.72809374e-01f, 1.35779560e-01f, 5.78736544e-01f, 5.84605455e-01f,
  -1.90305158e-01f, 2.90717334e-01f, 1.34539232e-01f, -2.83729881e-01f, 5.62340245e-02f, 2.93912292e-01f, 1.38961270e-01f, -1.97306741e-02f, 3.50788742e-01f, -3.49590123e-01f,
  2.51436736e-02f, -6.41619563e-01f, 4.21617687e-01f, 2.06600744e-02f, 1.64177701e-01f, -1.24512628e-01f, 1.35531709e-01f, 1.50764152e-01f
};

// L3_fan_Bp_bar (Shape: 1 x 14)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 14;
const float L3_fan_Bp_bar_data[] = {
  -1.36400536e-01f, 2.15249911e-01f, 1.63892418e-01f, -9.67980549e-02f, 2.45714247e-01f, 2.76976079e-01f, -1.92979604e-01f, 2.59550422e-01f, -1.76003557e-02f, 1.14462867e-01f,
  5.16320067e-03f, 2.25861937e-01f, 2.08691403e-01f, 1.27259851e-01f
};

// L4_linear_W (Shape: 12 x 32)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 32;
const float L4_linear_W_data[] = {
  -1.42320022e-01f, 1.78384379e-01f, 1.08245648e-01f, -1.78619623e-01f, -4.20755476e-01f, -2.62767255e-01f, 8.42327997e-02f, -3.48672062e-01f, -6.11915350e-01f, 2.12248252e-03f,
  3.83370310e-01f, -3.84354353e-01f, 3.13721627e-01f, -2.61625051e-01f, -1.19116873e-01f, 5.56831621e-02f, -4.41102199e-02f, -2.56036222e-01f, -4.19670433e-01f, -4.13941562e-01f,
  -6.26631528e-02f, 1.38158858e-01f, -6.86195970e-01f, -4.52421039e-01f, -3.58860418e-02f, 2.31769234e-01f, 2.78079778e-01f, 1.90240800e-01f, 5.77474721e-02f, 1.79078788e-01f,
  -1.15684196e-01f, 2.58213311e-01f, 2.46704310e-01f, 2.76520133e-01f, 2.47466788e-01f, -2.04274595e-01f, 3.50937307e-01f, 1.91751510e-01f, -1.80695951e-01f, 4.52297442e-02f,
  2.50054479e-01f, 3.49648856e-02f, 4.31410551e-01f, 3.10576111e-01f, -1.63854033e-01f, -1.29981324e-01f, -3.60100031e-01f, -1.39800832e-02f, 4.62967426e-01f, 5.60179278e-02f,
  -3.82115036e-01f, 4.77366894e-01f, -4.06927377e-01f, -5.41720390e-01f, 2.41587937e-01f, -2.79036134e-01f, -3.94641161e-01f, 1.73977956e-01f, 2.59656757e-01f, -4.02100295e-01f,
  -5.37223756e-01f, 3.63731772e-01f, -2.26004392e-01f, 3.62006545e-01f, -1.03231177e-01f, 1.07026719e-01f, -4.90604006e-02f, 3.24652374e-01f, -2.99302619e-02f, 2.11540964e-02f,
  1.32360816e-01f, -3.76431733e-01f, -2.24809334e-01f, 3.94340828e-02f, 4.09073740e-01f, 1.13129124e-01f, 3.29335392e-01f, -2.03358293e-01f, -3.96595389e-01f, -4.41361517e-01f,
  3.48869562e-01f, -2.90714260e-02f, -5.68955421e-01f, 3.15574288e-01f, 1.79687496e-02f, 1.02156922e-02f, -7.35237062e-01f, -1.63828999e-01f, 3.97685409e-01f, 2.51705289e-01f,
  -2.79619366e-01f, -7.87712157e-01f, -7.57690847e-01f, 6.21266365e-01f, 1.68600887e-01f, 7.02668855e-04f, -4.02116507e-01f, -1.45185795e-02f, -1.90949023e-01f, 1.43225063e-02f,
  5.15870973e-02f, 1.50076449e-01f, -4.96978760e-01f, -1.82221174e-01f, -2.39553154e-02f, -2.19076127e-01f, -5.19451201e-01f, 5.60339019e-02f, 3.22522849e-01f, 3.44096750e-01f,
  1.82499528e-01f, -7.96799436e-02f, -1.29840583e-01f, -1.14633115e-02f, -1.22318119e-01f, -4.17676121e-01f, -4.91914093e-01f, -4.55285430e-01f, -2.63636291e-01f, -4.80898827e-01f,
  2.99325615e-01f, -1.52891383e-01f, -2.70175431e-02f, 2.08752409e-01f, 3.21088284e-01f, -5.70579886e-01f, -2.86907732e-01f, 2.72795051e-01f, 2.72334784e-01f, 3.01235467e-01f,
  -2.99993485e-01f, 5.27750887e-02f, 3.29809785e-01f, 3.49376172e-01f, 9.05927867e-02f, 7.21372291e-02f, 1.72736794e-01f, -6.22669220e-01f, -5.31864345e-01f, -1.20506369e-01f,
  -2.53124833e-01f, 5.37759125e-01f, -2.43801370e-01f, 2.65304327e-01f, -3.38691562e-01f, -3.32856178e-02f, -4.06389475e-01f, -5.44867337e-01f, 1.57492191e-01f, 2.94857949e-01f,
  5.45447245e-02f, -3.13347340e-01f, 3.05768579e-01f, 1.55230492e-01f, -3.20989162e-01f, -7.43769854e-02f, 1.36327446e-01f, -3.44810933e-02f, 2.44594425e-01f, -6.19453430e-01f,
  3.98060232e-02f, 7.85235241e-02f, -2.76514143e-02f, 3.20289105e-01f, 3.92622128e-03f, 6.01517782e-02f, 3.74296010e-01f, 5.71697772e-01f, -1.80589445e-02f, 2.07409084e-01f,
  -2.88118571e-01f, 3.33658457e-01f, 8.86181835e-03f, -9.76155549e-02f, -2.47329623e-01f, -1.58122644e-01f, -2.48603195e-01f, -4.28922176e-01f, 3.31218034e-01f, 2.34913483e-01f,
  2.51087874e-01f, 4.35220838e-01f, -1.64471686e-01f, -3.29478174e-01f, -3.62022251e-01f, 2.26003334e-01f, 1.70544729e-01f, -1.73822269e-01f, -1.42639011e-01f, -8.81572738e-02f,
  3.42717439e-01f, -4.40520108e-01f, -3.17168981e-01f, -3.98013175e-01f, 3.52444291e-01f, 3.92500192e-01f, 3.54780853e-01f, 4.59506720e-01f, -5.03162205e-01f, 5.30274451e-01f,
  -5.31821907e-01f, 5.62410593e-01f, 4.89505917e-01f, -4.10128981e-01f, 3.51556003e-01f, -4.68220979e-01f, 3.71443003e-01f, 3.64096999e-01f, 5.72620779e-02f, -4.83431295e-02f,
  -1.36496440e-01f, -2.04820279e-02f, 4.06278856e-03f, -4.35747236e-01f, 2.12977931e-01f, 4.68745261e-01f, -7.92403340e-01f, -8.83202702e-02f, -6.86603427e-01f, 1.01995945e-01f,
  -2.61479557e-01f, -3.74609143e-01f, 3.08549739e-02f, -5.03542781e-01f, -1.23674348e-02f, -6.52671605e-02f, 1.91612408e-01f, 1.19855195e-01f, 1.27866551e-01f, -4.49330598e-01f,
  1.90085739e-01f, -2.91309841e-02f, 2.01290384e-01f, -4.84000146e-01f, -3.09007674e-01f, 2.30059385e-01f, 1.73118070e-01f, 3.92684698e-01f, -1.19573966e-01f, 8.83178487e-02f,
  -2.46502742e-01f, 8.93950090e-02f, -2.44765028e-01f, -4.54757214e-01f, -6.51775897e-01f, -3.12660515e-01f, 5.61873317e-01f, 2.44278446e-01f, 1.42976463e-01f, -3.05009127e-01f,
  -2.31193691e-01f, -5.74562430e-01f, 4.88089286e-02f, -5.09686768e-01f, -7.93237269e-01f, -5.26919700e-02f, -2.76482962e-02f, -2.16384739e-01f, -3.35688382e-01f, 7.04335123e-02f,
  -2.75989115e-01f, 7.19281435e-02f, -2.53365248e-01f, 7.39376014e-03f, -7.44196028e-02f, 3.08239549e-01f, 1.63693145e-01f, -2.35152572e-01f, -8.03038254e-02f, -5.59534073e-01f,
  -1.68900222e-01f, -4.04905677e-01f, -7.47232363e-02f, 5.48683882e-01f, 3.02058756e-01f, -3.99297535e-01f, 1.38296500e-01f, 4.29357916e-01f, 3.09132248e-01f, -3.20202678e-01f,
  2.01251373e-01f, 4.88111600e-02f, 7.05376565e-02f, -2.29050353e-01f, -4.51057792e-01f, -7.79357433e-01f, -6.89131916e-01f, 3.58158171e-01f, -1.45817054e-02f, -2.97855526e-01f,
  2.37728745e-01f, -4.64583039e-01f, -3.16181779e-01f, -1.18722834e-01f, 9.39268842e-02f, 1.09986901e-01f, 2.07976207e-01f, 1.76183581e-01f, 4.70075645e-02f, -6.07200824e-02f,
  -4.55941148e-02f, -3.18855755e-02f, 8.23733285e-02f, 2.15362221e-01f, 5.63451588e-01f, 4.96661337e-03f, -1.02507576e-01f, -6.85673237e-01f, 3.63063902e-01f, -4.74648923e-01f,
  -6.62760615e-01f, 3.52317750e-01f, 1.22864321e-01f, -5.97065330e-01f, -6.05032265e-01f, -8.77597213e-01f, -4.20968682e-01f, 1.08787723e-01f, 3.00996035e-01f, 2.07894817e-01f,
  3.50015134e-01f, -2.78645992e-01f, 7.75745586e-02f, -4.43054914e-01f, -2.21122816e-01f, -2.81586319e-01f, 1.37930155e-01f, 1.59811944e-01f, 5.81269085e-01f, 1.21562090e-02f,
  -7.46840954e-01f, -4.54668790e-01f, -3.41442823e-01f, 6.12655818e-01f, -3.23908001e-01f, -4.05853242e-01f, -4.90373045e-01f, 6.88498318e-01f, -4.78820503e-01f, 3.93901348e-01f,
  -9.53887224e-01f, 2.32410923e-01f, -8.42237890e-01f, 1.86714865e-02f, -6.63169324e-01f, 1.82883769e-01f, 9.25381482e-03f, 2.97696680e-01f, 3.40250045e-01f, -3.71568799e-01f,
  2.07945451e-01f, 2.58852363e-01f, 2.50771701e-01f, 2.26790175e-01f, -8.43883634e-01f, -3.57120365e-01f, -1.16694868e-01f, -3.62774730e-01f, 1.81183368e-01f, -4.14069653e-01f,
  8.66687149e-02f, -2.78385401e-01f, -1.82843745e-01f, 4.26552624e-01f, 2.52153546e-01f, -1.77827120e-01f, 4.86985564e-01f, -5.50232589e-01f, -1.51261333e-02f, -7.02257976e-02f,
  4.86175150e-01f, -2.29529560e-01f, 2.52236187e-01f, -5.62526509e-02f, 3.79002616e-02f, 2.40796223e-01f, -3.88343275e-01f, -6.97753668e-01f, -2.23960102e-01f, -1.58809684e-02f,
  -9.95893553e-02f, -3.13487172e-01f, -3.50311607e-01f, -5.83006740e-01f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  1.37172658e-02f, 3.30467597e-02f, -1.67715445e-01f, -2.21786901e-01f, 8.65372941e-02f, -7.67619982e-02f, -4.16310132e-02f, -1.61208972e-01f, -2.42318600e-01f, -3.03690396e-02f,
  -8.72909799e-02f, -2.44441062e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 9, 14
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 9, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        32, 9, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        32, 9, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        32, 12
    );
    }
    