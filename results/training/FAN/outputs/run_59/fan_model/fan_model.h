/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 12 x 120)
const int L0_fan_Wp_rows = 12;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -4.13052768e-01f, -3.50223243e-01f, -4.12432045e-01f, -2.46810779e-01f, -1.13215260e-01f, 4.00265485e-01f, 4.94055375e-02f, -1.98144689e-01f, -3.35850924e-01f, 2.41410837e-01f,
  -2.43505854e-02f, 7.79314712e-02f, -1.96740329e-01f, -9.67172533e-02f, -1.23815283e-01f, -1.49454966e-01f, 5.90875559e-02f, 1.33251831e-01f, -1.49175093e-01f, -9.30864587e-02f,
  -1.69025376e-01f, 9.16562602e-02f, -2.76674837e-01f, 1.41208321e-01f, -1.19346716e-01f, -6.05598986e-02f, 8.84690881e-02f, -1.23094171e-02f, 1.57449096e-01f, 1.15777388e-01f,
  -1.04729719e-01f, -2.26182476e-01f, -1.53490409e-01f, 6.64514303e-02f, -5.05819321e-02f, 1.70282617e-01f, 1.50112748e-01f, 1.08258636e-03f, -8.29132497e-02f, 5.13417274e-02f,
  3.37875374e-02f, 2.24063676e-02f, 5.68776801e-02f, -1.06596397e-02f, 5.78153394e-02f, -2.90735830e-02f, -5.05392812e-02f, -1.11541845e-01f, -6.98397905e-02f, -1.28743574e-01f,
  -1.30532578e-01f, -8.23944435e-02f, 3.21349613e-02f, -2.96237704e-04f, -5.04616722e-02f, 2.72021517e-02f, 4.12346795e-02f, 8.77435692e-03f, 1.20714195e-02f, 5.34938760e-02f,
  1.39489233e-01f, 6.64191842e-02f, -3.69337387e-02f, -6.21568747e-02f, -7.22873285e-02f, -4.04627807e-02f, 3.22110131e-02f, 4.09367383e-02f, -2.72752512e-02f, 2.18980890e-02f,
  -3.01536079e-02f, -6.60357550e-02f, 4.55853678e-02f, 1.09884121e-01f, -2.15713517e-03f, -3.15210491e-04f, 5.03299534e-02f, 4.89951707e-02f, -6.72288761e-02f, -3.96599956e-02f,
  5.29606715e-02f, 7.02429861e-02f, -7.92351514e-02f, -3.31329629e-02f, 4.53825109e-02f, -6.47601187e-02f, 5.40067442e-03f, -8.20574015e-02f, -6.79070577e-02f, 2.57444642e-02f,
  2.02266783e-01f, 3.67607653e-01f, 5.02892444e-03f, -2.65270956e-02f, 3.95228192e-02f, -4.76111360e-02f, -7.00331032e-02f, 6.91338480e-02f, 1.22098118e-01f, 7.03457147e-02f,
  1.05507828e-01f, 4.60891984e-03f, 7.72970617e-02f, 3.04741487e-02f, -3.09578385e-02f, -5.87596558e-02f, 1.03745244e-01f, 8.36910754e-02f, 1.16287619e-01f, 2.46016197e-02f,
  1.40093416e-01f, 7.81124681e-02f, 8.41151699e-02f, 4.17838898e-03f, 1.22128949e-01f, 1.42924543e-02f, 6.37236685e-02f, 2.98171714e-02f, 6.73301369e-02f, -6.81727007e-02f,
  -5.11870384e-01f, 5.23731828e-01f, -1.60098597e-01f, -1.81730434e-01f, 2.63530225e-01f, 1.05795898e-02f, -3.59265298e-01f, 2.50341862e-01f, -2.80756027e-01f, 4.11906600e-01f,
  1.75173774e-01f, -1.31135523e-01f, -3.41958702e-02f, 2.65097320e-01f, -3.15391928e-01f, -2.59901822e-01f, 1.32480234e-01f, -2.93097887e-02f, -2.31788471e-01f, 2.90856361e-01f,
  -9.16673094e-02f, 1.98919833e-01f, 1.22857429e-01f, 2.48214245e-01f, 9.37101692e-02f, -1.07276447e-01f, 1.87980205e-01f, -1.07531480e-01f, 2.59193718e-01f, -2.36473531e-02f,
  -8.48411247e-02f, 7.88198560e-02f, -1.59082077e-02f, -5.93514815e-02f, 1.09475471e-01f, 2.97495183e-02f, -4.00168821e-02f, -7.27634653e-02f, -2.81117577e-02f, -8.94022174e-03f,
  -1.14889212e-01f, -5.81648871e-02f, -6.27758652e-02f, -2.56620497e-02f, 2.85481829e-02f, -4.10961598e-04f, -4.52700332e-02f, 5.60419783e-02f, 3.05979159e-02f, -2.44666673e-02f,
  4.29202989e-02f, -6.38083648e-03f, -4.66263620e-03f, -3.66018638e-02f, -3.71777415e-02f, -3.74680422e-02f, 1.18938470e-02f, -3.72940861e-02f, 7.02575147e-02f, -2.82607600e-02f,
  -3.71196121e-02f, 1.21922046e-02f, 2.92461216e-02f, 4.71055731e-02f, 5.37030539e-03f, 8.66807327e-02f, -1.07143978e-02f, 3.81692313e-02f, -1.07576974e-01f, 5.48854610e-03f,
  4.48705405e-02f, -2.84729917e-02f, 1.94811425e-03f, 5.18990383e-02f, 3.54680419e-02f, -1.67463738e-02f, -3.41381505e-02f, -1.11868707e-02f, -6.80955574e-02f, 4.65663187e-02f,
  -3.50414589e-02f, 6.18550181e-02f, -7.17284111e-03f, -6.61672419e-03f, 2.99745891e-02f, -3.67312580e-02f, 3.22415940e-02f, 3.73146348e-02f, 4.03160565e-02f, -5.46186082e-02f,
  1.46820530e-01f, 2.10290164e-01f, -7.87596703e-02f, 2.85456330e-03f, -1.83496613e-03f, 1.94168335e-03f, -4.18156721e-02f, 7.26277335e-03f, -2.78384686e-02f, 4.21469770e-02f,
  3.41770239e-02f, 9.68069583e-02f, 7.87330195e-02f, -4.49970365e-03f, -3.07865124e-02f, 6.12758659e-02f, 3.90741378e-02f, -4.23795059e-02f, -2.74711400e-02f, 1.42561179e-02f,
  4.77797315e-02f, -3.65535878e-02f, -1.29388675e-01f, 9.10443440e-02f, 1.00195214e-01f, -2.51845028e-02f, -5.14145754e-03f, -3.36667430e-03f, -5.06591015e-02f, 5.04263490e-02f,
  -3.45891826e-02f, -3.05956960e-01f, -1.58132166e-01f, -1.18377663e-01f, 2.07108483e-01f, 3.45526546e-01f, 7.83205852e-02f, -9.64650363e-02f, -3.27148288e-01f, -7.62047768e-02f,
  2.98389733e-01f, -3.36136371e-01f, 7.70783098e-03f, 3.44183534e-01f, 2.43285030e-01f, -1.00122569e-02f, 2.60162979e-01f, -6.02656510e-03f, -8.52058306e-02f, -4.57172208e-02f,
  8.78690258e-02f, 2.19105676e-01f, 1.75007015e-01f, -1.08020576e-02f, 2.87527740e-01f, -1.56814620e-01f, 1.03861406e-01f, -1.28434941e-01f, 9.19297561e-02f, 8.10025632e-02f,
  3.42406839e-01f, -1.24031253e-01f, -3.95377306e-03f, -2.52035931e-02f, 7.81045705e-02f, 9.42903012e-02f, -1.64696679e-03f, -2.45877309e-03f, -9.65697914e-02f, -3.82658951e-02f,
  -3.88063267e-02f, -5.55998869e-02f, -6.24219561e-03f, -8.75181481e-02f, -1.37086203e-02f, -6.28939085e-03f, -2.56683994e-02f, 9.79124829e-02f, -2.39671189e-02f, 1.13764666e-01f,
  3.09058651e-02f, 4.59462181e-02f, 9.47345421e-02f, -1.42122107e-02f, -2.62877531e-02f, -2.01166291e-02f, 7.34531041e-03f, 1.75947305e-02f, -3.21268700e-02f, -8.85024145e-02f,
  -1.51776550e-02f, 1.04792612e-02f, -9.91509762e-03f, 8.73060226e-02f, -1.73187703e-02f, 2.98593715e-02f, 4.01361994e-02f, 7.30743958e-03f, -5.50522842e-02f, 3.30983917e-03f,
  3.67324520e-03f, 6.61539733e-02f, -3.08698565e-02f, 6.97324611e-03f, 7.69055411e-02f, -3.44919451e-02f, 5.92987984e-03f, -1.71158798e-02f, 7.88305327e-02f, 4.37549874e-02f,
  4.95379372e-03f, -2.77983118e-02f, 3.26873362e-02f, 9.22109932e-02f, 6.24979883e-02f, -1.93422064e-02f, -4.91657779e-02f, 4.19932604e-02f, 4.33997288e-02f, 3.84253338e-02f,
  -1.23557232e-01f, -4.64826345e-01f, -7.55950138e-02f, -3.15098502e-02f, -6.62526488e-02f, 1.37639828e-02f, -5.68858758e-02f, 5.21607399e-02f, -5.72434999e-02f, 1.13422833e-02f,
  3.77299376e-02f, 7.37997517e-02f, -4.35268357e-02f, 1.54440865e-01f, 6.25633402e-03f, -2.72725392e-02f, -2.73372214e-02f, -4.23364975e-02f, -1.22636929e-02f, -1.29183475e-02f,
  -4.25143316e-02f, -5.68214506e-02f, -8.02574009e-02f, 3.11326943e-02f, 5.40462248e-02f, -6.68770960e-03f, -2.22054031e-02f, -2.44230242e-03f, 6.86515942e-02f, -4.99055814e-03f,
  5.70290923e-01f, 1.09090872e-01f, -1.26648163e-02f, -3.07806749e-02f, -2.79498715e-02f, 6.29310384e-02f, 3.06059998e-02f, -2.95602325e-02f, 3.50007713e-01f, -1.51968330e-01f,
  -2.62077153e-01f, 3.64146411e-01f, -2.61770219e-01f, -1.53420240e-01f, -1.93502773e-02f, -6.69323877e-02f, -1.85375199e-01f, -5.67803308e-02f, 2.14252859e-01f, -4.38656509e-02f,
  -5.87395467e-02f, -1.95111424e-01f, -2.88108528e-01f, -2.17979904e-02f, -1.70229554e-01f, 1.16082959e-01f, -3.29419583e-01f, -1.36356866e-02f, -1.35871977e-01f, 9.85221937e-02f,
  -6.55442402e-02f, 1.57397598e-01f, -8.33254457e-02f, -7.73633597e-04f, -1.45864815e-01f, -3.93011458e-02f, -7.62048364e-02f, -4.04630974e-02f, 9.46547240e-02f, 9.95574817e-02f,
  4.56790850e-02f, 7.64964968e-02f, 2.81743333e-02f, 6.19155392e-02f, 1.30406320e-01f, 2.73887627e-02f, 9.11683366e-02f, -1.32582188e-02f, 4.22812179e-02f, -7.69911334e-02f,
  2.36601532e-02f, -5.88306412e-02f, -7.73187503e-02f, 3.36891972e-02f, -2.95800585e-02f, 8.67510736e-02f, 1.68925337e-02f, -9.49592814e-02f, -2.07935683e-02f, 1.17661193e-01f,
  -7.30430111e-02f, 2.01251693e-02f, 2.45284243e-03f, -1.91623680e-02f, 3.02552502e-03f, -1.02393061e-01f, 3.25861499e-02f, -3.28790322e-02f, 1.29375264e-01f, -8.54051486e-02f,
  1.91013585e-03f, 7.87483901e-02f, 5.07330783e-02f, 4.58644750e-03f, 3.83707918e-02f, 9.53753572e-03f, -5.60549013e-02f, 6.10402646e-03f, -1.26585048e-02f, -5.26156370e-03f,
  4.51482721e-02f, 7.98504520e-03f, -1.64306052e-02f, -6.98542781e-03f, 8.59526265e-03f, 1.55390101e-02f, 3.11189014e-02f, -3.04869004e-02f, -5.02792895e-02f, -1.27860457e-01f,
  -1.10757805e-01f, -1.99951679e-01f, 4.68592532e-02f, 6.43665716e-02f, 5.04518822e-02f, -7.73628009e-03f, 2.43098792e-02f, 6.20168485e-02f, -1.23824790e-01f, -2.13012695e-02f,
  -7.13993981e-02f, -1.17154326e-02f, -7.29113147e-02f, 3.67132365e-03f, -3.93538848e-02f, -9.58943926e-03f, -4.27521579e-02f, 3.11154686e-02f, -1.48220822e-01f, -5.72470054e-02f,
  -9.17727500e-02f, 4.17891778e-02f, 6.76203426e-03f, -3.56020816e-02f, 1.04451785e-02f, -1.22798368e-01f, 1.84194501e-02f, 4.25026529e-02f, -6.02205768e-02f, -1.01966903e-01f,
  -1.66630879e-01f, -4.50120836e-01f, -4.83630002e-01f, -1.68376938e-01f, 3.90474796e-01f, -1.77315231e-02f, 1.24275759e-01f, -4.58022989e-02f, -3.55603755e-01f, 2.18413807e-02f,
  3.76400501e-01f, -2.16745749e-01f, 6.39440045e-02f, 6.64599165e-02f, 4.67340574e-02f, -2.28604734e-01f, -7.73822069e-02f, 1.74743461e-03f, -8.42730179e-02f, -8.55513290e-02f,
  -1.00463413e-01f, 3.13833505e-01f, -1.10988930e-01f, 5.45338392e-02f, 1.03927135e-01f, -2.04113588e-01f, 2.97255963e-01f, 5.08122370e-02f, 4.43533324e-02f, 9.63236839e-02f,
  8.62222463e-02f, 9.55482386e-03f, -3.95211093e-02f, -1.06133074e-01f, -2.89894007e-02f, 1.03652023e-01f, 7.82890841e-02f, 2.02007309e-01f, -8.72992054e-02f, -6.63233399e-02f,
  3.33795249e-02f, 4.03955206e-02f, -4.40001152e-02f, -6.39779773e-03f, 3.18322629e-02f, -7.31375488e-03f, -6.46702126e-02f, -3.74552757e-02f, -6.37180358e-02f, -5.47403768e-02f,
  -8.80972669e-03f, -1.87962651e-02f, 1.43080307e-02f, -4.97992598e-02f, -4.22336496e-02f, -4.17617895e-02f, -6.20309338e-02f, 1.02001287e-01f, 3.37330215e-02f, -7.55609870e-02f,
  4.39765900e-02f, -1.24102142e-02f, 1.05835113e-03f, -2.29743067e-02f, 1.59956347e-02f, 9.34844464e-02f, 3.23475227e-02f, 6.65845200e-02f, -1.76817011e-02f, 1.43962890e-01f,
  2.87545342e-02f, 3.53856869e-02f, 7.35518858e-02f, -1.56023065e-02f, 2.03024317e-02f, -6.53326511e-02f, 6.60493150e-02f, 4.20968160e-02f, -6.47349283e-02f, 4.08906005e-02f,
  6.98087811e-02f, -4.01540659e-03f, 1.30506628e-03f, 6.51375428e-02f, 5.30363731e-02f, -5.25412597e-02f, 2.10670270e-02f, -2.19476130e-02f, -3.78656946e-02f, 7.04244375e-02f,
  -1.41374201e-01f, -1.89993069e-01f, -7.41945952e-02f, -2.57033259e-02f, 4.35241349e-02f, 9.81660560e-02f, -5.35570420e-02f, -5.42147420e-02f, -4.01382521e-02f, 1.70218423e-02f,
  2.57761087e-02f, 2.89822780e-02f, 1.09565454e-02f, 8.80980641e-02f, -7.46233463e-02f, 1.48239210e-02f, 2.95692086e-02f, -2.44926717e-02f, 4.63145003e-02f, 2.83421930e-02f,
  1.23801209e-01f, 5.44404760e-02f, 2.89711766e-02f, 2.25196183e-02f, 5.49331382e-02f, 9.19198990e-03f, -3.96285355e-02f, -1.30055115e-01f, 8.37725028e-02f, -1.75503939e-02f,
  -7.37779975e-01f, 2.34323516e-01f, -1.57972462e-02f, -2.50612557e-01f, -3.50219756e-01f, -2.55761296e-01f, -2.15855986e-01f, -1.18756130e-01f, 5.18237241e-02f, 6.11211360e-02f,
  3.00596207e-02f, -3.94136369e-01f, 3.50516319e-01f, -2.41427913e-01f, -2.38482997e-01f, 3.29981565e-01f, 1.03099914e-02f, -2.16014490e-01f, 1.51010334e-01f, -3.48076165e-01f,
  -5.50591499e-02f, -2.65092254e-01f, -3.07059679e-02f, -3.53677161e-02f, -9.94965285e-02f, 3.93645130e-02f, 8.46094489e-02f, 1.74598768e-01f, -2.24098995e-01f, 4.23523188e-02f,
  -8.11064988e-02f, 5.97375110e-02f, -8.17354620e-02f, 7.44270310e-02f, -2.56227069e-02f, -8.13915506e-02f, -1.07989170e-01f, -2.18818858e-02f, -3.94585449e-03f, 3.78635041e-02f,
  3.08739580e-02f, -8.66732076e-02f, -3.47696431e-02f, 6.70681000e-02f, -1.55393660e-01f, -7.84910992e-02f, -5.85532859e-02f, 3.83170284e-02f, -4.94492017e-02f, -1.60178721e-01f,
  2.67871823e-02f, 1.51673509e-02f, -1.36604076e-02f, 3.54886539e-02f, 2.42354833e-02f, 1.89623684e-02f, 1.85354019e-03f, -6.44668788e-02f, 1.10739348e-02f, -1.22760693e-02f,
  -3.73166576e-02f, 1.13159284e-01f, 8.86092242e-03f, 6.51372969e-02f, -1.71753336e-02f, -2.61829924e-02f, 2.32760310e-02f, -4.11520787e-02f, 8.57893154e-02f, -1.05401680e-01f,
  4.28614300e-03f, -1.07487515e-01f, 2.84800027e-02f, -1.14552595e-01f, -9.70366150e-02f, -1.39660910e-01f, -5.49904406e-02f, -5.98897040e-02f, 6.42026588e-02f, -3.54719758e-02f,
  3.22516784e-02f, 1.72599722e-02f, 2.58334819e-02f, 5.08635975e-02f, 2.61728168e-02f, -4.68231365e-02f, 3.49461772e-02f, -1.30176600e-02f, -3.58079327e-03f, -1.78386997e-02f,
  8.83572176e-02f, 2.78608352e-01f, 1.35246918e-01f, -7.74977058e-02f, 1.05500817e-01f, 2.09986549e-02f, 1.06882222e-01f, -8.37234929e-02f, 4.69627976e-02f, 6.01032823e-02f,
  -6.35005012e-02f, -7.08286613e-02f, 6.33833036e-02f, -1.04459018e-01f, 5.88918850e-02f, 8.49295687e-03f, 4.61930223e-02f, 6.56346232e-02f, -9.52503923e-03f, 3.49541530e-02f,
  -1.12804212e-01f, 7.21882842e-03f, 1.03573268e-02f, -5.46741448e-02f, -5.44461496e-02f, 9.76894982e-04f, -3.44001725e-02f, 1.99662037e-02f, 5.52951694e-02f, 7.48372823e-02f,
  -2.30818987e-01f, -4.40066636e-01f, 2.00539842e-01f, -7.68813044e-02f, -6.11980297e-02f, -1.51938543e-01f, -5.22739887e-02f, -2.45060071e-01f, -2.14706004e-01f, -3.33287567e-01f,
  -9.33208317e-02f, 5.57279773e-02f, -9.73790735e-02f, -4.41867143e-01f, 5.63692987e-01f, -1.15054652e-01f, -1.47495002e-01f, -1.06031597e-01f, -1.09507434e-01f, 1.95616316e-02f,
  -2.24355031e-02f, -1.79226786e-01f, 6.36446550e-02f, -1.63483053e-01f, -2.67162204e-01f, 1.72650188e-01f, 4.72070366e-01f, 1.08622834e-01f, 2.95861989e-01f, -2.38635633e-02f,
  -1.35118067e-01f, -3.45352560e-01f, -5.46415076e-02f, -6.10152334e-02f, 1.59906838e-02f, 1.31309303e-02f, 1.30446538e-01f, 7.41498247e-02f, 6.05241358e-02f, -2.01928280e-02f,
  -1.04505323e-01f, 9.11380947e-02f, -8.14086199e-02f, -3.66492867e-02f, -1.00017525e-01f, 4.79143821e-02f, 1.58705516e-03f, -1.00475900e-01f, 5.83727797e-03f, -7.56788850e-02f,
  -7.42795095e-02f, -2.82550100e-02f, -3.18783857e-02f, 1.86821952e-01f, 1.41834065e-01f, -2.81554423e-02f, 1.72310516e-01f, 1.15733884e-01f, 1.21726161e-02f, -8.98291264e-03f,
  -7.15395957e-02f, 6.30760342e-02f, -1.44738592e-02f, -1.57461122e-01f, -1.12170773e-02f, -3.27237695e-02f, -2.79853828e-02f, -1.09038144e-01f, 4.96343561e-02f, -4.31814045e-02f,
  1.62221659e-02f, 3.42379622e-02f, -1.11950286e-01f, 4.15219786e-03f, 4.71215062e-02f, -1.23327017e-01f, 8.93663466e-02f, -3.95351499e-02f, 1.27381962e-02f, -1.48462951e-01f,
  -5.47193438e-02f, 2.25469638e-02f, 3.98012325e-02f, 3.08850016e-02f, -9.18007493e-02f, 1.26132384e-01f, -8.73270258e-02f, 3.69495787e-02f, -4.14418913e-02f, 2.76046041e-02f,
  1.70370847e-01f, 3.21374804e-01f, -2.53765658e-02f, 3.18545923e-02f, -4.06627078e-03f, -1.32028893e-01f, -1.02727354e-01f, 2.43584346e-02f, 1.93491593e-01f, -1.19445473e-01f,
  4.05593775e-03f, -4.47143093e-02f, 6.73494935e-02f, 2.27077901e-02f, 1.44816801e-01f, 5.70587348e-03f, -3.81162427e-02f, 8.00538957e-02f, 5.94886355e-02f, 1.19183123e-01f,
  -1.64139352e-03f, 7.53464177e-02f, -1.05939582e-01f, -4.49301526e-02f, -2.49002203e-02f, -2.77703675e-03f, 6.05627783e-02f, 2.09117923e-02f, 1.10153062e-02f, 1.30551606e-01f,
  -6.71485305e-01f, 4.41011250e-01f, -1.57860994e-01f, 2.32246205e-01f, -2.40371510e-01f, -7.53911808e-02f, -9.92197394e-02f, 8.87643620e-02f, -2.07324624e-01f, 2.46244967e-01f,
  3.76758724e-02f, -6.57785386e-02f, -2.89551765e-02f, 3.33516896e-01f, -4.47545379e-01f, 1.62783504e-01f, 1.35918437e-02f, 5.90008423e-02f, 2.72302106e-02f, -3.55768502e-02f,
  -2.11417168e-01f, 2.25130007e-01f, -3.54644768e-02f, 6.87319338e-02f, -1.90844443e-02f, 4.47805263e-02f, -9.15296152e-02f, -7.00046420e-02f, 2.91106164e-01f, -1.43494429e-02f,
  -1.55783547e-02f, -3.24831754e-02f, 7.76898265e-02f, -6.86862171e-02f, -1.06984451e-01f, -1.71307594e-01f, -1.35115236e-01f, 1.25322556e-02f, -6.58015758e-02f, 6.19916134e-02f,
  -1.03329912e-01f, -5.15150046e-03f, 3.42430361e-02f, 1.93462837e-02f, -4.26903032e-02f, 4.50803638e-02f, 6.81411326e-02f, 9.82997343e-02f, 2.07399726e-02f, -7.35086873e-02f,
  1.01557843e-01f, 2.91143674e-02f, -9.67315747e-04f, 1.00050196e-01f, -1.39443636e-01f, 5.73429912e-02f, -3.39600164e-03f, -5.47502786e-02f, -8.53179395e-02f, 7.70587428e-03f,
  -7.70956054e-02f, -4.09071669e-02f, -3.02163009e-02f, 6.42914250e-02f, 4.62580398e-02f, -6.29587770e-02f, 5.95752709e-02f, 7.31403986e-03f, -1.27232466e-02f, -5.10376282e-02f,
  -1.12775918e-02f, -7.27158487e-02f, 2.45026536e-02f, -3.30689363e-03f, 9.84978396e-03f, 6.21812604e-03f, -8.20424221e-03f, 3.21117765e-03f, -3.47383656e-02f, 1.02324933e-02f,
  4.30505909e-02f, -1.39865512e-02f, 5.01926690e-02f, -1.29654139e-01f, 4.20479178e-02f, -4.19185944e-02f, -4.05157804e-02f, 1.91868842e-02f, -4.89168316e-02f, -8.80339444e-02f,
  -1.63966909e-01f, -2.41668820e-01f, -3.06146368e-02f, -1.24958931e-02f, 9.90361944e-02f, 4.30465527e-02f, 3.69139425e-02f, -5.82770864e-03f, 9.37122479e-02f, -6.97328076e-02f,
  5.43612195e-03f, -8.11002403e-02f, -9.81962308e-02f, -2.14439780e-02f, 1.13202445e-02f, 1.36269582e-02f, -2.84004267e-02f, -5.04347421e-02f, -1.23209260e-01f, 6.58654943e-02f,
  3.86739057e-03f, 7.38412142e-04f, 1.16600804e-02f, -3.66727933e-02f, -3.68443616e-02f, -6.92909956e-02f, -8.26873481e-02f, 8.03755969e-02f, 2.38164607e-02f, -4.46595773e-02f,
  5.78491509e-01f, -1.61630720e-01f, -2.38886669e-01f, 3.89823735e-01f, 3.04526031e-01f, -5.40258944e-01f, -3.30297858e-01f, 4.98134010e-02f, 4.79010135e-01f, -3.11047941e-01f,
  1.74461380e-01f, -1.97950490e-02f, 1.08528854e-02f, -6.21566884e-02f, 2.67449737e-01f, -1.54735819e-01f, -1.10704295e-01f, -1.52600020e-01f, 1.54456988e-01f, -1.13043608e-02f,
  7.62486607e-02f, 5.85670173e-02f, -1.89470500e-01f, 1.66013852e-01f, -6.92595243e-02f, -1.74558982e-02f, -2.76119425e-03f, -5.20215258e-02f, -6.01612516e-02f, -1.62541252e-02f,
  -1.93402693e-01f, 2.57862329e-01f, 3.98213305e-02f, -4.00181822e-02f, -3.29676643e-02f, -3.59767675e-02f, -1.46859095e-01f, 2.38887034e-02f, 3.91616859e-02f, 5.37598133e-02f,
  -5.06743677e-02f, 3.83425020e-02f, 6.82098493e-02f, 1.08219065e-01f, 3.40006165e-02f, 2.39566322e-02f, -6.62657293e-03f, -5.33388034e-02f, 3.73021327e-02f, -3.60887945e-02f,
  5.61990067e-02f, -6.80418015e-02f, -2.49793683e-03f, 7.98197463e-03f, 2.19450947e-02f, 8.31403658e-02f, -1.40348837e-01f, -2.79483050e-02f, -1.53315607e-02f, 8.40669647e-02f,
  2.62412503e-02f, -1.27950311e-03f, 1.60316657e-02f, 1.91300157e-02f, 3.47436704e-02f, 1.25557324e-03f, 1.31819040e-01f, -1.23224474e-01f, 3.13604921e-02f, -1.73351523e-02f,
  5.24079427e-02f, 3.35316025e-02f, 5.65294884e-02f, 2.40022745e-02f, 1.81346163e-02f, -1.14127602e-02f, 7.79776077e-04f, -1.82007682e-02f, -4.81833741e-02f, 5.33390045e-03f,
  2.13161502e-02f, 1.21379076e-02f, -8.14612657e-02f, -1.06914558e-01f, -2.92980131e-02f, 5.50692566e-02f, -2.45972238e-02f, -2.23798566e-02f, -3.75061743e-02f, -1.54916728e-02f,
  -9.03144181e-02f, -1.83020592e-01f, -6.75572827e-02f, 3.66815180e-02f, -1.91044882e-02f, -1.14909634e-02f, 3.09192892e-02f, -2.31596958e-02f, 5.21935411e-02f, 1.80335040e-03f,
  6.78031892e-02f, -3.21004391e-02f, -8.72722417e-02f, 1.56140747e-02f, 3.07532698e-02f, -4.41690572e-02f, -1.80660989e-02f, -2.21244078e-02f, -5.34317903e-02f, 5.25199100e-02f,
  -5.82352504e-02f, 3.69512811e-02f, -5.63737564e-03f, -6.12050295e-02f, -9.11388099e-02f, -2.13123634e-02f, 4.20837924e-02f, 2.69785859e-02f, 6.14192896e-03f, -3.47321294e-02f,
  2.55131423e-01f, 2.59621680e-01f, 1.80411592e-01f, 3.81635018e-02f, -4.32297736e-02f, -6.50963068e-01f, -1.08792618e-01f, 5.05954698e-02f, 4.86060269e-02f, -4.95197177e-02f,
  -7.29815066e-02f, -6.99298605e-02f, 3.88353169e-02f, -1.98173270e-01f, -6.32819653e-01f, -1.57930851e-01f, -4.30585772e-01f, -9.46225673e-02f, 1.42356381e-01f, 5.41175231e-02f,
  4.72734740e-04f, -1.70879424e-01f, -9.18963999e-02f, 1.05924234e-01f, 1.17536411e-01f, 1.56948909e-01f, -1.35627612e-01f, 1.00426838e-01f, 6.02628775e-02f, -1.47686720e-01f,
  2.51011491e-01f, 4.00947958e-01f, 5.70999570e-02f, -1.37965474e-02f, -3.56021896e-02f, 1.20415241e-01f, -2.59298775e-02f, 7.35933110e-02f, 5.61647154e-02f, -4.49961098e-03f,
  5.25442250e-02f, 1.09985776e-01f, -1.47236725e-02f, -7.80440122e-02f, 6.32528681e-03f, 1.18372187e-01f, 3.35067324e-02f, -8.48198682e-02f, 2.46478036e-01f, -1.54439593e-02f,
  -4.35063429e-02f, 2.15451606e-02f, -7.63195455e-02f, -8.72670859e-02f, -4.97220717e-02f, 1.82864125e-04f, -1.67166311e-02f, -1.39260441e-01f, -1.77586377e-02f, -5.91008514e-02f,
  -1.78991761e-02f, 2.89120781e-03f, -7.96962902e-02f, 3.24237049e-02f, -4.08846028e-02f, 1.35820657e-01f, -7.54171759e-02f, 8.76799319e-03f, -2.86617484e-02f, -1.31115252e-02f,
  -1.00212336e-01f, 5.24239875e-02f, 4.33065370e-02f, 1.22049346e-03f, -9.50270593e-02f, 1.10752717e-01f, -6.74967766e-02f, 5.61139844e-02f, -5.50608188e-02f, 3.50799598e-02f,
  7.41757303e-02f, -8.43168274e-02f, -8.67933333e-02f, 1.56973265e-02f, -3.13239843e-02f, -1.05510391e-02f, -1.60589386e-02f, 1.55632412e-02f, 1.43400757e-02f, -1.68732330e-02f,
  -9.15166214e-02f, -2.45721534e-01f, -5.51476479e-02f, 1.64467413e-02f, 3.44675481e-02f, -1.78349987e-01f, -3.69123258e-02f, -5.40254964e-03f, -2.51781251e-02f, -5.70017658e-03f,
  -1.54135432e-02f, -5.79755800e-03f, -1.16717704e-01f, 7.66080767e-02f, 3.29994969e-02f, -1.44714102e-01f, 3.53143848e-02f, 1.36655122e-02f, -2.05779046e-01f, -1.05074439e-02f,
  -1.50049413e-02f, -5.00041991e-02f, -3.25428359e-02f, 2.83838566e-02f, 5.34722731e-02f, -3.10255680e-02f, -1.03622265e-01f, 9.79810730e-02f, -4.55029123e-02f, 1.30485725e-02f,
  5.92322230e-01f, 8.14407691e-02f, 3.27754579e-02f, 5.93367219e-01f, -1.47034585e-01f, 1.23335697e-01f, 8.34691674e-02f, 1.75020367e-01f, 3.68358612e-01f, 2.84225889e-03f,
  8.00822824e-02f, -5.37038147e-02f, -1.52493417e-01f, 3.42433751e-01f, 1.58386260e-01f, -1.08411629e-02f, 5.32185912e-01f, 1.78503081e-01f, 1.65463816e-02f, 3.06192618e-02f,
  1.69033095e-01f, 1.92224994e-01f, 3.30059290e-01f, -8.14351737e-02f, 1.07677951e-01f, -8.26491266e-02f, 5.35478927e-02f, -1.97767556e-01f, 5.01720980e-02f, -1.17418699e-01f,
  -8.74916762e-02f, 1.11438446e-01f, -5.97621277e-02f, 8.57656747e-02f, 1.19687825e-01f, -1.35034889e-01f, -6.57453015e-02f, -6.41599745e-02f, -8.16607997e-02f, -2.27487180e-02f,
  -8.51179138e-02f, 7.39850337e-03f, 2.19216216e-02f, -2.09185146e-02f, 1.09690152e-01f, 9.15021822e-02f, 4.70574722e-02f, 1.42743054e-03f, 1.23186447e-02f, 3.91941704e-02f,
  -1.46244662e-02f, 8.84720385e-02f, 1.72585115e-01f, 5.74124418e-02f, 4.58817147e-02f, 1.10411756e-02f, 6.79538846e-02f, -1.85247824e-01f, 5.72125055e-02f, 3.58124338e-02f,
  1.71837080e-02f, 5.46177290e-03f, -3.41204181e-02f, -1.70464907e-02f, -3.61122377e-02f, -3.03824078e-02f, -4.06815000e-02f, -1.03245210e-02f, 8.50793254e-03f, -6.13132445e-03f,
  3.61842737e-02f, 7.58628026e-02f, 4.94956076e-02f, 1.90259181e-02f, -6.66336669e-03f, 3.36569361e-02f, -9.27835703e-02f, -2.08220966e-02f, 8.71146172e-02f, 1.60096176e-02f,
  1.80226937e-02f, 5.52373789e-02f, -3.28790396e-02f, 4.59145568e-02f, -1.69326644e-02f, -2.27116253e-02f, 1.50150955e-02f, 5.44726998e-02f, -7.23320767e-02f, -7.98698068e-02f,
  5.15452698e-02f, 2.17472151e-01f, -2.13271286e-02f, 5.31217717e-02f, -5.92856184e-02f, 8.17779824e-02f, 4.68529873e-02f, -4.59558843e-03f, -2.66840272e-02f, 3.78535353e-02f,
  1.04061991e-01f, 2.90148482e-02f, 1.80875454e-02f, -2.51521040e-02f, -8.70270375e-03f, 2.47830562e-02f, -8.27425271e-02f, -4.31963652e-02f, 9.21003427e-03f, 6.82124170e-03f,
  6.60395399e-02f, -1.19258933e-01f, -5.07589728e-02f, 1.73598845e-02f, -8.11129436e-02f, -4.09926362e-02f, -2.43305340e-02f, 4.95994948e-02f, -8.14596936e-02f, 6.28153831e-02f,
  -5.28477848e-01f, 1.88170057e-02f, 2.11302578e-01f, -1.95753530e-01f, -5.47575355e-01f, -1.06158599e-01f, 1.05110027e-01f, -3.65418911e-01f, -1.95767637e-02f, 9.61094871e-02f,
  -2.47932166e-01f, 2.21326008e-01f, 9.59053859e-02f, 1.56840965e-01f, 3.55781376e-01f, 3.74817640e-01f, 1.37125403e-01f, 5.00923861e-03f, 7.39017427e-02f, -2.38854215e-01f,
  -3.71765234e-02f, -2.62240410e-01f, 7.10730106e-02f, -1.67170927e-01f, -4.66983348e-01f, -2.44479984e-01f, -1.27302408e-01f, 2.00499706e-02f, -1.18252896e-01f, 1.38767019e-01f,
  -4.56156768e-02f, 7.15188030e-03f, -5.78545779e-02f, 4.38249819e-02f, -1.14759684e-01f, 8.80814344e-02f, -6.17964678e-02f, 7.66237378e-02f, 7.05823228e-02f, 6.16427474e-02f,
  5.21579059e-03f, 5.42771677e-03f, -2.95276288e-02f, -2.41822042e-02f, -4.55791242e-02f, -1.86329968e-02f, 3.09366193e-02f, -4.00706306e-02f, 1.48469890e-02f, 1.86298043e-02f,
  1.32435799e-01f, 8.51055309e-02f, 9.42019224e-02f, -1.77474990e-02f, -4.11203802e-02f, -9.66677908e-03f, 7.20882714e-02f, -5.13206236e-02f, 2.84786262e-02f, -1.00460067e-01f,
  -2.33469717e-02f, 1.29516225e-03f, 4.44887169e-02f, 1.30103424e-01f, -4.08142619e-02f, 8.55426490e-03f, 1.21225663e-01f, -4.81540896e-02f, 8.57125297e-02f, -4.26391587e-02f,
  -6.07438944e-02f, -4.53192368e-03f, 4.89279293e-02f, -4.19967994e-02f, 1.20584918e-02f, -1.18351569e-02f, -9.92490351e-03f, -7.14914650e-02f, -1.23193242e-01f, -3.89223024e-02f,
  6.05675727e-02f, -5.15100872e-03f, -1.12773374e-01f, 2.23558247e-02f, 7.48247802e-02f, 1.09844850e-02f, -1.20836385e-02f, -2.23210193e-02f, 7.22054159e-03f, -3.93196382e-02f,
  -1.83757320e-01f, -1.23534173e-01f, -1.91345606e-02f, -6.28531277e-02f, 3.37981656e-02f, 4.23316397e-02f, 1.60995692e-01f, -6.98448122e-02f, -4.19747597e-03f, -7.98616409e-02f,
  -8.58218744e-02f, -9.24064294e-02f, -4.65373807e-02f, -6.87707774e-03f, -9.06307343e-03f, -2.16790549e-02f, 7.05332533e-02f, -8.00628737e-02f, 8.86732433e-03f, -7.91624337e-02f,
  -8.04704279e-02f, -1.06052905e-01f, 4.09239307e-02f, -3.33873108e-02f, -1.69333704e-02f, -2.35991017e-03f, -1.36738390e-01f, 1.37601122e-02f, 9.41628516e-02f, 8.00401345e-02f
};

// L0_fan_Wp_bar (Shape: 8 x 120)
const int L0_fan_Wp_bar_rows = 8;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  1.81636781e-01f, -8.17014277e-01f, 4.39226061e-01f, 7.76862383e-01f, 2.42191002e-01f, -4.58415717e-01f, -6.16838448e-02f, -1.04155362e-01f, -2.41434216e-01f, -8.19929659e-01f,
  -6.98859571e-03f, -3.25689763e-01f, -3.83697867e-01f, 5.45616984e-01f, 9.70566630e-01f, -3.62273417e-02f, 4.58199561e-01f, 3.01361885e-02f, 3.01156044e-01f, 1.49463177e-01f,
  6.64569259e-01f, 5.05762339e-01f, 8.25292349e-01f, 3.67517203e-01f, 3.28674704e-01f, 2.68844187e-01f, 3.75385821e-01f, 1.54462352e-01f, 3.53597164e-01f, 1.79639846e-01f,
  -3.22573572e-01f, 7.51728490e-02f, 1.31496593e-01f, -1.27498180e-01f, 2.90242732e-02f, -1.99371800e-01f, -4.48222551e-03f, 3.11538875e-01f, 1.63156226e-01f, -6.90967143e-02f,
  -1.13321543e-02f, 4.50114086e-02f, 2.01285109e-01f, 7.17718229e-02f, -1.18434466e-01f, 4.17552004e-03f, 4.62300777e-02f, -1.31500348e-01f, -9.08532217e-02f, -1.05573937e-01f,
  -7.00397864e-02f, 2.91078854e-02f, 1.22250043e-01f, 5.70792295e-02f, 2.15030536e-01f, -6.07906580e-02f, 3.73293273e-02f, -6.01980723e-02f, -7.55410492e-02f, 1.34332016e-01f,
  -5.82967028e-02f, -5.83139248e-03f, -8.17662552e-02f, 1.62895069e-01f, 3.26283760e-02f, 1.16410777e-01f, 3.47615220e-02f, 4.69321944e-02f, 8.47128257e-02f, -3.86771746e-02f,
  6.73860982e-02f, 1.78598077e-03f, -9.94635150e-02f, -4.01552953e-02f, 4.83578444e-02f, -3.95129509e-02f, 6.60019591e-02f, 7.68771991e-02f, -5.65026626e-02f, 1.57755584e-01f,
  -4.61456776e-02f, 2.12916937e-02f, -1.67042166e-01f, 3.47294547e-02f, -1.80349514e-01f, 7.44501268e-03f, 7.45374411e-02f, -2.29047954e-01f, -5.04611507e-02f, 2.66571462e-01f,
  -3.98211837e-01f, 3.25831920e-02f, 4.36919034e-02f, 1.54226376e-02f, -2.15392234e-03f, 1.76563226e-02f, 1.23153850e-01f, -1.20200768e-01f, -1.06164142e-01f, 1.82096697e-02f,
  -2.82024946e-02f, 9.21531543e-02f, -1.28426284e-01f, 8.09976086e-02f, 1.63215429e-01f, -1.18104488e-01f, 1.86289120e-02f, -1.30797803e-01f, 8.50626230e-02f, 1.78534478e-01f,
  5.54564707e-02f, -2.55553853e-02f, 2.37957984e-01f, 9.13553387e-02f, 5.15756048e-02f, -4.10612412e-02f, -7.11550713e-02f, -7.31677711e-02f, 1.12056836e-01f, 3.83337587e-02f,
  2.99950391e-01f, 5.56561112e-01f, -4.76073712e-01f, 7.59139836e-01f, 2.28986278e-01f, 1.00617766e+00f, 7.23115325e-01f, 4.43020225e-01f, 7.77300239e-01f, 3.51086825e-01f,
  2.56229401e-01f, -2.30704442e-01f, -1.73627302e-01f, 8.70885730e-01f, 1.04557782e-01f, 4.49222416e-01f, 9.01853323e-01f, 5.42645991e-01f, 2.97901422e-01f, 3.77035826e-01f,
  1.86002970e-01f, 6.41999483e-01f, -7.88280129e-01f, -2.49498725e-01f, 7.65087977e-02f, -3.52352083e-01f, -4.91379142e-01f, -5.76499879e-01f, -2.89400160e-01f, 3.81588787e-02f,
  3.69196944e-02f, 2.18335405e-01f, -5.91766089e-02f, -1.33993953e-01f, 3.99433039e-02f, -8.83321911e-02f, -2.29696557e-01f, -2.46470973e-01f, -2.58619547e-01f, 3.35503519e-02f,
  6.73228130e-02f, -1.11211382e-01f, 2.38514096e-01f, 2.15486605e-02f, 1.03044838e-01f, -8.63764659e-02f, -1.16170913e-01f, -4.92610186e-02f, -1.86178535e-02f, -5.81875518e-02f,
  8.75429735e-02f, 1.61235221e-02f, 9.94745120e-02f, 1.70828849e-01f, -2.68479064e-02f, 8.34849179e-02f, -5.41472510e-02f, -9.90455076e-02f, 3.32784988e-02f, 1.65612429e-01f,
  -2.20996775e-02f, 1.63289651e-01f, -8.35121721e-02f, -1.90005720e-01f, 1.01543225e-01f, 3.02965250e-02f, -1.38065359e-02f, -1.13498732e-01f, 2.37247534e-02f, 7.25656450e-02f,
  2.36257501e-02f, -6.52394220e-02f, 1.90275148e-01f, -4.55133915e-02f, 1.79603204e-01f, 9.94880274e-02f, -2.06257418e-01f, 1.12932213e-01f, 1.03403807e-01f, -1.05441473e-01f,
  -2.07802281e-02f, 7.41367042e-02f, -5.18866070e-02f, -1.75469786e-01f, 2.49819960e-02f, -2.07645163e-01f, 8.24610889e-02f, -6.72903331e-03f, -1.26312643e-01f, 5.64587265e-02f,
  3.32316130e-01f, 6.59626245e-01f, 1.03421777e-01f, 1.73603036e-02f, -2.53192578e-02f, 2.79241838e-02f, 1.12268433e-01f, 1.76493809e-01f, 8.09406713e-02f, 1.37742817e-01f,
  1.54782357e-02f, 5.73543496e-02f, -3.10962182e-02f, -9.32901651e-02f, -6.97198510e-02f, 1.61382079e-01f, 6.13810904e-02f, 6.81730285e-02f, 8.64870027e-02f, -8.00080970e-02f,
  -1.39546812e-01f, 2.12757066e-01f, 4.14706301e-03f, 1.18873999e-01f, 9.60371867e-02f, -7.78303370e-02f, 2.04400972e-01f, -1.59356728e-01f, -5.67736439e-02f, 9.08742920e-02f,
  -5.93208000e-02f, -5.71242034e-01f, -1.00696616e-01f, 2.14424700e-01f, 6.17515743e-01f, 3.04303761e-03f, -6.26146495e-02f, 2.32655331e-01f, 2.96635002e-01f, -9.49462801e-02f,
  -3.40311021e-01f, -6.75701618e-01f, -6.87069654e-01f, -4.00440723e-01f, -8.21169734e-01f, -9.65943992e-01f, -1.22052401e-01f, -2.97181278e-01f, -1.50321156e-01f, 1.37332439e-01f,
  2.61725131e-02f, -1.83429718e-01f, -1.50974140e-01f, 3.93908590e-01f, 4.26232249e-01f, 6.07114375e-01f, 2.30972186e-01f, -5.40013611e-03f, 1.50562927e-01f, -1.66382000e-01f,
  -4.63535031e-03f, -1.62305176e-01f, -5.60201220e-02f, 1.48752630e-01f, 1.87563151e-01f, 1.66606858e-01f, 1.78245217e-01f, -2.69544631e-01f, 9.44412500e-02f, 3.11647281e-02f,
  -3.37690078e-02f, -1.20197266e-01f, -1.64733708e-01f, -8.00548941e-02f, 2.42011681e-01f, 5.39727323e-02f, 1.20193079e-01f, 1.62796855e-01f, -1.52600249e-02f, -2.91036963e-01f,
  -7.65327662e-02f, -7.24094808e-02f, 2.72155762e-01f, -8.58806744e-02f, 7.39025846e-02f, 9.98121873e-02f, 4.43317071e-02f, -1.39705032e-01f, 1.36135980e-01f, -1.30691184e-02f,
  -6.28297701e-02f, 1.14401571e-01f, -1.38612553e-01f, 1.30251169e-01f, -4.11846070e-03f, 1.11540429e-01f, 8.41451362e-02f, -4.02950943e-02f, 1.49193481e-01f, -4.59443294e-02f,
  9.73585397e-02f, -6.59113079e-02f, 1.61741152e-02f, 1.57420382e-01f, 2.78432611e-02f, 6.82921335e-02f, -1.17315553e-01f, -1.78695962e-01f, 1.55818373e-01f, 1.07814096e-01f,
  -3.52957956e-02f, 3.15247215e-02f, -8.53793770e-02f, 1.41121864e-01f, -1.30609963e-02f, -3.00691333e-02f, -3.79062854e-02f, -7.75907263e-02f, 1.65280893e-01f, -8.76737535e-02f,
  -7.19586201e-03f, -3.86687011e-01f, 4.99826781e-02f, -1.14287604e-02f, -7.61485547e-02f, -2.88104396e-02f, -1.35636568e-01f, -4.41582985e-02f, -9.38519649e-03f, -1.49502188e-01f,
  2.19762772e-01f, 2.06991196e-01f, 1.77266315e-01f, -6.03634529e-02f, -2.33993847e-02f, -4.91484776e-02f, -2.45371331e-02f, 1.56651393e-01f, 1.99309349e-01f, 8.78847316e-02f,
  1.28494591e-01f, 8.09929743e-02f, 1.19287878e-01f, 2.03705981e-01f, 8.10167715e-02f, 4.24088165e-02f, -2.74907369e-02f, 7.19741285e-02f, -8.72993842e-02f, -1.03438079e-01f,
  6.14055872e-01f, 2.59250440e-02f, -4.94075596e-01f, -5.26377082e-01f, -1.17753029e-01f, -3.87061566e-01f, -8.80481422e-01f, 7.26811297e-04f, -6.69686258e-01f, -1.92389823e-02f,
  -2.57743113e-02f, -3.70212644e-01f, 1.42152738e-02f, -3.57109338e-01f, 1.73969582e-01f, 2.14799978e-02f, 1.03723407e-01f, -1.49065748e-01f, 3.87811601e-01f, 3.36869687e-01f,
  4.44003582e-01f, 6.00368857e-01f, 1.45441845e-01f, 5.91865718e-01f, 1.40846655e-01f, 4.12967801e-01f, 7.79712379e-01f, -3.06119751e-02f, 1.15600459e-01f, 1.14726380e-01f,
  -2.23354504e-01f, 7.93219134e-02f, -2.11688936e-01f, -2.46503308e-01f, 2.20395148e-01f, 2.44732965e-02f, -5.81726730e-02f, -7.97072574e-02f, -1.20738223e-01f, -1.64096996e-01f,
  -5.24266958e-02f, 6.63236305e-02f, -4.38614488e-02f, -2.53626760e-02f, 9.89164412e-02f, -1.87615111e-01f, -2.85204295e-02f, -1.39834136e-01f, -3.06293279e-01f, 2.05659091e-01f,
  -8.67801160e-02f, -1.40387742e-02f, 1.30552396e-01f, -1.16472527e-01f, -9.02448148e-02f, 4.66650575e-02f, -8.50638375e-02f, -1.20780453e-01f, -1.44527480e-02f, 8.97306800e-02f,
  2.98004359e-01f, -7.53172040e-02f, 2.60258883e-01f, -2.03494653e-01f, -3.72876786e-03f, -4.73809950e-02f, 3.88225843e-03f, -1.01172822e-02f, 2.91942842e-02f, 1.42370509e-02f,
  -1.25934556e-01f, -3.35174948e-02f, -1.39283627e-01f, 7.72084668e-02f, 1.30464226e-01f, 9.47800875e-02f, 6.25324473e-02f, 1.79673523e-01f, -2.46620640e-01f, -6.25935793e-02f,
  -1.16662480e-01f, 2.73192897e-02f, -1.20803572e-01f, -9.87270325e-02f, -1.75657406e-01f, -9.57611352e-02f, 2.27129355e-01f, -2.36594565e-02f, 6.21078722e-02f, 1.05887882e-01f,
  2.04439983e-02f, 5.92278719e-01f, -4.03209180e-02f, -1.11894995e-01f, -1.04177848e-01f, 1.76365659e-01f, -1.29094809e-01f, 4.66937274e-02f, 1.14942066e-01f, 6.22294471e-02f,
  3.14803392e-01f, -8.32540244e-02f, 1.83471173e-01f, -2.46594865e-02f, -9.95809361e-02f, 1.47642329e-01f, 1.31499380e-01f, -8.52111652e-02f, -1.43646851e-01f, 2.59363145e-01f,
  6.71669981e-03f, 2.06495866e-01f, -5.27511612e-02f, -1.84685230e-01f, -1.19889146e-02f, -9.33036804e-02f, 4.48551849e-02f, 2.95689143e-02f, 1.85127676e-01f, -1.65905505e-01f,
  -9.56473589e-01f, -6.19613491e-02f, -9.99577343e-01f, -2.89048642e-01f, -5.96070111e-01f, -8.43149602e-01f, -2.88796693e-01f, -3.67158175e-01f, 1.51461720e-01f, 7.38053262e-01f,
  2.74815470e-01f, -1.56625360e-01f, 8.02095115e-01f, -8.71731192e-02f, -7.62331605e-01f, 7.51358449e-01f, -3.58352691e-01f, 6.78882748e-02f, 7.36704245e-02f, -4.37982202e-01f,
  -3.69988263e-01f, -5.19406721e-02f, -2.62150586e-01f, -2.18237892e-01f, -8.97689641e-01f, -4.59450215e-01f, 2.41176188e-01f, -2.65436083e-01f, -4.77375805e-01f, -2.45941490e-01f,
  -1.33756205e-01f, 1.51356369e-01f, -1.27858028e-01f, -7.51104429e-02f, -3.61567229e-01f, -2.18167171e-01f, -1.66458473e-01f, -4.25775126e-02f, -4.26546820e-02f, -9.10517760e-03f,
  5.43646999e-02f, -3.85223925e-02f, -5.54302335e-02f, 1.73717439e-01f, -9.19600111e-03f, -1.30797669e-01f, -1.44389585e-01f, -1.35264412e-01f, -5.97031638e-02f, -6.96331114e-02f,
  -1.50274962e-01f, -1.49308592e-01f, -1.08884508e-02f, 7.67392814e-02f, -1.87490538e-01f, -7.17960075e-02f, -4.59878929e-02f, -7.13906884e-02f, -1.22189581e-01f, -2.10701540e-01f,
  -1.80116426e-02f, -5.12639433e-02f, 1.77767538e-02f, -1.49620865e-02f, -6.25205413e-02f, 4.67159599e-02f, -1.93864796e-02f, 8.67726468e-03f, 4.73007299e-02f, -3.22478265e-02f,
  -6.69404492e-02f, 2.09798180e-02f, 5.36822109e-03f, -5.49225323e-02f, -3.01287649e-03f, 1.36556804e-01f, 1.32515460e-01f, 3.01009864e-02f, -8.19118470e-02f, -9.51434001e-02f,
  1.27635732e-01f, 5.90357855e-02f, 1.02242246e-01f, 1.70022309e-01f, -4.68237400e-02f, 7.83452690e-02f, 3.65540795e-02f, -6.97035566e-02f, 8.81099701e-02f, -1.14842303e-01f,
  -4.73236471e-01f, -4.13006902e-01f, 1.13239691e-01f, 6.73401505e-02f, 9.33548138e-02f, -1.16940215e-01f, -1.56811737e-02f, -1.61929697e-01f, -3.15344900e-01f, -3.44702266e-02f,
  -3.69497687e-02f, 1.51644856e-01f, -2.85168320e-01f, 4.59616370e-02f, 5.66704124e-02f, 1.70719959e-02f, -9.24939476e-03f, 3.20986059e-04f, -1.37504473e-01f, -7.58300275e-02f,
  1.11334890e-01f, 6.78362772e-02f, 7.37497732e-02f, -4.07345742e-02f, 1.25631481e-01f, 9.04964730e-02f, -7.51345903e-02f, -9.03021172e-02f, -8.40407237e-02f, 2.50725392e-02f,
  -1.71225810e+00f, 7.06964552e-01f, 1.96961209e-01f, -9.75476503e-01f, 5.39376080e-01f, 4.17196602e-01f, -5.06184638e-01f, 6.10814929e-01f, -2.12661535e-01f, 1.36615798e-01f,
  4.90875803e-02f, -4.94132638e-01f, 4.32779819e-01f, -4.68765408e-01f, -5.14911711e-01f, 1.29243953e-03f, -5.50445378e-01f, -5.68840683e-01f, 1.58795178e-01f, -1.72180906e-01f,
  -1.53297991e-01f, -1.78610146e-01f, -9.70426649e-02f, 6.79910779e-01f, -7.98659399e-02f, 8.95982385e-02f, -2.79858261e-01f, 5.71001053e-01f, -2.52385408e-01f, -2.28492580e-02f,
  -1.19463779e-01f, -2.49389224e-02f, -9.65457708e-02f, 1.21579498e-01f, 2.91482564e-02f, -9.83256921e-02f, -1.86988324e-01f, -7.73899704e-02f, -2.05550686e-01f, -1.37199992e-02f,
  -1.40416384e-01f, 1.89840928e-01f, -1.73777476e-01f, 1.32576898e-01f, 1.13407366e-01f, 1.32959023e-01f, 1.71264976e-01f, 1.37378660e-03f, 6.08035997e-02f, 9.88224000e-02f,
  6.71929419e-02f, 1.88299611e-01f, -1.03908824e-03f, -5.65862209e-02f, 5.05206659e-02f, 9.74497497e-02f, -3.20979021e-02f, -2.43299417e-02f, -3.82594094e-02f, -6.45049065e-02f,
  1.51210912e-02f, 1.39305145e-02f, 9.17407591e-03f, 2.74702557e-03f, -4.15150374e-02f, 3.58315781e-02f, -6.82954956e-03f, -1.27776518e-01f, -9.57294255e-02f, 9.15767401e-02f,
  -7.38889650e-02f, -3.15523846e-03f, 1.07195340e-01f, -1.00486763e-01f, -3.68083306e-02f, -1.15675494e-01f, -8.10050312e-03f, -6.79410528e-03f, -1.11403517e-01f, -1.78690180e-02f,
  -1.53165795e-02f, -5.79997525e-02f, -1.22851789e-01f, -2.28058472e-02f, 6.54743612e-02f, 7.86203705e-03f, 1.50268406e-01f, -3.16840932e-02f, -7.16925599e-03f, 2.28846874e-02f,
  -6.03460856e-02f, 1.16247334e-01f, 3.41456234e-02f, 3.60042509e-03f, -2.87743863e-02f, 9.68782045e-03f, 1.48686080e-03f, -3.29453265e-03f, -1.45288378e-01f, -1.18958894e-02f,
  -1.26646860e-02f, -9.36721042e-02f, -1.13817602e-02f, 1.09078633e-02f, 9.59408563e-03f, -3.86427343e-02f, -1.77505210e-01f, -1.13381073e-01f, -8.49175826e-02f, 3.49999890e-02f,
  -6.33719796e-03f, 7.44979382e-02f, -4.70095016e-02f, 6.67885318e-02f, -2.40152609e-03f, -8.41419771e-02f, -5.48748598e-02f, 7.42724165e-02f, 2.07751542e-02f, 4.24678773e-02f,
  8.60390782e-01f, -4.99640346e-01f, 1.01330888e+00f, 2.68725473e-02f, 5.92991233e-01f, 6.10056043e-01f, 4.76551354e-01f, 1.95246458e-01f, 4.51529145e-01f, -6.77537978e-01f,
  -4.39007521e-01f, -1.89233765e-01f, 3.24713767e-01f, -5.83486497e-01f, 6.33929193e-01f, 3.02337617e-01f, -4.83093522e-02f, -1.59022227e-01f, 2.47334778e-01f, -2.85356700e-01f,
  1.20970853e-01f, -8.65357757e-01f, 6.12714812e-02f, -9.30987716e-01f, -2.31235072e-01f, -3.30914170e-01f, -7.25085258e-01f, -1.46456823e-01f, -8.21023524e-01f, -6.65877014e-02f,
  -1.61319315e-01f, -7.82796517e-02f, -9.98711810e-02f, -1.40350675e-02f, 4.68914919e-02f, -6.36012852e-02f, 4.03021723e-02f, 5.58224618e-02f, 1.05713129e-01f, 8.27088952e-02f,
  -1.12062477e-01f, 4.80919555e-02f, -2.45438784e-01f, 4.72385809e-03f, 1.57811388e-01f, -3.56024727e-02f, 1.06667615e-01f, 1.37927979e-01f, -4.16416153e-02f, 2.55319864e-01f,
  3.19083989e-01f, 1.08299509e-01f, 2.08523363e-01f, 4.98972367e-03f, 1.27034977e-01f, -1.17827952e-01f, 1.27465993e-01f, 1.88734189e-01f, 2.31341589e-02f, 6.57458156e-02f,
  -1.88534647e-01f, 3.71013284e-02f, 2.94351634e-02f, -1.14024363e-01f, 4.62462716e-02f, 3.94060798e-02f, 1.08808582e-03f, -6.22006319e-02f, 8.40814784e-02f, 4.24718745e-02f,
  -2.88415644e-02f, -5.91118187e-02f, 1.06014907e-01f, 1.91009536e-01f, -8.34300518e-02f, 5.79261333e-02f, -6.62061498e-02f, 6.24809451e-02f, -5.58043495e-02f, -1.21258330e-02f,
  1.22004263e-02f, 2.04156432e-02f, -4.48075570e-02f, 6.67308494e-02f, -1.88364107e-02f, 9.86831039e-02f, -2.51743376e-01f, 2.40208507e-01f, 1.70761775e-02f, -1.05967876e-02f,
  -4.59267199e-01f, -8.77917230e-01f, -2.24983722e-01f, -1.56954721e-01f, -9.33356285e-02f, -1.85272142e-01f, -2.95761675e-02f, 2.03052675e-03f, -1.08229116e-01f, 3.48213203e-02f,
  -7.26636648e-02f, -5.51652946e-02f, -9.53699201e-02f, 1.57108322e-01f, -1.34751901e-01f, 4.43730839e-02f, -1.87005237e-01f, -2.04776064e-01f, -2.14362800e-01f, -2.90343374e-01f,
  1.89608932e-02f, 4.80271392e-02f, 3.49503011e-02f, -1.72221020e-01f, -1.22729167e-01f, -8.85129049e-02f, -4.03807638e-03f, -4.91913110e-02f, -9.31251571e-02f, -8.80829468e-02f,
  4.39736545e-01f, 9.18356001e-01f, 5.76602340e-01f, 5.34207165e-01f, -2.75305778e-01f, -9.57170725e-01f, -6.95543826e-01f, 1.90701947e-01f, 1.00985534e-01f, 2.13248193e-01f,
  -3.39545459e-01f, 8.86576772e-01f, -6.66242465e-02f, 1.65627692e-02f, -8.93392444e-01f, -4.81906116e-01f, -1.28143758e-01f, 3.34523767e-02f, 2.01439992e-01f, 4.10087258e-01f,
  1.57773923e-02f, -5.31311572e-01f, 2.76084132e-02f, -1.30710050e-01f, 2.64257073e-01f, 6.39147818e-01f, 2.64476329e-01f, 6.76541105e-02f, 3.06101859e-01f, -1.71049982e-01f,
  -3.21150035e-01f, 2.66580611e-01f, 2.18946144e-01f, 3.58463712e-02f, -2.17636023e-02f, -9.20395926e-03f, 7.31682479e-02f, -1.63095683e-01f, -1.99039072e-01f, 1.30682543e-01f,
  1.07438080e-01f, -7.21881762e-02f, 9.00666788e-02f, -4.12533283e-02f, 7.56007433e-02f, 1.97534308e-01f, 1.19615048e-01f, 1.46284297e-01f, 1.64954528e-01f, 1.28875703e-01f,
  1.61804318e-01f, 1.04068778e-01f, 1.35633036e-01f, 1.75969854e-01f, 1.51732236e-01f, -3.83536108e-02f, -5.47597893e-02f, 1.41741827e-01f, 1.65898308e-01f, 4.44660895e-02f,
  2.04161089e-02f, -7.10567534e-02f, -7.32994974e-02f, -1.16212247e-02f, -9.19232816e-02f, 2.75758412e-02f, 6.58175126e-02f, -8.45778883e-02f, -2.33969372e-02f, -4.43679392e-02f,
  -1.08922727e-01f, 1.60111815e-01f, -3.96883115e-02f, -3.71214002e-02f, 1.35154337e-01f, -1.03087944e-03f, -7.91091025e-02f, 1.03055581e-01f, 3.03177945e-02f, 1.16683811e-01f,
  2.11610794e-02f, -1.48637846e-01f, -1.45348860e-02f, -7.03829108e-03f, -2.74540275e-01f, 3.07066087e-03f, 1.73100948e-01f, 1.31139144e-01f, -4.88953590e-02f, 3.21966484e-02f,
  1.13775760e-01f, 4.64877635e-01f, 2.11400867e-01f, -4.53381129e-02f, 3.50924395e-02f, -2.52143349e-02f, -1.27533078e-01f, 9.76165310e-02f, 1.34566545e-01f, -2.50654310e-01f,
  4.48108017e-02f, 7.81587735e-02f, 5.15498370e-02f, -1.48546427e-01f, -1.70407270e-03f, -5.48627861e-02f, 7.05426112e-02f, 7.19617531e-02f, 1.08673640e-01f, 2.28252217e-01f,
  1.79472625e-01f, -9.46499873e-03f, -2.00412255e-02f, -8.05330053e-02f, 6.17419370e-02f, -8.15794710e-03f, 7.20166638e-02f, 7.27944151e-02f, 1.68444857e-01f, 4.88561317e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 8)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 8;
const float L0_fan_Bp_bar_data[] = {
  6.25071943e-01f, 5.35669744e-01f, 8.04873288e-01f, 6.84291661e-01f, 5.42746484e-01f, 9.23729122e-01f, 1.16060424e+00f, 8.17249000e-01f
};

// L1_linear_W (Shape: 12 x 32)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 32;
const float L1_linear_W_data[] = {
  2.84397930e-01f, -2.98330724e-01f, -1.75826237e-01f, -5.54090381e-01f, 4.94364113e-01f, 3.14498782e-01f, -3.17172527e-01f, -1.27369452e+00f, -8.78664553e-01f, -1.74334511e-01f,
  4.24209565e-01f, -9.07554448e-01f, 1.27346590e-01f, 6.14612639e-01f, 8.01082730e-01f, -9.90897298e-01f, 2.11720482e-01f, 8.94317746e-01f, -4.74989802e-01f, 4.44656193e-01f,
  -6.47113800e-01f, -5.74162066e-01f, 5.07024646e-01f, 6.80476129e-01f, -3.68140012e-01f, 3.48662138e-01f, -3.06157559e-01f, -4.76323813e-01f, 1.05682099e+00f, -4.94529188e-01f,
  -7.69889057e-01f, -8.43268156e-01f, 2.40271054e-02f, -4.05651391e-01f, -1.56453192e-01f, 9.33788642e-02f, -9.53081697e-02f, 7.03626424e-02f, 3.22161466e-01f, 5.47040522e-01f,
  4.14663196e-01f, -8.17520857e-01f, 8.29532295e-02f, 1.84788406e-01f, 6.51716590e-01f, 9.60995078e-01f, 9.77273643e-01f, -3.00722033e-01f, 1.19858432e+00f, -1.29757833e+00f,
  -1.04561937e+00f, 4.34082747e-01f, 1.86959002e-02f, 2.88946211e-01f, 5.37730038e-01f, -9.25701678e-01f, -5.45601666e-01f, 8.39608490e-01f, -7.28345454e-01f, 8.28583062e-01f,
  -7.69229293e-01f, -1.01469696e+00f, -1.05557144e+00f, -9.59694624e-01f, 2.20704731e-02f, 3.81156236e-01f, -7.29320884e-01f, 4.20759439e-01f, -3.06815982e-01f, -7.47792780e-01f,
  -2.43091196e-01f, 2.49443531e-01f, 1.00896865e-01f, -3.74424249e-01f, -8.56124088e-02f, -7.80656561e-02f, 8.70892882e-01f, -3.16755354e-01f, 3.14684838e-01f, -1.67377368e-01f,
  5.58927774e-01f, -3.20058167e-01f, 6.58259511e-01f, 1.93620518e-01f, 7.18850911e-01f, -3.20152074e-01f, 3.65410119e-01f, 1.27364144e-01f, 1.07295501e+00f, -4.81100619e-01f,
  6.65197670e-01f, -3.09904367e-01f, -5.69228232e-01f, -5.96584737e-01f, -1.05298710e+00f, -1.18302166e+00f, 1.63522869e-01f, 1.61399886e-01f, -5.42060196e-01f, 1.54062100e-02f,
  -3.88226695e-02f, -4.05536324e-01f, -2.05708131e-01f, -5.29003382e-01f, 1.04479805e-01f, -1.05516720e+00f, -9.20673907e-01f, 7.88752854e-01f, 7.64920861e-02f, 1.79110304e-01f,
  -2.39534020e-01f, 5.63852906e-01f, 3.84533674e-01f, 4.83192176e-01f, -8.40370297e-01f, 7.32814610e-01f, 9.77792203e-01f, 6.58912122e-01f, -8.08796734e-02f, -2.95856893e-01f,
  -4.84406233e-01f, -7.44407594e-01f, -1.87580258e-01f, -4.18222517e-01f, 6.19295537e-01f, 9.04327512e-01f, -1.05823827e+00f, 4.18009385e-02f, 1.85211286e-01f, 7.23228276e-01f,
  1.85997501e-01f, 6.35901764e-02f, 2.23020434e-01f, 2.51413118e-02f, 4.89462852e-01f, 3.15262407e-01f, -1.26849905e-01f, 5.16743362e-01f, 4.56344426e-01f, 2.04703445e-03f,
  -5.91924846e-01f, 2.64096372e-02f, 4.50748682e-01f, -1.08417124e-01f, -5.78614771e-01f, 9.51676071e-01f, -5.01240313e-01f, 7.92906761e-01f, -9.16777551e-01f, -5.02184451e-01f,
  -9.07147884e-01f, 9.68102276e-01f, -3.28481831e-02f, -8.92963052e-01f, -5.28521657e-01f, 1.75399318e-01f, -5.97642303e-01f, 1.01586711e+00f, 4.45632398e-01f, -9.06224847e-01f,
  3.83827269e-01f, 7.91842461e-01f, 5.19478381e-01f, 3.59047204e-01f, -1.65788114e-01f, 5.50288141e-01f, -1.58276141e-01f, 8.54915440e-01f, 4.46301341e-01f, 1.75853848e-01f,
  2.85085708e-01f, 1.57118976e-01f, 3.79679739e-01f, -9.44070280e-01f, -1.47638106e+00f, 1.01157200e+00f, -1.22439837e+00f, 5.76439738e-01f, 6.53459013e-01f, -5.64634800e-01f,
  -2.98938543e-01f, -9.19507384e-01f, 6.83524609e-01f, 4.03264999e-01f, -6.43044651e-01f, 8.05702209e-01f, -5.33932090e-01f, -6.15917027e-01f, -2.17289217e-02f, -5.45647800e-01f,
  -2.94881593e-02f, -2.14526758e-01f, -7.45033145e-01f, -6.70876130e-02f, 2.93003798e-01f, -2.98743933e-01f, 2.65862226e-01f, -4.24476653e-01f, 2.68782616e-01f, -4.12067473e-01f,
  -7.35485375e-01f, 3.43486607e-01f, -4.22937304e-01f, -1.78276986e-01f, -8.68896067e-01f, -3.68339926e-01f, 3.74265820e-01f, 6.10414982e-01f, -4.68076438e-01f, -1.71540350e-01f,
  -5.94815254e-01f, -5.16510487e-01f, 1.16877186e+00f, 8.14030945e-01f, 7.07404494e-01f, -9.34486091e-01f, 1.44629374e-01f, 2.40178660e-01f, 7.82983601e-01f, -3.82687747e-01f,
  -7.43277311e-01f, -8.06649029e-01f, 6.96827412e-01f, -8.05736601e-01f, -1.93106532e-02f, -7.76118279e-01f, -4.61776108e-01f, -6.76425099e-01f, 1.15949504e-01f, -4.77583528e-01f,
  -4.39189434e-01f, -2.95282185e-01f, -4.13518161e-01f, 1.04292534e-01f, -4.39822860e-02f, -3.14094037e-01f, -2.64617264e-01f, -6.57095075e-01f, -5.95973194e-01f, 5.68101764e-01f,
  -3.04791361e-01f, 2.14551240e-01f, 8.00853252e-01f, -8.06365728e-01f, 8.30407441e-01f, 4.31254387e-01f, 2.19412893e-02f, 4.11342353e-01f, -4.98626024e-01f, -8.07902515e-01f,
  -6.92026079e-01f, 4.46042269e-01f, 8.72584760e-01f, -3.58564317e-01f, 3.56345147e-01f, 1.35821309e-02f, -3.45755696e-01f, -3.75722051e-01f, 8.21405351e-02f, -5.90403140e-01f,
  -4.88907956e-02f, 2.60832042e-01f, -1.50656834e-01f, 9.99376029e-02f, -2.08271533e-01f, 4.53859091e-01f, -5.63590646e-01f, 9.99856293e-02f, -7.01872408e-01f, 4.22879279e-01f,
  -4.26675141e-01f, -6.99562907e-01f, -4.38937217e-01f, -3.93297337e-02f, 4.71901059e-01f, 2.80476600e-01f, 4.18253481e-01f, 1.46641076e-01f, 3.21030200e-01f, -4.37720239e-01f,
  5.78616381e-01f, -2.96433240e-01f, -6.87126338e-01f, 3.07728231e-01f, -9.70156550e-01f, -4.47230667e-01f, -5.11209965e-01f, 6.69062912e-01f, 4.59822983e-01f, -9.61664796e-01f,
  9.29844156e-02f, 5.15771568e-01f, 3.56220722e-01f, 3.88393015e-01f, -1.52974334e-02f, -4.77226198e-01f, 3.19051027e-01f, 2.82268435e-01f, 7.45141566e-01f, -1.27527997e-01f,
  -4.15522397e-01f, -7.13738918e-01f, 4.76673752e-01f, -3.27917457e-01f, 7.73879349e-01f, -6.93688989e-01f, 9.12931085e-01f, -8.53667259e-01f, -6.07159495e-01f, -7.74183452e-01f,
  -8.44019592e-01f, 8.85573328e-01f, 4.30547684e-01f, -1.38292778e+00f, -1.13407004e+00f, -8.02362502e-01f, -3.60924959e-01f, -1.08260477e+00f, 8.91573429e-01f, -3.15296561e-01f,
  -9.43477511e-01f, -2.42621973e-01f, 3.83721143e-01f, 1.71294987e-01f, -3.89265060e-01f, 3.33013147e-01f, 2.36364752e-01f, 6.81226969e-01f, 9.58954468e-02f, 6.90888047e-01f,
  -2.20128238e-01f, -5.77018261e-01f, 7.88534045e-01f, 7.18329191e-01f, -5.08828342e-01f, -7.78934777e-01f, 6.29729629e-01f, -8.55591893e-02f, 9.05190110e-01f, -6.56320333e-01f,
  -7.38719761e-01f, 5.82509995e-01f, -7.51574874e-01f, -7.49830127e-01f, -1.16481376e+00f, -3.51326227e-01f, 9.82447326e-01f, 2.47471914e-01f, -3.65850478e-01f, 2.71106988e-01f,
  -7.99905837e-01f, -2.22705491e-02f, 2.54565418e-01f, 3.63708258e-01f, -6.49444759e-02f, -2.02429779e-02f, -4.60961252e-01f, 2.03026846e-01f, 7.89857209e-02f, 2.17458770e-01f,
  1.94562390e-01f, -1.09107971e-01f, 2.88625211e-01f, 4.13472652e-01f, -5.18989921e-01f, 3.21520895e-01f, -4.20733124e-01f, 8.73003602e-01f, -5.88783026e-01f, -6.91949666e-01f,
  -3.07633102e-01f, 3.09978098e-01f, -3.27964664e-01f, 6.18155241e-01f, -1.91522427e-02f, -4.14534181e-01f, -9.66535866e-01f, -7.42432714e-01f, 1.62414964e-02f, -9.37210679e-01f,
  -6.58083737e-01f, -6.65240407e-01f, 3.21333736e-01f, 1.35063207e+00f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  1.53480591e-02f, 2.64043480e-01f, 4.75561759e-03f, -2.79286504e-01f, 2.88624447e-02f, 1.89402431e-01f, -1.89532652e-01f, -1.99675903e-01f, -4.05530185e-01f, 2.71365523e-01f,
  5.91829754e-02f, -4.75404598e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 12, 8
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        32, 12
    );
    }
    