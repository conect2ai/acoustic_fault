/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -3.48747261e-02f, -2.04026163e-01f, -2.64531374e-01f, 2.14319780e-01f, 7.74514154e-02f, 4.42998946e-01f, 2.76392281e-01f, -1.05412513e-01f, 1.81210712e-01f, -8.13577771e-02f,
  8.83629099e-02f, -2.50303373e-02f, -1.33927628e-01f, 2.67299235e-01f, 2.79387981e-01f, 1.54616639e-01f, 3.12222481e-01f, 1.41640916e-01f, 6.70220554e-02f, 1.02620012e-04f,
  7.85022601e-02f, 2.22635105e-01f, 3.53824551e-04f, -2.97523178e-02f, -5.81804737e-02f, -1.59904972e-01f, -1.08456559e-01f, -1.24504991e-01f, -8.41719732e-02f, 6.46128729e-02f,
  6.85696527e-02f, -7.77460039e-02f, -1.10589273e-01f, 2.22046562e-02f, -3.22001688e-02f, -4.97882180e-02f, 1.47564979e-02f, -5.21566831e-02f, 1.34428153e-02f, -2.91503463e-02f,
  -4.48774584e-02f, -1.67362299e-02f, 4.89047691e-02f, 2.91257864e-03f, 1.11174807e-02f, -3.22599150e-02f, 8.28661397e-03f, 2.30971593e-02f, -6.10696636e-02f, -1.96986701e-02f,
  2.89294757e-02f, 5.07796556e-02f, -9.56188829e-04f, 8.34798738e-02f, -2.96839941e-02f, 8.18377733e-02f, 4.57444548e-04f, 5.05323382e-03f, 3.60530354e-02f, -1.27073575e-03f,
  -9.58278216e-03f, -6.76106960e-02f, -1.76411308e-02f, 1.96670033e-02f, -6.58811303e-03f, -1.06177563e-02f, 1.26978103e-02f, -2.83457227e-02f, -3.10348012e-02f, 9.55122709e-03f,
  4.01577689e-02f, 3.79120708e-02f, 4.12837379e-02f, 5.82470223e-02f, -1.01949815e-02f, 1.29228700e-02f, 1.92287136e-02f, 1.51827373e-02f, 5.89336641e-02f, 4.29826267e-02f,
  4.93152358e-04f, 8.12777802e-02f, -1.46165928e-02f, 2.16052085e-02f, 1.60468239e-02f, -2.65592579e-02f, 3.74576449e-02f, -5.46207186e-03f, -4.07601818e-02f, -2.82708984e-02f,
  2.57489700e-02f, -2.73693919e-01f, 1.88373551e-02f, 4.46202122e-02f, 5.30509017e-02f, 6.41761161e-03f, 3.02398726e-02f, 9.56702232e-03f, -5.36093116e-02f, -1.77244935e-02f,
  -1.32865990e-02f, -2.22461880e-03f, -2.61371415e-02f, 2.51148045e-02f, 6.15191571e-02f, 2.41071153e-02f, -1.94699429e-02f, -4.26411629e-02f, 3.87042090e-02f, -2.39921976e-02f,
  -9.55690220e-02f, -2.12729611e-02f, -1.84632856e-02f, -8.58329386e-02f, 4.82538901e-02f, -6.99042380e-02f, 1.30062392e-02f, -7.05561647e-03f, -1.21736443e-02f, 4.87420894e-02f,
  1.10273302e+00f, 8.38288441e-02f, 3.21612716e-01f, 1.39171347e-01f, 7.74094686e-02f, 9.26871449e-02f, 2.62038201e-01f, -4.45412770e-02f, 3.81036222e-01f, -1.08775802e-01f,
  -5.36946505e-02f, 2.39340782e-01f, -2.69858502e-02f, -1.12236673e-02f, -6.95802122e-02f, 3.21558975e-02f, -1.86998136e-02f, 5.12548126e-02f, 6.36902675e-02f, -3.20342928e-02f,
  5.73230162e-02f, -1.66491345e-01f, -6.40019262e-03f, -1.85343951e-01f, 5.51405847e-02f, -8.04994814e-03f, -2.07880467e-01f, 4.61907854e-04f, -9.36579853e-02f, -3.36527415e-02f,
  9.04621035e-02f, 6.91653937e-02f, 3.39005850e-02f, -7.74190798e-02f, -3.37952003e-02f, 1.91733167e-02f, 1.25803137e-02f, -3.61879729e-03f, 5.87698398e-03f, 1.46954972e-02f,
  3.51779722e-02f, 1.27476957e-02f, -3.61267552e-02f, -2.13351473e-02f, 6.48997501e-02f, 3.90556753e-02f, 3.34101319e-02f, -1.40412934e-02f, 1.21969925e-02f, 2.04498451e-02f,
  1.13198739e-02f, -1.11798607e-02f, 2.16561370e-02f, -2.94664670e-02f, 2.55011115e-02f, 2.75111664e-02f, -3.06582563e-02f, -6.67236606e-03f, 7.57465279e-03f, 2.04430278e-02f,
  -3.41829881e-02f, 2.18398422e-02f, -5.56827523e-02f, -1.16474098e-02f, -2.75325216e-02f, -4.75894809e-02f, -1.39906798e-02f, -3.17873769e-02f, 4.50447053e-02f, -5.69362231e-02f,
  3.16367783e-02f, -1.32708601e-03f, 2.35811658e-02f, 2.07743384e-02f, 1.12683494e-02f, 5.09189116e-03f, 8.30216333e-03f, -1.05131336e-03f, 4.07122672e-02f, 2.80105285e-02f,
  1.66472960e-02f, 3.80780436e-02f, 1.23106278e-02f, 1.00846104e-02f, -6.48362515e-03f, 4.21576351e-02f, -1.04238940e-02f, -1.04543357e-03f, 2.87525132e-02f, -3.79672833e-02f,
  -2.78386444e-01f, -2.00378090e-01f, -5.81777003e-03f, 5.20690829e-02f, 3.98497432e-02f, -9.28032119e-03f, -6.27331529e-03f, -1.01216254e-03f, 1.27545102e-02f, -1.34281525e-02f,
  -2.56936997e-02f, -1.27734048e-02f, -2.17715802e-04f, -2.01484957e-03f, -3.78375426e-02f, -4.06267829e-02f, -1.92344766e-02f, 1.35617591e-02f, -3.30568738e-02f, -4.43548933e-02f,
  -2.28778757e-02f, -1.98938847e-02f, -1.71508268e-02f, -9.96504445e-03f, -2.83844247e-02f, -2.57025175e-02f, 3.25264595e-02f, 2.43914016e-02f, -5.64074814e-02f, -6.06372254e-03f,
  -1.12460211e-01f, -1.84116721e-01f, 1.49517730e-01f, -1.20969437e-01f, 7.61723965e-02f, 5.80708563e-01f, 3.25096011e-01f, 1.97481886e-02f, -1.73590362e-01f, 4.18600673e-03f,
  -4.86365426e-03f, -1.17691927e-01f, 8.26150121e-04f, 3.73455249e-02f, 3.23009670e-01f, 1.61519483e-01f, 7.34108984e-02f, 3.41262370e-02f, 3.76140350e-03f, 1.40245661e-01f,
  9.19260010e-02f, 1.09611496e-01f, 1.40912816e-01f, 9.42364857e-02f, 1.07753947e-01f, -6.62929565e-02f, 1.47840250e-02f, 9.04665887e-02f, -7.28735253e-02f, 1.90286189e-02f,
  -8.29761699e-02f, -2.17218280e-01f, -6.00234009e-02f, 1.53470291e-02f, 4.32441048e-02f, 1.77856199e-02f, 3.11920438e-02f, -3.49481776e-02f, 7.05574546e-03f, -1.47220362e-02f,
  6.56434521e-03f, 2.60350984e-02f, -1.05679156e-02f, -3.31532583e-02f, 5.09025436e-03f, -3.87187563e-02f, 3.64595428e-02f, 1.24821141e-02f, -3.23253870e-03f, 3.06631736e-02f,
  4.58759218e-02f, -4.86664614e-03f, 3.17430757e-02f, -4.48717847e-02f, 2.61639059e-02f, -4.83303890e-02f, 4.08581719e-02f, 1.59584489e-02f, 3.55745829e-03f, -5.52021004e-02f,
  3.88768362e-03f, 2.43518706e-02f, 1.98388416e-02f, -6.29666895e-02f, 3.78687307e-02f, -1.88746192e-02f, 7.13076890e-02f, -1.27351889e-02f, -1.18573382e-02f, 1.94434356e-02f,
  -3.18901893e-03f, -3.14142182e-02f, -2.44624875e-02f, 3.33520733e-02f, 1.38376234e-02f, -4.93802801e-02f, -3.88543878e-04f, -2.50222702e-02f, 3.78344022e-02f, 2.60675251e-02f,
  3.51440348e-02f, -1.04306042e-02f, 1.64864433e-03f, 3.88121493e-02f, 7.26148486e-03f, 1.13090975e-02f, -1.75153222e-02f, 1.34991703e-03f, -2.31129695e-02f, 6.77868128e-02f,
  1.78165376e-01f, 4.70838882e-02f, -9.16703232e-03f, -4.34311964e-02f, -2.59904526e-02f, -1.40303955e-03f, 1.72836799e-02f, 3.49877514e-02f, 1.98358018e-02f, 3.29604782e-02f,
  3.76441181e-02f, -3.70082557e-02f, 1.73558760e-02f, 6.84843911e-03f, 3.18613537e-02f, -1.37260696e-02f, -9.52927116e-03f, 9.01825447e-03f, 5.60291782e-02f, -1.43792666e-02f,
  1.66787151e-02f, 3.17591662e-03f, -3.22266743e-02f, 3.81280743e-02f, 1.42184980e-02f, 4.36908677e-02f, -5.68757728e-02f, -3.94832157e-02f, 4.83242050e-02f, 4.77291793e-02f,
  -3.68336588e-01f, 4.17108744e-01f, -4.25671712e-02f, -1.56285062e-01f, -1.17428347e-01f, 4.84198779e-01f, 2.77176529e-01f, -1.39138419e-02f, -1.13988155e-02f, 2.11439639e-01f,
  6.12852275e-02f, 8.62952918e-02f, 3.10922563e-01f, 1.65878311e-01f, 3.01900096e-02f, 4.37399924e-01f, 3.01616285e-02f, 2.78251171e-02f, 4.43325890e-03f, -1.95987877e-02f,
  -8.10847878e-02f, 1.42376974e-01f, 7.13158585e-03f, -3.04122618e-03f, -6.71646893e-02f, -1.61110729e-01f, -1.74722329e-01f, -2.61670202e-02f, -6.73950762e-02f, 4.59576510e-02f,
  4.28376207e-03f, -5.13343364e-02f, -1.00581059e-02f, -2.64590662e-02f, -9.77236629e-02f, -6.50461297e-03f, -1.91137642e-02f, 1.78793445e-02f, -9.77002680e-02f, -3.47386636e-02f,
  8.39319602e-02f, 1.68151017e-02f, -4.67092320e-02f, 3.62197235e-02f, -3.26898471e-02f, -2.26856433e-02f, -1.77572090e-02f, 2.26603542e-02f, -1.12246713e-02f, 9.95322969e-03f,
  1.51576772e-02f, -4.46409509e-02f, -3.08060274e-02f, 6.20565936e-02f, -3.85372825e-02f, 5.30097913e-03f, 1.60008520e-02f, -1.58209261e-02f, -5.19887470e-02f, -1.32667692e-02f,
  -3.81257422e-02f, -4.96513722e-03f, 5.84567562e-02f, -7.66513050e-02f, 2.14687865e-02f, -7.14728013e-02f, 7.05060661e-02f, -1.27503471e-02f, -2.36622710e-02f, -1.70918589e-03f,
  -2.57666316e-03f, -4.25511375e-02f, -1.68338995e-02f, -1.18300468e-02f, -4.93408693e-03f, 1.23257348e-02f, 1.12579782e-02f, 5.52538894e-02f, -4.53115674e-03f, -1.96398050e-02f,
  4.08720821e-02f, -1.34938834e-02f, 4.97904122e-02f, -1.31310597e-02f, 5.93332155e-03f, 2.07817424e-02f, 1.12590594e-02f, 4.85495180e-02f, -1.74420439e-02f, -1.35699101e-02f,
  3.76472026e-02f, -1.92160502e-01f, 4.67365757e-02f, -2.71178456e-03f, 1.58915296e-02f, -2.38133501e-02f, 3.18037271e-02f, -1.36266313e-02f, 7.87441954e-02f, 3.87631133e-02f,
  -6.79577962e-02f, -4.43010181e-02f, 7.24849757e-03f, -1.55839780e-02f, 4.47014682e-02f, 1.95909627e-02f, 3.25915702e-02f, -1.97981223e-02f, -4.69486117e-02f, -6.05091602e-02f,
  -4.37106565e-02f, 1.40485764e-02f, -8.68663751e-03f, -3.69675346e-02f, -7.61484588e-03f, -1.97959542e-02f, -8.60649198e-02f, -5.81422879e-04f, 1.65738668e-02f, 8.26419331e-03f,
  -2.18159497e-01f, 1.25278756e-01f, -4.36800748e-01f, 2.33915448e-01f, -5.93106337e-02f, 3.29566076e-02f, -1.44907191e-01f, 9.96320769e-02f, 3.41762342e-02f, 2.53273994e-01f,
  9.28942412e-02f, -4.04258352e-03f, -9.70680192e-02f, 2.95463771e-01f, -1.35711178e-01f, 8.67366195e-02f, 1.35702610e-01f, 1.32900506e-01f, -1.16434999e-01f, 5.89995608e-02f,
  -9.74106863e-02f, 2.57312894e-01f, -8.69845077e-02f, 1.02391213e-01f, 1.04621025e-02f, -6.44278228e-02f, 8.96764174e-02f, -1.83848396e-01f, 1.66337013e-01f, 3.22422124e-02f,
  -1.04165703e-01f, -1.36628792e-01f, -5.66375405e-02f, -3.25237252e-02f, -2.24402081e-02f, -8.57241377e-02f, 1.56040126e-02f, -7.22550303e-02f, -8.05497840e-02f, -5.93238370e-03f,
  -3.46291275e-03f, -5.51731326e-02f, -1.80970579e-02f, -4.38533612e-02f, -5.65258488e-02f, 1.28023662e-02f, 1.27634313e-02f, 4.82443487e-03f, -2.83864867e-02f, -1.11861341e-01f,
  -2.04870403e-02f, 2.20875777e-02f, 4.20356318e-02f, 3.31534334e-02f, 2.55931634e-03f, -9.49574541e-03f, 2.85059381e-02f, -1.79870427e-02f, 8.08306411e-03f, 5.90491481e-02f,
  1.00131407e-02f, -4.66158390e-02f, 3.19918431e-02f, 2.85637192e-02f, -8.28376878e-03f, 2.99428068e-02f, 4.71652187e-02f, 1.69120934e-02f, -4.39119413e-02f, 4.35887016e-02f,
  6.97454736e-02f, 9.54706129e-03f, 6.40007630e-02f, -1.36018107e-02f, 6.46182476e-03f, 7.42612332e-02f, -3.93655337e-02f, 9.17962715e-02f, 2.19237972e-02f, 4.43874896e-02f,
  -4.46213828e-03f, 3.24704987e-03f, 3.04507818e-02f, 1.65046658e-02f, 2.27054749e-02f, -1.76322050e-02f, 2.69080214e-02f, 3.05571891e-02f, 8.32803361e-03f, -1.14067430e-02f,
  1.61884770e-01f, 7.02915937e-02f, 3.00879143e-02f, 3.47189717e-02f, 6.99858880e-03f, 7.13828802e-02f, -7.69057963e-03f, 2.50046365e-02f, 2.46562175e-02f, 2.14563552e-02f,
  -1.51319336e-02f, -9.59116034e-03f, -1.11928326e-03f, 3.01624984e-02f, 7.16558546e-02f, -5.44909807e-03f, 1.67323090e-02f, 2.47324891e-02f, 8.84470567e-02f, -9.07318015e-03f,
  -6.49339473e-03f, 1.41906401e-03f, -2.40489244e-02f, -6.31108531e-04f, 3.04133464e-02f, 2.19211578e-02f, -1.30429445e-02f, -1.18367132e-02f, -3.62620922e-03f, -3.49367447e-02f,
  4.50239539e-01f, -7.36968871e-03f, -5.86535595e-02f, 2.67478585e-01f, 2.82537732e-02f, -7.74063095e-02f, -9.81249660e-03f, 7.24189281e-02f, -1.12872891e-01f, -4.78092209e-02f,
  4.43515964e-02f, 6.74522743e-02f, -4.10964154e-02f, 1.01464920e-01f, 4.29533124e-01f, -1.22488692e-01f, 2.18158156e-01f, 1.31718279e-03f, -2.53031570e-02f, 1.45295516e-01f,
  6.67649209e-02f, 2.82792270e-01f, 1.26146182e-01f, 1.34437338e-01f, 1.10490821e-01f, 3.01666232e-03f, 2.32179463e-01f, -4.17492278e-02f, 2.07115665e-01f, 2.47854665e-02f,
  -3.13291699e-02f, -1.47647619e-01f, 3.17577682e-02f, -2.99411099e-02f, 4.60197637e-03f, 5.93077112e-03f, -9.28317662e-03f, 2.17076018e-02f, -7.41276145e-03f, 2.69675199e-02f,
  4.46970994e-03f, 1.41750835e-02f, -2.60301530e-02f, 9.44592990e-03f, -5.87421060e-02f, -3.63602536e-03f, -5.26489541e-02f, -3.74008976e-02f, -5.59632592e-02f, -2.15004142e-02f,
  -5.18679470e-02f, -7.60297403e-02f, -1.59684252e-02f, 1.53353084e-02f, 7.96960387e-03f, -4.16894071e-02f, -1.20105231e-02f, -1.81495473e-02f, -7.91184083e-02f, 3.77615690e-02f,
  6.69798627e-02f, 1.81078818e-02f, 1.13644395e-02f, 4.07782122e-02f, 4.70525883e-02f, 1.41871450e-02f, 1.31338788e-02f, 3.07965055e-02f, -4.54681516e-02f, 5.00859320e-02f,
  2.67294291e-02f, -2.28327718e-02f, -1.97561961e-02f, -2.12067477e-02f, 3.01643391e-03f, 9.90509521e-03f, 1.51930572e-02f, -2.07057428e-02f, -1.26286661e-02f, -2.60002576e-02f,
  1.42216366e-02f, -2.16825511e-02f, 3.70634720e-02f, 1.55817037e-02f, -2.12196773e-03f, 1.13137104e-02f, 2.95207109e-02f, -3.11664063e-02f, -7.58493552e-03f, 3.42057794e-02f,
  9.26879495e-02f, 2.86149710e-01f, 1.43271396e-02f, -1.65008232e-02f, -1.91132370e-02f, 2.36755162e-02f, 2.85725500e-02f, 3.97683531e-02f, 2.41189916e-03f, -3.25099565e-03f,
  -7.17707863e-03f, -2.19180118e-02f, 3.63954008e-02f, -1.34340525e-02f, 4.22377586e-02f, 2.63906196e-02f, 3.67145687e-02f, 2.34373962e-03f, 8.75300840e-02f, 5.49216121e-02f,
  4.02989425e-03f, 6.11183941e-02f, 3.30431126e-02f, -5.22044394e-03f, -1.49546620e-02f, 2.58323401e-02f, -1.16607137e-02f, -2.16495972e-02f, 4.63579781e-02f, -3.48679759e-02f
};

// L0_fan_Wp_bar (Shape: 4 x 120)
const int L0_fan_Wp_bar_rows = 4;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  2.88798362e-01f, -1.39696687e-01f, -2.09999919e-01f, -2.56551445e-01f, -1.04590327e-01f, -1.86494827e-01f, -1.56830505e-01f, -2.57054478e-01f, -2.34509096e-01f, -1.08621322e-01f,
  -1.28773907e-02f, 8.63408521e-02f, 2.41413504e-01f, -3.02337468e-01f, 4.79154915e-01f, 2.55903661e-01f, -1.71960101e-01f, -1.17140703e-01f, -6.81879818e-02f, -1.97190002e-01f,
  -4.08870131e-02f, -2.56903291e-01f, 1.20897621e-01f, -2.42427468e-01f, -2.30137020e-01f, -1.16961963e-01f, 2.27951840e-01f, 1.86474808e-02f, -1.61829218e-01f, 8.84736255e-02f,
  -4.45785234e-03f, -6.01653848e-03f, 5.86831495e-02f, 4.36135344e-02f, -9.24351737e-02f, -9.99079347e-02f, 1.54003222e-02f, 9.97400656e-02f, -1.85778160e-02f, 5.92383044e-03f,
  1.47923380e-02f, 1.54300993e-02f, -1.02299891e-01f, -1.68253612e-02f, -1.00026295e-01f, -4.65716496e-02f, -5.32119162e-03f, -8.80075991e-02f, -3.38714407e-03f, -7.47822970e-03f,
  1.49787301e-02f, 1.54927460e-04f, -8.47055390e-02f, 7.34697375e-03f, 3.07418648e-02f, -6.13174476e-02f, 2.12615728e-02f, 9.87709314e-02f, -6.30043820e-03f, -6.72756806e-02f,
  -6.25215890e-03f, -3.70247737e-02f, -1.04065677e-02f, -2.67997440e-02f, 1.79502834e-02f, -2.39150021e-02f, -2.91604567e-02f, 3.07059847e-02f, -1.71411112e-02f, 2.74981634e-04f,
  -2.93292571e-02f, 2.13107392e-02f, -1.83263421e-02f, -6.06388710e-02f, -5.99152148e-02f, 3.94868199e-03f, 4.23540920e-02f, 1.94864329e-02f, -5.33382110e-02f, 3.25858733e-03f,
  4.22476567e-02f, -1.43293263e-02f, -4.39209267e-02f, 7.67429918e-03f, -2.13620290e-02f, 3.91106531e-02f, -2.80883368e-02f, 3.80926132e-02f, -6.39138510e-03f, 6.06672019e-02f,
  -1.22954287e-01f, -2.49407485e-01f, -8.49224031e-02f, -1.46859298e-02f, 7.95077980e-02f, 6.79670647e-02f, -2.87741497e-02f, -8.33185110e-03f, -4.26812880e-02f, -4.56276583e-03f,
  -8.85151401e-02f, -1.47075607e-02f, -1.25366226e-02f, -2.72891447e-02f, 3.75382379e-02f, -8.87795240e-02f, 3.95296887e-03f, -2.37567886e-03f, -5.50889745e-02f, -5.56513257e-02f,
  -2.09212787e-02f, 5.56196049e-02f, 3.46805453e-02f, 1.64190978e-02f, -5.17251249e-03f, 6.15215413e-02f, 2.98821670e-03f, -4.59120572e-02f, 2.34078504e-02f, -5.35032563e-02f,
  2.15395942e-01f, 3.38761598e-01f, -1.68567136e-01f, -1.68134913e-01f, 7.80392578e-03f, 4.31232035e-01f, 6.88305050e-02f, -4.66775931e-02f, -1.59179956e-01f, 2.05116063e-01f,
  6.50601014e-02f, 6.52688295e-02f, 1.01361386e-01f, 1.48811787e-01f, 1.15792274e-01f, 2.85050780e-01f, 1.17045030e-01f, 1.63165540e-01f, 4.79799993e-02f, 5.77773117e-02f,
  -1.17917210e-01f, 2.39861831e-01f, 4.89359088e-02f, 9.65631679e-02f, 4.88765053e-02f, -5.84329851e-02f, -1.15834385e-01f, -5.45388795e-02f, -4.87855524e-02f, 7.43103921e-02f,
  4.51244302e-02f, 9.73501429e-02f, -6.60650283e-02f, -5.43629155e-02f, 6.85753897e-02f, -6.80946931e-02f, -7.63102770e-02f, 2.83523686e-02f, -7.51293898e-02f, -9.54558924e-02f,
  3.94516475e-02f, -1.23622047e-03f, 8.52848217e-02f, 4.16201577e-02f, 2.49634050e-02f, -7.18293414e-02f, -2.42159497e-02f, 6.68788776e-02f, -1.47004230e-02f, 5.77579550e-02f,
  -1.54047310e-02f, 1.89814456e-02f, 3.42272930e-02f, 2.11968012e-02f, -1.29427895e-01f, 6.04598746e-02f, 5.79215661e-02f, -5.97892739e-02f, -2.32889708e-02f, 1.04927728e-02f,
  3.39031890e-02f, -4.92582284e-02f, 3.79688926e-02f, -3.95982154e-02f, 1.03486471e-01f, 5.89050911e-03f, 7.09934831e-02f, -3.74893025e-02f, -6.37812819e-03f, 7.20239878e-02f,
  -4.93329577e-02f, -6.13692887e-02f, -2.93575637e-02f, -1.08901635e-02f, -7.47264847e-02f, -2.70482269e-03f, 8.66026711e-03f, -5.07036448e-02f, -6.74171597e-02f, -7.20042512e-02f,
  -3.38246003e-02f, -4.33259122e-02f, 8.93995108e-04f, -5.57884537e-02f, -9.44751687e-03f, -1.07488088e-01f, -1.50197791e-02f, -1.40846539e-02f, -5.03046922e-02f, -3.22461352e-02f,
  2.98166037e-01f, 1.42914951e-01f, 3.80680221e-03f, -5.57142273e-02f, -6.47928715e-02f, 8.60506017e-03f, -5.01356535e-02f, 4.69869375e-02f, -5.85453324e-02f, -2.25078035e-02f,
  1.82963777e-02f, 4.18967120e-02f, 3.30854282e-02f, -4.09130566e-02f, -8.30111727e-02f, 8.51723924e-02f, -3.54931802e-02f, -5.59657924e-02f, -1.82827394e-02f, -3.81005108e-02f,
  6.35938020e-03f, -2.63645258e-02f, 9.20622796e-03f, -1.77152138e-02f, -1.23702614e-02f, 9.79236793e-03f, -1.32953133e-02f, -2.43926849e-02f, -6.81035873e-03f, -4.74511012e-02f,
  -4.94510047e-02f, 6.05933070e-02f, 1.89069986e-01f, -4.60498258e-02f, -1.48291374e-02f, 1.71148434e-01f, 2.48412848e-01f, 8.80515203e-02f, 2.64636338e-01f, 8.32339227e-02f,
  8.79482850e-02f, 1.83102325e-01f, 1.63584337e-01f, -1.08187497e-02f, 1.73065767e-01f, 5.15599661e-02f, 1.81003734e-02f, 1.02672897e-01f, 5.23490161e-02f, -2.48314980e-02f,
  -2.66691856e-02f, -2.74605937e-02f, -1.85625628e-01f, -2.17443004e-01f, -1.95456058e-01f, -1.48343220e-01f, -1.96229264e-01f, -1.90988407e-02f, -8.50622356e-02f, 2.34570522e-02f,
  -1.30234227e-01f, -7.31623471e-02f, -6.16127774e-02f, 1.18892610e-01f, 4.30049337e-02f, 1.16883786e-02f, 1.98813621e-02f, 3.66914235e-02f, 4.35921736e-02f, 8.46917555e-02f,
  2.86224708e-02f, -5.58259450e-02f, -1.56687980e-03f, 2.40655746e-02f, -1.59910582e-02f, -3.80339921e-02f, -4.11001071e-02f, -8.40146020e-02f, 6.85377941e-02f, -7.55384117e-02f,
  -2.98723988e-02f, 5.02749160e-03f, -4.92910184e-02f, 3.37002911e-02f, 4.21122238e-02f, 3.46456394e-02f, -7.13198856e-02f, 9.58226845e-02f, 4.55709733e-02f, 7.11588860e-02f,
  8.15117732e-03f, 6.66269809e-02f, -5.74665405e-02f, -4.59267795e-02f, -4.51122746e-02f, -1.32334292e-01f, -6.84942827e-02f, -2.34943833e-02f, 4.35948297e-02f, -9.19524133e-02f,
  4.45170281e-03f, 3.64448293e-03f, 1.82663277e-02f, -1.36556150e-03f, 5.60145378e-02f, 1.34518677e-02f, 2.56212130e-02f, 2.52384152e-02f, -1.21434703e-02f, 2.36573480e-02f,
  -1.26193929e-02f, -1.18179210e-02f, -3.52742188e-02f, -1.78317688e-02f, 2.10066959e-02f, -1.16767362e-02f, 9.33599006e-03f, -3.88401970e-02f, 8.80776625e-03f, 5.55282049e-02f,
  2.34727979e-01f, 2.99058229e-01f, 5.98980114e-02f, 3.35958228e-02f, 1.99777670e-02f, -6.89902855e-03f, 1.82858799e-02f, -6.17745034e-02f, 1.27971783e-01f, 9.96845141e-02f,
  -8.94741639e-02f, -2.77583171e-02f, -5.70108406e-02f, -2.75765453e-02f, -1.59150232e-02f, 7.62148714e-03f, 4.36153524e-02f, 6.81152344e-02f, -5.60045149e-03f, 3.77088762e-03f,
  -4.73053753e-02f, 3.32592730e-03f, -1.65398102e-02f, -7.99032599e-02f, 9.34048183e-03f, -8.41427892e-02f, -2.57473788e-03f, -4.91990261e-02f, -2.88731717e-02f, -8.74369964e-03f,
  3.07918340e-01f, 1.07562996e-01f, 6.44199923e-02f, 1.21120557e-01f, -2.06624314e-01f, -2.20253766e-01f, -9.95753706e-02f, -1.27838895e-01f, -1.82836071e-01f, -7.39056841e-02f,
  1.10864542e-01f, -1.05717942e-01f, 2.67716497e-01f, 1.19362749e-01f, 9.72135887e-02f, 1.31304279e-01f, 1.32495403e-01f, -1.37414383e-02f, 2.38889251e-02f, 2.14945659e-01f,
  8.32300037e-02f, 8.01296458e-02f, 2.99773067e-01f, 1.07759938e-01f, 3.69445682e-02f, -5.46024041e-03f, 1.27588645e-01f, 8.05839002e-02f, 3.45644467e-02f, -9.77268293e-02f,
  9.24819484e-02f, 1.35551721e-01f, -4.91275564e-02f, 6.94703311e-02f, 5.87974563e-02f, -4.35766988e-02f, 3.07229403e-02f, -1.10252784e-03f, 1.21045327e-02f, 4.86256462e-03f,
  1.42976912e-02f, 4.27932888e-02f, -1.07313313e-01f, -9.32190474e-03f, -5.79774454e-02f, -4.12061773e-02f, -1.71895251e-02f, -6.73977984e-03f, 2.30833720e-02f, 6.34403080e-02f,
  -5.47703616e-02f, 5.78250438e-02f, 3.03271748e-02f, 1.32967317e-02f, -3.35815176e-02f, -1.70701556e-02f, -8.62231106e-02f, -2.01290715e-02f, -7.49660730e-02f, -1.86151974e-02f,
  -9.00168158e-03f, 2.17684042e-02f, 2.51988843e-02f, -1.07763708e-02f, -4.06969525e-02f, 3.76070999e-02f, -3.83928907e-03f, -2.86882576e-02f, 2.21240912e-02f, -2.50721760e-02f,
  1.63961723e-02f, -4.80506644e-02f, -8.68612230e-02f, 6.75523952e-02f, 3.98163758e-02f, 4.15046625e-02f, 1.44768776e-02f, -1.31131351e-01f, 2.17475425e-02f, -6.65645301e-02f,
  -2.64223441e-02f, -9.34416149e-03f, -3.94753031e-02f, 7.24073453e-03f, -4.74762870e-03f, -5.43895178e-02f, -5.96445845e-03f, -9.41402018e-02f, -2.31163185e-02f, 3.57372425e-02f,
  -5.41555472e-02f, 1.74125016e-01f, -1.38066877e-02f, -8.88702795e-02f, 1.19438050e-02f, 1.66691337e-02f, 3.41142863e-02f, -5.74041680e-02f, 8.54822025e-02f, 5.47092780e-02f,
  1.43141961e-02f, -2.21980270e-02f, 2.33690329e-02f, 1.22626275e-02f, 1.43639958e-02f, 1.47835305e-02f, 5.42112738e-02f, -6.11837097e-02f, -1.05884507e-01f, 2.93880701e-03f,
  6.86364919e-02f, -2.80212890e-02f, -1.70610636e-03f, -8.78085196e-03f, -3.73136858e-03f, 1.64181530e-03f, -2.52386704e-02f, 1.60185155e-02f, -2.05489327e-04f, -3.37035358e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 4)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 4;
const float L0_fan_Bp_bar_data[] = {
  1.10216022e-01f, -8.25727358e-02f, 2.80178003e-02f, -9.19486955e-03f
};

// L1_fan_Wp (Shape: 6 x 16)
const int L1_fan_Wp_rows = 6;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  -1.57870770e-01f, -3.48068476e-01f, -6.64267242e-01f, -1.80148244e-01f, 1.19199984e-01f, -2.02553526e-01f, -3.31791610e-01f, 2.41417840e-01f, -6.60319328e-01f, 3.64244264e-03f,
  -1.48140445e-01f, -3.43320429e-01f, 3.12020063e-01f, -3.54835361e-01f, -3.05048585e-01f, 2.84043163e-01f, -1.28622994e-01f, -4.76147920e-01f, 1.66434139e-01f, -1.86916497e-02f,
  5.49203813e-01f, 6.14671469e-01f, 1.65155485e-01f, 5.73540270e-01f, -2.23475173e-01f, -2.93557584e-01f, -3.30966741e-01f, -3.65971923e-01f, -2.92950064e-01f, -1.18273593e-01f,
  2.65310436e-01f, -1.77468628e-01f, -3.02964389e-01f, 2.68203914e-01f, 1.22250289e-01f, 2.78051674e-01f, 2.86362935e-02f, 2.28897296e-03f, 6.34472668e-01f, -2.54135042e-01f,
  2.76160091e-01f, 3.92075002e-01f, 5.69709301e-01f, -2.27695890e-02f, -1.81331336e-01f, 2.63610594e-02f, 1.91347942e-01f, -5.18762052e-01f, 3.22497874e-01f, 3.47582877e-01f,
  1.04442738e-01f, -1.31125584e-01f, -3.99849415e-01f, 2.02527523e-01f, 6.23880923e-01f, 4.26530659e-01f, 1.26717910e-01f, 2.22269967e-01f, -5.10989968e-03f, 5.39065361e-01f,
  2.57503450e-01f, 4.73055333e-01f, 4.77463424e-01f, 1.07272156e-01f, -1.34435534e-01f, 1.23144954e-01f, 5.19299686e-01f, -3.36122304e-01f, -3.90103579e-01f, -1.46595448e-01f,
  7.25204051e-02f, -6.15397215e-01f, 1.44344628e-01f, -7.01580703e-01f, 1.77093595e-01f, 1.71034649e-01f, -1.81914702e-01f, -2.11224943e-01f, -2.72910595e-01f, 3.60188603e-01f,
  -1.71052709e-01f, 4.69211638e-01f, 2.81976372e-01f, -1.19329721e-01f, -1.92307204e-01f, -5.91694057e-01f, -2.22905919e-01f, -6.13466442e-01f, 3.23955491e-02f, 4.55574453e-01f,
  2.76654661e-01f, 1.75695240e-01f, -3.03290337e-01f, 1.89003140e-01f, 2.17364952e-01f, 4.01621521e-01f
};

// L1_fan_Wp_bar (Shape: 4 x 16)
const int L1_fan_Wp_bar_rows = 4;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  1.80511400e-01f, 3.17220718e-01f, -4.03857499e-01f, 1.89100549e-01f, -1.83868706e-01f, 2.30930030e-01f, 1.66015804e-01f, 1.88379496e-01f, 1.68784425e-01f, 2.08762094e-01f,
  -3.90283763e-01f, 2.10812837e-01f, 7.98993528e-01f, 9.61619839e-02f, 1.25138775e-01f, 3.26194018e-02f, -2.80126721e-01f, -3.26206326e-01f, 1.23778768e-01f, 1.63655102e-01f,
  2.58216381e-01f, -4.55546230e-02f, 2.30201155e-01f, 2.24791124e-01f, 1.96725696e-01f, -2.01760545e-01f, -1.35466784e-01f, 2.19148338e-01f, -2.06445381e-01f, -1.50271833e-01f,
  -1.10435896e-01f, -2.59359568e-01f, -1.83021918e-01f, 2.62427386e-02f, 5.33208013e-01f, 1.64730206e-01f, 3.92325610e-01f, -3.02821398e-01f, -1.88247580e-02f, -3.36180121e-01f,
  -3.15213501e-01f, -8.96093011e-01f, 2.79064596e-01f, 4.20906901e-01f, -1.40744165e-01f, -5.01171410e-01f, -3.27094853e-01f, 8.89270678e-02f, -1.12232246e-01f, -1.83019623e-01f,
  1.29651397e-01f, -3.51202309e-01f, -1.29184529e-01f, -5.33998981e-02f, -4.88743819e-02f, -2.35430688e-01f, -1.18729942e-01f, -1.99482247e-01f, 1.26153588e-01f, 2.89567653e-02f,
  -2.34880507e-01f, -1.03910200e-01f, 1.61659017e-01f, 2.28476271e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 4)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 4;
const float L1_fan_Bp_bar_data[] = {
  8.11638162e-02f, -4.82926182e-02f, 5.46255469e-01f, 7.10790753e-02f
};

// L2_fan_Wp (Shape: 6 x 16)
const int L2_fan_Wp_rows = 6;
const int L2_fan_Wp_cols = 16;
const float L2_fan_Wp_data[] = {
  -6.88074589e-01f, -2.63733882e-02f, -5.46562076e-01f, 4.75326478e-01f, -3.29164505e-01f, -2.35345572e-01f, -2.67768085e-01f, -5.06322324e-01f, -3.54583450e-02f, 7.82778203e-01f,
  4.10357684e-01f, 6.73851609e-01f, 4.70778272e-02f, 9.53483731e-02f, -1.66766822e-01f, -8.25601965e-02f, 5.84489524e-01f, 1.61488175e-01f, 2.79113948e-01f, 5.55780947e-01f,
  1.20259807e-01f, 5.11481285e-01f, -7.45470405e-01f, 7.99733222e-01f, -1.95156202e-01f, -1.59698218e-01f, -2.07222432e-01f, -7.17300117e-01f, -2.57549256e-01f, 2.65980124e-01f,
  -2.09524751e-01f, 1.54106393e-01f, -4.06002820e-01f, -3.51656944e-01f, -6.12348974e-01f, -8.02670479e-01f, 3.87365557e-03f, -6.27114534e-01f, 3.17416072e-01f, -1.02989348e-02f,
  7.15000834e-03f, 9.68043685e-01f, -4.58965838e-01f, 1.49687734e-02f, 3.21155161e-01f, 1.94100067e-01f, -4.24539894e-01f, -1.79240294e-02f, -2.71241665e-01f, -1.38743713e-01f,
  -1.18049100e-01f, 3.44782233e-01f, -4.14871007e-01f, 3.52873683e-01f, -5.41420102e-01f, -5.53666115e-01f, 3.50236535e-01f, 7.82055631e-02f, 9.44211662e-01f, 9.02732551e-01f,
  -2.94659197e-01f, -1.37981862e-01f, 2.58580357e-01f, 3.86977404e-01f, 3.24999362e-01f, 1.62268266e-01f, 3.23549032e-01f, 6.56242788e-01f, 6.96680918e-02f, 1.95115089e-01f,
  8.89242351e-01f, 2.34894395e-01f, -4.60180998e-01f, -8.29603732e-01f, -7.51159787e-01f, 6.38478063e-03f, -6.03735149e-02f, -1.19117051e-01f, 2.59470999e-01f, -1.14120476e-01f,
  -5.05296946e-01f, -8.28655362e-01f, -7.09923863e-01f, -1.22492403e-01f, -4.34015095e-01f, -5.53230286e-01f, 4.71171066e-02f, -4.21373457e-01f, -8.17039073e-01f, 1.62155122e-01f,
  4.08166796e-01f, -3.00711244e-01f, 5.72109744e-02f, 2.46202320e-01f, 3.05365652e-01f, -1.22201785e-01f
};

// L2_fan_Wp_bar (Shape: 4 x 16)
const int L2_fan_Wp_bar_rows = 4;
const int L2_fan_Wp_bar_cols = 16;
const float L2_fan_Wp_bar_data[] = {
  -6.74618185e-02f, 4.60545629e-01f, 4.75387156e-01f, 1.85642332e-01f, -6.12831831e-01f, 3.09372574e-01f, -5.64229131e-01f, -2.42555439e-01f, 1.97811171e-01f, -4.92557168e-01f,
  9.09133673e-01f, 5.27933121e-01f, -2.46659979e-01f, -1.68191582e-01f, 1.01073349e+00f, 3.61770362e-01f, -5.75513653e-02f, 2.13890765e-02f, -8.22607428e-03f, 4.00982261e-01f,
  6.42447829e-01f, 3.60367984e-01f, -3.24963897e-01f, -3.17255616e-01f, 4.72424060e-01f, 1.56815633e-01f, 1.34490520e-01f, 2.90042728e-01f, -1.10789031e-01f, 2.55183905e-01f,
  2.33877167e-01f, -2.13427737e-01f, -2.34903321e-01f, 4.22311783e-01f, 4.29451205e-02f, -2.71561354e-01f, 4.73536819e-01f, 6.93495452e-01f, -6.76413119e-01f, -5.26203454e-01f,
  8.86782229e-01f, 9.79095161e-01f, -3.28354776e-01f, 7.24853992e-01f, -5.88753298e-02f, -2.17713311e-01f, -4.24237937e-01f, 3.34513299e-02f, -2.21615797e-03f, 9.00356412e-01f,
  4.16719258e-01f, 3.29149485e-01f, 1.12454690e-01f, 2.35032782e-01f, 2.65574362e-02f, -6.67128384e-01f, -4.33927298e-01f, 5.87789118e-01f, -5.81995010e-01f, 5.70238158e-02f,
  8.69823396e-01f, -4.26003426e-01f, -6.06808722e-01f, -2.32325673e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 4)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 4;
const float L2_fan_Bp_bar_data[] = {
  3.15063775e-01f, 2.25038901e-01f, 8.06122839e-01f, 5.81391752e-02f
};

// L3_linear_W (Shape: 12 x 16)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 16;
const float L3_linear_W_data[] = {
  -3.08702737e-01f, 5.72798610e-01f, 8.22688699e-01f, -6.24998569e-01f, -3.40936393e-01f, -5.69058001e-01f, 8.90111744e-01f, -2.66384363e-01f, -7.36774564e-01f, 8.77689600e-01f,
  -8.75351071e-01f, -4.59266454e-01f, 1.14385292e-01f, 2.08224773e-01f, 6.32471919e-01f, 9.42936912e-03f, -5.81009313e-02f, -6.60375953e-01f, 7.31315389e-02f, 3.52072477e-01f,
  -5.93738377e-01f, 9.17750835e-01f, 8.75132442e-01f, -1.00218344e+00f, 4.84284580e-01f, 6.86732590e-01f, -8.86844695e-01f, 9.49687660e-01f, -3.87303501e-01f, 3.32804322e-01f,
  6.99286938e-01f, 4.85974438e-02f, 1.44412726e-01f, 2.61190563e-01f, -8.94156694e-01f, -4.81098980e-01f, 6.01735651e-01f, 1.55823052e-01f, 6.93578184e-01f, 3.92311737e-02f,
  -4.54248101e-01f, 4.15741205e-01f, -9.28499281e-01f, -1.55700237e-01f, 7.89302528e-01f, 3.99054736e-01f, 5.49009675e-03f, -6.05260491e-01f, -6.41947389e-01f, 8.62381995e-01f,
  -8.12793970e-01f, 1.04690409e+00f, -1.10048199e+00f, -1.07189786e+00f, -4.96878594e-01f, 6.13026135e-02f, -9.04150784e-01f, -3.53490770e-01f, 6.52573586e-01f, 3.19560841e-02f,
  1.15256989e-02f, 2.91866332e-01f, -3.31543684e-02f, -1.15013123e-01f, 4.39980209e-01f, -2.87741780e-01f, -1.42065063e-01f, 8.01130831e-01f, 6.54902101e-01f, -6.71528697e-01f,
  3.14398795e-01f, 5.00612795e-01f, -9.31371868e-01f, 3.24318558e-01f, 7.01651275e-01f, 1.75811991e-01f, -3.60266298e-01f, 3.03695321e-01f, 6.25690222e-01f, 6.34740591e-01f,
  6.45754874e-01f, 5.41305423e-01f, 7.10237026e-01f, 1.31732142e+00f, 4.40902025e-01f, -4.29105520e-01f, 2.56847113e-01f, 2.44665906e-01f, 1.01393390e+00f, -2.29648888e-01f,
  -8.13756466e-01f, -4.56635892e-01f, -4.38010454e-01f, -2.20935926e-01f, 9.32833791e-01f, -3.28901768e-01f, 3.23773563e-01f, -9.12264764e-01f, 7.64264941e-01f, 3.83303165e-01f,
  1.16585255e+00f, 3.86403650e-01f, -6.75064087e-01f, 5.15008330e-01f, -4.68364060e-01f, -1.38709617e+00f, 5.79173803e-01f, -3.98663104e-01f, -3.73027980e-01f, 3.71889502e-01f,
  -3.66903245e-01f, -6.20431125e-01f, 2.19653010e-01f, -8.67418796e-02f, 5.28912693e-02f, -7.78811216e-01f, 3.73012051e-02f, 3.91434252e-01f, 7.15550780e-01f, -8.74659181e-01f,
  1.05848825e+00f, -6.66595578e-01f, 5.56317151e-01f, 8.29717577e-01f, -3.33983004e-01f, -1.74282104e-01f, -5.50615251e-01f, 1.02587521e+00f, 4.59864169e-01f, 2.68165320e-01f,
  -8.38092923e-01f, -7.35639691e-01f, 2.14639768e-01f, 2.36618161e-01f, 3.11138779e-01f, -3.29777420e-01f, -2.90375769e-01f, 8.66180003e-01f, 5.50432146e-01f, 9.10128176e-01f,
  1.07784426e+00f, -4.41461951e-01f, -1.05891716e+00f, -2.52479941e-01f, -1.69060275e-01f, -3.71301696e-02f, 7.05161691e-01f, -8.65727305e-01f, 7.67819405e-01f, -2.65651941e-01f,
  -5.38573861e-01f, 5.96186757e-01f, 8.60637486e-01f, -5.49758852e-01f, -2.26375759e-01f, -3.88703793e-01f, -5.39496958e-01f, -4.86860067e-01f, 1.64335445e-01f, 7.62436867e-01f,
  -6.98930860e-01f, -3.54512960e-01f, -1.06456983e+00f, 8.62425804e-01f, 4.20262456e-01f, -1.30357623e-01f, -6.01137757e-01f, 6.87734783e-01f, 5.03947914e-01f, 1.02600157e+00f,
  4.35205251e-01f, -5.15877187e-01f, 8.60574007e-01f, 6.02476262e-02f, -5.95187545e-01f, -2.15760097e-01f, -1.01104665e+00f, -3.54540318e-01f, 3.28285307e-01f, -1.01696730e+00f,
  -1.35759711e+00f, 6.09800756e-01f, -6.56778932e-01f, 3.05729210e-01f, -7.77557313e-01f, -8.50816548e-01f, 4.07075524e-01f, -1.14964344e-01f, -4.05722797e-01f, -4.22371298e-01f,
  -8.32299590e-01f, -2.86037177e-01f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  -3.74841839e-01f, 1.99152395e-01f, -2.84220427e-01f, 3.55073810e-01f, -1.40488327e-01f, -2.62949318e-01f, 5.40098608e-01f, -3.63560505e-02f, -2.36254513e-01f, 3.72802727e-02f,
  -1.97238863e-01f, 5.21627665e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 4
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 6, 4
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        16, 6, 4
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        16, 12
    );
    }
    