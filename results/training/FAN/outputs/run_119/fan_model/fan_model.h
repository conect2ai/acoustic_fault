/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 25 x 120)
const int L0_fan_Wp_rows = 25;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  4.68972236e-01f, 6.69451803e-02f, 3.18378776e-01f, 1.85227200e-01f, 8.97909179e-02f, 2.01816097e-01f, 2.51530353e-02f, 1.01442769e-01f, 1.48149818e-01f, -9.93691161e-02f,
  -1.20989755e-01f, 1.15062088e-01f, -2.69229889e-01f, 1.43546034e-02f, 2.24478915e-01f, -2.43411720e-01f, 1.65209234e-01f, 6.26790002e-02f, -6.23824149e-02f, 9.56478342e-02f,
  8.01035538e-02f, -1.18381597e-01f, -1.39294453e-02f, -2.85794344e-02f, 1.56522334e-01f, 1.09910846e-01f, -4.85989526e-02f, -6.13079257e-02f, 9.10342261e-02f, 2.29587089e-02f,
  -1.26090236e-02f, -1.52060643e-01f, -4.55178646e-03f, -9.05997679e-02f, 2.28428226e-02f, -2.05675773e-02f, 9.07915607e-02f, -3.32848579e-02f, -8.06001127e-02f, -2.96725500e-02f,
  5.58761060e-02f, 4.49978784e-02f, -1.18482254e-01f, 3.72048840e-02f, 1.31615505e-01f, 5.82157001e-02f, 7.60191828e-02f, 1.50639087e-01f, -3.39567126e-03f, 3.09196021e-02f,
  -3.99301201e-03f, 7.02011958e-02f, 1.05044164e-01f, -6.27177162e-03f, 6.11353926e-02f, 1.84773728e-02f, 4.12054323e-02f, 6.08118735e-02f, -1.87678058e-02f, -2.87476648e-02f,
  -3.79037857e-02f, -6.82086572e-02f, 2.03380752e-02f, 1.30637772e-02f, 3.34331170e-02f, 1.39912842e-02f, 6.99589178e-02f, -2.15559602e-02f, 1.02887124e-01f, -6.03722828e-03f,
  3.69646885e-02f, 1.43795274e-02f, 4.89924662e-02f, 1.36947379e-01f, 9.20054130e-03f, 3.36545706e-03f, 4.96119857e-02f, -1.95717160e-02f, 4.03706953e-02f, 1.17243633e-01f,
  -3.19835320e-02f, 1.89191848e-02f, 1.48319863e-02f, 3.82442810e-02f, 3.49663831e-02f, 7.86942467e-02f, 3.43446201e-03f, 9.00066718e-02f, -5.39012067e-02f, -2.17153449e-02f,
  5.41368052e-02f, 7.42864935e-03f, -1.19671546e-01f, -3.06365755e-03f, -2.33319253e-02f, 1.86172109e-02f, -4.49833134e-03f, 1.29303902e-01f, 4.32417430e-02f, -2.61219330e-02f,
  9.98891667e-02f, -2.00880505e-02f, 1.49076208e-02f, 1.09869493e-02f, 4.95608933e-02f, 4.00432236e-02f, -6.98458031e-02f, 2.03515179e-02f, -5.45821674e-02f, 4.59838957e-02f,
  3.15639973e-02f, -4.82449196e-02f, 1.23222031e-01f, 1.90909058e-02f, 1.00256195e-02f, 6.84531629e-02f, 3.99804004e-02f, -3.84070575e-02f, -1.10226963e-02f, -1.27923608e-01f,
  -1.41596213e-01f, 8.28324482e-02f, -1.52494356e-01f, 9.31930169e-02f, -8.00282657e-02f, 7.09158927e-02f, -6.32970035e-02f, -1.97895896e-02f, -8.97784382e-02f, 2.36970335e-01f,
  1.93512902e-01f, -8.54852982e-03f, -3.53707075e-02f, 1.79679930e-01f, 1.35255292e-01f, -2.10757256e-01f, 1.98623985e-01f, 1.34279296e-01f, -2.01272026e-01f, -1.78362112e-02f,
  -3.78985666e-02f, 1.05414703e-01f, 1.49102896e-01f, 1.79601192e-01f, 9.32338089e-02f, 1.37635064e-03f, 2.33410567e-01f, 2.30139066e-02f, 2.74138153e-01f, 9.63157881e-03f,
  4.16071601e-02f, -1.01016149e-01f, -7.67906606e-02f, -1.93012819e-01f, 1.18833415e-01f, 4.88754585e-02f, -9.94320773e-03f, -1.72315046e-01f, -9.34189111e-02f, -1.65520072e-01f,
  6.43360149e-03f, -5.76910153e-02f, -2.59221848e-02f, -2.51807761e-03f, -2.54842881e-02f, -5.84751591e-02f, -1.15344906e-02f, 5.62974811e-02f, -7.98225328e-02f, 3.59765179e-02f,
  3.88114005e-02f, -3.46020199e-02f, 4.61548530e-02f, 8.29919998e-04f, -4.01081033e-02f, 3.69668044e-02f, -5.60747311e-02f, 3.02718896e-02f, -4.56882827e-03f, -2.29139756e-02f,
  -7.02768117e-02f, -5.98368756e-02f, -9.50052589e-03f, -2.77726408e-02f, -1.85764749e-02f, 4.87600639e-02f, 1.24495037e-01f, 3.57562900e-02f, 4.62314002e-02f, 9.11484808e-02f,
  1.34734660e-01f, 5.39796166e-02f, -9.87927243e-03f, 5.77622056e-02f, 2.75822580e-02f, 9.86650772e-03f, 6.39777407e-02f, -4.30166274e-02f, 8.24297294e-02f, 1.00955576e-01f,
  -3.90908569e-02f, 4.54758704e-02f, -1.42889181e-02f, 5.27808256e-02f, 1.18093014e-01f, -1.50718018e-01f, 6.27675354e-02f, -1.45755798e-01f, 4.02531661e-02f, 1.17985671e-02f,
  1.48669943e-01f, 1.35547712e-01f, -9.73103866e-02f, -1.16082415e-01f, -6.22760281e-02f, 5.51363407e-03f, -8.48001540e-02f, -1.56537816e-01f, -5.13101518e-02f, -1.41918719e-01f,
  4.04910296e-02f, -6.14507310e-03f, 8.84881467e-02f, -1.42136812e-02f, 4.08797823e-02f, 1.48101285e-01f, 7.71840364e-02f, 4.49953154e-02f, 5.27496077e-02f, 5.45603186e-02f,
  7.15605617e-02f, -6.75985441e-02f, -6.44156411e-02f, -3.54206818e-03f, 1.21797949e-01f, 1.78316161e-01f, 7.45141804e-02f, -2.31380407e-02f, 4.52929671e-04f, -5.87219968e-02f,
  1.99082792e-01f, 1.70793146e-01f, 9.10616368e-02f, 1.66728288e-01f, 1.98193565e-02f, -1.78592667e-01f, -2.44690254e-02f, 1.38038499e-02f, 3.39911401e-01f, -1.49454460e-01f,
  -1.35350063e-01f, 2.82262683e-01f, -9.49543864e-02f, -1.26283675e-01f, 9.98219326e-02f, 4.13254276e-02f, -1.75317585e-01f, -9.50563848e-02f, 1.60631046e-01f, 6.41279444e-02f,
  6.05756380e-02f, -1.27453670e-01f, 1.10398643e-02f, 1.44062350e-02f, -2.18349397e-01f, 4.69853394e-02f, -1.75317347e-01f, 6.24064133e-02f, -1.91097230e-01f, -5.14143035e-02f,
  -9.60012153e-02f, 1.84302330e-01f, -1.99693665e-02f, -1.87290888e-02f, 5.65262558e-03f, -5.74071072e-02f, -9.86133069e-02f, -1.71899144e-02f, 1.08867526e-01f, 3.80843282e-02f,
  -5.29089607e-02f, 1.37989027e-02f, 9.30514466e-03f, 6.15888946e-02f, 1.69293061e-02f, -3.99327464e-03f, 1.11651123e-02f, -1.67708453e-02f, 8.19863379e-02f, -5.76745383e-02f,
  6.20291941e-03f, -3.38719971e-02f, -9.37950164e-02f, -7.73805827e-02f, -1.73773617e-02f, -2.35466193e-02f, -8.68461467e-03f, -1.02244891e-01f, -3.43631804e-02f, 8.14837962e-02f,
  9.69408527e-02f, -3.34634893e-02f, -4.06912640e-02f, -1.02396227e-01f, -2.18264498e-02f, -1.08148634e-01f, -2.49943379e-02f, -5.56459352e-02f, -8.90108347e-02f, -4.05255035e-02f,
  -9.08016041e-02f, -7.55183622e-02f, -2.17572842e-02f, -9.27391425e-02f, -3.02935634e-02f, -1.94160491e-02f, -3.93359289e-02f, -8.88361931e-02f, 9.81433969e-03f, -1.34297404e-02f,
  1.25302315e-01f, -7.85767287e-03f, -3.28168012e-02f, -1.27260476e-01f, -6.11962862e-02f, 1.08106639e-02f, -4.46209833e-02f, 4.63711321e-02f, -2.94791870e-02f, -3.18562309e-03f,
  -7.50318691e-02f, 1.49077430e-01f, -4.24397253e-02f, 1.45013332e-02f, 5.27865216e-02f, -2.18595378e-02f, 9.17760655e-02f, -8.49833414e-02f, 1.35865360e-01f, -4.75063082e-03f,
  -4.91441265e-02f, -1.98076531e-01f, 9.00162309e-02f, -2.86383275e-03f, 5.39165884e-02f, -3.26822065e-02f, 3.85395400e-02f, -1.99510586e-02f, 1.21317640e-01f, -8.97196122e-04f,
  -5.96738933e-03f, -1.91063397e-02f, -6.02396391e-02f, -3.21340077e-02f, -1.25727743e-01f, -4.63824607e-02f, 7.70791173e-02f, -3.86551069e-03f, -3.53545472e-02f, 6.77738637e-02f,
  8.21722150e-02f, -1.89000800e-01f, -1.90127715e-01f, 8.09011161e-02f, -7.52496570e-02f, 3.38845760e-01f, 2.65994161e-01f, -8.67825821e-02f, -1.18794598e-01f, 8.66575316e-02f,
  1.33204982e-02f, -2.01912820e-01f, -1.90684535e-02f, 6.42365019e-04f, 1.92643300e-01f, 1.03755377e-01f, 1.66037709e-01f, -2.39153728e-02f, 1.97639931e-02f, -9.86914150e-03f,
  1.19403198e-01f, 1.37559116e-01f, -1.10693939e-01f, -5.04811071e-02f, 4.42736000e-02f, -1.66087449e-01f, 4.30659428e-02f, -3.18035297e-02f, 7.90239312e-04f, -4.75309938e-02f,
  -1.10873030e-02f, -8.17421749e-02f, -7.52605870e-02f, 5.66981696e-02f, 7.31439292e-02f, 2.19562948e-02f, -4.16042805e-02f, -1.33831529e-02f, 1.56370297e-01f, 3.41692157e-02f,
  -6.53806329e-02f, -4.43589836e-02f, -3.07840109e-02f, -5.83355166e-02f, 1.77101046e-02f, -2.45582741e-02f, -6.28725663e-02f, -8.52457210e-02f, -8.27671066e-02f, -9.67838801e-03f,
  1.21081555e-02f, -4.93482985e-02f, 3.77953425e-02f, -7.55708758e-03f, -6.95483983e-02f, -4.03781347e-02f, 5.83200008e-02f, -2.29841154e-02f, 7.69925937e-02f, -4.50253226e-02f,
  -7.20812455e-02f, 6.55830726e-02f, 1.13962535e-02f, -3.62281278e-02f, 4.29922231e-02f, -2.58518588e-02f, -6.11407235e-02f, 5.41419312e-02f, 6.02039509e-03f, -1.59231434e-03f,
  -1.65816955e-03f, -1.42002806e-01f, -7.22803026e-02f, 7.62142166e-02f, 5.71443960e-02f, -5.88085279e-02f, -6.84503168e-02f, 7.03502148e-02f, 9.35714170e-02f, 1.39112892e-02f,
  7.11561367e-02f, 5.56303747e-02f, -1.54452743e-02f, 2.17204802e-02f, 2.94767879e-02f, 5.04047386e-02f, 5.68732545e-02f, 1.22332469e-01f, -7.78642669e-02f, 1.25167862e-01f,
  5.70143685e-02f, 5.29954210e-02f, -4.43955660e-02f, -5.19167297e-02f, -1.68949682e-02f, 7.54531026e-02f, -4.40409668e-02f, 3.02071664e-02f, 3.16035636e-02f, 6.59210309e-02f,
  -1.77581850e-02f, -3.35658230e-02f, 7.91790783e-02f, 6.79519400e-02f, -4.55668978e-02f, 2.44079977e-02f, 4.09452952e-02f, -4.36496697e-02f, 5.64571563e-03f, -1.02068976e-01f,
  3.72637175e-02f, 4.64907400e-02f, -4.91129570e-02f, 2.55018733e-02f, 3.37296240e-02f, -1.25305611e-03f, -2.03279331e-02f, -8.64592344e-02f, 4.04736362e-02f, 6.70619681e-02f,
  3.40713769e-01f, 7.66245201e-02f, 3.17617536e-01f, 1.10425115e-01f, -2.07996026e-01f, 1.94681525e-01f, 2.99519658e-01f, -9.42181721e-02f, 1.42094165e-01f, -3.96003090e-02f,
  -2.10210588e-02f, 3.23776640e-02f, -1.78385992e-02f, 1.57133073e-01f, 1.30099460e-01f, 1.72047570e-01f, 3.70731913e-02f, 5.67579083e-02f, -1.66079737e-02f, -4.59119864e-02f,
  3.91177014e-02f, -1.79541722e-01f, 1.71477690e-01f, -2.74848282e-01f, 7.57621080e-02f, 6.85948208e-02f, -1.56722218e-01f, 1.30576706e-02f, -9.40582678e-02f, -5.03586791e-02f,
  9.71066132e-02f, -2.71802414e-02f, 1.08500659e-01f, 6.54288009e-02f, 8.80206004e-03f, 1.43035740e-01f, 7.98923224e-02f, 6.81631342e-02f, -2.05641445e-02f, 3.45200337e-02f,
  -2.62657721e-02f, -6.15806952e-02f, -1.40494592e-02f, -1.18267676e-02f, -6.28583953e-02f, -4.82959561e-02f, -7.56509081e-02f, 4.43624035e-02f, 4.26515341e-02f, 7.41562769e-02f,
  6.04475364e-02f, 4.11364399e-02f, -5.51227620e-03f, -7.24094436e-02f, -5.93221523e-02f, -5.91491312e-02f, 6.43646270e-02f, 3.34639288e-02f, 7.96559360e-03f, -4.32378575e-02f,
  -9.96776372e-02f, 3.55129018e-02f, 6.14165813e-02f, 4.13219519e-02f, 2.50310749e-02f, 1.91409644e-02f, -3.72457993e-03f, -1.00956941e-02f, 3.21274553e-03f, -4.83071059e-02f,
  -4.11513597e-02f, 8.77463724e-03f, -9.69632529e-03f, -1.47829475e-02f, -3.17951217e-02f, 9.71244127e-02f, 8.60618129e-02f, -6.93271384e-02f, 8.22662637e-02f, 6.10610954e-02f,
  1.18912153e-01f, 6.74349256e-03f, 6.53873533e-02f, 8.97927862e-03f, 5.12351319e-02f, 4.70545255e-02f, -1.16464548e-01f, 1.31905992e-02f, 2.62904949e-02f, 3.59987840e-02f,
  -8.76643658e-02f, -1.90918639e-01f, 1.26494259e-01f, 1.24370530e-02f, 5.00634685e-02f, 3.53302285e-02f, 9.32329148e-02f, -1.28591117e-02f, -4.67635728e-02f, -4.33957539e-02f,
  -6.73903525e-02f, 2.11420469e-02f, 1.45587127e-03f, 3.54272537e-02f, -5.67645542e-02f, -3.80439311e-03f, -5.47949830e-03f, -4.60735001e-02f, 2.10773982e-02f, -3.03947404e-02f,
  -8.43446702e-02f, -9.86314416e-02f, -1.90452044e-03f, -1.09177135e-01f, -8.29251781e-02f, -6.60039559e-02f, 2.43242420e-02f, -9.25388709e-02f, -1.63298458e-01f, -1.16480878e-02f,
  3.94489378e-01f, -1.74421445e-01f, -1.22337922e-01f, 1.98462546e-01f, 8.21448788e-02f, -2.58672863e-01f, -3.82163860e-02f, 1.12709485e-01f, 1.16489083e-01f, -5.61964214e-02f,
  1.51238918e-01f, 9.75581631e-03f, 5.31274527e-02f, 1.48372486e-01f, 2.10703999e-01f, 1.36307642e-01f, 1.55622438e-01f, 1.00797312e-02f, 1.64472118e-01f, 1.60328463e-01f,
  1.26829505e-01f, 3.05485845e-01f, 1.05521277e-01f, 4.91361367e-04f, 7.47380182e-02f, 1.42510561e-02f, 4.41244245e-02f, -8.32011700e-02f, -5.46705462e-02f, 3.00288983e-02f,
  5.30882366e-02f, 2.02460840e-01f, 6.40855730e-02f, -1.03593335e-01f, 6.84348121e-02f, -7.18091205e-02f, -8.15069452e-02f, 3.21321026e-03f, 2.58217733e-02f, -4.85935155e-03f,
  -1.67363957e-01f, 5.16996235e-02f, 8.95071402e-02f, -4.73347865e-03f, -4.13162597e-02f, -1.09574787e-01f, -1.36566162e-02f, -5.36687374e-02f, 6.65057916e-03f, -7.96757918e-03f,
  -2.38436144e-02f, -2.84153875e-02f, -1.29064679e-01f, -4.94810343e-02f, -5.17014563e-02f, -5.77097423e-02f, 2.41002254e-02f, -1.10721305e-01f, -7.65436469e-03f, 3.42529975e-02f,
  -6.09989055e-02f, 6.12220727e-02f, 1.08993547e-02f, 4.16897908e-02f, 1.33739755e-01f, 8.91771317e-02f, 3.88196036e-02f, 2.56747287e-02f, 8.35897177e-02f, 2.78527429e-03f,
  1.51408873e-02f, 6.95912838e-02f, 6.99932873e-02f, -3.18895988e-02f, 7.99603760e-02f, 9.79701877e-02f, -1.61300544e-02f, -1.63348429e-02f, -5.53381182e-02f, -5.97525537e-02f,
  1.18454499e-02f, 5.19934781e-02f, 4.56003519e-03f, -3.59536968e-02f, 9.66543481e-02f, 4.21020128e-02f, -2.15707272e-02f, -4.84055169e-02f, 1.03247240e-01f, 5.11932699e-03f,
  1.71706732e-02f, 7.14519173e-02f, 5.39489873e-02f, 3.13726366e-02f, 1.98899638e-02f, 2.60633836e-03f, 3.73804085e-02f, -5.16824499e-02f, -6.55630082e-02f, 2.12677047e-02f,
  -1.56374946e-01f, 7.14097768e-02f, -2.20473558e-02f, 6.14100508e-02f, -5.66988811e-02f, -8.41272809e-03f, 4.39803600e-02f, 5.06115891e-02f, 7.56118074e-02f, -2.40649655e-02f,
  -1.41623795e-01f, 7.26997927e-02f, -1.19226836e-02f, 1.09645560e-01f, 2.07821019e-02f, -2.50897650e-02f, 3.35572548e-02f, -8.01992118e-02f, -1.06349014e-01f, -3.21489666e-03f,
  -4.31100458e-01f, 4.86253388e-02f, 3.31001848e-01f, -3.91429886e-02f, -1.93614632e-01f, -6.54508993e-02f, 1.34380266e-01f, -7.07213730e-02f, -2.54809052e-01f, -4.17991839e-02f,
  1.24871068e-01f, 1.31437093e-01f, 1.00339144e-01f, 1.41874433e-01f, 1.35815784e-01f, 9.04435664e-02f, -1.88629031e-01f, 6.22865185e-02f, 2.39941087e-02f, -1.96099989e-02f,
  -6.93316162e-02f, -2.18219444e-01f, 3.37577313e-01f, -1.01407118e-01f, 1.29788220e-02f, 1.07784666e-01f, -5.09808250e-02f, 1.54949203e-01f, -4.97396700e-02f, 1.27625376e-01f,
  1.12604462e-01f, 6.47169445e-03f, 3.01979911e-02f, -8.75939988e-03f, -6.88454658e-02f, -5.00220619e-02f, 1.58070713e-01f, 1.32614225e-01f, -1.37844933e-02f, -3.84144001e-02f,
  -7.61666000e-02f, -7.29562491e-02f, -3.07250861e-02f, -1.31295540e-03f, -1.04530543e-01f, -4.11210246e-02f, -8.50240439e-02f, 6.70693070e-02f, 5.72356582e-02f, -6.23523444e-02f,
  5.36106303e-02f, 6.69132778e-03f, -1.16491325e-01f, -5.63134737e-02f, 1.66957837e-03f, -1.09998398e-01f, 3.37393545e-02f, 1.71144083e-02f, -5.10642529e-02f, -1.01900809e-01f,
  -5.85178733e-02f, -6.26594797e-02f, -3.29105183e-02f, 4.24883626e-02f, -2.78598238e-02f, 6.59116283e-02f, -5.50607778e-03f, 5.97586110e-02f, -3.52845043e-02f, 5.50809205e-02f,
  -1.55386673e-02f, 3.16085741e-02f, 1.67870671e-02f, -9.69083165e-04f, -1.14753060e-01f, -2.63033882e-02f, 8.44032094e-02f, 3.08941100e-02f, -8.62853751e-02f, 6.92793652e-02f,
  6.78370893e-02f, 4.76944670e-02f, 6.43736646e-02f, 1.29984498e-01f, 5.71397282e-02f, -1.25440642e-01f, -2.88651511e-02f, 7.76048237e-03f, 7.21581876e-02f, -2.23420206e-02f,
  -2.69835768e-03f, -9.82850567e-02f, 9.18731764e-02f, 3.45539264e-02f, 5.05696647e-02f, -1.19704053e-01f, -8.03269595e-02f, -8.12380686e-02f, -8.57294202e-02f, -4.91752103e-02f,
  -1.39473826e-01f, 8.73254836e-02f, -2.08484810e-02f, 2.24612132e-02f, 8.62882957e-02f, -2.56663971e-02f, 2.69571077e-02f, 3.65978256e-02f, -5.03222011e-02f, 6.48598000e-02f,
  -1.92151498e-02f, -7.62749836e-02f, -5.40431663e-02f, -4.26830649e-02f, -6.41089231e-02f, 6.16835617e-02f, -5.17837256e-02f, -4.15107273e-02f, -4.93827984e-02f, -3.67753929e-03f,
  -5.33447266e-01f, -2.61061966e-01f, -5.31506278e-02f, -3.36135298e-01f, 1.27881780e-01f, 1.82803527e-01f, -1.34896412e-01f, -1.05406165e-01f, -2.49943465e-01f, -1.87507212e-01f,
  2.78401412e-02f, -1.80216849e-01f, -4.16991226e-02f, -2.97831595e-01f, 2.32176140e-01f, -9.23707634e-02f, -2.31286943e-01f, -1.79503679e-01f, -2.71070823e-02f, -1.16474904e-01f,
  -2.40790509e-02f, -5.14361635e-02f, 4.10663076e-02f, 1.57012329e-01f, -7.83001855e-02f, -8.27098414e-02f, 1.24547914e-01f, 1.08835518e-01f, 8.47576559e-03f, 1.07875019e-01f,
  2.61675362e-02f, -1.37550160e-01f, -5.40339462e-02f, -1.34167280e-02f, -1.85855466e-03f, -3.42000388e-02f, 1.30309999e-01f, 6.07314594e-02f, -3.85978594e-02f, -1.07696801e-01f,
  -1.93437189e-02f, 1.18697800e-01f, 3.27862916e-04f, 3.73861939e-02f, -3.42675112e-02f, -7.06639979e-03f, -5.93219325e-03f, 7.41988420e-02f, 5.56385890e-03f, -1.38321351e-02f,
  -2.77763475e-02f, 2.43405774e-02f, 3.17993127e-02f, -4.54666652e-02f, 1.61786173e-02f, 4.05294076e-03f, -3.95815670e-02f, 8.81156698e-02f, -4.84699532e-02f, -7.95415044e-02f,
  -2.77862642e-02f, -1.93610713e-02f, -5.19502126e-02f, 1.04528910e-03f, -1.53389629e-02f, 1.09445386e-01f, 4.88945097e-02f, 8.04587901e-02f, -1.61185525e-02f, 6.46908358e-02f,
  1.21918451e-02f, 3.95928212e-02f, -3.50615010e-02f, 3.69362384e-02f, -4.85394523e-02f, -8.99716280e-03f, 6.38559759e-02f, -3.84030230e-02f, -8.03960711e-02f, 3.64651680e-02f,
  -3.28219198e-02f, 7.56748617e-02f, -3.36404480e-02f, 5.86619675e-02f, 1.00934774e-01f, -3.30585800e-02f, -2.17990261e-02f, -3.30080539e-02f, 5.89825101e-02f, -1.40838260e-02f,
  -1.78051330e-02f, -5.66852614e-02f, -2.54379325e-02f, -4.55507357e-03f, -9.37579293e-03f, -2.94033457e-02f, -1.92373507e-02f, -4.01615389e-02f, -3.10804341e-02f, -5.17391674e-02f,
  6.60935417e-02f, 2.29373444e-02f, -3.94437928e-03f, 1.69430431e-02f, 9.66269299e-02f, 4.99623977e-02f, 3.00901156e-04f, 9.03225467e-02f, -1.48571152e-02f, 9.37187523e-02f,
  1.78621113e-02f, 1.53563907e-02f, 5.34965796e-03f, 2.34543886e-02f, 3.53009067e-03f, 6.17079027e-02f, -2.47550551e-02f, 1.25858607e-02f, -3.56024280e-02f, -6.43371120e-02f,
  -1.44247726e-01f, -3.74440849e-01f, 1.01564424e-02f, -4.11072135e-01f, 7.66428411e-02f, -3.06424405e-02f, 1.08742572e-01f, -1.84513494e-01f, -2.39589363e-01f, 1.19349785e-01f,
  3.80584151e-02f, 4.99323830e-02f, 3.43878955e-01f, -2.93291479e-01f, -1.07165016e-01f, 7.07504675e-02f, -2.59420186e-01f, 7.70394132e-02f, -6.69858009e-02f, 2.01807134e-02f,
  -8.60451609e-02f, 1.30458428e-02f, 3.95352300e-03f, -1.31619483e-01f, 8.39670375e-03f, -9.24956426e-03f, 6.36945060e-03f, 1.07562415e-01f, -6.37981966e-02f, 6.63237125e-02f,
  -1.10863559e-01f, -1.41615719e-02f, 2.71786693e-02f, -2.47655753e-02f, 5.83294034e-02f, 8.85891616e-02f, 5.52779362e-02f, 1.35861412e-01f, 1.70703337e-03f, -6.76008910e-02f,
  8.46612230e-02f, 2.23243721e-02f, -5.32134846e-02f, 6.98989853e-02f, -1.21681318e-01f, -1.91937052e-02f, -3.64959724e-02f, 3.85647900e-02f, -2.25174427e-03f, -1.19448500e-02f,
  -4.04336601e-02f, -3.12353056e-02f, -4.87393588e-02f, -1.96742360e-02f, 6.99289218e-02f, -6.71121329e-02f, 9.30013135e-02f, 1.34586811e-01f, -8.51731282e-03f, -7.29329810e-02f,
  2.57782172e-02f, 5.30548543e-02f, 2.14235783e-02f, -2.92016268e-02f, 2.62423959e-02f, 3.61059122e-02f, 1.83351263e-02f, 2.49156561e-02f, 1.91191789e-02f, 3.36326733e-02f,
  -2.60100737e-02f, -2.72558331e-02f, -6.44600168e-02f, 6.72426820e-02f, 6.35984167e-02f, -4.16146265e-03f, 1.18239075e-01f, 4.37141284e-02f, -7.00027496e-02f, -6.11736774e-02f,
  -3.73193212e-02f, -8.80357623e-02f, 6.55661756e-03f, 2.62570865e-02f, -6.88142553e-02f, 1.00000232e-01f, -1.84283145e-02f, -1.01604965e-02f, -5.97153232e-02f, 3.61073501e-02f,
  5.36688156e-02f, 3.68083231e-02f, 2.42570229e-02f, -3.01134791e-02f, 1.80313196e-02f, -1.03894196e-01f, 3.44383046e-02f, -1.38109878e-01f, 5.33427820e-02f, 1.38766284e-03f,
  9.35884006e-03f, 5.08199669e-02f, 1.01011313e-01f, -5.22678606e-02f, -5.30956835e-02f, -1.10350236e-01f, 5.91830276e-02f, 4.03881073e-02f, 2.83422358e-02f, -1.22709155e-01f,
  5.22458591e-02f, 1.30026191e-01f, 3.93174626e-02f, 9.39137563e-02f, 6.33508489e-02f, 2.61879452e-02f, 1.53972516e-02f, -1.51148625e-02f, 4.46011648e-02f, 3.56133878e-02f,
  -4.98709440e-01f, 2.10953981e-01f, 1.57213733e-02f, -1.15336776e-02f, -1.16647951e-01f, -6.13219179e-02f, -1.40634820e-01f, 1.38614029e-02f, -2.69929282e-02f, 9.82563719e-02f,
  4.08805422e-02f, -3.83840688e-02f, 1.11602925e-01f, 1.62548870e-01f, -3.33105356e-01f, 9.28217843e-02f, -1.31446853e-01f, -7.65542611e-02f, 3.66155803e-02f, 1.19344346e-01f,
  3.05053834e-02f, 1.91643640e-01f, -9.55810621e-02f, 8.30411017e-02f, 6.53802603e-02f, 6.33846670e-02f, -4.75025252e-02f, -1.17706202e-01f, 1.61435574e-01f, -6.16913177e-02f,
  1.32892326e-01f, 1.35316655e-01f, 1.14334732e-01f, 9.76461247e-02f, 6.15519173e-02f, 1.01180449e-01f, -2.61030048e-02f, -1.13645449e-01f, -7.98539165e-03f, 7.56337717e-02f,
  -1.22658513e-01f, 3.56936939e-02f, -3.57665569e-02f, -5.82328141e-02f, 1.89515203e-02f, 2.15989421e-03f, -8.84813815e-02f, -6.02240162e-03f, 3.91198769e-02f, -5.47807524e-03f,
  -3.41942869e-02f, -2.88849548e-02f, -2.01479141e-02f, -2.84801563e-03f, -1.17458686e-01f, -8.63120183e-02f, -1.13604560e-01f, -1.31220087e-01f, 6.95377067e-02f, -5.13906544e-03f,
  -5.91878965e-02f, 1.18888706e-01f, 1.80515591e-02f, 6.72604069e-02f, 4.65641171e-02f, 3.74220982e-02f, -1.59083493e-02f, 6.00135624e-02f, 4.34719026e-03f, 3.61208059e-02f,
  1.01836976e-02f, -2.56069358e-02f, -6.51943590e-03f, 5.75633757e-02f, 4.36551534e-02f, 5.30110858e-02f, -7.68285170e-02f, -4.52358322e-03f, 2.76435446e-03f, -2.54426803e-02f,
  9.20954049e-02f, -4.22438644e-02f, 5.64548410e-02f, -4.86832894e-02f, 2.60196999e-02f, -9.85196307e-02f, -3.88142243e-02f, 1.09980129e-01f, 5.04662506e-02f, -1.72211025e-02f,
  9.12172794e-02f, 1.34886056e-01f, 2.06067674e-02f, 1.01498432e-01f, 1.18152343e-01f, 4.42719460e-02f, 1.02738589e-02f, -4.16750945e-02f, 5.22554591e-02f, 7.44017288e-02f,
  -1.18557237e-01f, -1.73630530e-03f, 6.49169534e-02f, 3.23023163e-02f, -4.32131365e-02f, -6.00692704e-02f, -7.79892206e-02f, -4.54930030e-02f, -7.13004544e-02f, -3.23682576e-02f,
  -6.70175329e-02f, 4.67052480e-04f, -5.35688512e-02f, -4.82859612e-02f, -6.88577369e-02f, -1.60968542e-01f, 7.28634419e-04f, -1.13851480e-01f, -4.77683991e-02f, 7.07689226e-02f,
  -5.67248417e-03f, -1.03104413e-01f, 1.61135510e-01f, 4.95195203e-02f, 2.27630436e-01f, -9.78143811e-02f, -2.60313123e-01f, 8.88568610e-02f, -1.46486893e-01f, -3.36843878e-01f,
  -8.48841518e-02f, -2.47740354e-02f, -1.73101261e-01f, 1.92440059e-02f, -7.64085054e-02f, -1.05996065e-01f, 1.46549121e-01f, 3.04222964e-02f, 1.31775707e-01f, 5.74985966e-02f,
  2.43241236e-01f, 3.57356146e-02f, 2.19319239e-01f, 1.58465594e-01f, 2.07594201e-01f, 1.09827012e-01f, 8.51823017e-02f, 2.27920222e-03f, 2.31322832e-02f, -7.27173463e-02f,
  -2.34103631e-02f, -8.98813605e-02f, 1.60417616e-01f, 3.72823030e-02f, -1.68054048e-02f, 5.53371869e-02f, 6.17006496e-02f, -1.22189848e-02f, 9.77242514e-02f, 7.41797313e-02f,
  6.07552752e-03f, 9.06543583e-02f, 8.63083266e-03f, -6.56716675e-02f, -2.57764701e-02f, 1.63954660e-01f, 1.04421385e-01f, -1.19333891e-02f, 1.14354514e-01f, 2.47260276e-02f,
  4.49287742e-02f, 7.32469931e-02f, -1.81399453e-02f, -1.54534932e-02f, 7.59026036e-02f, -2.18767226e-02f, -2.42513549e-02f, 7.14103039e-03f, 1.01805188e-01f, -5.04668765e-02f,
  -5.47632836e-02f, 2.98796277e-02f, 8.16879198e-02f, 2.18750667e-02f, -8.48399848e-02f, -4.34111394e-02f, -1.06730141e-01f, 3.04303803e-02f, 2.99269566e-03f, -7.27066696e-02f,
  1.37463706e-02f, 9.94448960e-02f, -3.33865024e-02f, 6.23245873e-02f, 5.23398258e-02f, -1.26507198e-02f, -2.48290617e-02f, -2.37419270e-02f, -2.02784631e-02f, 7.50041101e-03f,
  2.97713708e-02f, -4.65683686e-03f, -1.43502122e-02f, 6.69549406e-03f, -1.20149828e-01f, 6.99183792e-02f, 1.11170948e-01f, 2.34579593e-02f, 1.14349522e-01f, 4.15769182e-02f,
  -1.98736653e-01f, -3.09184551e-01f, 2.54408503e-03f, 4.82624993e-02f, -9.32359397e-02f, 1.44705161e-01f, 1.38816983e-03f, 3.69333848e-02f, -7.80047625e-02f, 9.81819704e-02f,
  6.59514442e-02f, 1.75019484e-02f, -8.01401138e-02f, 2.54003750e-03f, 2.49938499e-02f, 1.15653523e-03f, 9.58731957e-03f, 1.50021054e-02f, 6.83731884e-02f, -1.34485662e-01f,
  5.55764921e-02f, -1.99505799e-02f, -1.04597816e-02f, 1.43344536e-01f, 3.80626917e-02f, -1.17348358e-01f, -5.71880154e-02f, -1.02614947e-01f, -5.19569740e-02f, -7.47202849e-03f,
  -3.24312001e-01f, 2.01710574e-02f, -2.28194505e-01f, -2.50113219e-01f, 1.15893997e-01f, -8.79473463e-02f, 3.92159931e-02f, 9.30753499e-02f, -2.95659095e-01f, 1.85773522e-01f,
  1.25564650e-01f, -2.89819330e-01f, 4.28940281e-02f, -1.53311893e-01f, -3.43245625e-01f, -2.35336900e-01f, -1.72484726e-01f, -1.05899684e-01f, -3.78188416e-02f, -4.19792756e-02f,
  -5.45330085e-02f, 1.81266800e-01f, -3.69274355e-02f, 2.10061282e-01f, 1.27882719e-01f, -1.13803474e-02f, 2.35675931e-01f, 6.63551465e-02f, -1.06634330e-02f, -3.12879235e-02f,
  1.49432300e-02f, 7.31486306e-02f, 3.22413929e-02f, -3.60885076e-02f, 2.06288714e-02f, 4.28618491e-02f, 2.25715972e-02f, -6.58581173e-03f, -6.67519569e-02f, -1.02191478e-01f,
  -4.09829011e-03f, -4.35280502e-02f, -7.93542042e-02f, 1.62175521e-02f, -6.74086669e-03f, -1.52816281e-01f, -7.03947395e-02f, 1.50721110e-02f, 3.39819640e-02f, -7.64789283e-02f,
  -3.06115355e-02f, -7.77247772e-02f, -5.42741381e-02f, 1.91065064e-03f, -2.04509813e-02f, -3.47484052e-02f, -4.69532097e-03f, -1.96696147e-02f, -1.20624408e-01f, -1.32999554e-01f,
  5.56889139e-02f, 2.64729541e-02f, 1.61398705e-02f, 1.50716240e-02f, -2.17456855e-02f, -1.42625161e-03f, -6.31673485e-02f, 2.91061290e-02f, -7.48432651e-02f, -6.43099919e-02f,
  -3.65557969e-02f, 2.77593173e-02f, 4.82448600e-02f, -1.69816520e-02f, 2.84494972e-03f, -2.67247185e-02f, -9.33082551e-02f, 3.08170840e-02f, 1.93794891e-02f, 1.02731250e-01f,
  2.56962162e-02f, -7.30240121e-02f, 5.45530990e-02f, 1.16305850e-01f, -8.43805671e-02f, -3.96395810e-02f, 3.19494004e-03f, -8.86565447e-02f, -2.41781287e-02f, -2.16141064e-03f,
  1.40653607e-02f, 2.27022246e-02f, 1.84080172e-02f, 2.03649681e-02f, -5.00799976e-02f, -2.18674671e-02f, -4.21415940e-02f, 1.03783935e-01f, -6.10222518e-02f, 4.95556742e-02f,
  1.38155054e-02f, -2.28414219e-02f, -1.73908789e-04f, 2.07857490e-02f, -1.88396070e-02f, 7.64530674e-02f, 3.23513104e-03f, -1.31678246e-02f, 3.46606039e-02f, 8.13238695e-03f,
  5.59799336e-02f, 1.30006140e-02f, -5.80085032e-02f, 4.26742174e-02f, 6.06142394e-02f, 8.24654251e-02f, -1.08391687e-01f, -7.13872537e-02f, 2.27475092e-02f, -7.51252174e-02f,
  1.15596978e-02f, -4.20958549e-01f, -9.40511450e-02f, -2.36843243e-01f, 4.77190875e-03f, -2.53060728e-01f, -1.99395955e-01f, -1.13534726e-01f, -9.43599120e-02f, -2.38078788e-01f,
  1.32824868e-01f, -2.98065066e-01f, -8.56476650e-02f, -2.42789462e-01f, 1.25270084e-01f, -1.00506544e-01f, -2.45205998e-01f, -2.46444061e-01f, 3.96402582e-04f, -1.14401981e-01f,
  -2.02318979e-03f, -8.28801766e-02f, -1.18419126e-01f, 1.31189320e-02f, -3.90681997e-02f, 4.02879119e-02f, 1.50515527e-01f, 4.67416793e-02f, -1.09930955e-01f, -3.80535498e-02f,
  1.09805033e-01f, 1.19763911e-01f, 2.22251900e-02f, 1.90135706e-02f, 1.57218275e-03f, 6.58002794e-02f, 7.94673245e-03f, 9.34690684e-02f, 7.04258233e-02f, -6.11923374e-02f,
  -1.48914799e-01f, -1.10944419e-03f, -3.10192667e-02f, -1.53062828e-02f, -2.02387441e-02f, 1.33605162e-02f, -7.10729808e-02f, -4.53409515e-02f, -4.26102690e-02f, -9.81567428e-02f,
  -1.74313430e-02f, -8.96762498e-03f, -1.24613442e-01f, -1.08254448e-01f, -3.85380127e-02f, -3.20665762e-02f, -1.02086328e-01f, -5.60314171e-02f, -5.02880663e-02f, -1.15686595e-01f,
  -7.75860846e-02f, 6.75651012e-03f, 7.87272751e-02f, 1.16507322e-01f, 3.98308188e-02f, 1.12498879e-01f, -4.14157137e-02f, 6.41846657e-02f, 8.83072615e-03f, 6.12747706e-02f,
  7.82279596e-02f, -4.18349057e-02f, 1.91373453e-02f, -3.90581563e-02f, -5.51620536e-02f, -2.68076099e-02f, -8.03845283e-03f, -1.78347703e-03f, -3.05738226e-02f, 1.59279794e-01f,
  2.95376908e-02f, -3.60009260e-02f, 6.90151677e-02f, -2.65449919e-02f, 2.90190423e-04f, 8.94698501e-03f, -1.02983244e-01f, 2.29376517e-02f, 2.50452030e-02f, -3.43387830e-03f,
  -4.33346257e-02f, -2.22990736e-01f, 3.39929014e-02f, 2.07933113e-02f, 3.33348215e-02f, 3.25414073e-03f, 3.17315236e-02f, 2.87779458e-02f, -6.30278289e-02f, 3.22830528e-02f,
  -4.98095714e-02f, -3.49476300e-02f, -1.96426921e-02f, 7.25958720e-02f, -6.06564768e-02f, -4.54567969e-02f, -1.53265864e-01f, -6.59630299e-02f, -1.40990853e-01f, -2.18376052e-02f,
  -5.25006652e-02f, -3.27330902e-02f, -9.62087885e-03f, 3.47372494e-03f, -1.62056282e-01f, -3.68247814e-02f, -2.89466623e-02f, -6.29315898e-02f, 7.68361380e-03f, -1.63351059e-01f,
  -6.28802106e-02f, -4.90106866e-02f, 7.92237297e-02f, 6.73876330e-02f, -1.91940963e-01f, -2.16406494e-01f, 4.32377718e-02f, -1.60579190e-01f, 3.48659605e-02f, -1.18756749e-01f,
  3.37893590e-02f, 1.11577831e-01f, 1.17797367e-01f, -2.98844539e-02f, 4.93245870e-01f, 2.34010175e-01f, 8.72604102e-02f, -2.96732113e-02f, -3.54257249e-03f, 4.78865914e-02f,
  9.06272456e-02f, -7.44347423e-02f, 1.35635033e-01f, -2.73737758e-01f, -2.63334334e-01f, -9.86722857e-02f, 1.18306875e-01f, -5.63205779e-02f, -1.71977267e-01f, -2.98387334e-02f,
  -4.12817253e-03f, -1.71098076e-02f, -7.70824775e-02f, -1.41727068e-02f, 4.94208094e-03f, 9.71104670e-03f, -8.43422934e-02f, 9.63401645e-02f, 2.06424575e-02f, -5.85700236e-02f,
  1.00042019e-02f, 2.19126102e-02f, 6.34899363e-03f, -1.08588487e-02f, -1.87232554e-01f, -3.16543058e-02f, -3.45399007e-02f, 6.01270841e-03f, -6.69748783e-02f, -9.66468826e-02f,
  2.64749937e-02f, 1.62135419e-02f, -1.09664746e-01f, 1.95093360e-02f, -1.14576016e-02f, 4.49167155e-02f, 2.38997862e-02f, -1.55347167e-02f, -4.69718501e-02f, -5.14067002e-02f,
  -7.03906193e-02f, 8.60375911e-02f, 6.10882640e-02f, 9.05075967e-02f, 1.71499234e-02f, -1.23159001e-02f, 2.61909068e-02f, 8.82680044e-02f, 2.12843474e-02f, 7.86943957e-02f,
  7.28913173e-02f, 8.08797311e-03f, -7.79872090e-02f, -7.08348677e-02f, 4.64832559e-02f, -3.31333056e-02f, 2.20566764e-02f, -4.85679992e-02f, -6.42040074e-02f, 5.92406504e-02f,
  8.71437266e-02f, -4.04349854e-03f, 6.14538155e-02f, -1.25900894e-01f, -5.62336259e-02f, 1.99495584e-01f, -1.25247464e-01f, -1.10557482e-01f, -6.47588149e-02f, 7.25816712e-02f,
  1.18540607e-01f, 2.26033986e-01f, 6.38707541e-03f, 1.84017816e-03f, -1.55995851e-02f, 6.66977838e-02f, 1.16013419e-02f, -4.49139774e-02f, 2.87619494e-02f, 4.29939926e-02f,
  -4.91918661e-02f, -5.66622876e-02f, 2.33397763e-02f, 4.61517135e-03f, -3.90390269e-02f, -3.84164453e-02f, 1.08327202e-01f, 2.58314312e-02f, -4.81436960e-02f, -1.35284707e-01f,
  8.48658476e-03f, 4.68850695e-02f, -2.71574985e-02f, -6.82582781e-02f, -1.34557456e-01f, 9.25640855e-03f, -5.65740392e-02f, -1.43428445e-01f, 5.93834557e-03f, -1.03358500e-01f,
  3.74226570e-01f, 1.20302536e-01f, 1.03738621e-01f, 4.04222962e-03f, -8.83219093e-02f, -3.52823406e-01f, -2.50684410e-01f, -9.63203162e-02f, -2.32705057e-01f, -1.11886851e-01f,
  -7.50808343e-02f, -5.70619740e-02f, 6.46375911e-03f, -1.73763990e-01f, -3.23964685e-01f, -7.03731254e-02f, -1.94926620e-01f, -9.41962749e-02f, 2.78436090e-03f, 1.48216009e-01f,
  1.05904035e-01f, -2.46127695e-02f, 4.76873517e-02f, 5.63568622e-02f, 7.94645101e-02f, 1.85055330e-01f, 2.87132651e-01f, 7.68670365e-02f, 1.37605101e-01f, -1.60623401e-01f,
  -1.42783940e-01f, -1.86660811e-02f, 1.36027811e-02f, -3.72925550e-02f, -1.35397008e-02f, 6.17377572e-02f, 4.03364189e-02f, 2.02637911e-02f, -2.21265685e-02f, 4.49898019e-02f,
  3.66254225e-02f, 2.38755550e-02f, -9.73930955e-02f, -8.38990882e-02f, 5.66105284e-02f, -9.52008367e-03f, 8.80062133e-02f, -7.01735541e-02f, 2.11881697e-02f, 8.32682401e-02f,
  2.42948513e-02f, 1.12411276e-01f, 1.68493405e-01f, 6.17827773e-02f, 1.41860973e-02f, -2.11025607e-02f, -8.98530260e-02f, -2.47782469e-02f, 8.12581275e-03f, -8.00573677e-02f,
  1.49218543e-02f, 4.66602184e-02f, 4.95766848e-02f, 1.63699556e-02f, -4.47411947e-02f, 7.04504922e-02f, -5.05995713e-02f, -6.25627860e-02f, -1.32393111e-02f, -1.81311481e-02f,
  -3.30719426e-02f, -5.04317544e-02f, 3.34208496e-02f, -4.30695191e-02f, 6.32174592e-03f, 7.69139081e-02f, 8.44109356e-02f, 3.09955496e-02f, 3.14131267e-02f, -8.81753787e-02f,
  7.64585659e-02f, 2.73605101e-02f, -6.57062829e-02f, 1.03138043e-02f, 3.80271263e-02f, -6.08308055e-02f, 3.19256485e-02f, 8.35960209e-02f, 5.66979945e-02f, 1.56271514e-02f,
  -1.19519278e-01f, -9.71709788e-02f, -1.48617283e-01f, -1.73613187e-02f, 1.84796583e-02f, -6.33630389e-03f, -1.26191318e-01f, 5.67019284e-02f, 5.03704473e-02f, 6.56440109e-02f,
  -5.23344940e-03f, -1.04660958e-01f, 1.06216140e-01f, 2.00107433e-02f, -5.10594249e-02f, -1.47281677e-01f, 1.66753635e-01f, -1.49851283e-02f, 2.86950786e-02f, 1.47473169e-02f,
  6.89954758e-02f, 6.93281293e-02f, 1.43296598e-02f, -1.42434850e-01f, -4.32993695e-02f, 1.13333084e-01f, -2.15579402e-02f, -2.48826691e-03f, 9.90745649e-02f, -3.48860808e-02f,
  3.21369290e-01f, -1.05254970e-01f, 1.67427555e-01f, -8.70081931e-02f, -1.64898485e-01f, -1.51004508e-01f, -4.84885573e-02f, -2.21610010e-01f, -1.72002107e-01f, -1.82122216e-01f,
  -2.65976340e-01f, 7.46751279e-02f, -1.38581768e-01f, -2.02692419e-01f, -2.20309079e-01f, -6.17548041e-02f, -1.30577013e-01f, 9.85449087e-03f, -3.38571928e-02f, -1.48753226e-01f,
  3.75150368e-02f, -2.39992782e-01f, 1.12192715e-02f, -9.61020440e-02f, 2.69528721e-02f, 1.13168292e-01f, -9.52670723e-02f, 8.58893692e-02f, -4.55344241e-04f, -9.76883471e-02f,
  6.48952276e-02f, -1.18535599e-02f, 6.46071136e-02f, 3.61761488e-02f, -3.09193041e-02f, 1.18814208e-01f, 1.22375347e-01f, 2.18626056e-02f, 7.36156628e-02f, -2.86072865e-02f,
  1.06584974e-01f, -1.73654559e-03f, -7.01345950e-02f, 1.14738747e-01f, -7.00011924e-02f, -1.67472959e-02f, -1.48991477e-02f, 9.14321318e-02f, -5.82513325e-02f, 4.39045541e-02f,
  -1.17345452e-02f, 3.61055247e-02f, 1.62293087e-03f, -1.53259304e-03f, -6.63875341e-02f, -9.43708867e-02f, 3.35675813e-02f, 1.70847669e-01f, -8.82765502e-02f, 2.59242225e-02f,
  1.41314734e-02f, 7.16553703e-02f, -3.33735049e-02f, 4.76583000e-03f, 3.13395285e-03f, -1.28975213e-01f, -1.14711054e-01f, -5.44739105e-02f, -1.21064913e-02f, -1.13493480e-01f,
  -1.26821056e-01f, -8.44830349e-02f, -5.87562211e-02f, 2.08516344e-02f, 2.31207013e-02f, 2.03680974e-02f, 2.22683866e-02f, -5.68261929e-02f, 3.89289446e-02f, -8.00259635e-02f,
  -1.16661554e-02f, -1.26037397e-04f, -1.17136471e-01f, -2.46362779e-02f, -6.22526072e-02f, 3.18959132e-02f, -4.44696136e-02f, -2.15705298e-02f, -4.46539447e-02f, -5.27860783e-03f,
  -1.04770064e-01f, -9.37599838e-02f, -5.19864820e-02f, -5.69702499e-03f, 1.79943815e-02f, 6.54176772e-02f, 1.04630098e-01f, -1.13062687e-01f, -4.49627079e-03f, 1.26792621e-02f,
  6.20748512e-02f, -1.34569630e-01f, -8.75360072e-02f, -7.08047708e-04f, -1.04148619e-01f, -1.54384971e-01f, 2.00673100e-02f, -3.45321596e-02f, -6.82974681e-02f, -4.60564755e-02f,
  4.79652472e-02f, -8.63573402e-02f, 3.76381576e-02f, -1.21888153e-01f, -6.35419935e-02f, -3.65571911e-03f, -2.52951104e-02f, 8.17501247e-02f, -3.22028622e-02f, -7.77104273e-02f,
  9.09421667e-02f, -5.68640903e-02f, -7.06381053e-02f, -4.50491495e-02f, -1.59277141e-01f, 1.47155732e-01f, 2.45813057e-01f, -2.54868269e-01f, -2.86491454e-01f, 8.02946910e-02f,
  2.02005319e-02f, 1.32962108e-01f, 6.93913102e-02f, 1.94358945e-01f, 2.36836538e-01f, 8.17735270e-02f, 3.96606736e-02f, 1.11321986e-01f, -1.95484698e-01f, -1.90239977e-02f,
  -9.46842954e-02f, 2.32201070e-01f, 9.24093798e-02f, -3.10186408e-02f, 2.81760041e-02f, -2.53263265e-01f, 1.74173247e-02f, -2.65633091e-02f, 4.19538170e-02f, 6.17065392e-02f,
  4.59035188e-02f, -4.49834652e-02f, 4.71300706e-02f, 1.07618617e-02f, -9.66554582e-02f, 5.60230464e-02f, 7.75705576e-02f, 1.88899413e-01f, 7.29433959e-03f, -2.22353674e-02f,
  1.44043826e-02f, 8.56400840e-03f, 5.82681969e-03f, -2.28154895e-05f, -1.26011014e-01f, -4.06654701e-02f, -4.15500104e-02f, -1.09655537e-01f, -3.72177549e-02f, 3.54855545e-02f,
  5.97717240e-03f, -9.39893350e-02f, -4.45669070e-02f, -1.08473688e-01f, -3.81201357e-02f, -6.32383451e-02f, 1.06277699e-02f, 2.89954934e-02f, 1.17064863e-01f, 1.12158619e-02f,
  6.31981716e-02f, -4.05901857e-02f, 5.85587397e-02f, 1.90150514e-02f, 3.49353366e-02f, -3.83532196e-02f, 7.89728481e-03f, -9.25584324e-03f, -2.80342810e-02f, 6.51495531e-02f,
  -9.65423808e-02f, -6.48036450e-02f, -6.41672462e-02f, -1.11869918e-02f, -4.43191752e-02f, -2.59319153e-02f, 6.54131025e-02f, 1.53395599e-02f, -2.57784575e-02f, 9.17956457e-02f,
  -1.47930663e-02f, 1.63362827e-02f, 6.79047331e-02f, -4.75363731e-02f, 5.14695495e-02f, -3.18486057e-02f, -1.27778515e-01f, 5.15268631e-02f, 3.03404443e-02f, 9.76617187e-02f,
  -4.68902402e-02f, -2.12745607e-01f, -3.73036824e-02f, 4.89573851e-02f, -2.05681417e-02f, 1.32196033e-02f, 6.73341379e-03f, -1.03489459e-02f, -1.98222294e-01f, 6.78379238e-02f,
  5.75513393e-03f, 6.92872554e-02f, 2.37141289e-02f, 3.55073698e-02f, -6.23676106e-02f, 8.23215917e-02f, 3.84858586e-02f, -1.04792349e-01f, -5.82568459e-02f, -7.69495070e-02f,
  6.95478618e-02f, 6.63721487e-02f, -1.85754783e-02f, -4.04254086e-02f, -3.30602704e-03f, -9.70226452e-02f, 8.25622305e-03f, 2.29157954e-02f, 4.30223942e-02f, 3.05004790e-02f,
  2.96807736e-01f, 2.91212648e-01f, -4.05458640e-03f, 1.86145723e-01f, 7.97370374e-02f, -2.33210936e-01f, 1.86948195e-01f, 7.60947093e-02f, 1.66223302e-01f, 1.81696013e-01f,
  2.16938138e-01f, 9.37119424e-02f, 8.46099034e-02f, 9.79798809e-02f, -3.31594735e-01f, -1.28606260e-01f, 4.01365869e-02f, 8.84696394e-02f, -9.28193107e-02f, 1.42834470e-01f,
  -5.29280379e-02f, -1.58517752e-02f, -6.40869364e-02f, 2.54241750e-02f, 1.03422821e-01f, -8.83228984e-03f, 4.80558584e-03f, 1.06911391e-01f, -1.00412808e-01f, 4.11991030e-03f,
  -1.33193405e-02f, 1.90808877e-01f, 2.03614123e-02f, -8.66296589e-02f, -5.09630702e-02f, -5.17839827e-02f, 5.56239225e-02f, 3.84948496e-03f, -8.95790085e-02f, -4.02741693e-02f,
  1.79011226e-02f, 1.88601632e-02f, 3.36270854e-02f, 5.49953133e-02f, 1.27531275e-01f, 1.80020146e-02f, -7.60676712e-02f, 4.82471399e-02f, 9.22186971e-02f, 7.07796142e-02f,
  2.97608860e-02f, -3.96250226e-02f, -3.16597521e-02f, 1.71321984e-02f, 4.82917391e-03f, 7.92329162e-02f, 3.28193977e-02f, 8.50692857e-03f, -4.66802940e-02f, -5.23505472e-02f,
  3.06513850e-02f, -1.21011930e-02f, -1.61398035e-02f, 2.26710457e-02f, 7.98694137e-03f, 7.82523453e-02f, 1.01442225e-01f, -9.09606591e-02f, -3.81605998e-02f, 2.39539030e-03f,
  -2.72027757e-02f, 4.77920957e-02f, 1.36237130e-01f, 2.64495704e-02f, -3.01655922e-02f, 1.43618420e-01f, 5.88354049e-03f, -5.34127764e-02f, -4.54341210e-02f, -3.83710191e-02f,
  -3.08027286e-02f, 3.32026854e-02f, 3.42952572e-02f, 5.81590571e-02f, 1.49968592e-02f, -7.38144070e-02f, 1.23791778e-02f, -1.37096168e-02f, 9.48540121e-02f, -1.18394621e-01f,
  5.33272838e-03f, -1.53596792e-02f, -6.02231771e-02f, -4.10218211e-03f, -7.62519091e-02f, -1.22226439e-01f, -4.53989841e-02f, -7.17537757e-03f, -1.08308122e-01f, -5.80278924e-03f,
  -4.02875990e-02f, 1.26611710e-01f, -2.32645813e-02f, 2.32941154e-02f, 1.91004574e-02f, 6.94684833e-02f, -6.88069779e-03f, 2.32920144e-02f, -4.81030010e-02f, 8.76526684e-02f,
  3.11698802e-02f, 9.22262967e-02f, -3.44451591e-02f, 6.32577538e-02f, 1.31287593e-02f, 5.32460772e-02f, 9.06741247e-02f, 1.22465640e-01f, -1.27154604e-01f, -1.01745754e-01f,
  2.50395805e-01f, -1.37368515e-01f, -6.73691630e-02f, -6.59136940e-03f, -8.15816398e-04f, -2.90622532e-01f, -2.90017009e-01f, 3.56952362e-02f, 1.54973837e-02f, -3.71906124e-02f,
  -3.20948102e-02f, -6.77868947e-02f, -4.35390621e-02f, -1.18032128e-01f, 1.76409092e-02f, -3.77821960e-02f, -1.51597470e-01f, -4.38623466e-02f, 4.96902391e-02f, 3.78695652e-02f,
  5.35375327e-02f, -4.96015698e-02f, -6.45678639e-02f, 1.41963482e-01f, -5.62592819e-02f, 1.31154552e-01f, 5.57599589e-02f, 1.12303011e-02f, -2.64459867e-02f, 9.15257707e-02f,
  -1.35556698e-01f, -5.13511635e-02f, 1.88636091e-02f, 1.45103717e-02f, -3.57213691e-02f, 1.20332213e-02f, -8.98301899e-02f, -1.73389316e-02f, 4.39261124e-02f, -3.01620252e-02f,
  -1.33271083e-01f, 1.04978591e-01f, 5.99477328e-02f, 1.38443843e-01f, 1.98193677e-02f, 7.38571063e-02f, 7.51253963e-02f, -4.84240148e-03f, 6.62225857e-02f, -1.29324630e-01f,
  -5.29519990e-02f, 6.76062703e-02f, 1.67141147e-02f, -6.65822327e-02f, -3.10887024e-02f, 4.22988497e-02f, -1.73184015e-02f, -5.15830852e-02f, -3.40092853e-02f, 5.25994152e-02f,
  2.59090848e-02f, -4.23973687e-02f, 8.08793865e-03f, 8.97979736e-02f, 4.65881787e-02f, 1.74567215e-02f, 2.77392436e-02f, 1.23949489e-02f, 8.22409987e-02f, -4.66191992e-02f,
  1.10852323e-01f, -3.20221501e-04f, -2.94677299e-02f, -1.07001783e-02f, 5.62550463e-02f, -6.05847314e-02f, -2.94215535e-03f, -2.75664870e-02f, 4.23026271e-03f, 1.08961994e-02f,
  1.62428617e-02f, 6.79121315e-02f, 1.16082849e-02f, 1.25390505e-02f, -7.50052780e-02f, 4.33071256e-02f, -3.18415426e-02f, -2.98849270e-02f, -4.22641300e-02f, 3.43600400e-02f,
  -9.52241048e-02f, -5.91289327e-02f, 3.91010307e-02f, 2.89866850e-02f, 2.61886306e-02f, 9.17297676e-02f, 8.09462462e-03f, -5.85995764e-02f, -1.49977356e-02f, -5.39324246e-02f,
  -4.67149280e-02f, -2.54224683e-03f, 4.81044613e-02f, 5.88387214e-02f, -3.16208266e-02f, -5.24343625e-02f, -1.78706255e-02f, 8.97389054e-02f, 3.78386751e-02f, -3.89004033e-03f,
  4.45804968e-02f, 6.06989898e-02f, 2.85923742e-02f, 4.15564813e-02f, -6.47144765e-02f, -3.52755077e-02f, 7.41273388e-02f, 1.34197250e-02f, -4.39995080e-02f, -2.44342559e-03f,
  4.69478697e-01f, 2.28775650e-01f, -9.56852213e-02f, 1.46169558e-01f, 5.17923795e-02f, -7.71981180e-02f, -1.75590113e-01f, 7.67110139e-02f, -3.14153433e-02f, -9.10352319e-02f,
  2.75400118e-03f, 7.83254281e-02f, -4.41804901e-03f, -1.88931972e-01f, 1.22739989e-02f, -1.35399342e-01f, 2.80125216e-02f, 4.16421145e-02f, -1.41639803e-02f, 1.88253745e-01f,
  5.37449718e-02f, -1.00156456e-01f, -1.13839611e-01f, 6.66707531e-02f, -2.38580387e-02f, -1.26552293e-02f, 3.24189402e-02f, -9.98718739e-02f, 6.43956289e-02f, -4.30216566e-02f,
  7.80304074e-02f, 1.14660218e-01f, -7.61836246e-02f, 2.75235940e-02f, 4.21420969e-02f, -6.27247021e-02f, 2.83026602e-02f, -1.96110204e-01f, -9.88056511e-02f, -3.23110186e-02f,
  9.97603219e-03f, 5.21017052e-03f, 2.87873903e-03f, -7.02234954e-02f, 8.80617797e-02f, -7.74874305e-03f, -9.93373245e-02f, 7.38317445e-02f, -5.93376346e-02f, 1.71550997e-02f,
  1.16457464e-02f, 1.01551436e-01f, -1.36507563e-02f, 6.91602081e-02f, 8.68023094e-03f, -8.76684021e-03f, -5.69374524e-02f, 2.21594125e-02f, 3.72094177e-02f, -5.17622866e-02f,
  3.27701159e-02f, -6.88737333e-02f, -5.53953871e-02f, 3.75191309e-02f, 2.52502505e-03f, 6.88496903e-02f, 5.96937202e-02f, -1.94068383e-02f, -6.59908280e-02f, 5.35409637e-02f,
  6.37224615e-02f, 8.58525112e-02f, 2.94385944e-02f, -9.43286810e-03f, -3.22664008e-02f, 2.78138444e-02f, 4.71170954e-02f, -1.54616684e-02f, -4.20287177e-02f, -3.70775759e-02f,
  3.25271152e-02f, 4.82740290e-02f, -2.15040334e-02f, 5.78067414e-02f, 1.54010290e-02f, -1.29018635e-01f, -9.80434124e-04f, -3.34404446e-02f, -2.09166873e-02f, -5.79865761e-02f,
  1.77601501e-01f, 2.53654450e-01f, -1.10684298e-01f, 1.82996895e-02f, -6.47217557e-02f, -7.29606077e-02f, -7.78226182e-02f, -7.82834664e-02f, -2.17953604e-03f, -4.90268357e-02f,
  -4.68115918e-02f, 2.59874924e-03f, 1.20947659e-01f, 8.02658091e-04f, 8.44078660e-02f, -3.66287604e-02f, -6.16023429e-02f, 5.53974099e-02f, 2.15395633e-02f, 1.89873025e-01f,
  2.30029458e-03f, 6.14453815e-02f, -1.44037932e-01f, 3.55749615e-02f, -2.80184485e-03f, 2.90209744e-02f, 1.12119801e-01f, -2.94569768e-02f, -8.03771317e-02f, -3.29774283e-02f,
  -3.02836508e-01f, 1.90883040e-01f, -2.38305673e-01f, -8.50646757e-03f, 1.98065475e-01f, 1.69544280e-01f, -1.69999138e-01f, 1.05681300e-01f, -3.01326096e-01f, 2.06328377e-01f,
  1.10178366e-01f, -1.41812444e-01f, -9.34998319e-02f, 1.31520867e-01f, -7.44037032e-02f, -1.68922842e-01f, 1.91483080e-01f, 6.57965764e-02f, -1.96964264e-01f, 3.62721756e-02f,
  -1.54390916e-01f, 2.23261327e-01f, 2.40243673e-02f, 1.33494064e-01f, 2.09706509e-03f, -5.83218411e-02f, 2.33066544e-01f, -2.25855634e-01f, 2.05184311e-01f, 8.72622281e-02f,
  -2.03524418e-02f, -1.72250241e-01f, -8.60557333e-03f, -1.61145031e-01f, 1.77028887e-02f, 1.89742539e-02f, -3.74512561e-02f, -1.67455167e-01f, 8.50384217e-03f, -2.49498524e-02f,
  -8.14624652e-02f, 8.58449116e-02f, 1.64279272e-03f, 1.07623085e-01f, -2.46328153e-02f, 5.04783839e-02f, -3.55318710e-02f, 5.59718497e-02f, 3.64365242e-02f, -6.30153567e-02f,
  -6.78194463e-02f, 6.33867979e-02f, -6.37101056e-03f, 8.30998570e-02f, 3.57930809e-02f, -1.44578908e-02f, 1.35916665e-01f, 5.04320376e-02f, 4.08166349e-02f, -6.34863554e-03f,
  -1.52904792e-02f, -1.18226990e-01f, -8.40204060e-02f, -5.63219897e-02f, 4.81252419e-03f, 3.66135351e-02f, 6.00019246e-02f, 7.91890845e-02f, -6.45359457e-02f, 6.35695383e-02f,
  -4.36579287e-02f, 7.59668201e-02f, -9.33168158e-02f, 8.48906860e-02f, 8.35338607e-02f, 5.36091551e-02f, -7.45537430e-02f, -6.02140129e-02f, -1.50111526e-01f, -3.16031724e-02f,
  2.01695506e-02f, -1.11923210e-01f, -8.08131471e-02f, -7.45632872e-02f, -8.27429444e-02f, 2.39878688e-02f, -9.64765996e-03f, -6.55127391e-02f, -2.97767967e-02f, -5.83318919e-02f,
  1.99115396e-01f, 7.65863806e-02f, -9.35987607e-02f, -2.14362284e-03f, -1.86831448e-02f, -1.66297853e-02f, -2.68952772e-02f, -2.82163396e-02f, 2.45787147e-02f, -6.62784129e-02f,
  7.67063051e-02f, 7.50683174e-02f, -9.25504789e-03f, -1.88458078e-02f, 9.63776261e-02f, -2.14857645e-02f, -6.34890273e-02f, 1.04814870e-02f, 1.72885895e-01f, 2.15016361e-02f,
  4.63990495e-02f, -3.88868079e-02f, -3.87676358e-02f, 3.48836333e-02f, 1.44019440e-01f, -3.64859886e-02f, 7.56499395e-02f, -1.76001526e-02f, 6.27863705e-02f, 6.24493361e-02f,
  -1.95402890e-01f, 1.55356765e-01f, 1.30104106e-02f, -3.27159166e-01f, -1.90479860e-01f, 3.09650928e-01f, 2.04227403e-01f, -1.17847227e-01f, -1.93653420e-01f, 1.37984663e-01f,
  -1.43890148e-02f, 1.58757046e-01f, 2.13162363e-01f, -5.21221943e-02f, 1.14904441e-01f, 1.14014290e-01f, 4.41108346e-02f, 1.35761097e-01f, 2.05925256e-02f, 1.07650626e-02f,
  -1.73935786e-01f, -2.52006412e-01f, -1.55600952e-02f, -1.61679998e-01f, -9.69510227e-02f, -5.46844341e-02f, -1.77230477e-01f, 1.33259594e-03f, -2.42249463e-02f, 5.14007658e-02f,
  1.48918569e-01f, -1.16002642e-01f, 2.76924204e-03f, 2.65081190e-02f, -2.84976047e-03f, 4.01125848e-02f, 6.12653159e-02f, -1.02273270e-03f, -1.92430362e-01f, 3.00423335e-02f,
  7.80983344e-02f, -3.39111984e-02f, -5.51270088e-03f, -8.81520137e-02f, 3.74127179e-02f, -1.65015776e-02f, -8.57327878e-03f, 6.58028647e-02f, -3.04644313e-02f, 1.01238117e-01f,
  2.95515656e-02f, 8.35194215e-02f, -1.51622742e-01f, 5.23427799e-02f, -3.95975709e-02f, -9.19160098e-02f, 5.80143780e-02f, 3.26085165e-02f, -1.14399076e-01f, -6.19456507e-02f,
  7.48608857e-02f, -8.90737921e-02f, -5.62436432e-02f, -6.77835792e-02f, -5.81945926e-02f, -6.54875860e-02f, 1.82177173e-03f, 8.50054249e-02f, -1.08905114e-01f, 4.22509620e-03f,
  -4.41713519e-02f, 1.94319095e-02f, 3.89448665e-02f, -1.07510529e-01f, -3.10164355e-02f, -2.61897780e-02f, 4.92396578e-02f, -9.40794498e-02f, -6.27623051e-02f, -1.11266546e-01f,
  -2.84059886e-02f, -3.06290649e-02f, -1.04010813e-02f, 3.43444422e-02f, 2.60032918e-02f, -1.08504377e-01f, 2.19052155e-02f, 4.24029604e-02f, 8.18245113e-02f, -4.16309722e-02f,
  1.03992894e-01f, -1.15196571e-01f, 5.87470829e-02f, -1.97051261e-02f, -1.15981735e-02f, -4.46816534e-02f, 2.20586304e-02f, 9.14776977e-03f, -6.41189814e-02f, -7.33398497e-02f,
  -3.16485353e-02f, -8.69014859e-02f, 4.72278986e-03f, -6.12408333e-02f, 1.01013720e-01f, 1.18060627e-04f, 1.82341542e-02f, -1.00101233e-01f, -1.34364038e-03f, 8.40471089e-02f,
  -3.60385105e-02f, -6.44954713e-03f, -6.32881448e-02f, -7.63828233e-02f, 5.00690900e-02f, 1.14538588e-01f, -4.50766608e-02f, -5.94517514e-02f, -2.99598388e-02f, 1.80449965e-03f,
  -1.37799203e-01f, -5.88464998e-02f, -2.01985210e-01f, 8.95203426e-02f, -2.36750066e-01f, 4.67435978e-02f, -3.02439518e-02f, -8.22235122e-02f, -1.47063762e-01f, 1.35266826e-01f,
  -1.43579338e-02f, -7.22659007e-02f, -9.65422671e-03f, 9.91874039e-02f, 1.63325623e-01f, 1.73866689e-01f, 1.87318400e-01f, 6.79341853e-02f, -1.53595775e-01f, 1.06304072e-01f,
  2.88037378e-02f, 1.59109786e-01f, -1.13544077e-01f, -9.13954061e-03f, -2.03946382e-01f, 5.48435654e-03f, 2.14825481e-01f, -2.73536742e-01f, 1.62387937e-01f, -1.38284042e-01f,
  -5.49249649e-02f, -1.33016378e-01f, -8.10114816e-02f, 9.46390536e-03f, 2.51366962e-02f, 1.95107982e-02f, 5.68224117e-02f, -5.03360853e-03f, -3.37920710e-02f, -1.24413595e-02f,
  9.32915136e-03f, -8.40710825e-04f, -1.44735649e-02f, -2.33078357e-02f, -1.24627218e-01f, -4.98830192e-02f, 3.87830250e-02f, -5.15563637e-02f, 2.94002006e-03f, -1.84518188e-01f,
  -2.07499668e-01f, -1.46000013e-01f, -3.47593538e-02f, 1.06377535e-01f, -4.07294966e-02f, -3.78105454e-02f, 7.02635851e-03f, -1.04688503e-01f, -7.11047091e-03f, -4.32562530e-02f,
  -4.07355875e-02f, 8.20733979e-02f, 7.42833689e-02f, 6.71662018e-02f, 3.42203956e-03f, -3.98543701e-02f, -3.58728543e-02f, 6.73443228e-02f, -7.43804500e-02f, 4.99837883e-02f,
  1.40678540e-01f, -2.22362652e-02f, -6.62627816e-02f, -5.10873459e-02f, 5.90640195e-02f, 1.40361667e-01f, 1.17367566e-01f, 7.96564892e-02f, -1.66785158e-02f, 1.60016138e-02f,
  1.16101928e-01f, 3.06829214e-02f, 8.67466908e-03f, -1.03037015e-01f, -1.78696029e-02f, 1.71759482e-02f, -7.26977736e-02f, -1.04414888e-01f, -2.95715071e-02f, 8.11549556e-03f,
  2.63196498e-01f, 3.10094059e-01f, -3.15138921e-02f, -2.09374540e-03f, 5.94192632e-02f, 7.58479536e-02f, 2.89325486e-03f, 4.04334664e-02f, 1.31691515e-01f, 1.37097955e-01f,
  8.61529335e-02f, 1.36948535e-02f, -6.39160722e-03f, 1.04153395e-01f, -4.58142720e-02f, -4.61088009e-02f, 1.28776804e-01f, 1.37100548e-01f, 9.62697342e-02f, -4.46141735e-02f,
  1.00272104e-01f, 7.70005956e-02f, 1.02405235e-01f, -1.41038001e-02f, -1.51977632e-02f, 2.92405114e-02f, -4.22935002e-03f, -5.28575890e-02f, 6.96260191e-04f, -7.57628381e-02f,
  -2.04057917e-01f, 1.24450669e-01f, 1.40049160e-01f, -1.88275680e-01f, 4.29540090e-02f, -3.14208686e-01f, -2.63229430e-01f, -6.76332414e-02f, -2.06802398e-01f, -1.25712706e-02f,
  -2.95495480e-01f, 8.79042447e-02f, -8.57301056e-02f, -3.37976664e-01f, -3.30299348e-01f, -2.16232002e-01f, -2.54359603e-01f, -8.56042355e-02f, -5.22090867e-02f, 5.95822558e-02f,
  -1.27513707e-01f, -1.30042285e-01f, -2.51319371e-02f, 8.64358172e-02f, 5.90422675e-02f, 3.80720526e-01f, -1.65166948e-02f, 1.10543817e-01f, -3.75295915e-02f, -9.33308247e-03f,
  -4.57591228e-02f, -4.52603698e-02f, 1.63021326e-01f, 7.95217529e-02f, 6.60084784e-02f, 6.40212521e-02f, 1.02478880e-02f, 2.43017059e-02f, -5.45513034e-02f, -8.33556578e-02f,
  -7.17602000e-02f, 3.25624645e-02f, 3.11768409e-02f, 8.97678081e-03f, -6.17763512e-02f, 5.73586524e-02f, -1.09098457e-01f, -3.70591693e-02f, -1.06327184e-01f, -6.34005889e-02f,
  -7.57446662e-02f, -2.66336501e-02f, -9.04590711e-02f, -3.82128581e-02f, 2.95846704e-02f, -1.31644145e-01f, 3.86116728e-02f, 8.82492140e-02f, -1.78680010e-02f, 4.25321572e-02f,
  -2.87232101e-02f, 5.42705460e-03f, 3.21958885e-02f, 3.35597582e-02f, 2.82731857e-02f, 2.60958709e-02f, -4.98000495e-02f, 1.13887943e-01f, 2.94753835e-02f, -2.45214254e-02f,
  -5.12264902e-03f, 6.68617710e-02f, -1.70822725e-01f, 4.28250879e-02f, 3.34571265e-02f, 2.66090147e-02f, 4.80454527e-02f, 4.38841991e-02f, 5.17338105e-02f, 1.02703646e-01f,
  -5.83778024e-02f, -7.14302287e-02f, 1.26072764e-01f, 3.42879221e-02f, -8.31050426e-02f, -3.81628796e-02f, -1.05960339e-01f, -3.33876908e-03f, -4.37796786e-02f, 1.36023918e-02f,
  -9.27142974e-04f, 1.42131761e-01f, 1.11702904e-01f, 2.33167019e-02f, 1.02808885e-01f, -1.95474154e-03f, 3.99815291e-03f, -2.59884614e-02f, -1.61053967e-02f, -5.53172939e-02f,
  3.57345790e-02f, 1.00822024e-01f, 2.95404475e-02f, 5.16463593e-02f, 2.18107458e-02f, -7.24970326e-02f, -4.06861790e-02f, 5.78262843e-03f, -2.00373903e-02f, -3.42589393e-02f,
  -6.16803542e-02f, -3.26809436e-02f, -1.39461197e-02f, 3.06830257e-02f, 2.62548421e-02f, 8.13266169e-03f, 4.02513593e-02f, -9.57021315e-04f, -6.38848692e-02f, -1.95428487e-02f,
  5.54413721e-02f, 2.14610770e-01f, 1.07504856e-02f, 1.13489985e-01f, -2.28100300e-01f, -2.68834144e-01f, -2.01329991e-01f, 7.98505731e-03f, 1.96179435e-01f, 1.80654630e-01f,
  -1.57506868e-01f, 1.08432643e-01f, -1.19443551e-01f, -7.01381788e-02f, -2.77868301e-01f, -3.63046564e-02f, -7.95278177e-02f, -2.45595518e-02f, 2.62598954e-02f, -1.52073562e-01f,
  -1.57158613e-01f, -2.92564571e-01f, -2.37277195e-01f, -2.18965009e-01f, -2.59373635e-01f, 6.22374043e-02f, -2.15026543e-01f, -1.95994854e-01f, -8.27935413e-02f, -3.72403078e-02f,
  -3.84059995e-02f, 1.44770235e-01f, 5.85461669e-02f, 7.23626912e-02f, 2.69510373e-02f, -8.83667916e-02f, -9.74375010e-02f, -5.85102737e-02f, -3.96476239e-02f, 5.15506305e-02f,
  6.63039014e-02f, -3.47452126e-02f, 1.31625935e-01f, -7.28617460e-02f, -7.17516895e-03f, 6.12561703e-02f, -1.21515736e-01f, -9.24760252e-02f, -2.76638921e-02f, -8.90554488e-02f,
  -8.07433203e-02f, 1.23180889e-01f, -7.70997405e-02f, 7.99104869e-02f, -6.90826029e-02f, 4.71737683e-02f, 3.01494692e-02f, -4.53611128e-02f, -3.05313431e-02f, 1.03676982e-01f,
  -7.43570998e-02f, -3.56049687e-02f, -9.05692801e-02f, 1.03205748e-01f, -2.49591973e-02f, 1.03142321e-01f, 6.45787641e-02f, 6.97809607e-02f, 2.07536556e-02f, 8.56642574e-02f,
  1.17722288e-01f, 1.00304812e-01f, 6.65910263e-03f, -1.38617847e-02f, 5.37525304e-02f, 1.49998859e-01f, 4.35602441e-02f, 2.44374163e-02f, -2.61398181e-02f, -7.08154868e-03f,
  -4.94840816e-02f, -1.02453955e-01f, -8.68414436e-03f, 6.78251982e-02f, 4.61316928e-02f, 1.28204953e-02f, -5.35925403e-02f, -4.48284065e-03f, -2.44063269e-02f, -2.27876186e-01f,
  2.84973513e-02f, -1.92642249e-02f, 6.81470409e-02f, 1.82524789e-02f, 5.61950356e-02f, -7.00188277e-04f, -6.01949394e-02f, 3.74114253e-02f, -2.63023451e-02f, -9.06237066e-02f,
  -1.25737503e-01f, 2.38851607e-02f, 4.90563251e-02f, 6.48988504e-03f, -3.30008715e-02f, 5.81062101e-02f, -3.59079912e-02f, 5.39530143e-02f, -8.13601986e-02f, 1.53480861e-02f,
  -1.85332194e-01f, -3.19789127e-02f, 6.96504430e-05f, -2.64818445e-02f, -6.37403643e-03f, 1.95829608e-02f, 1.37850305e-03f, 3.62466415e-03f, -8.31193477e-02f, 4.82190922e-02f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -1.01804323e-01f, 4.74089049e-02f, 1.09681092e-01f, 1.47880524e-01f, -1.31442681e-01f, -2.93233246e-01f, -4.45638865e-01f, -1.63278673e-02f, -1.95003286e-01f, -4.04856980e-01f,
  -9.87626612e-02f, 1.28423190e-03f, -1.64811924e-01f, 1.35821640e-01f, 2.32020959e-01f, 6.70178700e-03f, 2.31419459e-01f, 8.20251107e-02f, 2.23207906e-01f, 1.36509344e-01f,
  1.94422349e-01f, 1.54092818e-01f, 4.37343121e-01f, 2.47042254e-01f, 5.60027398e-02f, 2.71664679e-01f, 2.60624766e-01f, 2.06416324e-02f, 3.37227732e-01f, 2.17483491e-02f,
  -1.09247107e-03f, 4.59913239e-02f, 5.89835681e-02f, 4.40268517e-02f, 3.88894714e-02f, -7.61871636e-02f, -3.58956754e-02f, -7.70225748e-02f, -1.04758635e-01f, -2.84027327e-02f,
  1.09710926e-02f, 5.80308139e-02f, 9.57320109e-02f, 2.99840812e-02f, -9.49474797e-02f, 3.80449966e-02f, 7.14844745e-03f, -5.49266078e-02f, -3.36483382e-02f, -1.33776382e-01f,
  -1.09975286e-01f, -3.03487256e-02f, -1.14194505e-01f, 2.14892682e-02f, 6.17429428e-02f, -2.00643074e-02f, -3.55558507e-02f, -1.45263989e-02f, -7.31764957e-02f, -9.05126520e-03f,
  3.40437256e-02f, -1.76155046e-01f, -3.59944627e-02f, -4.21235412e-02f, 6.18917346e-02f, 4.70514558e-02f, -6.48802239e-03f, 1.69710740e-02f, -4.63701272e-03f, -4.50727083e-02f,
  3.07676699e-02f, 2.67746523e-02f, 4.80891578e-02f, -1.27373874e-01f, -1.67387240e-02f, 1.16309207e-02f, 2.89158672e-02f, -2.28736158e-02f, -3.51155698e-02f, 3.66750285e-02f,
  -7.07867295e-02f, -1.22391051e-02f, -8.67722780e-02f, 8.40708613e-02f, -9.12172422e-02f, -1.69355452e-01f, 9.90718976e-03f, -5.74430898e-02f, 5.76670207e-02f, 1.21512599e-02f,
  1.45836666e-01f, 1.67434186e-01f, 7.32449740e-02f, 2.59376038e-02f, 6.39259070e-02f, -4.01544161e-02f, 3.47918719e-02f, 2.63282657e-02f, -7.29793857e-04f, -1.42252380e-02f,
  -5.71678989e-02f, -3.10788862e-02f, 4.69693244e-02f, 5.60729317e-02f, 1.00447483e-01f, 2.14222278e-02f, -9.85545292e-02f, 4.62370701e-02f, 6.68351427e-02f, 1.63420215e-01f,
  -2.17645504e-02f, -1.44246385e-01f, -8.11263546e-02f, 3.24462764e-02f, -2.70125605e-02f, -1.61587559e-02f, -2.75640395e-02f, -1.15107492e-01f, -1.73235277e-03f, 1.58405323e-02f,
  2.53620565e-01f, -1.80835381e-01f, -3.49397868e-01f, -5.59205376e-03f, -2.58614169e-03f, -5.25845028e-03f, -1.11589067e-01f, 1.16520278e-01f, -2.83352733e-01f, 9.25980657e-02f,
  1.72337741e-01f, -7.20608383e-02f, -2.70551026e-01f, 2.99093783e-01f, 3.06288064e-01f, -2.85252780e-01f, 2.53657341e-01f, 1.51889205e-01f, -7.52105266e-02f, 1.77446619e-01f,
  2.40593791e-01f, 5.00838339e-01f, 5.32926656e-02f, 3.14824551e-01f, 1.93777889e-01f, 7.85399526e-02f, 3.77038836e-01f, -5.80128357e-02f, 3.28851879e-01f, 2.17733175e-01f,
  1.77528448e-02f, 1.60198808e-02f, -1.22324051e-02f, -6.74124137e-02f, -4.55239601e-02f, -3.64579856e-02f, 2.80606933e-02f, 1.06328465e-01f, 7.12537766e-02f, 1.07042408e-02f,
  -1.03252986e-02f, -5.76773919e-02f, -6.27043545e-02f, 5.79498261e-02f, 6.21816367e-02f, -2.09793020e-02f, -5.84859736e-02f, -4.27652821e-02f, -5.94292246e-02f, 3.48035842e-02f,
  -1.08998835e-01f, -3.91514003e-02f, 3.89442444e-02f, -7.61513934e-02f, -7.45062903e-02f, 1.88930202e-02f, -6.78065121e-02f, 3.46255749e-02f, -5.06937914e-02f, 3.43531519e-02f,
  1.47951335e-01f, 3.32422554e-02f, -5.35625853e-02f, -5.65210395e-02f, -1.57872841e-01f, -1.01890646e-01f, 2.52359007e-02f, -1.64616965e-02f, -2.97982264e-02f, -1.50952950e-01f,
  -6.18482716e-02f, -9.13375542e-02f, 5.54762669e-02f, -2.42193062e-02f, 3.75341475e-02f, -3.85805927e-02f, -2.58083437e-02f, 1.65577650e-01f, -7.09071830e-02f, -9.88455936e-02f,
  -3.98011617e-02f, 1.01943642e-01f, -1.26533899e-02f, 8.75052586e-02f, 8.80093798e-02f, 6.23208750e-03f, 1.75869703e-01f, 1.90493874e-02f, -5.09249978e-02f, 1.29968701e-02f,
  1.60479248e-02f, 2.59000296e-03f, -4.12140787e-02f, 5.78483380e-02f, -1.93222344e-01f, -2.25936566e-02f, 1.89377479e-02f, 1.07277237e-01f, 8.44900869e-03f, 3.54995616e-02f,
  8.79346579e-02f, -6.38237521e-02f, -2.49026418e-02f, -4.13396731e-02f, 7.02906325e-02f, -5.85303120e-02f, 1.13336548e-01f, 1.05963778e-02f, -6.12929910e-02f, 2.16450673e-02f,
  -3.69891860e-02f, 3.97317037e-02f, -1.46628022e-02f, -2.35086054e-01f, -6.29627109e-02f, -4.20162454e-02f, 5.19293547e-02f, -8.91988818e-03f, 8.55018273e-02f, -1.62651371e-02f,
  -6.42281994e-02f, -5.82675934e-01f, 8.80048703e-03f, 9.68927294e-02f, 2.37687424e-01f, 1.06400818e-01f, -8.91923234e-02f, 2.26391796e-02f, 1.76866271e-03f, -2.11736262e-01f,
  -2.03123748e-01f, -2.06115380e-01f, -4.09965396e-01f, -8.53868667e-03f, 2.10639417e-01f, -3.28237355e-01f, 5.49901910e-02f, -7.50193521e-02f, -2.36306693e-02f, -2.06264824e-01f,
  2.37289388e-02f, 8.17028731e-02f, 3.80897261e-02f, 1.15324579e-01f, 2.93684397e-02f, 1.88039258e-01f, 2.08577551e-02f, -1.10955518e-02f, 2.44687080e-01f, 6.79389387e-02f,
  -1.59692004e-01f, -1.70936912e-01f, -8.05493742e-02f, 2.84574702e-02f, -6.00742139e-02f, -1.07053876e-01f, -1.03514351e-01f, 2.57329158e-02f, 4.47993204e-02f, 1.10341899e-01f,
  -2.33036652e-02f, -1.53154302e-02f, 1.88290924e-01f, 4.46831696e-02f, 4.58901823e-02f, 1.36973217e-01f, 2.32530087e-02f, -6.47929832e-02f, -5.54452613e-02f, -3.48060764e-02f,
  -4.24151868e-02f, 5.70885018e-02f, -1.36720210e-01f, 1.12229683e-01f, 4.22709528e-03f, 9.25280973e-02f, 7.89689720e-02f, -7.37006357e-03f, -5.34657277e-02f, 1.22785009e-01f,
  1.41004384e-01f, 7.64721632e-02f, -2.02495188e-01f, -4.04763483e-02f, -8.47187117e-02f, 1.23127311e-01f, 1.11266516e-01f, 3.86102498e-03f, 5.35767414e-02f, -4.90264669e-02f,
  2.17552762e-02f, -7.31849968e-02f, 9.06076375e-03f, -4.78198156e-02f, -3.40719447e-02f, 6.05147220e-02f, 3.60651165e-02f, -3.68706807e-02f, -3.77094708e-02f, -8.91179312e-03f,
  3.89479543e-03f, 3.34449783e-02f, -4.40399013e-02f, 6.67336807e-02f, 6.16997816e-02f, -9.77197569e-03f, -1.86025798e-02f, -2.33973395e-02f, -1.76927131e-02f, -8.87925997e-02f,
  -6.04243994e-01f, -3.20169091e-01f, -7.58118555e-02f, -2.50711516e-02f, -7.62974843e-02f, -6.02608696e-02f, 1.29394745e-02f, 3.40228677e-02f, -1.38799548e-01f, -1.05904266e-01f,
  -4.70496379e-02f, 4.27574739e-02f, -2.97162496e-02f, 2.93889958e-02f, 8.03519934e-02f, -6.57660440e-02f, 2.78670285e-02f, -5.10905124e-02f, -5.90909943e-02f, 1.45815834e-02f,
  -1.03660554e-01f, -6.55770153e-02f, 7.34604150e-02f, 1.27182871e-01f, 9.50163007e-02f, 6.76085129e-02f, -5.32836020e-02f, -5.51592335e-02f, 9.11955163e-02f, -2.69522471e-03f,
  -5.88618964e-03f, -1.09401913e-02f, -1.23954810e-01f, -1.75625518e-01f, -4.80977399e-03f, -2.72922188e-01f, -3.16717833e-01f, -6.01489805e-02f, 6.38549551e-02f, -4.81452011e-02f,
  -1.34009928e-01f, 8.19288120e-02f, 1.47506461e-01f, -2.97592461e-01f, 2.90147454e-01f, 1.27952069e-01f, -2.05397472e-01f, -9.12180543e-02f, 9.01255291e-03f, -3.08292657e-01f,
  -3.26479762e-03f, -1.97564200e-01f, -5.53460605e-02f, -1.15013137e-01f, -3.54456514e-01f, -7.96114579e-02f, 1.00202791e-01f, -1.05737425e-01f, -1.84111297e-01f, 6.37956560e-02f,
  -1.00435920e-01f, -1.62395939e-01f, -1.41920060e-01f, -3.09539419e-02f, -1.40817419e-01f, -6.70005903e-02f, -5.23780845e-02f, 2.27440223e-02f, -1.56611562e-01f, -5.55852614e-02f,
  5.07598072e-02f, 5.16102836e-02f, -2.42359191e-02f, 8.74200538e-02f, -8.46614540e-02f, -4.08883542e-02f, -5.67700826e-02f, -1.75199002e-01f, -1.47316858e-01f, 7.88822547e-02f,
  5.70346154e-02f, -6.74481988e-02f, -1.41768837e-02f, 5.02961762e-02f, 3.56980078e-02f, -3.08640804e-02f, 2.19040122e-02f, 1.23411082e-01f, 1.90572515e-02f, -1.31589884e-03f,
  -8.94664600e-02f, 4.18111645e-02f, -1.32138720e-02f, 1.80536881e-02f, -7.15788677e-02f, 1.68243811e-01f, -2.59658843e-02f, -1.27607109e-02f, 1.59127004e-02f, 1.37256896e-02f,
  3.69062424e-02f, 5.03824502e-02f, -3.43164392e-02f, -4.83800098e-02f, -9.01330262e-02f, 2.53666770e-02f, 1.71914380e-02f, 9.99595225e-02f, -2.11700052e-02f, 8.67081583e-02f,
  1.09527661e-02f, 7.65162557e-02f, 1.31759107e-01f, 9.98352244e-02f, 7.37669170e-02f, 6.69587255e-02f, 1.04106151e-01f, 1.09395348e-01f, -7.02987909e-02f, -8.30729157e-02f,
  -6.81018382e-02f, -2.10570484e-01f, -1.05031900e-01f, -4.20720987e-02f, 3.56772617e-02f, 5.40382741e-03f, -4.77770828e-02f, -2.15950236e-02f, -1.08638674e-01f, -1.34180114e-01f,
  -1.17507942e-01f, 1.12049215e-01f, -1.03393853e-01f, -2.80055162e-02f, 1.40014142e-01f, 6.14409707e-02f, 3.73124145e-02f, -4.57837321e-02f, -1.49746761e-01f, 1.51469082e-01f,
  -1.08305752e-01f, -6.92023188e-02f, 1.65212244e-01f, -8.54195270e-04f, -3.18147019e-02f, 3.41502763e-02f, 5.14025390e-02f, 8.29407349e-02f, -9.29431338e-03f, 5.05234562e-02f,
  -6.72257185e-01f, 2.09470123e-01f, -1.93331525e-01f, 2.72215098e-01f, -2.38287136e-01f, -2.33938619e-01f, 4.45347838e-02f, -1.75198719e-01f, -9.14408416e-02f, 3.63192856e-01f,
  2.48449370e-01f, -3.03279907e-01f, 1.83486566e-01f, 4.70826238e-01f, -3.62424046e-01f, 4.15389001e-01f, 2.27951095e-01f, 1.12936445e-01f, -6.43594041e-02f, -3.41063477e-02f,
  -6.51721284e-02f, 2.73665756e-01f, 1.17957287e-01f, -1.27114626e-02f, -1.68366358e-01f, -4.96475212e-02f, 1.99443772e-01f, -1.16336741e-01f, 1.22482531e-01f, -1.56659186e-01f,
  -2.40663588e-01f, -8.81804973e-02f, -9.92788300e-02f, -1.12522855e-01f, -9.35199857e-02f, -6.35286942e-02f, -1.03228621e-01f, -5.43078333e-02f, -4.80644815e-02f, -5.63677847e-02f,
  -5.19756712e-02f, -6.47541881e-02f, 2.37382967e-02f, -1.18671125e-02f, -1.11518554e-01f, 3.52854393e-02f, 6.99867085e-02f, 8.56454000e-02f, 9.32564121e-03f, 2.39864327e-02f,
  4.49379273e-02f, 3.84465754e-02f, 1.54560581e-01f, 9.71779078e-02f, 3.07876859e-02f, 1.14859551e-01f, 1.16004590e-02f, -5.69665432e-02f, -8.22527930e-02f, -5.03516980e-02f,
  -1.72166061e-02f, 2.85497662e-02f, -5.02744950e-02f, -2.36285925e-02f, -1.93453040e-02f, 6.14535995e-02f, 8.31837766e-03f, -1.22700155e-01f, 5.17552458e-02f, 7.91557878e-03f,
  -1.04471631e-01f, 7.10765785e-03f, 6.88848421e-02f, 7.74074048e-02f, 6.83974028e-02f, 5.25683761e-02f, -1.65392868e-02f, -2.18489952e-02f, -3.43115926e-02f, -2.95289550e-02f,
  2.08922606e-02f, 2.69163977e-02f, 1.10323824e-01f, 6.18171915e-02f, -4.87744100e-02f, 2.69212164e-02f, 6.66350722e-02f, 4.95297760e-02f, 4.58177552e-03f, -1.07207641e-01f,
  -4.20618147e-01f, -2.52416432e-01f, 5.44821378e-03f, -1.84598058e-01f, -7.93452635e-02f, -8.92156269e-03f, 5.16971387e-02f, -1.25150234e-01f, -9.59061235e-02f, -3.88340615e-02f,
  -3.52591760e-02f, 3.82582769e-02f, -1.33133024e-01f, -5.23393117e-02f, 9.30840001e-02f, 6.76997453e-02f, 1.00413911e-01f, -5.46334572e-02f, -1.13074938e-02f, -1.42861128e-01f,
  3.35084982e-02f, -1.44626442e-02f, 4.36121896e-02f, 6.05725497e-02f, -2.55900472e-02f, 2.56828573e-02f, -6.15944751e-02f, 3.22309583e-02f, 9.54283495e-03f, 3.04864366e-02f,
  1.25535816e-01f, -2.33411923e-01f, -1.62918881e-01f, -2.81721205e-01f, -1.96243346e-01f, -2.82194555e-01f, -2.30205148e-01f, -2.78919727e-01f, -6.28342777e-02f, -6.37895614e-02f,
  -1.31047279e-01f, 1.65153459e-01f, 1.59562886e-01f, -2.57242769e-01f, 2.49651209e-01f, 2.53970861e-01f, -2.16844141e-01f, -8.28455389e-02f, -1.57428339e-01f, -1.70709655e-01f,
  -7.71210566e-02f, -2.12807566e-01f, 1.60662513e-02f, -2.61814982e-01f, -3.42042178e-01f, -1.69306561e-01f, -1.32751450e-01f, -1.33812875e-01f, -2.67204911e-01f, -5.12565114e-02f,
  -1.24409303e-01f, 1.56637117e-01f, 9.82348248e-02f, 7.72849470e-02f, -7.96839520e-02f, -2.62111682e-03f, -9.82637256e-02f, 7.00568929e-02f, 1.34401871e-02f, 1.02855608e-01f,
  1.01506695e-01f, 3.58710699e-02f, 4.34155650e-02f, -8.51160195e-03f, -9.04162303e-02f, -4.99376468e-02f, -5.19136293e-03f, -3.59064899e-02f, 5.60147911e-02f, 1.57692768e-02f,
  -5.70518197e-03f, 1.50249362e-01f, -1.00165702e-01f, 5.06743155e-02f, 4.50689113e-03f, -9.05988812e-02f, 1.83089852e-01f, 7.33304620e-02f, 6.11809120e-02f, 8.35204795e-02f,
  -9.42768808e-03f, -4.04051021e-02f, 5.13222627e-02f, -2.56517082e-02f, 8.58923122e-02f, 3.30633409e-02f, 6.83891848e-02f, 6.46312013e-02f, 9.88883600e-02f, 1.18973069e-01f,
  1.07438713e-01f, 8.80450606e-02f, 1.24017680e-02f, -4.01386246e-02f, -1.07943475e-01f, 1.49293467e-01f, 1.08564496e-01f, -3.10014002e-02f, -6.12982027e-02f, -7.84606636e-02f,
  2.53467709e-02f, 7.33337998e-02f, -7.73230642e-02f, -1.50620297e-01f, -1.68408692e-01f, 1.08209744e-01f, -1.05907209e-01f, 5.20124286e-02f, -1.58420522e-02f, 2.06936281e-02f,
  -6.26792982e-02f, -3.28075886e-03f, 4.38662097e-02f, 7.81676546e-02f, 1.88601837e-02f, -9.21431482e-02f, -8.47834647e-02f, -9.16245356e-02f, -5.52737005e-02f, -7.00802263e-03f,
  -1.38757512e-01f, 6.09150790e-02f, -2.17457004e-02f, -1.44232690e-01f, -5.77838980e-02f, -5.68927266e-02f, 2.06006207e-02f, 1.02187335e-01f, -2.30626948e-02f, -2.45095082e-02f,
  2.91215517e-02f, 1.52788907e-01f, 1.55906200e-01f, 4.36124280e-02f, 7.54530877e-02f, -2.55950559e-02f, 2.29074862e-02f, -7.01900572e-03f, 9.88255441e-02f, -3.45790349e-02f,
  -5.97581685e-01f, 4.28791046e-01f, 2.59182662e-01f, -5.32373250e-01f, 2.86190629e-01f, 1.43384412e-01f, -3.46618056e-01f, 1.94467172e-01f, -1.25958130e-01f, -1.57318458e-01f,
  -1.16864190e-01f, -1.48337156e-01f, 1.95312515e-01f, -1.28152341e-01f, 1.38500584e-02f, 2.10487261e-01f, -1.86080113e-01f, -2.84843922e-01f, 7.53058642e-02f, -1.17722094e-01f,
  -6.40322790e-02f, -1.79511711e-01f, 5.24205947e-03f, 1.40942752e-01f, -1.61027815e-02f, -8.32011476e-02f, -2.02890709e-01f, 1.28091276e-01f, -4.15780619e-02f, 6.64389431e-02f,
  -4.90821563e-02f, -2.76582927e-01f, 7.48298764e-02f, 1.28432587e-01f, -1.30679412e-02f, -3.85676175e-02f, -1.53171986e-01f, 4.47021611e-02f, 2.36846469e-02f, 4.99991886e-02f,
  -7.66113997e-02f, 2.16320902e-03f, -1.21417247e-01f, 1.39228418e-01f, -8.92266817e-03f, 3.17721702e-02f, 1.25899166e-01f, 9.09578577e-02f, 9.37421322e-02f, 1.59968585e-01f,
  1.66578084e-01f, 9.15682018e-02f, 1.93274417e-03f, -7.26401359e-02f, 8.66814703e-02f, -6.62618205e-02f, -1.09610252e-01f, 3.53661142e-02f, 3.60686146e-02f, 6.94664987e-03f,
  2.55832286e-03f, -6.97446167e-02f, 1.12823337e-01f, 2.93074120e-02f, 3.43442932e-02f, 1.85432900e-02f, 4.09356505e-02f, -7.51458108e-02f, -5.37486076e-02f, -7.74299949e-02f,
  -5.23658097e-02f, -7.55097866e-02f, -9.10003632e-02f, -1.02049850e-01f, -1.03398435e-01f, -9.44487825e-02f, 3.46904397e-02f, 1.00912955e-02f, 2.22627968e-02f, -8.43405053e-02f,
  -2.81989668e-02f, -1.04605734e-01f, -7.42822140e-02f, -1.33092552e-01f, 2.42564324e-02f, 6.44102767e-02f, -1.23057133e-02f, 4.16755080e-02f, -6.86309934e-02f, 3.62517983e-02f,
  -1.13163531e-01f, -4.98977542e-01f, -4.29457799e-02f, -4.01217006e-02f, 2.31760759e-02f, 3.56804617e-02f, -3.75204696e-03f, 2.60757487e-02f, -2.78863646e-02f, 4.97111604e-02f,
  3.51391695e-02f, -7.18251839e-02f, -1.89988464e-02f, -1.25740767e-02f, -7.71882012e-02f, -1.20242964e-02f, -1.07461974e-01f, -5.80428503e-02f, -2.27557383e-02f, 1.41715799e-02f,
  1.06796473e-01f, -2.62151230e-02f, 1.58584695e-02f, -1.09798171e-01f, -6.75988272e-02f, -9.81454700e-02f, -1.33873343e-01f, -1.03984727e-02f, -2.07628664e-02f, -4.08241600e-02f,
  -5.79900108e-02f, 2.83286929e-01f, 3.19170356e-01f, 4.00400639e-01f, -2.48069003e-01f, -3.95677537e-01f, -2.58178622e-01f, 5.24497628e-02f, -1.71485022e-01f, -1.00353986e-01f,
  2.35116086e-03f, 1.72655255e-01f, -1.20288610e-01f, 1.22141115e-01f, -9.98046175e-02f, -3.04433644e-01f, 3.29041760e-03f, -1.92839891e-01f, -1.09514490e-01f, 1.28010795e-01f,
  1.10868514e-01f, -8.73601288e-02f, 2.22240135e-01f, 4.41728234e-02f, -6.80957269e-03f, 3.14122647e-01f, 2.93557882e-01f, 8.89302120e-02f, 2.34222680e-01f, -9.99376252e-02f,
  -1.14488773e-01f, 7.08575100e-02f, -5.25350962e-03f, -1.03546664e-01f, 9.28516984e-02f, 2.30702385e-02f, 7.14219781e-03f, 1.20715396e-02f, 1.47008989e-03f, 7.92628229e-02f,
  1.86677165e-02f, -1.50123417e-01f, 1.13188088e-01f, -5.67578860e-02f, -5.53935580e-02f, 3.22203338e-02f, 5.25103547e-02f, -4.37835790e-02f, -1.68350607e-03f, 1.34664088e-01f,
  2.24514529e-01f, 2.24623121e-02f, 5.80003075e-02f, 6.13000104e-03f, 1.15180552e-01f, -1.80900493e-03f, -9.57315490e-02f, 1.43557042e-01f, 4.65280451e-02f, -2.90365703e-02f,
  1.25186458e-01f, -3.90836149e-02f, -1.00620799e-01f, -1.30636543e-01f, -4.38538119e-02f, -8.53042454e-02f, -6.34426549e-02f, 6.33145720e-02f, -3.10754105e-02f, -5.22867441e-02f,
  -1.32871211e-01f, -2.27106065e-02f, -1.24539673e-01f, -9.97496489e-03f, 8.03412311e-03f, -5.95332645e-02f, -2.24945904e-03f, -2.23800354e-02f, 1.15578502e-01f, 7.14835152e-02f,
  1.28766410e-02f, -7.40812942e-02f, -1.74031314e-02f, -5.57340682e-02f, -1.53691530e-01f, 6.46161735e-02f, 1.18626356e-01f, -4.34894487e-03f, 4.30031680e-02f, 1.30948350e-01f,
  1.15490250e-01f, 2.98621655e-01f, 7.41447806e-02f, -1.00966156e-01f, -5.34932315e-02f, 8.84429365e-02f, -3.13703343e-02f, 8.82013962e-02f, 4.33507450e-02f, -3.56285833e-02f,
  1.13201015e-01f, -6.47732019e-02f, 4.19079810e-02f, 3.23163271e-02f, 3.26099396e-02f, 8.36972073e-02f, 7.92698562e-02f, -4.17793691e-02f, 1.13264978e-01f, 1.22223169e-01f,
  2.71533579e-01f, -6.11390881e-02f, -1.03330929e-02f, -1.26660302e-01f, 4.32118066e-02f, 5.89795150e-02f, -6.53091120e-03f, 6.15226142e-02f, 1.00170121e-01f, 7.34925419e-02f,
  2.39605814e-01f, -2.53236473e-01f, -3.20433348e-01f, -4.47585732e-02f, 2.11655706e-01f, 1.88514471e-01f, 1.38103232e-01f, -9.09945145e-02f, -3.11632842e-01f, -7.06250742e-02f,
  2.29211003e-01f, 1.48817539e-01f, -1.14443600e-02f, 4.15842146e-01f, 3.94710839e-01f, 8.90078768e-02f, 1.65828660e-01f, 6.99282885e-02f, -1.82485491e-01f, -6.55620620e-02f,
  6.35578260e-02f, 3.96957308e-01f, 1.33289337e-01f, 1.09774314e-01f, 3.15300375e-01f, -1.59609780e-01f, 1.87554657e-01f, 7.84045737e-03f, 2.48309508e-01f, 2.23866209e-01f,
  1.53093681e-01f, -3.81975528e-03f, -1.28270105e-01f, -3.66027132e-02f, 2.85091847e-02f, 1.24621071e-01f, 5.56332767e-02f, 1.66854143e-01f, 4.37844032e-03f, 5.65362955e-03f,
  3.73409949e-02f, 4.02115397e-02f, -5.86516336e-02f, 1.26502723e-01f, -5.28310649e-02f, -9.45943594e-02f, -1.19659472e-02f, -8.08127001e-02f, -1.34336099e-01f, 8.87503549e-02f,
  -8.91056210e-02f, -8.41156170e-02f, -4.15143929e-02f, -5.21867611e-02f, -1.09876163e-01f, -9.31658745e-02f, -1.61373302e-01f, -2.88134604e-03f, -8.50092247e-02f, -9.18465033e-02f,
  3.52004915e-02f, 1.38151105e-02f, 4.91622053e-02f, 3.28850672e-02f, -8.24882765e-04f, -5.04983068e-02f, -1.58423167e-02f, -7.20487386e-02f, -6.11867234e-02f, -6.65637106e-03f,
  -1.54689059e-01f, -7.36261681e-02f, -1.92169882e-02f, -2.18324130e-03f, -4.16678144e-03f, -4.72861677e-02f, -3.67555432e-02f, 6.56941161e-02f, -2.36285180e-02f, -4.74018157e-02f,
  2.52825376e-02f, 8.93464126e-03f, 4.81424816e-02f, -7.97875077e-02f, 4.42533754e-03f, 4.43730876e-02f, 1.13319241e-01f, 1.82026364e-02f, -5.28903902e-02f, 7.70286620e-02f,
  3.38220894e-02f, -7.42099956e-02f, -3.30013670e-02f, 3.38064320e-02f, -4.15647291e-02f, 1.36190414e-01f, 8.38631317e-02f, -5.49875833e-02f, 2.34000348e-02f, 3.66945416e-02f,
  7.88576975e-02f, -8.15415457e-02f, -3.54391672e-02f, 3.50306220e-02f, -1.06153898e-01f, -2.16609128e-02f, 4.19870540e-02f, -9.11915228e-02f, -5.27675748e-02f, -3.79418232e-03f,
  2.30945572e-02f, -3.88186760e-02f, -8.32933486e-02f, 1.33633213e-02f, -4.12420705e-02f, -1.75791001e-03f, 3.09312604e-02f, -5.27516194e-02f, 1.86593588e-02f, -1.43909365e-01f,
  6.26969695e-01f, -2.05404773e-01f, -5.56338914e-02f, 2.30381414e-01f, 2.26512924e-01f, 8.25032592e-02f, 1.49277210e-01f, 1.60487220e-01f, 3.01855505e-01f, -8.08073208e-02f,
  -2.33006515e-02f, -1.50783271e-01f, -1.63896918e-01f, 2.37288192e-01f, -1.30246595e-01f, -8.49457458e-02f, 1.72536388e-01f, -5.34915254e-02f, 1.13401778e-01f, 4.90192100e-02f,
  3.07136774e-01f, 2.15483323e-01f, -2.38848433e-01f, -2.15184577e-02f, 1.75019473e-01f, 4.38653136e-04f, -2.08236650e-01f, -2.16766030e-01f, -8.71258527e-02f, -1.27862856e-01f,
  9.48582739e-02f, 1.17918216e-01f, -6.82068150e-03f, -1.83719508e-02f, -1.14795212e-02f, 3.01453378e-02f, -8.67919400e-02f, -1.59015685e-01f, -2.00181585e-02f, 6.95484597e-03f,
  -5.42395376e-03f, -4.13495228e-02f, 5.35119586e-02f, -7.08846748e-02f, 8.20319802e-02f, -1.67544652e-02f, 9.51661989e-02f, 3.85513753e-02f, -6.60149008e-02f, -2.10496411e-02f,
  9.11807120e-02f, -7.40464106e-02f, 1.46950185e-01f, -1.08131528e-01f, 2.39893552e-02f, 1.09300371e-02f, -1.41864851e-01f, -7.92145655e-02f, 5.07409638e-03f, 5.80151193e-02f,
  9.08064395e-02f, 7.80425072e-02f, 6.66296929e-02f, -2.47314740e-02f, -6.26057899e-03f, 5.16617787e-04f, -6.76418468e-02f, -7.17514530e-02f, 1.12530431e-02f, -7.03739226e-02f,
  -6.47346526e-02f, 2.48397421e-02f, 4.79334258e-02f, -8.55530612e-03f, 7.95939565e-02f, 2.84251245e-03f, -1.25828356e-01f, -2.44812146e-02f, 1.65974721e-01f, -3.21643800e-02f,
  -6.32653683e-02f, 1.31619824e-02f, -1.44304866e-02f, -6.80313483e-02f, -3.28653157e-02f, 9.03890282e-02f, 1.91898644e-01f, 1.51977330e-01f, -5.59423901e-02f, 5.46576865e-02f,
  3.01347720e-03f, -1.16102651e-01f, 4.15515713e-02f, -6.36959597e-02f, -8.29495043e-02f, 1.03791855e-01f, -2.36152112e-02f, 1.35373771e-01f, -1.33936688e-01f, 1.24633186e-01f,
  1.13412380e-01f, -7.57774785e-02f, -3.62040065e-02f, 1.74658019e-02f, -9.61157829e-02f, 2.47214492e-02f, 1.12271398e-01f, -8.92478507e-03f, -1.35396142e-02f, -1.07654601e-01f,
  3.45333144e-02f, 8.12268332e-02f, 8.15202668e-02f, 3.42993103e-02f, 1.02891698e-01f, -4.07475159e-02f, -8.33238140e-02f, -5.87896779e-02f, 5.72804585e-02f, -3.15071493e-02f,
  -4.07379955e-01f, 2.12020755e-01f, -2.48338923e-01f, -3.35273474e-01f, -8.59617889e-02f, -3.34803879e-01f, -2.09891737e-01f, -8.23396444e-02f, -5.58934547e-02f, 8.60361010e-02f,
  -1.02944292e-01f, -2.77155545e-02f, 2.34467328e-01f, -2.81954482e-02f, -1.89690962e-01f, 2.23324805e-01f, -3.23774725e-01f, -2.55342960e-01f, 1.85961440e-01f, -1.96022362e-01f,
  -4.65218015e-02f, -1.82632245e-02f, -1.51470900e-01f, 1.24676675e-01f, -2.08146676e-01f, 7.11415242e-03f, 2.73034554e-02f, 1.40249178e-01f, -1.66706920e-01f, 1.14837535e-01f,
  -1.48646086e-01f, 2.20687110e-02f, -1.14329152e-01f, -8.36309269e-02f, -1.76350266e-01f, 3.24488804e-02f, -1.64278820e-01f, 3.87683250e-02f, 3.26515026e-02f, 3.26055437e-02f,
  5.12975156e-02f, -4.68490683e-02f, -1.13762859e-02f, 5.75724989e-02f, 4.93575968e-02f, -1.12989873e-01f, -2.80194972e-02f, 9.23502445e-03f, -3.38216387e-02f, 1.31206233e-02f,
  1.13283461e-02f, -5.79825714e-02f, -1.10445470e-01f, -9.29025002e-03f, -2.05279887e-02f, 3.82214040e-02f, -2.69311070e-02f, -5.50239757e-02f, -5.18588014e-02f, -1.71997234e-01f,
  2.04547137e-01f, 6.17864653e-02f, -5.60514890e-02f, 5.61089255e-03f, 4.36796583e-02f, -1.54078990e-01f, 2.68450882e-02f, -6.06311299e-02f, 8.85342062e-02f, -2.48723347e-02f,
  -8.60455260e-02f, -9.79243964e-02f, -8.40667486e-02f, -5.54371588e-02f, -1.71953980e-02f, 4.45768610e-03f, -8.64099562e-02f, -9.05287415e-02f, -3.83513905e-02f, 2.72867195e-02f,
  -1.30139822e-02f, 6.21188506e-02f, 1.55289797e-02f, -6.54470921e-02f, -7.91815072e-02f, 9.55727473e-02f, 4.89392020e-02f, -1.23417750e-01f, -1.25112832e-01f, 5.10626063e-02f,
  -2.83654392e-01f, -2.74888486e-01f, -4.49700579e-02f, -1.24743946e-01f, -1.35145992e-01f, 7.61729805e-03f, 8.23153406e-02f, 4.85176593e-02f, 3.88062410e-02f, -6.27344325e-02f,
  -7.25567713e-02f, -1.01824947e-01f, -2.12053493e-01f, 2.41730064e-02f, 4.05595638e-02f, -3.58471945e-02f, 2.82985605e-02f, -3.33276391e-02f, -2.01363474e-01f, -8.28013495e-02f,
  -1.42644182e-01f, -7.26986304e-02f, 9.68983099e-02f, -9.94955823e-02f, -6.15635887e-03f, -3.09456494e-02f, -4.83949892e-02f, 8.01600963e-02f, 2.82115191e-02f, -7.71105513e-02f,
  3.94086659e-01f, -5.29694080e-01f, 1.22349910e-01f, 3.90768141e-01f, 2.94013947e-01f, -1.39861321e-02f, 2.83410758e-01f, -1.52013257e-01f, -9.29060280e-02f, -5.61919749e-01f,
  4.62625436e-02f, 3.51626799e-02f, -1.25045866e-01f, 1.78598147e-02f, 3.07368040e-01f, -1.83710411e-01f, -5.31390682e-02f, 1.16081047e-03f, -5.78567982e-02f, 4.22064029e-02f,
  1.83167249e-01f, 8.68164450e-02f, 1.14043027e-01f, -2.32058287e-01f, 1.35652408e-01f, -1.41034201e-01f, -6.56031445e-02f, 3.48972306e-02f, -3.26234996e-02f, 1.33859396e-01f,
  7.79414997e-02f, 2.72420701e-02f, 1.03711784e-01f, -2.36513447e-02f, -5.17671108e-02f, 1.54031720e-02f, 9.55140591e-02f, 6.41999021e-02f, 2.05954060e-01f, -9.37284157e-02f,
  -4.02018502e-02f, 7.22543523e-03f, -5.50855882e-02f, 3.70577537e-02f, 9.52338874e-02f, 7.36343935e-02f, -3.74548580e-03f, 5.15669212e-02f, 1.45559870e-02f, -3.05363294e-02f,
  -3.02099362e-02f, 1.33321295e-02f, 1.74112245e-01f, -1.04307950e-01f, -2.32815836e-02f, -1.08909495e-01f, -3.87360081e-02f, 9.98406187e-02f, 8.56048837e-02f, -5.42931519e-02f,
  -7.58496150e-02f, -1.67531773e-01f, -8.44455033e-04f, 6.67866319e-02f, 9.32781547e-02f, 3.40866037e-02f, 2.93042287e-02f, 6.66091964e-03f, -6.87851608e-02f, 8.29629079e-02f,
  6.73002675e-02f, 5.90938851e-02f, -4.32334244e-02f, 2.96228994e-02f, -1.00187413e-01f, -4.66960594e-02f, 9.59263593e-02f, -1.89731568e-02f, 3.28510590e-02f, 2.45603751e-02f,
  8.00637528e-02f, 2.51158923e-02f, -4.78948243e-02f, 3.26015688e-02f, -8.11429694e-03f, 6.31817803e-02f, -1.27884552e-01f, 5.67187788e-03f, -3.34583335e-02f, 1.09789610e-01f,
  -2.82900501e-02f, -6.59188390e-01f, -6.69623092e-02f, 1.05714845e-02f, -7.71399662e-02f, -1.19443022e-01f, -1.07730053e-01f, -7.18244389e-02f, 1.95950512e-02f, 6.56250026e-03f,
  -3.69090848e-02f, 9.10418853e-02f, -4.85510007e-02f, 1.23374656e-01f, 8.47387239e-02f, -1.18282132e-01f, -6.95445240e-02f, 1.38827870e-02f, 1.04759298e-01f, 1.46912718e-02f,
  4.14692611e-02f, -1.02645062e-01f, 1.21899635e-01f, 8.79705790e-03f, -3.15969512e-02f, -6.43694103e-02f, -2.09957976e-02f, 8.33350867e-02f, -5.77686913e-02f, 7.40619004e-02f,
  2.24740550e-01f, -2.91097283e-01f, 1.91637203e-02f, 8.01782683e-02f, 1.89883843e-01f, -1.29518285e-01f, 1.90257028e-01f, -3.95861566e-02f, 1.72546417e-01f, -2.77002931e-01f,
  1.06380776e-01f, 5.90208098e-02f, 2.53938615e-01f, -1.82965130e-01f, 4.03044909e-01f, 1.33346006e-01f, -7.33821690e-02f, 2.11633667e-02f, 1.15836143e-01f, -9.05120894e-02f,
  -5.51705062e-03f, -1.24096692e-01f, 1.52103841e-01f, -2.81614721e-01f, -9.48505402e-02f, -1.75270826e-01f, -7.22052529e-02f, 1.11228593e-01f, -3.21888804e-01f, -9.57024936e-03f,
  -9.44786593e-02f, -1.12073142e-02f, -4.82948720e-02f, -1.18389226e-01f, -8.81187394e-02f, 3.79246473e-02f, 2.38365885e-02f, 1.34869203e-01f, 1.83429897e-01f, -2.69918889e-02f,
  -2.55517494e-02f, -4.28116210e-02f, -9.37858745e-02f, 3.05515551e-03f, 2.46398635e-02f, -7.77965263e-02f, 2.63407044e-02f, -1.31785765e-01f, -7.14490488e-02f, 6.24211915e-02f,
  9.90442932e-03f, -1.21581823e-01f, -2.51385141e-02f, -3.09220906e-02f, 9.21832174e-02f, -1.59389433e-02f, -2.33423375e-02f, 6.07529357e-02f, -3.51780206e-02f, 1.27337769e-01f,
  8.63301232e-02f, 1.65775299e-01f, 1.81097491e-03f, -9.82638523e-02f, -1.74720556e-01f, -1.17110349e-02f, -6.79623857e-02f, -3.73968259e-02f, -1.03738017e-01f, -9.81343389e-02f,
  -9.87545922e-02f, 1.31721571e-02f, 6.26040027e-02f, 7.06496909e-02f, -1.39956493e-02f, 3.33692729e-02f, 5.73374256e-02f, -2.94649582e-02f, 1.12965874e-01f, 2.10650116e-02f,
  -2.26965011e-03f, -1.52934471e-03f, -6.95089810e-03f, 5.28242216e-02f, 1.71030946e-02f, 1.97594911e-02f, -1.09126769e-01f, -6.17541522e-02f, 6.72989562e-02f, 3.32930200e-02f,
  -2.28200436e-01f, -2.73862958e-01f, -3.99165228e-02f, -1.74021885e-01f, -1.25534877e-01f, 1.21853244e-03f, 5.47250211e-02f, -3.01505271e-02f, -5.66873029e-02f, 5.18953428e-02f,
  7.52521604e-02f, -7.93247763e-03f, -9.53146517e-02f, 5.67053966e-02f, 3.07330210e-02f, -6.86077913e-03f, 3.05382218e-02f, 3.36464383e-02f, 2.15601996e-02f, -7.29549304e-02f,
  -8.65342766e-02f, -2.91682594e-02f, -2.61330493e-02f, -6.70753568e-02f, 8.79696310e-02f, 1.08857192e-01f, -3.31151253e-03f, -6.47126213e-02f, 6.73454702e-02f, 6.15083277e-02f,
  -3.57006639e-01f, 2.37440258e-01f, -3.24302882e-01f, -5.12232184e-02f, 5.64991236e-02f, -3.94962162e-01f, -8.41438621e-02f, -8.35153237e-02f, -5.04402742e-02f, 3.64550322e-01f,
  -1.09858043e-01f, 1.91138729e-01f, 9.98929441e-02f, -1.92619607e-01f, -6.90964997e-01f, -2.64842957e-01f, -4.49212134e-01f, -8.39088112e-02f, -5.64530082e-02f, -3.62881646e-02f,
  -2.24821210e-01f, -1.13525167e-01f, -2.74333507e-01f, 1.67268410e-01f, -3.01452931e-02f, 1.41731590e-01f, 3.39348167e-02f, 2.04154983e-01f, -1.12826146e-01f, 2.32623033e-02f,
  -1.38492599e-01f, 1.18290931e-01f, 3.02902292e-02f, 2.32995469e-02f, -2.10632578e-01f, -1.00529706e-02f, -6.66348962e-03f, 3.02234646e-02f, 5.93776873e-04f, -4.57461029e-02f,
  1.15435407e-01f, 1.93604305e-02f, 2.99134068e-02f, 8.08800831e-02f, 5.65818623e-02f, 5.06886616e-02f, -2.03944761e-02f, -1.41605631e-01f, 8.63593891e-02f, -6.63977265e-02f,
  5.61973415e-02f, -6.76929997e-03f, -2.50161835e-03f, 6.24796376e-02f, -1.09610118e-01f, 8.10662061e-02f, 1.46459145e-02f, 6.53533340e-02f, -3.60868610e-02f, -1.23488225e-01f,
  -9.39832851e-02f, -9.34745371e-02f, -2.68065347e-03f, -9.11622774e-03f, 3.77650522e-02f, -1.23313349e-02f, 6.20842688e-02f, 8.64411667e-02f, 1.93497092e-02f, -3.69217955e-02f,
  1.96642838e-02f, 2.33412255e-02f, 5.89343123e-02f, -2.72309296e-02f, -7.31384382e-02f, 6.94948360e-02f, 2.90403906e-02f, 5.88779636e-02f, -1.66439921e-01f, -5.39610088e-02f,
  1.24802306e-01f, 2.13491935e-02f, 6.31874576e-02f, 1.74167119e-02f, -7.15727732e-02f, 1.26273383e-03f, 7.69986957e-02f, -1.68927088e-02f, 2.95190327e-02f, 1.81319509e-02f,
  -5.57123199e-02f, 1.04267420e-02f, 6.54786825e-02f, 1.39103070e-01f, 3.90227661e-02f, 2.30291300e-02f, -2.17616148e-02f, -8.85080695e-02f, -6.61261305e-02f, 2.81652575e-03f,
  1.77695304e-02f, 1.15060970e-01f, -4.56750505e-02f, 1.00993672e-02f, 3.95210199e-02f, 2.72233319e-02f, 6.51964396e-02f, 5.03198691e-02f, -5.70535101e-02f, 8.23094547e-02f,
  9.25602838e-02f, 1.28611252e-01f, -1.15018645e-02f, 3.28455456e-02f, 2.60906722e-02f, 4.74181436e-02f, 7.46872798e-02f, 4.04200964e-02f, -3.13544050e-02f, 3.26129459e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  1.26906574e-01f, 1.59656987e-01f, 6.89589372e-03f, 4.65324372e-02f, 1.34463057e-01f, 3.01488116e-02f, 2.19347015e-01f, 1.71858266e-01f, 2.22653389e-01f, 2.65507847e-01f,
  3.21271449e-01f, 2.93055862e-01f, 2.52914846e-01f, 2.38651097e-01f
};

// L1_fan_Wp (Shape: 25 x 64)
const int L1_fan_Wp_rows = 25;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  1.54576674e-01f, 1.03895483e-03f, 9.67576355e-02f, 1.53315753e-01f, -9.81878266e-02f, -4.22096886e-02f, -7.13062808e-02f, -4.28210851e-03f, 3.22386883e-02f, -5.64324297e-02f,
  3.15263942e-02f, 1.21080773e-02f, 1.35689393e-01f, 1.87893081e-02f, 1.52657703e-01f, 1.19953357e-01f, -2.02567894e-02f, 3.41873243e-02f, -3.69808078e-02f, 2.82356441e-02f,
  -1.65745697e-03f, 3.11723966e-02f, 4.10146005e-02f, 7.49156773e-02f, -7.42639825e-02f, 9.64370519e-02f, 3.54649648e-02f, -1.26512095e-01f, 4.58329953e-02f, 9.92334187e-02f,
  -5.32558896e-02f, -6.57247826e-02f, 3.96399140e-01f, 2.16158152e-01f, -2.75218070e-01f, 2.05447257e-01f, 1.21833958e-01f, 2.76839674e-01f, 5.81084809e-04f, -1.27206445e-01f,
  7.65968785e-02f, -5.57652488e-02f, -2.48208702e-01f, 8.65889341e-02f, -6.74941093e-02f, -9.66367871e-02f, -1.82692055e-02f, -7.71285295e-02f, -1.26289248e-01f, -2.05512881e-01f,
  -1.49550721e-01f, -5.18874675e-02f, 1.78834409e-01f, 1.41100556e-01f, -2.96385169e-01f, -2.06819433e-03f, 4.21791477e-03f, -1.98909670e-01f, -2.55661737e-02f, 7.77959870e-03f,
  -1.09337352e-01f, 1.86512738e-01f, 1.86351284e-01f, -1.41138628e-01f, -1.50142401e-01f, -3.43934223e-02f, -1.95633431e-04f, -8.04492608e-02f, 5.05919848e-03f, -1.21847000e-02f,
  3.37362811e-02f, -5.05963303e-02f, -2.78828982e-02f, -8.43113381e-03f, -1.31955016e-02f, -1.09810971e-01f, -5.14307544e-02f, -4.65115868e-02f, -1.78264093e-03f, -2.07623169e-02f,
  1.13514766e-01f, 9.41815972e-02f, 5.89005742e-03f, 2.83647683e-02f, -1.26687184e-01f, -8.64385255e-03f, 3.25567788e-03f, -1.26851663e-01f, 1.09587004e-02f, -1.04852676e-01f,
  1.86251283e-01f, -8.79062861e-02f, -1.17376640e-01f, -9.92744938e-02f, 4.78531644e-02f, -1.48811504e-01f, -3.43045942e-03f, -1.10949226e-01f, 2.05055073e-01f, 3.87181789e-02f,
  1.86717257e-01f, 1.04109913e-01f, -2.12426737e-01f, 2.20963702e-01f, 3.65764089e-02f, -5.63660935e-02f, 1.72826469e-01f, 1.42444834e-01f, 1.30136851e-02f, 5.30266277e-02f,
  -2.42776293e-02f, -4.51757871e-02f, 2.31908068e-01f, 1.59155846e-01f, 2.78711058e-02f, 1.45049706e-01f, -1.34919867e-01f, -1.26160651e-01f, 2.26975642e-02f, -9.52909440e-02f,
  4.27853055e-02f, 1.81951210e-01f, 3.14802118e-02f, 2.37612143e-01f, 6.83287764e-03f, -9.75244045e-02f, -1.67187959e-01f, 2.88610727e-01f, 1.91086158e-01f, -1.40599996e-01f,
  -4.22489531e-02f, 1.01016723e-02f, 1.71457663e-01f, -1.12258724e-03f, 1.13275319e-01f, 1.38351945e-02f, 5.13476171e-02f, 9.87567604e-02f, -8.88259187e-02f, 2.05871060e-01f,
  -5.41660823e-02f, 1.08935498e-01f, -1.94387108e-01f, 6.86161518e-02f, 1.49630427e-01f, 4.23512347e-02f, -1.14176832e-02f, 4.02903259e-02f, -3.00630610e-02f, -4.92429957e-02f,
  -1.00495443e-02f, -1.25745898e-02f, -2.79483909e-04f, 1.65336549e-01f, -5.40486500e-02f, 1.70116290e-01f, -9.86315086e-02f, 8.55182260e-02f, 1.01199307e-01f, -1.37097821e-01f,
  -3.03200573e-01f, -2.70973742e-01f, -5.50406054e-03f, -1.12782195e-01f, -3.05812299e-01f, -3.18926781e-01f, 7.62339085e-02f, 5.47405481e-02f, -6.61018724e-03f, 1.20634809e-02f,
  3.77984941e-02f, 6.36874810e-02f, 2.16504455e-01f, 3.76708843e-02f, -5.64179057e-03f, 8.03304911e-02f, -2.39252858e-02f, 7.54989758e-02f, 2.00197130e-01f, 2.14042634e-01f,
  -5.05140200e-02f, -2.39305757e-02f, -1.50162429e-01f, 7.45657384e-02f, -2.26932883e-01f, 1.02607705e-01f, -2.09562723e-02f, 2.19193384e-01f, -1.14721544e-01f, -1.22251846e-01f,
  -1.12941884e-01f, -1.59233704e-01f, -8.46166536e-02f, -9.60119292e-02f, -4.98708151e-03f, -9.22708213e-02f, -5.06593175e-02f, 1.00148225e-03f, -1.56569399e-03f, 7.90657923e-02f,
  8.67842287e-02f, -2.61772603e-01f, -5.31214848e-02f, 1.04906112e-01f, -9.84391645e-02f, -4.53766389e-03f, -5.27906406e-04f, -2.26139069e-01f, -1.54337630e-01f, -1.41328529e-01f,
  -7.01911747e-02f, -2.77789891e-01f, -1.60700321e-01f, 8.02701190e-02f, 7.60559142e-02f, -6.97659627e-02f, -4.53550294e-02f, -1.06507912e-01f, 1.65616214e-01f, -1.46102160e-01f,
  2.87128855e-02f, -2.15828475e-02f, -8.94188061e-02f, 1.53474227e-01f, 8.08487087e-03f, 2.67765462e-01f, 3.27993296e-02f, -1.66682631e-01f, -6.69360086e-02f, 3.35664861e-02f,
  1.49769112e-01f, -4.26087677e-02f, 2.28386763e-02f, 2.42024064e-01f, -5.91704957e-02f, -1.40172720e-01f, -1.68377608e-01f, -3.88962254e-02f, 1.75792947e-01f, 9.03147683e-02f,
  -9.96247679e-02f, -1.02234378e-01f, -1.68651883e-02f, 2.92728306e-03f, 2.13118363e-02f, 1.13182575e-01f, 1.28264815e-01f, 1.46676883e-01f, -6.91215098e-02f, -2.29512960e-01f,
  2.86724657e-01f, -2.08810255e-01f, 1.31410420e-01f, 1.38427634e-02f, -1.58580095e-01f, -3.97166088e-02f, -2.07966894e-01f, 2.03383323e-02f, 5.81118874e-02f, -9.63793173e-02f,
  -1.50910735e-01f, 3.02825700e-02f, -1.38694840e-02f, 9.14991051e-02f, -8.25758725e-02f, -8.87801573e-02f, 1.30739510e-02f, -1.91336453e-01f, 3.75054516e-02f, -1.43609256e-01f,
  1.59937292e-01f, 1.37777075e-01f, 5.56547195e-02f, 9.50112864e-02f, -1.39061600e-01f, 1.44604504e-01f, 1.36763260e-01f, -1.65997595e-01f, -1.21126525e-01f, -1.08394079e-01f,
  -2.05131769e-01f, -4.11137678e-02f, -1.05489135e-01f, 1.83472827e-01f, -1.47731915e-01f, 5.67806810e-02f, 2.51513243e-01f, 3.84978428e-02f, -2.50089645e-01f, 8.90636295e-02f,
  -2.19567612e-01f, 2.14200377e-01f, -7.99162984e-02f, 9.89408419e-02f, 1.47590026e-01f, 5.97861148e-02f, -4.87420447e-02f, -1.74676329e-01f, 1.77713081e-01f, 1.96453154e-01f,
  1.17972106e-01f, -2.20352888e-01f, -2.57916778e-01f, -1.36810839e-01f, 1.44532874e-01f, 1.43111333e-01f, -3.23675154e-03f, -1.61749408e-01f, -4.92376573e-02f, 6.04573563e-02f,
  2.15583872e-02f, 4.28999402e-02f, -1.09421074e-01f, 1.12415567e-01f, -1.96247011e-01f, 9.66275185e-02f, 9.64993536e-02f, 1.42117038e-01f, 2.01445028e-01f, 1.75073072e-01f,
  -7.92636797e-02f, 2.55782139e-02f, -2.22360045e-02f, 4.98720706e-02f, 8.86761695e-02f, 1.62269250e-01f, 2.02907622e-02f, -1.80423837e-02f, -5.55591621e-02f, 1.99697651e-02f,
  -1.38239399e-01f, 3.28012928e-02f, -1.30284742e-01f, 1.09607838e-02f, -9.87425074e-02f, -2.66077608e-01f, -9.38226953e-02f, -4.33162861e-02f, -1.51245058e-01f, -1.12449713e-01f,
  -4.56427932e-02f, 7.59071633e-02f, 1.21992499e-01f, -3.27319056e-02f, 4.90916718e-04f, -1.75231658e-02f, 1.32015228e-01f, 8.55178162e-02f, 1.23740226e-01f, -1.43813565e-01f,
  9.92412567e-02f, -3.69257629e-02f, -1.03435457e-01f, -1.76454503e-02f, 7.64355808e-02f, -1.38087317e-01f, -1.82702690e-01f, -1.42518371e-01f, 1.26865968e-01f, 1.56475469e-01f,
  -8.86904225e-02f, 1.73463702e-01f, -4.90259491e-02f, 6.62436783e-02f, -1.78346764e-02f, 3.56670991e-02f, 9.88181457e-02f, 2.13689446e-01f, -1.93004221e-01f, 1.00379661e-01f,
  1.53190613e-01f, 2.57282138e-01f, -6.46413565e-02f, 1.38758048e-01f, -1.44867823e-01f, 1.66744426e-01f, -1.01962574e-01f, 2.54017813e-03f, 1.97285146e-01f, -3.69130597e-02f,
  -3.69459912e-02f, -1.81242198e-01f, -1.02506533e-01f, -1.16518788e-01f, 2.79182233e-02f, -1.55426502e-01f, -4.93372418e-02f, 6.84628636e-02f, -5.83407003e-03f, -5.27854301e-02f,
  -4.12312597e-02f, 6.76320419e-02f, -2.06389856e-02f, -5.95966205e-02f, 5.96957542e-02f, 1.41717628e-01f, -1.53474128e-02f, 4.86422703e-02f, -6.54316768e-02f, -1.10006161e-01f,
  -1.05250701e-01f, 1.10561596e-02f, -1.20195802e-02f, -1.45974740e-01f, -2.25715622e-01f, 7.28077218e-02f, 2.02666540e-02f, -3.16439755e-02f, 1.56918317e-01f, -2.11409196e-01f,
  2.39512101e-01f, -2.59904861e-01f, 8.68852660e-02f, -1.22071385e-01f, -4.98191863e-02f, -7.88987577e-02f, 2.19777048e-01f, 1.77233443e-01f, 1.48311347e-01f, -2.37120643e-01f,
  1.67614073e-01f, 1.04576349e-01f, 9.84079987e-02f, -1.75475068e-02f, -4.86510023e-02f, 1.72925085e-01f, -1.03769585e-01f, -1.19610995e-01f, -1.81654379e-01f, 2.26167232e-01f,
  1.28433570e-01f, 2.09575877e-01f, -1.80815473e-01f, -1.04781158e-01f, -8.41763243e-02f, 1.91389605e-01f, 1.29718468e-01f, -1.19093455e-01f, 1.57357126e-01f, -1.26588538e-01f,
  -1.75504550e-01f, -1.02868579e-01f, 2.41473839e-01f, -3.85633968e-02f, -2.22273067e-01f, 1.00038454e-01f, -1.21760562e-01f, -1.90736517e-01f, -5.50729483e-02f, -8.28482136e-02f,
  -1.11502491e-01f, -4.31203321e-02f, -5.06580248e-02f, 3.68028507e-02f, 5.03605464e-03f, 3.41885872e-02f, -4.53073420e-02f, 7.98768699e-02f, 1.98860317e-01f, -4.98578995e-02f,
  -1.10609960e-02f, -1.01503186e-01f, -1.35132328e-01f, 2.21362188e-02f, -2.03713644e-02f, 7.44879097e-02f, 2.13629827e-02f, -1.17565557e-01f, -1.35294810e-01f, 1.40934587e-01f,
  -3.51653472e-02f, -1.87314048e-01f, 1.39650762e-01f, -1.67859629e-01f, 2.25757971e-01f, -2.23993823e-01f, 2.18090434e-02f, -1.07228793e-01f, -2.10514307e-01f, -3.23596713e-03f,
  -8.57897326e-02f, 1.38881311e-01f, 2.56549239e-01f, -2.37670913e-01f, 2.26283357e-01f, -1.28892154e-01f, -4.19830084e-02f, 2.92913347e-01f, 3.37746032e-02f, 4.58297208e-02f,
  2.04933375e-01f, -9.91325527e-02f, 7.93880448e-02f, 1.97616115e-01f, -9.96105932e-03f, 1.49048477e-01f, 7.36444294e-02f, 4.51035351e-02f, 2.87871249e-02f, 5.64187728e-02f,
  -3.16843271e-01f, -1.43028557e-01f, 2.04168707e-01f, -1.87646508e-01f, -1.16975099e-01f, 1.53335676e-01f, 8.98310915e-03f, 4.76888791e-02f, -6.15065917e-02f, -1.31599560e-01f,
  -2.20176384e-01f, 1.56760454e-01f, 1.66400909e-01f, -7.82391280e-02f, -1.29446164e-01f, 2.40868047e-01f, 3.07644382e-02f, -1.20477136e-02f, 6.76821023e-02f, -4.10951488e-02f,
  -4.01905105e-02f, 1.74886256e-01f, 3.38627137e-02f, -5.92363067e-02f, 6.89415485e-02f, 7.97798038e-02f, -5.19133396e-02f, 1.60971228e-02f, 2.40733847e-02f, 1.02577597e-01f,
  6.12665080e-02f, -9.84393060e-03f, -2.22510868e-03f, -3.14749330e-02f, 5.52755930e-02f, 1.00610398e-01f, 1.92133710e-01f, -1.01448009e-02f, 7.32637495e-02f, -1.99633315e-01f,
  6.70062825e-02f, -1.95620153e-02f, -2.51291543e-01f, -1.18697092e-01f, -5.55406744e-03f, -2.38093827e-02f, 1.54537618e-01f, -1.28645688e-01f, 1.89180344e-01f, -1.70264617e-01f,
  -1.57909051e-01f, 1.47162117e-02f, 1.39412982e-02f, -1.69605464e-01f, 2.82813348e-02f, -1.58133209e-02f, 7.11914292e-03f, 1.33162126e-01f, 9.07940604e-03f, 1.63506567e-01f,
  9.10663009e-02f, 5.97917661e-02f, 4.90209498e-02f, -6.26632944e-02f, -8.88407156e-02f, -1.18728280e-01f, 1.77458033e-01f, -1.40384406e-01f, -7.44976103e-02f, 2.03471869e-01f,
  -1.80796757e-01f, 1.45693019e-01f, -1.30403236e-01f, -1.94208488e-01f, -6.38921708e-02f, -1.01694323e-01f, -1.20728705e-02f, 7.66060129e-02f, 3.08071375e-02f, -8.03620815e-02f,
  -8.58950168e-02f, -1.76351041e-01f, 4.52518240e-02f, 2.54718531e-02f, -5.22926077e-03f, -1.89501755e-02f, -1.71477854e-01f, 1.23580791e-01f, -5.33869211e-03f, 1.47649543e-02f,
  5.46448827e-02f, -7.87072480e-02f, 8.93180352e-03f, -9.84112695e-02f, -5.67301083e-03f, 4.97286161e-03f, 5.72136343e-02f, -1.94773734e-01f, -6.81372285e-02f, 1.95824981e-01f,
  -2.32502036e-02f, 9.58618149e-02f, -7.27043450e-02f, -3.96633074e-02f, -1.81049153e-01f, -1.03347056e-01f, 1.98035613e-01f, 9.57209617e-02f, 2.21588150e-01f, -1.72540769e-01f,
  -4.96679470e-02f, 3.05153400e-01f, 1.06610872e-01f, 1.92981988e-01f, 1.32593974e-01f, -1.48075297e-01f, -1.72447473e-01f, -7.62463883e-02f, -1.94942355e-01f, 8.45410898e-02f,
  -1.29202873e-01f, -9.39920470e-02f, -4.24848646e-02f, -1.02809481e-01f, -2.83424556e-02f, -9.13875084e-03f, 2.07972527e-01f, -1.36200609e-02f, 2.76181400e-01f, 1.31365001e-01f,
  9.00971368e-02f, -6.48611113e-02f, 2.46342465e-01f, 9.64118317e-02f, 1.18889488e-01f, -1.61888555e-01f, 2.24788174e-01f, -3.04194205e-02f, 3.62569876e-02f, -5.29837534e-02f,
  2.38236394e-02f, -3.94009762e-02f, -7.05170259e-02f, 1.01190120e-01f, 7.97028467e-02f, -4.35662232e-02f, 7.57710189e-02f, 3.72122191e-02f, 4.01978269e-02f, 6.95480406e-02f,
  -4.23449986e-02f, 1.22561447e-01f, -7.87972510e-02f, -2.52093505e-02f, 4.99000363e-02f, 1.35521382e-01f, 7.71325082e-02f, 1.00593127e-01f, 9.29858088e-02f, 1.02659158e-01f,
  2.86469888e-02f, -1.06653266e-01f, 2.89784390e-02f, 3.80465165e-02f, -6.67382851e-02f, 1.30321801e-01f, -1.49591699e-01f, 1.79007009e-01f, -3.07758730e-02f, 2.71530837e-01f,
  1.33793175e-01f, -6.57938495e-02f, -2.97206402e-01f, -1.78633451e-01f, -2.36314401e-01f, 6.56211525e-02f, -2.71987736e-01f, -3.69251966e-02f, 1.38482496e-01f, 9.18470509e-03f,
  1.02202505e-01f, 1.00150406e-01f, 2.69081891e-01f, 1.08890668e-01f, 2.30139107e-01f, -1.31578147e-01f, -1.48054004e-01f, -2.61165619e-01f, 5.33837080e-02f, 1.94191873e-01f,
  1.12196989e-02f, 5.57847619e-02f, 7.81859737e-03f, -4.40013744e-02f, -2.38311052e-01f, 6.73132911e-02f, -2.71632969e-01f, 2.34437078e-01f, -1.63466334e-02f, 1.42959207e-01f,
  -1.90281689e-01f, 1.02602705e-01f, 1.89997643e-01f, -9.31707919e-02f, -5.56858107e-02f, 1.01927832e-01f, 6.50684163e-02f, -3.69149633e-02f, 2.89055202e-02f, 1.08371131e-01f,
  1.16214663e-01f, 6.73044175e-02f, 1.60625968e-02f, -1.33277044e-01f, -3.70741524e-02f, -6.64000679e-03f, -4.26218249e-02f, 1.03091322e-01f, 7.41358697e-02f, 1.01132624e-01f,
  4.76033874e-02f, 2.17407085e-02f, 3.60024907e-02f, 9.72791985e-02f, 6.29788917e-03f, -4.68892753e-02f, 2.17101630e-03f, 3.82532761e-03f, -4.87169251e-02f, 7.42194355e-02f,
  -1.77929595e-01f, 2.72864401e-01f, 3.08261067e-02f, 6.64802417e-02f, 2.73941785e-01f, -1.63447976e-01f, -1.61437482e-01f, -9.31705683e-02f, -2.79700249e-01f, 9.83688049e-03f,
  -2.55882889e-01f, 6.92592040e-02f, 6.80490881e-02f, -6.17659874e-02f, 1.63779147e-02f, 8.64528641e-02f, 5.85927591e-02f, 2.01415792e-02f, 1.08701944e-01f, -1.54648855e-01f,
  -1.14648059e-01f, -6.93697035e-02f, -2.28851736e-02f, 4.42469008e-02f, -1.33472010e-01f, -1.67981163e-02f, 2.36503303e-01f, 1.14854068e-01f, -2.56937474e-01f, 1.97778627e-01f,
  -1.62647381e-01f, -1.02945521e-01f, 5.50726391e-02f, 2.01486722e-01f, 5.44963665e-02f, 2.79767454e-01f, 1.81317434e-01f, 4.99494560e-02f, 2.71313023e-02f, -4.43467945e-02f,
  9.20481142e-03f, 4.12048250e-02f, 2.72471886e-02f, 5.46145206e-03f, 4.27891128e-02f, 2.26697605e-02f, 2.93927919e-02f, -5.43947741e-02f, 1.96429081e-02f, 1.99160323e-01f,
  -1.41486421e-01f, 1.58771705e-02f, -1.15728304e-01f, -1.88659444e-01f, -1.22738063e-01f, 5.52718341e-02f, -1.73844174e-01f, -8.84286761e-02f, -2.00139001e-01f, -1.50370719e-02f,
  1.28088757e-01f, -1.16963340e-02f, 1.09777652e-01f, -1.13124818e-01f, 9.71250907e-02f, -6.72330633e-02f, 1.42718032e-01f, -1.46903386e-02f, 1.32597506e-01f, -1.80361748e-01f,
  -1.57863006e-01f, -7.57957995e-02f, -2.74900906e-02f, -2.93540865e-01f, -9.28803459e-02f, -1.49744242e-01f, 1.17546916e-01f, -8.77961237e-03f, -9.07476991e-02f, 9.60364491e-02f,
  -7.29765818e-02f, -2.20961664e-02f, -1.41122416e-02f, 1.19002365e-01f, 5.55989631e-02f, 2.37266749e-01f, -1.78305045e-01f, 3.62770185e-02f, 1.27692342e-01f, 1.89019546e-01f,
  1.80996209e-01f, 1.13265701e-01f, 3.80681455e-02f, 1.46360934e-01f, -2.49434099e-01f, -1.68797776e-01f, 1.68425024e-01f, 1.31446263e-03f, -4.85014170e-02f, 1.49467766e-01f,
  6.46430850e-02f, -1.43651009e-01f, 2.84614731e-02f, -7.93328211e-02f, -1.29208609e-01f, -4.02741283e-02f, -5.85536174e-02f, -9.67956781e-02f, -5.36092035e-02f, 5.06274924e-02f,
  4.39038053e-02f, -2.60564461e-02f, -1.36861637e-01f, 7.16955587e-02f, -7.56196007e-02f, -6.91808090e-02f, -1.46749899e-01f, -3.38227451e-02f, -8.35607946e-02f, -8.89773369e-02f,
  -6.94749877e-02f, -2.60569245e-01f, 4.41754162e-02f, -1.26116142e-01f, -4.65951674e-03f, 1.16709493e-01f, 3.16483751e-02f, -8.02860558e-02f, 1.48965418e-01f, -8.32887366e-02f,
  -4.17157561e-02f, -1.27049088e-01f, 1.11830523e-02f, 1.59216315e-01f, 3.43929306e-02f, -1.03683673e-01f, 3.08305532e-01f, -8.13817009e-02f, 1.54546246e-01f, -3.07692289e-02f,
  7.92267248e-02f, -1.17807679e-01f, -2.11277306e-01f, 5.41905724e-02f, -1.07499070e-01f, -1.01435818e-01f, -2.65699744e-01f, 9.87798274e-02f, 2.17731893e-02f, 4.80520055e-02f,
  -7.14396760e-02f, 6.45201607e-03f, 2.31101900e-01f, 1.17620863e-01f, 7.42141902e-02f, -5.20842075e-02f, 3.31123948e-01f, -1.28675774e-01f, 2.09634781e-01f, -2.69302297e-02f,
  1.75995544e-01f, -1.49587691e-01f, 7.61864409e-02f, -1.95302605e-03f, -2.36675531e-01f, -5.59618659e-02f, 7.26247057e-02f, -1.55245423e-01f, -3.36047588e-03f, 5.92682399e-02f,
  2.15578489e-02f, -7.90196508e-02f, -1.84624307e-02f, -6.87400326e-02f, -6.88332990e-02f, -4.20658104e-02f, 6.51829317e-02f, -1.79658905e-01f, -6.07537813e-02f, -6.68918192e-02f,
  -9.04559568e-02f, -2.00124141e-02f, 4.62739207e-02f, 1.30715504e-01f, 8.72689188e-02f, 3.36477533e-02f, -1.63176849e-01f, 3.83920409e-02f, -1.27849281e-02f, -1.24447145e-01f,
  1.80758089e-01f, 2.37335712e-02f, 1.67775273e-01f, -1.36471316e-01f, -1.86465718e-02f, -1.52452201e-01f, 1.21270515e-01f, -2.94993728e-01f, 8.15921649e-02f, -5.40347844e-02f,
  -8.02503526e-03f, -6.73097074e-02f, 1.48993254e-01f, 8.32778290e-02f, -1.31630883e-01f, 1.80628642e-01f, -9.11783706e-03f, -3.81881632e-02f, -3.57979513e-03f, 2.09351867e-01f,
  1.34026483e-01f, 1.96000695e-01f, -1.81960270e-01f, 1.35269746e-01f, 2.83598490e-02f, 1.96591187e-02f, 6.35291189e-02f, 2.28290260e-01f, 2.75578760e-02f, -2.40133047e-01f,
  -2.12437332e-01f, -2.65197605e-01f, -2.84460455e-01f, 4.72038202e-02f, 3.78485173e-02f, 2.34161198e-01f, -2.96506494e-01f, 2.09389612e-01f, -1.25208706e-01f, -8.25797468e-02f,
  -2.03033224e-01f, 1.34940937e-01f, -2.32476778e-02f, -6.91667199e-02f, -1.41095623e-01f, 3.53863128e-02f, 8.61828327e-02f, 4.21283161e-03f, 3.12021151e-02f, -3.04027442e-02f,
  -4.90220301e-02f, -1.66557252e-01f, 1.21286437e-01f, 2.22694017e-02f, 2.60744929e-01f, 6.52957782e-02f, -3.28866765e-02f, -1.45961478e-01f, -3.26433638e-03f, 1.74829178e-02f,
  1.17608458e-01f, -8.12119246e-03f, -5.27916811e-02f, 6.13747463e-02f, -2.20203195e-02f, -7.28419656e-03f, 7.92722311e-03f, -3.13136801e-02f, -1.19714484e-01f, -9.46923420e-02f,
  -1.25569291e-02f, 1.46786883e-01f, 1.21864788e-01f, -3.27682961e-03f, 7.26922899e-02f, 1.23957060e-01f, 2.45999396e-01f, 1.58803180e-01f, -7.23114163e-02f, -1.79187626e-01f,
  1.49121974e-02f, -9.57508162e-02f, -5.58821484e-02f, -4.22640853e-02f, -2.78583080e-01f, -1.29247189e-01f, -2.00993996e-02f, -1.12584919e-01f, 5.69513552e-02f, -4.26358823e-03f,
  -6.70518875e-02f, -1.76175907e-01f, 1.47897616e-01f, 1.76526252e-02f, 3.01426530e-01f, 4.70011048e-02f, 1.75755188e-01f, -1.19601324e-01f, -1.05800904e-01f, -8.97341669e-02f,
  2.15588108e-01f, 1.02132685e-01f, 5.32855988e-02f, 2.89314240e-01f, -8.73005204e-03f, -1.49330702e-02f, 1.44273639e-04f, 1.55408438e-02f, 1.42181152e-02f, 1.88205525e-01f,
  8.67108256e-02f, 6.45920560e-02f, -5.06618246e-02f, 3.52042615e-02f, 8.74094199e-03f, -1.18570387e-01f, -1.12071298e-01f, 1.10365167e-01f, -9.20600519e-02f, 1.15918294e-01f,
  -3.91038246e-02f, 9.13463160e-02f, -6.32549971e-02f, 7.65405893e-02f, -6.61405101e-02f, 1.04280621e-01f, 8.38587508e-02f, -1.08708531e-01f, 1.52735189e-01f, -2.78276086e-01f,
  -2.09007487e-02f, 6.82163984e-03f, 2.94934455e-02f, -2.59592652e-01f, -6.78520501e-02f, -3.11227798e-01f, 1.20922178e-02f, 8.25424865e-02f, 7.24711418e-02f, -4.07586366e-01f,
  1.01691633e-01f, -6.35831133e-02f, -4.07811329e-02f, -7.92284235e-02f, -1.44294158e-01f, -4.96734958e-03f, 6.54176027e-02f, -8.03230517e-03f, -1.70057348e-03f, 1.53089672e-01f,
  -5.79149798e-02f, 1.67244568e-01f, -8.58076289e-02f, -3.30961160e-02f, -1.76883250e-01f, 8.95459503e-02f, -9.06646550e-02f, 4.00732160e-02f, -2.00485721e-01f, 5.30885532e-02f,
  -1.77098632e-01f, -1.74840197e-01f, 3.78252752e-02f, 9.91929173e-02f, 3.35204899e-02f, -1.91714481e-01f, -1.30276471e-01f, 1.71138540e-01f, -1.71058372e-01f, 5.34653403e-02f,
  3.23885418e-02f, -3.50523107e-02f, -8.59284103e-02f, 1.70208439e-01f, -4.95804697e-02f, 1.25259832e-01f, 7.88923576e-02f, -1.53693095e-01f, -1.15010561e-02f, 3.95151749e-02f,
  3.09721455e-02f, -1.07477143e-01f, 2.02533707e-01f, 4.62217368e-02f, -1.55711308e-01f, -1.93357348e-01f, -8.72530602e-03f, -1.07680634e-01f, 3.98505591e-02f, -4.29792553e-02f,
  -6.90093869e-03f, 4.50213104e-02f, -1.82601944e-01f, -2.08887130e-01f, -2.35438198e-02f, -9.84867588e-02f, -2.75449059e-03f, -1.57222480e-01f, -1.16023809e-01f, 3.26869160e-01f,
  2.09800467e-01f, 2.48131528e-01f, -3.48744914e-03f, 1.45560324e-01f, 1.76858917e-01f, 2.33352229e-01f, 1.43443599e-01f, -1.03820190e-01f, -6.29464909e-02f, 1.18596062e-01f,
  -8.14782307e-02f, -5.48365004e-02f, -2.92691737e-01f, -8.57402310e-02f, 1.31978452e-01f, -4.03409936e-02f, 3.85608971e-02f, -7.04688504e-02f, -1.10383831e-01f, -1.51762486e-01f,
  1.64340332e-01f, 2.09473521e-01f, 1.89797595e-01f, 1.57370329e-01f, 1.83666825e-01f, -7.12870210e-02f, 2.93318555e-02f, -2.25527376e-01f, 2.58263409e-01f, -6.55922517e-02f,
  1.51886523e-01f, 1.66994676e-01f, -1.90576747e-01f, 8.28177631e-02f, 1.11734439e-02f, -4.80640568e-02f, -1.59578145e-01f, 5.47686331e-02f, 6.72379509e-02f, -1.63327605e-01f,
  -1.23330601e-01f, 5.77615276e-02f, -5.58836460e-02f, -3.14233184e-01f, -3.97525690e-02f, -6.59931302e-02f, 7.78853223e-02f, -1.57398805e-01f, 1.99209601e-02f, -1.62594929e-01f,
  -1.84462150e-03f, 1.56696096e-01f, 6.16291612e-02f, 1.64558645e-02f, 4.70769405e-02f, -1.20445706e-01f, -2.23314703e-01f, 2.28341557e-02f, -3.73703577e-02f, 1.78271085e-02f,
  -1.68047935e-01f, -1.31090939e-01f, -8.36442336e-02f, -1.44417363e-03f, 1.70853212e-01f, -9.83296521e-03f, 7.34124929e-02f, 1.97210431e-01f, 7.74730295e-02f, 4.74862307e-02f,
  -2.82228023e-01f, 2.18385637e-01f, 1.74438700e-01f, -1.41013190e-01f, 3.00709549e-02f, 1.45174593e-01f, -8.12737737e-03f, 1.06466990e-02f, -1.08805276e-01f, -1.12569980e-01f,
  2.73720086e-01f, 1.35717228e-01f, -4.86514308e-02f, -2.14996785e-01f, -1.63388312e-01f, 1.47493616e-01f, -6.40417114e-02f, 3.46811600e-02f, 1.37320682e-01f, -3.76024237e-03f,
  -2.36323416e-01f, -8.07985216e-02f, 1.43476278e-01f, -1.16725583e-02f, -1.33134276e-01f, 2.42072821e-01f, -8.14578906e-02f, -4.84990515e-02f, -7.72727355e-02f, 7.55775422e-02f,
  7.03713484e-03f, 9.81500819e-02f, 1.66080803e-01f, 1.36435246e-02f, -6.85254037e-02f, 1.83046669e-01f, 7.76933208e-02f, -9.01789516e-02f, -8.43939930e-03f, -9.02590230e-02f,
  -8.31817612e-02f, 6.32914752e-02f, -4.25773449e-02f, 7.49757215e-02f, 1.47374067e-02f, -2.05246080e-03f, 9.66932066e-03f, 1.11856833e-01f, -3.35518201e-03f, -1.93508983e-01f,
  1.93555668e-01f, -1.74566105e-01f, 1.20153666e-01f, -2.00146269e-02f, 1.62673707e-04f, -7.45555982e-02f, -2.16133088e-01f, -9.71233770e-02f, -2.07405791e-01f, -3.17572765e-02f,
  3.20241928e-01f, -2.49663949e-01f, 1.38380468e-01f, -1.80453569e-01f, -1.58970192e-01f, 9.42999423e-02f, -6.06859326e-02f, -7.31706545e-02f, 2.31502861e-01f, -3.99318933e-02f,
  1.06824175e-01f, 1.43319607e-01f, 2.22276859e-02f, 1.10688306e-01f, 9.07973051e-02f, 8.80262628e-02f, 8.44463557e-02f, -6.26464337e-02f, -2.44231001e-01f, -1.41519442e-01f,
  2.22604960e-01f, -1.56459942e-01f, -5.49863987e-02f, 2.57612854e-01f, -3.93675230e-02f, 6.94465041e-02f, 4.95873205e-02f, -1.91968009e-01f, -1.31777748e-01f, 3.25497240e-01f,
  2.22418532e-01f, -1.19268961e-01f, 8.62515792e-02f, 1.73893601e-01f, 7.83805698e-02f, -7.62858242e-03f, -3.58078582e-03f, 9.16180983e-02f, 3.45276482e-02f, 1.32836163e-01f,
  9.66078341e-02f, 1.99486062e-01f, 5.02500385e-02f, 8.16633403e-02f, -6.26678988e-02f, 8.45756829e-02f, -1.32922694e-01f, 1.03659369e-01f, 2.87789926e-02f, -3.98438983e-03f,
  -7.57907256e-02f, 4.39710580e-02f, 1.64872892e-02f, -2.24824101e-02f, 2.22985893e-01f, -1.08154953e-01f, 7.34887570e-02f, -1.34207606e-01f, 2.68041879e-01f, -8.76242816e-02f,
  -1.07698381e-01f, 7.49945268e-03f, 2.36474216e-01f, 1.69389665e-01f, 1.31306455e-01f, -2.10362867e-01f, 6.89552631e-03f, -5.97274005e-02f, 2.32315049e-01f, 7.38469651e-03f,
  -3.70546989e-02f, 1.68443352e-01f, -1.83029816e-01f, -2.08196655e-01f, 6.62366599e-02f, 2.36475721e-01f, 1.56138137e-01f, 2.13915661e-01f, -1.52161285e-01f, -2.23898143e-01f,
  3.01051177e-02f, 2.48274192e-01f, 6.87540397e-02f, -5.10986671e-02f, -2.35799309e-02f, -7.18738437e-02f, 3.87855805e-02f, 1.39438152e-01f, 1.66116297e-01f, -1.26160398e-01f,
  -2.07469136e-01f, 3.24701928e-02f, -8.34409595e-02f, -1.72964439e-01f, -1.88543722e-01f, -1.03199027e-01f, -1.21813715e-01f, -1.34101540e-01f, -3.41506824e-02f, 6.52475134e-02f,
  -7.23053515e-03f, -5.98851889e-02f, -2.15784628e-02f, 1.08034186e-01f, 1.39152855e-01f, -4.02062461e-02f, -1.05258115e-01f, -1.00771472e-01f, -1.31789088e-01f, -5.77920564e-02f,
  -4.32749242e-02f, 6.92668557e-02f, -3.23632509e-02f, -7.88450092e-02f, -6.91253766e-02f, 1.19919524e-01f, -7.96014890e-02f, -1.45099163e-01f, 1.12697281e-01f, -2.20563307e-01f,
  2.14378759e-01f, -1.33872479e-01f, -1.56614989e-01f, -6.96126819e-02f, -2.60593235e-01f, 3.90638597e-02f, -1.05234496e-01f, -3.71308401e-02f, 3.93053949e-01f, -1.17626481e-01f,
  1.42916054e-01f, -1.86945379e-01f, -1.29872859e-01f, 2.40409851e-01f, 8.67598131e-02f, 4.94118445e-02f, 1.35727972e-01f, -4.82857088e-03f, 3.04893740e-02f, 1.82816893e-01f,
  6.76109046e-02f, 2.05108061e-01f, 1.60443634e-01f, 2.00624600e-01f, 1.83229774e-01f, 1.21205159e-01f, -2.48841301e-01f, -1.32770151e-01f, 2.25639999e-01f, -1.94849014e-01f,
  -9.02861282e-02f, 1.68751881e-01f, 1.15052611e-02f, 3.69863436e-02f, 3.34257558e-02f, -1.65702328e-01f, -2.73610920e-01f, 2.99103558e-01f, -6.71629384e-02f, 1.73054397e-01f,
  7.63953626e-02f, -4.99227047e-02f, 1.81713756e-02f, 2.07039282e-01f, -4.29964885e-02f, -1.48025593e-02f, 5.53787835e-02f, 5.05500324e-02f, 3.80691253e-02f, 4.63267177e-04f,
  1.54903457e-01f, -4.28548269e-02f, 9.18480456e-02f, 2.58136820e-02f, 1.61984973e-02f, 7.57037625e-02f, 9.07299966e-02f, -2.06424948e-02f, 7.61025399e-02f, 8.68944358e-03f,
  4.81630750e-02f, 3.31784971e-02f, 3.21885496e-02f, -1.37824938e-01f, -2.15292368e-02f, 5.61339296e-02f, 3.00465357e-02f, -9.84799489e-02f, -3.11899722e-01f, 1.92780152e-01f,
  6.57873452e-02f, 2.64218718e-01f, 1.34024709e-01f, -6.43362850e-02f, -4.13131248e-03f, -1.70615353e-02f, -7.19665363e-02f, 1.05861947e-02f, 1.71420649e-02f, -8.37280676e-02f,
  -1.44938929e-02f, -1.55790538e-01f, -6.67414889e-02f, -1.05396204e-01f, 1.95481122e-01f, -4.39341404e-02f, 4.73989220e-03f, -8.53503402e-03f, -2.38210902e-01f, -1.49574861e-01f,
  -9.41460654e-02f, 7.50370100e-02f, 1.23074479e-01f, 1.35792196e-01f, 2.30055436e-01f, -6.73658028e-02f, -8.33353773e-02f, -1.76512226e-01f, 2.96600461e-01f, -2.40950584e-01f,
  1.21548310e-01f, 2.42801309e-01f, -2.16968998e-01f, 4.36549596e-02f, -1.80410773e-01f, 3.48074473e-02f, 3.96409892e-02f, 9.17785764e-02f, 1.35685736e-03f, -5.03585897e-02f,
  4.18994911e-02f, -2.81092841e-02f, -7.48562813e-02f, 7.10778236e-02f, -1.51949093e-01f, 1.12282768e-01f, -7.75311887e-02f, 5.38363494e-03f, 4.15969454e-02f, -5.12425303e-02f,
  -2.54880153e-02f, -4.29040100e-03f, -2.27822480e-03f, 1.73959844e-02f, -2.10358903e-01f, 9.03237090e-02f, 4.57082130e-02f, 2.18777061e-02f, -5.25928289e-02f, 1.01652451e-01f,
  -6.91319183e-02f, 1.16023548e-01f, 1.67849138e-01f, 4.11926657e-02f, -4.25814420e-01f, -3.04157078e-01f, 5.50689399e-02f, -1.43794209e-01f, -2.39235952e-01f, -1.52589574e-01f,
  2.32766941e-02f, -1.79206923e-01f, -1.32024035e-01f, -1.71988085e-01f, 1.63773119e-01f, -5.41407168e-02f, 1.24083064e-01f, -1.23841807e-01f, -3.16596515e-02f, 4.37031165e-02f,
  -7.45003149e-02f, 1.96414381e-01f, 1.73141882e-01f, -9.39632729e-02f, -9.55793634e-02f, 2.08372418e-02f, 2.83954322e-01f, 1.48112252e-01f, -8.18953663e-03f, 7.75178596e-02f,
  -5.09690046e-02f, 1.39645770e-01f, 2.30871990e-01f, -3.30484033e-01f, 4.85633761e-02f, 1.47273034e-01f, -3.95181812e-02f, -7.36710429e-02f, -4.73389700e-02f, -1.06058337e-01f,
  -2.83045974e-03f, -1.45536475e-02f, 1.51899338e-01f, 3.06469034e-02f, 4.31519523e-02f, 1.20020270e-01f, 8.23227502e-03f, -1.55152425e-01f, 5.21493331e-02f, -3.71446162e-02f,
  -6.82894439e-02f, -3.77135426e-02f, -8.39813799e-03f, -5.32656200e-02f, 7.71535411e-02f, -8.53816792e-02f, -8.55472460e-02f, 4.38203067e-02f, -1.27552867e-01f, -8.24155733e-02f,
  8.55350643e-02f, -1.52410224e-01f, 2.65041590e-01f, -2.41140738e-01f, -6.03799932e-02f, 5.07325772e-03f, -2.88098484e-01f, -4.38448526e-02f, 1.04125232e-01f, 3.49512324e-02f,
  3.23350221e-01f, 4.16488610e-02f, 2.12310970e-01f, -1.92875955e-02f, -3.23766142e-01f, 1.04820885e-01f, 1.13018364e-01f, 6.68184310e-02f, 9.94883329e-02f, -5.98839149e-02f,
  -3.57631296e-02f, 1.20157547e-01f, 5.66810146e-02f, 9.80680808e-02f, 2.38466099e-01f, 1.15463361e-01f, -9.62447226e-02f, 1.34803265e-01f, 1.52164577e-02f, -1.64933234e-01f,
  2.92464018e-01f, -2.05703601e-01f, 8.10186416e-02f, -1.11869968e-01f, 1.09515071e-01f, 6.89946190e-02f, 4.89558652e-02f, 2.63911840e-02f, -3.34000528e-01f, 2.77890593e-01f
};

// L1_fan_Wp_bar (Shape: 14 x 64)
const int L1_fan_Wp_bar_rows = 14;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  3.66185695e-01f, -5.94849065e-02f, 2.90162146e-01f, 1.62738353e-01f, 2.77136415e-02f, 1.25580803e-01f, 8.39737058e-02f, 2.10086107e-01f, 7.11774305e-02f, 2.50673722e-02f,
  3.38176757e-01f, 8.49314556e-02f, 2.86651492e-01f, 1.54228732e-01f, 1.70315444e-01f, 4.18546936e-03f, 1.89225405e-01f, 3.68444592e-01f, 2.68277556e-01f, 2.50088871e-01f,
  -2.41795138e-01f, 2.81166166e-01f, 3.28479439e-01f, -1.15046471e-01f, 2.11520910e-01f, -6.09317161e-02f, 2.23973319e-01f, -3.88258427e-01f, 1.11608818e-01f, -2.04080150e-01f,
  1.37471110e-01f, -4.29947853e-01f, 4.89807039e-01f, 3.46545815e-01f, -1.55113220e-01f, 1.29658058e-01f, 2.27377146e-01f, 4.43730742e-01f, -1.26326397e-01f, 1.77875832e-01f,
  7.29466900e-02f, 1.84483349e-01f, -1.09730447e-02f, 4.03849818e-02f, 3.48438183e-03f, 2.37291709e-01f, -8.13433528e-02f, -1.32269248e-01f, -5.24153709e-02f, -4.28985566e-01f,
  -3.07857364e-01f, 3.11796010e-01f, 4.13961023e-01f, -3.99695970e-02f, -4.09876883e-01f, -1.97147518e-01f, -3.75940144e-01f, -1.18220165e-01f, 4.10969436e-01f, 2.29841948e-01f,
  -4.95032072e-01f, 7.55629122e-01f, 2.35450640e-01f, -3.72869931e-02f, 1.56864449e-01f, 1.93432033e-01f, 1.21040687e-01f, 2.40812406e-01f, 2.90615380e-01f, 3.07143688e-01f,
  2.53140241e-01f, 8.49029049e-02f, 6.55105785e-02f, 4.33024257e-01f, -2.92932335e-03f, -5.94754368e-02f, 1.25160545e-01f, 2.00668827e-01f, 9.90549475e-02f, 5.03810227e-01f,
  2.27160841e-01f, 2.62624413e-01f, 3.62183511e-01f, 3.02089095e-01f, 4.35508102e-01f, 1.77899703e-01f, 9.52739418e-02f, 1.56435549e-01f, 1.83999971e-01f, 1.87616453e-01f,
  -3.77720684e-01f, 4.85237509e-01f, -2.32191966e-03f, 1.02094956e-01f, -3.20186079e-01f, 5.29964976e-02f, -2.30804682e-01f, -6.65276498e-02f, 7.93370679e-02f, -1.21100821e-01f,
  -2.99743891e-01f, -4.31095004e-01f, -1.82185426e-01f, -1.08726121e-01f, -2.04350241e-02f, -3.45826954e-01f, 1.42096773e-01f, -8.09741616e-02f, 2.20438614e-01f, -2.08162010e-01f,
  3.63566466e-02f, -2.35269040e-01f, 2.12518916e-01f, 2.90316284e-01f, 1.25353664e-01f, -2.42386609e-01f, -1.99849740e-01f, -4.93228324e-02f, -1.45066574e-01f, -1.48782637e-02f,
  2.48528734e-01f, 5.20403862e-01f, -3.94657493e-01f, 5.46517409e-02f, 6.50606453e-02f, -3.09669316e-01f, 1.15937948e-01f, 4.10887510e-01f, 2.78248549e-01f, 1.45562381e-01f,
  9.26582292e-02f, 3.39606196e-01f, 2.66366422e-01f, 8.49883705e-02f, 1.11123607e-01f, 2.05829546e-01f, 6.35603890e-02f, 2.15265647e-01f, -1.25383362e-01f, 3.04410785e-01f,
  1.10458456e-01f, 9.37590823e-02f, 1.97741047e-01f, 2.89472938e-01f, 6.05303422e-02f, 1.22597679e-01f, 4.40635718e-02f, 7.96183124e-02f, 2.62927920e-01f, 1.34429960e-02f,
  2.01404735e-01f, 3.86449993e-01f, 1.69713691e-01f, -1.90428682e-02f, -2.15842962e-01f, 1.00366637e-01f, 3.05894911e-01f, 3.04498434e-01f, -4.98876795e-02f, 2.42051706e-01f,
  2.13211820e-01f, 5.26037589e-02f, -3.49242955e-01f, -1.40566990e-01f, -2.36743212e-01f, -1.00269960e-02f, 3.99055779e-01f, -5.28578877e-01f, -1.08849980e-01f, -5.04478021e-03f,
  -3.82107437e-01f, -2.61624366e-01f, -2.48075709e-01f, -2.31881797e-01f, 1.76642895e-01f, -2.37114076e-02f, -4.17588055e-01f, -7.45843053e-02f, 1.98560938e-01f, -1.10390157e-01f,
  3.16410482e-01f, 3.02056193e-01f, -1.37927069e-03f, 3.39681923e-01f, 2.38448396e-01f, 3.15986387e-03f, -5.90194575e-02f, -2.14704320e-01f, 1.79540917e-01f, -1.04611136e-01f,
  4.58263755e-01f, -4.43673640e-01f, 1.18376814e-01f, 1.08754024e-01f, 9.21373144e-02f, 5.29278032e-02f, 1.27905598e-02f, -2.23375633e-02f, 1.48344800e-01f, 3.08509115e-02f,
  -4.78716120e-02f, 1.05981536e-01f, 2.61049289e-02f, -1.63318247e-01f, 2.13749528e-01f, 7.05286711e-02f, 2.94608265e-01f, 6.07428625e-02f, 1.41753748e-01f, 7.46581033e-02f,
  1.95790783e-01f, 1.22879855e-01f, 1.01442844e-01f, 1.79439381e-01f, 1.19555630e-01f, 9.19276923e-02f, 9.63953584e-02f, -1.70819089e-01f, -3.15426737e-02f, -1.43581957e-01f,
  -1.84539974e-01f, -3.73004258e-01f, -1.79276466e-01f, 9.68139991e-02f, 4.19832408e-01f, 1.27486169e-01f, 2.16312274e-01f, 1.16156735e-01f, 3.68717998e-01f, 3.81665975e-01f,
  -3.01067680e-01f, 2.82944068e-02f, -1.60894822e-02f, -2.95603454e-01f, -1.32110745e-01f, 3.40435952e-02f, -2.33388260e-01f, -9.49164405e-02f, -1.72145292e-02f, -1.15406767e-01f,
  1.98831648e-01f, -3.00233308e-02f, 2.96420641e-02f, -1.12990394e-01f, 4.73809429e-02f, 5.11931702e-02f, -2.66258437e-02f, -6.42622169e-03f, 5.10483861e-01f, -6.57444224e-02f,
  -9.46429074e-02f, -1.92225531e-01f, 3.30750734e-01f, -3.36481690e-01f, -1.05912849e-01f, 2.85018831e-01f, -3.02361727e-01f, 1.42895222e-01f, -1.35831222e-01f, 1.33296534e-01f,
  -4.06612977e-02f, 4.04791772e-01f, 1.45065293e-01f, 3.73035997e-01f, 1.67690799e-01f, -6.38072342e-02f, 3.22410313e-04f, -2.96662331e-01f, 1.07407793e-01f, 4.80352603e-02f,
  1.36490926e-01f, 4.96721298e-01f, 5.12924753e-02f, 1.39914617e-01f, 1.76954940e-01f, 5.27926721e-02f, 3.13200921e-01f, -1.40752494e-01f, 2.02277657e-02f, 6.17596358e-02f,
  3.50409627e-01f, -4.24310148e-01f, -1.41988248e-01f, 1.65320858e-01f, 2.07597688e-01f, 5.32855541e-02f, 2.37318333e-02f, 9.95741412e-02f, -1.94489002e-01f, 1.65409729e-01f,
  1.03772528e-01f, -3.76607329e-01f, 1.20985888e-01f, 5.64150326e-02f, 2.49120191e-01f, -4.49910432e-01f, -3.51524323e-01f, -3.17117982e-02f, 2.56808013e-01f, -2.51320451e-01f,
  -2.67122090e-01f, -2.24375084e-01f, -1.76291600e-01f, 5.04179709e-02f, -2.18944177e-01f, 9.48110595e-02f, -2.05259487e-01f, -3.97414386e-01f, 9.90162119e-02f, -2.08638847e-01f,
  5.58119476e-01f, 8.25870223e-03f, -1.52180478e-01f, -1.38013944e-01f, -9.53367129e-02f, 1.56139463e-01f, 2.25946620e-01f, 2.94650555e-01f, 3.06477308e-01f, 5.43419123e-01f,
  2.72645414e-01f, 1.61208436e-02f, 6.94595426e-02f, 1.70203462e-01f, 1.85361072e-01f, 1.85396984e-01f, 2.17412375e-02f, 1.86781332e-01f, 3.76927406e-01f, 3.12464654e-01f,
  2.11940438e-01f, 5.03332496e-01f, 1.81758463e-01f, 3.37252319e-01f, -1.87625252e-02f, -1.51589110e-01f, 8.29043612e-02f, 1.40665203e-01f, 1.93078294e-01f, -1.02530994e-01f,
  1.21827520e-01f, 2.39108041e-01f, 1.37542039e-01f, 2.88378656e-01f, 2.97300130e-01f, -1.52507678e-01f, -3.49150635e-02f, -2.38292947e-01f, 3.39487523e-01f, 3.01450461e-01f,
  -2.74363935e-01f, 1.56976253e-01f, -3.38140503e-02f, 2.70275444e-01f, 2.69723833e-01f, -5.03294468e-01f, 1.90408811e-01f, -4.18988973e-01f, 1.88926950e-01f, -3.26584399e-01f,
  -5.78405038e-02f, 4.04144526e-01f, -1.39526635e-01f, -5.12343943e-01f, -3.45210254e-01f, 1.96832910e-01f, 5.74400008e-01f, 2.32576013e-01f, -3.18574220e-01f, -1.57607540e-01f,
  3.87038514e-02f, 9.76174176e-02f, -2.28446722e-01f, -7.85954073e-02f, 3.26609761e-01f, 1.63653299e-01f, 2.97343940e-01f, -3.24520946e-01f, 3.53165418e-01f, -1.04464523e-01f,
  -5.21051325e-02f, -1.59235865e-01f, -1.87651411e-01f, -3.29471707e-01f, 2.21562088e-01f, 7.83265606e-02f, 1.04696512e-01f, 9.28194672e-02f, 6.29256219e-02f, -8.32251236e-02f,
  5.22045046e-02f, 6.15507290e-02f, 1.27266631e-01f, 2.06845820e-01f, -5.49736805e-02f, -7.01764151e-02f, 2.73338974e-01f, -5.46577945e-03f, 1.40384227e-01f, 1.62120149e-01f,
  7.42245018e-02f, 3.88260223e-02f, 1.76651135e-01f, -2.95874048e-02f, 1.17035866e-01f, 1.37288108e-01f, 1.30896941e-01f, 1.50114357e-01f, 1.08652562e-01f, -1.75099269e-01f,
  1.63636431e-01f, -3.38873774e-01f, 6.08036406e-02f, -2.77833045e-01f, -3.02030981e-01f, 2.73046374e-01f, 5.03419340e-01f, 1.25340536e-01f, 2.92489022e-01f, 1.60099238e-01f,
  3.03956896e-01f, 1.48196876e-01f, -1.89660758e-01f, -1.52467832e-01f, -1.36609390e-01f, -2.87124719e-02f, -2.85250366e-01f, 4.27084304e-02f, -3.96150053e-01f, 2.64911801e-01f,
  8.22659731e-02f, 8.75138640e-02f, 1.20787114e-01f, -1.58795431e-01f, 3.59750271e-01f, 3.01652074e-01f, 3.45205784e-01f, -5.27050793e-02f, 3.40309143e-01f, -2.91705579e-01f,
  4.87376481e-01f, 1.04967482e-01f, 2.65104026e-01f, -2.06254601e-01f, 1.15907714e-01f, 6.20851927e-02f, -2.36878917e-01f, 4.75363024e-02f, 7.52876000e-03f, 1.70438200e-01f,
  7.06963465e-02f, 6.74151480e-02f, 7.30678812e-02f, -1.15646370e-01f, 2.56008208e-01f, 1.11969449e-01f, 1.80962622e-01f, 1.24772705e-01f, -2.38523453e-01f, 3.20268683e-02f,
  2.04254985e-01f, 2.03089938e-01f, 2.95022726e-01f, 1.96586534e-01f, 1.56960770e-01f, -1.06948413e-01f, 1.76125154e-01f, 1.17894255e-01f, 1.86944067e-01f, -1.15472674e-01f,
  -1.76517174e-01f, 8.51063803e-02f, -2.06264295e-02f, 8.24879408e-02f, -2.86081403e-01f, 1.62863865e-01f, -1.03732325e-01f, 7.27932751e-02f, 5.58704287e-02f, 5.91151863e-02f,
  3.25254686e-02f, -4.92857635e-01f, -8.01935419e-02f, 3.53066623e-01f, 4.69024740e-02f, 2.48498678e-01f, -2.66327441e-01f, -3.92668813e-01f, -4.93542925e-02f, -2.01683924e-01f,
  -1.33762226e-01f, 8.97092596e-02f, -3.48530352e-01f, -1.10170290e-01f, -6.43272921e-02f, -2.74907470e-01f, -8.03581625e-03f, 1.89161628e-01f, 1.77083686e-01f, -1.06553130e-01f,
  5.51995099e-01f, -1.16843656e-02f, 3.79518330e-01f, -4.18365784e-02f, 4.81214136e-01f, -2.76026160e-01f, 3.68675892e-03f, 3.45265597e-01f, 4.46759224e-01f, 1.31648779e-01f,
  2.22363412e-01f, -1.44685823e-02f, 8.44362229e-02f, -4.64835502e-02f, 1.38837649e-02f, 1.18042290e-01f, 5.05389683e-02f, -2.00598225e-01f, 9.73586664e-02f, 2.49592423e-01f,
  1.54240489e-01f, 2.46713087e-02f, 1.68753833e-01f, 2.86318868e-01f, 1.35390863e-01f, -2.65217945e-02f, 9.93333310e-02f, -1.10908095e-02f, 3.75431031e-02f, 1.80052489e-01f,
  1.61050316e-02f, -5.29647758e-03f, -1.33029386e-01f, -1.27930626e-01f, -8.46370310e-02f, 1.13350309e-01f, 1.34833530e-01f, 6.19081743e-02f, 2.21359670e-01f, -1.08451761e-01f,
  3.17452438e-02f, 2.83182561e-01f, 2.29932383e-01f, 1.00675009e-01f, -1.94936514e-01f, -1.67483717e-01f, 1.34137556e-01f, 1.63500816e-01f, 1.21611813e-02f, 7.69550949e-02f,
  2.25865141e-01f, 1.16514079e-01f, 5.73359169e-02f, 1.99191511e-01f, 1.80608764e-01f, -6.87533617e-02f, -4.35886011e-02f, 8.75617787e-02f, -1.07546754e-01f, 2.17675185e-03f,
  -3.06572821e-02f, -9.28329527e-02f, 2.97643811e-01f, 3.14695746e-01f, 1.40079141e-01f, -1.44267946e-01f, 4.39454168e-01f, -7.77040198e-02f, -3.05216283e-01f, 3.60689640e-01f,
  3.14995736e-01f, 2.14331523e-01f, -1.25307351e-01f, 6.52354479e-01f, 1.81977928e-01f, -1.43566191e-01f, 1.61399588e-01f, -1.53109524e-02f, 2.57447898e-01f, 1.67436287e-01f,
  1.06561361e-02f, -1.42407212e-02f, 3.27078067e-02f, 6.77377656e-02f, -1.52976379e-01f, -1.70603078e-02f, 9.92437229e-02f, 2.06114367e-01f, 2.12236587e-02f, 8.10380951e-02f,
  -3.38101834e-02f, -1.53721988e-01f, 1.29085138e-01f, 2.92022735e-01f, -5.21502160e-02f, 3.02430131e-02f, -1.17744818e-01f, 2.93672353e-01f, 1.45999432e-01f, 6.28562868e-02f,
  1.72730282e-01f, -3.50994438e-01f, 2.82136679e-01f, -1.48230657e-01f, -7.11231604e-02f, -4.18212622e-01f, 2.54824221e-01f, -3.50337803e-01f, 5.74910678e-02f, 1.92609176e-01f,
  8.77208486e-02f, -2.24639446e-01f, 2.24656373e-01f, 1.27688259e-01f, 1.18585311e-01f, 4.39983696e-01f, -1.49015352e-01f, -1.73839077e-01f, 6.58311248e-02f, 2.89707452e-01f,
  2.62336284e-01f, 5.30430712e-02f, -7.76207894e-02f, 3.46427739e-01f, -1.24935070e-02f, 4.76328544e-02f, 2.46424735e-01f, 2.99944192e-01f, -5.64045787e-01f, 3.61558795e-01f,
  3.67976055e-02f, 5.05662978e-01f, 9.23859235e-03f, 1.54939443e-01f, 3.04795235e-01f, 1.78745776e-01f, 2.01708093e-01f, -4.51617360e-01f, 1.20022051e-01f, 1.66557446e-01f,
  2.74026960e-01f, 7.40558207e-02f, 6.08524047e-02f, 1.44459650e-01f, 1.05018746e-02f, -1.51819572e-01f, 1.59000158e-01f, -1.85704101e-02f, -9.20429975e-02f, 2.18092382e-01f,
  -2.50543386e-01f, -1.18797943e-01f, 1.02901019e-01f, -1.02867499e-01f, 1.01415686e-01f, 3.29189777e-01f, 1.24535516e-01f, 1.09653801e-01f, 1.07042633e-01f, 2.10432708e-01f,
  8.43563527e-02f, -1.08234033e-01f, 2.02124745e-01f, 1.66150346e-01f, 5.41400351e-03f, -5.23693264e-02f, 7.65508711e-02f, 7.09196553e-02f, -1.42832592e-01f, -4.82428908e-01f,
  1.84882969e-01f, -5.72505668e-02f, 4.07243639e-01f, -2.13751569e-01f, -6.09960929e-02f, 3.57456237e-01f, 7.79031068e-02f, 2.46841922e-01f, 1.36536747e-01f, -2.74837501e-02f,
  -2.08042219e-01f, -2.80003965e-01f, -3.51120174e-01f, 1.88055336e-01f, 1.86860427e-01f, 1.06346175e-01f, -4.32190001e-01f, 2.77727664e-01f, 1.44851893e-01f, 5.48121892e-02f,
  5.41543722e-01f, 1.94416285e-01f, 3.94749463e-01f, 3.11800629e-01f, -2.91925408e-02f, -6.10274635e-03f, 2.11703077e-01f, 4.26009178e-01f, -4.88423631e-02f, -2.17210665e-01f,
  3.26018065e-01f, -1.09829307e-01f, 8.51242319e-02f, 1.38679788e-01f, 7.99329132e-02f, 2.97564149e-01f, 2.52216488e-01f, 3.14417593e-02f, 1.26975670e-01f, 3.07649910e-01f,
  8.54518265e-02f, 3.32839526e-02f, 3.51623856e-02f, -2.73253433e-02f, 2.12060183e-01f, 1.61745548e-01f, 1.63008839e-01f, 6.41575605e-02f, 2.62388140e-01f, 2.48662438e-02f,
  1.40954942e-01f, 1.62287980e-01f, 2.04586759e-01f, 2.69871414e-01f, 1.16439313e-01f, 1.61191016e-01f, 8.17798004e-02f, 1.33083425e-02f, -2.96514165e-02f, -3.73939797e-02f,
  -1.27685443e-01f, 1.70264378e-01f, -9.45740864e-02f, 1.10183628e-02f, -1.77167758e-01f, 5.07603101e-02f, 1.99620742e-02f, 3.44078630e-01f, -1.97293133e-01f, 1.83917582e-01f,
  -2.92025417e-01f, 2.17202350e-01f, -8.07339922e-02f, 3.22470248e-01f, 3.44166666e-01f, 9.22170356e-02f, 8.49839449e-02f, 8.91486257e-02f, 1.85906664e-01f, -3.48896176e-01f,
  1.29007548e-01f, -3.03977668e-01f, 1.61554143e-01f, 1.23613872e-01f, -3.40439111e-01f, -1.83767408e-01f, -1.31544545e-01f, 3.71335447e-01f, -2.14879245e-01f, 4.27599221e-01f,
  2.20648557e-01f, 1.66410446e-01f, 3.92818600e-02f, 1.80172101e-02f, 2.57070094e-01f, 3.01901937e-01f, 3.86711925e-01f, 4.03864026e-01f, 3.31722200e-01f, 2.13229284e-01f,
  2.66500652e-01f, 5.81570081e-02f, 6.33444414e-02f, 8.44689086e-02f, -7.66048357e-02f, -4.66966350e-03f, -2.76600178e-02f, -5.54919690e-02f, 1.26864627e-01f, 2.89840728e-01f,
  1.68613568e-01f, -5.54235503e-02f, 2.11202875e-01f, -6.82048425e-02f, 2.20079020e-01f, -3.95225398e-02f, 6.83979839e-02f, 1.65133759e-01f, 2.03725874e-01f, 1.32408395e-01f,
  2.16762140e-01f, 3.01787853e-01f, -2.74681568e-01f, 1.97098598e-01f, -2.25446954e-01f, 1.22542605e-02f, -1.91724882e-01f, -9.93664656e-03f, -1.95931390e-01f, 5.35488665e-01f,
  3.40536267e-01f, 2.46654779e-01f, -1.73561581e-04f, 3.84922445e-01f, -4.01703954e-01f, 1.04017533e-01f, 2.82896101e-01f, 2.94211805e-01f, 3.77364933e-01f, 1.32392153e-01f,
  -3.37779582e-01f, 6.89770281e-02f, 4.01035734e-02f, -1.31796703e-01f, 2.68064111e-01f, -2.04415023e-01f, 2.08294034e-01f, -9.75468978e-02f, 3.14851046e-01f, 2.22259834e-01f,
  8.12824294e-02f, 3.68089020e-01f, -9.33603346e-02f, 2.56479949e-01f, 4.86704826e-01f, 6.41040623e-01f, 2.59532839e-01f, -4.82229441e-01f, 2.61198699e-01f, 1.90692812e-01f,
  1.78894550e-01f, -2.41375994e-02f, 2.62602478e-01f, 3.34062390e-02f, 1.66916072e-01f, 8.56622830e-02f, 9.47587863e-02f, 3.52343321e-02f, 2.81920314e-01f, -8.13714340e-02f,
  7.08738193e-02f, 3.41781139e-01f, 2.94159591e-01f, 2.22750321e-01f, 2.67824441e-01f, 2.48540044e-01f, 4.08808775e-02f, -1.83226578e-02f, 1.59905076e-01f, 1.88558996e-01f,
  2.63081521e-01f, 2.02030867e-01f, -9.58195627e-02f, 4.06575263e-01f, 3.94465923e-02f, -1.22587532e-01f, 1.13588110e-01f, 3.39370847e-01f, 3.21186185e-01f, -3.21974933e-01f,
  -6.17100410e-02f, 8.39280933e-02f, -1.23010293e-01f, -3.86702985e-01f, -1.31683394e-01f, -2.53815532e-01f, 1.92744702e-01f, 1.28073603e-01f, 7.63524547e-02f, -2.57105887e-01f,
  -5.04123569e-01f, 3.74811649e-01f, 3.37686926e-01f, -1.96443778e-02f, 2.15425700e-01f, 5.40341847e-02f, 3.95635575e-01f, 3.70943725e-01f, -1.14225723e-01f, 6.69853315e-02f,
  2.43183643e-01f, 7.14030862e-02f, -2.48129237e-02f, 4.52402800e-01f, 1.55074254e-01f, -2.86420912e-01f, -2.54306167e-01f, -2.07446203e-01f, -2.37811550e-01f, 1.43280938e-01f,
  1.55780226e-01f, 5.11457145e-01f, -4.95108128e-01f, 2.89289564e-01f, -3.75084758e-01f, 7.66496733e-02f
};

// L1_fan_Bp_bar (Shape: 1 x 14)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 14;
const float L1_fan_Bp_bar_data[] = {
  2.13182569e-01f, 2.32808724e-01f, 1.29075631e-01f, 1.56922638e-01f, 1.86637253e-01f, 3.12060028e-01f, 1.96163341e-01f, 2.16983393e-01f, 1.27136573e-01f, 2.02723503e-01f,
  7.92724192e-02f, 1.64531142e-01f, 9.71823409e-02f, 2.77140766e-01f
};

// L2_linear_W (Shape: 12 x 64)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 64;
const float L2_linear_W_data[] = {
  -9.46280807e-02f, 1.23159394e-01f, 1.94197387e-01f, -5.48730977e-02f, 3.55391353e-02f, 5.88397272e-02f, -1.54596359e-01f, -1.50754213e-01f, -1.17054075e-01f, 2.34010607e-01f,
  -1.66298091e-01f, 1.77658405e-02f, 5.69670182e-03f, -2.52783626e-01f, 1.60458833e-02f, -2.59005446e-02f, 1.13271736e-01f, 5.69075346e-02f, -1.35740474e-01f, -1.27891153e-01f,
  -7.57050188e-03f, 2.56539811e-03f, 1.01135887e-01f, -1.74549118e-01f, -2.29591936e-01f, -1.82339415e-01f, -9.06416476e-02f, -2.12540761e-01f, 4.48603094e-01f, -2.35781267e-01f,
  4.39467793e-03f, 4.06132370e-01f, 4.24335361e-01f, 6.84401095e-02f, -1.00935191e-01f, -3.11750352e-01f, -3.94866705e-01f, 3.00599188e-01f, 2.90017426e-01f, -2.77587146e-01f,
  3.03346038e-01f, 1.18034899e-01f, 3.29337090e-01f, -1.71147078e-01f, 1.88875571e-01f, 2.34027341e-01f, 5.12107074e-01f, 7.82278851e-02f, 3.43483269e-01f, 3.30005735e-01f,
  -6.39889479e-01f, -2.12325752e-01f, 1.41495630e-01f, -2.97577620e-01f, 6.28763974e-01f, 4.81784582e-01f, 1.91637993e-01f, 7.74304196e-02f, 2.00341970e-01f, -1.88129708e-01f,
  -4.98369545e-01f, -6.15457475e-01f, -5.39672673e-01f, -2.61592090e-01f, 1.15410313e-01f, 6.71275705e-02f, -8.71686861e-02f, 1.77668661e-01f, -3.35322112e-01f, -8.47200304e-02f,
  -1.74732894e-01f, 9.54818800e-02f, 9.88370106e-02f, 2.09356010e-01f, 3.90867472e-01f, 2.06916049e-01f, -2.13022783e-01f, 2.24637717e-01f, 3.17803435e-02f, -6.16746722e-03f,
  2.23863497e-02f, 1.71548256e-03f, -1.13127470e-01f, 1.53980136e-01f, -2.31175125e-01f, 2.19565004e-01f, 2.01281846e-01f, 1.73043713e-01f, 1.83925509e-01f, -1.11506633e-01f,
  6.80890903e-02f, 2.04224020e-01f, 1.88737124e-01f, -2.84853399e-01f, 1.89946160e-01f, 2.61381745e-01f, 2.95972943e-01f, 1.83301177e-02f, -1.93855941e-01f, -2.47321114e-01f,
  -3.72880287e-02f, 2.59979069e-01f, 2.25908905e-01f, 2.80610681e-01f, -3.12653422e-01f, 2.81844288e-01f, -2.67186999e-01f, 1.14902481e-02f, 1.10645041e-01f, -2.02920437e-02f,
  9.46455002e-02f, -3.65439504e-01f, 1.05330244e-01f, 1.88907474e-01f, 3.03394765e-01f, -5.75418293e-01f, -2.35627279e-01f, -2.65800744e-01f, -5.85256457e-01f, 4.00809675e-01f,
  -5.58259748e-02f, -4.26966488e-01f, 1.25443697e-01f, 4.63006645e-01f, -5.05827546e-01f, -1.86746731e-01f, -2.90525138e-01f, 3.93681794e-01f, 3.31211314e-02f, -1.38341948e-01f,
  -3.36401574e-02f, 8.20746124e-02f, -5.25430515e-02f, 8.29505771e-02f, -1.82896361e-01f, -1.45293936e-01f, -1.76746383e-01f, -2.68769085e-01f, 1.23642325e-01f, -2.21550852e-01f,
  -3.08842570e-01f, -4.52794284e-02f, -2.36612514e-01f, 2.98108105e-02f, -4.11703922e-02f, 1.32596701e-01f, -8.62681419e-02f, -1.99312627e-01f, -1.43369377e-01f, 2.85048280e-02f,
  -3.01707506e-01f, -2.04518005e-01f, -6.29566386e-02f, 3.63827765e-01f, -9.39121619e-02f, 1.84430793e-01f, -4.36341092e-02f, -3.11720639e-01f, 2.47582033e-01f, 3.59849393e-01f,
  -4.47019100e-01f, -1.88530192e-01f, 1.96700543e-01f, 1.46585166e-01f, 2.68354118e-01f, 3.70733701e-02f, 2.74632931e-01f, 1.42809317e-01f, -5.53987771e-02f, -1.05076931e-01f,
  -3.66824530e-02f, 7.06518814e-02f, -3.78974676e-01f, -6.77053956e-03f, -3.17933977e-01f, 8.00889730e-02f, -3.24910253e-01f, 2.18105510e-01f, 3.57113838e-01f, -7.56785154e-01f,
  -3.28711607e-02f, -2.68317789e-01f, -4.88603294e-01f, -5.23909807e-01f, 3.72539729e-01f, 2.00195238e-01f, 1.49853125e-01f, -6.52523100e-01f, 4.07270253e-01f, -6.62869096e-01f,
  5.70612960e-02f, 2.47678205e-01f, -2.09149092e-01f, -3.41806650e-01f, -1.87584072e-01f, 1.20322444e-01f, -2.18668908e-01f, -9.70360637e-02f, -2.11171061e-01f, 1.63714483e-01f,
  1.28845662e-01f, 3.83455232e-02f, -1.18244186e-01f, 3.64369005e-02f, -2.61954099e-01f, 1.58272803e-01f, -1.01484254e-01f, -4.05120790e-01f, -9.95115787e-02f, -4.28534567e-01f,
  -2.96197474e-01f, -2.58547843e-01f, -6.52257204e-02f, -6.67945389e-03f, -1.17738798e-01f, 7.81507045e-02f, -1.05755165e-01f, -3.33190590e-01f, 3.39283407e-01f, -1.23665273e-01f,
  -5.62201850e-02f, 4.15042073e-01f, -8.81024525e-02f, -1.06868945e-01f, 2.33680740e-01f, -2.17546254e-01f, 1.94360539e-01f, -1.14843756e-01f, -4.88281026e-02f, -1.66017070e-01f,
  1.67144701e-01f, -3.65573764e-01f, -8.47647861e-02f, 3.33173275e-01f, 2.30450317e-01f, 1.12969287e-01f, 7.07122311e-02f, -4.98769104e-01f, 4.02183980e-01f, -7.43851736e-02f,
  2.05106184e-01f, 1.01489834e-01f, -7.25676119e-01f, 1.73793331e-01f, -6.57611549e-01f, 4.35476422e-01f, 5.56561530e-01f, -4.87389237e-01f, 1.32740423e-01f, 1.30749092e-01f,
  -3.76538068e-01f, 1.38628379e-01f, 8.72307867e-02f, 1.07467614e-01f, -1.16958089e-01f, -7.37418652e-01f, 1.71794016e-02f, 1.27933398e-01f, 1.95548251e-01f, 7.03722388e-02f,
  3.32410969e-02f, -2.07075283e-01f, 1.18388809e-01f, 5.46082482e-02f, 1.05321072e-01f, -2.28903562e-01f, 1.72923297e-01f, 1.37120426e-01f, 1.00913560e-02f, 8.64673853e-02f,
  -2.36726269e-01f, -1.61468148e-01f, -6.58672825e-02f, -8.58939290e-02f, 4.10142034e-01f, 2.99803108e-01f, 1.41661733e-01f, 2.64126062e-01f, -1.26386777e-01f, 2.23923046e-02f,
  2.79876173e-01f, 2.91342497e-01f, -2.40881607e-01f, -3.94819349e-01f, -1.11967549e-01f, -3.32609296e-01f, -2.05127418e-01f, -2.01339558e-01f, -4.27784622e-01f, 1.33616656e-01f,
  3.96753460e-01f, -2.80337870e-01f, -2.39233449e-01f, -4.26324934e-01f, 2.25126639e-01f, -1.54221758e-01f, 3.42989594e-01f, -2.61003941e-01f, 2.59600371e-01f, -7.63005950e-03f,
  -1.92304611e-01f, 5.75303063e-02f, -4.09818590e-01f, 1.41943812e-01f, -1.58837736e-01f, 6.56427890e-02f, -3.19114536e-01f, 7.65962750e-02f, 3.20123225e-01f, 2.40502551e-01f,
  -3.50849360e-01f, 1.82940468e-01f, 3.13637376e-01f, 3.66584629e-01f, -3.82284611e-01f, -3.35328251e-01f, 2.73231603e-03f, -2.36169621e-01f, 2.44251236e-01f, -2.78656721e-01f,
  2.47810468e-01f, -1.64054744e-02f, -2.24884629e-01f, -3.06845009e-02f, 2.31531560e-01f, 2.49602363e-01f, 3.29100251e-01f, 1.45442560e-01f, 1.02199629e-01f, -6.90791532e-02f,
  7.45108575e-02f, 2.08451860e-02f, 2.42290825e-01f, 2.41169304e-01f, -1.39466040e-02f, 1.99901149e-01f, -1.53981373e-02f, -3.36877257e-02f, -1.78193435e-01f, 2.24194482e-01f,
  1.28317162e-01f, 2.35139549e-01f, 1.26888789e-02f, -1.94414616e-01f, 7.93118849e-02f, -2.78040200e-01f, -3.29466850e-01f, 3.18517059e-01f, -3.00879151e-01f, -1.57496169e-01f,
  2.03393161e-01f, -3.13902199e-01f, -1.05256766e-01f, 1.57880455e-01f, -3.49645764e-01f, 3.76125634e-01f, 4.53500569e-01f, 3.43896329e-01f, -3.95391256e-01f, -1.40090764e-01f,
  -3.08826655e-01f, 4.84350741e-01f, -1.95711538e-01f, -3.74226809e-01f, 2.73514450e-01f, 2.48956010e-01f, -3.87774080e-01f, 1.56810448e-01f, 3.72483820e-01f, -4.87804443e-01f,
  -4.39425051e-01f, 5.83884180e-01f, 4.03826445e-01f, -7.15821028e-01f, 3.71609449e-01f, 1.79634333e-01f, -5.69688976e-01f, -8.35386291e-02f, -3.45233917e-01f, -1.73395500e-01f,
  -2.21342489e-01f, -2.01234952e-01f, -5.19790590e-01f, -1.30312726e-01f, -7.75985569e-02f, 7.11965635e-02f, 1.37706548e-01f, -3.96694005e-01f, -1.66690588e-01f, -2.35675022e-01f,
  1.39706372e-03f, -1.91032752e-01f, 1.53986663e-01f, 5.23396395e-02f, -3.40690076e-01f, -2.37625122e-01f, 2.76117057e-01f, -2.30435893e-01f, 9.24689919e-02f, 1.15501106e-01f,
  1.23127244e-01f, 5.15109412e-02f, 1.31114289e-01f, 3.04470994e-02f, 1.98531061e-01f, -4.07446265e-01f, -1.13327980e-01f, 2.89140344e-01f, 6.67168945e-02f, 4.73184317e-01f,
  -9.27905291e-02f, 1.57826662e-01f, -3.10044825e-01f, 5.66859543e-01f, -4.67211187e-01f, -4.31733400e-01f, -2.98354536e-01f, -6.21571839e-02f, 1.00725591e-01f, 8.17425177e-02f,
  -7.87424892e-02f, -1.06738031e-01f, -2.86757350e-01f, 4.12035763e-01f, 2.12431222e-01f, -3.79360139e-01f, -3.93999487e-01f, -3.18818629e-01f, -4.29573536e-01f, -5.60683191e-01f,
  -2.82240897e-01f, -4.52264279e-01f, -4.98160236e-02f, -3.03838789e-01f, 4.12351966e-01f, -1.38374031e-01f, -6.77357987e-02f, -1.70900583e-01f, 2.77517051e-01f, -6.82903528e-01f,
  -5.24057865e-01f, 4.76848543e-01f, 2.73445308e-01f, -2.81865954e-01f, -1.60397902e-01f, -5.79424538e-02f, -8.44145119e-01f, 1.88732207e-01f, -6.60965443e-02f, 3.61141637e-02f,
  -6.42903671e-02f, 4.89925444e-02f, -4.12041284e-02f, -2.12470114e-01f, -1.78768560e-01f, -2.05911502e-01f, -1.41382009e-01f, -9.05011818e-02f, 3.07236575e-02f, -3.52901459e-01f,
  -6.00343607e-02f, -1.76413864e-01f, -1.28594697e-01f, -1.03866547e-01f, 7.37496838e-02f, -1.56721994e-01f, -7.99775869e-02f, -3.07037178e-02f, -4.10623811e-02f, -4.38790470e-02f,
  9.70966555e-03f, -2.86212057e-01f, -8.92499313e-02f, 9.34526473e-02f, -4.03488651e-02f, 2.50921641e-02f, 2.97748446e-01f, 1.46748558e-01f, 3.25610310e-01f, 1.93660427e-02f,
  -1.70680046e-01f, -2.09084243e-01f, 7.07868785e-02f, -3.29823121e-02f, 1.93375677e-01f, 2.13932678e-01f, -1.21093601e-01f, 3.43391262e-02f, 7.61873871e-02f, 1.42109394e-01f,
  6.44310638e-02f, 1.85165048e-01f, -2.17749804e-01f, -1.23481832e-01f, -1.93581179e-01f, 4.12780382e-02f, 2.13928103e-01f, -2.23602220e-01f, -2.87607342e-01f, -1.78217173e-01f,
  1.86164588e-01f, -7.40044052e-03f, -3.00402880e-01f, -4.52787399e-01f, -5.81996560e-01f, 6.58332780e-02f, -3.19011092e-01f, 5.46826601e-01f, 3.27010900e-01f, 3.10190380e-01f,
  3.42480689e-01f, -2.79021859e-01f, -3.20292920e-01f, -1.53157741e-01f, -3.31162155e-01f, -2.95759976e-01f, 8.22444111e-02f, 6.70966581e-02f, 1.68539137e-01f, -1.57576706e-02f,
  -1.42583996e-01f, -1.69709980e-01f, -1.67009711e-01f, 1.01383083e-01f, 1.39487892e-01f, 1.34151038e-02f, -1.16718024e-01f, -2.30808139e-01f, -1.48327470e-01f, -2.88404435e-01f,
  -1.17346846e-01f, -1.70691699e-01f, -1.07733637e-01f, -2.31398176e-02f, -2.57900715e-01f, -2.20587522e-01f, 3.57633829e-02f, -2.77012587e-01f, 1.70458734e-01f, -1.44044101e-01f,
  -1.57166973e-01f, 1.47914797e-01f, 1.70201823e-01f, -1.39927298e-01f, 1.76443338e-01f, 2.51927137e-01f, 2.44461924e-01f, 2.13351071e-01f, -3.22122663e-01f, 2.16240808e-03f,
  2.97907233e-01f, 2.54580557e-01f, -1.92670405e-01f, -3.01480532e-01f, -2.11555526e-01f, -8.36518779e-02f, 2.59883583e-01f, 1.42701536e-01f, 2.60340184e-01f, -1.35356471e-01f,
  2.37752184e-01f, -1.43529281e-01f, -4.12294298e-01f, 1.35001674e-01f, -1.87799990e-01f, -2.92704105e-01f, -2.81872362e-01f, -5.62229276e-01f, 6.76276907e-02f, -3.11093867e-01f,
  3.80276382e-01f, 3.00227374e-01f, 5.33790469e-01f, -5.53656101e-01f, 3.24368060e-01f, 4.04928625e-02f, -2.15725511e-01f, -3.92084420e-01f, 1.52564287e-01f, 1.09594323e-01f,
  1.49342522e-01f, 1.06574416e-01f, 1.72566637e-01f, 9.17229708e-03f, -1.60243139e-01f, 1.00920610e-01f, 5.44914380e-02f, -4.31913100e-02f, 7.20934346e-02f, -4.32311520e-02f,
  5.72459511e-02f, 2.90726125e-02f, -1.66843131e-01f, 8.31051841e-02f, -4.99261469e-02f, -1.71611726e-01f, -1.88309431e-01f, -2.31166869e-01f, 1.73559144e-01f, -2.47342706e-01f,
  -1.99686855e-01f, 1.45857811e-01f, -6.31608516e-02f, -3.78556788e-01f, 2.25719467e-01f, 9.45196152e-02f, -2.19151154e-01f, 1.89593598e-01f, -4.35161078e-03f, -2.76474774e-01f,
  7.56036714e-02f, 3.20027798e-01f, 1.23806193e-01f, -5.74285053e-02f, -1.22779250e-01f, -2.89802253e-01f, 4.93711159e-02f, -1.52276307e-01f, 4.42483008e-01f, -3.15393582e-02f,
  3.50114927e-02f, 3.34132344e-01f, -2.54697260e-02f, 1.54423252e-01f, -5.63969433e-01f, -1.82503104e-01f, 4.23456162e-01f, -3.70338470e-01f, 2.74998814e-01f, -4.47762966e-01f,
  4.72695492e-02f, 4.96406816e-02f, -2.26287454e-01f, -4.58963722e-01f, 1.50341377e-01f, -3.68732750e-01f, -5.79296410e-01f, 3.20330799e-01f, 5.32258272e-01f, -4.95234936e-01f,
  7.69570768e-02f, -1.93938300e-01f, 8.81418735e-02f, -1.66868120e-01f, 6.88904226e-02f, 8.21514502e-02f, 1.86623380e-01f, -2.86192536e-01f, -2.95330852e-01f, 9.29744989e-02f,
  9.26713347e-02f, -1.83991287e-02f, 7.45467171e-02f, 4.86197919e-02f, 9.22715589e-02f, 2.92972535e-01f, -1.53814897e-01f, 3.07432294e-01f, 1.47780806e-01f, -2.27157384e-01f,
  1.38664976e-01f, -3.46004069e-02f, -6.11902177e-02f, -1.52630582e-02f, -2.58194268e-01f, 2.42697239e-01f, 2.08719671e-01f, -3.90326738e-01f, -1.01202726e-01f, -1.64742500e-01f,
  -2.23933876e-01f, 2.49850422e-01f, 2.16790289e-01f, 1.77832350e-01f, -4.06640619e-01f, -4.12376642e-01f, -2.96791852e-01f, -2.61859596e-01f, -3.34407836e-01f, 4.52512085e-01f,
  2.74957240e-01f, 4.10890639e-01f, 1.20461650e-01f, 2.85955608e-01f, 1.43649176e-01f, 3.24883699e-01f, 1.24724291e-01f, 4.06794429e-01f, -5.26734650e-01f, 1.92441314e-01f,
  5.19610226e-01f, 8.11959505e-02f, -3.41707647e-01f, 3.03769380e-01f, -1.47622272e-01f, -2.45650247e-01f, 2.72810400e-01f, -5.43935657e-01f, -5.41985154e-01f, 3.27265888e-01f,
  2.21821204e-01f, -1.24734957e-02f, -2.18631864e-01f, 2.77320564e-01f, 4.30059284e-02f, -5.32938279e-02f, 1.35172769e-01f, -1.80057436e-01f, 7.59168044e-02f, 1.33364320e-01f,
  -5.08692205e-01f, 1.81419894e-01f, 9.27167684e-02f, 1.20176397e-01f, -1.47042185e-01f, 5.19525856e-02f, -8.69608447e-02f, -2.84155756e-01f, 5.10271192e-02f, 1.63699552e-01f,
  -5.34628332e-02f, 1.77993849e-01f, 5.95921017e-02f, -2.15067416e-02f, 1.04945805e-02f, 1.11833788e-01f, 1.16698980e-01f, 1.41159939e-02f, 1.21787019e-01f, -4.00968254e-01f,
  2.24858716e-01f, 2.98200816e-01f, -2.14643270e-01f, 2.73720711e-01f, -1.91248551e-01f, -1.16594978e-01f, 1.39176950e-01f, 3.88694815e-02f, -4.18381959e-01f, 2.58393526e-01f,
  1.38699234e-01f, -3.91842484e-01f, -3.32920194e-01f, -2.46269450e-01f, 8.16127583e-02f, -4.94833022e-01f, -2.30361551e-01f, 5.31843603e-01f, 1.98078156e-01f, -3.65571439e-01f,
  3.37340355e-01f, 4.06183511e-01f, 2.47834608e-01f, 2.64550120e-01f, -5.53693056e-01f, 5.40733576e-01f, -6.58449233e-01f, -1.91359699e-01f, -4.39311326e-01f, -3.67621630e-01f,
  -3.99755806e-01f, -1.47323348e-02f, -1.51543289e-01f, -4.86237854e-01f, -4.83680755e-01f, 4.30111617e-01f, 3.53031278e-01f, 5.19069135e-01f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  3.03809196e-02f, 1.09843679e-01f, -1.04684927e-01f, -2.03902647e-02f, -1.27645627e-01f, 5.39489090e-03f, -1.11290067e-02f, 3.93812284e-02f, -1.46973142e-02f, -3.05315610e-02f,
  -6.51055500e-02f, 2.22574305e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 25, 14
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 25, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        64, 12
    );
    }
    