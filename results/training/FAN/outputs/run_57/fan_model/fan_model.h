/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 12 x 120)
const int L0_fan_Wp_rows = 12;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -7.32047737e-01f, -1.66076228e-01f, 4.65233959e-02f, -5.69629908e-01f, -6.42816257e-03f, 8.76849145e-02f, -3.43859941e-01f, -4.97395471e-02f, -2.72239566e-01f, -1.26957104e-01f,
  -2.68494785e-01f, 1.43843845e-01f, -2.43169695e-01f, -3.88906240e-01f, -6.35161484e-03f, -1.73402503e-01f, -3.53112042e-01f, -1.90820351e-01f, 3.21207345e-02f, -1.24755897e-01f,
  -9.85269547e-02f, -2.83322990e-01f, -2.44604379e-01f, 2.21523032e-01f, -1.51340961e-01f, 6.63843155e-02f, -1.06026627e-01f, 1.63814530e-01f, 1.11558303e-01f, 1.27194539e-01f,
  3.39995138e-02f, -7.84300715e-02f, -3.73493098e-02f, 4.61068042e-02f, -1.10712580e-01f, 4.32711355e-02f, 9.67277959e-02f, 6.39131144e-02f, 5.05121760e-02f, -1.19435340e-02f,
  1.33295748e-02f, 4.88759354e-02f, -1.17057627e-02f, 5.27063906e-02f, -1.12669736e-01f, 1.98985003e-02f, -3.36735509e-02f, 1.04248514e-02f, 5.76505996e-02f, -1.48995429e-01f,
  -7.56361932e-02f, -6.89654499e-02f, -1.84798405e-01f, -4.24027890e-02f, 1.28699709e-02f, -4.64504659e-02f, 4.83598188e-03f, 5.55703007e-02f, 4.23009694e-02f, 2.70225387e-02f,
  -6.13109358e-02f, 4.42609861e-02f, -9.46033746e-02f, -1.91376861e-02f, -6.74505457e-02f, 3.06191742e-02f, -7.02341646e-02f, 4.55066934e-03f, -2.69027296e-02f, 1.61921531e-02f,
  -1.65354628e-02f, -4.55409288e-02f, -2.82210782e-02f, 3.70243564e-03f, -6.45663217e-02f, 1.50332265e-02f, 2.51003187e-02f, 3.02325916e-02f, -6.43174052e-02f, 3.26312557e-02f,
  6.73723407e-03f, -2.31470149e-02f, 1.66718476e-02f, -2.20485684e-02f, -4.79367115e-02f, 1.03940750e-02f, 1.19171012e-02f, 2.23962422e-02f, 3.41805778e-02f, -2.91143525e-02f,
  -2.29647178e-02f, -5.31105585e-02f, 3.55846658e-02f, 7.74844214e-02f, 8.81790817e-02f, -2.76529659e-02f, -3.98780406e-02f, 5.65494746e-02f, 5.26632518e-02f, -8.14315304e-03f,
  -3.89464549e-03f, -1.92501210e-02f, 9.92099419e-02f, -1.86931174e-02f, 5.11875786e-02f, -5.04047126e-02f, 5.87989166e-02f, 3.47085223e-02f, -3.90833691e-02f, 1.08161904e-01f,
  6.80734739e-02f, 4.13914099e-02f, 3.70747559e-02f, 4.84524295e-02f, 4.54668216e-02f, 2.23781038e-02f, 4.52636704e-02f, -5.27122654e-02f, 9.43537988e-03f, -4.77745049e-02f,
  2.93643087e-01f, 1.20674014e-01f, 3.98001671e-01f, 5.65103702e-02f, 8.00032318e-02f, -9.86682326e-02f, -1.92161649e-01f, 8.96634758e-02f, 4.23368722e-01f, -3.44303221e-01f,
  -2.03427300e-01f, 8.47914815e-02f, -4.69336845e-02f, -2.71360546e-01f, 3.61732155e-01f, 1.63038447e-01f, -1.20692402e-01f, -9.61567536e-02f, 1.97657660e-01f, 2.02766359e-01f,
  2.19016835e-01f, -3.24510410e-02f, 1.11677632e-01f, 1.30414188e-01f, 2.04826146e-02f, -1.59131512e-01f, -2.41496906e-01f, -3.95912342e-02f, -2.87934989e-01f, -8.94385502e-02f,
  -2.01158598e-01f, 7.41038918e-02f, 9.37321037e-02f, -8.51253793e-03f, 1.40771959e-02f, -1.90034494e-01f, -2.03920752e-01f, -1.74879551e-01f, 2.70743780e-02f, -4.66069728e-02f,
  -7.41703883e-02f, -7.55843744e-02f, 5.38538471e-02f, 3.99424955e-02f, -3.05527057e-02f, 1.23151822e-03f, 2.50772443e-02f, -5.84839657e-02f, 1.11648075e-01f, 5.48182661e-03f,
  1.72168136e-01f, -1.25191882e-01f, -3.33992913e-02f, -1.33679554e-01f, 1.45502195e-01f, -2.08329204e-02f, -5.89221902e-03f, 5.01236543e-02f, 1.05025358e-02f, 4.95120697e-02f,
  1.98791120e-02f, -5.60873263e-02f, -5.25433272e-02f, -3.08936592e-02f, 1.42158926e-01f, -1.00506982e-02f, -2.01542792e-03f, -1.21770546e-01f, -5.07341139e-03f, 3.11768502e-02f,
  -6.99119046e-02f, 1.26230359e-01f, 2.60801986e-02f, 4.52949218e-02f, 3.81936133e-02f, -2.60921773e-02f, 4.45504896e-02f, -1.97464526e-02f, 8.02031681e-02f, 2.52556261e-02f,
  -1.28432855e-01f, 6.82942150e-03f, 8.12439099e-02f, -1.03990071e-01f, -1.23308487e-01f, 1.11820243e-01f, -1.66186329e-03f, 6.48250058e-02f, 3.05163320e-02f, 1.55543849e-01f,
  1.16639897e-01f, 2.91742414e-01f, 9.38747972e-02f, -3.49311009e-02f, 7.43588731e-02f, 7.59431124e-02f, 1.34035096e-01f, 4.27272469e-02f, 4.67773080e-02f, 3.80848832e-02f,
  -2.00601742e-02f, -1.29825920e-01f, -1.43432647e-01f, -8.65709558e-02f, 5.58577701e-02f, 4.59740646e-02f, -3.74665894e-02f, -5.39170168e-02f, 3.16512287e-02f, 3.24353538e-02f,
  -1.09508596e-01f, -5.82871996e-02f, 3.59643018e-03f, -5.85396662e-02f, -5.30422293e-02f, -9.98212472e-02f, 5.71437255e-02f, -2.40802709e-02f, -4.83637825e-02f, 3.52218561e-02f,
  -1.77691355e-01f, 5.15334427e-01f, -2.55840085e-02f, 2.03199953e-01f, -2.45017827e-01f, 1.53204143e-01f, 9.23836827e-02f, 1.88687555e-02f, 8.18067938e-02f, 2.86427945e-01f,
  -2.11167019e-02f, 1.36727706e-01f, -4.66146832e-03f, 3.71844500e-01f, -4.04536217e-01f, 3.23831648e-01f, 1.81652725e-01f, 1.94824547e-01f, 4.82530296e-02f, -2.54077651e-02f,
  -6.24985844e-02f, 2.25530099e-02f, 1.04790457e-01f, -1.14662580e-01f, 2.16437221e-01f, -1.12481207e-01f, -2.35569581e-01f, -1.12909585e-01f, 1.27280459e-01f, -5.53996190e-02f,
  -8.93713757e-02f, -1.46652520e-01f, -1.30302263e-02f, -2.67853625e-02f, -6.00147285e-02f, -1.24846525e-01f, 7.28128385e-03f, -9.34539214e-02f, 2.41560955e-02f, 4.54858989e-02f,
  1.09882616e-02f, -7.62693733e-02f, -3.77496402e-03f, -1.89527180e-02f, 4.40744497e-02f, 1.74706373e-02f, 1.08263835e-01f, 1.24611355e-01f, 8.43817070e-02f, -7.36850221e-03f,
  7.41105452e-02f, 8.03722292e-02f, 5.20532392e-02f, 5.49841411e-02f, -3.80607918e-02f, 7.50503391e-02f, -8.01626891e-02f, -6.13647476e-02f, 1.13010429e-01f, -1.55161498e-02f,
  3.31660286e-02f, -8.91311392e-02f, 3.92285399e-02f, -1.79141611e-02f, 2.67129354e-02f, -6.14120997e-02f, 8.15938115e-02f, -4.63355938e-03f, 3.73714906e-03f, -3.46798524e-02f,
  4.00401428e-02f, 2.42637005e-02f, -2.42025610e-02f, 5.52883334e-02f, -3.05665210e-02f, 3.00579332e-02f, 7.58718923e-02f, -2.15345081e-02f, 6.71557710e-02f, 7.25614876e-02f,
  -2.08612196e-02f, 2.84210350e-02f, 1.75485909e-02f, -3.81843522e-02f, 1.88789554e-02f, 4.12441529e-02f, -2.05885991e-03f, 1.23942584e-01f, -1.66740417e-02f, -1.33597374e-01f,
  7.19151199e-02f, -2.87469357e-01f, 6.87142536e-02f, 1.46488324e-02f, 1.25995493e-02f, 5.90953864e-02f, -3.60201485e-02f, -8.20019632e-04f, 8.07427615e-03f, -1.05494549e-02f,
  -7.92337954e-02f, 1.06904563e-02f, -1.38553167e-02f, 4.05113772e-02f, 2.38570180e-02f, -3.28361057e-02f, -3.04360166e-02f, -4.15106080e-02f, -1.24899251e-02f, -2.37151072e-03f,
  -3.05359140e-02f, -9.29606706e-02f, -4.89662178e-02f, -1.07679419e-01f, -1.52834877e-02f, -2.92924400e-02f, -7.76375756e-02f, -1.25325201e-02f, -7.65171051e-02f, 2.81168874e-02f,
  -3.80082995e-01f, 4.60676812e-02f, -3.23078781e-01f, -2.54997224e-01f, 1.79326072e-01f, 4.71954495e-02f, -7.29859844e-02f, 1.75420955e-01f, 1.72646224e-01f, 1.61954671e-01f,
  2.19730899e-01f, -5.09732783e-01f, 3.05266201e-01f, -2.48066351e-01f, -3.08569938e-01f, 2.51739025e-01f, -2.38063619e-01f, -1.03417411e-01f, 5.64310737e-02f, 1.23062089e-01f,
  -6.36938289e-02f, -1.96611006e-02f, -1.13271708e-02f, 1.29886806e-01f, -1.35892048e-01f, -1.11943714e-01f, -2.36603245e-01f, 1.04725190e-01f, -3.47964615e-01f, -1.73807681e-01f,
  -7.03650936e-02f, 9.24195163e-03f, -5.95752522e-03f, 1.52805485e-02f, -3.01693752e-02f, 1.47385105e-01f, -7.11669326e-02f, -1.07778907e-01f, 4.69356263e-03f, 1.03174113e-01f,
  1.12066098e-01f, -1.43800601e-01f, -3.04804835e-02f, -2.84801181e-02f, -4.25779931e-02f, -4.30821180e-02f, -3.84511687e-02f, 9.59269982e-03f, -1.06913373e-01f, -1.48865804e-02f,
  3.14942300e-02f, -3.13122272e-02f, -9.48751047e-02f, -7.25697801e-02f, -1.54765099e-01f, -8.25538114e-02f, -5.70189841e-02f, -3.56601849e-02f, 6.22148206e-03f, -7.55440295e-02f,
  2.68584047e-03f, 3.23271714e-02f, 4.04797159e-02f, 4.12722826e-02f, 3.85169722e-02f, -4.08555679e-02f, -2.82715838e-02f, 2.58364584e-02f, 4.74611158e-03f, 3.44900824e-02f,
  1.41215306e-02f, 3.35752079e-03f, 2.23668832e-02f, 6.91116648e-03f, -1.07445847e-02f, 4.48322408e-02f, -5.46441972e-02f, -9.82267223e-03f, 8.11598748e-02f, 4.18854021e-02f,
  2.42633838e-02f, -3.91102731e-02f, -9.03276913e-03f, -1.21059576e-02f, 6.69702664e-02f, -3.29015218e-02f, -3.86946686e-02f, -6.64099455e-02f, 9.09975991e-02f, 1.77617390e-02f,
  6.40491992e-02f, -2.15476856e-01f, 5.53442575e-02f, -1.01987049e-01f, 2.05675960e-02f, -5.44425286e-02f, -3.67202871e-02f, -1.34118078e-02f, -1.31378114e-01f, -4.53396700e-02f,
  -4.05877456e-02f, 7.68932253e-02f, -5.17928675e-02f, -2.91525312e-02f, 2.22491603e-02f, 7.18367398e-02f, -1.53593523e-02f, -6.22041188e-02f, 2.07874049e-02f, -6.60992414e-03f,
  -4.57657017e-02f, 3.74411903e-02f, 6.33574650e-02f, 2.43755486e-02f, 9.56270844e-02f, -3.95224197e-03f, -4.12326753e-02f, 2.72757839e-02f, 1.84075756e-03f, -2.66580209e-02f,
  6.90857351e-01f, -1.22106612e-01f, 1.97147399e-01f, 3.39654237e-01f, 1.29762441e-01f, 2.52120167e-01f, 2.94815302e-01f, -7.09573105e-02f, 1.90784112e-01f, -2.19294608e-01f,
  -6.13874234e-02f, 1.67575367e-02f, -4.22150850e-01f, -3.42231691e-02f, 1.96033835e-01f, -3.08221549e-01f, 4.31472719e-01f, 6.98840767e-02f, -7.06070364e-02f, 4.11664769e-02f,
  6.21739887e-02f, -4.44590859e-02f, 8.04595351e-02f, -1.46623194e-01f, 2.11133182e-01f, 8.85857940e-02f, 3.60971093e-02f, -9.38645098e-04f, 2.00940058e-01f, 3.45413685e-02f,
  6.97541535e-02f, -1.61124051e-01f, 9.56333429e-02f, -9.11965147e-02f, 9.90393534e-02f, 4.63105924e-02f, 1.20296270e-01f, -1.39174331e-02f, 2.17837915e-02f, -4.74191941e-02f,
  2.50802469e-02f, -6.63825721e-02f, -1.42002150e-01f, -6.68263510e-02f, 8.31084698e-02f, 6.20829116e-04f, 1.50233414e-02f, 4.77656610e-02f, -5.79054914e-02f, 1.05983196e-02f,
  3.08070015e-02f, 6.43639043e-02f, 1.17649272e-01f, 4.80045751e-03f, 8.96636993e-02f, -4.34404947e-02f, -3.95707749e-02f, 6.99197650e-02f, 6.76581264e-02f, 8.01361278e-02f,
  2.94977240e-03f, -3.69373821e-02f, -5.24704158e-02f, -2.13460671e-03f, -3.99227068e-02f, -8.47471785e-03f, 4.96793091e-02f, -9.12698656e-02f, 7.00066090e-02f, 2.43236814e-02f,
  4.59935926e-02f, 2.53450666e-02f, 1.98857524e-02f, 5.25216758e-02f, 2.19043028e-02f, 5.43389730e-02f, 1.86082814e-02f, -5.54787703e-02f, 1.46917999e-01f, 4.38837670e-02f,
  4.74290177e-03f, 4.66747545e-02f, -1.79422274e-02f, -1.26828616e-02f, -2.12020278e-02f, 4.09113206e-02f, -6.36348501e-02f, 7.37676248e-02f, 4.27246690e-02f, 8.92713070e-02f,
  -6.52775466e-02f, -1.50742352e-01f, -1.19355388e-01f, 3.37422453e-02f, 4.83036600e-03f, 3.47564630e-02f, -5.49104325e-02f, 4.16450016e-02f, 9.20411758e-03f, -8.24375078e-03f,
  3.92596275e-02f, 3.37438397e-02f, 1.76006734e-01f, 4.37666709e-03f, 5.20599522e-02f, -2.47852691e-03f, -5.57845570e-02f, 6.36011437e-02f, 1.57517374e-01f, -9.25229862e-02f,
  -5.39610945e-02f, 5.93860110e-04f, -3.65170138e-03f, 3.75919566e-02f, -1.06128464e-02f, 8.51027817e-02f, 8.76502171e-02f, 4.97856438e-02f, -4.64292839e-02f, -1.29120972e-03f,
  7.42406428e-01f, -2.86669642e-01f, 3.11644882e-01f, -3.18714142e-01f, 1.56662807e-01f, 1.40160369e-02f, -5.85392378e-02f, -1.13089591e-01f, 3.66785944e-01f, -3.38844240e-01f,
  -2.34061673e-01f, 2.58897603e-01f, -6.51278123e-02f, -2.94405788e-01f, 3.28305155e-01f, -1.56989232e-01f, -5.07909060e-02f, -4.80980091e-02f, 1.00529566e-01f, -1.02445908e-01f,
  6.54083267e-02f, -2.74994880e-01f, -1.15162479e-02f, -1.87574014e-01f, 8.20122510e-02f, 7.44858533e-02f, -2.27476686e-01f, -3.91517170e-02f, -2.75558800e-01f, 1.59439277e-02f,
  -6.01095632e-02f, -4.30084281e-02f, 3.48029705e-03f, 7.66639411e-02f, 2.57980432e-02f, 9.68004763e-03f, 2.24218629e-02f, -8.78112111e-03f, 3.44796814e-02f, 1.37968473e-02f,
  8.26714113e-02f, 2.13815905e-02f, 1.07920967e-01f, 6.92813396e-02f, 3.99775952e-02f, 5.83609603e-02f, 6.13688752e-02f, -6.51882216e-02f, -4.77363318e-02f, 5.97000532e-02f,
  7.94507861e-02f, -6.52345316e-03f, 5.22020608e-02f, 3.45368050e-02f, 8.97608846e-02f, 3.78457626e-04f, 1.08561795e-02f, 5.98628409e-02f, 2.36025210e-02f, 3.30141820e-02f,
  2.81251222e-02f, -1.16705960e-02f, -3.86257954e-02f, -7.47606112e-03f, -4.73263972e-02f, -4.41088863e-02f, 4.49575335e-02f, -7.32624084e-02f, 9.15431976e-02f, -3.07185501e-02f,
  -1.49455396e-02f, -1.76973604e-02f, -3.11787948e-02f, -4.72772531e-02f, -5.18920384e-02f, -3.93983275e-02f, 3.59343626e-02f, 1.84195004e-02f, 4.46210802e-03f, -1.55490208e-02f,
  -1.58343930e-02f, -3.38635850e-03f, -4.44841273e-02f, 3.47407092e-03f, -2.31718831e-02f, -2.17775516e-02f, -6.10201582e-02f, -5.24293771e-03f, 6.14289939e-03f, 7.06111044e-02f,
  -6.03862740e-02f, -1.26961842e-01f, -2.72466652e-02f, -6.20695353e-02f, -4.89040390e-02f, 3.07828374e-02f, 8.15295614e-03f, 5.06058298e-02f, -1.00530172e-02f, -5.74276410e-03f,
  8.99095926e-03f, -1.80227868e-02f, -3.58805768e-02f, 4.19852417e-03f, -5.31198047e-02f, -4.44973186e-02f, -5.35772406e-02f, 7.70191401e-02f, 4.97710751e-03f, -7.30501786e-02f,
  -7.09082186e-02f, 6.93233311e-02f, 1.46249160e-02f, -1.65783651e-02f, -5.69300428e-02f, 1.66438110e-02f, 2.72578318e-02f, -6.55550836e-03f, -3.40484008e-02f, -6.14701677e-03f,
  6.92775071e-01f, 6.27449751e-02f, -4.84634489e-02f, 1.06895939e-01f, 2.82099813e-01f, 4.18842077e-01f, 7.09070340e-02f, 1.63792878e-01f, 2.84025401e-01f, -1.48326933e-01f,
  1.30557716e-01f, -1.33240208e-01f, 6.76009208e-02f, -2.66563985e-02f, 5.17239928e-01f, -8.59301761e-02f, 1.85185835e-01f, -5.59894592e-02f, 1.36563769e-02f, 2.13380158e-01f,
  1.35986596e-01f, 1.41063780e-01f, -2.04870161e-02f, 5.41468672e-02f, 1.18852042e-01f, -1.08018383e-01f, 3.94404382e-02f, -8.69243294e-02f, -1.30991951e-01f, 1.13427313e-02f,
  5.50252479e-03f, 1.65291205e-02f, -1.51536047e-01f, -1.53714176e-02f, 8.78458694e-02f, -9.27862246e-03f, -6.90026581e-02f, -2.56521106e-02f, 2.86096130e-02f, -2.23914515e-02f,
  1.09255058e-03f, 4.20357250e-02f, -8.53149965e-02f, -4.69430126e-02f, 7.53401369e-02f, -8.35468844e-02f, 5.19618988e-02f, -2.21335031e-02f, -4.59710732e-02f, 7.55688036e-03f,
  -5.92410117e-02f, -8.23027194e-02f, 9.61888283e-02f, 2.40446511e-03f, 4.66358922e-02f, -2.54557766e-02f, -7.27981254e-02f, -6.52231947e-02f, 6.32145628e-02f, 2.13577021e-02f,
  1.46014737e-02f, 3.07842977e-02f, 1.00895418e-02f, -6.51237294e-02f, 6.91504031e-02f, 1.68892071e-02f, 1.08787175e-02f, -6.63950900e-03f, 1.36125833e-02f, 4.65818867e-02f,
  8.15231800e-02f, 9.20150522e-03f, 2.80076824e-02f, 3.01189218e-02f, -3.16600956e-04f, -6.22745268e-02f, 8.38072132e-03f, 1.77746417e-03f, 5.05913422e-02f, 4.09223512e-02f,
  1.00246659e-02f, 5.18882982e-02f, 1.53889451e-02f, -1.68884844e-02f, 6.34127706e-02f, -1.85865369e-02f, 2.43624728e-02f, -9.62847786e-04f, -1.56760197e-02f, 2.19571702e-02f,
  4.35405582e-01f, 2.93116242e-01f, 4.64259610e-02f, 2.61353143e-03f, -7.09936768e-02f, -7.32662296e-03f, -2.57561766e-02f, 5.25173247e-02f, 4.20547649e-02f, 9.12106335e-02f,
  -2.38051359e-02f, -5.94071858e-02f, 8.40269998e-02f, 5.29170260e-02f, -2.54717115e-02f, 8.30085054e-02f, -2.17332970e-02f, -6.32430986e-02f, 6.82987496e-02f, 7.67776230e-03f,
  1.71544997e-03f, 5.66960173e-03f, -5.48916459e-02f, 5.14370278e-02f, 9.67308972e-03f, 6.33181445e-03f, 1.02438122e-01f, -7.16435835e-02f, -2.58279294e-02f, 1.57181360e-02f,
  2.76828587e-01f, 3.60369347e-02f, 1.26049653e-01f, 1.60857335e-01f, 3.68175119e-01f, 1.89711124e-01f, -2.52423752e-02f, 3.36042553e-01f, -6.92040697e-02f, -1.25800654e-01f,
  -5.23654446e-02f, -1.35235399e-01f, -1.98138312e-01f, -1.57270297e-01f, 6.37785718e-02f, -4.63463902e-01f, -7.50136152e-02f, -1.16325766e-01f, -1.08612172e-01f, 2.60491103e-01f,
  1.65200964e-01f, 1.36703148e-01f, 2.62946516e-01f, 3.08604777e-01f, 2.96212435e-01f, 2.94294626e-01f, 1.59734100e-01f, 1.19558431e-03f, 1.88281626e-01f, -2.09881589e-01f,
  -1.17742926e-01f, -1.71890840e-01f, 6.38722703e-02f, -1.65025517e-02f, 1.50165886e-01f, -6.98059127e-02f, 4.78736982e-02f, -9.18572471e-02f, 5.45963570e-02f, 4.47886214e-02f,
  -4.19587642e-02f, -2.73327250e-02f, -6.95745125e-02f, -7.09552318e-02f, -1.91976018e-02f, -8.03097934e-02f, 8.45660865e-02f, 1.24631159e-01f, -4.08953093e-02f, -3.88643071e-02f,
  3.23715620e-02f, -4.87610400e-02f, -2.35313494e-02f, -7.98287019e-02f, 3.01988218e-02f, -2.62222476e-02f, -5.98285384e-02f, 4.39117700e-02f, -5.10313176e-02f, 9.72629488e-02f,
  -9.23310742e-02f, -5.02835140e-02f, -6.13729795e-03f, -1.70159459e-01f, -6.53721541e-02f, -6.56719059e-02f, -9.75785479e-02f, 1.53617254e-02f, 2.46257558e-02f, -3.58297937e-02f,
  1.41785726e-01f, -2.74890140e-02f, -1.37834311e-01f, 6.35054410e-02f, -9.29549205e-05f, -1.52500421e-01f, -4.68211584e-02f, -1.77626051e-02f, 1.60426348e-02f, 6.13087267e-02f,
  -1.67357475e-01f, 1.50592008e-03f, 7.89664872e-03f, 3.02067436e-02f, -7.25709051e-02f, 8.45049974e-03f, -4.26094681e-02f, -6.36996105e-02f, 1.33194225e-02f, 5.45742847e-02f,
  3.05607766e-01f, 1.32205874e-01f, 7.69541711e-02f, 2.79502403e-02f, -2.01408081e-02f, -1.02411257e-02f, 1.02300243e-03f, 7.58973183e-03f, 6.09421246e-02f, -1.07303455e-01f,
  7.33299702e-02f, 1.24740601e-01f, 8.03425089e-02f, 3.67740467e-02f, 7.32691959e-02f, 1.18533522e-01f, -2.25479752e-02f, 1.40594542e-01f, 1.37064457e-01f, 1.90216303e-02f,
  3.92940901e-02f, 1.14995584e-01f, 1.62318721e-02f, 1.26506254e-01f, 1.10690333e-02f, 3.51362266e-02f, 3.90912369e-02f, 8.47394988e-02f, -1.00791596e-01f, -1.45305544e-01f,
  -2.74068683e-01f, -1.28376886e-01f, -7.68434862e-03f, -1.85381100e-01f, 1.24558941e-01f, 7.84955025e-02f, 7.69050792e-02f, 1.86437517e-01f, 1.97714716e-01f, 3.13738652e-04f,
  1.83047265e-01f, -2.19301045e-01f, 1.12399668e-01f, 2.35003456e-01f, 9.55395307e-03f, 2.94409841e-01f, -1.66115046e-01f, -1.25038564e-01f, 2.35031456e-01f, -1.48723900e-01f,
  4.86338884e-02f, 3.02608609e-02f, 1.68787494e-01f, 1.88098893e-01f, -7.08216801e-02f, -3.77033949e-02f, -1.55562311e-01f, 2.57635731e-02f, -2.09552765e-01f, 1.08747944e-01f,
  1.42966554e-01f, 5.40687819e-04f, 5.49679287e-02f, -7.33670294e-02f, -2.03588847e-02f, -1.42195448e-01f, -1.91168860e-01f, 6.87157363e-03f, 8.31081793e-02f, -8.28919560e-03f,
  -1.20444424e-01f, -5.12285857e-03f, 1.44590726e-02f, -1.12017624e-04f, -3.24350484e-02f, 2.32215952e-02f, 4.46256064e-02f, 7.48583227e-02f, 6.53359964e-02f, -6.62998259e-02f,
  4.79093492e-02f, 7.49652088e-02f, -1.57999655e-03f, -1.36863366e-01f, -6.96492344e-02f, 2.39829533e-02f, -1.09261371e-01f, -1.58722222e-01f, -1.55477673e-01f, -6.27928153e-02f,
  1.03737518e-01f, -3.69349979e-02f, 8.85986388e-02f, -3.12911123e-02f, -1.96819343e-02f, 1.09859154e-01f, -4.32883054e-02f, 5.92847019e-02f, -4.59887162e-02f, -8.75422880e-02f,
  2.43932679e-02f, 3.39211188e-02f, -9.51472204e-03f, -3.24187626e-04f, 1.18882945e-02f, 1.12935431e-01f, -5.53944558e-02f, 6.76065683e-03f, -5.33211455e-02f, 4.88043651e-02f,
  -1.93018019e-02f, -1.02103971e-01f, 1.57269612e-02f, 8.93135369e-03f, 2.76852194e-02f, 8.16206113e-02f, -4.90176044e-02f, 2.61273999e-02f, 8.44868571e-02f, 4.38156985e-02f,
  -3.68179619e-01f, -6.93416774e-01f, 1.19889647e-01f, 1.35689219e-02f, 2.49416679e-02f, -7.75664765e-03f, 4.70394567e-02f, -6.56635761e-02f, -9.30432677e-02f, -1.39591880e-02f,
  4.92681600e-02f, -3.50023136e-02f, -5.76918274e-02f, 5.29071279e-02f, -7.63453171e-03f, 3.39243002e-02f, -1.15253232e-01f, -1.45867601e-01f, -1.35575131e-01f, 3.61948051e-02f,
  -6.79977164e-02f, -6.96801990e-02f, 7.90271834e-02f, 3.86733934e-02f, -1.09598882e-01f, 4.17774022e-02f, -6.89617917e-02f, 8.37938935e-02f, -9.32230130e-02f, -8.08803365e-02f,
  -3.65435332e-01f, 1.48934096e-01f, 2.71086603e-01f, -1.05614521e-01f, 1.09176837e-01f, -1.19026667e-02f, -6.58946931e-02f, 1.48768380e-01f, 1.01695666e-02f, -6.27106726e-02f,
  -1.51484996e-01f, 6.91833198e-02f, -2.00686827e-01f, 8.82681236e-02f, -4.13250118e-01f, -1.50257885e-01f, -1.01165012e-01f, -1.42898422e-03f, 9.92310196e-02f, -1.39448881e-01f,
  1.06045213e-02f, 1.19234519e-02f, -6.18616343e-02f, 3.62120569e-01f, -3.12473793e-02f, 1.21140972e-01f, -4.57319945e-01f, 2.91076839e-01f, -9.13978294e-02f, 1.36686802e-01f,
  1.47982895e-01f, 1.08336993e-01f, 3.06173302e-02f, 1.47364512e-01f, -1.62347376e-01f, -2.14370042e-02f, -1.32975616e-02f, 1.09614693e-01f, 4.82053636e-03f, 1.20302448e-02f,
  -4.79062498e-02f, 5.04919048e-03f, 8.86547938e-02f, 1.95717383e-02f, -2.98339082e-03f, 7.62960762e-02f, 4.93407547e-02f, -6.30848929e-02f, 2.45131508e-01f, -1.05823517e-01f,
  -3.57108116e-02f, 2.89316028e-02f, -1.20316565e-01f, 3.31978798e-02f, 3.42732519e-02f, 9.73600149e-02f, 4.04371992e-02f, -8.76292735e-02f, -7.71521553e-02f, 1.88330747e-02f,
  -8.50547329e-02f, 2.64261737e-02f, 5.65559566e-02f, -4.45832945e-02f, -3.99872884e-02f, 9.80623290e-02f, 1.06644884e-01f, -7.30756298e-02f, 1.85362771e-02f, -7.26744682e-02f,
  2.02573668e-02f, 5.52306734e-02f, 8.32978263e-02f, 5.52600203e-03f, -4.97776903e-02f, 5.71804168e-03f, 7.60027790e-04f, -3.55081484e-02f, -9.04450864e-02f, -6.93277968e-03f,
  4.28826958e-02f, -3.27764675e-02f, 6.38762191e-02f, -3.90833206e-02f, -1.79882031e-02f, -1.93760693e-02f, 4.32513617e-02f, -5.42626418e-02f, -2.87276544e-02f, -8.32158625e-02f,
  -1.35594234e-01f, -1.64448828e-01f, 2.45684234e-04f, 1.13070622e-01f, 2.69251801e-02f, -8.03596452e-02f, 3.01995222e-02f, 1.38395904e-02f, 7.58737773e-02f, -1.13273047e-01f,
  -2.33640149e-02f, 4.34108116e-02f, -1.64453730e-01f, -6.40366971e-03f, 1.01837434e-01f, -5.29021993e-02f, -2.34480333e-02f, 1.72687788e-02f, -1.84905976e-01f, -1.08215129e-02f,
  -5.10158874e-02f, 7.65726669e-03f, 8.09852257e-02f, -2.51601245e-02f, -1.83908455e-02f, -8.79417658e-02f, -1.31934062e-01f, 7.79044479e-02f, -1.43822888e-02f, 3.33732814e-02f,
  1.21653661e-01f, 3.06801349e-01f, 4.66124527e-02f, -2.40927219e-01f, -2.00934783e-01f, 3.80891532e-01f, 2.54541427e-01f, 1.01502247e-01f, 3.85077715e-01f, 1.45390168e-01f,
  -2.86617309e-01f, 6.68409921e-04f, 3.94604765e-02f, -2.54316956e-01f, -4.64667380e-01f, -2.02160761e-01f, 3.00979801e-02f, 6.08152449e-02f, 1.48294359e-01f, 8.79406184e-02f,
  -8.16865191e-02f, -3.51093382e-01f, -4.14950728e-01f, 8.75508133e-03f, -1.51951507e-01f, 2.75515407e-01f, -2.40402147e-01f, 3.49408835e-02f, -4.87664044e-02f, 7.33603910e-02f,
  -2.13487700e-01f, 6.75529540e-02f, -5.66788092e-02f, 2.81271767e-02f, 3.43754068e-02f, 2.68125404e-02f, -5.45336567e-02f, 3.69931385e-02f, 2.29054093e-02f, 7.49668851e-02f,
  5.64608499e-02f, -1.17099404e-01f, 2.32362840e-02f, -1.73387304e-01f, 8.82649869e-02f, 4.31629568e-02f, -1.27679082e-02f, -4.51417938e-02f, 1.15813509e-01f, 2.05128491e-02f,
  2.72146054e-02f, -1.56667549e-02f, -2.66225240e-03f, 5.23420461e-02f, 1.56316645e-02f, 2.77489983e-02f, 1.01380264e-02f, 1.82917695e-02f, 9.79011953e-02f, 2.32052375e-02f,
  4.49915901e-02f, 3.12283710e-02f, -2.41300296e-02f, -2.14949414e-01f, 3.01569011e-02f, 1.13737978e-01f, -5.71232140e-02f, -1.42002553e-02f, 1.93659700e-02f, -3.44861113e-02f,
  -3.91448708e-03f, -3.90852764e-02f, 6.74747229e-02f, 2.82668974e-02f, 2.41163857e-02f, 2.76993047e-02f, -9.79304016e-02f, -2.45160572e-02f, 8.03136900e-02f, -2.00544417e-01f,
  1.41660839e-01f, 6.29093871e-02f, -3.50570008e-02f, -1.13980606e-01f, -6.28468720e-03f, -4.07350734e-02f, -6.89703152e-02f, 3.02842464e-02f, -4.47856523e-02f, 4.14136611e-02f,
  1.47826612e-01f, 4.02870625e-01f, 1.35996491e-01f, 3.47782229e-03f, 3.08457911e-02f, -1.26194105e-01f, -5.98443151e-02f, 4.89660911e-02f, 1.08836256e-01f, 3.93538661e-02f,
  5.81862824e-03f, 7.70374760e-02f, 3.29610929e-02f, 6.94682524e-02f, -1.44200832e-01f, -2.18382496e-02f, 2.13292558e-02f, 3.41986977e-02f, -4.84282598e-02f, 5.05455956e-02f,
  -8.24055970e-02f, -4.42533307e-02f, 9.10389125e-02f, 4.81833741e-02f, -5.66101260e-02f, 7.15220422e-02f, 6.65913820e-02f, 1.21661417e-01f, -6.78726584e-02f, 3.28726578e-03f,
  5.46727836e-01f, -1.12648673e-01f, -1.36400864e-01f, 2.19506219e-01f, -1.11833647e-01f, -5.55413127e-01f, 2.09475264e-01f, -4.36912216e-02f, 1.37482643e-01f, 4.71277982e-02f,
  -8.46605077e-02f, 8.59470218e-02f, 6.06577024e-02f, -2.94984162e-01f, -2.50342458e-01f, -1.06649481e-01f, -2.57273048e-01f, 3.33746299e-02f, 9.92539003e-02f, 2.05793288e-02f,
  3.83134112e-02f, -2.19672993e-01f, -1.26711756e-01f, -9.37964246e-02f, 4.24549973e-04f, -9.89048858e-04f, 4.79638390e-03f, 1.11651525e-01f, -1.50929838e-01f, -9.02590454e-02f,
  -1.33508062e-02f, 2.83126205e-01f, -5.43123595e-02f, -2.09609084e-02f, -5.95271103e-02f, 1.19158246e-01f, 1.04301125e-01f, 2.14533899e-02f, 5.61108664e-02f, -8.65046456e-02f,
  3.28941420e-02f, 4.89044078e-02f, -6.53066784e-02f, 9.17155519e-02f, -3.43636796e-02f, -3.59396450e-02f, -1.28541529e-01f, -4.58104955e-03f, 9.66820046e-02f, -6.20226003e-02f,
  -7.19430745e-02f, -6.42762333e-02f, -5.91597296e-02f, -1.04293171e-02f, 1.47439586e-02f, -1.80783297e-03f, -3.09700109e-02f, 1.28409918e-02f, -4.18866985e-02f, 5.53519651e-02f,
  4.86085862e-02f, 5.36043197e-02f, 6.82245567e-02f, 4.43089418e-02f, -2.46766731e-02f, 2.70796940e-02f, -4.68914136e-02f, -7.78028592e-02f, 6.10913225e-02f, -2.91211084e-02f,
  -7.35441968e-02f, 3.04240137e-02f, 1.89842563e-02f, 8.07606652e-02f, 6.66215047e-02f, 1.07410401e-01f, -9.23639804e-04f, -1.33901536e-02f, -4.33920734e-02f, -1.03407493e-02f,
  6.63582888e-03f, 7.62858940e-03f, 3.26049998e-02f, 2.08874028e-02f, -1.01101011e-01f, 1.65297724e-02f, 4.37919842e-03f, -8.49262439e-03f, 5.26461704e-03f, 2.49490724e-03f,
  3.35982628e-02f, 1.17440797e-01f, 2.51592342e-02f, 6.39456362e-02f, -1.24430522e-01f, -1.26385376e-01f, 4.83579077e-02f, -1.09484412e-01f, 1.94967398e-03f, 5.58139607e-02f,
  2.96478365e-02f, 7.58731365e-02f, -3.25528346e-02f, -3.83775160e-02f, -9.98991728e-03f, -6.53699487e-02f, 9.36562493e-02f, 1.12213142e-01f, -8.28778604e-04f, 2.90087722e-02f,
  1.03725702e-01f, 8.89847726e-02f, 1.27528496e-02f, 4.31290567e-02f, -3.37997600e-02f, 2.68416591e-02f, 3.73694710e-02f, -4.68583442e-02f, -3.61091681e-02f, -6.06279895e-02f
};

// L0_fan_Wp_bar (Shape: 8 x 120)
const int L0_fan_Wp_bar_rows = 8;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  3.36729646e-01f, -2.10275561e-01f, 6.58382475e-01f, 9.05291617e-01f, -8.45304355e-02f, -8.33647072e-01f, -1.00120759e+00f, 3.58837754e-01f, 3.37301940e-01f, -5.85045993e-01f,
  -1.32349625e-01f, 2.41689794e-02f, -7.00469792e-01f, 6.41549408e-01f, 1.64828420e-01f, -2.94541866e-01f, 5.00343144e-01f, 1.62720934e-01f, 2.40723699e-01f, 4.98217285e-01f,
  6.97471142e-01f, 2.41262719e-01f, 4.52476323e-01f, 3.19058627e-01f, 3.68139774e-01f, 5.97537458e-01f, 2.53025800e-01f, -1.79632798e-01f, 5.21928191e-01f, -9.87441912e-02f,
  -9.95658785e-02f, 1.64909780e-01f, 1.99456707e-01f, 5.48240915e-02f, -1.64567464e-04f, -2.58707345e-01f, -7.22098947e-02f, -2.40095541e-01f, 5.85161410e-02f, 6.34841248e-02f,
  -9.55185518e-02f, 1.65806666e-01f, 3.09185326e-01f, 7.41957054e-02f, -6.39615348e-03f, 2.05439717e-01f, 1.73396975e-01f, 6.57437369e-02f, -2.65966896e-02f, 1.90321758e-01f,
  7.23105818e-02f, 1.30912289e-01f, 1.16872609e-01f, 4.94293943e-02f, 1.29317522e-01f, 9.00691897e-02f, -1.42939826e-02f, -6.47662431e-02f, 6.35022894e-02f, 1.21549398e-01f,
  -1.28530324e-01f, -7.45704249e-02f, -2.41951682e-02f, 1.30601779e-01f, 8.56570061e-03f, 6.28968850e-02f, -5.34002110e-02f, -9.62901562e-02f, -2.30890885e-02f, 1.24430843e-02f,
  2.08881479e-02f, 2.03425616e-01f, 8.92629772e-02f, -7.37702847e-02f, 4.73354608e-02f, 1.59679621e-01f, -7.89535046e-02f, 1.04360968e-01f, 1.27868816e-01f, 9.90304798e-02f,
  -8.57051909e-02f, -8.95780548e-02f, -4.52399738e-02f, -7.92211071e-02f, 7.26041570e-03f, -1.50654286e-01f, 1.30277082e-01f, 5.59829362e-03f, 1.10792676e-02f, -7.10102543e-03f,
  -3.90590787e-01f, -1.57323293e-02f, -1.13076732e-01f, -1.97443701e-02f, 5.71133569e-02f, 6.95300475e-02f, 1.00875363e-01f, 2.60012567e-01f, -1.17080532e-01f, -7.44870603e-02f,
  9.28156674e-02f, -7.30803758e-02f, -1.93829089e-02f, 1.05599845e-02f, -1.09721953e-02f, 4.42205779e-02f, -7.43198395e-02f, -9.76070836e-02f, -2.04706658e-02f, 2.23531425e-01f,
  2.89925672e-02f, -2.50481427e-01f, 1.38852745e-01f, 6.40134364e-02f, 1.12509005e-01f, -8.41587260e-02f, -9.33911372e-03f, 5.72560392e-02f, 7.75516257e-02f, 6.53884187e-02f,
  2.02980027e-01f, -3.92631859e-01f, -3.52048688e-02f, 7.30318904e-01f, -1.77215502e-01f, 8.12306881e-01f, 1.34366465e+00f, -2.08360106e-01f, 5.60189605e-01f, 1.83778808e-01f,
  9.43235159e-02f, 4.01471369e-02f, 5.11331111e-02f, 6.10851943e-01f, 6.77234650e-01f, 5.31658232e-01f, 8.32534671e-01f, 6.32361114e-01f, 5.79408854e-02f, 1.05904646e-01f,
  1.27757043e-01f, 5.77861428e-01f, -1.96816713e-01f, -5.14765978e-01f, -2.08334655e-01f, -4.97036397e-01f, -4.26257998e-01f, -3.62810284e-01f, -9.66823846e-02f, 8.11830088e-02f,
  1.49280578e-01f, -4.40824144e-02f, -1.22906089e-01f, 8.40143561e-02f, 3.79855465e-03f, 3.28014954e-03f, 8.74602646e-02f, 6.77556768e-02f, -7.42685273e-02f, -7.37147965e-03f,
  8.20742399e-02f, -1.17742702e-01f, 3.14556569e-01f, -2.99605099e-03f, -8.48725140e-02f, -1.01454690e-01f, -1.61337882e-01f, -1.47396266e-01f, -1.57757401e-02f, -1.87195927e-01f,
  -9.70338192e-03f, -1.50044098e-01f, -2.02207621e-02f, 9.19149145e-02f, -3.33917774e-02f, 1.14131920e-01f, 2.16525599e-01f, -7.12520629e-02f, -3.22973765e-02f, 1.20607726e-02f,
  -9.50932130e-02f, 1.31685987e-01f, -9.46712121e-02f, -5.19126058e-02f, 4.16749120e-02f, -5.93850128e-02f, -8.19683746e-02f, -5.53817814e-03f, -5.91480657e-02f, 5.78608885e-02f,
  7.36764818e-02f, 2.75791120e-02f, 6.18602112e-02f, -7.61284530e-02f, 8.57780650e-02f, 2.80571412e-02f, -9.80463624e-02f, 1.03914745e-01f, 6.52290508e-02f, -3.96224335e-02f,
  6.75588995e-02f, 1.30964667e-01f, 7.09651131e-03f, -1.02233849e-01f, 2.76701469e-02f, -5.22571802e-02f, 6.53898865e-02f, -1.56572297e-01f, -2.69843619e-02f, 1.07276633e-01f,
  1.13876842e-01f, 2.42886096e-01f, 1.03246383e-01f, 7.95818027e-03f, -1.02786971e-02f, -1.63702071e-01f, 3.84651460e-02f, -5.04867220e-03f, -5.52451909e-02f, 1.95819467e-01f,
  -1.39432717e-02f, -7.30570704e-02f, -1.27482072e-01f, -1.76385760e-01f, 1.77844036e-02f, -3.01358826e-03f, 3.34208280e-01f, 1.53323755e-01f, 6.77637363e-05f, -1.44706532e-01f,
  -8.66157562e-02f, 7.25761801e-02f, 1.37388304e-01f, -4.18986715e-02f, 9.18934569e-02f, -8.47356487e-03f, -6.16041422e-02f, -6.70844838e-02f, -5.78837208e-02f, 7.41994977e-02f,
  7.29957402e-01f, -4.62261617e-01f, -9.40833807e-01f, -2.68367957e-02f, 7.65940726e-01f, 8.98235500e-01f, 6.38447180e-02f, 3.21485043e-01f, -2.40481883e-01f, 1.32575678e-02f,
  3.71568590e-01f, -5.28179646e-01f, -4.99452025e-01f, 1.46899670e-01f, 1.60802260e-01f, -5.62341154e-01f, 2.15729401e-01f, -5.16924821e-02f, 5.79330996e-02f, 1.83793277e-01f,
  1.35803238e-01f, 8.55352581e-01f, -5.44869959e-01f, 5.52553058e-01f, 4.75438058e-01f, -1.09847531e-01f, 3.26199770e-01f, -2.67119914e-01f, 4.47484106e-01f, 1.55377671e-01f,
  -3.73845845e-02f, 2.68953815e-02f, -4.78397347e-02f, -1.17849171e-01f, 1.24973625e-01f, 1.66613549e-01f, 3.54574248e-02f, -8.01428333e-02f, -1.82191133e-01f, -2.03081667e-02f,
  -3.34687345e-02f, 5.27357589e-03f, -2.95979194e-02f, 1.54296616e-02f, 2.17144936e-01f, 1.21833310e-01f, 3.44271073e-03f, -5.40855229e-02f, -1.16877921e-01f, -3.69305685e-02f,
  -2.27745041e-01f, -1.33494377e-01f, 9.62268282e-03f, -1.48721799e-01f, -2.25350544e-01f, 6.39375150e-02f, -6.87433034e-02f, -1.08665273e-01f, 7.01752380e-02f, 1.02099977e-01f,
  7.48882815e-02f, 1.19279422e-01f, 5.50095327e-02f, 6.53167889e-02f, 8.92595425e-02f, 2.21996773e-02f, 8.60153586e-02f, -4.73837219e-02f, -6.10906035e-02f, 7.74978623e-02f,
  1.92676559e-02f, 7.84409046e-03f, 1.59942642e-01f, 1.59506544e-01f, 8.95404071e-02f, 7.11266771e-02f, -5.86046539e-02f, 4.00229841e-02f, -8.20143893e-02f, 3.35716754e-02f,
  -9.29899588e-02f, 8.86109844e-02f, 1.64179895e-02f, -6.49528578e-02f, 1.47447549e-02f, -5.50790131e-02f, 2.30427712e-01f, 4.36782390e-02f, -7.51184300e-02f, -5.34447329e-03f,
  -6.61874795e-03f, -7.35629052e-02f, -2.61368483e-01f, -3.90538275e-02f, -1.79438263e-01f, 1.58619568e-01f, -3.11533939e-02f, -1.28732733e-02f, -8.80555362e-02f, 1.08597293e-01f,
  1.01228356e-01f, 6.79181218e-02f, 2.62351632e-01f, 2.07281746e-02f, -9.47974995e-02f, 7.81493932e-02f, -1.04290731e-01f, -3.00389305e-02f, 1.11509196e-01f, 8.56957808e-02f,
  1.31651744e-01f, 1.12616494e-01f, -4.90732528e-02f, 7.91074485e-02f, 1.66511551e-01f, -8.65387172e-02f, 1.45597488e-01f, -7.39766732e-02f, 8.02675262e-02f, -1.75706863e-01f,
  -8.66686404e-01f, 6.07358038e-01f, -4.73105371e-01f, -4.47239518e-01f, -5.31241357e-01f, -1.07327104e-02f, -6.30758405e-01f, 5.85401878e-02f, 4.81439322e-01f, -1.26509249e-01f,
  -4.58892107e-01f, -1.98522047e-03f, 3.46740186e-01f, -5.62979460e-01f, 5.72020531e-01f, 8.84480238e-01f, -1.45066410e-01f, -2.84225523e-01f, 3.93181205e-01f, -3.99235547e-01f,
  -7.47869760e-02f, -5.43426633e-01f, -3.51057500e-01f, -1.77955642e-01f, -6.81066096e-01f, -2.47279063e-01f, -4.56214637e-01f, -4.23009507e-02f, -6.52649403e-01f, -1.62972599e-01f,
  -3.08138907e-01f, -4.71112192e-01f, -3.96945775e-01f, -4.75970171e-02f, -1.95953518e-01f, -9.55807716e-02f, -2.52742432e-02f, -5.28321788e-03f, -1.22018062e-01f, 4.69002686e-02f,
  1.05079830e-01f, 1.07332267e-01f, 3.38732973e-02f, 1.66764572e-01f, -1.67553276e-02f, -1.27458006e-01f, 8.53525698e-02f, -9.47053134e-02f, -2.57345945e-01f, -5.49165867e-02f,
  -1.00084856e-01f, 4.24290858e-02f, -1.25340685e-01f, -4.16855142e-02f, -1.16447404e-01f, -7.45088188e-03f, 1.03777058e-01f, -6.81043491e-02f, -1.31647801e-02f, 1.71630174e-01f,
  2.34472752e-02f, 3.97757664e-02f, -5.07223196e-02f, -5.52343251e-03f, -5.37823364e-02f, -1.72263294e-01f, -4.61770082e-03f, -6.21602573e-02f, 1.25996500e-01f, -5.18143065e-02f,
  -9.20131281e-02f, -4.91684526e-02f, 6.17996044e-02f, 1.87109392e-02f, -1.00800723e-01f, -2.75077932e-02f, -1.41883761e-01f, 5.83548322e-02f, 3.29432078e-02f, 7.09047839e-02f,
  -5.53574301e-02f, 8.52121636e-02f, -1.04033567e-01f, -1.09379077e-02f, 1.07268989e-02f, 4.16333787e-02f, 1.47546455e-01f, -1.02415770e-01f, -7.33136758e-03f, -1.91300437e-01f,
  1.12038568e-01f, 1.39051273e-01f, -1.43651053e-01f, -1.89091027e-01f, 1.71435744e-01f, -5.48604243e-02f, 1.65322050e-01f, -9.53176990e-02f, 6.24100901e-02f, -4.99849431e-02f,
  -1.11314304e-01f, 1.57059267e-01f, -1.80131220e-03f, -5.16625047e-02f, 2.27922857e-01f, 2.80852705e-01f, -6.57166317e-02f, 2.38689631e-02f, -2.74969749e-02f, -1.39243245e-01f,
  -2.85671443e-01f, -1.04925837e-02f, -6.84498949e-03f, 1.23867684e-03f, -3.58091891e-02f, -1.32883638e-01f, -1.59986038e-02f, 4.31172587e-02f, -9.06827301e-02f, 1.28864661e-01f,
  -4.21904176e-02f, -3.32592368e-01f, 1.03852546e+00f, -5.25887489e-01f, 4.32382345e-01f, 5.97225070e-01f, 4.24753994e-01f, 1.84470743e-01f, -4.12880152e-01f, -5.93473315e-01f,
  -9.78111401e-02f, -1.96865313e-02f, 4.97695714e-01f, -3.42943281e-01f, 6.61127210e-01f, 1.78643823e-01f, -2.04173058e-01f, -2.54454464e-01f, 3.47372964e-02f, -1.75179988e-01f,
  -5.28176427e-02f, -4.62131798e-01f, 6.28944516e-01f, -3.68959367e-01f, 2.68984228e-01f, -2.63523042e-01f, -3.91212314e-01f, 3.95286441e-01f, -4.35040385e-01f, 1.61054686e-01f,
  -1.34071052e-01f, -1.53424680e-01f, -1.14704117e-01f, -5.56043461e-02f, 1.49236515e-01f, 1.36252239e-01f, 1.38444692e-01f, 2.38579914e-01f, 4.89556715e-02f, 1.35751637e-02f,
  9.76394638e-02f, 9.04006958e-02f, -2.26528287e-01f, 1.87864397e-02f, 5.17433137e-03f, 2.83548515e-02f, 1.60563350e-01f, 5.46875061e-04f, -2.93570966e-03f, 3.55541646e-01f,
  2.93799788e-01f, 2.19451725e-01f, 1.84372187e-01f, -6.17162436e-02f, 2.09357232e-01f, 1.12809002e-01f, 1.25400648e-01f, 2.21200213e-01f, -5.04882522e-02f, -2.18081307e-02f,
  -2.83507016e-02f, -1.41997248e-01f, 8.49420801e-02f, -1.02522306e-01f, 6.01209998e-02f, -3.21842656e-02f, -1.02326371e-01f, -3.91955003e-02f, 1.94721594e-02f, 2.68454682e-02f,
  -4.80982959e-02f, 4.17284705e-02f, -4.27235067e-02f, -7.03375600e-03f, -1.27247274e-01f, -1.47333995e-01f, 3.52636315e-02f, 4.13141660e-02f, 1.82660259e-02f, 2.64605023e-02f,
  -7.02348202e-02f, 1.46876536e-02f, 3.30021717e-02f, -4.87249941e-02f, -6.07039109e-02f, -2.95299906e-02f, -3.47796790e-02f, 1.66733801e-01f, 5.94765767e-02f, 8.13766196e-02f,
  -7.00920880e-01f, -8.38231564e-01f, -2.58674860e-01f, -1.65908098e-01f, -2.11604133e-01f, -5.97263649e-02f, -9.30830315e-02f, -1.40303746e-01f, -1.94870889e-01f, -9.38508380e-03f,
  -1.03156269e-01f, -6.31284416e-02f, -1.36139691e-01f, -8.68662596e-02f, -2.14814276e-01f, -3.47687267e-02f, -1.08601362e-01f, -2.53879398e-01f, -1.68475583e-01f, -1.44719258e-01f,
  -9.36240777e-02f, -1.85826197e-01f, -1.63292009e-02f, -7.12240636e-02f, -1.45392969e-01f, -5.57607673e-02f, -1.65799171e-01f, -1.02275617e-01f, 1.01549484e-01f, -2.03769263e-02f,
  2.98240185e-01f, -1.27740443e+00f, 1.70320868e-01f, 6.18439913e-01f, 6.27393365e-01f, 9.78247747e-02f, 5.13114870e-01f, -2.36522958e-01f, 9.94039252e-02f, -8.73368621e-01f,
  -1.75108090e-01f, -3.08236152e-01f, -3.80881995e-01f, -2.88182646e-01f, 8.10281456e-01f, -3.14478725e-01f, -1.14460468e-01f, -2.86549568e-01f, 5.58966585e-02f, -1.86942354e-01f,
  3.38737518e-01f, 6.81714341e-02f, 3.55204731e-01f, -2.76134431e-01f, 6.37550876e-02f, 1.25859343e-02f, 7.02550933e-02f, 3.96764539e-02f, -1.04631767e-01f, 1.95064366e-01f,
  -5.69726564e-02f, 4.23626266e-02f, 4.97450158e-02f, -6.21630773e-02f, -1.07037306e-01f, 1.09666780e-01f, -7.24791586e-02f, 1.94150910e-01f, 3.67399216e-01f, -2.23498028e-02f,
  -5.79649433e-02f, 3.53168771e-02f, 5.03458194e-02f, 9.17134732e-02f, 7.27620572e-02f, 1.80521812e-02f, -3.27201486e-02f, 1.59439761e-02f, -1.59889176e-01f, 1.95702780e-02f,
  -8.03433433e-02f, -7.16312304e-02f, 1.06042922e-01f, -1.03019245e-01f, 8.99881050e-02f, 1.69023760e-02f, 3.76428589e-02f, -8.15063715e-03f, -5.53378612e-02f, 7.42154792e-02f,
  -1.66403890e-01f, 3.34260650e-02f, -1.74897850e-01f, -3.03746052e-02f, 2.52190083e-02f, 7.63257518e-02f, 3.20485048e-02f, 2.60781702e-02f, 2.36955713e-02f, -1.14146017e-01f,
  1.33937206e-02f, 1.21236600e-01f, -1.34767648e-02f, 1.02180406e-01f, -1.78708024e-02f, -4.38305959e-02f, 3.10640782e-02f, -2.91151535e-02f, -1.95077173e-02f, 1.05076268e-01f,
  -2.16728784e-02f, 8.01646262e-02f, -1.34833828e-01f, 6.97210431e-02f, -3.61023396e-02f, 1.03191607e-01f, -1.07639372e-01f, -1.34376451e-01f, -4.41805311e-02f, 1.22712106e-01f,
  -5.69370508e-01f, -1.01574719e+00f, -7.97535628e-02f, 9.03621223e-03f, -1.22606486e-01f, -1.92343950e-01f, -3.56925651e-02f, -1.67920381e-01f, -1.04677409e-01f, -6.15433790e-02f,
  -8.86237770e-02f, 6.87023401e-02f, -1.69919342e-01f, 1.48954660e-01f, 1.10650398e-01f, -1.39536008e-01f, 7.31343254e-02f, -1.20999932e-01f, 2.94867586e-02f, -1.17359884e-01f,
  -1.21947505e-01f, -1.42169163e-01f, 1.60072833e-01f, 1.21500671e-01f, 5.82271367e-02f, -6.98822215e-02f, -2.29007695e-02f, -2.65662093e-02f, -1.17557488e-01f, -1.89090967e-02f,
  -6.91078126e-01f, 3.12473536e-01f, -4.11527485e-01f, -1.85756564e-01f, 5.60028613e-01f, -8.66897762e-01f, -3.66930991e-01f, 4.10147190e-01f, -2.27792561e-01f, 3.63051116e-01f,
  2.22098574e-01f, -3.16951871e-01f, 3.38712960e-01f, -5.63010693e-01f, -9.27167952e-01f, -5.44119656e-01f, -4.96185988e-01f, -4.48561728e-01f, -2.21526876e-01f, 2.09321991e-01f,
  -2.55509645e-01f, 2.48364910e-01f, -5.00055730e-01f, 6.76130772e-01f, 1.84040591e-01f, 2.18813568e-01f, 7.82194078e-01f, 4.94143993e-01f, -3.37921232e-02f, -1.51795983e-01f,
  -3.53922576e-01f, 1.49067521e-01f, -2.95991218e-03f, -1.63305551e-01f, 4.83130477e-02f, 4.98146378e-02f, -1.23248957e-02f, -7.93598294e-02f, -2.56400019e-01f, -1.38600081e-01f,
  3.59172896e-02f, 2.02394370e-02f, -6.02437817e-02f, 3.07145491e-02f, 9.68067870e-02f, 7.97371864e-02f, -1.34010449e-01f, -1.85421050e-01f, -7.64178559e-02f, -1.74089223e-01f,
  -1.64717913e-01f, -2.26869687e-01f, 1.13629259e-01f, -8.98855031e-02f, 1.93154979e-02f, -3.35742496e-02f, -2.65322268e-01f, -6.65459782e-02f, -1.72102284e-02f, -7.09202737e-02f,
  3.59961428e-02f, -8.84374045e-03f, -5.46546802e-02f, -1.23733282e-01f, -5.50842620e-02f, 6.70597032e-02f, 2.91528683e-02f, -5.30798966e-03f, 2.91708838e-02f, 3.03839836e-02f,
  5.80026954e-02f, 4.45998013e-02f, 7.28869215e-02f, -2.96319425e-02f, -7.50667900e-02f, -6.88145757e-02f, 1.10278204e-01f, 1.47015795e-01f, -9.73428972e-03f, -3.19199152e-02f,
  2.04942614e-01f, -6.71802163e-02f, 9.53608453e-02f, 9.90582481e-02f, -5.26630841e-02f, 1.86253011e-01f, 5.07749729e-02f, 2.47442983e-02f, -3.07320505e-02f, 8.23707953e-02f,
  8.35997686e-02f, 5.57099104e-01f, -1.03006242e-02f, -4.65041511e-02f, 3.24638821e-02f, 5.18282056e-02f, -7.98619688e-02f, -6.49492517e-02f, 1.12375051e-01f, 1.87904965e-02f,
  2.22067267e-01f, -1.49018234e-02f, 5.74978292e-02f, -3.19440998e-02f, -1.11507820e-02f, 8.18659589e-02f, 1.43341571e-01f, -4.69562262e-02f, 2.56016940e-01f, 1.54901911e-02f,
  2.39393875e-01f, 6.20220900e-02f, -4.88154218e-02f, 5.58172911e-02f, 1.50812820e-01f, 5.59969172e-02f, 6.96563274e-02f, 1.79153532e-02f, 1.37403131e-01f, 4.56041396e-02f,
  8.46256077e-01f, 4.86578315e-01f, 4.72767830e-01f, 6.90587699e-01f, 4.27087039e-01f, -1.31768093e-01f, 9.64410752e-02f, 5.95011234e-01f, 1.26161778e+00f, 9.81895402e-02f,
  -3.49167436e-01f, 4.65854794e-01f, -4.07320648e-01f, 2.77566642e-01f, -1.17442942e+00f, -4.58814591e-01f, -1.74678907e-01f, 5.04216366e-02f, 4.08810854e-01f, 1.61302119e-01f,
  -4.22632098e-02f, -7.17755735e-01f, -5.57610571e-01f, -2.06361637e-01f, 4.22079146e-01f, 3.30521613e-01f, -8.03659022e-01f, -8.14989060e-02f, -2.26530805e-01f, -2.18224287e-01f,
  8.82621035e-02f, 6.04534030e-01f, 1.56272054e-01f, -3.38884406e-02f, 6.95976019e-02f, 4.48227935e-02f, -1.25076607e-01f, -2.24157482e-01f, 8.31328779e-02f, 8.11898559e-02f,
  2.68764272e-02f, -3.49282734e-02f, 7.30662644e-02f, -4.21831310e-02f, 4.41062391e-01f, 1.80637494e-01f, 1.42319277e-01f, 1.74826264e-01f, 2.78105736e-01f, 2.20579356e-01f,
  2.15756133e-01f, 1.74196973e-01f, 9.36553851e-02f, -8.65911618e-02f, -3.17026377e-02f, 2.99834937e-01f, -3.82156763e-03f, -1.24957629e-01f, 8.73005316e-02f, 2.08074331e-01f,
  -1.54884875e-01f, 2.61878595e-02f, -5.21291718e-02f, 1.18860587e-01f, -1.22466922e-01f, 9.26022604e-02f, -7.72100687e-02f, -1.88237265e-01f, 7.95650780e-02f, -1.60539359e-01f,
  4.71789390e-02f, 1.62029620e-02f, 1.06348604e-01f, 9.49863046e-02f, -6.84518218e-02f, 1.18557341e-01f, -2.39525303e-01f, 7.69694820e-02f, 1.68041646e-01f, 9.31885615e-02f,
  1.29502462e-02f, 1.12927435e-02f, -1.17865346e-01f, -1.96180940e-02f, 1.83350989e-03f, -7.63637871e-02f, 8.44385847e-02f, 1.46275252e-01f, 2.88253091e-02f, -3.59764695e-01f,
  -4.28464532e-01f, -4.08719212e-01f, -1.51187196e-01f, 8.36760104e-02f, -1.83841139e-01f, -1.09593175e-01f, -5.72891794e-02f, 1.77484512e-01f, -1.75982296e-01f, 1.54566476e-02f,
  5.00551658e-04f, 1.01625547e-01f, -2.64774673e-02f, 3.79710421e-02f, -2.93730289e-01f, -3.91227491e-02f, -2.50698067e-02f, -3.35756652e-02f, -2.14733362e-01f, -2.43338048e-01f,
  -3.37425247e-02f, -1.58686474e-01f, -1.01157874e-01f, 7.47809783e-02f, 2.16712132e-02f, -1.13424078e-01f, 1.68070480e-01f, 6.12082658e-03f, -1.88552827e-01f, -6.52129203e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 8)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 8;
const float L0_fan_Bp_bar_data[] = {
  6.04859173e-01f, 9.40749288e-01f, 6.03271484e-01f, 8.34116757e-01f, 6.79906189e-01f, 4.66712385e-01f, 6.57759011e-01f, 1.04998398e+00f
};

// L1_linear_W (Shape: 12 x 32)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 32;
const float L1_linear_W_data[] = {
  -7.86626711e-02f, -4.57465917e-01f, -1.24948585e+00f, 1.29930869e-01f, -1.83900427e-02f, -1.46320903e+00f, 2.68153965e-01f, -7.04845607e-01f, 1.00499399e-01f, 3.28219444e-01f,
  4.29206610e-01f, 1.43995008e-03f, -9.26649034e-01f, -1.27988470e+00f, 2.36675680e-01f, 9.02924359e-01f, -6.19948626e-01f, -6.93352222e-01f, -1.30226624e+00f, -7.51948059e-01f,
  8.53223860e-01f, -4.27984565e-01f, -5.15849173e-01f, -6.94427609e-01f, -2.81052560e-01f, 6.52727723e-01f, -6.48060381e-01f, 7.30045438e-02f, -4.99962360e-01f, -3.74820948e-01f,
  -2.15120211e-01f, -8.52189541e-01f, -5.96760869e-01f, 4.06512439e-01f, -3.03890519e-02f, 5.42417228e-01f, 4.76244003e-01f, 2.13310108e-01f, -1.06271327e+00f, 8.25345755e-01f,
  3.97726983e-01f, -3.46306086e-01f, 7.14531064e-01f, -3.84641558e-01f, -5.87927163e-01f, -5.02682209e-01f, 9.39030468e-01f, -6.61614120e-01f, 3.26289386e-01f, -7.81295717e-01f,
  7.75166810e-01f, 3.65551144e-01f, -3.15561384e-01f, -5.64847052e-01f, -4.22070891e-01f, -5.83233774e-01f, -4.38375205e-01f, 3.06857675e-01f, 1.34770036e+00f, -1.09253550e+00f,
  -4.98627275e-01f, -1.22282279e+00f, -4.98586714e-01f, -1.01311553e+00f, 2.61294901e-01f, -3.20426188e-02f, -9.14345980e-02f, -6.78954601e-01f, -7.67253041e-01f, 4.72026199e-01f,
  3.71833026e-01f, -2.35530257e-01f, 7.60822892e-02f, 6.12700731e-02f, -6.78955555e-01f, -6.58952057e-01f, 7.82613337e-01f, -7.25384295e-01f, -6.34094834e-01f, -3.67075831e-01f,
  3.52604568e-01f, -1.07241690e-01f, -1.74185455e-01f, -1.54667974e-01f, 6.74992576e-02f, 6.35161519e-01f, -3.04312915e-01f, -5.35402298e-01f, 5.98051250e-01f, 4.07344801e-03f,
  5.26048481e-01f, -6.78325415e-01f, -7.94017553e-01f, 7.10354984e-01f, -4.22478199e-01f, -1.09084988e+00f, -2.76728123e-01f, 1.03331178e-01f, 4.39706862e-01f, -4.98468041e-01f,
  -1.33379483e+00f, 5.35007417e-02f, -7.07723618e-01f, 3.95689875e-01f, 5.45931794e-02f, -7.10117757e-01f, -1.37364522e-01f, -2.02997327e-01f, 2.85220683e-01f, 2.83689857e-01f,
  7.62122869e-02f, 1.90962538e-01f, -3.24312598e-01f, -6.75750911e-01f, -4.46386009e-01f, -1.05109608e+00f, 1.12238324e+00f, 9.31964219e-01f, -4.17952985e-01f, 4.89206791e-01f,
  -6.48451984e-01f, -5.78819931e-01f, -8.26061130e-01f, -9.49393958e-03f, -5.57640254e-01f, -3.70576233e-01f, 9.45337772e-01f, 4.73885655e-01f, 3.76993597e-01f, 3.17390978e-01f,
  1.36976987e-01f, 3.87851894e-01f, 8.04199934e-01f, 6.48902833e-01f, 5.79553723e-01f, 2.44755283e-01f, -2.67426759e-01f, 2.46535063e-01f, 1.33329719e-01f, -9.20874178e-02f,
  1.12420690e+00f, 5.70032835e-01f, 4.27983671e-01f, 1.17553341e+00f, -1.21970069e+00f, -2.29403213e-01f, -3.21677178e-01f, 1.18564203e-01f, 8.52176726e-01f, 1.05252230e+00f,
  -1.98284257e-02f, -1.43235970e+00f, -1.51278883e-01f, -1.19459677e+00f, -3.21190566e-01f, 2.55831420e-01f, 9.80783582e-01f, -2.69789040e-01f, -7.52569437e-01f, -1.26127023e-02f,
  5.38961649e-01f, 4.53067362e-01f, 2.14936063e-01f, -2.65515149e-01f, 1.30385146e-01f, 1.13521206e+00f, 1.64412454e-01f, 3.06567580e-01f, -1.31499961e-01f, 5.64307094e-01f,
  -4.62998658e-01f, 5.55517554e-01f, -6.43420100e-01f, 1.09550560e+00f, 3.46016288e-01f, -4.91437614e-01f, 9.27366763e-02f, 8.15634966e-01f, 9.72620487e-01f, -3.59651268e-01f,
  -9.02930319e-01f, 9.03114080e-02f, 1.17337036e+00f, 5.04496358e-02f, -4.24858093e-01f, 7.42925465e-01f, -7.78486311e-01f, 5.31012118e-01f, -1.05498719e+00f, -7.24536300e-01f,
  -9.22573447e-01f, 2.05207333e-01f, -8.06857646e-01f, -3.16309094e-01f, 3.94125730e-02f, 4.41292614e-01f, -7.39159942e-01f, -3.68800819e-01f, -4.49874967e-01f, -7.01526880e-01f,
  -2.02458333e-02f, -2.03296542e-01f, 3.07600468e-01f, -1.91645220e-01f, -5.55072963e-01f, 7.44176924e-01f, -5.95454693e-01f, 5.70645154e-01f, 3.46826881e-01f, 5.73476017e-01f,
  6.47010148e-01f, 5.67268491e-01f, 9.33518410e-01f, -2.07188338e-01f, -5.04310913e-02f, 6.98799372e-01f, 3.95408198e-02f, 9.83593017e-02f, 3.53476666e-02f, -7.10147023e-01f,
  1.72138792e-02f, 5.36118507e-01f, -5.15743971e-01f, 7.65468597e-01f, 9.42402259e-02f, 1.61515232e-02f, -1.18960232e-01f, -4.11945283e-02f, -4.02503103e-01f, -9.53057408e-01f,
  -1.46492049e-01f, -4.81954902e-01f, 4.56688464e-01f, -5.29619753e-01f, -3.49309921e-01f, -8.97611976e-01f, 5.08252323e-01f, 8.15489292e-01f, -7.83008695e-01f, -8.44749510e-01f,
  -4.94440436e-01f, 7.79386044e-01f, -2.37699255e-01f, -4.96915966e-01f, -1.89275578e-01f, -7.77619600e-01f, 2.68417913e-02f, 8.55911255e-01f, 1.93607420e-01f, -9.91581559e-01f,
  1.70048714e-01f, 1.10381269e+00f, -1.20917268e-01f, -1.76135808e-01f, -4.83616173e-01f, -5.66941857e-01f, -8.36453959e-02f, -4.51762825e-01f, 2.77094752e-01f, -5.75448275e-01f,
  4.80495691e-01f, -3.22939694e-01f, 2.30573535e-01f, -4.65425164e-01f, -3.97279143e-01f, -1.09012937e-02f, -1.45319760e-01f, 4.20216322e-01f, -7.95159817e-01f, 7.20755041e-01f,
  -3.70825112e-01f, -5.46447992e-01f, -2.20325157e-01f, -4.94598448e-01f, 6.95890665e-01f, 5.21683216e-01f, -2.27296904e-01f, -2.05525085e-01f, -5.68741500e-01f, 4.74696517e-01f,
  1.24187815e+00f, -4.60062861e-01f, -6.74040198e-01f, -6.76085413e-01f, -2.70138174e-01f, -5.50972283e-01f, 3.12860847e-01f, -5.99540055e-01f, 4.55494106e-01f, -1.05176404e-01f,
  2.97674507e-01f, 6.25244081e-02f, 1.55414149e-01f, -2.81621516e-01f, 3.58447015e-01f, 1.36356190e-01f, 1.19277164e-01f, -1.85524940e-01f, -2.37127945e-01f, 5.66988349e-01f,
  1.81639284e-01f, -5.32669008e-01f, -8.08362663e-01f, -3.52850288e-01f, 7.67043948e-01f, 7.44090676e-01f, 1.58287515e-03f, -6.32911623e-01f, 2.22400557e-02f, -3.85551274e-01f,
  -5.58842242e-01f, 1.92725226e-01f, -1.28134787e+00f, 2.24451512e-01f, -8.19449663e-01f, -7.83404946e-01f, 9.08072591e-01f, 8.75626802e-01f, -5.28456748e-01f, -1.50713146e+00f,
  -2.56519228e-01f, -3.52269113e-01f, -7.66632631e-02f, 4.77879167e-01f, 9.18605626e-01f, 1.68566987e-01f, 7.19625831e-01f, -9.31212753e-02f, -1.94072857e-01f, 7.74304152e-01f,
  1.18831564e-02f, 2.09844440e-01f, 8.70923579e-01f, -8.07009101e-01f, -6.77157760e-01f, 8.10967028e-01f, 8.50379243e-02f, -1.18665636e-01f, -9.81466752e-03f, 1.00273180e+00f,
  -1.15311885e+00f, -4.14517462e-01f, 8.59216988e-01f, 5.93930304e-01f, -9.03625190e-01f, -7.44234681e-01f, 4.93964761e-01f, -6.13924026e-01f, -6.10525370e-01f, -4.29892719e-01f,
  8.41832638e-01f, -2.76561141e-01f, 4.92600858e-01f, 3.78634900e-01f, -1.86426193e-01f, 2.51855198e-02f, 3.31180900e-01f, 6.82483837e-02f, -2.33462214e-01f, 5.08345366e-01f,
  -3.46096680e-02f, 1.30816460e-01f, -9.77367908e-02f, 3.22258532e-01f, 1.44813672e-01f, 5.39803877e-02f, 8.07651401e-01f, -8.10157120e-01f, 7.34424174e-01f, 5.94037056e-01f,
  -9.16947842e-01f, 4.26886469e-01f, -7.04467714e-01f, 5.69071829e-01f, 4.22646910e-01f, 5.32377243e-01f, 3.02531302e-01f, -1.24739993e+00f, -9.12666380e-01f, -8.15380335e-01f,
  -9.32321250e-02f, -1.04185963e+00f, -6.36514664e-01f, 1.27424276e+00f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  2.98138797e-01f, 2.36998230e-01f, -3.78792375e-01f, -3.27617973e-01f, 2.76571304e-01f, -6.80377036e-02f, -4.36553478e-01f, 2.59418875e-01f, -7.79415201e-03f, 4.18753177e-02f,
  -1.78511497e-02f, 2.01927006e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 12, 8
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        32, 12
    );
    }
    