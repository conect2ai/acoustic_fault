/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 19 x 120)
const int L0_fan_Wp_rows = 19;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -9.34310332e-02f, -5.96607430e-03f, -3.24299097e-01f, -2.64257882e-02f, 3.53272222e-02f, -6.35463968e-02f, -1.36486918e-01f, 1.29057273e-01f, -2.81921297e-01f, 2.72359818e-01f,
  1.56400800e-01f, -1.57515317e-01f, -1.37663186e-01f, 1.14884898e-01f, -3.12894508e-02f, -1.87778607e-01f, 1.84889510e-01f, 1.98346600e-02f, -2.01417759e-01f, 1.35965928e-01f,
  -9.36132967e-02f, 3.06221694e-01f, -3.67442928e-02f, 1.87510565e-01f, 1.41710982e-01f, 5.33360168e-02f, 3.78755391e-01f, -1.43725976e-01f, 3.09341967e-01f, -2.57931445e-02f,
  -4.26835567e-03f, -8.44257995e-02f, -2.12000851e-02f, -3.41793634e-02f, 6.36014417e-02f, 5.94126135e-02f, -9.57509037e-03f, -1.33086279e-01f, -1.01549380e-01f, -9.62751266e-03f,
  -4.59770486e-02f, 1.81757361e-02f, 7.42546171e-02f, -4.36534807e-02f, -9.10669267e-02f, 1.45639079e-02f, -3.73435840e-02f, 3.66443209e-02f, -3.45974639e-02f, -2.96976417e-02f,
  -9.38120484e-02f, -4.92254421e-02f, 1.39074808e-03f, 8.34182724e-02f, -1.25298992e-01f, -5.49707189e-02f, -4.29523177e-02f, 1.26041612e-02f, -2.82301847e-02f, -4.79350984e-02f,
  5.13719358e-02f, -4.35860790e-02f, 3.69729288e-02f, 7.06453100e-02f, 7.73352087e-02f, 1.69662759e-02f, 4.64837663e-02f, 4.59484942e-02f, 1.18040033e-02f, 5.38612939e-02f,
  5.12070842e-02f, 2.02577983e-04f, -6.95866998e-03f, 1.03131961e-02f, -7.28064589e-03f, 6.59339130e-03f, 3.60723846e-02f, 6.66068308e-03f, -1.76371019e-02f, 2.78972872e-02f,
  -4.68225740e-02f, -1.95763409e-02f, -2.81482525e-02f, 2.72348784e-02f, -3.38083096e-02f, -4.08982076e-02f, -1.19163422e-02f, 1.18491631e-02f, -4.40448634e-02f, 2.35272534e-02f,
  2.66544521e-01f, 2.02691987e-01f, 4.02987301e-02f, 3.43185216e-02f, 1.06423654e-01f, 7.71192238e-02f, -2.71740127e-02f, 6.85838610e-02f, 7.86763430e-02f, 4.84151533e-04f,
  6.58518448e-02f, 1.63728874e-02f, -1.06958346e-02f, 2.57419124e-02f, 4.48923074e-02f, 3.88085097e-02f, 5.75671531e-02f, 3.07422187e-02f, 1.01012051e-01f, 4.98276018e-02f,
  1.35975510e-01f, 2.87350900e-02f, -1.38560904e-03f, 1.22429256e-03f, 1.10286810e-01f, 6.72749802e-02f, 5.69297448e-02f, -1.02712944e-01f, 6.52914867e-02f, 5.61835524e-03f,
  -2.90239006e-02f, -2.02750966e-01f, -1.08951181e-01f, -5.14203459e-02f, 9.30742640e-03f, 2.68656611e-01f, 3.47269654e-01f, -1.10222533e-01f, -8.48476440e-02f, 1.57164320e-01f,
  2.14778781e-01f, -1.42790556e-01f, 2.59491857e-02f, 5.14401421e-02f, -6.13516662e-03f, -7.16030300e-02f, 1.49628580e-01f, 1.07357733e-01f, -1.79036483e-01f, -3.28190289e-02f,
  -7.53589720e-02f, 2.08277792e-01f, -7.80946165e-02f, -1.08838022e-01f, -7.10267350e-02f, -2.96457224e-02f, 7.68058077e-02f, 4.23631538e-03f, 7.24920109e-02f, 6.75620809e-02f,
  1.64535958e-02f, -4.50772345e-02f, -7.56341070e-02f, -5.10715181e-03f, 5.79125509e-02f, 6.56310245e-02f, 1.02287620e-01f, 8.67213383e-02f, 3.04031186e-02f, 3.18081826e-02f,
  1.74360126e-02f, 6.62011802e-02f, 7.57405907e-02f, 1.32173095e-02f, -1.09147010e-02f, -7.43075237e-02f, -9.47038233e-02f, -1.24414163e-02f, 2.22093146e-02f, -5.09661585e-02f,
  -4.97222207e-02f, -5.50628118e-02f, 3.15054469e-02f, 9.15221348e-02f, -1.81429274e-02f, 8.89184773e-02f, 6.48849979e-02f, 4.72570695e-02f, 1.31992334e-02f, 5.15141990e-04f,
  5.50211407e-02f, -1.44687798e-02f, 5.38594313e-02f, -6.69412687e-02f, -4.61740345e-02f, 1.98701471e-02f, 5.38107846e-03f, 6.43440038e-02f, -4.19507436e-02f, 4.53195833e-02f,
  3.58355790e-02f, -5.79630584e-02f, -5.17242355e-03f, 1.02852564e-03f, 1.48626631e-02f, 1.20472331e-02f, 3.22872028e-02f, -1.20883137e-02f, -4.16006111e-02f, -2.60585118e-02f,
  1.59065463e-02f, 2.75569484e-02f, -6.79260641e-02f, 3.38312890e-03f, 2.79448573e-02f, -1.77196860e-02f, 3.95814702e-02f, -4.40046377e-02f, 2.52241804e-03f, 1.39383618e-02f,
  1.18227057e-01f, 4.01472002e-02f, 6.90620244e-02f, 4.14801314e-02f, -5.42724319e-02f, 4.52841520e-02f, -4.71915044e-02f, -5.77719770e-02f, 2.65001412e-02f, 6.87869638e-02f,
  7.22866356e-02f, 9.27129295e-03f, 2.14822926e-02f, 6.92625493e-02f, 8.42660889e-02f, 1.05858982e-01f, 3.63999903e-02f, -3.88809806e-03f, 4.24410067e-02f, -1.67567208e-02f,
  7.97066558e-03f, -2.44638901e-02f, 2.32418869e-02f, 2.43719351e-02f, 8.94364044e-02f, 1.33959437e-02f, -8.22356269e-02f, 4.69517000e-02f, 4.45068292e-02f, -1.13259852e-02f,
  -3.39621544e-01f, -9.40136686e-02f, 9.35094878e-02f, -8.61404762e-02f, -3.43448818e-02f, -1.78790674e-01f, -1.69270009e-01f, -9.37024951e-02f, -1.52378216e-01f, -2.59118229e-01f,
  -9.46022719e-02f, -8.94074813e-02f, 4.32266854e-04f, -1.34715945e-01f, 1.04364954e-01f, 7.74472803e-02f, -7.00416043e-02f, -1.27640128e-01f, 3.70866023e-02f, -4.48562764e-02f,
  -2.21278537e-02f, -7.88719952e-02f, 8.49142522e-02f, 4.99552600e-02f, -5.51727526e-02f, -9.11914110e-02f, 1.00160100e-01f, 1.28037944e-01f, -3.66063491e-02f, -4.36796285e-02f,
  -3.84684280e-02f, -1.72981948e-01f, 4.18568291e-02f, 1.78303849e-02f, -7.78210014e-02f, 1.48658985e-02f, 4.16629352e-02f, 5.49976528e-02f, 6.61274046e-02f, -3.26148011e-02f,
  -2.54557915e-02f, 7.95385465e-02f, -6.72082677e-02f, 1.56124746e-02f, -5.09468168e-02f, -2.35368609e-02f, 8.57520923e-02f, 5.21203354e-02f, 9.32953414e-03f, 2.89445603e-03f,
  -1.66308153e-02f, 6.82763085e-02f, 1.78205892e-02f, -2.92337723e-02f, 3.73629220e-02f, -2.89295428e-02f, 2.33107582e-02f, 5.18197827e-02f, -4.88879047e-02f, -5.73219433e-02f,
  -1.01356983e-01f, 3.97382975e-02f, 4.46990430e-02f, 2.49443389e-02f, -2.39747067e-04f, 1.32938689e-02f, 3.41382250e-02f, -3.66146211e-04f, 7.11334916e-03f, -1.00483000e-02f,
  -3.04205287e-02f, 2.90993340e-02f, -3.20099927e-02f, -9.64630768e-03f, -6.87128752e-02f, -6.14847019e-02f, 4.38674726e-02f, -4.30875830e-02f, -1.48223666e-02f, -3.30448598e-02f,
  -8.65122229e-02f, -1.74839161e-02f, -7.16442391e-02f, -4.24861498e-02f, -2.34049913e-02f, 4.77637388e-02f, 2.72273142e-02f, 2.71043908e-02f, -2.40556225e-02f, 4.59171422e-02f,
  -1.51527062e-01f, -2.62472898e-01f, 1.18064955e-02f, -3.09758354e-02f, 2.25537289e-02f, 7.17882887e-02f, -2.99389642e-02f, 9.51254857e-04f, -1.22527912e-01f, -2.61909775e-02f,
  3.38539928e-02f, -1.36727439e-02f, -2.56712586e-02f, 1.06822401e-02f, 6.46797344e-02f, -1.21815335e-02f, -2.98980139e-02f, -6.66341558e-02f, -5.82360663e-02f, -5.41388988e-02f,
  3.69325019e-02f, -4.57071140e-02f, 3.46136205e-02f, -2.65755318e-02f, -8.73899739e-03f, -1.76984444e-02f, -1.52594121e-02f, 6.73673395e-03f, -1.25471558e-02f, -3.01160477e-02f,
  8.62667337e-02f, 2.48471886e-01f, 1.29612073e-01f, -9.69602093e-02f, -3.40432785e-02f, 2.54880100e-01f, 4.75585349e-02f, -2.01004371e-02f, -5.49869388e-02f, 1.52162522e-01f,
  -1.92063451e-02f, 5.53548858e-02f, 3.67630310e-02f, 7.16635361e-02f, -1.66172422e-02f, 1.46709889e-01f, 1.27414048e-01f, 4.23062779e-02f, 4.93830889e-02f, 4.55259606e-02f,
  2.42422447e-02f, 1.17208622e-01f, 7.76731297e-02f, -3.24774608e-02f, -1.01149315e-03f, -1.21142924e-01f, -1.78068399e-01f, -7.27331638e-02f, 7.95729533e-02f, 1.70518830e-02f,
  1.37943342e-01f, -1.05139516e-01f, 6.35172278e-02f, -3.76642346e-02f, -7.94098377e-02f, 3.57638206e-03f, -4.84832078e-02f, 3.02932579e-02f, -7.79009610e-02f, 5.07668853e-02f,
  -1.84883457e-02f, -3.15800160e-02f, -2.35502142e-02f, 5.94783574e-03f, 1.07999571e-01f, 6.30484568e-03f, 7.93501213e-02f, 1.60563327e-02f, -1.16197467e-02f, 9.47423130e-02f,
  3.08545064e-02f, -2.73581110e-02f, -8.92544314e-02f, -5.80586679e-02f, -3.72615340e-03f, 1.83948893e-02f, 3.95582803e-02f, -2.86199823e-02f, -6.35103360e-02f, 2.47278325e-02f,
  -1.18573733e-01f, -2.81389093e-05f, 7.26276189e-02f, -5.27328774e-02f, 6.11973479e-02f, 1.91030353e-02f, -1.96816120e-02f, -4.74224463e-02f, 2.24253945e-02f, 1.21643402e-01f,
  9.08463225e-02f, 3.91202457e-02f, -3.58573496e-02f, 6.47931686e-03f, 3.01346295e-02f, -5.89417480e-02f, 6.93356171e-02f, 9.58720129e-03f, 9.52323601e-02f, -4.25125025e-02f,
  4.01669666e-02f, -6.73853979e-02f, -4.41432074e-02f, -5.74514829e-02f, 5.13382256e-02f, -2.31098607e-02f, -3.14749926e-02f, 7.19158202e-02f, 1.79978111e-03f, 2.90447734e-02f,
  1.74193472e-01f, -1.11891896e-01f, 3.02329771e-02f, 2.47770920e-02f, -3.14758383e-02f, 5.81231527e-02f, -5.40068336e-02f, 6.79356009e-02f, 4.03729081e-02f, 7.17375800e-03f,
  -5.34357801e-02f, 1.26121915e-03f, 2.41025798e-02f, 9.57170129e-02f, 3.84505428e-02f, 3.32151838e-02f, -6.13341108e-02f, -2.28366721e-02f, -3.73239517e-02f, -7.40647092e-02f,
  -1.14750072e-01f, -6.96933717e-02f, -5.17131761e-02f, -6.33760914e-03f, 6.00753073e-03f, -8.05032328e-02f, -2.24233568e-02f, -7.82250147e-03f, 9.36876633e-04f, 2.85412110e-02f,
  3.62939298e-01f, -2.52441138e-01f, -1.30276799e-01f, 4.24373262e-02f, 1.60972863e-01f, -2.21132502e-01f, -1.68428540e-01f, 8.90479386e-02f, -8.57240185e-02f, -7.68152103e-02f,
  9.96704493e-03f, -7.46091530e-02f, -1.95653979e-02f, -4.40014862e-02f, 1.46472394e-01f, -1.60425201e-01f, 2.47919597e-02f, -5.31053282e-02f, -2.13960093e-02f, 1.23628609e-01f,
  8.77152532e-02f, 6.73519000e-02f, -3.09192054e-02f, 2.04707459e-02f, 8.64753723e-02f, 7.85093904e-02f, 1.03937916e-01f, 1.84050128e-02f, -4.75614779e-02f, 1.78979617e-02f,
  7.60513246e-02f, 1.57692388e-01f, -4.76746075e-02f, -8.27497691e-02f, 6.69730315e-03f, -1.62806269e-02f, -6.05860502e-02f, -1.52996778e-01f, -1.73738711e-02f, -2.99904533e-02f,
  1.39641380e-02f, 6.69464469e-02f, 1.23066884e-02f, -9.33083706e-03f, 5.27199470e-02f, -6.69490397e-02f, 5.99765629e-02f, -1.01324730e-01f, -1.06744794e-02f, -3.94327976e-02f,
  -2.27589589e-02f, -6.05093967e-03f, -3.11676003e-02f, 2.08726134e-02f, -1.55113274e-02f, -5.04100844e-02f, 5.95940165e-02f, 6.09327015e-03f, 2.86950916e-02f, -3.69587801e-02f,
  5.28565096e-03f, -6.28302665e-03f, 2.98528373e-02f, -3.42753902e-02f, 3.68179120e-02f, -4.14338335e-03f, 4.01203819e-02f, -2.55959462e-02f, 4.87142205e-02f, 5.19389026e-02f,
  1.09024167e-01f, 2.77313534e-02f, -2.85918778e-03f, -6.50481805e-02f, 7.31417611e-02f, -6.05585473e-03f, 3.58621925e-02f, -1.72330663e-02f, -2.63863038e-02f, 3.84117215e-04f,
  1.22117400e-02f, -4.74817380e-02f, -4.18862468e-03f, 9.76098515e-03f, 6.86921775e-02f, -3.44394073e-02f, -8.20883550e-03f, -1.25891780e-02f, -1.31622432e-02f, 3.31899822e-02f,
  1.00497767e-01f, 2.64155686e-01f, -2.24199630e-02f, 2.45338511e-02f, -1.10396021e-03f, 7.42782354e-02f, -5.07875234e-02f, 4.59729582e-02f, -5.43344393e-02f, -1.83631144e-02f,
  -5.77475987e-02f, -4.34821546e-02f, 7.78275430e-02f, 3.70989032e-02f, -3.14394422e-02f, -3.49970534e-02f, 2.17470080e-02f, 2.38421019e-02f, 2.41327956e-02f, 7.38577396e-02f,
  -4.54487614e-02f, -1.47795575e-02f, 9.38382000e-02f, 9.55257937e-02f, 4.57670726e-02f, 7.37702148e-03f, -1.58996333e-03f, 1.22407088e-02f, 5.07158786e-02f, 4.98497821e-02f,
  6.91063285e-01f, 2.02146411e-01f, 8.73767063e-02f, 2.82121390e-01f, -1.03134811e-01f, 2.98831195e-01f, 1.90948859e-01f, -7.15479180e-02f, 2.45461836e-01f, -6.02709502e-02f,
  -1.30754650e-01f, 2.77894616e-01f, -2.06029236e-01f, 5.20377830e-02f, -1.40931653e-02f, -4.06870693e-02f, 1.72954798e-01f, 8.53376091e-02f, 1.29043106e-02f, 8.86936933e-02f,
  1.84159279e-02f, -1.14408948e-01f, -9.82040986e-02f, -1.55801043e-01f, 1.32751539e-01f, 5.52560650e-02f, -1.87585905e-01f, -6.60041645e-02f, -6.89768791e-03f, -7.15817586e-02f,
  -9.76735167e-03f, -1.07798958e-03f, 5.41334134e-03f, -4.02127430e-02f, -3.25812772e-02f, 1.35743245e-02f, 1.29160862e-02f, -2.34414246e-02f, -5.42449914e-02f, -3.17656882e-02f,
  1.29082566e-02f, -1.19608326e-03f, -4.18606726e-03f, -5.78455776e-02f, -4.13779952e-02f, -3.41458432e-02f, 5.54244183e-02f, 7.34129772e-02f, -2.30217725e-02f, 6.41694963e-02f,
  -5.43748774e-03f, 4.36734967e-02f, 4.42935200e-03f, 2.49224919e-04f, 7.19663948e-02f, 2.47866232e-02f, 5.51334843e-02f, 5.10777859e-03f, 1.87872797e-02f, 7.24009722e-02f,
  1.57428421e-02f, -5.62740229e-02f, -6.21718653e-02f, -7.71161988e-02f, 4.36212664e-04f, -4.45946492e-02f, 4.50638309e-02f, -5.83784431e-02f, 7.70934075e-02f, 1.65621135e-02f,
  6.59169033e-02f, -9.87326633e-03f, -1.04800696e-02f, 3.05551887e-02f, 3.77245247e-02f, -4.39133793e-02f, -1.07720122e-02f, 9.18111484e-03f, 1.02148056e-02f, -7.93309789e-03f,
  -1.10343331e-03f, 5.22494433e-04f, -1.84741374e-02f, -9.79538169e-03f, -3.55344787e-02f, -4.27057035e-02f, 2.47083325e-02f, 7.50010647e-03f, -5.84538206e-02f, 3.36757302e-02f,
  -2.23559197e-02f, 1.82606578e-02f, 7.38825230e-03f, -1.55382510e-02f, -1.62278768e-02f, 4.59982306e-02f, 3.64834629e-02f, 6.70745969e-02f, 3.48196141e-02f, 2.64200177e-02f,
  8.89799464e-03f, -1.54657336e-02f, 4.19149138e-02f, 3.58843133e-02f, 2.97307111e-02f, 5.48795499e-02f, -1.99063104e-02f, 7.75159895e-03f, 3.59012000e-02f, -9.41691771e-02f,
  4.41870838e-02f, -1.68803390e-02f, -1.29662501e-02f, 1.56510342e-03f, -1.21842942e-03f, -6.05633156e-03f, 7.96122253e-02f, 2.21988056e-02f, -2.77491901e-02f, -4.76975664e-02f,
  -1.47005856e-01f, 4.54476118e-01f, 8.70819688e-02f, -1.57723248e-01f, -1.89981058e-01f, -1.30105242e-01f, -2.32179910e-01f, 5.98460510e-02f, -1.86820999e-01f, 2.61089951e-01f,
  -6.17531948e-02f, 2.73059625e-02f, 1.19957365e-01f, -7.55153522e-02f, -2.71292716e-01f, -6.30224217e-03f, -1.91205293e-02f, 1.33057879e-02f, -3.89290974e-03f, 5.20405807e-02f,
  -1.22926511e-01f, -1.22942522e-01f, 3.25260200e-02f, 1.79531917e-01f, -7.23737478e-02f, 1.57285795e-01f, 7.20198676e-02f, 6.80838898e-02f, 1.89291202e-02f, -6.73173694e-03f,
  -1.18164569e-01f, 7.75514320e-02f, 2.41585802e-02f, 2.85478355e-03f, 8.93503204e-02f, 4.00346331e-02f, 5.97425923e-02f, 1.48887476e-02f, -5.36822081e-02f, 2.02435758e-02f,
  2.98359506e-02f, -1.42129580e-03f, -5.95076941e-03f, -7.16223270e-02f, -2.23006867e-02f, -6.04046918e-02f, 3.04070972e-02f, -8.02240819e-02f, -9.30179376e-03f, -1.17850294e-02f,
  5.13726473e-02f, 3.32122482e-02f, -4.62097954e-03f, 3.23838368e-02f, 8.06475803e-02f, -2.28594430e-03f, 2.96021700e-02f, 3.95673253e-02f, 1.17489463e-02f, -1.48852617e-02f,
  7.38530681e-02f, 3.84022743e-02f, 3.12799998e-02f, 2.52377521e-03f, 1.51671451e-02f, -9.54690054e-02f, -3.01087778e-02f, -2.05848869e-02f, 2.23683845e-02f, -4.38750675e-03f,
  -4.66070548e-02f, -6.88127801e-02f, -1.59233646e-03f, -4.17257771e-02f, 1.96832628e-03f, -2.37710029e-02f, 7.40099372e-03f, -1.34852882e-02f, -2.19665486e-02f, -4.43161093e-02f,
  3.46099809e-02f, -6.52446076e-02f, 3.16575356e-02f, 1.17662521e-02f, 4.66785720e-03f, 3.10708452e-02f, 6.97176456e-02f, -1.28816552e-02f, -3.92682105e-03f, 4.46013035e-03f,
  5.34929857e-02f, 2.36843884e-01f, 1.92670561e-02f, 3.07402462e-02f, 2.15249751e-02f, 3.91135141e-02f, -9.05514136e-03f, 4.90326807e-03f, 5.61957695e-02f, -5.52276447e-02f,
  1.23380506e-02f, -3.61242145e-02f, -6.08702889e-03f, 2.39964034e-02f, -3.82197686e-02f, 2.31129769e-02f, 6.32485971e-02f, 4.26474363e-02f, 3.61485803e-03f, 2.06880718e-02f,
  4.26848978e-02f, 4.33058813e-02f, -2.29097512e-02f, 4.90581617e-02f, -7.65567366e-03f, -9.99067561e-04f, -8.61304533e-03f, 2.32605301e-02f, -1.96886566e-02f, 3.70491296e-02f,
  -2.02058434e-01f, 6.82421699e-02f, -7.18765557e-02f, 5.74820787e-02f, -8.78769159e-03f, -2.08754793e-01f, -4.03963402e-02f, -2.66219266e-02f, -1.61281437e-01f, 6.06709458e-02f,
  -1.94532312e-02f, -9.80801731e-02f, -5.84736839e-02f, -2.15946534e-03f, -3.46573800e-01f, -1.54334888e-01f, -8.57283827e-03f, 3.76910046e-02f, -9.05377883e-03f, 3.11227813e-02f,
  3.82166244e-02f, 4.61709276e-02f, 6.33685589e-02f, 1.77402735e-01f, 1.14173353e-01f, 1.37740359e-01f, 2.23291386e-02f, 6.73454255e-02f, 2.10053977e-02f, -9.21669900e-02f,
  -1.09580293e-01f, -2.38218326e-02f, 6.14758432e-02f, 4.96106874e-03f, -6.84353486e-02f, -5.93173057e-02f, -3.86525057e-02f, -1.81652140e-02f, -3.18726636e-02f, -6.23082742e-02f,
  -4.33200672e-02f, -1.63994804e-02f, -7.97717124e-02f, 1.06768794e-01f, -1.93588212e-02f, 7.85892084e-02f, 3.16543877e-02f, 1.49217425e-02f, -1.62147693e-02f, 3.40300538e-02f,
  -2.56312396e-02f, 2.36076619e-02f, -4.70688902e-02f, 2.29214989e-02f, 6.71028579e-03f, -4.69563383e-04f, 8.82812291e-02f, -9.88600496e-03f, 2.23000050e-02f, -6.40736520e-02f,
  6.81658611e-02f, -2.41571106e-02f, -1.00109866e-02f, -5.49843647e-02f, -1.02065885e-02f, -5.63208573e-03f, 4.55159768e-02f, -7.28404969e-02f, 1.66913979e-02f, 1.87047813e-02f,
  -8.17176420e-03f, -5.42304888e-02f, 1.06104603e-02f, 1.02044903e-01f, -1.78589597e-02f, -2.70569436e-02f, 5.52354679e-02f, 1.94496140e-02f, -7.55638210e-03f, 9.45091713e-04f,
  3.77796143e-02f, -7.77638629e-02f, 5.41006699e-02f, -1.06706787e-02f, 3.79039012e-02f, 1.55135803e-02f, 3.32393460e-02f, 3.02156880e-02f, -1.15867136e-02f, 1.59559008e-02f,
  -1.67024374e-01f, -3.40444855e-02f, -3.15407626e-02f, 4.66568395e-03f, -4.84874919e-02f, 6.67471439e-02f, 5.70545271e-02f, -3.45011689e-02f, -4.95752990e-02f, 2.23069526e-02f,
  6.92232475e-02f, 9.96235991e-04f, -1.26557304e-02f, -1.45143289e-02f, 4.79748249e-02f, -2.59308890e-02f, -4.13878337e-02f, -1.67792775e-02f, -1.23837013e-02f, -4.64285202e-02f,
  8.02149437e-03f, -6.12120107e-02f, 2.61307005e-02f, 1.13554792e-02f, 1.84093062e-02f, 6.38346225e-02f, -3.61101925e-02f, -4.17623222e-02f, -3.08451001e-02f, -4.59902920e-02f,
  2.40847856e-01f, -4.69740666e-02f, -1.96105393e-04f, 2.18604669e-01f, 4.56383340e-02f, -1.16335429e-01f, -1.35417670e-01f, 1.37184158e-01f, 1.96451157e-01f, 8.17243233e-02f,
  2.46052444e-02f, 4.23135683e-02f, -2.09817171e-01f, 7.27555454e-02f, -3.52471322e-01f, -3.29302341e-01f, -4.28312756e-02f, -2.88427602e-02f, -7.44858757e-02f, 1.47483170e-01f,
  1.25669008e-02f, -1.08123170e-02f, -1.93104163e-01f, 6.69047534e-02f, 3.43744010e-02f, 1.34689808e-01f, 6.85603768e-02f, -1.60411578e-02f, 5.62882125e-02f, -1.04436010e-01f,
  -2.40132236e-03f, 1.60796523e-01f, 2.59449091e-02f, -3.81964929e-02f, -4.09937054e-02f, -4.30798493e-02f, -4.02982421e-02f, -5.08452170e-02f, 7.86185935e-02f, -6.32671788e-02f,
  3.19126584e-02f, 4.60565239e-02f, 2.20376812e-02f, -3.10197473e-02f, 3.40538062e-02f, 2.88696326e-02f, -8.47003050e-03f, -2.41767615e-02f, 7.87676945e-02f, -2.26157121e-02f,
  -7.97422379e-02f, -5.05785830e-02f, 4.39596847e-02f, -5.98332332e-03f, 8.99918005e-03f, -1.02670789e-02f, -3.29087898e-02f, -2.20873160e-03f, -3.46767381e-02f, 4.56998460e-02f,
  -8.86743367e-02f, 3.97717878e-02f, -6.69057146e-02f, 1.34046618e-02f, -3.64574306e-02f, 2.98782904e-02f, -4.57787933e-03f, 4.08609770e-03f, 1.13870669e-03f, 8.46338086e-03f,
  -1.60459187e-02f, 9.09654275e-02f, -4.15636320e-03f, -3.03107202e-02f, -3.25086936e-02f, 4.80270237e-02f, -3.93248089e-02f, -5.39743863e-02f, -1.33158844e-02f, -1.65515263e-02f,
  -2.85297241e-02f, -7.24276295e-03f, -5.97345904e-02f, -4.63637225e-02f, -3.00636049e-02f, 8.81680229e-04f, -2.05117539e-02f, -5.64717390e-02f, -4.87775020e-02f, -8.57026130e-02f,
  -7.89199844e-02f, 6.60164952e-02f, 5.37958667e-02f, -7.60622881e-03f, 3.51965874e-02f, 4.77484688e-02f, 1.69912144e-03f, 5.20964935e-02f, -1.82325840e-02f, 3.74050178e-02f,
  -3.26758549e-02f, 3.13370153e-02f, 1.00745680e-02f, 2.55450178e-02f, 1.94913447e-02f, 1.20615847e-02f, -7.91902933e-03f, 6.83142617e-02f, 5.05275745e-03f, -1.25881191e-02f,
  2.94150747e-02f, -4.48171329e-03f, 4.01405208e-02f, 3.55889089e-02f, -1.25753116e-02f, 4.83045094e-02f, 4.87102754e-02f, 3.74509133e-02f, -6.47320449e-02f, 7.82389101e-03f,
  -2.68652260e-01f, -1.22340620e-01f, -4.71759513e-02f, -1.23621151e-02f, -8.33243504e-02f, -5.89624792e-02f, -1.67632520e-01f, 3.67855504e-02f, -1.50073439e-01f, -7.30096474e-02f,
  -7.75691569e-02f, 1.74565837e-02f, 5.51743209e-02f, 2.84027271e-02f, 2.88475186e-01f, 1.74135432e-01f, 4.34840806e-02f, 7.72367567e-02f, 2.24052817e-02f, 1.63145345e-02f,
  2.00103763e-02f, -1.27098872e-03f, 1.70566037e-01f, 9.66241807e-02f, -4.41768691e-02f, -3.28612253e-02f, 1.79665536e-01f, 3.00456013e-05f, 1.71418395e-03f, -4.36545797e-02f,
  -1.15899369e-01f, 7.74293095e-02f, -8.17055441e-03f, 5.99849261e-02f, 5.02678789e-02f, -7.72245377e-02f, -1.92333106e-02f, 3.73169705e-02f, -1.41734767e-04f, -3.13770100e-02f,
  2.21727323e-02f, -1.74515229e-02f, -5.09080254e-02f, 3.41410227e-02f, -7.20842034e-02f, 2.47686151e-02f, 8.43310207e-02f, -3.11556794e-02f, 4.27440926e-02f, 3.08255088e-02f,
  3.38424034e-02f, -3.67290489e-02f, 5.32790506e-03f, 6.82938248e-02f, 7.83694834e-02f, -1.76764969e-02f, 6.41262606e-02f, -1.00252870e-02f, 9.31039080e-02f, -1.57448538e-02f,
  4.20854054e-02f, 1.82054713e-02f, -1.70290433e-02f, 4.06663530e-02f, 1.02675073e-02f, 3.69782783e-02f, -2.21665949e-02f, -2.45442465e-02f, 4.06984240e-02f, 3.91507857e-02f,
  -4.32367846e-02f, -4.71444577e-02f, -4.37715240e-02f, -2.56211329e-02f, 4.57842834e-02f, -8.31176341e-03f, 4.72437814e-02f, 2.26929504e-02f, -9.43063665e-03f, -1.97242964e-02f,
  3.96547019e-02f, 3.40158343e-02f, 4.52113673e-02f, 1.06125055e-02f, 3.70689109e-02f, 3.62516232e-02f, 1.33637246e-02f, -7.46363262e-03f, 4.51553762e-02f, 3.30293439e-02f,
  1.16975494e-01f, 2.72136480e-01f, -4.83356677e-02f, -2.25315373e-02f, 2.08578706e-02f, 4.02043127e-02f, 4.50257249e-02f, -5.14780097e-02f, 6.69281408e-02f, 5.04684821e-02f,
  2.90243351e-03f, -1.26671847e-02f, 2.48737279e-02f, -5.40847071e-02f, 9.17065665e-02f, 3.06318770e-03f, -1.10090924e-02f, 7.42041022e-02f, 2.63341283e-03f, 5.23370951e-02f,
  3.73943672e-02f, 6.49075359e-02f, 4.07194644e-02f, 5.23089878e-02f, -9.77760274e-03f, 3.93946916e-02f, -1.92961302e-02f, 2.63186637e-02f, 6.36500344e-02f, 2.52472740e-02f,
  -7.42596984e-02f, 6.18454777e-02f, 1.04451468e-02f, -1.67154312e-01f, -9.73996520e-02f, 3.52429524e-02f, -2.70280596e-02f, 1.29386736e-02f, -1.74502917e-02f, -6.35146871e-02f,
  -9.23599377e-02f, 4.84286137e-02f, 1.22122891e-01f, -1.51876375e-01f, 2.16561273e-01f, 3.45408916e-02f, -1.65359350e-03f, -5.12529686e-02f, 5.59022999e-04f, -1.21087313e-01f,
  -7.15960115e-02f, -1.16356865e-01f, -3.08320727e-02f, -5.20768538e-02f, -6.32308498e-02f, -1.01852104e-01f, -6.69118762e-02f, 4.40925546e-02f, -5.68524487e-02f, 7.20110461e-02f,
  1.09751418e-01f, -3.42789590e-02f, -7.72612691e-02f, 1.70435477e-02f, 1.01536848e-02f, -8.27885941e-02f, 9.79904644e-03f, 5.28160781e-02f, 5.07567497e-03f, 6.15024827e-02f,
  -3.20581570e-02f, 1.50971180e-02f, 2.57138088e-02f, 5.06637096e-02f, 5.79463504e-02f, -6.01089234e-03f, -6.41564876e-02f, -7.93870986e-02f, -3.39706242e-02f, -5.08953221e-02f,
  -5.70963509e-02f, 1.38930660e-02f, 2.59047486e-02f, -4.63806540e-02f, -2.59169843e-02f, -5.68350405e-02f, 4.36174311e-02f, 9.65237319e-02f, 2.46379990e-02f, -3.52072231e-02f,
  3.22591118e-03f, 1.78181753e-02f, -2.23381948e-02f, -8.14069957e-02f, 2.69287806e-02f, -9.26194191e-02f, 4.21547890e-02f, -3.24178599e-02f, 1.72940660e-02f, -1.68264471e-02f,
  -5.58607168e-02f, -7.90665075e-02f, -8.94007366e-03f, 2.87185293e-02f, -1.73221417e-02f, -7.17430040e-02f, 2.31286883e-02f, -7.86090717e-02f, -1.09778401e-02f, -1.80816650e-02f,
  -4.67645675e-02f, 1.48100397e-02f, 8.52667447e-03f, -3.76444906e-02f, 8.85663088e-03f, -3.08636613e-02f, -5.20911906e-03f, 2.68238019e-02f, -2.98181232e-02f, -1.28763467e-02f,
  1.42088011e-01f, 8.67241398e-02f, -1.97947677e-02f, -8.59769806e-02f, 1.59377605e-02f, 2.76156403e-02f, 6.02204306e-03f, 2.20313184e-02f, 2.10940856e-02f, -4.00248617e-02f,
  6.03576712e-02f, 1.99568681e-02f, 4.80857352e-03f, -4.11874913e-02f, -2.82876007e-02f, -2.02333014e-02f, 2.16280416e-04f, 9.76152793e-02f, -5.87871559e-02f, 6.38884213e-03f,
  -1.93967409e-02f, -3.82539034e-02f, 5.40632522e-03f, 2.83458028e-02f, -2.86741909e-02f, -1.16603021e-02f, 1.68966204e-02f, 8.13025050e-03f, -3.34640220e-02f, 5.42246513e-02f,
  4.10001278e-01f, 1.42193362e-01f, 2.08010480e-01f, 2.72030801e-01f, -5.04645668e-02f, -2.35114321e-02f, -2.17684619e-02f, 1.81055114e-01f, 2.73351967e-01f, -1.30696977e-02f,
  -1.57121897e-01f, 1.33473560e-01f, -6.75919130e-02f, 1.57158077e-01f, 2.67928336e-02f, 2.17218548e-02f, 1.11001514e-01f, 6.71182992e-03f, 7.36363679e-02f, 1.58909619e-01f,
  5.58154844e-02f, -1.14610113e-01f, -5.65226004e-03f, -3.57713411e-03f, -5.47404774e-03f, 1.53854728e-01f, -7.13342875e-02f, -1.23517357e-01f, -3.62749435e-02f, -8.08102041e-02f,
  6.28378615e-02f, 2.42177561e-01f, 5.86668514e-02f, 8.27329978e-02f, 7.03356490e-02f, -2.98902262e-02f, 5.06603904e-02f, -9.28221047e-02f, 2.07505259e-03f, 3.36995684e-02f,
  1.24380747e-02f, 2.41636578e-02f, 6.54448867e-02f, 1.39561836e-02f, 3.70699167e-02f, 4.55172509e-02f, -5.10583445e-02f, 8.42185225e-03f, 2.79500578e-02f, -3.64116132e-02f,
  -3.84064130e-02f, -4.31582481e-02f, -6.20663650e-02f, -5.83915412e-03f, -4.78884466e-02f, 8.40394050e-02f, -2.82071438e-02f, -7.86420237e-03f, 1.78893760e-03f, -1.14222802e-02f,
  5.29082306e-02f, 3.19260731e-02f, 5.39075546e-02f, 8.28035362e-03f, -6.03444036e-03f, -3.19000520e-02f, -3.54740880e-02f, -3.93597819e-02f, -5.32620139e-02f, -4.82597714e-03f,
  -4.00762744e-02f, -6.06871163e-03f, 8.85179490e-02f, 1.55418888e-02f, -2.82037221e-02f, 2.09403541e-02f, -8.31296202e-03f, -2.17275247e-02f, -3.91602032e-02f, -3.43577862e-02f,
  -1.42892329e-02f, -3.77978124e-02f, 4.83492017e-02f, -1.25575587e-02f, 3.67996544e-02f, 2.07464173e-02f, 8.54921639e-02f, 2.33150404e-02f, 6.09168224e-02f, -4.48416211e-02f,
  1.38364896e-01f, 2.02950060e-01f, -3.59829739e-02f, 7.40066618e-02f, -8.29745233e-02f, 4.74982522e-03f, -1.40436487e-02f, -1.69678908e-02f, -2.95200804e-03f, -3.05220261e-02f,
  -3.71141806e-02f, 1.06373811e-02f, 8.79129954e-03f, -4.47261631e-02f, -2.24911198e-02f, -2.81467140e-02f, 5.24175726e-02f, 6.06198274e-02f, -6.08055964e-02f, -3.64064202e-02f,
  -4.06315848e-02f, 5.18266000e-02f, 1.14576495e-03f, 3.19101140e-02f, -6.54455721e-02f, -4.80094962e-02f, 5.94577529e-02f, -4.91073728e-03f, -3.92095521e-02f, -6.75374316e-03f,
  -6.21078573e-02f, 1.31848767e-01f, 4.68732528e-02f, -1.06643654e-01f, 5.77678205e-03f, -6.78068697e-02f, -1.33204743e-01f, 1.75641701e-01f, 1.65019736e-01f, -4.71818335e-02f,
  -1.35142013e-01f, -1.15065798e-01f, -6.17869757e-02f, -8.10756311e-02f, -2.33940154e-01f, 6.86204731e-02f, -1.95730329e-01f, -4.23146598e-02f, 1.09690279e-01f, -7.62507319e-02f,
  3.77758518e-02f, -2.21490130e-01f, -1.59665778e-01f, -4.67177592e-02f, -9.34265703e-02f, 1.68124720e-01f, -2.29094267e-01f, -7.15190358e-03f, -9.36729908e-02f, -1.35789543e-01f,
  -1.44626321e-02f, 9.04255882e-02f, -5.11475373e-03f, 5.19174486e-02f, 3.12057231e-02f, 2.61882097e-02f, -5.57761006e-02f, -5.10577001e-02f, 1.24399820e-02f, 1.66058410e-02f,
  4.54296134e-02f, 3.38412262e-02f, 4.34264317e-02f, 3.10895201e-02f, 1.46221370e-02f, 7.58102089e-02f, -3.71837541e-02f, -4.23164386e-03f, 9.85148847e-02f, -7.68754706e-02f,
  6.98338300e-02f, 5.79221062e-02f, -2.60313619e-02f, 4.57857922e-02f, 5.99688925e-02f, -1.74542554e-02f, 1.41211029e-04f, -4.05398048e-02f, 1.81088820e-02f, 1.91521347e-02f,
  7.17182178e-03f, -4.39455360e-02f, -7.70279467e-02f, -6.98252721e-03f, -2.79903170e-02f, 7.44184703e-02f, -3.70682403e-02f, -2.86747292e-02f, 8.59636290e-04f, -4.07113098e-02f,
  9.02297627e-03f, -4.39148024e-02f, -2.64271963e-02f, 3.81085947e-02f, 3.32141705e-02f, -2.05007512e-02f, -2.73257326e-02f, -1.91547312e-02f, -3.42496894e-02f, 6.41543418e-02f,
  4.16259468e-02f, 2.23010946e-02f, -6.13117218e-02f, 8.61249119e-02f, -7.64313200e-03f, 4.77381423e-02f, -3.15145589e-02f, 7.26443576e-03f, -3.21361385e-02f, 5.68411034e-03f,
  4.73167151e-02f, -1.33723572e-01f, -3.04156616e-02f, -8.09451789e-02f, 1.07007911e-02f, 3.79516073e-02f, -6.59920499e-02f, 2.90202349e-02f, 4.13748696e-02f, 8.50864314e-03f,
  -3.49956080e-02f, -5.62360659e-02f, -7.62460232e-02f, 1.99908838e-02f, -1.00252125e-02f, 2.13820441e-03f, -2.68079881e-02f, 2.87439320e-02f, -4.88114320e-02f, 4.75695878e-02f,
  -9.75844115e-02f, -1.01411581e-01f, -2.51625925e-02f, -3.17526124e-02f, 2.78154910e-02f, -3.01554520e-02f, 3.36792842e-02f, 7.61155337e-02f, -3.67370411e-03f, 1.45455515e-02f,
  2.25979790e-01f, -7.75248259e-02f, 1.08447336e-01f, 1.53360292e-01f, 1.32061988e-01f, -1.47840604e-01f, -1.62546322e-01f, 1.26389936e-01f, 3.41839753e-02f, -2.17423379e-01f,
  -4.63621430e-02f, 3.71794440e-02f, -8.35669935e-02f, -1.92571525e-02f, 1.78046644e-01f, -2.95411386e-02f, 1.11921549e-01f, 3.57105695e-02f, 1.16048314e-01f, 1.33270681e-01f,
  1.52850926e-01f, 1.13097265e-01f, 1.01743467e-01f, 5.82045354e-02f, 4.45322745e-04f, 8.16839002e-03f, 4.92368639e-02f, -1.34214433e-02f, -3.61937545e-02f, 2.21882109e-02f,
  -4.33767512e-02f, -6.62631616e-02f, -6.25579730e-02f, 4.71279062e-02f, -3.29771899e-02f, -2.30164267e-03f, 2.46687997e-02f, -1.40208891e-02f, 1.01642460e-01f, 8.66581686e-03f,
  -6.84505980e-03f, 7.03340909e-03f, 5.49730435e-02f, -4.93901074e-02f, 3.93165648e-02f, 5.70766367e-02f, 9.85196158e-02f, 4.71457727e-02f, 3.10276262e-02f, -3.42999818e-03f,
  4.03755810e-03f, 2.20322721e-02f, 5.03276698e-02f, -7.60788023e-02f, 6.61599264e-02f, -1.46519551e-02f, -1.12511897e-02f, 4.10709605e-02f, -1.77797151e-03f, 5.21361455e-03f,
  7.70687871e-03f, 7.32034561e-04f, 4.09263261e-02f, 1.91946272e-02f, 3.99178155e-02f, -2.43232958e-03f, 1.76859200e-02f, 1.14913862e-02f, 1.95952621e-03f, 1.44406976e-02f,
  2.31382940e-02f, 3.92425153e-03f, -4.36704718e-02f, 6.56271949e-02f, 5.31719625e-02f, -5.47579229e-02f, 7.21072266e-03f, 1.13314735e-02f, 6.39009029e-02f, 1.85156614e-02f,
  -9.08485614e-03f, -1.69388670e-02f, -3.83889377e-02f, -9.95966345e-02f, -2.67443843e-02f, -3.89341488e-02f, 1.91842001e-02f, -1.67637989e-02f, -8.09305683e-02f, -5.53782396e-02f,
  1.96051765e-02f, -1.23519287e-01f, 1.60334781e-02f, -1.48572568e-02f, -8.66962895e-02f, -1.34844808e-02f, 8.72581452e-03f, 2.78585088e-02f, -5.70622683e-02f, -1.82315882e-03f,
  4.76530306e-02f, 2.95521207e-02f, -6.63513988e-02f, 4.08406854e-02f, -3.41473185e-02f, 3.46212015e-02f, -6.72953501e-02f, -5.04856668e-02f, 3.61862630e-02f, 7.91302472e-02f,
  4.27423604e-02f, -5.10558933e-02f, -1.13348030e-01f, 4.12466452e-02f, -6.70758858e-02f, -3.69348563e-02f, 8.90889093e-02f, -4.62902756e-03f, -1.57716330e-02f, -7.21150041e-02f,
  2.40194663e-01f, -4.18267325e-02f, 1.67262003e-01f, 1.19499236e-01f, -4.17940021e-02f, 2.64081240e-01f, 1.44950360e-01f, 7.42054507e-02f, 5.87622672e-02f, -1.56362444e-01f,
  -1.24133736e-01f, -1.00762155e-02f, -8.02453756e-02f, 1.05572797e-01f, 1.40468374e-01f, -8.58268365e-02f, 9.22835320e-02f, 1.27830237e-01f, 1.71539783e-02f, 8.05270299e-02f,
  1.26837865e-01f, -6.29259795e-02f, 7.67626613e-02f, -1.00050621e-01f, 1.28440589e-01f, -5.35720289e-02f, -6.40061796e-02f, -5.81616312e-02f, 2.79419366e-02f, 7.76933460e-03f,
  3.98094729e-02f, -8.34302381e-02f, 6.21273071e-02f, 8.95267874e-02f, 1.33325994e-01f, -3.28813270e-02f, 1.90325920e-02f, -8.49258825e-02f, 1.69466957e-02f, 9.85586667e-04f,
  3.86746377e-02f, 1.61595866e-02f, 1.88783966e-02f, 1.17042335e-02f, 3.16749848e-02f, -1.05283735e-02f, -2.47593336e-02f, 1.55877443e-02f, -2.46792417e-02f, 6.70760050e-02f,
  7.18278959e-02f, 9.21714772e-03f, 1.20633647e-01f, -2.01979578e-02f, 4.54650037e-02f, 1.25539745e-03f, -4.14932705e-02f, 6.21188991e-02f, -9.31133237e-03f, -1.02144880e-02f,
  1.71305351e-02f, 3.32849026e-02f, 4.93382476e-02f, 3.81344445e-02f, -3.12325004e-02f, 1.29676135e-02f, -2.51971576e-02f, -3.26870941e-02f, 3.18673290e-02f, -3.77339832e-02f,
  1.96922645e-02f, 4.50372621e-02f, 2.83241253e-02f, 1.00584496e-02f, -3.93047649e-03f, 7.07764104e-02f, 3.93695273e-02f, 4.59600426e-02f, 3.42318304e-02f, 3.61717008e-02f,
  3.41847073e-03f, -1.75578825e-04f, -2.37177238e-02f, -4.22257707e-02f, 7.65643716e-02f, -1.46489218e-03f, 4.18301187e-02f, -4.52661663e-02f, 4.37064953e-02f, 5.31732067e-02f,
  -3.41859944e-02f, -3.06019392e-02f, -8.83207843e-02f, -1.00133508e-01f, -1.54418899e-02f, 4.60511148e-02f, 3.28034982e-02f, 5.52428067e-02f, 1.06017031e-02f, 3.97619568e-02f,
  7.59653375e-02f, 6.85612336e-02f, -5.62778525e-02f, -1.77345704e-02f, -3.44724692e-02f, 3.76411974e-02f, -2.84342351e-03f, -7.19181597e-02f, 3.58688347e-02f, -1.40495608e-02f,
  -4.92851809e-02f, 1.50762014e-02f, -5.00728842e-03f, 6.27942532e-02f, 2.25222651e-02f, 5.29999435e-02f, 2.86866557e-02f, 1.31056448e-02f, 2.37182342e-02f, 4.33535241e-02f,
  -1.63517714e-01f, 2.68015772e-01f, -2.80892234e-02f, -1.38920005e-02f, -1.02122970e-01f, 6.55010119e-02f, 1.10675104e-01f, 4.44613062e-02f, 1.06673032e-01f, 2.30331406e-01f,
  8.29529297e-03f, 6.45204186e-02f, 1.46355525e-01f, 2.92141885e-01f, -6.95362613e-02f, 1.87275559e-01f, 1.37527391e-01f, 1.41651928e-01f, -2.50776540e-02f, -3.97733413e-02f,
  -4.05652225e-02f, 9.82142463e-02f, 6.66107237e-02f, 1.80195812e-02f, -1.79505181e-02f, -6.09298646e-02f, -9.82650295e-02f, -2.49145683e-02f, 6.18494861e-02f, -5.88870142e-03f,
  6.58671781e-02f, -8.35873559e-02f, -5.34601435e-02f, -6.18024310e-03f, -3.20217945e-02f, -6.78513423e-02f, -9.60176513e-02f, -9.76071209e-02f, -7.95617874e-04f, -2.23574266e-02f,
  2.09882762e-03f, 3.54810804e-02f, 8.31833184e-02f, 1.57822911e-02f, -1.23452786e-02f, -6.51531070e-02f, 9.65837240e-02f, -2.11104304e-02f, 3.98630742e-03f, -1.97572485e-02f,
  1.05029032e-01f, -2.48571020e-02f, -2.10012868e-02f, 1.15375906e-01f, -2.68004853e-02f, -1.00764912e-03f, 9.98876542e-02f, -4.99981381e-02f, -5.97894900e-02f, -3.93909663e-02f,
  -2.19879318e-02f, 2.07845997e-02f, -3.40495035e-02f, 4.48152572e-02f, -3.46833318e-02f, 3.77883427e-02f, 2.93885674e-02f, 2.57087648e-02f, -1.47266705e-02f, -1.44525315e-03f,
  -4.39818949e-02f, 6.85734153e-02f, 2.85708271e-02f, -8.52595270e-03f, -1.69902314e-02f, 1.72085427e-02f, -5.42925531e-03f, 4.70058201e-03f, 8.86926521e-03f, 4.38481309e-02f,
  -1.00333532e-02f, 3.12376320e-02f, 9.04055536e-02f, -1.52259767e-02f, -3.11250798e-02f, -2.41841991e-02f, 1.96578465e-02f, -1.25026042e-02f, -1.72500182e-02f, -6.14905357e-02f,
  4.60851453e-02f, -5.53264236e-03f, -4.01948802e-02f, -4.81792502e-02f, -2.78114602e-02f, -4.84929271e-02f, -2.79729236e-02f, 6.61712289e-02f, -4.55129556e-02f, -5.06338663e-02f,
  -7.89557099e-02f, -7.20922351e-02f, -2.63765622e-02f, -5.72945215e-02f, -5.86881079e-02f, 4.04969379e-02f, -6.36289120e-02f, -4.92912084e-02f, -1.23215960e-02f, 6.56565884e-03f,
  -7.56450444e-02f, -3.87465395e-02f, 6.33706078e-02f, -2.23579202e-02f, -3.12707238e-02f, -1.59683228e-02f, -1.01255029e-01f, -2.66814660e-02f, 4.52065207e-02f, 4.91129421e-02f,
  1.25762951e-02f, 3.48756552e-01f, -7.45440274e-02f, 6.09610192e-02f, 6.84805810e-02f, 1.24075180e-02f, 1.73816923e-02f, 1.15051612e-01f, 2.68445872e-02f, 1.58767983e-01f,
  8.58658031e-02f, -1.53968548e-02f, 2.36883666e-02f, 7.01440275e-02f, -1.98862821e-01f, -7.30780512e-02f, 1.29380181e-01f, -1.76416785e-02f, 2.90700383e-02f, 1.53130591e-01f,
  3.00401356e-02f, 1.31839290e-01f, -1.19686574e-01f, 1.79971740e-01f, 1.24288924e-01f, 7.23619834e-02f, 3.81277762e-02f, -7.38590062e-02f, -4.88980208e-04f, -8.82286876e-02f,
  3.81632186e-02f, 1.77246612e-02f, -2.91737393e-02f, -1.30896494e-01f, 5.78368753e-02f, 3.86399701e-02f, -4.22388278e-02f, -3.58866788e-02f, 3.93201225e-03f, 1.31536229e-02f,
  3.52395847e-02f, -4.68578041e-02f, -2.61048730e-02f, -2.44860873e-02f, 7.74718374e-02f, -6.49831863e-03f, -8.12346209e-03f, -1.30597278e-02f, 2.91434452e-02f, -4.35282253e-02f,
  -5.83470836e-02f, 8.23105276e-02f, 3.46056856e-02f, -1.08332895e-02f, 5.92083205e-03f, 6.91942424e-02f, -1.07686967e-02f, -1.07915878e-01f, 6.45556077e-02f, -1.82063244e-02f,
  -7.01594108e-04f, 1.65093727e-02f, 8.00444037e-02f, -1.86290592e-02f, 6.42363057e-02f, 3.64567302e-02f, 7.97259584e-02f, 1.97778232e-02f, -5.54254539e-02f, 2.73621492e-02f,
  3.98643091e-02f, -2.05922294e-02f, -2.72227749e-02f, 1.32900588e-02f, -5.07668545e-03f, 2.35582553e-02f, 5.05706072e-02f, -1.13218687e-02f, 6.52520508e-02f, -1.71446335e-02f,
  1.61329750e-02f, 2.15370078e-02f, 1.39087168e-02f, 7.29301060e-03f, -3.24525386e-02f, -6.48204312e-02f, 3.42319608e-02f, -1.33843478e-02f, 3.56708616e-02f, -4.35845330e-02f,
  1.69596560e-02f, 9.84633565e-02f, 4.33880575e-02f, 5.51411361e-02f, 3.24796848e-02f, 6.14341684e-02f, -6.81875087e-03f, 1.65266786e-02f, 5.17148990e-03f, 4.09421958e-02f,
  9.30068141e-04f, -3.04657687e-02f, 6.42846227e-02f, 7.17369746e-03f, 4.00828989e-03f, -8.12470540e-03f, -8.82264599e-03f, -6.32022927e-03f, -4.53860871e-03f, -2.06402931e-02f,
  5.39897084e-02f, -2.37120073e-02f, 5.44812456e-02f, 5.85121214e-02f, 6.19558096e-02f, -1.76635012e-02f, 7.74376839e-02f, 4.79067005e-02f, 3.90651822e-02f, -2.68022772e-02f,
  4.74236496e-02f, 1.47850454e-01f, -1.13064826e-01f, 1.15420915e-01f, 2.95063164e-02f, 3.13543454e-02f, -2.21740715e-02f, 7.19595002e-03f, 1.53042749e-01f, 6.68262243e-02f,
  -5.62473498e-02f, 7.12609068e-02f, -5.55040240e-02f, 9.72333103e-02f, -7.85838142e-02f, -5.46040833e-02f, 1.40409824e-02f, 6.03291057e-02f, 5.87822609e-02f, -5.71350977e-02f,
  -1.95169244e-02f, 5.87135963e-02f, 9.81388241e-03f, 4.36556377e-02f, -6.73263744e-02f, -3.78569476e-02f, -4.41217050e-03f, -4.80546169e-02f, -2.56606601e-02f, -1.39825363e-02f,
  -2.64547598e-02f, -7.28678778e-02f, 6.71178401e-02f, -7.10279867e-02f, 1.08297430e-02f, -5.51619604e-02f, 1.26933912e-02f, -7.48015046e-02f, -2.21347529e-02f, 4.94344495e-02f,
  -4.38586138e-02f, 2.68122094e-04f, -3.87345403e-02f, 5.55661358e-02f, -4.75115217e-02f, -3.76131497e-02f, 6.61825016e-02f, -1.96761489e-02f, 4.59569916e-02f, -1.82062183e-02f,
  -8.70416015e-02f, -8.81504714e-02f, 2.27115247e-02f, -3.33548300e-02f, 4.45605144e-02f, -3.22642140e-02f, 7.07406700e-02f, -5.23548238e-02f, 5.92551120e-02f, -4.12360057e-02f,
  -2.05677580e-02f, -2.53126230e-02f, -2.87145171e-02f, 7.01202303e-02f, 1.08856522e-02f, -2.82756984e-02f, 7.79343918e-02f, 1.19775059e-02f, 6.73034564e-02f, -4.16532196e-02f,
  -4.09305617e-02f, 2.32347883e-02f, 1.34516535e-02f, -6.10868894e-02f, -5.40361330e-02f, 6.50844276e-02f, 7.09312269e-03f, -1.04446039e-02f, 1.98347215e-02f, 7.01601058e-02f,
  -7.53995106e-02f, -5.74556999e-02f, -2.63671149e-02f, 4.06662337e-02f, 1.72579866e-02f, 4.25661309e-03f, -2.13833191e-02f, -3.30077857e-02f, -5.91056161e-02f, 2.67225634e-02f,
  2.45840428e-03f, 6.76650777e-02f, 6.52566254e-02f, 6.40897527e-02f, -5.02334051e-02f, -9.53253731e-03f, 5.18952496e-02f, -4.19620611e-03f, -2.67503923e-03f, 6.99624419e-02f,
  7.31891766e-02f, 9.36090201e-02f, 1.62260607e-02f, -6.57847449e-02f, -2.72022467e-02f, -1.22195212e-02f, 1.79298855e-02f, -1.31718414e-02f, -3.65596302e-02f, 1.64985936e-02f,
  2.95220017e-02f, 5.79639077e-02f, 4.50014044e-03f, -4.18233648e-02f, -5.95413521e-03f, 5.63201904e-02f, -6.21264428e-02f, -4.88940664e-02f, -1.30528091e-02f, -2.25574076e-02f,
  1.23520993e-01f, -1.22565761e-01f, -1.72006879e-02f, 1.28889933e-01f, 7.81264389e-04f, 2.87449926e-01f, 2.41421565e-01f, -6.05144762e-02f, 9.45723504e-02f, 2.97218142e-03f,
  9.57203805e-02f, -1.84914216e-01f, -2.45559804e-05f, 2.78921217e-01f, 2.22525522e-01f, 2.99935527e-02f, 2.69937962e-01f, 8.96728262e-02f, 5.77662811e-02f, -2.61042221e-03f,
  2.06882711e-02f, 1.23308383e-01f, 3.60580571e-02f, 9.24385246e-03f, 6.47709891e-02f, -1.21745728e-01f, -1.23768508e-01f, -7.47446939e-02f, -4.03747335e-02f, -4.03589606e-02f,
  1.89674392e-01f, -4.12987880e-02f, -7.56398588e-02f, 4.55995835e-03f, 3.28399800e-02f, 5.65108769e-02f, 2.09193435e-02f, -6.53939554e-03f, -6.18478730e-02f, -1.69075429e-02f,
  1.19117936e-02f, -5.04208170e-02f, 1.74849164e-02f, 1.06050763e-02f, 1.09005319e-02f, 2.40078811e-02f, 6.09555207e-02f, -2.03809291e-02f, -5.09470664e-02f, -3.48365935e-03f,
  -6.24430249e-04f, 4.45886864e-04f, 5.69833368e-02f, -6.40112832e-02f, 5.18198051e-02f, 5.27224168e-02f, 5.05642369e-02f, -3.05686090e-02f, -5.00740595e-02f, -1.76925063e-02f,
  -2.57210881e-02f, -5.05391955e-02f, -3.76529507e-02f, 3.43256220e-02f, 7.32641742e-02f, -4.01137620e-02f, 4.20586504e-02f, -9.83039965e-04f, -8.40524794e-04f, 4.67662588e-02f,
  5.47795650e-03f, -4.10959646e-02f, 3.31486203e-02f, 3.01982239e-02f, 1.21575007e-02f, -2.98388675e-02f, -6.68689236e-02f, -3.41366902e-02f, 4.21301685e-02f, -1.32600395e-02f,
  2.42729690e-02f, 4.49206622e-04f, -4.32266034e-02f, 3.06100715e-02f, 2.40884442e-02f, 7.17557818e-02f, -3.74874403e-03f, -4.78856936e-02f, -5.96463457e-02f, -4.04255725e-02f,
  -6.28867373e-02f, -1.46620646e-01f, -5.02012856e-02f, 2.18582992e-02f, -5.78395426e-02f, 1.31396586e-02f, 2.85042124e-03f, -1.78193245e-02f, 8.57552513e-04f, -2.44265031e-02f,
  1.39905997e-02f, 3.30856931e-03f, -3.84913310e-02f, -6.24998063e-02f, -2.78750435e-02f, -6.26500174e-02f, -4.69228113e-03f, -2.57112123e-02f, -5.23877405e-02f, -6.32112548e-02f,
  -5.16127422e-02f, 4.85790186e-02f, -1.09285470e-02f, 1.12788640e-02f, 2.11992823e-02f, -4.14555818e-02f, -3.73499170e-02f, -1.98783092e-02f, -5.45283966e-02f, 4.80361730e-02f
};

// L0_fan_Wp_bar (Shape: 26 x 120)
const int L0_fan_Wp_bar_rows = 26;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  1.28152013e-01f, -2.36850411e-01f, -2.07542837e-01f, -7.52076332e-04f, 1.75608173e-01f, 7.78058022e-02f, -8.80635977e-02f, 2.35123783e-02f, -4.41084690e-02f, 6.73821996e-05f,
  7.64714926e-02f, -7.72842690e-02f, -1.58130541e-01f, -3.77824977e-02f, -3.79841104e-02f, -2.62848675e-01f, 1.17247969e-01f, 4.34004366e-02f, -1.26663983e-01f, 8.08973797e-03f,
  3.64777595e-02f, 7.11708665e-02f, -6.17518239e-02f, 2.12549284e-01f, -3.04342583e-02f, 1.44841298e-01f, 1.16114542e-01f, 1.96776744e-02f, 2.70099998e-01f, 7.40784928e-02f,
  8.63057077e-02f, -1.69679090e-01f, -3.81547362e-02f, 6.32685376e-03f, 8.67884904e-02f, 7.14390799e-02f, 4.53757942e-02f, 3.90420705e-02f, 3.90768833e-02f, -3.28369141e-02f,
  -1.50584755e-02f, 5.40156476e-03f, -3.16765793e-02f, -2.15246435e-02f, 2.60763150e-02f, -1.44151971e-02f, -4.89889234e-02f, -2.54760087e-02f, -7.18805790e-02f, -2.83614621e-02f,
  1.07571634e-03f, 9.00956988e-03f, -7.93002844e-02f, -5.92450425e-02f, -3.46819535e-02f, -6.24389481e-03f, 7.79700279e-02f, -5.97695261e-02f, -8.64402950e-03f, 7.55819827e-02f,
  1.33227140e-01f, -4.02374081e-02f, -2.80029252e-02f, -4.55316156e-02f, -6.69852570e-02f, 3.65279876e-02f, 2.32630670e-02f, -4.08519395e-02f, -9.28137675e-02f, 4.74275947e-02f,
  4.70216796e-02f, -3.49408239e-02f, 6.78105578e-02f, 1.89100467e-02f, -1.60253234e-02f, -8.37909356e-02f, 6.66065887e-02f, -2.83715446e-02f, -3.43995355e-02f, -3.71288545e-02f,
  -4.25357595e-02f, 8.11427832e-02f, 9.58591998e-02f, 4.30443324e-02f, -4.96827364e-02f, 7.51349106e-02f, -1.01030534e-02f, 3.45035866e-02f, -7.18739524e-04f, 5.83386570e-02f,
  4.33674380e-02f, 1.98038872e-02f, -5.66332461e-03f, -5.10673411e-02f, -4.31716442e-02f, 1.83493420e-02f, -6.81997314e-02f, 7.54478648e-02f, 4.07314822e-02f, 1.10405758e-01f,
  7.59341270e-02f, 4.96272519e-02f, 6.76495507e-02f, 6.73664659e-02f, 2.87401304e-02f, 1.27689112e-02f, -5.40364385e-02f, 8.46816376e-02f, 8.23859945e-02f, -5.09195812e-02f,
  -2.25404557e-02f, 8.07893425e-02f, -1.96954738e-02f, 4.14184332e-02f, -1.32046733e-02f, 8.12944099e-02f, 3.30721922e-02f, 1.25372514e-01f, -9.44745913e-02f, -4.34497595e-02f,
  -7.51328468e-02f, 2.63235122e-01f, -1.69860110e-01f, 6.18512183e-03f, -8.57231840e-02f, 1.71366572e-01f, 1.86072096e-01f, 1.43835768e-01f, 2.01702729e-01f, 3.13224256e-01f,
  1.48024410e-01f, 3.84134501e-02f, 6.27511814e-02f, 1.32825479e-01f, 4.31104600e-02f, 2.43004486e-01f, 2.07668602e-01f, 1.62584558e-01f, 4.78337333e-02f, 3.19631137e-02f,
  -9.31928214e-03f, 1.43644437e-01f, -4.90777893e-03f, 1.23255681e-02f, -9.98506397e-02f, -1.01850599e-01f, -7.44283944e-02f, -1.13871403e-01f, 1.56297870e-02f, 3.29967812e-02f,
  -2.88975649e-02f, -3.84174399e-02f, -9.18234661e-02f, 4.28124256e-02f, -2.17865445e-02f, -7.46269524e-02f, -1.01076663e-02f, 2.84331739e-02f, 3.69389146e-03f, 1.98383670e-04f,
  -4.07448113e-02f, -4.25283425e-02f, 7.22086877e-02f, 4.38718311e-02f, -2.33039130e-02f, -1.66213997e-02f, 2.98588872e-02f, -3.50623354e-02f, 4.89425920e-02f, -1.98274869e-02f,
  6.28227144e-02f, 9.94222425e-03f, -7.58856954e-03f, -1.55202756e-02f, -7.32554123e-02f, -2.24119872e-02f, 8.85942876e-02f, -3.61356847e-02f, 3.31406929e-02f, 1.13392279e-01f,
  4.50349133e-03f, 5.91739081e-03f, 5.75063343e-04f, -7.22871795e-02f, -1.12498016e-03f, -4.64554168e-02f, 6.64554117e-03f, 3.32313664e-02f, -1.71633641e-04f, -1.02401944e-02f,
  -6.33190200e-02f, 1.83654502e-02f, 5.18342154e-03f, 8.53716210e-02f, 4.62182419e-04f, 1.42981894e-02f, 4.01634090e-02f, -2.60574780e-02f, -2.43136473e-02f, -3.66951600e-02f,
  6.51963055e-02f, 3.91389504e-02f, -2.41147727e-03f, 3.52960341e-02f, 5.29378951e-02f, 1.26891546e-02f, 1.00601185e-02f, 2.62450967e-02f, -2.69548688e-02f, 4.06678915e-02f,
  1.66030258e-01f, 1.87418655e-01f, 6.01990260e-02f, -1.36881676e-02f, 7.54379779e-02f, -4.86998707e-02f, -1.06982868e-02f, -3.30561474e-02f, 6.09186590e-02f, -1.79923698e-02f,
  -1.41801303e-02f, -2.50174175e-03f, -2.82932762e-02f, -2.20229067e-02f, -4.55587683e-03f, 4.58245426e-02f, 2.99682822e-02f, 8.67837742e-02f, 6.58498630e-02f, -7.18294270e-03f,
  -2.32173167e-02f, 8.45104177e-03f, -3.12503614e-02f, -4.76835817e-02f, -3.02850213e-02f, 1.25141190e-02f, 2.93218978e-02f, 2.86561623e-02f, -5.68676181e-02f, -5.36932945e-02f,
  1.62608787e-01f, -1.74884070e-02f, -1.44222915e-01f, 8.36211722e-03f, 6.75091296e-02f, -2.80996095e-02f, 5.04583344e-02f, -5.51006943e-02f, -1.44483805e-01f, 3.04520447e-02f,
  2.32890099e-02f, -9.60986689e-02f, 2.22064108e-02f, 1.31410971e-01f, 8.76403749e-02f, -6.86304569e-02f, 1.37518898e-01f, 1.19868647e-02f, -2.06368361e-02f, 7.68695921e-02f,
  4.31024097e-02f, 5.05130850e-02f, -4.89548184e-02f, 4.92360592e-02f, 4.67871130e-02f, -7.48975128e-02f, 7.10347071e-02f, -7.19955638e-02f, 1.14201069e-01f, 2.13170145e-02f,
  2.05724519e-02f, 5.39791957e-02f, -2.71643531e-02f, -3.60767469e-02f, 3.72616127e-02f, 1.18604876e-01f, 9.25163329e-02f, 6.65098354e-02f, 1.74014177e-02f, -6.40798733e-02f,
  6.45066127e-02f, -5.49348742e-02f, -7.54353628e-02f, 8.70411918e-02f, 5.85846091e-03f, -5.27947359e-02f, -5.95619120e-02f, -2.89880801e-02f, 3.72678190e-02f, -4.95992713e-02f,
  -3.58105190e-02f, -7.25018531e-02f, 1.39674032e-02f, 3.88672464e-02f, 5.74685261e-02f, -1.06985755e-01f, -8.33269507e-02f, -5.72555959e-02f, -4.90144975e-02f, -4.99750450e-02f,
  4.74739708e-02f, 7.39868134e-02f, -9.73403268e-03f, 5.54753281e-03f, -5.20399064e-02f, 8.21159780e-02f, -3.52765471e-02f, -4.24161963e-02f, 2.97193564e-02f, -4.10440974e-02f,
  -7.59748593e-02f, 3.70019972e-02f, -4.18667682e-02f, -5.09670526e-02f, -1.03504788e-02f, -1.21228937e-02f, -2.99644209e-02f, -2.77008507e-02f, 5.28756008e-02f, 1.77151710e-02f,
  3.01214308e-02f, 1.00130802e-02f, -5.79897948e-02f, 5.36196008e-02f, -1.59775149e-02f, 2.76803062e-03f, 6.59605116e-02f, -2.62723733e-02f, 3.45022976e-02f, 2.55254637e-02f,
  -8.89991131e-03f, 7.21440166e-02f, -7.73225650e-02f, 2.43629720e-02f, 4.98974286e-02f, 3.54449600e-02f, 3.66923143e-03f, -1.06684547e-02f, -5.19551001e-02f, -2.79833432e-02f,
  6.85170591e-02f, -9.29025635e-02f, 3.33998054e-02f, 4.79993857e-02f, -9.16325599e-02f, 7.26712346e-02f, 2.81296745e-02f, 5.25973849e-02f, -1.54118305e-02f, 2.06051692e-02f,
  -5.95145226e-02f, -1.05613776e-01f, -2.47858278e-02f, 2.48197988e-02f, 1.79241924e-05f, 5.29242493e-03f, -5.06475270e-02f, -2.44514961e-02f, 5.95909916e-02f, 1.04453100e-03f,
  -4.12918180e-02f, 1.68230549e-01f, -9.62392986e-03f, 5.42444214e-02f, -1.32190213e-01f, 5.92628643e-02f, -9.46189761e-02f, 5.87106086e-02f, 9.09177884e-02f, -1.73204672e-02f,
  -1.31473690e-01f, 8.61959308e-02f, -2.65117325e-02f, -5.30775823e-03f, -9.87413749e-02f, 4.13313434e-02f, -1.24294572e-01f, 2.20814459e-02f, 1.24713527e-02f, -1.29552158e-02f,
  -3.67019475e-02f, -5.74772432e-02f, -8.83221105e-02f, 5.22046164e-03f, -7.48076290e-02f, -4.99768108e-02f, -9.56815705e-02f, -1.13965953e-02f, -7.11639225e-02f, -3.43883783e-02f,
  3.42553854e-02f, 1.87298860e-02f, -7.42981955e-02f, -5.35515398e-02f, -4.97806333e-02f, 1.44548377e-03f, -7.10209310e-02f, 1.01487808e-01f, 7.06250221e-02f, -6.85579777e-02f,
  3.66078019e-02f, -3.46345529e-02f, -5.21669947e-02f, 5.12440540e-02f, -3.63716781e-02f, 4.46951240e-02f, -5.90982176e-02f, -3.39153074e-02f, 8.99626017e-02f, 1.44459568e-02f,
  -1.94410123e-02f, 1.73274651e-02f, -3.18522565e-02f, 6.73291832e-02f, -4.63165017e-03f, 3.22471224e-02f, -1.06074668e-01f, 5.23761325e-02f, 1.66048650e-02f, 8.58923569e-02f,
  -6.97122514e-02f, -8.32594782e-02f, -6.95592836e-02f, -3.24329771e-02f, 1.09609691e-02f, 5.36577478e-02f, -4.21847217e-02f, 1.30126234e-02f, 2.82109492e-02f, -4.21776325e-02f,
  -3.33104469e-02f, -7.30719194e-02f, -6.94655105e-02f, -4.98296916e-02f, 8.62873420e-02f, 7.06210732e-02f, 8.58543664e-02f, -7.26271495e-02f, 3.92149799e-02f, -2.37818807e-02f,
  -4.71176067e-03f, 2.30566245e-02f, -6.68242574e-02f, 2.06157309e-03f, -3.47240595e-03f, 2.41595712e-02f, -9.77795497e-02f, 2.32361630e-03f, 2.94869337e-02f, 5.19910008e-02f,
  -3.68929356e-02f, -2.10862048e-03f, 1.01259999e-01f, 3.59206460e-02f, 3.46229970e-02f, -2.75391994e-05f, -2.30759922e-02f, -4.01221439e-02f, 4.11895700e-02f, 1.89518388e-02f,
  2.09174920e-02f, -1.22796837e-02f, -1.37746399e-02f, 4.84718718e-02f, 7.06936941e-02f, 4.78953160e-02f, 6.67243153e-02f, -9.36627835e-02f, -3.58938845e-03f, 4.31869878e-03f,
  -6.31503239e-02f, -2.48670094e-02f, 9.37075764e-02f, -5.82577996e-02f, -7.56771713e-02f, -2.04581991e-02f, 4.04052325e-02f, 9.10640359e-02f, -3.33496332e-02f, 3.69837135e-02f,
  -1.18083775e-01f, -8.91477913e-02f, -7.53100216e-02f, -5.77561036e-02f, -4.64234129e-02f, -9.82405767e-02f, -3.03080212e-02f, 8.86521563e-02f, 4.69944701e-02f, -4.05423902e-02f,
  -4.20333445e-02f, -1.31260157e-01f, 2.18333639e-02f, 3.66973989e-02f, 5.46679534e-02f, -8.25428516e-02f, -2.04403605e-02f, -4.69900332e-02f, -8.93412232e-02f, 3.72781530e-02f,
  4.09008451e-02f, -4.20733802e-02f, -9.49393883e-02f, -2.67033968e-02f, -5.47600389e-02f, 4.63744439e-02f, 7.25155184e-03f, -6.85609952e-02f, -3.05454675e-02f, -1.01087607e-01f,
  5.77702373e-02f, -4.81413975e-02f, 6.66363612e-02f, -3.10201794e-02f, -2.96283769e-03f, 5.05158864e-02f, -6.61291331e-02f, -1.38709764e-03f, -1.98819581e-02f, -6.08738214e-02f,
  4.86780219e-02f, -5.69113679e-02f, 8.42035487e-02f, 7.15266019e-02f, -4.52321395e-02f, 2.53499318e-02f, 4.40777317e-02f, 5.61856888e-02f, 3.47635499e-03f, -5.81880063e-02f,
  -7.91926458e-02f, 6.55389950e-02f, 7.97360539e-02f, 1.80133432e-02f, 2.07454767e-02f, 8.28118250e-02f, -8.21642652e-02f, 1.43976938e-02f, 9.87083912e-02f, 4.80880886e-02f,
  -7.11721368e-03f, 1.04823872e-01f, -7.42484480e-02f, -7.37990215e-02f, -1.64511558e-02f, 3.18603660e-03f, 9.69332978e-02f, -8.03753510e-02f, 1.26475235e-03f, -6.26484007e-02f,
  2.09810752e-02f, 5.15015349e-02f, -2.59118602e-02f, -1.02812257e-02f, -3.87541726e-02f, 1.38029894e-02f, -3.46124209e-02f, -9.05769877e-03f, 7.34771788e-02f, -5.02927741e-03f,
  7.52310455e-02f, -7.62566701e-02f, 1.40906367e-02f, 1.10671073e-01f, -5.83343790e-04f, -5.85435443e-02f, 3.34853336e-04f, -7.37844557e-02f, -2.92233797e-03f, -1.07324179e-02f,
  7.98394978e-02f, -2.40090839e-03f, -5.26136570e-02f, -7.97310993e-02f, 1.73633639e-02f, 2.51666270e-02f, 6.03397340e-02f, 5.05768955e-02f, -7.59039968e-02f, 2.24566907e-02f,
  -6.08735494e-02f, -4.49656174e-02f, 3.75288352e-02f, -2.61660796e-02f, 9.61513743e-02f, 6.30042329e-02f, -6.74068779e-02f, -1.41916890e-02f, 3.24649811e-02f, 9.02484655e-02f,
  -1.52821038e-02f, -1.37723563e-02f, -6.63700849e-02f, 1.53460307e-02f, -2.51336060e-02f, 3.32849994e-02f, 3.00095472e-02f, 3.42880674e-02f, -3.38428654e-02f, -2.47881208e-02f,
  2.38773048e-01f, -2.59828493e-02f, 2.72146650e-02f, 2.55455941e-01f, 3.14439051e-02f, -1.46491438e-01f, -1.86541274e-01f, 2.38391325e-01f, 8.99306014e-02f, -1.61040977e-01f,
  9.89851207e-02f, -1.89596415e-02f, -2.52635598e-01f, 2.11215824e-01f, 1.38829216e-01f, -5.83933629e-02f, 2.07969949e-01f, 5.29213659e-02f, -2.40439661e-02f, 1.34917080e-01f,
  7.43824318e-02f, 1.96436107e-01f, 5.20811938e-02f, 1.58201948e-01f, 1.04690768e-01f, 1.60806060e-01f, 6.99066073e-02f, -1.80477113e-01f, 1.75109804e-01f, -5.30762747e-02f,
  -1.43323606e-02f, 8.81905481e-02f, -5.40937530e-03f, 9.96575225e-03f, 3.62473950e-02f, -2.53418833e-02f, 8.69950466e-03f, 5.16499244e-02f, -5.11209890e-02f, 2.02042907e-02f,
  -8.73502716e-02f, -3.22340429e-02f, 1.16026528e-01f, 7.98396692e-02f, 5.58701418e-02f, 7.31905326e-02f, 6.49353787e-02f, 5.22222407e-02f, -3.56134214e-02f, 7.79448152e-02f,
  7.07176253e-02f, 3.25975530e-02f, 1.09970588e-02f, 4.76565072e-03f, -3.52192037e-02f, 3.85565311e-02f, 4.60148454e-02f, 3.20658349e-02f, 3.85596491e-02f, 1.02395914e-01f,
  -3.06202704e-03f, 1.89280454e-02f, -6.49125353e-02f, -2.57500764e-02f, -4.11392115e-02f, 5.21607548e-02f, -1.66476835e-02f, -8.15114230e-02f, 1.29082659e-02f, 1.14982668e-02f,
  9.27967057e-02f, -2.59258691e-02f, -5.07204123e-02f, 1.80630712e-03f, 5.11662588e-02f, -6.59932755e-03f, 3.25298496e-02f, 3.71518992e-02f, 3.23714241e-02f, 6.65191561e-02f,
  -2.90024909e-03f, 8.50917422e-04f, 1.88225415e-02f, -3.63271087e-02f, 6.95305318e-02f, 3.80943120e-02f, 3.85822542e-02f, 1.96307693e-02f, 5.03658131e-02f, 6.11912385e-02f,
  -4.40330356e-02f, -5.82779497e-02f, 4.72398922e-02f, 2.54104026e-02f, -6.42745793e-02f, -4.96230908e-02f, -6.01836555e-02f, 8.92891884e-02f, 4.21919897e-02f, 2.09419597e-02f,
  5.94612472e-02f, -2.74648387e-02f, -5.66825755e-02f, 7.55908638e-02f, 1.13202417e-02f, -2.30824519e-02f, 4.63083684e-02f, 3.07864416e-02f, 2.72185635e-02f, 2.99126422e-03f,
  -2.26555653e-02f, 5.87037206e-02f, 8.33336934e-02f, -1.31638739e-02f, 6.30529597e-02f, -8.03132914e-03f, -6.78319857e-02f, -3.85772549e-02f, 5.16535193e-02f, -5.43924607e-02f,
  -1.03227951e-01f, 1.50660938e-02f, 1.05137425e-02f, -5.33832982e-02f, -1.69799104e-01f, -6.15982106e-03f, 1.03305764e-01f, -6.03241138e-02f, 8.50431435e-03f, 8.58510509e-02f,
  1.06101424e-01f, -5.00455126e-03f, 1.02787092e-01f, 6.15292275e-03f, -2.58407798e-02f, 6.73395246e-02f, 8.96189809e-02f, -8.82537104e-03f, -1.99789889e-02f, -3.31524611e-02f,
  7.67702237e-02f, -2.81914305e-02f, -4.29518558e-02f, 1.04341470e-02f, 5.17653115e-02f, -1.21791624e-01f, 7.95200542e-02f, -6.56633154e-02f, -6.90396950e-02f, 7.22441599e-02f,
  -3.13668326e-02f, -3.34800966e-02f, -4.24718633e-02f, 6.58555850e-02f, 4.05844115e-02f, -8.87781158e-02f, -4.58100811e-02f, 7.67838359e-02f, 5.94727285e-02f, 4.15537730e-02f,
  4.84569483e-02f, -5.93280196e-02f, -5.26335090e-02f, 7.21019357e-02f, -4.91755717e-02f, 4.38809693e-02f, -7.02440366e-02f, -4.16596560e-03f, -6.05855789e-03f, 4.34189988e-03f,
  -2.27264445e-02f, 1.60408076e-02f, -3.48968133e-02f, 7.31490552e-02f, 4.33809459e-02f, 8.39389414e-02f, 4.49097008e-02f, -5.95756732e-02f, -2.31142482e-03f, 3.43818069e-02f,
  1.11554721e-02f, -3.15313041e-02f, 6.02432117e-02f, 6.70416374e-03f, -3.73165458e-02f, 1.84984822e-02f, 4.08301987e-02f, -5.65034486e-02f, -8.48789215e-02f, -4.66480432e-03f,
  -8.06231052e-02f, -7.45967031e-02f, 9.34963394e-03f, 9.97170061e-03f, -1.43338935e-02f, 4.55579348e-02f, -3.74614447e-02f, 5.71869873e-02f, -7.48611167e-02f, 1.60348625e-03f,
  7.93508887e-02f, 4.00481261e-02f, 5.47832176e-02f, 2.61173286e-02f, -2.53697559e-02f, 6.27166405e-02f, 1.37299793e-02f, 3.72779034e-02f, -2.74698506e-03f, -6.35391995e-02f,
  -6.00482039e-02f, -6.59228638e-02f, -5.96707352e-02f, -6.68710545e-02f, -8.82827193e-02f, -1.38965994e-02f, 2.80222464e-02f, -6.44973591e-02f, -9.57129523e-03f, -8.98149237e-02f,
  -3.18403430e-02f, -7.06149042e-02f, 1.09181013e-02f, 7.64237493e-02f, -5.21452650e-02f, 8.76432732e-02f, -2.74602901e-02f, 2.12120228e-02f, -1.68559887e-02f, -9.67292786e-02f,
  9.82670039e-02f, -4.86570373e-02f, 6.58643991e-02f, 3.52810398e-02f, 1.11642890e-02f, -2.37361644e-03f, -4.04725298e-02f, -1.64500494e-02f, 6.47544954e-03f, 6.43161982e-02f,
  -1.81423891e-02f, 5.31409606e-02f, -2.62230914e-02f, -7.28624612e-02f, 1.51978582e-02f, -1.88206639e-02f, -1.16406858e-01f, 6.08044192e-02f, 1.54143274e-02f, 4.09445502e-02f,
  -4.80769463e-02f, -8.74519125e-02f, 6.95993230e-02f, -1.72153860e-01f, -1.79548278e-01f, -9.79650989e-02f, -1.10648558e-01f, -7.46607035e-02f, -9.35878232e-02f, -9.90836248e-02f,
  -1.77180663e-01f, -1.29365653e-01f, -1.77629396e-01f, -4.05849814e-02f, -1.02544069e-01f, 6.61164373e-02f, 8.21782351e-02f, 7.27433013e-03f, 6.65849308e-03f, 2.41338555e-02f,
  1.69684738e-02f, -1.02895729e-01f, -1.20724486e-02f, 7.03697745e-03f, 4.69191261e-02f, -2.70926319e-02f, -6.69939891e-02f, -1.65058635e-02f, -5.64628653e-02f, 5.64698083e-03f,
  -9.38604877e-04f, 4.64446656e-02f, 4.21370044e-02f, -7.73092136e-02f, 1.91359464e-02f, -5.06865457e-02f, -5.90539239e-02f, -1.81059400e-03f, -6.90898821e-02f, -9.24635306e-02f,
  -2.04054099e-02f, -2.91353110e-02f, -2.87560076e-02f, -3.61857377e-02f, -5.66151328e-02f, 8.09273720e-02f, -6.71833083e-02f, -3.20573114e-02f, -4.04644459e-02f, -4.64086933e-03f,
  -4.72878180e-02f, -5.99422045e-02f, 7.20053241e-02f, 3.53571437e-02f, 5.19316681e-02f, 3.80905829e-02f, 4.28712256e-02f, 2.95299627e-02f, -2.83016711e-02f, -3.95390205e-02f,
  5.72019890e-02f, 5.34504540e-02f, 5.63480146e-02f, -5.95144928e-02f, -4.26906757e-02f, -1.74140651e-02f, 2.32007019e-02f, 9.15902629e-02f, 1.41572291e-02f, 2.31790543e-02f,
  3.43860425e-02f, 8.37019607e-02f, 4.72005755e-02f, -2.37111710e-02f, -2.58228872e-02f, -4.76237340e-03f, -1.82104670e-02f, 2.75532678e-02f, -1.94794405e-02f, 5.43924533e-02f,
  -4.66294140e-02f, -4.63456511e-02f, -3.42858508e-02f, 1.46851670e-02f, -6.00676499e-02f, 5.68567365e-02f, -4.24090773e-02f, -3.30611132e-02f, -2.03897636e-02f, -5.50718978e-02f,
  2.21426990e-02f, -5.84647059e-02f, 6.64987639e-02f, 8.28121454e-02f, -6.48694336e-02f, 3.76342726e-03f, 1.34891607e-02f, 9.68708247e-02f, 1.93417463e-02f, 4.08567227e-02f,
  8.53928104e-02f, 6.63112029e-02f, 5.22378124e-02f, 3.66343968e-02f, -8.74377880e-03f, -5.26814582e-03f, 7.30743408e-02f, -3.02148554e-02f, 2.81575341e-02f, -3.99550311e-02f,
  -1.40377536e-01f, -1.08128779e-01f, -2.59950787e-01f, -1.56830400e-01f, -1.12617940e-01f, -3.21903020e-01f, -8.68702382e-02f, -1.59634888e-01f, 1.69494197e-01f, 1.39771938e-01f,
  -2.23182049e-02f, 1.00255147e-01f, 1.36483982e-01f, -1.02750197e-01f, -1.78004038e-02f, 1.11618787e-01f, -1.69982776e-01f, -8.39417130e-02f, -2.51861140e-02f, -2.06046954e-01f,
  -4.67479741e-03f, -1.93538126e-02f, -1.78468093e-01f, 4.37716860e-03f, -1.96836725e-01f, 2.30322778e-02f, 1.36402354e-01f, -1.17615223e-01f, -9.16000530e-02f, 6.89891800e-02f,
  -3.97114791e-02f, -1.03602577e-02f, -8.63697007e-02f, 2.02650204e-02f, -3.20840068e-02f, 3.97191104e-03f, -2.75237765e-03f, 5.73912039e-02f, -6.46569058e-02f, -6.60178438e-02f,
  9.04419050e-02f, -4.08210009e-02f, 5.63366339e-02f, 3.89079452e-02f, 4.23457548e-02f, -4.26509641e-02f, 6.12652749e-02f, 4.23038788e-02f, -8.98674130e-02f, 4.20926474e-02f,
  -9.89933163e-02f, -7.90307149e-02f, -4.28069979e-02f, -4.12906148e-03f, 4.60743196e-02f, -1.06691904e-01f, 2.87208781e-02f, 6.08799867e-02f, -1.06855437e-01f, -2.75466070e-02f,
  3.09879426e-02f, -4.72875917e-03f, 7.93947354e-02f, 7.26427361e-02f, -7.83682391e-02f, 5.94738387e-02f, -3.47762294e-02f, 5.84469102e-02f, -5.64527474e-02f, 8.64673257e-02f,
  2.23979615e-02f, -4.99451831e-02f, 3.07088322e-03f, -2.82284711e-02f, 5.03890682e-04f, 6.84115663e-02f, 4.40506823e-02f, -2.88439579e-02f, 4.09636796e-02f, -4.26383913e-02f,
  3.16197351e-02f, -9.46079418e-02f, 5.48262931e-02f, 6.10037595e-02f, 6.87473454e-03f, 5.55162765e-02f, 9.61782504e-03f, -1.33006144e-02f, -6.03832975e-02f, -9.78744105e-02f,
  -1.68301851e-01f, -1.44889444e-01f, 1.32940700e-02f, -3.97757813e-02f, -9.18243267e-03f, -1.07124105e-01f, 4.01163809e-02f, 3.94749194e-02f, 3.58814560e-03f, -3.92139442e-02f,
  -1.12488091e-01f, 2.03647986e-02f, 2.37485897e-02f, -1.71495564e-02f, -1.19274075e-03f, -5.29702678e-02f, -7.33077675e-02f, 3.29093672e-02f, -3.72143439e-03f, -9.92076192e-03f,
  4.54759113e-02f, 1.04775233e-02f, -1.31658167e-02f, 1.00922927e-01f, 1.12298061e-03f, 1.36232376e-02f, 4.14390210e-03f, 1.27807884e-02f, 2.60205548e-02f, -5.21581359e-02f,
  8.90941992e-02f, -1.03409231e-01f, -7.43667185e-02f, -8.75520334e-02f, 3.61930951e-02f, -3.70574258e-02f, -5.37380502e-02f, 3.68554629e-02f, -1.21358030e-01f, -5.30721284e-02f,
  -1.01355717e-01f, 6.56875074e-02f, -6.89562261e-02f, 4.89670709e-02f, 1.51255921e-01f, 8.62584487e-02f, -4.82462645e-02f, -4.47856486e-02f, 8.48710537e-02f, 5.47646284e-02f,
  -4.63771001e-02f, 7.17415521e-03f, 6.25506267e-02f, -9.86706764e-02f, 2.91677471e-02f, -2.10405346e-02f, -7.74587318e-02f, 4.05046679e-02f, -8.50763619e-02f, -1.28857614e-02f,
  -3.96310948e-02f, 6.92551509e-02f, 1.33067733e-02f, 6.52907707e-04f, -5.03749996e-02f, -4.79908921e-02f, -1.76035818e-02f, 7.53552988e-02f, 5.20861596e-02f, -2.29923483e-02f,
  8.60092975e-03f, -2.62607690e-02f, 1.86544303e-02f, 1.52861364e-02f, 6.98086843e-02f, 6.12523891e-02f, -6.35955408e-02f, -4.15184870e-02f, -6.94692554e-03f, 1.23081074e-04f,
  -5.02978340e-02f, 4.06778902e-02f, -3.88590852e-04f, -1.55696096e-02f, 1.70083425e-03f, -7.68723264e-02f, 1.15184058e-02f, -4.20681201e-02f, 6.19585104e-02f, -1.81034543e-02f,
  -3.07487920e-02f, 2.70983633e-02f, -5.15044555e-02f, 1.33357299e-02f, -5.46901338e-02f, -5.49367703e-02f, 1.21251112e-02f, -4.26812656e-02f, -4.61643822e-02f, -9.19413045e-02f,
  -1.33544374e-02f, -1.85788330e-02f, -3.88627015e-02f, 5.82070183e-03f, -6.14274992e-03f, 7.99553990e-02f, 7.93200806e-02f, 2.04074662e-02f, -6.00917824e-02f, -6.19876683e-02f,
  -5.79600669e-02f, -6.70288131e-02f, 5.86022586e-02f, 4.76254746e-02f, -3.08958720e-02f, 1.67112108e-02f, -5.26662692e-02f, -7.50639588e-02f, 6.79544434e-02f, -1.65353715e-02f,
  5.63421547e-02f, -4.97783758e-02f, -9.94558185e-02f, -2.67485715e-03f, -5.29079791e-03f, -5.08044846e-02f, 4.45777774e-02f, 4.07111496e-02f, -3.72425094e-02f, -7.77502805e-02f,
  -6.17541745e-02f, 5.04285395e-02f, 5.51733514e-03f, -3.52937430e-02f, 4.28883806e-02f, -5.99663146e-02f, 6.35550246e-02f, -5.39490161e-03f, -8.28375295e-02f, -8.52317270e-03f,
  -5.69150560e-02f, -3.41687091e-02f, -3.77714299e-02f, 4.90444414e-02f, -8.18107575e-02f, -2.81827599e-02f, 2.43495516e-02f, -7.69622996e-02f, 5.92256011e-03f, -9.44421394e-04f,
  1.54514551e-01f, -5.56035824e-02f, 9.16238781e-03f, 1.74231112e-01f, 7.69625232e-02f, -2.17617273e-01f, -5.76568060e-02f, 2.93246340e-02f, 1.01781406e-01f, 1.22336373e-02f,
  -3.53697836e-02f, 1.02733470e-01f, 9.76891350e-03f, 6.90779388e-02f, 1.60666898e-01f, -4.09128740e-02f, 7.01077431e-02f, 3.94234546e-02f, 8.90006199e-02f, 5.74942306e-03f,
  3.86119410e-02f, 1.50702089e-01f, 1.56335339e-01f, 5.82525209e-02f, 8.27509761e-02f, 1.56852156e-02f, 5.38451634e-02f, -1.07445316e-02f, 7.95537382e-02f, -7.26063624e-02f,
  8.61458778e-02f, 7.93694332e-02f, -2.00990476e-02f, 7.91340880e-03f, 5.50363734e-02f, -1.20524123e-01f, -1.14704259e-01f, -2.91433390e-02f, -1.50756016e-02f, -5.93977571e-02f,
  -7.38854557e-02f, 7.82555789e-02f, 4.62027155e-02f, -3.39450017e-02f, 7.96070620e-02f, 1.10967783e-02f, 5.37378266e-02f, -5.72379082e-02f, 3.30442050e-03f, 5.92047581e-03f,
  1.14853065e-02f, 1.98857710e-02f, -3.38533297e-02f, -5.54314591e-02f, 4.89653125e-02f, -3.17731500e-02f, -8.05173367e-02f, 7.16493577e-02f, -4.79478240e-02f, -2.43557747e-02f,
  6.67187348e-02f, -5.03546111e-02f, 2.41753943e-02f, 5.09694442e-02f, 7.41131604e-02f, -6.64778352e-02f, -8.27103257e-02f, 4.69258614e-02f, 1.84555613e-02f, -1.29038431e-02f,
  -2.71673147e-02f, 3.27885225e-02f, -8.31855237e-02f, 1.04182810e-01f, -3.99320275e-02f, 5.70381060e-02f, 3.72775085e-02f, -4.80985921e-03f, 2.97902880e-04f, 1.77708957e-02f,
  -6.29606023e-02f, 7.95917884e-02f, -2.01030727e-02f, -3.38228233e-02f, -2.80486904e-02f, -1.32533479e-02f, 4.61642444e-02f, 4.28156555e-02f, -7.79123418e-03f, -2.68647121e-03f,
  9.52645857e-03f, 9.01888534e-02f, -5.31783001e-03f, -9.34407637e-02f, 2.25199144e-02f, 2.87622418e-02f, -3.18659050e-03f, 1.98549987e-03f, 6.88544661e-02f, -3.49904262e-02f,
  7.08545968e-02f, 2.98614223e-02f, -8.02069679e-02f, -4.03063139e-03f, -3.94875742e-02f, 6.13540970e-02f, -7.84552656e-03f, -1.21806306e-03f, -2.12840792e-02f, -3.63318920e-02f,
  4.01587076e-02f, -5.69665879e-02f, 6.31127730e-02f, 1.96759272e-02f, 7.93996900e-02f, -5.13715260e-02f, -6.24039099e-02f, 2.16517737e-03f, -3.46885100e-02f, 2.16884185e-02f,
  1.08137831e-01f, -5.31858951e-02f, 5.99156544e-02f, 1.52872488e-01f, 9.47286859e-02f, -1.21251941e-01f, 6.42699152e-02f, 4.77983207e-02f, 3.28026973e-02f, -7.50490651e-02f,
  -4.11354713e-02f, 1.48274591e-02f, -1.34639367e-02f, -3.13286595e-02f, 9.38750580e-02f, 5.85003244e-03f, 4.03240845e-02f, -7.88675249e-02f, -3.43149086e-03f, -4.14080769e-02f,
  1.24853045e-01f, 7.05183968e-02f, 1.06281988e-01f, 5.64474799e-03f, 8.22494701e-02f, -5.92861138e-02f, -7.18541071e-02f, -6.26244843e-02f, 5.73398732e-02f, 3.68713662e-02f,
  -1.10198203e-02f, 8.68114159e-02f, -8.67909715e-02f, 2.59580892e-02f, -3.15786228e-02f, -6.32100850e-02f, 3.28607708e-02f, 1.72408447e-02f, 8.29958692e-02f, -4.72795404e-02f,
  -3.17983739e-02f, 3.50284353e-02f, 5.13856709e-02f, 8.25904012e-02f, 8.36875886e-02f, 7.22086290e-03f, 2.94994134e-02f, 1.53040811e-02f, 2.86071058e-02f, 5.32659106e-02f,
  3.56462151e-02f, -3.04677468e-02f, 7.60602802e-02f, -6.25694394e-02f, -3.27908508e-02f, 6.18012249e-02f, 7.10134581e-02f, -2.56582089e-02f, -6.55161366e-02f, 7.63887092e-02f,
  1.43760219e-02f, -6.05427623e-02f, -1.80990808e-02f, 1.72605515e-02f, 5.01136221e-02f, 1.06629822e-02f, -4.74436730e-02f, 1.91103190e-03f, 4.64406684e-02f, 1.04444250e-02f,
  -6.35097921e-02f, 7.81554505e-02f, 9.51553658e-02f, -8.76964629e-02f, 2.66273157e-03f, 8.34048241e-02f, 9.11847726e-02f, -3.49556804e-02f, -3.16400221e-03f, 3.51750590e-02f,
  4.56813350e-02f, -7.79553736e-03f, 4.24648076e-02f, 2.23632902e-02f, 2.16930266e-02f, -7.93739408e-02f, -7.25380257e-02f, 4.49225008e-02f, 9.38408598e-02f, 7.18134120e-02f,
  4.70494200e-03f, -3.74594815e-02f, -9.01821405e-02f, 9.31360573e-02f, -5.20813651e-02f, -6.63836896e-02f, -5.80315851e-02f, 4.96805646e-02f, 2.98736375e-02f, 5.36782742e-02f,
  -2.12512650e-02f, 7.90697187e-02f, -5.48040979e-02f, -8.24605674e-02f, -5.57169784e-04f, 3.94846462e-02f, -2.85518896e-02f, -5.88566214e-02f, 3.15876082e-02f, 3.67802642e-02f,
  -4.43685278e-02f, -7.12655336e-02f, -4.13016900e-02f, -4.15324830e-02f, 1.11661470e-02f, -7.88783506e-02f, 7.62942508e-02f, -2.27397215e-02f, -8.99383575e-02f, 6.45187646e-02f,
  5.45772389e-02f, -3.02005019e-02f, -9.55761522e-02f, -7.59984851e-02f, -1.89393833e-01f, -5.26550561e-02f, -7.73376971e-02f, -7.79680088e-02f, 1.29923159e-02f, 2.18268469e-01f,
  -4.53121699e-02f, -6.18392080e-02f, 1.64350465e-01f, 1.37035415e-01f, -3.72947752e-02f, 1.81055054e-01f, 1.17754437e-01f, 1.54546216e-01f, -8.88635963e-03f, 6.32253662e-03f,
  5.87164275e-02f, 1.75687037e-02f, -2.61826739e-02f, 8.44559371e-02f, -4.84738462e-02f, -7.01802075e-02f, 4.58581746e-03f, -1.41105339e-01f, -7.28967041e-02f, -1.22541569e-01f,
  2.59885658e-03f, 2.43289415e-02f, -6.85496777e-02f, 3.07554081e-02f, -9.58987921e-02f, -3.60788368e-02f, 4.80881631e-02f, -9.68087167e-02f, 2.47808918e-02f, -5.34674264e-02f,
  -4.23040465e-02f, 8.15707073e-02f, 4.82119024e-02f, -2.34452616e-02f, -9.37689841e-03f, -2.07588747e-02f, -7.34705105e-02f, 7.17848986e-02f, 5.84738217e-02f, -5.47952019e-02f,
  -4.14395258e-02f, -1.22017972e-02f, 2.32468098e-02f, 4.77729551e-02f, -1.07361972e-01f, -1.57540739e-02f, 1.63116418e-02f, -7.38637596e-02f, 1.60496216e-02f, -7.85167143e-02f,
  3.38944793e-02f, 6.02164445e-03f, 7.04324916e-02f, -1.17613431e-02f, -9.69478022e-03f, 6.05796315e-02f, -2.82588173e-02f, 7.16807367e-03f, 8.57982971e-03f, 1.00131519e-01f,
  3.35431658e-02f, 1.73320286e-02f, -3.02692000e-02f, 5.61099127e-02f, 6.20206371e-02f, 6.77163005e-02f, -4.32827063e-02f, 1.23629114e-02f, 1.78374965e-02f, -5.66436909e-02f,
  9.72942859e-02f, -5.28469272e-02f, 3.09445187e-02f, 6.27215281e-02f, -4.80821356e-02f, -2.97736079e-02f, 7.44488463e-02f, -3.05746421e-02f, 4.70140204e-03f, -4.13255654e-02f,
  5.35661876e-02f, -5.46970107e-02f, 1.71041638e-02f, -1.82989966e-02f, -3.00665461e-02f, 5.12842946e-02f, -6.83026016e-02f, -9.87569243e-02f, -8.05515647e-02f, -2.67816857e-02f,
  8.81002937e-03f, 1.58519056e-02f, -3.45997289e-02f, -3.75243872e-02f, -7.54255150e-03f, -4.96133007e-02f, 6.55177981e-02f, -3.31409499e-02f, -2.32840460e-02f, 6.72777593e-02f,
  -8.09819549e-02f, 9.41533782e-03f, 7.23574907e-02f, -1.22843226e-02f, 3.10373437e-02f, 7.66804209e-04f, -5.24654835e-02f, -4.33087125e-02f, -6.05502203e-02f, -1.85774127e-03f,
  7.10204095e-02f, 6.17166124e-02f, -5.98504990e-02f, 6.46986961e-02f, -2.35369764e-02f, -7.30706155e-02f, 6.26746146e-03f, -5.53160831e-02f, 1.69266582e-01f, 9.61425826e-02f,
  5.69297858e-02f, 4.15591113e-02f, -8.07588398e-02f, 2.87916698e-02f, -1.13794178e-01f, -9.02454332e-02f, -7.90942013e-02f, -2.80861259e-02f, 9.10616517e-02f, -6.63855299e-02f,
  -5.95448352e-02f, -4.60849926e-02f, -6.18229881e-02f, -3.03651728e-02f, 4.51018624e-02f, 1.24129280e-01f, -1.31513521e-01f, 4.80981879e-02f, -2.72996295e-02f, 6.25087367e-03f,
  5.00121824e-02f, 9.71176922e-02f, 3.30344997e-02f, 7.27710649e-02f, -7.47592468e-03f, -3.54371704e-02f, 7.39805624e-02f, 3.10447868e-02f, 1.27802521e-01f, 9.22614783e-02f,
  -3.55208702e-02f, 5.62881716e-02f, 1.20968381e-02f, 6.59321696e-02f, 4.64321412e-02f, -5.90453520e-02f, 1.02328174e-01f, -1.60337631e-02f, 6.34516329e-02f, -6.29176497e-02f,
  9.63896066e-02f, -4.56972308e-02f, 8.98604020e-02f, -7.59187043e-02f, -3.99264023e-02f, 6.52840221e-03f, 1.35552196e-03f, -2.32781135e-02f, -3.49148139e-02f, 1.76975317e-02f,
  -6.78152665e-02f, -5.44620790e-02f, 5.27156331e-02f, -1.02781281e-02f, -3.08394209e-02f, 2.11863704e-02f, 1.19422987e-01f, -4.27473485e-02f, 1.14989966e-01f, 7.85828903e-02f,
  9.13258716e-02f, -8.27813074e-02f, -1.35020800e-02f, -3.50659564e-02f, -6.43262342e-02f, 3.29322107e-02f, -5.80278644e-03f, 1.07281497e-02f, 2.24271305e-02f, -8.86641741e-02f,
  -8.94188881e-02f, -8.09682766e-04f, 2.57265437e-02f, -5.42243235e-02f, 1.78135522e-02f, 6.32725889e-03f, -6.58945814e-02f, 2.89532058e-02f, -4.98410203e-02f, 7.04784021e-02f,
  5.70334233e-02f, -6.79430887e-02f, -6.02442548e-02f, -9.60309245e-03f, 6.28616214e-02f, -5.60298301e-02f, -3.41243856e-02f, 6.49976954e-02f, 5.85678518e-02f, -3.06594763e-02f,
  3.03716511e-02f, -1.58327240e-02f, -6.84306677e-03f, -9.40874964e-03f, -3.01475488e-02f, 4.56316583e-02f, -4.90589924e-02f, -2.62624305e-02f, 8.68896991e-02f, 1.47920521e-02f,
  9.32272300e-02f, 1.89022329e-02f, 7.17357174e-02f, 8.27545151e-02f, 8.35593119e-02f, -5.32974526e-02f, -2.58601457e-02f, -1.04481382e-02f, -6.64435849e-02f, -3.92210670e-03f,
  -5.54248057e-02f, 7.84576032e-03f, -9.59254205e-02f, -1.06774509e-01f, -1.08862475e-01f, -1.64051428e-01f, 1.99204516e-02f, -1.32253602e-01f, 4.72264364e-02f, -1.65984314e-02f,
  -8.27085003e-02f, -6.28186911e-02f, 1.21344298e-01f, -1.18536070e-01f, 2.60638967e-02f, 1.87256299e-02f, -1.40696287e-01f, 1.80252995e-02f, 8.49474221e-03f, -7.47043341e-02f,
  -1.21782303e-01f, -1.92369539e-02f, -9.10822526e-02f, -2.17421241e-02f, -1.56136259e-01f, 2.60953791e-02f, 1.91207901e-02f, -8.54306221e-02f, -9.83381122e-02f, -8.07549283e-02f,
  -4.17472944e-02f, 4.43348177e-02f, -8.61192197e-02f, -2.97543360e-03f, -1.02961347e-01f, -8.76418576e-02f, 5.60599528e-02f, -1.36060975e-02f, 8.77102613e-02f, -1.91135192e-03f,
  1.36213992e-02f, -1.43256094e-02f, 2.51246821e-02f, -8.37258995e-02f, -1.84751581e-02f, 3.63241285e-02f, -1.19511383e-02f, -6.41649738e-02f, -2.86083501e-02f, 1.11896498e-02f,
  -2.88812835e-02f, -2.15080772e-02f, -4.50493209e-02f, -3.68855856e-02f, -5.51396906e-02f, 6.22282587e-02f, 2.01781448e-02f, 7.71918148e-02f, -2.57299989e-02f, 1.72579251e-02f,
  -2.59491429e-02f, -7.81085938e-02f, -8.86763558e-02f, 2.06363145e-02f, 6.76404983e-02f, 7.50166327e-02f, 6.71642572e-02f, -3.62488702e-02f, 4.55955751e-02f, -4.78308015e-02f,
  -8.76446888e-02f, -5.05901426e-02f, -5.92636056e-02f, -6.85401112e-02f, -9.58417635e-03f, -5.56146577e-02f, 8.01597373e-04f, 1.35689517e-02f, 2.03364668e-03f, -2.58129537e-02f,
  -9.84253455e-03f, -8.80266353e-03f, -7.73843154e-02f, -8.04525763e-02f, 4.44429107e-02f, 7.91141987e-02f, -1.12024201e-02f, -9.11236182e-02f, 8.01103264e-02f, 7.17300251e-02f,
  1.92780029e-02f, -1.76981557e-02f, -3.81396152e-02f, 8.56861547e-02f, -2.58029625e-02f, 5.74337356e-02f, -5.77824749e-02f, 2.21458022e-02f, 7.41742402e-02f, 7.23065436e-03f,
  -3.22637111e-02f, -5.32300286e-02f, -7.14740753e-02f, -4.25681733e-02f, -4.71585318e-02f, 5.41367270e-02f, 5.30278794e-02f, -5.30529693e-02f, -2.13005338e-02f, -4.68968675e-02f,
  -7.51335695e-02f, 5.97964488e-02f, 6.44854009e-02f, -1.05392411e-01f, 1.24100475e-02f, 1.24410810e-02f, 6.01049811e-02f, 3.06695718e-02f, -1.33846956e-03f, 4.32163365e-02f,
  -4.04112646e-03f, -1.30807430e-01f, 5.10415900e-03f, -4.50157523e-02f, 1.60922688e-02f, 1.60731971e-02f, 8.78303349e-02f, -7.79270977e-02f, -1.65214539e-01f, -3.63853276e-02f,
  -1.09613776e-01f, -5.67569584e-02f, -1.05847321e-01f, 7.12719411e-02f, 1.01292826e-01f, 5.10865152e-02f, 2.46331654e-02f, 7.43757784e-02f, -6.16315715e-02f, -6.85079694e-02f,
  -2.67857648e-02f, 9.02367383e-02f, 5.91753870e-02f, 4.61145379e-02f, 1.47912920e-01f, 6.89979037e-03f, -2.32167598e-02f, -3.84887159e-02f, 4.77814451e-02f, 1.23462118e-01f,
  1.20638259e-01f, -7.68073201e-02f, 4.83911950e-03f, -4.79139052e-02f, 9.31516290e-03f, -1.68320234e-03f, 5.23819886e-02f, 3.20401490e-02f, -8.19076821e-02f, -1.38838172e-01f,
  -9.08230767e-02f, -7.29088858e-03f, -7.69169396e-03f, 3.67693678e-02f, -2.36009695e-02f, 2.05781162e-02f, -6.24593087e-02f, -1.86425578e-02f, -1.93018354e-02f, 3.13819721e-02f,
  -9.69603434e-02f, -7.24585578e-02f, -3.28180753e-02f, 6.51014671e-02f, -6.82582855e-02f, 1.81593783e-02f, 6.81565106e-02f, -5.19820563e-02f, -4.84954864e-02f, -3.03097405e-02f,
  -5.79437129e-02f, 1.06791377e-01f, -3.30453254e-02f, 2.65188254e-02f, -4.61781137e-02f, 2.66605113e-02f, 1.26765156e-02f, 4.94500399e-02f, 2.89671831e-02f, -8.79779235e-02f,
  -4.47049290e-02f, -1.29819782e-02f, 5.65875955e-02f, -1.20440647e-02f, -2.35940274e-02f, 9.96167399e-03f, 5.38043827e-02f, 1.42019540e-02f, -6.42439537e-03f, -1.74337924e-02f,
  2.36724201e-03f, -7.85368010e-02f, -2.94638779e-02f, 2.03330200e-02f, 5.43289520e-02f, 4.52062394e-03f, -4.54386882e-02f, 2.18441710e-02f, 4.20883670e-03f, 2.29680594e-02f,
  -2.49052960e-02f, -3.54733989e-02f, 1.19629120e-02f, 9.75074768e-02f, 3.72263119e-02f, -4.61267531e-02f, 3.81278805e-02f, 1.42332222e-02f, -5.37344888e-02f, -4.82808752e-03f,
  -3.58433947e-02f, 9.06739831e-02f, 2.11108476e-02f, 4.72702943e-02f, -1.89077165e-02f, 4.86741401e-02f, -1.73852965e-02f, 6.56865761e-02f, -2.63334606e-02f, 2.03743633e-02f,
  5.67321852e-02f, -8.55888203e-02f, 7.62437284e-02f, -1.98755171e-02f, -8.22901726e-02f, 3.93843614e-02f, 3.88998426e-02f, -1.16833276e-03f, 1.00349262e-01f, 1.65738177e-03f,
  -3.66761163e-02f, 2.04232886e-01f, 1.00992851e-01f, 4.18177396e-02f, 8.74058232e-02f, 5.94173186e-02f, -2.57120300e-02f, 1.06762098e-02f, 3.60376351e-02f, -6.12828173e-02f,
  -1.03130080e-01f, 9.60209146e-02f, 5.16035967e-02f, 1.07577723e-02f, -2.36036964e-02f, 6.07451946e-02f, -4.45454977e-02f, 5.33548519e-02f, 1.03931069e-01f, -2.39185821e-02f,
  3.33812684e-02f, -2.80002672e-02f, 1.79122463e-02f, -2.98506226e-02f, 3.16078514e-02f, 7.12654516e-02f, -7.10027963e-02f, 8.50515589e-02f, 1.02105170e-01f, 9.38934386e-02f,
  6.97456449e-02f, -6.36729002e-02f, -5.67141548e-02f, 1.14043012e-01f, -2.03928612e-02f, 3.85028496e-02f, -2.47055609e-02f, -3.71066406e-02f, -7.70749450e-02f, 3.86766791e-02f,
  -4.51466627e-03f, 7.16403201e-02f, 5.87281547e-02f, 5.14013506e-02f, -2.45871320e-02f, 2.81175356e-02f, 7.37288743e-02f, 5.52521087e-02f, 9.34334472e-02f, 1.36720479e-01f,
  1.07295200e-01f, 5.53253805e-03f, 8.15344453e-02f, -8.44002590e-02f, 3.57769579e-02f, 3.82854696e-03f, -7.42529426e-03f, 3.48200202e-02f, 3.93775813e-02f, -4.99046110e-02f,
  8.48420337e-02f, 4.32877205e-02f, 3.74767072e-02f, 5.62926605e-02f, -7.65351504e-02f, 7.71973506e-02f, 2.74916925e-02f, 3.06180287e-02f, -1.51535058e-02f, -4.43347581e-02f,
  1.05035761e-02f, -4.23550978e-02f, 9.18056220e-02f, 3.31499390e-02f, 5.03558256e-02f, 3.48021388e-02f, -3.81352683e-03f, -6.78847656e-02f, 2.43737884e-02f, -9.22173709e-02f,
  -1.13004982e-01f, 8.37579221e-02f, 5.82139008e-02f, 5.18019944e-02f, 5.72933964e-02f, 9.49813332e-03f, 5.07642180e-02f, 2.49948818e-02f, 1.22146094e-02f, -1.67838950e-02f,
  -6.36328161e-02f, -7.81015456e-02f, 6.56131804e-02f, 2.82770582e-02f, 7.09197670e-02f, -2.04634829e-03f, 4.55201939e-02f, 9.06260386e-02f, -2.87373085e-02f, 2.34257784e-02f,
  9.32896137e-02f, -7.27009634e-03f, 1.83266383e-02f, -7.16118291e-02f, -6.30285367e-02f, 6.11527450e-03f, -4.71276119e-02f, -8.78366269e-03f, 5.13189621e-02f, 1.83772929e-02f,
  5.06090261e-02f, 2.14295425e-02f, -1.18550211e-02f, 6.04053251e-02f, -1.39812762e-02f, 1.40000340e-02f, -7.95033202e-02f, 4.55539413e-02f, -1.68541763e-02f, -5.37241460e-04f,
  -7.65917450e-02f, 7.21833184e-02f, 1.29096478e-01f, 1.15216240e-01f, -2.51979269e-02f, 1.97191481e-02f, 1.03630081e-01f, 5.51013183e-03f, 1.52383924e-01f, -4.55084303e-03f,
  1.91899873e-02f, 1.90301970e-01f, 7.89243635e-03f, 2.02765269e-03f, 1.79999005e-02f, 9.76985600e-03f, 3.37447338e-02f, 7.66277388e-02f, -9.72724557e-02f, 3.12767997e-02f,
  5.89260384e-02f, -3.21505107e-02f, -1.08031623e-01f, 2.13011689e-02f, -6.90110354e-03f, 1.68022085e-02f, 3.86058912e-02f, -5.18959761e-02f, 2.63253450e-02f, -2.57560052e-02f,
  4.63683419e-02f, 1.16234437e-01f, -8.16605687e-02f, 1.12698391e-01f, -1.00725353e-01f, 1.58111900e-02f, 3.21787558e-02f, -6.78293174e-03f, -7.90962949e-02f, 4.43491759e-03f,
  1.06319807e-01f, 7.80423209e-02f, -6.72916397e-02f, 5.39845824e-02f, 4.61367443e-02f, 5.81378527e-02f, -9.94847864e-02f, -7.80485794e-02f, -4.75260988e-02f, 2.62076333e-02f,
  -8.73428807e-02f, 6.22993968e-02f, 7.63059855e-02f, 7.58952275e-02f, -8.19874331e-02f, 8.90211239e-02f, 2.95143463e-02f, 1.65204015e-02f, 5.94347641e-02f, 4.52695787e-02f,
  2.30638832e-02f, 5.47494777e-02f, 2.93602468e-03f, 3.60423662e-02f, 8.20337161e-02f, 1.93758402e-02f, -2.71303449e-02f, 1.93693042e-02f, -7.92929344e-03f, -4.93132696e-03f,
  1.91996340e-02f, 9.83166248e-02f, -1.01074100e-01f, 4.19526733e-02f, -8.79534781e-02f, 2.45348234e-02f, -6.95620701e-02f, 2.15280820e-02f, -3.05403154e-02f, -1.69274546e-02f,
  5.38064428e-02f, -1.87766328e-02f, -4.19502100e-03f, 1.90926138e-02f, -5.16120791e-02f, 7.95170814e-02f, -7.27636367e-02f, 4.83329333e-02f, -5.80787621e-02f, -5.90235032e-02f,
  2.27702968e-02f, 1.93457350e-01f, -2.67283842e-02f, -6.60124570e-02f, 6.60810843e-02f, -2.37117596e-02f, 7.69148301e-03f, 5.19964956e-02f, -3.01046651e-02f, -6.28002211e-02f,
  1.09289344e-02f, -7.82718658e-02f, 7.65842572e-02f, 1.48416050e-02f, 1.30142802e-02f, 2.38011889e-02f, 4.15118001e-02f, -2.72343513e-02f, 5.12788706e-02f, 3.64974886e-02f,
  -8.76969621e-02f, 3.42602953e-02f, 6.50321245e-02f, 8.02314878e-02f, -9.96524375e-03f, 7.02061728e-02f, 6.32800907e-02f, -1.40841007e-02f, -6.78574145e-02f, -6.95741847e-02f,
  7.79353753e-02f, -3.96729745e-02f, -6.41689673e-02f, 6.94873855e-02f, 8.44007209e-02f, -8.09117481e-02f, -1.36088967e-01f, -2.72924062e-02f, -2.92558223e-02f, -6.46936297e-02f,
  5.85896410e-02f, 1.01896897e-01f, -1.34977475e-01f, 1.48478851e-01f, 1.62545979e-01f, -8.30454901e-02f, 5.53115159e-02f, -4.58076447e-02f, -2.49392986e-02f, 2.10184082e-02f,
  1.27517387e-01f, 6.71034828e-02f, 5.88537529e-02f, 7.74848461e-02f, 2.72613522e-02f, 6.78753629e-02f, -5.25517277e-02f, -1.12757504e-01f, 1.06512874e-01f, 9.62540060e-02f,
  -5.09093143e-02f, 5.63340187e-02f, 2.94574071e-02f, -8.64258211e-04f, -9.28565934e-02f, -5.62663414e-02f, 2.11325251e-02f, 2.16949433e-02f, 5.39009273e-02f, 6.80139884e-02f,
  -8.77999794e-03f, -8.77281278e-02f, -8.54263734e-03f, -7.52586350e-02f, -2.22546216e-02f, 4.47919825e-03f, -4.59757112e-02f, -1.48387784e-02f, -5.92857716e-04f, -2.35718861e-02f,
  -6.89745545e-02f, 3.22459042e-02f, -1.93188395e-02f, -3.91985103e-02f, 7.50860572e-02f, 6.85099661e-02f, -2.83722058e-02f, -6.08920343e-02f, 9.14520584e-03f, 3.61657888e-02f,
  -6.23753928e-02f, 5.72681986e-02f, 1.46211255e-02f, 2.97772083e-02f, 4.02271934e-02f, 5.53081594e-02f, -4.51901816e-02f, 7.91000500e-02f, -5.89550361e-02f, -4.35314253e-02f,
  -6.51241764e-02f, 4.75548655e-02f, 8.03989619e-02f, 1.55790159e-02f, 1.10778183e-01f, -2.72061247e-02f, -2.77589578e-02f, 6.51863068e-02f, 1.69407334e-02f, -7.35687278e-03f,
  -5.84488213e-02f, 1.01184081e-02f, 1.69360302e-02f, -9.55800712e-03f, -4.59697470e-02f, 8.80460441e-02f, -2.45742202e-02f, -1.93662439e-02f, 8.45653657e-03f, -7.79873952e-02f,
  -2.88502816e-02f, 1.65658109e-02f, -1.68810505e-02f, -3.34534384e-02f, -5.29773645e-02f, -7.10889548e-02f, -3.94697189e-02f, 5.97334132e-02f, -5.62188961e-02f, -4.20538895e-02f,
  4.42782678e-02f, 4.84397709e-02f, 2.08558515e-02f, -7.41610595e-04f, 4.77822721e-02f, 5.49604371e-02f, 2.92295553e-02f, -5.21012098e-02f, -5.13846427e-02f, -4.24885750e-02f,
  5.51091395e-02f, -1.07886240e-01f, -6.13909215e-02f, 5.05561531e-02f, 8.96786004e-02f, -5.43397516e-02f, -2.44659148e-02f, 8.88739771e-04f, -2.23508701e-02f, -4.29046303e-02f,
  5.11975065e-02f, -7.02572465e-02f, -1.94906071e-01f, -4.45480011e-02f, -1.42165616e-01f, -2.74137557e-01f, -2.46085450e-01f, -5.85068949e-02f, -7.85280019e-03f, 3.14839631e-02f,
  -1.35809690e-01f, 1.13450170e-01f, -3.03611699e-02f, -1.13097936e-01f, 1.25804201e-01f, 1.18088618e-01f, -6.54645637e-03f, 5.60426712e-02f, 1.10290334e-01f, -1.16938844e-01f,
  1.18913203e-01f, -3.07368375e-02f, -1.52183548e-02f, -8.02657530e-02f, -1.91896886e-01f, -2.10663248e-02f, 1.62393987e-01f, -1.40810460e-01f, -8.63864645e-02f, 5.15080476e-03f,
  -1.86393037e-03f, 1.62713006e-02f, -7.92566091e-02f, -6.56515956e-02f, -6.05507568e-02f, -8.38529989e-02f, -7.80394524e-02f, -7.17183873e-02f, -3.94514687e-02f, 7.99326822e-02f,
  3.52040716e-02f, -4.13283035e-02f, -3.94391157e-02f, -1.91595517e-02f, -7.45915025e-02f, 3.52966897e-02f, -4.70925607e-02f, 4.95590307e-02f, -1.02246553e-02f, -1.36271557e-02f,
  2.93864403e-02f, 6.77073374e-02f, -6.48353174e-02f, -3.01915612e-02f, -3.65854204e-02f, 2.22852118e-02f, -2.00616419e-02f, 9.18631908e-03f, 1.10487700e-01f, 5.34604788e-02f,
  4.87226397e-02f, -4.10028659e-02f, -1.15842698e-02f, -7.55975693e-02f, -4.74246554e-02f, 3.84760350e-02f, -1.96302570e-02f, 6.00610599e-02f, 5.50510958e-02f, -6.11193962e-02f,
  -5.94161730e-03f, 1.01352014e-01f, -1.18915597e-02f, 4.71785739e-02f, -1.05231009e-01f, 3.46637666e-02f, 8.45198240e-03f, 3.14996950e-02f, -8.22263584e-03f, 2.62640067e-03f,
  7.48120397e-02f, -3.72793525e-02f, 1.40442550e-02f, -8.18482786e-02f, 5.39816637e-03f, -2.52949651e-02f, 2.57522259e-02f, 1.22892959e-02f, -1.97307561e-02f, 3.21752625e-03f,
  -2.71113757e-02f, 1.24999218e-01f, 8.24547000e-03f, -7.62924105e-02f, 6.26062825e-02f, 6.65350556e-02f, -3.22550274e-02f, 1.99717041e-02f, 4.28987853e-02f, -6.21140972e-02f,
  6.16436265e-02f, 7.66020268e-02f, -5.31512359e-03f, -6.92301476e-03f, -7.89580196e-02f, -2.18450818e-02f, -5.69543429e-02f, -9.86616872e-03f, 7.52861798e-02f, 5.07985614e-02f,
  -7.53752664e-02f, 3.03463209e-02f, 5.75768203e-02f, 5.54609783e-02f, -1.22029139e-02f, 4.59620506e-02f, 8.00689682e-02f, -3.68170515e-02f, 1.10457480e-01f, 3.95975448e-03f,
  3.54370415e-01f, 3.09161425e-01f, 9.21148211e-02f, 2.06718743e-01f, -2.63128728e-01f, -1.65727347e-01f, -5.02858534e-02f, 3.44628505e-02f, -7.96552598e-02f, 1.07658520e-01f,
  3.01818689e-03f, 1.77496836e-01f, -9.37441587e-02f, 5.94389923e-02f, -3.56144309e-02f, 4.51720096e-02f, 9.48388949e-02f, -1.65930055e-02f, -6.08712668e-03f, 1.94219083e-01f,
  3.84403300e-03f, 5.11706471e-02f, 4.37340923e-02f, -5.61216138e-02f, 1.23282306e-01f, 1.21497951e-01f, -2.53731832e-02f, 6.34576473e-03f, 4.07954901e-02f, -5.93324080e-02f,
  -5.96890412e-02f, 5.01068197e-02f, 1.69735290e-02f, 7.99031183e-02f, 1.29031288e-02f, 3.21231857e-02f, -5.17636612e-02f, 5.13320863e-02f, -7.81177403e-03f, 3.76346856e-02f,
  -1.99787114e-02f, -5.15952706e-02f, 5.11353314e-02f, 2.35789306e-02f, -9.54740681e-03f, -1.03701083e-02f, 7.47285411e-02f, 6.77582845e-02f, -6.31332248e-02f, 6.85640126e-02f,
  -2.20574420e-02f, 5.70738651e-02f, -3.59629989e-02f, 6.25274181e-02f, 2.40953118e-02f, -1.57558341e-02f, -2.76847892e-02f, 2.33921818e-02f, 6.43874854e-02f, 1.67345796e-02f,
  -1.59335230e-02f, 3.27119716e-02f, -4.39162180e-02f, -4.32534069e-02f, 7.39749297e-02f, -4.38497448e-03f, 1.19062851e-03f, -6.88049793e-02f, -4.41890322e-02f, -4.96071354e-02f,
  -5.43962717e-02f, -1.00448239e-03f, -8.58910233e-02f, -2.64403019e-02f, -1.62065066e-02f, 2.85316966e-02f, 3.37468721e-02f, 4.70014550e-02f, 2.52146064e-03f, -1.39211938e-02f,
  -5.30092046e-02f, -3.01265270e-02f, -3.92992422e-02f, -5.07072732e-02f, -9.75646898e-02f, -1.51993912e-02f, -3.18821683e-03f, 1.37881218e-02f, -1.32528814e-02f, -3.38599994e-03f,
  1.35025168e-02f, 1.07725218e-01f, 8.89807194e-02f, 8.79263598e-03f, -2.67324112e-02f, 2.58674975e-02f, 9.55325812e-02f, -2.58820951e-02f, -2.08337177e-02f, 4.62672822e-02f,
  -9.32760630e-03f, 2.18335148e-02f, 3.43376137e-02f, -2.55437829e-02f, -2.40295362e-02f, 1.98973045e-02f, -5.19054346e-02f, 5.06926104e-02f, 8.01279442e-04f, 8.02816532e-04f,
  3.50141115e-02f, -8.27695206e-02f, 3.92615236e-02f, -3.13368812e-02f, 1.11249359e-02f, -3.80731113e-02f, 7.05113038e-02f, -2.10142322e-02f, 1.67110667e-03f, -2.23924182e-02f,
  -7.37920031e-02f, 6.78735832e-03f, -2.96735670e-02f, 4.21773531e-02f, 2.63185683e-03f, 8.85342211e-02f, -3.06947883e-02f, 1.03849001e-01f, -2.35764049e-02f, 7.20797703e-02f,
  -2.05563102e-02f, 3.84735279e-02f, -5.24747446e-02f, 4.51069511e-02f, 6.56020045e-02f, 1.84144005e-02f, 7.59570897e-02f, 2.68816557e-02f, 2.14767810e-02f, -1.07709765e-02f,
  -7.33057410e-02f, 5.02469726e-02f, 9.95703861e-02f, -2.98936013e-02f, 1.03824446e-02f, -5.81681766e-02f, -7.62039199e-02f, 6.21316247e-02f, -2.06028782e-02f, 2.04687659e-02f,
  -4.79648747e-02f, 2.25087255e-03f, -1.96273271e-02f, -4.29289341e-02f, -2.34034620e-02f, -5.95635676e-04f, 8.63185711e-03f, 2.10093092e-02f, -1.31755341e-02f, -1.80275142e-02f,
  8.55532568e-03f, -7.09147938e-03f, 4.17689569e-02f, -6.13989215e-03f, -4.36137728e-02f, -2.55689081e-02f, -8.85226652e-02f, -1.45725813e-02f, -3.81731540e-02f, -8.38144124e-02f,
  -8.12729970e-02f, 6.70668036e-02f, -7.91216940e-02f, 1.48007255e-02f, 5.39118573e-02f, -5.92155149e-03f, 9.16468129e-02f, 8.23794454e-02f, 7.34078959e-02f, 1.64816845e-02f,
  -7.77373388e-02f, 5.61705902e-02f, -2.32047439e-02f, 6.62624612e-02f, -3.96150723e-03f, -1.05076537e-01f, 3.25217955e-02f, 1.30628487e-02f, -1.26057453e-02f, -4.88420203e-02f,
  2.78769676e-02f, -8.36635157e-02f, 5.38194366e-02f, 1.27256280e-02f, 7.60738598e-03f, -3.39311361e-02f, -5.63396960e-02f, -6.75401911e-02f, -7.73817971e-02f, -4.25386019e-02f,
  -4.63602878e-02f, 2.61974265e-03f, -2.37154737e-02f, 4.80540693e-02f, 2.20934413e-02f, 1.29436543e-02f, -3.06467544e-02f, 3.62277292e-02f, -9.05179009e-02f, -1.78137086e-02f,
  1.27300084e-01f, 5.54666035e-02f, -3.02662645e-02f, 7.18460679e-02f, 3.89621295e-02f, 5.23755476e-02f, -2.69021676e-03f, -7.39124343e-02f, -6.73635304e-02f, -5.73402606e-02f,
  -3.76252532e-02f, 4.00688797e-02f, 4.62047709e-03f, 4.99118911e-03f, -3.91505919e-02f, -4.66472842e-02f, 9.41120312e-02f, 8.53684731e-04f, -5.12529314e-02f, 7.30438307e-02f,
  7.69404247e-02f, -1.04841903e-01f, 9.15723369e-02f, -8.84120315e-02f, 7.81679377e-02f, -1.14780478e-02f, -6.35121688e-02f, 3.71493623e-02f, 1.63375437e-02f, -2.12552994e-02f,
  4.89967391e-02f, -1.12318166e-01f, 9.89397392e-02f, 3.69121283e-02f, 3.77134904e-02f, 1.68700702e-02f, 6.16333820e-02f, 3.83416973e-02f, 1.27100497e-01f, -1.51381744e-02f,
  -8.27226415e-02f, 1.49215269e-03f, 6.47435803e-03f, -4.11229394e-02f, -7.00682849e-02f, 5.27311116e-02f, -7.68333972e-02f, -4.79041673e-02f, -5.94231635e-02f, -4.48350981e-02f,
  -1.80966826e-03f, 1.20231798e-02f, 9.53725204e-02f, -3.14636007e-02f, -1.47238430e-02f, 1.03775099e-01f, 6.89359382e-02f, 2.31650304e-02f, -7.29914531e-02f, -1.53842671e-02f,
  2.36584041e-02f, 6.56786636e-02f, 1.03812099e-01f, -2.95021478e-02f, -2.51028314e-02f, -1.18787354e-02f, -7.39175230e-02f, 2.71084327e-02f, 2.16449387e-02f, -6.21769540e-02f,
  -3.13841179e-02f, 5.11263274e-02f, 1.46282269e-02f, -3.92963402e-02f, 8.71965513e-02f, -6.56575859e-02f, 2.71998259e-04f, 1.02592520e-01f, -4.94967289e-02f, 1.45172467e-02f,
  -3.40093449e-02f, -5.50747178e-02f, 7.01942071e-02f, 5.56682572e-02f, 2.97468286e-02f, 7.40021244e-02f, -5.33460127e-03f, -5.45391254e-02f, 7.84160346e-02f, 3.48302163e-02f,
  -5.87927997e-02f, -1.41891069e-03f, -1.54925184e-02f, 4.96570952e-02f, 4.26073968e-02f, -6.18635342e-02f, -8.26332420e-02f, 7.59689435e-02f, 2.80857496e-02f, 3.94259728e-02f,
  -2.78666206e-02f, -9.16020945e-03f, -5.83566502e-02f, 3.54708731e-02f, 1.58152170e-02f, -6.00409554e-03f, -4.52018790e-02f, -6.64541274e-02f, 2.02578064e-02f, -5.09946235e-02f,
  5.97793721e-02f, -4.49391380e-02f, -8.51526633e-02f, 8.70494023e-02f, -2.56143492e-02f, 8.26825276e-02f, 7.10525960e-02f, -8.81155506e-02f, 8.72838423e-02f, -8.33963417e-03f,
  -6.32614419e-02f, 3.11897267e-02f, -2.59604584e-02f, 2.85017211e-02f, -5.47651015e-02f, -3.20973210e-02f, -3.34572829e-02f, 2.96391901e-02f, -4.43394035e-02f, 3.98914889e-02f,
  9.33751613e-02f, -2.99189072e-02f, 1.27998432e-02f, -8.03747550e-02f, -2.23471932e-02f, -3.54310498e-02f, 5.39065339e-02f, -6.50113001e-02f, 1.56709962e-02f, -2.13896316e-02f,
  -5.97156212e-02f, -1.39064910e-02f, 7.80344531e-02f, -8.18763152e-02f, 1.56510603e-02f, -7.19637424e-02f, 3.09944823e-02f, 4.35858294e-02f, -7.31219500e-02f, -7.87699446e-02f,
  6.12979420e-02f, -3.08068953e-02f, 7.62178302e-02f, 1.62256926e-01f, -1.11971922e-01f, -8.20417553e-02f, -5.77086993e-02f, -3.81945111e-02f, 1.72695313e-02f, -1.04473032e-01f,
  1.34972349e-01f, 5.87401576e-02f, 8.65007862e-02f, 1.04476705e-01f, 1.89632773e-01f, -1.08168526e-02f, 2.04936750e-02f, 3.85091938e-02f, 2.91963834e-02f, 1.32387623e-01f,
  1.74594432e-01f, 1.77993847e-04f, 1.04704425e-01f, 8.87935385e-02f, 3.72890010e-02f, 3.86079252e-02f, 4.92265858e-02f, -5.78290261e-02f, 2.58577112e-02f, 3.85994874e-02f,
  4.65667397e-02f, 5.13689220e-03f, 3.98800075e-02f, -3.33230644e-02f, -5.96001334e-02f, -1.15152389e-01f, 3.39288190e-02f, -7.46614262e-02f, 9.31814238e-02f, 7.29416981e-02f,
  -5.09551503e-02f, -4.88079451e-02f, -5.11778379e-03f, -2.74699442e-02f, 5.61333261e-03f, 1.89881809e-02f, 4.91627790e-02f, -3.52755487e-02f, -6.61249682e-02f, 6.10477701e-02f,
  5.73472083e-02f, -6.19631074e-02f, 4.00381163e-02f, -8.62362906e-02f, 1.00924939e-01f, 2.01355573e-02f, -4.57616895e-02f, -5.36861643e-02f, -8.02974924e-02f, -2.16167979e-02f,
  -1.10760180e-03f, -4.59784232e-02f, -1.07879467e-01f, -6.42375723e-02f, 3.57698649e-04f, -7.92579651e-02f, -5.88810034e-02f, 6.64374605e-02f, 2.38773189e-02f, 1.00935129e-02f,
  -5.27759679e-02f, 8.31297338e-02f, 5.02781421e-02f, 2.22407002e-02f, 2.05896664e-02f, -1.25369299e-02f, -1.41963863e-03f, -3.04214284e-02f, -1.77772380e-02f, -5.87807642e-03f,
  5.07355332e-02f, -5.81387617e-03f, 2.12123804e-02f, -1.57366111e-03f, -4.65682186e-02f, 1.34276794e-02f, -1.79012585e-02f, 7.58703798e-02f, -9.18989927e-02f, -1.74530167e-02f,
  5.92572205e-02f, 1.55100614e-01f, -8.66888804e-05f, -7.49092102e-02f, 2.41762921e-02f, -1.01691775e-01f, -3.79087916e-03f, 9.41845924e-02f, 1.14374869e-01f, -2.19032951e-02f,
  2.89171655e-02f, 3.99412364e-02f, 4.47056629e-03f, -2.25717127e-02f, 3.08698844e-02f, -1.73183307e-02f, 2.31700833e-03f, -3.57218133e-03f, -7.62196109e-02f, 1.10139206e-01f,
  -3.08054797e-02f, -1.09733745e-01f, 3.49402688e-02f, -1.15095094e-01f, -6.42897487e-02f, -8.68033990e-02f, -3.06709949e-02f, -1.15279732e-02f, 6.50255159e-02f, 6.56119883e-02f,
  -1.03399828e-02f, 5.58533184e-02f, -1.04117550e-01f, 8.83423463e-02f, -9.77626517e-02f, -4.43463065e-02f, 5.19159809e-02f, 7.32142329e-02f, -5.50012738e-02f, 1.13774441e-01f,
  4.72967811e-02f, -7.26799816e-02f, -3.61705478e-03f, 1.45299748e-01f, 6.55112788e-02f, 9.46832672e-02f, 7.96710625e-02f, -6.42470131e-03f, -1.39002856e-02f, 6.62960410e-02f,
  1.03207439e-01f, 6.88099563e-02f, 1.14671856e-01f, -1.30361523e-02f, -9.87549499e-03f, 5.97383454e-02f, 1.17442399e-01f, -8.88535455e-02f, 6.77246228e-02f, 5.02932742e-02f,
  -5.49323820e-02f, 1.48285804e-02f, -2.64115315e-02f, -9.37308371e-02f, -1.01779420e-02f, 5.28807156e-02f, 2.86067743e-02f, -1.09418705e-01f, 3.30331177e-02f, 2.65478976e-02f,
  -5.15850037e-02f, 9.71397944e-03f, -2.85062101e-02f, 6.22971877e-02f, -8.77896603e-03f, 4.58908305e-02f, -5.50357774e-02f, -4.81603406e-02f, -1.29977223e-02f, -3.46831381e-02f,
  1.81506779e-02f, 8.34381208e-03f, -8.45247656e-02f, 1.41883194e-02f, -2.67956685e-03f, 2.91465148e-02f, 1.61949303e-02f, -1.00794788e-02f, -8.68595317e-02f, -5.42378947e-02f,
  -5.25405519e-02f, -6.66045770e-02f, 1.41301081e-02f, -2.72012688e-02f, -9.16441083e-02f, 1.32446773e-02f, -8.04422572e-02f, -8.00659657e-02f, 6.15105890e-02f, 2.35727839e-02f,
  6.45196140e-02f, 2.47936626e-03f, -2.11581565e-03f, 3.79352942e-02f, 4.63806987e-02f, 7.90005829e-03f, -8.03912506e-02f, 7.39132017e-02f, -6.98749498e-02f, -6.66140839e-02f,
  5.22071049e-02f, -5.49830236e-02f, -6.64917827e-02f, 7.87668601e-02f, 1.59113184e-02f, -3.16340365e-02f, -4.97332066e-02f, 3.60116456e-03f, -9.29691121e-02f, 7.80577213e-03f,
  1.01756133e-01f, 1.11700408e-01f, 3.19358259e-02f, -5.39148003e-02f, -3.89959710e-03f, -5.15259169e-02f, 7.71683455e-02f, 3.09795942e-02f, -2.00875048e-02f, -2.91837640e-02f,
  4.05583978e-02f, 3.78349237e-02f, -2.98509840e-02f, -6.68053925e-02f, -3.38094905e-02f, 1.84647162e-02f, -6.88245669e-02f, -1.21243177e-02f, 8.02186206e-02f, -3.00647169e-02f,
  3.07867080e-02f, 6.71007037e-02f, -9.25373510e-02f, -1.14109050e-02f, -2.64856350e-02f, -6.93935677e-02f, -1.94940381e-02f, 7.42633268e-02f, -7.79872388e-02f, 4.37738448e-02f,
  1.34956867e-01f, -5.93044981e-02f, -5.29690534e-02f, 7.90278763e-02f, -6.37075007e-02f, -1.03355423e-01f, -1.11014107e-02f, -1.63576752e-02f, -3.95433120e-02f, -1.51935905e-01f,
  -6.66229054e-02f, -4.96338308e-03f, -2.41340939e-02f, -1.18232459e-01f, 1.07885696e-01f, 6.28097281e-02f, -4.38441560e-02f, -8.23531002e-02f, 7.87418261e-02f, -1.01175971e-01f,
  9.99421552e-02f, -5.52590042e-02f, 6.94027767e-02f, 2.25787479e-02f, -3.69917750e-02f, 5.15956767e-02f, 2.89230738e-02f, -1.18105270e-01f, -2.29423953e-04f, 3.07758693e-02f,
  -3.16409692e-02f, 2.18309555e-02f, 5.94934337e-02f, 1.95379462e-02f, 6.47124723e-02f, -6.17443286e-02f, 5.72165884e-02f, 8.91985521e-02f, -7.21002296e-02f, 3.12347952e-02f,
  -5.28504550e-02f, -2.50188913e-02f, 4.71633747e-02f, 2.25441605e-02f, 2.90831644e-02f, -7.66883139e-03f, -2.31220163e-02f, -9.88809615e-02f, -7.28431717e-02f, 2.68259905e-02f,
  -1.12082355e-01f, 7.93835595e-02f, -7.06118345e-02f, -9.03817173e-03f, 1.27833188e-02f, 2.53164079e-02f, -2.32908148e-02f, 3.92944515e-02f, -5.17752916e-02f, -1.98384486e-02f,
  5.66028282e-02f, 4.94424552e-02f, 5.57843037e-02f, 4.23113890e-02f, 3.99632044e-02f, -2.41669845e-02f, 2.17354354e-02f, -2.17335802e-02f, 3.44024450e-02f, -1.33623346e-03f,
  -4.74613020e-03f, -1.90727375e-02f, 5.25551178e-02f, -3.42964306e-02f, 3.61384265e-02f, 1.24996398e-02f, -1.71504952e-02f, 2.62916051e-02f, -3.24056149e-02f, -5.78298140e-03f,
  -6.25104308e-02f, 1.03392050e-01f, -3.74342618e-03f, 2.45930851e-02f, -6.60242066e-02f, -6.25618994e-02f, 8.03766251e-02f, -3.17627974e-02f, 4.28322516e-02f, -4.02414724e-02f,
  5.46126328e-02f, -5.54352999e-02f, 2.23293751e-02f, 3.21185477e-02f, -1.87897757e-02f, -5.18950298e-02f, -1.08492710e-02f, 6.61940426e-02f, -5.99554554e-02f, -7.06346193e-03f,
  -1.63520612e-02f, 5.80131523e-02f, 3.17054503e-02f, -4.89208326e-02f, 4.35829274e-02f, -7.93224201e-02f, 4.84755673e-02f, -4.72459979e-02f, 6.86580688e-02f, 2.51381025e-02f,
  -1.94249991e-02f, -1.57025307e-02f, 9.87728983e-02f, 2.36470830e-02f, 2.06601433e-03f, 3.73798446e-03f, 1.58337352e-03f, -9.67239290e-02f, -2.90469900e-02f, -1.20607456e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 26)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 26;
const float L0_fan_Bp_bar_data[] = {
  1.17043421e-01f, 1.38140276e-01f, 7.20103532e-02f, 2.91061383e-02f, 1.31120216e-02f, 1.61072239e-01f, -3.49898003e-02f, 6.61937296e-02f, -2.19246261e-02f, 1.62148811e-02f,
  3.16991583e-02f, -4.78088669e-02f, -9.83670587e-04f, 6.24381863e-02f, 4.09843549e-02f, -2.29085609e-02f, -5.98303340e-02f, 8.96673948e-02f, -1.89542565e-02f, 3.33661102e-02f,
  1.08022571e-01f, 8.27874895e-03f, 4.09286693e-02f, -1.02083040e-02f, -2.43225452e-02f, -8.20598740e-04f
};

// L1_fan_Wp (Shape: 19 x 64)
const int L1_fan_Wp_rows = 19;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  1.55276835e-01f, 8.08168426e-02f, -3.59095931e-02f, 2.08452865e-02f, -1.60586238e-02f, -2.47268781e-01f, 1.21408798e-01f, 7.58609325e-02f, 7.88890123e-02f, -6.22512139e-02f,
  -6.51709363e-02f, -3.81685980e-02f, 4.54697162e-02f, 1.39839232e-01f, -6.04376197e-02f, 1.84320077e-01f, 1.57134347e-02f, 1.39210364e-02f, 6.84306324e-02f, -2.03604117e-01f,
  -2.25904986e-01f, -1.89120084e-01f, 6.73479736e-02f, 3.79232056e-02f, 3.44070554e-01f, 1.67284742e-01f, 5.38555123e-02f, 1.97084621e-01f, -2.02602521e-01f, -7.63950869e-02f,
  1.42948434e-01f, 1.50002301e-01f, 9.71037000e-02f, 1.09587140e-01f, -5.71935251e-02f, 1.11164518e-01f, 4.56068590e-02f, 1.05121806e-01f, -9.53007936e-02f, 1.24531686e-01f,
  8.81050713e-03f, 2.07911991e-02f, 5.58718480e-02f, 1.36945203e-01f, -3.67066376e-02f, -1.00536257e-01f, -2.74770498e-01f, 4.00440879e-02f, -6.93867495e-03f, 1.00100987e-01f,
  -3.38969305e-02f, 8.37890804e-02f, -4.74217273e-02f, -6.37411997e-02f, 5.55042699e-02f, 1.01450391e-01f, 7.13418052e-02f, -1.97934791e-01f, 1.93587080e-01f, 1.07377227e-02f,
  -1.92615464e-02f, 6.77079521e-03f, -2.55718995e-02f, 9.69807990e-03f, 6.33309036e-02f, -4.66535874e-02f, 5.81722409e-02f, 5.05309366e-02f, 1.87100887e-01f, -1.30559459e-01f,
  -8.46258774e-02f, -3.69926095e-02f, -1.53658062e-01f, -1.69950891e-02f, -7.59958029e-02f, -7.53333196e-02f, -6.30311221e-02f, -6.16671368e-02f, -1.34246707e-01f, 9.13687572e-02f,
  1.05394818e-01f, 1.03549554e-03f, -4.30829637e-02f, -3.29348356e-01f, -2.82872945e-01f, 1.20282620e-01f, -4.98067662e-02f, -4.23322767e-02f, -1.46518394e-01f, 1.42007083e-01f,
  1.57709002e-01f, -4.91148531e-02f, 4.97424714e-02f, 7.79451877e-02f, 2.08029270e-01f, 1.90273434e-01f, 5.97797744e-02f, -6.89328909e-02f, -1.25543222e-01f, -4.75100875e-02f,
  -1.15879700e-01f, -2.69929439e-01f, -1.06580742e-01f, -2.32245892e-01f, -3.90088814e-03f, -1.55812819e-02f, -1.08492143e-01f, -3.41721848e-02f, 4.72330600e-02f, 1.41056150e-01f,
  2.00247005e-01f, 2.41275970e-02f, 3.22508439e-02f, -2.32947618e-02f, -1.98856696e-01f, 5.54291706e-04f, 2.34923791e-02f, -1.22784086e-01f, 1.06277004e-01f, 1.16035499e-01f,
  7.27206916e-02f, 1.01636440e-01f, 2.78427266e-02f, -1.58811033e-01f, 8.35400820e-02f, 4.06677350e-02f, -1.55197904e-01f, -7.66039193e-02f, 2.16315299e-01f, -5.01871556e-02f,
  2.92162281e-02f, 4.54625823e-02f, 1.03387944e-01f, -2.03206539e-01f, -4.92177159e-02f, -5.44876568e-02f, -7.45297670e-02f, -5.38833514e-02f, 9.23940539e-02f, -2.86705252e-02f,
  1.57101855e-01f, -1.93676781e-02f, -3.03687546e-02f, 5.06709656e-03f, 1.02827743e-01f, 6.04044348e-02f, 1.10061979e-03f, -2.28783116e-01f, -8.48385841e-02f, -8.58591795e-02f,
  1.38506353e-01f, -1.53601214e-01f, 3.00045460e-02f, 1.72980782e-03f, 2.35332295e-01f, 1.97108224e-01f, -1.66780036e-02f, 3.30370404e-02f, 2.37615317e-01f, 2.25003749e-01f,
  -8.84935483e-02f, 7.32622668e-02f, 7.64123052e-02f, 2.01213777e-01f, 5.26590683e-02f, -3.32914181e-02f, -1.28721327e-01f, -1.18277565e-01f, -1.47398025e-01f, 8.99355561e-02f,
  -9.18815956e-02f, -1.81919355e-02f, -9.61499736e-02f, -5.71929254e-02f, -1.88543554e-03f, -1.71421945e-01f, 6.88549280e-02f, 5.72205521e-03f, -2.71954127e-02f, 1.33051679e-01f,
  -1.53571203e-01f, -1.17240921e-01f, 7.56967217e-02f, 3.65442969e-02f, -3.10326088e-02f, -3.71279903e-02f, -1.57797970e-02f, -5.12370430e-02f, -2.52744537e-02f, -1.57808155e-01f,
  -6.73015714e-02f, -1.76104143e-01f, -8.37466270e-02f, -2.23016143e-02f, 8.37103575e-02f, -9.29624736e-02f, -1.15622535e-01f, 6.27906322e-02f, -1.41480446e-01f, 3.03300135e-02f,
  4.52676453e-02f, -1.31471395e-01f, -2.88354140e-03f, -3.76949534e-02f, -9.91293713e-02f, -1.15455031e-01f, -1.11033700e-01f, 7.63758868e-02f, -1.23205353e-02f, 7.63092712e-02f,
  -4.39607166e-02f, -1.70950040e-01f, -2.12254062e-01f, 2.08609000e-01f, 4.92994254e-03f, 4.02023382e-02f, -9.24109370e-02f, 3.50063071e-02f, 1.26778945e-01f, -5.42602651e-02f,
  -5.92850260e-02f, -9.20051411e-02f, 1.00572743e-01f, -4.93194461e-02f, -1.23167445e-03f, 3.37153412e-02f, 8.69703963e-02f, -1.57426581e-01f, -2.83880625e-02f, -1.59686282e-01f,
  -1.73482329e-01f, -1.82843164e-01f, -6.06002398e-02f, -3.94183584e-02f, 8.39603096e-02f, 4.65629734e-02f, -2.07744427e-02f, -3.12523767e-02f, -8.01978037e-02f, -8.59475583e-02f,
  6.08172342e-02f, 7.11373538e-02f, -1.50852710e-01f, 3.81005276e-03f, 4.19113180e-03f, -4.01791893e-02f, 1.22815102e-01f, 7.46048018e-02f, 1.23851545e-01f, -1.87583026e-02f,
  4.68870029e-02f, 2.07755975e-02f, 9.43689570e-02f, 1.49497330e-01f, 9.66197774e-02f, -2.89288163e-02f, 9.49504375e-02f, -7.74514228e-02f, -7.60274827e-02f, 9.74826291e-02f,
  8.88478532e-02f, -1.59886241e-01f, 1.31946430e-01f, 2.04818584e-02f, -2.28400212e-02f, -1.64553642e-01f, -1.14036733e-02f, -1.53880030e-01f, -9.95801985e-02f, -3.91718838e-03f,
  3.20791751e-02f, -1.02306224e-01f, 5.94199859e-02f, 3.79577540e-02f, 8.38931128e-02f, -1.01665861e-03f, -1.51236311e-01f, -5.23299985e-02f, 3.64955105e-02f, -2.23179951e-01f,
  -5.52453548e-02f, 1.36137500e-01f, 7.86154047e-02f, 5.89586869e-02f, 1.22210450e-01f, -4.39644307e-02f, 2.41156787e-01f, -3.22472001e-03f, -1.30239516e-01f, -1.06444843e-01f,
  5.32451980e-02f, -9.21109393e-02f, 1.55641474e-02f, -1.60925880e-01f, -1.67870849e-01f, 1.22577243e-01f, 1.78528167e-02f, 7.84429535e-02f, 7.58689791e-02f, 1.32922148e-02f,
  8.39181915e-02f, -2.62939371e-02f, 1.25780895e-01f, 2.36676242e-02f, 1.49358526e-01f, -9.27618891e-03f, -2.00642068e-02f, 9.27142128e-02f, 1.29331335e-01f, -1.27838612e-01f,
  -2.99235117e-02f, 1.30681872e-01f, 2.38907393e-02f, 1.10812701e-01f, 2.11397275e-01f, 1.14958107e-01f, -4.87413071e-02f, -7.26667941e-02f, 8.10522735e-02f, 4.70422320e-02f,
  7.65578896e-02f, 6.52885437e-02f, -1.20600022e-01f, -2.94654015e-02f, 8.41277167e-02f, 2.97558866e-03f, 1.18463300e-01f, -1.96644869e-02f, -1.69263929e-02f, 2.09735762e-02f,
  7.07973093e-02f, -1.17840737e-01f, -2.87788957e-02f, -5.90812899e-02f, 3.80379111e-02f, 4.62908149e-02f, -4.54569645e-02f, 4.74303886e-02f, 1.74476057e-02f, -3.07472467e-01f,
  -9.23250020e-02f, 1.54903561e-01f, 1.44621998e-01f, -2.01612264e-01f, 5.05944826e-02f, 1.38936564e-01f, -6.50776848e-02f, -1.86838418e-01f, 1.88472688e-01f, 1.60067126e-01f,
  4.98782210e-02f, 4.57319990e-02f, -1.42278686e-01f, 8.21695477e-02f, 4.71232124e-02f, -1.36641428e-01f, -1.22706577e-01f, -1.35634482e-01f, -2.10277960e-01f, -1.29356757e-01f,
  -1.69336513e-01f, 1.76694959e-01f, 7.97591582e-02f, -1.82307288e-01f, -5.66866174e-02f, -6.99398518e-02f, 9.62742642e-02f, -8.18687957e-04f, -2.82786470e-02f, 4.93537188e-02f,
  1.12723149e-01f, 1.07492730e-01f, 6.56081587e-02f, 5.99617092e-03f, 7.76321813e-02f, 7.59300739e-02f, -3.79786827e-02f, 8.60714391e-02f, -4.73479480e-02f, -2.00271215e-02f,
  7.21630678e-02f, -2.01302357e-02f, -8.78161639e-02f, 7.17912242e-02f, 5.99416858e-03f, -2.29479168e-02f, -3.99121977e-02f, -9.24741700e-02f, -1.13178149e-01f, 4.75360081e-02f,
  -4.65701288e-03f, 2.02127304e-02f, -9.00960043e-02f, 7.70939961e-02f, 4.08664905e-02f, 9.06423032e-02f, 3.15105058e-02f, 7.37641379e-02f, -1.21359408e-01f, 3.55537944e-02f,
  -1.10052653e-01f, -4.37083170e-02f, -6.23446191e-03f, -2.23868527e-02f, 1.13849029e-01f, 2.04394817e-01f, 6.30722567e-02f, -1.54734164e-01f, -2.50106245e-01f, 1.31772682e-01f,
  1.53757796e-01f, -1.00742476e-02f, 1.38440607e-02f, -3.62534113e-02f, -3.19999665e-01f, 4.36658673e-02f, -1.42070174e-01f, -4.22257185e-02f, 8.77997205e-02f, -7.37092420e-02f,
  -9.73860696e-02f, -5.33092134e-02f, 1.00438014e-01f, -7.69733936e-02f, -1.20053358e-01f, 1.09437980e-01f, -6.88299115e-05f, -6.45056367e-02f, 1.19474672e-01f, 1.29566580e-01f,
  2.78715312e-01f, 7.70931765e-02f, -1.68286845e-01f, -7.49334618e-02f, 1.19421482e-01f, -3.00600063e-02f, -3.92372161e-02f, 8.37852657e-02f, -3.56575251e-02f, 4.04546876e-03f,
  1.06736332e-01f, 1.73630148e-01f, -6.30735457e-02f, 8.43848363e-02f, 9.79078654e-03f, -1.62389100e-01f, 9.66732204e-03f, -3.77706476e-02f, -2.79496498e-02f, 3.77135053e-02f,
  9.80923548e-02f, -9.30749699e-02f, 4.03888859e-02f, 5.15086465e-02f, 3.59677598e-02f, -2.44126446e-03f, 1.32642642e-01f, -1.41017258e-01f, 1.12789676e-01f, -1.56770984e-03f,
  -1.15016133e-01f, -1.23242766e-01f, -1.46181993e-02f, 1.81413174e-01f, 2.08475702e-02f, -1.02967024e-01f, -9.71346796e-02f, 2.27030069e-01f, -1.21399522e-01f, -3.78494188e-02f,
  -4.67161462e-02f, 1.60058036e-01f, -1.29853711e-01f, 2.97449440e-01f, 1.55103952e-01f, 2.49182791e-01f, 1.48445060e-02f, -3.45459804e-02f, -3.36593464e-02f, 6.07777312e-02f,
  2.85063200e-02f, -1.65686160e-01f, 2.62652105e-03f, 8.36872384e-02f, 6.87672049e-02f, -1.90060422e-01f, 5.94314300e-02f, -2.25013848e-02f, -5.52337952e-02f, -1.07700512e-01f,
  4.06141318e-02f, 4.62987227e-03f, -2.16610432e-02f, 1.53493285e-01f, 1.18283607e-01f, -8.91158432e-02f, 5.24204709e-02f, -4.17061001e-02f, -9.49000791e-02f, -5.78366965e-03f,
  1.15464635e-01f, -1.01380654e-01f, -1.11047186e-01f, -1.81622652e-03f, 1.27971098e-01f, 9.12312344e-02f, 9.79069993e-02f, -1.16314113e-01f, -2.89961812e-03f, 1.05095051e-01f,
  1.88736226e-02f, 3.69059034e-02f, 4.23217379e-02f, 1.26619354e-01f, -2.12136749e-02f, 2.12597921e-02f, 6.55312762e-02f, 1.95847824e-01f, 7.57090151e-02f, -3.78058068e-02f,
  -5.39504513e-02f, 1.53119594e-01f, 7.77709708e-02f, 2.08543185e-02f, 2.75261421e-02f, -4.75643203e-02f, 1.08723557e-02f, -3.06237675e-02f, -1.03875928e-01f, -2.57410556e-02f,
  4.35500480e-02f, 1.03886724e-01f, 1.55880317e-01f, 4.76073883e-02f, -5.73036224e-02f, 3.14098448e-02f, 1.47018805e-01f, -2.70279765e-01f, -1.04304619e-01f, -2.36501917e-01f,
  -7.35041797e-02f, 5.27523644e-02f, 7.61609944e-03f, -2.05414012e-01f, 1.11214146e-01f, 9.39549655e-02f, 4.28985283e-02f, -6.12307079e-02f, 1.59124583e-02f, 2.51028866e-01f,
  -2.93978071e-03f, 1.48236766e-01f, 8.38105381e-02f, 8.13388557e-04f, -3.71013433e-02f, -3.80017853e-04f, 7.24793691e-03f, 2.27276459e-02f, -8.25528204e-02f, -9.07246768e-02f,
  8.82793739e-02f, 9.86445248e-02f, 5.54141439e-02f, -1.61086917e-01f, -8.59862287e-03f, 1.42549023e-01f, -1.46872699e-01f, 3.22511978e-02f, 7.32151344e-02f, -5.28306812e-02f,
  -1.23663001e-01f, 9.34512466e-02f, -1.32909026e-02f, 1.21700026e-01f, -1.51994349e-02f, 2.29372866e-02f, 1.79245636e-01f, -1.32422805e-01f, -1.25670806e-01f, 4.73495759e-03f,
  -2.56030280e-02f, -7.28259683e-02f, 2.91435495e-02f, -9.19457525e-02f, -1.35425637e-02f, -3.93069461e-02f, -1.18310668e-01f, -1.72058821e-01f, -1.49549618e-02f, -5.49095310e-02f,
  -6.44009039e-02f, -2.45480105e-01f, -6.14753775e-02f, 7.61278626e-03f, 3.94955883e-03f, -1.04102209e-01f, 1.18185915e-01f, -2.30967671e-01f, 1.95940778e-01f, -1.73080400e-01f,
  -3.11903935e-02f, 6.86234795e-03f, -1.45812677e-02f, 8.90606865e-02f, -1.10911898e-01f, 9.76120029e-03f, 1.59545034e-01f, 7.25397915e-02f, -4.40418161e-02f, 4.36767675e-02f,
  2.41970137e-01f, 1.48682907e-01f, 5.08351885e-02f, 1.43417865e-01f, -5.31478040e-02f, 2.94250578e-01f, -5.68831228e-02f, -5.11149317e-02f, -1.22693609e-02f, -1.73429489e-01f,
  4.82573248e-02f, -1.14784800e-01f, -4.62034391e-03f, -2.15680767e-02f, -1.42823800e-01f, -4.96298112e-02f, 1.16444126e-01f, 5.01607582e-02f, 9.70154107e-02f, -1.12549841e-01f,
  -1.43839628e-01f, 3.94096822e-02f, -6.38632663e-03f, 3.04902140e-02f, 6.44445568e-02f, 9.22967419e-02f, -9.91912633e-02f, 1.37880584e-02f, 7.69068301e-02f, -1.46567881e-01f,
  2.26632148e-01f, -7.17167854e-02f, -2.58019511e-02f, 1.48825824e-01f, 2.00470269e-01f, -2.13781759e-01f, -6.70266971e-02f, 9.19439457e-03f, -5.59312589e-02f, -2.18444783e-02f,
  1.84601381e-01f, -8.42918903e-02f, 5.92672750e-02f, 5.66624589e-02f, -8.84516612e-02f, 1.66397706e-01f, 1.54797778e-01f, -3.26012075e-02f, 4.85585481e-02f, -3.08744133e-01f,
  -5.97650781e-02f, -1.63787216e-01f, 2.31189847e-01f, -2.64930189e-01f, 2.75763035e-01f, 2.70155948e-02f, 2.06728149e-02f, 1.29068151e-01f, -1.77889287e-01f, 3.59657127e-03f,
  2.01153070e-01f, 5.21916896e-02f, -7.40066096e-02f, 7.66526535e-02f, 6.04299642e-02f, 1.44339427e-01f, 4.27924395e-02f, 1.36334136e-01f, -3.20730098e-02f, 9.73091125e-02f,
  1.97134865e-03f, 7.98790306e-02f, -1.91126689e-01f, -1.56957984e-01f, 5.49152009e-02f, 1.37717957e-02f, -1.18576616e-01f, 1.21402722e-02f, -4.04675677e-02f, 3.19534540e-02f,
  3.40096131e-02f, 1.18490130e-01f, -9.88205671e-02f, -4.33972031e-02f, 1.56707734e-01f, 1.46691591e-01f, -1.82506636e-01f, -2.19940200e-01f, -1.76003762e-02f, -5.35287447e-02f,
  1.51309157e-02f, -1.74718097e-01f, -1.09763324e-01f, -8.77924040e-02f, -1.94989443e-01f, 1.45192698e-01f, 2.17816919e-01f, 4.62318026e-02f, -1.28568634e-02f, 9.99575108e-02f,
  -2.40295038e-01f, 9.07950476e-02f, 1.33502409e-01f, 6.93469569e-02f, 2.52634436e-02f, -4.69491584e-04f, 3.58337089e-02f, -3.28518078e-02f, 6.80755009e-04f, 3.72473872e-03f,
  1.04362316e-01f, 1.47668079e-01f, -5.73797040e-02f, 1.05804197e-01f, 4.17860001e-02f, -4.18443196e-02f, -2.40885347e-01f, 2.27686882e-01f, -3.48937437e-02f, -5.54746427e-02f,
  1.58829853e-01f, 1.57944798e-01f, -9.16686899e-04f, -1.67682245e-01f, -7.06495158e-03f, -8.98054913e-02f, 1.02784567e-01f, 9.83311012e-02f, -1.89875096e-01f, 1.39665663e-01f,
  -5.67550063e-02f, -1.02825575e-01f, 1.74681723e-01f, 4.43182047e-03f, 4.78884429e-02f, -1.52882949e-01f, -1.92530137e-02f, 1.53252348e-01f, -6.65614009e-02f, -4.69072685e-02f,
  -1.72555342e-01f, 1.58038773e-02f, 1.13650128e-01f, 1.33885920e-01f, -2.24574864e-01f, 2.55677570e-02f, -1.16282795e-02f, -1.10306226e-01f, -7.89671838e-02f, -4.54719663e-02f,
  1.73160911e-01f, -1.16452187e-01f, -6.36824071e-02f, 7.72568733e-02f, 4.66787331e-02f, 1.46205530e-01f, 3.07901041e-03f, -8.59194919e-02f, 1.99301943e-01f, -5.06916195e-02f,
  1.83455363e-01f, 9.06025991e-02f, -4.51299697e-02f, -1.55538216e-01f, 8.68354179e-03f, 1.03937477e-01f, -2.13217232e-02f, -6.60594404e-02f, -3.36032398e-02f, 1.05561437e-02f,
  1.63552299e-01f, -2.59698406e-02f, -1.48173243e-01f, 1.49829775e-01f, 3.74641679e-02f, -7.55266324e-02f, -7.94017836e-02f, -4.92556095e-02f, -8.54411423e-02f, -7.47539774e-02f,
  -1.31737679e-01f, -1.15083672e-01f, -8.34048539e-02f, 9.77590084e-02f, 1.90584213e-01f, 2.63468087e-01f, -1.21944226e-01f, -1.94517732e-01f, 1.21496029e-01f, 9.09049883e-02f,
  8.94175768e-02f, -6.36951551e-02f, 5.72647229e-02f, 1.46377549e-01f, 9.83517691e-02f, -2.09918678e-01f, -8.26254338e-02f, -1.47030920e-01f, -5.96577227e-02f, -9.94711071e-02f,
  -1.01476384e-03f, 1.53778657e-01f, 8.44708681e-02f, 6.16523847e-02f, 7.22035393e-02f, -1.27741992e-01f, 1.00808859e-01f, 8.90570208e-02f, 3.79627571e-02f, 1.34026244e-01f,
  -6.62891120e-02f, -2.94460151e-02f, -5.67435585e-02f, 8.87380242e-02f, 4.81786281e-02f, 7.72441030e-02f, 1.38470516e-01f, -7.23761842e-02f, -4.48636711e-02f, 1.52300328e-01f,
  8.71116519e-02f, -6.74608871e-02f, 1.94372416e-01f, 2.13113382e-01f, 1.38750970e-01f, 1.71383381e-01f, 2.04229757e-01f, 1.67849921e-02f, -8.61936063e-03f, -7.57331997e-02f,
  -7.20569193e-02f, -6.90834373e-02f, -2.61690132e-02f, 5.40379025e-02f, 1.73298553e-01f, 8.16903934e-02f, 1.06224872e-01f, 1.34961903e-01f, -5.68848336e-03f, 3.65956537e-02f,
  -3.28210108e-02f, -3.69521528e-01f, -2.13102013e-01f, 6.92130104e-02f, -8.23739171e-02f, -4.60336581e-02f, -1.15582064e-01f, -5.44489436e-02f, 1.41451746e-01f, 3.25425640e-02f,
  -9.77876037e-02f, -3.72472708e-03f, 5.58564067e-02f, 2.61648029e-01f, 1.34494109e-02f, 3.64778116e-02f, 8.66515338e-02f, 2.85507943e-02f, -5.68936802e-02f, -1.51952386e-01f,
  -1.38544524e-02f, -9.12272632e-02f, -8.92671272e-02f, 8.85523036e-02f, 7.25733116e-02f, -1.69606328e-01f, -6.89256340e-02f, 2.67928969e-02f, -9.85538960e-02f, 4.71988842e-02f,
  -1.83471441e-01f, 1.83778102e-04f, -9.04165283e-02f, 1.24518730e-01f, -6.22008108e-02f, 2.01296457e-03f, -4.19847369e-02f, -9.64266155e-03f, -4.62497659e-02f, -9.30544510e-02f,
  -1.37393415e-01f, 4.65778224e-02f, 8.79729614e-02f, -1.33921960e-02f, -1.45042062e-01f, 2.80717649e-02f, 1.93556771e-01f, 1.08796969e-01f, -5.77310435e-02f, 6.45116717e-02f,
  -2.73856819e-02f, 5.72771057e-02f, 4.56443354e-02f, -2.05073245e-02f, 1.80152413e-02f, 1.56562030e-02f, 3.46528813e-02f, -7.86503255e-02f, 1.10479891e-01f, 7.92581239e-04f,
  8.37149918e-02f, 4.15146910e-03f, -8.80782157e-02f, -1.97898522e-02f, -1.49981240e-02f, -2.46264055e-01f, 8.61243997e-03f, 6.50672987e-02f, 7.51902461e-02f, -1.34400055e-01f,
  -2.45554462e-01f, -3.82859819e-02f, 1.25806555e-01f, -2.45186225e-01f, -1.64716113e-02f, 4.16339114e-02f, -2.04665646e-01f, -5.97990826e-02f, -2.23514944e-01f, -8.47678408e-02f,
  1.12676714e-02f, -1.14735045e-01f, -1.58513069e-01f, -1.41828030e-01f, -1.25511974e-01f, 4.10545282e-02f, -7.63332099e-02f, 1.13365740e-01f, 3.81847732e-02f, -2.54219204e-01f,
  4.63345647e-03f, 3.92639302e-02f, 2.78790027e-01f, -3.62765379e-02f, -5.12352102e-02f, 1.72753595e-02f, -2.79870890e-02f, -2.40968987e-02f, 1.81097224e-01f, -5.19374833e-02f,
  7.95739517e-02f, 6.08309992e-02f, -1.78112209e-01f, -5.34823947e-02f, -1.82559162e-01f, -1.16599627e-01f, -8.21655989e-02f, -4.70391214e-02f, -4.90025096e-02f, -7.95254856e-02f,
  1.81481123e-01f, 1.61315501e-02f, -6.39270172e-02f, -4.98773903e-02f, -3.19165587e-02f, 2.68139150e-02f, 5.37798554e-02f, 1.94616187e-02f, -1.15697019e-01f, 5.86408600e-02f,
  1.40296787e-01f, 9.62926224e-02f, 7.87717327e-02f, 3.04986797e-02f, 1.25156995e-02f, 5.16499989e-02f, -1.82646466e-03f, 1.03334032e-01f, -4.76871803e-02f, -6.44552037e-02f,
  1.24416895e-01f, -1.83151543e-01f, -2.02133320e-03f, -2.14153871e-01f, 1.00184448e-01f, -1.63215585e-02f, -6.48124814e-02f, -1.10532142e-01f, -8.29463676e-02f, -2.77419835e-02f,
  -4.93127406e-02f, -1.03633061e-01f, -1.41072303e-01f, 1.50491983e-01f, 9.06733200e-02f, -8.03156383e-03f, -4.79181074e-02f, 1.06295682e-01f, 9.43516791e-02f, 2.12036952e-01f,
  4.88273129e-02f, -8.55543837e-03f, -1.07929945e-01f, -2.07645208e-01f, -7.27107450e-02f, -1.32707581e-01f, -4.76802886e-02f, -7.91905746e-02f, -1.35613844e-01f, -1.55279860e-01f,
  1.39713466e-01f, -2.41119359e-02f, 7.99878594e-03f, 6.89057633e-02f, -8.14242586e-02f, 8.94094631e-02f, -9.83764231e-02f, -1.79742761e-02f, 2.12553935e-03f, 6.92922398e-02f,
  -1.00319743e-01f, -9.28806067e-02f, 2.57897619e-02f, 1.58324726e-02f, 6.25066052e-04f, 1.16910577e-01f, -5.98802604e-02f, 3.41255441e-02f, -5.60183637e-02f, -6.47515208e-02f,
  -8.13182036e-04f, -7.39319623e-02f, -4.71118093e-02f, -4.10981849e-02f, -7.43263811e-02f, -4.86573763e-02f, -1.27854988e-01f, 1.20474890e-01f, 1.39827982e-01f, 1.58453912e-01f,
  -3.48710977e-02f, 2.18543336e-02f, 3.15759629e-02f, 8.45254958e-02f, -1.50595248e-01f, -5.43351844e-02f, 9.44456365e-03f, 1.61013439e-01f, 2.11239263e-01f, -1.72914267e-01f,
  -8.19371268e-02f, 1.04322694e-01f, -9.69506241e-03f, 2.10777614e-02f, 1.55830428e-01f, -6.40578791e-02f, 2.71615952e-01f, 2.35225484e-01f, 8.25556926e-03f, 8.04661363e-02f,
  -1.21290676e-01f, 7.64028952e-02f, 1.11065030e-01f, -7.55536407e-02f, -3.06426212e-02f, -1.43369511e-01f, -1.17008589e-01f, 2.17256233e-01f, -5.12660667e-02f, -1.27107138e-02f,
  -2.96222925e-01f, 4.90270853e-02f, -5.93081601e-02f, -4.01309282e-02f, -1.84495047e-01f, -1.17673695e-01f, -1.61997899e-01f, 1.19762301e-01f, 7.42446212e-03f, -5.54049648e-02f,
  3.25220427e-03f, -2.51502872e-01f, 4.36764695e-02f, 5.54220490e-02f, -1.11063356e-02f, 2.64088120e-02f, -1.02400012e-01f, 5.78934960e-02f, -3.75282019e-02f, -2.49985978e-03f,
  7.59882703e-02f, 4.83975969e-02f, 3.65506895e-02f, -5.28436229e-02f, 1.40578553e-01f, 3.22793685e-02f, -1.17706433e-01f, 2.05243547e-02f, 1.26252845e-01f, -5.40205054e-02f,
  1.26969919e-01f, 1.30909085e-01f, 1.56303972e-01f, -5.83673175e-03f, 7.24667385e-02f, -4.74980474e-02f, 7.25923777e-02f, 7.28604272e-02f, 2.03586578e-01f, -1.47941962e-01f,
  3.30722518e-02f, -1.88689217e-01f, 1.16845250e-01f, -5.02368696e-02f, 4.60595563e-02f, -5.34459464e-02f, 3.95175852e-02f, -6.07717782e-02f, -1.57913223e-01f, -1.20949872e-01f,
  -3.34058888e-02f, 4.94289510e-02f, 1.71302602e-01f, 1.72071345e-02f, -1.07265925e-02f, 9.50922072e-02f, 1.85196102e-01f, 1.60899222e-01f, -3.23168077e-02f, -1.22256756e-01f,
  -1.11506470e-01f, -8.26694965e-02f, -9.18000750e-03f, -1.10750422e-01f, -6.87966049e-02f, 1.73279550e-02f, -1.52986884e-01f, -1.03549093e-01f, -1.88831543e-03f, -6.85012341e-02f,
  -1.11093551e-01f, -3.40329879e-03f, 8.16996954e-03f, 5.69037944e-02f, -5.22115193e-02f, -1.95491880e-01f, -1.58543855e-01f, -1.43277217e-02f, -3.04568224e-02f, -1.55838907e-01f,
  -5.98457009e-02f, -1.27612323e-01f, 7.17293024e-02f, -3.95974889e-02f, 1.44765839e-01f, -6.58740178e-02f, -5.18368706e-02f, -1.86275244e-01f, -2.00640857e-01f, 4.01963741e-02f,
  -1.04895517e-01f, -1.19262390e-01f, -7.10527077e-02f, -2.11042702e-01f, 7.96507113e-03f, -1.78712517e-01f, -8.54187906e-02f, 1.31371945e-01f, 1.14589207e-01f, -9.18197855e-02f,
  -1.54018968e-01f, -2.89536570e-03f, -2.86606878e-01f, -1.45531418e-02f, -1.11271236e-02f, -9.21366084e-03f, -1.21113747e-01f, 2.02136889e-01f, 2.40103126e-01f, 2.51282364e-01f,
  -1.35752887e-01f, -2.58657217e-01f, 1.56195626e-01f, 2.21937731e-01f, 1.91743061e-01f, 1.37199551e-01f, 7.20936060e-02f, 9.17466283e-02f, -2.57932041e-02f, -3.88074084e-03f,
  2.39341017e-02f, -7.05241784e-02f, -9.46115609e-03f, 4.26588673e-03f, 1.12896850e-02f, 1.22062609e-01f, -1.35268539e-01f, 1.02015898e-01f, -9.79065225e-02f, -6.04930446e-02f,
  8.57438147e-03f, -3.32606048e-03f, 5.05023301e-02f, -2.08510575e-03f, -1.21138982e-01f, -1.43234611e-01f, 1.18931383e-01f, -1.42408893e-01f, -4.20594066e-02f, -3.24897096e-02f,
  1.46213070e-01f, -3.57085802e-02f, 3.63342315e-02f, 5.73620573e-02f, 5.89897893e-02f, -6.86158463e-02f
};

// L1_fan_Wp_bar (Shape: 26 x 64)
const int L1_fan_Wp_bar_rows = 26;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  2.67724488e-02f, 2.01121122e-02f, -2.04138923e-02f, 4.22880165e-02f, 9.67700109e-02f, 1.23664685e-01f, -7.30069354e-02f, -6.06287643e-03f, 1.44179584e-02f, -5.21490946e-02f,
  -1.85007008e-03f, -6.71931356e-02f, 6.33053035e-02f, 4.84113172e-02f, -7.24757314e-02f, 9.67900306e-02f, -7.84803107e-02f, 1.79881230e-02f, 5.33216912e-03f, 3.73601727e-02f,
  1.09260686e-01f, 3.47137935e-02f, -4.54528332e-02f, 6.04608953e-02f, 1.93633363e-01f, -2.02067971e-01f, 2.18520276e-02f, -1.07703879e-01f, -5.77848218e-02f, -6.39034659e-02f,
  -3.07410397e-02f, -4.58884016e-02f, -2.08402909e-02f, 7.20539391e-02f, -1.15794465e-01f, -6.69536069e-02f, -6.47462383e-02f, 1.86196715e-01f, 8.30961168e-02f, -3.42023298e-02f,
  3.24141234e-02f, -4.64665145e-02f, 2.81424709e-02f, 1.63946405e-01f, 1.04907677e-01f, 8.65785405e-02f, -1.16226129e-01f, 9.63313058e-02f, 1.42600968e-01f, 8.38577226e-02f,
  1.19010769e-02f, -4.37419899e-02f, -1.18996715e-02f, 6.19726926e-02f, -4.03252840e-02f, 2.35009305e-02f, -4.49578837e-02f, 2.49525663e-02f, 6.25220314e-03f, -5.54688722e-02f,
  2.13456284e-02f, 1.34058505e-01f, 4.64576706e-02f, 4.34923768e-02f, 1.39998898e-01f, 1.04300985e-02f, 1.30319238e-01f, 1.20622739e-01f, 1.13431878e-01f, 1.52165890e-01f,
  9.24729705e-02f, 1.24674089e-01f, -6.70127347e-02f, 2.24980544e-02f, 1.89939097e-01f, 1.38548017e-01f, 7.39714056e-02f, -2.22865399e-02f, -5.42226760e-03f, -7.00652748e-02f,
  1.18799113e-01f, 2.35328395e-02f, 1.76263139e-01f, 6.43696040e-02f, 1.30781814e-01f, 9.56573039e-02f, -5.74877225e-02f, -1.74472287e-01f, -8.26445073e-02f, 1.11267582e-01f,
  1.52383074e-01f, -5.05937636e-02f, -2.63081118e-02f, -5.30321114e-02f, -2.78081566e-01f, -6.56155348e-02f, -1.72659412e-01f, -2.01351851e-01f, 4.62134602e-03f, -9.51787457e-02f,
  2.64236834e-02f, 7.18049556e-02f, -5.40957339e-02f, 7.65399933e-02f, -7.12281987e-02f, -8.37254971e-02f, 7.44737238e-02f, 1.26781715e-02f, 2.66894121e-02f, 1.30345970e-01f,
  1.75724879e-01f, 7.68599892e-03f, 1.60283297e-02f, 5.77258207e-02f, 6.82697073e-02f, 3.72694954e-02f, 1.14849791e-01f, 6.99418038e-02f, 3.92080285e-02f, -8.92233625e-02f,
  -1.35270610e-01f, -8.52386132e-02f, -3.74803059e-02f, 3.91668975e-02f, -6.48948252e-02f, -9.24764946e-02f, -4.50171940e-02f, -6.51263893e-02f, 6.51096106e-02f, 1.46668136e-01f,
  1.71498895e-01f, 6.39680028e-02f, 1.94990724e-01f, -2.21335307e-01f, 2.25476269e-02f, 6.81348816e-02f, 9.73076075e-02f, 1.48324639e-01f, 9.92183089e-02f, 4.77274694e-02f,
  1.45969674e-01f, 2.52132654e-01f, -4.03856672e-02f, 2.02222094e-01f, 2.53044218e-01f, 6.59366474e-02f, 1.99191377e-01f, -8.43816996e-02f, -1.77121997e-01f, -8.02924931e-02f,
  -2.78348550e-02f, -3.59678455e-02f, 1.92056701e-01f, 2.14915529e-01f, 1.75315768e-01f, 2.49755263e-01f, -2.47339711e-01f, 3.02585922e-02f, 2.25215822e-01f, 2.74599522e-01f,
  -4.31406647e-02f, 3.42670679e-02f, 2.36851741e-02f, 1.37811691e-01f, 9.23466831e-02f, -2.09071189e-01f, -1.27530307e-01f, 4.01152149e-02f, -1.14171997e-01f, 1.59361765e-01f,
  -1.42728761e-01f, 1.98759228e-01f, -1.31200284e-01f, -2.64547560e-02f, 3.53496298e-02f, -1.39277130e-01f, -5.26686348e-02f, 1.16580948e-01f, -1.23300888e-01f, 2.73643225e-01f,
  5.41779399e-02f, -1.26872003e-01f, 1.25367835e-01f, 1.17233075e-01f, -1.07688732e-01f, -1.32392794e-01f, 1.49766773e-01f, 2.19319351e-02f, -4.24040779e-02f, -5.28273098e-02f,
  5.27330190e-02f, -1.43702269e-01f, -1.16913341e-01f, -5.96585236e-02f, 2.16763839e-03f, -1.08753838e-01f, -2.37599071e-02f, 1.10426888e-01f, -7.76634365e-02f, -1.27678961e-01f,
  -4.28430475e-02f, 5.70864305e-02f, -3.89006292e-03f, 9.02101099e-02f, -1.11152157e-02f, -3.90542671e-03f, -1.85297821e-02f, -1.16947651e-01f, -1.17203526e-01f, -9.68285576e-02f,
  -1.13482781e-01f, -4.20749262e-02f, -4.56910804e-02f, -9.22073796e-03f, -1.08102888e-01f, 3.16111036e-02f, 1.00934945e-01f, 5.87154329e-02f, -3.04717682e-02f, 7.69169405e-02f,
  5.48029095e-02f, 4.73911837e-02f, -2.74040606e-02f, -4.77170460e-02f, -5.84984571e-02f, -3.88552025e-02f, -7.74098486e-02f, 6.73834980e-02f, -7.42183104e-02f, 7.77497813e-02f,
  -9.06181708e-03f, -1.24421872e-01f, 1.25157729e-01f, 4.52854745e-02f, 8.21356755e-03f, -3.70813236e-02f, 3.40254009e-02f, 1.11956246e-01f, 1.28066412e-03f, 1.50372675e-02f,
  -5.22784591e-02f, -7.47333840e-02f, -2.42593400e-02f, -1.18278019e-01f, 7.23204166e-02f, -1.20664336e-01f, -3.34096164e-03f, -6.79915100e-02f, -7.10935742e-02f, 6.72794580e-02f,
  9.90408510e-02f, -4.70805317e-02f, 8.48724097e-02f, -4.43488955e-02f, 5.65813892e-02f, 9.11279693e-02f, 8.22636113e-02f, 1.24688614e-02f, 1.00696079e-01f, 5.02570122e-02f,
  -5.29200546e-02f, 2.16092348e-01f, -4.64217849e-02f, 3.68311293e-02f, 1.30324259e-01f, 1.31503612e-01f, 1.75844148e-01f, 1.79760754e-01f, 1.14621054e-02f, -1.22204572e-01f,
  1.96186408e-01f, -1.30470157e-01f, 8.54550302e-02f, 3.91749926e-02f, -1.14655077e-01f, 3.73245418e-01f, 2.09378853e-01f, 7.23292604e-02f, -1.37588277e-01f, 1.04731344e-01f,
  -1.71894416e-01f, 1.10785790e-01f, 7.78205767e-02f, -8.68600421e-03f, 1.43939644e-01f, -1.14742652e-01f, -1.59475029e-01f, -1.04856089e-01f, -4.76003736e-02f, -1.16330326e-01f,
  2.02121977e-02f, 1.51381522e-01f, 8.06175321e-02f, 1.66852206e-01f, 1.20656289e-01f, 1.31229609e-01f, 1.59461439e-01f, -1.45493940e-01f, 1.13703601e-01f, 2.20704302e-01f,
  1.17327698e-01f, -3.82683687e-02f, -2.93765683e-02f, -1.04470029e-01f, 1.82969600e-01f, 7.90302306e-02f, 2.23237693e-01f, -9.34208408e-02f, -2.55628470e-02f, 2.10510492e-01f,
  -9.07632858e-02f, -1.18003085e-01f, 1.17903858e-01f, 1.68547079e-01f, -1.68206319e-02f, -7.98860285e-03f, -4.12328318e-02f, 1.35860071e-01f, 1.10782951e-01f, 1.05697609e-01f,
  -6.55057281e-02f, -1.23316169e-01f, -1.33351967e-01f, 1.03575394e-01f, 1.32079376e-02f, -1.87961720e-02f, 2.60046907e-02f, 6.89983368e-02f, 7.06018955e-02f, -8.02833140e-02f,
  -1.30559802e-01f, 1.12385847e-01f, -1.16254590e-01f, 7.80208781e-02f, -7.95079842e-02f, 1.32752553e-01f, 8.97070169e-02f, -7.51841217e-02f, -2.49177832e-02f, -9.61103197e-03f,
  -3.35154869e-02f, -3.09205242e-02f, 5.04617393e-02f, 3.89407314e-02f, 3.37308906e-02f, -6.51338324e-02f, 6.29317611e-02f, 3.42425480e-02f, 1.60814933e-02f, 1.90213136e-02f,
  -1.00441985e-01f, 5.74711785e-02f, -8.56109932e-02f, -1.24993496e-01f, 3.50939669e-02f, -1.25990719e-01f, -7.73253441e-02f, -9.43670049e-02f, 3.99503410e-02f, -3.01273409e-02f,
  -1.08364716e-01f, -4.00355691e-03f, -8.85531902e-02f, -9.47936624e-02f, 7.28607178e-02f, -3.59750576e-02f, 2.07396016e-01f, 9.89550874e-02f, 6.54702187e-02f, 1.17064714e-02f,
  8.28284472e-02f, -5.20831980e-02f, 1.66480273e-01f, 9.18490142e-02f, -2.17803493e-02f, 3.94286588e-02f, -1.86841711e-02f, 1.31171122e-01f, 1.52519152e-01f, 3.46582159e-02f,
  1.20522015e-01f, 7.74475336e-02f, 2.88307723e-02f, 1.15277981e-02f, 5.30383028e-02f, 9.94458571e-02f, -5.02679758e-02f, 1.45646945e-01f, 4.55311909e-02f, 1.10087372e-01f,
  -1.99738592e-02f, 6.71212701e-03f, 4.63513061e-02f, -6.57793060e-02f, -4.73432131e-02f, -4.63015661e-02f, 9.26357210e-02f, 7.51034617e-02f, -1.01536825e-01f, 1.69557691e-01f,
  5.71977794e-02f, 1.72761723e-01f, -2.01401766e-03f, -9.50433835e-02f, -1.12747580e-01f, -2.78016869e-02f, 3.18466616e-03f, -4.53538960e-04f, 2.76258253e-02f, -1.51323438e-01f,
  1.02070414e-01f, -5.37966974e-02f, -1.10394336e-01f, 8.64315704e-02f, -1.65023692e-02f, 1.37773499e-01f, 1.47310302e-01f, -2.60390248e-02f, -8.26694965e-02f, -1.93450227e-01f,
  7.11964816e-02f, -1.81638785e-02f, -1.39216259e-01f, -7.07974657e-02f, -3.46732326e-02f, -1.27223525e-02f, -4.70644906e-02f, 5.22540659e-02f, 3.93321477e-02f, -1.51429456e-02f,
  2.34154463e-01f, 1.44146949e-01f, 1.07056543e-01f, 1.36613458e-01f, -9.67728123e-02f, 2.42795926e-02f, 1.17885627e-01f, 4.93881777e-02f, 4.25569993e-03f, -1.65707115e-02f,
  4.50338274e-02f, 2.14963585e-01f, -1.21377945e-01f, 2.25845315e-02f, 1.65643524e-02f, -8.22405890e-02f, -7.29013979e-02f, 1.04089558e-01f, -1.37414530e-01f, 1.35381028e-01f,
  2.06261232e-01f, 1.59384459e-01f, 2.05811337e-01f, 2.15394109e-01f, -2.37121925e-01f, 2.99485610e-03f, 3.27810273e-02f, 2.02594828e-02f, -3.91953066e-03f, 6.81972206e-02f,
  -6.32767379e-02f, 6.28281310e-02f, 1.64009377e-01f, 1.84836105e-01f, -9.98901762e-03f, 1.68468401e-01f, 1.55442655e-01f, -1.07322663e-01f, 1.66570500e-01f, 6.66022748e-02f,
  -3.81092168e-02f, 2.19666660e-01f, 2.21880883e-01f, -2.65327841e-01f, -1.71236217e-01f, 7.52824470e-02f, -1.81607798e-01f, -7.95119330e-02f, -9.38536152e-02f, -1.62279382e-01f,
  1.60105631e-01f, 1.72742978e-01f, -2.49204174e-01f, -1.74698934e-01f, 1.54770305e-03f, 1.80677757e-01f, 2.00439304e-01f, -1.94073692e-01f, 1.50318041e-01f, -5.26187792e-02f,
  1.11925006e-01f, 1.78251654e-01f, 3.44674550e-02f, -2.41565444e-02f, 3.20001915e-02f, 1.65346235e-01f, 1.29473239e-01f, 1.69796526e-01f, -6.48315623e-02f, 5.92746884e-02f,
  1.21815158e-02f, -4.09222487e-03f, -7.21346363e-02f, -3.35927308e-02f, 9.12753642e-02f, -7.40430970e-03f, -6.45699799e-02f, 1.11997366e-01f, 1.53973937e-01f, 1.05525374e-01f,
  -8.09890777e-02f, 1.29037753e-01f, 1.84811577e-02f, -3.56435999e-02f, 8.16448312e-03f, 8.65344033e-02f, 1.04456827e-01f, -1.55543322e-02f, 1.99010372e-01f, 8.90864506e-02f,
  4.72030565e-02f, 1.79591268e-01f, 6.26538321e-02f, -3.96004654e-02f, -3.49427797e-02f, 1.29617333e-01f, 7.25287646e-02f, 5.10979742e-02f, 1.33687943e-01f, 6.59552366e-02f,
  1.09820135e-01f, 5.77233033e-03f, 1.56331345e-01f, -7.11977035e-02f, 1.32077068e-01f, -1.04524031e-01f, 1.08608946e-01f, 2.90242210e-02f, 8.49086139e-03f, -9.30346996e-02f,
  1.18203284e-02f, -4.62465249e-02f, -7.54525885e-02f, -1.34423515e-02f, -1.78411941e-03f, 2.72242576e-02f, 3.94707266e-03f, -2.36945134e-02f, -3.14137451e-02f, -6.88191280e-02f,
  1.57868937e-01f, 1.45782113e-01f, 5.73307872e-02f, -8.43329728e-02f, 7.68451169e-02f, 4.69651446e-02f, -1.05440274e-01f, 4.31949645e-02f, -1.30370378e-01f, -1.08982511e-01f,
  -2.27464754e-02f, -1.87431630e-02f, -7.57022277e-02f, 6.20993460e-03f, -7.77558535e-02f, 2.86256243e-02f, 3.69843654e-02f, 2.48740129e-02f, 1.29463181e-01f, 3.51935998e-02f,
  8.23764876e-02f, 2.00392492e-02f, -9.03181732e-02f, -1.25397205e-01f, -4.79893386e-02f, 5.45810089e-02f, 7.52317160e-02f, -7.25712162e-03f, 4.69417730e-03f, 1.66505620e-01f,
  4.40148674e-02f, -4.29481305e-02f, -6.60899803e-02f, 6.77203611e-02f, 1.11824676e-01f, 7.82459378e-02f, 1.43702477e-01f, 1.29105464e-01f, 5.66830561e-02f, 9.73140169e-03f,
  -6.53706864e-02f, -1.88245401e-02f, 1.54301003e-01f, 1.85430303e-01f, -8.25296938e-02f, -1.12333804e-01f, -8.57306719e-02f, 1.56969592e-01f, 8.18331093e-02f, -1.00240611e-01f,
  1.36690969e-02f, 8.50351229e-02f, 1.92343995e-01f, -1.58543270e-02f, -6.50693253e-02f, -8.79675969e-02f, -1.19428761e-01f, 6.03541881e-02f, 6.40208125e-02f, -1.35657683e-01f,
  8.44610035e-02f, -1.25446841e-01f, 9.24992487e-02f, -8.51846635e-02f, 9.48207304e-02f, -3.30832303e-02f, 1.08027376e-01f, 4.58396748e-02f, 5.60915582e-02f, -2.16858536e-02f,
  5.04831783e-02f, 1.59830257e-01f, 2.31866036e-02f, 1.00245690e-02f, -1.01720296e-01f, 1.43780693e-01f, -6.96790591e-02f, -3.72946635e-02f, 5.21965325e-02f, -8.04239437e-02f,
  -5.52492663e-02f, 8.11361149e-02f, 4.17230651e-02f, 9.10886377e-02f, -1.09732486e-01f, -1.78283341e-02f, 6.41262382e-02f, -9.90769938e-02f, 4.57621142e-02f, 4.20940667e-02f,
  -1.05505206e-01f, -1.32980302e-03f, 7.07527623e-02f, 8.38484466e-02f, 2.11911187e-01f, 6.93425015e-02f, -1.66306064e-01f, 6.69531077e-02f, 6.66656271e-02f, 2.13366225e-01f,
  1.25060886e-01f, 1.00498676e-01f, 1.37934312e-01f, 7.33646303e-02f, 1.16045855e-01f, 1.87520251e-01f, -3.99348530e-04f, -2.83493958e-02f, -1.84290428e-02f, 1.14768304e-01f,
  7.92317763e-02f, -2.66106665e-01f, 2.43291538e-02f, 2.25508437e-01f, 3.65182161e-01f, -2.59792089e-01f, -1.58534184e-01f, 1.78542525e-01f, -2.08283275e-01f, -6.60376623e-02f,
  2.21267402e-01f, -6.02370535e-04f, 1.40142471e-01f, 8.48621652e-02f, -3.15645374e-02f, -3.56432609e-02f, 1.30176440e-01f, 2.05549598e-01f, 2.44846046e-01f, -1.61498748e-02f,
  -4.10430552e-03f, -6.15202375e-02f, 1.96182095e-02f, 1.98558643e-01f, -6.25466853e-02f, -2.37390343e-02f, -8.69876668e-02f, -3.07687465e-02f, 1.08323306e-01f, 3.13246287e-02f,
  1.07439362e-01f, 1.05655402e-01f, -2.20873170e-02f, 8.89812708e-02f, -6.75578639e-02f, -3.11305132e-02f, 1.84887856e-01f, -2.06434429e-02f, 4.23202552e-02f, 2.96791596e-03f,
  -6.88014477e-02f, -1.19990788e-01f, -1.14941962e-01f, 1.68040201e-01f, 1.81374505e-01f, 1.44173518e-01f, -1.49509963e-02f, 5.77735007e-02f, 1.16598971e-01f, 3.11168302e-02f,
  2.28576995e-02f, -3.75840347e-03f, 1.47710219e-01f, 1.45701960e-01f, 5.92770427e-02f, 8.10403451e-02f, 1.98682144e-01f, -4.96938825e-02f, -7.87583068e-02f, -2.44944380e-03f,
  3.44009250e-02f, 1.69977203e-01f, -6.62159175e-02f, 3.98954190e-02f, 6.52676299e-02f, -1.79029867e-01f, 5.21846414e-02f, -7.95580819e-02f, -4.41316403e-02f, 1.64014593e-01f,
  4.45509702e-02f, -5.86339273e-03f, -1.65774509e-01f, -1.31003574e-01f, -1.63457461e-03f, 9.15496349e-02f, -5.78501076e-02f, -9.83774960e-02f, -4.84211650e-03f, 2.06342265e-01f,
  1.22799844e-01f, -1.03110932e-01f, -1.68434214e-02f, -3.01407613e-02f, -7.00857639e-02f, -5.03455587e-02f, 1.21335156e-01f, -3.74415815e-02f, -2.83858106e-02f, 1.00935929e-01f,
  4.69573885e-02f, -8.42754990e-02f, 2.83321831e-02f, 3.85312065e-02f, 5.75026684e-02f, 8.26602653e-02f, -4.36469615e-02f, -6.26606643e-02f, 6.18878677e-02f, 1.16597101e-01f,
  -4.76463512e-02f, -4.46784683e-02f, -1.13539156e-02f, 2.77041793e-02f, 5.39686494e-02f, -6.71728253e-02f, 7.33126700e-02f, 8.06436464e-02f, -3.21851037e-02f, -4.31323564e-03f,
  5.05932570e-02f, -8.95531923e-02f, 7.67298564e-02f, 6.30160123e-02f, 1.14134699e-02f, 2.39143539e-02f, -3.69109586e-02f, 4.36914526e-03f, 4.88421358e-02f, -7.16765150e-02f,
  8.29232708e-02f, 8.78130645e-02f, 1.83346053e-03f, 1.11781545e-01f, 3.02427672e-02f, -1.36240683e-02f, -5.77221029e-02f, -1.06501356e-01f, 1.21965997e-01f, -1.44095227e-01f,
  9.39399377e-02f, -2.45691873e-02f, 1.19554088e-01f, -9.19379815e-02f, -9.68215242e-02f, -4.30944040e-02f, 4.01937868e-03f, -9.81372073e-02f, -2.23983657e-02f, -1.72115281e-01f,
  5.50953783e-02f, -1.03008300e-01f, 1.16118096e-01f, 1.10305242e-01f, -2.88077835e-02f, 8.55979621e-02f, 4.04072665e-02f, 3.84571054e-03f, -5.98498248e-02f, -1.03117071e-01f,
  3.92903127e-02f, 4.68130559e-02f, 1.18488647e-01f, -1.28816381e-01f, 6.90501481e-02f, 5.00912555e-02f, -1.30531648e-02f, -1.00810774e-01f, 3.85306627e-02f, 1.18866339e-01f,
  1.15218773e-01f, -6.30612448e-02f, -1.11025900e-01f, 1.31774992e-02f, -7.79754445e-02f, -2.75102793e-03f, -7.68266991e-02f, -6.27309904e-02f, 7.50918090e-02f, 1.10106267e-01f,
  5.68172075e-02f, 7.48563483e-02f, -4.69267182e-02f, 1.93449222e-02f, 5.80302738e-02f, -4.37909067e-02f, -1.15012892e-01f, -8.12460929e-02f, -1.20833494e-01f, 1.18125482e-02f,
  -3.14973742e-02f, 1.10054575e-01f, 1.05748855e-01f, 1.22926477e-02f, 3.74310724e-02f, 6.94895983e-02f, -3.11799627e-02f, -1.25591353e-01f, -9.69691947e-02f, -1.01742558e-01f,
  -3.67420889e-03f, 1.07276037e-01f, 8.36584195e-02f, -3.76992812e-03f, -7.42437616e-02f, 1.23913333e-01f, 6.20425828e-02f, 7.21983537e-02f, -2.83156522e-02f, -2.83815973e-02f,
  -6.49864599e-02f, 7.38795325e-02f, 2.32874062e-02f, -8.73553008e-02f, -9.55366343e-02f, -2.01934371e-02f, -1.51157733e-02f, 1.01254724e-01f, -1.03555709e-01f, 9.02215987e-02f,
  -8.06301981e-02f, 1.11983605e-02f, 9.37086418e-02f, 1.60707235e-02f, 9.77179930e-02f, -1.08124778e-01f, -7.73540186e-03f, 9.21733305e-02f, 2.32485402e-02f, 1.11485548e-01f,
  -9.52253789e-02f, 2.72207633e-02f, -3.89167219e-02f, 3.65787260e-02f, -9.00808349e-02f, 2.44328752e-03f, -9.15391594e-02f, -1.65163781e-02f, -1.23216987e-01f, -2.43704338e-02f,
  -1.11778624e-01f, -3.21621858e-02f, 7.42696524e-02f, 5.25044836e-02f, 4.03695218e-02f, -5.23686372e-02f, -8.81026238e-02f, 4.81489934e-02f, 5.14929779e-02f, -7.39337504e-02f,
  -1.14967287e-01f, 1.41778499e-01f, 1.00248381e-01f, 1.57386839e-01f, 6.61345571e-02f, 1.29170448e-01f, -6.32783324e-02f, 1.23779312e-01f, 2.61089262e-02f, 1.43536041e-02f,
  1.13278605e-01f, 1.10999137e-01f, 3.61256562e-02f, -5.42424340e-03f, -5.13874646e-03f, 9.93042737e-02f, -9.33413133e-02f, -1.60730164e-02f, 1.78225830e-01f, 2.85352450e-02f,
  2.60721855e-02f, 1.25769332e-01f, 2.35916208e-02f, -1.11986071e-01f, 1.20530520e-02f, -1.77571587e-02f, 1.73700988e-01f, 9.46691930e-02f, 1.54871568e-01f, 6.87092915e-02f,
  1.35230541e-01f, 1.45954803e-01f, 8.12389627e-02f, -1.62654016e-02f, 1.33682996e-01f, 5.39571419e-02f, 1.40291020e-01f, 9.53325033e-02f, -4.32611741e-02f, 1.43934608e-01f,
  4.11049537e-02f, 3.22214551e-02f, -9.87025127e-02f, 1.04247339e-01f, 9.98293236e-02f, -9.06284600e-02f, 1.86835453e-02f, -3.18036638e-02f, 1.69372912e-02f, -8.24340507e-02f,
  1.68804801e-03f, 1.02174886e-01f, 1.11752316e-01f, 1.46813720e-01f, 2.46197045e-01f, 1.46782994e-01f, -1.04012147e-01f, 8.78585950e-02f, 1.23472176e-01f, 4.45191227e-02f,
  2.71989387e-02f, -9.08358023e-02f, 5.05987629e-02f, -9.37062278e-02f, -8.61841291e-02f, 6.36405870e-02f, -2.25811992e-02f, 1.53925151e-01f, 8.10160022e-03f, 2.11797282e-02f,
  7.46336207e-02f, 7.58679360e-02f, 6.58451468e-02f, 5.06448559e-02f, 5.17999232e-02f, 4.08847034e-02f, 1.50706500e-01f, -5.69702312e-02f, 1.39011687e-03f, 1.54894084e-01f,
  1.49871781e-01f, 8.65134522e-02f, -9.89646912e-02f, 1.41298875e-01f, -1.10168472e-01f, 1.25743717e-01f, 1.87512394e-02f, 5.90712279e-02f, 7.34221786e-02f, -1.33012205e-01f,
  -5.68344705e-02f, -1.33762136e-01f, -1.03115164e-01f, -7.42531791e-02f, -1.39879033e-01f, 1.89977035e-01f, -1.02417506e-01f, -9.99710560e-02f, 2.01740131e-01f, 1.47472620e-01f,
  1.51827157e-01f, -1.15122363e-01f, -5.70403337e-02f, 2.32821479e-01f, -6.86760386e-03f, 6.16152957e-02f, -1.08079068e-01f, -1.87572371e-02f, 5.76219857e-02f, 1.60519481e-02f,
  1.27554506e-01f, -1.07036188e-01f, -1.05134897e-01f, -3.82845327e-02f, 8.34757015e-02f, -6.31398857e-02f, -4.20746841e-02f, 6.98899031e-02f, 8.43393281e-02f, 2.98809763e-02f,
  -6.88645616e-02f, 6.98479787e-02f, 7.71161616e-02f, -6.79911599e-02f, -1.07657358e-01f, 9.77894813e-02f, -7.04163103e-04f, -1.04550958e-01f, 7.91599303e-02f, 4.11279537e-02f,
  2.42022742e-02f, -9.99256149e-02f, 4.05544899e-02f, -7.61536211e-02f, 2.94324476e-02f, 5.10927215e-02f, -9.70197618e-02f, -1.14095043e-02f, 1.40366908e-02f, 4.10949774e-02f,
  -1.97184831e-02f, -1.19359657e-01f, 3.15398313e-02f, 1.76675562e-02f, 3.09010148e-02f, 1.06402032e-01f, 7.55888596e-02f, -4.54499573e-02f, 3.17518115e-02f, 1.57531295e-02f,
  -8.97311792e-03f, -5.68660460e-02f, 1.10505335e-01f, -9.02273729e-02f, -3.99674177e-02f, 1.47006451e-03f, -1.00599378e-01f, 1.05545275e-01f, 7.64368922e-02f, -5.92458360e-02f,
  -1.07188977e-01f, -6.14337213e-02f, -1.56743340e-02f, 4.23657754e-03f, -8.67357031e-02f, -8.91204365e-03f, 4.13776450e-02f, -4.33903225e-02f, -4.44172975e-03f, 6.21642210e-02f,
  -5.12749441e-02f, 7.97165856e-02f, -1.09698147e-01f, -1.04502074e-01f, -1.23812556e-01f, 9.40951928e-02f, -8.20184946e-02f, 9.86935720e-02f, -7.08962455e-02f, 1.00960605e-01f,
  9.00485590e-02f, -2.71505862e-02f, 1.00664079e-01f, -3.34601551e-02f, -8.77591074e-02f, -1.39912851e-02f, 5.90875447e-02f, 2.40982566e-02f, -1.27614275e-01f, -1.52846929e-02f,
  6.90959692e-02f, 1.21764749e-01f, -1.11706808e-01f, 1.30284443e-01f, 8.35838392e-02f, -2.49601789e-02f, 9.27188322e-02f, -7.91494548e-02f, -3.91467959e-02f, -1.12107480e-02f,
  -1.11295193e-01f, -4.03946154e-02f, 4.66582701e-02f, -2.46469136e-02f, -1.15414262e-01f, 1.22742482e-01f, 1.01041637e-01f, -5.76724745e-02f, 5.53799346e-02f, 1.04648888e-01f,
  6.57034889e-02f, 4.92734388e-02f, -4.16251309e-02f, 6.89892173e-02f, -2.96456758e-02f, 8.45874399e-02f, 7.02149123e-02f, 9.87915173e-02f, -2.92050410e-02f, 4.21542153e-02f,
  1.11782342e-01f, 8.82354975e-02f, -5.24887927e-02f, -9.41606089e-02f, -1.79128945e-02f, -8.95754248e-02f, 7.88024589e-02f, 3.23941484e-02f, -1.21805176e-01f, -5.63236065e-02f,
  -7.72912577e-02f, -3.19327638e-02f, -9.75558385e-02f, 8.97221714e-02f, -3.80417705e-02f, -6.58700392e-02f, 1.08727604e-01f, -5.21648414e-02f, 4.57653496e-03f, 1.05727859e-01f,
  1.37634575e-01f, -1.50373923e-02f, 1.17605656e-01f, 7.86475465e-02f, -8.66272300e-02f, 1.19945869e-01f, -4.87396009e-02f, 7.94871449e-02f, -1.05690822e-01f, -9.65099931e-02f,
  -7.95043074e-03f, -7.88780972e-02f, -6.74197078e-03f, 1.01249002e-01f, -1.26111016e-01f, 1.18841477e-01f, 3.34298387e-02f, 8.68876204e-02f, 3.87742847e-01f, 3.38574387e-02f,
  2.01803714e-01f, 5.97327165e-02f, 1.72198951e-01f, 1.86483189e-01f, 6.73927069e-02f, 3.15493464e-01f, 2.82827467e-01f, 1.10419542e-01f, 1.53619736e-01f, 4.40128930e-02f,
  2.68412113e-01f, -7.30843991e-02f, 1.98497623e-02f, -3.12832177e-01f, 2.66918004e-01f, -2.11649500e-02f, 3.55322272e-01f, 1.34008408e-01f, -2.50836760e-01f, -1.47750929e-01f,
  1.26837924e-01f, 2.04018965e-01f, 1.60133466e-01f, -1.33480981e-01f, -1.38415292e-01f, 1.53217688e-01f, 1.77304879e-01f, 1.59553543e-01f, 4.18292582e-02f, 1.41200274e-01f,
  -9.39626917e-02f, 3.91260833e-01f, 1.46378741e-01f, 1.57180101e-01f, -7.50075504e-02f, 6.04259335e-02f, -1.36346780e-02f, -1.76099256e-01f, -2.35313714e-01f, 7.78079927e-02f,
  1.93519723e-02f, -2.09443681e-02f, 1.22363679e-02f, -2.57465709e-02f, -3.68008725e-02f, -3.68746221e-02f, 8.19659010e-02f, 2.19442323e-01f, -8.99406970e-02f, 1.52746346e-02f,
  3.05068344e-01f, 9.19996724e-02f, -7.83675164e-02f, 1.85618609e-01f, 5.08400574e-02f, 8.59025028e-03f, -1.75276981e-03f, -5.55750467e-02f, -8.24151710e-02f, -2.91204993e-02f,
  1.66992486e-01f, -1.54926591e-02f, 1.31058633e-01f, -3.79679985e-02f, -3.52272205e-02f, 7.48591945e-02f, 1.45098969e-01f, 2.08474640e-02f, 1.99742466e-02f, 5.62979765e-02f,
  1.65752620e-01f, 1.52616754e-01f, 9.96333584e-02f, -2.63365189e-04f, -5.56917936e-02f, 2.45296657e-02f, -1.36766523e-01f, -5.23421653e-02f, 1.50417671e-01f, -9.72610116e-02f,
  7.77618438e-02f, 1.27450243e-01f, 1.34749666e-01f, 2.31571179e-02f, -1.33423612e-01f, -1.41258419e-01f, 2.93308832e-02f, 8.07264075e-03f, -1.25542417e-01f, 5.64762652e-02f,
  2.37247646e-02f, 1.66438699e-01f, -5.73423542e-02f, -8.12153518e-02f, -1.59448143e-02f, -1.81264784e-02f, 1.13536507e-01f, -3.54624651e-02f, 8.31301045e-03f, -4.64102030e-02f,
  -6.65913597e-02f, 6.20178021e-02f, -1.01383209e-01f, -6.13444448e-02f, -4.99677137e-02f, -9.16286036e-02f, 1.07489578e-01f, 4.35457975e-02f, 7.59067982e-02f, 6.92142621e-02f,
  1.34163409e-01f, 9.24843773e-02f, 1.06249616e-01f, -1.21731520e-01f, 1.87725395e-01f, -6.21109903e-02f, 9.58980173e-02f, 1.83240585e-02f, 8.94116685e-02f, -6.18999936e-02f,
  -7.78428838e-02f, 1.48929190e-02f, -5.40594198e-03f, -9.62099507e-02f, -4.90361638e-03f, -6.32875189e-02f, -2.37138420e-02f, -1.12708755e-01f, -8.08077529e-02f, 9.37172547e-02f,
  -8.85202065e-02f, -2.02654349e-03f, -1.39819188e-02f, 1.83221493e-02f, 2.97010168e-02f, -5.66097200e-02f, -2.46309824e-02f, 2.16340460e-02f, -1.05212249e-01f, -7.76269212e-02f,
  1.08351953e-01f, 1.18898293e-02f, 1.01375744e-01f, -1.07937254e-01f, 6.87852874e-02f, -6.66179657e-02f, 9.52327773e-02f, 1.16383590e-01f, 4.99973185e-02f, -1.05844580e-01f,
  -7.27939531e-02f, -1.07918166e-01f, -1.05062947e-01f, -6.08603191e-03f, 2.13763434e-02f, 2.96825953e-02f, 3.52281146e-02f, -3.59503143e-02f, 1.39738977e-01f, -8.24782550e-02f,
  -2.89254598e-02f, -6.91310242e-02f, 1.11810993e-02f, 1.02344520e-01f, -5.96878454e-02f, -1.22070260e-01f, 1.18108809e-01f, 7.50089064e-02f, -5.62380590e-02f, 6.47613953e-04f,
  -8.32600817e-02f, 1.49488961e-02f, -7.70210251e-02f, 1.21955037e-01f, 5.40041924e-02f, -2.41374616e-02f, 1.06318071e-01f, -1.04247279e-01f, -1.05720358e-02f, 1.15463361e-01f,
  1.10266037e-01f, 5.87764429e-03f, -9.79503840e-02f, -6.52054790e-03f, -6.44877478e-02f, 7.76106119e-02f, 2.10571918e-03f, 8.31035674e-02f, -1.05084136e-01f, 5.15024103e-02f,
  6.61154091e-02f, 1.18033811e-01f, 5.55149093e-02f, 2.55844388e-02f, 1.92966893e-01f, -4.80730496e-02f, 9.41229388e-02f, 1.28109097e-01f, 1.36654556e-01f, -3.96629833e-02f,
  -5.63765690e-02f, 1.12559825e-01f, 6.39457405e-02f, 2.23272845e-01f, -1.29105926e-01f, -9.33574811e-02f, -1.12895193e-02f, 9.71225873e-02f, -2.10421056e-01f, 3.58572640e-02f,
  1.65996686e-01f, 2.03717366e-01f, 9.86897722e-02f, -6.43075705e-02f, 9.68634188e-02f, 4.50511426e-02f, -2.61617117e-02f, -4.31459174e-02f, -3.13908271e-02f, 2.04744875e-01f,
  -1.00041449e-01f, -1.29381642e-01f, 1.31874427e-01f, -5.15675619e-02f, 4.17283922e-02f, 1.13375694e-01f, 1.47833958e-01f, 1.59247920e-01f, 6.79669604e-02f, 6.57436997e-02f,
  -8.58429074e-02f, 3.35124917e-02f, 1.52642235e-01f, 4.71351370e-02f, -1.13033272e-01f, 1.02601210e-02f, 9.14912075e-02f, -3.99593301e-02f, -1.26702920e-01f, 1.11653216e-01f,
  -4.00274396e-02f, 2.19032122e-03f, 3.25614400e-02f, 1.26052335e-01f, 4.92302738e-02f, 4.39821705e-02f, 1.05058786e-03f, -1.14544399e-01f, -1.98693182e-02f, -8.18758458e-02f,
  1.11483775e-01f, -6.41646981e-02f, 2.38133948e-02f, -5.23490906e-02f, 4.28565703e-02f, -4.39856648e-02f, 3.55595276e-02f, 4.86352071e-02f, 1.14307813e-01f, -4.14999090e-02f,
  1.37376234e-01f, 5.51816355e-03f, -6.78196549e-02f, -1.00283325e-01f, -5.19484580e-02f, 9.78541821e-02f, 1.44525720e-02f, -4.17048223e-02f, 5.17336316e-02f, -7.02498183e-02f,
  -8.40617195e-02f, 8.05467889e-02f, -1.47912920e-01f, 1.03080846e-01f, 1.57809064e-01f, -2.89094821e-02f, -8.17038864e-02f, -5.18829711e-02f, -3.09940260e-02f, 3.73507254e-02f,
  -8.65642726e-02f, -8.69134739e-02f, -5.57622612e-02f, 1.09986059e-01f, 1.09552667e-01f, -1.40222073e-01f, 9.56008509e-02f, 1.29054293e-01f, 1.00338839e-01f, 1.07737251e-01f,
  1.17999062e-01f, -1.25279933e-01f, 9.42428410e-02f, -5.11470363e-02f, 1.39429569e-01f, -1.28244311e-01f, -1.06217466e-01f, 5.47727309e-02f, -8.87223259e-02f, 9.91769731e-02f,
  -1.05341621e-01f, 5.79205453e-02f, -4.20363806e-02f, 9.82184708e-02f, 1.09053403e-01f, 1.00715989e-02f, -7.43031874e-02f, -1.04680344e-01f, -3.51631641e-02f, -8.33100919e-03f,
  -2.37811711e-02f, -1.35195464e-01f, 1.96025111e-02f, -2.43536178e-02f, 2.26515710e-01f, -7.51023665e-02f, -5.65322638e-02f, 2.50864804e-01f, -1.39563426e-01f, -1.58223715e-02f,
  2.22691968e-01f, 1.27857864e-01f, 1.09728627e-01f, 1.30971953e-01f, -2.35239998e-03f, 1.17221646e-01f, 1.37111023e-01f, -1.11085884e-01f, 1.00774750e-01f, 9.94729716e-03f,
  -5.46145998e-02f, 2.20083058e-01f, 2.83702433e-01f, -3.62775549e-02f, -1.65488154e-01f, 1.36756793e-01f, -1.02851637e-01f, -2.19100118e-01f, 9.45513472e-02f, 3.78073789e-02f,
  -1.71982974e-01f, -7.43758753e-02f, -1.77584291e-01f, -1.14407755e-01f, -2.67560296e-02f, 9.12161022e-02f, -2.07344040e-01f, 1.27284855e-01f, -7.74319917e-02f, 2.10042194e-01f,
  2.89736390e-01f, 2.54087020e-02f, 9.49087739e-02f, -1.45557925e-01f, 7.55134150e-02f, 1.47879437e-01f, 5.84819131e-02f, 6.26863912e-02f, 4.79525775e-02f, -5.51927201e-02f,
  -2.68265810e-02f, 8.41592848e-02f, -4.22791354e-02f, 9.50481743e-02f, -2.84779407e-02f, 1.86917372e-02f, -1.90670177e-01f, 3.26396450e-02f, 1.88281909e-02f, -1.27791792e-01f,
  -1.56452715e-01f, -7.41537437e-02f, 2.78989095e-02f, -9.48565677e-02f, 1.28814697e-01f, -2.35454813e-02f, -1.00410908e-01f, 4.89750914e-02f, 1.39736444e-01f, 1.41796529e-01f,
  -5.53813055e-02f, 3.14053968e-02f, 5.58289625e-02f, 1.95663944e-01f, -3.09699625e-02f, -2.55654100e-02f, 1.61975488e-01f, -1.97654087e-02f, 1.48924604e-01f, -1.30499993e-02f,
  7.37622902e-02f, 1.21649787e-01f, 3.71011123e-02f, 9.86056775e-02f, 1.80674478e-01f, -1.17113173e-01f, -7.72355869e-02f, 2.16829509e-01f, -4.72994670e-02f, 1.23955071e-01f,
  -1.74764127e-01f, 1.20134309e-01f, -8.15581903e-02f, -1.08375221e-01f, 1.22792922e-01f, 2.87804566e-02f, -1.27702534e-01f, 1.56415358e-01f, 8.05795342e-02f, -7.98846483e-02f,
  -2.10314095e-02f, -3.19064446e-02f, -1.28186330e-01f, -1.81333646e-01f, -1.09544341e-02f, -1.80737078e-01f, 6.31250441e-02f, 1.26343012e-01f, -7.58084096e-03f, -3.75103876e-02f,
  -3.68190557e-02f, 1.44318938e-01f, -4.54344861e-02f, -4.10145409e-02f, -8.82486440e-03f, 1.15545258e-01f, -1.58549577e-01f, -6.21525906e-02f, 1.08471125e-01f, 8.01758021e-02f,
  -1.50589505e-02f, 1.09296560e-01f, -7.71287158e-02f, -2.46366020e-02f, -1.16922185e-02f, 1.00316741e-01f, 1.28584430e-02f, 4.46659848e-02f, 7.29560480e-02f, 6.22880161e-02f,
  -8.48510116e-02f, 1.14811435e-01f, -9.77340266e-02f, -7.92128295e-02f, -4.94593009e-02f, -9.60751921e-02f, 1.38860123e-04f, -4.99531850e-02f, 4.02270071e-02f, 5.33769913e-02f,
  1.15643308e-01f, -9.48642418e-02f, 1.76594816e-02f, -3.37454975e-02f, 3.71537954e-02f, 9.64470506e-02f, 1.21284515e-01f, -1.06298558e-01f, 1.21303737e-01f, 9.01864395e-02f,
  2.87554003e-02f, -1.30281851e-01f, 1.28184762e-02f, -8.48761424e-02f, -1.12336218e-01f, 2.73399483e-02f, -1.05760224e-01f, -4.19063605e-02f, 3.66446376e-02f, 5.29686734e-02f,
  -1.05646849e-01f, 1.08417854e-01f, -2.52743680e-02f, 5.44950590e-02f, 1.10271983e-02f, 7.02252761e-02f, 1.15771785e-01f, -4.44813492e-03f, -6.51626289e-02f, 2.10707150e-02f,
  6.18555173e-02f, -3.52232940e-02f, -1.52088003e-02f, 1.06466413e-01f, 7.24772587e-02f, -1.17094874e-01f, 9.60952416e-02f, -1.56550277e-02f, 1.33097291e-01f, -9.17336717e-02f,
  -9.73214507e-02f, -7.99017698e-02f, -2.91059911e-02f, 5.69161475e-02f, -9.99152735e-02f, 1.34737357e-01f, -2.92004533e-02f, -9.87438709e-02f, -1.75399985e-03f, -7.22497702e-02f,
  -5.79476766e-02f, 6.56269491e-02f, 4.44540791e-02f, -1.04727857e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 26)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 26;
const float L1_fan_Bp_bar_data[] = {
  -6.33449182e-02f, 9.28003639e-02f, 2.41310865e-01f, -1.15309983e-01f, -7.53107760e-03f, -6.86466470e-02f, 1.01977259e-01f, 1.28660232e-01f, -4.88404594e-02f, -5.23944385e-03f,
  7.80699551e-02f, 9.45731811e-03f, 3.14165913e-02f, -8.01510811e-02f, -3.45823653e-02f, 1.60719045e-02f, -1.00749461e-02f, -9.40550789e-02f, 1.23942256e-01f, 8.30796361e-02f,
  -3.17990854e-02f, 6.33907691e-02f, -1.87171586e-02f, 1.75479963e-01f, 1.36405781e-01f, 2.56129578e-02f
};

// L2_fan_Wp (Shape: 19 x 64)
const int L2_fan_Wp_rows = 19;
const int L2_fan_Wp_cols = 64;
const float L2_fan_Wp_data[] = {
  2.61894632e-02f, -5.55337034e-02f, -6.97560515e-03f, -2.55184788e-02f, -5.75653762e-02f, 2.33933376e-03f, -8.55077356e-02f, -4.20117341e-02f, 1.43901154e-01f, -1.52878195e-01f,
  -1.19639806e-01f, -1.23291157e-01f, 8.03752840e-02f, 8.17442238e-02f, 6.49408773e-02f, 6.15458563e-02f, -1.45597100e-01f, 6.75658090e-03f, 1.42424151e-01f, -2.44314551e-01f,
  7.03637153e-02f, -1.84594050e-01f, 1.07065894e-01f, 9.50122923e-02f, -1.42418191e-01f, 1.91358596e-01f, 2.56318510e-01f, -1.14478052e-01f, -3.17110531e-02f, -2.35937983e-01f,
  1.80698391e-02f, 1.48250163e-01f, -5.38414828e-02f, -5.69596738e-02f, -1.89729378e-01f, -1.10238098e-01f, -1.87855288e-01f, 1.03708049e-02f, -9.90798026e-02f, 1.55204386e-01f,
  6.39452934e-02f, -1.06206387e-01f, 3.53809297e-02f, 6.28321171e-02f, -1.56870391e-02f, -2.13963408e-02f, 6.93664104e-02f, -1.44806458e-02f, -5.34896851e-02f, -4.52153832e-02f,
  -9.19102728e-02f, -2.58179028e-02f, 5.61457202e-02f, 1.26747116e-01f, -1.02665447e-01f, 8.05159509e-02f, -2.03982249e-01f, -1.48539290e-01f, -9.61365327e-02f, 6.81200251e-02f,
  5.65775260e-02f, -3.56545113e-02f, -1.95360463e-03f, -8.95389020e-02f, 1.13194190e-01f, 2.52571523e-01f, -5.95913641e-02f, 2.13429838e-01f, 1.41551811e-02f, -5.54372706e-02f,
  7.70898443e-03f, -2.67058164e-02f, -4.62840497e-02f, -1.18595436e-01f, -3.51188146e-02f, -1.10964343e-01f, -3.49124521e-03f, 2.57340875e-02f, -7.90815726e-02f, -5.98934805e-03f,
  2.69644279e-02f, -5.14936745e-02f, -3.89751755e-02f, 1.25797033e-01f, 9.67205614e-02f, -1.05624953e-02f, 3.19459200e-01f, 7.24058673e-02f, -1.72198359e-02f, -1.65029734e-01f,
  3.17370892e-02f, 3.38597968e-02f, -2.15105414e-01f, -1.96740478e-01f, -2.26211529e-02f, -1.50709838e-01f, 7.63503686e-02f, 1.19941890e-01f, -2.63993353e-01f, 1.84834898e-01f,
  -2.30655670e-01f, 8.98290947e-02f, -2.36945190e-02f, -3.21613415e-03f, -8.19927156e-02f, 3.98898311e-02f, 7.15119485e-03f, 5.08577339e-02f, 1.97971225e-01f, 2.39330217e-01f,
  -1.27627715e-01f, 8.53212997e-02f, -1.34051934e-01f, -1.70749024e-01f, 3.68705839e-02f, 2.63938643e-02f, 5.34850126e-03f, -7.13632628e-02f, 2.51990203e-02f, 2.83800391e-03f,
  -9.45256799e-02f, -1.58427149e-01f, -9.58269015e-02f, -8.02513212e-02f, 9.12699755e-03f, -1.55266717e-01f, 1.27423927e-01f, -1.22904301e-01f, 9.58293825e-02f, 7.30582476e-02f,
  3.36608588e-04f, 2.24857107e-02f, -1.42145753e-02f, -2.09249351e-02f, -2.79893745e-02f, -1.16111655e-02f, 9.49425697e-02f, 7.05128303e-03f, 9.02847052e-02f, -1.42746046e-01f,
  -4.64493409e-02f, -5.92587367e-02f, -1.46219330e-02f, -9.16070193e-02f, 3.04977763e-02f, 9.79727805e-02f, 1.86056525e-01f, -5.00450172e-02f, 1.48134364e-03f, -1.90213807e-02f,
  1.11407503e-01f, 2.83796731e-02f, -5.71253970e-02f, -7.20789880e-02f, 9.68918651e-02f, 8.99437815e-02f, 4.93706055e-02f, -1.95393026e-01f, 1.99247807e-01f, 1.73206091e-01f,
  5.92242032e-02f, -9.82633531e-02f, -2.13323832e-02f, 9.09740329e-02f, -1.58931732e-01f, 3.65209617e-02f, 1.01918757e-01f, -4.04468589e-02f, 8.67168903e-02f, 8.43223333e-02f,
  2.20826283e-01f, -8.54014307e-02f, 7.84395933e-02f, 8.34225565e-02f, -1.36439323e-01f, 8.54403060e-03f, -8.18814412e-02f, -2.33396087e-02f, 9.65558887e-02f, -3.94187942e-02f,
  -6.85733110e-02f, 1.46962911e-01f, -8.90392587e-02f, 1.70203261e-02f, -2.04701930e-01f, -8.01797435e-02f, 3.91362561e-03f, 1.65940389e-01f, 7.72209316e-02f, 1.91166818e-01f,
  3.83645631e-02f, -7.15812370e-02f, -1.40468121e-01f, -2.20477179e-01f, -1.52751082e-03f, 2.57936511e-02f, 7.31212124e-02f, -3.57553326e-02f, 5.04480712e-02f, 3.85501646e-02f,
  4.03573923e-02f, -2.32957527e-02f, -4.50116135e-02f, 1.38092950e-01f, -3.72216129e-03f, 5.26798479e-02f, -1.55876717e-02f, -2.26256978e-02f, -3.48319821e-02f, -9.06034783e-02f,
  -1.54267401e-01f, -1.00582406e-01f, -5.41113056e-02f, -9.03167203e-02f, -4.56421636e-02f, 1.34575173e-01f, 1.18204094e-01f, 7.82606304e-02f, -1.63874850e-01f, 9.56573114e-02f,
  -3.28045860e-02f, -1.05971053e-01f, -2.76386142e-01f, -1.56688064e-01f, -1.93762690e-01f, -8.59508514e-02f, 1.61812380e-01f, 1.94064602e-02f, 1.01168416e-02f, -2.29816124e-01f,
  -9.18648317e-02f, -4.86537591e-02f, -8.62441882e-02f, 9.66299474e-02f, 1.10296614e-01f, 1.38991013e-01f, 9.15703550e-02f, -1.56274810e-01f, 5.18678762e-02f, -1.30187869e-01f,
  -1.20240636e-02f, -1.55996397e-01f, 2.57797036e-02f, -5.54718263e-02f, 2.02903405e-01f, -8.25876072e-02f, -1.18037552e-01f, 5.81058897e-02f, 3.76023740e-01f, -3.25418450e-02f,
  1.26742497e-02f, -1.26966005e-02f, -1.94013268e-01f, -1.83404416e-01f, 4.41553481e-02f, 4.74688336e-02f, -1.29272804e-01f, -2.26349398e-01f, -1.14613682e-01f, 9.42114070e-02f,
  5.44758774e-02f, 3.46474373e-03f, -2.90952288e-02f, -3.67504805e-02f, -7.95979053e-02f, -9.44879502e-02f, -1.84511393e-02f, -1.52075425e-01f, -6.67203292e-02f, 1.32129431e-01f,
  3.76122519e-02f, 1.97212677e-02f, 1.11969881e-01f, -5.20112179e-02f, -4.36938144e-02f, -5.79305589e-02f, -1.89528123e-01f, -1.75831512e-01f, 9.63741466e-02f, 5.42034097e-02f,
  -1.92519620e-01f, -2.64312029e-01f, 6.82197660e-02f, 2.08066136e-01f, -1.48185208e-01f, -1.07852817e-01f, 1.67983249e-02f, -1.10354222e-01f, -2.68899173e-01f, -2.29637638e-01f,
  -9.18994322e-02f, 1.86187521e-01f, -2.21967950e-01f, 1.16760485e-01f, 1.74675837e-01f, -4.37844992e-02f, -1.73943147e-01f, -6.35750592e-03f, 3.25493165e-03f, -1.11841988e-02f,
  1.21024929e-01f, 2.57252157e-01f, 8.00681412e-02f, -1.05906688e-01f, 2.18555108e-01f, -1.04884431e-01f, -2.36573908e-02f, -4.10407456e-03f, 5.71029074e-02f, 6.89292476e-02f,
  -6.57997653e-02f, -2.68893372e-02f, 1.03571787e-01f, -1.23235583e-01f, 1.08703166e-01f, 9.10039153e-03f, -6.59696162e-02f, 1.19115680e-01f, 9.52195153e-02f, -2.19220519e-02f,
  -7.69917369e-02f, -1.10142782e-01f, -4.82134297e-02f, -3.72764915e-02f, -1.87071655e-02f, -9.05309170e-02f, -7.04352781e-02f, 1.09781735e-01f, 1.88487768e-02f, -1.33355364e-01f,
  9.10791755e-02f, -1.10244825e-01f, -2.02644728e-02f, 6.22271374e-02f, -8.18475708e-02f, 4.60756309e-02f, 1.32083774e-01f, 8.22315342e-04f, -4.97958027e-02f, -1.69090573e-02f,
  -1.45923913e-01f, 9.57710221e-02f, -1.33345082e-01f, -1.63124517e-01f, -1.34718508e-01f, -1.14024661e-01f, -9.67271775e-02f, 9.11811441e-02f, -1.71728179e-01f, -3.13594453e-02f,
  2.64976114e-01f, -8.09260756e-02f, -5.03398813e-02f, -2.18320504e-01f, -7.59210512e-02f, 1.93591505e-01f, 1.07670143e-01f, -3.48226689e-02f, 1.52308628e-01f, -1.81313127e-01f,
  -1.06918052e-01f, -8.74835774e-02f, -1.15094207e-01f, 4.64577563e-02f, 1.07700728e-01f, 2.35452294e-01f, -3.13286111e-02f, -1.24011889e-01f, 3.42579544e-01f, 4.01443057e-02f,
  -3.38038281e-02f, -1.05502814e-01f, 5.35441972e-02f, -1.20493241e-01f, -4.94014621e-02f, 9.57354605e-02f, 4.07461002e-02f, 8.90677050e-02f, -3.07763778e-02f, -1.32497072e-01f,
  -5.20429499e-02f, 8.88071880e-02f, 5.03371768e-02f, -3.17291580e-02f, -1.21603981e-01f, -2.04367727e-01f, 5.56951808e-03f, -9.87276062e-02f, 7.28122070e-02f, 8.47450942e-02f,
  4.10271669e-03f, -1.52239025e-01f, 2.09891293e-02f, -1.02819666e-01f, -1.33893415e-01f, -1.27939925e-01f, -1.20187707e-01f, -1.33013651e-01f, -1.63981430e-02f, -6.63389638e-02f,
  5.32004163e-02f, -5.44264093e-02f, -1.00941241e-01f, 2.92130262e-01f, -2.58251011e-01f, 1.62771836e-01f, -1.09379917e-01f, 3.35465372e-03f, -1.62338212e-01f, -2.00794995e-01f,
  7.48945326e-02f, 1.95629135e-01f, 1.59760565e-01f, 2.52202582e-02f, 4.60286215e-02f, 9.77586582e-02f, -2.22205579e-01f, -3.27855468e-01f, 8.67022127e-02f, 2.11911928e-02f,
  1.01975732e-01f, 1.41989604e-01f, -1.10657185e-01f, -1.39035404e-01f, 1.55097112e-01f, 4.96136993e-02f, 8.73017032e-03f, -5.36003634e-02f, -2.10241616e-01f, 5.82934506e-02f,
  1.10890912e-02f, 1.63745880e-02f, 2.21296966e-01f, 4.54529449e-02f, -1.09048888e-01f, 1.27936244e-01f, 8.98452252e-02f, 1.17051350e-02f, -5.06348684e-02f, 6.70846328e-02f,
  2.17297807e-01f, -1.61519814e-02f, 9.83038545e-02f, 1.11516289e-01f, -9.96308923e-02f, 1.63098454e-01f, -1.78123087e-01f, -9.17179957e-02f, -1.45722851e-01f, -4.88219634e-02f,
  -1.71197951e-01f, -7.23463297e-02f, -4.59101088e-02f, 2.62137447e-02f, -9.03685465e-02f, 5.22985077e-03f, -1.65921137e-01f, -7.78086111e-02f, -1.16361469e-01f, -2.18029216e-01f,
  2.85811126e-02f, 1.27342775e-01f, -6.71792477e-02f, -3.33601087e-02f, 1.63355544e-01f, 3.44984420e-02f, -8.14886168e-02f, 2.22434346e-02f, -1.25985220e-01f, -1.41255915e-01f,
  3.24319005e-02f, -1.97553337e-01f, -8.30417573e-02f, -1.27686337e-01f, 9.83140245e-02f, -3.58225517e-02f, -1.41154185e-01f, -6.44457936e-02f, 2.26945311e-01f, -6.71411678e-02f,
  4.80659269e-02f, -2.64861524e-01f, -6.40506521e-02f, 1.49155766e-01f, -4.18293010e-03f, 1.31677628e-01f, 1.11454226e-01f, -1.33018702e-01f, 3.81828398e-02f, -4.87441709e-03f,
  7.24981725e-02f, 9.12314504e-02f, -8.71736109e-02f, 1.25753343e-01f, 1.00819685e-01f, -8.08350295e-02f, 2.66037822e-01f, -1.16858967e-01f, -1.17520012e-01f, -9.61788446e-02f,
  -2.21432429e-02f, -2.67021600e-02f, -1.11222617e-01f, 5.48223555e-02f, -5.28929010e-02f, -1.39514595e-01f, -2.38915477e-02f, 2.75778621e-02f, -7.81121552e-02f, 1.54770836e-01f,
  -1.00851553e-02f, -1.18815310e-01f, 1.30906180e-01f, -6.28354400e-02f, -1.25886396e-01f, -4.80730012e-02f, -9.71547440e-02f, -1.54563427e-01f, -5.49097359e-02f, -1.68497592e-01f,
  -4.54438366e-02f, -1.27435312e-01f, -7.07499459e-02f, -1.50974303e-01f, -1.71543315e-01f, -1.44176975e-01f, -1.31271303e-01f, -4.68607340e-03f, -7.60908946e-02f, 3.57616283e-02f,
  3.33998054e-02f, -6.66868240e-02f, 9.15593654e-02f, -4.45812605e-02f, 1.51976064e-01f, 7.32995430e-03f, -1.70143962e-01f, 1.09385885e-01f, 2.46843800e-01f, -1.49888605e-01f,
  -1.03264652e-01f, -2.67191797e-01f, 1.08224377e-01f, -6.28908724e-02f, -6.50409013e-02f, -1.54471949e-01f, 6.42315298e-02f, -7.36728087e-02f, -4.98830639e-02f, 9.66873989e-02f,
  3.24708559e-02f, 1.02209700e-02f, -5.88587858e-02f, -1.67800263e-02f, 8.15129951e-02f, -3.54322270e-02f, -7.31557608e-02f, -2.00231090e-01f, -4.56887148e-02f, 2.49487651e-03f,
  -4.28899899e-02f, -6.12970665e-02f, -1.21981047e-01f, 1.03379346e-01f, 3.31524611e-02f, 1.53897539e-01f, 5.27238101e-03f, 4.01777290e-02f, 6.56125173e-02f, 6.63532168e-02f,
  9.52646509e-02f, 9.89808813e-02f, 7.94883370e-02f, -5.43526821e-02f, 1.20136611e-01f, 8.95233005e-02f, 1.65627867e-01f, 2.18011528e-01f, 1.74419388e-01f, 2.04834975e-02f,
  5.14330082e-02f, -2.25420203e-02f, 1.65414393e-01f, -1.09167211e-01f, 1.06033131e-01f, -1.20914459e-01f, 5.08854575e-02f, 3.35672386e-02f, 1.61771998e-01f, 9.33761001e-02f,
  -1.08864754e-01f, -6.96621314e-02f, -4.47450858e-03f, -4.76431660e-02f, 7.46290460e-02f, -1.78186640e-01f, -1.11427464e-01f, -1.39880106e-01f, 1.91513211e-01f, -8.24551880e-02f,
  9.55284387e-02f, 2.24277049e-01f, 5.20118251e-02f, 1.77417230e-02f, -1.92325234e-01f, -2.90943861e-01f, 1.03821876e-02f, 4.94811237e-02f, -6.73380122e-02f, 1.30767897e-01f,
  -1.58123314e-01f, -1.03716571e-02f, 6.83986247e-02f, 2.14765519e-02f, 1.22530125e-01f, 1.46981418e-01f, -2.21290931e-01f, -7.43034333e-02f, 2.05644399e-01f, 1.14252158e-01f,
  8.39560255e-02f, 3.73270065e-02f, -7.41608962e-02f, 6.60157576e-02f, -2.81516790e-01f, -1.37887552e-01f, 3.43272637e-04f, 1.10478252e-01f, 6.69382215e-02f, 1.27749979e-01f,
  8.06627870e-02f, 8.94205198e-02f, -1.73070326e-01f, -1.68045253e-01f, 9.84639600e-02f, 7.31997490e-02f, -2.62972135e-02f, 1.73390448e-01f, 2.66373158e-01f, 9.95699689e-02f,
  -2.94566294e-03f, 1.51906222e-01f, 1.08036503e-01f, 2.05370009e-01f, -8.23691264e-02f, 9.28474292e-02f, 1.99878849e-02f, -8.17963406e-02f, 7.51397908e-02f, -1.13756359e-01f,
  -7.69293159e-02f, -1.38034567e-01f, -1.06647603e-01f, 2.77911276e-02f, -2.39408738e-03f, 6.92864433e-02f, -4.27166261e-02f, -3.44695128e-03f, 9.46919471e-02f, -3.06029581e-02f,
  1.09332941e-01f, 4.31430228e-02f, 1.86965644e-01f, 1.88814867e-02f, -1.42022863e-01f, 1.42415106e-01f, 2.87313074e-01f, -2.81568438e-01f, -2.02947244e-01f, -1.63312495e-01f,
  1.32577121e-02f, 2.12107182e-01f, 1.00827843e-01f, 6.81324676e-02f, -2.36558229e-01f, 1.10363223e-01f, -1.58895984e-01f, 2.53066450e-01f, 2.62652151e-02f, -8.56892169e-02f,
  1.80867851e-01f, 4.31425497e-03f, 5.68217738e-03f, 5.31431586e-02f, 9.63972881e-02f, -1.13369867e-01f, -1.71208363e-02f, 1.61559619e-02f, -1.58661276e-01f, 9.78533551e-02f,
  -1.31478190e-01f, 4.00666147e-02f, 6.54913932e-02f, 5.56698032e-02f, -1.15605563e-01f, -2.88167987e-02f, -2.24514604e-01f, -2.39651818e-02f, -6.40584230e-02f, 2.07206085e-01f,
  -5.46359941e-02f, -1.60450429e-01f, 9.41362008e-02f, -4.02667895e-02f, -1.49086267e-01f, 1.92431081e-02f, -8.32787976e-02f, 9.96362641e-02f, 1.21243373e-02f, 1.34504154e-01f,
  1.49591699e-01f, -1.30964652e-01f, 3.98263820e-02f, -1.54768869e-01f, -1.06488943e-01f, -1.53518736e-01f, 1.61930472e-02f, -1.26082212e-01f, -1.00658916e-01f, -9.86211076e-02f,
  5.42693846e-02f, 4.09644172e-02f, -1.99674498e-02f, 1.95514992e-01f, -2.47427821e-03f, 4.85814512e-02f, -2.50146315e-02f, -5.29028773e-02f, -1.02006212e-01f, 1.00099303e-01f,
  2.75898486e-01f, -2.28495672e-01f, -1.65001079e-01f, -9.52738523e-02f, 1.93337604e-01f, 7.60063604e-02f, -8.53342563e-02f, -2.17297614e-01f, -4.65320535e-02f, 1.67365819e-01f,
  -4.80155274e-03f, 2.47054562e-01f, -9.30508599e-02f, 1.05194248e-01f, 1.71472386e-01f, -9.88112018e-03f, -6.99880719e-02f, -8.46170038e-02f, -1.66138828e-01f, 3.90045866e-02f,
  9.34675261e-02f, -3.11359689e-02f, -5.33136874e-02f, 1.34451911e-01f, -1.41587421e-01f, -8.78877640e-02f, -6.43928647e-02f, 1.59837961e-01f, -7.02976063e-02f, -3.52608263e-02f,
  -1.09122992e-01f, 2.04009816e-01f, 2.03276016e-02f, 5.86489514e-02f, -4.43276316e-02f, 1.64056063e-01f, 5.73776802e-03f, 9.17833969e-02f, 1.26248419e-01f, -1.56337708e-01f,
  -3.39365378e-02f, 4.22780849e-02f, 1.06979117e-01f, 8.29858519e-03f, 7.88956881e-02f, 3.27999294e-02f, -1.68762609e-01f, -9.50653572e-03f, 9.86389592e-02f, -3.45655903e-03f,
  -8.86046216e-02f, -8.30659419e-02f, 4.46851216e-02f, -8.98464993e-02f, 3.02645098e-02f, -4.31324504e-02f, -1.01961024e-01f, -7.98049420e-02f, -3.57494578e-02f, -1.40108958e-01f,
  -8.92199948e-02f, -1.14324763e-01f, -5.06942254e-03f, 9.15171579e-02f, 9.23952013e-02f, -9.71007496e-02f, -5.67921437e-02f, 1.14564061e-01f, -8.04400723e-03f, 3.71385515e-02f,
  -9.53052565e-02f, 1.47005826e-01f, 6.35439083e-02f, -5.13131320e-02f, -7.46289045e-02f, -2.23549366e-01f, 8.90476331e-02f, -9.94824767e-02f, 6.03445843e-02f, 8.00821632e-02f,
  1.79360714e-02f, 1.36137933e-01f, 4.57679704e-02f, 1.41414702e-01f, 2.98910234e-02f, -7.67545104e-02f, -4.39166166e-02f, 6.00941777e-02f, 1.11748964e-01f, 1.26997128e-01f,
  -1.35166988e-01f, -1.39744999e-02f, 7.70068392e-02f, -1.16617858e-01f, -3.87203246e-02f, -7.89737999e-02f, -1.16348729e-01f, 3.41515504e-02f, 7.24278539e-02f, 4.65094149e-02f,
  -4.64960411e-02f, 8.67667124e-02f, -1.59666371e-02f, 8.14780295e-02f, -8.45424980e-02f, 9.58997458e-02f, 2.10719705e-02f, -7.84824416e-02f, 9.15670618e-02f, 9.15237516e-02f,
  -1.04431495e-01f, -1.05969474e-01f, 4.07593623e-02f, 7.64453337e-02f, 2.19231043e-02f, 2.32576765e-02f, 1.19242251e-01f, 8.05759337e-03f, -6.16397895e-02f, 1.39970616e-01f,
  -2.20821574e-01f, 6.79907352e-02f, -5.65378368e-02f, -1.86714709e-01f, -6.37494475e-02f, -1.51955292e-01f, -5.81161231e-02f, -1.00998320e-01f, -2.33752310e-01f, 2.73987591e-01f,
  -1.14253327e-01f, 1.50864378e-01f, 3.49954423e-03f, -2.58325011e-01f, 3.84267382e-02f, -5.67899011e-02f, 1.19874164e-01f, 4.35537659e-02f, -3.84125374e-02f, -2.29518428e-01f,
  1.11167476e-01f, 1.17649296e-02f, -7.35848173e-02f, 7.53331780e-02f, -1.45198449e-01f, 4.03672364e-03f, -4.91259843e-02f, 1.99234262e-01f, -7.99812675e-02f, 2.68525165e-02f,
  1.10786900e-01f, -2.06703827e-01f, 1.61804613e-02f, 9.22947749e-02f, -1.41815647e-01f, -1.08377568e-01f, 5.56741748e-03f, -4.70777526e-02f, -2.05781590e-02f, -8.79878104e-02f,
  2.50513516e-02f, -1.75403059e-01f, -1.31250411e-01f, 6.67258352e-02f, -9.91004035e-02f, -3.65197137e-02f, 4.21233438e-02f, -8.39398131e-02f, -3.95767651e-02f, 8.27725977e-02f,
  -4.87640724e-02f, -1.01761363e-01f, -1.83758549e-02f, -1.12628587e-01f, 7.67487362e-02f, 5.19913472e-02f, -1.23113304e-01f, -5.77508770e-02f, -1.13893427e-01f, 1.87342372e-02f,
  1.95565522e-02f, -1.15045622e-01f, -1.87094763e-01f, -1.77671820e-01f, -9.68518332e-02f, -1.81900665e-01f, -1.00719847e-01f, -1.30569994e-01f, -3.13390642e-02f, 2.93846846e-01f,
  1.24774866e-01f, 1.11168608e-01f, 7.46584907e-02f, -9.43433121e-02f, 2.02445745e-01f, -2.48539485e-02f, -2.56329834e-01f, 1.45165950e-01f, -2.34851584e-01f, 3.60214189e-02f,
  4.43491153e-02f, -1.39298914e-02f, 2.71125715e-02f, -8.07298794e-02f, 3.84414627e-04f, -6.89524859e-02f, -1.17734469e-01f, -2.66247522e-02f, 1.88179165e-01f, -2.67415456e-02f,
  7.20194802e-02f, -1.90901920e-01f, -5.28834835e-02f, -1.40456902e-02f, -1.84508041e-01f, 3.42103392e-02f, 1.04322188e-01f, -8.86673257e-02f, -2.52663437e-02f, 1.52654340e-03f,
  2.05070507e-02f, 1.39538765e-01f, 1.85103007e-02f, 1.07874356e-01f, -1.03314430e-01f, 9.02717113e-02f, 7.46352449e-02f, -1.80932939e-01f, -1.08985394e-01f, -2.36505200e-03f,
  -6.76796585e-02f, -6.25562593e-02f, -6.05963729e-02f, 1.24410307e-02f, 3.21604013e-02f, 1.34001896e-01f, 6.24476261e-02f, 5.15172631e-02f, 5.03204018e-02f, 1.12204431e-02f,
  5.81490919e-02f, 1.76066831e-01f, -3.75041105e-02f, -1.21318556e-01f, 3.26551758e-02f, -5.32496236e-02f, 1.86785713e-01f, -3.68703194e-02f, 1.58987183e-03f, 2.70295471e-01f,
  -7.77608007e-02f, 1.34723827e-01f, -9.72380117e-02f, 3.62364985e-02f, 1.66796381e-04f, -1.81505084e-01f, -1.37103155e-01f, -1.81625108e-03f, -6.97634444e-02f, 3.05692613e-01f,
  9.74040180e-02f, -8.50382447e-02f, -9.20358300e-02f, 7.75837600e-02f, -1.12477792e-02f, 5.36042750e-02f, 1.99546646e-02f, 1.27494991e-01f, 1.36514651e-02f, -2.18685977e-02f,
  6.11958019e-02f, -6.55215904e-02f, -1.58424586e-01f, 3.03039197e-02f, -1.91216916e-01f, -8.92393067e-02f, 4.13130857e-02f, 3.13937059e-03f, 3.99186872e-02f, -1.16402522e-01f,
  -9.87349004e-02f, 2.02924795e-02f, 2.35006623e-02f, -1.34643406e-01f, 1.19166695e-01f, -9.20189694e-02f, 3.41562092e-01f, 7.56957829e-02f, -1.62105169e-02f, 6.50201738e-02f,
  7.28620291e-02f, -1.02104440e-01f, -3.10179964e-02f, 9.03583691e-02f, -4.46921811e-02f, 5.19411601e-02f, 6.27496690e-02f, -6.10141270e-02f, 1.22495010e-01f, 1.65339351e-01f,
  -6.95682094e-02f, -5.84673509e-02f, 1.74041420e-01f, 2.07781151e-01f, -2.94895358e-02f, 7.08276220e-03f, 1.55532718e-01f, 4.00614887e-02f, 1.70906231e-01f, -7.17994347e-02f,
  -1.70301627e-02f, -6.26446232e-02f, -9.32696834e-02f, -1.53217852e-01f, 6.51141778e-02f, 1.73266158e-01f, 2.97524706e-02f, 1.84023425e-01f, 2.64502883e-01f, 5.36170267e-02f,
  -8.54913443e-02f, -4.41753715e-02f, -2.01403964e-02f, 2.24026576e-01f, -2.14185208e-01f, 4.90790345e-02f, 1.17728792e-01f, 2.41663709e-01f, 1.80204853e-01f, -2.34486073e-01f,
  6.68468699e-02f, 4.54456024e-02f, -7.65568167e-02f, 1.63233906e-01f, 4.93393242e-02f, 5.65656126e-02f, -1.17072657e-01f, -3.31556462e-02f, 1.31773010e-01f, -1.58934012e-01f,
  1.11380957e-01f, 7.41122812e-02f, -7.58288279e-02f, -2.63643712e-02f, 3.66756096e-02f, -9.39135328e-02f, -1.71837866e-01f, -1.54008895e-01f, -6.81554303e-02f, 6.85660839e-02f,
  1.39888287e-01f, -6.89515397e-02f, 7.03952601e-03f, -5.57291731e-02f, -5.94732463e-02f, -2.48626489e-02f, -1.14145011e-01f, 1.30063266e-01f, -6.67968243e-02f, -1.55304775e-01f,
  -1.36883510e-02f, -1.35816455e-01f, 3.68809095e-03f, 1.34710088e-01f, 2.77059134e-02f, 9.47783217e-02f, -5.75950965e-02f, 1.16811045e-01f, 3.71711142e-02f, 2.18139216e-01f,
  8.05868804e-02f, -3.37900110e-02f, -1.76735912e-02f, -5.38632609e-02f, 6.54670373e-02f, 5.94173819e-02f, 6.91023320e-02f, 1.42244354e-01f, -1.17814071e-01f, 1.84910208e-01f,
  -9.67512652e-02f, 1.71816632e-01f, 5.49480058e-02f, -7.24739069e-03f, 1.10834241e-01f, 4.66020480e-02f, 2.01062739e-01f, 3.25757414e-01f, -1.12985663e-01f, 1.03445895e-01f,
  -1.92077965e-01f, 3.70899029e-02f, 2.50405669e-01f, -1.05918437e-01f, 1.75952151e-01f, -8.29019677e-03f, 9.17346403e-02f, 4.26104441e-02f, 1.98853388e-01f, 1.23214051e-01f,
  4.28726673e-02f, 3.78014110e-02f, -1.71508223e-01f, -2.71511257e-01f, 1.47988856e-01f, -1.20864615e-01f, -5.26857637e-02f, -5.78090847e-02f, 1.22841261e-01f, 9.85533446e-02f,
  1.55915335e-01f, -9.15222988e-02f, 5.96074872e-02f, -1.08452581e-01f, 3.35986733e-01f, 6.01700954e-02f, -5.73092960e-02f, 3.04642301e-02f, -3.54202348e-03f, -1.72846943e-01f,
  -1.36351630e-01f, 8.16313699e-02f, -8.57526958e-02f, -3.08809817e-01f, -1.19390592e-01f, 3.79061364e-02f, -1.67616516e-01f, -3.93097028e-02f, -4.69013527e-02f, -1.76901579e-01f,
  -1.45276830e-01f, -1.87131390e-01f, -1.88655913e-01f, -1.81252345e-01f, -1.85484886e-01f, 5.80821559e-02f, -2.22545534e-01f, -9.58085060e-02f, -1.69410884e-01f, -4.31682058e-02f,
  -9.48454998e-03f, -5.33015393e-02f, -1.57686286e-02f, -1.26593307e-01f, -3.93766612e-02f, -4.56002820e-03f, -3.35695028e-01f, 2.71388572e-02f, 1.86666563e-01f, 3.79117988e-02f,
  -2.44382061e-02f, -2.67343670e-01f, 1.00964690e-02f, 1.19518740e-02f, -3.12775671e-01f, -2.07018137e-01f, -1.50732905e-01f, 4.26584631e-02f, -1.41228154e-01f, 7.03923926e-02f,
  -2.48080362e-02f, -1.15319220e-02f, -1.78259045e-01f, -4.31235135e-02f, 2.87344635e-01f, 1.09110981e-01f, -1.42775252e-01f, -5.71092889e-02f, -1.07302785e-01f, 8.11448768e-02f,
  6.31365404e-02f, -6.32109046e-02f, 9.50243846e-02f, 1.15069572e-03f, -8.01521819e-03f, 2.13796765e-01f, -1.21712081e-01f, -1.24516055e-01f, -1.70190454e-01f, -1.06381550e-01f,
  1.61793437e-02f, 4.25345004e-02f, 1.27001628e-01f, 2.00742155e-01f, -1.36385083e-01f, -8.27273056e-02f
};

// L2_fan_Wp_bar (Shape: 26 x 64)
const int L2_fan_Wp_bar_rows = 26;
const int L2_fan_Wp_bar_cols = 64;
const float L2_fan_Wp_bar_data[] = {
  -1.07430510e-01f, 2.21417136e-02f, 5.05947061e-02f, 1.13336578e-01f, 1.19731501e-01f, -9.70513597e-02f, -9.10026059e-02f, -4.78105322e-02f, 8.75418931e-02f, 1.23082399e-01f,
  -6.99832588e-02f, 1.12149999e-01f, -1.31672442e-01f, 1.61884725e-02f, -8.30156356e-02f, -8.88751168e-03f, -6.48117214e-02f, -3.15472204e-03f, 7.54728466e-02f, 1.11252936e-02f,
  1.48641989e-01f, 1.10266902e-01f, -9.78369862e-02f, -5.01351170e-02f, -8.15613493e-02f, 1.86115578e-02f, -3.90734859e-02f, 1.12703331e-02f, -1.02216221e-01f, 4.29087207e-02f,
  -4.67727482e-02f, 2.55202386e-03f, 2.38854028e-02f, 1.30358800e-01f, -5.22017181e-02f, 3.67952175e-02f, -6.48217648e-02f, 1.56197086e-01f, 1.04040749e-01f, 5.23342118e-02f,
  1.01152152e-01f, -6.16838485e-02f, -1.05496489e-01f, -1.23897441e-01f, -2.54709143e-02f, -4.67971675e-02f, -1.84729565e-02f, 1.20785922e-01f, -1.04295753e-01f, 7.74196088e-02f,
  2.64562108e-02f, -2.80420370e-02f, -6.67813420e-02f, 1.03759602e-01f, 9.12173241e-02f, 1.26254201e-01f, 8.77449140e-02f, 3.28095406e-02f, -6.23528212e-02f, 3.40887457e-02f,
  -1.55437430e-02f, 1.10048596e-02f, -8.99787471e-02f, 7.56849647e-02f, 2.57838190e-01f, -1.72404036e-01f, 1.31646708e-01f, 7.74947628e-02f, 1.97124258e-01f, -2.80429572e-02f,
  6.26840144e-02f, 1.43092901e-01f, 1.39520854e-01f, -3.51617709e-02f, 1.98329061e-01f, -4.19377945e-02f, 1.97656333e-01f, 2.30171338e-01f, -3.11514717e-02f, 1.44376308e-01f,
  -1.66493818e-01f, 1.87068939e-01f, 8.10752809e-02f, -7.94095322e-02f, -1.50461748e-01f, -1.35569260e-01f, -1.60045996e-01f, -8.00944418e-02f, -2.83657670e-01f, 1.64994802e-02f,
  -3.47605385e-02f, 1.28983423e-01f, -7.86585659e-02f, -2.35754624e-01f, 2.24157199e-01f, 4.87288795e-02f, -1.09221049e-01f, 1.23328306e-02f, 3.04119363e-02f, -1.01016395e-01f,
  -1.70305446e-02f, -1.50025249e-01f, 1.71626911e-01f, 1.48434222e-01f, -1.73764899e-01f, -8.63222480e-02f, 4.40846264e-01f, -7.87437409e-02f, 5.28202318e-02f, 2.23589897e-01f,
  -9.66049507e-02f, 5.00385463e-02f, 2.81374097e-01f, 7.04135820e-02f, 7.20523298e-02f, 2.54638828e-02f, -4.89309011e-03f, 1.67185336e-01f, -1.15510672e-01f, -5.85479243e-03f,
  3.55022475e-02f, -1.78469002e-01f, 1.25073448e-01f, 1.30063266e-01f, -4.80857380e-02f, 4.32676882e-01f, -5.43963052e-02f, 1.15150675e-01f, -3.30187678e-02f, 3.49148542e-01f,
  9.59890410e-02f, 1.03613600e-01f, 8.33939612e-02f, 1.33190125e-01f, -4.79498468e-02f, 1.88787133e-01f, 3.39870267e-02f, 1.76417843e-01f, -7.64458925e-02f, 1.41110808e-01f,
  -3.65175232e-02f, -7.87350908e-02f, 1.88240796e-01f, 1.99047282e-01f, 1.84239447e-01f, 2.29753092e-01f, 1.00042738e-01f, 3.57775807e-01f, -2.92947274e-02f, 1.53078124e-01f,
  1.38128117e-01f, -2.80347299e-02f, 2.16870025e-01f, -2.03477025e-01f, -1.42124981e-01f, -6.54501915e-02f, -1.61040261e-01f, 2.77735084e-01f, 1.86376721e-01f, 8.04986879e-02f,
  2.46200189e-01f, -6.14493564e-02f, 4.53953482e-02f, 1.45437285e-01f, -4.06875536e-02f, 1.89342469e-01f, 5.08432388e-02f, -1.18116550e-01f, 3.52788329e-01f, 4.81792688e-02f,
  -1.39756382e-01f, -6.90286281e-03f, 1.34701565e-01f, 1.99231431e-01f, -5.72869647e-03f, 1.12810411e-01f, 1.18673667e-01f, 3.69499698e-02f, -7.91892782e-02f, 8.08572620e-02f,
  4.60622832e-02f, -1.39846370e-01f, 8.29261318e-02f, -4.29306924e-02f, 4.13182788e-02f, 4.60977480e-02f, -5.64837679e-02f, -9.77660865e-02f, 6.32005278e-04f, -1.34510338e-01f,
  7.24405125e-02f, 5.49507439e-02f, -2.12872252e-02f, -8.82939771e-02f, -5.49432002e-02f, 4.59953677e-03f, 1.34426802e-02f, 1.30464688e-01f, -9.02835727e-02f, 3.45919766e-02f,
  -1.01833470e-01f, 8.02912712e-02f, 4.48381491e-02f, 9.01532546e-03f, 3.90430354e-02f, -2.25660671e-02f, 7.99891949e-02f, -1.26996934e-01f, -7.78074563e-02f, 3.65986563e-02f,
  -3.91013287e-02f, -1.23384349e-01f, -1.08248435e-01f, 4.00904007e-02f, 3.62870917e-02f, -2.18811668e-02f, 1.23517811e-01f, -3.62431370e-02f, 1.33571997e-02f, -5.96589930e-02f,
  1.24448001e-01f, 1.19630404e-01f, -8.16413090e-02f, 2.55277846e-02f, 2.26564687e-02f, 1.87159747e-01f, 9.50141177e-02f, -1.56183794e-01f, 2.48529017e-02f, 8.44637770e-03f,
  -6.34168216e-04f, 9.59457234e-02f, 1.13611095e-01f, 1.08419493e-01f, -9.35456976e-02f, -7.74177909e-02f, 2.19303463e-02f, -6.73355013e-02f, 1.17491812e-01f, 6.28155470e-02f,
  3.19192596e-02f, 1.39481589e-01f, -4.96670380e-02f, -2.02407800e-02f, 8.46599564e-02f, -4.42041941e-02f, -4.24786005e-03f, -5.32881469e-02f, 1.52758211e-01f, -3.75400782e-02f,
  1.10577486e-01f, -6.71956167e-02f, -4.51277941e-02f, 9.95048136e-03f, 8.00586790e-02f, -8.10959786e-02f, 2.27746978e-01f, 2.65393239e-02f, -2.99244391e-04f, 4.95752878e-02f,
  2.25923851e-01f, 1.47335812e-01f, 1.88977167e-01f, 9.26447809e-02f, 1.15334652e-01f, -4.48511429e-02f, 3.69456083e-01f, 6.86108768e-02f, 2.01328650e-01f, 2.23117262e-01f,
  1.94945067e-01f, 1.58457726e-01f, 1.62548468e-01f, 2.36533538e-01f, -1.33601665e-01f, -1.95490628e-01f, -2.17909038e-01f, -1.19525373e-01f, -1.13589175e-01f, -2.90880650e-01f,
  -1.64566115e-02f, 2.12375522e-01f, -2.42834613e-01f, 2.90868998e-01f, -8.64982978e-02f, -6.40108064e-03f, -1.89268384e-02f, -2.32788011e-01f, 8.14737231e-02f, 2.20320255e-01f,
  2.06763357e-01f, 4.54154564e-03f, 2.69856006e-01f, -1.31289646e-01f, 1.24735713e-01f, 2.53453106e-01f, -7.15100691e-02f, 1.13079110e-02f, 1.37184843e-01f, -1.27279237e-01f,
  2.64013540e-02f, 2.41820097e-01f, 1.79365188e-01f, 1.29584968e-01f, -4.48136516e-02f, -1.11998335e-01f, -6.47798181e-02f, 1.11351706e-01f, -2.02048287e-01f, 1.08482219e-01f,
  -1.02116115e-01f, 9.46545824e-02f, -8.48143175e-02f, 2.98666880e-02f, 3.22132511e-03f, -4.68846038e-02f, 8.30045044e-02f, 2.49539971e-01f, 1.37723595e-01f, -6.10468052e-02f,
  1.29384279e-01f, 1.16959937e-01f, 1.84938863e-01f, 1.52915314e-01f, 2.34740674e-01f, 2.01715022e-01f, 2.15939544e-02f, 9.49355960e-02f, -4.30992991e-03f, -1.29476991e-02f,
  9.15232226e-02f, 5.42982295e-02f, 1.06535070e-01f, 1.04687005e-01f, 2.10268974e-01f, -5.91371953e-02f, 1.50402755e-01f, 9.60451439e-02f, -8.31805691e-02f, 5.51754236e-02f,
  -2.39760950e-01f, -2.61153162e-01f, -2.32807826e-02f, 1.10538550e-01f, -2.98040304e-02f, -1.91759810e-01f, -2.13563621e-01f, 2.29086399e-01f, 6.85124844e-02f, -6.98443875e-03f,
  -2.70226579e-02f, -2.07957253e-01f, -2.36812696e-01f, -1.39981925e-01f, 6.01253547e-02f, -1.43521912e-02f, 1.22137830e-01f, -2.84942746e-01f, 1.24890730e-01f, 7.17697479e-03f,
  -9.00835916e-02f, -1.36753861e-02f, 2.19382271e-01f, -4.60814163e-02f, -1.62897274e-01f, 7.71720335e-02f, 2.06726402e-01f, -1.49982229e-01f, 2.30401084e-02f, -1.03434231e-02f,
  1.24556735e-01f, -5.23370244e-02f, 2.12026805e-01f, 1.61000803e-01f, 1.16437055e-01f, -7.56963119e-02f, 6.25766933e-01f, 4.27963175e-02f, 1.16111033e-01f, 6.34573027e-02f,
  6.70938939e-02f, 1.25585999e-02f, 5.89653663e-02f, -3.97930481e-02f, -1.13018513e-01f, 2.24829555e-01f, 4.53837439e-02f, 1.91553012e-02f, 1.03409737e-01f, 1.16434023e-01f,
  1.47338361e-01f, 3.62803116e-02f, 5.30137420e-02f, 2.12148100e-01f, -1.34321943e-01f, 1.27923429e-01f, -4.80643995e-02f, 4.89751212e-02f, 5.44026829e-02f, 9.59115028e-02f,
  2.56126136e-01f, 1.42446265e-01f, 2.22806260e-01f, 3.57551008e-01f, 1.19661242e-01f, 2.08097562e-01f, -1.51173202e-02f, 1.26216412e-01f, 7.51591027e-02f, -2.62277871e-01f,
  6.54089227e-02f, -9.91934612e-02f, -1.10410042e-02f, 2.27259830e-01f, 1.12972379e-01f, 2.41893709e-01f, 1.08930610e-01f, -2.27670625e-01f, -3.68337855e-02f, 6.21861368e-02f,
  -1.85494214e-01f, 2.69325614e-01f, -2.75117103e-02f, -1.88155055e-01f, 4.23236221e-01f, 6.02299608e-02f, -1.12442233e-01f, 6.22717813e-02f, 4.18906286e-02f, -9.22742784e-02f,
  2.24077310e-02f, 1.35387322e-02f, 6.86172545e-02f, 1.62700582e-02f, -4.72029932e-02f, -5.36408797e-02f, 1.61556944e-01f, 1.17216423e-01f, -5.43591380e-03f, 9.01168492e-03f,
  4.20564950e-01f, 5.42560443e-02f, -1.87503770e-02f, 6.97494298e-02f, -9.53535810e-02f, -2.15201333e-01f, 1.52849972e-01f, 1.27634376e-01f, 2.03961693e-02f, -1.34316176e-01f,
  7.67910630e-02f, -7.63343871e-02f, -3.77279520e-02f, 1.17524434e-03f, -8.16011801e-02f, 2.03855000e-02f, 2.71989498e-02f, 6.37808256e-03f, -1.15878247e-01f, 1.03234708e-01f,
  -8.43864605e-02f, -1.24598749e-01f, 6.50049075e-02f, -1.07233949e-01f, -1.09857023e-01f, 1.05373770e-01f, 6.35722354e-02f, -4.81356680e-02f, 2.15980802e-02f, -1.22592956e-01f,
  9.90689620e-02f, 3.47751677e-02f, -1.24034852e-01f, -4.08545509e-02f, 1.16391346e-01f, -3.04998662e-02f, 1.19000867e-01f, -9.39102005e-03f, -2.17449572e-02f, -1.12063950e-02f,
  -1.31826594e-01f, -1.07007720e-01f, 9.67753455e-02f, 1.02839716e-01f, -1.71941472e-03f, 8.81400779e-02f, -5.10107279e-02f, 5.57969278e-03f, 3.30333598e-02f, 2.91480217e-02f,
  1.10763587e-01f, 7.70711526e-02f, -7.60810301e-02f, 9.77009907e-02f, 6.82779402e-02f, -1.26134872e-01f, -4.54751775e-02f, 9.68816578e-02f, 1.03953205e-01f, -7.32787140e-03f,
  -1.07231379e-01f, 2.66314447e-02f, -5.98607957e-02f, 8.87790248e-02f, 5.33291958e-02f, 1.09490491e-01f, 7.82531947e-02f, -1.00344010e-01f, 7.73539841e-02f, 3.36559080e-02f,
  5.81934229e-02f, 8.48507509e-02f, 6.03248440e-02f, 2.28039678e-02f, 1.38565958e-01f, 1.21421898e-02f, 1.05148174e-01f, 4.54313308e-02f, 1.30839244e-01f, 1.67598188e-01f,
  1.98528662e-01f, -3.01831309e-02f, -5.98459132e-02f, 1.44243509e-01f, 9.92782488e-02f, 5.13886139e-02f, -4.14060205e-02f, 7.87089244e-02f, -9.13899243e-02f, 1.25843585e-01f,
  2.23381847e-01f, -2.27245182e-01f, 2.88225353e-01f, 2.41030380e-02f, -6.66664243e-02f, 2.02374086e-02f, 2.02982798e-01f, 1.24533869e-01f, 7.47205913e-02f, -1.70980975e-01f,
  -7.93519840e-02f, -2.19784632e-01f, -6.69887587e-02f, -2.46514473e-02f, 1.29188821e-01f, 9.37352255e-02f, -7.56586790e-02f, -2.65599430e-01f, -1.90507755e-01f, -1.62918806e-01f,
  -1.12062909e-01f, 2.27708399e-01f, 1.49406381e-02f, 6.61344826e-02f, 1.26280010e-01f, 1.42187297e-01f, 1.42633989e-01f, -9.43018571e-02f, -6.97557405e-02f, 2.63282746e-01f,
  -1.11770891e-01f, 1.03152178e-01f, -4.64845523e-02f, -1.71093848e-02f, 3.43501531e-02f, -5.64907938e-02f, -6.85700700e-02f, -4.02627178e-02f, -1.58364505e-01f, -4.10399884e-02f,
  1.64419785e-02f, -5.08794971e-02f, -2.81762481e-02f, -1.05627269e-01f, 1.24394119e-01f, -4.88414951e-02f, -1.54343948e-01f, 2.71823555e-01f, 1.92148656e-01f, 1.98027313e-01f,
  1.99914530e-01f, 1.75705180e-01f, -1.11372834e-02f, 1.16580889e-01f, 7.55315647e-02f, -1.87579487e-02f, -1.58096164e-01f, 3.10033541e-02f, -6.76640421e-02f, 1.80337965e-01f,
  -3.54769975e-02f, 1.23203591e-01f, 1.16094388e-01f, 1.59681872e-01f, 1.85436428e-01f, 1.85458973e-01f, 2.25384697e-01f, 2.51445264e-01f, 1.97535560e-01f, 1.69349924e-01f,
  9.91991088e-02f, -1.64056525e-01f, -3.36475410e-02f, -1.79432705e-01f, -1.26524597e-01f, 1.67779028e-01f, 5.05636483e-02f, 2.83749372e-01f, 1.43823013e-01f, -1.49159834e-01f,
  7.22754747e-03f, -3.23488824e-02f, -2.48313323e-01f, 2.59163111e-01f, 6.93340451e-02f, 4.57959510e-02f, 3.74526113e-01f, -4.80729528e-02f, -1.65797383e-01f, 1.20642083e-02f,
  -1.78570990e-02f, 4.97881323e-02f, -1.12930842e-01f, 1.02900527e-01f, 4.13999371e-02f, -7.13597909e-02f, 4.70155925e-02f, 8.41829255e-02f, 2.86219418e-02f, 7.05380598e-03f,
  1.19666299e-02f, -1.13159448e-01f, 2.01196700e-01f, 4.39750738e-02f, -8.72716866e-03f, 1.50964260e-01f, -9.21028554e-02f, -1.36456758e-01f, 1.45332754e-01f, -6.39838651e-02f,
  -6.12814240e-02f, -8.75412449e-02f, -7.52582587e-03f, 4.72898558e-02f, 2.78822090e-02f, -5.31142727e-02f, -1.23988658e-01f, 3.24113369e-02f, 5.48020750e-02f, 5.99804185e-02f,
  1.29355162e-01f, -2.63488349e-02f, -1.08603485e-01f, -6.68924749e-02f, 3.51112857e-02f, 1.10117607e-01f, 1.05930388e-01f, -1.08347669e-01f, 1.32955134e-01f, 4.23458219e-02f,
  -7.08731040e-02f, 3.00250947e-02f, 3.02772578e-02f, -6.12691380e-02f, -5.77036813e-02f, -1.11372575e-01f, -2.94127408e-02f, -8.63358527e-02f, 9.85573977e-02f, 5.29882088e-02f,
  3.20821740e-02f, 7.41855651e-02f, -4.10012901e-02f, 1.08057968e-01f, -4.27672490e-02f, -5.90397157e-02f, -7.67523982e-03f, 1.03894256e-01f, 9.44136307e-02f, -1.04784824e-01f,
  -4.96352911e-02f, 2.08856612e-02f, -8.56164768e-02f, -2.73355413e-02f, 1.01885170e-01f, 1.28576487e-01f, 8.99370089e-02f, -2.01050304e-02f, -6.80151768e-03f, 9.24642012e-02f,
  1.09670926e-02f, 4.73243892e-02f, -7.97247887e-02f, -8.51064324e-02f, 1.23089917e-01f, -3.08901072e-02f, 5.65827563e-02f, -4.96671349e-02f, -8.97727534e-02f, -1.04834832e-01f,
  1.53869288e-02f, 8.72358680e-02f, -1.06969006e-01f, -1.23422295e-02f, -5.11476994e-02f, 7.15953410e-02f, 1.64023172e-02f, 1.57640148e-02f, 4.50110361e-02f, 1.31518915e-01f,
  1.66967660e-01f, -5.01695834e-02f, -1.05756195e-02f, 6.74414039e-02f, -4.51430194e-02f, 1.28633350e-01f, -5.22431545e-02f, -1.58479847e-02f, 1.30558878e-01f, 2.10129261e-01f,
  2.50868853e-02f, 8.38617384e-02f, 8.43702853e-02f, 5.53802624e-02f, 2.03054637e-01f, 2.25887716e-01f, -5.02607189e-02f, 1.19451500e-01f, 1.73415821e-02f, 1.06960915e-01f,
  1.13045879e-01f, -1.67782694e-01f, -9.68773291e-02f, 4.05557565e-02f, 5.40088452e-02f, 2.17042804e-01f, 1.27105355e-01f, 1.30181447e-01f, 1.01525798e-01f, 1.25902425e-02f,
  7.06950650e-02f, -6.00032354e-06f, -2.08318960e-02f, 1.52968258e-01f, 3.26072782e-01f, -5.71051128e-02f, -2.04925567e-01f, 7.96153769e-02f, 1.37321532e-01f, 1.20508477e-01f,
  5.72241805e-02f, 1.96028203e-02f, 7.71246105e-02f, -2.48824097e-02f, -9.34537128e-02f, 2.63109896e-02f, -1.21843331e-01f, 4.91715595e-02f, 5.86450882e-02f, 1.96113251e-02f,
  -5.72997704e-02f, 4.69081923e-02f, 2.01302897e-02f, 1.04250051e-01f, 1.64400131e-01f, -9.44235325e-02f, 9.12629664e-02f, 3.82771343e-02f, 2.05119867e-02f, -4.76655997e-02f,
  1.25836164e-01f, -3.10833585e-02f, 1.17584296e-01f, 5.67581691e-02f, -1.22137062e-01f, 9.61078703e-03f, -7.75088668e-02f, -8.99843872e-02f, 8.18699822e-02f, -1.60460010e-01f,
  -6.56784549e-02f, -9.15359557e-02f, -7.48448819e-02f, -9.40650031e-02f, -5.32261766e-02f, 8.43100771e-02f, -1.09750004e-02f, 7.01812655e-02f, 3.43098566e-02f, -7.07839876e-02f,
  1.36627167e-01f, -2.44249459e-02f, 5.95928803e-02f, -1.16814733e-01f, -1.35042891e-01f, 3.31626013e-02f, 4.49712463e-02f, -9.00062323e-02f, 8.01235139e-02f, 1.02491640e-01f,
  1.14705384e-01f, 1.82857588e-02f, 1.78764313e-02f, 1.10817328e-01f, -1.17585041e-01f, -2.28168592e-02f, 1.28356874e-01f, -9.25607085e-02f, 6.03831112e-02f, -4.67623286e-02f,
  1.18406992e-02f, -1.14442497e-01f, -5.02591096e-02f, 2.13921010e-01f, -2.04564747e-03f, 6.29401579e-02f, 1.91817090e-01f, 4.11603972e-02f, 4.92591858e-02f, 3.83943552e-03f,
  8.40038210e-02f, -1.16070457e-01f, 9.81725156e-02f, -1.15991339e-01f, -6.67327046e-02f, -9.26941931e-02f, -3.34047712e-02f, 1.19144194e-01f, 9.08199511e-03f, 4.45248149e-02f,
  -5.53261042e-02f, -6.97095096e-02f, 2.43125126e-01f, -9.28510204e-02f, -2.54740082e-02f, -2.83362214e-02f, 2.15929702e-01f, -3.76232229e-02f, 1.15069300e-01f, 1.55953705e-01f,
  1.06961466e-01f, 8.62670317e-02f, 1.12791657e-01f, -1.80142045e-01f, -1.19988178e-03f, -6.61703423e-02f, 9.25517976e-02f, 1.00795157e-01f, 2.57545948e-01f, 5.69764599e-02f,
  1.35800749e-01f, 2.11189821e-01f, -1.63685516e-01f, -6.15720786e-02f, 3.69130485e-02f, -1.49227336e-01f, -1.64103955e-01f, -1.82413310e-01f, 2.43376732e-01f, 6.16948120e-02f,
  -2.65861955e-02f, -1.59284085e-01f, 1.65379882e-01f, 3.30278911e-02f, -6.37378618e-02f, -1.44336537e-01f, -9.75008979e-02f, 6.02425598e-02f, 7.39612281e-02f, -1.73565745e-02f,
  -7.94400554e-03f, 1.51844462e-02f, 1.23836540e-01f, -7.26372376e-02f, 3.35790604e-01f, -2.50364058e-02f, -2.04012290e-01f, 1.19118365e-02f, 1.56416103e-01f, -1.13283629e-02f,
  1.02600619e-01f, 1.12121046e-01f, -8.41417089e-02f, 8.23646337e-02f, 2.02302679e-01f, 2.51984894e-01f, 8.15519169e-02f, 2.58293133e-02f, 2.44611189e-01f, 1.55181125e-01f,
  -9.75448545e-03f, 3.03154588e-01f, -2.87359469e-02f, 2.38290355e-01f, 2.39220764e-02f, 1.88946316e-03f, -6.99063987e-02f, 3.75335775e-02f, 1.57517359e-01f, 1.46237120e-01f,
  8.74097049e-02f, -5.12281619e-03f, 1.75742462e-01f, 5.91641478e-02f, 1.01508774e-01f, 2.44651556e-01f, 1.19247228e-01f, 1.74822226e-01f, 2.17112675e-01f, -8.47408250e-02f,
  9.78990048e-02f, 1.30800173e-01f, 8.32840875e-02f, 1.79639235e-01f, 2.67337173e-01f, 2.10959271e-01f, -9.95333716e-02f, 2.77519375e-01f, 1.18024312e-02f, 1.63126469e-01f,
  4.12032288e-03f, 1.24426618e-01f, -7.68528506e-03f, 2.14238521e-02f, 1.89382896e-01f, 4.23308820e-01f, -1.52811244e-01f, 1.12650640e-01f, 1.61327615e-01f, 1.16320498e-01f,
  8.06180090e-02f, -1.19331121e-01f, 1.98584765e-01f, -3.58315296e-02f, -6.02396801e-02f, 1.79782927e-01f, 2.23598003e-01f, 9.70078111e-02f, 1.00539349e-01f, -1.34805307e-01f,
  8.48487094e-02f, -3.10881346e-01f, 9.56432447e-02f, 1.22118458e-01f, -1.57259911e-01f, 2.33340517e-01f, -4.98354249e-02f, -4.94736657e-02f, 4.59813066e-02f, -5.89137785e-02f,
  -5.29481694e-02f, -1.45628318e-01f, 5.57549968e-02f, 1.10548563e-01f, 9.92895290e-02f, 3.54354903e-02f, 1.23993687e-01f, -8.24602991e-02f, -1.41609117e-01f, 3.22290286e-02f,
  -7.24800229e-02f, 1.34240771e-02f, 6.99309632e-02f, -5.33254556e-02f, -6.20139427e-02f, 3.40945050e-02f, -5.17432429e-02f, 8.51961076e-02f, -6.35018721e-02f, -1.57770477e-02f,
  6.33145794e-02f, -1.08018368e-01f, -1.22087650e-01f, -1.07543863e-01f, -1.13805206e-02f, -8.88440683e-02f, -1.09380297e-01f, -4.38922495e-02f, -7.44581819e-02f, -9.93903279e-02f,
  -4.81491312e-02f, 1.16373643e-01f, -1.27588073e-02f, -8.94631594e-02f, 2.30306573e-02f, -1.22639872e-01f, 9.02697369e-02f, -2.04108357e-02f, -7.13575855e-02f, 8.91086683e-02f,
  1.06872693e-01f, 7.25462064e-02f, 1.01271242e-01f, 6.37043417e-02f, 8.23191926e-02f, 2.62413323e-02f, -4.67901118e-02f, 6.41081631e-02f, 1.11406832e-03f, -1.21637538e-01f,
  -1.20219409e-01f, 1.06778279e-01f, -1.15470037e-01f, 4.99741733e-02f, 1.25292521e-02f, 4.59150225e-03f, 6.29476681e-02f, 5.67276180e-02f, 2.12129336e-02f, 4.15790118e-02f,
  -7.53942803e-02f, -3.36832069e-02f, -1.03920840e-01f, 2.75092367e-02f, -5.63091896e-02f, -1.13867940e-02f, 7.00283200e-02f, -1.12268701e-01f, -4.85219382e-04f, 1.06562778e-01f,
  -1.17780946e-01f, -6.73136637e-02f, -5.71750812e-02f, 2.39259633e-03f, 8.77685845e-02f, -1.26852185e-01f, -9.83732641e-02f, 1.54669791e-01f, -9.38301682e-02f, 5.02460338e-02f,
  1.10740744e-01f, 3.14087719e-02f, -2.71783285e-02f, -1.54204458e-01f, -2.02088766e-02f, -3.16615999e-02f, 9.09497291e-02f, -5.47167547e-02f, 4.93084043e-02f, -7.85995722e-02f,
  1.29151300e-01f, 1.37191162e-01f, -1.63484022e-01f, -1.48553982e-01f, -1.76283444e-04f, -1.45366833e-01f, 3.89749967e-02f, -1.00065932e-01f, 9.41310376e-02f, 9.19182599e-02f,
  -1.02450863e-01f, 1.29293099e-01f, -1.15673788e-01f, -1.71927258e-01f, 1.29808202e-01f, 2.29852051e-02f, -7.77955353e-02f, -1.24561965e-01f, -5.85941300e-02f, 1.64273977e-02f,
  -5.46494685e-02f, -1.90385610e-01f, 1.64683655e-01f, -1.18790761e-01f, -1.56765699e-01f, -8.79085734e-02f, 1.21297568e-01f, 1.27922386e-01f, 5.19800112e-02f, 1.07021779e-01f,
  1.50521949e-01f, 2.42179241e-02f, 3.09690889e-02f, -1.33816004e-01f, 1.29471358e-03f, -1.37338275e-02f, 1.05247229e-01f, 8.87734592e-02f, 8.49950910e-02f, 5.89757450e-02f,
  -2.05425248e-02f, -9.53492895e-02f, 1.08719140e-01f, -1.01480477e-01f, -2.04342008e-02f, 2.13665031e-02f, -6.14157394e-02f, 7.13046268e-02f, 1.03176683e-01f, -5.93879260e-02f,
  -5.98810576e-02f, 6.39762506e-02f, -1.08702593e-01f, -7.85559416e-02f, -1.20299086e-01f, -1.09204594e-02f, -1.23701520e-01f, -1.32186357e-02f, -8.14054385e-02f, 3.55072729e-02f,
  3.27348001e-02f, -4.75703217e-02f, 8.07432383e-02f, -1.02273151e-01f, 7.23881796e-02f, -2.34857313e-02f, 3.59006401e-04f, -2.06119642e-02f, 6.56084642e-02f, -1.03331670e-01f,
  -9.05383844e-03f, 1.54201407e-02f, 1.27685934e-01f, -7.98730031e-02f, -2.74177119e-02f, 2.66292151e-02f, 1.26411557e-01f, -2.39771120e-02f, -4.93888929e-02f, 2.36533619e-02f,
  -2.26294845e-02f, -5.13495095e-02f, 7.68639892e-02f, -2.70304549e-02f, 1.04357406e-01f, 1.09029345e-01f, 9.57887769e-02f, -7.53474757e-02f, 1.08653300e-01f, 5.38717397e-02f,
  -3.36630270e-02f, -5.70484139e-02f, -4.11690287e-02f, -1.31551251e-01f, 9.32725146e-02f, 5.24738915e-02f, 8.52784067e-02f, -6.39097467e-02f, 1.06025875e-01f, 3.09481770e-02f,
  -2.60745771e-02f, 1.76895391e-02f, -1.94719508e-02f, 8.99389610e-02f, 2.41286848e-02f, 4.67041098e-02f, 5.16375341e-02f, -4.55416515e-02f, -4.30538394e-02f, -1.18584633e-01f,
  -1.23898052e-01f, 3.76188494e-02f, 1.23247467e-01f, 1.19178310e-01f, 2.48671710e-01f, -1.48787238e-02f, 1.16896205e-01f, 9.65134799e-02f, 1.44090518e-01f, 1.28268391e-01f,
  7.04407785e-03f, 6.47855327e-02f, 1.39101535e-01f, 1.02873966e-01f, 4.54413965e-02f, 1.15764327e-01f, 6.66822940e-02f, 6.29683286e-02f, 1.75783709e-01f, 2.30231434e-01f,
  -2.65309662e-02f, -7.22170323e-02f, -1.79715250e-02f, 2.32354924e-01f, -1.32207528e-01f, 8.72453004e-02f, 1.03178561e-01f, -1.03633419e-01f, 6.48041517e-02f, -9.18549448e-02f,
  4.47365157e-02f, 1.95862100e-01f, 1.55262768e-01f, 3.79036479e-02f, 2.57234216e-01f, 1.26117811e-01f, 1.19196355e-01f, -1.93519458e-01f, -1.93230771e-02f, 6.96285674e-03f,
  1.56454109e-02f, 1.01139992e-01f, 2.07886606e-01f, 2.70723850e-02f, -1.93656504e-01f, -3.99467908e-03f, -6.29750490e-02f, -8.12579691e-02f, 4.49850708e-02f, 2.28076186e-02f,
  5.75516261e-02f, 1.04532517e-01f, -4.65543382e-02f, 7.00050816e-02f, -1.90170676e-01f, -1.51915252e-01f, -7.90401772e-02f, -2.23887824e-02f, 1.09770067e-01f, -1.17576301e-01f,
  9.57678258e-02f, 2.65194532e-02f, 6.75989613e-02f, 1.38605565e-01f, 7.13938475e-02f, -2.77453922e-02f, -1.10609517e-01f, 9.88487154e-02f, -5.89572825e-02f, -1.16948485e-01f,
  -1.40437984e-03f, -1.14900030e-01f, 1.10550039e-02f, -8.23977441e-02f, -8.99566114e-02f, -1.07822083e-01f, -1.09126456e-01f, 9.65390429e-02f, 7.70693570e-02f, -9.96666029e-02f,
  -2.72806529e-02f, 1.60937347e-02f, 9.38740373e-03f, -1.14701837e-01f, 8.23461544e-03f, -5.21001546e-03f, 5.98778948e-02f, -1.21797681e-01f, 8.85592028e-02f, -3.52442302e-02f,
  1.19671792e-01f, -9.80419740e-02f, 5.71082048e-02f, -1.92333180e-02f, 8.75958987e-03f, 5.31265065e-02f, 8.74307379e-02f, -3.03167291e-02f, -8.82542878e-02f, -2.81468313e-02f,
  -8.95187110e-02f, 1.22895390e-01f, -5.57832681e-02f, 3.52918096e-02f, 5.72507754e-02f, 1.22723326e-01f, -1.14815377e-01f, 1.10464450e-02f, 1.83721967e-02f, -6.94499835e-02f,
  1.28713041e-03f, -7.77873918e-02f, -8.81510302e-02f, -1.04924381e-01f, -4.76047061e-02f, -1.38305044e-02f, 2.59168725e-02f, 8.76940563e-02f, 2.93389166e-04f, -7.23835230e-02f,
  1.21746361e-01f, 1.04078136e-01f, 1.09626435e-01f, 6.55663945e-03f, -2.76523679e-02f, -5.12830075e-03f, -1.18168034e-01f, 8.61230306e-03f, -1.38847502e-02f, 4.48838323e-02f,
  -1.87885523e-01f, 2.11721081e-02f, -1.13523668e-02f, -1.71733163e-02f, -1.87597089e-02f, 1.81031581e-02f, 5.58210127e-02f, -1.76984742e-02f, 3.46411802e-02f, 1.72517076e-01f,
  -1.10657163e-01f, -1.36468560e-02f, 2.12784018e-02f, 9.46658254e-02f, 1.28948048e-01f, -2.86591873e-02f, 1.36520127e-02f, 1.15724124e-01f, -2.66262749e-03f, 2.70516455e-01f,
  -1.47348657e-01f, 1.57822013e-01f, -7.81575367e-02f, -3.78218405e-02f, -1.13287076e-01f, -2.23089427e-01f, -1.33839354e-01f, 3.57717574e-02f, -2.25516893e-02f, 1.83467895e-01f,
  -6.56867623e-02f, -6.50064200e-02f, 2.46296916e-02f, -2.73700953e-01f, 1.55626431e-01f, 1.84577808e-01f, 9.82933939e-02f, 1.81607809e-02f, 1.39210537e-01f, -1.96819067e-01f,
  2.06190512e-01f, 5.25937080e-02f, -1.33860514e-01f, 2.97333915e-02f, 6.04769625e-02f, 3.55864078e-01f, 1.74533546e-01f, -9.23574120e-02f, 4.88667339e-01f, 6.16038851e-02f,
  9.55823585e-02f, 5.09559065e-02f, 1.11427180e-01f, 3.38885561e-02f, 4.76500094e-02f, -3.07070967e-02f, 1.92306831e-01f, 1.07335456e-01f, 1.01593077e-01f, -5.26724309e-02f,
  -6.24493435e-02f, 1.02807626e-01f, -2.02128217e-01f, -1.01728149e-01f, 2.17623785e-02f, 3.02767873e-01f, 9.25561786e-02f, 1.17146298e-01f, 1.09797433e-01f, 1.97505206e-02f,
  6.06174693e-02f, 2.07271934e-01f, 1.10780850e-01f, 1.69047385e-01f, 1.73111092e-02f, 1.20239481e-01f, 1.81505755e-01f, 3.01643573e-02f, 7.09179640e-02f, 2.39177167e-01f,
  -3.16885449e-02f, 2.03332126e-01f, 7.46159926e-02f, -8.09197128e-03f, 2.20133439e-01f, -7.72764310e-02f, -1.06208190e-01f, 5.33369258e-02f, 2.86062062e-01f, 2.48779520e-01f,
  8.25505983e-03f, -2.36088544e-01f, -1.72548175e-01f, 1.36103407e-01f, -1.63037837e-01f, -8.29098895e-02f, 2.39761099e-01f, 2.36490548e-01f, 1.50402054e-01f, -2.18451202e-01f,
  -2.37490758e-02f, -1.41435608e-01f, 4.21757139e-02f, 2.90278252e-02f, 1.27425447e-01f, -5.96813597e-02f, -1.90084115e-01f, 5.75015061e-02f, 1.94707941e-02f, -7.49123096e-02f,
  -3.72832678e-02f, 1.80326581e-01f, -1.10106878e-01f, 9.16723460e-02f, -3.65903787e-02f, 4.34332788e-02f, 8.60423520e-02f, 6.26726300e-02f, 2.54903119e-02f, 2.53911875e-02f,
  1.37415782e-01f, -2.28893384e-02f, -1.14413142e-01f, 4.33477350e-02f, 5.19633591e-02f, -8.58329013e-02f, 2.63863027e-01f, -1.10501833e-01f, 1.68851525e-01f, 6.93111196e-02f,
  1.07659407e-01f, -5.25382394e-03f, -1.36507666e-02f, 3.94782573e-02f, 4.43885848e-02f, -3.45029607e-02f, 4.58603464e-02f, -1.13000616e-01f, -5.12849987e-02f, 6.71820045e-02f,
  1.90650150e-01f, 2.25478947e-01f, 8.04164931e-02f, -8.13831692e-04f, 8.89158547e-02f, 5.39908595e-02f, -1.49143517e-01f, -8.40709135e-02f, -1.67550072e-01f, -2.09164441e-01f,
  -1.57510474e-01f, -1.60459772e-01f, 1.02307931e-01f, 9.06851143e-02f, 3.22770625e-02f, 1.60959050e-01f, -1.70110613e-02f, -1.40971631e-01f, 9.44610164e-02f, -1.19715296e-01f,
  6.18724190e-02f, 1.16282813e-01f, 1.33290529e-01f, -4.30047419e-03f, 1.65251300e-01f, -1.89278826e-01f, -2.07877737e-02f, 9.00672749e-02f, 5.18850088e-02f, 1.14922993e-01f,
  1.78098023e-01f, -1.06165051e-01f, 3.38149909e-03f, 1.70066401e-01f, 9.10602957e-02f, -5.33390082e-02f, -9.47671682e-02f, -1.47663653e-01f, -4.27205674e-02f, 1.30153792e-02f,
  1.57330651e-02f, -1.98310590e-03f, -4.38375957e-03f, 3.27481255e-02f, 9.59870294e-02f, -9.49364752e-02f, 1.11271858e-01f, 1.02613360e-01f, 7.64102042e-02f, 7.19244406e-02f,
  1.06817722e-01f, -3.53485420e-02f, 4.77773398e-02f, 3.01335216e-03f, -2.60532741e-02f, 8.82247686e-02f, 2.99349055e-02f, -1.09633088e-01f, -9.96802747e-02f, 7.56116137e-02f,
  5.54826297e-02f, 1.36043578e-01f, -1.09286755e-01f, -5.97071834e-02f, 4.75045256e-02f, -7.42246434e-02f, 9.37867761e-02f, -1.36336116e-02f, -1.11591712e-01f, -4.33084890e-02f,
  -5.69987707e-02f, -7.42403045e-02f, -6.56663552e-02f, -6.71774670e-02f, -1.32426322e-01f, 1.52651474e-01f, 8.63327086e-02f, 8.91500264e-02f, 9.70774963e-02f, 1.15868263e-01f,
  -6.91314042e-02f, -1.36186078e-01f, -1.73576355e-01f, -1.20438777e-01f, 6.40709698e-02f, -1.78707074e-02f, 1.99603476e-02f, -1.56489179e-01f, -1.20001718e-01f, -3.71784866e-02f,
  -1.35635614e-01f, 1.35813206e-01f, -9.86755267e-02f, -5.90116121e-02f, 3.97345461e-02f, 1.43107429e-01f, 1.01974085e-01f, 4.54108231e-02f, -8.03875625e-02f, -9.78716016e-02f,
  -7.83425719e-02f, -4.74775247e-02f, -1.53649896e-02f, -4.96081188e-02f, 1.11215562e-01f, 5.42868339e-02f, -2.77674031e-02f, 6.28694752e-03f, 1.01206355e-01f, 2.57899817e-02f,
  -9.07490682e-03f, -4.52602841e-02f, 4.21330845e-03f, -8.10279250e-02f, 2.39200424e-03f, -1.04577228e-01f, -8.99783708e-03f, 9.75717008e-02f, 4.96689379e-02f, 1.30617991e-01f,
  5.79945445e-02f, 7.71232545e-02f, -7.37469867e-02f, 5.17905131e-02f, 4.64681871e-02f, 6.86226785e-02f, 7.47502223e-02f, 2.46309042e-02f, -5.21657690e-02f, 1.38640195e-01f,
  -7.63517395e-02f, 1.25909030e-01f, -7.25949332e-02f, 1.48391053e-02f, 2.06404045e-01f, -5.67461289e-02f, 1.80994809e-01f, 6.53844848e-02f, 1.05410218e-01f, -5.42746205e-03f,
  -1.60995081e-01f, 9.15618241e-02f, 1.96467444e-01f, -1.16055198e-01f, -2.03048155e-01f, 1.27914762e-02f, 1.62176833e-01f, 2.03115299e-01f, 1.01617053e-01f, -4.40963060e-02f,
  -5.47252744e-02f, -1.62884250e-01f, -1.88198045e-01f, 9.97039974e-02f, -7.86928758e-02f, 1.17543429e-01f, 2.81031102e-01f, 2.25357804e-02f, 1.61076300e-02f, 1.38805285e-01f,
  -3.50500718e-02f, -9.64888409e-02f, -8.99739470e-03f, 1.69524282e-01f, -6.43093139e-02f, 2.14400366e-01f, -2.19119955e-02f, -8.60972628e-02f, 1.12131990e-01f, 1.22290596e-01f,
  -1.25981495e-01f, 8.69578794e-02f, -1.67182624e-01f, 1.74698144e-01f, 1.94209907e-02f, 2.25180238e-01f, 9.83975902e-02f, -1.56524815e-02f, 1.62352219e-01f, -5.81610464e-02f,
  8.03004652e-02f, -1.55110704e-03f, 1.01322234e-01f, 2.91417558e-02f, 1.66498143e-02f, 6.78320229e-02f, 3.03812716e-02f, 1.82976276e-01f, -4.73961011e-02f, 1.21754408e-01f,
  -3.48883308e-02f, 5.75647093e-02f, 1.10716499e-01f, -1.07418768e-01f, 1.86521746e-02f, 1.23342812e-01f, 1.45447880e-01f, 8.40560123e-02f, -1.58328693e-02f, -1.08870687e-02f,
  3.40505168e-02f, 9.55761299e-02f, -1.13416158e-01f, 5.97790554e-02f, 1.53555267e-03f, -7.04678297e-02f, -1.82610154e-01f, 1.61682256e-02f, -8.03473294e-02f, 3.01751345e-01f,
  2.75308397e-02f, -1.27330201e-03f, -1.65497195e-02f, 9.98729467e-02f, 2.11856380e-01f, -1.01207413e-01f, 8.16754028e-02f, -9.40898806e-02f, -3.56779993e-02f, -4.98929136e-02f,
  8.81664008e-02f, 1.15108602e-01f, -1.84136212e-01f, -1.24295413e-01f, -6.20323978e-02f, 4.01825197e-02f, -1.28257340e-02f, 7.29111722e-03f, 6.89264014e-02f, -3.71240526e-02f,
  1.35636404e-01f, -4.69607040e-02f, 9.82398465e-02f, 3.68474573e-02f, -1.16768286e-01f, 2.51419619e-02f, 3.53587300e-01f, 4.84204814e-02f, -1.17193479e-02f, -6.53950199e-02f,
  -1.20710373e-01f, -1.09568313e-01f, -1.04427047e-01f, 8.20314959e-02f
};

// L2_fan_Bp_bar (Shape: 1 x 26)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 26;
const float L2_fan_Bp_bar_data[] = {
  -9.77647230e-02f, 2.25019395e-01f, 1.32535562e-01f, -4.68801372e-02f, 4.21306267e-02f, 2.42498353e-01f, 5.86128496e-02f, -6.08166307e-02f, 1.97266296e-01f, 1.53458133e-01f,
  -5.25129735e-02f, 1.54731005e-01f, -5.35755828e-02f, 1.23306558e-01f, 1.72238335e-01f, 1.25661820e-01f, 1.05578229e-01f, -1.17309384e-01f, -4.10297066e-02f, -1.11427009e-01f,
  -1.32577782e-02f, 1.93007305e-01f, 1.80584669e-01f, 1.03637874e-01f, 9.58324969e-02f, 2.58368608e-02f
};

// L3_linear_W (Shape: 12 x 64)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 64;
const float L3_linear_W_data[] = {
  1.02722883e-01f, -3.60312492e-01f, 7.92045239e-03f, 6.54890165e-02f, 1.86562747e-01f, 1.36952430e-01f, 1.85854450e-01f, -3.82030122e-02f, -1.39731439e-02f, 9.75325182e-02f,
  -2.75195181e-01f, 3.94915715e-02f, 1.48828654e-03f, -5.19552305e-02f, 3.89545232e-01f, 1.20162368e-01f, -3.75704058e-02f, -2.59348541e-01f, 2.46751457e-01f, -9.26079974e-02f,
  -2.52932161e-01f, -4.63487767e-02f, 3.06082785e-01f, -1.25795692e-01f, -3.39977354e-01f, -2.71951631e-02f, -3.37272882e-01f, -1.96757793e-01f, 1.33066848e-01f, -3.26843202e-01f,
  -3.11604202e-01f, -3.12183499e-02f, -7.37403706e-02f, 4.74662632e-01f, -5.36075234e-02f, 2.89836586e-01f, 4.13603902e-01f, -2.94705570e-01f, -4.55873879e-03f, 3.66550177e-01f,
  -5.40730536e-01f, 2.17654511e-01f, 4.07559901e-01f, 2.88270921e-01f, -5.02100527e-01f, 4.16082777e-02f, 1.39216483e-02f, -3.88222069e-01f, -7.84807578e-02f, -3.36170822e-01f,
  -3.61965708e-02f, -1.04890458e-01f, 3.90711814e-01f, 1.21529214e-01f, -1.36558861e-01f, 8.58430862e-02f, 4.03366657e-03f, 1.20495050e-03f, -2.29058459e-01f, -2.68608127e-02f,
  1.45233363e-01f, 8.27833787e-02f, -1.84494510e-01f, 3.53717394e-02f, -1.85792848e-01f, -3.25285971e-01f, 9.99751240e-02f, -1.76232278e-01f, -4.19333816e-01f, -2.03030199e-01f,
  -7.50951767e-02f, 2.02323377e-01f, 1.44075960e-01f, 1.98899493e-01f, -3.85925323e-01f, 1.54306605e-01f, -7.09557980e-02f, 1.32307321e-01f, -3.55888791e-02f, -8.97838101e-02f,
  -1.15056168e-02f, -1.91674188e-01f, 3.56412441e-01f, -2.32554838e-01f, -3.03498149e-01f, -8.17435235e-02f, 3.68784308e-01f, 3.67363870e-01f, 3.82951051e-01f, 3.13207507e-01f,
  2.24946693e-01f, -2.82665808e-02f, -3.55369687e-01f, -1.95351720e-01f, -9.96556878e-02f, 1.73127025e-01f, 1.35627821e-01f, -1.65391620e-02f, 1.91950932e-01f, -2.43068114e-01f,
  4.06612784e-01f, -1.05127193e-01f, -6.91982135e-02f, 1.99707329e-01f, -3.88723791e-01f, -1.42993271e-01f, -1.54645946e-02f, 5.17146587e-01f, -4.53858562e-02f, 1.00834407e-01f,
  -1.48394495e-01f, -4.53670710e-01f, -5.07018119e-02f, -3.58455747e-01f, -1.35535657e-01f, 3.13218564e-01f, -2.72992402e-01f, 6.34317845e-02f, 1.30329326e-01f, -3.79412472e-02f,
  -2.38497540e-01f, -6.21049553e-02f, 2.86439866e-01f, -3.52580935e-01f, -6.63499087e-02f, -9.92658958e-02f, 2.22043004e-02f, 2.43023291e-01f, 1.57894567e-02f, 1.18596531e-01f,
  -1.26820698e-01f, 1.52685689e-02f, -2.60771781e-01f, -3.13651085e-01f, 2.98152324e-02f, -3.37974668e-01f, 4.40978408e-02f, -7.03433082e-02f, 1.75249815e-01f, 8.59658420e-02f,
  -1.13306558e-02f, 1.13006860e-01f, -1.57730088e-01f, 1.29152099e-02f, -4.26883042e-01f, 2.53557526e-02f, 1.09368294e-01f, 1.50346398e-01f, 4.08709496e-02f, 1.79466218e-01f,
  -1.61632989e-02f, -1.34492621e-01f, 1.80522770e-01f, 2.31158406e-01f, 2.84204304e-01f, 1.23513632e-01f, 6.53170571e-02f, -1.75502017e-01f, 1.05235912e-01f, -9.21131391e-03f,
  2.08560035e-01f, 2.54647620e-02f, -3.54224801e-01f, -1.48904100e-01f, -5.17890871e-01f, 5.22286832e-01f, -7.23990351e-02f, 4.85457063e-01f, -2.40287110e-01f, 5.15119098e-02f,
  1.98729053e-01f, 8.78067464e-02f, -4.32951689e-01f, -7.99732506e-02f, -7.67762680e-03f, -3.42948645e-01f, 6.83647245e-02f, 1.53867230e-02f, 7.10460916e-02f, 2.34667644e-01f,
  -3.63715410e-01f, 1.01381190e-01f, 3.38583916e-01f, -1.18573621e-01f, -3.81908566e-01f, 6.56422004e-02f, 1.64671734e-01f, -4.69067961e-01f, 1.51687428e-01f, -9.39129889e-02f,
  -1.36526421e-01f, -2.86191136e-01f, 1.57181919e-01f, -1.15316054e-02f, -5.22756837e-02f, -1.71188176e-01f, -2.74853170e-01f, -1.30606860e-01f, -1.94458425e-01f, -2.55674183e-01f,
  1.18146606e-01f, 2.08065018e-01f, -7.41060078e-02f, 1.04559928e-01f, 2.88999937e-02f, -1.91329747e-01f, 8.76348019e-02f, 1.31793171e-01f, 1.80818774e-02f, 1.58722401e-01f,
  -2.18095198e-01f, 2.08423406e-01f, -7.42234886e-02f, -3.22786323e-03f, -4.51566458e-01f, -3.77418816e-01f, -3.69287401e-01f, -3.66634816e-01f, -2.45630607e-01f, 9.28287283e-02f,
  5.81853501e-02f, 3.26714963e-01f, 5.31532243e-02f, 1.82330266e-01f, -1.04445517e-01f, 1.06933797e-02f, -1.42538235e-01f, 2.39631027e-01f, 1.80967629e-01f, -2.36334458e-01f,
  1.83535010e-01f, -1.65539995e-01f, 9.74954888e-02f, 8.03297013e-02f, -2.16867179e-01f, -6.59668982e-01f, 1.21102713e-01f, -4.93645258e-02f, 2.52192050e-01f, 3.12694937e-01f,
  9.70082078e-03f, 4.19722140e-01f, -1.51315732e-02f, -2.88144827e-01f, 3.60253245e-01f, 4.91232462e-02f, -3.27645168e-02f, 1.18105143e-01f, 2.60083526e-01f, -9.19508114e-02f,
  -3.87601137e-01f, 1.66889966e-01f, -3.63155633e-01f, -2.32306853e-01f, 3.98957670e-01f, -1.01528585e-01f, 2.29956836e-01f, 1.49372905e-01f, 6.70297071e-02f, 1.73483565e-01f,
  1.92967176e-01f, 1.37987509e-01f, -2.70850826e-02f, -1.47939488e-01f, -1.94400325e-02f, 6.97729215e-02f, 4.47939366e-01f, 1.02710582e-01f, -8.43548924e-02f, 2.66850203e-01f,
  6.96632080e-03f, 1.36896819e-01f, 4.70985472e-02f, 1.74269587e-01f, -4.17208225e-01f, -2.67773062e-01f, 9.62370560e-02f, -1.80488274e-01f, 1.96064666e-01f, -3.98182213e-01f,
  -2.05184862e-01f, -5.58161736e-01f, -1.59352377e-01f, -5.74096180e-02f, 2.32245639e-01f, -1.15227155e-01f, -2.18438774e-01f, -1.82184801e-01f, -6.08709687e-03f, -2.61752337e-01f,
  2.13093132e-01f, 2.47361958e-01f, 2.54479617e-01f, 3.24282348e-01f, 8.34357589e-02f, -3.81334662e-01f, 1.40177116e-01f, -1.45804808e-02f, 2.79229581e-01f, 5.19825257e-02f,
  1.31229177e-01f, 5.22144064e-02f, 2.42347255e-01f, 6.09920062e-02f, 1.01349331e-01f, -5.60212620e-02f, 1.24560436e-02f, -7.93244243e-02f, 3.31407547e-01f, 7.33390972e-02f,
  -6.99145347e-02f, 1.08560115e-01f, 9.83211026e-02f, 1.00397892e-01f, -3.95419806e-01f, 4.52510923e-01f, 7.54033327e-02f, 4.32162993e-02f, -1.84519649e-01f, 2.00804248e-01f,
  -2.48979822e-01f, -3.26864332e-01f, -1.73947196e-02f, -1.80967510e-01f, 9.25963745e-02f, 1.03389435e-01f, -9.62063000e-02f, 9.12214592e-02f, -2.19029739e-01f, -1.18806362e-01f,
  -3.33060592e-01f, -3.91015597e-02f, -7.49431700e-02f, -6.70029200e-04f, 1.61974490e-01f, -1.86681122e-01f, 1.12511665e-02f, -5.66812575e-01f, -2.86862910e-01f, -1.59702927e-01f,
  -1.51931882e-01f, -3.43807280e-01f, 2.72113502e-01f, -5.78570776e-02f, 2.23308429e-02f, 2.39315167e-01f, -3.08986977e-02f, -9.61673539e-03f, -4.60077643e-01f, -2.96985775e-01f,
  -2.73612440e-01f, 5.40591823e-03f, 1.77663505e-01f, -1.11706473e-01f, 2.18187034e-01f, 2.73704886e-01f, 5.48824407e-02f, 1.11697756e-01f, -1.56014845e-01f, -3.19348544e-01f,
  1.41400188e-01f, 2.15911701e-01f, -2.67936081e-01f, 3.57715517e-01f, 3.22526127e-01f, 4.07068580e-02f, -3.59748006e-01f, 1.12686634e-01f, 9.40317288e-02f, -2.61146389e-02f,
  -1.37802050e-01f, -1.17196530e-01f, 2.77254969e-01f, -1.22581556e-01f, -1.02561951e-01f, 1.13427728e-01f, 3.10208201e-01f, -1.27500668e-02f, 3.27981025e-01f, 7.94164240e-02f,
  7.16703236e-02f, 2.27917638e-03f, -4.17460293e-01f, 2.95134097e-01f, -4.68698069e-02f, 4.43035290e-02f, -1.65831834e-01f, -8.30060020e-02f, -5.02787121e-02f, -3.39073300e-01f,
  1.75293118e-01f, 5.26048988e-02f, -3.04434299e-01f, 1.65640697e-01f, 1.03351019e-01f, 9.27715003e-02f, 1.49243267e-03f, 2.77356338e-02f, -4.92658615e-01f, 6.84886891e-03f,
  1.60544351e-01f, 3.20226580e-01f, -1.48184419e-01f, -2.65762985e-01f, 1.41966462e-01f, 1.31019384e-01f, -3.85669440e-01f, 3.64703596e-01f, 2.13716939e-01f, 3.09775114e-01f,
  3.94814640e-01f, -2.54231006e-01f, -3.12223017e-01f, -8.63018557e-02f, -6.79843128e-02f, -1.43809333e-01f, 1.69626608e-01f, 8.72116163e-02f, 4.10582200e-02f, -1.50932774e-01f,
  -1.94495589e-01f, -2.18315601e-01f, -1.19944476e-01f, 1.46630019e-01f, 4.90141869e-01f, -2.25386277e-01f, -5.55375963e-02f, -1.83080181e-01f, 2.55790114e-01f, -8.94154236e-02f,
  -9.13367048e-02f, 2.75582343e-01f, 1.66827589e-01f, -6.01903424e-02f, 2.79771656e-01f, -8.96177664e-02f, 1.01496466e-02f, 8.94521847e-02f, -2.10327551e-01f, 2.98698060e-02f,
  6.35423213e-02f, 4.53179628e-02f, 4.60519850e-01f, -2.29363963e-01f, -2.29545295e-01f, 8.66818354e-02f, 1.80420522e-02f, 1.04885958e-02f, 4.77680340e-02f, 2.02913564e-02f,
  7.75395408e-02f, 8.10930654e-02f, 2.42386997e-01f, 9.09025595e-02f, -4.13044304e-01f, 1.06857829e-01f, 1.67549983e-01f, -5.85690662e-02f, 1.45652324e-01f, 2.97798570e-02f,
  2.96277069e-02f, 1.84480369e-01f, 1.99041024e-01f, -2.67413445e-02f, 1.76295832e-01f, 1.77451476e-01f, 1.40492871e-01f, 4.47156459e-01f, 2.59565115e-01f, -5.79702295e-02f,
  3.88342440e-01f, -7.27429241e-02f, -2.18921885e-01f, -3.51304442e-01f, -2.72231698e-01f, -7.76358098e-02f, 3.61208804e-02f, 2.57015228e-01f, -3.69968891e-01f, 4.86791022e-02f,
  -1.37204722e-01f, 3.81985903e-01f, -4.72167134e-01f, 1.96376994e-01f, -3.70009929e-01f, -1.56723037e-01f, 6.46659173e-03f, 8.67735073e-02f, -3.26956242e-01f, -6.87592477e-02f,
  -1.24495484e-01f, -1.92774326e-01f, -9.74843204e-02f, 6.24576285e-02f, 6.48778617e-01f, 7.36108124e-02f, -8.52462277e-02f, 7.51776323e-02f, 6.15032995e-03f, -5.25670171e-01f,
  -2.39386588e-01f, 5.86165115e-03f, 5.51172532e-02f, -1.18129939e-01f, -1.68062836e-01f, -6.87628686e-02f, -2.15667803e-02f, 4.35038626e-01f, 5.05948290e-02f, 2.48757124e-01f,
  1.89909130e-01f, -1.93493232e-01f, 1.07541867e-01f, -5.14332131e-02f, -2.70492017e-01f, 9.27635375e-03f, -3.09368640e-01f, 1.18728131e-01f, 1.95538402e-02f, 4.61622477e-02f,
  1.79637179e-01f, -2.29114234e-01f, -1.13256395e-01f, -8.36283416e-02f, 3.50541547e-02f, -3.09369490e-02f, 1.31899223e-01f, 1.17783509e-02f, -1.67512253e-01f, 1.21013515e-01f,
  1.69293493e-01f, 3.13827962e-01f, 4.46303189e-01f, 2.09276810e-01f, 5.60777113e-02f, 2.76345998e-01f, 5.26694022e-03f, 1.83989495e-01f, 3.10315996e-01f, 3.98267418e-01f,
  1.31003618e-01f, 4.49088216e-01f, 8.99050459e-02f, -1.82014346e-01f, -3.57465416e-01f, -4.54436149e-03f, -1.68006513e-02f, -2.92676240e-01f, -2.21852198e-01f, 2.35453516e-01f,
  -5.15173338e-02f, 9.84781086e-02f, 3.06399204e-02f, -7.08715022e-02f, -5.68343222e-01f, 3.44363719e-01f, 4.07783091e-01f, -7.24504441e-02f, -3.22307013e-02f, 3.49782109e-01f,
  -1.78405531e-02f, -1.96573243e-01f, 7.48281255e-02f, 4.23103511e-01f, -3.52487803e-01f, -6.91574141e-02f, -1.56854317e-02f, -4.60829400e-02f, -3.19831908e-01f, 5.67092337e-02f,
  -1.86294094e-01f, -3.27519029e-01f, -2.14767847e-02f, -5.50288819e-02f, 1.60311505e-01f, -1.46254137e-01f, -4.51541543e-02f, 2.12658539e-01f, 4.13797610e-02f, 2.16157302e-01f,
  1.58921778e-01f, 6.58717230e-02f, 2.29524210e-01f, 1.50233388e-01f, -1.38045073e-01f, 1.60283998e-01f, -1.75103888e-01f, 6.85334355e-02f, -1.27344087e-01f, -4.22219336e-01f,
  -1.49706051e-01f, 1.86161861e-01f, 2.28605315e-01f, 3.59960049e-01f, -2.79928237e-01f, -2.31541887e-01f, 1.83612540e-01f, -1.09311588e-01f, 1.04492739e-01f, 3.23329896e-01f,
  4.00039494e-01f, -3.68262917e-01f, 1.54331014e-01f, -6.94471225e-02f, 2.31017619e-01f, -3.50434631e-01f, -2.45482102e-01f, 2.00285226e-01f, 3.48020196e-01f, -1.66159719e-01f,
  7.46260881e-02f, 5.06459661e-02f, -1.82210520e-01f, -1.84384540e-01f, -6.20324537e-03f, 5.45845367e-02f, 6.98329881e-02f, 2.84525845e-02f, 5.87893963e-01f, 2.63307869e-01f,
  -3.48446429e-01f, 2.27205008e-02f, -2.12751552e-01f, -1.18987918e-01f, 4.45885994e-02f, -2.23603658e-02f, -1.30215744e-02f, -3.23630601e-01f, -4.20048118e-01f, 1.21883780e-01f,
  2.40759715e-01f, 1.12449311e-01f, 1.25232279e-01f, -1.15003012e-01f, -2.16537397e-02f, 6.96095750e-02f, 2.88981020e-01f, -1.35600448e-01f, -2.84406394e-01f, 1.03570983e-01f,
  2.41256002e-02f, -3.95873711e-02f, -1.89140767e-01f, -8.30091611e-02f, 3.75510603e-01f, 9.91700217e-02f, 2.19142064e-01f, 2.52988309e-01f, 2.26702616e-01f, -1.04823902e-01f,
  3.41993243e-01f, -1.56938717e-01f, 4.30318266e-02f, 9.11445022e-02f, -1.34683013e-01f, 1.28337070e-01f, 2.19872147e-01f, 3.49427879e-01f, 2.66933531e-01f, 1.71699584e-01f,
  -2.95309126e-01f, 2.44031310e-01f, -3.61921549e-01f, 8.05220846e-03f, 6.64419383e-02f, 2.37697270e-02f, 1.42918199e-01f, 1.25448152e-01f, 6.67683706e-02f, 2.21295998e-01f,
  3.58701408e-01f, 1.30853895e-02f, -2.73443580e-01f, -1.65126204e-01f, -1.05330847e-01f, -2.82676071e-01f, -2.37336934e-01f, -1.89353436e-01f, -3.61025147e-02f, 2.29324266e-01f,
  -2.34470680e-01f, 3.27275507e-02f, 2.07313865e-01f, -5.18915765e-02f, -1.36234179e-01f, -1.14053696e-01f, 8.30401853e-02f, -1.44532949e-01f, 4.81838733e-02f, 8.68651271e-02f,
  -1.88288063e-01f, 3.45559478e-01f, -1.14598600e-02f, -1.00364149e-01f, -1.80978999e-01f, 7.49885887e-02f, 2.34648988e-01f, 5.89270480e-02f, -2.83229291e-01f, 5.73391356e-02f,
  2.16176197e-01f, -8.21276084e-02f, 3.34857106e-01f, -2.26010755e-01f, -1.54320136e-01f, -1.00367792e-01f, 1.34231687e-01f, -5.91971315e-02f, 1.13561645e-01f, 1.56984851e-01f,
  3.72861661e-02f, -3.10995076e-02f, -9.07370821e-02f, -2.37723276e-01f, 1.90834880e-01f, -2.24860132e-01f, -1.29911434e-02f, -1.28144681e-01f, -6.31869435e-02f, -1.59338817e-01f,
  7.17707127e-02f, -2.76324838e-01f, -2.49587908e-01f, -1.12690311e-02f, -1.34568244e-01f, -2.32010424e-01f, -3.42397429e-02f, -1.15340315e-01f, 1.70637481e-02f, 1.49880588e-01f,
  1.37475058e-01f, -6.56970665e-02f, -3.39003384e-01f, 2.97481418e-01f, 3.47351670e-01f, -2.29853153e-01f, -2.54972011e-01f, -1.33942857e-01f, 1.24700367e-01f, 5.86075187e-02f,
  2.31082916e-01f, -3.46342623e-02f, 1.47624359e-01f, -7.27271378e-01f, 4.14404720e-01f, 2.21703071e-02f, -4.63942736e-01f, -2.83148438e-01f, 5.76570153e-01f, 2.81528407e-03f,
  -1.59321368e-01f, 4.96670604e-01f, -1.06216051e-01f, 3.36105019e-01f, -1.09688826e-01f, -1.97104961e-01f, 2.28431597e-01f, 1.00282945e-01f, 4.60970849e-02f, 7.58950338e-02f,
  -5.86944930e-02f, 5.60513400e-02f, 2.76614636e-01f, 8.09016898e-02f, -3.33821803e-01f, -1.42751979e-02f, 1.70583159e-01f, 1.24033444e-01f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  -7.19919801e-02f, -1.05780266e-01f, 1.58926332e-03f, -8.89619291e-02f, 8.12114105e-02f, -1.17091708e-01f, -1.13761790e-01f, 5.19655533e-02f, -1.47025683e-03f, 4.48400043e-02f,
  -1.02444947e-01f, -2.07186624e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 19, 26
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 19, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        64, 19, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        64, 12
    );
    }
    