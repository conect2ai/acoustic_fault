/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 9 x 120)
const int L0_fan_Wp_rows = 9;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -8.20918009e-02f, -1.52507154e-02f, -1.76495630e-02f, -1.18998967e-01f, -1.95567757e-01f, 2.70602584e-01f, 2.82957822e-01f, -2.17387900e-01f, -2.86388189e-01f, 1.23543710e-01f,
  1.04937099e-01f, 7.97849335e-03f, 1.68158874e-01f, 4.29313071e-02f, 3.51381898e-01f, 9.55399722e-02f, 4.86147702e-02f, 2.81711966e-02f, -1.79386929e-01f, -5.28572649e-02f,
  -1.34252816e-01f, 1.38938189e-01f, 1.64943695e-01f, -3.11134346e-02f, 9.94168222e-02f, -1.33481279e-01f, 6.53601214e-02f, 3.91804101e-03f, 1.08666070e-01f, 4.68176715e-02f,
  9.32594463e-02f, -3.33195850e-02f, -3.95551771e-02f, -3.08179203e-02f, -6.17614985e-02f, 6.94859680e-03f, 6.29541203e-02f, 1.28432944e-01f, -2.93367566e-03f, 4.32126038e-02f,
  1.99543312e-02f, 3.49750295e-02f, -6.10053679e-03f, 1.26640061e-02f, -1.32788092e-01f, -4.07674126e-02f, -6.36940151e-02f, -6.12974651e-02f, -3.00695132e-02f, 7.64240623e-02f,
  7.90383220e-02f, -5.32586686e-02f, -4.67008613e-02f, -4.58386168e-02f, -2.56067943e-02f, -8.10126662e-02f, 3.34851332e-02f, 6.90248087e-02f, 3.79187018e-02f, -5.03337756e-02f,
  2.23562755e-02f, -7.18105957e-02f, 3.97018194e-02f, -5.82033675e-03f, 5.49749546e-02f, 3.50256190e-02f, -5.31829894e-03f, 3.82226817e-02f, -3.47889699e-02f, 4.65334281e-02f,
  -7.36634731e-02f, -1.56750642e-02f, 2.82128155e-03f, 7.05789169e-03f, 1.29462844e-02f, -1.70660596e-02f, 3.33750769e-02f, 2.98427343e-02f, -1.09441690e-01f, -1.19870361e-02f,
  3.72251235e-02f, 3.38700041e-02f, 1.91605203e-02f, 5.65806441e-02f, 4.44320887e-02f, -4.98343259e-04f, -7.36695454e-02f, 4.54982333e-02f, -3.21449302e-02f, 8.16047192e-02f,
  -5.22379167e-02f, -1.71030119e-01f, -2.14857589e-02f, 6.75358670e-03f, -1.09182682e-03f, 6.85169995e-02f, -5.29641360e-02f, -3.94077525e-02f, -8.59994628e-03f, 6.00279123e-02f,
  1.35328686e-02f, 1.21822841e-02f, -9.90257598e-03f, 9.04848799e-03f, 5.47792716e-03f, 7.99000561e-02f, 5.76304831e-03f, -5.18382043e-02f, 1.94106866e-02f, -1.09534949e-01f,
  4.58620153e-02f, 7.79498601e-03f, -4.12074290e-02f, -1.35049978e-02f, 1.17167365e-02f, 2.14150120e-02f, -6.58507496e-02f, -6.17758892e-02f, 5.49031310e-02f, 2.33148783e-02f,
  -1.65756270e-01f, 4.43557858e-01f, 1.65017337e-01f, 1.57368511e-01f, -2.13492617e-01f, -4.25143540e-01f, -1.38099164e-01f, 2.24122684e-02f, -5.35770021e-02f, 3.04342330e-01f,
  2.97013987e-02f, 2.47609437e-01f, 1.64205134e-01f, 1.88685149e-01f, -3.26150179e-01f, 1.31194934e-01f, 7.78739713e-03f, 8.61368924e-02f, 4.19035554e-02f, 1.09761663e-01f,
  3.12754437e-02f, -3.27674709e-02f, 1.97352692e-01f, 3.21901925e-02f, 8.38709995e-02f, 1.66440398e-01f, 6.91544637e-02f, 5.18264063e-02f, 1.56003296e-01f, -1.71176009e-02f,
  -6.61797747e-02f, 2.15830088e-01f, 6.08319044e-03f, 1.29252123e-02f, 2.76535209e-02f, 4.48295586e-02f, 1.10962437e-02f, 6.43340498e-02f, 5.24051934e-02f, 8.38209391e-02f,
  2.94566602e-02f, -6.14537159e-03f, -1.10063178e-03f, 3.00380569e-02f, -9.02348310e-02f, 4.16247807e-02f, -2.14173850e-02f, -6.20149188e-02f, 2.30653603e-02f, -5.64934034e-03f,
  -1.73513051e-02f, 4.91564013e-02f, -8.09509605e-02f, 3.43615226e-02f, -3.88231538e-02f, 5.67880422e-02f, 4.94797863e-02f, -5.56126498e-02f, -2.43107062e-02f, 1.51657453e-03f,
  -6.07883818e-02f, -5.28238192e-02f, -3.02729215e-02f, 1.01985104e-01f, 1.77680224e-04f, -1.49950041e-02f, 1.72314122e-02f, 1.25880195e-02f, -8.19319766e-03f, -2.42443271e-02f,
  -4.92836013e-02f, 1.63859297e-02f, -7.04258587e-03f, -6.30961582e-02f, -7.87824218e-04f, 1.71995070e-02f, 3.01181595e-03f, 2.02544760e-02f, 4.73479964e-02f, -1.04926452e-01f,
  8.60117376e-02f, -4.42599282e-02f, 6.60256762e-03f, 6.59777001e-02f, 3.52510251e-02f, 4.01001424e-02f, 3.00077349e-03f, 3.53411981e-03f, 5.60675561e-02f, -5.24691679e-02f,
  -6.00852184e-02f, 1.62897855e-02f, -3.16360919e-03f, -3.15366383e-03f, 4.86520939e-02f, 4.30214778e-02f, -5.03448173e-02f, -9.98556167e-02f, 7.75978575e-03f, 3.77209927e-03f,
  -8.83377250e-03f, 1.35715306e-02f, -8.00456554e-02f, 1.12107107e-02f, -3.60638164e-02f, 2.42491439e-02f, 7.31691793e-02f, 1.41042322e-02f, -5.71165904e-02f, 9.23168939e-03f,
  -5.27079031e-03f, -3.67380157e-02f, -6.64426107e-03f, -7.15284050e-02f, -6.20775335e-02f, -2.66300123e-02f, -7.52108321e-02f, 1.70246400e-02f, 4.30731243e-03f, 1.13370651e-02f,
  -3.87713373e-01f, -1.98738068e-01f, -1.89606294e-01f, -4.38910276e-01f, 2.95439754e-02f, 1.10987417e-01f, -4.81037833e-02f, -1.65440589e-01f, -3.32659781e-01f, 3.21836472e-02f,
  5.04926853e-02f, -1.37526974e-01f, -1.64005980e-02f, -1.75846666e-01f, -2.48969585e-01f, -1.54233634e-01f, -1.96976259e-01f, -5.91325313e-02f, -1.23534247e-01f, -1.22245423e-01f,
  -1.34449810e-01f, 3.81635316e-02f, -6.89231232e-02f, 1.08998954e-01f, 6.28945157e-02f, -9.64106992e-02f, 1.33741125e-01f, 1.59021482e-01f, 5.82566531e-03f, 1.04388677e-01f,
  5.49396910e-02f, -5.41825173e-03f, -6.12387694e-02f, -2.74827573e-02f, -6.24841936e-02f, 6.27419353e-02f, 1.22182168e-01f, 8.69283006e-02f, -8.59784633e-02f, -2.65690815e-02f,
  8.00065771e-02f, -3.58568840e-02f, -6.33733571e-02f, 1.12148291e-02f, -3.15299928e-02f, -4.93048877e-02f, -4.55321744e-02f, 1.77636426e-02f, -4.29461412e-02f, 1.08562512e-02f,
  -3.35403904e-02f, 1.17384754e-02f, 6.30832091e-02f, -5.00160344e-02f, 2.69222390e-02f, -6.09710552e-02f, 3.22999135e-02f, 8.74208063e-02f, -1.05034402e-02f, -5.06873503e-02f,
  7.68021122e-02f, -1.72538552e-02f, 2.70804688e-02f, -3.83300297e-02f, -4.29742187e-02f, 3.99176963e-02f, 3.31434645e-02f, 2.50532571e-02f, -3.82567495e-02f, 8.40242673e-03f,
  -6.64737225e-02f, -3.44955362e-02f, 5.09211607e-03f, 4.50401055e-03f, -6.53228443e-03f, -5.32608256e-02f, 1.65650749e-03f, 9.26337913e-02f, -8.82867798e-02f, -3.28602083e-02f,
  5.07379062e-02f, -8.82674474e-03f, 4.92662005e-02f, 8.59450549e-02f, 7.55602494e-03f, 1.04134483e-03f, -9.55633074e-03f, 9.03348628e-05f, -1.57714859e-02f, 4.66071591e-02f,
  6.55920208e-02f, -8.03160593e-02f, -9.01268646e-02f, 1.00952899e-02f, 2.73359492e-02f, -2.22740322e-02f, -1.12647891e-01f, -1.00879800e-02f, 3.83864790e-02f, 5.01899328e-03f,
  6.11394048e-02f, -2.30647102e-02f, 5.11107668e-02f, 9.93064977e-03f, -2.23653484e-02f, 3.28947492e-02f, 1.07433766e-01f, 1.67339668e-02f, 2.36815051e-03f, -1.62332524e-02f,
  4.78435718e-02f, -3.57767381e-02f, -5.76109923e-02f, -4.77483450e-03f, -5.46193565e-04f, 8.40729177e-02f, -1.17284916e-02f, -1.44597553e-02f, 5.65211065e-02f, -6.75403997e-02f,
  -4.50316072e-01f, 3.64982814e-01f, 3.11856344e-03f, -1.33206576e-01f, 7.81982169e-02f, 9.29824486e-02f, -2.30122313e-01f, 2.52518386e-01f, 2.18372539e-01f, 3.52774821e-02f,
  7.88333267e-03f, -2.14207172e-01f, -1.53273263e-03f, 1.55317098e-01f, -1.24131702e-01f, 8.95908475e-02f, 6.88934997e-02f, -8.06269869e-02f, 1.34033322e-01f, -1.00652561e-01f,
  1.07954163e-03f, 3.69840860e-03f, -1.27065629e-01f, 1.04467265e-01f, -1.70966443e-02f, -6.96117133e-02f, -1.86999097e-01f, -7.06159920e-02f, -5.18304221e-02f, 9.83864889e-02f,
  4.27665859e-02f, 1.40236542e-01f, 3.44908908e-02f, 4.20468524e-02f, 4.74346466e-02f, 3.00661661e-02f, -1.60898566e-01f, -7.44875595e-02f, -3.86988334e-02f, 5.78354485e-02f,
  -8.50536600e-02f, -4.93001081e-02f, 9.26589221e-02f, 4.41813562e-03f, 5.54065406e-02f, 4.00118344e-02f, 7.25926682e-02f, 5.54581247e-02f, -4.80319634e-02f, -8.53760913e-02f,
  6.05919361e-02f, -3.86353694e-02f, 8.55936036e-02f, 2.49723792e-02f, 1.10274190e-02f, 7.03149959e-02f, -5.78150116e-02f, -9.82819274e-02f, 1.16299719e-01f, -1.23079885e-02f,
  1.43775428e-02f, -4.35235649e-02f, -6.07195757e-02f, 2.58325450e-02f, 5.29100075e-02f, 5.23158163e-02f, 1.58244185e-03f, -2.75103259e-03f, -2.41036550e-03f, -6.11243099e-02f,
  -8.25644732e-02f, -8.84549785e-03f, 1.11214750e-01f, -4.99004014e-02f, -9.42463204e-02f, -4.33316566e-02f, -5.17632663e-02f, 1.93172926e-03f, -4.98447269e-02f, -6.21915124e-02f,
  2.89895739e-02f, 5.92843406e-02f, -1.10177482e-02f, 6.11596704e-02f, 5.69885969e-02f, -1.69806667e-02f, 1.22619763e-01f, 2.92823333e-02f, -1.23483464e-02f, -3.10890153e-02f,
  -1.16448877e-02f, 9.53327194e-02f, 2.60578049e-03f, 3.03659886e-02f, 2.92228833e-02f, 3.20852399e-02f, 4.29833494e-02f, 7.12079182e-02f, -2.85470597e-02f, -1.38164228e-02f,
  -5.00229336e-02f, -3.78920361e-02f, 2.04558391e-02f, -1.61369126e-02f, -3.56375836e-02f, 1.37936130e-01f, -9.36875865e-02f, -1.06750928e-01f, 4.74339264e-04f, -3.38859744e-02f,
  -5.64714111e-02f, -8.44717026e-02f, -4.75779325e-02f, -1.06519451e-02f, 1.28078116e-02f, -1.65172726e-01f, -4.14095968e-02f, -3.54015492e-02f, 9.90819857e-02f, 9.48325079e-03f,
  3.96744043e-01f, -3.61016303e-01f, 2.23541126e-01f, -1.04371771e-01f, -1.19269058e-01f, -2.81198204e-01f, 7.19863549e-02f, -7.09492117e-02f, 7.50107393e-02f, -1.61121190e-01f,
  -6.72655273e-03f, -9.17657167e-02f, 1.91705093e-01f, -1.79171726e-01f, 3.17120135e-01f, 1.84016243e-01f, 1.23018689e-01f, -4.00105193e-02f, 1.49507254e-01f, 5.78994453e-02f,
  2.12560996e-01f, -2.32250765e-02f, 3.08082759e-01f, -5.38690239e-02f, -3.97310704e-02f, 1.11941867e-01f, 8.49625245e-02f, 1.03044733e-01f, -1.32114291e-01f, -2.69014910e-02f,
  1.24921966e-02f, -1.20888270e-01f, -4.53799181e-02f, 9.05227885e-02f, 4.63804156e-02f, 3.43292244e-02f, -1.54360076e-02f, 4.58687022e-02f, 5.17693050e-02f, 2.84198783e-02f,
  -9.39218327e-02f, 6.07461110e-03f, 1.68531742e-02f, 5.56459837e-02f, -3.67926508e-02f, -9.84920636e-02f, -1.71301868e-02f, 4.62403968e-02f, -7.71783069e-02f, 9.61960386e-03f,
  -1.19762961e-03f, -2.75690071e-02f, 5.13779074e-02f, 3.83247361e-02f, -1.02773309e-02f, -4.06121612e-02f, 3.72603983e-02f, 3.03735472e-02f, -1.14670977e-01f, -8.99418145e-02f,
  4.36257524e-03f, 4.75152656e-02f, -6.12099282e-02f, 5.56636893e-04f, -5.74336797e-02f, 2.62742639e-02f, 4.96675186e-02f, 3.88071616e-03f, -3.38499376e-05f, -7.13641196e-02f,
  4.39099222e-02f, -6.26301542e-02f, 7.29015395e-02f, 4.02073562e-03f, -4.77417652e-03f, 7.56637333e-03f, 7.70255104e-02f, 7.10371975e-03f, 2.44122501e-02f, -2.38314997e-02f,
  -2.58859992e-02f, 1.13750622e-01f, -8.23966488e-02f, 2.19328832e-02f, -5.03497459e-02f, 9.06769857e-02f, -1.27779953e-02f, -9.30356421e-03f, 1.02893628e-01f, 9.91720036e-02f,
  -1.69526502e-01f, -2.34892778e-02f, 6.91214576e-02f, -2.45452803e-02f, -3.79878171e-02f, -3.75241935e-02f, -2.29831152e-02f, -7.71413893e-02f, -2.84190942e-02f, -8.03129002e-02f,
  4.65643080e-03f, 3.74861695e-02f, 5.78052066e-02f, -2.19731797e-02f, -3.53264809e-02f, 3.92118283e-03f, 6.91588148e-02f, -3.31766158e-02f, 2.48553157e-02f, -8.05493146e-02f,
  -7.52866734e-04f, 3.12758982e-02f, -6.11408753e-03f, -1.47051262e-02f, -3.69969429e-03f, 1.10158045e-02f, -4.02960368e-02f, -7.64113739e-02f, 6.38035834e-02f, 1.69783679e-03f,
  1.71470478e-01f, -2.65384793e-01f, -1.98962942e-01f, 9.21104327e-02f, -1.23939022e-01f, 2.41924286e-01f, 1.67706192e-01f, -7.22088814e-02f, -4.15742062e-02f, 6.70436323e-02f,
  2.14891911e-01f, -3.17013085e-01f, 1.34422436e-01f, 1.53771326e-01f, 3.21576893e-01f, 1.80552274e-01f, 2.71187276e-01f, 8.84689689e-02f, -1.09838486e-01f, 7.97281042e-02f,
  3.60469660e-03f, 4.93128896e-02f, 2.49471515e-02f, -1.87707067e-01f, -1.52625367e-01f, -1.76188320e-01f, 2.40433156e-01f, -9.23337191e-02f, 1.30606201e-02f, 6.48885742e-02f,
  1.07466653e-01f, -1.85784802e-01f, -1.19951762e-01f, -1.30641371e-01f, 8.83609802e-02f, 7.75197968e-02f, 4.70367745e-02f, -2.06967611e-02f, 3.57438512e-02f, 6.60417601e-02f,
  -7.11352332e-04f, -4.78592366e-02f, 1.43273920e-03f, -1.33806420e-02f, -6.57334924e-03f, -1.03971444e-01f, -7.95292780e-02f, -1.05685778e-02f, -9.92718115e-02f, -6.96127787e-02f,
  -3.23782228e-02f, 1.48925018e-02f, 2.35431157e-02f, -2.16235891e-02f, -4.09529321e-02f, -8.04956779e-02f, -2.04171408e-02f, -3.73529457e-02f, 6.75283596e-02f, -2.41732504e-03f,
  7.05761835e-02f, -1.09473914e-01f, -3.18408050e-02f, -4.10517864e-02f, 2.18313914e-02f, -4.38752957e-02f, -2.39019431e-02f, 8.12366512e-03f, -3.49045731e-02f, -8.72892048e-03f,
  7.13981017e-02f, -2.65043066e-03f, -3.32864635e-02f, 1.16699617e-02f, 3.09160389e-02f, 5.02225570e-02f, 2.44992282e-02f, -1.68098826e-02f, -2.17888318e-03f, 5.32231815e-02f,
  -3.19951773e-02f, 6.30469322e-02f, 4.22466062e-02f, 1.14711091e-01f, 8.35047942e-03f, 2.28124224e-02f, -5.33546209e-02f, -2.43123081e-02f, -1.33246630e-02f, 1.11631908e-01f,
  2.33566850e-01f, 4.77309264e-02f, -5.90674169e-02f, -3.04168612e-02f, 1.26484092e-02f, 1.34873204e-02f, 1.23752831e-02f, -3.79301384e-02f, 6.26627356e-02f, 1.94206405e-02f,
  4.45039535e-04f, 1.22533645e-02f, -1.41744781e-02f, 1.15476437e-02f, 3.97517979e-02f, 5.32751568e-02f, 1.04781128e-01f, 5.08611798e-02f, 3.97614725e-02f, -2.59786788e-02f,
  1.67222414e-02f, -2.30880361e-03f, -7.70445028e-03f, -4.74763196e-03f, 2.48348136e-02f, -5.08400351e-02f, 4.26458418e-02f, -1.16418581e-03f, 5.69285303e-02f, -4.66491282e-02f,
  9.26409438e-02f, -1.48133397e-01f, 3.22034985e-01f, 3.67688127e-02f, -2.34201908e-01f, 8.06928948e-02f, 2.38418370e-01f, -2.61719167e-01f, 1.57815963e-01f, -3.25096995e-01f,
  -1.20103627e-01f, 2.89086223e-01f, 3.75206396e-02f, -1.25218630e-01f, 2.34052196e-01f, 1.64881751e-01f, -9.88106057e-02f, 2.74609644e-02f, 2.63762437e-02f, -2.32051209e-01f,
  4.80384342e-02f, -3.76307517e-01f, 1.74263064e-02f, -2.49509513e-01f, -1.43571571e-01f, 5.91670163e-02f, -1.85155794e-01f, 1.04312502e-01f, -2.97339588e-01f, 2.60507930e-02f,
  -3.69995795e-02f, -1.01099908e-01f, 8.40514153e-02f, 4.89038490e-02f, -9.04243588e-02f, -2.61588506e-02f, 1.10445023e-01f, 1.20494641e-01f, 9.03720185e-02f, 1.10518271e-02f,
  9.69046652e-02f, -6.47675544e-02f, -1.63299348e-02f, 8.15783069e-03f, -3.74860279e-02f, -5.75057091e-03f, -7.19821826e-03f, -7.72088245e-02f, 2.80244891e-02f, 3.22156884e-02f,
  1.14805698e-01f, 6.79526478e-02f, 2.62245610e-02f, 5.10607734e-02f, 1.44355372e-01f, 1.09308369e-01f, 7.58783368e-04f, 1.06717795e-01f, 9.59463045e-03f, -8.76493193e-03f,
  2.56041735e-02f, -1.39754238e-02f, 6.25165999e-02f, -2.36065146e-02f, 2.04385873e-02f, -8.77478719e-02f, 2.34076660e-02f, -3.82512249e-02f, 2.04844736e-02f, -3.14924084e-02f,
  -1.22515306e-01f, 6.09241007e-03f, -4.71184030e-02f, -1.63476598e-02f, 3.75992106e-03f, 2.41342094e-03f, 6.33016601e-02f, -6.79628924e-02f, -3.40657905e-02f, -8.16562101e-02f,
  4.62004766e-02f, 1.53463858e-04f, -1.12300143e-02f, -3.05129830e-02f, 6.63735792e-02f, 6.20074607e-02f, -1.33154958e-01f, -3.18838954e-02f, -6.03328180e-03f, -5.59114618e-03f,
  -1.76497489e-01f, -3.45010519e-01f, 7.51068210e-03f, -8.48924145e-02f, -4.40122746e-02f, -8.78859013e-02f, 7.64854625e-02f, 1.37617495e-02f, 6.49332479e-02f, -2.58786511e-02f,
  -3.40271220e-02f, -7.33639002e-02f, -3.27080563e-02f, -6.20567938e-04f, 8.00285265e-02f, -2.29618140e-02f, -6.15040176e-02f, 2.49896348e-02f, -6.23517334e-02f, -4.18737717e-02f,
  -1.94729030e-01f, -4.59941989e-03f, 9.98592898e-02f, -8.98061320e-02f, -8.44248682e-02f, 8.72075278e-03f, 2.23167753e-03f, 2.97507346e-02f, -8.03636238e-02f, -1.20654628e-02f,
  -1.37711972e-01f, -1.36347711e-01f, 7.46563869e-03f, -6.45219162e-02f, 8.90943184e-02f, -4.11624044e-01f, -2.44934320e-01f, 1.32991090e-01f, -1.88547745e-02f, -1.32538453e-01f,
  -5.26107922e-02f, -2.91101545e-01f, -1.79880075e-02f, -3.53258163e-01f, -1.33908257e-01f, -1.23309307e-01f, -2.52407581e-01f, -1.98202074e-01f, 6.53547198e-02f, -1.86445229e-02f,
  -8.77544656e-03f, -1.27807795e-03f, -4.62975614e-02f, 1.72909394e-01f, 3.28048505e-02f, 1.80669665e-01f, 3.35677654e-01f, 1.16826408e-01f, 7.08325505e-02f, -5.03765345e-02f,
  -2.25106359e-01f, -4.94651049e-02f, 3.22108455e-02f, -5.10936603e-02f, 1.84355993e-02f, -1.40333837e-02f, -3.19502153e-03f, 1.32920761e-02f, 4.46616299e-02f, 9.08935722e-03f,
  -3.82305682e-02f, -3.03913956e-03f, 1.64880641e-02f, -7.00785872e-03f, -2.16164924e-02f, 1.34890480e-02f, -5.93804419e-02f, -4.00020443e-02f, -7.23105669e-02f, -1.15734488e-01f,
  -6.65796846e-02f, -3.52850966e-02f, -4.16108146e-02f, -3.80032472e-02f, 1.71809294e-03f, -8.34473073e-02f, -1.73322950e-02f, -7.15965452e-03f, 1.43165663e-02f, 2.28087846e-02f,
  2.83919740e-02f, 2.25654803e-02f, -1.67183392e-02f, 3.04433648e-02f, -6.57064142e-03f, 5.22008985e-02f, -7.04219937e-02f, 1.48431566e-02f, 1.62997637e-02f, -3.63631733e-02f,
  7.27834925e-02f, 4.08697175e-03f, 3.91559824e-02f, -8.11030343e-03f, -1.54785085e-02f, 4.13568430e-02f, 1.33034131e-02f, 1.36523433e-02f, 1.02439001e-02f, 8.19203071e-03f,
  3.12726349e-02f, -2.04040967e-02f, 3.45479813e-03f, 4.39533554e-02f, -6.34317547e-02f, 1.69401581e-04f, 4.23911065e-02f, 9.74078383e-03f, 3.42844501e-02f, 3.50890718e-02f,
  -5.17073385e-02f, 1.23483114e-01f, 3.68437953e-02f, 2.00108197e-02f, -3.02921310e-02f, -1.58790089e-02f, -4.40739729e-02f, 1.72485020e-02f, 3.53464410e-02f, 7.87063254e-05f,
  -2.23227398e-04f, -1.16722379e-02f, 9.54195037e-02f, -3.34173744e-03f, 3.86431962e-02f, 4.01251065e-03f, 2.65455134e-02f, 5.63581027e-02f, 7.71046281e-02f, 6.83555752e-02f,
  6.66260421e-02f, 1.50280595e-02f, 1.74460397e-03f, 3.53188850e-02f, 3.21673937e-02f, 7.40565881e-02f, 1.77132245e-02f, 3.31897475e-02f, 6.90937638e-02f, -1.71149634e-02f,
  -4.44037497e-01f, -8.45856816e-02f, 9.33722109e-02f, -3.22350174e-01f, 1.22626819e-01f, -2.04373434e-01f, -3.68140548e-01f, 4.40787598e-02f, -8.70285854e-02f, -1.90626279e-01f,
  3.10846325e-02f, -1.03847601e-01f, 1.35899678e-01f, -3.15387547e-01f, 9.98679250e-02f, -1.65008828e-02f, -3.78675848e-01f, -2.53188848e-01f, 4.44154739e-02f, -1.35140285e-01f,
  3.66817117e-02f, -1.74584270e-01f, 5.71898632e-02f, 9.67459828e-02f, -1.39861390e-01f, 6.92119375e-02f, 1.46379452e-02f, 2.22983792e-01f, -1.07667744e-01f, 1.98236443e-02f,
  -2.25976445e-02f, -2.61350349e-02f, -1.28889112e-02f, -3.42723951e-02f, -5.09996116e-02f, 1.84480809e-02f, 3.83780542e-04f, -1.27932953e-03f, 8.53399560e-02f, -1.81336328e-02f,
  -8.28807149e-03f, 2.26698164e-02f, -5.72688095e-02f, 6.73252866e-02f, 1.42330714e-02f, 1.88943353e-02f, 2.12162230e-02f, 1.10752136e-02f, 4.20096284e-03f, -3.06533650e-03f,
  4.45248112e-02f, 3.47550027e-02f, -6.73992261e-02f, -5.21725155e-02f, 4.30320315e-02f, -2.25936174e-02f, -1.05476812e-01f, 3.51230539e-02f, -1.38344220e-03f, -2.33831108e-02f,
  -3.69729660e-02f, -4.44673225e-02f, 1.08369840e-02f, -1.89029449e-03f, 3.52104716e-02f, 1.84214506e-02f, -7.52611877e-03f, -3.01724160e-03f, 5.68008572e-02f, -2.44136509e-02f,
  -3.29881199e-02f, 4.49580625e-02f, -3.82266678e-02f, -4.55737300e-02f, -6.95901662e-02f, -4.01042104e-02f, -3.58864516e-02f, -1.84039481e-03f, -3.95264430e-03f, 7.60021657e-02f,
  -3.39587294e-02f, -2.82947496e-02f, -3.58590204e-03f, 7.37895863e-03f, 1.38159525e-02f, 2.78252773e-02f, -2.01245286e-02f, -2.87961494e-02f, 3.31403203e-02f, 5.65413013e-02f,
  -4.83999681e-03f, -3.93932238e-02f, 6.39307275e-02f, -1.13892434e-02f, 1.17969625e-02f, 5.61488830e-02f, -2.09664609e-02f, -1.18913092e-02f, 1.89742178e-03f, -3.85010354e-02f,
  -3.09541319e-02f, -7.54543468e-02f, -9.90831759e-03f, -4.11160849e-02f, -2.54121590e-02f, 1.08317342e-02f, -6.62345737e-02f, -5.73884137e-02f, -1.45690460e-02f, 3.69146951e-02f,
  -4.31629196e-02f, -6.39128536e-02f, 3.69872302e-02f, 1.54314693e-02f, -7.78169930e-02f, -2.63254549e-02f, 5.03059551e-02f, 2.67030820e-02f, 8.21901187e-02f, -2.29979493e-02f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  2.48563305e-01f, -3.34751457e-02f, 1.80298612e-01f, 1.32500902e-01f, -5.03515862e-02f, -1.29980341e-01f, -1.57114625e-01f, -1.17499843e-01f, 2.27367237e-01f, -2.02963531e-01f,
  -1.96745336e-01f, 2.89008319e-01f, -1.08722851e-01f, -1.64095581e-01f, 1.44540027e-01f, 1.91329177e-02f, -1.06741443e-01f, 6.67756870e-02f, 5.24981730e-02f, -2.07150385e-01f,
  -9.64011177e-02f, -3.54931861e-01f, -2.34398514e-01f, -3.78253400e-01f, -1.68816671e-01f, -1.10521622e-01f, -2.63856977e-01f, -1.52140334e-01f, -2.42533445e-01f, -2.04827599e-02f,
  -9.96923074e-02f, -6.28620684e-02f, -1.19305030e-01f, 5.29848374e-02f, -1.56582177e-01f, -5.85535960e-03f, -1.29695814e-02f, 2.91534420e-02f, -7.09779635e-02f, -2.02753171e-02f,
  9.20402855e-02f, -4.21036333e-02f, 3.46686691e-02f, -5.16010299e-02f, -1.17457649e-02f, -2.28556842e-02f, -7.79733667e-03f, 4.08791117e-02f, -1.81972794e-02f, 1.15159020e-01f,
  8.86962488e-02f, -4.75657359e-03f, -3.89990322e-02f, -7.68156052e-02f, -4.07781191e-02f, -7.64066800e-02f, 6.71447888e-02f, -3.19588259e-02f, 1.15236901e-01f, 6.84798434e-02f,
  -4.34430840e-04f, -2.59834845e-02f, -5.85606880e-02f, -6.40484989e-02f, -5.56654222e-02f, -2.58482676e-02f, -5.99061735e-02f, -3.52164707e-03f, 6.85036406e-02f, 4.20982726e-02f,
  -1.31247327e-01f, -8.97588767e-03f, 4.82701771e-02f, 4.87284660e-02f, 5.68433069e-02f, 1.99731309e-02f, -2.04096995e-02f, -1.08342785e-02f, -5.22756279e-02f, 1.06897809e-01f,
  5.18902428e-02f, -6.20963909e-02f, -1.31348865e-02f, 5.97998612e-02f, 3.65334712e-02f, -2.26981025e-02f, 1.09944784e-03f, 8.02407414e-03f, 4.47990000e-02f, -5.92827238e-02f,
  -2.21418723e-01f, -2.88453609e-01f, -1.60539299e-01f, 1.73381995e-02f, -5.13131879e-02f, 3.52125876e-02f, -1.17343113e-01f, -2.68402845e-02f, -9.58312526e-02f, 3.06607736e-03f,
  -1.29862390e-02f, -2.14058440e-03f, 4.79346812e-02f, 8.10101032e-02f, -4.55001295e-02f, -5.40451594e-02f, -5.80661297e-02f, -1.04310602e-01f, -9.55946818e-02f, 4.58911173e-02f,
  -5.61740585e-02f, -1.30612656e-01f, -6.22591749e-02f, -1.25139952e-01f, 2.31333058e-02f, -3.73436660e-02f, 1.60475880e-01f, -3.78502230e-03f, 1.09651752e-01f, 8.97470023e-03f,
  2.17355981e-01f, 1.82685420e-01f, 1.12226076e-01f, 9.66571365e-03f, 3.46457660e-01f, -1.48898706e-01f, 6.61284775e-02f, 5.44903800e-02f, 1.24305170e-02f, 1.25840634e-01f,
  -2.46218756e-01f, 9.22028944e-02f, -3.03488553e-01f, -2.54199833e-01f, -7.98591077e-01f, -6.01373017e-01f, -2.24093229e-01f, -7.05852807e-02f, -1.60706624e-01f, 1.36160001e-01f,
  -1.00996979e-01f, -2.65860856e-01f, -1.39303803e-01f, 1.21525355e-01f, 3.88139695e-01f, 4.22896892e-01f, 3.86793725e-02f, 1.13728985e-01f, 2.19598994e-01f, -1.54903859e-01f,
  -1.35663122e-01f, -1.22730397e-01f, 1.66968808e-01f, 4.76792641e-02f, 2.02780683e-03f, 2.00345814e-01f, 6.46294951e-02f, -4.79645804e-02f, -3.66470888e-02f, 8.13365951e-02f,
  4.26728837e-02f, -4.69080135e-02f, -4.95101921e-02f, -4.65993136e-02f, 1.88119754e-01f, 4.78266515e-02f, -1.93686609e-03f, 1.62693992e-01f, 5.56107946e-02f, 5.98007292e-02f,
  1.15704864e-01f, 4.36372720e-02f, 5.54664284e-02f, 1.23614417e-02f, 1.94264948e-02f, -3.82559001e-02f, 3.08694523e-02f, 8.89735669e-02f, 3.48505750e-02f, 8.38548690e-02f,
  -3.59577425e-02f, -2.94356793e-02f, -1.88533738e-02f, 1.72768831e-02f, -5.64519987e-02f, 5.09886332e-02f, -7.08812103e-02f, 6.91029504e-02f, 4.05252725e-02f, -3.77558060e-02f,
  3.00474409e-02f, 2.37676427e-02f, -3.22395228e-02f, 1.09016702e-01f, 3.81329618e-02f, 5.93400523e-02f, 3.05843651e-02f, 1.34929852e-03f, 6.50663748e-02f, 5.47495373e-02f,
  -8.00123885e-02f, 2.33639516e-02f, 3.96640860e-02f, 8.18089470e-02f, -1.57862350e-01f, 4.35041226e-02f, -3.73516083e-02f, 8.30235928e-02f, 3.32223587e-02f, 1.52454469e-02f,
  -7.75282383e-02f, -1.61943078e-01f, 5.61257964e-03f, -3.32037061e-02f, 3.62186879e-02f, -4.20341082e-03f, -1.30448133e-01f, 5.03907986e-02f, -1.26883492e-01f, -6.59660548e-02f,
  1.19939722e-01f, 2.34515339e-01f, 1.14857024e-02f, 3.36318426e-02f, -6.03324249e-02f, -6.23176843e-02f, -3.62758636e-02f, -3.66753824e-02f, 3.46166454e-02f, 6.10027350e-02f,
  1.44047767e-01f, 1.54879289e-02f, 3.04047428e-02f, 1.02629237e-01f, 5.85685298e-02f, 4.24269363e-02f, 8.02868456e-02f, -2.76735947e-02f, 1.86373852e-02f, -1.36978060e-01f,
  -4.37563449e-01f, -3.37531380e-02f, -3.43749404e-01f, -3.34500343e-01f, -2.69291222e-01f, -2.67386883e-01f, -2.10034207e-01f, -1.10117413e-01f, -1.96443304e-01f, 3.79328847e-01f,
  1.10137373e-01f, -1.97483212e-01f, 2.42385224e-01f, 4.07887809e-03f, -4.24145222e-01f, 2.93487430e-01f, -2.68151343e-01f, -8.40736851e-02f, 7.06122592e-02f, -1.20103143e-01f,
  -8.52747187e-02f, 1.29237652e-01f, -6.54089153e-02f, 2.61641532e-01f, -2.37064302e-01f, -1.71933211e-02f, 1.49944061e-02f, 4.24707979e-02f, -9.75044593e-02f, -1.56633884e-01f,
  1.70065612e-01f, 2.53900230e-01f, -5.82891004e-03f, 1.84648819e-02f, -1.08437665e-01f, -4.57692631e-02f, -1.21569164e-01f, 2.89274938e-03f, 2.09643925e-03f, -1.11769466e-02f,
  -4.08989750e-02f, 3.96601390e-03f, 4.07930799e-02f, 8.02988559e-02f, -2.91407667e-02f, -3.60826515e-02f, -8.82874727e-02f, -8.61641169e-02f, 1.40523706e-02f, 1.95176098e-02f,
  -6.55794591e-02f, -5.64926602e-02f, -7.35739246e-02f, -4.70135920e-03f, -2.93240510e-02f, -2.80589648e-02f, 2.82276683e-02f, -1.05264962e-01f, -5.28394841e-02f, -9.92340073e-02f,
  -3.60357389e-02f, -1.20912902e-01f, 7.39280209e-02f, 1.59714092e-02f, 6.04713485e-02f, -1.94180291e-02f, -2.85642277e-02f, -2.86753215e-02f, 1.20870406e-02f, 5.82835674e-02f,
  -9.68200155e-03f, -1.07093446e-01f, -1.66574866e-02f, -2.82440763e-02f, 3.57249342e-02f, 3.14030647e-02f, 7.21551776e-02f, -2.45364252e-02f, -1.89494133e-01f, 7.04693869e-02f,
  1.00914538e-01f, 1.73343364e-02f, 3.44372690e-02f, 1.20696630e-02f, -6.94424510e-02f, -2.13690195e-02f, 6.32326454e-02f, -4.29392196e-02f, -1.10329511e-02f, -6.71110302e-02f,
  -1.00978218e-01f, -5.72230443e-02f, 4.68811169e-02f, 6.89259544e-02f, 7.63526186e-02f, -6.74457848e-02f, 2.38543823e-02f, -3.22426744e-02f, -1.00556880e-01f, -1.00430220e-01f,
  -1.03603676e-02f, 2.52184030e-02f, -1.69438243e-01f, -3.38615738e-02f, -4.56888601e-02f, -5.26602007e-02f, -6.93960115e-02f, -4.26665135e-02f, -1.22292705e-01f, -8.44274685e-02f,
  -2.72545964e-02f, 1.01929769e-01f, 3.84159088e-02f, 1.19024463e-01f, 4.65840213e-02f, -2.10266039e-02f, -1.05346523e-01f, -3.05764121e-03f, 4.52853180e-02f, -1.07679944e-02f,
  3.42958152e-01f, 6.36496842e-02f, -2.16539130e-01f, 1.67594969e-01f, 8.92868042e-02f, 1.11310825e-01f, -3.51662159e-01f, 1.35930240e-01f, -3.67653519e-01f, -1.29472971e-01f,
  6.98407143e-02f, -7.48437792e-02f, -2.91714549e-01f, 4.16166574e-01f, 3.93056363e-01f, -5.06764427e-02f, 3.85411650e-01f, 7.15261251e-02f, 1.08367465e-02f, 1.17699422e-01f,
  1.00033015e-01f, 5.21972001e-01f, 5.95398620e-02f, 4.27410632e-01f, 2.93630660e-01f, 3.22230160e-02f, 1.69623151e-01f, -7.28741065e-02f, 2.48963997e-01f, 1.31907374e-01f,
  6.01647682e-02f, -6.11538962e-02f, -1.04114868e-01f, -4.16003168e-02f, -5.48766516e-02f, -5.03357453e-03f, 3.02060694e-03f, 9.40914154e-02f, -3.53640094e-02f, -8.13378543e-02f,
  4.10899818e-02f, 9.06904340e-02f, 6.31615147e-02f, -6.19672518e-03f, 5.68700656e-02f, -3.62097775e-03f, -1.14078552e-01f, -1.60673454e-01f, -4.02275994e-02f, 1.13004595e-02f,
  -7.51395002e-02f, 9.34912860e-02f, -3.12388428e-02f, -6.52484372e-02f, -7.63552040e-02f, -3.99001017e-02f, -6.97611347e-02f, -1.36920422e-01f, 4.84277382e-02f, -1.85935814e-02f,
  3.12460773e-02f, -3.98580320e-02f, 5.81771843e-02f, 4.28267829e-02f, -1.33128064e-02f, 3.16467136e-02f, 7.67802373e-02f, -8.99205683e-04f, -1.23685531e-01f, 5.30645736e-02f,
  1.03643537e-02f, 3.05627696e-02f, -3.24878842e-02f, -1.69350859e-02f, -1.56520456e-02f, -1.38319070e-02f, -1.95750911e-02f, 4.10971083e-02f, -1.11635648e-01f, 1.11565115e-02f,
  -3.60496691e-03f, 2.48679463e-02f, -7.40536526e-02f, -3.38929519e-03f, 8.38104934e-02f, -7.33293593e-02f, 9.37783942e-02f, -2.59712059e-02f, -1.51434571e-01f, -1.97447836e-03f,
  4.18068357e-02f, 6.55003935e-02f, -5.94670922e-02f, 7.83095360e-02f, -7.16704354e-02f, 1.15680195e-01f, -2.75471900e-02f, 9.60939154e-02f, 7.90215156e-04f, 5.50284982e-02f,
  -8.88968934e-04f, -5.29540591e-02f, 3.41436788e-02f, -4.06104997e-02f, -2.90995594e-02f, -1.02885544e-01f, -5.29167168e-02f, -2.80859284e-02f, -1.03841342e-01f, 1.05887391e-01f,
  2.12190319e-02f, 4.51414660e-02f, -3.45273390e-02f, 3.28516327e-02f, 5.06642535e-02f, -1.32728191e-02f, 6.62408248e-02f, 1.06209414e-02f, 1.08705968e-01f, -3.46677490e-02f,
  2.73962498e-01f, -2.46461794e-01f, -3.77044290e-01f, 5.46714067e-02f, 2.88521409e-01f, -2.30080578e-02f, -3.31706673e-01f, 2.10361227e-01f, -1.28215954e-01f, -6.42523095e-02f,
  9.77347791e-02f, -2.07962900e-01f, -3.48560393e-01f, 8.61925259e-02f, 2.90207297e-01f, -4.72698838e-01f, 4.12385195e-01f, 4.97603044e-02f, -8.73027369e-02f, 1.94790408e-01f,
  1.46919757e-01f, 4.70992327e-01f, 3.91143896e-02f, 3.84114027e-01f, 1.39071107e-01f, 5.79745173e-02f, 3.03238273e-01f, -7.56528880e-03f, 2.38623753e-01f, 1.68133661e-01f,
  -3.91991325e-02f, -1.52777890e-02f, 3.09636649e-02f, -6.90975711e-02f, 1.62957050e-02f, 9.12888423e-02f, 4.35506832e-03f, -1.95661630e-03f, -4.58572395e-02f, -2.94565521e-02f,
  -6.42103702e-02f, 7.13422745e-02f, 3.15464251e-02f, 7.65332356e-02f, 3.16053592e-02f, 9.89386961e-02f, -7.74261653e-02f, -2.25379970e-02f, -8.18659812e-02f, -9.83993113e-02f,
  -5.62486500e-02f, -1.14439383e-01f, 9.88127291e-02f, -9.16589350e-02f, -4.10575084e-02f, 4.48640175e-02f, 4.43005003e-02f, -6.95915371e-02f, -1.08091868e-01f, 1.09567143e-01f,
  1.25987038e-01f, -8.81718806e-05f, -1.16562732e-02f, -3.94509099e-02f, 9.99677032e-02f, -1.61173344e-02f, -6.97247237e-02f, -6.76077232e-02f, 1.88429700e-03f, 3.70220654e-02f,
  -3.10808085e-02f, -4.90295328e-02f, 7.62597099e-02f, -2.14852532e-03f, 5.37008159e-02f, -2.31609959e-02f, -1.88648328e-02f, -2.24756319e-02f, 1.75050944e-02f, -1.50399059e-01f,
  -3.33684348e-02f, 2.22139303e-02f, 3.06166317e-02f, 2.52903719e-03f, 4.92996052e-02f, 8.73484537e-02f, 1.67873949e-02f, 4.01459411e-02f, -7.21929148e-02f, 1.14426157e-02f,
  6.05421364e-02f, 1.91795155e-01f, -4.43499684e-02f, 4.27893139e-02f, 2.42278911e-02f, 5.21189384e-02f, 1.05563859e-02f, -5.97650446e-02f, 4.78859209e-02f, -8.53966624e-02f,
  1.03859589e-01f, 1.76125448e-02f, 3.01933214e-02f, 5.48951812e-02f, 3.17748040e-02f, 9.18023735e-02f, -3.00569162e-02f, 7.31498674e-02f, 1.02629289e-01f, 2.35107727e-02f,
  -8.69055241e-02f, -2.32591089e-02f, 3.26108150e-02f, -4.33067568e-02f, -3.74858342e-02f, -9.48014855e-02f, 6.20091781e-02f, 1.04214728e-01f, -8.66816416e-02f, -5.49681820e-02f,
  -4.18785244e-01f, -3.42018664e-01f, 5.70204794e-01f, -2.13392645e-01f, 3.86786550e-01f, 4.27792698e-01f, 2.62736708e-01f, 1.43392548e-01f, -2.01665536e-02f, -3.05999786e-01f,
  -1.35596573e-01f, -2.63587803e-01f, -6.37432560e-02f, -1.04198873e-01f, 4.11157250e-01f, 4.60235998e-02f, -9.25845234e-04f, -1.71970919e-01f, 2.72654481e-02f, 6.74734125e-04f,
  1.65134296e-02f, -1.12088419e-01f, 2.53782868e-01f, 6.77898526e-02f, 1.05449863e-01f, -6.70317113e-02f, -1.79289833e-01f, 2.17030823e-01f, 1.13195896e-01f, 1.80351272e-01f,
  -1.44201383e-01f, -2.25272983e-01f, -1.36639446e-01f, -1.53718321e-02f, 3.61505114e-02f, -2.00661290e-02f, 5.11079095e-03f, 2.04676576e-02f, -3.50893289e-02f, 1.96941812e-02f,
  -8.13042894e-02f, 1.04745641e-01f, 9.34498198e-03f, -3.22075933e-02f, 8.57711658e-02f, 8.79945680e-02f, 1.15677677e-01f, 7.07539544e-02f, 6.72575086e-02f, 1.38331085e-01f,
  1.37333453e-01f, 8.37502182e-02f, 2.07236083e-03f, 6.35109469e-03f, 1.20643549e-01f, -2.50842199e-02f, 3.63624096e-02f, 1.06881045e-01f, -2.64657829e-02f, 1.02453947e-01f,
  1.01581044e-01f, 3.18777934e-02f, 1.17251705e-02f, -8.07242021e-02f, 1.24962572e-02f, -2.89865043e-02f, -1.03226863e-01f, 2.05665305e-02f, 1.90191083e-02f, 4.74438891e-02f,
  -5.08478694e-02f, -4.14549112e-02f, 2.75434330e-02f, -6.81490311e-03f, -6.27105311e-02f, -7.38544315e-02f, -1.28951848e-01f, -9.15446877e-02f, 6.49174303e-02f, 5.63666783e-02f,
  -5.85312434e-02f, -5.53147634e-04f, 1.75809010e-03f, 7.13743940e-02f, 1.98419252e-03f, 1.08220689e-02f, -6.84791356e-02f, 8.25534686e-02f, -1.74665060e-02f, 2.38017477e-02f,
  -5.07597029e-01f, -3.84783924e-01f, -1.31901711e-01f, -4.17573787e-02f, -1.50613248e-01f, -3.31782736e-02f, -1.65442750e-02f, 3.45134921e-02f, -9.03242379e-02f, -3.97622678e-03f,
  -9.80788935e-03f, -4.19414937e-02f, -1.25550747e-01f, 9.21309087e-03f, -3.11949919e-03f, 8.09004705e-04f, -1.09825358e-01f, -1.13534369e-01f, -1.83169931e-01f, -4.92878333e-02f,
  -6.89088851e-02f, -6.64861873e-02f, -9.53734946e-03f, -6.87787235e-02f, -5.11075333e-02f, -1.17883319e-02f, -1.12326257e-01f, -8.53989720e-02f, 3.69722433e-02f, 2.07371591e-03f,
  -8.60450327e-01f, 5.45222759e-01f, -6.01707585e-02f, 2.14553788e-01f, -6.39485801e-03f, 4.85613972e-01f, 4.06286418e-01f, 2.80655295e-01f, 3.58894438e-01f, 3.42008740e-01f,
  3.37820202e-02f, 1.76990107e-01f, 6.90136477e-02f, 1.59897476e-01f, -4.38049398e-02f, 1.79836005e-01f, 1.58089340e-01f, 1.44551501e-01f, 1.71487853e-01f, -8.89100209e-02f,
  -6.44915923e-02f, 1.12213045e-01f, -1.59573287e-01f, 2.07228828e-02f, -2.61754155e-01f, -1.08791746e-01f, -1.97157606e-01f, -2.13114526e-02f, -6.13537468e-02f, 1.36567339e-01f,
  -2.52295136e-01f, -2.55898088e-01f, -2.11991549e-01f, -6.52133822e-02f, -1.78445444e-01f, -9.41342562e-02f, -1.00611346e-02f, 3.16384844e-02f, -4.69847210e-02f, 1.11696370e-01f,
  -4.38028537e-02f, 4.50252146e-02f, 1.00272879e-01f, 7.24191591e-02f, 7.72170424e-02f, -3.38168591e-02f, 2.05088239e-02f, 3.92698832e-02f, 2.82764845e-02f, 1.05830720e-02f,
  2.96966210e-02f, 5.84205100e-03f, -6.88673109e-02f, 6.43101633e-02f, -3.85564379e-02f, 3.12448610e-02f, 8.83932710e-02f, -5.34328818e-02f, 5.37121184e-02f, 1.08934946e-01f,
  -4.13511582e-02f, 2.34897230e-02f, 3.54298688e-02f, -1.30031511e-01f, 3.95202637e-02f, -8.30433294e-02f, -4.51233946e-02f, -1.17561102e-01f, 6.02168357e-03f, -7.17173964e-02f,
  -3.08456160e-02f, -5.45510352e-02f, -1.05168223e-01f, 6.25371188e-02f, 3.75038013e-02f, 9.03395563e-02f, -9.04470757e-02f, -6.23538047e-02f, 7.03077987e-02f, 6.30789390e-03f,
  -1.74779836e-02f, 6.75828755e-02f, 1.65982470e-02f, -6.65374740e-04f, 4.87287119e-02f, -5.86750871e-03f, -3.57755050e-02f, 2.84545459e-02f, 5.40955998e-02f, -7.76568875e-02f,
  2.40200371e-01f, 1.64105177e-01f, -1.04908017e-03f, 3.83219915e-03f, -3.76468413e-02f, -5.15898280e-02f, -1.80077869e-02f, -1.34786936e-02f, 1.59683391e-01f, 1.38895828e-02f,
  -1.80674568e-02f, 5.73876984e-02f, -7.65319690e-02f, 1.85504109e-02f, 3.18087898e-02f, 1.45166323e-01f, 2.50969213e-02f, 6.58110306e-02f, 4.65089008e-02f, -1.87464748e-02f,
  -9.65567082e-02f, -1.36116743e-02f, -9.53962468e-03f, -1.65918544e-02f, -7.54117384e-04f, -4.69349809e-02f, 1.96011886e-02f, 2.54897401e-02f, -2.31281463e-02f, 3.32635008e-02f,
  -5.03599465e-01f, 2.75567234e-01f, -2.16271803e-01f, -1.12171113e-01f, -1.79936633e-01f, 2.34195087e-02f, 9.83533263e-02f, -4.71124910e-02f, -2.43437335e-01f, 2.03954309e-01f,
  2.85555571e-01f, -3.31622243e-01f, 2.34751418e-01f, 3.91478509e-01f, -4.06145394e-01f, 4.06690747e-01f, 1.35948703e-01f, 1.40500531e-01f, -2.15666462e-02f, 1.14531562e-01f,
  -1.24498412e-01f, 3.29138756e-01f, 1.84345722e-01f, 3.18598241e-01f, 1.06737293e-01f, -8.07251930e-02f, 3.57688367e-02f, -4.11848724e-02f, 1.48980081e-01f, -1.42808989e-01f,
  2.43588641e-01f, -3.21822404e-03f, -2.30968539e-02f, -9.78635475e-02f, -1.08800791e-01f, 6.99840263e-02f, -8.68359506e-02f, -9.82445627e-02f, -3.54980305e-02f, -8.71978700e-02f,
  -7.20576644e-02f, -9.39108208e-02f, -2.39292029e-02f, -1.45928964e-01f, -5.78979813e-02f, -1.22111954e-01f, 8.33511502e-02f, 6.73864335e-02f, 8.82745758e-02f, 4.79784198e-02f,
  -1.73186939e-02f, -6.85919076e-02f, -9.04012024e-02f, 3.60451862e-02f, -9.73304361e-02f, 4.48149070e-02f, -3.49660148e-03f, -9.66304019e-02f, -8.27068090e-02f, -6.59122840e-02f,
  -7.77454525e-02f, 4.54332680e-02f, -4.04700404e-03f, 1.40769497e-01f, 1.58375707e-02f, 1.18845575e-01f, 3.59574147e-02f, 2.25365870e-02f, -1.29725441e-01f, 2.06704531e-02f,
  -6.83706952e-03f, -6.17323630e-02f, 1.17033836e-03f, -7.98360258e-03f, -5.66110127e-02f, 8.31805915e-03f, -5.07014096e-02f, 1.98460296e-02f, 2.78922915e-03f, 6.98580686e-03f,
  -3.49876992e-02f, -2.00718809e-02f, 4.23412677e-03f, 9.23968619e-04f, 8.99410620e-02f, -5.79851344e-02f, -1.70385391e-02f, 1.25106767e-01f, 3.54425050e-02f, -9.70506817e-02f,
  2.74187047e-02f, -2.94391453e-01f, 3.44595239e-02f, -5.77195548e-02f, 5.03737107e-02f, -3.72463167e-02f, -2.45904196e-02f, -7.10445419e-02f, -4.68462855e-02f, -5.96707612e-02f,
  -1.04602002e-01f, -7.15814978e-02f, -6.49648756e-02f, 1.39755458e-01f, -1.27387822e-01f, 9.32763666e-02f, 8.62593353e-02f, -9.55317393e-02f, -1.23200610e-01f, 7.46620703e-04f,
  6.37806058e-02f, -1.50612006e-02f, -8.33495185e-02f, 1.28931249e-03f, -4.28545363e-02f, 1.10631101e-02f, -7.16386735e-02f, -2.19982397e-02f, -7.44678676e-02f, -3.58357020e-02f,
  -1.01378217e-01f, -4.06218208e-02f, 1.87468559e-01f, -5.28176904e-01f, -6.65128306e-02f, 1.38719063e-02f, -2.57754624e-01f, -1.80920511e-01f, -3.10559511e-01f, -2.68067896e-01f,
  -3.37515295e-01f, -5.30484430e-02f, 2.02532440e-01f, -3.14431727e-01f, 4.06554401e-01f, 1.76040813e-01f, -1.56397521e-01f, -1.64797883e-02f, 2.40586000e-03f, -2.01477468e-01f,
  -9.00742970e-03f, -2.45670259e-01f, 2.64177710e-01f, -3.40766460e-02f, -1.04077794e-01f, -1.04517974e-01f, -1.00022316e-01f, -5.62810935e-02f, -2.24872053e-01f, -2.13514753e-02f,
  7.31108934e-02f, -3.57978083e-02f, 7.27414414e-02f, 1.09303281e-01f, 1.22906417e-01f, 5.88919707e-02f, -3.17755602e-02f, -2.48600133e-02f, -6.01122044e-02f, 1.74540002e-02f,
  -2.25676363e-03f, 1.33621600e-03f, -8.69379938e-02f, 3.53602134e-02f, -1.10262625e-01f, -1.21474586e-01f, 4.92447317e-02f, 4.58226055e-02f, 9.42667425e-02f, 9.84128714e-02f,
  5.13793044e-02f, 6.44079745e-02f, -6.96283206e-02f, 1.69825908e-02f, 1.89583674e-02f, -1.12087190e-01f, 1.81029066e-02f, 1.13397352e-01f, -3.11149228e-02f, -8.53563007e-03f,
  3.08423606e-03f, -1.38374055e-02f, 6.29210770e-02f, 2.09588390e-02f, 1.00277476e-01f, -6.54478297e-02f, 1.93444733e-02f, 1.12840049e-02f, -3.46106961e-02f, -2.82271150e-02f,
  6.57848418e-02f, -4.44457540e-03f, -1.46578504e-02f, -5.37244007e-02f, -1.66844670e-02f, -3.80290970e-02f, 1.53132275e-01f, -2.58656405e-02f, 5.43420389e-03f, -8.68792757e-02f,
  -1.24170564e-01f, 3.62486057e-02f, -4.44226265e-02f, 5.81562705e-03f, -4.76270132e-02f, 5.90323098e-03f, 4.33949148e-03f, 1.20797746e-01f, 5.04467897e-02f, -1.75365508e-02f,
  -3.07091698e-02f, -1.09845966e-01f, -5.78879938e-02f, -2.70917062e-02f, 1.35912299e-01f, 4.08313535e-02f, 9.77582932e-02f, -8.15683603e-02f, -5.55716231e-02f, 4.56214249e-02f,
  -1.67444766e-01f, 4.26659286e-02f, 7.73463622e-02f, -4.80339192e-02f, -5.78307509e-02f, -1.51725754e-03f, -1.17610693e-02f, -5.72776906e-02f, 1.15619954e-02f, -6.73187105e-03f,
  4.94757965e-02f, 5.70898168e-02f, 2.44056527e-02f, 3.74018587e-02f, -1.44201383e-01f, -9.18392763e-02f, 1.14939362e-01f, 2.05231439e-02f, -3.12330015e-02f, -1.01989456e-01f,
  3.75685185e-01f, -6.27528071e-01f, 2.12645948e-01f, 6.45248711e-01f, 3.30597609e-01f, -1.31190836e-01f, 9.68613401e-02f, -5.83063904e-03f, 3.44115674e-01f, -5.45163929e-01f,
  4.89173308e-02f, -2.18124211e-01f, -2.45881647e-01f, 1.72534555e-01f, 2.56304443e-01f, -1.12345919e-01f, 4.59590517e-02f, 4.60495129e-02f, 8.19839165e-02f, -3.72950956e-02f,
  2.00326234e-01f, 2.96625979e-02f, 9.95519161e-02f, -1.48656100e-01f, 1.42616823e-01f, -1.63709689e-02f, -1.94241758e-02f, -7.77337849e-02f, -6.52030185e-02f, 6.81219250e-02f,
  5.71823902e-02f, 9.34607610e-02f, -4.86237369e-03f, -2.08351780e-02f, -9.64764804e-02f, -6.35843575e-02f, 3.07143237e-02f, 7.80337080e-02f, 1.96108729e-01f, -7.62485638e-02f,
  -3.82923856e-02f, 5.31411879e-02f, 2.07549669e-02f, 6.24081567e-02f, 2.30870619e-02f, 5.45582101e-02f, 8.30360577e-02f, 4.00529727e-02f, 3.48813981e-02f, -1.13662682e-01f,
  2.05155555e-02f, 1.60250701e-02f, -1.24152545e-02f, -1.71682760e-02f, 5.34977317e-02f, 1.02230072e-01f, -2.45378967e-02f, -9.88218933e-02f, 2.29659099e-02f, -1.74333602e-02f,
  -1.71998486e-01f, -1.47349179e-01f, -5.46549261e-03f, 1.45542800e-01f, 1.22846328e-01f, 1.50874689e-01f, -2.31797416e-02f, -8.64926260e-03f, -1.49273537e-02f, -4.63537872e-02f,
  9.36024562e-02f, 2.58619199e-03f, 6.15097070e-03f, 5.75486198e-02f, 3.77127454e-02f, 3.74598838e-02f, 6.81952164e-02f, -4.60925028e-02f, -3.39005776e-02f, 5.32485247e-02f,
  1.46074900e-02f, 9.78309289e-02f, 1.07190590e-02f, 7.70434439e-02f, 1.00420982e-01f, -5.42543158e-02f, -1.08994499e-01f, 1.75175257e-02f, 2.88329478e-02f, -5.34742847e-02f,
  -3.51397619e-02f, -5.43030202e-01f, -5.02663478e-02f, 3.70348021e-02f, 3.21280062e-02f, -8.37641656e-02f, -3.74727026e-02f, 9.68783628e-03f, -8.14422593e-02f, 9.39289555e-02f,
  -1.31988600e-01f, 1.44470811e-01f, -1.61649540e-01f, 1.33579478e-01f, -2.53550150e-02f, 3.08262669e-02f, -1.95795554e-03f, -1.62868753e-01f, -6.17720187e-02f, -1.21794611e-01f,
  -2.31162924e-03f, -6.52819360e-03f, -4.07740066e-04f, 3.00524868e-02f, -5.80444001e-02f, -8.34579170e-02f, -1.99139602e-02f, 3.43528874e-02f, -4.89081517e-02f, -1.07234672e-01f,
  -7.03168154e-01f, -4.12174284e-01f, -1.53195783e-01f, 1.84438527e-01f, 1.64824687e-02f, 3.04247379e-01f, 2.04359889e-01f, -1.71549395e-01f, -2.41469041e-01f, 5.39177991e-02f,
  1.47160619e-01f, 9.53638852e-02f, -1.67509869e-01f, 4.34899777e-01f, 2.21323088e-01f, -7.00596049e-02f, 1.16461702e-01f, 1.33815408e-01f, -6.98984116e-02f, -3.44791681e-01f,
  -1.76854338e-02f, 2.93475300e-01f, 2.28388101e-01f, 5.17083518e-02f, 1.96980070e-02f, -6.20581806e-02f, 2.81655472e-02f, -1.36901006e-01f, 3.83665144e-01f, 2.40662366e-01f,
  -2.36623406e-01f, -3.92648578e-01f, 6.29970133e-02f, 7.20025152e-02f, -4.63280268e-02f, 1.25487996e-02f, -3.77413630e-02f, 7.88566545e-02f, 1.92025639e-02f, -1.67040676e-02f,
  -4.53451388e-02f, 3.37199792e-02f, 8.31558555e-02f, 6.77360548e-03f, -1.12071753e-01f, -2.34159417e-02f, 5.72171733e-02f, 3.26739028e-02f, -3.98145132e-02f, -8.81769732e-02f,
  -5.89763448e-02f, 2.52065267e-02f, 2.41258945e-02f, 8.25005323e-02f, -7.46780168e-03f, -4.43277229e-03f, 6.08220138e-02f, -1.21471379e-02f, -2.64997445e-02f, 8.38951528e-05f,
  -3.33318487e-02f, 2.43636835e-02f, -1.64947689e-01f, 8.84399042e-02f, 9.98851936e-03f, 1.01361454e-01f, 4.38060574e-02f, -8.33189487e-03f, 1.11254930e-01f, -2.01234370e-02f,
  6.68356866e-02f, 3.75737017e-03f, -6.45203516e-02f, 1.80791523e-02f, 9.15056095e-02f, 5.11504523e-02f, 2.30368264e-02f, 1.00532454e-02f, -1.07421156e-03f, 1.26429036e-01f,
  2.35841121e-03f, -2.71129943e-02f, 4.22084779e-02f, -3.00069340e-02f, -5.77709861e-02f, 5.35924099e-02f, 5.51303849e-02f, -5.30546233e-02f, 7.26695731e-02f, -1.71435494e-02f,
  -5.68598032e-01f, -4.75221276e-01f, 5.98331988e-02f, 4.76738401e-02f, -1.11491540e-02f, -1.16430029e-01f, 2.86489911e-02f, -4.62072454e-02f, -1.46800220e-01f, -1.27132654e-01f,
  -2.53883973e-02f, 1.03347473e-01f, 6.34248322e-03f, 5.10467216e-02f, 1.56743407e-01f, -2.76535694e-02f, -1.42258868e-01f, 5.83772473e-02f, 8.74251220e-03f, 1.89644229e-02f,
  2.75220517e-02f, -7.85120130e-02f, 1.98467314e-01f, -3.43492776e-02f, 1.30015984e-01f, 6.56449124e-02f, -1.23550490e-01f, 1.18478276e-02f, 5.72894886e-02f, 8.01786110e-02f,
  2.45274410e-01f, -8.83678272e-02f, -1.20124936e-01f, 1.59056619e-01f, 1.25000685e-01f, -1.00989051e-01f, -2.05533817e-01f, 1.69286668e-01f, -2.17503548e-01f, -1.07507721e-01f,
  3.75235587e-01f, 8.92794728e-02f, -9.72285047e-02f, 2.85362124e-01f, 3.82931888e-01f, -2.76069026e-02f, 1.01572551e-01f, -7.56114768e-03f, 4.02721502e-02f, 1.66987851e-01f,
  2.17163950e-01f, 1.99061424e-01f, 2.45384917e-01f, 2.15438083e-01f, 5.26804291e-02f, 2.53016472e-01f, 3.75528365e-01f, 1.92098389e-03f, 4.23264772e-01f, 1.62004977e-01f,
  -6.12276383e-02f, -4.23742980e-02f, -5.81460306e-03f, -1.57391757e-01f, 7.11658373e-02f, 3.05602290e-02f, -9.74659398e-02f, 7.74786025e-02f, 2.43962370e-02f, -7.54954889e-02f,
  -8.85270908e-02f, 4.67235595e-02f, -4.54017557e-02f, -4.41008620e-02f, 2.34619547e-02f, -7.52565116e-02f, -6.85542729e-03f, -4.23353948e-02f, -7.26026744e-02f, 3.09391376e-02f,
  -1.01447254e-01f, -8.70394558e-02f, -1.18958712e-01f, -1.75784919e-02f, 5.93332574e-02f, 2.09399797e-02f, -9.22663137e-02f, -9.85405445e-02f, -8.74151438e-02f, -3.22389156e-02f,
  1.13174692e-01f, -6.09146655e-02f, -1.46104908e-02f, 1.85475778e-02f, 2.28096731e-02f, 4.12606895e-02f, 1.17062569e-01f, 4.72003184e-02f, 4.04909737e-02f, -1.77088026e-02f,
  2.96704303e-02f, 9.97578278e-02f, -5.36039248e-02f, -2.67576687e-02f, 2.00490747e-02f, -1.04693256e-01f, -6.64673420e-03f, 3.68820652e-02f, -4.18125018e-02f, -1.62041187e-02f,
  -5.00605218e-02f, 2.81971805e-02f, 5.27819991e-02f, 3.36544253e-02f, -4.03215736e-02f, 6.25548139e-02f, 6.31677434e-02f, -2.06991266e-02f, 4.54991311e-02f, 4.28544208e-02f,
  3.67940329e-02f, 3.06747526e-01f, -5.68245724e-02f, -4.85982858e-02f, -3.99102131e-03f, 9.39677954e-02f, -5.31953052e-02f, 1.20669872e-01f, 2.70675123e-02f, 1.11082844e-01f,
  -1.74646936e-02f, -2.62346808e-02f, -5.66475540e-02f, -2.35022251e-02f, -1.24173827e-01f, 8.83097947e-02f, 1.50312126e-01f, -3.46048959e-02f, 6.33369982e-02f, 1.35293052e-01f,
  7.95632228e-03f, -6.80416375e-02f, -9.53307971e-02f, 6.25243550e-03f, 5.06856926e-02f, 5.03628440e-02f, -8.32613930e-02f, -6.48733899e-02f, 1.91950992e-01f, -2.13897298e-03f,
  4.32581156e-01f, 4.49348360e-01f, 4.86366630e-01f, 3.12182426e-01f, -3.08618873e-01f, -5.45587301e-01f, -4.37723190e-01f, -6.90890625e-02f, -2.49925479e-02f, 6.34612143e-03f,
  -2.89052039e-01f, 4.90232110e-01f, -2.60627829e-02f, 2.25387380e-01f, -1.09717071e-01f, -9.76907313e-02f, 1.01844937e-01f, -1.57296956e-02f, 6.72482252e-02f, 2.91559190e-01f,
  2.08814725e-01f, -8.78097340e-02f, 3.40814084e-01f, -9.40303728e-02f, 1.75608739e-01f, 2.49021634e-01f, 4.85510081e-02f, -5.21426797e-02f, 1.83636725e-01f, -1.15575939e-01f,
  -1.23589739e-01f, 2.21706927e-01f, 1.15596794e-01f, 2.68108100e-02f, 3.38974148e-02f, -1.27627969e-01f, -2.97771748e-02f, -8.39579329e-02f, -6.76730499e-02f, 3.31928954e-02f,
  7.59036317e-02f, 5.32945581e-02f, -8.07896554e-02f, -6.56160191e-02f, -7.47724622e-02f, 1.50340736e-01f, 1.86895937e-01f, 1.35345727e-01f, 1.00414418e-01f, 6.50792718e-02f,
  1.69440225e-01f, 1.58118710e-01f, 1.04912259e-01f, 1.19189218e-01f, 6.38100430e-02f, 2.50490848e-02f, 1.94300264e-02f, 1.01719528e-01f, 1.14429280e-01f, 1.32875308e-01f,
  4.47245613e-02f, -1.15238786e-01f, -6.08982369e-02f, 3.22367959e-02f, 1.60903648e-01f, 1.61983687e-02f, 2.33558752e-02f, -5.39935045e-02f, 1.35470545e-02f, 3.61259654e-02f,
  -6.96233734e-02f, 4.30922359e-02f, -5.71575388e-02f, -9.68435109e-02f, 7.80577511e-02f, 1.97390504e-02f, -4.12906669e-02f, -2.68207099e-02f, -8.74172151e-02f, -6.57101572e-02f,
  -8.11317489e-02f, -1.65644605e-02f, 1.07634902e-01f, -1.40001569e-02f, -8.89296979e-02f, 7.53957033e-02f, 5.69084063e-02f, 1.82437092e-01f, -1.38855144e-01f, -4.11049537e-02f,
  -1.26738949e-02f, 3.25784296e-01f, 4.55925316e-02f, 9.30399820e-03f, 4.34568785e-02f, -1.15612030e-01f, -1.49459150e-02f, 1.00826569e-01f, 6.70322850e-02f, -4.68203388e-02f,
  -1.32901385e-01f, -6.37811422e-02f, -8.39216709e-02f, -8.63946695e-03f, -1.76014733e-02f, 2.65128631e-02f, 3.57261561e-02f, 3.35762240e-02f, 4.36016731e-02f, 4.65647466e-02f,
  4.78965342e-02f, -1.44914389e-01f, -5.88296074e-03f, -1.04641952e-01f, -4.68584374e-02f, 5.32682752e-03f, -9.12206173e-02f, -4.99297539e-03f, 4.45561819e-02f, 5.52650802e-02f,
  5.89367673e-02f, 1.64945930e-01f, -1.54581308e-01f, -2.21691072e-01f, -1.58778969e-02f, -5.08079648e-01f, -2.34024733e-01f, -9.98355821e-02f, 1.38614953e-01f, -9.77881029e-02f,
  -1.21186450e-01f, 2.72556812e-01f, 1.88236400e-01f, -3.07125151e-01f, 8.01342353e-03f, 7.24421442e-02f, -5.71380317e-01f, -2.78984010e-01f, 6.97700381e-02f, -3.69654864e-01f,
  -2.20082670e-01f, -2.10316479e-01f, -1.57632068e-01f, -3.41652781e-01f, -2.49605075e-01f, -3.48099321e-02f, 4.36322093e-02f, 5.27306870e-02f, -1.67770401e-01f, 2.48194933e-01f,
  -1.13315634e-01f, -2.00719953e-01f, -4.95390827e-03f, -8.94323513e-02f, -3.29996258e-01f, -1.31369069e-01f, -1.04218386e-01f, 1.24420740e-01f, -1.89957693e-02f, -1.31502571e-02f,
  1.05271988e-01f, -4.99314256e-03f, -2.89591495e-02f, 1.35628894e-01f, -2.61994228e-02f, 1.03251666e-01f, 3.65940086e-03f, -1.21518113e-01f, 6.39173528e-03f, 4.21407744e-02f,
  3.55392024e-02f, -1.08015291e-01f, -8.13203081e-02f, 3.76972035e-02f, -1.27786156e-02f, 2.63612363e-02f, 1.22574167e-02f, 8.83673504e-02f, -1.00400992e-01f, -1.36906102e-01f,
  -1.57272052e-02f, 3.56173329e-02f, -2.61962041e-02f, 3.26924361e-02f, -3.99877876e-02f, 1.03026122e-01f, -2.98559554e-02f, 1.26840889e-01f, -7.77870230e-03f, -2.49782931e-02f,
  8.00407976e-02f, 6.13952316e-02f, -1.26925502e-02f, -1.18658639e-01f, -6.62629679e-02f, 8.71227831e-02f, 1.79088619e-02f, 8.49482566e-02f, 8.21948331e-03f, -1.15180150e-01f,
  -7.00169578e-02f, 6.69149961e-03f, 1.07858509e-01f, 5.53031489e-02f, -1.56190423e-02f, 3.42549011e-02f, 4.14814427e-02f, -1.20976269e-02f, 4.21200581e-02f, -2.23971363e-02f,
  -2.28027970e-01f, -4.56550211e-01f, 3.62996431e-03f, -1.51361013e-02f, 7.65606984e-02f, -7.83704892e-02f, -9.37478766e-02f, -7.56994309e-03f, -1.73061132e-01f, -1.30808607e-01f,
  -8.33836645e-02f, 1.20143540e-01f, -1.37033761e-01f, -4.36670855e-02f, 1.10031649e-01f, -5.95208369e-02f, -6.11930713e-02f, 1.52035952e-02f, -1.15938358e-01f, -2.19048709e-02f,
  -5.00925519e-02f, 5.88489324e-02f, 1.84295014e-01f, -5.91169037e-02f, 4.52898927e-02f, -6.96711764e-02f, -2.29848661e-02f, 8.87712315e-02f, -9.45066884e-02f, 2.53980123e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  4.66097444e-01f, 5.59441686e-01f, 4.58221704e-01f, 5.54990582e-02f, 3.52662146e-01f, 4.09632087e-01f, 4.40593004e-01f, 1.87183633e-01f, 1.79085523e-01f, 1.54276431e-01f,
  2.23972667e-02f, 2.97667563e-01f, 3.16457838e-01f, 2.50029385e-01f
};

// L1_fan_Wp (Shape: 9 x 32)
const int L1_fan_Wp_rows = 9;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  -1.32614933e-02f, -1.05274478e-02f, 1.51123807e-01f, 8.18303227e-03f, -3.90872955e-01f, -3.31087202e-01f, -1.04167145e-02f, 6.06604926e-02f, -1.26741096e-01f, 2.50724345e-01f,
  1.99649557e-01f, 2.83785284e-01f, 3.57940942e-01f, -1.64851949e-01f, -2.48150721e-01f, -1.87691957e-01f, -6.53674155e-02f, 1.41050503e-01f, -1.57493562e-01f, -2.37930596e-01f,
  4.82250862e-02f, 1.82577208e-01f, -1.10360399e-01f, 9.93116051e-02f, 1.11296490e-01f, 4.14324284e-01f, 3.90043929e-02f, -3.73773873e-01f, 7.35235885e-02f, 8.60577151e-02f,
  7.64074326e-02f, 2.05510750e-01f, -8.20234790e-02f, -7.61998370e-02f, 6.59550950e-02f, -4.82336320e-02f, -3.47057208e-02f, 2.75400579e-01f, -1.35908559e-01f, 3.31328452e-01f,
  2.14721590e-01f, 5.23061864e-02f, 6.34907093e-03f, 2.28845403e-01f, -3.04840535e-01f, 2.71846622e-01f, -2.79337645e-01f, 1.58837572e-01f, -9.61232856e-02f, 2.43400991e-01f,
  1.77374601e-01f, 1.98204562e-01f, -1.57004550e-01f, -1.17351040e-01f, -1.07363276e-01f, 3.00311953e-01f, -2.89014608e-01f, -8.47663879e-02f, 2.00133324e-01f, 1.71380684e-01f,
  1.12772033e-01f, -1.10338151e-01f, -2.51652151e-01f, 3.74588221e-02f, 1.70750290e-01f, 2.12694630e-02f, -3.46433163e-01f, 1.04607865e-01f, 2.92016029e-01f, 3.14905047e-01f,
  -7.32876956e-02f, -2.44324774e-01f, 1.59295470e-01f, -2.84826100e-01f, -2.56520867e-01f, -1.64867535e-01f, -2.04918280e-01f, 1.69672761e-02f, 1.46056950e-01f, -1.70224905e-01f,
  3.33177179e-01f, -6.44559488e-02f, -1.99627262e-02f, 1.88068241e-01f, -1.50488287e-01f, 3.33196372e-02f, 2.56992549e-01f, -6.21329024e-02f, -1.82813928e-01f, -2.85854906e-01f,
  -2.78704315e-01f, 3.19824576e-01f, -1.74041420e-01f, 1.01798683e-01f, 7.14448020e-02f, -2.65461147e-01f, -4.44130935e-02f, -6.95190579e-02f, -7.66873136e-02f, -1.20550938e-01f,
  1.42458707e-01f, 2.33447701e-02f, -7.52582625e-02f, -1.05237260e-01f, 8.81013870e-02f, 3.36035974e-02f, -2.15367332e-01f, -3.88460577e-01f, -2.16401920e-01f, 1.45508751e-01f,
  3.70518744e-01f, 1.93092152e-02f, -3.60279411e-01f, -3.95811737e-01f, -2.36331932e-02f, -9.71319675e-02f, -2.43475258e-01f, 1.72068402e-01f, 1.50831223e-01f, -1.99223645e-02f,
  7.57098123e-02f, -2.92584538e-01f, -2.25581490e-02f, 3.04073453e-01f, 4.75107721e-04f, 9.30245444e-02f, 1.42371178e-01f, -2.48582453e-01f, -7.17633516e-02f, -2.66028065e-02f,
  -4.79668230e-02f, 9.18263793e-02f, 1.15994811e-01f, -1.77981570e-01f, 3.64859045e-01f, 4.65560444e-02f, -2.79006362e-01f, -1.68531865e-01f, 1.66046038e-01f, -2.15717122e-01f,
  3.79437119e-01f, 5.41273914e-02f, -1.04172356e-01f, 3.23059559e-01f, -2.68996835e-01f, -2.87557155e-01f, 2.76270248e-02f, -7.75867626e-02f, 2.40958437e-01f, -1.87241644e-01f,
  -2.34591648e-01f, -2.28136331e-02f, 2.53154159e-01f, 1.37549192e-01f, 1.53629467e-01f, -1.40054315e-01f, -3.18637937e-02f, -3.21442962e-01f, 1.53769866e-01f, 9.20209885e-02f,
  8.39377940e-02f, -1.39896676e-01f, 2.85667200e-02f, 1.70274545e-02f, 1.32861510e-01f, 1.49810612e-01f, 4.93889675e-02f, 1.90876573e-01f, -4.86231595e-03f, -2.20841125e-01f,
  -2.71891784e-02f, -4.38199580e-01f, 2.53361985e-02f, 2.60409951e-01f, -5.94396889e-03f, 3.63418102e-01f, 1.45581458e-02f, -6.48334995e-03f, 2.41893128e-01f, 6.23181723e-02f,
  -8.67806077e-02f, -2.55014122e-01f, -6.78479299e-02f, 6.72012717e-02f, -1.85269527e-02f, -3.56190294e-01f, 1.56891972e-01f, 7.78350681e-02f, -3.76316816e-01f, -8.17110837e-02f,
  2.88865894e-01f, 5.86270951e-02f, -6.21441863e-02f, 1.75836161e-01f, 2.90539712e-01f, -1.49230853e-01f, 1.59387991e-01f, 2.76909262e-01f, -5.70043921e-02f, 3.09287399e-01f,
  -2.32584425e-03f, 2.97227532e-01f, -1.94076374e-02f, 1.47298142e-01f, -8.56239349e-02f, 1.62515312e-01f, -1.19472325e-01f, 2.51024991e-01f, -2.78654873e-01f, 2.61603385e-01f,
  -9.17524472e-03f, -3.93116266e-01f, 4.76881899e-02f, -1.49456963e-01f, -3.24738681e-01f, 2.20991671e-01f, 1.52331501e-01f, -3.66465859e-02f, 3.52545232e-01f, -2.14333773e-01f,
  7.00861067e-02f, 5.20701222e-02f, -2.09327847e-01f, -3.60356681e-02f, -3.31728831e-02f, 1.86721206e-01f, -6.39094636e-02f, -4.13450785e-02f, -2.13149320e-02f, -5.72806187e-02f,
  -3.66129845e-01f, -1.78807482e-01f, 1.30524963e-01f, 1.68557778e-01f, -1.61583021e-01f, 2.23072529e-01f, -4.08419162e-01f, -9.25498307e-02f, 4.86358374e-01f, -3.14330280e-01f,
  1.52829260e-01f, -3.60230744e-01f, 6.65747076e-02f, -1.10815696e-01f, 1.54364973e-01f, -8.31247792e-02f, 1.02750912e-01f, -2.45343238e-01f, -1.24059981e-02f, 3.53047065e-02f,
  3.63261774e-02f, -1.57206133e-01f, 1.08794287e-01f, 3.01216960e-01f, -2.03645736e-01f, 4.96966988e-02f, -7.40863085e-02f, 2.10203812e-01f, 1.21902302e-01f, -5.50682098e-02f,
  -1.58652544e-01f, -1.04508132e-01f, -1.25901893e-01f, 1.58869132e-01f, -1.24633983e-01f, 1.66518226e-01f, 2.73112178e-01f, 4.96453017e-01f, 4.29647788e-02f, -1.75070420e-01f,
  -1.37097061e-01f, -4.90327403e-02f, 2.09930778e-01f, 4.79526043e-01f, -5.38199283e-02f, -1.42046869e-01f, 2.67748624e-01f, -1.76849604e-01f, -1.62429079e-01f, 1.34685889e-01f,
  3.05209439e-02f, 2.78139532e-01f, 1.56773642e-01f, -1.51310056e-01f, 1.74253851e-01f, -1.58850372e-01f, -3.00781518e-01f, 3.26315731e-01f
};

// L1_fan_Wp_bar (Shape: 14 x 32)
const int L1_fan_Wp_bar_rows = 14;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  9.28584114e-02f, 4.78647277e-02f, 4.60059166e-01f, 9.42544192e-02f, 2.32611075e-01f, 4.25883569e-02f, 2.06459612e-01f, 4.52443838e-01f, 1.12878397e-01f, 1.74629152e-01f,
  4.50199276e-01f, 3.53490822e-02f, 1.15592025e-01f, 4.09246027e-01f, -2.06212342e-01f, 5.34634590e-01f, -2.73380429e-01f, 1.37445316e-01f, 3.86467308e-01f, -1.51114380e-02f,
  7.13213801e-01f, -4.57552552e-01f, -5.49776137e-01f, 6.67756379e-01f, 3.69559646e-01f, 5.71314692e-01f, 3.23928088e-01f, 2.67535716e-01f, 2.93623716e-01f, -4.31590915e-01f,
  3.35912444e-02f, 6.11563742e-01f, 4.35656965e-01f, 2.42559180e-01f, -6.01480380e-02f, -7.50037432e-02f, -1.66220456e-01f, -1.21940942e-02f, 3.39460708e-02f, 3.17018479e-01f,
  -2.02313498e-01f, -2.58633256e-01f, -1.35773644e-01f, 5.83934426e-01f, 5.66889703e-01f, -3.07803661e-01f, -5.25973141e-01f, -2.72521619e-02f, 5.40721834e-01f, 7.52925754e-01f,
  -7.10909218e-02f, 4.60152933e-03f, 4.63667274e-01f, 3.39892298e-01f, 5.05084097e-01f, 3.57684284e-01f, 2.56668150e-01f, -2.37749025e-01f, 4.82377172e-01f, -2.96081096e-01f,
  2.06795055e-02f, -1.83573887e-02f, -3.37678224e-01f, 5.78842521e-01f, 2.95525223e-01f, 5.88562712e-02f, -7.69650936e-02f, 4.36678231e-01f, 4.60457057e-01f, 4.54631507e-01f,
  3.92232776e-01f, -3.51450965e-02f, 1.12684481e-01f, -6.83699489e-01f, 1.09721169e-01f, -7.87347615e-01f, 2.71424372e-02f, 2.69316621e-02f, 3.15250665e-01f, 1.76239625e-01f,
  1.70703471e-01f, -6.55489922e-01f, 4.83856350e-01f, 4.48427022e-01f, 1.37876764e-01f, -2.78125942e-01f, 1.86558738e-01f, -3.28814119e-01f, 1.91792361e-02f, -4.31475967e-01f,
  -1.74086690e-02f, 2.75113344e-01f, -5.99712014e-01f, 3.04232892e-02f, 6.82932913e-01f, 1.57393664e-01f, 1.06506288e-01f, -2.96135396e-01f, 1.73303813e-01f, 9.04186592e-02f,
  4.88640182e-02f, 1.16666764e-01f, -2.44151980e-01f, 2.77972877e-01f, 4.50815320e-01f, -8.33889171e-02f, -1.31257311e-01f, -3.11450988e-01f, -5.45680344e-01f, 6.48991346e-01f,
  -6.13657758e-02f, 3.82873714e-01f, 8.81873444e-02f, -1.02293231e-01f, 5.54327548e-01f, 2.93821037e-01f, -4.34459388e-01f, -1.77105796e-02f, 1.19168960e-01f, 5.67244947e-01f,
  -6.46335602e-01f, -4.44260836e-01f, 1.97503611e-01f, 9.04971719e-01f, 4.60696787e-01f, 3.07209313e-01f, 4.14344430e-01f, 4.11020279e-01f, 1.38892859e-01f, 6.05470717e-01f,
  3.54298949e-01f, -4.82067913e-02f, -8.12073126e-02f, 1.85706541e-02f, -1.77625522e-01f, 1.42802130e-02f, 6.21900894e-02f, 6.98769152e-01f, -4.37889248e-01f, 2.83406228e-01f,
  -5.55684157e-02f, -4.93672609e-01f, 5.88071108e-01f, -3.58929753e-01f, -6.19319320e-01f, -5.16601264e-01f, -1.43953755e-01f, -1.21242099e-01f, 2.93886781e-01f, 5.10040700e-01f,
  5.37522137e-01f, 1.26130238e-01f, 5.88304281e-01f, 3.10921699e-01f, 3.59005988e-01f, -2.08174229e-01f, 6.40286922e-01f, 2.84901917e-01f, -2.27858081e-01f, -2.15430111e-01f,
  1.78141698e-01f, 3.26216012e-01f, 3.08208942e-01f, 3.07349488e-02f, 1.40160739e-01f, 7.09638417e-01f, -1.63667038e-01f, 3.43178630e-01f, 1.25515431e-01f, 2.82137245e-01f,
  -1.84530228e-01f, -3.74740064e-01f, -1.53503548e-02f, 3.94897014e-01f, 1.60946772e-01f, 3.97691190e-01f, -1.75875440e-01f, 3.00843298e-01f, 3.36454600e-01f, -7.32818604e-01f,
  -1.53327614e-01f, 2.42773443e-01f, 6.09212928e-03f, 4.64540333e-01f, 3.98454309e-01f, -1.94016919e-01f, 8.08740914e-01f, -1.76925316e-01f, -4.51197922e-01f, 5.11359870e-01f,
  6.33136749e-01f, 2.11078614e-01f, 2.70203203e-01f, 3.34669828e-01f, -2.34119073e-01f, 3.92291009e-01f, 3.06698084e-01f, 4.84389514e-01f, 3.07859331e-01f, 2.56339639e-01f,
  1.34437442e-01f, -4.87374127e-01f, -2.14830831e-01f, 4.15220298e-02f, 5.17486513e-01f, 3.90878730e-02f, -4.18307066e-01f, 8.14819336e-02f, 4.28773224e-01f, 4.87266988e-01f,
  -7.46165663e-02f, 2.71065474e-01f, 1.98044688e-01f, -1.70721069e-01f, 2.24710897e-01f, 5.98107755e-01f, 2.46747345e-01f, 1.38879612e-01f, -6.52878508e-02f, 2.43314639e-01f,
  -3.97525936e-01f, -1.03336707e-01f, -4.53062624e-01f, -3.05139661e-01f, 2.01378420e-01f, -6.15252461e-03f, -3.20166111e-01f, 4.59441155e-01f, 3.29783648e-01f, 5.15828431e-01f,
  -1.67220265e-01f, -9.98827443e-02f, 3.01804364e-01f, -2.99332768e-01f, -3.45444828e-01f, 2.99824588e-02f, -4.53887314e-01f, 3.09603900e-01f, -7.35334530e-02f, -3.50378036e-01f,
  5.95720112e-01f, 2.29720041e-01f, 6.49693012e-02f, 5.87842047e-01f, -3.43090296e-02f, 1.18294522e-01f, 3.99828404e-01f, 3.55866820e-01f, -5.76492190e-01f, -2.34106928e-01f,
  -1.94750085e-01f, 6.61770105e-01f, 3.32913756e-01f, 3.25273395e-01f, -2.71930367e-01f, -5.71429968e-01f, 2.76872247e-01f, 3.77442330e-01f, 1.24257386e-01f, 4.33712125e-01f,
  4.88481462e-01f, 3.56036663e-01f, 3.08570683e-01f, 2.46660009e-01f, 2.73883253e-01f, -3.35832328e-01f, -3.52094680e-01f, -6.16396487e-01f, 1.79749802e-01f, -2.02329680e-01f,
  7.68085867e-02f, 2.62555927e-01f, -3.73517752e-01f, -2.63792515e-01f, 3.92731160e-01f, 4.99554962e-01f, -1.63904861e-01f, -4.21674401e-01f, -7.03938305e-02f, 2.86913663e-01f,
  3.12398165e-01f, -2.05202684e-01f, 6.51368685e-03f, 4.08999801e-01f, -5.69305658e-01f, -4.33376759e-01f, 2.53241420e-01f, -4.42607790e-01f, 2.14863941e-01f, -1.98630691e-02f,
  -1.00038676e-02f, 2.35072240e-01f, 2.53906716e-02f, 3.83693516e-01f, -2.96183497e-01f, 4.08034120e-03f, 3.41974616e-01f, 2.43036970e-01f, -3.87851596e-01f, 1.35562360e-01f,
  -2.56516337e-01f, 1.84907958e-01f, 1.44745307e-02f, -5.47526062e-01f, 2.49694586e-01f, 2.46939406e-01f, -1.86050579e-01f, 9.40190926e-02f, -2.15810433e-01f, 5.07822692e-01f,
  5.99830210e-01f, 4.37520534e-01f, -1.35205910e-01f, 1.01271726e-01f, 1.05855353e-01f, 5.25846362e-01f, 1.72402799e-01f, 6.63876295e-01f, 1.25193909e-01f, -2.48008549e-01f,
  2.93293655e-01f, 1.39422193e-01f, 3.59961063e-01f, 3.52673680e-02f, 3.22651863e-01f, -6.24841787e-02f, 4.56038117e-01f, 1.30387142e-01f, -2.11647496e-01f, 1.23608783e-01f,
  9.04973075e-02f, -2.76373327e-01f, 5.94022930e-01f, -4.58199590e-01f, -4.70456444e-02f, 8.73312447e-03f, -5.19794405e-01f, -3.02695900e-01f, -1.05128855e-01f, 5.03346436e-02f,
  1.32293761e-01f, 6.92562103e-01f, 4.01290029e-01f, 1.63953051e-01f, 7.15739489e-01f, 4.81791258e-01f, 1.09928459e-01f, -2.50146031e-01f, 4.75580782e-01f, 1.79748878e-01f,
  3.75674933e-01f, -1.80776224e-01f, 2.77614027e-01f, 1.19267572e-02f, -1.28223762e-01f, 3.96987677e-01f, -2.91184008e-01f, -1.88614964e-01f, -1.73144177e-01f, 1.71788871e-01f,
  2.07915887e-01f, -3.44351143e-01f, 6.06846333e-01f, 2.91775376e-01f, 1.13207720e-01f, -1.70387238e-01f, -1.90081865e-01f, -3.80674899e-01f, 5.98793447e-01f, 1.78694472e-01f,
  4.61095691e-01f, 6.99929357e-01f, 4.51628029e-01f, 4.28963900e-02f, 3.66183102e-01f, -5.71740270e-01f, -2.35445261e-01f, 1.33461505e-01f, 6.02209456e-02f, -4.42789555e-01f,
  -4.98845249e-01f, 2.98581719e-01f, 7.56379604e-01f, 5.80213547e-01f, 9.99186337e-02f, 1.91452503e-01f, 2.69222379e-01f, 1.41388411e-02f, 8.68638977e-03f, 1.12518825e-01f,
  -1.06116347e-01f, 4.64206338e-01f, 3.47270012e-01f, 1.98730126e-01f, 9.06237066e-02f, 3.97848696e-01f, -4.75971133e-01f, -1.00353092e-01f, -1.70689732e-01f, 2.00994924e-01f,
  -8.29024240e-02f, 4.53641236e-01f, 3.12427461e-01f, 5.72515488e-01f, -1.10613219e-01f, -3.18942755e-01f, -2.49617279e-01f, 4.14773136e-01f, -2.29191810e-01f, -5.94444983e-02f,
  5.63095212e-01f, -9.69455391e-02f, 3.79518084e-02f, -1.05186172e-01f, 1.58462256e-01f, 5.27522147e-01f, 1.16352342e-01f, 1.87788233e-01f, 4.59724776e-02f, 2.78341264e-01f,
  3.98971856e-01f, -2.55748957e-01f, 2.65200585e-01f, 1.37212500e-01f, 1.61139175e-01f, -1.66862637e-01f, 4.66293752e-01f, 4.21238124e-01f, 1.53825983e-01f, -5.54692626e-01f,
  -2.52690911e-01f, -4.37234566e-02f, 1.54856250e-01f, -1.44047514e-01f, -1.74325462e-02f, 6.79240525e-01f, 4.89459485e-01f, -3.55607539e-01f, -4.02024806e-01f, -2.32944638e-01f,
  5.19710541e-01f, 6.24737382e-01f, -3.46497983e-01f, -2.38067642e-01f, 3.99709284e-01f, -3.65133256e-01f, 2.44919658e-01f, 6.17494285e-02f
};

// L1_fan_Bp_bar (Shape: 1 x 14)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 14;
const float L1_fan_Bp_bar_data[] = {
  2.73860365e-01f, 1.98264390e-01f, 2.68704981e-01f, 1.36359274e-01f, 3.40388179e-01f, 3.01241875e-01f, 2.93672532e-01f, 2.39177257e-01f, 2.33150840e-01f, 3.18089187e-01f,
  1.60582647e-01f, 1.52665406e-01f, 3.66984904e-01f, 3.12357754e-01f
};

// L2_linear_W (Shape: 12 x 32)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 32;
const float L2_linear_W_data[] = {
  -3.01561654e-01f, 5.19408472e-02f, -4.14878011e-01f, 2.79311925e-01f, -2.41477221e-01f, -4.53329265e-01f, 1.47296250e-01f, -1.73341110e-02f, 8.05441588e-02f, 3.16983640e-01f,
  -2.53963143e-01f, -2.26753458e-01f, -1.06676370e-01f, 3.11368763e-01f, -2.20390901e-01f, 3.41374695e-01f, 3.74586880e-01f, 6.38711572e-01f, 5.55392623e-01f, -7.46502936e-01f,
  -7.19378173e-01f, -2.01926470e-01f, 3.41692865e-01f, -6.54428542e-01f, -2.90631711e-01f, -1.90882921e-01f, -3.30806702e-01f, -4.23301697e-01f, 2.87429363e-01f, -2.86772996e-01f,
  -4.65773433e-01f, 6.97604716e-01f, -3.68474261e-03f, -2.87839860e-01f, 4.79232818e-01f, 1.44191742e-01f, 3.99244010e-01f, -2.17462122e-01f, 3.23444515e-01f, -1.10780336e-01f,
  4.15530771e-01f, 6.48527145e-01f, -2.43683964e-01f, -3.33781272e-01f, 5.65255225e-01f, -3.02022308e-01f, -4.41408455e-01f, -3.57413977e-01f, 4.03493822e-01f, -3.60747784e-01f,
  -9.01181340e-01f, 1.90514579e-01f, -5.79772413e-01f, -7.35216320e-01f, 7.77133167e-01f, -4.85027917e-02f, -5.21053910e-01f, -6.15197241e-01f, -2.47316301e-01f, 2.73313671e-01f,
  4.31931317e-01f, 7.17894137e-02f, -2.35196382e-01f, -4.52097237e-01f, -7.03062043e-02f, 2.75323182e-01f, -2.55486220e-01f, -2.40431115e-01f, -1.81652203e-01f, -1.71019554e-01f,
  -6.30702674e-02f, 1.52385652e-01f, -3.18298608e-01f, -3.51203501e-01f, 3.93519580e-01f, 2.30693266e-01f, 9.39726532e-02f, 5.02987206e-02f, -2.87838250e-01f, -1.05104946e-01f,
  1.03541061e-01f, -1.64465696e-01f, -6.91353977e-01f, 1.12329870e-01f, -5.24733543e-01f, 5.30580819e-01f, 1.13900930e-01f, -4.82635409e-01f, -9.80811790e-02f, 6.23810887e-01f,
  -5.84735811e-01f, 2.83299655e-01f, 2.19478130e-01f, -6.76501513e-01f, -4.91687328e-01f, -2.63945550e-01f, -9.14577767e-02f, 1.86282173e-01f, 1.27731323e-01f, -3.12565833e-01f,
  1.21499330e-01f, 2.32542902e-02f, 1.43008798e-01f, 1.05908930e-01f, -3.63585293e-01f, 4.80904192e-01f, -3.00171405e-01f, -5.31589329e-01f, 6.84330910e-02f, 4.92747396e-01f,
  -2.10029423e-01f, -4.04908687e-01f, -3.01111311e-01f, 5.46498969e-02f, 2.92111248e-01f, 5.48369408e-01f, -3.02566916e-01f, -5.67846298e-01f, -7.20899820e-01f, -8.25875223e-01f,
  2.05390230e-01f, -6.50158584e-01f, -5.45722604e-01f, -6.14634931e-01f, -7.65262842e-02f, 4.84207034e-01f, 3.52805033e-02f, 5.92315316e-01f, 8.36027563e-02f, 1.19351283e-01f,
  -9.33241025e-02f, 3.54433060e-03f, 1.94793493e-01f, 4.84540686e-02f, -5.64308882e-01f, -4.11179572e-01f, -2.01684222e-01f, 4.41277385e-01f, 6.60874844e-01f, -3.80432338e-01f,
  -7.87021279e-01f, 3.73101443e-01f, 1.36796445e-01f, 2.40974292e-01f, -6.21565461e-01f, 6.42843902e-01f, 3.81207854e-01f, 4.95243311e-01f, -8.63161564e-01f, -3.97721052e-01f,
  -2.01949075e-01f, 4.20114905e-01f, 5.37948787e-01f, -1.30039051e-01f, 4.07299213e-02f, 7.49529079e-02f, 1.82670817e-01f, -6.01185322e-01f, 2.55192697e-01f, -2.14252412e-01f,
  3.71388793e-01f, -9.85331535e-02f, 4.87055182e-01f, 8.61909539e-02f, -1.59514412e-01f, 3.90553862e-01f, 2.06622496e-01f, 3.53709131e-01f, 1.74698859e-01f, -5.09884477e-01f,
  -5.56050181e-01f, -6.38107434e-02f, 3.66338879e-01f, 3.35606933e-01f, 6.34297848e-01f, 3.32371742e-01f, -1.00206256e-01f, -5.61895490e-01f, 1.41814491e-02f, -3.00576359e-01f,
  5.67369103e-01f, -5.79971492e-01f, -3.90146710e-02f, 4.83870238e-01f, 1.67417616e-01f, -6.06294096e-01f, 6.05870068e-01f, -5.87772489e-01f, 2.92387724e-01f, -6.63350880e-01f,
  -5.67829311e-01f, -7.91712627e-02f, -3.32349867e-01f, 1.07161939e-01f, -3.61720532e-01f, 3.06938291e-02f, 2.80642867e-01f, -1.80398277e-03f, 4.33456540e-01f, -1.46874771e-01f,
  -3.15653294e-01f, -2.16450408e-01f, 3.74279886e-01f, 4.91453260e-01f, 1.37832269e-01f, -6.44940063e-02f, 4.83409762e-01f, -4.49283779e-01f, -2.61164844e-01f, -4.05699313e-01f,
  3.08781751e-02f, -2.27598503e-01f, 4.35822368e-01f, 2.95418471e-01f, -8.98971438e-01f, -2.48599589e-01f, 4.80253458e-01f, 5.56022286e-01f, 5.47857106e-01f, 1.94632024e-01f,
  -3.48323375e-01f, -6.06383741e-01f, -3.49558681e-01f, -6.93011522e-01f, 1.18186675e-01f, 5.12530142e-03f, -1.58323467e-01f, -2.14864746e-01f, -6.52638674e-02f, -3.17878872e-01f,
  2.09349040e-02f, 3.45490947e-02f, -1.72722846e-01f, 8.50929245e-02f, 1.67505428e-01f, -3.06821585e-01f, -2.65443753e-02f, 2.07803726e-01f, 3.46244931e-01f, 1.01769917e-01f,
  3.79058361e-01f, 2.53501981e-01f, 3.20889860e-01f, 3.23863387e-01f, 2.92241782e-01f, 1.42902970e-01f, -3.61821622e-01f, 3.03962648e-01f, -4.79168981e-01f, -3.61222982e-01f,
  -6.86795712e-01f, -4.12512660e-01f, -6.33974552e-01f, 4.89751279e-01f, 2.38241822e-01f, -6.28809869e-01f, 1.16387270e-01f, -1.97105214e-01f, -2.68489808e-01f, 2.67701689e-02f,
  -2.19478339e-01f, 1.76190704e-01f, -2.31821924e-01f, 9.22781006e-02f, -3.29654396e-01f, 2.78432906e-01f, -3.90249342e-01f, 2.40716055e-01f, 2.46476084e-01f, -2.72063203e-02f,
  1.16264768e-01f, -3.09636712e-01f, 5.50772622e-02f, 2.27846354e-02f, -5.87602794e-01f, -5.46360552e-01f, 4.03950572e-01f, 1.96369424e-01f, -6.18789554e-01f, 4.37391877e-01f,
  -2.22651705e-01f, 7.03356043e-02f, -5.22600234e-01f, 3.64650279e-01f, -2.71281339e-02f, 5.76079488e-01f, -4.38770115e-01f, -3.85619104e-01f, 2.36872837e-01f, -2.49159783e-01f,
  4.08539295e-01f, 1.33503348e-01f, 2.48733178e-01f, 2.38818169e-01f, -4.32430863e-01f, 3.49564642e-01f, 4.46077108e-01f, -4.94563341e-01f, 3.29617083e-01f, -2.49456912e-01f,
  4.82667565e-01f, -5.48952937e-01f, 2.84927160e-01f, 5.65005422e-01f, 2.86859185e-01f, 2.37782419e-01f, 3.36166203e-01f, -5.79319119e-01f, -7.80958951e-01f, 6.39246881e-01f,
  -2.29932964e-02f, 4.15722311e-01f, -5.32462180e-01f, -1.01167895e-01f, -3.00038844e-01f, 2.47067481e-01f, -6.37649298e-01f, -6.09461665e-01f, 5.62693894e-01f, -3.06151450e-01f,
  3.20368767e-01f, 1.37143970e-01f, -5.93255609e-02f, -1.32114127e-01f, -1.56915128e-01f, 7.97938406e-02f, 5.68082072e-02f, 1.20780349e-01f, 2.76739597e-01f, -3.02550673e-01f,
  2.59586722e-01f, 6.12794638e-01f, -5.77106833e-01f, -5.87466061e-01f, -3.60945076e-01f, -1.96511358e-01f, 5.88801324e-01f, 5.76688826e-01f, -5.11915922e-01f, 1.20463364e-01f,
  -2.05596164e-02f, -6.64505601e-01f, -2.69146226e-02f, -5.04221439e-01f, 3.12908709e-01f, 6.51772618e-01f, 6.84882775e-02f, 1.25036687e-01f, -5.02942920e-01f, 4.05295134e-01f,
  3.23584795e-01f, 3.40877414e-01f, 4.30164896e-02f, 1.14926010e-01f, 1.81143224e-01f, 2.98839957e-01f, -9.60441977e-02f, -1.58406451e-01f, -1.84408545e-01f, -2.45740995e-01f,
  -1.42335862e-01f, -1.43264875e-01f, 2.34549135e-01f, -5.72096137e-03f, -1.35373026e-01f, 2.62209535e-01f, 2.28107557e-01f, -3.45224023e-01f, -3.41401845e-01f, -4.33586240e-01f,
  -1.73736066e-02f, -6.82963073e-01f, 5.18646419e-01f, 2.02132821e-01f, -8.06048930e-01f, -5.64066172e-01f, -3.13210160e-01f, -4.00972486e-01f, 5.03288507e-01f, -5.68816900e-01f,
  1.27548650e-02f, 3.58793497e-01f, 4.76464331e-01f, 3.56234074e-01f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  1.41522154e-01f, 3.65449376e-02f, -7.58391842e-02f, -8.23727399e-02f, -4.89556678e-02f, 1.63605690e-01f, 1.42930359e-01f, 1.17072100e-02f, -8.92473087e-02f, 1.59176346e-02f,
  -5.32247610e-02f, -8.97315145e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 9, 14
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 9, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        32, 12
    );
    }
    