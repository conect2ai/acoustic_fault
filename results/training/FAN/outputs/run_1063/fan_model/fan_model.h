/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 19 x 120)
const int L0_fan_Wp_rows = 19;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -3.22012544e-01f, -1.34243235e-01f, 1.61343083e-01f, -1.51833117e-01f, -1.25461176e-01f, -8.18876103e-02f, -5.89699075e-02f, 4.91980277e-02f, 7.68217966e-02f, -2.36118007e-02f,
  -1.73810586e-01f, -4.26225923e-02f, 2.09837124e-01f, 1.79687217e-01f, 6.07546605e-02f, 2.71761149e-01f, 3.76723677e-01f, 1.25157043e-01f, -2.74592191e-02f, -1.37115449e-01f,
  -1.15146734e-01f, -7.83734098e-02f, -9.68110859e-02f, 2.11436048e-01f, 2.77672678e-01f, 1.32665545e-01f, 2.26362303e-01f, 1.53021142e-01f, 1.49127454e-01f, 3.32141161e-01f,
  -8.82427171e-02f, -1.23881638e-01f, 3.33554135e-03f, 4.64187674e-02f, 2.81881355e-03f, 6.15200177e-02f, -8.87995865e-03f, 5.08798473e-02f, 7.43210018e-02f, 1.85720492e-02f,
  3.46340761e-02f, 8.10258463e-02f, -1.96283753e-03f, -6.71325298e-03f, -4.24078554e-02f, 3.73819657e-02f, 1.17293723e-01f, 1.89456791e-01f, 1.16588868e-01f, 2.52185985e-02f,
  5.66864200e-02f, -4.21083532e-03f, -8.97160992e-02f, 1.05924539e-01f, 8.49710181e-02f, -1.12048797e-02f, -5.65201305e-02f, 9.78732598e-04f, 9.91298407e-02f, -6.83770925e-02f,
  -2.44219005e-02f, -8.17828160e-03f, -3.83285992e-02f, -1.32791186e-03f, -8.67221728e-02f, 3.34350648e-03f, -2.53326520e-02f, -2.35339515e-02f, -1.09828077e-01f, 1.90563854e-02f,
  -4.73323427e-02f, -3.11207827e-02f, -4.46013026e-02f, -1.11826167e-01f, -3.63115259e-02f, -1.80621650e-02f, -1.32467926e-01f, -7.65105784e-02f, -9.30328667e-02f, -3.71852219e-02f,
  -5.87197281e-02f, 1.06379390e-02f, -4.68843132e-02f, -1.19090145e-02f, 8.51048380e-02f, 4.43761615e-04f, -1.51028439e-01f, -2.51847785e-02f, 1.97234694e-02f, -1.29873697e-02f,
  -2.34386563e-01f, 4.36053751e-03f, -9.25866067e-02f, -1.91406365e-02f, 4.05146554e-02f, 5.68313971e-02f, 1.50255114e-02f, -4.79085967e-02f, -5.02994061e-02f, -3.13603953e-02f,
  -9.17593017e-02f, -9.40899029e-02f, -3.62933613e-02f, 2.44903825e-02f, -4.15481478e-02f, -8.25037286e-02f, -2.42319275e-02f, 1.43642100e-02f, 1.22379161e-01f, 5.49749471e-03f,
  5.96317798e-02f, -1.43440261e-01f, -1.61256284e-01f, -1.00250252e-01f, -7.29041398e-02f, -7.64030069e-02f, -6.82813535e-03f, -4.23681140e-02f, -7.96799511e-02f, -6.95195869e-02f,
  -5.12137890e-01f, -5.88561237e-01f, -7.34800324e-02f, -2.14975312e-01f, -8.05086866e-02f, -1.12195306e-01f, -3.09774041e-01f, -2.71806791e-02f, -2.67234463e-02f, -1.87885419e-01f,
  2.42082104e-02f, 1.44383177e-01f, 1.36826694e-01f, 1.87644199e-01f, 5.60284778e-02f, -1.29130244e-01f, -2.00874340e-02f, 7.10240379e-02f, 2.71943867e-01f, 1.78269580e-01f,
  9.89763737e-02f, -7.63302296e-02f, -3.12633887e-02f, 8.73925388e-02f, -2.70337537e-02f, 2.70116818e-03f, -1.23758875e-01f, -2.99266055e-02f, 5.39670736e-02f, 1.35823470e-02f,
  -1.43574057e-02f, -1.83970615e-01f, 1.54714331e-01f, -3.67166810e-02f, -6.72646537e-02f, -2.56882589e-02f, -1.47469193e-02f, 4.83254343e-02f, 4.59414022e-03f, -6.98101968e-02f,
  -5.50305210e-02f, -3.99905220e-02f, 1.96465924e-02f, 4.90807965e-02f, -5.84338680e-02f, -1.16810622e-02f, 8.54516104e-02f, -5.24841659e-02f, 6.91097602e-02f, 5.72034717e-02f,
  3.52103598e-02f, -1.45764977e-01f, -1.27308413e-01f, 4.54531796e-02f, -1.03879219e-03f, 1.35873258e-02f, -2.98825838e-03f, -4.59483117e-02f, -9.39270575e-03f, -6.22397736e-02f,
  -1.34251341e-01f, -1.55200353e-02f, -1.52407694e-04f, 4.69443128e-02f, 4.67346497e-02f, 3.92900733e-03f, -8.08685645e-02f, -2.45029163e-02f, 1.12894095e-01f, -5.51727861e-02f,
  5.31055816e-02f, -3.23376767e-02f, 2.99657471e-02f, -5.78557998e-02f, 2.76400093e-02f, -4.15120795e-02f, -5.75755276e-02f, -2.41368599e-02f, -3.95903252e-02f, 3.63308601e-02f,
  2.45394725e-02f, -3.01993005e-02f, -1.04408085e-01f, -4.90499623e-02f, -2.13757399e-02f, -1.92287620e-02f, -5.99241666e-02f, 6.11379817e-02f, -4.01044525e-02f, -1.03121296e-01f,
  2.03533545e-02f, 4.17372696e-02f, 3.82471830e-02f, 1.42240711e-02f, -8.47673789e-02f, 8.90276879e-02f, -8.59036893e-02f, 1.03324473e-01f, 1.13575943e-02f, -3.55124054e-03f,
  1.49116218e-02f, -5.66071160e-02f, -1.39413133e-01f, 9.55187306e-02f, 1.14091691e-02f, 5.73295727e-02f, -4.42918614e-02f, 2.33049616e-02f, 3.40688191e-02f, 5.46986200e-02f,
  -5.21005392e-02f, -5.28766923e-02f, -6.26660436e-02f, -1.00351609e-02f, 5.55380955e-02f, -1.63565502e-02f, 4.43618186e-02f, 6.11678883e-02f, -3.74219567e-02f, -1.73032179e-01f,
  1.88387781e-01f, -1.53147832e-01f, -1.31087869e-01f, 6.48459792e-02f, -1.84626356e-02f, -3.68178003e-02f, -1.67952161e-02f, -4.53195274e-02f, -1.46970777e-02f, -2.28704792e-02f,
  -3.16890538e-01f, -1.04102835e-01f, 8.64762887e-02f, 5.97920716e-02f, 2.70377219e-01f, 1.78912818e-01f, 3.23233306e-01f, 2.75667131e-01f, 1.24734521e-01f, 3.29410285e-02f,
  1.37415454e-01f, 2.19743177e-01f, 1.57892138e-01f, 2.27941319e-01f, 9.70162153e-02f, 2.08094027e-02f, 3.33970673e-02f, 1.09310098e-01f, -3.80632952e-02f, 6.01752512e-02f,
  -1.43266752e-01f, -1.26467243e-01f, 9.25140902e-02f, 7.18435794e-02f, -1.09447092e-01f, 2.58571506e-02f, -3.26645598e-02f, 8.96871742e-03f, 5.07076010e-02f, 5.68736866e-02f,
  -3.69869284e-02f, 4.38322462e-02f, 8.66686180e-02f, -8.57010111e-02f, 5.69885559e-02f, 3.55517678e-02f, 1.05265625e-01f, 1.46063864e-01f, 1.70419142e-01f, -1.02372821e-02f,
  -6.57227561e-02f, 1.11226313e-01f, 7.09625036e-02f, -6.30870974e-03f, 1.91572886e-02f, 4.39458191e-02f, -1.12782538e-01f, 5.24121337e-03f, 5.91719300e-02f, -1.46915363e-02f,
  3.85269113e-02f, -3.87938432e-02f, -3.21076401e-02f, -7.29535148e-02f, -5.32603413e-02f, -4.60852832e-02f, -7.24170823e-03f, -2.14501773e-03f, 7.33101442e-02f, -3.69122885e-02f,
  -1.93086974e-02f, 2.31282692e-02f, 7.82733262e-02f, 9.73556712e-02f, 1.22866124e-01f, 6.51626959e-02f, 6.60372674e-02f, 3.56306843e-02f, 1.91431329e-01f, -2.45795515e-03f,
  1.11944094e-01f, 6.43851608e-02f, -6.99914992e-03f, 4.68618646e-02f, 1.16325729e-01f, 8.63887444e-02f, -5.57839237e-02f, -1.41054571e-01f, -5.13144210e-02f, 5.69005013e-02f,
  -1.58061922e-01f, 1.48978531e-01f, -3.17906588e-02f, 9.26305130e-02f, 6.78668991e-02f, 7.28828683e-02f, -3.96606028e-02f, 3.86491679e-02f, 1.38849989e-02f, -1.10061601e-01f,
  -7.21965209e-02f, -4.76872921e-02f, -6.11015819e-02f, -8.40007514e-02f, 1.71653051e-02f, -8.21936429e-02f, 5.81185482e-02f, 7.22659454e-02f, 3.34644355e-02f, 7.54695684e-02f,
  1.11480886e-02f, 1.71621889e-01f, 7.54874870e-02f, -2.38144323e-02f, -2.12322585e-02f, 4.51789983e-02f, 4.43496136e-03f, -7.89931417e-02f, 1.28484949e-01f, 1.56496063e-01f,
  6.27961814e-01f, -4.02680099e-01f, -4.14628536e-01f, 4.01267320e-01f, -6.16285205e-02f, -1.57830834e-01f, -2.24655122e-01f, 6.66398779e-02f, 3.18770587e-01f, -6.52033016e-02f,
  -3.05218160e-01f, 1.33966759e-01f, 3.96614969e-02f, -2.09352374e-02f, -4.12770174e-03f, -2.03989089e-01f, -9.29525569e-02f, -4.20040509e-04f, 2.01967523e-01f, 5.83990514e-02f,
  1.64863113e-02f, 1.36839986e-01f, 2.96093047e-01f, 1.05565682e-01f, 2.33331099e-02f, 5.67997843e-02f, -2.01179475e-01f, -1.40015796e-01f, -2.43255034e-01f, -1.64092034e-01f,
  -2.68756688e-01f, -2.11052328e-01f, 1.17690176e-01f, 1.04069024e-01f, -2.14074805e-01f, 2.68832780e-02f, -2.27038544e-02f, 1.73947103e-02f, -6.19359426e-02f, -5.60124107e-02f,
  -5.42760715e-02f, 2.10956903e-03f, -7.77769089e-02f, -1.24998011e-01f, 1.46759246e-02f, -8.11575577e-02f, -2.16253484e-05f, 2.01810934e-02f, -4.78423908e-02f, -2.15325192e-01f,
  -1.15126066e-01f, -1.30773604e-01f, -1.18985802e-01f, -4.46586348e-02f, -8.72181579e-02f, 5.55300564e-02f, -1.57723024e-01f, 1.73925143e-03f, -5.21529615e-02f, -6.84677884e-02f,
  8.04133862e-02f, -7.23814266e-03f, 3.12793367e-02f, 7.02806115e-02f, 5.26803471e-02f, -3.64524052e-02f, 1.69037823e-02f, 1.90989859e-02f, 1.08749531e-01f, 8.60153139e-03f,
  -1.40385125e-02f, 5.06861433e-02f, 1.68373790e-02f, 4.41723615e-02f, -2.07031276e-02f, 3.42760496e-02f, -3.68788168e-02f, 8.57618917e-03f, -4.93522212e-02f, 3.33790742e-02f,
  5.44340797e-02f, 5.75740375e-02f, 4.39493619e-02f, -2.46992819e-02f, 5.21111749e-02f, 6.62949830e-02f, 9.51766875e-03f, 7.52503648e-02f, 4.17495817e-02f, 1.78759103e-03f,
  1.18846014e-01f, -1.00611873e-01f, -4.53663506e-02f, 3.01199295e-02f, -3.96469943e-02f, -1.29675165e-01f, -6.92063794e-02f, -6.67951629e-02f, -4.49897759e-02f, -8.67607072e-03f,
  -1.07185028e-01f, -1.58849992e-02f, -5.93734868e-02f, -1.06888480e-01f, 6.28623366e-02f, -8.90919566e-03f, -2.06687916e-02f, -1.07294542e-03f, -4.80980463e-02f, -1.31862968e-01f,
  1.14973830e-02f, 1.03880972e-01f, 5.13310060e-02f, -6.67459611e-03f, -3.77446264e-02f, 1.42437667e-01f, -1.19096570e-01f, -3.00504826e-02f, -3.85813341e-02f, 1.64089173e-01f,
  3.24319899e-01f, 3.11003905e-02f, 4.01285470e-01f, -6.71589375e-02f, 1.94856346e-01f, 2.25487962e-01f, 5.29267341e-02f, 1.17838174e-01f, 7.68857151e-02f, -5.51156923e-02f,
  -8.36445112e-03f, -1.48736402e-01f, 1.26606720e-02f, -5.15125543e-02f, -7.20031410e-02f, 3.78173334e-03f, -9.29017812e-02f, 5.65446280e-02f, -7.59399729e-03f, -1.15625039e-01f,
  -3.01189333e-01f, -1.54691651e-01f, 3.37352082e-02f, -1.02984563e-01f, -7.42711872e-02f, -8.28835741e-02f, 4.73024510e-02f, 4.67092954e-02f, 7.82952085e-02f, -7.78000280e-02f,
  -3.33598144e-02f, 2.43405655e-01f, -6.41018599e-02f, 3.86482035e-03f, -4.30156700e-02f, 1.33878067e-01f, 7.52326399e-02f, 1.27187654e-01f, 1.01266421e-01f, 6.99096099e-02f,
  -3.50371152e-02f, 3.60095315e-02f, 4.80892360e-02f, 2.37982068e-02f, 7.46905208e-02f, -3.02198920e-02f, -3.39512005e-02f, 1.11384906e-01f, 8.48563164e-02f, 1.47716671e-01f,
  -7.81736597e-02f, 1.73751801e-01f, 1.75286040e-01f, 6.63024262e-02f, 7.88997486e-02f, 4.96479459e-02f, 1.48253635e-01f, 1.41486600e-01f, 2.22705439e-01f, 7.10609602e-03f,
  -9.72649902e-02f, 6.60382062e-02f, 3.37859988e-02f, 3.15237828e-02f, -7.97888339e-02f, 1.30495308e-02f, -3.34638804e-02f, -9.77332219e-02f, -5.52597828e-02f, -6.61061257e-02f,
  1.33639509e-02f, 7.57621182e-03f, 2.92835664e-02f, 1.38154998e-02f, -1.40851513e-02f, 7.94510022e-02f, 5.00465296e-02f, 2.06526909e-02f, -2.70457231e-02f, 3.86818387e-02f,
  2.00999063e-02f, 6.68629035e-02f, -4.73458283e-02f, -4.44578677e-02f, 3.58785316e-02f, -1.52603798e-02f, 4.29928266e-02f, 3.50682475e-02f, -8.07029754e-02f, 1.31300241e-01f,
  -4.25425433e-02f, 2.84461290e-01f, -1.42950024e-02f, -6.94578663e-02f, 4.81955055e-03f, -7.37940222e-02f, -6.98565990e-02f, -8.65173563e-02f, 8.10688064e-02f, -4.31409851e-02f,
  9.16460762e-04f, -6.26409650e-02f, -5.94154634e-02f, -7.57738436e-03f, -4.45134640e-02f, -2.95966566e-02f, -1.95915084e-02f, -1.75970197e-02f, -3.51601765e-02f, 2.00632066e-02f,
  -9.48411152e-02f, 8.76477510e-02f, -8.48382562e-02f, -7.03346655e-02f, 2.39363909e-02f, 3.66826281e-02f, 7.05594849e-03f, -6.13515973e-02f, 5.55467084e-02f, -2.76574194e-01f,
  4.83165160e-02f, -1.21033303e-01f, -1.91451713e-01f, -1.45890191e-01f, 9.74841490e-02f, 3.14026505e-01f, 1.42017677e-01f, 1.45761529e-02f, 1.46919023e-02f, 1.50501266e-01f,
  2.48835027e-01f, 2.91031539e-01f, 1.26006827e-01f, 1.00113288e-01f, 1.01387598e-01f, -9.81200263e-02f, -2.70335257e-01f, -1.39509872e-01f, 1.56865135e-01f, 2.69035280e-01f,
  1.41660780e-01f, -9.01186615e-02f, -9.04453024e-02f, -6.54453859e-02f, -1.09946676e-01f, 6.22765385e-02f, -1.82079017e-01f, -2.37283587e-01f, -1.18457943e-01f, -2.48416483e-01f,
  1.69342682e-01f, 1.87877137e-02f, 1.65517598e-01f, 9.22606289e-02f, 1.67365789e-01f, 1.39370009e-01f, 1.57119021e-01f, -3.02754156e-02f, 1.14470676e-01f, 9.10966098e-02f,
  1.22125827e-01f, 1.65627196e-01f, 8.63402933e-02f, 1.25031903e-01f, 1.74142316e-01f, 8.88929218e-02f, 2.98435744e-02f, -1.97823793e-02f, -9.08645277e-04f, 5.60999140e-02f,
  8.92321691e-02f, 1.31536171e-01f, 1.85168684e-01f, 3.83305252e-02f, 8.39123577e-02f, 1.13970585e-01f, 3.37239392e-02f, 6.64165616e-02f, 5.18005081e-02f, 8.80575331e-04f,
  1.40171036e-01f, -2.43564919e-02f, -8.59245583e-02f, -1.88460782e-01f, 9.75132734e-03f, -7.28112534e-02f, -3.55829373e-02f, -3.65547799e-02f, -2.90689841e-02f, -6.45635873e-02f,
  -1.16940662e-02f, -1.26091555e-01f, -3.98641918e-03f, -6.70326129e-02f, -2.53691543e-02f, -5.65481670e-02f, -9.30554941e-02f, -5.45124114e-02f, -3.37506309e-02f, -5.53737916e-02f,
  8.85129534e-03f, -4.83264886e-02f, -9.12884548e-02f, -2.93009821e-02f, -4.22903299e-02f, -1.06794082e-01f, -7.66601786e-02f, -9.81104001e-02f, -4.54520993e-02f, -6.63820207e-02f,
  7.93665126e-02f, 1.68042585e-01f, 7.70747587e-02f, 1.37879625e-01f, 1.22144148e-02f, 1.29401863e-01f, 1.80611596e-01f, 3.75191607e-02f, 1.18956305e-01f, 1.08043730e-01f,
  1.85496628e-01f, 9.37350318e-02f, 1.17903747e-01f, 3.67394611e-02f, 1.93094522e-01f, 1.19385585e-01f, 9.49384570e-02f, 6.60604239e-02f, 1.14532642e-01f, 1.73367411e-01f,
  5.46512157e-02f, 2.01517269e-01f, 2.14785025e-01f, 8.82577449e-02f, 6.71321303e-02f, 2.47404486e-01f, 2.39144161e-01f, 2.53475845e-01f, 1.27608716e-01f, 3.72692198e-02f,
  -1.93335056e-01f, -1.01623833e-01f, -8.57255831e-02f, 5.34165092e-03f, 9.18501467e-02f, 1.18296921e-01f, 2.25210920e-01f, 2.35114276e-01f, 1.01861060e-01f, 5.47691211e-02f,
  -3.12663496e-01f, -1.06856212e-01f, 3.17822210e-02f, 2.50765141e-02f, 1.18600711e-01f, 2.37533018e-01f, 3.29926014e-01f, 1.60720035e-01f, 3.08287680e-01f, 1.33543000e-01f,
  2.09612891e-01f, 1.90308869e-01f, 1.41763687e-01f, 1.12326458e-01f, 6.01380225e-03f, 9.70039293e-02f, -1.36092126e-01f, -6.27605468e-02f, -2.31630355e-03f, -3.48108151e-04f,
  -1.99304312e-01f, -3.50026459e-01f, 8.83376226e-02f, -5.93518913e-02f, -1.50730893e-01f, 5.85011765e-02f, -5.68811074e-02f, -2.46411767e-02f, -1.29997274e-02f, -5.41726984e-02f,
  -3.59470434e-02f, 7.46838702e-03f, -3.62698361e-02f, -1.75486933e-02f, -2.13689264e-02f, 1.86135098e-02f, -9.88300238e-03f, 8.07657018e-02f, -7.73804188e-02f, -1.10752590e-01f,
  -1.25166439e-02f, 3.95998433e-02f, 6.37296885e-02f, 1.08510524e-01f, -3.68179358e-03f, 1.05862662e-01f, -9.19125900e-02f, -3.19211408e-02f, 4.83264215e-02f, 9.08700824e-02f,
  1.08629838e-01f, -3.84158045e-02f, -2.58178879e-02f, 6.52278308e-03f, 2.56255288e-02f, -2.08415408e-02f, -8.57306458e-03f, 3.59745994e-02f, 3.97787541e-02f, 8.66793543e-02f,
  -5.73909990e-02f, -5.75551838e-02f, 3.44429500e-02f, -2.03409232e-02f, -4.61360924e-02f, 3.13785449e-02f, 9.61136371e-02f, 2.30521783e-02f, 1.55482879e-02f, -6.59456104e-02f,
  -9.18148533e-02f, -4.12923209e-02f, -1.18791368e-02f, 1.68443676e-02f, -2.30069254e-02f, 2.49709822e-02f, 4.75728922e-02f, -4.24058735e-02f, -5.60331866e-02f, 3.75436172e-02f,
  1.25246599e-01f, -3.85351069e-02f, 1.22966953e-01f, 6.42435774e-02f, -8.65170136e-02f, -2.10239980e-02f, 1.51496651e-02f, -5.58367334e-02f, -3.47943418e-02f, 4.14059944e-02f,
  -6.31451830e-02f, 7.88173452e-03f, -2.21840516e-02f, 4.97884154e-02f, 2.52786595e-02f, 1.71737485e-02f, 6.91496879e-02f, 2.85528116e-02f, 1.04560897e-01f, -5.88848926e-02f,
  1.29947633e-01f, 2.00331926e-01f, 1.75368965e-01f, 9.92703140e-02f, 1.26027122e-01f, 1.85300678e-01f, 1.84820324e-01f, 1.09969430e-01f, 1.22471616e-01f, 3.08738261e-01f,
  1.69287980e-01f, 1.44549370e-01f, 4.98529166e-01f, 1.94696978e-01f, -4.25137952e-02f, -2.30931059e-01f, -2.94251442e-01f, -2.66110092e-01f, -5.47845922e-02f, -4.27081995e-02f,
  -2.16543496e-01f, -2.37832852e-02f, 1.98140725e-01f, 1.27301672e-02f, -5.37958108e-02f, 7.11240768e-02f, 3.22535574e-01f, 3.64955127e-01f, 3.17146666e-02f, -1.25663251e-01f,
  -7.79890269e-02f, 1.89462956e-02f, 1.63797230e-01f, 9.86645520e-02f, 2.55959570e-01f, 6.52189106e-02f, 2.56050766e-01f, 2.22460136e-01f, 7.29050711e-02f, 4.67140645e-01f,
  1.79736078e-01f, -8.44762027e-02f, -6.98734745e-02f, -1.11039244e-01f, -9.23436955e-02f, -4.24650908e-02f, -9.88342240e-02f, 1.97374113e-02f, -5.69658577e-02f, 2.24595368e-02f,
  -2.91517470e-02f, -2.30151368e-03f, 6.27611056e-02f, -4.37229238e-02f, -2.57190615e-02f, -2.36007757e-02f, -2.86209211e-02f, 4.30369750e-02f, 7.78279677e-02f, 5.16109131e-02f,
  -9.72504448e-03f, 3.23938429e-02f, 6.98573366e-02f, -5.72749265e-02f, -4.92104702e-02f, 1.13412894e-01f, -3.68444398e-02f, 8.99320841e-03f, -1.65191323e-01f, -4.74012308e-02f,
  -9.96598005e-02f, 5.24238162e-02f, 3.12390290e-02f, 1.47165172e-02f, 6.48512468e-02f, 5.45925349e-02f, 9.77315754e-03f, 1.81896221e-02f, -7.50322416e-02f, 8.15666690e-02f,
  4.68029492e-02f, -7.27965683e-02f, -1.94280073e-02f, 4.62232381e-02f, 3.14119682e-02f, 1.75270606e-02f, -3.24528059e-03f, -4.40001972e-02f, -1.07205734e-02f, -2.77716424e-02f,
  1.97805967e-02f, 3.58771123e-02f, 4.67055850e-02f, -2.80939136e-02f, -1.42283477e-02f, 1.10310977e-02f, 1.28617417e-02f, -9.86722782e-02f, -9.15278867e-02f, 3.41053978e-02f,
  -2.47722343e-01f, -2.47603491e-01f, 2.46187039e-02f, -7.18164211e-03f, -4.07057628e-03f, -2.97673270e-02f, 4.63087996e-03f, -3.48763764e-02f, 1.57942027e-02f, -7.85045177e-02f,
  -8.68309140e-02f, 2.76376400e-02f, -1.02243787e-02f, -8.87457654e-03f, -6.05023019e-02f, -4.93047014e-02f, -1.31107807e-01f, 1.42195553e-01f, -6.87077865e-02f, 2.51672771e-02f,
  3.04747671e-02f, -1.65142491e-01f, -2.01455690e-02f, -1.01354674e-01f, -1.88307121e-01f, -9.21116173e-02f, -8.91392156e-02f, -1.00868784e-01f, -7.59854987e-02f, -1.12041116e-01f,
  -4.34052557e-01f, -3.63993138e-01f, -1.59043998e-01f, -3.47920418e-01f, -3.01778316e-01f, -2.45828182e-01f, -2.23654285e-01f, -1.05775788e-01f, -8.10470432e-02f, -2.58966267e-01f,
  -8.60928223e-02f, -9.88489017e-02f, -1.90966893e-02f, -3.49119231e-02f, -4.95886728e-02f, -2.02502444e-01f, -7.56336600e-02f, -5.52500561e-02f, 5.65284528e-02f, -1.60572052e-01f,
  -2.16469944e-01f, -1.13145754e-01f, -1.03201181e-01f, -1.33907637e-02f, -1.20576769e-01f, -1.02373129e-02f, -9.90706682e-02f, -1.94807008e-01f, -5.88265024e-02f, -1.71482235e-01f,
  -8.89914259e-02f, -9.82426330e-02f, 7.82335848e-02f, 4.18320931e-02f, -3.34538817e-02f, 3.60098146e-02f, -6.72284961e-02f, 1.33074075e-01f, 5.33146970e-02f, -2.33632848e-02f,
  -6.76271766e-02f, 1.51322670e-02f, 7.30473325e-02f, -5.48557863e-02f, 6.66241050e-02f, 7.87650570e-02f, 5.64032905e-02f, 7.12437034e-02f, 3.11101843e-02f, -7.75910690e-02f,
  -1.22276634e-01f, -1.20328315e-01f, -2.56549679e-02f, 8.58023539e-02f, 8.36284906e-02f, -1.90693308e-02f, -2.89121158e-02f, 8.99681225e-02f, 5.18685691e-02f, 3.37918028e-02f,
  6.09362163e-02f, -3.96114960e-02f, 5.83144948e-02f, 3.99338119e-02f, 1.56579074e-02f, -9.65512265e-03f, 4.23416868e-02f, 2.00932007e-02f, -4.43789475e-02f, -3.56750898e-02f,
  -2.31878795e-02f, 7.25771338e-02f, 1.20365694e-02f, -2.55822688e-02f, -7.40680611e-03f, 1.85609644e-03f, -1.66743156e-02f, -2.95556486e-02f, 2.21118219e-02f, -8.11619405e-03f,
  -4.40770462e-02f, 1.01890760e-02f, -4.92989598e-03f, 4.89354581e-02f, -6.72161505e-02f, -2.11247392e-02f, 5.78102469e-02f, -2.75515784e-02f, -1.09810822e-01f, -8.81019048e-03f,
  3.28692719e-02f, 8.24496672e-02f, 1.48728387e-02f, 9.51888487e-02f, -1.57310832e-02f, 2.41031200e-02f, 4.42632362e-02f, 1.39996514e-01f, 3.08634546e-02f, -1.36728780e-02f,
  2.34266277e-02f, -4.70707752e-02f, 2.11476292e-02f, 4.25981842e-02f, -6.91498369e-02f, 4.51563187e-02f, -3.70547622e-02f, -6.86099902e-02f, 1.23043597e-01f, 2.76792254e-02f,
  -1.85821764e-02f, 5.10251895e-02f, 7.40234330e-02f, 1.38207451e-01f, 1.87468680e-03f, 1.47172973e-01f, 4.95083295e-02f, 1.17562808e-01f, 2.87120882e-02f, -3.51511277e-02f,
  -4.13631141e-01f, -3.60829979e-01f, -7.25388676e-02f, -3.08714006e-02f, 4.19102490e-01f, 3.76250893e-01f, 2.97312409e-01f, 1.12649925e-01f, -3.54352668e-02f, -4.78133298e-02f,
  -3.31317894e-02f, -1.10836379e-01f, -1.68455750e-01f, -2.75390595e-01f, -2.47380823e-01f, -1.10199139e-01f, -2.61212051e-01f, -2.74383873e-01f, 9.75184068e-02f, 2.51124978e-01f,
  1.37367651e-01f, -6.27423152e-02f, -2.12296695e-01f, -1.14257850e-01f, 2.50059199e-02f, 3.98031771e-02f, -4.44942787e-02f, -1.20865516e-01f, 4.60262336e-02f, -1.86328411e-01f,
  -6.11162633e-02f, -1.47310853e-01f, -7.39199901e-03f, -2.74298433e-02f, -2.38236822e-02f, -1.44207463e-01f, -2.43880078e-02f, -6.89136833e-02f, -2.12089717e-02f, -1.34358585e-01f,
  9.06092022e-03f, -8.37138146e-02f, -5.59885018e-02f, 1.27942758e-02f, -3.07713705e-03f, -6.17712028e-02f, -1.01685442e-01f, -1.46114752e-01f, -1.13128647e-01f, -9.84014757e-03f,
  1.40941180e-02f, -3.09616122e-02f, -2.95475796e-02f, 3.89695843e-03f, -1.39037818e-01f, -1.00953110e-01f, -1.01611406e-01f, -5.10964319e-02f, 2.39026193e-02f, -5.32752951e-04f,
  2.82431711e-02f, 9.53496546e-02f, 1.52852267e-01f, 9.25134122e-02f, 1.18356690e-01f, 9.79955941e-02f, 3.72690894e-02f, 3.24367881e-02f, 4.62881774e-02f, 2.30380967e-02f,
  1.11414477e-01f, 3.18056233e-02f, 6.67307079e-02f, 2.28682905e-02f, -5.30389510e-02f, 8.08622241e-02f, 2.12088297e-03f, -1.01551786e-02f, -5.76020824e-03f, 9.96665284e-02f,
  1.35986879e-01f, 1.53008699e-01f, 9.67203751e-02f, 6.99863061e-02f, -1.76667590e-02f, -2.33728886e-02f, -1.22542039e-03f, 5.68846613e-02f, 8.05608183e-02f, 2.83319205e-02f,
  -5.89777604e-02f, 3.27690068e-04f, -1.36252031e-01f, -1.26693949e-01f, -1.00061424e-01f, -8.89097676e-02f, -5.91614433e-02f, -1.00863725e-01f, -8.92973840e-02f, -4.53451946e-02f,
  2.17907391e-02f, -8.02438334e-02f, -2.08039284e-01f, -8.90701450e-03f, -1.77516211e-02f, -3.26386541e-02f, -1.79543607e-02f, -9.61596817e-02f, -7.14001954e-02f, 4.80295829e-02f,
  -3.69859934e-02f, 1.12055428e-01f, 3.97791900e-02f, 3.22097428e-02f, 1.81269050e-02f, -2.42328662e-02f, 7.14645386e-02f, 2.94681359e-02f, -1.67569220e-02f, 2.11800486e-02f,
  2.28211030e-01f, -2.20468760e-01f, -3.19220036e-01f, -8.87802765e-02f, -3.52794945e-01f, -2.28131726e-01f, -1.97664142e-01f, 4.13818471e-02f, -2.08777208e-02f, -1.94131002e-01f,
  -2.83303231e-01f, -1.08447768e-01f, -2.23823562e-01f, -1.34492740e-01f, 7.98869729e-02f, -1.99665174e-01f, -9.10594240e-02f, -6.71562413e-03f, 7.02166706e-02f, -2.24695094e-02f,
  9.69847012e-03f, 6.42089620e-02f, 1.34686679e-01f, 8.32510889e-02f, -8.19774717e-02f, -7.02393204e-02f, -1.38705373e-01f, -1.31994173e-01f, -1.61199570e-01f, -9.69236642e-02f,
  -3.96117985e-01f, 1.24964910e-02f, -8.11646283e-02f, -1.55182765e-03f, -1.13841303e-01f, 8.56424272e-02f, -1.26152992e-01f, 7.53407106e-02f, 3.20276842e-02f, -7.33727440e-02f,
  -1.90646335e-01f, -7.01821446e-02f, -8.28521922e-02f, 1.52468532e-02f, -4.07762751e-02f, 8.36953595e-02f, 7.36894011e-02f, 7.94979334e-02f, -9.67297610e-03f, -1.01637796e-01f,
  -1.81193963e-01f, -1.37140881e-02f, -4.55189683e-02f, 5.58203831e-02f, 4.98772003e-02f, -8.05864707e-02f, 1.30660273e-02f, 5.71980029e-02f, -4.34589423e-02f, 5.09097576e-02f,
  6.78014681e-02f, -5.82065023e-02f, -3.72438803e-02f, -1.17342090e-02f, 4.58020121e-02f, 2.93179788e-02f, -4.09877636e-02f, -3.18070985e-02f, -8.03740323e-03f, 9.50141065e-03f,
  1.16576152e-02f, -4.41799462e-02f, 8.18707496e-02f, -3.03627215e-02f, -2.02884506e-02f, -1.93448626e-02f, -4.78920266e-02f, -1.18676405e-02f, 4.23117317e-02f, 2.87054870e-02f,
  -8.42161179e-02f, -1.35586942e-02f, -3.31338309e-02f, -1.22745857e-02f, -5.92269078e-02f, 1.31874206e-02f, -5.56684211e-02f, 1.12950578e-02f, -1.21452436e-02f, -1.34723485e-02f,
  -1.76577494e-01f, -7.68109858e-02f, -5.41849658e-02f, 9.88959298e-02f, -2.89633404e-02f, 9.76532623e-02f, -8.37800577e-02f, 7.77790546e-02f, -2.25615669e-02f, 9.24343523e-03f,
  -1.19784467e-01f, 2.14129090e-02f, -6.46202192e-02f, -1.83717832e-02f, 1.59730501e-02f, -5.31799942e-02f, -3.74008715e-03f, -1.35393590e-01f, -3.91588248e-02f, -9.05577019e-02f,
  -7.10118515e-03f, 1.21891931e-01f, 1.43735111e-01f, -2.87522860e-02f, -4.68594115e-03f, -9.48455408e-02f, -8.95144120e-02f, -3.66577506e-02f, 5.70723340e-02f, 3.07225082e-02f,
  1.05788507e-01f, 5.41785300e-01f, 1.84015080e-01f, 1.76759571e-01f, 5.03147282e-02f, 3.07754278e-02f, 1.92504093e-01f, 1.85651407e-01f, -2.82059349e-02f, 9.49032828e-02f,
  2.57027969e-02f, -1.85484141e-01f, -1.18452162e-01f, -1.77780941e-01f, 2.74996217e-02f, 2.79105902e-01f, 3.01621825e-01f, -7.20249563e-02f, -2.93185651e-01f, -1.27003744e-01f,
  7.60305226e-02f, 3.35473642e-02f, 4.12904806e-02f, -3.47333923e-02f, 1.89358905e-01f, -8.19650944e-03f, 2.77530491e-01f, 1.96848318e-01f, 6.79333955e-02f, 3.34129542e-01f,
  -1.38176277e-01f, 2.16043085e-01f, -8.78002048e-02f, -3.81254852e-02f, -4.78328094e-02f, 2.80628987e-02f, 2.78120767e-02f, -1.60313379e-02f, -2.59723831e-02f, 1.64441802e-02f,
  1.05417604e-02f, 1.59681793e-02f, 6.13296144e-02f, -2.22347938e-02f, 1.54397618e-02f, 7.31238648e-02f, 1.44339979e-01f, -2.26274822e-02f, -4.89928126e-02f, -4.49674204e-03f,
  1.49520770e-01f, 2.68703196e-02f, 6.47581648e-03f, -1.56428069e-02f, 4.44532670e-02f, -1.13224760e-01f, 6.14939854e-02f, 7.73643106e-02f, -7.96033219e-02f, 1.75726697e-01f,
  4.25641164e-02f, 1.04030361e-02f, 4.01630104e-02f, -1.37795303e-02f, 1.46248182e-02f, 1.31313540e-02f, -2.21224246e-03f, 5.42449430e-02f, -1.51150422e-02f, 5.26184887e-02f,
  -5.95846958e-02f, -2.86687352e-02f, 4.96843755e-02f, 2.90315393e-02f, -3.39906253e-02f, 3.19442078e-02f, 2.56562624e-02f, 3.15388925e-02f, -7.46408999e-02f, -1.39080025e-02f,
  -4.78339344e-02f, -8.72628167e-02f, -2.07611155e-02f, 7.92332888e-02f, -1.68203693e-02f, -1.45944522e-03f, -1.97620969e-02f, -2.49860827e-02f, -5.30601367e-02f, 5.94173223e-02f,
  -1.05678767e-01f, -1.67562753e-01f, 7.99635425e-02f, 2.52744555e-02f, 1.07420169e-01f, 1.03059418e-01f, 2.59203743e-03f, 1.25900328e-01f, 3.75187881e-02f, 6.66560605e-02f,
  -5.29821478e-02f, 4.94442098e-02f, -2.14719353e-03f, 5.44244982e-02f, -4.17031758e-02f, -6.76508844e-02f, 7.50419050e-02f, 8.71236250e-02f, 6.03183284e-02f, 4.95081060e-02f,
  1.31867349e-01f, 1.15081474e-01f, -1.01734579e-01f, 6.41149059e-02f, -6.25085235e-02f, -6.85179904e-02f, -4.56389710e-02f, 2.06394494e-02f, -5.97811714e-02f, 1.81237653e-01f,
  4.78703678e-01f, -4.20388997e-01f, 2.26130322e-01f, 2.89846361e-02f, 4.04199632e-03f, 5.01044318e-02f, -1.80664003e-01f, -9.33173522e-02f, -4.20798920e-02f, -1.16757490e-01f,
  -1.17858477e-01f, -1.61202461e-01f, -7.48405531e-02f, -7.21461773e-02f, -2.58461721e-02f, -3.05353314e-01f, -1.16791114e-01f, 1.99626252e-01f, 2.98604906e-01f, -1.96161382e-02f,
  -2.52357781e-01f, 6.36334419e-02f, 2.39111573e-01f, -4.39596027e-02f, -3.22969109e-01f, -1.58689931e-01f, -1.34529009e-01f, -7.54886344e-02f, -1.21821269e-01f, -3.38773191e-01f,
  -8.50450471e-02f, 4.95628566e-02f, 3.10476255e-02f, -6.49811924e-02f, 5.93824638e-03f, -6.86210394e-02f, -2.00099032e-02f, 1.51807806e-02f, -9.73349735e-02f, -1.46157876e-01f,
  -8.27504694e-03f, 6.11447878e-02f, -4.27675061e-02f, -1.29120559e-01f, 5.26213124e-02f, -1.12732872e-01f, -9.36490949e-03f, -3.89744118e-02f, -1.11926377e-01f, -6.17750138e-02f,
  -2.08202541e-01f, 4.79416475e-02f, 1.65108982e-02f, -2.09414344e-02f, 3.87684628e-02f, 6.66030198e-02f, -8.37722197e-02f, 1.37514723e-02f, -2.86583975e-03f, -1.44474626e-01f,
  2.10298859e-02f, -4.44819592e-02f, 3.25164981e-02f, 1.14160404e-03f, 2.28299964e-02f, -6.44218326e-02f, -2.37391945e-02f, -3.77630405e-02f, 2.45010369e-02f, -1.32529968e-02f,
  1.33111021e-02f, 1.42687159e-02f, -3.15060606e-03f, 1.09769655e-02f, -4.76405956e-02f, -3.48658371e-03f, 1.90548021e-02f, -7.46494532e-02f, -5.47040254e-02f, 1.24207903e-02f,
  4.40636203e-02f, -3.28590758e-02f, 8.88533425e-03f, -3.71442921e-02f, -2.40128525e-02f, 2.85678115e-02f, -4.28245887e-02f, -3.54764238e-02f, 1.64642036e-02f, 2.76883729e-02f,
  -2.72555709e-01f, 2.48722345e-01f, -6.72849491e-02f, -7.28797242e-02f, -1.87103562e-02f, -5.63520938e-02f, -6.42962083e-02f, -7.50725940e-02f, 3.03394487e-03f, -1.28879890e-01f,
  8.72723351e-04f, -6.64315149e-02f, -2.18592640e-02f, -2.89249830e-02f, 2.93306876e-02f, 3.66760604e-02f, -1.48683369e-01f, -6.87597767e-02f, -8.57435539e-02f, -1.38200983e-01f,
  -2.07064003e-01f, -3.39499977e-03f, 1.08401172e-01f, -1.54412836e-01f, -1.06045067e-01f, 9.43590105e-02f, -7.26666078e-02f, 1.27962825e-03f, 5.00252619e-02f, -1.55181170e-01f,
  4.31470037e-01f, -2.06642956e-01f, -1.47293031e-01f, 1.85980022e-01f, -1.91138968e-01f, -3.18348736e-01f, -3.66331816e-01f, -1.11460917e-01f, -9.67242494e-02f, -1.80733323e-01f,
  -1.80974573e-01f, 1.65995564e-02f, -1.39244482e-01f, -7.13405684e-02f, -3.97259556e-02f, -3.61037493e-01f, -1.64398119e-01f, 7.13299364e-02f, 1.18420936e-01f, 1.31269321e-01f,
  -8.13976675e-02f, 1.15428977e-01f, 3.13134968e-01f, 1.80181578e-01f, 7.13834465e-02f, -9.99337658e-02f, -1.13545515e-01f, 2.03975707e-01f, -7.45712966e-02f, 1.63666040e-01f,
  -9.78716016e-02f, 2.77197182e-01f, -1.59727722e-01f, -8.92960802e-02f, -1.52568929e-02f, -2.24115211e-03f, -4.22892235e-02f, 2.05166601e-02f, -2.87453644e-02f, -1.52878230e-02f,
  7.05013343e-04f, -3.92220020e-02f, 4.88123819e-02f, 5.18750101e-02f, 2.33301390e-02f, -2.91237049e-02f, 6.74829781e-02f, 9.72766876e-02f, -9.00392886e-03f, 1.59395728e-02f,
  -2.77038924e-02f, 5.93279041e-02f, 1.43565293e-02f, 5.38640888e-03f, 7.07648089e-03f, 1.55937178e-02f, -3.60827558e-02f, 1.16361454e-01f, 5.36526777e-02f, -2.26158407e-02f,
  -1.24434665e-01f, -4.38942276e-02f, 8.44261050e-02f, 1.02714650e-01f, 3.03177852e-02f, -4.99103870e-03f, 1.16621934e-01f, 2.62165796e-02f, 1.80123616e-02f, 6.94015324e-02f,
  1.04453817e-01f, 4.02367823e-02f, 1.59072094e-02f, 3.98645066e-02f, 3.99890263e-03f, 2.73996666e-02f, 2.72921839e-04f, 8.75872523e-02f, 2.29446078e-03f, 6.74907565e-02f,
  4.56551015e-02f, 4.91163060e-02f, 6.59198361e-03f, -6.93028560e-03f, 1.16641402e-01f, 9.79033411e-02f, 1.09248646e-01f, 3.92556749e-02f, 1.07533470e-01f, 4.62522618e-02f,
  -1.71973079e-01f, -1.28817856e-01f, -1.14702426e-01f, -3.39761749e-02f, -2.26057246e-02f, -2.90828850e-02f, -1.44974932e-01f, -1.04143873e-01f, -2.94215679e-02f, -6.61155283e-02f,
  -2.80052386e-02f, -3.11346594e-02f, -4.19874527e-02f, -8.58440548e-02f, -1.03962332e-01f, -1.45889185e-02f, -1.33885816e-01f, -4.40376252e-02f, -1.38829768e-01f, -1.22377783e-01f,
  -2.33431637e-01f, -1.27099156e-01f, -2.42326230e-01f, -2.29344785e-01f, -7.60111511e-02f, -2.57348657e-01f, -2.35048920e-01f, -1.71609804e-01f, -1.97152704e-01f, -3.19974244e-01f,
  -4.45868760e-01f, 1.24654755e-01f, -3.08463395e-01f, 9.51887891e-02f, 2.98534542e-01f, 1.20511718e-01f, 1.62444234e-01f, 7.67114665e-03f, 9.53993648e-02f, 7.45620951e-02f,
  1.51929259e-01f, 4.22809683e-02f, -1.70291156e-01f, -1.93537667e-01f, -1.93731472e-01f, -1.11195341e-01f, -9.70082805e-02f, -3.00993800e-01f, -3.24632198e-01f, -6.38931617e-02f,
  1.58915430e-01f, 7.92609304e-02f, -2.17053086e-01f, -2.05819994e-01f, 1.33306846e-01f, -7.40920156e-02f, -3.81750725e-02f, 6.86132237e-02f, -5.18481135e-02f, -1.50971055e-01f,
  -2.03673795e-01f, 7.01619918e-03f, -2.37413764e-01f, -6.86243922e-02f, -3.64662707e-02f, -2.18651578e-01f, -1.08765267e-01f, -1.31935060e-01f, -1.18240090e-02f, -6.27201423e-02f,
  -7.55858347e-02f, 2.03536302e-02f, 2.69067623e-02f, -9.57136229e-02f, -6.51941672e-02f, -7.78321503e-03f, -1.06504671e-01f, -1.98863119e-01f, -1.46519437e-01f, -1.09841160e-01f,
  1.86943859e-02f, 1.65349543e-02f, -2.76962698e-01f, -1.81576937e-01f, -1.45290717e-01f, -2.09634960e-01f, -7.36183897e-02f, -1.40841022e-01f, -3.00229400e-01f, -2.70796865e-01f,
  -1.24294885e-01f, 2.27647200e-02f, 4.38046791e-02f, 7.87478983e-02f, 3.20199095e-02f, 1.55813256e-02f, 3.70608680e-02f, 1.83870606e-02f, -2.98323594e-02f, 3.64455767e-02f,
  7.96884224e-02f, -2.79489979e-02f, -9.12689511e-03f, 8.12584534e-03f, -1.41553767e-02f, -1.67468134e-02f, 2.02428866e-02f, 6.74301907e-02f, 2.72998735e-02f, -1.79175697e-02f,
  -5.42602055e-02f, -5.96296415e-02f, 4.74724993e-02f, 4.97759059e-02f, 8.24745446e-02f, -6.69722930e-02f, 9.79008526e-03f, 3.38163078e-02f, -4.61097360e-02f, 9.52941403e-02f,
  3.51277143e-02f, -1.57538444e-01f, -1.44477829e-01f, -1.49643525e-01f, 4.34211688e-03f, 9.55229811e-03f, -5.46895228e-02f, -2.23645419e-02f, -8.83161724e-02f, -1.01754062e-01f,
  -4.51966524e-02f, -7.65979216e-02f, 4.59438749e-02f, -3.11250854e-02f, -5.49391285e-02f, -8.22712705e-02f, 2.71821618e-02f, -4.19200361e-02f, -1.93368822e-01f, -3.29747312e-02f,
  -4.85071614e-02f, -1.00520141e-01f, -2.72814333e-01f, -1.39560208e-01f, -1.70655876e-01f, -1.40520677e-01f, -2.15383038e-01f, -1.13820247e-01f, -1.78667948e-01f, -1.08228989e-01f,
  6.74847722e-01f, -5.13289154e-01f, -4.10039097e-01f, 1.55303165e-01f, -3.10554236e-01f, -4.02529329e-01f, -5.80484152e-01f, -1.20752677e-02f, 2.26294860e-01f, -3.08039606e-01f,
  -2.34644338e-01f, 8.62122327e-02f, -5.71033172e-02f, -1.33967921e-01f, -3.93735096e-02f, -4.82185602e-01f, -3.14852983e-01f, -5.80203719e-02f, 2.90165514e-01f, 1.30684197e-01f,
  -5.02015799e-02f, 1.68192044e-01f, 2.93367147e-01f, 1.06087789e-01f, -6.02323413e-02f, -3.30239609e-02f, -2.58177847e-01f, -1.12843037e-01f, -3.42233121e-01f, -3.79576325e-01f,
  -3.06073636e-01f, -1.87675040e-02f, -4.35830243e-02f, 2.50268560e-02f, -1.08632028e-01f, 3.12165748e-02f, -1.02756135e-02f, 5.52940257e-02f, 4.97481339e-02f, -5.65554202e-02f,
  -5.98548763e-02f, 6.31587580e-02f, -5.93885779e-02f, -1.61509439e-02f, -3.44995260e-02f, -6.39047921e-02f, 8.73018131e-02f, 7.22579062e-02f, -3.61367129e-02f, -1.43663421e-01f,
  -2.08977893e-01f, -2.32401550e-01f, -1.85248747e-01f, -1.04465082e-01f, -4.81770228e-04f, -4.85183597e-02f, -3.13982293e-02f, -3.75386141e-02f, -8.68186951e-02f, 3.57188843e-02f,
  1.22779995e-01f, -8.93275440e-03f, 6.10207543e-02f, 8.89326483e-02f, 6.90676495e-02f, 1.10272691e-02f, -5.98628423e-04f, -8.03563446e-02f, 5.03397845e-02f, 9.33572352e-02f,
  5.77847473e-02f, -7.51718953e-02f, 3.86033468e-02f, -1.51730068e-02f, 1.77681874e-02f, 6.06898777e-03f, -1.63902137e-02f, -7.89622683e-03f, -3.71466018e-02f, 4.24583852e-02f,
  4.48571928e-02f, 4.93459515e-02f, -3.39701050e-03f, 6.23229519e-02f, 1.11460956e-02f, 3.66378166e-02f, 5.96037097e-02f, 4.46172319e-02f, 8.42695907e-02f, 7.02179223e-02f,
  1.33167893e-01f, -1.98302686e-01f, -1.29175320e-01f, -2.38851458e-02f, -1.32705316e-01f, -2.31454223e-02f, -1.39214948e-01f, -8.04463997e-02f, -1.88960969e-01f, -9.25825462e-02f,
  -1.66441292e-01f, -1.71125587e-02f, -1.72183841e-01f, -1.02050558e-01f, -4.00178786e-03f, 1.56529751e-02f, -9.90864635e-02f, -8.28785971e-02f, -7.09924623e-02f, -1.02444552e-01f,
  -9.97721180e-02f, -6.01118281e-02f, -4.59491834e-02f, -9.74379033e-02f, -7.23366290e-02f, -5.16478941e-02f, -1.64722174e-01f, -9.24318060e-02f, -1.20503120e-01f, -3.23358290e-02f,
  -3.82374823e-01f, -1.88477989e-02f, 6.54015765e-02f, 3.57268490e-02f, 1.93686992e-01f, 2.79659271e-01f, 3.23414177e-01f, 3.81112508e-02f, -6.06505647e-02f, 4.74690087e-03f,
  -1.23375924e-02f, -1.42104506e-01f, -1.08662948e-01f, -1.15819559e-01f, -5.75496331e-02f, 1.42898500e-01f, 1.84784725e-01f, 3.25442478e-02f, 1.00450262e-01f, 2.02773347e-01f,
  1.02129459e-01f, 5.79509325e-03f, 5.78050129e-02f, 3.92849073e-02f, -8.08101520e-02f, -1.65139344e-02f, 9.81987491e-02f, 7.59171844e-02f, 1.03126876e-01f, 1.38917431e-01f,
  -2.67959148e-01f, -7.54513592e-02f, 7.92751387e-02f, -1.11362487e-01f, -9.03824270e-02f, -1.74970672e-01f, -1.70451865e-01f, -4.14471067e-02f, -1.61639944e-01f, -5.26341386e-02f,
  6.29633898e-03f, -1.02751590e-01f, -5.92597090e-02f, 4.70703728e-02f, -9.47190598e-02f, -1.04558498e-01f, -1.12788007e-01f, -1.68188270e-02f, -5.46427779e-02f, -5.41797802e-02f,
  1.00192688e-02f, 3.50160487e-02f, -1.00749031e-01f, -2.94836750e-03f, 1.14312889e-02f, -4.15242128e-02f, -8.09620097e-02f, -1.01313174e-01f, -1.37432083e-01f, -1.78161696e-01f,
  9.55106691e-03f, 6.29250780e-02f, 1.36819631e-02f, 1.20357975e-01f, 1.70227233e-02f, 5.51381893e-02f, 4.80330028e-02f, 1.07779749e-01f, 6.39201850e-02f, 2.14092154e-02f,
  1.08030386e-01f, -1.99522241e-03f, 3.80868949e-02f, 1.24684788e-01f, 1.72793660e-02f, 1.04756132e-01f, 6.06198162e-02f, 3.43260355e-02f, 8.95998850e-02f, 8.31329226e-02f,
  1.48749603e-02f, 1.57702398e-02f, 3.47565599e-02f, -5.47683623e-04f, -1.08563667e-03f, 9.11746174e-02f, -1.39094274e-02f, 4.75591905e-02f, 6.83441907e-02f, 6.52475655e-02f,
  -3.66538256e-01f, 1.37426779e-01f, -1.74481913e-01f, -3.15885358e-02f, -7.74724558e-02f, -9.01198313e-02f, -8.18742886e-02f, -4.09300998e-03f, -6.30706474e-02f, -1.19181061e-02f,
  4.99766495e-04f, -5.94651289e-02f, -7.46037886e-02f, -3.55611593e-02f, 1.98293962e-02f, 2.31519081e-02f, -2.63293907e-02f, -6.11471310e-02f, 2.91679204e-02f, -3.12857106e-02f,
  1.18232369e-02f, 2.06927601e-02f, -7.26823583e-02f, -4.06180397e-02f, -6.81987777e-02f, -7.66000673e-02f, -7.68427104e-02f, -7.73722231e-02f, -5.56069203e-02f, -2.31167853e-01f,
  1.72671005e-01f, 2.81121105e-01f, -3.31897914e-01f, 1.84911802e-01f, 1.69243440e-01f, -4.50656079e-02f, 1.65691108e-01f, 1.93060711e-02f, 1.53765053e-01f, 1.07508808e-01f,
  9.80764180e-02f, -1.92798391e-01f, -1.36306956e-01f, -1.51780829e-01f, -3.23763728e-01f, -1.56838179e-01f, -1.02471463e-01f, -4.18471336e-01f, -3.34731460e-01f, -5.95929697e-02f,
  1.01073869e-01f, 1.40993774e-01f, -2.12596804e-02f, -5.45787849e-02f, 2.95417875e-01f, -5.11474907e-02f, 6.92717433e-02f, 8.73779431e-02f, 1.16786867e-01f, 1.45691736e-02f,
  -1.58539534e-01f, 1.14182420e-01f, -1.98447719e-01f, -2.78767850e-02f, 2.66545732e-02f, 1.51389064e-02f, -9.27764922e-02f, 2.01608166e-02f, -4.45129983e-02f, -3.09690554e-02f,
  1.36371432e-02f, -1.37517005e-02f, -1.01047941e-02f, 6.97444705e-03f, 7.62533396e-02f, -1.13400808e-02f, -6.77169189e-02f, -4.91656251e-02f, -1.09738290e-01f, 3.39852273e-02f,
  1.26776425e-02f, 4.34024930e-02f, -6.26637489e-02f, 2.55668834e-02f, -5.13963141e-02f, -1.68514729e-01f, -6.73233420e-02f, 1.13181800e-01f, -9.91819203e-02f, 1.92123681e-01f,
  -3.87669653e-02f, 2.94228867e-02f, 5.26563339e-02f, 5.59430569e-03f, 1.36189982e-01f, -2.23242436e-02f, 3.20445858e-02f, 5.47146564e-03f, 4.36764732e-02f, 6.20617457e-02f,
  -9.30095994e-05f, -4.78998758e-02f, -1.49324937e-02f, 7.37363547e-02f, 5.16125858e-02f, 2.81211268e-02f, -1.26987556e-03f, 4.50476276e-04f, 4.71173786e-02f, 9.64609832e-02f,
  -1.21313101e-02f, 1.73616372e-02f, -1.44200055e-02f, 5.84423058e-02f, 5.76974675e-02f, 1.13459239e-02f, -1.26289697e-02f, 3.97315584e-02f, 5.71514182e-02f, 1.15268268e-01f,
  3.76145579e-02f, -1.66424453e-01f, -4.99450825e-02f, -5.29021397e-02f, -4.15957570e-02f, -9.99797881e-03f, 4.33188081e-02f, -2.80622337e-02f, 3.49129848e-02f, 2.92574819e-02f,
  -6.41920716e-02f, -8.11301544e-02f, -3.49579044e-02f, -1.48729607e-02f, -7.99020156e-02f, -5.78189380e-02f, 1.28923655e-01f, -9.15242657e-02f, -9.32902247e-02f, 9.07401592e-02f,
  2.66113020e-02f, -5.60061447e-02f, -1.10246658e-01f, -5.30933924e-02f, -8.80162418e-03f, -2.04073206e-01f, -5.57068586e-02f, -8.68848432e-03f, -2.42495939e-01f, 1.48629472e-01f,
  4.66047414e-02f, 9.21780430e-03f, 2.37324238e-01f, 4.54869447e-03f, 2.22515956e-01f, 3.47297698e-01f, 4.48551536e-01f, 3.19481552e-01f, 1.49365768e-01f, 6.64665624e-02f,
  4.90270332e-02f, 5.89691177e-02f, 1.35890841e-02f, 1.73851728e-01f, 2.02940702e-01f, 3.81897092e-01f, 2.55647093e-01f, 1.58053622e-01f, 1.56207055e-01f, -4.30666236e-03f,
  -5.99573180e-02f, -1.75900742e-01f, -1.13156348e-01f, -1.28655821e-01f, -2.91206002e-01f, -1.87783644e-01f, 7.64203593e-02f, -1.71294548e-02f, 4.40479256e-02f, -2.66777724e-01f,
  -1.51902348e-01f, 1.14516236e-01f, 1.34832129e-01f, -2.10229550e-02f, -3.18951011e-02f, 2.46250518e-02f, -7.42075220e-03f, -2.80090831e-02f, 1.19584382e-01f, -2.85787061e-02f,
  9.48408395e-02f, 1.73299927e-02f, 1.07536251e-02f, 2.73057409e-02f, 5.21267429e-02f, 8.14723000e-02f, 1.37247935e-01f, 2.15176959e-02f, 1.61545634e-01f, 1.39093667e-01f,
  9.06872228e-02f, 4.36066352e-02f, 1.91888005e-01f, 1.06084183e-01f, 6.27378225e-02f, 2.69572973e-01f, 1.57507602e-02f, 3.45957801e-02f, 2.09395230e-01f, -8.54964182e-02f,
  -1.41889557e-01f, -7.25743324e-02f, -1.08095273e-01f, -1.12808987e-01f, -4.18666042e-02f, -9.92077962e-02f, -5.03382161e-02f, -1.45564631e-01f, -7.50463158e-02f, -9.01189074e-02f,
  -7.82565773e-02f, -2.54755728e-02f, -5.25732487e-02f, -7.20259622e-02f, -1.60625085e-01f, -7.04672933e-02f, -8.34508240e-02f, -1.08454183e-01f, -8.35551769e-02f, -1.08895436e-01f,
  -8.40835646e-02f, -6.13349788e-02f, -1.06440701e-01f, -1.93006486e-01f, -2.76629031e-02f, -3.70873883e-02f, -8.42516497e-02f, -7.10334182e-02f, -9.93462726e-02f, -1.46661559e-02f,
  -1.13147072e-01f, 3.77861232e-01f, 6.94719553e-02f, 6.88764974e-02f, 1.15298621e-01f, 7.07397461e-02f, 7.18571022e-02f, 9.44240093e-02f, 1.02208242e-01f, 4.17020582e-02f,
  7.92218000e-02f, 7.60201067e-02f, 1.51778266e-01f, 1.18237160e-01f, 4.46467139e-02f, 1.18300036e-01f, 7.99426213e-02f, 1.13659374e-01f, 1.89720258e-01f, -8.28366843e-04f,
  7.64100403e-02f, 1.48422465e-01f, 1.78966895e-01f, 1.95640892e-01f, 1.24501497e-01f, 1.60321116e-01f, 5.19594364e-02f, 4.09363629e-03f, 2.05224991e-01f, 2.98291296e-02f
};

// L0_fan_Wp_bar (Shape: 26 x 120)
const int L0_fan_Wp_bar_rows = 26;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  9.11982358e-01f, 4.20669675e-01f, 4.13726181e-01f, 1.42951593e-01f, -1.73107773e-01f, -4.26513314e-01f, -2.82438606e-01f, -4.46085125e-01f, -2.92289674e-01f, 1.47796683e-02f,
  5.08414134e-02f, -1.40856117e-01f, -1.88060164e-01f, -1.14336677e-01f, -1.73668638e-02f, -1.01373363e-02f, -1.21642232e-01f, 4.04089540e-01f, 1.44640908e-01f, 4.28627431e-02f,
  1.16601475e-02f, 3.19317967e-01f, 5.41945696e-01f, 2.65741825e-01f, 3.94507796e-02f, -1.45666987e-01f, -4.41587344e-02f, 2.99717307e-01f, 1.77724615e-01f, 4.60813403e-01f,
  3.94321173e-01f, 3.65168095e-01f, -3.21678430e-01f, -1.17190465e-01f, 8.64286423e-02f, 6.41963705e-02f, 3.52111384e-02f, -8.39153603e-02f, -3.36952694e-02f, -1.19468257e-01f,
  1.04024038e-01f, 1.52222803e-02f, -1.56698786e-02f, -1.47207767e-01f, -7.45289177e-02f, -9.60366428e-02f, -1.01769216e-01f, 3.86345461e-02f, -1.36786506e-01f, 8.67903233e-02f,
  -1.12037696e-01f, -9.21812560e-03f, -1.10843226e-01f, -3.90125990e-01f, -1.46628872e-01f, -1.78193435e-01f, -1.58473477e-01f, -9.64717418e-02f, -2.35959202e-01f, -3.64678982e-03f,
  -2.49979958e-01f, -6.26984006e-03f, -5.97687624e-02f, -8.28862712e-02f, -1.77084133e-01f, -1.81781650e-01f, -1.51220262e-01f, -1.22166924e-01f, -8.54909606e-03f, -4.56786826e-02f,
  -2.35157281e-01f, -7.33865099e-03f, -2.04416513e-01f, -2.06712857e-01f, -1.52587488e-01f, -5.40695861e-02f, -3.17773521e-02f, -1.15468554e-01f, 5.11225127e-02f, 2.39445064e-02f,
  1.05431341e-02f, -9.86811370e-02f, -3.25847305e-02f, -1.34230867e-01f, -1.66756794e-01f, -2.24280000e-01f, -1.78974643e-01f, -1.83810323e-01f, -7.41665736e-02f, -6.10464700e-02f,
  -4.43935603e-01f, -9.06365886e-02f, 5.24370112e-02f, 2.25112423e-01f, 2.35769495e-01f, 2.01916113e-01f, 1.80995584e-01f, 3.55923653e-01f, 1.13288417e-01f, 1.08667359e-01f,
  9.19779316e-02f, 2.14678988e-01f, 8.98991972e-02f, -5.52379154e-02f, -5.27432282e-03f, -5.11406101e-02f, 1.06400944e-01f, 4.97976467e-02f, 1.12396823e-02f, 1.65761963e-01f,
  -2.08804179e-02f, -2.03435495e-01f, -2.70505458e-01f, -2.28359163e-01f, -2.00156242e-01f, -3.10852706e-01f, -1.82665616e-01f, -1.72675088e-01f, -1.99959725e-01f, -2.74270713e-01f,
  7.42589533e-02f, 2.53450155e-01f, 5.51083863e-01f, -2.84583122e-01f, -7.31644094e-01f, -5.15493393e-01f, -3.10603410e-01f, -1.41579499e-02f, -8.68776292e-02f, -1.93387829e-02f,
  -4.14710432e-01f, -1.67823642e-01f, 1.73796713e-01f, 2.68382967e-01f, 3.35322052e-01f, 2.75376707e-01f, 2.59003937e-01f, 4.63241339e-01f, 2.34793216e-01f, -1.19034141e-01f,
  -7.71357790e-02f, 4.09297049e-02f, 3.13712835e-01f, 2.48160303e-01f, 2.20791232e-02f, -1.16724864e-01f, 1.42353624e-01f, -2.35133678e-01f, 5.28841629e-04f, 3.01256239e-01f,
  5.82979858e-01f, 9.43634957e-02f, 7.92890415e-02f, 2.31956448e-02f, 2.80901175e-02f, 3.07826370e-01f, 1.31582722e-01f, 1.34510368e-01f, -1.14774503e-01f, 1.25358805e-01f,
  -9.70018096e-03f, 8.90425686e-03f, 4.69097756e-02f, 2.59794574e-03f, -5.07332869e-02f, -2.43457872e-02f, 1.25333577e-01f, 9.66138989e-02f, 8.58988911e-02f, 2.09550709e-01f,
  5.03642485e-02f, -2.28073090e-01f, -1.61788370e-02f, 9.12888348e-02f, 4.40252982e-02f, -3.18044680e-03f, 3.34914774e-02f, 9.44155380e-02f, 1.85643639e-02f, 1.23412862e-01f,
  1.47979781e-01f, 2.76835799e-01f, 8.14354792e-02f, -3.77474166e-03f, 6.58998489e-02f, -3.91860539e-03f, -2.96749100e-02f, -1.01171382e-01f, 8.87044966e-02f, -6.58680573e-02f,
  -6.67432025e-02f, -5.76444231e-02f, 2.55789552e-02f, -4.28100466e-04f, 1.00869775e-01f, 5.30741364e-02f, 3.95314731e-02f, 1.73737884e-01f, 6.81378692e-02f, 1.19886823e-01f,
  3.37965712e-02f, 1.26660168e-01f, -1.27496898e-01f, 1.00703508e-01f, -1.40609920e-01f, -1.02248006e-02f, 6.40759394e-02f, 4.96036820e-02f, -2.94665694e-02f, -1.19661510e-01f,
  1.55523911e-01f, -1.13524333e-01f, 8.28996971e-02f, 6.50329366e-02f, -4.09908108e-02f, 1.78589504e-02f, 4.66035232e-02f, 5.11561893e-03f, -7.50325918e-02f, 9.75199938e-02f,
  6.20898455e-02f, 2.17965588e-01f, 1.42745629e-01f, 6.69338182e-02f, -1.95029303e-01f, -8.19950476e-02f, -1.26789048e-01f, -8.61206427e-02f, 1.12963483e-01f, 1.17035612e-01f,
  5.32771461e-02f, -1.26116350e-01f, -3.05967275e-02f, 4.25269529e-02f, -9.16845538e-03f, -5.69743738e-02f, 2.97198612e-02f, 5.02039455e-02f, -1.25185609e-01f, -1.93347394e-01f,
  8.27404931e-02f, 4.22512203e-01f, -5.81341267e-01f, -3.18741471e-01f, -3.41985255e-01f, -1.62004068e-01f, 3.19399238e-01f, -2.41976436e-02f, -2.12879986e-01f, 3.51641744e-01f,
  4.61962551e-01f, 3.34848464e-01f, 4.24622238e-01f, 3.48108768e-01f, 3.72404248e-01f, 2.63646364e-01f, -1.61462799e-01f, -1.91511497e-01f, -1.33374706e-01f, 9.65197533e-02f,
  2.22864047e-01f, 9.41091925e-02f, -6.12029321e-02f, -1.40885532e-01f, -1.97233677e-01f, -2.24722400e-02f, -2.66820043e-01f, -2.68267214e-01f, 1.17805384e-01f, -3.29407692e-01f,
  4.61397320e-01f, -3.17776859e-01f, -1.43731087e-01f, -3.37422639e-02f, -1.98954374e-01f, -4.35110554e-02f, -1.81663930e-02f, -2.33795002e-01f, -1.01386108e-01f, -8.11728984e-02f,
  -2.86781698e-01f, -1.29526988e-01f, -6.06149249e-02f, -2.61257906e-02f, -1.40568838e-01f, -5.09080961e-02f, -1.08381681e-01f, -2.06716761e-01f, -3.49656716e-02f, 9.66680124e-02f,
  1.73004076e-01f, -2.26669252e-01f, -1.85694784e-01f, -8.55141208e-02f, -1.24409907e-01f, -1.40083954e-01f, -3.59512940e-02f, -2.72289574e-01f, -1.25638187e-01f, 1.91268586e-02f,
  4.21911553e-02f, 4.40756045e-02f, 1.65246129e-02f, -8.65056217e-02f, 1.50979742e-01f, 4.23088633e-02f, -8.42157230e-02f, 6.05525859e-02f, 2.69443374e-02f, -3.17881554e-02f,
  -1.72854587e-02f, 1.04323231e-01f, -9.34151281e-03f, 8.77390653e-02f, 9.73782688e-02f, -1.79312795e-01f, -1.81975756e-02f, 1.38742656e-01f, -3.39664668e-02f, 3.63779510e-03f,
  -8.74776170e-02f, -6.87678829e-02f, -2.56976066e-03f, -4.48086299e-02f, -9.84840915e-02f, -2.43924912e-02f, -3.36219743e-02f, 1.08636916e-01f, 5.09805903e-02f, 4.92686704e-02f,
  5.04637241e-01f, 1.82164818e-01f, 1.74968347e-01f, -1.52470455e-01f, -2.37837449e-01f, -3.60163189e-02f, -1.91474147e-02f, -1.48678571e-01f, -1.81992665e-01f, 3.70719619e-02f,
  -8.94059762e-02f, 1.04947723e-01f, 5.85352890e-02f, -4.23074365e-02f, 2.13243868e-02f, -4.70252782e-02f, 1.31669864e-01f, 1.17841959e-01f, 1.21981472e-01f, 4.10485081e-02f,
  2.34628841e-01f, 6.34209141e-02f, 1.80115089e-01f, 2.15331063e-01f, 9.72196460e-02f, 7.92867094e-02f, 1.53532729e-01f, 1.37147516e-01f, 2.55302489e-01f, 3.68308187e-01f,
  3.02988291e-02f, 1.01368856e+00f, 3.41432244e-01f, 2.14373916e-01f, 6.05803013e-01f, 2.51005918e-01f, 6.00585520e-01f, -3.23391818e-02f, -5.14288396e-02f, 3.87115538e-01f,
  4.10327792e-01f, -1.96235478e-02f, 1.04612924e-01f, -5.15073799e-02f, -2.27493033e-01f, 2.73118109e-01f, 3.25886011e-01f, -3.78636569e-01f, -8.40845227e-01f, -4.55391228e-01f,
  -7.30556482e-03f, -2.60023177e-01f, -6.38971210e-01f, -4.96997982e-01f, 3.60612035e-01f, -2.13059485e-01f, 2.72369772e-01f, 2.36188620e-01f, 2.62093991e-01f, 4.45027441e-01f,
  2.42717996e-01f, 5.22860587e-01f, -5.41283071e-01f, 1.22585826e-01f, 3.66706878e-01f, -3.42100203e-01f, -3.67841482e-01f, -3.17960046e-02f, 4.32478040e-02f, -2.24282086e-01f,
  3.52429748e-01f, 3.02300267e-02f, 4.20508087e-01f, 3.22242118e-02f, 8.72718841e-02f, -3.54127884e-01f, -5.03321998e-02f, -3.18860739e-01f, -2.61618733e-01f, -5.85032403e-02f,
  3.31180066e-01f, 3.35544437e-01f, 2.43608996e-01f, 1.82768106e-02f, 1.68440174e-02f, -2.36086324e-01f, 6.87478259e-02f, -2.50603974e-01f, -5.99986136e-01f, -2.10894257e-01f,
  -3.11841309e-01f, 6.65305108e-02f, 2.28948101e-01f, 1.53286427e-01f, -1.63948104e-01f, 1.63494591e-02f, 3.19419563e-01f, 1.56217486e-01f, 1.97493881e-02f, -3.01326346e-02f,
  -9.38507244e-02f, -7.59321377e-02f, -1.03764705e-01f, -7.84431212e-03f, -3.93085517e-02f, 4.11325768e-02f, -1.97937518e-01f, -1.18450031e-01f, 1.49977118e-01f, -1.94992751e-01f,
  8.79911035e-02f, -6.93348944e-02f, 3.57864946e-02f, -1.60879016e-01f, -1.63324833e-01f, 6.82874098e-02f, -2.39361688e-01f, -3.54254991e-01f, -2.03640699e-01f, -1.02338240e-01f,
  -1.83615178e-01f, -1.53968528e-01f, -2.65908897e-01f, -2.13624816e-02f, 3.64759296e-01f, -2.20000558e-02f, 1.28137216e-01f, 1.20687671e-01f, 4.00254518e-01f, -1.94590420e-01f,
  -1.55775353e-01f, -3.84739488e-01f, 2.30731025e-01f, -2.02882335e-01f, -3.31165075e-01f, -1.28667101e-01f, 7.38325119e-02f, 9.71765742e-02f, -1.97682530e-01f, -1.07042857e-01f,
  3.76873910e-02f, -5.31527936e-01f, -4.15432751e-01f, -1.19307719e-01f, -3.04204792e-01f, -9.61071312e-01f, -5.39768457e-01f, -5.65407574e-01f, -5.04932642e-01f, -5.27921200e-01f,
  9.65157330e-01f, 4.04830664e-01f, -1.10972822e+00f, 9.46647227e-01f, 1.42869234e-01f, -6.32448435e-01f, -4.59510237e-01f, -4.31104898e-02f, 5.92118144e-01f, 2.17775226e-01f,
  -3.62595136e-04f, -2.29548998e-02f, -1.35861695e-01f, -4.85728621e-01f, -9.20456052e-01f, -6.95249557e-01f, -7.01837540e-01f, -7.95552135e-01f, -8.24629545e-01f, -1.97099477e-01f,
  2.63936996e-01f, 5.57668567e-01f, 1.64898291e-01f, -1.25891596e-01f, 3.83437634e-01f, 8.00455436e-02f, -2.08384946e-01f, -1.71627826e-03f, -5.12109458e-01f, -4.40269150e-02f,
  -4.90082234e-01f, -3.97055037e-02f, -2.66377479e-01f, 3.46175469e-02f, 2.20751867e-01f, 6.48510605e-02f, -2.26866622e-02f, 1.27938613e-01f, 2.01422051e-01f, -5.43179028e-02f,
  5.41548058e-02f, -3.40563357e-02f, -3.36979628e-02f, 3.12622488e-02f, 3.11574172e-02f, -9.90433395e-02f, -1.91134214e-02f, -1.88136593e-01f, -7.74036944e-02f, 2.93312445e-02f,
  1.75273746e-01f, -1.88401595e-01f, -2.79957205e-01f, -1.43297136e-01f, -3.10993075e-01f, -1.43234670e-01f, -1.45127773e-01f, -2.08684772e-01f, -4.44199234e-01f, 2.22577974e-01f,
  1.99651960e-02f, 1.26222763e-02f, 9.29094106e-02f, 1.28934786e-01f, 2.05635741e-01f, -3.12188212e-02f, -3.71338315e-02f, -1.96168330e-02f, -1.82528887e-02f, 7.75985196e-02f,
  1.00176074e-02f, -6.16219342e-02f, -6.55923635e-02f, 4.66179708e-03f, -5.92955500e-02f, -7.65909394e-03f, -7.38858134e-02f, 6.14085160e-02f, -6.65599555e-02f, 1.33982331e-01f,
  4.11054492e-02f, -4.28999029e-02f, 1.54670507e-01f, -2.50659361e-02f, -5.14195077e-02f, -8.62066299e-02f, 1.00653179e-01f, 1.05836056e-02f, 4.69486378e-02f, -3.11015756e-03f,
  5.99590063e-01f, -3.25264871e-01f, 3.14361006e-01f, -7.95878991e-02f, 2.53682453e-02f, 1.23370431e-01f, 2.20429033e-01f, 1.17484063e-01f, 1.65476754e-01f, -2.46768463e-02f,
  -2.11679891e-01f, -3.86071429e-02f, 6.21378981e-02f, -2.07282789e-02f, -9.70014036e-02f, -1.19233914e-01f, 1.75038651e-01f, -3.90808061e-02f, -1.04067408e-01f, 2.40429610e-01f,
  1.85760006e-01f, 3.24048810e-02f, 3.36679444e-02f, 2.04635840e-02f, 1.06175967e-01f, -9.23536420e-02f, -1.51500881e-01f, 1.10535100e-02f, -2.79808223e-01f, 4.28165555e-01f,
  -8.83960068e-01f, -3.86002153e-01f, 3.91601503e-01f, -1.27444118e-01f, 3.18860829e-01f, 2.25736946e-01f, 3.86221886e-01f, -1.16933197e-01f, -2.32115179e-01f, -4.28006276e-02f,
  -2.30585888e-01f, -2.70550221e-01f, -2.94017494e-01f, -2.33123466e-01f, -1.38391778e-01f, 3.42714190e-01f, 2.89176583e-01f, 1.37812912e-01f, 1.94281116e-01f, 8.02967474e-02f,
  -9.70307663e-02f, -1.71291575e-01f, -3.51130664e-01f, -1.15645602e-01f, -1.31390601e-01f, 6.21640533e-02f, -3.04570682e-02f, -6.99052289e-02f, -1.80414040e-02f, -3.01669501e-02f,
  2.79905498e-01f, -4.97721761e-01f, 8.68530348e-02f, -2.80453712e-01f, -1.18917182e-01f, -2.61165142e-01f, -6.11343831e-02f, -1.31227076e-01f, -1.43398076e-01f, -3.44824120e-02f,
  -1.96443185e-01f, -9.00516286e-02f, -3.50484177e-02f, 1.13382913e-01f, 1.10513791e-01f, -3.85546982e-02f, -1.65000036e-01f, -1.07451156e-01f, -9.31197256e-02f, -1.10762954e-01f,
  -2.18303993e-01f, -1.22735677e-02f, 4.74414267e-02f, -6.67301714e-02f, -2.20005631e-01f, 6.87314803e-03f, -6.87068850e-02f, -7.53115639e-02f, 1.85384993e-02f, -3.07090674e-02f,
  -3.97521146e-02f, -6.51113987e-02f, -2.18738705e-01f, -2.80722473e-02f, -8.89503732e-02f, 3.58351469e-02f, 1.24824829e-01f, -6.54960573e-02f, -3.37337516e-02f, 8.85517569e-04f,
  7.51260668e-02f, 2.93144919e-02f, 2.54803151e-03f, 8.65147263e-03f, -1.24921389e-01f, -1.48535267e-01f, -1.16257770e-02f, -2.05152541e-01f, -2.00815633e-01f, -1.20271586e-01f,
  -1.41366348e-01f, 7.49746189e-02f, 1.23540750e-02f, 3.79616059e-02f, -1.80431064e-02f, -4.48208228e-02f, -5.14863841e-02f, -8.24198797e-02f, -7.84204081e-02f, -1.14233360e-01f,
  8.69377851e-02f, -1.98080540e-01f, 2.63734162e-01f, -1.13337457e-01f, 1.62362307e-02f, -1.35182276e-01f, -1.53589249e-01f, -1.97599512e-02f, 1.42649606e-01f, 1.17749482e-01f,
  -8.78640413e-02f, 1.26446649e-01f, 6.93942830e-02f, 3.40345092e-02f, 2.46898666e-01f, 1.41438946e-01f, -1.03817999e-01f, 6.68290118e-03f, 3.06484364e-02f, -1.73246693e-02f,
  -1.97772291e-02f, 2.15320766e-01f, 2.92971373e-01f, 2.50609726e-01f, 6.23297319e-03f, 3.00393760e-01f, 2.82837033e-01f, 1.01848878e-01f, 2.48199716e-01f, 3.66216481e-01f,
  9.91206169e-01f, -1.06480920e+00f, -5.87443352e-01f, 2.64861137e-01f, -6.89683333e-02f, -3.61452043e-01f, -1.03140330e+00f, -2.92927504e-01f, 3.48719001e-01f, -4.79249567e-01f,
  1.35926589e-01f, 1.02714467e+00f, 7.99597144e-01f, 5.19043982e-01f, 2.68134952e-01f, -7.82958031e-01f, -4.89639789e-01f, 4.12269473e-01f, 7.02487588e-01f, 1.82333648e-01f,
  -2.29602400e-02f, 1.73784792e-01f, 3.77003253e-01f, 2.60706127e-01f, -4.32578772e-01f, 2.85861254e-01f, -5.99633932e-01f, -1.82316244e-01f, -3.82752895e-01f, -5.88522017e-01f,
  -1.25856951e-01f, -5.28026640e-01f, 2.27427900e-01f, 5.22287011e-01f, 1.10521592e-01f, -1.67583480e-01f, -4.45359081e-01f, -8.35921392e-02f, -6.81449249e-02f, -2.39617959e-01f,
  3.02705616e-01f, 2.00064550e-03f, 1.64719805e-01f, -6.51524141e-02f, -2.05043599e-01f, -1.64717838e-01f, -1.62718311e-01f, -4.47672866e-02f, -1.89265698e-01f, -2.12246597e-01f,
  -7.35891052e-03f, 2.38071591e-01f, 1.29923671e-02f, -5.12531340e-01f, -3.66871148e-01f, 4.10239786e-01f, -5.14511704e-01f, -1.79538921e-01f, -1.12085663e-01f, -7.34268904e-01f,
  1.29357845e-01f, 1.26610443e-01f, 1.77264493e-02f, -9.39881727e-02f, -6.36872128e-02f, 5.45816347e-02f, -1.22900248e-01f, -3.98550089e-03f, 1.42168319e-02f, -9.66871679e-02f,
  -2.64216377e-03f, -8.66440311e-02f, 5.33088855e-02f, -1.11256197e-01f, 4.33699880e-03f, -8.20954219e-02f, -1.41998664e-01f, -1.08559348e-01f, 9.21300799e-02f, 3.33234668e-03f,
  2.11386159e-01f, 1.82057098e-02f, -5.08022681e-02f, 6.92297518e-02f, -5.08671887e-02f, 1.51381060e-01f, 4.05894332e-02f, -5.74068427e-02f, 1.22872926e-01f, -6.94674328e-02f,
  2.78777093e-01f, 3.37590963e-01f, -1.62630022e-01f, 1.69519663e-01f, -2.41506356e-03f, 3.19505520e-02f, -1.16939723e-01f, 1.37705728e-01f, 3.14681679e-02f, -1.24099597e-01f,
  -1.25745237e-01f, -9.38130841e-02f, -2.92966992e-01f, -1.99434847e-01f, 9.31476504e-02f, -1.11526415e-01f, -5.31693101e-02f, 3.65226895e-01f, 1.30510718e-01f, -2.52000779e-01f,
  -2.63602763e-01f, -1.09606482e-01f, 3.84797633e-01f, -1.00057721e-02f, 4.28804718e-02f, 4.17375505e-01f, -3.84496003e-01f, -1.10605218e-01f, 2.35519409e-01f, -8.69976163e-01f,
  -1.07786322e+00f, -4.05318230e-01f, -2.42804483e-01f, -4.85004812e-01f, 4.90131468e-01f, 1.79740582e-02f, -5.47368646e-01f, -3.64458293e-01f, -1.91180691e-01f, -1.88517958e-01f,
  6.23198271e-01f, 6.32304788e-01f, -3.96870881e-01f, -7.88524151e-02f, -6.47036731e-01f, -6.31459057e-01f, -4.88439381e-01f, -3.79405469e-01f, 1.89104930e-01f, 7.39332914e-01f,
  7.30195642e-01f, -4.82991245e-03f, -1.87891856e-01f, 2.53086668e-02f, 1.46476641e-01f, 2.96107650e-01f, -8.39006305e-02f, 1.03564681e-02f, 6.71870187e-02f, -1.12479724e-01f,
  -2.26482883e-01f, -4.80027676e-01f, 2.68583834e-01f, 3.52083743e-01f, 3.10278952e-01f, -4.70829755e-01f, -2.62766182e-01f, -2.50322759e-01f, 2.11192384e-01f, -1.73563600e-01f,
  1.85144633e-01f, 1.55113041e-01f, 1.66278601e-01f, 7.99605474e-02f, -1.95972435e-02f, -3.82911563e-02f, -2.51443654e-01f, -3.22303891e-01f, -6.22924030e-01f, 9.37552601e-02f,
  5.43479264e-01f, 5.31192243e-01f, -3.57532382e-01f, -4.75140437e-02f, -4.29492444e-01f, 1.64226927e-02f, 1.82967827e-01f, 1.92967772e-01f, -6.22091055e-01f, -5.70297122e-01f,
  2.36796707e-01f, -1.66950841e-02f, -4.05212864e-02f, -2.13336214e-01f, 2.52104867e-02f, 7.15594292e-02f, -1.45026997e-01f, -3.18331271e-02f, 1.60513490e-01f, -1.42852604e-01f,
  6.67721778e-02f, 1.46516129e-01f, 1.16070963e-01f, 3.99084849e-04f, 9.27352682e-02f, -2.10364163e-02f, 9.83597040e-02f, -1.22738019e-01f, 7.18222857e-02f, -2.60373503e-02f,
  -1.41727626e-01f, -6.71161665e-03f, 8.37934017e-02f, 8.57122764e-02f, 2.81719677e-02f, -1.37408137e-01f, 1.13410696e-01f, 1.03446171e-01f, -2.48529866e-01f, -1.74071550e-01f,
  -3.51774514e-01f, 2.37479225e-01f, -3.34974319e-01f, -2.16404498e-01f, 9.38654691e-02f, 2.63015807e-01f, 2.80197579e-02f, -7.34439418e-02f, -1.03801534e-01f, -4.98274863e-02f,
  -1.13896541e-02f, -1.52615756e-01f, -1.45577744e-01f, 3.21202241e-02f, -4.31074202e-02f, -5.24439709e-03f, -2.35798195e-01f, -9.14041698e-03f, -1.53003305e-01f, 9.42479223e-02f,
  -4.26392913e-01f, -2.86709011e-01f, -4.28854018e-01f, -4.24691617e-01f, -1.73935726e-01f, -2.06983477e-01f, -2.17444360e-01f, -1.25894219e-01f, -6.62016213e-01f, -6.77134454e-01f,
  -6.42499566e-01f, 4.12512347e-02f, 7.04721827e-03f, -4.60862428e-01f, 1.54597670e-01f, 4.64300543e-01f, 3.79455745e-01f, 3.82044017e-01f, 1.62912160e-01f, -1.42763918e-02f,
  1.94673806e-01f, -2.37084985e-01f, -5.61763883e-01f, -4.76006866e-01f, -5.95366716e-01f, -5.78967094e-01f, -6.40267193e-01f, -7.05479383e-01f, -5.99271715e-01f, 1.07083626e-01f,
  -2.18388662e-01f, -4.46467459e-01f, -3.85903984e-01f, -1.17546640e-01f, 5.01998141e-02f, -3.56438309e-01f, -2.18799248e-01f, -2.46355593e-01f, 1.25495922e-02f, -5.49715877e-01f,
  -4.78915632e-01f, 5.30051708e-01f, -9.62273777e-02f, -1.73334405e-01f, -1.07584670e-01f, 7.96678588e-02f, 1.67157069e-01f, 2.40292326e-02f, 5.35159633e-02f, 1.12574790e-02f,
  1.75698265e-01f, 2.59958029e-01f, 1.39045313e-01f, 4.93407771e-02f, 1.04870893e-01f, 7.37291947e-02f, -1.35756180e-01f, -2.27495834e-01f, -2.14342371e-01f, 4.43713039e-01f,
  1.53826520e-01f, -2.76519544e-02f, 4.47317213e-02f, 2.92080522e-01f, 3.35728884e-01f, -1.55743703e-01f, 2.68238962e-01f, 2.84512877e-01f, 5.99723123e-02f, -3.16578656e-01f,
  -1.81716561e-01f, -1.99069660e-02f, 5.10898419e-02f, 4.68315259e-02f, -7.00773373e-02f, -8.79968181e-02f, 3.46522103e-03f, -4.43451889e-02f, 1.53590828e-01f, -2.02956066e-01f,
  1.25861615e-01f, 1.16940536e-01f, 1.30403295e-01f, 3.73125970e-02f, -1.26037188e-02f, -4.17806208e-02f, 9.25088674e-03f, -3.87145975e-03f, 7.50712380e-02f, -1.31799921e-01f,
  -1.21969536e-01f, -1.21841663e-02f, -1.43604070e-01f, -9.32141095e-02f, 4.88513112e-02f, -1.62002429e-01f, 1.05436757e-01f, 1.86962903e-01f, -8.90073404e-02f, 6.06310852e-02f,
  -7.19425082e-01f, 1.28912941e-01f, -1.86323956e-01f, -5.62905483e-02f, 6.97496906e-02f, 4.73294258e-02f, 9.28949043e-02f, 3.26642469e-02f, -7.72160143e-02f, 1.66737232e-02f,
  4.61017221e-01f, 1.28330842e-01f, 9.86656621e-02f, 7.17929825e-02f, 2.54172981e-02f, 1.70859590e-01f, -1.14097372e-01f, -1.73632339e-01f, 6.84458911e-02f, 3.42232525e-01f,
  -3.99006940e-02f, -1.73925191e-01f, -3.90448987e-01f, -2.85875559e-01f, 1.53694436e-01f, -1.71254292e-01f, -2.79661804e-01f, -4.76095341e-02f, -3.24852705e-01f, -4.28835422e-01f,
  -7.96849608e-01f, -2.55875230e-01f, -6.70954362e-02f, -8.59257936e-01f, -7.71314859e-01f, -3.57220083e-01f, -4.53464925e-01f, -2.92414844e-01f, -1.13653898e-01f, -1.61419660e-02f,
  4.37045768e-02f, -1.61062226e-01f, -5.53210964e-03f, -4.37116921e-02f, -3.34936753e-02f, 1.84261516e-01f, 9.68360975e-02f, -1.49773300e-01f, -5.33606410e-01f, -6.74164832e-01f,
  -6.70583129e-01f, -6.58464789e-01f, -4.90903050e-01f, -2.84793198e-01f, -3.79648685e-01f, -3.27082872e-01f, 4.76704352e-02f, -2.32928246e-01f, 2.82241534e-02f, 2.07738951e-02f,
  -5.16615748e-01f, -3.46438527e-01f, -1.02051683e-01f, 1.72675550e-01f, -7.14775026e-02f, 5.35735078e-02f, -1.61864445e-01f, 5.94022833e-02f, 1.16334977e-02f, -1.83162820e-02f,
  -8.38691741e-02f, -1.05284579e-01f, -1.67716488e-01f, -1.30788296e-01f, -4.25068885e-01f, 2.08959877e-02f, 7.42002428e-02f, -1.19732305e-01f, 5.68987317e-02f, 2.40200505e-01f,
  1.88398927e-01f, -6.31041778e-03f, -3.11575569e-02f, 1.09527193e-01f, 2.48168662e-01f, 1.28799990e-01f, 3.21347043e-02f, 7.80708864e-02f, 2.49356374e-01f, -2.08711214e-02f,
  3.20787996e-01f, 7.34726712e-02f, -1.00238763e-01f, -1.36861637e-01f, 7.34911114e-02f, 1.02526143e-01f, -1.59902841e-01f, 4.27664220e-02f, -1.02941856e-01f, -9.34788883e-02f,
  -4.47110757e-02f, 1.72241256e-01f, -9.49000120e-02f, -6.68548793e-02f, -4.85298410e-03f, -1.23124018e-01f, 1.03869988e-03f, 1.71231236e-02f, 1.58557922e-01f, 9.93721262e-02f,
  5.55329490e-03f, -4.53976877e-02f, 8.33097938e-03f, -5.69868945e-02f, 1.18726112e-01f, -9.67442468e-02f, 3.38612311e-02f, 1.13779001e-01f, -8.03575218e-02f, 5.00380471e-02f,
  -8.08692694e-01f, 5.24562657e-01f, 1.70950592e-02f, -2.54849177e-02f, 7.10138530e-02f, 2.66033888e-01f, 7.21470267e-02f, 1.06953710e-01f, -7.49763623e-02f, -8.10474232e-02f,
  -2.39071921e-02f, 2.94004455e-02f, -8.01143572e-02f, 2.57626697e-02f, -2.35794365e-01f, 7.89496824e-02f, 1.82132289e-01f, -1.47468433e-01f, 1.57092109e-01f, 1.59848571e-01f,
  2.12701112e-01f, 2.20328182e-01f, 9.52836275e-02f, 1.99185491e-01f, 2.08915263e-01f, 1.26781523e-01f, 6.06284477e-03f, -2.44933236e-02f, 2.97023445e-01f, 1.36862714e-02f,
  5.85563779e-01f, -4.48609352e-01f, -3.31243694e-01f, 5.03993511e-01f, 1.94996059e-01f, 1.91709444e-01f, 3.58398110e-01f, 4.76105213e-01f, 4.71191615e-01f, 1.77569509e-01f,
  -7.20377982e-01f, -8.32332909e-01f, -6.66457891e-01f, -4.61976230e-01f, -4.50701594e-01f, 5.94077826e-01f, 5.76930404e-01f, -1.76298007e-01f, -3.12996328e-01f, -1.50051460e-01f,
  2.01753423e-01f, 4.97695565e-01f, 2.03851953e-01f, -5.54712228e-02f, 1.66842535e-01f, 1.06589690e-01f, 3.75047684e-01f, -7.15908632e-02f, -4.14280891e-01f, 2.46713653e-01f,
  -5.78474700e-01f, -4.06689137e-01f, -1.23330317e-01f, -2.74391383e-01f, -2.04771563e-01f, -6.88522011e-02f, 7.36335218e-02f, -9.57627594e-02f, -2.71595299e-01f, -2.55620759e-02f,
  -1.95912674e-01f, -2.91306406e-01f, -2.45501935e-01f, -1.76068410e-01f, 1.37821034e-01f, -1.22508667e-01f, -2.90814769e-02f, -1.58352375e-01f, -1.87831149e-01f, -3.61988902e-01f,
  -3.78602237e-01f, -2.97919601e-01f, -2.91317195e-01f, -1.70771942e-01f, -2.02897608e-01f, -2.78786063e-01f, -2.18687773e-01f, -2.28523314e-01f, -2.90489197e-01f, 2.90399194e-01f,
  4.15972248e-02f, 4.43326756e-02f, 6.51010573e-02f, 1.33174464e-01f, 3.01189460e-02f, -4.76776510e-02f, -3.25574316e-02f, -2.79534962e-02f, -6.13157414e-02f, -8.26467481e-03f,
  -1.27506092e-01f, -3.78522463e-02f, -9.08052176e-02f, 3.17294593e-03f, -1.35851949e-01f, 3.99069265e-02f, -7.47166425e-02f, 7.31528997e-02f, -1.20137319e-01f, 7.63937086e-02f,
  -5.68060167e-02f, 1.20932914e-01f, -4.92466837e-02f, 3.28426547e-02f, -1.10033117e-01f, -1.78568840e-01f, 1.33140907e-01f, -1.37875780e-01f, 3.18628363e-03f, -2.67006736e-02f,
  4.17404294e-01f, -3.24104339e-01f, 2.14225128e-01f, 1.34340413e-02f, 1.09654650e-01f, -2.53242075e-01f, -1.14549898e-01f, -5.05528972e-02f, -1.91412121e-01f, -2.35749453e-01f,
  -3.38933110e-01f, -2.43655264e-01f, -6.87926039e-02f, -7.31948391e-03f, 2.62737900e-01f, 1.86698139e-03f, -1.25280932e-01f, 7.04332367e-02f, 5.71371354e-02f, 5.43015152e-02f,
  2.60066569e-01f, 3.11065733e-01f, 3.55571777e-01f, 2.74179101e-01f, 2.12148592e-01f, -1.20875752e-02f, 1.43981054e-01f, 2.31478512e-01f, 2.59952322e-02f, 7.59031832e-01f,
  -7.17426956e-01f, -9.11591053e-02f, 2.74231642e-01f, 1.83585808e-01f, 1.68150663e-01f, -7.48025179e-01f, -1.31249487e+00f, -8.15946519e-01f, 1.05744116e-01f, -2.88685672e-02f,
  2.29839697e-01f, 4.19954032e-01f, 5.35043120e-01f, 9.00529623e-02f, -6.60331488e-01f, -2.17429832e-01f, 1.08779117e-01f, -9.84929875e-02f, -5.66503167e-01f, -5.03436744e-01f,
  -3.87043133e-02f, -2.07212642e-02f, -1.18593857e-01f, -1.83920369e-01f, 6.37908816e-01f, 4.51178193e-01f, 6.18370593e-01f, 3.95885885e-01f, 3.18813957e-02f, 9.12583768e-01f,
  6.82632089e-01f, -1.48506865e-01f, -3.26659918e-01f, 2.69343471e-03f, 4.17123616e-01f, -1.74641579e-01f, -1.60013996e-02f, 1.51948661e-01f, -2.18209907e-01f, -2.08988488e-02f,
  1.88309297e-01f, -3.81721817e-02f, 1.84450205e-02f, 1.06092639e-01f, -1.44324809e-01f, -4.29942816e-01f, 5.01967147e-02f, -3.83297890e-01f, -2.11480200e-01f, 1.61714390e-01f,
  1.35325611e-01f, -3.58445384e-02f, -6.50030896e-02f, -1.84423700e-01f, -2.02724710e-01f, 1.07444748e-01f, -3.70890759e-02f, -1.38999671e-01f, -1.73932791e-01f, 2.97490746e-01f,
  1.14514664e-01f, 1.69938989e-02f, 1.63440797e-02f, 9.21796411e-02f, 7.84011111e-02f, 3.06988299e-01f, 2.43323311e-01f, 7.12061226e-02f, 6.24124259e-02f, 1.45154679e-02f,
  -8.67411345e-02f, -5.56192435e-02f, 8.70167911e-02f, -6.18749522e-02f, 6.16165511e-02f, 2.48622168e-02f, 6.42070323e-02f, -5.43424860e-02f, -1.94285557e-01f, -1.01625044e-02f,
  -5.08347340e-02f, -1.55165613e-01f, 1.32567942e-01f, -8.93032625e-02f, 8.22275653e-02f, -9.67404395e-02f, -8.16626698e-02f, 3.40274461e-02f, 2.28688270e-01f, -4.43790294e-02f,
  3.42971832e-01f, -4.56385553e-01f, 3.03772032e-01f, 1.20939024e-01f, -6.77354410e-02f, 9.10050943e-02f, 2.94124067e-01f, -2.77983904e-01f, -4.48771976e-02f, -2.84015357e-01f,
  -2.93225557e-01f, -1.46039322e-01f, 3.75249982e-01f, -1.04216494e-01f, -1.79008529e-01f, -1.08730219e-01f, 4.32869699e-03f, -1.04427204e-01f, -3.31129789e-01f, -1.09511286e-01f,
  -1.14892103e-01f, -5.52272379e-01f, -4.63512540e-01f, -2.59891957e-01f, 2.21036613e-01f, -1.15640223e-01f, 7.65999481e-02f, -5.19945174e-02f, -4.12808746e-01f, -4.64544803e-01f,
  5.61443605e-02f, -1.33155629e-01f, 3.43125649e-02f, 2.04665035e-01f, -1.07620299e-01f, -1.01951599e-01f, -8.47958922e-02f, 1.78116634e-01f, 3.48976612e-01f, 1.24710321e-01f,
  -1.20592132e-01f, 2.89627284e-01f, 2.22985655e-01f, 1.09589100e-01f, 1.96274519e-01f, 2.74211287e-01f, 3.50511789e-01f, 2.35566735e-01f, 2.92507559e-02f, 8.63660872e-02f,
  2.95610815e-01f, 7.75229782e-02f, 5.66642471e-02f, 2.64922291e-01f, 2.39537075e-01f, 3.21603626e-01f, 1.26764208e-01f, 6.25055134e-02f, 1.99122995e-01f, 6.35412514e-01f,
  1.50511071e-01f, -8.29745457e-02f, 2.54147942e-03f, -8.33702236e-02f, -1.73918992e-01f, -1.09148592e-01f, 3.32196355e-02f, -4.23850864e-02f, -7.30810985e-02f, 9.99332219e-02f,
  7.86295310e-02f, -2.65861135e-02f, -1.19410187e-01f, -2.19669379e-02f, -8.52811933e-02f, -2.66705966e-03f, 6.69944510e-02f, 2.28615358e-01f, 1.96170956e-01f, 1.06693685e-01f,
  -4.08735970e-04f, -5.66429757e-02f, 3.02814301e-02f, -8.91561881e-02f, 1.64048865e-01f, -8.11453760e-02f, -1.20271899e-01f, -5.34087680e-02f, -4.23213206e-02f, 1.83501020e-01f,
  1.28848031e-01f, 2.02153996e-02f, 5.69399446e-02f, 2.18031421e-01f, 1.41682118e-01f, 1.23625338e-01f, 1.41689315e-01f, 6.79675266e-02f, 3.53779793e-02f, 4.42566387e-02f,
  -8.64152517e-03f, 1.42527968e-01f, 2.79786400e-02f, 8.76267180e-02f, 4.65545617e-02f, 5.79998605e-02f, -5.95789626e-02f, -7.62126520e-02f, -5.20816706e-02f, 1.10423580e-01f,
  1.15850873e-01f, 1.18261039e-01f, -1.25038996e-01f, 1.48130432e-01f, 3.84531990e-02f, 1.34440130e-02f, 1.74106598e-01f, -8.77551064e-02f, -6.42156228e-02f, 4.15373147e-02f,
  -3.42100799e-01f, -2.57397264e-01f, 3.01904082e-01f, 1.23597540e-01f, -8.73235613e-02f, -8.92766789e-02f, -8.24968051e-03f, -6.18339106e-02f, -1.10544495e-01f, 1.44175757e-02f,
  -8.57015476e-02f, -7.13866651e-02f, -1.85106799e-01f, 1.31074162e-02f, -1.38721213e-01f, -4.94401492e-02f, 4.41871323e-02f, 1.73151568e-01f, 1.17845172e-02f, -3.50243859e-02f,
  3.35566187e-03f, -1.21972002e-02f, -9.02772620e-02f, -7.34968930e-02f, 2.02339031e-02f, -1.43289015e-01f, -2.47671157e-01f, -2.61624325e-02f, -1.05754845e-01f, -1.06015950e-01f,
  3.09287786e-01f, -6.38360739e-01f, 3.07638049e-01f, 2.26796448e-01f, 2.69607693e-01f, 1.52125373e-01f, -2.05601379e-01f, -1.14776678e-02f, -1.23471711e-02f, -1.52981922e-01f,
  -7.78726637e-02f, 3.08946788e-01f, 2.49283612e-01f, 2.18990684e-01f, 9.45865810e-02f, -1.54033452e-01f, 1.65137723e-01f, 4.78582144e-01f, 4.03571308e-01f, 1.31435748e-02f,
  -1.33717194e-01f, -7.93370977e-02f, -5.14896710e-05f, -5.25373444e-02f, -1.81635261e-01f, 1.07900530e-01f, -1.36244670e-01f, -2.47728854e-01f, -3.13430458e-01f, -2.63193905e-01f,
  -2.32502222e-01f, -2.67500520e-01f, 1.90151811e-01f, -8.87339935e-02f, -4.09416370e-02f, -6.74479902e-02f, 1.57718305e-02f, -1.22670166e-01f, -1.23548038e-01f, -9.97205898e-02f,
  -1.82607155e-02f, -1.09036975e-02f, 4.20799479e-02f, -1.57071844e-01f, -1.75173461e-01f, -2.92028021e-02f, -1.22351043e-01f, -1.25510454e-01f, 2.94737406e-02f, -7.46418908e-02f,
  -2.22657889e-01f, -6.12607896e-02f, 6.53581172e-02f, 7.14469180e-02f, 8.23834985e-02f, 1.70707464e-01f, -5.72881959e-02f, -6.85899630e-02f, 1.10261356e-02f, -6.76551759e-02f,
  -1.82426274e-02f, -1.97054967e-02f, 1.37117043e-01f, 8.30346569e-02f, 3.87900881e-02f, 8.27773958e-02f, 1.73732787e-01f, 3.07954270e-02f, 1.69952944e-01f, -9.57692340e-02f,
  -2.07164455e-02f, 2.30123803e-01f, 9.27953944e-02f, -6.68054894e-02f, 1.47828683e-01f, 1.03698615e-02f, -5.27943559e-02f, -1.93263844e-01f, 1.12085134e-01f, -2.73424555e-02f,
  5.30888699e-02f, -1.11807793e-01f, -1.33781970e-01f, -9.20427814e-02f, -1.34918675e-01f, -3.35059427e-02f, 1.94725599e-02f, -3.25254612e-02f, -1.45291522e-01f, -2.51710445e-01f,
  -3.13687921e-01f, 3.88496339e-01f, 3.47473100e-02f, 4.13208120e-02f, 1.34703880e-02f, -1.07360907e-01f, 2.24746719e-01f, 1.80127304e-02f, -1.22204319e-01f, 2.64828857e-02f,
  -9.13566798e-02f, -5.15116602e-02f, -5.02478592e-02f, -1.39170840e-01f, 5.14730103e-02f, 1.83575880e-02f, -8.05670545e-02f, 4.88102175e-02f, 1.97182409e-02f, -1.21689245e-01f,
  -7.28963614e-02f, 1.34587988e-01f, 1.86402872e-01f, 3.09650362e-01f, 3.27113345e-02f, 2.68123806e-01f, 8.14713314e-02f, 7.61507377e-02f, 2.51902074e-01f, -5.25692068e-02f,
  8.22484434e-01f, 1.00618333e-01f, 2.74749398e-01f, 1.91170514e-01f, 2.66238183e-01f, 1.29123375e-01f, 3.20909023e-02f, 4.02508229e-02f, -1.80909783e-02f, 8.96741673e-02f,
  1.16448209e-01f, -1.53230742e-01f, -4.95480672e-02f, -1.10704571e-01f, -1.29582882e-01f, -1.91213265e-01f, -1.30831406e-01f, 2.26602089e-02f, 4.32062671e-02f, -6.54836418e-03f,
  -9.35109779e-02f, 2.08101600e-01f, 3.22599590e-01f, 1.27683833e-01f, 2.57618036e-02f, -8.91082063e-02f, 1.78369686e-01f, 2.04224199e-01f, 5.06592542e-02f, -2.49423623e-01f,
  -3.08171147e-03f, 3.81547004e-01f, -2.03286633e-01f, 2.56992467e-02f, 2.76353687e-01f, 1.57921284e-01f, 1.83139369e-01f, 1.36200145e-01f, 3.25649939e-02f, -5.80338612e-02f,
  2.39390023e-02f, 2.42160931e-01f, 1.44496888e-01f, 2.25349262e-01f, 1.73914865e-01f, 7.90698007e-02f, 2.24756733e-01f, 7.52737327e-03f, -1.62812024e-01f, -3.40128108e-03f,
  5.68960197e-02f, 1.72348976e-01f, 8.40578005e-02f, -7.99023807e-02f, 1.20266378e-02f, 1.69713199e-01f, 7.61022270e-02f, -5.60141131e-02f, 1.31851643e-01f, -2.92653702e-02f,
  1.40790194e-01f, 2.90780902e-01f, 2.16636077e-01f, 8.18425789e-02f, -5.26026338e-02f, 7.06044734e-02f, 9.71171632e-02f, -7.55712539e-02f, 1.24764979e-01f, 3.33613276e-01f,
  -9.80826318e-02f, -2.26970688e-02f, 1.76524475e-01f, 1.20874688e-01f, 2.80521303e-01f, 4.57646549e-01f, 1.05216578e-01f, 1.56606689e-01f, 3.64404023e-01f, 1.55795529e-01f,
  6.38482571e-02f, 9.09394473e-02f, 4.16065067e-01f, 3.97169553e-02f, 2.51449482e-03f, 2.22976297e-01f, 1.97572440e-01f, 1.07363418e-01f, 3.95095706e-01f, 3.76574963e-01f,
  -4.13602479e-02f, 2.80911475e-01f, -3.31751913e-01f, -1.38970703e-01f, 1.81161121e-01f, 1.36134222e-01f, 2.10168082e-02f, -8.84682685e-02f, -1.75876915e-01f, -2.47715726e-01f,
  -1.58204496e-01f, 1.01674281e-01f, 1.46543056e-01f, 7.71301463e-02f, 1.05779849e-01f, 3.31517719e-02f, 1.68165773e-01f, -2.55331434e-02f, -2.34587178e-01f, -1.76430389e-01f,
  -3.40843610e-02f, -1.22765176e-01f, -1.65232643e-01f, -1.19299874e-01f, -1.68607384e-01f, -3.25687081e-02f, -7.22307116e-02f, -6.27573654e-02f, -4.45248820e-02f, 3.88200791e-03f,
  4.05136943e-01f, -3.92814636e-01f, 3.93153057e-02f, 2.06740275e-01f, -6.53648376e-02f, -2.39106640e-01f, -1.06231666e+00f, -7.61455968e-02f, 2.76077539e-01f, -6.16954207e-01f,
  -4.29915696e-01f, 5.79236686e-01f, 6.46289885e-01f, 4.57438864e-02f, -2.79302895e-01f, -8.79476786e-01f, -7.88198650e-01f, -1.76912978e-01f, -6.09778278e-02f, -5.66317260e-01f,
  -5.33746839e-01f, -2.42346421e-01f, -1.65784627e-01f, 3.28021944e-02f, 3.28346081e-02f, 3.40432614e-01f, -7.35082552e-02f, -2.16536507e-01f, -3.56958747e-01f, -1.95351228e-01f,
  5.97085916e-02f, 3.30492437e-01f, -8.59832466e-02f, -1.53233498e-01f, -1.97285444e-01f, -2.27134936e-02f, -1.39704496e-01f, -9.78089124e-02f, -2.03262880e-01f, -1.50163069e-01f,
  -1.68015689e-01f, -9.06418252e-04f, 1.25642285e-01f, 1.30526274e-01f, -7.43433684e-02f, -2.42176652e-02f, -3.20186943e-01f, -1.11155540e-01f, -7.25651160e-02f, -1.60395727e-01f,
  -3.70309800e-01f, -1.38135388e-01f, 3.62746835e-01f, 3.82547453e-02f, -3.36281583e-02f, -8.27938132e-03f, 2.35798117e-02f, 2.13556699e-02f, 1.17885776e-01f, 1.76206976e-03f,
  -2.41870552e-01f, 6.21425770e-02f, -2.98572749e-01f, -6.19945349e-03f, -9.98613760e-02f, 2.86721904e-02f, 2.46420987e-02f, -1.10571437e-01f, 1.08112097e-02f, 8.53896216e-02f,
  3.59939411e-02f, -6.50684312e-02f, 6.11626059e-02f, 4.13641743e-02f, 8.31283927e-02f, 2.33563073e-02f, -6.63018897e-02f, -6.16928823e-02f, -7.09996074e-02f, -1.26963988e-01f,
  6.46972563e-03f, 9.38204899e-02f, 1.58581525e-01f, 8.57196301e-02f, -1.38489723e-01f, -4.28364892e-03f, 1.99446976e-01f, 9.88262445e-02f, 1.10574938e-01f, -2.93735657e-02f,
  5.42509496e-01f, -2.93312013e-01f, 2.08118141e-01f, -7.16997357e-03f, -9.20621902e-02f, -5.36322221e-02f, 9.77002922e-03f, -1.45380735e-01f, 6.90777525e-02f, -4.32631187e-02f,
  -1.09869041e-01f, -2.78345793e-02f, 2.54928529e-01f, -2.12748479e-02f, -1.99609566e-02f, -6.07888028e-02f, -5.26526153e-01f, -3.71149741e-02f, 8.56993869e-02f, -2.62191631e-02f,
  -3.49819124e-01f, -4.29803431e-02f, 8.02807584e-02f, 2.66788095e-01f, 1.56816393e-01f, 2.91669786e-01f, 2.46335760e-01f, 8.06255564e-02f, 1.81941673e-01f, -7.13795274e-02f,
  -6.46216050e-02f, 4.28589672e-01f, -1.01774395e-01f, 1.86398089e-01f, -8.62769559e-02f, -3.04864883e-01f, -7.28920251e-02f, 1.99148953e-01f, 1.86400622e-01f, 3.72447848e-01f,
  2.25967705e-01f, 6.26638457e-02f, 1.54403418e-01f, 8.85671657e-03f, -1.44301802e-01f, 2.30961859e-01f, 3.17570195e-02f, -3.72235239e-01f, -5.25742590e-01f, -3.28530997e-01f,
  -2.29804456e-01f, -4.09948044e-02f, -2.03140974e-01f, 3.19827683e-02f, 2.49978781e-01f, 3.78663093e-03f, 3.70458841e-01f, 6.00246191e-02f, -1.51540950e-01f, 1.89201221e-01f,
  1.98573880e-02f, -2.02749908e-01f, -1.94319531e-01f, -2.65301727e-02f, -5.92337176e-02f, 3.05094216e-02f, -1.21684223e-01f, 1.39939979e-01f, 1.87515199e-01f, 1.00984752e-01f,
  -7.40024587e-03f, 2.78886296e-02f, -6.59410283e-02f, 7.81079233e-02f, 1.23301655e-01f, 2.60340190e-03f, 3.66460085e-02f, -7.30759278e-02f, 7.50725577e-03f, -1.92369090e-03f,
  -2.73165070e-02f, -2.23931283e-01f, -1.30828977e-01f, -8.72783437e-02f, -2.03648701e-01f, -1.11795142e-01f, -6.46227524e-02f, -9.09415707e-02f, -1.27244651e-01f, 2.59351730e-01f,
  -5.81661314e-02f, 1.51643649e-01f, -1.54632747e-01f, -9.30486992e-02f, 2.83107068e-03f, 1.16660483e-01f, 7.91928694e-02f, 1.04440764e-01f, -2.40936540e-02f, 1.19701043e-01f,
  2.10364580e-01f, -8.84206221e-03f, 6.40411302e-02f, 9.56683755e-02f, 1.40244532e-02f, 2.08552964e-02f, -9.74486321e-02f, 4.42239270e-02f, -4.09027822e-02f, 3.85878123e-02f,
  -1.18427403e-01f, 3.33386697e-02f, 1.73718348e-01f, -6.71468750e-02f, -1.53620597e-02f, -2.39255931e-02f, -1.01136863e-01f, -1.04714841e-01f, 2.79320311e-03f, -2.07135398e-02f,
  2.90052831e-01f, -5.90615749e-01f, 6.78906366e-02f, -1.68414861e-02f, -3.82310934e-02f, 1.18135832e-01f, -6.49247393e-02f, -8.78843591e-02f, 1.30808264e-01f, 7.11517036e-02f,
  -8.29418376e-02f, 7.69314691e-02f, 1.52648976e-02f, 6.20157197e-02f, -7.20552951e-02f, -1.29633974e-02f, 2.80570351e-02f, -9.12613992e-04f, 8.28373134e-02f, 1.12605616e-01f,
  2.33737752e-01f, 9.37465578e-02f, 3.10899317e-02f, 1.33541748e-01f, -2.96333712e-02f, -1.45906702e-01f, 1.68505367e-02f, 4.34254184e-02f, -7.49723166e-02f, 3.32603782e-01f,
  5.96031904e-01f, 5.12074828e-01f, 7.35524148e-02f, 2.73057789e-01f, 5.09148657e-01f, 6.98468447e-01f, 7.27511227e-01f, 4.57029372e-01f, 2.62308687e-01f, 2.21429408e-01f,
  3.77940834e-01f, 9.83514488e-02f, 7.84536377e-02f, -4.39229198e-02f, 2.05942020e-02f, 4.07971479e-02f, -1.73686087e-01f, -1.49757937e-01f, -2.26802472e-02f, 5.86639456e-02f,
  -4.18108106e-02f, 1.62413806e-01f, 3.73174548e-02f, -3.29807065e-02f, -2.44847760e-01f, -2.83229649e-01f, 2.96370275e-02f, 1.21463798e-01f, -1.02473006e-01f, -7.42039800e-01f,
  -5.92472374e-01f, 2.92056948e-01f, -1.08206958e-01f, -4.84880176e-04f, -1.10075362e-01f, 2.04131263e-03f, 2.64066961e-02f, -7.84720778e-02f, 2.19446927e-01f, 7.04664066e-02f,
  -3.03160436e-02f, -1.04598235e-02f, -7.25367246e-03f, 3.71842310e-02f, 1.48908764e-01f, 1.47277880e-02f, 2.11788163e-01f, 1.19677097e-01f, 5.33563597e-03f, -5.03522903e-03f,
  1.42808808e-02f, 1.64595306e-01f, 2.52706170e-01f, 2.69083470e-01f, -3.39378752e-02f, 8.51148590e-02f, 1.13432042e-01f, 7.56818727e-02f, 1.26447737e-01f, 1.49956390e-01f,
  -8.61967262e-03f, -3.44755091e-02f, -8.59640688e-02f, 5.49640916e-02f, 5.88781089e-02f, 1.00105032e-02f, -1.10915959e-01f, 7.39560947e-02f, -1.37429535e-02f, 8.55399966e-02f,
  -1.47409560e-02f, -1.68234408e-01f, -7.67661035e-02f, -2.94135660e-02f, -1.45989403e-01f, -5.48088625e-02f, -3.23873945e-02f, -5.36898859e-02f, -1.50638014e-01f, -3.19344848e-02f,
  -3.63111570e-02f, -2.97811553e-02f, -5.44700325e-02f, -8.90870169e-02f, 1.70175266e-02f, 1.60026461e-01f, -5.52506559e-02f, 5.75120002e-02f, 1.27776980e-01f, -3.48780467e-03f,
  1.72258001e-02f, 6.08307356e-03f, -3.51950705e-01f, -3.22642058e-01f, -6.19255528e-02f, -8.10304880e-02f, -1.75275534e-01f, -1.85199052e-01f, -5.73643530e-03f, -6.96460828e-02f,
  -3.41410004e-02f, -8.99439752e-02f, -1.60594493e-01f, 2.49739159e-02f, 6.30761087e-02f, -8.01941678e-02f, 7.62699991e-02f, -6.95764348e-02f, -6.80120736e-02f, -1.10868149e-01f,
  -2.51017231e-02f, 2.11700007e-01f, 2.58683026e-01f, 1.21384196e-01f, -7.61926267e-03f, -7.36005753e-02f, -1.97743978e-02f, -1.98871344e-02f, 1.32936358e-01f, 2.61877567e-01f,
  -3.74241948e-01f, -2.71518648e-01f, 7.64144138e-02f, 5.05352378e-01f, 4.01306003e-01f, 2.44586512e-01f, 1.81085303e-01f, 8.79076049e-02f, 3.52878481e-01f, 2.99276739e-01f,
  3.30764502e-01f, 3.64042372e-01f, 3.80704701e-01f, 2.73943603e-01f, 2.49289066e-01f, 2.99164444e-01f, 2.86034465e-01f, 5.10625951e-02f, 1.46700412e-01f, 2.38550752e-01f,
  3.70766401e-01f, 2.31812168e-02f, -4.85954322e-02f, 1.38216421e-01f, 1.75930411e-01f, 2.82451630e-01f, 2.06279188e-01f, 1.93423882e-01f, 2.25572750e-01f, 2.59447247e-01f,
  -1.38278380e-01f, -1.31557405e-01f, 2.36654893e-01f, -6.84699714e-02f, -1.05391957e-01f, -1.80815652e-01f, -9.45603289e-03f, -7.07469136e-02f, -1.22190312e-01f, -1.05511084e-01f,
  4.45634350e-02f, -1.35878533e-01f, 4.46601026e-02f, -1.19017221e-01f, -1.51887074e-01f, -1.94786251e-01f, -1.34190544e-01f, 8.73882696e-02f, 4.03460152e-02f, -1.84420571e-02f,
  1.28125742e-01f, 1.45285781e-02f, 5.11115119e-02f, 3.34062763e-02f, 1.57316163e-01f, 3.00658401e-02f, -1.51398733e-01f, 3.64237837e-02f, -1.87134873e-02f, 6.15172647e-02f,
  5.26405752e-01f, 2.92097121e-01f, 2.44972706e-01f, 1.87710449e-01f, 4.19401824e-02f, 4.24603932e-02f, -3.61208916e-02f, 1.71486393e-01f, 1.61043197e-01f, -5.71383834e-02f,
  4.02009115e-02f, 1.68511078e-01f, -1.15266824e-02f, 1.03585340e-01f, 1.09668516e-01f, 1.12316526e-01f, -1.29377712e-02f, 1.22073889e-01f, -4.31136005e-02f, -2.54310556e-02f,
  1.42249107e-01f, 1.78851429e-02f, -1.90514565e-01f, -2.05105972e-02f, -1.14676975e-01f, 9.77343321e-02f, 1.30238742e-01f, 6.04965352e-02f, -1.99837051e-02f, -5.58780767e-02f,
  2.41414085e-01f, 1.68949664e-01f, 2.22884089e-01f, 8.93364847e-02f, -3.98015976e-02f, -1.88879371e-01f, 7.78365433e-02f, -1.27076820e-01f, -2.22154930e-01f, 7.56783132e-03f,
  -7.27759525e-02f, -1.26449510e-01f, -4.92245890e-02f, -5.70881106e-02f, -1.84043869e-01f, -2.51263175e-02f, -2.57024467e-02f, 1.46093488e-01f, 5.84008917e-03f, 4.93305698e-02f,
  -1.14079211e-02f, 1.14673726e-01f, 6.06408641e-02f, 1.33654311e-01f, 1.04562834e-01f, 1.70254037e-01f, -6.19635358e-02f, -3.02558262e-02f, -8.90279114e-02f, -5.72681725e-02f,
  -1.02864981e+00f, 3.48391235e-01f, -1.94550470e-01f, -5.27521372e-01f, -4.66289103e-01f, -4.48945791e-01f, 2.36006543e-01f, 4.25081849e-02f, -1.13649599e-01f, 3.39789599e-01f,
  2.04142839e-01f, -9.98707712e-02f, 1.10563435e-01f, -6.18418343e-02f, -1.17721453e-01f, 5.01903817e-02f, -3.24949980e-01f, -5.64888954e-01f, -7.46747196e-01f, -5.65979540e-01f,
  -4.10319418e-01f, -5.06567836e-01f, -6.28811002e-01f, -3.65547478e-01f, -3.66686583e-02f, -4.54098791e-01f, -3.47182266e-02f, -4.51042980e-01f, -5.81871927e-01f, -4.72946584e-01f,
  5.99025965e-01f, -2.22023070e-01f, -1.54587954e-01f, -1.86078981e-01f, 6.59700036e-02f, -6.89325528e-03f, -4.12196591e-02f, 9.49047320e-03f, 1.58620715e-01f, 1.07478201e-01f,
  9.91550740e-03f, 3.25770229e-02f, -5.37690669e-02f, 8.53901580e-02f, 3.45539711e-02f, 6.76158164e-03f, 1.57899216e-01f, -6.80440068e-02f, 9.03367922e-02f, 3.18927169e-01f,
  2.59618878e-01f, 4.13657352e-02f, 2.14105651e-01f, 8.95414054e-02f, 7.13822246e-02f, -1.46076947e-01f, 8.61824155e-02f, -1.05628788e-01f, -1.50782794e-01f, 9.07551050e-02f,
  -3.18132229e-02f, 1.14402220e-01f, -9.80779622e-03f, -3.18228304e-02f, 3.95768434e-02f, 7.24621937e-02f, 4.47286479e-02f, 7.08775446e-02f, 2.15013362e-02f, 1.12216532e-01f,
  1.32895485e-01f, 1.69338793e-01f, 8.75838194e-03f, 5.85462525e-02f, -5.52513786e-02f, -3.58556546e-02f, 1.30730849e-02f, 1.57530293e-01f, 3.04202568e-02f, 4.82965000e-02f,
  -2.22949445e-01f, -1.12795681e-01f, -1.68535665e-01f, 2.38150433e-02f, -8.64863172e-02f, 2.25851405e-02f, 3.92244235e-02f, 2.49254797e-02f, -5.10635562e-02f, 2.93681715e-02f,
  2.98669606e-01f, -3.46331418e-01f, 1.41639933e-01f, -1.19375819e-02f, -6.56548962e-02f, 5.02330661e-02f, 5.67242224e-03f, -1.19284116e-01f, -9.09418985e-02f, -1.17837256e-02f,
  -9.21969116e-02f, -6.16758615e-02f, 1.21719375e-01f, 5.41326702e-02f, -1.54716996e-04f, -4.46909331e-02f, 8.43668208e-02f, -6.98029948e-03f, -1.23017162e-04f, 1.03544630e-01f,
  7.68439174e-02f, 3.24419700e-02f, 1.52892813e-01f, 1.91410065e-01f, 1.32612094e-01f, -1.93169713e-01f, 2.00396672e-01f, 1.53703261e-02f, -1.21863961e-01f, 3.12439740e-01f,
  5.08979738e-01f, -4.25596714e-01f, -1.20146012e+00f, -3.90843809e-01f, -7.44894087e-01f, -3.72704625e-01f, -2.82176156e-02f, 1.97523966e-01f, -2.01660782e-01f, -4.90535170e-01f,
  5.52938804e-02f, 1.16741642e-01f, -3.66861135e-01f, 1.39833525e-01f, 3.78501058e-01f, -6.56478345e-01f, -8.10971975e-01f, -4.66032118e-01f, 2.84276098e-01f, 4.29191113e-01f,
  2.26054505e-01f, 7.38996193e-02f, 1.77110091e-01f, 5.99250896e-03f, -5.27227819e-01f, -2.83831716e-01f, -8.68501246e-01f, -3.52502048e-01f, -2.04127058e-01f, -8.42283845e-01f,
  -5.97694457e-01f, -3.54450732e-01f, -2.31373357e-03f, 2.59150594e-01f, -1.59532115e-01f, 1.36724383e-01f, 2.42804110e-01f, -6.57535493e-02f, 2.09064364e-01f, -6.12518713e-02f,
  -2.90977731e-02f, 1.07156157e-01f, 2.08751082e-01f, -1.51777789e-01f, -6.69085281e-03f, 1.18369818e-01f, -4.97774407e-02f, -1.47960991e-01f, -1.38271108e-01f, -5.31067066e-02f,
  3.66207696e-02f, -2.73034334e-01f, -1.56979486e-01f, -1.05869457e-01f, 2.32434459e-02f, -8.47142935e-02f, -1.92806765e-01f, -1.59715619e-02f, -1.89022750e-01f, -3.31312209e-01f,
  -1.00290060e-01f, -1.86744049e-01f, 1.28156930e-01f, 1.76612124e-01f, 2.08660632e-01f, 3.41113098e-02f, 6.66103733e-04f, 1.03515610e-01f, 4.94949222e-02f, 3.60762561e-03f,
  -7.08134919e-02f, -7.82777183e-03f, 7.86389485e-02f, 7.24037457e-03f, -6.96446151e-02f, -1.00296132e-01f, -3.88555303e-02f, -5.77448346e-02f, 2.22874004e-02f, 6.84375264e-05f,
  -1.84435491e-02f, 2.87085604e-02f, -9.55938399e-02f, 4.27960493e-02f, 2.68134046e-02f, -5.14991060e-02f, -4.69323695e-02f, 2.13278890e-01f, 8.14826787e-02f, 5.60700744e-02f,
  3.62402469e-01f, 8.77240300e-02f, -2.50658870e-01f, 1.72235310e-01f, -1.25463113e-01f, -6.93863332e-02f, -2.03424811e-01f, -5.55465696e-03f, -3.19515429e-02f, 3.08000632e-02f,
  6.45164698e-02f, 1.46299556e-01f, 4.82635945e-02f, -1.91925876e-02f, 7.10963458e-02f, 1.89192131e-01f, 2.45136648e-01f, -1.02236934e-01f, 1.22424841e-01f, -1.49301827e-01f,
  6.15600497e-02f, -3.64528480e-03f, 4.99750108e-01f, 1.16983838e-01f, 1.50538608e-01f, 1.72761947e-01f, -1.02566883e-01f, -1.15557224e-01f, 2.76355773e-01f, 2.03766614e-01f,
  1.33889782e+00f, 6.66688085e-01f, 5.93480349e-01f, 1.09674603e-01f, -7.82667026e-02f, 2.47612029e-01f, 5.84748805e-01f, 3.20904851e-01f, 6.07290752e-02f, 2.53683507e-01f,
  -5.65401092e-02f, -3.34480405e-01f, -9.34332013e-02f, -1.40732706e-01f, 2.55605340e-01f, 2.56496042e-01f, -8.90616328e-02f, 2.21717000e-01f, 1.93477660e-01f, 8.73647928e-02f,
  -2.98250943e-01f, 8.35505649e-02f, 2.65582800e-01f, 1.55087918e-01f, -3.68587370e-03f, -1.16833657e-01f, 2.73691528e-02f, 2.74505187e-02f, 2.28440892e-02f, 5.45055382e-02f,
  -1.05860708e-02f, 5.35706997e-01f, -3.61593485e-01f, -2.28817701e-01f, -2.34830473e-02f, -4.93163764e-02f, 6.41207173e-02f, -6.07474484e-02f, -4.05408517e-02f, -4.64294590e-02f,
  -1.91544354e-01f, 2.91883014e-03f, 1.47507833e-02f, -8.76056999e-02f, 2.85201613e-02f, 1.38474032e-02f, 9.86905172e-02f, 1.33870512e-01f, 1.59555525e-01f, -5.73957339e-02f,
  -2.72805870e-01f, -1.52408347e-01f, 3.78697403e-02f, 9.09292251e-02f, 1.32261351e-01f, -1.49027646e-01f, 1.62277669e-01f, 1.62359267e-01f, 2.39310801e-01f, 1.75447762e-01f,
  -4.49246429e-02f, 1.98406547e-01f, 1.50773540e-01f, 2.09283903e-01f, 1.75231323e-01f, 1.05622627e-01f, -6.25144541e-02f, -8.08539912e-02f, 1.38503551e-01f, 1.82525381e-01f,
  5.00569828e-02f, 5.51318042e-02f, 2.18545347e-01f, 8.36511105e-02f, -1.43104017e-01f, 1.00730825e-03f, -6.75111935e-02f, -7.08002895e-02f, -4.26683165e-02f, 1.04284190e-04f,
  5.15355803e-02f, -3.56420167e-02f, 8.80537555e-02f, 1.89484790e-01f, -6.09844700e-02f, 1.54248010e-02f, 6.28413213e-03f, -1.40726581e-01f, -6.49785846e-02f, -1.48323134e-01f,
  -5.63158453e-01f, 2.08478142e-02f, -3.86043638e-02f, 1.14661101e-02f, -4.94493730e-02f, 3.34031060e-02f, 1.07736133e-01f, -1.19175196e-01f, -2.20525831e-01f, -1.00906409e-01f,
  -9.88495573e-02f, -1.81453492e-04f, 3.94826569e-02f, 1.10221609e-01f, -9.51048285e-02f, -1.56221017e-01f, -2.00257882e-01f, -4.96508442e-02f, -1.30412817e-01f, -1.16883926e-01f,
  -2.25019321e-01f, -1.94101721e-01f, -1.84917912e-01f, -3.00379116e-02f, -1.12291925e-01f, -2.92588204e-01f, -1.31748915e-01f, -4.06101160e-02f, -4.33363914e-02f, 2.93790828e-02f,
  -7.62314081e-01f, -1.97032183e-01f, 4.09671694e-01f, -2.01729402e-01f, 3.89021069e-01f, 5.77338636e-01f, 4.90839124e-01f, 8.68013427e-02f, -1.43660575e-01f, -1.09821215e-01f,
  -2.59858400e-01f, -3.61368448e-01f, -3.79411668e-01f, -1.38609782e-01f, 2.42008213e-02f, 3.35174590e-01f, 2.15703040e-01f, 2.56628484e-01f, 2.30692014e-01f, 2.34184191e-01f,
  -1.47023536e-02f, -9.02146846e-02f, -3.52989316e-01f, -2.37107292e-01f, -2.23674282e-01f, -6.51847944e-03f, -1.24038279e-01f, -6.55198693e-02f, 6.43739626e-02f, -1.88280106e-01f,
  4.31571215e-01f, -2.33720452e-01f, -2.55915578e-02f, -3.19862664e-01f, -2.33478665e-01f, -2.76015401e-01f, -7.87749887e-02f, -9.29636583e-02f, -1.59372687e-01f, 3.42864916e-02f,
  -3.43084312e-03f, -2.24377960e-02f, 4.91914675e-02f, 2.76879519e-02f, 7.67537951e-02f, 6.86414167e-02f, -1.23366967e-01f, -5.58849759e-02f, -7.98641518e-02f, -8.03562850e-02f,
  -7.24630058e-02f, 1.16727591e-01f, 2.28860244e-01f, 8.74933153e-02f, 5.02639897e-02f, -4.40599322e-02f, -4.97711226e-02f, 5.44986166e-02f, 8.11731815e-02f, -1.00230753e-01f,
  -7.50747472e-02f, -3.31458561e-02f, -6.69825301e-02f, 6.72679618e-02f, 1.11979835e-01f, 1.45717785e-01f, 3.16870324e-02f, 1.30875751e-01f, -1.34996912e-02f, 1.33663833e-01f,
  1.92487821e-01f, 1.24392621e-01f, 7.25062424e-03f, 4.90559004e-02f, -1.43152326e-01f, 5.05313575e-02f, 1.30099699e-01f, 3.69490832e-02f, 1.45960534e-02f, 2.04943062e-04f,
  7.35803973e-04f, 4.61279340e-02f, -1.02632977e-02f, 9.71482471e-02f, 2.44910959e-02f, 9.90775898e-02f, 6.73973188e-02f, 2.38888562e-02f, 4.12228554e-02f, 9.74979624e-02f,
  -7.14884251e-02f, 2.71529496e-01f, 1.55635804e-01f, -1.30226403e-01f, -1.19516701e-02f, -1.38200626e-01f, 8.13391525e-03f, -9.47203711e-02f, -2.81477012e-02f, 1.29438058e-01f,
  8.73533189e-02f, -5.93801886e-02f, -9.52942763e-03f, -3.24317999e-02f, 2.40563989e-01f, 6.59077987e-02f, -1.23583473e-01f, -8.30421597e-03f, -5.32203987e-02f, -3.63850631e-02f,
  -9.88416597e-02f, 1.33090630e-01f, 1.84175402e-01f, 2.40377292e-01f, 1.75501540e-01f, 1.95210665e-01f, 2.22106278e-01f, 2.10134879e-01f, 2.42893457e-01f, 1.36033177e-01f,
  8.28813493e-01f, -5.57868063e-01f, -5.36853552e-01f, -3.07080857e-02f, -2.79521435e-01f, -1.69735670e-01f, -2.26366848e-01f, 1.02210276e-01f, 3.24931443e-02f, -2.01270565e-01f,
  -1.55655161e-01f, 3.57828319e-01f, 1.45312980e-01f, 1.54141128e-01f, 1.87059164e-01f, -3.64936382e-01f, -4.30046052e-01f, 1.38923433e-02f, 4.07859445e-01f, 2.40962595e-01f,
  1.40211955e-01f, 1.34915307e-01f, 3.09594572e-01f, 5.06553799e-02f, -4.10892218e-01f, -8.16115271e-03f, -4.67339486e-01f, -3.11821908e-01f, -3.97523493e-01f, -6.00568056e-01f,
  -3.94097120e-01f, -1.60586938e-01f, 1.51248306e-01f, 1.58986896e-01f, -4.65421267e-02f, 1.91328809e-01f, 7.33161941e-02f, 3.68911680e-03f, 8.43573660e-02f, -4.25756760e-02f,
  -1.58711553e-01f, 3.76141194e-04f, 7.97820017e-02f, -8.66307095e-02f, 5.23789264e-02f, 5.60253449e-02f, -5.96906394e-02f, 6.02292344e-02f, -9.44164470e-02f, -8.69641304e-02f,
  -1.63061574e-01f, -1.30020067e-01f, 7.27156177e-04f, 1.71218082e-01f, 1.22574709e-01f, 1.22082785e-01f, -2.76773013e-02f, 8.35616142e-02f, 5.05695399e-03f, 1.14019290e-01f,
  -4.67461087e-02f, 4.25410457e-02f, 6.03179075e-02f, 4.00129892e-02f, 1.71277672e-01f, 1.88454121e-01f, 3.78603786e-02f, 7.33093470e-02f, 7.67916813e-02f, 1.41038999e-01f,
  3.78343873e-02f, -7.34612420e-02f, 4.28627152e-03f, 6.94951639e-02f, -1.12222277e-01f, -1.29115507e-01f, -6.86591957e-04f, 2.90043056e-02f, 2.30246000e-02f, -2.66560391e-02f,
  4.02106121e-02f, -9.37878415e-02f, -2.39631414e-01f, -5.68126105e-02f, -2.65107483e-01f, -8.95249546e-02f, -7.09226355e-02f, 1.57597605e-02f, 2.02846099e-02f, -1.17210701e-01f,
  7.27583170e-02f, 4.32053879e-02f, 5.10563105e-02f, 1.09843113e-01f, -9.09155160e-02f, -1.90579444e-01f, -2.61498932e-02f, 2.45587956e-02f, -2.02524439e-01f, -8.00156668e-02f,
  1.32158408e-02f, 7.84935281e-02f, -9.86400321e-02f, 5.77017926e-02f, 1.16792180e-01f, 7.27707222e-02f, 1.30184069e-01f, 7.65677840e-02f, -1.27141804e-01f, -1.74161717e-01f,
  -1.54528379e-01f, 6.70671836e-02f, 2.15424895e-01f, 6.30313233e-02f, 1.98245153e-01f, 1.14225060e-01f, 9.70981121e-02f, 1.45814233e-02f, 1.22033425e-01f, 3.41657698e-01f,
  -1.58023179e+00f, -5.47596872e-01f, 7.17105865e-01f, -3.74004215e-01f, 2.54992098e-01f, 6.92319870e-02f, -5.03287911e-01f, -3.84644233e-02f, 4.53451909e-02f, -5.42301178e-01f,
  -1.92955628e-01f, -9.58002582e-02f, -1.30675018e-01f, -1.59609467e-01f, -2.84659952e-01f, -4.81616795e-01f, 1.57647878e-01f, 3.73740196e-01f, 6.38739407e-01f, -4.47056703e-02f,
  -5.17738640e-01f, -1.08121745e-01f, 1.11125663e-01f, 1.92816585e-01f, -4.52618629e-01f, -2.56142855e-01f, 1.41977534e-01f, -1.71423391e-01f, -3.98520172e-01f, -8.97728562e-01f,
  -3.83599311e-01f, -9.27131251e-02f, 3.86866778e-01f, -1.77950729e-02f, 2.37211570e-01f, -3.83811533e-01f, -2.65924215e-01f, 1.31148860e-01f, -1.22569792e-01f, -4.41654306e-03f,
  -2.01716304e-01f, 9.69253555e-02f, -1.84625626e-01f, 7.12628383e-03f, -1.59136951e-01f, -1.89383671e-01f, 5.33396959e-01f, 3.48058850e-01f, 3.00919831e-01f, 5.82474582e-02f,
  -2.28921011e-01f, -6.46887362e-01f, -1.42896269e-03f, 4.71667379e-01f, 1.53077856e-01f, 2.31415421e-01f, 3.17411453e-01f, -5.27431630e-02f, 2.78921336e-01f, -1.04687345e+00f,
  -9.21033546e-02f, -3.48508283e-02f, 2.21488208e-01f, 1.52506322e-01f, -2.82191396e-01f, -2.82715391e-02f, -5.10016456e-02f, -1.19264722e-01f, 4.57383953e-02f, -1.02516249e-01f,
  8.40820465e-03f, -5.97791523e-02f, 1.57236338e-01f, -1.17628254e-01f, -2.01919183e-01f, -4.02838215e-02f, -1.66845024e-01f, 1.49159553e-02f, 1.25239938e-01f, -1.78729877e-01f,
  3.64872292e-02f, -4.99720015e-02f, 2.13515073e-01f, 2.44411603e-02f, 8.87694433e-02f, 1.92872375e-01f, -1.18121058e-01f, 1.38668805e-01f, 1.83384985e-01f, -8.36613923e-02f,
  -1.36256933e-01f, 6.87289655e-01f, -6.69234574e-01f, 1.51943818e-01f, -1.62907705e-01f, 1.43340990e-01f, -1.42942339e-01f, 2.91654915e-01f, 3.59640457e-02f, -9.15556848e-02f,
  3.72074954e-02f, -1.19410641e-01f, 2.22951509e-02f, 2.27184728e-01f, -1.12302087e-01f, -1.45493066e-02f, -2.87680000e-01f, -2.35729054e-01f, -4.39261980e-02f, -9.68749076e-02f,
  4.34926972e-02f, -7.43582487e-01f, -8.24391425e-01f, -5.04951477e-01f, -4.04395252e-01f, -4.35305536e-01f, -3.17591637e-01f, -2.03935906e-01f, -4.52966154e-01f, -1.33093107e+00f,
  -1.26697659e+00f, 1.52613759e-01f, -7.09106207e-01f, -6.34377658e-01f, 1.32658109e-01f, 5.70234895e-01f, 8.84626448e-01f, 4.16758507e-01f, -1.60426840e-01f, -1.80752650e-01f,
  2.55514346e-02f, 4.39649187e-02f, -3.01692784e-01f, 1.94599062e-01f, 4.02731657e-01f, 3.86371791e-01f, 1.31628588e-01f, -4.78363484e-02f, 2.75689512e-01f, 5.51567137e-01f,
  5.27693689e-01f, -6.92381486e-02f, -4.50278878e-01f, 2.66653560e-02f, -1.87864944e-01f, -5.16197719e-02f, -4.77173001e-01f, -3.27585846e-01f, 1.95593029e-01f, -2.50113040e-01f,
  -6.13306820e-01f, -5.28362393e-01f, 3.47720273e-02f, 1.04517832e-01f, -1.81657910e-01f, -2.12826043e-01f, -1.67605549e-03f, -3.35411131e-01f, -6.80895075e-02f, -3.35175276e-01f,
  -3.01129937e-01f, 4.87002991e-02f, -3.31948996e-01f, 7.06965476e-02f, -1.06814727e-01f, -1.53411239e-01f, -1.72386929e-01f, -1.09408446e-01f, -2.56989509e-01f, 5.50971329e-02f,
  8.12606990e-01f, 1.09742396e-04f, -6.81419969e-01f, 3.97908062e-01f, -8.59735757e-02f, -3.31938446e-01f, -1.17912106e-01f, -6.98468238e-02f, -1.33464664e-01f, -6.62889004e-01f,
  3.28106731e-02f, -1.87719949e-02f, 1.96533259e-02f, -3.65059380e-03f, 1.83842540e-01f, -1.69055745e-01f, -5.10670356e-02f, 2.67837673e-01f, 5.84141687e-02f, -5.53830229e-02f,
  7.95120671e-02f, -1.80274814e-01f, -1.09185658e-01f, -2.16490865e-01f, -5.90466149e-02f, -1.74961954e-01f, 1.86730951e-01f, -4.77035530e-02f, -1.55838698e-01f, -6.08810633e-02f,
  5.63999191e-02f, -1.02652259e-01f, -2.20742434e-01f, 1.93626493e-01f, 1.82902031e-02f, -4.63986732e-02f, -9.60364565e-02f, 1.68893576e-01f, 1.14144191e-01f, 1.06609464e-01f,
  -3.53792101e-01f, 3.20337564e-01f, -5.76895475e-01f, 2.92352080e-01f, -7.49891177e-02f, -1.19016431e-01f, -2.13072076e-01f, 2.41251830e-02f, -1.56375095e-01f, -1.39445916e-01f,
  1.15328714e-01f, 1.04541183e-02f, -3.18344146e-01f, 3.10720861e-01f, -6.61359429e-02f, -2.26548627e-01f, 1.04436405e-01f, 2.42590550e-02f, 2.33265162e-01f, -1.89390749e-01f,
  8.14993028e-03f, 1.54643103e-01f, -4.44227248e-01f, -1.01273798e-03f, -8.29658657e-02f, -2.32151955e-01f, -4.34761316e-01f, 2.52602380e-02f, -1.67273030e-01f, -3.36108387e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 26)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 26;
const float L0_fan_Bp_bar_data[] = {
  6.01088941e-01f, 4.23110843e-01f, 8.77942920e-01f, 6.87394261e-01f, 4.49983001e-01f, 8.91808569e-01f, 4.73910809e-01f, 2.57837027e-01f, 6.02308929e-01f, 4.95877504e-01f,
  1.05292606e+00f, 7.72423327e-01f, 2.15977058e-01f, 7.21054912e-01f, 6.26318216e-01f, 2.32349083e-01f, 5.15529931e-01f, 3.90302807e-01f, 1.25927746e-01f, 7.46603608e-01f,
  2.83350885e-01f, 6.27879143e-01f, 9.41324949e-01f, 6.87633097e-01f, 4.92136538e-01f, 3.21662903e-01f
};

// L1_linear_W (Shape: 12 x 64)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 64;
const float L1_linear_W_data[] = {
  8.31757411e-02f, -2.93617010e-01f, -1.01988807e-01f, 1.01192584e-02f, -1.04494467e-01f, -2.57788301e-02f, 6.14371747e-02f, -4.04010534e-01f, -3.50342631e-01f, -3.01317036e-01f,
  -2.38600567e-01f, -3.66866142e-01f, -5.50310081e-03f, -1.73651371e-02f, 1.65313538e-02f, -5.03590286e-01f, -5.49966730e-02f, -8.15224126e-02f, -2.18290314e-01f, -2.08161309e-01f,
  1.51479274e-01f, 7.17235133e-02f, 5.63670695e-01f, -8.35680440e-02f, 3.48197520e-01f, -8.33762996e-03f, -1.52767539e-01f, 1.60846815e-01f, 1.26404151e-01f, -4.83827703e-02f,
  -1.45601720e-01f, 1.73601180e-01f, 2.00570509e-01f, -5.42400703e-02f, 4.61005032e-01f, 5.32996245e-02f, 1.64886728e-01f, -1.92910448e-01f, -6.40224934e-01f, 1.61137000e-01f,
  -3.89464706e-01f, -1.73685932e+00f, 9.31272879e-02f, -7.75309741e-01f, 2.74109125e-01f, 4.31795299e-01f, 3.49884838e-01f, -2.99787074e-01f, -5.43131292e-01f, -6.78463459e-01f,
  -2.17144996e-01f, -3.04349184e-01f, -5.99038839e-01f, 1.53607652e-02f, -4.66816843e-01f, 2.23289281e-01f, -8.36827993e-01f, -1.04633749e-01f, 5.20786285e-01f, -1.00499816e-01f,
  -3.48168284e-01f, 3.61340135e-01f, 1.82291850e-01f, 5.42214334e-01f, -9.23931673e-02f, 5.02411127e-02f, 1.02145024e-01f, -2.24234909e-01f, -1.26940802e-01f, -1.02173850e-01f,
  1.02220125e-01f, 9.72340181e-02f, -3.64268064e-01f, 2.67520752e-02f, -2.11784616e-01f, -1.16158523e-01f, -1.67120367e-01f, -1.46070896e-02f, -7.83383474e-02f, -1.07808881e-01f,
  -2.66334534e-01f, -2.43292674e-01f, 7.79742673e-02f, -8.28426853e-02f, 2.54212737e-01f, -1.36068212e-02f, 3.08845907e-01f, 1.65129021e-01f, 2.25429252e-01f, -5.91302849e-02f,
  -4.79289740e-02f, -3.77730001e-03f, -1.62797481e-01f, -5.15862145e-02f, -3.09693247e-01f, 3.62271637e-01f, 4.52419231e-03f, -2.43517369e-01f, 1.11794710e-01f, -2.74526894e-01f,
  -4.68565285e-01f, 1.49343714e-01f, -8.71323273e-02f, -1.08741798e-01f, 1.37413651e-01f, -4.25607204e-01f, -4.79611278e-01f, -4.67315137e-01f, 1.21801794e+00f, -1.03505683e+00f,
  -3.06569308e-01f, 8.07702243e-02f, -1.05284965e+00f, -1.28713238e+00f, 1.16487451e-01f, 6.55051827e-01f, 4.17151339e-02f, 6.49667501e-01f, -4.64295805e-01f, 5.97066395e-02f,
  1.22948222e-01f, -4.49319422e-01f, 6.10164464e-01f, 5.16725481e-01f, -2.98019469e-01f, 5.52819192e-01f, -9.48222280e-01f, -8.11836004e-01f, -1.60005316e-02f, -1.54983357e-01f,
  2.47110073e-02f, 2.89996564e-02f, 9.44832414e-02f, -4.31877971e-02f, 2.30558604e-01f, -5.27808964e-02f, 2.94684857e-01f, 1.11632802e-01f, 1.26685396e-01f, 9.86207947e-02f,
  -7.45504498e-02f, -3.42970416e-02f, 1.42754197e-01f, -1.11054763e-01f, 1.01988882e-01f, -2.36057839e-03f, 1.41167283e-01f, 3.04253697e-01f, 3.55350077e-01f, 2.27084816e-01f,
  1.22778445e-01f, -2.04726622e-01f, -1.62978008e-01f, 4.58118618e-02f, 8.64840224e-02f, 3.51666838e-01f, -1.25096157e-01f, 8.10030624e-02f, -3.77856463e-01f, 3.78930151e-01f,
  2.14857474e-01f, -1.11713894e-01f, 4.13625807e-01f, 1.27067342e-01f, -2.47922421e-01f, 1.12600708e-02f, -5.87177649e-02f, 3.01146597e-01f, -7.45109558e-01f, -7.64219463e-01f,
  -1.11499190e+00f, -1.48280650e-01f, 7.13357389e-01f, 1.43974304e-01f, -8.83332968e-01f, 3.87759864e-01f, -3.91710520e-01f, 1.92063659e-01f, -4.56088185e-01f, 4.61512715e-01f,
  3.80915701e-01f, -4.11127150e-01f, -4.98621494e-01f, -9.59204212e-02f, -3.55916649e-01f, -7.79316783e-01f, -7.86815941e-01f, -5.68656683e-01f, -2.77111769e-01f, -2.90188733e-02f,
  1.14480293e+00f, -7.95106441e-02f, -2.39566974e-02f, -3.76159921e-02f, -5.42184012e-03f, -5.38447857e-01f, 1.86896935e-01f, -2.41775662e-02f, -1.52096627e-02f, -3.24956238e-01f,
  -9.32135358e-02f, -2.56105691e-01f, 5.18492341e-01f, 1.44489661e-01f, 1.06154315e-01f, 4.18179333e-02f, 1.54300760e-02f, -3.83454598e-02f, 1.47328496e-01f, 1.63944721e-01f,
  -4.07977402e-01f, 3.70617509e-01f, 4.01639193e-01f, 2.88981423e-02f, -6.04766667e-01f, 3.54297847e-01f, -8.34927242e-03f, -1.13455892e-01f, -1.92611039e-01f, 6.07387386e-02f,
  3.61279011e-01f, 2.56083846e-01f, -1.69441819e-01f, -3.09637606e-01f, -4.56362367e-01f, 1.54812858e-01f, -8.12900960e-01f, 4.76576209e-01f, -2.22709663e-02f, 2.91663140e-01f,
  -5.63936889e-01f, -6.11534595e-01f, 3.86848539e-01f, 1.30293111e-03f, -1.11222970e+00f, 1.01041310e-01f, -1.23316431e+00f, 3.84006053e-01f, 3.87451530e-01f, 5.28816044e-01f,
  -9.63099480e-01f, -6.12966895e-01f, -4.02198970e-01f, -2.54623860e-01f, -4.63873565e-01f, -8.50396395e-01f, -4.24771547e-01f, -3.45948100e-01f, -6.14179492e-01f, 1.35602027e-01f,
  4.20718342e-02f, -1.95081353e-01f, 5.04420936e-01f, -8.87102544e-01f, 3.07934672e-01f, 8.73939097e-01f, -1.01599090e-01f, 6.03558458e-02f, -3.23127538e-01f, 1.18647821e-01f,
  -1.77969337e-01f, -1.05685301e-01f, -3.32394898e-01f, 4.10417199e-01f, 6.91375807e-02f, 1.93190411e-01f, 2.11044908e-01f, -1.98043175e-02f, -7.82701671e-02f, 1.43217787e-01f,
  -5.66925332e-02f, 3.24267864e-01f, 2.99750008e-02f, -3.57208371e-01f, 2.65058093e-02f, 2.62760013e-01f, -3.42177153e-02f, 2.94889510e-02f, -3.28051478e-01f, 1.96159214e-01f,
  -2.16979548e-01f, -9.92013328e-03f, -1.67260185e-01f, 1.56751737e-01f, 1.78913876e-01f, 1.95230201e-01f, 8.22803006e-02f, -1.15932338e-01f, -2.00748816e-02f, 7.33040124e-02f,
  2.61457562e-01f, -2.03279063e-01f, 1.07335679e-01f, -2.43450161e-02f, -4.92472082e-01f, 1.77738946e-02f, -6.11394525e-01f, 1.76668078e-01f, 2.27300450e-01f, -5.53710818e-01f,
  -4.50724512e-01f, -2.20917985e-02f, 2.27003798e-01f, 3.94252717e-01f, -9.08402205e-02f, 6.78855240e-01f, 8.84665735e-03f, -4.71812427e-01f, -9.42987353e-02f, 4.22535360e-01f,
  5.20166934e-01f, 2.44200215e-01f, 1.12010941e-01f, 3.73112857e-01f, -5.83738387e-01f, -3.12449574e-01f, -5.17380238e-01f, -7.15201080e-01f, 2.16473073e-01f, -9.43869531e-01f,
  2.60136813e-01f, 1.68216601e-01f, 2.92105913e-01f, -2.49565057e-02f, 5.41627668e-02f, 1.22062996e-01f, 6.67041689e-02f, 1.33365497e-01f, 2.25634113e-01f, 1.04635753e-01f,
  -3.02623779e-01f, 2.74017185e-01f, 2.46367514e-01f, 2.44569227e-01f, 1.39955610e-01f, 1.40254915e-01f, 9.97611433e-02f, -6.20350316e-02f, 1.33450730e-02f, -2.43226618e-01f,
  -3.43453556e-01f, -7.72126839e-02f, 4.83016938e-01f, -3.84826303e-01f, -1.75453246e-01f, 3.12007129e-01f, -3.46486092e-01f, 1.30271792e-01f, -1.08742490e-01f, 2.44871408e-01f,
  2.30333388e-01f, -4.92551863e-01f, -1.45227581e-01f, 2.80753702e-01f, 4.42378163e-01f, -8.17504823e-02f, 4.60811794e-01f, -1.08509451e-01f, -2.30871305e-01f, -2.43884757e-01f,
  5.91960907e-01f, -5.57257354e-01f, 9.28660274e-01f, -1.39385626e-01f, -2.89999008e-01f, -7.25539207e-01f, -4.20699954e-01f, -1.35621116e-01f, 8.19710433e-01f, -3.03213805e-01f,
  -2.49871895e-01f, -5.62351525e-01f, -9.10298377e-02f, -2.99062043e-01f, 4.70702380e-01f, 3.43169063e-01f, -1.27111778e-01f, 1.25000700e-01f, 3.19622368e-01f, -1.73827529e-01f,
  -7.23514438e-01f, 1.67120531e-01f, -7.89208353e-01f, -1.18425831e-01f, 1.26425758e-01f, 1.50081530e-01f, 1.65814877e-01f, 2.32106373e-01f, 3.76488000e-01f, -3.09264898e-01f,
  1.93193108e-01f, -4.50999945e-01f, -9.30812955e-02f, -4.66612190e-01f, 4.09863234e-01f, -1.57772768e-02f, 3.77192080e-01f, -4.75926131e-01f, 1.46845758e-01f, 2.25859076e-01f,
  3.89318705e-01f, 1.67721197e-01f, -4.21167426e-02f, 1.28314316e-01f, -3.69639993e-01f, 3.36219490e-01f, 5.05376756e-02f, 9.65882465e-02f, -2.03946024e-01f, -2.29507938e-01f,
  1.59550831e-01f, -5.30651569e-01f, -4.02779490e-01f, 1.18353948e-01f, 4.35463876e-01f, 3.86015698e-02f, 1.61074832e-01f, -3.24555784e-01f, 5.94936728e-01f, -1.73340626e-02f,
  7.24694803e-02f, -5.31130314e-01f, 6.16176486e-01f, 4.67461437e-01f, -5.07382035e-01f, 2.92098522e-02f, -4.33513194e-01f, -6.97357297e-01f, -7.75544465e-01f, -1.23043168e+00f,
  -8.42670918e-01f, -4.93706763e-01f, 5.65534346e-02f, 2.74075288e-03f, 3.94989759e-01f, -7.52328634e-01f, -1.17237523e-01f, -3.85349631e-01f, 1.19683713e-01f, -4.61098164e-01f,
  -2.83602655e-01f, -2.91924149e-01f, -2.57992268e-01f, 6.17425203e-01f, -1.01117623e+00f, -4.02863503e-01f, -6.02285445e-01f, -6.38702989e-01f, -1.35870785e-01f, -2.15899110e-01f,
  -6.28679991e-02f, 7.43105635e-02f, -3.57943565e-01f, 1.06415108e-01f, -1.87290058e-01f, 6.78269938e-02f, -1.99699238e-01f, -5.04198112e-02f, -1.35383099e-01f, -2.78542370e-01f,
  -2.45280743e-01f, 7.07208663e-02f, -3.73120070e-01f, -2.96149224e-01f, -4.08894151e-01f, -4.17733341e-02f, -1.36152813e-02f, 2.58085251e-01f, -7.59157911e-02f, -8.53391662e-02f,
  -1.27031848e-01f, -1.70963377e-01f, -1.31933123e-01f, 1.24491647e-01f, 7.46752322e-02f, -1.10508725e-01f, 1.36080361e-03f, -1.60948500e-01f, 9.44434106e-02f, -3.14027369e-01f,
  -8.51797983e-02f, 7.10743517e-02f, -1.71005636e-01f, -9.26003680e-02f, 6.96781278e-02f, 1.74490333e-01f, -7.45943666e-01f, 9.53022614e-02f, -8.69245678e-02f, 6.11351192e-01f,
  2.67992951e-02f, 2.21753046e-01f, -1.26355898e+00f, 1.33338466e-01f, -3.52278173e-01f, -8.17357123e-01f, 1.43867671e-01f, -1.22165747e-01f, 2.40664184e-01f, -6.05504289e-02f,
  -7.23051488e-01f, -4.29079205e-01f, -5.68906665e-02f, -4.96013463e-02f, 4.21397537e-01f, -7.83310175e-01f, -3.96385431e-01f, -5.28040767e-01f, 1.14068359e-01f, -7.83663809e-01f,
  4.51926216e-02f, 9.37377274e-01f, 1.40130043e-01f, 1.58751860e-01f, -4.99109924e-03f, 9.06667560e-02f, 9.07902420e-02f, 1.86864343e-02f, -2.53482103e-01f, 1.02625810e-01f,
  1.04382806e-01f, 2.45789010e-02f, -2.93710772e-02f, 1.52105927e-01f, -1.67712212e-01f, -6.09969012e-02f, -1.39040351e-01f, 1.50368750e-01f, -2.43847575e-02f, -4.55478206e-02f,
  1.26402387e-02f, -1.50776237e-01f, -2.86628187e-01f, 5.09959280e-01f, 4.75022137e-01f, 2.55402744e-01f, 5.54959327e-02f, 3.35876375e-01f, -9.68188271e-02f, 2.98912227e-02f,
  4.62902874e-01f, 7.35976472e-02f, -2.23174635e-02f, 3.46799105e-01f, -2.10920483e-01f, -2.58917063e-01f, 1.52987437e-02f, -3.05609815e-02f, -9.34896544e-02f, 2.81892627e-01f,
  -2.39054352e-01f, -4.85338867e-01f, -8.12615633e-01f, -3.65172893e-01f, -9.46239233e-01f, 5.79804003e-01f, -8.99759471e-01f, -2.14732811e-01f, -5.83156168e-01f, -5.78573942e-01f,
  1.41063857e+00f, -6.13372445e-01f, 7.18279108e-02f, 5.15951514e-01f, 1.94031253e-01f, 1.81560844e-01f, -3.62294614e-01f, -1.37764752e-01f, -5.17305918e-02f, -7.06682146e-01f,
  -8.58208776e-01f, -1.46444827e-01f, 5.66859961e-01f, 2.35240236e-01f, -3.88077497e-01f, -5.16865373e-01f, 8.78360197e-02f, 3.11176330e-01f, -1.66100740e-01f, 1.17878437e-01f,
  -5.48071638e-02f, 2.35375792e-01f, 2.13534366e-02f, -1.44458905e-01f, -8.91601890e-02f, 2.96619236e-02f, -2.19669238e-01f, 8.95187929e-02f, 9.92978066e-02f, 4.84678000e-02f,
  4.20247987e-02f, 2.63161510e-01f, -5.07667214e-02f, -1.46430194e-01f, -3.46012294e-01f, 8.52082893e-02f, 2.01245278e-01f, -3.82082164e-01f, -1.51015267e-01f, -5.63541576e-02f,
  -1.34484828e-01f, -2.72753567e-01f, 3.72612208e-01f, -2.11992234e-01f, -1.14558868e-01f, -1.74074739e-01f, 1.52472332e-02f, -2.14151666e-01f, 3.34568739e-01f, 5.38462877e-01f,
  -4.77008484e-02f, 1.27682790e-01f, 2.63932198e-01f, -3.93701762e-01f, 4.82231021e-01f, -1.66766480e-01f, -6.50491655e-01f, 3.03008854e-01f, 9.32272136e-01f, 6.57417327e-02f,
  4.73454177e-01f, 8.12095463e-01f, -2.24146873e-01f, -6.12973869e-01f, -8.81187439e-01f, 8.71583402e-01f, 4.40375172e-02f, -1.54989421e-01f, 2.75909871e-01f, -2.68612117e-01f,
  -3.98564786e-02f, -3.65641177e-01f, 1.77113548e-01f, -7.68864512e-01f, -6.90178037e-01f, -1.16902363e+00f, -3.30019593e-01f, -3.56012255e-01f, -1.21358168e+00f, -4.05227333e-01f,
  1.04549853e-02f, -5.02590686e-02f, 1.04392469e-01f, -3.24996822e-02f, 4.16632593e-02f, -6.26584440e-02f, 1.66022658e-01f, -8.45799129e-03f, 3.38138710e-03f, -4.21362184e-03f,
  1.28601745e-01f, -1.35978624e-01f, -3.75576392e-02f, -4.38096315e-01f, 1.17094770e-01f, 1.24278061e-01f, -9.61897373e-02f, 8.86702016e-02f, 2.82310974e-02f, -1.73410937e-01f,
  4.06047195e-01f, -3.95576328e-01f, -6.46323383e-01f, -5.64933896e-01f, 4.10574526e-01f, 2.52574861e-01f, -2.24240378e-01f, 1.31681427e-01f, 1.42999694e-01f, -6.26571655e-01f,
  -2.98679620e-01f, -5.25739312e-01f, -3.22007418e-01f, -2.49053553e-01f, -5.65975845e-01f, -2.88049430e-01f, -3.68921071e-01f, -2.16818511e-01f, -4.63600367e-01f, 1.84500352e-01f,
  9.18697298e-01f, -7.39540696e-01f, -6.89489126e-01f, 5.40573895e-01f, -6.75402284e-01f, -5.11068046e-01f, -7.51394212e-01f, -3.50405455e-01f, -3.21628004e-01f, 5.52695870e-01f,
  -3.33992571e-01f, 2.12593954e-02f, -6.94536746e-01f, 3.03095728e-01f, 6.67556822e-02f, -1.10397625e+00f, -4.44944501e-01f, 5.25919199e-01f, -3.89495105e-01f, -3.89380395e-01f,
  3.13303739e-01f, 7.37618804e-02f, -4.76854980e-01f, -2.96772093e-01f, 8.58749151e-02f, -5.55373847e-01f, 2.14916050e-01f, -2.18410287e-02f, -1.20423891e-01f, 1.97816491e-02f,
  5.06474487e-02f, 4.30434436e-01f, 1.30175993e-01f, 4.39748973e-01f, -5.85593618e-02f, -2.90513430e-02f, -3.03855762e-02f, 2.34444737e-01f, 2.25863270e-02f, -3.65849108e-01f,
  4.74468842e-02f, 8.71289372e-02f, 2.42268965e-01f, -4.16008562e-01f, -1.60313353e-01f, -4.65987027e-02f, -5.37465155e-01f, 5.32346427e-01f, 2.24017993e-01f, -1.31495133e-01f,
  1.30035303e-04f, -4.76058014e-02f, -1.13656893e-01f, -3.70169371e-01f, 8.57798383e-02f, 4.53885585e-01f, 3.29939350e-02f, 2.53745645e-01f, -5.47225654e-01f, 3.05149764e-01f,
  1.61680177e-01f, 5.28141916e-01f, 2.57103354e-01f, -6.25893652e-01f, 5.87374270e-02f, 7.46719897e-01f, -6.11603200e-01f, -5.06725729e-01f, -7.43806839e-01f, -4.39533859e-01f,
  6.27695799e-01f, -7.07184136e-01f, -6.32281363e-01f, -1.07214940e+00f, -4.90991622e-01f, -6.28321588e-01f, 5.42547882e-01f, -2.07874715e-01f, -4.54322964e-01f, 2.04712704e-01f,
  -4.51387614e-01f, 6.58034384e-02f, -1.71998277e-01f, 7.46836245e-01f, 2.59628564e-01f, -7.36119986e-01f, -2.32361495e-01f, -1.92715794e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -1.73679605e-01f, -1.98475551e-02f, 1.22974344e-01f, 5.53702563e-03f, -2.41554990e-01f, 5.79365483e-03f, 1.12020724e-01f, 4.79333252e-02f, -7.04185814e-02f, 1.24231614e-01f,
  4.71779704e-02f, -9.86495018e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 19, 26
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        64, 12
    );
    }
    