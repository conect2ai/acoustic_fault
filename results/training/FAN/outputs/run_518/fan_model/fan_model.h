/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -1.80709153e-01f, 7.58424327e-02f, -5.79864345e-03f, -2.01841652e-01f, -7.08539709e-02f, -1.02443360e-01f, -9.85840987e-03f, -8.68288279e-02f, -1.26061052e-01f, -3.53659540e-02f,
  2.23991871e-02f, 1.54155241e-02f, 1.21913999e-01f, -5.28743528e-02f, 6.89669549e-02f, 1.18369877e-01f, -1.26873374e-01f, -7.12799206e-02f, 1.56682339e-02f, -1.38685480e-01f,
  1.50112212e-02f, -6.70356527e-02f, 6.36622533e-02f, 2.63107736e-02f, -9.69410986e-02f, -5.86036146e-02f, 3.66320573e-02f, 4.52542044e-02f, -9.60565731e-02f, 4.02056165e-02f,
  -3.29848472e-03f, 5.75100034e-02f, 1.44946910e-02f, -3.87427136e-02f, 2.05516741e-02f, -2.51463335e-02f, -8.91857445e-02f, -3.11241932e-02f, 1.50191104e-02f, 3.71631905e-02f,
  -8.61162543e-02f, 4.00075875e-02f, -4.85917926e-02f, 6.33967072e-02f, -7.47556090e-02f, -2.29470003e-02f, 5.31095602e-02f, -1.96478199e-02f, -4.35168529e-03f, 3.62441130e-02f,
  8.54746327e-02f, 6.63519576e-02f, 3.02694030e-02f, 5.88777214e-02f, -4.41717580e-02f, 5.12275286e-02f, -3.05610411e-02f, 9.88216549e-02f, -8.13963041e-02f, -4.94329855e-02f,
  1.80787295e-02f, 1.45164467e-02f, -2.41343491e-02f, -6.48318678e-02f, -4.08673510e-02f, -2.49784291e-02f, -7.65416911e-03f, 4.48708907e-02f, -7.17465281e-02f, 4.28417511e-02f,
  -2.78595299e-03f, 1.69701446e-02f, 2.95206271e-02f, -1.64515134e-02f, -5.35559021e-02f, -9.52727869e-02f, -2.68266760e-02f, 4.70506772e-02f, -3.07352492e-03f, -7.17836842e-02f,
  -4.61837426e-02f, 3.66627015e-02f, 3.58965136e-02f, -4.38528696e-05f, -3.92305516e-02f, -5.47370575e-02f, -3.89289853e-05f, 7.27890581e-02f, 2.28840131e-02f, -1.71618517e-02f,
  3.22625339e-02f, -1.41170278e-01f, -5.79594970e-02f, -3.57782245e-02f, -4.19996940e-02f, 5.15650921e-02f, 1.01130456e-01f, 1.71624348e-02f, -1.25288337e-01f, -4.89904396e-02f,
  -8.75744373e-02f, -2.56700981e-02f, 7.18187541e-02f, 4.87015136e-02f, -8.78301170e-03f, -5.89742437e-02f, -1.36798903e-01f, -5.39765507e-02f, -5.31207509e-02f, 3.52883823e-02f,
  -4.22429256e-02f, -7.03456923e-02f, 9.21219587e-03f, -5.50960042e-02f, -2.34336648e-02f, -3.94589640e-02f, -5.43310493e-02f, 6.08025752e-02f, 1.19996592e-02f, 7.35209882e-02f,
  -1.25459656e-01f, 4.86000255e-03f, 1.78688541e-01f, -1.69104710e-02f, 5.34402169e-02f, -1.84582621e-02f, 4.34767120e-02f, -1.10422827e-01f, 9.88989547e-02f, -6.63677379e-02f,
  -1.32504225e-01f, 8.03837106e-02f, -1.01404209e-02f, -2.74772272e-02f, -3.32196355e-02f, 2.96384096e-03f, -1.03002265e-01f, -4.39318977e-02f, 1.45327821e-01f, -3.26353051e-02f,
  -3.66990678e-02f, -1.00093074e-01f, 1.42176136e-01f, -7.61013702e-02f, 2.17174795e-02f, -7.64810890e-02f, -1.23164006e-01f, -4.48598564e-02f, -8.90291408e-02f, 1.21278977e-02f,
  -1.05438612e-01f, -6.97797015e-02f, -3.37200016e-02f, 1.31882370e-01f, -1.02300659e-01f, 1.55571019e-02f, 3.80146950e-02f, 7.09973350e-02f, 1.56384110e-02f, -1.45066753e-02f,
  7.17090443e-02f, 6.60545528e-02f, -2.71832757e-02f, 1.58410706e-02f, 6.70618862e-02f, 5.55864023e-03f, -5.31200413e-03f, -2.41414644e-02f, -8.23852792e-03f, 4.48843203e-02f,
  7.31819794e-02f, 1.10170674e-02f, -3.07743791e-02f, 2.72725262e-02f, 1.06215477e-01f, 7.83124045e-02f, -3.30744125e-02f, -1.98703147e-02f, -6.72158077e-02f, -6.20245561e-02f,
  6.92289770e-02f, 8.01250048e-04f, -2.72324570e-02f, -5.48071042e-02f, -1.08119860e-01f, -5.58173098e-02f, -9.33780894e-02f, -2.30537262e-02f, -5.72304130e-02f, 8.27821344e-03f,
  -3.44540253e-02f, -6.32550269e-02f, -7.42046610e-02f, -6.73334002e-02f, 3.02887689e-02f, -8.26839805e-02f, 5.34533076e-02f, 8.63541104e-03f, -2.30854992e-02f, -8.82870238e-03f,
  -4.38530818e-02f, -2.04138793e-02f, -7.95634985e-02f, 3.15155983e-02f, -6.27274141e-02f, -1.07401758e-02f, 2.24976465e-02f, 2.18312237e-02f, 8.87282416e-02f, -4.34609354e-02f,
  -1.47014275e-01f, -1.42667875e-01f, 1.02237292e-01f, -2.51482744e-02f, 5.58771379e-02f, -9.78575200e-02f, -5.73832542e-03f, 8.66990685e-02f, 1.16835851e-02f, -1.31645482e-02f,
  -2.00081593e-03f, -5.79329506e-02f, -1.18795186e-01f, 5.16487025e-02f, 8.39309487e-03f, -8.75090063e-02f, -3.92502286e-02f, -1.82564966e-02f, -6.11181445e-02f, -5.14482744e-02f,
  -4.97493856e-02f, 2.12460756e-02f, -5.08344267e-03f, 5.45016974e-02f, -1.00765720e-01f, -1.02733597e-01f, -8.65567103e-02f, 1.13716023e-02f, 1.13847409e-03f, 4.15297896e-02f,
  2.18570322e-01f, -1.90479800e-01f, -1.12096488e-01f, -1.10587068e-01f, 7.42488801e-02f, -2.97287613e-01f, -1.90636769e-01f, 1.73025541e-02f, 1.95857212e-02f, -1.48678482e-01f,
  -7.18127415e-02f, -6.49213269e-02f, -6.88315779e-02f, -2.64326572e-01f, -1.06427766e-01f, -1.09525941e-01f, -1.56240806e-01f, -5.18190749e-02f, -4.00464535e-02f, 4.47506644e-02f,
  5.43965660e-02f, -9.85109154e-03f, -7.27456138e-02f, 4.09511179e-02f, 2.50559486e-02f, 6.30504265e-02f, 2.18425423e-01f, 5.27481921e-02f, -9.44852736e-03f, -7.31075481e-02f,
  -1.22288942e-01f, 5.09920716e-03f, -8.89660604e-03f, -1.23349316e-01f, 3.91456969e-02f, 8.95547774e-03f, -7.66979018e-03f, 9.26840771e-03f, -3.67096849e-02f, -4.99751009e-02f,
  -2.76021138e-02f, -2.11154390e-02f, -8.13323073e-03f, -4.52085137e-02f, -4.47147526e-02f, -1.95046384e-02f, 4.91536222e-02f, 3.99450219e-04f, -2.37314054e-03f, -1.00983143e-01f,
  -5.32526672e-02f, -5.18640270e-03f, 6.24993164e-03f, -8.13006684e-02f, 4.65421528e-02f, -4.20458242e-02f, -5.15195355e-02f, -3.58970724e-02f, 2.01673545e-02f, -4.53976952e-02f,
  -3.07064131e-02f, -9.40728094e-03f, -5.80725074e-02f, -5.93770519e-02f, -4.54248525e-02f, 1.83184855e-02f, -1.01987999e-02f, 1.97316129e-02f, 3.10689285e-02f, -5.94913401e-02f,
  3.85993309e-02f, -4.69783247e-02f, 3.35205682e-02f, -9.42108594e-03f, 4.51967716e-02f, -2.67243944e-02f, 8.54299664e-02f, -3.39642987e-02f, 5.06341606e-02f, 5.72790541e-02f,
  1.32077280e-02f, -4.89566661e-03f, -3.66732292e-02f, 4.60608490e-02f, -8.27413052e-02f, -2.52741836e-02f, -2.63047535e-02f, -8.63100365e-02f, 6.17739419e-03f, 2.74657551e-02f,
  -3.37065570e-02f, 4.80752997e-02f, 1.61804035e-02f, -2.71404237e-02f, -4.27822322e-02f, 3.59172327e-03f, 3.33543308e-02f, -3.24339941e-02f, 1.61223114e-02f, 8.68710596e-03f,
  3.80455814e-02f, 5.65369911e-02f, -1.77256595e-02f, 8.83324258e-03f, 1.01379026e-02f, -3.72123607e-02f, -3.80277224e-02f, -1.70581900e-02f, -3.40839848e-03f, 7.57086799e-02f,
  9.05731171e-02f, -2.05078013e-02f, -1.33710578e-02f, 4.69443612e-02f, -1.74007826e-02f, -4.92033362e-02f, 4.29734997e-02f, 5.38114756e-02f, -2.45110188e-02f, -1.05866697e-02f,
  -6.72975183e-02f, -1.51056454e-01f, -3.27785879e-01f, -5.80578810e-03f, -6.07792959e-02f, -2.44367365e-02f, 3.18243960e-03f, 8.67704954e-03f, -2.22724050e-01f, 1.15082441e-02f,
  9.75627974e-02f, -2.65311092e-01f, -7.92252943e-02f, 9.93388221e-02f, 4.43392545e-02f, -1.31868273e-01f, 4.77982350e-02f, -9.08490550e-03f, -6.87236637e-02f, -5.60971610e-02f,
  6.83994517e-02f, 1.27497450e-01f, 6.52864277e-02f, 9.05208141e-02f, -2.66260505e-02f, -7.46489465e-02f, 2.18338698e-01f, -3.83843854e-02f, 6.93551376e-02f, -4.23760340e-03f,
  1.82936061e-02f, -7.52086043e-02f, 1.07047908e-01f, 7.91832656e-02f, 3.01541276e-02f, 4.68085669e-02f, -3.21086310e-02f, 4.44140397e-02f, -2.53518336e-02f, 1.13420943e-02f,
  -5.62062785e-02f, -6.64994791e-02f, 1.55415004e-02f, -7.16806436e-03f, -1.46198487e-02f, -3.88535298e-02f, -2.35110335e-02f, -3.57712880e-02f, 1.04410993e-03f, -7.27467751e-03f,
  4.18668799e-02f, -3.54611874e-02f, 2.91832518e-02f, -8.35871398e-02f, -3.32146604e-03f, 2.31709108e-02f, 2.23638546e-02f, -1.24030203e-01f, 4.28843535e-02f, 8.04962683e-03f,
  5.25045358e-02f, -2.42961198e-02f, -3.89233674e-03f, 5.37403636e-02f, -4.69434410e-02f, 8.14567730e-02f, -3.47223766e-02f, 3.45837176e-02f, -8.25113244e-03f, -5.41267730e-02f,
  6.58720657e-02f, -5.25624631e-03f, -1.11705409e-02f, -3.45454328e-02f, 3.99373705e-03f, -5.09282053e-02f, -1.31972302e-02f, -8.58840626e-03f, -4.00876775e-02f, -2.87107285e-02f,
  -2.62138378e-02f, 4.61106151e-02f, 3.09443213e-02f, 4.23435085e-02f, 1.19161438e-02f, 1.80493307e-03f, -4.59778879e-04f, -8.49456415e-02f, -3.25387195e-02f, -1.31846929e-03f,
  1.62746310e-01f, 1.21560454e-01f, 6.71436414e-02f, 8.28753039e-02f, 1.72229595e-02f, 7.10912570e-02f, -5.20069599e-02f, 3.29675563e-02f, -7.02077290e-04f, -4.79220646e-03f,
  -4.42126952e-02f, 1.06294136e-02f, 4.10553589e-02f, -8.47061202e-02f, -4.22767363e-03f, 5.40981740e-02f, 2.20253714e-03f, 5.56894690e-02f, 1.08594328e-01f, -1.58951506e-02f,
  1.01783536e-01f, 6.41112104e-02f, 1.75785534e-02f, 5.75568713e-02f, -1.44676387e-03f, 6.53576478e-02f, 3.14217922e-03f, -5.74135184e-02f, -1.91823039e-02f, -3.96602750e-02f,
  -2.06127599e-01f, -9.52607021e-02f, -1.58720538e-02f, -1.71164975e-01f, -8.91594738e-02f, -8.09273217e-03f, 1.12055391e-01f, -5.17325029e-02f, -6.85391277e-02f, 7.74187595e-02f,
  4.36996408e-02f, -1.23457566e-01f, 6.11447319e-02f, -1.24035656e-01f, -8.78070444e-02f, 7.28083774e-02f, -1.68376826e-02f, -2.67116148e-02f, 4.89826361e-03f, -1.30271226e-01f,
  5.95137593e-04f, -9.04291570e-02f, 2.55295839e-02f, 4.88022268e-02f, -9.00391191e-02f, 1.18804742e-02f, 6.15194179e-02f, 1.30356416e-01f, -7.55128860e-02f, 6.70486391e-02f,
  5.22245988e-02f, 1.86945759e-02f, -4.45135571e-02f, -1.14671246e-03f, 2.65805200e-02f, 5.93670160e-02f, 7.38045871e-02f, 8.73469636e-02f, -8.64587910e-03f, -1.38052702e-02f,
  7.44428709e-02f, -8.17615837e-02f, 2.90600862e-03f, 1.31009929e-02f, 1.63274482e-02f, -2.38538496e-02f, -1.19234994e-02f, -5.84187992e-02f, 4.03914079e-02f, -5.53966649e-02f,
  -6.06440566e-02f, -4.20310609e-02f, -2.25887056e-02f, 5.37043028e-02f, -2.93213874e-02f, 1.32290004e-02f, -3.83146703e-02f, -8.39201137e-02f, 2.90219821e-02f, -8.45939368e-02f,
  -1.58304442e-02f, -3.82515718e-03f, 6.82354271e-02f, 2.25396454e-02f, -5.07394932e-02f, 3.78742740e-02f, 5.77940829e-02f, 6.81755459e-03f, 4.61846441e-02f, -1.77474488e-02f,
  -9.05223861e-02f, -1.37977721e-02f, 3.56209185e-03f, 1.85851958e-02f, -9.73957703e-02f, -2.71078609e-02f, 6.21021586e-03f, -4.76498716e-02f, 3.44956778e-02f, 3.23349312e-02f,
  5.02270497e-02f, 9.32081137e-03f, -1.61161274e-02f, 3.99006903e-02f, -5.24819158e-02f, -1.10832660e-03f, -3.11990362e-02f, 2.30336860e-02f, -3.41445245e-02f, 7.04357624e-02f,
  -8.18212926e-02f, 5.24989851e-02f, -3.12705263e-02f, 2.25648545e-02f, 8.70004967e-02f, 6.39030486e-02f, 6.11469485e-02f, 1.16288308e-02f, 1.69040747e-02f, 2.92610992e-02f,
  -4.78396676e-02f, 3.26362923e-02f, 1.66102313e-02f, -4.71243188e-02f, 2.07011718e-02f, -2.85831187e-02f, -6.39897808e-02f, 5.22188321e-02f, 1.37177873e-02f, -6.98468182e-03f,
  -5.89538179e-03f, -6.03614263e-02f, 1.61078069e-02f, -7.77346864e-02f, -2.26760772e-03f, 5.49843460e-02f, -5.64900562e-02f, 5.13112813e-04f, 3.56518873e-03f, 6.85815737e-02f,
  -1.35902479e-01f, 4.55575436e-02f, 9.06202495e-02f, -4.90697622e-02f, 8.49912167e-02f, 6.26049042e-02f, 3.08211171e-03f, -8.38110223e-02f, 1.58772737e-01f, -1.21887736e-01f,
  -1.70282751e-01f, 9.74344239e-02f, 6.51868805e-02f, -3.42703471e-03f, -9.34124291e-02f, 8.64314958e-02f, -1.17316917e-02f, -8.74639228e-02f, 1.24084614e-01f, 2.13581249e-02f,
  -3.89624424e-02f, -6.13970077e-03f, 7.77257159e-02f, -1.62341949e-02f, -1.96470022e-02f, -1.82938892e-02f, -1.65620714e-01f, 3.80199887e-02f, -5.69729432e-02f, -5.40568046e-02f,
  -9.25530493e-02f, -1.68960005e-01f, -4.48492318e-02f, 5.84534481e-02f, -7.03129545e-02f, -1.12057969e-01f, 1.94244459e-02f, -1.62412357e-02f, 5.44750430e-02f, 5.30560650e-02f,
  9.51410085e-03f, 8.63972027e-03f, 6.30799457e-02f, 6.69936910e-02f, 4.66058515e-02f, 5.23387566e-02f, 8.75659809e-02f, 6.30426109e-02f, 1.94570294e-03f, 6.70122132e-02f,
  3.82300913e-02f, -1.52773485e-02f, -6.67918772e-02f, -6.12406135e-02f, -8.42599571e-02f, 6.73293397e-02f, -4.45509218e-02f, -4.70496677e-02f, 8.79948679e-03f, 4.98389304e-02f,
  -1.79252252e-02f, -4.50085811e-02f, 4.09468077e-03f, 2.65501998e-02f, 2.28456855e-02f, -7.28325099e-02f, -3.69117707e-02f, -2.55289022e-02f, 2.39168014e-02f, -1.61764324e-02f,
  2.43908144e-03f, 3.60900648e-02f, 1.92855764e-02f, -1.35102486e-02f, -4.85374592e-03f, -4.88822442e-03f, 1.65498834e-02f, 4.31471318e-02f, -9.39487945e-03f, -1.60011556e-02f,
  5.22795394e-02f, -1.63711030e-02f, 2.25924561e-03f, 5.03349043e-02f, -2.45663114e-02f, -2.12083571e-02f, 1.77576207e-02f, -4.32756776e-03f, 2.91766226e-02f, -4.90900949e-02f,
  -1.71646595e-01f, -1.18138798e-01f, 5.29152267e-02f, -1.26979155e-02f, 6.97014388e-03f, -3.53482775e-02f, -3.22726145e-02f, 3.65268402e-02f, -1.36736631e-02f, 8.05771947e-02f,
  1.52989943e-02f, -7.83790797e-02f, -9.43275765e-02f, -2.15560198e-02f, -1.55878253e-02f, -1.26909325e-03f, -4.58606146e-03f, -7.57240579e-02f, -6.47154376e-02f, -8.35905299e-02f,
  -1.19408509e-02f, -3.30670066e-02f, 4.38762680e-02f, -5.72967269e-02f, -6.97759464e-02f, -4.85946275e-02f, -8.47743750e-02f, 3.14893499e-02f, -7.10357502e-02f, -5.40786907e-02f
};

// L0_fan_Wp_bar (Shape: 52 x 120)
const int L0_fan_Wp_bar_rows = 52;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  2.12457716e-01f, 3.01680919e-02f, 2.36866280e-01f, 2.55033076e-02f, 9.12404247e-03f, 1.91093728e-01f, 2.04756230e-01f, 7.59667531e-02f, 1.69508010e-01f, -1.57993764e-01f,
  -5.59376664e-02f, 3.39858159e-02f, -1.84999928e-02f, -1.59349918e-01f, 5.59087284e-02f, 4.61011305e-02f, 1.06193557e-01f, -3.21852192e-02f, 1.83969066e-01f, 1.37928888e-01f,
  5.82591854e-02f, -6.68087229e-02f, 3.58746164e-02f, -1.02381974e-01f, 4.73327823e-02f, -8.36101919e-02f, -2.02845231e-01f, 3.13625559e-02f, -1.77158505e-01f, -5.13508655e-02f,
  8.41164887e-02f, 9.00158435e-02f, -2.39752922e-02f, -7.72998631e-02f, -3.34878005e-02f, 3.92799340e-02f, -6.25588894e-02f, -2.13670619e-02f, 1.35474431e-03f, 4.58154269e-02f,
  -3.59743312e-02f, -7.39615783e-02f, 4.31003980e-02f, 1.19585311e-03f, 3.80102657e-02f, 4.95715775e-02f, 1.04731172e-01f, 1.01080537e-01f, 3.77213992e-02f, 1.06906116e-01f,
  1.06579296e-01f, -4.16722186e-02f, 3.22730392e-02f, -1.54899374e-01f, -2.45027356e-02f, 5.46639524e-02f, 6.59513474e-02f, -8.81391987e-02f, -4.67575788e-02f, 4.08520773e-02f,
  -4.86907251e-02f, 4.18010056e-02f, 2.22914037e-03f, -5.86872397e-04f, -4.25262786e-02f, -9.17179734e-02f, 7.87013099e-02f, 4.87919971e-02f, 6.38841689e-02f, -1.01561502e-01f,
  -9.84004233e-03f, 1.11025898e-02f, 8.45268816e-02f, -4.75146770e-02f, 3.83567698e-02f, -1.05650416e-02f, -8.86693075e-02f, -1.34913221e-01f, 4.14673276e-02f, 1.19063713e-01f,
  2.85593756e-02f, 5.77449463e-02f, 1.01724481e-02f, -4.16273288e-02f, -4.11094129e-02f, 5.81771061e-02f, -8.38158876e-02f, -4.58301641e-02f, -4.41975147e-02f, -4.38029179e-03f,
  -9.03436840e-02f, 2.59870733e-03f, -3.02351154e-02f, 1.77661784e-03f, 2.25938428e-02f, 9.52600688e-03f, 5.62877655e-02f, -2.41892599e-02f, 2.75693070e-02f, -7.97215924e-02f,
  6.07445315e-02f, -6.95322156e-02f, 7.07721338e-02f, -3.85069922e-02f, 7.03190491e-02f, 2.91289226e-03f, -1.58958286e-02f, 5.67793585e-02f, 6.04524575e-02f, -3.24111469e-02f,
  -3.02445777e-02f, 1.86190493e-02f, -4.35506925e-02f, -6.11776337e-02f, 2.66070962e-02f, -1.18948989e-01f, -7.92402029e-02f, -8.41794163e-03f, -1.28440531e-02f, 7.82530531e-02f,
  -3.85402977e-01f, 6.08039796e-02f, 7.98957050e-02f, -1.67519301e-01f, -9.77656320e-02f, 1.51105538e-01f, 8.38151500e-02f, -8.13744366e-02f, -2.02167436e-01f, -1.30490780e-01f,
  -1.68978438e-01f, -9.33447629e-02f, 1.85043350e-01f, 1.27488477e-02f, 1.93547994e-01f, 8.66273269e-02f, -7.53312092e-03f, 7.73077533e-02f, 3.29541564e-02f, 2.51681749e-02f,
  -3.45371738e-02f, -1.22634038e-01f, 1.66329756e-01f, -3.68086807e-02f, 2.13365350e-03f, -9.16955173e-02f, -9.17224139e-02f, 1.89857688e-02f, -7.80610889e-02f, -7.31208846e-02f,
  -1.63962260e-01f, -2.78775394e-01f, -1.51810693e-02f, -7.04170093e-02f, -9.11675543e-02f, -3.95735092e-02f, 3.18259932e-02f, 9.48422700e-02f, -4.51022610e-02f, 9.88097265e-02f,
  -3.29232551e-02f, -8.35892558e-02f, 8.02519731e-03f, 7.48488083e-02f, -4.09857370e-03f, -6.19961433e-02f, -3.03800516e-02f, 4.69981506e-02f, -4.16232646e-02f, 8.22929516e-02f,
  3.33445966e-02f, 6.14184774e-02f, 4.03815545e-02f, 6.35808706e-02f, 1.42345661e-02f, -8.25373754e-02f, 2.54178885e-02f, 1.77380326e-03f, -1.80378072e-02f, -2.07311586e-02f,
  -3.76359932e-02f, -7.29999244e-02f, -1.15560696e-01f, -4.76806350e-02f, 1.91530548e-02f, -1.72451865e-02f, -3.47354449e-02f, 1.60126723e-02f, -3.27587388e-02f, -1.64678171e-02f,
  -7.18248682e-03f, -1.09265022e-01f, -6.54472606e-05f, 6.83265403e-02f, -2.65744142e-02f, 7.32782530e-03f, 4.93797660e-02f, -8.04778934e-02f, 1.18602090e-01f, -1.22048333e-02f,
  4.65647057e-02f, 2.41362699e-03f, -5.50601690e-04f, -4.53038067e-02f, -9.18805897e-02f, 7.07799196e-02f, 7.39236251e-02f, -2.68027745e-02f, 9.44796763e-03f, 3.64342667e-02f,
  -2.20015943e-01f, -2.51374841e-01f, -9.06784087e-02f, -1.60055801e-01f, 6.05160519e-02f, 2.29576044e-02f, 6.67614676e-03f, 4.68446612e-02f, -5.10401651e-02f, -1.03396058e-01f,
  -3.30039002e-02f, -2.79332441e-03f, -6.67614639e-02f, -5.25898486e-02f, 1.36999384e-01f, -5.95317520e-02f, 1.92457978e-02f, -1.08619733e-02f, -3.21598984e-02f, -9.09392908e-02f,
  7.60973096e-02f, 5.94826341e-02f, -3.97609733e-03f, 9.37169231e-03f, -5.36405183e-02f, -7.96049237e-02f, -2.50576530e-02f, -3.27199586e-02f, -7.61848539e-02f, -2.92839427e-02f,
  -3.31034869e-01f, 2.40196377e-01f, -5.21509200e-02f, 1.81112140e-01f, -1.58115789e-01f, -1.39714733e-01f, 3.18295769e-02f, 9.44275409e-02f, -3.92325707e-02f, 2.09205806e-01f,
  1.56857491e-01f, -7.40392657e-04f, 1.10102795e-01f, 2.23038867e-01f, -1.54491082e-01f, 3.51044275e-02f, 1.77478909e-01f, 3.61668654e-02f, -5.53081594e-02f, 4.78652865e-02f,
  -1.73758604e-02f, 9.12574381e-02f, 1.26909748e-01f, -3.87327820e-02f, -3.81674767e-02f, -5.95412850e-02f, 1.28043443e-01f, -2.64611784e-02f, 6.09219223e-02f, -8.48455261e-03f,
  -1.22259304e-01f, 3.36971134e-02f, -2.09099762e-02f, -6.25948235e-02f, -1.12028308e-01f, -6.69481903e-02f, -1.02205351e-01f, -3.92438769e-02f, -4.77885418e-02f, 6.10624105e-02f,
  -1.45246580e-01f, 4.95515298e-03f, 4.83745821e-02f, 2.67805830e-02f, 8.95104650e-03f, 4.41322997e-02f, 5.30019542e-03f, -1.20341182e-02f, 1.50593501e-02f, -5.90200126e-02f,
  -5.51439933e-02f, 2.53956928e-03f, 2.12430451e-02f, -3.22251096e-02f, -2.91244965e-02f, -2.77535822e-02f, 4.00104709e-02f, -1.00674080e-02f, -2.21521296e-02f, 1.13103921e-02f,
  -1.06897861e-01f, 1.07420579e-01f, 7.90650863e-03f, -3.16533037e-02f, 4.87676188e-02f, -4.23019938e-02f, 4.47483808e-02f, 9.48637084e-04f, -4.38879207e-02f, 4.42692749e-02f,
  4.79860082e-02f, 4.73135896e-02f, 4.95551601e-02f, 4.14151065e-02f, 8.46584514e-02f, 6.35993630e-02f, 2.03924943e-02f, 7.23341778e-02f, -1.64492019e-02f, -1.19931074e-02f,
  -2.04986166e-02f, -1.70747247e-02f, -6.11854196e-02f, -5.85257076e-02f, 8.01054686e-02f, -5.30124865e-02f, 3.94919468e-03f, -1.19205834e-02f, 5.06686568e-02f, 4.59393300e-02f,
  1.13823459e-01f, 1.73151389e-01f, -4.52113375e-02f, -9.08477381e-02f, 2.88061276e-02f, -1.09995678e-01f, 2.00387537e-02f, 5.74107207e-02f, 3.78450863e-02f, 2.38663107e-02f,
  -6.30870983e-02f, 6.40284494e-02f, -6.93717822e-02f, 4.45676818e-02f, -2.38687973e-02f, 3.88165680e-03f, 3.15933898e-02f, -7.32945129e-02f, -2.96270009e-02f, -5.25762774e-02f,
  4.18112576e-02f, -5.84822185e-02f, -3.53331566e-02f, 7.59643465e-02f, 6.13887459e-02f, -9.81344003e-03f, -1.11366645e-01f, -9.68712568e-02f, -1.09604262e-01f, 6.61653578e-02f,
  -1.39526770e-01f, -1.59518465e-01f, 1.82124496e-01f, -1.85576797e-01f, 1.94273870e-02f, 8.38396177e-02f, 1.37361631e-01f, -6.85971752e-02f, -1.18433133e-01f, -1.58630475e-01f,
  -6.60710111e-02f, 1.00245968e-01f, 1.00073680e-01f, -1.51490599e-01f, 2.95146376e-01f, 1.05270982e-01f, -1.29475579e-01f, 2.63434555e-03f, -1.20071948e-01f, -1.09620117e-01f,
  -7.97807723e-02f, -2.11361602e-01f, 5.08824140e-02f, -1.77854419e-01f, -6.39067069e-02f, -5.07708304e-02f, -5.13882674e-02f, -1.39704095e-02f, -7.37833306e-02f, -3.44835706e-02f,
  2.79677031e-03f, -3.86959910e-02f, 6.52004629e-02f, 9.06979442e-02f, -3.60612608e-02f, 2.93812696e-02f, -1.00884521e-02f, 8.97413269e-02f, -5.97707089e-03f, 7.00425953e-02f,
  -2.83822659e-02f, -5.76827824e-02f, -3.28573287e-02f, -4.85822745e-02f, -9.87242833e-02f, -2.92636035e-03f, 4.27387375e-03f, -3.06839403e-02f, -3.12382192e-03f, -3.98150235e-02f,
  6.96715266e-02f, 5.53994700e-02f, 5.80316447e-02f, -8.57183412e-02f, -9.84235853e-03f, -5.25723398e-02f, 3.18696983e-02f, 2.36132946e-02f, 2.89772935e-02f, -1.03784926e-01f,
  -3.19277984e-03f, -3.31537426e-03f, 5.88861220e-02f, -4.82011139e-02f, 4.89957221e-02f, -1.29801705e-01f, 6.92465380e-02f, -1.12544395e-01f, -3.46635319e-02f, -2.52820570e-02f,
  -1.08751968e-01f, -7.30410591e-02f, 1.37086085e-03f, 9.11231525e-03f, -1.42202109e-01f, 5.06908484e-02f, -4.06757258e-02f, -1.17514394e-01f, -2.86487732e-02f, -2.35760417e-02f,
  8.58045928e-03f, 3.66451517e-02f, -6.61475584e-02f, -6.01965142e-03f, -1.73641797e-02f, 9.60210264e-02f, -6.15115650e-02f, 8.91843066e-03f, -3.38321142e-02f, -4.22135033e-02f,
  8.13336894e-02f, -1.01482719e-01f, 1.50150126e-02f, 4.57715169e-02f, -2.91947015e-02f, 1.21691592e-01f, -6.96633430e-03f, 1.55826602e-02f, -3.04762218e-02f, 1.66881010e-02f,
  -6.20611720e-02f, 5.65746389e-02f, -2.71783434e-02f, -2.69503295e-02f, 7.80752720e-03f, 3.26103158e-02f, 6.75986409e-02f, 5.90746701e-02f, 1.67129207e-02f, -2.42741667e-02f,
  -8.78181458e-02f, -3.14652994e-02f, -7.88186118e-02f, -1.19138800e-01f, -1.57209337e-02f, -6.92241266e-02f, 5.11852205e-02f, 8.38355124e-02f, -3.00177149e-02f, -7.57932663e-02f,
  -5.02434187e-02f, 1.42960832e-01f, 1.27856314e-01f, -1.31518543e-01f, 1.64556578e-01f, -1.29275277e-01f, -8.36906359e-02f, 9.98639092e-02f, -2.11608544e-01f, 1.27758920e-01f,
  -1.37071431e-01f, 9.29507390e-02f, -2.56714039e-02f, -1.81287199e-01f, -3.17907363e-01f, -2.66492367e-01f, -2.78600305e-01f, -1.21773422e-01f, -2.86740791e-02f, 8.03375468e-02f,
  -1.56287327e-01f, -2.14966938e-01f, -1.47047937e-01f, 9.61506516e-02f, 1.20739982e-01f, 2.28326589e-01f, 9.63328704e-02f, 9.96003672e-02f, 9.39128622e-02f, -5.70373796e-02f,
  -1.05855919e-01f, -4.51995656e-02f, 6.10469580e-02f, 6.01841658e-02f, 8.05101469e-02f, 1.36749208e-01f, 1.08762659e-01f, -4.15549092e-02f, -6.87664002e-02f, 1.01231076e-01f,
  -2.63416837e-03f, -5.22699989e-02f, -3.74856452e-03f, 1.67009756e-02f, 2.55472865e-02f, 1.20666705e-01f, 1.10792205e-01f, 1.39556490e-02f, 3.14571783e-02f, 4.03692871e-02f,
  -1.03250640e-02f, 8.36830139e-02f, 1.29412025e-01f, 2.29824407e-04f, -7.59779811e-02f, 2.51954980e-02f, -1.83218606e-02f, -2.43628491e-02f, 5.78160922e-04f, -2.05720998e-02f,
  4.77493246e-04f, 4.13043164e-02f, -8.62952620e-02f, 4.46183421e-02f, -2.02614702e-02f, -7.67251104e-02f, 1.75177213e-02f, 9.27561074e-02f, 3.70257627e-03f, 9.25565064e-02f,
  -1.15886033e-02f, 4.86139096e-02f, -5.91483957e-04f, -4.32707407e-02f, -6.47448003e-02f, 4.56560217e-02f, 9.56881344e-02f, -2.93727163e-02f, 5.53239211e-02f, -5.11433817e-02f,
  -4.73676994e-02f, 1.49487741e-02f, -2.01841677e-03f, 9.79755297e-02f, 4.70694248e-03f, -3.82697433e-02f, -1.92072950e-02f, -4.12108526e-02f, -3.51393633e-02f, -7.86777493e-03f,
  -2.98589114e-02f, -6.24370165e-02f, -3.15920599e-02f, -3.48240510e-02f, 8.06189701e-02f, 4.17793207e-02f, 2.95863574e-04f, 8.71789455e-02f, 8.92973691e-03f, 5.22023439e-02f,
  1.21815257e-01f, 1.21249147e-01f, 4.94248830e-02f, 4.66930084e-02f, 3.22568975e-02f, -7.73829445e-02f, -5.25924889e-03f, 6.07154295e-02f, 5.83838932e-02f, 1.55857820e-02f,
  1.39775187e-01f, 7.86773302e-03f, 1.97282620e-03f, -1.30900806e-02f, 3.30847912e-02f, 3.29882279e-02f, 1.26006588e-01f, 3.01604010e-02f, -7.18166772e-03f, 2.81873662e-02f,
  -6.54743612e-02f, 2.69910917e-02f, 1.86590443e-03f, -1.21018857e-01f, -2.96507720e-02f, -1.35730729e-01f, -8.34461376e-02f, -1.51721194e-01f, -1.80517025e-02f, -1.72400735e-02f,
  -5.05638756e-02f, 1.25508234e-01f, 1.50474180e-02f, 3.32527943e-02f, 7.34002814e-02f, 1.66227788e-01f, -4.79823425e-02f, -9.70292166e-02f, -8.92105997e-02f, -1.96460962e-01f,
  5.37780225e-02f, -8.61937851e-02f, 9.17463526e-02f, -6.87033758e-02f, -1.89594328e-02f, -6.63442090e-02f, -4.66122199e-03f, 1.10610919e-02f, -7.36499801e-02f, 6.81003258e-02f,
  -1.01139709e-01f, -2.07616255e-01f, -2.12386623e-01f, -1.28675550e-01f, -8.41085762e-02f, -8.62265527e-02f, 4.78360598e-05f, 4.93681580e-02f, -6.08076081e-02f, -6.32767528e-02f,
  6.22430071e-02f, 1.26626622e-02f, -6.44970462e-02f, -3.52124460e-02f, -9.18494165e-02f, -4.63635251e-02f, 2.48778332e-03f, 3.98090854e-03f, -5.59647679e-02f, -3.39514352e-02f,
  -2.97654439e-02f, -2.46590208e-02f, 1.51527915e-02f, 8.79185554e-03f, 2.90302141e-03f, -9.14925486e-02f, -1.40255387e-03f, -3.70743908e-02f, 5.25428839e-02f, -3.17791700e-02f,
  -6.40773624e-02f, -6.24142736e-02f, -8.93892162e-03f, -6.59753606e-02f, -2.25991663e-03f, 7.12725446e-02f, -9.48136598e-02f, -7.23410174e-02f, 4.95355614e-02f, 2.73079351e-02f,
  5.06114550e-02f, 2.21083537e-02f, -1.24445692e-01f, -6.45896271e-02f, -2.18347926e-02f, -1.52991503e-03f, -2.20629387e-02f, -2.27585845e-02f, 1.61156263e-02f, 1.43778240e-02f,
  -2.39406619e-02f, -6.63333535e-02f, 1.24359891e-01f, -7.33465031e-02f, 2.75532547e-02f, -4.34670672e-02f, 2.80038957e-02f, -1.75782654e-03f, 1.98010709e-02f, -3.01728919e-02f,
  -1.01031490e-01f, -2.42532253e-01f, -2.55445242e-02f, -1.07099354e-01f, 2.80635413e-02f, -5.84950335e-02f, -5.77225201e-02f, -1.17554784e-01f, -1.02450974e-01f, -2.17407551e-02f,
  -9.09494534e-02f, -1.39219202e-02f, 6.45515323e-02f, -5.03131095e-03f, 1.33407593e-01f, -5.92309143e-03f, 2.36626416e-02f, 2.52703950e-02f, -1.04280159e-01f, 3.08264308e-02f,
  4.61776182e-02f, 1.17636591e-01f, 1.20630078e-02f, 8.65677558e-03f, -6.34988025e-02f, -7.63969794e-02f, 1.12728635e-02f, 5.89547753e-02f, -6.80964291e-02f, 7.86700398e-02f,
  2.07098927e-02f, -1.31560555e-02f, 1.56549141e-01f, -6.32173344e-02f, 9.97749716e-02f, 8.72240290e-02f, -7.69447116e-03f, -2.64846254e-02f, 1.98261634e-01f, -1.22653969e-01f,
  -9.41721201e-02f, -2.05514580e-02f, 5.67466654e-02f, -2.08593845e-01f, 1.08868532e-01f, 1.09608108e-02f, -7.62343258e-02f, -6.11314848e-02f, 1.53095052e-01f, 4.49570157e-02f,
  5.29999137e-02f, -1.25269160e-01f, 1.22401202e-02f, 6.02092370e-02f, -6.82887286e-02f, -4.50227670e-02f, -1.13753133e-01f, 1.26801774e-01f, -1.31651387e-01f, -2.29804292e-02f,
  -5.42327464e-02f, 1.25598148e-01f, 5.04363924e-02f, -2.39700135e-02f, -1.30889699e-01f, -2.38824543e-02f, -4.77520302e-02f, 4.53677438e-02f, -9.13030505e-02f, 4.47126031e-02f,
  -1.26479715e-01f, -1.95395723e-02f, -1.44602042e-02f, 9.30482075e-02f, 2.77120825e-02f, 8.78641009e-02f, 2.75022388e-02f, -6.54808655e-02f, 9.81945917e-02f, 1.46551207e-01f,
  1.54814407e-01f, -1.22847371e-02f, -5.65955378e-02f, 2.55612144e-03f, 3.51421461e-02f, -5.38248122e-02f, -8.69839936e-02f, -7.98673332e-02f, 2.44338084e-02f, -5.55608720e-02f,
  1.15793347e-01f, -1.20926676e-02f, 9.90213268e-03f, 5.96067235e-02f, 6.56452700e-02f, -2.69195568e-02f, 6.96771070e-02f, 5.01510650e-02f, 1.23045184e-02f, 6.55129775e-02f,
  -1.34126306e-01f, -1.07461400e-02f, -6.79515824e-02f, 4.24830914e-02f, 6.90829903e-02f, -3.87285464e-02f, -5.39475195e-02f, 3.30390073e-02f, -6.53508976e-02f, -1.04097851e-01f,
  7.49336109e-02f, -3.97261642e-02f, 7.91708454e-02f, 1.07897952e-01f, 1.99928377e-02f, 7.99572319e-02f, -8.09527859e-02f, 1.56192943e-01f, -2.39686277e-02f, 1.31618408e-02f,
  -2.44964823e-01f, 1.90333545e-03f, -7.08597302e-02f, 7.92308524e-02f, -8.23049098e-02f, -7.35882819e-02f, -1.82743426e-02f, -5.84412441e-02f, 3.87105830e-02f, 2.47863289e-02f,
  -9.49953273e-02f, -5.90803176e-02f, -4.14640009e-02f, -1.51667409e-02f, 1.09068339e-03f, 3.54329757e-02f, -8.10059234e-02f, -8.82904828e-02f, -1.05083995e-01f, -8.64416808e-02f,
  -3.46532613e-02f, 1.32843247e-02f, 1.56126201e-01f, 4.07934710e-02f, -5.82117736e-02f, -7.70973787e-02f, 6.63347393e-02f, -2.59852558e-02f, 6.25938699e-02f, -1.18809722e-01f,
  3.14722955e-02f, -1.81154773e-01f, 2.13950649e-02f, -3.30142118e-02f, -5.81163727e-02f, -7.45038763e-02f, 2.29929481e-02f, 1.34964949e-02f, 1.87541440e-01f, -1.22564230e-02f,
  4.17639874e-02f, 1.11360662e-01f, 7.53006861e-02f, -1.73604444e-01f, 1.88153937e-01f, 6.98930351e-04f, -2.31386393e-01f, 2.22820137e-02f, -5.87974750e-02f, 3.47929937e-03f,
  2.93379556e-02f, -8.09571370e-02f, -8.74356702e-02f, -9.43026841e-02f, -9.10357311e-02f, 2.52444930e-02f, -1.23435464e-02f, -7.71748424e-02f, -1.38025194e-01f, -8.87779668e-02f,
  -1.77219450e-01f, -9.21025276e-02f, -3.06929257e-02f, 2.26709694e-02f, -1.35788560e-01f, -1.13543622e-01f, -7.19308555e-02f, 9.10520330e-02f, -3.58689316e-02f, -5.02148969e-03f,
  1.20895617e-01f, -6.69550821e-02f, 1.34539502e-02f, 1.19150490e-01f, -3.40993479e-02f, 1.98622439e-02f, 3.36397514e-02f, -5.16947033e-03f, -3.75233702e-02f, 1.17771685e-01f,
  4.66766134e-02f, -1.02665588e-01f, -8.19194615e-02f, 2.92885713e-02f, -2.34358739e-02f, -1.08239837e-01f, 1.25923995e-02f, -3.43735181e-02f, 5.25693111e-02f, -2.50587501e-02f,
  -6.34792820e-02f, -6.27418086e-02f, -4.94984835e-02f, 4.16513458e-02f, -5.53014651e-02f, 5.79644218e-02f, -6.20761737e-02f, -1.69169120e-02f, -8.69330391e-02f, 3.60832252e-02f,
  5.88893257e-02f, 3.18363644e-02f, -1.08462289e-01f, -1.53205851e-02f, -4.39326465e-02f, 8.94594863e-02f, -8.80773738e-02f, -3.67301218e-02f, -7.74588138e-02f, 1.61870569e-02f,
  5.09729274e-02f, 1.47719413e-01f, -1.85549222e-02f, 7.51386732e-02f, -1.65927205e-02f, 4.43460308e-02f, 8.08656663e-02f, 4.11987901e-02f, -8.57518539e-02f, -2.88543710e-03f,
  -1.72389612e-01f, -1.70859382e-01f, -1.04069682e-02f, -7.30092824e-02f, -7.65172988e-02f, -5.68979084e-02f, 7.07335919e-02f, -4.29844782e-02f, -2.50372589e-02f, 3.21280994e-02f,
  -1.17718443e-01f, -2.63885725e-02f, -7.87048042e-02f, -1.05953969e-01f, -5.06737679e-02f, -1.35692582e-02f, 6.07863516e-02f, -1.14345506e-01f, 7.45532382e-03f, -1.49212480e-02f,
  5.11784777e-02f, -8.50847084e-03f, 2.13494319e-02f, -3.39724347e-02f, -2.37189997e-02f, -9.62483510e-02f, 7.14122206e-02f, 6.48105890e-02f, 4.72808490e-03f, 3.74695249e-02f,
  1.18470974e-01f, 1.90617368e-01f, 1.99243903e-01f, 3.67171578e-02f, -1.33988693e-01f, 1.31790131e-01f, 2.13710278e-01f, -9.67645422e-02f, 2.46050090e-01f, -3.88849080e-02f,
  -1.59889102e-01f, 1.81422472e-01f, 1.65423304e-02f, -3.00135259e-02f, 1.83864489e-01f, 9.00644735e-02f, 1.22920193e-01f, 5.08986525e-02f, 2.70499829e-02f, -3.11370231e-02f,
  5.20022027e-02f, -1.64402843e-01f, -1.45707443e-01f, -2.83742577e-01f, -1.29912436e-01f, 2.01976355e-02f, -1.81191653e-01f, -2.27045976e-02f, -1.55049950e-01f, -4.32299115e-02f,
  -4.32925001e-02f, 6.20054640e-03f, -6.14217408e-02f, 7.15134889e-02f, -2.44279299e-02f, -7.19267875e-02f, 4.69958298e-02f, 5.63984737e-02f, -1.29030524e-02f, 1.53446980e-02f,
  5.50461262e-02f, -2.89910082e-02f, 1.34991780e-01f, -6.61183074e-02f, -5.67036681e-02f, 5.10125048e-02f, -1.88672133e-02f, -1.14375494e-01f, -5.64027429e-02f, -3.09768686e-04f,
  5.06793819e-02f, -1.60865095e-02f, 3.95961776e-02f, 6.16387799e-02f, 4.10530381e-02f, -4.38015088e-02f, 7.21349791e-02f, 8.49016309e-02f, 5.57903163e-02f, 1.00157194e-01f,
  -1.41091170e-02f, 1.13343641e-01f, -1.81570370e-02f, -7.59980306e-02f, 7.27118328e-02f, -4.20070551e-02f, -1.42339347e-02f, -1.83765329e-02f, 5.35245240e-02f, -6.60311989e-03f,
  -9.72223177e-04f, 7.29952604e-02f, 8.41550678e-02f, -2.18691933e-03f, -2.93772016e-03f, -3.95830125e-02f, -4.07140749e-03f, 1.34102181e-02f, 9.10182390e-03f, -5.07416204e-02f,
  -8.18674564e-02f, -2.13353336e-02f, 1.10753719e-02f, -8.34674984e-02f, 3.51918675e-02f, 4.37150635e-02f, -5.29411174e-02f, -3.19785923e-02f, 5.08356206e-02f, 1.09255038e-01f,
  5.89295104e-02f, 1.14044368e-01f, 4.33133617e-02f, 2.38059107e-02f, 7.87840188e-02f, -6.83715343e-02f, 4.90270741e-02f, 7.19565675e-02f, 4.42636535e-02f, 3.86919058e-03f,
  -1.95246947e-03f, -3.85044105e-02f, -3.26331109e-02f, 5.73041327e-02f, 1.82771198e-02f, -2.12682951e-02f, 8.29072148e-02f, 5.32684214e-02f, 3.77163179e-02f, 8.91595118e-05f,
  -4.28344756e-02f, 1.99385881e-02f, 9.84010696e-02f, -3.70602719e-02f, -7.12088123e-02f, 6.48044469e-03f, -3.35314944e-02f, 8.31380039e-02f, 2.25544963e-02f, -3.40665951e-02f,
  1.82180181e-01f, 3.86895402e-03f, 3.34829316e-02f, 1.73914537e-01f, -5.19058220e-02f, -1.03638344e-01f, -1.36876523e-01f, 7.98704699e-02f, -1.67584315e-01f, -8.81423503e-02f,
  6.74764141e-02f, 4.03065719e-02f, 9.36178770e-03f, 8.70815292e-02f, 1.36680715e-02f, -7.51274973e-02f, 1.91701185e-02f, -4.87703048e-02f, -3.94909903e-02f, 1.33046150e-01f,
  4.75157946e-02f, 9.93228331e-02f, 4.64209262e-03f, 1.37627691e-01f, 6.72086328e-02f, 1.38456404e-01f, 2.28402972e-01f, -6.65488071e-04f, 3.84312645e-02f, 5.79387359e-02f,
  -3.33132260e-02f, -5.59992269e-02f, -2.73141842e-02f, 4.72150855e-02f, -3.26746590e-02f, 3.38022783e-02f, -2.31493283e-02f, 7.49331340e-02f, 1.06645832e-02f, -1.72384586e-02f,
  -1.03453897e-01f, 1.17608029e-02f, 5.92765287e-02f, -4.15102318e-02f, 3.52315791e-02f, -2.74009481e-02f, -1.94108654e-02f, 1.99622083e-02f, -1.10981368e-01f, -2.51891315e-02f,
  -6.64703082e-03f, 3.25524621e-02f, 1.22989453e-01f, 6.91168085e-02f, 6.62362203e-03f, -8.46354570e-03f, -7.08365962e-02f, -1.08752303e-01f, -1.20000511e-01f, -6.61971280e-03f,
  6.32379726e-02f, -1.01357829e-02f, 3.37825157e-02f, 8.61677006e-02f, -5.69835901e-02f, 4.62334752e-02f, -4.05603200e-02f, 7.51724020e-02f, 4.61361222e-02f, -2.14158893e-02f,
  -7.22744465e-02f, 4.46421281e-02f, 9.72443372e-02f, 5.09264022e-02f, -1.79471280e-02f, 2.67525800e-02f, -4.37799096e-02f, -4.83308546e-02f, 3.69035709e-03f, -1.22428015e-02f,
  -3.75242494e-02f, 2.07975991e-02f, 3.79195772e-02f, 5.70803583e-02f, -1.69115160e-02f, -8.21016505e-02f, 5.20532914e-02f, 3.69628109e-02f, -1.24682844e-01f, -4.13711555e-02f,
  7.73657560e-02f, 4.60020080e-02f, -6.17579632e-02f, 3.21017690e-02f, -5.80222383e-02f, -7.23431110e-02f, 7.88156018e-02f, 3.51847336e-02f, 1.30936578e-01f, 9.85993594e-02f,
  4.04530801e-02f, 4.53323405e-03f, -1.04331030e-02f, 2.16677897e-02f, 1.16165970e-02f, -6.99022040e-02f, 5.95400780e-02f, -1.15941390e-02f, -6.42856583e-02f, 2.39130985e-02f,
  -2.02094167e-02f, -1.02071166e-01f, -4.27558087e-02f, 1.85702834e-02f, -6.41440079e-02f, -4.38455380e-02f, -8.82827118e-03f, 3.46027948e-02f, -2.56616417e-02f, 5.04407324e-02f,
  -1.60869420e-01f, -4.65288945e-03f, -1.65462434e-01f, -6.16520606e-02f, -1.80662841e-01f, 7.02696666e-02f, 4.38803062e-02f, 6.22651204e-02f, -7.71277621e-02f, 3.28299612e-01f,
  2.82728493e-01f, -1.49217680e-01f, 1.65887415e-01f, 1.23021290e-01f, -2.59592146e-01f, 1.06435165e-01f, 1.95567369e-01f, 1.89658254e-01f, -7.39790350e-02f, 8.18891749e-02f,
  -6.15735613e-02f, 1.36598706e-01f, -1.35808304e-01f, -5.32700419e-02f, -6.52011111e-02f, 2.26611532e-02f, 7.45801777e-02f, -1.42204553e-01f, 9.66676325e-02f, -9.49955657e-02f,
  2.56859474e-02f, 1.22489743e-01f, -4.90906611e-02f, 2.44727102e-03f, -3.57798785e-02f, 4.45936136e-02f, -3.23304087e-02f, 3.25409770e-02f, -6.74820319e-02f, -2.54374631e-02f,
  -3.20747681e-02f, -9.37789977e-02f, 1.26654180e-02f, 1.15852868e-02f, -3.45759876e-02f, 4.05597463e-02f, -2.84244213e-02f, -4.61471193e-02f, 3.09558287e-02f, -8.74601528e-02f,
  -9.96459499e-02f, -5.22748493e-02f, 1.07187564e-02f, -4.00822833e-02f, -1.13366015e-01f, -2.64911354e-02f, 4.12094668e-02f, 9.44044720e-03f, -8.22151005e-02f, -5.46259386e-03f,
  -1.05079357e-02f, 8.02277774e-02f, 2.16194820e-02f, 6.71581998e-02f, 4.97548282e-02f, -3.00190691e-02f, 1.70463473e-02f, 1.06682293e-01f, 2.68322136e-02f, 5.69468923e-02f,
  -5.20579256e-02f, -3.90357673e-02f, 4.09616679e-02f, 3.24813463e-02f, 4.34272997e-02f, -4.20344993e-02f, -2.29603797e-02f, -3.50877978e-02f, 4.12098914e-02f, 1.48420883e-02f,
  -6.26386106e-02f, -8.73790756e-02f, 2.19651386e-02f, 9.13766325e-02f, -2.59432793e-02f, 8.72318633e-03f, -1.25558488e-02f, 4.48827958e-03f, -2.49171257e-02f, -1.06104568e-01f,
  8.63754302e-02f, 1.63259521e-01f, 9.18513164e-02f, -4.24309112e-02f, -4.84144129e-02f, 8.92477036e-02f, 7.89317563e-02f, -6.12307191e-02f, -1.96254309e-02f, -1.94940399e-02f,
  -2.30547450e-02f, -3.69406166e-03f, -3.45616266e-02f, -7.69278258e-02f, 3.10764518e-02f, 2.99233384e-02f, 6.97821239e-03f, -1.09553844e-01f, -1.93753336e-02f, -1.23227000e-01f,
  -2.22228244e-02f, 1.10291392e-01f, -1.98847782e-02f, 5.84406443e-02f, -4.54896167e-02f, 3.01945023e-02f, -1.16993934e-01f, 2.98872925e-02f, -4.64721881e-02f, -5.85946031e-02f,
  -9.38157886e-02f, -1.61132365e-01f, -5.31050786e-02f, -4.93318141e-02f, 8.09070766e-02f, -2.76098736e-02f, -1.30803093e-01f, -1.18274935e-01f, -5.56795076e-02f, -1.47587657e-01f,
  -1.26526445e-01f, 1.74425378e-01f, 1.40854076e-01f, -1.54413566e-01f, 3.01187605e-01f, 1.34975940e-01f, -1.29849583e-01f, -1.21323038e-02f, -5.23003079e-02f, -9.59411412e-02f,
  1.65895224e-02f, -1.63045079e-01f, 1.20814599e-01f, -6.06592000e-02f, -7.53759667e-02f, 2.98291352e-02f, 7.87439719e-02f, 2.16444256e-03f, 5.36288954e-02f, 8.70798081e-02f,
  9.46439356e-02f, -2.56358415e-01f, 3.02529093e-02f, 1.52699975e-02f, -5.84065877e-02f, -1.67504307e-02f, 2.86483504e-02f, 1.64793789e-01f, 9.26045235e-03f, -1.53841935e-02f,
  7.76142403e-02f, 4.19140905e-02f, 1.21157141e-02f, -2.34421045e-02f, 3.47449146e-02f, -2.91140880e-02f, 3.03120464e-02f, 8.77748728e-02f, -6.24053665e-02f, -2.35186564e-03f,
  3.18132661e-04f, 8.61969292e-02f, 1.41706802e-02f, -7.94845000e-02f, -2.09777709e-02f, -9.24022570e-02f, 7.91778322e-03f, 2.67387815e-02f, -2.83615999e-02f, -1.03958240e-02f,
  -4.15677130e-02f, 3.01763508e-02f, -7.10561723e-02f, 4.08017598e-02f, -2.50493698e-02f, 1.27445152e-02f, -1.04956090e-01f, -1.99257676e-02f, -6.62405044e-02f, 4.16671112e-02f,
  -8.15399662e-02f, -6.15976788e-02f, 6.23468794e-02f, -8.09674524e-03f, -4.04190418e-04f, 5.13317287e-02f, -1.91580690e-02f, 5.36966659e-02f, -2.64666770e-02f, 1.19682914e-02f,
  -8.47975612e-02f, -4.46113683e-02f, 1.88078340e-02f, 2.84427521e-03f, -9.34122596e-03f, 3.18702161e-02f, -2.85370760e-02f, -2.67596506e-02f, 2.91590337e-02f, 1.28253683e-01f,
  9.54387859e-02f, -2.24730447e-01f, -7.75071979e-02f, -8.31069723e-02f, 6.66337013e-02f, -1.72330928e-03f, 1.03202030e-01f, -6.56506121e-02f, 1.77775286e-02f, -5.52694127e-02f,
  3.18389386e-02f, 1.25882812e-02f, 3.03997565e-02f, 4.93471436e-02f, -5.30951284e-02f, -9.99821424e-02f, -4.82407920e-02f, 5.53358831e-02f, -1.05229534e-01f, -1.21673867e-01f,
  -1.96420960e-02f, -9.10818502e-02f, -3.26244608e-02f, -5.35232425e-02f, -1.83713101e-02f, -1.70438290e-02f, 4.54633012e-02f, -7.54745379e-02f, 1.51325911e-02f, -3.73750255e-02f,
  -6.39997274e-02f, 1.82736039e-01f, 1.29197642e-01f, -1.73414364e-01f, -4.29742940e-04f, 5.49893044e-02f, 8.70349184e-02f, -5.03961258e-02f, 1.08302824e-01f, -1.33290872e-01f,
  5.67757711e-02f, -9.10596475e-02f, 1.07394487e-01f, -1.26851305e-01f, 1.84290588e-01f, 3.22687142e-02f, -3.74495536e-02f, -8.40995610e-02f, 5.49743138e-02f, 3.54188681e-02f,
  2.19793878e-02f, -1.52630508e-01f, 9.15724412e-02f, -1.07969239e-01f, 3.45889042e-04f, 3.86629403e-02f, -1.83478266e-01f, 8.66154805e-02f, -2.32275769e-01f, -3.05141956e-02f,
  9.81005803e-02f, 3.78313251e-02f, 1.13707244e-01f, 7.08602592e-02f, -1.01250894e-02f, -7.85636604e-02f, -2.53893975e-02f, -1.09433029e-02f, 7.30510280e-02f, -7.70488158e-02f,
  7.12755620e-02f, -3.19546387e-02f, 4.77515943e-02f, -5.09605482e-02f, 3.86918224e-02f, 4.86207008e-02f, 6.17248639e-02f, -7.03347614e-03f, 8.87714997e-02f, -1.85439840e-03f,
  -2.13389210e-02f, -6.82873130e-02f, -5.92284948e-02f, -2.13015848e-03f, -1.00921504e-01f, -6.68487698e-02f, 6.78832605e-02f, 1.91668700e-03f, 2.38003451e-02f, 7.90237356e-03f,
  1.64945459e-03f, -2.76727509e-02f, 5.64480424e-02f, -4.89609763e-02f, 5.30660041e-02f, 5.65516390e-02f, -6.86270744e-02f, -5.99530861e-02f, -1.07728265e-01f, -4.15415168e-02f,
  9.26976651e-02f, -1.76489335e-02f, -5.36577255e-02f, 1.71584003e-02f, -8.42082202e-02f, -6.36230484e-02f, -8.00967496e-03f, 3.84655446e-02f, -3.20967659e-02f, -8.26461911e-02f,
  -8.39291289e-02f, -8.54244456e-02f, -8.74289777e-03f, -6.37988979e-03f, -1.20741082e-02f, -3.82592790e-02f, 6.23676321e-03f, -3.77070382e-02f, -1.27101336e-02f, -1.13967858e-01f,
  8.77176523e-02f, -7.99534023e-02f, 1.30820766e-01f, -6.01925179e-02f, 9.63300020e-02f, -1.32940874e-01f, 5.10105789e-02f, 4.87810075e-02f, 1.23606240e-02f, 3.80498916e-02f,
  2.39118487e-02f, 6.60788082e-03f, -5.12593873e-02f, -9.95073617e-02f, -3.54672633e-02f, 1.95234306e-02f, -1.07268244e-01f, -3.34015936e-02f, -9.30006057e-02f, 4.82925437e-02f,
  -8.69434625e-02f, -7.02726766e-02f, 6.67176545e-02f, 9.74715129e-02f, -1.48551241e-01f, 5.50257750e-02f, -4.41582352e-02f, -4.35685331e-04f, 6.03350662e-02f, 2.99590034e-03f,
  -1.51250020e-01f, -8.10104385e-02f, 3.38645577e-02f, -1.28415555e-01f, 1.05905803e-02f, -1.56532243e-01f, -4.91024926e-03f, -1.56281441e-01f, -6.71312362e-02f, -1.91585019e-01f,
  5.28705530e-02f, 1.00718968e-01f, 1.65459231e-01f, -8.09170082e-02f, 2.86635190e-01f, 8.42876732e-02f, -5.25401533e-02f, -1.26624256e-01f, 7.88406655e-02f, -5.01715727e-02f,
  -6.13916516e-02f, -1.95534587e-01f, 9.84498337e-02f, -1.42814115e-01f, -1.09222353e-01f, 2.83582676e-02f, 6.23201132e-02f, -1.70812011e-02f, -1.12791896e-01f, 1.17361940e-01f,
  1.16019063e-02f, -1.58295393e-01f, 8.40162486e-03f, 7.56572094e-03f, -6.47812849e-03f, 1.03690095e-01f, 1.74093638e-02f, 1.11742444e-01f, 8.59504640e-02f, -8.86952728e-02f,
  -4.97857220e-02f, 7.58425519e-03f, -6.14546612e-02f, -4.20327075e-02f, -9.98711511e-02f, -3.46700964e-03f, 6.10806905e-02f, 7.05829486e-02f, -5.83486035e-02f, 8.23173579e-03f,
  4.44884300e-02f, 7.91668221e-02f, -9.00990292e-02f, -3.12048532e-02f, 1.26459882e-01f, -4.39220779e-02f, 6.08866103e-02f, 1.56955689e-01f, -1.30230272e-02f, -1.25297368e-01f,
  3.33446823e-02f, 1.76664382e-01f, -9.98261012e-03f, -8.20591347e-04f, -6.44159168e-02f, -1.39052793e-01f, -8.28832611e-02f, 4.85373437e-02f, 6.48552477e-02f, -9.98969153e-02f,
  3.24875303e-02f, 6.02390543e-02f, 3.08262222e-02f, -2.52804272e-02f, -8.62336755e-02f, -9.38317999e-02f, -3.77969854e-02f, -6.87839165e-02f, 2.12571435e-02f, 1.48623884e-02f,
  -3.12973708e-02f, -1.03484459e-01f, -8.02785065e-03f, 6.53174594e-02f, -1.20023377e-01f, 9.29087996e-02f, -5.23024201e-02f, -1.53408954e-02f, 9.27365422e-02f, 9.03409943e-02f,
  -1.29840389e-01f, -1.17533460e-01f, 1.08857028e-01f, -9.02221631e-03f, 1.99742597e-02f, 8.14622641e-02f, 3.08959130e-02f, -3.42440456e-02f, -1.15823843e-01f, 3.50267887e-02f,
  -8.93613845e-02f, -2.25564949e-02f, -2.33616233e-02f, -7.56337121e-02f, 9.61401463e-02f, 4.67282385e-02f, 6.31723925e-02f, -1.01764217e-01f, -4.63335216e-02f, 8.53813142e-02f,
  -1.14171077e-02f, 7.06054494e-02f, -2.14201789e-02f, 2.20983382e-02f, -5.83102815e-02f, 2.45271921e-02f, 7.14857457e-03f, 1.31539423e-02f, -7.75402412e-03f, 5.45968302e-02f,
  1.35095477e-01f, 6.52986467e-02f, -3.22698914e-02f, 1.67620257e-01f, -1.78101867e-01f, -1.12183809e-01f, -8.44167396e-02f, 2.60618161e-02f, -6.19707666e-02f, 8.17710087e-02f,
  4.12987396e-02f, 1.04983881e-01f, 8.17985237e-02f, 2.15115264e-01f, 8.87815207e-02f, 2.26032268e-03f, 2.71881297e-02f, -7.13773891e-02f, 4.89932857e-02f, 1.68792710e-01f,
  8.92338976e-02f, 1.66255817e-01f, 1.60578206e-01f, -3.18882205e-02f, 4.18063030e-02f, 1.30213192e-02f, 6.72527775e-02f, 1.15650473e-02f, 1.82890385e-01f, 6.09062910e-02f,
  2.70376839e-02f, 7.90178310e-03f, 5.94148114e-02f, -9.59118381e-02f, -5.70962951e-02f, 7.13126585e-02f, 7.34178722e-02f, 6.58161268e-02f, 1.23318443e-02f, 9.02238637e-02f,
  -9.68762040e-02f, -6.01483509e-02f, 3.08159962e-02f, -2.00037174e-02f, 6.60591796e-02f, 7.74967158e-03f, 2.97487807e-02f, -5.20848036e-02f, 7.22613856e-02f, 6.82989359e-02f,
  9.16972850e-03f, 1.87865347e-02f, 2.31658667e-02f, 5.89001849e-02f, -7.02819675e-02f, -5.58840893e-02f, -9.78333689e-03f, 1.92501619e-02f, -2.18489021e-02f, -1.23952841e-02f,
  -4.10096627e-03f, -7.83257186e-02f, 9.25849155e-02f, -4.52636145e-02f, 4.82780337e-02f, 8.07072148e-02f, 1.09277144e-02f, -6.28975332e-02f, -4.76285629e-02f, -4.01840545e-02f,
  6.95512220e-02f, -4.02765535e-02f, 6.02053218e-02f, -5.57954125e-02f, 1.51384339e-01f, -5.21377511e-02f, 2.34415028e-02f, 9.18668360e-02f, -2.64336951e-02f, -4.87062186e-02f,
  -7.43753910e-02f, -3.40530686e-02f, -4.61273007e-02f, -4.94733974e-02f, 2.40039416e-02f, 3.72487344e-02f, 2.21847594e-02f, -3.79794799e-02f, -1.21042706e-01f, 3.50640379e-02f,
  1.05974697e-01f, 2.15641633e-01f, 6.50247931e-02f, -9.80125070e-02f, -2.14261245e-02f, 8.76583830e-02f, 2.50777975e-02f, 8.58756006e-02f, 8.56426451e-03f, 4.35007736e-02f,
  -4.21022177e-02f, 5.22028506e-02f, -5.07330559e-02f, -5.55097796e-02f, 5.46608493e-02f, -6.88437074e-02f, 5.79282157e-02f, 2.31238343e-02f, 9.98277664e-02f, 6.44384548e-02f,
  5.85049950e-02f, 3.42780538e-02f, -1.06471600e-02f, -3.97501513e-02f, 8.03439990e-02f, -4.53048311e-02f, -6.74391687e-02f, 3.97406071e-02f, 1.38286009e-01f, 1.40458103e-02f,
  3.22884172e-01f, -4.00715880e-02f, 1.93301700e-02f, 1.07281551e-01f, 8.64073113e-02f, 9.92508829e-02f, 1.09921239e-01f, -5.71960434e-02f, 1.81088120e-01f, -1.39674291e-01f,
  2.43562646e-02f, 9.69976485e-02f, -1.48731589e-01f, 4.20928821e-02f, 9.86577421e-02f, 5.63901998e-02f, 4.02746946e-02f, -4.82065529e-02f, 2.83585321e-02f, 2.49702334e-02f,
  8.92467350e-02f, -1.25900462e-01f, -7.38306344e-02f, -2.52599001e-01f, 1.44974971e-02f, -3.96512412e-02f, -3.36454920e-02f, -1.15538523e-01f, -1.09795608e-01f, -2.79423818e-02f,
  4.25863126e-03f, 4.52980492e-03f, 3.95562761e-02f, -9.57229175e-03f, 2.29378194e-02f, -3.73195671e-02f, -9.81247500e-02f, 6.76906183e-02f, 1.31436482e-01f, -4.89828689e-03f,
  8.42477381e-03f, -1.18572898e-04f, 6.26505464e-02f, 1.73725337e-02f, 4.30011787e-02f, 2.50930339e-03f, 7.41152763e-02f, -7.06865415e-02f, 6.65850863e-02f, -3.26260440e-02f,
  2.78103002e-03f, -2.77213752e-02f, 1.37011498e-01f, 9.07689333e-02f, 3.97285968e-02f, -5.89837246e-02f, 1.06555648e-01f, 5.94096147e-02f, 1.92057267e-02f, -3.17470171e-02f,
  -8.53283554e-02f, -9.73183066e-02f, 2.42105797e-02f, 4.67565618e-02f, -1.69599913e-02f, 6.27539456e-02f, 4.14192826e-02f, -2.95398813e-02f, -1.28974179e-02f, 3.23423557e-02f,
  -6.87099695e-02f, 7.71828555e-03f, 7.59842619e-02f, -5.41454218e-02f, -8.26362707e-03f, 1.03630424e-02f, 1.29245490e-01f, 7.65018538e-02f, -2.08178386e-02f, -1.10493876e-01f,
  -8.06962699e-03f, -1.74836162e-02f, -6.22543395e-02f, -1.08958289e-01f, 5.09437220e-03f, 7.17923865e-02f, -1.00193016e-01f, -6.58582896e-02f, -8.16370770e-02f, 5.14950901e-02f,
  2.54632775e-02f, -7.87426457e-02f, -1.05190299e-01f, 1.18464557e-02f, -4.01063636e-02f, -1.49051458e-01f, 1.29924819e-01f, 8.70919451e-02f, 1.01881906e-01f, 7.84381256e-02f,
  -2.41534691e-02f, 5.43156415e-02f, 7.07814051e-03f, 2.96613593e-02f, -8.03952441e-02f, 3.24530192e-02f, 7.98940193e-03f, 7.47736096e-02f, 1.05361792e-03f, -6.23991564e-02f,
  -6.06103949e-02f, 7.57617578e-02f, 7.46087776e-03f, 6.12117201e-02f, -3.90259176e-02f, 9.16200206e-02f, 2.87003163e-02f, 7.64784738e-02f, -6.47956803e-02f, -1.88378189e-02f,
  1.39467195e-01f, -1.47213936e-01f, 1.83538079e-01f, 8.57771784e-02f, 1.28073990e-01f, 1.96861222e-01f, 1.94091618e-01f, 1.06823342e-02f, 7.31297433e-02f, -1.18025891e-01f,
  -1.25432596e-01f, -1.41923472e-01f, -1.19095586e-01f, -8.52978528e-02f, 1.19014665e-01f, -1.89643681e-01f, -9.78216249e-03f, -3.97799611e-02f, -4.70093917e-04f, -2.27120575e-02f,
  9.87498388e-02f, 1.01848066e-01f, 1.54668018e-01f, 1.18846260e-01f, 1.46858618e-01f, 1.77545637e-01f, 1.40383184e-01f, 1.43868566e-01f, 2.89204940e-02f, 5.57707027e-02f,
  -5.43509871e-02f, 6.89542145e-02f, -8.95761698e-03f, -9.37099606e-02f, 8.37683380e-02f, -4.70229611e-02f, -3.53520215e-02f, 4.04804274e-02f, 1.97471678e-02f, 5.54547906e-02f,
  -3.41139399e-02f, 9.45147499e-03f, 1.25707507e-01f, 8.84086937e-02f, 6.37632683e-02f, 3.98429111e-02f, 6.83772489e-02f, -2.24747765e-03f, 8.12856294e-03f, 5.89292822e-03f,
  -1.17269337e-01f, 3.12439306e-03f, -5.34782149e-02f, -6.65681511e-02f, 2.57006101e-02f, 1.86538398e-02f, -3.13911997e-02f, -9.34890937e-03f, 4.04957905e-02f, -1.30525641e-02f,
  1.27656579e-01f, 6.62462264e-02f, -4.98030223e-02f, -5.08865267e-02f, -3.81299704e-02f, 4.78745773e-02f, 3.73328999e-02f, -7.18704984e-02f, 3.80491070e-03f, -8.21918435e-03f,
  -3.80589673e-03f, 6.65148124e-02f, -1.16579412e-02f, -9.48448256e-02f, 9.82699320e-02f, -2.34175939e-02f, -5.99515587e-02f, -8.55648294e-02f, 6.35727048e-02f, 7.92455822e-02f,
  1.85068566e-02f, -6.13576025e-02f, -1.07804127e-01f, 6.12161830e-02f, -8.49498585e-02f, 2.97026932e-02f, -1.04725838e-01f, -8.34778473e-02f, 5.55228703e-02f, 7.37438798e-02f,
  -2.80893981e-01f, -2.87434787e-01f, -2.56120004e-02f, -9.01458189e-02f, -2.37631518e-02f, -8.97551924e-02f, 2.14750823e-02f, -4.74895500e-02f, -1.09239798e-02f, -9.90624130e-02f,
  -1.24136798e-01f, -1.55926775e-02f, -7.81488344e-02f, -3.31431814e-02f, -9.94454026e-02f, 3.59345460e-03f, -1.13735199e-01f, -1.29776508e-01f, 3.39464918e-02f, 2.66806632e-02f,
  -6.57425495e-03f, -4.91869710e-02f, 6.41606227e-02f, 6.68678060e-02f, 2.24136412e-02f, 1.30678520e-01f, -6.78169206e-02f, -3.38361599e-02f, -5.43459058e-02f, 2.21754983e-02f,
  -6.98191952e-03f, -1.44280389e-01f, -3.48607674e-02f, -1.91774249e-01f, 5.60313798e-02f, 1.16718514e-02f, -8.25335681e-02f, -1.43577591e-01f, 1.84906923e-04f, -8.39895308e-02f,
  1.11388966e-01f, -2.15854585e-01f, -9.19840112e-03f, -2.13011056e-01f, -1.14830866e-01f, 1.07361414e-01f, -1.12901978e-01f, -4.32979316e-02f, -2.21990757e-02f, -2.97620054e-02f,
  -6.95873797e-02f, 2.28750501e-02f, -2.10684165e-02f, 2.54068691e-02f, -5.64925792e-03f, -1.49074793e-01f, -9.68269408e-02f, -4.50478718e-02f, -1.41794304e-03f, 2.13402398e-02f,
  1.34713191e-04f, 6.30208924e-02f, 1.00637518e-01f, -7.49991760e-02f, 6.46913201e-02f, 1.22440338e-01f, -1.24712743e-01f, -8.56321976e-02f, 5.92148528e-02f, 1.09041572e-01f,
  -1.33322716e-01f, -4.71640527e-02f, -1.52758313e-02f, 8.51728395e-03f, -4.80182804e-02f, 6.30496442e-02f, -2.50589959e-02f, 6.27924204e-02f, -2.04891209e-02f, 3.23106581e-03f,
  -5.28539391e-03f, -9.53486264e-02f, -1.35064855e-01f, -9.84501317e-02f, -2.88948976e-02f, -1.02493718e-01f, -6.86216280e-02f, -1.44191028e-03f, 1.74954478e-02f, 5.85115887e-03f,
  -1.99517831e-02f, -3.35363150e-02f, -3.97405848e-02f, -5.81279099e-02f, 3.90895009e-02f, 9.49887652e-03f, 3.92202958e-02f, -3.08806207e-02f, 4.10438851e-02f, -1.79721985e-03f,
  -8.66926461e-02f, -1.07108623e-01f, -2.62507517e-02f, 3.55573967e-02f, -1.35927955e-02f, -1.07448362e-01f, -5.24080098e-02f, 1.11411987e-02f, -1.58633944e-02f, 9.43404436e-03f,
  -5.06357402e-02f, -6.78750053e-02f, -5.17281368e-02f, -1.31166801e-01f, -9.36159585e-03f, -2.06917699e-04f, 5.48920706e-02f, 6.69443160e-02f, 5.02049103e-02f, -2.21663229e-02f,
  7.76194260e-02f, 3.64818349e-02f, -1.49527323e-02f, 3.74145992e-02f, 5.80378659e-02f, 1.75784621e-02f, -6.23632595e-02f, -1.22970417e-02f, -2.40515899e-02f, -2.36151684e-02f,
  -1.45399734e-01f, -2.44017486e-02f, -7.69243091e-02f, -3.89628001e-02f, 1.80848947e-04f, 6.81383610e-02f, -4.27090153e-02f, -5.76258339e-02f, 4.78207581e-02f, -6.73984215e-02f,
  -2.48157568e-02f, 1.02979746e-02f, 3.46354134e-02f, 6.16897382e-02f, 9.79737565e-02f, -1.22791938e-01f, 1.68547151e-04f, -1.18507721e-01f, -7.25940987e-02f, -1.45084122e-02f,
  6.88776001e-02f, -5.35339788e-02f, -2.15098441e-01f, 1.12613969e-01f, 1.76314682e-01f, 1.91489328e-02f, -6.84786811e-02f, 8.38308334e-02f, -8.27951282e-02f, 1.05463073e-01f,
  7.38861039e-02f, -1.77530706e-01f, -1.99988782e-01f, 3.70333865e-02f, 6.54847547e-02f, -1.77823707e-01f, 2.30932906e-01f, 7.97313526e-02f, -1.04992405e-01f, 2.46367529e-02f,
  4.51888219e-02f, 1.44086763e-01f, -1.04508838e-02f, 1.55309409e-01f, 1.49653956e-01f, -7.66323954e-02f, 1.22538880e-01f, -5.86192161e-02f, 1.29442602e-01f, 6.91849887e-02f,
  3.08358446e-02f, 5.73649406e-02f, -4.86246906e-02f, -2.78399531e-02f, 1.08220667e-01f, 5.71632087e-02f, 4.47926894e-02f, -6.65159598e-02f, 7.23046809e-02f, 2.31408398e-03f,
  1.26360664e-02f, 1.97621230e-02f, -1.35537526e-02f, -3.78528833e-02f, 7.18535483e-02f, 6.01037331e-02f, -2.74915472e-02f, -1.12905420e-01f, 2.79208235e-02f, -5.48511036e-02f,
  -1.03951409e-01f, -9.28760543e-02f, -7.94058759e-03f, 3.41613740e-02f, -3.10137309e-02f, -9.19903517e-02f, -8.04203078e-02f, -7.07983598e-02f, 5.81337996e-02f, -2.49232259e-02f,
  6.02098331e-02f, 3.06567103e-02f, -5.89129552e-02f, -6.46277815e-02f, 2.74584386e-02f, -1.29973069e-02f, 4.63899747e-02f, 4.77583818e-02f, -3.06699295e-02f, 8.78869146e-02f,
  4.54135239e-03f, -7.23266415e-03f, 1.93020049e-02f, 1.42415226e-01f, 1.05086967e-01f, -4.16038372e-02f, 1.36362314e-02f, 5.37042543e-02f, 5.44472225e-02f, -5.54671250e-02f,
  2.25108732e-02f, -4.53865267e-02f, -1.40421037e-02f, -3.79019193e-02f, -2.94436961e-02f, 7.74170784e-03f, 1.04032293e-01f, -5.30144535e-02f, -1.13339715e-01f, -5.77955879e-03f,
  4.85645533e-02f, -1.29973209e-02f, -2.00203806e-02f, 9.71376076e-02f, -5.89121990e-02f, 7.35972449e-03f, 4.06692550e-02f, 1.06556609e-01f, -6.58227354e-02f, -3.56030241e-02f,
  -5.41441217e-02f, -1.00174896e-01f, -5.23085939e-03f, -1.88277662e-03f, 6.23330474e-02f, 6.96010366e-02f, 2.60107759e-02f, 2.46262327e-02f, 9.52196494e-02f, 2.93353293e-02f,
  3.07058208e-02f, -2.42643766e-02f, -6.87124357e-02f, -1.05059318e-01f, -1.55172236e-02f, -7.04269335e-02f, -3.49381790e-02f, -1.06550917e-01f, -1.28182815e-02f, 6.76724315e-02f,
  1.97421759e-01f, 1.70177832e-01f, 2.77682822e-02f, 4.68334891e-02f, -7.01522082e-02f, 8.65225121e-02f, 1.25647858e-01f, -2.42624748e-02f, 2.31275752e-01f, 2.00443521e-01f,
  -2.89328285e-02f, 1.14721760e-01f, -1.61669210e-01f, 3.04536540e-02f, -2.05332011e-01f, -4.78821024e-02f, 9.54858735e-02f, 1.48532614e-01f, 1.25688836e-01f, -4.21089306e-02f,
  -1.00894488e-01f, -9.76162329e-02f, -9.17123631e-02f, -4.16778168e-03f, -1.29937222e-02f, 8.29999743e-04f, -2.14699313e-01f, -1.83981974e-02f, -5.85641935e-02f, 4.93947938e-02f,
  -1.76816080e-02f, 1.47748142e-01f, 8.59562755e-02f, -4.84256595e-02f, 1.13934673e-01f, 1.14333564e-02f, 6.82796314e-02f, 7.70186931e-02f, 2.34231167e-02f, 2.07184330e-02f,
  -5.47602475e-02f, -6.28471524e-02f, 8.04315433e-02f, -5.71736470e-02f, 4.36751954e-02f, 9.10197422e-02f, 5.82988970e-02f, -3.35116172e-04f, -4.00855392e-02f, 2.05490738e-02f,
  1.66821107e-02f, 6.53202981e-02f, -3.08639705e-02f, -1.00074120e-01f, -1.61784664e-02f, -1.70247890e-02f, -6.00189762e-03f, 3.34551334e-02f, 4.10121493e-02f, -6.20638533e-03f,
  7.46378005e-02f, -1.07127372e-02f, -6.04349598e-02f, 7.55210370e-02f, -8.95246267e-02f, -2.40243208e-02f, -3.69624943e-02f, 2.01727711e-02f, -1.86558701e-02f, -5.47226332e-02f,
  2.79392414e-02f, -8.93747136e-02f, -5.54018170e-02f, 7.34588057e-02f, -5.23426570e-02f, 6.20983206e-02f, 5.09002358e-02f, -3.39897461e-02f, -3.80440685e-03f, -3.43380608e-02f,
  3.25223021e-02f, -3.12568177e-03f, 5.05007729e-02f, 3.71354073e-02f, 7.77846947e-03f, 8.57929587e-02f, -1.30248559e-03f, 2.12655775e-02f, 1.63081214e-02f, -7.55587667e-02f,
  -2.57528038e-03f, 1.00797847e-01f, 7.85879493e-02f, 9.54235792e-02f, -4.25987095e-02f, -2.72154175e-02f, -3.87307443e-02f, -1.66859129e-03f, -2.80487118e-03f, 1.77394040e-02f,
  7.29152262e-02f, -4.83630821e-02f, 6.26737028e-02f, -9.56722442e-03f, 1.09219812e-02f, 7.99014568e-02f, -8.45098589e-03f, -7.34845474e-02f, -1.02983965e-02f, 3.85928480e-03f,
  4.34172451e-02f, -8.78352523e-02f, 7.72845224e-02f, -5.66730648e-02f, -9.02727619e-02f, 1.69739686e-02f, 3.51752974e-02f, -7.26632250e-04f, 4.80533857e-03f, -4.64260355e-02f,
  -2.47031190e-02f, -8.72915462e-02f, 5.50985662e-03f, 1.03297286e-01f, -1.14181668e-01f, -2.70057172e-01f, -7.31817260e-02f, -3.70408259e-02f, 6.30118102e-02f, -4.32795770e-02f,
  -3.18347779e-03f, 1.18591696e-01f, 1.14265196e-01f, -8.38664696e-02f, 2.60227472e-01f, 1.89576820e-01f, -1.15403995e-01f, -1.07559167e-01f, -1.23860113e-01f, -1.77152723e-01f,
  3.46370339e-02f, -1.28828079e-01f, -1.69197493e-03f, -1.60665497e-01f, -1.45497501e-01f, 5.85383177e-03f, 1.35112420e-01f, 7.14113042e-02f, -8.60874355e-02f, 9.20920298e-02f,
  -1.31431758e-01f, 4.20520343e-02f, -1.13370921e-02f, -2.86655296e-02f, -8.57861564e-02f, 6.97770342e-02f, -4.29088064e-02f, 1.15601318e-02f, -2.74819471e-02f, -3.62036377e-02f,
  9.29972157e-02f, -9.97638423e-03f, -3.96022089e-02f, -3.02260220e-02f, 7.44794309e-02f, 1.04134418e-02f, 7.85126835e-02f, -1.09605722e-01f, -2.92562097e-02f, -4.96346764e-02f,
  -1.19384214e-01f, -4.19946685e-02f, 2.43328176e-02f, 4.07125317e-02f, -6.76436871e-02f, -4.28531989e-02f, -1.38416244e-02f, 7.09537268e-02f, 1.91787705e-02f, -4.73074540e-02f,
  -8.41354951e-02f, -2.24292967e-02f, 1.00561082e-02f, -1.34448837e-02f, 2.15266570e-02f, -1.26496060e-02f, 1.09500019e-02f, -3.20903882e-02f, -6.38166592e-02f, 4.59677428e-02f,
  2.23955885e-02f, 2.45418400e-02f, 5.18271737e-02f, 5.57643771e-02f, -5.35739176e-02f, -4.28427048e-02f, -3.56479324e-02f, -3.96080241e-02f, 2.22636703e-02f, -7.51486793e-02f,
  3.94036509e-02f, 1.38735082e-02f, 7.08688647e-02f, -4.61670123e-02f, -5.80039360e-02f, 9.00233909e-02f, -1.28762931e-01f, 4.05962095e-02f, 2.17947140e-02f, -9.85877961e-02f,
  -5.94927967e-02f, 1.82426095e-01f, -2.75654346e-02f, 9.73672792e-02f, 4.20116528e-04f, -4.90073077e-02f, -1.74034480e-02f, -9.48762000e-02f, 1.44309020e-02f, -4.04128432e-02f,
  5.47245555e-02f, 5.24281710e-02f, 3.49170193e-02f, -8.42663273e-02f, 3.35090235e-02f, -8.70843381e-02f, -5.27460873e-02f, -2.55799778e-02f, -1.02070393e-02f, -1.13325909e-01f,
  4.73701172e-02f, 1.64458584e-02f, 7.98507407e-03f, -8.24301019e-02f, 9.11224782e-02f, -2.05219798e-02f, 2.17810050e-02f, 3.69041637e-02f, 6.93494156e-02f, 1.36877634e-02f,
  2.42772773e-01f, -7.61080086e-02f, 3.82097922e-02f, 1.74025506e-01f, 1.91819802e-01f, 1.03315569e-01f, 9.21261609e-02f, -4.00648080e-02f, 1.68514118e-01f, -1.01926535e-01f,
  -6.75727352e-02f, 2.82745417e-02f, -4.54347655e-02f, 2.38719732e-02f, 7.98126683e-02f, -1.32478714e-01f, 8.23460636e-04f, -1.97102129e-02f, 8.30385387e-02f, 2.76514273e-02f,
  1.04528762e-01f, -8.25160369e-02f, -7.97935948e-02f, -7.13311955e-02f, -1.43818585e-02f, 1.43702567e-01f, -1.28446698e-01f, -1.30993217e-01f, 3.63860093e-02f, 8.77039358e-02f,
  4.08043303e-02f, 2.37997826e-02f, -6.14317618e-02f, 1.10269468e-02f, 4.99379933e-02f, -1.77540202e-02f, 4.53923643e-02f, -9.83140171e-02f, 8.26136116e-03f, 4.66041826e-02f,
  -1.00350857e-01f, -6.21036300e-03f, -2.76677404e-02f, 8.03830773e-02f, -9.41997617e-02f, -1.14381053e-02f, -2.14979779e-02f, -1.13385255e-02f, -1.62574649e-03f, -4.79571261e-02f,
  -1.28356693e-02f, 5.49618080e-02f, 8.45591798e-02f, 1.03317894e-01f, -5.46557195e-02f, 5.54173216e-02f, -4.49071452e-02f, 8.40605497e-02f, -3.89653854e-02f, 1.87500790e-02f,
  -2.19621584e-02f, 4.74931225e-02f, 6.46551177e-02f, 3.37089002e-02f, 3.60887237e-02f, -5.24600931e-02f, -2.43547224e-02f, 1.01452470e-02f, -2.71382760e-02f, -5.32694273e-02f,
  -5.70395589e-02f, -3.09524611e-02f, -1.13727726e-01f, 8.49598125e-02f, -1.51823589e-03f, 6.10619225e-02f, -3.08965594e-02f, 4.07323614e-02f, 6.51788339e-02f, -7.56269246e-02f,
  2.98595484e-02f, -8.10261741e-02f, -1.39082074e-02f, 1.30830809e-01f, 4.01301347e-02f, -6.48515671e-03f, -4.68247607e-02f, -9.88011714e-03f, -5.18518463e-02f, -6.31491691e-02f,
  6.31752843e-03f, 3.09754983e-02f, -1.01534821e-01f, -4.02438454e-02f, -3.19236927e-02f, 5.41941859e-02f, -2.00785156e-02f, 3.67473140e-02f, 5.99674247e-02f, -7.78268427e-02f,
  7.00399727e-02f, -3.94846573e-02f, -7.87315816e-02f, -9.12951399e-03f, -5.07497564e-02f, 6.23493530e-02f, 7.58407786e-02f, -4.40150546e-03f, -9.89093035e-02f, -7.06429482e-02f,
  -7.59705901e-02f, -2.26291940e-02f, 1.45027600e-02f, -2.52296217e-02f, -4.02741656e-02f, 1.53319249e-02f, -6.44154660e-03f, 4.52040210e-02f, -9.73537341e-02f, -4.51296531e-02f,
  2.86981225e-01f, 9.77630764e-02f, 1.24914259e-01f, 6.35463372e-02f, -2.28651851e-01f, -2.25528568e-01f, -7.35099763e-02f, -1.53988758e-02f, -5.21451980e-02f, 3.84334400e-02f,
  -1.25718057e-01f, 2.02024534e-01f, -6.41420633e-02f, -3.91490757e-02f, -2.44756490e-01f, -2.19930023e-01f, -6.51459917e-02f, -2.40330882e-02f, -1.39041409e-01f, 1.33131236e-01f,
  2.59902589e-02f, -1.18206888e-01f, -9.43131093e-03f, 6.42993860e-03f, 1.00650646e-01f, 3.08952779e-01f, 1.54977426e-01f, 4.90868278e-02f, 1.71670020e-01f, -7.19569698e-02f,
  -5.59283756e-02f, 9.49833319e-02f, 8.58749971e-02f, -7.03505725e-02f, -1.72180738e-02f, 8.23334157e-02f, 1.09100685e-01f, -5.41794039e-02f, 1.24132503e-02f, 9.66810994e-03f,
  5.93788587e-02f, -4.30134982e-02f, -3.76434959e-02f, -1.02251386e-02f, 7.22805038e-02f, -8.11655889e-04f, -4.25537415e-02f, -6.94101676e-02f, 1.91866066e-02f, 4.19540927e-02f,
  5.52780405e-02f, -2.56652627e-02f, 1.06834382e-01f, -5.89368790e-02f, -5.28860763e-02f, 2.44403407e-02f, 3.33494730e-02f, 1.12669528e-01f, 8.23434740e-02f, 1.13187708e-01f,
  -7.44683668e-02f, 8.70927423e-02f, -4.34139930e-02f, -1.14832176e-02f, -7.49544986e-03f, -3.05336844e-02f, 1.28351282e-02f, -1.15740178e-02f, 4.17035334e-02f, 2.95471027e-02f,
  -4.19927798e-02f, 4.62510288e-02f, -1.20540962e-01f, -2.17014141e-02f, 4.32245247e-02f, -3.90944444e-02f, -3.18978392e-02f, -1.09400980e-01f, 9.12272371e-03f, -3.37092243e-02f,
  -1.53121561e-01f, 1.01712532e-02f, 5.83994463e-02f, 3.81680392e-02f, -5.99089377e-02f, -7.26430342e-02f, 9.60485637e-03f, 1.84511289e-01f, -2.66607618e-03f, -1.10875376e-01f,
  -7.64086694e-02f, -2.90121902e-02f, 6.58005476e-02f, -1.46964164e-02f, -5.27582271e-03f, 1.72633063e-02f, 3.78637612e-02f, 6.92490116e-02f, -1.48088587e-02f, 1.76860914e-02f,
  1.18664138e-01f, -1.79348104e-02f, 7.48617575e-02f, -2.88298205e-02f, -4.37364094e-02f, 4.68786582e-02f, 7.10452199e-02f, -6.86937943e-04f, 5.32925427e-02f, 8.20554793e-02f,
  7.74640143e-02f, -2.18669120e-02f, 1.39663473e-01f, -4.49960008e-02f, 3.59019041e-02f, 1.01215011e-02f, 1.98872760e-02f, 2.10892912e-02f, 1.55506027e-03f, -7.10522337e-03f,
  2.44255722e-01f, -2.20325693e-01f, 1.02048427e-01f, 1.61780924e-01f, 1.38962597e-01f, 5.65716531e-03f, 1.24773636e-01f, -1.27135649e-01f, 5.02544791e-02f, -1.82407364e-01f,
  3.84554304e-02f, -1.78409796e-02f, -1.17901489e-01f, -1.03206858e-01f, -3.14526539e-03f, -2.21734658e-01f, 4.63109463e-02f, 8.29633400e-02f, -1.34210840e-01f, 6.62709773e-02f,
  4.21047024e-02f, -4.00538072e-02f, -6.51172623e-02f, -2.67523900e-02f, 6.97810277e-02f, 1.54382130e-03f, 7.27820471e-02f, 2.79778633e-02f, 1.14056177e-01f, -6.28079101e-02f,
  1.38285488e-01f, -9.09050182e-02f, -4.99801338e-02f, 2.21609417e-02f, 1.36826485e-02f, 7.84171149e-02f, 1.76107921e-02f, -1.01761818e-01f, -1.98170524e-02f, -5.24828443e-03f,
  1.20722745e-02f, 6.93716407e-02f, -1.63711272e-02f, 8.93825367e-02f, 9.38825905e-02f, 8.05208161e-02f, 1.36009818e-02f, 6.78591207e-02f, -4.51325811e-02f, 5.53237647e-02f,
  -2.41960920e-02f, 1.76781807e-02f, 8.72224122e-02f, 6.19950704e-02f, 4.16001119e-02f, 4.13256846e-02f, -3.78541648e-02f, 9.47950482e-02f, -5.44724092e-02f, 4.16448899e-02f,
  -1.03523470e-01f, 1.33398362e-02f, -7.95455724e-02f, -4.51785214e-02f, 7.53138587e-02f, 2.15923749e-02f, 4.80455235e-02f, -5.58094308e-02f, 6.45329952e-02f, 2.26731729e-02f,
  8.27730447e-02f, 5.31801991e-02f, -1.00827172e-01f, -5.51140457e-02f, 3.52778770e-02f, 2.11968757e-02f, 2.59165466e-02f, 6.46732450e-02f, -3.27543414e-04f, 3.77001390e-02f,
  -7.23169670e-02f, -1.25847769e-03f, -1.10809812e-02f, 6.52286708e-02f, -9.93582532e-02f, 7.15837851e-02f, 4.17981297e-03f, -5.91337830e-02f, 2.69911066e-02f, 2.29906831e-02f,
  4.89415089e-03f, -1.94595143e-01f, -3.88953835e-02f, -6.94164932e-02f, -2.92482283e-02f, 8.74747187e-02f, 5.94167300e-02f, -2.43349429e-02f, -6.54713139e-02f, 2.18702983e-02f,
  -2.06544362e-02f, 9.02955607e-02f, -9.59702134e-02f, 8.37784857e-02f, -1.33870374e-02f, -4.29253019e-02f, -7.62173384e-02f, -6.12902492e-02f, 9.53689159e-04f, -8.72900635e-02f,
  6.00197017e-02f, -3.11828274e-02f, -1.06576169e-02f, 4.13614735e-02f, 7.90101960e-02f, -5.81418648e-02f, -6.92423955e-02f, 4.10435535e-02f, 6.32491037e-02f, 2.10378151e-02f,
  1.79992810e-01f, -1.12902336e-01f, 2.19198033e-01f, 1.85722753e-01f, 9.68476012e-02f, -1.49047757e-02f, 1.87486321e-01f, -1.82024434e-01f, 1.44719973e-01f, -1.50121659e-01f,
  4.49046977e-02f, 9.30241719e-02f, -4.00708988e-02f, -1.81434095e-01f, 1.99988663e-01f, 3.33955958e-02f, -8.69484544e-02f, 9.57419053e-02f, 1.87956318e-02f, 2.84357686e-02f,
  1.96904894e-02f, -2.19555065e-01f, 2.50669625e-02f, -1.61899224e-01f, 3.94531898e-02f, -8.53802338e-02f, -7.59312287e-02f, 1.29813664e-02f, -2.43528083e-01f, -8.01240578e-02f,
  5.40095940e-02f, 9.84435230e-02f, -1.73251405e-02f, -1.36807397e-01f, -6.79637445e-03f, 5.39650917e-02f, 1.75555777e-02f, -3.35581861e-02f, 1.13464676e-01f, 2.57700738e-02f,
  -8.37904140e-02f, -9.12803486e-02f, -2.66724341e-02f, -8.64897296e-03f, -6.71523437e-02f, -8.48357677e-02f, -1.15485163e-02f, -6.33981377e-02f, -9.71568376e-02f, 3.18097249e-02f,
  7.12049827e-02f, 2.79931948e-02f, 5.99244647e-02f, -2.48139780e-02f, 3.24179344e-02f, 7.08271638e-02f, 1.74098816e-02f, 1.72178131e-02f, -4.19524461e-02f, -7.69940689e-02f,
  -6.18244000e-02f, 4.69430014e-02f, -9.59260091e-02f, -7.06840232e-02f, 2.86786407e-02f, -1.29148904e-02f, -2.60742437e-02f, 5.91641180e-02f, -5.04224151e-02f, 2.59229001e-02f,
  2.09735148e-02f, 2.09295396e-02f, -3.69139761e-02f, 1.06428385e-01f, 1.10152531e-02f, 1.98549069e-02f, -1.73978694e-02f, 4.41193916e-02f, 1.55342985e-02f, 4.59295064e-02f,
  8.91674459e-02f, -1.19006718e-02f, 4.22592945e-02f, -1.26463957e-02f, 8.73111561e-02f, 5.62382378e-02f, -7.69913495e-02f, 2.28305571e-02f, -4.47188951e-02f, -3.30371293e-03f,
  -1.09823950e-01f, -2.88235955e-02f, -2.76707150e-02f, 1.04784751e-02f, 4.50143479e-02f, -5.28093893e-03f, 8.95869210e-02f, 4.14467081e-02f, -6.27570003e-02f, -2.92358752e-02f,
  -8.78004208e-02f, 7.09885880e-02f, -3.64773944e-02f, -4.07949165e-02f, 7.00231001e-04f, -8.66776258e-02f, 4.89149354e-02f, -4.19678353e-02f, 7.25201964e-02f, -9.77845713e-02f,
  -4.82330099e-02f, 1.06986146e-02f, 6.02913164e-02f, 2.30304152e-02f, 2.95111537e-03f, 2.59527890e-03f, 9.89124402e-02f, 4.98408377e-02f, -5.37874922e-02f, 5.05207889e-02f,
  4.96714488e-02f, -8.93396139e-02f, 4.55171876e-02f, 1.57635584e-01f, 7.60806873e-02f, -9.70221832e-02f, -1.00434162e-01f, 1.68339573e-02f, -1.37346596e-01f, -1.49995461e-01f,
  1.54836094e-02f, -6.70899451e-02f, -2.09412411e-01f, 8.75674561e-02f, 2.00441971e-01f, -5.04336245e-02f, 1.09207831e-01f, -4.67542596e-02f, -2.87104417e-02f, 3.61100882e-02f,
  1.11813053e-01f, 2.64135357e-02f, 1.58608794e-01f, 9.90256518e-02f, 2.91715767e-02f, 2.34766170e-01f, 1.51356682e-01f, 5.24640307e-02f, 2.95089215e-01f, 9.27295834e-02f,
  -3.84613164e-02f, 9.71427001e-03f, 2.20898222e-02f, -7.31836557e-02f, -1.37877418e-03f, 4.45236042e-02f, -2.70936545e-02f, 1.05104029e-01f, -3.83517370e-02f, 9.07066837e-02f,
  9.03273597e-02f, 2.14198139e-02f, 1.42939940e-01f, 3.37392720e-03f, 1.43791279e-02f, 5.82330935e-02f, -2.34661046e-02f, 2.37861443e-02f, -7.26436898e-02f, -5.09718340e-03f,
  -6.34237304e-02f, -1.50854001e-02f, -7.36740306e-02f, 9.14091766e-02f, 4.92079034e-02f, 7.12488359e-03f, 7.93273598e-02f, 7.99911022e-02f, 2.70588920e-02f, 3.62512358e-02f,
  3.74779999e-02f, -4.72899005e-02f, 5.81456050e-02f, 3.26474458e-02f, -5.59005551e-02f, -3.39733735e-02f, -5.06570637e-02f, -7.37194866e-02f, -4.81963530e-02f, -6.74908757e-02f,
  -3.34413573e-02f, 9.24048126e-02f, -1.17365550e-02f, -8.83773714e-02f, 3.32518332e-02f, -8.85488614e-02f, 2.22443268e-02f, 7.88431242e-02f, 1.87541787e-02f, -4.30192761e-02f,
  -6.13650307e-02f, 3.73848602e-02f, -3.39522809e-02f, 7.61545636e-03f, 2.09555067e-02f, 4.71225530e-02f, -8.93763751e-02f, -1.68298874e-02f, -4.65289364e-03f, -4.99132127e-02f,
  2.99559552e-02f, 1.38926432e-01f, -5.54726971e-03f, -2.01442260e-02f, 3.45050283e-02f, 4.01172191e-02f, -6.11493774e-02f, 1.34386957e-01f, -7.27776438e-02f, -2.12631840e-02f,
  5.68054840e-02f, 5.93237616e-02f, -3.45471054e-02f, 1.15785869e-02f, 4.00529942e-03f, 1.01101510e-02f, 1.14818685e-01f, -3.80948894e-02f, 9.76528972e-02f, -3.52509599e-03f,
  4.87495326e-02f, 6.32260591e-02f, -1.56261455e-02f, 1.05772041e-01f, 1.38742998e-02f, -4.15825052e-03f, -3.56693603e-02f, -6.93996772e-02f, -1.43577717e-02f, 8.98471102e-03f,
  -2.24726480e-02f, -1.99394673e-01f, -1.89241394e-02f, 1.33571737e-02f, -4.36697379e-02f, -2.06997469e-01f, -1.32665992e-01f, -1.80326775e-01f, 2.36775670e-02f, -9.55932662e-02f,
  -6.39678836e-02f, 1.78711399e-01f, 1.71193257e-01f, -2.43943334e-01f, 2.34504730e-01f, 8.57485607e-02f, -8.97219777e-02f, 3.48178074e-02f, 6.26241118e-02f, -7.09367245e-02f,
  -1.18345870e-02f, -1.07392132e-01f, 4.47822437e-02f, -7.17421174e-02f, -8.70580077e-02f, -1.58435449e-01f, 1.49877638e-01f, -8.03842172e-02f, -9.76184905e-02f, -1.06735770e-02f,
  -3.93779464e-02f, 3.23499516e-02f, 2.09440303e-04f, 1.05829127e-01f, 4.09617573e-02f, 4.12338413e-02f, 1.92450229e-02f, 1.01790480e-01f, 5.49761467e-02f, 6.94169030e-02f,
  6.12777583e-02f, -3.10098492e-02f, -1.20297838e-02f, 1.16194241e-01f, -2.52812412e-02f, 6.80749789e-02f, -5.66316508e-02f, 6.85141757e-02f, -6.82389960e-02f, -1.55253187e-02f,
  1.23128379e-02f, -3.62521084e-03f, 4.12436426e-02f, -2.97502708e-02f, -1.63761582e-02f, -5.36532840e-03f, -3.76619510e-02f, 7.06005096e-02f, 7.56434202e-02f, 2.45129317e-02f,
  -9.03393030e-02f, 2.30335463e-02f, 1.78345554e-02f, 5.01717851e-02f, -3.06145232e-02f, 4.72567230e-02f, 4.33093216e-03f, 2.64009051e-02f, -8.08262900e-02f, -8.25568438e-02f,
  1.10000595e-02f, 2.74684150e-02f, 4.58072498e-02f, 2.68320832e-02f, 1.27802668e-02f, 2.61329988e-04f, 1.25519574e-01f, 5.37359528e-02f, -2.05716789e-02f, 7.09314346e-02f,
  1.84112117e-02f, 6.47130013e-02f, -8.90922174e-03f, -2.23593898e-02f, 2.20486298e-02f, -4.97757941e-02f, -1.45717025e-01f, -2.49792989e-02f, 1.21564925e-01f, -3.13402973e-02f,
  3.16393860e-02f, 3.57401296e-02f, -2.34406628e-02f, 1.14957221e-01f, -5.71900383e-02f, -4.14224342e-02f, -1.09232500e-01f, -1.41713798e-01f, -1.63827408e-02f, 4.23998795e-02f,
  6.20100722e-02f, -2.77797692e-02f, -2.46850476e-02f, -5.81169361e-03f, 4.73207235e-02f, -8.05722177e-02f, 6.40580729e-02f, 1.37940913e-01f, 2.00715996e-02f, 7.47975558e-02f,
  9.38102752e-02f, -5.89238256e-02f, -3.25261499e-04f, 6.36703968e-02f, 3.65278982e-02f, 5.40478900e-02f, -2.65977830e-02f, -8.37536156e-02f, 8.61529931e-02f, 1.16033880e-02f,
  -1.48290187e-01f, 4.78191711e-02f, -1.38245821e-01f, -1.93718925e-01f, 6.67218268e-02f, -3.45115930e-01f, -2.74812311e-01f, -4.22963761e-02f, 1.66504279e-01f, -3.00085992e-02f,
  -1.61917627e-01f, 6.18491992e-02f, 1.30656110e-02f, -2.74633169e-01f, -3.26591939e-01f, -9.71811786e-02f, -3.99682969e-01f, -2.79996604e-01f, 1.04177155e-01f, -1.27087325e-01f,
  -7.74419606e-02f, -1.34490877e-01f, -3.01852494e-01f, 1.42889112e-01f, -1.18573971e-01f, 6.02075718e-02f, 7.34702796e-02f, 9.71130505e-02f, -1.41824305e-01f, -1.30780777e-02f,
  -1.42093360e-01f, -5.26914634e-02f, -1.44581506e-02f, -2.65731253e-02f, -1.65250897e-01f, -1.12663969e-01f, -1.79645866e-01f, 2.98927650e-02f, 7.25095794e-02f, -1.09991152e-02f,
  4.43370342e-02f, 1.25095192e-02f, -1.02112889e-02f, 3.46581377e-02f, 4.10885774e-02f, -5.69987446e-02f, -7.16469586e-02f, 7.74884876e-03f, 1.46930781e-03f, 7.03214994e-03f,
  -5.23741618e-02f, 2.41133012e-02f, -1.06784910e-01f, 2.53286045e-02f, 3.53738703e-02f, -4.60787304e-02f, -3.37916519e-03f, 4.47443612e-02f, -1.34427384e-01f, 6.87268516e-03f,
  -3.44087705e-02f, 3.74657027e-02f, 7.79972672e-02f, 3.82812172e-02f, 8.99882391e-02f, 3.57319415e-02f, -5.28674312e-02f, 2.66238805e-02f, 7.56380409e-02f, -4.27562818e-02f,
  9.96117759e-03f, 2.42824219e-02f, 4.47433293e-02f, -9.00034234e-02f, -3.44585441e-02f, -3.76255363e-02f, 2.43915431e-02f, -1.14712110e-02f, -3.49411890e-02f, 2.83626886e-03f,
  4.68396815e-03f, -4.19356190e-02f, 7.27718547e-02f, -8.64654109e-02f, 4.76062410e-02f, 5.64235672e-02f, 5.00968546e-02f, 5.81630133e-02f, -5.44876009e-02f, 5.01975119e-02f,
  -1.26176002e-02f, -7.72178471e-02f, 1.75625384e-02f, 3.44603397e-02f, 1.07679717e-01f, -6.97402060e-02f, -6.80744201e-02f, 8.67510028e-03f, -9.64986384e-02f, -4.70961854e-02f,
  -1.06573328e-01f, -4.56662215e-02f, 8.59983452e-03f, -1.09512154e-02f, -6.68166876e-02f, 6.30700216e-02f, -2.92970631e-02f, -2.63023358e-02f, -5.72782643e-02f, -6.57892525e-02f,
  2.02458259e-03f, 1.11433379e-02f, 2.91898847e-03f, 1.24148456e-02f, -9.64590982e-02f, -1.07186716e-02f, 4.29078452e-02f, 7.22371936e-02f, 3.79043296e-02f, -2.50642393e-02f,
  1.24564841e-01f, 4.82490845e-02f, 1.21719576e-01f, 3.70944687e-03f, -1.30266130e-01f, -3.87356337e-03f, 3.24592181e-02f, 3.58486734e-02f, 2.80165941e-01f, -7.68403932e-02f,
  -9.63966250e-02f, 7.00039789e-02f, 1.26003530e-02f, -4.66978364e-02f, 1.92639261e-01f, 7.80967027e-02f, -6.00994006e-02f, 2.39222050e-02f, 3.71688530e-02f, 9.38394368e-02f,
  1.86374150e-02f, -1.44221961e-01f, -1.52617604e-01f, -2.06622377e-01f, -2.35585749e-01f, -9.29221436e-02f, -1.29576504e-01f, -8.60834867e-02f, -2.28121936e-01f, -1.31025448e-01f,
  1.16607628e-03f, 1.18022256e-01f, 4.10076752e-02f, 2.55539771e-02f, 2.71716416e-02f, -7.46621788e-02f, 2.30821352e-02f, -1.87307447e-02f, 1.07438564e-01f, 3.70968692e-02f,
  1.00400150e-01f, -2.12130491e-02f, 7.00315759e-02f, -3.70925777e-02f, -4.55040559e-02f, -9.31667909e-02f, -5.94031923e-02f, -3.35615873e-02f, 4.98758554e-02f, -7.96666965e-02f,
  -1.38421450e-02f, -2.76656933e-02f, -6.81711501e-03f, -2.25653071e-02f, 5.69744520e-02f, 7.83856064e-02f, 1.43948302e-01f, -1.55353546e-02f, 1.61103103e-02f, 9.84662250e-02f,
  5.80369309e-02f, 2.98277177e-02f, -1.06522903e-01f, -1.02548167e-01f, -3.68616991e-02f, -3.04752402e-02f, -2.13773176e-02f, 7.34442547e-02f, 1.13314465e-01f, 3.00140232e-02f,
  4.92421165e-02f, 1.38260669e-03f, -6.83192238e-02f, 1.69077702e-02f, 3.16508971e-02f, 8.83544534e-02f, 7.46141672e-02f, -2.60163918e-02f, 9.08039212e-02f, 6.28204346e-02f,
  1.03913441e-01f, 9.66246352e-02f, -1.18107967e-01f, -1.02391161e-01f, 1.33800379e-03f, -3.70691158e-02f, -5.51114008e-02f, 5.00129946e-02f, -5.10195270e-03f, -2.36959588e-02f,
  2.95916386e-02f, 7.94216618e-02f, -6.12981990e-02f, 5.15159518e-02f, -5.74007146e-02f, 9.70939267e-03f, 3.36200185e-02f, -7.41088167e-02f, 5.45466766e-02f, -6.20485246e-02f,
  -1.30906776e-01f, -1.88541773e-03f, 3.41611244e-02f, -3.98879834e-02f, -3.91484089e-02f, -1.21063124e-02f, -5.26941530e-02f, -2.05867514e-02f, -1.73565410e-02f, -6.03567213e-02f,
  -5.25381565e-02f, 1.04098640e-01f, 1.24733068e-01f, 3.30917947e-02f, -8.59673973e-03f, -4.01407145e-02f, -2.56606820e-03f, -1.00909425e-02f, -8.57816786e-02f, -9.73045081e-03f,
  -3.59853536e-01f, -2.77314316e-02f, -1.16493098e-01f, -9.75860357e-02f, 4.21553254e-02f, -6.32427260e-02f, 9.58810747e-02f, -1.22603878e-01f, -8.98741707e-02f, 5.42293005e-02f,
  6.42398596e-02f, -1.61010966e-01f, 1.01110637e-01f, 2.46431269e-02f, -1.58325937e-02f, 7.48850256e-02f, 1.11613022e-02f, 8.34349468e-02f, -9.40802023e-02f, -1.85367063e-01f,
  4.16932534e-03f, 3.74493115e-02f, 4.46493272e-04f, -7.48403147e-02f, -9.17913616e-02f, -1.08985946e-01f, 3.24298255e-02f, -1.54277133e-02f, -6.41611442e-02f, -1.08428426e-01f,
  -2.04921260e-01f, -1.84470236e-01f, -8.01122189e-02f, 4.05647159e-02f, -3.65721397e-02f, -5.34237083e-03f, 4.29349877e-02f, 7.39484355e-02f, 3.23735513e-02f, -8.81553907e-03f,
  -2.56937724e-02f, 3.59991491e-02f, 1.12957396e-02f, -1.35811478e-01f, -5.01866639e-02f, -9.96634066e-02f, -4.95283157e-02f, 4.06358810e-03f, 1.18743461e-02f, 1.13377936e-01f,
  3.40342894e-02f, -4.86919917e-02f, 7.94297904e-02f, -8.97930283e-03f, 9.28622633e-02f, 4.34577838e-02f, -8.65681097e-02f, 4.17932905e-02f, -1.69128273e-02f, -6.69059306e-02f,
  2.31180154e-03f, -9.30232108e-02f, -5.38139604e-02f, 6.42963545e-03f, 6.98844418e-02f, -2.52064019e-02f, 1.23613970e-02f, -1.57946572e-02f, 4.24384363e-02f, 9.00090188e-02f,
  -4.43124725e-03f, -1.25599444e-01f, 2.64526345e-02f, 4.13000807e-02f, 9.86237898e-02f, 6.52275011e-02f, -2.69410443e-02f, 2.32858685e-04f, -2.95956247e-02f, 8.76364112e-03f,
  1.04418047e-01f, -3.01712509e-02f, -2.47513386e-03f, 7.22390786e-02f, 6.25002803e-03f, 3.72364111e-02f, 2.97971871e-02f, -2.71471497e-02f, -5.77347465e-02f, 4.50985245e-02f,
  -1.67179137e-01f, -2.19822615e-01f, 3.09419837e-02f, 7.45116249e-02f, 2.79443618e-03f, -4.28733155e-02f, -1.61965657e-02f, 6.44225329e-02f, 7.39413127e-02f, -1.29862845e-01f,
  2.89375037e-02f, -4.01385985e-02f, -5.27996235e-02f, 5.57984710e-02f, 3.81977819e-02f, 6.36572093e-02f, -2.35731117e-02f, -2.67610829e-02f, 5.83728179e-02f, -1.93085968e-02f,
  -5.55488467e-02f, -1.65193435e-02f, 8.70316476e-03f, 2.03138031e-02f, 4.65619043e-02f, -3.37439738e-02f, -5.06080780e-03f, -1.37437470e-02f, 4.25436422e-02f, 1.31178154e-02f,
  -1.95321485e-01f, 1.87320262e-01f, 2.73880631e-01f, 4.43036765e-01f, -2.41873711e-01f, -3.50421548e-01f, -1.07572472e-03f, -4.10317406e-02f, 1.65035784e-01f, -7.42455348e-02f,
  1.74978524e-02f, 1.08595453e-01f, 8.53456035e-02f, 1.70305714e-01f, 2.47819304e-01f, 1.16000123e-01f, 1.10584177e-01f, -3.43248285e-02f, 2.28097156e-01f, 1.25865370e-01f,
  1.84056193e-01f, -2.10248493e-02f, 1.89435944e-01f, -4.39609773e-02f, -2.10656654e-02f, 1.28539950e-01f, 2.42943853e-01f, 8.28094482e-02f, 1.73956916e-01f, 3.91687043e-02f,
  -6.90463930e-02f, 1.08114637e-01f, 2.93582194e-02f, -7.57924886e-03f, 4.43860963e-02f, -7.93990567e-02f, -6.36270791e-02f, 2.52770502e-02f, 3.68551724e-02f, 2.24320274e-02f,
  -1.04010105e-01f, -3.72759216e-02f, 2.37406138e-02f, 3.46218273e-02f, -1.60892263e-01f, 6.39470816e-02f, -6.26753196e-02f, 2.30382197e-02f, -5.33146737e-03f, -8.54590833e-02f,
  2.95459107e-02f, -7.02172816e-02f, -1.65681355e-03f, 5.90430163e-02f, 1.05436683e-01f, -2.68181004e-02f, 4.98244725e-02f, -3.06544430e-03f, 6.52918518e-02f, 2.55746841e-02f,
  6.41848072e-02f, -1.07202344e-02f, 2.02720128e-02f, -3.67010273e-02f, -5.97969256e-02f, -4.72504757e-02f, 1.40975239e-02f, -6.73772842e-02f, 1.03691079e-01f, 5.74151911e-02f,
  -6.79612234e-02f, -2.95648687e-02f, -1.98661406e-02f, -7.56888911e-02f, 4.61023562e-02f, -6.64024279e-02f, 2.16315617e-04f, 6.26958301e-03f, 2.50082314e-02f, 2.67269611e-02f,
  1.06864832e-02f, 2.11038254e-03f, -2.96259560e-02f, 5.70480153e-02f, 5.99983446e-02f, -2.12883614e-02f, 2.01922096e-02f, 4.52150293e-02f, 4.59245816e-02f, 4.57124747e-02f,
  9.68657061e-02f, 3.53177905e-01f, 4.82355170e-02f, -1.82180032e-01f, 8.19463506e-02f, -7.35904053e-02f, 1.15476012e-01f, 7.11397529e-02f, 1.89611226e-01f, -2.38402113e-02f,
  8.77552480e-03f, 4.95856702e-02f, -7.82639235e-02f, 8.09725672e-02f, 7.18056634e-02f, 1.11394346e-01f, 3.23666073e-02f, 1.05402218e-02f, 5.41726686e-03f, 6.55443221e-02f,
  3.75780165e-02f, -2.54305564e-02f, -2.41737105e-02f, -2.84618065e-02f, -1.41255921e-02f, 6.20430671e-02f, -9.62947831e-02f, -7.24037588e-02f, 1.75273288e-02f, 7.03161657e-02f,
  -2.13512629e-01f, -1.53823402e-02f, 6.27147853e-02f, -9.86113492e-03f, 5.98852560e-02f, -2.40039140e-01f, -1.14559889e-01f, 5.05084135e-02f, -1.05405807e-01f, 3.83270979e-02f,
  4.38203365e-02f, -6.45589903e-02f, -4.98003066e-02f, -2.60005593e-01f, -1.70975938e-01f, -2.67870337e-01f, -1.80389553e-01f, -1.48679122e-01f, -3.79497185e-02f, 1.19956478e-01f,
  6.54026400e-03f, -8.68790224e-02f, 7.56500363e-02f, 1.47093505e-01f, 2.78484430e-02f, 1.37710229e-01f, 2.33987927e-01f, 1.63277254e-01f, 2.14902833e-02f, -1.18824720e-01f,
  -7.64107704e-02f, -4.45993654e-02f, 7.93531444e-03f, -6.57052966e-03f, 7.36615732e-02f, 7.94333816e-02f, 5.37949502e-02f, -7.87262246e-02f, 1.26035318e-01f, -8.02959874e-02f,
  2.34215297e-02f, -1.11716557e-02f, -9.48249474e-02f, -1.18103817e-01f, 6.81157224e-03f, 1.20430943e-02f, -7.58566102e-03f, -1.12522192e-01f, -8.17709118e-02f, -8.33663940e-02f,
  7.66178221e-02f, -1.99192595e-02f, 4.22464050e-02f, 3.61076035e-02f, 1.69331525e-02f, -3.68259028e-02f, -4.63666692e-02f, 7.58149922e-02f, -6.28905371e-02f, 1.58421304e-02f,
  6.17480613e-02f, 1.95479318e-02f, -2.34355833e-02f, -1.55485317e-01f, -7.75452182e-02f, 8.30606669e-02f, -1.03308178e-01f, -1.21948598e-02f, 4.02784310e-02f, 7.50299245e-02f,
  -7.03818128e-02f, 2.00211699e-03f, -5.34669869e-02f, -3.02297203e-03f, 2.23766901e-02f, -4.87130135e-02f, -2.11430043e-02f, 7.29297623e-02f, 3.10337227e-02f, -3.34358141e-02f,
  -6.74168766e-03f, 7.01249251e-03f, -6.63867220e-02f, -2.45484542e-02f, -1.22277215e-01f, 1.48078606e-01f, -4.36317399e-02f, 2.88863331e-02f, 4.50317301e-02f, -5.69051504e-02f,
  1.36506930e-01f, 2.17666104e-01f, -7.85014778e-02f, 1.00448662e-02f, -4.56380285e-02f, 2.05615796e-02f, -8.56899545e-02f, 4.79738340e-02f, 1.10465705e-01f, 2.45365296e-02f,
  1.69141561e-01f, 2.72456231e-03f, -2.28301231e-02f, 6.40081838e-02f, -1.10276788e-02f, 5.45723783e-03f, 1.41552061e-01f, 1.92578603e-03f, -1.05519649e-02f, 1.13086216e-02f,
  1.02628969e-01f, 6.44557774e-02f, -3.31185013e-02f, -6.68495148e-02f, 2.14711409e-02f, 8.91433954e-02f, -1.13572329e-02f, 6.89168274e-02f, 2.60659144e-04f, 1.46469940e-02f,
  -8.45602825e-02f, 5.25356606e-02f, -7.44761825e-02f, -1.54612511e-02f, -2.02516720e-01f, -3.38480771e-01f, -2.98522711e-01f, -4.14138064e-02f, 1.81828082e-01f, 5.14652766e-02f,
  -7.97421262e-02f, 3.68679278e-02f, 1.06646664e-01f, -1.44906610e-01f, 1.96670741e-02f, 8.74960124e-02f, -1.06835496e-02f, -5.20965643e-02f, 3.64077725e-02f, -9.20158997e-02f,
  1.95448831e-01f, 1.11059316e-01f, -1.05392060e-03f, 5.34675876e-03f, -1.63466766e-01f, -7.28802308e-02f, 1.27854690e-01f, -2.40765080e-01f, -1.63971558e-01f, -1.29220515e-01f,
  -1.24642598e-02f, 5.20278886e-02f, -7.24122440e-03f, -1.17460294e-02f, -4.90214415e-02f, -2.67001856e-02f, -1.38539225e-01f, -8.28345567e-02f, -5.83944283e-02f, 5.23095503e-02f,
  1.05180219e-01f, -1.49301356e-02f, 2.29295604e-02f, 7.04403222e-02f, -1.14270367e-01f, 1.01824023e-01f, 2.19495371e-02f, 1.34676006e-02f, 1.74993668e-02f, 4.07352746e-02f,
  -6.90562930e-03f, 6.96990937e-02f, 5.10908104e-03f, 6.29581884e-02f, -3.20149548e-02f, -1.52983069e-01f, 7.49510601e-02f, 1.74802113e-02f, 7.83263445e-02f, 5.46517260e-02f,
  5.48202060e-02f, 1.03903087e-02f, -6.47609159e-02f, -4.81050462e-02f, 1.06195677e-02f, 1.27144292e-01f, -9.87910293e-03f, -3.47568393e-02f, 5.88978454e-02f, -9.47724730e-02f,
  -3.88237126e-02f, -1.73978303e-02f, -2.56171897e-02f, -6.82354718e-02f, 4.33586612e-02f, 4.95936768e-03f, -1.46255270e-02f, 7.00715929e-02f, 9.16305259e-02f, 1.54824890e-02f,
  -6.22335402e-03f, 2.96072774e-02f, -2.25863177e-02f, 8.29147175e-03f, -1.19913444e-01f, 3.48091125e-02f, 9.16904435e-02f, -1.20383305e-02f, 4.88704927e-02f, -7.23980740e-02f,
  8.41074735e-02f, 1.54036596e-01f, 6.63133338e-02f, 1.35600150e-01f, 1.22110024e-02f, 2.38646157e-02f, -5.37011772e-02f, 6.07713498e-02f, -3.07943374e-02f, -2.10244115e-02f,
  -4.97203656e-02f, 1.05420411e-01f, 6.09664731e-02f, -4.67900932e-02f, -3.25660817e-02f, -1.75249688e-02f, -1.78214870e-02f, 6.64673150e-02f, 2.86560562e-02f, 2.88083106e-02f,
  -1.09564560e-02f, 4.54391018e-02f, 1.58472061e-01f, 6.89988136e-02f, -8.15829113e-02f, -3.94293889e-02f, -3.75250690e-02f, 3.13811153e-02f, 1.00534149e-01f, -1.73433926e-02f,
  -1.38276160e-01f, 1.68908685e-01f, 6.17889725e-02f, 1.37718067e-01f, 2.82119997e-02f, -2.03745231e-01f, -1.39191121e-01f, 9.48267952e-02f, -1.32342994e-01f, 1.45555034e-01f,
  -1.05018325e-01f, -7.17059746e-02f, -1.15547299e-01f, 1.61811799e-01f, 7.58477077e-02f, -1.44925967e-01f, 2.14634091e-01f, -6.99310079e-02f, -1.19016014e-01f, 1.77311048e-01f,
  -1.54143898e-02f, 1.94302753e-01f, 4.45752665e-02f, -1.20829456e-02f, 2.89059486e-02f, -3.53265405e-02f, 1.23522535e-01f, -1.00835137e-01f, 1.09318249e-01f, 7.01543242e-02f,
  -5.39504085e-03f, 8.20706859e-02f, -7.13023320e-02f, 4.21142951e-02f, 9.66768116e-02f, 2.01479867e-02f, -3.46283652e-02f, -3.23586091e-02f, 4.44874354e-03f, 5.47981672e-02f,
  3.75774242e-02f, -8.89782012e-02f, -8.55347589e-02f, 3.46929953e-02f, -7.24907592e-02f, -1.23204954e-03f, 3.19196144e-03f, 3.43107767e-02f, 2.93825176e-02f, 1.10356420e-01f,
  8.31425376e-03f, 4.83893380e-02f, -1.90977380e-02f, -5.53686842e-02f, -1.00854191e-03f, 1.30045731e-02f, -4.51376028e-02f, 5.46799675e-02f, 3.76465432e-02f, -4.73326147e-02f,
  -5.76473065e-02f, 8.87553617e-02f, -9.83959287e-02f, 1.06391432e-02f, 3.62776667e-02f, -5.97713217e-02f, 6.24662228e-02f, -6.65353015e-02f, -7.41988793e-02f, 7.04027042e-02f,
  -8.13032240e-02f, -4.97217365e-02f, 7.22279027e-02f, -1.51843652e-02f, 4.27799411e-02f, 1.91589836e-02f, -1.15963660e-01f, -5.61131313e-02f, -5.00229262e-02f, 1.16129555e-02f,
  3.28689329e-02f, 3.18398215e-02f, 3.51629183e-02f, 4.69999090e-02f, -5.65003045e-03f, 9.47492719e-02f, 2.90506501e-02f, 1.54601689e-02f, 2.51059048e-02f, -8.29861537e-02f,
  2.31168736e-02f, 1.15933135e-01f, -3.12922942e-03f, 6.98795449e-03f, -6.15665689e-03f, -5.48844710e-02f, 4.10784259e-02f, -8.74151736e-02f, -7.71266446e-02f, 2.30916943e-02f,
  4.42432687e-02f, 1.49558336e-02f, -6.22497536e-02f, 4.13285233e-02f, 3.46060321e-02f, -4.04192805e-02f, 9.40787345e-02f, 9.34122801e-02f, 9.14742649e-02f, 1.09088890e-01f,
  2.92091612e-02f, 9.35574397e-02f, 2.01222617e-02f, -3.11362576e-02f, -4.45776694e-02f, 2.45750099e-02f, -7.71507015e-03f, 9.23158079e-02f, 6.56086951e-03f, -3.04802470e-02f,
  -1.59851685e-01f, 1.54338822e-01f, 7.26876110e-02f, -1.17043935e-01f, 1.33801587e-02f, 1.45253345e-01f, 1.21434271e-01f, 1.45718053e-01f, 5.42416088e-02f, 2.34017849e-01f,
  8.11838061e-02f, 1.20435253e-01f, 8.34808201e-02f, -1.19403042e-02f, -1.43472046e-01f, -2.78007035e-04f, -5.42539805e-02f, 3.07768732e-02f, 1.80364046e-02f, -1.10507101e-01f,
  -1.50251865e-01f, -9.15597007e-02f, -3.60916331e-02f, -5.18931001e-02f, -5.43380305e-02f, 6.69468418e-02f, -2.33770952e-01f, -6.11433797e-02f, 5.23726689e-03f, 2.46717967e-03f,
  -1.91193242e-02f, 1.30354583e-01f, -1.62161875e-03f, 2.67992746e-02f, -2.93633714e-02f, 2.90474724e-02f, -9.48384106e-02f, -6.95801601e-02f, -8.31895694e-02f, -3.95306423e-02f,
  3.01048420e-02f, 8.00984204e-02f, 1.36681451e-02f, 5.83020262e-02f, -4.06259373e-02f, 9.85489488e-02f, 7.35058263e-02f, 1.06662577e-02f, 7.94760659e-02f, 3.64274792e-02f,
  9.50940922e-02f, 1.26177952e-01f, -7.06877261e-02f, -4.78706509e-02f, -6.86486214e-02f, 4.59976122e-02f, -5.31024635e-02f, -7.84453377e-02f, -3.63520421e-02f, 3.35818939e-02f,
  -7.87387639e-02f, -2.86125913e-02f, 3.74873951e-02f, -1.46813586e-03f, 8.23064819e-02f, -1.08557870e-03f, -1.82973538e-02f, -6.50853813e-02f, -3.68949249e-02f, -2.90742330e-02f,
  -7.29900450e-02f, 7.89664984e-02f, 5.59237748e-02f, -1.04432799e-01f, -4.58920635e-02f, -1.36787174e-02f, -1.18619781e-02f, 9.91241410e-02f, -8.08017328e-02f, 3.45795341e-02f,
  1.15065433e-01f, 7.95113109e-03f, -3.81837673e-02f, -1.29869759e-01f, 1.37738988e-01f, 1.00670964e-01f, 8.58011376e-03f, 8.30407664e-02f, -6.33750260e-02f, -8.34139511e-02f,
  5.25607131e-02f, 8.63685682e-02f, -7.57575314e-03f, 9.84956101e-02f, 5.80527782e-02f, -4.08031121e-02f, -1.37994751e-01f, -3.80299147e-03f, 4.63089198e-02f, -6.43327534e-02f,
  -8.13631415e-02f, 1.24263018e-01f, 5.90554159e-03f, -9.76197198e-02f, 1.36193736e-02f, -1.38046565e-02f, -8.56485963e-03f, -3.52827609e-02f, 1.61484573e-02f, -3.76359001e-02f,
  3.89537052e-03f, -2.37749740e-02f, 1.66182294e-02f, -2.49438211e-02f, -7.04022944e-02f, -1.56406648e-02f, 4.87309024e-02f, -2.92977039e-02f, -1.66567460e-01f, 1.34951817e-02f,
  1.46625817e-01f, 2.09455892e-01f, 1.58107415e-01f, -9.70606040e-03f, 2.20918898e-02f, -9.52700526e-02f, -4.54353467e-02f, 1.15193032e-01f, 2.32704788e-01f, 9.37507004e-02f,
  -7.97953680e-02f, 2.43836313e-01f, -3.47235724e-02f, -6.56593814e-02f, -2.46426761e-01f, -2.17966601e-01f, -2.43101448e-01f, -2.87233368e-02f, 2.01741576e-01f, -6.03605099e-02f,
  -3.99343902e-03f, -2.98204213e-01f, -1.34311035e-01f, -4.52060923e-02f, 1.06771730e-01f, 1.53370067e-01f, -2.22784117e-01f, 2.27223933e-02f, -7.93236569e-02f, 3.84370573e-02f,
  -9.39729437e-02f, 8.59705955e-02f, 1.45625979e-01f, 8.98970813e-02f, -3.96092143e-03f, 6.71022832e-02f, 5.09146340e-02f, -1.77846570e-02f, 7.57889077e-02f, 9.93193835e-02f,
  3.96368764e-02f, 3.48681845e-02f, -4.54909317e-02f, 3.73859555e-02f, 1.48996875e-01f, 1.19755507e-01f, 3.71998213e-02f, 1.25300005e-01f, 1.82574019e-01f, 8.59976336e-02f,
  5.93123138e-02f, 9.31810495e-03f, 1.14605717e-01f, 7.58810639e-02f, 8.07255134e-02f, 2.57539563e-02f, 7.57492930e-02f, -3.84059474e-02f, 7.62026086e-02f, 2.38620769e-02f,
  -6.48978502e-02f, 9.78580713e-02f, -1.61629543e-02f, 4.61806357e-02f, -4.67629954e-02f, 7.93446898e-02f, -4.60747629e-02f, -2.07234249e-02f, 1.16137015e-02f, -3.75763588e-02f,
  2.89303134e-03f, 6.42547831e-02f, 6.04122207e-02f, 5.62281236e-02f, -8.03003460e-03f, -3.92873585e-03f, -1.40813053e-01f, -9.52891335e-02f, 3.49223204e-02f, 4.67991419e-02f,
  -1.17263168e-01f, -1.21291161e-01f, 7.68925110e-03f, -6.10264093e-02f, -6.95938170e-02f, -3.40675451e-02f, 5.22064380e-02f, -1.48069095e-02f, 1.83408186e-02f, -3.25725153e-02f,
  -2.06681583e-02f, -9.82520804e-02f, 4.08917740e-02f, -5.15956916e-02f, -7.89974481e-02f, 1.49653386e-02f, 4.15873863e-02f, -1.89727526e-02f, -6.31290972e-02f, 6.20031506e-02f,
  5.56395203e-02f, 1.01140238e-01f, 1.88637599e-02f, -7.12019205e-02f, 2.88532791e-03f, -1.00247934e-01f, 6.03086222e-03f, -1.52468146e-03f, -4.31954786e-02f, 5.14967293e-02f,
  -3.85683998e-02f, 6.39127120e-02f, -1.21503286e-02f, 8.34445879e-02f, 5.71176223e-02f, -7.50999013e-03f, -3.42708714e-02f, 2.64522452e-02f, -9.75478515e-02f, 3.59556749e-02f,
  3.33340287e-01f, 4.08494212e-02f, 7.72481710e-02f, 1.04788519e-01f, 3.02824955e-02f, 1.17403880e-01f, 9.19478685e-02f, 1.35863408e-01f, 3.16620648e-01f, 8.91229138e-02f,
  -1.15541480e-01f, 2.16794729e-01f, -1.59406632e-01f, 1.50425389e-01f, 1.35192350e-01f, -9.33258682e-02f, 2.32597828e-01f, -2.33864225e-02f, 3.87364961e-02f, 1.36817664e-01f,
  7.89098814e-03f, 8.66503343e-02f, -5.29699549e-02f, -2.83038039e-02f, -3.54985371e-02f, -1.34996444e-01f, -1.99943185e-01f, -2.92406112e-01f, -6.97843954e-02f, -1.21443033e-01f,
  -6.29027486e-02f, -1.06937923e-02f, -4.64473628e-02f, 2.96458788e-03f, -1.37073651e-01f, -2.73510758e-02f, 5.44031821e-02f, 5.38581563e-03f, -5.53291477e-03f, 9.27856471e-03f,
  -7.59245642e-03f, 3.05065196e-02f, 1.49534047e-01f, -3.58712412e-02f, 7.78647065e-02f, -6.19685417e-03f, -4.88915220e-02f, 3.91850434e-02f, 9.22823846e-02f, -9.14212689e-02f,
  -1.14800401e-01f, -2.99152154e-02f, -2.27198992e-02f, 2.59920526e-02f, -1.46716293e-02f, -4.02099490e-02f, 2.54094955e-02f, -3.61688323e-02f, -7.61028985e-03f, 2.53791083e-02f,
  -3.44364271e-02f, -3.18639468e-05f, 2.71111424e-03f, -5.30749410e-02f, -3.07377726e-02f, -8.38142410e-02f, 1.48643199e-02f, -5.86167611e-02f, -2.39061527e-02f, 6.01561069e-02f,
  1.05832793e-01f, 1.39882667e-02f, 8.04325100e-03f, 6.36033192e-02f, 2.55533848e-02f, 5.49500138e-02f, -1.85577124e-02f, -1.31692458e-02f, 1.96875967e-02f, -9.60531682e-02f,
  5.73962890e-02f, 1.00096457e-01f, 2.38080602e-02f, -5.57734594e-02f, 4.49813250e-03f, 8.57320353e-02f, -9.32940841e-02f, 7.85736814e-02f, 1.41528784e-03f, 7.11748302e-02f,
  5.11986166e-02f, 8.22007954e-02f, 5.25692329e-02f, 4.70792912e-02f, -3.20204603e-03f, 7.66779808e-03f, -1.06726894e-02f, 1.07855700e-01f, -4.75038253e-02f, 2.08256152e-02f,
  2.63161976e-02f, 1.10443503e-01f, 8.63628238e-02f, 1.95285771e-02f, 7.53128529e-02f, -3.86088639e-02f, -4.35602181e-02f, -5.67399301e-02f, 3.77265103e-02f, -9.63886902e-02f,
  2.60148812e-02f, 3.32971103e-02f, -4.53857332e-02f, 4.82176691e-02f, -6.96537923e-03f, 8.14992711e-02f, 2.51390729e-02f, -1.48605421e-01f, -3.53294164e-02f, -5.00512682e-03f,
  3.87622893e-01f, 1.72813788e-01f, 6.98346645e-02f, 1.37521222e-01f, -1.75502673e-01f, 6.56052902e-02f, -8.84598419e-02f, -2.70545413e-03f, 1.44150928e-01f, 2.59504523e-02f,
  5.25815785e-02f, 8.79384652e-02f, -1.06549747e-01f, 2.07908064e-01f, 7.27908313e-02f, 2.42198389e-02f, 1.57488450e-01f, 1.51183873e-01f, -1.45307453e-02f, 5.45812361e-02f,
  1.07903056e-01f, -9.43002664e-03f, 3.29617271e-03f, -8.98624584e-02f, 9.71703827e-02f, 1.02167532e-01f, -1.06147662e-01f, -2.58410834e-02f, -6.06132448e-02f, -1.81645621e-02f,
  1.21398136e-01f, 6.21643029e-02f, -1.40637876e-02f, -1.23702465e-02f, 8.08302313e-02f, 5.82221802e-03f, -6.88445717e-02f, -5.84723726e-02f, -1.10038109e-01f, 5.12924381e-02f,
  1.08864136e-01f, -8.63988400e-02f, 5.42399995e-02f, 9.07178521e-02f, 4.55311574e-02f, 5.71916662e-02f, -2.15621628e-02f, 4.04520743e-02f, 6.04125597e-02f, 3.17029352e-03f,
  1.23159453e-01f, 7.90033210e-03f, -8.27660486e-02f, 3.41890305e-02f, 3.93618569e-02f, 2.55530458e-02f, 8.45392793e-02f, 4.78354935e-03f, 1.12049520e-01f, 8.49734768e-02f,
  1.10990733e-01f, 6.47875518e-02f, 2.84789894e-02f, 3.45195644e-02f, -1.57610141e-02f, 1.42535958e-02f, 4.97713685e-02f, -2.57464387e-02f, 5.60688563e-02f, 8.98054335e-03f,
  -2.03355402e-02f, -7.09211826e-02f, 2.38404181e-02f, -2.63998588e-03f, 7.90016279e-02f, 2.56456882e-02f, -2.12277211e-02f, 5.43181272e-03f, 4.09122221e-02f, 7.62929767e-02f,
  1.70195904e-02f, -1.76654011e-02f, -4.62764949e-02f, -4.62617129e-02f, -1.25820339e-01f, -6.45291284e-02f, 3.95005606e-02f, -3.60480733e-02f, 1.60164516e-02f, -1.01201579e-01f,
  8.59057251e-03f, -1.95854832e-03f, -5.90193197e-02f, 4.53870967e-02f, -1.00332074e-01f, 6.47008494e-02f, -7.25311041e-02f, 7.78702348e-02f, -6.03047572e-02f, -4.01330516e-02f,
  5.55405021e-02f, -1.50825515e-01f, -1.87289286e-02f, -6.92240987e-03f, 4.83642193e-03f, -1.24602988e-02f, 1.50802732e-03f, -3.60487178e-02f, -1.40054161e-02f, 1.04561634e-01f,
  -8.65586549e-02f, -1.45286825e-02f, -6.03032149e-02f, -5.44614792e-02f, -5.65190278e-02f, 2.28095986e-02f, 6.44404814e-02f, 4.29394990e-02f, -4.02677432e-02f, 5.68992011e-02f,
  -5.75230271e-03f, 3.48896325e-01f, 1.69922888e-01f, 1.07473530e-01f, 1.80362836e-01f, -8.41748863e-02f, -4.16788235e-02f, 3.84631474e-03f, -2.46083345e-02f, 9.60854217e-02f,
  -9.39982831e-02f, 1.98135674e-01f, -4.36591990e-02f, -8.83180201e-02f, -3.43912721e-01f, -2.38498434e-01f, -1.05524734e-01f, -1.15151808e-01f, -7.50257596e-02f, 6.27625883e-02f,
  -3.36363129e-02f, -4.28941660e-02f, 3.28458399e-02f, 3.49893309e-02f, 1.25914723e-01f, 1.43715218e-01f, -5.03335730e-04f, 1.13124056e-02f, -5.46354894e-03f, -2.01563612e-02f,
  1.56688709e-02f, -8.72696936e-03f, 2.35608357e-04f, 3.31665240e-02f, -1.28546432e-01f, -8.65621641e-02f, 4.00904417e-02f, -9.54051837e-02f, 2.08761021e-02f, -6.68231025e-02f,
  8.41299295e-02f, -5.93272373e-02f, 4.10512201e-02f, -6.41332939e-02f, 7.57109746e-02f, -7.73672685e-02f, -1.87597368e-02f, 1.59357965e-01f, -3.39201391e-02f, 2.28724014e-02f,
  7.04821199e-02f, 9.13580041e-03f, -6.70715934e-03f, 1.17918970e-02f, -3.34587023e-02f, -5.92601746e-02f, 5.97250042e-03f, 1.02273978e-01f, 1.17954180e-01f, -6.63060769e-02f,
  9.23421234e-02f, -9.05719995e-02f, 2.28765588e-02f, 3.44109796e-02f, 3.35455015e-02f, 1.31907128e-02f, -2.04190779e-02f, -3.94407734e-02f, -7.79464096e-02f, -9.16187316e-02f,
  -8.94001499e-02f, 6.29060194e-02f, -3.62491719e-02f, -3.12874317e-02f, 4.67290543e-03f, 2.62355637e-02f, 8.44648033e-02f, -2.46101734e-03f, 2.55681667e-02f, 6.31179661e-02f,
  8.02086145e-02f, -3.71853113e-02f, -6.19006976e-02f, 9.01471823e-04f, -3.95892486e-02f, -8.54910836e-02f, -1.27331480e-01f, 5.01071773e-02f, 3.81977670e-02f, -1.25076594e-02f,
  -2.52683973e-03f, 7.82737043e-03f, 2.56999992e-02f, -2.37672329e-02f, -6.97225099e-03f, -7.73725584e-02f, -3.55531275e-02f, 1.09173231e-01f, -2.41449364e-02f, -1.03879079e-01f,
  1.37195429e-02f, 7.96196684e-02f, -1.89909898e-02f, -5.13198748e-02f, -1.23320408e-01f, -3.36729549e-02f, 4.51826192e-02f, 2.38791686e-02f, 5.08773625e-02f, -5.45877963e-02f,
  1.61253512e-01f, 3.69544402e-02f, 3.36602218e-02f, 8.75403136e-02f, 4.75940630e-02f, 6.24613166e-02f, 5.87669052e-02f, 5.91012165e-02f, 1.14058033e-01f, -5.53657068e-03f,
  2.43111864e-01f, -2.12720171e-01f, 2.86982320e-02f, 1.96858987e-01f, 1.60415202e-01f, 6.12057075e-02f, 1.45406157e-01f, 1.06663451e-01f, 2.40668446e-01f, -1.07193455e-01f,
  -3.57021280e-02f, 8.81873965e-02f, -8.15314129e-02f, 1.70651481e-01f, 1.91998243e-01f, -8.37310031e-02f, 9.86119509e-02f, 5.91860265e-02f, 1.56087950e-02f, 5.32111786e-02f,
  1.44831479e-01f, 5.81053682e-02f, -3.41106281e-02f, -3.34702842e-02f, -2.60767825e-02f, -3.66799049e-02f, -1.05266318e-01f, -4.51833718e-02f, -5.35684917e-03f, -9.03181583e-02f,
  -5.22517711e-02f, 2.88623944e-02f, -2.74328608e-02f, 3.26151997e-02f, -2.26439554e-02f, -5.59293889e-02f, 7.42768720e-02f, 3.39066610e-02f, 7.96867535e-02f, 3.53826955e-02f,
  -1.19621456e-02f, -1.41869187e-02f, -4.92885802e-03f, -4.57490655e-03f, -2.38134023e-02f, -2.28727981e-02f, 8.68393704e-02f, 9.70312804e-02f, 8.09658393e-02f, -1.54360048e-02f,
  -3.63483578e-02f, -3.32836695e-02f, -4.92000207e-02f, -9.05302987e-02f, 2.34534498e-02f, 4.97320388e-03f, -7.72871971e-02f, 1.48423575e-02f, -4.81671318e-02f, 6.10449985e-02f,
  1.08424462e-01f, -4.86983657e-02f, -9.05279256e-03f, -3.11658680e-02f, 2.76836324e-02f, 8.27953294e-02f, 5.63462730e-03f, 1.07726334e-02f, 1.15989083e-02f, 9.86380503e-03f,
  4.76564094e-02f, -8.94684121e-02f, 7.83362165e-02f, -4.54274863e-02f, -2.91276164e-02f, 9.39228848e-05f, -7.15550035e-02f, -6.35072216e-02f, 6.13379255e-02f, 6.32014647e-02f,
  5.26220016e-02f, 5.81736788e-02f, -1.11386448e-01f, -2.16258578e-02f, 3.38095352e-02f, -7.95684680e-02f, 1.09877260e-02f, -3.11214998e-02f, 6.94740191e-02f, -8.98827687e-02f,
  -7.90426973e-03f, -1.09141678e-01f, 3.30314226e-02f, 2.06291135e-02f, 9.40235853e-02f, -1.25218034e-01f, 1.05784438e-03f, 1.05657512e-02f, -4.99580279e-02f, 3.05236690e-02f,
  1.74464732e-02f, 3.84849384e-02f, 3.62278335e-03f, -2.31490228e-02f, -7.62932226e-02f, 1.08162276e-02f, 2.29937606e-03f, 3.63569930e-02f, 6.74784258e-02f, -4.15048636e-02f,
  -5.45473173e-02f, 4.95149270e-02f, 3.00434809e-02f, -4.96536084e-02f, 4.64433618e-02f, -4.42325063e-02f, -2.09001880e-02f, -1.35304943e-01f, -7.08404183e-02f, -5.78818992e-02f,
  -1.49376914e-02f, -1.00174427e-01f, -1.62611917e-01f, 8.43297541e-02f, 1.41725421e-01f, -8.75875726e-03f, -7.41099343e-02f, 3.54427658e-02f, -1.31769791e-01f, 3.92879918e-02f,
  3.84079851e-02f, -1.70455910e-02f, -1.14559278e-01f, 1.19157016e-01f, 7.17853829e-02f, -1.94539875e-01f, 9.37025398e-02f, -6.82136882e-03f, -2.81102229e-02f, 1.56904802e-01f,
  6.05241731e-02f, 1.55192941e-01f, -4.14285995e-02f, 1.71075612e-01f, 2.06451137e-02f, 2.82696933e-02f, 2.73197353e-01f, -7.13880360e-02f, 2.05189854e-01f, 1.45092428e-01f,
  4.19543758e-02f, 3.72534879e-02f, -6.16734885e-02f, 1.23208412e-03f, 9.54905525e-02f, 1.80980936e-02f, -3.08716334e-02f, 9.36612710e-02f, 6.30308613e-02f, 3.26865055e-02f,
  -6.71372190e-02f, 5.82784340e-02f, 3.78904454e-02f, 6.56557232e-02f, -3.54260206e-02f, 1.00062631e-01f, -3.01489811e-02f, 4.88919504e-02f, -9.99623463e-02f, -3.54157239e-02f,
  -1.07877158e-01f, 4.13451493e-02f, 4.47210409e-02f, -3.61565016e-02f, -7.77525082e-02f, 5.52646592e-02f, -2.61428095e-02f, 3.52841765e-02f, 7.92236552e-02f, 4.28632237e-02f,
  7.10061416e-02f, 5.70147522e-02f, 1.07790967e-02f, -2.94740330e-02f, -2.91811656e-02f, -2.70429421e-02f, 5.28544672e-02f, 6.42803684e-02f, -8.52969438e-02f, 4.02797200e-02f,
  -5.69432676e-02f, 6.33614659e-02f, 6.92349374e-02f, -3.23031321e-02f, 7.41710365e-02f, 4.81438264e-02f, -8.14169645e-02f, 2.19684318e-02f, -3.06549519e-02f, -1.53350970e-02f,
  4.39397693e-02f, 1.94044486e-02f, -4.88288850e-02f, -5.99276200e-02f, -5.96510805e-02f, -3.26155052e-02f, 3.00692134e-02f, -4.83443262e-03f, -9.98078138e-02f, 3.16033922e-02f,
  -3.99848633e-03f, 6.55276403e-02f, 1.20168403e-02f, -1.95103828e-02f, -7.78751299e-02f, 1.29278954e-02f, 4.10594754e-02f, 1.07159913e-01f, 4.72589359e-02f, -7.70005137e-02f,
  5.81516512e-03f, -3.55486497e-02f, 3.71235870e-02f, -5.72944470e-02f, 5.27572818e-02f, 1.38795441e-02f, 3.33811855e-03f, -1.65240299e-02f, 8.59148726e-02f, 1.03118597e-02f,
  8.71618539e-02f, -8.43344182e-02f, 4.36538234e-02f, 5.10066859e-02f, -3.39376330e-02f, -7.02641010e-02f, 2.75363084e-02f, 3.32499407e-02f, 2.76589990e-02f, -6.57545030e-02f,
  1.57214165e-01f, 9.83808562e-03f, -1.87456027e-01f, 1.96846247e-01f, 5.17562442e-02f, 1.68985754e-01f, 7.85097778e-02f, 1.79270387e-01f, 2.81988263e-01f, -8.40139668e-03f,
  2.28722170e-01f, -2.91702729e-02f, -9.71843153e-02f, 1.10473365e-01f, 9.07036439e-02f, 1.01642951e-01f, 1.38528377e-01f, 1.43651918e-01f, -5.79310581e-02f, 1.72490731e-01f,
  1.06695428e-01f, 1.70798019e-01f, -7.90013298e-02f, -1.09434262e-01f, 1.11879602e-01f, -1.97246462e-01f, -4.76333946e-02f, -1.91102415e-01f, 5.16602844e-02f, -6.48179203e-02f,
  3.17586847e-02f, 1.51339183e-02f, -8.02040398e-02f, -1.11995809e-01f, 6.13260381e-02f, -4.53002304e-02f, -5.32211103e-02f, -1.31392702e-01f, -1.66141782e-02f, 7.29073538e-04f,
  -5.32166623e-02f, 6.41025184e-03f, 1.40537517e-02f, 4.56918739e-02f, -2.71538347e-02f, 2.17300411e-02f, 9.68845040e-02f, 5.71191087e-02f, -7.93179274e-02f, 8.55492353e-02f,
  -1.37286559e-02f, 4.32370463e-03f, 5.03746755e-02f, -1.43105626e-01f, 5.45013845e-02f, 6.13388158e-02f, 6.87986836e-02f, 4.42941819e-04f, 3.47819291e-02f, -3.17731053e-02f,
  -2.62440625e-03f, -7.23755509e-02f, 5.51330373e-02f, 5.61434850e-02f, 6.09442927e-02f, -1.06207557e-01f, -6.29977733e-02f, -3.68942991e-02f, 4.65051122e-02f, -2.25249175e-02f,
  5.62291779e-02f, -6.83521181e-02f, -3.52021493e-02f, -1.24874925e-02f, -2.18264237e-02f, -3.86645980e-02f, -2.10984480e-02f, 1.54170450e-02f, 6.33292422e-02f, 6.40057996e-02f,
  2.70268861e-02f, 3.73778455e-02f, 7.36099668e-03f, -3.53253372e-02f, -9.29613262e-02f, -2.03560237e-02f, 1.17549561e-01f, 6.01733029e-02f, 4.63917553e-02f, 1.93972569e-02f,
  3.32726352e-02f, -1.38305813e-01f, 2.86934879e-02f, 2.50860490e-02f, -4.72432971e-02f, 8.18990842e-02f, -1.10890619e-01f, -8.43801722e-02f, 1.19047398e-02f, 1.22908376e-01f,
  -1.92356054e-02f, 4.01917025e-02f, -6.56429976e-02f, 1.33936331e-01f, -7.71831200e-02f, 7.76767731e-02f, 5.94898239e-02f, -1.09962612e-01f, -7.74788558e-02f, -8.79980810e-03f,
  -1.57841612e-02f, -7.84295499e-02f, -3.19266543e-02f, -7.19352886e-02f, 1.28670812e-01f, -1.03968523e-01f, -3.01042926e-02f, 1.23653552e-02f, -6.60704300e-02f, 8.14966112e-02f,
  1.26917688e-02f, -2.45816484e-01f, 4.83638905e-02f, 4.75046076e-02f, 1.30630210e-01f, -6.94265813e-02f, 1.46430880e-01f, -1.49689317e-01f, 2.64521595e-02f, -1.70797825e-01f,
  7.90908113e-02f, -6.05782792e-02f, 2.74343044e-02f, -1.90424785e-01f, 1.54710114e-01f, -3.86074409e-02f, -1.92147955e-01f, -2.43229736e-02f, 7.86969811e-02f, 6.98461309e-02f,
  -4.51920405e-02f, -1.00258127e-01f, -4.07945924e-02f, -2.06640720e-01f, -5.95991574e-02f, -6.77188039e-02f, -1.26214772e-01f, 1.07438579e-01f, -8.74781609e-02f, 1.60958260e-01f,
  -2.36386910e-01f, -1.81142855e-02f, -8.65332931e-02f, -5.89519627e-02f, -7.19667319e-03f, 9.42132100e-02f, -4.02505212e-02f, 8.43035132e-02f, 8.60541314e-02f, 2.32654773e-02f,
  4.94651049e-02f, 2.40984391e-02f, -8.37473944e-02f, 2.93272678e-02f, 1.87712128e-03f, -1.13235984e-03f, -1.57774175e-05f, -2.24952661e-02f, 6.43874705e-02f, 2.04093121e-02f,
  1.21921323e-01f, 1.23614939e-02f, -4.95289154e-02f, -6.35318682e-02f, -5.37781306e-02f, 6.31635040e-02f, -4.17694412e-02f, 3.78942788e-02f, -1.12092253e-02f, -2.93885283e-02f,
  5.87034300e-02f, -7.44055659e-02f, 9.48620513e-02f, 3.65209617e-02f, 1.82516947e-02f, -3.27014141e-02f, 5.78656979e-02f, 3.53610478e-02f, 3.30440514e-02f, 1.02884108e-02f,
  -1.04567870e-01f, 4.34475951e-02f, -1.52854323e-02f, 3.44175696e-02f, 1.76387858e-02f, -1.59687288e-02f, -3.18156518e-02f, -1.14126503e-01f, -7.85976127e-02f, -1.73789468e-02f,
  -1.14786297e-01f, -1.88885517e-02f, -6.02378361e-02f, 1.99803454e-03f, 7.58051500e-02f, 2.61357985e-02f, 1.87392049e-02f, 4.99374270e-02f, 3.23907076e-03f, 1.30325370e-03f,
  -3.51352185e-01f, -6.71578422e-02f, -6.24046475e-02f, -6.08242564e-02f, -8.93490985e-02f, -1.07002571e-01f, -2.55415738e-02f, 2.62723882e-02f, 8.64395034e-03f, 7.49004111e-02f,
  4.74461690e-02f, -1.81665607e-02f, -8.11053887e-02f, 5.89152239e-02f, 5.95506802e-02f, -8.93495381e-02f, 5.20377979e-02f, 2.99005024e-02f, -7.51882568e-02f, -1.55843124e-02f,
  2.14802008e-02f, -4.23648395e-02f, 1.05246985e-02f, -9.95519757e-02f, -8.37620795e-02f, 5.33868074e-02f, -9.20384005e-02f, -3.32764238e-02f, -2.94795819e-02f, 2.17882711e-02f,
  2.27655560e-01f, -1.57667547e-01f, -2.54634977e-03f, 2.84955669e-02f, 5.78397773e-02f, 1.97359174e-01f, 2.77011096e-01f, -8.76861736e-02f, -3.22326906e-02f, -5.18187843e-02f,
  2.30937481e-01f, 2.46085841e-02f, 5.46003617e-02f, 2.61507869e-01f, 2.82442629e-01f, 4.13369313e-02f, 2.53705740e-01f, 2.64766127e-01f, -4.69211973e-02f, 5.33810891e-02f,
  -5.22055402e-02f, 1.16076149e-01f, -7.44532719e-02f, -9.74606127e-02f, -5.77595010e-02f, -2.64930278e-01f, -1.17322363e-01f, -1.60029426e-01f, -5.68910390e-02f, 6.75799549e-02f,
  5.65344393e-02f, -1.76887661e-02f, -9.75137949e-03f, -6.42265975e-02f, 5.04852198e-02f, 4.41725366e-02f, 7.12530240e-02f, 7.69281294e-03f, 5.95913362e-03f, -4.36177999e-02f,
  -3.38887423e-03f, 5.00224270e-02f, -3.42329070e-02f, -5.95951080e-02f, -1.23572936e-02f, -1.35106653e-01f, -4.07639593e-02f, 3.39863114e-02f, -8.73879902e-03f, 6.94605783e-02f,
  1.03134019e-02f, 8.59566033e-02f, 3.42600197e-02f, 2.10946649e-02f, -2.89815981e-02f, 2.57411171e-02f, 3.09267198e-03f, -4.48054783e-02f, -1.11489117e-01f, -1.04103126e-01f,
  1.80778410e-02f, 9.37091634e-02f, 5.74713796e-02f, -3.20418589e-02f, 6.66266605e-02f, 2.47057434e-02f, 1.40905887e-01f, 7.00063333e-02f, -6.61328286e-02f, 3.55288200e-02f,
  -3.60096022e-02f, 3.96064594e-02f, 8.21306333e-02f, -2.49795169e-02f, -6.85510710e-02f, -1.00076757e-01f, -1.84245352e-02f, -9.55229625e-02f, -4.03054170e-02f, 9.40352795e-04f,
  -2.33958699e-02f, 3.07066496e-02f, -4.57333727e-03f, 1.72299240e-02f, -1.48148108e-02f, -5.16736601e-03f, 4.15682085e-02f, 3.56548578e-02f, 5.23552392e-03f, -2.07048878e-02f,
  9.79209617e-02f, -1.78291574e-02f, 6.73952848e-02f, -1.18633201e-02f, -1.33851198e-02f, 8.76181945e-02f, -3.12808454e-02f, 1.02824476e-02f, -7.03100041e-02f, -1.26556363e-02f,
  7.03740443e-05f, 5.25430404e-02f, 2.56714579e-02f, -6.04836680e-02f, 1.78897232e-02f, -3.92945409e-02f, -3.13382000e-02f, -3.54898088e-02f, -2.81065283e-03f, 2.28687730e-02f,
  3.58573049e-02f, 2.50371266e-03f, 1.18620634e-01f, -8.73570070e-02f, -5.21396622e-02f, 4.88321781e-02f, 2.79006250e-02f, -4.74991426e-02f, -6.22134423e-03f, 2.41491664e-02f,
  -3.06715101e-01f, 6.44807741e-02f, -1.72495656e-02f, -9.31617916e-02f, -8.17323923e-02f, -1.75099477e-01f, 5.43826297e-02f, 2.99156159e-02f, 1.69017196e-01f, 2.09648833e-01f,
  2.78495960e-02f, -1.04986124e-01f, 1.57759860e-01f, 6.40061572e-02f, 1.11395447e-02f, 1.70167401e-01f, -1.29795939e-01f, 5.34284376e-02f, -1.52459577e-01f, -1.15888320e-01f,
  -1.68280751e-01f, -9.80613157e-02f, -1.75571791e-03f, -3.91578265e-02f, -1.73512876e-01f, -1.43891692e-01f, 4.76554185e-02f, -9.90836471e-02f, -5.30229062e-02f, -5.06236730e-03f,
  -1.09933421e-01f, -9.81928688e-03f, -4.91853617e-03f, -1.06061762e-02f, 2.40830686e-02f, -5.23866788e-02f, -1.64978448e-02f, -6.92718998e-02f, 1.03826709e-02f, -4.73480113e-03f,
  -7.49359876e-02f, 9.57104284e-03f, -8.00538063e-02f, 1.14882462e-01f, 1.71093475e-02f, 2.67414544e-02f, 4.28970717e-02f, -1.02056384e-01f, -6.59381747e-02f, 1.56056955e-02f,
  -3.11443638e-02f, -9.55860093e-02f, 5.61069660e-02f, -4.97069545e-02f, -2.14340426e-02f, 1.17804082e-02f, 7.00723156e-02f, 1.74439065e-02f, -1.15445741e-01f, -1.68009177e-02f,
  4.13908027e-02f, -3.37621607e-02f, 3.69422659e-02f, 3.10896523e-02f, -7.10517690e-02f, 3.97455655e-02f, 1.09894127e-01f, -1.56888540e-03f, -4.63605672e-02f, -1.44717088e-02f,
  -1.24229036e-01f, 3.27243432e-02f, -1.13567682e-02f, 3.13229784e-02f, -1.38495713e-02f, 3.54651995e-02f, -5.24296947e-02f, 1.69216618e-02f, 1.93408914e-02f, 8.24243110e-03f,
  8.55027139e-02f, -2.08228201e-04f, 1.22221157e-01f, -2.18575224e-02f, 6.48588911e-02f, 3.67535651e-02f, 2.33585052e-02f, 6.12413287e-02f, 6.71149939e-02f, -5.77362701e-02f,
  -1.82830632e-01f, -1.44655183e-01f, 2.22881753e-02f, 1.97687838e-02f, -5.06886691e-02f, -3.03716417e-02f, -7.58904293e-02f, -7.22313523e-02f, 1.05211260e-02f, 1.77891832e-02f,
  5.19551262e-02f, 3.39116380e-02f, -1.29342854e-01f, 3.35044637e-02f, 3.00877560e-02f, -1.59361009e-02f, 6.24287948e-02f, 5.30764721e-02f, -8.33119899e-02f, -7.62185454e-02f,
  3.36746052e-02f, -8.44120607e-02f, 9.20030754e-03f, 1.00781560e-01f, 7.97580332e-02f, -6.74668476e-02f, 4.22608014e-03f, 3.14841350e-03f, 1.57560445e-02f, -1.86046138e-02f,
  1.94743678e-01f, -1.72107175e-01f, -5.45280054e-02f, 1.61273435e-01f, 1.10069580e-01f, 2.91970139e-03f, 3.66645418e-02f, -1.35690020e-02f, 1.63742840e-01f, -1.40400633e-01f,
  -1.07019328e-01f, -5.88792376e-02f, -2.15739205e-01f, 3.35104279e-02f, 6.89904243e-02f, -1.49446249e-01f, 2.20449772e-02f, -1.07655264e-01f, 7.54642561e-02f, -1.11400045e-01f,
  1.29386976e-01f, -5.65258972e-03f, 1.20201237e-01f, -8.20781961e-02f, 1.10606641e-01f, 1.34288639e-01f, 1.83724850e-01f, -1.22985467e-01f, -3.19444155e-03f, 1.30667567e-01f,
  -6.03161193e-03f, 2.22625192e-02f, -8.49765316e-02f, -1.93948578e-02f, 1.08484633e-01f, -1.06668510e-01f, -1.17365867e-01f, -1.05351679e-01f, 4.12748940e-02f, -2.45484728e-02f,
  -6.88380897e-02f, -7.68829882e-02f, 1.21909894e-01f, 4.79006208e-03f, 1.04289874e-01f, 1.77803282e-02f, 6.39517978e-02f, -6.43862113e-02f, 2.80027185e-02f, -3.48517448e-02f,
  -3.17703956e-03f, -6.83683231e-02f, 2.50774845e-02f, 6.35883659e-02f, -6.59671053e-02f, 1.03585341e-03f, 1.36954552e-02f, 6.80865198e-02f, -1.37102101e-02f, 4.85536503e-03f,
  -8.90479460e-02f, 1.43203717e-02f, -3.81009877e-02f, 8.29932317e-02f, -2.26199459e-02f, -1.24841451e-03f, 7.66711906e-02f, -1.45271597e-02f, 5.74492663e-02f, -6.78683370e-02f,
  -6.16114512e-02f, 4.33872938e-02f, 3.34979594e-02f, -9.03399810e-02f, 3.19982544e-02f, -7.26793855e-02f, 1.74451247e-02f, -9.89335701e-02f, 1.15616098e-02f, 7.99961910e-02f,
  -6.42884001e-02f, 2.93644499e-02f, -4.31449041e-02f, 2.56315432e-02f, 8.45041424e-02f, 5.12554906e-02f, -2.99131195e-03f, 9.38901212e-03f, 5.79018034e-02f, 4.64786552e-02f,
  -2.31446349e-03f, -1.40117824e-01f, 7.07046688e-02f, -8.81728232e-02f, -9.64149088e-03f, -3.22018340e-02f, -4.50607203e-02f, -3.34753022e-02f, -7.98451453e-02f, -9.66419815e-04f,
  -5.76451467e-03f, 7.02959225e-02f, 4.46224399e-02f, 2.34144903e-03f, 1.15838706e-01f, -2.08828468e-02f, 7.51492754e-02f, 2.90505644e-02f, -1.68922395e-02f, -1.27227113e-01f,
  4.13544886e-02f, 5.94636016e-02f, 5.98843060e-02f, 3.19147892e-02f, 4.94008586e-02f, -4.68181632e-02f, 2.11444926e-02f, 1.10387290e-02f, -4.38949838e-02f, 3.50983217e-02f,
  -1.68435708e-01f, -2.09876522e-01f, -1.52903199e-01f, -1.29263818e-01f, 2.00044625e-02f, -4.96953912e-02f, -6.04660623e-02f, -9.53392461e-02f, 1.34062305e-01f, 1.18210822e-01f,
  1.34726921e-02f, -4.88902535e-03f, 1.56317532e-01f, -6.15498275e-02f, -1.41811922e-01f, 6.16908520e-02f, -1.11406535e-01f, -5.63344359e-02f, -1.23169385e-02f, -1.07038170e-01f,
  -1.12975435e-02f, 5.79205863e-02f, -4.46841642e-02f, -3.20649482e-02f, -6.00826591e-02f, 2.12828373e-03f, 7.67855793e-02f, 2.23446544e-02f, 8.61776061e-04f, -2.93975901e-02f,
  -1.96998417e-01f, -1.32299215e-01f, -8.53813291e-02f, -3.91262770e-02f, -1.70704290e-01f, 7.77599141e-02f, 3.33701670e-02f, -1.71537101e-02f, -4.00308184e-02f, 3.61970216e-02f,
  -4.88879308e-02f, -3.52195799e-02f, -6.90582022e-02f, -6.36506081e-02f, 6.42500222e-02f, 3.85557525e-02f, 3.25289220e-02f, 3.09150992e-03f, -3.88518870e-02f, 3.03865154e-03f,
  -6.79864809e-02f, 3.59221883e-02f, -6.72060698e-02f, 6.92180321e-02f, -3.04659754e-02f, 4.40925919e-02f, 6.74626976e-02f, -3.96462232e-02f, -1.27521500e-01f, -3.43042761e-02f,
  -4.23080064e-02f, 1.51403427e-01f, 5.08896746e-02f, 7.66412392e-02f, 1.82225425e-02f, -9.35614016e-03f, -7.97636509e-02f, 5.95144108e-02f, -1.88491028e-02f, -9.96633060e-03f,
  -6.03877753e-03f, -6.46756887e-02f, -3.31573859e-02f, -7.50826225e-02f, -5.18271215e-02f, 5.76249249e-02f, -1.55487116e-02f, -3.50588933e-02f, -4.09249477e-02f, 4.47077043e-02f,
  -3.87199596e-02f, 4.60825153e-02f, 1.01942070e-01f, -6.22829348e-02f, -2.51029581e-02f, -5.52506968e-02f, -5.45012429e-02f, -7.71617144e-02f, -1.95653122e-02f, -8.88440683e-02f,
  -2.30186731e-01f, -1.41795322e-01f, 2.58794259e-02f, -9.41443369e-02f, 5.77286184e-02f, -7.20745027e-02f, -4.31618616e-02f, 3.32333930e-02f, 5.27778827e-02f, -1.86568331e-02f,
  -6.79996610e-03f, -4.24041832e-03f, -4.22701612e-02f, 3.79115418e-02f, -5.85522950e-02f, -1.59347747e-02f, 6.68517053e-02f, -4.42462452e-02f, 3.53006907e-02f, 1.26328850e-02f,
  -7.40597770e-02f, 4.38693212e-03f, 4.46717665e-02f, 3.15648243e-02f, -1.50498208e-02f, 4.72195745e-02f, 3.16738822e-02f, -5.28451465e-02f, -5.90231232e-02f, -8.08159336e-02f,
  3.66269827e-01f, 1.15827238e-02f, 2.50443555e-02f, 1.46287054e-01f, 1.39308691e-01f, 4.92291711e-02f, -8.55397359e-02f, 8.92560035e-02f, 2.08237246e-01f, -2.45589335e-02f,
  -2.83114891e-02f, -8.66786018e-03f, -1.53437063e-01f, 1.36990204e-01f, -1.67548165e-01f, -1.07780308e-01f, 1.22360267e-01f, 1.62483558e-01f, 6.97129965e-02f, 6.26471639e-02f,
  8.75331014e-02f, -6.85255229e-02f, -8.81455094e-02f, -1.54490769e-01f, 2.90840175e-02f, 8.68431628e-02f, -4.40139957e-02f, -1.73031151e-01f, 3.08960862e-02f, -6.39053136e-02f,
  4.64291424e-02f, -2.09042467e-02f, 8.34760219e-02f, 4.34339046e-02f, -5.53016327e-02f, 7.72453994e-02f, -1.02786846e-01f, -3.99549631e-03f, -9.97263789e-02f, 1.86284408e-02f,
  3.09437290e-02f, -2.69657150e-02f, -4.27096970e-02f, -8.81834924e-02f, 9.48451832e-02f, -3.42757963e-02f, 5.95222740e-03f, -2.37015206e-02f, -4.60686311e-02f, -3.71768475e-02f,
  6.08074144e-02f, -4.22891378e-02f, 3.26475352e-02f, 2.83419471e-02f, -9.20995548e-02f, 2.72091646e-02f, -8.53458792e-02f, -7.25564361e-02f, -2.09847698e-03f, 1.56934969e-02f,
  7.22243637e-02f, -1.68732461e-02f, 4.52684723e-02f, -2.13568602e-02f, 8.99748877e-02f, -6.77050883e-03f, -1.09930858e-01f, -8.69332105e-02f, -5.80192655e-02f, 5.69441635e-03f,
  5.14977146e-03f, -2.91784760e-02f, 2.79923994e-02f, 1.17976367e-02f, -6.69770911e-02f, -1.23254694e-02f, 2.59833969e-02f, 2.23404691e-02f, -4.51913513e-02f, -5.34281507e-02f,
  -8.41090605e-02f, -1.38851078e-02f, 3.42901854e-04f, 6.33861404e-03f, 1.48041630e-02f, 8.17973912e-02f, 5.16201593e-02f, 4.49592769e-02f, 6.07314669e-02f, -1.38938362e-02f,
  3.11895236e-02f, -1.34399608e-02f, -4.86690961e-02f, 2.55226903e-02f, 1.33399628e-02f, 3.92057821e-02f, -1.24508433e-01f, 1.14947267e-01f, -1.64363114e-03f, -4.19825017e-02f,
  -2.36483719e-02f, -3.40912789e-02f, -2.92142350e-02f, 3.48157957e-02f, -3.58935707e-04f, -2.76223123e-02f, -6.98833019e-02f, 1.28821330e-02f, -1.19994819e-01f, -6.47295192e-02f,
  6.28136843e-02f, 9.40917153e-03f, 4.85329032e-02f, 6.71378896e-02f, -2.02734582e-02f, -1.06127247e-01f, 7.58450925e-02f, -3.96928750e-02f, -5.00275567e-03f, -1.19150199e-01f,
  2.71262616e-01f, -2.88212836e-01f, -5.06317057e-02f, 2.10841686e-01f, 1.43869832e-01f, 4.05244045e-02f, 1.60465285e-01f, 8.65056515e-02f, -1.27401575e-01f, -7.69010559e-02f,
  -8.33643824e-02f, -1.13653526e-01f, -1.50203183e-01f, 5.09479046e-02f, 2.61022359e-01f, -1.32857770e-01f, 7.11270198e-02f, -1.04310997e-01f, -1.21758617e-01f, -8.27798396e-02f,
  -1.20705497e-02f, 4.48183008e-02f, 1.09193936e-01f, 3.20721306e-02f, 1.97109714e-01f, -1.12509755e-02f, 6.64184615e-02f, 1.19922988e-01f, 1.29497796e-01f, 1.44499794e-01f,
  7.67306536e-02f, -6.98809549e-02f, 6.23860471e-02f, -4.57795896e-02f, -3.86649556e-02f, 3.93996947e-02f, 8.60295221e-02f, -1.29822250e-02f, 3.55326198e-02f, -9.56220180e-02f,
  -4.05914932e-02f, -4.81201746e-02f, -3.18744481e-02f, 5.33635952e-02f, 2.15216260e-02f, 3.58819142e-02f, -2.67270114e-02f, 2.88022105e-02f, -9.57286824e-03f, -6.24845736e-02f,
  -9.41663533e-02f, -3.07684820e-02f, 6.61542080e-03f, -3.58257443e-02f, -4.97955866e-02f, 1.27927540e-02f, 3.87888476e-02f, 7.26507306e-02f, -2.62491424e-02f, 1.05090789e-01f,
  -3.64953503e-02f, 6.94891885e-02f, -1.96662592e-03f, 1.20765924e-01f, 1.00700952e-01f, -4.19576652e-02f, -5.88162802e-02f, -1.03359960e-01f, -4.45173010e-02f, 1.94359776e-02f,
  -6.55092020e-03f, -4.13414352e-02f, -7.69653171e-02f, 6.83074743e-02f, -3.78772020e-02f, -3.41092274e-02f, 7.63587058e-02f, 4.06270139e-02f, 3.76879126e-02f, -2.52992827e-02f,
  -8.50494131e-02f, 4.52711619e-02f, -2.00848132e-02f, -2.01121159e-02f, 3.30936126e-02f, -1.31324064e-02f, 6.13061851e-03f, 5.80989011e-02f, -5.18870167e-02f, 4.74163257e-02f,
  -1.23417154e-01f, -2.08101377e-01f, 2.81699118e-03f, 9.78958681e-02f, -5.19389361e-02f, -1.29277939e-02f, -8.38124473e-03f, 5.88896498e-02f, 4.74155787e-03f, -3.66932899e-02f,
  -3.83767113e-02f, 7.00089484e-02f, -3.83723117e-02f, 6.69450760e-02f, 1.26848236e-01f, 2.17920635e-02f, -1.26690313e-01f, -5.82968183e-02f, -6.63597956e-02f, 3.42715008e-04f,
  7.32660294e-02f, -6.51732609e-02f, 3.30834948e-02f, -2.75380048e-03f, -4.95533012e-02f, -1.00110853e-02f, 2.00495832e-02f, -4.26964872e-02f, -2.99336202e-03f, -2.56667249e-02f,
  -2.30230451e-01f, -1.00207500e-01f, 1.88547656e-01f, -9.49792266e-02f, -7.45616853e-02f, -8.08160752e-03f, -6.06582640e-03f, -1.16768286e-01f, -6.87760413e-02f, -4.24869638e-03f,
  -3.03538982e-02f, -1.16075035e-02f, 1.70067437e-02f, -7.57387131e-02f, 1.32998213e-01f, 3.75508405e-02f, -6.70009479e-02f, -1.31362677e-01f, -8.77044126e-02f, -1.21087372e-01f,
  4.69343588e-02f, -7.51897693e-02f, -9.03919153e-03f, -7.20628798e-02f, 3.94628085e-02f, -2.42966637e-02f, -1.05070032e-01f, 6.75251009e-03f, -7.91378766e-02f, 1.35187823e-02f,
  -1.14650458e-01f, -1.29791930e-01f, -1.11547992e-01f, -3.91740166e-02f, 3.60067599e-02f, -5.59063405e-02f, -2.76171286e-02f, 7.07565024e-02f, -8.90669897e-02f, -3.34082171e-03f,
  2.67436891e-03f, -2.32302062e-02f, -1.58964042e-02f, -1.91793852e-02f, -1.35210846e-02f, 9.39200222e-02f, -4.96275770e-03f, -5.43789528e-02f, 1.51538206e-02f, 1.70769766e-01f,
  4.63664159e-02f, -1.45012233e-02f, -6.96248487e-02f, -3.68988886e-02f, 9.10014436e-02f, -3.32243443e-02f, 1.86989158e-02f, 9.99156237e-02f, -1.60629563e-02f, -6.00850545e-02f,
  7.79327154e-02f, 8.55677575e-02f, -6.89717662e-03f, 5.05641997e-02f, 7.96937644e-02f, 3.36866193e-02f, 7.31597617e-02f, -1.85495485e-02f, 2.86944173e-02f, -2.88812164e-02f,
  -6.44090548e-02f, -1.61169749e-02f, 1.23244701e-02f, -9.18072984e-02f, -4.20841016e-02f, -5.85256778e-02f, 5.94283640e-02f, -1.16842175e-02f, 2.08152216e-02f, -1.72753811e-01f,
  5.51583581e-02f, 4.13580835e-02f, 2.87161209e-02f, 6.08309768e-02f, -5.55185154e-02f, 3.91048305e-02f, -1.58413932e-01f, 3.51381600e-02f, -9.67557058e-02f, 7.59350806e-02f,
  -2.77940005e-01f, -1.18015073e-01f, -2.28817705e-02f, 2.64276471e-02f, -7.77384937e-02f, -1.71914902e-02f, -3.02969888e-02f, 5.66656105e-02f, -4.97961231e-02f, 5.33175878e-02f,
  -4.99579683e-02f, -2.87469067e-02f, -2.13732123e-02f, 4.40363213e-02f, -5.77684455e-02f, 5.73868416e-02f, -6.50321990e-02f, -1.56738306e-03f, 7.41558149e-03f, -9.67372432e-02f,
  3.28753926e-02f, 6.27902150e-03f, 1.17755122e-01f, -8.05957094e-02f, -1.52790686e-03f, -1.65300779e-02f, -3.19492724e-03f, 8.16081837e-02f, -1.13714347e-02f, 4.03024852e-02f,
  -4.20431718e-02f, -3.49976242e-01f, -8.18666071e-03f, 2.61990577e-01f, 7.48209134e-02f, -8.19499046e-02f, 2.57141478e-02f, -6.28271922e-02f, -1.27322599e-01f, -1.90188363e-01f,
  1.65691033e-01f, 6.70777783e-02f, -6.49529994e-02f, 1.26296207e-01f, 2.98940986e-01f, -4.83373776e-02f, 2.25154117e-01f, 1.53552860e-01f, -2.56663654e-02f, 2.38760263e-02f,
  1.12808831e-01f, 1.94846481e-01f, 1.81606397e-01f, -9.45042074e-02f, 9.71335098e-02f, 3.72999199e-02f, 2.05335677e-01f, -9.36247632e-02f, 9.77454409e-02f, 1.34869024e-01f,
  -7.03574345e-02f, 5.27438074e-02f, 7.64958113e-02f, -1.41090721e-01f, -7.46712163e-02f, 1.07320007e-02f, -3.02116107e-02f, 1.10776320e-01f, -1.27780726e-02f, 4.87656780e-02f,
  -5.14988080e-02f, 9.58567951e-03f, 9.92293954e-02f, -2.23496351e-02f, 2.80447602e-02f, -3.74756902e-02f, -2.53315773e-02f, -5.30337542e-02f, 2.49889139e-02f, -3.42027396e-02f,
  7.67618716e-02f, -9.84854717e-03f, 8.21565539e-02f, -1.84179451e-02f, -1.18953651e-02f, 6.71075806e-02f, -3.61265130e-02f, 5.55214286e-03f, -1.47365332e-02f, -7.97232687e-02f,
  -4.29528877e-02f, 1.53591428e-02f, 5.57686575e-02f, 1.92377679e-02f, 5.58026433e-02f, 7.03429431e-03f, -7.51673281e-02f, 1.05306990e-02f, -8.52790009e-03f, -1.93958320e-02f,
  7.86194503e-02f, 1.63350347e-02f, -1.88927464e-02f, -6.03838451e-02f, -4.83925715e-02f, -7.53588676e-02f, 1.99183286e-03f, -7.78783709e-02f, -9.61421356e-02f, 4.60770819e-03f,
  -3.95475030e-02f, 5.33848442e-03f, 5.55940308e-02f, -4.86163870e-02f, -3.50775011e-02f, -6.90285340e-02f, 5.32104000e-02f, -8.52249861e-02f, 4.73627746e-02f, 4.04752698e-03f,
  -2.02357739e-01f, -5.84434085e-02f, -7.72020742e-02f, -9.92289484e-02f, -4.25038822e-02f, -7.99234360e-02f, 1.60588250e-02f, -9.83717665e-02f, -1.16053432e-01f, 4.51371372e-02f,
  5.88552691e-02f, 6.66421726e-02f, 4.43587378e-02f, 2.92594228e-02f, 2.38050167e-02f, -6.76966459e-02f, 2.84309834e-02f, -7.67424703e-02f, -4.85861703e-04f, 5.84199354e-02f,
  -8.64397883e-02f, 4.91717607e-02f, 6.90147355e-02f, -2.09566113e-02f, -1.40487566e-03f, 8.58849660e-03f, -6.23296201e-02f, 2.91994605e-02f, 3.55045199e-02f, -1.48135036e-01f,
  3.75644080e-02f, -9.58924890e-02f, -1.15906581e-01f, 7.12954700e-02f, -1.37749091e-01f, -1.34223282e-01f, -1.74376518e-01f, -8.38980898e-02f, -1.51673794e-01f, -2.11192816e-01f,
  8.29344317e-02f, -4.32243757e-02f, 5.59334420e-02f, -3.86746228e-02f, 2.89260566e-01f, 8.80300179e-02f, -7.46748000e-02f, 5.86246513e-02f, 8.64015296e-02f, -1.24687113e-01f,
  1.14589848e-01f, -3.22441533e-02f, 9.40967873e-02f, 1.69954151e-02f, -1.33465916e-01f, -5.26765781e-03f, 9.27618891e-02f, 1.37698352e-02f, 8.95504951e-02f, -8.18594396e-02f,
  6.92305863e-02f, 7.83208087e-02f, 1.79728959e-02f, -3.67121510e-02f, 3.13446224e-02f, 3.62638086e-02f, 5.69524318e-02f, -4.57130186e-03f, 8.43057409e-02f, -3.48098017e-02f,
  2.57631652e-02f, -1.38520384e-02f, -4.77112643e-02f, 5.94767258e-02f, -2.68799383e-02f, -4.94934954e-02f, 5.34928851e-02f, -8.41722712e-02f, 8.28679353e-02f, -2.22993921e-03f,
  -1.06298709e-02f, -5.67809194e-02f, -3.30821313e-02f, 1.47453118e-02f, 8.68181661e-02f, -1.12252988e-01f, -4.48947959e-02f, -5.83171435e-02f, 9.42725539e-02f, 5.48010729e-02f,
  -1.64700244e-02f, -7.73014352e-02f, -4.84924503e-02f, 4.60875593e-02f, 1.23034241e-02f, 9.02671814e-02f, 4.94996384e-02f, 4.25197892e-02f, 8.74488056e-03f, 1.60667840e-02f,
  7.90231153e-02f, 4.96072210e-02f, -3.91331464e-02f, -1.45233989e-01f, -3.14343572e-02f, 5.79936393e-02f, -1.13766650e-02f, -6.75069466e-02f, -9.01953876e-02f, -7.58114755e-02f,
  6.01367168e-02f, -4.60387319e-02f, 1.86422523e-02f, 1.38241043e-02f, 4.23600003e-02f, -2.06175502e-02f, 3.31150033e-02f, -6.65881857e-02f, -5.04650399e-02f, 1.03948032e-02f,
  7.18315765e-02f, 5.94318008e-05f, 5.22700744e-03f, -1.98347904e-02f, 9.22350287e-02f, 8.10769126e-02f, -5.23224333e-03f, 4.59996052e-02f, -1.24062505e-03f, 5.26605733e-02f,
  2.02860925e-02f, -5.87701378e-03f, -5.07767424e-02f, -4.46821526e-02f, -6.32576942e-02f, -3.03754751e-02f, 1.11464085e-03f, 1.49815619e-01f, 1.34003293e-02f, 1.70683805e-02f,
  1.11709945e-02f, -9.39787775e-02f, 1.22548304e-02f, 1.63836591e-03f, 4.17843461e-02f, 1.89372823e-02f, -7.98442960e-02f, -1.10101625e-02f, 1.50619829e-02f, -7.45113716e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 52)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 52;
const float L0_fan_Bp_bar_data[] = {
  1.87733740e-01f, 8.51008967e-02f, 1.25644267e-01f, 7.73929656e-02f, 1.47181794e-01f, 1.12705700e-01f, 8.52716565e-02f, 1.72470734e-01f, 2.03575820e-01f, -1.26707344e-03f,
  1.09534077e-01f, 6.09786287e-02f, 1.58045053e-01f, 1.03471735e-02f, 6.91214576e-02f, 1.88974783e-01f, 1.68240294e-01f, -4.29031327e-02f, 2.83976868e-02f, 2.41038561e-01f,
  7.64073059e-02f, 2.72562373e-02f, 1.65016219e-01f, 9.03487876e-02f, 1.54027730e-01f, -8.66613016e-02f, 5.81577560e-03f, 1.41025051e-01f, 2.24720731e-01f, 7.15520307e-02f,
  2.20089912e-01f, -4.26273560e-03f, 1.57866344e-01f, 2.64260825e-02f, 1.89197108e-01f, 2.65416980e-01f, 9.93125662e-02f, 2.41136238e-01f, 6.97391778e-02f, 1.99854940e-01f,
  1.04262486e-01f, 1.40448391e-01f, 3.87208760e-02f, 2.78375089e-01f, 5.62642813e-02f, 9.57336929e-03f, 1.34063149e-02f, 1.31028175e-01f, 1.52810365e-01f, -4.59003001e-02f,
  1.60721570e-01f, -5.11072986e-02f
};

// L1_fan_Wp (Shape: 6 x 64)
const int L1_fan_Wp_rows = 6;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  7.50178471e-02f, 6.17015921e-02f, 1.16749242e-01f, 9.48852971e-02f, 2.18255483e-02f, 1.41997293e-01f, -5.90836629e-02f, 1.06028132e-01f, -2.97171861e-01f, -1.75120965e-01f,
  -6.07245751e-02f, 9.16394740e-02f, 3.10656782e-02f, 1.04932800e-01f, 1.47674248e-01f, 5.79447113e-02f, -2.09052354e-01f, 6.98134080e-02f, -1.87766328e-02f, 1.04909815e-01f,
  1.28638238e-01f, 2.07797006e-01f, 1.08466044e-01f, -9.43900645e-02f, 1.28755420e-01f, 8.02290663e-02f, 1.16082527e-01f, 6.09241165e-02f, -1.58433095e-01f, -8.78079906e-02f,
  -1.89200237e-01f, 1.47059947e-01f, -6.88629150e-02f, 8.79837871e-02f, 1.47640705e-01f, 8.42364430e-02f, 1.90615669e-01f, -2.15557474e-03f, -6.34910762e-02f, -4.01694506e-01f,
  1.74089536e-01f, -1.00744337e-01f, 2.79539645e-01f, -1.46009251e-01f, 1.29317388e-01f, 1.89350963e-01f, 3.29015404e-02f, -1.98890686e-01f, -9.33262520e-03f, 2.09985688e-01f,
  -1.27851501e-01f, 1.90698996e-01f, -3.53144147e-02f, 1.19739152e-01f, -4.14869189e-02f, 2.28635684e-01f, 1.04449719e-01f, 2.57780571e-02f, -1.50563389e-01f, -3.59506533e-02f,
  6.13394864e-02f, 7.54479766e-02f, 1.64723992e-01f, 1.43828019e-01f, 9.44232121e-02f, -7.35955238e-02f, -1.00028254e-01f, 3.78845409e-02f, -1.18443541e-01f, -1.18304685e-01f,
  1.59172162e-01f, -4.75001968e-02f, 4.88529056e-02f, -3.17472033e-03f, 2.16904301e-02f, -6.71047494e-02f, -4.17381991e-03f, 1.26239851e-01f, 1.62013292e-01f, -1.73388317e-01f,
  2.59460270e-01f, -1.01107962e-01f, -1.61285341e-01f, -1.80797145e-01f, -4.61663380e-02f, 1.08842231e-01f, -3.81421708e-02f, 2.20561288e-02f, 3.76369655e-02f, 1.04318626e-01f,
  -4.93436866e-02f, -1.59632787e-01f, -1.96964025e-01f, -8.52148682e-02f, -1.23464398e-01f, 4.21725661e-02f, 7.42064193e-02f, -1.25809357e-01f, 1.90647453e-01f, -5.54839969e-02f,
  8.16238225e-02f, 7.63270864e-03f, -2.30442248e-02f, 4.58972454e-02f, -1.62659481e-01f, 6.32918254e-02f, 2.28307799e-01f, 1.85761511e-01f, -7.59692416e-02f, 1.67419270e-01f,
  9.09292027e-02f, 1.32859632e-01f, -1.40117258e-01f, 6.90020947e-03f, 2.22859725e-01f, -1.09802924e-01f, 2.99401805e-02f, -1.15052886e-01f, -2.27451418e-02f, 2.66537466e-03f,
  7.62892514e-02f, 3.82316555e-03f, -8.00075680e-02f, 2.63333004e-02f, -1.25711113e-01f, -6.40781671e-02f, -1.72355190e-01f, 7.44057149e-02f, 3.73215391e-03f, -2.22215727e-02f,
  2.07467340e-02f, -8.18313137e-02f, -4.35833782e-02f, 8.81971791e-03f, 9.08788592e-02f, -6.89989403e-02f, -7.65722692e-02f, -9.31183845e-02f, -1.46310419e-01f, 1.24249600e-01f,
  -1.27082080e-01f, 7.92207420e-02f, 2.42985383e-01f, -3.88691202e-02f, 1.42636448e-01f, -4.84363586e-02f, -1.39228627e-01f, -2.40058359e-02f, -9.93871987e-02f, 4.95410450e-02f,
  2.08003134e-01f, -8.70660394e-02f, 3.10947336e-02f, -1.14053190e-01f, 9.91242900e-02f, 1.84211582e-02f, -1.66107804e-01f, 7.60403201e-02f, -2.06653886e-02f, 1.34493351e-01f,
  -1.53138965e-01f, -1.01918563e-01f, 2.14720368e-01f, 1.17044803e-02f, -1.82205856e-01f, -9.08418149e-02f, -1.39612183e-01f, 9.02196467e-02f, -1.15715183e-01f, 2.15328718e-03f,
  1.43195316e-02f, 1.63369123e-02f, -7.68981129e-02f, -6.97699413e-02f, 6.53473735e-02f, 1.28634438e-01f, 4.01988477e-02f, 1.25149250e-01f, 2.16207936e-01f, -2.08631139e-02f,
  9.54567418e-02f, 2.44272389e-02f, -1.63632825e-01f, 2.57856995e-02f, -7.98624102e-03f, -1.27987772e-01f, -2.78974101e-02f, 1.41882300e-01f, -1.04838330e-02f, -1.62257597e-01f,
  5.04828766e-02f, 2.33914461e-02f, -3.08062416e-02f, 3.62728871e-02f, -1.73861027e-01f, 3.77776474e-02f, -1.20714881e-01f, -8.33321270e-03f, 3.83955128e-02f, -9.71405432e-02f,
  1.84035916e-02f, 1.08289905e-01f, 8.41385592e-03f, -5.70103452e-02f, -2.25541741e-01f, -8.22641328e-02f, -6.46560639e-02f, -1.31354719e-01f, 6.51600808e-02f, -1.66683972e-01f,
  -8.80602971e-02f, -1.66772962e-01f, -2.32399330e-01f, 6.43281490e-02f, -6.66129589e-02f, -9.87588316e-02f, -9.92655903e-02f, -1.07284740e-01f, 3.61313224e-02f, -2.15636849e-01f,
  6.56591952e-02f, 3.46638486e-02f, 1.12858638e-01f, 1.33844856e-02f, -1.93732351e-01f, -9.18313190e-02f, -9.72135291e-02f, 7.82613009e-02f, -2.28793457e-01f, 3.93862389e-02f,
  -1.07909590e-01f, 1.48012694e-02f, -1.82860494e-01f, -4.26982790e-02f, -1.34608939e-01f, 2.12801918e-01f, 1.73331257e-02f, 1.01836741e-01f, -9.91764590e-02f, -1.01509579e-01f,
  9.58065838e-02f, -4.18451168e-02f, 9.93225276e-02f, -1.84139945e-02f, 1.68485627e-01f, 6.21150732e-02f, -1.29928395e-01f, -4.35486101e-02f, 1.21625483e-01f, 9.67789218e-02f,
  -4.11331828e-04f, -8.24964419e-02f, 8.43899772e-02f, -8.63592997e-02f, 5.83310910e-02f, -6.84603825e-02f, -2.74270847e-02f, -3.59622724e-02f, 1.88616142e-01f, -8.55326355e-02f,
  8.17452595e-02f, -8.23760703e-02f, 1.61904559e-01f, 1.42760612e-02f, 1.50310352e-01f, -3.80101353e-02f, 6.43520132e-02f, -7.65140122e-03f, -8.00384730e-02f, -1.05703741e-01f,
  -5.25134131e-02f, 1.42008618e-01f, -2.13279799e-01f, 1.11366902e-03f, 1.75204590e-01f, 4.20409292e-02f, -3.34854797e-02f, -9.38792806e-03f, -1.99321419e-01f, 3.79661769e-02f,
  1.25690047e-02f, 2.36467555e-01f, -6.85506612e-02f, 1.10771552e-01f, 1.51839614e-01f, -1.18366949e-01f, 1.12701446e-01f, -1.30882524e-02f, 2.13944927e-01f, 7.57091120e-02f,
  -3.87071520e-02f, 8.27138424e-02f, 1.53026199e-02f, 6.29619285e-02f, -4.11951952e-02f, 1.60596132e-01f, -1.29065951e-02f, -6.60592169e-02f, 1.35550514e-01f, -1.42820194e-01f,
  -5.79040386e-02f, -1.02842502e-01f, -1.14893667e-01f, -7.87032396e-03f, 5.52303530e-02f, -3.04937996e-02f, -8.01883340e-02f, -4.58488837e-02f, -6.75898343e-02f, -5.34476154e-02f,
  6.65749907e-02f, 1.09000355e-02f, 7.79302120e-02f, 1.64930895e-01f, -1.54149439e-03f, 4.70875613e-02f, 4.30764966e-02f, -3.44305001e-02f, -5.69943935e-02f, -1.58876196e-01f,
  -6.33902699e-02f, -1.16872378e-02f, -3.20487618e-02f, -9.27771330e-02f, -1.08458549e-01f, 1.41301945e-01f, -1.81314928e-04f, 1.09476954e-01f, 2.31562465e-01f, 1.84316888e-01f,
  -7.79178143e-02f, -9.31593552e-02f, -1.21042624e-01f, 7.18406439e-02f, -1.66004583e-01f, 1.26373425e-01f, 1.57811865e-01f, 8.26317593e-02f, -4.24569212e-02f, -4.67101596e-02f,
  -1.02932572e-01f, -8.78772885e-02f, -1.88917711e-01f, 1.47793233e-01f, 1.19126827e-01f, 1.99327946e-01f, 3.57499197e-02f, -5.74894855e-03f, 1.24236055e-01f, 6.43920749e-02f,
  -1.57400426e-02f, -6.34945557e-02f, 1.00432716e-01f, -5.90875931e-02f, -1.17679983e-01f, 1.70874760e-01f, 1.40673712e-01f, 1.15068935e-01f, 1.23294555e-01f, 1.93248764e-01f,
  -1.08667515e-01f, 7.16553330e-02f, -1.80849776e-01f, 1.58247232e-01f, 6.25272468e-02f, 2.48546116e-02f, -1.23886548e-01f, -3.74696814e-02f, -1.13663934e-01f, -1.07196853e-01f,
  -5.06079420e-02f, 1.18969128e-01f, 1.00982092e-01f, -2.28608418e-02f, 2.05692828e-01f, 1.36510581e-02f, -7.25139976e-02f, -5.46758510e-02f, 2.30828226e-02f, -1.80343226e-01f,
  7.63924718e-02f, 5.85256033e-02f, 9.44686532e-02f, 4.61483337e-02f
};

// L1_fan_Wp_bar (Shape: 52 x 64)
const int L1_fan_Wp_bar_rows = 52;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  2.13011935e-01f, 1.83043227e-01f, 1.04431525e-01f, 9.20974985e-02f, 1.58091351e-01f, 1.30766621e-02f, 1.80037752e-01f, 1.07932866e-01f, -2.61011899e-01f, -1.48976490e-01f,
  1.90936439e-02f, 1.55224234e-01f, 1.19984686e-01f, 2.58644432e-01f, 1.53536201e-01f, 1.06434841e-02f, 2.05863550e-01f, 5.66570982e-02f, -1.67611931e-02f, -6.19112849e-02f,
  1.28155023e-01f, 6.82581333e-04f, 1.76750690e-01f, 1.06650062e-01f, 1.42606243e-01f, -1.64715293e-05f, -2.58867871e-02f, -1.03217205e-02f, 2.01213986e-01f, -5.28759733e-02f,
  -7.61854346e-04f, 2.06446066e-01f, -4.03707959e-02f, -3.07149906e-02f, 9.23127756e-02f, -1.23061672e-01f, -4.30635475e-02f, -4.35357913e-02f, -2.34266371e-01f, -3.64246219e-02f,
  -1.00056626e-01f, -5.12368837e-03f, -9.00910888e-03f, -1.38000369e-01f, -6.91722482e-02f, -4.22582123e-03f, 7.87329376e-02f, 2.41429210e-01f, -1.72718782e-02f, 8.26682448e-02f,
  2.10383445e-01f, -1.67020001e-02f, -1.10677972e-01f, 3.74717102e-03f, -2.37372983e-02f, -1.68399826e-01f, 9.48512182e-02f, -1.77777991e-01f, -1.06717616e-01f, 1.55505344e-01f,
  1.59689542e-02f, 9.65807363e-02f, -1.73313573e-01f, -4.15162370e-03f, -8.18773434e-02f, -3.02023496e-02f, 4.48339991e-02f, -9.48929973e-03f, 1.13321006e-01f, 6.09717816e-02f,
  1.25781730e-01f, 6.91338331e-02f, 1.43706203e-01f, -3.63115445e-02f, 1.37375981e-01f, 6.42020479e-02f, 3.68444286e-02f, 1.41892895e-01f, 6.00992590e-02f, 1.56223625e-01f,
  1.15650795e-01f, 1.42411515e-01f, 3.45169365e-01f, 1.25826836e-01f, -1.00149244e-01f, -8.55081230e-02f, 2.91050728e-02f, 2.81681605e-02f, -1.18886093e-02f, 4.79275212e-02f,
  -6.61770925e-02f, -5.41117229e-02f, -4.78165112e-02f, 2.03602672e-01f, -3.49734910e-02f, 1.44515097e-01f, 2.45458215e-01f, -1.46570414e-01f, -3.73549201e-02f, -3.77774686e-01f,
  3.74781750e-02f, -4.42394875e-02f, 1.51649609e-01f, 3.67112011e-01f, 8.29925537e-02f, 2.71846019e-02f, -9.28405449e-02f, 8.89629424e-02f, 2.36645147e-01f, 1.56109527e-01f,
  2.22546846e-01f, 1.32333234e-01f, -9.88441780e-02f, 3.70391295e-03f, -2.96046515e-03f, -1.15990847e-01f, 5.85544668e-03f, -1.26385644e-01f, 1.88711151e-01f, -2.11450025e-01f,
  1.17955729e-01f, -1.45772487e-01f, 6.00113757e-02f, -1.65121958e-01f, -2.17406988e-01f, 1.01983836e-02f, -1.46306470e-01f, 6.15058169e-02f, 1.78283155e-01f, 2.02486202e-01f,
  1.68997586e-01f, 1.16794512e-01f, 1.62950188e-01f, 1.32568613e-01f, 2.11277977e-01f, 4.81420606e-02f, -3.14678848e-01f, -1.09197140e-01f, 2.71675408e-01f, -3.04735843e-02f,
  1.11278988e-01f, 2.68103540e-01f, 2.98183262e-02f, 2.59543777e-01f, -6.74235076e-03f, 2.83087380e-02f, -1.56367585e-01f, 1.68197751e-02f, 7.55251274e-02f, -1.15297131e-01f,
  1.55176252e-01f, 2.34271958e-02f, 7.96285793e-02f, 3.25714916e-01f, -1.28335699e-01f, -3.20838019e-02f, 7.06976503e-02f, -9.24618617e-02f, -1.18356600e-01f, 2.82574333e-02f,
  8.10145438e-02f, -7.23939016e-02f, -1.15415096e-01f, 9.01134834e-02f, 1.12855606e-01f, 4.08328250e-02f, 1.40876114e-01f, -2.95088977e-01f, -2.35495288e-02f, 1.86599195e-01f,
  1.70921817e-01f, -7.64616281e-02f, -8.12307745e-02f, -1.02963708e-01f, 1.36542127e-01f, 1.93725508e-02f, -8.52045417e-02f, 3.27262916e-02f, -1.86901152e-01f, -9.82507318e-02f,
  -5.31343780e-02f, -1.64910108e-02f, 1.43665299e-01f, 1.71770796e-01f, 1.46779329e-01f, -4.04271111e-02f, 3.46127711e-02f, -1.87259346e-01f, 5.93981445e-02f, 4.07399125e-02f,
  -7.39158168e-02f, -1.46749526e-01f, 1.18408702e-01f, 4.92734611e-02f, 1.84668139e-01f, 2.95757055e-02f, 2.09595829e-01f, 1.79795697e-01f, -5.20845968e-03f, -4.01484817e-02f,
  1.12456940e-02f, 1.27575517e-01f, -1.75897077e-01f, -6.49305508e-02f, -1.67041714e-03f, -9.38984379e-02f, -8.98652226e-02f, 2.83895191e-02f, -3.59349214e-02f, 4.82862210e-03f,
  -1.66794240e-01f, 7.36272708e-02f, -9.90806893e-02f, 2.06669316e-01f, -1.06603980e-01f, 1.50618002e-01f, -8.77115224e-03f, -1.40120713e-02f, 7.77612403e-02f, 4.36954685e-02f,
  1.86915323e-01f, -1.09214276e-01f, 1.04574813e-02f, -1.99389890e-01f, 6.87508360e-02f, -1.70031805e-02f, -1.39095575e-01f, 2.28559956e-01f, 5.27988793e-03f, 1.30609170e-01f,
  5.72612099e-02f, -1.94585636e-01f, -1.34715691e-01f, 5.47752790e-02f, 1.82258695e-01f, 1.59553327e-02f, -5.63979819e-02f, 8.62523094e-02f, 4.45792973e-02f, -1.98915228e-01f,
  1.54271498e-01f, -1.08102933e-01f, -4.44632620e-02f, 2.41679013e-01f, 2.06501186e-01f, 9.76940244e-02f, 7.86298886e-02f, 2.41587907e-01f, -1.44993573e-01f, 1.92859411e-01f,
  -5.54485573e-03f, 6.85811266e-02f, 2.93385446e-01f, 3.16196829e-02f, 3.10790688e-01f, 1.52592689e-01f, -8.01275671e-02f, 1.67250633e-01f, -4.11329865e-02f, 3.87225747e-02f,
  9.96567830e-02f, 1.76946037e-02f, -3.63847576e-02f, 1.80629224e-01f, -2.39053220e-02f, -1.15629338e-01f, 1.81551754e-01f, -2.21716166e-02f, -1.05313070e-01f, 1.29407004e-01f,
  2.81520009e-01f, 3.42018865e-02f, -8.12836066e-02f, 1.87135115e-01f, -2.82568624e-04f, 1.10404909e-01f, 1.27265528e-01f, -9.60100964e-02f, 9.72989574e-02f, 1.93811860e-02f,
  -2.13984977e-02f, 1.34432495e-01f, 9.80164781e-02f, 2.26933043e-02f, -2.05402404e-01f, -3.35067697e-02f, -4.47904989e-02f, 2.14647546e-01f, 2.31723234e-01f, -1.08801924e-01f,
  -1.61436081e-01f, -2.74045140e-01f, -1.29666343e-01f, -1.49210364e-01f, 2.61811744e-02f, 5.26941270e-02f, 1.54331774e-01f, 7.46017024e-02f, 2.94042885e-01f, -1.49101421e-01f,
  1.47835672e-01f, 1.26119718e-01f, 8.67165923e-02f, 3.69029045e-02f, 2.26417799e-02f, -1.62785553e-04f, 7.45811090e-02f, -2.49567032e-02f, -6.00995459e-02f, 7.86894485e-02f,
  -7.28542879e-02f, -2.00740844e-02f, 2.56644726e-01f, 1.06974304e-01f, 2.48102635e-01f, -1.42943934e-01f, -1.77679598e-01f, 1.12637445e-01f, 1.45274580e-01f, -1.47851501e-02f,
  1.15960635e-01f, 7.72945955e-02f, 9.10804719e-02f, 1.62126645e-01f, 8.86472762e-02f, 1.29764333e-01f, -1.94907010e-01f, -2.18253940e-01f, 2.33475283e-01f, 1.36439130e-01f,
  -1.52012691e-01f, -1.35352820e-01f, -7.59853572e-02f, -2.70763099e-01f, 1.23860732e-01f, 3.26205678e-02f, 6.42795637e-02f, -3.31998914e-02f, -4.12738174e-02f, 1.21915229e-01f,
  2.02577431e-02f, 3.28373648e-02f, -1.16712041e-02f, 7.93622285e-02f, -1.84269547e-01f, -1.71182528e-02f, 3.44137885e-02f, -7.57772848e-02f, 1.31958306e-01f, 5.90521954e-02f,
  2.40122780e-01f, 4.47904654e-02f, 9.64978635e-02f, 1.31606460e-01f, 7.99527317e-02f, 2.37980977e-01f, 2.32464690e-02f, 2.08960503e-01f, 8.71438533e-02f, 2.26806819e-01f,
  1.93772782e-02f, 6.63268268e-02f, 1.73104420e-01f, 1.85830310e-01f, 1.00131899e-01f, 1.07756764e-01f, -1.68025434e-01f, -9.91451740e-02f, 2.73633432e-02f, -9.22047496e-02f,
  -4.53593843e-02f, 1.04633763e-01f, 2.51828972e-02f, 6.05412014e-02f, -8.95663723e-02f, -6.85414523e-02f, -3.15837678e-03f, 1.61598846e-01f, 2.10546330e-01f, 4.37901020e-02f,
  2.20154732e-01f, -8.30279812e-02f, 2.31020585e-01f, 1.01569682e-01f, -3.98748852e-02f, 2.87389904e-01f, 1.46910995e-01f, 1.42211363e-01f, 1.71252906e-01f, 1.60603032e-01f,
  -1.80204993e-03f, 1.44709513e-01f, 2.04150155e-01f, -2.81927884e-01f, 3.25218076e-03f, 1.19137928e-01f, 2.85368919e-01f, 5.65273836e-02f, -1.72831595e-01f, 1.82686895e-02f,
  1.33173883e-01f, 4.67525385e-02f, 2.46769026e-01f, 1.39609069e-01f, 1.07887611e-01f, -1.22286521e-01f, 2.68560220e-02f, 3.85768078e-02f, 1.51102379e-01f, 1.43178374e-01f,
  -1.07455198e-02f, -1.54268276e-02f, 3.10636878e-01f, 7.34556541e-02f, -1.56951845e-01f, 1.53964013e-01f, 8.87293592e-02f, 1.75009072e-01f, 1.84664562e-01f, 1.16567895e-01f,
  2.11413264e-01f, -1.49754897e-01f, 6.12316243e-02f, 2.16507882e-01f, 1.67156607e-01f, 2.61170026e-02f, 2.23312750e-02f, -2.60383356e-02f, -4.26992355e-03f, -1.24545902e-01f,
  1.25026107e-01f, 2.74919510e-01f, -2.00809427e-02f, 3.71271521e-02f, 7.34308735e-02f, 3.48323286e-02f, -1.56387195e-01f, -1.20632416e-02f, 1.44292489e-01f, -1.18081151e-02f,
  8.53465497e-03f, 2.17216074e-01f, 6.23342916e-02f, 9.24227312e-02f, -7.54325315e-02f, 2.06384674e-01f, 6.63837716e-02f, 7.59343803e-02f, 9.90326032e-02f, 2.14014873e-01f,
  2.45030761e-01f, 5.86528964e-02f, 2.17174292e-01f, 9.64362025e-02f, -1.90455139e-01f, 1.65048195e-03f, 1.13672368e-01f, 1.63689196e-01f, -1.97654635e-01f, 3.40127014e-02f,
  6.82373270e-02f, -5.61187081e-02f, -1.67335153e-01f, -8.98670629e-02f, -9.53292921e-02f, -1.03160992e-01f, 1.00440815e-01f, 1.08551674e-01f, -1.30892605e-01f, 1.12751037e-01f,
  -2.89220475e-02f, 7.82602802e-02f, 1.31805673e-01f, 1.52555797e-02f, -4.54155244e-02f, 1.56495288e-01f, 2.77244478e-01f, 1.80146083e-01f, 1.28992409e-01f, -9.54844430e-02f,
  -1.59564063e-01f, 3.94406393e-02f, -6.98438659e-02f, 1.81996897e-01f, 9.93821025e-02f, 2.31121778e-02f, -9.49600264e-02f, -1.57741502e-01f, -6.49024323e-02f, -1.09966416e-02f,
  -1.10172585e-01f, 1.00702383e-02f, -1.17511101e-01f, -2.19215862e-02f, -7.25870058e-02f, 5.12212794e-03f, 4.28734496e-02f, 7.70296231e-02f, -6.10209927e-02f, 2.94992715e-01f,
  2.29428560e-01f, 1.59193903e-01f, 2.64805347e-01f, 1.70783207e-01f, -1.35115057e-01f, 1.21370971e-01f, 9.33057815e-02f, 2.39454657e-01f, 2.85779029e-01f, -1.69857852e-02f,
  1.80683687e-01f, -4.61667730e-03f, 3.01765148e-02f, 2.80309677e-01f, 2.37278789e-01f, 1.93242341e-01f, 2.59827256e-01f, 2.32347265e-01f, -1.43054411e-01f, -1.69458315e-01f,
  3.20841721e-03f, -1.31882608e-01f, -9.53076631e-02f, -8.55681449e-02f, 1.91899881e-01f, -1.81638617e-02f, 1.69389501e-01f, -1.67310238e-02f, -2.14058727e-01f, 3.78096774e-02f,
  -1.74640846e-02f, 1.89414471e-01f, 2.84366012e-01f, 1.63068041e-01f, -1.19952366e-01f, 9.62692872e-02f, 1.38056561e-01f, -5.17343059e-02f, 1.70688212e-01f, 2.64709055e-01f,
  7.11358935e-02f, 2.03351211e-02f, 2.51951925e-02f, 1.64045811e-01f, 5.87045923e-02f, 1.81316778e-01f, 5.57230860e-02f, -3.42235602e-02f, 2.87317872e-01f, 2.23939672e-01f,
  1.53982416e-01f, -1.64991945e-01f, 2.26272240e-01f, -1.54851660e-01f, 1.29768357e-01f, -6.34484738e-02f, 1.99972942e-01f, -9.10242498e-02f, 7.97794834e-02f, 9.36345011e-03f,
  2.77303755e-01f, 2.39002526e-01f, -1.08023621e-01f, 1.54143527e-01f, 4.27517341e-03f, 1.74647748e-01f, 2.26848036e-01f, 1.36486247e-01f, 1.27208322e-01f, 1.60063729e-01f,
  -1.24215573e-01f, 8.98304582e-02f, 1.81081608e-01f, 4.50521754e-03f, 1.51052643e-02f, 7.60895908e-02f, -1.12931980e-02f, 8.77927020e-02f, -7.67714577e-03f, 2.29797617e-01f,
  1.69598341e-01f, 1.14879869e-01f, 1.74673289e-01f, 2.58053958e-01f, -7.92369992e-02f, -1.64194161e-03f, 2.20443383e-01f, 2.22510144e-01f, 5.91995642e-02f, 2.67052531e-01f,
  2.18198430e-02f, 2.50039488e-01f, -1.12980336e-01f, 2.16137379e-01f, 1.17704093e-01f, -8.81139003e-03f, -7.63930902e-02f, -6.11868687e-02f, 7.42697120e-02f, 2.25847676e-01f,
  -5.44451363e-03f, 1.74186230e-01f, 7.30093122e-02f, 9.94437141e-04f, 4.59616259e-02f, -4.87441309e-02f, 3.90255116e-02f, -4.28092703e-02f, 1.77591547e-01f, -5.22436276e-02f,
  -2.17343077e-01f, -1.01370625e-01f, -1.66709721e-02f, -8.38757306e-02f, 1.37047201e-01f, 1.83814263e-03f, -8.45842808e-02f, 7.20109046e-02f, 1.05693795e-01f, -9.66981202e-02f,
  -5.26531413e-02f, 9.29921567e-02f, 9.80135053e-02f, 4.35253121e-02f, -2.63096958e-01f, -9.74178463e-02f, 9.05792415e-02f, 2.86416095e-02f, -9.72407088e-02f, -1.36714801e-01f,
  1.32213622e-01f, 9.25080627e-02f, 1.50125757e-01f, -1.13037132e-01f, 1.98323831e-01f, -2.21709907e-01f, -1.16763581e-02f, 2.07766220e-01f, 5.28086238e-02f, 1.11457333e-01f,
  -7.50050098e-02f, 5.92126250e-02f, -1.32743001e-01f, -1.05581880e-01f, 3.38613205e-02f, 1.59703672e-01f, 5.96371517e-02f, -1.29010156e-01f, 1.61493793e-01f, 1.13254324e-01f,
  6.20386265e-02f, -1.70448452e-01f, -1.12833112e-01f, 6.27031969e-03f, -1.58083029e-02f, 3.26295309e-02f, -7.49779642e-02f, 1.20095983e-02f, 4.89531197e-02f, 1.61075428e-01f,
  1.43156916e-01f, 1.86064839e-01f, -3.35982174e-01f, 1.12295806e-01f, -9.85193253e-02f, 1.89589143e-01f, 1.21282056e-01f, 9.84793380e-02f, 1.84437744e-02f, -2.32407823e-01f,
  -8.09434727e-02f, -1.89250901e-01f, 4.66655381e-02f, 9.14984848e-03f, -1.65423304e-01f, 2.48865068e-01f, 5.09575978e-02f, 2.33299822e-01f, 9.33370367e-02f, 5.91555424e-02f,
  -4.46770936e-02f, 3.24010663e-02f, 1.37281463e-01f, 2.17533141e-01f, 2.14336812e-01f, 2.28910103e-01f, -7.48496577e-02f, -2.99061481e-02f, 1.29079282e-01f, -4.24590074e-02f,
  -1.81737944e-01f, 4.73766997e-02f, 1.06837496e-01f, -1.65626228e-01f, 2.00319827e-01f, 7.59947374e-02f, -1.16065424e-02f, 1.42040670e-01f, 1.97141469e-02f, -3.46071087e-02f,
  1.06978729e-01f, 4.95149009e-02f, 1.31964043e-01f, 1.06617637e-01f, 2.65958220e-01f, 2.07063779e-01f, 1.18282169e-01f, 1.61064282e-01f, 1.56644553e-01f, 4.54323106e-02f,
  -1.12287225e-02f, -6.02987520e-02f, -3.16615462e-01f, -6.85758293e-02f, -7.31672570e-02f, 3.79605889e-02f, 1.88638419e-01f, 3.62617448e-02f, 4.96406853e-02f, 6.32228097e-03f,
  -1.30020839e-03f, -8.98443069e-03f, 2.57194731e-02f, -3.13455500e-02f, 3.15871209e-01f, 1.03816710e-01f, 1.91867739e-01f, -2.01518714e-01f, -6.36925772e-02f, -2.53091127e-01f,
  1.02375641e-01f, 2.14287639e-01f, -1.60286561e-01f, 5.36017306e-03f, 3.50942463e-02f, 2.92892396e-01f, 1.04357503e-01f, 1.17313132e-01f, 7.66479298e-02f, -2.44263210e-03f,
  -8.93991441e-02f, 1.94214731e-02f, -8.95460993e-02f, -1.40893474e-01f, 2.71780580e-01f, -7.75321871e-02f, 3.88483070e-02f, -3.62559676e-01f, 9.03802514e-02f, 3.73514853e-02f,
  1.43955141e-01f, 7.05261379e-02f, 2.71373898e-01f, 2.07816690e-01f, 9.37801972e-02f, 8.49101618e-02f, 9.63826701e-02f, 1.08694911e-01f, -1.60783619e-01f, 1.64612859e-01f,
  -3.47766355e-02f, 8.99196193e-02f, -1.46115273e-01f, 1.49254292e-01f, -8.86117015e-03f, -1.32074043e-01f, -1.64520726e-01f, 3.07638068e-02f, 4.16417718e-02f, -1.06949890e-02f,
  -1.20787080e-02f, 3.99087323e-03f, 1.79115549e-01f, 4.89278734e-02f, -1.88676476e-01f, -1.71856746e-01f, 5.24262004e-02f, 1.01988755e-01f, -1.98157147e-01f, -2.06632391e-01f,
  4.66185026e-02f, -2.08818823e-01f, 1.94479004e-01f, -9.08034667e-02f, 1.47185832e-01f, 5.66974841e-02f, -1.82825759e-01f, 3.58312614e-02f, -1.00663617e-01f, 2.39809737e-01f,
  2.79491097e-02f, -6.94189444e-02f, -6.87617287e-02f, -9.26489606e-02f, 1.71323434e-01f, 2.16857400e-02f, -1.11433215e-01f, -3.66710797e-02f, 8.08270201e-02f, -7.11517185e-02f,
  -8.12159479e-02f, 9.64089856e-02f, 1.16510190e-01f, 6.16044030e-02f, -2.51377504e-02f, 1.93061322e-01f, 9.98474541e-04f, 5.88412248e-02f, 1.15865514e-01f, -3.48217487e-02f,
  2.14854181e-01f, 2.13479832e-01f, 4.88168858e-02f, 1.90210760e-01f, -5.88785373e-02f, 6.06565550e-02f, 8.47140774e-02f, 2.30299443e-01f, 1.64104909e-01f, 1.51353732e-01f,
  1.38670355e-01f, 1.36327565e-01f, -8.96577984e-02f, 8.29942599e-02f, -8.08236971e-02f, -3.46366391e-02f, -1.34600937e-01f, 1.99001625e-01f, 1.40726447e-01f, -1.13447368e-01f,
  1.42030016e-01f, 4.17797966e-03f, 8.47081989e-02f, 1.77054346e-01f, 3.18860970e-02f, 2.13583916e-01f, 2.02936396e-01f, 9.94274840e-02f, 1.24744043e-01f, 1.82022810e-01f,
  -1.07094578e-01f, 3.73604782e-02f, 9.12022740e-02f, 9.12411436e-02f, 9.47493464e-02f, 1.53395250e-01f, 1.00903131e-01f, 1.31648928e-01f, -1.66195825e-01f, 1.74671754e-01f,
  1.50579229e-01f, 3.12363692e-02f, 1.02599345e-01f, -1.38858065e-01f, -4.37938087e-02f, 1.88626036e-01f, 1.44637540e-01f, 1.77442029e-01f, -1.34666292e-02f, 1.61431860e-02f,
  4.38056551e-02f, -8.15788880e-02f, -1.31822512e-01f, -7.15306699e-02f, -6.19420148e-02f, 1.74535602e-01f, -1.12128496e-01f, 1.22461636e-02f, 4.38440740e-02f, -7.15004504e-02f,
  1.33787185e-01f, 4.37220894e-02f, -2.83293966e-02f, -2.46334933e-02f, -6.66234940e-02f, -2.05160782e-01f, -7.34763071e-02f, -1.06553845e-01f, 1.02457091e-01f, -6.01532161e-02f,
  4.20772582e-02f, -5.72984144e-02f, -2.11430237e-01f, 1.08051516e-01f, -1.44224375e-01f, -6.61157295e-02f, 2.01472670e-01f, -5.60127497e-02f, 3.86398621e-02f, 8.41099918e-02f,
  3.39478850e-02f, -9.61987227e-02f, 1.35492042e-01f, 2.40538090e-01f, 1.70409799e-01f, 7.23575875e-02f, 1.93987414e-01f, 1.26920700e-01f, 1.55247435e-01f, -3.37179564e-02f,
  9.58102196e-02f, 2.08307177e-01f, -8.86672176e-03f, 1.57638788e-01f, -1.18497228e-02f, -1.49793644e-02f, -6.11030534e-02f, 1.30447730e-01f, 1.44227356e-01f, -1.24506392e-02f,
  -1.15442567e-01f, 2.38944869e-03f, -4.77493787e-03f, 1.38899922e-01f, 4.12463993e-02f, 1.20618917e-01f, 4.75986674e-02f, 7.27144480e-02f, -1.13689773e-01f, 1.15121059e-01f,
  1.32908419e-01f, -5.57214022e-02f, -2.54216865e-02f, 2.14918390e-01f, 2.29472831e-01f, -2.60091349e-02f, 4.36667055e-02f, 1.20532334e-01f, 7.00228587e-02f, 9.00157839e-02f,
  -1.41337104e-02f, 2.22361088e-01f, 7.39797801e-02f, 1.05228633e-01f, 1.84063409e-02f, 1.56313986e-01f, 9.61844549e-02f, -2.07084283e-01f, -1.48502305e-01f, -1.64431766e-01f,
  -1.03583001e-01f, -6.23944104e-02f, 4.87812981e-02f, 1.73355624e-01f, 1.99066505e-01f, 1.40682429e-01f, 4.10126336e-02f, 1.54666454e-01f, 9.65815037e-02f, 2.21797913e-01f,
  2.66192496e-01f, -1.20274378e-02f, -2.65477188e-02f, 2.56891757e-01f, -9.93882790e-02f, 1.29888773e-01f, 2.41417840e-01f, 4.74433824e-02f, 7.86717311e-02f, -4.60143089e-02f,
  8.31998512e-02f, 5.38015887e-02f, 2.96770334e-02f, 7.28531927e-02f, 1.96094230e-01f, 1.72463521e-01f, -2.01471314e-01f, -2.35754356e-01f, -1.80369660e-01f, 2.36184672e-02f,
  -1.75912082e-01f, -7.44709820e-02f, -1.18365232e-02f, -1.70462146e-01f, 9.52786803e-02f, -1.66112393e-01f, 4.06466164e-02f, -1.25605077e-01f, 9.71478689e-03f, 1.12615518e-01f,
  2.00602859e-01f, 2.07294021e-02f, -2.32383870e-02f, -2.02080697e-01f, 8.80195871e-02f, -2.02854201e-01f, 2.93091387e-02f, 1.13439374e-01f, 8.29270110e-03f, -5.25557697e-02f,
  9.44346040e-02f, 2.04092115e-01f, 6.58109188e-02f, -5.38206287e-02f, 2.46402371e-04f, -3.63176949e-02f, 6.38123462e-03f, -1.54957827e-02f, 7.84672648e-02f, -1.63660854e-01f,
  2.50011533e-01f, 3.08081862e-02f, 5.24825826e-02f, -1.26569480e-01f, 9.34727192e-02f, 1.24899149e-01f, -6.97628483e-02f, -4.33307961e-02f, 3.21771622e-01f, 2.27487519e-01f,
  8.78620148e-03f, 1.84120759e-01f, 1.84448034e-01f, 1.47792712e-01f, 2.27995645e-02f, 6.63831979e-02f, -1.58500690e-02f, 3.29524502e-02f, -8.43660086e-02f, 2.43124366e-01f,
  8.24027583e-02f, -2.74883896e-01f, 9.41640213e-02f, 1.00672208e-01f, 1.24388300e-01f, 2.43285567e-01f, 5.87856211e-02f, 1.31804869e-01f, 2.13659391e-01f, 2.25261211e-01f,
  -2.08592877e-01f, -2.30117459e-02f, -1.92627534e-01f, -1.87025703e-02f, 6.77854121e-02f, -1.04283415e-01f, -6.73251301e-02f, -4.02313769e-02f, 2.14311570e-01f, 1.35973603e-01f,
  -2.42138878e-01f, 1.75424851e-02f, -2.51181662e-01f, 1.34065911e-01f, 1.70054898e-01f, 2.30944492e-02f, 7.79246315e-02f, 2.06204072e-01f, -1.98915731e-02f, 9.87246186e-02f,
  1.94841206e-01f, 1.41812161e-01f, -1.31806806e-01f, -9.18249413e-02f, 1.52387157e-01f, 5.52194286e-03f, 2.32204556e-01f, 1.41081167e-03f, 5.13430759e-02f, 1.04825512e-01f,
  2.62133896e-01f, 2.17023879e-01f, 2.99899161e-01f, -1.71772048e-01f, 2.39084303e-01f, 1.66216359e-01f, 3.14043522e-01f, -3.77416238e-02f, 1.80883184e-01f, 1.73030302e-01f,
  1.16015859e-01f, -2.05343097e-01f, 1.86477885e-01f, 1.72108784e-01f, -6.67861104e-02f, 1.94603547e-01f, 1.59658492e-01f, 1.46445945e-01f, -2.13914849e-02f, 1.68558687e-01f,
  1.21696711e-01f, 1.57384679e-01f, 1.34216323e-01f, 4.92470972e-02f, 2.10645825e-01f, -1.07920013e-01f, 2.41118282e-01f, 1.57740280e-01f, 2.11972997e-01f, 2.86167804e-02f,
  7.69897401e-02f, 1.31841764e-01f, 1.03340305e-01f, 2.08347186e-01f, -1.03391387e-01f, -2.15374365e-01f, -3.05022895e-02f, 2.11442754e-01f, -8.80778581e-02f, -2.05477387e-01f,
  -1.39907196e-01f, -9.55786631e-02f, 1.23500854e-01f, -9.64258835e-02f, -9.20692012e-02f, -1.82291176e-02f, -2.93809563e-01f, -1.91274256e-01f, -1.72155038e-01f, 2.26691991e-01f,
  1.43525451e-01f, 6.11279272e-02f, -8.08672514e-03f, -1.27132356e-01f, 1.98454976e-01f, -2.54222844e-03f, 1.86245851e-02f, -3.79412025e-02f, 1.68957636e-02f, -2.03018747e-02f,
  3.03700808e-02f, 6.33011833e-02f, 1.08891457e-01f, 2.95982808e-02f, -1.95598409e-01f, 1.32132694e-01f, -1.83154419e-02f, -1.65196165e-01f, -7.32100010e-02f, 1.87896252e-01f,
  9.72965583e-02f, 1.09622411e-01f, 1.12632468e-01f, 2.20180824e-01f, -8.27205181e-02f, -2.60804355e-01f, -4.78779264e-02f, 7.52770007e-02f, -5.20232804e-02f, 6.09190483e-03f,
  6.09524781e-03f, 9.56691578e-02f, -1.96810722e-01f, 2.09167302e-01f, 1.84597239e-01f, 6.60951808e-02f, 1.34629235e-01f, -4.08822559e-02f, 2.27266438e-02f, -1.13355771e-01f,
  2.40164578e-01f, 2.74846945e-02f, 2.23821670e-01f, 2.20142871e-01f, 1.68709934e-01f, 1.32416993e-01f, 1.09186009e-01f, 1.22748584e-01f, 7.38860592e-02f, -1.00427391e-02f,
  4.39793110e-01f, 2.34999731e-02f, 4.07628193e-02f, -5.72598213e-03f, 8.28963071e-02f, -1.13909513e-01f, -2.55407155e-01f, -5.29792197e-02f, 1.33317977e-01f, 1.50388665e-02f,
  1.03671901e-01f, 2.61287808e-01f, -3.43605387e-03f, -1.45522952e-02f, 2.73758546e-02f, 6.96260259e-02f, 1.21886387e-01f, 7.47941434e-02f, -2.24692561e-02f, 8.20222422e-02f,
  7.09666833e-02f, 2.86491841e-01f, 2.53895104e-01f, 2.33008694e-02f, 9.15722847e-02f, 4.56287041e-02f, -9.06453878e-02f, 1.38497308e-01f, 4.58479784e-02f, -1.81511343e-01f,
  2.20717758e-01f, 4.94314820e-01f, 1.62219033e-01f, 6.72635958e-02f, -2.10433125e-01f, 2.68904090e-01f, 1.83946356e-01f, 7.67992670e-03f, 7.12487986e-03f, 2.20590785e-01f,
  -9.94867310e-02f, -4.88713905e-02f, 7.84430057e-02f, 1.52144477e-01f, 1.87239140e-01f, 2.28758037e-01f, 1.16865665e-01f, -9.09109339e-02f, 1.03148676e-01f, 2.35158369e-01f,
  1.52698964e-01f, 2.46014297e-01f, 1.17358722e-01f, -5.78453690e-02f, 9.46016684e-02f, -3.01609859e-02f, 4.92687523e-02f, 5.03106117e-02f, -1.44635057e-02f, 3.24047469e-02f,
  1.55539997e-02f, 1.47389993e-02f, 1.17136841e-03f, 2.01858312e-01f, 3.60366553e-02f, -1.57215104e-01f, 2.06041366e-01f, 5.31410314e-02f, -1.62716769e-02f, 1.17105626e-01f,
  1.57384485e-01f, 4.61724401e-02f, 2.70524248e-02f, 2.19860077e-01f, 6.70925751e-02f, -2.96458490e-02f, 7.31024444e-02f, -8.85487348e-02f, 1.78014953e-03f, 1.90431431e-01f,
  1.29307762e-01f, 1.59289464e-01f, 8.58256370e-02f, -8.19694698e-02f, -1.14805087e-01f, 2.69128401e-02f, -1.22975327e-01f, 1.57874674e-01f, 1.82483926e-01f, -1.24170877e-01f,
  -2.03629181e-01f, -2.31047124e-01f, -3.61786373e-02f, 4.14694194e-03f, 1.08055249e-01f, 2.34217286e-01f, 1.81837633e-01f, 1.04838148e-01f, 1.08004056e-01f, -1.54416010e-01f,
  1.38162836e-01f, -9.49366838e-02f, 7.95290992e-02f, 1.62411898e-01f, -7.02605024e-02f, -4.52858284e-02f, -1.64414141e-02f, 2.98450924e-02f, 2.01726754e-04f, -3.45987417e-02f,
  6.06937893e-02f, -1.64389402e-01f, -1.57007705e-02f, 2.38316879e-02f, 1.11357749e-01f, -6.26151487e-02f, -1.31055519e-01f, 2.16771424e-01f, -3.94529365e-02f, 4.87471335e-02f,
  1.46013811e-01f, 1.96373835e-01f, 1.94850922e-01f, 1.77194238e-01f, 2.77946353e-01f, 1.93430454e-01f, -1.29296556e-02f, 1.33831665e-01f, -4.35389876e-01f, -9.25636739e-02f,
  4.63738218e-02f, 1.26832664e-01f, -3.19468565e-02f, 2.45319098e-01f, 2.59301007e-01f, 1.22909509e-01f, -1.26084164e-01f, 1.42677873e-01f, -1.60988361e-01f, -1.82850569e-01f,
  3.14538479e-02f, -1.25042442e-02f, 2.81815499e-01f, 3.30102481e-02f, 1.24818072e-01f, -1.28739089e-01f, 2.02612206e-01f, -1.34594083e-01f, -1.16225444e-01f, -3.07709239e-02f,
  9.32743922e-02f, 4.62226309e-02f, -1.59485728e-01f, 2.17124098e-03f, -2.46317476e-01f, -1.38875216e-01f, -2.18023434e-01f, 4.96846437e-02f, -1.61297783e-01f, -2.48218775e-01f,
  -1.12787254e-01f, 2.90712953e-01f, 1.86516017e-01f, -2.95989692e-01f, -4.65731360e-02f, 2.35231653e-01f, 1.42553911e-01f, -1.51861683e-01f, -1.24339368e-02f, 1.81587398e-01f,
  8.50293040e-02f, -2.72969659e-02f, -1.95554420e-02f, 1.97060406e-01f, -2.04212219e-01f, 1.65706828e-01f, 2.54489690e-01f, -1.52133346e-01f, -2.78479997e-02f, -5.57270274e-02f,
  7.50011578e-02f, 7.80884251e-02f, 1.22507080e-01f, 7.55845830e-02f, 1.87997147e-01f, 2.21884586e-02f, -3.51128355e-02f, 2.40083188e-01f, 1.91518590e-01f, 2.49216817e-02f,
  1.23427078e-01f, -5.09949885e-02f, -2.76729435e-01f, 4.06614728e-02f, 1.01879090e-01f, 1.21690139e-01f, -1.15671560e-01f, 6.73670992e-02f, 1.76600024e-01f, -8.59297141e-02f,
  4.65092026e-02f, 1.24149308e-01f, -1.01535924e-01f, -7.36720785e-02f, -2.21652016e-02f, 4.61088195e-02f, 3.17536503e-01f, -3.12803686e-02f, -2.04379596e-02f, -1.51338875e-01f,
  -1.35168210e-01f, 2.15692557e-02f, -1.43789366e-01f, 7.33157992e-02f, 1.49068654e-01f, 2.57383227e-01f, -4.65650633e-02f, -1.17196448e-01f, 1.83859803e-02f, -1.09496480e-02f,
  -2.63613582e-01f, -1.01463862e-01f, -1.62399590e-01f, 6.28139377e-02f, -1.98115349e-01f, 2.17915654e-01f, -1.57767236e-01f, 6.74355850e-02f, 2.62916498e-02f, 1.59579173e-01f,
  7.10923523e-02f, 3.68743986e-02f, -1.13066705e-02f, -2.04773210e-02f, 2.36728355e-01f, -6.45057485e-02f, 1.79580413e-03f, 1.91736326e-01f, -3.96214202e-02f, -4.84600551e-02f,
  2.57893413e-01f, -1.64023772e-01f, 2.30308414e-01f, 4.09129225e-02f, -1.86115637e-01f, 4.83823307e-02f, 1.07742831e-01f, -7.60938823e-02f, 1.35050207e-01f, 5.84405512e-02f,
  1.89968720e-01f, 5.43512031e-02f, 2.52180904e-01f, 6.96298778e-02f, -5.60986027e-02f, 1.15676329e-01f, -1.39865741e-01f, -2.92531818e-01f, -2.08066359e-01f, 1.04692541e-01f,
  7.79737765e-03f, 6.25239015e-02f, 5.49255833e-02f, -4.62058261e-02f, 2.69112796e-01f, 1.44150868e-01f, 2.18969867e-01f, 3.65697928e-02f, 9.69399959e-02f, -7.93094486e-02f,
  -7.03488514e-02f, -4.43016440e-02f, 8.91424045e-02f, -2.33975679e-01f, -2.41460111e-02f, 1.03425473e-01f, 1.40217274e-01f, -6.31376207e-02f, -1.73479915e-01f, 1.01267330e-01f,
  8.73038620e-02f, 7.46560842e-02f, 2.58740067e-01f, 2.42524259e-02f, -3.66847329e-02f, -1.44740969e-01f, -2.45687634e-01f, 2.82076061e-01f, 3.26274559e-02f, -2.02827841e-01f,
  2.96593048e-02f, 1.14343733e-01f, -2.51960661e-02f, -7.42652714e-02f, 1.18758716e-01f, 3.17928314e-01f, 9.70206037e-02f, 2.47724906e-01f, 1.04545988e-01f, 7.03025311e-02f,
  -1.79509576e-02f, 1.46999338e-03f, 4.55501638e-02f, -1.57459736e-01f, -1.11563094e-01f, 1.46645844e-01f, -1.36702344e-01f, 2.17226699e-01f, -2.06046298e-01f, -5.20999096e-02f,
  -2.31864616e-01f, -1.47589624e-01f, -1.07839135e-02f, 1.77510366e-01f, 1.07762225e-01f, 4.37408797e-02f, 1.93179473e-01f, 5.65075725e-02f, 1.39452428e-01f, 7.71526247e-02f,
  -3.51801850e-02f, -7.11622536e-02f, 1.51923764e-02f, -4.07408997e-02f, 2.22622929e-03f, -3.57735641e-02f, -1.92302410e-02f, 2.71090657e-01f, -1.54119328e-01f, 1.91586450e-01f,
  1.40072688e-01f, 8.89859255e-03f, 1.00529147e-02f, -2.95361765e-02f, 2.66893283e-02f, 2.25137606e-01f, 6.66323379e-02f, 2.88068682e-01f, -9.91501138e-02f, 1.28315270e-01f,
  -9.94029716e-02f, 7.78749511e-02f, -1.80177856e-02f, 6.09288923e-03f, 6.01749383e-02f, 4.93798852e-02f, -1.91916078e-01f, 1.05692536e-01f, 1.19453795e-01f, 3.77713963e-02f,
  1.92089543e-01f, -4.56254296e-02f, 1.11382388e-01f, 7.76812211e-02f, -4.36321460e-02f, -1.57087877e-01f, 2.29598284e-01f, -8.83351266e-02f, -5.45107275e-02f, 1.37320105e-02f,
  1.70656834e-02f, 1.18125096e-01f, -2.44375840e-01f, 1.51158854e-01f, -1.33329824e-01f, -1.13007203e-01f, 4.97626774e-02f, -1.57936793e-02f, -8.35148618e-02f, 8.98569524e-02f,
  -3.20395641e-02f, -9.42728370e-02f, 9.48423613e-03f, -7.44361104e-03f, 8.30466449e-02f, -9.31170881e-02f, 7.82406405e-02f, 2.24194959e-01f, 2.91465163e-01f, 3.71226035e-02f,
  2.16388181e-01f, 1.48219287e-01f, 6.68105409e-02f, 1.39059335e-01f, -9.66589451e-02f, -1.19950496e-01f, -1.75348367e-03f, 3.47720794e-02f, 1.53291568e-01f, -5.69244809e-02f,
  -1.61574036e-01f, -1.57102402e-02f, -9.30651724e-02f, -1.93412118e-02f, 2.42396846e-01f, 1.15209661e-01f, 8.39720964e-02f, -2.73478404e-02f, -1.38277993e-01f, -1.09417990e-01f,
  5.10830544e-02f, 1.09365202e-01f, -2.76677590e-02f, 2.32229665e-01f, 2.50755996e-01f, -1.16770931e-01f, -9.08256695e-02f, 1.48384675e-01f, -1.05742387e-01f, 1.74228162e-01f,
  2.34788224e-01f, 6.39827475e-02f, 2.69850820e-01f, -1.37151793e-01f, 7.41909971e-05f, -2.05840930e-01f, 2.22496927e-01f, -2.51741558e-01f, 9.47482437e-02f, -2.57448345e-01f,
  -7.65942633e-02f, -1.01114050e-01f, 6.43861815e-02f, 7.64051676e-02f, 3.47148590e-02f, 2.06063136e-01f, 9.89464074e-02f, 6.65319199e-03f, -4.16376181e-02f, 1.04932874e-01f,
  1.76916823e-01f, 3.43677178e-02f, -1.14730097e-01f, 8.32944140e-02f, -3.54899801e-02f, 2.60806620e-01f, 1.99809462e-01f, 1.36326835e-03f, -1.28685936e-01f, -1.64401993e-01f,
  -4.79779691e-02f, 5.40799387e-02f, -5.25610149e-02f, -5.14100380e-02f, -7.52614886e-02f, -3.35808732e-02f, -1.39061868e-01f, -4.62174267e-02f, 1.09655298e-01f, 2.44363412e-01f,
  -8.11954662e-02f, 4.27027717e-02f, -6.04811311e-02f, -1.82538986e-01f, 2.96831504e-02f, -2.35036784e-03f, -6.07065707e-02f, -2.86356490e-02f, 5.24489954e-02f, -8.57358892e-03f,
  2.93188654e-02f, 1.76480398e-01f, 5.19623747e-03f, -1.17216788e-01f, -9.57150850e-03f, -1.48569331e-01f, -5.83191626e-02f, 1.25874922e-01f, 2.02976570e-01f, -1.09490290e-01f,
  5.75934015e-02f, -1.50104657e-01f, -1.08809233e-01f, 3.22161242e-02f, -6.59392849e-02f, 7.66459927e-02f, 1.46540865e-01f, 5.40814139e-02f, 1.34595290e-01f, -1.08669333e-01f,
  -5.68099618e-02f, -2.65118293e-02f, 2.46656984e-02f, 5.42279752e-03f, 6.62572607e-02f, 2.27051944e-01f, -1.90135449e-01f, -9.78046805e-02f, 2.65126944e-01f, -3.03052347e-02f,
  8.20825994e-02f, 1.62244886e-01f, 1.60844132e-01f, 5.64264581e-02f, 6.48232400e-02f, 1.91097781e-01f, -3.11703235e-02f, 1.65278569e-01f, 3.68283093e-02f, 1.17261909e-01f,
  1.80580035e-01f, -1.19523421e-01f, 9.03396010e-02f, 5.61718531e-02f, -8.52133557e-02f, 5.06937802e-02f, -5.57215512e-02f, 2.36561418e-01f, 1.85320258e-01f, 3.58946249e-02f,
  1.04523130e-01f, 1.14074975e-01f, 2.67051440e-02f, 1.53356612e-01f, -3.82091710e-03f, 1.47997439e-01f, -1.01696312e-01f, 2.78031174e-02f, 1.25589386e-01f, 9.14876908e-02f,
  -2.26686582e-01f, 2.18387604e-01f, 5.97989932e-02f, 1.46262944e-01f, -7.22419694e-02f, -8.99164230e-02f, 4.04746607e-02f, 2.10173652e-01f, 5.99429756e-02f, 8.92228168e-03f,
  -7.18263239e-02f, 3.38315703e-02f, -5.59745207e-02f, 1.23654619e-01f, 5.25011681e-02f, -1.46343738e-01f, 1.98037550e-01f, -6.89744065e-03f, -4.20047827e-02f, 3.98408286e-02f,
  -6.19943142e-02f, 8.99248645e-02f, 1.42025307e-01f, 1.18230082e-01f, 2.52788477e-02f, 1.78318888e-01f, 1.38872460e-01f, 5.10085262e-02f, 1.75012574e-02f, -4.40643430e-02f,
  6.20036311e-02f, -8.05933923e-02f, -1.31996408e-01f, 5.94659662e-03f, 7.08888397e-02f, -6.30202368e-02f, 1.15897946e-01f, -9.91002470e-02f, 1.04054734e-01f, 1.99773498e-02f,
  1.78640410e-01f, -6.66230991e-02f, 1.18414164e-01f, -2.02555478e-01f, -6.86458051e-02f, 2.20318362e-01f, 2.21589342e-01f, 1.41954452e-01f, 1.14785820e-01f, 1.44692987e-01f,
  8.32897723e-02f, 4.33141887e-02f, 1.31181881e-01f, 1.51098490e-01f, -8.45214650e-02f, -2.97978539e-02f, 1.35696709e-01f, 8.69674515e-03f, 1.99465826e-01f, 3.42425443e-02f,
  -1.54495612e-01f, 9.56294760e-02f, 2.06868678e-01f, 5.08521385e-02f, 1.51860401e-01f, 1.74293667e-02f, 1.08399177e-02f, -1.57778069e-01f, -2.31682435e-01f, 4.59339656e-03f,
  2.64308751e-01f, -1.07098080e-01f, 4.53277081e-02f, -1.81789920e-01f, -1.24990284e-01f, -1.77216634e-01f, 2.16050968e-02f, 5.33031635e-02f, 2.12244734e-01f, 1.45805821e-01f,
  -1.52393460e-01f, -1.81569323e-01f, -7.50315711e-02f, 6.91634417e-02f, -8.41142014e-02f, -1.46679997e-01f, -5.37445582e-02f, 2.92471766e-01f, -1.02565147e-01f, 2.92864680e-01f,
  -7.03980997e-02f, 3.08444053e-01f, 3.51434806e-03f, 2.08562791e-01f, 1.34324774e-01f, 1.43034801e-01f, -2.19075531e-01f, -1.91570714e-01f, 2.14591011e-01f, -1.00729935e-01f,
  2.19603986e-01f, 2.42142733e-02f, -1.23429753e-01f, 1.01263605e-01f, 2.10297793e-01f, -2.78921574e-01f, 1.35996072e-02f, 5.76939732e-02f, -1.78772941e-01f, -1.11173034e-01f,
  -5.68139292e-02f, -1.32692516e-01f, -9.26069766e-02f, 1.43057659e-01f, 1.01471953e-01f, 9.66224074e-02f, 1.01937123e-01f, 3.02026439e-02f, -1.07358865e-01f, 1.25145718e-01f,
  -5.93619235e-02f, 2.30129575e-03f, 1.87435716e-01f, -1.44140478e-02f, 4.01908159e-02f, 1.51193023e-01f, 2.82463640e-01f, 7.43552148e-02f, -3.67715508e-02f, 1.62677839e-01f,
  1.25451954e-02f, 2.15210721e-01f, 4.65099402e-02f, -4.23617251e-02f, 9.27186087e-02f, -1.07457759e-02f, -2.95217726e-02f, 1.33650199e-01f, 9.20036584e-02f, -2.58793347e-02f,
  -9.84455645e-02f, -4.08494249e-02f, 6.18578456e-02f, 5.00012562e-02f, 4.94108833e-02f, -1.63759887e-02f, 7.26185739e-02f, -1.94240123e-01f, 5.20897172e-02f, -2.73251347e-02f,
  6.22445196e-02f, 2.00443983e-01f, 7.29168579e-02f, 6.23061657e-02f, 1.50424898e-01f, 7.92786330e-02f, 1.20481439e-01f, 1.08424775e-01f, 1.03688963e-01f, 4.89152521e-02f,
  -1.63597763e-01f, -1.14806488e-01f, 9.81076956e-02f, -8.38381723e-02f, -6.49455637e-02f, -1.63148493e-01f, 7.49060586e-02f, -9.53480508e-03f, 2.68647254e-01f, -2.86624264e-02f,
  8.85202959e-02f, -1.72089532e-01f, -2.28121892e-01f, 9.78185907e-02f, 6.27319589e-02f, -1.34085566e-01f, 5.68685979e-02f, 2.12724611e-01f, 1.92139491e-01f, 1.91290602e-01f,
  1.55996740e-01f, 2.16521680e-01f, -3.07660196e-02f, -1.93237439e-02f, 1.76004022e-01f, -2.39547357e-01f, -1.19233532e-02f, -1.92229692e-02f, 7.59206712e-02f, -1.69533238e-01f,
  5.66142164e-02f, -7.71189034e-02f, 2.81522065e-01f, -3.68522257e-02f, 4.45118248e-02f, 7.74683282e-02f, 1.02672704e-01f, -3.93717960e-02f, -2.06153952e-02f, -2.41255201e-02f,
  -7.86355212e-02f, -1.64525166e-01f, 5.42833135e-02f, 1.43620059e-01f, 9.58711654e-02f, -1.20124407e-01f, -1.69831946e-01f, 1.36162892e-01f, 2.97467527e-03f, 4.10076864e-02f,
  2.18015775e-01f, -4.54032943e-02f, 1.23120159e-01f, -1.86077282e-01f, -6.03609122e-02f, 1.58114567e-01f, 1.83591709e-01f, -2.38456950e-01f, -7.81997219e-02f, 1.98087275e-01f,
  -8.62525627e-02f, -1.85901318e-02f, -2.26604939e-02f, 3.63751352e-01f, 1.49392664e-01f, 5.67517020e-02f, 3.17979515e-01f, -3.21452953e-02f, -5.81782423e-02f, -1.12678837e-02f,
  1.00037411e-01f, -2.45226294e-01f, -1.00713663e-01f, 5.34867533e-02f, 1.13534734e-01f, 2.28964090e-01f, -1.37068897e-01f, -1.24393612e-01f, -2.84159064e-01f, -2.87386179e-01f,
  -5.42259440e-02f, 2.07108468e-01f, 4.99928780e-02f, 1.92466870e-01f, 1.77370578e-01f, 6.09754920e-02f, 1.40973791e-01f, 4.07132655e-02f, -1.28184304e-01f, -7.19511136e-02f,
  1.28962755e-01f, 1.32084101e-01f, 1.67939812e-01f, 8.40881392e-02f, 1.33030683e-01f, 2.52219617e-01f, -2.69587398e-01f, 1.41354784e-01f, 7.30256960e-02f, -1.65896043e-02f,
  2.62265891e-01f, -1.14981279e-01f, 9.08764526e-02f, 1.47795916e-01f, 2.14982554e-01f, 1.08101480e-01f, -1.21504106e-02f, -2.85676382e-02f, 9.94482040e-02f, -1.70840472e-02f,
  -1.94943681e-01f, 5.22112176e-02f, 9.11093280e-02f, 5.20662405e-02f, -5.74781261e-02f, -5.85094094e-02f, -1.49109736e-02f, 6.28065243e-02f, 1.49961337e-01f, -1.39878541e-01f,
  2.49686882e-01f, 1.37255434e-02f, 1.92776576e-01f, -5.04563265e-02f, 1.78486153e-01f, -7.59795085e-02f, 1.47690132e-01f, -6.40782416e-02f, 1.17696673e-01f, -8.79116207e-02f,
  -1.91317290e-01f, -1.20207690e-01f, -1.30206212e-01f, -9.71114337e-02f, 1.70610715e-02f, -5.62840886e-02f, 1.36870444e-01f, 6.31674798e-03f, 2.15265173e-02f, -3.47732753e-02f,
  -1.76085263e-01f, 4.64438600e-03f, -1.02479719e-01f, 3.46083157e-02f, 1.11243315e-01f, 2.13959888e-01f, -3.40175107e-02f, 1.66250497e-01f, 1.30198210e-01f, 1.65415093e-01f,
  -4.97427657e-02f, -4.52316850e-02f, -1.01662792e-01f, 2.90518031e-02f, 1.60837416e-02f, -4.79402803e-02f, -1.43631190e-01f, 1.57606632e-01f, 1.56496212e-01f, 3.33255902e-02f,
  -1.84086427e-01f, -6.28623292e-02f, -2.66258750e-04f, 8.10865611e-02f, 1.61702484e-01f, 2.40936689e-02f, 2.43240312e-01f, -5.27633019e-02f, 6.48031235e-02f, 3.42916436e-02f,
  1.97266623e-01f, 1.04064383e-01f, -2.64939740e-02f, -1.15617387e-01f, 1.84222050e-02f, 4.52475026e-02f, 2.75002629e-01f, 6.94692060e-02f, 1.05460182e-01f, -1.96418852e-01f,
  1.34986579e-01f, 1.02688884e-02f, 1.22278892e-01f, 1.22549117e-01f, 1.79429725e-01f, 4.62310091e-02f, 3.97295058e-01f, 2.22017750e-01f, 1.61257714e-01f, 2.38027021e-01f,
  8.57868511e-03f, -1.48279458e-01f, 9.40346345e-03f, -5.76863177e-02f, 1.77963246e-02f, -5.86420521e-02f, -4.11685668e-02f, -4.42406014e-02f, -3.50855701e-02f, -1.59882590e-01f,
  2.10949019e-01f, -2.54053734e-02f, 2.00803265e-01f, -2.08799690e-01f, -1.87247455e-01f, -3.68141159e-02f, 2.12487400e-01f, -8.35896805e-02f, -1.53358968e-03f, 1.25069827e-01f,
  1.56342015e-01f, 2.71701574e-01f, 3.00111294e-01f, 1.89968646e-01f, 6.79497141e-03f, 1.97037607e-01f, -8.23351666e-02f, -2.21813962e-01f, 1.41778484e-01f, 2.00945318e-01f,
  1.75940081e-01f, 3.12179089e-01f, 2.01015417e-02f, 2.59113997e-01f, 6.24699928e-02f, 1.93826422e-01f, 2.90661544e-01f, -1.58153363e-02f, 1.05707437e-01f, 8.07896256e-02f,
  -7.58951679e-02f, 1.75350890e-01f, 2.28783756e-01f, 1.96289554e-01f, -7.98466802e-02f, 1.07090726e-01f, 1.64060608e-01f, 7.70858396e-03f, -1.15066618e-01f, 1.52671337e-01f,
  2.24530116e-01f, -3.29099111e-02f, 2.85030864e-02f, 3.88460718e-02f, 2.01703813e-02f, -1.02675103e-01f, -9.21221748e-02f, -9.80852023e-02f, 6.51276633e-02f, -5.94153889e-02f,
  1.60547122e-01f, 1.08507210e-02f, 1.33556232e-01f, -1.17349736e-01f, 1.01313047e-01f, 1.42687425e-01f, 1.24657914e-01f, 4.83024679e-02f, -1.64705113e-01f, 1.40089929e-01f,
  -1.36875749e-01f, -8.91499668e-02f, 1.84833184e-01f, -1.43954113e-01f, 1.52547061e-01f, -5.76687977e-02f, -1.08949868e-02f, 8.08293596e-02f, -5.11958264e-02f, 1.63621560e-01f,
  -8.30811188e-02f, 1.71803532e-03f, -2.57339180e-02f, 1.57207668e-01f, 6.11395016e-02f, -3.66795342e-03f, 1.55920580e-01f, 1.06762327e-01f, 1.80021182e-01f, 2.42318943e-01f,
  1.05110615e-01f, 2.41603795e-02f, 8.63486379e-02f, 1.76028118e-01f, -1.19118109e-01f, -3.22055095e-03f, -1.20326623e-01f, 1.18259490e-01f, 7.81385079e-02f, 9.30597037e-02f,
  7.55973905e-02f, 1.79580510e-01f, -1.11357905e-01f, -6.49370328e-02f, 3.97977419e-02f, 1.31627545e-01f, 1.56673297e-01f, 1.64475664e-01f, -3.38272378e-02f, 8.99205133e-02f,
  2.52258661e-03f, 7.36658871e-02f, -2.20374260e-02f, -5.98822460e-02f, 1.01678036e-01f, -1.77955031e-01f, 2.11163238e-02f, -1.26989827e-01f, 4.66747545e-02f, 8.09974447e-02f,
  2.09365234e-01f, 3.71081591e-01f, 9.63428691e-02f, 1.47275954e-01f, -6.47253394e-02f, 9.65396408e-03f, 1.90014437e-01f, 1.67548135e-02f, 9.57410857e-02f, 2.06180498e-01f,
  -2.28817791e-01f, -3.80004123e-02f, -5.02395444e-03f, -6.02513105e-02f, 1.12442121e-01f, -1.43849730e-01f, 1.73393279e-01f, -1.55982316e-01f, 1.76652715e-01f, -4.31396179e-02f,
  1.23207606e-01f, 5.92383593e-02f, -2.01388612e-01f, 1.99966431e-01f, -3.42553183e-02f, 1.34527281e-01f, 1.70198277e-01f, -6.40528500e-02f, 4.60671224e-02f, 2.24935114e-01f,
  1.62552312e-01f, 2.20461786e-01f, 8.01152959e-02f, -1.93292215e-01f, -2.33213186e-01f, 1.78004175e-01f, 2.04841681e-02f, -6.05830923e-02f, -2.06329599e-01f, 7.20319748e-02f,
  3.02062869e-01f, -1.12933010e-01f, -2.38034036e-02f, -3.68882269e-02f, -1.95159748e-01f, 4.64643259e-03f, -1.02762528e-01f, 1.31251231e-01f, 3.57434690e-01f, -8.50500241e-02f,
  -8.62652734e-02f, -1.96174428e-01f, 1.19859539e-01f, -1.00643411e-01f, -1.07328773e-01f, 2.10727472e-02f, 9.18241069e-02f, -7.09358416e-03f, 4.36157770e-02f, -2.46510822e-02f,
  -8.83776546e-02f, -5.10668661e-03f, -1.47887036e-01f, 2.71854317e-03f, -1.22772753e-01f, -7.96952173e-02f, -2.26337656e-01f, 1.30308717e-01f, -6.15344159e-02f, -3.38310981e-03f,
  -6.42378479e-02f, 7.48815536e-02f, 1.46071717e-01f, -4.79678102e-02f, -5.94264008e-02f, 1.86241612e-01f, 2.49185357e-02f, -5.22135533e-02f, 1.52191862e-01f, 5.62758856e-02f,
  -2.70719409e-01f, 2.37344891e-01f, 8.06945413e-02f, -6.19853847e-02f, 1.71501651e-01f, 7.98690692e-02f, -2.22662799e-02f, -1.96815997e-01f, 1.10246941e-01f, 2.51385458e-02f,
  -5.11120036e-02f, 1.84730589e-01f, -3.04845087e-02f, 5.26858158e-02f, 2.04791695e-01f, 1.09475456e-01f, 1.25450015e-01f, 1.04636580e-01f, -2.31448412e-01f, -1.71745270e-01f,
  2.09121972e-01f, 2.11109370e-01f, -2.70042066e-02f, 1.69947430e-01f, 1.73241824e-01f, 2.34819844e-01f, -5.20698726e-03f, 8.42136070e-02f, -2.89716781e-03f, -8.17688461e-03f,
  8.89418498e-02f, 3.46295163e-02f, 1.99747384e-01f, 1.20684214e-01f, 1.86572433e-01f, 8.71025398e-02f, 1.21822938e-01f, -4.89189923e-02f, -9.95264277e-02f, -5.91342114e-02f,
  -7.37761566e-03f, 1.50798514e-01f, 4.98979166e-02f, -9.00570601e-02f, -9.40531492e-02f, -4.48485464e-02f, -2.89090294e-02f, -1.64310724e-01f, 1.54484436e-01f, 2.15019509e-02f,
  -4.54778858e-02f, 2.03472719e-01f, 1.21909641e-01f, -1.13763615e-01f, 1.86527595e-01f, -3.45973708e-02f, 1.54220596e-01f, -6.18241914e-02f, 3.09682153e-02f, -2.37882938e-02f,
  -1.47525147e-01f, -1.06469169e-01f, -7.19987750e-02f, 1.67211536e-02f, 5.03326915e-02f, 9.82019305e-02f, 2.63887107e-01f, -9.32906643e-02f, 1.79193258e-01f, 1.77103765e-02f,
  -1.41480491e-01f, 1.68298855e-01f, 7.13042617e-02f, 1.35854959e-01f, 1.11903116e-01f, 1.53183311e-01f, 1.43757522e-01f, -1.32810343e-02f, 8.05127770e-02f, 4.27651703e-02f,
  -1.11233622e-01f, 1.16694495e-01f, -1.89997450e-01f, -1.45038888e-01f, -1.78249642e-01f, -2.63802558e-02f, 2.11247653e-01f, -8.42488483e-02f, -4.70892563e-02f, -6.06003515e-02f,
  -1.10326521e-01f, -1.23655669e-01f, 2.87027266e-02f, 1.24575324e-01f, 3.30430865e-01f, 1.12938896e-01f, -5.63861132e-02f, -8.18016902e-02f, -6.42889813e-02f, -5.51758986e-03f,
  1.77569166e-01f, 1.54429659e-01f, -1.53802782e-01f, 1.54975557e-03f, -1.13724425e-01f, 1.23083599e-01f, 6.05147071e-02f, 8.72595236e-02f, 1.48690984e-01f, 3.79420929e-02f,
  1.76793516e-01f, -1.68055259e-02f, -1.43624559e-01f, -2.90249616e-01f, 1.51343748e-01f, -4.50234748e-02f, -1.32819433e-02f, -2.03113124e-01f, 1.18075438e-01f, 1.32655725e-01f,
  2.07059588e-02f, 1.96610704e-01f, 3.66185665e-01f, 1.69965416e-01f, 4.88462746e-02f, 1.37594834e-01f, -5.39746620e-02f, 1.15253426e-01f, -6.54281229e-02f, 1.75267249e-01f,
  -3.53290215e-02f, 4.55106534e-02f, -1.20876543e-01f, 2.58913010e-01f, -1.93833355e-02f, -1.65737420e-01f, -4.51140329e-02f, -1.42408952e-01f, -6.41634911e-02f, 6.35503903e-02f,
  2.11676240e-01f, 2.19794080e-01f, 2.32060224e-01f, 2.26118505e-01f, 5.69294654e-02f, 1.31474137e-01f, -1.53304830e-01f, -7.09585100e-02f, 2.23541558e-01f, 9.19485018e-02f,
  -1.25797689e-01f, 2.30136946e-01f, 1.49671823e-01f, 3.14749591e-02f, 3.59307379e-02f, 1.62451550e-01f, 1.80322915e-01f, 1.63866878e-01f, -7.84646869e-02f, -6.48497865e-02f,
  1.88651919e-01f, 4.52049747e-02f, 1.23084754e-01f, -2.12900396e-02f, -3.42258927e-03f, -1.00666896e-01f, 5.47739044e-02f, 1.75590992e-01f, -1.01782873e-01f, -1.25236269e-02f,
  1.61771253e-01f, -1.35574788e-01f, 7.44434744e-02f, -4.42162901e-02f, -1.15359582e-01f, -1.64184004e-01f, 1.29129544e-01f, 3.04783374e-01f, 1.66657567e-01f, 2.26602137e-01f,
  1.03323944e-01f, 3.11818961e-02f, 1.92309350e-01f, 1.02063268e-01f, 1.74839348e-01f, 1.75788537e-01f, -8.32673684e-02f, -1.16537794e-01f, -9.37774181e-02f, 3.64057273e-02f,
  1.03089087e-01f, -1.68558493e-01f, 4.46479674e-03f, 7.15557998e-03f, 2.34284207e-01f, -1.89055596e-02f, 1.54079571e-01f, -1.62066281e-01f, -1.61335781e-01f, 1.99979350e-01f,
  4.67949733e-02f, 8.53756070e-02f, 1.64666429e-01f, 2.02675432e-01f, 1.12775601e-01f, 8.39151163e-03f, 1.58236101e-01f, 1.58607855e-01f, -2.16583118e-01f, 1.44702550e-02f,
  -1.59823552e-01f, 2.01093256e-02f, -1.50099650e-01f, -1.15934853e-02f, 4.63565253e-02f, -1.73204765e-01f, 5.80734871e-02f, 3.47026847e-02f, 2.01647386e-01f, -4.62205755e-03f,
  8.50728974e-02f, -6.08881526e-02f, 2.44049147e-01f, 3.30340825e-02f, 2.01221883e-01f, -2.62438636e-02f, -1.93526316e-02f, -1.20446272e-02f, 7.07401484e-02f, 2.17265591e-01f,
  -6.88373223e-02f, -8.20084661e-02f, 2.31646076e-02f, 2.20231637e-01f, -1.17561489e-01f, 1.64891034e-01f, 1.90726995e-01f, 1.89876497e-01f, 2.11455505e-02f, -2.62976009e-02f,
  -4.89493608e-02f, -1.34666279e-01f, 1.10231563e-01f, -1.84628338e-01f, 1.16873684e-03f, -5.72973676e-02f, -3.14437747e-02f, -1.19927386e-03f, 1.78341284e-01f, 2.03626975e-01f,
  2.21654400e-01f, 2.61990309e-01f, 1.84297383e-01f, 1.25148118e-01f, -2.79754847e-02f, 2.30323046e-01f, -1.84843436e-01f, 7.46283382e-02f, -3.12350951e-02f, -6.43532872e-02f,
  -6.53380668e-03f, 2.62269408e-01f, -7.42012709e-02f, -1.45446330e-01f, -8.25077891e-02f, -6.83696866e-02f, 1.29797950e-01f, 1.31529450e-01f, -1.17223479e-01f, 1.34003073e-01f,
  4.50579524e-02f, 1.14830390e-01f, -1.10179059e-01f, -1.80394933e-01f, 4.54701781e-02f, -1.81634016e-02f, -1.65452316e-01f, -7.64114335e-02f, 1.84507277e-02f, -1.30327672e-01f,
  2.54226357e-01f, -6.45991564e-02f, -8.77503827e-02f, -5.32555990e-02f, -6.91040531e-02f, 7.14479387e-02f, 2.66120136e-01f, 2.40082040e-01f, -1.09998718e-01f, 6.59141392e-02f,
  -6.61048815e-02f, -3.59985307e-02f, 2.07088321e-01f, -1.08793832e-01f, 6.97684735e-02f, -1.44851938e-01f, 3.04021244e-03f, -8.94401781e-03f, 1.08425274e-01f, -9.89885405e-02f,
  9.55665559e-02f, -1.62925258e-01f, 1.65393278e-01f, 1.40025849e-02f, 1.25583142e-01f, -1.74068753e-02f, 5.09729870e-02f, -1.88071534e-01f, 3.63664001e-01f, 2.15527058e-01f,
  7.86592960e-02f, 1.24151722e-01f, -2.77734008e-02f, -1.58674307e-02f, 2.54016310e-01f, 2.08806887e-01f, 3.43491621e-02f, 7.21424371e-02f, 2.16451101e-03f, -6.98771179e-02f,
  -1.39107198e-01f, -1.16397694e-01f, -6.23130277e-02f, -1.18827717e-02f, -6.54358342e-02f, -3.55908126e-02f, -1.11082017e-01f, -2.05391511e-01f, -6.18774369e-02f, -4.98492159e-02f,
  1.49737298e-01f, -7.71780824e-03f, 6.81662932e-02f, 1.66273847e-01f, 1.46727934e-01f, 7.26437522e-03f, -3.81593443e-02f, -5.05091697e-02f, 1.31509587e-01f, 1.37248203e-01f,
  -5.43047395e-03f, -1.61183238e-01f, -1.35315403e-01f, -4.11184803e-02f, 2.26614565e-01f, -1.02293171e-01f, 1.68329522e-01f, 6.04556538e-02f, -2.12834105e-01f, 9.33659151e-02f,
  -1.80712976e-02f, 1.03480369e-01f, 2.00845331e-01f, -1.31172091e-01f, -3.10253166e-02f, -2.18412399e-01f, 1.27983108e-01f, -9.76376049e-03f, 9.48133878e-03f, 4.68016509e-03f,
  -3.76397781e-02f, -5.21325730e-02f, 3.68236415e-02f, -9.44937989e-02f, 4.81855348e-02f, -2.23865658e-02f, -1.51354700e-01f, -4.28329268e-03f, -1.28607601e-01f, 1.40765443e-01f,
  -6.64852113e-02f, 2.22368822e-01f, 2.32817620e-01f, 2.41868675e-01f, -8.90408829e-02f, 1.41907856e-01f, -2.05653440e-02f, 7.76934996e-02f, 6.14330955e-02f, -1.80837866e-02f,
  5.44713587e-02f, -1.05153294e-02f, 3.19919502e-03f, 1.25534898e-02f, -4.37366515e-02f, -3.22424956e-02f, 2.27606565e-01f, -1.58008933e-02f, 2.22555771e-01f, -1.66032650e-02f,
  -6.27114698e-02f, -1.09820649e-01f, 4.66775708e-02f, 6.30644411e-02f, 2.02611342e-01f, 2.79935986e-01f, 1.48300663e-01f, 1.44483849e-01f, 1.79620609e-01f, 2.53543288e-01f,
  -9.04775411e-02f, 8.14460963e-02f, 3.25380743e-01f, -4.85865865e-03f, 2.76616588e-02f, 9.54747051e-02f, 4.53834161e-02f, -4.59213443e-02f, -2.20660150e-01f, 7.55445287e-02f,
  3.71069908e-02f, 3.49711366e-02f, 6.74421564e-02f, 1.55638054e-01f, -9.95077640e-02f, -2.62415726e-02f, -2.24325210e-01f, 1.40275538e-01f, 1.01700194e-01f, 9.70153604e-03f,
  -1.77121893e-01f, -6.57978375e-03f, 3.23150992e-01f, 5.04082739e-02f, 1.27999216e-01f, -3.48034985e-02f, -2.09115702e-03f, 7.65402392e-02f, -2.38787066e-02f, 4.74357940e-02f,
  2.81968087e-01f, 1.41112521e-01f, 2.49260552e-02f, 9.77268070e-02f, 1.72294483e-01f, -1.16198182e-01f, -2.09326893e-01f, -1.03270993e-01f, 1.59427837e-01f, -1.14709862e-01f,
  -9.47761759e-02f, 4.10474837e-02f, -5.70200980e-02f, 6.30516410e-02f, -1.12006590e-01f, 1.69769302e-01f, 6.25754148e-02f, 1.47313863e-01f, 2.75356770e-01f, 5.85841127e-02f,
  -1.74743339e-01f, 2.30543986e-01f, 1.58485740e-01f, 5.02405241e-02f, 1.63006261e-01f, 1.09282129e-01f, 2.24143535e-01f, -2.89257821e-02f, 1.34875476e-01f, 8.78770184e-03f,
  -7.53790662e-02f, 1.69914037e-01f, 5.98357245e-02f, 1.18158408e-01f, -8.17747936e-02f, -1.89970046e-01f, 2.86361903e-01f, 1.51991531e-01f, 8.92632082e-02f, -2.49062981e-02f,
  -1.76561087e-01f, -2.50946075e-01f, 1.15398578e-01f, -1.64660737e-01f, 3.04196835e-01f, -2.54349615e-02f, 1.75303109e-02f, -1.38246968e-01f, -2.11951286e-01f, -2.00964641e-02f,
  3.62856053e-02f, 3.51018249e-03f, -4.98070307e-02f, 9.64906532e-03f, 1.18112164e-02f, -1.60846740e-01f, 4.82795723e-02f, 4.00169790e-02f, 2.12618813e-01f, 7.33702257e-02f,
  2.17083339e-02f, -7.89825525e-03f, 1.95649624e-01f, 1.66395828e-01f, -9.02378857e-02f, 6.06986284e-02f, 1.68187022e-01f, 6.57787621e-02f, -1.06580563e-01f, -3.05698216e-02f,
  1.22429002e-02f, 3.14050376e-01f, 8.41224715e-02f, 2.50609145e-02f, -6.39879331e-02f, 1.49287447e-01f, -8.16063955e-02f, -4.70599905e-02f, 2.47657821e-01f, 1.76060107e-02f,
  1.53194457e-01f, -1.40569463e-01f, -7.93575943e-02f, 4.35941778e-02f, -2.08118066e-01f, 1.29497409e-01f, -3.32236588e-02f, 1.81258157e-01f, 2.75592729e-02f, -1.01354413e-01f,
  1.30079333e-02f, -1.09126322e-01f, -7.97484219e-02f, -1.79740731e-02f, 1.30065247e-01f, 1.82808623e-01f, 4.87922765e-02f, 9.10697803e-02f, -4.63231802e-02f, 4.27342616e-02f,
  -4.97504026e-02f, -1.29603352e-02f, 1.40548706e-01f, 1.70941409e-02f, 1.46182537e-01f, 1.56888425e-01f, -2.04871073e-01f, 2.64655173e-01f, -1.68652132e-01f, 1.42972767e-01f,
  9.89434496e-02f, 1.20445512e-01f, 8.89710188e-02f, -6.50940090e-02f, -2.16389015e-01f, 9.37459245e-02f, -2.44734939e-02f, 2.80659467e-01f, 2.99639665e-02f, 1.91637635e-01f,
  1.10634156e-01f, 1.08302999e-02f, -1.85324654e-01f, -1.17971197e-01f, 1.97976038e-01f, 4.78326976e-02f, -8.76150280e-02f, 6.53788894e-02f, 2.51312643e-01f, 1.55251529e-02f,
  1.52056161e-02f, 4.83439229e-02f, 1.04846254e-01f, 3.89503874e-02f, 1.04425453e-01f, -1.66661084e-01f, -6.46597520e-02f, -9.88764763e-02f, 8.52599964e-02f, -1.84409395e-01f,
  -1.81784242e-01f, -1.20054200e-01f, -8.90843868e-02f, -2.10787226e-02f, -4.17713933e-02f, -6.62279874e-02f, 1.78697646e-01f, 1.14891278e-02f, -1.10647917e-01f, 8.62853602e-02f,
  -2.76478427e-03f, -4.67258878e-02f, 1.65581509e-01f, 1.91522866e-01f, 9.94771123e-02f, -1.32763892e-01f, 6.96754362e-03f, 3.55416127e-02f, 1.38402939e-01f, -1.27935400e-02f,
  1.71352312e-01f, -6.06039597e-04f, -2.94604748e-02f, 1.54573862e-02f, 3.27594206e-02f, -2.51407743e-01f, -2.44437188e-01f, 1.53547600e-01f, 1.83795020e-01f, 4.70623970e-02f,
  -7.56504387e-02f, -6.51661530e-02f, 7.69736394e-02f, -1.20395031e-02f, 3.93717289e-02f, 1.01854309e-01f, 1.29604578e-01f, -8.14283416e-02f, -1.92378387e-01f, -5.23917452e-02f,
  1.18152544e-01f, 1.05514862e-01f, -5.73700778e-02f, 1.40442610e-01f, 3.90103087e-02f, -7.55409077e-02f, -1.41305551e-01f, 1.00450248e-01f, 3.16805951e-02f, 2.45108053e-01f,
  2.81444311e-01f, 1.56690031e-01f, 1.71275482e-01f, 5.07433228e-02f, -8.69514123e-02f, -1.69916838e-01f, 1.89218715e-01f, -6.82811961e-02f, 3.81290764e-02f, -4.38560434e-02f,
  -4.56272811e-02f, -1.39929891e-01f, 5.09494310e-03f, 2.40309998e-01f, 8.48121420e-02f, 2.61079103e-01f, 1.58845246e-01f, 8.96838754e-02f, -1.98340490e-01f, 9.96625349e-02f,
  2.42265724e-02f, -5.33677824e-02f, -3.40824686e-02f, 1.19195297e-01f, -2.04022795e-01f, 1.92902684e-01f, -2.03079954e-02f, -6.41173869e-02f, -1.24320053e-01f, -1.38438925e-01f,
  4.51046489e-02f, -2.40105633e-02f, -5.06470837e-02f, -1.59322321e-02f, -7.07979351e-02f, 2.35022474e-02f, -6.63543567e-02f, -2.15836689e-02f, 3.48119646e-01f, 1.45661101e-01f,
  -1.67518497e-01f, -1.74237669e-01f, 2.11138558e-03f, -1.62412971e-01f, 1.23027183e-01f, -6.83774799e-02f, 1.53358549e-01f, -1.49488285e-01f, 3.27806845e-02f, -2.15833653e-02f,
  -1.26964018e-01f, 9.54998434e-02f, -1.46538243e-01f, 9.90112871e-02f, -1.65933833e-01f, -4.62002270e-02f, 3.93008105e-02f, -1.39166132e-01f, 1.15633957e-01f, -2.15058520e-01f,
  8.52535293e-02f, -1.81856677e-01f, 8.61180872e-02f, -1.02649555e-01f, 1.56233534e-01f, 5.04398271e-02f, -1.22296229e-01f, 1.61556020e-01f, 1.30660072e-01f, 1.43172964e-01f,
  -4.81887199e-02f, -1.95414484e-01f, 2.90657967e-01f, 9.49328691e-02f, 1.85189173e-01f, 1.32803172e-01f, -2.68615723e-01f, 3.13908271e-02f, -2.10975409e-02f, 2.39693914e-02f,
  3.89311984e-02f, -5.28477095e-02f, 1.76244050e-01f, -1.13434620e-01f, 3.12344693e-02f, -1.52470291e-01f, -8.49153399e-02f, 2.90075876e-02f, -9.26916227e-02f, -9.78380442e-02f,
  7.73903877e-02f, -1.01572685e-01f, 1.77617922e-01f, 8.88880268e-02f, -9.83629525e-02f, 1.46279693e-01f, 1.43516362e-01f, 1.93333048e-02f, 1.32994846e-01f, 1.02227191e-02f,
  -6.27858639e-02f, 1.44115403e-01f, -1.77640039e-02f, -8.52345452e-02f, 9.69504286e-03f, 1.20267570e-01f, 8.95404965e-02f, -1.89514402e-02f, -1.31391332e-01f, 2.28787884e-01f,
  1.50545705e-02f, 7.01527903e-03f, 8.44320096e-03f, 3.14651914e-02f, 9.15065482e-02f, -1.14369534e-01f, -1.48894623e-01f, 1.09944619e-01f, 2.05863938e-01f, 1.28572404e-01f,
  -9.17392746e-02f, 2.14028925e-01f, 1.47531971e-01f, -1.09465733e-01f, 4.69633378e-02f, -1.29394993e-01f, 1.42757580e-01f, 1.24958292e-01f, -2.88269878e-03f, 2.25612119e-01f,
  2.91024119e-01f, 1.64485082e-01f, 6.96107671e-02f, -2.32560351e-01f, 1.66190937e-01f, -5.59338927e-02f, 8.91661048e-02f, -7.79889598e-02f, -2.20067382e-01f, -1.36432394e-01f,
  2.93138269e-02f, -6.12188689e-03f, 1.05969673e-02f, -1.05518952e-01f, -2.18307525e-01f, 2.03129217e-01f, 7.81133771e-02f, -1.68311913e-02f, 1.72720805e-01f, 1.31717786e-01f,
  -8.75210576e-03f, 2.19596401e-01f, -1.40672207e-01f, 6.00764640e-02f, 2.05841318e-01f, 1.06995143e-02f, 1.09674655e-01f, -8.43710601e-02f, -6.16242923e-03f, 1.52653530e-01f,
  2.03071367e-02f, 1.03664510e-01f, 8.64717066e-02f, 1.68022886e-01f, 8.87538791e-02f, 2.03011349e-01f, -7.53652453e-02f, -7.87362158e-02f, 8.54761433e-03f, 5.38883805e-02f,
  1.66086748e-01f, 1.41606465e-01f, -2.11264968e-01f, 2.39483148e-01f, -3.24387988e-03f, -9.69058648e-02f, 1.99749302e-02f, 1.89903826e-01f, 1.78899512e-01f, 2.79152906e-03f,
  -1.91596434e-01f, -3.31972651e-02f, 1.33747339e-01f, 1.95646614e-01f, -9.51237977e-02f, 5.81369922e-02f, 1.62847608e-01f, 7.92945102e-02f, -6.37953579e-02f, -1.06339075e-01f,
  1.79050848e-01f, -4.14953642e-02f, -8.64458382e-02f, 2.32765004e-01f, 2.97089309e-01f, 1.06330603e-01f, 1.33595660e-01f, -2.55142748e-01f, 4.35416549e-02f, 9.91843939e-02f,
  1.00820892e-01f, -4.69549447e-02f, -8.83396566e-02f, -1.53317139e-01f, -7.88878277e-03f, 6.04075156e-02f, 1.68089062e-01f, 7.23191630e-03f, -1.58258930e-01f, 1.46753371e-01f,
  -1.06269062e-01f, 8.99584144e-02f, 1.95759147e-01f, 6.10015318e-02f, 3.42012420e-02f, -5.48391901e-02f, 6.58159256e-02f, 3.12871039e-02f, 1.68034092e-01f, 1.26924351e-01f,
  1.11794032e-01f, 4.86122221e-02f, 1.24325216e-01f, 1.73797339e-01f, 1.37204096e-01f, 9.78718847e-02f, 7.34343454e-02f, 1.75683171e-01f, -1.94033667e-01f, -2.09893122e-01f,
  2.34089360e-01f, -4.01872247e-02f, -2.07157791e-01f, -5.12954853e-02f, 1.59462482e-01f, -5.56581505e-02f, -9.36701074e-02f, -1.57040700e-01f, 2.04816148e-01f, -1.29930109e-01f,
  5.57709020e-03f, 4.55742795e-03f, -7.27879778e-02f, 9.49132740e-02f, 3.33420336e-02f, -1.59324929e-01f, -1.07405119e-01f, -1.78140834e-01f, 3.42723168e-02f, 1.22400589e-01f,
  1.37836814e-01f, 5.14622182e-02f, 1.97303966e-01f, -2.78390814e-02f, -8.51617083e-02f, 3.27720605e-02f, 2.80103236e-01f, 1.90700844e-01f, 4.83517759e-02f, 1.31871458e-02f,
  -6.63715005e-02f, 5.88384829e-02f, -2.25017834e-02f, -5.86468205e-02f, -1.20167546e-02f, -7.37671927e-02f, -4.08439673e-02f, -7.20444843e-02f, -1.10475719e-01f, 3.66761833e-02f,
  1.08610034e-01f, 1.46049455e-01f, 2.21332967e-01f, 2.61656176e-02f, 1.00426152e-01f, 1.96567014e-01f, -1.04862526e-01f, 1.48887798e-01f, -2.15887427e-01f, 2.97672283e-02f,
  -1.45051613e-01f, 1.87520191e-01f, 1.77743733e-01f, 2.70864624e-03f, 1.59916118e-01f, 1.41843349e-01f, -7.00822845e-02f, 7.53167272e-02f, 3.15353274e-02f, 1.03830904e-01f,
  1.61944050e-02f, 2.46839017e-01f, 1.52081847e-01f, 2.57127695e-02f, -1.27501190e-01f, -1.13697417e-01f, 1.38728678e-01f, -8.19009617e-02f, 1.14013091e-01f, 1.71342537e-01f,
  6.24996051e-02f, 2.54973054e-01f, -6.72882199e-02f, 8.99804458e-02f, 7.45696947e-02f, 8.72520655e-02f, 1.43103942e-01f, -1.53045088e-01f, 2.85498630e-02f, 1.32050753e-01f,
  1.65970758e-01f, 1.64402381e-01f, -7.46580362e-02f, 7.75021687e-02f, 1.25144064e-01f, -1.39995024e-01f, -2.10826024e-01f, -5.78543264e-03f, 1.32419422e-01f, -2.74796952e-02f,
  -1.97846130e-01f, 3.95371355e-02f, 2.03205980e-02f, 2.88805980e-02f, 2.27912903e-01f, -5.98101392e-02f, 8.06062222e-02f, 3.19638140e-02f, 2.53397942e-01f, -3.82375717e-02f,
  1.25338987e-01f, -5.58428206e-02f, 4.96026017e-02f, -1.51901573e-01f, -4.89174277e-02f, -1.06373891e-01f, -2.22464964e-01f, -3.67068984e-02f, -1.24395795e-01f, -9.08852518e-02f,
  2.04091653e-01f, 1.39604270e-01f, 1.17459461e-01f, 1.23662122e-01f, -1.78973712e-02f, -1.34771720e-01f, 9.05809700e-02f, 9.89227891e-02f, 1.52868420e-01f, 3.37619334e-02f,
  2.04083577e-01f, -1.06677888e-02f, 1.56004086e-01f, -1.11394227e-02f, 9.61651281e-02f, 1.66641641e-02f, -9.44760293e-02f, 1.64542586e-01f, 1.00621998e-01f, 5.23938760e-02f,
  -8.99877027e-02f, 1.82657480e-01f, 7.63506889e-02f, 8.93783048e-02f, -1.63737446e-01f, 1.32425427e-01f, -2.24115215e-02f, -4.52664979e-02f, 1.36100367e-01f, 1.30983874e-01f,
  -6.40543103e-02f, 7.93323740e-02f, -1.44044563e-01f, -9.00105536e-02f, -1.47635443e-03f, -9.73480660e-03f, 8.37049112e-02f, 9.75124985e-02f, 1.72290578e-01f, 1.35381863e-01f,
  1.69263944e-01f, 1.34763896e-01f, -1.56696752e-01f, 1.61775127e-01f, -1.65102817e-02f, 2.41895691e-01f, 2.33857259e-01f, 1.62334256e-02f, -1.17190734e-01f, -2.89388388e-01f,
  7.49073103e-02f, 1.26220854e-02f, 2.89833192e-02f, -1.47555262e-01f, -5.40892780e-02f, -9.96605828e-02f, -8.59965011e-02f, -1.50735185e-01f, 9.63580832e-02f, 9.35255736e-02f,
  -1.04910284e-01f, 2.82439619e-01f, 1.10327806e-02f, 2.67775178e-01f, 1.57750472e-01f, 2.02854395e-01f, 8.47766548e-02f, 2.13030159e-01f, -1.32054063e-02f, 2.43461072e-01f,
  2.54111499e-01f, 6.09394535e-02f, 2.11610496e-01f, -7.46317133e-02f, -1.31410267e-02f, 3.83196026e-02f, -2.87787896e-02f, 1.14730828e-01f, 3.20321396e-02f, -3.65107171e-02f,
  1.83503434e-01f, 7.74484798e-02f, -9.45189744e-02f, 1.22085130e-02f, 1.67757109e-01f, 1.89702630e-01f, 1.19407371e-01f, 3.16221058e-01f, 1.59532636e-01f, 1.60383984e-01f,
  1.03067435e-01f, 1.94322348e-01f, 1.19357839e-01f, -5.53295054e-02f, -1.84259340e-01f, -1.14815377e-01f, 1.19724475e-01f, 1.13458574e-01f, 3.97117399e-02f, 2.91078771e-03f,
  -1.96070522e-02f, -2.39738315e-01f, 1.31524026e-01f, 6.48813928e-03f, 4.36863527e-02f, 3.02840676e-02f, -8.13890398e-02f, -1.74473897e-01f, -6.63309097e-02f, -1.09097935e-01f,
  -1.34673327e-01f, -4.92450409e-02f, -6.69275299e-02f, 1.49217680e-01f, -6.92750514e-02f, 2.51575559e-01f, -1.27165869e-01f, -3.99135128e-02f, 6.60554618e-02f, 7.31124431e-02f,
  1.30311921e-01f, 3.00377682e-02f, -3.26563746e-01f, -1.93036497e-01f, 1.78256571e-01f, -1.30966783e-01f, -5.08859828e-02f, -2.48500947e-02f, 6.69332519e-02f, -1.58643257e-02f,
  4.00967672e-02f, 9.24150366e-03f, 1.15633376e-01f, -9.97734163e-03f, -2.16963843e-01f, 2.52251327e-01f, 7.87782520e-02f, -7.28364736e-02f
};

// L1_fan_Bp_bar (Shape: 1 x 52)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 52;
const float L1_fan_Bp_bar_data[] = {
  3.44318449e-02f, 1.84045792e-01f, 1.30783349e-01f, 1.16715237e-01f, 9.11051705e-02f, 1.89690724e-01f, 2.01821640e-01f, 1.42949089e-01f, 2.26934478e-01f, 1.14910468e-01f,
  3.15247662e-02f, 1.67574987e-01f, 6.33721575e-02f, 5.80487922e-02f, 2.27812842e-01f, 1.78080589e-01f, 2.68237174e-01f, -1.00232940e-02f, 1.09905705e-01f, 4.88084517e-02f,
  2.27420092e-01f, 1.01563059e-01f, 2.17183962e-01f, 8.14284722e-04f, 4.26512547e-02f, 1.59948561e-02f, 1.46076769e-01f, 1.08031332e-01f, 1.94709226e-01f, 1.44269586e-01f,
  2.00845942e-01f, 1.25528006e-02f, 1.69357330e-01f, -3.18744928e-02f, 2.00335532e-01f, 3.48732099e-02f, 6.68531507e-02f, 5.86885028e-02f, 1.53854996e-01f, 5.42028919e-02f,
  7.55421966e-02f, 1.39845416e-01f, 1.20568536e-01f, 5.28500713e-02f, 1.03265211e-01f, 3.88979353e-02f, 2.48800814e-02f, 1.73736766e-01f, 1.48037598e-01f, 6.65969551e-02f,
  1.28873616e-01f, 1.94970474e-01f
};

// L2_fan_Wp (Shape: 6 x 64)
const int L2_fan_Wp_rows = 6;
const int L2_fan_Wp_cols = 64;
const float L2_fan_Wp_data[] = {
  7.68705234e-02f, 2.49809556e-04f, 2.35408563e-02f, 3.79411392e-02f, 1.30366772e-01f, 9.65781733e-02f, 1.77973241e-01f, -8.67197961e-02f, 1.30504102e-01f, -6.97632879e-03f,
  -1.81783155e-01f, -5.88690303e-02f, 8.35473612e-02f, -1.05927832e-01f, 8.09148885e-03f, -1.94931269e-01f, 1.20918788e-01f, -1.54591382e-01f, 1.31860688e-01f, -3.70786265e-02f,
  -2.52714958e-02f, 8.45249072e-02f, -2.60026783e-01f, 1.91685170e-01f, 2.20796820e-02f, 1.40468195e-01f, 1.28243968e-01f, -8.71331543e-02f, 6.10047542e-02f, -1.11659363e-01f,
  9.83206853e-02f, 8.26838091e-02f, 1.04182726e-03f, 1.50783151e-01f, 1.36811107e-01f, 5.43119758e-02f, 1.32843196e-01f, 6.55229241e-02f, 8.50042850e-02f, 5.95804639e-02f,
  8.27635601e-02f, 1.01664755e-02f, 1.31036803e-01f, -9.65265259e-02f, 2.67015379e-02f, -7.11685717e-02f, 1.25984788e-01f, 1.71702504e-01f, -6.24262262e-03f, -2.53570694e-02f,
  -3.95045504e-02f, -1.63144052e-01f, 2.77736429e-02f, 1.34154245e-01f, -1.27160728e-01f, 6.71563148e-02f, 8.70035514e-02f, -1.36387751e-01f, 1.11730933e-01f, 1.10327892e-01f,
  -9.50150341e-02f, -3.05832885e-02f, -4.20615524e-02f, -8.86260718e-02f, 5.91632016e-02f, -6.84825331e-02f, 3.18751559e-02f, -1.75447911e-01f, -1.71587780e-01f, 4.32093590e-02f,
  -1.68624613e-02f, -1.72464475e-01f, -7.45899454e-02f, -1.67994236e-03f, 6.91412836e-02f, 2.18049020e-01f, -1.58842370e-01f, 1.12803183e-01f, 7.77389854e-03f, 1.59988835e-01f,
  -1.31392762e-01f, -1.48644708e-02f, 1.32976338e-01f, 1.50132641e-01f, 3.63709703e-02f, -1.26929224e-01f, -6.17610803e-03f, -1.57955721e-01f, -4.01817672e-02f, 5.25868312e-02f,
  9.29439291e-02f, -1.10049479e-01f, 3.54776196e-02f, -4.51995581e-02f, 2.06840262e-01f, 9.87609997e-02f, -1.95962831e-01f, 2.26069707e-03f, -1.63680911e-01f, 1.78011805e-01f,
  -4.15292233e-02f, 1.08789228e-01f, 5.67796193e-02f, 1.62338853e-01f, 1.17974519e-03f, -4.38146256e-02f, -1.23251818e-01f, -1.28926322e-01f, -1.36344895e-01f, 4.69680279e-02f,
  5.40670566e-02f, -7.72652403e-02f, -6.16106167e-02f, 4.59952019e-02f, 4.01208550e-02f, -2.10760027e-01f, -1.71649098e-01f, 1.22910641e-01f, 6.13139868e-02f, -2.84162220e-02f,
  -1.28762037e-01f, -1.80743128e-01f, 2.35437602e-01f, 7.32030571e-02f, -1.23289026e-01f, -1.03818484e-01f, -3.43026295e-02f, -5.23760244e-02f, -1.80338949e-01f, -1.11290991e-01f,
  -3.97939719e-02f, -6.63068742e-02f, -2.00131368e-02f, -1.57957956e-01f, 1.97040007e-01f, 6.38367981e-02f, -3.50502580e-02f, -1.21065758e-01f, -1.17335968e-01f, 8.19324106e-02f,
  6.21397980e-02f, -6.95791617e-02f, 1.32331520e-01f, 8.09312165e-02f, 8.78653601e-02f, 1.56869143e-02f, -1.41508609e-01f, -1.17069799e-02f, 1.44715577e-01f, 4.74947356e-02f,
  8.05628970e-02f, -1.16945088e-01f, 1.64692700e-01f, 2.37925835e-02f, -1.71070620e-01f, 7.23642260e-02f, 4.90456857e-02f, 4.61607091e-02f, -7.89272934e-02f, -1.36646122e-01f,
  1.33439839e-01f, -9.58979651e-02f, -2.12506771e-01f, 1.29499301e-01f, -1.00672029e-01f, 7.78772682e-02f, 9.23273433e-03f, -3.17873955e-02f, 9.27224532e-02f, -1.10994533e-01f,
  2.59264372e-02f, 1.87596425e-01f, -1.25504538e-01f, -7.72535503e-02f, -3.43078636e-02f, 1.32756591e-01f, 3.15115266e-02f, -3.68911922e-02f, 7.44604096e-02f, 1.71503037e-01f,
  -1.11693650e-01f, -1.74318086e-02f, 3.20881559e-03f, 1.07877158e-01f, -1.26224980e-01f, 7.55116791e-02f, -3.19046900e-02f, 7.90602267e-02f, -9.51548144e-02f, 1.17917061e-01f,
  -1.30921304e-01f, -9.67690349e-02f, -7.33633153e-03f, -6.52396157e-02f, -7.20845908e-02f, -1.01592273e-01f, -3.15882936e-02f, 6.26458898e-02f, -9.63590518e-02f, -2.10100159e-01f,
  -9.43628624e-02f, 1.18711099e-01f, 1.13961488e-01f, 1.17861129e-01f, -1.71537563e-01f, -1.06020845e-01f, 6.67347088e-02f, 2.04098150e-02f, -5.45751788e-02f, 3.62305460e-03f,
  -1.31128877e-01f, 5.17826108e-03f, 1.03218965e-01f, 1.28445074e-01f, 8.35877284e-02f, -4.94692884e-02f, -9.74299684e-02f, 1.35563657e-01f, 2.74322238e-02f, -1.38137251e-01f,
  -8.71318877e-02f, -3.82988900e-02f, 1.10897169e-01f, -3.82171385e-02f, -2.00809985e-02f, -1.06613636e-01f, -1.49899870e-01f, 1.58140302e-01f, -2.52645612e-02f, 1.83464691e-01f,
  1.45295903e-01f, -7.51098692e-02f, -3.20744328e-02f, -1.33061156e-01f, -8.49086046e-02f, -7.80842975e-02f, -2.53785513e-02f, 1.38386741e-01f, 2.87865922e-02f, -8.22920725e-02f,
  -6.47827312e-02f, -8.85290727e-02f, -1.50592566e-01f, -2.42278129e-01f, -9.56228077e-02f, -6.01179451e-02f, -8.17006230e-02f, 1.25463560e-01f, -1.28998071e-01f, 1.16833029e-02f,
  -1.74192991e-02f, 1.16901822e-01f, 3.31465229e-02f, 1.53750435e-01f, 1.31865576e-01f, -1.71194568e-01f, 4.44011092e-02f, -7.20154820e-03f, -1.23312394e-03f, -6.26568571e-02f,
  -1.10996090e-01f, -8.55946839e-02f, 4.08663154e-02f, -1.33962333e-01f, -5.84365390e-02f, 2.62635816e-02f, -7.52885640e-02f, -2.04998866e-01f, -2.19899379e-02f, 6.41221702e-02f,
  -1.81158245e-01f, -7.90944919e-02f, 2.09089696e-01f, -2.22243387e-02f, 6.80011213e-02f, -1.57198176e-01f, -7.54145756e-02f, 7.72929117e-02f, 3.01230736e-02f, 1.21060207e-01f,
  -6.35522231e-02f, 6.27950728e-02f, -8.49903375e-02f, 3.87899838e-02f, 7.24639371e-02f, -1.48524240e-01f, -7.86854699e-02f, 1.43641397e-01f, -1.11763209e-01f, 1.65319964e-01f,
  6.55933246e-02f, 8.93314481e-02f, -2.20329687e-02f, -1.19100787e-01f, -8.69690925e-02f, -4.51556705e-02f, 1.33866638e-01f, -3.98243926e-02f, 1.23610370e-01f, 1.78437438e-02f,
  -6.82032257e-02f, 1.40546739e-01f, 1.01156913e-01f, 1.35067418e-01f, 4.60172109e-02f, 1.40488595e-01f, -7.71413893e-02f, -1.31170392e-01f, -5.71782850e-02f, -1.74823180e-02f,
  -7.92255178e-02f, 3.00718173e-02f, 3.15644662e-03f, 1.29399626e-02f, -7.26745725e-02f, -1.41902015e-01f, -1.18391231e-01f, -9.81187150e-02f, -1.11695409e-01f, 1.21911159e-02f,
  1.41944498e-01f, 1.49242491e-01f, -9.04684141e-02f, 3.52211446e-02f, 6.47949427e-02f, -9.05832052e-02f, -1.65691301e-01f, -1.45078570e-01f, 4.67423536e-02f, -5.98289408e-02f,
  1.87528729e-01f, 1.61649376e-01f, 1.05751514e-01f, 1.66298851e-01f, -1.60839632e-01f, -9.98550355e-02f, -6.10630512e-02f, 6.51188046e-02f, 4.45697568e-02f, 1.01115257e-02f,
  -5.47391102e-02f, 8.90879426e-03f, -6.38876334e-02f, 2.10773814e-02f, -9.41825390e-04f, 3.43991369e-02f, 1.02963582e-01f, -6.96367323e-02f, -1.86911866e-01f, -1.60520479e-01f,
  3.91918756e-02f, 6.73647225e-02f, -7.16975182e-02f, -9.17143300e-02f, 2.57304072e-01f, 3.96470018e-02f, 6.70774421e-03f, -1.36463359e-01f, 1.21339019e-02f, 6.49242550e-02f,
  -2.05814205e-02f, 1.11699440e-01f, -7.16198832e-02f, -1.67149398e-02f, 4.22610529e-02f, 1.72112808e-01f, -1.31058339e-02f, 2.47304663e-02f, -1.05780534e-01f, -8.25509131e-02f,
  3.53558958e-02f, -7.67929852e-02f, -9.26747322e-02f, 8.69806036e-02f, 1.22689761e-01f, 4.86741811e-02f, 9.21359584e-02f, -3.41635793e-02f, -1.14530496e-01f, -1.41215250e-01f,
  -2.95691080e-02f, -1.08560078e-01f, -1.62024736e-01f, 7.52502605e-02f
};

// L2_fan_Wp_bar (Shape: 52 x 64)
const int L2_fan_Wp_bar_rows = 52;
const int L2_fan_Wp_bar_cols = 64;
const float L2_fan_Wp_bar_data[] = {
  1.76931515e-01f, 1.59868091e-01f, 2.49275535e-01f, 4.15662900e-02f, 7.06344470e-02f, 1.45985454e-01f, -1.17766239e-01f, -6.27600849e-02f, 2.21160352e-01f, 1.33921489e-01f,
  -1.29209816e-01f, 1.60494745e-01f, -3.84836867e-02f, 1.27620772e-02f, -4.19019982e-02f, 8.79422352e-02f, -3.83356750e-01f, 1.76652208e-01f, -1.05426133e-01f, 3.01738948e-01f,
  1.62312046e-01f, -1.86495885e-01f, -2.98390221e-02f, 1.64885238e-01f, 2.66558051e-01f, 5.90772629e-02f, 1.33180723e-01f, 1.95888877e-01f, 5.21200411e-02f, 2.07544237e-01f,
  1.01670161e-01f, -2.67146140e-01f, 6.70387894e-02f, -7.55133033e-02f, -1.08186305e-01f, -1.20533094e-01f, 6.23378977e-02f, 1.46193534e-01f, 3.85027044e-02f, 1.75024137e-01f,
  -2.48883545e-01f, 1.02938628e-02f, -2.32911706e-01f, -1.57409728e-01f, -1.83817059e-01f, -1.55870855e-01f, 3.04108053e-01f, -1.32774413e-01f, -2.10420284e-02f, -1.23868652e-01f,
  1.27334911e-02f, -9.35555622e-02f, 7.44371116e-02f, 9.05133784e-02f, 3.32287222e-01f, -1.90397650e-01f, 1.85421184e-02f, 7.37474719e-03f, 6.89718276e-02f, 3.56075615e-02f,
  1.75402850e-01f, -1.20177284e-01f, 1.88922003e-01f, -2.49726325e-02f, -4.91163246e-02f, 8.51250347e-03f, 8.77052471e-02f, 1.00897796e-01f, 1.96807280e-01f, 1.26234442e-01f,
  1.95481271e-01f, -7.89678842e-02f, 1.17685363e-01f, -2.20865011e-01f, -5.19166179e-02f, -3.54792416e-01f, 1.30874455e-01f, 7.45452940e-02f, 2.47328073e-01f, -1.18448958e-01f,
  3.51576447e-01f, 1.68167744e-02f, -1.35707287e-02f, 2.76532280e-03f, 4.56997864e-02f, 1.98290393e-01f, -2.33211130e-01f, 2.44991153e-01f, -8.56414810e-03f, 1.93470150e-01f,
  4.16634567e-02f, -5.48844971e-02f, 7.53649026e-02f, -7.43762637e-03f, -8.63819420e-02f, 1.63173929e-01f, 2.67088711e-01f, 1.46698862e-01f, 2.09742248e-01f, 7.51226768e-02f,
  1.18458211e-01f, -7.61864707e-02f, -4.45116730e-03f, 1.63912326e-01f, 2.61960417e-01f, 1.19764619e-01f, 1.62806958e-01f, 2.47334301e-01f, 2.24822819e-01f, 4.89343368e-02f,
  2.55829424e-01f, 2.90315628e-01f, -1.44973472e-02f, 2.30619460e-01f, 3.51709202e-02f, 3.48398387e-02f, 6.24263547e-02f, -1.50078535e-01f, -1.19486101e-01f, -7.90703297e-02f,
  -1.06197365e-01f, -2.42062256e-01f, -1.09391034e-01f, 3.03881783e-02f, -1.62635818e-01f, -1.16539663e-02f, 6.83040097e-02f, 2.07335874e-01f, -9.91875082e-02f, -5.86986281e-02f,
  -8.90761763e-02f, 5.02626039e-02f, 7.57348835e-02f, -7.89875761e-02f, 5.52840643e-02f, -2.34883174e-01f, -1.71347171e-01f, -1.42073825e-01f, 1.03735171e-01f, 6.81343973e-02f,
  -1.30774990e-01f, 9.58987698e-02f, -9.05703977e-02f, 1.51704326e-01f, 9.32278410e-02f, 1.36923552e-01f, 1.58995256e-01f, 2.08047912e-01f, 1.18792810e-01f, -4.98530380e-02f,
  3.59002734e-04f, 5.02920225e-02f, -2.56815203e-03f, 1.05889268e-01f, 2.27003515e-01f, 8.67512897e-02f, 1.66190863e-01f, -7.47877806e-02f, 2.86404997e-01f, 1.33454934e-01f,
  -2.16809079e-01f, -1.97446674e-01f, -9.77043286e-02f, 2.69798070e-01f, 1.58534631e-01f, -1.42363682e-02f, 1.45015806e-01f, -1.92158833e-01f, 1.25313297e-01f, -7.91866183e-02f,
  1.32928148e-01f, -6.37184680e-02f, 9.09229442e-02f, 2.11748391e-01f, -1.39392495e-01f, 1.34251028e-01f, -2.01835539e-02f, 1.25483826e-01f, -2.14223731e-02f, 3.79517600e-02f,
  -1.84520230e-01f, 2.41064027e-01f, -4.01992761e-02f, 2.25864738e-01f, 6.57953918e-02f, -4.54893634e-02f, 1.59667104e-01f, 1.38015881e-01f, 4.61437441e-02f, 1.13579474e-01f,
  1.33289710e-01f, -1.32561222e-01f, -5.62462360e-02f, -1.38640285e-01f, -3.64243202e-02f, -1.51368573e-01f, -4.04361775e-03f, -1.10350579e-01f, -5.42928651e-02f, -3.26353520e-01f,
  -1.69969469e-01f, 2.83510089e-02f, 2.03574285e-01f, 7.87460729e-02f, -6.39036968e-02f, 2.56983582e-02f, -3.55675220e-02f, 2.39649490e-01f, 1.28432915e-01f, 1.95057198e-01f,
  -6.37488486e-03f, 2.07969263e-01f, 2.33860105e-01f, 4.13215440e-03f, 2.11302325e-01f, 8.82289559e-03f, 6.87094107e-02f, 7.66552314e-02f, 1.80541039e-01f, -1.30292715e-03f,
  1.92217082e-01f, 1.42395183e-01f, 1.47305012e-01f, 1.64431296e-02f, -2.99005881e-02f, -1.94433957e-01f, -2.15457276e-01f, 2.60400772e-01f, 1.40062392e-01f, 1.48679748e-01f,
  4.55325395e-02f, -4.97337878e-02f, 9.22174156e-02f, -1.35754377e-01f, 5.61894029e-02f, -1.00289851e-01f, 7.24723190e-02f, 2.00141922e-01f, 1.49821513e-03f, -3.22059840e-02f,
  1.12511270e-01f, 1.32736385e-01f, 3.82542424e-02f, -1.19310534e-02f, -3.44481245e-02f, 2.69127429e-01f, -4.03649323e-02f, 1.38589889e-01f, -5.41709214e-02f, -8.88978131e-03f,
  8.70022178e-02f, 8.90047848e-02f, 5.98562472e-02f, 2.24686638e-01f, 1.47575527e-01f, -1.93985283e-01f, 1.41474932e-01f, 8.73803198e-02f, -6.27721250e-02f, 1.87104940e-01f,
  6.31818399e-02f, 1.09509997e-01f, 5.87237962e-02f, 3.05017143e-01f, 3.62870768e-02f, 3.78389023e-02f, -1.45979032e-01f, -7.36229494e-02f, 5.57911359e-02f, 2.68965453e-01f,
  8.82719364e-03f, -3.91852222e-02f, 1.53793767e-01f, 1.26244962e-01f, -1.82969384e-02f, -1.44507974e-01f, -1.11239821e-01f, 1.85420647e-01f, -1.35685638e-01f, 5.34774847e-02f,
  9.53138471e-02f, -9.26443487e-02f, -1.43996701e-01f, -6.47670105e-02f, 1.25681430e-01f, 1.26530305e-01f, 1.89572498e-01f, 1.53274462e-01f, -3.22376490e-02f, 1.97457418e-01f,
  1.64091304e-01f, -1.52418748e-01f, -1.30841881e-01f, -3.46844792e-02f, 2.58065045e-01f, 2.78533340e-01f, 1.91581026e-01f, 5.18269390e-02f, -1.26161054e-01f, 1.93620920e-01f,
  1.40467942e-01f, 2.48364046e-01f, 2.70831257e-01f, 4.91133146e-02f, -1.55011520e-01f, 1.79066509e-01f, 5.78223728e-02f, 9.94460806e-02f, 1.61098167e-01f, 1.54983830e-02f,
  9.14615542e-02f, -1.29576385e-01f, 6.11484684e-02f, 1.94099516e-01f, -2.60763645e-01f, 6.95443079e-02f, 8.02069753e-02f, -6.19920343e-02f, -6.91776571e-04f, 8.14201236e-02f,
  9.23629757e-03f, 2.11825714e-01f, -1.10924048e-02f, 1.52595595e-01f, 1.08881213e-01f, 1.28815919e-01f, 3.38429958e-01f, -1.86728716e-01f, 1.69032335e-01f, -3.00162658e-02f,
  -3.59322876e-01f, -2.47995242e-01f, 3.38024274e-02f, -5.51183559e-02f, -4.50224876e-02f, 2.36142114e-01f, 1.19706750e-01f, 2.33646519e-02f, -3.17033410e-01f, 5.62923681e-03f,
  4.54988144e-02f, -8.39745626e-02f, 1.65057510e-01f, 1.69389084e-01f, 7.07990229e-02f, 7.33576864e-02f, -4.59408434e-03f, 2.55727172e-01f, 2.69474596e-01f, 1.96885377e-01f,
  -1.76800907e-01f, -1.48898214e-01f, 2.66105413e-01f, 1.77390888e-01f, -5.08080721e-02f, -6.40916526e-02f, -1.46488128e-02f, 1.95926070e-01f, 9.46547836e-02f, -1.52892217e-01f,
  -9.54870600e-03f, -3.22528541e-01f, -2.37336885e-02f, -2.77977046e-02f, -1.78771496e-01f, -2.17427298e-01f, 2.66700864e-01f, 1.94891974e-01f, 1.07413448e-01f, 8.19944814e-02f,
  9.64513719e-02f, 9.77469143e-04f, 1.83445945e-01f, -2.10516006e-01f, -5.58479019e-02f, -1.67025208e-01f, -2.19788015e-01f, 1.87486932e-02f, 4.44670062e-04f, -6.51685819e-02f,
  7.15685934e-02f, 2.67653614e-02f, 5.40685020e-02f, -1.31790387e-02f, 1.76012143e-01f, 1.87748417e-01f, 1.75223157e-01f, -5.59014687e-03f, 2.03688473e-01f, 8.49304721e-02f,
  1.38009995e-01f, -1.98236078e-01f, -5.76250255e-02f, -2.36341760e-01f, 3.56027670e-02f, -8.89655501e-02f, 1.17689900e-01f, 1.78388432e-02f, 1.54168203e-01f, 8.83487538e-02f,
  -2.47422792e-02f, -6.68515563e-02f, 2.45028704e-01f, 2.68088400e-01f, 1.27056658e-01f, -7.35058710e-02f, -1.90240994e-01f, 1.49188891e-01f, -5.19047119e-02f, 1.56281814e-01f,
  2.40426451e-01f, 8.94305408e-02f, -8.95851254e-02f, -2.21209809e-01f, 1.98735967e-02f, -5.46442941e-02f, 1.19157359e-01f, -1.82201058e-01f, 9.98166949e-02f, 5.05279042e-02f,
  1.68133587e-01f, -4.81470302e-02f, 2.73896735e-02f, -3.91575359e-02f, -1.93440795e-01f, 1.46193281e-01f, 5.20359650e-02f, -1.80734843e-01f, 2.67070353e-01f, 1.66745652e-02f,
  -1.94353789e-01f, -3.21021490e-02f, 7.43044689e-02f, -1.50979146e-01f, 2.62283608e-02f, -1.41060516e-01f, -7.93484971e-02f, 2.76051700e-01f, -1.22552797e-01f, 2.46144384e-01f,
  2.50859439e-01f, -1.45199355e-02f, 1.19916812e-01f, 1.48694232e-01f, 2.17412844e-01f, 1.05646569e-02f, 1.94130778e-01f, -7.62514472e-02f, -1.25037417e-01f, -2.00562611e-01f,
  5.64037599e-02f, -1.81218550e-01f, -1.11321948e-01f, 3.90209146e-02f, -1.51377050e-02f, -2.76458770e-01f, -2.44088277e-01f, -9.54153612e-02f, 1.44460723e-01f, -5.74755743e-02f,
  -2.61757702e-01f, 4.48529236e-02f, 1.18863530e-01f, 7.33699203e-02f, -2.69262050e-03f, 1.38540968e-01f, -4.11663018e-02f, 1.61835849e-01f, 2.07504958e-01f, 8.45597908e-02f,
  2.00394541e-01f, 1.16667412e-01f, 3.16818580e-02f, 1.12120278e-01f, 8.06681886e-02f, 1.27006948e-01f, 2.41560012e-01f, -1.40887678e-01f, 8.45704153e-02f, -1.13410026e-01f,
  -1.72065765e-01f, -1.83161244e-01f, -1.64557263e-01f, 2.74542660e-01f, 2.01448500e-01f, 1.72330171e-01f, -6.09899946e-02f, -1.99974030e-01f, -5.99405207e-02f, 8.47209769e-04f,
  1.44548342e-01f, 2.09712148e-01f, 1.12685017e-01f, -1.13189876e-01f, -1.98153108e-01f, 7.09682852e-02f, 1.02925673e-01f, -1.15160741e-01f, 4.34764996e-02f, 1.86728239e-01f,
  8.75842869e-02f, 6.22072108e-02f, 2.74008550e-02f, 7.78188258e-02f, 3.79957817e-02f, 2.01857165e-01f, 2.77622253e-01f, 2.29601651e-01f, 2.05219723e-02f, 1.71157092e-01f,
  6.14805929e-02f, -1.69002950e-01f, 1.12618618e-01f, 7.01051056e-02f, 1.11902140e-01f, 7.74526596e-02f, 7.09243491e-02f, 4.12560664e-02f, -2.14878023e-01f, 9.66419466e-03f,
  7.70263225e-02f, 3.12523842e-01f, 1.05314769e-01f, 4.59003672e-02f, -1.83566481e-01f, 8.39701369e-02f, -1.77266449e-01f, 1.22751296e-01f, -1.64718509e-01f, 2.58504927e-01f,
  -6.57735243e-02f, 1.86080188e-01f, 4.56377119e-02f, -1.33332063e-03f, -2.64203525e-04f, -8.04461986e-02f, 1.09981060e-01f, -1.51728973e-01f, 1.38950855e-01f, 1.79640159e-01f,
  1.61922306e-01f, 7.33508617e-02f, 1.17488399e-01f, -2.80437022e-02f, -5.57214469e-02f, -5.74889258e-02f, 5.54830506e-02f, -2.17113093e-01f, -8.52068886e-03f, 1.50732696e-01f,
  -6.36428595e-02f, 1.97605655e-01f, -3.56937535e-02f, -1.88515559e-02f, -2.23416224e-01f, -1.17676822e-03f, -1.81568727e-01f, 1.77889373e-02f, 1.26414329e-01f, -2.86685944e-01f,
  -1.74518198e-01f, 6.73913062e-02f, 1.23854969e-02f, 1.20929264e-01f, 2.20965862e-01f, 2.55939275e-01f, 2.50189211e-02f, -1.18755922e-01f, -1.70904681e-01f, 2.78135180e-01f,
  2.07954235e-02f, -8.35501626e-02f, 1.36689529e-01f, 6.11212384e-03f, 1.33501232e-01f, -1.31389990e-01f, -2.98506729e-02f, -3.90566862e-03f, 1.72625333e-02f, 5.23519777e-02f,
  -2.34625079e-02f, 8.53820443e-02f, -3.91472206e-02f, -1.76234692e-01f, -2.25965455e-01f, 5.17004216e-03f, 1.66158065e-01f, 2.22272098e-01f, -1.24239407e-01f, -8.57153013e-02f,
  1.56463325e-01f, 1.96193859e-01f, 1.92180846e-03f, 6.28198609e-02f, 1.66499302e-01f, 2.20297053e-01f, 1.93218872e-01f, 7.03950226e-02f, 1.85723171e-01f, -3.42215016e-03f,
  -1.18879348e-01f, 2.04929143e-01f, 6.22245967e-02f, 1.26926741e-02f, 1.95547771e-02f, -9.88889188e-02f, 2.05832079e-01f, -1.18911937e-02f, -3.53387697e-03f, -1.88241944e-01f,
  -1.04618929e-01f, 2.05664977e-01f, 1.33082941e-01f, -9.45368782e-03f, 7.30554760e-02f, -2.15855256e-01f, -4.14076895e-02f, -7.74471983e-02f, 5.42669818e-02f, 5.90815023e-02f,
  -2.25184076e-02f, 1.40723556e-01f, -1.00056417e-01f, 1.54642373e-01f, -5.70319854e-02f, 1.03743359e-01f, -1.00937486e-02f, -2.18035176e-01f, -1.29967496e-01f, 2.30530351e-01f,
  -6.63819611e-02f, 2.18405172e-01f, 2.42615640e-02f, -9.91246402e-02f, 1.51783496e-01f, 2.10273281e-01f, -2.15148330e-02f, -4.57512634e-03f, 2.18753025e-01f, -9.35658216e-02f,
  1.77535698e-01f, 1.52074039e-01f, 1.09128505e-01f, -5.56478184e-03f, 1.42142856e-02f, 1.78692907e-01f, 8.57100934e-02f, -4.79055867e-02f, -2.15559632e-01f, -2.08279952e-01f,
  1.50473893e-01f, 2.14682315e-02f, 9.48752910e-02f, -3.42911929e-02f, 2.63363302e-01f, 1.23100676e-01f, -1.50556937e-01f, -5.04403636e-02f, 2.80656755e-01f, 2.09359512e-01f,
  8.68592262e-02f, 1.82940334e-01f, -1.12798542e-01f, -4.57780100e-02f, 2.64689960e-02f, 1.68269739e-01f, 2.27605283e-01f, -2.92712636e-02f, 1.14882231e-01f, -2.39925072e-01f,
  3.95493321e-02f, -1.05351768e-03f, -1.52959108e-01f, -6.91163167e-02f, 2.17392713e-01f, 2.11777866e-01f, 2.98889965e-01f, 1.24819251e-02f, -8.95725191e-02f, -2.71450788e-01f,
  6.38636723e-02f, -1.18416362e-02f, 2.02794239e-01f, -1.45785809e-01f, 2.10422561e-01f, 1.00062877e-01f, -1.79452762e-01f, 1.26787513e-01f, 1.72645599e-01f, -6.63044080e-02f,
  6.56331405e-02f, -3.94533128e-02f, -1.92734227e-01f, 1.04029253e-01f, -3.35339904e-02f, 3.28163385e-01f, 9.22445506e-02f, -1.61199141e-02f, 2.38924921e-01f, 3.16467643e-01f,
  1.24825217e-01f, 1.27252251e-01f, 1.74765810e-01f, -8.31930563e-02f, -2.76221354e-02f, 5.64847095e-03f, 8.68321508e-02f, 8.95656869e-02f, 7.81631991e-02f, 6.98105469e-02f,
  1.71803869e-02f, 4.32614684e-02f, 5.44009097e-02f, -1.75571978e-01f, 1.08122759e-01f, -2.05722041e-02f, 4.78696600e-02f, 2.83305556e-01f, -6.83981692e-03f, -9.67161916e-03f,
  3.11580569e-01f, -1.27042189e-01f, 1.77683353e-01f, -8.77666473e-02f, 7.21255764e-02f, 2.45045543e-01f, 9.38062519e-02f, 7.13939220e-02f, -1.83357641e-01f, -2.74923742e-02f,
  7.41395801e-02f, -1.12497702e-01f, -7.36690164e-02f, 6.14137612e-02f, 1.41216934e-01f, 2.23786891e-01f, 3.82212573e-04f, 1.79849669e-01f, 1.38897687e-01f, 1.75990954e-01f,
  3.41160223e-02f, -1.22352233e-02f, 2.53317654e-01f, 3.00920382e-02f, 7.95075372e-02f, 3.52417529e-02f, 1.28923282e-01f, 1.47120506e-01f, -1.79305242e-03f, 2.27668107e-01f,
  -1.55919334e-02f, 2.36492798e-01f, -3.95474434e-02f, 1.61762670e-01f, -1.44804493e-01f, 1.89247895e-02f, -3.78979966e-02f, -6.57170685e-03f, -2.15602323e-01f, 1.44448161e-01f,
  -2.22752273e-01f, -7.57644624e-02f, -1.09789394e-01f, -1.10674620e-01f, -1.81777716e-01f, 1.12061262e-01f, -1.29387259e-01f, 9.58609283e-02f, -3.93251926e-02f, -1.11203372e-01f,
  1.07033746e-02f, 6.78110421e-02f, 5.67154866e-03f, -2.55961418e-02f, 4.88331914e-02f, -2.44964838e-01f, 1.42867095e-03f, 2.46286154e-01f, -3.58627178e-02f, 1.19383528e-03f,
  -1.46190599e-01f, -1.20718062e-01f, -1.42654419e-01f, 1.83443710e-01f, -2.63871640e-01f, 1.69015732e-02f, -1.49313956e-01f, 2.59445816e-01f, 1.51400715e-01f, -1.83688611e-01f,
  1.20174631e-01f, 6.48647025e-02f, 2.29678676e-03f, 5.17910421e-02f, 1.08683124e-01f, 1.63742393e-01f, 2.25749221e-02f, 2.06790477e-01f, 1.81720272e-01f, -1.34901434e-01f,
  1.73362151e-01f, -6.30779490e-02f, -2.84812659e-01f, 1.00876890e-01f, 8.39558244e-02f, 2.18630895e-01f, -7.70006552e-02f, -2.61982996e-02f, -3.41070682e-01f, -2.52623320e-01f,
  -1.59301877e-01f, -5.94436377e-02f, -1.45732448e-01f, -1.23879500e-01f, 1.56475142e-01f, -1.22285774e-02f, -1.87694710e-02f, -3.63878831e-02f, -7.23737106e-02f, 1.91797540e-02f,
  7.13977739e-02f, 1.80903494e-01f, 1.11674182e-01f, -5.31210639e-02f, 1.33979283e-02f, 1.47689238e-01f, 5.10617867e-02f, -6.07727654e-02f, 2.11858869e-01f, -1.63467035e-01f,
  2.04686061e-01f, -1.16533816e-01f, -1.83211312e-01f, 2.72812750e-02f, 6.25322089e-02f, -1.31431501e-04f, 1.28319919e-01f, 1.84816867e-03f, 1.40742078e-01f, 2.26512492e-01f,
  1.62845761e-01f, -9.01019499e-02f, -2.05077678e-01f, -2.17553571e-01f, 7.91349187e-02f, -1.68126598e-01f, 1.14420287e-01f, -2.22450309e-02f, 1.18911535e-01f, 1.03855401e-01f,
  -3.95775959e-03f, -2.11370125e-01f, 1.83267757e-01f, 3.57706994e-02f, 1.33986771e-01f, 2.27992967e-01f, 2.28144482e-01f, -1.20231368e-01f, -1.52830809e-01f, 2.04170957e-01f,
  6.38871938e-02f, 1.79986328e-01f, -2.28803173e-01f, -8.43046457e-02f, 2.33565688e-01f, 7.76965916e-02f, 9.22985673e-02f, -1.17747607e-02f, -2.79912092e-02f, 1.16031440e-02f,
  4.88074608e-02f, 2.43011359e-02f, 2.29382552e-02f, 8.58958513e-02f, -6.88546672e-02f, 2.75276214e-01f, -5.24769118e-03f, -6.08648844e-02f, 2.49003381e-01f, 1.38818920e-01f,
  1.70785606e-01f, 4.99838628e-02f, 1.17398255e-01f, 2.38422126e-01f, 2.37517014e-01f, -2.22022459e-01f, 1.53398350e-01f, -4.59729172e-02f, 8.65695700e-02f, 1.84855178e-01f,
  -8.66449773e-02f, -8.98983702e-02f, 1.03991829e-01f, 8.19161534e-02f, -1.04475975e-01f, -1.24628082e-01f, 4.33309115e-02f, -6.45928383e-02f, 1.55343758e-02f, 6.47693649e-02f,
  -6.04793578e-02f, 9.80277061e-02f, 1.56625838e-03f, -2.55294681e-01f, -2.63916910e-01f, -2.98725590e-02f, 3.53195295e-02f, 1.85169995e-01f, 2.95221135e-02f, 2.57504731e-02f,
  6.70533348e-03f, 2.30859399e-01f, -6.69085160e-02f, 1.98566347e-01f, 1.67234659e-01f, 1.30801097e-01f, 1.98109463e-01f, 5.01309596e-02f, 2.54105806e-01f, 2.54519507e-02f,
  -3.69971991e-02f, 1.07792780e-01f, 2.40604222e-01f, -1.47128507e-01f, -3.10159493e-02f, -8.76537189e-02f, 1.06627673e-01f, 1.92348540e-01f, -8.90407786e-02f, -1.68068632e-01f,
  -1.72190532e-01f, 1.04181729e-01f, 1.37949944e-01f, 4.79622232e-03f, 7.87615553e-02f, -1.39984742e-01f, 8.47015232e-02f, -2.19310567e-01f, 7.03583658e-02f, -6.22253492e-02f,
  1.51192561e-01f, 6.30066395e-02f, -2.29852468e-01f, 1.63240716e-01f, 1.09820038e-01f, 3.81095000e-02f, -1.25120461e-01f, -3.10458103e-03f, -1.46198645e-01f, 1.69231966e-01f,
  1.50417732e-02f, 1.69613913e-01f, -4.29143868e-02f, -2.36935187e-02f, 2.74047375e-01f, 9.41333249e-02f, 2.52143703e-02f, 2.61919975e-01f, 1.33184224e-01f, 1.43443868e-01f,
  1.49457008e-01f, 2.44130306e-02f, 2.33106669e-02f, 4.73444452e-05f, -1.03204615e-01f, 4.34581526e-02f, -7.04492331e-02f, 3.69954184e-02f, 3.77595872e-02f, -4.42390032e-02f,
  8.31257552e-02f, 8.52210894e-02f, -4.49368320e-02f, 3.25455397e-01f, -1.12830684e-01f, -8.56559426e-02f, 5.77239804e-02f, -5.13268374e-02f, 1.76094964e-01f, -3.66119184e-02f,
  -2.96020303e-02f, 2.32620224e-01f, 6.50779456e-02f, -1.21382765e-01f, -1.26100212e-01f, 2.04128340e-01f, -5.50771952e-02f, -6.94405437e-02f, 2.18468681e-02f, -1.62388772e-01f,
  2.73673296e-01f, 1.79174587e-01f, -6.77113011e-02f, 3.10427994e-02f, 1.80083960e-02f, 1.02059424e-01f, -1.45137206e-01f, -1.66194350e-01f, 4.84946109e-02f, -1.16915718e-01f,
  4.02682200e-02f, -1.02984414e-01f, 1.92476660e-01f, 5.23898490e-02f, 2.06512257e-01f, 3.37427557e-01f, -1.21045664e-01f, 2.02545196e-01f, -2.67364830e-01f, 9.18348879e-02f,
  -1.62342787e-01f, -6.36284947e-02f, -1.71872243e-01f, 1.10576481e-01f, 5.31306714e-02f, 1.38371095e-01f, -1.56817883e-01f, 5.00895195e-02f, -8.69197771e-02f, 7.59825110e-02f,
  -1.63078517e-01f, -4.88336794e-02f, -9.12240222e-02f, 2.10984498e-01f, 5.08248918e-02f, -9.15357322e-02f, -1.04421087e-01f, -7.88405240e-02f, 4.06671390e-02f, 7.41812810e-02f,
  1.29898965e-01f, -1.05356976e-01f, 1.78001255e-01f, -1.99483797e-01f, 1.11313723e-01f, -9.01330858e-02f, 2.16332451e-01f, -4.49749790e-02f, 5.84737547e-02f, -3.04240524e-03f,
  1.03894643e-01f, 4.99383323e-02f, 2.87896663e-01f, 1.21682644e-01f, 4.10616584e-02f, 2.40396950e-02f, -2.20348030e-01f, 7.62931332e-02f, -5.42385615e-02f, 1.13061734e-01f,
  9.76862237e-02f, 2.19845753e-02f, 1.95252690e-02f, -1.90139085e-01f, -6.35892153e-02f, 1.68176908e-02f, -1.61633343e-01f, -1.33827627e-01f, 3.18139851e-01f, -1.14332817e-01f,
  2.02237770e-01f, -8.34965184e-02f, -4.62930501e-02f, 3.14217294e-03f, 3.55134979e-02f, 1.34834349e-01f, -7.07113892e-02f, -1.41920179e-01f, 1.77734092e-01f, 2.51151458e-03f,
  -1.15420602e-01f, -1.13055833e-01f, 2.59594977e-01f, -9.92313307e-03f, 1.14701122e-01f, 8.19148794e-02f, -4.08694819e-02f, -9.11716186e-03f, -1.10608414e-01f, 1.07107416e-01f,
  3.13900948e-01f, -9.69000310e-02f, 7.32412329e-03f, -1.45859923e-02f, 1.18890479e-02f, -5.77595495e-02f, 1.57004118e-01f, 2.70182062e-02f, 1.28845841e-01f, 7.03879297e-02f,
  4.56437841e-02f, 2.31060237e-01f, 1.81383416e-01f, 1.90292805e-01f, -1.03254784e-02f, -1.86484620e-01f, 1.54457301e-01f, 2.93399580e-02f, -2.00483054e-01f, -1.23752378e-01f,
  -9.62971523e-02f, -1.18822984e-01f, -1.78566411e-01f, 1.50844499e-01f, -2.47582003e-01f, 1.52108103e-01f, 8.13251436e-02f, 2.77616769e-01f, -3.74367507e-03f, -2.78910190e-01f,
  -1.03703476e-01f, 1.83248237e-01f, 2.61511028e-01f, -1.69506952e-01f, 2.33851314e-01f, 2.27785215e-01f, 1.55968308e-01f, 2.09349975e-01f, 2.56856263e-01f, -2.08665416e-01f,
  -7.65100261e-03f, 2.20985338e-02f, -1.21912993e-02f, -1.63715973e-01f, 1.15624063e-01f, 2.31992617e-01f, -1.62354916e-01f, 9.09225941e-02f, -2.48305485e-01f, -5.25692701e-02f,
  -1.93725958e-01f, -2.23508433e-01f, -2.01385036e-01f, -1.43603176e-01f, 9.95225981e-02f, -2.03875646e-01f, 2.27537677e-01f, -1.14471890e-01f, 2.30060294e-01f, -3.63409333e-02f,
  7.44526312e-02f, 1.07451715e-01f, 9.63985696e-02f, -2.09825486e-01f, -1.59285124e-02f, 1.39382839e-01f, 1.08152747e-01f, 5.22793569e-02f, 2.51801163e-01f, -1.29924253e-01f,
  1.42201960e-01f, -1.80234477e-01f, -3.21096927e-02f, 8.79445672e-02f, 9.89740863e-02f, 1.61384881e-01f, 5.75818866e-02f, -1.15368456e-01f, 1.13429949e-01f, -4.13109586e-02f,
  -8.04826245e-02f, -1.42550439e-01f, -6.65533263e-03f, -1.06160797e-01f, 1.96874440e-01f, 5.94596900e-02f, 6.04097247e-02f, -6.26978725e-02f, 1.75693452e-01f, -1.01136006e-01f,
  -4.67294035e-03f, -4.90188226e-02f, 1.37037054e-01f, 1.63203284e-01f, -1.13905005e-01f, 1.51815072e-01f, -1.42601222e-01f, 1.12889051e-01f, 9.15753692e-02f, 1.31909177e-01f,
  -5.52167892e-02f, -2.65721455e-02f, -3.01920809e-02f, 1.07769966e-01f, 2.71137983e-01f, 1.10533208e-01f, 1.16374241e-02f, 6.38071746e-02f, -6.00499175e-02f, -1.55403674e-01f,
  4.02456522e-02f, 1.35540873e-01f, 9.21414942e-02f, 9.78177264e-02f, 3.09899837e-01f, 2.06377298e-01f, 1.58053096e-02f, 2.08375648e-01f, -4.44202358e-03f, 3.23969811e-01f,
  -4.56529930e-02f, 2.48171508e-01f, -9.37059671e-02f, 1.55968107e-02f, 5.69305103e-03f, -9.85596702e-02f, -5.67322262e-02f, 3.05657759e-02f, 5.36902770e-02f, -2.55375236e-01f,
  4.15666588e-02f, 7.65708461e-02f, -1.92982003e-01f, 9.28708091e-02f, -1.34691149e-01f, 2.78101146e-01f, -5.16582131e-02f, 1.97599128e-01f, 5.45398258e-02f, 1.65852606e-01f,
  1.73565641e-01f, 1.20204777e-01f, -9.93491383e-04f, 8.25919658e-02f, 2.31179267e-01f, -8.93300027e-02f, -1.11219339e-01f, -1.34995356e-01f, 6.31093234e-02f, 1.35431796e-01f,
  -3.66275050e-02f, 9.08010751e-02f, 1.14935398e-01f, 2.46884115e-02f, 8.43027160e-02f, -1.13701478e-01f, 1.89597577e-01f, -3.14421952e-02f, -1.77653581e-01f, 2.62635648e-01f,
  6.47663474e-02f, -1.09146461e-01f, 2.16468219e-02f, 6.91031069e-02f, 7.08194217e-03f, 9.19867754e-02f, 1.16725005e-02f, -2.27153990e-02f, 1.79545194e-01f, 1.82694718e-01f,
  1.99369177e-01f, -2.11165529e-02f, 2.34673042e-02f, -9.01792292e-03f, 3.59013379e-02f, 2.69729376e-01f, 5.20319231e-02f, 1.68086037e-01f, -8.21146592e-02f, 1.83840111e-01f,
  8.87923688e-02f, 1.45730987e-01f, 1.78884745e-01f, 2.49509178e-02f, 9.31903794e-02f, -4.11118157e-02f, 1.14672258e-01f, 8.36572498e-02f, 2.67320752e-01f, -3.07595003e-02f,
  1.05960518e-01f, -1.14955336e-01f, 1.90348506e-01f, -7.13140145e-02f, -2.37019323e-02f, 1.25533659e-02f, 1.69653371e-01f, -1.39577895e-01f, -1.11522466e-01f, -1.24519460e-01f,
  3.57919395e-01f, 2.23602161e-01f, 2.15593696e-01f, 1.52020469e-01f, 1.70325205e-01f, 1.75635338e-01f, -1.32746287e-02f, -9.26896110e-02f, -2.74277329e-01f, -1.64879829e-01f,
  1.33811370e-01f, 9.98789966e-02f, 6.94218129e-02f, -8.03404003e-02f, 2.19973668e-01f, 2.98565418e-01f, -1.71368957e-01f, 2.20423508e-02f, 4.22140621e-02f, 2.63602287e-01f,
  -7.07101077e-02f, 2.10133448e-01f, 1.37933940e-01f, -1.02644801e-01f, -1.51752830e-01f, 1.99073926e-01f, 2.07943991e-01f, -2.02957317e-01f, -1.16982013e-01f, 8.49091485e-02f,
  -7.23451972e-02f, -1.29416808e-01f, -8.00303463e-03f, -2.88984273e-02f, -8.06345344e-02f, 1.30160928e-01f, 7.28536025e-02f, -2.50417776e-02f, 4.92543802e-02f, -2.01021824e-02f,
  -1.28463402e-01f, -1.83994189e-01f, -9.22456011e-02f, -1.82668969e-01f, 2.06406340e-01f, 1.44989595e-01f, -1.65223211e-01f, 3.42331082e-02f, -1.91435665e-01f, 7.85525367e-02f,
  -4.69985157e-02f, -2.64349163e-01f, -1.46502376e-01f, 1.62720248e-01f, -3.70791443e-02f, 2.22263306e-01f, 3.31540965e-02f, -1.52030170e-01f, 2.20481947e-01f, 1.65360525e-01f,
  1.04705878e-01f, 1.50320560e-01f, 2.34082013e-01f, 1.92537636e-01f, 1.94045734e-02f, 4.05352972e-02f, 9.79068801e-02f, 1.83439493e-01f, 2.07851440e-01f, 8.78667086e-02f,
  1.19767010e-01f, -5.89760579e-02f, 8.89502764e-02f, 9.11585055e-03f, 4.09122333e-02f, -2.59396821e-01f, 8.41998607e-02f, -8.99421871e-02f, -1.03697605e-01f, 6.37987815e-03f,
  -2.13908143e-02f, 1.37650698e-01f, 2.50182301e-01f, 2.79871196e-01f, 1.94823116e-01f, -2.16480523e-01f, -2.77324885e-01f, 1.14342645e-01f, 2.60520894e-02f, -3.61830443e-02f,
  2.52119541e-01f, 1.93726018e-01f, 8.25865194e-03f, 2.66123749e-02f, 1.83419406e-01f, -5.21136560e-02f, 5.05248420e-02f, 2.15488449e-02f, 2.70829946e-01f, 6.80327043e-02f,
  9.39339176e-02f, 1.33667842e-01f, -2.21698523e-01f, -1.26807004e-01f, -1.88359097e-01f, 2.06938967e-01f, -1.11753188e-01f, -3.09624523e-01f, 2.38842797e-02f, -1.56098023e-01f,
  7.09206089e-02f, -7.49259442e-02f, 2.15550169e-01f, 1.27758859e-02f, 1.73582762e-01f, -6.63883835e-02f, -1.62675947e-01f, 2.21655861e-01f, 2.52196193e-02f, -1.43387094e-01f,
  5.50509430e-02f, -5.96160479e-02f, -7.22394278e-03f, 1.00369066e-01f, 2.34643221e-01f, -1.88027337e-01f, 2.05998793e-01f, -8.81630927e-02f, 1.11306332e-01f, 1.86068356e-01f,
  1.76069021e-01f, 2.62521595e-01f, 8.68448094e-02f, 1.77233264e-01f, 4.30371352e-02f, 1.95987031e-01f, 3.13264072e-01f, -1.21268898e-01f, -1.50793627e-01f, -4.18781899e-02f,
  1.74303725e-01f, 7.17316717e-02f, -6.63950443e-02f, -1.48706082e-02f, -8.97674933e-02f, -2.57212371e-02f, 1.82680175e-01f, 1.17811434e-01f, -1.98576096e-02f, 9.65252817e-02f,
  -7.53617436e-02f, 1.08208232e-01f, 1.21944323e-01f, -8.32461119e-02f, 1.52316302e-01f, 3.88117228e-03f, 1.19352870e-01f, 5.33705316e-02f, 1.33275896e-01f, 1.93356052e-02f,
  8.41627717e-02f, 2.25119844e-01f, 2.48687401e-01f, -1.32694051e-01f, 1.10800050e-01f, -1.86507717e-01f, -6.13114908e-02f, 1.47142187e-01f, 1.48048908e-01f, 3.03479224e-01f,
  -1.22252315e-01f, 8.35868120e-02f, 1.01859413e-01f, -1.74134895e-02f, 2.67974347e-01f, -2.85791699e-02f, 2.48299614e-01f, 1.99217036e-01f, 1.75605327e-01f, 1.95011154e-01f,
  1.39052927e-01f, -7.83975199e-02f, 2.74785995e-01f, -1.57173663e-01f, 1.88960254e-01f, -1.06037810e-01f, -1.47522777e-01f, -8.87877494e-02f, 2.49541566e-01f, -1.58058032e-01f,
  -1.64920688e-02f, 1.53245941e-01f, -1.01072453e-01f, -2.30930466e-02f, 1.43511951e-01f, 1.32471025e-01f, 1.17774054e-01f, 9.14911926e-02f, 5.92256784e-02f, 1.71917096e-01f,
  1.65339693e-01f, 1.45271882e-01f, -2.41156727e-01f, -1.06751285e-01f, 1.04584768e-01f, -1.20456234e-01f, 1.10056043e-01f, 2.63893366e-01f, 1.15712076e-01f, 1.24012433e-01f,
  -1.39520615e-01f, 2.07747146e-01f, -8.04918036e-02f, 2.09894136e-01f, 1.77941993e-02f, -9.90270376e-02f, 1.78372756e-01f, 9.50662270e-02f, -5.96437380e-02f, 5.70117198e-02f,
  1.24363475e-01f, 2.08590835e-01f, -1.40747428e-01f, -2.62136441e-02f, 2.19634399e-01f, 1.81412265e-01f, -2.11002484e-01f, 5.34888059e-02f, -2.53888369e-01f, 1.21065959e-01f,
  2.64854223e-01f, 6.85623586e-02f, 7.26037193e-03f, -2.00485602e-01f, 1.22333057e-01f, 3.35159302e-02f, -1.85115300e-02f, 5.46011887e-02f, 7.95282647e-02f, 1.85644045e-01f,
  -1.10513188e-01f, 2.17737667e-02f, -4.64856327e-02f, 3.91086899e-02f, 1.71336755e-01f, -4.99336496e-02f, 5.14009930e-02f, -8.02486241e-02f, -1.17588155e-01f, 1.50299177e-01f,
  -7.44459108e-02f, 4.17791791e-02f, 5.39757982e-02f, 8.37139338e-02f, 1.25315607e-01f, 1.96781918e-01f, 2.34246731e-01f, 4.13992815e-02f, -4.52658795e-02f, -5.16098626e-02f,
  9.71681103e-02f, -6.89422712e-02f, 1.88453838e-01f, -1.05199873e-01f, -1.40026122e-01f, -2.10219502e-01f, 1.45264313e-01f, 1.79012284e-01f, -9.53766480e-02f, 6.61663562e-02f,
  1.32361725e-01f, 9.66691077e-02f, 9.56339091e-02f, -2.65265200e-02f, 1.99754313e-01f, -5.24811596e-02f, -2.64005028e-02f, 1.26907632e-01f, 1.63729936e-01f, -1.37958020e-01f,
  -5.77704050e-02f, 1.61954910e-02f, 1.77371204e-01f, -1.40428990e-01f, 1.90156594e-01f, -5.04625104e-02f, 6.97442889e-02f, 7.37471655e-02f, -1.30431622e-01f, -1.01488337e-01f,
  1.89707652e-02f, 5.01142889e-02f, -4.90528978e-02f, 7.25567862e-02f, 1.72576755e-01f, -1.09595001e-01f, -4.18030843e-02f, -2.95282640e-02f, 1.67365015e-01f, 3.71433725e-03f,
  2.02620879e-01f, 1.16367735e-01f, -1.25067130e-01f, 1.45818397e-01f, -1.62673876e-01f, 1.97787628e-01f, -7.68482173e-03f, 4.83894944e-02f, -1.92849874e-01f, 2.19508663e-01f,
  -6.14988394e-02f, 2.72188276e-01f, 1.78688820e-02f, 3.39777619e-02f, 1.13035202e-01f, 7.39390850e-02f, 2.92928927e-02f, 2.45959431e-01f, 9.94011611e-02f, 7.48063996e-02f,
  -3.38387936e-02f, 1.04992650e-01f, 9.74663645e-02f, -1.00735530e-01f, 7.41233900e-02f, 7.14791194e-02f, -3.75047773e-01f, 2.28395864e-01f, 5.72451427e-05f, 1.06259771e-01f,
  -5.95661551e-02f, 1.57102972e-01f, -8.94263461e-02f, 2.12488547e-01f, 7.20965117e-02f, 5.54145016e-02f, 1.28277525e-01f, 2.34416217e-01f, 5.78289032e-02f, 1.17314514e-02f,
  1.20121725e-02f, 3.29641737e-02f, 7.89077431e-02f, -1.26626000e-01f, 2.20742598e-01f, -3.09760626e-02f, -1.70747340e-01f, -7.50727544e-04f, 1.01414733e-01f, 9.65062678e-02f,
  2.94196010e-01f, -3.59490588e-02f, -3.44760343e-02f, 2.29221910e-01f, -9.11068395e-02f, -1.02074794e-01f, -1.46652952e-01f, 1.62023008e-01f, 1.10706531e-01f, 1.82021335e-01f,
  2.31634647e-01f, 2.04597086e-01f, 1.11666493e-01f, 3.05121511e-01f, -1.33115292e-01f, 2.01980352e-01f, -3.76597904e-02f, 1.22296112e-02f, -1.45835117e-01f, 1.03223063e-01f,
  2.73676850e-02f, 1.30990341e-01f, 1.75428733e-01f, 5.35150338e-03f, 2.80071467e-01f, -1.07328400e-01f, -1.39342844e-01f, 2.42654845e-01f, -1.15972184e-01f, -1.49391443e-01f,
  1.64988935e-01f, 1.26348555e-01f, -1.48393422e-01f, -7.50363544e-02f, 2.48905480e-01f, 1.23011574e-01f, 1.74743965e-01f, 1.61571000e-02f, 1.96522444e-01f, 1.88798785e-01f,
  2.30619237e-01f, 6.79906532e-02f, -9.26061496e-02f, -2.48371258e-01f, -8.63426402e-02f, 4.76096310e-02f, 9.59609449e-02f, 2.77792841e-01f, 1.98933467e-01f, 7.56201074e-02f,
  7.17625394e-02f, -1.03784412e-01f, 2.34558284e-02f, -6.21019825e-02f, -6.62543625e-02f, 2.75270969e-01f, -3.95428166e-02f, -5.59998229e-02f, -1.38608977e-01f, 1.18397400e-01f,
  3.20013911e-02f, -1.04250692e-01f, -4.21236977e-02f, -7.13845640e-02f, 1.38149619e-01f, 1.03075415e-01f, 2.15096354e-01f, 1.19214758e-01f, -3.45843881e-02f, 5.03241131e-03f,
  8.69932920e-02f, -2.02787980e-01f, 2.47058615e-01f, 1.08069040e-01f, 1.51475981e-01f, 1.02015570e-01f, 1.37152210e-01f, 4.17140946e-02f, 8.28094259e-02f, 2.64135867e-01f,
  1.15787543e-01f, 1.14594333e-01f, -5.34257144e-02f, 2.78456300e-01f, 2.75898241e-02f, -3.39356996e-02f, -8.88886750e-02f, -2.41825916e-02f, -5.44828027e-02f, 2.24978626e-02f,
  9.09047723e-02f, -2.43755542e-02f, -3.53054553e-02f, 6.75149411e-02f, -1.91307291e-01f, 4.44316864e-02f, -3.61291654e-02f, 2.60848582e-01f, 1.42912313e-01f, 2.93698739e-02f,
  8.18940029e-02f, 1.50055096e-01f, 1.14262737e-01f, 1.20935887e-01f, -2.60617644e-01f, 9.25632045e-02f, 8.09416100e-02f, 1.49266809e-01f, 6.71640858e-02f, 1.61423206e-01f,
  -8.27837288e-02f, 2.41270036e-01f, -1.10252174e-02f, -4.49465998e-02f, -4.30337563e-02f, 2.06259266e-01f, 1.38074756e-01f, -1.42319173e-01f, 6.76292032e-02f, -1.16642423e-01f,
  1.38511434e-01f, -9.56401601e-02f, 4.53546122e-02f, -1.76741794e-01f, -8.53937715e-02f, 4.45193164e-02f, 9.86733213e-02f, 1.20371073e-01f, 3.36404324e-01f, 3.63375433e-02f,
  -2.90369391e-01f, 5.55957183e-02f, 1.12413526e-01f, -1.32574260e-01f, -2.04481021e-01f, 3.60997729e-02f, -2.85707340e-02f, 2.99493700e-01f, 2.25133300e-01f, 2.69019961e-01f,
  -1.74598888e-01f, 2.86342442e-01f, -3.43047008e-02f, 1.08223811e-01f, 5.84533177e-02f, -3.05987120e-01f, -1.25041381e-01f, 1.20555118e-01f, 7.46760592e-02f, 1.10914327e-01f,
  2.87653267e-01f, 1.05954066e-01f, 2.55687863e-01f, -7.51001388e-02f, -3.17815542e-02f, 6.73629418e-02f, -2.97434330e-01f, -2.64453322e-01f, -1.60889439e-02f, -1.79077148e-01f,
  -1.04638077e-01f, 1.58386052e-01f, -1.74167916e-01f, -1.71212748e-01f, -1.83469765e-02f, -1.62552327e-01f, 6.56807125e-02f, -6.82250112e-02f, 4.21780087e-02f, -1.20462202e-01f,
  -2.12129146e-01f, 1.21105956e-02f, 9.98633653e-02f, 1.79274216e-01f, -2.86249250e-01f, -3.70868444e-02f, 7.90848807e-02f, 1.26532987e-01f, -4.44308706e-02f, 1.24007285e-01f,
  5.13898991e-02f, 1.50656998e-01f, 2.16177240e-01f, -5.39769456e-02f, 2.15287998e-01f, -9.19534415e-02f, 7.74350425e-04f, 2.12662876e-01f, 1.00422073e-02f, 1.55757993e-01f,
  1.64838687e-01f, 1.84990559e-03f, 1.43951967e-01f, 1.85129434e-01f, -1.14282317e-01f, -3.24922413e-01f, -1.31591067e-01f, 1.74589798e-01f, 1.96934883e-02f, 2.26884466e-02f,
  1.63964912e-01f, -1.64322108e-01f, 7.69640319e-03f, 1.47281447e-02f, 1.35185674e-01f, 1.58453926e-01f, 1.25903770e-01f, 1.34113408e-03f, -1.43500835e-01f, -2.46806592e-02f,
  1.91184223e-01f, -2.27828510e-02f, -3.39252688e-02f, 1.92168668e-01f, 7.84045756e-02f, 4.28247079e-02f, 8.50801393e-02f, 2.03681946e-01f, 5.24316132e-02f, 3.39297175e-01f,
  1.81686491e-01f, 8.12718272e-02f, -1.24812359e-02f, 2.42789775e-01f, 8.90296176e-02f, -3.70525755e-02f, 1.32656377e-02f, 4.43790890e-02f, 7.18545094e-02f, -2.42008511e-02f,
  1.92245275e-01f, 1.04881011e-01f, 3.16016227e-01f, 6.76009506e-02f, -1.73376665e-01f, -1.19061619e-01f, -5.77154197e-02f, -1.34150967e-01f, 2.32594043e-01f, -8.94855857e-02f,
  2.72807628e-01f, -1.17753796e-01f, 4.49516252e-02f, -2.51974631e-02f, 1.20310105e-01f, -3.80631238e-02f, 6.51097577e-03f, 1.89907759e-01f, 1.80811081e-02f, 1.44988641e-01f,
  -4.25244756e-02f, 8.03164989e-02f, -6.08180054e-02f, 4.36869785e-02f, 2.38700639e-02f, -1.17436916e-01f, -2.56153733e-01f, 8.60006213e-02f, 2.83109516e-01f, -1.64771006e-01f,
  1.31993622e-01f, 6.85636373e-03f, 1.65043473e-01f, -1.59155622e-01f, -6.83749840e-02f, -4.38402854e-02f, 1.84781179e-01f, 8.01243782e-02f, 2.38821343e-01f, 2.09613562e-01f,
  2.69080967e-01f, 3.35195810e-02f, 2.51737721e-02f, 2.28602767e-01f, 8.11701566e-02f, 1.56897143e-01f, 8.61894488e-02f, 6.77371919e-02f, 4.11570407e-02f, 7.02413097e-02f,
  -2.54429936e-01f, 1.85878217e-01f, 1.09916411e-01f, -1.10557668e-01f, 1.73935935e-01f, 1.00504734e-01f, -6.32318407e-02f, 2.42318541e-01f, 5.19213229e-02f, 2.70127114e-02f,
  1.93373710e-01f, 1.03074692e-01f, 1.00881591e-01f, 1.19676597e-01f, 2.21533075e-01f, 6.50330782e-02f, 2.89098650e-01f, -5.56497946e-02f, 5.38403131e-02f, -7.53466189e-02f,
  -1.80264041e-01f, -2.93351617e-02f, 6.46973848e-02f, 1.00864042e-02f, 2.94688404e-01f, -9.94118891e-05f, 1.60150379e-01f, -2.83139795e-02f, 1.47613868e-01f, 5.12744114e-02f,
  -2.03652754e-02f, 2.78577358e-01f, -1.32161394e-01f, 5.72393299e-04f, 1.78722739e-02f, 8.99349302e-02f, -7.02350363e-02f, -1.02722079e-01f, 2.23880529e-01f, 2.11937144e-01f,
  2.39243377e-02f, -4.85724732e-02f, 2.01251969e-01f, 2.66163081e-01f, -1.72317401e-01f, 1.79110765e-01f, -8.94405842e-02f, -1.02171667e-01f, 8.14965814e-02f, 1.38110369e-01f,
  4.29820530e-02f, -1.93514019e-01f, -2.36901566e-02f, 9.73943323e-02f, 5.63302115e-02f, 2.95984652e-02f, 1.46953195e-01f, 2.69131988e-01f, -1.80873394e-01f, 1.94844916e-01f,
  5.21278102e-03f, -1.85093939e-01f, 2.18417011e-02f, -1.11018019e-02f, -2.71644983e-02f, 1.26387522e-01f, -1.60064638e-01f, -1.31008700e-01f, 1.45397604e-01f, -2.10599788e-02f,
  -7.95659274e-02f, 3.35011259e-02f, 1.30011097e-01f, 3.41407806e-01f, -5.40073104e-02f, -4.55326512e-02f, -1.13038430e-02f, -1.20333031e-01f, 2.07413677e-02f, -3.27385850e-02f,
  5.93889877e-02f, 4.75704707e-02f, 1.27755227e-02f, -1.39977008e-01f, -6.90330118e-02f, -3.17505240e-01f, 5.76182865e-02f, 5.25982864e-02f, 7.67266378e-02f, -1.65037006e-01f,
  8.59987643e-03f, -3.53860259e-02f, 2.50146121e-01f, -8.43789876e-02f, 1.38664976e-01f, -2.04321995e-01f, -6.57385364e-02f, 2.52775401e-01f, 6.64058477e-02f, -6.88605458e-02f,
  2.22398221e-01f, 2.16348805e-02f, -3.24640535e-02f, -4.12400626e-02f, 1.96954738e-02f, 1.15042426e-01f, -2.50608623e-02f, -1.46380618e-01f, 2.08947703e-01f, 1.19072488e-02f,
  3.09961587e-01f, -1.14804149e-01f, -3.20710838e-01f, -1.99046195e-01f, -1.23384282e-01f, 2.04912111e-01f, 2.23029524e-01f, 3.19858417e-02f, 1.55085728e-01f, -1.69042293e-02f,
  -1.44784406e-01f, -8.61273147e-03f, 3.08610827e-01f, -1.00571856e-01f, 2.65165329e-01f, 6.01092502e-02f, -3.85780968e-02f, -9.34619233e-02f, -4.99816425e-02f, -1.60668537e-01f,
  3.01534086e-01f, -6.64224103e-02f, 1.02666050e-01f, 6.62773028e-02f, 1.45971566e-01f, -2.01399043e-01f, 2.18555871e-02f, -2.02883080e-01f, 2.25218996e-01f, -1.27439767e-01f,
  -6.78186193e-02f, 1.55368485e-02f, 7.53710866e-02f, 5.11358418e-02f, -1.64774179e-01f, 8.22507590e-02f, 1.74125433e-01f, 3.85518931e-02f, -8.12949091e-02f, -3.27704735e-02f,
  -6.46292872e-04f, -1.59037724e-01f, -1.83840901e-01f, -8.36479198e-03f, -1.95046470e-01f, 1.30410209e-01f, 2.50045061e-01f, 1.80522501e-01f, 4.95240688e-02f, -4.65319157e-02f,
  -1.84234530e-01f, -3.70908082e-02f, 1.40413046e-01f, -3.41925286e-02f, 1.85571611e-01f, -6.32569566e-02f, -1.40955552e-01f, -4.59003225e-02f, 2.98959553e-01f, -2.16985658e-01f,
  -2.04918817e-01f, -1.07787982e-01f, 2.30633393e-01f, -6.44538924e-02f, 1.92529589e-01f, 1.05440438e-01f, -2.57133543e-01f, 9.37341601e-02f, -1.77955255e-01f, 1.95068046e-01f,
  -2.29002580e-01f, -3.70188683e-01f, 3.91065590e-02f, 1.14350356e-01f, -1.15133300e-01f, -2.57416576e-01f, 1.38228387e-02f, -1.88682124e-01f, 1.86215863e-01f, -2.38264427e-01f,
  -5.43214045e-02f, 1.76193714e-01f, 2.95123458e-01f, 3.08037698e-02f, 2.77586669e-01f, 1.10888399e-01f, 7.53046349e-02f, 1.80359021e-01f, 3.29434603e-01f, 9.79065336e-03f,
  1.45515174e-01f, -1.53157543e-02f, 8.36126581e-02f, 1.10263050e-01f, -2.98022386e-02f, 8.85935873e-02f, 1.71215102e-01f, 1.70477666e-02f, 5.54806814e-02f, -2.67319351e-01f,
  -1.45965621e-01f, -8.78635868e-02f, 7.08681047e-02f, -4.42284122e-02f, -1.38887331e-01f, 1.23755813e-01f, 1.26995608e-01f, 2.66685396e-01f, 8.06100443e-02f, 2.13308349e-01f,
  8.56326148e-02f, 1.37870431e-01f, 2.54645348e-01f, 2.18797356e-01f, 2.30650648e-01f, 8.41641948e-02f, -2.65112165e-02f, 1.04273312e-01f, 1.23256050e-01f, 4.46417928e-02f,
  2.99061269e-01f, -1.56842656e-02f, -6.40940852e-03f, 1.79267898e-01f, 1.13547012e-01f, -3.44281644e-02f, -1.93829924e-01f, 1.53679952e-01f, -4.69859019e-02f, 1.20766975e-01f,
  1.50615677e-01f, -4.16910164e-02f, 1.32520244e-01f, -1.96758151e-01f, 2.48715922e-01f, 1.62559777e-01f, 3.42249614e-03f, 1.27499297e-01f, 3.88734080e-02f, 2.20053464e-01f,
  -1.25033287e-02f, 1.98656619e-01f, -7.02652112e-02f, 7.60846436e-02f, -1.15310065e-01f, -2.67071126e-04f, -1.04982629e-01f, 1.52603194e-01f, 7.41098896e-02f, -1.21841975e-01f,
  2.12339699e-01f, 1.23711266e-01f, 1.13885902e-01f, 2.76478887e-01f, 1.78427279e-01f, 3.89029109e-03f, 1.30520329e-01f, 8.61388445e-02f, 1.51137516e-01f, 6.85212240e-02f,
  2.06971020e-01f, 1.27159610e-01f, 4.18838382e-01f, -2.76891083e-01f, 1.36897668e-01f, -3.13231081e-01f, -1.60603791e-01f, -2.52192110e-01f, 2.73088634e-01f, -3.68562192e-02f,
  3.39805633e-01f, 4.49874178e-02f, -4.25608121e-02f, -1.39019772e-01f, -1.83635240e-03f, 1.46108583e-01f, 1.66474611e-01f, 2.64879279e-02f, -1.63943663e-01f, 2.16333523e-01f,
  -1.82981882e-02f, 1.69200599e-01f, 2.75909211e-02f, 1.62083462e-01f, 1.92731678e-01f, 1.52075170e-02f, -2.36340210e-01f, -1.53412819e-02f, 3.47404599e-01f, 3.96781191e-02f,
  1.61428154e-01f, 1.30070180e-01f, 1.01150244e-01f, -2.19469711e-01f, -3.73678841e-02f, -2.29222793e-03f, -6.93738507e-03f, -7.81746209e-02f, 1.53659254e-01f, 3.92200686e-02f,
  2.68155485e-01f, -1.65591046e-01f, 1.60288647e-01f, 2.30335686e-02f, 2.61099041e-01f, -1.96447577e-02f, 2.58478403e-01f, -1.07797816e-01f, -6.08948879e-02f, 1.09975815e-01f,
  -2.10908487e-01f, 8.13141912e-02f, 5.30409478e-02f, -2.54701406e-01f, 1.46438191e-02f, 1.60012856e-01f, -2.07752641e-02f, 1.36486381e-01f, 9.04407427e-02f, -1.27854764e-01f,
  1.68408170e-01f, 1.93380237e-01f, 1.94444343e-01f, 4.53380309e-02f, 7.28699118e-02f, 4.06505875e-02f, -1.36973962e-01f, 3.89812551e-02f, -8.97038728e-03f, 3.58916819e-02f,
  -7.68202096e-02f, 1.77996174e-01f, 8.34731460e-02f, 2.55543500e-01f, 6.73984364e-02f, 3.79724763e-02f, 1.35883875e-03f, 2.01528728e-01f, 5.58376722e-02f, 1.26132995e-01f,
  -2.00968444e-01f, 4.61062975e-02f, -1.23661339e-01f, -6.86507225e-02f, -1.12021513e-01f, -8.11693445e-03f, 2.03439239e-02f, -8.24040398e-02f, 7.92068802e-03f, -3.74945533e-03f,
  3.79084587e-01f, 1.75019398e-01f, 1.06927395e-01f, 3.02872628e-01f, 3.09137590e-02f, 4.14706543e-02f, -1.01332709e-01f, -1.31444737e-01f, 2.37725377e-01f, 2.82394618e-01f,
  2.75659800e-01f, 1.59326613e-01f, -1.67006291e-02f, 1.46696016e-01f, 1.73348427e-01f, 3.17866087e-01f, 2.36857951e-01f, 8.25351663e-03f, -3.49364042e-01f, 2.91613579e-01f,
  8.07195157e-02f, -2.09544361e-01f, 1.89248592e-01f, 2.12545007e-01f, 9.73554254e-02f, -1.07921138e-01f, -2.74086028e-01f, -1.91090196e-01f, -2.34714031e-01f, -1.18166856e-01f,
  4.58481722e-02f, -4.32000728e-03f, -2.40626946e-01f, 3.51475626e-01f, -1.55405989e-02f, 5.65780997e-02f, 5.09823998e-03f, 6.70632906e-03f, 1.87545925e-01f, 1.90342188e-01f,
  -7.26339668e-02f, 1.53435081e-01f, 1.36159465e-01f, -1.08191613e-02f, -1.92240044e-01f, 4.43638340e-02f, 4.88308035e-02f, -1.27966046e-01f, 5.77461347e-02f, 5.21685518e-02f,
  -2.62732267e-01f, 1.90627307e-01f, 7.55317360e-02f, 1.96521148e-01f, 7.34230801e-02f, -8.15676525e-02f, -6.81820139e-02f, 1.70230940e-01f, 1.85429499e-01f, -1.78769335e-01f,
  4.35867533e-02f, 1.77836433e-01f, 6.68136850e-02f, 1.43099964e-01f, 2.33485103e-02f, -2.16615275e-01f, 8.99012536e-02f, 7.72383586e-02f, 2.28861988e-01f, -3.86750959e-02f,
  2.06833314e-02f, -1.02912590e-01f, -1.47167236e-01f, 1.39386326e-01f, -1.93980858e-01f, 2.34491780e-01f, -2.22368419e-01f, -2.32887380e-02f, -1.64986789e-01f, 5.41096665e-02f,
  8.70402008e-02f, -2.60012269e-01f, 6.09028265e-02f, -5.48263341e-02f, 1.26880854e-01f, 9.83996615e-02f, 1.54043734e-01f, 4.73632328e-02f, 1.91098794e-01f, -2.31516287e-01f,
  -1.06142601e-02f, 1.26861213e-02f, -1.76118478e-01f, -3.76841649e-02f, 6.10853657e-02f, -2.52737850e-01f, 1.16551235e-01f, -1.35586128e-01f, -1.77904159e-01f, -7.85600320e-02f,
  -1.55681923e-01f, -2.12505996e-01f, -1.77174136e-01f, -2.00951651e-01f, -4.93460074e-02f, 8.30586106e-02f, -4.02734093e-02f, -3.67875732e-02f, 1.00241087e-01f, 1.77938014e-01f,
  -3.21430415e-01f, 6.15090970e-03f, 1.72512121e-02f, 2.55900681e-01f, 2.75354415e-01f, 1.79102674e-01f, -4.22504507e-02f, 1.22210413e-01f, 4.52675223e-02f, 2.41679959e-02f,
  2.61338562e-01f, -5.53964637e-02f, 2.06978485e-01f, 1.10704461e-02f, -5.90522401e-02f, -3.52981612e-02f, 1.44428909e-01f, 2.01624677e-01f, -1.72434654e-02f, 1.11669108e-01f,
  -8.14321414e-02f, -4.13639098e-01f, 1.51660023e-02f, 7.22058117e-02f, -1.02378882e-01f, 1.72588900e-01f, 2.15050280e-01f, -2.53378659e-01f, 1.04526393e-01f, -4.89175878e-02f,
  9.53833982e-02f, 2.45491445e-01f, 1.42048553e-01f, 2.67035574e-01f, -7.66998604e-02f, -2.18889154e-02f, 2.57715881e-02f, 1.83603808e-01f, -1.18559748e-01f, 2.32852384e-01f,
  1.73991229e-02f, 1.93202123e-01f, 1.87692180e-01f, 8.49200189e-02f, -5.87836392e-02f, 3.87118191e-01f, 1.04042299e-01f, 2.12313622e-01f, -4.39719632e-02f, 4.03207801e-02f,
  -5.89356497e-02f, -2.36279979e-01f, 6.73828050e-02f, -1.18375883e-01f, -1.22857630e-01f, -1.37224048e-01f, -1.50096685e-01f, -1.28753558e-01f, -1.21316694e-01f, -2.30950173e-02f,
  -1.44505277e-01f, 7.89597034e-02f, 4.63986211e-03f, 2.07651377e-01f, -1.33579478e-01f, 1.89178899e-01f, 1.24005172e-02f, 1.34445369e-01f, 2.33112603e-01f, 2.01410845e-01f,
  4.08663005e-02f, 1.09676577e-01f, 1.23793326e-01f, -2.85373628e-02f, 3.57498229e-01f, -1.11992233e-01f, 1.02639124e-01f, 8.23791847e-02f, 4.62946370e-02f, -5.09868376e-02f,
  2.27468610e-01f, 2.33792827e-01f, 8.76096264e-02f, 8.92395899e-02f, 5.78485541e-02f, -1.85691476e-01f, -1.51333764e-01f, 1.06476560e-01f, 5.84045909e-02f, 2.64278259e-02f,
  2.47428015e-01f, -9.05020311e-02f, 1.47818968e-01f, -1.32228598e-01f, -5.12847193e-02f, 2.78755426e-01f, 4.15391959e-02f, 1.18592292e-01f, -1.00246184e-01f, -2.12675408e-02f,
  -1.16981454e-01f, 4.45877425e-02f, -1.19162388e-01f, 1.62679389e-01f, 1.15222983e-01f, -2.37397533e-02f, 1.89286157e-01f, 1.07518941e-01f, -1.25986785e-01f, 2.20948160e-01f,
  1.66275680e-01f, 4.04099515e-03f, -3.72395441e-02f, 1.39029473e-01f, -3.31237633e-03f, -8.06180164e-02f, -3.76130193e-02f, 9.71872453e-03f, -3.12193688e-02f, 6.64950460e-02f,
  6.95201382e-02f, -3.23161632e-02f, 2.26897851e-01f, 1.25338405e-03f, -1.63206384e-01f, -1.81102797e-01f, -2.56484877e-02f, 2.18765456e-02f, -2.84044305e-03f, 1.16958722e-01f,
  2.78033286e-01f, 1.87351018e-01f, 9.32081565e-02f, 9.88067165e-02f, 3.21752988e-02f, 4.15065698e-02f, 3.67267504e-02f, 1.64215773e-01f, 1.46529200e-02f, 8.01089555e-02f,
  -1.30890951e-01f, 1.92271978e-01f, 1.03589267e-01f, -1.16669707e-01f, 2.62016386e-01f, 2.16114953e-01f, -2.14566998e-02f, 1.42374367e-01f, 3.29139888e-01f, 1.41216129e-01f,
  -2.32867271e-01f, 1.51461765e-01f, -1.23735353e-01f, -1.74660295e-01f, 1.65808816e-02f, 4.47004847e-02f, 1.71468239e-02f, -1.14412479e-01f, 1.90453559e-01f, 6.17500916e-02f,
  1.85382247e-01f, -1.64245218e-02f, 1.52986180e-02f, 2.87914902e-01f, -3.23353596e-02f, 2.07703754e-01f, -7.43203331e-03f, -5.66566586e-02f, -1.00961655e-01f, 1.07207768e-01f,
  -1.49058133e-01f, 1.18647330e-01f, -1.15393430e-01f, -1.59345061e-01f, -1.88331716e-02f, 1.53313115e-01f, -7.17814714e-02f, 2.02389136e-01f, -5.19723967e-02f, 1.82752833e-01f,
  -1.79666251e-01f, 2.08861262e-01f, 1.09502271e-01f, 6.33499995e-02f, 2.20088661e-01f, 1.35741517e-01f, 1.77814379e-01f, -9.40176658e-03f, 3.00635904e-01f, 1.84739567e-02f,
  -1.64958864e-01f, -3.28371257e-01f, 9.80278328e-02f, -2.12344155e-01f, 1.12274498e-01f, 5.81423193e-02f, 1.38357088e-01f, 2.06136331e-01f, -1.22627877e-01f, -2.60567330e-02f,
  2.38765016e-01f, -1.70762315e-01f, -8.58548060e-02f, 1.75617933e-01f, 1.77622065e-01f, -1.11013263e-01f, -1.51437824e-03f, 2.37416252e-01f, 2.04278231e-01f, 1.10960610e-01f,
  2.58656051e-02f, -1.12236924e-01f, 2.53481269e-01f, 1.61071494e-01f, -4.72562723e-02f, 8.54998305e-02f, 6.70177788e-02f, 1.49004176e-01f, 4.40605804e-02f, 2.31090672e-02f,
  -1.67572767e-01f, -5.32469191e-02f, 1.50076166e-01f, -7.20447078e-02f, 7.43074939e-02f, -7.91937113e-02f, 2.47554973e-01f, 1.63497746e-01f, 2.33867437e-01f, -1.25896171e-01f,
  2.42480904e-01f, 1.40539289e-01f, 1.80069491e-01f, -5.61528690e-02f, 1.41934559e-01f, -1.51393369e-01f, 1.69517249e-01f, 9.16030034e-02f, -9.69626531e-02f, 8.81046355e-02f,
  1.31907985e-01f, -2.42207665e-04f, 6.31899536e-02f, -2.33330056e-01f, 1.58285126e-01f, 2.21808225e-01f, -4.40079998e-03f, 1.71279714e-01f, 1.60399780e-01f, 2.42250860e-01f,
  8.03044718e-03f, 3.22790965e-02f, 2.76775379e-02f, -1.68563068e-01f, 8.35772324e-03f, 2.08367899e-01f, 1.20923102e-01f, 1.96356043e-01f, 1.46781921e-01f, 9.93125588e-02f,
  -2.64684185e-02f, -1.32291272e-01f, 2.21731663e-01f, 1.15826085e-01f, -9.26027596e-02f, 2.00409085e-01f, -7.52816647e-02f, -1.83092490e-01f, -2.65203625e-01f, 1.33193359e-01f,
  8.88535827e-02f, -3.61081600e-01f, -1.81568917e-02f, 4.42401655e-02f, 7.41637573e-02f, 9.54007059e-02f, 2.38716990e-01f, 1.79824278e-01f, 5.74624352e-02f, 1.80003736e-02f,
  7.32875690e-02f, -1.72460616e-01f, 3.32318544e-01f, 1.61569908e-01f, 1.49734691e-01f, 1.88652351e-02f, 1.48082301e-01f, 2.83154082e-02f, 2.34036580e-01f, 3.01995218e-01f,
  1.10768415e-01f, 1.78097799e-01f, -3.39194119e-01f, 1.40599191e-01f, -1.89978302e-01f, -1.97601318e-01f, 7.03373477e-02f, 6.60289302e-02f, -1.44567862e-01f, 2.78779436e-02f,
  1.08589958e-02f, -2.30355009e-01f, -5.53414077e-02f, 7.68639147e-02f, -5.29766940e-02f, 1.49128035e-01f, -1.14153668e-01f, 2.61314183e-01f, -5.45477383e-02f, 1.22148938e-01f,
  1.65926844e-01f, 1.97388649e-01f, 1.07972939e-02f, -3.99667583e-02f, 3.11003804e-01f, -1.47197887e-01f, 2.05447599e-01f, -2.00253770e-01f, 1.31163418e-01f, -2.34363168e-01f,
  1.80152029e-01f, -3.68954763e-02f, -4.82137129e-02f, -2.30935127e-01f, -1.85675807e-02f, -5.75468950e-02f, 3.79926749e-02f, -3.66167165e-02f, 2.37246796e-01f, -1.03787698e-01f,
  -1.89407736e-01f, 2.10409522e-01f, 2.74681095e-02f, 1.32855594e-01f, 1.36516780e-01f, 1.64444968e-01f, -3.17205973e-02f, -2.16840163e-01f, 7.92166963e-02f, 1.89583376e-02f,
  -1.35745564e-02f, 3.53504345e-02f, 3.12141448e-01f, 7.44141713e-02f, 2.90731400e-01f, 2.58566402e-02f, -1.09324507e-01f, -1.70964450e-01f, -1.23864360e-01f, 1.77317604e-01f,
  1.70374691e-01f, -7.85387009e-02f, 2.54676372e-01f, -1.08993292e-01f, -1.55651093e-01f, -7.78565630e-02f, 2.41867155e-01f, 2.98990961e-02f, 2.48028845e-01f, 9.33324024e-02f,
  -2.58335210e-02f, 6.70460286e-03f, -7.86155984e-02f, -5.30190170e-02f, 2.07947135e-01f, -2.02941194e-01f, 1.91054866e-01f, 1.10747822e-01f, 1.81311578e-01f, 3.45000476e-02f,
  1.09642394e-01f, -1.58718154e-01f, 1.68453157e-02f, 2.26600036e-01f, 2.07273692e-01f, 1.66591853e-01f, 2.25698277e-01f, 2.44452983e-01f, -3.07710946e-01f, 2.84899116e-01f,
  2.85340399e-01f, 1.18475623e-01f, -1.97218750e-02f, 6.07389435e-02f, 2.66318232e-01f, 1.59253642e-01f, -1.27534658e-01f, 4.61049005e-02f, 2.64643226e-02f, 1.98456496e-01f,
  2.57371932e-01f, -5.55783957e-02f, -8.83586984e-03f, -1.18324079e-03f, -1.57058343e-01f, -5.23477644e-02f, 3.32017280e-02f, 3.68023850e-02f, 1.40633956e-01f, -6.87720627e-02f,
  -1.45568684e-01f, 6.60681799e-02f, 3.68368149e-01f, 7.07731619e-02f, -1.23127371e-01f, 1.12649843e-01f, 3.27167988e-01f, 1.96489263e-02f, -4.44640964e-02f, -2.20602617e-01f,
  1.06859051e-01f, 4.20749247e-01f, 2.61527121e-01f, 2.05729872e-01f, 2.62418147e-02f, -3.49107534e-02f, 1.77720804e-02f, 2.30763108e-01f, 1.35664448e-01f, 1.72640253e-02f,
  -1.11719176e-01f, 3.00855607e-01f, 2.67659761e-02f, 6.94662184e-02f, 2.84923643e-01f, 7.78870285e-02f, 2.36294165e-01f, -1.14535891e-01f, 1.40039429e-01f, 1.41541332e-01f,
  -1.10443540e-01f, -1.25590533e-01f, 2.18246311e-01f, -3.17877196e-02f, -1.94792360e-01f, 2.97769397e-01f, -1.12458326e-01f, -9.75667313e-02f, -1.25961766e-01f, -1.77034557e-01f,
  -1.15604386e-01f, -1.24598764e-01f, 2.11564988e-01f, 3.28734927e-02f, -3.90705802e-02f, 7.65668228e-02f, 5.70904836e-02f, 2.29840409e-02f, -2.15548605e-01f, 1.24490112e-01f,
  -5.07316887e-02f, 1.32465139e-01f, 2.69875318e-01f, 9.75427330e-02f, -8.74377030e-04f, 5.14510237e-02f, 2.06317425e-01f, 1.43396020e-01f, 2.96179593e-01f, 1.28852978e-01f,
  8.88297707e-02f, -1.30060902e-02f, 8.15244392e-02f, 3.67560051e-02f, 2.04328313e-01f, 1.29485965e-01f, -9.58632529e-02f, 4.60506417e-02f, -1.81094408e-02f, -7.15332627e-02f,
  -2.11527482e-01f, 1.26027502e-02f, 1.46497572e-02f, 3.98183241e-02f, 6.28115758e-02f, -1.95679247e-01f, 1.76606134e-01f, -1.60085186e-01f, 1.14537418e-01f, 3.46493214e-01f,
  1.99408755e-02f, -1.04362980e-01f, 2.25640927e-02f, 8.29229504e-02f, 2.17656881e-01f, -3.83390114e-02f, -7.94013217e-02f, 2.45879948e-01f, 6.92639574e-02f, 3.99912633e-02f,
  7.69105107e-02f, 2.80550234e-02f, -1.29565686e-01f, 2.93266445e-01f, 1.01266801e-01f, 1.19464464e-01f, 3.26208100e-02f, 1.02256000e-01f, 9.87231135e-02f, -1.21193953e-01f,
  2.81092823e-02f, 1.37429982e-01f, 4.59888205e-02f, 1.93781391e-01f, 1.81345150e-01f, 3.22061963e-02f, 2.04456940e-01f, -1.50520220e-01f, 1.12528987e-01f, 8.62095281e-02f,
  -3.10621578e-02f, -3.66975728e-04f, 1.33943884e-02f, -1.50735214e-01f, -4.44324166e-02f, 1.45891026e-01f, -2.09594399e-01f, -2.85238866e-02f, 3.72331925e-02f, 1.50013193e-01f,
  1.96039394e-01f, -1.80932581e-01f, -4.62486856e-02f, 4.12159339e-02f, 1.51351035e-01f, 3.54120741e-03f, 1.50876850e-01f, 1.73961416e-01f, 1.60506725e-01f, 1.48561805e-01f,
  1.75514922e-01f, -1.80373847e-01f, -8.11991096e-02f, -1.04388885e-01f, 1.98083818e-01f, -1.27145544e-01f, 2.58723557e-01f, 1.81993246e-01f, -2.43370682e-01f, -1.16679557e-01f,
  -3.98373269e-02f, 1.69758901e-01f, -1.48091316e-01f, -2.03235775e-01f, -4.28770557e-02f, -5.75339273e-02f, 6.22322820e-02f, -1.22941643e-01f, 2.53453612e-01f, -1.20880585e-02f,
  5.00713363e-02f, 2.69995853e-02f, -4.53005508e-02f, 2.02769056e-01f, 6.53259084e-02f, -8.61760229e-02f, 1.11544847e-01f, 1.28119616e-02f, 1.30393542e-02f, -9.79033485e-02f,
  2.69483536e-01f, -1.20635271e-01f, 4.28997539e-02f, -1.05520956e-01f, -1.71188992e-02f, 1.34167895e-01f, 1.75358474e-01f, 1.50756210e-01f, 1.67912707e-01f, 2.50914562e-02f,
  7.04823881e-02f, 8.88090059e-02f, 9.29431766e-02f, 5.79180717e-02f, -1.78338140e-01f, -9.71543491e-02f, -1.28660724e-01f, -1.82732269e-02f, -3.10799992e-03f, 2.06495538e-01f,
  -1.35664701e-01f, 1.75842419e-01f, -1.79529861e-01f, 1.05298832e-01f, 1.11188434e-01f, -8.32828358e-02f, -2.02633739e-02f, 1.54454827e-01f, 1.15934506e-01f, -1.42463401e-01f,
  -3.39724012e-02f, 2.21332297e-01f, 1.40705317e-01f, 2.08078325e-01f, 1.67552724e-01f, 7.42687203e-04f, 2.28154305e-02f, 1.11165091e-01f, -3.53237987e-02f, -1.60753310e-01f,
  -9.27425176e-02f, 1.14115171e-01f, 3.98576483e-02f, 1.22062221e-01f, -1.04267308e-02f, -3.98880430e-02f, -8.99331346e-02f, 1.37744620e-01f, -1.13274418e-02f, -2.70886291e-02f,
  2.71283716e-01f, 9.40878168e-02f, -3.26862521e-02f, 8.11905935e-02f, 5.18471040e-02f, 7.21843690e-02f, 6.10976219e-02f, -5.22420742e-03f, 1.33663684e-01f, -1.49133861e-01f,
  -1.62682995e-01f, -1.32578788e-02f, -9.72047895e-02f, -2.26757713e-02f, 2.04126388e-01f, -1.44094765e-01f, 1.09239668e-01f, -1.37359455e-01f, -1.53848985e-02f, 1.45273894e-01f,
  -4.60495204e-02f, 5.47360582e-03f, 6.66757077e-02f, -5.55489846e-02f, 3.12062763e-02f, 3.76458205e-02f, -2.06165895e-01f, -2.83115923e-01f, 3.05509955e-01f, -1.51739553e-01f,
  -1.01157082e-02f, 3.31234097e-01f, 1.66529231e-03f, -3.59442644e-03f, 1.63744092e-01f, -3.53459269e-02f, 2.16072083e-01f, -8.63085464e-02f, 2.50486851e-01f, -2.41093356e-02f,
  6.41591772e-02f, 5.20683341e-02f, 1.17808424e-01f, -5.92046883e-03f, 1.34815782e-01f, 7.52816126e-02f, 1.39690503e-01f, -3.21554132e-02f, 1.46792799e-01f, 2.38071010e-01f,
  -1.99793845e-01f, -1.16688795e-01f, 2.67431259e-01f, 1.81200251e-01f, 1.31837681e-01f, -1.27141908e-01f, -2.84536276e-02f, 7.25924596e-02f, 1.20602973e-01f, 8.86511803e-02f,
  2.02045053e-01f, 2.34386623e-01f, 2.50480860e-01f, 2.54809976e-01f, -1.56217203e-01f, 1.84944466e-01f, 1.36492237e-01f, 2.28521749e-01f, -6.03390783e-02f, 1.74364671e-01f,
  6.10365346e-02f, 1.90824553e-01f, -9.03638825e-02f, 4.75910269e-02f, 7.47012272e-02f, 1.75942361e-01f, -1.81787442e-02f, 2.07895022e-02f, -6.76880702e-02f, 1.90574259e-01f,
  -7.82176554e-02f, -2.87788752e-02f, 1.05849572e-01f, 2.61093110e-01f, 1.39336720e-01f, 1.40523687e-01f, 2.55859159e-02f, 3.23084407e-02f, 1.21109404e-01f, -2.66413745e-02f,
  1.16695063e-02f, -1.68180600e-01f, 1.19600885e-01f, -2.72143513e-01f, 2.99159110e-01f, 1.91098243e-01f, 9.45214033e-02f, -2.06918076e-01f, 1.57535672e-01f, -7.42275119e-02f,
  5.10224998e-02f, -2.65892223e-02f, 9.89809334e-02f, 1.07164301e-01f, -1.61266044e-01f, 1.42693892e-01f, -4.03226577e-02f, 5.62210381e-02f, 7.93544203e-02f, 1.12915836e-01f,
  2.29853522e-02f, 7.28627741e-02f, -6.35877773e-02f, 1.82931378e-01f, 7.48128444e-02f, 2.17954338e-01f, 3.44961077e-01f, 1.49004325e-01f, 3.08131729e-03f, -2.01587752e-02f,
  1.62313432e-01f, 8.45392607e-03f, 3.28570396e-01f, 2.00951666e-01f, 3.02525371e-01f, 1.91534325e-01f, 2.72537708e-01f, 3.73346210e-02f, -1.56994700e-03f, 4.34704386e-02f,
  -3.89382653e-02f, 2.46875182e-01f, 1.41264796e-01f, 1.08297311e-01f, -1.13860974e-02f, -1.51980910e-02f, -8.27578157e-02f, -1.12812459e-01f, 1.54765934e-01f, -1.25385851e-01f,
  -4.02261540e-02f, -2.29809862e-02f, -1.00082748e-01f, -2.42536422e-02f, -1.76309139e-01f, 1.72400996e-01f, 2.39851564e-01f, 1.39385596e-01f, -1.53261274e-02f, 2.28769064e-01f,
  1.17356837e-01f, -7.58309988e-03f, 1.82553574e-01f, 4.74136472e-02f, -4.96703945e-02f, -1.20371230e-01f, 3.40972096e-02f, -1.98994473e-01f, 2.11321190e-01f, 2.25895554e-01f,
  5.20241708e-02f, -1.08818434e-01f, 3.85523438e-02f, -5.59022017e-02f, 2.04073891e-01f, -5.05024055e-03f, 1.44859582e-01f, 2.90506512e-01f, -1.88168004e-01f, 5.02205566e-02f,
  6.80981670e-03f, 1.04369402e-01f, -2.51693316e-02f, -4.13252972e-03f, -1.28555372e-01f, -1.59948170e-01f, 9.98690724e-02f, 2.23374113e-01f, 1.36037663e-01f, 1.22998461e-01f,
  8.52522030e-02f, 1.78672969e-01f, 1.91353098e-01f, -1.42866477e-01f, 2.19688401e-01f, 1.60167664e-02f, 7.36538917e-02f, -3.17135826e-03f, 7.19646141e-02f, -1.28498757e-02f,
  9.85537022e-02f, 1.98353946e-01f, 9.17238556e-03f, 6.90334812e-02f, -7.16672242e-02f, 2.76400238e-01f, 1.20523721e-01f, 3.68718542e-02f, 8.57536048e-02f, 4.29222360e-02f,
  3.18723135e-02f, 1.13607109e-01f, -9.79314838e-03f, -1.60989910e-01f, 8.38714764e-02f, 1.99264064e-02f, -1.08164020e-01f, 3.69570814e-02f, 1.05743393e-01f, 1.08896732e-01f,
  -6.59843460e-02f, 8.37641209e-03f, 1.04864873e-01f, 2.57951990e-02f, 4.07361090e-02f, -1.01019233e-01f, 9.67416912e-02f, -1.03209212e-01f, -1.39076293e-01f, -1.09872043e-01f,
  1.89409822e-01f, 1.21664576e-01f, 3.26343179e-02f, -3.42538320e-02f, 1.68206662e-01f, 1.97716393e-02f, 9.65521857e-02f, 3.70474271e-02f, 1.41848639e-01f, -9.75631550e-02f,
  1.40535444e-01f, 2.13439986e-01f, 2.00893089e-01f, 5.75288683e-02f, -1.43835574e-01f, 1.90022454e-01f, 1.33787477e-02f, -5.61935008e-02f, 3.22349705e-02f, -1.04486786e-01f,
  -6.30692169e-02f, 9.71832424e-02f, -2.52975598e-02f, -2.36076832e-01f, -1.39566541e-01f, 2.24002600e-01f, 9.64076295e-02f, 2.24097427e-02f, 1.41668310e-02f, -2.77342588e-01f,
  1.45782813e-01f, 4.45184074e-02f, 2.78947741e-01f, 2.56423205e-01f, 1.90459162e-01f, -6.90966994e-02f, -6.96375743e-02f, 4.05888595e-02f, -2.01567579e-02f, -2.50642896e-02f,
  3.27802822e-02f, 1.60173297e-01f, -1.85649440e-01f, -3.53069860e-03f, -2.07361564e-01f, 2.27621987e-01f, 1.18579090e-01f, -1.32717341e-01f, 2.53739476e-01f, 1.07140973e-01f,
  -8.93285349e-02f, 1.25389203e-01f, 1.32374629e-01f, 3.16165015e-02f, -6.49192706e-02f, 2.20399931e-01f, 1.29371546e-02f, 1.31463319e-01f, 9.18227807e-02f, 1.27632022e-01f,
  2.53904969e-01f, -2.00543299e-01f, 4.59632054e-02f, -8.87786895e-02f, -1.55625105e-01f, -2.11669892e-01f, 2.93156896e-02f, -2.54811764e-01f, 2.66106755e-01f, 1.40673682e-01f,
  2.25129321e-01f, -2.17457861e-02f, -1.49908170e-01f, -7.20528290e-02f, 2.10430339e-01f, 1.40097946e-01f, 5.22348806e-02f, 1.79264635e-01f, 1.87111199e-01f, 2.31813714e-01f,
  -3.96554172e-02f, 1.68766111e-01f, 2.93605089e-01f, 1.96684971e-01f, -1.44989088e-01f, -6.25240207e-02f, 3.52764279e-01f, 2.09436670e-01f, -1.41294032e-01f, -2.52171904e-02f,
  -5.42114340e-02f, -7.65806139e-02f, 1.93958864e-01f, 3.95238139e-02f, 1.55542985e-01f, -2.62584001e-01f, 6.80201203e-02f, 2.85977393e-01f, -1.71879530e-02f, -2.52965510e-01f,
  3.00010562e-01f, 9.11668688e-02f, 9.43270773e-02f, 9.07544419e-03f, 8.61242190e-02f, 1.94520831e-01f, 1.47391617e-01f, -1.70355067e-01f, -2.29319111e-01f, -5.19487113e-02f,
  -2.53988564e-01f, 2.77846977e-02f, -1.22598439e-01f, 5.41423308e-03f, -4.06562388e-02f, 1.80764377e-01f, 1.29272044e-02f, 4.33033518e-02f
};

// L2_fan_Bp_bar (Shape: 1 x 52)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 52;
const float L2_fan_Bp_bar_data[] = {
  1.35060385e-01f, -3.32448110e-02f, -2.39165965e-02f, 4.17580679e-02f, 8.45446959e-02f, -3.38344909e-02f, 9.14181918e-02f, 4.87024076e-02f, 5.14477976e-02f, -1.06055439e-01f,
  6.47560954e-02f, -1.38801429e-02f, 8.33788961e-02f, 1.27893373e-01f, -7.58254752e-02f, -3.64777222e-02f, -3.73686180e-02f, 8.24886635e-02f, 1.16691060e-01f, -5.63213183e-03f,
  1.69184610e-01f, 1.18554324e-01f, 2.40368083e-01f, -1.51085835e-02f, 1.03288651e-01f, -2.34978311e-02f, 6.68656379e-02f, 1.73671901e-01f, -1.15962029e-01f, 1.11031353e-01f,
  1.79917857e-01f, -7.92765692e-02f, 5.64252073e-03f, 1.90918371e-01f, 1.11395523e-01f, 1.62509516e-01f, 1.84936047e-01f, -1.44657716e-01f, 1.03950731e-01f, 5.14651164e-02f,
  2.92699179e-03f, 1.84204295e-01f, 2.20309481e-01f, 6.71802461e-02f, 8.30312744e-02f, 1.18101552e-01f, 1.91769361e-01f, 1.79588974e-01f, 1.48892775e-01f, 1.18551493e-01f,
  1.53537974e-01f, 6.75201789e-02f
};

// L3_fan_Wp (Shape: 6 x 64)
const int L3_fan_Wp_rows = 6;
const int L3_fan_Wp_cols = 64;
const float L3_fan_Wp_data[] = {
  1.89127624e-02f, 1.13713257e-01f, 2.66164225e-02f, -2.69227941e-02f, 5.18971793e-02f, 1.21048398e-01f, 7.98181444e-02f, 3.67123783e-02f, 3.11418585e-02f, 4.70482223e-02f,
  -6.04814989e-03f, 1.26221865e-01f, 5.26505895e-02f, 9.23706815e-02f, -8.64955783e-02f, -1.77665167e-02f, 5.25107235e-02f, -8.27553198e-02f, -5.86387366e-02f, -7.45786726e-02f,
  3.46879438e-02f, 9.55870748e-02f, 7.80376643e-02f, 7.10321441e-02f, -6.59159645e-02f, -1.31952584e-01f, 6.75384104e-02f, 9.91954356e-02f, 8.07312503e-02f, -6.91276640e-02f,
  -1.36904344e-01f, 1.43511575e-02f, 6.08546659e-02f, 5.96294440e-02f, -4.63373736e-02f, 7.51048177e-02f, 2.77928598e-02f, 1.60640236e-02f, 4.47145551e-02f, 2.23173033e-02f,
  -8.42532292e-02f, 2.17840169e-02f, -1.45517988e-02f, 1.19372625e-02f, 2.04709351e-01f, 6.81446865e-02f, -1.21784046e-01f, 9.68174040e-02f, -6.33481443e-02f, 9.57370773e-02f,
  -9.91633255e-03f, 1.65635478e-02f, -1.02229871e-01f, -1.44767568e-01f, -1.10522054e-01f, 7.90626779e-02f, -3.88897248e-02f, 2.15808582e-02f, -1.08911410e-01f, 2.84228334e-03f,
  -3.37293968e-02f, 5.85260019e-02f, 3.43154706e-02f, -1.14664033e-01f, 7.86036700e-02f, 1.34662583e-01f, -1.03343241e-01f, 3.96180116e-02f, 1.16057836e-01f, 6.48069605e-02f,
  -2.81815585e-02f, -7.74507225e-02f, -1.75841823e-01f, 2.26362385e-02f, -7.08046705e-02f, -1.58763248e-02f, 5.17719649e-02f, -7.84328952e-02f, -3.63812479e-03f, 1.54084750e-02f,
  -2.32033469e-02f, 9.31547806e-02f, -7.83271417e-02f, -1.69481248e-01f, -3.14357542e-02f, -9.25784335e-02f, 1.03887722e-01f, 2.43564751e-02f, 9.76375118e-02f, -7.07284659e-02f,
  4.71883863e-02f, -2.76430659e-02f, 7.65623664e-03f, 2.04546332e-01f, -2.03719176e-02f, -3.69486026e-02f, -4.70050052e-02f, 1.06463000e-01f, -5.41602075e-02f, 1.43325150e-01f,
  6.50329813e-02f, 1.84578784e-02f, -9.43400804e-03f, -5.56283407e-02f, -5.92855699e-02f, -6.78905547e-02f, 9.49888024e-03f, -6.14126995e-02f, 1.00288324e-01f, -6.39861897e-02f,
  3.78242433e-02f, -4.81848828e-02f, 7.57951885e-02f, -3.94149013e-02f, 2.84815412e-02f, -1.02778792e-01f, -2.23820377e-02f, 3.59336846e-02f, 1.34143963e-01f, 6.19835742e-02f,
  -8.09491053e-02f, 1.05487034e-01f, -2.45809574e-02f, -6.16471283e-02f, -1.71596315e-02f, -1.49000222e-02f, -1.41686583e-02f, -1.12126775e-01f, -8.09590891e-03f, -3.50764617e-02f,
  -1.26977295e-01f, 5.76010086e-02f, -4.53080498e-02f, 1.03863254e-01f, -3.95663530e-02f, -1.22036105e-02f, 6.09565116e-02f, -8.20463672e-02f, -4.16415632e-02f, -7.05662221e-02f,
  1.25694647e-01f, 9.23727974e-02f, -1.59384072e-01f, -6.75561279e-02f, 9.19982865e-02f, 5.15381396e-02f, 2.20927615e-02f, -1.84772432e-01f, -2.50473674e-02f, 1.74079053e-02f,
  9.14802253e-02f, -8.40313882e-02f, -8.90845731e-02f, 2.33167745e-02f, -7.35791475e-02f, -3.16836424e-02f, -1.44117057e-01f, 6.23532534e-02f, 1.29376110e-02f, 4.43590656e-02f,
  1.53180107e-01f, 7.29629472e-02f, 5.90422526e-02f, 1.54515672e-02f, -7.35711530e-02f, -7.50049949e-02f, -2.16886140e-02f, 4.72280718e-02f, -1.17505722e-01f, -1.37958407e-01f,
  3.00489180e-02f, 9.18162335e-03f, 8.61259773e-02f, -1.01900853e-01f, 5.06767072e-02f, 6.33621812e-02f, 1.53340563e-01f, -1.61420241e-01f, -1.17643625e-01f, -2.60325763e-02f,
  3.97644565e-03f, 2.21347455e-02f, -1.40840322e-01f, 1.36510164e-01f, -5.40865622e-02f, 3.08473967e-02f, -2.93771029e-02f, -1.37939621e-02f, 9.32409521e-03f, 2.42196210e-02f,
  -1.26569808e-01f, 3.73577699e-03f, 5.95836993e-03f, -9.45067704e-02f, -1.15010114e-02f, -6.99861944e-02f, -1.31041214e-01f, 5.90179674e-02f, 1.30392183e-02f, 7.52955973e-02f,
  1.11853436e-01f, 9.34066325e-02f, 1.76439434e-01f, 8.50272104e-02f, -1.04074731e-01f, 4.33824770e-02f, 1.43166006e-01f, 1.27387047e-01f, -1.05708286e-01f, -3.05455346e-02f,
  1.42596802e-02f, 1.15209036e-01f, -1.33965034e-02f, 8.63433927e-02f, -6.20270185e-02f, -1.03332348e-01f, -4.12034616e-02f, -1.74399605e-03f, -3.78108919e-02f, 1.35871202e-01f,
  -6.51175482e-03f, 1.28513515e-01f, -6.04615023e-04f, -9.27034244e-02f, 1.21293262e-01f, 8.73537064e-02f, -1.75692305e-01f, -7.46973380e-02f, 5.52809797e-03f, -8.64255503e-02f,
  -6.19323179e-02f, -1.87682174e-02f, 2.57367939e-02f, -8.61969590e-02f, 2.34519914e-02f, -1.04345463e-01f, 1.80007175e-01f, -4.36478145e-02f, 1.93744842e-02f, -2.39465549e-03f,
  6.06597848e-02f, 5.11941174e-03f, 1.08102247e-01f, 7.18230307e-02f, -3.27066444e-02f, 5.50606176e-02f, -4.44288217e-02f, -1.61403827e-02f, -4.88101617e-02f, -8.96261930e-02f,
  -2.50684172e-02f, 1.87928732e-02f, -1.33751526e-01f, -2.84917001e-02f, 5.42211458e-02f, -5.59520610e-02f, 5.57231158e-02f, 1.39083654e-01f, 8.98955297e-03f, 5.81893921e-02f,
  -7.31307641e-03f, -9.63526443e-02f, -1.54975861e-01f, 1.97589342e-02f, -2.11938471e-01f, -4.00194600e-02f, 6.56914115e-02f, 1.79211512e-01f, 8.47535431e-02f, -1.22485161e-01f,
  -1.59567297e-02f, -3.98752093e-02f, -9.36333239e-02f, 8.39161947e-02f, 6.74490705e-02f, 1.82036031e-03f, 1.77490681e-01f, -1.17004193e-01f, -9.07645449e-02f, 1.94644195e-03f,
  1.94654539e-01f, -1.20308036e-02f, 4.92526367e-02f, 4.21945751e-02f, -8.15129876e-02f, 1.44163370e-01f, -1.31578922e-01f, 3.60854305e-02f, 3.56653892e-02f, 6.56665340e-02f,
  -1.63234249e-02f, -9.81255993e-02f, -4.94784266e-02f, 4.62222248e-02f, 1.11482553e-01f, -5.19170575e-02f, -2.68933866e-02f, -1.45919081e-02f, -1.50963768e-01f, -1.60084575e-01f,
  9.75386724e-02f, -8.81943405e-02f, -8.90484601e-02f, 8.31152424e-02f, 1.26193985e-01f, 1.08089469e-01f, 5.75810112e-02f, 4.23217937e-02f, -1.38993427e-01f, 5.00006182e-03f,
  2.92425230e-02f, 1.90830365e-01f, -6.14426658e-02f, -4.45824396e-03f, 9.27080661e-02f, 1.47016928e-01f, 5.75743951e-02f, 6.01718910e-02f, -5.44221215e-02f, 5.71289882e-02f,
  -2.07458786e-03f, 6.63979873e-02f, 6.32589906e-02f, -1.11514516e-02f, 4.64857817e-02f, -6.37107939e-02f, 2.33942717e-02f, -1.39016896e-01f, -9.66008101e-03f, -3.30438241e-02f,
  -6.76282197e-02f, 4.19147760e-02f, -3.43932118e-03f, -2.07897853e-02f, -6.59368485e-02f, -1.53244231e-02f, -4.28785803e-04f, -6.36906028e-02f, -5.21605313e-02f, -3.05211097e-02f,
  1.34443939e-01f, -7.48079419e-02f, -8.46401528e-02f, -5.59897199e-02f, 8.49053562e-02f, 6.14662729e-02f, -3.28417607e-02f, 7.67305086e-04f, -5.47800995e-02f, -7.24223331e-02f,
  1.50858462e-01f, -7.22658038e-02f, 5.88928461e-02f, 1.75247598e-03f, -5.05690500e-02f, 4.39140573e-02f, -2.73305494e-02f, 3.48811895e-02f, -2.12054793e-02f, 5.81839047e-02f,
  7.09700584e-02f, -5.82697354e-02f, 1.25012835e-02f, -1.04658321e-01f, -9.83590260e-02f, -1.99888963e-02f, -9.75682959e-02f, 1.48429662e-01f, 9.46062356e-02f, -1.14075653e-01f,
  2.35494934e-02f, 6.15025423e-02f, 1.05745710e-01f, 2.73292530e-02f, -3.81436646e-02f, 4.72651310e-02f, 1.07144313e-02f, 6.74015284e-02f, 4.91275527e-02f, 6.50316626e-02f,
  -5.96460067e-02f, 3.20497304e-02f, -7.28730857e-02f, 1.07116520e-01f
};

// L3_fan_Wp_bar (Shape: 52 x 64)
const int L3_fan_Wp_bar_rows = 52;
const int L3_fan_Wp_bar_cols = 64;
const float L3_fan_Wp_bar_data[] = {
  2.59877611e-02f, -7.85482228e-02f, 1.67128712e-01f, -1.59079224e-01f, 1.08621284e-01f, 8.42186287e-02f, 1.63213238e-01f, 5.60747012e-02f, 2.34884381e-01f, 1.44754887e-01f,
  7.57020116e-02f, -7.81508982e-02f, -1.71611041e-01f, 1.31793842e-01f, 1.51616409e-01f, -4.44688946e-02f, -1.26197681e-01f, -7.71236345e-02f, -1.43786231e-02f, 7.81283230e-02f,
  -1.31009385e-01f, 1.21985041e-01f, 6.10520467e-02f, 1.40931785e-01f, -1.61067128e-01f, 1.59848049e-01f, 1.47472501e-01f, -3.02469824e-02f, -7.33312666e-02f, -1.35973334e-01f,
  1.20918453e-01f, 1.16205374e-02f, -2.82052476e-02f, -3.44983600e-02f, -4.03916761e-02f, -6.28167018e-02f, 4.70991470e-02f, -1.35160089e-01f, 1.27603531e-01f, 6.59585521e-02f,
  -5.34355454e-02f, -3.13596539e-02f, 1.72669053e-01f, 4.94974293e-02f, -1.49237350e-01f, -6.19368330e-02f, 4.65185866e-02f, -4.00538221e-02f, 9.07070935e-02f, -3.31534282e-03f,
  1.48399398e-02f, 1.58009380e-01f, -4.77936976e-02f, 1.22740649e-01f, 1.02657862e-01f, 1.73735917e-02f, 1.44040778e-01f, 2.02148911e-02f, 8.15733429e-03f, 2.12200329e-01f,
  9.81133655e-02f, -1.04438029e-02f, 3.81228700e-02f, -8.13929886e-02f, 3.09590064e-02f, 2.78355442e-02f, 1.17079452e-01f, 4.11999859e-02f, 2.13314109e-02f, 1.81079000e-01f,
  1.68966696e-01f, -1.46221086e-01f, -2.41494719e-02f, -1.70315698e-01f, 1.03421044e-03f, 4.91546579e-02f, 6.61041141e-02f, 9.01814029e-02f, -7.95316473e-02f, -1.70119554e-01f,
  2.11600572e-01f, 1.19057275e-01f, -3.11652757e-02f, -1.75467402e-01f, -1.11138739e-01f, -9.81781036e-02f, 6.62044138e-02f, -6.66143075e-02f, -1.46153048e-01f, 2.06880882e-01f,
  6.51647430e-03f, 6.95971847e-02f, 2.15783063e-02f, 9.83014181e-02f, 1.12387463e-01f, 2.24317193e-01f, -1.14049435e-01f, 2.42431760e-01f, 1.96657807e-01f, 2.21378312e-01f,
  -6.70089107e-03f, -7.49461725e-02f, 1.61674052e-01f, -9.26124230e-02f, -2.31562242e-01f, 8.76927599e-02f, 1.84277683e-01f, 1.94110066e-01f, 5.60559146e-02f, 8.37077051e-02f,
  1.55812681e-01f, 1.97570994e-01f, 1.85494259e-01f, -2.60019988e-01f, -2.04822570e-01f, 7.59136006e-02f, 1.84814274e-01f, 2.21993849e-02f, 2.16965899e-01f, 1.82097897e-01f,
  -1.01551473e-01f, 1.48377120e-01f, 5.61320670e-02f, 6.10874332e-02f, 2.62211680e-01f, 9.87637639e-02f, -5.55963218e-02f, 6.42156526e-02f, 5.27226590e-02f, 5.17884009e-02f,
  3.54120024e-02f, 6.97077662e-02f, 4.44713905e-02f, 1.45102218e-01f, 2.11467490e-01f, -2.02533543e-01f, -5.67726195e-02f, -1.51031792e-01f, -1.09619908e-02f, -7.09272027e-02f,
  -6.92466348e-02f, -5.35454713e-02f, -1.22293632e-03f, 3.95518430e-02f, -5.25021963e-02f, -4.17648368e-02f, 2.72498667e-01f, 2.30075121e-01f, -1.09165408e-01f, 1.17060050e-01f,
  2.04441577e-01f, -5.61377313e-03f, -1.11798979e-01f, -2.95693073e-02f, -3.08813294e-03f, -1.37657672e-01f, 2.13103220e-01f, -4.27726619e-02f, 9.27479938e-02f, 4.82349172e-02f,
  1.76178947e-01f, 2.14934796e-01f, 1.65470019e-01f, -2.42900595e-01f, 5.87262958e-02f, -2.18034729e-01f, -9.31256916e-03f, -4.16105837e-02f, -8.10370892e-02f, 3.96694802e-02f,
  -1.32912263e-01f, 7.58440420e-02f, -6.43045306e-02f, -4.10108380e-02f, 1.92155749e-01f, -1.89750910e-01f, -5.27886264e-02f, -1.01238742e-01f, -6.00397363e-02f, 2.97299474e-02f,
  -1.71840005e-02f, 2.80207470e-02f, 1.82944134e-01f, -1.41870111e-01f, -7.52224773e-02f, 5.41969687e-02f, 8.34270641e-02f, 1.67710379e-01f, 6.60300031e-02f, 1.09567083e-01f,
  2.22902387e-01f, 1.00120023e-01f, -9.41834152e-02f, 1.11227602e-01f, -9.08064991e-02f, 1.47332232e-02f, -8.07244927e-02f, -4.68347259e-02f, 1.03061751e-01f, 1.91946700e-01f,
  -1.03500955e-01f, 1.53552949e-01f, 6.94001541e-02f, 9.91966873e-02f, 8.04896429e-02f, -1.00710414e-01f, 1.28366441e-01f, 2.32038826e-01f, -1.80552155e-01f, 2.60506687e-03f,
  2.27232352e-01f, 2.12948412e-01f, 1.61874443e-01f, 2.26622581e-01f, 2.50604391e-01f, -8.40536039e-03f, 1.06293619e-01f, -2.98451483e-01f, 1.86553746e-01f, 5.89080006e-02f,
  5.05599717e-04f, 1.80607617e-01f, -5.07215597e-02f, -2.01389417e-01f, 2.84054339e-01f, 2.43459065e-02f, -1.60510898e-01f, -3.86635810e-02f, 2.91696072e-01f, -1.96388289e-02f,
  1.38587669e-01f, 1.89175960e-02f, 2.29267657e-01f, 2.05881447e-02f, -4.09030588e-03f, -1.65767863e-01f, 2.19196871e-01f, 1.50521472e-01f, 6.82162195e-02f, 6.61275014e-02f,
  -6.89901859e-02f, 5.44487983e-02f, 1.62107289e-01f, 1.50724977e-01f, -1.52902633e-01f, 1.44870564e-01f, 5.62041141e-02f, -1.38983605e-02f, -9.28371400e-03f, 1.10465288e-02f,
  -1.13642029e-01f, -1.37742842e-02f, 8.15044120e-02f, 1.21305168e-01f, 2.11243659e-01f, -8.40875581e-02f, -7.69786835e-02f, -5.85599840e-02f, 3.47964168e-02f, -4.96978946e-02f,
  -1.19079754e-01f, -8.22260138e-03f, 9.43436548e-02f, 8.40940997e-02f, -1.04257531e-01f, -6.91011688e-03f, -2.32583329e-01f, 3.34364325e-02f, 1.88612118e-01f, -1.19439870e-01f,
  1.97010875e-01f, 1.99357748e-01f, 5.10269701e-02f, -5.82214482e-02f, 2.21011981e-01f, 1.85803384e-01f, 8.41426551e-02f, 1.65901780e-01f, 2.41942465e-01f, -9.30932909e-02f,
  1.77700311e-01f, -4.71357219e-02f, 9.54637378e-02f, -2.92611644e-02f, 1.96497485e-01f, 6.69784769e-02f, -3.59567739e-02f, -9.92990937e-03f, 2.49312013e-01f, 2.28557721e-01f,
  1.47812337e-01f, 1.41479596e-01f, 1.44108698e-01f, -1.87254697e-01f, 1.84170231e-02f, -1.56480744e-01f, 1.71174798e-02f, 1.23480946e-01f, 1.51654825e-01f, -4.14325930e-02f,
  2.43964955e-01f, 9.53904539e-02f, 2.03322858e-01f, -1.22703694e-01f, -4.35788333e-02f, 1.32579610e-01f, 1.62267193e-01f, 7.09329918e-02f, 1.06896482e-01f, 4.35782559e-02f,
  8.97676498e-02f, 7.23494440e-02f, 1.53447762e-01f, 2.62156785e-01f, -5.77668585e-02f, -3.84968370e-02f, -1.80803105e-01f, -3.31127495e-02f, 1.29669726e-01f, 4.99393642e-02f,
  6.12138733e-02f, 1.83022216e-01f, -2.86581554e-03f, 2.18716770e-01f, 5.21448590e-02f, 6.91080466e-02f, 4.25748602e-02f, -1.56883955e-01f, -1.49297610e-01f, -2.52725482e-01f,
  -8.55596885e-02f, -1.43702313e-01f, 2.45274916e-01f, 1.01045638e-01f, 1.22660629e-01f, 7.19502047e-02f, -2.00157896e-01f, 1.40032694e-01f, 1.96547404e-01f, 1.06991053e-01f,
  1.13906853e-01f, -4.67233695e-02f, 6.20074160e-02f, -7.70601556e-02f, 7.18632862e-02f, -1.07654586e-01f, 3.74387540e-02f, -2.27255568e-01f, 7.51105621e-02f, 1.12164006e-01f,
  1.25372345e-02f, 1.74656659e-01f, -1.45794198e-01f, 1.34297147e-01f, 1.68201596e-01f, -8.72079581e-02f, -1.26683757e-01f, -1.18444085e-01f, -1.81065381e-01f, -3.41377147e-02f,
  -1.12747192e-01f, -1.38597712e-01f, -5.17173372e-02f, 1.87281873e-02f, 1.55149192e-01f, 1.21411517e-01f, 2.57185008e-02f, 5.41271009e-02f, 6.55369535e-02f, -1.37156799e-01f,
  -2.26308212e-01f, -8.16801861e-02f, 1.87688202e-01f, -1.72475994e-01f, 2.61228889e-01f, -1.38689965e-01f, -5.48653714e-02f, 1.22049123e-01f, -2.26391144e-02f, -1.37107283e-01f,
  2.13446748e-02f, -4.40191142e-02f, -7.23726898e-02f, 9.34122428e-02f, -4.36353497e-03f, -7.02969804e-02f, -1.25325933e-01f, 3.54609750e-02f, -2.92773638e-02f, -1.28291130e-01f,
  8.19042604e-03f, 1.16397358e-01f, 1.26259729e-01f, 9.96281356e-02f, 5.70488982e-02f, 1.38976857e-01f, -5.72868958e-02f, 1.82550132e-01f, 1.28222987e-01f, 9.16351005e-03f,
  6.00313768e-02f, -1.07418388e-01f, -3.15848365e-02f, 5.77216328e-04f, -9.44016501e-02f, -3.31800245e-03f, -8.86977743e-03f, 9.24940780e-02f, -1.04955561e-01f, -6.95500970e-02f,
  2.07646694e-02f, 2.77671486e-01f, 1.03286095e-01f, -1.91241637e-01f, 1.30381256e-01f, -8.39400142e-02f, 2.41353393e-01f, 1.08996317e-01f, -4.64889631e-02f, 1.21086434e-01f,
  1.00084610e-01f, -6.96874857e-02f, 2.23035187e-01f, -9.27276313e-02f, 1.09739252e-03f, 1.61793113e-01f, 2.19432205e-01f, -1.13994323e-01f, 1.66949168e-01f, 4.24943231e-02f,
  4.06367099e-03f, 1.62675634e-01f, -1.28901020e-01f, 4.22498286e-02f, 2.14424431e-02f, 2.55316421e-02f, -1.85995668e-01f, 1.95987627e-01f, -9.28602815e-02f, 1.17718123e-01f,
  4.13073301e-02f, -1.18723281e-01f, -1.14455290e-01f, 5.12255728e-02f, 4.15676795e-02f, 1.54117048e-01f, 1.32692963e-01f, -1.57445535e-01f, 9.55340639e-02f, 8.93750861e-02f,
  -1.51891708e-01f, -5.57026528e-02f, -1.01337753e-01f, -1.14488043e-01f, 1.14783598e-02f, -1.18701845e-01f, 6.49249777e-02f, -7.25372881e-02f, 8.80139694e-02f, 2.49263316e-01f,
  4.82798368e-03f, 1.14497527e-01f, 7.36567155e-02f, -8.09265599e-02f, 1.28506333e-01f, 6.97384700e-02f, -5.85048720e-02f, -3.24171454e-01f, -3.57699133e-02f, -1.15730859e-01f,
  1.00104157e-02f, 1.15681581e-01f, 1.21160015e-01f, 2.32292316e-03f, -3.36947329e-02f, 2.01000944e-01f, 5.45289256e-02f, 1.22095875e-01f, 3.33395042e-02f, 2.08151773e-01f,
  5.85761145e-02f, 2.35998016e-02f, 1.61665857e-01f, 1.41638204e-01f, 6.76562637e-02f, -1.29375041e-01f, 7.46506974e-02f, 3.54880244e-02f, -2.11304426e-01f, 1.35626383e-02f,
  1.92797393e-01f, -1.19142060e-03f, 2.39002421e-01f, 8.57842937e-02f, -6.81112707e-02f, 2.09271416e-01f, 1.55815911e-02f, -1.43475056e-01f, -5.33747971e-02f, 3.28666642e-02f,
  -8.41676351e-03f, 1.63405553e-01f, 3.58143151e-02f, 3.07134658e-01f, -1.06929079e-01f, -2.38682330e-02f, 6.08858615e-02f, 2.25145407e-02f, 1.36252850e-01f, 1.61436871e-01f,
  -1.05902828e-01f, 9.22453869e-03f, 1.11649312e-01f, 4.14795950e-02f, 2.83481479e-01f, 1.04607001e-01f, 2.53840536e-01f, 2.67354399e-01f, 9.26885083e-02f, -2.44916394e-01f,
  -7.84406066e-02f, -1.89163223e-01f, -2.32688755e-01f, -1.11603469e-01f, 1.18195035e-01f, 1.65947199e-01f, -1.23863101e-01f, -1.69431537e-01f, -9.90423262e-02f, 2.50103772e-01f,
  -9.39448830e-04f, -1.36563763e-01f, -1.01805583e-01f, -3.89494188e-02f, 9.84909907e-02f, -1.35166854e-01f, -5.59092052e-02f, 1.82884350e-01f, -1.34130418e-01f, -8.32542703e-02f,
  -4.26475406e-02f, 1.62319615e-01f, 7.24253953e-02f, 4.55155969e-02f, 5.55409342e-02f, -1.53168375e-02f, 1.80405855e-01f, -5.57616651e-02f, 5.64018153e-02f, -5.40530868e-02f,
  1.28008217e-01f, -2.72383969e-02f, -1.20477423e-01f, 1.36559471e-01f, 1.52553573e-01f, 2.01309957e-02f, -6.02265298e-02f, -8.21605399e-02f, 2.69537628e-01f, 4.54120114e-02f,
  2.32999995e-01f, -2.06008241e-01f, -9.90984663e-02f, 1.86387450e-01f, 1.66920528e-01f, 5.87163456e-02f, 1.41337156e-01f, -7.48801902e-02f, -1.96854532e-01f, -6.98724613e-02f,
  2.12714840e-02f, -1.15868993e-01f, 1.55822411e-01f, 1.22564800e-01f, 7.92212635e-02f, 1.17417224e-01f, 5.50808236e-02f, 8.86675194e-02f, -2.94215437e-02f, -6.97017238e-02f,
  1.50197893e-01f, 1.10646628e-01f, 1.97419688e-01f, -1.65397853e-01f, -1.94988355e-01f, -1.97078139e-01f, -1.13225497e-01f, 3.22045572e-02f, 5.33004627e-02f, 1.43119469e-01f,
  2.99060959e-02f, -1.25459850e-01f, -1.03016449e-02f, -5.25480229e-03f, 2.09923655e-01f, 5.07634319e-03f, -8.11173022e-03f, 4.16946523e-02f, 8.11222345e-02f, -1.05702104e-02f,
  -1.49369072e-02f, 2.67153624e-02f, -1.77058578e-01f, -8.28214586e-02f, 1.67834118e-01f, 1.72756031e-01f, 3.82684357e-02f, 1.85709655e-01f, -3.74771953e-02f, 2.96654731e-01f,
  9.34408903e-02f, -2.04423368e-01f, -5.85007221e-02f, 2.15328895e-02f, -1.20773844e-01f, 9.04721841e-02f, -8.80423486e-02f, 6.63913190e-02f, -1.87537581e-01f, 1.21776886e-01f,
  1.05418392e-01f, -7.28984326e-02f, 2.04037249e-01f, -2.70494353e-03f, 2.04483256e-01f, -1.70616105e-01f, -2.47120813e-01f, -8.93986598e-02f, 1.56973675e-01f, -2.77583972e-02f,
  1.66452438e-01f, 2.00563610e-01f, -1.24982290e-01f, 2.34542221e-01f, -3.81195539e-04f, 3.83698009e-02f, 1.14938043e-01f, 4.44019213e-02f, -1.26621768e-01f, 5.83329126e-02f,
  -6.19449355e-02f, 8.40128958e-02f, 7.17276484e-02f, 2.53043566e-02f, 2.68025156e-02f, 1.66821748e-01f, 1.17396027e-01f, -5.76029234e-02f, 2.50156343e-01f, 7.34939054e-02f,
  9.76676270e-02f, -8.21463317e-02f, -1.35059446e-01f, 4.84352931e-02f, 8.70880764e-03f, -2.70895977e-02f, -6.77184910e-02f, 2.52560042e-02f, 1.16028592e-01f, -9.58176032e-02f,
  -2.64378369e-01f, 1.83281243e-01f, 1.16653152e-01f, 1.16289251e-01f, -7.66462460e-02f, -8.51086378e-02f, 1.54977113e-01f, -2.89603285e-02f, 1.32717993e-02f, -2.72263944e-01f,
  -6.26061996e-03f, -1.51987210e-01f, 2.41689667e-01f, -1.65173426e-01f, -1.34977058e-01f, 1.91308364e-01f, 1.32174075e-01f, -1.97758839e-01f, 1.07424587e-01f, -2.81435281e-01f,
  1.91744715e-02f, 2.41414040e-01f, 2.79224664e-01f, -9.28999707e-02f, -2.13537961e-01f, 2.10637614e-01f, 2.97769271e-02f, 5.99403121e-02f, -7.48858154e-02f, 4.57810387e-02f,
  3.34612690e-02f, 2.59567767e-01f, -3.66728529e-02f, 1.99415192e-01f, -1.49977012e-02f, -7.00750574e-02f, -1.96066961e-01f, -2.01696068e-01f, -5.48182130e-02f, 4.19690646e-02f,
  1.26097351e-01f, 8.28311667e-02f, 1.20794356e-01f, 2.18930125e-01f, -2.37548072e-02f, -8.51673335e-02f, -9.53228027e-02f, -2.14545871e-03f, -1.71812981e-01f, -7.21042827e-02f,
  -1.02261469e-01f, 1.68870762e-01f, 9.94299203e-02f, 1.43803820e-01f, 1.06795214e-01f, -4.01699133e-02f, 8.82419944e-03f, -1.23746194e-01f, 3.04904222e-01f, 3.04520667e-01f,
  -8.94669592e-02f, -4.07933183e-02f, 1.29556963e-02f, 3.25495303e-01f, 1.06240593e-01f, 1.20238200e-01f, 1.10532634e-01f, 1.33611307e-01f, 1.80310726e-01f, 4.05691285e-03f,
  2.18383238e-01f, -3.81928049e-02f, -6.76125148e-03f, 1.67802230e-01f, -2.29820013e-02f, -1.18625343e-01f, 4.58260663e-02f, 2.66043730e-02f, -2.25449400e-03f, 1.79827139e-02f,
  1.34369090e-01f, 1.53963149e-01f, -1.19344130e-01f, 1.53116428e-03f, 3.47830981e-01f, -6.56644925e-02f, -1.67121232e-01f, 1.88788194e-02f, 1.11209117e-01f, 2.08397448e-01f,
  -1.44845724e-01f, -4.27236333e-02f, 1.04374878e-01f, 2.52996087e-01f, 1.66959494e-01f, -2.23400015e-02f, 7.66249597e-02f, -1.23273082e-01f, -2.37848777e-02f, -1.01856217e-01f,
  2.39643693e-01f, 1.56596571e-01f, 1.71228815e-02f, 2.52527297e-01f, -4.42414433e-02f, -4.05232906e-02f, 1.64361984e-01f, -5.93036078e-02f, -1.14720359e-01f, 1.02357984e-01f,
  1.23595215e-01f, -6.70605106e-03f, 1.53452694e-01f, 1.79981768e-01f, 2.12208390e-01f, -2.23611474e-01f, 6.42127544e-03f, 2.87747085e-02f, 4.51081358e-02f, 1.47389427e-01f,
  -1.70319751e-01f, 1.22491032e-01f, -2.85647698e-02f, -1.05730243e-01f, 5.63803827e-03f, -1.32459015e-01f, 1.88972235e-01f, -1.75129995e-02f, -6.91023171e-02f, -8.99908915e-02f,
  4.60724086e-02f, 1.10171556e-01f, 6.41910732e-03f, -1.02242976e-01f, -2.83919685e-02f, 5.19733541e-02f, -5.25683723e-02f, -1.39478967e-01f, 2.09872454e-01f, 2.98541542e-02f,
  1.82640001e-01f, -5.94268329e-02f, 1.19150400e-01f, -9.47175920e-03f, 3.90589386e-02f, -1.02301747e-01f, 4.86988835e-02f, 7.23452196e-02f, -3.71709242e-02f, 7.44989514e-02f,
  1.46956995e-01f, 2.37694802e-03f, -2.35411152e-01f, 4.34460491e-02f, 1.54560804e-01f, 9.69293788e-02f, -1.60348177e-01f, -3.29724461e-01f, -2.20189288e-01f, 2.72941161e-02f,
  -3.42346989e-02f, 1.14004239e-01f, 1.62263200e-01f, 5.65207414e-02f, -1.96691290e-01f, -2.77286135e-02f, -3.16099524e-02f, 7.96645805e-02f, 4.97726388e-02f, 1.51775077e-01f,
  9.87795144e-02f, 3.63758914e-02f, 8.67800936e-02f, -3.35871391e-02f, 2.08727777e-01f, 9.22875032e-02f, 1.47874534e-01f, 1.46549895e-01f, 2.02819079e-01f, -1.86978295e-01f,
  1.13132164e-01f, -8.66701379e-02f, 1.04345575e-01f, -2.38383800e-01f, 2.95203719e-02f, 3.02748889e-01f, 1.38671696e-01f, 1.50703549e-01f, -5.61251938e-02f, 1.33068830e-01f,
  9.34558883e-02f, 1.93123966e-01f, -6.57566041e-02f, -4.53516059e-02f, 1.08389102e-01f, 2.30332971e-01f, 7.03722658e-03f, -1.72645710e-02f, -4.34762873e-02f, -7.70808682e-02f,
  -4.53300402e-02f, -1.60918429e-01f, 2.55837053e-01f, 8.70588496e-02f, -5.44662252e-02f, -5.60299642e-02f, -3.14114988e-02f, -4.52255532e-02f, 1.47698149e-01f, -1.11706078e-01f,
  1.63544521e-01f, -8.54834467e-02f, 2.70642657e-02f, 2.13013008e-01f, 1.84880808e-01f, -8.98395553e-02f, -1.94085613e-01f, 2.26187155e-01f, 2.12284356e-01f, 1.34610310e-01f,
  -1.74775153e-01f, -3.29126157e-02f, -5.20128645e-02f, 7.55512416e-02f, -1.47011429e-02f, -4.18736003e-02f, 3.85822766e-02f, -7.05961778e-04f, 8.21052939e-02f, -1.62082747e-01f,
  5.59103191e-02f, 1.07240446e-01f, 1.48219600e-01f, 9.72035006e-02f, 2.03545749e-01f, 2.68353283e-01f, 1.38942048e-01f, 1.33057786e-02f, 1.28650919e-01f, 8.64755660e-02f,
  1.40230861e-02f, -7.52620474e-02f, 1.69453919e-01f, -2.79593375e-02f, -9.02391449e-02f, 3.54524404e-02f, 1.88478142e-01f, 1.44385502e-01f, -4.66196053e-02f, 3.56891751e-02f,
  -8.64248350e-02f, -7.73343667e-02f, 2.19834328e-01f, 1.50947914e-01f, -2.12130532e-01f, -8.62846673e-02f, 1.87409054e-02f, -9.70609039e-02f, 2.92881578e-02f, 2.52728939e-01f,
  1.72177982e-02f, 1.94511246e-02f, -4.12393473e-02f, 1.54542252e-01f, -9.24123973e-02f, -7.61769339e-02f, 1.58249661e-01f, 1.09373249e-01f, 1.60185531e-01f, -1.13473520e-01f,
  1.18331306e-01f, 2.71520346e-01f, -6.21467270e-03f, 1.14394657e-01f, 2.75656670e-01f, 1.40449759e-02f, -1.88559994e-01f, -4.64041717e-02f, 2.48763204e-01f, -2.14663923e-01f,
  -2.24485397e-01f, 1.61400735e-01f, -1.53596267e-01f, 2.67869234e-01f, 1.77532360e-02f, -6.98194057e-02f, -2.64883153e-02f, 1.02848060e-01f, -3.56728621e-02f, 2.64849007e-01f,
  -1.29355669e-01f, 1.11127764e-01f, 3.16981389e-03f, -2.16155112e-01f, 2.21717298e-01f, 6.45844638e-02f, 9.82229933e-02f, 2.28067398e-01f, -3.83229554e-02f, 2.07858577e-01f,
  -2.23274361e-02f, -1.02018461e-01f, -1.85181741e-02f, 1.06003672e-01f, -1.06255926e-01f, 7.96978921e-02f, 1.00630164e-01f, 6.68179244e-02f, 2.72099048e-01f, -1.50190309e-01f,
  -9.36510134e-03f, -3.06968719e-01f, 1.56626686e-01f, 3.46724391e-02f, 2.93917246e-02f, 1.81129873e-01f, 3.11733149e-02f, 1.85280949e-01f, 7.92805627e-02f, 6.42953441e-02f,
  -3.87274660e-02f, 2.51761973e-01f, 4.29862998e-02f, -5.06236479e-02f, 1.25455588e-01f, 1.13569014e-01f, 1.07154518e-01f, -8.58048871e-02f, -1.63295895e-01f, 7.96057433e-02f,
  1.01349726e-01f, -6.62243664e-02f, -7.73335993e-02f, -1.17290579e-01f, -1.33354917e-01f, 4.10261098e-04f, 8.82043242e-02f, 7.36227185e-02f, 8.91612191e-03f, -5.09384386e-02f,
  1.68579862e-01f, 1.08213432e-01f, 2.54610062e-01f, 3.48631963e-02f, 3.90121341e-02f, 1.41566768e-01f, 1.48566708e-01f, 8.93168002e-02f, -1.23339243e-01f, 3.46503034e-02f,
  7.81041458e-02f, 2.49759093e-01f, 1.24130063e-01f, -6.20927960e-02f, -2.45639551e-02f, -1.78216383e-01f, -7.56332576e-02f, -4.40474935e-02f, 6.95545450e-02f, 7.04684108e-02f,
  6.78477958e-02f, 6.07486032e-02f, 1.09074891e-01f, 2.28758872e-01f, -1.64145395e-01f, -2.36623380e-02f, -1.95447430e-01f, -1.65149048e-01f, -1.62405789e-01f, -1.74264729e-01f,
  -9.80336890e-02f, -2.78550275e-02f, 1.61799744e-01f, 1.89775914e-01f, 1.55323446e-01f, 1.62789240e-01f, -3.95077206e-02f, 1.12753026e-01f, 1.32915797e-02f, 5.61104231e-02f,
  2.05943108e-01f, 1.70644209e-01f, -2.13238582e-01f, -1.19534954e-01f, -5.78807183e-02f, 2.05031149e-02f, -1.22431926e-01f, 2.15913311e-01f, 2.78332196e-02f, 1.05605535e-01f,
  7.00306073e-02f, 1.28009170e-01f, -1.05649084e-01f, -1.39362425e-01f, 1.19420193e-01f, -3.87404077e-02f, -1.54745653e-01f, -1.83601499e-01f, 3.09305433e-02f, 1.28288001e-01f,
  6.57419786e-02f, 1.20632596e-01f, -4.53793630e-02f, 5.33752516e-02f, -1.08605064e-02f, 5.47521096e-03f, 8.43253583e-02f, -4.05020751e-02f, -1.67705849e-01f, -4.58007939e-02f,
  -1.22298889e-01f, 2.21190024e-02f, 5.33206314e-02f, 2.76053160e-01f, 2.10914180e-01f, 1.46491215e-01f, 1.28890900e-02f, 7.51655400e-02f, -2.81266440e-02f, 7.71409273e-02f,
  1.76727355e-01f, -9.35458764e-02f, -8.25001299e-02f, 7.98895285e-02f, 9.18309316e-02f, 1.62828699e-01f, 9.65871066e-02f, -9.13516730e-02f, 2.07054913e-01f, 4.53871451e-02f,
  2.00269356e-01f, 9.30435583e-02f, 2.57116765e-01f, 2.23466009e-01f, 1.56667337e-01f, -2.67905742e-01f, 3.91900949e-02f, -2.19377786e-01f, -1.15181834e-01f, 3.03472392e-02f,
  9.04434696e-02f, 2.26059183e-01f, -8.20283443e-02f, -2.41037626e-02f, 1.01091349e-02f, -5.15791550e-02f, 1.95722710e-02f, -1.53538197e-01f, -4.05307300e-02f, -1.11672796e-01f,
  2.10323930e-02f, -1.36710510e-01f, -2.28729099e-01f, 2.42004231e-01f, -6.83335140e-02f, -8.74869749e-02f, -5.95542155e-02f, 1.19556539e-01f, 4.14400436e-02f, 2.13873491e-01f,
  8.71714428e-02f, -5.66087887e-02f, 1.78377613e-01f, 1.74099177e-01f, -1.09096222e-01f, -1.20973013e-01f, 1.42554283e-01f, -1.04863919e-01f, -1.66724682e-01f, 2.23862261e-01f,
  1.74186215e-01f, 9.23142433e-02f, -5.68920448e-02f, -4.50873226e-02f, 2.81348109e-01f, -1.30514219e-01f, 3.31732333e-02f, -2.07139850e-01f, -2.21347764e-01f, 1.11043975e-01f,
  1.01273611e-01f, 1.41627043e-01f, 1.23109184e-01f, 8.56329035e-03f, -1.30099520e-01f, 6.11757264e-02f, 1.35945380e-01f, -5.89689724e-02f, 1.66742101e-01f, 1.97901502e-01f,
  1.21542975e-01f, 2.22431496e-01f, 7.43004382e-02f, -1.32794246e-01f, -3.67684029e-02f, 5.09153679e-02f, -7.83315450e-02f, -1.75989658e-01f, -2.82288790e-02f, 1.60885323e-02f,
  2.00587928e-01f, -8.65927190e-02f, -1.28524303e-01f, -2.87564933e-01f, 1.68374032e-01f, 1.77655041e-01f, -8.73146653e-02f, 1.10342406e-01f, -2.93443035e-02f, 2.15776637e-01f,
  -1.02044791e-01f, 2.48000979e-01f, 6.05306551e-02f, -4.51485887e-02f, -3.67203131e-02f, -9.55089033e-02f, 1.30091339e-01f, 2.22732261e-01f, -9.10967067e-02f, -1.89725429e-01f,
  -1.73311442e-01f, 1.87817588e-01f, 4.91023511e-02f, 2.27248240e-02f, -1.41332418e-01f, 1.79037735e-01f, 1.46724507e-02f, 1.39374301e-01f, -9.38592330e-02f, -7.75347799e-02f,
  8.48085657e-02f, -1.32129475e-01f, 2.48364992e-02f, 3.68516636e-03f, 1.91988289e-01f, -1.98630840e-02f, -1.65527880e-01f, 1.78472966e-01f, 2.39732698e-01f, -4.14119065e-02f,
  -4.76873368e-02f, 1.06753558e-01f, 4.21220697e-02f, 2.30366245e-01f, 2.88642108e-01f, -2.30495203e-02f, -4.39285375e-02f, -2.06526801e-01f, 1.55571759e-01f, 1.13587759e-01f,
  1.55287623e-01f, -1.17573589e-01f, 1.15349434e-01f, -1.38156950e-01f, -7.01575056e-02f, 3.22731167e-01f, 7.81218186e-02f, -6.81069866e-02f, 2.93770805e-02f, -9.19222385e-02f,
  -5.75719029e-02f, 2.24395078e-02f, 1.29411131e-01f, 6.06981292e-02f, -1.59791484e-01f, 1.64402813e-01f, 1.21359438e-01f, 2.27158412e-01f, -1.03028364e-01f, 6.24794811e-02f,
  1.47785336e-01f, -1.03774831e-01f, 1.79565817e-01f, -2.17538122e-02f, 8.46699532e-03f, -7.20254704e-02f, -7.80262006e-03f, -1.06059670e-01f, -7.85438344e-02f, 1.07815869e-01f,
  -3.10310684e-02f, 1.30836040e-01f, -6.50544092e-02f, 1.25228167e-01f, 1.14245474e-01f, -1.34361044e-01f, 6.14974648e-03f, 1.68344900e-01f, -9.00068730e-02f, -8.36172234e-03f,
  8.36497024e-02f, -5.12842350e-02f, 2.52444502e-02f, 2.17434078e-01f, -2.79911701e-02f, 7.37234131e-02f, 1.02921076e-01f, -1.78897768e-01f, -8.46627429e-02f, -1.48777636e-02f,
  8.79166499e-02f, 1.80738531e-02f, -2.27713212e-01f, 1.73882842e-01f, 1.08643472e-01f, 1.92759514e-01f, 1.18125372e-01f, -5.60239255e-02f, 1.51057998e-02f, 1.17440805e-01f,
  6.23296499e-02f, 1.09899297e-01f, -6.61660656e-02f, 9.00197849e-02f, -7.22884387e-02f, 1.50305346e-01f, 1.89491622e-02f, 6.97076842e-02f, -1.14732534e-01f, 4.62073386e-02f,
  1.77771598e-01f, 2.66890116e-02f, -6.30924702e-02f, -2.73121111e-02f, 1.21936752e-02f, 1.49668157e-01f, 1.18927807e-02f, 9.45831016e-02f, -2.55713552e-01f, -7.84321129e-02f,
  -2.38094866e-01f, 1.01387650e-01f, 1.23084292e-01f, -1.01271085e-01f, -7.03647733e-02f, 7.87203088e-02f, 6.26015365e-02f, -1.17864780e-01f, -1.56073375e-02f, -2.52764788e-03f,
  8.31891373e-02f, -8.00235942e-02f, 1.65853146e-02f, -1.83343828e-01f, -6.12700656e-02f, 8.15994143e-02f, -9.17031243e-02f, -1.21208034e-01f, -1.17769755e-01f, -1.80954428e-03f,
  -1.08830824e-01f, -4.02337871e-02f, 1.20475009e-01f, -6.83442876e-02f, 4.63180803e-02f, 5.87102026e-02f, -1.41023740e-01f, 1.63320005e-01f, -8.20086896e-02f, 8.44004229e-02f,
  -9.00563300e-02f, -2.34377742e-01f, -5.13294078e-02f, -1.39500514e-01f, 2.16718823e-01f, -1.18229054e-01f, -2.34033033e-01f, 1.94492340e-02f, 1.06077321e-01f, 9.55019817e-02f,
  -1.66647527e-02f, -1.96253091e-01f, -4.18376215e-02f, 8.79491270e-02f, -1.63475841e-01f, 1.96969166e-01f, -1.28941610e-01f, 2.67196875e-02f, 1.03360675e-01f, -1.15036359e-02f,
  -1.12810060e-01f, -2.04495326e-01f, -1.56358659e-01f, 6.70941025e-02f, -2.94249244e-02f, 1.59187883e-01f, 1.12519942e-01f, 5.00697196e-02f, 1.66499778e-03f, 9.10362378e-02f,
  9.69919562e-02f, 1.05091833e-01f, 9.77276862e-02f, -1.15864076e-01f, -1.39667526e-01f, 4.98534553e-03f, 3.69320661e-02f, 7.38707259e-02f, 8.12048465e-02f, 1.53357252e-01f,
  2.78763603e-02f, 2.20729172e-01f, -1.10103846e-01f, -9.50437263e-02f, 2.24107087e-01f, 3.12607572e-03f, -1.89610183e-01f, 7.14592785e-02f, 1.48613572e-01f, -2.83052158e-02f,
  -1.35334671e-01f, -1.67074427e-01f, -2.43425295e-01f, 1.59046426e-01f, -4.30091731e-02f, -7.12879607e-03f, -5.12666292e-02f, 1.92360833e-01f, 1.96113288e-01f, 7.46540353e-02f,
  -1.71653450e-01f, 1.19597428e-01f, 1.13902688e-01f, 6.53532743e-02f, -1.36894405e-01f, -1.72684848e-01f, 2.13535085e-01f, -2.45293364e-01f, -2.47348510e-02f, 1.00604005e-01f,
  3.78936492e-02f, 2.85293102e-01f, -3.00298966e-02f, -2.20092669e-01f, 9.93355140e-02f, 9.48797017e-02f, -4.16526990e-03f, -6.57241717e-02f, -2.22050808e-02f, 2.27256387e-01f,
  -5.93933910e-02f, 1.20931372e-01f, 2.43319318e-01f, -1.01820566e-01f, -1.23714663e-01f, -1.00985304e-01f, -1.94840714e-01f, 3.19131017e-02f, 1.57583907e-01f, 8.91414508e-02f,
  1.32593557e-01f, 1.34852573e-01f, 6.61481991e-02f, 6.12567775e-02f, 1.00504354e-01f, -1.61934793e-01f, -7.14754835e-02f, -1.87143505e-01f, -1.67503253e-01f, -1.66966081e-01f,
  -4.50578108e-02f, 3.99781056e-02f, 2.54047334e-01f, 1.92375079e-01f, -6.59721941e-02f, -1.21164449e-01f, 2.70101458e-01f, 1.99411929e-01f, 3.88805903e-02f, 5.35582043e-02f,
  2.62312889e-01f, -4.59636860e-02f, 1.32687520e-02f, -1.33611649e-01f, 2.32114553e-01f, -8.39448348e-02f, 1.53400749e-01f, 1.47030026e-01f, -5.33423349e-02f, 1.73033383e-02f,
  1.58831552e-01f, 2.53756136e-01f, 1.03205383e-01f, -2.63768941e-01f, 2.35781968e-01f, -2.78965592e-01f, 1.05241358e-01f, -1.28867000e-01f, 1.10517666e-01f, 2.07023591e-01f,
  2.05267407e-02f, 2.02066287e-01f, 6.71226233e-02f, 1.83298513e-01f, 1.37382597e-01f, -6.87205940e-02f, -2.52167676e-02f, -2.10780755e-01f, -7.90996775e-02f, -4.14991342e-02f,
  1.40974939e-01f, 9.83364582e-02f, 2.65897185e-01f, -1.92292720e-01f, -2.98233032e-02f, 2.22946927e-01f, 4.78375927e-02f, 2.11626306e-01f, 1.97984800e-02f, 5.73939420e-02f,
  1.93271473e-01f, -1.60228193e-01f, -6.38680346e-03f, -5.13631366e-02f, -2.47190848e-01f, -1.73004046e-01f, -1.51870906e-01f, -8.89476240e-02f, 4.78275530e-02f, -6.76770657e-02f,
  2.25491636e-02f, 1.38475090e-01f, 1.18270956e-01f, 1.37076885e-01f, -4.54631448e-02f, 7.11624650e-03f, -1.23341940e-01f, 5.35618253e-02f, 1.00207008e-01f, 9.85791385e-02f,
  7.51965865e-02f, -1.84004843e-01f, 5.77751100e-02f, -1.72289774e-01f, 6.51944354e-02f, 2.19841123e-01f, 1.77279729e-02f, 2.06779927e-01f, -6.47115931e-02f, 1.78254247e-01f,
  1.97361156e-01f, -1.01167820e-01f, 2.05869779e-01f, 1.81797668e-02f, -6.53434098e-02f, -1.11115858e-01f, 1.28671110e-01f, 2.38561958e-01f, -4.79626209e-02f, -2.19211285e-03f,
  1.93471804e-01f, -1.59956187e-01f, -5.32351136e-02f, 1.59474134e-01f, -2.64536627e-02f, 1.43803388e-01f, 2.58953143e-02f, 4.02454585e-02f, -7.95487687e-03f, 6.59810901e-02f,
  -6.24204315e-02f, 6.62371591e-02f, 2.36699134e-01f, 1.61023840e-01f, 1.65477917e-01f, 2.12219968e-01f, -9.93685424e-02f, 6.31158799e-02f, 1.76292837e-01f, 9.81428623e-02f,
  -1.09332502e-01f, -2.72543449e-02f, 1.00620668e-02f, -2.06624041e-03f, -7.56135136e-02f, 2.55240276e-02f, -5.47815524e-02f, -1.45830167e-02f, 7.19857588e-02f, -3.60504873e-02f,
  -9.08329189e-02f, -7.37910122e-02f, -1.13406174e-01f, -3.32132317e-02f, 6.16218783e-02f, -9.85793993e-02f, -3.82862948e-02f, -7.58494511e-02f, 1.24950498e-01f, -1.02589682e-01f,
  -1.20065641e-03f, 8.63062963e-02f, -6.60415217e-02f, 2.67578512e-01f, -1.93439424e-01f, 1.40178606e-01f, -1.38988579e-02f, -1.08281346e-02f, -8.29219073e-02f, -8.59493390e-02f,
  1.30670995e-01f, 1.76442444e-01f, -1.49570662e-03f, 3.52003761e-02f, -1.02262504e-01f, 3.61799449e-02f, 1.93648227e-02f, 2.00884894e-01f, -1.17549017e-01f, 1.05163455e-02f,
  2.45855357e-02f, 6.22844622e-02f, -7.06831440e-02f, 2.39297897e-01f, -1.62980989e-01f, 1.66943684e-01f, 9.33035314e-02f, 1.69770233e-02f, 7.67310616e-03f, 5.19803129e-02f,
  -2.22839460e-01f, 2.21873634e-02f, -1.46360800e-01f, -1.12715244e-01f, 1.89040944e-01f, 2.12269500e-01f, 8.75938088e-02f, -4.34688888e-02f, 1.66803733e-01f, -1.10733084e-01f,
  -2.27088295e-02f, 1.26470208e-01f, 2.26551995e-01f, 1.35547832e-01f, 2.20127180e-01f, -1.12297691e-01f, -1.17699660e-01f, -1.30763561e-01f, -5.51402420e-02f, 1.69368833e-01f,
  -7.61325508e-02f, -4.41124849e-02f, -6.78324774e-02f, 8.48688483e-02f, -1.34697795e-01f, -2.25983381e-01f, -1.00138962e-01f, 3.87319997e-02f, 2.58396477e-01f, -1.16788037e-01f,
  -5.06031560e-03f, -1.58339038e-01f, 1.49640769e-01f, 1.07563734e-01f, -8.46763849e-02f, 1.77707285e-01f, 1.41373441e-01f, 1.93783551e-01f, -1.36632681e-01f, 5.82165681e-02f,
  8.66002869e-03f, -3.49127539e-02f, -1.53967142e-01f, 9.10075307e-02f, 1.15975961e-01f, 1.89453810e-01f, 1.28850669e-01f, 1.08249106e-01f, -4.80078012e-02f, 7.04139145e-03f,
  -1.93651039e-02f, -3.37975360e-02f, -8.13948587e-02f, 6.53996095e-02f, -6.30015135e-02f, 1.66495785e-01f, 1.01234838e-01f, 1.65241256e-01f, -1.20968306e-02f, 1.14250287e-01f,
  7.25771347e-03f, 3.14076357e-02f, 1.39447441e-02f, -2.35000730e-01f, -1.71160325e-01f, 1.38212308e-01f, -3.47395800e-02f, 3.59731615e-02f, 3.18883285e-02f, 2.41925269e-01f,
  2.53609806e-01f, 8.33001658e-02f, 1.33166701e-01f, 8.92493650e-02f, -2.01449528e-01f, 4.40219976e-02f, 2.08562046e-01f, 1.29908979e-01f, 1.38032481e-01f, -1.02772415e-01f,
  -6.90808594e-02f, -1.46039248e-01f, -6.52267933e-02f, 2.69569397e-01f, 1.50899626e-02f, 5.56407943e-02f, -2.37986743e-02f, 2.10105479e-01f, 2.00863898e-01f, 1.48547456e-01f,
  1.72379658e-01f, -2.59754062e-02f, -1.14113845e-01f, -1.89116284e-01f, -1.71943218e-01f, 9.60092098e-02f, 2.13168636e-01f, 2.72656590e-01f, -1.46951243e-01f, -5.62174246e-02f,
  3.47339153e-01f, 7.87951425e-02f, -1.31546244e-01f, -2.50769734e-01f, 6.67275861e-03f, 3.19415182e-02f, -1.11878574e-01f, 1.32733628e-01f, -1.91783365e-02f, 1.61796436e-01f,
  -1.78387225e-01f, 9.03913602e-02f, -2.98687667e-01f, -2.04074513e-02f, 1.54381722e-01f, 1.34453088e-01f, 1.46564335e-01f, 8.17029625e-02f, 2.14320779e-01f, 2.13184744e-01f,
  -3.74695212e-02f, 2.10644811e-01f, 7.72431791e-02f, 3.75191458e-02f, -1.97391510e-01f, 1.04050532e-01f, 2.72742242e-01f, -2.83853114e-01f, -1.23909242e-01f, -8.12308304e-03f,
  1.12936579e-01f, 3.35091114e-01f, 1.20295383e-01f, -5.55649512e-02f, 1.11507669e-01f, 2.05888860e-02f, -6.53848518e-03f, 2.68011183e-01f, -1.95588544e-01f, 1.31748095e-01f,
  -6.97677433e-02f, -1.06935851e-01f, 6.07630163e-02f, -8.11653063e-02f, 9.11791399e-02f, 1.15842409e-01f, -1.89645216e-01f, 2.88796782e-01f, 3.73433717e-02f, 9.13120210e-02f,
  1.20560400e-01f, 9.73198935e-02f, 1.33222848e-01f, 1.28561080e-01f, 2.68205136e-01f, 1.53673932e-01f, -8.17778409e-02f, 1.47110432e-01f, 1.05663640e-02f, 2.53549993e-01f,
  3.18428315e-02f, -9.09977313e-03f, 9.36067626e-02f, 3.36125530e-02f, -5.98054705e-03f, -2.43498787e-01f, 1.67450458e-01f, 1.10123947e-01f, -1.43008694e-01f, 1.94601774e-01f,
  1.97050139e-01f, 5.17906174e-02f, -1.42949015e-01f, -1.08176932e-01f, 1.14751784e-02f, 1.24969274e-01f, 3.66108082e-02f, -2.34587789e-02f, 3.83328721e-02f, 4.97869030e-03f,
  5.77917099e-02f, -1.11023255e-01f, 1.38579234e-01f, 1.13375364e-02f, 2.06938684e-01f, 2.14239769e-02f, 2.62528285e-02f, 7.07058236e-02f, 6.77723289e-02f, -6.82732165e-02f,
  -5.08891344e-02f, 1.46429846e-02f, 9.60217882e-03f, 1.83195576e-01f, -4.61456291e-02f, 1.36003301e-01f, -7.40676671e-02f, -1.11929923e-01f, 8.46873745e-02f, -8.88082311e-02f,
  -2.46102601e-01f, 1.01791538e-01f, 1.21378146e-01f, 2.48469010e-01f, -1.92559987e-01f, -6.41479865e-02f, -1.50457367e-01f, 3.15736473e-01f, 1.90581918e-01f, 1.98827744e-01f,
  -8.51798523e-03f, -2.45123595e-01f, -5.13074808e-02f, 1.45574585e-01f, -7.36367479e-02f, 1.49057791e-01f, 8.92343894e-02f, 2.27108702e-01f, 2.61719555e-01f, 1.75442863e-02f,
  -2.44697273e-01f, -7.30088130e-02f, 1.10937925e-02f, 2.88770914e-01f, 8.08165595e-03f, 2.27347121e-01f, 4.55913506e-02f, -2.25774967e-03f, 1.74503803e-01f, -2.02589482e-01f,
  9.26317647e-02f, 4.22684029e-02f, 8.36210996e-02f, 3.21766064e-02f, 3.19484249e-02f, 2.02249929e-01f, -2.11965024e-01f, 6.51390329e-02f, 7.92668313e-02f, 5.74979261e-02f,
  2.11916983e-01f, -2.14112531e-02f, 3.60850170e-02f, 6.71064034e-02f, -5.46117015e-02f, 1.95225552e-01f, 1.74411014e-01f, -1.95329472e-01f, 5.34267165e-02f, 5.83075248e-02f,
  2.41360143e-01f, 2.55187422e-01f, 1.19628944e-03f, 5.36715351e-02f, 2.38249861e-02f, 2.50964046e-01f, 2.68194377e-01f, -1.18053071e-01f, -6.76008761e-02f, 3.15711796e-01f,
  -1.49297612e-02f, -1.73681974e-01f, -1.76438466e-01f, -1.10165052e-01f, -4.80592549e-02f, 7.67515972e-02f, 1.75270975e-01f, 3.07990938e-01f, -2.43470460e-01f, 7.56361708e-02f,
  2.72769853e-02f, 3.34770352e-01f, 2.02318102e-01f, 8.83388221e-02f, -3.03121340e-02f, -1.81678429e-01f, -1.30793611e-02f, -9.61804464e-02f, -1.61911607e-01f, -1.76578704e-02f,
  -1.06969573e-01f, -1.09957114e-01f, -9.26610231e-02f, -1.38766780e-01f, 1.17745101e-01f, -8.31558034e-02f, -1.25581309e-01f, -9.40675661e-02f, 3.15844752e-02f, 8.17342568e-03f,
  -9.65798944e-02f, 4.59168889e-02f, 1.70192823e-01f, 1.04777567e-01f, -5.97957112e-02f, 2.23805849e-03f, 1.65265482e-02f, 6.74420819e-02f, 4.79754759e-03f, -2.58565038e-01f,
  1.22757792e-01f, 1.37116551e-01f, -3.24855410e-02f, -3.62352915e-02f, 7.25188404e-02f, 1.53218791e-01f, -1.17009789e-01f, 1.14271507e-01f, 1.96536910e-02f, 1.60043597e-01f,
  1.18384305e-02f, 1.99555397e-01f, 6.93258494e-02f, 1.76996831e-02f, -3.20737571e-01f, 1.01756960e-01f, 1.22177921e-01f, -9.04550478e-02f, -8.11328590e-02f, 2.34053597e-01f,
  1.66434973e-01f, -7.75810406e-02f, 4.98256879e-03f, -2.70403236e-01f, -3.62557173e-02f, -5.20241959e-03f, -6.52153492e-02f, -5.28402589e-02f, 1.46195322e-01f, -3.35886300e-01f,
  8.71237367e-02f, -3.44588682e-02f, 2.55147845e-01f, 3.11302952e-02f, -1.39100673e-02f, 8.33005831e-02f, -1.58306316e-01f, -3.19838561e-02f, 8.98776725e-02f, 6.35757297e-03f,
  4.59189750e-02f, -1.00728787e-01f, 3.83912250e-02f, -9.40042809e-02f, 5.08501865e-02f, 1.48394316e-01f, 1.97138160e-01f, -1.05995603e-01f, 1.04002021e-01f, 2.99497284e-02f,
  1.77895218e-01f, -1.02303796e-01f, -2.34188735e-01f, 1.69311717e-01f, 5.12538850e-02f, 6.16171099e-02f, 1.27805220e-02f, 4.90833558e-02f, -2.13262322e-03f, -1.18877329e-01f,
  -2.07376659e-01f, -4.20884490e-02f, -6.31948095e-03f, 2.69174665e-01f, -2.23747507e-01f, 9.81741771e-02f, 3.36290412e-02f, 1.61925286e-01f, -2.48825662e-02f, -1.30527705e-01f,
  3.33927542e-01f, 4.35172021e-02f, 1.43931597e-01f, -7.79832304e-02f, -9.01520997e-02f, 4.29850370e-02f, 2.26660147e-01f, 4.91040014e-02f, 2.85970509e-01f, -1.35056272e-01f,
  -3.68995965e-02f, 1.33144110e-01f, 9.35102776e-02f, -1.48075476e-01f, -2.53969431e-01f, 1.88449681e-01f, 1.45998582e-01f, 3.75639126e-02f, -1.74716204e-01f, -4.02026949e-03f,
  -1.11694932e-01f, 2.03957558e-01f, -2.15946250e-02f, 1.47670358e-01f, 1.01695433e-01f, 9.86213908e-02f, -7.89283682e-03f, -8.32489207e-02f, -3.01114898e-02f, 2.40778640e-01f,
  2.60013700e-01f, 2.58420467e-01f, 1.25413716e-01f, 1.91745505e-01f, -1.78744346e-01f, -1.40027525e-02f, -6.51357323e-02f, 2.25475337e-02f, 4.50568311e-02f, 1.09775573e-01f,
  2.62046307e-02f, -2.82119721e-01f, -2.43802473e-01f, 3.50889121e-03f, 7.88336396e-02f, 2.04391971e-01f, 2.14342698e-02f, 1.85443565e-01f, -1.14336669e-01f, -5.43273576e-02f,
  2.26533264e-02f, 8.86080638e-02f, -7.90848657e-02f, -4.16898355e-02f, -2.00165603e-02f, -1.28369927e-01f, -9.38481539e-02f, 1.12076081e-01f, -8.38915259e-02f, 6.28198758e-02f,
  -6.03411272e-02f, -1.24188140e-02f, 2.67328937e-02f, -1.16833620e-01f, 6.01106733e-02f, 1.43518597e-01f, -1.06505305e-01f, 2.15272605e-02f, 1.67025387e-01f, -1.04407363e-01f,
  2.68280413e-02f, 1.36854619e-01f, 2.86181793e-02f, 4.47792187e-03f, -3.07446010e-02f, 2.08136916e-01f, -2.12001964e-01f, 2.07657129e-01f, -1.08889110e-01f, -5.66335768e-03f,
  1.00782938e-01f, -1.38419926e-01f, -6.13190532e-02f, 1.78593799e-01f, 7.03454316e-02f, 4.37687105e-03f, 3.74205336e-02f, 7.45932385e-02f, 9.30143595e-02f, 3.14297643e-03f,
  7.66996518e-02f, 6.91286549e-02f, 5.90442568e-02f, 2.50055134e-01f, 2.86419570e-01f, 9.22041088e-02f, 5.95516637e-02f, 1.25349104e-01f, -6.19867072e-02f, -1.59561768e-01f,
  -9.14298818e-02f, -1.24011904e-01f, 2.57332679e-02f, 8.18003640e-02f, -9.97697115e-02f, -8.79395008e-02f, -5.15657887e-02f, -4.23096679e-02f, 5.20956889e-02f, -4.06701444e-03f,
  -1.46242231e-02f, 1.32405326e-01f, 2.02520728e-01f, 1.69161975e-01f, -6.19910918e-02f, -1.17939033e-01f, -1.05844870e-01f, 2.30980590e-01f, -1.15099527e-01f, 3.89461173e-03f,
  -3.39469425e-02f, 3.69530022e-02f, -2.12425739e-01f, 1.08375758e-01f, 6.95412531e-02f, 7.12573156e-02f, -2.84441821e-02f, -8.49397387e-03f, 2.91374102e-02f, -5.13096564e-02f,
  -2.61076421e-01f, 3.84759940e-02f, -7.28047490e-02f, -2.58809984e-01f, 1.17335744e-01f, 1.19971469e-01f, 9.53896642e-02f, 1.63452059e-01f, 2.86035351e-02f, 1.53727323e-01f,
  2.78350394e-02f, 2.17880681e-01f, -1.21652104e-01f, 1.52891591e-01f, 3.48772258e-02f, -6.26218170e-02f, 2.48651039e-02f, 1.93059564e-01f, 1.48067996e-01f, 7.48977214e-02f,
  -2.07052156e-02f, -1.48515642e-01f, 2.05655292e-01f, -7.72424974e-03f, 2.87190564e-02f, -7.24658892e-02f, 4.59735058e-02f, 3.00585210e-01f, 2.17612058e-01f, 1.28040239e-02f,
  1.98061779e-01f, -8.05048347e-02f, 1.31453499e-01f, 2.91671604e-02f, 1.03276856e-01f, -5.95723204e-02f, -7.55685791e-02f, -7.41603896e-02f, -8.59182142e-03f, 2.96804965e-01f,
  1.97789773e-01f, 2.16865361e-01f, -1.25970721e-01f, -1.06862091e-01f, 6.79001510e-02f, -1.00187017e-02f, 3.15762870e-02f, 7.15154335e-02f, 8.30239337e-03f, 3.62045616e-02f,
  -6.62599429e-02f, 1.28969520e-01f, -1.01366058e-01f, 2.03925982e-01f, 1.53600231e-01f, 5.90833127e-02f, 5.26427710e-03f, -1.48687452e-01f, 1.54053852e-01f, 2.21112162e-01f,
  -6.68010935e-02f, -8.31716880e-03f, -1.02757839e-02f, -2.55007833e-01f, 1.13326982e-01f, -1.37447119e-01f, -2.84289747e-01f, -2.14412194e-02f, 2.70050257e-01f, 5.55211417e-02f,
  6.58582225e-02f, -6.30135834e-02f, 1.97790191e-01f, 1.04457818e-01f, 7.91354105e-02f, -2.35375375e-01f, 1.21238366e-01f, 2.03684032e-01f, -3.17508169e-02f, 5.42682149e-02f,
  5.52010201e-02f, 1.81968719e-01f, 3.25800061e-01f, 1.81369081e-01f, -5.37618995e-02f, 1.36269972e-01f, -1.15344770e-01f, -2.14453220e-01f, -5.07195108e-02f, 1.26057699e-01f,
  -8.32442567e-02f, 3.64810713e-02f, -1.53999835e-01f, -4.13078554e-02f, 9.87549126e-02f, 8.13559145e-02f, 1.49700135e-01f, -8.17013811e-03f, 5.12014739e-02f, -6.01541586e-02f,
  -3.78113650e-02f, 1.24226294e-01f, -1.72941238e-01f, 1.06085137e-01f, -2.37167761e-01f, 8.10255110e-02f, -1.37050584e-01f, 9.99514759e-02f, 2.10820273e-01f, -2.04015762e-01f,
  3.41157988e-02f, 1.39832154e-01f, -4.36731540e-02f, -9.73028690e-02f, -9.07350704e-02f, -2.59076767e-02f, 1.69221550e-01f, -4.67897616e-02f, -2.85684653e-02f, -1.25261173e-01f,
  2.14992255e-01f, -8.45348015e-02f, 1.55262694e-01f, -2.19539881e-01f, -2.39119366e-01f, 3.17082219e-02f, -1.28844470e-01f, 1.41614959e-01f, 1.06782652e-01f, 9.46603529e-03f,
  -3.52790132e-02f, 1.56023651e-01f, 3.12311705e-02f, 2.60910690e-01f, -7.24226460e-02f, 2.25935847e-01f, 1.13629684e-01f, -2.53201693e-01f, -1.39680415e-01f, -2.01687813e-01f,
  1.37539640e-01f, 5.68680614e-02f, -8.06429014e-02f, 2.16304183e-01f, 7.64243230e-02f, 1.96452737e-01f, 8.42109248e-02f, -1.85255017e-02f, -3.32832821e-02f, -1.33807808e-01f,
  -2.01490611e-01f, 2.31680021e-01f, 1.48246646e-01f, 7.68217869e-05f, 2.53049769e-02f, -1.97689623e-01f, -1.18891276e-01f, -1.84104502e-01f, -9.73037258e-02f, 5.93258142e-02f,
  5.23501486e-02f, -5.08352630e-02f, 1.62045419e-01f, 1.23334359e-02f, 1.17762610e-01f, 5.52068986e-02f, -3.78256328e-02f, 1.70419961e-01f, -2.68181801e-01f, -1.96621045e-02f,
  -1.20817035e-01f, 1.92097649e-02f, 2.51888692e-01f, -2.24075913e-01f, -4.75785956e-02f, 1.17233194e-01f, 5.69937611e-03f, -4.24747393e-02f, 1.01563884e-02f, 1.86404362e-01f,
  1.53783381e-01f, 7.02122077e-02f, 1.20070063e-01f, -1.43259272e-01f, 8.97277370e-02f, -5.55978827e-02f, 1.63854286e-01f, -2.11948156e-01f, -1.46340027e-01f, 1.59507543e-01f,
  -1.50931180e-01f, 1.94018334e-02f, 7.89269283e-02f, 1.42075628e-01f, 1.40534997e-01f, 9.63775143e-02f, 4.55518737e-02f, 1.36176109e-01f, -8.18985775e-02f, 1.15368441e-01f,
  -1.02852201e-02f, -7.10460842e-02f, -1.20584540e-01f, -1.17456898e-01f, 1.95199504e-01f, 1.28474593e-01f, -2.06790194e-01f, 4.33417335e-02f, 1.26672775e-01f, 1.04409590e-01f,
  8.85827467e-02f, 2.08747424e-02f, 9.43684131e-02f, 5.92134111e-02f, -1.98341981e-01f, 1.03515647e-01f, -3.95835005e-02f, 6.17991686e-02f, 8.95582736e-02f, -6.00348264e-02f,
  -8.12169164e-02f, -1.16057664e-01f, 7.33546466e-02f, -1.30347580e-01f, -2.23182499e-01f, -2.35730663e-01f, -8.07198733e-02f, -2.30236754e-01f, 3.29876244e-02f, 8.64955038e-02f,
  3.68226804e-02f, -2.32499674e-01f, 5.54388389e-02f, -7.55661204e-02f, 1.25460938e-01f, -1.55971453e-01f, -3.15111876e-02f, 1.73642799e-01f, -1.48741081e-02f, 1.19881425e-03f,
  -8.62465799e-02f, 1.25437126e-01f, -1.36263981e-01f, 1.15559623e-01f, 1.02694042e-01f, -7.88485333e-02f, 1.29220366e-01f, 9.40284226e-03f, -1.14867203e-01f, 2.35068172e-01f,
  -7.95365050e-02f, -2.73543391e-02f, -1.16667086e-02f, 4.34996635e-02f, 2.02487841e-01f, 1.24248996e-01f, -1.18124984e-01f, -1.53190821e-01f, -7.41873160e-02f, -9.25676152e-02f,
  -2.43869983e-02f, 1.21423662e-01f, 5.00608124e-02f, -2.26106215e-02f, 1.51760921e-01f, 2.13800445e-01f, -5.22610545e-02f, 8.01386759e-02f, -2.71214455e-01f, 7.02022612e-02f,
  -3.35873254e-02f, -2.49881074e-01f, -7.38643706e-02f, 2.58655846e-01f, 2.51440763e-01f, 9.15023834e-02f, 2.14211076e-01f, -1.50980398e-01f, 7.35739917e-02f, -1.21958509e-01f,
  1.55813783e-01f, -1.00702636e-01f, -9.40769538e-02f, 2.95125991e-01f, 7.07613304e-02f, 2.14054491e-02f, 2.56968766e-01f, 1.95544392e-01f, 1.91635527e-02f, -1.67437911e-01f,
  3.61837558e-02f, -1.40888393e-01f, -1.05817817e-01f, -3.24955657e-02f, -2.75875945e-02f, -7.74919838e-02f, 1.53065294e-01f, 1.12689465e-01f, 1.24086656e-01f, -1.75490916e-01f,
  -1.44244611e-01f, 4.56796512e-02f, 2.30946466e-01f, 7.86251575e-02f, -1.67300537e-01f, -4.36094329e-02f, 5.84916547e-02f, 7.89681375e-02f, 6.07488528e-02f, 9.56928357e-02f,
  1.01114310e-01f, -9.63134132e-03f, -1.91078454e-01f, -3.08358427e-02f, 1.04557581e-01f, -7.08507150e-02f, -4.50578183e-02f, -9.49598700e-02f, 1.87976789e-02f, 1.82978641e-02f,
  -6.26785457e-02f, -5.54547124e-02f, 6.48717880e-02f, -2.12405883e-02f, 7.79597312e-02f, -5.66941127e-02f, 5.96774332e-02f, -8.27507079e-02f, 2.19542496e-02f, 5.79826767e-03f,
  -4.72145528e-02f, 1.20989732e-01f, -9.21982378e-02f, 1.57012418e-01f, 8.74574408e-02f, -6.94087222e-02f, -4.35400903e-02f, 1.82295695e-01f, 1.49041951e-01f, 1.67400241e-01f,
  -7.89303631e-02f, -9.65100303e-02f, 1.62231609e-01f, -3.84519845e-02f, 1.32400677e-01f, 1.04710162e-01f, -1.15186132e-01f, 1.17217399e-01f, 7.39053041e-02f, 1.28760278e-01f,
  3.70471105e-02f, 5.86560816e-02f, -1.10831333e-03f, -3.07966191e-02f, 1.22396566e-01f, -2.63982844e-02f, -9.57087055e-03f, 8.48690420e-02f, -1.80597398e-02f, -5.55519611e-02f,
  -1.62997708e-01f, -1.60490677e-01f, -7.89809823e-02f, 1.26985731e-02f, 8.86109769e-02f, -6.27086759e-02f, -1.06780164e-01f, 2.40825079e-02f, 1.69645339e-01f, -6.87717497e-02f,
  -2.57814061e-02f, -1.45498127e-01f, 9.06217247e-02f, -1.78601608e-01f, -8.63638818e-02f, -1.75422296e-01f, -1.15444362e-01f, 2.05925077e-01f, -2.02839598e-01f, -8.50898996e-02f,
  1.13676511e-01f, 3.44682857e-02f, -1.38765872e-01f, 1.89854369e-01f, -1.75271928e-01f, 3.31955776e-02f, 2.58372366e-01f, -8.74618739e-02f, -1.47514284e-01f, 6.64290786e-02f,
  -1.40451163e-01f, 2.32868075e-01f, -3.32556642e-03f, 2.44950000e-02f, -1.28540635e-01f, 1.68873176e-01f, 2.13133082e-01f, -2.68287212e-03f, -5.49760722e-02f, 1.52891010e-01f,
  2.64465511e-01f, -1.80284515e-01f, -7.69397020e-02f, -2.01314032e-01f, 1.73287928e-01f, -1.19146213e-01f, 2.45133370e-01f, 9.11639854e-02f, -2.15527847e-01f, 8.26430097e-02f,
  6.99424967e-02f, 8.57763886e-02f, 1.27714574e-01f, 5.73108569e-02f, -1.02099441e-01f, -1.74326777e-01f, 1.91531572e-02f, -9.81177539e-02f, -1.23816237e-01f, -1.82490781e-01f,
  1.08977873e-03f, -1.21714726e-01f, -2.10591137e-01f, -9.19992402e-02f, 1.62753463e-01f, -8.85457322e-02f, -1.82238463e-02f, -1.33326247e-01f, 1.16641216e-01f, 5.58834374e-02f,
  -3.51516567e-02f, 1.03696860e-01f, 1.16286606e-01f, 1.62286744e-01f, -1.52547732e-01f, 1.44923180e-01f, 1.40423119e-01f, -5.39662987e-02f, 6.05498850e-02f, 4.60846424e-02f,
  -5.17306402e-02f, 1.67529300e-01f, -4.96193469e-02f, -1.43092275e-01f, -3.21917571e-02f, 3.84187736e-02f, 1.20033203e-02f, 7.25667030e-02f, -5.40230162e-02f, -7.09224269e-02f,
  -1.05410842e-02f, 1.90022811e-01f, -4.85428981e-02f, 8.39294940e-02f, -8.74038264e-02f, 1.42630830e-01f, 1.59259483e-01f, 1.73975840e-01f, 1.27740785e-01f, 8.34812783e-03f,
  -2.42374539e-01f, 1.51328892e-01f, 2.23473459e-02f, -1.47726461e-01f, 5.91209857e-03f, 2.21852452e-01f, 1.47600263e-01f, 1.67021379e-01f, -2.91723618e-03f, -9.08805057e-02f,
  5.78778423e-02f, 5.59698232e-02f, 8.34496170e-02f, -2.05122512e-02f, 1.12680607e-01f, -1.69126596e-02f, -1.26308158e-01f, -1.56207129e-01f, 2.56103754e-01f, 1.75210774e-01f,
  -9.63421836e-02f, -3.10157221e-02f, -2.83541512e-02f, -5.02339788e-02f, -7.51967430e-02f, 6.70591071e-02f, 7.85907656e-02f, -2.05060486e-02f, -8.69125128e-02f, -4.75418642e-02f,
  -1.01936087e-01f, -1.88625127e-01f, -5.49039431e-02f, -4.84038219e-02f, 1.30760461e-01f, -5.90114221e-02f, -1.88762601e-03f, 1.90101594e-01f, 3.63145061e-02f, 9.81334895e-02f,
  -6.69929832e-02f, 1.17266156e-01f, 1.59142315e-01f, -1.81520849e-01f, -1.24022558e-01f, -1.59852970e-02f, 5.78367077e-02f, -1.06318772e-01f, 1.95840225e-01f, 1.04400247e-01f,
  6.41985163e-02f, -1.64345074e-02f, 7.16909487e-03f, 2.44619817e-01f, 1.30979434e-01f, -2.11439073e-01f, 2.77718529e-02f, -1.98696837e-01f, -1.42703906e-01f, -1.31456599e-01f,
  7.80303329e-02f, 3.99749056e-02f, -1.33599550e-01f, 5.88121116e-02f, 2.59499162e-01f, -3.58030684e-02f, 1.86905846e-01f, -2.31977820e-01f, 2.12098002e-01f, -1.18079059e-01f,
  -1.84922844e-01f, 7.50532374e-03f, 1.06287822e-01f, -1.39929608e-01f, 2.56254941e-01f, -6.22316301e-02f, -1.35039106e-01f, 2.07520425e-01f, 1.34996682e-01f, 1.59028471e-01f,
  -2.96137501e-02f, 3.73424813e-02f, -9.90959909e-03f, 1.23321719e-01f, -5.24366200e-02f, 2.15301231e-01f, -5.81438132e-02f, 2.67853495e-02f, 1.33023858e-01f, 2.79731378e-02f,
  8.20329133e-03f, -3.23559605e-02f, -2.92885005e-01f, -1.71162084e-01f, -2.19708964e-01f, 2.04628125e-01f, 1.92389369e-01f, -2.45279018e-02f, 2.14393754e-02f, -1.89227760e-01f,
  1.16245039e-01f, -4.18955326e-01f, 2.48161569e-01f, -2.02981025e-01f, 1.05872825e-01f, 4.82317582e-02f, 8.52058902e-02f, 1.80101797e-01f, -1.37524992e-01f, -3.24369296e-02f,
  -6.50419965e-02f, 2.29677465e-02f, 1.70419365e-01f, 1.59793451e-01f, -8.29122141e-02f, 5.95324561e-02f, 9.64983180e-02f, 2.00374693e-01f, 2.00432956e-01f, -6.33689612e-02f,
  -4.02858220e-02f, 2.47069672e-01f, 1.02662675e-01f, 2.85242975e-01f, -4.99458350e-02f, -1.00988291e-01f, -1.48439240e-02f, 1.01284675e-01f, 3.32342565e-01f, -2.06592709e-01f,
  1.53550440e-02f, 1.58035576e-01f, 1.76717550e-01f, -3.65360230e-02f, -5.04912324e-02f, -1.02853805e-01f, -1.31216310e-02f, 8.49963054e-02f, 1.09432414e-02f, 2.20330074e-01f,
  -3.74343634e-01f, 2.22259581e-01f, 9.34299082e-02f, 8.96492675e-02f, 8.81225988e-02f, 1.47339806e-01f, -1.84629217e-01f, -2.70840168e-01f, 9.47192162e-02f, 4.96471897e-02f,
  2.02564150e-01f, 2.99842022e-02f, 1.05983667e-01f, 1.38555616e-01f, -7.82420579e-03f, 2.81675556e-03f, -7.83840790e-02f, 4.95410599e-02f, -3.34411822e-02f, 5.52851558e-02f,
  4.77030985e-02f, 6.18743338e-02f, 1.66234672e-01f, 1.84360102e-01f, -1.39212236e-01f, -1.78593710e-01f, 1.75788388e-01f, 5.93721084e-02f, 4.77147941e-03f, 2.75791436e-01f,
  2.22329631e-01f, 3.22687887e-02f, -1.07407970e-02f, -1.45731643e-01f, 2.69368500e-01f, -4.22335975e-03f, 1.31302506e-01f, -8.13111365e-02f, 2.18499615e-03f, -1.73072487e-01f,
  1.88203409e-01f, 1.58895403e-01f, -2.07844168e-01f, -2.17952147e-01f, 1.36124089e-01f, -8.02265406e-02f, -3.63804423e-03f, -6.84634224e-02f, 2.74761528e-01f, 1.26444846e-01f,
  2.07545571e-02f, 1.17991462e-01f, -5.91748729e-02f, 1.71201810e-01f, 1.59323752e-01f, 1.07785188e-01f, -1.67468354e-01f, 9.54394042e-02f, 9.32034701e-02f, 1.03854813e-01f,
  -3.35412845e-02f, 7.81521350e-02f, 5.24628237e-02f, -1.97532415e-01f, 1.60737008e-01f, 9.13845096e-03f, -4.83964309e-02f, 1.27887011e-01f, -9.53655690e-02f, 1.66285530e-01f,
  2.25272521e-01f, -2.97857132e-02f, 2.80010942e-02f, -1.19700134e-01f, -1.06377803e-01f, -1.56847611e-01f, -1.27275601e-01f, -1.16848022e-01f, 4.56697531e-02f, 2.02806562e-01f,
  -2.96743680e-02f, -4.46112975e-02f, 9.72051397e-02f, 1.10230751e-01f, 1.61906146e-02f, -7.47302100e-02f, 2.58490108e-02f, 1.56055167e-01f, 1.98156476e-01f, -1.50154397e-01f,
  -1.79806843e-01f, -8.38862807e-02f, 1.06260307e-01f, -7.33999461e-02f, -7.04522431e-02f, -9.03321779e-04f, 4.32475843e-02f, 3.45540754e-02f, -1.04892969e-01f, 1.68001205e-01f,
  -1.08751528e-01f, 2.93307798e-03f, 1.07427388e-01f, 7.94006437e-02f, -1.34585857e-01f, -2.18196169e-01f, 7.11191073e-02f, -8.24624524e-02f, -5.55030480e-02f, 3.55229288e-01f,
  1.07723303e-01f, 3.98437709e-01f, 9.89661217e-02f, -1.26298770e-01f, 3.73645425e-02f, -1.10339364e-02f, -6.98212534e-02f, 6.41420633e-02f, -2.88153976e-01f, 9.71225500e-02f,
  1.25946831e-02f, 2.37395555e-01f, 2.50972837e-01f, 3.94174084e-03f, 2.07077805e-03f, 5.44267632e-02f, -2.38554686e-01f, 1.53277263e-01f, 7.94808641e-02f, -1.16003528e-01f,
  1.68512568e-01f, 1.94068685e-01f, 1.13866352e-01f, 3.92244160e-02f, -5.80049530e-02f, -2.31884867e-01f, 7.27356747e-02f, -9.28831697e-02f, 5.20333974e-03f, -8.76599774e-02f,
  1.00714035e-01f, -9.33670029e-02f, -6.20403513e-02f, -5.30503839e-02f, -1.65564239e-01f, -1.62643090e-01f, -6.63627163e-02f, 7.73809478e-02f, 7.42826089e-02f, -1.58907697e-01f,
  -7.62863979e-02f, -1.35806501e-01f, 6.91746175e-02f, -7.20959753e-02f, -1.01437122e-01f, 5.46125881e-02f, 2.30168961e-02f, -1.33057728e-01f, -1.96499139e-01f, -5.76310828e-02f,
  -2.00843103e-02f, 1.23669371e-01f, -1.85591951e-02f, -7.56076872e-02f, -6.22722395e-02f, 3.93537097e-02f, -1.25749171e-01f, 1.60762459e-01f, -5.55390082e-02f, 9.34774727e-02f,
  1.53121963e-01f, 1.30019233e-01f, -3.99991162e-02f, 2.34922752e-01f, 1.05023943e-01f, 1.05368339e-01f, 8.20790753e-02f, 4.04548980e-02f, -1.30976895e-02f, -4.72634397e-02f,
  -3.18705216e-02f, -1.10448979e-01f, -1.99455649e-01f, 5.39351217e-02f, 1.66219726e-01f, 1.84517428e-01f, 2.13072091e-01f, -1.49693862e-01f, 1.35143608e-01f, -1.13264062e-01f,
  -1.57823443e-01f, 1.31545737e-01f, 1.10828966e-01f, 1.17892258e-01f, 1.61683843e-01f, 1.61698252e-01f, -6.82672486e-02f, -1.50164679e-01f, 8.52226932e-03f, -8.44794326e-03f,
  -1.44691607e-02f, 1.90027252e-01f, 1.21963330e-01f, 1.20626882e-01f, 1.05821818e-01f, -6.94947019e-02f, 5.09381294e-02f, -1.94568872e-01f, 3.46272662e-02f, -6.42486662e-02f,
  -1.68433189e-01f, -4.02370060e-04f, 5.61069027e-02f, -2.18721762e-01f, -3.03331260e-02f, -1.45770714e-01f, 1.39817625e-01f, 1.17255807e-01f, -9.65821370e-02f, -1.45495474e-01f,
  1.69756591e-01f, -1.66309223e-01f, -1.10357195e-01f, -7.89920166e-02f, -1.82145182e-02f, 1.31540135e-01f, -1.70209065e-01f, -1.10372365e-01f, -1.53951123e-01f, 2.01705009e-01f,
  -1.47899047e-01f, 7.57882223e-02f, -1.63759351e-01f, -6.12744018e-02f, 1.10191405e-01f, 2.02814445e-01f, -3.59849073e-02f, 2.44940281e-01f, 4.76660542e-02f, 2.15534881e-01f,
  1.92750543e-02f, -2.17433944e-02f, -1.11339919e-01f, 3.70096825e-02f, 6.24692328e-02f, -5.91439102e-03f, -1.33255377e-01f, -6.77841529e-02f, 1.68238282e-01f, -8.37853402e-02f,
  9.85783264e-02f, -1.37785047e-01f, 2.01711386e-01f, 4.25085723e-02f, 4.67112325e-02f, 2.38303244e-01f, 3.48918736e-02f, 1.31060943e-01f, 2.28606775e-01f, -7.16049448e-02f,
  -1.43305629e-01f, -1.06438845e-01f, -1.73778728e-01f, 8.10431316e-02f, 4.65696864e-02f, -4.70119677e-02f, 4.64271531e-02f, -1.05022520e-01f, -1.84005257e-02f, 3.27702053e-02f,
  -1.42225213e-02f, 3.39162565e-04f, 2.25483716e-01f, 1.43087432e-01f, 3.53825428e-02f, -9.26237702e-02f, -1.01765931e-01f, 1.78767547e-01f, 2.75878534e-02f, -1.06186777e-01f,
  1.32427216e-01f, -5.70094436e-02f, -3.00821692e-01f, 1.18321933e-01f, 1.43216997e-02f, 8.90331417e-02f, -1.95703819e-01f, 1.10461108e-01f, -1.21169716e-01f, 1.56807125e-01f,
  -8.86098966e-02f, -4.42029312e-02f, -2.23333627e-01f, -4.86827791e-02f, -3.46285067e-02f, 1.16462842e-01f, -1.88086495e-01f, -1.56884581e-01f, 8.93356279e-02f, 4.30807136e-02f,
  8.49768445e-02f, 2.69969374e-01f, 5.97223081e-03f, 1.39701575e-01f, 3.73865031e-02f, -4.31752875e-02f, 2.19173934e-02f, -1.88962221e-01f, -1.29451513e-01f, -8.25996771e-02f,
  -1.76756412e-01f, 2.31217340e-01f, -2.29072180e-02f, -2.00085044e-02f, 1.65644124e-01f, 1.05138659e-01f, 1.43063948e-01f, 1.09403990e-01f, -2.25732192e-01f, 9.38222259e-02f,
  1.13851838e-01f, -1.49558872e-01f, 5.24940714e-02f, 6.91965148e-02f, 8.56948942e-02f, 1.71232030e-01f, -5.06158732e-02f, 2.11155802e-01f, 1.63982704e-01f, -2.26974804e-02f,
  9.45901126e-02f, -7.23776296e-02f, -1.64338071e-02f, -9.86062214e-02f, 6.37951419e-02f, 7.43261725e-02f, 1.77727655e-01f, 3.66227552e-02f, -1.73668161e-01f, -2.50419229e-03f,
  2.34305754e-01f, -1.16199009e-01f, 4.36011627e-02f, 1.05373293e-01f, 2.96813603e-02f, 2.87449718e-01f, -1.14624277e-01f, -4.31021899e-02f, 5.16292565e-02f, 3.80216874e-02f,
  -9.73816887e-02f, 1.44124329e-01f, 2.47145444e-01f, 8.25831890e-02f, -2.79970504e-02f, 2.24145144e-01f, -4.07439619e-02f, 2.05183774e-01f, -4.84515652e-02f, 1.19722724e-01f,
  5.86952381e-02f, 6.00831546e-02f, 1.64829865e-02f, 1.39093520e-02f, 1.23066999e-01f, 6.26664143e-03f, -5.72318397e-02f, -7.62845278e-02f, 3.87205817e-02f, -1.74918056e-01f,
  8.72321501e-02f, -8.25678483e-02f, -2.21726075e-01f, 6.76245615e-02f, 7.03725368e-02f, -1.73843801e-02f, 1.24498181e-01f, 1.35662720e-01f, 6.96594492e-02f, -5.34092560e-02f,
  1.39761329e-01f, -4.33978625e-02f, -1.20557368e-01f, 4.27368283e-02f, 1.15227573e-01f, 1.55051634e-01f, 2.24318221e-01f, 1.98377413e-03f, -1.04741439e-01f, -9.54996943e-02f,
  -5.03102951e-02f, 2.54709125e-01f, 1.42812982e-01f, 1.00515045e-01f, 1.19172983e-01f, -1.34265706e-01f, -2.46009929e-03f, -6.26331195e-02f, -6.58425242e-02f, -1.58685476e-01f,
  1.48123324e-01f, -2.19120607e-01f, 8.26691464e-03f, -2.75471747e-01f, 1.73797570e-02f, 2.79514026e-02f, 4.45721634e-02f, 2.26833411e-02f, -5.69129400e-02f, 1.98787317e-01f,
  -7.90863112e-02f, 1.60780409e-03f, 1.94986269e-01f, -1.42401829e-01f, -1.23543538e-01f, 9.67876464e-02f, 9.94807258e-02f, 1.80547252e-01f, 1.99238751e-02f, -5.34740835e-02f,
  5.35303093e-02f, 2.23608941e-01f, -2.35703262e-03f, 1.01134509e-01f, -1.38081044e-01f, -2.30465620e-03f, -2.82477457e-02f, 1.98703051e-01f, -2.01214701e-01f, 6.37303665e-02f,
  -4.46356088e-02f, 1.30977944e-01f, 7.40868375e-02f, 1.30544618e-01f, -4.63926010e-02f, -9.84691828e-02f, -3.85796964e-01f, 4.57025543e-02f, 1.57036662e-01f, -1.91444978e-01f,
  8.78379494e-02f, 6.09917007e-02f, 5.06586954e-02f, 5.37066385e-02f, 1.69906199e-01f, -2.27742326e-02f, 8.46203864e-02f, -7.19890967e-02f, 3.03263843e-01f, 9.29644611e-03f,
  2.33555630e-01f, 1.24719299e-01f, 5.85051719e-03f, -2.88735218e-02f, 8.78609018e-04f, 1.44838437e-01f, 2.19584107e-01f, 1.06366135e-01f, 1.88595146e-01f, 2.73221582e-01f,
  -3.96577567e-02f, 1.08990237e-01f, 7.26009235e-02f, 1.32484481e-01f, -6.20855093e-02f, 3.48097645e-02f, -1.25849456e-01f, 5.57016246e-02f, 2.71876425e-01f, 7.28086159e-02f,
  2.24247247e-01f, 2.07568914e-01f, -2.37443577e-02f, 6.11649416e-02f, 1.63584054e-01f, 1.06788516e-01f, -4.68598343e-02f, 2.35732973e-01f, 5.18226288e-02f, -1.65094715e-02f,
  1.76718995e-01f, 1.55083346e-03f, 1.58148497e-01f, 2.12627083e-01f, -2.79090013e-02f, 2.33487308e-01f, 5.48809022e-02f, -1.26451790e-01f, 6.96800277e-02f, 1.57355398e-01f,
  -1.67333886e-01f, -1.20098544e-02f, 3.68130836e-03f, -1.39200762e-01f, 8.38733092e-02f, -1.69440195e-01f, 1.18252356e-02f, -2.24796683e-02f, 1.48031414e-01f, -4.17379029e-02f,
  1.26661539e-01f, 4.13943827e-02f, 4.81456369e-02f, 1.37889571e-02f, -1.41866565e-01f, -8.62157419e-02f, 4.34068069e-02f, 1.50964618e-01f, 9.34157893e-02f, 3.46697047e-02f,
  3.96560729e-02f, -2.22218037e-02f, 6.64367452e-02f, 1.12741143e-01f, 1.43860847e-01f, 3.06654833e-02f, -2.98684705e-02f, 2.32023243e-02f, -1.12856813e-02f, -1.24393940e-01f,
  6.53310195e-02f, 2.41766140e-01f, 1.80084690e-01f, 1.43043101e-01f, -8.03484861e-03f, 1.78425670e-01f, 1.06723309e-01f, 4.67177816e-02f, -5.42740673e-02f, -2.12310240e-01f,
  2.19321996e-02f, -3.48804370e-02f, 1.10184111e-01f, -8.56028870e-02f, 4.91511412e-02f, 1.43803731e-01f, -1.46992996e-01f, 7.68895149e-02f, -8.06434732e-03f, -2.71397512e-02f,
  -2.99982969e-02f, 7.69873187e-02f, -3.60694714e-02f, 1.19383529e-01f, 2.39303768e-01f, -9.14517939e-02f, 1.88120335e-01f, 2.11185321e-01f, -2.57908013e-02f, 2.25613862e-02f,
  4.66493852e-02f, 3.96061838e-02f, 1.86761394e-01f, 9.21560545e-03f, -1.26280650e-01f, 3.69669273e-02f, 1.51982844e-01f, -3.85939367e-02f, -6.95111752e-02f, 5.04239164e-02f,
  4.64763865e-02f, -8.58223625e-03f, 2.15874687e-02f, 5.41918315e-02f, 6.12139478e-02f, 1.39245421e-01f, 3.07314489e-02f, 1.97127774e-01f, 3.80316116e-02f, -1.05099455e-01f,
  -4.06325608e-02f, -1.98976049e-04f, 4.76993434e-02f, 5.30932061e-02f, 3.31792384e-02f, -9.60277095e-02f, -1.42413527e-01f, 1.22999310e-01f, 1.70726329e-01f, 1.31056115e-01f,
  -1.10830210e-01f, 1.63638383e-01f, 6.76052049e-02f, -4.38489877e-02f, 8.01067650e-02f, -1.34148039e-02f, 4.64583747e-03f, -1.86816797e-01f, -1.20361328e-01f, -1.36741102e-01f,
  8.87380540e-02f, 1.67486340e-01f, 1.90296900e-02f, -3.49427611e-02f, 2.05469201e-03f, 1.55468807e-01f, 1.51365131e-01f, -1.59451086e-02f, 1.63204610e-01f, 1.27301380e-01f,
  2.39820287e-01f, 8.27437080e-03f, -1.53202981e-01f, 2.55292989e-02f, 4.19445969e-02f, 1.43677711e-01f, 6.58056289e-02f, 1.62550867e-01f, 7.36517310e-02f, 3.91299240e-02f,
  -2.64545139e-02f, 1.74095795e-01f, -7.65379220e-02f, -7.66120479e-02f, 1.56456918e-01f, -1.20125987e-01f, -7.77583942e-03f, 4.60655475e-03f, -7.28011057e-02f, 1.78766593e-01f,
  1.60137460e-01f, 1.35910779e-01f, 1.23203732e-01f, 2.23462477e-01f, -1.39435485e-03f, 9.23353732e-02f, 1.31203085e-02f, -1.33959696e-01f, -5.96207082e-02f, -2.91800704e-02f,
  -9.24973488e-02f, 2.44803309e-01f, -4.20282744e-02f, 2.04190373e-01f, 2.84655124e-01f, 1.58972397e-01f, -1.78669080e-01f, 1.90962866e-01f, -1.87444463e-01f, 2.06492871e-01f,
  1.99009646e-02f, -1.03697099e-01f, -3.94720286e-02f, -6.17660880e-02f, 9.73570570e-02f, 6.58244081e-03f, 1.59977376e-01f, 2.84322575e-02f
};

// L3_fan_Bp_bar (Shape: 1 x 52)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 52;
const float L3_fan_Bp_bar_data[] = {
  6.43078759e-02f, 1.05829619e-01f, 1.69758633e-01f, 4.19995636e-02f, 1.62905514e-01f, 8.08554217e-02f, 6.49226084e-02f, 5.56764007e-02f, 8.47469550e-03f, 1.16782770e-01f,
  8.58030617e-02f, 1.20780747e-02f, 1.85409963e-01f, 1.19673900e-01f, 1.42414421e-01f, -4.26012911e-02f, -7.61465505e-02f, -2.41477601e-03f, 8.86086896e-02f, 1.93154812e-02f,
  2.95577608e-02f, 1.04554862e-01f, -6.10880973e-03f, -4.33813334e-02f, 9.84387696e-02f, 6.00326061e-02f, 1.09692268e-01f, 1.57767400e-01f, 1.00386813e-01f, -6.01422191e-02f,
  3.58054489e-02f, -6.00308962e-02f, 2.23355182e-02f, -5.18104583e-02f, 1.60162821e-01f, 1.77570418e-01f, -1.11510098e-01f, -9.39999148e-02f, 1.74046740e-01f, 7.84376189e-02f,
  -4.78916131e-02f, 6.46890560e-03f, -7.44767189e-02f, 1.19653709e-01f, 1.02316484e-01f, 1.79942995e-01f, 1.18603110e-01f, 1.36044219e-01f, -1.18794702e-02f, 4.18826379e-03f,
  -4.20793146e-02f, -3.29163671e-02f
};

// L4_linear_W (Shape: 12 x 64)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 64;
const float L4_linear_W_data[] = {
  -9.87660140e-02f, 3.05806641e-02f, 1.77616440e-02f, 1.00854486e-02f, -8.14695954e-02f, -3.06879841e-02f, 5.20875724e-03f, 7.71360518e-03f, 4.86456342e-02f, 1.31895766e-01f,
  -2.49371290e-01f, -1.17644798e-02f, -3.48978415e-02f, 1.47117600e-01f, -1.39400378e-01f, -2.59047359e-01f, -5.42861223e-02f, -5.56806959e-02f, 3.00101712e-02f, 2.55723745e-02f,
  1.77119579e-02f, -1.29762262e-01f, 1.68041319e-01f, -1.40397176e-01f, -1.11803794e-02f, 1.06238000e-01f, 1.20259240e-01f, 1.49176449e-01f, 1.01673402e-01f, 1.01441272e-01f,
  1.32630289e-01f, -7.19243214e-02f, 9.20364708e-02f, 1.02290928e-01f, -2.21192062e-01f, 1.59294173e-01f, -1.39963120e-01f, 1.63031921e-01f, 1.90663621e-01f, -2.75993377e-01f,
  -4.41053808e-02f, -1.54425249e-01f, 1.11696087e-01f, -7.55251721e-02f, -4.89519127e-02f, 1.45979021e-02f, -1.05313987e-01f, -4.72583175e-02f, 7.61903822e-02f, -4.20224182e-02f,
  -1.85987338e-01f, 8.48712400e-02f, -8.54897723e-02f, -2.03836903e-01f, -2.00201049e-01f, -1.45558715e-01f, -2.27411255e-01f, -1.86884731e-01f, 1.81381971e-01f, -8.36069584e-02f,
  1.55325122e-02f, -2.35029742e-01f, -1.04676314e-01f, 4.08444963e-02f, -5.86773362e-03f, -7.91508425e-03f, 7.78559521e-02f, -1.47513011e-02f, -3.76647748e-02f, 1.31820962e-01f,
  -1.92654222e-01f, 1.24771945e-01f, 1.92534506e-01f, -2.10105881e-01f, 1.99361622e-01f, 1.45895824e-01f, -1.42451495e-01f, 1.61886230e-01f, 1.94183141e-02f, -2.04130366e-01f,
  9.17749852e-02f, 1.99010074e-01f, -2.03418121e-01f, 1.07852273e-01f, 2.03421667e-01f, 7.17970207e-02f, -1.83274552e-01f, -1.43038526e-01f, -3.02184194e-01f, 1.77184381e-02f,
  2.36121584e-02f, 1.01383984e-01f, -2.75854856e-01f, 6.17648028e-02f, 1.35378152e-01f, -5.67896627e-02f, -1.59840733e-01f, 1.74141511e-01f, 7.91608989e-02f, -9.30088852e-03f,
  6.98151737e-02f, 1.50566444e-01f, 1.20899357e-01f, -1.02061033e-01f, -3.80669296e-01f, 1.14761427e-01f, -1.55937761e-01f, -1.47967681e-01f, -3.00622046e-01f, -1.42759025e-01f,
  -1.44471079e-01f, -4.31533121e-02f, -1.23216897e-01f, -2.32792318e-01f, -2.82258336e-02f, -5.72787831e-03f, 1.27805278e-01f, -3.97123061e-02f, -2.06225991e-01f, -1.49990335e-01f,
  -2.92644296e-02f, 1.55115008e-01f, -1.24592163e-01f, 1.94183439e-01f, 1.45060286e-01f, 1.14017315e-01f, 1.05480529e-01f, -2.43041024e-01f, -1.08099774e-01f, -9.27883461e-02f,
  4.36254367e-02f, 2.21259724e-02f, 4.18436620e-03f, 6.04445934e-02f, -1.31402194e-01f, 1.02225877e-01f, -8.04272518e-02f, 4.87708338e-02f, 1.09432645e-01f, -8.52470845e-02f,
  -1.90991029e-01f, -2.82766432e-01f, -1.27458751e-01f, 1.83048368e-01f, 1.61639348e-01f, 9.28180441e-02f, -1.65641770e-01f, -1.56898782e-01f, -3.37370157e-01f, -1.96362138e-01f,
  -7.40100741e-02f, 2.17720836e-01f, 2.63733622e-02f, -2.72553246e-02f, -2.21461788e-01f, -5.68412803e-02f, -4.07287665e-02f, -3.10675681e-01f, 1.80692285e-01f, -1.08730279e-01f,
  9.79343280e-02f, 1.70854613e-01f, -8.75371769e-02f, 5.97909167e-02f, 1.23056613e-01f, 1.40074700e-01f, -3.15608770e-01f, -1.89748019e-01f, -2.26092756e-01f, -6.71607703e-02f,
  -1.85114443e-01f, -2.16247126e-01f, -2.41849735e-01f, 1.34125456e-01f, 1.71574429e-01f, 2.28130385e-01f, -2.94224862e-02f, -2.49459787e-04f, -7.08963871e-02f, 1.43999802e-02f,
  -8.84308740e-02f, 2.00421717e-02f, 5.58550507e-02f, -1.19286932e-01f, 7.81113748e-04f, -1.11453056e-01f, -2.87837267e-01f, 1.48058861e-01f, 6.42078593e-02f, 1.25029936e-01f,
  8.12552869e-02f, 7.32078478e-02f, -5.37691116e-02f, -7.42189214e-02f, 1.22804176e-02f, 1.24038281e-02f, -2.29631681e-02f, -1.32534459e-01f, 1.16208032e-01f, -9.95950699e-02f,
  -9.25405603e-03f, 2.16380246e-02f, 1.35578215e-01f, 9.94395316e-02f, -2.11473014e-02f, 1.58051271e-02f, -1.08290523e-01f, -9.50298980e-02f, -3.06124836e-01f, -2.69041993e-02f,
  1.25655249e-01f, 1.40507922e-01f, -2.49606490e-01f, -7.62054510e-03f, -1.33641794e-01f, -1.85442463e-01f, 1.79490328e-01f, 1.91135220e-02f, 2.08874673e-01f, -2.27893889e-01f,
  1.15114070e-01f, -1.37063295e-01f, -3.04727852e-01f, 1.64779291e-01f, -1.89279974e-01f, 5.35071641e-02f, -2.27600768e-01f, 6.40297532e-02f, -1.98954642e-01f, 6.84623271e-02f,
  2.01661855e-01f, 2.18749315e-01f, 1.88948959e-01f, -2.06342824e-02f, 1.36402965e-01f, 2.04935167e-02f, -2.98513137e-02f, -1.78607807e-01f, -2.57544518e-01f, -2.90850490e-01f,
  -2.87502110e-01f, -2.83978730e-01f, -8.32264647e-02f, -1.17565110e-01f, -3.73347774e-02f, 5.16713709e-02f, -7.78767318e-02f, 2.12081149e-01f, -2.51289606e-02f, -9.78801847e-02f,
  1.13260046e-01f, -9.81366485e-02f, 5.88615499e-02f, -3.08597356e-01f, -5.23668006e-02f, 7.42237940e-02f, 1.06966928e-01f, 9.08632353e-02f, 1.54074878e-01f, 1.56873971e-01f,
  1.65728599e-01f, 1.89909250e-01f, 2.12459520e-01f, -2.47808591e-01f, -1.62980780e-01f, 5.45503274e-02f, -1.14074536e-01f, -1.38452634e-01f, 1.72030888e-02f, 1.47123978e-01f,
  4.39479873e-02f, 4.19234484e-02f, -6.52896287e-03f, -2.15435028e-01f, 1.26146957e-01f, 5.61533682e-02f, 1.17878899e-01f, -1.15193397e-01f, 2.09592462e-01f, -2.32798994e-01f,
  2.12863907e-01f, 8.30085650e-02f, 9.22566876e-02f, -2.12701987e-02f, -3.25069614e-02f, 9.66378376e-02f, -2.24937052e-01f, -1.26323253e-01f, -1.10250339e-01f, -2.06259057e-01f,
  7.59725645e-02f, 9.26585495e-02f, -1.20219938e-01f, -1.47975147e-01f, 1.21733487e-01f, 1.55056357e-01f, 1.69544592e-01f, 1.52827483e-02f, 1.22434542e-01f, 2.77981088e-02f,
  -5.42341955e-02f, 1.93384569e-02f, -5.48368506e-03f, -1.01262152e-01f, -8.55284631e-02f, -8.37293416e-02f, -2.31100842e-01f, -2.12540418e-01f, -1.16389781e-01f, -3.33264992e-02f,
  5.74381240e-02f, -2.09173992e-01f, -5.27257584e-02f, -6.08775616e-02f, -1.12313017e-01f, -2.63809663e-04f, -2.67670900e-01f, 5.99148497e-02f, 1.00625560e-01f, 3.47319320e-02f,
  -1.62452757e-01f, 7.95839503e-02f, -5.93193807e-02f, 2.19952613e-02f, -1.07441276e-01f, 8.69323462e-02f, -2.47521345e-02f, -6.36060312e-02f, -1.78146273e-01f, -7.36674294e-02f,
  -5.67694828e-02f, -2.51806796e-01f, 9.58992541e-02f, 9.14293230e-02f, 1.76115930e-01f, -9.21868384e-02f, -4.69231121e-02f, 3.39483134e-02f, -2.46501133e-01f, -2.23949894e-01f,
  1.28239527e-01f, 1.40976995e-01f, -6.00556582e-02f, 4.97020222e-03f, 1.22965701e-01f, 1.81100473e-01f, -1.24411412e-01f, 8.47440865e-03f, -1.21777914e-01f, 5.80178015e-02f,
  6.46962896e-02f, -2.10185170e-01f, -9.45969298e-02f, -2.46323749e-01f, 8.54434595e-02f, -5.04138209e-02f, 2.54192706e-02f, -1.12892628e-01f, -1.20071732e-01f, -6.24818504e-02f,
  8.16146806e-02f, -3.96533497e-02f, 1.06224038e-01f, 1.15661129e-01f, 1.73802301e-01f, -2.87688524e-01f, -1.51254863e-01f, -1.18406810e-01f, 2.56015092e-01f, 8.85056183e-02f,
  -5.62697053e-02f, 4.32788506e-02f, 8.05613324e-02f, -8.62859190e-02f, 9.20572430e-02f, -9.03738439e-02f, -1.46578252e-01f, -1.44534111e-01f, -1.60768822e-01f, 2.36777384e-02f,
  1.08928658e-01f, -6.17472604e-02f, 8.20744666e-04f, -1.78768173e-01f, -1.28389215e-02f, 8.47862512e-02f, 3.92835550e-02f, -1.27853036e-01f, -9.02302861e-02f, -1.69208870e-04f,
  -7.99522474e-02f, 2.26387247e-01f, -6.38456345e-02f, 2.10481942e-01f, 6.16861172e-02f, -1.22096173e-01f, -1.52646586e-01f, -3.37222517e-02f, 1.44036740e-01f, 8.36478770e-02f,
  1.73002109e-01f, 1.72807187e-01f, -2.51680538e-02f, -1.42479405e-01f, -2.24533290e-01f, 1.56702489e-01f, -1.61261186e-01f, 1.86903611e-01f, -9.37785953e-02f, -7.05715176e-03f,
  -1.47495512e-02f, 1.03649810e-01f, 1.44919334e-02f, -1.76137745e-01f, -8.08094889e-02f, -4.71026078e-02f, 2.74039758e-03f, -1.06863745e-01f, 1.51670501e-01f, -2.31819123e-01f,
  -1.93059936e-01f, -2.14867890e-01f, -6.10191897e-02f, 7.88595453e-02f, 1.10960677e-01f, 1.78854749e-01f, -2.43125379e-01f, -1.66517437e-01f, 6.98378608e-02f, -9.74075720e-02f,
  -2.28273034e-01f, 4.49612848e-02f, -1.21374331e-01f, -2.34519951e-02f, -3.06087852e-01f, -8.55929255e-02f, 1.53597966e-01f, 8.44606236e-02f, 1.16256334e-01f, -6.82722405e-02f,
  -1.54747460e-02f, 7.01957708e-03f, -7.55958259e-02f, -1.62475392e-01f, -1.40282631e-01f, 1.51781589e-01f, 1.41189978e-01f, -1.90767601e-01f, 1.04894973e-02f, -1.06433809e-01f,
  -1.24975175e-01f, -2.18394697e-02f, 1.28030023e-02f, 7.00015947e-02f, -7.30536273e-03f, 1.13235407e-01f, -1.23368070e-01f, 1.20197110e-01f, -3.83309647e-02f, -1.16320670e-01f,
  3.88236418e-02f, -3.20233107e-02f, -2.79462755e-01f, 1.41349726e-03f, -1.08249798e-01f, -1.86185643e-01f, 1.10970452e-01f, 2.68524997e-02f, -3.15029770e-01f, -2.10387617e-01f,
  -1.93178300e-02f, 1.58303276e-01f, -2.19612852e-01f, 2.96152756e-02f, 7.48733133e-02f, 1.21618852e-01f, 2.11800486e-01f, -3.09993804e-01f, -2.26220161e-01f, 1.37472406e-01f,
  3.40058357e-02f, -3.62446420e-02f, -3.14036608e-02f, 6.79193139e-02f, 8.20288584e-02f, 7.60055706e-02f, -6.16710410e-02f, 7.73755834e-02f, 8.31618011e-02f, -2.51762476e-02f,
  6.36121407e-02f, -9.22673792e-02f, 1.53729871e-01f, 1.75318226e-01f, -3.60833481e-02f, -9.56889167e-02f, 1.05656214e-01f, 1.06240064e-01f, -2.77259573e-02f, -1.27509996e-01f,
  -1.26308367e-01f, -9.14508849e-02f, 3.34452391e-02f, 2.38846779e-01f, -1.74172297e-01f, -1.68542907e-01f, 6.43823296e-02f, 1.45617411e-01f, -1.13936946e-01f, 4.59709875e-02f,
  1.54282287e-01f, 1.73991695e-01f, -1.46598607e-01f, 5.58349974e-02f, 4.26175334e-02f, -4.57760245e-02f, -1.26255020e-01f, -1.00733034e-01f, -1.24118999e-01f, -5.97127862e-02f,
  -6.13721348e-02f, -1.34306744e-01f, 4.01505753e-02f, 8.33693370e-02f, -6.06354401e-02f, -6.09374940e-02f, 9.76138562e-03f, -1.84206158e-01f, 5.82442153e-03f, -1.75641954e-01f,
  1.34600908e-01f, -5.27632870e-02f, -1.91400349e-01f, -2.10365713e-01f, -2.35468894e-02f, 1.64569780e-01f, 1.74417160e-02f, -1.43518314e-01f, -6.11566156e-02f, -5.38498210e-03f,
  1.73582450e-01f, -1.68605149e-01f, 9.19954926e-02f, 4.54280712e-02f, 5.85953072e-02f, -1.05068959e-01f, -1.69449523e-01f, 1.74343809e-01f, 1.33738160e-01f, 1.89399540e-01f,
  3.33607048e-02f, 9.68477689e-03f, -1.74812749e-01f, 2.07123622e-01f, -1.20188877e-01f, 1.54308110e-01f, 2.09126800e-01f, -1.38743334e-02f, 3.15944217e-02f, -2.32058344e-03f,
  1.95280701e-01f, -7.72818848e-02f, -2.46778261e-02f, 1.99397877e-01f, -5.48331961e-02f, 6.61057048e-03f, -1.18044302e-01f, 1.44643739e-01f, 2.09250674e-01f, 1.50401995e-01f,
  5.15107438e-02f, 7.41456002e-02f, 1.09934345e-01f, -1.91246480e-01f, -2.02809751e-01f, 2.45078709e-02f, -6.69257902e-03f, -1.08501703e-01f, 3.97084504e-02f, -2.13376675e-02f,
  -1.36168748e-01f, -8.43631923e-02f, 1.08960103e-02f, 7.13891070e-03f, -1.57183990e-01f, 1.84443340e-01f, -1.01764470e-01f, -1.81444243e-01f, 1.35414347e-01f, -3.62079263e-01f,
  8.58337879e-02f, 1.00772589e-01f, 1.54241040e-01f, -2.26973578e-01f, 7.73498118e-02f, -3.38726252e-01f, -1.04542963e-01f, -2.37604186e-01f, 1.58508956e-01f, 7.12991431e-02f,
  -2.10608840e-02f, 1.08808130e-01f, -1.96418196e-01f, 5.63424341e-02f, -1.19829617e-01f, -5.07003702e-02f, -1.23052588e-02f, -1.22205660e-01f, -2.13254336e-02f, -9.68181714e-02f,
  1.02008156e-01f, -1.27866775e-01f, -1.71126634e-01f, 8.45274609e-03f, -1.37061074e-01f, 1.09716870e-01f, -1.72626391e-01f, -2.31377572e-01f, 7.58775994e-02f, -2.98883736e-01f,
  3.17243375e-02f, 2.31349826e-01f, -1.40322357e-01f, -2.51388289e-02f, 5.93054108e-02f, 9.93469581e-02f, -1.54587120e-01f, 8.18636343e-02f, 7.38659054e-02f, -7.90710747e-02f,
  1.52582109e-01f, -1.12061001e-01f, -7.68991709e-02f, -5.45743182e-02f, 1.04901735e-02f, -7.84094110e-02f, -1.45276770e-01f, -1.40113374e-02f, 1.31905982e-02f, 5.58841303e-02f,
  1.82651713e-01f, 3.80127281e-02f, -9.62635353e-02f, -9.52141136e-02f, -6.36628270e-02f, -1.13880306e-01f, 1.75017416e-01f, 1.68804780e-01f, 1.96385622e-01f, -1.11095354e-01f,
  7.11314753e-02f, 1.35108441e-01f, -2.18036920e-01f, 9.10343230e-02f, -2.70208698e-02f, -2.57056475e-01f, -2.36623883e-01f, -3.86727639e-02f, -2.68873125e-01f, -1.38786118e-02f,
  6.36866167e-02f, 5.30621372e-02f, -1.41836256e-01f, -2.19548583e-01f, -8.07597563e-02f, -2.43881837e-01f, 2.53061820e-02f, -1.44309700e-01f, -2.07934797e-01f, 1.86502226e-02f,
  -1.11685045e-01f, 3.88991386e-02f, 3.37598264e-01f, 1.95544153e-01f, -1.84756935e-01f, -2.09322616e-01f, -2.56311819e-02f, -9.31073166e-03f, 2.12004244e-01f, 6.05390035e-02f,
  1.52830228e-01f, -2.34873489e-01f, -2.32713416e-01f, -1.33420095e-01f, -1.80570617e-01f, -2.25449830e-01f, 2.72936463e-01f, 2.58537799e-01f, -1.93938479e-01f, -1.80010960e-01f,
  2.31715724e-01f, 1.17131844e-02f, -1.75253868e-01f, 2.30071336e-01f, -1.04694538e-01f, 1.48815364e-01f, 1.32951006e-01f, 2.12410077e-01f, 2.73652542e-02f, -5.42156920e-02f,
  -4.01706770e-02f, -1.44658059e-01f, 6.48751259e-02f, 5.25673851e-02f, 4.73159365e-02f, 1.09179802e-01f, 5.77070154e-02f, -1.60642117e-01f, 8.27149525e-02f, -1.32767662e-01f,
  -1.12918831e-01f, 1.75032139e-01f, 1.41791627e-01f, -8.97710100e-02f, 1.76775709e-01f, -1.14814669e-01f, 9.95189510e-03f, 2.01515988e-01f, 9.54369232e-02f, -8.18433315e-02f,
  1.17967822e-01f, 6.57423586e-02f, -1.26368850e-02f, 1.60973340e-01f, 1.19538605e-01f, 1.81771457e-01f, -1.79535255e-01f, -1.36588037e-01f, -1.54531701e-03f, -7.04146251e-02f,
  -2.76866257e-01f, -3.32751781e-01f, -6.31045327e-02f, 1.27259448e-01f, -1.12841345e-01f, 6.58348352e-02f, -1.03426529e-02f, -1.32482678e-01f, 8.28716382e-02f, 1.38977468e-01f,
  -7.89729953e-02f, -5.72162680e-02f, -1.14505939e-01f, 1.00533053e-01f, 1.89977244e-01f, 3.58783454e-02f, -8.05783644e-02f, 5.96949905e-02f, 5.72966691e-03f, -9.46528837e-02f,
  -2.08535880e-01f, -1.37329787e-01f, -6.11383887e-03f, -1.92725286e-02f, 2.02194691e-01f, -1.87093124e-01f, 1.89759806e-01f, 2.04339728e-01f, -1.12696186e-01f, -1.50503427e-01f,
  1.78654399e-02f, -3.63325216e-02f, -2.45565280e-01f, -2.29031324e-01f, -1.38836920e-01f, -2.15717241e-01f, -2.21704081e-01f, -1.25202999e-01f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  -5.51050417e-02f, 1.06955394e-01f, -1.25054568e-01f, 1.22754581e-01f, -1.99174099e-02f, -1.27131529e-02f, -7.38713518e-02f, -6.72308654e-02f, -1.53543234e-01f, 1.06516331e-01f,
  1.39118597e-01f, -1.14612304e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 52
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 6, 52
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        64, 6, 52
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        64, 6, 52
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        64, 12
    );
    }
    