/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 4 x 120)
const int L0_fan_Wp_rows = 4;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  8.13411400e-02f, -5.03488362e-01f, 3.37351143e-01f, -8.72692615e-02f, -2.27953747e-01f, 1.92864642e-01f, -1.48157895e-01f, 5.60498908e-02f, 6.68005943e-02f, -1.82785004e-01f,
  -3.38563740e-01f, -6.36474639e-02f, 3.34577225e-02f, 1.49760708e-01f, 9.23094600e-02f, -6.71933442e-02f, -1.85261786e-01f, 2.34300613e-01f, 5.44883132e-01f, 2.14509472e-01f,
  -9.70755443e-02f, 5.95513918e-02f, 1.27984554e-01f, 3.04223802e-02f, -1.89197615e-01f, 5.38838059e-02f, -1.04221299e-01f, -6.31538555e-02f, -5.79376779e-02f, -3.57449293e-01f,
  1.59634575e-01f, -2.02992246e-01f, 1.55684322e-01f, -1.29366457e-01f, -7.00804591e-02f, 2.08880715e-02f, 3.83978486e-02f, 4.87231649e-02f, -2.79266853e-03f, 1.28401399e-01f,
  -7.86079690e-02f, -3.63992229e-02f, 1.56137031e-02f, 7.27982223e-02f, 6.69493303e-02f, 6.20324165e-02f, 5.56195155e-02f, 1.24661244e-01f, 1.71689719e-01f, 9.01940838e-02f,
  -1.83482006e-01f, -1.03607632e-01f, 5.81925921e-02f, -1.97974443e-02f, 1.05464526e-01f, 7.44103938e-02f, -7.08340779e-02f, 5.36074005e-02f, 9.19349119e-02f, -1.59515962e-01f,
  5.44012152e-03f, -6.00007400e-02f, -5.80424294e-02f, -6.96928725e-02f, 3.85556072e-02f, -1.28209684e-02f, -2.11905558e-02f, -2.63415053e-02f, -2.26132181e-02f, 3.59104015e-02f,
  1.38292462e-02f, -1.19134551e-03f, 3.40284109e-02f, 3.88212129e-02f, -5.46926931e-02f, -4.15622778e-02f, -6.88249664e-03f, 2.72314977e-02f, 4.56017181e-02f, -9.03465506e-03f,
  7.52944201e-02f, 5.74193290e-03f, -1.40136266e-02f, 5.94707429e-02f, -5.48663177e-02f, 5.55420760e-03f, 7.57012749e-03f, 1.23772863e-02f, -6.08646218e-03f, -6.86080754e-02f,
  1.09951675e-01f, -5.12183532e-02f, -3.13537754e-02f, -2.61194948e-02f, -4.09946330e-02f, 1.52215371e-02f, -7.17894360e-02f, -4.45342287e-02f, -9.91091132e-02f, 6.66230544e-02f,
  3.53028923e-02f, 3.60357612e-02f, -1.43556045e-02f, 1.45114819e-02f, 4.51547951e-02f, 6.08493760e-03f, -1.18669577e-01f, 4.17026728e-02f, 6.96136430e-02f, 4.63214405e-02f,
  4.16353196e-02f, 7.90308490e-02f, 1.95937455e-01f, 4.44279872e-02f, 1.13700912e-03f, 9.95487999e-03f, 7.38430992e-02f, 1.67467043e-01f, 1.57011196e-01f, 3.16392072e-02f,
  -5.11891127e-01f, -6.40601292e-02f, 3.84719223e-01f, -1.81635126e-01f, 4.65323716e-01f, 3.33054215e-01f, 2.63430834e-01f, 3.85862216e-02f, -1.37048468e-01f, 1.09397046e-01f,
  9.74020511e-02f, -2.06234410e-01f, -2.95047283e-01f, -1.01351269e-01f, -1.05135784e-01f, 1.37730360e-01f, 3.79852578e-02f, -6.07470702e-03f, -5.51877134e-02f, 1.54087469e-01f,
  -5.03083579e-02f, 1.10747805e-03f, -1.30806416e-01f, -4.73635495e-02f, -2.48692092e-02f, -1.93948090e-01f, 1.00335844e-01f, 1.25009492e-01f, 5.72074912e-02f, -7.93925226e-02f,
  4.98549715e-02f, 5.25101274e-02f, 8.87958035e-02f, -3.31955217e-02f, 1.06071688e-01f, -1.19467773e-01f, 6.06285445e-02f, 1.00869965e-02f, -6.96916804e-02f, 5.59604652e-02f,
  8.30728561e-02f, 1.97077706e-03f, -2.78962571e-02f, -3.37438099e-02f, 3.50390486e-02f, -4.51952182e-02f, -2.48646252e-02f, -6.24955930e-02f, -1.77000351e-02f, 4.04217169e-02f,
  1.38058560e-02f, 2.39715397e-01f, 2.62928545e-01f, 1.14274219e-01f, 8.94944593e-02f, 1.59974709e-01f, 1.02775984e-01f, 7.84392878e-02f, 1.90858543e-01f, -8.79121423e-02f,
  5.85402921e-03f, -1.54400505e-02f, 9.62669775e-03f, -4.29537101e-03f, -1.26091288e-02f, -1.06191104e-02f, 2.39507928e-02f, 1.56689808e-02f, 4.93052742e-03f, -3.26525345e-02f,
  2.79634409e-02f, 5.02898991e-02f, 2.70560347e-02f, -6.42576963e-02f, -6.06878325e-02f, 2.20258981e-02f, 3.56936338e-03f, -2.07421873e-02f, 2.48559657e-03f, 3.61475870e-02f,
  -4.34910133e-03f, 7.38009214e-02f, 1.43699171e-02f, -8.77962336e-02f, 8.30498189e-02f, -2.60034315e-02f, -1.41133247e-02f, 5.90894092e-03f, -7.90490508e-02f, 7.97399208e-02f,
  -3.05962950e-01f, 1.82790294e-01f, -1.18408650e-01f, -2.18410268e-02f, -7.74005707e-03f, -8.07346404e-02f, -1.78569136e-03f, -2.82412767e-02f, 5.87941054e-03f, -2.51589883e-02f,
  4.82987612e-02f, -5.70716336e-02f, -1.72012560e-02f, -3.44661251e-03f, 1.11645535e-01f, 9.34081059e-03f, -1.80502534e-02f, -4.30899076e-02f, -7.64021799e-02f, 9.44942534e-02f,
  -3.26069146e-02f, -4.57680039e-02f, -1.03251800e-01f, -5.42507842e-02f, -3.64848599e-02f, -1.20141268e-01f, -2.13408191e-02f, -2.33214740e-02f, -2.68757343e-02f, -1.87301591e-01f,
  3.23106557e-01f, 2.65101194e-01f, -1.61740124e-01f, -6.15568310e-02f, 4.73668240e-02f, 1.72384322e-01f, 5.55921555e-01f, 3.02102625e-01f, 9.93432477e-02f, 1.50144219e-01f,
  1.68261513e-01f, 5.44189196e-03f, -8.33267495e-02f, 3.77926277e-03f, 1.63282320e-01f, 1.11827262e-01f, -1.02794833e-01f, -8.87048393e-02f, -7.36054331e-02f, 6.22735498e-03f,
  7.36677204e-04f, -2.78825033e-02f, -1.90934792e-01f, -8.43290612e-02f, -3.08523923e-01f, -1.71261072e-01f, -2.61372834e-01f, -1.31514519e-01f, -1.41579479e-01f, -4.01370376e-01f,
  -3.00664663e-01f, 2.15806484e-01f, -1.40231505e-01f, -4.11224179e-03f, -7.74120614e-02f, -2.88557485e-02f, -8.33168700e-02f, -3.78994271e-02f, 8.30354244e-02f, 3.34837772e-02f,
  -9.11866203e-02f, -2.76697408e-02f, 3.96901779e-02f, -7.34957904e-02f, -7.76516506e-03f, 6.10333905e-02f, 9.42129940e-02f, 1.09055191e-02f, -2.06033755e-02f, -7.42397308e-02f,
  2.10359208e-02f, 4.25556041e-02f, 6.44045174e-02f, 1.58606559e-01f, 1.88427135e-01f, 2.14626454e-02f, 9.81848836e-02f, -3.52885760e-02f, 6.71817735e-02f, -1.06942885e-01f,
  -2.37556770e-02f, -3.25146094e-02f, -1.84334721e-02f, -3.50916386e-02f, 1.92086007e-02f, 2.42734514e-02f, -3.04659065e-02f, -1.50411315e-02f, 5.63254431e-02f, 1.25607466e-02f,
  -7.12852553e-03f, 1.16338432e-02f, -1.10475607e-02f, 7.56619219e-03f, -5.29779978e-02f, -4.68340740e-02f, -1.33527974e-02f, -1.61232483e-02f, -2.64410544e-02f, -2.15657167e-02f,
  4.31246310e-02f, 2.62176264e-02f, -2.15657149e-02f, -2.39594597e-02f, 6.98047280e-02f, -6.93927258e-02f, -7.97606334e-02f, 8.52484033e-02f, 1.50370887e-02f, 4.83939685e-02f,
  5.43951765e-02f, 1.57479197e-01f, -1.43643141e-01f, -7.48111606e-02f, 4.03499883e-03f, 1.52387992e-02f, -4.59843203e-02f, -4.87921946e-03f, -3.24031599e-02f, -9.83516406e-03f,
  5.15053496e-02f, -2.45688893e-02f, -2.45007109e-02f, -3.55483703e-02f, 6.19109371e-04f, -3.46373096e-02f, 1.00849103e-02f, -7.01246858e-02f, -1.98398493e-02f, 5.71735054e-02f,
  2.31480338e-02f, 7.21534491e-02f, 1.49841253e-02f, 1.23749925e-02f, -4.95804027e-02f, 7.39438506e-03f, -7.71506652e-02f, -8.21543336e-02f, 3.59436832e-02f, -2.94734985e-02f,
  -8.73311758e-01f, -3.57851654e-01f, -7.67228007e-02f, 1.12100065e-01f, 2.31964394e-01f, 2.29561478e-02f, -3.32871854e-01f, -1.37966856e-01f, 1.58624709e-01f, -1.43483758e-01f,
  7.69378543e-02f, 9.61808339e-02f, 8.60543698e-02f, 1.63931370e-01f, -6.09687939e-02f, -1.27266318e-01f, 1.30885700e-02f, 5.24753928e-02f, 1.88009709e-01f, 1.84433147e-01f,
  2.35515743e-01f, 9.07898843e-02f, 1.11752912e-01f, 3.10786888e-02f, -9.06489566e-02f, 8.65629837e-02f, -1.14438068e-02f, 1.07263783e-02f, -3.21556516e-02f, -1.63052112e-01f,
  -2.21632823e-01f, -3.10444802e-01f, 6.43773600e-02f, 1.72753166e-02f, 6.17778972e-02f, -5.51354215e-02f, -9.50156674e-02f, 5.59959598e-02f, 1.70755107e-02f, 3.30880508e-02f,
  3.42368595e-02f, 6.24081492e-02f, 7.61061162e-02f, 5.63894399e-02f, -1.23055510e-01f, -1.51716962e-01f, 2.88884807e-02f, -7.60408044e-02f, -5.60129620e-02f, -6.54927939e-02f,
  1.90851867e-01f, 7.41516352e-02f, -7.82856420e-02f, 2.37375107e-02f, -3.50192888e-03f, 8.55331048e-02f, 3.35611147e-03f, -1.86351180e-01f, -1.25445411e-01f, -2.73474783e-01f,
  1.24585116e-02f, -7.34827220e-02f, -2.73415968e-02f, -8.62292871e-02f, 1.38919381e-02f, 6.11183345e-02f, -1.04482926e-01f, 4.13473845e-02f, 4.38922122e-02f, -2.18338948e-02f,
  -7.96800926e-02f, 5.19961305e-02f, -2.25090627e-02f, -6.33713081e-02f, 3.05703133e-02f, 4.28428166e-02f, -7.22187757e-02f, 1.02157556e-02f, 4.55257967e-02f, -9.32719186e-02f,
  -6.77876547e-02f, 2.70140246e-02f, -2.76150022e-05f, -9.28439274e-02f, 6.32629590e-03f, -6.39068782e-02f, 1.30746625e-02f, 6.35627797e-03f, 1.13306763e-02f, 1.62382878e-03f,
  8.47744495e-02f, 1.13439284e-01f, -1.38703451e-01f, -9.62902755e-02f, 1.54201565e-02f, 7.39160404e-02f, 5.96229956e-02f, 1.08988248e-02f, 8.31101369e-03f, 1.76126920e-02f,
  2.87403539e-02f, -3.66032496e-02f, -1.52078243e-02f, 7.56742656e-02f, -1.10550504e-02f, 8.78217220e-02f, 5.45663722e-02f, 3.48228924e-02f, -3.15442495e-02f, 1.35052472e-01f,
  2.12360322e-02f, 3.55801843e-02f, -8.50858986e-02f, -7.74371400e-02f, 2.92758010e-02f, -9.54559445e-02f, -4.32330556e-02f, -1.06607459e-01f, -1.09671973e-01f, -2.39065468e-01f
};

// L0_fan_Wp_bar (Shape: 8 x 120)
const int L0_fan_Wp_bar_rows = 8;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  5.79060376e-01f, 3.67967002e-02f, 4.87490535e-01f, 8.94773975e-02f, 1.23687372e-01f, 2.50643104e-01f, 2.34995529e-01f, 2.42296215e-02f, -6.48316443e-02f, -3.33170369e-02f,
  -2.00956568e-01f, -3.20094317e-01f, -2.93554068e-01f, -2.30303749e-01f, -3.12155075e-02f, 6.56038597e-02f, 1.67710111e-01f, 1.51924491e-01f, 1.69867069e-01f, 5.21174446e-02f,
  -6.95482343e-02f, 7.76230693e-02f, 1.09632947e-01f, 4.46268916e-02f, -7.97712523e-03f, -1.69626206e-01f, 3.98765840e-02f, 9.81565937e-02f, 9.93145443e-03f, 1.91194750e-02f,
  7.54753873e-02f, 3.31695199e-01f, -1.36452079e-01f, -2.95946300e-01f, -7.20929578e-02f, -1.14229517e-02f, 2.81381444e-03f, 9.60361809e-02f, -9.70344245e-02f, 5.50665855e-02f,
  -6.20515868e-02f, 2.76920339e-03f, -1.57044567e-02f, 2.92339064e-02f, 5.90323396e-02f, 6.97825104e-02f, 2.10571866e-02f, 1.38400123e-01f, -6.10845983e-02f, -4.60039526e-02f,
  -2.78231770e-01f, 1.63579702e-01f, 1.77395746e-01f, 3.25583480e-02f, -2.82721594e-02f, -3.91058996e-02f, -4.41063307e-02f, -2.57002637e-02f, -6.24338314e-02f, 6.87095076e-02f,
  -5.09509705e-02f, 8.75075310e-02f, 1.46773867e-02f, -4.82882513e-03f, 7.08793551e-02f, -3.43874842e-02f, 1.14850281e-02f, 2.57757325e-02f, 4.22222093e-02f, 1.26373991e-01f,
  -5.76048568e-02f, 9.35913920e-02f, -4.99385558e-02f, -7.18559884e-03f, -2.13152338e-02f, 2.86337249e-02f, 7.55398022e-03f, -2.65288148e-02f, -2.71196780e-03f, -1.14946743e-03f,
  3.40828300e-02f, 4.44411412e-02f, 5.55630438e-02f, -5.52912336e-03f, 5.09252734e-02f, 2.84644426e-03f, 2.30291132e-02f, -5.43729216e-02f, 1.65357701e-02f, 4.41469736e-02f,
  -3.62887084e-01f, -1.05406694e-01f, 7.06674415e-04f, -1.26777142e-01f, 6.55752793e-02f, -3.09529565e-02f, -1.38108447e-01f, -1.52137624e-02f, -4.22251523e-02f, 3.70498560e-02f,
  -2.70484090e-02f, -4.00838675e-04f, 6.39891485e-03f, -1.92597427e-03f, 1.08341388e-01f, 1.02022134e-01f, -5.06122783e-02f, -2.45770812e-02f, -1.20598972e-01f, -2.57365569e-03f,
  -5.65345734e-02f, 1.55440167e-01f, 6.82668015e-02f, 3.12871784e-02f, -1.14818309e-02f, 3.62074748e-02f, 2.51447596e-02f, -1.14347357e-02f, 1.11711405e-01f, -2.86168382e-02f,
  -3.00513566e-01f, -2.84533769e-01f, -6.56345636e-02f, -1.28057733e-01f, -7.03357607e-02f, -1.12775236e-01f, -4.32493597e-01f, -1.91050425e-01f, -4.27020416e-02f, -1.43582061e-01f,
  -1.27362013e-02f, 6.03905581e-02f, 1.19292121e-02f, -2.63500474e-02f, -1.87352732e-01f, -4.78555948e-01f, -2.93507159e-01f, -5.22680990e-02f, 9.31858793e-02f, 8.72750133e-02f,
  7.24342242e-02f, 1.31122582e-02f, 1.56135753e-01f, 8.33386183e-02f, -1.16729543e-01f, -2.09547412e-02f, -9.95230377e-02f, -3.08463406e-02f, -1.14923321e-01f, -3.15124899e-01f,
  -1.46229053e-02f, 7.91537575e-03f, 1.33135185e-01f, 1.98666025e-02f, 5.79378940e-02f, -6.75644502e-02f, -8.09433609e-02f, -6.39227331e-02f, 6.92762509e-02f, -4.58638221e-02f,
  1.01065496e-02f, -1.42182233e-02f, 1.65516883e-02f, 8.73975828e-02f, -8.47484618e-02f, -7.03088269e-02f, -3.02598886e-02f, 6.37778491e-02f, -3.10389865e-02f, -2.52627712e-02f,
  -7.75880963e-02f, -3.54251117e-02f, -1.39515862e-01f, 3.29864882e-02f, -2.21641809e-02f, 1.14880271e-01f, -4.72678691e-02f, -4.03278582e-02f, -3.05437646e-03f, -3.31835777e-01f,
  1.34638427e-02f, 6.93635195e-02f, 9.85717252e-02f, -4.70872931e-02f, 2.36992463e-02f, -4.70994040e-02f, -8.95046256e-03f, -6.08162992e-02f, 1.73333753e-02f, -1.00615546e-01f,
  4.00528051e-02f, 3.30654085e-02f, 4.39291187e-02f, -5.45467511e-02f, 3.31545398e-02f, 2.47892626e-02f, -1.52078532e-02f, -8.18619207e-02f, 1.13450084e-02f, -1.96511596e-02f,
  1.80985071e-02f, -2.51633916e-02f, 1.80482492e-02f, 5.59207387e-02f, 4.14904766e-02f, -4.07469012e-02f, 4.42899838e-02f, 4.77083474e-02f, 8.01301152e-02f, -3.20905528e-04f,
  -1.90245241e-01f, 3.02984983e-01f, -9.96560231e-02f, -4.26142216e-02f, -5.93089946e-02f, 2.15502642e-02f, 3.39829437e-02f, -4.50772457e-02f, 4.72385846e-02f, -1.92998536e-03f,
  7.49558862e-03f, 9.78517812e-04f, -1.57380566e-01f, 8.37767050e-02f, -1.08861935e-03f, 1.10771339e-02f, -1.83503300e-01f, -9.94297862e-02f, 2.35298928e-03f, 3.62147647e-03f,
  -8.54596198e-02f, -3.03963274e-01f, -2.86298126e-01f, -1.93022296e-01f, -1.41905159e-01f, -1.16129242e-01f, -1.71284765e-01f, -1.25383362e-01f, -1.98481157e-01f, -4.79145855e-01f,
  -6.90159738e-01f, 2.45083049e-01f, 2.41992682e-01f, -2.36284837e-01f, -1.42195582e-01f, -1.66283071e-01f, 7.95635581e-02f, -1.52773440e-01f, -1.46535277e-01f, 2.18148127e-01f,
  1.27402097e-01f, 3.71289998e-02f, 2.26961121e-01f, 1.06140211e-01f, -2.28381246e-01f, 3.63237746e-02f, 3.53152538e-03f, -2.62695730e-01f, -3.65033001e-01f, -2.47993603e-01f,
  -1.08289145e-01f, -1.52694300e-01f, -3.88405830e-01f, -2.34474242e-01f, 1.60680383e-01f, 2.57710069e-02f, 1.76744908e-01f, -1.05321862e-01f, -4.09085117e-03f, 1.81072950e-01f,
  5.85485518e-01f, -1.00052319e-01f, -7.48435482e-02f, -2.57209837e-01f, 8.24910030e-02f, -7.97303766e-02f, 3.70120965e-02f, -9.27821025e-02f, -1.12869591e-02f, 1.02033978e-02f,
  -7.49928579e-02f, -1.09409261e-02f, -8.45183805e-02f, 1.48310163e-03f, -8.06690678e-02f, -2.71545146e-02f, -7.12222159e-02f, -5.92046157e-02f, -5.17068766e-02f, 1.22243918e-01f,
  2.12755993e-01f, -5.94379827e-02f, 1.25417591e-03f, 2.13723257e-02f, -8.08702186e-02f, 1.30636310e-02f, 6.94900006e-02f, -1.09378830e-01f, -1.68609425e-01f, -6.73241867e-03f,
  -1.89211965e-03f, 8.33302140e-02f, -6.07222803e-02f, 3.73526034e-03f, 5.05004711e-02f, 4.45557907e-02f, -5.40773384e-02f, 3.23256105e-02f, -1.93429757e-02f, 3.66024338e-02f,
  -1.06157539e-02f, 7.90808797e-02f, 7.24165440e-02f, 3.40794399e-02f, 2.31046043e-02f, -6.82026446e-02f, -2.29261555e-02f, -4.33211215e-03f, 4.18570861e-02f, -6.09122142e-02f,
  -2.94061881e-02f, -5.87985776e-02f, 3.39627750e-02f, 2.73262449e-02f, -4.76169623e-02f, -2.07308549e-02f, 1.62105244e-02f, 1.74906012e-03f, -1.96767896e-02f, -2.10920218e-02f,
  1.30967498e-01f, -1.14503019e-01f, 7.82966092e-02f, -1.51119545e-01f, -4.52027619e-02f, 1.69559084e-02f, 1.09344162e-01f, -1.07055269e-01f, 5.10437824e-02f, -1.82118211e-02f,
  -5.97795583e-02f, -6.93895482e-03f, 5.79781681e-02f, 7.20753223e-02f, -4.19295803e-02f, -6.54571280e-02f, -2.85518891e-03f, -6.79628029e-02f, -7.03206509e-02f, 2.46595405e-02f,
  -1.31614702e-02f, -3.41544449e-02f, 5.50470278e-02f, 1.41425639e-01f, -1.46416761e-02f, -2.60957945e-02f, 2.57045627e-01f, 1.18019514e-01f, -7.93661997e-02f, 3.29835951e-01f,
  1.39283478e-01f, -4.11995202e-01f, 6.11035340e-02f, 2.28648916e-01f, 1.54840723e-01f, 2.01591015e-01f, 4.66237403e-02f, 5.48529625e-02f, 2.33541846e-01f, 2.68212818e-02f,
  -1.30193681e-02f, 5.24093248e-02f, 4.70167510e-02f, 1.10478006e-01f, 6.13657758e-02f, 1.47379875e-01f, 1.75577372e-01f, 1.58631727e-01f, 1.80748031e-01f, 1.57909349e-01f,
  6.65794015e-02f, -1.40511990e-01f, -5.64081892e-02f, 7.17386678e-02f, -1.04646221e-01f, 1.44544363e-01f, 3.79453041e-02f, -3.38879935e-02f, -7.86529481e-02f, -2.05974653e-02f,
  2.73589906e-03f, -9.50450152e-02f, 2.39485383e-01f, -6.10412136e-02f, -1.45647183e-01f, 1.51768140e-02f, -8.31438883e-05f, -9.59870070e-02f, -1.32607331e-03f, 3.80963087e-02f,
  -9.58682150e-02f, -1.32642105e-01f, -6.26827255e-02f, -1.04457945e-01f, -3.91897559e-02f, -9.99422148e-02f, -1.52951330e-01f, -8.94991606e-02f, 1.34788662e-01f, 3.52903130e-03f,
  -1.86253135e-04f, -4.19800756e-07f, 7.23965764e-02f, 3.08753476e-02f, 1.56659439e-01f, 6.92777410e-02f, -7.10141659e-02f, 1.53343584e-02f, -1.95233524e-02f, -2.61109676e-02f,
  8.13529566e-02f, 8.22928324e-02f, 5.47144609e-03f, -8.95139202e-02f, -3.23876143e-02f, 9.94447470e-02f, 1.74725149e-02f, -6.96112076e-03f, 4.29413840e-03f, -8.00223742e-03f,
  -4.22357284e-02f, 1.53293848e-01f, -3.21440957e-02f, 5.69136143e-02f, 1.38125457e-02f, -4.79638092e-02f, -8.81928727e-02f, -7.93276802e-02f, 4.90941573e-03f, -9.56049748e-03f,
  -1.56716947e-02f, 1.18013002e-01f, -1.02435857e-01f, -7.47699738e-02f, 1.53186610e-02f, 5.18172011e-02f, 1.68835856e-02f, -2.69038118e-02f, 3.15062106e-02f, -1.68757644e-02f,
  -1.17988527e-01f, 1.77947685e-01f, 1.81562647e-01f, 4.33834549e-03f, 2.95860171e-02f, -1.23390339e-01f, 9.34407711e-02f, -1.08313650e-01f, -4.44420166e-02f, 2.90970225e-02f,
  -2.83760075e-02f, -4.69665527e-02f, -1.25281528e-01f, -3.37297656e-02f, 1.09686524e-01f, 4.62467037e-02f, -1.18956707e-01f, 9.87769291e-02f, -3.18280756e-02f, 5.29257730e-02f,
  -3.49719115e-02f, 1.21348247e-01f, 1.76499948e-01f, 2.25543022e-01f, 1.35404795e-01f, 2.25911349e-01f, -6.33214414e-02f, 7.56188259e-02f, 1.11123264e-01f, -1.66569166e-02f,
  1.67840272e-01f, 4.69826430e-01f, 1.69193000e-01f, 2.84568012e-01f, 2.67935097e-01f, 3.05220753e-01f, 4.67580467e-01f, 1.84355050e-01f, 1.11681312e-01f, 1.53264180e-01f,
  2.78949767e-01f, -9.95168928e-03f, 6.54109344e-02f, 8.88287798e-02f, 1.79797143e-01f, 1.16912663e-01f, 1.53031558e-01f, -6.91070780e-02f, -1.03259705e-01f, 4.46555316e-02f,
  7.10007697e-02f, 1.22489125e-01f, 7.29051381e-02f, 5.68872206e-02f, 8.84021297e-02f, -5.33876605e-02f, 1.97422683e-01f, 1.27249345e-01f, 1.52319983e-01f, 5.62204234e-02f,
  -9.48630646e-02f, 3.36184412e-01f, -8.00563022e-02f, -6.57349378e-02f, 3.52240689e-02f, -1.57120287e-01f, 1.98352449e-02f, -2.04791903e-01f, 3.38221365e-03f, -8.17038268e-02f,
  1.79609619e-02f, -9.20160189e-02f, 1.40234292e-01f, -2.62104832e-02f, -1.03429081e-02f, -2.71367989e-02f, 2.59597935e-02f, -6.11569732e-03f, 5.91140054e-02f, -2.44546402e-02f,
  1.05963655e-01f, 5.03804674e-03f, 3.52014601e-02f, 5.80362342e-02f, 9.84793901e-02f, -5.76998480e-02f, 6.17342293e-02f, -6.15315177e-02f, 4.34657112e-02f, 6.95441812e-02f,
  -1.60033796e-02f, 2.97202654e-02f, 7.84339607e-02f, 8.53264257e-02f, -7.04872189e-03f, 8.09302833e-03f, -2.72311177e-02f, -5.12300469e-02f, 8.54518563e-02f, -8.44511464e-02f,
  -1.92495398e-02f, -1.15939486e-03f, 4.44704518e-02f, -2.06628372e-03f, -1.29696890e-03f, 2.80809011e-02f, -1.79464165e-02f, -4.72981203e-03f, 8.08966160e-03f, -7.75827020e-02f,
  3.94206271e-02f, 1.04517480e-02f, 3.95001136e-02f, -3.63437086e-02f, 3.00536677e-02f, 3.89851481e-02f, -5.72438613e-02f, 3.72188874e-02f, 1.10041335e-01f, -1.22079015e-01f,
  -2.93370504e-02f, 6.54688179e-02f, -1.13737226e-01f, -4.94704470e-02f, -6.09866343e-02f, -1.14919327e-01f, 6.47570267e-02f, -2.17546578e-02f, -1.09439708e-01f, -2.28224080e-02f,
  -5.56630306e-02f, -5.72225824e-02f, 1.36874337e-02f, -1.14531778e-01f, -1.24057628e-01f, -7.47726858e-02f, -1.05443373e-01f, 9.13311243e-02f, 5.07828221e-02f, -6.14743903e-02f,
  -4.33529876e-02f, -1.93422958e-01f, -2.28189319e-01f, -2.17608418e-02f, -1.29295383e-02f, -9.81819257e-02f, -9.62199941e-02f, -1.56964317e-01f, -2.78840624e-02f, -1.92635342e-01f,
  -7.76019096e-02f, 7.05081299e-02f, -7.46267736e-01f, -7.77005702e-02f, -2.15745836e-01f, -3.03116232e-01f, -2.74685770e-01f, 1.44137502e-01f, 2.31180698e-01f, -1.04993924e-01f,
  -1.00955321e-02f, 4.95634899e-02f, -3.01898774e-02f, -1.95420906e-01f, -2.23905206e-01f, -3.36499989e-01f, -4.70883965e-01f, -5.92166424e-01f, -4.86865193e-01f, -1.36741161e-01f,
  -2.32032269e-01f, -1.73888788e-01f, -2.01722071e-01f, -7.82271102e-02f, 1.21316127e-01f, -8.89556557e-02f, -1.24234073e-01f, -1.92216799e-01f, -2.34069690e-01f, -1.76713988e-01f,
  -4.60187912e-01f, -7.00321794e-02f, -1.31748423e-01f, 1.16554331e-02f, -1.53817818e-01f, 1.15856439e-01f, -6.63483469e-03f, 3.13972868e-02f, 1.07783213e-01f, 4.74602506e-02f,
  -5.30557744e-02f, -3.66428271e-02f, -4.36643623e-02f, -8.07522610e-03f, -2.10248083e-02f, -1.18814990e-01f, 2.47689094e-02f, -1.56530574e-01f, -2.34536622e-02f, 1.09046645e-01f,
  -1.21794883e-02f, -2.23215416e-01f, -1.95076004e-01f, 8.19546133e-02f, -5.03813550e-02f, -1.44104794e-01f, 2.80875596e-03f, 1.14548825e-01f, -4.53186370e-02f, 1.29545540e-01f,
  -1.89723948e-03f, 4.17899676e-02f, -7.63608590e-02f, 1.06977463e-01f, 5.83990887e-02f, 1.83104444e-02f, 1.09241148e-02f, 4.82575335e-02f, 1.82640385e-02f, -8.25840887e-03f,
  3.06223277e-02f, -2.42315140e-02f, -6.79476261e-02f, 5.13827652e-02f, -4.15194258e-02f, -4.06869650e-02f, -5.71078621e-03f, 4.97667193e-02f, -6.77466094e-02f, 2.13400330e-02f,
  1.50929401e-02f, -2.11507524e-03f, -4.20779511e-02f, 3.35111357e-02f, -3.05590313e-02f, 6.61409553e-03f, -2.08079033e-02f, 3.31686549e-02f, 2.46568061e-02f, 3.22488025e-02f,
  4.05643314e-01f, -2.59512603e-01f, 7.70275518e-02f, 1.04380988e-01f, -1.93012040e-02f, 4.16333564e-02f, 7.48541951e-02f, 1.62472740e-01f, 8.23753402e-02f, 6.62775384e-03f,
  -1.19077452e-02f, 8.49850848e-02f, 1.04599008e-02f, -1.34470370e-02f, -2.85693984e-02f, 2.55981293e-02f, 1.32542700e-01f, -1.32386312e-01f, -2.10376196e-02f, 2.90552713e-02f,
  1.00397892e-01f, 3.89760211e-02f, 8.72149989e-02f, 9.43967402e-02f, 1.07149966e-01f, -1.14441298e-01f, 1.23323016e-02f, 8.67957547e-02f, -4.94380184e-02f, 3.60409796e-01f,
  5.57750940e-01f, -5.34946859e-01f, -2.73592591e-01f, -1.81159779e-01f, -2.54156381e-01f, -4.51204553e-02f, -2.19783813e-01f, 1.08351922e-02f, 2.67731715e-02f, -3.18397433e-01f,
  -2.76984088e-02f, 2.72040993e-01f, 2.90925145e-01f, 1.57802045e-01f, 3.22498053e-01f, -1.97925493e-01f, -1.86567709e-01f, 2.39452705e-01f, 5.94441056e-01f, 6.23135827e-02f,
  -2.59192325e-02f, -1.34990543e-01f, 1.95915550e-01f, 1.01316668e-01f, -3.18197429e-01f, 7.03612566e-02f, -2.42195651e-01f, -1.93665877e-01f, -6.53406605e-02f, -5.46331048e-01f,
  -1.37609001e-02f, -2.00953051e-01f, 1.74365908e-01f, 1.61290020e-01f, -7.14963377e-02f, 7.70808384e-02f, 7.85445496e-02f, -5.49553521e-02f, 4.40669321e-02f, -9.56551433e-02f,
  2.30889767e-03f, -6.22745790e-03f, 5.36482260e-02f, -9.72101316e-02f, -3.53124365e-02f, 1.86121021e-03f, -2.58217622e-02f, 1.06836997e-01f, 8.49237517e-02f, -1.64604038e-01f,
  -1.11307852e-01f, -9.08671170e-02f, -9.49105695e-02f, 1.29218444e-01f, 1.32872641e-01f, 2.04173461e-01f, -1.21434249e-01f, 4.25014161e-02f, 2.00290382e-01f, -2.06321523e-01f,
  -2.10914947e-02f, 9.77984536e-03f, 9.01759416e-02f, -4.10118653e-03f, 8.34629163e-02f, -4.89996374e-02f, -1.17905373e-02f, -2.47266591e-02f, 1.05527885e-01f, -2.44766101e-02f,
  -3.17708328e-02f, 1.18956333e-02f, -4.38036583e-02f, 1.71365403e-02f, -6.49765432e-02f, -3.22212577e-02f, 6.50338605e-02f, -7.02331960e-02f, 1.37130767e-02f, 9.65054147e-03f,
  6.89154416e-02f, 1.71359871e-02f, -2.01379023e-02f, -1.34477802e-02f, -4.67501096e-02f, -2.32432410e-02f, 2.11766362e-02f, 4.63496037e-02f, 1.04262130e-02f, 6.16044365e-03f,
  1.72301906e-03f, 3.76205176e-01f, -5.04094958e-02f, 3.65227312e-02f, -8.11143070e-02f, -4.09647226e-02f, -3.28766368e-02f, 1.18794143e-02f, -4.94106263e-02f, -7.67985582e-02f,
  -3.80267464e-02f, 6.01731427e-02f, -1.11100443e-01f, 3.39370966e-02f, 5.81524558e-02f, 4.27392544e-03f, 8.80929362e-03f, -4.31201700e-03f, 2.74131577e-02f, -1.42438337e-01f,
  -2.67863944e-02f, 7.60837272e-02f, 1.42864704e-01f, 7.52611533e-02f, 2.92791035e-02f, 1.95456803e-01f, 8.11215937e-02f, -6.39608130e-02f, 1.88411102e-01f, -9.62853953e-02f,
  -1.00712121e+00f, 8.27597827e-02f, -1.31808192e-01f, -2.82873273e-01f, 1.86533839e-01f, 3.39955270e-01f, 5.18885076e-01f, 1.64010364e-03f, -1.28536433e-01f, 8.49793106e-02f,
  6.70621619e-02f, -2.44461462e-01f, -8.18084553e-03f, 1.01686992e-01f, 2.27310926e-01f, 4.57790315e-01f, 2.85680741e-01f, -7.02826828e-02f, -1.95801422e-01f, -3.89533164e-03f,
  1.14465572e-01f, -1.92720279e-01f, -4.70439881e-01f, -1.19858272e-01f, -8.89668241e-02f, -1.22375675e-01f, 1.83551889e-02f, -9.61811841e-02f, 1.15973540e-01f, 1.60750985e-01f,
  -1.25352263e-01f, -2.91574597e-01f, 6.11416921e-02f, -5.31195551e-02f, -7.15116635e-02f, -6.18919060e-02f, 1.17107201e-02f, -9.23424140e-02f, -1.57089215e-02f, -3.60019580e-02f,
  -7.04218447e-02f, -2.11878400e-02f, -2.09917855e-02f, 1.03485910e-02f, -5.16025163e-02f, -1.21227866e-02f, -9.78642553e-02f, -3.42021361e-02f, 3.17207463e-02f, 3.72745208e-02f,
  2.71527916e-01f, 6.47072420e-02f, -2.08291739e-01f, 4.77919169e-02f, 8.61488935e-03f, -2.56922152e-02f, -9.22656506e-02f, 5.76245859e-02f, -6.60470733e-03f, -1.85571223e-01f,
  1.12185344e-01f, -1.47963641e-03f, 4.54524383e-02f, -1.14951339e-02f, -1.62685663e-02f, -2.53561195e-02f, 3.57804857e-02f, 5.76949976e-02f, 1.79199036e-03f, -1.07250318e-01f,
  5.63137159e-02f, 3.60435806e-02f, -4.33547795e-02f, -1.25512965e-02f, -3.65591049e-02f, 3.49511802e-02f, 9.35054943e-02f, 5.80171570e-02f, 5.94523847e-02f, -2.75466545e-03f,
  1.56897884e-02f, -2.01569684e-02f, -4.73735295e-02f, 6.13438850e-03f, 8.39689374e-02f, 6.32641092e-02f, 1.22515000e-02f, -3.69985290e-02f, -5.45321517e-02f, -8.92921165e-03f,
  -3.24596018e-01f, 1.39092922e-01f, -2.94362474e-02f, 8.62132013e-03f, -1.18158953e-02f, -2.23124120e-02f, -3.98175009e-02f, 3.26591618e-02f, -8.20561275e-02f, 2.58195251e-02f,
  3.49104144e-02f, -9.12168548e-02f, 1.45918112e-02f, 2.14246940e-02f, -7.10468218e-02f, 1.10344142e-02f, 1.17809325e-01f, -5.39654456e-02f, 9.59970877e-02f, -1.03490427e-01f,
  1.24334767e-01f, 7.22601963e-03f, -1.24699324e-01f, 1.90892741e-02f, 4.98883575e-02f, -2.46019885e-02f, -1.03928596e-01f, -7.01857805e-02f, -3.30983214e-02f, -1.11512318e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 8)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 8;
const float L0_fan_Bp_bar_data[] = {
  3.44345868e-01f, 2.74031907e-01f, 4.08698946e-01f, 1.20384008e-01f, 3.39866340e-01f, 6.80198848e-01f, 5.46422362e-01f, 1.44595295e-01f
};

// L1_fan_Wp (Shape: 4 x 16)
const int L1_fan_Wp_rows = 4;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  -1.26084059e-01f, -6.60809204e-02f, 2.81273816e-02f, 3.88358057e-01f, -7.74898648e-01f, -1.87875107e-01f, -6.53708875e-02f, -1.89915016e-01f, 6.47331700e-02f, -3.48688960e-01f,
  5.89802623e-01f, -5.14103472e-01f, 1.85310766e-01f, -1.71721593e-01f, -2.98333943e-01f, 2.21564651e-01f, 1.49681553e-01f, 5.62062338e-02f, 3.75710875e-01f, 5.25034666e-01f,
  -2.00103670e-01f, -7.36902475e-01f, -1.35264263e-01f, -3.60347241e-01f, -2.40441233e-01f, -5.74145854e-01f, 1.80707708e-01f, 3.44551086e-01f, 2.68196195e-01f, 7.56178871e-02f,
  2.50870019e-01f, 3.71968895e-01f, -2.11754903e-01f, -1.60499848e-02f, 3.39653850e-01f, 1.48437202e-01f, 4.42327946e-01f, -4.15241152e-01f, -2.73360968e-01f, -3.88789147e-01f,
  1.24597199e-01f, -6.02194190e-01f, 1.36918455e-01f, 6.70096040e-01f, -1.60735026e-01f, 7.58693814e-02f, 4.95590828e-02f, -1.66777447e-01f, 1.82265341e-01f, 1.19603299e-01f,
  7.23636150e-02f, 1.25929594e-01f, -4.21861112e-01f, 4.49887440e-02f, 1.02963388e-01f, -7.50265658e-01f, 3.03501368e-01f, -2.55325019e-01f, -2.83994138e-01f, -1.54733229e-02f,
  1.72426119e-01f, -2.48725176e-01f, -5.56519449e-01f, 2.84835458e-01f
};

// L1_fan_Wp_bar (Shape: 8 x 16)
const int L1_fan_Wp_bar_rows = 8;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  -2.85703450e-01f, 1.35779828e-01f, 2.64560819e-01f, 1.13599345e-01f, -7.99358547e-01f, 4.27895486e-01f, 3.11571687e-01f, 5.38535655e-01f, -4.57637340e-01f, 2.93592006e-01f,
  1.85091868e-01f, 3.05092514e-01f, 6.88981771e-01f, 6.31368220e-01f, -1.85006961e-01f, 1.22628021e+00f, 3.79601866e-01f, 5.27480721e-01f, -4.43617217e-02f, -4.28449735e-02f,
  -7.94787288e-01f, -3.79190028e-01f, -3.15253586e-01f, -4.50481594e-01f, 3.13370466e-01f, 2.33327106e-01f, 9.73446369e-02f, -2.73214906e-01f, 4.92701650e-01f, 7.50105143e-01f,
  -8.67222786e-01f, -7.97392488e-01f, 3.49165618e-01f, -2.87077934e-01f, 1.97091207e-01f, 5.14012724e-02f, 3.47694159e-01f, -9.14237082e-01f, 4.55091119e-01f, -2.57285744e-01f,
  -3.73623580e-01f, -2.63539761e-01f, 7.19049498e-02f, 1.54882610e-01f, 4.63965654e-01f, 1.23922718e+00f, 5.10766387e-01f, -6.28534138e-01f, 3.25695574e-01f, -1.56507269e-01f,
  2.60136008e-01f, 2.47907355e-01f, 1.78134322e-01f, 4.00142401e-01f, 8.03786039e-01f, -5.52671790e-01f, 9.27779734e-01f, -5.30294375e-04f, -3.71654302e-01f, 7.09446967e-02f,
  5.78741431e-01f, 4.00040835e-01f, 9.04748797e-01f, 1.02425016e-01f, 5.94178557e-01f, 7.16968238e-01f, 5.39917529e-01f, 3.71524900e-01f, -3.61163855e-01f, -5.35169423e-01f,
  -7.35831439e-01f, 2.95509726e-01f, 1.95297580e-02f, 6.10749245e-01f, -5.73644459e-01f, 1.33823439e-01f, 2.93340564e-01f, -1.70462146e-01f, 6.18755817e-01f, -3.95955592e-01f,
  8.42892826e-02f, 5.06371260e-01f, -2.59185106e-01f, 3.82411540e-01f, -5.14489233e-01f, 2.98155725e-01f, -1.59201756e-01f, 6.27686501e-01f, -1.27847493e-01f, 6.39556825e-01f,
  7.00831354e-01f, 9.25917253e-02f, -2.19286770e-01f, 9.14735317e-01f, 9.31378677e-02f, 2.24224672e-01f, -7.55472854e-02f, 1.90347731e-01f, 1.59450009e-01f, 2.10347429e-01f,
  6.13327920e-01f, 2.32209995e-01f, -1.80942416e-01f, -3.98993939e-01f, 2.78358966e-01f, 1.16821252e-01f, 6.18551970e-01f, 8.32710192e-02f, 1.09812334e-01f, -4.74086925e-02f,
  2.93017328e-01f, -7.78222084e-03f, 7.92040676e-03f, 7.22928226e-01f, 1.12389013e-01f, 5.40260136e-01f, 1.52097270e-01f, -5.44570744e-01f, -7.88166583e-01f, -2.81040639e-01f,
  3.76408875e-01f, -1.54796019e-01f, 8.77456725e-01f, 2.58825988e-01f, -9.90576744e-02f, 1.00538455e-01f, -5.07029653e-01f, -1.75837114e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 8)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 8;
const float L1_fan_Bp_bar_data[] = {
  1.72186777e-01f, 4.50931281e-01f, 1.36462614e-01f, 1.02322094e-01f, 6.39889061e-01f, 3.83659065e-01f, 1.23957366e-01f, 5.41149139e-01f
};

// L2_linear_W (Shape: 12 x 16)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 16;
const float L2_linear_W_data[] = {
  -1.40336502e+00f, 1.18926987e-01f, -5.38264692e-01f, -8.59645158e-02f, -4.32454079e-01f, -5.55918694e-01f, -2.13213891e-01f, 9.39482227e-02f, 8.24276060e-02f, 2.29047656e-01f,
  5.80901802e-01f, 1.56062260e-01f, -7.76370764e-02f, 4.46013749e-01f, -2.53921956e-01f, -5.40516913e-01f, -2.09192023e-01f, -7.54586160e-01f, -2.52959549e-01f, -3.56162041e-01f,
  -4.60471123e-01f, -6.48786798e-02f, 3.60834420e-01f, -1.65853333e-02f, -1.61672890e-01f, -6.49019837e-01f, 8.87376726e-01f, 7.75214970e-01f, 2.53634840e-01f, -3.12338680e-01f,
  7.44812861e-02f, -6.66960895e-01f, -1.13505200e-01f, 4.65098709e-01f, 2.98975140e-01f, 8.39520916e-02f, -7.69557416e-01f, -8.10612857e-01f, -6.26417756e-01f, -7.01164246e-01f,
  -4.01418507e-01f, -6.38146818e-01f, -4.02289897e-01f, -1.98304147e-01f, 1.03454256e+00f, 2.00072765e-01f, 6.85670376e-02f, -3.11682224e-02f, 3.66908729e-01f, 2.45080397e-01f,
  -5.17585933e-01f, 2.07787424e-01f, -2.52216250e-01f, -1.09713286e-01f, -9.16564241e-02f, -5.83821595e-01f, 8.53130102e-01f, -2.90365279e-01f, -6.21446192e-01f, -1.63675085e-01f,
  -9.78419662e-01f, 8.79841924e-01f, 2.87059508e-02f, -3.80010039e-01f, 4.22989190e-01f, 4.20363814e-01f, 5.06649427e-02f, -3.56016606e-01f, -3.83657396e-01f, -2.92093307e-01f,
  -3.23970824e-01f, -6.25341758e-02f, 4.40034837e-01f, 9.73217726e-01f, 7.90818408e-02f, -5.75495899e-01f, -4.22680676e-01f, 4.01134491e-01f, -1.93926558e-01f, 1.03563122e-01f,
  7.44849622e-01f, -7.70684481e-01f, 2.45786950e-01f, 7.29649305e-01f, 5.92274219e-02f, 4.42598701e-01f, 4.12277132e-01f, -4.88009810e-01f, -1.55152231e-01f, 2.28465036e-01f,
  1.08506656e+00f, 1.29259676e-01f, -2.55189717e-01f, -8.63879099e-02f, -4.16154832e-01f, -3.34690548e-02f, 3.71026248e-01f, -7.71654695e-02f, 4.03173983e-01f, -4.13924992e-01f,
  3.86201233e-01f, 5.36022186e-01f, 4.92336869e-01f, 9.08094525e-01f, -8.52206588e-01f, 7.99194217e-01f, -2.35925704e-01f, -1.23298153e-01f, 6.28625453e-01f, -8.98697019e-01f,
  4.45007682e-02f, 5.44922471e-01f, -2.73603082e-01f, -4.98379439e-01f, -7.55206048e-02f, -3.67788702e-01f, 3.82330805e-01f, -1.76153764e-01f, -2.89635420e-01f, 3.46012324e-01f,
  1.27410030e+00f, -6.37637854e-01f, -2.47528747e-01f, -9.37925279e-03f, -2.22954899e-01f, -4.60164964e-01f, -3.35393757e-01f, -2.96852112e-01f, 1.69150382e-02f, 2.85768598e-01f,
  -5.90607882e-01f, 2.21116960e-01f, -7.04598784e-01f, 6.35827541e-01f, 8.23465765e-01f, 3.07456076e-01f, -6.32103682e-01f, -7.03613758e-01f, -5.88939369e-01f, 8.71074855e-01f,
  8.81295279e-02f, -4.22954261e-01f, 5.56950986e-01f, 3.64816576e-01f, 4.36385244e-01f, 1.67718962e-01f, 3.53470653e-01f, 9.21611488e-01f, 7.22748280e-01f, 1.94434047e-01f,
  -5.56900442e-01f, 6.52694553e-02f, 8.15127790e-02f, 6.53970301e-01f, -6.05270326e-01f, -7.41875529e-01f, 7.69880354e-01f, 2.53097832e-01f, -3.22284102e-01f, 3.63243192e-01f,
  -7.08840042e-02f, -5.08216918e-01f, -2.63223916e-01f, -1.32192656e-01f, 4.64559078e-01f, 3.67231332e-02f, 2.86556035e-01f, -5.46675324e-01f, -5.16723514e-01f, 8.37063789e-02f,
  3.21588635e-01f, -6.01957321e-01f, -5.83892047e-01f, 1.64168805e-01f, 6.30649507e-01f, 1.08388186e+00f, -1.55001935e-02f, 5.10188818e-01f, 3.97343397e-01f, -6.56559825e-01f,
  6.77581012e-01f, 3.63040380e-02f, -6.27368569e-01f, 5.80802381e-01f, -1.64635867e-01f, 2.47740477e-01f, -3.00304890e-01f, 9.53395963e-01f, -3.64286631e-01f, -5.51131010e-01f,
  -6.88467771e-02f, -5.78441978e-01f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  -1.91337913e-01f, -7.02294335e-02f, 4.69819129e-01f, -7.40315467e-02f, -2.79384375e-01f, 1.21937998e-01f, 1.56604275e-01f, 6.77046031e-02f, 4.98081595e-01f, -7.79079646e-02f,
  -5.97897060e-02f, 4.24934715e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 4, 8
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 4, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        16, 12
    );
    }
    