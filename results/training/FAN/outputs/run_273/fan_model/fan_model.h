/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 12 x 120)
const int L0_fan_Wp_rows = 12;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -4.21111554e-01f, -1.08352304e-02f, 9.93334805e-04f, -2.22228155e-01f, -5.78628853e-02f, 1.86401233e-01f, 1.84115037e-01f, -7.34921396e-02f, -1.09252550e-01f, 1.15284964e-01f,
  3.23619284e-02f, 1.17000984e-02f, 2.48853132e-01f, 1.06807705e-02f, 2.21448973e-01f, 3.26949209e-01f, -5.18881120e-02f, -6.72721639e-02f, -1.27890259e-02f, -1.65463418e-01f,
  -6.42211959e-02f, -1.01258988e-02f, 8.11294094e-02f, -6.37674332e-02f, -5.14485799e-02f, -1.68613717e-01f, 2.43498608e-02f, 3.64548489e-02f, -5.56812920e-02f, 9.19896737e-02f,
  1.47793964e-01f, -2.64809262e-02f, -4.24654186e-02f, 3.74285430e-02f, 1.08103734e-02f, -2.30339188e-02f, -7.19869230e-03f, 6.64799809e-02f, -5.50181977e-02f, 2.66642962e-02f,
  3.57096433e-03f, -1.90864094e-02f, -7.63917640e-02f, 5.56033961e-02f, -6.40942976e-02f, -6.02962077e-02f, -7.28029087e-02f, -9.49315820e-03f, -2.57271398e-02f, 5.49576022e-02f,
  -4.37107831e-02f, 1.67213809e-02f, -6.35217279e-02f, 1.35675343e-02f, -2.37162262e-02f, -4.14115041e-02f, 2.39820257e-02f, 6.70179352e-02f, 2.51053516e-02f, -4.48458083e-02f,
  3.21365334e-02f, -9.08211712e-03f, 5.33004329e-02f, 4.01237756e-02f, 3.76736298e-02f, -5.04623018e-02f, 2.30714984e-04f, -6.92139938e-03f, -6.25376850e-02f, -2.06921399e-02f,
  -4.90975678e-02f, -6.69628382e-02f, -2.02405173e-03f, -1.52412811e-02f, -2.97562405e-02f, 3.42840562e-03f, 9.70315840e-03f, 2.26700888e-03f, -2.54648328e-02f, -2.09250227e-02f,
  -2.05721520e-02f, 1.79899279e-02f, 7.37955719e-02f, 1.53014169e-03f, 3.79140899e-02f, 7.34110102e-02f, -1.60328411e-02f, 6.42163903e-02f, 2.09543612e-02f, -1.62643157e-02f,
  -9.16392193e-04f, -4.07953784e-02f, 5.11285812e-02f, -3.97877991e-02f, 7.98721611e-03f, 3.76510024e-02f, -2.29089591e-03f, -2.42858212e-02f, 7.09789526e-03f, -6.88360492e-03f,
  -6.55478910e-02f, -3.75665948e-02f, 1.10749733e-02f, -3.70618962e-02f, -5.69101144e-03f, 5.68496361e-02f, 5.32503650e-02f, -3.54878157e-02f, -4.03503925e-02f, -4.18558046e-02f,
  -3.27986777e-02f, -6.88244998e-02f, -1.31706968e-02f, -6.60515428e-02f, -1.38298813e-02f, 3.79018150e-02f, -4.48449999e-02f, -1.06806969e-02f, -2.59664911e-03f, 4.26474363e-02f,
  4.98852968e-01f, -3.01082730e-01f, -1.33787379e-01f, 1.69146568e-01f, 1.44581169e-01f, 4.08643007e-01f, 3.85779083e-01f, -4.50018328e-03f, 1.62296116e-01f, -1.80799842e-01f,
  2.34895367e-02f, -3.34049501e-02f, -1.43298313e-01f, 4.52779233e-02f, 3.66972089e-01f, 4.67353277e-02f, 2.46991456e-01f, 1.34803787e-01f, 2.39625643e-03f, -4.49067019e-02f,
  3.69530767e-02f, 1.50610268e-01f, -7.17612207e-02f, -4.86150458e-02f, 9.44370404e-02f, 2.10889224e-02f, 5.37569150e-02f, 3.86564177e-03f, -7.46200755e-02f, 6.04104362e-02f,
  5.12356646e-02f, -1.05905101e-01f, -9.33578424e-03f, -2.15643942e-02f, -1.20786652e-02f, -6.84090704e-02f, -5.15276892e-03f, 3.82836089e-02f, 6.33290559e-02f, -3.57358530e-02f,
  -7.24071041e-02f, -1.62514690e-02f, 2.39923876e-02f, 3.69545557e-02f, -2.30317507e-02f, -3.46058272e-02f, -3.23404297e-02f, 1.32304616e-02f, -6.53227344e-02f, -2.51538400e-02f,
  -1.98339652e-02f, 3.58164008e-03f, -1.35645270e-02f, 5.84152639e-02f, -5.53136542e-02f, -2.96267937e-03f, -1.98614728e-02f, -6.92013418e-03f, -5.75778121e-03f, 6.68355003e-02f,
  2.27981759e-03f, 2.00746562e-02f, 3.11479717e-02f, -4.32232134e-02f, 4.31441665e-02f, -4.90440167e-02f, -1.40396170e-02f, 8.34663585e-03f, 4.69704457e-02f, -4.84548835e-03f,
  -4.70338250e-03f, -5.20696165e-03f, -9.18870908e-04f, -1.19052490e-03f, 9.23664682e-03f, 1.07060783e-02f, 1.48468232e-02f, -5.93417734e-02f, 7.91702345e-02f, 4.13582772e-02f,
  2.91579254e-02f, 4.97433208e-02f, 7.89970998e-03f, -1.71405673e-02f, 4.64045107e-02f, 1.49858035e-02f, -5.24857678e-02f, -3.74380127e-02f, -2.93686576e-02f, -2.97433082e-02f,
  -3.91344428e-02f, 8.66703391e-02f, 2.33385116e-02f, 5.07522337e-02f, -1.76110342e-02f, 2.97738630e-02f, 4.87996899e-02f, 4.75103036e-02f, -4.13114019e-02f, 1.73236094e-02f,
  -1.29848775e-02f, 3.65989320e-02f, -9.25874151e-03f, 1.07978052e-02f, 4.43380401e-02f, 2.42551696e-02f, -1.39475511e-02f, 5.27427793e-02f, 5.44506460e-02f, -3.78641933e-02f,
  -2.88837869e-02f, 2.87858993e-02f, 3.21522541e-02f, 6.41619437e-04f, 4.75354120e-02f, 1.12271840e-02f, 9.69673395e-02f, -2.54297163e-02f, -7.30708912e-02f, -1.66161675e-02f,
  8.62995461e-02f, -3.39132994e-02f, -1.37920499e-01f, 1.22794509e-01f, -7.47982739e-03f, 2.14627102e-01f, 1.28108755e-01f, 1.06440745e-01f, -2.18979329e-01f, 1.42159849e-01f,
  -2.72803940e-03f, -3.51400413e-02f, -7.80796111e-02f, 1.41154721e-01f, -5.63004613e-02f, 3.61297466e-02f, 1.26411468e-01f, 1.41536832e-01f, -7.59788379e-02f, 1.80172995e-01f,
  2.78462074e-03f, 1.06146760e-01f, -7.97367245e-02f, -3.35565098e-02f, 6.44224957e-02f, -3.79160559e-03f, 1.98944002e-01f, 1.03116985e-02f, 3.57358754e-02f, -1.25622571e-01f,
  -9.68872458e-02f, -4.25194465e-02f, -6.95999712e-02f, -5.37019782e-02f, 7.39347786e-02f, -2.06128042e-02f, -1.28465807e-02f, -7.57813156e-02f, -4.43638600e-02f, -7.41789341e-02f,
  1.06982943e-02f, -3.97539278e-03f, 1.76682901e-02f, -6.25255480e-02f, -3.06848418e-02f, -3.22182700e-02f, -1.31309396e-02f, 2.27951668e-02f, -3.28069925e-02f, -4.49655913e-02f,
  -3.85534428e-02f, -3.08650848e-03f, 3.72647941e-02f, 4.17034291e-02f, -3.12227719e-02f, -7.89436176e-02f, -2.09959149e-02f, -4.12666006e-03f, -2.45648026e-02f, -2.47515887e-02f,
  4.67466302e-02f, -1.04020648e-02f, 2.06667110e-02f, 6.96019549e-03f, -1.64361615e-02f, -3.41784842e-02f, -9.68004167e-02f, 2.46295333e-02f, -5.88483736e-02f, 3.31095457e-02f,
  7.10441321e-02f, -1.34103848e-02f, -1.86690465e-02f, -1.48129789e-02f, 7.84588158e-02f, -5.26202396e-02f, 3.49707752e-02f, 1.91555750e-02f, -1.36491191e-02f, 1.46425068e-02f,
  2.62615532e-02f, 4.07912172e-02f, -1.87655799e-02f, 4.56090309e-02f, -5.94769008e-02f, -1.01291932e-01f, -7.30806077e-03f, 1.86027978e-02f, 1.61960069e-02f, 3.56917344e-02f,
  1.27241731e-01f, 2.73805797e-01f, 5.78952543e-02f, 1.34472800e-02f, -2.53268108e-02f, 2.70032007e-02f, 1.77458171e-02f, 5.53813800e-02f, 4.83514890e-02f, 1.18569441e-01f,
  3.33584361e-02f, 1.45253539e-03f, 3.98886250e-03f, -2.63367966e-02f, -3.66949886e-02f, -1.92958284e-02f, 5.18375188e-02f, 7.04516321e-02f, 5.49495257e-02f, 4.33492251e-02f,
  2.23901533e-02f, 4.35476564e-02f, -9.03863832e-03f, 6.66007549e-02f, -5.05563058e-02f, 8.94562602e-02f, 8.98891836e-02f, -5.76232113e-02f, -6.06831238e-02f, -4.51503438e-04f,
  2.44537845e-01f, -9.49375257e-02f, -1.43940782e-03f, -2.56603539e-01f, -1.29406288e-01f, -4.46640290e-02f, -5.96660934e-02f, -5.71862720e-02f, -1.01727344e-01f, 6.01071604e-02f,
  -1.44850025e-02f, 4.72036563e-02f, 1.64528713e-01f, -1.40298679e-01f, -1.61572233e-01f, 6.17889389e-02f, -1.87548399e-01f, -9.88707393e-02f, 3.25490944e-02f, 2.43549719e-02f,
  -5.62651865e-02f, -2.22941101e-01f, -4.49817181e-02f, -3.86456549e-02f, -2.09211595e-02f, -8.60981364e-03f, -1.55798495e-01f, 1.04516789e-01f, -1.18791163e-01f, -8.75579342e-02f,
  3.85920815e-02f, 8.38577896e-02f, -6.97702467e-02f, 8.19486678e-02f, 2.76409239e-02f, 6.49690181e-02f, 4.21939343e-02f, -2.61087269e-02f, 1.37573043e-02f, 2.08934303e-02f,
  6.86861947e-02f, 6.34413809e-02f, 4.43033408e-03f, -4.59603220e-02f, 8.23626760e-03f, -2.68462813e-03f, 4.10184339e-02f, -3.93397324e-02f, -4.94950488e-02f, 4.79427017e-02f,
  5.78829832e-02f, 7.94954598e-02f, 2.15987563e-02f, 2.80479770e-02f, 3.82948518e-02f, 3.37038636e-02f, -9.80617013e-03f, 3.27054970e-02f, 5.82471266e-02f, -2.77243406e-02f,
  7.64263272e-02f, 6.72359839e-02f, 4.76680025e-02f, 3.03165372e-02f, -1.07272724e-02f, 3.66921443e-03f, -9.33795124e-02f, -2.19923425e-02f, -6.17271625e-02f, -5.53359538e-02f,
  2.79309470e-02f, -5.05369380e-02f, -1.77003555e-02f, 2.54812501e-02f, -5.07319607e-02f, 6.72017336e-02f, 3.54206562e-02f, 6.65329397e-02f, -6.42728433e-02f, -5.39991111e-02f,
  -6.21393463e-03f, -3.71807702e-02f, -3.92833203e-02f, 2.87167113e-02f, -1.15391426e-01f, 5.10596596e-02f, 6.66480046e-03f, 2.00847425e-02f, -1.91278104e-02f, -8.91678780e-03f,
  -1.65680930e-01f, -1.62677959e-01f, 1.32172909e-02f, 6.10003108e-03f, -3.48392613e-02f, 2.30192076e-02f, -1.09883890e-01f, -1.53938849e-02f, -3.12477481e-02f, 4.96445550e-03f,
  5.54354340e-02f, 4.39772988e-03f, -3.63762118e-02f, 3.68071371e-03f, -1.07736299e-02f, -3.71765271e-02f, -1.49112204e-02f, -6.81640301e-03f, -7.58042559e-02f, -4.91732731e-03f,
  3.27285193e-02f, 5.99624701e-02f, -5.02466448e-02f, -4.62237606e-03f, -2.63089035e-02f, 2.01387033e-02f, -3.89956944e-02f, 4.59510684e-02f, 9.22389887e-03f, -1.53466538e-02f,
  -8.38596597e-02f, -3.26709114e-02f, -1.49169669e-01f, 1.06275961e-01f, -5.70369475e-02f, 4.06454466e-02f, 1.14087477e-01f, 4.55923378e-03f, 2.62746923e-02f, 1.49068996e-01f,
  1.05837129e-01f, -2.17210904e-01f, -1.26858046e-02f, 1.16199240e-01f, -1.19146273e-01f, -3.09476219e-02f, 2.55467474e-01f, 1.33540839e-01f, -4.37847748e-02f, 9.80250910e-02f,
  1.04460930e-02f, 1.78910762e-01f, -7.21832886e-02f, 4.36013378e-02f, 5.19323088e-02f, 1.21015788e-03f, 6.49520522e-03f, 5.24984747e-02f, 8.67307484e-02f, -7.55618736e-02f,
  -3.28141116e-02f, 6.07716432e-03f, -1.10879112e-02f, -2.96244975e-02f, 2.29462292e-02f, 5.25382124e-02f, 8.07077736e-02f, -1.38624504e-01f, 3.68408337e-02f, -4.69967052e-02f,
  -4.92369011e-02f, -2.12963298e-02f, 1.36999204e-03f, -4.91991378e-02f, 5.28845191e-02f, -2.91881245e-02f, -3.09648272e-02f, -1.49789518e-02f, -1.00432821e-01f, -7.60971606e-02f,
  -5.61414706e-03f, 2.58451011e-02f, 5.08658849e-02f, 8.15092474e-02f, -7.47261941e-02f, 8.92569646e-02f, -1.33002903e-02f, -4.27683555e-02f, 7.52104148e-02f, 2.01695729e-02f,
  -1.16890319e-01f, -3.77768353e-02f, 8.50129053e-02f, 5.10963798e-03f, 1.29862323e-01f, 3.57734822e-02f, 1.20918512e-01f, 1.95769910e-02f, 4.02262732e-02f, 8.29625726e-02f,
  -2.10948605e-02f, 8.98623187e-03f, 4.58368799e-03f, 1.45027572e-02f, 7.06562167e-03f, 8.99214968e-02f, 2.98751928e-02f, 2.21875077e-03f, 7.13491961e-02f, -4.00678292e-02f,
  2.33106762e-02f, -7.86012691e-03f, -3.74931935e-03f, 1.64485257e-02f, 3.29509526e-02f, 4.39473353e-02f, -1.34013593e-02f, 5.06042466e-02f, -9.71234366e-02f, -9.98681691e-03f,
  3.19227487e-01f, 2.23640665e-01f, -2.90447101e-02f, -6.39400305e-03f, 3.30802538e-02f, 2.42305920e-02f, -7.76705295e-02f, 4.07682881e-02f, 5.07055074e-02f, -3.12349387e-02f,
  2.64239106e-02f, 1.05888611e-02f, 7.32618803e-03f, 7.96742290e-02f, -2.90732849e-02f, 4.04325053e-02f, 3.00061200e-02f, -3.32037024e-02f, -1.60534345e-02f, 1.74540598e-02f,
  -1.07308440e-02f, -4.53863256e-02f, -3.25290821e-02f, -7.48304883e-04f, 5.76827154e-02f, 2.78965775e-02f, 4.62714862e-03f, 5.39594330e-02f, -2.16172338e-02f, -1.28560979e-03f,
  3.89976650e-02f, 1.61351740e-01f, 2.45702356e-01f, -7.83606246e-02f, 7.16856495e-02f, -3.92181762e-02f, 1.56532958e-01f, -1.27470315e-01f, 3.14815849e-01f, -1.73579633e-01f,
  -3.11458886e-01f, 1.61041990e-01f, 9.70952213e-02f, -1.36448935e-01f, -1.14117466e-01f, 1.04674973e-01f, -6.15207180e-02f, 1.16506405e-03f, 1.07323818e-01f, -1.24852158e-01f,
  -6.47596493e-02f, -3.32189620e-01f, -4.73885573e-02f, -1.79206356e-01f, -6.53240085e-02f, -5.66442460e-02f, -3.23111624e-01f, 4.34736274e-02f, -2.71465987e-01f, -2.14462122e-03f,
  1.54962778e-01f, 1.15395948e-01f, 7.70744830e-02f, -3.48238833e-02f, -1.39411092e-01f, -7.28757530e-02f, -4.11544591e-02f, -1.43544506e-02f, 8.86693299e-02f, 2.26662271e-02f,
  6.26192763e-02f, -9.35314149e-02f, -3.62993293e-02f, 2.11412050e-02f, 3.48194987e-02f, -3.97634134e-03f, 4.96134087e-02f, 7.14274123e-02f, 1.07808664e-01f, 9.19111967e-02f,
  8.55240896e-02f, -3.49766724e-02f, -1.82876550e-02f, -1.66213699e-02f, 4.24982095e-03f, -2.48221327e-02f, 2.77690161e-02f, -1.10341711e-02f, -3.07001732e-02f, -2.49931831e-02f,
  -4.21970785e-02f, 3.83654498e-02f, 2.61059124e-02f, 6.91398559e-03f, 4.20213956e-03f, -1.98606029e-02f, 3.60853374e-02f, -3.97500321e-02f, 4.68546562e-02f, -1.01692520e-01f,
  -1.19893707e-01f, 4.49252836e-02f, -2.75194701e-02f, 1.77186832e-03f, 2.92263040e-03f, -2.32973527e-02f, 2.23422237e-02f, -4.66830954e-02f, 6.66821888e-03f, 3.99774164e-02f,
  -7.53419567e-03f, -4.06006128e-02f, 6.39919005e-03f, 2.87797954e-02f, -2.18019467e-02f, 1.42211597e-02f, -1.19140156e-01f, -3.14096734e-02f, 6.13512807e-02f, -1.33053437e-02f,
  -1.52451038e-01f, -1.15135320e-01f, -3.16824056e-02f, 4.52413186e-02f, 5.28617576e-02f, -2.35290956e-02f, 6.82454035e-02f, 1.47356307e-02f, -3.27566229e-02f, 2.95900460e-02f,
  -9.43440050e-02f, 7.28016943e-02f, -7.27638155e-02f, -1.76740400e-02f, -1.65064428e-02f, -1.24292456e-01f, -4.82807085e-02f, -3.26845720e-02f, -9.80366468e-02f, -9.50894877e-02f,
  -4.04892713e-02f, -1.20680267e-02f, 3.95608693e-03f, 1.16019137e-02f, -7.01520741e-02f, -8.11727252e-03f, 2.18190700e-02f, -2.22144872e-02f, -8.72163549e-02f, 3.05758696e-02f,
  3.83718967e-01f, 4.27428633e-01f, 2.22056851e-01f, 3.15419704e-01f, 9.99285728e-02f, 8.95135105e-02f, 2.26192221e-01f, 1.10334724e-01f, 2.14974344e-01f, 7.90397897e-02f,
  -6.96345558e-03f, 1.25779390e-01f, 2.22025681e-02f, 2.66549230e-01f, 1.77732259e-01f, -3.54109295e-02f, 1.77871570e-01f, 8.61544535e-03f, 5.69498949e-02f, 1.83170259e-01f,
  5.71817383e-02f, 2.32038945e-01f, 2.58029420e-02f, 5.16358390e-02f, 2.39400744e-01f, -1.22454047e-01f, -8.57545994e-03f, -1.15890335e-02f, -4.57033515e-02f, 7.17509463e-02f,
  7.99514279e-02f, 3.12383454e-02f, -1.69050251e-03f, -7.32853892e-04f, 2.26160847e-02f, 1.75944865e-02f, -2.07875278e-02f, 4.33971658e-02f, -5.22581786e-02f, 2.12558378e-02f,
  -7.29290769e-03f, 4.09206450e-02f, 6.42462373e-02f, 1.20469108e-02f, -5.32408245e-03f, 1.52775515e-02f, -2.46409960e-02f, -3.31089459e-02f, 2.35242378e-02f, -2.60393471e-02f,
  2.56175660e-02f, 2.84587163e-02f, 2.33448539e-02f, -4.29073162e-02f, 2.92302184e-02f, 2.14534495e-02f, 5.81806414e-02f, -1.77997295e-02f, 3.02844271e-02f, 8.00677240e-02f,
  7.10153580e-02f, 3.51987071e-02f, 3.82880047e-02f, -4.36849222e-02f, 5.81054166e-02f, 1.04568410e-03f, -3.07948440e-02f, -5.03096841e-02f, -1.77818518e-02f, 7.48013239e-03f,
  3.70864582e-04f, -4.35880013e-02f, 3.79876830e-02f, 2.90350188e-02f, -5.88676566e-03f, 2.11172947e-03f, -2.46065464e-02f, 3.10442448e-02f, -1.58747248e-02f, -6.61999807e-02f,
  3.99793935e-04f, 3.03106327e-02f, -2.31905151e-02f, -2.60703582e-02f, -9.07351542e-03f, 2.79386975e-02f, 1.30898254e-02f, -4.57507605e-03f, 2.65056416e-02f, 5.07067405e-02f,
  1.44109428e-01f, 9.11975950e-02f, 1.93089619e-02f, 4.31301482e-02f, -7.54847378e-02f, -5.38470037e-02f, 4.34537567e-02f, 2.15852447e-02f, 6.39466755e-03f, 1.50566036e-02f,
  1.92677006e-02f, -2.69519519e-02f, 3.55387293e-02f, 2.40744818e-02f, 2.60476656e-02f, 4.41918448e-02f, 6.03232048e-02f, -2.66590081e-02f, 5.05409092e-02f, -2.60884613e-02f,
  -9.59044229e-03f, 5.70504926e-03f, 1.54332398e-02f, 2.06574518e-02f, 2.57279002e-03f, -6.02535754e-02f, -3.72853652e-02f, 5.58492206e-02f, 1.88816320e-02f, 1.23689324e-02f,
  -4.86028045e-01f, -2.07113355e-01f, -2.93709207e-02f, -6.90909773e-02f, -1.06708027e-01f, 7.28753731e-02f, 1.79134116e-01f, 2.20505912e-02f, -1.97761729e-01f, 1.66244898e-02f,
  -2.61593238e-02f, -1.19555518e-01f, 7.58615285e-02f, 5.53357340e-02f, -1.97043821e-01f, -1.09721482e-01f, 1.02149213e-04f, -5.23675755e-02f, -1.78284854e-01f, -2.75392961e-02f,
  -6.43198937e-02f, 9.37128812e-02f, 1.14042684e-01f, 1.70549557e-01f, 5.78437187e-02f, 5.44954045e-03f, 3.39094922e-02f, 1.36854753e-01f, 4.42305356e-02f, 1.03037976e-01f,
  7.43046626e-02f, -6.89533912e-03f, 3.34879197e-02f, -1.55851701e-02f, -5.33338301e-02f, 4.48300391e-02f, 7.00270534e-02f, 3.63499410e-02f, 6.90219104e-02f, -4.88920324e-02f,
  -1.71387047e-02f, 1.98854897e-02f, -3.40846032e-02f, -1.46663319e-02f, 1.96294524e-02f, -7.29138032e-02f, 1.11563383e-02f, 2.74596550e-02f, 2.30771694e-02f, -8.27914849e-02f,
  8.87689088e-03f, -2.42012441e-02f, 2.92812195e-02f, 3.76122110e-02f, -1.58276223e-02f, -1.65659375e-02f, 5.53497933e-02f, 3.46675403e-02f, -1.36242481e-03f, -6.66605607e-02f,
  5.88531606e-03f, 1.18813366e-02f, 1.42534673e-02f, 4.78674611e-03f, -9.37747391e-05f, 1.10557964e-02f, -4.57680151e-02f, 1.39972912e-02f, -1.76093113e-02f, -4.43207435e-02f,
  -2.44257934e-02f, 1.72894988e-02f, 2.62924819e-04f, -8.53845477e-03f, 3.21938880e-02f, 3.85569595e-02f, 1.25722867e-02f, 3.90726402e-02f, 2.87164585e-03f, -3.21064726e-03f,
  2.02793609e-02f, -3.11323237e-02f, -4.40228097e-02f, 4.77878973e-02f, 3.52805271e-03f, -4.67256978e-02f, -5.52615933e-02f, 3.78871076e-02f, 5.10843061e-02f, 3.19719538e-02f,
  5.00261709e-02f, -6.28767014e-02f, -2.41638981e-02f, 5.01459762e-02f, 3.11995037e-02f, -5.80897601e-03f, -2.85829343e-02f, 4.72894311e-03f, -7.43652601e-03f, 4.23892885e-02f,
  -5.99124376e-03f, 7.34700635e-02f, -6.23440258e-02f, -3.43318330e-03f, 5.19217588e-02f, -7.57680461e-02f, 2.79902592e-02f, 2.87641361e-02f, 1.76634807e-02f, -1.89802703e-02f,
  4.02932987e-02f, -3.61492112e-02f, -2.15578005e-02f, 2.06429530e-02f, -4.93717305e-02f, -7.08982348e-02f, -1.44079598e-02f, -6.83336928e-02f, -3.50078158e-02f, 1.56209767e-02f,
  2.71853879e-02f, 2.03735933e-01f, -9.74143445e-02f, 3.19219334e-03f, -1.02500558e-01f, 9.34142470e-02f, -1.71945635e-02f, -5.21903578e-03f, 6.11283891e-02f, 6.79894462e-02f,
  -2.80055404e-02f, 1.13986023e-01f, 5.53042479e-02f, -5.52363694e-02f, 3.29037081e-03f, 1.01122722e-01f, -4.27264497e-02f, -3.14237624e-02f, -3.24014388e-02f, -1.73333231e-02f,
  2.53416020e-02f, -1.10856436e-01f, -1.18397241e-02f, -2.05370203e-01f, -3.54178287e-02f, -6.83557987e-02f, -1.27374455e-01f, -1.00379035e-01f, -1.23153448e-01f, -6.24608882e-02f,
  -1.45556158e-04f, 4.09978516e-02f, -2.42206492e-02f, 4.17019576e-02f, -2.11394839e-02f, 3.26380096e-02f, 1.21689234e-02f, -7.42475390e-02f, 6.40237033e-02f, 1.18397260e-02f,
  5.81041984e-02f, -1.43192671e-02f, 1.23497946e-02f, -3.07172667e-02f, 2.85263713e-02f, -2.10027192e-02f, -6.01024330e-02f, 7.36394003e-02f, -4.74314280e-02f, -3.62781696e-02f,
  3.38297663e-03f, -5.88172041e-02f, 1.04931220e-01f, -4.80117984e-02f, 2.79075950e-02f, 1.12382323e-03f, -8.30492526e-02f, -8.06982219e-02f, 1.53289670e-02f, -3.48552018e-02f,
  8.96245837e-02f, -3.01877651e-02f, -3.98934968e-02f, -1.94754582e-02f, -4.50170971e-02f, -7.10047334e-02f, 4.91388738e-02f, -2.67823860e-02f, 8.57671574e-02f, 3.24832126e-02f,
  -2.54821330e-02f, -5.17540472e-03f, -4.76082042e-03f, -1.11586578e-01f, 4.13372694e-03f, -1.81836206e-02f, -2.11097095e-02f, -5.49441874e-02f, -4.22673263e-02f, -6.50908872e-02f,
  -2.64019165e-02f, -2.31013652e-02f, 6.66397437e-02f, -4.84012663e-02f, -4.84018214e-02f, 3.98327149e-02f, -5.71370870e-02f, -1.76623818e-02f, 8.34753644e-03f, -4.63022068e-02f,
  1.81848869e-01f, 2.61779606e-01f, 3.74720767e-02f, 2.23458931e-02f, 2.26190798e-02f, 1.09636113e-02f, -6.53931350e-02f, -5.44951577e-03f, 8.73766318e-02f, -2.01713410e-03f,
  4.54381369e-02f, -6.46731555e-02f, 5.46130687e-02f, -7.12269396e-02f, 4.61157523e-02f, -5.34148701e-02f, 6.25300854e-02f, 3.78128402e-02f, 6.34404197e-02f, -2.72600334e-02f,
  7.02944919e-02f, 3.46633159e-02f, -2.21785214e-02f, -9.35689881e-02f, -8.57305527e-02f, -8.97606276e-03f, 1.56721510e-02f, 3.11657484e-03f, -4.33381721e-02f, 2.13922150e-02f,
  -7.34296022e-03f, -6.18547909e-02f, 3.26415658e-01f, -2.33965546e-01f, 2.34172419e-01f, 2.25368366e-01f, 2.86764711e-01f, -9.36944634e-02f, 4.29555736e-02f, -3.23960066e-01f,
  -1.86917737e-01f, -1.62098914e-01f, 1.26996115e-01f, -1.52367756e-01f, 2.13128224e-01f, 9.36163217e-02f, 2.89755035e-02f, -1.14294544e-01f, 1.95702493e-01f, 7.72463605e-02f,
  3.83073986e-02f, 6.95994198e-02f, 1.64824814e-01f, -2.92387959e-02f, -2.00680885e-02f, -1.13814801e-01f, -7.25274757e-02f, 1.50749743e-01f, -8.06354657e-02f, -1.91498436e-02f,
  3.99143733e-02f, -1.30376279e-01f, 3.53569016e-02f, -7.12167993e-02f, -3.37854177e-02f, -3.11724879e-02f, 1.83056742e-02f, 3.69094536e-02f, 1.58311427e-02f, -3.50688100e-02f,
  -2.55420413e-02f, -3.86259183e-02f, -2.43122932e-02f, -7.81134516e-02f, 2.43082289e-02f, -4.52185832e-02f, 1.32893873e-02f, -1.04608554e-02f, -1.19165210e-02f, 4.72387932e-02f,
  3.55542414e-02f, -9.44257081e-02f, 7.27353394e-02f, -5.07333055e-02f, 1.37685370e-02f, -5.93402497e-02f, 5.13668619e-02f, 3.17827202e-02f, -4.25012223e-02f, -1.01719365e-01f,
  -1.82872042e-02f, 7.02904388e-02f, -4.76112515e-02f, -1.00291193e-01f, 2.29193885e-02f, -3.97785902e-02f, 2.00863089e-02f, 2.70271506e-02f, -4.20946442e-02f, 4.88825627e-02f,
  -8.34480822e-02f, -5.73487487e-03f, 7.59078655e-03f, 1.16918618e-02f, -1.81299588e-03f, -1.07389919e-01f, -2.11875867e-02f, -1.51892123e-03f, -7.15292543e-02f, 1.08217364e-02f,
  -4.28408533e-02f, 5.64803602e-03f, -1.09082470e-02f, -5.70565648e-02f, -1.27223693e-02f, 8.79158601e-02f, -7.84338787e-02f, 5.77067351e-03f, 6.15977980e-02f, 1.03321940e-01f,
  7.83723518e-02f, 2.73003429e-02f, -3.04581854e-03f, -7.31396377e-02f, 9.45071783e-03f, -1.01520889e-01f, -2.04056595e-03f, 3.46887931e-02f, 1.18117899e-01f, 2.02942211e-02f,
  2.80227233e-02f, -1.08006351e-01f, 6.22176416e-02f, 2.94514336e-02f, -6.16999976e-02f, -2.34266315e-02f, 4.21079807e-02f, 6.43423349e-02f, -2.23701494e-03f, 5.03304489e-02f,
  -2.14793812e-02f, -5.13074063e-02f, 7.44642410e-03f, -2.92431246e-02f, -1.07486993e-01f, -2.73588784e-02f, -3.87363173e-02f, -3.12647149e-02f, 5.28705828e-02f, 6.67619705e-02f,
  -2.40710258e-01f, 7.44593004e-03f, -3.02175190e-02f, -4.03463766e-02f, 4.12786864e-02f, 3.83118361e-01f, 4.19251740e-01f, -1.21742040e-02f, -1.73252902e-03f, 1.12527058e-01f,
  1.64358705e-01f, -8.48375726e-03f, 5.91827221e-02f, 2.73412675e-01f, 9.72451866e-02f, 1.73420414e-01f, 9.95602310e-02f, 1.64293930e-01f, -3.71744111e-02f, -8.14927593e-02f,
  -5.78017905e-02f, 1.05440840e-01f, 7.72626027e-02f, -5.38520962e-02f, -5.59065714e-02f, -1.69493243e-01f, -1.85858652e-01f, 2.44057272e-03f, 8.47620983e-03f, 9.31067988e-02f,
  -1.86315663e-02f, -4.04910035e-02f, 4.31472734e-02f, 1.94708668e-02f, -2.07428019e-02f, -7.78633207e-02f, -2.94664390e-02f, 3.62122431e-03f, -4.07962240e-02f, -7.44153699e-03f,
  -1.79151557e-02f, 1.58222683e-04f, 6.81202635e-02f, -2.25659218e-02f, -2.55491748e-03f, -1.51606342e-02f, -1.72598346e-03f, -3.75523716e-02f, 3.53447981e-02f, -2.39544790e-02f,
  2.57469472e-02f, 5.71285700e-03f, -7.34743327e-02f, -5.60902385e-03f, -1.70909464e-02f, 5.00926338e-02f, 1.73704268e-03f, 4.63137962e-02f, -9.11232904e-02f, -6.14653016e-03f,
  -1.22955076e-01f, -3.38543542e-02f, -3.16947252e-02f, -5.88927651e-03f, -3.29699516e-02f, 1.45590454e-02f, 1.02065261e-02f, 2.35901158e-02f, -4.59592305e-02f, 2.75790170e-02f,
  -3.04013118e-03f, -7.01677473e-03f, -2.05367245e-02f, -3.79791819e-02f, -4.77542654e-02f, -4.15456630e-02f, -2.33704150e-02f, 3.88208334e-03f, -6.62304685e-02f, -6.34088041e-03f,
  4.73626740e-02f, -3.34527604e-02f, 5.04802391e-02f, 2.18774565e-02f, 4.41259854e-02f, -5.35089485e-02f, -1.39241461e-02f, -7.27272704e-02f, -4.22581770e-02f, 4.10340168e-02f,
  1.09365262e-01f, -5.99133857e-02f, 5.80971390e-02f, 1.87283643e-02f, 4.44310941e-02f, 5.46301268e-02f, 1.38769140e-02f, 1.95848150e-03f, -3.25501384e-03f, 6.16722517e-02f,
  -5.86036481e-02f, -4.50085523e-03f, -4.84274551e-02f, 2.06442010e-02f, 5.56442328e-02f, 1.12853348e-02f, -1.25379255e-02f, -4.18750495e-02f, -5.16559817e-02f, -3.55269387e-02f,
  -1.38168797e-01f, 8.30717757e-03f, 2.39929813e-03f, 4.43295464e-02f, 3.45510431e-03f, -3.15729599e-03f, 1.30369551e-02f, -1.11064501e-01f, -5.85452374e-03f, 3.42836641e-02f,
  6.53611481e-01f, 1.11564122e-01f, 1.48815334e-01f, 1.45543009e-01f, 1.03670517e-02f, 1.57305762e-01f, 2.71731585e-01f, 2.59633847e-02f, 2.30217680e-01f, 7.13765994e-02f,
  7.54221231e-02f, 1.89457506e-01f, 6.33476004e-02f, 4.68162028e-03f, 1.06826901e-01f, -1.55216753e-01f, -8.82223323e-02f, 4.02765907e-02f, -8.17545429e-02f, -3.24725583e-02f,
  -3.83679047e-02f, -4.02421206e-02f, -1.40895188e-01f, -1.15283117e-01f, 5.02205454e-02f, 3.13038975e-02f, -1.51449382e-01f, -6.75038546e-02f, -4.98811752e-02f, -5.53711411e-03f,
  1.90430880e-01f, 1.57359019e-01f, 3.51854675e-02f, -2.16908567e-02f, 2.42667403e-02f, 3.14234197e-02f, 3.22027951e-02f, -6.39817864e-02f, -2.48871539e-02f, -2.61083096e-02f,
  1.38069857e-02f, 1.45995459e-02f, -1.23179648e-02f, 1.05524659e-02f, 9.00246799e-02f, 2.68489458e-02f, -6.17933366e-03f, -9.25385207e-03f, -3.74337472e-02f, -1.38165876e-02f,
  -1.06889913e-02f, -6.71665883e-04f, 7.42629776e-03f, -8.48013209e-04f, -1.45382425e-02f, -3.53199355e-02f, -1.42052593e-02f, 2.29970515e-02f, 4.21401449e-02f, 2.75217257e-02f,
  3.78337130e-02f, -1.28179230e-02f, -1.26311323e-02f, 5.17322905e-02f, 1.83954462e-02f, -1.14110177e-02f, -2.22489163e-02f, 2.53860019e-02f, 3.45717669e-02f, 2.81864982e-02f,
  6.91989586e-02f, 3.74784358e-02f, 2.24145688e-02f, 9.84344538e-03f, -2.72145495e-02f, 2.39295028e-02f, 3.17926682e-03f, 2.52649933e-02f, 3.30975577e-02f, -2.28009261e-02f,
  -8.29138979e-03f, 4.18458953e-02f, -2.33263187e-02f, 6.66108506e-04f, 8.05053562e-02f, -1.71517849e-03f, -1.98487528e-02f, 6.48291931e-02f, 4.70444467e-03f, 3.03408094e-02f,
  6.11490868e-02f, -9.29633970e-04f, -1.19533204e-02f, 8.51139054e-02f, 5.58087826e-02f, 5.48862480e-03f, -3.92259937e-03f, -3.92551832e-02f, 2.64285654e-02f, 1.88432224e-02f,
  -5.59389964e-03f, -1.23472866e-02f, 4.09525121e-03f, 8.16829130e-03f, -6.41160458e-02f, 5.76409604e-03f, 1.50153646e-02f, 1.85421444e-02f, 9.56575479e-03f, -1.27820419e-02f,
  -9.63848829e-02f, -4.18166630e-02f, -8.28616768e-02f, -1.66365094e-02f, -2.47564372e-02f, 3.21334042e-02f, 6.33559152e-02f, -5.91523200e-03f, -6.81653693e-02f, 3.05577577e-03f
};

// L0_fan_Wp_bar (Shape: 8 x 120)
const int L0_fan_Wp_bar_rows = 8;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  1.95723120e-02f, -1.01745844e-01f, 1.67238668e-01f, 2.61891335e-01f, -1.35143384e-01f, -1.58709407e-01f, -1.31012052e-01f, 5.55944033e-02f, -1.42096296e-01f, -1.54943362e-01f,
  -8.04271623e-02f, -9.01214927e-02f, -6.27139732e-02f, 1.19063757e-01f, 2.17630621e-02f, -1.42287269e-01f, 7.92203005e-03f, -9.61346477e-02f, 4.57273200e-02f, 8.40502698e-03f,
  1.67322010e-01f, 1.40132517e-01f, 2.18761876e-01f, 1.93384290e-01f, 7.62594938e-02f, 1.75033614e-01f, 1.63334474e-01f, 3.72173563e-02f, 1.75272137e-01f, 6.39940575e-02f,
  -3.45333070e-02f, -7.64001813e-03f, 4.80151996e-02f, 2.90204100e-02f, 1.04668252e-01f, 3.38348225e-02f, 2.84002852e-02f, -2.50320919e-02f, 4.51410981e-03f, 1.90874711e-02f,
  -3.78200188e-02f, 7.35308826e-02f, 3.25498804e-02f, 5.89990355e-02f, 1.29183112e-02f, 4.12252033e-03f, -4.14673984e-02f, -6.86312690e-02f, 4.34374698e-02f, 8.33320767e-02f,
  6.24516234e-02f, 3.86453681e-02f, 1.87485032e-02f, 4.62748446e-02f, 3.68888192e-02f, 9.72753798e-04f, 2.81896051e-02f, 1.54178655e-02f, -3.85371484e-02f, 2.17461702e-03f,
  3.57248709e-02f, 2.71961223e-02f, 1.39694056e-03f, -2.57730782e-02f, -9.39517748e-03f, -3.80289555e-02f, 2.28921436e-02f, -1.93382073e-02f, 5.54679260e-02f, -3.95670496e-02f,
  -7.25803897e-02f, 6.71028048e-02f, 2.71048844e-02f, -1.82028543e-02f, -2.97147296e-02f, 3.05832159e-02f, 1.98970865e-02f, 2.38042101e-02f, -1.89134479e-02f, -2.22222079e-02f,
  -8.03895295e-02f, -1.25660263e-02f, -3.25715765e-02f, -3.02507747e-02f, -2.60963757e-02f, 3.73435020e-02f, -5.78705780e-03f, -7.82536343e-02f, -1.62934382e-02f, 3.79090151e-03f,
  5.66215329e-02f, 1.17509149e-01f, 2.14519147e-02f, -1.01634882e-01f, -3.37475315e-02f, -1.49850160e-01f, -4.77403738e-02f, -4.57399860e-02f, 3.24006565e-02f, 7.67795071e-02f,
  4.24201563e-02f, 9.54386219e-02f, 2.90493164e-02f, -4.56189588e-02f, 8.66593942e-02f, -8.40548053e-03f, 1.37518467e-02f, -1.66724678e-02f, 5.16870245e-02f, 3.61833796e-02f,
  -5.58177903e-02f, -1.67638343e-02f, -2.41892450e-02f, -8.65403190e-02f, 1.59342531e-02f, -2.69507477e-03f, 4.35685813e-02f, -3.23237367e-02f, -3.55162136e-02f, -1.75045859e-02f,
  9.86512899e-02f, -3.57559443e-01f, 9.42883566e-02f, 9.27738026e-02f, 1.72526091e-01f, 3.45055759e-02f, 1.53510273e-01f, -3.39177512e-02f, -8.25971738e-02f, -1.89154893e-01f,
  -5.58760539e-02f, -1.63035523e-02f, -4.54754308e-02f, 8.13591704e-02f, 1.13959529e-01f, 4.54215258e-02f, -6.02193400e-02f, -7.36428499e-02f, -1.54884011e-01f, -1.35561451e-02f,
  3.11189927e-02f, 1.49142370e-01f, 1.52892530e-01f, -9.88950804e-02f, 2.15688385e-02f, -8.61921161e-02f, 1.32451266e-01f, 6.68142289e-02f, 6.55635595e-02f, -2.46356446e-02f,
  -1.03521226e-02f, -2.74553057e-03f, -7.99148530e-03f, -1.17353089e-01f, 2.94086542e-02f, -2.64669321e-02f, 7.78572112e-02f, 3.36792059e-02f, 2.03921180e-02f, 2.55139414e-02f,
  7.84811676e-02f, 4.85747978e-02f, 9.02098641e-02f, 2.73710713e-02f, -4.90695201e-02f, 2.57347547e-03f, -7.58568570e-02f, -6.21826611e-02f, -3.52411866e-02f, -7.26976097e-02f,
  -3.33375968e-02f, 2.22390462e-02f, 6.30774871e-02f, -4.95437905e-02f, 4.29070666e-02f, -7.72766322e-02f, 8.12235102e-02f, -1.12666758e-02f, 5.44299707e-02f, -7.33092148e-03f,
  3.07327099e-02f, -2.64149811e-02f, -6.83532730e-02f, -1.81803778e-02f, -5.61635010e-03f, 3.08123417e-02f, -2.96874344e-02f, 4.81913984e-02f, 3.44481319e-02f, 1.06859952e-01f,
  9.14250687e-02f, -5.36528639e-02f, 9.62807331e-03f, -5.40327169e-02f, 1.72094293e-02f, -4.11172137e-02f, 3.84436622e-02f, 6.70442879e-02f, -4.37259376e-02f, -2.33763214e-02f,
  1.37834325e-01f, 2.05647089e-02f, -3.06464620e-02f, 4.20391075e-02f, -6.31613731e-02f, -3.92316431e-02f, 6.60760254e-02f, -8.13219175e-02f, -1.48242991e-03f, 9.57653522e-02f,
  -2.41333768e-01f, -1.93744734e-01f, 1.94214862e-02f, 9.80732962e-04f, -5.94859943e-02f, -1.10409096e-01f, 1.88846663e-02f, -9.28338338e-03f, -5.60350195e-02f, 6.00578077e-02f,
  -6.04418628e-02f, 4.87976372e-02f, -3.64187844e-02f, -5.30761518e-02f, 1.55204320e-02f, 4.57835570e-02f, 6.85925828e-03f, -6.91690519e-02f, 5.51388599e-02f, -5.36222942e-02f,
  7.76637569e-02f, 4.47574668e-02f, 2.14070864e-02f, -3.99184413e-03f, -5.44102229e-02f, 1.03001289e-01f, -3.35352309e-02f, -5.25083616e-02f, 1.88333280e-02f, -1.66646354e-02f,
  3.95816207e-01f, -2.94531167e-01f, 1.18842594e-01f, 3.52002889e-01f, 1.78901002e-01f, -7.11627454e-02f, -4.17574309e-03f, 9.03159901e-02f, 2.34792456e-01f, -1.45833343e-01f,
  -3.27279493e-02f, -3.70634347e-02f, -3.11302125e-01f, 1.00527868e-01f, -1.61474496e-01f, -2.06492826e-01f, 1.08580612e-01f, 7.47594843e-03f, 6.15039095e-02f, 4.15371731e-02f,
  1.76020280e-01f, -4.43729162e-02f, -7.39858523e-02f, -1.07176170e-01f, 1.53407767e-01f, 2.93909088e-02f, -1.23990558e-01f, -1.20819800e-01f, 7.33186603e-02f, -3.98108400e-02f,
  -3.08790011e-03f, 3.44123319e-02f, -3.12827677e-02f, -4.02739011e-02f, 1.53878136e-02f, 2.67887162e-03f, -9.30800587e-02f, -1.12469852e-01f, 6.53790310e-02f, 8.95986930e-02f,
  -3.51445600e-02f, 1.75152849e-02f, 1.03259347e-01f, -2.76723206e-02f, 3.28639746e-02f, 8.82566497e-02f, 7.62600377e-02f, 7.60283172e-02f, 5.97144067e-02f, 1.79351792e-02f,
  1.58138853e-02f, 3.16537470e-02f, 5.88550344e-02f, 3.40048522e-02f, 1.58306565e-02f, 3.36978808e-02f, 6.24110596e-03f, 1.66521594e-02f, 7.54389688e-02f, 2.45178454e-02f,
  -1.24176731e-02f, -1.70871690e-02f, 2.53660884e-02f, 7.30339289e-02f, 1.49479648e-02f, 8.64828974e-02f, -1.51296752e-02f, 1.32869547e-02f, 2.05870494e-02f, 1.58746243e-02f,
  -1.38069354e-02f, 7.20000118e-02f, 2.68924832e-02f, 7.26054562e-03f, 6.15934618e-02f, 9.28572342e-02f, 2.59419493e-02f, 1.90604515e-02f, -2.63224412e-02f, 2.18376536e-02f,
  -4.89217564e-02f, 4.43683146e-03f, 1.62080973e-02f, 8.23796466e-02f, -4.72183488e-02f, -7.13721290e-02f, -3.85719016e-02f, 3.97820771e-02f, 1.46434074e-02f, -1.93709396e-02f,
  -2.30478793e-01f, -1.69682249e-01f, -2.60817930e-02f, -2.85170190e-02f, -4.53245714e-02f, 8.68814765e-04f, -4.69963215e-02f, 5.95931415e-05f, -1.56410392e-02f, 4.04414311e-02f,
  1.12607712e-02f, -2.06328393e-03f, -5.45108467e-02f, 3.53845321e-02f, -1.05937384e-01f, -9.43837315e-02f, 4.52258177e-02f, -6.19132519e-02f, -8.64098221e-02f, 1.83055662e-02f,
  -4.98351129e-03f, -7.41929933e-02f, 6.33852407e-02f, -2.40931977e-02f, -2.51673628e-02f, -3.96354571e-02f, 4.36812416e-02f, -6.12903424e-02f, -8.14654231e-02f, -2.12227665e-02f,
  -4.43458796e-01f, 8.61468762e-02f, -2.66036183e-01f, -1.91474974e-01f, 1.67502984e-02f, -9.17962044e-02f, -1.79499649e-02f, -5.87839000e-02f, -1.24273807e-01f, 2.05262229e-01f,
  6.20625056e-02f, -2.44267002e-01f, 7.35042244e-02f, -1.74091667e-01f, -4.16696548e-01f, -9.14016142e-02f, -2.71490574e-01f, -1.75017998e-01f, -8.04537907e-02f, -9.24147740e-02f,
  -1.37795061e-01f, -5.50169556e-04f, -2.05679491e-01f, 8.29691961e-02f, -4.49124426e-02f, 2.37822141e-02f, 8.33004639e-02f, 6.02342598e-02f, -6.11855350e-02f, -3.70721593e-02f,
  -3.14022228e-02f, 4.22024280e-02f, -2.18226034e-02f, -3.82059291e-02f, -1.19559638e-01f, 1.87573452e-02f, -5.52358031e-02f, 1.01583013e-02f, -2.94774026e-02f, -4.17349711e-02f,
  -6.35921806e-02f, -4.18860391e-02f, -2.21376400e-02f, 1.56024992e-02f, -5.07909022e-02f, -1.15301469e-02f, -5.11886999e-02f, -3.83106321e-02f, -2.76441239e-02f, -4.87624966e-02f,
  -1.00134172e-01f, -2.56699719e-03f, 3.94392200e-03f, -1.07876509e-01f, -3.29066180e-02f, 1.50848059e-02f, -8.53971913e-02f, -8.26105382e-03f, -7.16808215e-02f, 1.25266965e-02f,
  8.00865442e-02f, 3.39377597e-02f, 9.88719314e-02f, -4.93732542e-02f, 4.09954265e-02f, 1.34850489e-02f, -2.32688691e-02f, 3.68086658e-02f, 4.62693013e-02f, 6.53737485e-02f,
  -7.71555398e-03f, -5.60090994e-04f, 2.15859208e-02f, -5.73964650e-03f, -1.69767719e-02f, 2.90646702e-02f, -1.53900078e-02f, 4.25803624e-02f, 8.72553606e-03f, -1.36046335e-02f,
  2.00123116e-02f, 5.11788316e-02f, 5.09714708e-02f, 3.51164415e-02f, 1.12846512e-02f, 1.15701621e-02f, 4.52121114e-03f, 2.17675604e-02f, -4.73909825e-02f, -4.44557220e-02f,
  -9.30690616e-02f, 3.48132774e-02f, 4.56476100e-02f, -7.96359871e-03f, 1.50481267e-02f, -2.76647378e-02f, -5.60566075e-02f, -2.54189614e-02f, -7.13832155e-02f, 7.23570026e-03f,
  -2.65539195e-02f, -2.74226069e-02f, -8.26265365e-02f, -3.37951034e-02f, 8.55555199e-03f, -2.23182281e-03f, 7.74225742e-02f, 4.70776036e-02f, -4.04540170e-03f, -4.48191240e-02f,
  1.90598350e-02f, 8.48075375e-02f, 3.13356519e-02f, 8.65545794e-02f, -3.57309058e-02f, 2.25205086e-02f, 5.06765321e-02f, -5.14745750e-02f, -4.40604426e-02f, -6.96109310e-02f,
  1.35285422e-01f, 4.80115004e-02f, -2.54176199e-01f, -1.58891991e-01f, -1.85348958e-01f, 1.05020806e-01f, 4.53746021e-02f, -1.53603777e-01f, 5.13178222e-02f, 1.26788050e-01f,
  -1.34112490e-02f, -3.11440113e-03f, 1.72806546e-01f, -3.00707929e-02f, 4.29857671e-02f, 2.66466260e-01f, 1.12339064e-01f, 1.87876672e-02f, -9.66960490e-02f, -1.64161116e-01f,
  -8.52851719e-02f, -7.97308534e-02f, -4.51432914e-03f, -1.60172090e-01f, -1.75200075e-01f, -1.93763554e-01f, -5.91538660e-02f, -1.81455344e-01f, -1.31416112e-01f, -7.28421956e-02f,
  1.91394575e-02f, 2.18496658e-02f, -1.22174285e-01f, -1.29171489e-02f, 5.61283417e-02f, -6.91362843e-02f, -7.58104026e-02f, 1.64750796e-02f, -5.52156307e-02f, 4.02070209e-03f,
  4.63533588e-02f, 3.57021540e-02f, 4.96249758e-02f, -3.12406663e-02f, -1.57827839e-01f, -8.56620148e-02f, 1.99977332e-03f, -4.52935994e-02f, -4.23636548e-02f, -6.85598254e-02f,
  -8.69358182e-02f, -8.53527859e-02f, -4.79935259e-02f, 3.22943390e-03f, -1.53137594e-01f, -3.31528187e-02f, 1.31888226e-01f, -1.72797858e-03f, -9.58308578e-02f, -3.81848402e-02f,
  3.55446897e-03f, 6.33533522e-02f, 3.34110968e-02f, 3.71873491e-02f, -3.68276685e-02f, -7.53075769e-03f, 4.92419377e-02f, 6.54774085e-02f, 5.29643707e-02f, 3.01636513e-02f,
  1.35642421e-02f, -5.96892573e-02f, 1.79644059e-02f, 1.34749133e-02f, 8.21771100e-02f, 1.04913354e-01f, 6.08163290e-02f, -5.99674135e-03f, 2.90976893e-02f, 6.70353696e-02f,
  5.78091964e-02f, -3.34552526e-02f, 2.85072327e-02f, 1.13810385e-02f, 2.24720053e-02f, -4.86159399e-02f, -2.68482845e-02f, -3.21987532e-02f, 4.69275080e-02f, -1.88276841e-04f,
  2.93905511e-02f, 3.41306366e-02f, 3.66364531e-02f, -2.08156072e-02f, 1.77146550e-02f, -6.09152988e-02f, 5.50665483e-02f, -7.19422251e-02f, 5.67406677e-02f, -1.53100993e-02f,
  6.79595098e-02f, -2.70027178e-03f, -5.42165600e-02f, -5.34017496e-02f, -5.70230465e-03f, 1.89493243e-02f, 3.64197753e-02f, 6.28032237e-02f, 6.36552423e-02f, 3.79963182e-02f,
  3.39781567e-02f, 3.82521078e-02f, -1.76772140e-02f, 3.22954245e-02f, 3.96213830e-02f, -2.27547809e-02f, -3.12014222e-02f, -3.36340815e-02f, -4.04289737e-02f, -5.61269745e-02f,
  -4.15240414e-02f, 9.47738737e-02f, -1.32150324e-02f, 6.93046078e-02f, -1.04648054e-01f, -5.60430717e-03f, 6.55377433e-02f, 1.02453902e-02f, -1.43450312e-02f, 3.05509102e-03f,
  9.80139971e-02f, -2.42375303e-02f, -1.92971490e-02f, 6.72500730e-02f, 5.92808202e-02f, 1.44696787e-01f, -1.45979673e-02f, 7.07601681e-02f, 1.48491021e-02f, -7.11506903e-02f,
  7.67368749e-02f, 3.96729857e-02f, -1.39852688e-02f, 3.22907530e-02f, 2.10154545e-03f, -3.14747728e-02f, -7.07496107e-02f, -1.26313167e-02f, 2.31328048e-02f, 6.31529167e-02f,
  -8.06363076e-02f, -1.29808798e-01f, -9.98603478e-02f, 3.72613519e-02f, -7.07960501e-02f, -9.57650542e-02f, -4.48126756e-02f, -1.18199848e-02f, 8.85671079e-02f, 4.67297509e-02f,
  2.77318545e-02f, -5.29586058e-03f, 4.65540402e-02f, 9.13500495e-04f, -5.73030561e-02f, 5.80438673e-02f, -6.16980046e-02f, 3.36334221e-02f, -2.27206983e-02f, -4.24446277e-02f,
  -8.18958580e-02f, 6.97780401e-02f, 3.91485058e-02f, 1.87288020e-02f, -6.77920803e-02f, -9.35325325e-02f, 2.35066377e-02f, 1.55866481e-02f, 6.00545071e-02f, -9.86507814e-03f,
  1.87996421e-02f, -8.74218568e-02f, -4.29391637e-02f, -9.27588567e-02f, 2.61409041e-02f, -1.09252729e-03f, -7.73035884e-02f, 3.58001925e-02f, 4.20605838e-02f, -8.71351436e-02f,
  5.59841283e-03f, 2.65776236e-02f, 5.91646023e-02f, 1.73122305e-02f, -4.75968942e-02f, -6.00690581e-02f, 3.36454902e-03f, 4.58886512e-02f, -5.72625399e-02f, 4.42225933e-02f,
  2.49109254e-03f, 6.59208074e-02f, -4.13570590e-02f, 3.47791500e-02f, 5.72054163e-02f, -7.48899132e-02f, 4.63097058e-02f, -7.88596272e-02f, -1.57588702e-02f, 6.42455965e-02f,
  -3.32612731e-02f, -1.18093334e-01f, -9.31718796e-02f, -1.44245308e-02f, 2.83564758e-02f, -5.05049750e-02f, -8.01896676e-02f, -5.44764176e-02f, 6.21573068e-02f, -2.57048961e-02f,
  -8.49575922e-02f, -4.16536890e-02f, 7.58873448e-02f, -4.15168218e-02f, -1.11887418e-02f, 3.07585783e-02f, -8.03534612e-02f, 4.22117002e-02f, -2.80384682e-02f, 6.25700038e-03f,
  8.01171735e-03f, -3.93493380e-03f, 2.25289855e-02f, -4.49907780e-02f, -8.69347155e-02f, 6.53732046e-02f, 4.32582796e-02f, -7.66555443e-02f, -1.34713212e-02f, -1.59654934e-02f,
  -1.29617572e-01f, 2.61842906e-01f, 3.36400978e-02f, -2.04765171e-01f, 9.53107625e-02f, -1.09706812e-01f, -7.59411380e-02f, 2.69729104e-02f, 2.00657416e-02f, 7.85078406e-02f,
  -5.22818789e-02f, 1.71798214e-01f, -3.43603715e-02f, -1.72903553e-01f, -5.99335849e-01f, -2.63257176e-01f, -3.40354592e-01f, -3.02366936e-03f, -4.93133068e-02f, -2.77672056e-02f,
  -1.48442402e-01f, -1.35976404e-01f, -2.18710884e-01f, 6.97507337e-02f, 9.03429836e-02f, 1.42530918e-01f, 3.05897184e-02f, 1.47115678e-01f, 1.25960039e-03f, -4.89966646e-02f,
  1.51183167e-02f, 1.14372395e-01f, 1.13133669e-01f, 2.97151059e-02f, 2.43486576e-02f, 5.54390950e-03f, 1.98330614e-03f, 2.88673509e-02f, 3.21153142e-02f, 7.99415261e-03f,
  7.52789602e-02f, 3.81158851e-02f, -2.33141016e-02f, 2.25286651e-02f, 9.63203609e-02f, 5.97866178e-02f, 3.63448784e-02f, 5.92735596e-02f, 1.55089293e-02f, -1.61329452e-02f,
  -1.55831585e-04f, -1.26950219e-02f, -1.35250695e-04f, -9.41553246e-03f, -7.59659335e-02f, 1.20794028e-02f, -1.85162984e-02f, 1.29273273e-02f, 2.53384709e-02f, -2.84851082e-02f,
  -7.14193657e-02f, -2.96963844e-02f, -9.18906480e-02f, 7.85603896e-02f, -2.68428978e-02f, 3.23626818e-03f, -4.94777970e-03f, -6.46362305e-02f, -2.02291254e-02f, -1.19609805e-02f,
  2.92253904e-02f, -4.84380275e-02f, 4.84894961e-03f, -8.37967452e-03f, -3.83927189e-02f, 1.81946978e-02f, 1.82855148e-02f, -3.41199450e-02f, -3.01865917e-02f, -4.95152846e-02f,
  3.87331545e-02f, -6.12298213e-02f, 6.12456240e-02f, -2.69322507e-02f, -3.41099352e-02f, 1.93080287e-02f, -4.97253351e-02f, 6.06861077e-02f, -4.07174230e-02f, 2.63176905e-03f,
  7.71730021e-02f, -3.66397644e-03f, 3.75103727e-02f, 6.53587207e-02f, 6.45783097e-02f, -7.95216486e-02f, -4.08005752e-02f, -3.85273471e-02f, 3.43799330e-02f, -3.59743834e-02f,
  5.76362945e-02f, -8.31188518e-04f, 2.48416588e-02f, 4.09292569e-03f, -6.46372046e-03f, -1.85699128e-06f, -1.05327293e-01f, 3.28705981e-02f, 2.39385292e-02f, 4.29811329e-02f,
  6.57078251e-02f, -2.02039517e-02f, -8.99248198e-02f, -4.89392169e-02f, -1.14977378e-02f, 2.33453978e-02f, 3.44314948e-02f, 4.14467938e-02f, -2.21919864e-02f, -3.47501859e-02f,
  -5.62093854e-02f, -9.98492017e-02f, 2.16558389e-02f, 8.68525803e-02f, -1.62041634e-01f, -2.78108597e-01f, -2.24976391e-01f, -3.60523686e-02f, 1.34037048e-01f, -1.60501093e-01f,
  -1.18368261e-01f, 1.27704680e-01f, 1.51069276e-02f, -7.63278501e-03f, -2.92980261e-02f, 4.46429141e-02f, -9.16958228e-02f, 1.62590314e-02f, 1.07411370e-01f, -6.58972487e-02f,
  5.64401224e-02f, 3.89957726e-02f, 8.56624842e-02f, 6.65597320e-02f, -3.12774740e-02f, 1.26885667e-01f, 1.59398720e-01f, 1.05212048e-01f, 2.55579650e-02f, 5.24610840e-02f,
  -4.39531356e-02f, -4.43623737e-02f, 7.33355619e-03f, -1.74699537e-02f, -7.78013691e-02f, -2.08972730e-02f, -3.50801237e-02f, 2.59463564e-02f, -7.67550468e-02f, 3.27636153e-02f,
  1.16145154e-02f, -4.83044535e-02f, 1.36185894e-02f, 6.85605556e-02f, 6.30317209e-03f, -4.90336046e-02f, 1.79503858e-02f, -2.90411543e-02f, 2.01430023e-02f, -4.24754880e-02f,
  3.91229875e-02f, 2.96871085e-02f, -3.96930762e-02f, 6.80113211e-03f, 2.91322172e-02f, 1.73959117e-02f, 5.45850471e-02f, -5.31656258e-02f, 8.12326521e-02f, 5.03115244e-02f,
  -4.49553691e-02f, 6.77991956e-02f, -6.41440004e-02f, 9.11569223e-02f, 4.35744934e-02f, 7.28723593e-03f, -7.07147717e-02f, 2.54079234e-02f, 3.09243356e-03f, -4.11055936e-03f,
  -2.10629068e-02f, -4.01745401e-02f, 1.84377320e-02f, 4.74296138e-02f, -5.82099557e-02f, 5.42430058e-02f, -1.08146053e-02f, 2.33544968e-02f, 3.06830015e-02f, 2.06693020e-02f,
  6.90644011e-02f, -2.54597105e-02f, -3.61267035e-03f, -2.31854245e-02f, -9.19288099e-02f, -2.70026848e-02f, 4.15833332e-02f, 1.54036125e-02f, 3.73014063e-02f, -1.86489746e-02f,
  -2.46783290e-02f, 5.89630082e-02f, 2.68191774e-03f, -4.00175387e-03f, -4.94647324e-02f, 2.53775399e-02f, -3.50896679e-02f, 2.63436213e-02f, 2.62028109e-02f, 3.98696288e-02f,
  -2.55322759e-03f, -1.81607734e-02f, -6.76012114e-02f, 4.04821150e-02f, 1.16983093e-02f, -9.44416132e-03f, 7.50577822e-02f, 9.48004276e-02f, -1.08718760e-02f, -1.92683015e-03f,
  -1.44671295e-02f, -1.09815933e-01f, 3.13982554e-02f, -6.74732998e-02f, 1.22321611e-02f, -1.48119126e-02f, 2.39325352e-02f, 5.83492741e-02f, -1.82027109e-02f, 1.54115586e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 8)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 8;
const float L0_fan_Bp_bar_data[] = {
  3.69591117e-02f, 4.50123027e-02f, 1.16984524e-01f, 2.07457095e-01f, 1.87169001e-01f, 4.96109538e-02f, 1.49938419e-01f, -2.68071201e-02f
};

// L1_fan_Wp (Shape: 12 x 32)
const int L1_fan_Wp_rows = 12;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  2.59680599e-01f, 8.99525732e-02f, 9.25322697e-02f, -2.17875868e-01f, 1.21852115e-01f, -5.91545701e-02f, -1.71270654e-01f, -1.28659874e-01f, 7.40250647e-02f, 3.65049750e-01f,
  -6.01354688e-02f, 2.72216201e-01f, -2.12443113e-01f, 1.28634349e-01f, 3.14095020e-01f, -1.27047077e-01f, 1.88331351e-01f, -1.53562337e-01f, 1.83092386e-01f, -1.97098166e-01f,
  2.41553649e-01f, -1.85522094e-01f, -1.06660381e-01f, 2.65354604e-01f, 3.58681590e-03f, -1.82210550e-01f, 4.27060276e-02f, -7.15259835e-02f, 2.25224376e-01f, -6.97206855e-02f,
  -1.68462366e-01f, 2.94918478e-01f, 2.28166595e-01f, 2.63008047e-02f, -1.16667710e-01f, -1.21365950e-01f, 6.46812022e-02f, -8.16233233e-02f, -1.44790515e-01f, -1.00070558e-01f,
  1.10889293e-01f, 1.53647244e-01f, -9.25614834e-02f, -2.10757311e-02f, -2.84538358e-01f, 1.45720735e-01f, 3.13426554e-01f, 1.41446218e-01f, 5.99545650e-02f, -8.90087709e-02f,
  3.59312832e-01f, -3.74457538e-01f, 8.32072049e-02f, -1.85588345e-01f, -2.06321135e-01f, 2.62451589e-01f, -1.11225918e-02f, -2.04956427e-01f, 1.16579607e-01f, -2.39836812e-01f,
  1.90811992e-01f, 4.36962396e-03f, 1.14696838e-01f, 1.72380209e-02f, -3.50600630e-02f, 1.44992322e-01f, 7.49093592e-02f, 1.47724554e-01f, -1.28671497e-01f, 2.46950790e-01f,
  4.15454432e-02f, 1.63904086e-01f, 4.28876691e-02f, -2.29435146e-01f, -2.47715209e-02f, 7.86381960e-02f, 3.29281121e-01f, -1.25942221e-02f, -1.35389045e-01f, 2.05505237e-01f,
  3.57275605e-02f, 2.10034505e-01f, -9.86460075e-02f, 7.76062012e-02f, 1.62769496e-01f, 1.89329103e-01f, 4.17730302e-01f, 5.10645397e-02f, -5.07220887e-02f, -1.10765561e-01f,
  -3.28753084e-01f, -2.21243277e-01f, 6.46402091e-02f, 5.17163128e-02f, 4.35502790e-02f, -6.29632771e-02f, -9.78874862e-02f, 1.38970790e-02f, -1.70133740e-01f, -9.16490331e-02f,
  -4.32987213e-02f, 3.16579580e-01f, -1.33967325e-01f, 2.12955430e-01f, 1.96772456e-01f, -1.92130879e-01f, 2.29737163e-02f, 3.75726745e-02f, 4.67564911e-01f, 1.45847812e-01f,
  -1.40997991e-01f, -2.25406475e-02f, -1.15112722e-01f, 2.39797123e-02f, 6.44396991e-02f, -6.19994514e-02f, -5.66190854e-02f, 3.55698401e-03f, 1.02697805e-01f, 1.40613079e-01f,
  -2.35398874e-01f, 1.99977294e-01f, 9.82204918e-03f, -1.03917606e-01f, 2.57714778e-01f, 5.75480005e-03f, -2.48849899e-01f, 1.06997900e-01f, 1.41030163e-01f, 1.28140152e-01f,
  9.35003683e-02f, -3.65689769e-02f, -6.35501891e-02f, -1.34485379e-01f, -8.43794271e-02f, 1.66997895e-01f, 9.90837440e-02f, -4.84412648e-02f, -7.14639351e-02f, 6.20653816e-02f,
  5.09666562e-01f, -2.58248955e-01f, 1.11077599e-01f, 6.66338578e-02f, -6.21538498e-02f, -6.15487434e-02f, 4.15512696e-02f, -2.05236644e-01f, 5.67448959e-02f, -1.74116455e-02f,
  9.80309471e-02f, -1.01177633e-01f, -1.87173367e-01f, 1.91066682e-03f, -1.20755918e-01f, -2.95218099e-02f, 3.34732354e-01f, 2.73596440e-02f, -1.08367980e-01f, 8.78240392e-02f,
  3.05994973e-02f, 2.25213587e-01f, -4.36290279e-02f, 1.25263497e-01f, -1.15605354e-01f, 3.05749308e-02f, -9.90834311e-02f, -2.36669436e-01f, 1.71713028e-02f, -7.43269771e-02f,
  -1.26723096e-01f, 4.61160541e-02f, 6.72858506e-02f, -4.49261487e-01f, 1.98307298e-02f, -8.61440748e-02f, 1.00182362e-01f, -6.10773675e-02f, -3.86742771e-01f, 3.12235743e-01f,
  1.04582570e-01f, 6.57883957e-02f, -1.82594106e-01f, -2.56968975e-01f, -2.31444687e-01f, -1.25517929e-03f, -1.87631279e-01f, 3.93722206e-01f, 5.04941940e-02f, 2.15301546e-03f,
  2.65752286e-01f, 1.18978932e-01f, 3.25387903e-02f, 1.62581801e-01f, 8.06070566e-02f, 1.71787236e-02f, 1.19953804e-01f, -1.64835602e-01f, -9.32091922e-02f, 4.44414057e-02f,
  -2.75020134e-02f, 1.36123896e-01f, 4.17779088e-02f, 1.20706195e-02f, 8.40488449e-02f, 1.33203343e-01f, 9.06606838e-02f, -2.94055462e-01f, 1.85790971e-01f, -1.71479896e-01f,
  2.10342377e-01f, 7.18405545e-02f, 1.10179029e-01f, -6.56023473e-02f, 8.05056244e-02f, -1.76628843e-01f, 2.34339938e-01f, -7.01582134e-02f, -2.81119585e-01f, -2.37474814e-01f,
  1.00545309e-01f, 2.31931801e-03f, -3.16305786e-01f, -8.87915716e-02f, -1.54526338e-01f, -4.15121298e-03f, 1.08263567e-01f, 5.73912896e-02f, 1.65876031e-01f, -8.72702450e-02f,
  8.20471868e-02f, -1.31575465e-01f, 7.37095997e-02f, -2.24810233e-03f, 4.67358641e-02f, -6.18176274e-02f, -1.12524964e-01f, -3.63302976e-02f, 3.69090773e-02f, -4.51355502e-02f,
  -6.13318570e-03f, -2.10221514e-01f, -2.61720605e-02f, 1.72687382e-01f, -3.49982046e-02f, 1.05999596e-01f, -1.59156784e-01f, 3.26366909e-02f, 3.25752944e-02f, -9.27130803e-02f,
  -3.23465094e-02f, 2.39988267e-01f, 9.15140808e-02f, -7.86933675e-02f, -1.03177549e-02f, 1.99347675e-01f, 3.60864662e-02f, -2.20958009e-01f, 1.05883263e-01f, 2.88284063e-01f,
  -5.66008501e-02f, 1.20754816e-01f, 2.45955244e-01f, -1.42936856e-01f, -4.63939719e-02f, -2.21497193e-01f, 3.75917219e-02f, -4.29360978e-02f, -2.43428543e-01f, 2.48406231e-01f,
  -3.15322131e-01f, -1.44971339e-02f, -1.45768553e-01f, 1.76241964e-01f, -2.44558394e-01f, -2.84919720e-02f, -7.79190809e-02f, -5.72048267e-03f, 1.28316134e-01f, 1.76715642e-01f,
  4.61021764e-03f, 7.61508346e-02f, 2.67627746e-01f, 7.02019557e-02f, -2.35748470e-01f, -1.26750872e-01f, 3.03824306e-01f, -3.44271809e-02f, -8.10619071e-02f, 4.01763208e-02f,
  7.72385672e-02f, -1.48720548e-01f, 8.33606347e-02f, -2.38617793e-01f, -2.36107767e-01f, 4.52050529e-02f, 1.61700606e-01f, 1.37955725e-01f, -7.33705685e-02f, 5.79603016e-02f,
  1.00220129e-01f, -4.36229914e-01f, 3.32383551e-02f, -2.33263910e-01f, 7.97031149e-02f, -1.66243892e-02f, 1.31792083e-01f, 1.23306222e-01f, 3.83406244e-02f, -2.63520807e-01f,
  -2.45294482e-01f, -1.81856588e-01f, 9.08448696e-02f, -1.83431298e-01f, 2.12915242e-01f, 6.87723458e-02f, -8.90438110e-02f, 3.71042043e-02f, 1.79364860e-01f, 2.08369672e-01f,
  1.38839409e-01f, -8.09958130e-02f, 2.03578904e-01f, -5.65900579e-02f, 2.34717712e-01f, -5.57723083e-02f, -1.98608655e-02f, 1.73388049e-02f, 5.60356751e-02f, 1.95463628e-01f,
  1.35449588e-01f, 1.77174941e-01f, -6.66623473e-01f, 1.31605178e-01f, 3.04853469e-01f, -2.25542247e-01f, 2.31652603e-01f, -1.22884996e-01f, 3.67331058e-01f, -1.05286799e-01f,
  7.59509429e-02f, -1.20778784e-01f, -3.24456125e-01f, 3.81057203e-01f, 1.41391858e-01f, -2.10818142e-01f, 2.79257029e-01f, -2.15565786e-01f, -2.52552420e-01f, -2.04886511e-01f,
  8.81362036e-02f, -1.20929889e-01f, 2.38391813e-02f, 1.87738612e-01f, -5.66214547e-02f, -9.75888297e-02f, -8.27761143e-02f, 1.86989740e-01f, -1.44385993e-01f, 2.64291298e-02f,
  2.59953499e-01f, -2.04760611e-01f, -9.75628495e-02f, -4.36263010e-02f, 4.05922264e-01f, 1.42370686e-01f, 1.91873953e-01f, 2.16721460e-01f, 1.66620031e-01f, 1.37517765e-01f,
  2.86103308e-01f, -1.30251303e-01f, 2.20853090e-01f, 1.45745263e-01f, 2.92245358e-01f, 9.56759825e-02f, -2.63262600e-01f, -1.10521525e-01f, -3.36463630e-01f, -2.76609540e-01f,
  3.14995974e-01f, 1.55302845e-02f, -2.05966353e-01f, -1.15160018e-01f
};

// L1_fan_Wp_bar (Shape: 8 x 32)
const int L1_fan_Wp_bar_rows = 8;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  1.25347704e-01f, -1.59518182e-01f, 2.23130882e-01f, 2.55265826e-04f, 2.70427495e-01f, 1.29071727e-01f, -7.79756755e-02f, -1.40484869e-01f, -1.37183085e-01f, -1.05529698e-03f,
  -2.47796886e-02f, 1.61918417e-01f, -1.12510681e-01f, 3.88943911e-01f, 7.92729929e-02f, -2.00656563e-01f, -1.19825611e-02f, 1.40100360e-01f, 3.06269765e-01f, -1.44792870e-01f,
  6.13639727e-02f, 1.43670872e-01f, 8.15358311e-02f, 7.83220008e-02f, 3.52640487e-02f, 1.65167123e-01f, 3.04597229e-01f, 5.72715327e-02f, 1.62671745e-01f, 6.53886795e-02f,
  -1.76221341e-01f, 1.69857383e-01f, 2.74399258e-02f, -4.28138711e-02f, 2.85525080e-02f, 6.87424541e-02f, 1.73216358e-01f, 1.05730340e-01f, -1.10389590e-01f, -9.71628353e-02f,
  -6.96991235e-02f, -1.05221748e-01f, -7.49087334e-02f, -8.30271766e-02f, -8.02292153e-02f, 1.42855421e-01f, -1.17258564e-01f, -7.89892972e-02f, -1.00443743e-01f, -1.34678483e-01f,
  -4.83715301e-03f, 8.31981674e-02f, 9.64650288e-02f, 1.38950735e-01f, -6.77202120e-02f, 4.96338028e-03f, -9.73925591e-02f, -9.70869362e-02f, 1.26398534e-01f, -1.00522719e-01f,
  1.45303920e-01f, 1.62758812e-01f, -1.58326775e-01f, -1.29255340e-01f, -1.50247477e-02f, 7.56918043e-02f, -1.00364342e-01f, 2.41639197e-01f, 9.69227552e-02f, 2.74856240e-01f,
  2.34652832e-01f, 2.63765454e-02f, 5.72885759e-02f, -1.09850965e-01f, 1.98117197e-01f, 1.19274100e-02f, 3.93114835e-02f, 1.45090120e-02f, -1.34932220e-01f, 1.40509367e-01f,
  7.03650787e-02f, -8.43918920e-02f, -3.06963623e-01f, 1.79048568e-01f, -1.48686633e-01f, -2.12149546e-02f, 1.01533987e-01f, -2.50156164e-01f, -1.72080815e-01f, 8.08702186e-02f,
  -4.67671007e-02f, 2.22109735e-01f, 1.05556570e-01f, -6.95133582e-03f, 2.99204618e-01f, -8.21968243e-02f, 2.36430675e-01f, -3.66382599e-02f, 2.98995852e-01f, 2.39444554e-01f,
  6.22548796e-02f, 3.36915225e-01f, 2.37707600e-01f, 1.95950866e-01f, 9.38536692e-03f, -4.53500375e-02f, 1.10087425e-01f, 1.97541326e-01f, 2.58119971e-01f, 4.31910247e-01f,
  6.73908833e-03f, -1.24580652e-01f, -7.42683634e-02f, -4.27561440e-02f, -4.58812118e-02f, 2.59802878e-01f, -1.73002735e-01f, 2.70367324e-01f, 3.54317427e-01f, -4.98139895e-02f,
  -1.04705922e-01f, 4.14806187e-01f, 7.48602077e-02f, 4.47744206e-02f, 7.59354830e-02f, -1.00436032e-01f, -2.40730703e-01f, -2.21690491e-01f, 1.10523135e-03f, 4.56125915e-01f,
  2.45926440e-01f, 1.97495706e-02f, 1.51885942e-01f, 6.37486875e-02f, 3.28393519e-01f, 2.10528195e-01f, 3.97554815e-01f, 4.37682569e-01f, -1.36181965e-01f, 3.33433747e-01f,
  1.70981944e-01f, -4.35567468e-01f, 5.55058599e-01f, -6.16534412e-01f, 4.62327808e-01f, -6.25418901e-01f, 8.77004638e-02f, 3.76032561e-01f, -7.67664658e-03f, -2.10691303e-01f,
  2.19801873e-01f, -5.67059278e-01f, 3.86640131e-01f, -1.86996520e-01f, -1.67217329e-01f, 1.73923030e-01f, 5.36448769e-02f, 1.82039276e-01f, 1.00073151e-01f, 7.22328946e-03f,
  4.02346738e-02f, -2.18790472e-01f, 1.60542786e-01f, -1.25075802e-01f, 4.25615683e-02f, 7.73106068e-02f, 2.24617049e-02f, 7.91648999e-02f, -1.29802451e-01f, 1.15020432e-01f,
  2.47258648e-01f, 6.38491586e-02f, -2.84176946e-01f, 1.43119320e-01f, -9.81329829e-02f, -1.45570561e-01f, 1.57450318e-01f, -5.78227937e-02f, -2.77857125e-01f, 1.68446690e-01f,
  -2.35331133e-01f, -6.23174831e-02f, -2.97703836e-02f, -2.02390432e-01f, 5.66726550e-02f, 1.90156564e-01f, 8.34137276e-02f, 3.21849316e-01f, -2.49243632e-01f, 1.35849997e-01f,
  4.24279779e-01f, -1.82116684e-02f, 1.55016914e-01f, -2.41408899e-01f, 3.29030991e-01f, 2.15598866e-01f, 3.05320144e-01f, 3.04230899e-01f, 5.30402243e-01f, 3.27192456e-01f,
  3.60162146e-02f, -1.43968016e-01f, 5.11017621e-01f, 1.90180406e-01f, -1.16501614e-01f, 6.13764346e-01f, -2.64099360e-01f, 1.18521400e-01f, -1.13446660e-01f, 4.06949729e-01f,
  1.92861006e-01f, 1.05177853e-02f, -1.00775525e-01f, 2.88797349e-01f, -1.85324177e-02f, 4.64410335e-01f, -1.06693797e-01f, 2.06433401e-01f, 4.65389848e-01f, -4.75424007e-02f,
  -2.39557847e-02f, -1.05075635e-01f, 1.81586951e-01f, -2.37689093e-01f, 5.80773354e-02f, 1.82764381e-01f, 1.78528547e-01f, 1.16524927e-01f, -8.58813450e-02f, 3.18458289e-01f,
  2.46169090e-01f, 2.31413871e-01f, 3.12854230e-01f, 5.34601435e-02f, 2.61449695e-01f, 4.28578109e-02f, 1.67425796e-01f, -4.40777600e-01f, -1.45186111e-01f, 2.22982243e-01f,
  -2.50840157e-01f, 2.76006639e-01f, -2.48259619e-01f, 5.12068979e-02f, 8.32902789e-02f, -1.14873417e-01f, -1.55273497e-01f, -9.41051692e-02f, -6.63733482e-02f, -1.32055789e-01f,
  1.13131456e-01f, 4.28797662e-01f, 5.99803329e-02f, 8.48093852e-02f, 3.04309905e-01f, -6.13672659e-04f
};

// L1_fan_Bp_bar (Shape: 1 x 8)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 8;
const float L1_fan_Bp_bar_data[] = {
  2.22527042e-01f, -1.26062796e-01f, 6.75998256e-02f, 3.19986612e-01f, 1.81605235e-01f, 2.17689171e-01f, 2.86399454e-01f, 1.87528685e-01f
};

// L2_fan_Wp (Shape: 12 x 32)
const int L2_fan_Wp_rows = 12;
const int L2_fan_Wp_cols = 32;
const float L2_fan_Wp_data[] = {
  1.58533946e-01f, -6.01693913e-02f, -4.72199321e-02f, -2.59402633e-01f, -1.56746045e-01f, -5.40757105e-02f, -1.94242567e-01f, -2.39159718e-01f, -2.29642421e-01f, -8.16861242e-02f,
  -2.59124041e-01f, -1.06057703e-01f, 6.17042221e-02f, 1.43492132e-01f, -3.39940965e-01f, -4.73236233e-01f, -3.70256871e-01f, -5.21626286e-02f, -7.84596056e-02f, 3.28285992e-02f,
  2.37874448e-01f, 4.84481677e-02f, 5.30798674e-01f, -4.42927480e-01f, 8.14207941e-02f, 3.20737213e-02f, -1.36384413e-01f, -3.26134488e-02f, 1.16791874e-02f, 2.43826613e-01f,
  -1.38683259e-01f, -1.72270551e-01f, 6.21304847e-02f, 2.06061393e-01f, 8.42469633e-02f, 1.51443496e-01f, -8.80612656e-02f, -1.49276599e-01f, 1.42024755e-01f, 2.55440772e-01f,
  3.16301419e-04f, 2.71077096e-01f, 7.07116723e-02f, -4.16212119e-02f, 2.91245282e-01f, 1.12344265e-01f, -3.35447431e-01f, -3.89296152e-02f, 6.25691339e-02f, 2.70393878e-01f,
  9.51663628e-02f, 1.34476811e-01f, -2.37790376e-01f, 1.97275698e-01f, 1.28244340e-01f, -3.33333135e-01f, -4.31871153e-02f, 1.06666625e-01f, -1.01284958e-01f, -1.76322550e-01f,
  3.76777291e-01f, 2.28079602e-01f, -4.19270873e-01f, -1.27236217e-01f, 8.10816512e-02f, -7.40024447e-02f, 2.28419721e-01f, 1.42214835e-01f, -1.96149886e-01f, 2.49772623e-01f,
  -2.01998517e-01f, 1.08415432e-01f, -1.54172912e-01f, 1.45523436e-02f, -6.44800812e-03f, 1.20269313e-01f, 1.03099234e-01f, 8.85786191e-02f, 6.92265481e-02f, 2.10321158e-01f,
  1.52700141e-01f, 8.26727673e-02f, 1.55621976e-01f, -8.58525783e-02f, -2.56170213e-01f, 3.68268520e-01f, -1.77702010e-01f, 7.32903332e-02f, 2.10295375e-02f, -3.28779817e-02f,
  -8.06704909e-02f, -3.78349453e-01f, 1.53081477e-01f, -2.70283580e-01f, -3.70020360e-01f, 1.82947576e-01f, 3.93500589e-02f, -5.67624252e-03f, 1.93037376e-01f, -1.01973407e-01f,
  1.10787310e-01f, -9.98532921e-02f, 1.22685567e-01f, 8.70492607e-02f, -1.74291641e-01f, -1.42099401e-02f, 2.44218320e-01f, 8.91161412e-02f, -1.50205180e-01f, 1.17738567e-01f,
  2.70367973e-03f, 5.93533888e-02f, -7.98261687e-02f, -1.63045049e-01f, -1.19516753e-01f, -1.60449818e-01f, 1.04340591e-01f, -2.40289301e-01f, -5.02831675e-02f, 1.24624237e-01f,
  -1.51028171e-01f, 1.66193992e-01f, 1.17269933e-01f, 2.11519107e-01f, -3.85256380e-01f, 1.12576902e-01f, 4.85174984e-01f, 9.79122296e-02f, 1.81260332e-01f, 2.22313523e-01f,
  6.05508238e-02f, 1.53787628e-01f, 2.01468974e-01f, 1.60488904e-01f, -1.34578079e-01f, 5.16624004e-02f, 1.01540193e-01f, 3.91474739e-02f, -2.23713415e-03f, 1.25850171e-01f,
  -1.01870939e-01f, -8.62844959e-02f, 2.13209823e-01f, -2.21654087e-01f, 1.05102681e-01f, 3.50050509e-01f, -6.40958995e-02f, 1.86723575e-01f, 2.60560978e-02f, 4.00645971e-01f,
  -1.77412346e-01f, -3.45550507e-01f, -2.24098876e-01f, -9.42004323e-02f, 1.15517072e-01f, -2.26860613e-01f, 4.27630633e-01f, -1.11384578e-01f, -1.92525387e-01f, 2.82453477e-01f,
  4.33757640e-02f, -2.12460414e-01f, -2.52954781e-01f, 1.34434238e-01f, -6.65351450e-02f, 6.50997385e-02f, -1.34609714e-01f, -7.14578629e-02f, -7.29121417e-02f, 8.81871879e-02f,
  1.22673243e-01f, -8.77974033e-02f, -4.42853898e-01f, -4.04869229e-01f, 1.33399650e-01f, 6.53257966e-03f, -9.89471525e-02f, -3.44400704e-02f, -5.27980477e-02f, 2.74965726e-03f,
  3.48034441e-01f, -3.79099369e-01f, -8.31827745e-02f, -1.58238351e-01f, 9.36349556e-02f, -3.32707092e-02f, 8.04590881e-02f, 3.87684435e-01f, -2.95306742e-01f, 2.82991081e-01f,
  3.66068572e-01f, -1.60634235e-01f, -8.03594068e-02f, 2.67559923e-02f, -2.13537827e-01f, -9.38883051e-02f, -6.17235154e-02f, -2.43747026e-01f, 3.09565756e-03f, -2.34568231e-02f,
  -1.80951715e-01f, -1.44358590e-01f, -1.30369915e-02f, -2.52180934e-01f, -3.79117608e-01f, -4.00383323e-01f, 2.49982789e-01f, 1.86207831e-01f, 8.71750619e-03f, 3.52160513e-01f,
  -2.20593393e-01f, 1.23643272e-01f, 1.34818450e-01f, -1.55525327e-01f, -2.81561434e-01f, -1.13419339e-01f, -2.06357047e-01f, -2.53578816e-02f, 3.63879442e-01f, 2.97392845e-01f,
  1.81241363e-01f, -8.60440508e-02f, -2.94788461e-02f, 1.05471626e-01f, -4.93836813e-02f, -1.08648986e-02f, -1.27209306e-01f, -1.22860000e-01f, -2.07147628e-01f, -2.19353005e-01f,
  5.20866886e-02f, -1.55798867e-01f, -1.03507243e-01f, -1.99096486e-01f, 7.78857945e-03f, -1.08957201e-01f, -3.42276424e-01f, -3.95953119e-01f, 2.11145543e-03f, -7.74945468e-02f,
  -2.46242002e-01f, 3.05962712e-01f, -7.94266611e-02f, 4.60200869e-02f, -1.48764718e-02f, 2.51846433e-01f, -2.70054311e-01f, -4.57507312e-01f, -8.79565030e-02f, -8.06678236e-02f,
  2.35384613e-01f, 1.50004461e-01f, 3.96128863e-01f, 1.97251111e-01f, -1.99486256e-01f, -1.85023379e-02f, -4.36845496e-02f, 1.54209673e-01f, 2.26747972e-04f, -6.21477067e-02f,
  6.32813722e-02f, 2.13556979e-02f, -1.37928367e-01f, -1.37928829e-01f, 5.88077866e-03f, 1.99663877e-01f, -1.16680831e-01f, -8.64537880e-02f, 3.76177043e-01f, 2.77208716e-01f,
  -4.41214889e-01f, -1.33778229e-01f, 2.13296078e-02f, -2.58538604e-01f, 2.60876775e-01f, 1.52055873e-03f, -3.25048089e-01f, 2.55737960e-01f, 3.76720548e-01f, -1.69314519e-02f,
  6.14161342e-02f, 7.94449374e-02f, -1.49789333e-01f, -2.01899618e-01f, 3.62891853e-01f, 1.53604940e-01f, -1.17304713e-01f, -3.33545685e-01f, -7.42723346e-02f, 1.05545141e-01f,
  -2.43545733e-02f, -5.93553632e-02f, -3.64284217e-02f, 3.53358919e-03f, 1.11774303e-01f, -2.96456497e-02f, 5.37406579e-02f, 8.59136060e-02f, -1.87070504e-01f, 1.22907460e-02f,
  4.43455935e-01f, 3.48933339e-01f, -8.57333094e-02f, -1.18143864e-01f, 3.73792760e-02f, -1.29688412e-01f, 2.08566070e-01f, -4.09297608e-02f, -2.62875408e-01f, 2.46217102e-01f,
  3.34949195e-01f, 1.41115665e-01f, 1.60988301e-01f, 1.30742997e-01f, -1.96153522e-01f, -3.07956845e-01f, 3.07697296e-01f, -7.13494495e-02f, -1.15042113e-01f, -4.65845689e-02f,
  1.20808601e-01f, 1.49729192e-01f, 6.21329397e-02f, -9.80818197e-02f, -1.71242908e-01f, -1.30736530e-01f, 1.89026430e-01f, 7.91031271e-02f, 1.31269529e-01f, 1.34730467e-03f,
  5.91990054e-02f, 1.82737127e-01f, -2.61458248e-01f, -1.74247965e-01f, -1.93594415e-02f, 2.08114073e-01f, 1.69338837e-01f, 1.68850884e-01f, -3.53189141e-01f, -1.45772398e-01f,
  2.02914834e-01f, -1.27190739e-01f, -3.98281246e-01f, -7.02745914e-02f, 1.94223568e-01f, -3.24152783e-02f, 1.61339968e-01f, -5.68342544e-02f, -5.04292607e-01f, -1.12028114e-01f,
  2.62617856e-01f, 3.53339463e-01f, 1.16644919e-01f, 8.78002942e-02f, -1.69957411e-02f, 2.62716487e-02f, 7.67437890e-02f, 2.37975374e-01f, 2.11895570e-01f, -1.21055469e-02f,
  -8.79321247e-02f, -4.77236658e-02f, -1.17763653e-01f, -1.14327163e-01f, -1.65254235e-01f, 7.91093186e-02f, 1.61547780e-01f, 1.31191552e-01f, -2.43819341e-01f, -2.88330227e-01f,
  -1.62363108e-02f, -2.49179617e-01f, 3.18133175e-01f, -3.78072470e-01f, 2.96446115e-01f, 2.70479828e-01f, -4.19035926e-03f, 9.65635031e-02f, 3.99235673e-02f, 7.00658262e-02f,
  -2.81575382e-01f, -2.30757773e-01f, 6.05671942e-01f, -5.18421270e-02f
};

// L2_fan_Wp_bar (Shape: 8 x 32)
const int L2_fan_Wp_bar_rows = 8;
const int L2_fan_Wp_bar_cols = 32;
const float L2_fan_Wp_bar_data[] = {
  -6.43378645e-02f, 1.44635230e-01f, 1.16284400e-01f, -3.78800929e-02f, 2.86974162e-01f, 1.59862228e-02f, -6.39624298e-02f, 1.81037247e-01f, 1.15622528e-01f, -1.36692390e-01f,
  -5.62755577e-02f, 6.33249283e-02f, 3.21899891e-01f, 4.76440787e-02f, -1.84235916e-01f, -3.65380764e-01f, -2.20399782e-01f, -1.35758117e-01f, 1.13559760e-01f, 1.05856963e-01f,
  -1.60545573e-01f, 1.86998934e-01f, 4.38825935e-01f, -2.07766280e-01f, -1.59272239e-01f, -1.90122500e-01f, -1.83819711e-01f, 7.32766911e-02f, 6.84502840e-01f, -3.97705175e-02f,
  -9.07669291e-02f, -7.28820115e-02f, 3.96518052e-01f, 6.70435280e-02f, 3.09454679e-01f, 1.94001615e-01f, 3.10000151e-01f, -3.06920260e-01f, -8.25795531e-02f, 1.88977093e-01f,
  1.23999946e-01f, 3.64899397e-01f, 8.35306048e-02f, -5.69207296e-02f, -2.95759648e-01f, -2.87377238e-01f, -2.89302051e-01f, -2.37119317e-01f, -3.53637457e-01f, 3.29956025e-01f,
  -4.45720434e-01f, 1.70848474e-01f, 3.65489751e-01f, 3.74940366e-01f, 1.04603961e-01f, -8.35529625e-01f, -2.44466681e-02f, -1.51990876e-01f, 2.64506042e-01f, -1.96551874e-01f,
  2.57717278e-02f, 5.57303905e-01f, 5.39943755e-01f, 4.99996871e-01f, 2.40423650e-01f, -3.75037715e-02f, 6.56959489e-02f, 5.08147888e-02f, 5.35987616e-02f, -1.35561243e-01f,
  1.77108034e-01f, 1.73829213e-01f, 1.14688911e-02f, 3.55291064e-03f, 9.93624609e-03f, 1.42226964e-01f, -1.18927240e-01f, -1.18180975e-01f, 3.13120112e-02f, -1.76070958e-01f,
  1.92699954e-01f, 3.05708230e-01f, -5.28193638e-02f, 9.17620063e-02f, 4.65291142e-02f, -9.11918096e-03f, -1.17663339e-01f, 5.41578159e-02f, -1.41727537e-01f, -3.05289123e-02f,
  1.50792122e-01f, -1.02097303e-01f, 3.85634154e-01f, -4.05078605e-02f, -1.47181168e-01f, 4.62188005e-01f, 2.21419707e-01f, 3.92443120e-01f, 2.39511337e-02f, 1.63307667e-01f,
  2.05583170e-01f, 4.41301502e-02f, 1.24197975e-01f, 3.20628911e-01f, -2.40588989e-02f, -1.83772538e-02f, -7.08124042e-02f, 2.47547533e-02f, 3.31941277e-01f, 7.61961415e-02f,
  -5.55562116e-02f, 1.35093868e-01f, -2.15766564e-01f, -4.42455679e-01f, -3.08101694e-03f, 1.19716808e-01f, -8.66258144e-02f, -1.48386760e-02f, 1.90617219e-01f, 8.25373083e-02f,
  4.69549209e-01f, 1.61044002e-01f, -9.46360826e-02f, 2.35174432e-01f, -1.58570930e-01f, -1.45586655e-02f, 6.82880282e-01f, -3.20636541e-01f, 6.00264296e-02f, -9.40049142e-02f,
  7.41526335e-02f, 1.52626753e-01f, 2.38215268e-01f, 4.29875731e-01f, 1.58119351e-01f, 1.99246168e-01f, 2.57301688e-01f, 1.84182465e-01f, 3.26513618e-01f, 4.96572226e-01f,
  -3.89451563e-01f, -3.50301296e-01f, 3.88097972e-01f, 5.11170805e-01f, 4.46938396e-01f, -1.20729923e-01f, 2.04741985e-01f, -1.75337598e-01f, -3.25957805e-01f, -4.19711173e-02f,
  -5.71754515e-01f, 4.48935628e-01f, -2.29006127e-01f, -5.71940001e-03f, -3.75073217e-03f, 5.11921227e-01f, 3.11536580e-01f, -3.15612525e-01f, 1.14928238e-01f, 1.03472978e-01f,
  5.75601347e-02f, 1.60177678e-01f, -3.80522348e-02f, -2.77716410e-03f, -6.74444661e-02f, -8.05498511e-02f, -9.39009115e-02f, -8.56704020e-04f, 1.77526861e-01f, 1.60260141e-01f,
  1.44756794e-01f, -2.10709214e-01f, 3.02428663e-01f, 6.88028112e-02f, 8.13379809e-02f, 2.10688844e-01f, -6.48900047e-02f, -4.11721587e-01f, 3.04515660e-01f, 6.35332093e-02f,
  -4.30160016e-02f, -1.57974049e-01f, 9.91267040e-02f, 1.93891704e-01f, 3.39897364e-01f, 9.00107101e-02f, -2.07702100e-01f, 4.72552031e-01f, 1.39574766e-01f, -9.70493183e-02f,
  4.51008767e-01f, -2.25176424e-01f, 2.39385441e-01f, -6.94908015e-03f, -1.72611400e-02f, -2.79372707e-02f, 1.56636491e-01f, 2.86228862e-02f, 2.40798563e-01f, -7.26895705e-02f,
  1.71288084e-02f, 2.37137437e-01f, 1.84423566e-01f, 2.49900427e-02f, 6.22051395e-02f, -1.10984169e-01f, 3.51197422e-02f, -9.79392380e-02f, 9.34384465e-02f, 1.82621598e-01f,
  3.54906797e-01f, 9.40800831e-02f, -1.17829047e-01f, 1.95395887e-01f, 3.23720723e-01f, 1.90618917e-01f, 4.01519798e-02f, 1.47595137e-01f, 9.55109447e-02f, 2.17836663e-01f,
  9.12043571e-01f, 3.77547331e-02f, -2.78001875e-01f, -1.45582825e-01f, 6.48247227e-02f, -6.50604889e-02f, -2.83388197e-02f, 2.71107405e-01f, -1.48539143e-02f, 7.29222521e-02f,
  1.85153201e-01f, 2.53839403e-01f, 2.16875404e-01f, -3.01326402e-02f, 1.51390582e-01f, 9.86564904e-02f, 2.38652542e-01f, -1.00553602e-01f, -2.03487482e-02f, -4.90126684e-02f,
  4.60221916e-02f, -1.39499381e-01f, 4.06794101e-01f, -1.77186411e-02f, -2.01599851e-01f, -4.27280553e-02f, -1.87892362e-01f, 2.44381696e-01f, -6.50516078e-02f, 4.56862561e-02f,
  -1.35404080e-01f, -8.74972120e-02f, 5.27869642e-01f, -9.94417518e-02f, -5.78722358e-02f, -2.06463858e-02f
};

// L2_fan_Bp_bar (Shape: 1 x 8)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 8;
const float L2_fan_Bp_bar_data[] = {
  1.12121012e-02f, 2.15243511e-02f, 8.36758241e-02f, 1.25202850e-01f, 2.63660789e-01f, 1.51158959e-01f, 1.58293381e-01f, 2.06970826e-01f
};

// L3_linear_W (Shape: 12 x 32)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 32;
const float L3_linear_W_data[] = {
  -5.07736206e-01f, -9.76981819e-02f, -1.24244373e-02f, 2.20638011e-02f, -3.28438312e-01f, 2.92555206e-02f, -9.25395265e-02f, -1.22427583e-01f, 2.89848179e-01f, 2.37409323e-01f,
  1.88364089e-01f, -8.76077861e-02f, -2.91293673e-02f, 1.85236372e-02f, 4.68146473e-01f, -2.76195854e-01f, -3.90535630e-02f, -2.42479712e-01f, 4.64505374e-01f, 4.34567571e-01f,
  3.33144128e-01f, 1.81766510e-01f, -2.31886625e-01f, -2.73034245e-01f, -1.12603664e-01f, -4.79040146e-01f, 1.12383559e-01f, -4.21517700e-01f, 5.37215531e-01f, 8.34446922e-02f,
  5.19997180e-01f, 3.89755905e-01f, 1.25018120e-01f, -5.18790111e-02f, 3.20040077e-01f, 4.28682476e-01f, 4.02881086e-01f, 6.15687761e-03f, -3.21273834e-01f, -2.24865794e-01f,
  -6.04203165e-01f, -2.17168599e-01f, -2.61074483e-01f, 2.22958073e-01f, -4.49915975e-01f, 3.98646861e-01f, 1.55348450e-01f, -2.75423657e-02f, -5.51392585e-02f, -6.80130243e-01f,
  -4.91125911e-01f, -7.10532129e-01f, 6.20379746e-01f, 5.08249044e-01f, -4.91050750e-01f, 1.58417355e-02f, 2.91199028e-01f, -7.72952199e-01f, -2.90308177e-01f, 6.14456534e-02f,
  2.44430974e-01f, 1.59560189e-01f, 3.49654853e-01f, 2.34223232e-01f, 2.20980227e-01f, -1.59351408e-01f, -3.35640401e-01f, 1.31631985e-01f, 5.03392279e-01f, 1.56180546e-01f,
  6.35385215e-02f, 2.37153873e-01f, -3.41348618e-01f, 2.07251847e-01f, 2.82762162e-02f, 2.85301447e-01f, 6.23758793e-01f, 4.43273306e-01f, -2.95695484e-01f, -1.98320881e-01f,
  1.29701391e-01f, 4.21030134e-01f, -2.14999825e-01f, 1.83153212e-01f, 3.37692946e-01f, 3.01666379e-01f, -5.00261903e-01f, 1.41007632e-01f, 2.55497158e-01f, 2.21539631e-01f,
  -3.97974461e-01f, 3.24913293e-01f, -3.38496923e-01f, 3.15222532e-01f, 2.00155839e-01f, -7.76774576e-03f, 7.53409714e-02f, 1.16784953e-01f, 2.64683980e-02f, -1.43582210e-01f,
  -8.37236494e-02f, 9.62729603e-02f, -5.22584915e-01f, -6.20552719e-01f, -1.54289648e-01f, -2.51363724e-01f, -4.24531959e-02f, 2.07906455e-01f, -1.54794067e-01f, 1.28504276e-01f,
  -1.48763791e-01f, 5.27029112e-02f, 9.77014098e-03f, 4.39812690e-01f, 4.40886736e-01f, 5.96951246e-01f, -4.46753740e-01f, -1.44224763e-01f, 3.44306111e-01f, -3.61821473e-01f,
  -2.45775014e-01f, 8.40049624e-01f, 1.04276143e-01f, -4.57050472e-01f, -3.58493000e-01f, -1.80500627e-01f, -3.11019361e-01f, -2.82212496e-01f, -4.74949151e-01f, 1.97360650e-01f,
  9.74040478e-02f, -2.71393359e-02f, 3.14346515e-02f, 2.34880447e-02f, 2.29436103e-02f, 2.61224031e-01f, -3.83469790e-01f, -1.27684638e-01f, -1.05725110e-01f, 3.09745580e-01f,
  -6.69823065e-02f, -3.86896044e-01f, -6.43406510e-02f, 3.09149623e-01f, 3.53264958e-01f, 7.22365797e-01f, 3.68252397e-01f, 4.03802276e-01f, -3.27133864e-01f, -5.15891492e-01f,
  1.21963084e-01f, 4.57109630e-01f, -2.66143322e-01f, 1.19524486e-01f, 7.66121075e-02f, -4.16419417e-01f, 8.46799731e-01f, -2.64166951e-01f, 5.93305752e-02f, 7.35474601e-02f,
  -3.13983113e-01f, 4.24998581e-01f, 1.88758925e-01f, 8.53595138e-02f, 3.66320968e-01f, 4.56764966e-01f, -6.59405068e-02f, -5.21043837e-01f, 3.10412675e-01f, 1.33080408e-01f,
  4.32210088e-01f, -4.72016037e-01f, -1.97835654e-01f, -4.43883240e-01f, -2.57697999e-01f, 4.69759077e-01f, -2.84293860e-01f, 1.72029793e-01f, -3.21611524e-01f, -4.99199450e-01f,
  -5.59096858e-02f, 2.22867772e-01f, 3.56618911e-02f, 5.17649651e-01f, -1.84755385e-01f, -7.88432181e-01f, -1.75311521e-01f, 4.37953800e-01f, 1.95407167e-01f, 5.67365885e-01f,
  -4.86364029e-02f, 2.01576591e-01f, 5.07743418e-01f, -3.54806171e-03f, -3.55495125e-01f, -3.25743049e-01f, -1.68964431e-01f, -3.90850157e-01f, 1.80657268e-01f, -1.73145309e-01f,
  3.39129239e-01f, 1.05708703e-01f, -1.02145039e-02f, -3.43043149e-01f, -9.34193935e-03f, -2.29297876e-01f, -2.40067597e-02f, -4.67682369e-02f, -6.94144726e-01f, 4.05306727e-01f,
  -3.04373205e-01f, -1.42464668e-01f, -2.55130053e-01f, -2.50627995e-01f, 2.89894104e-01f, -3.28656025e-02f, -2.45216429e-01f, 1.63837641e-01f, -3.94075960e-01f, 5.73117137e-01f,
  -5.43949783e-01f, 4.47926551e-01f, -5.04972339e-01f, -3.71484309e-01f, -5.10197163e-01f, 1.60237074e-01f, -9.47953314e-02f, 4.29760635e-01f, -4.61824760e-02f, -1.48273436e-02f,
  3.90308261e-01f, 2.57337809e-01f, 4.32498425e-01f, 2.46840045e-01f, -2.96991915e-01f, 3.97416502e-01f, -2.96833694e-01f, 4.40223753e-01f, 6.69442415e-01f, -1.87121856e-03f,
  5.56451082e-01f, -7.65857458e-01f, -1.02838844e-01f, -3.83415282e-01f, -5.56547821e-01f, 3.78166363e-02f, 7.32477367e-01f, -6.31505430e-01f, -5.09878039e-01f, 5.29357269e-02f,
  1.59876749e-01f, -1.59582853e-01f, 3.59076589e-01f, -2.98502922e-01f, -2.97740549e-01f, 3.19435708e-02f, 3.13419998e-01f, -4.93924975e-01f, 6.15000166e-02f, -2.32389107e-01f,
  -6.11465394e-01f, -3.27818066e-01f, -4.23708418e-03f, 1.82421744e-01f, -3.18869531e-01f, -2.20147625e-01f, -3.55592847e-01f, 2.28320472e-02f, 3.23962480e-01f, 1.37164816e-01f,
  3.29990923e-01f, -4.52492088e-01f, 2.41062850e-01f, -3.96247387e-01f, -3.00733060e-01f, 1.33727625e-01f, 6.27643988e-02f, 2.24148721e-01f, -9.74624306e-02f, -6.23350203e-01f,
  6.48733139e-01f, -3.03875148e-01f, -5.68083562e-02f, -2.93088201e-02f, -4.46785331e-01f, -1.06513195e-01f, 2.97024786e-01f, 3.16402823e-01f, -4.11947936e-01f, -4.69422281e-01f,
  -3.25092822e-01f, -4.61467057e-01f, 3.20807666e-01f, -2.56618440e-01f, 1.43539384e-01f, 8.40755329e-02f, -4.19639051e-01f, -4.22098935e-01f, -2.06424724e-02f, -3.37738007e-01f,
  -2.80997127e-01f, -1.31025136e-01f, -8.89215211e-04f, -1.35661975e-01f, -4.80006576e-01f, 3.29473108e-01f, 4.33979541e-01f, -3.42462242e-01f, -2.88325220e-01f, -4.11289543e-01f,
  1.76633194e-01f, -3.14580649e-02f, -2.02779666e-01f, -2.84077317e-01f, -1.89784989e-01f, 3.39168459e-01f, 6.59119964e-01f, 2.72939444e-01f, -3.55142742e-01f, -2.19913125e-01f,
  1.58069000e-01f, -4.08531487e-01f, 8.82613808e-02f, 9.94678289e-02f, -3.90364498e-01f, 1.34896591e-01f, 1.00702435e-01f, -2.58298993e-01f, 2.75195301e-01f, 2.26048514e-01f,
  4.03484732e-01f, -1.74655276e-03f, 3.40452075e-01f, 2.97406137e-01f, -2.75653303e-01f, -1.95949823e-01f, -1.98480412e-02f, -4.16450173e-01f, 4.74993676e-01f, 2.20755532e-01f,
  1.81935415e-01f, 3.50277752e-01f, -2.55232602e-01f, -1.73781112e-01f, 2.43730292e-01f, 4.72072780e-01f, 3.23932230e-01f, -3.74237657e-01f, -5.90563953e-01f, -3.33189338e-01f,
  4.44725722e-01f, -2.18439162e-01f, 3.76032829e-01f, 2.24440679e-01f, 1.03167407e-01f, -1.34532899e-01f, 1.83879703e-01f, 5.52245617e-01f, 1.53131381e-01f, 2.78002292e-01f,
  3.35022479e-01f, 4.12827730e-01f, 2.07172126e-01f, -3.05076897e-01f, 2.34491795e-01f, -1.70936793e-01f, -1.63800552e-01f, 2.89536715e-01f, 5.22193611e-01f, 2.23904118e-01f,
  -4.34185773e-01f, -4.72147971e-01f, -2.10625917e-01f, 5.87193593e-02f, 2.60765791e-01f, 5.54419398e-01f, 3.90651934e-02f, 7.48375773e-01f, -2.24839434e-01f, 6.75385818e-02f,
  -3.24655980e-01f, -3.00160825e-01f, -4.05761570e-01f, -2.58681983e-01f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  -1.23941392e-01f, 9.29525271e-02f, -5.32921739e-02f, -3.42553332e-02f, 1.42810240e-01f, 1.54480532e-01f, 3.16880755e-02f, 1.34697393e-01f, 8.97892844e-03f, 9.89703909e-02f,
  -1.41178101e-01f, -3.74650657e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 12, 8
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 12, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        32, 12, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        32, 12
    );
    }
    