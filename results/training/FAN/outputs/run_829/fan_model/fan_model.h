/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 3 x 120)
const int L0_fan_Wp_rows = 3;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  1.50876101e-02f, 2.77154505e-01f, 1.79920271e-01f, 4.09781141e-03f, -2.49401048e-01f, -2.15923205e-01f, -1.64943412e-01f, -1.31342307e-01f, -9.51807722e-02f, 1.14999279e-01f,
  -2.78017595e-02f, -1.29058599e-01f, 5.87915368e-02f, -5.22286035e-02f, -1.99169904e-01f, 8.84847119e-02f, 1.23357832e-01f, 2.16303486e-02f, -2.61929512e-01f, -2.21358091e-01f,
  -1.33177936e-01f, 4.00988646e-02f, -5.26606143e-02f, 3.44143733e-02f, 2.27554679e-01f, -5.15229860e-03f, 2.40748584e-01f, 1.21422760e-01f, -3.49351168e-02f, 2.94143140e-01f,
  2.30275452e-01f, 4.43114601e-02f, -2.63775766e-01f, -4.30210792e-02f, 2.51811501e-02f, 6.58765882e-02f, -4.29894216e-02f, 1.97913200e-01f, 9.56321508e-03f, 1.22331209e-01f,
  2.45655198e-02f, -3.88913937e-02f, -1.80737022e-02f, 1.53840166e-02f, 1.25702724e-01f, -6.66188821e-03f, 1.51114523e-01f, 1.59270152e-01f, -4.27667797e-03f, -2.65215375e-02f,
  -3.22007053e-02f, -2.80533526e-02f, 8.03933591e-02f, -6.48124665e-02f, -5.72161786e-02f, -9.10978690e-02f, 2.23175120e-02f, -6.71533123e-02f, -5.35561442e-02f, 1.91618010e-01f,
  -4.55184467e-02f, 3.21774036e-02f, -1.07960656e-01f, 1.26263509e-02f, -2.17906982e-02f, 1.68818310e-02f, 1.97808892e-02f, -1.70530397e-02f, -1.82827003e-02f, 9.79931187e-03f,
  -5.75774536e-02f, -3.04648597e-02f, -5.54848351e-02f, 1.11992925e-01f, 3.56139205e-02f, -7.10556109e-04f, 1.23083666e-02f, 1.67196691e-02f, -8.45093862e-04f, -2.19753478e-02f,
  -7.58507941e-03f, -5.19256480e-02f, 5.13897240e-02f, 1.43890921e-02f, -6.94109946e-02f, -2.84985453e-02f, 9.80956256e-02f, -3.53703275e-02f, 1.08215928e-01f, 6.19401485e-02f,
  2.28078842e-01f, -2.49459878e-01f, 1.30642697e-01f, 1.88479833e-02f, 6.15179539e-02f, 2.62589660e-02f, 2.61844192e-02f, 4.05436521e-03f, 9.56737697e-02f, -8.00305419e-03f,
  -1.10419005e-01f, 1.67108178e-02f, 1.09501056e-01f, 2.43009045e-03f, -8.30173641e-02f, -9.57471058e-02f, -1.42899211e-02f, -2.02347524e-02f, -3.16021405e-02f, 1.21320626e-02f,
  -1.46865649e-02f, -1.03511820e-02f, -5.14744595e-02f, 2.36207824e-02f, -1.10005200e-01f, -1.20942228e-01f, 6.72198832e-02f, 4.65991683e-02f, -1.53164700e-01f, 1.12322420e-01f,
  -1.88174129e-01f, 3.74446124e-01f, 1.03875160e-01f, -2.43993308e-02f, -4.53165621e-02f, 4.87968363e-02f, 1.14331499e-01f, -6.68803090e-03f, -6.71211779e-02f, 1.12197362e-02f,
  -2.10766435e-01f, -2.74813026e-01f, -2.24277303e-01f, -1.15409493e-01f, -1.08886110e-02f, 2.11849883e-01f, 2.33829439e-01f, 1.11002110e-01f, -2.11563319e-01f, -8.73415098e-02f,
  1.52210429e-01f, 1.12466840e-02f, -5.65896779e-02f, 1.10222392e-01f, 9.94633287e-02f, -1.29941598e-01f, 1.10314317e-01f, 6.99991062e-02f, 1.18922830e-01f, 4.41301912e-01f,
  -2.19877183e-01f, 1.88296184e-01f, -5.18178605e-02f, -2.02869009e-02f, -4.61692512e-02f, -6.48410395e-02f, -6.69835657e-02f, 7.16304630e-02f, -5.45195006e-02f, 1.38336122e-01f,
  4.87810634e-02f, -2.37102062e-02f, 5.09065576e-02f, 1.14188135e-01f, 4.86994237e-02f, -1.11647695e-02f, 9.07538906e-02f, 1.60114095e-01f, 2.52769142e-03f, 6.40586466e-02f,
  7.68199190e-02f, 6.30107149e-02f, -5.96346986e-03f, -2.66281012e-02f, 2.22838335e-02f, -1.12200245e-01f, 3.78408879e-02f, 1.60682679e-03f, 3.36066596e-02f, 4.31272797e-02f,
  -2.69993562e-02f, -5.95359772e-04f, -3.12936567e-02f, 5.35786375e-02f, 1.37127726e-03f, -1.31177623e-02f, 8.00404772e-02f, -1.14337280e-02f, 3.26721817e-02f, 4.33175415e-02f,
  8.56293067e-02f, 2.72400584e-02f, 4.78764325e-02f, 2.72882041e-02f, -5.92660792e-02f, 6.97265100e-03f, -1.44500518e-02f, -7.02417037e-03f, -4.04287577e-02f, -1.97275560e-02f,
  2.97610536e-02f, -3.79032381e-02f, 4.53982800e-02f, 3.87522914e-02f, 6.29840419e-02f, 1.66338701e-02f, 3.19937691e-02f, 2.16613226e-02f, -4.18778248e-02f, 6.75824583e-02f,
  -3.10854614e-01f, -2.68257875e-02f, -1.07905522e-01f, -4.43657972e-02f, -1.32404298e-01f, 1.26311546e-02f, -1.88767165e-02f, -1.29635315e-02f, -3.89727466e-02f, -1.52243646e-02f,
  1.60114318e-02f, -4.91756760e-03f, -2.00605653e-02f, 4.11520479e-03f, -8.27280656e-02f, -3.02335490e-02f, -9.06302035e-03f, -1.03802696e-01f, 2.71092691e-02f, -8.11425596e-02f,
  8.32533687e-02f, -9.44435447e-02f, -2.05888137e-01f, -7.27797672e-02f, -1.63904876e-01f, -2.52519459e-01f, -6.46701604e-02f, -1.01208374e-01f, -2.80390322e-01f, -6.19279556e-02f,
  6.15910351e-01f, -1.21651098e-01f, 1.94580778e-01f, 4.55454737e-02f, -1.38256595e-01f, 1.15861587e-01f, 1.76973119e-01f, 2.72403546e-02f, -5.68219498e-02f, -2.38085650e-02f,
  -2.15811297e-01f, -2.00790718e-01f, -6.57787845e-02f, -3.13502215e-02f, 2.04778954e-01f, 7.96337202e-02f, 8.29203054e-02f, 1.97820529e-01f, 2.61482477e-01f, -2.94859614e-02f,
  -1.78235561e-01f, -3.11450157e-02f, 1.97094724e-01f, -9.59839579e-03f, -2.51019508e-01f, -4.84334193e-02f, 5.23875207e-02f, 6.05785893e-03f, -1.19755985e-02f, -1.59674302e-01f,
  2.46166810e-02f, -7.70797674e-03f, 9.05802026e-02f, -4.15000282e-02f, -1.96325947e-02f, 1.54093191e-01f, 9.45855752e-02f, 9.00977924e-02f, 4.12364714e-02f, 6.87248260e-02f,
  -5.71356751e-02f, -4.77267876e-02f, -5.91892712e-02f, 7.85604399e-03f, 6.56581223e-02f, 1.36953533e-01f, 1.61885053e-01f, 2.03963861e-01f, 1.79767564e-01f, 8.00808072e-02f,
  -1.55833587e-01f, -8.29026103e-02f, 1.49697721e-01f, 8.08013529e-02f, 1.03581823e-01f, 9.43650901e-02f, -1.35090789e-02f, 3.03620566e-02f, 2.35236093e-01f, 1.00102723e-01f,
  -3.42507218e-03f, -1.06505373e-04f, -6.53225044e-03f, 2.57341303e-02f, 3.29226814e-02f, -1.31617729e-02f, -3.53969783e-02f, -9.67530068e-03f, -6.88383495e-03f, 3.79138701e-02f,
  -1.39191160e-02f, -2.49915943e-02f, -5.11553027e-02f, 1.22959986e-02f, -1.93092301e-02f, 4.35989164e-02f, -1.71976388e-02f, -2.47450247e-02f, 6.87369797e-03f, 1.56470165e-02f,
  -2.50593610e-02f, 2.51989774e-02f, -4.92392443e-02f, -7.91946948e-02f, -2.54693124e-02f, 4.58859466e-02f, 1.03265889e-01f, -7.13102445e-02f, 4.31664027e-02f, 2.80896202e-02f,
  1.21768922e-01f, -4.71675284e-02f, -4.71055647e-03f, -5.63952997e-02f, 1.11265056e-01f, 3.33860405e-02f, -1.73251275e-02f, 4.67735119e-02f, -5.47815338e-02f, 6.37406334e-02f,
  8.53952765e-03f, 6.83279112e-02f, -2.96538026e-04f, 3.89739266e-03f, 2.33466551e-02f, -1.91744715e-02f, 3.05773467e-02f, 6.07887395e-02f, -5.15384637e-02f, -4.25203007e-06f,
  -4.64602858e-02f, 1.10996403e-01f, 2.12123096e-01f, 7.81625435e-02f, -5.86668923e-02f, 8.04703403e-03f, 1.02637842e-01f, 9.31815431e-02f, 1.63200393e-01f, 2.91045338e-01f
};

// L0_fan_Wp_bar (Shape: 26 x 120)
const int L0_fan_Wp_bar_rows = 26;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  5.13180852e-01f, 3.32610272e-02f, 2.44200185e-01f, 2.53721595e-01f, 2.69813091e-01f, 3.46544504e-01f, 3.10239166e-01f, 2.43181154e-01f, 3.42454808e-03f, 4.37874235e-02f,
  3.34744155e-02f, -2.58090943e-02f, -1.47977397e-01f, -3.04802842e-02f, 7.82653987e-02f, 8.63445736e-03f, 6.20340966e-02f, 2.12629251e-02f, 1.96027085e-01f, 1.51895136e-01f,
  1.53518226e-02f, -5.05445413e-02f, -2.15314776e-02f, 4.07081917e-02f, 2.46261097e-02f, -1.35931626e-01f, 8.28875080e-02f, 5.22606187e-02f, 3.65648754e-02f, -1.22681767e-01f,
  -7.76571259e-02f, 1.38595968e-01f, 3.65523286e-02f, -2.21900150e-01f, -4.30463366e-02f, -7.62788430e-02f, -2.65247491e-03f, -1.29925817e-01f, -1.45930285e-03f, -7.44864121e-02f,
  -8.30647871e-02f, -4.74974997e-02f, 3.33983377e-02f, 1.42259421e-02f, 6.21189997e-02f, 1.32828010e-02f, -9.52461213e-02f, 8.34051743e-02f, 3.87596525e-02f, 2.12866589e-02f,
  -1.99475303e-01f, 3.35313044e-02f, 1.80392399e-01f, 3.97069678e-02f, 4.72013801e-02f, 3.38086560e-02f, -3.98166217e-02f, 1.44387856e-02f, 3.30781862e-02f, -1.22348152e-01f,
  -6.05086088e-02f, 4.86581959e-02f, 2.88824607e-02f, -3.72856595e-02f, 3.29699963e-02f, 3.25765610e-02f, -1.27541320e-03f, -8.11583027e-02f, 1.35413617e-01f, 3.24148452e-03f,
  7.67979026e-02f, 6.96882308e-02f, 3.56051959e-02f, 6.44032583e-02f, -6.58867508e-02f, -5.28957658e-02f, 5.18029779e-02f, 5.84277101e-02f, 7.58317336e-02f, 2.35794727e-02f,
  1.42216831e-02f, 5.11396080e-02f, 6.84169531e-02f, 8.32654983e-02f, -1.73230451e-02f, -8.00827984e-04f, -7.45429285e-03f, -4.26750295e-02f, 1.78954657e-02f, 4.87765037e-02f,
  -2.20266983e-01f, 3.55799831e-02f, -1.21025674e-01f, -4.46123518e-02f, 4.24419567e-02f, -1.10051878e-01f, 2.73223519e-02f, -6.40589595e-02f, -5.70737349e-04f, -8.38800967e-02f,
  -1.17017236e-02f, -6.11485541e-03f, 5.05600236e-02f, -5.94766811e-02f, 4.09244187e-02f, 4.63329518e-04f, -4.94231433e-02f, -6.69864565e-02f, -8.98495242e-02f, -1.06875964e-01f,
  -1.05674148e-01f, 8.19408894e-02f, 4.92227115e-02f, 6.65215869e-03f, -1.37561053e-01f, 8.52332115e-02f, -1.09804384e-01f, 2.13707536e-02f, 1.06786981e-01f, -5.09949476e-02f,
  4.04509127e-01f, -1.08616069e-01f, 7.14895129e-02f, 1.55903995e-01f, -4.74971123e-02f, 5.36479503e-02f, -4.38623317e-03f, 1.10422172e-01f, 7.59888291e-02f, 6.02673441e-02f,
  -7.82545432e-02f, -4.81528416e-02f, 7.74618611e-02f, -2.38721427e-02f, 8.21487606e-02f, -5.51827103e-02f, 3.56669091e-02f, -1.04770595e-02f, 7.52304569e-02f, -1.41655837e-04f,
  -5.71998768e-02f, 2.09667459e-02f, 1.20680854e-01f, 1.13284290e-01f, -1.89412590e-02f, -2.64653172e-02f, -1.01671480e-01f, -1.36013493e-01f, -1.18984900e-01f, -1.81327704e-02f,
  -3.09888907e-02f, 7.99928457e-02f, 2.67450213e-02f, -3.36806886e-02f, -1.60395890e-01f, -5.63704558e-02f, 1.06700584e-01f, -6.88277930e-02f, -3.10697593e-02f, -7.35135302e-02f,
  -6.01735525e-02f, -1.00574270e-02f, -1.72406435e-02f, 3.71955819e-02f, -6.93230927e-02f, -1.10545121e-02f, 7.18440721e-03f, -1.95705448e-03f, 7.05510080e-02f, -4.64717299e-02f,
  -1.39069051e-01f, -1.58358246e-01f, 9.02209990e-03f, -3.63822803e-02f, -1.80399921e-02f, -5.68288937e-02f, -4.13146392e-02f, 4.22398560e-02f, -5.94651178e-02f, 2.96984594e-02f,
  -1.08632088e-01f, -6.51925057e-02f, 2.02261768e-02f, 2.53622774e-02f, 2.44976841e-02f, 4.78722006e-02f, 7.15822875e-02f, -9.53233317e-02f, -6.64743409e-02f, -1.13247307e-02f,
  3.76795344e-02f, 7.41646439e-02f, 8.49669278e-02f, -4.77323718e-02f, -5.31064197e-02f, 6.63373247e-02f, 1.08313831e-02f, -6.01310655e-02f, -5.11842780e-03f, -1.87101662e-02f,
  -2.01264471e-02f, -5.31918630e-02f, 1.26119899e-02f, 3.47649045e-02f, 2.87176128e-02f, 3.87398228e-02f, 4.85372953e-02f, -2.96957395e-03f, 4.00343165e-02f, -3.81743424e-02f,
  1.13578476e-01f, -1.58062935e-01f, 3.84724177e-02f, -3.20777930e-02f, 1.58126615e-02f, -1.63799692e-02f, -6.85671419e-02f, 2.65005082e-02f, -4.89053950e-02f, 7.71285892e-02f,
  2.88723130e-03f, 2.57782312e-03f, 3.05753574e-02f, -1.88971702e-02f, 4.36124615e-02f, -8.97520632e-02f, -7.48661309e-02f, 8.35255682e-02f, 6.61394000e-02f, 6.45084167e-03f,
  -6.14617020e-03f, 9.48580205e-02f, 1.55496344e-01f, 2.52517983e-02f, 3.66143137e-02f, 5.27674286e-03f, 2.70933919e-02f, 6.24135435e-02f, 1.26921415e-01f, 1.60284728e-01f,
  -3.13425735e-02f, -2.78897941e-01f, -1.82520345e-01f, -2.10310414e-01f, -2.16255352e-01f, 7.79270194e-04f, -5.06763458e-02f, -7.84254968e-02f, -1.01727255e-01f, -1.22089118e-01f,
  2.37639230e-02f, 1.94652736e-01f, 1.93102017e-01f, 5.14352471e-02f, 2.13501170e-01f, -4.73717488e-02f, -1.14808522e-01f, 7.67249167e-02f, 1.19338065e-01f, 7.67286941e-02f,
  2.87762545e-02f, -2.26359531e-01f, -1.58745319e-01f, -1.22155726e-01f, -2.30062202e-01f, 4.83731441e-02f, -1.72038004e-01f, -9.82291698e-02f, -5.01061380e-02f, -2.81916171e-01f,
  3.79029930e-01f, -5.69659919e-02f, 7.61734471e-02f, -1.67033821e-02f, -5.79001494e-02f, 8.85683857e-03f, 6.69344328e-03f, -8.85627270e-02f, -1.08502619e-01f, -2.93833315e-02f,
  -2.93372683e-02f, 2.35718731e-02f, -2.93967407e-02f, 3.41345556e-02f, 1.03797195e-02f, -1.73330158e-02f, -6.45725951e-02f, -1.15371913e-01f, -7.54566267e-02f, 1.14241056e-02f,
  -3.38186845e-02f, 1.56433752e-03f, -3.90467118e-03f, 1.35869244e-02f, -7.36644585e-03f, 8.59347805e-02f, 4.09809574e-02f, -1.16493113e-01f, -9.64142159e-02f, -2.43904918e-01f,
  -5.81618063e-02f, 7.45567083e-02f, 1.82447843e-02f, 2.40259501e-03f, 5.25986440e-02f, -2.40119658e-02f, -3.75968702e-02f, 6.61251470e-02f, -4.04725634e-02f, -7.63014480e-02f,
  1.60892960e-02f, 5.33274114e-02f, -4.83267270e-02f, 3.56287397e-02f, -3.83970067e-02f, -1.04515195e-01f, 3.16669000e-03f, -9.14052427e-02f, 8.15740786e-03f, -6.18464984e-02f,
  -8.11441243e-03f, -2.98505705e-02f, -5.93146086e-02f, 1.07315384e-01f, 5.25040887e-02f, -2.56762002e-02f, 9.33236107e-02f, -6.22887956e-03f, 6.70625493e-02f, -2.15437412e-02f,
  1.15558222e-01f, 1.34120926e-01f, 1.18006669e-01f, 9.69112515e-02f, -9.21252742e-02f, 2.35979445e-03f, 3.90310660e-02f, -5.62278219e-02f, -5.26265018e-02f, -2.41043027e-02f,
  5.35981059e-02f, 9.67456028e-02f, -5.39732017e-02f, -4.38639149e-02f, 2.13479484e-03f, 2.81414688e-02f, -5.31572253e-02f, 1.12097394e-02f, 3.45720500e-02f, -2.75764186e-02f,
  -9.23802406e-02f, -2.89360322e-02f, 1.93749294e-01f, 9.97842625e-02f, -4.87973802e-02f, 1.60913855e-01f, 1.34835973e-01f, 1.00178428e-01f, 1.02651030e-01f, 3.95677201e-02f,
  2.19625562e-01f, -1.23861834e-01f, -5.25124133e-01f, -2.43612025e-02f, -2.71982789e-01f, -5.39508089e-02f, -7.27359504e-02f, 1.40237615e-01f, 1.06669001e-01f, -1.01055205e-01f,
  -1.31455844e-03f, 8.00518841e-02f, 1.01552144e-01f, 1.68166477e-02f, 9.68755558e-02f, -2.16273963e-01f, -2.38069654e-01f, -1.41295627e-01f, 7.98613578e-02f, 3.90755981e-02f,
  -8.56303126e-02f, 7.72436708e-02f, 1.42644256e-01f, 5.77716343e-02f, -1.36825547e-01f, -8.17236453e-02f, -3.06525946e-01f, -1.58930779e-01f, -1.94605708e-01f, -2.68585473e-01f,
  -2.44568996e-02f, -1.60037965e-01f, 2.68163830e-02f, 1.27274990e-01f, -1.48800865e-01f, -5.46345599e-02f, 3.12725827e-02f, 1.82292424e-02f, 5.72058260e-02f, -7.07029849e-02f,
  -7.59553015e-02f, 3.37919146e-02f, 3.71494591e-02f, -6.04679063e-02f, -3.64776999e-02f, -1.05515430e-02f, -3.73317786e-02f, -1.65951818e-01f, -1.55760959e-01f, -1.55466229e-01f,
  -9.96427760e-02f, -1.67452693e-01f, -3.85950655e-02f, 1.00835646e-02f, -1.25022843e-01f, -6.62824363e-02f, -1.70741633e-01f, -1.05776690e-01f, -1.44978061e-01f, 1.18290354e-02f,
  4.83184941e-02f, -5.55577539e-02f, 1.86759569e-02f, 2.24842988e-02f, 5.55602424e-02f, -6.63194805e-02f, 2.82863528e-02f, 1.40555520e-02f, 5.62782735e-02f, 2.71371882e-02f,
  1.28231704e-01f, -4.31521274e-02f, -5.84548637e-02f, 7.52425343e-02f, -1.04740064e-03f, -3.07722595e-02f, 8.80393088e-02f, 6.72183409e-02f, -2.12520398e-02f, 1.16722375e-01f,
  9.00632050e-03f, -8.17405805e-02f, 1.83449276e-02f, 9.66130421e-02f, -8.73557255e-02f, -2.22370829e-02f, 1.47251599e-02f, 3.03629059e-02f, -7.80965621e-03f, 2.80296318e-02f,
  3.77193004e-01f, -1.22687288e-01f, 1.01046033e-01f, 4.80915532e-02f, -3.31865461e-03f, -2.64096428e-02f, -7.20410198e-02f, -2.20443662e-02f, -7.71128088e-02f, 1.38076007e-01f,
  3.42247114e-02f, 4.64320555e-02f, -1.25773940e-02f, -3.60246748e-02f, 6.86561316e-02f, 2.96242759e-02f, 6.06737994e-02f, -1.54407751e-02f, 3.34380642e-02f, 3.01370909e-03f,
  7.78204873e-02f, 1.47593662e-01f, 2.18556911e-01f, 5.97035810e-02f, 5.19692786e-02f, 8.48853961e-02f, 3.57727855e-02f, 7.43614212e-02f, 9.73232463e-03f, 3.13262641e-01f,
  -2.69675374e-01f, -1.82182416e-01f, -2.94080883e-01f, -1.30221516e-01f, -1.27619104e-02f, -1.58002406e-01f, -2.73013949e-01f, -1.66755691e-02f, -4.45590690e-02f, -6.85416535e-02f,
  2.33486220e-02f, -1.24521032e-01f, -1.60485417e-01f, -8.19282085e-02f, -3.58318567e-01f, -1.77960008e-01f, -2.49109387e-01f, -2.65319765e-01f, -2.01560870e-01f, -4.28706519e-02f,
  -9.60252210e-02f, -6.32174015e-02f, -2.53815442e-01f, -1.35850891e-01f, 1.07908554e-01f, 2.99033951e-02f, -4.12027128e-02f, -1.49868086e-01f, -4.32122052e-02f, -4.42502648e-02f,
  -1.49637610e-01f, 6.11294396e-02f, 1.54842883e-01f, 4.00212854e-02f, 9.91384163e-02f, 4.69338037e-02f, 7.81259462e-02f, 2.36825123e-02f, 1.14570580e-01f, 2.79098004e-02f,
  -6.61730999e-04f, -1.99161768e-02f, 5.06714843e-02f, 6.59314916e-02f, 2.85483897e-02f, -4.37154435e-02f, -8.00742880e-02f, -3.59575562e-02f, -1.17403366e-01f, 6.17497489e-02f,
  -4.71643917e-02f, -1.57183796e-01f, -1.70585945e-01f, -6.44288734e-02f, 8.09448138e-02f, -7.15132281e-02f, -1.04231238e-02f, -1.83994398e-02f, -2.07862854e-02f, -8.72550309e-02f,
  -6.74176514e-02f, 1.85079984e-02f, 3.58221903e-02f, 1.38749052e-02f, -4.38863002e-02f, -1.09732933e-02f, -4.57807109e-02f, -6.93155378e-02f, 1.22590549e-03f, -8.44733492e-02f,
  2.74066627e-02f, 3.98529805e-02f, 5.51520847e-02f, -9.18390509e-03f, -6.68271212e-03f, 1.35896588e-02f, -5.34116514e-02f, -1.09634340e-01f, -4.48497459e-02f, -4.79904152e-02f,
  -8.37203711e-02f, -4.12781946e-02f, 2.56103873e-02f, -3.19862030e-02f, 7.63338478e-03f, -6.28693700e-02f, 7.82026872e-02f, 1.36973150e-02f, 2.29447037e-02f, 3.13936174e-02f,
  -1.44308150e-01f, -7.40099326e-02f, -1.02904495e-02f, -4.27077860e-02f, 7.33118644e-03f, -5.22199273e-02f, -7.82018006e-02f, -5.12659177e-02f, 1.56162903e-02f, -4.27149199e-02f,
  -1.00246947e-02f, 5.29461280e-02f, 8.41533067e-04f, -5.57459183e-02f, -2.24146806e-02f, 4.41778228e-02f, -3.79653089e-02f, -4.25392874e-02f, -1.11306779e-01f, 1.74635239e-02f,
  -4.59253788e-02f, -2.68008024e-01f, -1.73777461e-01f, -5.00447527e-02f, -7.96981305e-02f, -1.63766041e-01f, -1.56669065e-01f, -5.71940802e-02f, -1.72843874e-01f, -2.42086202e-01f,
  -6.35237277e-01f, 3.86770139e-03f, -9.35082585e-02f, -1.19554944e-01f, 1.80942476e-01f, 2.58308738e-01f, 4.35522258e-01f, 6.14973716e-04f, -1.11975715e-01f, 9.30980444e-02f,
  9.64550897e-02f, -8.52565244e-02f, -8.17054063e-02f, 1.19459806e-02f, 1.36047289e-01f, 2.47015223e-01f, 2.57301897e-01f, -1.24030173e-01f, -7.16633052e-02f, 6.18360043e-02f,
  2.05652162e-01f, -1.09566130e-01f, -4.14194643e-01f, -1.54961973e-01f, 1.23679057e-01f, 7.49873649e-03f, -1.63896546e-01f, -2.59614233e-02f, 1.59249708e-01f, 2.76657224e-01f,
  -5.68176620e-02f, -2.48536482e-01f, 1.25272095e-01f, 4.33718674e-02f, -2.48033404e-02f, -4.73065674e-02f, -2.20330618e-02f, -1.34880975e-01f, -6.85533583e-02f, -3.30863036e-02f,
  3.52447294e-02f, -4.52763140e-02f, -3.17739882e-02f, 5.25874877e-03f, -1.36854708e-01f, -7.58072585e-02f, -1.26229674e-01f, -1.43842548e-01f, -5.12826219e-02f, -1.24750677e-02f,
  1.74232811e-01f, 4.34354134e-02f, -1.38670474e-01f, 4.56246212e-02f, 2.17655245e-02f, -5.04260957e-02f, -1.22256681e-01f, 6.70794118e-03f, -5.47042042e-02f, -1.50793344e-01f,
  -1.45648411e-02f, 2.65649818e-02f, 9.52294767e-02f, -3.54497992e-02f, -4.52573597e-02f, -4.88582216e-02f, 4.38854024e-02f, 9.97605100e-02f, -3.33753042e-02f, 2.02701986e-03f,
  -3.38039324e-02f, 4.84981611e-02f, 3.17488760e-02f, -5.34851616e-03f, -1.52309416e-02f, 4.81004603e-02f, 8.56642276e-02f, 4.43394370e-02f, 2.91721262e-02f, -3.39821614e-02f,
  -5.66311879e-03f, -1.20136160e-02f, -2.92760096e-02f, -1.14403842e-02f, 8.31268951e-02f, 1.87240671e-02f, 8.35312679e-02f, -9.28165298e-03f, -2.51710527e-02f, -5.95905147e-02f,
  -2.06140935e-01f, 1.06055096e-01f, 5.16618602e-02f, 2.62963101e-02f, 9.83423740e-03f, -7.08098933e-02f, -4.24575768e-02f, 5.59818484e-02f, -1.11248735e-02f, 3.06143556e-02f,
  2.65396703e-02f, -3.68003845e-02f, 7.60030821e-02f, -5.05292090e-03f, -1.31955929e-03f, 2.87303422e-02f, 1.45836975e-02f, -7.12579768e-03f, 4.45470773e-02f, -1.30961373e-01f,
  3.85203697e-02f, 8.74212608e-02f, -3.35278362e-02f, 4.55448031e-03f, 6.19700998e-02f, -5.25937900e-02f, -7.23911375e-02f, -3.30394432e-02f, -1.21131420e-01f, -5.80105484e-02f,
  9.35636014e-02f, 5.97910993e-02f, -5.77345453e-02f, 2.20617518e-01f, -3.70608270e-02f, 1.35457534e-02f, -4.11072932e-02f, 1.22912563e-01f, 8.02646503e-02f, 1.79285526e-01f,
  -6.22912776e-03f, 2.27965832e-01f, 1.73472106e-01f, 1.17721856e-01f, 2.11109981e-01f, 2.13257670e-01f, 2.88469553e-01f, 1.51678279e-01f, 7.45363533e-02f, 8.87591466e-02f,
  2.79572010e-01f, 4.92894128e-02f, 1.61810398e-01f, 1.11317649e-01f, 3.01288694e-01f, 2.02112228e-01f, 1.09692952e-02f, 1.34892330e-01f, 9.13028419e-02f, 4.17776793e-01f,
  3.35088484e-02f, -4.16756794e-02f, -6.84957728e-02f, 4.89251874e-02f, -9.67968330e-02f, -5.90143129e-02f, -7.40583092e-02f, -4.62929085e-02f, -1.90677885e-02f, -8.07936862e-02f,
  -4.99962233e-02f, 1.96620245e-02f, 2.09851600e-02f, -7.35993683e-02f, -3.09636444e-02f, 2.40797480e-03f, -2.41821036e-02f, 6.95749372e-02f, -9.26008914e-03f, -1.40702650e-02f,
  9.64198112e-02f, -7.70091042e-02f, -7.52404407e-02f, -1.03479646e-01f, 4.53907102e-02f, 1.43036554e-02f, -1.64061919e-01f, 3.11252698e-02f, -1.45129398e-01f, 1.02623694e-01f,
  5.00823259e-02f, -4.87072803e-02f, -3.13512012e-02f, 1.80607531e-02f, 1.22458428e-01f, 9.42198187e-02f, 2.36503277e-02f, -1.69188026e-02f, 8.55503753e-02f, -8.25775117e-02f,
  5.90181798e-02f, 6.52119592e-02f, 2.20375862e-02f, 1.87124908e-02f, -3.98798399e-02f, 1.88737940e-02f, -4.01522033e-02f, -6.90947771e-02f, -3.37421447e-02f, -7.31099322e-02f,
  -1.54125951e-02f, 4.62321676e-02f, 3.97912823e-02f, -1.16782011e-02f, 6.85784072e-02f, -3.74548323e-02f, 4.32207622e-02f, -9.87407416e-02f, -3.52456123e-02f, -3.31390463e-02f,
  -2.68336125e-02f, -2.85808563e-01f, 2.67303009e-02f, 1.54014807e-02f, -1.42805995e-02f, -1.04357876e-01f, 6.59670755e-02f, -1.63303643e-01f, -1.44245178e-01f, -8.11049268e-02f,
  1.17892055e-02f, -2.24761050e-02f, 3.92933981e-03f, -5.44634871e-02f, -1.99769493e-02f, -1.97845958e-02f, -8.83044079e-02f, -2.43601296e-03f, -7.75868893e-02f, -8.41836929e-02f,
  7.75260711e-03f, -9.16085616e-02f, -4.38984782e-02f, -7.80375600e-02f, -7.63383042e-03f, -6.87274486e-02f, -1.80439174e-01f, -1.54021204e-01f, -2.05952093e-01f, -1.33767739e-01f,
  -3.74969281e-02f, -1.26241669e-01f, -8.59094560e-02f, 1.07386135e-01f, 3.80798727e-01f, -2.14250516e-02f, -2.13271961e-01f, -2.81776845e-01f, -7.54117668e-02f, 8.10346454e-02f,
  1.91727951e-01f, 2.53464878e-01f, -4.27137576e-02f, 1.55736944e-02f, -3.69123071e-01f, -1.02076150e-01f, -1.64928585e-01f, -1.55862972e-01f, -9.38179418e-02f, -2.37741433e-02f,
  7.01831877e-02f, 1.60562575e-01f, -1.20375000e-01f, -1.39509514e-01f, 7.60846734e-02f, -2.11133845e-02f, -1.51170464e-02f, 1.59745649e-01f, 1.12842157e-01f, 1.29444331e-01f,
  1.36781409e-01f, 3.32377516e-02f, 1.75823309e-02f, 2.08025202e-01f, 1.69341370e-01f, -1.07075624e-01f, -6.99772835e-02f, -3.33105633e-03f, 4.48167399e-02f, -7.09811747e-02f,
  2.69722730e-01f, 1.99425481e-02f, 4.75978181e-02f, -2.29260381e-02f, 3.19153219e-02f, -1.60566028e-02f, -1.21301524e-01f, -1.25860184e-01f, -1.95529848e-01f, -3.55651835e-03f,
  1.65331230e-01f, 1.17021084e-01f, 1.37032997e-02f, -2.12448269e-01f, -1.40163273e-01f, 5.64950369e-02f, -5.76123260e-02f, -4.86927852e-02f, -1.84936330e-01f, -2.52462983e-01f,
  2.81121563e-02f, 2.77120471e-02f, 4.95461076e-02f, -6.73612431e-02f, -2.96864435e-02f, 8.34417343e-02f, 7.82052241e-03f, 5.25277331e-02f, -1.91989262e-02f, -1.04240319e-02f,
  4.58483249e-02f, -3.51502025e-03f, -1.12147778e-02f, -2.25871727e-02f, -5.18113188e-02f, 7.25791901e-02f, -7.09917769e-02f, -7.75502697e-02f, 1.01345265e-02f, 4.52303030e-02f,
  -8.01522806e-02f, 9.66929495e-02f, 9.31172371e-02f, -1.03038146e-04f, -4.47710380e-02f, 1.57261558e-03f, 7.49170482e-02f, -3.88294645e-02f, -3.03518176e-02f, 6.55402392e-02f,
  -1.67429615e-02f, 1.02693439e-01f, -4.85864691e-02f, -1.55303165e-01f, 4.53978963e-02f, -3.43885273e-02f, 1.05848230e-01f, 2.26460863e-02f, 1.27625927e-01f, -1.50273219e-01f,
  1.25928167e-02f, -5.35687618e-03f, 5.05153164e-02f, -4.31660004e-02f, 2.26006154e-02f, -6.94764704e-02f, 6.41462356e-02f, -1.13951422e-01f, -7.74237439e-02f, -7.06113279e-02f,
  -5.43366671e-02f, -1.72742635e-01f, -1.14296429e-01f, -2.31341377e-01f, -3.35400179e-02f, -6.20771199e-02f, -1.91251010e-01f, -1.25660390e-01f, -3.20769638e-01f, -3.81807625e-01f,
  -4.76622313e-01f, -3.99583913e-02f, 1.01378359e-01f, -2.55777538e-01f, 9.10038948e-02f, 4.27938938e-01f, 5.17519951e-01f, 7.51692578e-02f, -1.81256711e-01f, 3.68801914e-02f,
  3.41910347e-02f, -1.65466800e-01f, -1.95806950e-01f, 4.43866476e-03f, 8.04681852e-02f, 1.84993193e-01f, 1.76734656e-01f, 7.90635347e-02f, -3.35508510e-02f, 1.73164889e-01f,
  -7.35695660e-03f, -2.32961386e-01f, -2.70347565e-01f, -1.14398323e-01f, -1.54727697e-01f, -1.16046444e-01f, 6.12616912e-03f, -2.40997784e-02f, 5.51539809e-02f, 2.66919136e-02f,
  1.61760360e-01f, -7.45661259e-02f, 1.77780930e-02f, -8.81767496e-02f, -1.04787424e-01f, -9.81674120e-02f, 8.69543385e-03f, -5.28198853e-02f, -3.05072358e-03f, -2.56460961e-02f,
  -6.02993742e-02f, -2.63447855e-02f, 2.78420057e-02f, -5.12528196e-02f, -8.86954144e-02f, -6.87858015e-02f, 3.36041786e-02f, -1.44057676e-01f, 1.31662497e-02f, 1.23269493e-02f,
  -1.15360168e-03f, 2.39609815e-02f, 7.87846893e-02f, -2.77299993e-02f, -5.10128923e-02f, -1.00386880e-01f, 9.92858335e-02f, -2.10251790e-02f, 6.15037158e-02f, -1.21013910e-01f,
  5.12476526e-02f, -6.10802509e-02f, 3.31548899e-02f, -9.01136100e-02f, 6.85757175e-02f, 1.76859461e-02f, 6.66295886e-02f, -1.51561322e-02f, 4.87298183e-02f, -7.30476156e-02f,
  5.02456427e-02f, -1.19771371e-02f, 1.41044967e-02f, -8.55172649e-02f, 1.26914568e-02f, -1.64244864e-02f, 8.64389986e-02f, 3.27713750e-02f, -7.39782350e-03f, -6.41492754e-02f,
  7.52155157e-03f, -2.11859848e-02f, -5.75928465e-02f, 1.03016626e-02f, 9.07388423e-03f, -8.03236514e-02f, 3.23737711e-02f, -3.00830393e-03f, -4.87965951e-03f, -4.66696247e-02f,
  -1.72898084e-01f, 2.09786370e-01f, -4.25132848e-02f, -6.77715689e-02f, -6.73543382e-03f, -9.72344130e-02f, -5.95005043e-02f, -3.51781063e-02f, -6.51277378e-02f, 3.95881310e-02f,
  -1.64770000e-02f, 1.83534122e-03f, -9.32516344e-03f, -2.88820895e-03f, 9.50040147e-02f, -1.09028583e-02f, -1.19173862e-02f, 5.46488948e-02f, -1.85436532e-02f, 5.88831417e-02f,
  4.68126684e-03f, 1.07326843e-01f, -5.41527160e-02f, 7.25933611e-02f, -2.48149340e-03f, 1.02843501e-01f, 9.01302770e-02f, 4.31089960e-02f, 9.72444639e-02f, 6.66635633e-02f,
  4.63184714e-02f, 3.22214574e-01f, 1.65642083e-01f, -9.41656083e-02f, -4.23496440e-02f, 1.46026596e-01f, 2.72949070e-01f, -6.48335665e-02f, -2.34495103e-01f, 6.23075999e-02f,
  1.43454581e-01f, -6.45742416e-02f, -1.31196663e-01f, -8.97975042e-02f, 8.42200592e-02f, 6.30944744e-02f, 6.88028634e-02f, 2.94997226e-02f, -1.52481571e-01f, 2.46998891e-02f,
  -3.94821540e-03f, -8.01784992e-02f, 7.46532902e-02f, -3.29276640e-03f, -1.34552211e-01f, -1.70707852e-01f, 7.65771344e-02f, -5.67462705e-02f, 7.40829483e-02f, -5.41418493e-02f,
  -6.20517880e-03f, 1.54929429e-01f, -1.40911818e-01f, -7.59544075e-02f, 6.25703037e-02f, -1.36082917e-01f, 2.86130756e-02f, -8.52077678e-02f, -2.96920277e-02f, -6.05138578e-02f,
  1.24629652e-02f, 5.05402163e-02f, 1.24505218e-02f, 1.16438735e-02f, -3.59512605e-02f, 6.76894411e-02f, 9.03856978e-02f, -5.32404939e-03f, 3.41053121e-02f, -4.99773324e-02f,
  7.09365159e-02f, 9.63064656e-02f, 7.02276677e-02f, -9.35425609e-02f, -1.01980321e-01f, -9.42615978e-03f, 7.12492466e-02f, 3.47070098e-02f, -7.11301491e-02f, 5.61421290e-02f,
  -7.81721696e-02f, -3.43662165e-02f, 1.09021708e-01f, -5.05994111e-02f, -9.67784610e-04f, -1.26660973e-01f, -7.78978392e-02f, -8.60777423e-02f, -5.69541454e-02f, 1.86914336e-02f,
  -8.08320567e-02f, -9.87583026e-02f, -5.04942685e-02f, 1.87225789e-02f, -8.00512508e-02f, 6.78385571e-02f, -2.28712354e-02f, -8.66293684e-02f, 8.73362496e-02f, -7.92729184e-02f,
  1.34416921e-02f, -7.41030052e-02f, -3.15386951e-02f, -1.50496578e-02f, -6.98421150e-02f, -8.56507793e-02f, -7.19549833e-03f, 1.72010809e-02f, -9.08598602e-02f, -9.48208850e-03f,
  -2.80906349e-01f, 1.32556379e-01f, -1.64443851e-01f, 1.28790131e-02f, 6.02539070e-02f, -9.98961627e-02f, -3.14872600e-02f, -5.09094819e-02f, -3.50656956e-02f, -1.07574917e-01f,
  5.67212291e-02f, -3.54569964e-02f, 6.02726229e-02f, 7.72687122e-02f, -1.01229534e-01f, -4.63435464e-02f, 1.10766932e-01f, -2.13606097e-02f, -2.42402405e-02f, -5.83189689e-02f,
  5.94491735e-02f, 1.56195667e-02f, -4.73196581e-02f, -2.88436227e-02f, -2.74178516e-02f, -1.18800163e-01f, -8.31980631e-02f, -7.96313677e-03f, -5.58645241e-02f, -7.75677115e-02f,
  8.53403211e-02f, -2.56173253e-01f, -2.80690156e-02f, 7.14161247e-02f, -1.92403644e-01f, -2.33561233e-01f, -4.41698551e-01f, -7.85832331e-02f, -4.36080098e-02f, -2.38719746e-01f,
  -1.44505426e-01f, 2.26836577e-02f, 1.66281402e-01f, 1.21211156e-01f, 1.74043715e-01f, -2.43055910e-01f, -1.74467843e-02f, 2.56810427e-01f, 2.93713063e-01f, 5.76026514e-02f,
  -1.10882120e-02f, 1.27950758e-01f, 3.20782661e-01f, 7.49674439e-02f, -2.78312176e-01f, -5.90876378e-02f, -2.15755049e-02f, 3.70047614e-02f, -1.49062291e-01f, -1.90674663e-01f,
  -2.06747472e-01f, -2.49998376e-01f, 6.43482953e-02f, 1.53490193e-02f, 2.21045129e-02f, -9.62524787e-02f, -8.31689686e-02f, -2.23370437e-02f, 1.49746682e-03f, -9.64898616e-02f,
  5.10181719e-03f, -3.46105061e-02f, -1.74536984e-02f, 2.45110616e-02f, -4.72651646e-02f, -1.71214174e-02f, 1.14673682e-01f, 5.20958826e-02f, 1.26547098e-01f, -7.87311867e-02f,
  -1.45233601e-01f, -4.51055616e-02f, -6.14305958e-02f, -4.05767784e-02f, 5.47345579e-02f, 8.66827443e-02f, -9.60399285e-02f, -5.69818318e-02f, -1.66877005e-02f, -2.32048675e-01f,
  -5.41057996e-02f, 2.94576120e-02f, -2.01903339e-02f, -4.20501747e-05f, -4.77449484e-02f, 1.32822329e-02f, 8.06718133e-03f, -6.13637455e-02f, 6.55473992e-02f, -9.00499814e-04f,
  1.61781758e-01f, 5.03327698e-02f, 1.11098230e-01f, 6.20011501e-02f, 1.06865630e-01f, 4.18384597e-02f, -1.02028534e-01f, -4.45083454e-02f, 6.25857636e-02f, 2.84333772e-04f,
  -2.76209041e-02f, -2.67121252e-02f, 3.35478671e-02f, 1.16871446e-02f, 4.92156819e-02f, 2.59914026e-02f, 2.96976324e-02f, -3.24390875e-03f, -3.96910310e-02f, -7.92399198e-02f,
  4.71435785e-02f, 3.19384605e-01f, -9.47913229e-02f, -1.32661432e-01f, 4.82372707e-03f, 3.44754197e-02f, -2.96371970e-02f, -3.18739191e-02f, 1.48334494e-02f, -1.45707890e-01f,
  3.56876627e-02f, 3.59837897e-02f, -1.00866444e-02f, -4.28867526e-03f, 1.54351490e-02f, -9.13931876e-02f, -1.35191195e-02f, -6.22496344e-02f, 2.09479425e-02f, -5.84140047e-02f,
  -1.18370680e-03f, -3.80872935e-02f, -1.04043046e-02f, 2.96833310e-02f, -6.44556060e-02f, 4.96380143e-02f, -1.06498517e-01f, -1.33842126e-01f, -2.83900392e-03f, -8.73471498e-02f,
  1.23691440e-01f, 1.98761627e-01f, 6.25205860e-02f, 4.77044880e-02f, -7.19486102e-02f, -4.58356366e-02f, -1.18751429e-01f, -9.17180628e-03f, 6.51223725e-03f, -1.01552391e-02f,
  -1.04651511e-01f, -5.58720008e-02f, 1.73644144e-02f, -2.01250296e-02f, 4.97992299e-02f, -2.51889247e-02f, -5.39029650e-02f, -3.66882160e-02f, -7.25593865e-02f, -9.80857685e-02f,
  -6.70712516e-02f, 1.15163466e-02f, 6.70085894e-03f, -5.99190183e-02f, 1.05017304e-01f, 2.70600189e-02f, 1.29985377e-01f, 3.59201716e-04f, 1.76823419e-02f, 3.59729491e-02f,
  1.51308522e-01f, 5.71873924e-03f, -1.25861838e-01f, -1.05735525e-01f, -3.92425656e-02f, 6.96147159e-02f, 4.81033511e-02f, -7.00410903e-02f, 2.06130594e-02f, 7.38508850e-02f,
  8.50047842e-02f, 2.93771904e-02f, -7.79456552e-03f, -2.81568523e-02f, -2.13205144e-02f, -2.29207538e-02f, 7.49499574e-02f, -9.30658542e-03f, 6.51723519e-02f, 6.07325733e-02f,
  -9.19387341e-02f, 4.63093109e-02f, -2.95559745e-02f, -7.95260742e-02f, -1.20610557e-02f, -5.66705316e-02f, -6.06641062e-02f, 8.07919577e-02f, 6.47806227e-02f, 5.11497185e-02f,
  5.14869280e-02f, 1.12425588e-01f, 5.26542589e-02f, 8.84450823e-02f, 6.69559613e-02f, 2.97476128e-02f, 8.05143192e-02f, 7.18514696e-02f, -6.71266625e-03f, 1.26039624e-01f,
  6.82277530e-02f, -4.70862128e-02f, 5.27620912e-02f, -2.12736279e-02f, 7.97215402e-02f, 1.06161356e-01f, 1.00503616e-01f, 1.27379775e-01f, 7.06664622e-02f, -5.69925979e-02f,
  -7.63598680e-02f, -4.94671538e-02f, 7.91084990e-02f, -5.42105176e-03f, -2.03701407e-02f, 1.20717376e-01f, -5.87164983e-02f, -2.30085030e-02f, 7.39167780e-02f, -1.44580267e-02f,
  -7.12692887e-02f, -2.91794334e-02f, -1.29006848e-01f, 1.30441263e-02f, -3.15193683e-02f, -4.66014631e-02f, 9.29812044e-02f, -7.20972121e-02f, -7.23806396e-02f, -8.90794396e-02f,
  -2.04908662e-02f, 1.04454719e-01f, -4.15378846e-02f, 2.09329464e-02f, -8.25619027e-02f, -6.52069971e-02f, 1.33149950e-02f, 7.56304041e-02f, -4.13028821e-02f, -1.96407689e-03f,
  -8.21766630e-02f, -1.30799636e-01f, 2.55885441e-02f, -1.43871948e-01f, -1.11667681e-02f, -3.67776901e-02f, 3.06792371e-02f, -9.33124945e-02f, -1.76686943e-02f, 6.49057934e-03f,
  -5.31994343e-01f, 8.75769183e-02f, -1.69913635e-01f, -1.81287527e-01f, -1.49387360e-01f, -3.91169749e-02f, -3.54197458e-03f, -4.00108285e-02f, -1.36433601e-01f, 4.17101644e-02f,
  6.13169037e-02f, -6.43328726e-02f, -1.55031204e-01f, -2.97895651e-02f, -2.10010394e-01f, -1.01795271e-01f, -2.01296896e-01f, -3.07849050e-01f, -3.43478292e-01f, -1.39975384e-01f,
  -4.23274226e-02f, -3.05308759e-01f, -3.10028851e-01f, -2.53160149e-01f, 5.55430427e-02f, -2.10569333e-02f, -2.97448528e-03f, -1.03801817e-01f, 3.64194997e-02f, 4.44448218e-02f,
  2.51803339e-01f, -1.07230321e-01f, -8.72405097e-02f, -2.67415643e-02f, 9.09147784e-03f, 2.70898063e-02f, -4.42722952e-03f, -4.33049724e-02f, -4.00480963e-02f, -3.13482694e-02f,
  -5.28459102e-02f, -9.47301909e-02f, -5.40247113e-02f, 4.01181839e-02f, -1.12886235e-01f, -6.21431135e-02f, 8.00593421e-02f, -2.14942824e-02f, 5.18988408e-02f, 1.69833213e-01f,
  9.05380771e-02f, -1.02887481e-01f, -8.01780820e-02f, 2.69212406e-02f, 8.71689394e-02f, -1.50056869e-01f, 9.85991359e-02f, 5.41173257e-02f, 2.00589187e-02f, 1.97555140e-01f,
  8.08952749e-03f, 7.74473175e-02f, -7.01723769e-02f, -7.89427981e-02f, 3.30417901e-02f, -9.53967031e-03f, 6.57750219e-02f, -3.75906155e-02f, -3.84104182e-03f, 1.13165446e-01f,
  5.72882704e-02f, 5.31194322e-02f, -3.00399307e-02f, 4.63512912e-02f, 3.70382419e-04f, -5.10182492e-02f, -1.12074658e-01f, 4.69920114e-02f, 3.03750504e-02f, 2.09271815e-02f,
  -4.64421697e-02f, -6.95372298e-02f, 7.07165822e-02f, -2.60968432e-02f, -3.13168019e-02f, -1.80014409e-02f, 4.00024243e-02f, -1.24300659e-01f, -2.89031696e-02f, -7.51338750e-02f,
  2.70874709e-01f, -1.73422977e-01f, 3.72655876e-02f, 3.12220920e-02f, -6.73943907e-02f, 6.97188675e-02f, 7.15197176e-02f, 1.81248840e-02f, -9.78202969e-02f, -8.49185139e-03f,
  2.02133507e-02f, -4.80948901e-03f, 3.80480289e-02f, 1.48687931e-02f, -4.86618979e-03f, -3.56507041e-02f, 9.39007699e-02f, -8.18647519e-02f, -1.10319974e-02f, 1.38116285e-01f,
  4.00465727e-02f, -1.82557441e-02f, -6.07305616e-02f, 1.43822253e-01f, -2.53416202e-03f, -1.15492754e-01f, 9.52555463e-02f, 3.56595777e-02f, -3.70784253e-02f, 2.54615843e-01f,
  -1.02519877e-02f, -1.08488984e-01f, -1.31894499e-01f, 4.45671864e-02f, -1.70769215e-01f, -1.63002327e-01f, -2.05263466e-01f, -1.43242240e-01f, -3.47457267e-03f, -1.77984200e-02f,
  -6.67339265e-02f, 1.19630687e-01f, 1.00714371e-01f, 4.18164916e-02f, -7.95013160e-02f, -1.06087051e-01f, -1.52024910e-01f, 4.06833142e-02f, 7.95388743e-02f, -3.31382565e-02f,
  7.86654931e-03f, 1.50898129e-01f, 3.14878076e-02f, 8.48181248e-02f, -1.54977646e-02f, 5.44724986e-04f, -5.96511178e-02f, 6.13477081e-02f, -5.16431592e-02f, -7.91782662e-02f,
  7.81238228e-02f, -2.34675974e-01f, -3.49026434e-02f, -4.25811559e-02f, 7.43805766e-02f, -9.34822299e-03f, -8.37498605e-02f, 9.83076170e-03f, -7.72578269e-02f, 7.75183691e-03f,
  -1.13203190e-01f, -5.75787351e-02f, 7.90180117e-02f, 4.90864329e-02f, -2.57671019e-03f, -9.73695070e-02f, 2.18618233e-02f, -2.51964433e-03f, -2.66816281e-02f, 4.27023461e-03f,
  -7.70433480e-03f, 1.57605782e-02f, -3.43800373e-02f, -6.27167895e-02f, -6.48408532e-02f, 2.92310975e-02f, 2.78738663e-02f, -9.34096705e-03f, 8.30216275e-04f, -8.49811658e-02f,
  1.43099315e-02f, -6.87570423e-02f, -8.05373937e-02f, -8.18065256e-02f, 5.86890914e-02f, 2.21354291e-02f, -3.66949141e-02f, 1.00827530e-01f, 7.10641742e-02f, 6.95193857e-02f,
  -6.70875013e-02f, -6.71744794e-02f, 4.96581793e-02f, 4.49275859e-02f, 8.75481293e-02f, -8.61319005e-02f, 2.72317566e-02f, -9.64849517e-02f, 5.36163934e-02f, -6.43752962e-02f,
  -6.97775632e-02f, -2.63441801e-02f, -5.97389713e-02f, -1.91017780e-02f, -6.47115929e-04f, -7.01770335e-02f, 7.65226269e-03f, 9.72805917e-02f, 1.24300882e-01f, -9.71240178e-02f,
  2.13908195e-01f, -1.04977034e-01f, -2.24269945e-02f, -7.98739493e-02f, -6.73839003e-02f, -1.01573460e-01f, -4.30654176e-03f, 4.75331768e-02f, 7.96308592e-02f, 4.90867272e-02f,
  4.55174036e-02f, 3.58818211e-02f, 5.01110330e-02f, -7.23728016e-02f, -5.30508347e-02f, -5.57056889e-02f, -5.76184355e-02f, -3.63036320e-02f, -4.52572107e-02f, -5.45912795e-02f,
  -7.01609999e-02f, -5.82556846e-03f, -2.79482845e-02f, 3.51760723e-02f, -6.95893914e-02f, -5.05990721e-03f, 1.02354430e-01f, 3.73813473e-02f, 4.83391546e-02f, -7.69174937e-03f,
  2.55878061e-01f, -3.23752493e-01f, -4.57744122e-01f, -8.69206488e-02f, -3.76769096e-01f, -1.82474881e-01f, -3.66439730e-01f, -4.29580994e-02f, 3.11508942e-02f, -3.38660240e-01f,
  -1.31149128e-01f, -3.10840700e-02f, 1.10924139e-03f, 9.46722254e-02f, 6.99391216e-02f, -2.30485901e-01f, -2.97167420e-01f, 1.06496498e-01f, 1.03097036e-01f, -3.49055864e-02f,
  -5.97992167e-02f, 5.36874048e-02f, 3.11299920e-01f, 3.12891565e-02f, -3.29391062e-01f, -8.56971815e-02f, -1.86102331e-01f, -2.34964758e-01f, -2.20243052e-01f, -4.44596618e-01f,
  -4.58607078e-01f, -1.47994727e-01f, 1.38299679e-02f, 1.19600624e-01f, -1.71129897e-01f, 2.28328351e-02f, -8.12088102e-02f, -4.00741212e-03f, 8.70480314e-02f, -4.24269252e-02f,
  5.40732918e-03f, -5.79673201e-02f, 2.98559666e-02f, 2.36464422e-02f, -6.64722547e-02f, -3.34745981e-02f, 6.69337213e-02f, 1.04847237e-01f, 7.03898221e-02f, -1.20715126e-01f,
  -5.30755185e-02f, -7.93273374e-02f, -9.56705064e-02f, 5.22765256e-02f, 7.33280107e-02f, -9.45242047e-02f, -5.80943413e-02f, -1.77768067e-01f, -1.41862547e-02f, -1.79510027e-01f,
  -6.37615249e-02f, 1.46220466e-02f, -3.60556357e-02f, -2.64800210e-02f, 2.81122494e-02f, 4.21654284e-02f, 5.17116277e-04f, -1.22397738e-02f, 8.80280882e-02f, 5.75793420e-05f,
  8.49070027e-03f, -6.95525110e-02f, 3.01849376e-02f, -6.74084872e-02f, -9.04142186e-02f, -1.01289861e-02f, 9.11342204e-02f, 9.32839699e-03f, 6.33440912e-02f, 7.23440573e-03f,
  3.62247159e-03f, -3.65207568e-02f, -4.24303263e-02f, 4.74455506e-02f, -7.03904629e-02f, -2.56651491e-02f, 2.41310671e-02f, 2.28502415e-02f, 6.59418255e-02f, 2.33514663e-02f,
  8.68294612e-02f, 6.39833137e-02f, -1.59300998e-01f, 6.74973428e-02f, -7.70194829e-02f, -2.36060228e-02f, -6.12667669e-03f, 6.56328127e-02f, -3.63019183e-02f, -4.66942713e-02f,
  -7.23538473e-02f, 1.29729077e-01f, -2.68871114e-02f, 1.98970847e-02f, 5.89983398e-03f, 7.75500908e-02f, -3.94740775e-02f, -2.32674684e-02f, -6.10922687e-02f, 1.19224133e-03f,
  2.78219786e-02f, 3.29946764e-02f, 3.36603597e-02f, -2.18168069e-02f, 2.59382427e-02f, 1.42645985e-02f, -1.21776368e-02f, 2.29862146e-02f, 1.35484576e-01f, 4.45619673e-02f,
  1.24480464e-02f, -1.96277693e-01f, 8.40226337e-02f, -1.32835373e-01f, -4.34186729e-03f, -1.12132207e-01f, -1.35422841e-01f, -9.22879502e-02f, -7.83392414e-02f, -1.61611885e-01f,
  5.67912171e-03f, 6.54363856e-02f, 1.08300850e-01f, 7.43154436e-02f, 1.05307652e-02f, -1.25623301e-01f, -4.23082858e-02f, 6.59210049e-03f, 3.20290662e-02f, -1.09892972e-01f,
  -1.48606002e-01f, -6.73606694e-02f, 9.22129825e-02f, 4.77821007e-02f, -2.15910867e-01f, -1.00709572e-01f, -1.22034222e-01f, -6.21463209e-02f, -9.86663401e-02f, -5.90842916e-03f,
  2.49630008e-02f, 1.02666259e-01f, 5.25243431e-02f, 4.07642126e-02f, 2.55080014e-02f, 1.14629678e-02f, 1.20403087e-02f, 3.87668386e-02f, 5.34108728e-02f, 6.43970892e-02f,
  -1.22465100e-02f, 1.74026098e-02f, -1.58767570e-02f, 1.32962028e-02f, -1.82093438e-02f, 7.33804423e-03f, -2.51353806e-04f, 1.00293696e-01f, 8.53598863e-02f, 3.10931932e-02f,
  -1.11807965e-01f, 1.58245646e-04f, 9.63224843e-02f, 9.78928730e-02f, 1.98645517e-02f, 1.35087609e-01f, -6.39466420e-02f, 6.40278161e-02f, 1.57537818e-01f, -1.23690829e-01f,
  4.63014357e-02f, 2.05263868e-02f, 2.02909429e-02f, 2.32736040e-02f, -1.62954666e-02f, -6.08593151e-02f, 8.49516988e-02f, -7.20980868e-04f, 6.77427277e-02f, -1.14377150e-02f,
  -3.74619402e-02f, 5.71858883e-02f, -1.30692990e-02f, -1.29215941e-02f, 8.89444426e-02f, 1.91051587e-02f, -6.29310682e-02f, -2.47796308e-02f, 2.52390057e-02f, 1.21320479e-01f,
  6.21779403e-03f, 4.03504074e-02f, -7.50357509e-02f, 1.65465642e-02f, -1.87622365e-02f, 1.11441845e-02f, -4.90780622e-02f, 6.52722688e-03f, 3.87540162e-02f, -3.14477533e-02f,
  -4.61700745e-02f, 3.49541634e-01f, 2.02696398e-02f, -1.84380524e-02f, -9.43739340e-02f, 5.69723211e-02f, 1.16150277e-02f, 5.07942848e-02f, 4.75638397e-02f, -6.97233900e-02f,
  7.01319100e-03f, -7.42985234e-02f, -4.92640734e-02f, -4.16985005e-02f, 5.53646684e-02f, 2.84454282e-02f, 3.13090696e-03f, 4.43090983e-02f, 1.01629972e-01f, -4.81932499e-02f,
  -7.22804219e-02f, -4.57635932e-02f, -5.08194454e-02f, -1.77723803e-02f, 4.24166583e-02f, 1.52038977e-01f, 6.50352836e-02f, -6.99089020e-02f, 6.78031370e-02f, -2.14783385e-01f,
  -1.69915885e-01f, 1.17451943e-01f, 1.15158064e-02f, -2.06929445e-01f, -4.71334942e-02f, 8.93556923e-02f, 1.47496402e-01f, 2.74338052e-02f, -1.01322606e-01f, 1.21989340e-01f,
  2.39010677e-02f, -6.26920685e-02f, -2.00855181e-01f, -3.59586328e-02f, 6.19237162e-02f, 1.24233663e-01f, -1.06034100e-01f, -1.01017371e-01f, -2.13596433e-01f, -1.01529181e-01f,
  -3.35559472e-02f, -2.37143010e-01f, -1.57370463e-01f, -1.96444646e-01f, -1.48366943e-01f, -2.80806690e-01f, -1.62541240e-01f, -2.19729424e-01f, -4.72061299e-02f, -2.21158043e-01f,
  -2.20293984e-01f, -3.13219652e-02f, 5.07405866e-03f, -1.41746238e-01f, 6.75263330e-02f, 1.29772993e-02f, 3.39916646e-02f, -4.97901477e-02f, -3.72267179e-02f, -4.40807678e-02f,
  -7.41964579e-02f, -1.68510117e-02f, -8.29592496e-02f, 4.86859441e-04f, -6.10635430e-02f, 4.46685180e-02f, -5.50727360e-02f, -3.73073742e-02f, -5.64655885e-02f, 9.70047489e-02f,
  2.58620922e-02f, -2.24967413e-02f, 7.67523497e-02f, 8.09779689e-02f, 6.22472577e-02f, -4.59753722e-02f, -7.39982426e-02f, -2.48395875e-02f, -2.34780330e-02f, -5.76597452e-02f,
  1.47482008e-01f, 2.09053624e-02f, 2.70073600e-02f, 5.28245121e-02f, -5.87757677e-02f, 5.61598204e-02f, -3.71578708e-02f, -6.55403957e-02f, 8.16200674e-02f, -6.32302389e-02f,
  3.46097834e-02f, 6.72232434e-02f, 1.67688653e-02f, -4.43734303e-02f, 3.38214450e-02f, 4.92761768e-02f, -2.71469690e-02f, -2.08634138e-02f, -4.17842716e-02f, -3.22649628e-02f,
  -2.70761903e-02f, 6.20500185e-02f, -2.73976363e-02f, -4.42217626e-02f, 4.27772067e-02f, 3.68842036e-02f, 5.73085155e-03f, 1.36109730e-02f, 3.08998078e-02f, 6.21792600e-02f,
  -2.48068884e-01f, 5.53320022e-03f, 1.04437638e-02f, -5.74771650e-02f, -7.28526488e-02f, 1.58817545e-02f, 5.44124749e-03f, 4.30969782e-02f, 1.68360732e-02f, 6.50471672e-02f,
  9.31074321e-02f, -2.87325145e-03f, 3.93746309e-02f, 3.45191620e-02f, -1.89194363e-02f, -4.08591852e-02f, 1.23142585e-01f, -3.56117487e-02f, 2.43885778e-02f, -1.14438338e-02f,
  7.89681897e-02f, 5.66561818e-02f, -9.50724632e-02f, -8.58161449e-02f, 1.28233321e-02f, -1.49087474e-01f, -8.45064223e-02f, -2.86496188e-02f, -1.50986593e-02f, 5.74025400e-02f,
  2.74917006e-01f, 1.29286811e-01f, 2.04019606e-01f, 1.64824039e-01f, 1.51074037e-01f, 1.11964166e-01f, 1.91196173e-01f, 5.45508675e-02f, -1.95628442e-02f, 1.41650438e-01f,
  1.85686335e-01f, 1.23601802e-01f, 8.95030051e-02f, -2.20022406e-02f, 1.13019347e-01f, -1.08221732e-01f, 2.20849272e-03f, 5.86857554e-04f, 1.43245272e-02f, 9.01655033e-02f,
  -4.98831756e-02f, -2.58939981e-04f, 6.44757897e-02f, -1.11033179e-01f, -1.48644507e-01f, -6.40764758e-02f, -1.69275086e-02f, -2.53367648e-02f, -9.79894772e-03f, -1.74529865e-01f,
  -2.47494853e-03f, 2.17529640e-01f, -1.16631851e-01f, 3.82003263e-02f, 1.57932714e-01f, -7.23940879e-02f, -2.75226496e-03f, -9.74636972e-02f, 5.01546776e-03f, 4.26909141e-02f,
  6.41643777e-02f, -1.18433163e-02f, 6.24610297e-03f, 2.00812472e-03f, -1.05652660e-02f, 7.67381638e-02f, -1.18679889e-01f, -2.48802137e-02f, 2.25072876e-02f, 5.97108752e-02f,
  -8.85074809e-02f, 7.72625431e-02f, 2.05469429e-02f, -2.93633081e-02f, -8.16564932e-02f, 8.33558571e-03f, 4.96449461e-03f, -1.11589488e-02f, 8.19237530e-02f, -3.77283990e-03f,
  -2.61805374e-02f, -6.86166137e-02f, -4.22499478e-02f, 1.08234491e-02f, -5.08472100e-02f, 1.89735405e-02f, -1.12221744e-02f, 6.05711415e-02f, 8.08370784e-02f, -5.01762293e-02f,
  2.28895508e-02f, -2.74893045e-02f, 4.11722213e-02f, 6.68732449e-02f, -8.73385295e-02f, -2.15295181e-02f, -2.54905391e-02f, 5.66046312e-02f, -6.68639168e-02f, 9.96150598e-02f,
  5.13704540e-03f, -1.77319366e-02f, -8.67530820e-04f, 9.05876420e-03f, 8.24737772e-02f, -4.42981981e-02f, 3.70483804e-07f, -5.19871488e-02f, 7.83279538e-03f, -1.72887165e-02f,
  5.58363833e-02f, 2.29096755e-01f, 6.21687155e-03f, -9.82492864e-02f, -1.08558629e-02f, -2.76725683e-02f, 9.93582159e-02f, 5.21045104e-02f, -2.18244307e-02f, 2.68968455e-02f,
  -3.47116962e-02f, -5.57577126e-02f, 2.60068402e-02f, -1.19837128e-01f, -2.99680196e-02f, -4.86582071e-02f, -3.46718840e-02f, 2.33702436e-02f, 3.46693955e-02f, 4.67804074e-02f,
  -7.81121925e-02f, -8.29178840e-02f, -6.32884428e-02f, -4.60597407e-03f, -4.54270951e-02f, -9.22207013e-02f, -8.05713981e-02f, 2.69840881e-02f, -4.29650657e-02f, 2.90064211e-03f,
  1.45210400e-01f, -1.47683427e-01f, 1.35279283e-01f, 1.00575387e-01f, 9.40303057e-02f, 2.23560780e-01f, 5.99004589e-02f, 1.76934168e-01f, 1.69385280e-02f, 1.31587777e-02f,
  -1.86416239e-01f, -1.81530580e-01f, -9.01091322e-02f, -2.51120739e-02f, 1.18646966e-02f, 1.01204731e-01f, 2.33333424e-01f, 1.56549737e-01f, 1.71290934e-01f, 5.19842766e-02f,
  -1.53310485e-02f, 6.16902038e-02f, -1.15630962e-02f, 3.20502482e-02f, 8.67618173e-02f, 3.65211591e-02f, -2.87210625e-02f, -2.91401427e-03f, 2.80745253e-02f, 1.28171369e-01f,
  2.55861711e-02f, 5.73047400e-02f, -4.58949320e-02f, -1.06370546e-01f, -6.10148422e-02f, -7.80340061e-02f, -7.60216936e-02f, -4.65460382e-02f, -7.36587420e-02f, 2.01584380e-02f,
  -5.90033010e-02f, -9.38569233e-02f, 3.76809314e-02f, -5.21336198e-02f, -4.83785048e-02f, -1.05642766e-01f, -1.20018363e-01f, -1.26755126e-02f, 3.73262949e-02f, -4.51532565e-02f,
  4.68899170e-03f, 4.15846780e-02f, 1.12100378e-01f, -3.04821730e-02f, 7.95400515e-02f, 1.48725370e-02f, 1.55919781e-02f, -7.20544979e-02f, -6.08648621e-02f, -2.44394727e-02f,
  -2.29586978e-02f, -5.12624793e-02f, 1.77084026e-03f, -6.99776635e-02f, -1.81384730e-05f, 5.38718626e-02f, 5.59815243e-02f, -3.65510210e-02f, -2.70850826e-02f, -4.39971872e-02f,
  8.06684196e-02f, -3.95506993e-02f, 7.89719746e-02f, 8.50074366e-02f, 2.37684380e-02f, -2.53030881e-02f, 4.76210900e-02f, 2.09271479e-02f, -6.09903373e-02f, -5.79375140e-02f,
  -6.99175103e-03f, 7.03862011e-02f, 4.80958726e-03f, 3.53417434e-02f, 7.46406382e-03f, -1.36663017e-04f, -1.69254988e-02f, -4.03888151e-02f, -6.35530893e-03f, -4.85657575e-03f,
  4.24269736e-02f, -8.43398273e-02f, 1.39691755e-01f, 5.66944890e-02f, 1.69928540e-02f, -5.64165562e-02f, 3.33776139e-02f, 4.96704020e-02f, 7.29707927e-02f, 9.99091119e-02f,
  -7.32465759e-02f, -2.46431697e-02f, 2.01542787e-02f, 1.23146996e-02f, 9.49834958e-02f, 7.31254816e-02f, -1.92737835e-03f, 1.48001192e-02f, 6.22471869e-02f, -2.29992880e-03f,
  -5.24910390e-02f, -1.35285985e-02f, 1.53176533e-02f, 9.15685892e-02f, 8.28158855e-03f, 1.09210849e-01f, 6.75425455e-02f, 6.32462883e-03f, -1.41038345e-02f, 7.93974474e-02f,
  -5.41950539e-02f, -3.09667159e-02f, 1.38570085e-01f, -9.17332694e-02f, 6.52894676e-02f, 7.34222755e-02f, 2.46423215e-01f, 2.89090965e-02f, 7.83227980e-02f, 3.78037915e-02f,
  -5.75845577e-02f, -2.37531960e-01f, -2.32387334e-01f, -1.77191868e-01f, -1.02300517e-01f, 1.71204135e-01f, 2.26595014e-01f, 9.52028856e-03f, -3.75924371e-02f, 8.62157252e-03f,
  5.21986336e-02f, -2.79785283e-02f, -3.64186391e-02f, -2.40774024e-02f, -6.16133288e-02f, 5.07428404e-03f, 1.69297494e-03f, -1.37768611e-01f, -9.66293588e-02f, 2.41416786e-02f,
  9.29415748e-02f, -4.26758200e-01f, 1.27912253e-01f, -1.17351830e-01f, -5.45539968e-02f, -7.72478282e-02f, -4.84460108e-02f, -8.69530812e-02f, -2.39575990e-02f, -1.34142339e-02f,
  -8.83782506e-02f, -1.31229505e-01f, -2.02330053e-01f, -1.63286045e-01f, 5.72646633e-02f, 2.63557639e-02f, -1.02929004e-01f, -1.78287223e-01f, -1.71846509e-01f, -3.00494283e-02f,
  -1.98075369e-01f, -1.77872613e-01f, 7.18767056e-04f, -9.35657918e-02f, -1.48001894e-01f, -1.03131376e-01f, -1.02817990e-01f, -2.20009148e-01f, -1.46631598e-01f, 8.56765285e-02f,
  4.80467975e-02f, 5.30010909e-02f, -2.18662880e-02f, 4.94647697e-02f, -1.62106175e-02f, 5.29743433e-02f, -4.58892509e-02f, 2.04370660e-03f, 8.38614404e-02f, 2.11892966e-02f,
  4.44385335e-02f, 7.31816888e-02f, 6.10598586e-02f, 5.14664128e-02f, 5.75847644e-03f, -3.57290730e-02f, -1.57226175e-02f, -6.20903075e-02f, 1.30299404e-02f, -5.63447922e-02f,
  -1.74918510e-02f, -5.60187772e-02f, 7.58654401e-02f, -5.84351905e-02f, -9.80514362e-02f, -6.33014664e-02f, -4.30621691e-02f, -1.62977520e-02f, -1.32740363e-02f, -8.01784396e-02f,
  2.78147399e-01f, -1.80080682e-01f, 1.04900956e-01f, 4.79297712e-02f, 1.99056230e-02f, -8.89328569e-02f, -3.14251799e-03f, -1.02832556e-01f, -1.01498984e-01f, -2.59445254e-02f,
  -1.28608435e-01f, -3.61087471e-02f, 1.80760596e-03f, 1.63823310e-02f, 1.23999283e-01f, 5.90727441e-02f, 7.85420910e-02f, 5.01034074e-02f, -8.20756629e-02f, -3.46409865e-02f,
  7.86936283e-02f, 2.60859609e-01f, 2.82695323e-01f, 2.05720305e-01f, 2.52496405e-03f, 4.55275066e-02f, 1.64047822e-01f, 1.02910742e-01f, 1.39928922e-01f, 5.01935601e-01f,
  1.43598631e-01f, -1.12570815e-01f, 2.98394769e-01f, 1.36754766e-01f, -2.59602398e-01f, -3.15511465e-01f, -3.36800963e-01f, -2.73160756e-01f, -2.61978768e-02f, -1.05760522e-01f,
  -1.89434499e-01f, 2.11971290e-02f, -1.06900660e-02f, 6.38320521e-02f, 1.86330661e-01f, 3.41042466e-02f, 3.68529633e-02f, 3.11195284e-01f, 1.63601398e-01f, -1.27097860e-01f,
  -6.51195496e-02f, 1.04754284e-01f, 3.14189345e-01f, 9.91570875e-02f, 4.82568815e-02f, 9.37947556e-02f, 1.25902146e-02f, 1.18276291e-01f, -3.73802483e-02f, 1.91267520e-01f,
  2.50278652e-01f, 1.29739240e-01f, 9.85893980e-02f, -7.93394223e-02f, 2.49887798e-02f, 6.60777912e-02f, -2.66439058e-02f, 1.11838438e-01f, -5.39257117e-02f, 4.69270051e-02f,
  2.99870875e-02f, 7.02463165e-02f, 1.52388988e-02f, 3.98397893e-02f, -8.42800289e-02f, -9.01545286e-02f, -2.41862666e-02f, 2.34945416e-02f, 1.79039333e-02f, 8.32788944e-02f,
  -7.61360750e-02f, -1.19911119e-01f, -9.89460722e-02f, -1.30109504e-01f, 1.40063651e-02f, 5.80857843e-02f, -6.46650568e-02f, -1.62008982e-02f, 2.53847521e-03f, -1.32442564e-01f,
  2.15818547e-02f, 7.57442415e-02f, -4.47124988e-02f, -5.23606874e-02f, -1.24899194e-01f, -1.20481119e-01f, 7.47046545e-02f, -5.04565090e-02f, -1.51550882e-02f, -1.14939861e-01f,
  3.84883098e-02f, -3.10197044e-02f, 2.37948559e-02f, -5.90521917e-02f, -1.13947699e-02f, -2.64565069e-02f, -3.76293762e-03f, 5.56729808e-02f, 4.65295836e-03f, 5.60115539e-02f,
  2.59407014e-02f, 6.11958914e-02f, 3.01368255e-02f, -1.88059304e-02f, -9.29929689e-02f, 1.00867592e-01f, 2.82791443e-02f, -1.17197998e-01f, -5.87326810e-02f, -1.77530525e-03f,
  -3.74017321e-02f, 1.59341693e-01f, 1.21041154e-02f, 4.41200957e-02f, 8.85603875e-02f, -2.02661529e-02f, -2.86409520e-02f, 2.29749791e-02f, 9.10855234e-02f, 3.41647677e-02f,
  -3.47548388e-02f, 4.39615659e-02f, 1.61894485e-02f, -1.33499561e-03f, 2.10320801e-02f, 3.10239987e-03f, -6.14305064e-02f, 6.92518726e-02f, 4.60397266e-02f, 8.00311044e-02f,
  5.81246987e-02f, -8.27614740e-02f, -2.31561009e-02f, -5.79437241e-02f, 1.56003982e-02f, -2.71744523e-02f, -7.15180784e-02f, -7.20000789e-02f, 2.89979298e-02f, -2.15296581e-01f,
  -4.93802845e-01f, 1.49127841e-01f, 8.93449411e-02f, -1.81936055e-01f, -4.32224013e-02f, -2.20330209e-02f, 6.51181340e-02f, -4.81714644e-02f, -8.71723965e-02f, 1.50259495e-01f,
  4.04421277e-02f, -3.95863652e-02f, -1.04258262e-01f, -6.16164654e-02f, -6.86773211e-02f, 7.35841244e-02f, -1.10985629e-01f, -1.78450420e-01f, -3.37402880e-01f, -1.24581248e-01f,
  -3.36334407e-02f, -1.83663800e-01f, -1.99787274e-01f, -1.23370998e-01f, 1.37359276e-01f, -6.01230264e-02f, 6.21956810e-02f, -7.10572377e-02f, 9.11599100e-02f, 1.45213827e-01f,
  2.11436674e-01f, 1.24466727e-02f, -5.80200851e-02f, -9.20808241e-02f, -7.98028987e-03f, -2.32326165e-02f, 4.92989235e-02f, -1.41620915e-02f, -7.26417452e-02f, -1.06464118e-01f,
  -2.08974220e-02f, -3.70992646e-02f, -1.21795461e-01f, -7.36260563e-02f, -8.03085789e-02f, -7.29553327e-02f, -5.03169112e-02f, -1.75074413e-01f, 5.15451245e-02f, 5.34023270e-02f,
  8.61164555e-03f, -8.86475015e-03f, 4.18074913e-02f, 5.98540455e-02f, 2.79418845e-02f, -7.19790086e-02f, 1.27410725e-01f, 8.00643042e-02f, 2.14961097e-02f, 1.58532456e-01f,
  -5.07394113e-02f, 3.86629850e-02f, 2.96413153e-02f, 6.01100475e-02f, -3.42771946e-03f, -3.15389526e-03f, -3.34381504e-04f, 7.72983255e-03f, 6.03789203e-02f, -4.93196584e-02f,
  5.33110201e-02f, 1.25023320e-01f, 8.28649849e-02f, 4.01464254e-02f, -3.74087342e-03f, -6.60548434e-02f, 7.56455958e-02f, 3.92372347e-02f, 5.32146310e-03f, 3.43427472e-02f,
  -3.67837027e-02f, 4.34828959e-02f, 4.67550792e-02f, 9.40941572e-02f, 1.46434665e-01f, 6.21791892e-02f, 4.40507755e-03f, 1.38088511e-02f, -1.32751673e-01f, -6.33357838e-02f,
  1.28540248e-01f, -2.29829606e-02f, -2.18056515e-02f, -1.71036005e-01f, -1.04623213e-01f, 9.42113996e-03f, 5.23181409e-02f, -1.16120316e-02f, 8.44964162e-02f, -2.03516446e-02f,
  -1.94348842e-02f, -9.69067868e-03f, 7.53324032e-02f, 7.05378177e-03f, -1.15396127e-01f, -3.44703835e-03f, 3.73823685e-03f, -4.71749008e-02f, 3.36519480e-02f, 3.18994820e-02f,
  -2.78269760e-02f, -3.01461611e-02f, 7.53571186e-03f, -3.66183184e-02f, 4.20221947e-02f, -2.85330564e-02f, 1.41920641e-01f, 1.13002084e-01f, -4.18521091e-02f, 1.11535035e-01f,
  2.36909278e-02f, 1.26993582e-01f, -5.22070862e-02f, 2.33767569e-01f, 2.64339507e-01f, 1.68593109e-01f, 5.33625893e-02f, 6.06678352e-02f, 1.88073814e-02f, -7.50747602e-03f,
  2.27898750e-02f, -4.29627746e-02f, 6.63422421e-03f, -1.09092072e-01f, 4.66886349e-02f, 1.67633951e-01f, 2.46490926e-01f, 3.38861123e-02f, -3.52706797e-02f, 7.29999989e-02f,
  1.89240843e-01f, 4.70100567e-02f, 7.01163290e-03f, 1.11603975e-01f, 1.73020259e-01f, 1.94841006e-03f, 6.88592270e-02f, 3.84277031e-02f, 1.59789845e-01f, 3.79213452e-01f,
  -1.04499631e-01f, -6.91170171e-02f, -1.10396758e-01f, -3.15685682e-02f, 1.42286457e-02f, -1.15052983e-01f, 2.99819326e-03f, -2.08836757e-02f, -1.10611774e-01f, 8.22576694e-03f,
  1.15792818e-01f, -5.18492348e-02f, 1.50961086e-01f, -5.35182022e-02f, 1.33428518e-02f, -1.48575194e-02f, -2.12522727e-02f, -3.57827917e-02f, -1.02560697e-02f, 5.50823053e-03f,
  1.36776015e-01f, 1.45023912e-01f, 5.12866341e-02f, -7.73779526e-02f, -1.73106194e-02f, 1.70627646e-02f, 2.01489497e-02f, 4.04575840e-02f, -8.07397217e-02f, 8.15989673e-02f,
  -2.91990279e-03f, -1.75095089e-02f, 4.47451957e-02f, 3.81597653e-02f, 3.28812599e-02f, -5.73992208e-02f, 5.94921261e-02f, 7.67910853e-02f, -2.74722017e-02f, 9.57242474e-02f,
  -7.13808388e-02f, -3.68813649e-02f, -5.27268229e-03f, -5.35566173e-02f, 4.50894572e-02f, 9.66449380e-02f, 1.01424210e-01f, 1.92607846e-02f, -2.91714035e-02f, 4.38941754e-02f,
  1.32750245e-02f, -1.48660187e-02f, -1.00245602e-01f, 8.67027044e-02f, 3.20130214e-02f, 1.05081880e-02f, 1.54978514e-03f, -8.43287185e-02f, -4.57925200e-02f, 6.95538968e-02f,
  -1.30575508e-01f, -3.00476164e-01f, 9.54059735e-02f, 9.87951644e-03f, 7.67422020e-02f, 1.58932351e-03f, 8.72344598e-02f, 9.93382651e-03f, 1.05723953e-02f, -1.12432288e-02f,
  -3.33660506e-02f, -3.99721079e-02f, -3.41812447e-02f, -4.96237539e-02f, 2.34363601e-03f, -1.00463115e-01f, 1.47148483e-02f, 9.32871476e-02f, -3.98594104e-02f, 3.28857675e-02f,
  -5.06021008e-02f, 1.95128024e-02f, -4.12748083e-02f, -1.06635787e-01f, -6.92582205e-02f, 4.53421511e-02f, -7.75740296e-02f, -6.27716957e-03f, -7.65868500e-02f, -1.59485698e-01f,
  3.18037361e-01f, -5.55175431e-02f, -3.50266472e-02f, 1.22255623e-01f, -6.09838916e-03f, 1.36880621e-01f, 1.36763006e-01f, 1.82088986e-01f, 1.05664767e-01f, 1.89660028e-01f,
  1.25981569e-01f, 2.45318487e-01f, 1.01242505e-01f, 1.36499047e-01f, 8.41248631e-02f, 3.55923548e-03f, 6.20258264e-02f, -6.74430877e-02f, 7.54141733e-02f, 4.48042937e-02f,
  -2.32962482e-02f, -5.96007407e-02f, 7.07983524e-02f, -2.40976419e-02f, 7.98514392e-03f, -4.88041006e-02f, 6.53107688e-02f, -4.02429216e-02f, -1.19333975e-01f, -1.30069464e-01f,
  -1.00498855e-01f, 8.18044022e-02f, 1.73984006e-01f, 4.44753878e-02f, 8.86523630e-03f, 1.56592220e-01f, 1.19481690e-01f, -3.87148559e-02f, 8.57251808e-02f, 1.35486675e-02f,
  2.87875533e-02f, -1.33925267e-02f, 2.58460194e-02f, -1.14076972e-01f, -4.50458527e-02f, -1.94775704e-02f, -1.02285281e-01f, 3.17441337e-02f, 3.59702669e-02f, -3.65982987e-02f,
  -4.71154898e-02f, -5.51592186e-02f, 6.20734021e-02f, -2.18150131e-02f, -1.19724935e-02f, 8.57919604e-02f, 6.01179991e-03f, -5.57095073e-02f, -4.86119986e-02f, 7.29655996e-02f,
  8.84931087e-02f, 9.61028636e-02f, 9.00254678e-03f, 7.32830092e-02f, 2.48273108e-02f, 2.98331678e-02f, -5.94321862e-02f, -5.65694533e-02f, 3.33845578e-02f, -8.79209414e-02f,
  -2.28392147e-03f, 7.80817447e-03f, -3.41910683e-03f, 4.98315766e-02f, 4.95828763e-02f, 3.48055456e-03f, -1.07181102e-01f, 1.42215602e-02f, 6.09002002e-02f, -4.85870130e-02f,
  8.34487677e-02f, -5.71671352e-02f, -1.16258459e-02f, -1.28006697e-01f, -3.97167765e-02f, 1.61487125e-02f, -9.24668238e-02f, 2.32937187e-02f, -1.25772059e-01f, -3.52704190e-02f,
  -5.07254787e-02f, 1.26359835e-01f, 1.73151046e-02f, -3.06848716e-02f, -9.38619748e-02f, -2.30030399e-02f, 5.07018603e-02f, -1.03683472e-02f, -1.24353528e-01f, -4.91811000e-02f,
  5.85690662e-02f, 2.81387083e-02f, -2.42473986e-02f, 4.43863533e-02f, -4.52123908e-03f, 8.57392401e-02f, -8.13194737e-02f, 2.90347859e-02f, 6.33866936e-02f, 1.04660183e-01f,
  5.35766520e-02f, 1.11326165e-01f, 1.46833584e-01f, 1.25706606e-02f, -2.18712129e-02f, 1.54421240e-01f, -1.13346353e-02f, -5.40035069e-02f, 1.12390615e-01f, 1.08903661e-01f,
  3.32085520e-01f, 2.48145789e-01f, 2.48275697e-01f, 3.00666802e-02f, 5.25524095e-03f, 1.58947110e-01f, 3.43091995e-01f, 1.47744656e-01f, -1.53860450e-01f, 3.73530500e-02f,
  5.39705604e-02f, -1.56078711e-01f, -1.71965450e-01f, -1.40367299e-01f, 3.55784558e-02f, -1.68165136e-02f, 1.47540839e-02f, 9.61135048e-03f, -7.85736591e-02f, -1.21906735e-02f,
  -1.02707714e-01f, -5.11755645e-02f, 6.72520027e-02f, -6.43170103e-02f, -4.56436016e-02f, -1.49232864e-01f, -8.59193876e-02f, 1.12204261e-01f, -5.06265685e-02f, -1.26447245e-01f,
  6.56939968e-02f, 3.14318538e-01f, -1.96155891e-01f, -1.54914543e-01f, 3.40775065e-02f, 2.36563887e-02f, -6.03280291e-02f, -3.27685550e-02f, 1.08953677e-01f, 8.22078511e-02f,
  -4.28911708e-02f, 2.02038512e-03f, -4.84573841e-02f, -4.16816100e-02f, 1.05242245e-01f, -4.47591096e-02f, 1.32795814e-02f, 7.39172176e-02f, -1.02544427e-02f, -9.60930586e-02f,
  1.09962132e-02f, 9.19254683e-03f, 1.07197128e-01f, 6.83925599e-02f, 4.87068482e-02f, -1.09339477e-02f, 3.29133719e-02f, 7.31095374e-02f, 4.11465168e-02f, -7.87168741e-02f,
  -3.42606045e-02f, 4.10925783e-02f, -3.60002480e-02f, 2.88683753e-02f, -3.13501693e-02f, -5.04218601e-02f, 3.97186726e-02f, 3.71770039e-02f, 5.18708676e-02f, -4.99287993e-02f,
  1.35154888e-01f, 8.79336521e-02f, -7.04721431e-04f, 8.44280981e-03f, -3.36257368e-02f, -3.14281024e-02f, 7.52870068e-02f, -5.74369095e-02f, 1.47148594e-02f, 4.30830196e-02f,
  -4.34067324e-02f, 4.72758114e-02f, 1.50897761e-03f, 5.58996573e-02f, 5.31078018e-02f, 6.35227785e-02f, -3.83940116e-02f, -3.92877124e-02f, 2.22120360e-02f, 9.73364189e-02f,
  -2.37071604e-01f, 1.99866623e-01f, -1.26923129e-01f, -8.27292576e-02f, 1.51214907e-02f, -5.33915311e-02f, -2.69487109e-02f, 3.66497636e-02f, 4.46203351e-02f, 6.45275563e-02f,
  6.61029071e-02f, 8.02472532e-02f, 1.48004189e-01f, -9.37607512e-03f, -2.99548917e-02f, 1.03391409e-02f, -1.01555049e-01f, -8.17971379e-02f, -2.41621789e-02f, -5.25576286e-02f,
  -4.74287458e-02f, -3.87564637e-02f, -3.67903486e-02f, 5.40131889e-03f, -7.69830716e-04f, -2.00614274e-01f, -1.02568105e-01f, -1.01283826e-01f, -2.34610122e-02f, -1.49300203e-01f,
  1.52560413e-01f, -9.19155106e-02f, 2.06975222e-01f, 6.46029562e-02f, 1.50394127e-01f, 3.11651468e-01f, 2.29027808e-01f, 9.62442458e-02f, -3.02524772e-02f, -2.82161925e-02f,
  -1.14654876e-01f, -2.81959772e-01f, -2.23798633e-01f, -1.66861773e-01f, -1.34097666e-01f, 7.89400190e-02f, 1.72316402e-01f, 5.31808548e-02f, 8.18992332e-02f, 7.91521147e-02f,
  -2.34924685e-02f, 5.89927733e-02f, 5.87080717e-02f, -3.80725861e-02f, -1.14956321e-02f, 1.22497743e-02f, -2.56732553e-02f, -3.39042507e-02f, -1.77396592e-02f, -1.35898560e-01f,
  -4.73655798e-02f, 8.69815610e-03f, -3.24208252e-02f, -1.99449621e-02f, -2.95818690e-02f, -2.59150052e-03f, -5.75352013e-02f, -2.94283256e-02f, 7.86329329e-04f, 8.25291872e-03f,
  1.02343289e-02f, -5.61804101e-02f, -1.38119459e-01f, -6.28802553e-02f, 1.07273065e-01f, 9.56715867e-02f, -6.01877719e-02f, -8.77649039e-02f, -3.01924348e-02f, -2.18185447e-02f,
  -7.69833475e-02f, 1.48661315e-01f, 9.02153701e-02f, 8.95246416e-02f, -9.51584801e-02f, -8.33056569e-02f, 5.40525913e-02f, 3.29673961e-02f, 1.54207954e-02f, 1.10684671e-02f,
  4.91982289e-02f, 1.76372547e-02f, -8.82323831e-02f, -7.04568923e-02f, -4.97930348e-02f, 7.10489322e-03f, -1.18844993e-02f, 2.91220509e-02f, 1.47929545e-02f, -1.53404735e-02f,
  -4.15840112e-02f, -8.08198657e-03f, -7.38702416e-02f, -3.00636869e-02f, -1.30576462e-01f, 9.13073681e-03f, 2.35639364e-02f, -1.08133726e-01f, -9.62829310e-03f, 5.24346940e-02f,
  -1.37526691e-01f, 1.01077326e-01f, 7.65090659e-02f, -4.72979248e-02f, -7.99223129e-03f, -1.87823025e-04f, 2.34754756e-02f, -1.04168192e-01f, -6.29995316e-02f, 8.93114787e-03f,
  -1.06607087e-01f, 6.92377090e-02f, -1.93204843e-02f, -8.80166665e-02f, -2.34827138e-02f, -4.39801402e-02f, -8.17025453e-02f, 2.42065713e-02f, 2.18510013e-02f, 6.48155659e-02f,
  -2.01733951e-02f, -1.10118173e-01f, -1.22285843e-01f, -6.85973987e-02f, 2.35182680e-02f, 9.02093053e-02f, -2.94187721e-02f, 4.11397107e-02f, 1.23339184e-02f, -4.77192439e-02f,
  -1.32239684e-01f, 5.56224883e-02f, 1.42274484e-01f, -1.28286751e-02f, -9.56942365e-02f, 1.33018702e-01f, 9.60321799e-02f, 5.95316328e-02f, 1.32483780e-01f, 6.87961951e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 26)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 26;
const float L0_fan_Bp_bar_data[] = {
  1.48949072e-01f, 3.11034441e-01f, 2.66859502e-01f, 2.38496751e-01f, 2.27668583e-01f, 2.58822113e-01f, 1.98067442e-01f, 2.51126111e-01f, 4.28604007e-01f, 3.00071001e-01f,
  2.65921533e-01f, 1.01156086e-01f, 3.69718045e-01f, 2.19402060e-01f, 2.68138051e-01f, 1.01999104e-01f, 2.05053866e-01f, 8.16004276e-02f, 1.45364404e-01f, 3.72619689e-01f,
  3.69804323e-01f, 2.56168336e-01f, 1.87665477e-01f, -1.15805464e-02f, 2.92585850e-01f, 2.33216554e-01f
};

// L1_fan_Wp (Shape: 3 x 32)
const int L1_fan_Wp_rows = 3;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  2.13080615e-01f, 2.38081098e-01f, 1.60531744e-01f, 1.56698778e-01f, -1.82428837e-01f, 4.22214746e-01f, 2.76028342e-03f, 1.99415758e-01f, 1.03844134e-02f, 2.80134648e-01f,
  -1.28425300e-01f, -4.35405880e-01f, -4.28980514e-02f, -1.43432319e-01f, -2.82687157e-01f, -1.42785639e-01f, 3.51705462e-01f, -3.41573171e-02f, -2.79485226e-01f, -1.22096976e-02f,
  1.96818516e-01f, -3.78978178e-02f, -1.38135642e-01f, 2.16095418e-01f, 2.56553054e-01f, 6.73309788e-02f, 3.11361969e-01f, -2.21191257e-01f, -2.23583356e-01f, 2.10944921e-01f,
  7.75725320e-02f, 1.74835861e-01f, 1.13399446e-01f, -2.01665640e-01f, -2.72381902e-01f, 1.79385081e-01f, 9.25863013e-02f, 5.22338934e-02f, -1.55414507e-01f, 3.23661566e-02f,
  -2.05118895e-01f, -1.12364814e-01f, 1.98297948e-01f, -7.14941025e-02f, 2.03594714e-01f, -6.49601370e-02f, -2.74066888e-02f, -1.52609110e-01f, -2.00867549e-01f, -6.41153008e-02f,
  3.23584557e-01f, -6.49776757e-02f, -3.94610554e-01f, -1.41593680e-01f, 8.73973742e-02f, -9.53753367e-02f, 1.04112357e-01f, -1.30060315e-01f, -4.34292629e-02f, 1.77660301e-01f,
  1.88393444e-01f, -2.83594267e-03f, -1.70606807e-01f, -2.69376904e-01f, -2.00119525e-01f, -9.86025035e-02f, -3.95448171e-02f, -5.63841641e-01f, -2.96573341e-01f, 3.22306961e-01f,
  1.87489957e-01f, 2.88012981e-01f, 1.66988298e-01f, 2.44618788e-01f, 2.06681207e-01f, -3.17767709e-01f, -6.15623109e-02f, -2.03856468e-01f, -4.66978438e-02f, -2.88101852e-01f,
  1.04433626e-01f, -1.70304596e-01f, -1.58648863e-01f, -7.74838179e-02f, 4.26071882e-01f, -3.17088254e-02f, 1.61991984e-01f, 2.85128415e-01f, 1.93084031e-01f, -2.60283530e-01f,
  6.58530684e-04f, -3.07527810e-01f, -2.74374217e-01f, 3.55664104e-01f, 6.08702265e-02f, 1.02246441e-01f
};

// L1_fan_Wp_bar (Shape: 26 x 32)
const int L1_fan_Wp_bar_rows = 26;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  1.28183877e-02f, -1.51222259e-01f, -1.88208610e-01f, -9.74544659e-02f, -1.47634700e-01f, 2.68306639e-02f, 3.12985152e-01f, 4.52320985e-02f, 3.37632358e-01f, 2.10843906e-02f,
  -8.22447985e-02f, 3.14553082e-02f, -4.43221442e-02f, -5.37682213e-02f, -3.19471173e-02f, -1.24386743e-01f, 7.42462724e-02f, 3.59409638e-02f, -1.01815939e-01f, 1.89581916e-01f,
  2.03918085e-01f, 1.40850812e-01f, -1.51498616e-01f, -4.86804880e-02f, 1.55943051e-01f, 3.53053063e-02f, 6.19915575e-02f, -1.53762847e-01f, 1.09679557e-01f, 7.33869299e-02f,
  -4.03029919e-02f, -6.61306605e-02f, 6.95477650e-02f, -2.68724293e-01f, -8.01642314e-02f, 1.91123545e-01f, 2.69550979e-01f, 3.05309184e-02f, -1.26929790e-01f, 7.05079436e-02f,
  3.24986018e-02f, -1.18854858e-01f, 2.18661129e-01f, 2.89650112e-01f, 3.20718676e-01f, 4.07664254e-02f, 1.03352226e-01f, -2.32912563e-02f, 5.16929142e-02f, 9.10294950e-02f,
  1.29358903e-01f, -1.40927449e-01f, -2.48630002e-01f, 3.32929157e-02f, -8.43115598e-02f, -4.87503037e-02f, 2.26176172e-01f, 1.71044439e-01f, -6.34649023e-02f, 2.57552981e-01f,
  3.19772750e-01f, 4.49548364e-02f, -1.62993688e-02f, -3.32677625e-02f, 1.66484937e-01f, -1.46815658e-01f, -2.45884433e-01f, -1.00042477e-01f, 2.15974823e-01f, -5.15359938e-01f,
  -3.00401539e-01f, -2.39847392e-01f, 2.72195607e-01f, 1.49223566e-01f, 4.29543883e-01f, 4.64786291e-01f, 3.14103842e-01f, 4.00373280e-01f, 3.65018308e-01f, -1.85226843e-01f,
  -3.04269046e-01f, -2.34893724e-01f, 2.04003289e-01f, 9.55487043e-02f, 4.98053096e-02f, -3.48881595e-02f, 2.63179839e-02f, -2.52130240e-01f, 5.54317683e-02f, -1.23055868e-01f,
  -1.28050089e-01f, 5.87226152e-02f, 2.40483925e-01f, -1.22644641e-01f, -1.49798900e-01f, -8.84115025e-02f, 1.33301392e-02f, -1.12191364e-01f, 2.36997887e-01f, -7.08368123e-01f,
  -1.70811921e-01f, 2.27127261e-02f, 4.68923002e-01f, -1.29988464e-02f, 4.11126673e-01f, 2.97481954e-01f, -6.85156286e-02f, 3.19804549e-01f, 2.25475639e-01f, -2.06772044e-01f,
  4.02897179e-01f, 2.95131385e-01f, 3.01730424e-01f, -2.01267302e-01f, 1.28952339e-01f, 1.43055664e-02f, 5.63999891e-01f, 1.46124110e-01f, 4.25893366e-01f, 3.31229687e-01f,
  -1.59295917e-01f, -9.70279872e-02f, -3.23160648e-01f, -6.39584213e-02f, -9.44303274e-02f, 2.69357353e-01f, 2.18749553e-01f, 9.39568281e-02f, -2.87489712e-01f, -5.95085844e-02f,
  -1.53985962e-01f, -1.50229931e-01f, -5.29891364e-02f, 2.10616723e-01f, -9.49264690e-02f, 1.44396126e-01f, 2.81811446e-01f, 3.68147314e-01f, 2.97358900e-01f, -1.74350411e-01f,
  1.34177580e-01f, 9.04166251e-02f, -2.71087617e-01f, -1.90426260e-01f, 2.65907854e-01f, 1.47194602e-02f, 9.33654457e-02f, 8.93254590e-04f, 4.84139562e-01f, 1.92868218e-01f,
  6.25557899e-02f, -4.82357554e-02f, -1.75619259e-01f, -2.83365905e-01f, 1.01449825e-01f, 6.00876883e-02f, -1.19958311e-01f, 1.58296302e-02f, 1.34248212e-01f, 1.03032053e-01f,
  6.41518682e-02f, 3.36104304e-01f, 4.82595414e-01f, -3.69005471e-01f, 8.36850181e-02f, 2.08033770e-01f, -3.46807614e-02f, 1.03702113e-01f, -6.97237328e-02f, 3.92137587e-01f,
  2.67453883e-02f, -1.07630059e-01f, -2.16627177e-02f, -1.40191808e-01f, -2.58116364e-01f, 2.57174410e-02f, 5.93984962e-01f, 4.90927808e-02f, -2.25357994e-01f, 2.09199697e-01f,
  6.71965897e-01f, 2.33593687e-01f, 1.53273687e-01f, -1.01600409e-01f, -7.67964683e-03f, 6.24698102e-02f, 1.76189765e-01f, -2.47540236e-01f, -2.37546220e-01f, 1.75382480e-01f,
  3.59673165e-02f, -1.04048453e-01f, 4.61215585e-01f, 9.34565663e-02f, 5.62557340e-01f, 5.40577471e-01f, 6.28023803e-01f, -1.01269670e-01f, 1.03651822e-01f, 4.04916145e-03f,
  2.26269048e-02f, -2.23043367e-01f, -1.18678086e-01f, -2.83206761e-01f, 2.13112220e-01f, 1.27671376e-01f, -6.49291649e-02f, 3.70614499e-01f, 4.61922705e-01f, 2.79441446e-01f,
  -2.10442573e-01f, -1.78340673e-02f, -1.01535425e-01f, 9.38777775e-02f, -8.41310620e-02f, 2.52472073e-01f, -3.89158428e-02f, -2.60909200e-01f, 6.56684458e-01f, 3.52747664e-02f,
  3.79076190e-02f, -1.63709432e-01f, 4.57955688e-01f, -4.25881706e-02f, 3.19940954e-01f, 4.44617987e-01f, -2.54163116e-01f, -2.30828464e-01f, 3.43688816e-01f, -4.53305244e-01f,
  -2.07142141e-02f, -3.02473485e-01f, -1.47102594e-01f, -3.49292696e-01f, 5.36309719e-01f, 2.73383617e-01f, -1.87850967e-01f, 5.85661590e-01f, 2.04793841e-01f, 2.09194068e-02f,
  1.77438349e-01f, 1.08880594e-01f, 2.69290626e-01f, -1.22156255e-01f, 4.78318222e-02f, 2.98274755e-01f, 4.24867153e-01f, 9.11645517e-02f, 8.94721597e-02f, -3.03138196e-01f,
  -2.44352384e-04f, 3.96761119e-01f, 1.65435642e-01f, -4.99122068e-02f, 1.13120183e-01f, 1.39218405e-01f, 2.32030954e-02f, 2.20218614e-01f, 2.81430393e-01f, 1.60004482e-01f,
  1.08248867e-01f, 2.10850611e-01f, -1.21133342e-01f, 2.15606838e-01f, 3.76794524e-02f, 1.45159811e-01f, -1.96692675e-01f, 8.13975409e-02f, 2.20186815e-01f, -2.27024257e-01f,
  8.83330479e-02f, -1.84137985e-01f, -2.66656101e-01f, 5.50405346e-02f, -6.39017075e-02f, 1.04337044e-01f, 1.70515731e-01f, -2.29685962e-01f, 1.14588633e-01f, -8.70523527e-02f,
  4.38428968e-02f, 6.69338346e-01f, 1.01011437e-05f, 1.52752787e-01f, 8.90236646e-02f, 1.11424387e-01f, -8.37263688e-02f, 3.17538291e-01f, 1.44234806e-01f, 3.27950716e-01f,
  -8.45531374e-02f, 7.20408633e-02f, -1.34694099e-01f, -3.08279186e-01f, 3.21124159e-02f, -1.51442721e-01f, -3.57798883e-03f, 8.54245871e-02f, 3.24749887e-01f, 3.72228287e-02f,
  7.40871206e-02f, 2.49894917e-01f, 2.15358227e-01f, 8.21101144e-02f, -2.76749015e-01f, 1.97783977e-01f, 6.87071323e-01f, 1.02761626e-01f, -1.13088451e-01f, -2.75984919e-03f,
  3.74581754e-01f, 3.28172371e-03f, -1.65979207e-01f, 9.22333077e-02f, -2.05753669e-01f, 5.17029166e-01f, -1.16952553e-01f, 1.03283755e-01f, 7.88157061e-03f, -8.87835249e-02f,
  1.96186468e-01f, 2.07879663e-01f, 8.82832184e-02f, 2.62473255e-01f, -2.23226979e-01f, 2.49469638e-01f, 3.18601966e-01f, 2.62595296e-01f, 3.46734971e-01f, 3.50185335e-01f,
  -1.64768443e-01f, 2.46207744e-01f, -1.68906391e-01f, -5.94956279e-02f, 4.99878138e-01f, 2.16967300e-01f, -2.23228976e-01f, 1.45949066e-01f, 3.83134335e-01f, -3.96279953e-02f,
  -2.84180045e-01f, -2.19243243e-01f, 2.44208034e-02f, -3.05938274e-02f, 2.09928542e-01f, 7.02914894e-01f, -7.44535923e-02f, 1.59138635e-01f, 4.70636040e-03f, -2.00639367e-01f,
  3.71483117e-02f, 4.41776007e-01f, 1.37384966e-01f, 2.95427769e-01f, -1.44944564e-01f, 3.57921422e-01f, 7.96187297e-02f, -7.29457512e-02f, -2.93682329e-02f, 1.71144933e-01f,
  5.53776138e-02f, -4.25807722e-02f, 2.12949723e-01f, -5.92393465e-02f, -7.48697817e-02f, 1.60343513e-01f, -7.35178590e-02f, 3.19903120e-02f, -2.03116804e-01f, -6.43477514e-02f,
  3.15623015e-01f, -5.41758426e-02f, -4.65818718e-02f, -9.74108055e-02f, 1.09944627e-01f, 1.20110974e-01f, -1.09090120e-01f, 4.67247702e-03f, -1.47500727e-02f, 3.13168108e-01f,
  6.57418594e-02f, 1.40022039e-01f, -1.00218661e-01f, -3.87637969e-03f, -2.92764418e-02f, 1.10450596e-01f, -2.56792188e-01f, -1.43151551e-01f, -6.89498335e-02f, 2.42245153e-01f,
  5.54586761e-02f, 8.54059830e-02f, -6.22507371e-02f, -1.09007552e-01f, -1.29710272e-01f, -4.33360934e-02f, -1.04734257e-01f, 1.78673621e-02f, 1.17312886e-01f, 1.35952055e-01f,
  9.43310112e-02f, -8.78321379e-02f, -1.94671452e-01f, -3.57867330e-02f, -5.48328832e-02f, -1.66213531e-02f, 5.04073538e-02f, -2.43188828e-01f, 2.98202991e-01f, 4.58714217e-01f,
  1.42697468e-01f, 5.40779382e-02f, 1.55320749e-01f, 8.46862607e-03f, -1.92925170e-01f, 3.46166790e-01f, 2.21292853e-01f, -1.36093721e-01f, -1.07866310e-01f, -1.54673621e-01f,
  -3.95109147e-01f, 1.49684027e-01f, 4.29061651e-01f, 1.47331789e-01f, 2.81342953e-01f, 1.93272099e-01f, -2.16665998e-01f, 2.60935992e-01f, 4.57075574e-02f, -8.10986906e-02f,
  1.11969762e-01f, -1.50356263e-01f, -6.54818192e-02f, -1.47771940e-01f, -1.80847540e-01f, -3.81059870e-02f, 1.65422648e-01f, 1.63184196e-01f, -1.96884334e-01f, -8.92852172e-02f,
  9.42563862e-02f, 2.03939408e-01f, -1.11966103e-01f, -2.06214800e-01f, 1.98128909e-01f, -4.33243737e-02f, 2.78859325e-02f, 2.80907720e-01f, 5.03771976e-02f, 9.79854614e-02f,
  -1.15874089e-01f, 2.00855955e-01f, -8.87992010e-02f, -7.76909234e-04f, -3.93467993e-02f, -7.38577396e-02f, -1.39671952e-01f, -1.54959530e-01f, 2.90360689e-01f, -3.43596600e-02f,
  -1.51056752e-01f, -7.86414370e-02f, -1.74445271e-01f, -6.52335212e-02f, -6.72942996e-02f, -9.45769623e-03f, 1.49866864e-01f, -1.39042428e-02f, -8.14859644e-02f, 1.75122485e-01f,
  6.16103336e-02f, -6.61959797e-02f, -5.57483733e-02f, -1.21753357e-01f, 1.32457703e-01f, -5.25711179e-02f, -1.49911225e-01f, -1.70367703e-01f, -4.22858931e-02f, -1.28833935e-01f,
  6.60840422e-02f, 2.91694671e-01f, 2.28470445e-01f, 1.93052828e-01f, 8.68342966e-02f, -2.07912147e-01f, -8.08878690e-02f, -5.81733845e-02f, 2.26246994e-02f, -2.18676686e-01f,
  2.02410147e-01f, -2.89276391e-01f, 1.99036315e-01f, 5.47395825e-01f, -2.43346691e-01f, 1.38386860e-02f, 2.78159678e-01f, 2.32982010e-01f, -1.12280682e-01f, 2.86656439e-01f,
  1.99856818e-01f, 1.42902344e-01f, -3.16339701e-01f, -1.10039815e-01f, -1.61655724e-01f, -1.40129685e-01f, 5.05281091e-01f, 8.45932290e-02f, 6.13356158e-02f, -7.43727386e-02f,
  -2.69181162e-01f, -1.90211266e-01f, -6.78154454e-02f, -1.37694418e-01f, -9.86568332e-02f, -1.50281951e-01f, 1.55864909e-01f, 1.67364046e-01f, -1.38161689e-01f, 6.68881983e-02f,
  -1.32108733e-01f, -9.87797529e-02f, 5.03852777e-02f, 3.76249626e-02f, -6.22819439e-02f, -6.51256815e-02f, 1.19738378e-01f, -9.94567052e-02f, 5.71970865e-02f, -2.77941395e-02f,
  5.46474941e-02f, 1.96934901e-02f, 1.29401699e-01f, -7.82343373e-03f, -1.37768298e-01f, -1.47799551e-01f, 1.04720227e-01f, 4.68612909e-02f, -1.32917479e-01f, -1.61133945e-01f,
  -6.02247044e-02f, -1.74288079e-01f, 1.17600791e-01f, -1.43979862e-01f, -1.36954084e-01f, -6.34458885e-02f, -1.50846347e-01f, -8.26983303e-02f, -3.30895334e-01f, 1.28045723e-01f,
  4.55120727e-02f, 8.93527791e-02f, 1.61825001e-01f, 2.57558733e-01f, 2.46352836e-01f, -2.00183108e-01f, 2.08903532e-02f, 1.19994752e-01f, -2.94431150e-01f, -2.21535727e-01f,
  3.90999429e-02f, 9.00909025e-03f, 1.43421248e-01f, 1.75943300e-01f, 1.18807055e-01f, -5.82499914e-02f, -2.48590454e-01f, 8.38585272e-02f, -9.37360823e-02f, -1.10757217e-01f,
  -4.71567214e-02f, 2.10924726e-02f, -2.21196772e-03f, 3.64343703e-01f, -1.12034731e-01f, -7.95726925e-02f, 4.57604378e-02f, 1.41362071e-01f, -5.21610938e-02f, 2.87361473e-01f,
  2.97050029e-02f, 1.86051339e-01f, 3.28159451e-01f, 1.56679004e-01f, 1.16492458e-01f, -2.06213757e-01f, -4.08897027e-02f, -2.22621068e-01f, 1.03045247e-01f, 2.07375303e-01f,
  -9.34404060e-02f, 2.37390712e-01f, -2.19680190e-01f, 2.83149362e-01f, 7.39366636e-02f, 9.26993936e-02f, 5.43416180e-02f, 4.78622969e-03f, 2.20341250e-01f, 1.19149208e-01f,
  -6.09942526e-02f, 2.65108198e-02f, -2.21811235e-02f, 1.68222502e-01f, 3.19891162e-02f, -3.19593027e-02f, 3.79244089e-01f, -8.86248872e-02f, 3.63149904e-02f, -2.48528481e-01f,
  4.90255773e-01f, 4.22896504e-01f, 6.46528229e-02f, 3.81071009e-02f, -7.81981573e-02f, 6.95619136e-02f, 2.60043681e-01f, 2.20346332e-01f, -1.35055557e-01f, -7.98083749e-03f,
  4.18020099e-01f, -3.72945964e-01f, -4.78391834e-02f, 1.14816576e-01f, -2.09218949e-01f, 1.17622636e-01f, 2.74863452e-01f, 1.31011128e-01f, -7.49043450e-02f, -1.91125780e-01f,
  4.08004262e-02f, -2.12158635e-01f, 5.32955676e-02f, 3.43302667e-01f, 2.44152457e-01f, 7.33703524e-02f, 7.37760365e-02f, 6.25645295e-02f, -1.49868548e-01f, -1.88083038e-01f,
  4.58533764e-02f, 1.88594237e-01f, 2.09442358e-02f, -1.65571988e-01f, 2.10777819e-01f, -1.20905980e-01f, 7.64341727e-02f, 2.97126640e-02f, -3.76652665e-02f, -2.11125284e-01f,
  3.00124474e-02f, 6.46462142e-01f, 3.55841339e-01f, 4.02871788e-01f, 4.49159920e-01f, 2.39788175e-01f, -9.93672907e-02f, 7.77143836e-02f, -9.26866457e-02f, -1.16050974e-01f,
  -3.17914605e-01f, 9.26894471e-02f, 4.07819785e-02f, 9.94489640e-02f, 1.75228983e-01f, 1.18499584e-01f, -4.53508430e-04f, 3.36548239e-02f, 3.84959280e-01f, -1.07401356e-01f,
  -6.90177977e-02f, 3.86883579e-02f, 1.39803186e-01f, -3.03759634e-01f, 1.50000751e-02f, -2.04292268e-01f, 1.68652192e-01f, 3.99382025e-01f, 5.09159148e-01f, 2.72014976e-01f,
  5.22008128e-02f, 8.68523344e-02f, -2.05525383e-01f, 2.82472342e-01f, 3.83016109e-01f, -1.05414450e-01f, 2.24573642e-01f, 1.69059426e-01f, 5.48747741e-02f, 1.11076668e-01f,
  -1.81029052e-01f, -6.79024383e-02f, 2.14122176e-01f, 8.83159414e-02f, -5.72096836e-03f, 4.02163453e-02f, 2.30145633e-01f, 3.64412330e-02f, -6.63011614e-03f, -3.22234273e-01f,
  3.61124784e-01f, -2.00979821e-02f, 5.04630864e-01f, 1.83715135e-01f, 6.70001358e-02f, -2.41942540e-01f, 4.34273988e-01f, -1.26255199e-01f, -3.32879037e-01f, 1.51628897e-01f,
  -2.47310862e-01f, 5.67319198e-03f, 5.64976156e-01f, 3.32607836e-01f, 4.16547433e-02f, -1.22147970e-01f, 1.66281953e-01f, -1.25556663e-01f, 1.46225309e-02f, -7.42686242e-02f,
  2.94632941e-01f, 1.48443073e-01f, 2.14152992e-01f, 3.57114941e-01f, 2.69110829e-01f, 2.19024003e-01f, -4.70488472e-03f, 3.11925709e-02f, -2.31767029e-01f, 6.21768422e-02f,
  1.60260126e-01f, 2.58893579e-01f, -2.19297186e-01f, -1.39636993e-01f, -1.71477646e-01f, -3.05370726e-02f, -4.11650762e-02f, 3.33553463e-01f, 1.73843578e-01f, 1.90238997e-01f,
  -3.42366636e-01f, 1.14453295e-02f, 1.77810639e-02f, 2.30533078e-01f, -9.95303094e-02f, 1.93579078e-01f, 3.88578027e-01f, -1.11132532e-01f, 2.16193557e-01f, 2.72369802e-01f,
  -3.30705941e-01f, -9.90675017e-02f, 1.18951477e-01f, -4.47988436e-02f, 3.57258946e-01f, 3.01574290e-01f, 3.99394721e-01f, 3.39142233e-02f, -7.15512335e-02f, 1.94630250e-01f,
  -1.34241268e-01f, -3.71361263e-02f, 2.57546026e-02f, -8.14507455e-02f, 1.77865371e-01f, 3.59001786e-01f, -9.61469859e-02f, -1.93019286e-01f, 2.38622025e-01f, 3.56480896e-01f,
  -8.25958792e-03f, -5.47089055e-02f, 6.15754165e-03f, -5.95151670e-02f, 1.50756940e-01f, -1.17498726e-01f, -2.41864309e-01f, 5.50750867e-02f, 2.92628109e-01f, -1.99302971e-01f,
  -3.74655247e-01f, 3.48451793e-01f, 3.20780464e-02f, 3.57711792e-01f, -1.80726364e-01f, 7.78531209e-02f, 3.18125725e-01f, -1.20605685e-01f, 4.46803831e-02f, -1.23476923e-01f,
  3.98104042e-01f, 2.43736789e-01f, -6.26766533e-02f, 9.97004807e-02f, -3.92225385e-01f, 3.27469021e-01f, 2.00961873e-01f, 1.01685449e-01f, 5.12278855e-01f, 3.40083271e-01f,
  3.51192594e-01f, 4.84760880e-01f, 3.13937366e-01f, 5.08732200e-02f, -3.55613828e-01f, -4.51684296e-02f, -8.73708352e-02f, 1.96282834e-01f, -2.67470777e-01f, 5.93872070e-01f,
  5.70667675e-03f, -1.42067537e-01f, 3.63524705e-01f, 3.01474810e-01f, -3.76001954e-01f, -1.82207942e-01f, 2.89873838e-01f, 4.72622663e-02f, 2.30324864e-01f, 2.78416604e-01f,
  3.67074996e-01f, -3.01062226e-01f, -6.69834986e-02f, 9.44899768e-02f, -2.33054776e-02f, 9.41460356e-02f, -1.76201627e-01f, -5.94332367e-02f, -3.41508724e-02f, -5.43461777e-02f,
  -2.12777644e-01f, -1.51747346e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 26)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 26;
const float L1_fan_Bp_bar_data[] = {
  -1.72009870e-01f, 1.51344717e-01f, 1.94731578e-01f, 1.26025528e-01f, -1.56878829e-01f, 7.54678845e-02f, 4.42633420e-01f, 2.99874693e-01f, 1.68715790e-01f, 7.01723620e-02f,
  2.16870308e-01f, 1.53860375e-01f, 1.23458290e-02f, 4.74283174e-02f, 3.87152322e-02f, 2.43363023e-01f, 5.64448629e-03f, 1.73467889e-01f, 3.86466943e-02f, 3.70665848e-01f,
  1.56745955e-01f, 3.16180825e-01f, 1.03338555e-01f, -3.40691768e-02f, 1.58710361e-01f, 3.90846848e-01f
};

// L2_linear_W (Shape: 12 x 32)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 32;
const float L2_linear_W_data[] = {
  -4.10952885e-03f, -7.59407133e-02f, -6.53564990e-01f, -2.82605529e-01f, -1.21407114e-01f, 5.46398349e-02f, 1.67188898e-01f, -3.80662084e-01f, 4.17371094e-01f, 4.32094872e-01f,
  5.50321758e-01f, 2.78538197e-01f, -3.80553007e-01f, 8.31854418e-02f, -2.05208525e-01f, 1.21709229e-02f, -3.59138697e-01f, -2.21144959e-01f, -1.80201158e-01f, -2.70974070e-01f,
  -1.27918646e-01f, -6.24768846e-02f, 1.52622461e-01f, 4.16313291e-01f, -3.13859433e-01f, -3.73615026e-01f, -3.71574461e-01f, -2.36240685e-01f, 7.76390284e-02f, 3.77654016e-01f,
  -4.66178432e-02f, 3.52454066e-01f, -4.66512680e-01f, -9.65819135e-02f, -7.34362066e-01f, 4.13434654e-01f, 6.52158558e-02f, 2.90942281e-01f, 4.02807117e-01f, 2.19287947e-02f,
  -3.91182572e-01f, 7.70878732e-01f, 5.37869334e-01f, 3.43779027e-01f, -2.86217600e-01f, -6.71313763e-01f, -2.91200876e-01f, -4.18409258e-01f, -2.90928423e-01f, -3.14109534e-01f,
  -3.12166870e-01f, 4.90644008e-01f, 7.59514645e-02f, -1.78699449e-01f, -6.64066970e-02f, 3.54126096e-01f, 1.81253314e-01f, 1.26532409e-02f, 1.44406229e-01f, 4.23398614e-01f,
  6.58882976e-01f, 1.93963543e-01f, -5.03981590e-01f, -2.36528739e-02f, -6.70031607e-02f, -2.03970019e-02f, 4.52616602e-01f, 4.72457230e-01f, -3.83119196e-01f, 3.98464559e-04f,
  1.29702896e-01f, -2.72610545e-01f, -3.92806321e-01f, 8.82919058e-02f, -1.86724141e-02f, 8.01338732e-01f, 6.01582348e-01f, 1.67033464e-01f, -1.44852534e-01f, -5.31896949e-01f,
  -4.32414889e-01f, -1.74717501e-01f, -1.36600822e-01f, -1.97765619e-01f, -9.52390507e-02f, 5.15904188e-01f, -1.27947748e-01f, -2.82852858e-01f, -2.47264400e-01f, -2.29993179e-01f,
  -2.10983038e-01f, -3.14592689e-01f, 2.51089573e-01f, 1.32266596e-01f, -3.33599865e-01f, 2.59743571e-01f, -5.35820961e-01f, 9.67234559e-03f, 2.08993360e-01f, -1.85372785e-01f,
  -4.50102575e-02f, 1.05359726e-01f, 2.35895179e-02f, -2.91584879e-02f, 4.41398054e-01f, 3.99525672e-01f, -1.94591403e-01f, -3.03020567e-01f, -5.50646007e-01f, 7.20099449e-01f,
  -1.56175181e-01f, 5.53963363e-01f, 1.45624220e-01f, 1.36443719e-01f, 2.76479088e-02f, 4.14090939e-02f, -1.33844391e-01f, -4.87894267e-01f, 1.62662581e-01f, -4.16313946e-01f,
  -6.26647621e-02f, -1.66432699e-03f, 2.26170629e-01f, -5.04307926e-01f, -1.44568637e-01f, -3.08648765e-01f, 2.87445992e-01f, -4.61062074e-01f, 9.75684822e-02f, 5.17410822e-02f,
  3.96220535e-01f, -6.38619840e-01f, 5.28811097e-01f, 1.94381759e-01f, 1.31377444e-01f, 2.18787551e-01f, -8.24320018e-02f, -6.43099666e-01f, 9.43421796e-02f, -2.61574298e-01f,
  -2.51861930e-01f, 4.70118791e-01f, -8.62334445e-02f, 6.37291849e-01f, -1.45500556e-01f, 5.08951902e-01f, -7.87761882e-02f, -6.82411939e-02f, 2.99533278e-01f, 1.14729770e-01f,
  1.73339825e-02f, 2.51074165e-01f, 3.28941047e-01f, -1.58639833e-01f, -5.37223876e-01f, -3.01874816e-01f, -1.00743033e-01f, 4.41907346e-01f, 4.87487078e-01f, 1.05710469e-01f,
  -7.25168735e-02f, 9.69187096e-02f, 1.60590827e-01f, 5.29258192e-01f, -3.86647165e-01f, 7.42684662e-01f, -2.78885663e-01f, -2.63421208e-01f, -3.65980297e-01f, 2.94877797e-01f,
  -1.10056862e-01f, 3.80724639e-01f, -3.27181637e-01f, -4.16581661e-01f, 4.82447416e-01f, 9.74441767e-02f, 1.60758033e-01f, 3.16854939e-02f, -2.19543148e-02f, 1.26311397e-02f,
  -7.53054023e-02f, -3.54882985e-01f, -4.83066440e-02f, -5.89670166e-02f, 2.95016710e-02f, 2.98539221e-01f, -2.94471413e-01f, -1.08093277e-01f, -5.80106303e-03f, 3.74444544e-01f,
  2.46526361e-01f, 9.32078838e-01f, 3.18856061e-01f, 3.55991840e-01f, 2.60941654e-01f, 3.41635078e-01f, 2.11193129e-01f, -5.48612714e-01f, -1.09580450e-01f, 2.11857602e-01f,
  -2.05484316e-01f, -6.34487748e-01f, -3.89016010e-02f, -6.03318065e-02f, 9.84665632e-01f, -5.47651947e-01f, 2.63931870e-01f, -3.36389810e-01f, -1.54764935e-01f, -1.10657834e-01f,
  1.26658473e-02f, -2.64817476e-01f, 8.06421712e-02f, 5.10139205e-02f, 2.43247114e-02f, -7.21823424e-02f, 2.27493361e-01f, 6.79125249e-01f, -7.67842159e-02f, 3.43112648e-01f,
  -2.73089588e-01f, -2.60892779e-01f, -5.04269302e-01f, -3.06448460e-01f, -4.23851788e-01f, -1.39933825e-01f, -5.69002569e-01f, -3.62328678e-01f, 3.40045661e-01f, -2.92956680e-01f,
  -1.05564609e-01f, 5.31276405e-01f, 6.30726814e-01f, 1.03993841e-01f, -1.80129379e-01f, -9.63046178e-02f, -1.50286853e-01f, 5.17287068e-02f, 1.78649314e-02f, -1.10667288e-01f,
  -1.77931428e-01f, -2.13123765e-02f, 1.93909958e-01f, 1.01135664e-01f, -1.73934594e-01f, -3.84076387e-01f, -6.36585057e-02f, 1.48342922e-01f, -2.41652519e-01f, 3.38406712e-02f,
  6.03930056e-01f, 3.59159917e-01f, -2.36700639e-01f, -2.59857506e-01f, -3.77964556e-01f, -5.13258994e-01f, -2.44195133e-01f, -1.06232569e-01f, 2.15073824e-01f, 4.39399540e-01f,
  -1.29216537e-01f, 4.43793476e-01f, 1.59619883e-01f, -7.52911419e-02f, -3.08787525e-01f, -9.53646898e-02f, -2.56874084e-01f, -1.30032241e-01f, -5.84411085e-01f, -3.38223279e-01f,
  4.94300842e-01f, -7.61042610e-02f, 7.75029957e-01f, -2.65098929e-01f, 6.54277265e-01f, 6.85232699e-01f, -1.37670234e-01f, -1.00259334e-01f, 1.03464812e-01f, -1.12609960e-01f,
  1.89967696e-02f, -2.58043885e-01f, 1.58876657e-01f, 3.97344798e-01f, -4.21819687e-01f, -4.30176914e-01f, -5.02118245e-02f, -1.76819310e-01f, 3.50753367e-01f, 1.32619634e-01f,
  -1.33795485e-01f, -2.89312810e-01f, -4.43443023e-02f, -5.51702738e-01f, 1.21393621e-01f, 3.96675579e-02f, 5.18172383e-01f, -5.98778129e-01f, -1.96487397e-01f, -3.99059445e-01f,
  2.50677466e-01f, 4.37906146e-01f, -1.63726211e-01f, -1.34257050e-02f, -4.17304218e-01f, 1.81345850e-01f, 2.05972102e-02f, -1.34301066e-01f, -6.56716377e-02f, 7.23797917e-01f,
  7.32592270e-02f, -1.03385635e-01f, 1.03136683e-02f, -1.32370844e-01f, 5.72442770e-01f, -3.94974738e-01f, -3.37038428e-01f, 2.26555601e-01f, -6.78096190e-02f, 3.50686491e-01f,
  1.08191356e-01f, -1.37668565e-01f, 2.66756177e-01f, -7.25690126e-02f, 1.43516943e-01f, -3.44077080e-01f, 1.36460578e-02f, 9.12590548e-02f, 8.80265906e-02f, -1.52240902e-01f,
  -2.69043058e-01f, -5.81778944e-01f, -3.43675733e-01f, -4.85816419e-01f, 3.10234696e-01f, 3.26286763e-01f, 7.77008772e-01f, 1.49781182e-01f, -4.73768562e-02f, 1.94669254e-02f,
  6.19716896e-03f, -1.93788752e-01f, 4.15479206e-03f, 9.97694880e-02f, 3.46657843e-03f, 6.48538232e-01f, -2.85159886e-01f, -6.16620958e-01f, 5.49319685e-01f, -1.20690814e-03f,
  -2.29207516e-01f, 1.41677454e-01f, 2.29714289e-01f, -1.39106140e-01f, 3.85700107e-01f, 1.56010389e-01f, -2.10889816e-01f, -1.79795504e-01f, -6.00947998e-02f, -1.68392509e-01f,
  -3.19114417e-01f, 3.20421368e-01f, -6.04626909e-02f, -1.83433414e-01f, 5.05404174e-01f, 1.50055602e-01f, -3.65923852e-01f, -6.78807199e-02f, 1.87416345e-01f, -1.19436122e-01f,
  -7.88120404e-02f, -4.75778012e-03f, 7.11530894e-02f, -3.77784848e-01f, 1.66921586e-01f, -1.66121393e-01f, 4.21436876e-01f, -4.87591088e-01f, 1.84554204e-01f, 3.06780100e-01f,
  -3.57544690e-01f, -4.64060545e-01f, 6.95265472e-01f, -4.39658761e-01f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  -2.48494253e-01f, -2.90519536e-01f, 6.96337074e-02f, -1.29305825e-01f, -1.54619440e-01f, 1.54681221e-01f, 1.51695609e-01f, -1.25405997e-01f, -7.39500821e-02f, 2.60851383e-01f,
  2.37236135e-02f, -9.18728709e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 3, 26
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 3, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        32, 12
    );
    }
    