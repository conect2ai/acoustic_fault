/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  2.88743824e-01f, -1.99265927e-01f, 5.85463457e-02f, 2.09307969e-01f, 1.96260840e-01f, 1.31030530e-02f, 6.44433722e-02f, 1.99818835e-02f, 1.82142019e-01f, -2.27727637e-01f,
  -2.79273182e-01f, 4.17171754e-02f, -1.46242172e-01f, -3.76138068e-03f, 8.45448226e-02f, 1.08588003e-01f, 2.52876356e-02f, 1.23096202e-02f, 9.68310758e-02f, 1.14038311e-01f,
  2.96607673e-01f, 7.49725029e-02f, 7.28508830e-02f, -4.08429913e-02f, -3.52888694e-03f, 6.64753607e-03f, -6.88124821e-03f, 3.20946388e-02f, -7.94857070e-02f, -2.92386375e-02f,
  -8.63406211e-02f, -7.73640350e-02f, -9.04102717e-03f, 8.91084373e-02f, -1.30697057e-01f, -6.37758076e-02f, -1.14808343e-01f, -5.08013926e-02f, 1.40591636e-01f, 1.33525366e-02f,
  -2.77752262e-02f, -7.09359869e-02f, 3.69652770e-02f, 4.85952310e-02f, 3.88666801e-02f, 5.62416501e-02f, 6.31179512e-02f, 5.80256525e-03f, -9.81067866e-03f, 4.38561989e-03f,
  9.19354260e-02f, -6.73337951e-02f, 7.30255321e-02f, -1.16765769e-02f, 1.05135702e-02f, -3.21980268e-02f, -1.59006082e-02f, 2.50432491e-02f, -3.06762792e-02f, -7.39056766e-02f,
  -1.20136373e-01f, 1.05663061e-01f, 1.51980529e-02f, 3.39421555e-02f, -3.02480049e-02f, -1.64772775e-02f, 3.60047398e-03f, -2.41044164e-03f, 4.57325727e-02f, 1.81277879e-02f,
  3.62458862e-02f, 4.58684340e-02f, 2.68361513e-02f, 1.23994745e-01f, -2.20512096e-02f, -3.40862316e-05f, 5.16074412e-02f, -8.78407713e-03f, 3.23758163e-02f, 2.30466705e-02f,
  -4.94218767e-02f, -2.44611390e-02f, 1.94918513e-02f, -5.84195592e-02f, -3.40919085e-02f, 9.49917808e-02f, -9.64533314e-02f, -3.40896137e-02f, -1.51737239e-02f, -3.87996063e-02f,
  3.13427970e-02f, -1.73456281e-01f, -4.52212729e-02f, -4.40065004e-02f, -6.29122555e-02f, -1.53124318e-01f, 7.45350122e-02f, -5.89544177e-02f, -4.38723303e-02f, 1.97390206e-02f,
  3.68373245e-02f, 7.05772452e-03f, -9.53549594e-02f, -1.89187862e-02f, 4.01357338e-02f, -2.20128465e-02f, -7.81257823e-02f, -4.11795778e-03f, 2.52247583e-02f, -1.07721366e-01f,
  -2.60991808e-02f, -4.41445857e-02f, 5.63366003e-02f, 2.53231041e-02f, 5.25072999e-02f, -9.15356055e-02f, 2.50416752e-02f, 1.45418504e-02f, -4.56939600e-02f, -3.99254076e-02f,
  4.05923754e-01f, 1.10996701e-01f, -6.02424517e-02f, 8.19140077e-02f, -1.15467399e-01f, -2.78201997e-01f, -3.34413052e-01f, 7.74814263e-02f, -1.61542334e-02f, -2.77650226e-02f,
  -1.31268770e-01f, 1.68328986e-01f, 7.67295860e-05f, -4.47590016e-02f, -1.67026743e-01f, 7.56763890e-02f, 1.62769966e-02f, 5.23346290e-02f, 3.33891325e-02f, 1.01676502e-03f,
  6.02015182e-02f, 1.37241513e-01f, 6.51213378e-02f, 8.60666670e-03f, -7.97017291e-02f, 1.34766117e-01f, -3.55268344e-02f, -9.52488035e-02f, -1.20388299e-01f, -1.02105334e-01f,
  6.93616718e-02f, 1.21615805e-01f, 6.97642937e-02f, -2.95436196e-02f, -7.90974200e-02f, -3.79971303e-02f, 4.67017591e-02f, -9.25626457e-02f, -5.52639067e-02f, -5.84241226e-02f,
  5.19707277e-02f, 4.83818818e-03f, 2.84058992e-02f, 3.00246733e-03f, -8.34954381e-02f, -1.27321139e-01f, -7.17758164e-02f, -6.48161471e-02f, 7.32932240e-02f, 9.11228880e-02f,
  -3.30943204e-02f, -1.12118730e-02f, -1.25095099e-01f, 7.74735138e-02f, -3.91176902e-02f, -9.66171175e-02f, 1.29435165e-02f, 4.09861356e-02f, 5.90190291e-02f, -3.72041203e-02f,
  5.95818087e-02f, -4.38741110e-02f, 6.63205385e-02f, 1.93150211e-02f, -4.63363677e-02f, 4.24768552e-02f, -3.78420465e-02f, 3.21647190e-02f, -6.04743361e-02f, 3.15803625e-02f,
  2.50772852e-02f, 6.61083683e-02f, 1.19315078e-02f, -1.21010859e-02f, 7.55834728e-02f, -6.46814033e-02f, 1.32142901e-02f, 3.85883823e-02f, -1.11539187e-02f, -6.33447841e-02f,
  4.97807227e-02f, -1.05789259e-01f, 6.29055053e-02f, 6.63103610e-02f, -9.13267285e-02f, -5.05515598e-02f, 3.49762104e-02f, -1.37462723e-03f, -7.80582801e-02f, -4.90574390e-02f,
  5.38677126e-02f, 1.88897729e-01f, 5.52855954e-02f, -5.25281504e-02f, -4.87896167e-02f, -3.01788151e-02f, -2.18318142e-02f, 3.84812690e-02f, -1.60615131e-01f, -3.35462950e-02f,
  -2.81173158e-02f, -3.44316177e-02f, -1.33333961e-02f, -8.19214806e-02f, 4.32880521e-02f, -4.90074344e-02f, 4.73820828e-02f, -7.32475566e-03f, -9.08255428e-02f, 3.10333688e-02f,
  4.76122275e-02f, 1.50408735e-02f, -5.75391725e-02f, 1.19738780e-01f, -2.81145293e-02f, 4.38145176e-03f, 5.29517978e-02f, -3.93683724e-02f, 5.25219552e-02f, -1.18913278e-01f,
  3.98557723e-01f, -2.37840325e-01f, -1.87836275e-01f, -7.25686317e-03f, 2.18952149e-01f, -4.39901948e-02f, -3.80817093e-02f, 1.24689609e-01f, 1.14755861e-01f, 4.11688313e-02f,
  -6.80844337e-02f, -1.74172297e-01f, -3.01657051e-01f, 1.29628673e-01f, 1.61941573e-01f, -1.44158483e-01f, 1.90603435e-01f, -7.55795240e-02f, -2.45684618e-03f, 1.06285915e-01f,
  -7.18026282e-03f, 4.91775759e-02f, -2.17371270e-01f, 7.19338208e-02f, 1.07816435e-01f, -8.01169574e-02f, 7.70002306e-02f, -2.72533536e-01f, 8.67541656e-02f, -3.96970697e-02f,
  3.46726030e-02f, -1.16809063e-01f, 1.20694032e-02f, -4.70959283e-02f, 2.86928285e-02f, 8.27837214e-02f, -1.05193675e-01f, -1.24370232e-01f, 5.48140556e-02f, 1.26900617e-02f,
  -7.27244988e-02f, -4.65388112e-02f, -4.75584790e-02f, 4.69864793e-02f, 1.93207059e-02f, -3.52269113e-02f, 6.35595918e-02f, 1.04707748e-01f, 6.42236546e-02f, -6.50579482e-02f,
  -4.18460332e-02f, -5.28122000e-02f, 2.68957261e-02f, -7.71123497e-03f, -2.78259758e-02f, -6.60960972e-02f, 1.84537917e-02f, 3.89220119e-02f, -1.66663975e-02f, 1.32980406e-01f,
  3.87967676e-02f, -7.56098107e-02f, -1.08743357e-02f, -5.74148633e-03f, 2.08112020e-02f, -5.11908680e-02f, -1.01633742e-03f, 1.00162541e-02f, 3.85873541e-02f, 9.83637646e-02f,
  -2.45685049e-04f, -5.86413071e-02f, -2.96177156e-03f, -5.70013076e-02f, 4.26845625e-03f, -4.25157472e-02f, 2.94581726e-02f, 1.10723544e-02f, -5.31118810e-02f, 2.02776175e-02f,
  -1.43626118e-02f, 5.52469457e-04f, -3.63123417e-02f, -1.07883997e-02f, -3.91786136e-02f, 1.73871797e-02f, -3.38387601e-02f, -9.70814750e-03f, -6.97197244e-02f, -8.63854289e-02f,
  1.47513123e-02f, 4.95701805e-02f, -1.07185412e-02f, -1.03716843e-01f, -4.51656990e-02f, 1.30241692e-01f, -4.41304035e-03f, -4.98920958e-03f, -1.21351769e-02f, 5.64913861e-02f,
  3.13145369e-02f, -2.55108550e-02f, 9.32756346e-03f, -6.22954741e-02f, -4.53579538e-02f, 3.67829017e-02f, -9.64263752e-02f, -6.77493885e-02f, 6.60570934e-02f, -3.65334712e-02f,
  7.36148879e-02f, 8.40699002e-02f, -3.71989310e-02f, 3.14212330e-02f, 4.99349721e-02f, -1.82375107e-02f, 1.64070763e-02f, -2.10970994e-02f, -3.89015265e-02f, -2.94235372e-03f,
  -3.02589417e-01f, 2.64206737e-01f, 7.09672123e-02f, 2.06169728e-02f, -1.78764597e-01f, -2.04945058e-01f, -2.55442977e-01f, 1.53349042e-01f, 1.79493472e-01f, 1.85914516e-01f,
  -1.66361853e-01f, -5.34528419e-02f, 1.92323625e-02f, 7.46702626e-02f, -3.24638128e-01f, 6.18492700e-02f, 5.97758554e-02f, -5.53494208e-02f, 9.55068171e-02f, -9.92483720e-02f,
  -1.25040233e-01f, -7.88476318e-02f, -5.53497002e-02f, 8.89130831e-02f, -1.86293408e-01f, 6.16639778e-02f, -1.83501646e-01f, -1.86609626e-02f, 5.96554950e-02f, -9.78634320e-03f,
  2.56911572e-02f, 1.35569246e-02f, 4.59785610e-02f, 7.80371502e-02f, -7.98845440e-02f, -8.42461362e-02f, -6.59865662e-02f, -1.47718281e-01f, 3.25012617e-02f, -2.45848764e-02f,
  -1.38058379e-01f, -3.70293967e-02f, 2.11698357e-02f, -9.54868458e-03f, -7.42019853e-03f, -1.44993411e-02f, 7.24544749e-02f, -1.69318393e-02f, 4.85776328e-02f, -7.37743638e-03f,
  -6.22455310e-03f, -1.81796476e-02f, -4.22786027e-02f, -1.66480634e-02f, -5.71079701e-02f, -4.13020775e-02f, -1.86292119e-02f, -4.50114952e-03f, -6.02240525e-02f, -5.99043109e-02f,
  -9.77248773e-02f, -3.10918726e-02f, 5.84987104e-02f, 4.39963164e-03f, 2.06376426e-02f, 1.54487211e-02f, 2.40864567e-02f, -1.28787896e-03f, 5.13502546e-02f, -1.14436997e-02f,
  -1.03964424e-02f, -1.18409339e-02f, 6.26661675e-03f, -5.26348837e-02f, 5.52413811e-04f, -1.05995713e-02f, -1.23483010e-01f, 2.93284990e-02f, 1.73716806e-02f, -6.10174984e-02f,
  -4.85689454e-02f, 2.74074338e-02f, 5.95522719e-03f, -1.08151501e-02f, -2.01910641e-02f, -7.00965384e-03f, 5.31842634e-02f, -1.51922213e-05f, -3.32810022e-02f, 5.18323760e-03f,
  6.54920936e-02f, 2.16160700e-01f, 5.87521605e-02f, 4.75579984e-02f, 1.11242756e-01f, 1.61065236e-02f, 6.88100606e-02f, -4.88366894e-02f, 1.06601544e-01f, -4.73767184e-02f,
  2.53998954e-03f, -6.05340786e-02f, -6.50607282e-04f, -6.04532696e-02f, 4.87919338e-02f, 1.09004445e-01f, -2.75543109e-02f, 2.12338474e-02f, 1.54994493e-02f, -5.83630055e-02f,
  -3.24146561e-02f, -6.84205070e-02f, -2.55965032e-02f, 4.24643010e-02f, 4.09910232e-02f, -8.79407600e-02f, -1.71131380e-02f, 3.05533260e-02f, 4.04746532e-02f, 7.15441108e-02f,
  -5.37704825e-02f, 7.52181187e-02f, 2.32212767e-01f, -1.17978886e-01f, 1.26493648e-01f, -3.85562256e-02f, -2.13416427e-01f, 2.82203436e-01f, 2.17876673e-01f, -3.02299969e-02f,
  -5.38716950e-02f, -8.02091584e-02f, -1.78990692e-01f, 3.94952251e-04f, -2.68002301e-01f, -1.20079309e-01f, -2.13435036e-03f, -9.22461897e-02f, 1.86061129e-01f, 4.30097729e-02f,
  8.08591619e-02f, -2.63289720e-01f, -1.27144933e-01f, -2.20815539e-02f, -6.59302622e-02f, 2.51831591e-01f, -3.03844720e-01f, 1.28891677e-01f, -1.65308371e-01f, -1.25422021e-02f,
  1.07707448e-01f, 5.53928539e-02f, 1.89677775e-02f, 9.15275812e-02f, -7.29495799e-03f, 9.24582034e-02f, 8.34870990e-03f, 1.80294961e-02f, 3.61949727e-02f, -8.18398595e-02f,
  -1.28749996e-01f, -1.89192761e-02f, 1.46870110e-02f, -3.78617421e-02f, 1.39045656e-01f, 5.65441586e-02f, 9.65770856e-02f, 7.94100575e-04f, 1.33711845e-02f, -1.65745523e-02f,
  -2.57509965e-02f, 1.76373906e-02f, 1.14782611e-02f, 1.14619313e-02f, 1.15344673e-01f, 6.48419261e-02f, -1.04760982e-01f, 2.99217384e-02f, -8.00795853e-02f, 4.61612642e-02f,
  -5.94925061e-02f, 1.94565125e-03f, -4.44048978e-02f, -1.23236790e-01f, 3.83192883e-03f, 1.54295552e-03f, -2.06228327e-02f, 8.49200413e-03f, 9.75584760e-02f, 2.07398310e-02f,
  -4.22207685e-03f, 2.18180264e-03f, 5.12957387e-02f, -2.00300142e-02f, 1.82662439e-02f, -3.99528071e-03f, -6.32011443e-02f, 1.45299071e-02f, 1.61167476e-02f, 4.46599834e-02f,
  5.40084206e-02f, 7.39110634e-02f, -1.02374129e-01f, -2.66977716e-02f, 7.14157820e-02f, 5.15695028e-02f, 5.74196018e-02f, 5.43836281e-02f, -5.47376685e-02f, -9.12302136e-02f,
  -3.44030857e-02f, -7.48344064e-02f, -2.55500190e-02f, -1.15816094e-01f, -2.43709534e-02f, -4.77616340e-02f, 2.57034022e-02f, 1.04616554e-02f, 1.61959410e-01f, -1.48296133e-02f,
  -7.44215325e-02f, -3.40358503e-02f, -1.03314035e-01f, 4.11170870e-02f, -1.59372147e-02f, -4.57348973e-02f, -1.68560386e-01f, -4.08477522e-02f, -2.41284128e-02f, 9.68837440e-02f,
  -2.41618007e-02f, -2.07804935e-03f, 7.99689814e-02f, 6.64373161e-04f, -7.55972043e-02f, -2.91448478e-02f, 7.41972625e-02f, -7.15695904e-04f, -8.08779746e-02f, -6.15075976e-02f,
  2.79481500e-01f, -1.64321601e-01f, -4.73951772e-02f, -1.98714621e-02f, 3.52640562e-02f, 3.12949181e-01f, 8.13772827e-02f, -6.87603056e-02f, 9.32828486e-02f, -1.03923097e-01f,
  9.20885354e-02f, 1.68220121e-02f, -1.01748388e-02f, 2.01335520e-01f, 4.89048660e-01f, 3.06096494e-01f, 2.53082663e-01f, 1.28104493e-01f, 7.14612454e-02f, -1.41555225e-04f,
  3.34038697e-02f, 1.83924109e-01f, 4.55562882e-02f, -1.44257635e-01f, -3.16965967e-01f, -3.09928745e-01f, -6.93666041e-02f, -1.65607229e-01f, -5.11232316e-02f, 6.97410330e-02f,
  4.96278368e-02f, -3.31357792e-02f, -1.65902033e-01f, 3.85678709e-02f, 9.07235965e-03f, -6.20951913e-02f, -4.29880014e-03f, -6.12425916e-02f, -6.61302544e-03f, -2.33569201e-02f,
  -1.59668531e-02f, 5.36313504e-02f, 7.43375123e-02f, 2.10153628e-02f, -2.44747698e-02f, 8.78023356e-03f, -6.33059442e-02f, -1.30988527e-02f, 3.85027044e-02f, -1.62346754e-02f,
  2.82865320e-03f, 7.39246756e-02f, 1.07066959e-01f, 6.99810386e-02f, -3.48486230e-02f, 1.01851616e-02f, -2.77204383e-02f, -7.86924511e-02f, -3.43633257e-02f, -1.38448859e-02f,
  2.56406907e-02f, 2.10540965e-02f, 2.57940013e-02f, -8.57106969e-02f, -2.07405630e-02f, -2.10755635e-02f, 3.88797745e-02f, 6.81461170e-02f, 5.78214191e-02f, 4.07707840e-02f,
  2.93684434e-02f, -1.14232516e-02f, 2.22847816e-02f, 3.47367153e-02f, -3.89917530e-02f, -3.08145434e-02f, -2.63111610e-02f, 3.00759953e-02f, -3.57650518e-02f, 1.64577160e-02f,
  -5.97443804e-02f, 7.48273134e-02f, -3.95346954e-02f, -5.87747656e-02f, 1.36392587e-03f, -3.82331423e-02f, 1.90591498e-03f, -6.01761136e-03f, -8.98872167e-02f, 3.56070437e-02f,
  6.78515211e-02f, -6.97110295e-02f, -5.19503243e-02f, 3.01374821e-03f, -4.23957296e-02f, 3.22521888e-02f, 6.21231198e-02f, -1.69787314e-02f, 1.61200785e-03f, -2.78634373e-02f,
  6.99310079e-02f, 3.99663970e-02f, -2.81329416e-02f, 9.01938304e-02f, -4.24897447e-02f, 1.03249162e-01f, -2.23296173e-02f, -4.90606911e-02f, -3.25334556e-02f, -7.41552934e-03f,
  -1.43798560e-01f, 1.83687642e-01f, -8.73072222e-02f, -6.84826300e-02f, -5.65297306e-02f, -8.99329931e-02f, 1.57673638e-02f, -1.22922484e-03f, 4.68313359e-02f, 6.96290433e-02f
};

// L0_fan_Wp_bar (Shape: 20 x 120)
const int L0_fan_Wp_bar_rows = 20;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -2.85183758e-01f, -1.82226837e-01f, -2.08049238e-01f, -1.90858945e-01f, -6.49468452e-02f, -2.91474521e-01f, -1.09800205e-01f, -4.57749069e-02f, -9.79675427e-02f, 6.49411455e-02f,
  -5.06332666e-02f, 8.01861808e-02f, 1.46888331e-01f, -1.47662684e-01f, 5.90409636e-02f, 1.72842249e-01f, -1.95188612e-01f, -4.77773100e-02f, -4.91334684e-02f, -2.02568486e-01f,
  -4.06156033e-02f, -1.70809492e-01f, 1.25709981e-01f, -2.13752925e-01f, -5.19153737e-02f, -1.11520536e-01f, 1.00839786e-01f, -4.94531244e-02f, -7.73322210e-02f, 4.27832641e-02f,
  -2.39610061e-01f, -4.14103456e-02f, -1.04602873e-01f, 1.21404946e-01f, -7.68453032e-02f, 6.06806688e-02f, -7.56038800e-02f, 1.28980979e-01f, 4.69028763e-02f, -1.79349408e-02f,
  6.07348643e-02f, 6.27757534e-02f, -8.85952115e-02f, -1.36744380e-01f, -3.24845174e-03f, -1.63471736e-02f, -3.03229201e-03f, -1.97967831e-02f, 5.42283058e-02f, 1.70179442e-01f,
  -6.13364466e-02f, -8.74907374e-02f, 7.23725930e-02f, -2.50495598e-02f, 6.70076460e-02f, -5.20802028e-02f, 2.52120420e-02f, -6.76371977e-02f, -2.69168280e-02f, -1.14552811e-01f,
  7.47325197e-02f, 9.13344547e-02f, -9.53769758e-02f, -2.35242508e-02f, 3.52026857e-02f, -1.85006574e-01f, -1.93830754e-03f, 1.02966957e-01f, 1.23572666e-02f, 1.04095750e-01f,
  -7.44485185e-02f, 9.52952728e-02f, -4.66816723e-02f, -2.71952003e-02f, -1.66139547e-02f, -6.32337481e-02f, -1.12631274e-02f, 1.12495303e-01f, -5.36529422e-02f, -2.49217376e-02f,
  4.39906940e-02f, 4.30519879e-03f, 5.49146347e-03f, -1.90407764e-02f, 2.25169174e-02f, 3.34218889e-02f, 2.61441357e-02f, -1.19830191e-01f, -6.57113940e-02f, -1.05508618e-01f,
  -2.74512708e-01f, -2.68618912e-01f, -4.06813100e-02f, -7.00133387e-03f, 6.21370748e-02f, -2.22235080e-02f, -8.55389703e-03f, -1.06645979e-01f, -1.14260800e-01f, -7.52839372e-02f,
  -1.40827492e-01f, -2.15220153e-02f, -5.39753065e-02f, 9.11841169e-03f, 2.32530627e-02f, -9.49242935e-02f, -1.55540733e-02f, -8.16936120e-02f, -6.41791373e-02f, 7.20950961e-02f,
  -8.52118991e-03f, 6.01547621e-02f, -6.84781224e-02f, -8.15126300e-02f, 1.17776290e-01f, 6.41534403e-02f, 2.26843869e-03f, 5.76329418e-02f, -3.09080910e-02f, -4.54909876e-02f,
  8.76981467e-02f, -1.91876277e-01f, 3.84417810e-02f, 2.20923930e-01f, -2.47271314e-01f, -2.25647897e-01f, -4.01972532e-01f, 8.92382935e-02f, -2.10960567e-01f, -1.31951243e-01f,
  4.72166874e-02f, -1.27021834e-01f, -1.20516986e-01f, 1.41790405e-01f, 3.36402282e-02f, -6.50782660e-02f, 2.61059791e-01f, -5.24177887e-02f, 5.51927835e-02f, 1.45028293e-01f,
  3.19920272e-01f, 2.23240986e-01f, 3.85445476e-01f, 3.65652680e-01f, 9.40048173e-02f, 2.67279148e-01f, 2.47870520e-01f, 1.13604896e-01f, 3.13982219e-01f, 8.01854581e-02f,
  -1.55693397e-01f, 2.77599934e-02f, -3.50401853e-03f, -1.32563123e-02f, 3.20955552e-02f, -6.03451058e-02f, -1.12038903e-01f, 1.27593139e-02f, -5.26729412e-02f, -3.38286981e-02f,
  -1.90109700e-01f, 1.13290101e-01f, 1.23764180e-01f, -4.53400500e-02f, -8.42604563e-02f, -1.06237076e-01f, -8.03333670e-02f, -7.69261178e-03f, -2.01626882e-01f, 5.39521948e-02f,
  -8.70729908e-02f, -1.11725032e-02f, 1.00524284e-01f, 1.27314761e-01f, 3.44737805e-02f, -3.83030996e-03f, -5.61052607e-03f, -4.61825691e-02f, -8.80172774e-02f, -2.32071765e-02f,
  7.18546808e-02f, -8.12357813e-02f, 3.91084105e-02f, -4.32593897e-02f, -6.27565607e-02f, 4.26626317e-02f, 3.12523986e-03f, -1.31738810e-02f, -1.13825083e-01f, -6.68718591e-02f,
  3.23530436e-02f, -3.55394483e-02f, -3.28077339e-02f, -6.23158626e-02f, 7.17174727e-03f, -2.82800943e-02f, -5.01038022e-02f, 1.07613511e-01f, 1.27748236e-01f, -2.81542186e-02f,
  -8.73990357e-02f, -1.80445537e-02f, -2.29817219e-02f, 2.21936461e-02f, -8.32771603e-03f, 7.80979246e-02f, 1.27553105e-01f, 3.50880511e-02f, 2.33908892e-02f, -1.92327760e-02f,
  -1.99433155e-02f, 1.71636119e-01f, -1.01636937e-02f, -2.13891882e-02f, -8.52546021e-02f, -1.35935545e-01f, 5.96923120e-02f, 1.06256299e-01f, 1.37211621e-01f, -1.02218412e-01f,
  2.45056711e-02f, 8.10124475e-05f, -2.52909809e-02f, 7.14265555e-02f, -7.42012868e-03f, 2.59565525e-02f, 2.83672679e-02f, 7.04663917e-02f, -4.45475765e-02f, 5.94625957e-02f,
  -5.62143289e-02f, -1.79448366e-01f, 3.48391645e-02f, -2.80812010e-02f, -5.20661548e-02f, 1.00617573e-01f, -3.95391434e-02f, 1.14375494e-01f, 6.69956300e-03f, 4.03966457e-02f,
  -3.81749153e-01f, 8.62820819e-02f, -1.45066738e-01f, -1.59945026e-01f, 1.23279855e-01f, -2.91204721e-01f, -2.24742875e-01f, -6.42363280e-02f, -2.67539889e-01f, 2.26371735e-01f,
  2.95156445e-02f, -4.15123925e-02f, 9.42839459e-02f, -4.11589146e-01f, -5.60965776e-01f, -2.86900133e-01f, -2.35024840e-01f, -1.53843492e-01f, -6.00475967e-02f, 1.70740589e-01f,
  -8.05672854e-02f, 3.20374593e-02f, -2.06445530e-01f, 1.46852940e-01f, -4.33950759e-02f, 1.73404649e-01f, 2.92946368e-01f, 1.78491607e-01f, 1.75026000e-01f, -1.75251752e-01f,
  -2.01668099e-01f, 3.07572889e-03f, 3.82918827e-02f, -1.83423832e-01f, -3.39147858e-02f, 9.13157687e-02f, 8.07801932e-02f, -3.14406119e-02f, -2.84800194e-02f, -1.25301540e-01f,
  8.45462233e-02f, 6.21945411e-03f, -7.87443668e-02f, -6.67217970e-02f, -5.53142428e-02f, 9.86748142e-04f, 1.67134833e-02f, 4.55066822e-02f, -8.07451457e-02f, -6.71327263e-02f,
  -1.23866476e-01f, -2.24527195e-02f, 8.97339359e-02f, -1.21580446e-02f, -8.76002088e-02f, -1.17992751e-01f, -1.92245040e-02f, -2.98644267e-02f, -9.01718661e-02f, -2.20227893e-03f,
  2.96626948e-02f, -3.37874852e-02f, -2.29494963e-02f, -1.02766357e-01f, -4.86947224e-02f, 2.42651496e-02f, -4.91540432e-02f, 4.60432656e-02f, -1.56850480e-02f, 4.36688475e-02f,
  4.80100662e-02f, -6.67238459e-02f, -3.75815406e-02f, 3.60484719e-02f, 1.23794720e-01f, -6.88991370e-03f, 5.59429675e-02f, 7.91239068e-02f, -9.24600139e-02f, 1.00059547e-01f,
  2.59813797e-02f, 1.11606931e-02f, 2.72965860e-02f, 7.70788267e-02f, -1.28157005e-01f, 2.36339513e-02f, -2.18933653e-02f, 2.92147347e-03f, -9.20029543e-03f, 1.07128732e-01f,
  9.25891921e-02f, 2.89630026e-01f, -1.74156837e-02f, -3.38190347e-02f, 9.20758676e-03f, -4.23935167e-02f, -2.10345685e-02f, 4.56331149e-02f, -6.57528313e-03f, 6.25445182e-03f,
  6.40351176e-02f, 5.80418259e-02f, 1.00555383e-01f, -4.65171039e-02f, -5.58494106e-02f, 9.30189118e-02f, 5.04768491e-02f, -2.64701322e-02f, 5.61012216e-02f, -2.65113041e-02f,
  1.60760596e-01f, 7.89668486e-02f, 5.32299234e-03f, -2.91847158e-03f, 2.97847372e-02f, 2.20207814e-02f, 4.88193780e-02f, 6.56052455e-02f, 1.16015509e-01f, -2.63923854e-02f,
  -2.19913721e-01f, -2.09557384e-01f, -3.59281838e-01f, -1.24272881e-02f, 2.48223439e-01f, -1.14199392e-01f, -2.81951755e-01f, -3.07599902e-02f, -7.50065073e-02f, 5.90636618e-02f,
  -3.73010449e-02f, -1.89996019e-01f, -2.03181669e-01f, -1.38818428e-01f, -1.30355030e-01f, -1.92173168e-01f, -5.59568703e-02f, 1.04841374e-01f, -8.37232172e-02f, -6.48065284e-02f,
  -3.54724936e-02f, 2.66907990e-01f, -1.20139144e-01f, 2.59318590e-01f, 4.89763729e-02f, 1.93171963e-01f, 2.40379930e-01f, 1.04624175e-01f, 1.66567147e-01f, 1.74869701e-01f,
  -1.58683360e-01f, -2.01970622e-01f, 2.50153393e-02f, 2.21245792e-02f, -3.22494805e-02f, 9.55389999e-03f, 4.50552925e-02f, 1.80838462e-02f, 2.19885893e-02f, -9.80692208e-02f,
  -9.44011807e-02f, 1.46643728e-01f, 7.00224936e-02f, 5.72134592e-02f, -2.13833991e-03f, 1.83747187e-01f, -1.17987670e-01f, -5.20612970e-02f, 2.27758698e-02f, -1.68985114e-01f,
  -1.68613479e-01f, 4.07157429e-02f, -9.71794426e-02f, 1.96686722e-02f, -8.71616527e-02f, 2.95970589e-02f, 3.74435484e-02f, 7.97930956e-02f, 6.60194084e-02f, -1.03380461e-03f,
  -3.79190072e-02f, 3.73684391e-02f, -5.91388009e-02f, -2.88229417e-02f, -8.22095349e-02f, -2.70989700e-03f, -4.30502035e-02f, 1.29327625e-02f, -1.54553158e-02f, 5.71461990e-02f,
  3.82638499e-02f, -2.17332710e-02f, 5.48507506e-03f, -4.33645956e-02f, 4.12938520e-02f, -2.30995547e-02f, 5.34870066e-02f, 3.32557857e-02f, -5.05630709e-02f, -1.64395720e-02f,
  -2.87463143e-02f, -9.63880587e-03f, -2.32217815e-02f, 4.43403460e-02f, 9.50053856e-02f, 6.91377930e-03f, -2.34043747e-02f, -8.35754722e-02f, 7.30189905e-02f, 5.81674837e-02f,
  -2.19478518e-01f, -2.51782477e-01f, -1.21221673e-02f, 2.78090290e-03f, -6.15929626e-02f, 1.47507386e-02f, 5.63087203e-02f, -1.15724459e-01f, 4.65832837e-02f, 1.90872827e-03f,
  1.02085639e-02f, 1.52322128e-02f, 1.12117738e-01f, -4.43901531e-02f, 4.92218472e-02f, 3.22266072e-02f, 1.79730169e-02f, 1.43899405e-02f, 7.51562715e-02f, 5.38382977e-02f,
  3.42959389e-02f, -3.21891382e-02f, 1.24045566e-01f, 1.93764642e-01f, 1.01415608e-02f, 6.29336983e-02f, 9.33341905e-02f, 1.22670783e-02f, -4.23180535e-02f, -6.24434985e-02f,
  -7.29414284e-01f, 7.25583658e-02f, 4.98930216e-02f, -5.42167544e-01f, 7.24742711e-02f, -3.87079269e-02f, -2.15846509e-01f, 1.26338109e-01f, -3.71926218e-01f, -3.80986184e-02f,
  -5.92601895e-02f, -6.17968403e-02f, 1.19454846e-01f, -1.00409195e-01f, -2.29099706e-01f, 2.86761280e-02f, -1.24129564e-01f, -1.57977104e-01f, 1.54233888e-01f, 3.30121629e-02f,
  -3.16913947e-02f, -5.21181151e-04f, 4.29628976e-02f, 2.84684539e-01f, -7.99095854e-02f, -6.92612454e-02f, 1.31286364e-02f, 8.62827003e-02f, -3.34277488e-02f, 1.13596991e-01f,
  -2.16198191e-01f, -1.31588891e-01f, -1.06401034e-01f, -6.96225613e-02f, -9.20328349e-02f, 7.12695718e-02f, -9.23823193e-02f, 8.63030273e-03f, -1.05823368e-01f, 2.54135896e-02f,
  -2.55776439e-02f, 9.66112837e-02f, 1.10120572e-01f, 1.79901168e-01f, -4.86743152e-02f, -5.72278276e-02f, 7.50034116e-04f, -6.20083585e-02f, 1.09552294e-02f, 6.97611719e-02f,
  6.33447431e-03f, 5.06533943e-02f, -1.00684024e-01f, -6.11645989e-02f, -6.10248260e-02f, -2.50803288e-02f, -2.32530255e-02f, 7.69927958e-03f, -5.74526265e-02f, 5.67060113e-02f,
  7.65251145e-02f, 7.63988793e-02f, -8.55692383e-03f, -4.87402491e-02f, 1.28835095e-02f, -4.06539217e-02f, 2.23901942e-02f, -4.26917225e-02f, -8.99287462e-02f, 7.44660646e-02f,
  -4.22830619e-02f, -3.56528424e-02f, 6.65678158e-02f, -8.77517625e-04f, -8.47731978e-02f, 2.29375754e-02f, 1.12033514e-02f, -5.18317446e-02f, -4.41353172e-02f, 2.05919426e-02f,
  -1.23070978e-01f, -1.14786297e-01f, 1.59793086e-02f, -1.17448740e-01f, 1.26577780e-01f, 4.01850380e-02f, 1.14356861e-01f, -1.89954191e-02f, -2.26429123e-02f, -2.87714507e-02f,
  -2.27657169e-01f, -2.39863738e-01f, -7.84904957e-02f, -7.14261234e-02f, -4.26005274e-02f, 6.58905581e-02f, 1.51436962e-03f, 1.85388199e-03f, 8.56613740e-02f, 1.90481674e-02f,
  7.67509360e-03f, -8.91024545e-02f, -8.85421485e-02f, 1.04985423e-02f, -3.46968472e-02f, 1.72329862e-02f, -1.17312171e-01f, -1.04179882e-01f, -1.56664163e-01f, 9.69463140e-02f,
  -5.94166927e-02f, 2.33779699e-02f, -3.63907255e-02f, 1.48203708e-02f, -9.11181886e-03f, -2.69556828e-02f, -1.05484299e-01f, -3.16940919e-02f, 3.53295840e-02f, -2.12485548e-02f,
  2.77048975e-01f, -1.08902484e-01f, 1.65558737e-02f, 2.38564298e-01f, -2.04237252e-02f, -1.51771858e-01f, -3.09291780e-01f, 1.70494094e-01f, -9.84113663e-02f, -1.45356715e-01f,
  8.70790184e-02f, -1.30343899e-01f, -2.42590204e-01f, 1.96405098e-01f, 8.70829076e-02f, -1.61977649e-01f, 1.83081880e-01f, -2.16089580e-02f, -9.86840799e-02f, 1.66713566e-01f,
  2.21565977e-01f, 2.97815323e-01f, 1.99499249e-01f, 1.69974416e-01f, -3.99177782e-02f, 2.19545066e-01f, 2.41507933e-01f, -8.96037444e-02f, 2.77502447e-01f, -6.80025667e-02f,
  1.39205437e-02f, -3.05540692e-02f, -5.39410003e-02f, -8.73063058e-02f, 5.80068417e-02f, 1.30230397e-01f, 3.02029233e-02f, -7.86564574e-02f, 2.11415607e-02f, -9.00574848e-02f,
  -9.06723738e-02f, 4.37552296e-02f, 5.97926416e-03f, 1.43234000e-01f, -3.98003962e-03f, 7.86582679e-02f, -3.75787802e-02f, -1.05379507e-01f, -1.86798841e-01f, 1.08716637e-01f,
  -2.53728381e-03f, -4.74924892e-02f, -3.88162443e-03f, -4.45700921e-02f, 6.51778728e-02f, 9.14876610e-02f, 7.67029403e-03f, -1.23934373e-01f, -7.29878247e-03f, 1.24645242e-02f,
  5.22887800e-04f, -4.83011594e-03f, 1.29672131e-02f, -6.16365299e-02f, -4.14504074e-02f, -4.41746379e-04f, -6.46897480e-02f, 5.37442183e-03f, -2.61558499e-02f, -6.56156689e-02f,
  -8.15335065e-02f, 1.59418955e-02f, -2.80298963e-02f, 4.01940569e-02f, 6.33758679e-02f, -9.66104120e-02f, -5.77171333e-02f, -4.30838577e-02f, 4.64801714e-02f, -8.02859850e-03f,
  -9.23210010e-02f, 5.54298162e-02f, -5.15562035e-02f, -9.47311223e-02f, 1.36830704e-02f, 5.21802492e-02f, 1.78165391e-01f, 6.30551353e-02f, -9.90429819e-02f, 2.68461909e-02f,
  3.66448686e-02f, 1.18783981e-01f, -7.35872537e-02f, 1.30122509e-02f, -8.84803757e-02f, 3.49713210e-03f, 5.93075082e-02f, 1.04267590e-01f, 3.90439890e-02f, 9.45343301e-02f,
  8.51138085e-02f, 3.87827568e-02f, -7.77783468e-02f, 2.49115061e-02f, 2.50883941e-02f, -1.31390579e-02f, 1.85593516e-02f, -2.45763734e-02f, 7.77780486e-04f, 1.88479394e-01f,
  1.38846459e-02f, -1.01689868e-01f, 4.47115712e-02f, -1.65991321e-01f, 3.61083075e-02f, -4.01431918e-02f, -1.23632485e-02f, 2.05090437e-02f, -4.43296181e-03f, 6.07282929e-02f,
  2.43534639e-01f, 3.80231626e-02f, -3.53424639e-01f, -1.31767124e-01f, 2.85848379e-01f, 5.37613630e-02f, -4.62644082e-03f, 4.27858196e-02f, -2.65659362e-01f, 2.11178631e-01f,
  2.38615274e-01f, -1.63315043e-01f, -1.21310502e-01f, 2.49401852e-01f, 1.23050690e-01f, -2.61111975e-01f, 1.28784567e-01f, 1.35393232e-01f, -1.30978554e-01f, 4.58455570e-02f,
  -9.52870548e-02f, 4.72094804e-01f, -1.90739796e-01f, 2.81148165e-01f, 2.25408763e-01f, -1.77577823e-01f, 2.25111127e-01f, -2.11536884e-01f, 2.78166056e-01f, 1.17956810e-01f,
  8.23865607e-02f, -4.75552827e-02f, 1.64239593e-02f, -5.23608215e-02f, 1.05669035e-03f, 8.31426159e-02f, -9.22867795e-04f, -1.15806952e-01f, 4.59478609e-02f, 2.96392366e-02f,
  3.89327146e-02f, 9.49422736e-03f, 9.06801447e-02f, -4.54212539e-02f, 7.31739700e-02f, 2.69639716e-02f, -2.78239232e-02f, -1.42177016e-01f, -3.57243083e-02f, -2.63268761e-02f,
  -8.66518021e-02f, -3.95203978e-02f, -1.07378639e-01f, -3.30182649e-02f, -1.03011634e-02f, 7.70945698e-02f, -1.37889758e-01f, -6.84044883e-02f, 1.87285393e-02f, -1.32116834e-02f,
  -3.37142386e-02f, -3.14062424e-02f, -2.68423483e-02f, 1.80013582e-01f, 3.13229561e-02f, 3.60715240e-02f, -9.18378879e-04f, 3.56210656e-02f, 5.50730303e-02f, 1.61885880e-02f,
  -5.65557554e-02f, 6.59857616e-02f, -4.07405458e-02f, 2.76871696e-02f, 1.19380012e-01f, -1.62424725e-02f, -7.95281455e-02f, 6.62752381e-03f, -4.81547639e-02f, 6.23053946e-02f,
  -9.28533599e-02f, -8.31911713e-02f, -4.41090669e-03f, -1.92157626e-02f, -3.45626064e-02f, -5.14503159e-02f, 4.25275927e-03f, -5.85354008e-02f, -4.60507609e-02f, 3.08217425e-02f,
  1.01094201e-01f, 4.12338004e-02f, -1.02375224e-01f, 4.50567566e-02f, 4.90377769e-02f, 1.13758370e-01f, -6.41231984e-02f, 6.36644214e-02f, -1.32968426e-01f, 2.43125781e-02f,
  6.41561374e-02f, 6.80773146e-03f, 9.02799070e-02f, 9.64512769e-03f, -4.63464521e-02f, 3.27688791e-02f, -6.35215566e-02f, 4.83357422e-02f, 9.58308354e-02f, 5.96801527e-02f,
  6.24139346e-02f, 8.63750502e-02f, 1.00231908e-01f, 1.11648031e-01f, 1.39639214e-01f, -7.60702789e-02f, 1.56256706e-02f, -1.42307863e-01f, 1.32249668e-01f, -1.83047265e-01f,
  1.07154876e-01f, 1.99483693e-01f, -1.39659762e-01f, 1.99296713e-01f, -1.18885383e-01f, -8.88470635e-02f, -1.36345744e-01f, 2.79732287e-01f, -1.07966721e-01f, 2.00309858e-01f,
  2.25974768e-01f, -3.75089236e-02f, 4.16788161e-02f, 4.38284039e-01f, 1.34478912e-01f, -8.22855905e-03f, 2.58548200e-01f, -7.15888739e-02f, -1.75888855e-02f, 1.39400572e-01f,
  1.45711631e-01f, 3.33282709e-01f, 9.21410099e-02f, 1.74443468e-01f, 1.98737293e-01f, 1.70919359e-01f, 1.54816613e-01f, -1.02363735e-01f, 3.06691647e-01f, 1.06260523e-01f,
  -2.74938829e-02f, 6.08335249e-02f, -5.25642149e-02f, -1.32206857e-01f, 9.11062211e-02f, 2.80249063e-02f, -2.69452155e-01f, -1.10407926e-01f, 4.52680588e-02f, 3.21919546e-02f,
  -1.52409390e-01f, -1.76380780e-02f, -7.33272731e-02f, -8.86597857e-02f, 6.82960376e-02f, -1.08145535e-01f, 8.50952342e-02f, -1.20908424e-01f, 3.73934098e-02f, -2.90804170e-02f,
  -2.41326541e-02f, 6.89708516e-02f, 1.17971869e-02f, 3.06175891e-02f, 3.25163715e-02f, -3.23639736e-02f, -2.94670593e-02f, -5.21474294e-02f, -4.68517765e-02f, -6.12762012e-02f,
  5.71450107e-02f, 2.26091146e-02f, -1.04283720e-01f, -2.31608376e-02f, 3.10762934e-02f, 3.83316316e-02f, 8.98140296e-02f, 8.35663453e-02f, -1.35110795e-01f, 2.39881612e-02f,
  7.87904337e-02f, 2.06429269e-02f, 3.62824053e-02f, -2.50848848e-03f, -3.18999663e-02f, -2.49955039e-02f, 6.07586540e-02f, 8.58799219e-02f, -4.89019556e-03f, -5.12059517e-02f,
  -2.11331043e-02f, 8.42372999e-02f, -2.90378579e-03f, -2.34253518e-02f, -6.89986944e-02f, 7.37154633e-02f, 1.02228627e-01f, -5.98055124e-02f, -7.97233954e-02f, -1.53653860e-01f,
  6.40019253e-02f, 2.44184867e-01f, -9.05468613e-02f, -7.17030168e-02f, 3.77422757e-02f, -3.77507359e-02f, -2.08341368e-02f, 7.98338428e-02f, 6.90231770e-02f, 8.35807845e-02f,
  -2.62616593e-02f, -1.11544251e-01f, 4.78736386e-02f, -3.55806910e-02f, 1.89771559e-02f, 3.91718633e-02f, 8.15562680e-02f, -6.07148670e-02f, 1.39169255e-02f, 1.23041362e-01f,
  -2.54139975e-02f, 5.09466343e-02f, -1.28807589e-01f, -8.78642276e-02f, 2.60386746e-02f, 1.03221379e-01f, -4.67528775e-02f, -2.14205813e-02f, 6.12700880e-02f, 1.68185737e-02f,
  -5.99454701e-01f, -1.76296961e-02f, -1.83836162e-01f, -8.63052309e-02f, -1.72725126e-01f, -1.20720372e-01f, -1.05664060e-01f, -2.23268270e-01f, -1.71480805e-01f, 7.13492036e-02f,
  5.63901477e-03f, -1.04540356e-01f, 1.22530028e-01f, 1.05015207e-02f, 1.29315928e-01f, 9.67484415e-02f, -1.75622888e-02f, -1.13914222e-01f, 6.59233779e-02f, -1.65762961e-01f,
  5.63992467e-03f, -5.09603741e-03f, 7.85359647e-03f, -6.16429001e-02f, -1.26862273e-01f, -5.10939658e-02f, -3.23787034e-02f, 1.98217556e-02f, 9.89961103e-02f, 7.66575783e-02f,
  -1.92289367e-01f, -3.74172121e-01f, -2.08945706e-01f, -1.83780372e-01f, -8.00536796e-02f, -1.11744776e-01f, 4.23117206e-02f, 3.55566554e-02f, -3.95017117e-02f, -4.41915020e-02f,
  7.65515640e-02f, -5.02029024e-02f, -3.03787682e-02f, 6.41889125e-02f, -3.63138989e-02f, -4.92294468e-02f, 6.32567182e-02f, -2.65659839e-02f, -9.83861275e-04f, 1.60785124e-01f,
  1.03860073e-01f, -5.98352253e-02f, -8.70835334e-02f, 9.35182124e-02f, 9.25997421e-02f, 3.21422480e-02f, 3.97416838e-02f, 4.33376394e-02f, -1.03252120e-01f, -6.46025240e-02f,
  5.83751732e-03f, 1.61263496e-02f, 4.11062986e-02f, -3.21160406e-02f, 2.34975759e-02f, 5.16710803e-02f, 3.52814011e-02f, 1.51708890e-02f, 4.96397614e-02f, -6.48714080e-02f,
  -7.88715016e-03f, -3.40467505e-02f, -9.08814594e-02f, 5.78132570e-02f, 2.43884884e-03f, -5.30015491e-02f, -2.76134927e-02f, 4.23034914e-02f, 7.67821693e-05f, -3.18537168e-02f,
  5.83636239e-02f, 3.21014151e-02f, -1.92458984e-02f, 7.34012127e-02f, -8.24585631e-02f, -8.03848496e-04f, -3.92434224e-02f, 6.27140477e-02f, -2.74539180e-02f, 1.74615290e-02f,
  -5.07382333e-01f, -4.92441505e-01f, -4.06894870e-02f, -9.73772556e-02f, -3.62699814e-02f, -1.07494399e-01f, 1.55946212e-02f, -9.07359943e-02f, -7.66971484e-02f, -5.82062230e-02f,
  -1.07443288e-01f, 5.07114865e-02f, 2.12830417e-02f, 7.16070309e-02f, 1.45944923e-01f, 3.79383452e-02f, -1.01846019e-02f, -1.21376114e-02f, -3.21620074e-03f, 1.63091663e-02f,
  -5.61650954e-02f, -2.07905006e-03f, 3.05473688e-03f, 1.25912383e-01f, -3.00329830e-02f, -1.31821111e-01f, -1.25517622e-01f, 9.11576152e-02f, 2.57499348e-02f, 7.94990733e-02f,
  -5.88642478e-01f, 8.12729076e-02f, -2.02740699e-01f, -2.95497864e-01f, -2.88471133e-02f, -2.39186406e-01f, -2.94965684e-01f, 8.70436355e-02f, -3.80397476e-02f, -8.52764547e-02f,
  -6.54547662e-02f, -4.21661288e-02f, 1.06318414e-01f, -2.59602088e-02f, -1.46546319e-01f, 1.75414547e-01f, -2.05852970e-01f, -1.14380457e-01f, -4.68938760e-02f, -6.93992153e-02f,
  -1.66895762e-01f, 9.64242890e-02f, 4.27964963e-02f, 1.00505494e-01f, -1.66132331e-01f, -1.01027414e-01f, 2.72118114e-02f, 1.47100478e-01f, -2.09677234e-01f, 5.77524165e-03f,
  1.94442307e-03f, 1.07668348e-01f, 4.92212921e-02f, 6.04294837e-02f, -2.36103386e-01f, -8.45380053e-02f, -1.37346238e-01f, -1.82367973e-02f, -1.12429570e-05f, -5.87124862e-02f,
  -2.78922729e-03f, 5.33410832e-02f, -3.27618942e-02f, 9.44258496e-02f, 4.59311604e-02f, 1.10718817e-01f, -4.29485831e-03f, -2.27564108e-02f, -5.65358102e-02f, 6.99634105e-03f,
  3.72319818e-02f, 4.87574656e-03f, -7.08166435e-02f, -1.74261760e-02f, -1.13847375e-01f, -4.00583334e-02f, -7.52935857e-02f, -4.79678512e-02f, -8.64175484e-02f, -4.54663346e-03f,
  1.78495590e-02f, -9.94229168e-02f, 5.51233664e-02f, 2.18244568e-02f, -1.17174543e-01f, -2.87617296e-02f, 2.09909584e-02f, -3.09807458e-03f, -1.15595885e-01f, 1.16386935e-01f,
  -6.88617304e-02f, 2.39681769e-02f, 2.98401006e-02f, 4.68908325e-02f, -3.33134085e-02f, -3.84412408e-02f, -7.63080344e-02f, 5.19608893e-02f, -9.71417502e-02f, -6.45160303e-02f,
  7.52262548e-02f, 6.18265867e-02f, -1.64616369e-02f, 5.55271283e-03f, 5.68281375e-02f, 5.39988745e-03f, 1.17464498e-01f, 5.00092879e-02f, 1.13846675e-01f, -1.43143982e-01f,
  -2.92882442e-01f, -1.10295527e-01f, 1.13461703e-01f, -9.35003161e-03f, -1.17753111e-01f, -4.77093160e-02f, 5.27885705e-02f, -8.89568552e-02f, -1.32199600e-01f, -2.67678257e-02f,
  -1.82443834e-03f, -9.33666453e-02f, -1.61419049e-01f, -6.57357052e-02f, -1.00297043e-02f, 4.86147366e-02f, -1.12870939e-01f, -9.62853283e-02f, -2.91916635e-02f, -7.99736977e-02f,
  -1.41745344e-01f, -8.37392211e-02f, -3.86069939e-02f, 8.42128098e-02f, -7.46582076e-02f, -9.50441509e-02f, -1.50541216e-01f, 7.59535208e-02f, 5.54267615e-02f, -3.77801284e-02f,
  -2.94888973e-01f, -8.24241415e-02f, -2.50702828e-01f, -2.38202900e-01f, 9.24476832e-02f, -2.09873199e-01f, -1.80460140e-01f, 1.24595910e-02f, 7.18576834e-02f, 1.54862553e-01f,
  5.49682230e-02f, -2.31186822e-01f, 1.69109210e-01f, -4.43242431e-01f, -3.61020982e-01f, -2.52614319e-01f, -5.30614436e-01f, -1.92608878e-01f, -1.03759810e-01f, -1.46802098e-01f,
  -9.31975842e-02f, -7.90620148e-02f, -2.98652291e-01f, 1.53967842e-01f, -1.61811872e-03f, 1.14466339e-01f, 2.19255477e-01f, 1.09105870e-01f, -1.03784837e-01f, 3.00012734e-02f,
  4.93640490e-02f, -2.42889952e-02f, 8.99580345e-02f, 2.36574523e-02f, 3.26545909e-02f, 1.22340890e-02f, -4.99872491e-02f, -3.22091058e-02f, 4.78981249e-02f, 6.54826220e-03f,
  2.07530428e-02f, -4.59304936e-02f, -9.32276174e-02f, 5.73784523e-02f, 5.88718504e-02f, -1.29263755e-02f, -3.47205345e-03f, 4.70172018e-02f, 2.07066070e-02f, -1.81628868e-01f,
  -8.77299309e-02f, -3.01435008e-03f, 9.28800087e-03f, 7.03503266e-02f, 3.33603621e-02f, -1.03233926e-01f, -2.24049523e-01f, 2.14912295e-02f, -4.15169261e-03f, -4.00885828e-02f,
  -6.86003789e-02f, -1.91407744e-02f, -4.03331891e-02f, 8.91343355e-02f, 2.66483072e-02f, 1.30912438e-01f, 7.70136490e-02f, 4.95127477e-02f, 7.12147504e-02f, 2.24379580e-02f,
  7.12855682e-02f, -1.33645663e-04f, -6.77456963e-04f, -9.33983456e-03f, -5.15784174e-02f, -9.51552466e-02f, -1.73721146e-02f, 5.24115525e-02f, -7.38105038e-04f, 2.69201007e-02f,
  7.98768029e-02f, -5.36940955e-02f, 7.50989541e-02f, 3.33390944e-02f, -2.19800845e-02f, 5.78706115e-02f, 4.01496887e-02f, 2.90542785e-02f, 5.79591794e-03f, -4.54124622e-02f,
  9.70106944e-02f, 9.49139893e-02f, 1.17952600e-01f, 2.09803149e-01f, 3.30428295e-02f, -1.05586596e-01f, -1.17661774e-01f, 6.42382726e-02f, -4.33734730e-02f, -5.05036898e-02f,
  7.33854771e-02f, 8.76757354e-02f, 2.03372110e-02f, 5.03496230e-02f, 4.96913530e-02f, -6.49635354e-03f, -3.14199179e-02f, 9.17877108e-02f, 6.75414875e-02f, -4.08739690e-03f,
  -5.70575520e-03f, -8.37636006e-04f, -3.52768670e-03f, 2.45532225e-04f, 1.14265317e-02f, 1.66809186e-02f, 2.77573615e-02f, -7.53965154e-02f, -5.39165661e-02f, 8.25723913e-03f,
  -3.34629416e-01f, 3.26251984e-01f, -9.94313657e-02f, 2.37875357e-01f, -2.88965255e-01f, 3.13095689e-01f, 5.35766602e-01f, 6.90625906e-02f, 1.41021892e-01f, 4.88707364e-01f,
  3.12284738e-01f, 3.50070409e-02f, 1.88852727e-01f, 4.43512022e-01f, -1.74646045e-03f, 2.96279907e-01f, 3.75452608e-01f, 2.58703649e-01f, -8.61515105e-02f, 2.19818324e-01f,
  -7.52323493e-02f, 3.24172080e-01f, 8.42518508e-02f, -6.29339069e-02f, 1.20347366e-01f, -1.98491886e-01f, 9.96859372e-02f, -3.00707638e-01f, 8.60402882e-02f, 8.60203174e-04f,
  4.18014489e-02f, -5.46445660e-02f, -5.44010550e-02f, -4.19396460e-02f, 1.26011372e-02f, -5.55182956e-02f, 9.25356373e-02f, -1.17213070e-01f, -9.56670567e-02f, -1.47454459e-02f,
  3.45304050e-02f, -1.40301324e-02f, 3.37005332e-02f, -4.24094172e-03f, -9.37135071e-02f, -6.16592094e-02f, -1.36092335e-01f, -1.75669622e-02f, 3.70853655e-02f, -1.04959376e-01f,
  -1.36112511e-01f, -1.27414554e-01f, -7.23480619e-03f, 1.45924076e-01f, -7.56334141e-02f, 3.68497185e-02f, 1.55948058e-01f, -2.91612297e-02f, -2.22605001e-02f, 4.61775810e-03f,
  -6.13326803e-02f, 5.37395887e-02f, 6.30001724e-02f, 8.14123154e-02f, -7.50203580e-02f, -6.07568445e-03f, -4.15864885e-02f, 1.33536197e-02f, 8.78266990e-03f, 4.52427343e-02f,
  5.98905459e-02f, -4.68960544e-03f, 2.25743861e-03f, 2.62586232e-02f, -9.81344748e-03f, 7.20429197e-02f, -8.55277944e-03f, -5.46614453e-03f, 4.81708460e-02f, 1.81605928e-02f,
  2.22583655e-02f, -1.04943221e-03f, 1.13479167e-01f, 1.22101054e-01f, -4.58335690e-02f, 2.63861410e-04f, 1.00993551e-01f, -8.56298115e-03f, 6.40467554e-02f, 4.52854447e-02f,
  2.15454757e-01f, 1.95669696e-01f, 1.05078757e-01f, 4.07017656e-02f, -8.09651613e-02f, -6.87350705e-02f, -2.46470142e-02f, -5.94022684e-02f, -2.91819591e-03f, -1.11347921e-02f,
  -2.87739336e-02f, -2.10210830e-02f, 2.13534012e-02f, -1.02523945e-01f, -2.58291643e-02f, 1.32691607e-01f, 8.30817595e-02f, 9.12100375e-02f, 1.06812648e-01f, -2.40196362e-02f,
  -2.28797155e-03f, 5.52424788e-02f, 6.38059974e-02f, -5.72691113e-02f, -2.93307342e-02f, 1.00748641e-02f, -1.29644394e-01f, -1.26452863e-01f, -1.43489882e-01f, 4.12380546e-02f,
  -7.14551985e-01f, -6.53473809e-02f, -9.15409401e-02f, -1.23601928e-01f, -1.73996285e-01f, -1.29829407e-01f, -1.90794647e-01f, -1.46210968e-01f, -1.69652849e-01f, 2.37583265e-01f,
  4.60530967e-02f, -2.80732334e-01f, 1.91984564e-01f, 8.11080169e-03f, -1.78511083e-01f, 1.99652165e-01f, 4.55002077e-02f, 5.58518656e-02f, -8.26074556e-02f, -1.27319843e-01f,
  1.67346443e-03f, 1.66040531e-03f, 1.10606924e-01f, 1.75699249e-01f, -1.63600072e-01f, -1.41240403e-01f, 1.34716472e-02f, -6.36248440e-02f, 3.69078703e-02f, 5.74257448e-02f,
  -1.94763690e-01f, 4.63397279e-02f, -9.81383920e-02f, 6.13833927e-02f, 3.12636159e-02f, 1.21473353e-02f, 6.14029542e-02f, -2.65526138e-02f, -5.47254980e-02f, -8.93735364e-02f,
  -1.54444680e-01f, -1.12536579e-01f, -1.77321378e-02f, -1.70398932e-02f, -2.49141548e-02f, 6.66448101e-02f, 1.64733957e-02f, 3.09481304e-02f, -2.99544856e-02f, -7.36305416e-02f,
  6.63300082e-02f, 9.21852589e-02f, 3.41021689e-03f, 7.00427890e-02f, -1.02653923e-02f, -3.13062035e-03f, 6.59447908e-02f, 2.38506589e-02f, 2.74419524e-02f, -9.19776186e-02f,
  8.73532072e-02f, 6.22225106e-02f, 1.94167681e-02f, 5.98737635e-02f, -7.72846490e-02f, 9.82191339e-02f, 6.55517802e-02f, -1.33007765e-02f, -6.06604181e-02f, 1.72863100e-02f,
  -9.96156558e-02f, 1.56815425e-02f, -1.29096270e-01f, 7.22787902e-02f, -8.87434557e-02f, 7.42594823e-02f, 4.82640974e-02f, -3.40099111e-02f, -5.86301051e-02f, -5.67309521e-02f,
  2.82097198e-02f, -3.26591134e-02f, 1.01958551e-01f, 6.77408874e-02f, -7.25432020e-03f, 7.62073472e-02f, -1.59119014e-02f, 1.41568258e-01f, -8.18535779e-03f, -7.10912934e-03f,
  -2.16988221e-01f, -2.59177357e-01f, 3.42470631e-02f, -3.10044959e-02f, -2.24827677e-02f, 1.38504291e-02f, 2.19549369e-02f, -1.53495194e-02f, -5.71863912e-02f, 8.13438743e-02f,
  1.47184422e-02f, 5.20292185e-02f, -1.92951784e-01f, -2.47684997e-02f, -7.91707709e-02f, -5.81538938e-02f, 1.59814153e-02f, -4.29336578e-02f, -3.38699594e-02f, -9.78031382e-02f,
  8.87842849e-02f, -6.84591308e-02f, 2.35681329e-02f, -5.36340997e-02f, 6.70617074e-02f, -8.56722742e-02f, 8.04922804e-02f, 3.54507938e-02f, 2.74510402e-02f, -6.18177354e-02f,
  -1.70113951e-01f, -1.91122621e-01f, -2.80970275e-01f, -9.51332077e-02f, -1.84908032e-01f, -4.26809996e-01f, -3.10374856e-01f, -3.01413387e-01f, 4.42310236e-02f, 8.85619894e-02f,
  3.70405577e-02f, -6.40010610e-02f, 1.38871074e-01f, -6.24483414e-02f, -5.15115112e-02f, 2.46259019e-01f, -2.44429842e-01f, -8.16833824e-02f, 6.25030473e-02f, -2.32433423e-01f,
  -1.11029871e-01f, -5.57762645e-02f, 8.68925243e-04f, -2.03963220e-01f, -1.74581587e-01f, -6.57476336e-02f, 1.61140561e-01f, -1.84067518e-01f, 6.99797869e-02f, -6.28245063e-03f,
  -5.88552095e-02f, -1.99192241e-01f, -1.67018190e-01f, -3.72643210e-02f, -1.90900892e-01f, -1.51009813e-01f, -5.58557082e-03f, -3.67909297e-02f, 1.18686492e-02f, -1.45899296e-01f,
  1.03423670e-01f, -5.22282273e-02f, 4.48069610e-02f, 1.46380374e-02f, -6.83317855e-02f, -5.64057827e-02f, 3.45244706e-02f, -1.40236672e-02f, -6.33401498e-02f, 1.51564823e-02f,
  -3.39988656e-02f, 2.59449817e-02f, -2.10488867e-03f, 5.42861521e-02f, 5.85624315e-02f, -1.26186579e-01f, 1.28921583e-01f, 1.56635627e-01f, -6.10476099e-02f, -1.09661400e-01f,
  2.17297357e-02f, -6.91124722e-02f, 7.10294321e-02f, -2.86953487e-02f, -2.35989448e-02f, -5.93331642e-02f, 3.99092771e-02f, 7.13066459e-02f, 3.87471095e-02f, -5.34166209e-02f,
  6.99384362e-02f, -7.43850693e-02f, -8.36957693e-02f, 1.75533742e-02f, 6.73494041e-02f, -3.37310582e-02f, 7.80104771e-02f, -5.80893643e-02f, -4.57247496e-02f, -6.98993132e-02f,
  -8.63105133e-02f, -5.23489602e-02f, -4.14963719e-03f, -9.36374441e-02f, -1.01799317e-01f, 3.04735750e-02f, -6.31080270e-02f, 6.32190928e-02f, 3.31364125e-02f, -5.37686273e-02f,
  -1.79895341e-01f, -2.74165213e-01f, 1.59891713e-02f, -1.29752055e-01f, 2.99388859e-02f, -1.29807740e-01f, -1.66707747e-02f, -8.25315639e-02f, 6.33215625e-03f, -5.43202385e-02f,
  7.11194500e-02f, -5.87298069e-03f, -2.55960729e-02f, 9.30993631e-03f, 1.37702256e-01f, -1.03935590e-02f, 5.78595810e-02f, 9.60209314e-03f, -2.17106249e-02f, -1.83659494e-02f,
  -4.05715555e-02f, -4.22220118e-02f, 1.02022693e-01f, -3.37567441e-02f, -4.20129038e-02f, 3.67123708e-02f, -8.69129375e-02f, 2.41067652e-02f, 8.91029427e-04f, 4.05664146e-02f,
  9.91782323e-02f, 2.88512677e-01f, 2.05272630e-01f, 3.46278489e-01f, -1.17632687e-01f, -2.57574022e-01f, -3.14668864e-01f, 1.37097046e-01f, -1.15788385e-01f, -6.51101172e-02f,
  -6.40329942e-02f, 2.99445719e-01f, -3.08128029e-01f, 2.76803672e-01f, -5.34695806e-03f, -1.73017725e-01f, 1.00846767e-01f, 1.82711985e-02f, -4.26555760e-02f, 1.18312977e-01f,
  2.20772818e-01f, 1.11959115e-01f, 6.90242499e-02f, 8.36308226e-02f, -2.13440377e-02f, 2.51036912e-01f, 2.13176742e-01f, 2.48296764e-02f, 4.52081919e-01f, 1.02105051e-01f,
  -4.28343453e-02f, -3.55753629e-03f, 5.06532118e-02f, 3.74259241e-02f, -5.26157394e-02f, 7.28185941e-03f, 6.17905147e-02f, 1.00467063e-01f, 5.07009961e-02f, 1.37717858e-01f,
  -9.69572738e-02f, 9.11485776e-02f, -7.18791224e-03f, 5.85123524e-03f, -1.30599225e-02f, 3.24610099e-02f, 4.55738492e-02f, 2.88183168e-02f, 8.09635594e-02f, 6.69999272e-02f,
  2.00837906e-02f, -2.60889847e-02f, 7.46205747e-02f, 3.43220830e-02f, 1.23133222e-02f, -3.84415276e-02f, -7.25654885e-02f, 4.29399684e-02f, -2.02703085e-02f, 6.59607947e-02f,
  -2.84701418e-02f, -2.50567663e-02f, -1.36651928e-02f, 8.97509530e-02f, 7.09400102e-02f, -7.02311518e-03f, 8.09609964e-02f, -1.13173626e-01f, -7.39388317e-02f, 4.33064848e-02f,
  7.31695490e-03f, 7.81521648e-02f, -1.26306489e-02f, -8.14196616e-02f, 2.15466414e-02f, 2.99994666e-02f, 1.05483783e-02f, -7.94695541e-02f, -1.64830107e-02f, 1.04518563e-01f,
  -1.32634938e-02f, -3.51893455e-02f, 1.14658520e-01f, -7.86179155e-02f, 2.41201986e-02f, -7.24518076e-02f, -4.68531325e-02f, 1.54866185e-03f, -2.19181161e-02f, -1.10826336e-01f,
  6.92642257e-02f, 1.94637164e-01f, -5.42438449e-03f, -5.47876395e-02f, 2.27605831e-02f, 4.84427512e-02f, 3.98639850e-02f, 9.36299041e-02f, 2.78586783e-02f, 6.23928159e-02f,
  9.13987830e-02f, 3.39434370e-02f, -4.20920737e-02f, 3.84401940e-02f, -6.25190325e-03f, -4.14035805e-02f, -2.06757765e-02f, 5.38483635e-03f, 2.17790246e-01f, 5.52179776e-02f,
  1.15728907e-01f, -1.69382349e-01f, 3.18139829e-02f, -3.47694643e-02f, 1.45791136e-02f, -1.02674209e-01f, 1.03841163e-01f, 1.10613026e-01f, -3.56949233e-02f, 7.16618374e-02f,
  3.74323055e-02f, -9.69249159e-02f, -2.65837491e-01f, -7.88597390e-02f, -9.91304368e-02f, -5.21233201e-01f, -4.78313446e-01f, -1.65587559e-01f, 8.74458551e-02f, 3.17870043e-02f,
  -9.18022320e-02f, 2.64207870e-01f, -5.02085425e-02f, -2.55650580e-01f, -3.84425335e-02f, 2.04281405e-01f, -4.27811950e-01f, -2.95453548e-01f, 7.92131126e-02f, -2.49151111e-01f,
  8.41676518e-02f, -2.58578151e-01f, -2.89141774e-01f, -6.95153475e-02f, -2.76445061e-01f, -7.29239583e-02f, 2.25649908e-01f, -1.31344050e-01f, -9.74825770e-02f, -6.74035028e-02f,
  -1.18399560e-01f, 1.34606823e-01f, 1.84969772e-02f, -5.21735214e-02f, -1.48898616e-01f, -2.01486468e-01f, -1.72910288e-01f, 7.55603462e-02f, 6.62584603e-02f, -3.63236777e-02f,
  2.17592213e-02f, 8.65372717e-02f, 6.56837896e-02f, -6.91867713e-03f, -1.29066020e-01f, 7.79749677e-02f, 3.62349041e-02f, 3.01869623e-02f, 4.21994291e-02f, -4.69194492e-03f,
  -1.50484666e-01f, -1.91677660e-02f, -5.08401319e-02f, 1.35520607e-01f, 7.51329958e-02f, 1.73700508e-02f, 4.21056990e-03f, 9.52440798e-02f, 5.35027571e-02f, 6.30310327e-02f,
  -4.60277498e-02f, -1.51731059e-01f, -1.09647699e-01f, 1.13053937e-02f, -6.10450581e-02f, -2.66296789e-02f, -1.68664366e-01f, -4.93515208e-02f, 1.98205877e-02f, -1.33032724e-01f,
  4.07112539e-02f, 1.30589409e-02f, -4.30358015e-02f, 5.39422175e-03f, -1.43115059e-01f, 9.28094387e-02f, -8.20560902e-02f, 2.19944809e-02f, -1.32825017e-01f, -3.04202549e-02f,
  1.07426144e-01f, -3.69419716e-03f, 8.03320706e-02f, -6.49175793e-02f, -1.19291335e-01f, 6.84542879e-02f, 1.86827853e-02f, -4.12087813e-02f, -5.75784221e-02f, 2.93812677e-02f,
  1.49417948e-02f, 8.19920599e-02f, 1.42912893e-02f, 4.07288224e-02f, 6.58916682e-02f, -7.71378446e-03f, -8.90448969e-03f, -8.22592378e-02f, 8.78363103e-02f, -6.21306151e-02f,
  -1.26269713e-01f, -8.17431211e-02f, 3.27813365e-02f, 1.39798626e-01f, -2.97384821e-02f, -8.06047171e-02f, 4.18601558e-03f, 4.25410047e-02f, 3.88648845e-02f, 1.56746209e-02f,
  2.38708239e-02f, 5.45830801e-02f, 1.23605013e-01f, -1.39805852e-02f, 2.34371796e-02f, 3.19776833e-02f, 6.40116856e-02f, -2.03647316e-02f, -1.34721486e-04f, 2.22158991e-02f,
  2.49939203e-01f, 3.76924872e-01f, 1.19143285e-01f, 2.12847054e-01f, -1.64299831e-01f, -2.25520432e-01f, -2.90264875e-01f, -4.77186404e-02f, 3.74989331e-01f, 2.11929053e-01f,
  -3.31369251e-01f, 6.08952761e-01f, -8.68049711e-02f, 5.31132594e-02f, -3.82792294e-01f, -2.51097441e-01f, -1.46478415e-01f, 1.42522216e-01f, -4.06872369e-02f, 9.02128220e-02f,
  -1.26199409e-01f, -4.77799624e-01f, -2.90526927e-01f, -1.20829277e-01f, 1.14977337e-01f, 1.44150034e-01f, -3.30020487e-01f, -1.02788977e-01f, 1.31429240e-01f, -1.58467889e-01f,
  -1.63510084e-01f, -5.57016693e-02f, 5.34445979e-02f, -1.86764030e-03f, -1.03040397e-01f, 2.08681524e-02f, 3.38621885e-02f, -1.22888990e-01f, -8.24555829e-02f, 8.69058669e-02f,
  1.86312750e-01f, -1.96724795e-02f, -2.28366815e-02f, -1.52394762e-02f, 8.69824067e-02f, 1.26800090e-01f, 9.66392681e-02f, -1.99888237e-02f, 6.03751428e-02f, 3.50715369e-02f,
  1.44291848e-01f, 1.22034676e-01f, -4.92446944e-02f, -8.29466805e-02f, -7.81972110e-02f, -1.82106532e-02f, -5.90196950e-03f, -1.47802406e-03f, 1.08522415e-01f, -5.65856993e-02f,
  -6.82914481e-02f, -2.16641352e-02f, -6.78034723e-02f, 4.82779220e-02f, -7.40462467e-02f, -3.56233446e-03f, 5.83924316e-02f, -1.00253887e-01f, 5.58518022e-02f, -6.50447980e-02f,
  -7.82073848e-03f, -7.95852318e-02f, 1.34713380e-02f, 1.22856423e-01f, -2.82130446e-02f, 2.05695853e-02f, 5.47679923e-02f, 2.47476511e-02f, 3.20455097e-02f, 3.68020236e-02f,
  -8.61040652e-02f, -1.41471997e-02f, 8.31442177e-02f, -4.72216047e-02f, -1.41453547e-02f, 5.14102094e-02f, 5.73454872e-02f, 2.03173846e-01f, -1.97708029e-02f, -7.61528835e-02f,
  -2.92774290e-02f, -1.55449420e-01f, -6.93078339e-03f, -1.20183523e-03f, 9.23673734e-02f, 2.11314280e-02f, -2.12394800e-02f, 3.55460607e-02f, 1.46386456e-02f, -9.09045711e-02f,
  8.01871791e-02f, 9.00164060e-03f, -3.64084356e-02f, -1.01079524e-01f, -2.27449629e-02f, 4.32345457e-02f, -1.24547314e-02f, -3.65613326e-02f, 1.53978635e-02f, -2.15220395e-02f,
  1.72623824e-02f, 1.15965143e-01f, 1.89311787e-01f, -1.85886361e-02f, 2.17306390e-02f, 8.49957615e-02f, -9.88823920e-03f, 1.81883331e-02f, -8.22210982e-02f, -5.40904440e-02f,
  2.81558242e-02f, -3.17395449e-01f, -3.78378704e-02f, -2.22481236e-01f, -1.70766160e-01f, -1.22134678e-01f, 1.11143766e-02f, -3.67053330e-01f, -3.95314634e-01f, -2.05758944e-01f,
  -1.72284722e-01f, -4.13718596e-02f, 2.88290173e-01f, -2.46573836e-01f, 2.70379633e-01f, 2.19018489e-01f, -2.88761139e-01f, -6.21402776e-03f, 1.67643465e-02f, -7.32126236e-02f,
  -9.38388407e-02f, -9.97583847e-04f, 1.07229806e-01f, -1.42708957e-01f, -1.77270353e-01f, -1.41065577e-02f, -1.00965863e-02f, 3.78036909e-02f, -2.25446224e-01f, -3.24584693e-02f,
  1.05739407e-01f, 1.40661821e-02f, -3.99739780e-02f, -1.23427585e-02f, 1.93256699e-02f, 5.64690381e-02f, 1.18810870e-01f, 6.70782849e-02f, 5.46570756e-02f, 2.69597652e-03f,
  -3.41047794e-02f, -5.37296711e-03f, -6.23231009e-02f, 3.58871035e-02f, -1.30121574e-01f, -7.86189288e-02f, -3.93027738e-02f, 2.60502063e-02f, 1.09089492e-02f, 9.66354012e-02f,
  -3.48896012e-02f, -5.04712127e-02f, 3.15769203e-02f, 3.70877087e-02f, -4.60935123e-02f, 2.97513232e-03f, 6.22462519e-02f, 5.18654548e-02f, 1.47604905e-02f, -5.00732139e-02f,
  -9.58038643e-02f, -2.76439497e-03f, 2.99073402e-02f, -1.03798341e-02f, -9.02036652e-02f, -4.94843833e-02f, -4.68579791e-02f, 4.98340174e-04f, -6.94155172e-02f, 1.75830517e-02f,
  -5.67198135e-02f, -2.92595942e-02f, 1.43583953e-01f, 9.33878496e-03f, -2.04087067e-02f, 1.27682565e-02f, 1.54387921e-01f, -1.05656646e-01f, -4.41805050e-02f, 1.33353561e-01f,
  1.14270844e-01f, -8.29221308e-02f, -7.29502961e-02f, 9.39818248e-02f, 3.43746357e-02f, 1.18624754e-01f, -7.29481280e-02f, 3.71808633e-02f, -3.51142660e-02f, 1.56862885e-01f,
  4.71472628e-02f, -1.54528916e-01f, 5.37316725e-02f, 3.06671578e-02f, 8.25011805e-02f, 7.67631531e-02f, 9.91243348e-02f, -6.39041662e-02f, -1.00310653e-01f, -3.00274999e-03f,
  -9.95206684e-02f, 7.47396201e-02f, -7.88117722e-02f, 5.89740649e-03f, -2.57292390e-02f, -1.58198327e-01f, 5.98218404e-02f, -6.29394501e-02f, -6.12896681e-02f, -1.60330191e-01f,
  5.47013618e-02f, 3.41698453e-02f, -5.39243929e-02f, 4.84474748e-02f, -1.18078254e-02f, 2.65797805e-02f, -3.16827074e-02f, -3.26017179e-02f, -1.20119743e-01f, -1.05519034e-01f,
  1.63610175e-01f, -3.79240692e-01f, -6.49013417e-03f, 3.32736939e-01f, 1.96166798e-01f, -1.66853219e-01f, -9.91836786e-02f, 1.38396680e-01f, 3.09155524e-01f, -2.34768465e-01f,
  9.51223224e-02f, -3.54353696e-01f, -3.58321309e-01f, 1.31211817e-01f, -9.77433100e-02f, -1.28058165e-01f, -1.19641982e-01f, -4.35171314e-02f, -2.75808782e-03f, 3.21395099e-02f,
  1.71120778e-01f, 8.30396861e-02f, -7.59496391e-02f, 4.21914551e-03f, 9.79704782e-02f, 1.03996910e-01f, 8.13006759e-02f, -1.59462541e-01f, 5.31597659e-02f, 1.01805246e-02f,
  1.02877608e-02f, 1.02651872e-01f, 2.26896461e-02f, -8.67909417e-02f, -6.25657737e-02f, -3.17931660e-02f, 2.75492370e-02f, -6.31636009e-02f, 1.07299745e-01f, -6.10630512e-02f,
  3.19464654e-02f, -3.31199653e-02f, 1.13419846e-01f, -3.63823101e-02f, -1.03931520e-02f, -2.72908751e-02f, 9.64925364e-02f, 9.49011520e-02f, 1.37420483e-02f, 2.68608760e-02f,
  6.89854994e-02f, -1.88329816e-02f, 5.41761592e-02f, -1.89794842e-02f, 2.12202463e-02f, 9.71674100e-02f, 2.42412761e-02f, -6.03841282e-02f, 7.26289698e-04f, -9.74169560e-03f,
  -4.64239419e-02f, -1.15139008e-01f, -4.14384976e-02f, 8.51050392e-02f, -3.64407375e-02f, 6.44983351e-02f, -4.05240804e-02f, 6.09135740e-02f, -8.25923495e-03f, -4.66420576e-02f,
  -7.46441307e-03f, 1.64643873e-03f, 1.13652557e-01f, 2.23697089e-02f, -8.36990699e-02f, 1.34008244e-01f, 5.46531677e-02f, 6.94268420e-02f, 4.55561727e-02f, -1.59148071e-02f,
  1.79935340e-02f, 3.64299975e-02f, -4.11962867e-02f, 1.20876044e-01f, 4.39718254e-02f, -9.91843492e-02f, 6.43620640e-02f, 3.29955965e-02f, 1.10131264e-01f, -4.03657891e-02f,
  -3.98873001e-01f, -1.65317357e-01f, 1.85121654e-03f, -2.60481946e-02f, 7.61364177e-02f, 6.52584806e-02f, -7.12121204e-02f, -1.26286689e-02f, -2.64184356e-01f, 5.24296537e-02f,
  -6.32084385e-02f, 2.33567171e-02f, -8.06185510e-03f, 3.50956582e-02f, -5.63369133e-03f, -1.42135963e-01f, 9.30327922e-02f, -5.18565532e-03f, -2.04403652e-03f, -5.39950794e-03f,
  -4.99797193e-03f, -5.78874126e-02f, 5.47137335e-02f, 3.75215337e-02f, 9.20358822e-02f, 5.46015091e-02f, 7.61096254e-02f, -1.15285115e-02f, 4.24458925e-03f, 2.07633786e-02f,
  2.94620395e-01f, -4.40411419e-01f, -1.49921462e-01f, 6.36942014e-02f, 1.49465144e-01f, 1.82627782e-01f, -9.63065550e-02f, -1.38364211e-01f, -1.31570101e-01f, -2.03927055e-01f,
  1.67739257e-01f, 4.08031717e-02f, -1.74821720e-01f, 1.01544149e-01f, 2.30341136e-01f, -2.23438486e-01f, 1.19933158e-01f, 1.94856599e-01f, -1.00445732e-01f, -8.25978145e-02f,
  -3.08650900e-02f, 2.87692994e-01f, 3.66057605e-02f, 1.40272558e-01f, 1.24361157e-01f, -1.13972865e-01f, -3.11901104e-02f, -2.52377540e-02f, 1.51507229e-01f, 2.62496799e-01f,
  1.12371705e-01f, -1.17878653e-01f, 5.15693948e-02f, 7.92850256e-02f, -1.24448784e-01f, -1.31030336e-01f, -1.26516772e-02f, 6.15658239e-02f, 3.65526490e-02f, -5.79974502e-02f,
  -8.53684321e-02f, 7.13096038e-02f, 8.54379386e-02f, -2.02112552e-02f, 4.93214019e-02f, 1.19970189e-02f, 5.81815355e-02f, -3.16735059e-02f, -7.28753507e-02f, 4.25809063e-02f,
  -6.03749529e-02f, -1.57571808e-02f, 7.73902386e-02f, -3.31691056e-02f, -2.62936503e-02f, -8.97810757e-02f, -7.02621490e-02f, -1.26773948e-02f, -2.53824815e-02f, 1.94035694e-02f,
  -3.62520218e-02f, 4.57539037e-02f, -6.22999482e-02f, 4.17725481e-02f, 3.14066634e-02f, 1.91288330e-02f, -2.58380808e-02f, -6.17563017e-02f, 4.24324200e-02f, -9.35276598e-02f,
  4.63232361e-02f, 9.85250026e-02f, -1.46643436e-02f, 7.22401217e-02f, 4.04670648e-02f, 1.27145350e-02f, 4.74362969e-02f, 5.33295497e-02f, -4.73248363e-02f, -4.31065597e-02f,
  4.34208363e-02f, 4.69561815e-02f, 8.19652304e-02f, 2.33388059e-02f, 8.89177173e-02f, 2.38704123e-02f, 4.47165966e-02f, -4.25813608e-02f, 4.17609476e-02f, 3.14137600e-02f,
  -7.66638443e-02f, -4.03519452e-01f, -6.36169389e-02f, 6.59227818e-02f, 3.23328003e-02f, -1.05021164e-01f, -4.13327217e-02f, -1.71960369e-02f, -5.51300962e-03f, -1.16516367e-01f,
  -5.71841747e-03f, -1.15806073e-01f, -6.45385981e-02f, 1.16324492e-01f, 1.77799359e-01f, -5.22136204e-02f, -5.04852757e-02f, -4.06260341e-02f, 3.83674838e-02f, -5.03434204e-02f,
  -5.94758317e-02f, -1.40933648e-01f, 3.65973040e-02f, -1.00780375e-01f, -5.85511513e-02f, -1.11279272e-01f, -6.57475516e-02f, 3.16002220e-02f, -5.53779975e-02f, -2.61533614e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 20)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 20;
const float L0_fan_Bp_bar_data[] = {
  -7.27408826e-02f, -1.00322925e-01f, 8.18942785e-02f, 4.85050008e-02f, 9.55553949e-02f, 1.52980760e-01f, 1.14504807e-01f, -4.78993952e-02f, 6.26894385e-02f, 4.76335511e-02f,
  1.56683758e-01f, 3.83019298e-02f, 1.57238528e-01f, -8.94631892e-02f, 1.95597991e-01f, -1.48150340e-01f, 2.41419181e-01f, -2.64803432e-02f, 1.06484011e-01f, 1.07546188e-01f
};

// L1_fan_Wp (Shape: 6 x 32)
const int L1_fan_Wp_rows = 6;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  1.32735670e-01f, 2.70759761e-01f, -2.46970784e-02f, 3.58133763e-02f, 1.94286779e-01f, -1.25368595e-01f, -3.35641168e-02f, 4.52494656e-04f, 5.34127541e-02f, -1.67321414e-01f,
  3.02901175e-02f, -1.22474983e-01f, -1.74256667e-01f, -1.17021658e-01f, 2.53150463e-01f, 1.86669648e-01f, 1.64752141e-01f, 4.58706655e-02f, 2.09182099e-01f, 2.83662286e-02f,
  -1.61749631e-01f, 2.12363064e-01f, 7.71589251e-03f, -1.60715450e-02f, -7.91873336e-02f, -1.10227242e-01f, -1.10343985e-01f, -2.17475012e-01f, 6.43180162e-02f, -1.65963128e-01f,
  1.06258243e-01f, 1.00914568e-01f, -9.69912484e-03f, 7.04393908e-03f, -1.25027403e-01f, -4.55956049e-02f, 1.27394497e-01f, -4.20559287e-01f, 2.20295325e-01f, 7.72216618e-02f,
  -1.13381006e-01f, 2.00296834e-01f, 3.37249994e-01f, -2.28468314e-01f, -3.44018906e-01f, 2.22950622e-01f, 2.32718527e-01f, 2.37890616e-01f, 1.75415710e-01f, 1.28393203e-01f,
  -4.71532047e-02f, -1.36244029e-01f, -2.94443388e-02f, 1.83696464e-01f, 2.16798961e-01f, -3.08046490e-01f, 1.15175145e-02f, -3.15167159e-01f, 2.92145967e-01f, -2.33868629e-01f,
  1.98273659e-01f, -3.36174369e-01f, 3.81343514e-01f, 1.45336762e-02f, -1.74576566e-01f, 6.62267134e-02f, 8.36557299e-02f, 4.43218136e-03f, -1.30962148e-01f, 2.90910333e-01f,
  -1.46353409e-01f, -2.46985093e-01f, -1.74621090e-01f, 1.67283863e-01f, -2.71835569e-02f, -2.64911652e-01f, 1.69768229e-01f, -6.21734299e-02f, 4.17781115e-01f, 5.81033006e-02f,
  3.78841519e-01f, -8.34927037e-02f, -6.18202053e-03f, -1.63934454e-01f, 1.80539578e-01f, 6.47350252e-02f, 2.24173397e-01f, 6.89543262e-02f, 4.41965818e-01f, 1.88677892e-01f,
  -1.84588253e-01f, -1.62840664e-01f, -2.85078436e-01f, 2.96014883e-02f, -1.20236687e-01f, -1.58003807e-01f, -5.24428263e-02f, -1.11684479e-01f, 1.19266853e-01f, -1.63545847e-01f,
  -1.14662640e-01f, -1.65237635e-01f, -1.90059319e-01f, 2.55368441e-01f, -1.83280334e-01f, -9.57503244e-02f, 3.17494497e-02f, -2.40507439e-01f, 6.81997975e-03f, -2.45548382e-01f,
  2.66376495e-01f, 4.90048751e-02f, 5.43012172e-02f, -9.05476362e-02f, 7.55086392e-02f, -1.84064358e-01f, -1.29097313e-01f, -6.62576407e-02f, 1.28358036e-01f, -1.69473961e-01f,
  9.98437330e-02f, 1.93706185e-01f, 3.07021141e-01f, 1.98482543e-01f, 1.33902848e-01f, -1.93512022e-01f, 7.74915069e-02f, 1.54427171e-01f, 1.00342520e-01f, -8.36082697e-02f,
  -8.67407396e-02f, -1.46794036e-01f, 1.20555356e-01f, -1.02617763e-01f, -2.81294048e-01f, 1.18097290e-01f, 1.93457808e-02f, -6.74692988e-02f, -2.59727776e-01f, 1.23475958e-02f,
  -3.52075808e-02f, 2.92391747e-01f, -1.38031729e-02f, 2.12300435e-01f, -1.36719570e-01f, 1.18834324e-01f, 4.47393298e-01f, 2.36798033e-01f, -1.08699687e-02f, -4.87969592e-02f,
  2.07154118e-02f, 2.02486947e-01f, 4.44388837e-02f, -5.73802926e-02f, 2.13153571e-01f, -5.59488311e-02f, -2.81515330e-01f, -2.53121629e-02f, -1.37477845e-01f, 2.31330954e-02f,
  -2.21747369e-01f, 9.07585211e-03f, -6.00549541e-02f, 1.24150962e-01f, -1.17517874e-01f, 7.49858916e-02f, 1.73107848e-01f, -3.26040871e-02f, 2.20770955e-01f, -7.49891847e-02f,
  1.77426606e-01f, -7.03973621e-02f, -2.22236797e-01f, 3.34854960e-01f, 2.00313434e-01f, 2.52929002e-01f, 1.86569631e-01f, 1.47123381e-01f, -3.15929264e-01f, -2.43371539e-02f,
  9.79313627e-02f, 1.64096862e-01f, 2.34032080e-01f, -1.39451548e-01f, 2.46772543e-01f, -2.42786133e-03f, -2.72638388e-02f, 2.77328014e-01f, -1.83499187e-01f, -3.15762311e-01f,
  3.36890936e-01f, -7.32364580e-02f
};

// L1_fan_Wp_bar (Shape: 20 x 32)
const int L1_fan_Wp_bar_rows = 20;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  -6.71477690e-02f, 9.17527452e-02f, 1.62248492e-01f, 1.00155167e-01f, -5.59770912e-02f, -8.07692390e-03f, 1.68100834e-01f, 4.06904668e-01f, 1.34173974e-01f, 1.87894419e-01f,
  -4.16619554e-02f, -1.42018393e-01f, -3.30827683e-01f, 4.63646919e-01f, 5.18669747e-02f, 3.24894004e-02f, -2.57830620e-01f, 2.27472216e-01f, 2.48639751e-02f, 1.92977712e-02f,
  -4.54547396e-03f, -2.34694824e-01f, -1.14203416e-01f, -2.08193138e-02f, -2.89770246e-01f, -2.17414975e-01f, 4.15685087e-01f, 1.17774136e-01f, 2.88697004e-01f, -2.89583355e-01f,
  3.72723520e-01f, 1.93687305e-01f, -2.84182411e-02f, 4.63995725e-01f, 2.99038351e-01f, 2.16427892e-01f, 1.16831228e-01f, -9.91046336e-03f, 5.06686449e-01f, 1.48959100e-01f,
  4.10763055e-01f, 1.68147217e-02f, 2.29771897e-01f, 1.21891186e-01f, -3.74496371e-01f, -1.65733159e-01f, -2.61294395e-01f, -4.69142348e-02f, -2.90894210e-01f, 1.03075922e-01f,
  1.75448924e-01f, -3.22770804e-01f, -3.29017252e-01f, -2.97938764e-01f, 2.92637229e-01f, 1.62457272e-01f, -3.11392933e-01f, -2.42934227e-01f, 1.48650602e-01f, -2.75520012e-02f,
  3.87719423e-01f, -1.73332766e-01f, 5.28953195e-01f, 1.13684321e-02f, 2.70154387e-01f, 2.89995760e-01f, 4.28073138e-01f, 3.86608839e-01f, 1.14111789e-01f, 3.14111523e-02f,
  -4.26489152e-02f, 1.36717543e-01f, 3.10773045e-01f, -1.94742858e-01f, 1.76459536e-01f, -4.71179366e-01f, -3.44732881e-01f, 2.05128580e-01f, 4.03144807e-01f, 2.07825437e-01f,
  -1.55761406e-01f, 1.91077039e-01f, 9.61201712e-02f, 6.54317290e-02f, -4.06542510e-01f, -2.93083280e-01f, 1.20729297e-01f, -1.88640263e-02f, -4.21745740e-02f, -9.86155719e-02f,
  3.83055568e-01f, -2.30866894e-02f, 1.98104814e-01f, -1.94846585e-01f, 7.00002760e-02f, -1.86710712e-02f, 3.09113145e-01f, -1.31838575e-01f, 3.99709940e-02f, 2.47530207e-01f,
  2.04864778e-02f, 3.12431931e-01f, -2.32271135e-01f, -1.17541194e-01f, 2.56881624e-01f, 9.54954475e-02f, -2.87623733e-01f, 2.44955659e-01f, -2.07860664e-01f, 2.07065269e-01f,
  -6.62683882e-03f, -2.90329248e-01f, -2.10603490e-01f, 3.53350133e-01f, 1.01851903e-01f, 3.42278779e-01f, -2.04828143e-01f, -8.63839965e-03f, -7.75951296e-02f, 4.71266925e-01f,
  -2.12383553e-01f, -2.16763511e-01f, 2.77545810e-01f, -3.60065661e-02f, -1.91995606e-01f, 1.68544799e-01f, -3.51393074e-01f, -8.64470378e-02f, -1.79585889e-01f, -1.58654377e-01f,
  8.09977949e-02f, -1.43708121e-02f, -2.84340046e-02f, -1.52488649e-01f, -2.14722514e-01f, 1.45090595e-01f, 4.61977497e-02f, 2.67898738e-02f, 1.06107490e-02f, -8.54276586e-03f,
  2.83610195e-01f, -1.70966461e-01f, 3.38780463e-01f, 2.17310160e-01f, 2.12763622e-02f, -1.20811254e-01f, 2.12834045e-01f, -5.20374849e-02f, 7.55965859e-02f, 3.56723845e-01f,
  4.43437129e-01f, -3.16100091e-01f, -7.17280386e-03f, 3.18890959e-01f, -1.31691862e-02f, 4.92843211e-01f, 6.13188464e-03f, 1.43509135e-01f, 3.01261693e-02f, -3.70043546e-01f,
  3.56150985e-01f, 8.91952664e-02f, 3.34774196e-01f, 3.08916539e-01f, -2.26043630e-02f, -3.96364927e-02f, 1.13385312e-01f, 1.91111520e-01f, -1.88692614e-01f, 3.81466478e-01f,
  -8.17181915e-02f, 2.95602947e-01f, 3.16001296e-01f, -1.13708064e-01f, -2.99829364e-01f, -5.65736629e-02f, -1.74908072e-01f, -1.49743617e-01f, -3.78865957e-01f, -7.64293876e-03f,
  1.50850639e-01f, -2.99439691e-02f, -1.80100858e-01f, 4.44974214e-01f, 3.72960307e-02f, 2.15788022e-01f, 3.68666083e-01f, 3.66993934e-01f, 6.43869460e-01f, 2.11020820e-02f,
  -1.43866569e-01f, -3.59033108e-01f, -9.84958038e-02f, 2.09499806e-01f, 1.25767350e-01f, 3.40216756e-02f, 3.34007949e-01f, -1.03811987e-01f, 1.22379713e-01f, -4.07330953e-02f,
  2.01468647e-01f, -2.40990058e-01f, 1.74598008e-01f, -2.24683642e-01f, 7.51427636e-02f, 1.17098823e-01f, 3.29475373e-01f, 3.17921579e-01f, 2.64874339e-01f, 1.93048909e-01f,
  1.88030839e-01f, -8.16714391e-02f, 1.85370788e-01f, -8.31796974e-02f, 2.04229817e-01f, -3.64087850e-01f, 1.75941125e-01f, -1.77038908e-02f, -1.08576082e-01f, -2.75030702e-01f,
  -2.14320794e-01f, 1.24137253e-01f, 4.24777627e-01f, 3.59736979e-01f, -1.26831131e-02f, 3.62209558e-01f, 1.38357267e-01f, 4.64819610e-01f, 2.95743853e-01f, 2.66588535e-02f,
  3.78767066e-02f, -1.50183171e-01f, 1.28878504e-01f, -2.10470915e-01f, -3.08219045e-02f, -2.82037437e-01f, -2.31423616e-01f, -2.64403254e-01f, 1.65383339e-01f, 1.58324748e-01f,
  3.34171236e-01f, 1.12258539e-01f, -1.85201287e-01f, -3.70807409e-01f, 2.69227400e-02f, -9.97512718e-04f, 3.00163716e-01f, -1.66590258e-01f, -2.56273150e-02f, -1.63104311e-01f,
  -1.68873206e-01f, -1.31764203e-01f, -8.22600275e-02f, -1.93151385e-01f, 2.67995924e-01f, -8.90718624e-02f, 4.98603672e-01f, 8.02355483e-02f, 2.67125636e-01f, 4.74224627e-01f,
  1.08677059e-01f, 1.49518788e-01f, -3.11668348e-02f, 2.51934584e-02f, -3.75972688e-01f, 5.15814424e-01f, 3.28709990e-01f, -5.49876802e-02f, -3.45011801e-02f, 4.31966335e-02f,
  4.98327017e-02f, 3.90172121e-03f, 6.05906248e-01f, 1.91550046e-01f, -4.06344384e-01f, -6.16759136e-02f, 1.44968629e-01f, 3.22046578e-01f, 4.56808060e-02f, 4.96651046e-02f,
  2.52632886e-01f, -1.90729335e-01f, 3.36618155e-01f, 1.93113923e-01f, 4.25468862e-01f, -2.82614082e-01f, -1.18615068e-01f, -4.53878760e-01f, 1.87188745e-01f, 1.53409779e-01f,
  1.60413578e-01f, 1.91717688e-03f, 3.04865241e-01f, 8.88666585e-02f, -7.79080763e-02f, 1.12904571e-01f, -2.53924370e-01f, 3.28316361e-01f, 9.28877443e-02f, -3.50230336e-01f,
  -1.04492337e-01f, 1.51638716e-01f, 5.31404853e-01f, 2.69554228e-01f, 4.61298913e-01f, 1.81865543e-01f, 4.01222818e-02f, -8.31125304e-03f, 1.48546606e-01f, 7.40467012e-02f,
  4.85165924e-01f, -4.70092028e-01f, 1.15468256e-01f, 1.64786413e-01f, 9.15171131e-02f, 1.52130738e-01f, 1.99784562e-01f, -3.97614960e-04f, -2.04108073e-03f, 9.04980749e-02f,
  6.63654432e-02f, -1.69587940e-01f, -4.60684076e-02f, 3.71997923e-01f, 9.46953893e-02f, 8.27376992e-02f, 5.30507006e-02f, 1.64353296e-01f, 3.88540745e-01f, -1.95535761e-03f,
  -2.14043841e-01f, -1.17214546e-01f, -2.91537672e-01f, 4.50825155e-01f, 2.23775923e-01f, 3.54843736e-01f, -1.96441352e-01f, 3.63308251e-01f, -2.09082663e-02f, 2.51140535e-01f,
  -2.91030705e-01f, -3.33025843e-01f, 2.71542192e-01f, -1.23896748e-02f, 7.88674317e-03f, -8.68104771e-02f, 1.15992345e-01f, -1.20718762e-01f, -3.29707533e-01f, -1.47300050e-01f,
  2.02400625e-01f, 2.00741321e-01f, 1.95476472e-01f, 4.38784957e-02f, 2.06471831e-01f, 2.05536082e-01f, 2.14885384e-01f, 3.91184896e-01f, -2.40954548e-01f, -1.73818022e-01f,
  -2.19644248e-01f, -2.59787232e-01f, -5.01597762e-01f, 3.57077330e-01f, -5.28751761e-02f, 2.51241714e-01f, -2.01087043e-01f, -2.12407723e-01f, -6.48630708e-02f, 1.37444839e-01f,
  3.70452583e-01f, 1.57782331e-01f, 1.48621216e-01f, -7.21907765e-02f, -3.86079341e-01f, 5.44402301e-01f, 1.82940811e-01f, 6.30410993e-03f, -3.25136706e-02f, -4.15305495e-01f,
  -3.79666299e-01f, 3.80245179e-01f, -2.40602374e-01f, 2.04936042e-01f, 2.27720793e-02f, 1.70722112e-01f, 1.16818855e-02f, -5.58115691e-02f, 1.10066377e-01f, 4.25556935e-02f,
  3.50404799e-01f, -1.79525137e-01f, 8.83299410e-02f, -5.65696359e-01f, -1.25147596e-01f, 2.63571173e-01f, 5.21168858e-02f, 4.79940362e-02f, -4.64018345e-01f, 3.82292002e-01f,
  -2.34804928e-01f, 1.35578766e-01f, 2.24628389e-01f, 5.33560589e-02f, 3.31469625e-01f, -3.93546522e-02f, 1.03745967e-01f, -2.91287154e-01f, -2.33153746e-01f, 6.15355521e-02f,
  4.11623577e-03f, -2.85716414e-01f, -3.62060308e-01f, 2.13506147e-01f, 1.38174832e-01f, 4.53143090e-01f, 2.56051302e-01f, -1.85273767e-01f, 2.43480578e-01f, 2.42358208e-01f,
  2.15955362e-01f, 1.73701048e-01f, -3.61720234e-01f, -6.64889254e-03f, -2.60159280e-02f, 3.50107253e-02f, -1.14826515e-01f, 2.75199205e-01f, -4.02511563e-03f, 1.18127182e-01f,
  -1.92664191e-01f, -2.49494791e-01f, -5.55188023e-02f, 2.46624835e-02f, 8.54451507e-02f, 2.99075153e-02f, 2.27934226e-01f, 1.62968621e-01f, -9.92267653e-02f, 5.53080201e-01f,
  2.78716296e-01f, 3.26385230e-01f, -4.87101153e-02f, 1.75693423e-01f, 1.31031657e-02f, 2.34150365e-01f, -6.41324669e-02f, -1.10117823e-01f, 1.45054400e-01f, 3.35044563e-02f,
  2.19494373e-01f, 1.95465818e-01f, 6.19676039e-02f, -1.93005875e-02f, -3.00032705e-01f, -6.13104440e-02f, -3.05001456e-02f, 4.70684111e-01f, -2.53964979e-02f, -2.87251472e-01f,
  2.04527870e-01f, -1.68704003e-01f, 1.22671977e-01f, 2.96560198e-01f, 3.44076723e-01f, -1.46280274e-01f, -1.49710223e-01f, 9.91672054e-02f, 2.48337299e-01f, 3.14083606e-01f,
  3.45316887e-01f, -7.30271712e-02f, 2.72688836e-01f, 2.33661011e-01f, 2.02328846e-01f, 3.71446222e-01f, 3.00021470e-01f, 1.60877764e-01f, 5.05419299e-02f, -2.45262563e-01f,
  3.46646756e-01f, 8.58675763e-02f, 1.83723062e-01f, 2.69839585e-01f, 1.66957691e-01f, -1.11218162e-01f, -2.35851482e-01f, 5.90801090e-02f, 3.36441994e-01f, -1.66598067e-01f,
  -1.89444020e-01f, -4.74810489e-02f, -4.01645273e-01f, 3.03258568e-01f, 2.59638518e-01f, 3.47915500e-01f, -1.96613044e-01f, 4.19177771e-01f, 1.87948704e-01f, 3.60321701e-01f,
  -4.10107046e-01f, -3.37505132e-01f, 2.65287026e-03f, 1.81462765e-01f, -3.87163833e-02f, -2.59299219e-01f, 2.19309643e-01f, 8.92152786e-02f, 2.18993649e-01f, -2.54804604e-02f,
  1.95980728e-01f, 1.95515677e-01f, -1.32472590e-01f, -2.26281196e-01f, 3.03400517e-01f, 2.42810935e-01f, 9.58334729e-02f, 3.95080924e-01f, -6.74395785e-02f, -3.63375217e-01f,
  -2.70543694e-01f, 1.59280643e-01f, 2.08093345e-01f, 6.65487126e-02f, 8.09711441e-02f, 1.05377577e-01f, -2.65165120e-01f, -1.50126487e-01f, 4.08671737e-01f, -1.27325654e-01f,
  -1.52520075e-01f, 5.05509265e-02f, 3.84757400e-01f, 2.74388731e-01f, 4.67493311e-02f, 2.54325271e-01f, 3.03512573e-01f, 7.96719342e-02f, 3.78855616e-02f, 1.13025241e-01f,
  7.91411996e-02f, 1.19805932e-01f, -2.32274920e-01f, -1.05185486e-01f, 4.49377090e-01f, 3.65915120e-01f, 4.11392808e-01f, 4.24328372e-02f, 3.57288361e-01f, 3.55566591e-01f,
  7.26904050e-02f, -3.90632063e-01f, -2.21398279e-01f, -1.31871104e-01f, 1.85178638e-01f, 5.70187032e-01f, 1.53455362e-01f, -2.61173874e-01f, -4.93442446e-01f, -1.68452561e-01f,
  2.12976888e-01f, -1.46988630e-01f, -4.61790055e-01f, -1.27750382e-01f, 2.09713623e-01f, 1.91007122e-01f, -2.24908158e-01f, 1.37740090e-01f, 3.52085344e-02f, -3.97219323e-02f,
  -1.04692087e-01f, -3.81268173e-01f, -2.09774990e-02f, 8.19982514e-02f, 7.16660023e-02f, -7.28470087e-02f, -7.36965537e-02f, -2.79093593e-01f, 9.53800753e-02f, -7.05273636e-03f,
  5.88101428e-03f, 4.14715856e-01f, -3.45311761e-01f, -1.56669125e-01f, -2.96548039e-01f, 8.72088447e-02f, -2.88456738e-01f, 5.27724102e-02f, 4.15952764e-02f, 1.83535293e-01f,
  -2.75989830e-01f, -7.79531151e-02f, 1.83691770e-01f, -1.99839156e-02f, -6.17350265e-02f, 1.49212196e-01f, 1.44683987e-01f, 2.13488564e-01f, 2.13837415e-01f, 3.82696271e-01f,
  3.32296252e-01f, 4.18689281e-01f, -1.66116670e-01f, 3.28213185e-01f, -6.25300184e-02f, 3.17405194e-01f, 2.01178625e-01f, 7.33266771e-02f, 3.15016389e-01f, 4.17364053e-02f,
  2.39757001e-01f, 5.26250720e-01f, 1.41589135e-01f, 1.12077877e-01f, -9.42093655e-02f, 3.48887175e-01f, 5.55398725e-02f, 1.26328409e-01f, 3.38638239e-02f, -3.82739082e-02f,
  -1.12993918e-01f, 3.35473090e-01f, 7.12237284e-02f, -3.80451471e-01f, -2.06566960e-01f, 1.80546060e-01f, 2.31315084e-02f, 2.55220771e-01f, -4.62903023e-01f, -2.01393798e-01f,
  -1.21496640e-01f, 4.36939359e-01f, -1.34692462e-02f, -2.64541239e-01f, 3.45051378e-01f, 2.41371334e-01f, 2.25161225e-01f, -2.27737740e-01f, -5.42194605e-01f, -3.80138308e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 20)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 20;
const float L1_fan_Bp_bar_data[] = {
  1.26519240e-02f, 5.19888699e-01f, 1.37817815e-01f, 1.24199249e-01f, -1.70234203e-01f, 1.65581569e-01f, 3.02433640e-01f, 6.57636821e-02f, 4.51839685e-01f, 2.87722647e-01f,
  1.10159390e-01f, 3.07755589e-01f, 7.56433979e-02f, 7.73296878e-02f, -6.01810077e-03f, 2.46543400e-02f, 4.01747376e-02f, 5.31340599e-01f, -1.59585197e-02f, 3.63931000e-01f
};

// L2_fan_Wp (Shape: 6 x 32)
const int L2_fan_Wp_rows = 6;
const int L2_fan_Wp_cols = 32;
const float L2_fan_Wp_data[] = {
  -1.30576566e-01f, 3.87189798e-02f, -1.00683317e-01f, 1.32798329e-01f, 2.50564545e-01f, 1.56283095e-01f, -1.28105745e-01f, 3.12520228e-02f, 2.92138010e-01f, 3.92621346e-02f,
  -2.67696112e-01f, -8.24239105e-02f, -2.95692891e-01f, 1.54047266e-01f, 2.00883269e-01f, 1.19115636e-02f, 2.97086328e-01f, -1.26028016e-01f, 4.93299309e-03f, 3.28742087e-01f,
  9.93112847e-02f, 1.53330350e-02f, -1.87257871e-01f, -2.97950536e-01f, 8.59773904e-03f, 2.95085385e-02f, 1.15288645e-02f, -5.42988889e-02f, -4.22709845e-02f, -3.21002528e-02f,
  -6.59671277e-02f, -4.73846532e-02f, -2.80846328e-01f, 1.76391050e-01f, -1.22768275e-01f, -2.07521722e-01f, 1.90344617e-01f, 4.62887324e-02f, 1.17654979e-01f, 5.33685312e-02f,
  2.87807018e-01f, -2.40350869e-02f, -1.40928239e-01f, 3.56360137e-01f, -1.36188060e-01f, 3.74099065e-04f, -1.94503784e-01f, 1.17251486e-01f, 1.20647237e-01f, -1.44539818e-01f,
  1.15257956e-01f, 2.27391407e-01f, -1.64697319e-02f, 1.23191185e-01f, 1.35568559e-01f, -1.37567118e-01f, -1.42917946e-01f, 6.51137605e-02f, 1.09998822e-01f, -1.82442814e-01f,
  -1.30030897e-03f, -1.17383219e-01f, -2.77959630e-02f, 2.81805731e-02f, 1.21621089e-02f, 2.05798417e-01f, -1.13568768e-01f, 1.24352328e-01f, 9.56527982e-03f, -7.23862499e-02f,
  1.31169647e-01f, 2.61458814e-01f, -4.80752140e-02f, 1.14244120e-02f, 5.65008447e-02f, -5.57699502e-02f, 1.79441676e-01f, 1.12443820e-01f, 2.30136171e-01f, 3.56829204e-02f,
  -1.21289147e-02f, 3.16248015e-02f, 4.86893430e-02f, -3.71093228e-02f, -2.15861434e-03f, 1.37519464e-01f, 2.81115949e-01f, -2.04900131e-01f, -7.70065039e-02f, -1.86378747e-01f,
  -2.89718211e-01f, 1.34186214e-02f, 4.05114628e-02f, 8.35022144e-03f, -1.65775523e-01f, -3.18250470e-02f, 1.20985322e-01f, -1.81137845e-02f, -6.55442253e-02f, 1.03887007e-01f,
  -2.49374822e-01f, 4.06059176e-02f, 2.12991223e-01f, 1.44145623e-01f, -3.62523884e-01f, 1.11292481e-01f, 1.34065315e-01f, -3.08712184e-01f, 2.37830415e-01f, -2.43298531e-01f,
  1.01381972e-01f, 5.05507588e-02f, -6.87713400e-02f, 1.77840799e-01f, 2.97242310e-02f, -1.56407449e-02f, -3.50766443e-02f, 9.27656740e-02f, -2.05432437e-02f, -1.34291351e-01f,
  1.16296932e-01f, -7.78194368e-02f, -1.65212780e-01f, 1.83676824e-01f, -2.90079921e-01f, -1.35098577e-01f, -6.12441860e-02f, 9.31690559e-02f, 4.19777818e-02f, -1.66258052e-01f,
  -7.86489695e-02f, -1.54901817e-01f, -9.14542675e-02f, 6.86195865e-02f, -1.62127927e-01f, -1.14861526e-01f, 3.71071957e-02f, 1.56689152e-01f, -1.13121063e-01f, -6.61389530e-02f,
  -9.13875103e-02f, 4.57903594e-02f, -2.08188705e-02f, 8.89279172e-02f, 1.01141341e-01f, 2.43779287e-01f, -1.28788874e-01f, -8.09608996e-02f, 8.10114965e-02f, -1.81757987e-01f,
  -2.39709571e-01f, 1.31500036e-01f, -1.68199111e-02f, 1.76818177e-01f, 9.58699659e-02f, -9.24157444e-03f, 1.79856122e-01f, 3.96699943e-02f, 2.15461124e-02f, -1.90796703e-01f,
  1.48828313e-01f, 1.19753115e-01f, -1.85819268e-01f, 1.73367843e-01f, -1.73358187e-01f, -9.89679098e-02f, 1.66178063e-01f, 1.69563517e-01f, -1.14307567e-01f, -9.44453031e-02f,
  3.98762077e-02f, 2.22369760e-01f, -1.47726581e-01f, -7.98331127e-02f, -2.44559254e-02f, 7.79160485e-02f, -3.23872775e-01f, -2.21105859e-01f, 2.61753589e-01f, 7.57971853e-02f,
  1.32536724e-01f, -1.67128388e-02f, 6.16359301e-02f, 2.78800905e-01f, 2.67823398e-01f, 1.13353349e-01f, -1.33082807e-01f, -2.56783068e-02f, -2.87679639e-02f, 4.95507196e-02f,
  -7.98730478e-02f, -1.47916287e-01f
};

// L2_fan_Wp_bar (Shape: 20 x 32)
const int L2_fan_Wp_bar_rows = 20;
const int L2_fan_Wp_bar_cols = 32;
const float L2_fan_Wp_bar_data[] = {
  2.48006076e-01f, 1.45929456e-01f, -1.84274629e-01f, -3.75876017e-02f, 1.09367840e-01f, 3.12423110e-01f, 5.73344193e-02f, 2.73111939e-01f, 5.06760418e-01f, 2.41519600e-01f,
  -4.18018401e-01f, 5.64322233e-01f, -2.77233630e-01f, 1.66207373e-01f, 3.03847753e-02f, -9.09054428e-02f, 4.54666585e-01f, -3.60179365e-01f, 2.69405544e-01f, 2.67143786e-01f,
  3.09247702e-01f, 2.66620874e-01f, -8.02052915e-02f, 1.40457246e-02f, 1.21347159e-01f, 9.53774378e-02f, 4.48216915e-01f, -2.41033081e-02f, 3.82240713e-01f, 1.37472421e-01f,
  2.19416693e-01f, -1.39953330e-01f, -7.04892650e-02f, 2.44493097e-01f, 1.31894574e-01f, -2.19229292e-02f, 2.42374446e-02f, 7.47467726e-02f, 3.42754573e-01f, 5.68663359e-01f,
  -3.60836893e-01f, 5.46433806e-01f, -4.90364851e-03f, 1.57984480e-01f, 1.86306775e-01f, 2.68465430e-01f, 3.69936645e-01f, -3.56715322e-01f, 9.08430517e-02f, 4.40387465e-02f,
  2.14128301e-01f, 3.29881072e-01f, -1.00149602e-01f, 1.56403944e-01f, 3.23698938e-01f, -1.61751166e-01f, 6.20455034e-02f, -1.54801592e-01f, 1.61847875e-01f, 2.26673931e-01f,
  -3.11480582e-01f, -5.24486899e-02f, -9.89203379e-02f, -5.42525500e-02f, 5.68891764e-01f, 2.29705036e-01f, 4.93198872e-01f, 5.20968020e-01f, 5.07804871e-01f, 3.13856512e-01f,
  -4.00944017e-02f, -9.96356755e-02f, -2.12665766e-01f, -5.06595731e-01f, -3.32028896e-01f, -1.71014935e-01f, 1.52882844e-01f, 5.64784348e-01f, 9.57236141e-02f, 3.30341697e-01f,
  -5.17993510e-01f, 4.91973937e-01f, -1.80799037e-01f, 7.61203617e-02f, 4.24238503e-01f, -1.93208560e-01f, -8.39702114e-02f, 3.41270238e-01f, -1.91728666e-01f, 3.68858308e-01f,
  -1.17702603e-01f, -5.28950617e-03f, 1.78963810e-01f, 5.19825637e-01f, -1.64193347e-01f, 4.31690276e-01f, -2.25212067e-01f, 1.24977164e-01f, 9.49255377e-02f, -4.00567204e-02f,
  -7.33002201e-02f, 2.12021455e-01f, 2.94652551e-01f, 1.02576956e-01f, -1.73958763e-01f, 5.60218915e-02f, 1.30944386e-01f, 4.07164484e-01f, 2.74601489e-01f, 1.79125100e-01f,
  2.51763731e-01f, -1.88754410e-01f, -1.15844950e-01f, -3.89178067e-01f, 3.44083369e-01f, 2.06216902e-01f, -3.68855059e-01f, 1.95626870e-01f, 1.94193676e-01f, 2.27056313e-02f,
  8.21711943e-02f, -1.40425831e-01f, -8.95980671e-02f, 2.54954875e-01f, -3.81274283e-01f, 6.72964975e-02f, -3.36553395e-01f, -2.80243427e-01f, 2.24553898e-01f, 4.19629306e-01f,
  3.54515254e-01f, 5.22315465e-02f, 1.58794373e-01f, 2.82507032e-01f, 3.77856821e-01f, 4.83642191e-01f, -3.04181457e-01f, 6.29262403e-02f, -3.63346815e-01f, -6.46905154e-02f,
  3.47615838e-01f, 4.41920429e-01f, 4.01317269e-01f, -1.30092204e-01f, -1.51958495e-01f, 2.31175631e-01f, -6.47385418e-02f, 3.66286337e-01f, 3.55301023e-01f, 7.61483833e-02f,
  8.79323855e-02f, -2.11665899e-01f, -6.14388883e-01f, -9.15297642e-02f, 1.94614738e-01f, 3.31158370e-01f, -1.42591437e-02f, 3.35662633e-01f, -3.73589635e-01f, 3.73188287e-01f,
  1.98027804e-01f, 3.11963677e-01f, 2.40116678e-02f, 2.52910703e-01f, 3.96504819e-01f, 1.16498865e-01f, 8.35607275e-02f, 2.62282819e-01f, -4.30489749e-01f, -1.63678482e-01f,
  -1.79707676e-01f, 2.03521580e-01f, 3.78665060e-01f, 5.31238496e-01f, 2.39357248e-01f, -4.44405466e-01f, -2.43917495e-01f, -1.37283489e-01f, 5.26198924e-01f, 4.31253344e-01f,
  -2.99706817e-01f, 9.64072868e-02f, 1.62467137e-01f, -2.80816287e-01f, 5.67456305e-01f, -4.29271340e-01f, -1.36481449e-01f, -8.07199534e-03f, -2.04527259e-01f, 1.37877479e-01f,
  -2.71623939e-01f, -2.83738852e-01f, 1.08446777e-01f, 2.48616233e-01f, 2.24059001e-01f, 1.79816354e-02f, -7.27144117e-03f, 2.75395274e-01f, 2.97885716e-01f, 3.92800093e-01f,
  -2.67174333e-01f, -6.05154112e-02f, 1.31170228e-02f, 1.76487435e-02f, 3.24408710e-01f, 2.89988905e-01f, 4.18195814e-01f, 3.61496419e-01f, -2.13157713e-01f, 2.89727181e-01f,
  4.10990752e-02f, 2.68328398e-01f, 1.56189620e-01f, -4.12504002e-02f, 4.25062478e-01f, -6.23449348e-02f, -1.23929858e-01f, -7.04739094e-02f, -7.50171766e-02f, 4.04655159e-01f,
  -1.08945690e-01f, 1.85651019e-01f, -3.25682282e-01f, 3.74143153e-01f, -1.27218157e-01f, -2.69566983e-01f, -1.11484051e-01f, -4.99440953e-02f, -4.37547535e-01f, -7.34482631e-02f,
  1.37158170e-01f, -3.03684503e-01f, 1.42315760e-01f, -3.16224806e-02f, 4.19654816e-01f, -1.87032521e-01f, 1.69733062e-01f, -1.56134456e-01f, 1.50571585e-01f, 3.25024813e-01f,
  2.04939544e-01f, -6.32697940e-02f, -1.38984779e-02f, -5.26002109e-01f, -1.48823023e-01f, -1.54404625e-01f, 4.59246516e-01f, 3.92972797e-01f, 2.83793695e-02f, 2.10055172e-01f,
  4.75653745e-02f, 2.08534524e-01f, 1.66379035e-01f, -3.15713249e-02f, 3.47164631e-01f, 1.70555919e-01f, -2.54006445e-01f, -5.09754479e-01f, 4.68742289e-02f, 1.01551667e-01f,
  1.72958866e-01f, 1.36959150e-01f, -4.38088953e-01f, -2.08151899e-02f, -1.48507580e-01f, 3.37836564e-01f, -1.78354397e-01f, -2.21626952e-01f, 2.14134797e-01f, 2.76422650e-01f,
  1.24600753e-01f, 1.59601390e-01f, 1.99028507e-01f, 6.54312968e-01f, -5.20656705e-01f, -3.46565992e-01f, 3.41452807e-01f, 2.06111912e-02f, -4.61440533e-01f, -7.85463303e-02f,
  -5.44658899e-01f, 4.02108282e-01f, 3.27748924e-01f, 1.20464265e-01f, 2.00072005e-01f, -1.41625032e-01f, 2.93398410e-01f, 4.37626660e-01f, 1.46096230e-01f, 1.93508014e-01f,
  3.44274670e-01f, 4.77018744e-01f, 2.08419859e-01f, 2.23199546e-01f, -1.77434102e-01f, -5.05111098e-01f, 4.04771984e-01f, -4.21679616e-01f, -1.79642960e-01f, -3.19122404e-01f,
  -3.19763809e-01f, 8.10243413e-02f, -1.36493668e-01f, 8.86443108e-02f, -7.74281397e-02f, 2.91227326e-02f, -3.15835141e-02f, -1.08417474e-01f, -3.88913825e-02f, 8.71700868e-02f,
  -1.32410869e-01f, 4.19279903e-01f, -1.06156142e-02f, 1.08636409e-01f, -3.44559066e-02f, -7.39618465e-02f, 3.08182985e-01f, 5.55710495e-01f, 2.95783520e-01f, -2.77669970e-02f,
  8.14936310e-02f, 2.70814717e-01f, 1.28129870e-01f, 2.61212528e-01f, 3.80730003e-01f, 3.23612392e-01f, 3.51540685e-01f, 4.48138475e-01f, -9.40048024e-02f, 3.70560557e-01f,
  -1.08511880e-01f, -1.21573703e-02f, 4.42476988e-01f, 2.58607686e-01f, 5.77261269e-01f, 2.22717121e-01f, -2.59348080e-02f, 2.35117394e-02f, 2.70267069e-01f, 2.46950030e-01f,
  2.88568497e-01f, 2.08010331e-01f, 2.33014375e-01f, 2.59766411e-02f, -5.86614609e-01f, -1.18977621e-01f, 1.24049835e-01f, 2.92988658e-01f, -1.27134368e-01f, 6.38997406e-02f,
  -1.17391646e-01f, 3.90143126e-01f, 1.43667743e-01f, 3.90218049e-02f, -9.53761786e-02f, 7.17089279e-03f, -8.56745765e-02f, 2.92628467e-01f, 6.33691847e-02f, 4.57548276e-02f,
  4.15067941e-01f, 4.62747425e-01f, -3.17460001e-01f, -7.48813674e-02f, -7.30163883e-04f, -1.58923760e-01f, 2.74783403e-01f, -4.08941880e-02f, 3.44427884e-01f, 7.75185600e-02f,
  1.08717568e-01f, 2.96451692e-02f, 5.12741089e-01f, 5.69116771e-01f, -1.35150224e-01f, 7.73840919e-02f, -4.45855230e-01f, 1.57720000e-02f, 5.21848857e-01f, -1.15201967e-02f,
  1.67777002e-01f, 6.69002086e-02f, -1.65773071e-02f, 2.63576686e-01f, -1.74410775e-01f, -9.14566219e-02f, -2.09663615e-01f, 3.15028317e-02f, 1.10441953e-01f, 1.33647710e-01f,
  -2.87816226e-01f, 3.92366052e-02f, 6.18444204e-01f, 2.08264142e-01f, -4.78428267e-02f, 2.47935489e-01f, 1.18273795e-01f, -6.53987601e-02f, 1.77422270e-01f, 1.07704431e-01f,
  4.62375790e-01f, -1.52640268e-02f, 1.87599808e-01f, -3.47084701e-02f, 2.37530068e-01f, 3.91439617e-01f, -2.87791658e-02f, -5.60936108e-02f, -2.29829654e-01f, 4.08027738e-01f,
  4.20307577e-01f, 1.67277809e-02f, 2.21010447e-01f, -3.47494110e-02f, 4.37230527e-01f, 1.60608962e-01f, 1.42466798e-01f, -1.35912746e-02f, 1.47028774e-01f, 2.50008583e-01f,
  -1.48941725e-01f, 2.92536139e-01f, 1.08676121e-01f, -4.37331766e-01f, -3.05643827e-01f, -5.06868780e-01f, 1.40565649e-01f, -4.98301715e-01f, -9.34729800e-02f, 1.00804359e-01f,
  -5.74852005e-02f, 4.33033764e-01f, -8.60000029e-03f, 5.11754341e-02f, 1.97551832e-01f, -1.13004178e-01f, -2.16675565e-01f, -1.94103405e-01f, 7.92742670e-02f, 5.84226072e-01f,
  3.34199131e-01f, 2.44397640e-01f, -2.07265876e-02f, 2.39506483e-01f, -9.65396538e-02f, 3.66300553e-01f, 2.25215405e-01f, 1.34916857e-01f, -1.95278630e-01f, -3.09172925e-03f,
  -1.90136135e-01f, 1.13741517e-01f, -1.72122493e-01f, -1.51835546e-01f, -9.22548920e-02f, 1.91833258e-01f, -3.07016838e-02f, -3.42258289e-02f, 2.56344348e-01f, 4.81054842e-01f,
  3.92288625e-01f, -1.95676941e-04f, 1.20744608e-01f, 1.12081885e-01f, -3.02884787e-01f, -1.21337928e-01f, 1.50911823e-01f, 8.43087360e-02f, -2.16359776e-02f, 8.49990919e-02f,
  5.00968039e-01f, -1.17925577e-01f, 3.27748924e-01f, -2.00996205e-01f, -3.98408994e-02f, 1.33598238e-01f, -7.96345100e-02f, -3.03450674e-01f, 2.40487978e-02f, 6.64552078e-02f,
  -2.97772586e-02f, -7.78634548e-02f, 4.50452000e-01f, 3.92944515e-01f, -3.62224847e-01f, 7.06434948e-03f, 3.12972814e-01f, -5.32253683e-01f, -3.78064990e-01f, -1.26225799e-01f,
  5.04534394e-02f, -5.57906210e-01f, -1.00286407e-02f, 2.00011566e-01f, -6.24803118e-02f, -1.75103601e-02f, -9.83486474e-02f, -1.08414702e-01f, 3.57551605e-01f, -9.91805643e-02f,
  -6.24687552e-01f, 6.60572276e-02f, -3.28562111e-02f, 2.93421715e-01f, 6.44424140e-01f, 1.17850065e-01f, -4.19937164e-01f, 9.79089513e-02f, -1.83821321e-01f, 2.72122592e-01f,
  1.29690632e-01f, -2.51848161e-01f, -1.73816774e-02f, -1.77562073e-01f, -2.71270610e-02f, -8.61463919e-02f, -1.26408815e-01f, 1.83367103e-01f, -8.03932473e-02f, -1.79255351e-01f,
  -1.51079550e-01f, -1.23862945e-01f, 2.49350369e-01f, 1.34775653e-01f, 8.50401893e-02f, -2.30409727e-01f, 1.76796094e-01f, 2.15172008e-01f, -7.97898248e-02f, 4.64549065e-01f,
  -3.60105783e-01f, -4.48306888e-01f, 6.12626709e-02f, -1.98564023e-01f, 3.87895435e-01f, 3.57608318e-01f, -3.73906821e-01f, 5.16938448e-01f, -1.58450287e-02f, 1.43675193e-01f,
  1.16900630e-01f, -1.10080026e-01f, 3.84893060e-01f, 4.52531934e-01f, -4.33201082e-02f, -1.27638981e-01f, -9.23755318e-02f, -1.23851918e-01f, -5.34013450e-01f, -1.40374973e-01f,
  -4.41894541e-03f, -3.56154889e-03f, -8.95817578e-02f, -1.50770307e-01f, 4.45086777e-01f, 3.64431664e-02f, 2.46414319e-01f, -1.29807726e-01f, 3.99709672e-01f, 3.65311146e-01f,
  1.39330393e-02f, -4.71503943e-01f, 2.24616099e-02f, 3.07268649e-02f, -1.96103305e-01f, 1.25951499e-01f, 4.19675142e-01f, 1.25170082e-01f, 3.20562690e-01f, 1.27028584e-01f,
  9.00932848e-02f, 4.64828283e-01f, -1.74652964e-01f, -2.60774672e-01f, 2.10288577e-02f, 2.38142177e-01f, 9.35597345e-02f, 1.79874673e-01f, 1.00931592e-01f, 1.55236647e-01f,
  -2.87407398e-01f, -2.45732740e-02f, 2.80265063e-01f, -1.26978070e-01f, -3.02516490e-01f, -1.51368156e-01f, 2.47108504e-01f, -2.21824035e-01f, 5.21712117e-02f, 1.24252424e-01f,
  1.07237630e-01f, 3.83394063e-01f, -1.11650608e-01f, 9.02953558e-03f, 1.13505349e-01f, -1.81654788e-04f, -1.01595536e-01f, 1.99243873e-01f, 4.00037616e-01f, 8.90020803e-02f,
  -5.02022803e-02f, 2.36018911e-01f, -1.80348456e-01f, 4.14251953e-01f, -2.80906022e-01f, -1.53732210e-01f, 1.89628433e-02f, 3.92152518e-01f, 3.54856670e-01f, 5.81033938e-02f,
  -2.77918149e-02f, 3.42531085e-01f, 3.56599241e-01f, 4.47333455e-01f, -1.79773852e-01f, -3.55787545e-01f, 5.75231969e-01f, -9.85840037e-02f, -2.00375572e-01f, 2.05245256e-01f,
  -4.68694538e-01f, -2.43572459e-01f, -2.32728720e-01f, 3.74340378e-02f, -1.40695035e-01f, 3.38817447e-01f, -1.48850814e-01f, -1.85916480e-02f, 2.61675149e-01f, -1.64551467e-01f,
  -2.38895774e-01f, 3.24144125e-01f, -2.78674643e-02f, 2.36541331e-01f, -9.59530380e-03f, -3.95030707e-01f, 6.09993517e-01f, 6.26618266e-01f, 4.50855017e-01f, -2.08978489e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 20)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 20;
const float L2_fan_Bp_bar_data[] = {
  1.84289619e-01f, 2.06679106e-01f, 2.47448310e-01f, 2.26035807e-02f, 3.49793494e-01f, 2.41393641e-01f, 1.38438523e-01f, 3.96050997e-02f, 7.29741901e-02f, 4.59229797e-01f,
  3.91827226e-01f, 2.10343957e-01f, 3.15815359e-01f, 2.17362434e-01f, -1.91702589e-03f, 2.62584239e-01f, -2.04422954e-03f, -8.56411457e-02f, 1.63206935e-01f, 1.89862415e-01f
};

// L3_fan_Wp (Shape: 6 x 32)
const int L3_fan_Wp_rows = 6;
const int L3_fan_Wp_cols = 32;
const float L3_fan_Wp_data[] = {
  -1.63533255e-01f, -5.85203171e-02f, 3.00066005e-02f, -2.40120906e-02f, 1.01237588e-01f, 9.35626775e-03f, 1.81972161e-01f, 5.22985198e-02f, 3.38689685e-02f, 1.24210797e-01f,
  2.91611180e-02f, 1.96195111e-01f, 2.23972544e-01f, 2.09660694e-01f, -1.41895175e-01f, 1.91259578e-01f, -1.72409579e-01f, -1.63857546e-02f, 9.23782587e-02f, -9.82256979e-02f,
  5.38176000e-02f, -9.41641107e-02f, -1.13884918e-01f, -1.61488369e-01f, 2.40312740e-01f, -6.16215393e-02f, -1.34450704e-01f, 2.81910688e-01f, -1.74152866e-01f, -4.54570577e-02f,
  1.78180560e-01f, -1.00701921e-01f, -2.17874184e-01f, 9.36636254e-02f, -1.17585197e-01f, -1.84309050e-01f, 2.51403898e-02f, -1.99753612e-01f, -1.74633086e-01f, -2.77153030e-02f,
  -1.70299299e-02f, 1.37821138e-01f, -1.54609263e-01f, 1.59201011e-01f, -2.38468777e-02f, 3.20295729e-02f, -3.46032381e-02f, 2.15618499e-02f, -2.19461024e-01f, 9.15323943e-02f,
  -1.22110076e-01f, 1.83683664e-01f, 1.10869177e-01f, -2.52979040e-01f, 2.39924025e-02f, -1.26314178e-01f, -1.20258518e-01f, 1.16319783e-01f, 4.34677303e-03f, -8.63050297e-02f,
  1.54956698e-01f, 1.04519777e-01f, 8.18898305e-02f, 1.66724131e-01f, 8.81207958e-02f, -9.64624509e-02f, 1.33016005e-01f, 1.33180037e-01f, 5.13930470e-02f, -1.92109291e-02f,
  -2.88320601e-01f, -4.56328597e-03f, -2.63204217e-01f, 2.09846944e-01f, 1.02270037e-01f, 1.80212587e-01f, -6.63361698e-02f, -6.75092563e-02f, -2.05487892e-01f, -3.00363116e-02f,
  -2.27729961e-01f, 1.59706399e-02f, -2.18959838e-01f, 2.42897108e-01f, 6.90481216e-02f, 2.58390289e-02f, -3.01995594e-02f, 1.33276477e-01f, 1.56082034e-01f, 9.13650393e-02f,
  5.34853190e-02f, 3.78195196e-01f, 4.97567244e-02f, 6.15231395e-02f, -1.17192231e-01f, -1.64566666e-01f, 1.30088016e-01f, 5.56363501e-02f, 2.04183478e-02f, 1.62450150e-01f,
  -1.26828119e-01f, 1.21815745e-02f, -2.38759384e-01f, -1.99733987e-01f, -1.28596559e-01f, 1.46695167e-01f, -2.78108455e-02f, -2.70334572e-01f, -1.24787301e-01f, -2.46452957e-01f,
  1.53453425e-01f, -6.36861995e-02f, 1.74780577e-01f, -4.49626632e-02f, -3.43130790e-02f, -1.72379494e-01f, -1.46107478e-02f, 1.48589909e-01f, -9.10314359e-03f, 1.05756884e-02f,
  -2.09791481e-01f, 9.21475291e-02f, 4.38608080e-02f, -1.32679895e-01f, 8.82234052e-02f, -2.35822469e-01f, 1.87268779e-01f, -1.94392726e-01f, -1.08362861e-01f, 1.13877781e-01f,
  1.13406695e-01f, -5.54503985e-02f, 1.91928327e-01f, -5.00782952e-02f, 1.90502584e-01f, 1.51304841e-01f, -9.64926183e-02f, -1.57665640e-01f, -7.46274218e-02f, 3.66714969e-02f,
  1.19365864e-01f, 6.66613802e-02f, -1.14059024e-01f, 1.28163487e-01f, -2.50602573e-01f, 1.75113901e-01f, -4.36255801e-03f, 2.28495687e-01f, -1.48622990e-01f, 1.25498027e-01f,
  -4.87718470e-02f, 1.94040835e-01f, 1.36466920e-01f, 7.04114139e-02f, -1.27704442e-01f, 1.80349484e-01f, -7.05065653e-02f, -8.66917223e-02f, -8.17038864e-02f, 1.45853003e-02f,
  4.99020610e-03f, -5.44505455e-02f, 6.89001083e-02f, 1.92363948e-01f, -3.90330143e-02f, -7.04173297e-02f, -5.54885045e-02f, 1.58559188e-01f, 2.35913143e-01f, -1.45774037e-01f,
  1.74021766e-01f, 2.26847082e-02f, 4.96184304e-02f, -6.08760342e-02f, -6.04165010e-02f, -2.63797432e-01f, -1.80896312e-01f, -8.36309977e-03f, -1.70938149e-01f, -2.26410493e-01f,
  2.08468556e-01f, 1.67072117e-01f, -1.24989942e-01f, -2.92363223e-02f, 2.30410740e-01f, 4.32954021e-02f, -5.72079644e-02f, -1.59326628e-01f, 1.20173156e-01f, -1.41129628e-01f,
  -5.85068651e-02f, -1.12294763e-01f
};

// L3_fan_Wp_bar (Shape: 20 x 32)
const int L3_fan_Wp_bar_rows = 20;
const int L3_fan_Wp_bar_cols = 32;
const float L3_fan_Wp_bar_data[] = {
  1.53405949e-01f, 2.34487623e-01f, 1.32696778e-01f, 2.33189702e-01f, 4.88634892e-02f, 3.98861855e-01f, -2.91295260e-01f, -1.32616326e-01f, -3.49921286e-01f, -3.57716203e-01f,
  4.79747392e-02f, 3.51857305e-01f, -4.96517271e-02f, -5.24458051e-01f, 5.64893961e-01f, -3.66260946e-01f, -1.18147776e-01f, -4.06022191e-01f, 2.17329919e-01f, 3.99542302e-01f,
  -1.77008584e-01f, 6.52921021e-01f, -4.37178649e-02f, -2.13731285e-02f, 2.29029357e-01f, 4.72798914e-01f, -5.60867265e-02f, -1.62076894e-02f, 5.91687262e-01f, 2.74969876e-01f,
  3.54314297e-01f, 4.08900172e-01f, 3.03474545e-01f, 2.44533047e-01f, 3.33882034e-01f, 2.56794989e-01f, 1.40560806e-01f, 4.53603238e-01f, -4.08756062e-02f, -4.34759371e-02f,
  -4.57592577e-01f, -5.02749383e-01f, 1.68074653e-01f, -1.28487915e-01f, 3.24991912e-01f, 1.45948142e-01f, 3.09187949e-01f, 1.29860286e-02f, -7.73061588e-02f, 2.25636810e-01f,
  -4.22857642e-01f, -1.57830656e-01f, -4.02893156e-01f, 3.97207260e-01f, -4.87499908e-02f, 1.81222588e-01f, 6.65520355e-02f, 1.92827344e-01f, -2.74131030e-01f, 1.92602620e-01f,
  -1.35156706e-01f, -4.56325173e-01f, -2.81581730e-01f, 3.58614355e-01f, -9.21376199e-02f, 1.82316527e-01f, -1.68473601e-01f, -1.71891581e-02f, -1.83551565e-01f, -4.47690254e-04f,
  1.60856947e-01f, 3.05115998e-01f, -1.78874627e-01f, -4.64125544e-01f, 1.44096017e-01f, -2.17565045e-01f, 5.34086168e-01f, -1.14495292e-01f, -9.79774911e-03f, -5.45915999e-02f,
  -5.95804676e-02f, -1.11351945e-01f, 4.87328358e-02f, 1.48163736e-01f, 4.88529176e-01f, 2.22583085e-01f, 1.56268924e-01f, 2.04641700e-01f, 4.77142811e-01f, -1.63851440e-01f,
  7.81242326e-02f, -2.08327875e-01f, 1.25074372e-01f, 3.76126282e-02f, 1.05570585e-01f, 1.40302092e-01f, 5.97057827e-02f, -9.86535400e-02f, 2.20183469e-02f, 2.88988262e-01f,
  7.45258033e-02f, 3.15646194e-02f, 3.98752809e-01f, 1.85759440e-01f, -8.75735730e-02f, 1.93403512e-01f, 1.18563965e-01f, -3.13563287e-01f, 3.23300660e-01f, 3.36036384e-01f,
  -2.97603279e-01f, -1.67547926e-01f, 2.08064750e-01f, -2.71116585e-01f, -6.39285892e-02f, -2.71999180e-01f, 3.72112632e-01f, -1.16072528e-01f, 3.06607664e-01f, 4.31647867e-01f,
  3.78997296e-01f, -3.54615867e-01f, -4.04181272e-01f, -3.12061340e-01f, -3.23432297e-01f, -6.96796104e-02f, -9.05143991e-02f, -6.37840703e-02f, 3.59442592e-01f, 4.28574622e-01f,
  4.42680717e-01f, 1.28803879e-01f, 5.54085195e-01f, 5.66709220e-01f, 3.20046365e-01f, -1.33171618e-01f, -1.75045267e-01f, -2.59939402e-01f, 4.67590719e-01f, -1.06169611e-01f,
  1.35874316e-01f, -2.75344282e-01f, 2.77045548e-01f, -5.04748464e-01f, 4.58789796e-01f, -2.69641560e-02f, -1.23904809e-01f, -1.16742507e-01f, -3.47240865e-01f, 3.37280482e-01f,
  1.96113765e-01f, 1.51787743e-01f, 1.02314753e-02f, 2.27802828e-01f, -3.02453071e-01f, -3.16159567e-03f, -4.58904266e-01f, -3.58488336e-02f, -1.15057305e-01f, 2.82234728e-01f,
  1.60033647e-02f, -2.26354208e-02f, 2.01288149e-01f, -1.26066670e-01f, 1.39651030e-01f, 3.51946056e-02f, 1.98419169e-01f, 2.59677559e-01f, -3.61431956e-01f, -4.14478362e-01f,
  3.86965036e-01f, 1.17721125e-01f, 4.36416745e-01f, -1.10173285e-01f, -2.39629373e-01f, -3.63558292e-01f, -2.51134392e-02f, -3.12705278e-01f, -2.22317144e-01f, -2.14416057e-01f,
  2.78352350e-01f, 5.80779044e-03f, -1.54551819e-01f, 1.86715320e-01f, 1.81712031e-01f, -9.56855863e-02f, -1.27886698e-01f, -2.95009434e-01f, -9.24771875e-02f, -2.32384697e-01f,
  -3.64813030e-01f, 2.08338499e-01f, -1.06287964e-01f, -2.71816641e-01f, 3.99529608e-03f, 1.01905547e-01f, 2.68132329e-01f, 6.06766008e-02f, 4.32280809e-01f, 3.69954050e-01f,
  -2.84156427e-02f, -3.84226799e-01f, -3.16888466e-02f, -4.62215096e-02f, 3.36001694e-01f, 7.84966499e-02f, -5.33224344e-01f, 3.26493055e-01f, -4.53936942e-02f, -3.47854853e-01f,
  -5.67254871e-02f, -1.53865263e-01f, -6.85251579e-02f, 7.02564232e-03f, 3.18081766e-01f, 4.44419473e-01f, 4.94354099e-01f, 8.28250591e-03f, -1.66785210e-01f, -8.13084468e-02f,
  -3.72613192e-01f, 1.90943524e-01f, -1.44401208e-01f, 7.97374174e-02f, 2.69730568e-01f, 3.56385052e-01f, 2.57187188e-01f, 7.60034099e-02f, 3.42478454e-01f, 4.29447055e-01f,
  3.10980946e-01f, 1.11030646e-01f, 2.06298813e-01f, -3.46235037e-02f, 2.46352389e-01f, -2.01093763e-01f, 2.93165833e-01f, 6.62863329e-02f, 3.82017195e-01f, -6.52157590e-02f,
  5.41912019e-01f, 1.32556990e-01f, 5.80780685e-01f, -4.01645690e-01f, -1.28928527e-01f, -3.14996690e-02f, 3.77118498e-01f, 8.12169611e-02f, -1.71805471e-01f, -1.79992229e-01f,
  -1.89113915e-01f, -3.31863672e-01f, -2.53006220e-01f, -3.65871161e-01f, 1.21853381e-01f, 1.46552071e-01f, 2.60305256e-01f, 5.34417965e-02f, 1.07934274e-01f, -1.02984585e-01f,
  1.73687354e-01f, -2.69082159e-01f, 4.25006866e-01f, 2.63736427e-01f, 1.75142378e-01f, -1.11492760e-01f, -8.04225281e-02f, 3.28301072e-01f, 3.91831279e-01f, 1.98192805e-01f,
  -1.44467354e-01f, 2.97744036e-01f, 2.65576601e-01f, 4.49125826e-01f, 1.50369599e-01f, -3.21917444e-01f, 1.63068056e-01f, -3.24954800e-02f, -7.04446211e-02f, 1.91189319e-01f,
  3.51165146e-01f, -2.38552272e-01f, 1.01211919e-02f, 8.87350962e-02f, -4.77232307e-01f, 5.82558140e-02f, -2.63063908e-02f, 1.59016877e-01f, -2.51182258e-01f, 2.29503699e-02f,
  -3.76861334e-01f, -3.13178092e-01f, -4.95181650e-01f, -4.22857225e-01f, 2.81384848e-02f, 6.55126125e-02f, 5.39740101e-02f, -2.22608656e-01f, 1.51882619e-01f, 1.85388774e-02f,
  -4.63532098e-02f, -2.95060247e-01f, 1.07876984e-02f, 9.82083529e-02f, -2.69249231e-01f, -4.26165983e-02f, 3.04904897e-02f, 2.48583540e-01f, 2.17426956e-01f, 2.14799955e-01f,
  2.47855000e-02f, 2.26915792e-01f, 3.22692454e-01f, 2.92878803e-02f, 9.90935117e-02f, -4.71753091e-01f, 2.63807237e-01f, 7.02674463e-02f, -2.08514720e-01f, 2.72931427e-01f,
  2.71376103e-01f, -1.20648677e-02f, -5.65534681e-02f, 1.07665211e-01f, 1.89070076e-01f, 4.45398353e-02f, 2.57844895e-01f, -2.06850037e-01f, -3.35989892e-01f, -3.74628663e-01f,
  2.99158990e-01f, 4.91044298e-03f, 1.34691626e-01f, -2.78801471e-01f, 2.52062529e-01f, -2.54369169e-01f, -2.08282202e-01f, -1.81035802e-03f, -1.46235570e-01f, -2.11520344e-01f,
  3.47027183e-01f, 2.63686359e-01f, -1.31273419e-01f, 2.59977072e-01f, 4.01749611e-01f, 7.53042614e-03f, -1.82462439e-01f, -4.69673483e-04f, 1.00655690e-01f, -3.95284981e-01f,
  5.80090517e-03f, 3.14009815e-01f, 1.79113179e-01f, 6.48382455e-02f, 1.09112754e-01f, 3.21680754e-01f, 1.54706761e-01f, -1.02324240e-01f, -3.06430459e-01f, -6.54742241e-01f,
  9.72617716e-02f, 4.90438759e-01f, 3.14831823e-01f, -3.42050701e-01f, -4.13838357e-01f, 9.72992629e-02f, 4.50018644e-01f, -6.78144321e-02f, 2.56596297e-01f, -6.35615215e-02f,
  2.25344807e-01f, 8.58494788e-02f, 5.53359509e-01f, 3.29549350e-02f, 1.50498867e-01f, 3.68846841e-02f, -2.04071984e-01f, 2.41089374e-01f, 2.09623072e-02f, 6.60532594e-01f,
  3.08133960e-01f, 4.30347249e-02f, 2.75987327e-01f, -9.89051387e-02f, 1.07062515e-02f, 6.66543171e-02f, -1.59912452e-01f, -1.54159665e-01f, -2.73946196e-01f, -4.73488681e-02f,
  -1.64182976e-01f, 3.06829102e-02f, 3.27711105e-01f, -7.00703263e-02f, -1.83511063e-01f, -4.23611403e-02f, -6.00925907e-02f, 2.55751342e-01f, 1.68651015e-01f, 2.85509109e-01f,
  2.29871601e-01f, 3.57910767e-02f, 1.95035845e-01f, 3.24178457e-01f, 2.26097912e-01f, -3.33240956e-01f, 3.28298748e-01f, -1.57859609e-01f, 2.03961298e-01f, 2.96056569e-01f,
  5.95073879e-01f, -1.84106305e-02f, 3.44548434e-01f, 4.84538227e-01f, 3.92017245e-01f, -2.68210005e-02f, 1.62731912e-02f, 6.31458834e-02f, 3.55139315e-01f, -8.76862407e-02f,
  2.02604949e-01f, -1.27162978e-01f, -5.59665978e-01f, -4.34991151e-01f, -1.41670495e-01f, 3.38064909e-01f, -2.45568343e-03f, -2.43813526e-02f, -1.43702760e-01f, -4.08290932e-03f,
  1.72456250e-01f, 2.74823934e-01f, 2.49342918e-02f, -1.50947839e-01f, 2.44477645e-01f, 1.35285184e-01f, -1.01233602e-01f, 5.64204790e-02f, 1.64564177e-02f, -2.45358482e-01f,
  -4.08077359e-01f, 4.55316991e-01f, 9.49013382e-02f, 5.37915945e-01f, 6.10933565e-02f, 3.19021821e-01f, 3.58129591e-01f, 9.95263755e-02f, 2.51938015e-01f, 2.53526986e-01f,
  2.08649829e-01f, 1.88920930e-01f, -4.35054041e-02f, 2.07858011e-01f, 7.50528648e-02f, -5.47718853e-02f, -3.04578543e-01f, -2.51532495e-02f, 1.64077640e-01f, 2.41590694e-01f,
  2.58365124e-02f, -4.08075154e-01f, 2.43075818e-01f, 1.27294883e-02f, -2.02581227e-01f, 2.18539715e-01f, -2.00251237e-01f, 1.67758334e-02f, 2.07150698e-01f, 5.00324786e-01f,
  -2.64601558e-02f, 3.03902733e-03f, -6.43383935e-02f, 2.25073621e-01f, -1.36889219e-01f, 2.69103050e-01f, 1.82483435e-01f, -1.32536978e-01f, -5.66611020e-03f, 5.82865536e-01f,
  4.39265013e-01f, 1.23900279e-01f, 3.06178927e-01f, 4.12357688e-01f, 3.34599584e-01f, 2.69252986e-01f, 4.81523089e-02f, -2.65546411e-01f, 3.12247664e-01f, -1.99663252e-01f,
  -2.95237303e-01f, 6.12939775e-01f, -2.52216385e-04f, 2.06688344e-01f, 3.20618868e-01f, 3.64110827e-01f, -1.87730622e-02f, 7.02302158e-01f, 8.62395987e-02f, -4.50185686e-01f,
  -4.03609753e-01f, 1.83790416e-01f, 1.94270499e-02f, -3.39487642e-01f, -4.64855403e-01f, 1.49275064e-01f, 1.48932502e-01f, 5.83106279e-01f, -1.65810570e-01f, -2.49295995e-01f,
  -1.43091828e-01f, 3.38698030e-01f, 3.57749313e-01f, 1.11894146e-01f, 2.58955508e-02f, 3.72346118e-02f, 4.56228629e-02f, 5.13745099e-02f, 1.56961977e-01f, -5.06184883e-02f,
  3.81549329e-01f, -1.12106092e-02f, -1.04903154e-01f, -4.44691867e-01f, -5.60101941e-02f, 3.34102780e-01f, 4.28301960e-01f, -5.38517896e-04f, 4.93276238e-01f, 2.20981300e-01f,
  3.22557628e-01f, -3.97028804e-01f, 4.75004107e-01f, 1.08294617e-02f, 3.70547712e-01f, 9.08944681e-02f, 1.98537603e-01f, -3.12547117e-01f, -8.88592824e-02f, -5.28692961e-01f,
  1.96699664e-01f, -2.17701465e-01f, -1.29059762e-01f, 8.60302076e-02f, 2.00746715e-01f, 2.67580211e-01f, 2.87425935e-01f, 4.51263934e-01f, 8.69563073e-02f, 4.21005875e-01f,
  1.49800405e-01f, 4.87642176e-02f, 2.60430396e-01f, 1.99732468e-01f, -4.00049657e-01f, 3.48217666e-01f, 2.89332941e-02f, 1.13398239e-01f, 2.43104212e-02f, 1.26210853e-01f,
  3.15406144e-01f, 2.51561463e-01f, 2.66699821e-01f, 1.88062042e-01f, -4.41553712e-01f, 1.98078170e-01f, 1.97222218e-01f, -1.43875346e-01f, 5.27676679e-02f, 3.39148998e-01f,
  -4.85303579e-03f, -2.16565523e-02f, -7.24792778e-02f, 1.89104974e-01f, 3.17778796e-01f, -1.70067698e-01f, -1.75853804e-01f, 1.68810189e-01f, -4.28556532e-01f, -1.71217203e-01f,
  -4.09451008e-01f, -3.88149589e-01f, 1.22148246e-01f, 2.50530183e-01f, 3.41455877e-01f, -2.11085036e-01f, -1.29852638e-01f, 3.88312995e-01f, 5.92669547e-02f, 3.72158229e-01f,
  -1.39530733e-01f, 4.18360829e-01f, -1.24490082e-01f, 6.80698812e-01f, 8.34269226e-02f, 1.56456694e-01f, 1.82403296e-01f, 2.10733991e-02f, -7.35320151e-02f, -7.00050145e-02f,
  9.12985727e-02f, 1.05345376e-01f, 2.38911375e-01f, -9.64352675e-03f, 2.71640688e-01f, -1.20463714e-01f, -1.47369713e-01f, 3.79818588e-01f, -2.63638198e-01f, -8.60115048e-03f,
  -1.80171624e-01f, -1.51553243e-01f, -1.88305415e-02f, -5.96482418e-02f, 8.78399163e-02f, -6.12892434e-02f, 3.48252535e-01f, 2.26246923e-01f, -3.98761965e-02f, -1.68637812e-01f,
  1.71599582e-01f, 4.91160542e-01f, -3.97446960e-01f, 2.47337371e-01f, 3.28157276e-01f, 4.46912944e-02f, 3.93612027e-01f, -4.01931144e-02f, -1.77278906e-01f, -4.60503757e-01f,
  3.91129017e-01f, 3.16971093e-01f, 1.41029254e-01f, -2.28561521e-01f, 4.02623028e-01f, -3.23081732e-01f, 1.50780588e-01f, 3.18518490e-01f, 2.14133278e-01f, -3.10282797e-01f
};

// L3_fan_Bp_bar (Shape: 1 x 20)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 20;
const float L3_fan_Bp_bar_data[] = {
  6.01096265e-02f, 1.88309476e-02f, 6.98757321e-02f, 5.64938076e-02f, 2.42050305e-01f, -3.26540805e-02f, 3.13296735e-01f, 1.89876795e-01f, 8.66880938e-02f, 3.61739211e-02f,
  1.99355811e-01f, 1.77994013e-01f, -7.69544691e-02f, 2.28898957e-01f, 2.68417388e-01f, 1.50314376e-01f, 5.78237437e-02f, 2.69838154e-01f, -4.65807691e-02f, 6.69447631e-02f
};

// L4_linear_W (Shape: 12 x 32)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 32;
const float L4_linear_W_data[] = {
  -1.77051395e-01f, -1.02565259e-01f, 4.03010286e-02f, 6.76138476e-02f, 1.34334583e-02f, 5.63417859e-02f, -1.39604777e-01f, -7.56731769e-03f, 1.48448914e-01f, -8.43615737e-03f,
  6.93233833e-02f, 2.94527947e-03f, 2.14139357e-01f, 1.38414830e-01f, 1.52893811e-01f, -3.31902444e-01f, -7.74900988e-02f, -5.75000308e-02f, -3.07728946e-01f, -4.84027714e-01f,
  -5.23617804e-01f, 2.67909557e-01f, 1.69467166e-01f, -1.03576154e-01f, -9.48381275e-02f, -2.28790641e-01f, 2.31738210e-01f, -3.43228281e-01f, 4.05152179e-02f, -4.29267436e-01f,
  3.68882030e-01f, -2.77127266e-01f, 2.38207430e-01f, -2.74575621e-01f, 2.01709732e-01f, -9.53292772e-02f, 2.48258322e-01f, -1.48284689e-01f, -3.56513411e-01f, 3.81601840e-01f,
  3.55591536e-01f, 1.93752959e-01f, -3.10476035e-01f, -2.70377666e-01f, 3.01051497e-01f, -4.16568547e-01f, -3.20017785e-01f, -1.76094234e-01f, -1.37064517e-01f, 4.75771204e-02f,
  -3.45800638e-01f, -2.51854360e-01f, -2.83986062e-01f, -1.76533893e-01f, -4.72392052e-01f, 2.11693078e-01f, 1.62521470e-02f, 4.16286200e-01f, -8.12038686e-03f, -9.39977989e-02f,
  -6.62820280e-01f, 2.13634744e-01f, -3.23724717e-01f, -1.01559915e-01f, -1.62655637e-01f, -9.22956392e-02f, 4.78740819e-02f, -3.90245505e-02f, -7.79479742e-03f, -6.10193312e-02f,
  1.11762509e-01f, 3.04924965e-01f, 5.27893960e-01f, -1.55098692e-01f, 9.33696255e-02f, 1.44590080e-01f, -4.90760386e-01f, -2.86466837e-01f, -1.17874347e-01f, -2.20838875e-01f,
  -3.49281192e-01f, 1.43397346e-01f, -2.63063610e-01f, -6.67825520e-01f, 1.71838343e-01f, -1.53757706e-01f, -2.57647522e-02f, 2.00300455e-01f, 2.96695143e-01f, 3.13898861e-01f,
  -2.42955089e-01f, 1.65125817e-01f, -6.50004268e-01f, -9.19716805e-02f, 3.36710125e-01f, 2.70206630e-01f, -2.97431707e-01f, -1.32668182e-01f, 6.66917637e-02f, 5.75003400e-02f,
  -2.79800352e-02f, -2.03303516e-01f, 3.31680685e-01f, -9.86002907e-02f, 3.98217410e-01f, -2.75482327e-01f, 2.47287497e-01f, 4.67713267e-01f, -7.92244375e-01f, 2.01552242e-01f,
  1.72770396e-01f, 3.58558834e-01f, 4.81192134e-02f, 2.88565069e-01f, 4.05570209e-01f, -6.01707809e-02f, 1.22773595e-01f, -1.12735793e-01f, 8.59507024e-02f, -4.34228033e-01f,
  -2.63333231e-01f, 1.33017361e-01f, -1.99653685e-01f, 2.56205164e-02f, -4.18647602e-02f, -5.51135719e-01f, -2.57869929e-01f, 4.74745743e-02f, 2.94654608e-01f, 3.48483101e-02f,
  -1.18292540e-01f, -6.12973887e-03f, -1.03932410e-01f, 2.14035034e-01f, -3.35887462e-01f, -3.33532810e-01f, -2.91511714e-01f, -4.30677325e-01f, 3.66559207e-01f, 3.39678288e-01f,
  8.73273388e-02f, 2.68588394e-01f, 1.58335328e-01f, -7.51876906e-02f, 4.25760388e-01f, 2.31487840e-01f, 8.19245651e-02f, 3.40700001e-01f, 1.05627403e-01f, 5.03664464e-02f,
  6.02094047e-02f, -6.43623412e-01f, -2.29523376e-01f, -6.12740040e-01f, 1.38869449e-01f, -2.38274127e-01f, 2.85741985e-02f, -1.03189938e-01f, -1.19995631e-01f, -4.05914217e-01f,
  -4.12840992e-01f, 3.49697731e-02f, -1.78602621e-01f, -4.51638460e-01f, -2.11800206e-02f, 2.53966689e-01f, 7.07795173e-02f, -2.04833925e-01f, -5.04127741e-01f, -1.55439200e-02f,
  -4.79306459e-01f, -9.92726237e-02f, 9.34300646e-02f, 1.00179322e-01f, 6.47671670e-02f, -4.74703580e-01f, 2.96262294e-01f, -2.71158397e-01f, -2.74538100e-02f, 2.41674408e-01f,
  -4.40407574e-01f, -9.27324519e-02f, 1.08881101e-01f, 1.86496302e-01f, -7.02780411e-02f, 3.94717325e-03f, 7.62369409e-02f, -8.23836029e-02f, 2.23097548e-01f, -1.36123900e-03f,
  -5.73350728e-01f, -3.87753755e-01f, 1.93342403e-01f, 3.33168089e-01f, -6.75857365e-02f, 1.45963848e-01f, 1.51403159e-01f, 1.11185730e-01f, 2.95547038e-01f, -5.55276535e-02f,
  -3.55834693e-01f, -2.18319356e-01f, 1.01443149e-01f, -3.00867915e-01f, -3.15715849e-01f, 1.06748017e-02f, -3.05137396e-01f, -4.32417154e-01f, -8.25270265e-02f, -3.20281208e-01f,
  -3.14116716e-01f, 1.86925605e-01f, 3.19927812e-01f, -5.38873151e-02f, -3.42747331e-01f, -9.57648531e-02f, -3.01130824e-02f, -2.16934025e-01f, -1.42564535e-01f, 6.15150511e-01f,
  1.22263245e-01f, 2.66907066e-01f, 2.41968557e-01f, -1.14245573e-02f, -4.10101786e-02f, 1.73135668e-01f, -2.18517542e-01f, -1.01066396e-01f, -2.63964031e-02f, -2.41158098e-01f,
  1.45131759e-02f, -1.78649127e-01f, 2.73735434e-01f, -1.86679456e-02f, 1.79641187e-01f, -1.73516631e-01f, -2.33675912e-01f, -1.50951162e-01f, 2.27835804e-01f, 1.38030022e-01f,
  -4.22159344e-01f, 2.33502716e-01f, 1.16121896e-01f, -6.16046369e-01f, 1.88481912e-01f, 3.37913364e-01f, 1.93878606e-01f, -2.88054347e-01f, -5.49274385e-02f, -2.60316010e-04f,
  6.81792721e-02f, -1.58649564e-01f, 5.66116311e-02f, -3.68952185e-01f, 4.82364357e-01f, -3.84417444e-01f, -1.97581753e-01f, -3.47747058e-02f, -5.82486130e-02f, -2.10662663e-01f,
  -2.90525138e-01f, -2.83428952e-02f, -1.28293678e-01f, 3.95919234e-02f, -2.51965433e-01f, -1.70691311e-02f, -1.07368290e-01f, -3.40919010e-02f, 5.86729012e-02f, -7.22609758e-02f,
  1.49370611e-01f, -1.37472764e-01f, -3.71771485e-01f, 4.70689498e-02f, -2.08095729e-01f, -6.23838454e-02f, -2.72938222e-01f, 9.84931886e-02f, -3.11339021e-01f, -8.47986788e-02f,
  3.04913819e-01f, 4.86743301e-02f, -4.92653221e-01f, -5.11216581e-01f, 4.41535003e-03f, 9.93712693e-02f, -2.08938360e-01f, 3.57884228e-01f, 5.52066006e-02f, 3.59369755e-01f,
  1.59877539e-01f, 2.15552986e-01f, 1.52278945e-01f, 6.36570156e-02f, -4.98124957e-01f, 1.95835922e-02f, 4.20399189e-01f, 4.31887925e-01f, 2.09873021e-01f, -1.12327337e-02f,
  1.14881925e-01f, 4.35679734e-01f, -4.86987144e-01f, -2.52645817e-02f, 2.82425970e-01f, -3.27255428e-01f, -1.71641722e-01f, -2.35906065e-01f, -3.32140237e-01f, -3.38457018e-01f,
  1.71094388e-01f, 7.09735043e-03f, -7.14328229e-01f, 1.19342975e-01f, 2.70387530e-01f, 4.37691182e-01f, -4.08751249e-01f, -4.21275385e-02f, -2.07914948e-01f, -1.22386560e-01f,
  -7.90252462e-02f, 5.09475544e-02f, 3.32141332e-02f, -1.02961756e-01f, 1.98755711e-01f, -8.36598650e-02f, 3.55069041e-01f, 4.39326465e-03f, -3.87037039e-01f, -2.62640238e-01f,
  2.82046318e-01f, -1.77662894e-01f, -4.08756882e-01f, -6.74721459e-03f, 3.48229967e-02f, 2.34904751e-01f, -2.41750106e-01f, -3.58994842e-01f, 3.18198085e-01f, -5.21461032e-02f,
  3.90923247e-02f, -3.93377393e-01f, -4.07653660e-01f, -4.34549689e-01f, 9.59493965e-02f, -2.52971232e-01f, -1.53489634e-01f, -3.81702602e-01f, 1.58848524e-01f, 2.00128376e-01f,
  1.58291891e-01f, 3.84853125e-01f, 1.16861150e-01f, 3.77792716e-02f, 6.13326877e-02f, 2.65182883e-01f, -2.85260826e-02f, 9.10566226e-02f, -1.19329512e-01f, -1.29509404e-01f,
  -1.94221780e-01f, 2.66321301e-01f, -8.08182806e-02f, -7.31833801e-02f, -4.82990861e-01f, -3.20102841e-01f, -1.10767528e-01f, 2.68407226e-01f, 8.01449493e-02f, -2.99595743e-01f,
  -2.37742946e-01f, 1.04482323e-01f, 1.16696276e-01f, -2.95474112e-01f, -1.02539822e-01f, 3.56091350e-01f, -5.07409722e-02f, -3.99451971e-01f, -1.43107891e-01f, -3.71758878e-01f,
  3.89275968e-01f, -1.77437693e-01f, -2.97581911e-01f, 1.57440230e-01f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  -2.87644565e-01f, -3.74102704e-02f, 2.99180467e-02f, -4.81242836e-02f, 1.45268723e-01f, 2.37921730e-01f, 1.52821988e-01f, 5.80312684e-02f, -7.87019655e-02f, 1.83361047e-03f,
  -8.89219865e-02f, 5.37792332e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 20
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 6, 20
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        32, 6, 20
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        32, 6, 20
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        32, 12
    );
    }
    