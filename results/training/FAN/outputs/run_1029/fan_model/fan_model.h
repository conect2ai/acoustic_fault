/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 12 x 120)
const int L0_fan_Wp_rows = 12;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -4.28109756e-03f, 4.14841110e-03f, 1.86081290e-01f, -1.41343087e-01f, -3.08925629e-01f, -2.22776502e-01f, -4.06681806e-01f, -1.76992700e-01f, -9.38661844e-02f, -1.26840044e-02f,
  2.12803826e-01f, 2.56974578e-01f, 3.70882809e-01f, 3.53045791e-01f, 1.94096133e-01f, -2.92754084e-01f, -3.50005925e-01f, 2.50495136e-01f, 3.74081224e-01f, 5.37764244e-02f,
  -1.13617726e-01f, -8.10913667e-02f, 1.46840766e-01f, 7.83289522e-02f, -1.30808443e-01f, 7.33241364e-02f, -8.34696814e-02f, -8.77427775e-03f, 7.50426129e-02f, -1.52550951e-01f,
  2.83460647e-01f, 3.62572335e-02f, 1.24653742e-01f, 1.62297472e-01f, 4.02787812e-02f, 8.19991007e-02f, -3.22442316e-02f, 1.04533099e-01f, 6.37739897e-02f, -4.69324924e-02f,
  3.73298526e-02f, 3.35680805e-02f, -7.58324005e-03f, 3.28172110e-02f, -7.87013099e-02f, -5.48699014e-02f, 6.31763935e-02f, 1.25493228e-01f, 5.28815128e-02f, 1.96378324e-02f,
  4.88461405e-02f, -1.31366134e-01f, -2.24683098e-02f, -2.80202515e-02f, 4.73299623e-02f, 7.75859058e-02f, 1.58502460e-02f, 6.47254288e-02f, 1.13457784e-01f, 3.80798895e-03f,
  8.55315179e-02f, -4.89000343e-02f, 4.66173794e-03f, -6.92752227e-02f, -3.05124298e-02f, -2.55852286e-03f, -6.68613315e-02f, -5.61613450e-03f, -3.70634571e-02f, -3.56442221e-02f,
  3.04125287e-02f, -3.30602825e-02f, -3.73569061e-03f, -6.63423166e-02f, 7.11360946e-02f, -2.06821784e-02f, 2.86772624e-02f, 8.46605822e-02f, 5.51787913e-02f, -6.58570379e-02f,
  6.39357120e-02f, -1.99739519e-03f, 3.82851809e-02f, 2.73693856e-02f, 5.26207834e-02f, 5.54073639e-02f, -1.64791849e-02f, 8.44062045e-02f, 6.43047020e-02f, 9.49270383e-04f,
  1.03017934e-01f, 4.90457155e-02f, -4.89691924e-03f, 7.93671608e-02f, 1.18370317e-02f, 6.56370595e-02f, 5.38182519e-02f, 4.95697707e-02f, -4.78863120e-02f, 7.02868626e-02f,
  6.54745698e-02f, 1.50248230e-01f, 8.79432410e-02f, 6.26793280e-02f, -6.92603691e-03f, 3.83651741e-02f, -2.33755186e-02f, 1.90125150e-03f, 4.45830496e-03f, 2.79796515e-02f,
  1.55463787e-02f, -1.58475310e-01f, -7.18609616e-02f, -4.70341966e-02f, 2.05305051e-02f, -6.23438805e-02f, 8.37460831e-02f, 1.16151304e-03f, 7.35491887e-02f, -1.42895415e-01f,
  2.44759861e-02f, 1.85131490e-01f, -2.51050163e-02f, 2.89947629e-01f, 5.75806350e-02f, 1.60279719e-03f, 2.32312262e-01f, -7.89297298e-02f, 7.79863894e-02f, 3.49381834e-01f,
  4.84779850e-02f, 8.34683925e-02f, 7.76951537e-02f, -3.35124023e-05f, -7.65348971e-02f, 2.03081459e-01f, 2.23214105e-01f, -1.82823375e-01f, -2.92824119e-01f, 2.32502930e-02f,
  1.43899083e-01f, 4.68543097e-02f, -3.09476495e-01f, -7.81327188e-02f, 4.69738811e-01f, 1.59658611e-01f, 1.69282451e-01f, 9.54472870e-02f, 1.68733671e-01f, 5.03839016e-01f,
  3.54696453e-01f, 2.37572882e-02f, 4.17509750e-02f, 1.13054663e-01f, 4.91381474e-02f, 8.93028304e-02f, 1.15175955e-01f, 4.97354269e-02f, 2.05560606e-02f, 1.14551790e-01f,
  3.93808596e-02f, 3.24532092e-02f, -2.47115102e-02f, 9.13592800e-02f, -1.56801119e-02f, 6.42982349e-02f, 3.64898378e-03f, 1.76682286e-02f, -6.23543486e-02f, 1.29347473e-01f,
  1.26305759e-01f, -7.16839954e-02f, -2.19386630e-02f, 1.58096161e-02f, -2.93586049e-02f, 3.14239115e-02f, 8.80921409e-02f, 6.53161332e-02f, 5.62515901e-03f, 2.51026124e-01f,
  4.34211530e-02f, -1.89224500e-02f, -2.86038052e-02f, -1.49084786e-02f, -2.07102094e-02f, -9.54024401e-03f, -1.86607074e-02f, -6.19866922e-02f, -3.43593098e-02f, 5.30167203e-03f,
  -1.05277747e-01f, -5.24488501e-02f, -8.67134854e-02f, -3.58944386e-02f, 6.47750404e-03f, -9.14295837e-02f, -7.96130374e-02f, -1.39049934e-02f, 6.15300564e-03f, -2.13939026e-02f,
  -6.20202646e-02f, -3.74772563e-03f, -6.80513605e-02f, -6.52200803e-02f, -4.56947424e-02f, -3.46174873e-02f, -1.39649343e-02f, -7.23997802e-02f, -4.49819006e-02f, -5.34612089e-02f,
  1.66270003e-01f, -1.96073741e-01f, 2.27321595e-01f, 6.66684881e-02f, 1.35668159e-01f, 6.61062524e-02f, 3.77529524e-02f, 8.50562677e-02f, 1.46185257e-03f, 2.92911977e-02f,
  2.42127664e-02f, -9.18664411e-03f, 4.46328968e-02f, -2.03691293e-02f, 4.37989011e-02f, 1.14026636e-01f, 7.66636804e-02f, -3.04197259e-02f, -4.01121601e-02f, 2.88410988e-02f,
  6.40183687e-02f, 9.37393457e-02f, 7.35580325e-02f, 1.52221441e-01f, 9.64941680e-02f, 3.97169925e-02f, 1.34474412e-01f, 1.89567968e-01f, -4.66866754e-02f, 3.27004462e-01f,
  6.92951560e-01f, -1.01160571e-01f, -1.06483713e-01f, 7.68393790e-03f, -8.49768817e-02f, -8.30095187e-02f, -2.47280985e-01f, 1.17731038e-02f, 5.98450042e-02f, -1.26105681e-01f,
  1.27103835e-01f, 1.60361424e-01f, -1.15084231e-01f, -6.23720177e-02f, -6.02401085e-02f, -4.07270700e-01f, -2.72290915e-01f, -1.31706027e-02f, 1.51415929e-01f, 6.15904182e-02f,
  -7.70951360e-02f, 1.52092248e-01f, 2.72935331e-01f, 8.50794688e-02f, -1.41229361e-01f, -3.21243182e-02f, -1.83939964e-01f, 5.56592941e-02f, -1.34997457e-01f, -3.13034952e-01f,
  4.46875915e-02f, 1.63152158e-01f, -4.90376800e-02f, 9.85610709e-02f, -3.34325735e-03f, 1.94204785e-02f, -2.92614568e-03f, 4.07642387e-02f, 8.79821777e-02f, 2.00607479e-02f,
  -2.40299739e-02f, 1.56852365e-01f, -4.04053815e-02f, -8.24024752e-02f, 2.95600053e-02f, 6.49920572e-03f, -1.43044023e-02f, -9.02356133e-02f, -3.70843895e-02f, -1.96013395e-02f,
  -6.61291480e-02f, 4.55217548e-02f, -1.40829943e-02f, -7.43053928e-02f, 8.64240155e-03f, 8.87631178e-02f, -6.18990473e-02f, -2.57504433e-02f, 6.95037097e-02f, -7.02684075e-02f,
  1.56369492e-01f, 3.95748444e-04f, 3.32782827e-02f, 1.17867604e-01f, -7.73532270e-03f, -4.89573628e-02f, -1.85577646e-02f, 1.94654595e-02f, 8.52843840e-03f, 2.17476152e-02f,
  -5.27255004e-03f, 5.02346195e-02f, 2.63555516e-02f, -8.26588646e-02f, -7.37301931e-02f, -2.22740583e-02f, -9.35606584e-02f, -4.93899770e-02f, 4.21972983e-02f, 1.01141119e-02f,
  -4.88673337e-02f, -1.78549998e-02f, -3.68095376e-02f, -3.94360423e-02f, -7.57404938e-02f, -9.39061642e-02f, -5.10168374e-02f, 7.99955651e-02f, 5.02578653e-02f, 2.37424728e-02f,
  2.81211827e-02f, -5.28365970e-02f, -1.52406886e-01f, -7.91935995e-02f, -2.11608801e-02f, -4.10220772e-02f, -5.69424890e-02f, -3.96083742e-02f, 1.12880545e-03f, -2.82202363e-02f,
  7.76334703e-02f, -9.45427734e-03f, -3.35022211e-02f, 7.91072194e-03f, 7.04086432e-03f, 5.52857369e-02f, -1.28332213e-01f, -4.49203737e-02f, -7.49196932e-02f, 5.30887134e-02f,
  -2.40437919e-03f, -5.06310351e-02f, -5.52241877e-02f, -7.56265819e-02f, -7.90034086e-02f, -1.11861236e-01f, -1.13105848e-01f, -8.49747434e-02f, -1.62976235e-01f, -1.77091792e-01f,
  -9.60011035e-03f, 3.50012630e-01f, 2.43964672e-01f, 1.24345116e-01f, 3.76556143e-02f, 2.01866001e-01f, 2.03020871e-01f, 9.81948525e-02f, -1.47440657e-01f, 6.23523593e-02f,
  -3.19798812e-02f, -2.50423819e-01f, -9.54034775e-02f, -8.80520977e-03f, -4.79771905e-02f, 2.14450359e-01f, 3.07135671e-01f, 8.41120332e-02f, 6.62024766e-02f, 6.61468655e-02f,
  1.27860755e-01f, 2.92963460e-02f, 3.81876118e-02f, 2.81402394e-02f, 1.48460194e-01f, -1.44524351e-01f, 5.34101166e-02f, 3.31515633e-02f, -2.78753024e-02f, 2.90344745e-01f,
  2.93779105e-01f, 1.80731058e-01f, -1.13647036e-01f, -3.22996937e-02f, -2.37964652e-02f, 5.13779521e-02f, 9.87671781e-03f, 2.21740641e-02f, -9.03759152e-02f, 1.04751982e-01f,
  5.31165563e-02f, 3.97438407e-02f, 5.02187498e-02f, 1.61511660e-01f, 1.17654786e-01f, 1.22221880e-01f, 1.25991657e-01f, 4.31756787e-02f, -5.71926087e-02f, 5.10793999e-02f,
  1.21335521e-01f, 6.89778626e-02f, -1.86179404e-03f, 1.80074070e-02f, -3.35788280e-02f, -5.13110571e-02f, 7.58152455e-02f, -4.19286918e-03f, -1.67862382e-02f, 2.37837825e-02f,
  8.95617157e-02f, -7.60431588e-02f, -1.68022942e-02f, -6.71928078e-02f, -6.56794310e-02f, -1.52518868e-01f, 1.39507940e-02f, -1.18623730e-02f, 3.10137477e-02f, 7.22855749e-03f,
  -3.49077731e-02f, 5.46908886e-05f, 5.13328165e-02f, 4.50273566e-02f, 6.26103282e-02f, 9.19096395e-02f, -4.38737944e-02f, 9.81952026e-02f, -6.58317208e-02f, 2.07812600e-02f,
  -7.52193332e-02f, -6.27759621e-02f, -2.61802729e-02f, 2.19155848e-02f, 6.58648461e-02f, 8.83152708e-02f, 9.64820106e-03f, -2.35746652e-02f, -5.66972280e-03f, 1.04144979e-02f,
  -2.18057960e-01f, -1.08836994e-01f, -7.15002343e-02f, -8.41928273e-03f, 1.43991811e-02f, -1.16908558e-01f, -4.38753366e-02f, -4.02799360e-02f, -5.85362129e-02f, -1.97446737e-02f,
  -4.46327875e-04f, -3.13012861e-02f, 1.16944805e-01f, -2.80271377e-02f, 4.26329598e-02f, -3.32093462e-02f, -9.21457559e-02f, 6.43620789e-02f, -1.60427727e-02f, -2.61904206e-02f,
  2.22851485e-02f, -5.96426707e-03f, -2.43283436e-01f, -1.80944562e-01f, -9.91352927e-03f, -1.70734823e-01f, -2.00978860e-01f, -1.06233880e-01f, -1.80900022e-01f, -9.97012556e-02f,
  1.99691346e-03f, -1.74420372e-01f, -5.84669895e-02f, 2.44799897e-01f, 1.92074060e-01f, -1.32695772e-02f, -1.96824670e-01f, -2.16121316e-01f, 7.57281259e-02f, -6.97715953e-02f,
  -6.35234192e-02f, 1.68714970e-02f, -7.68986791e-02f, -1.20239094e-01f, -1.13497503e-01f, 2.39426270e-02f, 2.12500125e-01f, 2.45963335e-02f, 7.43610784e-02f, 3.99984084e-02f,
  2.06320599e-01f, 5.74849695e-02f, 8.90257061e-02f, 1.61907859e-02f, 2.72194028e-01f, 3.13686699e-01f, 1.17000744e-01f, 1.39189273e-01f, 2.16027901e-01f, 6.44574463e-01f,
  8.54771882e-02f, -7.63224959e-02f, 1.12088844e-01f, 1.56521529e-01f, 5.17561883e-02f, 1.33140236e-01f, 3.08065787e-02f, 1.16568185e-01f, 1.46050632e-01f, 1.16512008e-01f,
  1.00110322e-01f, 8.68112519e-02f, 1.20573185e-01f, 1.26173735e-01f, -9.57823766e-04f, 7.35869631e-02f, -6.81519061e-02f, -2.41320133e-02f, 1.57662168e-01f, 6.57167435e-02f,
  2.62841284e-01f, 2.23636851e-01f, 1.31326869e-01f, 1.94611903e-02f, 1.04796611e-01f, 6.81240559e-02f, 5.47414757e-02f, 1.65319085e-01f, 1.75737500e-01f, 1.84338912e-01f,
  5.44912517e-02f, 7.59762675e-02f, 1.37662271e-03f, -3.23663875e-02f, -4.42377068e-02f, 9.52702165e-02f, 9.03652087e-02f, 2.52433587e-02f, 1.10727869e-01f, 7.74104521e-03f,
  1.81134790e-02f, 1.97781492e-02f, 4.02698182e-02f, 5.73203899e-02f, 3.36466208e-02f, 1.23350285e-01f, 8.56257230e-02f, 1.07483109e-02f, 6.59842193e-02f, 9.28024426e-02f,
  1.00834206e-01f, 1.22660801e-01f, 1.76912129e-01f, 1.03293909e-02f, 7.98524022e-02f, -1.32537093e-02f, 1.06704600e-01f, -4.07625623e-02f, 6.72628731e-02f, 4.06621210e-02f,
  -2.39516050e-01f, -8.59775245e-02f, 9.73268226e-02f, -3.51367728e-03f, 1.67981863e-01f, 8.63939300e-02f, 5.84226996e-02f, 7.68895000e-02f, 8.82586315e-02f, 3.11617609e-02f,
  8.45991448e-02f, 1.04725718e-01f, 7.63039738e-02f, 1.54657140e-02f, 2.97529846e-02f, 6.16505668e-02f, 2.29937602e-02f, 1.62387282e-01f, 4.11865860e-02f, 1.76055267e-01f,
  1.35524914e-01f, 1.18416756e-01f, 1.65883765e-01f, -1.88572146e-02f, 8.31566826e-02f, 8.94071534e-02f, -3.14485375e-03f, 1.20098211e-01f, 3.95312570e-02f, 3.81362587e-02f,
  -3.83285463e-01f, -5.11298239e-01f, 1.36953369e-01f, -3.85656714e-01f, -1.18526496e-01f, -3.98458801e-02f, -3.00082535e-01f, 7.12778047e-02f, -2.32024305e-02f, -1.19154111e-01f,
  -1.81853190e-01f, 1.16481796e-01f, 1.96600437e-01f, 1.75427869e-01f, 1.35980785e-01f, 9.26486775e-03f, -9.20076296e-02f, 1.83291554e-01f, 4.47115213e-01f, 1.02387384e-01f,
  -6.08843938e-02f, -1.79431081e-01f, -2.24852059e-02f, 2.45498523e-01f, -1.50469422e-01f, 9.33529362e-02f, -3.31521891e-02f, -8.68330449e-02f, 2.41879765e-02f, -1.84668094e-01f,
  -5.74603900e-02f, -1.70564711e-01f, 1.83162004e-01f, 4.19071130e-02f, -6.47968128e-02f, 1.05971798e-01f, 4.71068136e-02f, 3.90619710e-02f, 3.10346968e-02f, -1.33755580e-02f,
  -1.24523211e-02f, 3.56823504e-02f, -2.15600915e-02f, 8.62792060e-02f, -7.54220486e-02f, -9.79671138e-04f, 1.23689026e-02f, 1.22371718e-01f, 1.20951325e-01f, 8.04543048e-02f,
  -6.93442896e-02f, -1.12678237e-01f, -7.98217505e-02f, 1.79766696e-02f, 1.08526938e-01f, 1.06223442e-01f, -4.53847907e-02f, 4.45232652e-02f, 1.27958342e-01f, -9.57312658e-02f,
  -1.31689072e-01f, -3.84511650e-02f, 1.53076593e-02f, -1.56847686e-02f, 1.64383370e-02f, 4.39711660e-02f, 9.15106502e-04f, -2.04291521e-03f, 2.87460089e-02f, 5.41714132e-02f,
  7.73157552e-03f, -2.61568744e-02f, 1.05346162e-02f, -3.82679850e-02f, 2.80337017e-02f, -3.57942842e-02f, -4.28929515e-02f, 3.69039848e-02f, 1.19113021e-01f, -7.00188987e-03f,
  7.35368356e-02f, 6.97836578e-02f, -7.06553981e-02f, 5.99466152e-02f, -1.92518327e-02f, -5.16252927e-02f, -7.21181231e-03f, 3.48080732e-02f, -5.91700785e-02f, -7.01730028e-02f,
  1.26127288e-01f, 2.37800211e-01f, -4.28320132e-02f, 9.49490443e-02f, 6.37403354e-02f, 6.45293817e-02f, -6.68071285e-02f, 7.27420524e-02f, 3.52780297e-02f, -6.16496708e-03f,
  -5.00800200e-02f, 2.72896439e-02f, 1.54656954e-02f, 2.67327745e-02f, 1.88703667e-02f, 1.43825011e-02f, 7.76208788e-02f, -2.22542472e-02f, 5.07372916e-02f, -4.49582301e-02f,
  -1.84203777e-02f, 4.30026464e-02f, 1.17910337e-02f, 5.99410683e-02f, -2.12671179e-02f, -3.01419366e-02f, 7.75233358e-02f, 8.09410661e-02f, 2.64227577e-03f, -1.41458631e-01f,
  -5.64816713e-01f, 2.72588432e-01f, 6.23345226e-02f, 1.94992855e-01f, -1.51336059e-01f, -2.28634298e-01f, -5.13883727e-03f, 2.14967132e-01f, 4.40144055e-02f, 2.78640151e-01f,
  2.10844390e-02f, -7.89037123e-02f, 1.94977056e-02f, -8.55450239e-03f, -1.44249886e-01f, -8.11678078e-03f, -5.72838597e-02f, -2.00781673e-01f, -2.88012207e-01f, -1.73952416e-01f,
  -1.04494855e-01f, -1.12542138e-01f, -2.61801243e-01f, -8.56059939e-02f, 6.19784705e-02f, -8.44886303e-02f, 2.04388350e-01f, -7.67197832e-02f, -9.96813551e-03f, 1.24829568e-01f,
  -1.22942235e-02f, -6.08297880e-04f, -7.71942511e-02f, -1.47869885e-01f, 1.04103521e-01f, 6.31065760e-03f, -8.19984823e-02f, 9.50579415e-04f, 4.61780913e-02f, 6.25160262e-02f,
  -2.98938248e-02f, -2.24977694e-02f, -8.74310955e-02f, -2.18830016e-02f, -2.00373698e-02f, -1.01792731e-03f, 8.86756927e-02f, -1.94977876e-02f, -2.46407297e-02f, 1.08725645e-01f,
  -5.81840463e-02f, -3.88757922e-02f, -5.58048710e-02f, 2.76762508e-02f, -5.53997643e-02f, -2.10162714e-01f, 8.47188160e-02f, 6.83003962e-02f, -4.36153561e-02f, 1.68841898e-01f,
  -2.30357163e-02f, 4.35966253e-02f, -9.00023524e-03f, 4.89716902e-02f, 6.88850358e-02f, 5.72294109e-02f, 5.79550713e-02f, 3.02947802e-03f, -4.28453146e-04f, 8.48057866e-02f,
  1.98146747e-03f, 7.21257627e-02f, -1.70705677e-03f, 4.95788939e-02f, 4.71389899e-03f, 5.48034422e-02f, 2.54310924e-03f, 4.86597084e-02f, 5.80165535e-02f, -6.55214908e-03f,
  -1.84695143e-02f, 1.09637585e-02f, -4.86352853e-02f, 4.41525765e-02f, -4.63741906e-02f, 1.36585116e-01f, -5.51982224e-02f, -3.47702913e-02f, -4.52925190e-02f, -3.69428620e-02f,
  1.54734954e-01f, -2.01791808e-01f, -1.26277218e-02f, -6.52542114e-02f, -1.39722191e-02f, 6.48200735e-02f, 1.76598951e-02f, 1.97571721e-02f, -3.97359580e-03f, 1.78933684e-02f,
  -7.08674341e-02f, -2.94774175e-02f, 1.64568108e-02f, 4.17043045e-02f, -7.41401240e-02f, -8.21764022e-02f, 1.06887348e-01f, 1.74130630e-02f, -3.69924568e-02f, 9.98673812e-02f,
  1.35538846e-01f, 2.34336443e-02f, 4.44127619e-02f, 3.02122682e-02f, -1.53803090e-02f, -1.87458992e-01f, 2.87618600e-02f, -1.23623693e-02f, -2.15903029e-01f, 2.76684374e-01f,
  -2.26307467e-01f, 1.22088291e-01f, -6.58986121e-02f, -1.32347107e-01f, -1.73622593e-02f, -2.39573881e-01f, -2.66133457e-01f, -1.78621307e-01f, 9.76906065e-03f, 8.88445601e-02f,
  4.54812557e-01f, 4.17089164e-01f, 2.83255845e-01f, 1.11638010e-01f, -9.76992846e-02f, -1.44835204e-01f, -2.57836282e-01f, -3.11208695e-01f, -1.66384429e-01f, -1.65252879e-01f,
  -4.56819795e-02f, -1.41178310e-01f, -1.19406752e-01f, -6.99811578e-02f, 5.84023967e-02f, 6.44960850e-02f, 1.39523834e-01f, -1.23126611e-01f, 1.56891108e-01f, -3.48697715e-02f,
  2.47546062e-01f, 4.25854027e-02f, -3.97821777e-02f, 6.77758232e-02f, 1.11431241e-01f, -6.06788024e-02f, -3.14502604e-02f, 3.37532759e-02f, 8.45595077e-02f, 2.42794082e-02f,
  3.48373912e-02f, 3.88350412e-02f, 4.80351448e-02f, 3.01742163e-02f, -9.00404677e-02f, 8.94541573e-03f, -8.53727609e-02f, -1.06132962e-01f, -4.37220931e-03f, 5.85136563e-02f,
  1.45678684e-01f, -8.69222358e-02f, -1.50131404e-01f, -3.97816254e-03f, 1.92316249e-02f, 6.84784353e-02f, 4.74561900e-02f, 4.34341393e-02f, 7.64558613e-02f, 3.98424752e-02f,
  -9.90688652e-02f, 5.85738346e-02f, 4.99290600e-02f, 3.24557014e-02f, 5.79649284e-02f, 1.07660234e-01f, 3.87637615e-02f, 6.98643550e-02f, 2.78568640e-02f, -1.68183930e-02f,
  5.45545705e-02f, 7.56616443e-02f, 1.01937220e-01f, 3.13427746e-02f, 9.08066928e-02f, 2.16932707e-02f, 3.58196758e-02f, 8.95461738e-02f, 3.54262516e-02f, 6.28966242e-02f,
  8.56712386e-02f, 3.43887461e-03f, 7.46836811e-02f, 9.34985206e-02f, 4.88050003e-03f, 5.26153371e-02f, 4.61682491e-02f, 9.94688645e-02f, 6.38141111e-02f, 3.23202834e-02f,
  4.67886636e-03f, 6.38998821e-02f, 1.46451388e-02f, -5.92136495e-02f, 5.67197092e-02f, 1.39405746e-02f, 8.70132893e-02f, -6.15070052e-02f, 1.05701432e-01f, -3.93609628e-02f,
  7.58733824e-02f, 7.52607174e-03f, 9.25942212e-02f, 1.28492238e-02f, 1.67196151e-02f, -4.30677012e-02f, -2.70855203e-02f, -5.28602377e-02f, -1.91308521e-02f, 1.43637313e-02f,
  -5.07503562e-02f, -1.37398809e-01f, -1.79543778e-01f, -4.65001538e-02f, -3.30673195e-02f, -4.63875793e-02f, -2.88974755e-02f, -3.13006528e-02f, -4.76739183e-02f, -8.78598765e-02f,
  -4.01456028e-01f, 2.14461625e-01f, 2.62271259e-02f, 3.63950175e-03f, 1.17343785e-02f, -2.36495763e-01f, -1.70731843e-01f, -2.48253301e-01f, -3.79023813e-02f, 7.03520402e-02f,
  1.27112925e-01f, 6.28670305e-02f, 9.34986472e-02f, 5.95511459e-02f, -1.06545545e-01f, 2.49018930e-02f, 5.72953857e-02f, -1.95339203e-01f, -2.65388399e-01f, -1.22160688e-01f,
  9.71558094e-02f, 1.61332767e-02f, -2.55353540e-01f, -5.68245687e-02f, 1.35331154e-01f, -5.26402965e-02f, 2.31621508e-03f, -1.19755082e-02f, 8.09684023e-02f, 3.53685826e-01f,
  1.62938505e-01f, 1.20646678e-01f, -1.84612665e-02f, 1.10340632e-01f, 9.52644423e-02f, 7.45819956e-02f, 5.59272766e-02f, 3.29651237e-02f, 4.49453667e-02f, 5.47924303e-02f,
  1.27383068e-01f, 3.06320693e-02f, 1.81809545e-01f, 1.28146246e-01f, 1.85338911e-02f, -1.71598047e-02f, -5.47224097e-02f, -2.85012648e-02f, 7.32907951e-02f, 5.02237715e-02f,
  2.41902709e-01f, -1.41307397e-03f, -1.52121182e-03f, -1.68586581e-03f, 3.70630622e-02f, 3.06271520e-02f, -2.93115620e-03f, 6.33447841e-02f, -6.30163625e-02f, -4.01713997e-02f,
  -1.46462291e-01f, -3.35088745e-02f, 2.51320563e-02f, -1.11147286e-02f, -6.76508248e-02f, -7.30597740e-03f, 4.51967567e-02f, -3.16759273e-02f, -7.45348306e-03f, -3.00762709e-02f,
  2.36540916e-03f, 5.49467765e-02f, -4.21301322e-03f, -4.17535119e-02f, -3.41692730e-03f, 6.66989014e-02f, -4.02407907e-02f, -1.09525714e-02f, 5.87911084e-02f, -6.10809475e-02f,
  3.85742895e-02f, -2.60573216e-02f, 5.10464981e-02f, -1.54869733e-02f, 2.43274905e-02f, -1.83775816e-02f, -2.23835148e-02f, 6.16592504e-02f, -6.79247677e-02f, 1.64830480e-02f,
  -8.74838829e-02f, -1.00180395e-02f, 9.64083225e-02f, 7.06629071e-04f, 5.10988645e-02f, -2.99841426e-02f, 9.83854532e-02f, 3.87481712e-02f, 1.49423465e-01f, 4.32728007e-02f,
  5.54595981e-03f, 3.14210467e-02f, -4.32184339e-03f, 5.34263300e-03f, -6.50843680e-02f, -2.14971118e-02f, -6.13396289e-03f, 1.80758759e-02f, -4.02377583e-02f, 1.37210181e-02f,
  -4.95811142e-02f, -6.99967593e-02f, -2.22277284e-01f, -6.29391521e-02f, -3.30111794e-02f, -1.02752648e-01f, -5.98686598e-02f, -2.01393217e-01f, -2.70656377e-01f, -3.19089264e-01f,
  -2.64830682e-02f, 3.04588914e-01f, -1.46407038e-01f, 1.55095458e-01f, -2.64702469e-01f, -3.67016435e-01f, -2.12738559e-01f, -7.43636414e-02f, 8.00569281e-02f, 2.07899168e-01f,
  -1.21031523e-01f, -1.37875885e-01f, -1.80095881e-01f, -8.26321170e-02f, -1.91012830e-01f, 1.49019778e-01f, 6.98247775e-02f, 1.37798814e-02f, -3.03194553e-01f, -1.17988043e-01f,
  1.77146018e-01f, 2.04477206e-01f, 1.65056497e-01f, -1.01526566e-01f, 1.31910786e-01f, -6.57818839e-02f, 1.37248874e-01f, 9.31432322e-02f, 4.01186608e-02f, 5.56041658e-01f,
  1.21095292e-01f, 2.37814896e-02f, -1.05034634e-01f, 7.01432526e-02f, -6.15752041e-02f, -2.31241845e-02f, -7.26152882e-02f, 1.19023025e-02f, 1.81661788e-02f, 1.05856374e-01f,
  2.94782501e-02f, 9.08980146e-02f, -3.81024741e-02f, 4.83515672e-02f, 1.00320756e-01f, -5.69675416e-02f, 7.31857195e-02f, 3.21075767e-02f, 1.64561216e-02f, 6.19092695e-02f,
  1.79971829e-02f, 2.23667603e-02f, -1.01036340e-01f, -6.48892820e-02f, -4.99823093e-02f, -8.52123275e-02f, 1.14264600e-02f, 9.61014479e-02f, -3.75524946e-02f, 3.00000280e-01f,
  -4.39694114e-02f, -6.09681569e-03f, 5.33801541e-02f, -1.76358281e-03f, 3.95342335e-02f, 5.64538576e-02f, -2.74999738e-02f, 9.62218717e-02f, 4.50878255e-02f, 5.55692576e-02f,
  1.95680093e-02f, -3.25296931e-02f, 3.72343585e-02f, -4.21491191e-02f, -2.28124149e-02f, 1.98143572e-02f, -3.02169584e-02f, 6.70827329e-02f, 2.44350880e-02f, 3.98259461e-02f,
  1.73631627e-02f, 5.85072525e-02f, -4.28291373e-02f, 6.91476986e-02f, 1.69799738e-02f, -3.84302735e-02f, 2.99075525e-02f, -8.21854398e-02f, -3.30998041e-02f, -9.37471613e-02f,
  1.90950034e-03f, -2.05058292e-01f, 3.33148874e-02f, -6.80567548e-02f, 5.95642254e-02f, 6.67718276e-02f, 1.11591006e-02f, 7.72956340e-03f, 3.36278183e-03f, 4.89459969e-02f,
  -4.65806238e-02f, -6.39258251e-02f, -3.63764027e-03f, 1.34264693e-01f, 9.68719460e-03f, 4.19414900e-02f, 9.14684907e-02f, 2.22236644e-02f, 4.25951481e-02f, 1.03804231e-01f,
  7.58485198e-02f, -2.27910234e-03f, -5.88860102e-02f, 4.68701757e-02f, 4.53710780e-02f, -1.37350932e-01f, -8.23968276e-02f, -4.98413406e-02f, -1.75515443e-01f, 1.09544575e-01f,
  2.15050839e-02f, 3.81338865e-01f, -1.11580409e-01f, 1.25667173e-02f, 9.94180441e-02f, 1.29281819e-01f, 2.45309293e-01f, 5.28471433e-02f, 8.95889848e-02f, 2.59145588e-01f,
  3.68051142e-01f, 1.80944260e-02f, 9.97745395e-02f, -3.00462283e-02f, -1.17511690e-01f, 1.81064710e-01f, -7.18225315e-02f, -3.34528238e-01f, -3.55695546e-01f, -1.89446330e-01f,
  -4.76557128e-02f, 1.59419458e-02f, -1.52625203e-01f, -1.44919390e-02f, 8.66576657e-02f, -7.34136179e-02f, 1.84427455e-01f, 1.11678585e-01f, 2.44039014e-01f, -8.70739482e-03f,
  -5.33886552e-02f, 3.12886447e-01f, 1.94410048e-02f, 1.34095505e-01f, 1.51995450e-01f, 1.50296167e-01f, 1.01788715e-01f, 5.85816950e-02f, 1.65127113e-01f, 1.01750143e-01f,
  1.84464946e-01f, 6.33135140e-02f, 3.89653631e-02f, 3.67321521e-02f, 4.82342020e-02f, 6.24321252e-02f, 2.89677717e-02f, -3.12150791e-02f, 9.30731371e-02f, 2.07242802e-01f,
  1.41693518e-01f, 1.62478819e-01f, 1.85331330e-01f, 1.46947369e-01f, 9.09121037e-02f, 9.29417536e-02f, 1.88801244e-01f, 1.43747941e-01f, 1.48018062e-01f, 2.79193046e-03f,
  -1.43125921e-01f, -4.22214456e-02f, -4.07000333e-02f, -4.17770073e-02f, -4.51495461e-02f, 2.73246188e-02f, -5.91291487e-02f, -1.38652874e-02f, -8.65243822e-02f, -8.83497000e-02f,
  -1.90033838e-01f, -7.39565492e-02f, -6.69087693e-02f, -9.78769455e-03f, -6.80447975e-03f, 2.35949140e-02f, -5.96711300e-02f, -3.49811837e-02f, 1.50701227e-02f, -7.91334435e-02f,
  -1.29050821e-01f, -6.90315962e-02f, -9.79395807e-02f, -1.79666594e-01f, -3.55434306e-02f, -7.95462281e-02f, -2.33131647e-02f, -8.62213448e-02f, -8.90979767e-02f, -4.64163534e-02f,
  1.61402956e-01f, 2.00638145e-01f, 5.80988936e-02f, 2.98511107e-02f, 2.02202827e-01f, 1.61333680e-01f, 1.99567795e-01f, 9.36213806e-02f, 1.86050192e-01f, 1.14828154e-01f,
  1.52204588e-01f, 3.11273970e-02f, 1.84251368e-01f, 6.03428259e-02f, -1.61918607e-02f, 1.70523092e-01f, 2.46564701e-01f, 8.30040127e-02f, 9.65809003e-02f, 1.84667617e-01f,
  1.82442829e-01f, 1.69521555e-01f, 3.36748660e-02f, 1.97053373e-01f, 1.47923768e-01f, 1.04034729e-01f, 8.28903392e-02f, 4.94984984e-02f, 1.48934945e-01f, -1.46977296e-02f,
  -3.34397852e-01f, 4.35604602e-02f, -3.02557290e-01f, 3.05500835e-01f, 2.67085284e-02f, -2.80189663e-01f, -3.89834344e-01f, -8.92848223e-02f, 2.76294738e-01f, 7.84324110e-02f,
  4.14922014e-02f, 2.93954819e-01f, 1.51542306e-01f, 8.49686414e-02f, -2.58094609e-01f, -2.18335599e-01f, -3.86666842e-02f, -2.07002297e-01f, -2.17235506e-01f, -4.58384119e-02f,
  1.84499174e-01f, 2.55263329e-01f, 6.15540184e-02f, -1.90976057e-02f, 3.29533339e-01f, 2.03022659e-01f, -1.31356092e-02f, 1.32957578e-01f, -6.06047772e-02f, 4.84961808e-01f,
  -4.98146005e-02f, -1.46661565e-01f, -2.41284072e-02f, 4.59514745e-02f, 7.16549233e-02f, -1.79578327e-02f, -3.95572893e-02f, 4.43755239e-02f, 1.95957087e-02f, 4.07053791e-02f,
  4.20360789e-02f, 3.69245298e-02f, -2.02209875e-02f, 1.01304390e-01f, 2.96281315e-02f, 1.28028780e-01f, 1.17594957e-01f, 3.90134007e-02f, 5.30442297e-02f, -3.40376906e-02f,
  1.97596222e-01f, 1.80241652e-02f, -4.78477851e-02f, 2.89043002e-02f, -1.18024901e-01f, 5.91063919e-03f, 2.08673882e-03f, 8.95740315e-02f, -1.24370337e-01f, 1.05395816e-01f,
  -3.07958759e-02f, -5.44670820e-02f, -6.25755563e-02f, 2.60427278e-02f, -1.14623513e-02f, -3.27072181e-02f, 4.23633214e-03f, -4.01036665e-02f, 8.53086822e-03f, 3.62836644e-02f,
  3.01567391e-02f, -2.36563403e-02f, -4.67181057e-02f, -3.06854676e-02f, 3.29451896e-02f, -9.42196622e-02f, -7.49320090e-02f, 7.57359993e-03f, 5.79871750e-03f, -5.34096640e-03f,
  1.44583667e-02f, -6.19431026e-02f, -2.81228703e-02f, -2.90302734e-04f, 1.98588818e-02f, -6.27867207e-02f, 6.77237334e-03f, -4.99051646e-04f, -1.18614845e-02f, -1.83977820e-02f,
  1.15937442e-01f, -1.10462591e-01f, 9.59562808e-02f, 6.21185005e-02f, -2.44124215e-02f, 4.35066633e-02f, 5.93116432e-02f, 2.82007698e-02f, 2.68039368e-02f, 3.01789641e-02f,
  7.43839936e-03f, 2.12447029e-02f, -3.35241817e-02f, 1.10702038e-01f, -1.09294532e-02f, 1.88494399e-02f, 9.51964930e-02f, 4.10294831e-02f, 2.96227634e-02f, 9.40288976e-02f,
  1.95981842e-02f, -3.65049616e-02f, -4.15869914e-02f, 5.33706173e-02f, 6.13728315e-02f, -8.40357691e-02f, -1.80517305e-02f, 7.95131698e-02f, -8.39721859e-02f, 2.53835227e-02f
};

// L0_fan_Wp_bar (Shape: 8 x 120)
const int L0_fan_Wp_bar_rows = 8;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -6.74743116e-01f, 4.35193777e-01f, -3.39438200e-01f, -4.10531670e-01f, 4.69022721e-01f, 4.23014581e-01f, 6.68855846e-01f, 3.15613836e-01f, 1.24654733e-01f, 1.05002429e-02f,
  2.72338986e-01f, 2.11485680e-02f, -6.96126297e-02f, 7.42573068e-02f, -4.67362739e-02f, 1.56422302e-01f, 6.09974228e-02f, -3.13654870e-01f, 1.24658294e-01f, 3.86484891e-01f,
  3.80215168e-01f, -1.19840562e-01f, -5.14861226e-01f, -8.26773196e-02f, -1.15311809e-01f, -4.07496560e-03f, -3.59460980e-01f, -2.52812028e-01f, -5.14443517e-02f, -4.45246935e-01f,
  -2.11335883e-01f, -6.04472915e-03f, 1.95366055e-01f, 1.04239710e-01f, -2.42247060e-01f, -3.20740938e-01f, -7.29380324e-02f, -3.15964520e-01f, -1.85108781e-02f, 9.16124787e-03f,
  -2.41604730e-01f, -1.71669185e-01f, -1.34375349e-01f, 6.45798072e-02f, 2.57558911e-03f, 8.10593218e-02f, 1.09331124e-02f, -7.54480138e-02f, -1.66695401e-01f, 2.00811714e-01f,
  1.54031083e-01f, 1.98132873e-01f, -4.45256662e-03f, 3.73028636e-01f, 1.82984991e-03f, -2.74005860e-01f, -5.58748692e-02f, -6.44866899e-02f, -2.13909641e-01f, -5.88739753e-01f,
  1.27271846e-01f, -8.97807777e-02f, -2.15488095e-02f, -9.08164084e-02f, 1.49189875e-01f, 1.86131075e-02f, -8.01256299e-03f, 1.16510116e-01f, 7.63757527e-03f, -1.51917145e-01f,
  1.50495023e-01f, -4.77460548e-02f, 1.83663443e-02f, -6.81758970e-02f, -4.57845926e-02f, -1.44996285e-01f, -1.95773058e-02f, -1.50968879e-01f, 7.96731748e-03f, 8.26056898e-02f,
  6.30334169e-02f, -7.98033774e-02f, -1.17782399e-01f, 1.05676703e-01f, 8.31545293e-02f, 9.16568749e-03f, -2.92785149e-02f, 6.26004413e-02f, 6.19243714e-04f, -1.35659173e-01f,
  -1.35246709e-01f, -1.03579380e-01f, -1.90112859e-01f, 4.72583286e-02f, 1.08616948e-02f, 2.69307315e-01f, -3.62900831e-02f, 1.38456181e-01f, -7.59926736e-02f, 7.03607798e-02f,
  9.72413346e-02f, 4.70562018e-02f, -9.20792595e-02f, 8.22398216e-02f, 1.40634915e-02f, 5.72692044e-02f, 9.91394371e-02f, 6.30922690e-02f, 6.52721450e-02f, 3.07069477e-02f,
  5.49102798e-02f, 1.69789549e-02f, -2.70866007e-01f, -2.49198414e-02f, -1.66586876e-01f, -2.03321248e-01f, -1.92117602e-01f, -1.58427566e-01f, -1.57652915e-01f, -5.23823738e-01f,
  -1.02790952e+00f, -1.44221246e-01f, -3.21625441e-01f, 1.35043308e-01f, 5.06909013e-01f, 5.09591810e-02f, -4.26921755e-01f, -3.13413829e-01f, 1.93854213e-01f, -4.05417353e-01f,
  -3.75116728e-02f, 1.94662631e-01f, 3.69048379e-02f, -3.51781002e-03f, -2.99868673e-01f, -2.13502809e-01f, 3.49289179e-01f, 5.23526222e-02f, 7.08579049e-02f, 1.58865362e-01f,
  5.32177269e-01f, 3.77310187e-01f, 1.83956269e-02f, 1.50942519e-01f, 1.62039787e-01f, 3.97182494e-01f, 6.38827011e-02f, 2.22525403e-01f, -1.03351884e-01f, 1.03782274e-01f,
  -6.95713878e-01f, -6.67957723e-01f, 2.37631217e-01f, 4.24501225e-02f, 1.27130598e-01f, -2.92380363e-01f, -7.95942247e-02f, -2.07765535e-01f, 1.30972981e-01f, -1.13185868e-01f,
  4.38964069e-02f, -9.63671282e-02f, 2.35052466e-01f, 4.55890670e-02f, 1.47883520e-01f, -1.43133566e-01f, -6.40548319e-02f, -2.53088444e-01f, -2.32143372e-01f, -3.04313064e-01f,
  2.21881896e-01f, 3.05001587e-01f, -1.35582313e-01f, -2.58451849e-02f, -3.22632641e-01f, 3.43007118e-01f, -8.95209163e-02f, -1.56398937e-01f, -2.55429745e-01f, -3.64146620e-01f,
  1.27658262e-04f, 1.30990699e-01f, -6.62167743e-02f, -1.08567864e-01f, 6.49183691e-02f, -3.74255888e-02f, -4.27947827e-02f, 1.25203595e-01f, 1.30724519e-01f, -2.69735642e-02f,
  -1.05486855e-01f, -3.88067476e-02f, 1.83856988e-03f, -1.20558821e-01f, 7.36568272e-02f, -1.10105127e-01f, 1.36159807e-01f, -2.55093984e-02f, -4.78406921e-02f, -8.36776495e-02f,
  -1.09315291e-01f, -3.75955589e-02f, 5.23227863e-02f, 6.14196993e-02f, 2.89790295e-02f, -2.22288013e-01f, 9.30543989e-02f, -1.11605108e-01f, 8.37610289e-03f, -7.48602226e-02f,
  2.50003994e-01f, 4.07934368e-01f, -1.66543186e-01f, -1.69693843e-01f, 1.24431243e-02f, 1.00339659e-01f, -4.32526581e-02f, 2.71454221e-03f, -1.04130566e-01f, -1.31417677e-01f,
  -9.10787806e-02f, 6.17335131e-03f, -1.05034500e-01f, 4.89547551e-02f, -6.88202828e-02f, -1.22881055e-01f, 6.26987666e-02f, 1.51481917e-02f, 1.59024253e-01f, 1.53025568e-01f,
  -7.56888688e-02f, -4.88297679e-02f, -1.32109791e-01f, -3.76376987e-01f, 1.69269934e-01f, -8.77276734e-02f, -1.43406376e-01f, -1.13991216e-01f, -2.63491303e-01f, -4.20943826e-01f,
  7.79102325e-01f, 7.83082843e-01f, 2.26637349e-01f, 2.06203058e-01f, 7.45303854e-02f, 2.12634146e-01f, 4.48406994e-01f, 4.11675274e-01f, 1.54961362e-01f, 2.38801137e-01f,
  1.61856502e-01f, 2.03173548e-01f, 9.28644836e-02f, 1.61856502e-01f, 4.41497177e-01f, 3.22319984e-01f, 1.86595827e-01f, 9.51602012e-02f, -1.54267699e-01f, 1.46971881e-01f,
  2.07085073e-01f, 1.76469892e-01f, 1.92852557e-01f, 1.93747148e-01f, 2.39186749e-01f, -1.02127977e-02f, 2.05792874e-01f, 2.65021533e-01f, 1.92193598e-01f, 3.08975428e-01f,
  -9.02268384e-03f, 3.52644116e-01f, -1.17836401e-01f, -9.13069397e-02f, -6.13224395e-02f, 5.14290333e-02f, -5.60963005e-02f, -8.60245228e-02f, -6.47396073e-02f, -8.95012766e-02f,
  -1.32126525e-01f, -1.48693487e-01f, 9.78261605e-03f, -2.08889961e-01f, -8.81513953e-02f, -2.01566413e-01f, 1.77321453e-02f, 1.92648441e-01f, 1.04150519e-01f, 1.78397211e-04f,
  -1.11965043e-02f, -1.25659913e-01f, -2.69738939e-02f, 3.33256721e-02f, 1.59461141e-01f, -2.00234264e-01f, -2.68094484e-02f, 5.27443513e-02f, -2.38913894e-02f, 5.91464564e-02f,
  3.52663398e-02f, 1.41547993e-01f, -6.19209595e-02f, -1.16654053e-01f, -3.54761295e-02f, -1.41354725e-01f, 1.42202061e-02f, -6.85874149e-02f, 4.13004979e-02f, 9.16885212e-02f,
  -2.83079296e-01f, -2.29924358e-02f, -6.55387565e-02f, -9.34267044e-03f, -1.22775570e-01f, -3.82753797e-02f, -9.30332392e-03f, -1.06575467e-01f, -1.21329218e-01f, -5.23471609e-02f,
  -1.03400439e-01f, 2.64316481e-02f, -9.11714062e-02f, 2.28131879e-02f, -4.21193354e-02f, -8.15677558e-05f, -1.15159713e-01f, -1.53696433e-01f, -1.88052729e-02f, -2.28432287e-02f,
  -8.29414874e-02f, -1.11205995e-01f, 7.88262263e-02f, 2.10900709e-01f, 4.03785370e-02f, 3.60936560e-02f, 8.80816579e-02f, -4.56540585e-02f, -4.88258451e-02f, 1.95031520e-02f,
  1.37921507e-02f, -7.36570507e-02f, -8.68091639e-03f, -1.17514454e-01f, -3.54660451e-01f, -1.33176804e-01f, 8.68258700e-02f, 1.49012461e-01f, 8.74801204e-02f, -9.31395516e-02f,
  -4.69442010e-02f, -1.35823593e-01f, -2.33048186e-01f, -1.32163942e-01f, 1.09687867e-02f, -2.48806760e-01f, -1.96201414e-01f, -1.42226443e-01f, -2.80531824e-01f, -3.38887632e-01f,
  5.87043881e-01f, 1.01074293e-01f, -1.27852166e+00f, 2.60449111e-01f, -6.35740817e-01f, -1.24409020e-01f, 2.57275760e-01f, 5.89306653e-01f, 2.27257460e-01f, -5.83266318e-02f,
  -1.98943056e-02f, 2.23881841e-01f, -6.08996605e-04f, 1.10707618e-01f, 5.38570248e-02f, -3.83729160e-01f, -5.71569264e-01f, -5.02593219e-01f, -9.88031086e-03f, 2.62970805e-01f,
  3.46576512e-01f, 3.39069158e-01f, 3.83792251e-01f, 5.05909212e-02f, -3.40480059e-02f, -7.49250278e-02f, -3.90680045e-01f, -1.46557391e-01f, -3.04232180e-01f, -7.03330696e-01f,
  -3.85310709e-01f, -2.31334776e-01f, -6.03943970e-03f, 1.43065810e-01f, -1.29879624e-01f, 7.25788847e-02f, -2.81269476e-02f, -9.23939571e-02f, 3.28223296e-02f, -4.79093790e-02f,
  -1.34770066e-01f, 5.72328381e-02f, -4.17138003e-02f, -2.25027967e-02f, -4.03070226e-02f, 1.82243630e-01f, 1.80004314e-02f, -2.64082905e-02f, -3.37921456e-03f, -1.29552692e-01f,
  -3.56083387e-03f, -3.46877098e-01f, -3.76086444e-01f, -6.86809719e-02f, -2.60583639e-01f, -2.75912017e-01f, -2.38830894e-01f, -2.64483899e-01f, -2.63297766e-01f, -3.50686498e-02f,
  -8.10986236e-02f, 2.86446176e-02f, 9.68617480e-03f, -5.26400506e-02f, 2.80119777e-01f, -1.25355437e-01f, -1.25284567e-01f, 1.86219048e-02f, 1.30057633e-01f, 3.29336338e-02f,
  -1.07635424e-01f, 1.85987179e-03f, 4.00057733e-02f, -2.47725919e-02f, -1.69868916e-02f, -1.82981506e-01f, -7.13298470e-02f, 1.11435905e-01f, -2.17156252e-03f, 5.95513806e-02f,
  9.90167931e-02f, -6.45512342e-02f, -6.88467771e-02f, 1.99186414e-01f, -6.40370399e-02f, -4.26712781e-02f, 1.33123966e-02f, 5.16396165e-02f, 1.77433476e-01f, 1.91587154e-02f,
  5.97813427e-01f, -6.54628593e-03f, 1.07323229e-02f, 1.40928954e-01f, -1.10881008e-01f, -3.01305410e-02f, -1.17056385e-01f, 3.08701899e-02f, 8.33865404e-02f, 1.10364318e-01f,
  4.94426005e-02f, -1.61271114e-02f, 5.12682609e-02f, 6.29331023e-02f, 8.71519893e-02f, 4.51304875e-02f, 1.52596816e-01f, -1.48987053e-02f, 2.67742217e-01f, 1.11780740e-01f,
  2.71191210e-01f, 3.21128964e-01f, 2.36318499e-01f, 7.06986785e-02f, 1.98499396e-01f, 7.74095803e-02f, -2.61542257e-02f, 2.05471948e-01f, 3.88766336e-03f, 4.23199028e-01f,
  3.56353726e-03f, 1.28357247e-01f, 2.68341362e-01f, -3.58130693e-01f, 4.71891642e-01f, 5.66746473e-01f, 7.29013383e-01f, 1.31652594e-01f, -2.38081157e-01f, 1.35151327e-01f,
  1.40344813e-01f, -3.54645848e-01f, -3.10175747e-01f, -2.40564078e-01f, 1.54806271e-01f, 1.85074151e-01f, 2.22246312e-02f, 4.84977253e-02f, 8.69949758e-02f, 2.39208657e-02f,
  -1.53219789e-01f, -9.60242227e-02f, -1.01132892e-01f, -2.74788350e-01f, -3.90453398e-01f, -3.85437965e-01f, 2.71961838e-02f, 1.39151752e-01f, 3.26117367e-01f, -3.80817562e-01f,
  -3.03678513e-01f, 8.65601003e-02f, -2.77868778e-01f, -1.06642269e-01f, 1.08709693e-01f, -1.31102458e-01f, -1.50431264e-02f, -4.69008759e-02f, 1.23917282e-01f, -6.66930825e-02f,
  7.60082342e-03f, 1.22836627e-01f, 6.21204525e-02f, 1.28590718e-01f, 1.94277704e-01f, 1.30171880e-01f, 9.40038860e-02f, 2.31674034e-03f, -6.85059801e-02f, 6.44289795e-03f,
  1.18161635e-02f, 2.80873775e-01f, 2.21722782e-01f, 4.08556424e-02f, 1.62371218e-01f, 5.19459657e-02f, -1.00501683e-02f, 6.15706854e-03f, 1.76313341e-01f, -1.70285165e-01f,
  -9.01390612e-02f, 2.48291157e-02f, 2.19704174e-02f, 4.75322269e-02f, 4.99248840e-02f, -5.70447035e-02f, -1.33728191e-01f, 3.55742797e-02f, -6.65789470e-03f, 1.37491688e-01f,
  4.17363568e-04f, 7.38307089e-02f, -1.69991925e-02f, 9.65081621e-03f, -1.14072338e-01f, 1.64944567e-02f, 8.15898255e-02f, -2.82726418e-02f, 9.12053138e-02f, 5.36716497e-03f,
  1.54645577e-01f, -4.57129218e-02f, -4.53397706e-02f, -2.95115598e-02f, 1.89246476e-01f, -9.96854678e-02f, -6.49228245e-02f, 4.77558672e-02f, -2.44966336e-02f, 3.74652483e-02f,
  -4.03193951e-01f, 3.78879964e-01f, -2.78823793e-01f, -4.18808348e-02f, 2.32309289e-02f, -3.54087204e-02f, -1.28203675e-01f, -1.62260488e-01f, -1.04585201e-01f, -9.27262008e-02f,
  2.01373491e-02f, -1.42827496e-01f, 7.62055740e-02f, 5.31867705e-02f, -1.13318659e-01f, 9.59089920e-02f, 1.49025414e-02f, -6.50279969e-02f, 1.65281203e-02f, -1.94570735e-01f,
  -6.77693933e-02f, -1.59034040e-03f, -1.25588197e-02f, -1.13278218e-01f, -1.71356201e-01f, -3.43811475e-02f, 4.40800115e-02f, 1.37787862e-02f, 1.74357966e-01f, -1.73586383e-01f,
  -1.00430012e+00f, -1.91213205e-01f, -2.85560459e-01f, -3.30896080e-01f, -2.37306669e-01f, 4.16750787e-03f, -4.74898934e-01f, 3.37327361e-01f, 2.69058019e-01f, -5.67428589e-01f,
  -3.27950776e-01f, -1.10571861e-01f, -3.06662887e-01f, -1.19990177e-01f, -1.86764032e-01f, -6.36079669e-01f, -5.77502310e-01f, -4.44000602e-01f, -3.90914530e-02f, 1.87116325e-01f,
  -3.07083756e-01f, -4.99001145e-01f, -3.56099516e-01f, 8.85545239e-02f, -3.17371786e-02f, 1.61303189e-02f, -4.02409106e-01f, -1.18413270e-01f, 2.32197195e-01f, -4.80328590e-01f,
  -4.78837043e-01f, 2.71116525e-01f, -2.61787139e-02f, -1.50431499e-01f, -1.48072749e-01f, 1.60098046e-01f, 5.60416728e-02f, 1.08439557e-01f, 6.01509884e-02f, -1.73906293e-02f,
  -3.61418501e-02f, 2.54598320e-01f, 6.81060478e-02f, 1.24134133e-02f, -8.86252820e-02f, -3.15680988e-02f, 1.97215602e-02f, -6.29500002e-02f, 8.98909122e-02f, 1.24689683e-01f,
  7.24709705e-02f, -8.16420838e-03f, 1.26826659e-01f, 1.44210248e-03f, 2.39201173e-01f, -4.54624891e-02f, 2.17625380e-01f, 2.81045079e-01f, 2.82287389e-01f, 6.84761778e-02f,
  -1.56049535e-01f, -8.55321065e-03f, 3.57214250e-02f, 1.34323955e-01f, -1.16358526e-01f, 2.70547736e-02f, -1.37408614e-01f, -4.75300364e-02f, -3.26094255e-02f, -9.84297842e-02f,
  2.54146941e-02f, 2.94937026e-02f, -4.14125510e-02f, 1.11711947e-02f, -1.13279617e-03f, -3.91162448e-02f, 2.02943888e-02f, -4.94473502e-02f, 5.49851209e-02f, -3.88449640e-03f,
  1.42354025e-02f, 2.17104539e-01f, -4.51887846e-02f, -3.25494725e-03f, 5.82132079e-02f, -7.53136724e-02f, 5.34820780e-02f, 1.12803511e-01f, 4.40069623e-02f, 6.53573498e-02f,
  -1.60708383e-01f, -2.40901988e-02f, -2.46873900e-01f, 1.03677981e-01f, 5.66382473e-03f, -1.81897264e-02f, -8.12018290e-02f, 1.37665169e-02f, -3.57671604e-02f, -4.37432751e-02f,
  1.51522383e-01f, -6.48851916e-02f, -3.31316656e-03f, 2.09890287e-02f, -4.97537330e-02f, -1.54267214e-02f, -2.58144885e-02f, -1.35091722e-01f, 1.43488571e-01f, 2.17562586e-01f,
  8.58540684e-02f, -1.45994812e-01f, -2.79194146e-01f, -2.40370557e-01f, 1.05333172e-01f, -5.85279986e-02f, -2.40136087e-02f, 1.37586951e-01f, 4.73923311e-02f, -3.42763752e-01f,
  5.72570503e-01f, -5.19179583e-01f, -2.22025812e-01f, -1.42738253e-01f, 1.79172009e-01f, 3.80097926e-01f, -1.40088573e-01f, 2.64396846e-01f, 2.78758168e-01f, -1.35723874e-01f,
  1.13604702e-01f, 3.82143557e-01f, 1.12248987e-01f, 1.10477090e-01f, 2.02185318e-01f, -5.15992761e-01f, -4.65612710e-01f, 7.97907487e-02f, 5.58634579e-01f, 5.45945585e-01f,
  8.30034614e-02f, -1.97222412e-01f, -1.71441659e-01f, -4.71419990e-02f, -2.07317710e-01f, 7.51582384e-02f, -4.99549538e-01f, -3.25267136e-01f, -1.76742613e-01f, -8.06918383e-01f,
  -1.61124602e-01f, -4.28209677e-02f, 1.58565700e-01f, 1.40883088e-01f, -2.09680185e-01f, -1.04945816e-01f, 2.32573245e-02f, -1.02600478e-01f, -2.50201188e-02f, 1.89974699e-02f,
  -5.75032458e-02f, -2.80815158e-02f, -6.48057982e-02f, -1.10094488e-01f, 6.48404062e-02f, 9.07892883e-02f, -8.29942990e-03f, 5.54014519e-02f, 2.12545265e-02f, 4.85879183e-03f,
  -1.62679348e-02f, 1.02424160e-01f, 2.68583477e-01f, 1.55692011e-01f, 1.51153848e-01f, 2.35180333e-01f, -3.45454477e-02f, 1.98779315e-01f, 2.15025187e-01f, 1.28193796e-01f,
  6.28060475e-03f, -5.76997958e-02f, 6.95137307e-02f, 1.40923828e-01f, 5.29086106e-02f, 8.55861977e-02f, -4.08321843e-02f, 5.09223007e-02f, 1.16613634e-01f, 5.28964736e-02f,
  4.60913256e-02f, -5.50935492e-02f, -5.78355379e-02f, 1.33381691e-02f, 8.88869911e-03f, 1.48283213e-03f, -4.73911315e-02f, 1.46577368e-02f, -9.23706277e-04f, -2.87562292e-02f,
  1.26737535e-01f, 6.45136507e-03f, -1.97466955e-01f, -5.88082559e-02f, -9.53201652e-02f, 1.05620191e-01f, -1.01530226e-02f, -7.22469315e-02f, -1.18336812e-01f, -2.12162342e-02f,
  -1.71605587e-01f, 1.17150575e-01f, -3.51504534e-02f, 3.94985527e-02f, -1.14250466e-01f, -8.95608142e-02f, -1.34559691e-01f, -9.08811316e-02f, -1.69371009e-01f, 6.85091782e-03f,
  1.09444242e-02f, -1.20753966e-01f, -1.57447323e-01f, -3.00894044e-02f, 6.98401704e-02f, 9.73549932e-02f, -6.05319673e-03f, 8.71038511e-02f, -1.39236161e-02f, -8.83980095e-02f,
  -1.70269802e-01f, 1.56763598e-01f, 2.41222143e-01f, 5.15244789e-02f, 5.73663414e-02f, 2.19227925e-01f, -7.96036124e-02f, 1.14806607e-01f, 7.00348169e-02f, -9.76408422e-02f,
  -1.36574340e+00f, 2.85033166e-01f, -3.80418114e-02f, -6.80142939e-01f, -7.61931241e-02f, 4.15785670e-01f, 6.58203602e-01f, 1.12607770e-01f, -3.57861549e-01f, -3.73133533e-02f,
  9.62888822e-02f, -1.49047505e-02f, -4.58185337e-02f, 2.55881459e-01f, 2.85553813e-01f, 2.95386642e-01f, 6.10261671e-02f, -1.26445204e-01f, 7.42196366e-02f, 3.12304765e-01f,
  2.43263721e-01f, -1.26475722e-01f, -3.55435818e-01f, -1.67959139e-01f, -2.14788064e-01f, -9.84985381e-02f, -1.88022992e-03f, 1.48916077e-02f, 2.80058533e-01f, -5.69100715e-02f,
  3.98120463e-01f, -3.21083993e-01f, 3.18423994e-02f, -3.57779376e-02f, -1.15190096e-01f, -2.56624013e-01f, -3.17673758e-02f, -1.91677108e-01f, -9.94780734e-02f, 7.94933736e-02f,
  -4.25505415e-02f, -1.17314775e-02f, -1.08207978e-01f, 4.62893844e-02f, -5.89206032e-02f, -1.49955079e-01f, -9.83570740e-02f, -7.93488771e-02f, 4.39497977e-02f, 2.57430673e-01f,
  4.90420684e-02f, 7.46518597e-02f, 2.23873049e-01f, 2.50439882e-01f, 2.59073023e-02f, -2.88728047e-02f, 9.14654657e-02f, 3.00820488e-02f, 1.38726771e-01f, -1.31786808e-01f,
  -1.13971971e-01f, -5.78668676e-02f, 1.53509155e-02f, 1.72679499e-02f, -7.66513497e-02f, -6.15980886e-02f, 4.64240164e-02f, 5.84706143e-02f, 1.06666267e-01f, -6.56810254e-02f,
  -8.36071521e-02f, 8.12120512e-02f, -5.32869203e-03f, -1.28048390e-01f, -1.53879430e-02f, -1.45445680e-02f, 3.95842642e-02f, 4.02592532e-02f, -6.61740676e-02f, -5.50513081e-02f,
  -5.57004660e-02f, 8.55765585e-03f, -1.19981669e-01f, 6.53153360e-02f, 9.54780281e-02f, -1.06543481e-01f, -1.39940912e-02f, 6.73578978e-02f, 2.85553690e-02f, -4.62274775e-02f,
  2.36463383e-01f, -4.89161424e-02f, -1.09136254e-01f, 5.46567841e-03f, -1.34056285e-01f, -1.45936564e-01f, -1.10395193e-01f, -1.70636903e-02f, 3.53699625e-02f, 1.40005365e-01f,
  6.92592040e-02f, -7.53394887e-02f, -9.28314626e-02f, -2.44698003e-02f, -4.99290973e-02f, 1.16534419e-02f, 5.80839254e-03f, -2.41195541e-02f, 1.79948851e-01f, 6.93258122e-02f,
  2.15230491e-02f, 7.93318748e-02f, 4.55335490e-02f, -9.55158006e-03f, -1.29803540e-02f, -1.08901285e-01f, 1.52458072e-01f, 6.39514104e-02f, 1.01261422e-01f, 1.82417184e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 8)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 8;
const float L0_fan_Bp_bar_data[] = {
  3.85401934e-01f, 5.12455165e-01f, 3.41465175e-01f, 6.26658678e-01f, 7.71782219e-01f, 2.39427611e-02f, 4.62418050e-01f, 4.80278909e-01f
};

// L1_fan_Wp (Shape: 12 x 32)
const int L1_fan_Wp_rows = 12;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  9.14477557e-03f, -1.41176090e-01f, -4.71955091e-02f, 1.31705433e-01f, 1.16155125e-01f, -8.27922225e-02f, 4.36793305e-02f, 1.57834589e-01f, 3.21718931e-01f, -1.01295672e-01f,
  -9.63659510e-02f, -1.20842762e-01f, 2.61411637e-01f, -5.65448850e-02f, -7.78078437e-02f, -1.01285227e-01f, -1.13012306e-01f, -9.63455141e-02f, 2.41510779e-01f, 1.66661397e-01f,
  1.38201237e-01f, 7.59337619e-02f, 7.35543445e-02f, 8.72815996e-02f, -4.63695545e-03f, 2.35360458e-01f, -1.02209128e-01f, 2.62039572e-01f, 1.99389011e-02f, 1.13381378e-01f,
  3.36322248e-01f, 2.05353007e-01f, 1.86680146e-02f, 1.76704034e-01f, -3.73728544e-01f, -1.16000518e-01f, 1.06946096e-01f, -1.23794535e-02f, 3.04471582e-01f, 1.21333078e-01f,
  -1.03444941e-01f, 6.74762651e-02f, 1.39984518e-01f, -3.33494283e-02f, -2.60343432e-01f, 3.75274047e-02f, -5.23334667e-02f, 2.01726869e-01f, 1.46577224e-01f, -4.08807695e-01f,
  -2.58662820e-01f, 8.77144188e-02f, 3.71166617e-01f, 3.39138865e-01f, 4.63070022e-03f, 3.60676378e-01f, -3.67192745e-01f, 2.70917654e-01f, 5.53120896e-02f, -1.94022641e-01f,
  3.32965255e-01f, -2.40908146e-01f, -1.13393448e-01f, -2.24277779e-01f, 1.73431277e-01f, 9.51797068e-02f, 2.74712741e-01f, -7.45110512e-02f, 9.68938842e-02f, 7.50883669e-02f,
  1.05323032e-01f, 1.91702187e-01f, 4.34915274e-02f, 1.18431533e-02f, -4.07770723e-02f, 2.47983456e-01f, 7.88217932e-02f, -2.63177902e-01f, 2.44798809e-01f, 1.27687752e-01f,
  4.76353206e-02f, -1.29696086e-01f, -2.00632870e-01f, -1.95361897e-01f, 3.02177202e-02f, 1.79775715e-01f, -8.36355612e-02f, 1.32841989e-01f, -5.38821995e-01f, -3.88407886e-01f,
  2.83213019e-01f, 1.72758520e-01f, -6.31045038e-03f, -1.01425193e-01f, 1.60943985e-01f, -2.43094116e-01f, 8.94642994e-02f, -7.64233023e-02f, 2.62864888e-01f, -8.28169361e-02f,
  8.90489575e-03f, -5.29080443e-02f, -1.39384791e-01f, -3.57786678e-02f, -4.05231901e-02f, 2.69598197e-02f, 3.22598852e-02f, 2.39246408e-03f, -2.38179862e-01f, -1.03806339e-01f,
  1.13940187e-01f, -2.60105934e-02f, -9.18350369e-02f, -1.79895490e-01f, 7.85247087e-02f, 8.88241734e-03f, 9.63431820e-02f, 3.83804664e-02f, 6.87165335e-02f, 2.28048451e-02f,
  -2.68551677e-01f, -5.74849427e-01f, 1.35012716e-01f, 1.73281897e-02f, 3.37619819e-02f, -2.55446613e-01f, -4.74942535e-01f, 3.04374635e-01f, -4.27593738e-02f, 6.63442910e-02f,
  -5.52128907e-03f, 1.60008520e-01f, -8.28703307e-03f, 2.66999096e-01f, -3.47670346e-01f, -1.70726553e-01f, -6.31167963e-02f, -5.59763610e-02f, 5.26271164e-02f, 5.69913238e-02f,
  -1.03196427e-01f, -1.83714405e-02f, 3.40441950e-02f, -5.84647357e-02f, -2.46266574e-02f, -2.35270634e-01f, 2.53191203e-01f, 3.87507118e-02f, 7.28376508e-02f, -2.19751433e-01f,
  1.13040842e-01f, 2.08853036e-01f, -1.43592671e-01f, 2.38646820e-01f, -6.96252957e-02f, 3.20502341e-01f, -4.92743254e-01f, 3.35994005e-01f, -1.89839229e-01f, -4.29517955e-01f,
  1.43652661e-02f, 4.30469438e-02f, 3.16752702e-01f, -2.20027044e-01f, 1.05104074e-01f, -2.84369856e-01f, 3.39116842e-01f, 2.60496706e-01f, 1.79325789e-01f, -1.59882605e-01f,
  9.81908757e-03f, 1.42499715e-01f, 3.57283860e-01f, -8.97427648e-02f, 2.40622699e-01f, 2.22352982e-01f, 4.32176404e-02f, 2.21988142e-01f, 2.06262479e-03f, 1.64510846e-01f,
  -1.68561071e-01f, -1.82369929e-02f, -1.09138805e-02f, 5.49913337e-03f, -3.31348747e-01f, -5.32819271e-01f, 2.04972073e-01f, 2.34977692e-01f, 2.55225480e-01f, -3.15682471e-01f,
  -1.75324932e-01f, 4.03513879e-01f, -7.74836615e-02f, -1.36925831e-01f, -1.08955152e-01f, 6.12923726e-02f, 8.07870179e-02f, -1.79727405e-01f, 1.09640649e-02f, -2.00580675e-02f,
  9.45070162e-02f, 5.99211529e-02f, -1.50984645e-01f, -3.75872925e-02f, -1.85327232e-02f, -8.70162994e-02f, -3.23347077e-02f, 3.63124348e-02f, -4.07357663e-02f, 4.01291221e-01f,
  -5.85621968e-02f, -1.95020344e-02f, 5.37857190e-02f, -2.26978689e-01f, 1.30747706e-01f, -1.11371674e-01f, 4.56128687e-01f, 2.04603195e-01f, -8.33885744e-02f, -6.20398045e-01f,
  -4.53815788e-01f, 2.74092644e-01f, 3.58841926e-01f, 2.51964301e-01f, 2.86845844e-02f, 7.49481423e-03f, -9.74529982e-02f, -2.28571311e-01f, 2.35358074e-01f, -2.64032602e-01f,
  2.35712677e-01f, 1.64757624e-01f, -4.71550636e-02f, -3.52600962e-01f, -2.74074197e-01f, -1.35108754e-01f, 2.36178443e-01f, -1.68071780e-02f, 2.09928006e-01f, 2.13627607e-01f,
  1.13974772e-01f, -3.29308175e-02f, -5.12165070e-01f, 1.25982344e-01f, 9.89577547e-03f, -2.50535041e-01f, 1.73319280e-02f, 6.37293234e-02f, -9.09179747e-02f, -6.49040580e-01f,
  2.98670441e-01f, -6.17122091e-02f, 4.17777508e-01f, 5.08175232e-03f, 9.54546034e-02f, -7.88787007e-02f, -1.17829740e-01f, 1.12991162e-01f, -3.14681888e-01f, -1.38051376e-01f,
  1.60507172e-01f, -1.25559837e-01f, 4.14194822e-01f, 1.49800479e-01f, 2.51029134e-01f, -1.41393244e-01f, -5.41383810e-02f, -1.76199954e-02f, 2.49874983e-02f, 1.95261389e-01f,
  7.77597353e-02f, -1.86799280e-02f, 1.73043311e-02f, -5.75986989e-02f, 2.08384514e-01f, 7.63195334e-03f, -7.27862641e-02f, 3.30866426e-01f, -5.17299473e-02f, 2.45156229e-01f,
  2.44173795e-01f, 3.19340885e-01f, 1.28627894e-02f, 2.85982013e-01f, -3.62347275e-01f, 3.10716838e-01f, 1.75020322e-01f, -1.23020351e-01f, 1.63497195e-01f, -4.02346402e-02f,
  3.26040447e-01f, 3.50120328e-02f, 7.11334497e-02f, 5.41815087e-02f, -1.01663463e-01f, 1.05787218e-01f, 1.59222372e-02f, 2.44840831e-01f, -1.43461423e-02f, 1.16918109e-01f,
  4.08309609e-01f, -1.64737523e-01f, 1.21778242e-01f, 1.28354087e-01f, 3.99732776e-02f, 4.69096124e-01f, -1.70407861e-01f, -7.14224353e-02f, -1.69721797e-01f, -3.38788062e-01f,
  3.84239964e-02f, -2.27874398e-01f, 5.93428873e-02f, 5.28126664e-04f, -1.05615929e-01f, -2.97469854e-01f, 3.35135132e-01f, 2.08272517e-01f, 2.30210632e-01f, -2.12154225e-01f,
  6.48253337e-02f, 2.47478068e-01f, 2.25517944e-01f, -8.89334157e-02f, -7.65668079e-02f, 7.29022697e-02f, -2.91999698e-01f, 1.31134549e-02f, -3.94581631e-02f, -2.34676689e-01f,
  -7.92377815e-02f, 9.87003297e-02f, -2.19546080e-01f, 9.59540755e-02f, 2.05081850e-01f, -4.18837406e-02f, -1.10243917e-01f, -4.92975861e-01f, 3.00648749e-01f, 3.64540587e-03f,
  4.92110290e-02f, 4.43928987e-01f, 3.61483470e-02f, 3.56801957e-01f, -2.74115980e-01f, -1.18480019e-01f, 1.17057964e-01f, 2.20845789e-01f, -2.45800242e-01f, -6.56905845e-02f,
  6.61891624e-02f, -3.25058877e-01f, 4.68177646e-02f, 1.22753210e-01f, -3.79339606e-03f, 1.57128170e-01f, 5.54037988e-02f, -1.48965701e-01f, -1.54871300e-01f, 2.19882689e-02f,
  -1.39279589e-01f, -3.57365012e-02f, -1.42365322e-01f, -1.02072082e-01f, -7.77541846e-02f, 2.74298266e-02f, 1.32639349e-01f, -2.14438468e-01f, -1.75275326e-01f, -3.24462444e-01f,
  3.38782281e-01f, 1.07708469e-01f, 3.01058218e-03f, 4.52913165e-01f, 2.63534695e-01f, 3.13556284e-01f, 3.58050585e-01f, 3.53352427e-01f, -6.90815523e-02f, -6.57553971e-02f,
  3.16155523e-01f, 3.24402213e-01f, -2.71890789e-01f, -7.64563009e-02f
};

// L1_fan_Wp_bar (Shape: 8 x 32)
const int L1_fan_Wp_bar_rows = 8;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  7.36325905e-02f, 3.34650159e-01f, -4.67363477e-01f, -2.04230696e-01f, 2.23595902e-01f, 4.15407598e-01f, -8.72813538e-02f, 9.56386849e-02f, -2.19939753e-01f, 4.24655080e-02f,
  2.39743337e-01f, 1.52546810e-02f, -2.87099987e-01f, 1.11700632e-01f, -5.11984378e-02f, 3.84854048e-01f, 2.54742414e-01f, -5.16722441e-01f, 4.53280024e-02f, 1.76103100e-01f,
  4.97779191e-01f, 5.72520554e-01f, -1.94126099e-01f, 4.04326171e-01f, 6.21930480e-01f, 2.72085220e-01f, 5.55545568e-01f, -4.98103499e-01f, -3.73517334e-01f, 3.05612367e-02f,
  -2.33183831e-01f, 4.02578294e-01f, -3.35379690e-02f, 1.92355597e-03f, -1.54557467e-01f, -3.46754998e-01f, 1.27387434e-01f, 8.51403326e-02f, 6.10847883e-02f, 2.61817068e-01f,
  -1.17775217e-01f, 3.05208296e-01f, 4.41619158e-01f, 2.26492435e-01f, -8.28643739e-02f, -9.16053355e-03f, 1.77582309e-01f, -8.21227266e-04f, -5.07934056e-02f, 3.36046129e-01f,
  4.05633971e-02f, -9.18000117e-02f, -1.55616999e-01f, -5.15985548e-01f, 1.92035571e-01f, -1.46080449e-01f, 1.39540398e+00f, 4.49544191e-01f, 2.33130276e-01f, 8.43212903e-01f,
  3.63816768e-02f, 1.22417057e+00f, 8.52472901e-01f, 1.69309285e-02f, -8.23994447e-03f, -1.03932239e-01f, 2.34881058e-01f, -3.36165816e-01f, 5.29283941e-01f, 3.01200151e-01f,
  5.30999720e-01f, 6.61308527e-01f, 6.60747409e-01f, 7.41835535e-02f, 4.52655181e-02f, 7.57378697e-01f, 5.16582191e-01f, -2.37964734e-01f, 2.32064843e-01f, -1.10049658e-01f,
  -4.63064373e-01f, 6.63056731e-01f, 2.67211616e-01f, -2.10536510e-01f, -2.32255429e-01f, -1.35262728e-01f, -1.86473384e-01f, -1.36886433e-01f, -5.96121907e-01f, 2.19514430e-01f,
  2.13924751e-01f, 7.99684048e-01f, -6.21288061e-01f, -5.17252743e-01f, 1.36210486e-01f, 1.15055904e-01f, 4.75954533e-01f, 3.28240991e-01f, 6.64200962e-01f, 2.93296009e-01f,
  8.97820201e-03f, 8.65193546e-01f, -8.62352997e-02f, -8.46047550e-02f, -8.22852850e-02f, 5.34130454e-01f, 7.20217347e-01f, 4.09155488e-01f, -1.19756155e-01f, 6.72481239e-01f,
  -7.55937696e-01f, -3.91972810e-01f, -4.19530906e-02f, 1.32036969e-01f, 3.43038797e-01f, -5.08445576e-02f, -3.44957888e-01f, -5.47573864e-01f, 1.86461017e-01f, -5.96864879e-01f,
  2.66314149e-01f, -5.88440180e-01f, -4.32831854e-01f, 1.03091133e+00f, 3.54778133e-02f, 2.62644261e-01f, 7.92071130e-03f, 8.40965390e-01f, 6.92802370e-02f, 1.33305475e-01f,
  2.10362189e-02f, -8.26638713e-02f, 1.27464786e-01f, 2.05320194e-01f, 3.14344436e-01f, 3.63605376e-03f, 4.81107309e-02f, 5.07609248e-01f, 1.63039222e-01f, -3.44634131e-02f,
  -7.77307630e-01f, 8.29978101e-03f, -4.55950260e-01f, -2.61237651e-01f, -2.07312226e-01f, -3.20610851e-01f, -7.92128742e-02f, -3.91574264e-01f, -6.04027249e-02f, -2.99356848e-01f,
  2.53651589e-01f, -5.43308377e-01f, 7.99256921e-01f, 2.47940943e-01f, -1.00422017e-01f, 4.50401120e-02f, 8.90146613e-01f, -2.64966547e-01f, -2.65580297e-01f, 1.06509817e+00f,
  1.65799648e-01f, 3.32120717e-01f, 4.41494316e-01f, 1.13251515e-01f, 4.29933429e-01f, -2.77965516e-01f, 7.77387917e-02f, 6.13274276e-01f, 4.06248927e-01f, 5.20216048e-01f,
  1.67301875e-02f, 5.47834113e-02f, -4.91262274e-03f, -2.76004046e-01f, 3.61523628e-01f, 3.15575510e-01f, -1.49842054e-01f, -4.09109086e-01f, -1.86897054e-01f, 1.51638007e-02f,
  -2.65514284e-01f, -2.94204950e-01f, 4.75726753e-01f, -3.98168862e-01f, 1.16487324e-01f, -8.41318965e-01f, 3.50802213e-01f, 5.65873086e-01f, 6.12349212e-01f, 6.23556972e-01f,
  -1.44807339e-01f, -2.78729349e-01f, 1.18813969e-01f, -4.39927094e-02f, 1.38144553e-01f, -3.99833530e-01f, 1.52066294e-02f, 3.58191490e-01f, 3.07091117e-01f, 2.14223508e-02f,
  2.43469551e-01f, 1.61728889e-01f, 6.35417476e-02f, 1.48656800e-01f, -4.89334822e-01f, 1.81807637e-01f, -3.19652885e-01f, 9.55847353e-02f, 2.54327357e-02f, -3.44243139e-01f,
  -2.77626127e-01f, -4.81030971e-01f, -3.42074454e-01f, -2.52048492e-01f, -2.31388137e-01f, -3.64486188e-01f, -2.07715079e-01f, -2.18165696e-01f, 2.06162930e-01f, 9.71774936e-01f,
  3.78060371e-01f, -2.15434670e-01f, 5.78914821e-01f, -4.72921669e-01f, 4.36844826e-01f, 1.16990142e-01f, 2.28999540e-01f, 3.96443963e-01f, 8.11577588e-03f, 7.48969734e-01f,
  2.92761058e-01f, 2.75366269e-02f, -1.63897648e-01f, 5.14627934e-01f, 3.91635329e-01f, 3.27556916e-02f, -2.65244752e-01f, 3.15546751e-01f, -1.49845675e-01f, 7.90577084e-02f,
  2.06216127e-01f, -3.59800011e-01f, -3.57724190e-01f, -2.85050482e-01f, 3.12817305e-01f, 6.32504344e-01f, -4.04977858e-01f, 3.03075939e-01f, -2.03827113e-01f, 1.48042607e+00f,
  -2.54169911e-01f, 3.54617201e-02f, -1.08205415e-02f, -9.18761611e-01f, 1.30273908e-01f, -5.71462154e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 8)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 8;
const float L1_fan_Bp_bar_data[] = {
  4.23939645e-01f, -1.25975579e-01f, 5.72848320e-01f, 3.85803431e-01f, 3.54905665e-01f, 5.65812811e-02f, 4.81132656e-01f, 9.38532174e-01f
};

// L2_linear_W (Shape: 12 x 32)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 32;
const float L2_linear_W_data[] = {
  -9.53297257e-01f, -2.19963685e-01f, -2.28324458e-01f, -4.43134665e-01f, -1.51223749e-01f, -2.59081364e-01f, -5.22358835e-01f, 8.18827450e-02f, -2.51581311e-01f, 1.74606498e-02f,
  1.55586362e-01f, 1.84499592e-01f, -7.43305564e-01f, 3.45149130e-01f, -3.39466274e-01f, 1.04978251e+00f, 3.51018131e-01f, -4.28988308e-01f, 1.41848922e-01f, -6.99480474e-02f,
  -1.14152050e+00f, 7.91351646e-02f, -3.71426642e-01f, 5.43574452e-01f, -1.18727505e+00f, 6.10742986e-01f, -3.36260319e-01f, -4.77411263e-02f, -8.06006253e-01f, -2.09780931e-01f,
  4.65878798e-03f, -2.89862417e-02f, 4.13496792e-02f, 1.45200193e-01f, -2.22717449e-01f, -5.67068517e-01f, 4.42619801e-01f, 1.17236674e-01f, 3.47013861e-01f, -1.71019033e-01f,
  -1.12456009e-01f, -4.17654186e-01f, 3.10297042e-01f, 2.71997079e-02f, -1.84258208e-01f, -1.34186864e-01f, 6.20990932e-01f, -9.12673548e-02f, 1.58341646e-01f, 5.48194945e-01f,
  -5.56257367e-01f, 5.88890970e-01f, 1.76021531e-01f, 6.78180397e-01f, 1.42821833e-01f, -9.34123933e-01f, 1.02414705e-01f, 1.90769807e-01f, 9.10058171e-02f, -1.45735741e-01f,
  -8.96988809e-01f, 3.33693892e-01f, 2.48843715e-01f, -3.32169682e-01f, -8.26254413e-02f, 5.75571120e-01f, 3.41191143e-01f, -4.75740671e-01f, 5.48880100e-01f, 3.59509498e-01f,
  1.98900566e-01f, 1.33475978e-02f, 3.57496262e-01f, -3.09153467e-01f, 3.83326828e-01f, 5.10289669e-01f, 6.50154769e-01f, 2.55341716e-02f, 4.64666635e-01f, -8.59261692e-01f,
  -4.72805768e-01f, 3.22249085e-02f, 1.33266282e+00f, -5.77736735e-01f, 4.54329729e-01f, 8.51734161e-01f, -7.21166253e-01f, 2.76480377e-01f, -6.94083631e-01f, -2.97737360e-01f,
  6.19718432e-01f, -1.04384923e+00f, -4.42971349e-01f, -3.39440346e-01f, -1.90663263e-01f, 4.13019538e-01f, -2.89401323e-01f, -2.95662403e-01f, -8.44290435e-01f, -3.69578123e-01f,
  7.49935091e-01f, 3.86747539e-01f, -4.63584185e-01f, 1.65476680e-01f, 4.53390956e-01f, -1.14231908e+00f, -1.16727269e+00f, -6.49346948e-01f, -3.13816033e-02f, 2.85420239e-01f,
  3.99953365e-01f, -1.18100978e-01f, -6.93076551e-01f, -2.91072637e-01f, 1.28888533e-01f, 2.20239013e-01f, 1.39166355e-01f, 3.57491165e-01f, 2.36823812e-01f, 4.75494474e-01f,
  -3.34643126e-01f, 1.28132673e-02f, -1.45546377e+00f, 4.34551537e-01f, 4.28146422e-01f, 1.11556314e-01f, -1.17206120e+00f, -1.00087094e+00f, 5.48588336e-01f, 1.46795362e-01f,
  3.39545310e-01f, 4.03585017e-01f, -7.38267541e-01f, -3.79101396e-01f, 4.50330138e-01f, -3.22245732e-02f, -7.14269280e-01f, 2.53008395e-01f, 4.79301393e-01f, -7.73839653e-01f,
  6.82627499e-01f, -9.42492783e-01f, -1.02078617e+00f, -9.46799636e-01f, 8.44572246e-01f, -6.33947313e-01f, 5.69917738e-01f, -4.47812349e-01f, 1.19555128e+00f, 1.67293563e-01f,
  -4.39265780e-02f, 5.96012235e-01f, 1.99103966e-01f, 2.61227131e-01f, -5.43578029e-01f, -7.87251368e-02f, -5.10854244e-01f, 4.13801037e-02f, -5.37771821e-01f, -7.35299230e-01f,
  9.38531756e-02f, 4.55910742e-01f, 1.35016933e-01f, 5.15389860e-01f, -4.63718116e-01f, 1.35156691e-01f, -1.17607117e+00f, -4.22079027e-01f, -9.75608900e-02f, 4.37957227e-01f,
  -3.98107380e-01f, 3.22907567e-01f, 1.74178883e-01f, -2.66425103e-01f, 4.61577892e-01f, 5.58740616e-01f, 3.69704366e-01f, -1.93676740e-01f, -1.83578163e-01f, -9.47247684e-01f,
  3.97614568e-01f, -1.02564824e+00f, 9.96437073e-01f, 6.29441202e-01f, -2.29460806e-01f, -1.13323279e-01f, 2.13493288e-01f, 1.78206772e-01f, -3.12267691e-01f, 1.14012107e-01f,
  2.89933771e-01f, 8.77740234e-02f, 2.52967000e-01f, -2.82728434e-01f, -7.73478448e-01f, 2.48102956e-02f, 2.75804430e-01f, -8.04612517e-01f, 3.27141657e-02f, -1.38794377e-01f,
  5.99876821e-01f, 2.77780443e-01f, -2.08942920e-01f, 3.95972162e-01f, -9.10647035e-01f, 2.51792282e-01f, -4.28334802e-01f, 1.35963917e+00f, -4.38728899e-01f, 6.28967345e-01f,
  -1.00873840e+00f, 9.23491538e-01f, 3.09891492e-01f, -4.89122152e-01f, 7.43544459e-01f, -7.25093246e-01f, 3.39014888e-01f, -1.15390742e+00f, 5.44148266e-01f, -1.24757314e+00f,
  -6.14137232e-01f, -1.88240603e-01f, 2.37074971e-01f, 1.52802244e-01f, 3.82088035e-01f, -4.39249396e-01f, 1.14908814e-01f, -2.42389515e-01f, -2.15846837e-01f, -4.57036227e-01f,
  -2.48589858e-01f, -9.54914019e-02f, -2.46857584e-01f, -3.05766940e-01f, -9.36944261e-02f, -2.03486010e-01f, -2.13680089e-01f, -2.71325111e-01f, -2.20534399e-01f, -1.90075442e-01f,
  -5.14056444e-01f, -2.78300166e-01f, 6.63355112e-01f, 4.80053455e-01f, -1.15811005e-01f, -5.48481166e-01f, -7.64915198e-02f, 1.06433429e-01f, 4.50769633e-01f, -9.60013643e-02f,
  1.00739477e-02f, -6.59304142e-01f, 6.11140370e-01f, -6.13569438e-01f, -9.04752463e-02f, -9.51207578e-02f, -3.27586681e-01f, 5.01053154e-01f, 5.88493347e-01f, 2.12420195e-01f,
  3.42182070e-01f, 4.39972818e-01f, 6.47219837e-01f, 4.74258780e-01f, 2.38489136e-01f, 4.73991148e-02f, 1.24708287e-01f, -1.20148435e-01f, -5.98161161e-01f, 2.06732959e-01f,
  3.28535765e-01f, -5.82174599e-01f, -4.70004588e-01f, -6.77691758e-01f, -2.83771865e-02f, 2.06531718e-01f, -1.03040147e+00f, 3.60605478e-01f, -9.34460580e-01f, -8.60422969e-01f,
  -4.60744381e-01f, -3.63203943e-01f, -5.47639549e-01f, 2.57909179e-01f, 4.26710725e-01f, -7.31315792e-01f, 4.86393452e-01f, 3.32108796e-01f, 4.41264153e-01f, -5.06734848e-01f,
  8.27019036e-01f, 5.70620060e-01f, 4.80009496e-01f, 6.42734945e-01f, 6.06112421e-01f, 9.33303833e-01f, -2.47052789e-01f, 9.91428316e-01f, 7.31209457e-01f, 1.53006047e-01f,
  4.18877453e-01f, 3.64922881e-01f, 1.01996017e+00f, -2.41281688e-01f, 2.57637441e-01f, 8.04563239e-02f, -8.38594258e-01f, -1.31462008e-01f, 4.03646380e-01f, -8.11827719e-01f,
  6.59043372e-01f, 6.41904771e-01f, 3.47726762e-01f, -9.51046407e-01f, -1.95846185e-01f, -4.06862289e-01f, -3.90551925e-01f, -6.90357924e-01f, -8.09396744e-01f, 7.28367150e-01f,
  1.31093115e-01f, -4.13597554e-01f, -2.84712970e-01f, 6.22463405e-01f, 8.03319886e-02f, -6.21413350e-01f, 3.11710596e-01f, 1.35010272e-01f, 2.94701993e-01f, 3.47627670e-01f,
  -2.59561867e-01f, 2.57798791e-01f, 3.65421385e-01f, -4.64519188e-02f, -8.60443175e-01f, 5.68107963e-01f, -1.98125020e-01f, 9.85929668e-01f, -5.10946035e-01f, -6.76063657e-01f,
  8.20628703e-02f, -6.41963542e-01f, -3.41531008e-01f, -7.66309917e-01f, -4.63560939e-01f, -4.64700907e-01f, 4.52715844e-01f, 8.87417734e-01f, 7.60728717e-02f, -9.23082530e-01f,
  -1.00991559e+00f, -9.76930976e-01f, 3.72319035e-02f, -7.45876655e-02f, -2.43957564e-01f, -8.12280476e-02f, -9.37787712e-01f, -5.92822909e-01f, -2.31196448e-01f, -6.61842167e-01f,
  -2.28067890e-01f, -2.72912323e-01f, 8.72504935e-02f, 2.71722436e-01f, -1.73554197e-01f, 4.07817513e-01f, 3.54385108e-01f, 8.37084293e-01f, 1.29984677e-01f, 4.00727093e-01f,
  -6.14753902e-01f, -6.44522312e-04f, -7.72490025e-01f, 3.90225500e-01f, -7.77690887e-01f, 8.03396881e-01f, -2.24999502e-01f, -4.93431389e-01f, -6.27670228e-01f, -3.42982650e-01f,
  6.53903723e-01f, 6.54768407e-01f, -7.45702013e-02f, -3.14824909e-01f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  -3.21613699e-01f, -3.89266700e-01f, 2.29696289e-01f, -2.65897363e-01f, 4.36139137e-01f, 1.34134918e-01f, 1.23261057e-01f, -2.31747031e-01f, 8.64519328e-02f, 3.84132206e-01f,
  2.67367009e-02f, -3.15429270e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 12, 8
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 12, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        32, 12
    );
    }
    