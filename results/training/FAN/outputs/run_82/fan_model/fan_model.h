/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 12 x 120)
const int L0_fan_Wp_rows = 12;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  2.69186109e-01f, -7.64466524e-02f, 4.06324305e-02f, 2.86296336e-03f, 2.59335451e-02f, 1.75744429e-01f, 5.99761233e-02f, -4.60313670e-02f, 7.09649473e-02f, -1.45753965e-01f,
  -4.01330739e-02f, 1.85187489e-01f, -5.38489334e-02f, 5.72006367e-02f, 3.29596758e-01f, 2.24235848e-01f, 6.24292046e-02f, 4.97818291e-02f, 1.04011588e-01f, -1.67030737e-01f,
  2.24484447e-02f, -5.38795143e-02f, 1.22791544e-01f, -7.25495666e-02f, -1.21794932e-01f, -8.04614276e-02f, -1.83989316e-01f, 8.92998837e-03f, -6.36740327e-02f, 4.11652960e-02f,
  4.32786532e-02f, -2.19163224e-02f, -9.92667899e-02f, 3.23249511e-02f, -1.95776094e-02f, -5.27673066e-02f, -2.04466432e-02f, 3.47647741e-02f, 6.93233609e-02f, 4.39453358e-03f,
  4.20299843e-02f, 7.30221644e-02f, 3.43403891e-02f, 6.16651289e-02f, 2.90577561e-02f, 3.56020629e-02f, 3.95227075e-02f, -1.89267453e-02f, -4.47766334e-02f, 6.68233559e-02f,
  3.33371051e-02f, -3.30847241e-02f, -2.30315514e-02f, -7.07900152e-03f, 3.26039735e-03f, 7.10888719e-03f, 7.04080388e-02f, 2.87526585e-02f, -7.12364353e-03f, -2.06838585e-02f,
  -1.79234222e-02f, -3.23715387e-03f, 3.25010344e-03f, -3.74398977e-02f, 3.60953994e-02f, -2.77034156e-02f, -1.87514238e-02f, 1.33505343e-02f, 4.88036685e-02f, 1.90783180e-02f,
  -2.51031257e-02f, 5.03257513e-02f, -1.69224839e-03f, 3.85781517e-03f, -2.26236638e-02f, -4.30534966e-02f, 4.19686101e-02f, -2.52727233e-03f, 4.15658951e-03f, 3.31459679e-02f,
  -2.53415704e-02f, 2.67233700e-02f, -5.74879348e-04f, -5.61353900e-02f, -1.41388169e-04f, -2.55303085e-02f, 2.33487487e-02f, -2.03789417e-02f, -3.72667983e-02f, -1.78005695e-02f,
  -4.17217277e-02f, -2.18598336e-01f, -1.68886874e-02f, 8.98852199e-02f, -8.08278657e-03f, 1.67779624e-02f, 1.19160637e-02f, -3.48803890e-03f, 9.23414528e-03f, -1.28969857e-02f,
  -3.62504199e-02f, -1.03457971e-02f, -7.81178251e-02f, 1.48993274e-02f, -3.51658911e-02f, -1.00238649e-02f, -4.66479175e-02f, -3.77956927e-02f, -4.01863791e-02f, 1.36340680e-02f,
  -5.11781462e-02f, 5.79800867e-02f, 7.13652894e-02f, 2.31175683e-02f, 1.46639813e-02f, -4.07221094e-02f, -9.46317893e-03f, 2.34890729e-02f, -1.65091287e-02f, -1.56993959e-02f,
  -4.76558656e-01f, -9.10606161e-02f, 6.53676987e-02f, -1.88167781e-01f, -5.30844331e-02f, -2.72634923e-01f, 2.31588405e-04f, -1.52104273e-01f, -1.75970078e-01f, -7.57525861e-02f,
  -2.60081850e-02f, -2.26511341e-02f, 9.16400179e-02f, -9.84113738e-02f, 7.62808099e-02f, 6.60775155e-02f, -1.81990087e-01f, -6.01928979e-02f, 3.11601032e-02f, -1.39732987e-01f,
  -1.11642167e-01f, -1.83120012e-01f, 1.68648839e-01f, -1.09322481e-01f, -6.58717006e-02f, -1.05640218e-01f, 4.99000289e-02f, 3.81162241e-02f, -2.05675829e-02f, -3.44099514e-02f,
  -2.34263707e-02f, 3.57878022e-02f, 1.40987402e-02f, 1.42608145e-02f, -2.14851256e-02f, -1.85545497e-02f, -1.62986349e-02f, 6.43101633e-02f, -7.28382077e-03f, 8.01023375e-03f,
  -4.92181927e-02f, 8.01511202e-03f, -7.06735207e-03f, -3.60564850e-02f, -1.08164214e-01f, 2.89742984e-02f, 4.97500412e-02f, 4.22118157e-02f, 1.34181743e-02f, -8.79696477e-03f,
  -1.52021949e-03f, 1.64624897e-03f, -7.01651871e-02f, 7.00062281e-03f, 5.14301434e-02f, 3.06429435e-03f, 6.38497481e-03f, 4.48935702e-02f, 3.84668075e-03f, -6.14647120e-02f,
  -3.62474583e-02f, -3.04546077e-02f, 3.59368101e-02f, 1.80156436e-02f, -8.60210694e-03f, -1.23063056e-03f, -6.71168696e-03f, -6.35356177e-03f, -2.81188861e-02f, -1.50548257e-02f,
  4.89554787e-03f, -8.51037167e-03f, -4.87881750e-02f, -2.79434305e-02f, -9.19904187e-02f, -3.35679040e-03f, 1.78249693e-03f, -1.08768595e-02f, -7.26762116e-02f, -2.90785376e-02f,
  3.62326019e-02f, -3.59594822e-02f, 5.04846796e-02f, 5.06198294e-02f, 4.52050231e-02f, 3.07424217e-02f, 3.32325026e-02f, 4.18353640e-02f, 1.95290986e-02f, 4.96130250e-02f,
  3.91909145e-02f, -4.55174223e-03f, 9.04613659e-02f, 7.36022741e-02f, 6.97377101e-02f, -3.44753563e-02f, 3.75920348e-02f, -6.08699583e-02f, 2.01312397e-02f, -4.38187644e-02f,
  -5.42930402e-02f, 2.35423483e-02f, -6.95353150e-02f, 4.79827030e-03f, -2.31534373e-02f, -2.87161060e-02f, 7.78356846e-03f, -2.28107180e-02f, -3.55207026e-02f, 5.86542999e-03f,
  -3.86116095e-03f, -2.00479534e-02f, 2.11781785e-02f, -9.05478448e-02f, -7.14967698e-02f, 4.04185317e-02f, -7.72251189e-02f, 1.23815676e-02f, 2.66241729e-02f, -6.25739759e-03f,
  -7.12929070e-02f, -7.32162818e-02f, -2.54980624e-02f, -1.68094084e-01f, 1.47258028e-01f, -2.67794490e-01f, -2.42733628e-01f, -4.97864373e-02f, 2.23485589e-01f, -7.22367615e-02f,
  -1.71115622e-01f, 1.01150826e-01f, -6.88866302e-02f, -2.16374680e-01f, 2.13464610e-02f, -3.80826145e-02f, -1.46288082e-01f, -1.09592371e-01f, 4.95774336e-02f, -9.92133170e-02f,
  -1.80271473e-02f, -1.62427753e-01f, -1.51296332e-01f, -5.25540225e-02f, -9.51349065e-02f, 6.38667792e-02f, 5.42877167e-02f, -4.02142256e-02f, -3.64311486e-02f, -3.95019390e-02f,
  -8.75416324e-02f, 2.73757093e-02f, 6.15030900e-03f, -8.87868274e-03f, -8.97360370e-02f, -2.56386176e-02f, -1.21069372e-01f, -4.85827439e-02f, 5.01721865e-03f, 6.34096051e-03f,
  -7.87594728e-03f, 3.29764932e-02f, 3.32946926e-02f, 2.84617227e-02f, 6.28545657e-02f, 1.23437427e-01f, 2.10402552e-02f, 2.28733681e-02f, 2.12196205e-02f, -6.88447058e-02f,
  -1.08892387e-02f, -1.31271249e-02f, -2.25588847e-02f, -2.34580468e-02f, 3.98949571e-02f, -5.40340543e-02f, -1.53554194e-02f, -4.58650813e-02f, 7.87271094e-03f, 6.24098442e-02f,
  8.14314745e-03f, -3.38559821e-02f, -7.96503797e-02f, -3.78777459e-02f, -1.19892722e-02f, -4.06393670e-02f, -5.01134619e-03f, -1.70121696e-02f, 2.22427286e-02f, 7.32983608e-05f,
  -1.46247894e-02f, 6.09531440e-02f, -1.66613311e-02f, -6.88403525e-05f, -7.13830143e-02f, -4.30143215e-02f, -6.76464150e-03f, 4.46016602e-02f, -4.78997864e-02f, 1.57083292e-02f,
  1.39018204e-02f, 2.01486889e-02f, 2.76550394e-03f, -6.51040152e-02f, -5.76877147e-02f, 2.71042418e-02f, -2.22553237e-04f, 3.78441811e-02f, -2.41569243e-02f, -6.25243187e-02f,
  2.03261487e-02f, 1.61745816e-01f, 5.21186693e-03f, -8.50782767e-02f, 1.20800503e-01f, 1.60439480e-02f, 2.06583794e-02f, -5.83529985e-03f, 7.54896924e-02f, 2.56590880e-02f,
  1.41894333e-02f, -2.27221679e-02f, 9.98339802e-03f, -8.33631027e-03f, -2.96391957e-02f, -8.45111459e-02f, -1.39138717e-02f, 8.12588260e-02f, 1.26493694e-02f, 5.48983179e-02f,
  -7.57828578e-02f, 1.75848361e-02f, -1.98615231e-02f, 5.05745262e-02f, -3.14168981e-03f, -5.35289422e-02f, 5.98567985e-02f, 3.54764983e-02f, 6.49584457e-02f, -2.22785752e-02f,
  -3.89144629e-01f, -2.80573726e-01f, -1.23259254e-01f, -9.40064415e-02f, -1.79111049e-01f, -1.50862053e-01f, 1.37223408e-01f, -5.22781536e-02f, -2.15632468e-01f, -1.42604169e-02f,
  1.21127181e-01f, -1.09791569e-02f, 2.03501001e-01f, -3.01675592e-02f, -1.05730250e-01f, 1.55098379e-01f, -2.58850276e-01f, 4.68836278e-02f, -9.87929478e-02f, -1.75212979e-01f,
  -1.57553796e-02f, 2.52104225e-03f, 6.53828755e-02f, -6.77387491e-02f, -7.94690251e-02f, -5.83914109e-03f, 8.28505382e-02f, 1.13547429e-01f, -5.90924174e-02f, 3.71848866e-02f,
  -1.31751254e-01f, 7.79585866e-03f, -1.15334950e-01f, 7.86838606e-02f, -4.92053889e-02f, 8.38779137e-02f, 2.16036532e-02f, 1.01508245e-01f, 2.28195563e-02f, 1.69978272e-02f,
  1.14100277e-02f, 4.28673625e-02f, -1.92728546e-02f, 5.40624112e-02f, 2.18318850e-02f, -1.08709224e-01f, -2.67641917e-02f, -4.09218296e-02f, -1.81516148e-02f, 7.56122321e-02f,
  -6.99959025e-02f, -2.50430889e-02f, -1.52211860e-02f, 5.80585077e-02f, 2.75535565e-02f, -2.98360512e-02f, 2.36206818e-02f, 3.09027662e-03f, -3.69032659e-02f, -1.31565452e-01f,
  1.20265611e-01f, 3.23907770e-02f, -8.21807422e-03f, 1.48841636e-02f, 1.83408018e-02f, 3.94997373e-02f, -3.45017500e-02f, 5.76424450e-02f, -2.41306610e-02f, 1.03127572e-03f,
  -9.41530094e-02f, 7.87962675e-02f, 2.89254487e-02f, -2.11119000e-03f, -3.54801980e-03f, 1.33477449e-02f, 4.85259574e-03f, -1.92502290e-02f, -7.67515823e-02f, 1.23373605e-02f,
  2.60649715e-02f, -1.75554510e-02f, 5.40696979e-02f, -1.73721276e-02f, -8.19129944e-02f, -1.27792452e-02f, -2.51755212e-02f, -2.37067044e-02f, -9.02158022e-03f, -6.46060035e-02f,
  -2.09689677e-01f, -1.42260849e-01f, -1.19626019e-02f, -6.87886262e-03f, -9.31065753e-02f, -6.41264096e-02f, -2.82654446e-02f, -1.82821210e-02f, -2.26093568e-02f, -6.74954616e-03f,
  -1.18565029e-02f, -6.35408238e-02f, -2.77015977e-02f, 2.10158061e-02f, -1.76597945e-02f, -1.14135817e-01f, -7.20086545e-02f, 2.44246516e-02f, -2.86871335e-03f, -5.96037209e-02f,
  4.95975241e-02f, -8.14379379e-03f, 2.42157467e-02f, -6.48150668e-02f, 4.26575877e-02f, -1.17933042e-02f, -3.11505031e-02f, -8.48190263e-02f, -1.21773146e-02f, 1.89287607e-02f,
  -2.29499027e-01f, 2.69877240e-02f, -2.29955912e-01f, -9.73407030e-02f, -9.79205742e-02f, -1.80073887e-01f, -1.23673394e-01f, -1.17323495e-01f, -6.07588068e-02f, 2.01549754e-01f,
  8.21273923e-02f, -1.18792549e-01f, 7.51832873e-02f, -9.20033753e-02f, -3.11617464e-01f, 1.78443715e-01f, -4.18358557e-02f, 6.79355785e-02f, -4.76782359e-02f, -9.08380002e-02f,
  -1.14285596e-01f, -5.59354983e-02f, -1.68973997e-01f, 6.98491707e-02f, -6.30576909e-02f, 9.43764746e-02f, 1.99468866e-01f, -3.27070220e-03f, -2.87036262e-02f, -2.66335402e-02f,
  -9.48859900e-02f, 5.55633567e-02f, -1.23468071e-01f, 1.26161147e-02f, -4.46445942e-02f, 2.13091709e-02f, 3.72266099e-02f, -4.12721857e-02f, -4.02634777e-02f, -3.22149955e-02f,
  5.06965965e-02f, -2.35747714e-02f, -4.60210145e-02f, -1.80551503e-02f, 1.71018764e-04f, -7.68920034e-02f, -6.13200143e-02f, -2.68662963e-02f, -3.98275219e-02f, -4.61302474e-02f,
  -1.06706373e-01f, -2.83654146e-02f, -5.50539291e-04f, 1.08453557e-01f, -3.63216698e-02f, -4.66666091e-03f, 3.90081033e-02f, 2.35732514e-02f, -8.69669206e-03f, 3.75251025e-02f,
  3.56952362e-02f, 4.65175845e-02f, 3.76873724e-02f, -3.72928120e-02f, 1.95557880e-03f, 3.05684260e-03f, -1.51426793e-04f, -1.17632607e-02f, -1.23233953e-03f, 2.64599938e-02f,
  -2.04983149e-02f, -1.26280049e-02f, 5.34655116e-02f, -2.85241157e-02f, -1.09748291e-02f, 5.16942628e-02f, -6.82977214e-03f, 4.88444269e-02f, -3.23946029e-02f, -3.99805084e-02f,
  -2.16847155e-02f, -6.24687923e-03f, 7.56008434e-04f, 6.84625879e-02f, -8.19656067e-03f, -3.06698084e-02f, -4.20577452e-02f, -1.52424648e-02f, -2.68972497e-02f, -1.68107823e-02f,
  1.32898524e-01f, 2.61542171e-01f, -1.25168869e-02f, -9.10663803e-04f, 4.70241942e-02f, 2.87752803e-02f, 1.54461237e-02f, 1.36934044e-02f, 3.57308798e-02f, 4.63809706e-02f,
  7.84777999e-02f, 1.72175039e-02f, 8.86764936e-03f, -2.05091685e-02f, -8.65437761e-02f, 4.86173518e-02f, 1.06299601e-01f, -6.24166662e-03f, -1.04962112e-02f, 4.93867323e-02f,
  3.32267433e-02f, 8.94579515e-02f, 2.47585718e-02f, 9.93053056e-03f, 6.16892427e-02f, 6.31518960e-02f, 5.72417863e-02f, -1.14344917e-02f, 1.46171246e-02f, -1.85645409e-02f,
  3.14371705e-01f, -1.62227098e-02f, -2.09308326e-01f, 8.58107433e-02f, 1.60459235e-01f, 2.29348391e-01f, 1.63885415e-01f, 3.16458307e-02f, 2.79130973e-02f, 1.32471109e-02f,
  1.36081845e-01f, -2.19302028e-01f, -1.59869760e-01f, 1.08176537e-01f, -1.29886508e-01f, -8.12922511e-03f, 1.17660187e-01f, 1.69469677e-02f, 4.56721969e-02f, 6.85038716e-02f,
  7.71778896e-02f, 2.19552487e-01f, -5.44656301e-03f, 1.13272600e-01f, 6.17319643e-02f, 4.72453199e-02f, -6.03862992e-03f, -9.01290476e-02f, 8.31637233e-02f, -1.24012455e-02f,
  8.98182392e-02f, 2.61645894e-02f, -3.80333066e-02f, 1.46935713e-02f, 1.02074303e-01f, -1.39662670e-02f, -6.56729490e-02f, -4.20609415e-02f, -1.95938814e-02f, 1.18091824e-02f,
  -4.63132933e-02f, 1.62928067e-02f, 3.28630321e-02f, -5.17808683e-02f, 1.77450068e-02f, 3.08456831e-02f, 1.55735854e-02f, 6.70395344e-02f, -4.22575288e-02f, -6.82249367e-02f,
  -8.64516050e-02f, -2.06721742e-02f, -5.28713316e-02f, 3.24144177e-02f, -1.63777675e-02f, 2.09057685e-02f, -3.92158814e-02f, -7.60259777e-02f, -9.86118335e-03f, -1.63792875e-02f,
  5.91173917e-02f, 2.37631481e-02f, 4.31475528e-02f, 4.88024279e-02f, 7.08141997e-02f, 7.85073563e-02f, -1.52650289e-02f, 2.14299634e-02f, 7.92500935e-03f, -1.26910275e-02f,
  5.74501231e-02f, -2.89903842e-02f, -3.62553149e-02f, 3.22373807e-02f, 1.93519089e-02f, 8.45049843e-02f, 4.05930057e-02f, -2.18725530e-03f, -6.62657768e-02f, 2.05666255e-02f,
  -3.06052109e-03f, 3.25255916e-02f, 3.55616445e-03f, 2.48038638e-02f, 2.53081061e-02f, -4.79102805e-02f, -2.17626467e-02f, -2.16997769e-02f, 2.49520447e-02f, -2.51264102e-03f,
  -3.06382459e-02f, -2.21250970e-02f, 3.55559550e-02f, 5.06658219e-02f, -1.98964179e-02f, -4.76885363e-02f, -3.34341377e-02f, -2.29270998e-02f, 4.75391671e-02f, 5.54818138e-02f,
  3.67229767e-02f, -4.43240665e-02f, 3.62287164e-02f, 4.21949141e-02f, -7.43487030e-02f, -4.25049402e-02f, -1.28625392e-03f, 3.37846391e-02f, 7.81231746e-03f, 2.65482031e-02f,
  2.41509844e-02f, 1.44751091e-02f, -6.59492565e-04f, 4.55209576e-02f, 6.41443729e-02f, -4.12479080e-02f, 2.26121619e-02f, 1.84130780e-02f, -2.12972164e-02f, -2.15137266e-02f,
  7.98582509e-02f, 3.48295987e-01f, -1.89210340e-01f, -3.60107012e-02f, -2.45645061e-01f, 1.89697564e-01f, 1.73945770e-01f, -1.01459958e-01f, -2.45314650e-02f, 1.00938894e-01f,
  -6.05290271e-02f, 1.03117026e-01f, 1.00974910e-01f, 1.14396319e-01f, 1.07732981e-01f, 1.65575996e-01f, 1.99077055e-01f, 1.08172201e-01f, 5.53529756e-03f, 1.14677712e-01f,
  -6.24801069e-02f, 1.55985966e-01f, -4.66836505e-02f, -7.52084628e-02f, -2.46370628e-01f, -1.36181176e-01f, -4.85667624e-02f, -2.66223121e-02f, -8.99946317e-02f, 1.41640648e-01f,
  5.21389507e-02f, -4.15304005e-02f, -3.45532149e-02f, 3.91118713e-02f, -7.76597038e-02f, 7.56267272e-03f, 1.71917751e-02f, -1.18389605e-02f, -2.51841769e-02f, -1.54498816e-02f,
  -4.83943559e-02f, -8.39320794e-02f, 4.41941656e-02f, -9.51552615e-02f, -2.41065882e-02f, -7.98423514e-02f, -2.05087010e-02f, -6.03936203e-02f, -2.59422120e-02f, -5.21286428e-02f,
  -1.06215686e-01f, -6.46303445e-02f, 6.35603145e-02f, 3.79865952e-02f, -4.64066677e-02f, 2.48231720e-02f, -4.33514565e-02f, -2.84158229e-03f, -2.82956120e-02f, -4.32346612e-02f,
  1.03079975e-01f, 6.79923967e-02f, -8.67810380e-03f, -7.03781247e-02f, -4.91480716e-03f, -2.88703218e-02f, -4.49085236e-03f, -2.89363042e-02f, -2.78766956e-02f, -4.74540470e-03f,
  -6.23994088e-03f, -2.42971280e-03f, 6.84931278e-02f, -5.77703789e-02f, -5.64239696e-02f, -6.17459305e-02f, -1.49227763e-02f, -4.68355380e-02f, -9.35587101e-03f, -7.16980323e-02f,
  -1.57008544e-02f, 8.65210220e-03f, 2.26789098e-02f, -8.73725638e-02f, -9.84915905e-03f, -6.87974598e-03f, -1.00470088e-01f, -4.56186570e-02f, -6.08222447e-02f, 1.98492836e-02f,
  1.58177629e-01f, 1.93449706e-01f, 3.21688689e-02f, 2.40520928e-02f, 7.62398690e-02f, 1.74981188e-02f, 1.93286054e-02f, 2.44548474e-03f, 1.02481768e-01f, 2.60731112e-02f,
  1.75184775e-02f, -6.65822700e-02f, 3.20338011e-02f, 3.98205854e-02f, 7.11986944e-02f, -3.51496823e-02f, -4.52118963e-02f, 1.04570910e-01f, 9.51780379e-02f, 1.63772050e-02f,
  -5.17444611e-02f, 5.24781421e-02f, -4.50827852e-02f, -7.13303909e-02f, -3.13026793e-02f, -3.27612869e-02f, 4.18397831e-03f, 4.54213656e-02f, -6.31274283e-02f, 5.86236268e-02f,
  2.11845875e-01f, -1.88352570e-01f, 1.28484190e-01f, -5.16199023e-02f, 6.09439723e-02f, -2.55071670e-01f, -2.03341171e-01f, -8.56289938e-02f, -2.86149979e-01f, -3.37286234e-01f,
  -3.53500843e-02f, -7.23269209e-02f, -1.34089887e-01f, -2.39152491e-01f, -6.59839660e-02f, -2.58973867e-01f, -1.12611920e-01f, -3.21632735e-02f, -1.65106468e-02f, 8.09589997e-02f,
  3.22157927e-02f, -3.22752632e-02f, 2.51406953e-02f, 2.57405988e-03f, -6.57227403e-03f, 1.57439187e-01f, 8.81501064e-02f, 1.34576604e-01f, -3.48180672e-03f, -8.92605749e-04f,
  -1.00597605e-01f, -9.85494182e-02f, 2.40714736e-02f, -1.12213390e-02f, 5.37358113e-02f, 6.09210767e-02f, 5.27299866e-02f, 7.02119023e-02f, 3.21444869e-02f, -3.80959064e-02f,
  -1.78609919e-02f, 2.35037077e-02f, 9.99055430e-03f, -7.02621862e-02f, -2.70997491e-02f, 3.27852331e-02f, 5.50574809e-02f, 9.37993545e-03f, -3.34040709e-02f, -6.44351095e-02f,
  -4.54327911e-02f, -2.67177187e-02f, -8.14344734e-03f, -1.14179123e-02f, 2.39863545e-02f, -3.99234071e-02f, -3.47807147e-02f, 2.42532324e-02f, -4.90627363e-02f, -2.66612321e-02f,
  -5.51270845e-04f, 1.79737003e-03f, 6.14388846e-02f, -6.58166260e-02f, 1.69289615e-02f, 1.04971781e-01f, -7.09139556e-02f, 1.03426147e-02f, 3.28325927e-02f, 2.17356291e-02f,
  -9.73464083e-03f, 2.49126256e-02f, -7.57012470e-03f, 3.55324883e-05f, -7.55056739e-03f, -1.61499400e-02f, 6.67341650e-02f, -4.42926735e-02f, -3.41552459e-02f, -7.42631108e-02f,
  -5.65796681e-02f, -1.20876301e-02f, 6.28963634e-02f, -3.53256171e-03f, -7.07471967e-02f, 8.66673067e-02f, -7.92233050e-02f, -2.09203977e-02f, 3.50657739e-02f, 3.49282436e-02f,
  -1.70669004e-01f, -1.86846569e-01f, -5.16373888e-02f, 6.82586757e-03f, -5.46855889e-02f, 7.54800737e-02f, -7.89641961e-02f, 1.16449501e-02f, 7.05750883e-02f, -3.97938192e-02f,
  1.25085071e-01f, -2.59685777e-02f, 5.75949699e-02f, 3.14016305e-02f, 5.46660880e-03f, -4.05703709e-02f, -3.50380726e-02f, 4.44198735e-02f, 4.58306298e-02f, 1.89268626e-02f,
  9.12608728e-02f, 2.50677075e-02f, 4.44281958e-02f, 1.60153247e-02f, 1.46552846e-02f, 3.44187357e-02f, -1.40528101e-02f, 2.55431756e-02f, -2.73307152e-02f, -6.97633103e-02f,
  1.47129670e-01f, -3.77586365e-01f, -8.34010839e-02f, 2.04274073e-01f, 1.75705209e-01f, 6.98530152e-02f, 2.07039982e-01f, -1.12365663e-01f, 6.00087829e-02f, -1.70030132e-01f,
  1.51535198e-01f, -2.59242654e-01f, 3.71917114e-02f, -2.70261075e-02f, 3.45592648e-01f, -3.21830809e-02f, 1.24067374e-01f, 7.81600624e-02f, -5.67297004e-02f, 6.02594130e-02f,
  8.26133564e-02f, 1.23731904e-01f, 8.62395577e-03f, -7.18286633e-02f, 1.60275809e-02f, -1.63860470e-01f, 2.25524873e-01f, 4.54034703e-03f, -8.71279314e-02f, -1.03977956e-02f,
  -8.52162838e-02f, -5.51997647e-02f, -1.19205043e-01f, -1.07501224e-01f, 4.21594046e-02f, 4.25009802e-02f, 2.09149662e-02f, 7.38365389e-03f, 9.26588625e-02f, 2.74494700e-02f,
  -9.07444116e-03f, -5.03950636e-04f, -4.48310077e-02f, 6.80920435e-04f, 8.15101061e-03f, -3.00897341e-02f, -2.40255501e-02f, 1.52929891e-02f, -2.76243296e-02f, -5.65512963e-02f,
  -6.84654042e-02f, -5.06559610e-02f, 3.76511067e-02f, -1.01211118e-02f, -1.14740059e-02f, -2.34554056e-02f, -1.61003266e-02f, -4.85982327e-03f, -6.04495816e-02f, 1.53394500e-02f,
  -3.95056456e-02f, 1.46873565e-02f, -5.26801050e-02f, -1.07237309e-01f, -3.68825980e-02f, 3.81259806e-02f, 5.46960719e-02f, -3.46408389e-03f, -5.37989754e-03f, 5.28090075e-02f,
  2.91936286e-02f, 3.44263688e-02f, 2.22824533e-02f, 2.75882911e-02f, -7.66285090e-03f, -2.39946302e-02f, 8.30482412e-03f, -1.72648318e-02f, -6.81993961e-02f, -4.01729979e-02f,
  9.47912876e-03f, 4.02770489e-02f, -2.57247705e-02f, 1.11191720e-01f, 6.07968075e-03f, 1.62057094e-02f, 1.89192723e-02f, -4.95793705e-04f, -1.15027223e-02f, 2.31904071e-02f,
  9.40030813e-02f, 2.39878371e-02f, -9.34887901e-02f, -3.21043767e-02f, -3.06885168e-02f, -2.94017047e-03f, 6.28190413e-02f, -5.22068888e-02f, 4.91262674e-02f, -3.32961828e-02f,
  3.39061441e-03f, 5.35633899e-02f, 7.84311071e-03f, 3.92240584e-02f, 2.27545723e-02f, 5.52415662e-02f, 6.07626885e-02f, -4.94841412e-02f, 5.67080677e-02f, -9.59408563e-03f,
  3.83377932e-02f, 4.67572808e-02f, 1.62626673e-02f, -4.30051945e-02f, 4.20368537e-02f, 4.76070531e-02f, 2.54761148e-02f, -4.25384566e-02f, 9.88225788e-02f, -1.28984973e-02f,
  -8.12988877e-02f, -3.88026625e-01f, 1.02667324e-01f, -9.06637982e-02f, 2.29824707e-02f, 1.76057771e-01f, 2.24419788e-01f, -1.75586611e-01f, 1.13147140e-01f, -2.49767348e-01f,
  8.86253454e-03f, -3.98451723e-02f, -1.50247812e-02f, -4.39686887e-02f, 5.01869380e-01f, 1.76889822e-01f, 9.46798325e-02f, -3.94837707e-02f, 6.26860932e-02f, -2.41855104e-02f,
  5.13355546e-02f, 3.25877927e-02f, 9.34562460e-02f, -9.25837308e-02f, -8.51775408e-02f, -1.22464746e-01f, -3.05314157e-02f, -3.59748714e-02f, -1.47015318e-01f, 7.96463788e-02f,
  -4.58837710e-02f, -1.28677085e-01f, 1.63091731e-03f, 2.74006464e-02f, -8.54931474e-02f, -5.15565686e-02f, 1.26618159e-03f, 1.25316530e-01f, 6.91869259e-02f, -1.52857779e-02f,
  2.09384374e-02f, -1.47245498e-02f, -1.35830361e-02f, 6.30576685e-02f, -5.99138066e-02f, -2.63047740e-02f, -5.63165098e-02f, -5.25530837e-02f, -3.33630783e-03f, 6.43489361e-02f,
  1.53696630e-03f, 3.49476337e-02f, -1.11507252e-01f, -1.68310869e-02f, 8.52735862e-02f, 8.56492221e-02f, 3.79901528e-02f, -9.21396632e-03f, 2.45078187e-02f, 1.97533146e-02f,
  -3.31942574e-03f, 2.99897771e-02f, 6.72518536e-02f, 2.03800015e-02f, -5.45593211e-03f, -2.36418229e-02f, 3.24608311e-02f, -2.20070351e-02f, -3.47631387e-02f, -2.40764245e-02f,
  -7.94829205e-02f, -3.33414376e-02f, -1.97868459e-02f, -2.49848627e-02f, 9.93034057e-03f, -3.83015759e-02f, 3.51448194e-04f, -7.83623382e-03f, 1.91776583e-03f, -5.30715957e-02f,
  -2.00954508e-02f, 1.09474296e-02f, -5.20282798e-02f, -2.49699280e-02f, 3.22338268e-02f, 2.71023307e-02f, -8.32835659e-02f, -5.66908233e-02f, -9.33729671e-03f, 6.51109219e-02f,
  -2.16105491e-01f, -3.10469717e-01f, 8.59402213e-03f, -8.80498663e-02f, 1.35197695e-02f, 3.27752084e-02f, 4.57795784e-02f, -4.50172126e-02f, 5.06070862e-03f, 3.80609632e-02f,
  -9.02459770e-03f, -1.98714435e-02f, -4.11758050e-02f, 2.00832151e-02f, 2.44783144e-02f, -2.09986530e-02f, 7.69852772e-02f, 3.77542451e-02f, -1.55588584e-02f, -3.00103966e-02f,
  -1.47336587e-01f, -2.84576230e-02f, 1.07890725e-01f, 3.71282026e-02f, -3.82584557e-02f, -2.16443129e-02f, 1.53469120e-03f, 6.61626905e-02f, 1.05780317e-02f, 3.14256847e-02f,
  1.10826343e-01f, -1.31040230e-01f, -2.62717932e-01f, -2.28901669e-01f, 8.61485079e-02f, 2.47804988e-02f, -2.19465047e-01f, 1.15514286e-01f, 1.45081282e-01f, -1.11524705e-02f,
  -2.41330881e-02f, -8.16420540e-02f, 1.22318126e-03f, -2.52785206e-01f, -7.34347701e-02f, -7.91906118e-02f, -1.59066930e-01f, -8.59934464e-02f, 1.73592698e-02f, 2.44351514e-02f,
  -8.27953964e-03f, -1.01091072e-01f, -2.03720853e-01f, 1.09918326e-01f, -1.39073089e-01f, -7.10585527e-03f, -4.94844429e-02f, -1.26904041e-01f, -1.77067488e-01f, -1.62570298e-01f,
  -6.80683851e-02f, 1.04805171e-01f, 6.95444818e-04f, -1.85602382e-02f, -2.44780388e-02f, 1.29533012e-03f, -1.04832217e-01f, -8.73939767e-02f, 6.47699088e-02f, 7.83217046e-03f,
  5.84613485e-03f, 1.85920782e-02f, 2.00139899e-02f, -3.94381359e-02f, 5.15249521e-02f, -3.15920892e-03f, -1.23056844e-02f, 3.46926711e-02f, -5.07757850e-02f, -5.46477437e-02f,
  -1.55973742e-02f, -7.25916028e-02f, 1.96761768e-02f, -6.24331385e-02f, 2.76147239e-02f, 7.56876692e-02f, -3.54216844e-02f, -9.20876767e-03f, -2.45528258e-02f, 4.41882573e-02f,
  4.54810411e-02f, 2.96749920e-02f, -1.83489714e-02f, -3.73776816e-03f, 3.08745112e-02f, -6.18258119e-02f, -3.96209694e-02f, -1.13716824e-02f, -5.03270794e-03f, 8.64861012e-02f,
  5.51638603e-02f, -4.54463437e-03f, 7.57487316e-04f, 4.27299701e-02f, -5.37547097e-03f, 5.90440258e-02f, -6.92680404e-02f, -5.57647087e-03f, -1.11610228e-02f, -5.85886743e-03f,
  2.53512096e-02f, 3.08395252e-02f, -9.77914631e-02f, -3.05334069e-02f, -8.17767233e-02f, -4.74261791e-02f, -4.61691283e-02f, -7.82234669e-02f, -1.37674492e-02f, 5.09001454e-03f,
  -3.20003256e-02f, -1.20536812e-01f, 1.20000457e-02f, 4.26752903e-02f, -4.66385968e-02f, -4.78979945e-03f, 1.78293679e-02f, 1.07709967e-01f, 2.06900444e-02f, -3.53018977e-02f,
  3.11121568e-02f, -3.61484312e-03f, -9.08480287e-02f, 8.44734684e-02f, 1.69120748e-02f, -6.52563199e-03f, -5.77205569e-02f, -3.26615870e-02f, 2.17237566e-02f, -3.08410870e-03f,
  -1.97631828e-02f, -2.88492721e-02f, 5.77987023e-02f, -6.77796155e-02f, 1.10566346e-02f, -4.31612832e-03f, 1.10610217e-01f, -1.30643062e-02f, 1.99937914e-02f, -3.51724178e-02f,
  2.68815577e-01f, 3.67206097e-01f, 1.91896349e-01f, 1.76753804e-01f, -1.31112486e-01f, -1.60461411e-01f, -6.98530450e-02f, 5.15634045e-02f, 1.97009727e-01f, 1.27003789e-02f,
  -7.02413470e-02f, 1.84661031e-01f, 1.16292462e-01f, 7.52587989e-02f, -2.23547399e-01f, 8.20183381e-02f, -1.13059487e-02f, 9.45926607e-02f, 9.68459100e-02f, 1.41390815e-01f,
  8.13619867e-02f, -1.21006690e-01f, 4.05756235e-02f, -1.35901481e-01f, 5.05137332e-02f, 6.89095445e-03f, -1.48461089e-01f, -4.24094014e-02f, -1.33062333e-01f, -1.65163741e-01f,
  -1.04007192e-01f, 9.72576365e-02f, -3.44523671e-03f, 1.30233988e-02f, 1.44867590e-02f, -5.48851229e-02f, -7.90218711e-02f, -5.81519082e-02f, -3.05587356e-03f, 7.48662930e-03f,
  2.35460456e-02f, -7.20233098e-02f, 4.26157154e-02f, -2.77350619e-02f, -1.14972387e-02f, 1.00754974e-02f, 4.69558798e-02f, 3.98268998e-02f, 9.22235474e-02f, -3.83833330e-03f,
  7.81995356e-02f, 6.88299071e-03f, 1.35418316e-02f, -5.08179404e-02f, 3.09595037e-02f, 1.69035792e-02f, -1.53613752e-02f, -3.02789677e-02f, 3.02104582e-03f, -1.01037584e-02f,
  -1.70052536e-02f, -3.48168202e-02f, 4.77795266e-02f, -5.24002267e-03f, 2.86189113e-02f, -1.33470399e-02f, -2.86135245e-02f, -5.18420637e-02f, -1.53425774e-02f, 6.48554368e-03f,
  1.46949040e-02f, 2.32723411e-02f, 1.09545896e-02f, 1.47655560e-02f, -1.01558361e-02f, 1.15118232e-02f, -1.47210015e-02f, -2.74759568e-02f, 4.80336341e-04f, 4.65513803e-02f,
  4.66963798e-02f, -4.04369719e-02f, 6.64288476e-02f, -1.86757892e-02f, -3.82105559e-02f, 2.53282879e-02f, 1.71631034e-02f, 3.02838646e-02f, 2.37440299e-02f, -2.93276738e-02f,
  -4.33943467e-03f, 2.57168189e-02f, 1.84188168e-02f, -2.77818777e-02f, -1.87053978e-02f, -7.03591714e-03f, 2.33510826e-02f, 1.83823872e-02f, 4.97093871e-02f, 6.53940579e-03f,
  -4.42728885e-02f, 1.20535037e-02f, -6.85625002e-02f, -6.56177569e-03f, 2.11322005e-03f, -6.66056350e-02f, -3.53873633e-02f, -3.57893258e-02f, -3.96598205e-02f, 2.47786995e-02f,
  1.05906175e-02f, -3.40402536e-02f, -3.75496037e-02f, -5.16626723e-02f, 3.89285688e-03f, -3.19035500e-02f, -1.38090327e-02f, 4.65833163e-03f, -5.44805638e-02f, 2.13190932e-02f
};

// L0_fan_Wp_bar (Shape: 8 x 120)
const int L0_fan_Wp_bar_rows = 8;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -2.82624424e-01f, 1.37034105e-02f, -2.57597834e-01f, 1.17515318e-01f, 1.41266882e-01f, 3.89330238e-01f, 2.11981833e-01f, 2.61995513e-02f, 8.05567056e-02f, 2.31757253e-01f,
  2.94424474e-01f, 1.89715512e-02f, 3.03835664e-02f, 3.88508499e-01f, 5.64077087e-02f, 1.84802972e-02f, 1.39911592e-01f, 1.92305103e-01f, -1.13451831e-01f, -1.86356436e-02f,
  -2.81039327e-02f, 2.76499122e-01f, -1.49340080e-02f, 1.05641656e-01f, 1.85091153e-01f, -1.37789741e-01f, 1.15327857e-01f, -1.39543831e-01f, 2.54903853e-01f, 1.42420754e-01f,
  4.31302823e-02f, -8.18602815e-02f, -1.98039934e-02f, -1.38996825e-01f, 2.20950730e-02f, 1.99995488e-02f, -4.03626934e-02f, -7.54471645e-02f, 1.84922814e-02f, -1.55251035e-02f,
  -2.35270802e-02f, 1.18132830e-02f, 5.64786866e-02f, 5.88066541e-02f, -1.75895263e-02f, 2.23424844e-02f, 5.44551983e-02f, 1.04587689e-01f, 1.08276010e-02f, 1.23646669e-02f,
  5.79014095e-03f, 3.96616906e-02f, 1.54969776e-02f, -3.21468599e-02f, -2.39460100e-03f, 2.80053690e-02f, 1.71568282e-02f, 2.90682055e-02f, 6.92864368e-03f, -1.53323263e-02f,
  -2.81198490e-02f, -1.41055137e-01f, -4.70875949e-02f, 2.56830007e-02f, -7.61924759e-02f, -1.39876679e-02f, 5.16107082e-02f, 3.06952186e-02f, -4.35553566e-02f, 4.73384894e-02f,
  5.46772629e-02f, 6.71113804e-02f, -9.61220451e-03f, -9.65385791e-03f, -5.07663041e-02f, -3.58104184e-02f, -5.85216582e-02f, 7.50876516e-02f, -9.83199384e-03f, 9.99437459e-03f,
  -3.91992414e-03f, -9.23421457e-02f, 3.96159254e-02f, -4.24602255e-02f, -8.03584829e-02f, -2.18846221e-02f, 5.71676753e-02f, 5.09464107e-02f, -1.22793606e-02f, -1.02014706e-01f,
  6.10793382e-02f, -2.11939201e-01f, 5.36064915e-02f, 3.62618938e-02f, -3.03081032e-02f, -6.58254232e-03f, -4.37903665e-02f, 3.68579477e-02f, -1.03318080e-01f, -5.92045784e-02f,
  2.79369149e-02f, 3.36370170e-02f, -1.01162102e-02f, -1.41437324e-02f, -5.99243864e-03f, 3.71913724e-02f, -3.02134492e-02f, 1.44475652e-02f, 2.20533591e-02f, -3.65477353e-02f,
  -2.38814801e-02f, -1.41879246e-02f, -8.19804240e-03f, -1.20450547e-02f, 5.43793924e-02f, 5.89329675e-02f, -5.11566177e-02f, -4.80207428e-03f, 1.55086797e-02f, -3.29347998e-02f,
  1.39361292e-01f, 7.30811357e-02f, 2.28340477e-01f, 3.33193511e-01f, -1.15513138e-01f, -2.68724382e-01f, -1.89600766e-01f, 9.63245407e-02f, -2.35504344e-01f, -1.35772362e-01f,
  -8.95095617e-02f, 2.16093659e-01f, -3.81090701e-01f, 1.85395420e-01f, -1.47500575e-01f, -4.45151567e-01f, 7.55924359e-02f, 1.16790375e-02f, -1.52458668e-01f, 1.37446253e-02f,
  -1.07492758e-02f, -6.73156697e-03f, 1.46414787e-01f, 1.47431478e-01f, 1.98937669e-01f, 3.70243400e-01f, 1.19550265e-01f, 4.31996509e-02f, 4.25187856e-01f, 1.07458353e-01f,
  -1.09166920e-01f, -7.37801613e-03f, 7.15421811e-02f, 5.05933650e-02f, -1.92129016e-02f, 6.13292586e-03f, 2.76541691e-02f, -3.36376987e-02f, -1.95384696e-02f, -1.61055513e-02f,
  1.78438518e-02f, 3.69020216e-02f, 1.29300207e-01f, 6.00706600e-02f, 1.27935698e-02f, 6.87670782e-02f, 1.45575935e-02f, 1.31001219e-01f, 4.90716361e-02f, 1.43631734e-02f,
  1.27512962e-02f, 6.67334571e-02f, 7.58033805e-03f, 8.32442120e-02f, 9.47838873e-02f, 7.98337087e-02f, 3.11331935e-02f, 3.94470170e-02f, 4.23691235e-03f, 2.83560120e-02f,
  -6.04702681e-02f, -3.91649827e-02f, 1.84268244e-02f, 2.45204754e-02f, -4.35202708e-03f, -2.10687704e-02f, -2.43157502e-02f, -7.86734186e-03f, -2.64105443e-02f, -7.15828985e-02f,
  3.13026495e-02f, 7.58547261e-02f, -3.71143445e-02f, -3.82181965e-02f, -8.78352579e-03f, -1.51763838e-02f, 4.55127433e-02f, 7.21269101e-02f, 2.70951018e-02f, 3.37265283e-02f,
  -5.57416193e-02f, 2.19157524e-02f, -1.03609404e-02f, 3.84223051e-02f, -5.19144163e-02f, -5.74713871e-02f, -2.43260656e-02f, 3.92283238e-02f, -4.82134782e-02f, 1.46871610e-02f,
  -1.60077780e-01f, -1.60873160e-01f, 1.80688482e-02f, 7.04413131e-02f, 6.97163120e-02f, 5.26593346e-03f, -8.82434566e-03f, 2.24491004e-02f, -8.68653283e-02f, -8.92093107e-02f,
  2.89091934e-02f, 5.42967021e-02f, -3.63102332e-02f, 1.33962512e-01f, 3.60989086e-02f, -3.43031297e-03f, -3.74022014e-02f, -1.89687088e-02f, -5.12365368e-04f, 2.13322025e-02f,
  -1.30339637e-02f, -3.37403007e-02f, 7.55230188e-02f, 5.19094206e-02f, -6.62490129e-02f, 3.11210863e-02f, 1.20172417e-02f, 6.17370829e-02f, -3.01392265e-02f, -4.93537039e-02f,
  2.79389650e-01f, 1.01075359e-01f, 3.00602257e-01f, 2.37629101e-01f, 3.81092839e-02f, -3.15284990e-02f, 5.88236935e-02f, 1.69862390e-01f, 6.11162782e-01f, 9.51165706e-02f,
  -3.47431414e-02f, 9.65473652e-02f, -1.59255952e-01f, 1.76708922e-01f, -2.17936829e-01f, -1.58629209e-01f, 1.16298366e-02f, 7.81540424e-02f, 4.75862250e-02f, 3.86797339e-02f,
  -5.92254028e-02f, -3.28671634e-01f, -1.87723428e-01f, -1.54701576e-01f, 5.30281179e-02f, 1.59717634e-01f, -2.89563149e-01f, -1.13396503e-01f, -6.94699064e-02f, -1.84168573e-03f,
  3.46310921e-02f, 3.06566745e-01f, 4.44663595e-03f, 2.01336592e-02f, 5.16864173e-02f, -4.09387844e-03f, -3.24464031e-02f, -8.63554776e-02f, 8.02516043e-02f, 4.57397886e-02f,
  -1.01844929e-02f, 7.23598823e-02f, 1.49597861e-02f, -1.01208265e-04f, 1.60546079e-01f, 1.04226239e-01f, 1.05140060e-01f, 2.12505236e-02f, 3.87508981e-02f, 1.16885535e-01f,
  4.13394608e-02f, 7.74576366e-02f, 3.51723433e-02f, 1.26968026e-02f, -4.66362685e-02f, 1.33889169e-01f, -2.09843158e-03f, -5.25716543e-02f, -1.45951547e-02f, 7.79232532e-02f,
  -2.59983782e-02f, 3.95557247e-02f, -3.23145837e-02f, 5.13892919e-02f, -5.40064201e-02f, 4.82868329e-02f, 1.34708313e-02f, -1.25610372e-02f, 8.56077075e-02f, -7.35312253e-02f,
  9.19722859e-03f, 4.41987030e-02f, 4.57058698e-02f, 5.25608547e-02f, -1.75788552e-02f, 6.22984618e-02f, -7.79166296e-02f, 2.64478046e-02f, 3.42665464e-02f, -7.83476532e-02f,
  2.28066780e-02f, -5.35300151e-02f, -2.38086116e-02f, 1.98245719e-02f, 3.80486660e-02f, 6.15161844e-02f, 6.19968108e-04f, 1.06037050e-01f, -4.53138947e-02f, -1.49119318e-01f,
  -1.08020239e-01f, 6.19031377e-02f, -5.15787713e-02f, 1.85623504e-02f, -5.80069497e-02f, -6.00361340e-02f, -1.25661660e-02f, 5.66803738e-02f, 2.78083589e-02f, -6.99296817e-02f,
  6.93568066e-02f, 2.29951460e-02f, -8.66731480e-02f, 5.34437597e-03f, -7.85979927e-02f, 3.91805917e-02f, -3.38921919e-02f, -2.66740881e-02f, 3.89290217e-05f, -1.29977033e-01f,
  -8.12364295e-02f, -8.91470723e-03f, 2.93942839e-02f, -2.22436544e-02f, -4.02218774e-02f, -5.06709702e-02f, 5.02940500e-03f, 2.49704681e-02f, -2.33286712e-02f, -5.68264835e-02f,
  -3.92894626e-01f, 1.00417167e-01f, -3.55649799e-01f, -6.68926388e-02f, -3.45213383e-01f, -2.06035599e-01f, -1.35329485e-01f, -1.17307976e-01f, 2.79891565e-02f, 2.22060531e-01f,
  7.69887865e-02f, 3.04137375e-02f, 2.21581310e-01f, 9.94416848e-02f, -1.07383400e-01f, 3.40645999e-01f, -4.09021303e-02f, 1.64143052e-02f, 2.22412646e-02f, -1.06665745e-01f,
  -4.17028181e-02f, -1.01010250e-02f, -1.22197829e-02f, -1.35033086e-01f, -3.09386790e-01f, -1.21234737e-01f, -6.92229718e-02f, -2.35333264e-01f, -1.83171719e-01f, -1.76249295e-01f,
  -2.50009596e-01f, -1.93693280e-01f, -8.33005011e-02f, 9.03628184e-04f, -8.61210376e-03f, -1.25183821e-01f, -1.11629337e-01f, -7.90098011e-02f, -1.65983513e-02f, 3.22301835e-02f,
  7.70746768e-02f, -3.76900174e-02f, 5.39244488e-02f, 4.98929173e-02f, 2.24077795e-03f, 4.41246964e-02f, -8.69460404e-03f, -4.02758606e-02f, 3.87636274e-02f, 3.10757011e-02f,
  5.26375249e-02f, -3.88411735e-03f, -8.84728432e-02f, 8.19165856e-02f, -1.26847014e-01f, -4.94539589e-02f, 3.06041539e-03f, -1.15249634e-01f, -4.69282120e-02f, 1.19859464e-02f,
  -1.20289057e-01f, 2.75694747e-02f, 5.33673167e-02f, 2.16774903e-02f, 1.60361547e-02f, -8.57686438e-03f, -4.44335258e-03f, 3.44140120e-02f, 2.86659580e-02f, -2.14974675e-02f,
  -3.09207849e-02f, -1.72285493e-02f, -4.94121201e-02f, 9.46803167e-02f, 3.20326984e-02f, 7.66642243e-02f, -9.17500351e-03f, -2.41026934e-02f, 7.31301829e-02f, -8.13137740e-02f,
  3.45478058e-02f, 6.46674959e-03f, 8.07626639e-03f, -9.47230309e-03f, -4.34380062e-02f, -1.26173487e-02f, -5.01438007e-02f, -3.13542709e-02f, 4.40144073e-03f, -4.02149521e-02f,
  -2.85680145e-01f, -2.56482780e-01f, 6.98915645e-02f, -3.24102212e-03f, -3.24740782e-02f, -3.84634249e-02f, -3.79075445e-02f, -7.46203139e-02f, -1.46949245e-02f, -8.01645890e-02f,
  1.08142318e-02f, 2.22048666e-02f, -1.39659628e-01f, 6.35624379e-02f, 6.02931492e-02f, 4.50323336e-02f, -9.94033087e-03f, -5.85761219e-02f, 2.91513018e-02f, 6.02591923e-03f,
  2.50019059e-02f, -2.58191340e-02f, 8.16137716e-02f, 5.76292574e-02f, 2.56584994e-02f, 2.45931894e-02f, -4.48623970e-02f, 4.58223037e-02f, -7.36975446e-02f, -6.69347122e-02f,
  -9.11106706e-01f, 3.92127365e-01f, 1.73389036e-02f, -1.94146514e-01f, -1.07937127e-01f, -5.12268096e-02f, -8.18783715e-02f, -4.48583951e-03f, -1.27851292e-01f, 4.17195931e-02f,
  -1.38113229e-03f, -8.94326195e-02f, 1.02486558e-01f, 2.17681631e-01f, -2.15340465e-01f, 1.56539798e-01f, -2.11378168e-02f, -1.03214338e-01f, 1.71662867e-01f, 3.06201149e-02f,
  -1.02308728e-01f, 1.65879443e-01f, 2.25383751e-02f, 2.36920461e-01f, -4.29285280e-02f, -4.25423905e-02f, -1.41995981e-01f, 1.52495801e-01f, -5.24395928e-02f, -4.22060415e-02f,
  -1.07296750e-01f, -7.95011446e-02f, -3.82200256e-02f, -3.88921313e-02f, -1.10292196e-01f, -7.18525723e-02f, -1.20671108e-01f, -1.83628704e-02f, -1.49170617e-02f, -8.32449738e-03f,
  -6.93914369e-02f, 4.93262857e-02f, 2.09889691e-02f, 4.97726016e-02f, -7.15305358e-02f, -2.86260843e-02f, 2.46166624e-02f, 3.32869813e-02f, 7.75407851e-02f, -2.61233393e-02f,
  1.23323381e-01f, 9.48629901e-02f, -2.34068669e-02f, -4.58800420e-02f, -5.56938164e-03f, 6.79894537e-02f, 2.90364902e-02f, -2.07101125e-02f, -1.45433813e-01f, -9.11498442e-02f,
  1.31213605e-01f, -6.80385828e-02f, 1.33552589e-02f, 8.59182794e-03f, 2.57041864e-03f, -2.21612640e-02f, 1.04508840e-03f, 6.63256943e-02f, -2.00317167e-02f, 6.72809854e-02f,
  7.29236156e-02f, -9.45068225e-02f, 4.47702110e-02f, 2.61040963e-02f, -2.07164548e-02f, -5.32765873e-02f, 2.88390983e-02f, 1.73609089e-02f, -1.73060913e-02f, 5.47429547e-04f,
  -2.47329231e-02f, 2.73780450e-02f, -1.24801872e-02f, -3.39166187e-02f, 2.00358853e-02f, 3.57684419e-02f, 6.40411004e-02f, 1.09499685e-01f, -1.82173811e-02f, -7.30173886e-02f,
  -2.75478065e-01f, -2.71914393e-01f, -2.00135745e-02f, -7.52692670e-02f, 2.33491417e-03f, 6.00648336e-02f, 5.54930717e-02f, -3.11394911e-02f, 2.32089777e-02f, -8.88116211e-02f,
  -1.01293795e-01f, -5.22551052e-02f, -4.64373045e-02f, -2.71557793e-02f, 3.34425084e-03f, 2.99798790e-02f, -3.17558162e-02f, -2.43586339e-02f, -1.14286266e-01f, -2.07333658e-02f,
  -9.18147191e-02f, -5.55562526e-02f, 2.18933411e-02f, -7.86944851e-03f, 2.51755398e-02f, -3.11318263e-02f, -1.03906043e-01f, 2.18869206e-02f, 1.11920675e-02f, 8.56707618e-02f,
  1.26612440e-01f, 3.52905765e-02f, -4.05190652e-03f, 2.59009808e-01f, -9.77484211e-02f, -3.38230103e-01f, -4.89811689e-01f, 7.95812532e-02f, -1.40523121e-01f, -7.62212649e-02f,
  1.26207963e-01f, 8.40326324e-02f, 5.20491647e-03f, 1.77264303e-01f, 1.99006885e-01f, -3.58897932e-02f, 9.30922851e-02f, -1.16198674e-01f, 4.37932089e-02f, 7.37980604e-02f,
  2.54989177e-01f, 1.31253257e-01f, 2.05826163e-01f, 1.30159393e-01f, 4.29174192e-02f, 1.85292855e-01f, 4.15616959e-01f, 2.38728747e-02f, 1.76491097e-01f, 1.76060408e-01f,
  -1.16797350e-01f, 9.75638628e-02f, -7.19498750e-03f, -6.15217499e-02f, -6.66404888e-02f, -1.57216251e-01f, -1.15352213e-01f, 1.35917915e-02f, 2.68981587e-02f, 3.18506882e-02f,
  -8.14962387e-02f, 8.92845988e-02f, -6.22109603e-03f, 4.86293733e-02f, -2.46471018e-02f, 4.98336228e-03f, 9.68253333e-03f, -2.27165991e-03f, -9.78209917e-03f, 1.63765065e-02f,
  -1.79038045e-03f, -1.65147111e-02f, 1.71974842e-02f, -1.08823426e-01f, 3.72621194e-02f, -7.30589703e-02f, -3.26906405e-02f, 8.68653208e-02f, 2.70217657e-02f, -1.80196445e-02f,
  9.80787501e-02f, 4.37950864e-02f, -2.50515863e-02f, -6.19798154e-03f, 5.93049638e-02f, -6.19655512e-02f, 2.85062585e-02f, 1.05799891e-01f, 9.30823609e-02f, -5.66640683e-02f,
  7.71756470e-03f, -3.53584215e-02f, -2.12691328e-03f, 7.47417510e-02f, -2.86517385e-02f, 7.07035363e-02f, 3.24432887e-02f, 3.88653427e-02f, -9.26318914e-02f, -2.79385187e-02f,
  3.65609396e-03f, -4.03656736e-02f, -3.59739996e-02f, 1.58706456e-02f, -1.62226278e-02f, -1.75419718e-03f, 1.75174192e-01f, -1.53617933e-02f, 1.97443105e-02f, -2.05356218e-02f,
  8.93346965e-02f, 3.64686638e-01f, -8.17973837e-02f, 6.54191226e-02f, -4.76140715e-02f, -1.19181380e-01f, -7.69520253e-02f, 3.66084836e-02f, 1.07967876e-01f, -6.65474832e-02f,
  4.94506173e-02f, -3.74555141e-02f, -2.71245074e-02f, 2.12975480e-02f, 7.09757060e-02f, 1.13946944e-01f, 6.46042004e-02f, 1.39461728e-02f, 2.94693802e-02f, 1.25332609e-01f,
  7.45455623e-02f, -3.60771045e-02f, 5.30289374e-02f, -1.06030844e-01f, -1.99887399e-02f, 2.56075226e-02f, -2.40199491e-02f, -3.77437361e-02f, 7.96596780e-02f, 5.52275553e-02f,
  3.22951645e-01f, 2.00369105e-01f, -6.79256469e-02f, 1.50052994e-01f, -1.61682472e-01f, -1.57033518e-01f, -1.93631336e-01f, 1.25289097e-01f, -1.09301373e-01f, 3.64451259e-02f,
  1.24981031e-01f, -5.35698794e-02f, -3.92569266e-02f, 3.71657491e-01f, 1.10910445e-01f, -1.09283373e-01f, 2.59054244e-01f, 3.68460678e-02f, -3.13560441e-02f, 2.29811087e-01f,
  9.68900919e-02f, 3.05977315e-01f, 1.81251481e-01f, 2.60865092e-01f, 1.29207626e-01f, 1.50291115e-01f, 1.66377574e-01f, -6.25321493e-02f, 2.66991436e-01f, 9.87141579e-03f,
  -5.44694066e-02f, 7.78549463e-02f, -1.75543558e-02f, -2.21010577e-02f, 2.97036357e-02f, 9.12475735e-02f, -8.13678801e-02f, -1.03539927e-03f, 3.69987972e-02f, 5.98586462e-02f,
  -7.82101825e-02f, 1.01601139e-01f, -5.54821566e-02f, 7.66241224e-03f, 7.97709078e-03f, -3.65130678e-02f, -5.52581437e-02f, -9.66468006e-02f, 5.02850711e-02f, 1.48127377e-01f,
  -5.79001531e-02f, 2.79815178e-02f, -5.02988584e-02f, 3.40257995e-02f, 6.24307357e-02f, 4.56693135e-02f, -4.75498624e-02f, -1.34467557e-01f, -4.89578880e-02f, 2.33688354e-02f,
  7.29578212e-02f, -3.58053558e-02f, 5.82803227e-02f, 5.02473786e-02f, 3.39220725e-02f, 8.59242156e-02f, -3.55048329e-02f, -5.46148606e-02f, -5.85349556e-03f, 7.29694515e-02f,
  3.79588231e-02f, 4.67157885e-02f, 2.03326880e-03f, 2.02283114e-02f, 5.75392321e-02f, -2.55400930e-02f, -1.30329445e-01f, 3.66221890e-02f, -7.32800981e-04f, -5.95930889e-02f,
  1.63508784e-02f, 1.20052740e-01f, -2.84886956e-02f, -8.14557597e-02f, 1.70394517e-02f, 7.98692256e-02f, 5.60600683e-02f, 1.11899704e-01f, -4.90902737e-02f, -2.58962177e-02f,
  7.55103528e-02f, 1.00265093e-01f, -4.88360822e-02f, -6.40036985e-02f, -4.51370440e-02f, 9.15775821e-02f, 2.58133505e-02f, 4.96398844e-02f, 6.15921989e-02f, -2.26834621e-02f,
  9.54248905e-02f, -1.03032775e-02f, -3.00146360e-02f, 4.87698764e-02f, 2.50824192e-03f, 1.66454967e-02f, -3.53102828e-03f, 2.59741973e-02f, 1.23505294e-02f, 1.00551941e-01f,
  7.68747926e-02f, -5.98316006e-02f, 1.84598099e-02f, -1.16325952e-01f, 4.34587933e-02f, -7.13560581e-02f, -4.24688794e-02f, -9.10561532e-02f, 7.59254172e-02f, 8.42537452e-03f,
  -7.06925929e-01f, 2.40114897e-01f, -8.49268436e-02f, -4.28972632e-01f, 1.61065102e-01f, 6.54654652e-02f, -4.32567596e-02f, 1.43859610e-01f, -1.86938390e-01f, 6.38565496e-02f,
  1.06805347e-01f, -1.54675215e-01f, 1.43520981e-01f, -2.54665494e-01f, -2.62249231e-01f, -1.77504376e-01f, -1.52002409e-01f, -9.31699798e-02f, -3.54102366e-02f, -5.79392835e-02f,
  -1.99925322e-02f, 8.86932388e-02f, -2.30147038e-02f, 4.19711024e-01f, 2.82928790e-03f, 7.35968351e-02f, 4.93108761e-03f, 2.68445760e-01f, 2.62825470e-02f, 8.89327228e-02f,
  3.44616510e-02f, 5.29438490e-03f, -5.71777159e-03f, 5.81597090e-02f, -2.28290539e-02f, 1.03914207e-02f, -1.20068633e-03f, 6.44310378e-03f, 6.16088789e-03f, 5.19144023e-03f,
  -7.29791224e-02f, -1.79039082e-03f, -5.24797365e-02f, 1.24895915e-01f, 6.13665469e-02f, 2.48401202e-02f, 4.77104709e-02f, -5.43103255e-02f, 6.58041760e-02f, 7.45911896e-02f,
  -4.54659499e-02f, -3.61040942e-02f, -1.05814738e-02f, -1.11892246e-01f, -3.85685340e-02f, -1.18225357e-02f, -8.13245326e-02f, -2.75726747e-02f, 6.61998102e-03f, -7.00817555e-02f,
  -4.84081618e-02f, -3.76506336e-02f, 2.81084906e-02f, 2.85150396e-04f, 4.70947549e-02f, 1.00226082e-01f, 2.63933539e-02f, -2.63184588e-02f, -2.54547074e-02f, -1.04307628e-03f,
  -1.42729282e-02f, 7.59526156e-03f, -3.82331759e-02f, 1.22483401e-02f, -5.11977747e-02f, -4.09880653e-02f, -8.02668929e-02f, 2.92419214e-02f, -1.41671328e-02f, -2.26864293e-02f,
  5.69856949e-02f, -5.32243438e-02f, 2.06607506e-02f, -1.81347746e-02f, 7.09302202e-02f, -6.24170303e-02f, 8.03527012e-02f, 4.65204082e-02f, -6.38820007e-02f, 3.57295759e-02f,
  5.29654697e-02f, -2.71406062e-02f, 6.31345063e-02f, 7.31138363e-02f, 2.35908926e-02f, -2.21543554e-02f, -5.29122874e-02f, -1.52835725e-02f, -3.05325408e-02f, 5.08725271e-03f,
  4.93404977e-02f, 2.60713380e-02f, -2.01612115e-02f, -3.53996381e-02f, 4.94255610e-02f, 2.91403872e-03f, -4.89732213e-02f, 6.15096278e-03f, -2.22805887e-02f, 1.39141560e-01f,
  7.47206956e-02f, 3.33877504e-02f, 9.16591473e-03f, 4.41995598e-02f, 6.67902688e-03f, 5.33966906e-02f, -3.85990255e-02f, 5.67674898e-02f, -2.16652211e-02f, 2.36580782e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 8)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 8;
const float L0_fan_Bp_bar_data[] = {
  2.84059439e-02f, 1.99650005e-01f, 3.87417912e-01f, 1.13473602e-01f, 3.02982255e-04f, 6.39316961e-02f, 8.52336287e-02f, 1.80045947e-01f
};

// L1_fan_Wp (Shape: 12 x 32)
const int L1_fan_Wp_rows = 12;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  -1.49268106e-01f, 1.99152455e-01f, 4.72818255e-01f, 2.48461604e-01f, -1.19707443e-01f, 1.92827746e-01f, -1.42262354e-02f, 4.55838054e-01f, -1.09954342e-01f, -1.24455310e-01f,
  7.12040579e-03f, 9.29718390e-02f, 4.35703807e-02f, -1.11436537e-02f, 1.66959107e-01f, 7.56795928e-02f, -2.68325686e-01f, -3.29321101e-02f, -4.03276533e-01f, 3.32597882e-01f,
  -6.14541434e-02f, 1.11372530e-01f, 3.31208348e-01f, -2.08307996e-01f, -2.38157943e-01f, 1.04720429e-01f, 1.60688624e-01f, -3.03378344e-01f, 1.56318545e-01f, -1.94631472e-01f,
  -3.23224604e-01f, 4.96044248e-01f, -5.14934808e-02f, -1.61132053e-01f, -3.22581410e-01f, 5.75005636e-02f, -2.41292417e-01f, -6.16060942e-03f, 1.51774034e-01f, 1.38255492e-01f,
  6.09079935e-02f, -1.67798057e-01f, -6.00590147e-02f, 3.35075706e-01f, -2.22904146e-01f, 3.63151282e-01f, 2.77591616e-01f, 4.41705018e-01f, 2.91380286e-01f, -1.15490891e-01f,
  -7.35149309e-02f, 1.12603195e-01f, 2.85306983e-02f, 2.62916535e-01f, 2.29664724e-02f, -2.68152893e-01f, 4.90662828e-03f, -2.61456758e-01f, -1.11752041e-01f, 1.64893240e-01f,
  2.00579152e-01f, -8.56507942e-02f, -3.11893702e-01f, 3.51502150e-01f, -6.04762845e-02f, 2.94614322e-02f, -4.93554249e-02f, -1.46809071e-01f, -4.24596220e-02f, -4.42042015e-03f,
  3.01789995e-02f, -2.99808402e-02f, 2.26839036e-01f, 1.11923918e-01f, -1.51648208e-01f, 1.63388297e-01f, -2.11824656e-01f, 3.47395152e-01f, 1.73617005e-01f, 1.26881734e-01f,
  2.97774494e-01f, -1.80923685e-01f, 1.56363666e-01f, -7.50071630e-02f, -7.19298273e-02f, 1.31550282e-01f, -1.44196674e-01f, -3.27641308e-01f, -1.29340634e-01f, -2.56144941e-01f,
  -8.13668370e-02f, 6.22640923e-02f, 3.02223593e-01f, 1.93396240e-01f, -1.62783582e-02f, 1.83620036e-01f, -1.94827303e-01f, 6.06932454e-02f, -2.70629942e-01f, -9.62997526e-02f,
  -1.56907648e-01f, 1.16640888e-01f, 2.60493577e-01f, 2.45692641e-01f, -2.70115435e-01f, -1.94348738e-01f, -1.81731731e-01f, -2.00295858e-02f, -2.99553007e-01f, 3.03611755e-01f,
  1.48973197e-01f, 2.92783380e-01f, 5.86784482e-02f, -3.45834315e-01f, -1.00027151e-01f, 2.70127386e-01f, -3.03443730e-01f, -2.52207339e-01f, -1.07540444e-01f, 2.41236351e-02f,
  -1.20034754e-01f, 7.24215433e-02f, 1.38718272e-02f, 8.35089311e-02f, 2.64840908e-02f, 2.36742929e-01f, 1.99602377e-02f, -1.44858897e-01f, -2.71476388e-01f, 2.36376897e-01f,
  2.38335002e-02f, -3.25880870e-02f, -1.47829250e-01f, 3.23796540e-01f, 1.50207788e-01f, 1.49790555e-01f, -2.89758414e-01f, -2.25298509e-01f, -1.41891032e-01f, -1.63561940e-01f,
  -2.79074788e-01f, -1.17834359e-01f, 1.63357630e-01f, 9.12444592e-02f, 8.49350542e-02f, -4.55861911e-03f, -2.54594564e-01f, 2.16837287e-01f, -1.09509146e-02f, -2.77317792e-01f,
  1.04605459e-01f, 3.46388817e-01f, -3.92587543e-01f, 1.96234271e-01f, -2.02884860e-02f, -2.09757909e-01f, -7.61798173e-02f, 1.28407285e-01f, -3.28400321e-02f, 1.65352538e-01f,
  2.67573506e-01f, -1.13852814e-01f, -1.52428523e-01f, -4.51099873e-02f, 5.68340868e-02f, -3.27091485e-01f, -3.20692420e-01f, -1.75754819e-02f, 1.01011984e-01f, 2.30368525e-01f,
  1.70232877e-01f, 2.22052768e-01f, 6.21314310e-02f, 6.36701379e-03f, -1.24018937e-01f, -1.03922144e-01f, -2.26720244e-01f, 2.81531036e-01f, 8.75780880e-02f, -4.09011066e-01f,
  -1.88184172e-01f, 2.99539149e-01f, -2.59164125e-01f, 4.03783843e-02f, 2.06634924e-01f, -6.39784634e-02f, 2.16610238e-01f, 1.33044958e-01f, 3.98301095e-01f, -2.35121250e-01f,
  7.61501566e-02f, 6.20409437e-02f, 2.25217372e-01f, -1.62337855e-01f, -5.16773872e-02f, 4.72132638e-02f, 1.87554166e-01f, -2.57597536e-01f, -5.64817013e-03f, 5.96693344e-03f,
  -2.04244219e-02f, 5.45123704e-02f, 6.13290407e-02f, 1.41244113e-01f, 4.07042533e-01f, 3.00373677e-02f, -2.27647170e-01f, 4.57143486e-02f, -4.85021204e-01f, -5.34915831e-04f,
  1.08487651e-01f, -1.70275465e-01f, 2.89787322e-01f, 4.45503622e-01f, -1.45241469e-01f, -1.38963595e-01f, 4.47654456e-01f, -3.82333715e-03f, -6.38449043e-02f, 3.36244196e-01f,
  6.54700696e-02f, -1.32786408e-01f, -1.13987558e-01f, -1.43759593e-01f, -8.38193372e-02f, 1.07459925e-01f, -2.33620062e-01f, -1.05134539e-01f, -3.42929699e-02f, 9.27739739e-02f,
  5.58920652e-02f, -2.06357956e-01f, 2.02587187e-01f, 2.81791091e-02f, -3.71934213e-02f, 1.23164831e-02f, -3.73149604e-01f, -4.36620414e-02f, -2.45324895e-01f, -1.37104854e-01f,
  3.72642905e-01f, 2.44701967e-01f, 2.30597436e-01f, -2.25390255e-01f, 2.21415281e-01f, -4.37107593e-01f, -1.70302704e-01f, 3.61477695e-02f, 1.94995314e-01f, -2.98229694e-01f,
  -2.91760832e-01f, 9.46829990e-02f, 2.92836092e-02f, 2.10898183e-02f, 2.73908526e-01f, -2.18921378e-01f, 6.79132417e-02f, -1.36367783e-01f, 1.41698927e-01f, 9.36156809e-02f,
  -7.44796768e-02f, -2.43798167e-01f, -4.06788886e-01f, -2.04204023e-01f, 1.92404762e-01f, 2.38979340e-01f, 1.75403625e-01f, -6.64778724e-02f, 2.83645213e-01f, -2.89890707e-01f,
  -1.70314416e-01f, -2.98753351e-01f, -4.64228652e-02f, 4.17472094e-01f, 2.07496554e-01f, -1.05053619e-01f, 3.00604850e-01f, 4.09758091e-01f, 2.29942650e-01f, -2.36368090e-01f,
  5.76124601e-02f, -1.75504476e-01f, 3.52159068e-02f, -8.17489922e-02f, -1.13222003e-02f, -1.78305134e-02f, -2.88051590e-02f, 6.69652671e-02f, 1.92638144e-01f, -7.27581456e-02f,
  2.34326631e-01f, 8.32367092e-02f, 1.75767645e-01f, -6.69704750e-02f, -1.49822999e-02f, -1.15684897e-01f, -4.99635190e-02f, 2.31085401e-02f, 1.04172044e-01f, -3.25867534e-01f,
  2.97074199e-01f, -3.25735986e-01f, -1.90572977e-01f, -3.42428714e-01f, -3.16131920e-01f, 7.86368772e-02f, 4.75196950e-02f, -5.80672584e-02f, -1.30636856e-01f, -1.95190370e-01f,
  -7.66511634e-02f, 4.22871113e-01f, 2.56598536e-02f, 2.36613035e-01f, -6.29191939e-03f, -1.66097045e-01f, -3.59193683e-01f, 1.88989982e-01f, 2.46601269e-01f, -2.93016493e-01f,
  -1.63034439e-01f, -1.02776242e-02f, -6.10375293e-02f, 6.60894215e-02f, -9.40826070e-03f, -6.16909936e-02f, 5.82980402e-02f, -6.68937489e-02f, 1.17168836e-01f, -2.10961282e-01f,
  -1.77037045e-02f, -3.39801721e-02f, -3.49832736e-02f, -1.11613283e-02f, -1.80531457e-01f, -1.61975678e-02f, -8.23517889e-02f, 1.52678147e-01f, -6.64629415e-02f, 7.89478198e-02f,
  3.79901499e-01f, -7.50451684e-02f, -1.33488355e-02f, -1.39587745e-01f, 2.55865425e-01f, 5.58539852e-02f, -4.31345344e-01f, -1.76311240e-01f, -2.20956624e-01f, 8.75810459e-02f,
  4.78160232e-02f, -1.22009143e-01f, 3.11274845e-02f, -7.64682293e-02f, -1.95824310e-01f, 5.40634058e-02f, 1.39170513e-01f, -1.10754766e-01f, -2.40928270e-02f, -1.14899591e-01f,
  -1.17818937e-01f, -1.06236920e-01f, -9.74259228e-02f, -2.26077169e-01f, 3.26543868e-01f, -1.55885652e-01f, 1.02741331e-01f, -8.74127969e-02f, -2.04264238e-01f, -1.79739550e-01f,
  1.87826633e-01f, -4.41687834e-03f, -1.39596285e-02f, -8.13825652e-02f, -8.54967609e-02f, 2.42509782e-01f, -1.99762449e-01f, 2.23569974e-01f, -3.44825946e-02f, 2.34937686e-02f,
  -3.71386766e-01f, 2.82369792e-01f, 2.30548277e-01f, -2.70139754e-01f
};

// L1_fan_Wp_bar (Shape: 8 x 32)
const int L1_fan_Wp_bar_rows = 8;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  4.19621348e-01f, -7.67869353e-02f, -3.33783627e-01f, -1.42884448e-01f, 3.45390081e-01f, 5.02663143e-02f, 2.50278175e-01f, -1.79197773e-01f, 3.61828059e-01f, 4.11134690e-01f,
  -1.55971363e-01f, 4.17331606e-01f, 6.73396140e-02f, 2.57698923e-01f, 4.62611526e-01f, 7.53765553e-02f, 5.02463281e-01f, -4.15866852e-01f, 5.11882067e-01f, -3.44668657e-01f,
  -1.75277680e-01f, -9.35594514e-02f, -7.14967325e-02f, 2.85308540e-01f, -4.98842746e-02f, -8.27863812e-02f, 2.42030844e-01f, 7.19500780e-01f, -4.68504466e-02f, 6.80876195e-01f,
  2.46947572e-01f, -2.38024831e-01f, -5.41275088e-03f, 2.49643043e-01f, 3.04382771e-01f, 6.82807490e-02f, 9.29472521e-02f, 4.12077159e-01f, 1.50553733e-01f, 1.93662792e-01f,
  2.39145420e-02f, 3.66356969e-02f, 8.13966915e-02f, 3.72907408e-02f, -6.33680999e-01f, 1.93573833e-01f, 1.75670281e-01f, 2.23013818e-01f, 4.16929156e-01f, -1.95144117e-01f,
  -1.39701262e-01f, 9.37072113e-02f, -5.62231243e-01f, -4.28676158e-01f, 6.56353235e-02f, 1.38743713e-01f, -1.36959150e-01f, 7.52942786e-02f, 1.29647315e-01f, 2.19262280e-02f,
  4.81867045e-01f, 3.48703228e-02f, 7.87325203e-02f, 4.79181975e-01f, 1.69724494e-01f, 2.36933917e-01f, 4.53891754e-01f, 2.59921223e-01f, 7.03804791e-02f, 6.83617964e-02f,
  -1.99395772e-02f, 3.33949536e-01f, -1.21349946e-01f, 2.00124294e-01f, 2.92468488e-01f, 2.19115205e-02f, 5.02099544e-02f, -4.82945144e-01f, 2.01654106e-01f, -3.96156371e-01f,
  -2.15853199e-01f, 3.79727334e-01f, -2.41089135e-01f, -1.33652955e-01f, -8.43397006e-02f, -5.76576628e-02f, 3.21806222e-01f, 3.54048103e-01f, -5.52054755e-02f, 4.98648018e-01f,
  7.29714274e-01f, -1.02329785e-02f, -1.00218184e-01f, 2.56461576e-02f, 2.62889922e-01f, 1.66767895e-01f, 4.57499415e-01f, 1.04663372e-01f, -4.46842099e-03f, 8.13026577e-02f,
  5.12449622e-01f, -4.01446335e-02f, -1.82052314e-01f, -3.73051196e-01f, 3.17334652e-01f, 3.13053012e-01f, 2.41744429e-01f, 2.67494380e-01f, -3.26573439e-02f, -1.01212114e-01f,
  -3.20828527e-01f, -2.81239241e-01f, 4.04209346e-01f, 2.54988551e-01f, 5.28050542e-01f, -2.94405341e-01f, 5.84824160e-02f, -1.27463758e-01f, -1.27217457e-01f, -1.80444270e-02f,
  4.37849522e-01f, -3.36632997e-01f, 1.00345351e-02f, 3.68254334e-01f, 3.21893752e-01f, -3.91656607e-02f, 1.73809990e-01f, 1.43631384e-01f, 1.99966729e-02f, 3.11004519e-01f,
  2.92880774e-01f, 2.22172290e-01f, -1.23991072e-03f, 7.03495815e-02f, 1.01512961e-01f, -7.35466927e-02f, 4.88357067e-01f, -3.98842208e-02f, 3.33224922e-01f, 3.42476219e-01f,
  -1.69247448e-01f, -5.08217812e-01f, -1.05099291e-01f, -5.46796501e-01f, 2.14463353e-01f, 4.33995605e-01f, 9.94564891e-02f, 4.12453972e-02f, 4.33932006e-01f, -3.95876706e-01f,
  3.54331762e-01f, -2.38211140e-01f, 3.61672670e-01f, 5.16205877e-02f, -3.06551121e-02f, -2.84591258e-01f, -5.33161998e-01f, 1.66365430e-01f, 2.81754881e-01f, 1.48904413e-01f,
  1.96515262e-01f, 1.90087110e-01f, 4.21799242e-01f, 8.47553462e-02f, 2.08827928e-01f, 2.00742528e-01f, 2.06045926e-01f, 3.12320590e-01f, -8.87484383e-03f, 1.71717197e-01f,
  2.30327398e-01f, 4.34241861e-01f, -2.26549972e-02f, 3.08409538e-02f, 8.41995776e-02f, 8.25740919e-02f, -1.78771302e-01f, -5.51071689e-02f, -2.56857961e-01f, -2.95092501e-02f,
  -3.25371444e-01f, 3.07601273e-01f, 2.35488147e-01f, 2.02407956e-01f, -2.68763125e-01f, -1.37564629e-01f, 6.09311283e-01f, -1.00668264e-03f, 5.15677869e-01f, -2.66965121e-01f,
  -2.53791422e-01f, 5.33365905e-01f, 8.41341261e-03f, 3.79373074e-01f, -7.79474378e-02f, 1.56460375e-01f, 1.29678354e-01f, 2.93440461e-01f, 2.49150455e-01f, 1.13448612e-01f,
  2.15723321e-01f, -2.70152181e-01f, 2.37613678e-01f, -6.53893799e-02f, -2.04655543e-01f, -1.00783706e-01f, -1.96749493e-01f, -2.62410752e-02f, 2.77075283e-02f, 1.80731550e-01f,
  5.56306168e-02f, 4.20778662e-01f, 3.92389446e-01f, -5.45322537e-01f, -8.10981095e-02f, -3.53591651e-01f, 3.58328879e-01f, 4.34385806e-01f, -4.61212903e-01f, -2.27275506e-01f,
  -5.00995338e-01f, 3.79440516e-01f, 5.27503073e-01f, -3.54871191e-02f, 4.11245748e-02f, 3.31446737e-01f, 3.50308239e-01f, 1.30866244e-01f, 2.51382351e-01f, 4.11532283e-01f,
  2.41946176e-01f, 3.54221255e-01f, -7.59813562e-02f, -1.47017568e-01f, 5.06519489e-02f, -1.57892898e-01f, 9.07210484e-02f, 9.32273939e-02f, 7.66518014e-03f, 1.10962912e-01f,
  -4.13332224e-01f, -2.85817683e-01f, -2.02801153e-01f, 1.55769646e-01f, 5.05770370e-02f, -1.38134763e-01f, -9.74590033e-02f, 2.45640315e-02f, 5.14767580e-02f, 5.90046048e-01f,
  1.90580100e-01f, -8.87288600e-02f, -1.14763670e-01f, 3.18677932e-01f, 1.74570709e-01f, 1.69672385e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 8)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 8;
const float L1_fan_Bp_bar_data[] = {
  4.07455474e-01f, 1.88718408e-01f, 2.05952391e-01f, 2.38790095e-01f, 2.15079740e-01f, 3.92999560e-01f, 3.73192102e-01f, 1.44061953e-01f
};

// L2_fan_Wp (Shape: 12 x 32)
const int L2_fan_Wp_rows = 12;
const int L2_fan_Wp_cols = 32;
const float L2_fan_Wp_data[] = {
  -2.11219370e-01f, 2.37027511e-01f, -1.54228173e-02f, -4.15760316e-02f, 8.53502098e-03f, -2.69321948e-01f, 8.18019584e-02f, 3.60388234e-02f, 1.65623516e-01f, 2.69558460e-01f,
  1.01641931e-01f, -2.35950857e-01f, 2.43108466e-01f, 2.67546952e-01f, 2.99899310e-01f, -1.90622464e-01f, -2.25603417e-01f, 4.89868820e-02f, 3.28814648e-02f, 8.86330009e-02f,
  1.37734160e-01f, -3.71415854e-01f, -1.16864122e-01f, -2.58883923e-01f, -1.94125861e-01f, 1.19461216e-01f, 9.22498014e-03f, -1.22252092e-01f, 1.52846009e-01f, 2.50742465e-01f,
  -2.93269694e-01f, -2.06066091e-02f, -1.21791484e-02f, 4.62179743e-02f, 4.14850237e-03f, 2.26255390e-03f, 1.05929963e-01f, 3.78288068e-02f, 1.88904390e-01f, 9.64175835e-02f,
  1.36730388e-01f, 4.85429876e-02f, 1.35418281e-01f, 1.01396158e-01f, 2.14717854e-02f, 2.31751144e-01f, 1.93333834e-01f, 9.37546194e-02f, -1.52125120e-01f, 2.80383050e-01f,
  1.12109169e-01f, -1.84414178e-01f, -3.99368145e-02f, -2.01618850e-01f, -1.76408455e-01f, -2.00074255e-01f, 8.92922655e-02f, -3.26884836e-02f, -8.87171850e-02f, -6.38925955e-02f,
  -3.18770230e-01f, 3.20040554e-01f, -2.30342060e-01f, 1.73475146e-01f, -1.00622214e-01f, -4.90584746e-02f, -2.35133190e-02f, 3.14123362e-01f, 6.35540336e-02f, -4.83760275e-02f,
  -2.42475241e-01f, -1.77677974e-01f, -3.17606032e-02f, -1.78217232e-01f, -1.17820717e-01f, -2.70567209e-01f, 1.91869855e-01f, 9.13772807e-02f, 2.61320006e-02f, 2.20629215e-01f,
  2.77878672e-01f, -1.25627667e-01f, -7.07820505e-02f, 1.13062143e-01f, -3.50413173e-01f, -2.59713769e-01f, 8.68635625e-02f, -6.72869086e-02f, -3.13701719e-01f, 3.16122949e-01f,
  -1.16415255e-01f, 8.94684941e-02f, -2.74448991e-01f, -4.67303693e-02f, 1.61054775e-01f, 3.37594181e-01f, -9.88295209e-03f, 1.76518604e-01f, 3.33430022e-02f, 1.50777832e-01f,
  -1.12471938e-01f, 7.00606257e-02f, -2.43121371e-01f, -1.18451983e-01f, -3.89272198e-02f, 2.39591058e-02f, 1.22578800e-01f, 3.19141038e-02f, -1.14608251e-01f, -1.73953071e-01f,
  -1.61752120e-01f, 4.48566228e-02f, 1.54845357e-01f, -3.22939962e-01f, 1.21494658e-01f, 2.00666994e-01f, -6.39771670e-02f, 2.04887033e-01f, 2.38706455e-01f, -2.83629429e-02f,
  -7.58990049e-02f, 3.00585181e-02f, -1.47777990e-01f, 1.53820038e-01f, 3.59023631e-01f, -2.39776239e-01f, 3.03675681e-01f, 2.58303396e-02f, -1.38955951e-01f, 6.65326649e-03f,
  4.83242385e-02f, 2.64052041e-02f, -2.48791218e-01f, -1.62958488e-01f, -1.84180245e-01f, -3.68700236e-01f, -8.67890939e-02f, -1.67064108e-02f, 4.17822860e-02f, -1.63625911e-01f,
  -2.40480125e-01f, -2.01262031e-02f, 1.12163223e-01f, 2.28784606e-01f, 2.76056826e-01f, -1.62364632e-01f, -4.04614687e-01f, 3.90356719e-01f, -1.08893730e-01f, -1.73002422e-01f,
  2.00980008e-02f, 6.88146874e-02f, -1.08498849e-01f, 2.53831387e-01f, -6.80615306e-02f, 2.34562233e-01f, 2.41094157e-01f, -1.23010101e-02f, 1.53327689e-01f, -1.22541897e-01f,
  -7.51931816e-02f, 5.87639660e-02f, -1.21176071e-01f, 6.80056540e-03f, -1.45551592e-01f, -2.47712463e-01f, 4.54731137e-02f, -1.52097538e-01f, -8.89451578e-02f, 9.15254578e-02f,
  2.38662865e-02f, 1.20099224e-01f, -3.44222397e-01f, -2.31062025e-01f, -1.63313881e-01f, -3.20244044e-01f, -5.49107380e-02f, 2.09354714e-01f, 2.71229625e-01f, 1.14910550e-01f,
  1.59624174e-01f, 2.32124075e-01f, 5.53972311e-02f, -4.24220525e-02f, -3.43506895e-02f, -3.13368529e-01f, 9.02027041e-02f, 2.49131873e-01f, 1.47002563e-01f, -1.76935926e-01f,
  9.48220491e-02f, -1.85034856e-01f, -8.73100385e-02f, 1.00567937e-01f, 1.81755908e-02f, -9.50304642e-02f, -2.44923830e-02f, -1.02658503e-01f, 3.41734916e-01f, -1.50390700e-01f,
  1.66595995e-01f, 1.96816131e-01f, 1.94527030e-01f, -2.84532830e-02f, -3.69771123e-01f, 8.72672573e-02f, 1.75744653e-01f, -1.51621088e-01f, -3.72334093e-01f, 1.90061897e-01f,
  7.86374360e-02f, 3.12522687e-02f, 1.64302096e-01f, -2.16064095e-01f, -2.05477148e-01f, -2.35609427e-01f, 3.84021699e-01f, -2.76580423e-01f, -7.24392533e-02f, 5.93058951e-02f,
  -6.01417292e-03f, -6.17323890e-02f, -1.76529929e-01f, -1.09260455e-01f, -1.85274109e-02f, 1.87035382e-01f, 1.60776287e-01f, 2.33031869e-01f, -1.85520146e-02f, -2.99347360e-02f,
  -4.13420834e-02f, 8.80387053e-02f, 2.68738776e-01f, 1.13203138e-01f, 1.20269641e-01f, 2.00083423e-02f, 2.02010557e-01f, 2.79054403e-01f, 2.30311602e-01f, 9.57325995e-02f,
  -2.11623684e-02f, -1.90099448e-01f, 2.13571578e-01f, -1.83655217e-01f, -2.88500369e-01f, -4.05336827e-01f, -2.38790452e-01f, -2.38872036e-01f, 1.09263852e-01f, 5.40774539e-02f,
  -2.84464031e-01f, -2.44434550e-01f, -7.84006491e-02f, 8.96759182e-02f, 2.82280128e-02f, 3.57757434e-02f, -3.70317027e-02f, -1.10614032e-01f, -4.68479171e-02f, -7.18003809e-02f,
  -6.65367767e-02f, -2.86582589e-01f, -4.51207981e-02f, -3.10306370e-01f, 1.84926409e-02f, -1.76131632e-02f, -9.58419666e-02f, -2.17490435e-01f, -2.93734074e-01f, -2.89507713e-02f,
  2.00749803e-02f, -6.83023557e-02f, 5.05803898e-02f, -1.63956955e-01f, -2.07876321e-02f, 2.16151625e-01f, -9.63932276e-02f, -4.68769521e-02f, 1.97699472e-01f, 4.83302660e-02f,
  1.22696243e-01f, -8.72597992e-02f, -2.86940455e-01f, 2.65668064e-01f, 1.08102135e-01f, -3.31270278e-01f, 2.69426525e-01f, -2.10362345e-01f, -6.20860383e-02f, 1.95111930e-01f,
  1.97231770e-01f, 1.97478801e-01f, 7.71675352e-03f, -1.39011860e-01f, -1.28821760e-01f, -2.23778680e-01f, 4.44436707e-02f, 1.18485078e-01f, 1.57412976e-01f, -7.89047498e-03f,
  -2.30304077e-01f, 2.52947165e-03f, -2.68261850e-01f, -1.37155950e-01f, -9.16040018e-02f, -1.82921901e-01f, 2.89351046e-01f, 2.92322785e-01f, -1.01913221e-01f, 1.45709187e-01f,
  2.99652487e-01f, -7.79478475e-02f, 1.41484058e-02f, -1.38089925e-01f, -1.52222902e-01f, 2.58460730e-01f, 1.15524337e-01f, -2.15365797e-01f, 3.02556127e-01f, 6.90379143e-02f,
  7.82430843e-02f, 1.03973240e-01f, 1.23864427e-01f, 1.42039582e-01f, 6.25600070e-02f, 3.58683169e-02f, 9.89106596e-02f, 1.35111198e-01f, 2.17817068e-01f, 1.31951079e-01f,
  1.03449948e-01f, 6.48177117e-02f, -8.70982334e-02f, -6.15194300e-03f, 4.65650437e-03f, -3.01027987e-02f, -1.99949577e-01f, 3.67275923e-02f, 4.03522134e-01f, -1.79359436e-01f,
  -4.10836972e-02f, -2.32374370e-02f, 1.60304397e-01f, 1.10960513e-01f, 2.75621325e-01f, -2.73138881e-01f, -8.36845338e-02f, -1.89766496e-01f, -1.09140076e-01f, -1.91540584e-01f,
  2.48749778e-01f, 2.12031841e-01f, -2.32173912e-02f, -1.38396755e-01f, -1.65857747e-01f, -4.57329638e-02f, 1.70923732e-02f, 5.39232977e-02f, -1.12333283e-01f, 1.63267896e-01f,
  -1.28857046e-01f, -1.06538050e-01f, -1.64803669e-01f, -1.33237243e-01f, -6.05258159e-03f, 2.75970817e-01f, 2.33875602e-01f, 3.10655773e-01f, 3.05166662e-01f, -2.27298647e-01f,
  -3.43189120e-01f, 1.00847989e-01f, -2.44186550e-01f, -2.39131719e-01f, -5.39450757e-02f, 5.34710325e-02f, 1.48449972e-01f, 1.42791376e-01f, -1.30921155e-01f, -2.11339578e-01f,
  2.89850663e-02f, -2.78595760e-02f, -8.98080468e-02f, 3.16509642e-02f
};

// L2_fan_Wp_bar (Shape: 8 x 32)
const int L2_fan_Wp_bar_rows = 8;
const int L2_fan_Wp_bar_cols = 32;
const float L2_fan_Wp_bar_data[] = {
  -1.73605591e-01f, 1.52500078e-01f, -9.71720442e-02f, 2.26312011e-01f, 4.64002371e-01f, 2.82918960e-01f, 8.43619183e-02f, 1.67576432e-01f, 1.99328840e-01f, 3.40687484e-01f,
  2.01649174e-01f, 1.51306570e-01f, 6.80297554e-01f, -1.21981651e-01f, -2.65640080e-01f, -2.91026413e-01f, 1.68251127e-01f, 2.23149121e-01f, -9.67885181e-02f, -6.75038040e-01f,
  1.02690034e-01f, 6.46569133e-02f, -4.14047241e-01f, -2.91832745e-01f, -6.62533998e-01f, 5.98152280e-01f, 8.64518881e-01f, -2.09661007e-01f, 2.38648802e-01f, 9.64866161e-01f,
  -1.42219454e-01f, 3.35739821e-01f, -1.07720047e-01f, 1.63405165e-01f, 6.96627572e-02f, 3.13854218e-01f, 4.26450931e-02f, 1.41234219e-01f, -1.72440037e-01f, -2.19115932e-02f,
  2.22673967e-01f, 7.06856847e-02f, 3.96100402e-01f, 9.65337381e-02f, 1.76100820e-01f, -3.40775937e-01f, -5.74542105e-01f, -1.69293314e-01f, 4.11608309e-01f, -4.57215667e-01f,
  -1.18118897e-01f, -6.29087910e-03f, -2.96991080e-01f, 3.99919987e-01f, 2.72910416e-01f, 1.26772195e-01f, -4.22097623e-01f, 5.64817451e-02f, 4.37252223e-01f, -2.48077452e-01f,
  7.82007635e-01f, -1.50790453e-01f, 8.87161255e-01f, 6.10992074e-01f, 1.35355130e-01f, 2.82393306e-01f, 3.52988988e-01f, 7.45771676e-02f, -2.99919963e-01f, -1.82485133e-01f,
  1.64031327e-01f, -1.57652810e-01f, 1.86345339e-01f, 3.74935478e-01f, 1.99407294e-01f, 2.35286891e-01f, -5.38003564e-01f, 1.24039784e-01f, 2.96273917e-01f, -1.66941866e-01f,
  -3.98983389e-01f, 1.49930462e-01f, 2.27972642e-01f, 2.73409665e-01f, 1.51921645e-01f, -2.39726231e-01f, -1.32759914e-01f, -2.46925220e-01f, 6.70564950e-01f, -5.96349016e-02f,
  -2.33679578e-01f, 7.60387659e-01f, 3.08050036e-01f, 1.35639301e-02f, 6.27360269e-02f, -3.65540743e-01f, 1.00232745e-02f, 2.36647025e-01f, 4.41716075e-01f, 4.00728881e-01f,
  1.59674004e-01f, 2.60305882e-01f, -3.83027196e-01f, 2.68137485e-01f, 2.65684277e-01f, 2.93623149e-01f, 3.69948924e-01f, 4.71393585e-01f, 3.74898538e-02f, 4.90818590e-01f,
  5.77483326e-02f, 4.06994611e-01f, -1.76416747e-02f, -6.32899523e-01f, 3.41175586e-01f, -2.01678887e-01f, -5.58462203e-01f, -3.42838466e-01f, 4.99018162e-01f, -2.17981935e-02f,
  4.20927256e-01f, -1.26912028e-01f, -4.56186980e-01f, -1.56440258e-01f, 3.52409929e-01f, -2.98418343e-01f, 9.31816220e-01f, 3.03652078e-01f, -4.27890420e-01f, 1.89999819e-01f,
  1.61517039e-01f, 1.29475117e-01f, -3.42105508e-01f, -4.52611238e-01f, -1.70505226e-01f, -2.33536065e-01f, 1.32970646e-01f, 4.84144501e-03f, 2.87208319e-01f, -4.39447880e-01f,
  -4.34962064e-01f, 3.97887617e-01f, 6.11388564e-01f, 5.69894798e-02f, 1.79052860e-01f, -1.71810627e-01f, -4.07252282e-01f, 7.28798270e-01f, -3.27692926e-02f, -4.91305709e-01f,
  -1.35140315e-01f, -4.33838934e-01f, 3.96622181e-01f, 7.46915936e-01f, -6.19773418e-02f, 8.33557546e-01f, 6.17089868e-01f, 2.00370207e-01f, 3.84515077e-01f, -2.04110056e-01f,
  2.57156789e-01f, 3.90267879e-01f, 4.41250801e-01f, -3.93549651e-02f, 2.43835241e-01f, 9.36817974e-02f, 1.41558647e-01f, 1.93309888e-01f, 3.34134161e-01f, 4.55982447e-01f,
  2.02016875e-01f, 3.68900478e-01f, 2.45537683e-01f, -4.10717398e-01f, -3.16881508e-01f, -8.09098601e-01f, -6.99508369e-01f, 5.33764243e-01f, 7.69722641e-01f, -2.17440560e-01f,
  7.64904201e-01f, 1.56602293e-01f, 1.01230182e-02f, -2.79857635e-01f, -1.38727695e-01f, -4.07536596e-01f, 3.38360310e-01f, 7.63681293e-01f, 5.41434526e-01f, 4.27246571e-01f,
  6.60296828e-02f, 1.07133202e-01f, 7.25313544e-01f, -6.65884018e-01f, -8.49940926e-02f, -3.09371471e-01f, -6.15012646e-02f, 5.62283218e-01f, 1.94917157e-01f, 3.10416520e-01f,
  -2.94251144e-01f, -4.69033659e-01f, -2.63558060e-01f, 2.01498225e-01f, -4.45844680e-01f, -6.46847367e-01f, -1.50242746e-01f, 4.17344928e-01f, 1.73951238e-01f, 8.09611939e-03f,
  -3.56503516e-01f, 1.42983899e-01f, -1.53573081e-01f, 6.92969620e-01f, -1.21753864e-01f, 6.45821452e-01f, 1.00767720e+00f, 2.43130192e-01f, 5.02680719e-01f, 2.39675060e-01f,
  2.85070807e-01f, -1.77613065e-01f, 4.42186624e-01f, 4.03923154e-01f, 2.11396456e-01f, 2.45232835e-01f, 3.01494122e-01f, 4.18004125e-01f, 1.74046040e-01f, 9.58285928e-02f,
  1.22100666e-01f, 2.44111076e-01f, 2.22710952e-01f, 9.65483207e-03f, 3.71138845e-03f, -1.16591007e-01f, 1.23851351e-01f, 6.24146879e-01f, 5.62096536e-01f, 4.70403433e-01f,
  -2.10969359e-01f, 2.09097892e-01f, 2.19215199e-01f, -1.46244839e-01f, -5.92929959e-01f, -5.47299147e-01f, -4.03982073e-01f, -3.19494605e-01f, 8.99544716e-01f, 6.43399060e-01f,
  -1.45089328e-01f, 4.17054892e-01f, -4.50668037e-01f, 6.89104557e-01f, -1.41448006e-01f, 4.90045696e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 8)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 8;
const float L2_fan_Bp_bar_data[] = {
  3.12691778e-01f, 2.46677980e-01f, 2.26141334e-01f, 3.52969497e-01f, 2.11309388e-01f, 3.37891728e-01f, 1.71807021e-01f, 3.27097893e-01f
};

// L3_linear_W (Shape: 12 x 32)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 32;
const float L3_linear_W_data[] = {
  1.26214251e-01f, 1.43001780e-01f, 2.88982779e-01f, 1.95993990e-01f, -2.65263438e-01f, 4.89975065e-02f, -2.46270597e-01f, 1.72056794e-01f, 1.39498308e-01f, -2.30089858e-01f,
  -1.10973343e-02f, -1.36275021e-02f, 1.76005512e-01f, 2.53391325e-01f, -1.37470305e-01f, 3.34960103e-01f, 5.26376486e-01f, 4.21915501e-01f, 2.62904108e-01f, -1.28330034e-03f,
  6.20884836e-01f, 3.55059236e-01f, 5.45135066e-02f, -2.14283854e-01f, -9.58317161e-01f, -4.46372330e-01f, 3.44100803e-01f, -2.79483169e-01f, 6.15596354e-01f, -1.29076943e-01f,
  -7.53957152e-01f, 2.04815239e-01f, -7.25071505e-02f, -3.57371002e-01f, -3.23761463e-01f, -5.84629714e-01f, -1.36434898e-01f, -2.59592533e-01f, 1.61484763e-01f, -3.68868798e-01f,
  3.46108750e-02f, -3.63688916e-01f, 9.07199532e-02f, -2.61694223e-01f, -3.58717293e-01f, -5.08438110e-01f, -2.66472548e-01f, 1.62078738e-01f, 6.84875846e-01f, -7.27622062e-02f,
  1.62331030e-01f, -1.13314807e-01f, 5.68177402e-01f, -6.00805208e-02f, 1.19579406e-02f, -1.70539871e-01f, -7.87999451e-01f, -2.03538071e-02f, 2.89832503e-01f, -1.20940745e-01f,
  2.18833461e-01f, 2.57623613e-01f, 1.71709254e-01f, -9.26865637e-01f, -4.75049824e-01f, -1.55243650e-01f, 2.19007745e-01f, -3.23382467e-01f, 3.43567170e-02f, 1.93103611e-01f,
  -3.12414885e-01f, -4.83490117e-02f, 2.54753172e-01f, -2.85288632e-01f, -4.71929967e-01f, -2.14930251e-01f, -4.89722311e-01f, -5.21893680e-01f, -2.63354704e-02f, 2.59908497e-01f,
  -2.76156425e-01f, 2.84957498e-01f, -3.99364233e-01f, -2.64856607e-01f, -2.58993298e-01f, 2.12322146e-01f, 2.58412749e-01f, -2.46588752e-01f, -2.71635622e-01f, 3.13329726e-01f,
  -6.03650451e-01f, 3.29648644e-01f, -9.02639866e-01f, 2.10509077e-01f, 2.44693562e-01f, -9.82000887e-01f, 3.46727632e-02f, -3.65771323e-01f, -1.81199312e-01f, -1.29727647e-01f,
  3.70549932e-02f, -1.79991439e-01f, -5.00792675e-02f, 2.00721726e-01f, -2.76064664e-01f, -2.81519979e-01f, -2.81865686e-01f, -3.66718590e-01f, 3.45611274e-01f, 3.35869581e-01f,
  3.44283581e-01f, -5.27100205e-01f, 5.91266334e-01f, 4.46599275e-01f, -4.81100500e-01f, 8.38447958e-02f, -3.55266519e-02f, -1.44479945e-01f, -1.63989574e-01f, 4.87318009e-01f,
  1.18474104e-01f, -6.30020082e-01f, -7.42033064e-01f, -5.32607615e-01f, 1.42090783e-01f, -1.07846379e+00f, 7.27217346e-02f, 3.42028767e-01f, -4.46170390e-01f, -4.67979401e-01f,
  1.76788554e-01f, -2.86726624e-01f, 4.66128051e-01f, -1.14814632e-01f, 3.70030135e-01f, -2.26532161e-01f, -2.11798221e-01f, 1.79944679e-01f, 5.90287745e-01f, 5.54671943e-01f,
  1.66768759e-01f, -3.59657928e-02f, 3.56998235e-01f, -3.33547831e-01f, -2.23561525e-01f, -4.63115543e-01f, 4.49873507e-01f, 2.90795147e-01f, -2.25543350e-01f, -5.24716318e-01f,
  -1.82248503e-01f, -3.39523554e-01f, 1.17449291e-01f, -5.42451501e-01f, -7.84932896e-02f, -4.58551019e-01f, 1.89021535e-04f, 1.93942189e-02f, -1.08142173e+00f, 4.09800529e-01f,
  3.36150587e-01f, 1.92108944e-01f, -5.15497625e-01f, 2.48096839e-01f, 1.81230366e-01f, 1.97056621e-01f, -8.59433413e-02f, 2.50193059e-01f, -6.22104853e-02f, 4.43409324e-01f,
  1.22853853e-01f, -2.40387335e-01f, 7.73011670e-02f, 2.33191893e-01f, 1.46288112e-01f, -3.17894220e-02f, -4.63515848e-01f, 4.11028147e-01f, 5.93630612e-01f, -5.47878027e-01f,
  -6.08419597e-01f, 1.13672838e-01f, 1.93899512e-01f, -2.77421594e-01f, -3.54112059e-01f, -5.57472467e-01f, 1.92847267e-01f, -6.98802292e-01f, -3.87451917e-01f, 4.83328640e-01f,
  1.38667658e-01f, -5.76391593e-02f, 1.95309281e-01f, 3.38603348e-01f, -2.78276056e-01f, 3.83886784e-01f, -3.90509702e-02f, 3.55175376e-01f, 4.19190735e-01f, 7.09126666e-02f,
  -3.53940845e-01f, 1.62821516e-01f, 2.73600191e-01f, -4.36866969e-01f, 3.80691051e-01f, 3.01213115e-02f, -4.43782866e-01f, -2.36090831e-03f, -2.89131820e-01f, 4.49172288e-01f,
  -1.82104856e-01f, -4.83456343e-01f, 9.95436776e-03f, -1.43946081e-01f, 1.42896287e-02f, -1.92201376e-01f, 4.60347027e-01f, 2.54754663e-01f, -6.73325002e-01f, -9.34111774e-01f,
  -7.03484058e-01f, 3.02655399e-01f, -5.52930593e-01f, -8.31667840e-01f, 1.85955435e-01f, -2.23689884e-01f, -3.35627608e-03f, -5.41858636e-02f, 1.70828104e-01f, 1.40830725e-02f,
  -2.92290092e-01f, -1.13491461e-01f, 3.43782455e-01f, 1.80521265e-01f, -1.15432903e-01f, 1.42355278e-01f, -4.09481823e-01f, 1.66263849e-01f, -4.39212143e-01f, -2.51087725e-01f,
  -3.89071822e-01f, -2.10033014e-01f, 4.04239088e-01f, 3.55806112e-01f, -1.88273892e-01f, -4.57479864e-01f, 2.13709772e-01f, 5.17023802e-01f, -6.35155380e-01f, -6.24242306e-01f,
  2.17043176e-01f, 4.53062207e-01f, -2.67864048e-01f, -7.28784084e-01f, 2.88811266e-01f, 2.58032918e-01f, -2.84495682e-01f, -1.50944889e-01f, 2.13770226e-01f, -2.27069467e-01f,
  -1.43953487e-01f, -1.95197873e-02f, 2.01596946e-01f, 1.90435514e-01f, 1.73575565e-01f, -1.50385126e-01f, -2.95401543e-01f, 2.79132485e-01f, -9.55909863e-02f, -3.15882444e-01f,
  3.03552181e-01f, 2.01992273e-01f, 2.74585754e-01f, -2.10128754e-01f, -2.58742720e-01f, -2.24200323e-01f, 1.98733747e-01f, 1.68839082e-01f, 1.84050389e-02f, 3.37064028e-01f,
  -7.40075052e-01f, 2.71535903e-01f, -4.55995262e-01f, 1.50766820e-01f, 6.83857799e-02f, -8.28449726e-01f, 4.91779327e-01f, -1.69157863e-01f, 4.21446383e-01f, 5.39214797e-02f,
  3.84465367e-01f, 2.86285967e-01f, -2.13938858e-02f, 1.30257547e-01f, 3.33306372e-01f, -2.69434035e-01f, -1.45507544e-01f, 2.41443217e-02f, -2.82708198e-01f, 1.38262495e-01f,
  1.78509459e-01f, 3.16108108e-01f, 2.12395549e-01f, 5.32268643e-01f, -4.93669152e-01f, -4.45590526e-01f, -8.97174105e-02f, 3.60813171e-01f, -3.59884113e-01f, 5.05193770e-01f,
  3.12283754e-01f, -3.41944277e-01f, -1.23862304e-01f, 1.23649575e-01f, -2.58106828e-01f, 9.67670500e-01f, -9.18435872e-01f, 4.51323502e-02f, -9.58897054e-01f, 1.78435579e-01f,
  -1.67218164e-01f, 1.80777535e-01f, 1.53423976e-02f, -8.76371488e-02f, -3.65492970e-01f, -2.84461230e-01f, -1.67529732e-01f, -1.74664155e-01f, -3.04333884e-02f, 3.31139475e-01f,
  2.16706470e-01f, 7.43030831e-02f, 2.41067052e-01f, -1.85152769e-01f, 1.85355961e-01f, 4.42771256e-01f, 4.56290841e-01f, -1.20895334e-01f, -1.13749988e-01f, 2.75285274e-01f,
  -2.12588429e-01f, -6.08009100e-02f, -4.09400314e-01f, 3.99516851e-01f, 7.56676123e-02f, 3.73851299e-01f, -1.35388732e-01f, 4.28661853e-01f, 5.33999562e-01f, -6.44861937e-01f,
  -7.58486450e-01f, -3.09531927e-01f, 1.84963852e-01f, 2.42513314e-01f, -9.05613229e-03f, 1.86505184e-01f, 1.93846464e-01f, -1.37570888e-01f, -3.81989270e-01f, 8.27549547e-02f,
  -2.55490214e-01f, -1.19466633e-01f, 1.51110426e-01f, 3.94969225e-01f, -4.83169526e-01f, 1.12712577e-01f, 4.55559194e-01f, -4.31200713e-02f, 2.29335219e-01f, -2.21404985e-01f,
  -1.74555227e-01f, -3.52955848e-01f, 1.87460348e-01f, -4.54067826e-01f, -3.19579065e-01f, -1.83758497e-01f, 3.20929974e-01f, 2.44559661e-01f, -3.42882603e-01f, -5.15044868e-01f,
  -7.56059527e-01f, -7.21440732e-01f, 4.01144058e-01f, -6.64432272e-02f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  -1.68331861e-01f, 2.94857081e-02f, -4.91535701e-02f, 3.12535278e-02f, 1.15539201e-01f, 7.30249584e-02f, 2.05192342e-03f, 3.84765975e-02f, 5.84453531e-02f, 2.00371463e-02f,
  -9.73305553e-02f, -2.01368839e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 12, 8
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 12, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        32, 12, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        32, 12
    );
    }
    