/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 128 (x1)
    * Saída: 12
    * Buffer Máx: 128
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 128;
    const int FAN_MAX_BUFFER_SIZE = 128;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 12 x 120)
const int L0_fan_Wp_rows = 12;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -4.92454171e-02f, -1.84785321e-01f, -8.61128196e-02f, -1.30708113e-01f, -6.76490664e-02f, -4.00488498e-03f, -5.87166063e-02f, 2.16009617e-02f, 1.70071349e-02f, 1.60306897e-02f,
  -1.46323785e-01f, -1.26098350e-01f, 3.64167467e-02f, -6.47689030e-02f, 9.00535807e-02f, 1.15280256e-01f, 2.32531298e-02f, 2.47816946e-02f, 1.02746226e-01f, 3.63129266e-02f,
  -1.04052193e-01f, -1.59473762e-01f, -7.46384859e-02f, 2.21595005e-03f, -5.70121929e-02f, -1.12670988e-01f, -1.45054489e-01f, -7.12813213e-02f, 6.45583076e-03f, -1.71886489e-01f,
  8.76593143e-02f, -1.08441487e-01f, 1.05139725e-01f, -4.53820899e-02f, -6.31108731e-02f, -5.41077228e-03f, -4.46138941e-02f, -4.87780571e-02f, -1.19980067e-01f, -1.03446767e-01f,
  -2.48641204e-02f, -1.67953819e-02f, 2.56858058e-02f, -9.85156596e-02f, -7.69814923e-02f, -5.12985811e-02f, -4.99187112e-02f, -9.96576771e-02f, -5.37214652e-02f, -1.04296759e-01f,
  -1.00111030e-01f, 1.01291453e-02f, 5.16798608e-02f, 2.26972643e-02f, -1.17171695e-02f, 1.99153107e-02f, -1.18481377e-02f, -1.09087199e-01f, 7.29469508e-02f, 4.85035963e-02f,
  1.25950724e-02f, -2.97571579e-03f, -8.17958117e-02f, -7.83825368e-02f, -1.03904670e-02f, -2.68142056e-02f, 2.11396050e-02f, 2.74396203e-02f, -8.44179019e-02f, 9.69306752e-03f,
  7.30078062e-03f, -5.55247441e-03f, 2.70974562e-02f, -1.59592759e-02f, 3.18339770e-03f, -1.75832715e-02f, -7.21452683e-02f, -1.43152019e-02f, -1.46602290e-02f, 2.52559385e-03f,
  -6.21349216e-02f, 2.37728120e-03f, 4.20925878e-02f, -2.37522181e-02f, 5.88400923e-02f, -5.65634109e-02f, 2.47783978e-02f, 2.63612252e-02f, 3.13720591e-02f, 2.49210242e-02f,
  2.83489749e-02f, -1.96348652e-02f, 1.05570376e-01f, 4.62713279e-02f, -8.56472626e-02f, 3.07760518e-02f, -6.80580828e-03f, -4.25300449e-02f, -8.37056115e-02f, 5.52263409e-02f,
  2.58909948e-02f, 6.59206659e-02f, -7.26927221e-02f, 1.61750428e-02f, -1.76432766e-02f, -1.49832023e-02f, -2.56090499e-02f, 5.85699379e-02f, -6.66365231e-05f, -7.33265355e-02f,
  -4.94593754e-02f, 1.10607393e-01f, 1.88820913e-01f, 5.17957956e-02f, -5.88304177e-02f, 5.22686355e-02f, 1.13401368e-01f, 8.59748125e-02f, 1.69615865e-01f, 1.10007197e-01f,
  -2.33804017e-01f, -1.37387037e-01f, -4.83891973e-03f, 9.87509917e-03f, 8.85237083e-02f, 1.41188979e-01f, 2.43351564e-01f, 1.05824493e-01f, 6.93698376e-02f, -4.60220315e-02f,
  -4.61492315e-02f, -9.41235125e-02f, -4.81349155e-02f, 1.26445919e-01f, 1.36013791e-01f, 1.18503563e-01f, 4.28523980e-02f, 8.78782272e-02f, 1.41150147e-01f, 1.30845711e-01f,
  5.55407926e-02f, 5.48994094e-02f, -9.56696719e-02f, -2.67968103e-02f, -3.67627963e-02f, 3.50805856e-02f, -1.50115281e-01f, -8.66614878e-02f, -7.74866641e-02f, -1.28690973e-01f,
  -2.38418698e-01f, -1.46207824e-01f, 3.80504731e-04f, -8.06977674e-02f, -7.87595287e-02f, -2.18914282e-02f, -1.78727843e-02f, -8.98637995e-02f, -7.40145892e-02f, -3.46051529e-03f,
  -1.17256202e-01f, -9.28770080e-02f, -7.58125931e-02f, -1.19364545e-01f, 2.91980505e-02f, -5.00090756e-02f, -8.64289477e-02f, 2.40300335e-02f, -8.91815405e-03f, -9.17030349e-02f,
  -2.10620202e-02f, -1.29406065e-01f, -7.40053430e-02f, 8.52897540e-02f, -3.11683603e-02f, -3.54057960e-02f, 3.28156464e-02f, -1.18116718e-02f, -5.46828844e-02f, -6.80989325e-02f,
  4.17513922e-02f, -3.23178619e-02f, 4.07470763e-02f, 3.75865474e-02f, 6.50681108e-02f, -2.32099444e-02f, 2.94031817e-02f, -3.16860643e-03f, 3.43076652e-03f, -3.95182939e-03f,
  -2.17460915e-02f, 4.33169305e-02f, 8.26520696e-02f, 1.85749345e-02f, -6.84444420e-03f, -1.79850366e-02f, 1.11403137e-01f, 1.24944337e-01f, -3.15269493e-02f, 9.24438983e-02f,
  7.84060732e-03f, 6.90291170e-03f, 3.02486569e-02f, 4.50470597e-02f, -1.17858415e-02f, 9.65799838e-02f, 2.99525633e-02f, 4.90689836e-02f, 2.86102425e-02f, -5.19439466e-02f,
  8.15835670e-02f, 1.32545009e-01f, 5.80909811e-02f, 1.38777265e-04f, -8.78723338e-02f, -4.91640307e-02f, -9.87466574e-02f, -9.62767079e-02f, 6.06120145e-03f, 2.22457554e-02f,
  -3.60814519e-02f, -1.69366375e-02f, -4.15808782e-02f, 4.40862663e-02f, -5.00582196e-02f, -3.77139673e-02f, -3.93997766e-02f, 4.65970784e-02f, 8.40510707e-03f, 2.81823054e-02f,
  9.97970402e-02f, 1.74968854e-01f, 8.44208673e-02f, 1.53833702e-01f, -4.95784506e-02f, 1.46894127e-01f, 1.08518302e-01f, 2.71059927e-02f, 8.58924463e-02f, 2.24246923e-02f,
  9.70924050e-02f, -4.27575819e-02f, -1.64088026e-01f, 1.32826809e-02f, 2.27185711e-01f, 9.88485739e-02f, 2.23171875e-01f, 5.43843806e-02f, 1.23703647e-02f, -1.08714655e-01f,
  -6.49823919e-02f, -2.19903335e-01f, -1.71745107e-01f, -1.07610643e-01f, -9.77508053e-02f, -1.56798184e-01f, -6.33077249e-02f, -1.34810999e-01f, 1.34621426e-01f, 1.99903727e-01f,
  1.65806830e-01f, 1.81883201e-01f, -1.23600569e-02f, -1.10176340e-01f, -1.70511845e-02f, -7.06156939e-02f, -1.95081368e-01f, -1.19572759e-01f, -1.48428798e-01f, -9.29926634e-02f,
  -2.84655262e-02f, -4.35077175e-02f, 5.62727526e-02f, -8.82693455e-02f, -4.32868414e-02f, 4.73904014e-02f, -7.20180687e-04f, -7.31896982e-02f, -8.18383917e-02f, -5.13290837e-02f,
  -6.21568458e-03f, -1.15975626e-02f, -2.69323904e-02f, 8.53913799e-02f, 1.43100508e-02f, 9.65087041e-02f, -4.50210981e-02f, -1.01929106e-01f, -4.62770201e-02f, -7.50933960e-02f,
  1.55473631e-02f, 1.00032315e-01f, 1.00281276e-01f, 6.44725934e-02f, 1.72554720e-02f, -6.62096590e-02f, -1.02799316e-03f, 5.38831763e-03f, -6.98696449e-02f, 1.60752624e-01f,
  3.43007781e-02f, -7.34426603e-02f, -3.64194103e-02f, -2.18556784e-02f, -9.31075774e-03f, -1.07540965e-01f, -1.15090897e-02f, -1.13650970e-02f, -1.11333735e-01f, -8.41952190e-02f,
  1.14906766e-02f, -1.37112901e-01f, -3.31643559e-02f, -1.41539294e-02f, -6.18576370e-02f, 7.66568934e-04f, -1.29181728e-01f, -1.23851538e-01f, -7.50771835e-02f, -8.07747319e-02f,
  -1.37919679e-01f, -9.78738070e-02f, -1.32924274e-01f, 1.75689962e-02f, -1.53365970e-01f, -1.25210866e-01f, -1.52676161e-02f, -7.07803518e-02f, -5.12748100e-02f, -8.57428387e-02f,
  1.97903946e-01f, -1.63113430e-01f, 1.71245467e-02f, 1.19512510e-02f, -1.04511343e-03f, 4.01434768e-03f, 1.03521661e-03f, 1.04732644e-02f, -1.60862003e-02f, 4.84747589e-02f,
  -7.28934184e-02f, 1.29020598e-03f, 4.97267814e-03f, -4.12163176e-02f, 7.63941482e-02f, 1.81758069e-02f, 6.77393824e-02f, -9.57323518e-03f, -2.53862026e-03f, -5.42716347e-02f,
  9.49196890e-03f, 1.24673970e-01f, 7.43028075e-02f, -9.80739575e-03f, 1.26435244e-02f, 6.74438998e-02f, 1.28383609e-03f, 1.68957621e-01f, 1.10960357e-01f, 1.75128132e-01f,
  -1.25332281e-01f, 5.37624545e-02f, -1.95235595e-01f, -2.45663926e-01f, 6.25306591e-02f, 1.09032299e-02f, 3.09452303e-02f, 1.16854524e-02f, -1.08425487e-02f, -5.37379943e-02f,
  1.11906387e-01f, 2.56100148e-02f, -2.99147703e-02f, 2.88700890e-02f, 7.17956340e-03f, 2.63333600e-03f, -1.97813213e-01f, -1.31647542e-01f, -1.00984834e-02f, -6.30298778e-02f,
  -4.81611975e-02f, -1.40298665e-01f, -1.87359810e-01f, -2.11805161e-02f, -9.51391309e-02f, -4.60552014e-02f, -8.99744406e-02f, -4.45886813e-02f, 2.20021829e-02f, -1.73427001e-01f,
  -9.14426818e-02f, -1.80231303e-01f, 7.22667649e-02f, 2.12526564e-02f, 1.09645650e-01f, -9.86350048e-03f, 5.09575056e-03f, 5.36490120e-02f, 8.65710247e-03f, 8.26944336e-02f,
  -1.41278189e-02f, -3.55876759e-02f, -8.75239894e-02f, -6.45103529e-02f, -6.94019869e-02f, -7.41914660e-02f, 4.86053415e-02f, -1.15993962e-01f, 5.45098446e-02f, -7.50356838e-02f,
  -4.02217545e-02f, 7.15837404e-02f, 1.38744161e-01f, -4.34631901e-03f, -5.79393655e-02f, -3.49251479e-02f, 1.01034775e-01f, 6.33918494e-02f, -5.32370701e-04f, 7.45679066e-02f,
  -1.25545174e-01f, -3.35244946e-02f, 5.29871620e-02f, 4.31122407e-02f, 8.31262320e-02f, 9.65183675e-02f, -9.85020250e-02f, 1.22405319e-02f, -9.46247391e-03f, 3.94509025e-02f,
  -1.33002922e-02f, -7.47513324e-02f, -5.91103593e-03f, -9.40316245e-02f, -1.81705952e-02f, 4.81016412e-02f, -5.24256527e-02f, -5.32350224e-03f, -7.02922978e-03f, -4.80548590e-02f,
  -3.67861837e-02f, 9.98099893e-02f, -8.27540234e-02f, 3.23434956e-02f, -6.12656251e-02f, -5.41329682e-02f, -5.53812757e-02f, 2.88573112e-02f, 1.21492390e-02f, -6.22314513e-02f,
  4.56806831e-02f, -5.27455434e-02f, -5.26166297e-02f, 1.67836715e-02f, -2.55362038e-02f, -5.61893284e-02f, 6.28463477e-02f, 5.24595333e-03f, 2.23036837e-02f, -6.13425747e-02f,
  3.85503694e-02f, 9.26518291e-02f, -2.32053716e-02f, 9.79689434e-02f, 2.88392920e-02f, 5.37091382e-02f, 1.14938825e-01f, 4.21390578e-04f, 1.16308920e-01f, 1.47099137e-01f,
  3.16469446e-02f, 2.03596622e-01f, 1.02070741e-01f, 1.16756313e-01f, 1.04947783e-01f, 6.43320009e-02f, 1.97894752e-01f, 1.10685050e-01f, 9.19595063e-02f, 2.02706471e-01f,
  -2.00120866e-01f, 1.99985623e-01f, 7.90148303e-02f, 1.47499815e-01f, 2.70602852e-01f, 1.78329587e-01f, 3.78732681e-01f, 1.61411598e-01f, 2.11320132e-01f, 1.00817867e-01f,
  -5.82034029e-02f, -1.26850814e-01f, -1.06400244e-01f, -8.67820606e-02f, -4.19697687e-02f, 2.74139524e-01f, 2.78984487e-01f, 3.70332561e-02f, -1.14846721e-01f, 1.62222952e-01f,
  2.47490823e-01f, 1.25426710e-01f, 6.73397407e-02f, 1.24821462e-01f, 5.99652566e-02f, 7.12534413e-03f, 1.24884859e-01f, 1.55361652e-01f, 4.99531776e-02f, 1.26178443e-01f,
  -1.37611881e-01f, 5.83800748e-02f, 1.53101504e-01f, 6.53941929e-02f, 6.84976056e-02f, 4.70755715e-03f, 1.11621581e-01f, 7.39999413e-02f, 9.14211012e-03f, 1.68917149e-01f,
  2.63540670e-02f, 1.21999651e-01f, 3.42073967e-03f, 1.35571852e-01f, 1.68053702e-01f, 1.05059788e-01f, 1.67816773e-01f, 3.52185173e-03f, -2.91804969e-03f, 3.31199518e-03f,
  1.53279424e-01f, 5.08562699e-02f, 4.91320565e-02f, 7.62940496e-02f, -8.00177734e-03f, 9.23650041e-02f, 1.81335257e-03f, -1.29453782e-02f, 6.50550872e-02f, 9.91734415e-02f,
  -1.04433492e-01f, -9.61749852e-02f, -9.05128270e-02f, -5.60538918e-02f, -2.99692713e-03f, -7.02200979e-02f, -1.29924089e-01f, 1.43702759e-03f, -5.56020178e-02f, -2.74819118e-04f,
  -6.39146045e-02f, -3.13256793e-02f, -3.29483114e-02f, -1.01246588e-01f, -4.74861935e-02f, -8.87644738e-02f, -9.16650966e-02f, -8.99668112e-02f, -8.57141241e-02f, 1.17090493e-02f,
  -9.29936245e-02f, -4.97890674e-02f, -2.12333142e-03f, -8.35539866e-03f, -6.77811876e-02f, -2.48631425e-02f, -1.00244939e-01f, -1.89803727e-02f, -6.54812381e-02f, -3.19849104e-02f,
  1.37847692e-01f, 6.60230443e-02f, 5.89717105e-02f, 9.43445936e-02f, 1.97731093e-01f, 1.35710880e-01f, 7.72980228e-02f, 1.34720087e-01f, 1.69200376e-01f, 8.55145901e-02f,
  1.74578846e-01f, 9.36492346e-03f, 1.42981291e-01f, 1.25627920e-01f, 9.80445147e-02f, 2.29281798e-01f, 1.32136703e-01f, 1.71914995e-01f, 1.69447288e-01f, 1.80461198e-01f,
  2.61137366e-01f, 2.27346271e-01f, 1.58180326e-01f, 1.54331088e-01f, 1.93541527e-01f, 3.92000712e-02f, 8.32564235e-02f, 2.48424411e-01f, 8.82144570e-02f, 2.22603425e-01f,
  2.41354197e-01f, -1.99111372e-01f, -3.31480682e-01f, 5.09522809e-03f, -1.24317467e-01f, -1.12860076e-01f, -1.98956951e-01f, -1.19322449e-01f, -3.49214710e-02f, -1.12162597e-01f,
  3.03449994e-03f, 4.13457602e-02f, -9.95543972e-02f, -1.21093616e-01f, -9.03920159e-02f, -3.22241396e-01f, -2.25381121e-01f, -1.73493862e-01f, 4.51820083e-02f, -4.24887128e-02f,
  7.12935030e-02f, 9.12737399e-02f, 1.24021076e-01f, -1.08153606e-02f, -1.43543407e-01f, -4.37694602e-02f, -8.12369734e-02f, -3.95915359e-02f, -2.10047469e-01f, -1.34755895e-01f,
  -6.49798214e-02f, -7.12764859e-02f, 2.59093400e-02f, 1.17357299e-02f, -1.45510221e-02f, 6.08638339e-02f, 2.53496747e-02f, -5.66473193e-02f, -4.22202162e-02f, -8.62243772e-02f,
  -1.03601692e-02f, -7.23180249e-02f, -1.09240919e-01f, -1.41821086e-01f, -7.86736086e-02f, -2.81451531e-02f, -7.13743791e-02f, 1.05258822e-02f, -3.16684432e-02f, -8.55895579e-02f,
  -9.43388641e-02f, -1.63671881e-01f, -1.74212113e-01f, -1.15581378e-01f, -1.40713438e-01f, -5.80063164e-02f, -3.87954675e-02f, -5.97243458e-02f, -6.34223521e-02f, -1.82740554e-01f,
  7.21793398e-02f, -1.00811785e-02f, 5.11169843e-02f, 7.82572255e-02f, 9.50936526e-02f, -6.31291866e-02f, 5.29699251e-02f, -5.71421720e-02f, 6.77754506e-02f, 8.25112462e-02f,
  1.28904581e-01f, 3.20348218e-02f, -3.39536667e-02f, 3.22848447e-02f, 2.50688884e-02f, -4.46231700e-02f, 5.49792172e-03f, -4.53771986e-02f, 1.32280052e-01f, 8.01427588e-02f,
  6.80545345e-02f, 4.09657359e-02f, 8.42729956e-02f, 4.22475636e-02f, 1.01521611e-01f, -1.57877840e-02f, 5.36683090e-02f, 1.63994320e-02f, 9.89374816e-02f, 6.09309487e-02f,
  8.20267722e-02f, -1.73574369e-02f, 1.26153999e-03f, 1.82131268e-02f, -1.10027008e-01f, 5.04937172e-02f, -8.43741149e-02f, 4.30311309e-03f, 5.16908616e-02f, -1.91031899e-02f,
  -4.46629226e-02f, -1.17550910e-01f, -8.38721618e-02f, -3.96709926e-02f, 2.69069914e-02f, 1.05793141e-02f, 1.09618828e-02f, -5.72660863e-02f, -8.02293345e-02f, -1.10381089e-01f,
  -6.90076575e-02f, -1.48637354e-01f, -1.96960866e-02f, -7.00977370e-02f, -3.23918015e-02f, -8.34379047e-02f, -3.40966955e-02f, -8.00677538e-02f, -1.31467164e-01f, 1.80188175e-02f,
  -2.81005919e-01f, 7.15389401e-02f, -2.95882612e-01f, -2.83384502e-01f, -3.38852708e-03f, 4.40144259e-03f, 1.25598103e-01f, 3.03544546e-03f, -1.40387475e-01f, -1.57055542e-01f,
  2.57099532e-02f, -2.22987100e-01f, -1.56388402e-01f, -1.80884376e-01f, -1.25862584e-01f, -3.54203172e-02f, -9.16465148e-02f, -2.52120137e-01f, -1.95276916e-01f, 3.41561623e-02f,
  -7.14933872e-02f, -1.19167179e-01f, -1.91544145e-01f, -4.08952404e-03f, -1.19111717e-01f, -2.15374455e-01f, -1.46021351e-01f, -1.72321260e-01f, -8.01471993e-02f, -1.99063733e-01f,
  -1.95833623e-01f, -2.92670517e-03f, -2.36489549e-02f, -1.10119440e-01f, -1.80246793e-02f, -3.77639532e-02f, -4.97466549e-02f, -1.24976486e-02f, -8.08953121e-02f, -9.53022838e-02f,
  3.01032364e-02f, 1.21467244e-02f, 2.60925032e-02f, 2.51289438e-02f, -3.76513973e-02f, -8.79790448e-03f, -4.25987877e-02f, -6.18155412e-02f, -1.32316560e-01f, -8.49279836e-02f,
  9.63894941e-04f, -1.71499662e-02f, -1.20129883e-01f, -1.05515607e-01f, -6.82376251e-02f, -1.74405620e-01f, -2.92391097e-03f, -9.17403996e-02f, -5.56610376e-02f, -1.69713616e-01f,
  1.59613803e-01f, 5.84685914e-02f, 9.47603434e-02f, 4.24594432e-02f, 1.89207327e-02f, -2.06945706e-02f, -1.58594921e-02f, 6.08656555e-02f, 7.81709477e-02f, 8.10723156e-02f,
  7.33748004e-02f, -3.02839279e-02f, 7.11903721e-03f, 9.10935104e-02f, 1.00131556e-01f, 1.17432512e-01f, 9.78565291e-02f, 1.50143415e-01f, 4.66208160e-02f, 7.08321705e-02f,
  1.10910172e-02f, -4.02730238e-03f, 1.24429964e-01f, 1.44234031e-01f, 8.41764957e-02f, -8.79461225e-03f, 7.45975003e-02f, 1.54697672e-01f, -1.86650921e-03f, 1.27233207e-01f,
  -1.45819604e-01f, 3.15494128e-02f, -2.12343454e-01f, -6.72815070e-02f, -1.46676317e-01f, -1.28626019e-01f, -6.36998266e-02f, -1.57259613e-01f, -4.73367423e-02f, -8.92716050e-02f,
  -1.09656058e-01f, -1.37387455e-01f, -5.77996448e-02f, -2.79691517e-02f, -1.01963859e-02f, -1.11815348e-01f, -2.61279102e-02f, -2.03022957e-01f, -9.70713422e-02f, -2.57836953e-02f,
  -1.78073958e-01f, -7.22328946e-02f, -2.62327284e-01f, -1.28772989e-01f, -7.99783394e-02f, -2.67533481e-01f, -2.19680145e-01f, -1.79377109e-01f, -1.85652629e-01f, -2.65445769e-01f,
  -3.34561244e-02f, -3.18706572e-01f, -3.14784907e-02f, -2.11777613e-01f, -2.72767484e-01f, -2.70976186e-01f, -2.30991572e-01f, -1.45152077e-01f, -1.00942478e-01f, -1.84378758e-01f,
  -7.46618584e-02f, -9.49689820e-02f, -1.59259543e-01f, -3.25063989e-02f, -1.78008422e-01f, -2.60016382e-01f, -2.55210191e-01f, -3.82346958e-02f, -3.94751038e-03f, -7.66622648e-02f,
  -2.39201933e-02f, -1.46725029e-01f, 5.08550666e-02f, -5.81900915e-03f, 1.03763519e-02f, -1.02479815e-01f, -1.95144624e-01f, -3.50544346e-03f, -6.47003204e-02f, -8.07936266e-02f,
  1.61459401e-01f, -1.46957710e-02f, -4.13580202e-02f, -1.34532377e-01f, -1.39305502e-01f, -4.13955189e-02f, -2.76778750e-02f, -5.81375919e-02f, -9.52315703e-02f, -7.47478902e-02f,
  -5.20562101e-03f, -6.74172044e-02f, -4.25380282e-02f, 2.24428880e-03f, -3.98068316e-02f, 6.33571371e-02f, -1.09739147e-01f, -5.73753044e-02f, -1.37412082e-02f, 4.77630273e-02f,
  -1.63005814e-01f, -1.24398462e-01f, -1.01763584e-01f, -7.71774799e-02f, -3.05285415e-04f, -4.89640646e-02f, -3.68452929e-02f, -2.82811504e-02f, -9.10219401e-02f, -2.83483230e-02f,
  3.07597723e-02f, 1.13190776e-02f, 5.15993945e-02f, 3.31718214e-02f, 1.34423047e-01f, -2.01753341e-02f, 2.81570433e-03f, 8.06504190e-02f, 2.07274407e-02f, 7.14760423e-02f,
  3.69445980e-02f, 8.59193355e-02f, -1.83785520e-02f, 9.73871499e-02f, 5.13087288e-02f, 3.14973034e-02f, -5.92305977e-03f, 3.21161076e-02f, 3.13570946e-02f, 2.25595012e-02f,
  1.45674884e-01f, -3.17000374e-02f, 1.59097798e-02f, 2.08525509e-02f, -1.55467555e-04f, 7.45402873e-02f, 4.82292809e-02f, 2.28591710e-02f, 8.38851184e-02f, -2.63715605e-03f,
  -2.58521177e-02f, -1.83838442e-01f, 3.87314819e-02f, -2.72695664e-02f, -7.90521577e-02f, -2.59832968e-03f, -1.47687554e-01f, -1.23101100e-02f, 5.03088850e-05f, 3.25176492e-03f,
  -6.64451048e-02f, -1.43300653e-01f, -5.34383506e-02f, -4.51986678e-02f, -4.56822962e-02f, 1.26521976e-03f, -7.45924115e-02f, -1.81133837e-01f, -3.66380550e-02f, -6.16957113e-05f,
  -1.22908697e-01f, -9.02402699e-02f, -2.15686694e-01f, -7.42344558e-02f, -5.94972707e-02f, -2.15083718e-01f, -1.67599648e-01f, -7.62035921e-02f, -1.07109331e-01f, -2.56462425e-01f,
  2.93499947e-01f, -1.09786861e-01f, -7.67294243e-02f, -2.30234098e-02f, 6.87870383e-02f, 1.36930659e-01f, -1.82742253e-02f, 1.71227515e-01f, 1.51926205e-01f, 7.55579248e-02f,
  4.51473147e-02f, 5.92468902e-02f, 1.27368033e-01f, 1.97666779e-01f, 1.92529783e-01f, -1.19357102e-01f, 3.88039984e-02f, -1.02829151e-02f, 1.44323364e-01f, 2.36292817e-02f,
  -1.87339575e-03f, 8.18552636e-03f, -4.19470891e-02f, -2.53369808e-02f, -1.83026671e-01f, -6.17973581e-02f, -1.29172891e-01f, -2.87390724e-02f, -1.03681363e-01f, -1.72252342e-01f,
  -9.34256762e-02f, -6.85856352e-03f, 1.30682990e-01f, 1.06302887e-01f, 6.12855777e-02f, 3.99991833e-02f, 6.58777058e-02f, 1.60326157e-02f, 7.96586052e-02f, 6.28841370e-02f,
  3.54137234e-02f, 4.56437133e-02f, -6.25992985e-03f, -2.62559932e-02f, 4.05466221e-02f, 1.97150186e-02f, 1.51927844e-01f, -1.42068882e-02f, 1.19953722e-01f, 2.94418144e-03f,
  -2.61905920e-02f, -8.29254091e-02f, 3.43794338e-02f, -2.42916495e-02f, 4.52662297e-02f, 1.15099266e-01f, 4.96154651e-03f, 1.41048152e-02f, -4.75007631e-02f, -1.19837746e-01f,
  -4.43146229e-02f, -6.45076782e-02f, -6.40757382e-02f, -2.03665141e-02f, -8.30412507e-02f, -3.13560367e-02f, -1.42721817e-01f, -9.27277654e-02f, -4.93914261e-02f, -1.27356127e-01f,
  -2.77886391e-02f, 8.77566915e-03f, -4.03399989e-02f, -7.29564726e-02f, -5.71214892e-02f, -1.20364122e-01f, -7.42028803e-02f, -8.40710849e-02f, -1.53305233e-01f, -7.31610786e-03f,
  -3.66081920e-04f, -5.53118289e-02f, -4.25965190e-02f, -1.00042067e-01f, -1.18988650e-02f, 2.49763150e-02f, -4.40643504e-02f, 3.44903581e-02f, -2.94098258e-03f, -8.07435066e-02f,
  1.34975702e-01f, 2.76507407e-01f, 4.14913660e-03f, 4.14649993e-02f, 5.37839904e-03f, 1.42492488e-01f, -1.97585281e-02f, 9.94251892e-02f, 1.48027567e-02f, -3.87917203e-03f,
  8.78490657e-02f, 5.66995889e-02f, -2.48419084e-02f, 7.34102800e-02f, 5.76998256e-02f, 7.51011297e-02f, 1.32187098e-01f, 1.38506414e-02f, 5.87632731e-02f, 1.64668243e-02f,
  6.91574290e-02f, 1.84990503e-02f, 1.71872322e-02f, 1.37474477e-01f, -2.87643522e-02f, 1.50684223e-01f, 2.23882981e-02f, 2.19267830e-02f, 5.65256663e-02f, -4.94774766e-02f,
  2.41531562e-02f, -1.26079813e-01f, 2.92830188e-02f, 5.41256703e-02f, 1.07980417e-02f, 2.20647939e-02f, 5.36678210e-02f, 1.33647453e-02f, 1.17343105e-01f, 9.36660245e-02f,
  -1.52583376e-01f, 4.06361707e-02f, -5.22548519e-02f, -3.63108143e-02f, 9.34387445e-02f, 1.19260632e-01f, 1.56027392e-01f, 7.52713084e-02f, 4.40169834e-02f, 2.40180325e-02f,
  -5.18101305e-02f, 6.35380745e-02f, 1.87356714e-02f, 6.67564198e-02f, 9.28738415e-02f, 1.06741518e-01f, -5.08260913e-03f, 1.24440216e-01f, 1.04526713e-01f, 1.84805170e-01f,
  1.38336465e-01f, -1.70309216e-01f, -1.06421918e-01f, -2.01151326e-01f, -9.54342932e-02f, -3.40541750e-02f, -1.10793225e-01f, -6.02102801e-02f, -1.12557895e-01f, -1.08874505e-02f,
  -1.57157838e-01f, -8.39699358e-02f, 1.90599896e-02f, -3.40561010e-02f, 1.09402044e-02f, -1.14264704e-01f, -1.39799178e-01f, -4.93870303e-02f, -1.78141713e-01f, -5.65995909e-02f,
  -1.08320169e-01f, 1.44714490e-03f, -1.01033814e-01f, -3.95447761e-02f, -7.94711262e-02f, -1.65384803e-02f, -2.84642540e-02f, -2.13977359e-02f, -2.94423178e-02f, 8.68858546e-02f,
  1.30846694e-01f, 6.01663627e-02f, 7.19196349e-02f, -4.60130982e-02f, 6.89017847e-02f, -2.42318157e-02f, 6.86651990e-02f, -6.28468208e-03f, 1.28005326e-01f, 6.19808473e-02f,
  -3.28039378e-02f, 5.08345328e-02f, 6.13735057e-02f, 1.38699159e-01f, 1.53042659e-01f, 5.10014594e-02f, -1.51507491e-02f, 4.10686731e-02f, 6.32436499e-02f, 5.66539131e-02f,
  -3.40186134e-02f, 7.90567547e-02f, 4.54565510e-02f, -2.00488232e-02f, 3.70442495e-02f, 9.98472348e-02f, 1.28585845e-01f, -3.03342082e-02f, 1.46175966e-01f, 9.16768312e-02f,
  9.11147296e-02f, -2.24405587e-01f, 3.46715748e-02f, 3.16035412e-02f, -6.24876805e-02f, -1.22161552e-01f, -2.96355728e-02f, -8.79153386e-02f, -5.81748933e-02f, -6.73855916e-02f,
  -1.09143749e-01f, -5.41881882e-02f, 2.08943523e-02f, -1.08095534e-01f, -2.24009845e-02f, 4.64064702e-02f, -9.51403230e-02f, 1.17741497e-02f, -1.16223887e-01f, -5.60425967e-02f,
  -1.08741969e-01f, 9.93047208e-02f, -1.36306984e-02f, 8.14756900e-02f, 7.59783899e-03f, -4.80886772e-02f, 1.00955404e-01f, 6.58862814e-02f, 1.34959236e-01f, 1.29884467e-01f,
  2.54917681e-01f, -4.12870646e-01f, -9.04578418e-02f, 1.74400896e-01f, -3.84609513e-02f, -1.61528856e-01f, -2.50722677e-01f, -1.58746421e-01f, 6.77198544e-02f, -3.41546312e-02f,
  -2.00516060e-01f, 7.63660669e-02f, 2.04435810e-02f, -1.13289304e-01f, -1.46744996e-01f, -2.19494566e-01f, -2.41937302e-03f, 1.84574276e-02f, 1.33179381e-01f, 9.85750407e-02f,
  1.10969201e-01f, 3.81192751e-03f, 7.86776468e-02f, 4.62637097e-02f, -2.41860542e-02f, -6.14618324e-02f, -2.25560457e-01f, -1.44449785e-01f, -1.29261032e-01f, 1.64176017e-01f,
  4.12536412e-02f, -2.72905767e-01f, 1.99863631e-02f, -2.30182000e-02f, -9.21678692e-02f, -9.62876827e-02f, -1.10674761e-01f, -1.61701873e-01f, -1.60342410e-01f, -1.51025698e-01f,
  -7.22829551e-02f, -1.01623535e-01f, -3.83194201e-02f, -1.82282344e-01f, -3.60198095e-02f, -6.17464520e-02f, -1.30554080e-01f, -9.69502404e-02f, -9.42072943e-02f, -1.45482942e-01f,
  -1.09136678e-01f, -4.12912294e-02f, -1.73541039e-01f, -2.59989113e-01f, -1.78235263e-01f, -3.81396972e-02f, -2.24267393e-01f, -1.07029654e-01f, -2.14064538e-01f, -6.17761500e-02f,
  8.30383003e-02f, 9.20412838e-02f, 7.63834342e-02f, 6.03618706e-03f, 1.29487574e-01f, 8.44218954e-02f, 1.43289715e-01f, 8.29969868e-02f, 8.61682519e-02f, 1.49825662e-01f,
  3.37513536e-02f, 2.02635471e-02f, -2.12769322e-02f, 1.23624384e-01f, 1.49419412e-01f, 7.99977928e-02f, 8.53837952e-02f, 1.45639135e-02f, 3.73616591e-02f, 1.38816699e-01f,
  4.01084274e-02f, 5.50866202e-02f, 7.76441768e-02f, 4.70229797e-02f, 5.08007184e-02f, 8.17693844e-02f, 1.24566264e-01f, -3.79581004e-03f, 9.68164355e-02f, 9.49469954e-02f,
  -1.01351179e-01f, -1.88074797e-01f, 9.00447965e-02f, -1.49069190e-01f, -3.93257923e-02f, -4.48951088e-02f, -6.02931194e-02f, -4.54330966e-02f, -1.32229537e-01f, -9.70893726e-02f,
  -6.62023276e-02f, -1.00637555e-01f, -1.79705963e-01f, -1.24168240e-01f, -4.75770608e-03f, -9.53437388e-02f, -2.88850609e-02f, 2.30233674e-03f, -2.43951716e-02f, -1.59129009e-01f,
  -9.55945924e-02f, -7.25470185e-02f, 1.17288910e-01f, -9.85420346e-02f, -1.51592180e-01f, 7.23709613e-02f, -1.11582614e-01f, 7.00228149e-03f, -3.94660532e-02f, 3.57994199e-04f,
  4.23278242e-01f, 3.84644300e-01f, -1.78732842e-01f, 1.41838938e-01f, -2.74679121e-02f, -4.07168530e-02f, 1.28943235e-01f, 2.22878501e-01f, 1.39883772e-01f, 2.15830609e-01f,
  2.21621115e-02f, -1.25531070e-02f, -4.16832343e-02f, -1.94482133e-02f, 2.37849411e-02f, 6.13963790e-02f, -1.13862492e-01f, -1.35293409e-01f, -8.90175179e-02f, 1.11445874e-01f,
  1.93016469e-01f, 2.43688792e-01f, 1.70092598e-01f, 1.23663269e-01f, 2.05105901e-01f, 3.51648033e-02f, -9.02470481e-03f, 9.53959301e-02f, 7.16487644e-03f, 9.94541869e-02f,
  -9.82948020e-02f, 2.69087195e-01f, 2.03277208e-02f, 8.80350545e-02f, 6.91512227e-02f, 5.04193380e-02f, 1.17770486e-01f, 5.77154644e-02f, 4.93468679e-02f, 1.02503605e-01f,
  7.12591410e-02f, 1.98204786e-01f, 1.45666718e-01f, 8.76786336e-02f, 9.26296562e-02f, 1.32899731e-01f, 1.45159647e-01f, 3.59934904e-02f, 9.20444354e-02f, 1.78993970e-01f,
  1.27979070e-01f, 9.27119255e-02f, 6.81509972e-02f, 6.15896992e-02f, 3.62170748e-02f, -3.04003619e-02f, 6.76030740e-02f, 1.10687152e-01f, 1.50464356e-01f, 1.43801108e-01f,
  -5.71781322e-02f, -7.86441118e-02f, -1.37480959e-01f, -6.10942356e-02f, -6.83452711e-02f, -1.19019672e-01f, -1.32293582e-01f, -1.51835650e-01f, -1.87034961e-02f, -6.50350899e-02f,
  -1.13556072e-01f, -1.45424083e-01f, -1.09507628e-01f, -7.70658553e-02f, -1.10319763e-01f, -9.19260383e-02f, -1.24476641e-01f, -1.05649866e-01f, -9.34044197e-02f, -1.10254265e-01f,
  -1.24808438e-01f, -1.81649610e-01f, -3.44970413e-02f, -7.07094744e-02f, -1.43138945e-01f, -6.79522306e-02f, -9.53320116e-02f, -1.48324385e-01f, -1.05233788e-01f, -5.82322590e-02f,
  6.40393347e-02f, 1.85708851e-02f, 4.50805798e-02f, 1.18160181e-01f, 7.90348724e-02f, 5.95333055e-02f, 1.84877396e-01f, 8.32708701e-02f, 1.37078613e-01f, 1.28496200e-01f,
  1.32210270e-01f, 1.81977883e-01f, 9.63541120e-02f, 7.84968287e-02f, 8.18437487e-02f, 1.45063862e-01f, 1.75704554e-01f, 3.69401872e-02f, 1.59955174e-01f, 1.05688587e-01f,
  1.45715714e-01f, 4.91658449e-02f, -2.60583684e-02f, 9.64843184e-02f, 9.34486166e-02f, -3.32087204e-02f, 1.12289540e-01f, 6.18718192e-02f, 4.08295728e-02f, 2.01751560e-01f
};

// L0_fan_Wp_bar (Shape: 104 x 120)
const int L0_fan_Wp_bar_rows = 104;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -2.36590087e-01f, 2.91475989e-02f, 1.27364650e-01f, 8.62856135e-02f, 3.31066288e-02f, 2.25852896e-02f, 5.27757145e-02f, 2.43464019e-02f, 2.22170986e-02f, -6.40678629e-02f,
  -2.30705485e-01f, -1.87960610e-01f, -1.25582693e-02f, -4.31469791e-02f, 4.51701321e-02f, 1.78493097e-01f, 3.02813888e-01f, 1.17290467e-01f, -2.94965901e-03f, -1.59829259e-02f,
  1.39535759e-02f, 2.98572090e-02f, -8.58630426e-03f, 9.57840979e-02f, 1.80119276e-01f, 4.08684649e-02f, 1.17277980e-01f, 7.71257058e-02f, 6.42275959e-02f, 1.63392395e-01f,
  -3.81795764e-01f, -1.29500449e-01f, -2.06584930e-02f, -5.77087142e-02f, -7.57302567e-02f, -4.61313054e-02f, 5.57484813e-02f, 7.30009675e-02f, -5.28597385e-02f, -2.80968565e-03f,
  -6.84482604e-03f, -7.91217536e-02f, 1.22403335e-02f, 7.99572468e-02f, -7.69836158e-02f, -6.20386116e-02f, 1.43473178e-01f, 5.55178672e-02f, -1.56539287e-02f, -1.30981818e-01f,
  4.11778465e-02f, -1.05098158e-01f, -1.07375912e-01f, 8.23594779e-02f, 3.77334654e-02f, -5.31940162e-02f, -6.69813752e-02f, 6.04035612e-03f, -4.28877920e-02f, -3.93032655e-02f,
  -6.26957417e-02f, 5.03066741e-02f, 2.50145476e-02f, 3.85392946e-03f, 5.28866723e-02f, 3.20971534e-02f, 1.10001542e-01f, 1.64220091e-02f, -3.18260193e-02f, 1.34583097e-02f,
  2.98958123e-02f, -6.70034885e-02f, 2.71237511e-02f, -4.38873321e-02f, -7.54648447e-03f, 3.31481881e-02f, 2.39242427e-02f, 1.10627757e-02f, -3.63662094e-02f, 7.91625958e-03f,
  -5.22344634e-02f, 1.95860695e-02f, 6.44030645e-02f, 2.25895476e-02f, -7.71210864e-02f, 1.01100124e-01f, 4.34271805e-02f, -4.54906235e-03f, 7.15815835e-03f, -1.30029246e-02f,
  -1.73180789e-01f, 3.80512513e-02f, -1.17091164e-01f, 9.63178873e-02f, 7.16352789e-03f, 2.16403585e-02f, -3.31438333e-02f, -3.02728489e-02f, -9.33385454e-03f, -3.54645699e-02f,
  2.36808416e-02f, 3.88396010e-02f, -2.11250689e-02f, 3.25534008e-02f, -9.12195444e-02f, -4.77770306e-02f, 6.50602505e-02f, 4.07639571e-04f, 6.14286819e-03f, -2.10055765e-02f,
  9.04047564e-02f, -9.52645168e-02f, -1.36468887e-01f, -6.60128370e-02f, -6.93395734e-02f, -1.21808730e-01f, -9.38681960e-02f, -1.00022577e-01f, -1.47111729e-01f, -7.49358386e-02f,
  -1.30562603e-01f, 1.85816780e-01f, -4.56406735e-03f, 9.44108795e-03f, -1.52890086e-01f, -8.48602727e-02f, 1.44223422e-01f, 1.34442300e-01f, -1.20801099e-01f, -1.24348074e-01f,
  -1.25731856e-01f, -2.13539824e-01f, -6.14468679e-02f, 1.03503183e-01f, 1.06741495e-01f, 1.58692136e-01f, 1.89814121e-01f, 1.95482925e-01f, 7.18657747e-02f, 6.21017888e-02f,
  9.40480754e-02f, 1.74499109e-01f, 1.90326408e-01f, 1.33386090e-01f, -3.71885076e-02f, -6.00164980e-02f, 8.09650309e-03f, -5.36918938e-02f, 4.67081778e-02f, 1.04379684e-01f,
  -2.07449391e-01f, -7.93191344e-02f, -1.37888283e-01f, -1.30509943e-01f, -4.75183092e-02f, 7.62128830e-02f, 4.86577973e-02f, 1.02513088e-02f, 5.17759025e-02f, 1.05789728e-01f,
  -2.61027757e-02f, 1.09839737e-01f, 1.15592508e-02f, 1.29646391e-01f, 5.07835336e-02f, -3.38123739e-02f, 1.80657342e-01f, 1.75754547e-01f, 1.10222012e-01f, -8.50255936e-02f,
  3.52865234e-02f, -1.06424123e-01f, -2.00216845e-01f, -7.99884498e-02f, 1.58172902e-02f, -4.73571606e-02f, -2.29465831e-02f, -3.49625200e-02f, -8.64348486e-02f, -2.05353927e-02f,
  -1.60434842e-01f, 5.24926074e-02f, 1.59523666e-01f, 1.29360884e-01f, 1.58925831e-01f, 9.75915417e-02f, 8.25630799e-02f, 8.29302892e-02f, 1.03396632e-01f, 1.05433576e-01f,
  -2.08437052e-02f, -9.72012281e-02f, 3.50714587e-02f, -8.32791254e-02f, -6.18492998e-02f, 5.21950275e-02f, 7.65214115e-02f, 5.31830676e-02f, 4.64075431e-02f, -8.63561872e-03f,
  -4.97249812e-02f, 1.37858577e-02f, -2.23878287e-02f, 2.19214588e-01f, 5.63860536e-02f, 1.12833478e-01f, 7.76084214e-02f, -2.33207550e-02f, 2.42732223e-02f, 2.13535950e-02f,
  -1.45820463e-02f, 6.11564107e-02f, -9.58499461e-02f, 6.87441826e-02f, -7.04306364e-02f, -7.97612146e-02f, -1.79802403e-02f, 4.14221510e-02f, -2.72679906e-02f, 1.03564598e-01f,
  1.56702936e-01f, 1.41206801e-01f, 8.39367881e-02f, 1.51843205e-01f, -1.21729478e-01f, -2.03026250e-01f, -5.84112993e-03f, 1.54431034e-02f, 5.39116114e-02f, -1.78285569e-01f,
  2.28766240e-02f, -1.89393133e-01f, -1.81273252e-01f, -1.49436191e-01f, -1.18154638e-01f, -1.91921726e-01f, -1.17581353e-01f, -8.13810378e-02f, -1.56233862e-01f, -1.07651055e-01f,
  -3.46651487e-02f, -4.19218123e-01f, 2.08392841e-04f, 1.08191878e-01f, -8.85471478e-02f, -5.45567553e-03f, -2.78787673e-01f, -1.38607398e-01f, 3.98989357e-02f, -1.01957083e-01f,
  -1.10283956e-01f, 5.32901883e-02f, 2.69554287e-01f, 2.20756873e-01f, 2.56318808e-01f, 5.65149784e-02f, 2.00705633e-01f, 3.38228464e-01f, 2.87162393e-01f, 1.92364566e-02f,
  -1.38778891e-02f, -6.11533299e-02f, 9.53793153e-02f, 1.13184243e-01f, -4.23378758e-02f, 1.92180604e-01f, 2.40430534e-02f, -1.03883348e-01f, -1.78665132e-03f, -4.59378548e-02f,
  -5.56275509e-02f, 4.75167669e-02f, 2.79674262e-01f, 1.23546995e-01f, 5.08667380e-02f, 3.05474643e-03f, 1.23150997e-01f, -3.59247327e-02f, 4.81318263e-03f, -2.42615100e-02f,
  -1.71097834e-02f, 1.10029109e-01f, 2.75161583e-02f, -5.09297065e-02f, -8.19369033e-02f, 3.64633538e-02f, -3.53569351e-02f, 1.55026913e-02f, 5.03194146e-02f, 2.39391122e-02f,
  -7.38816634e-02f, -1.49762437e-01f, -7.67747685e-03f, 1.32239893e-01f, 1.03370070e-01f, 7.17412904e-02f, 3.33745293e-02f, 7.41310045e-02f, 1.39423385e-01f, -3.00109554e-02f,
  7.34053403e-02f, -4.20198329e-02f, 1.71902016e-01f, 4.12924178e-02f, 8.47728252e-02f, 5.68683892e-02f, -3.24219204e-02f, -5.70442230e-02f, 2.20007524e-01f, -1.51532218e-02f,
  -7.01768473e-02f, 1.27721131e-01f, 2.03421023e-02f, -9.86981019e-03f, 1.69806272e-01f, -4.23363000e-02f, -1.28689617e-01f, -4.24366184e-02f, 1.53889313e-01f, -2.18513310e-02f,
  1.28739998e-01f, -3.98261519e-03f, -9.27466229e-02f, 5.45265190e-02f, 1.55384978e-02f, -9.81127378e-03f, 9.31581110e-02f, 2.32849107e-03f, -2.86304634e-02f, -1.40290245e-01f,
  -2.62968034e-01f, 4.35044736e-01f, 8.00649375e-02f, -6.41621053e-02f, -1.14626825e-01f, 5.47609180e-02f, 1.52066708e-01f, -1.01514839e-01f, -1.62487820e-01f, -2.02592704e-02f,
  8.04604497e-03f, 2.87795216e-02f, -9.49164703e-02f, -3.43597904e-02f, 1.04512461e-02f, 7.82085210e-02f, -1.12392411e-01f, -5.22220880e-02f, 2.73420569e-02f, -7.62239099e-02f,
  -1.85886417e-02f, -2.87888907e-02f, 1.31756812e-02f, 4.56722453e-02f, 9.52059850e-02f, 1.83548629e-02f, -1.04808614e-01f, -1.22098282e-01f, 6.59300014e-02f, -5.08905537e-02f,
  1.95995003e-01f, -1.28000855e-01f, -3.06660891e-01f, 1.00887969e-01f, -2.06393778e-01f, -2.19544455e-01f, -2.52873152e-01f, 7.78807234e-03f, 2.02115029e-01f, -1.41230538e-01f,
  -1.09201595e-01f, 1.30172651e-02f, -6.01850823e-02f, -2.14911371e-01f, -1.72466248e-01f, -2.45304912e-01f, -2.01481134e-01f, -3.07058334e-01f, -2.76982784e-01f, -2.04168379e-01f,
  -1.23320922e-01f, -1.74552664e-01f, -1.19743228e-01f, -9.79453251e-02f, -5.93099967e-02f, -1.55007511e-01f, -1.07449844e-01f, -2.18622491e-01f, -2.94855982e-01f, -2.22274840e-01f,
  -2.43134171e-01f, 1.34875834e-01f, -2.68226378e-02f, -5.76197526e-05f, -3.81139219e-02f, 1.74295276e-01f, 4.36008722e-03f, 2.68645827e-02f, 1.11372195e-01f, 1.11846393e-03f,
  4.22106497e-02f, 8.80064741e-02f, 8.90671611e-02f, -6.75043911e-02f, 7.14683011e-02f, -5.17842509e-02f, -7.07603693e-02f, -1.05743073e-01f, -4.36217487e-02f, -6.29775925e-03f,
  -8.67097899e-02f, -1.97090492e-01f, -5.85032217e-02f, 2.25218087e-02f, 1.86385997e-02f, -1.29474118e-01f, -5.60241826e-02f, -9.89434272e-02f, -1.91991344e-01f, -1.39569670e-01f,
  1.07458413e-01f, 8.69617835e-02f, 2.98951175e-02f, -3.21639366e-02f, -2.55453233e-02f, 3.40260565e-02f, 5.29427864e-02f, -8.21871758e-02f, -7.07129389e-02f, -5.82740754e-02f,
  -5.33130430e-02f, 2.86298245e-02f, 4.67528515e-02f, 5.82249649e-02f, -8.83415565e-02f, -4.07384522e-02f, 7.67654777e-02f, 1.05008502e-02f, -1.01414561e-01f, -6.05193712e-02f,
  -1.34364426e-01f, -6.70265257e-02f, 6.55463189e-02f, 4.09616604e-02f, -6.58150837e-02f, -1.06609166e-02f, -3.24060656e-02f, -7.24386200e-02f, -8.84677321e-02f, -2.78064627e-02f,
  1.00263856e-01f, -1.36727095e-01f, 1.00052699e-01f, 1.10798612e-01f, 3.85727808e-02f, 6.39423821e-03f, 1.87166855e-02f, 7.52299875e-02f, 1.27335964e-02f, 7.38162249e-02f,
  -3.29268128e-02f, 1.06320336e-01f, 2.43472736e-02f, -2.13678237e-02f, -9.08043161e-02f, 4.43889089e-02f, 1.37406625e-02f, -1.43120497e-01f, -4.35658358e-02f, 1.99226797e-01f,
  2.73388159e-02f, -7.95036927e-02f, 1.65566858e-02f, -3.65131386e-02f, 9.10425708e-02f, 3.06558032e-02f, -8.13291147e-02f, 1.33063830e-02f, -1.89286359e-02f, -8.06433409e-02f,
  -4.52972293e-01f, 1.63223483e-02f, 1.09732173e-01f, -2.65742868e-01f, 1.31054372e-01f, 3.41217488e-01f, 4.19117242e-01f, 6.49358407e-02f, -1.82067886e-01f, -6.06675632e-02f,
  7.37237930e-03f, -1.26080066e-01f, -1.38912508e-02f, 1.23104472e-02f, 1.67342424e-01f, 1.48050666e-01f, 2.64609843e-01f, 5.52469045e-02f, -5.18106930e-02f, -5.03776642e-03f,
  1.36447757e-01f, 5.23276217e-02f, 1.68362651e-02f, 1.59219988e-02f, -7.67740831e-02f, -1.93605255e-02f, 1.96687400e-01f, 1.82404779e-02f, 2.35949218e-01f, -1.56940296e-01f,
  -3.46744657e-01f, -7.39618316e-02f, 1.40042305e-01f, -3.56179215e-02f, 4.69192900e-02f, -2.00062599e-02f, -3.92187722e-02f, -1.91747472e-02f, -3.19902338e-02f, -2.61454144e-04f,
  5.47059178e-02f, -9.34818387e-02f, -3.38023342e-02f, 1.33418608e-02f, 4.35497798e-02f, -1.50812631e-02f, 6.71591535e-02f, -4.17044908e-02f, -2.34335698e-02f, -4.19898257e-02f,
  1.01197191e-01f, 3.91149968e-02f, -4.23505604e-02f, 9.51385200e-02f, 8.59034341e-03f, 9.86509547e-02f, -1.08247340e-01f, -1.83191851e-01f, 1.39856897e-03f, -3.42519462e-01f,
  -8.39540735e-03f, -6.93899021e-03f, 2.89765596e-02f, 1.36556569e-02f, 1.80561598e-02f, -5.37050813e-02f, -9.19583440e-02f, -2.66271061e-03f, -4.18678708e-02f, 6.39433116e-02f,
  -1.36459917e-01f, -1.30901605e-01f, -2.17708379e-01f, -1.78811252e-01f, -1.52637675e-01f, -5.52151613e-02f, 2.61006318e-02f, -3.57141197e-02f, 2.02487186e-02f, 1.16656512e-01f,
  5.59753142e-02f, -9.10180956e-02f, -6.00152165e-02f, -7.95568377e-02f, -3.18215378e-02f, -2.32003420e-03f, -1.36032403e-01f, -1.25564545e-01f, -5.50363818e-03f, -1.88316591e-03f,
  -9.15950835e-02f, 5.01387954e-01f, -2.68031895e-01f, 2.15945784e-02f, 3.97400372e-03f, 4.13896553e-02f, -4.32191081e-02f, -3.43254581e-02f, -3.67413647e-02f, -2.02662244e-01f,
  -6.78432062e-02f, -2.11043075e-01f, -6.71300963e-02f, -7.82128274e-02f, -1.22948468e-01f, -1.12808287e-01f, 1.99008660e-04f, -1.57898352e-01f, 9.09595415e-02f, -6.27171919e-02f,
  4.24137414e-02f, -1.99245103e-02f, -3.44593942e-01f, -2.26869807e-01f, -2.63690680e-01f, -1.08128801e-01f, -9.50006023e-02f, -1.81646362e-01f, 1.02457218e-01f, -1.44199267e-01f,
  4.13371891e-01f, 7.10854456e-02f, -3.32925975e-01f, 2.11552270e-02f, -3.29550594e-01f, -3.21982473e-01f, -1.29467338e-01f, -5.22940457e-02f, -1.05185926e-01f, -3.97307612e-02f,
  -8.87961388e-02f, 5.29983044e-02f, 1.57237932e-01f, 1.01371519e-01f, 2.04178512e-01f, -7.49679655e-02f, -1.14170715e-01f, 1.05927074e-02f, -7.21954033e-02f, -5.71689457e-02f,
  -3.21424715e-02f, -3.85358091e-03f, 4.36305776e-02f, 1.16989175e-02f, -8.79066288e-02f, -3.63262966e-02f, -1.53282285e-01f, -1.52524874e-01f, -1.45355821e-01f, -9.65409055e-02f,
  1.29722878e-01f, -1.34131566e-01f, -1.36393756e-01f, 1.38406083e-02f, -1.51471078e-01f, -8.14034045e-02f, 4.58430557e-04f, -1.35487095e-01f, -3.25050466e-02f, -9.85049531e-02f,
  -5.24434112e-02f, -2.64736824e-02f, 3.15101892e-02f, -3.35525498e-02f, -5.88150509e-02f, -3.45138013e-02f, -1.12450898e-01f, -5.08763567e-02f, -4.35702913e-02f, 1.98636502e-02f,
  -1.77094643e-03f, -1.02819264e-01f, -6.45514876e-02f, -7.36094862e-02f, -5.53634465e-02f, 8.34805705e-03f, -5.28716147e-02f, -1.43921822e-01f, -7.66307786e-02f, -9.02475044e-02f,
  -8.60467553e-02f, 1.30155114e-02f, -8.65010023e-02f, -1.48697197e-01f, -4.09025513e-02f, 2.38536997e-03f, 5.01833372e-02f, -2.96775382e-02f, -6.56497404e-02f, 4.21695933e-02f,
  -1.56518482e-02f, -1.15649970e-02f, -3.64161246e-02f, -2.29600295e-02f, 4.75265458e-02f, 1.69765186e-02f, -5.78027032e-02f, 5.83332516e-02f, 2.14102622e-02f, -1.67238377e-02f,
  -1.28664216e-02f, -4.68669310e-02f, 5.83792031e-02f, -7.96632469e-03f, -9.81683359e-02f, -4.54823375e-02f, 1.23077957e-02f, 7.73381591e-02f, -1.97870508e-02f, -7.35449269e-02f,
  3.43365133e-01f, 3.67681980e-02f, 1.16092063e-01f, 6.27828762e-02f, -1.53299615e-01f, -4.95266877e-02f, -1.48969041e-02f, -2.84303818e-02f, -2.75879055e-02f, 5.36206290e-02f,
  -1.16411336e-01f, 2.06720699e-02f, 5.01869284e-02f, 2.40388345e-02f, 3.57917920e-02f, 4.17544842e-02f, 1.00014247e-01f, 8.42963830e-02f, -5.93153164e-02f, -9.70341489e-02f,
  2.60708686e-02f, 7.93474019e-02f, 1.49801329e-01f, 5.26613034e-02f, -8.51507410e-02f, 1.52451560e-01f, 1.17953509e-01f, 5.89842871e-02f, 1.28812551e-01f, 1.01258047e-01f,
  2.89396465e-01f, -2.58279532e-01f, -4.11198616e-01f, 8.01786482e-02f, -4.03625146e-02f, -2.04703674e-01f, -3.20313275e-01f, -1.60855398e-01f, -5.52374348e-02f, -1.93584397e-01f,
  -8.01842436e-02f, 8.58824328e-02f, -1.30728662e-01f, -8.85183364e-03f, 5.22305397e-03f, -2.18701303e-01f, -9.46388319e-02f, 1.03808604e-01f, 3.60110134e-01f, 4.15781051e-01f,
  2.22408399e-01f, 2.41971806e-01f, 2.94438928e-01f, 2.29702756e-01f, 1.48278907e-01f, 8.43451247e-02f, -2.30178684e-01f, 6.03271241e-04f, -1.26276938e-02f, 2.06000939e-01f,
  2.69135721e-02f, -3.31644602e-02f, -4.43235748e-02f, 1.95916131e-01f, 1.09571747e-01f, 3.95483263e-02f, 7.01110214e-02f, 8.79403576e-02f, 3.59317027e-02f, -5.64749315e-02f,
  1.32728249e-01f, 4.66529354e-02f, -3.94177176e-02f, 1.53005077e-02f, 8.04083571e-02f, -6.85158446e-02f, 5.71028441e-02f, 8.94709155e-02f, -1.26265973e-01f, 9.00856405e-02f,
  1.23527244e-01f, 1.11112006e-01f, -2.44258195e-01f, -2.55048156e-01f, -1.66757748e-01f, 5.02008982e-02f, -4.87654656e-02f, 1.61540687e-01f, -1.68489397e-01f, 8.76005962e-02f,
  -1.53255956e-02f, -1.01929553e-01f, -1.24768659e-01f, -1.05359145e-01f, 9.24037024e-02f, 4.03199345e-03f, -5.50792851e-02f, 1.87806301e-02f, 2.23226119e-02f, 6.54828250e-02f,
  -5.69160171e-02f, 6.76679090e-02f, 1.29391462e-01f, 7.29162470e-02f, 1.42979726e-01f, -1.02548644e-01f, 9.62057933e-02f, 4.47721183e-02f, 1.54012874e-01f, -4.27373201e-02f,
  3.87150683e-02f, -2.16317344e-02f, -1.63613725e-02f, 1.11662596e-01f, -3.05118579e-02f, -1.03456542e-01f, -1.29594728e-02f, 1.27888143e-01f, 4.03225943e-02f, -7.51839727e-02f,
  -2.26601213e-01f, -2.80438870e-01f, -3.74974981e-02f, -1.22084515e-02f, -5.04271090e-02f, 5.48568834e-03f, 2.34902408e-02f, -4.87470031e-02f, -3.70456353e-02f, 5.97127108e-03f,
  -5.65108061e-02f, -4.93155234e-02f, -2.13787347e-01f, 6.01194473e-03f, 3.10651138e-02f, -1.48460165e-01f, -2.90733799e-02f, -5.13908081e-02f, -9.69155058e-02f, -1.50844119e-02f,
  -5.89032322e-02f, -4.17862087e-02f, -1.84757814e-01f, -2.90484250e-01f, -1.02940872e-01f, -2.60893796e-02f, -1.59841523e-01f, -9.80718285e-02f, -3.54017556e-01f, -2.45299190e-01f,
  3.42038721e-01f, 1.36412337e-01f, 1.53765604e-01f, 1.27354532e-01f, 7.76367411e-02f, 7.32739642e-02f, 1.23877637e-01f, 6.87380433e-02f, 1.10518537e-01f, 2.83238776e-02f,
  2.36443788e-01f, 1.55225366e-01f, 1.73787221e-01f, 1.31590754e-01f, 8.00050572e-02f, -2.95481663e-02f, -2.47162841e-02f, -8.80199077e-04f, 9.70569625e-03f, 6.25949726e-02f,
  -4.03802097e-02f, -1.41657582e-02f, 3.78525164e-03f, 5.07147685e-02f, -3.62745449e-02f, -3.77262533e-02f, -2.70239338e-02f, -1.10741984e-02f, 3.68909538e-02f, -1.52428642e-01f,
  2.69835461e-02f, 1.51529178e-01f, -8.57870579e-02f, -1.38531830e-02f, 1.90715883e-02f, -3.45150977e-02f, 7.46919140e-02f, -4.24961038e-02f, -7.64359534e-02f, -1.54618323e-01f,
  6.23719674e-03f, -9.96194333e-02f, 1.21955406e-02f, -1.08712099e-01f, -6.34272397e-02f, -9.34846699e-02f, -6.97482973e-02f, -5.28133884e-02f, 7.75017822e-03f, 2.47175954e-02f,
  -7.72060677e-02f, -1.79334134e-02f, 1.04323007e-01f, 1.86691415e-02f, 1.63000692e-02f, 2.68947752e-03f, 1.23757146e-01f, 3.26703973e-02f, -4.41770069e-03f, -5.96848540e-02f,
  2.91934032e-02f, 1.81573376e-01f, 7.30914399e-02f, 1.55626878e-01f, 1.39381617e-01f, 5.23996279e-02f, 3.53102721e-02f, -3.64719220e-02f, 1.24277957e-01f, 7.02315718e-02f,
  -7.30539411e-02f, 1.36657171e-02f, 1.16161071e-01f, 1.05551377e-01f, -3.91801447e-02f, 8.64062533e-02f, 3.18801776e-03f, -1.58341788e-02f, 3.27275507e-03f, -1.24442456e-02f,
  1.00642126e-02f, -7.55143762e-02f, -1.99621636e-02f, -4.80624512e-02f, -6.73471717e-03f, 8.54302198e-02f, -1.46914087e-02f, 3.13651264e-02f, -5.64250909e-02f, -3.49246301e-02f,
  1.55856628e-02f, 2.54197925e-01f, -2.33027209e-02f, -1.05890445e-01f, -1.29377916e-01f, -2.10788473e-02f, 6.31474480e-02f, -9.63903591e-02f, -1.82811618e-01f, -1.17854811e-01f,
  3.13906483e-02f, -5.38123064e-02f, -5.89252189e-02f, -1.06618337e-01f, -2.13082023e-02f, -1.52453944e-01f, -3.43848914e-02f, 3.39090377e-02f, -1.37624711e-01f, -2.11899132e-02f,
  -2.15432867e-02f, 1.13518946e-01f, 2.10327525e-02f, 1.33863539e-01f, -4.60549593e-02f, 1.07162595e-01f, -1.10537279e-02f, -1.93464141e-02f, 1.20989054e-01f, -6.76500723e-02f,
  7.83253089e-02f, -1.67948216e-01f, 1.12717956e-01f, 2.91197360e-01f, -2.73623466e-02f, 2.59601157e-02f, 6.04246818e-02f, 4.56285924e-02f, 1.70154884e-01f, 6.29900321e-02f,
  -2.30318949e-01f, -2.49265015e-01f, -1.90810576e-01f, -2.37208486e-01f, -1.91355839e-01f, 2.50703752e-01f, 2.63454556e-01f, 8.12353045e-02f, 1.01762833e-02f, -1.26593322e-01f,
  3.55606079e-02f, 1.53802633e-01f, 9.44183618e-02f, 7.74277151e-02f, 1.15574878e-02f, 4.05728035e-02f, 1.68586478e-01f, -1.15514621e-01f, -2.31066898e-01f, -1.02827512e-02f,
  2.12806314e-02f, -3.65223289e-01f, -4.26810458e-02f, -1.72478706e-01f, -9.31710750e-02f, -1.32653981e-01f, 2.43486594e-02f, -1.55962966e-02f, -8.32950398e-02f, -5.77060282e-02f,
  -2.26077616e-01f, -1.62154317e-01f, -1.23801507e-01f, -1.11083172e-01f, 8.06033388e-02f, -7.70642888e-03f, 2.26629730e-02f, 1.85242388e-02f, 5.27880751e-02f, -1.74516380e-01f,
  -2.64592171e-01f, -6.04827553e-02f, -2.00429671e-02f, 4.55033593e-03f, -1.14086740e-01f, -1.39625177e-01f, 2.27406863e-02f, -1.27915785e-01f, -1.47903562e-01f, 2.39680707e-01f,
  2.06988659e-02f, 2.16109436e-02f, -3.62691097e-02f, 1.03461556e-01f, -1.45549336e-02f, 9.75385755e-02f, 1.82246119e-01f, 6.01864532e-02f, 5.64526431e-02f, 3.08833439e-02f,
  8.03858936e-02f, 1.57810107e-01f, 3.79484445e-02f, 4.59200516e-02f, 8.23869780e-02f, -1.37628876e-02f, -9.40074958e-03f, -2.84286849e-02f, -1.46711007e-01f, 1.21274050e-02f,
  -1.64848592e-04f, -6.51113093e-02f, -1.20925177e-02f, 6.50906935e-02f, 4.37541343e-02f, 6.44259602e-02f, -6.82817353e-03f, -6.20953888e-02f, -4.58024628e-02f, 8.10030662e-03f,
  3.76423359e-01f, -2.04162538e-01f, 1.16278850e-01f, 7.56929964e-02f, 1.82917472e-02f, -1.45050839e-01f, 1.73294563e-02f, 1.34889647e-01f, 2.41434965e-02f, -1.13085866e-01f,
  -1.47933453e-01f, -1.84205160e-01f, -1.02384433e-01f, -2.23347731e-02f, 1.78034246e-01f, 8.76537114e-02f, -7.19171390e-02f, 7.59569257e-02f, -2.89913416e-02f, -5.30846789e-02f,
  6.67143986e-02f, 1.39905155e-01f, 2.24442318e-01f, 2.06889749e-01f, -7.44157359e-02f, 1.17061742e-01f, 2.85217911e-01f, 6.68305308e-02f, 1.75294667e-01f, 3.93717825e-01f,
  6.75319195e-01f, 3.64607513e-01f, 8.58587846e-02f, 3.47980291e-01f, 2.54166067e-01f, 1.72736034e-01f, 1.97112560e-01f, 2.11843193e-01f, 2.15854701e-02f, 2.64092118e-01f,
  3.18749458e-01f, 1.79844543e-01f, 9.90943462e-02f, -1.20710535e-02f, 1.50965303e-01f, 1.69075504e-02f, -1.45456538e-01f, -1.23945456e-02f, 1.51337944e-02f, 1.41200930e-01f,
  1.23157471e-01f, 2.15789571e-01f, 1.13955468e-01f, -2.33719125e-02f, 6.10008612e-02f, -2.09390055e-02f, 2.58015227e-02f, 1.64092049e-01f, 4.71624136e-02f, -9.57231298e-02f,
  -3.56195420e-02f, 2.41309941e-01f, -2.21310884e-01f, -1.03842184e-01f, -4.95700575e-02f, -4.71559316e-02f, 3.45036201e-02f, 1.34929158e-02f, -3.18394825e-02f, -4.27465216e-04f,
  -1.00501411e-01f, -7.67467022e-02f, 8.61680601e-03f, -2.76322849e-03f, -1.14148006e-01f, -4.18434106e-02f, -1.59510970e-01f, -1.46730408e-01f, -1.48404256e-01f, 4.26931977e-02f,
  -2.81740483e-02f, 1.02821037e-01f, -4.23043147e-02f, -7.92016461e-02f, 2.96411905e-02f, -4.80071753e-02f, -4.44568023e-02f, 7.96109289e-02f, 3.42375628e-04f, -7.12695494e-02f,
  7.85536021e-02f, 9.13715139e-02f, 9.53076556e-02f, 1.13382250e-01f, 9.67801511e-02f, -8.72194301e-03f, -1.82670224e-02f, -9.65815932e-02f, 1.73424911e-02f, -4.12103347e-02f,
  -1.35497883e-01f, -9.95190218e-02f, -1.05277821e-01f, 5.26521318e-02f, 5.81351444e-02f, 9.61290598e-02f, -1.04104377e-01f, -5.48909940e-02f, -3.55954133e-02f, -8.03272997e-04f,
  -4.57238108e-02f, -1.83923528e-01f, 1.91082386e-03f, -1.58934161e-01f, -7.48445094e-02f, 6.17571129e-03f, 2.12630816e-02f, 1.35139059e-02f, 1.52664691e-01f, 3.55890160e-03f,
  -2.74189979e-01f, 8.59874487e-02f, -1.38861299e-01f, -1.32502064e-01f, 9.11320932e-03f, 2.30932329e-03f, 9.50793922e-02f, -5.56643717e-02f, 9.20883846e-03f, -1.41011430e-02f,
  -6.40831143e-02f, 3.31378952e-02f, -5.30064330e-02f, -4.07844633e-02f, -1.13214023e-01f, -2.65382342e-02f, 4.91673984e-02f, -6.20633438e-02f, -1.95989981e-02f, -1.11950241e-01f,
  -3.17615680e-02f, -1.68972939e-01f, -1.64436072e-01f, -6.82389140e-02f, -8.16553384e-02f, -1.33535653e-01f, 2.17082747e-03f, -1.09168716e-01f, -1.00667663e-01f, -4.36987951e-02f,
  3.19220692e-01f, 2.17696697e-01f, 2.15732396e-01f, 3.37894559e-02f, 1.57559544e-01f, -1.43565238e-02f, -2.20556095e-01f, -2.36681551e-01f, -1.72418803e-01f, -2.39249803e-02f,
  2.24067360e-01f, 1.29401088e-01f, -1.94131359e-02f, -4.04393934e-02f, -2.57816613e-02f, -1.89014673e-01f, -1.12554565e-01f, 8.88691023e-02f, 8.68614614e-02f, 4.33984958e-02f,
  -3.56220864e-02f, 1.20478071e-01f, 2.19248801e-01f, 3.44575681e-02f, 1.86816156e-02f, -3.67984846e-02f, -2.91398317e-02f, 1.52035564e-01f, 1.22884877e-01f, 8.40951353e-02f,
  1.13715746e-01f, 1.86817810e-01f, -2.40150005e-01f, -1.08598564e-02f, 2.14297041e-01f, -9.62181166e-02f, -9.50534940e-02f, 1.24719627e-02f, 1.19205602e-02f, -4.02416252e-02f,
  1.14185013e-01f, 1.16022341e-01f, 3.61552127e-02f, -7.03594983e-02f, 3.12775671e-02f, -8.63865390e-02f, 1.29796993e-02f, -6.26394302e-02f, -1.32351801e-01f, -1.88601818e-02f,
  -2.40697432e-03f, 1.85739025e-01f, 1.97165743e-01f, -9.12871808e-02f, -1.01214677e-01f, 7.74757192e-02f, 6.01614127e-03f, 4.04375084e-02f, 6.70018420e-03f, -1.05799221e-01f,
  2.78642327e-02f, 9.23091695e-02f, 7.99516141e-02f, 6.25688359e-02f, -1.00217409e-01f, -4.24748920e-02f, 5.26820868e-02f, 6.45776540e-02f, -1.00610440e-03f, 2.30791327e-02f,
  5.83806336e-02f, 9.78488252e-02f, 5.47831804e-02f, 2.73180334e-03f, -1.35326032e-02f, 1.10348471e-01f, 3.78277674e-02f, 3.40705439e-02f, 5.70548326e-02f, -1.73725933e-02f,
  9.62500423e-02f, 4.61436016e-03f, 1.19826771e-01f, 9.77911875e-02f, 6.42979071e-02f, 2.30747405e-02f, -4.75027896e-02f, 1.27578720e-01f, 2.38879081e-02f, 1.02890253e-01f,
  -1.85417518e-01f, -6.60626963e-02f, -1.68588802e-01f, 3.35208103e-02f, -4.88891751e-02f, 3.33578512e-02f, -1.20689347e-02f, 8.03276449e-02f, 1.22204766e-01f, -2.18930617e-02f,
  -8.82702600e-03f, -5.94269074e-02f, -2.65615806e-02f, 1.96843762e-02f, -7.37354085e-02f, -3.17200087e-03f, 1.06878400e-01f, 5.89084364e-02f, -5.49754351e-02f, 7.51103088e-02f,
  -3.81732509e-02f, -9.80003923e-02f, -9.74719301e-02f, -1.42965466e-01f, -2.31210105e-02f, -1.56579435e-01f, -1.83239296e-01f, -1.67328149e-01f, -1.96070224e-01f, -3.55320930e-01f,
  6.65517867e-01f, 1.63740814e-01f, 2.35164747e-01f, -1.90462060e-02f, -1.52149245e-01f, -3.49436589e-02f, -1.23599321e-01f, 3.10462676e-02f, 7.21406415e-02f, 1.42242476e-01f,
  2.26108447e-01f, 2.01712713e-01f, 1.65045649e-01f, 1.43751621e-01f, 1.19524412e-01f, 5.95706776e-02f, -9.20564458e-02f, 1.03254527e-01f, 1.25135601e-01f, 5.33384234e-02f,
  2.07025302e-03f, -5.04350439e-02f, 1.61808416e-01f, -2.68209856e-02f, 8.03578496e-02f, 3.16651538e-02f, 1.29440144e-01f, -8.97916674e-04f, 3.77690122e-02f, -4.35990952e-02f,
  1.73376352e-01f, 1.96076587e-01f, -2.68262792e-02f, -2.56476142e-02f, 8.24887380e-02f, -8.37221800e-04f, 2.93897633e-02f, 4.33008000e-02f, -4.22073491e-02f, -1.31747544e-01f,
  5.39784459e-03f, 8.16205218e-02f, 1.41141256e-02f, 1.14286388e-03f, -4.89684045e-02f, 3.69860306e-02f, -8.75850848e-04f, 8.26972723e-02f, -3.75870359e-03f, 1.14602551e-01f,
  -7.81246871e-02f, -5.36939614e-02f, 1.65715590e-02f, -8.26265886e-02f, 9.48338285e-02f, 1.23218052e-01f, 1.85210034e-02f, 3.18017751e-02f, -2.06056107e-02f, 9.49213505e-02f,
  6.63938448e-02f, 9.53326374e-02f, 1.14301100e-01f, 2.40590081e-01f, 2.66332895e-01f, 2.17885092e-01f, 1.09660693e-01f, -5.59953116e-02f, 1.01204202e-01f, -6.06784150e-02f,
  -9.39541161e-02f, 1.32913291e-01f, 5.40966131e-02f, 1.63807645e-02f, 1.27334550e-01f, 1.23178124e-01f, -1.53626893e-02f, 1.99010111e-02f, -5.26397303e-03f, 3.08623072e-02f,
  -6.55235052e-02f, -5.98004460e-02f, 9.92790535e-02f, 3.88315469e-02f, 9.19879749e-02f, 1.03354871e-01f, 5.64957745e-02f, 4.62881289e-02f, -3.71739566e-02f, 5.53045049e-02f,
  -2.68825322e-01f, 9.87114310e-02f, 1.03137210e-01f, -5.77491783e-02f, 2.77840812e-02f, 5.59562594e-02f, 2.33883988e-02f, -2.42184252e-02f, -5.91416173e-02f, -1.18483365e-01f,
  -7.73125663e-02f, -8.27840492e-02f, 8.42329264e-02f, -1.47035765e-02f, -1.49947420e-01f, -2.97890417e-02f, 6.25558570e-02f, -8.07740763e-02f, -5.57459220e-02f, -9.85291600e-03f,
  -1.30798951e-01f, -5.87722287e-02f, -9.87249240e-02f, -1.95343480e-01f, -1.54731482e-01f, -1.27504664e-02f, -8.74232277e-02f, -1.57591656e-01f, -2.55586002e-02f, 1.51662286e-02f,
  5.93489707e-01f, -1.62146777e-01f, -4.94863898e-01f, -2.06181243e-01f, -2.30735213e-01f, -2.88425386e-01f, -2.55000025e-01f, -5.82044497e-02f, -1.69635750e-03f, -2.29383215e-01f,
  -5.24793081e-02f, 3.16031039e-01f, 1.41554788e-01f, 1.43567830e-01f, 1.34972677e-01f, -3.20618242e-01f, -3.08443308e-01f, -9.20453593e-02f, 7.35653490e-02f, 8.38437006e-02f,
  1.86153445e-02f, -8.21409523e-02f, 3.52329090e-02f, -1.09458312e-01f, -3.16070050e-01f, -1.13888584e-01f, -4.70801622e-01f, -2.34110132e-01f, -1.72770679e-01f, -3.13751489e-01f,
  -3.11615795e-01f, -2.45418288e-02f, -1.65309608e-02f, 9.72071141e-02f, -1.48174405e-01f, 7.47575462e-02f, -1.30995633e-02f, -1.54497683e-01f, -6.73163775e-03f, -1.39018342e-01f,
  -7.45328590e-02f, 2.74374690e-02f, 8.03290382e-02f, -3.46069261e-02f, -1.08758539e-01f, -1.00610163e-02f, -1.42343923e-01f, -3.61387469e-02f, 4.51571308e-02f, -2.01215558e-02f,
  3.94381061e-02f, 1.10036433e-01f, 7.44937509e-02f, -1.16668902e-01f, 4.91506308e-02f, -8.42251629e-02f, -1.67211816e-01f, 8.20681155e-02f, -7.59317577e-02f, -1.08801745e-01f,
  -2.15556454e-02f, -2.52406429e-02f, -2.79159639e-02f, -1.12064218e-03f, 2.14767177e-02f, -1.37728481e-02f, 1.65713802e-02f, 1.03176832e-01f, 1.12451436e-02f, -3.52051780e-02f,
  4.36362438e-02f, -2.03187782e-02f, 4.76838043e-03f, -4.14603166e-02f, 6.18224032e-02f, -1.77068468e-02f, 1.22568086e-01f, 7.94731639e-03f, 1.58100724e-02f, -1.01634543e-02f,
  1.35997280e-01f, 5.43453097e-02f, -6.60220757e-02f, 5.27842864e-02f, 5.74468523e-02f, -4.21584118e-03f, 9.18568578e-03f, 9.48070213e-02f, 9.36210752e-02f, 9.41552371e-02f,
  -6.54842407e-02f, 7.03964429e-03f, 8.62238184e-02f, 1.20622821e-01f, -1.51568323e-01f, 1.07426930e-03f, -2.18417160e-02f, -7.32571557e-02f, 2.13289401e-03f, -5.17751090e-02f,
  2.92861555e-02f, 5.18557169e-02f, -9.54470932e-02f, -5.35950325e-02f, -1.01896510e-01f, 7.49711841e-02f, 1.19769521e-01f, 6.44424111e-02f, 9.39662233e-02f, -5.05705774e-02f,
  -5.28581180e-02f, 2.35117987e-01f, 1.90866530e-01f, 3.66432406e-02f, 9.60247964e-02f, 1.92030624e-01f, -5.04438728e-02f, -2.69740429e-02f, 1.78356215e-01f, 4.12654802e-02f,
  -6.86142221e-02f, -1.54455885e-01f, -1.63003299e-02f, 3.57903361e-01f, 2.39033550e-01f, 4.21718925e-01f, 3.24008733e-01f, 2.96520710e-01f, 3.62579077e-01f, 1.68213814e-01f,
  -6.40205713e-03f, 1.07387245e-01f, -1.21013718e-02f, 4.97362092e-02f, 1.55055344e-01f, 2.75106788e-01f, 2.57760406e-01f, 1.56431645e-01f, 5.72336838e-02f, 1.75805002e-01f,
  3.07245016e-01f, 1.05065331e-01f, 5.95243387e-02f, 6.56166747e-02f, -9.57196753e-04f, 1.14498653e-01f, 2.04591885e-01f, 9.29053202e-02f, 4.69396748e-02f, 8.59287679e-02f,
  -3.10483843e-01f, -1.28155023e-01f, 4.42392156e-02f, -1.74553245e-01f, -2.32909277e-01f, -2.31836230e-01f, 3.46586504e-03f, -5.35714068e-02f, 8.00426584e-03f, 3.08333547e-03f,
  -1.37730464e-01f, -1.47926003e-01f, -4.99742553e-02f, -1.47269204e-01f, -1.40230119e-01f, 1.17344884e-02f, -9.55388770e-02f, 2.01812927e-02f, 5.83822727e-02f, -3.08345072e-02f,
  -6.49233311e-02f, -6.03760453e-03f, 4.49547134e-02f, 1.58814713e-01f, -6.70851842e-02f, 4.11067903e-02f, -1.49420202e-01f, -7.61521831e-02f, 2.88541242e-02f, -3.89802754e-02f,
  1.43679306e-01f, 1.97669983e-01f, -6.53064027e-02f, 1.11733221e-01f, -5.24879731e-02f, -3.03057879e-02f, 5.72471172e-02f, 1.47602409e-01f, 1.75258785e-01f, 1.16425246e-01f,
  3.36313210e-02f, 4.36863862e-02f, 5.54370545e-02f, 1.23180911e-01f, -1.98156182e-02f, 6.79012239e-02f, 2.54441798e-02f, 1.33066308e-02f, -1.56125516e-01f, -9.76298898e-02f,
  1.61179751e-02f, 3.83565668e-03f, -1.99829668e-01f, -1.26832187e-01f, -6.33244589e-02f, -5.22919707e-02f, 2.85242684e-02f, 2.46986989e-02f, -5.33550456e-02f, 7.46241137e-02f,
  1.44738719e-01f, -1.11852713e-01f, 9.33814887e-03f, 6.56139180e-02f, 3.33528332e-02f, -1.51510775e-01f, -1.10009201e-01f, -4.76539880e-03f, -1.67101324e-01f, -5.91908023e-02f,
  -9.90908360e-04f, -3.60325933e-03f, -8.98282453e-02f, 1.05160423e-01f, 1.24519050e-01f, -1.46957189e-02f, 2.83366181e-02f, 1.54918194e-01f, 8.49058628e-02f, -3.80642340e-02f,
  -8.28640070e-03f, 1.47875518e-01f, 2.02928424e-01f, 1.37689620e-01f, 1.58975512e-01f, 2.30155095e-01f, 6.47269264e-02f, 8.41383412e-02f, 1.08022183e-01f, 1.72846943e-01f,
  2.23700732e-01f, 1.62966713e-01f, 1.12712771e-01f, -2.62744337e-01f, -2.41838485e-01f, 2.45202221e-02f, 2.63699114e-01f, 9.42371860e-02f, -1.88124955e-01f, 1.63347553e-02f,
  7.76920617e-02f, 5.23841428e-03f, 4.66177911e-02f, 8.62116367e-02f, 1.92119747e-01f, 1.36030093e-01f, -9.01805460e-02f, 3.34145762e-02f, 1.95017159e-01f, 1.37103170e-01f,
  3.36169824e-02f, 7.37706199e-03f, -2.97285579e-02f, 5.96554838e-02f, -6.32736534e-02f, -7.92048648e-02f, -9.16865319e-02f, -7.05663785e-02f, 2.13407222e-02f, -1.38132498e-01f,
  4.21103865e-01f, 5.98868877e-02f, -1.14827357e-01f, -2.12647155e-01f, -9.83205885e-02f, -7.89107308e-02f, 8.58681053e-02f, -5.44104315e-02f, -9.86755937e-02f, -2.46148556e-02f,
  -9.58888829e-02f, -5.68276495e-02f, -1.01979245e-02f, 2.19740868e-02f, -4.21015061e-02f, 9.09193605e-02f, 9.73623060e-03f, 1.46881295e-02f, -4.12847921e-02f, 8.03919062e-02f,
  -1.09021433e-01f, -8.53122100e-02f, 5.15514277e-02f, -1.32062072e-02f, 1.92524418e-02f, -1.22119926e-01f, 2.21097819e-03f, -6.04572780e-02f, 3.07889450e-02f, 2.84157582e-02f,
  -2.39885256e-01f, -1.45972557e-02f, -2.82600260e-04f, 4.51260731e-02f, 1.29697695e-01f, 6.12086095e-02f, 5.52851567e-03f, 1.07280515e-01f, 2.20667683e-02f, 7.76380375e-02f,
  1.26144543e-01f, 1.36911139e-01f, 1.35465100e-01f, 1.49795622e-01f, 2.70844698e-02f, 4.04603258e-02f, 2.11579069e-01f, 1.83542848e-01f, 8.72836784e-02f, 4.72381013e-03f,
  -3.47763672e-02f, 6.64191246e-02f, 3.73975076e-02f, 1.03641771e-01f, -2.25379262e-02f, 1.13476336e-01f, 1.13566108e-01f, 1.16194181e-01f, -1.37162693e-02f, 4.48344350e-02f,
  3.64744514e-02f, 2.38631628e-02f, -3.51127312e-02f, -8.16938058e-02f, -7.01390505e-02f, -1.03404179e-01f, -1.22849084e-01f, -1.41295642e-01f, -6.83029667e-02f, 9.18838903e-02f,
  1.41355768e-02f, -7.32165948e-02f, -6.93379622e-03f, 2.31655985e-02f, 6.64077839e-03f, -1.33695096e-01f, 3.49202789e-02f, -2.45643593e-03f, -6.30743802e-02f, 2.14880966e-02f,
  -1.00003302e-01f, 4.79489937e-02f, 1.19658373e-01f, -1.67003460e-02f, 2.51637842e-03f, 1.48208560e-02f, 1.08499192e-01f, 4.22175676e-02f, 7.08306432e-02f, 6.68037832e-02f,
  3.47471088e-01f, 2.44965687e-01f, -2.61657119e-01f, 3.67794544e-01f, 1.56399265e-01f, -2.37940103e-01f, -2.08381563e-01f, -2.11408734e-01f, 2.80155152e-01f, 2.51350880e-01f,
  9.82732922e-02f, -2.51228631e-01f, -1.66764751e-01f, -3.89856786e-01f, -6.22870326e-01f, -2.17965111e-01f, -1.40051886e-01f, -5.16412377e-01f, -6.71590626e-01f, -3.81163210e-01f,
  -7.36552328e-02f, 7.79078454e-02f, -1.18243031e-01f, -1.48987561e-01f, 2.80934662e-01f, -1.78577490e-02f, 1.93198919e-01f, 1.19322680e-01f, -9.19061750e-02f, 2.21324295e-01f,
  -8.72143731e-02f, 3.10770273e-02f, -2.44416580e-01f, 1.60520561e-02f, 2.19469547e-01f, -5.09962551e-02f, -1.29777119e-01f, 3.81927122e-03f, 3.24977338e-02f, 3.43322731e-03f,
  -3.29134651e-02f, 2.51889750e-02f, -5.09738438e-02f, -9.86748114e-02f, -1.01742581e-01f, -1.86946616e-01f, -1.37125298e-01f, -2.36462474e-01f, -6.52717724e-02f, -6.16609398e-03f,
  4.15698104e-02f, -8.87772813e-03f, -1.31848425e-01f, -9.23833847e-02f, -1.11608967e-01f, -7.16163218e-02f, -4.40793820e-02f, -9.69384313e-02f, -1.09689295e-01f, 2.81290203e-01f,
  -2.33151633e-02f, -3.14583890e-02f, -4.34599211e-03f, 6.69415817e-02f, 3.76246944e-02f, 2.26305500e-02f, 7.06318989e-02f, 2.96459422e-02f, -3.35279629e-02f, 5.69327548e-02f,
  -1.49080195e-02f, 3.02368253e-02f, -1.74615905e-02f, -7.30662569e-02f, -9.11729187e-02f, -1.44787161e-02f, 8.36303085e-02f, 8.01399164e-03f, -4.57957350e-02f, -1.75941046e-02f,
  -1.17643610e-01f, 1.54973082e-02f, 3.92997302e-02f, -1.35984362e-06f, 3.49386930e-02f, -3.60034592e-03f, -5.03714867e-02f, -1.49512244e-03f, -6.78105876e-02f, -4.48986962e-02f,
  6.84491992e-02f, -1.79615229e-01f, 1.34172007e-01f, -2.74681956e-01f, 7.55073801e-02f, 4.80035692e-02f, 1.14025138e-01f, 4.12481315e-02f, 1.30233943e-01f, -2.41356175e-02f,
  -1.34654686e-01f, -4.90025757e-03f, -4.48753312e-02f, -7.56379366e-02f, -1.98859200e-01f, -9.58341137e-02f, -7.41294622e-02f, 5.91314249e-02f, -8.56226385e-02f, 1.68715075e-01f,
  1.45541981e-01f, -4.14325558e-02f, -8.27396289e-03f, 1.08698860e-01f, 1.78009365e-02f, -7.16929212e-02f, -3.93425673e-03f, 2.94883195e-02f, -1.90650225e-01f, 3.38102221e-01f,
  -6.14225090e-01f, 2.43090317e-01f, -2.00485718e-02f, -5.23216873e-02f, 1.83345184e-01f, 1.28285512e-01f, 7.06003532e-02f, -1.04231521e-01f, 4.56619039e-02f, 1.35909185e-01f,
  1.19443834e-01f, -8.57393444e-02f, 7.89528638e-02f, 3.53134871e-02f, -1.15554765e-01f, 2.77598977e-01f, 3.18520069e-01f, -2.23112002e-01f, -3.88748616e-01f, -2.32725725e-01f,
  1.02818981e-01f, -1.84593812e-01f, -4.02578980e-01f, -1.96235970e-01f, 1.67225897e-01f, 3.41167524e-02f, 1.75245211e-01f, 9.58660692e-02f, 1.64548919e-01f, 2.35234827e-01f,
  -8.49823803e-02f, -1.01244181e-01f, -1.01452120e-01f, -1.00272276e-01f, 9.77664888e-02f, -1.26688272e-01f, -5.36120832e-02f, -5.86871095e-02f, 4.63433657e-03f, -5.07359654e-02f,
  2.62259487e-02f, 2.86792293e-02f, 8.67182985e-02f, -2.38348115e-02f, -1.02109008e-01f, -1.82619333e-01f, -1.66913822e-01f, -2.52063602e-01f, -1.59402117e-01f, -1.43751830e-01f,
  1.70528799e-01f, -1.39719350e-02f, -1.05206840e-01f, -7.88403228e-02f, -7.40254596e-02f, -1.22409843e-01f, -1.39887139e-01f, -2.10493505e-01f, -2.63671547e-01f, -1.91787779e-01f,
  5.86955957e-02f, 7.11726993e-02f, 5.70650063e-02f, -7.14959763e-03f, -6.80114795e-03f, 1.44050671e-02f, 1.12359397e-01f, 3.69176120e-02f, 4.01898883e-02f, -4.12018113e-02f,
  5.49478941e-02f, -5.80609813e-02f, -8.96089599e-02f, 5.16869090e-02f, -4.76988368e-02f, -5.48628345e-02f, 1.41122108e-02f, -2.15210449e-02f, 1.29526043e-02f, -3.72665264e-02f,
  1.93695258e-02f, 7.90149160e-03f, 6.88926056e-02f, -4.27799039e-02f, 1.03547633e-01f, 3.06929518e-02f, 6.78450987e-02f, -1.03872210e-01f, -1.17521904e-01f, 9.91496257e-03f,
  -1.33191034e-01f, -2.56624706e-02f, -3.87831554e-02f, -2.48149987e-02f, 8.59853476e-02f, -2.03977190e-02f, 3.41625996e-02f, -1.34922275e-02f, 7.61115327e-02f, -1.17969260e-01f,
  -8.26661587e-02f, -1.41350525e-02f, 1.31913751e-01f, -6.55847117e-02f, -1.49071723e-01f, -1.00987349e-02f, 8.64063948e-02f, -1.73788983e-02f, -5.19579090e-02f, -1.54780420e-02f,
  1.92150865e-02f, -1.71043172e-01f, -2.24623173e-01f, -8.55602697e-02f, 3.34917568e-03f, -1.62293702e-01f, -1.61432683e-01f, -2.07153276e-01f, -2.09399477e-01f, -1.98470399e-01f,
  -3.16643327e-01f, 2.20183939e-01f, 8.16763286e-03f, -3.31930250e-01f, 5.06215021e-02f, 2.03013510e-01f, 3.64155084e-01f, 2.00111926e-01f, -1.45214871e-01f, -4.18018829e-03f,
  1.36957988e-01f, -1.03210188e-01f, -1.35922655e-01f, -2.25081760e-02f, 1.01917587e-01f, 1.10855438e-01f, -1.29603103e-01f, -1.56200022e-01f, 7.29026943e-02f, 1.91129580e-01f,
  8.65522027e-02f, -1.32598981e-01f, -1.98870018e-01f, -1.17164068e-01f, -1.88164562e-01f, -2.03751951e-01f, -1.48239180e-01f, -1.50902256e-01f, 4.28066999e-02f, -2.36505941e-01f,
  -1.14603445e-01f, 8.58608913e-03f, 9.19039622e-02f, -1.01828352e-01f, -9.66378376e-02f, -1.22538134e-01f, 4.65960093e-02f, -3.14759724e-02f, 1.74329765e-02f, -3.58878858e-02f,
  -1.34053163e-03f, 2.04011034e-02f, -7.30426162e-02f, 1.59239047e-03f, 1.09227502e-03f, 5.11860363e-02f, -5.60369194e-02f, -6.01974363e-03f, -1.04000889e-01f, 2.69326754e-02f,
  -1.44532612e-02f, -9.81685147e-02f, -1.18302844e-01f, 9.59058106e-03f, -2.69411802e-02f, -1.56665668e-01f, 3.71131226e-02f, -1.68192293e-02f, -1.42891109e-02f, -2.16993108e-01f,
  1.04024783e-02f, 3.45670171e-02f, 6.15364090e-02f, 4.38441709e-02f, 2.45786384e-02f, 4.95265424e-02f, -2.77578067e-02f, -1.30922049e-02f, -4.42623049e-02f, 1.07046224e-04f,
  8.73979479e-02f, 4.64736298e-02f, 5.44269979e-02f, 1.35268485e-02f, -1.68330409e-02f, 1.31501779e-02f, -6.84006652e-03f, -2.46149227e-02f, -6.49417937e-02f, 3.05932835e-02f,
  -2.44474765e-02f, -5.87928630e-02f, -3.50428335e-02f, -1.49557143e-02f, -2.63421871e-02f, 4.54830676e-02f, -2.82068159e-02f, 2.34654639e-02f, 3.32146592e-04f, 1.33069873e-01f,
  -1.30475104e-01f, 1.50997117e-01f, -1.53000936e-01f, 4.98316810e-02f, -6.60121515e-02f, -6.92440420e-02f, -6.64112195e-02f, 3.38214822e-02f, -9.10630822e-03f, 1.13856234e-02f,
  1.39200285e-01f, -3.84310186e-02f, -9.29547921e-02f, 9.49322246e-03f, 1.66052189e-02f, -6.23708926e-02f, -3.38631384e-02f, -1.46748140e-01f, -3.84149551e-02f, -1.07463405e-01f,
  -1.55383229e-01f, -9.31388661e-02f, -2.67287016e-01f, -1.43813163e-01f, -1.40914768e-01f, -2.08733931e-01f, -1.01183407e-01f, -4.88404036e-02f, -9.74927396e-02f, -2.22141892e-01f,
  5.10914087e-01f, 5.18776774e-01f, -4.01006848e-01f, 2.74997413e-01f, -2.90852487e-01f, -4.02237892e-01f, -8.72297063e-02f, 7.15076849e-02f, 2.38665983e-01f, 2.83830166e-01f,
  -1.26749620e-01f, -2.60887533e-01f, -1.39714748e-01f, -1.91729382e-01f, -2.67869145e-01f, 7.99775571e-02f, 6.14997521e-02f, -2.73549289e-01f, -4.68539834e-01f, -1.63714707e-01f,
  8.89671072e-02f, 1.06009617e-01f, 8.76960158e-02f, 2.40953341e-02f, 3.82314712e-01f, -5.12988456e-02f, 1.56295806e-01f, 8.81889462e-02f, -6.21613376e-02f, 3.30842495e-01f,
  -6.01772405e-02f, 2.01876670e-01f, -2.87097245e-01f, 9.18588787e-03f, -7.54170641e-02f, -6.59081712e-03f, -8.79934356e-02f, -5.97068667e-02f, -8.80722255e-02f, 7.02462941e-02f,
  -1.35990649e-01f, -1.57192275e-02f, -1.20610505e-01f, -1.61571726e-02f, -2.64777429e-02f, -1.09346308e-01f, 4.00207676e-02f, -1.03524446e-01f, -1.96273364e-02f, -8.27929936e-03f,
  -7.03391209e-02f, -1.04193486e-01f, -1.60890266e-01f, -2.30199341e-02f, -2.81009879e-02f, -1.88700542e-01f, -6.43995032e-02f, 5.60032092e-02f, -1.43620431e-01f, 3.22292328e-01f,
  1.73225135e-01f, -8.14318284e-02f, -3.92257646e-02f, 7.39924982e-02f, 1.33519188e-01f, -2.52140742e-02f, 3.24017964e-02f, 6.43717945e-02f, -3.27886827e-02f, -1.22170374e-02f,
  -6.52867630e-02f, -3.32444310e-02f, -3.73590328e-02f, 1.94607098e-02f, 5.09532774e-03f, 5.51329134e-03f, -7.14362366e-03f, 1.19548947e-01f, 6.66960562e-03f, 6.90199807e-02f,
  1.58268847e-02f, -3.36939422e-03f, -9.89310890e-02f, 2.80758296e-03f, 2.26016659e-02f, -5.94391814e-03f, 1.85936019e-02f, -4.70438926e-03f, 2.56781690e-02f, 6.11825399e-02f,
  1.06371105e-01f, -2.79683143e-01f, 1.43873826e-01f, 3.28121893e-02f, 2.23648287e-02f, -2.58187391e-02f, 8.28610510e-02f, -2.87099779e-02f, -1.89184975e-02f, 2.56952886e-02f,
  -1.12553805e-01f, -2.97741666e-02f, -3.64839584e-02f, -8.28855187e-02f, -1.32265627e-01f, -6.69083968e-02f, 3.30477059e-02f, -8.49727467e-02f, -6.20712973e-02f, -5.35740284e-03f,
  7.36124068e-02f, -2.94155162e-02f, -6.47045225e-02f, -6.49900138e-02f, 3.16685401e-02f, -1.34094939e-01f, -3.40214893e-02f, 5.87721355e-03f, -3.07617962e-01f, 2.72469133e-01f,
  -3.28094959e-01f, 5.80284223e-02f, -7.07026124e-02f, -7.27997674e-03f, 7.29904622e-02f, 8.73776823e-02f, -1.67528074e-02f, 1.11752704e-01f, 1.00391619e-01f, -9.76430401e-02f,
  -1.71494248e-04f, -3.70840542e-02f, 5.43747358e-02f, 6.41975924e-02f, 1.85087278e-01f, 2.07471102e-01f, 2.16331691e-01f, 1.09660737e-01f, -1.04470802e-02f, -1.82655349e-01f,
  -2.26546004e-02f, -4.06359099e-02f, 2.11995319e-02f, 8.57946351e-02f, -8.12673792e-02f, -2.89687905e-02f, 1.02680333e-01f, 2.89306920e-02f, -8.27582832e-03f, 1.29893586e-01f,
  5.27572120e-03f, -3.79338339e-02f, 9.93793923e-03f, 1.14287466e-01f, -4.19225693e-02f, 7.63744712e-02f, 1.13810459e-02f, 2.87794210e-02f, -2.49675512e-02f, -6.98940009e-02f,
  4.02515382e-02f, 9.06409603e-03f, 1.51842181e-02f, -1.47669613e-01f, -7.11457208e-02f, -1.66216437e-02f, -1.04051247e-01f, -4.46313843e-02f, 1.48331985e-01f, 1.87336914e-02f,
  6.92061782e-02f, -1.27571285e-01f, -7.11243749e-02f, 3.17835137e-02f, 1.06345057e-01f, 6.99456688e-03f, -1.03328928e-01f, 7.14949390e-04f, -1.16031421e-02f, -5.37840948e-02f,
  1.51082382e-01f, 1.82236079e-02f, -1.01234415e-03f, -1.38277700e-02f, 3.28087658e-02f, -5.43232672e-02f, 5.89619577e-03f, -3.14405710e-02f, 1.19816542e-01f, 4.38725092e-02f,
  -1.05946645e-01f, 1.36482641e-02f, 6.04940653e-02f, -2.56218053e-02f, 4.84234467e-02f, -2.50767302e-02f, 3.37017677e-03f, 8.49660933e-02f, 2.07123943e-02f, 1.39460549e-01f,
  7.68678263e-03f, 2.34978888e-02f, 1.84949655e-02f, 6.27993271e-02f, -7.63543369e-03f, 4.76205610e-02f, 1.05783559e-01f, -1.22039681e-02f, 5.92205860e-02f, 1.00527957e-01f,
  9.13591608e-02f, 1.11636020e-01f, -7.26127401e-02f, 2.86546946e-02f, 3.64123210e-02f, -3.55789065e-02f, -9.65209007e-02f, -7.74985701e-02f, -7.60095716e-02f, -6.61990494e-02f,
  1.93755515e-02f, -1.37930468e-01f, 1.08043291e-02f, 2.76716542e-03f, -8.97712037e-02f, -5.68572767e-02f, -1.53512746e-01f, -9.00473297e-02f, 1.76110610e-01f, 1.06710494e-01f,
  4.85909581e-02f, -1.26856402e-01f, -1.50019467e-01f, -1.30138412e-01f, -2.41874065e-03f, -5.83512932e-02f, -1.86115205e-01f, -4.51018065e-02f, -1.23353273e-01f, -2.07530305e-01f,
  -3.24125022e-01f, -1.65906936e-01f, -2.61932462e-01f, -4.52267289e-01f, -2.83919275e-01f, -4.36548330e-02f, -1.59775037e-02f, -7.20163360e-02f, -1.21922307e-01f, -1.56616747e-01f,
  5.38313538e-02f, 1.73501462e-01f, 4.79445793e-02f, 1.55087441e-01f, 1.91417098e-01f, -8.36931914e-02f, -2.70533890e-01f, -7.60234520e-02f, 1.22386463e-01f, 6.55265450e-02f,
  -4.12331865e-04f, -2.11282462e-01f, -1.70658648e-01f, -2.72485670e-02f, -2.44869262e-01f, -4.08687368e-02f, -2.02816457e-01f, -2.07848430e-01f, 1.58746988e-02f, -2.69815356e-01f,
  1.65339008e-01f, -1.70584932e-01f, 1.04624098e-02f, -9.38979501e-04f, -1.64749056e-01f, -1.66957751e-02f, -1.11232623e-02f, -8.12717527e-02f, -9.95991156e-02f, -7.14292973e-02f,
  -1.03339396e-01f, 4.76993211e-02f, 6.48752078e-02f, 2.50699352e-02f, -1.54967576e-01f, 6.22835383e-02f, -7.88387209e-02f, -1.13380514e-01f, -1.01062089e-01f, 2.38142237e-02f,
  6.78927526e-02f, -6.99810917e-03f, 5.49806654e-02f, 4.60077170e-03f, -2.84639150e-02f, -3.21981907e-02f, -9.89372097e-03f, -5.56203350e-02f, 7.12017566e-02f, -1.24746218e-01f,
  -2.75395159e-02f, -8.53186026e-02f, -1.28443450e-01f, -2.54597366e-02f, -5.76988272e-02f, 5.61354719e-02f, -8.37455466e-02f, 2.95014400e-02f, 2.97216140e-02f, 3.62334698e-02f,
  -4.04135212e-02f, 2.17082147e-02f, 3.45364176e-02f, -2.65857894e-02f, -5.06658442e-02f, -4.70907949e-02f, 1.90951489e-02f, -3.01023647e-02f, 3.21949720e-02f, 9.24332161e-03f,
  7.63803581e-03f, -7.08191693e-02f, -6.80762976e-02f, -5.15425950e-03f, 3.19847651e-02f, -5.40661514e-02f, 4.22689505e-02f, 1.52939066e-01f, 5.72262220e-02f, -1.97908804e-02f,
  1.64420173e-01f, 1.19723938e-01f, 2.59850845e-02f, -7.98457339e-02f, -2.37199180e-02f, -2.97137313e-02f, -1.06242813e-01f, -4.64022644e-02f, 4.35179099e-02f, 1.35021089e-02f,
  7.14917257e-02f, 9.91192162e-02f, 5.00131063e-02f, -8.47818181e-02f, 1.01179909e-03f, -1.80256478e-02f, -3.06904111e-02f, 2.57385354e-02f, -3.60202342e-02f, -6.39117509e-02f,
  -3.63852046e-02f, 2.52373647e-02f, 1.70585558e-01f, 8.79085362e-02f, 5.41989766e-02f, 7.50861838e-02f, 1.37272179e-01f, 4.54294570e-02f, 1.53808266e-01f, -3.65636349e-02f,
  -3.24327648e-01f, 3.48487228e-01f, -2.96641976e-01f, 6.14118911e-02f, -6.06643744e-02f, -9.49689224e-02f, 2.51758903e-01f, 2.09938243e-01f, 2.47331053e-01f, 3.00452620e-01f,
  6.30643293e-02f, -1.68151364e-01f, -5.40235229e-02f, -8.69460031e-02f, -2.35550746e-01f, 3.29087347e-01f, 2.28471562e-01f, -4.02808756e-01f, -5.73029459e-01f, -2.76521087e-01f,
  3.92530747e-02f, -2.36334465e-02f, -2.65519023e-01f, -1.76883146e-01f, 2.74970084e-01f, -6.59056678e-02f, 2.08024383e-01f, -2.01218389e-02f, -1.39940660e-02f, 5.22593036e-02f,
  -2.08000019e-01f, -1.48394212e-01f, -1.23454385e-01f, -1.75391361e-01f, 1.32748799e-03f, -1.71875119e-01f, -1.10932581e-01f, -1.61281466e-01f, -1.89209044e-01f, -2.35978235e-02f,
  -1.78075761e-01f, -1.44104943e-01f, -2.01772064e-01f, -3.60587835e-02f, -1.19712800e-01f, -1.56682819e-01f, 6.79765120e-02f, -1.82239383e-01f, -1.03350110e-01f, -1.69377401e-01f,
  -6.17676601e-02f, -2.84893364e-01f, -2.90301353e-01f, -5.27191609e-02f, -1.09220766e-01f, -1.96566001e-01f, -9.56715643e-02f, -1.71981215e-01f, -2.09932730e-01f, 6.20484538e-02f,
  4.50318940e-02f, 2.46280488e-02f, -4.93985824e-02f, 9.66320932e-02f, 1.46750048e-01f, 7.01158568e-02f, 5.02924323e-02f, -4.59343605e-02f, -1.54452235e-01f, -7.36506879e-02f,
  -3.02939955e-03f, 8.28351080e-02f, -4.34529409e-02f, -4.71067131e-02f, 5.56401210e-03f, -2.51910482e-02f, -3.05765830e-02f, 2.14548022e-01f, 2.43943837e-02f, -3.68306153e-02f,
  -3.84440238e-04f, -8.56362730e-02f, -4.95437160e-02f, 1.07192772e-03f, 5.28897457e-02f, -3.85171585e-02f, 3.59652303e-02f, 4.15681340e-02f, 4.51482758e-02f, 6.98214769e-02f,
  2.36205384e-01f, -1.63471550e-02f, 1.34338915e-01f, 1.11896612e-01f, 4.21968754e-03f, -1.30113671e-02f, 6.22223020e-02f, 6.04778267e-02f, -2.49436516e-02f, -1.36284098e-01f,
  -1.19156435e-01f, -1.40218452e-01f, 6.62706420e-02f, -1.02800421e-01f, -2.26291150e-01f, 1.82955172e-02f, 2.22840756e-01f, 2.86143087e-02f, 3.39227100e-03f, -2.28606425e-02f,
  1.83490217e-01f, -4.34738733e-02f, -8.40667486e-02f, 4.06323224e-02f, 4.37518880e-02f, -3.36299874e-02f, 1.16615938e-02f, 2.91470364e-02f, -1.13433957e-01f, 3.32721084e-01f,
  -6.29324377e-01f, 3.49085212e-01f, 1.93637878e-01f, -3.64284694e-01f, -1.03871688e-01f, 1.27281412e-01f, 3.08038175e-01f, -1.16035238e-01f, -2.01540098e-01f, 2.01380357e-01f,
  1.59376152e-02f, -4.83738720e-01f, -2.24081933e-01f, -2.59258747e-01f, -2.06574872e-01f, 2.18343884e-01f, -3.09153274e-02f, -2.45692611e-01f, -5.21891773e-01f, -2.77321249e-01f,
  -2.15663239e-01f, -2.63058484e-01f, -3.99133652e-01f, -1.95621446e-01f, -5.35096936e-02f, -4.06118929e-01f, -3.78142744e-02f, -6.69227019e-02f, -3.27541344e-02f, -8.06614384e-02f,
  3.13163012e-01f, -1.03351519e-01f, -2.11229846e-01f, -2.06117064e-01f, 8.38009045e-02f, -8.66648182e-02f, 6.31246716e-02f, 2.01136917e-02f, 1.36407288e-02f, 5.31465635e-02f,
  -1.86889637e-02f, -4.20519635e-02f, -4.04456668e-02f, 7.93017149e-02f, 8.81787315e-02f, -2.67919488e-02f, 1.16036877e-01f, -6.80374354e-02f, -2.66083293e-02f, 1.74924076e-01f,
  -2.15367158e-03f, -3.92039120e-02f, 1.38560489e-01f, -8.37797020e-03f, 7.53873959e-02f, -3.99014242e-02f, 7.56270811e-02f, 6.56495010e-03f, -5.98625988e-02f, 9.64348316e-02f,
  4.44078520e-02f, 3.60456184e-02f, -1.04195811e-01f, -4.24129367e-02f, 4.80997749e-02f, 5.55953458e-02f, 6.16257042e-02f, 7.30237365e-02f, 3.48563008e-02f, 3.25732343e-02f,
  6.00799881e-02f, 1.50621543e-02f, 3.60808559e-02f, -4.11516847e-03f, -4.83918972e-02f, 1.43550104e-02f, -7.08063692e-02f, 5.83379194e-02f, 6.67494386e-02f, -3.27119306e-02f,
  -1.69986919e-01f, -7.23400526e-03f, -1.88710708e-02f, 7.73323029e-02f, 5.56015559e-02f, 5.72605431e-02f, 7.05860183e-03f, -1.55518334e-02f, 5.61271887e-03f, -2.45244093e-02f,
  -1.05145231e-01f, -8.66159946e-02f, -4.23572063e-02f, 5.84394531e-03f, 4.85744551e-02f, 2.83392668e-02f, -5.39305285e-02f, -4.17584181e-02f, -4.29339260e-02f, 4.33575138e-02f,
  -6.92836121e-02f, 3.71772721e-02f, 6.36506304e-02f, 9.48595256e-02f, -5.06220907e-02f, -6.34136284e-03f, 1.44587234e-01f, -3.64702120e-02f, 9.65339616e-02f, 2.11381361e-01f,
  2.51165777e-01f, 8.55210200e-02f, 9.09851715e-02f, 1.22206859e-01f, -1.83838382e-02f, -1.50707871e-01f, 1.13398328e-01f, 1.29950652e-02f, 1.04899041e-01f, 2.18189701e-01f,
  -3.61982882e-01f, -3.46005678e-01f, 2.59465009e-01f, -1.60179809e-01f, -4.21101265e-02f, 1.51712582e-01f, 5.27635105e-02f, -1.09047756e-01f, -1.36364207e-01f, -2.22390682e-01f,
  -3.17425579e-01f, -3.09932351e-01f, -2.64781415e-01f, -1.48104697e-01f, -1.14109665e-01f, 9.21137854e-02f, 2.45626897e-01f, 2.40489528e-01f, 2.12610021e-01f, 3.24859023e-02f,
  -3.96183729e-02f, 8.75508692e-03f, -1.02333147e-02f, -5.83660230e-02f, -1.39344379e-01f, -4.88801375e-02f, -9.62494165e-02f, -3.19723859e-02f, -9.13150907e-02f, -2.71820277e-02f,
  8.70504156e-02f, -2.07661971e-01f, 4.84172478e-02f, -1.69957787e-01f, -1.28961608e-01f, -9.96267051e-02f, -5.75501733e-02f, -1.22429177e-01f, -1.24834977e-01f, 5.12017682e-02f,
  -1.71219423e-01f, -7.35535920e-02f, -8.60914961e-02f, -1.11867040e-02f, -7.60241747e-02f, 6.28824160e-02f, -1.56753734e-01f, -6.08177446e-02f, -1.00491159e-02f, -1.71024457e-01f,
  -1.09839924e-01f, -9.82045233e-02f, -3.54626328e-02f, 1.20001277e-02f, -1.27485529e-01f, -1.66297927e-02f, -1.05466157e-01f, -3.10611632e-02f, -1.15520090e-01f, -1.02583796e-01f,
  1.86898187e-01f, -6.81867227e-02f, -8.80075321e-02f, -5.96188717e-02f, -1.44985402e-02f, -1.19654588e-01f, 3.26316729e-02f, -6.84124604e-02f, -9.43697169e-02f, 1.48330638e-02f,
  -1.02795057e-01f, -1.04658805e-01f, 1.97092257e-02f, -7.37121105e-02f, -1.11640900e-01f, 2.56650057e-02f, -3.18891741e-02f, 2.61848606e-02f, 1.97004620e-02f, -9.20250565e-02f,
  -1.48698106e-01f, 1.09625980e-02f, -3.52511369e-02f, 2.27281377e-02f, -5.75901903e-02f, 4.39725369e-02f, 5.09067141e-02f, -3.09545593e-03f, -7.81004280e-02f, -5.74311949e-02f,
  1.49579989e-02f, -1.15366027e-01f, -1.11870589e-02f, -2.97945794e-02f, -9.79370251e-03f, -3.47279757e-02f, -7.66883641e-02f, 4.57788333e-02f, -8.49681944e-02f, 1.25062779e-01f,
  3.41279209e-02f, -5.42917810e-02f, 1.77729893e-02f, 1.10169677e-02f, 1.41056031e-01f, -1.39117464e-02f, -6.85764290e-03f, 3.85197485e-03f, -7.65464008e-02f, 3.91930714e-02f,
  -7.72990957e-02f, 5.71045727e-02f, 1.00231476e-01f, -5.39791025e-02f, 1.59425233e-02f, 1.35568336e-01f, 1.00461662e-01f, 1.09714985e-01f, 1.48197263e-01f, 1.67652398e-01f,
  3.30470532e-01f, -1.18434161e-01f, -4.20490324e-01f, 2.64078587e-01f, 2.79038250e-01f, 1.02077067e-01f, -4.14290726e-02f, 4.83253933e-02f, 1.00149103e-01f, -3.35316546e-02f,
  1.83468342e-01f, 3.21086138e-01f, 4.47619408e-02f, 1.33282050e-01f, -1.00631127e-03f, -3.63663793e-01f, -3.39615077e-01f, -2.08375409e-01f, 1.01638228e-01f, 4.07634228e-01f,
  3.14596146e-01f, 1.93771809e-01f, 7.53502920e-02f, -2.98199896e-02f, -1.34255528e-01f, 7.09804669e-02f, -2.37627372e-01f, 2.54136305e-02f, -8.88465792e-02f, -2.88905919e-01f,
  -1.48339078e-01f, -1.25645265e-01f, 1.29353246e-02f, 1.82851806e-01f, -7.49429762e-02f, -2.08941534e-01f, -1.56971678e-01f, -2.77087837e-01f, -2.74479669e-02f, -2.22060353e-01f,
  2.92518567e-02f, -4.27262001e-02f, 5.92296571e-02f, -1.17327176e-01f, -3.62541489e-02f, -1.60960332e-02f, -1.39771655e-01f, -2.04841509e-01f, -1.84543654e-01f, -8.42243060e-02f,
  1.08522274e-01f, 9.91960838e-02f, -1.67784348e-01f, -1.33180216e-01f, -2.38205448e-01f, -7.54372329e-02f, -2.49347538e-01f, -1.09790519e-01f, -1.58482403e-01f, -2.71308422e-01f,
  1.03677742e-01f, 6.21258356e-02f, 9.32302251e-02f, -1.75689477e-02f, 9.31580439e-02f, -1.48733146e-02f, -5.56448521e-03f, 4.48208973e-02f, -2.74254438e-02f, -7.19362348e-02f,
  8.33038390e-02f, -1.60042178e-02f, 1.83589514e-02f, -6.95155561e-02f, 3.48275639e-02f, 1.67170935e-03f, 5.79443350e-02f, -3.98727953e-02f, -5.14876992e-02f, -4.10698028e-03f,
  4.32486720e-02f, -3.97273004e-02f, 3.97973359e-02f, -2.60252804e-02f, -3.02874893e-02f, 7.52889924e-03f, 4.22096550e-02f, 1.01947412e-01f, 8.92607644e-02f, 6.00689352e-02f,
  1.83506653e-01f, -4.09329405e-05f, -9.11192596e-02f, 3.38914320e-02f, -1.09913170e-01f, -3.63062061e-02f, -1.17805433e-02f, -1.01746514e-01f, -8.70091990e-02f, -3.44799496e-02f,
  2.17602402e-02f, -7.67293992e-03f, -6.21178597e-02f, -4.85374816e-02f, -1.80578511e-02f, -2.08365358e-02f, 1.03272907e-02f, 4.16843081e-03f, 1.62034687e-02f, -1.14982367e-01f,
  -9.88659337e-02f, 1.42986691e-02f, 6.92068860e-02f, -6.53131530e-02f, -6.20834762e-03f, 1.09312065e-01f, -1.81532413e-01f, -1.74897924e-01f, -1.11671738e-01f, -2.08188996e-01f,
  -7.63272882e-01f, -2.28867963e-01f, 5.66011555e-02f, 8.79152969e-04f, 2.18913401e-03f, -1.14405110e-01f, -5.97165152e-02f, -1.37518048e-01f, -3.73991765e-02f, 2.65745111e-02f,
  -8.98649730e-03f, 1.61954150e-01f, 1.77543774e-01f, 1.93730488e-01f, 1.27277344e-01f, 6.68453574e-02f, 2.06145853e-01f, 3.08130719e-02f, -1.02391921e-01f, -1.33515164e-01f,
  1.45639300e-01f, -6.82624057e-02f, -2.95737702e-02f, 4.29854877e-02f, 5.54725118e-02f, 1.21131659e-01f, 2.33707443e-01f, 2.26350054e-01f, 1.78155065e-01f, 2.59092540e-01f,
  5.96474826e-01f, -9.50151160e-02f, 7.33272433e-02f, -1.03817414e-03f, -7.11468458e-02f, -3.34922336e-02f, 3.31485681e-02f, -5.37467282e-03f, -3.16761583e-02f, -2.92754378e-02f,
  2.13436671e-02f, 9.19070616e-02f, 3.65558034e-03f, -3.94251980e-02f, -5.27820811e-02f, 6.69001713e-02f, -1.80971369e-01f, -7.99742192e-02f, 1.24887072e-01f, 1.51203766e-01f,
  -9.26220417e-02f, -6.37718290e-03f, 9.23902541e-02f, 3.32784019e-02f, -7.52024800e-02f, 5.00264652e-02f, 1.16522033e-02f, -8.56064782e-02f, 1.88804734e-02f, 4.23794379e-03f,
  4.19197977e-02f, -2.20106304e-01f, -5.00909379e-03f, 8.64352360e-02f, 1.29383784e-02f, -1.22888289e-01f, -7.88781717e-02f, -8.08531865e-02f, -1.47792306e-02f, -1.31727114e-01f,
  1.47588611e-01f, 2.18756512e-01f, -6.28455803e-02f, 1.11215949e-01f, 1.17117271e-01f, -7.13042319e-02f, -2.14718893e-01f, -5.01723122e-03f, 1.39977008e-01f, 3.00247758e-03f,
  -1.85245667e-02f, -5.96498922e-02f, 4.79292348e-02f, 8.81702080e-02f, 1.40492823e-02f, -4.94898930e-02f, 9.89232957e-02f, 6.94096088e-02f, -4.42350768e-02f, -1.18180677e-01f,
  4.81196761e-01f, 2.61993229e-01f, 1.04071528e-01f, -1.51591644e-01f, -9.32206810e-02f, -1.99487552e-01f, -1.77441668e-02f, 7.13579357e-02f, 1.51007965e-01f, 1.06258746e-02f,
  -3.47140804e-02f, -1.52853176e-01f, -8.83833393e-02f, 4.98453751e-02f, -3.40101495e-02f, -4.81891893e-02f, -7.79166222e-02f, -3.21086422e-02f, 1.33059084e-01f, 1.55470967e-01f,
  -1.97847723e-03f, -6.57666549e-02f, 9.96043086e-02f, -5.70981652e-02f, 3.93709354e-02f, 6.47693425e-02f, 1.51802763e-01f, 6.65105656e-02f, 8.67517143e-02f, -9.39418450e-02f,
  3.67697477e-01f, -1.32404760e-01f, -6.59554720e-01f, 1.59372330e-01f, -2.89065633e-02f, -1.03994146e-01f, -9.65594351e-02f, 2.24092836e-03f, 1.22880988e-01f, -1.56456515e-01f,
  -8.98554921e-02f, 8.14246759e-02f, -2.13440344e-01f, -1.59881994e-01f, -1.67907044e-01f, -3.47087771e-01f, -3.72894973e-01f, -2.75376111e-01f, 7.97272846e-02f, 3.51918370e-01f,
  2.94202596e-01f, 2.59048909e-01f, 1.78107694e-01f, 3.64688262e-02f, -7.77296769e-03f, 5.81949390e-02f, -3.10409039e-01f, -4.69143328e-04f, -1.66806236e-01f, -2.45446041e-01f,
  -1.70917973e-01f, -1.19970210e-01f, -8.00560489e-02f, 8.41683224e-02f, -1.06804945e-01f, 2.65906733e-02f, -6.39279326e-03f, -1.12745650e-01f, -2.04068255e-02f, -8.17606971e-02f,
  3.86925898e-02f, 2.77591534e-02f, -3.03489547e-02f, -1.79237302e-03f, 7.76989162e-02f, 9.81041715e-02f, -4.25622314e-02f, -8.34887624e-02f, -1.56966597e-01f, -4.74847034e-02f,
  -2.57368721e-02f, -6.09100573e-02f, -2.20030382e-01f, -7.92529061e-02f, -4.37542945e-02f, -4.26701717e-02f, -2.85653882e-02f, -3.45427729e-02f, -1.11962199e-01f, -3.22103165e-02f,
  -4.20433842e-02f, -2.55016331e-02f, 3.96336392e-02f, 8.45218748e-02f, 7.51710311e-02f, -8.94744396e-02f, -6.52051792e-02f, -8.39410499e-02f, 3.67885418e-02f, 1.71144679e-02f,
  -9.29198787e-02f, -1.49279147e-01f, -2.97290254e-02f, -3.96294706e-02f, 1.43544851e-02f, -5.75020574e-02f, -7.16744363e-02f, -1.84978507e-02f, -4.58308607e-02f, 2.43444610e-02f,
  3.19236293e-02f, 3.62982042e-02f, 5.32518998e-02f, 9.51836556e-02f, -8.82862806e-02f, -7.35322088e-02f, 3.53405736e-02f, 2.78749373e-02f, 6.40945211e-02f, -1.51686966e-02f,
  2.55513579e-01f, -1.60050347e-01f, 3.48944329e-02f, -2.60523036e-02f, -4.49262410e-02f, -4.55606282e-02f, -1.61914043e-02f, -3.08547541e-02f, -1.21661268e-01f, 6.03025630e-02f,
  7.35779107e-02f, 4.52787057e-02f, -5.75604029e-02f, 1.13564897e-02f, 7.11435825e-02f, 6.72382712e-02f, 7.23221898e-02f, -1.17873706e-01f, -4.38293181e-02f, 7.25002587e-02f,
  3.78310233e-02f, 6.21623173e-02f, 8.81694630e-02f, -4.40700576e-02f, 6.29648939e-02f, 5.64452484e-02f, -1.37120420e-02f, 3.36240977e-02f, -1.08334765e-01f, 6.31341189e-02f,
  -5.31864703e-01f, 1.56884313e-01f, -5.93992434e-02f, -2.48267248e-01f, 8.91567022e-02f, 1.04715466e-01f, 1.87659577e-01f, -5.80554083e-02f, -7.24783465e-02f, 1.30603060e-01f,
  2.50273012e-02f, -7.81166479e-02f, 2.58760969e-03f, 5.53622320e-02f, 7.34864250e-02f, 2.63274193e-01f, 2.59600073e-01f, -4.60611954e-02f, -1.52415112e-01f, -1.23131312e-02f,
  1.32264972e-01f, -1.41188413e-01f, -3.19018602e-01f, -1.03078924e-01f, -1.29543431e-02f, -3.06220893e-02f, 5.40763848e-02f, -4.96032238e-02f, 2.20486552e-01f, 1.45340189e-01f,
  -1.32244662e-03f, -2.23776251e-01f, -2.52136644e-02f, -1.05837062e-01f, -2.26015225e-02f, -3.46390158e-02f, -2.57811975e-02f, -1.48062348e-01f, -5.07418253e-03f, -2.02795491e-02f,
  -2.09662667e-03f, -2.73876246e-02f, -4.40418674e-03f, 3.71506810e-02f, -3.47576439e-02f, -8.19891393e-02f, -8.66159126e-02f, -1.06897190e-01f, -9.11532044e-02f, -8.40636492e-02f,
  2.04991236e-01f, -6.07117154e-02f, -1.65467396e-01f, -1.79126579e-02f, -1.04115486e-01f, -1.00673132e-01f, -1.15137637e-01f, -1.40604079e-01f, -2.05629155e-01f, -1.23364992e-01f,
  9.86865256e-04f, 4.99927439e-02f, 4.08519879e-02f, -5.13565838e-02f, -1.16996374e-02f, -2.11748900e-03f, 6.96345372e-03f, 5.74624278e-02f, 1.36749223e-02f, -1.60519388e-02f,
  -5.16134612e-02f, -5.98418266e-02f, -4.36624363e-02f, -6.08121231e-02f, -1.56947714e-03f, -4.25693616e-02f, 6.40766770e-02f, 3.81501317e-02f, -3.23840454e-02f, -2.46223547e-02f,
  -2.58046691e-03f, 2.27447022e-02f, 1.38896110e-03f, 5.93180731e-02f, 1.07350864e-01f, 4.32880875e-03f, 1.59136094e-02f, 9.60764010e-03f, -6.10005446e-02f, 2.88073588e-02f,
  -1.86088130e-01f, 7.00689629e-02f, -4.55963016e-02f, 2.06489880e-02f, -1.84745342e-02f, -1.05986549e-02f, -3.72277275e-02f, -4.15466697e-04f, 1.59211475e-02f, -6.20663427e-02f,
  1.06681865e-02f, -1.67227183e-02f, 4.11480442e-02f, 2.43477449e-02f, 3.36623495e-03f, 5.27420256e-04f, 1.29060879e-01f, 7.51894638e-02f, 2.49284375e-02f, 1.54202618e-02f,
  6.91875815e-02f, -2.64757294e-02f, -1.46904930e-01f, 2.19783261e-02f, -1.22158192e-02f, -1.30063489e-01f, -6.30162433e-02f, -5.13845012e-02f, -9.25295576e-02f, -9.77257714e-02f,
  2.40420908e-01f, 4.02144343e-01f, 1.69965893e-01f, 1.04147665e-01f, -5.59376404e-02f, -7.34023005e-02f, -1.65191423e-02f, -1.01393446e-01f, 4.40902598e-02f, -1.69257484e-02f,
  -6.67912364e-02f, -1.25474378e-01f, -1.16306409e-01f, -4.22084183e-02f, -1.62762150e-01f, -1.59141362e-01f, -1.07280277e-01f, 6.60124868e-02f, -2.58239023e-02f, -5.84928729e-02f,
  -7.09615201e-02f, 7.13158622e-02f, 1.55473843e-01f, 3.59923244e-02f, 2.04469919e-01f, -1.34433657e-01f, 9.13482625e-03f, -2.60280091e-02f, -5.75402826e-02f, 1.79202721e-01f,
  2.44843319e-01f, 2.68374830e-01f, -7.04210475e-02f, -2.07687151e-02f, 1.12029709e-01f, 3.48361656e-02f, 8.64183251e-03f, 1.13500364e-01f, -6.09928854e-02f, -5.24760000e-02f,
  7.92350471e-02f, -3.72553407e-03f, 9.64393243e-02f, 4.96875085e-02f, 1.24681883e-01f, 7.82670081e-03f, 1.46775573e-01f, -4.55727391e-02f, 5.30579053e-02f, 4.25456874e-02f,
  1.23323441e-01f, 4.70944215e-03f, -3.53976414e-02f, -6.54920414e-02f, -1.81688115e-01f, -4.45581824e-02f, 7.38686249e-02f, 2.75680311e-02f, -2.99226232e-02f, -5.41663580e-02f,
  -5.99999540e-02f, 1.01597719e-02f, 1.39685631e-01f, -5.12693599e-02f, -1.27629369e-01f, -8.08538646e-02f, 1.90776621e-03f, -2.67122723e-02f, -1.43116757e-01f, -1.31527379e-01f,
  -5.37884422e-02f, 8.96924268e-03f, -2.53697974e-03f, -1.18560292e-01f, -3.27739045e-02f, 7.59608373e-02f, 4.14939523e-02f, 1.23898409e-01f, 7.34087825e-02f, 3.97768654e-02f,
  3.74487154e-02f, 3.11162900e-02f, 1.31081790e-01f, 1.22086503e-01f, 1.04830362e-01f, -3.18602733e-02f, -2.05627084e-02f, 2.92198285e-02f, 1.62739474e-02f, -1.14002135e-02f,
  1.77226096e-01f, -6.07820936e-02f, 3.97753380e-02f, 6.80815727e-02f, 9.62636247e-02f, 1.41783118e-01f, 8.02374035e-02f, 1.34017900e-01f, 5.56190871e-02f, 1.28416434e-01f,
  7.84216672e-02f, 1.62158489e-01f, 2.09310144e-01f, -6.56503960e-02f, -2.24911515e-02f, 5.70358671e-02f, 7.77678266e-02f, -2.46012770e-02f, -2.07218565e-02f, 1.10016339e-01f,
  4.23933491e-02f, -6.51304051e-02f, -1.24508142e-01f, -1.26440823e-01f, -1.60883933e-01f, -1.87916234e-01f, -8.28979686e-02f, 8.68351087e-02f, -5.06478101e-02f, -2.49043629e-01f,
  4.88995433e-01f, -1.02281496e-01f, 9.90348384e-02f, -6.33156076e-02f, -2.14328706e-01f, -9.34176072e-02f, -2.98813313e-01f, -4.74138856e-02f, -9.29973200e-02f, 3.05857453e-02f,
  -3.69805768e-02f, 7.82928765e-02f, 1.30373552e-01f, 1.68958515e-01f, 1.20938048e-01f, -7.07104243e-03f, -1.02572972e-02f, 3.02355081e-01f, 2.62215585e-01f, 1.64785050e-02f,
  -3.63372900e-02f, 2.18526945e-02f, 2.62159675e-01f, 1.46022007e-01f, -1.30838767e-01f, -5.58264903e-04f, -4.34992202e-02f, -1.63952649e-01f, -9.14982632e-02f, -3.54522839e-02f,
  -3.82156335e-02f, 1.79449275e-01f, 1.24926306e-01f, 1.40544623e-01f, 9.91667882e-02f, 9.89214331e-02f, 1.27787605e-01f, 4.49947752e-02f, -1.38334468e-01f, -8.54523554e-02f,
  -4.98927683e-02f, -4.28242758e-02f, 5.25825545e-02f, -7.36604631e-02f, -7.79213086e-02f, 6.17005192e-02f, 4.80153738e-03f, -5.50674787e-03f, 2.69890446e-02f, 2.13348195e-02f,
  7.88533911e-02f, -6.36763498e-02f, -1.86927453e-01f, 5.19747026e-02f, 1.11291170e-01f, 7.10069984e-02f, 3.79305333e-02f, 6.59747096e-03f, -5.04817395e-03f, -3.75923850e-02f,
  2.30326429e-01f, 1.55801356e-01f, 1.18892610e-01f, 8.18260908e-02f, 1.32430181e-01f, -1.03947036e-01f, -3.66169587e-02f, -4.69520800e-02f, 9.24082622e-02f, 1.15802839e-01f,
  -1.18772253e-01f, -2.74577476e-02f, 7.00781122e-02f, -5.30776978e-02f, 1.57694757e-01f, 8.15149322e-02f, 4.66851257e-02f, 8.41060355e-02f, 1.34206593e-01f, -3.74427289e-02f,
  -5.28467484e-02f, -1.30726591e-01f, -5.73342182e-02f, -1.11224078e-01f, -9.50837061e-02f, -7.06952959e-02f, -8.49309862e-02f, 9.07499939e-02f, -5.64590432e-02f, -1.53776646e-01f,
  -2.75854677e-01f, 2.73264140e-01f, 1.42560899e-01f, 1.25419676e-01f, 1.98630616e-02f, 1.18006133e-01f, 1.45563841e-01f, 5.28457761e-02f, -1.71211824e-01f, -1.04649991e-01f,
  -1.66259538e-02f, 1.82983518e-01f, 4.41388525e-02f, 6.10449836e-02f, 8.94588325e-03f, 4.74501625e-02f, -4.53796349e-02f, 1.76846124e-02f, -9.30469260e-02f, -1.14618883e-01f,
  -3.33178490e-02f, -8.11831504e-02f, -7.83650354e-02f, -7.99058899e-02f, 1.06565364e-01f, -5.68075851e-02f, -6.38102815e-02f, -6.46340773e-02f, -7.05591664e-02f, -7.14732185e-02f,
  -2.90205628e-01f, -5.16217887e-01f, 4.47188646e-01f, 3.30244154e-02f, 4.07171935e-01f, 2.82718927e-01f, 1.66906998e-01f, 1.24496683e-01f, 8.95395055e-02f, -2.90160961e-02f,
  -2.62671649e-01f, -3.48005891e-01f, -3.34626466e-01f, -2.52156943e-01f, -1.31896034e-01f, 1.37097687e-01f, 4.01105911e-01f, 2.22968996e-01f, 1.72438353e-01f, 2.42603887e-02f,
  -6.08554743e-02f, 4.65299897e-02f, -8.81464332e-02f, 3.46939638e-02f, -3.45386118e-02f, -6.74114039e-04f, 1.68472350e-01f, 1.19684264e-01f, 6.60574362e-02f, 3.15684229e-02f,
  -2.83190489e-01f, -3.54024202e-01f, 1.23747103e-01f, -1.72142133e-01f, -2.93112993e-02f, -1.20672926e-01f, -2.31035091e-02f, 3.61666717e-02f, -1.83815211e-01f, 5.70786633e-02f,
  3.36460657e-02f, -1.80767491e-01f, -5.73394485e-02f, -6.06165603e-02f, 4.80632335e-02f, -6.48474321e-02f, 7.93534070e-02f, -9.49753001e-02f, -1.33371338e-01f, -1.20632567e-01f,
  -1.82981029e-01f, 2.02067539e-01f, 2.37619951e-01f, 1.12395085e-01f, 3.68525572e-02f, 1.54912531e-01f, 3.68842185e-02f, -9.65906233e-02f, 1.63694713e-02f, -1.13124087e-01f,
  -2.47843377e-03f, 6.94084987e-02f, 4.36277986e-02f, 1.64983477e-02f, -3.56485695e-02f, 3.69667262e-02f, -3.02146096e-02f, -3.63814943e-02f, 2.45170221e-02f, 7.56763341e-03f,
  1.89970918e-02f, 3.33525386e-04f, -8.64384249e-02f, -6.32062703e-02f, -7.95840546e-02f, 7.94528574e-02f, 3.30796801e-02f, -1.68086067e-01f, -2.66526663e-03f, -3.92956994e-02f,
  -9.88368038e-03f, 7.73597360e-02f, 5.54044694e-02f, -7.00579137e-02f, 2.46812049e-02f, 7.14161545e-02f, 1.04079572e-02f, -7.65196010e-02f, 1.91138629e-02f, 1.08310103e-01f,
  -3.25739413e-01f, -1.68555174e-02f, -1.12804279e-01f, -1.68108195e-01f, -1.86855569e-01f, -8.48196894e-02f, -8.53429958e-02f, -5.59704863e-02f, 3.39259803e-02f, -1.37441173e-01f,
  -4.80447710e-02f, -7.11200535e-02f, -9.02744308e-02f, 6.55331165e-02f, 1.83046713e-01f, 8.29164311e-02f, -1.12991333e-01f, 4.93618287e-02f, -4.71916087e-02f, -7.89710507e-02f,
  7.23026618e-02f, 1.19917519e-01f, 8.83452073e-02f, 3.60447243e-02f, 5.04831150e-02f, 5.53504787e-02f, 1.91918369e-02f, 2.86265556e-02f, 1.06570631e-01f, -1.04509257e-01f,
  1.87679753e-01f, -7.99474567e-02f, -2.11838558e-01f, -7.52070546e-02f, -2.15289637e-01f, -1.91343814e-01f, -2.74919569e-01f, -1.40531823e-01f, -1.69184506e-02f, -1.24839179e-01f,
  -7.08717555e-02f, -2.10193340e-02f, 2.23992597e-02f, -1.01230949e-01f, -1.39563322e-01f, -1.98720425e-01f, -2.01806307e-01f, -1.75466016e-01f, -2.87561148e-01f, -3.25137109e-01f,
  -2.24504918e-01f, -1.90676227e-01f, -1.50367647e-01f, -1.09842658e-01f, -1.80850513e-02f, -1.59978289e-02f, -4.37064879e-02f, -1.22191489e-01f, -1.22055374e-01f, -5.91303781e-03f,
  -6.08153827e-02f, 7.89550543e-02f, -8.25927928e-02f, 1.69994254e-02f, -9.87194129e-04f, 1.97922494e-02f, -2.24192180e-02f, 2.03434173e-02f, 6.40702918e-02f, -1.09076570e-03f,
  1.51922973e-02f, -4.13160585e-02f, 4.55312245e-02f, -2.88964212e-02f, -6.61228746e-02f, -8.48604143e-02f, -1.14309102e-01f, -8.17510486e-02f, -3.89096588e-02f, -1.17163002e-01f,
  -9.21050683e-02f, -2.13073995e-02f, 6.71018064e-02f, -4.84091528e-02f, -2.02266090e-02f, -6.59813080e-03f, -5.21088466e-02f, -1.14984848e-02f, 2.15169284e-02f, 8.77896398e-02f,
  1.80089884e-02f, 7.52060190e-02f, -5.78373447e-02f, -8.42762887e-02f, -4.58612889e-02f, 3.37225981e-02f, 4.03193608e-02f, -5.56992134e-03f, 4.76825759e-02f, -3.89031805e-02f,
  -9.96285900e-02f, -5.63149080e-02f, -2.69625988e-03f, 1.64997820e-02f, -7.28381472e-03f, -2.17151213e-02f, 5.23968115e-02f, -8.63124058e-03f, 5.54451272e-02f, 1.38004096e-02f,
  -2.67595854e-02f, 8.09011981e-03f, 5.10357805e-02f, 2.23678127e-02f, 6.25069439e-03f, -1.66873895e-02f, -4.12938790e-03f, -1.89954545e-02f, -7.72519335e-02f, -8.42166543e-02f,
  3.87772173e-02f, -1.50630008e-02f, 8.62680897e-02f, -3.14073935e-02f, 1.47283729e-02f, 3.12624127e-03f, 2.38396283e-02f, -4.61896881e-03f, 8.76018405e-02f, -4.96464781e-02f,
  -8.07831511e-02f, -2.67577097e-02f, 3.85518521e-02f, -2.09540576e-02f, -1.08824186e-01f, -6.32851869e-02f, -1.05624959e-01f, -5.07002696e-02f, -4.28526476e-02f, -8.47701803e-02f,
  -9.91837680e-02f, 2.10575536e-02f, 1.31853387e-01f, 5.66334575e-02f, 3.13968956e-02f, 7.24673495e-02f, 1.96477156e-02f, -6.05238974e-03f, 1.06902145e-01f, 8.20252225e-02f,
  2.37482756e-01f, -2.38914043e-01f, -1.27212167e-01f, -1.11100338e-02f, 5.11810072e-02f, 6.84400350e-02f, 8.57076496e-02f, 9.81613770e-02f, 8.63544121e-02f, -9.75548010e-03f,
  -3.01756095e-02f, 1.08451182e-02f, 2.47167908e-02f, 1.56236999e-02f, 5.11200055e-02f, -4.20144722e-02f, -7.66455382e-03f, 8.58522505e-02f, 1.26333565e-01f, 2.00172797e-01f,
  9.00461003e-02f, -1.27825863e-03f, 1.21342927e-01f, 1.17898673e-01f, 1.50159942e-02f, 8.06379020e-02f, 1.63707770e-02f, -3.28339301e-02f, 5.26826978e-02f, -2.41633505e-02f,
  -1.21977545e-01f, 1.21859265e-02f, 9.53522176e-02f, 4.84203622e-02f, -9.03593842e-03f, 3.78266945e-02f, -3.45681570e-02f, -5.06110117e-02f, -8.22211429e-02f, -1.13599069e-01f,
  -5.74414693e-02f, 2.88821124e-02f, 7.70440185e-03f, 1.69700254e-02f, 4.42010118e-03f, 1.84198506e-02f, -5.97025827e-02f, -7.86593258e-02f, -4.46532704e-02f, -1.80781465e-02f,
  -2.84919403e-02f, -2.65686922e-02f, -3.32142524e-02f, -8.97644926e-03f, -6.05349019e-02f, 1.25166520e-01f, 3.70564498e-02f, -2.52736211e-02f, 4.04936410e-02f, -1.13146178e-01f,
  5.89933209e-02f, 2.82193758e-02f, -2.74296524e-03f, -6.43163100e-02f, -4.32577580e-02f, -2.09540781e-02f, -2.54134294e-02f, 3.47898342e-02f, 4.95043360e-02f, -1.86822545e-02f,
  -7.46885836e-02f, 1.12698987e-01f, 1.50109291e-01f, 8.30890685e-02f, 7.50287399e-02f, 1.27738027e-03f, 7.61058554e-02f, 4.90146764e-02f, 9.83235016e-02f, 5.85622974e-02f,
  9.87206995e-02f, 1.06275894e-01f, 9.68899950e-02f, 3.99591215e-02f, 3.41226459e-02f, 3.30635607e-02f, 1.47294417e-01f, 2.64255386e-02f, 5.99045828e-02f, 1.53477073e-01f,
  -1.52192652e-01f, 8.14677551e-02f, -2.20892802e-02f, -9.07359198e-02f, -9.35338214e-02f, -7.05799684e-02f, 2.49213204e-02f, -1.28211975e-02f, -2.82338988e-02f, -1.98847000e-02f,
  -3.88273923e-03f, -8.15036967e-02f, -6.22721277e-02f, -6.82913437e-02f, 5.51414639e-02f, 4.71752807e-02f, -1.14938598e-02f, -9.05949473e-02f, -2.07242612e-02f, -1.82603709e-02f,
  -3.03572882e-02f, 5.17371446e-02f, 7.49155581e-02f, 3.83514650e-02f, -1.35942381e-02f, 1.11030526e-01f, 3.16076390e-02f, -5.27202711e-03f, 1.13663092e-01f, -3.83065268e-02f,
  4.28088307e-01f, -9.03578773e-02f, -4.80545498e-02f, 3.65922213e-01f, 1.53866902e-01f, -1.18009768e-01f, -1.74772471e-01f, 1.85540274e-01f, 2.01758265e-01f, -7.49377608e-02f,
  -3.68872762e-01f, -3.30564916e-01f, -1.72929600e-01f, -2.87022322e-01f, -2.95923144e-01f, -1.27576768e-01f, -2.11556330e-02f, -1.82040513e-01f, -2.36383125e-01f, -3.84014338e-01f,
  -2.99525768e-01f, 1.36092186e-01f, 8.53670239e-02f, 7.92136975e-03f, 9.24284607e-02f, -9.86724272e-02f, 1.73149616e-01f, 5.50912358e-02f, -2.46884003e-01f, -1.90167427e-02f,
  -1.83997333e-01f, 4.30199206e-01f, -1.60251170e-01f, -1.27060995e-01f, -7.16659473e-03f, -1.57844424e-01f, -1.49309218e-01f, 1.65648401e-01f, -7.93159083e-02f, 5.56858163e-03f,
  -1.28424555e-01f, -1.12849601e-01f, 2.55445149e-02f, -1.12693258e-01f, 2.92247012e-02f, -2.08190177e-02f, 1.93801716e-01f, -3.27099338e-02f, 3.65410112e-02f, -6.04333989e-02f,
  -2.93857008e-01f, -9.70699117e-02f, 9.92554799e-02f, 5.76408347e-03f, 1.74379330e-02f, -8.67918581e-02f, 9.13905278e-02f, 3.39382957e-03f, -5.07721305e-03f, 1.32454142e-01f,
  -1.49087653e-01f, -1.22694790e-01f, -2.02638600e-02f, -4.86606034e-03f, 3.05498857e-02f, -2.52976231e-02f, 2.65714852e-03f, -4.31057513e-02f, -4.50369120e-02f, -5.16252816e-02f,
  -3.85557301e-02f, 6.31919056e-02f, 4.88346145e-02f, 1.41686171e-01f, -8.22304040e-02f, 5.31011224e-02f, 6.66550733e-03f, -3.28359678e-02f, 7.42283687e-02f, 8.43262374e-02f,
  -2.68242694e-02f, -5.73881119e-02f, 1.24684066e-01f, 2.41475441e-02f, 4.51215683e-03f, 1.42632052e-02f, -3.42764854e-02f, -1.27039757e-02f, -2.76959239e-04f, 4.75183986e-02f,
  4.24262211e-02f, -1.54817119e-01f, 5.80180585e-02f, -7.44488761e-02f, 4.75268811e-02f, -8.73200595e-02f, -4.29379083e-02f, -2.25927841e-04f, 9.92462691e-03f, -1.65889636e-01f,
  -1.25570178e-01f, -1.84564367e-01f, 8.45834687e-02f, -9.41120908e-02f, -1.95925813e-02f, -1.45553481e-02f, -1.42670900e-01f, 1.41251860e-02f, 4.80073951e-02f, -3.38479318e-02f,
  2.87208427e-02f, -7.10101649e-02f, 3.15027423e-02f, 1.52917325e-01f, 1.01182565e-01f, -8.84746481e-03f, 6.46973252e-02f, -3.52461562e-02f, 2.92964187e-02f, 1.22591667e-01f,
  3.63678575e-01f, 3.42333853e-01f, -1.66969359e-01f, 1.41511485e-01f, -3.32337990e-02f, -1.70302466e-01f, 2.75644520e-03f, 2.14625057e-03f, 1.04464084e-01f, 1.37797475e-01f,
  1.23957045e-01f, 9.59540680e-02f, 1.95918411e-01f, -1.52913511e-01f, -2.18225643e-01f, 6.54138476e-02f, 5.41621968e-02f, -2.03287691e-01f, -4.26525652e-01f, -2.62067765e-01f,
  7.86362514e-02f, 1.18715905e-01f, 4.08026315e-02f, -3.33120599e-02f, 2.16122344e-01f, -5.13244011e-02f, 2.11911902e-01f, 1.14794686e-01f, 1.82866994e-02f, 1.67644873e-01f,
  -6.20122105e-02f, 1.54538125e-01f, -4.40455794e-01f, 1.94213353e-02f, -5.04554715e-03f, 5.80093116e-02f, -3.38074304e-02f, 1.51902169e-01f, 9.26441699e-02f, 7.22264498e-02f,
  1.61848634e-01f, 3.45735960e-02f, 1.92337722e-01f, 1.09320566e-01f, 1.56353995e-01f, -7.01806769e-02f, 8.77138674e-02f, -8.69235471e-02f, -1.44980535e-01f, -8.15542564e-02f,
  7.91991428e-02f, 7.87519664e-02f, -5.72126079e-03f, -1.36770964e-01f, -1.78059250e-01f, -2.07351282e-01f, -1.06523417e-01f, -1.73024938e-01f, -2.12876588e-01f, 1.43493444e-01f,
  -7.76830167e-02f, -7.78176030e-03f, 3.20229232e-02f, 1.21314429e-01f, 2.66494211e-02f, 6.42348751e-02f, 1.15208827e-01f, -1.37578860e-01f, -1.38938308e-01f, 1.99098177e-02f,
  -6.36272207e-02f, -2.15974644e-01f, -7.40779638e-02f, -4.73795552e-03f, 2.10952256e-02f, 5.66665223e-03f, -1.74921080e-01f, -8.00355598e-02f, -1.28540481e-02f, 2.65349597e-02f,
  2.46758740e-02f, -1.75050527e-01f, 1.87053755e-02f, -5.92036322e-02f, -3.68131772e-02f, -1.13922521e-01f, -1.21227190e-01f, -8.60320255e-02f, -2.29008347e-02f, 2.21069947e-01f,
  7.66081885e-02f, -1.95716873e-01f, -6.12048469e-02f, -1.12126902e-01f, -8.12446102e-02f, -9.55518559e-02f, -1.41339079e-02f, -2.29384571e-01f, 5.02777509e-02f, -1.61810648e-02f,
  3.47915525e-03f, -1.53350785e-01f, 2.03874722e-01f, -3.31064910e-02f, -5.68645149e-02f, -7.94674829e-02f, -9.15061682e-02f, -1.30847067e-01f, -1.49987429e-01f, -5.11974879e-02f,
  -3.39480788e-02f, -1.22541808e-01f, -1.15948334e-01f, -1.15901984e-01f, -4.57021222e-02f, -4.76777926e-02f, -9.07539725e-02f, -1.25691190e-01f, -2.67782032e-01f, 2.59892810e-02f,
  -2.50042111e-01f, -1.01435080e-01f, -1.47653911e-02f, -1.79565325e-01f, -1.04533613e-01f, -1.31406009e-01f, -2.94615567e-01f, -7.89638534e-02f, 4.91232984e-02f, -6.18949048e-02f,
  -7.73391500e-02f, -2.47520022e-02f, -5.22812866e-02f, -4.90688384e-02f, -1.47720098e-01f, -1.17574066e-01f, -5.21380752e-02f, -8.99090096e-02f, -7.60641769e-02f, -3.93154807e-02f,
  -9.71034244e-02f, -7.45360777e-02f, -2.52527017e-02f, 6.00297190e-02f, 1.15446851e-01f, 2.23734025e-02f, 6.69522658e-02f, 2.52594259e-02f, 3.34117301e-02f, 1.56559989e-01f,
  -7.08951280e-02f, 7.84837827e-02f, 1.29075600e-02f, 1.48256589e-02f, 8.32038466e-03f, 1.21519994e-02f, -5.28530478e-02f, -5.06914314e-03f, -1.87927447e-02f, -4.73980792e-04f,
  -7.59170055e-02f, 6.78863674e-02f, -2.64448971e-02f, -3.55248079e-02f, -1.68811344e-02f, -3.46565060e-02f, -2.50363685e-02f, -4.08263877e-02f, -4.16514166e-02f, 6.28953427e-02f,
  -5.83785065e-02f, -6.37904629e-02f, -9.24287364e-02f, 8.49524420e-03f, 5.34546971e-02f, -3.99406813e-02f, 2.36672796e-02f, 1.28334478e-01f, 2.75929142e-02f, -3.35788401e-03f,
  5.63451461e-02f, 3.44058871e-02f, -7.78015628e-02f, -1.35931820e-02f, -5.43768667e-02f, 4.75084549e-03f, 3.42850573e-02f, -5.25427498e-02f, 4.99293720e-03f, -3.76584344e-02f,
  1.93251837e-02f, 3.06711588e-02f, -1.00274924e-02f, 8.83217007e-02f, 4.49493080e-02f, -7.71488026e-02f, -3.35491560e-02f, 9.89640970e-03f, 3.84733379e-02f, 3.38899009e-02f,
  -3.14188600e-02f, -4.47486788e-02f, 3.33121158e-02f, -2.34461296e-02f, 2.15721801e-02f, 6.15371913e-02f, 2.95033772e-02f, -1.07333176e-02f, -2.04941705e-02f, 1.26817850e-02f,
  -1.33056015e-01f, 1.15622617e-02f, -6.63488582e-02f, -3.89746204e-02f, -4.67442907e-02f, 1.07480034e-01f, 1.34889614e-02f, -2.18086913e-02f, 1.24841221e-02f, -3.50627787e-02f,
  -3.79822999e-02f, 3.06181591e-02f, -1.78810898e-02f, -5.10537997e-02f, -7.74776712e-02f, -2.75784060e-02f, -1.60021380e-01f, -1.73058838e-01f, -6.80156201e-02f, 5.01226808e-04f,
  -1.24483898e-01f, -2.54341990e-01f, -3.83119792e-01f, -2.49187842e-01f, -1.06943637e-01f, -2.48777330e-01f, -1.70556605e-01f, -1.06664877e-02f, -2.27309167e-01f, -3.26050252e-01f,
  -4.68170017e-01f, 2.96589822e-01f, -3.21562111e-01f, -2.08096936e-01f, -1.04837283e-01f, -1.32871687e-01f, 1.15735538e-01f, 1.11582585e-01f, 9.56728980e-02f, 2.55512953e-01f,
  1.37251034e-01f, -1.52006730e-01f, -1.93352103e-01f, -2.15675533e-01f, -2.93304533e-01f, 1.50402151e-02f, -1.56894565e-01f, -4.00168747e-01f, -4.95210171e-01f, -1.16801381e-01f,
  -6.42655194e-02f, -2.56763458e-01f, -3.11646879e-01f, -2.44320139e-01f, 2.62114733e-01f, -1.35488883e-01f, -1.02565363e-01f, -3.11113000e-01f, -2.53788829e-01f, -1.62897319e-01f,
  -1.03350019e-03f, -3.21219444e-01f, -7.06230700e-02f, -6.82041934e-03f, 4.32742871e-02f, 9.51250494e-02f, 4.02928852e-02f, -2.05201581e-02f, 5.63514344e-02f, 1.69174120e-01f,
  -5.19198999e-02f, 6.72650710e-02f, -4.06769402e-02f, 8.77886787e-02f, -5.64720482e-02f, 6.20486811e-02f, 7.27841705e-02f, -5.68397827e-02f, 1.13537744e-01f, 1.85879201e-01f,
  1.89716950e-01f, -4.44879495e-02f, -1.68124214e-02f, 1.02010228e-01f, 1.05132446e-01f, -1.89060628e-01f, 7.51772076e-02f, -1.72195735e-03f, -8.46606120e-02f, 1.19442426e-01f,
  -8.51147715e-03f, 1.19014144e-01f, -2.18157861e-02f, -8.26755390e-02f, -6.32207748e-03f, 2.11729272e-03f, 3.13604884e-02f, 1.11573778e-01f, -4.57919128e-02f, 7.63403252e-02f,
  8.65273252e-02f, 2.59944424e-03f, 3.50116822e-03f, -7.82864913e-02f, -8.53626896e-03f, 9.55197588e-03f, -9.58220474e-03f, 7.52072185e-02f, 6.70000836e-02f, -8.68183281e-03f,
  3.32382768e-02f, 1.31365314e-01f, -1.87657364e-02f, 2.21353360e-02f, 1.07848570e-01f, -2.28798352e-02f, -5.95876807e-03f, -8.30165073e-02f, -8.86429381e-03f, 4.94877761e-03f,
  8.81185085e-02f, -4.37078893e-01f, 8.37362483e-02f, 7.84116238e-03f, -8.26431960e-02f, 1.70156315e-01f, 5.66047467e-02f, -2.13065408e-02f, -4.42251600e-02f, -2.44345795e-02f,
  8.00458565e-02f, 9.97193065e-03f, 4.67558671e-03f, 1.19125716e-01f, -2.93777157e-02f, -3.57240140e-02f, 6.90396726e-02f, 4.88106757e-02f, -2.86317337e-02f, 2.82567501e-01f,
  2.52060294e-01f, 7.81708807e-02f, 8.15398321e-02f, 6.44823313e-02f, 6.35555983e-02f, -1.78019390e-01f, 7.33509585e-02f, 2.83854026e-02f, -8.31567347e-02f, 2.26971313e-01f,
  -2.95024484e-01f, -1.28647611e-01f, -1.23364434e-01f, 6.98680356e-02f, 1.79011047e-01f, 7.45918453e-02f, -1.54474014e-02f, -4.79398109e-02f, 1.76824201e-02f, -6.42338917e-02f,
  3.86804179e-03f, 1.12902239e-01f, 1.28733248e-01f, 1.11886643e-01f, 6.19118772e-02f, 3.02369036e-02f, 1.61386669e-01f, 6.95577785e-02f, 5.65420128e-02f, 6.29659742e-02f,
  1.61582708e-01f, 9.13946610e-03f, -1.08618960e-01f, 2.59247851e-02f, 7.74566680e-02f, 1.20680749e-01f, -1.79684944e-02f, 7.82620162e-02f, 7.87834004e-02f, 1.64146975e-01f,
  -1.98632032e-01f, -2.39320010e-01f, 5.14256842e-02f, 4.17182632e-02f, 4.20902930e-02f, -8.11283216e-02f, -1.15135342e-01f, -5.28239496e-02f, -1.80727628e-03f, -6.69456199e-02f,
  9.27462708e-03f, -4.54821549e-02f, 5.42059094e-02f, -1.18658189e-02f, -8.78048167e-02f, -7.96444938e-02f, -1.62440985e-02f, -7.39678368e-02f, -7.18552992e-02f, -9.48157310e-02f,
  1.78414837e-01f, 1.04902107e-02f, -1.04687966e-01f, -7.90160447e-02f, -1.12721406e-01f, 2.53255349e-02f, -1.06769122e-01f, -1.02348246e-01f, -1.64278612e-01f, -1.16038576e-01f,
  2.08912464e-03f, -3.22181098e-02f, -2.05271617e-02f, -7.40085542e-02f, 8.06563720e-02f, 1.10061429e-02f, 6.82816803e-02f, 5.55542298e-02f, 5.03581949e-03f, -5.97319007e-02f,
  -1.20212184e-02f, -3.61680239e-02f, -3.97658125e-02f, -8.81576613e-02f, 2.42625661e-02f, -1.18884500e-02f, -4.99167727e-05f, -4.52351868e-02f, -2.50342246e-02f, -6.71768412e-02f,
  -6.40869215e-02f, 2.31949594e-02f, -2.35846061e-02f, 4.11676243e-02f, -3.81978340e-02f, -6.08992167e-02f, -5.80091029e-02f, -3.54732387e-02f, -2.12030225e-02f, -8.49322528e-02f,
  -2.04829037e-01f, -1.23458030e-02f, -7.25209862e-02f, 1.88287776e-02f, 5.35114482e-02f, 2.91051324e-02f, -5.22952527e-02f, 5.68146259e-02f, 1.56987365e-02f, -9.55192838e-03f,
  -1.61662251e-01f, -2.17002910e-02f, -4.29711379e-02f, -1.04386555e-02f, -4.23505940e-02f, -7.79410228e-02f, 6.50245920e-02f, 6.20715320e-02f, -2.69874074e-02f, -1.66093837e-02f,
  6.55573383e-02f, -5.66949286e-02f, -9.50389877e-02f, -3.81610058e-02f, -4.43301052e-02f, -2.35082302e-02f, -1.08440302e-01f, -1.20065391e-01f, -1.95568994e-01f, -1.74227595e-01f,
  2.92385995e-01f, -1.08073547e-01f, -4.82010059e-02f, -8.58642831e-02f, -2.64157087e-01f, -2.10933372e-01f, -2.38182127e-01f, -2.27825537e-01f, -7.94729963e-02f, -3.45019363e-02f,
  -8.54999050e-02f, 1.28313422e-01f, -9.39325150e-03f, 8.54324177e-02f, 1.06286481e-01f, -7.29628056e-02f, -7.63153955e-02f, 1.03971839e-01f, 4.99141999e-02f, 7.21218660e-02f,
  2.01124679e-02f, 5.58760203e-02f, 2.10568339e-01f, 1.73658386e-01f, 4.37624119e-02f, 1.37843877e-01f, 2.29977071e-02f, 1.31835453e-02f, -6.84988201e-02f, 5.53892739e-02f,
  1.24464594e-01f, -6.90083392e-03f, 8.36118236e-02f, 9.38584805e-02f, 5.39426133e-03f, 7.08323112e-03f, 5.87946400e-02f, 6.00724146e-02f, -6.81082997e-03f, -1.03614450e-01f,
  4.27135313e-03f, -4.86448780e-02f, 1.19771613e-02f, 3.96947823e-02f, -9.82936025e-02f, 7.63710914e-03f, -5.10039218e-02f, 7.70446509e-02f, -3.10656708e-02f, 2.95097120e-02f,
  -1.89490858e-02f, -3.95731218e-02f, -2.11884320e-01f, -1.65221915e-01f, 2.95401029e-02f, 2.00228784e-02f, 1.21272188e-02f, -8.90136808e-02f, -3.02129202e-02f, 7.20830227e-04f,
  -9.13494825e-02f, -1.24428883e-01f, -2.94239074e-02f, 3.24266925e-02f, 1.42266834e-02f, 2.54316684e-02f, -2.54715942e-02f, -1.50615759e-02f, 5.51762767e-02f, -5.41178789e-03f,
  3.04733757e-02f, -5.95889054e-02f, 3.73055898e-02f, 4.80324738e-02f, 6.71852827e-02f, -9.73900929e-02f, 1.31249707e-02f, 5.08125387e-02f, 3.28423232e-02f, -9.48317815e-03f,
  8.82915705e-02f, -8.85543972e-02f, -6.19066618e-02f, -5.35993390e-02f, -4.33699563e-02f, -1.22995526e-02f, -7.74490386e-02f, -2.93600727e-02f, -1.04652800e-01f, -9.76764187e-02f,
  -5.92096150e-02f, 9.66058671e-02f, 2.18814343e-01f, 1.44250661e-01f, 7.96955749e-02f, -1.04340818e-02f, 1.54422909e-01f, 1.52173832e-01f, 4.10961583e-02f, -4.58293334e-02f,
  1.50357396e-03f, 5.94751686e-02f, 2.51010749e-02f, 7.15256929e-02f, 4.79792058e-02f, 1.10521972e-01f, 1.78809002e-01f, 5.73245026e-02f, -8.86791870e-02f, -8.10290650e-02f,
  -8.71451646e-02f, -1.58053726e-01f, -8.95556211e-02f, -1.00984626e-01f, -4.74217981e-02f, 7.32296258e-02f, -9.34991520e-03f, -8.88312235e-02f, -5.79840392e-02f, 1.21110808e-02f,
  9.97495949e-02f, 1.41984358e-01f, -1.74610555e-01f, 6.61271513e-02f, -1.88458443e-01f, -2.95692950e-01f, -1.51297882e-01f, -5.04145063e-02f, -3.52655984e-02f, 8.33607931e-03f,
  -3.87186743e-02f, 7.57194310e-02f, 1.62525862e-01f, 5.45564219e-02f, 2.28278805e-02f, -2.64589153e-02f, -6.38521463e-02f, -1.27675489e-01f, -1.95327878e-01f, -2.10102230e-01f,
  -7.65563846e-02f, -2.80493647e-02f, 1.96153224e-02f, -6.52871355e-02f, -3.72863673e-02f, -6.84225839e-03f, -5.44900000e-02f, -5.59416823e-02f, -1.45828143e-01f, -1.16688095e-01f,
  4.20866497e-02f, -1.94972634e-01f, -6.69929981e-02f, -4.61501861e-03f, 1.17342398e-02f, 1.11730685e-02f, -7.93647468e-02f, -9.46266279e-02f, 2.95928656e-03f, -2.07118050e-04f,
  -5.91636784e-02f, -8.89384598e-02f, -5.42645529e-02f, 1.22132003e-02f, -5.13538048e-02f, -9.81420949e-02f, 4.11946811e-02f, -6.85196295e-02f, 3.34557518e-02f, -9.07233357e-02f,
  -6.12056218e-02f, -2.02692568e-01f, -9.27578285e-02f, -4.37793620e-02f, -1.50354743e-01f, -8.44776034e-02f, -1.26956061e-01f, -1.52025461e-01f, -1.05363518e-01f, 7.24270716e-02f,
  -2.57014036e-02f, 6.55418783e-02f, -6.54137284e-02f, -2.75297128e-02f, -8.69693421e-03f, -3.69074754e-02f, 1.89137068e-02f, -5.78429969e-03f, -2.83942316e-02f, 9.67747122e-02f,
  -2.00211853e-02f, 1.50429551e-02f, -3.65185272e-03f, -8.02004803e-03f, 1.15315849e-02f, -3.80794369e-02f, 2.07403582e-02f, 8.90860707e-02f, -2.47957259e-02f, -5.73632680e-02f,
  -6.15768023e-02f, -7.83175230e-02f, -3.05827539e-02f, 8.66559371e-02f, -1.23274304e-01f, -3.25178988e-02f, 2.06364542e-02f, -6.09305538e-02f, 3.32579650e-02f, -3.75064574e-02f,
  2.97585756e-01f, 2.06517763e-02f, 1.86473027e-01f, -3.98814529e-02f, -3.28368284e-02f, -7.41530359e-02f, -1.24874106e-02f, -5.24749830e-02f, 1.96144008e-03f, -3.72983851e-02f,
  -1.03346393e-01f, 3.14040110e-02f, 3.46781909e-02f, -2.46759225e-02f, -8.79602358e-02f, -1.12653404e-01f, 5.50737716e-02f, -2.64573358e-02f, -4.90491316e-02f, 6.60826871e-03f,
  9.18800607e-02f, -5.85229322e-02f, 1.96504503e-01f, 1.27798527e-01f, 1.46671906e-02f, 4.32382487e-02f, 1.46399543e-01f, 1.00196943e-01f, 2.83727422e-02f, 3.08835775e-01f,
  -4.05823648e-01f, 1.87840104e-01f, -3.79144371e-01f, -2.67587453e-01f, -1.53151333e-01f, 4.44923453e-02f, 3.82825494e-01f, 2.31490210e-01f, -5.96623681e-02f, 1.29415050e-01f,
  -3.42558809e-02f, -2.88413823e-01f, -3.16408306e-01f, -9.30537879e-02f, 2.39314549e-02f, 1.82998180e-01f, -1.40795395e-01f, -2.21553221e-01f, -1.58876449e-01f, 1.98004961e-01f,
  1.80701271e-01f, -1.52271003e-01f, -2.09890679e-01f, -1.36326954e-01f, -1.61563173e-01f, -2.91963130e-01f, -2.37808868e-01f, -2.32133940e-01f, -1.75154265e-02f, -2.28208050e-01f,
  -2.26197038e-02f, -2.27748528e-01f, 1.50958113e-02f, -1.29520833e-01f, -9.29906219e-02f, -2.48073954e-02f, 7.52430782e-02f, -1.85044631e-01f, -8.40067416e-02f, -3.44690681e-02f,
  -1.41387582e-01f, -2.96598370e-03f, -1.41242042e-01f, -7.00519159e-02f, -1.64562985e-01f, -2.90882085e-02f, -1.42965183e-01f, -9.87250730e-02f, -1.29000917e-01f, 7.79458731e-02f,
  8.76574218e-02f, -1.02030963e-01f, -2.04915985e-01f, 9.65912491e-02f, 2.48769987e-02f, -1.24454826e-01f, 3.95392105e-02f, 4.03781347e-02f, -9.33400765e-02f, 4.57344763e-02f,
  1.76320463e-01f, 5.27921394e-02f, -9.60785989e-03f, 6.57821149e-02f, 1.93155646e-01f, -2.63885614e-02f, -8.44911486e-02f, 2.62227748e-02f, -4.99775149e-02f, -3.06064263e-02f,
  1.19226113e-01f, 1.81100219e-01f, -2.29180744e-03f, -1.13928439e-02f, -1.44801848e-02f, -7.80050606e-02f, -1.04690734e-02f, 7.04943687e-02f, 4.32874169e-03f, 4.72746883e-03f,
  -3.80770862e-02f, -2.43619308e-02f, -1.54687569e-01f, 1.08715020e-01f, 3.58080119e-02f, 2.91173835e-03f, -2.84650046e-02f, -2.01872666e-03f, 1.61787644e-02f, -5.07659577e-02f,
  8.98676371e-05f, -3.24266441e-02f, -1.04382103e-02f, -8.91393702e-03f, -5.46416454e-02f, -7.15528009e-03f, -1.49937151e-02f, 1.31157875e-01f, -6.72307089e-02f, 1.16518974e-01f,
  9.01296288e-02f, 1.18943237e-01f, -1.62670419e-01f, -3.12512275e-03f, -4.87393923e-02f, 2.50771064e-02f, 2.23779052e-01f, -9.59163457e-02f, 6.75984621e-02f, 4.55241203e-02f,
  1.15550041e-01f, 1.08234040e-01f, 2.54550241e-02f, 1.01458713e-01f, 9.37981680e-02f, -9.85590145e-02f, 4.30970974e-02f, 1.01393871e-01f, 3.13832872e-02f, 3.51460367e-01f,
  2.59875834e-01f, -4.79769707e-01f, 4.40580733e-02f, 1.66692048e-01f, 3.11249107e-01f, 4.20626372e-01f, 2.49985695e-01f, 1.85297966e-01f, 1.50086746e-01f, -3.13544311e-02f,
  -2.71252960e-01f, -1.68983936e-01f, -2.18582526e-01f, -1.58347294e-01f, -1.03161801e-02f, 4.12985012e-02f, 1.53809533e-01f, 4.76128049e-02f, 3.19635004e-01f, 3.36566746e-01f,
  7.06576183e-02f, -4.31722477e-02f, -8.37840587e-02f, -8.98577943e-02f, -2.74803817e-01f, -1.64672211e-01f, -2.61889309e-01f, -1.86335191e-01f, -9.16409343e-02f, -2.55547673e-01f,
  -2.93237448e-01f, -1.76358506e-01f, 4.86832075e-02f, -1.97755203e-01f, -2.23214820e-01f, -1.14100099e-01f, -3.56510375e-03f, -1.75419107e-01f, -7.00192004e-02f, 8.18853006e-02f,
  -4.98074926e-02f, 3.21239941e-02f, -1.53866157e-01f, -6.66278228e-02f, -1.95895061e-02f, -1.00107267e-01f, -1.88670620e-01f, -1.94691941e-01f, -1.22257695e-01f, -4.61815298e-02f,
  -2.04844788e-01f, 1.19674787e-01f, 3.37996185e-02f, -4.41096574e-02f, -3.38072181e-02f, 3.40225697e-02f, -4.91315946e-02f, 3.53268795e-02f, -6.50034798e-03f, -1.07474715e-01f,
  -1.34733975e-01f, -2.97085494e-02f, -3.47472429e-02f, 4.98882830e-02f, 4.84069362e-02f, 1.18180707e-01f, -7.20880702e-02f, -2.77100578e-02f, 1.38583882e-02f, -7.40245059e-02f,
  -5.20049687e-03f, -1.00146718e-02f, -2.43500024e-02f, -1.53573141e-01f, -6.92890361e-02f, -1.23118930e-01f, -3.25346291e-02f, -7.04626366e-02f, -8.15498829e-02f, -4.31860015e-02f,
  -8.71474016e-03f, -5.77432439e-02f, -9.18466598e-02f, -1.23508811e-01f, -1.53892815e-01f, -1.66002646e-01f, 2.67738141e-02f, -1.34725004e-01f, -2.07208004e-02f, -1.06343925e-01f,
  -1.22638762e-01f, 2.15553984e-01f, 3.41007821e-02f, -3.20657566e-02f, -1.06876411e-01f, -1.69615045e-01f, -1.04497604e-01f, 4.36849184e-02f, 1.71805285e-02f, 1.79875996e-02f,
  -6.44996122e-04f, -7.51743279e-03f, -9.36342105e-02f, -7.74904490e-02f, 1.04046181e-01f, 5.28314244e-03f, -1.68751836e-01f, -6.96955100e-02f, -8.09331909e-02f, -1.21469244e-01f,
  2.09348593e-02f, 9.44872051e-02f, 1.24307990e-01f, 1.68457329e-02f, 1.21521547e-01f, 2.01900333e-01f, 2.00138111e-02f, 9.26560163e-02f, 8.39693621e-02f, 1.41763031e-01f,
  -5.53734422e-01f, -1.91052914e-01f, -1.30773216e-01f, -2.64553964e-01f, -2.44723871e-01f, -1.70433402e-01f, -3.60584766e-01f, -3.65845971e-02f, -1.00305028e-01f, -2.69185722e-01f,
  -1.60504192e-01f, -7.54077639e-03f, 5.40015884e-02f, -4.10685502e-02f, -1.41364992e-01f, -4.12056595e-01f, -3.36322397e-01f, -2.89807588e-01f, -2.20900387e-01f, -1.22646101e-01f,
  -2.18612418e-01f, -2.17844531e-01f, -1.91284642e-01f, -4.26249206e-02f, 8.69067833e-02f, -4.51451689e-02f, 3.06269918e-02f, -1.52454078e-01f, -1.86116174e-01f, -1.48110151e-01f,
  9.41955149e-02f, -1.90506820e-02f, -1.00830585e-01f, -1.73512250e-02f, -7.87248239e-02f, 3.47871371e-02f, -4.34174808e-03f, 1.19250432e-01f, -5.99331148e-02f, 2.85648718e-03f,
  -7.28188604e-02f, 1.87525898e-02f, 5.10362573e-02f, 1.16760604e-01f, 4.79231328e-02f, -5.50869517e-02f, 1.07832579e-02f, -4.39288877e-02f, -6.54081181e-02f, 1.51796460e-01f,
  5.93998022e-02f, -2.47390509e-01f, -1.07212685e-01f, -3.26134451e-03f, 1.25259221e-01f, -5.16931340e-02f, 1.13597579e-01f, 9.05909091e-02f, 5.93708418e-02f, 3.68709527e-02f,
  -3.18349749e-02f, 9.83627066e-02f, 5.61605468e-02f, 5.89030609e-02f, 1.61928795e-02f, -4.72558774e-02f, -1.93534382e-02f, -2.20605712e-02f, 1.98457483e-02f, -3.00045870e-02f,
  1.74027905e-02f, -3.74214649e-02f, 3.21614072e-02f, -2.65446343e-02f, 2.66316887e-02f, -8.43532011e-02f, -1.75710529e-01f, -9.43452772e-03f, -2.41163336e-02f, -5.79593666e-02f,
  -8.24493170e-02f, 4.76566143e-02f, -1.17283659e-02f, -3.25036906e-02f, -8.53413120e-02f, 1.93536077e-02f, 1.12495227e-02f, 1.13267571e-01f, 7.60676805e-03f, 6.12886716e-03f,
  1.87192738e-01f, -1.44856945e-01f, -4.44635227e-02f, 1.92499124e-02f, -9.31736361e-03f, 1.25185937e-01f, 1.19444862e-01f, -2.92488560e-02f, 1.10120429e-02f, 1.01095557e-01f,
  1.10193826e-01f, -2.47563664e-02f, 1.98593382e-02f, 8.01772550e-02f, -2.14860477e-02f, 3.07588726e-02f, -1.55393183e-01f, -1.36411831e-01f, 6.45178482e-02f, 1.55056000e-01f,
  6.94632111e-03f, -1.32841483e-01f, -1.09068677e-01f, 1.96099449e-02f, 9.88526344e-02f, -1.27542958e-01f, 4.66184579e-02f, 8.99920464e-02f, -7.65829487e-03f, -4.97241989e-02f,
  7.64866889e-01f, 2.50170588e-01f, -1.99180901e-01f, 1.31474450e-01f, -2.65593757e-03f, -1.28038153e-01f, -5.26951440e-02f, 2.93230433e-02f, 1.30484253e-01f, 1.15464069e-01f,
  2.47782707e-01f, 3.57729077e-01f, 2.54976511e-01f, 2.19473287e-01f, 5.84785864e-02f, -5.57714794e-03f, -1.00360354e-02f, -1.03666872e-01f, 1.33989165e-02f, -2.77784634e-02f,
  2.07354669e-02f, 8.30987543e-02f, 1.26915663e-01f, 1.29909039e-01f, 1.22099169e-01f, 1.95791200e-01f, 6.29912503e-03f, -7.79041052e-02f, -1.15102706e-02f, -3.90490070e-02f,
  -3.58205646e-01f, -7.78167322e-02f, 7.10560083e-02f, -1.18971225e-02f, 1.23483036e-02f, 1.37667418e-01f, -7.21250474e-02f, 1.75607204e-02f, 7.74985701e-02f, -1.34287387e-01f,
  -3.35246809e-02f, 3.68841700e-02f, -1.47230223e-01f, 2.53626630e-02f, -1.86852232e-01f, -8.58744383e-02f, 6.83598891e-02f, 1.27641782e-01f, -1.01853848e-01f, -7.83797204e-02f,
  8.20984170e-02f, -1.23889938e-01f, -1.66127190e-01f, -3.47965471e-02f, 3.72325778e-02f, 1.23245372e-02f, 2.86383312e-02f, -8.61541852e-02f, -1.78513993e-02f, 1.72106087e-01f,
  -1.94362462e-01f, 8.32974836e-02f, -7.16301128e-02f, 6.43374249e-02f, 3.79924104e-02f, 4.18411456e-02f, -1.27473390e-02f, -4.23417613e-02f, -4.35909368e-02f, -3.44721675e-02f,
  7.21848905e-02f, 5.79616986e-03f, 3.35163549e-02f, -4.44250591e-02f, 5.23429140e-02f, -4.87758815e-02f, 1.15069039e-02f, -6.71233088e-02f, -2.29424819e-01f, -9.02401060e-02f,
  1.52811613e-02f, -7.31273890e-02f, -4.22446132e-02f, -1.10552080e-01f, -3.56514081e-02f, -1.15231931e-01f, -4.29084785e-02f, -6.73554391e-02f, 3.47307287e-02f, 1.18048094e-01f,
  -9.13789794e-02f, -2.12619364e-01f, 1.40973374e-01f, 1.31963238e-01f, -6.51469231e-02f, 5.23346625e-02f, 2.75514107e-02f, 1.72167290e-02f, -1.24014243e-01f, -1.01095162e-01f,
  -5.85053004e-02f, -3.87377888e-02f, -1.03825532e-01f, 4.39951457e-02f, -2.00655311e-02f, -7.93563500e-02f, 9.76591930e-02f, 1.76882401e-01f, -5.97421192e-02f, -1.25764921e-01f,
  -1.85455605e-02f, 9.52451825e-02f, 9.30955559e-02f, -2.70519052e-02f, 5.05624525e-02f, 7.41351694e-02f, -7.21725821e-02f, -5.76263182e-02f, -1.70332491e-01f, 9.82030258e-02f,
  4.74907160e-01f, -2.88698047e-01f, -4.27219778e-01f, 4.26936857e-02f, -4.94041555e-02f, 9.11475644e-02f, -1.06687814e-01f, 8.71850923e-02f, 2.14941248e-01f, -2.03563690e-01f,
  -1.51585072e-01f, -7.99235553e-02f, -1.16983429e-01f, -2.57711351e-01f, -1.37114748e-01f, -3.36376429e-01f, -2.06887007e-01f, -2.53949970e-01f, 6.15854412e-02f, 1.06721586e-02f,
  -1.24492906e-02f, -1.36994980e-02f, -1.10044196e-01f, -1.65889099e-01f, -7.23512173e-02f, -1.04885727e-01f, -2.38155067e-01f, -1.94393739e-01f, -2.94315696e-01f, -3.94199163e-01f,
  -5.50545096e-01f, -6.94219097e-02f, 1.37674853e-01f, -9.00596753e-02f, -3.70624252e-02f, 6.57025129e-02f, -6.46054298e-02f, 1.06491320e-01f, 4.37693112e-02f, 1.15135610e-01f,
  -7.87258148e-02f, 2.90350039e-02f, -1.04974836e-01f, 8.48837942e-03f, 2.32219882e-02f, 1.23467393e-01f, 1.35647625e-01f, 1.81223243e-01f, -5.76887429e-02f, -5.14061302e-02f,
  2.91004088e-02f, 9.41028520e-02f, 9.59096178e-02f, 1.94018379e-01f, 1.95675656e-01f, 1.74701124e-01f, 1.44743845e-02f, 1.79407328e-01f, 1.86908275e-01f, 3.26559216e-01f,
  -7.44328722e-02f, 1.71637699e-01f, 1.53080955e-01f, 2.44647726e-01f, 2.75048435e-01f, 2.24839836e-01f, 1.78987339e-01f, 1.19019449e-01f, 8.57225582e-02f, 8.71711299e-02f,
  2.25011930e-02f, 4.67819609e-02f, 5.78478388e-02f, -2.48319265e-02f, -1.26907378e-01f, -5.85661866e-02f, -1.15447463e-02f, 7.87425693e-03f, -3.83334383e-02f, -5.05335294e-02f,
  -3.72911654e-02f, -8.68933126e-02f, -1.81140587e-01f, -1.64417312e-01f, -9.31041613e-02f, 6.08900003e-02f, -1.05625421e-01f, -1.61090195e-01f, -8.47324729e-02f, -8.41547623e-02f,
  -1.20118193e-01f, -2.06565902e-01f, -6.69002607e-02f, -1.03246555e-01f, 7.25403130e-02f, 1.43621564e-02f, -6.56089410e-02f, -3.06470436e-03f, -9.72198471e-02f, -3.68663520e-02f,
  -5.07841073e-02f, -1.56332478e-01f, -2.49872860e-02f, -3.89474966e-02f, 1.04167968e-01f, 6.58380315e-02f, 1.13523558e-01f, 1.01984568e-01f, -1.01080805e-01f, -1.21563226e-01f,
  5.57234921e-02f, 2.62792289e-01f, 1.38078049e-01f, 1.79741651e-01f, 1.80754825e-01f, 6.28722906e-02f, -6.76348582e-02f, 1.77281737e-01f, 2.49966383e-02f, 1.77692890e-01f,
  -1.08183578e-01f, 1.26826048e-01f, 2.83471882e-01f, 1.36292383e-01f, 1.55083105e-01f, 2.04874739e-01f, 2.93806911e-01f, 2.35243753e-01f, 2.09672809e-01f, 2.24387825e-01f,
  3.05176005e-02f, 1.05468154e-01f, 8.97328109e-02f, 1.67110845e-01f, 2.00135484e-01f, 2.89760232e-01f, 2.36636564e-01f, 1.71887472e-01f, 1.55438140e-01f, 3.64091210e-02f,
  -2.52406491e-04f, -3.99525166e-02f, 7.18645677e-02f, 7.76469335e-02f, 2.32255623e-01f, 2.04715937e-01f, 1.60252839e-01f, 5.16590588e-02f, 2.93757915e-02f, 3.11039835e-01f,
  6.00603260e-02f, -1.19686853e-02f, -1.27141193e-01f, -1.39561862e-01f, -8.24707672e-02f, -7.83742741e-02f, -3.90966721e-02f, 6.14689440e-02f, -1.60439447e-01f, -3.83230858e-02f,
  -3.59220430e-02f, 6.75258562e-02f, -2.57507358e-02f, -2.24481933e-02f, -2.40614871e-03f, -1.42602269e-02f, 9.25617665e-02f, 2.14175835e-01f, 1.29889145e-01f, 1.11437991e-01f,
  -1.58437004e-03f, 1.26318187e-01f, 1.06816761e-01f, 4.16041501e-02f, 1.28134666e-02f, 7.30777252e-03f, 1.52384117e-02f, 9.75212380e-02f, -2.88510472e-02f, 4.58973944e-02f,
  2.43065715e-01f, -1.29155198e-03f, 1.31943077e-01f, 2.08467454e-01f, 9.80044380e-02f, 6.17522746e-02f, 5.55137470e-02f, 5.54453060e-02f, 1.12153836e-01f, 4.21024896e-02f,
  1.67522356e-01f, 6.01704083e-02f, 1.13828667e-01f, -8.80364329e-03f, -5.21825738e-02f, 1.52389646e-01f, 1.41257927e-01f, -2.79283654e-02f, -9.15395841e-02f, 1.19103193e-01f,
  1.14745840e-01f, -3.78847271e-02f, 3.06008440e-02f, 1.00761518e-01f, -2.79137101e-02f, -3.24414298e-02f, 3.73262330e-03f, -2.14393879e-03f, -4.01130915e-02f, -1.23547204e-01f,
  1.15763722e-03f, -6.64739907e-02f, 9.27582234e-02f, 1.48185953e-01f, -3.49518135e-02f, -1.82989433e-01f, -8.83359462e-03f, -1.02007858e-01f, -1.62859380e-01f, 3.24654765e-02f,
  -7.63498992e-02f, -1.23322815e-01f, -6.70431852e-02f, -3.15175503e-02f, -7.88658019e-03f, -2.59842202e-02f, 3.02280951e-02f, 9.13806707e-02f, 2.33737729e-03f, 5.30856252e-02f,
  -9.75086018e-02f, 1.16159715e-01f, 1.01670198e-01f, -2.40830798e-02f, -1.16413459e-01f, -1.36586562e-01f, -1.79752201e-01f, -1.54022621e-02f, -1.63357213e-01f, -1.89957902e-01f,
  1.44064665e-01f, 3.64979923e-01f, -9.56181362e-02f, 2.85055898e-02f, 3.19276899e-01f, 1.58889890e-01f, 1.45125866e-01f, -9.02243629e-02f, -1.18149810e-01f, 9.92228687e-02f,
  2.36181363e-01f, 9.80567466e-03f, -1.06929287e-01f, -1.72537550e-01f, -1.70015663e-01f, -8.83234013e-03f, -5.39474450e-02f, -1.46802425e-01f, -1.36588797e-01f, 6.84334636e-02f,
  1.56630322e-01f, 1.69269785e-01f, 7.36635923e-02f, -1.36589333e-01f, 1.31262496e-01f, -6.47036433e-02f, 1.04641423e-01f, 2.97877014e-01f, 2.65895396e-01f, 9.31639411e-03f,
  5.94435185e-02f, 2.01112360e-01f, -3.41747940e-01f, 1.29663855e-01f, 1.77207574e-01f, -1.05966985e-01f, -1.27380967e-01f, -1.16399035e-01f, -2.91659553e-02f, -1.81913272e-01f,
  1.62263513e-01f, 1.23253375e-01f, 5.64150997e-02f, 6.85937703e-02f, -5.12503786e-03f, -2.15577781e-02f, 3.37168854e-03f, -1.34775177e-01f, -1.92500755e-01f, -8.51895735e-02f,
  5.40277772e-02f, 1.79935217e-01f, 8.37281197e-02f, -9.02256444e-02f, -1.33150488e-01f, -7.32972920e-02f, 5.25156111e-02f, 1.50373075e-02f, -1.80102419e-02f, -1.66334391e-01f,
  -1.97618473e-02f, 6.13890477e-02f, 9.22999904e-02f, 5.37202992e-02f, -1.95135572e-03f, -6.80775344e-02f, 3.76848364e-03f, 7.30193183e-02f, 3.61129679e-02f, 7.96413608e-03f,
  -1.60468727e-01f, -1.59868345e-01f, -1.72379434e-01f, -1.27279222e-01f, -1.05582282e-01f, 1.78726614e-02f, -6.84029460e-02f, -3.72427851e-02f, 3.39046456e-02f, 3.03500593e-02f,
  1.02723036e-02f, -1.58599451e-01f, 1.88066754e-02f, -8.27945471e-02f, -8.91479105e-02f, -6.45297468e-02f, -1.22603662e-01f, -3.12601253e-02f, 3.74308974e-02f, 1.18889874e-02f,
  -7.94029012e-02f, 1.09718628e-01f, -1.93154618e-01f, 3.79216261e-02f, 1.29770130e-01f, -1.17343739e-02f, -4.13461262e-03f, -5.63101619e-02f, 7.24048987e-02f, -1.68885425e-01f,
  4.46508266e-02f, -1.59785792e-01f, -4.26332392e-02f, -1.36083663e-02f, -1.03260599e-01f, -7.92350471e-02f, 8.01886022e-02f, -1.55885071e-01f, -1.27707183e-01f, -3.92519422e-02f,
  -4.42298800e-02f, -5.60198128e-02f, -1.54716223e-01f, -2.16263071e-01f, -1.00246653e-01f, -1.73888624e-01f, -6.60049692e-02f, -7.13778287e-02f, -5.72586879e-02f, -1.51058868e-01f,
  -1.34302944e-01f, -2.08217174e-01f, 9.95137095e-02f, 1.36741626e-04f, 1.44858554e-01f, -2.14121565e-01f, -5.40804863e-01f, -4.50240612e-01f, -1.04403988e-01f, -3.48113813e-02f,
  2.70620495e-01f, 4.04962361e-01f, 1.98997766e-01f, 1.32094741e-01f, -1.78027973e-01f, -2.19922110e-01f, -1.01881415e-01f, 5.18105105e-02f, 5.75262643e-02f, 3.24964337e-02f,
  1.37613788e-01f, 7.45771751e-02f, 7.92205855e-02f, -8.51155147e-02f, 1.53139740e-01f, 2.22149268e-01f, 5.12603000e-02f, 2.04250067e-01f, 1.16546340e-01f, 2.72663087e-01f,
  3.87695253e-01f, -2.09820479e-01f, -3.89291942e-02f, 1.13380007e-01f, 2.05099195e-01f, -2.01644033e-01f, -1.79725140e-01f, 3.31584997e-02f, -3.57117131e-02f, -1.78669766e-01f,
  2.00704321e-01f, 1.10974737e-01f, 3.80352640e-06f, -5.37335165e-02f, -7.02016205e-02f, -1.77699491e-01f, -1.02920026e-01f, -2.45495006e-01f, -1.33133009e-01f, -7.77010806e-03f,
  2.09987298e-01f, 2.11542115e-01f, 1.32955462e-01f, -8.41305256e-02f, -1.47467822e-01f, 1.98166385e-01f, -1.75416227e-02f, 3.54419718e-03f, -1.41247541e-01f, -8.20085257e-02f,
  4.38011959e-02f, 7.76354074e-02f, 4.31539789e-02f, 2.36261003e-02f, 1.45703247e-02f, 8.02920386e-02f, -7.37767573e-03f, 5.76044358e-02f, -3.36659923e-02f, 9.46177617e-02f,
  8.97335559e-02f, 2.60849260e-02f, -3.39098535e-02f, 1.62274390e-02f, 8.17968696e-02f, 1.20085485e-01f, 5.16918823e-02f, 2.59340312e-02f, 9.07148942e-02f, -7.70712504e-03f,
  1.11563198e-01f, -4.83447686e-02f, 5.10263667e-02f, -7.84479380e-02f, 8.02934766e-02f, 2.90702656e-02f, 1.34518947e-02f, 1.24649227e-01f, 1.11855619e-01f, 5.50578050e-02f,
  1.51263878e-01f, -1.08740963e-01f, -1.64479762e-02f, -5.81227243e-02f, 1.18792467e-02f, 5.41836843e-02f, 5.25045246e-02f, 4.86271307e-02f, 4.56263013e-02f, -9.67411920e-02f,
  -3.38916807e-03f, -5.13164513e-03f, 1.80737453e-03f, -1.42812058e-01f, -1.86044313e-02f, 1.10205188e-01f, 8.54928046e-02f, 1.70243785e-01f, -9.20434594e-02f, -9.01453570e-03f,
  -1.24561191e-01f, -1.32260069e-01f, 1.42189413e-02f, -5.85835390e-02f, -6.84176832e-02f, 3.79585363e-02f, 3.30599174e-02f, -3.34657393e-02f, -9.97277200e-02f, -2.55134374e-01f,
  -4.73333538e-01f, -4.23520416e-01f, 2.38098770e-01f, -5.21836579e-01f, 3.65439430e-02f, 3.20010543e-01f, 2.12294802e-01f, -6.16572760e-02f, -1.86724722e-01f, -1.49810001e-01f,
  -1.43291354e-01f, -4.33673784e-02f, -9.06879231e-02f, -7.40998089e-02f, -4.61371243e-02f, -6.81094155e-02f, 2.17697769e-02f, 1.58187568e-01f, 3.00348282e-01f, 2.55575508e-01f,
  -3.81591544e-02f, -3.32042128e-01f, -1.83394730e-01f, -1.81814328e-01f, -3.80811453e-01f, -1.44062459e-01f, -1.16936065e-01f, -1.61601990e-01f, -7.45936036e-02f, -3.57032090e-01f,
  3.06575119e-01f, -1.98506773e-01f, 1.81310385e-01f, -1.91995367e-01f, -6.00736402e-02f, -1.13179810e-01f, 2.55392678e-02f, -1.95373476e-01f, -6.07751980e-02f, -4.33008969e-02f,
  -1.07729279e-01f, -6.91916496e-02f, -2.04226226e-02f, -3.60239074e-02f, -1.16137810e-01f, 8.78619999e-02f, -1.26284108e-01f, -1.34083584e-01f, -6.00427501e-02f, 1.66060042e-03f,
  -1.71833396e-01f, -7.03932419e-02f, 3.63773555e-02f, 5.92282154e-02f, -6.11364702e-03f, 7.76430592e-02f, 3.85668129e-02f, 8.42565000e-02f, 1.10239200e-02f, -1.62394181e-01f,
  3.50137949e-02f, 2.54244879e-02f, -9.89505127e-02f, -5.50132096e-02f, -8.44152237e-04f, 2.30179261e-02f, 2.69965492e-02f, -9.06029493e-02f, -1.10756271e-02f, -7.01013356e-02f,
  -1.50286853e-01f, -6.83367848e-02f, -3.60720605e-03f, -6.42108172e-02f, 4.14500050e-02f, -1.35212213e-01f, 3.15715224e-02f, 1.97414849e-02f, -2.12777387e-02f, -5.58153801e-02f,
  7.00693671e-03f, -8.22360516e-02f, -6.38422556e-03f, -1.06271848e-01f, 1.55497920e-02f, -1.75407771e-02f, -2.77957022e-02f, 5.75046204e-02f, 2.16086861e-02f, 2.15007141e-02f,
  -7.74241388e-02f, 2.53473908e-01f, 2.38189474e-02f, -1.02339156e-01f, 3.49162668e-02f, -4.06076349e-02f, -1.98741872e-02f, 2.67690681e-02f, -7.97707662e-02f, 8.61048624e-02f,
  -8.21338035e-03f, 6.45325854e-02f, -1.49904788e-02f, -9.86300856e-02f, 1.39309406e-01f, 1.38749868e-01f, -1.39527649e-01f, -2.95955595e-02f, 6.93111941e-02f, -1.76507328e-02f,
  -8.07299167e-02f, 4.12234701e-02f, 9.05975252e-02f, 7.34689087e-02f, 1.12533718e-01f, 2.37251982e-01f, 1.91338062e-01f, 1.48458794e-01f, 2.94057310e-01f, 6.64272830e-02f,
  -4.40438092e-02f, -1.11711375e-01f, 2.72993952e-01f, 2.19877392e-01f, 9.98834521e-02f, -3.05089653e-01f, -6.04049206e-01f, -2.08837226e-01f, 1.20444588e-01f, 1.51008200e-02f,
  4.73396294e-02f, 5.37783951e-02f, 6.07535318e-02f, -6.83128908e-02f, -2.93666720e-01f, -1.23314761e-01f, 3.88059020e-02f, -5.93987443e-02f, -1.65598840e-01f, -1.87461093e-01f,
  -1.21520273e-01f, 6.38845935e-02f, 1.25684604e-01f, -1.46381417e-02f, 3.09752077e-01f, 7.40993917e-02f, 1.78915322e-01f, 1.14066742e-01f, -9.34269875e-02f, 3.30739498e-01f,
  2.07976803e-01f, 1.89232361e-02f, -1.54843330e-01f, 3.79114226e-02f, 1.74608409e-01f, -1.04447706e-02f, -8.96098241e-02f, 7.71611184e-02f, -9.45550799e-02f, 4.43258462e-03f,
  2.46184438e-01f, 3.97370085e-02f, -5.77729719e-04f, 1.13305137e-01f, 6.76227883e-02f, -6.68693632e-02f, 1.16041720e-01f, -2.16705054e-02f, -6.78766891e-02f, 9.09180194e-02f,
  3.11636552e-02f, 1.19226135e-01f, 7.18431696e-02f, -1.22662038e-01f, -7.81145096e-02f, 5.64565361e-02f, -1.14947081e-01f, -4.71270829e-03f, -8.94738138e-02f, 2.81791575e-02f,
  6.04389384e-02f, 2.19977107e-02f, -8.68668631e-02f, 3.39603312e-02f, -5.86163774e-02f, 3.73033285e-02f, 2.00013533e-01f, 1.25089316e-02f, 4.59652804e-02f, 4.27351370e-02f,
  3.21035720e-02f, 4.66103442e-02f, 9.29482863e-04f, -3.04796528e-02f, 1.28019676e-01f, 1.31655425e-01f, 3.20253074e-02f, -6.63853586e-02f, 1.02591246e-01f, 8.43913332e-02f,
  -2.78641321e-02f, 2.07310147e-03f, 1.64863855e-01f, -2.58695744e-02f, 7.92032480e-02f, 6.02375716e-02f, 1.22196652e-01f, -3.48379537e-02f, 3.28996368e-02f, 5.55609353e-02f,
  -6.14310149e-03f, -1.96949214e-01f, -1.18212877e-02f, 2.81848181e-02f, 1.02601647e-01f, 9.55268741e-02f, 2.84285452e-02f, -1.27481557e-02f, 2.05562022e-02f, -1.19414218e-02f,
  -7.01117446e-04f, -8.13537166e-02f, -3.04842182e-02f, 2.01810040e-02f, -5.27168512e-02f, 7.73365945e-02f, 8.69763270e-02f, 1.09325983e-02f, -6.18362762e-02f, 1.49591774e-01f,
  4.33746763e-02f, -2.60440201e-01f, -2.44130090e-01f, -2.61397928e-01f, -1.32275432e-01f, -2.21001863e-01f, -2.78340399e-01f, -2.72375405e-01f, -3.66211653e-01f, -5.24002790e-01f,
  -2.99118608e-01f, 4.25661564e-01f, 4.25044507e-01f, -2.29559913e-01f, 2.52888769e-01f, 2.16771379e-01f, 2.40799367e-01f, -6.24620877e-02f, -1.41751468e-01f, 1.72588974e-01f,
  3.38171363e-01f, -1.57171756e-01f, -6.69047683e-02f, -1.20486721e-01f, -2.36927927e-01f, 7.15038031e-02f, 3.99373919e-02f, -2.58111328e-01f, -3.95978600e-01f, -2.76330173e-01f,
  -1.19018175e-01f, -2.41036490e-01f, -3.92597675e-01f, -1.81282237e-01f, 7.05424100e-02f, -1.04629971e-01f, 2.10057124e-01f, 1.21422738e-01f, 1.88332349e-01f, 7.23772645e-02f,
  2.08946124e-01f, 2.82705009e-01f, -1.36055514e-01f, -2.58386172e-02f, 1.88512579e-01f, -1.35540858e-01f, 1.49425734e-02f, -4.76805717e-02f, -5.47429733e-02f, 4.93537448e-03f,
  1.14568464e-01f, -2.84505859e-02f, 8.94149318e-02f, 3.65610491e-03f, -1.75609458e-02f, -1.26669228e-01f, -1.53658316e-01f, -1.79450572e-01f, -1.92544162e-01f, 8.14231485e-03f,
  -2.11376697e-02f, 1.45281643e-01f, 1.48688138e-01f, -9.55618992e-02f, -7.63621628e-02f, -1.58707023e-01f, 9.73025635e-02f, -1.20595321e-01f, -1.25586465e-01f, -1.90640718e-01f,
  -1.16515242e-01f, 8.77979174e-02f, 2.54772417e-02f, -4.58105244e-02f, -6.71262220e-02f, 6.29637539e-02f, 2.46162992e-02f, -4.43904810e-02f, -7.32885525e-02f, -3.33644473e-03f,
  -2.84059327e-02f, 7.41228908e-02f, 4.73519824e-02f, 5.98480888e-02f, -1.68971512e-02f, -6.87824190e-02f, -9.42161866e-03f, -4.40636165e-02f, 7.36569017e-02f, -3.75604481e-02f,
  -1.06405675e-01f, 1.34360427e-02f, -3.57409008e-02f, -1.69009432e-01f, 6.66559115e-02f, 2.30005626e-02f, -7.15232342e-02f, -1.92266330e-02f, -5.37325889e-02f, 1.16402179e-01f,
  -1.63841665e-01f, 1.32396564e-01f, -1.24992011e-02f, -5.65681234e-02f, 1.31927848e-01f, 4.11328003e-02f, 1.26095220e-01f, 6.21914119e-02f, 9.04188231e-02f, 4.59888624e-03f,
  2.77706701e-02f, -4.13776934e-03f, 7.52682909e-02f, 1.12610999e-02f, -1.36890054e-01f, -4.23316434e-02f, -1.19457908e-01f, 2.43028607e-02f, -1.46721184e-01f, 1.16860578e-02f,
  -1.58204958e-01f, -2.45080814e-01f, -2.57776350e-01f, -1.25842035e-01f, -9.91582647e-02f, -2.10459456e-01f, -1.15639448e-01f, -8.68436173e-02f, -1.86656162e-01f, -2.65324205e-01f,
  -1.50232807e-01f, -3.47421169e-01f, 4.45686191e-01f, -4.89704497e-02f, -1.72400385e-01f, -2.05875784e-01f, -4.44212914e-01f, -5.56150451e-02f, -4.70239297e-03f, -1.98321074e-01f,
  -4.63218391e-01f, -3.31727296e-01f, -2.41260859e-03f, -7.77536854e-02f, -5.54713309e-02f, 2.93950960e-02f, 2.21820593e-01f, 3.14948559e-01f, 3.34233977e-02f, -3.96422863e-01f,
  -4.41411614e-01f, -8.28947648e-02f, 2.00360358e-01f, 2.41087884e-01f, 1.11072697e-01f, 2.55741104e-02f, 3.59430194e-01f, 3.46325450e-02f, 2.34159902e-02f, 2.32252285e-01f,
  1.23481460e-01f, 1.41597748e-01f, 5.43737337e-02f, -1.21298824e-02f, -8.03213865e-02f, -3.00170779e-02f, -1.58102363e-02f, 1.21670008e-01f, -1.33977726e-01f, 9.82779711e-02f,
  -1.56150162e-01f, -1.67800128e-01f, -1.27958775e-01f, -7.67549127e-02f, -7.44587183e-02f, -2.70024780e-02f, 1.62665844e-01f, 1.57443359e-01f, 1.67715460e-01f, -2.38679852e-02f,
  -3.54105741e-01f, -2.44545311e-01f, 3.96117121e-02f, 1.06528714e-01f, 2.00567991e-01f, -8.76674335e-03f, 5.65580577e-02f, 6.62559196e-02f, 1.93680540e-01f, 1.26527831e-01f,
  5.43069541e-02f, 5.12632057e-02f, 4.25578989e-02f, 3.93076278e-02f, -1.17123447e-01f, -6.54301047e-02f, 1.09986462e-01f, -8.91536009e-03f, 3.18850763e-02f, -1.66187268e-02f,
  4.77191545e-02f, -3.98145989e-02f, -5.16593531e-02f, 4.43711951e-02f, 3.50086391e-02f, -2.59722881e-02f, -1.03753962e-01f, 1.41722970e-02f, 5.96757792e-02f, 3.51120066e-03f,
  -5.74100763e-02f, 1.82094388e-02f, 6.96830302e-02f, 2.82833725e-02f, 3.38609107e-02f, 1.17336772e-01f, 2.92083398e-02f, -2.78082341e-02f, 1.73856840e-02f, -1.47268595e-02f,
  -1.81568503e-01f, 1.27535999e-01f, -9.54269022e-02f, 9.14813355e-02f, -8.19833763e-03f, 4.48619500e-02f, -6.17734976e-02f, -8.57810583e-03f, -4.91019571e-03f, -2.35363301e-02f,
  -6.69027716e-02f, -7.94383511e-02f, 5.08865751e-02f, 9.43071675e-03f, -1.22216992e-01f, -4.30053882e-02f, -2.44734928e-01f, -1.67344302e-01f, -1.23772748e-01f, -1.74696654e-01f,
  8.21342925e-04f, -2.42032290e-01f, -3.57446045e-01f, -2.08198845e-01f, -1.03462905e-01f, -2.15129659e-01f, -6.47959262e-02f, -7.65448287e-02f, -1.22492373e-01f, -2.55386949e-01f,
  4.45790172e-01f, 8.30119923e-02f, 1.24878317e-01f, 1.57473639e-01f, 1.90658793e-01f, 3.23799908e-01f, 2.08044097e-01f, 1.49893299e-01f, 9.72628742e-02f, 5.55687360e-02f,
  5.34485579e-02f, -6.63609430e-02f, -8.23365897e-02f, -1.21452749e-01f, 1.12775445e-01f, 4.05729450e-02f, -1.49764400e-02f, 2.25702487e-02f, 9.44945067e-02f, 6.57729134e-02f,
  -5.19283786e-02f, 9.74598378e-02f, 1.15592308e-01f, 8.20937380e-02f, -9.30795595e-02f, -3.47827189e-02f, 1.30865291e-01f, 1.02213308e-01f, 8.50708410e-02f, -2.43216187e-01f,
  -2.15668127e-01f, 2.79969782e-01f, 1.27104241e-02f, -1.18800983e-01f, -2.68919431e-02f, -4.12477814e-02f, 4.06277701e-02f, 6.28181407e-03f, -2.00048424e-02f, -7.66149387e-02f,
  -3.02318041e-03f, 7.24251010e-03f, 2.43575815e-02f, -8.13273489e-02f, -1.24679804e-02f, -5.84942885e-02f, 4.57676016e-02f, -5.72703928e-02f, -3.70078161e-02f, -1.23120449e-01f,
  -2.34561153e-02f, 9.08691734e-02f, 3.31634842e-02f, 7.63119024e-05f, 9.06519368e-02f, 1.15681678e-01f, 6.10237801e-03f, -5.03874123e-02f, 4.76501994e-02f, -6.41348213e-02f,
  1.69389427e-01f, 2.01784912e-02f, 8.21084306e-02f, 9.32105184e-02f, 1.25002861e-01f, 9.19178426e-02f, 1.08963348e-01f, 1.35529369e-01f, 2.10354403e-01f, 2.29914725e-01f,
  8.14197734e-02f, 7.75896385e-02f, 6.03081137e-02f, 5.51851057e-02f, 9.21352804e-02f, 4.86741699e-02f, 8.96653309e-02f, 1.08149432e-01f, 1.17571533e-01f, 1.16546594e-01f,
  4.45795879e-02f, 2.31153239e-02f, 9.63004380e-02f, 2.92227673e-03f, -2.50674523e-02f, 5.40897250e-02f, 1.16879106e-01f, 1.20351315e-01f, 1.44327775e-01f, 1.31202057e-01f,
  -5.78419678e-02f, 4.09307837e-01f, -9.69055854e-03f, -1.56601012e-01f, 4.04754579e-02f, 4.92973812e-03f, 3.36987376e-02f, -3.14310566e-02f, -1.47386715e-01f, -1.52899280e-01f,
  -3.92618999e-02f, -2.98566818e-02f, 1.15951523e-01f, 1.32920295e-01f, 1.82493687e-01f, 6.40795901e-02f, 5.68265319e-02f, 3.03765647e-02f, -1.28537357e-01f, -8.65411311e-02f,
  -2.49827392e-02f, 1.26401067e-01f, 7.89790526e-02f, 1.09198190e-01f, 1.81249306e-01f, 1.42869994e-01f, 9.68581960e-02f, -2.37905346e-02f, -5.23254694e-03f, 3.95055786e-02f,
  -1.49967283e-01f, -1.02065437e-01f, -1.52284294e-01f, 3.03477943e-01f, 2.74121612e-01f, 7.78137296e-02f, -5.39357662e-02f, -8.00360516e-02f, 1.03166200e-01f, 8.00225213e-02f,
  6.05506748e-02f, 1.93382904e-01f, 1.08113252e-01f, 9.88074094e-02f, -1.04285762e-01f, 2.34605046e-03f, 1.82771415e-01f, 6.40453305e-04f, 4.48684730e-02f, 1.20869517e-01f,
  2.53748506e-01f, 4.04006131e-02f, -1.13311209e-01f, 1.44467340e-03f, 1.88276574e-01f, 2.07159415e-01f, 9.46987420e-03f, 1.49219722e-01f, 1.06240466e-01f, 3.36414456e-01f,
  -4.27452177e-02f, -1.60419494e-01f, 1.06144235e-01f, 6.52571917e-02f, 7.15694651e-02f, -3.62405628e-02f, -9.16600898e-02f, -1.14016987e-01f, 3.33081111e-02f, -5.82635067e-02f,
  9.49728582e-03f, -1.09124690e-01f, 6.51175752e-02f, -4.58812676e-02f, -1.18487589e-01f, -1.28592119e-01f, -1.48843139e-01f, -1.82476491e-01f, -2.08523721e-01f, -1.49979040e-01f,
  1.93115667e-01f, 4.57907021e-02f, -1.58803210e-01f, -1.67823732e-01f, -1.95731640e-01f, -5.28995134e-02f, -2.07729831e-01f, -1.22721463e-01f, -3.16890448e-01f, -9.67701897e-02f,
  -1.19789213e-01f, -1.49686515e-01f, -5.34290038e-02f, -1.01097599e-01f, 6.54379651e-02f, 1.33926664e-02f, 9.33590382e-02f, 8.98000076e-02f, 1.96007490e-02f, -6.01082891e-02f,
  6.38192520e-02f, -1.25274202e-02f, -3.33099179e-02f, -7.17266798e-02f, 7.88196102e-02f, -5.72403744e-02f, 5.99440597e-02f, 2.70323697e-02f, -3.20227370e-02f, -1.23365290e-01f,
  -7.55401552e-02f, 9.66008194e-03f, -5.46895154e-02f, -1.55922733e-02f, -2.84888260e-02f, -1.56057030e-01f, 2.69367062e-02f, -9.85928997e-03f, -4.81182635e-02f, -1.64185360e-01f,
  -7.67486840e-02f, -2.14065254e-01f, 1.30126640e-01f, -7.41260573e-02f, 7.04286769e-02f, -2.65902895e-02f, 1.65779330e-02f, 2.62346379e-02f, -9.24285408e-03f, 8.88596848e-03f,
  -1.32978708e-01f, -8.89829248e-02f, -7.02214390e-02f, -4.21120562e-02f, 1.34377861e-02f, -3.31919305e-02f, 4.24578823e-02f, 1.00705937e-01f, -9.64380354e-02f, -1.25558665e-02f,
  5.49177192e-02f, 9.21039470e-03f, -4.88547757e-02f, -2.69441567e-02f, -7.12782592e-02f, -2.23314433e-04f, -1.73114955e-01f, -6.64741397e-02f, -2.44734526e-01f, -1.11424573e-01f,
  -5.76218188e-01f, -7.72059634e-02f, 8.52803364e-02f, -3.80512953e-01f, -3.32597256e-01f, -1.28139257e-01f, -8.82048532e-02f, -1.26052767e-01f, -1.44756496e-01f, -9.98906326e-03f,
  2.21130773e-01f, 1.40692994e-01f, 3.91562060e-02f, 1.13980025e-01f, -4.95846309e-02f, 3.03295627e-03f, -2.05489799e-01f, -1.49468467e-01f, -6.48684204e-02f, -1.41688779e-01f,
  -1.96766987e-01f, -3.49985063e-01f, -3.65053564e-01f, -1.99174687e-01f, -1.32112876e-01f, -8.69865939e-02f, -1.98853627e-01f, -3.02486688e-01f, -1.26222149e-01f, -3.09301525e-01f,
  2.86144614e-01f, -1.85756519e-01f, -1.11597456e-01f, -1.10553265e-01f, 5.58688492e-03f, 1.10635176e-01f, -5.90752140e-02f, -1.44397318e-01f, -3.28967161e-02f, 1.22872982e-02f,
  -7.38123506e-02f, 7.03560635e-02f, -1.31024033e-01f, 7.20779076e-02f, -1.47929089e-02f, 5.57747819e-02f, 7.84339309e-02f, -7.35954866e-02f, -8.34010765e-02f, 3.31885546e-01f,
  7.45019913e-02f, -1.13781378e-01f, 1.64896045e-02f, -3.03577948e-02f, -1.83502398e-02f, -6.35383576e-02f, 2.54313629e-02f, -3.55318636e-02f, -5.96404783e-02f, -1.46700948e-01f,
  -4.07155491e-02f, 1.06230453e-01f, 1.18212225e-02f, 3.07795336e-03f, -8.36697873e-03f, 9.91751626e-03f, -5.08577265e-02f, -6.62676319e-02f, -6.33725375e-02f, 2.00632773e-02f,
  4.25303653e-02f, 7.74369314e-02f, 4.86731976e-02f, -2.09382534e-01f, 3.73416543e-02f, -1.38903096e-01f, -6.71249852e-02f, 7.30755646e-03f, 3.14264260e-02f, -8.19128230e-02f,
  -3.81952412e-02f, -1.11962080e-01f, -1.02226384e-01f, -4.06196713e-02f, -1.98682807e-02f, -7.37248734e-02f, 5.76372743e-02f, 1.53864011e-01f, 1.06929056e-01f, 7.91358426e-02f,
  6.15695976e-02f, -2.98165902e-02f, -4.94583650e-03f, 5.18821739e-02f, -3.28929685e-02f, 2.04039097e-01f, 9.04457495e-02f, -9.52230953e-03f, -6.99794944e-03f, 8.77482593e-02f,
  1.01153597e-01f, -4.61007096e-02f, 2.79575065e-02f, 3.68890800e-02f, 2.94891372e-02f, 2.84138229e-02f, -7.90525973e-02f, -2.23155990e-01f, -4.21909876e-02f, 1.61314934e-01f,
  9.86553803e-02f, -9.72029716e-02f, -1.62315354e-01f, 8.61210972e-02f, -1.29864931e-01f, -7.20209107e-02f, 1.11236893e-01f, 2.57656127e-02f, 5.37964962e-02f, -9.06294286e-02f,
  4.09428269e-01f, 1.12362124e-01f, -4.26165253e-01f, 3.62137407e-01f, -1.25004411e-01f, -1.97854578e-01f, 1.06431939e-01f, 1.37432262e-01f, 1.51710704e-01f, 1.51621372e-01f,
  -1.23850450e-01f, -1.78874865e-01f, -1.36979250e-02f, -1.24164224e-01f, 2.58042454e-03f, 1.80806741e-01f, 1.76622331e-01f, -1.53308883e-01f, -2.15318754e-01f, -1.54685318e-01f,
  8.84559378e-02f, 2.20279977e-01f, 1.38825327e-01f, 4.09596413e-03f, -1.29303709e-02f, -6.38700053e-02f, 1.34027749e-02f, -3.21092680e-02f, -1.56483948e-01f, -9.68561769e-02f,
  -2.76660830e-01f, -2.48979881e-01f, -1.39673784e-01f, -3.10879797e-02f, -1.11221559e-01f, 2.18199678e-02f, -1.63902882e-02f, -6.23701811e-02f, -6.10329537e-03f, 4.89005856e-02f,
  -7.84992650e-02f, 1.12669645e-02f, -6.94731399e-02f, -6.52978895e-03f, -1.89262293e-02f, -3.97428637e-03f, -2.62577254e-02f, -9.24171731e-02f, -3.03942077e-02f, -1.72300458e-01f,
  -6.36605322e-02f, -2.26438671e-01f, -3.15067381e-01f, -7.45429695e-02f, -1.48088023e-01f, -6.61433265e-02f, -2.19660506e-01f, -2.12016821e-01f, -1.28806457e-01f, 2.60735191e-02f,
  4.64622378e-02f, 4.80597913e-02f, 3.27472836e-02f, -5.97044975e-02f, 8.44917148e-02f, -2.05678660e-02f, 6.98503330e-02f, 2.67635211e-02f, 5.88166378e-02f, 3.00845932e-02f,
  1.53112672e-02f, 2.99071409e-02f, -2.58108787e-02f, 7.07384944e-02f, 1.02676809e-01f, -1.55612687e-02f, -6.67267153e-03f, -5.63062308e-03f, -3.48243788e-02f, 1.39774203e-01f,
  -1.66345220e-02f, -1.62907597e-02f, -3.47078256e-02f, -1.40691809e-02f, -6.02166690e-02f, -1.08164251e-01f, 1.21680103e-01f, 1.98263656e-02f, 3.83424424e-02f, 1.38632115e-02f,
  3.14187676e-01f, -1.23765625e-01f, 1.13669828e-01f, 3.78615409e-02f, -5.02694026e-02f, -5.80985807e-02f, 6.30830675e-02f, -2.75264010e-02f, 4.37080041e-02f, 6.25031665e-02f,
  -3.54562402e-02f, 5.81277758e-02f, -6.64896891e-03f, 5.39873801e-02f, 3.82897370e-02f, 4.11440358e-02f, 8.45987797e-02f, -4.00829613e-02f, 6.36906028e-02f, -1.34982280e-02f,
  1.89939767e-01f, 1.68542817e-01f, 9.83308032e-02f, 1.17277749e-01f, 2.72888085e-03f, 1.18411049e-01f, 4.30809930e-02f, 1.49473445e-02f, 4.87018377e-02f, 4.48877841e-01f,
  6.06554449e-01f, -1.96163341e-01f, 4.04616855e-02f, 1.63204476e-01f, 7.29446784e-02f, -8.55730847e-02f, -2.37250075e-01f, 4.62532789e-02f, 1.93261236e-01f, 8.21241215e-02f,
  1.82343081e-01f, 3.55361491e-01f, 2.73556530e-01f, 1.98167190e-01f, 8.52423981e-02f, 1.00000605e-01f, 2.02640556e-02f, 2.38538861e-01f, 1.61017358e-01f, 1.08108833e-01f,
  1.51217848e-01f, 1.04042530e-01f, 6.69527128e-02f, 1.16072886e-01f, 1.44355044e-01f, 1.69515401e-01f, 9.71287116e-02f, -1.10855279e-02f, 1.30370080e-01f, 2.47351259e-01f,
  3.01263258e-02f, -2.70255487e-02f, 8.91135111e-02f, 6.03486896e-02f, 6.49013668e-02f, -9.06486213e-02f, -2.31849048e-02f, -1.14438832e-01f, 1.67916436e-02f, 2.70937253e-02f,
  4.15131859e-02f, 3.67039926e-02f, -7.35107437e-02f, -9.16497931e-02f, -3.84748243e-02f, -1.05179638e-01f, -5.77433109e-02f, -9.91722420e-02f, -5.60144987e-03f, -9.21838731e-02f,
  -2.81904414e-02f, 1.32897282e-02f, -1.22084923e-01f, -3.81195135e-02f, -4.66692299e-02f, 1.88198462e-01f, -1.25412624e-02f, -2.53455397e-02f, -6.46622106e-02f, 5.20111900e-03f,
  3.39365244e-01f, 6.20713830e-03f, 2.64155865e-01f, 6.75683618e-02f, 2.39239320e-01f, 1.04092769e-02f, -7.23597556e-02f, -1.55903185e-02f, 4.06210721e-02f, 2.63162311e-02f,
  -5.00377938e-02f, 1.32534713e-01f, -1.25659317e-01f, -1.31773770e-01f, 4.59916554e-02f, -1.10463180e-01f, -3.88030447e-02f, -9.02792439e-02f, 7.33048189e-03f, -7.70568475e-02f,
  2.69649103e-02f, -7.22965524e-02f, 5.79728670e-02f, -2.38553789e-02f, -5.93144074e-02f, 9.46300477e-02f, 1.25134796e-01f, 6.44474924e-02f, 3.04602180e-02f, -2.21422389e-02f,
  -3.83229166e-01f, 1.33863077e-01f, 1.87871158e-01f, 3.01527581e-03f, -1.41335443e-01f, -6.58260360e-02f, 2.25786287e-02f, -2.23692775e-01f, -1.81171134e-01f, -1.00766376e-01f,
  -9.68393385e-02f, -1.05926983e-01f, 4.22366057e-03f, 3.07184886e-02f, 3.31304856e-02f, -4.27016392e-02f, 2.31294967e-02f, -4.66583073e-02f, -8.48527253e-02f, -1.68659925e-01f,
  -1.09289557e-01f, -1.34651303e-01f, -4.98440005e-02f, -4.86736707e-02f, -2.03579459e-02f, 1.32039338e-01f, -8.82912502e-02f, -4.58281338e-02f, -1.08638853e-01f, -2.56052725e-02f,
  -2.25172043e-02f, 4.62953299e-02f, 1.71276554e-01f, -1.31896129e-02f, -1.62774548e-01f, -2.32892886e-01f, -3.21133971e-01f, -1.73431233e-01f, -1.50887519e-01f, -1.38463512e-01f,
  -1.72621116e-01f, -1.02724746e-01f, 1.38525590e-02f, 9.29219052e-02f, -1.62665937e-02f, 7.09287301e-02f, 2.93730378e-01f, 3.76595140e-01f, 1.43393904e-01f, -4.11935337e-02f,
  9.29599628e-02f, 1.75038517e-01f, 2.29074910e-01f, 2.22469524e-01f, 1.41063452e-01f, 3.24354358e-02f, 8.31386298e-02f, 1.38054922e-01f, 1.23367354e-01f, 3.32183212e-01f,
  -5.92852309e-02f, -2.09303677e-01f, -1.31809846e-01f, 5.12390919e-02f, 8.22872370e-02f, 4.74302582e-02f, -5.67098111e-02f, 1.69156536e-01f, 3.40490974e-02f, 9.18594822e-02f,
  5.47326356e-02f, 9.99258757e-02f, 2.07848400e-02f, 6.43526837e-02f, -3.43321338e-02f, -8.62538889e-02f, 8.08650106e-02f, 1.18821926e-01f, 4.10071574e-02f, -2.64066178e-02f,
  9.75088328e-02f, 3.52861807e-02f, -1.61986396e-01f, -1.29866004e-01f, -7.23955259e-02f, -5.95758036e-02f, -1.33648947e-01f, -1.28921885e-02f, -1.48024127e-01f, 1.68102868e-02f,
  -4.43878071e-03f, 8.35771114e-02f, 2.79073678e-02f, 7.02800155e-02f, 3.14861245e-04f, 2.04138458e-02f, 1.25755861e-01f, -8.42205016e-04f, -1.31667033e-02f, 8.34999606e-02f,
  -4.27450873e-02f, -6.40824735e-02f, 2.53014658e-02f, -6.64109066e-02f, 2.79066386e-03f, 4.96379733e-02f, -3.75858322e-02f, -6.34632446e-03f, -3.86563949e-02f, 1.44463507e-02f,
  -3.15427743e-02f, -3.41808312e-02f, 7.83939138e-02f, 5.66475354e-02f, 3.26759857e-03f, 6.49957582e-02f, -4.46994714e-02f, -3.21981162e-02f, 2.22018249e-02f, -1.01086080e-01f,
  -2.15561539e-01f, 1.80414952e-02f, -8.99593085e-02f, 6.62655011e-02f, -2.69927736e-02f, -1.22731896e-02f, -4.09564376e-02f, 8.09772313e-03f, -6.54455321e-03f, 2.84275785e-02f,
  -1.06831908e-01f, -2.18895655e-02f, -3.94062735e-02f, 1.58051234e-02f, -5.46204224e-02f, -1.84581414e-01f, -2.74398979e-02f, -6.77441880e-02f, -2.07849834e-02f, -3.61165889e-02f,
  3.10175531e-02f, -1.43605590e-01f, -2.41258681e-01f, -2.29248136e-01f, -1.33284539e-01f, -1.98226720e-01f, -1.33249536e-01f, -1.39809683e-01f, -2.35631064e-01f, -2.47309461e-01f,
  -2.84483641e-01f, 2.14226935e-02f, -3.63204449e-01f, -4.09924626e-01f, -2.15908036e-01f, 3.27769592e-02f, 3.49739254e-01f, 3.09701506e-02f, -2.62820184e-01f, 3.61010656e-02f,
  1.74849946e-02f, -1.89834699e-01f, -3.67343009e-01f, -1.21364743e-01f, 1.34302825e-01f, 2.02498019e-01f, -6.54776096e-02f, -1.19324312e-01f, 8.37520976e-03f, 2.52233624e-01f,
  1.18011080e-01f, -1.23968907e-01f, -1.58152431e-01f, -1.20275244e-01f, -2.85443783e-01f, -2.06447214e-01f, -2.78109282e-01f, -1.42343655e-01f, 5.65426908e-02f, -1.69138342e-01f,
  -5.74977472e-02f, -2.41306975e-01f, -2.85686762e-03f, -6.46424815e-02f, -3.89798842e-02f, 8.06360990e-02f, 3.55956815e-02f, -6.63279369e-02f, 5.04304580e-02f, -5.36756366e-02f,
  -1.81184247e-01f, 3.58299799e-02f, -8.55959877e-02f, -4.44323830e-02f, -1.26127794e-01f, -3.29414103e-03f, -1.96821287e-01f, -5.76092415e-02f, -1.13565169e-01f, 4.16278057e-02f,
  1.14101402e-01f, -3.40248831e-02f, -2.13775724e-01f, 6.60516471e-02f, 3.05892248e-03f, -1.11226141e-01f, -7.71913351e-03f, 2.10169703e-02f, 2.64746882e-03f, -5.68502918e-02f,
  1.28942549e-01f, -7.75169060e-02f, 5.52773662e-03f, -6.39276057e-02f, 6.53231218e-02f, -5.17220162e-02f, -6.14557229e-02f, 7.55956396e-02f, 9.01485458e-02f, -2.22575478e-02f,
  -2.55370345e-02f, 1.28356993e-01f, -2.19672136e-02f, -2.78228801e-02f, 2.01882143e-02f, -1.41067905e-02f, 1.14802815e-01f, 7.25558773e-02f, -1.49001377e-02f, 8.45137089e-02f,
  -7.73498742e-03f, 5.22767417e-02f, -1.62861049e-01f, 9.30008888e-02f, 3.78416255e-02f, 5.38064353e-03f, 1.67395230e-02f, 8.09569359e-02f, -8.96247849e-02f, 1.87804811e-02f,
  -1.93281382e-01f, 1.83363631e-01f, -8.08509216e-02f, -4.75725234e-02f, -3.05213910e-02f, 2.00206079e-02f, -4.39365283e-02f, 1.58322722e-01f, -5.53862005e-02f, 3.65205407e-02f,
  4.07327600e-02f, 1.06260031e-01f, -6.64335638e-02f, 1.64061915e-02f, 9.50122923e-02f, -4.72127460e-02f, 1.72572434e-01f, -4.14146893e-02f, -4.42377776e-02f, 6.72806334e-03f,
  1.30130306e-01f, 2.01668978e-01f, 4.72864546e-02f, -2.02074251e-03f, 6.96221273e-03f, -7.07199052e-02f, -3.53907072e-03f, 4.74980697e-02f, 1.35765269e-01f, 1.86876178e-01f,
  -1.41432628e-01f, 4.32829976e-01f, 2.97024906e-01f, -2.77930439e-01f, 2.17325643e-01f, 3.41761887e-01f, 3.68179977e-01f, 6.92136809e-02f, -1.58727109e-01f, -7.75539782e-03f,
  2.49920473e-01f, -1.76858798e-01f, -2.27402493e-01f, -2.14293078e-01f, -1.32322788e-01f, -1.03486665e-01f, -2.58919328e-01f, -2.66377836e-01f, -1.59799606e-01f, 2.26079803e-02f,
  -9.44191217e-02f, -9.44835693e-02f, -1.41366094e-01f, -1.86675757e-01f, -2.04929322e-01f, -2.58293152e-01f, -1.06926030e-02f, 3.48290913e-02f, 1.17678463e-01f, -2.87116081e-01f,
  -8.49529281e-02f, 3.03234309e-01f, -1.16325863e-01f, -1.87483743e-01f, 3.45043764e-02f, -1.40949845e-01f, 2.51536667e-02f, -1.47564635e-02f, -5.49708400e-03f, -6.75527230e-02f,
  -2.08436255e-03f, -8.07228126e-03f, 2.01145243e-02f, -2.60385182e-02f, 2.28283126e-02f, 3.24124726e-03f, -2.77754944e-02f, -5.28763086e-02f, -2.55355500e-02f, 1.67389959e-01f,
  3.02859806e-02f, 1.67972133e-01f, 1.93576604e-01f, 1.18485756e-01f, 2.87592243e-02f, -7.93409869e-02f, 1.38971522e-01f, 4.10646247e-03f, 5.25631085e-02f, -2.55859256e-01f,
  -1.42139956e-01f, -5.19732311e-02f, 9.24026303e-04f, 3.13911140e-02f, -7.81633928e-02f, 2.32026912e-02f, -4.12449390e-02f, 2.43852362e-02f, -2.89919823e-02f, -1.22950293e-01f,
  4.69518155e-02f, 1.61572158e-01f, 1.67012643e-02f, 3.03135160e-02f, -7.75662512e-02f, 6.23684451e-02f, 7.58350194e-02f, 4.55771647e-02f, 1.07511058e-01f, 1.76019017e-02f,
  -1.39270192e-02f, -3.65962163e-02f, 3.63545902e-02f, -2.04677489e-02f, 1.21915102e-01f, 3.79894897e-02f, -2.67977715e-02f, -1.96985360e-02f, -4.79880981e-02f, 9.91719142e-02f,
  -2.85175920e-01f, 2.36913398e-01f, -1.79795668e-01f, -1.56207249e-01f, -7.05197304e-02f, 9.04645957e-03f, 1.07255876e-01f, 8.18142220e-02f, 9.29570869e-02f, 5.92643693e-02f,
  1.43069744e-01f, -4.99464609e-02f, 4.20723334e-02f, 5.29188178e-02f, -3.10131516e-02f, -3.06129977e-02f, -7.91227594e-02f, -5.71363345e-02f, 2.39334535e-02f, 7.83371478e-02f,
  -7.68183917e-02f, -4.87544052e-02f, -2.06505299e-01f, -1.17079705e-01f, -1.14315040e-02f, -1.91591203e-01f, -1.52046904e-01f, -8.09333846e-02f, -9.92695019e-02f, -4.00827467e-01f,
  4.09759998e-01f, 3.71010900e-01f, 1.47611097e-01f, 9.30050015e-02f, 8.07472020e-02f, 9.22616124e-02f, 1.65329874e-01f, -1.40392125e-01f, -1.72807246e-01f, 2.09528238e-01f,
  8.80257562e-02f, -1.32111624e-01f, -1.41357675e-01f, -1.07795209e-01f, -1.15803089e-02f, 4.57732193e-02f, -6.58930764e-02f, -1.08433150e-01f, -4.14237231e-02f, 9.50228199e-02f,
  4.36526686e-02f, 8.27372670e-02f, 2.13091254e-01f, -4.40971218e-02f, 2.15334043e-01f, 3.31772305e-02f, 1.12373181e-01f, 1.94167152e-01f, 1.91165477e-01f, 3.01144332e-01f,
  2.77867168e-01f, 1.98216081e-01f, -3.16826016e-01f, -9.58503783e-02f, 8.68307352e-02f, -1.16479822e-01f, -1.92481815e-03f, -7.63966739e-02f, -8.59049931e-02f, -1.00730218e-01f,
  4.18472253e-02f, 5.86827062e-02f, -3.50433849e-02f, -7.93269128e-02f, -4.40531000e-02f, -1.45957842e-01f, -6.81678131e-02f, -1.00922637e-01f, -1.91706061e-01f, 1.12028018e-01f,
  -3.49457376e-02f, 1.84447542e-01f, 1.46921854e-02f, -2.07426459e-01f, -1.28962770e-01f, -7.22631812e-02f, 7.96355978e-02f, -2.77871615e-03f, -8.27282146e-02f, -1.88847503e-03f,
  -3.35688025e-01f, -9.40656364e-02f, 6.13225885e-02f, -1.72900513e-01f, -1.77241668e-01f, -1.76974893e-01f, -1.00001559e-01f, 4.35563065e-02f, 1.47985341e-02f, -1.65676624e-02f,
  -4.93983272e-03f, -2.54284181e-02f, -8.29438120e-02f, -8.06856975e-02f, -1.54356986e-01f, -7.45160796e-04f, 9.98245031e-02f, -1.44114316e-01f, -1.29411697e-01f, -1.48341656e-02f,
  -1.46715331e-03f, -6.10160194e-02f, -5.26618846e-02f, -4.24859859e-02f, -4.28799838e-02f, -1.62429452e-01f, -1.72605708e-01f, -1.92621976e-01f, -5.03432974e-02f, -3.69186886e-02f,
  -5.80396689e-02f, -7.82021284e-02f, 1.75921693e-02f, 6.03560731e-02f, 1.96272388e-01f, 2.05257963e-02f, 1.88406378e-01f, 2.32118368e-02f, 9.27761868e-02f, -2.70453505e-02f,
  1.51575997e-01f, -5.21339253e-02f, 9.31130275e-02f, -2.02711932e-02f, -9.89704058e-02f, -4.99140173e-02f, 8.06998983e-02f, 2.32073627e-02f, -2.28548478e-02f, -3.91583294e-02f,
  -4.12263460e-02f, -1.29354626e-01f, -1.24228187e-01f, -1.47478923e-01f, -9.26453248e-02f, -3.13214064e-01f, -1.25802442e-01f, -3.64522524e-02f, -1.17854372e-01f, -2.69898534e-01f,
  2.27512151e-01f, 2.62657069e-02f, 2.86239479e-02f, -3.52980718e-02f, -5.81805408e-02f, 9.68363509e-02f, 1.27962381e-01f, -5.59154786e-02f, -1.08687699e-01f, 4.38217781e-02f,
  5.78930713e-02f, 9.21029374e-02f, 7.71440864e-02f, -2.98348442e-02f, 6.61595985e-02f, 5.05468398e-02f, -9.49354991e-02f, -7.99510181e-02f, -2.63928585e-02f, -9.53461453e-02f,
  -8.96118358e-02f, -3.61695960e-02f, -2.68522874e-02f, -1.73090085e-01f, -2.69814789e-01f, -3.45239602e-02f, -4.28603962e-02f, -8.08845758e-02f, -9.89510491e-02f, -2.15535805e-01f,
  -1.44375399e-01f, -1.51869446e-01f, -1.08422250e-01f, -1.73524499e-01f, 1.08176861e-02f, 3.25419530e-02f, 1.63373537e-03f, -2.08486795e-01f, 4.48350646e-02f, -6.83183596e-02f,
  2.81618256e-02f, -7.89534077e-02f, -1.48175508e-01f, -1.51935279e-01f, -1.55953750e-01f, -1.07597254e-01f, -9.55986902e-02f, -1.98884681e-01f, -8.03748220e-02f, -1.50417298e-01f,
  -1.73670366e-01f, -1.38869554e-01f, 4.31356457e-04f, 4.02362607e-02f, -1.01581015e-01f, 6.03360087e-02f, -3.40236649e-02f, -7.94107690e-02f, 4.73259687e-02f, 1.68337092e-01f,
  -1.65126011e-01f, -9.04172659e-02f, -1.61589146e-01f, -1.38651013e-01f, -6.82851821e-02f, -1.16161637e-01f, -1.07205532e-01f, 2.28759758e-02f, -1.70116036e-04f, -5.25376834e-02f,
  -1.41806796e-01f, -1.04231283e-01f, -5.99295050e-02f, -5.77229299e-02f, -1.53749198e-01f, -7.62257427e-02f, -6.76540881e-02f, -1.14742823e-01f, -2.18949273e-01f, -2.18908891e-01f,
  -1.66637316e-01f, -1.80771649e-01f, -1.30057216e-01f, -2.45626658e-01f, -2.34952226e-01f, -6.85917139e-02f, -1.90922424e-01f, -7.45139942e-02f, 4.19421270e-02f, 1.21497745e-02f,
  -8.73493552e-02f, -2.26412296e-01f, 9.42427963e-02f, -3.26722935e-02f, -3.04865576e-02f, -2.77886782e-02f, -7.89985340e-03f, -1.53572053e-01f, -8.44063610e-03f, 3.69183160e-02f,
  7.31430873e-02f, -1.06474981e-02f, -1.51590586e-01f, 1.52913702e-03f, 5.32247163e-02f, -6.57003839e-05f, 1.69923697e-02f, 7.58356303e-02f, -6.81098998e-02f, -9.96275023e-02f,
  -9.30711702e-02f, 1.60067737e-01f, 1.93015680e-01f, 2.24252701e-01f, 1.78978905e-01f, 1.77924067e-01f, 1.41134441e-01f, 5.49985655e-02f, 8.91296268e-02f, 3.32149029e-01f,
  -1.00433134e-01f, 2.58973360e-01f, 1.23040363e-01f, 1.37554601e-01f, 7.56446719e-02f, -4.51526530e-02f, 1.26931757e-01f, 1.35511875e-01f, 1.76285535e-01f, 6.83337972e-02f,
  9.84778330e-02f, 7.28506520e-02f, 1.37897760e-01f, -4.41209879e-03f, -1.27235755e-01f, -1.69324666e-01f, -1.06268205e-01f, -1.60299316e-01f, -1.98196828e-01f, -2.37749919e-01f,
  -7.35746697e-02f, -5.54042570e-02f, -4.25692722e-02f, -9.85174105e-02f, 3.94827016e-02f, 6.17943853e-02f, 2.10105684e-02f, -4.78181690e-02f, 1.88661553e-03f, -2.88549140e-02f,
  8.92873481e-02f, 1.03096232e-01f, -1.61602125e-01f, -2.07399968e-02f, 6.41480312e-02f, -1.46803148e-02f, 3.43640074e-02f, 3.92096862e-02f, 6.59493357e-02f, -1.08856328e-01f,
  2.38182638e-02f, 2.58982964e-02f, 7.73468018e-02f, 5.92498519e-02f, 1.04624465e-01f, 5.70536852e-02f, -4.81754132e-02f, 5.72957098e-02f, -3.93269723e-03f, -5.63480658e-03f,
  8.87165368e-02f, -4.52316962e-02f, 9.20350328e-02f, -2.87327617e-02f, -9.34791267e-02f, -5.47630489e-02f, 9.74494126e-03f, 3.08568180e-02f, 3.10777575e-02f, 5.76826893e-02f,
  2.26287693e-01f, 1.18387461e-01f, -2.68986691e-02f, 5.99464700e-02f, 2.40543131e-02f, -8.82437900e-02f, -1.21771589e-01f, -8.44089910e-02f, -9.07657519e-02f, -3.26806353e-03f,
  2.07245499e-02f, -1.48658184e-02f, 1.29751459e-01f, -1.98524371e-01f, -1.32195219e-01f, 8.92812535e-02f, -1.12086259e-01f, -1.65700182e-01f, -7.41942078e-02f, -8.11410025e-02f,
  -1.07666418e-01f, -1.27638295e-01f, -8.55460167e-02f, -1.16005212e-01f, -2.20839679e-01f, -5.00167608e-02f, -1.30419284e-02f, -1.54837584e-02f, -4.74024527e-02f, -8.79765972e-02f,
  3.40304673e-01f, -1.22240141e-01f, -1.65241525e-01f, 2.09387951e-02f, 1.75894611e-02f, 3.34543884e-02f, 1.64851725e-01f, -1.07090496e-01f, -1.32283255e-01f, -1.45360574e-01f,
  -5.95464893e-02f, 1.05426498e-02f, -7.22861215e-02f, 7.80055672e-02f, -4.57993522e-02f, -3.23656797e-02f, -1.32267788e-01f, -9.76690277e-02f, -1.51935905e-01f, -3.26753519e-02f,
  -1.01241007e-01f, 6.00992851e-02f, 9.33262613e-03f, 7.07690464e-03f, -3.56763564e-02f, -5.48039526e-02f, -1.14371665e-01f, -8.63304958e-02f, -1.42030910e-01f, -9.90161821e-02f,
  4.88615364e-01f, 7.01315030e-02f, 1.51221529e-01f, 4.20111269e-02f, 4.02186736e-02f, -8.40929598e-02f, 8.14429969e-02f, 8.23578835e-02f, 4.80836034e-02f, 1.71299979e-01f,
  8.77497494e-02f, 7.62138665e-02f, 1.17118411e-01f, 3.72534916e-02f, 7.20237419e-02f, 2.60311179e-02f, -6.67712316e-02f, 1.55378819e-01f, 1.26855582e-01f, 8.10312554e-02f,
  1.16837703e-01f, 5.87058812e-02f, 1.05195113e-01f, 1.63655356e-01f, -2.51627844e-02f, -3.19639146e-02f, 2.92159785e-02f, 1.16165884e-01f, 1.60321862e-01f, 1.29952624e-01f,
  2.32701018e-01f, 2.73065060e-01f, 7.47549068e-03f, -2.73138676e-02f, -3.26071642e-02f, -9.91578866e-03f, -1.35885943e-02f, -5.07755354e-02f, 4.94391099e-02f, 3.13806050e-02f,
  -8.73648152e-02f, -3.75632457e-02f, 7.57642761e-02f, 5.47912717e-02f, 5.58097400e-02f, 7.00259162e-03f, 2.67282315e-02f, 7.95182015e-04f, -1.24834897e-02f, 9.24905017e-02f,
  -2.21410766e-02f, -2.84444839e-02f, -8.55201390e-03f, -6.69960752e-02f, -6.05155490e-02f, -7.24719167e-02f, -8.87645315e-03f, 4.56046388e-02f, 7.09931776e-02f, 1.95828304e-02f,
  1.26744628e-01f, 1.16093315e-01f, 1.65529028e-01f, 2.97421925e-02f, 1.44656315e-01f, 6.75554797e-02f, 5.33103012e-02f, -4.88055125e-02f, 5.75973839e-02f, 1.20492384e-01f,
  -1.91958882e-02f, 1.77280217e-01f, 2.08396395e-03f, -9.43390653e-03f, 5.56177385e-02f, 8.35702866e-02f, 4.43058871e-02f, 2.60673780e-02f, 1.02752030e-01f, 2.35538911e-02f,
  1.20335883e-02f, 5.09689376e-02f, 7.87005201e-02f, 3.06816236e-03f, 9.86337960e-02f, 4.90353778e-02f, -6.56560576e-03f, 1.31520003e-01f, 4.35229056e-02f, 1.14120543e-01f,
  -2.75020868e-01f, -2.54756752e-02f, 5.12350500e-02f, 3.63165163e-04f, 1.28204720e-02f, -3.52033898e-02f, -4.83278632e-02f, -1.97271258e-02f, -8.70729238e-02f, -6.74865395e-02f,
  -6.20310195e-02f, -2.41428427e-02f, 1.79224107e-02f, -8.32877904e-02f, -4.33115102e-02f, -5.10501303e-02f, 5.15723974e-03f, -3.40883732e-02f, -8.82591903e-02f, -4.95673940e-02f,
  -9.40566286e-02f, -1.59358289e-02f, -1.15214989e-01f, -1.55411229e-01f, -1.01806968e-01f, -7.80087858e-02f, -1.04055218e-01f, 2.02810951e-02f, 1.32974843e-02f, -6.38245270e-02f,
  -3.26941580e-01f, -2.44967669e-01f, -2.80885011e-01f, 9.26052928e-02f, 1.01445131e-01f, -2.02999994e-01f, -3.60414535e-01f, -2.79745907e-01f, 9.37900841e-02f, 2.02343147e-02f,
  1.16807468e-01f, 2.03829810e-01f, 5.26630022e-02f, -1.88948363e-02f, -2.23366529e-01f, -1.31225482e-01f, -7.08774244e-03f, -1.18938647e-01f, -8.31475705e-02f, 4.55168150e-02f,
  2.61235505e-01f, 2.60279149e-01f, 6.87984750e-02f, 5.96648455e-02f, 2.47372016e-01f, 2.17544317e-01f, 1.47182778e-01f, 1.51007116e-01f, 7.96166342e-03f, 6.17070533e-02f,
  -1.03514425e-01f, -1.36174008e-01f, 2.92644240e-02f, 1.23858534e-01f, 9.61303785e-02f, -1.31900176e-01f, -8.99159014e-02f, -1.46042425e-02f, -6.98807091e-02f, -7.58600757e-02f,
  1.16169982e-01f, 2.19842177e-02f, 5.82818910e-02f, 1.33047402e-01f, 6.59074262e-02f, -1.26805291e-01f, -1.17878355e-01f, -2.22879708e-01f, -1.92988470e-01f, -1.19830415e-01f,
  1.41956061e-02f, 7.55523751e-03f, -2.27436453e-01f, -1.70498252e-01f, -1.80570617e-01f, 2.21340656e-02f, -1.18690737e-01f, -9.15613472e-02f, -1.64412156e-01f, -7.77153745e-02f,
  -1.41952354e-02f, -1.49783101e-02f, -1.41850282e-02f, -5.06985895e-02f, 2.74026915e-02f, 5.24397418e-02f, 6.42056391e-02f, 1.44768469e-02f, 1.12354546e-03f, -3.67973372e-02f,
  -5.10941111e-02f, -3.11239231e-02f, 3.81022915e-02f, 2.52855103e-02f, 1.06913529e-01f, 2.12228075e-02f, -8.61985534e-02f, -1.89220235e-02f, 1.79994032e-02f, -1.81892957e-03f,
  4.16764356e-02f, 1.02645624e-02f, 1.91949531e-01f, -3.47916372e-02f, 2.13697832e-02f, -6.93196952e-02f, 3.21701169e-02f, 4.90435772e-02f, -2.47925147e-02f, 2.60061808e-02f,
  2.84589589e-01f, 1.76696926e-01f, 2.09614560e-02f, 6.01262273e-03f, -5.80812525e-03f, 8.06992874e-02f, 5.53585812e-02f, -2.14421516e-03f, -3.34841534e-02f, -7.70949423e-02f,
  -1.11543953e-01f, -1.46248743e-01f, 1.26777560e-01f, -2.25301087e-02f, 2.52792612e-02f, -2.86436211e-02f, -1.80251077e-02f, -1.27139822e-01f, -7.16111585e-02f, -1.11656648e-03f,
  -4.31337431e-02f, -1.02133311e-01f, -2.08307788e-01f, -2.20519334e-01f, -8.10978189e-02f, -4.08026315e-02f, -8.40509087e-02f, -4.38598096e-02f, -2.00843975e-01f, -1.48636132e-01f,
  -1.83873996e-02f, -7.42349476e-02f, -3.89014304e-01f, -7.27334544e-02f, -1.83398291e-01f, -1.55096948e-01f, -2.83167511e-02f, 3.43484282e-02f, -4.40721400e-03f, -5.53712696e-02f,
  -8.72143134e-02f, -1.24607019e-01f, -1.44894451e-01f, -1.07070036e-01f, -5.56104742e-02f, -2.58875415e-02f, -1.04775287e-01f, -2.16333643e-01f, -2.08156466e-01f, -4.33319733e-02f,
  -7.76686370e-02f, -1.41967937e-01f, -1.11355036e-01f, -7.60927722e-02f, -8.67980346e-02f, -1.64266512e-01f, -1.49895102e-01f, -1.38477117e-01f, -1.01488143e-01f, -1.33948520e-01f,
  -1.76172778e-01f, -2.01766826e-02f, -7.27739036e-02f, -5.68189360e-02f, -4.13325578e-02f, -6.99987169e-03f, -4.18037809e-02f, -2.75208708e-02f, 2.83387136e-02f, -1.20754642e-02f,
  -5.23296967e-02f, -2.81894468e-02f, -2.18929276e-02f, -7.11806715e-02f, -6.62949085e-02f, -3.64729539e-02f, -6.54750466e-02f, -5.16127758e-02f, -1.29446629e-02f, 3.08778882e-02f,
  4.16077897e-02f, -1.79220699e-02f, -3.08196675e-02f, 6.29665926e-02f, 2.99031567e-02f, -2.44302675e-02f, -1.41969528e-02f, 3.17798485e-03f, 2.08886992e-02f, 8.30943510e-03f,
  1.22427203e-01f, -2.52485066e-03f, -3.27645205e-02f, -1.43291592e-03f, 6.84725568e-02f, 3.54459807e-02f, 3.01466626e-03f, -4.74490784e-03f, 1.55668911e-02f, -6.58333004e-02f,
  -2.13249121e-02f, 2.57660951e-02f, -2.54091644e-03f, 3.29434052e-02f, 7.63532752e-03f, -5.46690710e-02f, 4.70652431e-02f, 3.07596605e-02f, 6.20501973e-02f, 4.57122326e-02f,
  -9.35208946e-02f, -3.17312330e-02f, -5.36175817e-02f, 2.22917683e-02f, -8.04257463e-04f, -1.60128400e-02f, 1.92019790e-02f, 8.15086998e-03f, -6.96006268e-02f, -4.14439626e-02f,
  -1.10530466e-01f, 2.66164113e-02f, -2.94458084e-02f, -4.07663509e-02f, -5.59109151e-02f, -1.87004600e-02f, 3.50267207e-03f, 6.18165471e-02f, -3.40343788e-02f, -3.69884670e-02f,
  -1.06187053e-02f, 5.76544646e-03f, -6.38691857e-02f, 6.17515016e-03f, -6.14504032e-02f, -2.47072484e-02f, 7.05969408e-02f, -1.51650146e-01f, -2.33885739e-03f, 1.63844395e-02f,
  6.26053810e-02f, 8.33201706e-02f, 3.70483026e-02f, -1.25897080e-02f, 6.83589801e-02f, -3.92618515e-02f, -6.38921857e-02f, -2.41017025e-02f, 6.17748983e-02f, 8.68902653e-02f,
  4.91120666e-01f, -3.17976058e-01f, -4.41354543e-01f, -7.78573230e-02f, -2.00902849e-01f, -2.05364123e-01f, -1.27370402e-01f, 1.24459788e-01f, 4.75376621e-02f, -7.37848803e-02f,
  -8.83488953e-02f, 1.35465279e-01f, 3.69320251e-02f, 1.82906121e-01f, 2.08411872e-01f, -1.15381993e-01f, -1.54965013e-01f, 8.48222002e-02f, 2.83662617e-01f, 8.92609656e-02f,
  2.70112045e-03f, 1.93519056e-01f, 1.98965564e-01f, 1.25510141e-01f, -3.02374810e-01f, -1.20536737e-01f, -2.35402852e-01f, -2.56839216e-01f, -2.22177669e-01f, -3.07346225e-01f,
  -2.12992698e-01f, -1.53094798e-01f, 9.92745254e-03f, 9.70623717e-02f, -9.15095359e-02f, 1.22544870e-01f, 7.62306212e-04f, -1.90386102e-02f, -7.60148391e-02f, -2.56727566e-03f,
  -1.12958640e-01f, 5.71871176e-02f, -1.10122047e-01f, -1.28307655e-01f, -1.20777361e-01f, -6.61665350e-02f, -1.71844754e-02f, 1.97275355e-02f, 4.53980379e-02f, -1.61780253e-01f,
  -2.15035707e-01f, -2.00726256e-01f, -8.86666998e-02f, -8.45717564e-02f, -2.97371224e-02f, 6.53211474e-02f, -2.12640539e-01f, -1.68445349e-01f, 2.94366144e-02f, -2.10746780e-01f,
  2.00242363e-02f, -5.33875115e-02f, -4.60123904e-02f, -2.94642486e-02f, 1.15546338e-01f, -2.31536068e-02f, -6.50573894e-02f, -3.62361409e-02f, -2.81978324e-02f, -1.31187551e-02f,
  -1.35391718e-03f, -3.96924932e-03f, -5.72964475e-02f, -2.68307123e-02f, -1.28365010e-01f, -1.13248818e-01f, -9.22642276e-02f, 1.07039630e-01f, 6.34291396e-02f, 1.07847191e-01f,
  -4.52803783e-02f, -6.05007298e-02f, -2.37868391e-02f, 9.08750761e-03f, 4.63652872e-02f, 3.29201445e-02f, 6.85518049e-03f, -1.59383751e-02f, -4.80273217e-02f, -5.64252660e-02f,
  2.67011881e-01f, 2.53900677e-01f, -9.45043098e-03f, 6.98304847e-02f, -3.76872979e-02f, -8.85283798e-02f, 7.52762631e-02f, 1.92770753e-02f, -1.77625846e-02f, 1.08629446e-02f,
  -1.07072555e-02f, 5.47794066e-02f, -6.72457889e-02f, -7.15517253e-02f, -2.22857352e-02f, 7.55671859e-02f, 9.26146209e-02f, 1.08059337e-02f, 1.07251227e-01f, 3.17212120e-02f,
  2.57893954e-03f, 1.51981441e-02f, 4.14454900e-02f, 1.85800400e-02f, 1.95686538e-02f, 9.94402394e-02f, -1.04844689e-01f, 1.78812034e-02f, 8.25634003e-02f, 1.28884479e-01f,
  3.07038814e-01f, 2.08621487e-01f, -3.38803381e-01f, 2.29746565e-01f, -1.80874184e-01f, -3.58726501e-01f, -1.01807617e-01f, -1.69783115e-01f, 6.71083331e-02f, 1.21657863e-01f,
  -6.17206655e-03f, 6.52568489e-02f, 9.03587043e-02f, -1.33387912e-02f, -8.53754506e-02f, 7.35594928e-02f, 3.92438807e-02f, -1.86499372e-01f, -3.06252301e-01f, -2.39618018e-01f,
  7.00755268e-02f, 1.70943215e-01f, 1.36916321e-02f, -1.42342359e-01f, 1.12424977e-01f, 2.95482930e-02f, -9.78575926e-03f, -5.41727282e-02f, -1.95745289e-01f, 8.52558315e-02f,
  9.15608630e-02f, -2.89140344e-01f, -9.51383933e-02f, -1.94796957e-02f, 7.00307190e-02f, 1.52696148e-01f, 4.01853323e-02f, 1.01470109e-02f, 1.89011153e-02f, 6.57266751e-02f,
  4.07472700e-02f, -7.78282285e-02f, -4.12317589e-02f, -4.76487121e-03f, -7.84287527e-02f, -8.00125226e-02f, -7.89934099e-02f, -1.55924961e-01f, -8.30454081e-02f, -4.07196395e-03f,
  2.30719373e-02f, -1.41381040e-01f, -1.35365739e-01f, -1.33733138e-01f, -1.97827324e-01f, -1.12402745e-01f, -2.19483510e-01f, -1.98721603e-01f, -3.11347455e-01f, 1.68469757e-01f,
  4.52604407e-04f, 1.58591077e-01f, 8.93725231e-02f, 6.27916679e-02f, 1.23951025e-01f, 1.12001911e-01f, 1.23691767e-01f, 5.12691028e-02f, 1.04256958e-01f, 5.85049540e-02f,
  -3.02887615e-02f, 4.09699902e-02f, 7.60725001e-04f, 8.62831548e-02f, 1.52532225e-02f, 7.61893541e-02f, 1.04734637e-01f, 1.00862108e-01f, 7.25026662e-03f, 1.31791160e-01f,
  4.18299101e-02f, 1.02455877e-02f, 6.02891259e-02f, 3.10185850e-02f, -1.32247880e-01f, -5.85275851e-02f, -5.53490706e-02f, -4.38602418e-02f, 3.08306664e-02f, -8.56689587e-02f,
  3.14315557e-01f, -2.93219924e-01f, 2.26549879e-01f, -8.40738714e-02f, -4.02899384e-02f, 1.22084022e-02f, 1.53776869e-01f, 9.25858542e-02f, 1.73363969e-01f, 1.09183170e-01f,
  -1.21332377e-01f, 1.43321410e-01f, 4.84911762e-02f, 4.22492363e-02f, 9.53140948e-03f, 9.59519148e-02f, 2.39509711e-04f, -1.15647621e-01f, 2.09438545e-03f, 8.63529667e-02f,
  1.24787025e-01f, 1.48128852e-01f, 1.91082761e-01f, 2.44258031e-01f, 1.22677656e-02f, 5.04678255e-03f, 1.92265615e-01f, -1.35472249e-02f, -1.56510398e-01f, 4.21653479e-01f,
  -4.19682115e-01f, 3.33000958e-01f, 2.90088087e-01f, -3.36432308e-01f, -2.19331514e-02f, 1.57275513e-01f, 2.03552723e-01f, 6.78615179e-03f, -8.81212130e-02f, 8.19533020e-02f,
  5.01644500e-02f, -1.87855110e-01f, -3.36052803e-03f, -5.61779644e-03f, 3.58584453e-04f, 2.01538593e-01f, 2.24030495e-01f, -3.46916765e-02f, -1.85999632e-01f, -2.13182077e-01f,
  -9.96904001e-02f, -2.26418033e-01f, -2.35615537e-01f, -7.87475780e-02f, 6.95190430e-02f, -7.27440715e-02f, 1.87147304e-01f, -1.04521159e-02f, 1.94023132e-01f, 2.50210017e-01f,
  -3.85879129e-02f, 5.79032488e-02f, -1.59674659e-01f, -1.89315692e-01f, -3.54706012e-02f, -2.83888727e-02f, 9.10577457e-03f, -2.82815769e-02f, -1.54553885e-02f, 4.64067906e-02f,
  -3.78698036e-02f, 1.53484549e-02f, 3.89240719e-02f, -4.63866591e-02f, -8.10681581e-02f, -5.51594794e-02f, -6.50451109e-02f, -3.75550091e-02f, -5.53962551e-02f, 3.60588282e-02f,
  3.86212803e-02f, -1.86006024e-01f, -3.55107188e-02f, 3.59492786e-02f, 4.95058764e-03f, -1.47672221e-01f, -1.85938305e-04f, 9.00449697e-03f, -1.75827090e-02f, -4.64481190e-02f,
  -7.69461170e-02f, -4.44887877e-02f, 2.61278916e-03f, -1.83012839e-02f, -5.09190559e-02f, 2.07056440e-02f, 2.57877149e-02f, 1.59173738e-02f, -1.35771623e-02f, -3.13599147e-02f,
  1.16010807e-01f, -9.35191754e-03f, 1.06649091e-02f, 9.52981114e-02f, 3.27116959e-02f, -4.23203930e-02f, -6.37224456e-03f, 2.22859979e-02f, -2.67095584e-02f, 2.68467818e-03f,
  -7.88006485e-02f, -7.77337840e-03f, -4.20758650e-02f, -2.56894212e-02f, 1.14214651e-01f, 2.40838192e-02f, -8.01197514e-02f, -3.35081331e-02f, -4.16579284e-02f, 7.88865313e-02f,
  -3.14102560e-01f, -2.60088872e-02f, -1.73796803e-01f, -6.98436424e-02f, -2.54493169e-02f, -1.21213319e-02f, 4.64435527e-03f, 1.18635306e-02f, -3.97443436e-02f, 7.35843601e-03f,
  6.02176189e-02f, -2.67259162e-02f, 3.82817015e-02f, -5.97968437e-02f, -1.56334922e-01f, -5.53748198e-02f, -1.76126152e-01f, -1.38465315e-01f, -1.31679520e-01f, -4.34321016e-02f,
  -3.75171900e-02f, -2.69183636e-01f, -3.36152852e-01f, -1.08946852e-01f, -1.65325597e-01f, -2.84713179e-01f, -1.53378144e-01f, -1.28007606e-01f, -2.23887041e-01f, -1.88912749e-01f,
  1.10534728e-01f, -5.13948917e-01f, 3.42533618e-01f, -2.79941350e-01f, 1.20755294e-02f, 1.48209706e-01f, -1.32515207e-01f, -6.10453933e-02f, -1.00034386e-01f, -2.58693218e-01f,
  -1.42507851e-01f, 2.41297528e-01f, 1.40236199e-01f, 1.79890364e-01f, 2.98229337e-01f, -1.74592957e-01f, -6.58104420e-02f, 4.87750888e-01f, 6.06112003e-01f, 1.54544458e-01f,
  -2.40253076e-01f, -1.20320968e-01f, 8.92123282e-02f, 4.74506132e-02f, -4.69251186e-01f, 7.89449215e-02f, -1.78120881e-01f, -2.41680384e-01f, -1.62348911e-01f, -3.57991427e-01f,
  7.74898231e-02f, -3.02260220e-01f, 1.99671462e-01f, -2.86592245e-02f, -1.10925049e-01f, -4.13914882e-02f, 2.00262871e-02f, -1.87988132e-02f, -2.01816838e-02f, -9.24609601e-02f,
  -7.88401067e-02f, -1.72946008e-03f, -9.90672112e-02f, -7.90776238e-02f, -1.42611176e-01f, -1.43032223e-01f, -2.53773741e-02f, 5.85708804e-02f, 2.55181808e-02f, -1.49526432e-01f,
  -2.12605119e-01f, -9.79075432e-02f, 8.70415196e-02f, -4.11775894e-03f, -1.12857558e-01f, 1.68777883e-01f, -6.54822737e-02f, -6.48920462e-02f, 4.82994094e-02f, -3.55573356e-01f,
  -4.90590334e-02f, -5.65868467e-02f, -1.33820310e-01f, 8.49397928e-02f, -5.19711338e-02f, 6.75526634e-02f, 4.88468371e-02f, -9.00046080e-02f, 2.21587047e-02f, -1.12450838e-01f,
  8.14555436e-02f, 3.97275314e-02f, 1.26009896e-01f, -1.11366875e-01f, -1.15316890e-01f, 1.43055888e-02f, 3.96376774e-02f, -4.36295867e-02f, -3.53053100e-02f, 8.61285850e-02f,
  8.08152258e-02f, -4.06605341e-02f, 1.14885181e-01f, 9.70080793e-02f, 1.07498705e-01f, 1.24140963e-01f, -4.69227508e-02f, -1.07087300e-03f, 5.18602924e-03f, 5.68883270e-02f,
  7.78844506e-02f, 2.47214064e-01f, -4.80211414e-02f, -1.99049134e-02f, -7.23339766e-02f, -3.90541293e-02f, 1.37941688e-02f, -9.88258980e-03f, 7.88680613e-02f, 3.52815762e-02f,
  5.05543575e-02f, 3.45214978e-02f, -4.24203277e-02f, 2.05773246e-02f, 1.11381151e-01f, 3.83256674e-02f, -2.81259157e-02f, 1.83690026e-01f, -1.54636241e-02f, -1.05214693e-01f,
  -1.83077142e-01f, 9.47460718e-03f, 1.76589951e-01f, 1.52347088e-01f, -1.50663063e-01f, 2.44848251e-01f, 1.35404170e-01f, 1.05420962e-01f, 2.69127488e-01f, -3.73806246e-02f,
  1.66283846e-01f, -5.43002933e-02f, -3.96061510e-01f, 5.80974407e-02f, -1.33978993e-01f, -1.49569169e-01f, -1.05671078e-01f, 7.87901599e-03f, 8.47242251e-02f, -3.42794731e-02f,
  7.35699311e-02f, 2.18799725e-01f, 4.13793549e-02f, 5.04968241e-02f, 3.90085503e-02f, -2.09852025e-01f, -2.76737154e-01f, -1.47039458e-01f, 1.85347944e-02f, 1.71733469e-01f,
  2.17889205e-01f, 1.36279151e-01f, 8.19193348e-02f, 2.48709898e-02f, -8.56080428e-02f, 1.79891922e-02f, -2.12125435e-01f, -9.15302262e-02f, -1.41061261e-01f, -2.75238365e-01f,
  1.29079178e-03f, -8.73481110e-02f, -1.70923658e-02f, 2.69466639e-02f, -6.19949326e-02f, 1.52667001e-01f, 1.35478675e-01f, -1.26472414e-02f, 3.06629692e-04f, 5.68035292e-03f,
  -5.09968959e-02f, 6.76637813e-02f, 4.51479517e-02f, 3.16636823e-02f, -4.61867033e-03f, 4.80730683e-02f, -6.78142980e-02f, -1.45002618e-01f, -1.79866403e-01f, -7.83745348e-02f,
  -2.31294613e-02f, -1.24684207e-01f, -2.16705814e-01f, -9.45796445e-02f, -2.06115782e-01f, -6.88190311e-02f, -1.90040588e-01f, -1.39973268e-01f, -1.47694722e-01f, -4.18327823e-02f,
  6.13050237e-02f, -3.62985916e-02f, -1.32183552e-01f, -6.89000040e-02f, 7.45825395e-02f, -1.15570687e-01f, 6.83032721e-03f, -7.88381696e-02f, -8.92466456e-02f, -4.52870242e-02f,
  6.80576358e-03f, -1.95755884e-02f, -5.41804358e-02f, -9.64870378e-02f, 2.82719638e-03f, -1.43766373e-01f, -9.40624848e-02f, -8.58349651e-02f, -1.45911559e-01f, -7.97543749e-02f,
  -7.17995092e-02f, -1.47315279e-01f, -5.84010445e-02f, -1.48684848e-02f, -6.01506867e-02f, -5.39040901e-02f, 1.55115472e-02f, 2.59470902e-02f, 1.12304635e-01f, 9.34602991e-02f,
  2.72197425e-01f, 6.34142291e-03f, 4.87549938e-02f, -5.15177101e-02f, -1.72470912e-01f, -2.08813399e-02f, -4.82283793e-02f, -2.67997254e-02f, -7.49849305e-02f, 5.13275936e-02f,
  -1.32954806e-01f, 1.62998624e-02f, -2.27703117e-02f, -5.22733964e-02f, 3.41239162e-02f, -7.08990451e-03f, -5.54125011e-03f, -1.63817197e-01f, -1.61748767e-01f, -7.96136260e-02f,
  -6.18037805e-02f, -7.03961030e-02f, 3.97747047e-02f, -2.27660034e-02f, -6.90982491e-02f, 8.73838589e-02f, 2.45352332e-02f, 2.86688711e-02f, 6.16773181e-02f, 1.39308557e-01f,
  5.67602813e-01f, -4.12805468e-01f, -2.13240668e-01f, 1.42399967e-01f, -1.83243692e-01f, -2.41150677e-01f, -3.94728810e-01f, -7.79507756e-02f, 1.28744483e-01f, -2.57840037e-01f,
  6.28113979e-03f, 4.33876902e-01f, 3.42506140e-01f, 1.94890037e-01f, 1.49946988e-01f, -3.19528848e-01f, -2.15343028e-01f, 1.38333738e-01f, 1.98646441e-01f, -1.10171944e-01f,
  -7.14893639e-02f, 4.26297188e-02f, 2.09331974e-01f, 4.77263629e-02f, -2.84573317e-01f, 6.33343384e-02f, -1.98479861e-01f, -1.81708261e-01f, -2.15654284e-01f, -3.10308009e-01f,
  -1.77053645e-01f, -2.24751040e-01f, 8.34892988e-02f, 2.39449382e-01f, -7.03348592e-02f, 6.87652230e-02f, -1.37757450e-01f, -7.18057454e-02f, 5.19609377e-02f, -1.31352440e-01f,
  6.15690723e-02f, 6.21919222e-02f, 8.38303864e-02f, -5.72614148e-02f, -1.19411685e-01f, -3.58978100e-02f, 9.93348937e-03f, 5.47058769e-02f, 5.91042750e-02f, -1.77069873e-01f,
  -1.06238022e-01f, -1.75692886e-02f, -7.00825006e-02f, -1.45980775e-01f, -1.65815204e-01f, 1.57884553e-01f, -3.47849190e-01f, -1.79692209e-01f, -9.34425090e-03f, -3.35414499e-01f,
  4.86566722e-02f, 4.17113714e-02f, -2.94561149e-03f, -4.65991311e-02f, -1.31969014e-03f, -2.78383810e-02f, -2.55107563e-02f, -8.95665959e-02f, -1.51171563e-02f, -1.06036268e-01f,
  7.37716677e-03f, 3.22926752e-02f, -2.54670382e-02f, -5.59730902e-02f, -1.66830085e-02f, 1.15075549e-02f, 9.60657001e-03f, 2.73178443e-02f, -1.40983835e-02f, 2.97723059e-02f,
  5.87869994e-02f, 1.61585528e-02f, 2.98109427e-02f, 4.80035879e-02f, -2.77701002e-02f, 4.23463881e-02f, 3.10922097e-02f, 9.77297872e-03f, 2.56238319e-02f, -1.05216326e-02f,
  2.27128953e-01f, 2.64108092e-01f, -1.52227923e-01f, 5.56490459e-02f, -7.30633438e-02f, 2.98823649e-03f, -1.41866850e-02f, -5.30431084e-02f, 4.56959233e-02f, 5.65015636e-02f,
  -1.38656095e-01f, 9.65631530e-02f, 9.15549323e-03f, -3.96025330e-02f, -2.62681860e-02f, -1.00346774e-01f, -4.38006315e-03f, 8.11175928e-02f, 1.11466963e-02f, -1.40611529e-01f,
  -2.49378029e-02f, -1.05675943e-02f, 1.08258918e-01f, -2.41134949e-02f, -7.30186626e-02f, 1.81886420e-01f, -2.08073169e-01f, -1.80154115e-01f, 9.13653299e-02f, -1.95853502e-01f,
  -1.87116355e-01f, -2.32678160e-01f, -1.57587335e-01f, -1.18663974e-01f, -1.27959713e-01f, -7.59229064e-02f, -1.81296960e-01f, -3.43955704e-03f, -5.18125035e-02f, -2.63757050e-01f,
  -8.45413506e-02f, 1.52975634e-01f, 3.80183309e-02f, 8.03878084e-02f, 4.12424058e-02f, -2.87122339e-01f, -3.05363864e-01f, -4.97238114e-02f, 2.46661022e-01f, 1.58342630e-01f,
  -1.24638723e-02f, 2.16963142e-02f, 1.07450552e-01f, 6.71743304e-02f, -9.72699150e-02f, 1.00587578e-02f, -1.63789928e-01f, -1.28264338e-01f, -1.64444387e-01f, -2.74973154e-01f,
  -3.48002017e-02f, -9.38839912e-02f, 8.25196058e-02f, 7.94514120e-02f, -2.32896600e-02f, -2.41598412e-02f, 4.56213392e-02f, -4.29999828e-02f, 2.85419077e-02f, -3.19739506e-02f,
  1.29301948e-02f, 2.06980258e-02f, -1.21695092e-02f, -1.83354001e-02f, -7.09879100e-02f, 1.00874761e-02f, 3.48321795e-02f, 7.10607320e-02f, -5.07290401e-02f, 2.48474814e-03f,
  -1.01466298e-01f, -1.39798045e-01f, 5.36233746e-02f, -3.94009389e-02f, 2.03329381e-02f, 9.56671387e-02f, 8.13585706e-03f, 3.19913290e-02f, 4.79364321e-02f, -1.57725796e-01f,
  -3.80226523e-02f, -2.06261612e-02f, -6.13171384e-02f, 6.35048822e-02f, 2.32840739e-02f, 1.58302598e-02f, 1.99002185e-04f, -1.67739131e-02f, 8.15032795e-02f, 2.22694911e-02f,
  8.23822021e-02f, 6.50836108e-03f, 9.26891565e-02f, 1.76772177e-02f, -1.96948573e-02f, -3.16543244e-02f, -2.84072701e-02f, 4.06003110e-02f, -5.79867363e-02f, -1.81664303e-02f,
  -2.61865382e-04f, -4.27963436e-02f, -4.58245613e-02f, 2.01379303e-02f, -9.23721567e-02f, 2.85489187e-02f, -6.17164187e-02f, 8.86144340e-02f, 4.18351442e-02f, -4.69099469e-02f,
  1.90896243e-01f, 4.93276305e-03f, -1.21287555e-01f, 8.80188048e-02f, -3.52672674e-02f, 8.84020422e-03f, -3.15776542e-02f, 1.33240586e-02f, 5.04073594e-03f, -7.14932382e-02f,
  -5.24799936e-02f, 4.33329865e-02f, -8.87136534e-02f, 2.58169565e-02f, 4.02113087e-02f, -5.24549074e-02f, -6.34909347e-02f, -2.55042575e-02f, -8.23486894e-02f, -4.45542037e-02f,
  -1.76565066e-01f, -1.08548954e-01f, -3.15717049e-02f, -4.95291241e-02f, 2.17417888e-02f, 6.29977435e-02f, 5.08958753e-03f, 4.92669903e-02f, 4.40823957e-02f, -1.06214069e-01f,
  1.74734533e-01f, -2.45125264e-01f, -2.19061717e-01f, -3.41339083e-03f, -1.17517009e-01f, -9.25551206e-02f, -2.14434698e-01f, -4.91210483e-02f, 1.14867766e-03f, -2.37948447e-01f,
  -1.09119140e-01f, 8.91210288e-02f, 2.83491109e-02f, 1.19224330e-02f, 9.12253466e-03f, -2.51179516e-01f, -2.10786268e-01f, -4.15542349e-02f, 3.42647359e-02f, -9.91249233e-02f,
  -1.61568642e-01f, -1.17282197e-01f, -3.39625007e-03f, -5.67112863e-03f, -1.21903293e-01f, 6.13564346e-03f, -1.58868939e-01f, -1.43589571e-01f, -1.27066225e-01f, -2.12622866e-01f,
  -3.40307914e-02f, 5.57641760e-02f, 1.01928394e-02f, 5.10637881e-03f, -2.16682125e-02f, -8.86163302e-03f, 2.43723262e-02f, -6.37631107e-04f, -1.71654020e-02f, -8.93568546e-02f,
  -4.48558815e-02f, 2.46257726e-02f, 9.94673744e-02f, -4.49652337e-02f, -1.24274399e-02f, -5.46735935e-02f, -1.29510134e-01f, -5.19434065e-02f, -6.04311414e-02f, -8.90255794e-02f,
  -2.32997850e-01f, -3.74280661e-02f, 6.32007495e-02f, -7.21327402e-03f, 1.28958737e-02f, 9.28624123e-02f, -9.88460034e-02f, -4.61394526e-02f, 7.47298822e-02f, -8.44906196e-02f,
  5.82312346e-02f, 5.55014461e-02f, -5.46358526e-02f, 1.42596317e-02f, 2.41175760e-02f, -3.87923047e-03f, 4.63106893e-02f, -8.83095246e-03f, 2.31124610e-02f, -3.77007648e-02f,
  -3.15317065e-02f, -5.08835278e-02f, 5.20830564e-02f, -1.70298479e-02f, 2.55597290e-02f, 3.87909934e-02f, -1.36526143e-02f, 2.57685483e-02f, 7.16349036e-02f, 2.34749466e-02f,
  1.03838239e-02f, -6.27610320e-03f, 8.58345926e-02f, 6.14104308e-02f, -6.69404911e-03f, -2.08484530e-02f, 1.60715748e-02f, 6.76599611e-03f, 3.07953153e-02f, -4.95059490e-02f,
  2.29562297e-01f, -4.65572178e-02f, 6.30062446e-02f, 5.33095784e-02f, 4.71626706e-02f, -1.43694123e-02f, -3.78273278e-02f, -3.31840850e-02f, 5.05644865e-02f, -3.86396646e-02f,
  -4.31525670e-02f, 2.67464947e-02f, 2.29090787e-02f, -9.12993308e-03f, 3.37976664e-02f, 4.35689231e-03f, -7.45968148e-02f, 3.85341630e-03f, 5.36273466e-04f, -7.29809850e-02f,
  -1.35326788e-01f, 5.52230813e-02f, 1.14626311e-01f, 6.47925660e-02f, 6.36621565e-02f, 2.20075682e-01f, 3.87479626e-02f, 3.16876061e-02f, 2.23302737e-01f, 2.18344629e-02f,
  -5.11849642e-01f, -4.99904126e-01f, 1.64361822e-03f, -3.51056874e-01f, -2.45154589e-01f, -1.69251680e-01f, -5.15080690e-01f, -2.67483801e-01f, -1.17876127e-01f, -4.21455026e-01f,
  -1.51563302e-01f, 1.58852823e-02f, -4.21443814e-03f, 3.17018740e-02f, -2.60277838e-02f, -3.91088426e-01f, -1.20179780e-01f, 4.36365753e-02f, 7.86532909e-02f, -1.73243761e-01f,
  -2.37025738e-01f, -2.69673437e-01f, -4.18851934e-02f, 1.08380700e-02f, -3.12134534e-01f, -1.29261360e-01f, -8.40480775e-02f, -1.95162550e-01f, -4.37818803e-02f, -3.62765849e-01f,
  -2.25471467e-01f, -6.82892278e-02f, 1.15475230e-01f, 7.88027719e-02f, -8.72377902e-02f, -1.91377755e-02f, -7.22114816e-02f, 3.13014910e-03f, 9.29800048e-02f, -6.44439757e-02f,
  4.65532057e-02f, 3.35943140e-02f, 5.70508502e-02f, 2.68636718e-02f, -1.59744576e-01f, 3.93985659e-02f, 5.42193130e-02f, 7.10808188e-02f, 8.57777596e-02f, 1.29859045e-01f,
  1.93774123e-02f, 6.18785284e-02f, 1.30948350e-02f, 1.21579178e-01f, 1.41031682e-01f, 1.27534896e-01f, 3.85525003e-02f, 1.25228211e-01f, 2.31500715e-01f, -2.23578185e-01f,
  -1.66975968e-02f, 2.00002361e-02f, 4.87990156e-02f, -2.56494265e-02f, 2.14845594e-03f, 6.68215826e-02f, 2.05815211e-02f, -5.39595485e-02f, 1.86098441e-02f, -9.53401849e-02f,
  -8.81691463e-03f, -6.22646250e-02f, 8.31396133e-03f, -9.66969877e-02f, 6.68846630e-03f, -4.50137779e-02f, 1.82496309e-02f, -6.64819330e-02f, 3.15608345e-02f, 4.64996845e-02f,
  3.12292948e-02f, 9.79851782e-02f, 8.62175003e-02f, 3.65552166e-03f, 9.13469791e-02f, 6.46524802e-02f, 7.50836506e-02f, 3.62575874e-02f, 5.31333201e-02f, -5.33709070e-04f,
  -2.88741589e-01f, 3.49499941e-01f, -3.15346956e-01f, 1.37604773e-01f, -3.07748392e-02f, 1.58915356e-01f, -1.53726973e-02f, 9.78467241e-02f, 6.53371811e-02f, -1.18994907e-01f,
  1.23983428e-01f, -1.08083941e-01f, -1.01681218e-01f, 3.89555506e-02f, -1.37530770e-02f, 2.61555030e-03f, -3.11064702e-02f, -5.69498427e-02f, 2.01704398e-01f, 8.24876726e-02f,
  1.31743491e-01f, -3.95900048e-02f, -1.28383175e-01f, -2.84253061e-02f, -2.92606819e-02f, -4.76370975e-02f, -7.25424439e-02f, -9.02289152e-02f, 6.32957742e-02f, -4.12297517e-01f,
  2.24822104e-01f, -2.25215837e-01f, 4.76893075e-02f, 1.42755345e-01f, 9.10846069e-02f, -1.31526515e-01f, -4.91509795e-01f, -2.22945422e-01f, 7.58736134e-02f, -2.44651049e-01f,
  5.94487265e-02f, 2.87295669e-01f, 7.90634155e-02f, -4.55060080e-02f, -3.20231616e-01f, -4.97244239e-01f, -4.00889069e-01f, -1.41804993e-01f, -4.68534753e-02f, -1.37387797e-01f,
  3.35942581e-03f, -2.85703540e-02f, -4.54350449e-02f, -1.17244177e-01f, -6.93850070e-02f, 6.81080371e-02f, -1.06143452e-01f, -4.77133244e-02f, -2.30135128e-01f, -1.10750131e-01f,
  -2.22147211e-01f, -9.94958729e-02f, 2.72152317e-03f, 8.00120234e-02f, 1.03422463e-01f, 7.79421851e-02f, -5.52147143e-02f, 1.00648720e-02f, 7.40166008e-02f, -8.74871835e-02f,
  5.42503782e-02f, 5.00991940e-02f, 7.53674377e-03f, -2.40081688e-03f, -1.16839886e-01f, -8.11685100e-02f, -4.54852022e-02f, -3.60442102e-02f, -3.18227448e-02f, -1.11190155e-01f,
  -4.10779640e-02f, -2.39473451e-02f, -1.05647437e-01f, -1.26143247e-01f, -1.21049330e-01f, 7.58895651e-02f, -1.17736362e-01f, -6.11013882e-02f, -1.87973961e-01f, -1.17726147e-01f,
  -1.86784953e-01f, -6.80451617e-02f, -9.88752544e-02f, 1.42113222e-02f, 4.90407161e-02f, -1.06450506e-02f, 2.04387847e-02f, -1.26378253e-01f, 4.91377003e-02f, -2.90404297e-02f,
  2.84071863e-02f, -1.74363572e-02f, 8.12223926e-02f, -2.10109606e-01f, -7.63151646e-02f, -4.93051782e-02f, -5.69252111e-03f, -1.03675790e-01f, -6.89996332e-02f, -4.63559031e-02f,
  1.72826741e-02f, -1.21365869e-02f, 2.27460172e-02f, -8.07886794e-02f, -5.89163005e-02f, -1.47377342e-01f, 6.85221702e-03f, -2.95252865e-03f, -1.29269481e-01f, -1.43575996e-01f,
  1.06112994e-01f, 6.80748001e-02f, -7.37484396e-02f, -9.17709991e-02f, -3.24343517e-02f, 5.66771552e-02f, 1.08259834e-01f, 9.17219073e-02f, 1.39793992e-01f, 1.27397269e-01f,
  -1.59874856e-01f, -7.72764981e-02f, -1.59491763e-01f, 4.28833142e-02f, -8.07846934e-02f, -3.72341052e-02f, -2.15038702e-01f, 2.29449328e-02f, -8.13552663e-02f, 9.84715521e-02f,
  -9.49727371e-02f, -1.96077123e-01f, -1.48369759e-01f, -9.43024531e-02f, -1.46425053e-01f, -2.79170778e-02f, -2.03702718e-01f, -9.15741846e-02f, -2.17934877e-01f, -3.13723475e-01f,
  -3.01977694e-01f, -1.16181903e-01f, 5.02513170e-01f, -2.06656575e-01f, -8.76826122e-02f, -1.84120610e-01f, -5.28573990e-01f, -4.98003185e-01f, -1.83620676e-01f, -9.43988189e-02f,
  2.95729935e-02f, 1.46289080e-01f, 4.27936226e-01f, 7.25533590e-02f, -2.25894928e-01f, -2.09371462e-01f, -6.32241219e-02f, 1.26733050e-01f, -2.37846136e-01f, -5.07875562e-01f,
  -2.78910577e-01f, -1.56272948e-01f, -1.15675375e-01f, -1.31241828e-01f, 6.00295812e-02f, 1.14951275e-01f, 2.49285758e-01f, 3.20281237e-02f, 8.94488618e-02f, 3.47557783e-01f,
  2.93177396e-01f, -2.01899379e-01f, 8.64896029e-02f, -7.75616243e-02f, -3.19010317e-02f, -5.08444756e-02f, -8.60976651e-02f, 8.86286348e-02f, -6.13450743e-02f, 4.73953923e-03f,
  2.86079012e-02f, -7.98452646e-02f, 5.31739704e-02f, -1.39074130e-02f, -1.95700288e-01f, -1.25157699e-01f, -9.65616256e-02f, -1.61364809e-01f, 3.68801020e-02f, -1.02476053e-01f,
  -2.63115913e-02f, -9.27806497e-02f, 1.90938711e-01f, -5.89279905e-02f, -6.84646070e-02f, 2.22430885e-01f, 8.64798352e-02f, -2.84170988e-03f, 1.67859286e-01f, -6.98687974e-03f,
  -1.29689097e-01f, 2.88993478e-01f, 7.79868960e-02f, 2.03635972e-02f, -6.27778322e-02f, 6.77942708e-02f, 3.02355886e-02f, -6.46092668e-02f, -3.42357084e-02f, 2.87081301e-02f,
  3.02411523e-02f, 4.42484654e-02f, -8.82031396e-02f, -1.45032899e-02f, 8.15419331e-02f, -2.83036381e-02f, 8.85939822e-02f, 3.14933173e-02f, 2.55784374e-02f, 2.17257980e-02f,
  2.17441376e-02f, 1.07730530e-01f, 1.10119194e-01f, -1.21654272e-01f, -1.54542569e-02f, -1.72514413e-02f, 7.02593774e-02f, 4.37396578e-03f, 2.72457581e-02f, -4.02674936e-02f,
  2.40133226e-01f, 9.67706889e-02f, 1.17470764e-01f, -1.14191115e-01f, -7.46141821e-02f, 6.58945069e-02f, -6.89506996e-03f, -8.64195004e-02f, 1.52221605e-01f, -2.15202700e-02f,
  5.23965247e-02f, -8.05683210e-02f, 1.37205586e-01f, 2.59700231e-02f, -1.58325583e-01f, -3.88145894e-02f, -1.91378653e-01f, 6.97308853e-02f, 5.13649136e-02f, -1.19430222e-01f,
  -1.12461716e-01f, -1.77081421e-01f, 7.84579813e-02f, 1.28878951e-01f, -6.84311092e-02f, 6.55260608e-02f, 2.37308115e-01f, 1.44334957e-01f, 6.40926510e-02f, -6.25704676e-02f,
  3.36541355e-01f, 2.92485297e-01f, 2.84376413e-01f, -1.33588105e-01f, -2.33900517e-01f, -7.23956004e-02f, 1.00126505e-01f, -4.82593384e-03f, -2.53555387e-01f, 5.74478880e-02f,
  -1.41769409e-01f, -2.49647379e-01f, -1.03965752e-01f, -3.13702342e-03f, 1.57646388e-01f, 1.88570529e-01f, 1.09275341e-01f, 2.46087015e-01f, 1.73902027e-02f, -1.37395784e-01f,
  -1.60437778e-01f, -5.18102711e-03f, 1.04808636e-01f, 4.29293923e-02f, 2.66166665e-02f, -1.53015286e-01f, 6.19390905e-02f, 6.16250858e-02f, 1.69017166e-01f, 2.61561215e-01f,
  2.25086659e-01f, 3.79256099e-01f, -2.29819760e-01f, -7.21903443e-02f, -4.70794402e-02f, -4.03075852e-02f, -1.17086768e-01f, -9.39446166e-02f, -9.45182741e-02f, 1.61673054e-01f,
  3.82587663e-03f, 4.22280431e-02f, 9.17128287e-03f, -6.47950694e-02f, -2.42646914e-02f, -3.67222317e-02f, -1.44111807e-03f, 1.97638929e-01f, 1.47238880e-01f, 1.58228338e-01f,
  -9.93748233e-02f, 2.24675220e-02f, 1.58757865e-01f, -8.93499628e-02f, 1.47832423e-01f, -1.51897311e-01f, 1.14577182e-01f, 1.58934355e-01f, -5.34391850e-02f, 1.56141281e-01f,
  -1.40473589e-01f, 6.80831596e-02f, -2.77599669e-03f, 4.45287488e-02f, -3.89661193e-02f, -1.06961720e-01f, 3.60580869e-02f, 3.62795964e-03f, 1.28467539e-02f, 1.01482393e-02f,
  -5.12504987e-02f, -1.07225493e-01f, -1.85287162e-03f, -5.83444675e-03f, -1.72092468e-01f, -6.72750771e-02f, -1.10880248e-01f, -1.22658208e-01f, 3.14991698e-02f, -5.90134710e-02f,
  3.06357979e-03f, 5.50169200e-02f, -1.16399147e-01f, -4.80981395e-02f, 4.59350422e-02f, -5.78910857e-02f, -1.53423741e-01f, -1.20276742e-01f, -1.80073172e-01f, -1.42893925e-01f,
  -2.13097334e-01f, -6.60217628e-02f, -1.03680924e-01f, 3.57505642e-02f, 2.68525686e-02f, -5.28739542e-02f, -1.21603385e-01f, -1.03733115e-01f, -1.33557254e-02f, 5.52599840e-02f,
  1.24476664e-01f, -2.05901015e-04f, -6.59552664e-02f, -7.25169107e-02f, -2.12539881e-01f, -1.75181299e-01f, -1.78582594e-01f, -1.69874579e-01f, -1.74728870e-01f, -5.17516583e-02f,
  -2.00439125e-01f, -2.06364721e-01f, -2.25550592e-01f, -2.78086513e-01f, -4.13308948e-01f, -4.42821026e-01f, -1.21284381e-01f, -1.86729640e-01f, -2.24210426e-01f, -2.63356149e-01f,
  2.57452488e-01f, -1.04125999e-01f, 2.76108086e-01f, 1.53121099e-01f, -3.51341963e-01f, -2.65016437e-01f, -3.23087782e-01f, -3.23596783e-03f, 9.02760401e-02f, 2.82392055e-02f,
  -1.50405616e-01f, -3.93140353e-02f, 1.49438187e-01f, 5.32871224e-02f, 6.26005381e-02f, 3.29199098e-02f, 1.11383066e-01f, 2.03715667e-01f, 3.35557275e-02f, -2.56144464e-01f,
  -2.23377869e-01f, -1.77092403e-02f, 1.60294086e-01f, 1.38737097e-01f, 4.53121513e-02f, -1.77497454e-02f, 1.72999471e-01f, 6.34300383e-03f, -4.00068574e-02f, 2.01757133e-01f,
  2.09013984e-01f, 2.07935628e-02f, -5.32738790e-02f, -1.04751468e-01f, -8.05091262e-02f, 1.52578831e-01f, -2.20614648e-03f, 8.09136629e-02f, -1.61278080e-02f, 6.18374422e-02f,
  -1.09343961e-01f, -1.18249217e-02f, -7.97452405e-02f, 2.90694702e-02f, 4.49020462e-03f, -7.63771236e-02f, 1.01835497e-01f, 9.05191451e-02f, 1.01113133e-01f, -2.83418931e-02f,
  -2.49012679e-01f, -2.04931915e-01f, -9.53833163e-02f, -7.99790919e-02f, 2.90518608e-02f, -7.12402686e-02f, -3.04308943e-02f, -6.37839884e-02f, -4.55724448e-03f, 1.49982139e-01f,
  -4.58944924e-02f, -1.61875021e-02f, 5.20271137e-02f, 8.92998502e-02f, 7.98088219e-03f, -8.75342861e-02f, -1.05103590e-01f, -4.67181914e-02f, 1.02223687e-01f, -4.90719602e-02f,
  -2.71681119e-02f, 7.68058822e-02f, 1.80163626e-02f, -3.79845686e-02f, 2.04653572e-02f, -2.36601252e-02f, -6.80352328e-03f, 5.59157878e-03f, -3.16315517e-02f, 1.98800433e-02f,
  2.83579547e-02f, 9.60545391e-02f, 7.85044115e-03f, 3.52411680e-02f, -1.00725656e-02f, 3.43792588e-02f, -2.85694916e-02f, -9.02916119e-02f, -2.56177709e-02f, -1.32237107e-01f,
  7.02077523e-02f, -1.80785134e-01f, 1.20656498e-01f, -5.70744416e-03f, -9.96073410e-02f, -9.45851766e-03f, 2.05773208e-02f, -7.89638162e-02f, -1.23647273e-01f, -1.20963573e-01f,
  -1.12911478e-01f, 5.54558970e-02f, -7.09665241e-03f, -5.07566845e-03f, 4.95856395e-03f, -6.66931868e-02f, -1.11430123e-01f, -1.20272569e-01f, -1.14155945e-03f, -5.19018434e-02f,
  -9.40366089e-02f, -1.57424077e-01f, -1.41886830e-01f, -1.20734394e-01f, -9.59713534e-02f, -1.77861691e-01f, -4.76393588e-02f, -1.21297404e-01f, -4.66539003e-02f, -9.74163122e-04f,
  -3.51219416e-01f, 1.73474908e-01f, 6.64984286e-02f, -2.02702895e-01f, -2.95469642e-01f, -2.33410716e-01f, -1.30371926e-02f, -2.53526986e-01f, -2.15655014e-01f, 9.24053118e-02f,
  7.67565286e-03f, -1.00034818e-01f, 2.75384914e-02f, 9.86989811e-02f, 7.70313814e-02f, 4.02780265e-01f, 3.13659191e-01f, 4.44826446e-02f, -3.03857774e-01f, -2.38547668e-01f,
  4.67090644e-02f, -4.09667194e-02f, -1.47748500e-01f, -3.85876969e-02f, -6.68546557e-02f, 2.04303246e-02f, 1.61335483e-01f, -7.31138606e-03f, 4.65056933e-02f, 1.79514155e-01f,
  2.52764881e-01f, -1.95178568e-01f, -2.74175107e-02f, -2.36342981e-01f, -9.67504606e-02f, -7.80635551e-02f, -1.18475214e-01f, -1.28330275e-01f, -2.45531246e-01f, -1.79984629e-01f,
  -2.43574783e-01f, -1.80266678e-01f, -6.23805746e-02f, 1.17686562e-01f, 3.71710099e-02f, -1.33362859e-01f, 3.83858867e-02f, -5.06588258e-02f, 4.41032760e-02f, 1.13353029e-01f,
  1.39494807e-01f, -1.12100862e-01f, -1.76178873e-01f, 8.44029635e-02f, -9.02439952e-02f, 2.88017374e-02f, -3.40187997e-02f, -2.40648732e-01f, -1.03790268e-01f, 1.06809251e-01f,
  -9.25989728e-03f, 3.16622704e-02f, -3.33059281e-02f, 5.92829585e-02f, 1.07973143e-02f, 5.31058013e-03f, -7.65679823e-03f, -1.30516157e-01f, -1.39505610e-01f, -1.25153825e-01f,
  -6.17489927e-02f, 9.07343552e-02f, -2.47220956e-02f, -7.84311891e-02f, -2.87648346e-02f, -9.09813344e-02f, -6.48444965e-02f, 9.00232568e-02f, -4.36807834e-02f, 3.18404362e-02f,
  -1.58071429e-01f, -2.30612513e-02f, -1.35306707e-02f, -1.82899907e-02f, -4.84453067e-02f, -1.56226009e-01f, -5.29583655e-02f, -5.79995215e-02f, -3.66507731e-02f, -1.10367879e-01f,
  3.37240219e-01f, 6.51715696e-02f, 8.37718099e-02f, -9.45129711e-03f, -7.04903677e-02f, -6.68791384e-02f, 3.64569500e-02f, -1.54243365e-01f, -5.89590520e-02f, -1.43793195e-01f,
  -2.35337228e-01f, -1.34819537e-01f, 4.19098213e-02f, 5.65015934e-02f, -3.48654874e-02f, -1.29758179e-01f, 2.43419617e-01f, -9.07349493e-03f, 7.57644996e-02f, 1.08011998e-01f,
  1.88265935e-01f, -4.24808301e-02f, -6.60660863e-02f, 8.66455063e-02f, 5.94544113e-02f, -3.57729495e-02f, 6.29422888e-02f, -1.20135747e-01f, 2.80324910e-02f, 1.04385130e-01f,
  7.73410082e-01f, 9.10197422e-02f, -2.18111232e-01f, 1.79792136e-01f, -3.09791327e-01f, -1.51739359e-01f, -2.33014628e-01f, 7.34931454e-02f, 1.97917402e-01f, -7.35481456e-03f,
  5.90579212e-02f, 2.54061013e-01f, 3.28500152e-01f, 1.72708020e-01f, 2.24957377e-01f, 5.98447360e-02f, -6.61589354e-02f, 1.79748565e-01f, 7.69632235e-02f, -3.84424552e-02f,
  3.82727683e-02f, 7.70731643e-02f, 2.24734932e-01f, 1.72999144e-01f, -4.83423807e-02f, 1.26608938e-01f, -3.94117646e-02f, -1.07872464e-01f, -1.89861521e-01f, -6.30364493e-02f,
  -3.72044981e-01f, -1.47837728e-01f, -1.98659068e-03f, 1.35950446e-01f, -5.71501702e-02f, 5.05630523e-02f, 6.69941604e-02f, 2.98466701e-02f, 7.95273017e-03f, -6.15004003e-02f,
  -6.92593902e-02f, 4.47730049e-02f, -4.46568094e-02f, -1.07869674e-02f, -1.15219466e-01f, -5.90004325e-02f, 7.33717252e-03f, 2.35752687e-02f, -5.08190179e-03f, 1.08733531e-02f,
  -5.55264279e-02f, -1.32811576e-01f, -9.99165475e-02f, 4.74783406e-02f, 1.08917966e-01f, 2.69315485e-02f, -8.45851526e-02f, -8.72536376e-02f, 2.41882261e-02f, 1.22648090e-01f,
  1.00276902e-01f, 4.78413366e-02f, 4.98522148e-02f, 6.43010885e-02f, 1.56237781e-01f, 4.69479375e-02f, -1.06345667e-02f, -2.69590281e-02f, -1.81672089e-02f, -5.19052893e-02f,
  -1.00629758e-02f, -2.34081503e-02f, -3.89284678e-02f, -3.11808791e-02f, 2.95996182e-02f, -1.19443253e-01f, -9.02008191e-02f, 6.58351108e-02f, 4.63295728e-02f, 4.71532764e-03f,
  9.00363028e-02f, -9.93165448e-02f, 5.22440718e-03f, 1.52759440e-02f, 4.29510660e-02f, 6.38582930e-02f, 2.59449217e-03f, 5.91063127e-02f, 5.72883300e-02f, -4.71362174e-02f,
  -9.17252526e-02f, 1.95777446e-01f, 3.84254232e-02f, 1.37910545e-01f, -1.52457088e-01f, -6.03161305e-02f, 3.59368809e-02f, 3.02294511e-02f, -2.13318452e-01f, -1.54392526e-01f,
  -1.21270202e-01f, 1.08510859e-01f, 2.30798405e-02f, 6.59828708e-02f, 8.19674358e-02f, -7.98279047e-02f, 3.35211121e-02f, 8.78478959e-02f, -4.58850563e-02f, -7.55641609e-02f,
  -4.23420556e-02f, -1.28523130e-02f, 1.18991407e-02f, -4.29306291e-02f, 8.24693963e-02f, 1.17285810e-01f, -3.23450081e-02f, -4.23217975e-02f, 4.99474369e-02f, 1.80855200e-01f,
  -3.58531326e-01f, 4.25608158e-02f, -2.65333448e-02f, -2.98337102e-01f, 6.82257861e-02f, 1.45623282e-01f, 3.16154771e-02f, -5.40276915e-02f, -6.45709485e-02f, -6.88071027e-02f,
  6.59322143e-02f, -7.09514543e-02f, -2.40838990e-01f, -1.87905505e-01f, -2.90487289e-01f, -2.33348981e-01f, -2.86756575e-01f, -3.30475599e-01f, -1.09044924e-01f, 1.82165489e-01f,
  6.13913760e-02f, -1.50821835e-01f, -2.28651345e-01f, -1.01041473e-01f, -7.45828375e-02f, -1.00923277e-01f, -1.09440781e-01f, -7.55413249e-02f, 5.95608912e-02f, -1.55801281e-01f,
  -9.68569145e-02f, 8.88724849e-02f, 1.54200450e-01f, -5.85859306e-02f, 9.49187577e-03f, -1.00889821e-02f, 3.46175674e-03f, -6.66925218e-03f, 4.20219973e-02f, -5.73135577e-02f,
  5.46022784e-03f, 5.43801114e-02f, -6.14574365e-03f, -1.51199922e-02f, -3.76964249e-02f, -2.93164514e-02f, -1.25583515e-01f, -6.06228970e-02f, -8.09244290e-02f, 9.55080166e-02f,
  5.73692508e-02f, 2.80144326e-02f, -1.47926122e-01f, -1.14916789e-03f, -3.00639588e-02f, -1.21099517e-01f, 4.03253324e-02f, 7.34770671e-02f, -6.22601025e-02f, -1.39558986e-01f,
  2.74703708e-02f, 4.87362407e-03f, 1.55355958e-02f, 3.37410867e-02f, -4.76980172e-02f, 5.34871686e-03f, -4.14538756e-02f, -4.46608737e-02f, 2.08513197e-02f, -4.25263941e-02f,
  1.06255347e-02f, 6.62650242e-02f, -3.12796235e-02f, 4.35790345e-02f, -3.78266014e-02f, -2.65764147e-02f, -2.27450263e-02f, 9.07990895e-03f, 1.83966607e-02f, 1.20669920e-02f,
  -3.80249955e-02f, -6.59827888e-02f, -5.02928859e-03f, -2.28462294e-02f, 5.06644659e-02f, -2.68051904e-02f, 3.60658653e-02f, -1.80603359e-02f, -3.70372832e-02f, 9.29935183e-03f,
  -1.61240235e-01f, 1.09855667e-01f, -1.19241178e-01f, -9.90597010e-02f, -6.35588542e-02f, 7.93950632e-02f, -3.73720452e-02f, 8.12216662e-03f, 2.65987702e-02f, 4.50502373e-02f,
  7.78280720e-02f, -1.92275234e-02f, -8.41959268e-02f, 3.59454826e-02f, -1.00967148e-02f, -2.01071575e-02f, -1.01893686e-01f, -1.14355542e-01f, -1.03242393e-03f, 4.96891774e-02f,
  -1.60914317e-01f, -2.26736471e-01f, -4.07175601e-01f, -2.19192713e-01f, -1.17520675e-01f, -2.56782472e-01f, -2.14749455e-01f, -3.74392681e-02f, -2.38075346e-01f, -3.69023055e-01f,
  4.16134983e-01f, -4.34295461e-02f, 1.91776678e-01f, 1.39678568e-01f, -5.31325452e-02f, -1.24085523e-01f, -9.06684995e-02f, -7.91927427e-02f, -4.77744304e-02f, 8.34110752e-02f,
  -1.56256691e-01f, -2.82728791e-01f, -2.62941033e-01f, -2.44661406e-01f, -1.26536772e-01f, 1.17364809e-01f, 1.94127768e-01f, 2.09175184e-01f, 1.67148724e-01f, 2.01591030e-01f,
  4.84938249e-02f, 3.62794578e-01f, 4.13380921e-01f, 1.26372352e-01f, 1.30059659e-01f, 6.33619167e-03f, 1.23594768e-01f, 1.51071548e-01f, 7.19500631e-02f, 2.19350263e-01f,
  1.80163071e-01f, 1.08339772e-01f, -1.89983305e-02f, -2.32060328e-02f, 2.27558073e-02f, 1.61509607e-02f, 2.58938950e-02f, 1.23068489e-01f, -1.03339307e-01f, 7.50664026e-02f,
  -3.18987221e-02f, -6.50338754e-02f, -1.73642844e-01f, -6.79825917e-02f, 8.27779935e-04f, -1.18676886e-01f, -7.62171531e-03f, -6.95243254e-02f, -8.43281001e-02f, 6.29668171e-03f,
  -2.05519706e-01f, 7.57323802e-02f, 7.18694031e-02f, -5.42491376e-02f, -1.32781595e-01f, -6.68428186e-03f, -7.48075098e-02f, -5.73239364e-02f, -1.25113502e-01f, 9.11164507e-02f,
  1.16651453e-01f, 1.10780075e-01f, -1.26844093e-01f, -5.01817986e-02f, -1.11412937e-02f, -9.37827751e-02f, -9.07562301e-02f, -2.15526268e-01f, -1.36330515e-01f, 3.01426742e-02f,
  -1.92597225e-01f, 8.91170651e-02f, 1.03595786e-01f, 4.33643087e-04f, -1.29408970e-01f, 4.96382304e-02f, 1.11347530e-02f, -8.12014788e-02f, 4.92502563e-02f, 1.12125821e-01f,
  4.85828146e-02f, 2.49020960e-02f, -6.51941262e-03f, -6.45965040e-02f, 5.56350015e-02f, -1.13131866e-01f, 1.81808591e-01f, 5.69477491e-02f, 7.13952407e-02f, 1.90592274e-01f,
  1.36139140e-01f, -1.58026546e-01f, 1.04355797e-01f, 6.40987232e-02f, 2.76253708e-02f, -1.58080041e-01f, -2.37093903e-02f, -8.39336962e-02f, -1.20443568e-01f, -1.20180547e-01f,
  -9.16497558e-02f, -2.67415673e-01f, -2.21799493e-01f, -1.15285240e-01f, 6.63169920e-02f, -5.35467919e-03f, 3.59062068e-02f, -1.01989903e-01f, -5.73531017e-02f, 4.78042252e-02f,
  -3.89074758e-02f, 7.16774762e-02f, 1.87678739e-01f, -8.76139924e-02f, -9.92220938e-02f, 4.04686444e-02f, 1.18977875e-02f, 5.03399372e-02f, -1.14345267e-01f, 3.04996848e-01f,
  3.05421531e-01f, -3.51820290e-01f, 1.54235378e-01f, 1.99780658e-01f, 2.07661808e-01f, 1.80506155e-01f, 8.48007500e-02f, 1.07650854e-01f, 1.82633772e-01f, 6.26149923e-02f,
  -8.24072734e-02f, -9.33277979e-02f, 1.88343599e-02f, -8.50212723e-02f, -4.92510982e-02f, 1.25715733e-01f, 1.82371274e-01f, 1.38709933e-01f, 1.79998726e-01f, 3.34240645e-02f,
  -3.96767482e-02f, -3.19521055e-02f, -6.40092865e-02f, 6.13483228e-02f, -6.13395758e-02f, 6.15087003e-02f, 3.16136964e-02f, 1.61442235e-02f, -2.09039319e-02f, 1.00927189e-01f,
  -4.82819304e-02f, -3.67962532e-02f, 4.69330810e-02f, -8.54193494e-02f, -1.33873284e-01f, -1.27482653e-01f, -9.18202568e-03f, -1.61115341e-02f, -1.46303654e-01f, -8.40166491e-03f,
  -1.08067840e-02f, -1.17118604e-01f, -2.69308984e-02f, -7.81163722e-02f, -7.99864531e-02f, 9.99018899e-04f, -7.81065375e-02f, -5.53207919e-02f, -6.84790313e-02f, -1.16643168e-01f,
  -1.76577657e-01f, 1.02009801e-02f, 5.61974421e-02f, 4.54368629e-02f, 3.84162366e-02f, 7.83852562e-02f, -1.21405013e-01f, 2.76689101e-02f, -8.43634903e-02f, -3.75989005e-02f,
  7.40186796e-02f, 5.53270653e-02f, 9.57982391e-02f, 1.41888466e-02f, -5.93411885e-02f, 1.01536378e-01f, 7.85473213e-02f, -1.39860539e-02f, 1.71360169e-02f, 8.13378915e-02f,
  5.79818711e-02f, 3.93539816e-02f, -2.08397005e-02f, 1.48544192e-01f, 5.38631566e-02f, 7.09403008e-02f, 1.63485743e-02f, -5.37089519e-02f, 7.32764676e-02f, 4.96719480e-02f,
  9.25424099e-02f, 1.22312708e-02f, 2.80826241e-02f, 1.00385500e-02f, 4.58074920e-03f, 1.14399694e-01f, 4.12687473e-02f, -7.68371597e-02f, 9.09220725e-02f, 8.52643400e-02f,
  -2.20409676e-01f, 3.16988640e-02f, 1.19494930e-01f, 6.17264435e-02f, -7.11080357e-02f, -3.19501013e-02f, 3.00953649e-02f, -1.74335659e-01f, -1.22064091e-01f, -2.19918750e-02f,
  -1.24300346e-02f, -5.91868395e-03f, -9.51907560e-02f, -3.29385735e-02f, 1.00592911e-01f, 6.41726628e-02f, -6.75392523e-02f, -1.28871715e-02f, -6.01725131e-02f, -7.23190159e-02f,
  -1.43412277e-01f, 8.65652338e-02f, 1.11880392e-01f, -2.99948845e-02f, 3.58995125e-02f, 1.12892032e-01f, 6.73765317e-02f, -4.12295051e-02f, 7.83856139e-02f, 3.51641439e-02f,
  9.11360532e-02f, -2.06793457e-01f, -4.92457598e-02f, 1.78905517e-01f, -1.66181494e-02f, -2.08339870e-01f, -4.76403654e-01f, -1.48345023e-01f, 2.22575873e-01f, -1.67563632e-01f,
  -6.78405389e-02f, 2.04586536e-01f, 1.07027285e-01f, -3.53114232e-02f, -2.84033209e-01f, -4.00088221e-01f, -2.59890556e-01f, -5.84477261e-02f, -1.31226659e-01f, -1.60651490e-01f,
  -9.51149613e-02f, 5.42222671e-02f, 9.32082832e-02f, -1.98301021e-02f, 1.34812146e-01f, 1.33311689e-01f, 1.41793685e-02f, 3.63335456e-03f, -2.08343208e-01f, -4.77370014e-03f,
  -7.03161284e-02f, -1.39854457e-02f, -1.20904602e-01f, 1.25800088e-01f, -1.25074468e-03f, -1.02340989e-02f, -9.89471823e-02f, 7.42814913e-02f, -4.11535800e-02f, -7.76999369e-02f,
  2.04727091e-02f, -2.56697182e-03f, 1.98061634e-02f, -2.64781062e-02f, -6.21904666e-03f, -6.56385198e-02f, -1.53196407e-02f, -6.71464726e-02f, -3.89115103e-02f, 2.19317805e-03f,
  -7.29602054e-02f, -2.08213050e-02f, -2.28901710e-02f, -7.82951266e-02f, -5.03120432e-03f, 4.67571579e-02f, -4.58671106e-03f, -1.36121027e-02f, -1.14422336e-01f, 2.21575759e-02f,
  3.21400464e-02f, 4.00129668e-02f, -6.09111832e-03f, 3.38252485e-02f, -3.92149352e-02f, 2.98317000e-02f, 4.09077294e-02f, -8.62785652e-02f, -2.74840314e-02f, 2.95843817e-02f,
  1.77219287e-02f, -2.62784883e-02f, 4.19753492e-02f, -1.10262044e-01f, -7.91211933e-05f, -2.77681742e-02f, -3.26741822e-02f, -3.87692265e-02f, -1.55829843e-02f, -2.31644418e-02f,
  2.30969116e-02f, 1.67266335e-02f, 1.22485518e-01f, 1.26649272e-02f, -2.04831874e-03f, 5.99608198e-03f, 4.11190465e-02f, 3.11023295e-02f, 4.40077782e-02f, -2.89511234e-02f,
  1.36468738e-01f, -1.78109452e-01f, -6.01398498e-02f, -7.76392296e-02f, -1.26161933e-01f, 9.02786329e-02f, 4.32188157e-03f, -7.35374317e-02f, 1.56265106e-02f, -1.20455138e-02f,
  -1.55522704e-01f, -5.89939617e-02f, -1.94540236e-03f, 2.75353016e-03f, -1.41551971e-01f, -2.86297556e-02f, -1.85695872e-01f, -6.16556741e-02f, -8.89179856e-02f, 1.06620111e-01f,
  -1.29365840e-03f, -1.93577826e-01f, -8.74186531e-02f, -6.42327443e-02f, 1.09560136e-02f, -1.87943690e-02f, -2.83151511e-02f, -9.24124718e-02f, -1.66342080e-01f, -1.81108043e-01f,
  -3.12950283e-01f, 2.39137352e-01f, -7.56894201e-02f, -6.06100224e-02f, 1.33630931e-01f, 1.29414305e-01f, 1.38754293e-01f, 1.34816259e-01f, 9.58736911e-02f, 5.89991687e-03f,
  6.61244267e-04f, -9.60440654e-03f, 4.36383262e-02f, 2.56853998e-02f, -8.34213793e-02f, 6.55337125e-02f, 6.04475215e-02f, -1.29941151e-01f, -1.63138136e-01f, -8.20454583e-02f,
  1.70020070e-02f, -1.76435545e-01f, -3.01379740e-01f, -6.16948716e-02f, 1.91243127e-01f, 3.96415107e-02f, 7.61076659e-02f, 7.25383088e-02f, 9.61866826e-02f, 2.39183143e-01f,
  -2.51890928e-01f, 5.36854230e-02f, -1.22461267e-01f, -6.41466156e-02f, -5.92618249e-02f, -4.19062227e-02f, -3.93350124e-02f, -7.28245750e-02f, -7.88984634e-03f, -4.80968915e-02f,
  -2.90488862e-02f, 1.06593883e-02f, 3.74673381e-02f, -5.70697002e-02f, -8.46576914e-02f, -1.25461789e-02f, -6.50789589e-02f, -8.22990462e-02f, -1.06275521e-01f, -2.94524133e-02f,
  8.03739652e-02f, -5.75698204e-02f, -4.57354225e-02f, 3.47412862e-02f, 3.42564285e-02f, -1.08022593e-01f, 8.63105152e-03f, 8.44298601e-02f, -7.90989399e-02f, 4.31561321e-02f,
  -3.20677832e-02f, -5.22384383e-02f, -4.39540483e-02f, 3.11594456e-02f, -1.95256397e-02f, -1.05721401e-02f, 5.24759330e-02f, -2.36303639e-02f, -5.07114269e-02f, -2.35665068e-02f,
  9.74223092e-02f, -8.81749168e-02f, -3.32440212e-02f, 3.46263833e-02f, 4.14527953e-03f, 2.11549108e-03f, 3.58525142e-02f, -2.61371234e-03f, -5.86805120e-02f, -1.93787250e-03f,
  -4.78450581e-02f, -1.53936278e-02f, 4.71414551e-02f, 9.55286399e-02f, 7.27623934e-03f, 2.64944304e-02f, -2.26343833e-02f, 4.95852949e-03f, 1.07910959e-02f, 4.97691147e-02f,
  -1.50780186e-01f, -2.20677048e-01f, -1.32853210e-01f, 1.78636704e-02f, -3.37127633e-02f, -1.60285286e-04f, -1.80103201e-02f, -7.39926919e-02f, -2.22111810e-02f, -8.18575546e-02f,
  -7.38837942e-02f, -1.66611280e-02f, -2.51198318e-02f, -1.05238799e-02f, -1.50199458e-01f, 1.19440947e-02f, -1.07248791e-01f, -8.44554752e-02f, -5.10666259e-02f, -1.80139132e-02f,
  -8.46838579e-03f, -1.94232687e-01f, -2.70993114e-01f, -5.78697510e-02f, -5.27582169e-02f, -2.02380687e-01f, -1.21905491e-01f, -8.85821283e-02f, -2.50174105e-01f, -1.71743333e-01f,
  -6.93363994e-02f, -2.33362228e-01f, 5.29036447e-02f, 8.63060877e-02f, 1.95511788e-01f, 2.46264577e-01f, 2.33694330e-01f, 6.82535022e-02f, 4.85841893e-02f, 3.91084328e-02f,
  -7.93169364e-02f, 7.93479476e-03f, 7.97205046e-02f, 9.30260271e-02f, 5.58744483e-02f, 1.30123988e-01f, 1.54566653e-02f, 9.68157649e-02f, 5.71135432e-02f, 6.80561066e-02f,
  2.18107998e-02f, -1.61906928e-02f, 1.69080558e-05f, 2.26798933e-02f, -2.92553473e-02f, 5.98417521e-02f, -8.12951028e-02f, -1.16121247e-01f, -1.52433917e-01f, -1.33538827e-01f,
  1.55632064e-01f, -2.28649512e-01f, 8.69395658e-02f, -1.58604905e-01f, -1.10501200e-01f, -4.18352149e-02f, 3.65983844e-02f, -1.84330344e-01f, -2.04812005e-01f, -1.39652133e-01f,
  -3.66764709e-07f, -6.57121744e-03f, 5.60326241e-02f, -1.59878969e-01f, -8.61586928e-02f, 1.61316711e-02f, -6.28984943e-02f, -1.20546289e-01f, -8.42562243e-02f, -6.50959983e-02f,
  -1.46904871e-01f, -1.33897439e-01f, 8.59196112e-02f, 6.97800592e-02f, -1.20428400e-02f, -7.29217986e-03f, -3.89948599e-02f, -4.70985612e-03f, 4.93664443e-02f, -8.50899592e-02f,
  5.33955619e-02f, 5.75485453e-02f, 1.43113196e-01f, 1.22549415e-01f, 5.60254455e-02f, 7.57840574e-02f, 2.47635990e-02f, 1.00281037e-01f, 1.72508359e-01f, 4.89292406e-02f,
  4.01034020e-02f, 1.88479081e-01f, -1.03788394e-02f, 1.14405900e-01f, 1.73278851e-03f, -1.02861822e-01f, -8.79563391e-02f, -6.25556111e-02f, 3.16201127e-03f, -8.29089135e-02f,
  1.22238465e-01f, -5.26838973e-02f, -8.78545865e-02f, 7.62685984e-02f, -5.43055087e-02f, 3.73347439e-02f, -4.55151983e-02f, -6.40089363e-02f, -4.67265658e-02f, -4.97822538e-02f,
  3.49003911e-01f, 9.64222178e-02f, 2.30874598e-01f, 1.15255199e-01f, -4.04806398e-02f, -1.42409772e-01f, 2.99651381e-02f, -9.99434367e-02f, -1.69950992e-01f, 8.07269886e-02f,
  3.89860235e-02f, -3.29417409e-04f, 9.26360413e-02f, -2.67194379e-02f, 1.97161868e-01f, 5.61273135e-02f, -6.48709089e-02f, 1.15466371e-01f, -2.89195729e-03f, 3.98980826e-02f,
  3.20680849e-02f, 1.17232114e-01f, 2.43264422e-01f, 1.08737268e-01f, 9.54657495e-02f, 7.12235123e-02f, 1.65675968e-01f, 6.22002259e-02f, 1.10422418e-01f, 9.52179283e-02f,
  5.30015945e-01f, 4.24406677e-01f, 2.99612582e-01f, 4.06450331e-02f, 2.25156471e-01f, 3.13599437e-01f, 3.79653871e-01f, 3.99290323e-01f, 1.89204477e-02f, 2.54374176e-01f,
  2.20637456e-01f, -1.71478778e-01f, -1.83478460e-01f, -1.86474144e-01f, 1.07957922e-01f, 1.24387197e-01f, -9.33731198e-02f, 8.48622154e-03f, -2.75407359e-02f, 7.01560825e-02f,
  -1.04904454e-02f, 1.55088112e-01f, 2.76797056e-01f, 1.04404144e-01f, -6.24156483e-02f, -2.30723709e-01f, 1.05516993e-01f, 1.98766649e-01f, 1.17963655e-02f, -2.20742434e-01f,
  -2.25657567e-01f, 1.56361192e-01f, -3.10590208e-01f, -1.00009710e-01f, 8.03413838e-02f, 1.84827402e-01f, 5.63354753e-02f, 9.10387710e-02f, 1.50208786e-01f, -1.24783078e-02f,
  -1.24604441e-02f, 8.31373930e-02f, 3.08287460e-02f, 2.01977327e-01f, 1.14865281e-01f, 7.64809996e-02f, 8.94147232e-02f, 1.07167199e-01f, -7.59678110e-02f, 1.41989654e-02f,
  -3.12174833e-03f, 6.84012920e-02f, 1.36090577e-01f, -3.31296064e-02f, -7.93660507e-02f, -1.60298899e-01f, 1.84225678e-01f, 1.91444287e-03f, 2.07835380e-02f, -1.05310388e-01f,
  -1.25583857e-01f, -1.12978116e-01f, -1.41001001e-01f, -4.40782979e-02f, -3.92672643e-02f, 1.39542343e-02f, 1.81104373e-02f, -1.32659093e-01f, 1.02127984e-01f, 1.62640408e-01f,
  6.37579337e-02f, -9.77882519e-02f, 1.18426412e-01f, -2.66581941e-02f, -7.94927182e-04f, 3.96026596e-02f, 3.12035605e-02f, 5.32873459e-02f, -2.14519277e-02f, -1.49255916e-01f,
  -1.72965348e-01f, 1.67492226e-01f, 1.51192442e-01f, 3.07249315e-02f, 1.56203151e-01f, -5.66723123e-02f, -4.89198044e-02f, 4.45323475e-02f, 2.35130459e-01f, 2.27382462e-02f,
  -8.25449079e-02f, -1.75404295e-01f, -3.28234583e-01f, -2.22474426e-01f, -3.68851200e-02f, 1.59988776e-01f, -2.34870329e-01f, -5.90894856e-02f, 8.59204978e-02f, -1.80610288e-02f,
  1.64345186e-02f, 1.62748173e-02f, -2.22396925e-02f, 4.45802733e-02f, 3.79116251e-03f, -3.09126079e-02f, -3.05042900e-02f, -4.97301761e-03f, -3.91583377e-03f, 5.54139204e-02f,
  -5.05851470e-02f, 1.16262421e-01f, 8.34307354e-03f, -3.95908579e-02f, -2.74971068e-01f, -2.05919832e-01f, -3.92124802e-03f, -2.89990790e-02f, -4.13212553e-03f, 1.01589411e-01f,
  6.72705352e-01f, 3.59329194e-01f, 2.81261116e-01f, -4.57399040e-02f, -3.27202499e-01f, 7.86867216e-02f, 3.03430319e-01f, 2.62039900e-01f, 4.41198573e-02f, 1.54688478e-01f,
  6.85398132e-02f, -1.86865583e-01f, 4.85427305e-02f, 6.52887970e-02f, 1.71908230e-01f, 1.70583755e-01f, -2.56769601e-02f, 2.13527441e-01f, 1.56759426e-01f, 1.59379259e-01f,
  -3.33211496e-02f, 1.43380761e-01f, 2.70417660e-01f, 1.69176206e-01f, -6.85367659e-02f, -1.59857154e-01f, -6.70719193e-03f, 8.52543488e-02f, 6.78063855e-02f, 3.22382967e-03f,
  -1.56941906e-01f, 4.57646936e-01f, -1.65013105e-01f, -2.54373312e-01f, -1.37377724e-01f, 1.17632121e-01f, 1.59508903e-02f, 3.26319076e-02f, -1.19941961e-02f, -2.98698097e-02f,
  -1.94803834e-01f, -5.46098165e-02f, -6.16185926e-03f, -4.11258861e-02f, 3.71973626e-02f, 8.90559256e-02f, 6.59612194e-02f, 9.88798812e-02f, 2.87116896e-02f, -1.20891733e-02f,
  -1.79615602e-01f, -9.70585868e-02f, -1.27613336e-01f, 8.12749658e-03f, 6.86369687e-02f, -1.04352139e-01f, 5.23088723e-02f, -1.23517187e-02f, 1.34507343e-01f, 1.61624044e-01f,
  -1.83904409e-01f, -4.48127352e-02f, 3.52254026e-02f, 2.20918834e-01f, 1.93803683e-01f, 1.16553633e-02f, 1.37808211e-02f, -6.77785650e-02f, 2.03566421e-02f, 1.27241954e-01f,
  2.76578981e-02f, 4.48894650e-02f, 3.02592386e-02f, 1.34353876e-01f, -1.10465430e-01f, -2.18063463e-02f, 5.69154657e-02f, 3.19523029e-02f, -1.71237625e-02f, -2.22990271e-02f,
  5.75504042e-02f, -2.91215759e-02f, 6.56191334e-02f, 1.04450539e-01f, 6.93817213e-02f, -2.58016004e-03f, 3.77299152e-02f, 5.83048388e-02f, -1.15141347e-01f, 4.16341089e-02f,
  -3.25452536e-01f, -7.12319911e-02f, -7.64919072e-02f, -3.31434002e-03f, -5.88336289e-02f, -6.65438399e-02f, -1.30335882e-01f, -2.77472287e-02f, -9.74452570e-02f, 4.52197567e-02f,
  1.79612916e-02f, 5.59197627e-02f, 2.77661234e-02f, 4.98320200e-02f, -1.18136525e-01f, -5.55890203e-02f, -1.67150289e-01f, -1.21934660e-01f, -1.62331596e-01f, -1.47139952e-01f,
  -4.93214689e-02f, -1.52962059e-01f, -1.75253481e-01f, -1.21612847e-01f, -1.13424353e-01f, -2.59987772e-01f, -6.89299405e-02f, -1.48834363e-01f, -4.92029637e-02f, -4.71982872e-03f,
  1.35536110e-02f, -3.36848162e-02f, -1.74738288e-01f, 1.70660362e-01f, -1.88267380e-02f, -1.67726308e-01f, -1.34939834e-01f, -1.86559096e-01f, 2.58340705e-02f, 1.48356751e-01f,
  1.30204260e-01f, 6.70363829e-02f, 1.02143891e-01f, -1.06666088e-01f, -2.41291031e-01f, -5.59417903e-02f, -5.43055348e-02f, -1.54110715e-01f, -2.25838095e-01f, -2.36131892e-01f,
  3.45388465e-02f, 3.88889313e-02f, -5.24390452e-02f, -1.40766144e-01f, 1.32277831e-01f, 1.08993307e-01f, 9.25151035e-02f, 2.12898850e-02f, -9.63716488e-03f, 1.86859936e-01f,
  2.83132792e-01f, -2.45686471e-01f, -5.97376972e-02f, -9.61149484e-02f, 6.04904220e-02f, 3.88417467e-02f, 7.56220743e-02f, -9.36681684e-03f, 2.00420022e-02f, 9.68784764e-02f,
  1.14511430e-01f, 3.50401737e-02f, 2.73612645e-02f, -2.59981398e-02f, 7.15542510e-02f, 2.82663759e-02f, -1.06007092e-01f, -1.36886343e-01f, -7.56182596e-02f, -1.48972319e-02f,
  3.29716764e-02f, 4.43966761e-02f, 3.84103917e-02f, -3.73008326e-02f, -1.66581169e-01f, -3.38979140e-02f, -5.93105555e-02f, -1.80264190e-01f, -1.53752312e-01f, 4.87195961e-02f,
  1.38286844e-01f, 2.33571917e-01f, 1.34228379e-01f, 1.20947942e-01f, 1.80978253e-01f, 9.20414850e-02f, 1.49913639e-01f, 1.70048639e-01f, 1.13327891e-01f, 5.64737692e-02f,
  5.06329052e-02f, 4.14811410e-02f, 7.46679157e-02f, 1.75649554e-01f, 1.81183338e-01f, 1.05342485e-01f, 2.12463573e-01f, 1.13701634e-01f, 7.40677714e-02f, 2.45052755e-01f,
  1.85268417e-01f, 1.83798149e-01f, 2.22527549e-01f, 5.65071180e-02f, 9.25932303e-02f, 8.95322785e-02f, 2.26599574e-01f, 1.19986475e-01f, 1.23896092e-01f, 7.99587592e-02f,
  2.61942327e-01f, -2.55076259e-01f, 2.16614008e-01f, -8.59123543e-02f, 7.71640614e-02f, -8.47838935e-04f, 1.20252691e-01f, -6.49013519e-02f, 8.11939165e-02f, 1.71091825e-01f,
  -3.07073426e-02f, 1.82980001e-01f, 7.92926922e-02f, -1.60704516e-02f, 1.02169149e-01f, 1.67411685e-01f, 7.27569833e-02f, -5.54025844e-02f, -1.48168907e-01f, -1.09449392e-02f,
  -1.84664447e-02f, 3.88774090e-02f, 1.52901202e-01f, 4.07280587e-02f, 7.96120614e-02f, 8.94795880e-02f, 1.87817782e-01f, -6.44635633e-02f, 3.69687565e-02f, 1.70484573e-01f,
  3.22359324e-01f, -1.09709918e-01f, 9.77896005e-02f, 2.44011134e-01f, 3.21589559e-02f, -3.67560796e-02f, -1.42767310e-01f, -2.22041365e-02f, 1.43377066e-01f, 5.08703990e-03f,
  1.54155985e-01f, 1.57824159e-01f, 1.49301425e-01f, -3.19243595e-02f, 5.89744840e-03f, -9.42172483e-02f, -1.26209334e-01f, -1.14598330e-02f, -6.67835325e-02f, -1.84305966e-01f,
  -5.99877313e-02f, -3.93688753e-02f, -1.60026904e-02f, -3.94305922e-02f, 4.10643891e-02f, 5.33871800e-02f, 9.74935889e-02f, -6.39436021e-02f, -6.15776032e-02f, -1.21321879e-01f,
  1.66904092e-01f, 9.93382335e-02f, 1.39259668e-02f, -1.39513806e-01f, -6.83495775e-02f, -1.46407023e-01f, -8.81336331e-02f, 2.94721257e-02f, -1.95091739e-02f, -6.82801381e-02f,
  7.93227181e-03f, -9.47576612e-02f, -4.45709936e-02f, -1.73354354e-02f, -7.69304335e-02f, 2.54543703e-02f, -2.35182941e-02f, -1.43932939e-01f, -1.05467543e-01f, -5.91606200e-02f,
  -1.25324845e-01f, -9.05077830e-02f, -5.34397326e-02f, -6.76933378e-02f, -3.88131514e-02f, 3.31916586e-02f, 5.39754797e-03f, 1.47594856e-02f, -1.08177625e-01f, -5.77296540e-02f,
  -7.03692883e-02f, -3.32404599e-02f, -5.86989559e-02f, 8.73966739e-02f, 1.92290340e-02f, 1.48496348e-02f, -1.16692409e-02f, 1.54958423e-02f, -2.90251654e-02f, -1.36790136e-02f,
  -1.43690228e-01f, 7.11695990e-03f, -1.01812426e-02f, -2.34174486e-02f, -1.41174416e-03f, -1.04202874e-01f, -1.81745160e-02f, -7.37709329e-02f, 5.46615459e-02f, -7.27031333e-03f,
  4.12088484e-02f, -7.12338239e-02f, 4.61052433e-02f, -1.15505055e-01f, -2.31789034e-02f, 3.92287895e-02f, 2.16718242e-02f, -6.11456782e-02f, -3.60015407e-02f, 2.61496417e-02f,
  1.45963177e-01f, 1.18098952e-01f, -4.01294744e-03f, -6.99486881e-02f, -5.61124971e-03f, -3.93584408e-02f, -1.89617686e-02f, -6.50547072e-02f, 1.01958767e-01f, -4.90146205e-02f,
  -3.91161479e-02f, -1.23756314e-02f, 7.98198655e-02f, -9.63840708e-02f, 2.60613505e-02f, 2.04304028e-02f, -5.03019914e-02f, -1.89137924e-02f, 1.52166700e-02f, -4.57258485e-02f,
  -2.31998209e-02f, -4.22700960e-03f, 8.46309885e-02f, 6.60899431e-02f, -9.15033445e-02f, 2.79239863e-02f, 7.21690208e-02f, -8.37544203e-02f, 7.97929987e-03f, -5.01295850e-02f,
  3.55275750e-01f, 8.91516283e-02f, 7.21715465e-02f, 1.01928398e-01f, 1.05961278e-01f, 1.00651346e-01f, 3.51803452e-01f, 2.09930196e-01f, 1.13899797e-01f, 7.63626546e-02f,
  -2.40062609e-01f, -3.67207795e-01f, -3.09673786e-01f, -2.56136715e-01f, -9.78652984e-02f, 1.79453760e-01f, 1.89200997e-01f, 1.30491573e-02f, 2.72896644e-02f, 1.77661702e-02f,
  5.47901653e-02f, 3.04107130e-01f, 2.93912679e-01f, 6.82404563e-02f, 3.16038728e-02f, -7.33373836e-02f, 1.45978823e-01f, 5.87621555e-02f, -1.28635764e-02f, -9.86612868e-04f,
  -2.85924047e-01f, 2.63080329e-01f, -3.64965163e-02f, -5.98363914e-02f, -1.20720774e-01f, 5.47718033e-02f, 3.31204571e-02f, 5.16655333e-02f, -5.26553057e-02f, -3.57003585e-02f,
  -1.71083018e-01f, -5.90145290e-02f, -1.86740547e-01f, -9.85539556e-02f, 6.81958720e-02f, 1.02193262e-02f, 2.28953324e-02f, 1.54389197e-03f, -1.04414538e-01f, -1.38607502e-01f,
  -1.67542741e-01f, -2.19940164e-04f, 2.45779157e-02f, -1.76875219e-02f, -8.48932192e-02f, -1.25678748e-01f, -6.12593777e-02f, -4.05028090e-03f, -2.63027996e-02f, 5.13115674e-02f,
  -1.74517352e-02f, -4.34290580e-02f, -2.50235479e-03f, 1.22361928e-01f, 9.47168022e-02f, -5.07540815e-02f, -7.22614303e-02f, -9.31682661e-02f, -4.81670126e-02f, 6.73537478e-02f,
  -1.01384453e-01f, -2.17698049e-02f, -1.49066402e-02f, -2.69824639e-02f, -1.20206065e-01f, 2.55550556e-02f, 4.28839736e-02f, 2.78598126e-02f, -3.64650823e-02f, 9.24061462e-02f,
  -5.70596894e-03f, 4.89759780e-02f, -8.47908556e-02f, -5.32053374e-02f, 6.49854168e-02f, 1.45225516e-02f, 4.41901349e-02f, -3.78134586e-02f, 3.26670557e-02f, 1.46533892e-01f,
  2.81118285e-02f, 1.60847995e-02f, -5.00972457e-02f, -2.71593537e-02f, 6.07056953e-02f, -9.79052559e-02f, -7.01506436e-02f, -1.90248806e-02f, -6.47003502e-02f, -2.41882466e-02f,
  -6.89750612e-02f, -1.34973824e-01f, -1.10074632e-01f, -6.91900477e-02f, 6.97046593e-02f, -6.01225421e-02f, -3.64670642e-02f, 1.38396246e-03f, -8.12384784e-02f, -4.67707328e-02f,
  8.53164401e-03f, 1.30780816e-01f, 1.40891626e-01f, 5.14805727e-02f, -1.03904717e-01f, -4.09218743e-02f, 9.27501768e-02f, -1.24974223e-02f, 5.28323092e-02f, 2.78397858e-01f,
  -1.58325136e-01f, -1.76755726e-01f, 3.47394235e-02f, 1.19595259e-01f, 2.21990526e-01f, 2.35073999e-01f, 8.64496827e-02f, 1.34743065e-01f, 2.41329238e-01f, 8.57022032e-02f,
  9.50847790e-02f, 2.63415843e-01f, 2.80526459e-01f, 1.20780632e-01f, 2.80230850e-01f, 1.56382322e-01f, 1.86120167e-01f, 9.49395895e-02f, 7.41594955e-02f, 5.64488992e-02f,
  1.60607010e-01f, 7.12810308e-02f, -5.19950455e-03f, -1.26380268e-02f, 7.59880021e-02f, 1.89074531e-01f, 3.72194052e-02f, -9.82906744e-02f, 6.24273084e-02f, -3.25196199e-02f,
  -2.64572203e-02f, -3.14104259e-01f, 5.27051017e-02f, -5.05771898e-02f, -2.32515082e-01f, -1.12530231e-01f, -4.40802574e-02f, -2.11361930e-01f, -1.38551712e-01f, -3.93215381e-02f,
  -3.76003161e-02f, -1.30843431e-01f, 1.36359064e-02f, -1.77437857e-01f, -1.57163277e-01f, -1.66069921e-02f, -1.44772574e-01f, -8.09368119e-02f, 1.68482870e-01f, -7.55259320e-02f,
  -1.11083619e-01f, -1.66171595e-01f, -7.86814168e-02f, 1.08362727e-01f, 1.38317823e-01f, 3.83228250e-02f, -1.40683293e-01f, -1.03525542e-01f, 5.20891137e-02f, -1.67786673e-01f,
  4.31249551e-02f, 4.36960757e-02f, -4.33740020e-02f, 6.69873133e-02f, 1.17078669e-01f, -5.46718501e-02f, -1.18256040e-01f, 6.25490621e-02f, 9.43502635e-02f, 9.87033593e-04f,
  -7.04146549e-02f, 7.23766610e-02f, 6.41596168e-02f, 5.53150438e-02f, 3.73085141e-02f, -2.87295543e-02f, -1.31393954e-01f, -9.86974090e-02f, 3.13482881e-02f, 1.79681499e-02f,
  4.62143496e-02f, -1.47559732e-01f, -2.43230224e-01f, 5.61024295e-03f, -1.41787127e-01f, -1.76300178e-04f, -7.80236796e-02f, -5.42847067e-02f, -5.63772768e-02f, -1.49077177e-01f,
  8.54144618e-02f, 1.57038331e-01f, 1.60360157e-01f, -5.05669899e-02f, -9.67481583e-02f, -1.06745720e-01f, 1.09758608e-01f, -2.20934376e-02f, -3.80107313e-02f, 4.23551574e-02f,
  -1.92704387e-02f, -7.91764855e-02f, -1.36146033e-02f, 5.23316562e-02f, 2.98487209e-03f, -1.27935186e-01f, -1.51127920e-01f, -1.13421269e-02f, 5.08843176e-02f, -1.11482836e-01f,
  -2.98869051e-03f, -7.25336075e-02f, 4.94549349e-02f, 1.33080214e-01f, 1.95192486e-01f, 4.57579903e-02f, 3.59357782e-02f, 6.37841523e-02f, 1.20094873e-01f, 5.84518798e-02f,
  2.96016902e-01f, -3.44559960e-02f, -2.86282033e-01f, 2.40648054e-02f, -6.34011775e-02f, -1.24299027e-01f, -1.56395242e-01f, -1.26173928e-01f, -7.45873675e-02f, -1.13108911e-01f,
  -1.78289220e-01f, -1.36796206e-01f, -2.32629210e-01f, -1.31882012e-01f, -2.01314345e-01f, -3.08823138e-01f, -2.08578885e-01f, -1.04487643e-01f, -2.10311804e-02f, 1.82626009e-01f,
  4.30414490e-02f, 4.73120101e-02f, 8.40281323e-02f, 3.78938429e-02f, 1.51635334e-01f, -1.34115532e-01f, -1.82661921e-01f, -1.42843381e-01f, -9.24139172e-02f, 6.36919588e-03f,
  -1.39237672e-01f, -1.94632709e-02f, 3.03711463e-02f, 1.73893616e-01f, 3.32665183e-02f, 9.81390998e-02f, 6.82618320e-02f, 1.75506428e-01f, 3.60705368e-02f, 2.73525175e-02f,
  8.03300738e-02f, 4.59023044e-02f, 5.07211722e-02f, 5.74468523e-02f, 1.48522928e-01f, 6.79177046e-02f, 1.83120921e-01f, 9.47411805e-02f, -2.34868862e-02f, 4.87627760e-02f,
  3.23415129e-03f, -2.16621645e-02f, -4.97678593e-02f, -2.67780833e-02f, -3.08739133e-02f, -4.18477841e-02f, 5.05690351e-02f, 3.46300304e-02f, 1.16372192e-02f, -5.67009449e-02f,
  -8.89480039e-02f, -3.54645289e-02f, -7.49486834e-02f, -8.95540565e-02f, -5.03080431e-03f, -3.19769047e-02f, 1.19383082e-01f, -1.77120402e-01f, -1.58128500e-01f, -5.88822588e-02f,
  3.49561597e-04f, -2.20887929e-01f, -1.52368411e-01f, 7.45153278e-02f, 1.02568381e-01f, -1.19738095e-01f, -6.82578757e-02f, -3.15606669e-02f, -8.88851434e-02f, 1.37643898e-02f,
  1.60012406e-03f, 1.82658043e-02f, 1.42604291e-01f, 4.60697971e-02f, 1.74621925e-01f, -9.05890204e-03f, 4.04318012e-02f, 2.62623169e-02f, -2.80192569e-02f, 3.47608961e-02f,
  -1.28779247e-01f, -2.95177370e-01f, 4.69891615e-02f, -1.14995182e-01f, 4.22547199e-02f, 1.69516191e-01f, -4.58632894e-02f, 1.30731866e-01f, 1.01142764e-01f, 9.48691964e-02f,
  -5.61973676e-02f, 6.22355454e-02f, 5.15486747e-02f, 3.12673710e-02f, 1.02337956e-01f, 2.35473569e-02f, 1.11691765e-01f, 4.34068367e-02f, -1.99817028e-02f, 1.66237518e-01f,
  2.03742042e-01f, 5.55164404e-02f, 2.52164807e-02f, -3.59643921e-02f, -1.23456270e-01f, -3.49822268e-03f, -3.01099718e-02f, 1.86543986e-02f, 4.71371859e-02f, 8.33388567e-02f,
  4.84556049e-01f, -1.02949105e-01f, 1.53616071e-01f, 5.56685701e-02f, -2.83211082e-01f, -4.81491446e-01f, -5.22511721e-01f, -3.22680086e-01f, -3.26211080e-02f, -9.35582817e-02f,
  1.68233234e-02f, 6.50490448e-02f, 1.79344282e-01f, 1.05761200e-01f, 1.66736785e-02f, -4.60781679e-02f, -1.25196651e-01f, 3.22818667e-01f, 2.07429320e-01f, -1.11321583e-02f,
  -6.83670193e-02f, 5.62470518e-02f, 2.51205921e-01f, 1.36151284e-01f, 2.10705534e-01f, 1.43700643e-02f, 8.15172680e-03f, 3.08069400e-02f, -5.21444827e-02f, 3.71050119e-01f,
  3.80392641e-01f, 1.67105004e-01f, -8.43077675e-02f, 8.34689662e-02f, 5.59939630e-02f, 1.04325071e-01f, 4.02311943e-02f, 6.26540917e-04f, -8.11983198e-02f, -7.90649503e-02f,
  3.13249640e-02f, -7.57311434e-02f, -5.63085414e-02f, -3.90106365e-02f, -1.50309518e-01f, -1.40695706e-01f, -1.22439817e-01f, 5.36229759e-02f, 6.40544742e-02f, 1.68005712e-02f,
  -1.93907991e-01f, -9.18647423e-02f, -1.68882713e-01f, -3.14980656e-01f, -7.56619945e-02f, -4.38803099e-02f, -6.27846122e-02f, 6.46731704e-02f, -1.12360470e-01f, 7.65855908e-02f,
  -7.44459555e-02f, 1.19895861e-01f, -1.20115504e-01f, -1.82016864e-01f, -1.64783478e-01f, -2.06163988e-01f, -7.27453381e-02f, -2.89151501e-02f, 3.97422537e-02f, -3.33157703e-02f,
  -1.14349619e-01f, -6.82850853e-02f, 1.03839366e-02f, -1.76285148e-01f, 5.42905815e-02f, 2.36402042e-02f, -3.10577117e-02f, -1.15833163e-01f, -1.14084996e-01f, -5.34812883e-02f,
  -5.86489141e-02f, 9.74542350e-02f, -1.27477497e-01f, -1.61206007e-01f, 1.07058883e-02f, -5.56004494e-02f, -6.52350113e-02f, -1.23150617e-01f, -6.53425977e-02f, -9.88524556e-02f,
  -8.28005746e-02f, -2.18378052e-01f, 7.25382641e-02f, 1.93292722e-01f, -2.12031114e-03f, 4.60280478e-03f, 5.90356886e-02f, 3.35718393e-02f, 6.80689663e-02f, 7.31046423e-02f,
  4.76772413e-02f, 6.82370886e-02f, -8.85248091e-03f, 6.10212237e-02f, -9.77705270e-02f, -1.08794197e-01f, -8.33200812e-02f, 9.00403131e-03f, -5.58890104e-02f, -4.57456103e-03f,
  -2.85459161e-02f, -2.57955462e-01f, -1.51058733e-01f, -2.94504434e-01f, -9.69674438e-02f, -9.86729041e-02f, -1.92149937e-01f, -6.39426410e-02f, -2.27069542e-01f, -3.45782161e-01f,
  1.34124175e-01f, 2.68348187e-01f, -2.98157096e-01f, 2.04642653e-01f, 2.64858305e-01f, 7.20982179e-02f, 1.47497490e-01f, 2.20634446e-01f, 2.98417389e-01f, 2.63554364e-01f,
  1.67625353e-01f, 2.94298947e-01f, 2.93465704e-01f, 5.86443953e-02f, 2.93072592e-02f, 2.26449832e-01f, 2.24821612e-01f, -1.69788286e-01f, -8.59121531e-02f, 1.15754552e-01f,
  2.46808037e-01f, 8.16506222e-02f, 1.22408168e-02f, 1.15524627e-01f, 1.78407520e-01f, 2.29150474e-01f, 2.54803091e-01f, 8.24156180e-02f, 2.51662761e-01f, 1.95605844e-01f,
  -3.31101060e-01f, -1.49274260e-01f, -1.52609600e-02f, -8.10509548e-02f, -5.84796555e-02f, -1.37301564e-01f, -9.67240334e-02f, 5.08721471e-02f, 1.61865093e-02f, -4.40621749e-02f,
  -8.62196460e-03f, 3.08863577e-02f, -1.57767445e-01f, 5.46091162e-02f, -1.32209018e-01f, -7.28573948e-02f, -4.09411304e-02f, 3.40839438e-02f, 2.21099295e-02f, -3.06066219e-02f,
  -4.18506451e-02f, 6.10228442e-02f, 3.97531837e-02f, -7.09571782e-03f, -2.37570144e-02f, 2.02880451e-03f, -4.56320010e-02f, -5.20474091e-02f, -8.98295566e-02f, 7.61266947e-02f,
  -3.44075739e-01f, -1.85287386e-01f, -2.05631688e-01f, -8.17814190e-03f, 2.29242519e-02f, -6.33580461e-02f, -2.58499682e-02f, -3.04561183e-02f, 2.05627177e-02f, -6.98376298e-02f,
  4.13771532e-02f, -2.54677162e-02f, -1.49580762e-01f, -1.25664711e-01f, -1.71650946e-01f, -6.53054118e-02f, -4.22478728e-02f, -1.83867440e-01f, -1.13939352e-01f, -5.16675785e-02f,
  2.75192522e-02f, 1.39285373e-02f, -2.35409718e-02f, -1.01042092e-01f, -5.64585403e-02f, -6.01080954e-02f, -9.57624093e-02f, -1.17550880e-01f, -1.09440610e-02f, 1.26002833e-01f,
  1.79957628e-01f, -1.94885448e-01f, 7.87841752e-02f, 1.25958264e-01f, -8.24614838e-02f, -9.17714611e-02f, 1.36537263e-02f, 7.96319395e-02f, 1.59623325e-02f, -1.29784018e-01f,
  -1.98461667e-01f, -1.59027740e-01f, -1.26809806e-01f, -2.54698861e-02f, -6.62557706e-02f, -1.47648945e-01f, 2.73886304e-02f, 1.49005324e-01f, -1.89641658e-02f, -5.09129390e-02f,
  1.38876541e-02f, 8.88738316e-03f, -4.21028174e-02f, 2.49694716e-02f, 4.40959893e-02f, -5.68557251e-03f, -5.83297312e-02f, -1.24788575e-01f, -2.33592559e-02f, -2.78684758e-02f,
  3.70505810e-01f, 1.09316677e-01f, 3.58884446e-02f, 2.68274061e-02f, -2.18561664e-01f, -1.80839762e-01f, -1.64370716e-01f, -1.81051940e-01f, -1.46464795e-01f, -1.35980025e-01f,
  1.65198520e-01f, 3.87998037e-02f, 1.21515349e-01f, -1.30429626e-01f, -4.91664447e-02f, -3.00482213e-01f, -3.27691168e-01f, -2.70241618e-01f, -2.79170036e-01f, -2.61707723e-01f,
  -2.85660148e-01f, -2.58432627e-01f, -1.09934203e-01f, -3.03814977e-01f, -4.36623663e-01f, -2.79647857e-01f, -1.74691826e-01f, -2.00186804e-01f, -1.90781131e-01f, -3.87179345e-01f,
  -2.73247898e-01f, 2.98074603e-01f, -6.35270178e-02f, -5.17927930e-02f, 1.14712656e-01f, 2.15179045e-02f, 4.29431386e-02f, -1.72647741e-02f, 1.06168650e-02f, 4.19227816e-02f,
  -4.51154821e-02f, 9.47528854e-02f, 6.17921688e-02f, -1.39013445e-02f, 7.52329603e-02f, 1.69458333e-02f, 1.26538679e-01f, 1.15851998e-01f, 6.01461269e-02f, 4.64341082e-02f,
  1.06641583e-01f, 2.45248839e-01f, 3.00224394e-01f, 2.38672197e-01f, 1.42839029e-01f, 1.21729597e-01f, 1.15550853e-01f, 9.63912439e-03f, 1.49870634e-01f, 3.16070616e-02f,
  -1.12635888e-01f, -4.82679345e-02f, -5.56079000e-02f, 2.10048571e-01f, 8.31787139e-02f, 1.85112674e-02f, 3.88301872e-02f, 2.22456753e-02f, -6.30736991e-04f, 1.86161622e-02f,
  3.81055661e-02f, 1.28312707e-01f, 8.40131193e-02f, -2.90407259e-02f, -1.24584185e-02f, 8.49074796e-02f, 2.45315451e-02f, -9.07048509e-02f, 1.05806455e-01f, 1.26156565e-02f,
  1.27923340e-01f, -5.89250512e-02f, -1.15221903e-01f, -1.12939529e-01f, 8.30013584e-03f, 2.40386871e-04f, 3.75935324e-02f, 1.57329813e-01f, -8.15777667e-03f, -2.93717217e-02f,
  1.21116228e-01f, 2.65455425e-01f, -8.61579776e-02f, -5.58304973e-02f, -8.91037751e-03f, -7.92865157e-02f, 4.30172160e-02f, -9.79584083e-02f, -1.83607012e-01f, -1.15420669e-01f,
  -1.47679150e-02f, 1.28889019e-02f, 8.49110708e-02f, -1.35350982e-02f, 1.00021604e-02f, 1.24826552e-02f, 1.65955737e-01f, 1.10139385e-01f, 6.11056685e-02f, -3.87487523e-02f,
  7.03248978e-02f, 1.08901426e-01f, 7.10297227e-02f, 1.38927415e-01f, 1.08536378e-01f, 1.10349067e-01f, -4.28332500e-02f, -9.17645842e-02f, 7.56841302e-02f, -3.29725780e-02f,
  -2.45458752e-01f, -3.22077960e-01f, -3.20055753e-01f, -1.95144206e-01f, 1.65318064e-02f, 5.94528504e-02f, -8.41099545e-02f, -3.80278565e-02f, -6.48620278e-02f, -2.12408617e-01f,
  1.82887111e-02f, 1.87987357e-01f, -3.59090567e-02f, 1.51766241e-01f, 1.94617659e-01f, -1.83471382e-01f, -1.01220816e-01f, 1.07428811e-01f, 2.56149381e-01f, 2.61238486e-01f,
  1.60964191e-01f, 1.03326708e-01f, 1.16520412e-01f, 9.79167894e-02f, -2.00458705e-01f, 2.93454435e-02f, -1.91100374e-01f, -3.82942855e-02f, -1.85119584e-02f, -1.82810470e-01f,
  -3.02289337e-01f, -2.75459260e-01f, 8.56588557e-02f, 5.83704785e-02f, 9.35829338e-03f, -1.15388714e-01f, -1.54533878e-01f, -5.26856184e-02f, 4.76012006e-02f, -1.93037301e-01f,
  -4.92464611e-03f, -4.64952253e-02f, -6.46356270e-02f, -1.27975466e-02f, -3.08820922e-02f, 2.27706395e-02f, 2.96728630e-02f, 6.65590391e-02f, -4.49962504e-02f, -4.45397720e-02f,
  8.61420855e-02f, -4.26739305e-02f, -2.42392689e-01f, -2.98823901e-02f, -1.12780385e-01f, 1.89705472e-02f, -1.00098766e-01f, -2.05643326e-02f, -5.99514954e-02f, -2.40894660e-01f,
  6.74329028e-02f, 8.55081305e-02f, 4.41321284e-02f, -1.92513857e-02f, 1.04754120e-01f, -8.84801801e-03f, 1.82663696e-03f, 9.85920206e-02f, 4.01950516e-02f, -2.03197487e-02f,
  3.53154168e-02f, 8.00385848e-02f, 4.08163816e-02f, -4.56433231e-03f, 7.61121362e-02f, -1.24670029e-01f, -1.29662883e-02f, 4.71705571e-02f, 4.30856198e-02f, 5.68260923e-02f,
  8.16221163e-02f, 5.66092972e-03f, -1.62268686e-03f, 1.13738388e-01f, 2.57255211e-02f, 8.33731666e-02f, -3.93301696e-02f, 7.45493844e-02f, -2.10137088e-02f, 7.20252097e-03f,
  -1.09938681e-01f, 2.02717707e-01f, -2.22741351e-01f, 1.14304051e-02f, -7.85771757e-02f, -9.17770248e-03f, -4.23395596e-02f, 2.92426459e-02f, -6.58554360e-02f, -6.63392171e-02f,
  -3.33059989e-02f, -9.00666639e-02f, -1.94373712e-01f, 6.27074614e-02f, 3.88503373e-02f, -9.46209133e-02f, -3.33180204e-02f, 6.18793583e-03f, 1.30903184e-01f, -7.89178908e-02f,
  -6.60979450e-02f, -3.26545932e-03f, -1.72345102e-01f, -6.67298287e-02f, -8.94662216e-02f, -1.46475118e-02f, -1.47546247e-01f, -1.25149831e-01f, -1.12423874e-01f, -2.35802248e-01f,
  1.20265327e-01f, 9.89680439e-02f, -2.80704170e-01f, 6.21037111e-02f, 1.02748379e-01f, -7.25121051e-02f, -2.30187811e-02f, -1.30392104e-01f, 1.01973288e-01f, 1.38490587e-01f,
  8.16501454e-02f, -9.83119830e-02f, -2.86604285e-01f, -3.50343794e-01f, -4.52942342e-01f, -2.42458403e-01f, -2.95039654e-01f, -3.94826382e-01f, -4.12770301e-01f, -1.42515940e-03f,
  8.92103985e-02f, -1.56683233e-02f, -1.83472797e-01f, -1.67036593e-01f, 6.48322552e-02f, -1.71838835e-01f, -1.24382190e-01f, -6.67274743e-02f, -1.49030253e-01f, -5.50580919e-02f,
  -1.35957643e-01f, -2.68039443e-02f, -4.71930131e-02f, -8.38292390e-02f, 6.95770532e-02f, 5.98285766e-03f, -2.37422120e-02f, -9.84517187e-02f, 3.16880681e-02f, -7.53797814e-02f,
  4.43402939e-02f, 5.10411039e-02f, 2.85741389e-02f, -3.35175321e-02f, -1.97753776e-02f, -6.10589534e-02f, -5.42942360e-02f, -1.47212625e-01f, -5.11863455e-02f, 4.91285436e-02f,
  1.02881297e-01f, 2.22542174e-02f, -2.44882330e-01f, -1.04182154e-01f, -1.47194847e-01f, -1.62904695e-01f, -7.75979683e-02f, -9.95441824e-02f, -1.61033183e-01f, -1.72152482e-02f,
  7.94900698e-05f, 1.92449000e-02f, 1.32116437e-01f, 1.23891473e-01f, 2.13673357e-02f, 1.61574613e-02f, -2.77157892e-02f, -9.10164267e-02f, -5.33230379e-02f, 7.69089311e-02f,
  4.69142683e-02f, -1.06867810e-04f, -5.83089292e-02f, -4.37797159e-02f, -2.06016943e-01f, 1.85768995e-02f, -1.79714970e-02f, -1.85162481e-02f, -8.45158473e-02f, -2.30739433e-02f,
  -7.78435245e-02f, -1.13536723e-01f, 5.57785816e-02f, -1.77900717e-02f, -1.79912187e-02f, -6.66389018e-02f, 1.14438003e-02f, -1.26920536e-01f, -2.48808432e-02f, -6.08625226e-02f,
  -1.49042103e-02f, -1.13126576e-01f, -1.96308140e-02f, -1.29500806e-01f, -4.11161520e-02f, 6.94060475e-02f, 9.77049991e-02f, -5.72259016e-02f, 9.29505080e-02f, 9.25587043e-02f,
  3.85948271e-02f, 1.66884139e-02f, 3.26489955e-02f, -2.12185755e-02f, -9.89668909e-03f, -4.94420752e-02f, 2.61302590e-02f, 8.74521676e-03f, -4.88961814e-03f, 1.91056669e-01f,
  4.12367098e-02f, -1.20549597e-01f, -2.12054610e-01f, -1.22954808e-01f, -4.02742587e-02f, -2.88929433e-01f, -2.04444826e-01f, -1.49560109e-01f, -2.94448465e-01f, -8.33377615e-02f,
  -3.55254710e-01f, -2.90812433e-01f, -7.90248141e-02f, -4.59057301e-01f, -3.57907385e-01f, -1.74269632e-01f, -1.26426518e-01f, -2.61051834e-01f, -3.57248217e-01f, -2.98437804e-01f,
  1.37299742e-03f, 1.60190433e-01f, -3.46373953e-02f, 1.30493432e-01f, 3.29148829e-01f, -4.73505966e-02f, -1.23347186e-01f, 1.30626276e-01f, 2.59231120e-01f, 5.16423136e-02f,
  -2.08053999e-02f, -2.29386732e-01f, -7.91735575e-02f, -1.26722217e-01f, -3.40363264e-01f, -1.48943439e-01f, -2.92454422e-01f, -1.19991459e-01f, 2.21621040e-02f, -3.32381546e-01f,
  -1.01405255e-01f, -2.82004327e-01f, 8.20439607e-02f, 4.50834483e-02f, -1.10488690e-01f, 1.69710387e-02f, -1.41037375e-01f, -1.02061220e-01f, -7.47609586e-02f, -1.44935012e-01f,
  -1.60634354e-01f, 8.07340071e-02f, -1.10740289e-01f, -5.26927486e-02f, -2.50949085e-01f, -1.08646877e-01f, -1.35363728e-01f, 6.26867265e-02f, 1.45046622e-01f, 1.04743280e-01f,
  7.38801733e-02f, -3.29368263e-02f, -8.67283065e-03f, 1.48002043e-01f, 7.38165528e-02f, 1.27552852e-01f, -4.68499102e-02f, 4.93812561e-03f, 1.54934049e-01f, -2.79956311e-01f,
  1.97003726e-02f, 1.10273799e-02f, 9.53720510e-02f, 3.72889973e-02f, 1.20635115e-01f, 4.57635485e-02f, -3.08805471e-03f, 5.50602712e-02f, 5.02272248e-02f, 5.29096276e-02f,
  -3.34806927e-02f, 3.81594116e-04f, -5.16653173e-02f, -2.33253315e-02f, 3.43641974e-02f, 4.87227589e-02f, 9.22879428e-02f, -1.14286900e-03f, 2.96356417e-02f, -2.08953228e-02f,
  2.00378690e-02f, -2.26288922e-02f, 3.78752239e-02f, 6.63144439e-02f, 8.88569504e-02f, -1.45809061e-03f, -5.06957397e-02f, 6.86666071e-02f, -8.57077688e-02f, -6.00347249e-03f,
  -1.80578172e-01f, 3.50934446e-01f, -7.61461556e-02f, 5.55490050e-03f, -5.05380929e-02f, -1.77197382e-02f, -1.21384889e-01f, 5.46037033e-02f, -1.83986410e-01f, -1.61480621e-01f,
  4.82823104e-02f, -7.03794584e-02f, -1.15976140e-01f, 2.34765816e-04f, 9.83642414e-02f, 9.69704986e-02f, -2.24047370e-04f, -5.41404355e-03f, 2.20610306e-01f, -7.83088207e-02f,
  9.43962038e-02f, 4.02668826e-02f, 1.61040619e-01f, 4.21940275e-02f, 2.56750695e-02f, 1.28942341e-01f, 1.09709404e-01f, 1.58823624e-01f, 2.65569717e-01f, -1.68328092e-01f,
  4.67039526e-01f, -4.81151134e-01f, 2.74806261e-01f, 1.50506601e-01f, -4.56362031e-02f, 3.23426374e-03f, -6.71482310e-02f, -1.14452563e-01f, 3.04553155e-02f, -2.34206423e-01f,
  -3.76851827e-01f, -2.13981286e-01f, -1.99022099e-01f, -1.96903665e-02f, 5.80990575e-02f, -5.66015542e-02f, 5.22183627e-02f, 3.42745781e-01f, 3.34445715e-01f, -1.09383225e-01f,
  -3.42834592e-01f, 8.19257572e-02f, 2.39474058e-01f, 1.29283771e-01f, -2.62908757e-01f, -1.06689893e-01f, -1.30189979e-03f, 4.51440103e-02f, -2.26379991e-01f, -1.65364116e-01f,
  -2.07623750e-01f, 1.32586166e-01f, -3.48264538e-02f, -3.58767100e-02f, -4.01781723e-02f, 4.54847291e-02f, -1.00937989e-02f, -5.70917428e-02f, -1.11151211e-01f, -7.55471811e-02f,
  -1.92267876e-02f, -1.92747973e-02f, -3.58055532e-03f, -3.43638472e-02f, -1.54304821e-02f, 3.84356081e-02f, -9.13859680e-02f, -1.34142950e-01f, -1.30635634e-01f, -1.89000532e-01f,
  -2.55088776e-01f, -5.70979491e-02f, 3.98762114e-02f, -6.08580038e-02f, -4.44365516e-02f, 1.23230569e-01f, -5.57013415e-02f, 1.40024675e-02f, 8.18941891e-02f, -1.16317369e-01f,
  1.91594422e-01f, 1.42271603e-02f, 5.76961935e-02f, -6.02005236e-02f, -3.87374945e-02f, -8.24004263e-02f, -9.41725224e-02f, -9.64458287e-02f, 2.70281248e-02f, -1.47357076e-01f,
  -1.62702098e-01f, 2.17594057e-02f, 1.20600592e-02f, -1.47499368e-01f, -7.91664794e-02f, -1.12384399e-02f, -5.60437031e-02f, -8.87188613e-02f, -3.26636992e-02f, -4.12899107e-02f,
  -8.44666734e-02f, -3.71988826e-02f, -9.19802636e-02f, -1.45411015e-01f, -1.34137750e-01f, -1.16271079e-01f, -2.40067262e-02f, 6.30854741e-02f, -6.87762573e-02f, -9.92881805e-02f,
  -3.26530218e-01f, 3.78179580e-01f, 4.60635051e-02f, 8.01398531e-02f, 1.42707512e-01f, 4.96149287e-02f, 1.45734936e-01f, 8.91612843e-02f, 3.22477818e-02f, 1.32641802e-02f,
  5.89373894e-02f, 1.23943843e-01f, 5.54754362e-02f, -1.53309196e-01f, -5.03651612e-02f, 1.90720763e-02f, -8.96601751e-02f, -1.17725842e-01f, 6.32884214e-03f, -4.66200933e-02f,
  -4.93382625e-02f, 3.92481200e-02f, 1.04100868e-01f, -3.03582810e-02f, 8.79767016e-02f, 1.63486660e-01f, -9.84928831e-02f, 2.04519220e-02f, 1.36056095e-01f, -5.68512753e-02f,
  -2.87767127e-02f, -1.91869631e-01f, -2.95272797e-01f, 5.11339605e-02f, -1.05662178e-02f, -7.79727548e-02f, -1.25731483e-01f, -1.58850215e-02f, 8.34877789e-02f, -1.55918390e-01f,
  -1.06274210e-01f, 9.57029164e-02f, -1.37951806e-01f, -1.20501474e-01f, -1.80167317e-01f, -3.82779151e-01f, -3.74359697e-01f, -1.98428318e-01f, 7.91606233e-02f, 2.36091688e-01f,
  1.15923934e-01f, 1.46557108e-01f, 3.57491262e-02f, -6.34853840e-02f, 1.15099087e-01f, 1.78432211e-01f, -1.85968548e-01f, -6.18287399e-02f, -1.74964204e-01f, -1.10080875e-01f,
  6.86063096e-02f, -1.61745861e-01f, -1.03566185e-01f, -1.61730215e-01f, -3.88406813e-02f, -4.51496430e-02f, 5.21637350e-02f, 3.50532345e-02f, -7.03500733e-02f, 7.11868051e-03f,
  4.56417240e-02f, -1.49117950e-02f, 7.73691237e-02f, 3.45589928e-02f, 7.54095614e-02f, 8.68103579e-02f, -1.07035711e-02f, -1.48366779e-01f, -2.10181937e-01f, -9.21426341e-02f,
  -1.24334330e-02f, -9.96353626e-02f, -1.31272390e-01f, -1.65513139e-02f, 7.12862089e-02f, 4.47348654e-02f, 1.96969621e-02f, 1.09183319e-01f, -6.02187477e-02f, 2.99888644e-02f,
  9.07415338e-03f, 1.47892656e-02f, 5.36813252e-02f, 7.66069293e-02f, 5.97693399e-02f, 3.44875008e-02f, 2.99653765e-02f, 8.31530690e-02f, 9.44001693e-03f, -7.81450793e-03f,
  -3.42432479e-03f, -8.37249681e-02f, 2.98620295e-02f, -1.11562371e-01f, -7.07393214e-02f, -8.48338529e-02f, -4.45854254e-02f, -6.93155080e-02f, -8.24905932e-02f, -4.26945910e-02f,
  -5.62961139e-02f, 8.01726058e-03f, 3.70213427e-02f, -1.40366163e-02f, -2.19199240e-01f, -1.26481026e-01f, -9.52071790e-03f, -2.64591798e-02f, 5.44648878e-02f, -6.18330501e-02f,
  2.69265831e-01f, -2.91857511e-01f, 1.69341750e-02f, -6.63605332e-02f, -1.19724803e-01f, -9.85359959e-03f, -3.75864506e-02f, -1.03660166e-01f, -4.89831641e-02f, 1.08689964e-01f,
  6.76977308e-03f, 8.15155730e-02f, 3.44925886e-03f, 1.12287188e-03f, 4.93641533e-02f, 1.02218632e-02f, -1.27988905e-01f, -3.00484337e-03f, -7.34242573e-02f, 9.43889916e-02f,
  -9.33161005e-02f, -1.40709400e-01f, 5.42026497e-02f, 8.23196918e-02f, 2.92265285e-02f, 1.13889299e-01f, 1.86157882e-01f, 1.66479468e-01f, -3.98956090e-02f, 7.97641575e-02f,
  -4.97886896e-01f, -3.09597433e-01f, -2.97357529e-01f, -3.72881256e-02f, 1.00220680e-01f, -2.18870804e-01f, -3.54924649e-01f, -3.07802647e-01f, -5.76690547e-02f, -1.82532445e-01f,
  5.48016140e-03f, 2.91084737e-01f, -2.28068745e-03f, 8.43229964e-02f, -2.55755521e-02f, -3.05826604e-01f, -9.35539156e-02f, 2.44526775e-03f, 2.44976148e-01f, 3.73124152e-01f,
  3.36269945e-01f, 3.24401945e-01f, 2.07152307e-01f, 1.17108352e-01f, 1.83368847e-01f, 2.36191779e-01f, -7.16059580e-02f, 1.25977650e-01f, -3.69290374e-02f, -1.32992446e-01f,
  -1.97873171e-02f, -3.77942055e-01f, 5.45225069e-02f, 1.70534149e-01f, 4.96594720e-02f, -1.59488723e-01f, -2.01583896e-02f, -7.68695995e-02f, -1.02468878e-01f, -1.36880666e-01f,
  1.01404555e-01f, -2.77602226e-02f, 9.30010080e-02f, 1.79580852e-01f, 1.19123749e-01f, -1.09192580e-01f, 3.75742055e-02f, -1.80597037e-01f, -2.08091855e-01f, 9.33510158e-03f,
  1.31222516e-01f, -6.04850128e-02f, -2.01564550e-01f, -1.22442029e-01f, -1.12309732e-01f, 9.71043333e-02f, 6.57535642e-02f, -7.52890203e-03f, -1.87723100e-01f, -7.93467835e-02f,
  1.13701252e-02f, 1.40351519e-01f, 4.55367863e-02f, -2.97241695e-02f, -2.65674223e-03f, -5.33284396e-02f, -5.81925586e-02f, -2.24147048e-02f, 2.34916378e-02f, -3.81442532e-02f,
  -1.19375877e-01f, -9.16528404e-02f, 7.06183314e-02f, -1.41624048e-01f, 4.70143333e-02f, 2.14524474e-02f, -1.36332169e-01f, -1.39389541e-02f, 3.72869223e-02f, -1.21360816e-01f,
  -6.89924732e-02f, -4.68411855e-03f, 8.49556252e-02f, -2.32161898e-02f, -8.60238895e-02f, -8.78289193e-02f, -3.88949364e-02f, 4.93085980e-02f, 1.67279109e-01f, -4.27324511e-02f,
  1.50242344e-01f, 3.67637549e-04f, -1.13869339e-01f, 3.11809517e-02f, -2.91065350e-02f, 5.20880185e-02f, -7.64368335e-03f, -6.84688911e-02f, -1.50347233e-01f, 8.25280510e-03f,
  2.22802740e-02f, -8.61316621e-02f, 2.43944172e-02f, 1.31516919e-01f, 6.26951307e-02f, 5.43564186e-03f, 6.57081883e-03f, -2.29615625e-02f, -1.10848345e-01f, 8.09120685e-02f,
  -2.39353199e-02f, -2.05265254e-01f, -1.78014100e-01f, -2.41065189e-01f, -4.59446055e-05f, -2.53467876e-02f, 4.52294648e-02f, 9.51221958e-03f, -1.77264810e-01f, -1.27073437e-01f,
  -3.96174520e-01f, 5.54403737e-02f, -5.38797723e-03f, 3.79629843e-02f, 2.34841947e-02f, 5.72120165e-03f, 9.36253965e-02f, 4.53784019e-02f, 4.21194620e-02f, 1.28150403e-01f,
  -2.24587638e-02f, -4.69152741e-02f, -6.10821433e-02f, -6.27682805e-02f, -6.82420582e-02f, 1.42822356e-03f, 1.03168935e-01f, -1.61883399e-01f, -1.28162175e-01f, 4.93402928e-02f,
  -8.24320018e-02f, -8.08099508e-02f, -1.78854793e-01f, 4.44980748e-02f, 1.43042460e-01f, 4.19543162e-02f, 3.71216796e-02f, -2.31455881e-02f, 5.48439957e-02f, -1.77278258e-02f,
  1.65917650e-01f, -1.47612080e-01f, 2.68177614e-02f, -2.49997228e-02f, 6.34851679e-02f, -4.68699560e-02f, -3.96893881e-02f, 1.18646272e-01f, 1.33639500e-01f, 1.87609211e-01f,
  9.86317173e-02f, -1.24387620e-02f, -8.47846642e-02f, 6.61543012e-02f, 1.13002993e-01f, -5.97389881e-03f, 8.35701972e-02f, 1.27685592e-01f, 1.89024583e-01f, 1.01125166e-01f,
  -1.35517595e-02f, -4.92050089e-02f, 2.06342787e-01f, 2.97086947e-02f, 2.51552928e-02f, 5.16757322e-03f, 2.09525675e-02f, 9.50660929e-02f, -5.36672845e-02f, 3.62372100e-02f,
  1.08401708e-01f, 1.93108097e-01f, -3.43793258e-02f, -4.01781313e-02f, -8.77383351e-02f, 1.49613425e-01f, 1.56514943e-01f, 1.36925623e-01f, 9.58842575e-04f, -8.40106755e-02f,
  9.09351483e-02f, -4.38536294e-02f, 1.73648242e-02f, 2.68719215e-02f, -1.05432272e-01f, 1.55794984e-02f, 1.10104783e-02f, -2.01808792e-02f, 1.33623509e-02f, -6.79142475e-02f,
  -1.23694554e-01f, 1.70516729e-01f, 5.12559712e-02f, 1.03540216e-02f, 8.64832252e-02f, 7.66957924e-02f, 1.82111114e-02f, -5.29563688e-02f, 2.98705362e-02f, 4.50195372e-02f,
  2.41500318e-01f, -4.58567739e-01f, -6.53215125e-02f, -1.66438907e-01f, -1.57709327e-02f, -1.77784986e-03f, -9.60863307e-02f, -5.99344969e-02f, 7.54858255e-02f, 1.44743517e-01f,
  4.57091406e-02f, 1.72706824e-02f, -4.17258143e-02f, 4.57215458e-02f, 7.20842183e-03f, 3.99331786e-02f, -5.63599318e-02f, -3.95485461e-02f, -6.43198332e-03f, 6.07991070e-02f,
  1.02020271e-01f, 6.38159961e-02f, 1.52952328e-01f, -1.29487729e-02f, -2.53987592e-02f, -7.98657686e-02f, 1.92111339e-02f, 2.72129104e-02f, 5.36473002e-03f, 1.61637425e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 104)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 104;
const float L0_fan_Bp_bar_data[] = {
  3.26207101e-01f, 3.42591286e-01f, 3.44556719e-01f, 1.56277955e-01f, 4.47215736e-01f, 4.01223868e-01f, 2.09940493e-01f, 2.18827665e-01f, 4.82839853e-01f, 4.36728179e-01f,
  2.77704239e-01f, 4.50654358e-01f, 7.85955116e-02f, 3.13515693e-01f, 3.91282469e-01f, 4.19805437e-01f, 2.94924140e-01f, 1.64649010e-01f, 5.54062068e-01f, 1.03517056e-01f,
  2.11164653e-01f, 4.95181680e-01f, 5.50078571e-01f, 3.99076790e-01f, 2.89622098e-01f, 1.67649925e-01f, 2.73221493e-01f, 2.44740844e-01f, 1.18773319e-01f, 2.05901742e-01f,
  6.29388571e-01f, 1.93232015e-01f, 1.49158403e-01f, 4.71494287e-01f, 4.29730773e-01f, 2.67752439e-01f, 3.76547605e-01f, 6.45575449e-02f, 1.61914617e-01f, 3.68545294e-01f,
  2.71759510e-01f, 6.23366773e-01f, 1.38509527e-01f, 2.82453656e-01f, 1.76197290e-01f, -9.87326168e-03f, 2.06102967e-01f, 2.74922907e-01f, 4.54497904e-01f, 3.33355427e-01f,
  3.82662982e-01f, 3.82180214e-01f, 3.40342283e-01f, -6.90701185e-03f, 2.28239894e-01f, 4.13443863e-01f, 3.35110515e-01f, 3.00866812e-01f, 1.34102806e-01f, 3.76092046e-01f,
  3.81345719e-01f, 2.98286289e-01f, 1.29734933e-01f, 2.20434815e-01f, 2.74257123e-01f, 2.03945950e-01f, 4.57112432e-01f, 5.07699013e-01f, 2.31254160e-01f, 7.17327058e-01f,
  3.20908159e-01f, 4.80934590e-01f, 1.39998823e-01f, 1.23493940e-01f, 2.96063721e-01f, 2.45655462e-01f, 4.27139223e-01f, 3.56315315e-01f, 3.81541312e-01f, 4.90401387e-01f,
  5.81661761e-01f, 1.18247949e-01f, 4.95824188e-01f, 1.30772516e-01f, 2.14260191e-01f, 1.08146459e-01f, 2.69097835e-01f, 2.20155656e-01f, 2.58595526e-01f, 2.12182879e-01f,
  3.67079169e-01f, 4.67920810e-01f, 2.52505928e-01f, 6.35235161e-02f, 3.14329654e-01f, 1.03134908e-01f, 3.07360888e-01f, 2.50788361e-01f, 2.74256319e-01f, 2.61518985e-01f,
  5.79467475e-01f, 2.29381830e-01f, 3.74320298e-01f, 4.04506028e-02f
};

// L1_linear_W (Shape: 12 x 128)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 128;
const float L1_linear_W_data[] = {
  -7.95483366e-02f, -4.24621776e-02f, -1.07545868e-01f, 3.50562111e-02f, -1.18380323e-01f, -1.78230643e-01f, -1.24907069e-01f, -1.49633884e-01f, -2.13062689e-01f, 4.25834134e-02f,
  -5.20817041e-02f, -3.08700707e-02f, 3.19375545e-02f, 2.69766245e-02f, 1.08971238e-01f, -8.41901824e-03f, 2.79657654e-02f, 1.01043731e-01f, 1.24651246e-01f, -2.99278852e-02f,
  -4.91077080e-02f, -6.75159926e-03f, 6.12996593e-02f, 5.31574041e-02f, -9.39315408e-02f, -6.15894049e-02f, 6.69798777e-02f, 1.78047955e-01f, -1.82701319e-01f, -9.54468623e-02f,
  5.93810201e-01f, -3.98428105e-02f, -3.71742219e-01f, -3.18274125e-02f, 9.22384858e-03f, -2.92428255e-01f, 2.04665974e-01f, -4.17797953e-01f, -9.60924327e-02f, -3.04150313e-01f,
  -4.37125742e-01f, 2.46905237e-01f, -1.35880217e-01f, -3.23006809e-02f, 1.89300179e-01f, -2.28884876e-01f, -3.74688983e-01f, -2.35776201e-01f, 6.02039635e-01f, -1.19649477e-01f,
  6.15819097e-01f, -2.78056353e-01f, 6.82002902e-02f, 3.67341116e-02f, -1.58796474e-01f, -6.43205121e-02f, 1.04878664e-01f, -1.78751037e-01f, -5.65537274e-01f, 1.27856269e-01f,
  3.57635901e-03f, 7.26657808e-02f, 6.03717640e-02f, -1.16784327e-01f, 2.16966346e-01f, 7.75227547e-02f, 1.84844211e-01f, -1.06695175e-01f, 3.15049022e-01f, -2.28720799e-01f,
  -9.73147526e-02f, -8.30921307e-02f, 1.07885497e-02f, -2.19327971e-01f, -5.13303041e-01f, -2.76183486e-01f, -1.09199353e-01f, 3.28801684e-02f, 1.56269390e-02f, -3.22229832e-01f,
  -8.92387033e-02f, -1.86306372e-01f, 1.64698228e-01f, 1.27696946e-01f, -3.08523566e-01f, -5.15135765e-01f, -6.79220706e-02f, -1.42715335e-01f, 1.45028114e-01f, 1.33941129e-01f,
  1.46205947e-01f, -4.87207383e-01f, -4.46748346e-01f, -1.95495393e-02f, 2.44824469e-01f, 1.44273147e-01f, 4.14815366e-01f, 1.09139577e-01f, 1.82061195e-01f, 2.53332376e-01f,
  -6.88392818e-01f, -4.61232781e-01f, -4.56084967e-01f, -5.88216186e-01f, -1.39997244e-01f, 2.90629864e-01f, -1.08647130e-01f, -5.99484518e-02f, 1.58144668e-01f, 5.34455962e-02f,
  -7.94149935e-02f, -1.61930650e-01f, 5.53050004e-02f, -4.93212581e-01f, -1.30764365e-01f, -1.51390463e-01f, -9.29106761e-07f, 1.15106024e-01f, -7.85285607e-03f, -1.78289354e-01f,
  2.34456450e-01f, 4.50963199e-01f, 2.15239927e-01f, 9.88969877e-02f, -1.78098425e-01f, 3.78340006e-01f, 4.88057107e-01f, 5.81639931e-02f, -3.06816157e-02f, 1.04165524e-01f,
  6.29653037e-02f, -1.41881302e-01f, -4.84114066e-02f, -8.56323317e-02f, 1.69272065e-01f, -3.85135934e-02f, 6.25384599e-02f, -2.91779209e-02f, -1.08962856e-01f, 3.54661308e-02f,
  1.36893407e-01f, 6.85754642e-02f, -3.32609713e-02f, -4.34193462e-02f, -2.36712262e-01f, 7.15328828e-02f, -1.45697519e-01f, -1.07797254e-02f, 1.67691499e-01f, 4.11322042e-02f,
  1.45931840e-02f, 1.93712506e-02f, -5.04727781e-01f, -3.21977139e-01f, 1.40484869e-01f, 1.46732941e-01f, -3.56355071e-01f, 2.26888150e-01f, -4.80583720e-02f, 1.21951737e-01f,
  -1.96454585e-01f, 3.11178505e-01f, -1.20981470e-01f, 2.23743632e-01f, 4.54227805e-01f, 6.62490502e-02f, 4.63711135e-02f, -5.89369178e-01f, -4.58940953e-01f, -3.76889318e-01f,
  -6.90786421e-01f, -4.21721255e-03f, 3.20089281e-01f, -9.10382450e-01f, -5.50932229e-01f, -2.35773340e-01f, 3.78105849e-01f, -1.09332092e-01f, 6.61109090e-02f, -3.43237549e-01f,
  -9.48290005e-02f, 1.43972903e-01f, -7.14851916e-01f, 3.59939545e-01f, 7.03892708e-02f, -1.57635987e-01f, -3.72363299e-01f, -5.30597150e-01f, -2.37593874e-01f, -1.28332712e-02f,
  9.88983586e-02f, 1.95509836e-01f, -5.15260518e-01f, 4.76882271e-02f, 3.83293978e-03f, 1.25267163e-01f, 1.84671074e-01f, -5.97911030e-02f, -2.70169348e-01f, -5.24933077e-02f,
  -9.17299986e-02f, -4.22378510e-01f, -1.97659999e-01f, -3.74294907e-01f, 6.16384596e-02f, 1.68850601e-01f, -7.43337814e-03f, -2.26755626e-02f, 3.24380994e-01f, -5.93584657e-01f,
  -5.85036390e-02f, -3.37037623e-01f, -1.14871047e-01f, 8.79079551e-02f, 3.03872824e-02f, 1.65367410e-01f, -5.02558112e-01f, 1.04339652e-01f, 3.60504270e-01f, -1.04905590e-01f,
  -1.57299638e-01f, 4.65655118e-01f, 2.13803738e-01f, 6.87719584e-01f, 1.66961193e-01f, 3.87533456e-01f, 3.21162969e-01f, 3.52533162e-01f, 1.60091534e-01f, -1.85457975e-01f,
  7.55765438e-02f, -3.06724846e-01f, 3.51256877e-01f, -6.31602347e-01f, -4.10177827e-01f, 1.26604289e-01f, 7.57723004e-02f, -2.49323279e-01f, 1.13947153e-01f, -1.41368940e-01f,
  1.42903075e-01f, -1.39194638e-01f, 1.69329435e-01f, -3.99153173e-01f, 2.22162962e-01f, -6.17357008e-02f, 1.09394111e-01f, 6.76942803e-03f, 2.12916732e-01f, 1.36629418e-01f,
  -6.00710750e-01f, 3.86305571e-01f, 1.02718055e-01f, -1.02632396e-01f, -5.02714515e-01f, -1.10010438e-01f, 1.29547119e-01f, 4.99867499e-02f, 1.99735798e-02f, 5.32062165e-02f,
  1.00400060e-01f, -3.34004732e-03f, 8.06361437e-02f, -3.44035705e-03f, 7.70786330e-02f, 1.89339504e-01f, 1.60073295e-01f, 3.03757191e-02f, -2.26609156e-01f, 1.17365532e-01f,
  -2.11329564e-01f, -2.15020701e-02f, -6.75034076e-02f, 1.24036670e-01f, -2.26603135e-01f, 1.50623530e-01f, 1.54058874e-01f, -1.36418164e-01f, 2.10807156e-02f, -1.95245460e-01f,
  2.45395854e-01f, 2.60645002e-01f, 2.51967996e-01f, -3.36516947e-01f, 3.54716390e-01f, -9.97256786e-02f, 1.22057766e-01f, -3.34973559e-02f, -3.06596886e-03f, -4.63566273e-01f,
  1.27492622e-01f, 7.65199959e-02f, -3.08002859e-01f, -4.80829298e-01f, -1.04011677e-01f, -3.91513318e-01f, -2.36384004e-01f, -9.33545008e-02f, -5.51896214e-01f, 6.60498738e-02f,
  -2.49628052e-01f, -2.51274437e-01f, -2.56353647e-01f, 2.18472153e-01f, -1.68845832e-01f, 7.22114369e-02f, -2.61420429e-01f, -8.78561288e-02f, 8.77323374e-02f, 2.17160806e-01f,
  3.67053092e-01f, -3.97622377e-01f, 1.40340161e-02f, 1.32459290e-02f, -3.42607856e-01f, 1.90389112e-01f, -2.81654477e-01f, 1.85995907e-01f, 9.19897482e-02f, -6.24281019e-02f,
  -2.85791844e-01f, -2.44218055e-02f, -1.51861265e-01f, -2.40464970e-01f, -1.38139918e-01f, -2.37733290e-01f, -2.10005492e-01f, 2.11618006e-01f, 3.92273702e-02f, 1.80379644e-01f,
  -3.12990189e-01f, 6.53022110e-01f, 1.15987487e-01f, -2.25483418e-01f, -1.87622979e-01f, -1.84741482e-01f, -5.09520024e-02f, 4.05395269e-01f, -1.76855415e-01f, -6.37828410e-02f,
  -2.96785742e-01f, -1.26847923e-02f, -8.88831690e-02f, -2.56822318e-01f, 1.38328522e-01f, -2.68440962e-01f, 1.66259155e-01f, -2.97213376e-01f, 9.36811194e-02f, 5.28200686e-01f,
  -1.57327116e-01f, 4.26808745e-01f, 1.50919765e-01f, -1.80426046e-01f, 3.80410492e-01f, 2.56359756e-01f, 3.47842216e-01f, 3.95706035e-02f, 3.29341263e-01f, 2.12821841e-01f,
  7.59287253e-02f, -1.67095572e-01f, -1.76555570e-02f, -3.61431651e-02f, 2.53943324e-01f, -2.41341114e-01f, -1.63176283e-01f, 1.13138042e-01f, -2.69129097e-01f, -3.40902776e-01f,
  -1.80351138e-02f, -1.57366842e-01f, -1.09542742e-01f, 1.10875949e-01f, 9.17843357e-02f, -2.65578687e-01f, -3.56526976e-03f, 4.46541309e-01f, -3.47504467e-01f, 2.73781806e-01f,
  2.15684652e-01f, -1.74781755e-01f, 3.57355267e-01f, -3.30830477e-02f, -5.65998033e-02f, -4.48365770e-02f, -8.32985267e-02f, -4.61458340e-02f, -3.54821724e-03f, 1.35216475e-01f,
  -1.37931392e-01f, 3.63697447e-02f, -6.95936754e-02f, -7.85426497e-02f, -1.52845234e-01f, 6.50732145e-02f, 1.38326049e-01f, 1.83670163e-01f, -1.43602639e-01f, 9.43596512e-02f,
  2.25664191e-02f, -6.57641888e-02f, 1.09302491e-01f, 6.80962577e-02f, 3.85519825e-02f, 5.89728029e-03f, -1.49969921e-01f, 1.59398913e-02f, -1.41292783e-02f, 7.61235729e-02f,
  6.66473731e-02f, -1.18062153e-01f, 4.52400684e-01f, -4.92686868e-01f, -2.27793247e-01f, -1.23749435e-01f, -3.51599783e-01f, -1.81068823e-01f, -1.30537629e-01f, -4.44837362e-02f,
  -2.37169921e-01f, -2.05149993e-01f, 1.78207397e-01f, -3.64570469e-01f, 4.03946280e-01f, 4.25618678e-01f, -2.12432563e-01f, 6.75837547e-02f, 2.47377902e-01f, 1.98159486e-01f,
  5.39928734e-01f, 1.23484373e-01f, -4.08560157e-01f, -1.22225948e-01f, -6.74495816e-01f, 4.83131617e-01f, -3.35980952e-01f, -5.16694523e-02f, 2.57629961e-01f, -9.90990698e-02f,
  1.16858222e-01f, -7.89124966e-01f, -3.91863227e-01f, 1.53149858e-01f, 1.73311025e-01f, -8.51171557e-03f, -1.65962890e-01f, -2.36167565e-01f, 4.65775669e-01f, -3.23953177e-03f,
  9.55692027e-03f, -2.00542957e-01f, -1.92435652e-01f, -3.70620221e-01f, 3.16211618e-02f, -2.73814708e-01f, 4.64297742e-01f, -3.92029613e-01f, 4.25213665e-01f, 6.31584302e-02f,
  -8.74962136e-02f, -2.97298551e-01f, 2.61365682e-01f, -3.97397399e-01f, -1.55255675e-01f, -1.11884765e-01f, 6.04106009e-01f, 3.63470435e-01f, -1.62284568e-01f, -8.57016593e-02f,
  -2.34879240e-01f, -1.05694747e-02f, -1.28565952e-01f, 1.13667041e-01f, -2.15884522e-01f, -5.27447581e-01f, 4.96578425e-01f, -4.13132831e-02f, -1.57562584e-01f, -3.24737728e-01f,
  -1.44677952e-01f, -2.31445640e-01f, 2.48846307e-01f, -2.08299056e-01f, -5.38968630e-02f, 1.39569342e-01f, -3.16209853e-01f, 2.44272813e-01f, -2.34411374e-01f, 3.35428864e-01f,
  -9.35426950e-02f, -5.61212264e-02f, -6.01129830e-01f, 1.52866274e-01f, -2.46778145e-01f, -1.79696500e-01f, 3.25991809e-02f, -2.35714510e-01f, -3.79910231e-01f, -1.06350459e-01f,
  -1.56082347e-01f, -3.86101574e-01f, -3.11322153e-01f, -1.61457449e-01f, -2.13553309e-02f, 1.12361193e-01f, 5.21146879e-02f, 3.95194799e-01f, -3.01143944e-01f, -5.18854618e-01f,
  -3.46782565e-01f, -4.20033708e-02f, -9.16500390e-02f, -4.54389527e-02f, 1.15756029e-02f, 4.89526950e-02f, -3.72060165e-02f, 9.84955672e-03f, 7.65613094e-03f, -1.57717854e-01f,
  -1.28923759e-01f, -1.78315610e-01f, -9.40011814e-02f, -2.02773232e-02f, -1.49003178e-01f, -2.21818343e-01f, -2.64973402e-01f, 2.37795740e-01f, 5.16865849e-02f, 3.85901928e-02f,
  -8.14054906e-03f, 1.35187134e-02f, 2.80630648e-01f, -1.10176101e-01f, -8.74802992e-02f, -3.82487625e-02f, 3.78327118e-03f, -3.69391322e-01f, -3.64502296e-02f, 2.34561548e-01f,
  -3.06730330e-01f, -2.45856464e-01f, -6.08131826e-01f, 7.02409297e-02f, 2.32579168e-02f, -1.90005854e-01f, -5.31562790e-02f, -2.57714838e-02f, -3.33542854e-01f, 1.23292003e-02f,
  -3.32873553e-01f, 4.57414836e-01f, 2.70148844e-01f, -1.56133547e-01f, 3.02801043e-01f, 8.11616182e-02f, -7.70319626e-02f, 3.02572042e-01f, 2.93812186e-01f, -2.59808004e-01f,
  -3.26982081e-01f, -3.38226394e-03f, -4.21376109e-01f, -1.43857032e-01f, 5.66364378e-02f, -7.11586177e-02f, -8.89952928e-02f, 2.16202825e-01f, -2.25084513e-01f, 3.89890820e-01f,
  2.66601354e-01f, 2.77372956e-01f, 1.81424603e-01f, -2.07241192e-01f, -1.12343267e-01f, 7.51548186e-02f, -2.97281086e-01f, -5.17156363e-01f, 3.18401158e-01f, 1.13159396e-01f,
  -2.17757285e-01f, 1.73903897e-01f, -6.89123124e-02f, 1.04040772e-01f, -2.96830922e-01f, 4.58843261e-01f, 3.23158354e-01f, 5.28901696e-01f, -2.49178745e-02f, -2.53478020e-01f,
  1.85813189e-01f, -2.32116967e-01f, -3.48971426e-01f, -1.93004459e-01f, -5.49351752e-01f, 7.78794885e-02f, -8.22795555e-02f, -1.39443651e-01f, 2.78741896e-01f, -1.86212748e-01f,
  1.98186219e-01f, 2.67732646e-02f, -2.59179443e-01f, -1.74203962e-02f, 9.88193527e-02f, -3.62192333e-01f, -9.48281735e-02f, -6.93743825e-02f, -6.60928562e-02f, 1.97433797e-03f,
  2.07890362e-01f, 2.08756804e-01f, 5.07238865e-01f, -1.59237668e-01f, 2.76437968e-01f, -8.24439600e-02f, -2.37721056e-02f, 1.02040969e-01f, -4.95555073e-01f, -2.35553849e-02f,
  3.39943290e-01f, 2.27508038e-01f, -1.12420976e-01f, 1.38312533e-01f, -1.35353714e-01f, 1.40587270e-01f, 2.06020951e-01f, -9.32201818e-02f, -2.56467223e-01f, -1.16852388e-01f,
  -6.15422521e-03f, 1.30947188e-01f, -6.11224510e-02f, -3.63718420e-01f, 1.71384037e-01f, -3.20745558e-01f, -1.11521028e-01f, -3.15764584e-02f, -2.19051465e-01f, 6.80987984e-02f,
  1.33975685e-01f, -6.79348176e-03f, 2.43755504e-02f, 9.50173959e-02f, 8.31968412e-02f, 1.28346369e-01f, 3.77764665e-02f, 1.29832149e-01f, 7.02307671e-02f, 1.16509497e-01f,
  1.21553890e-01f, 1.34491101e-01f, 5.89680038e-02f, 6.01289682e-02f, 6.47673383e-02f, 2.15004832e-01f, 9.37857851e-02f, 1.60283312e-01f, 3.05887032e-02f, -1.90276280e-01f,
  1.48593158e-01f, -3.20845321e-02f, 7.24202916e-02f, 1.13885030e-01f, -1.40961587e-01f, 1.79902777e-01f, -2.11273789e-01f, 1.73059374e-01f, 1.79160297e-01f, 2.68317699e-01f,
  -1.34356514e-01f, -1.60913214e-01f, 3.01949382e-01f, 1.23081580e-02f, -3.96972328e-01f, -8.99265930e-02f, 7.41996244e-02f, 5.52735999e-02f, -1.22218474e-03f, 5.80458224e-01f,
  -1.32664323e-01f, -2.69211262e-01f, 5.28837562e-01f, 1.55582996e-02f, -1.17558353e-01f, 5.50874770e-01f, 5.40801212e-02f, -1.18465498e-01f, 2.04752475e-01f, -1.37490243e-01f,
  3.68226320e-01f, -9.78909433e-02f, -7.31742233e-02f, -1.78927109e-01f, -4.74514484e-01f, 1.03857718e-01f, 1.63001548e-02f, 3.04830462e-01f, 3.61883491e-01f, -3.15584213e-01f,
  1.73895955e-01f, -2.02352569e-01f, -5.30065643e-03f, 3.82678837e-01f, 4.54132736e-01f, -8.70687366e-02f, -2.20494986e-01f, 1.55505747e-01f, 1.04294583e-01f, -3.24580759e-01f,
  7.85349607e-02f, -4.05809790e-01f, -4.29511189e-01f, -4.05029088e-01f, -6.36416614e-01f, -3.82012308e-01f, -1.48114234e-01f, -1.12459935e-01f, -2.57863164e-01f, 7.65164554e-01f,
  -6.09405562e-02f, -2.30745733e-01f, 2.95734346e-01f, -4.53526914e-01f, -1.62118316e-01f, 1.28138706e-01f, -3.16391662e-02f, -3.92411873e-02f, 3.05504084e-01f, 2.79755354e-01f,
  2.30480000e-01f, 6.19218171e-01f, -6.80941761e-01f, -5.71916938e-01f, 3.31578225e-01f, 7.41762063e-03f, -2.19665974e-01f, -4.90244292e-02f, -4.56623107e-01f, -2.98054248e-01f,
  -6.29457593e-01f, -4.62185711e-01f, 7.06565529e-02f, 2.88986772e-01f, 1.93389520e-01f, -4.35285091e-01f, 2.91252792e-01f, -1.61648840e-01f, -8.57152641e-02f, -4.95361716e-01f,
  -2.06091508e-01f, 1.17226958e-01f, 4.34055738e-02f, 2.57324725e-01f, 3.81111093e-02f, 3.75969052e-01f, -7.63769150e-02f, 1.07798129e-01f, -3.26345146e-01f, 1.56530097e-01f,
  -1.47993088e-01f, -9.31752995e-02f, 2.84221053e-01f, -1.82729572e-01f, -2.40436286e-01f, -3.89328822e-02f, 1.03925645e-01f, 1.16791598e-01f, 6.05857037e-02f, -1.78771123e-01f,
  1.68229789e-02f, -2.12973118e-01f, 1.79907158e-02f, 8.09912905e-02f, 2.02357117e-02f, 4.85066995e-02f, -1.15670197e-01f, 1.16559744e-01f, 1.16941169e-01f, 7.58100003e-02f,
  -1.03746980e-01f, -2.10038140e-01f, -8.17360878e-02f, -2.16588527e-01f, -2.36249089e-01f, -3.87667939e-02f, -1.46928415e-01f, 1.25899732e-01f, -1.28234521e-01f, 1.59982681e-01f,
  6.32172525e-02f, 1.82267919e-01f, 9.11582783e-02f, 3.54012966e-01f, -1.22245051e-01f, -2.60169327e-01f, -5.16015112e-01f, 8.95756409e-02f, 3.07757080e-01f, -1.71136990e-01f,
  8.80969167e-02f, -7.60748014e-02f, 1.53105900e-01f, 1.10763714e-01f, -1.58222601e-01f, -1.44477129e-01f, 2.81908453e-01f, -3.63895148e-01f, -4.99545336e-01f, -2.52516568e-01f,
  5.26650786e-01f, 6.30364344e-02f, -1.12329841e-01f, -1.91757917e-01f, -2.26032004e-01f, -7.50876740e-02f, -6.66188896e-01f, -2.19721496e-01f, -1.87522620e-01f, -3.09682906e-01f,
  2.21905664e-01f, 2.33774439e-01f, -3.42540532e-01f, -3.21372718e-01f, -9.64683220e-02f, 1.36014402e-01f, 2.03345537e-01f, 1.87626183e-01f, -1.24403477e-01f, -3.26806813e-01f,
  1.43801451e-01f, -1.89348519e-01f, -9.46342945e-02f, -4.08308715e-01f, -1.37705103e-01f, 2.22409517e-01f, -2.87593096e-01f, -9.45754051e-02f, -2.33888254e-01f, -4.03715938e-01f,
  -1.89853594e-01f, 1.98274061e-01f, -4.16994452e-01f, 4.53823149e-01f, -3.60900968e-01f, -2.92957276e-01f, -5.81595451e-02f, -5.87593857e-03f, -1.82466973e-02f, 3.56264472e-01f,
  -1.34054542e-01f, -4.68687952e-01f, 2.14586943e-01f, -6.15847558e-02f, -3.30406823e-04f, 2.37916484e-01f, -5.72881877e-01f, -1.83929935e-01f, -1.20036542e-01f, -1.37612200e-03f,
  1.78672731e-01f, -2.13893339e-01f, -2.75265694e-01f, -4.07532334e-01f, -1.87206745e-01f, -1.26601025e-01f, -3.42179954e-01f, -6.28209531e-01f, -3.18159878e-01f, 4.65993822e-01f,
  5.46126902e-01f, 7.38771483e-02f, 1.81692556e-01f, -4.21077937e-01f, 3.34737867e-01f, -9.12278965e-02f, -1.36124894e-01f, 5.10487035e-02f, -2.18238890e-01f, -1.89740419e-01f,
  4.40272510e-01f, -2.68003851e-01f, -1.17357887e-01f, 1.74633428e-01f, -3.21079135e-01f, 8.19650814e-02f, 5.39972842e-01f, 8.31097215e-02f, -4.55359101e-01f, -4.18239206e-01f,
  -4.94185001e-01f, -2.54647404e-01f, 1.33035168e-01f, -1.89092413e-01f, -6.81117058e-01f, -1.67005330e-01f, 5.08688390e-02f, -1.11827873e-01f, 4.66807261e-02f, -5.82758971e-02f,
  -1.23019896e-01f, -1.01826742e-01f, -2.07665965e-01f, -2.05749705e-01f, 1.04140304e-02f, -2.72606034e-02f, 7.11140111e-02f, -1.18591063e-01f, 5.15202843e-02f, 2.52854884e-01f,
  -6.72825705e-03f, -9.69325453e-02f, 1.43032402e-01f, -2.07489789e-01f, 1.05091088e-01f, -1.87620059e-01f, -2.04898730e-01f, 5.87655939e-02f, -1.78589880e-01f, -1.02114521e-01f,
  4.32172984e-01f, 2.80207604e-01f, 9.18717533e-02f, -9.09431204e-02f, 2.00069070e-01f, -3.75702903e-02f, -1.73817471e-01f, -2.79188459e-03f, -3.97419669e-02f, -1.55548781e-01f,
  -2.80139357e-01f, -2.56123722e-01f, -3.46447527e-02f, 1.87119842e-01f, -2.11884722e-01f, 1.40770460e-02f, 6.61921442e-01f, 5.45350909e-02f, 2.25331113e-01f, 1.90873995e-01f,
  -2.73428112e-01f, 4.51752603e-01f, -2.23719716e-01f, 5.74709475e-02f, 1.51227019e-03f, 2.84690171e-01f, -9.30014849e-02f, 4.80912149e-01f, -4.55043688e-02f, -1.61639854e-01f,
  2.26869136e-01f, -1.10125639e-01f, -1.43526092e-01f, -1.23245813e-01f, 1.71066523e-01f, -6.78132921e-02f, -1.39511451e-01f, 3.66730481e-01f, -7.34345242e-02f, -1.12999506e-01f,
  -1.62904516e-01f, -8.54643993e-03f, -1.31579012e-01f, -1.11517116e-01f, -5.07380188e-01f, 1.36851698e-01f, -1.30120758e-02f, -3.69599104e-01f, -1.15405053e-01f, -1.28262624e-01f,
  7.51398876e-02f, -1.28606677e-01f, -6.73250109e-02f, 3.38476807e-01f, -2.47959957e-01f, 1.33353904e-01f, -9.29523334e-02f, 1.08376443e-01f, -2.18970001e-01f, -1.15027241e-01f,
  -1.71881005e-01f, -3.05588067e-01f, 3.04326639e-02f, -3.14513147e-01f, -4.79262508e-03f, -1.57417193e-01f, -3.18895578e-01f, 4.50487174e-02f, 3.11615646e-01f, -2.59924889e-01f,
  -3.05105954e-01f, -1.85737997e-01f, -6.54795989e-02f, -5.46386801e-02f, -1.01038076e-01f, -1.23785578e-01f, -1.73715457e-01f, -1.70687854e-01f, -2.33145326e-01f, 3.29498172e-01f,
  -2.29542404e-01f, -2.10224930e-02f, -4.50418502e-01f, -1.66911734e-04f, -4.73474674e-02f, 5.39754450e-01f, 1.33926377e-01f, -1.98669121e-01f, -3.11463416e-01f, -7.77976289e-02f,
  -1.88190401e-01f, -7.55891204e-02f, 2.92052001e-01f, -2.40363732e-01f, -5.14330566e-01f, 1.70001328e-01f, -5.76907545e-02f, 1.52276218e-01f, -9.39100683e-02f, -2.00798288e-01f,
  -1.64277077e-01f, -8.58190134e-02f, -4.24335822e-02f, 1.18509963e-01f, -3.90011445e-02f, -5.87327871e-03f, 2.44829641e-03f, 1.13970928e-01f, -1.47858635e-01f, 1.04449809e-01f,
  -2.76021082e-02f, 2.22177934e-02f, 1.74068406e-01f, -6.38928637e-02f, 5.63682951e-02f, 1.29971117e-01f, 2.60439634e-01f, 2.09663838e-01f, 1.79733470e-01f, -9.42000654e-03f,
  2.10713223e-01f, -1.62984118e-01f, -9.44298208e-02f, -1.48624077e-01f, -3.45372371e-02f, 1.57385468e-01f, 1.57637209e-01f, -1.31817788e-01f, 1.15469441e-01f, -1.34949073e-01f,
  8.22203467e-04f, -2.46285751e-01f, 1.57382339e-02f, -1.72890261e-01f, 1.78578235e-02f, -8.99245441e-02f, 5.39191127e-01f, -1.95424542e-01f, -3.01155865e-01f, -1.77817374e-01f,
  -3.83387059e-01f, 1.62080467e-01f, 2.49120481e-02f, -2.62953252e-01f, -1.54476523e-01f, -1.56184137e-01f, -2.79363960e-01f, -1.30184948e-01f, -2.36364469e-01f, -1.85396284e-01f,
  -2.14534670e-01f, 3.95806462e-01f, -2.77754158e-01f, -2.10335568e-01f, 4.13894020e-02f, -1.09996915e-01f, -1.37851596e-01f, -3.32525849e-01f, 8.15006614e-01f, -2.45177567e-01f,
  1.22727282e-01f, 2.18489259e-01f, -3.55420470e-01f, -1.72432363e-01f, -3.59897137e-01f, -1.10879205e-01f, -1.04574636e-01f, -3.65041167e-01f, -2.03593001e-01f, 6.51341558e-01f,
  -2.49828666e-01f, -2.16979340e-01f, 1.12389766e-01f, 5.42954262e-03f, -2.78266579e-01f, -2.15596363e-01f, 3.68974924e-01f, -4.71891351e-02f, -1.12102643e-01f, 2.16751508e-02f,
  1.72017932e-01f, 1.21638343e-01f, -2.64409810e-01f, 1.86146915e-01f, -4.43734135e-03f, -6.21854961e-02f, -8.29047337e-03f, -3.22954506e-01f, -1.16839722e-01f, 1.72820270e-01f,
  -1.27560824e-01f, -2.73009483e-02f, -2.44742632e-01f, -2.71386147e-01f, -4.43868227e-02f, 9.98946000e-03f, -1.24338582e-01f, 3.62080574e-01f, -3.44577342e-01f, -3.89219612e-01f,
  -1.94658354e-01f, 1.04369245e-01f, -2.62611926e-01f, -1.96236610e-01f, -2.26808652e-01f, -1.65850908e-01f, -2.47227568e-02f, -3.67287695e-01f, -2.47242242e-01f, -5.26925661e-02f,
  5.86101711e-01f, 2.80859262e-01f, -2.06365675e-01f, -2.05162153e-01f, 2.18829259e-01f, 4.99167852e-03f, -1.87389165e-01f, 1.76023781e-01f, 7.13867834e-03f, 4.64329392e-01f,
  -2.39378437e-02f, -9.71636623e-02f, -1.89986140e-01f, -1.60641819e-01f, -3.75263274e-01f, -3.86578977e-01f, -1.60206929e-01f, -1.27670556e-01f, 4.57155138e-01f, 1.36049569e-01f,
  -1.94716766e-01f, -2.74740867e-02f, -5.14536686e-02f, -1.64604694e-01f, -7.48174936e-02f, 3.03746983e-02f, 3.50095779e-02f, 5.37319016e-03f, 7.96273649e-02f, 1.28660267e-02f,
  -9.48512703e-02f, -7.89434239e-02f, -1.21206902e-02f, -3.57217551e-03f, -1.31745964e-01f, -2.90450454e-01f, 3.91217507e-02f, 4.34688628e-02f, -2.40945257e-02f, 1.37803838e-01f,
  -3.19508053e-02f, 4.23255302e-02f, -9.48447511e-02f, -1.09259591e-01f, 2.18357801e-01f, -5.32667451e-02f, -1.35318205e-01f, -1.77175507e-01f, -9.18494985e-02f, -1.40739679e-01f,
  -3.24794054e-01f, -2.02924237e-01f, 4.15735424e-01f, -8.96460935e-02f, -2.98034996e-01f, 1.79860163e-02f, 3.92628402e-01f, 1.60948113e-01f, 1.17196687e-01f, -3.71750414e-01f,
  -2.21191332e-01f, 6.34543359e-01f, 1.47207499e-01f, -4.70452279e-01f, 1.82722300e-01f, -1.72096357e-01f, -2.44661793e-01f, -2.82329559e-01f, -3.63427579e-01f, -1.48029104e-01f,
  2.58805186e-01f, 2.85250783e-01f, 2.18744561e-01f, 6.61171004e-02f, 1.80860922e-01f, -1.67320088e-01f, -1.53501362e-01f, -4.92447428e-02f, 1.49526550e-02f, -2.42207304e-01f,
  2.24201828e-01f, 1.12431549e-01f, -2.41214529e-01f, 2.15504378e-01f, 2.02308655e-01f, -6.67515770e-02f, -2.28077710e-01f, -3.11651796e-01f, -3.26110661e-01f, -3.80560718e-02f,
  -2.38783404e-01f, -8.14832598e-02f, 3.56732965e-01f, 6.76296711e-01f, -2.22966433e-01f, 4.30033982e-01f, 1.08957745e-01f, -5.43935239e-01f, -1.24076374e-01f, 3.83680999e-01f,
  -3.19764078e-01f, -2.44429216e-01f, 2.60223210e-01f, 2.01718718e-01f, -3.12940106e-02f, -1.86744891e-02f, 1.46590248e-01f, -1.46571115e-01f, -1.44883290e-01f, 1.40551925e-01f,
  3.75842839e-01f, -1.83398336e-01f, -4.69496071e-01f, 1.99236915e-01f, -1.66042477e-01f, -5.64794719e-01f, 6.52772412e-02f, -8.03936347e-02f, -3.62607807e-01f, -3.77502978e-01f,
  -3.99107516e-01f, 4.85768974e-01f, 2.82251805e-01f, -1.53174892e-01f, -1.29364133e-01f, -9.77337509e-02f, -1.97256625e-01f, 1.07865155e-01f, 1.23594962e-01f, 9.40120686e-03f,
  2.92559862e-01f, -2.76882220e-02f, -2.80139357e-01f, -7.32689738e-01f, -6.61074340e-01f, 3.70984316e-01f, 1.71686821e-02f, -4.24318880e-01f, -2.05518529e-01f, 1.52887017e-01f,
  1.65357515e-01f, 1.69960767e-01f, -7.49183819e-02f, 4.28111702e-02f, 4.83593285e-01f, -3.70247453e-01f, -9.66073126e-02f, 1.46361068e-01f, 3.94458920e-01f, -3.06962341e-01f,
  -2.43140347e-02f, -1.81113761e-02f, 3.96873914e-02f, -6.70482367e-02f, 1.50079429e-02f, 4.07120138e-02f, 4.11681421e-02f, 9.86173674e-02f, 1.16455153e-01f, 1.92343101e-01f,
  8.70158896e-02f, -4.56326269e-03f, 2.32460707e-01f, 8.84261727e-02f, 1.18929923e-01f, 1.77607059e-01f, -2.77094897e-02f, -4.85912301e-02f, -1.06275409e-01f, 9.62067991e-02f,
  -1.04780436e-01f, 2.43838593e-01f, -7.90144429e-02f, -2.02705905e-01f, -2.14019790e-01f, -1.49925515e-01f, -1.55248091e-01f, -4.83047247e-01f, -1.45620435e-01f, 2.11441234e-01f,
  -1.24368489e-01f, 3.93398106e-02f, 2.21832097e-01f, -1.30123615e-01f, -1.12529196e-01f, 4.49441113e-02f, -2.55116820e-01f, -3.30411345e-01f, 4.57810342e-01f, -3.73734295e-01f,
  -1.55981407e-01f, 6.85221329e-03f, -2.49636337e-01f, -2.45534420e-01f, 3.71221215e-01f, 1.42423123e-01f, 2.82631546e-01f, 2.69026101e-01f, -1.71625748e-01f, 2.60305166e-01f,
  -1.53577790e-01f, 1.68267354e-01f, -2.08672643e-01f, -3.03890482e-02f, -3.28499377e-01f, -6.90167323e-02f, -2.68373907e-01f, -3.53329897e-01f, -1.62691906e-01f, -3.36585164e-01f,
  1.23672724e-01f, -7.57676661e-02f, 5.83289973e-02f, 2.95078248e-01f, 1.54490590e-01f, -2.40427315e-01f, 2.07857072e-01f, -1.01361454e-01f, -2.95650274e-01f, -1.01249650e-01f,
  -1.49318680e-01f, 2.39536881e-01f, 3.78310800e-01f, -3.07519436e-01f, -1.08960010e-02f, -3.48922014e-01f, -3.22690338e-01f, -9.07015353e-02f, 3.57783347e-01f, -1.62050262e-01f,
  -1.92269623e-01f, -1.49899706e-01f, 2.63081938e-02f, -3.01964521e-01f, -1.82703137e-02f, 2.71323383e-01f, 1.53082624e-01f, -8.08688998e-02f, -8.71602669e-02f, -4.28244412e-01f,
  -1.33686870e-01f, 2.67466307e-01f, -8.57508481e-02f, 3.51256996e-01f, 1.46318451e-01f, -4.11905587e-01f, 2.01577216e-01f, -9.70259425e-04f, -4.92351890e-01f, -4.55410570e-01f,
  4.83054519e-01f, -1.42019108e-01f, -2.42836811e-02f, 4.70238030e-01f, -2.16768041e-01f, -3.64115328e-01f, -1.35540813e-01f, -2.74120808e-01f, -1.17500253e-01f, -1.58230871e-01f,
  2.27672607e-01f, -1.45382747e-01f, -1.15154691e-01f, 1.96038842e-01f, 1.66145992e-02f, -2.52179056e-01f, 1.65413499e-01f, -3.30936253e-01f, -4.48924415e-02f, -3.09215367e-01f,
  -2.79464841e-01f, -2.47511715e-01f, -4.79563415e-01f, 1.97413415e-01f, -3.18898052e-01f, 2.96031773e-01f, 2.96154320e-01f, 1.23776026e-01f, 1.15407206e-01f, 1.11625619e-01f,
  1.24248251e-01f, 1.49677500e-01f, 9.30276662e-02f, 2.36013047e-02f, 5.68069294e-02f, -3.90443988e-02f, 1.24928311e-01f, 1.22774325e-01f, -4.19651754e-02f, -6.32837862e-02f,
  -1.54678166e-01f, -1.55010208e-01f, 5.79861067e-02f, -4.39572558e-02f, 1.10242264e-02f, -2.00684547e-01f, 2.47627378e-01f, -1.94931522e-01f, -1.02707095e-01f, -9.24600363e-02f,
  -3.03165793e-01f, 2.75986698e-02f, -5.72811849e-02f, 2.62181703e-02f, -3.72195929e-01f, -2.00152293e-01f, 2.76023686e-01f, -9.31164026e-02f, -3.66244406e-01f, 1.35350257e-01f,
  -3.52793306e-01f, 3.15311372e-01f, 2.73487657e-01f, 9.30496082e-02f, -2.31098756e-01f, -3.11298579e-01f, 2.88661212e-01f, 1.06462374e-01f, -7.40926638e-02f, 2.59063900e-01f,
  -1.43885657e-01f, 2.29297043e-03f, -4.98114713e-03f, -1.90444753e-01f, 3.47474992e-01f, -1.42296463e-01f, 1.40204608e-01f, -2.20543742e-01f, -1.00857228e-01f, -2.31859118e-01f,
  1.49803996e-01f, -2.86136597e-01f, 1.69604227e-01f, -1.04815960e-01f, -1.55715346e-02f, 2.63576865e-01f, 2.16176614e-01f, -2.51503289e-01f, -1.93212911e-01f, -2.46423975e-01f,
  -2.38159969e-01f, -2.12875247e-01f, -1.61101013e-01f, -6.39815852e-02f, -1.43306315e-01f, -3.09515923e-01f, -3.27540010e-01f, -1.23060226e-01f, 5.57378650e-01f, -2.58021861e-01f,
  -9.79453474e-02f, -2.52039135e-01f, 4.67159808e-01f, -2.48201340e-01f, 3.67724806e-01f, -4.92668778e-01f, -2.88808048e-01f, -2.10865155e-01f, -3.73326212e-01f, -2.92727143e-01f,
  -4.57277745e-02f, 7.87449062e-01f, 4.55993950e-01f, -1.09148942e-01f, 8.71656016e-02f, 1.22354783e-01f, -2.49540448e-01f, -8.80801231e-02f, -1.58697844e-01f, -3.39926571e-01f,
  1.43248484e-01f, -1.01834930e-01f, -3.59259248e-01f, -2.24586040e-01f, -9.38473642e-02f, -1.29646420e-01f, -1.93717331e-01f, -2.74789065e-01f, -8.50817040e-02f, 2.77027160e-01f,
  -3.01665902e-01f, -2.55262822e-01f, -3.54545385e-01f, 4.29021157e-02f, 4.88712564e-02f, -3.20447758e-02f, -2.67320395e-01f, -1.02464482e-02f, -1.09020039e-01f, 4.19496864e-01f,
  2.46451542e-01f, 1.45164207e-02f, 7.95606747e-02f, 2.87195295e-01f, -2.77692735e-01f, -2.84439623e-01f, -2.31693968e-01f, -6.29120320e-02f, 3.73305678e-01f, -1.46053880e-01f,
  -2.42292769e-02f, -8.72986540e-02f, 6.53025582e-02f, -1.79239094e-01f, -2.10669473e-01f, -1.36781886e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -1.66352570e-01f, 3.30117196e-02f, 6.71382472e-02f, -3.98520418e-02f, -9.87864211e-02f, -1.53409794e-03f, 5.25860712e-02f, -6.08636700e-02f, 1.35052074e-02f, 9.08257738e-02f,
  1.80019643e-02f, -4.07144940e-03f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 12, 104
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        128, 12
    );
    }
    