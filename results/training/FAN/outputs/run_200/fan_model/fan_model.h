/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 4 x 120)
const int L0_fan_Wp_rows = 4;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  4.21045929e-01f, -1.59967527e-01f, 1.21210463e-01f, -1.68244198e-01f, 2.68174112e-01f, 4.02908623e-01f, 8.00889507e-02f, -1.85992047e-02f, -9.58490521e-02f, -3.51255774e-01f,
  -5.41397333e-02f, 9.42926854e-02f, -1.96677312e-01f, -1.64463930e-02f, 6.29290760e-01f, -8.92576203e-02f, 7.19999149e-02f, -6.15363196e-02f, -4.32381928e-02f, -8.10948014e-02f,
  6.44530132e-02f, 2.05411930e-02f, 8.95181522e-02f, 4.08651307e-02f, 1.30089328e-01f, -9.93187577e-02f, 3.37685347e-02f, 4.24849205e-02f, 7.54473805e-02f, 1.95327461e-01f,
  6.52324036e-02f, -2.09408313e-01f, 1.13776373e-02f, 8.04911647e-03f, 4.17345949e-03f, -2.94486042e-02f, 1.90204959e-02f, 8.42258483e-02f, 1.95756629e-02f, -6.01879209e-02f,
  -2.40672398e-02f, 1.35539966e-02f, -3.70761589e-03f, 2.01900117e-02f, -7.50493025e-03f, 7.56478542e-03f, 5.84748909e-02f, 3.21108149e-03f, -2.03320310e-02f, 3.93349603e-02f,
  -3.35234664e-02f, 1.12074390e-02f, -9.98139381e-03f, -5.85693717e-02f, 4.74257246e-02f, -2.91143823e-02f, -5.04458062e-02f, 3.34993377e-02f, -4.16667908e-02f, 1.08908042e-02f,
  -5.30940946e-03f, 2.77065928e-03f, 2.04418395e-02f, 1.49175115e-02f, 4.50984985e-02f, -3.99132743e-02f, 1.81560256e-02f, -5.64323645e-03f, 1.53295393e-03f, 7.67108332e-03f,
  2.31919214e-02f, 1.45997070e-02f, 1.19028063e-02f, 5.54685306e-04f, 2.33691093e-02f, -5.05680665e-02f, 4.92376983e-02f, -2.25847904e-02f, -2.12237369e-02f, 4.89411801e-02f,
  -1.44766495e-02f, 2.54551191e-02f, -2.17576651e-03f, 7.78419618e-03f, 2.18005362e-03f, 1.76634416e-02f, -5.76236323e-02f, 2.78991740e-03f, -5.31725436e-02f, 5.91992252e-02f,
  -1.49052199e-02f, -1.60187542e-01f, -5.17576486e-02f, 6.04672823e-03f, -5.54250181e-02f, 6.21259809e-02f, -2.50483188e-03f, -2.89959069e-02f, 1.65542159e-02f, -4.70071845e-03f,
  -2.77842805e-02f, 1.33211818e-02f, 9.01215058e-03f, 2.97241136e-02f, 3.95800769e-02f, -3.60411592e-02f, -7.29617923e-02f, 6.34532562e-03f, 3.15079419e-03f, -3.00844982e-02f,
  1.05950145e-04f, -4.31012921e-02f, -9.75743122e-03f, 3.65458913e-02f, -8.31973553e-03f, 1.17420731e-02f, 7.05777854e-02f, -1.55637292e-02f, 2.48262547e-02f, -2.66470574e-02f,
  -1.75606981e-01f, 1.16066262e-02f, -9.35980678e-02f, -2.56745785e-01f, -2.10187405e-01f, 2.32281685e-01f, 2.10467190e-01f, -2.62653619e-01f, -9.58313420e-02f, 1.39349356e-01f,
  -1.54687716e-02f, 1.74329862e-01f, 2.54805326e-01f, -4.42523360e-02f, 1.95107162e-01f, 2.88894117e-01f, -4.21783589e-02f, 1.19639322e-01f, -1.74010750e-02f, -1.82121783e-01f,
  -1.99382663e-01f, 1.18100004e-04f, -7.59648159e-02f, -1.05094068e-01f, -1.83552489e-01f, -2.37836763e-01f, -1.49220571e-01f, 2.48606242e-02f, -3.20262909e-02f, 9.60333645e-02f,
  1.03261299e-01f, -1.22874931e-01f, -1.20871402e-01f, 8.40424374e-02f, -9.06703845e-02f, -3.60398591e-02f, 2.42778230e-02f, 1.29204139e-01f, 5.79209765e-03f, 2.44123079e-02f,
  4.43566330e-02f, 2.72658728e-02f, -4.94308323e-02f, 3.31060626e-02f, -1.70584600e-02f, -4.76810969e-02f, -4.08288725e-02f, -2.68402081e-02f, -1.63011607e-02f, -6.35380819e-02f,
  -9.05849319e-03f, -1.12539902e-02f, -3.37202772e-02f, 9.00454596e-02f, -5.47843752e-03f, -4.47081514e-02f, -2.47461256e-02f, 3.02274544e-02f, -4.22862172e-02f, -1.08534597e-01f,
  6.92794621e-02f, -5.30858450e-02f, 2.17062570e-02f, -2.44441070e-03f, 2.67168339e-02f, -7.75186419e-02f, 6.86560571e-02f, 1.99552979e-02f, -1.56711377e-02f, 1.89770479e-03f,
  -4.73491736e-02f, -2.85378173e-02f, -1.38562243e-03f, 7.44870072e-03f, -1.32131837e-02f, -2.12382879e-02f, 5.94883636e-02f, 2.12152097e-02f, -4.31223698e-02f, -4.19099964e-02f,
  2.71211043e-02f, 7.86213391e-03f, 1.76264141e-02f, -2.35675871e-02f, 5.88658415e-02f, 4.98712100e-02f, -4.47081551e-02f, 9.82489903e-04f, -3.61827612e-02f, 3.07598282e-02f,
  2.42470682e-01f, -3.20602581e-02f, -1.26890196e-02f, -1.43722091e-02f, 4.64112200e-02f, -5.54327033e-02f, 5.40456129e-03f, -2.45149862e-02f, 6.43898621e-02f, -1.44915162e-02f,
  -7.51816183e-02f, -3.66370492e-02f, 1.02569899e-02f, 1.63073782e-02f, 1.36772469e-02f, -2.13665348e-02f, 4.44714949e-02f, 5.28028980e-02f, -3.51476036e-02f, -1.37380455e-02f,
  -5.83545584e-03f, 5.88125028e-02f, 3.84724146e-04f, -9.68571529e-02f, 1.74655635e-02f, 1.13473274e-02f, -1.78114977e-02f, -1.83945950e-02f, 6.12561703e-02f, 5.83032481e-02f,
  -6.39340729e-02f, -2.36823440e-01f, -5.08090556e-01f, -1.23355657e-01f, 2.49251530e-01f, 4.59100679e-02f, -2.69760907e-01f, 7.69830272e-02f, 1.13448627e-01f, 4.38185036e-03f,
  6.50877580e-02f, -7.43787289e-02f, -2.40180969e-01f, -9.16058794e-02f, -4.73054290e-01f, -3.15182239e-01f, -8.06363821e-02f, -5.48246242e-02f, 2.14361921e-02f, 6.32338077e-02f,
  -2.61641797e-02f, 3.68489698e-02f, -3.97747099e-01f, 1.79724321e-01f, 1.19671337e-02f, 9.59616899e-02f, -6.03407770e-02f, 5.11649027e-02f, -6.10012524e-02f, -1.53599055e-02f,
  -3.69382463e-02f, 1.05227172e-01f, -3.90556902e-02f, -1.15646869e-02f, 3.92945111e-02f, -4.57985280e-03f, -2.96533536e-02f, -6.00663908e-02f, 4.04839627e-02f, -2.42872420e-03f,
  1.78494640e-02f, 8.08635727e-02f, 6.35968000e-02f, 1.50613617e-02f, 1.40728340e-01f, 3.08819022e-02f, 6.75623631e-03f, -1.11924848e-02f, 2.49295905e-02f, -2.01771148e-02f,
  -3.53498980e-02f, -5.31203412e-02f, 8.58417675e-02f, -1.88828390e-02f, 3.75370472e-03f, 4.14808169e-02f, -5.38305454e-02f, -5.05683869e-02f, 1.13485958e-02f, 5.87239154e-02f,
  1.09905548e-01f, 8.75769090e-03f, -3.11960634e-02f, 2.22131647e-02f, 7.43922638e-03f, 2.11601402e-03f, 1.00946082e-02f, 1.52666867e-02f, -2.58085621e-03f, 3.41264233e-02f,
  8.45987443e-03f, 2.06809659e-02f, 4.15221937e-02f, -1.57913901e-02f, -5.00232563e-04f, 2.41525564e-02f, -2.25972217e-02f, 7.63450656e-03f, 2.39147153e-02f, -4.35780473e-02f,
  6.55225804e-03f, 2.78652739e-03f, 1.93577231e-04f, -8.26414907e-04f, -1.47249578e-02f, -3.31244618e-02f, 4.04634289e-02f, 3.32528166e-03f, -4.69395854e-02f, 3.21549270e-03f,
  3.49864587e-02f, -3.56242321e-02f, 1.20199127e-02f, 1.59461387e-02f, -1.74223706e-02f, 8.42310209e-03f, -5.59080243e-02f, 7.24529922e-02f, -3.78847755e-02f, 1.68740265e-02f,
  3.52483951e-02f, -2.45267730e-02f, 1.05854915e-02f, 2.72208210e-02f, -6.56267032e-02f, -1.49971936e-02f, -4.65640463e-02f, 9.63689014e-03f, -6.52228948e-03f, -2.53274711e-03f,
  3.11611337e-03f, 6.06993362e-02f, -7.15500116e-02f, 5.41224852e-02f, 4.95507270e-02f, 2.21598540e-02f, 6.12623543e-02f, -1.63986664e-02f, -4.18623276e-02f, -1.20603452e-02f,
  -6.79219842e-01f, 3.51415984e-02f, 2.33195856e-01f, -3.90255868e-01f, -1.01530261e-01f, 8.17100257e-02f, -3.22671860e-01f, -1.30563006e-01f, -3.31929952e-01f, -1.03254750e-01f,
  -1.34454772e-01f, 2.85766721e-02f, 1.11458998e-03f, -2.11030021e-01f, -3.30102295e-01f, -2.81521175e-02f, -3.44375551e-01f, -1.46071777e-01f, -5.39822690e-02f, -1.08136065e-01f,
  -1.09050468e-01f, -3.39484841e-01f, -7.33961612e-02f, 8.51651356e-02f, -1.50481701e-01f, 1.11571021e-01f, -8.80704224e-02f, 2.61817932e-01f, -4.28403774e-03f, 2.81668194e-02f,
  1.32652357e-01f, -7.28083178e-02f, 4.84755486e-02f, 1.87042747e-02f, -1.68419406e-02f, 2.96660960e-02f, 6.15953170e-02f, 9.24040601e-02f, 1.77229885e-02f, -2.56262477e-02f,
  6.33657947e-02f, 3.63323130e-02f, -5.72416931e-02f, 1.16734491e-05f, -6.64988384e-02f, 1.11127703e-03f, -2.99512073e-02f, -1.63064152e-02f, 1.61883812e-02f, -4.65113223e-02f,
  -7.97078479e-03f, 5.43850847e-02f, -5.84795214e-02f, -2.79454309e-02f, 1.20760659e-02f, -1.17332963e-02f, 2.71008033e-02f, 1.12015031e-01f, -3.80077511e-02f, -5.80854304e-02f,
  -7.95919523e-02f, 1.88538153e-02f, -1.22991667e-04f, -7.34817283e-03f, -8.45946278e-03f, 3.52947935e-02f, -5.11828549e-02f, 3.54941338e-02f, 6.13633357e-03f, -1.14183594e-03f,
  -6.10981556e-03f, -3.82292569e-02f, -4.12769429e-02f, 4.16151044e-04f, -3.66407447e-02f, -1.14732701e-02f, 9.15020471e-04f, 9.47544165e-03f, -2.77845450e-02f, 2.46889107e-02f,
  7.78276753e-03f, -7.83769507e-03f, 1.35032255e-02f, 3.27376388e-02f, 7.18632946e-03f, 9.96709149e-03f, -5.76365832e-03f, -3.51511054e-02f, 3.06683723e-02f, 5.72441239e-03f,
  -1.10918365e-01f, -1.80799946e-01f, 2.09231675e-02f, -1.39468350e-02f, 4.50950526e-02f, -1.53666101e-02f, -3.30296643e-02f, 2.09492259e-02f, 1.45082967e-02f, -5.59384972e-02f,
  1.98437809e-03f, -3.78882256e-03f, 6.34113327e-02f, 1.44810425e-02f, 8.43195543e-02f, -4.33693640e-02f, 2.55315248e-02f, 5.60031831e-02f, -3.58669274e-02f, -9.38987080e-03f,
  1.40397502e-02f, -2.58643329e-02f, 1.50753064e-02f, -1.75191443e-02f, -1.03420168e-02f, -3.94540317e-02f, -2.98548248e-02f, -1.55062433e-02f, 4.28399183e-02f, 1.72193050e-02f
};

// L0_fan_Wp_bar (Shape: 8 x 120)
const int L0_fan_Wp_bar_rows = 8;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  5.77804297e-02f, 4.38882150e-02f, -2.38386303e-01f, -4.06096011e-01f, -1.41751617e-01f, -2.65293956e-01f, -4.88956183e-01f, -8.62970501e-02f, -1.04066655e-01f, -1.96135283e-01f,
  -3.72796804e-01f, -1.04798581e-02f, 9.99988839e-02f, -3.60228240e-01f, 4.13561255e-01f, 3.71696055e-01f, -3.09097171e-01f, -2.40169615e-01f, 1.07406169e-01f, -3.83947253e-01f,
  1.83243360e-02f, -3.59269917e-01f, 4.59063463e-02f, -7.43403807e-02f, -5.54938614e-01f, -2.02620849e-01f, 2.42732908e-03f, -1.94833264e-01f, -3.34087998e-01f, -9.42918882e-02f,
  -9.53402966e-02f, -1.34867281e-02f, -9.38022137e-02f, 4.97960709e-02f, -8.25578794e-02f, 4.17738371e-02f, -1.49371266e-01f, -3.89696658e-02f, -3.19891833e-02f, -2.82778647e-02f,
  1.29286433e-02f, 5.63965850e-02f, 1.85436420e-02f, 7.21908882e-02f, -7.21691251e-02f, -2.08323598e-02f, 2.63084378e-02f, -2.59320680e-02f, 4.32397164e-02f, 1.17248043e-01f,
  -5.53265288e-02f, 6.68951496e-02f, -7.09365904e-02f, -2.99518686e-02f, -2.66240370e-02f, -1.13192908e-01f, 3.69346626e-02f, -5.86256050e-02f, -2.22627353e-02f, 4.82737720e-02f,
  1.86156053e-02f, -6.11058250e-03f, 3.11543327e-02f, -9.02810395e-02f, -1.58907641e-02f, -6.25229403e-02f, -3.24669853e-02f, 6.24775933e-03f, -4.96630324e-03f, 3.96514907e-02f,
  4.17225529e-03f, -1.11594759e-01f, 2.00907104e-02f, 1.58826243e-02f, -5.16966358e-02f, -2.31912214e-04f, 4.76649478e-02f, 2.34227907e-02f, -4.81821299e-02f, 4.06504683e-02f,
  -9.89119709e-02f, 4.04250659e-02f, -6.60330504e-02f, -2.92366743e-02f, 3.55497487e-02f, -4.38707881e-02f, 5.07141687e-02f, -3.47249676e-03f, 3.79456058e-02f, -6.97008148e-02f,
  -6.05711415e-02f, 2.80766189e-02f, 5.18929027e-02f, 4.71657962e-02f, 6.57678768e-02f, -1.18703982e-02f, 8.31166655e-02f, -3.23885791e-02f, -2.53558904e-02f, 2.51849703e-02f,
  -6.78364607e-03f, 1.85772162e-02f, 5.38692847e-02f, -4.99066450e-02f, -6.86895475e-03f, 1.64588273e-03f, -1.11849658e-01f, 5.64392656e-02f, -5.67429997e-02f, -4.14648242e-02f,
  -5.25313988e-03f, -1.00637758e-02f, 6.40439941e-03f, -4.93065305e-02f, 1.04655223e-02f, -7.56688043e-02f, 4.06173244e-02f, 8.21667984e-02f, 9.29582212e-03f, 8.10511857e-02f,
  -4.01985675e-01f, 2.61648834e-01f, 7.12632835e-01f, -2.66577989e-01f, 4.45843071e-01f, 2.30869710e-01f, 3.01539283e-02f, 3.23693573e-01f, 1.42200291e-01f, -3.15927863e-01f,
  -8.13049525e-02f, 3.07500660e-02f, 2.06960872e-01f, -1.21931553e-01f, -1.67721242e-01f, -8.57139602e-02f, -2.43565127e-01f, -2.34815285e-01f, 2.87471741e-01f, -6.62319735e-02f,
  -1.17227063e-01f, -2.15143353e-01f, 1.50466144e-01f, 2.64867157e-01f, 1.21858373e-01f, 7.82785285e-03f, -4.67606217e-01f, 3.64596963e-01f, -2.08277836e-01f, 1.79581910e-01f,
  -2.65189439e-01f, -5.35863452e-02f, -1.00068219e-01f, 1.86293609e-02f, -7.81300943e-03f, -1.45662233e-01f, -7.04352185e-02f, 1.02451809e-01f, -8.07646513e-02f, -7.17540970e-03f,
  -1.81036186e-03f, -2.72595380e-02f, -1.22790737e-03f, 5.59352897e-02f, 4.93884459e-02f, 5.55186197e-02f, 2.00197890e-01f, 8.56957361e-02f, 1.09687671e-01f, 2.52880365e-01f,
  1.56104401e-01f, 9.17382389e-02f, 1.10714382e-03f, -4.57764119e-02f, 4.36455980e-02f, 1.66632589e-02f, -7.65912384e-02f, -3.69288363e-02f, -2.94347703e-02f, 3.07746977e-02f,
  1.01065442e-01f, -2.23899242e-02f, 1.72891617e-02f, -9.14173573e-03f, 4.03299145e-02f, 6.06626086e-02f, -1.34038953e-02f, -3.06193717e-02f, -4.26961854e-02f, -4.94636893e-02f,
  -3.73210013e-02f, -3.77901420e-02f, 2.50568353e-02f, -3.06866299e-02f, -4.45443541e-02f, -5.52361347e-02f, -7.14897662e-02f, 9.92258079e-03f, 1.14336153e-02f, 1.68112554e-02f,
  -3.17945029e-03f, -1.17561994e-02f, 3.01579274e-02f, -7.56631419e-02f, 3.34746651e-02f, -2.01650942e-03f, -6.23453073e-02f, 8.43823105e-02f, 2.62019690e-02f, -6.34571612e-02f,
  -4.44884449e-01f, -5.68574786e-01f, -1.67371139e-01f, -1.05652072e-01f, -1.15522482e-01f, -2.29476839e-02f, -2.22652294e-02f, -4.49244641e-02f, -1.46152630e-01f, -1.36757281e-03f,
  -7.94792771e-02f, -4.57648672e-02f, -5.49607053e-02f, -1.09231517e-01f, -4.34743688e-02f, -4.28315699e-02f, -1.17101543e-01f, -2.31261551e-01f, -1.52734458e-01f, -4.11161631e-02f,
  -7.51038045e-02f, -8.00639614e-02f, 1.89838037e-02f, -4.46337499e-02f, -1.16955444e-01f, -7.23394826e-02f, -2.89231148e-02f, -6.42369762e-02f, -1.32488851e-02f, 1.42730540e-03f,
  -8.95913169e-02f, 2.55153388e-01f, 9.78708267e-02f, 2.07726017e-01f, 2.53115944e-03f, 3.98224175e-01f, 3.61313760e-01f, 1.11577921e-01f, 6.52019262e-01f, 1.73581466e-01f,
  -3.63748193e-01f, 3.21770638e-01f, -2.16194704e-01f, -1.11606635e-01f, 8.98564234e-02f, 4.28341143e-02f, 2.22662300e-01f, 1.44188106e-01f, 1.14832476e-01f, 1.94789156e-01f,
  -6.78743422e-02f, -1.35601774e-01f, -5.25110185e-01f, -2.61803299e-01f, -2.10638791e-01f, -5.70666492e-02f, -3.73749286e-01f, -1.05127484e-01f, -1.99469879e-01f, 6.91621192e-03f,
  -1.11294374e-01f, -8.15568119e-03f, -2.21597567e-01f, -8.55714828e-02f, 1.16503974e-02f, -5.86158633e-02f, 1.92458667e-02f, -2.47805454e-02f, -7.11409748e-02f, -1.92348007e-02f,
  1.43212527e-01f, -5.26546761e-02f, 7.16831386e-02f, -9.17256698e-02f, -2.90975953e-03f, -5.44521492e-03f, -8.94693062e-02f, -1.44121051e-01f, -1.26515608e-02f, -1.59819618e-01f,
  -5.90681955e-02f, -2.24896614e-03f, -3.82758342e-02f, 3.97172086e-02f, -9.31571350e-02f, 3.74907553e-02f, 1.01344645e-01f, 4.46280651e-02f, 4.97857444e-02f, 1.47379711e-01f,
  -4.09733970e-03f, 1.51223764e-01f, -3.15066688e-02f, -8.70828554e-02f, -1.33915907e-02f, -6.87030628e-02f, 3.16151069e-03f, -3.41740437e-02f, 8.18150584e-03f, -1.57804415e-02f,
  6.16146363e-02f, -6.75721690e-02f, 8.05257447e-03f, 3.85635113e-03f, 7.52485991e-02f, 7.32011423e-02f, -2.79810205e-02f, 4.10893932e-02f, 5.43252043e-02f, -3.17652710e-02f,
  -2.27705948e-03f, 5.44226579e-02f, -7.15823397e-02f, -5.80108166e-02f, 2.68497355e-02f, -8.59954655e-02f, -8.91609024e-03f, -5.75797400e-04f, -2.16934383e-02f, -7.96163604e-02f,
  2.89358467e-01f, 6.45943046e-01f, -6.52886629e-02f, 1.89665798e-02f, 4.25426289e-02f, 2.04443205e-02f, 8.93212184e-02f, 9.95505005e-02f, 1.27196312e-01f, 1.33739546e-01f,
  5.51698767e-02f, 1.00275822e-01f, 8.77918303e-02f, -5.43772802e-02f, 4.16381136e-02f, 2.97765248e-02f, 1.68989137e-01f, 9.91212130e-02f, 1.27982944e-01f, -5.72698563e-02f,
  -6.42513260e-02f, 1.21585242e-01f, 1.11136317e-01f, 5.65518364e-02f, 4.04930338e-02f, -5.39267389e-03f, 1.69333607e-01f, -2.91147307e-02f, -1.49130477e-02f, 8.13115463e-02f,
  3.23053718e-01f, 3.60941999e-02f, 3.73723835e-01f, 5.85368633e-01f, -1.47257298e-01f, -3.40115637e-01f, -3.05185467e-01f, -8.40481147e-02f, 4.64123301e-02f, -9.85063463e-02f,
  -4.49868917e-01f, 7.64447153e-01f, -7.48136580e-01f, 3.34604144e-01f, -2.78705388e-01f, -6.36061311e-01f, 4.91648167e-03f, 1.82588622e-01f, -1.89829804e-02f, 1.61646437e-02f,
  4.60973606e-02f, -1.54315352e-01f, 6.38536066e-02f, -2.02489913e-01f, 2.74232447e-01f, 4.47418153e-01f, -4.03187908e-02f, -1.32943854e-01f, 5.67289531e-01f, 8.26875642e-02f,
  -2.88021136e-02f, -9.04680341e-02f, 1.70519605e-01f, 1.23145260e-01f, -7.59058073e-02f, 1.11989966e-02f, 6.83302656e-02f, 4.66851331e-03f, 6.92810640e-02f, 1.74050219e-03f,
  7.16781691e-02f, 8.61093178e-02f, 2.06338271e-01f, -4.86126803e-02f, 1.20439306e-01f, 1.75272673e-01f, 1.58440650e-01f, 9.38235372e-02f, 1.23254538e-01f, 8.83520767e-02f,
  9.72651765e-02f, 1.50018826e-01f, 7.91589245e-02f, 1.32314265e-01f, 5.47245555e-02f, 4.73397523e-02f, 5.06583080e-02f, 4.50094864e-02f, 7.80529007e-02f, 3.70011628e-02f,
  -2.54633389e-02f, -9.09477323e-02f, -2.91764401e-02f, 7.82899093e-03f, -1.03097446e-02f, 2.37314794e-02f, -2.97103040e-02f, -3.62580083e-03f, 8.63689091e-03f, -7.56727681e-02f,
  -3.79610471e-02f, 8.32287148e-02f, -2.57017300e-03f, 1.07553089e-02f, -2.84891371e-02f, 3.59003283e-02f, 7.16461390e-02f, 4.39200364e-02f, 5.35909720e-02f, 8.53782594e-02f,
  -4.93094102e-02f, -5.85723966e-02f, -8.13896358e-02f, 1.57424603e-02f, -8.32154304e-02f, -5.31423390e-02f, -2.35003382e-02f, 4.33564410e-02f, -4.41246219e-02f, -5.59668206e-02f,
  -2.47853562e-01f, -2.80678153e-01f, -4.73554842e-02f, 9.34897289e-02f, 4.25259992e-02f, -6.26714006e-02f, -8.83702748e-03f, 8.07996392e-02f, -1.20260164e-01f, -8.19013789e-02f,
  -4.37251478e-02f, 6.40537292e-02f, -3.29743400e-02f, 7.49433637e-02f, -4.48007770e-02f, -1.34836614e-01f, -1.04258349e-02f, 1.01008095e-01f, -6.10648617e-02f, 5.77957667e-02f,
  2.21377413e-04f, -7.35780969e-02f, -1.44917611e-02f, 6.44828826e-02f, 1.24805167e-01f, -3.89078110e-02f, 3.81052680e-02f, 4.62956466e-02f, 1.40866898e-02f, 5.33482209e-02f,
  -8.15920353e-01f, 2.21941859e-01f, -6.68519914e-01f, -4.97689307e-01f, -2.62447931e-02f, -6.41056359e-01f, -3.49246651e-01f, -1.10919923e-01f, -1.32093787e-01f, 5.31967998e-01f,
  2.37421408e-01f, -2.41038352e-01f, 3.77051950e-01f, -1.42996877e-01f, -7.40203619e-01f, 1.98726892e-01f, -4.47271973e-01f, -7.96069205e-02f, -9.86000746e-02f, -3.30340326e-01f,
  -3.02964926e-01f, 1.14204464e-02f, -1.43603027e-01f, 2.42141590e-01f, -2.55432397e-01f, -1.16569363e-01f, 2.62239695e-01f, 1.59511790e-01f, -5.38596138e-02f, -7.55151559e-04f,
  -2.56796539e-01f, -3.51630859e-02f, -1.30478755e-01f, -4.98895198e-02f, -2.43893102e-01f, -9.30992961e-02f, -5.92224114e-02f, -2.06350237e-02f, -4.72863428e-02f, -1.60943180e-01f,
  -3.59410159e-02f, -4.25230674e-02f, -9.34141204e-02f, 9.54863131e-02f, -4.60288264e-02f, -4.70452756e-03f, -5.55745922e-02f, -1.04749553e-01f, -7.92665631e-02f, -1.16082840e-01f,
  -1.08314939e-01f, 8.20319075e-03f, 1.65648907e-02f, -3.09361517e-02f, -6.94575757e-02f, 6.28583580e-02f, -4.38416116e-02f, -2.91950945e-02f, -9.04247984e-02f, -9.93802473e-02f,
  -3.53134163e-02f, -1.09515423e-02f, 7.33890245e-03f, 1.68462452e-02f, -6.92061558e-02f, 6.18765466e-02f, 5.03879040e-03f, 4.20190766e-02f, 5.83169982e-03f, 1.88939534e-02f,
  -5.66609502e-02f, -3.13205868e-02f, -8.41042679e-03f, -7.48292869e-03f, -3.03768255e-02f, 5.79949692e-02f, 4.76885866e-03f, -1.33161736e-03f, -8.66399035e-02f, -1.17432531e-02f,
  7.62750357e-02f, -2.52322201e-02f, 6.60747662e-02f, -2.71461420e-02f, 1.00017209e-02f, 8.65088962e-03f, 2.10001245e-02f, 4.21577832e-03f, 4.67479937e-02f, -7.02638179e-02f,
  -2.13357195e-01f, -9.08214897e-02f, -5.66193508e-03f, 4.15394977e-02f, 3.01919933e-02f, -2.82709412e-02f, 9.12634842e-03f, -7.38468170e-02f, -7.10351765e-02f, -2.24644337e-02f,
  -5.91902761e-03f, 9.90001038e-02f, -6.70878813e-02f, -2.24624500e-02f, -4.07848973e-03f, -6.55520037e-02f, 7.34502077e-02f, -1.34825753e-02f, -5.90806305e-02f, -1.96894445e-03f,
  -3.45923402e-03f, 4.51112948e-02f, -5.19579947e-02f, 4.97223586e-02f, 5.58657087e-02f, 7.50934109e-02f, -6.90046549e-02f, 6.56535756e-03f, -2.06014588e-02f, 2.39399727e-02f,
  2.99784597e-02f, -2.81297386e-01f, -7.59506285e-01f, -9.11882445e-02f, 2.38715917e-01f, 3.07972670e-01f, -9.81411338e-03f, -4.97794785e-02f, -6.64474905e-01f, 3.16106796e-01f,
  3.97702962e-01f, -3.96638602e-01f, -2.49756411e-01f, 3.87886465e-01f, 4.17116322e-02f, -2.67275482e-01f, 5.48081279e-01f, 3.29844981e-01f, -2.42681324e-01f, 2.29950413e-01f,
  1.01572806e-02f, 7.10715413e-01f, -1.63972586e-01f, 3.72194082e-01f, 2.35627085e-01f, -6.23343661e-02f, 5.84231198e-01f, -9.03280526e-02f, 6.25586033e-01f, 2.10969999e-01f,
  1.06351534e-02f, -1.79100394e-01f, -1.88987419e-01f, -2.04576299e-01f, 1.65669456e-01f, 1.89217716e-01f, 7.04356804e-02f, -5.25194779e-02f, -1.67921752e-01f, -9.45591480e-02f,
  1.45402197e-02f, -4.81154434e-02f, 3.13985832e-02f, -1.27384216e-01f, -6.03922680e-02f, -5.48546575e-02f, -1.64024144e-01f, -9.54029262e-02f, -1.51686534e-01f, -1.01991415e-01f,
  -1.71261773e-01f, 4.22974164e-03f, 2.13027447e-02f, 5.30236438e-02f, -1.09301485e-01f, -8.48724097e-02f, 1.32406378e-04f, -5.28234318e-02f, 9.97045562e-02f, 1.96230747e-02f,
  1.73741385e-01f, 7.76374415e-02f, -2.77566188e-03f, -4.17249463e-02f, 2.12444738e-02f, 7.67193660e-02f, 1.74651351e-02f, 8.03097412e-02f, -1.41869038e-01f, 5.07672802e-02f,
  2.31922511e-03f, -3.28636691e-02f, -1.60430633e-02f, 2.95364875e-02f, 1.15688011e-01f, -1.26451571e-02f, 3.21934302e-03f, 5.49064130e-02f, -5.30224554e-02f, -3.98762934e-02f,
  -4.00332958e-02f, 3.86334397e-02f, 2.62466935e-03f, 4.60438989e-02f, 5.05188573e-03f, -8.07494149e-02f, 8.75781924e-02f, 4.82988870e-03f, -9.08369548e-04f, 6.13177642e-02f,
  1.39476508e-01f, 2.50507325e-01f, -1.50720358e-01f, -5.30202016e-02f, 2.29195040e-02f, 1.24595277e-01f, -4.25780453e-02f, 4.17970233e-02f, 3.71904895e-02f, 1.29081961e-02f,
  2.06005335e-01f, 1.26651814e-02f, 7.68257156e-02f, 5.49279479e-03f, -2.22372636e-02f, 1.37228161e-01f, 1.65205419e-01f, 1.98314246e-02f, 1.37465760e-01f, 1.73435003e-01f,
  6.15979955e-02f, 1.23271286e-01f, -9.29359812e-03f, 5.48390159e-03f, 1.27417013e-01f, 1.34633988e-01f, 4.85514179e-02f, -4.02472839e-02f, 1.20868154e-01f, -4.21178192e-02f,
  2.93892413e-01f, -1.02112591e+00f, 8.62140357e-02f, 4.03836608e-01f, 5.01955628e-01f, -5.90054803e-02f, 3.84735584e-01f, -3.70997429e-01f, 1.17144145e-01f, -6.82427108e-01f,
  -7.99407884e-02f, -5.00519685e-02f, -1.42285049e-01f, -5.08756459e-01f, 6.73756838e-01f, -1.34286344e-01f, -2.88900971e-01f, -7.35031515e-02f, 3.44991754e-03f, -1.33755803e-01f,
  1.90609768e-01f, -2.17665538e-01f, -5.18127978e-02f, -5.38229465e-01f, -4.76220176e-02f, -4.95338105e-02f, 1.12673566e-01f, 1.83146715e-01f, -2.80553728e-01f, 8.09907392e-02f,
  -2.24845901e-01f, -1.49503708e-01f, -9.22870561e-02f, -2.05968574e-01f, -6.99900985e-02f, 8.30757171e-02f, 1.29195094e-01f, 1.60895258e-01f, 1.24012433e-01f, 3.17283832e-02f,
  7.90721774e-02f, 9.50557087e-03f, -1.02745235e-01f, 3.06095947e-02f, 4.03102338e-02f, -1.28832459e-01f, 1.41464695e-02f, -9.07651410e-02f, -3.08393929e-02f, 2.35789325e-02f,
  2.98102666e-02f, -3.14811096e-02f, 7.75492042e-02f, -2.85883024e-02f, 1.08300209e-01f, 1.47066358e-02f, 1.31309569e-01f, 1.35116637e-01f, -3.05565782e-02f, 2.21775670e-04f,
  -1.50617259e-02f, 5.75829037e-02f, -4.45021428e-02f, -1.09685853e-01f, -3.19241844e-02f, -1.15484500e-03f, -3.38736549e-02f, 2.03793775e-02f, 4.88783456e-02f, -6.34176359e-02f,
  -3.42409648e-02f, 3.48647311e-02f, -1.87826604e-02f, 1.64672323e-02f, 1.34389121e-02f, 6.43852428e-02f, 8.29110071e-02f, 2.98168659e-02f, -8.65881145e-03f, 2.94013135e-02f,
  9.26802214e-03f, 5.12163453e-02f, -5.91400973e-02f, 4.78076003e-02f, -4.28302065e-02f, 3.21678184e-02f, -9.55930427e-02f, -3.70668583e-02f, 9.64461267e-02f, 3.08106933e-02f,
  -2.88987756e-01f, -4.52746123e-01f, -1.47816449e-01f, 7.84362014e-03f, -9.59061086e-02f, -4.16831821e-02f, -8.45393166e-02f, -5.68370335e-02f, -1.41459092e-01f, -5.18139005e-02f,
  3.35173160e-02f, 8.83131847e-02f, -5.18910252e-02f, 4.13277671e-02f, -8.61040354e-02f, -5.86254988e-03f, 2.52188426e-02f, -6.47923499e-02f, 2.53924988e-02f, -1.17849901e-01f,
  -2.78837085e-02f, 8.92990306e-02f, 8.59677717e-02f, 7.39346445e-02f, -5.42991832e-02f, 1.08759895e-01f, 6.04124777e-02f, 6.05478091e-03f, 1.15577159e-02f, -4.71039712e-02f,
  1.26925841e-01f, 9.32618529e-02f, 1.26373395e-01f, 3.63382846e-01f, -1.70115933e-01f, -3.82240534e-01f, -2.23599061e-01f, 4.24971394e-02f, -1.52984604e-01f, -1.72560126e-01f,
  5.43251410e-02f, 1.25194147e-01f, -7.04038516e-02f, 1.62426546e-01f, 3.79182816e-01f, -3.95941846e-02f, 8.04122910e-02f, -1.00251921e-01f, 4.07874361e-02f, 2.63152272e-01f,
  2.89865285e-01f, 1.73214197e-01f, 3.04615706e-01f, 1.98104233e-01f, 2.38207206e-01f, 2.45605946e-01f, 4.63208318e-01f, 2.22048074e-01f, 3.40700835e-01f, 2.03411192e-01f,
  -1.15558304e-01f, 1.94774643e-01f, -1.62597820e-02f, 2.74655106e-03f, -1.87623780e-02f, -1.12122349e-01f, -7.02191750e-03f, 8.87187943e-02f, 1.18785715e-02f, -2.83380877e-02f,
  -8.22358765e-03f, -4.53524105e-03f, -3.35928649e-02f, 4.11833562e-02f, -1.67795662e-02f, 5.60983978e-02f, -3.29173058e-02f, -1.26625404e-01f, -3.31366509e-02f, 3.51102911e-02f,
  -3.22516561e-02f, -2.95186955e-02f, 8.89162943e-02f, 8.04135203e-02f, 1.56866163e-01f, 7.40508968e-03f, -7.44856447e-02f, 8.44679400e-02f, 5.78418449e-02f, 3.55388224e-02f,
  8.20066258e-02f, -4.63598482e-02f, -9.60265398e-02f, -2.66713686e-02f, -2.73267590e-02f, -3.94111574e-02f, -5.12780854e-03f, -5.72229326e-02f, 4.31455373e-05f, -2.24370193e-02f,
  3.56207392e-03f, 2.72348896e-02f, -7.57123679e-02f, -3.54573131e-02f, 6.02340624e-02f, -7.74730146e-02f, 5.14692627e-02f, 7.49395043e-02f, 1.05232839e-02f, 5.16417203e-03f,
  2.65456419e-02f, 3.83428968e-02f, 2.26687174e-03f, -9.34360474e-02f, -4.51895669e-02f, 7.50462934e-02f, 9.54019651e-02f, -2.84491666e-02f, 1.32444585e-02f, 8.94112661e-02f,
  2.66552977e-02f, 5.22452176e-01f, 9.60796140e-03f, -1.29982501e-01f, 2.64177611e-03f, -7.56494552e-02f, 1.93347465e-02f, 4.13504280e-02f, 1.82053447e-01f, 9.43340510e-02f,
  7.50857219e-02f, -4.27981578e-02f, 2.54992116e-02f, 1.51801761e-02f, -1.47928530e-02f, 8.77638385e-02f, 1.65601134e-01f, 1.23450749e-01f, 2.90611330e-02f, 1.00199662e-01f,
  1.40755177e-01f, -2.70584375e-02f, 2.02164217e-03f, -5.79248480e-02f, 2.46978346e-02f, 1.30365277e-02f, -1.03970030e-02f, 1.13216648e-02f, 6.42898232e-02f, 5.22611029e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 8)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 8;
const float L0_fan_Bp_bar_data[] = {
  6.66854754e-02f, 5.67358494e-01f, 4.45536315e-01f, 5.30177593e-01f, 5.73878407e-01f, 7.75927722e-01f, 6.98961854e-01f, 1.70422778e-01f
};

// L1_linear_W (Shape: 12 x 16)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 16;
const float L1_linear_W_data[] = {
  -1.05492659e-01f, -1.42858908e-01f, 4.19092268e-01f, 7.70916402e-01f, -1.07051182e+00f, 9.60517526e-01f, -1.09219503e+00f, -5.39554954e-01f, -3.61806452e-01f, -4.61123019e-01f,
  -1.69533864e-01f, -2.73387760e-01f, 8.15312088e-01f, 5.57512820e-01f, -5.52448809e-01f, -6.83666646e-01f, 2.39053041e-01f, 3.04577887e-01f, 2.55965084e-01f, -8.60439122e-01f,
  6.38241410e-01f, 4.38409477e-01f, 4.86687660e-01f, -6.19048893e-01f, 1.01964563e-01f, -5.60614705e-01f, 1.38689801e-01f, -6.87933385e-01f, -5.34805715e-01f, 1.18574893e+00f,
  -6.36234462e-01f, -9.30216722e-03f, -1.03519380e+00f, -2.23759800e-01f, -1.59340221e-02f, 1.83346435e-01f, 1.14265978e+00f, -3.89161229e-01f, 4.37504351e-01f, 6.31280616e-02f,
  -3.96003485e-01f, -5.63907385e-01f, -4.80291903e-01f, 7.36827314e-01f, -3.94044697e-01f, 7.85276771e-01f, 2.94690192e-01f, 2.46380240e-01f, -7.35286713e-01f, 4.08015512e-02f,
  -5.59694052e-01f, -3.36861819e-01f, -4.96233284e-01f, 4.43477482e-02f, 8.90802026e-01f, 3.04579347e-01f, -1.68572351e-01f, 4.69980180e-01f, -1.84702560e-01f, -2.68917263e-01f,
  1.20487344e+00f, -6.51195049e-01f, -5.65119028e-01f, -2.79599726e-02f, 7.02189922e-01f, 4.68327940e-01f, 4.66062844e-01f, -2.15872943e-01f, 4.34880257e-01f, 3.13132584e-01f,
  -4.97576714e-01f, 1.22211790e+00f, 3.94508511e-01f, 1.13288605e+00f, -1.75997555e-01f, -6.35319889e-01f, -6.22579567e-02f, -2.00045109e-01f, -2.93043613e-01f, -1.84467822e-01f,
  5.21469295e-01f, 2.03960612e-01f, 1.78454921e-01f, 1.70791805e-01f, -2.98585236e-01f, 6.67377591e-01f, -1.70770898e-01f, -8.91440034e-01f, 2.50039399e-01f, -2.37906292e-01f,
  1.39226222e+00f, 8.02413672e-02f, -6.32655025e-01f, -5.17695427e-01f, -3.01650196e-01f, 1.49544626e-01f, 3.01836580e-01f, -3.89060110e-01f, 7.17835486e-01f, -2.44318783e-01f,
  6.02548420e-01f, -1.13837838e+00f, 4.28788245e-01f, -9.49768960e-01f, -4.04252261e-01f, 2.20861465e-01f, 1.73623949e-01f, 1.90778777e-01f, -3.88993591e-01f, -7.43606150e-01f,
  1.07014346e+00f, -1.37590349e-01f, -3.71137783e-02f, -6.39868557e-01f, -2.72118062e-01f, 3.62046510e-02f, -3.96844506e-01f, 3.24053645e-01f, -1.82655007e-01f, -1.03083335e-01f,
  1.13236094e+00f, -3.85538161e-01f, -1.89590231e-01f, 1.68583408e-01f, 5.81840873e-01f, -4.31508482e-01f, 4.61219162e-01f, -3.22730243e-02f, 1.10581577e-01f, -7.28398979e-01f,
  -2.96889365e-01f, -7.30229318e-02f, -3.76456171e-01f, -7.93136299e-01f, -9.17478085e-01f, -4.20306832e-01f, -1.36139154e-01f, -4.46788907e-01f, -3.45967352e-01f, 2.83042938e-01f,
  -3.80826145e-01f, 2.65336245e-01f, -3.89750659e-01f, 1.18890011e+00f, -4.24219459e-01f, 1.71040729e-01f, -3.74734223e-01f, 6.45517886e-01f, 4.11538005e-01f, 8.04028332e-01f,
  -7.95327008e-01f, 2.67031610e-01f, -8.90099108e-02f, 2.10123975e-02f, -5.20699561e-01f, -2.66457438e-01f, -5.54413080e-01f, -3.72612387e-01f, 1.36403966e+00f, 1.00256227e-01f,
  2.89359242e-01f, 4.03668225e-01f, -8.40111971e-01f, 2.34611645e-01f, -9.43723798e-01f, -5.25561392e-01f, 1.22098243e+00f, 1.26573169e+00f, -4.06490028e-01f, -6.31268740e-01f,
  6.11685887e-02f, -1.75969489e-02f, 5.20527959e-01f, 8.18621695e-01f, 6.57051876e-02f, -8.62156227e-02f, 1.72159255e-01f, 1.82133988e-01f, 4.01012808e-01f, -3.26611459e-01f,
  -3.69162053e-01f, -2.59091228e-01f, 2.90054958e-02f, 7.98454404e-01f, -2.88118184e-01f, 2.77129799e-01f, 1.39437094e-01f, 1.50886106e+00f, -4.24813986e-01f, -6.62994981e-01f,
  -4.19069886e-01f, -2.79240429e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  1.41848609e-01f, 1.04177408e-01f, -1.57287493e-01f, -2.39116699e-01f, 2.11916178e-01f, 1.61476091e-01f, -9.37326346e-03f, -5.10331452e-01f, -2.96675950e-01f, -1.70472831e-01f,
  7.51428828e-02f, -3.18871513e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 4, 8
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        16, 12
    );
    }
    