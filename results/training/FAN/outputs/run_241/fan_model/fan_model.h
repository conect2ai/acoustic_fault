/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 3 x 120)
const int L0_fan_Wp_rows = 3;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -4.99903440e-01f, 2.88897634e-01f, -1.86890036e-01f, 4.22624871e-02f, -8.26993585e-02f, 1.90571472e-01f, -4.75118943e-02f, -6.90559074e-02f, -2.78507054e-01f, 1.96243525e-01f,
  -9.87624843e-03f, -2.18220040e-01f, -7.83326924e-02f, 1.85253426e-01f, 4.52603847e-02f, 1.40521243e-01f, 2.38206133e-01f, 4.61290739e-02f, -1.20474091e-02f, 4.20027152e-02f,
  6.13322333e-02f, 2.60258317e-01f, 1.90775990e-01f, 1.00545652e-01f, -5.30917384e-02f, -6.35138750e-02f, 1.67804211e-01f, -6.84543177e-02f, 2.02280551e-01f, -2.89503653e-02f,
  1.03619061e-01f, -1.94093466e-01f, -9.10812244e-02f, -8.57868940e-02f, -1.80857312e-02f, 1.66432671e-02f, 7.06551597e-03f, -3.38717848e-02f, -5.82725927e-02f, -9.97920148e-03f,
  -5.70261814e-02f, -5.34302518e-02f, 7.06946850e-02f, -1.98914483e-02f, -5.39599843e-02f, -4.66118392e-04f, -4.46871249e-03f, 1.37813082e-02f, -1.80482529e-02f, -3.05243739e-04f,
  -5.39557310e-03f, 6.09658398e-02f, 1.67624930e-05f, 9.46025625e-02f, -1.00994278e-02f, -2.99967639e-03f, 2.57288311e-02f, -2.33320314e-02f, 1.12671144e-01f, -3.11755538e-02f,
  -4.12988327e-02f, 4.06660326e-02f, 1.72119197e-02f, -4.70223092e-02f, 1.25948032e-02f, 6.63881674e-02f, 2.39649005e-02f, 4.84787785e-02f, -2.69593466e-02f, 6.70256093e-02f,
  1.02513074e-03f, -4.61462289e-02f, -4.19971645e-02f, 1.36027383e-02f, 7.31409267e-02f, 4.14600298e-02f, 1.00738602e-02f, -4.28023702e-03f, -1.41909858e-02f, 4.24029417e-02f,
  -6.29605129e-02f, 3.12159788e-02f, -1.21058067e-02f, 6.90954849e-02f, 3.91532704e-02f, -8.16453435e-03f, 5.50782867e-03f, 4.04243506e-02f, -2.84808800e-02f, 2.73981858e-02f,
  1.46255150e-01f, 2.16747046e-01f, 1.21424207e-02f, 1.01100304e-03f, 1.20795402e-03f, -1.55613711e-02f, 3.43692452e-02f, 1.54476399e-02f, 1.56369153e-02f, -7.14806914e-02f,
  5.85870855e-02f, 9.77532286e-03f, -3.12206103e-03f, 2.13334262e-02f, 1.18498821e-02f, 2.99980678e-02f, 8.28566775e-02f, 4.51905876e-02f, 1.11456364e-02f, 9.27341059e-02f,
  5.71341030e-02f, -2.02295724e-02f, -4.62655816e-03f, -1.95334367e-02f, 2.74769757e-02f, -6.52934890e-04f, -5.52529050e-03f, 1.04788505e-02f, 9.77139222e-04f, 2.82886531e-02f,
  2.50699427e-02f, 2.73498446e-01f, -3.24771740e-02f, -2.32291624e-01f, -1.46008223e-01f, 2.19194502e-01f, 3.14826727e-01f, -8.11717585e-02f, 1.65066235e-02f, 2.78328359e-01f,
  -8.43686834e-02f, 1.40966952e-01f, 2.95799047e-01f, -1.17753960e-01f, -1.82235762e-01f, 2.99774021e-01f, -1.18536294e-01f, 7.21627697e-02f, 6.15366958e-02f, -5.72422408e-02f,
  -1.47130132e-01f, -5.72225675e-02f, -9.68817845e-02f, 1.05955009e-03f, -5.39876521e-02f, -1.30117655e-01f, -2.59990036e-01f, 1.83097888e-02f, -1.30584329e-01f, -7.49719813e-02f,
  6.76867142e-02f, 7.92956352e-03f, 1.85191520e-02f, 5.75517938e-02f, -6.46977723e-02f, -2.20732335e-02f, -7.24919736e-02f, 4.86998484e-02f, -9.94880646e-02f, 2.49261465e-02f,
  8.56004357e-02f, -3.33595984e-02f, -5.35892136e-03f, -3.15555348e-03f, -7.87503794e-02f, -1.96814090e-02f, -8.71770978e-02f, -9.53230858e-02f, -8.00712314e-03f, -5.72079234e-03f,
  2.42579728e-02f, -4.85457368e-02f, -5.30449040e-02f, -2.60873549e-02f, -1.11311175e-01f, -8.47553276e-03f, 2.03950517e-02f, 6.15250878e-03f, -2.30118614e-02f, -1.94461904e-02f,
  -8.98836367e-03f, 5.88246584e-02f, 3.04848924e-02f, 6.36560544e-02f, -9.29020531e-03f, 8.00950546e-03f, -3.46487090e-02f, 2.31558513e-02f, -5.34684211e-03f, 3.36857922e-02f,
  -1.89939104e-02f, -4.16455530e-02f, -3.17769945e-02f, -5.58535475e-03f, 1.57547034e-02f, 5.84985763e-02f, 5.97388903e-03f, 1.97263137e-02f, -7.02570518e-03f, -6.19690530e-02f,
  3.68875749e-02f, 1.65377010e-03f, -2.07599765e-03f, -2.47579440e-02f, 2.31133271e-02f, -1.17843347e-02f, -7.22920522e-03f, 5.27678849e-03f, 2.79720742e-02f, 1.19235311e-02f,
  -1.20282568e-01f, -8.52708369e-02f, 1.33872358e-02f, -9.51347873e-03f, 3.64536121e-02f, 3.62707376e-02f, -8.70471913e-03f, 2.83437800e-02f, -2.92677656e-02f, 4.01806720e-02f,
  -2.46802326e-02f, -9.30022169e-03f, 2.28276420e-02f, -4.64451239e-02f, 5.85897872e-03f, 5.30333631e-02f, 1.48325097e-02f, -1.25434157e-02f, -1.09547980e-01f, -8.01704526e-02f,
  -8.24240316e-03f, 9.08143967e-02f, -2.88456064e-02f, -7.30580930e-03f, 4.91409190e-02f, -1.26772968e-03f, -2.56038401e-02f, -1.01091724e-03f, 2.62918603e-02f, -1.52692720e-02f,
  -3.28007251e-01f, 1.54915527e-01f, 1.89149678e-01f, -1.22547515e-01f, -1.40801398e-02f, -3.61439407e-01f, -3.81931484e-01f, 1.17652722e-01f, 5.82792722e-02f, 4.17198474e-03f,
  -1.90083593e-01f, 2.33205892e-02f, 1.00269549e-01f, -4.05265778e-01f, -3.75673294e-01f, -7.22917076e-03f, -3.67114335e-01f, -1.93471149e-01f, 5.34054600e-02f, -2.73284391e-02f,
  -4.89705242e-02f, -2.71240026e-01f, 3.48445680e-03f, 2.18014926e-01f, -4.97902110e-02f, 2.33409032e-01f, -2.62073670e-02f, 1.92797333e-01f, -7.31057152e-02f, -4.72992621e-02f,
  -1.19115934e-01f, 9.91762206e-02f, 7.34192133e-02f, 1.95754673e-02f, -5.44408150e-02f, -4.07962240e-02f, -6.66263774e-02f, -7.30609242e-03f, 1.19479652e-02f, 2.00156681e-02f,
  -1.77813992e-02f, -2.48839371e-02f, -2.20945012e-02f, 4.06715423e-02f, -4.05670404e-02f, 8.95818397e-02f, 6.27963664e-03f, 4.02744859e-02f, 5.17748632e-02f, -4.15257514e-02f,
  1.79286525e-02f, -6.09745495e-02f, -4.35156524e-02f, -3.64345796e-02f, 1.26421330e-02f, -4.28074710e-02f, -4.06092815e-02f, 2.93341968e-02f, -2.19995137e-02f, -4.42234799e-02f,
  -3.50456964e-03f, -5.31974696e-02f, -1.72816534e-02f, 6.56550238e-03f, -2.09759511e-02f, 4.75532748e-02f, -2.91743106e-03f, -1.93723999e-02f, 3.05080339e-02f, -1.07050650e-02f,
  -5.91123179e-02f, -1.41301155e-02f, -4.07765396e-02f, -2.30295304e-02f, -2.60794591e-02f, 9.37442854e-03f, -4.29231785e-02f, -1.60674993e-02f, -7.68534606e-03f, 1.34934103e-02f,
  2.27989759e-02f, -7.86001906e-02f, 3.81824225e-02f, -5.08808270e-02f, -2.96240374e-02f, 2.05425471e-02f, -2.60763224e-02f, 2.59442199e-02f, 4.77549098e-02f, -2.78178137e-02f,
  -1.30970757e-02f, 2.37743836e-02f, 9.38850641e-02f, 1.32672843e-02f, 1.61383767e-02f, -2.24191491e-02f, -1.95936654e-02f, 4.09756862e-02f, 3.58526111e-02f, -6.12275824e-02f,
  -3.48562449e-02f, -2.68451553e-02f, 1.89418811e-03f, -2.28278525e-02f, 2.49784552e-02f, -4.05070819e-02f, -5.87139204e-02f, -5.87136261e-02f, -5.67788035e-02f, 2.27716789e-02f,
  1.38041209e-02f, -2.49922425e-02f, 4.53470740e-03f, 2.63158586e-02f, -3.00902687e-02f, 9.95030045e-04f, 2.34614257e-02f, 4.03805561e-02f, -5.24056423e-03f, 1.45323230e-02f
};

// L0_fan_Wp_bar (Shape: 26 x 120)
const int L0_fan_Wp_bar_rows = 26;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  9.32259578e-03f, -3.89494523e-02f, -1.15360506e-01f, -4.15295690e-01f, -1.18076205e-01f, -2.85326719e-01f, -3.60056460e-01f, -2.23356307e-01f, 2.84603089e-02f, -8.95398781e-02f,
  -1.02757156e-01f, -4.23776284e-02f, 2.76619881e-01f, -3.53908926e-01f, 6.28880560e-02f, 2.28723571e-01f, -3.81556094e-01f, -1.92631260e-01f, -5.72776832e-02f, -3.04795891e-01f,
  -5.11095896e-02f, -1.25205010e-01f, -1.70751795e-01f, -1.12264089e-01f, -3.03549051e-01f, -1.83978438e-01f, -8.40713903e-02f, 7.67602697e-02f, -1.86592996e-01f, 2.76256762e-02f,
  -1.43091530e-01f, -9.32398289e-02f, 1.00717051e-02f, -7.74541572e-02f, -1.67948440e-01f, -1.03081115e-01f, -3.27977054e-02f, 1.51801379e-02f, 2.48705763e-02f, -1.18322400e-02f,
  -2.06200685e-02f, -1.55991893e-02f, -6.70297816e-02f, 6.08625065e-04f, -7.26107433e-02f, -6.17363006e-02f, 3.91542129e-02f, -6.97099343e-02f, -5.34614623e-02f, 7.34349666e-03f,
  -5.43435104e-02f, 9.97527316e-03f, -5.04135340e-02f, 6.20959736e-02f, 4.17531058e-02f, -5.00457175e-02f, 4.79953587e-02f, -3.43651487e-03f, 1.66990887e-02f, 1.52970226e-02f,
  -3.22098434e-02f, 8.03531781e-02f, -5.19200079e-02f, -2.36504395e-02f, 1.38600338e-02f, -1.34797357e-02f, -3.02781146e-02f, -4.14500386e-02f, -1.16896005e-02f, 6.49662316e-02f,
  -3.94174224e-03f, -6.16608448e-02f, -2.82985345e-02f, 1.23896142e-02f, -7.03526288e-02f, -4.50330302e-02f, 3.87286283e-02f, -3.11756786e-02f, -2.60147564e-02f, 1.40117062e-02f,
  -2.71231718e-02f, 1.13559945e-03f, 1.66828427e-02f, 3.83666605e-02f, 3.03075789e-03f, 7.97662064e-02f, -9.56350472e-03f, 3.00083272e-02f, 6.96937460e-03f, -4.31209803e-02f,
  -1.17899142e-02f, -1.22936592e-01f, -7.48449937e-02f, -1.28106596e-02f, -1.48343658e-02f, -8.86427015e-02f, -9.52582955e-02f, -1.08817309e-01f, -1.02434896e-01f, -9.49609745e-03f,
  -1.32393524e-01f, 1.20137902e-02f, -9.42023396e-02f, 4.20506336e-02f, -5.20969927e-02f, -4.80904952e-02f, -9.34074540e-03f, -3.15368903e-04f, 1.47547079e-02f, 1.28102610e-02f,
  4.77499282e-03f, -2.79669613e-02f, -3.10343206e-02f, 2.02492867e-02f, -2.95509286e-02f, 2.12598871e-02f, -3.46057042e-02f, -1.85044762e-02f, -1.26734246e-02f, -1.86172836e-02f,
  -1.78396389e-01f, -2.27529868e-01f, -1.35587558e-01f, 1.10823311e-01f, 1.16755426e-01f, -2.96055041e-02f, -2.31396869e-01f, -3.84029634e-02f, -2.63271004e-01f, -1.65752396e-01f,
  -9.60185751e-03f, -1.13525130e-01f, -2.90500879e-01f, -4.51307511e-04f, -1.23085761e-02f, -2.09747434e-01f, 1.68797988e-02f, 3.21644433e-02f, -3.87651287e-02f, 8.33072960e-02f,
  1.47219613e-01f, 2.64235705e-01f, 1.59582287e-01f, 3.41092587e-01f, 1.26051873e-01f, 2.36687511e-01f, 3.71561557e-01f, 1.42530024e-01f, 2.67916441e-01f, 1.20401546e-01f,
  -1.40712485e-01f, -5.58098741e-02f, -1.02489136e-01f, 4.87500511e-04f, -1.45701906e-02f, -2.35496107e-02f, -1.36210881e-02f, 1.80403348e-02f, 2.44684946e-02f, 5.04973792e-02f,
  -8.91597643e-02f, -7.33347982e-03f, 1.26065210e-01f, 6.50224984e-02f, -7.99271837e-03f, 9.28320065e-02f, -5.28816134e-02f, -2.96325586e-03f, -1.71969663e-02f, -9.09446552e-02f,
  -9.83528271e-02f, -6.37876987e-02f, 9.93560329e-02f, 6.24275245e-02f, -5.01319626e-03f, 1.65309943e-02f, -7.85867404e-03f, 5.53797372e-03f, 6.93317428e-02f, 2.27883514e-02f,
  -6.59416318e-02f, 5.61408475e-02f, 9.63945966e-03f, -3.24376188e-02f, 8.20677727e-03f, 2.34629046e-02f, -7.23149208e-03f, 9.40897390e-02f, 3.39490362e-02f, -5.88185936e-02f,
  -2.87010591e-03f, 3.56169343e-02f, -3.94719578e-02f, 3.19383964e-02f, 3.93037833e-02f, -1.03671737e-01f, 2.02098861e-03f, 3.97359654e-02f, 2.17874851e-02f, 5.89361861e-02f,
  1.63361281e-02f, -7.56722391e-02f, -6.07541054e-02f, 2.74225473e-02f, -6.79733455e-02f, 2.01667324e-02f, 2.87345517e-02f, -6.57727271e-02f, 3.50018330e-02f, 4.97953482e-02f,
  -9.62288082e-02f, 1.38208847e-02f, 2.63087079e-02f, 8.28283131e-02f, 7.84423426e-02f, 1.63077693e-02f, 5.55747785e-02f, -8.54861289e-02f, -2.23333612e-02f, -2.21539731e-03f,
  -1.90239623e-02f, 1.22663960e-01f, -4.36696224e-02f, 1.61547437e-02f, 1.44021571e-01f, -5.53067424e-04f, -2.05736253e-02f, -3.49589102e-02f, 2.64897235e-02f, 3.34221385e-02f,
  2.23640893e-02f, 8.48774612e-02f, -2.44899280e-02f, -1.83337030e-03f, 2.17855517e-02f, 1.01785071e-01f, -4.35473630e-03f, 1.61325764e-02f, -3.32406163e-02f, -3.95232141e-02f,
  2.90700495e-01f, -3.07980806e-01f, -2.45107129e-01f, 3.71283323e-01f, 2.81014502e-01f, 1.03195816e-01f, 3.28633279e-01f, 2.52719998e-01f, 5.92220306e-01f, -9.87840444e-02f,
  9.53095034e-02f, -2.32311919e-01f, -1.48210377e-01f, 1.50404230e-01f, 1.61471650e-01f, -3.83077450e-02f, 2.06922323e-01f, 1.19025566e-01f, 1.83855236e-01f, 1.59977917e-02f,
  1.62560150e-01f, 2.01032966e-01f, -1.90491885e-01f, -1.02775596e-01f, 3.18813622e-02f, -1.20652877e-01f, -9.09573138e-02f, -1.63327754e-01f, -1.98993251e-01f, -1.13715425e-01f,
  2.98752747e-02f, 1.24540463e-01f, 4.61685620e-02f, -1.11212298e-01f, 1.24868592e-02f, -1.37522388e-02f, -1.52697101e-01f, -7.41038397e-02f, 1.05545595e-01f, 1.21197008e-01f,
  -8.09206739e-02f, 2.59515662e-02f, 2.55719088e-02f, -4.71016914e-02f, 9.38555300e-02f, -1.12477224e-02f, -2.81161889e-02f, 6.76061139e-02f, -5.13233542e-02f, -7.83999786e-02f,
  -2.24280208e-02f, -3.44172530e-02f, 1.04369633e-02f, -3.87720950e-02f, 4.73041534e-02f, 6.73007369e-02f, -4.58590351e-02f, -1.00683622e-01f, -5.14654852e-02f, 4.40120846e-02f,
  -3.47240409e-03f, -6.81271553e-02f, -1.06880274e-02f, 4.16656248e-02f, 9.68623254e-03f, 2.87203006e-02f, 4.10361625e-02f, -6.13124855e-02f, 1.17862578e-02f, -4.16110456e-03f,
  7.72465020e-02f, 7.32553750e-02f, -1.05849504e-02f, -8.04735534e-03f, 6.02834634e-02f, 3.07919066e-02f, -1.18065134e-01f, 7.82822724e-03f, 3.45020853e-02f, 1.23760607e-02f,
  -1.96588524e-02f, -6.66389316e-02f, -2.70434376e-02f, 2.44517648e-03f, 2.81574298e-02f, 5.98539179e-03f, 6.56585395e-03f, -3.95005606e-02f, 1.02555854e-02f, 1.88223831e-02f,
  -1.04065696e-02f, -7.43495896e-02f, 2.89257932e-02f, -2.36995537e-02f, -1.15600973e-01f, 4.14117686e-02f, -2.88364310e-02f, -4.35103476e-02f, -7.77678043e-02f, 2.17200592e-02f,
  -7.03061000e-02f, 1.71938408e-02f, -2.50704512e-02f, -2.76395287e-02f, -1.35473730e-02f, 5.71299344e-02f, 4.84463796e-02f, -3.21895406e-02f, 2.88787764e-02f, -9.22028795e-02f,
  -9.36677977e-02f, -3.03342603e-02f, -2.27950644e-02f, 5.19132093e-02f, -4.35743146e-02f, -9.74178165e-02f, -2.87193097e-02f, -7.66528547e-02f, -9.96467397e-02f, -5.33130504e-02f,
  -1.01097792e-01f, 1.13734059e-01f, -3.14030737e-01f, -1.99078619e-01f, 4.36210744e-02f, -5.43291330e-01f, -2.82694191e-01f, -1.73366033e-02f, 1.79635227e-01f, 2.03713030e-01f,
  1.80662051e-01f, 4.24221493e-02f, 1.82129577e-01f, -1.56626746e-01f, -5.00697434e-01f, 5.52019402e-02f, -4.45175648e-01f, -1.99667946e-01f, -1.61212159e-03f, -7.83546492e-02f,
  -1.56363338e-01f, 5.76494187e-02f, -2.01224953e-01f, 1.73292413e-01f, -8.58016238e-02f, 3.07210311e-02f, 1.49482563e-01f, 9.93099585e-02f, -1.95234001e-01f, -1.62186418e-02f,
  -1.02661766e-01f, 2.05921084e-01f, -4.92682047e-02f, -5.59319556e-02f, -1.01980589e-01f, -3.27885449e-02f, -1.21940374e-01f, -4.52134833e-02f, -5.00835553e-02f, 2.67883250e-03f,
  -1.80331767e-02f, 7.75201654e-04f, 3.60048562e-02f, 1.29579768e-01f, 8.62405896e-02f, -2.52252035e-02f, 1.21426536e-02f, -3.99498269e-02f, 4.23088074e-02f, -2.30560154e-02f,
  -7.85358772e-02f, -1.12510026e-02f, -1.00725323e-01f, 4.79727946e-02f, -5.57925329e-02f, 3.32598910e-02f, -6.95269778e-02f, -1.07087933e-01f, 4.13959324e-02f, -4.70395423e-02f,
  7.85491720e-04f, 2.82895342e-02f, -1.68954246e-02f, -3.04550771e-02f, 2.32511852e-02f, 9.37166158e-03f, -1.67361181e-02f, 1.43202944e-02f, 5.83575778e-02f, -6.43560737e-02f,
  1.94093436e-02f, 4.75748489e-03f, 5.96314147e-02f, -7.31777549e-02f, -4.61465679e-02f, -4.38216981e-03f, -5.37577793e-02f, 5.33444583e-02f, -1.03398897e-01f, -9.37748924e-02f,
  3.33715789e-02f, 5.37225604e-03f, 2.83132959e-02f, 2.17722803e-02f, 2.73157153e-02f, 5.80047853e-02f, 6.44708648e-02f, -5.24164811e-02f, 9.73475922e-04f, 6.64377287e-02f,
  -1.55116647e-01f, 4.23857793e-02f, 5.51794004e-03f, 1.66742101e-01f, 1.56749543e-02f, -7.14730769e-02f, -2.32945122e-02f, -4.39784452e-02f, -1.07896319e-02f, 6.57698698e-03f,
  -7.80427605e-02f, -1.17069939e-02f, -8.56430903e-02f, 1.08627461e-01f, -2.49570291e-02f, -4.26995158e-02f, -3.66380848e-02f, 1.38297928e-02f, -1.11856192e-01f, -6.66714013e-02f,
  8.15981328e-02f, 2.92098094e-02f, 8.16650093e-02f, -3.58514227e-02f, -3.78663838e-02f, -7.49588534e-02f, 1.16313212e-02f, 5.92520945e-02f, -7.65268728e-02f, -4.93815579e-02f,
  -1.08334363e-01f, 7.66236186e-02f, 1.00827061e-01f, 9.72448885e-02f, -2.95037031e-02f, -3.22081000e-01f, -3.24209809e-01f, 9.50817764e-02f, 3.22159193e-02f, -2.05790266e-01f,
  -3.23876999e-02f, 1.02801919e-02f, 4.09504361e-02f, -1.13009632e-01f, 2.15855733e-01f, 2.54720598e-01f, -1.03988186e-01f, -4.10090834e-02f, 1.68725505e-01f, -5.85338585e-02f,
  1.81253284e-01f, -8.40967819e-02f, 2.12901071e-01f, 7.83579331e-03f, -1.36319786e-01f, 2.02233903e-02f, 1.20918907e-01f, 6.30829334e-02f, -1.20197982e-01f, 2.13158801e-02f,
  -3.44357602e-02f, 6.89818859e-02f, 1.29104424e-02f, -5.95322624e-02f, -1.12337628e-02f, -7.26236627e-02f, -1.00509822e-02f, -1.10056020e-01f, 4.61197309e-02f, 3.25077735e-02f,
  2.11250093e-02f, -2.41217408e-02f, 2.98528261e-02f, 1.39376486e-03f, -6.65720645e-03f, 2.15819720e-02f, -5.26025817e-02f, -5.27372956e-02f, -8.17445442e-02f, 3.05249467e-02f,
  -5.66785485e-02f, -2.27536913e-02f, -7.21013546e-02f, -2.73263101e-02f, 7.61828497e-02f, -4.65434864e-02f, -3.99307348e-02f, 3.62133682e-02f, 6.92973062e-02f, 6.93320064e-04f,
  -5.06224670e-02f, -3.18791680e-02f, 2.71631554e-02f, 8.44943076e-02f, 3.86247295e-03f, 1.77971758e-02f, -8.69640708e-02f, -2.43842229e-03f, 8.41699839e-02f, 5.24049923e-02f,
  8.58140662e-02f, 2.19765380e-02f, 8.34728852e-02f, -8.08106735e-02f, -5.16417995e-03f, 4.50503081e-02f, 3.99528854e-02f, -4.52291258e-02f, 7.04409629e-02f, 2.30258591e-02f,
  1.83319468e-02f, -4.38023321e-02f, 2.72922255e-02f, -2.90807392e-02f, -1.86386947e-02f, -6.16693310e-03f, -8.07211176e-02f, -2.69438718e-02f, 3.51151861e-02f, -8.69345944e-03f,
  -2.67364029e-02f, 1.66863516e-01f, -3.06435078e-02f, -1.26161918e-01f, 2.55714240e-03f, 2.59999977e-03f, -3.26379165e-02f, -2.44240277e-02f, -2.05295254e-03f, -3.81353237e-02f,
  -4.71063750e-03f, 2.38195397e-02f, -4.95863222e-02f, -2.05156300e-02f, -6.12980723e-02f, 2.61252262e-02f, 7.46214837e-02f, 7.60314614e-02f, 4.56606299e-02f, -1.68592222e-02f,
  -2.81161331e-02f, 6.34802580e-02f, 1.23367105e-02f, -4.86436263e-02f, -3.28604281e-02f, -3.14380527e-02f, 9.05954614e-02f, -5.95118068e-02f, -1.69736650e-02f, 1.26057178e-01f,
  6.69242322e-01f, 1.51728466e-01f, 4.67798799e-01f, 4.88308281e-01f, -4.40899059e-02f, -8.40085149e-02f, 2.03234196e-01f, -9.81485378e-03f, 5.27420044e-01f, -7.41906092e-02f,
  -2.97835737e-01f, 4.45328563e-01f, -2.99543381e-01f, 1.49061590e-01f, -3.24877590e-01f, -3.40827733e-01f, 7.69546181e-02f, 1.55157819e-01f, 7.29671717e-02f, 2.88747221e-01f,
  1.28271610e-01f, -3.51736337e-01f, -1.32301047e-01f, -3.33598644e-01f, 2.32583895e-01f, 2.33643055e-01f, -4.06617492e-01f, -1.82592854e-01f, -5.09079266e-03f, -3.08393836e-01f,
  1.05090216e-02f, 6.41635805e-02f, 1.30060196e-01f, 2.22903937e-02f, 5.87793626e-03f, -2.31384803e-02f, -2.92700678e-02f, -1.39293492e-01f, 2.29634661e-02f, 7.79986605e-02f,
  5.47090583e-02f, -1.16917521e-01f, 1.64646786e-02f, -6.19589444e-03f, 7.67727867e-02f, 8.01213011e-02f, 5.64088449e-02f, 1.07400618e-01f, 6.21709265e-02f, 1.02984540e-01f,
  2.15162754e-01f, 9.30708125e-02f, 1.53939173e-01f, -1.88357048e-02f, 1.85838584e-02f, -5.95173389e-02f, -3.74061242e-02f, -4.84014908e-03f, 1.41274557e-01f, 4.21237983e-02f,
  -1.07268289e-01f, -3.46770287e-02f, -1.48998704e-02f, 5.29441983e-02f, 3.01961275e-03f, -1.11198158e-03f, 4.06780653e-03f, -5.16335852e-02f, 9.22295228e-02f, 3.44385430e-02f,
  9.45263263e-03f, 1.84578523e-02f, 7.07451196e-04f, 3.84034887e-02f, 7.85259008e-02f, 2.00157668e-02f, 2.05100165e-03f, 4.29365598e-03f, 6.46686330e-02f, 8.63928720e-03f,
  -4.75186780e-02f, -5.28055020e-02f, -9.92743205e-03f, 6.18554614e-02f, -4.69425470e-02f, -2.53298581e-02f, 2.46253945e-02f, 1.51886642e-01f, 2.71825437e-02f, -6.54724464e-02f,
  -9.02149379e-02f, -1.85994938e-01f, -2.02238187e-02f, 5.93154542e-02f, 3.47831137e-02f, -8.81959274e-02f, -1.85987931e-02f, 8.06641486e-03f, -8.82240012e-02f, -4.81994301e-02f,
  -1.88416615e-02f, 7.05436021e-02f, -5.90439886e-02f, -3.30045843e-03f, -9.07596201e-02f, -5.96793853e-02f, -5.80912530e-02f, -4.76116762e-02f, -1.23456411e-01f, -2.63270568e-02f,
  5.45973368e-02f, -2.22087055e-02f, -8.23514274e-05f, 2.95991488e-02f, -3.80235142e-03f, -9.87823401e-03f, 9.23907682e-02f, -1.44714443e-02f, -3.65035012e-02f, 4.96737845e-03f,
  -2.70102322e-01f, 7.14351609e-02f, 1.83786139e-01f, 2.29747240e-02f, -3.17931324e-01f, 2.21266285e-01f, 3.30038130e-01f, -1.66235179e-01f, 2.31713355e-02f, -2.26774495e-02f,
  -9.95103717e-02f, 6.23538010e-02f, 2.63474882e-01f, 6.38627680e-03f, 3.62512231e-01f, 3.05749744e-01f, 2.12464780e-01f, 7.75652230e-02f, 1.76002830e-02f, -9.05865133e-02f,
  -1.60818666e-01f, -2.35969633e-01f, 3.68305147e-02f, -2.15212777e-01f, -1.76743865e-01f, -1.62855119e-01f, -2.51429886e-01f, -7.26344734e-02f, -2.14426503e-01f, -7.64035881e-02f,
  -1.30629629e-01f, -8.55369717e-02f, 1.82821546e-02f, 1.11177586e-01f, 9.70011391e-03f, -5.69449030e-02f, -6.59093335e-02f, 5.08529134e-02f, 6.22694306e-02f, -9.34045669e-03f,
  6.42701611e-02f, 5.02243564e-02f, -6.34233356e-02f, 1.81915481e-02f, -3.99968177e-02f, -1.16676055e-01f, -9.88474935e-02f, -6.06243648e-02f, 1.98240653e-02f, -1.93982050e-02f,
  -4.13713753e-02f, 2.62190811e-02f, -2.65942961e-02f, 1.22153953e-01f, -4.86478694e-02f, 2.00255122e-02f, 7.92015251e-03f, 8.21600407e-02f, -4.20570001e-02f, 1.03627685e-02f,
  -6.22888841e-03f, 2.34861602e-03f, 1.63559094e-02f, -9.08696577e-02f, 1.81978419e-02f, -1.09758474e-01f, -2.58805323e-02f, -2.37078569e-03f, -2.14101598e-02f, -2.78495289e-02f,
  -5.39499242e-03f, -6.40190765e-02f, -5.31344302e-02f, 2.59088390e-02f, -6.50511086e-02f, 5.95030971e-02f, 5.37173972e-02f, 1.32118389e-02f, 5.09454124e-02f, 6.04255423e-02f,
  -6.27405271e-02f, 3.80183905e-02f, 6.22911826e-02f, -3.99455475e-03f, 6.55307174e-02f, 4.44777645e-02f, -1.21808447e-01f, -3.65672936e-03f, 3.48344781e-02f, 3.58595252e-02f,
  -5.80345690e-02f, -8.13953429e-02f, -1.69861224e-02f, -2.07547043e-02f, -2.44911406e-02f, -4.55666482e-02f, 8.05799291e-02f, -9.05143917e-02f, 1.89359486e-02f, 2.49016788e-02f,
  -6.61919713e-02f, 2.95434389e-02f, 4.12720032e-02f, -3.70827429e-02f, 9.46128368e-03f, -4.27729972e-02f, 6.19544424e-02f, 7.53535107e-02f, -4.41724584e-02f, -7.75441229e-02f,
  3.03529706e-02f, -4.69075516e-02f, 9.76076350e-02f, -2.72907075e-02f, 8.64231810e-02f, 1.51811345e-02f, 3.20090018e-02f, 3.12686265e-02f, 6.87022805e-02f, 1.04836151e-02f,
  -3.96843433e-01f, 3.21417570e-01f, 1.02024749e-01f, -8.71317368e-03f, -1.01894759e-01f, 4.92938468e-03f, 2.87511736e-01f, -2.17535850e-02f, 3.18466395e-01f, 1.74146712e-01f,
  -7.61233494e-02f, 1.43179059e-01f, 2.11656958e-01f, 4.95766625e-02f, -1.79305181e-01f, 6.48936629e-02f, -2.21553221e-02f, 1.44837379e-01f, 2.07050711e-01f, -7.16303438e-02f,
  -1.92374632e-01f, 1.33471802e-01f, -8.98818895e-02f, 2.17704847e-02f, -1.83103457e-01f, 3.72906812e-02f, -1.42799407e-01f, 1.99179322e-01f, -1.48484185e-01f, -1.68906264e-02f,
  -1.18205659e-01f, -8.12411830e-02f, -6.47531450e-02f, -1.13216519e-01f, -1.42663494e-01f, -4.92337765e-03f, 2.74034590e-02f, -1.98739092e-03f, 1.82566531e-02f, -4.96165641e-02f,
  -5.79287810e-03f, -6.75829127e-02f, -5.46339862e-02f, 1.67592037e-02f, 6.40454292e-02f, -8.42409208e-02f, -7.70708695e-02f, -5.03821597e-02f, -4.97553758e-02f, -1.03268728e-01f,
  -5.47337979e-02f, -7.27582127e-02f, 2.28505880e-02f, 4.21704799e-02f, -2.13891198e-03f, -1.50184063e-02f, -2.34170742e-02f, -1.05479151e-01f, -1.19750462e-01f, -3.62162627e-02f,
  -1.69588588e-02f, 7.39683434e-02f, 3.77226286e-02f, 4.46896367e-02f, -2.45884396e-02f, 2.06500739e-02f, -1.90043859e-02f, 1.16962846e-02f, 1.31298946e-02f, -1.32005541e-02f,
  -8.69760513e-02f, -1.01185581e-02f, 2.24662218e-02f, -5.12654856e-02f, 1.81860644e-02f, 5.65824658e-02f, -1.05773211e-01f, -8.12791809e-02f, -5.22990189e-02f, -1.40404599e-02f,
  6.44969344e-02f, 1.71925984e-02f, -1.21605936e-02f, 5.15296869e-03f, 5.94765395e-02f, -5.58420271e-02f, 5.73102459e-02f, 8.45498964e-03f, 2.97376383e-02f, -4.32425328e-02f,
  -1.30091712e-01f, 7.34336898e-02f, -3.80780697e-02f, 3.78101245e-02f, 8.60311761e-02f, -1.37037709e-01f, 1.10824823e-01f, -6.62045181e-02f, 1.82238109e-02f, 9.36489403e-02f,
  -1.65627543e-02f, -6.11211509e-02f, -5.69353029e-02f, 6.28812015e-02f, 3.73591892e-02f, 1.08013414e-02f, 3.82064730e-02f, -3.79717536e-02f, 5.31808799e-03f, -1.48998415e-02f,
  -7.98299760e-02f, 9.61661115e-02f, -3.10783368e-02f, -7.37474784e-02f, -1.39192818e-02f, -6.82136863e-02f, -7.30206445e-02f, -3.31343636e-02f, 5.15274704e-03f, -5.78257255e-02f,
  1.15280740e-01f, 1.06615908e-01f, -3.60647142e-02f, 1.15175895e-01f, -1.64147079e-01f, -1.80809379e-01f, -1.43137798e-01f, -2.10648179e-02f, -1.29615786e-02f, 3.87944691e-02f,
  -3.06331478e-02f, 1.16466973e-02f, 9.33215860e-03f, 2.59929746e-01f, 1.62044600e-01f, -2.55370568e-02f, 2.02084959e-01f, 7.64878169e-02f, 9.38741863e-02f, 5.91520704e-02f,
  9.95605513e-02f, 2.32045278e-01f, 1.58670008e-01f, 2.88108345e-02f, 7.49237612e-02f, -3.08605861e-02f, 1.35465860e-01f, -2.62367856e-02f, 5.54064736e-02f, 2.61729863e-02f,
  1.39600530e-01f, 1.43512726e-01f, -1.31963538e-02f, 6.39744177e-02f, 9.12798643e-02f, 6.57890290e-02f, -1.39604742e-02f, -6.03636280e-02f, 6.35976642e-02f, 3.24651552e-03f,
  4.67380174e-02f, 4.35054414e-02f, 4.43654098e-02f, 5.88469319e-02f, -1.03430174e-01f, -7.10569043e-03f, 1.66682415e-02f, -4.87624928e-02f, 3.68174836e-02f, 2.64075659e-02f,
  -8.38802010e-02f, 3.70562226e-02f, -8.15891549e-02f, 3.43542323e-02f, -8.98411348e-02f, 2.09988430e-02f, 4.17321026e-02f, -3.28391418e-02f, 5.03220074e-02f, 1.09367361e-02f,
  1.03162704e-02f, 8.34678765e-03f, -1.76504592e-03f, 3.96908745e-02f, 2.37024222e-02f, -7.89329410e-02f, -2.67385673e-02f, 2.42402498e-02f, -3.43417041e-02f, 4.36565802e-02f,
  -6.89628944e-02f, -5.90261705e-02f, -2.54278607e-03f, 3.10894605e-02f, 7.44755566e-02f, 5.73606193e-02f, -4.66949679e-02f, 4.52448986e-03f, -6.62847161e-02f, -3.49080563e-02f,
  6.02241158e-02f, -4.91015762e-02f, 5.47164269e-02f, -7.17364997e-03f, -4.97115441e-02f, 1.26580084e-02f, -3.21899988e-02f, 3.57639790e-02f, 2.74904501e-02f, -8.85563716e-02f,
  -1.87836569e-02f, 1.39937058e-01f, 8.02689120e-02f, -9.82822292e-03f, 6.39834926e-02f, 1.60694160e-02f, 1.12466663e-01f, -1.63114909e-02f, 5.25013823e-03f, 5.59291728e-02f,
  6.80964738e-02f, 1.91498864e-02f, 2.54398007e-02f, 5.33576943e-02f, -6.14140928e-02f, 1.04242368e-02f, -8.77989549e-03f, -6.97493926e-02f, -6.69949725e-02f, 2.40630433e-02f,
  -3.35880257e-02f, -3.14042680e-02f, 7.32988268e-02f, 3.75366285e-02f, 3.56641077e-02f, 3.36913858e-03f, 3.91000360e-02f, -2.68232487e-02f, 5.81975430e-02f, -1.42868469e-02f,
  7.65253380e-02f, 1.08030625e-02f, -5.00689521e-02f, -1.85041755e-01f, -1.71141699e-01f, -1.32601187e-01f, -2.56971240e-01f, -1.47092566e-02f, 1.86265782e-02f, -1.60628363e-01f,
  -2.98080772e-01f, 9.91202071e-02f, 4.79139648e-02f, -1.80381685e-01f, 2.86348581e-01f, 1.66038007e-01f, -2.43495688e-01f, -1.67002574e-01f, 3.71968970e-02f, -2.72869229e-01f,
  -1.47733130e-02f, -3.73896271e-01f, 1.73783991e-02f, -2.21323133e-01f, -3.89675319e-01f, -1.87279001e-01f, -1.41617268e-01f, -2.75064766e-01f, -2.01766163e-01f, -8.50997306e-03f,
  -1.84908845e-02f, 6.01376407e-03f, -3.75348404e-02f, 2.24421024e-02f, -5.59924021e-02f, -2.41639744e-02f, -7.96005055e-02f, -8.69877785e-02f, 1.12553230e-02f, 4.81198281e-02f,
  6.02019243e-02f, 4.29646894e-02f, -6.22734874e-02f, 1.60679016e-02f, -1.57802254e-02f, 8.21616873e-02f, -1.65567473e-02f, 6.18729331e-02f, -1.94097236e-02f, 9.86179262e-02f,
  -1.12461708e-02f, 1.76385753e-02f, 4.35612388e-02f, 1.05312318e-02f, -1.21791358e-03f, -6.73147440e-02f, 4.48160209e-02f, 3.44597213e-02f, 1.68983191e-02f, -1.19503215e-02f,
  -8.64902139e-02f, 3.96280773e-02f, -2.22633276e-02f, -1.72384959e-02f, 4.52225730e-02f, -7.70215541e-02f, 8.24918151e-02f, -2.51682615e-03f, -4.20906879e-02f, -1.69894062e-02f,
  -4.37795445e-02f, -9.61319506e-02f, 2.16449681e-03f, 3.13712656e-02f, 2.56590135e-02f, 4.65877466e-02f, -4.77402136e-02f, 3.16483267e-02f, -6.78504482e-02f, -3.73184085e-02f,
  2.61305217e-02f, -2.17678118e-02f, -7.66315013e-02f, -8.39713141e-02f, 7.00663403e-03f, -4.94188257e-02f, -7.39134103e-02f, -3.22403200e-02f, -3.26880440e-02f, -6.01101387e-03f,
  -2.86439806e-02f, -1.37208089e-01f, -5.14933541e-02f, 4.66737598e-02f, 8.39647502e-02f, 1.05625980e-01f, 3.74903344e-02f, -1.36565128e-02f, -6.08644029e-03f, 8.26205499e-03f,
  2.63969041e-02f, -2.17159707e-02f, -7.35870153e-02f, 4.03638817e-02f, 1.17982123e-02f, -1.98331457e-02f, -1.29434928e-01f, 3.92874964e-02f, 2.04189755e-02f, -5.53628244e-02f,
  -7.11520910e-02f, 5.99660864e-03f, 5.40896729e-02f, -7.95649588e-02f, -5.48802465e-02f, -4.34253365e-02f, -5.32165356e-02f, 6.97311908e-02f, -3.78294587e-02f, -1.83680635e-02f,
  -5.95972389e-02f, -9.17740632e-03f, -1.03598065e-03f, 8.31500962e-02f, 8.10051635e-02f, -4.35128845e-02f, -7.78722391e-02f, 1.20404050e-01f, -1.91460811e-02f, -2.86154598e-02f,
  4.73739505e-02f, -1.05006583e-01f, -3.74163911e-02f, -2.39872694e-01f, -1.15766622e-01f, -2.26499200e-01f, -3.41778398e-02f, -9.56081301e-02f, -4.90938574e-02f, 1.27170712e-01f,
  2.33661830e-02f, 4.76383604e-02f, -2.82357670e-02f, 8.88323486e-02f, 1.04304422e-02f, 2.03703597e-01f, 2.20099479e-01f, 1.83452651e-01f, 1.08071879e-01f, -1.31761000e-01f,
  -7.00671002e-02f, -1.16597466e-01f, 2.33184025e-02f, -8.50193873e-02f, 1.05300210e-01f, 2.09315866e-02f, -1.97846685e-02f, -4.85167801e-02f, -4.92908284e-02f, 4.31840569e-02f,
  3.12090367e-02f, -1.31063927e-02f, -4.22513187e-02f, -8.25493783e-02f, -2.14740988e-02f, 8.88856873e-02f, -4.08907514e-03f, -5.77492155e-02f, -5.89980967e-02f, -3.91820036e-02f,
  7.22858235e-02f, -6.97437227e-02f, 6.23031221e-02f, 4.75850049e-03f, 6.69037774e-02f, 5.10217762e-03f, 5.86968772e-02f, 1.07658014e-01f, 3.46816033e-02f, -5.24847843e-02f,
  4.71272506e-03f, -6.72371686e-03f, -3.29260202e-03f, -8.48429874e-02f, -3.79496664e-02f, 7.18152970e-02f, -1.14121608e-01f, -7.68289110e-03f, -3.38398628e-02f, 2.04128884e-02f,
  3.71283176e-03f, -3.52999829e-02f, -9.81780440e-02f, -5.71987256e-02f, -3.11133675e-02f, 1.93151683e-02f, -5.72702475e-02f, -2.76882015e-02f, 2.87657436e-02f, -7.99850153e-04f,
  6.48797899e-02f, 4.56164367e-02f, -3.26651111e-02f, 4.25445521e-03f, -5.10749146e-02f, -2.38850303e-02f, 6.27603233e-02f, -5.74750192e-02f, -1.94318611e-02f, 8.78981054e-02f,
  1.18706040e-01f, 2.70783484e-01f, 8.19029659e-02f, -6.34588674e-02f, -1.90174915e-02f, -4.18469906e-02f, 2.68518971e-03f, -4.16955389e-02f, 1.11058466e-01f, 4.82492521e-02f,
  9.56830829e-02f, 1.10470839e-01f, -6.11849315e-02f, 2.88739745e-02f, 3.03403847e-02f, -4.29629069e-03f, 3.53739075e-02f, 6.56602606e-02f, 1.30708680e-01f, 7.04512298e-02f,
  5.36806174e-02f, 4.22121361e-02f, -1.90540366e-02f, -2.84350757e-03f, -3.61389704e-02f, 4.79809754e-02f, 8.31485242e-02f, 4.46212068e-02f, -2.40608398e-02f, 4.28594835e-02f,
  2.07549095e-01f, -5.91543078e-01f, 3.39852870e-01f, 1.50929466e-01f, 3.47838372e-01f, 1.98069602e-01f, 3.95596504e-01f, -2.30226129e-01f, -1.72868520e-01f, -6.15864277e-01f,
  -1.29609361e-01f, 1.68369035e-03f, 4.62291092e-02f, -6.99411035e-02f, 3.81115437e-01f, -8.35771337e-02f, -6.60898164e-02f, -6.89656883e-02f, 7.36182779e-02f, 7.80472765e-03f,
  6.08647689e-02f, -7.15142712e-02f, 1.59667030e-01f, -2.39607111e-01f, 2.99220216e-02f, -1.51305795e-01f, -6.69460520e-02f, 2.86625206e-01f, -1.03075057e-01f, 1.99399635e-01f,
  -1.00340724e-01f, -2.04201683e-01f, 2.68940385e-02f, -3.14471647e-02f, -4.16708253e-02f, -7.10235094e-04f, 5.82296550e-02f, 2.14005426e-01f, 7.48924837e-02f, 5.24122035e-03f,
  1.06451462e-03f, 3.80566008e-02f, -3.49562652e-02f, 6.57143295e-02f, -5.63104153e-02f, -1.90193001e-02f, 5.42427711e-02f, -1.58708040e-02f, 2.02146713e-02f, 1.02307782e-01f,
  3.44748190e-03f, -6.64368644e-02f, 5.10741659e-02f, -1.13133438e-01f, -5.46398433e-03f, 6.55138586e-03f, 5.10542542e-02f, 9.63416770e-02f, -5.49437702e-02f, -7.50034600e-02f,
  1.19172838e-02f, -4.53912141e-03f, -7.00029209e-02f, -1.10775661e-02f, 2.29261834e-02f, -9.10999195e-04f, -9.28115752e-03f, 4.58037630e-02f, -2.33571976e-02f, -3.25317681e-02f,
  -1.69755183e-02f, -1.23496447e-02f, -4.58159260e-02f, 2.02091355e-02f, -2.29928456e-02f, 4.14475473e-03f, 2.50526834e-02f, 4.80911545e-02f, -1.00369170e-01f, -1.46652851e-03f,
  -4.29171622e-02f, -2.12779939e-02f, -5.03519987e-05f, 2.75378190e-02f, -6.78925067e-02f, 8.87934677e-03f, -1.28085762e-01f, 1.81968734e-02f, -6.46572337e-02f, 6.38275072e-02f,
  -2.71551758e-01f, -3.93344313e-01f, -8.04751739e-02f, -7.85996690e-02f, -9.85101089e-02f, -1.54391989e-01f, -4.04398404e-02f, -4.40518092e-03f, -3.75621617e-02f, -2.52134483e-02f,
  -3.83650661e-02f, 1.42546056e-03f, -1.81650966e-02f, -2.55218558e-02f, -3.86908501e-02f, -8.00569579e-02f, -2.94855312e-02f, -1.21492282e-01f, -4.36058082e-02f, -3.04248370e-02f,
  1.86222363e-02f, -1.28911296e-02f, 7.43245706e-02f, 3.34263630e-02f, -7.12458342e-02f, -3.22889388e-02f, 4.50476110e-02f, 2.68922746e-02f, -2.50174422e-02f, -3.51513131e-03f,
  1.35659739e-01f, 3.79666030e-01f, -1.08155333e-01f, 6.92787766e-02f, 9.13221166e-02f, 2.66000390e-01f, 1.37204364e-01f, 1.57191321e-01f, 1.88856512e-01f, 1.85301229e-01f,
  -7.19613731e-02f, 1.96000993e-01f, -8.09178650e-02f, 1.34724960e-01f, -6.62494972e-02f, -6.03934610e-03f, 2.80532420e-01f, 2.66981632e-01f, 8.47846195e-02f, 1.07248172e-01f,
  -1.38893854e-02f, 1.74104095e-01f, -3.76742393e-01f, 5.40302694e-03f, 2.16109045e-02f, -7.37985000e-02f, -1.89779729e-01f, -1.64458841e-01f, 1.09724768e-01f, 7.83424675e-02f,
  -1.01673752e-01f, 8.63028108e-05f, -1.26212716e-01f, -3.48768570e-02f, -1.00518435e-01f, 1.12963738e-02f, -1.61021687e-02f, -1.26361817e-01f, -6.67453334e-02f, 1.57697368e-02f,
  1.86064214e-01f, -2.31992379e-02f, -1.27441734e-02f, 1.37219531e-02f, 1.18544519e-01f, -2.86328904e-02f, -7.87041858e-02f, 2.03884915e-02f, 4.65355627e-02f, 2.49103941e-02f,
  3.93157117e-02f, 2.36184988e-02f, -3.50197218e-02f, 1.26559973e-01f, -2.77962554e-02f, 6.97382689e-02f, 1.18390240e-01f, 2.75249816e-02f, 5.14438748e-02f, -2.41166260e-03f,
  1.00490294e-01f, 8.19178820e-02f, -2.12395377e-03f, -9.26206186e-02f, 4.69046198e-02f, -4.39837053e-02f, 8.75540525e-02f, -1.12675443e-01f, -4.54045981e-02f, 1.14468653e-02f,
  -1.41665833e-02f, 7.08274320e-02f, 5.62313981e-02f, 4.70998324e-02f, 6.04566745e-02f, 4.73626815e-02f, 9.23653948e-04f, 3.07345595e-02f, 4.20595519e-02f, -5.71057498e-02f,
  2.93139052e-02f, 4.13384512e-02f, -6.69798395e-03f, -9.53987539e-02f, 2.93262303e-02f, -9.56046358e-02f, 8.96698013e-02f, -2.65672877e-02f, -9.09354836e-02f, -2.95883920e-02f,
  2.21975997e-01f, 4.44965690e-01f, 5.52428067e-02f, 1.82234142e-02f, -4.72933892e-03f, 3.41972373e-02f, 8.46402496e-02f, 4.83534932e-02f, 8.39698166e-02f, 2.14349646e-02f,
  6.90788031e-03f, -6.93879873e-02f, 7.54099637e-02f, -1.12143150e-02f, -8.13037902e-02f, 3.07307635e-02f, -2.38979468e-03f, 1.43007725e-01f, 2.25585010e-02f, -3.67501937e-02f,
  1.82927810e-02f, 1.17207237e-01f, 1.50831956e-02f, 1.87881645e-02f, -2.64857151e-02f, 1.59676969e-02f, 1.25488400e-01f, 1.20407986e-02f, 3.45972478e-02f, 2.34082080e-02f,
  -1.73490103e-02f, 1.89344257e-01f, 3.15692842e-01f, 1.46400586e-01f, 1.58621743e-01f, 2.29739770e-01f, 1.59753844e-01f, 2.25907058e-01f, 6.55831754e-01f, 2.75315698e-02f,
  -2.33308196e-01f, 1.69936568e-01f, -1.82880491e-01f, 9.20839384e-02f, -1.20973364e-01f, -5.05451448e-02f, 1.85827777e-01f, 5.21308482e-02f, 2.00591281e-01f, -3.92585620e-02f,
  2.74934564e-02f, -2.62783110e-01f, -1.39262319e-01f, -1.88480854e-01f, -1.13081932e-01f, 2.75539029e-02f, -4.32422578e-01f, -2.01855674e-02f, -1.33115619e-01f, 8.02994892e-02f,
  -4.59274612e-02f, 8.45453292e-02f, -7.86412656e-02f, 5.39141409e-02f, 6.47125617e-02f, -2.91119013e-02f, -1.63221229e-02f, -8.56041536e-02f, -5.62034920e-03f, -6.42449036e-03f,
  -2.44002528e-02f, 3.76173705e-02f, 1.39496177e-01f, 1.51913129e-02f, 1.35910168e-01f, 3.14526483e-02f, 6.09288290e-02f, -8.49159155e-03f, 1.32836267e-01f, -8.18063226e-03f,
  -5.71565777e-02f, 2.50348058e-02f, 5.51218875e-02f, 2.23385189e-02f, 6.01292960e-02f, 1.11264527e-01f, 1.20068043e-01f, -1.14849005e-02f, -2.96268035e-02f, 6.04926459e-02f,
  -5.97416237e-02f, 7.62704462e-02f, -3.86706963e-02f, -7.80502334e-02f, -1.97036117e-02f, 3.68427783e-02f, -1.10880360e-01f, 1.01187099e-02f, 2.14962084e-02f, -5.24615869e-02f,
  3.75267342e-02f, -3.88399623e-02f, 6.32454753e-02f, -1.23335645e-02f, -1.16832312e-02f, 2.71918159e-02f, -4.36191857e-02f, 6.44421130e-02f, 2.57877428e-02f, -6.51299134e-02f,
  -1.53131615e-02f, 2.34095519e-03f, -1.11309864e-01f, -4.06081490e-02f, -2.01765336e-02f, -2.22638678e-02f, -3.41727063e-02f, 1.69617496e-02f, -6.90105036e-02f, -8.73485729e-02f,
  1.61064461e-01f, 3.63275766e-01f, -8.06537345e-02f, 3.06522660e-02f, 2.54522823e-02f, -8.33796114e-02f, -6.65606139e-03f, 1.04587547e-01f, 1.16090126e-01f, 5.25456220e-02f,
  2.15394236e-02f, 4.53343876e-02f, -8.27058852e-02f, -7.12516978e-02f, -1.95629634e-02f, 6.61653429e-02f, -8.77984613e-03f, 8.65516588e-02f, 5.27658947e-02f, -1.15679549e-02f,
  -9.67882872e-02f, -4.75209439e-03f, -5.36631681e-02f, 1.52459554e-02f, -3.13422978e-02f, -4.08246703e-02f, 3.70148942e-02f, 5.05959615e-02f, -6.67601824e-02f, 6.74146712e-02f,
  -2.01212421e-01f, -3.27392519e-01f, 3.78754795e-01f, -6.99504837e-02f, 2.23422479e-02f, 1.58070460e-01f, 5.36014795e-01f, -1.85810953e-01f, -1.19976193e-01f, -5.10026887e-02f,
  1.33165047e-01f, -2.35742226e-01f, 3.21993053e-01f, 1.50161296e-01f, 1.58834025e-01f, 2.59491026e-01f, 1.54334679e-01f, 1.88659832e-01f, -7.47979060e-02f, -1.73192367e-01f,
  1.76735967e-02f, -2.54085641e-02f, 2.96891272e-01f, -2.42528141e-01f, 1.37688249e-01f, -1.84253916e-01f, 2.85071181e-03f, 1.10202990e-01f, -1.09109648e-01f, 4.86040600e-02f,
  -7.84733444e-02f, -1.99007377e-01f, 8.96495488e-03f, -1.37897749e-02f, 6.26709089e-02f, 2.89658587e-02f, 4.84776907e-02f, 3.62440757e-02f, 1.41975107e-02f, 4.28585568e-03f,
  -4.02760878e-02f, -5.76292947e-02f, -5.31608947e-02f, 4.24158946e-02f, 1.79973599e-02f, -6.15805574e-02f, -3.49405222e-02f, 5.65071180e-02f, -4.43634912e-02f, 1.72859039e-02f,
  8.01241770e-02f, -2.31102109e-02f, 9.59634930e-02f, 6.91392645e-02f, 6.97224811e-02f, 4.36696038e-02f, 1.16108969e-01f, 1.03847027e-01f, -5.00270352e-02f, -7.77850673e-02f,
  -4.95823398e-02f, -4.68826368e-02f, -4.57883105e-02f, -7.45861307e-02f, -5.02850674e-02f, 5.18037565e-02f, -5.35672903e-03f, -3.44265923e-02f, -2.31767097e-03f, 9.01164338e-02f,
  -3.69510800e-02f, -2.87139770e-02f, 7.58098289e-02f, -2.22461261e-02f, 1.29626016e-03f, -8.81748926e-03f, 8.81310478e-02f, -7.46714249e-02f, 4.77617271e-02f, -2.07554754e-02f,
  -5.72120305e-03f, -8.80217645e-03f, 2.55724769e-02f, -4.26147990e-02f, -6.30249158e-02f, 3.48853543e-02f, 3.68752219e-02f, 8.60726535e-02f, 4.04609889e-02f, 4.07631882e-02f,
  -3.35089147e-01f, -4.22783703e-01f, -1.32651448e-01f, -4.54646051e-02f, -7.96178803e-02f, 9.88873187e-03f, -7.89636672e-02f, -7.14128986e-02f, -6.06988333e-02f, -6.51952019e-03f,
  2.80144829e-02f, 5.37506007e-02f, -1.62320614e-01f, 6.55280128e-02f, -7.68684372e-02f, 1.86285481e-03f, -1.04176328e-01f, -1.44617921e-02f, -1.31801898e-02f, -8.24349746e-02f,
  -4.26518321e-02f, -5.04113385e-04f, -4.52493392e-02f, -5.30387238e-02f, 5.09216730e-03f, -2.96611730e-02f, -1.66360140e-01f, -8.94791037e-02f, 1.08356690e-02f, -2.47866362e-02f,
  -5.10241091e-01f, 4.25518483e-01f, 3.45107079e-01f, -4.90311533e-01f, 3.84283870e-01f, 2.26146102e-01f, -1.82392776e-01f, 3.18976402e-01f, -1.07321657e-01f, -1.22648075e-01f,
  -9.17624980e-02f, -1.94140121e-01f, 8.28546360e-02f, -1.26225948e-01f, -1.44631132e-01f, 1.09568601e-02f, -1.68722972e-01f, -2.51920372e-01f, 1.81122303e-01f, -8.33729804e-02f,
  -6.52499199e-02f, -7.11891651e-02f, 1.05222546e-01f, 3.73614013e-01f, 1.45503774e-01f, 6.42709434e-02f, -2.38781810e-01f, 3.01907986e-01f, -2.24532764e-02f, 1.26237199e-01f,
  -8.84137452e-02f, -2.17567414e-01f, 3.01666167e-02f, -2.11452469e-02f, -3.67992707e-02f, -6.71732277e-02f, -1.18208654e-01f, -1.70467235e-02f, -1.36293480e-02f, 2.82708090e-02f,
  -1.85608137e-02f, 1.34635195e-01f, 7.73789873e-03f, 6.23480640e-02f, 6.81594461e-02f, 3.71086188e-02f, 1.18215695e-01f, 7.59014338e-02f, 8.72844756e-02f, 1.99810386e-01f,
  1.11250691e-01f, 3.13607715e-02f, -4.92128916e-03f, -4.00874354e-02f, -1.24600958e-02f, 5.34486584e-02f, -6.93809614e-02f, 2.15223432e-02f, -5.52451191e-03f, 2.43252888e-03f,
  -2.23235022e-02f, -4.48399410e-02f, 4.73580584e-02f, -7.80868484e-03f, 6.92297588e-04f, 4.17796290e-03f, -2.53249574e-02f, -4.88146916e-02f, -5.36754392e-02f, 3.14088464e-02f,
  1.37308147e-03f, -5.97347170e-02f, -2.99141034e-02f, -7.30019361e-02f, -8.00161809e-02f, -3.39749642e-02f, 1.03261936e-02f, -3.51573043e-02f, -3.49806156e-03f, -4.41609249e-02f,
  5.10686450e-03f, -2.81738620e-02f, 1.32723385e-03f, 6.74479036e-03f, 5.58287911e-02f, 5.00038452e-02f, 2.34041316e-03f, 7.32871667e-02f, -4.24166843e-02f, -4.99661267e-02f,
  -1.96501926e-01f, -3.51013213e-01f, 3.50457467e-02f, 4.99612354e-02f, -5.61268292e-02f, -2.09000912e-02f, 1.71991158e-02f, -1.83585379e-02f, -4.32527885e-02f, -5.52924583e-03f,
  -5.93795963e-02f, -1.24715112e-01f, -2.84141973e-02f, -6.07924983e-02f, -4.49325517e-02f, -3.38187329e-02f, -1.14852495e-01f, -7.81911835e-02f, -1.05215393e-01f, -2.19230726e-02f,
  -3.48844007e-02f, -2.31280979e-02f, -7.45551139e-02f, -2.00293381e-02f, -5.69132790e-02f, -5.17662466e-02f, -7.56926090e-02f, 2.87828445e-02f, -6.68726955e-03f, 1.35256555e-02f,
  -6.86603189e-02f, 4.14785683e-01f, 7.88574740e-02f, 2.26329446e-01f, -2.42972165e-01f, -2.20357552e-01f, -8.77847522e-02f, 1.04071617e-01f, 8.14675761e-04f, 1.85355857e-01f,
  3.11645001e-01f, 1.38009563e-01f, 1.86344787e-01f, 2.09074467e-01f, 1.51800796e-01f, 8.81887004e-02f, 2.95171171e-01f, -1.66141000e-02f, -4.28399369e-02f, 3.98303211e-01f,
  1.84227690e-01f, 2.49365851e-01f, 2.89626241e-01f, 1.98808506e-01f, 2.04907402e-01f, 1.84105307e-01f, 3.31076473e-01f, -3.52448523e-02f, 1.91369087e-01f, -1.16708472e-01f,
  -1.04285859e-01f, 1.74764857e-01f, -5.50541503e-04f, -1.09249324e-01f, 7.83016011e-02f, -3.56773846e-02f, -4.93628308e-02f, -1.33819863e-01f, 8.10229452e-04f, 5.92854507e-02f,
  -3.39031778e-02f, -6.85011372e-02f, 1.82562862e-02f, 3.11329942e-02f, -3.59731801e-02f, -4.13901219e-03f, -3.81176434e-02f, 2.40158495e-02f, 2.40393691e-02f, 6.01728354e-03f,
  4.34149727e-02f, 2.97324173e-02f, 6.03852198e-02f, -4.94729355e-02f, 2.51051299e-02f, -2.03189496e-02f, -4.59368378e-02f, 8.53918418e-02f, 1.09415809e-02f, 7.95485899e-02f,
  2.26361334e-01f, -8.28978121e-02f, -6.33864626e-02f, -6.80919886e-02f, 7.13802874e-02f, -1.60285980e-02f, 7.23861679e-02f, 3.27511802e-02f, -2.33099274e-02f, 6.55000955e-02f,
  1.23386811e-02f, 6.23925813e-02f, 2.13864334e-02f, 3.17258015e-02f, 6.60428777e-02f, 2.32451819e-02f, 3.11797718e-03f, 1.67271122e-02f, 1.75035521e-02f, -3.32241738e-03f,
  -3.67837623e-02f, 1.47301704e-02f, -7.89074786e-03f, -2.71088518e-02f, -9.41399857e-02f, 2.31789164e-02f, 1.43034756e-01f, 7.53039867e-02f, -5.35333976e-02f, 3.60200107e-02f,
  1.90027013e-01f, 6.12086177e-01f, 2.84042470e-02f, -1.30691230e-01f, -2.76466962e-02f, -3.25652957e-02f, -7.83162639e-02f, 7.36576766e-02f, 1.60789579e-01f, 9.80207622e-02f,
  6.03846312e-02f, 1.90762207e-02f, 1.93799455e-02f, -6.66160211e-02f, -4.46536541e-02f, 2.33562931e-01f, 8.41934457e-02f, -2.33753622e-02f, 2.70272116e-03f, 7.06047788e-02f,
  1.06650695e-01f, 2.83666551e-02f, 1.17159694e-01f, -5.64265773e-02f, -2.77184136e-02f, 7.92938769e-02f, -6.13701008e-02f, 5.47881983e-02f, 9.53409746e-02f, -3.15168388e-02f,
  -6.70704782e-01f, 2.55365610e-01f, -1.09453090e-01f, -1.19910382e-01f, -1.45044610e-01f, -4.84793149e-02f, 5.53020760e-02f, 4.84446473e-02f, -1.69581305e-02f, 5.08652270e-01f,
  3.07079703e-01f, -1.55111983e-01f, 3.01695675e-01f, 2.99876958e-01f, -2.69717306e-01f, 3.44990909e-01f, 2.79633701e-01f, 2.15782493e-01f, -5.18229045e-02f, -1.13642819e-01f,
  -7.75376484e-02f, 1.41225815e-01f, 6.45735860e-02f, 9.66503397e-02f, -8.75955522e-02f, -1.93670049e-01f, -6.78976327e-02f, -9.21372101e-02f, -6.16411902e-02f, -2.22159047e-02f,
  -1.77214697e-01f, -1.44878194e-01f, -6.76433817e-02f, -6.17873184e-02f, -6.06834032e-02f, -1.02819927e-01f, -1.16320431e-01f, 2.86806235e-03f, -1.14610851e-01f, -3.83980833e-02f,
  -8.96859989e-02f, -3.14929485e-02f, -6.19387776e-02f, -4.34162542e-02f, -4.16030064e-02f, 4.46238406e-02f, 1.99892633e-02f, 4.03637327e-02f, 2.06847433e-02f, -1.73377711e-02f,
  7.25812465e-02f, -7.38757011e-03f, 6.62295073e-02f, 1.32724820e-02f, -6.66689128e-02f, 3.14389840e-02f, 7.97357410e-03f, -8.81970301e-02f, -7.70121366e-02f, -2.03991961e-02f,
  5.02335317e-02f, 5.06192707e-02f, 3.63724818e-03f, 5.24154156e-02f, 1.78294312e-02f, -1.10611916e-02f, 5.72322123e-02f, 6.77488092e-03f, -3.19794342e-02f, 3.36894877e-02f,
  -3.52257714e-02f, -9.46006775e-02f, -5.30426875e-02f, -3.63230035e-02f, -1.78356543e-02f, -5.59733324e-02f, 1.22267772e-02f, 3.05651072e-02f, 2.81884074e-02f, -5.02840579e-02f,
  2.95310859e-02f, -6.31184056e-02f, 9.79743805e-03f, -4.33490286e-03f, -5.60368821e-02f, -1.51417116e-02f, -5.99030629e-02f, 5.85320499e-03f, 7.39929732e-03f, -1.03016190e-01f,
  -2.30174780e-01f, -2.30646610e-01f, -3.55728157e-02f, -4.69224826e-02f, -3.36941741e-02f, -6.07548580e-02f, -4.56896536e-02f, -5.83960153e-02f, -1.09740138e-01f, 2.25445833e-02f,
  -5.31926639e-02f, 5.04455008e-02f, -5.42874038e-02f, -2.71468051e-03f, 2.80120447e-02f, 2.11229362e-03f, -6.05658330e-02f, -6.03054836e-02f, -1.78820491e-02f, -3.43772247e-02f,
  4.11829203e-02f, -5.51809594e-02f, -3.84662598e-02f, 2.03423724e-02f, -2.00045668e-02f, 1.66218877e-02f, -6.41463548e-02f, -6.23141974e-03f, -6.20124787e-02f, -3.50154261e-03f,
  -7.30362236e-02f, 1.77388579e-01f, 9.23797935e-02f, 3.58068310e-02f, -2.81816255e-02f, -2.02847973e-01f, -2.46865705e-01f, -1.05918676e-01f, -1.41833425e-01f, 8.46339017e-02f,
  -8.68266448e-02f, 3.54860336e-01f, -2.58859634e-01f, -3.46193090e-02f, -3.02680820e-01f, -2.55677462e-01f, -1.43398687e-01f, 8.17870870e-02f, 1.12160733e-02f, -3.33546363e-02f,
  -1.40785977e-01f, -4.41073105e-02f, -8.81146863e-02f, -8.39005597e-03f, 1.36520207e-01f, 2.43710116e-01f, -2.37369277e-02f, 2.11097673e-02f, 1.99733168e-01f, 8.75219479e-02f,
  -4.51682508e-02f, -7.89288655e-02f, 9.41385627e-02f, 5.90411313e-02f, -8.40051696e-02f, 3.10417973e-02f, 9.07998905e-03f, -1.44960238e-02f, 2.68188515e-03f, -6.76064566e-02f,
  4.57680486e-02f, 7.44802356e-02f, 8.80829766e-02f, 3.18871788e-03f, 2.48836502e-02f, 3.28565277e-02f, 1.12075388e-01f, 5.55546843e-02f, 7.12004155e-02f, 7.69855306e-02f,
  3.10098799e-03f, 1.02500141e-01f, -4.50053178e-02f, 2.89214812e-02f, 2.62450185e-02f, -5.49733490e-02f, 1.11043409e-01f, 9.28818956e-02f, 5.53893410e-02f, 6.49996996e-02f,
  6.71074614e-02f, -7.88276568e-02f, -2.14546099e-02f, -4.29738723e-02f, -3.36732380e-02f, 6.88901842e-02f, -2.14486234e-02f, -1.84616316e-02f, 1.20442435e-02f, -8.53111893e-02f,
  -6.26311265e-03f, 5.96250333e-02f, -1.49680087e-02f, -9.22711939e-02f, 5.58994077e-02f, -3.38548832e-02f, -3.69869396e-02f, 2.33261418e-02f, -4.36743908e-02f, 3.87997627e-02f,
  -3.79297547e-02f, -9.05461088e-02f, 8.27229470e-02f, -1.24434242e-02f, -8.42134356e-02f, -4.88856435e-03f, 3.88290286e-02f, 3.30886059e-02f, -1.06960710e-03f, -5.12214042e-02f,
  -5.84815405e-02f, -2.16566890e-01f, -6.02621101e-02f, -1.45807731e-04f, -1.87398382e-02f, -1.00289565e-02f, 2.34566275e-02f, -1.00803683e-02f, -8.06533024e-02f, 1.41696259e-02f,
  -9.56589647e-04f, 2.65368782e-02f, 7.17573762e-02f, -9.62866656e-03f, 2.45445073e-02f, -1.53900549e-01f, -4.15629931e-02f, 4.70224246e-02f, 3.56406569e-02f, 1.59944862e-03f,
  7.28771612e-02f, -1.37464451e-02f, -9.11637172e-02f, -2.78797224e-02f, -3.23998965e-02f, -4.56258282e-02f, -2.38535902e-03f, 5.00580929e-02f, 7.12355822e-02f, 3.47444005e-02f,
  4.25215602e-01f, -3.47127199e-01f, -1.58978567e-01f, 3.16622287e-01f, 2.54274279e-01f, 4.91667986e-02f, -1.09698959e-01f, 1.54191017e-01f, -5.59189133e-02f, -2.65872270e-01f,
  2.03647390e-01f, -1.57950506e-01f, -3.96484584e-01f, 3.40022415e-01f, 4.13135707e-01f, -2.38930821e-01f, 3.91375870e-01f, 1.28167599e-01f, 3.03422771e-02f, 9.09780338e-02f,
  2.20429122e-01f, 5.34890354e-01f, 6.87989220e-02f, 2.92650431e-01f, 2.67889887e-01f, -6.54534921e-02f, 1.05223143e-02f, -1.33254930e-01f, 3.25683445e-01f, 1.36320934e-01f,
  1.24989830e-01f, 3.19009461e-02f, 8.77279192e-02f, -5.91070466e-02f, -8.79741739e-03f, -5.46916276e-02f, -1.39652491e-01f, 3.25068794e-02f, -1.33049870e-02f, -6.61417246e-02f,
  -1.53330550e-01f, -1.75960399e-02f, 1.18120402e-01f, -2.02321839e-02f, 4.58181910e-02f, 1.44100348e-02f, -9.79731884e-03f, 3.30604403e-03f, -1.10305309e-01f, -1.60413422e-02f,
  -1.00431219e-01f, -8.37645009e-02f, 9.03497711e-02f, -3.08372676e-02f, 1.56086786e-02f, -1.77452397e-02f, -2.62796879e-02f, -4.63846363e-02f, -5.46092615e-02f, 6.68770075e-02f,
  4.51758690e-02f, 3.34697664e-02f, -7.74743706e-02f, 5.54355234e-02f, 1.43569754e-02f, 8.74417275e-02f, -2.00701635e-02f, -3.06497496e-02f, -7.41407499e-02f, -2.08513811e-02f,
  -2.01973785e-02f, 3.16935219e-02f, 8.54205266e-02f, -1.33978613e-02f, 1.77855119e-02f, 5.17668836e-02f, -8.55852105e-03f, 5.50071336e-03f, 4.38753190e-03f, 7.09267333e-02f,
  -1.05882948e-02f, 9.81818885e-02f, -6.55279309e-02f, 2.55854875e-02f, -3.09028812e-02f, 3.24691050e-02f, 9.09218658e-03f, 4.71679717e-02f, -1.68905556e-02f, 1.83529444e-02f,
  -1.21232145e-01f, -1.90078259e-01f, -1.26644820e-01f, 4.47069034e-02f, -9.76889953e-02f, -3.95726087e-03f, -1.14728566e-02f, 9.81021151e-02f, -2.44803522e-02f, 4.97073568e-02f,
  4.98629659e-02f, -4.22951505e-02f, 3.01016811e-02f, 9.64141563e-02f, 7.18860561e-03f, 3.21749039e-02f, -5.66043369e-02f, -1.44660873e-02f, -1.04358355e-02f, 1.09613976e-02f,
  4.36979756e-02f, -8.80429819e-02f, -5.18842228e-02f, 3.57951410e-02f, 2.49547493e-02f, -6.71857446e-02f, -1.03102839e-02f, -4.00196202e-02f, 1.04251029e-02f, -1.00643523e-01f,
  2.64914930e-01f, -1.92319050e-01f, -5.85752964e-01f, -3.12739849e-01f, 3.38524491e-01f, 4.07353878e-01f, 9.14094150e-02f, 1.67796649e-02f, -4.38485116e-01f, 3.16818655e-01f,
  2.86566943e-01f, -2.42918983e-01f, -2.30992287e-01f, -1.11082504e-02f, -7.51358196e-02f, -2.58365273e-01f, 1.41251996e-01f, 1.57327607e-01f, -2.18868196e-01f, 1.14905633e-01f,
  -7.33625740e-02f, 2.95595109e-01f, -4.25987899e-01f, 2.77296454e-01f, 2.08589107e-01f, -1.09519117e-01f, 2.33899310e-01f, -5.82568832e-02f, 2.20478281e-01f, 1.14440031e-01f,
  -8.68444294e-02f, -1.58579215e-01f, -1.27878174e-01f, -1.15593538e-01f, 1.70883328e-01f, 1.69217676e-01f, 2.01966129e-02f, -5.21419942e-02f, -9.94031429e-02f, -6.80635199e-02f,
  -5.21616153e-02f, -4.96605178e-03f, -4.68324684e-02f, -4.02097963e-02f, 8.20258036e-02f, -9.40275937e-02f, -6.12554625e-02f, -6.73701540e-02f, -1.56086594e-01f, -4.01056744e-02f,
  -1.47453532e-01f, -6.36358410e-02f, 6.39305487e-02f, -8.30229819e-02f, -1.49943143e-01f, -2.00766791e-02f, 6.34201430e-03f, -4.52606454e-02f, 1.00665428e-01f, 4.95998859e-02f,
  1.13378435e-01f, 6.73485249e-02f, 6.77883476e-02f, -2.15018652e-02f, -1.58565686e-04f, -1.64496694e-02f, -5.17836809e-02f, 9.23130289e-03f, -8.13781992e-02f, 7.93593973e-02f,
  -2.04791725e-02f, -5.73173501e-02f, -3.02326288e-02f, 2.78323703e-02f, 2.03486811e-02f, -1.27425604e-02f, 4.09713760e-02f, 3.70811671e-02f, -8.40765238e-02f, -9.76932347e-02f,
  -1.20872207e-01f, 3.95277664e-02f, 6.48877099e-02f, 1.34129520e-03f, -3.22620682e-02f, -5.14465831e-02f, 4.08075638e-02f, -7.49790017e-03f, -3.27325277e-02f, 6.07960224e-02f,
  3.70954312e-02f, 1.53285727e-01f, -9.52455029e-02f, -3.50951105e-02f, -6.20665811e-02f, 1.19648740e-01f, -2.63589676e-02f, -1.98167302e-02f, -1.56317800e-02f, 7.49958009e-02f,
  1.56267673e-01f, -9.92563646e-03f, 1.25589237e-01f, 5.57924807e-03f, -6.56740144e-02f, 9.24323648e-02f, 1.56044820e-02f, -3.20230126e-02f, 1.25493631e-01f, 6.27516359e-02f,
  1.21407881e-01f, 1.27592593e-01f, -5.20474128e-02f, 3.87446359e-02f, 1.02698304e-01f, 5.01566865e-02f, 4.87737507e-02f, -5.22987135e-02f, 4.33607250e-02f, -9.06414241e-02f,
  -2.56362200e-01f, 1.98218375e-01f, -4.29174900e-02f, -1.37607187e-01f, 8.75619352e-02f, 3.55600268e-02f, -9.21687558e-02f, 6.30306229e-02f, -1.52835861e-01f, 2.97007084e-01f,
  5.86981997e-02f, 3.25122662e-02f, 8.18636119e-02f, -3.03136915e-01f, -7.57706046e-01f, -4.00408775e-01f, -2.66990662e-01f, -8.86952728e-02f, -2.45157614e-01f, 3.25578339e-02f,
  -2.35915110e-01f, -1.61948100e-01f, -1.80032730e-01f, 1.30161405e-01f, 1.20642498e-01f, 2.55666345e-01f, 1.22890256e-01f, 2.21449539e-01f, 2.44924594e-02f, -1.46071643e-01f,
  -1.97028182e-02f, -3.03583555e-02f, 7.17529580e-02f, 9.43941101e-02f, 9.03367698e-02f, 1.22227788e-01f, 9.18742493e-02f, -1.01859704e-01f, 1.95275014e-03f, -6.75172433e-02f,
  9.57448110e-02f, 1.35851381e-02f, -2.17161104e-02f, 2.66951835e-03f, -8.48440081e-03f, -4.51601222e-02f, 7.96786472e-02f, 6.02227785e-02f, 5.33514135e-02f, -5.46764210e-02f,
  -7.16019571e-02f, 6.49581626e-02f, 2.28711534e-02f, 6.25738651e-02f, 1.60925053e-02f, -1.56766009e-02f, -7.17061460e-02f, 6.19207183e-03f, -1.10935643e-02f, -7.85109401e-02f,
  -3.73824276e-02f, 1.83931477e-02f, -4.99603264e-02f, -1.13318544e-02f, -2.83495151e-02f, 1.01854615e-02f, 5.63704371e-02f, -5.13749160e-02f, 1.02508143e-02f, 6.23308495e-02f,
  -2.39794869e-02f, 3.64442579e-02f, 5.73881269e-02f, 1.90071203e-02f, -7.02266395e-02f, -1.27956585e-03f, -4.24177535e-02f, -1.92941036e-02f, -6.33455291e-02f, 2.41129920e-02f,
  -4.25859056e-02f, -3.23129329e-03f, -2.29890943e-02f, 7.33240321e-02f, -2.08218712e-02f, 1.89805590e-02f, -1.40794395e-02f, -2.90708635e-02f, -1.07858777e-02f, -1.63172595e-02f,
  2.66657881e-02f, 1.11685768e-01f, 3.61500457e-02f, 7.06883743e-02f, -1.13976130e-03f, 6.09211363e-02f, -1.08742118e-01f, -6.31821826e-02f, -8.70733336e-02f, 3.76932137e-02f,
  1.31528378e-01f, -9.34491679e-03f, 9.92853865e-02f, 1.93060338e-02f, 1.40578505e-02f, 5.40317558e-02f, 5.73486388e-02f, 8.65887329e-02f, 1.04105294e-01f, 4.87004817e-02f,
  5.60432486e-02f, 6.94880560e-02f, 8.12895503e-03f, 2.26430222e-02f, 1.04590198e-02f, 1.28765345e-01f, 1.68517753e-02f, -1.36199323e-02f, 5.34719005e-02f, 2.49244682e-02f,
  -1.25905324e-03f, 1.02491312e-01f, 4.25787605e-02f, -1.36943743e-01f, -6.62274510e-02f, 2.08902210e-01f, 7.28386343e-02f, 1.46334395e-01f, 6.89339489e-02f, -3.34370770e-02f,
  4.60320078e-02f, -1.64685071e-01f, 1.22629330e-02f, 4.42559421e-02f, 6.58953488e-02f, 2.44636580e-01f, 1.30758449e-01f, -1.71202570e-02f, 5.80846183e-02f, -1.33434743e-01f,
  6.55653849e-02f, -1.16510049e-01f, -7.59268776e-02f, -1.51107803e-01f, -9.86656472e-02f, -2.64425930e-02f, -2.13632032e-01f, -5.95889091e-02f, -1.43015161e-01f, 5.91212884e-03f,
  1.52064711e-01f, -1.70859229e-02f, 1.67727377e-02f, 8.40670839e-02f, 5.62415794e-02f, -3.50677110e-02f, 3.87022905e-02f, -1.49104251e-02f, -8.54613855e-02f, 9.07921791e-02f,
  -1.09131381e-01f, -1.20271146e-01f, -6.85044378e-03f, -1.07684478e-01f, -8.94512385e-02f, -1.04797505e-01f, 3.94526199e-02f, -1.19565744e-02f, -1.51659861e-01f, 1.52544016e-02f,
  -5.83187304e-02f, 9.87889320e-02f, -1.03170767e-01f, 2.35548895e-02f, -3.58211659e-02f, 1.21714605e-03f, -1.25742368e-02f, -7.75978668e-04f, 3.48298363e-02f, -2.78227348e-02f,
  5.15665412e-02f, 1.37709364e-01f, 1.09999530e-01f, 1.91671681e-02f, 2.31523328e-02f, 1.57759208e-02f, 1.42217483e-02f, -3.39873470e-02f, -3.32478248e-02f, 3.17930542e-02f,
  5.60581833e-02f, -8.58855322e-02f, 5.82678393e-02f, -1.73605271e-02f, 8.26021954e-02f, -8.30350891e-02f, -2.81469356e-02f, 1.02452738e-02f, 2.39553992e-02f, 5.36880456e-02f,
  -3.97429056e-02f, -2.49175280e-02f, 3.59553620e-02f, 4.24957043e-03f, -8.94417316e-02f, 1.25269908e-02f, 1.14739891e-02f, 4.83180322e-02f, 4.14358228e-02f, -2.43057888e-02f,
  1.30687177e-01f, 9.14068297e-02f, -3.15589504e-03f, 2.53956346e-03f, 8.47971365e-02f, -2.80292402e-03f, 1.05494842e-01f, -1.06897401e-02f, 1.12011686e-01f, 9.33193490e-02f,
  -8.52166414e-02f, -1.97245646e-02f, 9.58358720e-02f, 3.80484052e-02f, 9.47491545e-03f, 1.07156849e-02f, -5.28009869e-02f, -6.97267652e-02f, 5.27600199e-02f, -2.59550307e-02f,
  -4.13253009e-02f, -1.31456936e-02f, -8.42080787e-02f, 3.13449837e-02f, -1.12559482e-01f, -8.31587538e-02f, 5.34765720e-02f, 3.74225713e-02f, 8.98695961e-02f, 1.44157354e-02f,
  2.07364082e-01f, -2.22811610e-01f, 1.08258791e-01f, 3.35222363e-01f, 1.22584358e-01f, -2.80561477e-01f, -1.66614294e-01f, 8.68070722e-02f, 1.38776392e-01f, -1.44008726e-01f,
  -1.59426838e-01f, 4.00849544e-02f, -4.22569245e-01f, -5.10668606e-02f, -1.30372077e-01f, -2.51326799e-01f, 1.16062080e-02f, -8.23056209e-04f, 6.42490685e-02f, -3.46738584e-02f,
  2.70917386e-01f, -1.03099540e-01f, 9.09824073e-02f, 7.96059743e-02f, 1.76834852e-01f, 3.02070677e-01f, 6.24766722e-02f, -1.86199918e-01f, 1.70883864e-01f, -6.80046529e-02f,
  -7.14704990e-02f, 2.38666441e-02f, 3.51031311e-02f, -4.74704755e-03f, -1.21821575e-02f, 6.84026703e-02f, -4.03091423e-02f, -1.07049659e-01f, 1.15230210e-01f, 1.29992962e-02f,
  -5.24681062e-02f, 1.94080006e-02f, 9.68392640e-02f, -6.25758544e-02f, 7.14182705e-02f, 8.15702975e-02f, 6.19103983e-02f, 6.99705184e-02f, 1.37673109e-03f, -2.64521898e-03f,
  2.53841653e-02f, 4.42174152e-02f, 8.41199383e-02f, 9.04977024e-02f, -9.69736557e-03f, 9.02849734e-02f, 6.02357760e-02f, 7.68301710e-02f, -1.27683934e-02f, 9.02793556e-03f,
  7.62602240e-02f, 5.96639216e-02f, -2.36215796e-02f, 1.29978023e-02f, -5.66241704e-02f, 1.49116525e-02f, -3.08899209e-02f, -4.75130305e-02f, 9.77088697e-03f, -5.14618047e-02f,
  6.74641505e-02f, -2.48935167e-02f, -3.80634889e-03f, 8.96258163e-04f, -7.03081675e-03f, 5.90256788e-02f, 9.44436062e-03f, 5.25016189e-02f, 6.98728114e-02f, 6.67456612e-02f,
  -9.96592715e-02f, -3.55773326e-03f, -4.60297205e-02f, -6.42166957e-02f, -4.31878194e-02f, -8.46097022e-02f, 3.40132130e-04f, -1.01493299e-02f, 5.44526242e-02f, 3.00713293e-02f,
  -2.26937547e-01f, -1.52935833e-01f, 4.20767814e-03f, -2.18834840e-02f, -1.80098191e-02f, -1.04308119e-02f, -1.97445005e-02f, 2.66324785e-02f, -9.58530605e-03f, 2.38218326e-02f,
  8.63493085e-02f, 4.45693992e-02f, -5.62368780e-02f, 2.75720041e-02f, 3.62007283e-02f, -6.15688488e-02f, -4.97680195e-02f, 8.43475834e-02f, 3.29073370e-02f, -4.06122617e-02f,
  1.19639756e-02f, 1.63601376e-02f, 4.27461118e-02f, 7.92849734e-02f, 1.16317347e-01f, 5.54076508e-02f, -3.78465913e-02f, 6.33430704e-02f, 2.05578469e-02f, -6.69495314e-02f,
  -1.93731189e-01f, 1.92544892e-01f, 1.71356305e-01f, -1.62668139e-01f, -5.32117225e-02f, 1.22662343e-01f, 2.18482912e-01f, -1.20646261e-01f, -2.84221500e-01f, 1.74748972e-01f,
  8.35549906e-02f, 6.21873885e-02f, 1.93430305e-01f, 9.88350958e-02f, -1.86602920e-01f, 2.25749575e-02f, -7.38228112e-02f, 1.69458359e-01f, -7.57637322e-02f, -1.69470370e-01f,
  -1.38115600e-01f, -4.51146513e-02f, 4.55922522e-02f, -8.03012252e-02f, 5.93920052e-02f, -4.97319251e-02f, 3.99542712e-02f, 8.57271329e-02f, 1.40850112e-01f, -2.51047350e-02f,
  -1.11848682e-01f, -9.62580964e-02f, -2.51532402e-02f, 6.31234720e-02f, 5.64049073e-02f, 1.29800094e-02f, 1.37847945e-01f, -2.47252230e-02f, -2.44573038e-02f, -4.93264431e-03f,
  4.26660813e-02f, -8.13015029e-02f, -1.21891849e-01f, -1.02484442e-01f, 2.01884303e-02f, -9.35449675e-02f, 4.88593103e-03f, 6.80619702e-02f, -6.59183413e-02f, 4.07489426e-02f,
  6.56260028e-02f, 8.04386884e-02f, 1.13213390e-01f, -2.14220528e-02f, -1.05797229e-02f, 4.17709872e-02f, -5.51947691e-02f, 1.30644575e-01f, -1.58946030e-02f, -7.39829987e-02f,
  1.89522319e-02f, -5.85826710e-02f, 5.12996465e-02f, -2.58298479e-02f, 5.25695737e-03f, 5.00736497e-02f, -3.47944051e-02f, 4.74935099e-02f, 1.27751557e-02f, 7.11948471e-03f,
  3.26742530e-02f, 8.47296417e-02f, 5.68308821e-03f, -2.50776224e-02f, 5.22678941e-02f, -2.29152832e-02f, 5.05536571e-02f, 3.71791087e-02f, 2.59678196e-02f, 2.63533834e-02f,
  7.96350464e-03f, 2.78159175e-02f, -4.45294939e-02f, 7.51459152e-02f, 2.75016986e-02f, 8.69871210e-03f, 3.75805050e-02f, 3.43607552e-02f, 1.06433770e-02f, 3.26048844e-02f,
  -1.55217156e-01f, -2.53832847e-01f, -5.70603274e-02f, 6.22820929e-02f, -4.35393117e-02f, -2.03775615e-02f, 7.90678710e-03f, -5.73849156e-02f, -1.13997415e-01f, -2.47962084e-02f,
  -4.55792062e-02f, 6.14435188e-02f, -3.25968973e-02f, 3.15014762e-03f, -7.06248730e-02f, 9.65682906e-04f, -1.22392774e-02f, 1.79738030e-02f, -5.84713854e-02f, -6.57498837e-02f,
  -1.69717334e-02f, -8.17389973e-03f, -9.63285752e-03f, -9.27057955e-03f, 1.10224197e-02f, 3.22542377e-02f, -1.09456189e-01f, -1.76650491e-02f, -2.79872548e-02f, -7.19025405e-03f,
  -1.81135878e-01f, -2.12723343e-03f, 9.55914259e-02f, -8.42482075e-02f, 2.58204877e-01f, 2.19501778e-01f, 2.38200240e-02f, 2.86612093e-01f, 7.52785727e-02f, -1.87912554e-01f,
  -4.75930274e-02f, -2.91090101e-01f, -1.88604578e-01f, -4.20621261e-02f, -1.45546928e-01f, -1.54338658e-01f, -1.88561715e-02f, -2.02646732e-01f, 1.25716597e-01f, -1.85018964e-02f,
  6.86708093e-02f, -6.82406276e-02f, 8.53795260e-02f, 1.28358632e-01f, 5.20447418e-02f, 6.38404265e-02f, -9.75665972e-02f, 3.74988765e-02f, -2.01870222e-02f, -1.06172457e-01f,
  -5.37260436e-03f, -1.19794622e-01f, 3.49657610e-02f, 5.60576431e-02f, 4.22845110e-02f, 2.39823330e-02f, -1.12508954e-02f, -2.00268701e-02f, 4.85913409e-03f, 1.43420845e-02f,
  -1.41949505e-01f, 5.91700263e-02f, 4.59873751e-02f, 7.86196813e-02f, 3.91110107e-02f, 5.65766692e-02f, 4.98321205e-02f, 1.03314959e-01f, -5.25689870e-02f, 9.26121101e-02f,
  5.82481474e-02f, 1.51118204e-01f, -1.06994333e-02f, -8.79713967e-02f, -1.14018684e-02f, -2.28630193e-02f, 7.50909969e-02f, -8.42476934e-02f, 7.26226941e-02f, 3.76085080e-02f,
  -2.41860598e-02f, -4.59064506e-02f, -6.05950058e-02f, -2.89960764e-02f, -2.54721679e-02f, 6.57200143e-02f, 9.77224763e-03f, -5.76157263e-03f, 2.21401602e-02f, -6.96205720e-02f,
  -1.23961270e-02f, 5.34015633e-02f, -2.17525591e-03f, 1.39928102e-01f, -4.08557393e-02f, -2.30285712e-02f, -6.60236031e-02f, 3.69010083e-02f, 6.62948266e-02f, 4.33857106e-02f,
  -1.75941233e-02f, 6.43529296e-02f, -2.07035225e-02f, -2.25742236e-02f, 5.75017631e-02f, 5.57714105e-02f, 9.23856795e-02f, -2.52864398e-02f, 1.49182370e-02f, -2.22170483e-02f,
  -7.77374282e-02f, -1.77158117e-01f, -5.88013195e-02f, -1.69637788e-03f, -9.68013331e-02f, -3.31292115e-02f, 1.14212846e-02f, 5.29687628e-02f, -5.63757904e-02f, -4.90397997e-02f,
  2.62490865e-02f, -5.64276874e-02f, 3.20138000e-02f, 5.29298782e-02f, -6.40331283e-02f, -2.34032311e-02f, -5.05414717e-02f, -1.32237449e-01f, 8.03823303e-03f, -4.08713035e-02f,
  -2.10335143e-02f, -8.35911836e-03f, 9.69714019e-03f, 7.16037154e-02f, 2.90831793e-02f, -4.24055085e-02f, -2.02095024e-02f, -4.66026440e-02f, 2.89238952e-02f, -1.10296281e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 26)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 26;
const float L0_fan_Bp_bar_data[] = {
  2.42488787e-01f, 1.44846663e-01f, 2.15416253e-01f, 1.70355529e-01f, 1.38712049e-01f, 4.16982234e-01f, 3.74895811e-01f, 2.95870900e-01f, 4.12087739e-02f, 1.81935951e-01f,
  1.89599931e-01f, 3.98044318e-01f, 2.78864980e-01f, 3.58374536e-01f, 2.55393296e-01f, 3.05278122e-01f, 2.76218027e-01f, 1.92530692e-01f, 2.69294143e-01f, 2.65158981e-01f,
  4.58323419e-01f, 3.47740978e-01f, 1.88315660e-01f, 3.74292403e-01f, 3.27081472e-01f, 1.58632249e-01f
};

// L1_linear_W (Shape: 12 x 32)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 32;
const float L1_linear_W_data[] = {
  -4.13235366e-01f, 1.31767755e-03f, -8.58377144e-02f, 6.80407405e-01f, 2.83552974e-01f, -5.38102508e-01f, -3.62265036e-02f, -2.64256656e-01f, -5.51736057e-02f, -1.36939940e-04f,
  -1.97904631e-01f, -4.00567859e-01f, 4.01496738e-01f, 4.04551238e-01f, 2.96841383e-01f, -3.13668758e-01f, -1.37447387e-01f, -4.71333742e-01f, -9.11171734e-02f, -3.19772005e-01f,
  6.14658237e-01f, -4.80521917e-01f, 1.23567767e-01f, 1.03252196e+00f, -1.31188095e-01f, -2.71477044e-01f, -1.78265169e-01f, -1.86163448e-02f, 2.92211682e-01f, -1.22058116e-01f,
  4.26513702e-01f, -1.59513786e-01f, -4.07188237e-02f, 5.80496907e-01f, -5.98225474e-01f, 3.12766165e-01f, 7.94063434e-02f, -6.47160411e-01f, 1.34510458e-01f, -1.90797821e-01f,
  3.59474510e-01f, -8.46874341e-02f, -3.65549624e-01f, -3.08178991e-01f, -1.99358404e-01f, -2.62725323e-01f, 2.49141335e-01f, 2.62135249e-02f, -2.35007897e-01f, -4.92958605e-01f,
  5.86550653e-01f, -2.46574059e-02f, -1.71935812e-01f, -1.67466059e-01f, 3.24302286e-01f, 3.51748019e-02f, -2.82674015e-01f, 5.96415699e-01f, 1.04649699e+00f, -2.81192958e-01f,
  1.15695231e-01f, -4.01094824e-01f, -1.16250373e-01f, -1.89148515e-01f, 5.25869094e-02f, -5.13085485e-01f, -3.50598276e-01f, 1.60490826e-01f, -5.97513080e-01f, -3.76928419e-01f,
  -2.20359936e-01f, 7.03624725e-01f, 7.49362633e-02f, -1.66543528e-01f, -7.76595101e-02f, -3.71488661e-01f, -9.89557877e-02f, -2.66501009e-01f, 1.46410272e-01f, -8.33195746e-02f,
  -5.91865405e-02f, 1.87263712e-01f, -1.33273602e-01f, -3.06657523e-01f, -1.52105317e-01f, -7.87818655e-02f, -5.38147867e-01f, -5.37567921e-02f, 1.52849868e-01f, 9.81796980e-01f,
  1.53648943e-01f, -2.20891744e-01f, -2.72711784e-01f, 4.62957919e-01f, -3.16563398e-01f, 1.16132833e-01f, -8.85744579e-03f, -1.23082757e-01f, -6.30839467e-01f, -3.89871150e-01f,
  3.39409083e-01f, 4.66611087e-01f, 3.24164122e-01f, -6.04235604e-02f, -8.23824182e-02f, 9.33309972e-01f, 7.81865939e-02f, -3.43671918e-01f, -4.18362826e-01f, 5.08251667e-01f,
  -3.99521589e-02f, -3.82882893e-01f, -2.63250060e-02f, -1.45396501e-01f, 4.60728779e-02f, -2.61948295e-02f, -2.59333074e-01f, 5.18614233e-01f, -8.73837397e-02f, 3.30250949e-01f,
  1.18958160e-01f, -3.30618769e-01f, -2.65678078e-01f, 4.86035526e-01f, -2.25553483e-01f, -3.14494282e-01f, 6.20497242e-02f, -3.00835203e-02f, -8.23369995e-03f, 2.75068372e-01f,
  6.05170488e-01f, 2.69339174e-01f, 3.89224827e-01f, 7.93852568e-01f, 1.53623715e-01f, 4.58881147e-02f, -5.21423161e-01f, -5.41830659e-01f, 1.70622155e-01f, -3.08944762e-01f,
  2.32780814e-01f, 1.84277430e-01f, 9.81400087e-02f, 2.90500879e-01f, -8.39299932e-02f, 1.33136973e-01f, -3.35266411e-01f, 3.32720965e-01f, 3.85445297e-01f, 1.06884944e+00f,
  -2.25121021e-01f, 2.65821755e-01f, -2.07662314e-01f, -8.88821110e-02f, -2.39667013e-01f, -5.58043383e-02f, 4.28111374e-01f, -3.25853378e-01f, 1.99958608e-01f, 5.39115667e-01f,
  3.34128290e-01f, -7.38810226e-02f, 4.51342165e-01f, 5.81249483e-02f, 3.57570201e-01f, -6.52318835e-01f, -1.08143814e-01f, -2.94034839e-01f, 1.05742142e-01f, -2.63374567e-01f,
  -1.10917762e-02f, 2.87284911e-01f, 6.06304109e-01f, 5.51542819e-01f, 3.40431929e-02f, 6.60560504e-02f, 5.49937896e-02f, -2.59508938e-01f, 7.12014556e-01f, 9.43598449e-01f,
  -3.55214030e-01f, -4.27878231e-01f, 1.22636616e-01f, -6.06199056e-02f, -2.38559425e-01f, -3.44713509e-01f, -1.95791915e-01f, -2.51768529e-01f, 3.39528412e-01f, -2.92791963e-01f,
  -3.63017648e-01f, -1.01956367e-01f, -1.75596640e-01f, 1.91980749e-01f, 1.38486326e-01f, -5.50289571e-01f, -2.51668751e-01f, 1.04880832e-01f, -3.23342592e-01f, -1.28820002e-01f,
  8.79859746e-01f, -2.17489228e-01f, 1.20829307e-01f, 7.72079289e-01f, -1.49591669e-01f, -1.94703788e-01f, -6.94628805e-02f, -1.87126808e-02f, 6.61014393e-02f, 3.18913221e-01f,
  -3.03275466e-01f, 2.68361568e-01f, 1.85755938e-01f, 8.04739818e-03f, -4.86344397e-01f, -3.56083214e-01f, -5.36532581e-01f, 3.76573026e-01f, -2.53807694e-01f, -2.44689211e-01f,
  1.11718632e-01f, 4.51292485e-01f, -3.63345325e-01f, 4.16046858e-01f, -1.19812712e-01f, -3.48605901e-01f, 5.05776592e-02f, -1.84356198e-01f, 3.11413854e-02f, 3.37719053e-01f,
  9.40322161e-01f, -4.96242791e-02f, -1.12402216e-01f, 3.74161124e-01f, 3.90769452e-01f, -2.56307304e-01f, 1.04836725e-01f, -1.08560666e-01f, 1.63001254e-01f, 7.96333671e-01f,
  -2.67737955e-01f, -1.78792194e-01f, -1.41060978e-01f, -2.74387419e-01f, -2.63330042e-01f, -3.30945402e-01f, -2.53971130e-01f, -1.86417207e-01f, 9.15722772e-02f, -2.79861569e-01f,
  -2.47614026e-01f, -2.78459758e-01f, 1.74773619e-01f, 2.38951206e-01f, -1.12862915e-01f, -1.45841077e-01f, -1.70446575e-01f, -4.88485962e-01f, 2.56558686e-01f, 8.68386254e-02f,
  -4.13029939e-01f, 2.29827344e-01f, -8.40860754e-02f, 3.00155908e-01f, -2.70169526e-01f, -3.75574417e-02f, 4.30890173e-01f, -1.59552217e-01f, -2.65598178e-01f, -7.00684339e-02f,
  3.89401048e-01f, -1.50530338e-01f, 3.10155153e-01f, -2.91156322e-01f, 2.66142748e-02f, -3.11953932e-01f, -2.28673235e-01f, -1.09694742e-01f, 1.06725919e+00f, -1.43782645e-01f,
  -1.15363821e-01f, 2.25917190e-01f, -4.62545574e-01f, -2.22500131e-01f, -2.29838509e-02f, 3.04176718e-01f, -2.86071122e-01f, -1.67024925e-01f, 2.07999945e-01f, 2.95364976e-01f,
  3.13660085e-01f, -5.73961079e-01f, 1.24039233e-01f, -5.03040135e-01f, 1.84517935e-01f, -2.22728312e-01f, -2.01390132e-01f, -2.72834450e-01f, -6.33697882e-02f, -1.51611626e-01f,
  4.24508959e-01f, 6.99927956e-02f, -3.25834081e-02f, 2.08224747e-02f, -1.94734454e-01f, 1.16793156e+00f, -3.83262157e-01f, -3.87397200e-01f, 8.17814469e-01f, -3.30578893e-01f,
  -2.71694273e-01f, -3.75807256e-01f, -1.34207800e-01f, -1.06633596e-01f, -1.70676053e-01f, -1.36049882e-01f, -2.29016040e-02f, -2.92671680e-01f, 2.84819454e-01f, -3.18748385e-01f,
  3.44408303e-01f, 1.60460845e-01f, 2.74794102e-01f, 1.47318631e-01f, -1.93620294e-01f, 5.78573346e-01f, -5.28889969e-02f, 3.23234260e-01f, -2.99855888e-01f, 2.93372069e-02f,
  -1.98423445e-01f, -2.87958533e-01f, -3.44252348e-01f, -2.50894696e-01f, -3.64948511e-01f, -3.63926351e-01f, 5.28714597e-01f, -2.94521123e-01f, 1.88355580e-01f, -1.43139556e-01f,
  -3.10636908e-01f, -8.79278854e-02f, -3.05536352e-02f, -2.82050699e-01f, 1.39576597e-02f, -4.56854194e-01f, 9.02700186e-01f, 9.47190881e-01f, -1.22726737e-02f, 1.48589164e-01f,
  1.18597075e-01f, 1.17208026e-01f, 5.49306497e-02f, 9.78351980e-02f, 5.24861477e-02f, -3.39573264e-01f, 1.93220571e-01f, 5.08723497e-01f, -2.62256384e-01f, -3.21257859e-01f,
  -4.42779571e-01f, -9.59912688e-02f, -2.42565572e-01f, 1.25682068e+00f, -1.74260736e-01f, -4.86210249e-02f, 7.16540888e-02f, -2.11256207e-03f, -6.09815568e-02f, -1.42170936e-01f,
  2.06097275e-01f, 2.73248017e-01f, -3.53216082e-01f, -8.28539059e-02f, -1.16622657e-01f, -2.54873991e-01f, 5.90658009e-01f, -2.53060341e-01f, -3.74453098e-01f, 3.85770231e-01f,
  -1.18754975e-01f, 3.68340015e-01f, 2.81048477e-01f, -2.19940543e-02f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  8.40709917e-03f, -1.39878197e-02f, -8.45952109e-02f, -3.22185270e-02f, 1.75232798e-01f, 3.05009931e-01f, -1.21049076e-01f, -1.43599465e-01f, -1.67628467e-01f, 4.93075466e-03f,
  -1.20089009e-01f, -1.99038923e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 3, 26
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        32, 12
    );
    }
    