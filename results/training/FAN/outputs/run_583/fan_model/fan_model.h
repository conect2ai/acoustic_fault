/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 4 x 120)
const int L0_fan_Wp_rows = 4;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -7.64621735e-01f, 2.94431508e-01f, -4.66857627e-02f, 1.51214764e-01f, 4.81495827e-01f, 3.39079112e-01f, 3.45896751e-01f, 1.32401334e-02f, 8.60312581e-02f, 1.37281999e-01f,
  2.18071863e-01f, -2.15094075e-01f, -3.30695152e-01f, -1.99686840e-01f, -2.32111618e-01f, 1.42379880e-01f, 8.33973885e-02f, -4.99528557e-01f, -3.50911200e-01f, 1.00411497e-01f,
  1.93065986e-01f, 6.15039170e-02f, -1.03506424e-01f, -1.85912535e-01f, 1.43723637e-01f, 1.91001687e-02f, 2.77924865e-01f, 2.17104837e-01f, 9.48659256e-02f, -3.06013703e-01f,
  -2.70923585e-01f, -1.76838100e-01f, -3.38102854e-03f, 2.55820006e-02f, 9.02290791e-02f, -1.45285189e-01f, 6.12416118e-02f, -1.83113925e-02f, -4.67473008e-02f, -6.49893954e-02f,
  1.31464552e-03f, -9.31041464e-02f, -8.71901736e-02f, -7.33047398e-03f, 5.03536947e-02f, 1.15493620e-02f, -8.52053463e-02f, -2.23532736e-01f, -5.41004241e-02f, 7.10779056e-02f,
  2.87000835e-02f, 2.31822580e-02f, 1.25388324e-01f, 9.95954350e-02f, -1.63176917e-02f, -6.31724447e-02f, 1.17035374e-01f, -9.93973091e-02f, -1.04950547e-01f, 7.89841563e-02f,
  -1.40767038e-01f, 5.90866618e-02f, 1.05394371e-01f, 5.58045693e-02f, 6.95230886e-02f, 1.61840320e-02f, -3.37577574e-02f, 1.02574453e-01f, -9.01058391e-02f, 6.74758404e-02f,
  -1.65189747e-02f, 8.98859347e-04f, -2.36472487e-02f, 6.79604039e-02f, 1.81263387e-02f, 6.40322343e-02f, -8.36011767e-02f, 2.30885465e-02f, 2.01661531e-02f, 2.50144415e-02f,
  -2.79852413e-02f, -4.70418036e-02f, -1.00550512e-02f, -3.15445103e-02f, -3.66145149e-02f, -4.16245870e-02f, -1.11525841e-02f, 6.87306076e-02f, 5.52386753e-02f, 4.32365946e-02f,
  2.74592012e-01f, 7.73140043e-02f, -1.40286013e-01f, -1.04197279e-01f, 8.90525896e-03f, -1.28936721e-03f, 5.34695126e-02f, -7.43638203e-02f, -6.63592219e-02f, -1.68862212e-02f,
  2.76945289e-02f, -4.30438034e-02f, 2.72800568e-02f, 3.77831161e-02f, 9.85099003e-02f, 5.08623570e-02f, 1.11003488e-01f, -6.12580888e-02f, 2.20062528e-02f, 9.60180238e-02f,
  1.37517765e-01f, 7.91762471e-02f, 6.12870976e-02f, 2.25525815e-03f, 1.02796674e-01f, -1.17534079e-01f, 4.49897200e-02f, 5.24829440e-02f, 3.57857160e-02f, 3.78775507e-01f,
  4.84198123e-01f, 9.40754190e-02f, 1.99156582e-01f, -2.47288316e-01f, 1.57012697e-02f, 2.87386507e-01f, 3.88162374e-01f, 2.62131263e-02f, -2.00587839e-01f, 1.24022998e-01f,
  4.73960228e-02f, -7.05472380e-02f, -2.40336936e-02f, 1.22535182e-02f, 2.65428275e-01f, 2.42389500e-01f, -1.14426106e-01f, 1.23154253e-01f, 1.79863289e-01f, 3.36184464e-02f,
  -2.04402283e-01f, -3.15846086e-01f, -1.98054593e-02f, -1.10426046e-01f, -4.02875215e-01f, -8.39422420e-02f, -1.10826030e-01f, -2.20614612e-01f, 2.70326704e-01f, -2.75274128e-01f,
  1.23823456e-01f, -6.58507645e-02f, 4.82736416e-02f, 5.86378425e-02f, -2.74821613e-02f, 8.85997061e-03f, -9.87342373e-03f, -1.97005227e-01f, -1.86046399e-02f, -1.62662845e-02f,
  -1.28245220e-01f, -2.70781871e-02f, -6.67233095e-02f, -1.10417373e-01f, -4.39976789e-02f, -1.22027267e-02f, -7.56458640e-02f, -4.02349494e-02f, 4.59269844e-02f, 1.38583958e-01f,
  -3.59096229e-02f, 5.38588725e-02f, 7.21022533e-03f, 2.14147605e-02f, 6.08651433e-03f, 4.23970781e-02f, 1.09820336e-03f, -5.65676056e-02f, 1.12016581e-01f, -1.20094016e-01f,
  9.51070040e-02f, 1.16812466e-02f, 2.56617963e-02f, -1.50913686e-01f, -6.07895665e-02f, 2.34068651e-02f, -8.31109732e-02f, -6.14614002e-02f, 3.13305631e-02f, -1.15602545e-01f,
  7.11809751e-03f, 1.21448144e-01f, -1.85997449e-02f, -2.77146213e-02f, -5.09819528e-03f, -9.48897079e-02f, 3.15240175e-02f, 1.75895467e-02f, -1.96620952e-02f, 5.66092171e-02f,
  -3.15183438e-02f, 3.66209857e-02f, -5.48267365e-02f, -2.76374444e-02f, 3.43239084e-02f, -1.19939782e-01f, -1.12288743e-01f, -6.16100170e-02f, -1.75364345e-01f, -6.00664951e-02f,
  -2.23019361e-01f, 3.33650976e-01f, 4.35669161e-03f, -5.16903512e-02f, -3.44330147e-02f, -4.80162352e-03f, -9.06635448e-02f, -5.50177135e-02f, -4.08390276e-02f, -1.13851227e-01f,
  5.39792702e-02f, 3.04755066e-02f, 3.24911699e-02f, -4.14288752e-02f, -1.93672497e-02f, 2.23917812e-02f, 6.87415972e-02f, -4.37253602e-02f, 8.87435600e-02f, -9.97547805e-03f,
  6.34219944e-02f, 5.87507337e-02f, 1.43312946e-01f, 8.80934298e-04f, -5.65783791e-02f, 1.80965334e-01f, 3.63380276e-02f, 1.68026164e-02f, 1.98298335e-01f, 4.13622744e-02f,
  -3.05652529e-01f, -3.07625443e-01f, -1.03028491e-01f, -4.52949703e-01f, -2.66391814e-01f, 5.38185574e-02f, -2.32573494e-01f, 6.39100000e-02f, 3.17414920e-03f, -3.06197733e-01f,
  1.09427191e-01f, 3.95539522e-01f, 2.13826835e-01f, 3.24695557e-01f, 3.62663001e-01f, -3.85608494e-01f, -4.62722778e-01f, 8.38436410e-02f, 4.78918523e-01f, 3.58823240e-01f,
  -1.69603437e-01f, -2.86820740e-01f, 5.05398549e-02f, 1.51036143e-01f, -2.38437638e-01f, 1.64707974e-01f, -2.27834165e-01f, -6.30281717e-02f, 1.79280266e-01f, -4.26970810e-01f,
  8.23718980e-02f, -4.81574573e-02f, 1.83240637e-01f, 2.54647410e-03f, 3.37194167e-02f, 8.51860866e-02f, 6.55451939e-02f, 1.02823541e-01f, 7.13333786e-02f, -5.00265602e-03f,
  3.71553376e-02f, -1.12837451e-02f, -2.93140355e-02f, -5.31174801e-03f, 3.52410749e-02f, 3.64941172e-02f, 1.67195089e-02f, 1.59631804e-01f, 3.70174460e-02f, 9.58832800e-02f,
  -1.53847234e-02f, -5.54107241e-02f, -2.88790427e-02f, 6.83374107e-02f, 8.52104276e-02f, 1.04500085e-01f, 6.58901408e-02f, 1.21108480e-01f, 6.46432564e-02f, -1.92380957e-02f,
  3.57369930e-02f, -5.13691455e-02f, -7.22486600e-02f, -1.33104436e-02f, -6.12635491e-03f, -4.46488410e-02f, -7.77038932e-02f, -2.57008858e-02f, 4.85624336e-02f, -6.64597377e-02f,
  1.52505003e-02f, -6.68465160e-03f, 4.60933968e-02f, -4.46680933e-02f, -3.74371000e-03f, -1.04499064e-01f, -2.56752577e-02f, -1.12622967e-02f, 9.54530984e-02f, -4.83365059e-02f,
  2.33939588e-02f, 2.12307721e-02f, -1.24000616e-01f, 6.53478876e-02f, -3.26106623e-02f, 5.56526333e-03f, -4.86337952e-02f, 7.96739906e-02f, -2.95757037e-02f, -6.98399469e-02f,
  -4.55019251e-02f, 1.05744213e-01f, -4.46064621e-02f, 1.46337211e-01f, -7.55586177e-02f, 4.96466309e-02f, 2.04205308e-02f, 6.71571344e-02f, 2.95499414e-02f, 1.78537518e-02f,
  1.45719320e-01f, 8.96346420e-02f, 7.89193716e-03f, 1.37992188e-01f, 5.32608032e-02f, 7.33191296e-02f, -2.81316899e-02f, 3.25735360e-02f, 1.41492844e-01f, 2.03524586e-02f,
  -2.83176005e-02f, -4.10887972e-02f, 1.94032490e-02f, 9.72881913e-02f, 9.14193019e-02f, -2.38498561e-02f, 5.58750518e-02f, 1.44618034e-01f, 9.36749727e-02f, -1.59892336e-01f,
  -3.05783972e-02f, 2.74926335e-01f, -7.77318850e-02f, 3.83977324e-01f, -3.66723925e-01f, -3.88432503e-01f, -3.44076306e-01f, 3.13251093e-02f, 3.24023485e-01f, 1.62873089e-01f,
  -1.18728824e-01f, 8.69046822e-02f, 1.22854769e-01f, 5.50637245e-02f, -1.67880550e-01f, 9.67785567e-02f, 1.67814136e-01f, -7.12775737e-02f, -3.39791328e-01f, -3.37107807e-01f,
  -4.34076898e-02f, 2.54352748e-01f, 2.76104510e-01f, 1.60840169e-01f, 1.74625233e-01f, -3.54347080e-02f, 2.84427315e-01f, -1.37215257e-01f, -1.13047697e-01f, 4.09234822e-01f,
  -2.31996849e-01f, 3.22199427e-02f, -3.55485715e-02f, 1.22100063e-01f, 1.08983545e-02f, 1.55976832e-01f, -2.30745748e-02f, 1.42026439e-01f, 1.00343511e-01f, 1.22261569e-01f,
  1.05593257e-01f, 7.56265372e-02f, -9.44826100e-03f, 1.31339133e-01f, 4.37947661e-02f, -2.41273213e-02f, 1.98337421e-01f, 1.84276417e-01f, 7.99025074e-02f, -7.15485662e-02f,
  6.58508837e-02f, -1.35245562e-01f, -2.12418884e-01f, 2.40996443e-02f, 4.25060019e-02f, 1.78263504e-02f, -3.30070741e-02f, -7.32826395e-03f, 6.86894171e-03f, 2.55440205e-01f,
  8.39826763e-02f, -9.21061039e-02f, -1.29375890e-01f, -2.56242678e-02f, 3.63811897e-03f, -3.69772688e-03f, 1.85114648e-02f, -1.86232384e-02f, -2.17144471e-02f, -6.42186478e-02f,
  -2.08997708e-02f, -3.85196470e-02f, -2.36238539e-02f, -3.57197709e-02f, 2.59303376e-02f, 6.42774114e-03f, -1.00832038e-01f, 1.06630318e-01f, -5.16078994e-03f, 1.00970663e-01f,
  -5.51367924e-03f, -1.10806368e-01f, -7.55174607e-02f, 1.54615566e-02f, -4.04628552e-03f, 1.48234889e-02f, 2.62075886e-02f, 2.46130526e-02f, -6.16155937e-02f, -4.95212451e-02f,
  2.71122009e-01f, -1.45913079e-01f, 1.59325540e-01f, -4.92156530e-03f, 1.13603901e-02f, 7.13364780e-02f, 1.43411560e-02f, 3.10617574e-02f, 1.19286347e-02f, 3.96934971e-02f,
  -1.18895464e-01f, -4.54546697e-02f, 7.38724554e-03f, 2.73336750e-03f, -2.45872587e-02f, 2.51296293e-02f, -3.46527658e-02f, -8.33710209e-02f, 1.15442678e-01f, 1.43474611e-02f,
  8.62265155e-02f, -3.30516777e-04f, -8.96117017e-02f, -5.70353679e-02f, 6.25564754e-02f, -1.44851640e-01f, -8.25951919e-02f, -3.84331420e-02f, -1.80504873e-01f, 2.00776666e-01f
};

// L0_fan_Wp_bar (Shape: 8 x 120)
const int L0_fan_Wp_bar_rows = 8;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  4.17504838e-04f, 2.36764044e-01f, -7.22086906e-01f, -3.02057173e-02f, -5.97725093e-01f, -7.29601264e-01f, -8.67204726e-01f, -4.68479007e-01f, 1.46710742e-02f, 6.25515431e-02f,
  3.70760024e-01f, 9.39836323e-01f, 1.08270955e+00f, 1.95430309e-01f, -3.82814556e-01f, -4.61453229e-01f, -6.84650242e-01f, -6.92902684e-01f, -9.24929321e-01f, -9.95271862e-01f,
  -6.03427470e-01f, -5.86040258e-01f, -5.95840454e-01f, -1.93428546e-01f, 2.19369963e-01f, 4.97022629e-01f, 2.97548681e-01f, -2.69596696e-01f, -1.87630221e-01f, -3.36220562e-02f,
  4.21952337e-01f, -4.43354517e-01f, -1.09256968e-01f, -1.72141835e-01f, 6.64619207e-02f, 9.92009118e-02f, 8.38344730e-03f, 3.40312682e-02f, 3.68899137e-01f, 1.92465529e-01f,
  2.45320443e-02f, 2.27756426e-03f, 8.12841803e-02f, 6.82093501e-02f, -1.10927485e-01f, -1.06058046e-01f, -2.07277730e-01f, -3.18312466e-01f, -4.81696390e-02f, -6.00844529e-03f,
  -4.94961813e-02f, -4.71040964e-01f, 3.31773795e-02f, -9.37985778e-02f, -1.24565095e-01f, -1.75288185e-01f, -4.92995903e-02f, -1.90090925e-01f, -2.00826645e-01f, 2.14722797e-01f,
  2.98497248e-02f, 3.02297592e-01f, -7.43844882e-02f, -2.75032241e-02f, 4.74839285e-02f, 1.10146977e-01f, 1.05872244e-01f, 1.40346348e-01f, -3.85917835e-02f, 1.71372950e-01f,
  4.52172803e-03f, 1.37112468e-01f, -4.02302630e-02f, 9.24528316e-02f, 5.87187856e-02f, -2.32401118e-01f, -1.13315500e-01f, -4.43563052e-03f, 2.23365966e-02f, -8.21268037e-02f,
  -1.06624804e-01f, -1.62985414e-01f, 7.60179013e-02f, 1.39111996e-01f, -3.00720155e-01f, -7.95657411e-02f, -8.98177326e-02f, 7.34764785e-02f, -1.10059064e-02f, -1.90582916e-01f,
  7.68539190e-01f, -1.64263219e-01f, 4.69346642e-01f, -1.24289870e-01f, -1.21742092e-01f, -2.05330402e-02f, 2.21716642e-01f, -5.39406687e-02f, 1.67138919e-01f, 2.93295253e-02f,
  -2.36157283e-01f, 1.27469614e-01f, 8.89327899e-02f, 7.22139049e-03f, 5.50225973e-02f, -1.38123199e-01f, -3.19225155e-02f, 1.34008974e-01f, -1.24930486e-01f, -2.36954600e-01f,
  9.47636459e-03f, -7.49833882e-02f, 3.71320188e-01f, 2.53032416e-01f, -6.73554186e-03f, 1.66585788e-01f, 2.91142464e-01f, -1.89951416e-02f, 9.32539105e-02f, 3.78915280e-01f,
  -2.05326247e+00f, -2.15712786e-01f, -1.06789637e+00f, -3.08887750e-01f, 7.93365955e-01f, 2.92836875e-01f, -1.14717983e-01f, -4.62073177e-01f, -2.63286352e-01f, -3.00176352e-01f,
  4.88107800e-01f, 7.53468931e-01f, -2.32027978e-01f, 2.70620495e-01f, -1.63753241e-01f, -5.51259667e-02f, 8.52227062e-02f, -3.55458051e-01f, 1.04231015e-01f, 7.85203040e-01f,
  8.23382199e-01f, 1.45162180e-01f, -4.68549341e-01f, -9.92649049e-02f, 1.58810779e-01f, 3.91530275e-01f, -4.62923735e-01f, -1.84843674e-01f, 3.67141545e-01f, 2.71588951e-01f,
  -5.56328058e-01f, -1.09983885e+00f, 3.96691829e-01f, 3.85160536e-01f, 1.66011676e-01f, -5.79021692e-01f, -1.31830618e-01f, -4.23023492e-01f, 9.86089855e-02f, -2.50468761e-01f,
  1.55495048e-01f, -1.50513843e-01f, 3.24285835e-01f, 3.33106548e-01f, -1.10093743e-01f, -3.30663383e-01f, -2.62055963e-01f, -7.04069078e-01f, -7.18845367e-01f, -2.89757729e-01f,
  9.02744353e-01f, 2.76997238e-01f, -6.35492742e-01f, 8.51789042e-02f, -1.19849831e-01f, 1.50403127e-01f, -4.97887805e-02f, -3.11027795e-01f, -7.13721633e-01f, -6.21397853e-01f,
  9.56542343e-02f, -7.14120567e-02f, 1.39944911e-01f, -3.39345634e-01f, 1.42923251e-01f, 2.36047894e-01f, 1.26433104e-01f, 6.91362321e-02f, 2.05002427e-01f, -2.53798783e-01f,
  3.13065439e-01f, 1.74253136e-02f, -5.77848144e-02f, -2.80027181e-01f, 1.32524505e-01f, -1.90890193e-01f, -1.42705196e-03f, -4.46296073e-02f, 2.02054568e-02f, 2.32759118e-02f,
  6.83736652e-02f, -2.18761727e-01f, -1.39265105e-01f, 1.21171527e-01f, 1.11430958e-01f, -2.53460199e-01f, -8.69390741e-02f, 2.08254948e-01f, -1.53275371e-01f, -1.38425067e-01f,
  -1.90862611e-01f, 4.89666671e-01f, -3.18344861e-01f, -1.61852702e-01f, -2.33442277e-01f, 1.27206936e-01f, 7.57638812e-02f, 2.38719564e-02f, -7.34659955e-02f, -2.91063488e-01f,
  1.99911576e-02f, -2.06680328e-01f, -8.30289125e-02f, 2.33653083e-01f, 5.69026358e-02f, -1.33994520e-01f, 1.59300357e-01f, 1.17758974e-01f, 6.11506030e-03f, 7.00718537e-02f,
  -1.21088456e-02f, -1.00626417e-01f, -5.04591465e-01f, -4.15863216e-01f, -6.66355565e-02f, -2.04560727e-01f, -3.39306086e-01f, -4.67951924e-01f, -8.30435872e-01f, -7.53664851e-01f,
  -7.95346916e-01f, 2.29503945e-01f, 1.45876670e+00f, -7.13969946e-01f, 3.40727836e-01f, 6.07673228e-01f, 5.72966933e-01f, 2.27786377e-01f, -1.74329057e-01f, 8.87759700e-02f,
  5.44776142e-01f, -8.13833177e-01f, -4.24286544e-01f, -3.66619140e-01f, -1.53126031e-01f, 1.03141554e-01f, -2.12788954e-01f, -3.78332257e-01f, -3.20250988e-01f, -4.61691350e-01f,
  -9.42834973e-01f, -6.82302535e-01f, -3.32345933e-01f, -1.87054455e-01f, -5.68255544e-01f, -1.10205448e+00f, 4.32470113e-01f, -4.53328863e-02f, 2.44801883e-02f, -1.32171214e+00f,
  1.53680928e-02f, 9.54985976e-01f, -3.73491868e-02f, -3.66232961e-01f, 2.13491678e-01f, -1.78337038e-01f, -1.75394073e-01f, 1.59611359e-01f, -8.53753462e-02f, 5.34192510e-02f,
  2.10225031e-01f, 7.43793845e-02f, 1.13400482e-01f, 1.85356066e-01f, 3.87335777e-01f, 8.91776606e-02f, 6.03558064e-01f, 2.74635196e-01f, 7.32524134e-03f, 4.44839388e-01f,
  -6.12290442e-01f, -1.37890667e-01f, 3.81086975e-01f, 5.79394579e-01f, 5.39794862e-01f, -2.85701782e-01f, 4.91718262e-01f, 8.45442563e-02f, 4.90415424e-01f, -8.59760404e-01f,
  -2.62935609e-01f, -2.44988240e-02f, 1.32285550e-01f, -3.75458971e-02f, -1.45724833e-01f, 1.41668990e-01f, -3.39599513e-02f, 1.65944416e-02f, -5.37420437e-02f, -9.39878300e-02f,
  1.34207472e-01f, 1.47658646e-01f, 4.20198627e-02f, 1.26973867e-01f, -1.97951626e-02f, -4.61718366e-02f, -5.03471382e-02f, -9.36595425e-02f, 1.15543298e-01f, 5.83453216e-02f,
  -1.43992335e-01f, 8.52413997e-02f, 1.29352123e-01f, -1.69478029e-01f, 2.34717056e-01f, 1.93360969e-02f, 1.57615878e-02f, -9.35935080e-02f, -7.85200745e-02f, 1.64774284e-01f,
  -7.48470366e-01f, 5.64825237e-01f, -7.44074047e-01f, -2.06933677e-01f, -3.50119956e-02f, 4.89874296e-02f, -1.53079443e-02f, 2.15354890e-01f, -7.23187476e-02f, -1.56506330e-01f,
  2.33689427e-01f, 4.78721000e-02f, 2.18409747e-01f, -3.29632163e-02f, -1.24586388e-01f, 1.09838128e-01f, -2.46203635e-02f, -3.33531141e-01f, -1.07923791e-01f, -4.25447412e-02f,
  -1.91143289e-01f, -4.85680133e-01f, -1.08011246e+00f, -3.18486512e-01f, -5.33410728e-01f, -1.03283894e+00f, -4.33061630e-01f, -5.71043491e-01f, -5.36205888e-01f, -1.52528501e+00f,
  4.49205488e-01f, -1.60185575e+00f, 5.29608130e-01f, -2.05345303e-01f, -2.17045203e-01f, 4.44356985e-02f, -4.75632727e-01f, -5.48689552e-02f, -1.55612454e-01f, -6.60518408e-01f,
  -7.89160132e-01f, -1.85613841e-01f, -1.62117511e-01f, 1.76117837e-01f, 3.60429615e-01f, -5.53734601e-01f, -8.89765620e-02f, 9.06351864e-01f, 1.56210792e+00f, 5.77286184e-01f,
  -2.60118008e-01f, 3.28930825e-01f, 6.07649386e-01f, 3.73749018e-01f, -8.47113252e-01f, 2.54850388e-01f, -4.48593885e-01f, -3.49879354e-01f, -7.02233255e-01f, -1.17535973e+00f,
  -1.36467487e-01f, -8.30061436e-01f, 3.72838497e-01f, -1.70142516e-01f, -2.53725946e-01f, 6.16275333e-02f, 1.25771001e-01f, 1.36640891e-01f, -1.28064156e-01f, -7.87870437e-02f,
  -2.30722606e-01f, 2.24700421e-02f, -1.06433881e-02f, -1.25052392e-01f, 1.77214906e-01f, 6.31387755e-02f, -2.52700206e-02f, -1.42628551e-02f, -8.53850171e-02f, -3.56460184e-01f,
  -5.30408084e-01f, -4.61012274e-01f, -2.22486138e-01f, 1.14891402e-01f, -2.99020201e-01f, 1.23415217e-01f, -3.38992774e-01f, -2.24849507e-01f, -3.63298841e-02f, -3.20869029e-01f,
  -1.24436738e-02f, 1.18538618e-01f, -1.14541210e-01f, 1.72510907e-01f, 1.02863684e-01f, -1.90384183e-02f, 1.06008962e-01f, 9.78613496e-02f, 9.21327323e-02f, 8.74299109e-02f,
  7.08829835e-02f, -5.92088662e-02f, 9.43210721e-02f, -5.43573052e-02f, -1.98622346e-01f, -3.32928240e-01f, 7.43048936e-02f, -2.19372362e-02f, -9.93997976e-02f, -8.15494508e-02f,
  -4.29580398e-02f, -1.17819533e-01f, -5.79578951e-02f, 7.95462206e-02f, -3.58546555e-01f, 9.17615145e-02f, -1.38525531e-01f, 4.79739979e-02f, 8.90707001e-02f, -1.51249066e-01f,
  5.70150554e-01f, 2.86505491e-01f, -2.34705850e-01f, -1.02331102e-01f, -1.73483402e-01f, -1.93716168e-01f, -3.41123343e-02f, 9.29132476e-02f, -1.28895074e-01f, -2.51825452e-02f,
  -2.89061554e-02f, 2.28215411e-01f, -7.68102929e-02f, -3.58779989e-02f, 4.12953079e-01f, 6.95016235e-02f, -1.38669759e-01f, 1.70896634e-01f, -1.08129151e-01f, 1.43499719e-02f,
  -4.84619252e-02f, 2.23083124e-01f, 5.63263893e-01f, 2.47339547e-01f, -8.48695114e-02f, 4.21026677e-01f, 3.61369759e-01f, 2.08074361e-01f, 3.20472032e-01f, 3.94873172e-01f,
  1.49191833e+00f, -1.16314065e+00f, -5.27147233e-01f, 4.63267952e-01f, 2.05912456e-01f, 2.28953436e-01f, -2.72495300e-01f, 9.86194834e-02f, 4.48835641e-01f, -2.20387995e-01f,
  -9.01613086e-02f, 4.78486389e-01f, 6.11776039e-02f, 2.40607802e-02f, 6.71249554e-02f, -5.21797776e-01f, -4.74164307e-01f, 1.10602237e-01f, 5.67921877e-01f, 4.28978324e-01f,
  9.30125359e-04f, 6.69880137e-02f, 2.58332551e-01f, 9.84279811e-03f, -3.48498344e-01f, 1.37060598e-01f, -5.52693844e-01f, -3.65196645e-01f, -4.11789894e-01f, -8.06860387e-01f,
  -7.49178588e-01f, 9.91559122e-03f, 2.46045291e-01f, 3.72989774e-02f, -1.81088403e-01f, -7.81401619e-03f, 5.62961921e-02f, -7.66081288e-02f, -4.24905568e-02f, -1.49766713e-01f,
  3.10341399e-02f, -2.35874765e-02f, 3.40077793e-03f, -7.02878535e-02f, 6.92226961e-02f, 6.03905171e-02f, 2.03673262e-03f, 7.79405758e-02f, 1.56466328e-02f, -1.67657182e-01f,
  -2.46135712e-01f, 3.32236588e-02f, 6.19314099e-03f, 1.91276386e-01f, 1.27182797e-01f, 1.20919921e-01f, -2.08422318e-01f, -3.42682214e-03f, 2.13816717e-01f, 7.51680806e-02f,
  1.67806242e-02f, -4.01776209e-02f, 2.29238346e-01f, 7.96951577e-02f, 6.70019090e-02f, 3.36607434e-02f, -4.68957387e-02f, 9.99816880e-02f, 1.89676121e-01f, 5.11821546e-02f,
  -1.93955109e-01f, 7.40598738e-02f, 1.02169812e-01f, 7.61043206e-02f, 4.95970547e-02f, -1.24002928e-02f, -7.99425393e-02f, -2.70920284e-02f, 4.00607623e-02f, -3.24510895e-02f,
  1.13239728e-01f, 3.25754210e-02f, -5.52005731e-02f, -1.77038833e-01f, -1.45064592e-01f, -1.06129214e-01f, 1.34314850e-01f, -3.96030620e-02f, -6.53136000e-02f, 5.01222014e-02f,
  -1.51043579e-01f, 3.72491509e-01f, -1.29152033e-02f, 1.06241301e-01f, -1.80782918e-02f, -1.79143131e-01f, 6.16642721e-02f, -5.69410250e-02f, -2.41605237e-01f, -4.48319130e-02f,
  -1.43967429e-02f, 2.91531859e-03f, -1.61980733e-01f, -8.22107196e-02f, 2.29679197e-01f, 1.45594835e-01f, -6.02243170e-02f, 1.05709195e-01f, 2.78561991e-02f, -1.32075384e-01f,
  -3.67438197e-01f, 1.18607417e-01f, 2.53534615e-01f, 6.32507056e-02f, 2.16944590e-01f, 2.42629290e-01f, -4.20543104e-02f, 3.65092396e-03f, 1.93632990e-01f, -1.54787591e-02f,
  1.14444566e+00f, 7.16955960e-01f, -1.82833946e+00f, 3.76538008e-01f, -4.95593786e-01f, -6.99317038e-01f, 2.87932128e-01f, 7.27517426e-01f, 4.39332873e-01f, 1.90334380e-01f,
  1.33063152e-01f, -2.71535516e-01f, -8.00540447e-01f, -3.35643798e-01f, -7.64855742e-02f, -4.12380159e-01f, -7.24702358e-01f, -1.03251743e+00f, -6.64955199e-01f, 4.62162346e-01f,
  6.46021247e-01f, 4.80120689e-01f, 5.74008644e-01f, 1.30726457e-01f, -1.11314587e-01f, -4.47226167e-01f, -5.45691431e-01f, -4.66489345e-01f, -4.64845061e-01f, -9.00018156e-01f,
  -8.54321480e-01f, -3.65788676e-02f, -3.70502979e-01f, 1.92856222e-01f, -1.70516580e-01f, 1.57460719e-01f, -5.02368547e-02f, -1.32608294e-01f, 1.03322454e-01f, 6.70645162e-02f,
  -3.45990419e-01f, 1.30767763e-01f, -2.70542830e-01f, -1.65726066e-01f, 5.98684587e-02f, 2.03936458e-01f, 4.60787639e-02f, -5.44101298e-02f, -7.59544745e-02f, 1.46393646e-02f,
  7.08810389e-02f, -7.02966690e-01f, -8.03154111e-01f, 2.38263965e-01f, -2.86086053e-01f, -6.36727333e-01f, -1.21540114e-01f, -3.26052189e-01f, -5.04230738e-01f, 1.62763849e-01f,
  -5.01397066e-02f, -7.93386400e-02f, 2.41346583e-01f, 1.16559833e-01f, 3.15617919e-01f, -9.72869396e-02f, -1.68709934e-01f, -2.02107225e-02f, 5.55183142e-02f, -6.84454888e-02f,
  1.33493751e-01f, 8.62119067e-03f, 1.52947962e-01f, 3.67912687e-02f, -1.98053136e-01f, -2.01491967e-01f, -1.31184623e-01f, 1.29639730e-01f, -8.63694213e-03f, 1.91413686e-01f,
  -1.07366974e-02f, -1.61713213e-01f, -3.82268503e-02f, 1.49706960e-01f, -7.35971853e-02f, -2.18305230e-01f, -2.19834208e-01f, 2.87175208e-01f, 1.51884630e-01f, -8.16871151e-02f,
  6.42814338e-01f, -1.65352479e-01f, -1.24418549e-01f, -1.50936365e-01f, -2.05626935e-01f, 1.19410502e-02f, -4.45519239e-02f, 4.38138902e-01f, 8.49491265e-03f, 1.92865878e-02f,
  -4.88609727e-03f, 1.20056421e-01f, -2.33216044e-02f, 2.63699949e-01f, 1.54981986e-01f, 3.46448012e-02f, 4.23046917e-01f, -2.28613362e-01f, 7.27760345e-02f, -8.13294202e-03f,
  2.41857991e-01f, 1.21953063e-01f, 2.07369998e-01f, 1.96233578e-02f, 2.80282404e-02f, -9.33009684e-02f, -1.85849950e-01f, 7.64585435e-02f, -2.94135004e-01f, 8.52896869e-01f,
  1.73812497e+00f, -3.58735293e-01f, 1.59686595e-01f, 6.31226003e-01f, 4.46120650e-02f, -9.64902103e-01f, -1.88487995e+00f, -8.19623291e-01f, 4.25217032e-01f, -4.53109175e-01f,
  2.05619648e-01f, 7.95297086e-01f, 5.25905609e-01f, -8.60044807e-02f, -7.49938130e-01f, -1.24028087e+00f, -4.00836408e-01f, 2.41507515e-01f, 2.72854920e-02f, -3.19008976e-01f,
  -1.61835715e-01f, 4.20811266e-01f, 6.80995047e-01f, 1.08459085e-01f, 2.14873374e-01f, 2.73289979e-01f, 1.08832665e-01f, 4.77351546e-01f, -2.70223618e-01f, 2.75541574e-01f,
  2.67750829e-01f, 2.44678453e-01f, -4.90483344e-01f, 4.46038812e-01f, 4.73294526e-01f, -3.05938367e-02f, -1.42127842e-01f, 4.77317542e-01f, -7.58473352e-02f, -1.78920791e-01f,
  4.30954367e-01f, -4.31900322e-02f, 3.96118909e-01f, -1.13148361e-01f, 1.43995985e-01f, -3.15427035e-01f, 6.00138344e-02f, -1.17157497e-01f, 1.88579291e-01f, -2.32647266e-03f,
  -5.50758876e-02f, 1.92721456e-01f, 1.85997844e-01f, -6.61838233e-01f, -4.74951237e-01f, 3.86576027e-01f, -2.35025704e-01f, 5.64302132e-02f, -6.03074804e-02f, -1.41142979e-01f,
  -2.02589795e-01f, 1.75523520e-01f, 4.40598391e-02f, 9.61532295e-02f, -8.78684074e-02f, 4.59035113e-02f, 1.87304839e-01f, -1.24440111e-01f, 5.51175922e-02f, -1.64384633e-01f,
  -8.72822329e-02f, -9.93669778e-03f, -5.13672270e-02f, -1.59535725e-02f, 9.30387974e-02f, 2.15086341e-01f, 8.70307349e-03f, -1.57024428e-01f, 1.81208640e-01f, 1.26351371e-01f,
  4.91733514e-02f, -1.96415216e-01f, 1.83115155e-01f, -2.66254187e-01f, -1.07074842e-01f, 1.14127904e-01f, 8.39126706e-02f, -5.66742346e-02f, 2.01035082e-01f, 6.67179897e-02f,
  2.32323632e-02f, 1.81612968e-02f, -3.82628739e-02f, -1.11001357e-01f, 8.61043483e-02f, 7.84431919e-02f, 1.77824140e-01f, -7.75012448e-02f, 3.47510904e-01f, -2.47573599e-01f,
  -2.90786535e-01f, 5.94752841e-02f, -7.26777837e-02f, -1.73330486e-01f, -1.35848477e-01f, -1.86209101e-02f, -2.14080941e-02f, -5.01190834e-02f, -1.04266517e-01f, 1.88065618e-01f,
  -1.58328235e-01f, -9.13433671e-01f, -4.61172342e-01f, -4.74517286e-01f, -5.58477864e-02f, -2.69355744e-01f, -4.59977537e-01f, -3.57398599e-01f, -5.27235925e-01f, -1.06477427e+00f,
  1.35199356e+00f, 1.00261533e+00f, 3.57985437e-01f, 5.86175144e-01f, 6.68771267e-02f, 7.94867948e-02f, 4.16529834e-01f, 3.23877841e-01f, 6.15393706e-02f, 3.79873812e-01f,
  2.07095653e-01f, 2.65534461e-01f, 1.16897620e-01f, 1.64800972e-01f, 3.05369884e-01f, 2.35340908e-01f, 9.07853097e-02f, 2.51944482e-01f, 2.37456292e-01f, 2.28051364e-01f,
  2.00953409e-01f, 1.14579260e-01f, 1.91983610e-01f, 3.44641685e-01f, 2.47584969e-01f, 5.12192138e-02f, 7.13454261e-02f, 4.41409647e-02f, 2.73319036e-01f, 3.33431423e-01f,
  -5.33870328e-03f, 5.74075520e-01f, -3.93101096e-01f, -8.28041285e-02f, -2.03515723e-01f, -2.36907780e-01f, -1.03336260e-01f, -1.65475711e-01f, -6.23816289e-02f, -1.49810046e-01f,
  -1.94482788e-01f, -1.00803040e-01f, -1.98479705e-02f, -1.58319011e-01f, 1.39707057e-02f, -1.63479447e-01f, 2.92586274e-02f, 1.41937375e-01f, 6.20825253e-02f, 3.54460478e-02f,
  -1.65827591e-02f, -5.85285015e-02f, -7.68814236e-02f, -6.49036095e-03f, 2.03493580e-01f, -2.36377135e-01f, -5.19143343e-02f, 7.81409517e-02f, -3.55334533e-03f, 1.85922146e-01f,
  -2.55625229e-02f, 1.23303324e-01f, 1.74668252e-01f, 7.08960742e-02f, 2.36994192e-01f, -3.31503078e-02f, 7.01491609e-02f, 1.49348140e-01f, 1.86286747e-01f, -5.40128946e-02f,
  -5.55867404e-02f, 1.31858289e-01f, -5.26408777e-02f, 4.05754521e-02f, 3.84117253e-02f, 1.73982471e-01f, -1.53505698e-01f, -4.60925847e-02f, -1.65115669e-02f, -5.66202849e-02f,
  9.48771760e-02f, -2.76361018e-01f, -1.32832676e-01f, 9.93901119e-02f, -2.98345715e-01f, 3.12720090e-02f, -1.98614318e-02f, 7.78150186e-02f, 1.56679183e-01f, -2.04691693e-01f,
  -8.08433473e-01f, -2.87041336e-01f, -5.00106700e-02f, -1.48126617e-01f, -6.93786144e-02f, -4.28005159e-02f, 2.06731975e-01f, -5.15543520e-02f, -5.46149723e-02f, -1.72010958e-02f,
  -1.19927719e-01f, 4.84315716e-02f, 9.97163802e-02f, -8.37159753e-02f, -2.32885569e-01f, -2.06847399e-01f, -3.76808387e-03f, -1.32967338e-01f, -1.45509705e-01f, -1.60621405e-01f,
  -1.09608382e-01f, -2.17905879e-01f, -3.19043338e-01f, -7.59643465e-02f, -1.59537047e-01f, -2.65347570e-01f, -3.39044869e-01f, -3.94101381e-01f, -1.40584111e-01f, -2.83767045e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 8)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 8;
const float L0_fan_Bp_bar_data[] = {
  1.36521006e+00f, 1.05122256e+00f, 1.16624832e+00f, 1.65455174e+00f, 7.95673609e-01f, 4.70890045e-01f, 1.70942700e+00f, 5.84469318e-01f
};

// L1_linear_W (Shape: 12 x 16)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 16;
const float L1_linear_W_data[] = {
  -5.66689968e-02f, -5.06753981e-01f, -1.08103144e+00f, -4.21819538e-01f, -1.36936142e-03f, -2.34555542e-01f, 3.41468066e-01f, -1.84447140e-01f, -3.22172254e-01f, 4.15163219e-01f,
  -6.81716725e-02f, -1.13477588e-01f, 6.12807453e-01f, 6.67188048e-01f, -2.02293783e-01f, -1.59451318e+00f, -5.70346534e-01f, -5.67342162e-01f, -3.56954724e-01f, -8.28551352e-02f,
  -1.04994035e+00f, 4.10464644e-01f, 8.29045117e-01f, -4.15383488e-01f, 3.94250810e-01f, -1.25838196e+00f, -1.58037174e+00f, 3.09304416e-01f, 1.07808673e+00f, -8.56067464e-02f,
  1.37779266e-01f, 6.30234182e-01f, 6.33560866e-02f, 1.15890481e-01f, -1.93242892e-03f, -4.31846343e-02f, -7.05076456e-01f, -3.31550151e-01f, 4.40789819e-01f, 5.10211051e-01f,
  -1.70480371e+00f, 1.36276521e-02f, 1.64387286e-01f, 1.02611613e+00f, 1.17795058e-01f, -1.78535664e+00f, 7.77138174e-01f, -1.27584267e+00f, -5.66703498e-01f, 2.38991708e-01f,
  -4.65020984e-01f, 2.44802177e-01f, 8.04545701e-01f, 1.79698265e+00f, 9.16310847e-01f, -1.23303008e+00f, -9.97049063e-02f, 6.32846296e-01f, 9.42256510e-01f, -9.34284985e-01f,
  -1.81180751e+00f, -4.88176337e-03f, -2.07183552e+00f, -1.21309900e+00f, 2.09383622e-01f, 3.07620037e-02f, 5.09403586e-01f, -1.82286844e-01f, 9.13108468e-01f, -1.08398879e+00f,
  -1.70391217e-01f, 1.05715346e+00f, 9.05731320e-01f, -5.31302929e-01f, 5.74872673e-01f, -1.53322041e+00f, -8.87051344e-01f, -4.62404251e-01f, 3.98273349e-01f, -5.46076715e-01f,
  2.07468912e-01f, 4.51957226e-01f, 8.16901207e-01f, 3.31160203e-02f, 6.44871950e-01f, 1.60871997e-01f, -1.05713463e+00f, 9.82200980e-01f, 3.09825718e-01f, -2.31227756e-01f,
  -1.66501391e+00f, -4.13881660e-01f, 9.28511694e-02f, 1.31929970e+00f, -6.27155483e-01f, 4.42250706e-02f, -7.96603799e-01f, 7.47300863e-01f, 5.37177920e-01f, -2.21096382e-01f,
  -1.56429005e+00f, -9.41691756e-01f, -9.68180656e-01f, 1.25529528e+00f, -1.22613442e+00f, -2.19961429e+00f, -4.15067732e-01f, -5.06362915e-01f, -1.28208137e+00f, -5.28832436e-01f,
  9.32384908e-01f, 3.55501324e-01f, -3.55554044e-01f, -6.30885541e-01f, -3.87252241e-01f, 1.13853790e-01f, 3.76515687e-01f, -7.21046567e-01f, 5.48605695e-02f, 3.16435516e-01f,
  -1.15203261e+00f, 1.25298500e+00f, -4.49552834e-01f, -1.18220472e+00f, -5.83558321e-01f, -8.29169095e-01f, -1.53737426e+00f, 9.47415456e-02f, 4.17351186e-01f, 5.55832870e-02f,
  2.27755398e-01f, -9.23778415e-02f, 4.75207061e-01f, 7.25875378e-01f, -7.23219454e-01f, -9.05895233e-01f, -1.93227327e+00f, -7.25653991e-02f, -9.27834928e-01f, 1.77288055e+00f,
  3.07482213e-01f, -1.25500321e+00f, -1.73785663e+00f, 1.20144319e-02f, 8.10282946e-01f, -5.35724878e-01f, 3.11956286e-01f, 5.17946005e-01f, -7.57273555e-01f, -5.34487724e-01f,
  -5.00926375e-01f, 6.25305831e-01f, 6.30267262e-02f, 6.51430428e-01f, -1.54514396e+00f, -2.23458600e+00f, -1.02754331e+00f, -4.92093831e-01f, 1.38830292e+00f, -7.07720280e-01f,
  4.13161904e-01f, 7.71143556e-01f, -4.16496098e-01f, 3.36358249e-01f, 5.42675436e-01f, -8.36736262e-02f, 6.14253342e-01f, -8.78728867e-01f, 8.38914692e-01f, 6.65663928e-03f,
  -1.20065939e+00f, 1.04418766e+00f, -1.69180107e+00f, -1.30566382e+00f, -1.57261205e+00f, -1.08834779e+00f, 5.53009212e-01f, 1.19353428e-01f, -2.84980506e-01f, 3.05528045e-01f,
  1.02720439e+00f, 1.22237790e+00f, -4.55582857e-01f, -1.07353830e+00f, -9.07711327e-01f, -1.56356943e+00f, 1.26795661e+00f, -1.54190826e+00f, -5.61272025e-01f, -1.13321459e+00f,
  -6.45320490e-02f, 4.23720986e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -6.20648801e-01f, -1.24482262e+00f, 1.22410417e-01f, 4.25561309e-01f, 4.69539106e-01f, 1.41168669e-01f, 2.79300421e-01f, 9.78975236e-01f, -3.26619655e-01f, 2.18165293e-01f,
  -1.12700112e-01f, 1.80440113e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 4, 8
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        16, 12
    );
    }
    