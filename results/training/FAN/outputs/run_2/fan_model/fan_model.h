/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 1 x 120)
const int L0_fan_Wp_rows = 1;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  3.52385879e-01f, -1.25218973e-01f, 1.33348122e-01f, -7.62407184e-02f, 2.18172789e-01f, 9.28135514e-02f, -8.53955373e-02f, 5.98501116e-02f, 1.00673018e-02f, -2.46446446e-01f,
  -2.34010711e-01f, -2.67606471e-02f, -3.83340359e-01f, -3.20732892e-01f, -7.58648291e-02f, -4.16488975e-01f, -8.88471380e-02f, -1.93148971e-01f, -1.52669087e-01f, 1.86241511e-02f,
  3.96351293e-02f, -4.64726388e-01f, -4.52830233e-02f, -1.20932445e-01f, 1.57697484e-01f, 1.69667393e-01f, -4.45101671e-02f, -8.73660520e-02f, -4.26703654e-02f, -6.43180460e-02f,
  -2.55820286e-02f, -7.88050666e-02f, 1.71793461e-01f, 6.27434701e-02f, -1.22215664e-02f, 1.33988917e-01f, 1.38648346e-01f, -1.08833395e-01f, 9.53358933e-02f, -9.53685120e-02f,
  5.61099723e-02f, 1.62267029e-01f, -3.04170270e-02f, -1.49347097e-01f, 5.33641241e-02f, 7.15186745e-02f, -3.85851078e-02f, 5.77544346e-02f, 1.52076106e-03f, 1.10145956e-01f,
  -9.56392288e-03f, 1.03954514e-02f, 1.47558212e-01f, -6.56317696e-02f, 7.57046565e-02f, 1.40178213e-02f, 9.29379612e-02f, 7.57836103e-02f, 6.34576678e-02f, 5.72228990e-02f,
  -4.26131710e-02f, 7.53472745e-02f, -6.18400536e-02f, 5.69883212e-02f, -8.83551985e-02f, 3.28621715e-02f, -9.68434960e-02f, -9.40617472e-02f, -2.32039555e-03f, -5.75597808e-02f,
  -4.87514399e-02f, 3.18527152e-03f, 8.23665468e-04f, 2.88895611e-02f, 8.13243166e-02f, 2.78382935e-02f, 4.15233374e-02f, -7.14895353e-02f, 7.62522370e-02f, -1.67925078e-02f,
  -3.83553840e-02f, 1.62595918e-03f, -8.45811293e-02f, 7.03599229e-02f, -5.01548536e-02f, -6.98273107e-02f, 3.21663469e-02f, 2.34926422e-03f, 1.80956032e-02f, 5.43859303e-02f,
  -2.12860003e-01f, -2.11709961e-01f, -9.34541523e-02f, 3.22531164e-02f, -1.43463433e-01f, 1.09897284e-02f, 3.47566791e-02f, 6.33912385e-02f, -1.01639897e-01f, 5.16321920e-02f,
  1.33184835e-01f, 5.27023105e-03f, 9.22502056e-02f, -1.78734772e-02f, -1.33952526e-02f, 3.37257353e-03f, 3.64499874e-02f, 4.53163236e-02f, 1.29964098e-01f, 7.88735878e-03f,
  1.74043775e-02f, -9.11934860e-03f, 4.49143387e-02f, 1.31628186e-01f, 1.44792115e-02f, 7.58177415e-02f, 6.39751479e-02f, -1.24383055e-01f, -9.61295068e-02f, 2.79457644e-02f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  5.85453093e-01f, -1.32393256e-01f, 1.10571235e-01f, 5.73715091e-01f, -2.28935570e-01f, 3.32402050e-01f, 8.96875978e-01f, -3.08221608e-01f, -2.69898504e-04f, -2.12358460e-01f,
  3.53400767e-01f, -2.42220536e-01f, 7.09026575e-01f, 3.66557360e-01f, 1.83859050e-01f, 3.52062434e-01f, 3.40047061e-01f, 1.72461867e-01f, 8.16242211e-03f, 1.37978150e-02f,
  -6.98211323e-03f, -1.37971580e-01f, 6.24537885e-01f, -6.70349717e-01f, 4.63663071e-01f, -2.21683145e-01f, -1.15159012e-01f, 9.81902406e-02f, -4.47395921e-01f, -9.75105464e-02f,
  2.69058645e-01f, 1.63231567e-01f, 1.19537763e-01f, -1.51178032e-01f, 3.39175850e-01f, 1.77946433e-01f, 7.00038224e-02f, -4.54931296e-02f, 1.79577004e-02f, 9.10202693e-03f,
  6.35195524e-02f, -2.83492774e-01f, -2.09926143e-01f, -1.18090726e-01f, -9.43057239e-02f, -1.84038535e-01f, 1.20712258e-02f, 2.74340898e-01f, -1.51143536e-01f, 2.33919829e-01f,
  3.28197330e-01f, 1.56840011e-01f, 1.50679156e-01f, -1.79762527e-01f, -1.40864491e-01f, -4.65401970e-02f, 1.52067333e-01f, 2.67884165e-01f, -8.67026523e-02f, -1.40701875e-01f,
  -2.71524608e-01f, 1.39611974e-01f, 2.81647891e-01f, 8.58194828e-02f, -7.17007816e-02f, -4.49027345e-02f, -8.95372480e-02f, -8.35386105e-03f, -6.84554651e-02f, 4.99742292e-02f,
  1.54163018e-01f, 1.09493680e-01f, -8.62220675e-02f, 2.41365610e-03f, 5.42966537e-02f, 6.67628497e-02f, 3.55107673e-02f, -1.13271490e-01f, 3.27305973e-01f, 1.76144615e-01f,
  -1.51876071e-02f, -1.93881631e-01f, 2.30237022e-02f, 8.50537866e-02f, -2.51341574e-02f, 4.34785965e-04f, -1.98235035e-01f, -2.80954819e-02f, 1.40225992e-01f, -6.58213273e-02f,
  6.81795971e-03f, -5.21070778e-01f, -2.49876305e-02f, -8.60200599e-02f, 3.55256721e-02f, 1.60705261e-02f, -3.20820771e-02f, -2.74895281e-01f, -1.10403247e-01f, -1.68220147e-01f,
  3.64427306e-02f, 1.53709218e-01f, -6.05167896e-02f, -1.33805230e-01f, -1.03503563e-01f, -2.01342441e-02f, 3.39003354e-02f, -1.02474846e-01f, -8.49084407e-02f, -1.27513409e-01f,
  -1.52117044e-01f, 1.73544854e-01f, -9.69098955e-02f, 8.46812502e-03f, -1.94459483e-01f, -1.06203062e-02f, -2.80735135e-01f, -2.18147617e-02f, -8.58725086e-02f, -5.56215122e-02f,
  -2.70576656e-01f, 4.31534290e-01f, -7.24314898e-02f, -1.43452093e-01f, -4.81903255e-01f, 2.88748533e-01f, 2.27063596e-01f, 7.36310286e-03f, 8.36673617e-01f, 1.42168611e-01f,
  -5.20208001e-01f, -6.88586012e-02f, 2.17514232e-01f, -3.40000123e-01f, -3.40442881e-02f, 5.68186164e-01f, 2.13770702e-01f, 1.63551178e-02f, 5.51917374e-01f, -2.02857837e-01f,
  -1.77560419e-01f, -4.63840723e-01f, -7.27761090e-01f, -3.27563077e-01f, -7.05607831e-01f, 4.90379333e-03f, -7.59551704e-01f, -4.23395224e-02f, -7.52659142e-01f, 9.44786612e-03f,
  -3.88820507e-02f, 3.98567431e-02f, -3.62446815e-01f, 7.51777440e-02f, 7.90447667e-02f, -2.43097823e-02f, 8.20488576e-03f, -1.19231075e-01f, 1.04115039e-01f, -5.28132617e-02f,
  9.94962156e-02f, 3.65215875e-02f, 1.85730249e-01f, -1.29476681e-01f, -1.11416034e-01f, -2.01651871e-01f, -2.19618291e-01f, -9.74950567e-03f, -5.46372719e-02f, -2.08865836e-01f,
  -2.54465878e-01f, -4.46143970e-02f, -8.01824555e-02f, 8.31678957e-02f, -1.67512491e-01f, 7.36258253e-02f, 1.22864708e-01f, -8.05224180e-02f, -1.62936784e-02f, 1.97680071e-02f,
  -1.25423446e-01f, 2.29416713e-01f, 9.59485024e-02f, 6.46731704e-02f, -1.34255826e-01f, -4.17973213e-02f, -1.41175091e-01f, -1.13675743e-01f, 8.74940678e-02f, -2.53630489e-01f,
  7.62336478e-02f, -1.36305496e-01f, 5.41094989e-02f, -4.98626456e-02f, 2.96819843e-02f, 1.17629446e-01f, 3.34758610e-02f, 1.51566744e-01f, 1.11491427e-01f, -1.19731992e-01f,
  -6.75197272e-03f, -2.18131486e-02f, -1.63742989e-01f, -3.54105569e-02f, -9.80763063e-02f, -9.42235664e-02f, 4.67338078e-02f, -1.17038399e-01f, 1.87395164e-03f, -1.54443800e-01f,
  2.90618807e-01f, 6.79897726e-01f, 5.44327497e-02f, -4.62480672e-02f, 1.31716013e-01f, -1.10600643e-01f, 1.09023847e-01f, -1.22943707e-01f, 2.03342229e-01f, 1.32963598e-01f,
  8.80355202e-03f, 3.27781439e-02f, 1.17388479e-02f, -6.12816326e-02f, -3.79809109e-03f, -7.68501535e-02f, 1.38396993e-01f, 1.81725040e-01f, 1.77782938e-01f, -1.88367218e-01f,
  -2.89021969e-01f, 1.66637674e-01f, 2.96251457e-02f, 4.51901108e-02f, 5.14673581e-03f, -9.92214009e-02f, 2.30163299e-02f, 5.59464507e-02f, -1.00458711e-01f, 1.68799222e-01f,
  -1.72669101e+00f, 6.57949269e-01f, 2.28212580e-01f, -3.17000568e-01f, -2.77654886e-01f, 2.62235135e-01f, 8.38111192e-02f, -3.26491371e-02f, -4.43368852e-01f, 2.35556290e-01f,
  2.74944529e-02f, -1.07669234e-01f, 5.95547408e-02f, 5.88644445e-01f, -7.17070401e-01f, 1.78574562e-01f, -1.03574492e-01f, -1.19709179e-01f, 2.88737137e-02f, -3.59336525e-01f,
  -1.98728591e-01f, 1.39224470e-01f, 1.10811323e-01f, 3.52043897e-01f, 2.51673251e-01f, -2.43740082e-02f, -1.12287611e-01f, 1.63473636e-01f, 5.12688816e-01f, 3.66805553e-01f,
  -5.43237031e-01f, -5.09716690e-01f, -7.80062452e-02f, -1.57644808e-01f, -2.50168383e-01f, -6.88147768e-02f, -6.17457181e-02f, 3.43631953e-02f, -5.25667183e-02f, -7.89459199e-02f,
  -3.87482718e-02f, 6.91964999e-02f, 1.00459084e-01f, -6.16318882e-02f, -1.26003578e-01f, 3.29683833e-02f, 8.83427709e-02f, 1.17016166e-01f, 1.49894044e-01f, 6.72686324e-02f,
  9.41024870e-02f, 2.15706661e-01f, -3.67931388e-02f, 7.04950094e-02f, 1.02741793e-01f, -2.59463172e-02f, 1.09622724e-01f, -3.92439552e-02f, -3.36377509e-02f, -6.41256049e-02f,
  -4.68579642e-02f, -1.06060140e-01f, 1.37841746e-01f, -4.85448800e-02f, 3.99636626e-02f, 1.40909895e-01f, -3.39503586e-02f, -7.33216014e-03f, -3.32250409e-02f, -1.00572862e-01f,
  2.68625356e-02f, -2.68451497e-03f, -1.20384239e-01f, 2.08671764e-03f, -3.28889787e-02f, -8.17018794e-04f, -7.37590566e-02f, -3.36305052e-02f, -3.99380699e-02f, -1.07026123e-01f,
  -1.41123682e-01f, -4.37890738e-02f, 6.75353780e-02f, 8.40308070e-02f, 2.16150917e-02f, -1.61003917e-01f, 4.69332896e-02f, 1.11500993e-01f, -7.91577622e-02f, -1.58252120e-01f,
  -1.43501687e+00f, -9.41956341e-01f, -1.64542012e-02f, -4.57384484e-03f, -4.22930904e-03f, -3.43952291e-02f, 4.25291508e-02f, 7.85741806e-02f, -1.54610917e-01f, -1.80590957e-01f,
  -1.90011021e-02f, 9.86062586e-02f, -1.36886880e-01f, -9.35068130e-02f, 8.66585821e-02f, -3.65112722e-02f, -3.20303053e-01f, -1.28530890e-01f, -3.15944791e-01f, 6.16100803e-02f,
  -4.70233075e-02f, -1.47098571e-01f, 7.95896128e-02f, -1.82445254e-02f, 2.29591131e-02f, -1.01587363e-01f, -2.13610083e-01f, 1.80495158e-01f, 1.09504797e-02f, 1.07621588e-01f,
  1.58530235e-01f, 7.55882084e-01f, 7.50421435e-02f, -1.87403500e-01f, -1.09268621e-01f, -6.82894409e-01f, -3.62451136e-01f, -7.75805488e-02f, 1.02987468e-01f, 5.22605777e-01f,
  -5.96546710e-01f, 9.02564287e-01f, -1.30116969e-01f, -5.54843903e-01f, -1.06419849e+00f, -5.53855479e-01f, -6.10371351e-01f, -1.50546134e-01f, -1.70012414e-02f, 1.07778974e-01f,
  -3.71083170e-01f, -6.19081438e-01f, -5.17368495e-01f, 8.30846652e-02f, 6.34683594e-02f, 4.90454733e-01f, -4.18382108e-01f, 1.48411855e-01f, 5.70216700e-02f, -1.64483935e-01f,
  7.08652253e-04f, 2.63325453e-01f, 1.14798136e-01f, -1.19277593e-02f, -1.15228690e-01f, 9.74370316e-02f, 1.07468233e-01f, -1.65491059e-01f, 3.18023632e-03f, 2.15092432e-02f,
  3.09257597e-01f, 2.31579877e-02f, 7.33668506e-02f, -1.56923495e-02f, 2.16437116e-01f, 1.49045989e-01f, 9.68438163e-02f, -6.26856089e-02f, 1.18757859e-01f, 1.26046717e-01f,
  4.94734719e-02f, 1.01110823e-02f, -1.51739746e-01f, -4.66618463e-02f, -3.91586348e-02f, -7.06836581e-02f, -5.78112863e-02f, 1.11180283e-01f, 1.07947960e-01f, -5.18296510e-02f,
  -4.85675484e-02f, 5.04644699e-02f, -2.62735710e-02f, 1.63162589e-01f, -1.94213301e-01f, -6.48723543e-02f, -4.27241921e-02f, 2.99636647e-02f, 3.11911181e-02f, 8.40561017e-02f,
  -9.91535839e-03f, 8.26250985e-02f, -9.57120955e-02f, -5.26878349e-02f, -1.13418289e-01f, 1.39518246e-01f, -4.83595282e-02f, 1.88910156e-01f, -5.95462620e-02f, -2.40148399e-02f,
  -3.62781547e-02f, -2.43921295e-01f, 4.83202040e-02f, 9.01178941e-02f, -8.12094286e-02f, 2.78548226e-02f, 1.00589599e-02f, 7.42552504e-02f, -2.22379286e-02f, -2.52572656e-01f,
  -3.38127136e-01f, -3.91902328e-01f, -2.79023405e-02f, 1.68243006e-01f, 4.09036539e-02f, 3.48326527e-02f, -1.72248319e-01f, -3.38241016e-03f, -1.01038419e-01f, -1.11765616e-01f,
  6.31952658e-02f, 8.57028440e-02f, 2.84389704e-02f, 3.15916538e-02f, -6.08553812e-02f, -2.27928936e-01f, -1.34919062e-01f, 3.87969911e-02f, -1.29348785e-01f, 3.73077542e-02f,
  6.01813160e-02f, 7.35914931e-02f, -6.69976547e-02f, -1.22525021e-02f, 4.68108011e-03f, 1.53901994e-01f, 1.67685449e-01f, 1.24728359e-01f, -1.45503566e-01f, -6.49545118e-02f,
  -6.25586569e-01f, 3.30512881e-01f, 4.44995821e-01f, -5.62043786e-02f, 8.53046000e-01f, 2.35204831e-01f, -3.30355465e-01f, 7.10499823e-01f, 6.88973427e-01f, -4.03320968e-01f,
  -3.24894488e-02f, -3.51284415e-01f, 2.72086322e-01f, -2.56519914e-02f, -3.56757432e-01f, 3.59536171e-01f, -2.94816315e-01f, -3.59074563e-01f, 4.95447457e-01f, -3.24300043e-02f,
  1.45241797e-01f, -1.94083437e-01f, 7.27483705e-02f, 4.84670043e-01f, 2.57110089e-01f, 1.46111816e-01f, -6.41344249e-01f, 4.07947987e-01f, -3.15655529e-01f, 9.76806656e-02f,
  1.33784145e-01f, 6.36238098e-01f, 2.06843302e-01f, 1.51022941e-01f, 5.56937791e-02f, -9.18693021e-02f, -2.21920505e-01f, -2.81638093e-02f, 3.13574597e-02f, 2.21618116e-01f,
  -2.18910307e-01f, 6.30241558e-02f, 8.05010349e-02f, 8.91734287e-02f, 2.15818807e-01f, 1.90555707e-01f, 3.11286986e-01f, 9.77829993e-02f, 2.01784298e-01f, 8.23784247e-02f,
  1.71064888e-03f, 1.47294551e-01f, 5.84710017e-02f, -1.88928157e-01f, 4.04518610e-03f, 1.59395561e-01f, -9.21384767e-02f, -2.15251550e-01f, -2.85173729e-02f, 3.95267084e-02f,
  9.59942564e-02f, 3.91181819e-02f, -2.96509955e-02f, 7.10143298e-02f, 2.89168991e-02f, 1.25197507e-02f, 8.00001621e-03f, -1.57641754e-01f, 1.95634086e-03f, -1.13636807e-01f,
  -4.49569225e-02f, 2.72954139e-03f, 1.72830939e-01f, -3.71171758e-02f, -1.62554812e-02f, -5.80597960e-04f, -1.77682608e-01f, -3.34645924e-03f, -9.44566801e-02f, -5.89814298e-02f,
  9.74638984e-02f, -7.63530359e-02f, 1.11511581e-01f, -5.44193089e-02f, -5.75912185e-03f, 1.47828739e-02f, 1.61765382e-01f, 1.71467528e-01f, 1.73031911e-01f, -1.34342879e-01f,
  -5.02800941e-01f, -2.97634512e-01f, 1.17808849e-01f, 1.73112303e-01f, -1.40265569e-01f, -3.63933966e-02f, 2.83228830e-02f, -2.29239371e-02f, -3.28255817e-02f, 1.47894755e-01f,
  -7.66045600e-02f, -1.78566217e-01f, -2.35185742e-01f, -4.72879484e-02f, -1.50209039e-01f, -3.73503082e-02f, -2.47634187e-01f, -1.99783847e-01f, -3.27437371e-01f, -1.31853357e-01f,
  -1.58834457e-01f, -5.44835068e-02f, -1.43590972e-01f, 1.39032796e-01f, -1.24079295e-01f, -1.60885081e-01f, -2.22262844e-01f, 8.81767366e-03f, -1.00594632e-01f, -1.30387217e-01f,
  4.44851696e-01f, -2.56509244e-01f, -6.60965860e-01f, -1.63561866e-01f, 1.03478156e-01f, 9.73618090e-01f, 9.25867319e-01f, -3.08587760e-01f, -5.85179985e-01f, 4.84834135e-01f,
  5.23369074e-01f, -3.86682451e-02f, -4.81593311e-02f, 9.75401759e-01f, 5.31298697e-01f, 2.57765979e-01f, 6.76645517e-01f, 5.48391283e-01f, -2.77042300e-01f, -1.77375451e-01f,
  -8.19836408e-02f, 8.97943199e-01f, -1.66557461e-01f, -2.79755779e-02f, 2.97620445e-01f, -6.18746698e-01f, -2.34190933e-02f, -2.36133277e-01f, 6.40556633e-01f, 5.47615469e-01f,
  1.47201344e-01f, -4.94855978e-02f, -1.83944672e-01f, 7.52551407e-02f, -1.01338968e-01f, -5.18302880e-02f, 2.20941857e-01f, 1.99720100e-01f, -6.10167198e-02f, -1.53572867e-02f,
  6.09750524e-02f, 2.83142999e-02f, 1.76264852e-01f, 8.84236991e-02f, 4.26262468e-02f, 6.66222721e-02f, -1.58999935e-01f, -1.64654925e-01f, -9.55578685e-02f, -6.80741221e-02f,
  -3.35085034e-01f, -1.19591631e-01f, -8.26395452e-02f, 5.81942052e-02f, -1.04878083e-01f, 1.51613234e-02f, 6.51567653e-02f, -2.17450380e-01f, -6.52002394e-02f, -3.74762178e-03f,
  -6.99976692e-03f, 7.54105076e-02f, -3.38458456e-02f, 7.22376928e-02f, 1.58229589e-01f, 9.03129205e-03f, 9.96704996e-02f, 1.89554784e-02f, -2.25566804e-01f, 8.37497041e-02f,
  -1.55250177e-01f, 7.72307888e-02f, 6.27201423e-02f, 1.44550592e-01f, 2.06246808e-01f, 3.02675832e-02f, 7.43029565e-02f, 1.66290715e-01f, -1.76821113e-01f, -2.46269271e-01f,
  1.52882813e-02f, -5.78848005e-04f, 5.95465302e-02f, -9.32148471e-02f, 1.35570467e-01f, -1.45287558e-01f, 1.95582673e-01f, -9.63488314e-03f, -1.30240336e-01f, 3.22043858e-02f,
  -4.75003384e-02f, -1.10627845e-01f, -1.22868419e-01f, 1.70005038e-01f, -5.10528535e-02f, -6.24488369e-02f, 1.37282133e-01f, -1.02891430e-01f, -1.85994413e-02f, 1.12731032e-01f,
  -5.81900254e-02f, -3.93983759e-02f, -5.46394996e-02f, -4.13335823e-02f, -4.72167470e-02f, -9.54225436e-02f, 1.48588568e-01f, -7.41103441e-02f, 1.54589070e-03f, -2.84486543e-02f,
  7.99938515e-02f, 6.31938428e-02f, -6.86183050e-02f, -5.70094772e-02f, -1.70174986e-02f, 6.48954958e-02f, -1.53817281e-01f, -4.04863581e-02f, 1.15166843e-01f, -6.44567236e-02f,
  -1.43269634e+00f, -2.28868112e-01f, -8.55167329e-01f, -5.23098707e-01f, -2.50543177e-01f, -3.69258672e-01f, 1.08260065e-01f, -2.36190557e-01f, -3.95491332e-01f, 7.44987547e-01f,
  4.07909513e-01f, -6.30379915e-01f, 5.92597306e-01f, -3.94009382e-01f, -1.28034592e+00f, -1.07830368e-01f, -4.76306617e-01f, -1.19439207e-01f, -3.19436222e-01f, -1.49926230e-01f,
  -5.28452814e-01f, 1.08953543e-01f, -3.49284351e-01f, 3.92096102e-01f, -2.54680246e-01f, 8.59738290e-02f, 6.26285136e-01f, 4.66977954e-01f, 7.72240907e-02f, -3.85357857e-01f,
  -4.57095653e-01f, 9.68958214e-02f, -2.89158244e-02f, -9.83221084e-02f, -4.93302122e-02f, 1.34399578e-01f, 5.04449271e-02f, 4.37893979e-02f, -1.11983038e-01f, -1.46124706e-01f,
  1.45228148e-01f, -1.47761047e-01f, -1.25460729e-01f, 4.12004218e-02f, -1.33898377e-01f, -2.05405146e-01f, -2.45453492e-01f, -1.21121526e-01f, -2.91788541e-02f, -2.73065716e-01f,
  -1.68846771e-01f, -1.08857445e-01f, -8.31936311e-04f, 3.83051671e-02f, -1.87214121e-01f, 1.85506307e-02f, -2.04327889e-02f, 2.12931801e-02f, -2.13254765e-01f, -2.81426877e-01f,
  1.80072822e-02f, 8.25474933e-02f, 8.12850669e-02f, 1.49245383e-02f, 4.44259606e-02f, 1.20258816e-01f, 6.35962710e-02f, 8.82409606e-03f, 7.50765875e-02f, -6.29032329e-02f,
  -9.25659388e-02f, -7.30224550e-02f, -1.50979189e-02f, -1.98778864e-02f, 4.76129279e-02f, 6.72864914e-03f, 4.46303673e-02f, -5.90247661e-03f, -8.13122168e-02f, -1.01435035e-01f,
  1.93694264e-01f, -6.35844246e-02f, 5.57665378e-02f, 1.20907143e-01f, -6.53783903e-02f, -3.88579480e-02f, 7.48815909e-02f, -9.55521390e-02f, -4.55456879e-03f, 1.00116841e-01f,
  -1.14602260e-01f, 2.02449739e-01f, 3.17327045e-02f, -6.16631061e-02f, 1.20729089e-01f, 5.31981960e-02f, 2.94153616e-02f, -1.70620620e-01f, -1.14356667e-01f, 9.55458954e-02f,
  3.26320007e-02f, 1.37678653e-01f, 1.28723029e-02f, 1.88284870e-02f, -7.77067095e-02f, 5.12192622e-02f, 1.84588671e-01f, -1.71340839e-03f, 1.04285359e-01f, 2.12235637e-02f,
  1.49487987e-01f, 1.73898682e-01f, 6.93093166e-02f, 1.75040469e-01f, 1.46361575e-01f, 2.42404696e-02f, -7.94344023e-02f, 1.11614494e-02f, 1.23055145e-01f, 6.72664642e-02f,
  -1.13653684e+00f, 6.92201316e-01f, -6.44970015e-02f, -1.77308559e-01f, -6.70137525e-01f, 9.95539367e-01f, 4.58067685e-01f, 1.70041472e-02f, 1.74492106e-01f, 7.45786488e-01f,
  -8.55616182e-02f, -2.24052325e-01f, 2.69538850e-01f, 3.86289328e-01f, 2.26990819e-01f, 6.02667630e-01f, 3.06968927e-01f, 2.34864876e-01f, -1.26819327e-01f, -3.48943919e-02f,
  -5.96761191e-03f, -6.56567439e-02f, 1.38565928e-01f, -1.02535397e-01f, -3.67161870e-01f, -2.22279668e-01f, -4.05266762e-01f, -2.35991314e-01f, 2.22724415e-02f, -1.42152339e-01f,
  -2.79628664e-01f, -6.43116593e-01f, -4.46965188e-01f, -1.15021624e-01f, -8.16072449e-02f, -5.87912574e-02f, 3.14803049e-02f, -1.02596760e-01f, -2.78142154e-01f, -2.28693732e-03f,
  1.27208382e-01f, -4.22287658e-02f, 1.40608251e-01f, -5.16953878e-02f, -4.97862510e-02f, 6.63182437e-02f, 1.51146933e-01f, -3.10410047e-03f, 1.94104221e-02f, 1.20895468e-01f,
  1.80383310e-01f, 9.37355310e-02f, 8.51599202e-02f, 1.00074001e-01f, -1.89442173e-01f, 3.18309739e-02f, 2.27688298e-01f, 8.45582485e-02f, -8.25396776e-02f, 6.52993098e-02f,
  -4.00435328e-02f, 2.45086830e-02f, 1.08436733e-01f, -5.14489636e-02f, 1.15682088e-01f, -1.34341210e-01f, 5.96641079e-02f, -5.33418134e-02f, 4.91830930e-02f, 8.71962830e-02f,
  -5.03911600e-02f, -1.55390456e-01f, -8.19011852e-02f, 6.15708791e-02f, -3.66515443e-02f, 8.65631551e-02f, -3.38053741e-02f, -1.09691069e-01f, 1.21838324e-01f, 2.88131041e-03f,
  -6.92894729e-03f, 1.20484635e-01f, -1.16285026e-01f, -3.00357528e-02f, 1.21440344e-01f, 5.08104414e-02f, 1.20974027e-01f, 7.64742717e-02f, -6.63929060e-02f, -1.25154540e-01f,
  4.26099338e-02f, -1.08957306e-01f, -1.63776115e-01f, -2.57162660e-01f, -3.61378156e-02f, -1.99042056e-02f, -1.34675011e-01f, -1.96467284e-02f, -1.62613131e-02f, 1.57513991e-02f,
  -5.91813363e-02f, -2.49976311e-02f, -9.41086709e-02f, -5.86096123e-02f, 8.87721702e-02f, 2.76572227e-01f, 4.75543886e-02f, -2.50149369e-01f, -1.14390679e-01f, -1.00179784e-01f,
  -1.64097294e-01f, -5.00925295e-02f, 4.20164876e-02f, 3.30338590e-02f, -1.17276892e-01f, -7.88469166e-02f, -1.85397208e-01f, -6.02874272e-02f, -4.58348617e-02f, -2.35086754e-02f,
  2.14029074e-01f, 8.22223306e-01f, 1.15069902e+00f, 5.74052215e-01f, -6.93114161e-01f, -2.55056888e-01f, 2.69218206e-01f, -1.19672403e-01f, -1.63519979e-01f, 9.91874710e-02f,
  -2.80475527e-01f, 8.49256098e-01f, 2.64197528e-01f, 2.86224335e-01f, 3.01434934e-01f, 5.51908724e-02f, -5.39142415e-02f, 2.47124255e-01f, -2.98724137e-02f, 3.27184081e-01f,
  4.34082001e-02f, -4.35750723e-01f, 3.97874445e-01f, -1.28754631e-01f, 4.32574838e-01f, 4.48081821e-01f, 4.54328619e-02f, 3.06087852e-01f, 3.65989208e-01f, 7.74438977e-02f,
  -5.61140180e-01f, 6.85478300e-02f, 2.10229471e-01f, 1.52475357e-01f, -1.35840535e-01f, -5.94846681e-02f, 2.25453794e-01f, 1.78734049e-01f, -1.01950960e-02f, 4.10702527e-02f,
  1.77217916e-01f, -1.60220012e-01f, -5.73816039e-02f, 1.15324356e-01f, -2.27954805e-01f, 7.81986117e-02f, -5.40786944e-02f, -9.73670855e-02f, 1.30523831e-01f, 3.57713513e-02f,
  1.83602005e-01f, 1.12052597e-02f, -1.27703790e-03f, 5.75043373e-02f, 3.13098907e-01f, -2.84137093e-02f, 9.39732194e-02f, 2.08731920e-01f, 1.10251725e-01f, -8.36995691e-02f,
  -2.48813108e-02f, -1.01460367e-01f, -9.88620892e-02f, -1.22803919e-01f, 1.03187479e-01f, 6.77710958e-03f, 6.08751066e-02f, -2.13786900e-01f, 5.02339052e-03f, -2.87165698e-02f,
  -2.62247503e-01f, 2.77170911e-02f, -2.02985168e-01f, -1.41821355e-02f, -7.55083654e-03f, -1.88993067e-01f, -1.28773954e-02f, -1.32978363e-02f, -8.53122547e-02f, -2.88785875e-01f,
  1.05002195e-01f, 9.72724780e-02f, 1.60341561e-01f, -1.75943121e-01f, -1.38801634e-01f, 1.67386141e-02f, 2.91131884e-02f, 1.41653955e-01f, -1.01395682e-01f, 2.12229535e-01f,
  -2.13822350e-02f, 7.32803524e-01f, 3.32130380e-02f, -1.01259500e-01f, -4.82204966e-02f, 7.14247152e-02f, 3.48075405e-02f, 2.77998839e-02f, 2.75578469e-01f, 2.88285017e-02f,
  -1.00194484e-01f, -3.75243202e-02f, -5.30133732e-02f, -1.24695748e-01f, 6.75680563e-02f, -6.85926666e-03f, 1.86403289e-01f, 5.05803935e-02f, 3.03330868e-02f, 1.15348287e-01f,
  1.65187001e-01f, 2.82713491e-02f, 2.12726533e-01f, -2.89186910e-02f, -1.66791171e-01f, 1.82407051e-02f, -6.72180206e-02f, 2.70249676e-02f, 1.00664862e-01f, 1.52952090e-01f,
  -5.85184038e-01f, -7.77889848e-01f, -3.97943228e-01f, -2.28592791e-02f, -6.00806288e-02f, -3.90000224e-01f, -8.22609663e-01f, -6.39814511e-02f, -6.97782755e-01f, -4.72174793e-01f,
  -3.10641583e-02f, -2.40963951e-01f, -5.60930073e-01f, -2.28477828e-02f, 2.48334706e-01f, -5.14364064e-01f, 1.12126268e-01f, 1.75532654e-01f, -5.20664193e-02f, 1.90436676e-01f,
  2.75240839e-01f, 2.94264466e-01f, 6.94881797e-01f, 5.45441210e-01f, 8.89363810e-02f, 5.74924469e-01f, 8.31799746e-01f, 3.32264930e-01f, 8.09575796e-01f, 2.66575366e-01f,
  -6.39728755e-02f, -1.19178563e-01f, -9.77069810e-02f, -4.02117474e-03f, 2.11649552e-01f, 1.05946392e-01f, 2.35162869e-01f, 6.87936991e-02f, 6.28820136e-02f, 1.12653226e-01f,
  -9.57382023e-02f, 1.58539549e-01f, 3.80583070e-02f, -9.43944603e-02f, -1.86016858e-01f, 4.92700823e-02f, -5.11375442e-02f, -8.41677003e-03f, -1.94830783e-02f, -1.25025585e-01f,
  -3.12045336e-01f, -8.33397210e-02f, -3.47767211e-02f, 9.86831039e-02f, -9.85128954e-02f, -1.56434774e-01f, 1.56087205e-02f, 9.67817679e-02f, -6.26066402e-02f, -2.39657667e-02f,
  -2.07491238e-02f, -7.33626485e-02f, -1.14333585e-01f, -2.71238573e-02f, -7.91856050e-02f, 2.71782875e-02f, -8.82107466e-02f, 5.66726737e-02f, -3.92735526e-02f, -4.61731143e-02f,
  1.17018074e-01f, -1.38757408e-01f, -2.50656661e-02f, -3.10046487e-02f, -3.80555540e-02f, -1.37696177e-01f, 7.83995092e-02f, 1.05391532e-01f, 1.44165516e-01f, 1.30084231e-02f,
  -1.29526541e-01f, -2.23708805e-02f, 2.05766819e-02f, 1.03907637e-01f, -1.62373409e-01f, 7.55681470e-03f, 4.99686524e-02f, -5.17366715e-02f, 2.53657579e-01f, 1.74071901e-02f,
  3.09805810e-01f, 1.89693481e-01f, 1.76664852e-02f, 1.10317975e-01f, 4.82170507e-02f, -1.88291259e-02f, -8.17274153e-02f, -3.84002621e-03f, 5.70021085e-02f, -9.96789560e-02f,
  9.62026566e-02f, 4.80497591e-02f, 1.02468841e-01f, 7.02281669e-02f, 1.87441334e-01f, -1.14999302e-01f, 9.29430798e-02f, 1.10169657e-01f, 6.28300011e-02f, 2.52654135e-01f,
  -3.10461968e-02f, -4.75174077e-02f, 4.32479680e-02f, -5.69439121e-02f, -1.11366481e-01f, 5.13906451e-03f, -3.93329784e-02f, 4.24538888e-02f, 1.20629564e-01f, 3.12345698e-02f,
  8.64146233e-01f, -1.04824197e+00f, 6.63660645e-01f, 6.59699023e-01f, 6.69884205e-01f, 4.31347519e-01f, 7.27168620e-01f, 5.11345938e-02f, 4.19076145e-01f, -7.85284042e-01f,
  -5.49896836e-01f, -2.17860565e-01f, -6.27660334e-01f, -5.91791458e-02f, 8.64712417e-01f, -3.14172238e-01f, 3.27051789e-01f, -6.42488226e-02f, 2.86207885e-01f, 5.33353761e-02f,
  3.66727233e-01f, -8.81993100e-02f, 2.02805817e-01f, -4.34621096e-01f, 7.10317791e-02f, 8.33737627e-02f, -3.53665441e-01f, 1.95699781e-01f, -1.50046110e-01f, 3.76818657e-01f,
  -3.49462032e-01f, -1.79389685e-01f, -6.08974323e-02f, -1.51724860e-01f, -8.65766332e-02f, -5.47290631e-02f, 2.03111634e-01f, 2.21922368e-01f, 3.02114993e-01f, -3.13970335e-02f,
  -1.88972205e-02f, 1.93406478e-01f, -5.54247294e-03f, 1.82602197e-01f, 2.34986052e-01f, 2.04348788e-01f, 1.42149165e-01f, -1.81766793e-01f, 2.76469123e-02f, 1.00084998e-01f,
  5.51553704e-02f, -1.97352409e-01f, -1.18999235e-01f, 1.25377048e-02f, 5.50130419e-02f, 7.85956532e-02f, 1.39307976e-01f, 7.62758180e-02f, -4.98091690e-02f, 7.60656595e-02f,
  1.66802883e-01f, -9.11589265e-02f, -1.76433846e-01f, -8.66034403e-02f, 4.42616232e-02f, -1.17042344e-02f, 3.09516564e-02f, -2.53883470e-02f, 5.02529554e-02f, -1.27142429e-01f,
  5.60628548e-02f, -4.18844074e-02f, -3.74126844e-02f, 4.28081974e-02f, -3.52111645e-02f, 1.14996303e-02f, 1.12065576e-01f, -4.30307165e-02f, -1.42986700e-01f, 1.63553078e-02f,
  -9.51126888e-02f, 8.32613856e-02f, -2.46069685e-01f, 1.31866291e-01f, 1.02951946e-02f, 2.59678555e-03f, -1.60129264e-01f, 6.70310259e-02f, -2.51501743e-02f, -4.37873416e-02f,
  -1.21007729e+00f, -8.27083230e-01f, -2.00533226e-01f, -2.43639544e-01f, -1.11595154e-01f, -1.66192323e-01f, 1.25658929e-01f, -4.98769693e-02f, -1.77582234e-01f, 1.20911002e-01f,
  -3.27324979e-02f, 1.00441007e-02f, -1.46869808e-01f, 1.60477459e-01f, -1.43632099e-01f, -1.43957302e-01f, -2.86050253e-02f, -2.37451881e-01f, -1.96484238e-01f, -1.37571752e-01f,
  -1.51821494e-01f, 3.55143249e-02f, 1.36087507e-01f, -2.12286453e-04f, -3.17572057e-02f, -2.06699986e-02f, -2.66314596e-02f, 2.26994720e-03f, -4.04351167e-02f, -1.03574581e-01f,
  -4.05616283e-01f, -3.39308769e-01f, 4.07738268e-01f, -1.22764313e+00f, 2.10356638e-01f, 5.76793790e-01f, 9.35277268e-02f, -3.15368623e-01f, -1.05317175e+00f, -5.50020754e-01f,
  -2.87238479e-01f, -1.39384106e-01f, 5.66932380e-01f, -9.62871671e-01f, 9.76176023e-01f, 3.85830671e-01f, -7.15504706e-01f, -4.71382797e-01f, -2.07062498e-01f, -4.29996222e-01f,
  -3.05574834e-01f, -7.26431787e-01f, 3.18019450e-01f, -3.27183038e-01f, -3.21049094e-01f, -3.49258065e-01f, 1.56841725e-02f, 5.27206481e-01f, -3.77537012e-01f, 2.47383773e-01f,
  1.25886369e-02f, -4.35308963e-01f, 2.08897889e-02f, 5.43293590e-03f, 1.15101440e-02f, 1.65837497e-01f, 1.13471642e-01f, 3.31072748e-01f, -5.24978573e-03f, -1.54155970e-01f,
  -4.49630208e-02f, -3.33173163e-02f, -3.89315486e-01f, 2.97301292e-01f, -3.23602766e-01f, -2.73272902e-01f, 1.14196166e-03f, 3.21329036e-03f, -1.13733761e-01f, 1.29027516e-01f,
  2.24854704e-02f, 6.83008432e-02f, -2.03002408e-01f, -1.59318000e-01f, 7.49147311e-02f, -1.51959807e-01f, 1.38016462e-01f, 2.11009353e-01f, -6.41924068e-02f, -2.13017493e-01f,
  -5.96629232e-02f, 1.40661761e-01f, 4.01212834e-02f, -2.84352042e-02f, -6.60380125e-02f, 1.21144000e-02f, -3.76875661e-02f, 5.85929938e-02f, -2.20395196e-02f, 2.33125202e-02f,
  -1.51291832e-01f, -1.37717249e-02f, -1.65233895e-01f, -1.29380867e-01f, -8.62887874e-02f, -1.83814496e-01f, 1.71048790e-01f, 1.05727941e-01f, -1.80907577e-01f, 6.39824569e-02f,
  7.06765568e-03f, -1.69693958e-02f, -7.62823224e-02f, 8.68155882e-02f, 4.93444949e-02f, 7.07858102e-03f, -1.20419264e-01f, -2.62915809e-03f, 1.37063265e-02f, 2.11032763e-01f,
  -1.59177091e-03f, -2.59601593e-01f, -1.12506241e-01f, -9.55840275e-02f, 8.56294036e-02f, 3.66370268e-02f, 9.47704166e-02f, -1.89632118e-01f, -7.42967725e-02f, -1.16197495e-02f,
  -1.19578108e-01f, 7.58092059e-03f, -5.67999016e-03f, 2.60709077e-02f, 3.61591242e-02f, 1.46463335e-01f, 1.87101010e-02f, -1.54614195e-01f, -2.45178826e-02f, -2.83925664e-02f,
  -3.67117077e-02f, -1.41440034e-01f, 3.61786038e-02f, -2.55869538e-01f, -1.86881214e-01f, 5.93311414e-02f, -1.57429978e-01f, -7.24715926e-03f, 9.63501856e-02f, -1.07477710e-01f,
  4.01659846e-01f, -7.32886314e-01f, -3.56717676e-01f, -2.30564132e-01f, -1.42128021e-01f, -8.78930867e-01f, -6.62023365e-01f, -4.76628214e-01f, 4.83266205e-01f, -5.45938373e-01f,
  2.88706813e-02f, 1.21300466e-01f, 5.25066376e-01f, -5.48195541e-01f, 4.77182895e-01f, 5.78965604e-01f, -7.59669125e-01f, -4.87987339e-01f, 3.48525673e-01f, -3.07573736e-01f,
  3.52208138e-01f, -2.44633928e-01f, -1.25080459e-02f, -4.37378347e-01f, -2.97644705e-01f, 1.07018705e-02f, 3.27486871e-03f, 1.08361229e-01f, -5.77998519e-01f, 9.64703411e-03f,
  -9.38999951e-02f, 2.06059411e-01f, -1.95239559e-01f, 2.32866704e-02f, -1.93502247e-01f, -1.58155531e-01f, -6.80146217e-02f, 1.18620552e-01f, 3.35730702e-01f, 2.78592166e-02f,
  -9.23984963e-03f, 2.81381667e-01f, -2.32665345e-01f, 1.50689766e-01f, 5.48335947e-02f, -4.62159999e-02f, 3.43908258e-02f, -1.54684424e-01f, -1.83229595e-02f, 4.89213355e-02f,
  1.43014351e-02f, -4.77482304e-02f, 1.93459660e-01f, -1.44027807e-02f, 2.44283110e-01f, 1.73652768e-01f, -1.01063609e-01f, -6.64136782e-02f, -8.56684595e-02f, -1.42757848e-01f,
  -1.32931825e-02f, 1.12842396e-01f, 3.06692887e-02f, 9.23254937e-02f, 3.94292623e-02f, 7.78018031e-03f, 2.88015231e-02f, -1.27260312e-01f, 2.72569746e-01f, -7.21146092e-02f,
  -7.66415223e-02f, -8.59059989e-02f, 1.73377961e-01f, -4.41503190e-02f, -5.17220329e-03f, 1.52967453e-01f, -7.88892880e-02f, 5.44360504e-02f, 6.56066313e-02f, -1.86456397e-01f,
  1.31828085e-01f, 1.24323741e-01f, -1.14279263e-01f, -8.29323456e-02f, -4.35600020e-02f, 2.24052534e-01f, -7.09988453e-05f, 8.94400664e-03f, -6.88461075e-03f, 1.72105338e-02f,
  -8.98188800e-02f, -3.01934779e-01f, -1.40442103e-01f, -1.07305683e-01f, -2.05898672e-01f, -2.18970731e-01f, -1.31165951e-01f, -2.09450021e-01f, 2.04993300e-02f, -1.08853094e-02f,
  -1.77173421e-01f, -2.26089761e-01f, 1.39900044e-01f, 1.65296450e-01f, -7.51972720e-02f, -1.45902365e-01f, -1.04986899e-01f, -2.35556692e-01f, -1.02078654e-01f, -3.10336083e-01f,
  -1.57096222e-01f, -6.13836478e-03f, -2.07343511e-02f, -2.23821297e-01f, -2.11623311e-01f, -1.45630911e-01f, -8.32942221e-03f, 1.95256934e-01f, 1.42996430e-01f, 9.31484848e-02f,
  5.83195746e-01f, -1.08823134e-02f, -5.26583970e-01f, -1.69874042e-01f, 5.01473844e-01f, 4.15244967e-01f, 4.63745464e-03f, 2.42948681e-01f, -3.62046987e-01f, 3.27652693e-01f,
  2.97561198e-01f, -6.44341588e-01f, -4.71224904e-01f, 2.44611263e-01f, 1.25720054e-01f, -6.62752330e-01f, 6.08069777e-01f, 2.63413191e-02f, -1.13879487e-01f, 4.94451702e-01f,
  2.67150607e-02f, 7.32926726e-01f, -5.98088503e-01f, 3.61596495e-01f, 8.28290999e-01f, -1.43394828e-01f, 4.83785480e-01f, -2.13311404e-01f, 1.58476681e-01f, 8.08845088e-02f,
  -3.78167182e-02f, 2.11222731e-02f, -2.99339835e-02f, -2.50035256e-01f, 2.86799490e-01f, 2.14942604e-01f, -1.43671595e-02f, -2.63458967e-01f, -2.41166458e-01f, -2.62901634e-01f,
  -2.73180120e-02f, -5.05355708e-02f, -8.81616771e-02f, -1.28674224e-01f, 2.52692223e-01f, -2.76194923e-02f, -4.26965505e-02f, -8.85799434e-03f, -2.34241486e-01f, 8.48455206e-02f,
  -1.28058195e-01f, -8.95716473e-02f, 9.94352996e-02f, -5.49316332e-02f, -2.03270346e-01f, 2.87574958e-02f, -1.31520718e-01f, -1.33443270e-02f, 3.09743322e-02f, 1.31475702e-01f,
  3.03198963e-01f, 1.31759197e-01f, 1.06025606e-01f, -8.89283642e-02f, 7.65534565e-02f, 9.50837135e-02f, -7.12358952e-02f, 4.23269626e-03f, -8.30548853e-02f, 3.31941582e-02f,
  2.25402992e-02f, 6.15501702e-02f, -1.00308374e-01f, 5.61278276e-02f, 2.03497395e-01f, -6.16092570e-02f, -5.27913403e-03f, -2.65480522e-02f, 4.55425344e-02f, 1.49734225e-02f,
  -1.86862528e-01f, 1.59305289e-01f, -5.10841794e-02f, 6.03759326e-02f, -1.74955130e-01f, -5.09742498e-02f, 2.28855044e-01f, 5.22299856e-02f, -2.04584584e-01f, 1.74945384e-01f,
  2.88372040e-02f, 5.01219928e-01f, -1.28863931e-01f, -2.03212157e-01f, -9.99677703e-02f, 3.23120892e-01f, 2.70348862e-02f, 2.09716737e-01f, 1.81182567e-02f, 1.37835637e-01f,
  2.76645303e-01f, 5.26409708e-02f, 9.66506526e-02f, -8.12660828e-02f, -2.61630177e-01f, 3.71586055e-01f, -7.43581727e-02f, -1.82645276e-01f, 1.65723100e-01f, 2.62261391e-01f,
  1.98000968e-01f, 1.54878467e-01f, 4.62181792e-02f, 3.78154330e-02f, 1.14909045e-01f, 7.50658885e-02f, 1.33853912e-01f, -8.81243572e-02f, 1.28963053e-01f, -1.90917298e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  9.11478221e-01f, 6.34446025e-01f, 5.69280386e-01f, 8.08404863e-01f, 6.57061219e-01f, 7.54932463e-01f, 7.45816648e-01f, 6.22046649e-01f, 9.86087620e-01f, 5.79980493e-01f,
  1.12301159e+00f, 9.85077441e-01f, 4.29613560e-01f, 1.04536378e+00f
};

// L1_linear_W (Shape: 12 x 16)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 16;
const float L1_linear_W_data[] = {
  -9.14779902e-01f, -1.48126975e-01f, 6.69767261e-01f, -1.69143364e-01f, 7.27701187e-01f, -9.64103281e-01f, -9.50659990e-01f, 4.22490358e-01f, 5.71964264e-01f, 6.65112734e-01f,
  -6.21926665e-01f, -2.59613335e-01f, -1.00311148e+00f, -1.02145886e+00f, -5.73260605e-01f, -9.45714116e-01f, -3.77601013e-02f, -7.07560182e-01f, 1.41149871e-02f, -7.54720569e-01f,
  -7.10167050e-01f, -4.74502653e-01f, -4.21656996e-01f, 1.28930616e+00f, -1.30110967e+00f, 4.40361984e-02f, -8.95136595e-01f, -6.40429199e-01f, -1.31339145e+00f, 3.78850959e-02f,
  3.07565987e-01f, 1.20425820e+00f, 9.50699449e-02f, 4.30712551e-01f, -1.09615970e+00f, -7.22309768e-01f, 4.46836621e-01f, -6.58744335e-01f, -7.49963105e-01f, 5.93198001e-01f,
  -5.56796372e-01f, -9.93514955e-01f, -9.70037222e-01f, 9.94189620e-01f, 5.46233237e-01f, -6.89736545e-01f, -5.64961791e-01f, -2.09018335e-01f, 2.08795398e-01f, -9.43580389e-01f,
  -9.98946369e-01f, -3.52574825e-01f, 8.29107046e-01f, 5.11158168e-01f, 6.33172810e-01f, -6.42016709e-01f, 9.60988998e-01f, -6.66171074e-01f, -4.12968516e-01f, -1.33624423e+00f,
  -1.09820020e+00f, -3.17509055e-01f, 1.47504881e-01f, -1.11488760e+00f, 1.54510856e-01f, -2.28338897e-01f, -2.70497739e-01f, -8.42872262e-02f, 9.95309532e-01f, -5.97620249e-01f,
  8.17255318e-01f, -1.17497277e+00f, -7.98193812e-01f, 5.06195366e-01f, 4.43670675e-02f, 1.98289767e-01f, -4.58205819e-01f, 1.11626816e+00f, -8.61056745e-01f, -2.45128945e-01f,
  1.02318716e+00f, -8.28014016e-01f, -1.74226642e-01f, 1.30766368e+00f, -1.49859238e+00f, -5.98990381e-01f, 1.35526955e-01f, -8.68356880e-03f, -8.87664437e-01f, 7.06496775e-01f,
  8.49703014e-01f, -9.00978744e-01f, -6.82649240e-02f, -6.93608165e-01f, -1.20981967e+00f, -4.65129972e-01f, -3.72375697e-01f, 1.03193581e+00f, 8.31834495e-01f, -2.51800567e-01f,
  -7.53590286e-01f, -5.99014044e-01f, 8.47245157e-01f, -6.06283247e-01f, -4.77400720e-01f, -8.16822708e-01f, -1.04735613e+00f, -9.38704967e-01f, 9.62642670e-01f, -1.70711517e+00f,
  3.28009039e-01f, 2.50265747e-01f, -1.35477707e-01f, -1.64583102e-01f, -8.91498864e-01f, 2.61579365e-01f, -7.14050710e-01f, 3.09418827e-01f, -5.34187615e-01f, -4.00187731e-01f,
  -2.26868138e-01f, -1.01417407e-01f, -5.00107050e-01f, 7.79950693e-02f, -5.80272436e-01f, 5.94905376e-01f, 9.37738717e-01f, -8.10360849e-01f, -1.92008857e-02f, -7.61150241e-01f,
  -2.15464160e-01f, -6.22415841e-01f, -4.81693208e-01f, -8.84158015e-01f, 1.33810759e-01f, -1.21510291e+00f, -7.90591538e-01f, -4.96212363e-01f, 1.08022285e+00f, 8.08473110e-01f,
  -9.31245685e-01f, -8.51426125e-01f, -2.24950463e-01f, 5.79496920e-01f, 2.08709449e-01f, 2.27792636e-01f, 5.62674522e-01f, -9.90925133e-01f, -3.67804229e-01f, -8.67759049e-01f,
  -1.26758432e+00f, 1.22262582e-01f, -3.28154027e-01f, -5.95949352e-01f, 3.91500384e-01f, -6.62606537e-01f, 5.50277948e-01f, 1.15695608e+00f, 1.49432436e-01f, -1.15727818e+00f,
  -3.22098099e-02f, 9.74511504e-01f, -9.05472636e-01f, 1.87462643e-02f, -8.72814000e-01f, 2.20375329e-01f, -9.88224149e-01f, -5.01360357e-01f, 1.12136722e+00f, -8.52219284e-01f,
  -7.12227523e-01f, 4.93448198e-01f, -8.09788346e-01f, 7.98552260e-02f, -1.04728079e+00f, 4.85017240e-01f, -1.73188254e-01f, 7.66119361e-01f, 2.44914681e-01f, -3.60764533e-01f,
  2.89899170e-01f, 1.27877307e+00f, 1.04355123e-02f, -7.76091158e-01f, -8.82684588e-01f, -8.12768042e-01f, 8.97688568e-01f, -9.55074787e-01f, -3.00086796e-01f, -6.91763163e-01f,
  -7.50376880e-01f, -5.20306289e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -1.90887645e-01f, 1.38691843e-01f, -2.71472991e-01f, -4.91034865e-01f, -4.22049910e-02f, 4.72312987e-01f, 4.81365323e-01f, -4.29464191e-01f, 1.69030130e-01f, -3.46871555e-01f,
  1.18761603e-02f, 1.28775284e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 1, 14
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        16, 12
    );
    }
    