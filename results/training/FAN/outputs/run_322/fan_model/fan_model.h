/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 25 x 120)
const int L0_fan_Wp_rows = 25;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  4.10252094e-01f, 3.19556855e-02f, 7.85641223e-02f, 3.03258091e-01f, -3.25974487e-02f, -9.08989087e-02f, 8.90995376e-03f, 1.00209601e-02f, 1.52879834e-01f, -7.54247010e-02f,
  1.90319009e-02f, 1.93286240e-01f, -1.25881597e-01f, 2.60969073e-01f, 2.96789169e-01f, 4.52979170e-02f, 1.71136275e-01f, 2.83209048e-02f, 1.35524362e-01f, 3.80292088e-02f,
  1.10529758e-01f, 5.54041155e-02f, 7.06642270e-02f, -1.74570037e-03f, 6.66010976e-02f, 4.17699665e-02f, 2.47700233e-03f, -7.38397539e-02f, -9.54562740e-04f, 8.97638500e-02f,
  -9.06184390e-02f, -9.77471750e-03f, 7.12115914e-02f, -5.95591404e-02f, 5.93066588e-02f, -1.00672543e-02f, 3.10811922e-02f, 1.19603463e-01f, 5.68410084e-02f, -4.32586297e-03f,
  3.54881845e-02f, 2.29252484e-02f, 4.15073335e-02f, 4.16750759e-02f, 1.03087798e-01f, 1.73030924e-02f, -1.61430147e-02f, 7.99395442e-02f, 3.54785360e-02f, 4.65782769e-02f,
  -8.97558033e-03f, 5.86408712e-02f, -2.89618056e-02f, 2.42182203e-02f, -1.22862272e-02f, 1.23811467e-02f, 1.67904366e-02f, -2.30614133e-02f, -2.68063080e-02f, -1.03500681e-02f,
  2.11010221e-03f, 3.88446078e-02f, -2.02381145e-02f, 3.49623598e-02f, 7.36346915e-02f, -2.96201557e-02f, 2.86074504e-02f, -2.29405481e-02f, 3.49098966e-02f, 5.66070490e-02f,
  -3.64927687e-02f, -3.59040126e-02f, 4.83354833e-03f, -5.07217385e-02f, 6.28344491e-02f, -4.67045866e-02f, -4.90152696e-03f, -9.05290805e-03f, 4.83752117e-02f, 3.15205455e-02f,
  -1.52180046e-02f, 3.29969898e-02f, 5.63953593e-02f, -8.91783908e-02f, -7.01565295e-02f, -3.68618853e-02f, 8.94920826e-02f, 1.71025079e-02f, -1.06408529e-01f, -7.63861556e-03f,
  5.58483861e-02f, 6.49729893e-02f, -8.24933127e-03f, -2.13205405e-02f, -9.84163061e-02f, -4.24915589e-02f, 3.13646765e-03f, 2.25366428e-02f, -5.53034665e-03f, 7.07464442e-02f,
  -4.39381152e-02f, -1.31267561e-02f, -6.69428986e-03f, -3.43752876e-02f, -7.62638287e-04f, 3.28198113e-02f, -7.21562132e-02f, -4.52916510e-02f, -3.28920297e-02f, -2.14241594e-02f,
  1.21166771e-02f, -3.20919380e-02f, 1.00772670e-02f, -5.21897785e-02f, 2.11103112e-02f, -7.52203315e-02f, -4.93981652e-02f, 1.82151087e-02f, 9.32192313e-04f, 6.03745840e-02f,
  6.19862489e-02f, 2.34823860e-02f, -6.75408095e-02f, 5.75634688e-02f, 1.43285573e-01f, 3.27005357e-01f, 1.99822202e-01f, -1.22198835e-03f, 1.23833276e-01f, -7.08196908e-02f,
  -5.28692864e-02f, -1.09112471e-01f, -1.07494600e-01f, 4.68934029e-02f, 9.57300067e-02f, -3.55834626e-02f, 1.42503664e-01f, 2.62377970e-02f, 3.70744057e-02f, -6.60808608e-02f,
  -3.54557857e-02f, 1.09736070e-01f, -1.14000432e-01f, -6.84449226e-02f, 2.02831402e-02f, -1.26104206e-01f, -1.76336586e-01f, -1.34741753e-01f, -1.57585193e-03f, 3.99992988e-02f,
  1.31747514e-01f, -2.65086237e-02f, -6.60179332e-02f, 3.93424667e-02f, -8.91963392e-03f, 9.50636528e-03f, 3.46257016e-02f, -1.00544346e-02f, -4.71477285e-02f, -2.10757200e-02f,
  -1.10230027e-02f, -5.80822676e-02f, -3.46498303e-02f, -7.32008144e-02f, 2.81474926e-02f, 2.91910525e-02f, 4.36524227e-02f, -1.12419156e-02f, -7.31663406e-02f, -7.81214982e-02f,
  -3.93626317e-02f, -3.89177054e-02f, 4.28076647e-02f, 4.94535156e-02f, 1.88473370e-02f, -3.49981873e-03f, -3.09461802e-02f, 4.55614030e-02f, -1.26423920e-03f, 2.67520621e-02f,
  7.54253343e-02f, 8.68698284e-02f, -5.60445897e-02f, 1.46204103e-02f, -6.03857450e-02f, -1.72186934e-03f, -5.12304110e-03f, -8.51257816e-02f, 7.09048333e-03f, -5.44797741e-02f,
  9.82911297e-05f, -1.77977066e-02f, -1.74130686e-02f, 1.55623751e-02f, 4.35986882e-03f, 5.27841710e-02f, 4.56825225e-03f, 2.31741164e-02f, -5.73430024e-02f, -5.77658564e-02f,
  -1.05376214e-01f, 8.53897352e-03f, -1.75877344e-02f, -7.78236846e-03f, 6.57448024e-02f, 7.03400224e-02f, -3.30993384e-02f, 2.65129078e-02f, 7.80472672e-03f, 7.51168845e-05f,
  4.90741916e-02f, 1.93592384e-02f, -1.67247113e-02f, 2.43923459e-02f, -5.17866500e-02f, -3.89584862e-02f, -1.14700226e-02f, 6.29807413e-02f, -4.95405272e-02f, 4.10015807e-02f,
  3.64956968e-02f, -3.60754915e-02f, 1.20664872e-02f, 4.42223214e-02f, -6.15147594e-03f, 8.82413313e-02f, 3.83095518e-02f, -9.15358216e-02f, -1.71717666e-02f, 1.68402027e-02f,
  2.15835832e-02f, -5.58775151e-04f, 5.17370701e-02f, 7.59363398e-02f, 6.72608614e-02f, 2.30361931e-02f, 8.51436891e-03f, 4.62808535e-02f, 3.92640345e-02f, 2.60504708e-02f,
  -1.65748179e-01f, 1.31813258e-01f, -9.79872188e-04f, -3.19978446e-02f, 1.61745567e-02f, 7.31871650e-02f, 1.05575092e-01f, -1.05536105e-02f, -2.39481349e-02f, 8.58357847e-02f,
  -4.86986302e-02f, 1.11208275e-01f, 3.52741554e-02f, 6.62570000e-02f, -8.51579159e-02f, 6.69705346e-02f, 3.21665895e-03f, -1.93322264e-02f, 2.16480419e-02f, -9.79852676e-02f,
  8.54569604e-04f, -5.50664254e-02f, -6.88748285e-02f, -4.31734249e-02f, 9.87145957e-03f, 1.78055260e-02f, -7.96223208e-02f, -5.15778102e-02f, -1.10305481e-01f, -5.15603125e-02f,
  -4.58123386e-02f, 6.99126944e-02f, 4.93706726e-02f, -3.66204008e-02f, -2.91843023e-02f, 2.18912400e-03f, 5.08365501e-03f, 2.35127490e-02f, 2.07121242e-02f, 8.37618336e-02f,
  -6.44143149e-02f, 7.18996823e-02f, -9.17505752e-03f, 3.25850323e-02f, -2.50874623e-03f, 1.21479072e-02f, -8.52026604e-03f, -1.20970067e-02f, -1.35591095e-02f, 8.28002859e-03f,
  -5.14025195e-03f, -3.64058465e-02f, 3.94664109e-02f, 9.49346796e-02f, -5.08125462e-02f, 7.11144805e-02f, -1.33083146e-02f, -8.14757869e-02f, -8.08379147e-03f, -5.46507984e-02f,
  -7.07011148e-02f, 1.69492383e-02f, -5.77976694e-03f, -6.24776967e-02f, 3.29228118e-02f, 5.25809005e-02f, -5.42138703e-02f, 6.21566959e-02f, -9.76846218e-02f, 3.72852758e-02f,
  6.58956543e-02f, -2.76361983e-02f, -2.79931352e-02f, 2.66354289e-02f, -2.86667868e-02f, 5.84835969e-02f, -4.84041683e-02f, -6.26343349e-03f, -4.68314998e-02f, -3.30667906e-02f,
  4.14036810e-02f, 2.64047273e-02f, -8.01103711e-02f, -2.64829285e-02f, 8.46218169e-02f, 3.06524374e-02f, -7.82895759e-02f, 2.13483386e-02f, -2.03310009e-02f, -7.46326149e-02f,
  -5.70916459e-02f, 2.65800338e-02f, -6.77434877e-02f, -3.01222242e-02f, -2.15679780e-02f, -1.00561276e-01f, 1.56876985e-02f, -9.17758327e-03f, -8.09368491e-03f, -3.04197147e-02f,
  -7.17808753e-02f, 6.31835982e-02f, 5.47165386e-02f, -1.49135711e-02f, 3.00055984e-02f, 5.03131002e-02f, -8.24541692e-03f, 1.14409598e-02f, 5.07417927e-03f, 3.93648446e-02f,
  6.63367808e-02f, -4.48565781e-02f, 1.62990559e-02f, -6.51717465e-03f, -1.61133241e-02f, -5.84770776e-02f, -5.15770502e-02f, -2.01757532e-02f, -9.75549128e-03f, 5.80449915e-03f,
  -8.87508392e-02f, -2.94163488e-02f, 1.17392793e-01f, -1.14202455e-01f, 1.49134519e-02f, -7.90229142e-02f, 3.43665816e-02f, -9.74043757e-02f, 1.76120475e-01f, -4.27683517e-02f,
  -1.59067228e-01f, 1.58551678e-01f, 1.44998401e-01f, -2.15681139e-02f, 1.60520826e-03f, 7.53626823e-02f, -1.23951368e-01f, -4.23039459e-02f, 5.63247278e-02f, -3.24198715e-02f,
  -3.42149334e-03f, -8.72522369e-02f, -4.83178766e-04f, -1.50534451e-01f, -8.47943500e-03f, -6.11897521e-02f, -2.19591096e-01f, 7.32164783e-03f, -1.81941867e-01f, -2.99050449e-03f,
  1.81671549e-02f, 1.77974030e-02f, -3.19739282e-02f, 5.04157022e-02f, -3.56276035e-02f, 1.02517726e-02f, 1.07257934e-02f, -3.66956890e-02f, 4.09857072e-02f, 2.76790373e-02f,
  5.00627793e-02f, 9.15933475e-02f, 6.84595257e-02f, 5.99475391e-02f, 1.60055645e-02f, -8.83864705e-03f, 9.04592574e-02f, 9.03024711e-03f, -2.42283996e-02f, 7.99497515e-02f,
  -2.81936652e-03f, 8.83633923e-03f, 4.49988507e-02f, 2.69291811e-02f, 3.25966291e-02f, -4.18919586e-02f, 9.81868990e-03f, -3.43339294e-02f, -2.58697122e-02f, 3.31272520e-02f,
  -4.93926071e-02f, -2.27531251e-02f, 5.70420772e-02f, -8.87649413e-03f, -3.05073359e-03f, 5.12181707e-02f, 5.90534247e-02f, 2.62281541e-02f, -8.69509950e-02f, 2.44005434e-02f,
  -5.98289333e-02f, -7.48588592e-02f, -6.75514787e-02f, -4.74558435e-02f, 4.95654903e-02f, 4.83312421e-02f, -1.59479920e-02f, 6.38939366e-02f, 9.07051265e-02f, 7.17319176e-03f,
  -4.91650216e-02f, -1.98728628e-02f, -1.08987158e-02f, 3.75061408e-02f, 6.66026920e-02f, 4.02735695e-02f, 2.17512273e-03f, 5.89082055e-02f, 7.76687637e-03f, -8.25654566e-02f,
  -7.99934864e-02f, -1.63036853e-01f, 5.76273538e-02f, 7.47138187e-02f, -5.38996235e-02f, -9.98612344e-02f, 5.12119420e-02f, -1.06917704e-02f, -7.49574155e-02f, 6.07356988e-02f,
  -1.71845555e-02f, -7.23440796e-02f, -5.89212105e-02f, -4.09137346e-02f, -1.68803819e-02f, -5.75802242e-03f, -7.98113048e-02f, 2.23589800e-02f, -7.75313377e-02f, -1.13627084e-01f,
  -2.01676488e-02f, 5.88188767e-02f, 5.25635965e-02f, 5.35455607e-02f, -3.66557837e-02f, 7.23209307e-02f, -8.43875855e-02f, 7.90150166e-02f, -7.40983058e-03f, -4.89104874e-02f,
  -1.91792831e-01f, -4.39486057e-02f, -2.52260864e-01f, -6.36886433e-02f, -3.76983844e-02f, -6.70110583e-02f, -6.52349666e-02f, -9.09992680e-02f, -1.73356339e-01f, 9.92283821e-02f,
  5.41648939e-02f, -1.30167365e-01f, 1.36206076e-02f, 1.17863752e-01f, -1.27267152e-01f, 4.47199643e-02f, 1.65406370e-03f, -7.57915247e-03f, -9.72202420e-02f, -5.86857498e-02f,
  4.78339382e-02f, 1.94789559e-01f, -7.73729458e-02f, 9.91707295e-02f, -3.86905298e-02f, 6.16124384e-02f, 2.36566514e-01f, -1.09829092e-02f, 9.39744040e-02f, 1.61017776e-02f,
  4.33667190e-03f, -8.62722937e-03f, -4.32837382e-02f, 2.81366687e-02f, -3.92867737e-02f, -2.40492932e-02f, -3.31109315e-02f, 5.06976284e-02f, -5.63692674e-02f, -1.03655569e-02f,
  -1.07238572e-02f, 3.18723470e-02f, -4.42017615e-02f, 7.07412884e-02f, -8.78733397e-02f, -1.03672361e-02f, 6.59434870e-02f, -2.10027248e-02f, -4.81416769e-02f, -6.49345145e-02f,
  -2.84055620e-02f, 8.19763169e-02f, 7.18855113e-02f, -4.95950262e-05f, 3.53955664e-02f, 3.56055088e-02f, 6.21251799e-02f, 1.74992939e-03f, 4.33740877e-02f, -7.56378891e-03f,
  -6.04681969e-02f, -1.79987345e-02f, 3.61589864e-02f, -2.18435992e-02f, 6.28569126e-02f, 7.35438466e-02f, 9.90277454e-02f, 9.54349861e-02f, 6.77993521e-02f, 6.43773973e-02f,
  -4.90025617e-03f, -3.91767584e-02f, 3.59068066e-02f, -9.41211078e-03f, 1.01951808e-01f, -4.42715511e-02f, 1.03152089e-03f, -3.90675478e-02f, -7.32751340e-02f, 1.43914996e-02f,
  3.86658162e-02f, -5.69536127e-02f, 6.07639700e-02f, 5.29066250e-02f, 2.39929482e-02f, -3.99815012e-03f, 2.14929637e-02f, -1.64961889e-02f, 3.65550742e-02f, -2.09287996e-03f,
  7.38362223e-02f, 6.44410029e-02f, 3.49263512e-02f, 4.34554033e-02f, 3.97814102e-02f, -3.96176875e-02f, 4.93445881e-02f, 5.58045655e-02f, -1.35020977e-02f, -2.36048382e-02f,
  3.44393738e-02f, 3.46705206e-02f, -2.55479012e-02f, -9.55949351e-02f, -1.70517974e-02f, 7.13577718e-02f, -6.19128533e-02f, -2.47833028e-04f, 3.38001475e-02f, -4.97260801e-02f,
  -3.69204469e-02f, -2.90618204e-02f, 4.25685309e-02f, 1.94424465e-02f, 3.60031649e-02f, 1.03448607e-01f, -5.65391332e-02f, -2.02777255e-02f, 2.00961716e-02f, -1.80019923e-02f,
  -1.53248295e-01f, 8.34763646e-02f, -1.83802456e-01f, 8.96584988e-02f, 3.01222540e-02f, -5.25194332e-02f, -1.78539678e-01f, 9.62280706e-02f, -2.75941510e-02f, 6.73868731e-02f,
  -8.63448754e-02f, -1.84361875e-01f, -3.64278033e-02f, 9.33388472e-02f, -3.22213978e-01f, -1.51391760e-01f, -3.44775356e-02f, 2.97622364e-02f, -4.96277474e-02f, 1.59641892e-01f,
  6.16326444e-02f, 1.08707130e-01f, -3.91681306e-02f, 2.51461416e-01f, 2.30423734e-02f, 9.79488119e-02f, 3.59129310e-02f, 6.97623640e-02f, 1.80755574e-02f, 9.79409553e-03f,
  -5.91829456e-02f, 9.86162424e-02f, 6.29716069e-02f, -4.30633947e-02f, 1.77125148e-02f, 3.24283727e-03f, 6.97722957e-02f, -5.15291803e-02f, -8.59285984e-03f, -4.39014249e-02f,
  -5.50231747e-02f, 3.64515232e-03f, 3.50989066e-02f, 6.85924441e-02f, 7.14063346e-02f, -1.79648735e-02f, 2.23982092e-02f, -3.39746848e-02f, -5.20694703e-02f, -1.02419183e-02f,
  -7.43245557e-02f, -8.00843239e-02f, -4.45470586e-02f, -7.72619471e-02f, -5.40295430e-02f, 1.60650779e-02f, -2.92400680e-02f, -7.41886497e-02f, -3.40189785e-02f, -3.00481580e-02f,
  -3.22361733e-03f, -5.53731062e-03f, -2.70440858e-02f, -3.95320095e-02f, -3.98588553e-02f, -2.96049770e-02f, -4.24253121e-02f, -3.57498489e-02f, -7.20344717e-03f, -3.72459814e-02f,
  3.92315574e-02f, -4.66484614e-02f, 1.70991011e-02f, -2.52030976e-02f, 7.83334225e-02f, -2.87009124e-02f, -1.44544896e-02f, 3.78188789e-02f, 2.92918365e-02f, -3.41974087e-02f,
  -7.13597005e-03f, -1.35550378e-02f, -2.34562773e-02f, 3.98006439e-02f, 2.05453523e-02f, -7.27785900e-02f, 5.88549487e-02f, 2.72150282e-02f, 5.03022559e-02f, -8.28393549e-03f,
  -5.51888905e-03f, 7.66346678e-02f, -7.92128220e-03f, -6.04513101e-02f, -2.71344185e-02f, 1.32845864e-02f, -4.94331727e-03f, 3.76198292e-02f, -5.57198306e-04f, 6.91475794e-02f,
  4.57626395e-02f, -2.54982524e-02f, 4.99842465e-02f, 1.71882529e-02f, -1.06394654e-02f, -3.01249735e-02f, 3.86655964e-02f, -1.61699075e-02f, 2.88097914e-02f, -5.46770468e-02f,
  6.21538833e-02f, 2.21785400e-02f, -2.38131806e-02f, 5.38706817e-02f, 9.21716243e-02f, -6.42128140e-02f, -4.15200628e-02f, -1.60241779e-02f, 9.39952489e-03f, 3.04844510e-02f,
  2.44996604e-02f, 3.40423845e-02f, 7.36892298e-02f, 1.33392856e-01f, 3.14136520e-02f, -1.20355174e-01f, -1.91353306e-01f, 9.41185951e-02f, -9.48174894e-02f, 2.31013894e-02f,
  -1.86050255e-02f, 9.13019404e-02f, -2.72951871e-01f, -3.04581155e-03f, -2.01213434e-01f, -3.46356630e-01f, -8.14312603e-03f, -8.23657028e-03f, -7.88216218e-02f, 7.27446079e-02f,
  5.24895675e-02f, 1.45899400e-01f, 7.10125118e-02f, 2.15314180e-01f, 1.68544322e-01f, 2.41041735e-01f, 2.14539573e-01f, 2.25223843e-02f, 1.67388827e-01f, -9.72748920e-02f,
  -1.53831422e-01f, -7.29865059e-02f, 2.38285083e-02f, 3.55038350e-03f, 4.91854586e-02f, 1.02761813e-01f, -2.69500501e-02f, -2.65875403e-02f, -7.44752400e-03f, -4.94871289e-02f,
  -2.55380552e-02f, -4.94408309e-02f, 5.76271117e-02f, -6.25230893e-02f, 5.22635803e-02f, 1.57322325e-02f, 3.16149532e-03f, 3.17561999e-02f, 7.87105486e-02f, -5.66052422e-02f,
  3.36911567e-02f, -3.92994098e-03f, 9.53541026e-02f, 2.00915653e-02f, -1.64681561e-02f, -1.97232552e-02f, -1.36703439e-02f, -1.23416306e-02f, 2.22568656e-03f, 2.98018213e-02f,
  1.80743262e-02f, -2.50301287e-02f, -2.60500293e-02f, -1.00037390e-02f, -1.74715389e-02f, 1.99065655e-02f, 3.28217000e-02f, 1.87602192e-02f, -1.29836136e-02f, 6.37845919e-02f,
  -7.40526244e-03f, 7.13639520e-03f, 2.47929106e-03f, 4.89955656e-02f, 8.71264748e-03f, 6.56519905e-02f, 5.23441583e-02f, -1.04115363e-02f, -3.43653653e-03f, -1.04184831e-02f,
  6.58143032e-03f, 1.96585874e-03f, 5.92652522e-02f, 5.13577349e-02f, 8.31553340e-03f, 2.84589510e-02f, -8.08472410e-02f, 5.23997657e-02f, -6.90067932e-02f, -1.08368769e-02f,
  1.01034977e-01f, 1.16168797e-01f, 3.14326305e-03f, 5.59411310e-02f, 2.91147605e-02f, -9.62031540e-03f, 4.47622500e-02f, -2.20216205e-03f, 1.30989300e-02f, 2.52157040e-02f,
  8.40794891e-02f, 2.11959379e-03f, -2.08115578e-02f, 3.81720699e-02f, -2.69843377e-02f, 1.58015471e-02f, -3.88304591e-02f, 3.49401496e-02f, 4.65917215e-02f, 2.45103594e-02f,
  7.61655644e-02f, 6.55602012e-03f, -7.83119909e-03f, 1.85078039e-04f, 9.91788954e-02f, -4.61437367e-02f, 4.91458960e-02f, 2.61383355e-02f, -2.01637987e-02f, 3.75388004e-02f,
  4.62427326e-02f, -9.51605663e-02f, -1.88835204e-01f, 4.53216620e-02f, -4.87989560e-02f, -7.51891434e-02f, -1.44805104e-01f, -1.44565897e-03f, -1.79992646e-01f, 2.16519445e-01f,
  4.56154756e-02f, -4.59636524e-02f, 2.25022156e-02f, 1.47522628e-01f, 3.72979082e-02f, 8.19308013e-02f, 6.62531406e-02f, 7.94092044e-02f, -1.08634263e-01f, -5.22860326e-03f,
  1.52837439e-02f, 2.18143329e-01f, 1.29090935e-01f, 8.23223069e-02f, 1.16893813e-01f, -8.99842083e-02f, 2.58005708e-01f, -1.55107811e-01f, 1.54200271e-01f, 1.15944773e-01f,
  -5.06221838e-02f, 1.07825570e-01f, -7.89791420e-02f, -8.94416030e-03f, -3.93791795e-02f, -4.68294509e-02f, -2.67046504e-02f, -6.46237209e-02f, -7.49323890e-02f, -5.52716367e-02f,
  4.53637205e-02f, -1.02137681e-02f, 5.15912920e-02f, -1.35266781e-02f, -8.48357305e-02f, -3.77047546e-02f, -3.21033644e-04f, -7.34596327e-02f, -2.51108371e-02f, 2.73447391e-02f,
  -1.01303108e-01f, 2.34334227e-02f, 3.80633250e-02f, 2.53960788e-02f, -5.09062894e-02f, -1.58572420e-02f, 2.45375801e-02f, -3.42276767e-02f, 3.16279382e-02f, -6.06644563e-02f,
  4.91275191e-02f, 9.38186981e-03f, 5.47793917e-02f, 5.93093336e-02f, 3.87522578e-02f, -2.19485234e-03f, 7.80221373e-02f, -2.36572679e-02f, -4.63952422e-02f, 3.07122106e-03f,
  -9.64399707e-03f, -1.56075452e-02f, -2.10954454e-02f, -3.70523296e-02f, -2.19226927e-02f, 7.62713701e-02f, -3.31119709e-02f, -2.03374960e-02f, 3.89620401e-02f, 2.95561994e-03f,
  5.85475471e-04f, -4.49736379e-02f, 1.14909820e-02f, 1.49530293e-02f, -1.54255107e-02f, 2.56134439e-02f, -9.56171006e-03f, 3.36273871e-02f, 1.27810594e-02f, -4.53268215e-02f,
  6.47284016e-02f, 3.41414586e-02f, -3.30719315e-02f, 3.22264805e-02f, -2.98995357e-02f, 8.94291922e-02f, 1.19887898e-02f, 4.92348755e-03f, -5.77003174e-02f, 1.68403573e-02f,
  5.83807975e-02f, -2.19325237e-02f, -3.56391892e-02f, 4.29873578e-02f, -5.36692217e-02f, 1.40345218e-02f, 3.31522664e-03f, 1.97516307e-02f, 6.98817149e-02f, 2.73540523e-02f,
  4.39984314e-02f, -1.85225680e-02f, -2.21270192e-02f, -4.77226973e-02f, 8.89827162e-02f, 2.67174859e-02f, -6.97046285e-03f, -5.13341986e-02f, 4.30668704e-02f, -5.07285036e-02f,
  -1.03253787e-02f, -2.67302841e-01f, 4.78913486e-02f, -1.01003364e-01f, 1.72493920e-01f, 2.61592478e-01f, 1.72146410e-01f, 5.00064194e-02f, -6.89837858e-02f, -9.55376625e-02f,
  9.78519171e-02f, -1.77722067e-01f, 5.27643133e-03f, 4.36002947e-02f, 2.16915101e-01f, -3.71626318e-02f, 4.46041860e-02f, -5.35474624e-04f, -4.24868464e-02f, -8.99989903e-02f,
  3.42196003e-02f, 3.66032049e-02f, 1.65917680e-01f, 2.98765413e-02f, 3.15301716e-02f, -1.42158449e-01f, 5.94957806e-02f, 3.99123132e-02f, -3.19849513e-02f, 3.93676609e-02f,
  1.37273178e-01f, -9.56999436e-02f, 4.42819670e-02f, 4.66281213e-02f, 1.15338616e-01f, 6.81134164e-02f, -8.42651993e-04f, 7.43558630e-02f, 5.30223548e-03f, -2.72984598e-02f,
  -5.60889691e-02f, -1.41572542e-02f, -9.84835904e-03f, 7.46893212e-02f, 3.30705456e-02f, 2.38116309e-02f, -2.22442057e-02f, -7.96953775e-03f, -2.27441825e-02f, 1.03911027e-01f,
  5.31922141e-03f, 4.92909215e-02f, 4.86243963e-02f, 2.37389840e-02f, 4.88264896e-02f, 1.70380399e-02f, -2.67216228e-02f, 1.95740983e-02f, 4.39944565e-02f, -2.94160452e-02f,
  7.53800422e-02f, -3.48662175e-02f, 1.06783984e-02f, -7.09776580e-02f, -4.26729443e-03f, 4.01033871e-02f, 1.96693186e-02f, -2.65608188e-02f, 2.27050576e-02f, 2.32950374e-02f,
  4.15661149e-02f, -2.12456286e-03f, -5.31275086e-02f, 5.95518537e-02f, -7.79527985e-03f, 2.16410067e-02f, 4.19169664e-02f, -3.19812782e-02f, 1.77337565e-02f, 4.49091420e-02f,
  3.15165482e-02f, 8.95884540e-03f, 1.62366256e-02f, 7.54487962e-02f, 1.16863130e-02f, -1.75737478e-02f, 1.14625655e-02f, 8.13876241e-02f, 1.69773940e-02f, 2.62177344e-02f,
  -1.12654760e-01f, -2.10540146e-01f, -8.22294429e-02f, -2.79698186e-02f, -8.53872746e-02f, 4.76815924e-02f, -3.48543040e-02f, -3.93232256e-02f, -1.39461877e-02f, 7.11644292e-02f,
  8.53348374e-02f, 6.95934445e-02f, -4.97246534e-02f, -5.63232265e-02f, -2.21440452e-03f, 4.64033782e-02f, -6.58832565e-02f, 2.18155384e-02f, 2.69733276e-02f, -1.14307813e-02f,
  -4.03980054e-02f, 1.04696658e-02f, -1.87101811e-02f, 3.46702635e-02f, 1.80294029e-02f, 6.07360713e-03f, -6.21127300e-02f, -7.46165588e-02f, -6.96384534e-03f, 7.38593265e-02f,
  5.56672961e-02f, -3.42035927e-02f, -1.01025976e-01f, 5.87831847e-02f, -2.18797982e-01f, -6.40137196e-02f, 7.41836354e-02f, -1.73869044e-01f, 1.09156288e-01f, 2.06584111e-02f,
  5.82831167e-02f, 7.65350163e-02f, 1.97964534e-01f, 6.21684082e-02f, 9.56338793e-02f, 1.79378301e-01f, -1.57988537e-02f, 1.06713556e-01f, -5.90090156e-02f, -2.65864767e-02f,
  -3.21172352e-04f, -7.07055256e-03f, -2.48950981e-02f, -1.03368767e-01f, -1.50055394e-01f, -9.51199010e-02f, 9.27779078e-02f, -1.03804655e-01f, -1.31848201e-01f, -2.95822602e-02f,
  -5.66013493e-02f, 1.79386809e-02f, -1.00658588e-01f, -2.75119562e-02f, -1.18508041e-02f, -6.34157611e-03f, 4.21040840e-02f, 5.07021183e-03f, -3.03181205e-02f, 4.70352694e-02f,
  2.46818941e-02f, -4.62390147e-02f, -5.53666949e-02f, 2.03719027e-02f, -2.21973341e-02f, -1.06185272e-01f, -3.45320106e-02f, -2.09648092e-03f, -3.32852043e-02f, -4.20257263e-02f,
  -1.36118149e-03f, -1.73034556e-02f, -8.95922184e-02f, -1.52147701e-02f, -5.55395409e-02f, -3.17698568e-02f, -5.70775419e-02f, 7.34597743e-02f, 9.76180751e-03f, 3.12188193e-02f,
  2.51580421e-02f, 3.17942910e-02f, 3.22573818e-02f, 7.62541546e-03f, -1.43097248e-02f, -3.73132415e-02f, 3.13422792e-02f, -1.96950417e-02f, 3.98130566e-02f, 3.99172753e-02f,
  3.63926664e-02f, -1.76630430e-02f, -7.47407973e-02f, 6.65773973e-02f, -1.78739130e-02f, 3.07329390e-02f, 2.65811533e-02f, 1.18023129e-02f, -8.61971378e-02f, -8.57922435e-02f,
  2.60676760e-02f, -1.93327721e-02f, 2.82261539e-02f, -7.96767045e-03f, -6.75907964e-03f, 1.23183066e-02f, -3.23659219e-02f, 1.91803295e-02f, -8.60330183e-03f, -1.25712128e-02f,
  4.93647158e-02f, 1.63775101e-01f, 8.47930685e-02f, -3.35279927e-02f, 6.31876737e-02f, 4.33987528e-02f, -3.82332094e-02f, -2.75063924e-02f, 5.76474927e-02f, -2.88179200e-02f,
  -3.56527157e-02f, 2.60394849e-02f, 7.08182603e-02f, -5.61333522e-02f, 3.95775698e-02f, 4.51624021e-02f, -9.93366260e-03f, 1.46470824e-02f, -5.59808463e-02f, 4.23606439e-03f,
  2.02413369e-02f, 6.68481737e-02f, 4.94761690e-02f, 3.62730548e-02f, -1.31897721e-03f, -1.02251787e-02f, 1.91897713e-02f, -3.21177430e-02f, -7.55203888e-02f, 2.24367697e-02f,
  2.03499034e-01f, -2.71542490e-01f, -6.36588708e-02f, 1.76266849e-01f, 2.67745733e-01f, 8.18691850e-02f, 1.94529384e-01f, 5.35832942e-02f, -2.62599979e-02f, -1.34648278e-01f,
  1.23794243e-01f, -1.89779595e-01f, 2.81191431e-03f, -4.37881723e-02f, 1.39151022e-01f, -7.15924203e-02f, 6.74233139e-02f, 3.39149386e-02f, 2.12666988e-02f, 6.07806295e-02f,
  9.90060717e-02f, 2.04673409e-01f, 3.57486308e-02f, -2.99048182e-02f, 8.35590437e-02f, -3.68308462e-02f, 9.04594287e-02f, 1.78969745e-02f, -5.65752946e-02f, 1.11459540e-02f,
  1.57587100e-02f, -4.90746722e-02f, -3.55564393e-02f, -1.79933086e-02f, 7.65628740e-02f, 4.90959957e-02f, -2.93075544e-04f, -4.31420393e-02f, 4.75827605e-02f, -5.46550788e-02f,
  8.94219906e-04f, -1.02453522e-01f, 5.97346202e-03f, 1.93719324e-02f, 2.02441085e-02f, -1.34867185e-03f, -1.55300060e-02f, 4.68397699e-02f, 9.12847405e-04f, -7.03545436e-02f,
  -3.45610306e-02f, -8.62647295e-02f, -1.29316254e-02f, -1.04621530e-01f, -4.10109237e-02f, 2.20623072e-02f, 5.42358262e-03f, -1.71339158e-02f, -1.26446690e-02f, -4.32922170e-02f,
  -6.21040538e-02f, -7.18450993e-02f, 3.11535746e-02f, -2.81513967e-02f, -5.09900600e-02f, 6.16241507e-02f, 2.52307439e-03f, 7.15468749e-02f, -4.38262261e-02f, -5.29287271e-02f,
  3.61242238e-03f, -4.43897545e-02f, -2.59116217e-02f, 2.27922425e-02f, 4.57466207e-02f, -9.39706638e-02f, 4.16034367e-03f, 1.44391395e-02f, -9.92555916e-03f, -1.52531508e-02f,
  -5.79529293e-02f, -6.17131125e-03f, -4.50266935e-02f, 7.54126161e-02f, -8.22398737e-02f, -7.85649344e-02f, -2.65463106e-02f, -2.65460238e-02f, -2.21527275e-02f, 8.24989006e-02f,
  8.88409764e-02f, -9.77362157e-04f, 2.75742151e-02f, -1.30161578e-02f, -5.88157512e-02f, -6.69882223e-02f, 3.23570706e-02f, -3.10241356e-02f, 9.12161618e-02f, 6.48083612e-02f,
  1.31592248e-02f, 6.66676238e-02f, 3.94159026e-04f, 2.64121918e-04f, -5.08783534e-02f, -1.24102202e-03f, 1.35820821e-01f, -2.35937070e-03f, 2.63792071e-02f, 1.07841650e-02f,
  1.69657879e-02f, 4.96157557e-02f, 6.18768781e-02f, 3.57563049e-02f, 7.55460486e-02f, 2.86158212e-02f, -2.06801649e-02f, 3.76323797e-03f, 2.23877151e-02f, -4.35988717e-02f,
  5.31701185e-02f, -1.99385043e-02f, -4.02187492e-04f, -4.74544987e-02f, -6.83181956e-02f, 1.36355504e-01f, -4.42487448e-02f, -1.22321196e-01f, -1.04803018e-01f, -3.31248641e-02f,
  -1.04099624e-01f, -8.68063197e-02f, -1.28302574e-01f, 6.35462552e-02f, 1.73575640e-01f, 8.39653090e-02f, 1.21775314e-01f, 9.45238322e-02f, 1.15537331e-01f, -1.81879681e-02f,
  6.38206527e-02f, 1.05233878e-01f, 8.70086476e-02f, 2.41765883e-02f, -9.26395431e-02f, 1.08969556e-02f, -5.07494994e-02f, -1.12511769e-01f, -3.41334089e-04f, 8.99411440e-02f,
  5.73023930e-02f, -1.28350064e-01f, -6.55378997e-02f, -8.47112313e-02f, 8.45076516e-03f, 4.92346436e-02f, 4.15352918e-02f, -5.54358959e-02f, 3.75443101e-02f, -2.08404195e-02f,
  -9.41570401e-02f, 6.06199019e-02f, 5.25139570e-02f, 7.67025724e-02f, -4.61628148e-03f, 7.51919225e-02f, 2.61948723e-02f, 3.97870392e-02f, 2.14833338e-02f, -5.44219725e-02f,
  -1.42900841e-02f, -2.95998305e-02f, 3.50106955e-02f, 3.36271822e-02f, -2.58518327e-02f, -1.89252235e-02f, 9.63876955e-03f, -8.16189572e-02f, -2.82551665e-02f, -4.41184677e-02f,
  -1.27190342e-02f, 2.10044608e-02f, -5.88764856e-03f, 8.35677236e-02f, 9.82653908e-03f, 6.78540813e-03f, -7.92915672e-02f, 5.70555404e-02f, -4.52596880e-03f, 6.58745365e-03f,
  -5.75071499e-02f, 3.05294394e-02f, 5.84031902e-02f, -1.48775987e-02f, 6.37932196e-02f, -3.82800102e-02f, -6.22518696e-02f, 7.29632378e-02f, 4.96535674e-02f, 4.07246239e-02f,
  -7.81172812e-02f, -8.57930481e-02f, -3.33765373e-02f, -4.07803021e-02f, -1.29034845e-02f, -6.46770746e-02f, -5.72090223e-02f, -3.81031632e-02f, 1.32396603e-02f, 4.02071029e-02f,
  -6.58819405e-03f, -1.54310584e-01f, 1.67813171e-02f, 3.01920325e-02f, 1.89084765e-02f, 1.40944161e-02f, -1.47664677e-02f, -4.16112453e-04f, 4.43103611e-02f, -2.78368536e-02f,
  5.41335391e-03f, -1.53108314e-02f, -1.31821679e-02f, 7.81487487e-03f, 7.97889307e-02f, -5.73492274e-02f, -8.14659446e-02f, -3.51787992e-02f, 2.46891640e-02f, -5.39671779e-02f,
  -2.94693038e-02f, -5.65299988e-02f, 2.90677194e-02f, 6.03556558e-02f, 1.56075740e-02f, -1.64047740e-02f, 8.72586947e-03f, -4.51433100e-02f, 7.23692030e-03f, -3.79685014e-02f,
  -1.25992909e-01f, 7.23779015e-03f, 1.16986670e-01f, -1.22171178e-01f, -5.20273447e-02f, 4.84167114e-02f, -5.10574915e-02f, -7.81586468e-02f, -4.93720062e-02f, -9.33860093e-02f,
  -1.25821140e-02f, -3.95538099e-02f, -5.80542646e-02f, -5.95023371e-02f, -4.13085520e-02f, 6.08727708e-02f, -1.23760559e-01f, -4.56058383e-02f, 4.07457091e-02f, -6.42986223e-02f,
  -7.02709556e-02f, -3.03300396e-02f, 4.08655917e-03f, -9.62013900e-02f, 4.25509848e-02f, 2.68909261e-02f, -1.10423788e-02f, 4.30420190e-02f, -5.98314367e-02f, 1.12006091e-01f,
  3.59826558e-03f, -6.04122542e-02f, 4.25712019e-02f, -7.80739635e-02f, -1.07905954e-01f, 5.02631515e-02f, -4.10342105e-02f, 4.68003303e-02f, 9.65371802e-02f, -4.78264503e-02f,
  -2.43530329e-02f, -6.57920167e-03f, 2.75269933e-02f, 8.51849020e-02f, 3.23799774e-02f, -2.09006798e-02f, 4.94930334e-03f, 6.64688945e-02f, -5.41987233e-02f, 1.27469786e-02f,
  6.52862191e-02f, -3.43619995e-02f, -1.14393122e-01f, -7.64246657e-02f, 3.27603891e-02f, -3.28946710e-02f, 1.25475340e-02f, -2.57057585e-02f, -2.82842424e-02f, -3.50216292e-02f,
  -5.60133234e-02f, 2.48004086e-02f, 4.03720960e-02f, 8.40779301e-03f, 5.20120524e-02f, -4.26122472e-02f, 4.88765463e-02f, -5.98359816e-02f, -2.05310602e-02f, 2.94196084e-02f,
  -6.79380000e-02f, -8.62731773e-04f, 3.46287116e-02f, -8.85803625e-02f, -2.10393295e-02f, 7.10039735e-02f, 5.32365814e-02f, -1.13611771e-02f, -4.88887765e-02f, 3.93602401e-02f,
  -2.86647491e-02f, -7.04220906e-02f, -5.32354787e-02f, -3.36580500e-02f, -2.37415526e-02f, 3.02200969e-02f, -4.54667956e-02f, 3.42189968e-02f, -2.06793305e-02f, 3.21530679e-04f,
  -4.26773466e-02f, -2.41251528e-01f, 3.58417891e-02f, -9.47463959e-02f, 9.09552947e-02f, -7.23171607e-02f, 7.85696432e-02f, 5.49418032e-02f, -1.91430040e-02f, -4.87299562e-02f,
  -2.15744097e-02f, 1.13236122e-02f, -3.33150104e-02f, -4.38262708e-02f, 8.16178843e-02f, 1.26059577e-02f, -2.96187997e-02f, 3.52314557e-03f, 4.51239683e-02f, 6.48804381e-03f,
  -1.00950092e-01f, -2.38063037e-02f, 7.25169927e-02f, 5.40708490e-02f, -2.08227728e-02f, -4.66067083e-02f, -4.53916900e-02f, 3.56664024e-02f, 2.89319903e-02f, 4.11957614e-02f,
  -4.23134007e-02f, 1.38704076e-01f, 5.77336326e-02f, 1.26542717e-01f, 2.00434420e-02f, -2.10007161e-01f, -2.10884631e-01f, 9.52178836e-02f, 1.53628185e-01f, -1.23439012e-02f,
  -6.16347864e-02f, 5.73567254e-03f, -9.57340896e-02f, -1.30894095e-01f, -3.16719353e-01f, -4.70149331e-02f, -1.29580304e-01f, 3.25637311e-02f, 1.06995218e-01f, 6.93993345e-02f,
  8.56592283e-02f, -9.42999423e-02f, -1.44371852e-01f, -4.93095852e-02f, -1.01826407e-01f, 1.12725340e-01f, -2.61856988e-02f, -3.67344096e-02f, 2.24275850e-02f, 9.10550170e-03f,
  -1.23913497e-01f, 8.70907754e-02f, -1.95636153e-02f, -1.80568714e-02f, -4.80200052e-02f, -1.38833048e-02f, -8.60575438e-02f, -2.42840871e-02f, 4.80151176e-02f, -1.51501903e-02f,
  -1.04416460e-02f, -9.58206598e-03f, -8.61198381e-02f, 9.78109092e-02f, -9.03040078e-03f, 5.85928001e-02f, -1.15372557e-02f, -1.80354174e-02f, -3.60479653e-02f, 1.04288096e-02f,
  -7.24272653e-02f, -7.21887201e-02f, 8.16315934e-02f, 5.18693104e-02f, 1.97999366e-02f, -1.91407967e-02f, 4.81563713e-03f, -6.48845285e-02f, -1.17445029e-02f, -1.96276009e-02f,
  4.07480635e-02f, 2.82124355e-02f, -8.94008391e-03f, -3.99817564e-02f, 2.08925158e-02f, -6.51063845e-02f, 8.47920030e-02f, 6.13396894e-03f, 8.24296772e-02f, -7.56364688e-02f,
  -2.61335373e-02f, 5.51686175e-02f, -3.40967178e-02f, 1.54534783e-02f, 6.33952860e-03f, 1.89905912e-02f, 2.79213078e-02f, 1.84520781e-02f, 2.93249991e-02f, 2.08901186e-02f,
  2.77614612e-02f, 1.13561461e-02f, -3.26754786e-02f, -7.23581836e-02f, -5.17062545e-02f, -4.89701405e-02f, 6.03549592e-02f, 2.91177873e-02f, -1.81663912e-02f, 3.49546783e-03f,
  8.29663649e-02f, 1.52211949e-01f, 7.26555884e-02f, -1.17077613e-02f, -3.46433558e-02f, -2.55071539e-02f, 4.83727530e-02f, -2.93345340e-02f, 4.15015519e-02f, 3.80457304e-02f,
  1.40721612e-02f, 4.59824950e-02f, -1.45269912e-02f, -5.67121431e-02f, -1.15753636e-02f, -3.53306457e-02f, 3.97523642e-02f, 1.06370382e-01f, 5.51771410e-02f, 6.95879310e-02f,
  -9.09131765e-02f, 6.78805187e-02f, 1.20179425e-03f, 3.95513847e-02f, -7.41337100e-03f, 1.72673948e-02f, -6.80984333e-02f, 6.77943453e-02f, -4.61300984e-02f, 1.63338613e-02f,
  -1.38849661e-01f, -5.11945449e-02f, -6.75147623e-02f, -2.05346182e-01f, -1.77974984e-01f, 1.47332519e-01f, 1.84158981e-01f, -1.86803937e-01f, 4.56538126e-02f, 1.41047284e-01f,
  3.46096605e-02f, 1.04621165e-01f, 2.19605222e-01f, 3.10808001e-03f, 3.57320905e-02f, 2.08033860e-01f, 3.56180705e-02f, 2.02364195e-02f, -1.79766808e-02f, -3.16872820e-02f,
  -1.14355445e-01f, 1.10047376e-02f, 1.26725929e-02f, -1.60909086e-01f, -1.32668734e-01f, -2.94330090e-01f, -1.17922343e-01f, 8.56982730e-03f, -1.34341136e-01f, 1.91852897e-02f,
  3.86183001e-02f, 5.51861152e-02f, -1.19161107e-01f, 6.16035312e-02f, -3.83571200e-02f, 1.63221620e-02f, 6.07924238e-02f, 5.93929403e-02f, -2.34943721e-02f, 3.10969502e-02f,
  9.89796296e-02f, -6.91321641e-02f, -9.42620784e-02f, 7.16060912e-03f, 3.43248099e-02f, -1.14848791e-03f, -7.47096837e-02f, 2.28769779e-02f, 8.15609470e-03f, -1.20728025e-02f,
  -4.39555682e-02f, -6.64130375e-02f, 3.49413566e-02f, -8.46350845e-03f, -1.17234014e-01f, -9.61593762e-02f, 4.11150120e-02f, -4.25283946e-02f, -4.45233211e-02f, -1.11914083e-01f,
  7.07491860e-03f, -8.65258947e-02f, -3.55097316e-02f, -9.37666968e-02f, -2.93745864e-02f, -8.47443566e-02f, 3.07925697e-02f, -5.73606640e-02f, 4.25122306e-02f, 3.86879034e-02f,
  -5.84798679e-02f, 1.03036202e-02f, 8.79015401e-02f, -2.16320753e-02f, 3.08232978e-02f, -2.29722494e-03f, 2.83817369e-02f, 5.67728246e-04f, -2.18021963e-02f, -4.47381958e-02f,
  4.77955267e-02f, -4.27404279e-03f, 1.68068148e-02f, 8.61589331e-03f, 3.49890031e-02f, -7.88258240e-02f, 2.05293261e-02f, -4.69734706e-02f, -1.61199011e-02f, 7.84467831e-02f,
  2.05130190e-01f, 5.58049232e-02f, -6.32389188e-02f, 7.09516578e-04f, 4.82665077e-02f, -1.78947262e-02f, 5.17961010e-02f, -7.22345933e-02f, 6.24650531e-02f, 4.72359844e-02f,
  -5.32715209e-02f, -1.42488629e-02f, 3.53109464e-02f, 2.80198921e-02f, 1.81008736e-03f, -5.66794015e-02f, 4.71205264e-02f, 8.83723050e-03f, -1.82861257e-02f, -1.44582829e-02f,
  -1.86268426e-02f, 1.04025692e-01f, -4.79026176e-02f, -2.73165833e-02f, 6.52997103e-03f, -1.57263689e-02f, -5.56999296e-02f, 6.53609401e-03f, 3.09296011e-04f, 1.02436012e-02f,
  -1.11064613e-01f, 4.29307856e-02f, -2.21447065e-01f, -2.56312247e-02f, -2.88348068e-02f, 8.94342363e-02f, -7.27239326e-02f, -8.56945664e-02f, -9.04893205e-02f, 7.42709488e-02f,
  1.84285387e-01f, -1.58777803e-01f, 1.63150281e-02f, 1.10272668e-01f, 1.10117957e-01f, -3.87041923e-03f, 6.17793053e-02f, -4.83289212e-02f, -1.27662465e-01f, -3.33550870e-02f,
  -1.77923441e-02f, 2.26019979e-01f, 1.78790651e-02f, 8.33312199e-02f, 6.35286793e-02f, 5.63380606e-02f, 1.57710224e-01f, -1.26533687e-01f, 1.85495347e-01f, 1.42835723e-02f,
  6.07953519e-02f, -3.17041315e-02f, 2.95367762e-02f, -7.86498785e-02f, 5.56774624e-02f, -2.52441037e-02f, 2.05585603e-02f, 5.60716214e-03f, 4.53335755e-02f, 6.87591080e-03f,
  -5.93249351e-02f, 5.17452694e-02f, 9.68500227e-02f, -4.34749424e-02f, -1.14309816e-02f, -6.95741549e-02f, -2.51679979e-02f, 2.50979364e-02f, -4.88869622e-02f, -6.32478893e-02f,
  -5.99820539e-02f, -5.34113310e-02f, -5.11219166e-02f, 1.06091522e-01f, -1.85396541e-02f, -3.33226956e-02f, -5.66735789e-02f, 7.14813126e-03f, 2.25588996e-02f, 5.18225022e-02f,
  -2.63270456e-02f, 4.05087024e-02f, 4.09972854e-02f, 7.99219459e-02f, -2.54367404e-02f, 4.51695733e-02f, 6.25484437e-02f, 1.19059533e-02f, -4.11946885e-03f, 4.15169857e-02f,
  1.10597454e-01f, 7.13322125e-03f, -1.91848520e-02f, -1.12659387e-01f, -6.08958397e-03f, 4.35565785e-02f, 7.99082294e-02f, 8.89560580e-02f, 9.02263168e-03f, 6.22702297e-03f,
  3.14512439e-02f, 4.13074158e-02f, 5.18438034e-03f, -3.07335444e-02f, 2.30659414e-02f, -2.43954863e-02f, 4.18244191e-02f, -2.30514109e-02f, -8.49709138e-02f, 9.32103256e-04f,
  2.22116664e-01f, 1.92769766e-01f, 6.58970550e-02f, 2.51775049e-02f, 6.84171617e-02f, 4.64907177e-02f, 8.98991339e-03f, -9.77162570e-02f, 1.36927133e-02f, -4.74253844e-04f,
  5.91584016e-03f, 6.44906536e-02f, -1.98613741e-02f, 1.46895833e-02f, 3.73681821e-02f, -5.86921088e-02f, 1.69324856e-02f, 1.33574724e-01f, 9.10362527e-02f, 6.27250299e-02f,
  1.09103091e-01f, 3.90339382e-02f, 2.45418679e-03f, -5.90964733e-03f, 1.49133522e-02f, 2.87048686e-02f, -2.85003390e-02f, 1.33122718e-02f, 3.77469361e-02f, -3.90148461e-02f,
  2.68862039e-01f, -1.09645911e-01f, 8.83150697e-02f, 8.61205831e-02f, 1.03346340e-01f, -5.33940457e-02f, 6.87304437e-02f, 4.48777154e-02f, -1.00914277e-01f, -2.10601300e-01f,
  1.35141820e-01f, -1.70061004e-03f, -6.52365386e-02f, 8.30716267e-02f, 1.74747244e-01f, -1.42589793e-01f, 1.26713887e-01f, -2.51370948e-02f, -8.58225971e-02f, 1.26984090e-01f,
  1.30304396e-01f, 1.30924180e-01f, 6.58379793e-02f, 1.13039337e-01f, 2.42390949e-02f, 1.25287116e-01f, 1.51718378e-01f, 6.00031465e-02f, 1.24612629e-01f, 5.61970435e-02f,
  -2.71059256e-02f, -7.41324201e-02f, -4.08589020e-02f, -6.60687014e-02f, -3.11134402e-02f, 7.20390826e-02f, 6.51535532e-03f, 4.28518057e-02f, 7.39171430e-02f, -1.23302061e-02f,
  -1.15685547e-02f, 1.00886598e-01f, -3.81007195e-02f, 3.62726264e-02f, -8.15514252e-02f, -6.66168034e-02f, 2.49518566e-02f, 1.69997476e-02f, -6.51431158e-02f, 7.75081813e-02f,
  -3.91034931e-02f, -4.01711278e-02f, -1.89058185e-02f, -5.72448000e-02f, 4.19203043e-02f, -5.85936382e-02f, -4.46346179e-02f, -7.12040886e-02f, -6.60160258e-02f, 6.20513670e-02f,
  4.62149419e-02f, -5.22398129e-02f, 4.30415012e-02f, -4.78023924e-02f, -4.80063230e-04f, 5.84609248e-03f, 8.70115776e-03f, 3.37364301e-02f, -2.52371356e-02f, -1.62708126e-02f,
  -8.12914874e-03f, 2.67317984e-02f, -1.01255178e-02f, 8.61654337e-03f, 2.43777614e-02f, -5.41155785e-02f, 1.49911281e-03f, -4.49652504e-03f, -2.85318848e-02f, -6.04181029e-02f,
  1.79685168e-02f, -1.71773043e-02f, -4.55735885e-02f, 3.24844718e-02f, 1.87780857e-02f, 1.00999057e-01f, -7.45788263e-03f, -1.38300071e-02f, -1.96003746e-02f, 3.58873792e-02f,
  8.28910768e-02f, 5.44283278e-02f, -3.43416333e-02f, 4.32268940e-02f, -1.99421365e-02f, -2.68953163e-02f, -4.89624105e-02f, 2.61543598e-02f, -1.68485045e-02f, -2.04595961e-02f,
  8.18615407e-03f, -6.76407069e-02f, -3.05253509e-02f, 3.43666375e-02f, 3.84751298e-02f, 6.66674450e-02f, 1.02371210e-02f, -6.41251951e-02f, 5.49701601e-03f, 3.35568041e-02f,
  6.01000004e-02f, -3.02611999e-02f, 1.54680223e-03f, 3.22733112e-02f, 6.25393465e-02f, 2.80996524e-02f, 2.08790991e-02f, 5.62930144e-02f, 2.07670294e-02f, -4.04629447e-02f,
  -3.00527394e-01f, -8.36618170e-02f, 3.08288559e-02f, -6.75683394e-02f, -7.75189251e-02f, -6.76666796e-02f, -4.89142835e-02f, -8.76313597e-02f, 1.26389284e-02f, -9.55982506e-02f,
  1.86644588e-02f, -5.25496788e-02f, 1.24863341e-01f, 1.63658671e-02f, 1.12731457e-02f, 8.15333799e-02f, -1.98127434e-01f, 9.91389994e-03f, 2.06787512e-02f, -2.09611103e-01f,
  -1.43086491e-03f, -8.74761268e-02f, 2.00654238e-01f, -2.60033160e-02f, -1.32603034e-01f, 1.14779240e-02f, -1.08954914e-01f, 6.30915835e-02f, -3.77171002e-02f, 7.11773634e-02f,
  -7.60024339e-02f, 8.71597081e-02f, 8.19272548e-02f, 7.13203028e-02f, -1.45883843e-01f, -2.66564749e-02f, 1.86983831e-02f, 1.59126669e-01f, -2.98484531e-03f, -4.65541780e-02f,
  4.20319736e-02f, -7.13634640e-02f, 3.46774347e-02f, 2.52082758e-02f, -3.73810093e-04f, 9.29578207e-03f, -9.20284167e-03f, -1.38883386e-02f, 6.53508604e-02f, 3.32445875e-02f,
  -2.00148895e-02f, 1.55237122e-02f, -4.97463942e-02f, 3.73095982e-02f, 1.96107887e-02f, 5.19418940e-02f, 3.93614657e-02f, 8.34709480e-02f, 3.15004587e-02f, -2.28158515e-02f,
  6.13804758e-02f, -1.53479595e-02f, 3.52010876e-02f, 2.53521595e-02f, -7.15780854e-02f, -2.41484810e-02f, -4.75896373e-02f, -2.26898938e-02f, 4.30287719e-02f, -5.38884364e-02f,
  -4.35551703e-02f, 3.01767606e-02f, 1.17676053e-02f, -2.29886938e-02f, -3.98598947e-02f, -2.07232051e-02f, 1.02009904e-02f, -4.91006412e-02f, -1.71495005e-02f, -1.51453279e-02f,
  6.75294176e-02f, -2.38219444e-02f, 2.67282128e-02f, 2.31639966e-02f, 2.39010043e-02f, 7.32446313e-02f, -5.22759138e-03f, 9.22852010e-03f, -1.94042437e-02f, 5.64683825e-02f,
  -3.13873589e-01f, -1.03544138e-01f, -9.84903891e-04f, -2.58448124e-02f, 1.00877555e-02f, 3.80024761e-02f, -2.44584922e-02f, -5.40209897e-02f, 3.78720611e-02f, 6.08389787e-02f,
  -2.21406668e-02f, -4.71516605e-03f, -1.29580900e-01f, 6.10711332e-03f, -3.18810926e-03f, 4.36576316e-03f, 2.98009608e-02f, -7.52904415e-02f, -5.15625924e-02f, -4.55317460e-02f,
  3.95981893e-02f, -4.56070788e-02f, 6.73242100e-03f, -4.65313122e-02f, 5.94860539e-02f, -4.12264466e-02f, -5.77470884e-02f, 1.05695864e-02f, 1.18629327e-02f, 3.51607539e-02f,
  2.57212460e-01f, -1.81174129e-01f, 7.33039379e-02f, 1.87424287e-01f, 7.55825604e-05f, -8.96561667e-02f, -8.50385949e-02f, -5.07184565e-02f, -4.49806545e-03f, -3.02714795e-01f,
  -1.92515478e-02f, -2.48725954e-02f, -8.79343227e-02f, -1.13819860e-01f, 2.51662463e-01f, -1.14207372e-01f, -2.90720370e-02f, -9.31396261e-02f, 2.78922096e-02f, 4.68694232e-02f,
  1.70720324e-01f, -1.13771278e-02f, 2.44159922e-01f, 1.56572778e-02f, 8.42007846e-02f, 2.43962854e-02f, 8.04862007e-02f, 2.89465301e-02f, 3.93674485e-02f, 8.49839970e-02f,
  -1.49632134e-02f, 7.51701824e-04f, -1.91566953e-03f, 1.98454875e-02f, -9.12417471e-03f, -7.03043714e-02f, 1.02654686e-02f, 5.10495007e-02f, 6.95591122e-02f, -4.53457050e-02f,
  4.23750328e-03f, 5.91952354e-03f, 1.86830182e-02f, 6.36395067e-02f, 2.54690628e-02f, 5.82296848e-02f, 7.64305368e-02f, -4.86727320e-02f, -6.30578175e-02f, 1.65018216e-02f,
  2.79483590e-02f, -4.01422419e-02f, 5.88019639e-02f, -1.29467631e-02f, 3.08001526e-02f, -1.92757174e-02f, -1.23739382e-02f, 1.64313316e-02f, 5.42635620e-02f, -6.57142326e-02f,
  -6.81058541e-02f, 4.02096324e-02f, 8.16969052e-02f, 3.63574624e-02f, 3.66594940e-02f, -4.03982364e-02f, -7.10602198e-03f, 2.57291514e-02f, 4.66435738e-02f, 8.37483257e-03f,
  5.25784343e-02f, 4.12669070e-02f, 7.08815381e-02f, 3.46147716e-02f, -5.30720502e-02f, 3.82808708e-02f, 3.36937010e-02f, -2.31418223e-03f, -8.22643284e-03f, -6.74783764e-03f,
  -2.83742901e-02f, 7.11454228e-02f, -6.76960871e-02f, -3.73037942e-02f, 8.75210613e-02f, 8.02792907e-02f, -1.40741086e-02f, 1.87081341e-02f, 2.66140234e-02f, 2.07972135e-02f,
  -1.79659769e-01f, -1.61868364e-01f, 9.34288371e-03f, -1.11883953e-02f, 1.81276612e-02f, 4.48302031e-02f, -6.01338316e-03f, -7.25354627e-02f, -6.51541874e-02f, 3.48864347e-02f,
  -7.04199523e-02f, 7.58767873e-02f, -4.67852503e-02f, 1.67792644e-02f, 4.59774360e-02f, -9.15538222e-02f, -1.54704815e-02f, 7.32900277e-02f, 5.78010781e-03f, 1.60384774e-02f,
  -8.21301267e-02f, -9.43757687e-03f, -1.26518244e-02f, -1.64646730e-02f, -6.59818500e-02f, -4.90095699e-04f, -4.50175665e-02f, -3.02221440e-02f, -4.71527167e-02f, -4.83991541e-02f,
  -3.05852920e-01f, -7.38943815e-02f, -3.90252620e-02f, -1.90029129e-01f, 5.48096672e-02f, 1.79009929e-01f, 2.98126461e-03f, -8.85698199e-02f, -3.03545505e-01f, 1.33460611e-01f,
  1.53737515e-01f, -7.55519420e-02f, 4.52788025e-02f, 9.30687115e-02f, -1.04566634e-01f, -1.29233569e-01f, -4.03987728e-02f, -1.82130523e-02f, -1.04240507e-01f, 6.35378137e-02f,
  -8.02515671e-02f, 6.63259700e-02f, -1.55559415e-02f, 2.13957980e-01f, 6.12445213e-02f, -5.20891510e-02f, 2.41261702e-02f, 1.24878541e-01f, 9.71383899e-02f, 8.70752409e-02f,
  9.82228220e-02f, -1.96670461e-02f, -4.82749045e-02f, -3.93958949e-02f, 8.84416513e-03f, 1.02913804e-01f, 6.90723956e-02f, 7.31000751e-02f, 1.61239039e-02f, -7.13195875e-02f,
  -5.18584661e-02f, 9.59010869e-02f, -6.83132485e-02f, -3.52993794e-02f, -2.97881998e-02f, 3.82164270e-02f, -5.89159690e-02f, -4.44728658e-02f, -4.46662195e-02f, 3.06915212e-02f,
  1.00106383e-02f, 5.12376204e-02f, -7.55933225e-02f, -9.28622931e-02f, -3.70274074e-02f, -2.67180316e-02f, -5.34624159e-02f, 5.71768209e-02f, 1.93701056e-03f, -4.81599495e-02f,
  -7.59495469e-03f, 8.41445290e-03f, 2.53882762e-02f, 7.22415522e-02f, -1.40316971e-02f, -1.58083905e-02f, 1.56308282e-02f, 7.45377364e-03f, -1.66328363e-02f, 5.27670830e-02f,
  -4.87480126e-02f, -1.83557477e-02f, -1.38750188e-02f, -1.60627719e-02f, 1.49409799e-02f, -1.97068527e-02f, 4.07107063e-02f, 1.72529854e-02f, 5.62526239e-03f, -2.98198201e-02f,
  -3.36758345e-02f, 2.24752557e-02f, 2.26148777e-02f, 7.03823417e-02f, 6.40646964e-02f, -1.83956064e-02f, 5.17042615e-02f, -3.29031385e-02f, 5.51857650e-02f, -2.06248667e-02f,
  -1.78759620e-02f, -1.39146984e-01f, 4.08106782e-02f, 9.87390522e-03f, -5.35859503e-02f, -2.90611945e-02f, -2.72535905e-02f, 1.32428147e-02f, -7.89299831e-02f, 4.48132716e-02f,
  3.11932843e-02f, -7.55511075e-02f, 6.72401860e-02f, 2.52830721e-02f, 2.02829987e-02f, -1.74755789e-02f, -2.41163070e-03f, -3.83714028e-03f, 1.72934644e-02f, -5.45535050e-02f,
  1.16815502e-02f, -1.37552666e-02f, -1.60300117e-02f, 3.90586592e-02f, 6.91916980e-03f, -1.22830747e-02f, -8.83731693e-02f, 1.08735226e-02f, 3.14440322e-03f, 4.66407351e-02f,
  -4.47131336e-01f, 1.32027447e-01f, -2.47960687e-01f, -4.86367494e-02f, 8.20680801e-03f, 4.82512116e-02f, 1.32728610e-02f, -7.82908723e-02f, -1.06665447e-01f, 1.51198134e-01f,
  9.32438374e-02f, -9.10985991e-02f, -3.67909484e-02f, 7.90529326e-02f, -1.54025778e-01f, 3.31484783e-03f, 2.06440073e-02f, -3.62010598e-02f, 5.46294115e-02f, 4.44353521e-02f,
  -8.29689205e-02f, 1.67197138e-01f, -1.26812542e-02f, 2.33201876e-01f, 4.94034179e-02f, 2.73489822e-02f, -1.59077644e-02f, 5.82576655e-02f, 2.92885564e-02f, 3.00838780e-02f,
  -3.54111716e-02f, -2.41102297e-02f, -1.27120152e-01f, 5.82700968e-02f, -2.53459234e-02f, -7.22299591e-02f, -2.09335424e-02f, -3.93945836e-02f, -8.35643932e-02f, -2.42101550e-02f,
  6.48646429e-02f, -6.05696775e-02f, -2.60676630e-02f, -8.21050256e-02f, 5.82781807e-02f, -1.97557546e-03f, 6.00131378e-02f, 4.69727302e-03f, -3.01251523e-02f, 3.06809582e-02f,
  3.97902317e-02f, -3.73923331e-02f, -2.84589101e-02f, 4.07763422e-02f, 5.54097518e-02f, -6.63608173e-03f, -2.65579987e-02f, -7.60999173e-02f, -1.64897460e-02f, -1.03270672e-02f,
  1.19545087e-02f, 1.74967311e-02f, 1.60753541e-02f, -4.00006864e-03f, 3.66252437e-02f, 6.62586465e-02f, -1.92529839e-02f, 4.33157757e-03f, -1.36993527e-02f, 2.07230728e-02f,
  -3.46155800e-02f, 2.79856399e-02f, -2.98927911e-02f, 3.16924416e-02f, 4.66555990e-02f, 9.39544290e-02f, -2.27605421e-02f, 6.03946932e-02f, -6.12125807e-02f, 2.63982657e-02f,
  -1.95888989e-02f, 3.38597968e-02f, 5.16698733e-02f, 2.85568926e-03f, -3.52763049e-02f, 2.25811359e-02f, 3.35042141e-02f, 4.79567647e-02f, -1.13619659e-02f, -2.25559529e-02f,
  3.17894369e-02f, 4.61601317e-02f, 4.72521335e-02f, 6.71539083e-02f, 1.32818455e-02f, 1.60358660e-02f, -5.82451411e-02f, 4.21993919e-02f, 2.77722478e-02f, 1.75206643e-02f,
  -4.70616072e-02f, 2.42975559e-02f, 5.10738455e-02f, 2.83636563e-02f, -2.57345922e-02f, -1.66484024e-02f, 2.91074626e-02f, 6.30840436e-02f, -4.72356007e-02f, 6.07272945e-02f,
  8.86879340e-02f, -1.90123487e-02f, 5.25133535e-02f, 2.13317182e-02f, -2.03803703e-02f, -1.15986066e-02f, -3.38176936e-02f, 3.14532989e-03f, 5.21346405e-02f, -1.85426958e-02f,
  -5.22000611e-01f, -1.54629380e-01f, -1.04776628e-01f, -2.85894364e-01f, -2.63535269e-02f, -9.29072276e-02f, -9.13590342e-02f, -1.67895079e-01f, -3.06120455e-01f, -6.54476061e-02f,
  -4.58146352e-03f, -5.16004786e-02f, 1.29584298e-01f, -2.27124896e-02f, 1.10016145e-01f, 1.41363695e-01f, -2.10612610e-01f, -5.80321029e-02f, 7.21922219e-02f, -1.87719718e-01f,
  -4.16495465e-02f, 9.67468917e-02f, 1.28432348e-01f, 2.65273079e-02f, -1.60131991e-01f, -9.48755369e-02f, 1.07974850e-01f, 8.88396949e-02f, 2.83587594e-02f, 3.97155769e-02f,
  -3.17242835e-03f, -2.88808674e-01f, -8.82866159e-02f, -8.39946568e-02f, -1.98772289e-02f, -2.93966774e-02f, 1.19399885e-02f, 5.52568175e-02f, 3.81853543e-02f, -3.14606838e-02f,
  2.38145553e-02f, 1.25689162e-02f, -2.98835523e-03f, 2.53586285e-02f, -5.86708449e-02f, -6.96115196e-02f, 3.08977738e-02f, -2.18709465e-02f, 1.09793982e-02f, 5.69666401e-02f,
  3.27479988e-02f, 2.20908746e-02f, 1.19843765e-03f, -1.89503320e-02f, 3.50714847e-02f, -1.07574994e-02f, 1.72869340e-02f, 4.32326756e-02f, -2.84008868e-02f, -5.81329204e-02f,
  -1.15042820e-03f, 3.46727110e-02f, -5.37794344e-02f, -1.70320005e-03f, 4.82348315e-02f, -3.03407405e-02f, 8.50746632e-02f, 6.13617562e-02f, 3.25189568e-02f, 1.58268586e-02f,
  -2.54906854e-03f, -5.33066764e-02f, -1.15281092e-02f, -1.30716655e-02f, 1.51909040e-02f, -4.43649404e-02f, 1.84011506e-03f, -1.85031146e-02f, 3.44996266e-02f, -3.45059740e-03f,
  -2.04684231e-02f, 1.87309049e-02f, 1.65327489e-02f, -1.72157045e-02f, -1.18938116e-02f, 7.44574070e-02f, -4.00010236e-02f, -6.06677346e-02f, 4.92176972e-02f, 3.87099385e-02f,
  -1.29326925e-01f, -2.77159542e-01f, 2.10153013e-02f, -5.71550205e-02f, 8.89376104e-02f, 1.14953863e-02f, -6.64908737e-02f, -8.14691186e-02f, -7.22604617e-02f, -1.04178330e-02f,
  -2.71857437e-02f, -3.49445902e-02f, -5.98824546e-02f, -1.94308870e-02f, 2.43881531e-02f, -3.65362354e-02f, -1.58339739e-02f, -3.02002877e-02f, -6.16851710e-02f, -1.06947338e-02f,
  -5.43787591e-02f, -4.61090840e-02f, 9.20901522e-02f, -2.29867380e-02f, 3.22106481e-02f, -2.26036180e-02f, -1.19327724e-01f, -2.34041195e-02f, 1.55207543e-02f, 2.02132743e-02f,
  2.45694309e-01f, 4.90718074e-02f, -1.42155349e-01f, 2.83512741e-01f, -3.01068395e-01f, -1.04514107e-01f, 9.44723710e-02f, -1.63264778e-02f, 1.90861195e-01f, 4.35437001e-02f,
  4.97042462e-02f, -5.70939258e-02f, 8.19306672e-02f, 1.99766845e-01f, 4.32833165e-01f, 3.08264315e-01f, 2.24890783e-01f, 2.22310528e-01f, 1.47295259e-02f, 2.59736390e-03f,
  4.56799157e-02f, 8.94277841e-02f, 5.48988692e-02f, -2.25555614e-01f, -1.49783343e-01f, -1.90248311e-01f, 2.03758776e-02f, -1.91848725e-01f, 1.86352115e-02f, 5.29104052e-03f,
  4.51540649e-02f, 7.12514594e-02f, -1.19514965e-01f, -8.25358555e-03f, 2.89741550e-02f, -3.80366594e-02f, -3.22257616e-02f, -3.72489169e-02f, -6.09475514e-03f, -4.10474725e-02f,
  -2.59634741e-02f, -6.28152415e-02f, 2.17302386e-02f, -9.85194091e-03f, -2.54266132e-02f, -5.78138418e-02f, -1.00587368e-01f, -1.08205318e-01f, -8.28315988e-02f, -7.59204663e-03f,
  -2.46868376e-02f, -5.99999316e-02f, 7.97821023e-03f, 4.81573306e-02f, -3.38138342e-02f, -2.26298701e-02f, -4.28737961e-02f, 4.08119801e-03f, -7.43074119e-02f, 1.44124646e-02f,
  2.72167828e-02f, 8.72745819e-04f, -2.85817473e-03f, -1.31279882e-02f, 1.95918474e-02f, 2.56094486e-02f, -6.38481835e-03f, 3.88991907e-02f, -2.96367463e-02f, 5.27944863e-02f,
  3.10226344e-02f, 5.69986179e-02f, 3.31450887e-02f, -4.98064570e-02f, 2.36141123e-02f, 2.37910040e-02f, 1.04477108e-02f, -4.70462702e-02f, 1.96716078e-02f, 2.71447916e-02f,
  4.65570614e-02f, 2.52283402e-02f, 2.87449826e-02f, 7.75948958e-03f, 1.79703871e-03f, -2.13006809e-02f, -1.02164768e-01f, -8.48533064e-02f, 3.58348526e-02f, -3.28712463e-02f,
  1.03397802e-01f, 1.76597163e-01f, 5.76813966e-02f, -1.86203662e-02f, 2.19238941e-02f, -4.48777564e-02f, 9.93893296e-02f, 2.63119638e-02f, 4.72827740e-02f, 1.20698884e-02f,
  -1.34439394e-01f, -7.63111142e-03f, -2.42547821e-02f, -2.58268006e-02f, 6.66906312e-02f, 9.61775333e-02f, 9.65326428e-02f, 5.45683876e-02f, 2.81203203e-02f, -1.09825730e-02f,
  -3.78008708e-02f, -6.13388345e-02f, -1.20270313e-04f, -7.48259202e-02f, -7.77089596e-03f, -1.28570525e-02f, 3.71710397e-02f, 4.83599771e-03f, -5.61837060e-03f, -7.50349555e-03f,
  -4.03042406e-01f, 1.41836796e-02f, -4.63267006e-02f, 1.69781446e-02f, 6.96251094e-02f, 1.57069534e-01f, 1.50641993e-01f, 1.02236658e-01f, -1.97808091e-02f, 1.81147754e-01f,
  7.09108710e-02f, -9.19133425e-02f, -2.53618648e-03f, 1.26654143e-02f, -2.54310239e-02f, 5.13168145e-03f, 1.84140697e-01f, 8.35625157e-02f, 1.58334915e-02f, -2.03318149e-02f,
  -6.56047314e-02f, 7.72300065e-02f, -5.40270060e-02f, -2.96590924e-02f, 4.18999754e-02f, -4.62816656e-02f, 8.32450911e-02f, -7.98838586e-02f, 4.44646701e-02f, -3.50542776e-02f,
  1.72308702e-02f, -2.68170796e-02f, 2.66381521e-02f, 2.86993552e-02f, -3.90850101e-03f, 1.79198552e-02f, -4.70280871e-02f, -2.40182132e-02f, -2.91648339e-02f, 3.88843752e-02f,
  -3.49590257e-02f, -8.91934708e-03f, 7.11682215e-02f, 3.75439338e-02f, 1.71757601e-02f, -8.22745934e-02f, 3.80767696e-03f, 6.38857633e-02f, 1.80199742e-02f, 5.18620834e-02f,
  4.14290279e-02f, -5.21663651e-02f, 5.21886162e-02f, 7.29777589e-02f, 4.62451368e-04f, 4.68561463e-02f, 9.96212363e-02f, 1.84890740e-02f, -6.17509335e-03f, 1.15999971e-02f,
  -7.58451894e-02f, -1.71896815e-02f, 3.43807824e-02f, 1.25120049e-02f, 7.47784926e-03f, -6.64638914e-03f, -1.42423036e-02f, 4.66215424e-02f, -4.90608439e-02f, -6.14124201e-02f,
  -4.96348776e-02f, 3.07416841e-02f, 2.44731195e-02f, 7.32825473e-02f, 6.85332939e-02f, 6.07070439e-02f, -5.93128800e-02f, 4.15383801e-02f, -4.28997958e-03f, 8.54139104e-02f,
  5.20298183e-02f, -5.02767824e-02f, 6.20355904e-02f, 8.38824175e-03f, 8.47813413e-02f, 1.61755867e-02f, -1.15426546e-02f, 7.29531571e-02f, -4.25476627e-03f, -2.60647386e-02f,
  2.06077993e-01f, 2.79504564e-02f, -3.31813209e-02f, -7.10473657e-02f, -2.66373809e-02f, -3.10329348e-02f, -2.99539845e-02f, -3.23549621e-02f, 1.83669664e-02f, 3.60830575e-02f,
  8.34433176e-03f, 5.40242083e-02f, 5.86138107e-03f, -2.32815724e-02f, 5.43609597e-02f, 7.61556774e-02f, -4.32142504e-02f, -9.54610668e-03f, 1.06497124e-01f, 4.56261169e-03f,
  -3.12040206e-02f, 6.58120811e-02f, -9.09662247e-02f, -5.05537540e-02f, 5.35121448e-02f, 8.85498226e-02f, 6.55168993e-03f, 4.35204916e-02f, 8.02947208e-04f, 3.84914465e-02f,
  2.61511430e-02f, 2.06777364e-01f, 4.20298763e-02f, 4.37583365e-02f, 1.87370405e-01f, 3.34438592e-01f, 2.52109408e-01f, 9.82490033e-02f, 2.18496677e-02f, -9.43999679e-04f,
  -6.28758967e-03f, 9.05274451e-02f, -1.73632540e-02f, 9.94008109e-02f, -1.57315880e-02f, -3.62343229e-02f, 1.14201576e-01f, 6.32480308e-02f, 3.94519120e-02f, 6.05203956e-02f,
  -7.33385906e-02f, 9.63600129e-02f, -1.49400057e-02f, 4.41425256e-02f, 1.30561262e-01f, -4.28179689e-02f, -1.38890028e-01f, 2.52198782e-02f, 1.00257851e-01f, 7.00944811e-02f,
  7.77831748e-02f, 3.02373711e-02f, -2.50975788e-02f, -7.77176842e-02f, 1.58085264e-02f, 7.99606144e-02f, -1.62116494e-02f, 8.09628330e-03f, 1.98262520e-02f, 2.51504872e-02f,
  4.07145061e-02f, 7.26572191e-03f, 1.03237843e-02f, 5.61235799e-03f, 6.40499592e-02f, -1.52230524e-02f, -1.16804671e-02f, -4.43612710e-02f, -3.27771679e-02f, -3.65843102e-02f,
  3.00834682e-02f, 1.07504912e-01f, -3.11108446e-03f, -5.57822250e-02f, 6.66904375e-02f, -4.47730310e-02f, 7.69609660e-02f, -8.18051323e-02f, 7.10540414e-02f, 1.86523143e-02f,
  7.16527700e-02f, 4.42694128e-02f, 5.88581264e-02f, -4.65598479e-02f, 4.09928411e-02f, 1.99224576e-02f, -5.52604906e-02f, 1.58670247e-02f, -5.26936427e-02f, 1.26903374e-02f,
  -4.59178537e-02f, 4.62399200e-02f, 2.23620068e-02f, -6.97854906e-02f, 7.22462195e-04f, -7.81440586e-02f, -1.67445578e-02f, -8.79674312e-03f, 7.61115253e-02f, -2.46627983e-02f,
  -6.28134534e-02f, 7.09467232e-02f, -6.69350401e-02f, 4.51247431e-02f, -7.05989636e-03f, -2.07020137e-02f, -2.31043100e-02f, -5.73907793e-02f, -3.25547755e-02f, 2.12099757e-02f,
  4.99308333e-02f, 1.36434648e-03f, 3.85188945e-02f, 2.48560496e-02f, 1.29624493e-02f, 5.36578260e-02f, 6.96011260e-02f, 6.97169229e-02f, 8.01702812e-02f, 8.86075050e-02f,
  -7.78245330e-02f, -6.42228648e-02f, 3.41027528e-02f, 1.73751658e-04f, -6.77712411e-02f, 3.19920965e-02f, -3.48101277e-03f, 5.38562909e-02f, -2.12948266e-02f, -3.11448071e-02f,
  3.78051959e-02f, -5.31711206e-02f, -3.43357660e-02f, 2.18637679e-02f, -5.97125888e-02f, 1.04110176e-02f, -6.03233352e-02f, 2.11911947e-02f, 2.26773955e-02f, 1.53323021e-02f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  2.09753141e-01f, 1.69199869e-01f, 7.19497502e-02f, 1.40591070e-01f, -4.18591164e-02f, -1.28288910e-01f, -1.04493514e-01f, -3.52542028e-02f, 1.92255378e-02f, -2.28610635e-03f,
  -1.34819718e-02f, 1.47520900e-01f, 1.15483582e-01f, 5.12726940e-02f, 3.75038944e-02f, -2.53357068e-02f, -5.28280484e-03f, 7.12252557e-02f, -2.79150400e-02f, 1.07647799e-01f,
  1.04789644e-01f, 2.78086420e-02f, 1.46549612e-01f, -2.15849075e-02f, 5.48847802e-02f, 1.30577207e-01f, 1.69100706e-02f, -1.61642823e-02f, 1.10990591e-01f, 9.64852702e-03f,
  -2.98607652e-03f, 2.67354753e-02f, 7.60213658e-02f, 9.10179093e-02f, -3.46123986e-02f, -1.69109721e-02f, -5.79091571e-02f, -8.57367143e-02f, 1.19995642e-02f, 5.90951443e-02f,
  -4.12348062e-02f, 4.27527539e-02f, -3.24100326e-03f, -4.11981083e-02f, -1.28537249e-02f, -3.96854319e-02f, -1.78206898e-02f, 3.73961491e-04f, 2.34487969e-02f, 2.40840809e-03f,
  1.03345171e-01f, 5.68952225e-02f, 5.81656641e-04f, 7.52710626e-02f, 1.28120840e-01f, 2.57698186e-02f, 2.33105477e-02f, 7.00001195e-02f, 5.86114675e-02f, -2.46204473e-02f,
  2.30742656e-02f, -2.65380554e-02f, -3.75415310e-02f, 7.66962171e-02f, 3.64071392e-02f, -6.15288615e-02f, -4.66002934e-02f, -6.29302561e-02f, -5.14834151e-02f, -5.16672134e-02f,
  -1.50431627e-02f, 8.97855498e-03f, -1.19214626e-02f, -4.19823192e-02f, 4.09724824e-02f, -6.37663007e-02f, 1.73818246e-02f, 5.70530817e-02f, 9.41789895e-02f, -1.91737525e-02f,
  -2.34436430e-02f, -3.43189575e-02f, -1.34189231e-02f, 5.68251535e-02f, 7.01277554e-02f, -3.14441063e-02f, -4.80100662e-02f, -9.40411445e-03f, 7.52483830e-02f, -4.99318391e-02f,
  -3.99263538e-02f, 1.62432138e-02f, 1.50945205e-02f, 1.35750026e-02f, -6.59571290e-02f, -3.80776115e-02f, 6.77588629e-03f, 1.00562692e-01f, -4.61893640e-02f, 4.42679692e-03f,
  5.40831871e-02f, 6.06287941e-02f, -3.14490125e-02f, -3.61626735e-03f, -2.36116406e-02f, -3.29634771e-02f, 1.00744404e-02f, 7.72069916e-02f, 8.57220441e-02f, 5.05569857e-03f,
  -4.21825573e-02f, -5.56119196e-02f, 5.58155887e-02f, 8.23558494e-02f, 9.24477652e-02f, 3.54427285e-03f, 5.46822883e-02f, 6.16946481e-02f, -2.19448358e-02f, 6.16399720e-02f,
  -1.19712040e-01f, 1.76177427e-01f, 1.00372225e-01f, -5.97552583e-02f, 4.40426916e-02f, -1.00678481e-01f, -1.46155626e-01f, -1.58072319e-02f, -9.44405422e-03f, -5.87135777e-02f,
  -4.19932380e-02f, 9.86815169e-02f, 1.48622598e-02f, -4.77789454e-02f, -1.67542130e-01f, -6.76379912e-03f, -3.97013240e-02f, -2.96332762e-02f, 1.10548288e-01f, -4.81746793e-02f,
  -2.37337910e-02f, -4.37139459e-02f, -6.07240126e-02f, 1.66700318e-01f, 2.36491766e-03f, -7.01860860e-02f, -1.00124732e-01f, 1.24115773e-01f, -6.83129281e-02f, 8.20431486e-02f,
  1.20004348e-01f, -4.61785421e-02f, 3.68975960e-02f, 7.29269981e-02f, 4.07156460e-02f, -8.31021145e-02f, 4.80882488e-02f, 2.34350692e-02f, -2.03546453e-02f, -1.20573631e-02f,
  -2.35655531e-02f, -4.68486138e-02f, -1.00512861e-03f, -1.64023656e-02f, -1.23358844e-02f, 1.82320662e-02f, 1.07859083e-01f, 2.38002408e-02f, 7.37516135e-02f, 1.12927109e-01f,
  1.31381705e-01f, -6.50814548e-02f, -1.12140626e-01f, -5.90793826e-02f, -8.29791427e-02f, -7.88603947e-02f, -7.25929961e-02f, -5.59369614e-03f, 4.96735424e-02f, -1.04075037e-01f,
  -8.60767365e-02f, -3.44224437e-03f, 2.70561725e-02f, 1.18401870e-02f, -4.18207049e-02f, 5.19537963e-02f, 1.11841001e-02f, 4.21014801e-02f, -8.36591795e-02f, -6.91774040e-02f,
  -1.13011904e-01f, -4.09173854e-02f, -1.35718510e-02f, -1.09189123e-01f, -1.80370559e-03f, -2.38086972e-02f, -8.59953836e-02f, -2.28734799e-02f, -1.96708813e-02f, -5.18620983e-02f,
  -9.40970704e-02f, -7.67714083e-02f, 8.36683363e-02f, 3.31527069e-02f, -3.98796871e-02f, -4.54006344e-02f, -4.32743020e-02f, -2.36233827e-02f, -2.53291465e-02f, -6.94580823e-02f,
  -1.83827560e-02f, -1.64261073e-01f, -3.19079533e-02f, 6.29316717e-02f, 1.14517743e-02f, -4.23267521e-02f, -1.03358962e-01f, -5.18459082e-02f, -9.49635804e-02f, -3.97065803e-02f,
  -3.22639458e-02f, 2.02151928e-02f, -2.23043598e-02f, -5.74231707e-02f, -7.22022448e-03f, 7.07638115e-02f, -4.32878733e-03f, 1.71243809e-02f, -2.77712885e-02f, -1.11285234e-02f,
  6.41924655e-03f, 6.96867183e-02f, -3.85895148e-02f, -9.72742513e-02f, -2.20202096e-02f, 2.82970890e-02f, 3.52104194e-02f, -1.91524755e-02f, -4.68471609e-02f, 5.50178811e-02f,
  2.20958874e-01f, -1.19249813e-01f, -7.52321556e-02f, -5.22137880e-02f, 5.18728308e-02f, 1.10254556e-01f, -1.86581817e-02f, 9.45774280e-03f, -1.22449718e-01f, 3.90806934e-03f,
  -6.43615350e-02f, -4.32722494e-02f, 3.16106863e-02f, 5.58625348e-02f, 7.98375160e-02f, -4.42374200e-02f, -1.50972512e-02f, 7.93193281e-02f, -8.15578327e-02f, 1.25008613e-01f,
  5.74701317e-02f, 1.13251746e-01f, -1.22828537e-03f, -3.72307608e-03f, -2.30094548e-02f, -2.96197236e-02f, -8.43562856e-02f, -7.29178712e-02f, -1.91996507e-02f, 7.58436918e-02f,
  1.24378629e-01f, -6.54253215e-02f, 1.10005073e-01f, 2.76784878e-02f, 9.06664208e-02f, 5.91646731e-02f, 6.28210977e-02f, -5.69376200e-02f, -8.43069851e-02f, -6.66247830e-02f,
  9.95601490e-02f, -5.32290004e-02f, 4.94870655e-02f, -4.79695909e-02f, 6.58648610e-02f, -8.49683061e-02f, -9.04577300e-02f, -5.89381047e-02f, 1.03442436e-02f, -1.19800605e-02f,
  -1.51136164e-02f, 3.54714021e-02f, -1.01778634e-01f, -4.78551015e-02f, -8.69183391e-02f, 6.36369064e-02f, -6.53312355e-03f, 1.57456882e-02f, 5.57702854e-02f, -9.84530672e-02f,
  1.39262183e-02f, 5.45341484e-02f, 8.13202560e-03f, 3.21698785e-02f, 6.40039891e-02f, 3.09667340e-03f, 9.70181376e-02f, -7.67655596e-02f, -5.95610961e-02f, -1.30616995e-02f,
  5.56888841e-02f, 2.19406188e-02f, 5.94278574e-02f, 1.70965958e-02f, 5.40434308e-02f, -3.35792289e-03f, 2.69723833e-02f, -5.27842902e-02f, -2.30714921e-02f, 2.97361873e-02f,
  -8.05813000e-02f, 2.32490227e-02f, -3.24220620e-02f, -4.33987863e-02f, 7.73478225e-02f, -5.68989068e-02f, 2.04814523e-02f, -4.19376940e-02f, -2.60070292e-03f, 7.80913187e-03f,
  7.57245049e-02f, 5.92788495e-02f, -7.30528831e-02f, -2.58862861e-02f, 4.11503352e-02f, -3.23765613e-02f, 1.03455864e-01f, 9.69158206e-03f, 8.07340890e-02f, 9.75295752e-02f,
  5.53047583e-02f, -3.98129746e-02f, 6.78533316e-02f, 6.49912953e-02f, -5.41158654e-02f, 1.48636308e-02f, 8.14813972e-02f, -7.67345587e-03f, 5.55996187e-02f, -4.86113802e-02f,
  1.04703672e-01f, 8.37138146e-02f, -5.18633565e-03f, 5.95820583e-02f, -7.26891086e-02f, -9.93127842e-03f, 3.47406417e-02f, 2.66297907e-02f, -2.67001316e-02f, 6.46110531e-03f,
  1.13012576e-02f, -5.80196753e-02f, 2.35717312e-01f, 1.53551744e-02f, 5.63339740e-02f, 1.25673920e-01f, 1.51789099e-01f, 3.97010148e-02f, 6.29512295e-02f, -1.50934188e-02f,
  -1.78671498e-02f, 5.11667170e-02f, 8.26303288e-02f, -5.89891039e-02f, 5.70283644e-02f, 8.82662609e-02f, 8.31840560e-02f, -3.20006795e-02f, -2.46270187e-02f, 6.04164600e-02f,
  2.69990880e-02f, -1.35299593e-01f, 5.58989905e-02f, -2.16748342e-02f, 8.32467228e-02f, 5.53267859e-02f, -1.12914681e-01f, 7.72260427e-02f, -5.61492220e-02f, 8.60772580e-02f,
  -8.69945139e-02f, 4.33540195e-02f, 5.89306802e-02f, 5.25098145e-02f, 6.86779246e-02f, 7.78723806e-02f, 4.85599861e-02f, 6.13528341e-02f, 6.31165579e-02f, -4.44754288e-02f,
  4.92831282e-02f, 4.42089327e-02f, -3.68245430e-02f, 1.92972440e-02f, -9.72057879e-02f, -3.50688957e-02f, 1.00996740e-01f, -5.53020202e-02f, 1.35394675e-03f, -3.66391838e-02f,
  5.53992800e-02f, 4.98567335e-02f, -2.18886267e-02f, 8.32639728e-03f, 6.14075214e-02f, -8.76218826e-02f, -3.95549126e-02f, 8.61218944e-02f, -4.27033007e-02f, -8.98697227e-03f,
  -3.05600408e-02f, 4.17498760e-02f, 7.57337660e-02f, 7.01548383e-02f, -4.83349860e-02f, -1.02244345e-02f, -3.39021087e-02f, 1.57491229e-02f, 2.99082529e-02f, -2.04089507e-02f,
  -2.24299263e-02f, -6.73043802e-02f, -9.22151953e-02f, 5.93486205e-02f, -1.63703430e-02f, 7.11349025e-02f, 6.82770461e-02f, 5.99983037e-02f, 6.06896207e-02f, -7.95434490e-02f,
  1.96347572e-02f, 6.33953512e-02f, 5.16740941e-02f, -1.47270858e-02f, 9.53370780e-02f, -3.06123942e-02f, -7.74400756e-02f, 3.19547094e-02f, 2.89998930e-02f, -4.55005281e-02f,
  -1.04187898e-01f, -1.06706455e-01f, -5.54146767e-02f, 6.85045496e-02f, 5.01059182e-02f, -7.11196428e-03f, 8.05817321e-02f, -6.72946051e-02f, -7.52959102e-02f, 4.30229073e-03f,
  -6.59296289e-02f, -5.22980727e-02f, 3.32961008e-02f, -5.17299958e-03f, -1.14337631e-01f, -8.51090923e-02f, -8.22986290e-02f, 4.87488024e-02f, -1.26034173e-03f, -4.58704904e-02f,
  -6.04911186e-02f, -1.77661069e-02f, -6.85861036e-02f, 7.32298242e-03f, 1.04531981e-02f, 2.09042449e-02f, 6.80925250e-02f, 3.47074643e-02f, -6.03870004e-02f, 5.57429418e-02f,
  -9.23078135e-02f, 4.64363098e-02f, 5.90798166e-03f, -4.04043943e-02f, 9.27980468e-02f, 4.72130515e-02f, -2.43476387e-02f, 5.93583472e-02f, -1.20148495e-01f, -3.48809944e-03f,
  7.08765835e-02f, 2.36423258e-02f, -5.62150851e-02f, -5.36147431e-02f, -6.05155788e-02f, -1.17758624e-01f, 6.05531447e-02f, -2.20228620e-02f, -1.28194273e-01f, 1.42541513e-01f,
  -5.17407209e-02f, 1.25710398e-01f, -8.28553438e-02f, 4.10959758e-02f, 8.90908986e-02f, 7.53031299e-02f, 8.84256065e-02f, -1.32389385e-02f, -2.42680870e-02f, 4.80156438e-03f,
  -1.65814105e-02f, 6.09280616e-02f, -8.22869986e-02f, -1.00540137e-02f, 1.90474633e-02f, 6.81761280e-02f, -3.54119018e-02f, 5.24227023e-02f, 5.50922342e-02f, -7.93096423e-02f,
  2.83543132e-02f, 3.14347483e-02f, -2.37162318e-02f, -6.45046979e-02f, 8.73127952e-02f, -6.55800989e-03f, 4.48075905e-02f, -7.61645362e-02f, -7.57797956e-02f, 3.12031209e-02f,
  4.52697612e-02f, 9.60096195e-02f, 7.24841952e-02f, -3.85125987e-02f, -6.80171847e-02f, -5.60438521e-02f, -7.29145184e-02f, 1.73588265e-02f, 6.81863502e-02f, -2.60264650e-02f,
  -2.86662728e-02f, -2.14371886e-02f, 7.92544335e-03f, 2.65393611e-02f, -4.86925542e-02f, -3.51774432e-02f, -5.49042262e-02f, -8.37104023e-02f, 3.20688658e-03f, -1.92158129e-02f,
  -1.54010514e-02f, 4.33395617e-02f, 1.50263300e-02f, -2.38499828e-02f, 1.91794503e-02f, 6.43929988e-02f, 2.19812058e-02f, -8.27614591e-03f, 1.77730322e-02f, -7.90048540e-02f,
  -9.42625776e-02f, -2.83803064e-02f, 4.10630973e-03f, -9.54820067e-02f, -8.65439102e-02f, -1.22108143e-02f, -1.12940222e-02f, -6.64095059e-02f, -1.77293294e-03f, -1.45348087e-02f,
  6.36837780e-02f, 7.80296177e-02f, -6.34429529e-02f, -5.50733358e-02f, 8.12631473e-02f, -2.22819205e-02f, -6.01974279e-02f, 2.14136671e-03f, -3.08990963e-02f, 1.36326496e-02f,
  -4.93682474e-02f, -3.81715260e-02f, -5.33841327e-02f, 3.11091989e-02f, 8.26961696e-02f, 8.99429843e-02f, 7.58951679e-02f, 6.40557259e-02f, -4.89734262e-02f, -8.51567369e-04f,
  1.02910791e-02f, -2.54146773e-02f, -9.06208754e-02f, 4.97536454e-03f, -7.23956600e-02f, 8.96283388e-02f, 4.33201827e-02f, -9.40589141e-03f, 4.85813506e-02f, 2.72909570e-02f,
  2.30078310e-01f, 8.41175243e-02f, 1.00399256e-01f, 2.04096928e-01f, -3.88163753e-04f, -4.62969858e-03f, -1.46235466e-01f, 5.33591211e-02f, 1.48435548e-01f, -7.37071931e-02f,
  -2.92191915e-02f, 3.51637341e-02f, -1.18895195e-01f, 1.87223941e-01f, -9.98729989e-02f, -4.08306383e-02f, -3.09063774e-02f, 1.63785331e-02f, 4.20908630e-02f, 7.36779496e-02f,
  -3.90818231e-02f, -8.98798406e-02f, 7.15025142e-02f, -3.51274051e-02f, 1.32155031e-01f, -1.49771692e-02f, -1.01001322e-01f, -6.43198118e-02f, 8.88003558e-02f, -1.25147253e-01f,
  -5.68373390e-02f, 5.21985479e-02f, -2.95985676e-02f, 5.38825169e-02f, 1.65671390e-02f, 8.66430700e-02f, 8.83874595e-02f, -4.19872291e-02f, -3.70873362e-02f, -5.78755252e-02f,
  4.89618927e-02f, 2.06004754e-02f, 8.30877572e-02f, 9.23307519e-03f, 1.19322874e-01f, -4.57001813e-02f, 5.05995750e-02f, 1.02570996e-01f, 2.85151415e-02f, 5.58095798e-02f,
  9.50857997e-02f, 9.90157947e-02f, -8.37243535e-03f, -4.78219837e-02f, -1.00638000e-02f, 4.00668196e-02f, -4.29368131e-02f, -8.58814493e-02f, 7.29465783e-02f, -2.48518400e-03f,
  -5.37571199e-02f, -8.07305276e-02f, 4.55595441e-02f, -3.00259851e-02f, 7.80192688e-02f, 1.06764525e-01f, -2.42737569e-02f, -2.25824676e-02f, 7.07431957e-02f, 3.25272121e-02f,
  -8.45302641e-02f, 3.77792455e-02f, -3.30593549e-02f, -4.82813902e-02f, 8.17816034e-02f, 7.11363703e-02f, 6.95134774e-02f, 5.43130487e-02f, -3.28953862e-02f, 9.21269283e-02f,
  -8.85621384e-02f, -1.86529420e-02f, 5.60002401e-02f, 5.85303735e-03f, 5.24759404e-02f, -2.08793283e-02f, -7.47114345e-02f, 5.55343889e-02f, 3.39073315e-02f, -1.71928238e-02f,
  3.52150537e-02f, 6.82937652e-02f, -7.32100531e-02f, -9.27002281e-02f, 4.21833657e-02f, 5.33835143e-02f, -2.20126081e-02f, 7.67443031e-02f, 9.12047029e-02f, 5.69844283e-02f,
  -4.82108742e-02f, 8.90191738e-03f, -4.56398465e-02f, -2.22819224e-02f, -2.92060506e-02f, 8.63726735e-02f, 5.57235489e-03f, -9.42841638e-03f, 6.36535585e-02f, -1.37282699e-01f,
  5.97320870e-02f, -6.31110817e-02f, 6.87081069e-02f, 3.19190100e-02f, 3.52944061e-02f, 3.98006923e-02f, -4.67646196e-02f, 1.59562994e-02f, -5.85004650e-02f, -3.15014496e-02f,
  4.08784375e-02f, 2.89520212e-02f, 1.87416580e-02f, -2.79600844e-02f, 8.94704740e-03f, -3.67342271e-02f, 7.13302717e-02f, 4.97781783e-02f, -3.34155709e-02f, 6.36401623e-02f,
  1.15891635e-01f, -7.31256604e-02f, -1.19417263e-02f, 3.23712490e-02f, -7.45194182e-02f, 8.35473090e-02f, 2.55632494e-02f, -6.63059056e-02f, -8.34953934e-02f, 7.84265436e-03f,
  5.78084253e-02f, 3.16300802e-02f, -1.01518482e-01f, 2.26266012e-02f, 2.55753901e-02f, 2.05846205e-02f, -5.20036183e-02f, -3.22616659e-02f, 4.60942164e-02f, -5.74916936e-02f,
  6.43660799e-02f, 7.68908784e-02f, 8.16745311e-02f, 6.31989166e-02f, 4.79140803e-02f, -7.46708885e-02f, 2.13494562e-02f, 7.45165497e-02f, -5.93480393e-02f, 4.31032628e-02f,
  -6.12070039e-03f, -5.20095713e-02f, 3.76418382e-02f, -5.72656952e-02f, 3.27699520e-02f, 3.62471715e-02f, 4.50408272e-02f, -9.69279930e-02f, 1.88128697e-03f, -3.58326100e-02f,
  -3.42994109e-02f, 4.54003476e-02f, 1.08988592e-02f, -5.60601577e-02f, -8.03077146e-02f, 3.02084945e-02f, 7.67314881e-02f, -7.82433003e-02f, 6.21911027e-02f, 3.65934782e-02f,
  6.62903395e-03f, -8.82325843e-02f, 9.11055505e-02f, -1.25809070e-02f, 1.72410514e-02f, -6.46353438e-02f, -4.58692573e-02f, -7.18981996e-02f, 7.71675408e-02f, 9.10181738e-03f,
  5.87849617e-02f, 4.25902493e-02f, 1.71111245e-02f, 1.72211919e-02f, -5.63255996e-02f, -1.99526493e-02f, -5.29314987e-02f, -4.52049077e-02f, 3.32881659e-02f, -2.89014708e-02f,
  8.59085992e-02f, 6.86914325e-02f, -1.54498098e-02f, -4.18527313e-02f, 7.16968030e-02f, 4.66387123e-02f, -4.95652147e-02f, 6.99635223e-02f, -2.00539753e-02f, -3.61175537e-02f,
  -1.92386322e-02f, 6.59911633e-02f, -2.87009589e-02f, 6.84185103e-02f, -4.72850204e-02f, 6.55232221e-02f, 6.34534806e-02f, 3.33496481e-02f, -6.48479238e-02f, 1.89315788e-02f,
  -2.43381765e-02f, -8.72176141e-02f, 8.72236341e-02f, -7.84804076e-02f, 1.24845253e-02f, -3.47420536e-02f, 8.60687420e-02f, -9.84153971e-02f, -1.00317821e-01f, -6.70961216e-02f,
  -7.54287094e-02f, 4.72785905e-02f, 2.41132397e-02f, 3.74940485e-02f, -1.24507234e-03f, -3.45285125e-02f, -8.37622955e-02f, 6.16250075e-02f, 1.64730251e-02f, -7.02439398e-02f,
  4.92177755e-02f, -3.84763293e-02f, 3.01362798e-02f, 1.08128071e-01f, 1.35009766e-01f, 5.55861332e-02f, 6.60675019e-02f, -9.80913453e-03f, 4.76630107e-02f, -1.45018592e-01f,
  -4.87340242e-02f, 2.28007231e-02f, -2.46657822e-02f, 2.15127529e-03f, -8.50960463e-02f, 1.66754872e-02f, 6.87188981e-03f, -2.38139331e-02f, 1.01648010e-01f, 3.27786021e-02f,
  1.14598656e-02f, -8.37788880e-02f, -1.33311711e-02f, 3.87148559e-02f, -5.52215502e-02f, -2.45394576e-02f, -1.36571005e-01f, -8.05339068e-02f, -1.03358679e-01f, -8.40777904e-02f,
  -5.16600721e-02f, 2.99133267e-02f, 4.00308780e-02f, -1.75820049e-02f, 7.82578513e-02f, -4.02635895e-02f, -3.01412004e-03f, -4.75162528e-02f, 6.34248778e-02f, -6.44278303e-02f,
  -1.61067564e-02f, -1.15086315e-02f, 7.22493306e-02f, 6.76964149e-02f, 7.39755705e-02f, -2.60052737e-02f, 4.58172821e-02f, 7.80851543e-02f, 3.90198603e-02f, 8.35436881e-02f,
  1.67141315e-02f, -1.90771893e-02f, -1.86157264e-02f, -7.52172619e-02f, 4.23978828e-02f, -2.45882608e-02f, -6.00456744e-02f, -2.41430048e-02f, -2.87145823e-02f, -6.86227381e-02f,
  7.50792697e-02f, 5.46104200e-02f, -6.08862750e-02f, -4.09404822e-02f, -5.37369214e-02f, -5.87145090e-02f, 3.82121792e-03f, -6.57714903e-02f, -3.31369997e-03f, 7.29884803e-02f,
  4.82413322e-02f, 2.19286270e-02f, 5.26131690e-02f, 4.67009507e-02f, 5.76335490e-02f, 4.04991582e-02f, 4.67664525e-02f, -1.05003625e-01f, -6.37237355e-02f, 7.79179996e-03f,
  5.64426519e-02f, -4.18245122e-02f, 2.50958502e-02f, -3.16898301e-02f, -9.55620222e-03f, 7.12318346e-02f, 8.77391621e-02f, 8.17827284e-02f, 7.09221438e-02f, -3.36834304e-02f,
  3.88314426e-02f, -1.09937720e-01f, 8.56632441e-02f, 8.59164372e-02f, -8.25394318e-02f, -8.95069987e-02f, -2.44143587e-02f, -7.16374293e-02f, -7.56610632e-02f, 3.46398428e-02f,
  2.34300829e-02f, -7.45766237e-02f, 3.71923447e-02f, -9.39555466e-02f, 7.76384547e-02f, 5.37133180e-02f, -4.51237485e-02f, -4.24115434e-02f, 3.60662863e-02f, -4.70134243e-02f,
  4.26799431e-02f, 1.09899960e-01f, -7.68213868e-02f, -4.14845906e-02f, 5.37040718e-02f, -3.84602435e-02f, -2.09093411e-02f, 2.37721088e-03f, -3.95913608e-02f, -3.25066969e-02f,
  -2.91434471e-02f, -4.67451625e-02f, -3.69347297e-02f, 2.81657837e-02f, -1.77070778e-02f, -6.45705536e-02f, -1.41221613e-01f, -3.67423217e-03f, 1.15393577e-02f, -7.40274563e-02f,
  8.67869258e-02f, -1.08950846e-01f, -1.38057675e-02f, -2.56867893e-02f, -1.96955018e-02f, 9.67233703e-02f, 1.34899188e-02f, -6.95954114e-02f, -1.22158036e-01f, -1.32488534e-01f,
  -4.62014712e-02f, -2.35269535e-02f, 5.25077283e-02f, -8.21887031e-02f, -5.81258209e-03f, -9.76477489e-02f, 9.02010724e-02f, -9.66686085e-02f, -1.03643358e-01f, 6.31102249e-02f,
  2.87781339e-02f, 2.27876902e-02f, -3.42608639e-03f, -7.92478099e-02f, -4.52921763e-02f, -4.57893834e-02f, -1.48223191e-02f, -2.52423249e-02f, 3.95362377e-02f, -8.82775709e-02f,
  -6.74296990e-02f, 1.17215356e-02f, -8.44191685e-02f, 7.89563879e-02f, -3.59936357e-02f, 6.17846623e-02f, 5.27385157e-03f, -8.15431327e-02f, -8.99209455e-02f, 6.73899949e-02f,
  -5.89212887e-02f, 1.73048917e-02f, 6.95005478e-03f, -2.72919815e-02f, 6.31005615e-02f, -3.06559503e-02f, 2.15133391e-02f, 9.41430926e-02f, -2.56086569e-02f, -2.67112236e-02f,
  1.82364788e-02f, -1.21495668e-02f, 3.44852246e-02f, -7.69305453e-02f, -7.95450062e-02f, 6.32298887e-02f, 5.38892560e-02f, -2.38295794e-02f, -3.17470580e-02f, -7.66693428e-02f,
  -2.53674220e-02f, -7.57293627e-02f, -2.17947587e-02f, 4.15321551e-02f, 4.16332893e-02f, -2.26949565e-02f, -2.85929069e-02f, -5.60676791e-02f, 8.87201130e-02f, 3.86868492e-02f,
  -6.95891976e-02f, 3.45664509e-02f, -4.41813618e-02f, 6.35866448e-02f, -8.15924034e-02f, -5.26760854e-02f, -2.55761091e-02f, 1.16073797e-02f, -3.99537422e-02f, -2.10679211e-02f,
  -1.37459040e-01f, -5.58655560e-02f, -2.92579904e-02f, -5.92381656e-02f, -6.48921579e-02f, -4.31056656e-02f, 5.36613613e-02f, -3.61271435e-04f, -3.82935628e-02f, -8.86065140e-02f,
  -9.64084931e-04f, -9.93767381e-03f, 1.12767983e-02f, 1.17391847e-01f, 3.38264443e-02f, -7.94960856e-02f, -1.37502626e-02f, 4.37556989e-02f, -7.14861676e-02f, -4.34924674e-04f,
  -1.01204306e-01f, -3.22650485e-02f, -2.97149718e-02f, 3.62935029e-02f, 6.69381842e-02f, -4.33245189e-02f, -2.43139323e-02f, -5.06783798e-02f, 5.57850078e-02f, -2.70961178e-03f,
  6.20273426e-02f, -3.37316580e-02f, -1.84661955e-01f, -1.06649011e-01f, 3.01362853e-02f, -2.50427186e-01f, -9.95202139e-02f, -1.46211743e-01f, -8.11833888e-02f, 4.65138704e-02f,
  -7.49529973e-02f, 1.47896901e-01f, 8.07590485e-02f, -1.75380319e-01f, 6.03871867e-02f, -9.03622340e-03f, -1.39012426e-01f, -1.27886400e-01f, -5.32487184e-02f, -1.59736902e-01f,
  -2.78694369e-02f, -1.15633756e-01f, -8.55999291e-02f, -1.09957613e-01f, -1.07245728e-01f, 4.19609323e-02f, 4.21218127e-02f, -8.18574876e-02f, -8.08232650e-02f, 8.09919834e-03f,
  -6.95493445e-02f, 9.32504237e-02f, 6.20904053e-03f, 7.19388425e-02f, -9.58705023e-02f, -5.67612164e-02f, -7.65304044e-02f, 5.06508984e-02f, 9.94819775e-03f, -3.07219313e-03f,
  3.52510847e-02f, 5.03854710e-04f, 5.70875071e-02f, 3.12235299e-02f, -5.09786867e-02f, 2.16749664e-02f, -2.67404821e-02f, 7.90654123e-02f, 3.27351429e-02f, -6.26581609e-02f,
  -1.61654092e-02f, 4.57682237e-02f, -4.40203659e-02f, 5.48109077e-02f, 6.18124492e-02f, -7.46350810e-02f, -4.39829156e-02f, -5.44123054e-02f, 6.75000250e-02f, 1.59644298e-02f,
  5.96357882e-02f, -5.02420440e-02f, 2.11051013e-02f, 6.42714724e-02f, -5.31657115e-02f, 5.45307212e-02f, -7.29460046e-02f, 3.33974212e-02f, -2.15784553e-02f, -3.52532268e-02f,
  2.60782111e-02f, 3.79288346e-02f, 5.83257005e-02f, -1.59606133e-02f, 2.92607099e-02f, 3.28749977e-02f, 4.26878743e-02f, 2.92756651e-02f, -6.87933788e-02f, -4.48455401e-02f,
  -1.80899131e-03f, -2.71130493e-03f, 8.88233334e-02f, 5.30201718e-02f, 3.26228440e-02f, 1.02491654e-01f, -7.05192015e-02f, 7.40229413e-02f, 7.24354107e-03f, -2.71154214e-02f,
  -4.35327785e-03f, -1.14856645e-01f, 4.69312966e-02f, 5.79507044e-03f, 1.59011986e-02f, 3.14935260e-02f, -1.13629878e-01f, -1.69647373e-02f, 4.73857671e-02f, -5.49563095e-02f,
  -1.29990324e-01f, -1.52578019e-02f, -6.74331337e-02f, 3.49290259e-02f, 1.25763216e-03f, 2.20204368e-02f, -2.44242866e-02f, -1.10867871e-02f, 1.62792932e-02f, -4.71095741e-02f,
  -1.01589402e-02f, -6.79070130e-02f, -5.38584217e-02f, -4.89025936e-02f, 3.90476398e-02f, 1.98747143e-02f, -4.45967130e-02f, 6.37841672e-02f, -5.18791750e-02f, 3.55906785e-02f,
  4.57111597e-02f, -4.20044959e-01f, 7.20610172e-02f, 2.05121800e-01f, 1.46170735e-01f, -9.92712285e-03f, 1.55261815e-01f, -1.05988242e-01f, -4.84536551e-02f, -2.34703586e-01f,
  1.07552512e-02f, -4.33939882e-02f, -1.78525791e-01f, -8.76154401e-04f, 2.65318453e-01f, -1.21808611e-01f, 2.94250762e-03f, -8.52214247e-02f, 1.81310028e-02f, -5.07583916e-02f,
  3.82376127e-02f, 5.97661622e-02f, 1.55913085e-01f, -1.96987460e-03f, 6.35114610e-02f, 1.41519280e-02f, 5.42357638e-02f, 1.37694534e-02f, 8.27108100e-02f, 1.00953780e-01f,
  -7.87244663e-02f, -4.78837527e-02f, 4.98372652e-02f, -1.84662864e-02f, -6.31534755e-02f, -5.74104898e-02f, -3.09021324e-02f, 1.10246219e-01f, 2.44755042e-03f, 3.99248824e-02f,
  -4.90324125e-02f, -6.97348593e-03f, 7.65671879e-02f, 3.30091566e-02f, 3.09334863e-02f, -2.07556114e-02f, 3.32815014e-02f, -2.69467421e-02f, -2.12798864e-02f, -3.88288088e-02f,
  -8.92313123e-02f, -5.81564382e-02f, 2.19435953e-02f, -1.02409320e-02f, -3.99934202e-02f, -4.70416620e-02f, 6.38147667e-02f, -1.02098957e-01f, -9.63194445e-02f, -4.51155892e-03f,
  -4.06977646e-02f, 3.79484259e-02f, -2.44054031e-02f, -2.63297949e-02f, -7.13219270e-02f, 8.55807811e-02f, -4.89911810e-02f, -3.54527719e-02f, 6.13081595e-03f, -5.02590910e-02f,
  -1.27882585e-02f, 5.05369678e-02f, -6.84218630e-02f, -6.66601807e-02f, 7.50783607e-02f, 4.87922654e-02f, 1.52887432e-02f, -3.29789408e-02f, -7.17972144e-02f, 5.79317957e-02f,
  3.45806708e-03f, 4.18750159e-02f, -1.21511798e-02f, -4.82634612e-04f, -5.46339005e-02f, -4.46497574e-02f, -3.40977386e-02f, -1.03098594e-01f, 1.99926309e-02f, 6.35329187e-02f,
  -2.16388643e-01f, -2.28254497e-01f, -4.61519584e-02f, 1.75120253e-02f, -1.31602101e-02f, -8.46035480e-02f, 1.90592576e-02f, -2.27252450e-02f, -4.98670079e-02f, 2.81609874e-02f,
  -1.08707342e-02f, 8.22175667e-02f, -2.31481753e-02f, -2.24931668e-02f, 5.17813563e-02f, -5.02939858e-02f, -4.51342762e-02f, -1.07476488e-02f, -6.68502524e-02f, -2.29924209e-02f,
  1.96512826e-02f, -4.14071605e-04f, 2.34192442e-02f, -1.60439685e-02f, -7.36059695e-02f, 2.00795904e-02f, -4.82210517e-02f, 6.60135224e-02f, -1.30537385e-02f, 1.05502745e-02f,
  4.21658196e-02f, 4.32479680e-02f, -1.22940794e-01f, -8.65256712e-02f, 4.75453660e-02f, 1.93501100e-01f, 6.27635196e-02f, 1.12283394e-01f, 6.34627342e-02f, 1.48638710e-01f,
  8.70448351e-02f, 8.82008821e-02f, -2.26432551e-02f, 8.10490698e-02f, 3.14132459e-02f, 9.71035734e-02f, 1.75381541e-01f, 9.92412269e-02f, 3.74718159e-02f, 9.29287598e-02f,
  5.10655716e-02f, 1.17495030e-01f, -9.57468227e-02f, -9.20771435e-02f, -6.17413186e-02f, -8.97768810e-02f, -1.61727563e-01f, -9.87000167e-02f, 3.76023985e-02f, -1.11968415e-02f,
  8.43728036e-02f, 1.07264910e-02f, -7.06214681e-02f, -6.11457415e-02f, -4.47909497e-02f, -1.09428763e-01f, -8.45088065e-02f, 9.21723840e-04f, -1.59711353e-02f, 6.48919046e-02f,
  3.85242677e-03f, -4.63831536e-02f, 6.62690550e-02f, 5.47777377e-02f, -2.30804663e-02f, 2.20909845e-02f, -8.01470727e-02f, 3.42502594e-02f, 4.47742939e-02f, 5.86049026e-03f,
  -3.30916643e-02f, -3.49486992e-02f, -6.54045790e-02f, -1.57454628e-02f, 5.15275374e-02f, 4.43069078e-02f, -7.54968524e-02f, -5.41607775e-02f, 3.72903645e-02f, 4.69916649e-02f,
  3.51630971e-02f, 8.11215863e-02f, 4.17951904e-02f, -3.89183648e-02f, -4.54604886e-02f, -6.45120889e-02f, -2.71237195e-02f, 6.33921549e-02f, 3.32996342e-03f, 5.05538024e-02f,
  3.03509440e-02f, 5.71077019e-02f, 4.61903326e-02f, 7.31514320e-02f, 4.16050442e-02f, 3.95778157e-02f, -1.04960822e-01f, 1.23203837e-03f, 6.54248968e-02f, 6.99242949e-02f,
  -5.87651059e-02f, 1.06173381e-01f, -8.06812346e-02f, -7.24724010e-02f, 5.89052448e-03f, 6.84517324e-02f, 2.18113717e-02f, 7.58644715e-02f, -6.22716732e-02f, 4.59843762e-02f,
  9.91991758e-02f, 5.62586896e-02f, -1.45439568e-04f, 7.08335713e-02f, -7.71752223e-02f, 5.23839891e-02f, -1.10572893e-02f, 3.21992598e-02f, -6.20884784e-02f, -6.70963451e-02f,
  6.12030877e-03f, -7.68269971e-03f, 2.02085916e-02f, -2.42191795e-02f, -3.10924556e-02f, 2.37954482e-02f, 2.16379669e-02f, -1.21048037e-02f, -1.63104869e-02f, -1.82315949e-02f,
  -4.53724898e-02f, -1.93329081e-02f, 9.11903605e-02f, -6.54097274e-02f, 1.08002119e-01f, 2.37603020e-02f, 8.84221308e-03f, -5.93188331e-02f, -5.64467236e-02f, -4.39434685e-03f,
  -1.79899484e-01f, 5.45446835e-02f, -7.03535378e-02f, -1.09997563e-01f, -3.37310061e-02f, 2.28235554e-02f, 1.54558178e-02f, 9.81471911e-02f, -7.49000683e-02f, 1.11553319e-01f,
  6.36473373e-02f, -4.32898775e-02f, -3.65052894e-02f, -1.15720175e-01f, -1.43123239e-01f, -1.35364741e-01f, -7.11070523e-02f, -4.64294367e-02f, -4.78124917e-02f, -5.78606874e-02f,
  -3.40217538e-02f, -1.88549596e-03f, -8.00728276e-02f, -2.04111934e-02f, 8.51654708e-02f, -2.12069899e-02f, 1.02361560e-01f, 9.16383192e-02f, 7.68542066e-02f, -1.14118410e-02f,
  3.25155444e-02f, 6.15193173e-02f, -2.68699154e-02f, 7.46195689e-02f, 1.03329845e-01f, 1.32420380e-02f, -3.71133387e-02f, -1.82346988e-03f, 1.77248996e-02f, 6.91141039e-02f,
  5.40966652e-02f, -1.77830271e-03f, -3.81616428e-02f, 8.50670859e-02f, 2.93072630e-02f, -4.04056720e-02f, -9.10096690e-02f, 2.20014248e-02f, 8.27942938e-02f, -4.64558564e-02f,
  -4.10074629e-02f, 1.42332129e-02f, 5.05474284e-02f, -6.62773773e-02f, 5.33672161e-02f, -5.59630394e-02f, -1.43042682e-02f, 7.34886974e-02f, 4.55129668e-02f, 6.09876178e-02f,
  6.11768477e-02f, 1.45653458e-02f, 1.83987543e-02f, -2.37716865e-02f, -3.62114199e-02f, 1.00467123e-01f, -7.30203912e-02f, -7.31953457e-02f, -9.41712875e-03f, -3.98669504e-02f,
  5.59619814e-03f, 3.76104601e-02f, 8.70728120e-02f, 3.80690657e-02f, -8.38731602e-02f, 1.20907854e-02f, -7.26322606e-02f, 7.57275224e-02f, 3.12681347e-02f, -3.91784683e-02f,
  9.05954167e-02f, 2.28819344e-02f, 1.08107254e-02f, 5.21162711e-02f, 5.38015217e-02f, -2.64056902e-02f, -5.53429499e-02f, -2.07119770e-02f, -3.05845775e-02f, 1.10885762e-02f,
  2.75492594e-02f, 3.41089852e-02f, -2.37287842e-02f, 4.32843342e-02f, 4.73531755e-03f, 5.07637337e-02f, -2.12745443e-02f, -7.80101195e-02f, 5.98567389e-02f, -1.28163975e-02f,
  5.87158091e-02f, 6.91972822e-02f, -1.01847574e-02f, -3.52266878e-02f, 5.41128069e-02f, 4.63103354e-02f, -1.33928470e-03f, -8.34807903e-02f, -2.80824695e-02f, -1.08764498e-02f,
  8.02919418e-02f, 2.24896874e-02f, -4.27412987e-02f, 7.63848945e-02f, 5.88657334e-03f, -2.89907716e-02f, -4.97452915e-02f, 4.20636609e-02f, -8.02239683e-03f, -3.99249345e-02f,
  1.58407673e-01f, -5.89407422e-02f, 1.69275612e-01f, 1.65734753e-01f, 2.13461980e-01f, 8.04093033e-02f, -1.31885502e-02f, 1.08677343e-01f, 1.39721707e-01f, -5.80510050e-02f,
  2.72752177e-02f, 5.72354421e-02f, -9.62592363e-02f, 1.27312616e-01f, -6.89887116e-03f, -2.35505914e-03f, 5.17360494e-02f, 5.20543708e-03f, 5.61062582e-02f, -4.96420041e-02f,
  3.00294291e-02f, -8.34896490e-02f, -1.22185588e-01f, -1.52476162e-01f, 6.33499920e-02f, 1.14329746e-02f, -8.78628269e-02f, -1.35656883e-04f, -1.71156332e-01f, -9.60091725e-02f,
  1.00769013e-01f, -2.27885321e-02f, -6.29506856e-02f, -2.53636506e-03f, 4.44367900e-02f, -3.34168710e-02f, -3.26445103e-02f, -9.65864062e-02f, -2.57082358e-02f, -2.43824720e-02f,
  -8.15536827e-02f, -6.07430413e-02f, -3.22510414e-02f, -5.03014810e-02f, 2.92744720e-03f, -4.53786552e-02f, 8.37759227e-02f, 2.52433848e-02f, 6.74869344e-02f, 3.69070023e-02f,
  9.52532440e-02f, 2.13028491e-02f, 8.92121196e-02f, -1.25100911e-01f, 1.11886580e-02f, 4.60939705e-02f, -7.44341910e-02f, 5.39061688e-02f, 5.70148230e-02f, -5.33765852e-02f,
  -3.28047797e-02f, -5.92473857e-02f, -2.68363766e-02f, -8.00739527e-02f, -6.46211356e-02f, -2.43738424e-02f, 5.68107404e-02f, -1.04864212e-02f, 7.81997219e-02f, 2.61050668e-02f,
  -5.91430701e-02f, 2.47775577e-03f, 8.50950405e-02f, -5.38173541e-02f, 6.93645701e-02f, 5.61016090e-02f, -5.42574236e-03f, -1.26660243e-01f, 9.51266885e-02f, -7.61099383e-02f,
  8.09879825e-02f, 2.33912468e-02f, 5.89351431e-02f, -1.33017590e-02f, 8.65607802e-03f, -4.80340347e-02f, -3.03768720e-02f, -3.88606265e-02f, 1.27283735e-02f, -2.51243263e-02f,
  6.11177310e-02f, -7.29645640e-02f, 1.65939443e-02f, -7.27336630e-02f, 7.35289827e-02f, 4.17543203e-02f, -6.02037087e-02f, -1.21140946e-02f, -1.62829850e-02f, -1.14164487e-01f,
  -2.80241352e-02f, -5.74162900e-02f, 6.66299388e-02f, 5.40299974e-02f, 1.99386589e-02f, 1.87460277e-02f, -5.61920479e-02f, -3.35878655e-02f, 3.71740758e-02f, -3.90546285e-02f,
  -3.77093554e-02f, -3.75383534e-02f, 7.57616535e-02f, 6.70928136e-02f, 3.24737802e-02f, -8.64648893e-02f, -9.27256793e-02f, 2.01907996e-02f, 4.52984236e-02f, -6.29066443e-03f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  1.04459219e-01f, 9.91424695e-02f, 1.28256707e-02f, 4.29896787e-02f, 1.42275421e-02f, -1.62138732e-03f, -1.16970195e-02f, -2.45288759e-02f, 8.38117152e-02f, 1.27294645e-01f,
  7.13205561e-02f, -1.71971247e-02f, 8.97002146e-02f, 6.15582317e-02f
};

// L1_fan_Wp (Shape: 25 x 64)
const int L1_fan_Wp_rows = 25;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  1.04961731e-01f, 7.73034943e-03f, -5.05766682e-02f, -9.01931375e-02f, -2.62015848e-03f, -5.34832627e-02f, -3.96142043e-02f, -4.28907126e-02f, 4.17515151e-02f, -3.02380025e-02f,
  -1.32989049e-01f, -7.62016922e-02f, -1.02732062e-01f, -6.90230653e-02f, -1.59773335e-01f, 9.87713039e-03f, -1.08466350e-01f, 3.41609977e-02f, 4.58270311e-02f, 4.51518334e-02f,
  -6.16141818e-02f, -8.93487036e-02f, 1.36536404e-01f, 3.91217843e-02f, 6.66346624e-02f, 2.31260374e-01f, 1.07106484e-01f, 1.87029149e-02f, -8.75073075e-02f, -1.65284425e-01f,
  -1.33541524e-01f, -2.50548078e-03f, -7.18284845e-02f, 1.09088235e-01f, 1.02328606e-01f, -2.46903617e-02f, 7.03266487e-02f, -1.15017816e-01f, 4.33632843e-02f, -1.73311979e-01f,
  -3.55225652e-02f, 5.51175699e-02f, -1.40065789e-01f, 1.27630726e-01f, -2.41629869e-01f, -1.29156634e-01f, -2.26979345e-01f, 1.94187105e-01f, -2.01494440e-01f, -5.50256707e-02f,
  1.20920956e-01f, -7.21333846e-02f, -5.34907132e-02f, -6.01699986e-02f, -8.60990882e-02f, 9.85665694e-02f, -9.63750854e-02f, -7.42331967e-02f, 2.80246623e-02f, -3.97545323e-02f,
  1.65901795e-01f, -6.24689311e-02f, -7.43849427e-02f, 4.00964506e-02f, 6.45663738e-02f, 1.32635638e-01f, -4.11060043e-02f, -2.02327464e-02f, -2.81853676e-02f, -1.55659765e-01f,
  2.03831583e-01f, 3.89185213e-02f, -1.11654215e-01f, 1.05990730e-01f, -4.66914177e-02f, -7.96477795e-02f, -1.15765736e-01f, -1.34552062e-01f, 9.01915655e-02f, 9.86291692e-02f,
  -3.33907157e-02f, 3.78137678e-02f, 1.87099371e-02f, 7.96048418e-02f, -2.95484513e-02f, -1.10386930e-01f, -1.45344466e-01f, 6.47854805e-03f, 1.16093792e-01f, -2.78333604e-01f,
  2.16436498e-02f, 1.38625547e-01f, 1.02287017e-01f, 8.99887085e-02f, 1.71966955e-01f, -8.11158642e-02f, -9.69974995e-02f, 1.29663259e-01f, -1.18617058e-01f, 1.02172233e-01f,
  5.54686934e-02f, -9.17258672e-03f, 5.42892665e-02f, 1.65924415e-01f, -4.28626314e-02f, -8.99743587e-02f, 2.18820110e-01f, -1.10223278e-01f, 2.30952367e-01f, 1.84419647e-01f,
  2.51453102e-01f, -2.16774926e-01f, 6.54287189e-02f, -7.92011023e-02f, -1.11147165e-01f, 8.57501104e-02f, 1.54832052e-02f, -8.04480761e-02f, 7.08143339e-02f, -1.21534705e-01f,
  -2.88007576e-02f, 2.33512409e-02f, 5.69035150e-02f, 4.16800566e-02f, -5.86454831e-02f, 4.32324316e-03f, 7.12289736e-02f, -4.34923470e-02f, 9.29516330e-02f, -6.64983019e-02f,
  9.63123573e-04f, 1.09947905e-01f, -6.11695871e-02f, 1.94425620e-02f, 1.06034085e-01f, 5.50057553e-02f, -5.65922214e-03f, -4.23047878e-02f, -8.68758559e-02f, 6.31133020e-02f,
  6.79402947e-02f, 7.70167187e-02f, 7.50842467e-02f, 3.93986069e-02f, 6.46076277e-02f, 6.80674464e-02f, 1.14943884e-01f, 7.45658576e-03f, 2.98749264e-02f, 5.49857318e-02f,
  3.63444015e-02f, 1.29807323e-01f, 9.74191278e-02f, -2.22137898e-01f, -3.00023463e-02f, -4.92589623e-02f, 1.93544794e-02f, -1.08017877e-01f, 1.26167446e-01f, 7.34100938e-02f,
  -2.40705803e-01f, 3.25190998e-03f, -1.33761704e-01f, -1.12115160e-01f, 4.67360504e-02f, 1.01833686e-01f, 1.46068797e-01f, -1.50536507e-01f, -1.17598616e-01f, -1.38169840e-01f,
  -3.53623927e-02f, 2.65802965e-02f, -9.46254805e-02f, 7.87612796e-02f, -1.09609090e-01f, -3.86085033e-01f, -7.40614831e-02f, -1.21045612e-01f, 5.41721843e-02f, 1.72223464e-01f,
  -1.24945287e-02f, 1.01639211e-01f, 3.77593078e-02f, 1.76647782e-01f, -1.03653505e-01f, 1.51410252e-01f, -8.73275995e-02f, -1.02758696e-02f, -6.63257390e-02f, -2.35610511e-02f,
  1.35600403e-01f, 7.86862373e-02f, -3.08713387e-03f, -5.39933741e-02f, -4.13148068e-02f, -6.86784983e-02f, 2.89744465e-03f, -1.18139990e-01f, 1.12257779e-01f, -5.56447096e-02f,
  1.69150941e-02f, -7.21895620e-02f, 4.75715101e-02f, -1.33721441e-01f, 2.44168155e-02f, -5.01423329e-02f, 1.15767773e-02f, 9.11299139e-02f, 1.48739934e-01f, -1.66658009e-03f,
  -1.51074529e-02f, 4.07743081e-02f, -1.31863400e-01f, -1.17618173e-01f, -9.56624001e-02f, -7.61758089e-02f, 1.00210264e-01f, -1.86657190e-01f, -4.26765159e-02f, 5.88816293e-02f,
  -6.40602708e-02f, -5.56637254e-03f, 1.53761223e-01f, -1.27166867e-01f, -9.95584875e-02f, 2.67868228e-02f, -6.36737037e-04f, 8.22324306e-02f, 6.74291775e-02f, 7.64230341e-02f,
  -1.28124028e-01f, 1.24711068e-02f, 7.69221410e-02f, 2.34963316e-02f, 3.85171967e-03f, -1.47033095e-01f, 1.59066781e-01f, 1.94649354e-01f, 5.04431129e-02f, -2.53454357e-01f,
  1.24708682e-01f, 6.68504164e-02f, -9.03285965e-02f, 1.71906516e-01f, -1.92657933e-02f, 1.32578894e-01f, 1.10893950e-01f, -6.66690692e-02f, 9.21826288e-02f, -3.09525970e-02f,
  -8.65752175e-02f, 3.85229848e-02f, -1.95890255e-02f, -9.34989378e-02f, 9.88737494e-02f, -1.56624660e-01f, 1.11637577e-01f, 2.06389371e-02f, -6.03494123e-02f, -3.47307436e-02f,
  2.59932410e-02f, 7.99106658e-02f, 4.05210219e-02f, 1.59910828e-01f, 4.70733345e-02f, -2.12711319e-02f, -1.02744199e-01f, 1.25985578e-01f, 9.56120566e-02f, 9.95810404e-02f,
  7.67065510e-02f, 9.05308723e-02f, 6.66664168e-02f, -2.16592588e-02f, -1.83366537e-02f, -5.10714985e-02f, -5.18616438e-02f, -4.09937277e-02f, 1.52269006e-01f, 5.65561093e-02f,
  -5.66792442e-03f, -1.56757042e-01f, -5.85630275e-02f, 1.00553304e-01f, 7.72348866e-02f, -5.55433072e-02f, 3.68192084e-02f, -2.40849461e-02f, -1.52499527e-01f, -1.32664382e-01f,
  -6.56174868e-02f, -1.39217556e-01f, 1.04221620e-01f, 6.36477023e-02f, 1.73886139e-02f, 6.86703548e-02f, -2.89676577e-01f, -4.80877087e-02f, 1.87550411e-01f, 7.89450258e-02f,
  -2.03363255e-01f, -1.68826848e-01f, 3.46357413e-02f, -1.61095545e-01f, -3.37096527e-02f, -6.19899258e-02f, -1.05833486e-01f, 8.65085050e-02f, -1.33304760e-01f, 1.46836728e-01f,
  -1.78291991e-01f, -5.62847406e-02f, 2.02154461e-02f, 1.64333522e-01f, -5.57972863e-02f, -2.80671474e-02f, 5.96922226e-02f, -3.35982442e-02f, -1.11541793e-01f, -5.47750145e-02f,
  1.31708995e-01f, 5.83816618e-02f, 4.81506698e-02f, 6.65642917e-02f, 3.44531164e-02f, -7.58232549e-02f, -2.76621599e-02f, -1.92241073e-02f, -7.42987841e-02f, -1.05316631e-01f,
  2.74672583e-02f, 1.09689005e-01f, 5.27083613e-02f, 4.54794392e-02f, -1.07369073e-01f, 1.13314309e-04f, 7.62398317e-02f, 4.42391038e-02f, 1.21494755e-01f, -8.23460594e-02f,
  -2.73086689e-02f, -9.38359573e-02f, -7.56650344e-02f, 3.70870456e-02f, -3.69367115e-02f, 7.46133327e-02f, 4.78502773e-02f, 8.47946331e-02f, 1.68066069e-01f, -6.86900541e-02f,
  -1.58760503e-01f, -1.67551994e-01f, -5.63516691e-02f, 2.62974184e-02f, 1.33979857e-01f, -3.44638266e-02f, 1.34628238e-02f, 1.04292236e-01f, -5.43908961e-02f, 1.36669680e-01f,
  -4.62876484e-02f, -2.93955412e-02f, -4.06060554e-02f, 7.54261836e-02f, -8.42897594e-02f, -1.05491709e-02f, 1.78451374e-01f, -7.03655854e-02f, -5.34320585e-02f, 3.09096985e-02f,
  1.49010413e-03f, 1.10571623e-01f, 9.03599113e-02f, -2.05191765e-02f, 2.98324823e-02f, -1.31525591e-01f, -4.75218482e-02f, -9.45953131e-02f, -5.43061122e-02f, 1.18585728e-01f,
  -2.02413537e-02f, -3.68022956e-02f, -1.22677855e-01f, -1.07430264e-01f, 8.02521110e-02f, 1.74848624e-02f, 5.38617112e-02f, -6.67248070e-02f, -1.57113690e-02f, 8.11984017e-02f,
  1.61193073e-01f, -1.27016574e-01f, -5.83905652e-02f, -6.92271590e-02f, 8.22609365e-02f, 8.79431739e-02f, 1.26565754e-01f, -1.53419942e-01f, 4.47961874e-02f, 3.48254144e-02f,
  -2.89895460e-02f, 5.61765097e-02f, 7.07621723e-02f, 5.44137396e-02f, 2.05005873e-02f, -3.74785736e-02f, 1.17105432e-01f, -3.23956087e-02f, -1.54446855e-01f, -9.56582651e-03f,
  -2.01735198e-02f, -5.55980243e-02f, 6.04233444e-02f, 1.09235503e-01f, -5.86038418e-02f, -1.45291463e-01f, 1.39753714e-01f, 7.18949884e-02f, 2.00160339e-01f, -4.88575622e-02f,
  1.28024191e-01f, 8.63700584e-02f, -1.42632768e-01f, 2.54114747e-01f, 1.20699927e-01f, 9.07307938e-02f, 4.37860824e-02f, -1.79645658e-01f, 8.09586346e-02f, 1.44974291e-01f,
  2.01434344e-01f, 1.63090050e-01f, -9.41878837e-03f, 1.33232266e-01f, -1.17138542e-01f, 9.04844105e-02f, 2.03876883e-01f, 4.75633983e-03f, -5.44006526e-02f, -1.19201496e-01f,
  -7.98901245e-02f, -5.64159490e-02f, 4.96582277e-02f, 1.48253009e-01f, -4.03127111e-02f, 2.63238568e-02f, -9.90158692e-02f, -1.31076232e-01f, 1.25249282e-01f, 1.07745506e-01f,
  1.03294790e-01f, 4.32133265e-02f, 4.47549783e-02f, -3.48468013e-02f, -6.45835623e-02f, 1.08663425e-01f, 1.11760721e-01f, 1.22408420e-01f, 3.22056971e-02f, 1.44077316e-01f,
  1.15110420e-01f, 1.17746234e-01f, -1.67734921e-02f, 5.32270595e-02f, 6.09003752e-02f, 1.14338594e-02f, 9.75713730e-02f, -2.84197032e-02f, 9.71236005e-02f, 1.12736925e-01f,
  1.70951132e-02f, 1.24238394e-01f, 1.14653766e-01f, 1.21006399e-01f, 1.74915388e-01f, -3.73929664e-02f, 1.91843174e-02f, -7.46830627e-02f, -1.32878840e-01f, 9.06294286e-02f,
  -2.42428407e-02f, 1.50773033e-01f, -1.69317529e-01f, 2.36553431e-01f, -1.45495728e-01f, 7.86248315e-03f, -1.80854008e-01f, -1.16752662e-01f, 1.04924478e-01f, 2.25762233e-01f,
  -2.32363135e-01f, 1.41644672e-01f, -2.58251671e-02f, -9.38733816e-02f, -2.49512836e-01f, -1.71082079e-01f, -3.79506126e-02f, 1.52756274e-01f, 7.77629092e-02f, 7.30038881e-02f,
  1.81985632e-01f, 1.51216328e-01f, -1.43577317e-02f, 6.54438436e-02f, -6.08412512e-02f, 5.13440408e-02f, -1.30041435e-01f, -8.40142220e-02f, 1.98725194e-01f, -4.04193997e-02f,
  -2.65909843e-02f, 6.92922473e-02f, -1.92712262e-01f, 7.94497058e-02f, 6.52953461e-02f, -1.10780545e-01f, 8.58692676e-02f, -1.37451347e-02f, -1.83106750e-01f, 1.04213879e-01f,
  -4.03745137e-02f, 8.79664123e-02f, -8.65122229e-02f, 3.45316343e-02f, -6.80211037e-02f, 3.25435959e-02f, 1.11085519e-01f, -2.65531354e-02f, -1.11854561e-01f, 8.63370225e-02f,
  -8.66545066e-02f, -1.71039384e-02f, -5.80781996e-02f, 3.70229734e-03f, -3.72907668e-02f, 1.34985447e-02f, 1.71465486e-01f, -4.18325663e-02f, -2.14886934e-01f, -1.16651028e-01f,
  1.10784777e-01f, -7.01759681e-02f, 1.09395161e-01f, 2.62087107e-01f, 3.98683064e-02f, -1.12421446e-01f, -2.25981697e-01f, -3.17948461e-02f, -2.80295461e-02f, 6.22589365e-02f,
  1.52477443e-01f, -3.25805128e-01f, -1.09947897e-01f, 3.81368995e-02f, 1.69245183e-01f, 2.45451212e-01f, 7.40345009e-03f, -6.74997121e-02f, 2.34357528e-02f, -3.13173622e-01f,
  -1.80649757e-01f, -4.54485863e-02f, 3.27178873e-02f, -1.55405421e-03f, -1.90464690e-01f, -1.18697807e-01f, 3.61822844e-02f, 1.16689883e-01f, -8.04409906e-02f, -3.70513502e-04f,
  8.97921100e-02f, 4.44195569e-02f, 1.89228371e-01f, -2.07694843e-01f, 4.60133441e-02f, 5.26212528e-02f, -4.89564501e-02f, 1.80124313e-01f, 1.56383187e-01f, 8.46165195e-02f,
  1.00322373e-01f, -8.80298093e-02f, 1.23065569e-01f, 5.76726310e-02f, -1.39978155e-01f, 5.00470474e-02f, -1.19219787e-01f, 8.23454410e-02f, -4.47273925e-02f, -1.08205844e-02f,
  -7.67202601e-02f, -1.72535591e-02f, -1.09546624e-01f, 7.18585253e-02f, -9.38054360e-03f, 9.47420821e-02f, -3.55470702e-02f, 6.10373951e-02f, 8.81782100e-02f, 6.26596957e-02f,
  9.37522054e-02f, -2.43131340e-01f, -1.60500661e-01f, 7.45406300e-02f, 6.63774088e-02f, 2.22046122e-01f, -8.22821483e-02f, -1.08615398e-01f, 6.33930415e-02f, 8.41762573e-02f,
  1.16886841e-02f, -2.17895228e-02f, 1.45147830e-01f, 1.94109499e-01f, -6.25012517e-02f, -2.44564936e-02f, 7.47025460e-02f, 4.97755669e-02f, 1.53189495e-01f, 3.91781367e-02f,
  1.29925594e-01f, 5.01968637e-02f, 4.01435912e-01f, -1.36136487e-01f, -7.43485242e-02f, -1.95933834e-01f, -1.01660015e-02f, 6.72363117e-02f, -2.15902813e-02f, -2.92295311e-02f,
  -2.51015904e-03f, -1.36802411e-02f, -2.16178484e-02f, -9.54022035e-02f, 1.24358639e-01f, 2.28506684e-01f, 2.16488630e-01f, -1.20709516e-01f, 1.53144538e-01f, -9.45225805e-02f,
  1.24977541e-03f, 4.83294725e-02f, -1.20698186e-02f, 1.24127939e-01f, -4.75496612e-02f, 1.17720269e-01f, 1.22574769e-01f, -6.70212805e-02f, 9.66901034e-02f, 1.72631405e-02f,
  1.16741750e-02f, 1.12634219e-01f, -1.14543229e-01f, 1.99934351e-03f, -1.63927048e-01f, 6.83310777e-02f, -5.99661320e-02f, -9.13632214e-02f, 7.63892606e-02f, -1.42560974e-01f,
  6.93593919e-02f, 6.32600412e-02f, 7.84687102e-02f, -6.89224005e-02f, -1.38312697e-01f, -1.40255243e-02f, -1.10202208e-01f, 7.55482242e-02f, -2.45889463e-03f, 1.34331405e-01f,
  6.76019415e-02f, -9.31922942e-02f, 9.12071764e-02f, -8.27944651e-02f, 1.43082216e-01f, 7.73630440e-02f, -8.24949145e-02f, -1.78531818e-02f, 1.00710047e-02f, 2.60945022e-01f,
  1.94066599e-01f, -1.66823834e-01f, -5.86242881e-03f, -1.35639936e-01f, -1.47603434e-02f, 6.66346699e-02f, 7.23256692e-02f, 2.78402507e-01f, 1.30548514e-02f, -6.53134361e-02f,
  -4.80514802e-02f, 3.20939533e-02f, 1.18747577e-02f, -1.79227013e-02f, 1.79741289e-02f, -7.97087699e-02f, 5.92703260e-02f, -1.03006534e-01f, -1.47440648e-02f, -7.43331620e-03f,
  -1.10246249e-01f, 3.52075025e-02f, -7.98063446e-03f, -1.16976224e-01f, -7.71315172e-02f, 6.19604029e-02f, -9.98280197e-02f, -7.22835306e-03f, -8.39764848e-02f, -2.08464801e-01f,
  -9.68133882e-02f, -7.92950168e-02f, -1.03366010e-01f, -3.86173390e-02f, -1.83688715e-01f, -8.61991048e-02f, -1.13225989e-01f, 3.30068320e-02f, -3.26401889e-02f, 4.82438244e-02f,
  -1.62856020e-02f, -1.32897601e-01f, -1.08908191e-01f, -1.32752851e-01f, 6.97522536e-02f, -8.52951314e-03f, 8.78485572e-03f, 1.29623875e-01f, -8.88431147e-02f, 1.46420673e-01f,
  2.08233818e-02f, -8.48703012e-02f, -4.58192490e-02f, -1.23292655e-01f, -6.42093420e-02f, -1.75113291e-01f, -1.37496918e-01f, 1.59148663e-01f, 1.71068907e-02f, 2.24946752e-01f,
  -1.00343049e-01f, -6.48300275e-02f, -2.19076380e-01f, -1.91891447e-01f, -1.00926079e-01f, 1.75201446e-01f, 1.45747006e-01f, 3.04489940e-01f, -3.83676440e-02f, -1.56725556e-01f,
  1.19583726e-01f, -1.76445171e-01f, -1.83757633e-01f, -1.71689391e-01f, 7.75378719e-02f, -1.39152110e-01f, 2.36461516e-02f, 6.08150661e-02f, -1.41900688e-01f, -2.31562518e-02f,
  -1.55473456e-01f, 1.44729331e-01f, 1.21029718e-02f, 6.36901408e-02f, 2.26566583e-01f, -1.39967516e-01f, 3.64687364e-03f, 5.59034385e-02f, -9.89789739e-02f, 7.29110613e-02f,
  -1.06551655e-01f, 2.57823057e-03f, -8.14482197e-02f, -3.51690277e-02f, 7.55269676e-02f, -6.79928288e-02f, -1.07306754e-02f, 5.67501858e-02f, -2.19029444e-03f, -9.02786478e-02f,
  -1.59331754e-01f, -8.06249231e-02f, -1.08916005e-02f, -2.75360346e-02f, 3.99802066e-03f, 8.88739973e-02f, -4.38521653e-02f, -9.72540453e-02f, 4.71973279e-03f, -1.54912606e-01f,
  -1.17372826e-01f, 1.21672414e-01f, 6.93812072e-02f, -9.24589932e-02f, -2.23322436e-01f, 3.56539078e-02f, -4.04212810e-02f, -1.78318813e-01f, -3.98940779e-02f, -5.02952635e-02f,
  -3.08776367e-02f, -2.02069923e-01f, -3.46335955e-02f, -1.68253705e-01f, -1.50752798e-01f, 2.59651877e-02f, 2.24506125e-01f, -1.38792425e-01f, -1.94958135e-01f, -1.87399492e-01f,
  1.53195709e-01f, 3.89836021e-02f, 9.80668068e-02f, 1.43599045e-02f, -1.29947692e-01f, -2.23812252e-01f, -1.38697401e-01f, -9.23231170e-02f, 1.71985459e-02f, 6.51567802e-02f,
  -1.50476277e-01f, 9.92512405e-02f, -7.75868744e-02f, 9.22113210e-02f, -1.29561350e-02f, 4.48325202e-02f, -1.10254206e-01f, -1.90827847e-02f, -1.21558793e-01f, 1.66646056e-02f,
  4.26014289e-02f, -6.73914030e-02f, 1.70256823e-01f, 6.73500672e-02f, -3.47956782e-03f, 3.91947664e-03f, -7.51751512e-02f, -8.40737671e-02f, 1.46858150e-03f, -7.38168955e-02f,
  -7.87325576e-02f, -2.92535294e-02f, 4.04096581e-02f, 1.34617031e-01f, -3.39146666e-02f, -4.93263789e-02f, -1.98791847e-02f, -8.39031115e-03f, 3.00964043e-02f, -4.14984711e-02f,
  1.10232830e-01f, 2.32834704e-04f, -7.70594701e-02f, 3.36536840e-02f, 1.64011434e-01f, 4.72789519e-02f, -1.19725160e-01f, 3.07211429e-01f, -1.05411932e-01f, 1.07615441e-01f,
  1.19851679e-01f, -1.62328780e-01f, -2.17465073e-01f, -4.27070260e-02f, -1.36943027e-01f, -2.07883939e-01f, 2.17599079e-01f, -1.29602805e-01f, -1.02770485e-01f, -6.97275391e-03f,
  1.14348315e-01f, -7.71606565e-02f, -2.63067722e-01f, -1.47625655e-02f, 2.60705855e-02f, 2.53519136e-02f, -2.79242933e-01f, -2.65886247e-01f, -2.83516496e-01f, 2.96686620e-01f,
  -4.38929647e-02f, 1.04996383e-01f, 1.59678131e-01f, -5.67167178e-02f, -1.40022654e-02f, 8.77536982e-02f, -6.12846985e-02f, 1.33899733e-01f, -1.79271977e-02f, 6.86396956e-02f,
  9.84461233e-02f, 1.06435321e-01f, -7.28109106e-02f, -9.94600430e-02f, -6.17895871e-02f, 1.60465345e-01f, -1.33466259e-01f, 3.83653082e-02f, 5.12452014e-02f, -6.37058169e-02f,
  6.69447184e-02f, -9.39642489e-02f, 9.38777626e-02f, -1.10387459e-01f, 6.29157126e-02f, 1.18429594e-01f, -3.39601859e-02f, -1.39877871e-01f, -3.98675762e-02f, 6.42211363e-03f,
  1.98413967e-03f, -5.79267628e-02f, 1.48461247e-02f, -3.56222987e-02f, -3.51804793e-02f, 1.62403315e-01f, 1.24808319e-01f, 1.46166891e-01f, -8.35010186e-02f, 7.91783109e-02f,
  5.93235828e-02f, -1.46126121e-01f, -1.29064962e-01f, 2.34439038e-02f, -1.57453999e-01f, 1.85132161e-01f, 2.04092547e-01f, 1.59935087e-01f, 1.66539177e-01f, 1.07138082e-01f,
  -9.76624433e-03f, 2.11378895e-02f, -6.26130179e-02f, 4.17804904e-02f, -1.57893114e-02f, 1.54903652e-02f, 1.18833914e-01f, 7.09570274e-02f, -5.42008653e-02f, -1.43672854e-01f,
  1.49949804e-01f, 2.67568409e-01f, 1.68432608e-01f, -4.82802652e-02f, 4.67641354e-02f, 2.65629385e-02f, -1.20667912e-01f, -4.17781286e-02f, 3.94045338e-02f, -7.24546015e-02f,
  1.14027306e-01f, -2.39286255e-02f, 9.86729711e-02f, 7.52993599e-02f, -2.91417204e-02f, -8.77945870e-02f, 2.38328502e-02f, -9.69507471e-02f, 1.07589193e-01f, -8.84085149e-02f,
  1.09664604e-01f, 1.01362206e-01f, 6.04445487e-02f, 1.13426633e-01f, -1.83909535e-02f, -6.62924498e-02f, -2.11418960e-02f, 1.23219274e-01f, -1.14591837e-01f, -1.07471623e-01f,
  -8.97452980e-02f, -1.17651932e-01f, -2.88219135e-02f, -9.13543329e-02f, -2.73118597e-02f, -5.02538234e-02f, 7.49614686e-02f, 3.48171704e-02f, 6.76018745e-02f, -1.45843461e-01f,
  1.68208722e-02f, 4.93118800e-02f, 8.72668475e-02f, 5.31122610e-02f, -1.20862678e-01f, -2.00327545e-01f, -3.04361107e-03f, -5.01754519e-04f, 1.62268683e-01f, 9.49544609e-02f,
  -2.19824985e-02f, -1.53030887e-01f, -1.65337652e-01f, 5.96507713e-02f, 4.78118435e-02f, -1.74751505e-01f, 5.35767991e-03f, 1.29659116e-01f, -5.67094795e-02f, 1.44231349e-01f,
  -1.17184334e-01f, -1.21365361e-01f, 2.22466245e-01f, 8.33190829e-02f, -7.90965185e-02f, 3.96014750e-03f, 2.00405836e-01f, -9.19931158e-02f, 9.98960808e-02f, 4.65889946e-02f,
  -1.03791356e-01f, 3.82592604e-02f, -5.03410362e-02f, -6.61990047e-02f, -1.08599655e-01f, -1.27641171e-01f, 8.34871829e-02f, 1.15984850e-01f, 9.61670429e-02f, 1.28451303e-01f,
  2.94295419e-03f, -2.10729152e-01f, 1.18130609e-01f, -1.04535781e-01f, -1.12562299e-01f, -8.60894322e-02f, -3.98018807e-02f, -1.25045240e-01f, -4.96112593e-02f, -1.46074787e-01f,
  -4.97074500e-02f, 3.46855409e-02f, -9.28111840e-03f, 9.66957137e-02f, -6.58213198e-02f, 1.28100455e-01f, -1.08823903e-01f, -9.44394693e-02f, -4.34358008e-02f, -1.13713615e-01f,
  -5.74794859e-02f, -4.36962284e-02f, 9.56940055e-02f, -4.68355268e-02f, -1.23582203e-02f, 5.57617471e-02f, -1.93442442e-02f, 2.37654056e-02f, -1.38494849e-01f, 1.66926816e-01f,
  -1.92596346e-01f, -3.54964212e-02f, 5.77070471e-03f, -1.32021666e-01f, -1.15548179e-01f, 8.27792510e-02f, 1.28351063e-01f, 4.65602130e-02f, 9.38369036e-02f, 1.55028924e-02f,
  -6.10084599e-03f, 7.50850840e-03f, -6.26494065e-02f, -1.47322789e-01f, -1.22335494e-01f, 1.49724424e-01f, 4.23829928e-02f, 2.51006544e-01f, -4.59102802e-02f, -2.32364163e-01f,
  1.36009216e-01f, 1.70450639e-02f, -1.73872277e-01f, -1.99956089e-01f, 1.54463291e-01f, -1.64063387e-02f, -1.11864589e-01f, -1.03249021e-01f, 6.47458062e-02f, -1.19798250e-01f,
  3.35298963e-02f, 1.12274140e-01f, 6.42400526e-04f, 1.88417837e-01f, 9.58116949e-02f, -1.23395957e-01f, -1.52846292e-01f, -4.18717228e-02f, -1.21376012e-02f, -6.26806095e-02f,
  -7.71584883e-02f, 7.22325966e-02f, 8.40552896e-02f, -1.01270489e-01f, 1.37879863e-01f, -1.54370546e-01f, 1.17516741e-01f, 6.18320741e-02f, 1.46665797e-01f, -1.48670450e-01f,
  -5.27196527e-02f, 1.60962753e-02f, 8.81335139e-02f, -1.22588515e-01f, 4.67613526e-02f, -8.21956396e-02f, -1.33746132e-01f, 1.40559852e-01f, -7.46446997e-02f, 6.90599456e-02f,
  -2.46015824e-02f, -7.83691369e-03f, 9.21230987e-02f, -1.79749746e-02f, 1.42983213e-01f, 9.39813256e-02f, -1.38717622e-01f, 1.93745345e-01f, 1.01194464e-01f, -1.98026553e-01f,
  1.57386422e-01f, 1.58802092e-01f, -2.69249268e-02f, -7.09589047e-04f, -2.08159741e-02f, -1.31821886e-01f, 1.23422104e-03f, 1.72957033e-01f, 2.19736308e-01f, -5.01136333e-02f,
  -6.63098246e-02f, -6.46623690e-03f, 2.26855695e-01f, 1.91936061e-01f, 1.31641075e-01f, 6.79323450e-02f, 7.98409879e-02f, 1.47804201e-01f, -1.74073502e-01f, -2.41595916e-02f,
  1.36383057e-01f, -1.79714970e-02f, -5.38480394e-02f, -1.26434937e-01f, 1.13159772e-02f, -1.28086790e-01f, -9.63755399e-02f, -1.80860043e-01f, 7.83336908e-02f, 4.16389704e-02f,
  2.33617406e-02f, -7.21071661e-02f, -1.14044331e-01f, -9.79920775e-02f, -5.61458208e-02f, 2.27183960e-02f, -1.20475918e-01f, -6.76656887e-02f, 1.52461126e-01f, -9.85035896e-02f,
  5.20150401e-02f, -1.03921384e-01f, 3.39843147e-02f, 4.40968201e-02f, -7.62709305e-02f, -5.53763821e-04f, -2.76659988e-02f, 9.84394923e-02f, 1.57017633e-01f, -6.91186637e-02f,
  1.55477285e-01f, -2.66187638e-02f, 5.83415478e-02f, 5.35312295e-02f, -1.35491773e-01f, -1.38018876e-01f, -4.97070178e-02f, -9.77109298e-02f, 2.01293733e-03f, -2.71650720e-02f,
  -8.15752298e-02f, 1.02315836e-01f, 4.68045399e-02f, 2.35614087e-02f, 1.37474835e-02f, -2.04646319e-01f, 1.22673064e-01f, -2.07017750e-01f, -1.31637320e-01f, -1.16908260e-01f,
  2.06821084e-01f, 1.15298517e-01f, 8.83931741e-02f, -1.41513288e-01f, -7.37481639e-02f, -2.18461350e-01f, -5.62743507e-02f, 2.05950499e-01f, -7.73778483e-02f, -3.57420519e-02f,
  1.07959688e-01f, 9.47637856e-02f, 1.88950468e-02f, 1.40051454e-01f, 2.09787600e-02f, -1.37682110e-02f, 5.89827001e-02f, 7.44735263e-03f, -2.61948742e-02f, -1.07944138e-01f,
  5.70666641e-02f, 2.52570547e-02f, -2.11827442e-01f, -2.34637726e-02f, 1.57370195e-01f, -1.34053141e-01f, -4.57010306e-02f, 1.16741374e-01f, -1.61646977e-02f, -3.78747173e-02f,
  -4.84431162e-02f, -6.10760339e-02f, -2.60903724e-02f, 8.65980983e-03f, -6.22034222e-02f, 1.23152509e-01f, 1.74022496e-01f, 9.15822685e-02f, 1.58484504e-02f, -5.60388789e-02f,
  3.37433070e-02f, 5.82875684e-02f, 1.91039741e-02f, -4.20677848e-02f, 5.28769307e-02f, 2.17532995e-03f, 7.74014294e-02f, 1.87575698e-01f, 1.27250895e-01f, 5.05228564e-02f,
  1.89414188e-01f, 1.15354568e-01f, 1.00482598e-01f, -1.01890363e-01f, -2.31777251e-01f, -4.69389707e-02f, 3.03012971e-02f, 5.59801646e-02f, 7.81594738e-02f, 1.32439762e-01f,
  4.51947227e-02f, 2.37975344e-01f, -1.06264882e-01f, -1.00281209e-01f, -1.19588517e-01f, 8.19751248e-02f, 2.24423453e-01f, 8.40021595e-02f, -1.90202445e-01f, 8.67503360e-02f,
  1.35321990e-01f, -7.17707351e-02f, -7.05743358e-02f, 3.23697962e-02f, 1.61806300e-01f, 5.78892324e-03f, -6.38845637e-02f, -4.39897105e-02f, 4.53805365e-02f, 2.12282520e-02f,
  1.62595779e-01f, -7.44149014e-02f, 1.54437646e-02f, 7.82759711e-02f, -9.46080312e-02f, -6.97195381e-02f, -3.30054760e-02f, 1.32188290e-01f, 4.57187369e-02f, 1.39793515e-01f,
  -6.17945902e-02f, -3.98704372e-02f, 1.32025912e-01f, 4.70370688e-02f, 3.85768190e-02f, -8.15456957e-02f, 7.40178907e-03f, 1.17533235e-02f, 8.66082385e-02f, 2.01730151e-03f,
  7.62766898e-02f, -7.68162683e-02f, 3.71349417e-02f, 6.53405301e-03f, -1.57357771e-02f, 8.43424499e-02f, 7.47547895e-02f, 1.59117524e-02f, -1.15860336e-01f, 9.15015042e-02f,
  7.65468925e-02f, 1.26545029e-02f, -8.77111852e-02f, 3.37652341e-02f, 2.62223799e-02f, -7.13240821e-03f, -1.15470886e-01f, -9.12054926e-02f, -9.53132585e-02f, 4.66934554e-02f,
  1.49635449e-01f, 1.29675284e-01f, 6.47235885e-02f, -9.22124758e-02f, 5.64902946e-02f, 8.35501254e-02f, -1.56589095e-02f, -1.54283151e-01f, 6.71852157e-02f, 7.84036443e-02f,
  1.68660488e-02f, 2.40569767e-02f, -1.78095717e-02f, -9.07858163e-02f, -3.97670828e-02f, -1.10376373e-01f, 6.28223643e-02f, 1.47183254e-01f, 1.16173029e-01f, -8.63562226e-02f,
  2.71191373e-02f, -1.45792708e-01f, -3.43908146e-02f, -6.58635423e-02f, 6.32814365e-04f, -9.54232141e-02f, 9.75311920e-02f, 1.83550883e-02f, 2.15194412e-02f, -2.53817085e-02f,
  -1.30058497e-01f, 1.07367197e-02f, -4.05769050e-02f, -1.48145542e-01f, -1.23474449e-01f, -1.23454005e-01f, 1.29290983e-01f, -7.90231824e-02f, -6.41662106e-02f, 2.46841796e-02f,
  -1.52563378e-01f, -1.89686590e-03f, -7.70222694e-02f, -5.49908206e-02f, 7.28137605e-03f, -7.73759484e-02f, 5.74122667e-02f, 1.03137404e-01f, -4.30882908e-02f, 1.27073586e-01f,
  -7.04890192e-02f, 2.78435852e-02f, 8.35412815e-02f, -9.58656147e-02f, -7.61627182e-02f, 4.88501824e-02f, -9.33628157e-02f, -5.34357876e-02f, -1.54852405e-01f, 7.94543922e-02f,
  -2.53346980e-01f, 3.51056755e-02f, 4.65269648e-02f, -3.15513238e-02f, 1.91478893e-01f, 3.19236457e-01f, 2.81408411e-02f, -2.88078010e-01f, -1.53959878e-02f, -2.15223625e-01f,
  -1.13846697e-01f, -1.17414612e-02f, 3.14070433e-01f, -1.51581496e-01f, -3.49064916e-02f, -8.43213275e-02f, -6.07359083e-03f, -6.48113936e-02f, -1.47936568e-01f, 6.86396509e-02f,
  2.87201125e-02f, 1.03426725e-01f, -1.61706135e-01f, -1.87956855e-01f, 2.98645366e-02f, 1.47026718e-01f, -1.62428111e-01f, -2.65392680e-02f, -1.92040880e-03f, 1.11934774e-01f,
  -1.13855153e-01f, -1.26499478e-02f, -2.40325239e-02f, 1.83744371e-01f, -2.08613247e-01f, -1.63349018e-01f, 7.53205270e-02f, -1.51005119e-01f, 4.39956896e-02f, -6.11578189e-02f,
  6.40935227e-02f, 1.54726341e-01f, -7.23068714e-02f, 4.61270064e-02f, 1.27740771e-01f, -7.92422593e-02f, 1.24502555e-02f, -2.00705286e-02f, -8.58574212e-02f, 9.46753472e-02f,
  -4.98082824e-02f, 5.59918880e-02f, 9.05617252e-02f, -2.50782836e-02f, 2.27782484e-02f, -7.66334496e-03f, 1.70681775e-01f, 8.07870030e-02f, 9.27784219e-02f, -1.62015464e-02f,
  5.80776623e-03f, 5.73323891e-02f, -7.54190385e-02f, -1.85153529e-01f, -7.81827495e-02f, 1.76311836e-01f, 2.72234172e-01f, -1.35619715e-01f, -1.05083913e-01f, -7.09714070e-02f,
  -1.71396106e-01f, -2.26502702e-01f, -3.27271931e-02f, -1.83777213e-01f, 3.37925591e-02f, 2.81281900e-02f, 1.62694290e-01f, -1.21653574e-02f, -1.76050574e-01f, -2.47350708e-01f,
  1.59924343e-01f, -1.79159805e-01f, -1.16187707e-01f, -1.64429266e-02f, -1.26512736e-01f, -7.28058517e-02f, -4.94627208e-02f, 1.78407535e-01f, -1.62690386e-01f, 1.51870862e-01f,
  -3.74259241e-02f, -8.67659673e-02f, 4.03421447e-02f, 1.44881651e-01f, 1.41730711e-01f, 8.28917921e-02f, 1.44541442e-01f, 1.38536721e-01f, -1.69182599e-01f, 8.86866730e-03f,
  -1.16852978e-02f, 5.27946949e-02f, 4.50880863e-02f, 3.49319987e-02f, 3.87654565e-02f, -1.06566017e-02f, -9.67406556e-02f, 3.38234529e-02f, -8.91296193e-02f, 5.91790043e-02f,
  -2.85503604e-02f, 2.04255525e-02f, -3.03055383e-02f, 2.23502871e-02f, 6.42796978e-02f, 2.92473752e-02f, -3.88833657e-02f, 5.71726449e-02f, 9.34677199e-02f, 4.52399626e-02f,
  7.65185133e-02f, 1.47752076e-01f, -5.35200238e-02f, -8.48424658e-02f, -3.20455036e-03f, 1.44979298e-01f, 1.50378138e-01f, 8.47597898e-04f, 1.11267664e-01f, 7.58681074e-02f,
  6.93733664e-03f, 1.69627909e-02f, -7.01552629e-02f, -7.02709258e-02f, 1.44871492e-02f, 2.54957765e-01f, -2.10387215e-01f, 1.19457491e-01f, 1.02008060e-01f, -4.19204682e-03f,
  -9.61654782e-02f, -8.53220969e-02f, -2.97507402e-02f, 1.26968995e-01f, 1.03151731e-01f, -2.10558064e-02f, 7.48340711e-02f, -9.51493531e-02f, 9.86614525e-02f, -1.07463039e-01f,
  1.44216657e-01f, 1.09621055e-01f, -1.13202013e-01f, 2.02797470e-03f, 7.12706372e-02f, 9.03037097e-03f, -7.63234645e-02f, 1.67007335e-02f, -3.27436216e-02f, 1.44751862e-01f,
  -5.94430976e-02f, -1.44637674e-01f, 2.07594737e-01f, -3.51388659e-03f, -3.49735096e-02f, 1.35447353e-01f, 1.23667359e-01f, -7.85471052e-02f, -1.98806431e-02f, -1.30153686e-01f,
  -1.06429420e-01f, 5.40029258e-02f, -1.68216571e-01f, -1.13087177e-01f, -6.06841333e-02f, 4.80785035e-02f, 1.91889182e-02f, 9.64313596e-02f, -6.07057400e-02f, 7.87324551e-03f,
  -1.25501260e-01f, -7.37715513e-02f, -1.58105507e-01f, 8.44958946e-02f, -5.43330312e-02f, 1.15513235e-01f, 1.51190206e-01f, 9.90481302e-02f, 1.17353998e-01f, 9.12996680e-02f,
  9.54710990e-02f, 1.87283400e-02f, -5.57794943e-02f, -1.35314807e-01f, -8.37899968e-02f, 2.77423188e-02f, -1.62631795e-01f, 4.82655456e-03f, 2.72489619e-03f, 1.73902549e-02f,
  8.77045095e-02f, 1.36586794e-04f, 7.78264478e-02f, -1.54022768e-01f, -1.84299722e-01f, 1.18789151e-01f, 9.51427147e-02f, 1.91819549e-01f, -1.15563989e-01f, 1.82791471e-01f,
  -1.04159936e-01f, 3.74602973e-02f, 7.70879015e-02f, 2.62319863e-01f, -1.21555120e-01f, -4.51498516e-02f, 1.10048383e-01f, -3.70778120e-03f, -1.82932615e-02f, -5.58446757e-02f,
  -4.16147076e-02f, 3.36901605e-04f, -1.46914065e-01f, 4.06122208e-03f, 8.39500502e-02f, 9.44812074e-02f, 6.11672215e-02f, 6.58993274e-02f, -3.33397649e-02f, 1.00315973e-01f
};

// L1_fan_Wp_bar (Shape: 14 x 64)
const int L1_fan_Wp_bar_rows = 14;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  7.41584077e-02f, 1.07234223e-02f, -1.37531692e-02f, 6.96781799e-02f, 1.08738087e-01f, -5.09495623e-02f, 4.79871407e-02f, -4.71415631e-02f, 6.56451136e-02f, 1.28708228e-01f,
  1.45050555e-01f, -4.31789979e-02f, -4.08696383e-02f, 1.82357058e-01f, -1.21187288e-02f, -7.52853081e-02f, -1.19845845e-01f, 6.82806820e-02f, -1.06532328e-01f, -1.96532831e-02f,
  1.02963850e-01f, 9.21736807e-02f, 1.89231113e-01f, 4.15403098e-02f, 1.87581688e-01f, 1.33564740e-01f, 1.46154556e-02f, -1.37731835e-01f, -3.55546735e-03f, 1.15044758e-01f,
  -3.87905464e-02f, 3.84115987e-02f, 1.13626517e-01f, 2.38724172e-01f, -1.79946199e-01f, 1.00961402e-01f, 1.06615029e-01f, -7.36907125e-02f, -9.21023041e-02f, -8.53679255e-02f,
  1.37732118e-01f, 2.37866640e-01f, 1.90996882e-02f, 2.20635161e-01f, -4.02663872e-02f, 6.56337366e-02f, 1.63786545e-01f, -8.76456648e-02f, 7.41273910e-02f, 4.99853641e-02f,
  -1.66982301e-02f, -3.68053876e-02f, 3.32973003e-02f, 2.98563000e-02f, -2.63377512e-03f, 4.15712744e-02f, -6.46056756e-02f, -2.21588183e-02f, 6.53612018e-02f, 5.95624261e-02f,
  3.26708913e-01f, -2.27935035e-02f, 6.69689849e-02f, -1.05819134e-02f, -1.43320709e-02f, -2.87290085e-02f, -1.86719559e-02f, -7.58879036e-02f, 7.15560541e-02f, 1.23816617e-01f,
  4.94430587e-02f, 1.25366867e-01f, 5.16408347e-02f, 6.84284717e-02f, -4.48194594e-04f, 2.92091817e-02f, 7.62492940e-02f, 9.30544734e-03f, 1.32189959e-01f, 5.98232746e-02f,
  -5.61194196e-02f, -1.31393014e-03f, -4.08107936e-02f, 1.04914820e-02f, 7.71837905e-02f, 1.38808310e-01f, -4.93714474e-02f, 3.19189392e-03f, 4.44861874e-02f, 3.08223311e-02f,
  -1.27718598e-01f, 2.64036078e-02f, -5.76592535e-02f, 1.22109897e-01f, 1.89892009e-01f, 2.27339134e-01f, 4.75716358e-03f, -1.21450618e-01f, -1.64643586e-01f, 9.89283994e-02f,
  -6.43180758e-02f, -4.72388528e-02f, 1.39845878e-01f, -1.07976377e-01f, -1.19785601e-02f, 1.46611109e-01f, -1.49633080e-01f, 7.93571696e-02f, 7.13030025e-02f, -2.21362393e-02f,
  -7.58503228e-02f, -1.21059231e-01f, -9.29364935e-02f, 3.50580551e-02f, 9.09810886e-02f, 1.30671948e-01f, 8.86103138e-02f, -3.68360914e-02f, 1.36277243e-01f, 4.63041030e-02f,
  5.24260961e-02f, 1.98961180e-02f, -1.53904697e-02f, 1.92272235e-02f, 9.50819999e-02f, -6.59456104e-02f, 9.38250031e-03f, 1.56216383e-01f, 1.86302513e-02f, -1.37804374e-01f,
  -7.84387719e-03f, -9.45670530e-02f, 5.43647632e-02f, -9.08319801e-02f, -6.39449060e-03f, 5.95584735e-02f, 6.42574653e-02f, -1.02124214e-01f, -3.44689265e-02f, 6.51682317e-02f,
  -9.65498686e-02f, -5.43523356e-02f, -5.57614863e-02f, 5.80564104e-02f, 9.49825346e-02f, 7.14191943e-02f, -9.46457088e-02f, -1.17630839e-01f, -7.23472014e-02f, 1.02807321e-01f,
  -2.22464427e-02f, 4.74410355e-02f, 7.56618083e-02f, 8.06724280e-02f, -1.10507116e-01f, -2.85801403e-02f, 8.03348422e-02f, 1.29196510e-01f, -6.67544082e-02f, -1.07379660e-01f,
  -3.47226858e-02f, -1.05222225e-01f, 9.33966115e-02f, -9.24460068e-02f, -7.96681270e-02f, 5.08946143e-02f, 8.94312635e-02f, -7.80161917e-02f, -5.89759983e-02f, -5.14065661e-03f,
  -1.21233268e-02f, 4.08017263e-02f, 1.05552234e-01f, 1.19678423e-01f, -4.08324227e-02f, 6.75496310e-02f, 1.27421618e-01f, 4.21201661e-02f, -9.40753073e-02f, -6.45714924e-02f,
  8.76768529e-02f, 3.58017087e-02f, 6.26104549e-02f, 3.62942591e-02f, 1.02308728e-01f, 3.43639478e-02f, 1.75904483e-02f, -8.27719718e-02f, 7.48427883e-02f, 6.65860577e-03f,
  -1.30335540e-01f, 6.72931550e-03f, -4.51976359e-02f, -1.64380614e-02f, -4.12521437e-02f, 1.13291115e-01f, 9.62883905e-02f, 7.84525461e-03f, 8.44058469e-02f, -1.91184841e-02f,
  6.32868782e-02f, 6.44937754e-02f, -1.24792382e-01f, 1.26976579e-01f, 8.09967369e-02f, -6.76075742e-02f, 9.34168510e-03f, -4.97501828e-02f, 4.15794253e-02f, 6.90846071e-02f,
  1.34073034e-01f, -7.78514892e-02f, -4.14630696e-02f, -1.14965193e-01f, 2.80549154e-02f, 6.65847063e-02f, 1.44264460e-01f, 8.17922503e-02f, 5.62922806e-02f, -5.18858880e-02f,
  -8.28579068e-02f, -4.69301306e-02f, 8.29679240e-03f, -7.39011168e-02f, -1.79766431e-01f, 1.11548781e-01f, -9.79380682e-02f, -2.95349509e-02f, 9.40842852e-02f, -1.66257620e-02f,
  -5.73641062e-02f, 6.07444383e-02f, -1.30724013e-01f, -4.11334150e-02f, -8.26847404e-02f, 1.04208812e-01f, -1.67298764e-02f, 5.62938377e-02f, -1.31543398e-01f, -1.68735147e-01f,
  3.01459320e-02f, 1.01146445e-01f, -6.85518831e-02f, 1.91517305e-02f, 8.27703401e-02f, 1.24679036e-01f, 6.65512681e-02f, 4.15852889e-02f, -2.83953603e-02f, 3.34748849e-02f,
  9.66614336e-02f, 2.75832620e-02f, 5.94495870e-02f, -1.12716049e-01f, -5.11694141e-02f, 5.84994908e-03f, -1.33577371e-02f, -4.86222981e-03f, -2.45309602e-02f, 3.92189659e-02f,
  -8.57235640e-02f, 6.51093349e-02f, -1.20421611e-02f, -1.18428161e-02f, -6.41992241e-02f, -8.73818025e-02f, 1.01859398e-01f, -3.68969478e-02f, 1.06707856e-01f, 9.38271824e-03f,
  9.82311144e-02f, 7.14780688e-02f, 7.15887174e-02f, -2.25301199e-02f, -5.50117753e-02f, 4.11987901e-02f, -5.66843338e-03f, 7.48616979e-02f, -5.44069074e-02f, 1.27207041e-01f,
  3.46198343e-02f, 3.61605994e-02f, 1.22661255e-02f, 5.89468367e-02f, 1.45505428e-01f, -7.32672140e-02f, 9.06602517e-02f, 7.42525533e-02f, 1.08923443e-01f, 7.57569075e-02f,
  4.61702049e-02f, 1.73313841e-02f, 4.33275290e-02f, -5.83679030e-05f, 1.13604344e-01f, 1.02753259e-01f, -2.57871430e-02f, -8.24516825e-03f, -6.32195994e-02f, -7.15997592e-02f,
  -1.82692930e-01f, -6.35694340e-02f, -1.27751231e-02f, 1.42360836e-01f, -5.40901488e-03f, 2.20785756e-02f, 5.35783474e-04f, 1.16578765e-01f, -2.89473366e-02f, -3.62525284e-02f,
  7.86704496e-02f, -9.38872900e-03f, 2.74433326e-02f, -3.83033156e-02f, 9.91618782e-02f, 1.38399899e-01f, 3.54654863e-02f, 1.14428550e-01f, -8.84578526e-02f, -1.73844714e-02f,
  -3.50148678e-02f, 1.71243280e-01f, 1.22921705e-01f, 8.40053409e-02f, 1.08316906e-01f, -1.02673154e-02f, 9.98921245e-02f, 7.87618533e-02f, -9.59860533e-02f, -2.90019270e-02f,
  3.53616588e-02f, 1.56081915e-01f, 1.31355360e-01f, 8.91610160e-02f, 1.74903989e-01f, 4.18625884e-02f, 9.18157049e-04f, -7.18517080e-02f, 4.68484089e-02f, 1.65540889e-01f,
  -2.61438135e-02f, -8.01253617e-02f, 2.14262888e-01f, -1.03973811e-02f, -9.35528055e-02f, -7.13260397e-02f, -1.85729057e-01f, 8.82631093e-02f, 1.69961840e-01f, -6.46760985e-02f,
  -2.15451553e-01f, -1.93468079e-01f, 4.52232063e-02f, -8.83178860e-02f, 1.18407972e-01f, -2.20500231e-01f, -7.64895678e-02f, 1.76427305e-01f, -1.27928793e-01f, 2.47688279e-01f,
  -1.45759270e-01f, -2.11259723e-01f, 4.21946675e-01f, -8.24317932e-02f, 8.12069699e-02f, 1.21893831e-01f, 4.07053351e-01f, -1.10401809e-01f, -1.36358917e-01f, -1.07537173e-01f,
  -1.53468968e-03f, 2.20066383e-01f, 5.77095449e-02f, 2.04845294e-01f, -3.22392248e-02f, -1.78874031e-01f, 8.52770507e-02f, -8.42795372e-02f, 1.04325481e-01f, 1.81933179e-01f,
  1.43970132e-01f, -1.42190143e-01f, -1.08848177e-01f, -1.69478148e-01f, 1.91084579e-01f, 5.91734378e-03f, 4.75120097e-02f, 7.60132298e-02f, 1.31987602e-01f, 2.11096313e-02f,
  1.12726226e-01f, 5.47980368e-02f, -6.17731325e-02f, 1.62627265e-01f, -5.28188683e-02f, 1.54323606e-02f, -6.05783053e-02f, 9.47814286e-02f, 1.78217769e-01f, -3.86341382e-03f,
  1.85572639e-01f, 8.54115859e-02f, 7.62745887e-02f, 3.97170186e-02f, 5.96670695e-02f, 8.50539431e-02f, 1.94817632e-01f, 2.11267158e-01f, 2.28556633e-01f, 8.72521773e-02f,
  7.79913366e-02f, -9.70557556e-02f, 2.17614442e-01f, -3.12906265e-01f, -3.19053769e-01f, -2.54312873e-01f, -3.12564075e-01f, 1.85092911e-01f, -1.49175152e-01f, 1.56403497e-01f,
  -6.59342408e-02f, 1.79309428e-01f, -2.03132272e-01f, -4.44086380e-02f, -2.75142699e-01f, 4.58529145e-02f, 1.96102098e-01f, 1.85401365e-01f, -3.70244752e-03f, -2.65884608e-01f,
  -1.07410766e-01f, -1.74536034e-01f, -1.38504550e-01f, 1.81299448e-01f, -5.00249565e-02f, 1.32038921e-01f, 1.25738218e-01f, 2.25598142e-01f, -8.63042325e-02f, -4.99211736e-02f,
  -2.71029882e-02f, 7.44650960e-02f, -1.76493265e-02f, -3.44693661e-02f, 2.06468970e-01f, -1.05956554e-01f, -5.17586665e-03f, 2.37792552e-01f, -4.30980362e-02f, -4.27149311e-02f,
  -6.31215274e-02f, 1.14225365e-01f, -1.15091607e-01f, 1.52679561e-02f, 9.66752917e-02f, 8.59147012e-02f, 1.48483971e-02f, 7.17090815e-02f, -2.52480600e-02f, -5.49777877e-03f,
  -9.82881859e-02f, 1.06524810e-01f, 6.08264618e-02f, 5.10112420e-02f, -6.95791543e-02f, -7.76684359e-02f, -6.69285506e-02f, 5.00887744e-02f, -6.79744929e-02f, -4.19043675e-02f,
  -1.16080798e-01f, -6.24189805e-03f, -3.37912478e-02f, -6.51855245e-02f, 3.13156396e-02f, 5.75708970e-02f, -6.02916144e-02f, 8.86084884e-02f, 7.90889114e-02f, 6.30108640e-03f,
  -3.36836800e-02f, -7.93115422e-02f, 1.08527862e-01f, 2.01217849e-02f, 6.97606290e-03f, 2.37032194e-02f, -9.95493978e-02f, -4.06710356e-02f, -8.26948732e-02f, 6.90644374e-03f,
  -9.67684090e-02f, 7.63205364e-02f, 4.61903848e-02f, -1.98021531e-02f, 9.88111645e-02f, 7.56837428e-02f, 3.40255257e-03f, 5.18184081e-02f, -4.74403985e-02f, -5.65664023e-02f,
  -5.95129542e-02f, 1.17701432e-02f, 2.09179651e-02f, -5.13235778e-02f, -6.44755885e-02f, -9.74810496e-02f, -4.56526913e-02f, 3.17543484e-02f, 2.54597161e-02f, 2.95586623e-02f,
  8.39938235e-04f, -4.60980125e-02f, -1.17406689e-01f, 9.50496644e-02f, -3.09482822e-03f, -1.00629069e-01f, -5.18870763e-02f, -8.87872055e-02f, -8.40126723e-03f, -6.04174808e-02f,
  1.17864318e-01f, -1.09997973e-01f, 7.52752423e-02f, -9.78866741e-02f, -2.16500461e-02f, -2.85412241e-02f, -3.70438397e-02f, -6.60179779e-02f, -9.84002650e-02f, 1.01820342e-01f,
  2.09210254e-02f, -6.24084249e-02f, -9.72879902e-02f, 1.35738060e-01f, 8.11469331e-02f, -7.77120739e-02f, 4.81587686e-02f, -1.45120556e-02f, 4.41649929e-02f, -5.44912107e-02f,
  1.14500485e-01f, 1.11006401e-01f, 1.34554012e-02f, -8.42143595e-03f, -4.83080186e-02f, 5.77593967e-02f, -8.98806080e-02f, 1.14686981e-01f, 7.55029246e-02f, -1.25440925e-01f,
  1.79528564e-04f, -9.70826149e-02f, -6.58451542e-02f, -1.09988876e-01f, -7.45777786e-02f, 8.33259746e-02f, 7.55394697e-02f, 2.69029550e-02f, 9.71673876e-02f, -1.99430641e-02f,
  9.74368528e-02f, 5.13434689e-03f, -5.68378754e-02f, -1.22976437e-01f, -8.26903582e-02f, 7.75478110e-02f, -7.38409087e-02f, 1.23731166e-01f, 1.00102253e-01f, 8.62328783e-02f,
  1.17633797e-01f, 5.89943565e-02f, -1.92786269e-02f, 8.65850970e-02f, 1.09134749e-01f, 1.05459936e-01f, -1.69558115e-02f, -4.76950407e-02f, -2.76682470e-02f, 3.55424173e-02f,
  -3.36459577e-02f, 1.49397716e-01f, -8.20205510e-02f, 3.29616778e-02f, 5.32351620e-02f, -2.99325231e-02f, 1.67521909e-01f, 1.71291411e-01f, 2.52590012e-02f, 1.88883394e-01f,
  8.14523101e-02f, 1.68745697e-01f, 1.36634901e-01f, 8.06692094e-02f, 1.07309327e-01f, 3.61933783e-02f, 1.51447654e-01f, 1.10927537e-01f, -4.96033132e-02f, 2.44997572e-02f,
  -8.05504769e-02f, -1.58157766e-01f, -5.88920293e-03f, -5.09373657e-03f, 3.76948006e-02f, 1.18624642e-01f, 1.77899227e-01f, 8.30936953e-02f, 1.82024077e-01f, -1.66481569e-01f,
  7.39173293e-02f, -1.43372521e-01f, -3.39815468e-02f, -1.01949133e-01f, 1.83087550e-02f, 8.31222683e-02f, -4.07453962e-02f, -8.82608518e-02f, -6.16640449e-02f, 7.13660643e-02f,
  9.14952308e-02f, 1.06759131e-01f, 6.13850579e-02f, 5.46368435e-02f, 1.37794524e-01f, -1.18665010e-01f, -2.82030515e-02f, 8.42123777e-02f, 1.27381295e-01f, -8.40330198e-02f,
  1.41715035e-01f, 7.64151514e-02f, -5.78794219e-02f, -2.87540853e-02f, 1.20985806e-01f, 1.71528414e-01f, 2.32839920e-02f, -4.38147858e-02f, 5.83914667e-02f, -3.98551673e-02f,
  9.97055992e-02f, 1.67428538e-01f, 1.61059022e-01f, -2.92690471e-02f, 9.27875564e-02f, 3.05333128e-03f, 1.68592453e-01f, 4.65023741e-02f, -5.49437925e-02f, 9.64032784e-02f,
  1.39699638e-01f, -1.03602305e-01f, 1.01975732e-01f, 7.17105567e-02f, 1.49302587e-01f, 3.18658948e-02f, 6.77508786e-02f, 5.46043999e-02f, 9.33895782e-02f, -6.54652854e-03f,
  6.67123273e-02f, -7.79737309e-02f, -6.59623444e-02f, 8.19943920e-02f, 4.28688489e-02f, -2.30062380e-01f, -1.16446458e-01f, 4.31892797e-02f, -5.90485036e-02f, 1.37223676e-02f,
  1.71714291e-01f, 2.20663361e-02f, -6.28574863e-02f, -1.09087765e-01f, -2.14407161e-01f, -1.83091447e-01f, -1.20702051e-01f, 5.32847345e-02f, 2.13615760e-01f, -1.31203398e-01f,
  2.17182226e-02f, -1.66562364e-01f, 6.66190535e-02f, -2.41084006e-02f, 1.85070649e-01f, 2.14274094e-01f, 1.80967316e-01f, -2.53605247e-01f, 1.31760901e-02f, -1.04203999e-01f,
  -7.18483180e-02f, 1.55879647e-01f, -4.39467393e-02f, -8.42675641e-02f, 4.85906750e-03f, 1.53870974e-03f, -6.31362274e-02f, -1.55425142e-03f, 1.17508315e-01f, -4.49270883e-05f,
  -1.36058673e-01f, -5.31781912e-02f, 2.22203165e-01f, 3.99695011e-03f, 2.29357988e-01f, 9.51910540e-02f, 8.01553875e-02f, 5.01973405e-02f, 1.66597411e-01f, 7.12133124e-02f,
  -3.92291928e-03f, 1.38491511e-01f, 1.20139420e-01f, 6.58889264e-02f, 1.33868933e-01f, 3.60672995e-02f, 3.44612822e-02f, 1.23269614e-02f, 6.16364479e-02f, 9.92696956e-02f,
  1.87047303e-01f, 7.31745809e-02f, 2.61402074e-02f, 6.02796525e-02f, 1.24725938e-01f, 6.89386725e-02f, -8.32412913e-02f, 5.39141633e-02f, 1.48349525e-02f, -1.32398382e-01f,
  1.56138271e-01f, 1.30823955e-01f, 1.05152443e-01f, 1.15766577e-01f, -1.76270723e-01f, -3.38365048e-01f, -3.63149494e-02f, 6.01144470e-02f, 6.85150772e-02f, 2.56302096e-02f,
  7.72145286e-04f, -1.15045778e-01f, -9.59944129e-02f, 2.98496395e-01f, 7.38705993e-02f, -9.73167717e-02f, 2.34673731e-02f, -2.17290491e-01f, 1.21537462e-01f, -5.18277362e-02f,
  1.69661015e-01f, 1.61343783e-01f, 2.25414947e-01f, -3.76899764e-02f, 5.10005131e-02f, -8.87600034e-02f, 3.82003444e-03f, 2.04429641e-01f, 8.55021551e-02f, -7.04770684e-02f,
  -7.09026307e-02f, -7.69114261e-03f, -6.52770326e-02f, -1.29593119e-01f, -3.79151106e-02f, 1.89132392e-01f, -3.67190526e-03f, 6.84176534e-02f, -9.67254937e-02f, 4.33183722e-02f,
  9.58048180e-03f, 1.17216073e-01f, 7.54900202e-02f, 9.50398222e-02f, -5.20648398e-02f, 1.07038751e-01f, 6.45090640e-02f, 7.98197987e-04f, 4.87452326e-03f, 2.11250469e-01f,
  9.38655213e-02f, 1.63555831e-01f, 1.14871517e-01f, -3.46976444e-02f, 7.70256594e-02f, 4.44392767e-03f, 1.37762666e-01f, 5.27308555e-03f, 1.08563490e-01f, 3.95613536e-02f,
  -2.16456205e-02f, 2.03320801e-01f, 8.74139965e-02f, 1.36778682e-01f, -1.42126046e-02f, -3.95612232e-02f, -4.85296324e-02f, -1.39694959e-02f, 1.24745704e-01f, 1.67379513e-01f,
  6.69209361e-02f, -7.66931400e-02f, 6.55612499e-02f, 1.52579516e-01f, 1.85116306e-02f, -2.10909113e-01f, 9.97884125e-02f, -8.54417011e-02f, 4.06057760e-02f, 2.57666558e-01f,
  -3.42299640e-01f, 7.68110678e-02f, -8.46602470e-02f, -1.59589261e-01f, -3.90762717e-01f, 1.20535903e-01f, -9.87009481e-02f, 2.93042697e-02f, 2.42476135e-01f, -1.58504277e-01f,
  1.34749174e-01f, -4.95918095e-02f, 1.10885121e-01f, 1.91350698e-01f, 1.32287636e-01f, 8.36334452e-02f, -3.55047472e-02f, -5.50792739e-02f, -5.78401983e-02f, 1.04365900e-01f,
  -8.42523128e-02f, 1.71421647e-01f, -7.73426220e-02f, 9.25814174e-03f, 1.86938405e-01f, -8.58239364e-03f, 1.39600337e-01f, 2.00423226e-01f, -3.82567421e-02f, 1.45380855e-01f,
  -6.08115532e-02f, 5.20068444e-02f, 7.66350850e-02f, 1.88114703e-01f, 9.99732092e-02f, 1.14609770e-01f, 1.72283903e-01f, 7.37236440e-02f, 1.74133331e-02f, 1.26807883e-01f,
  -1.83567982e-02f, 1.02176555e-01f, 4.11578156e-02f, -1.96726155e-02f, -2.19691657e-02f, 2.17730746e-01f, 3.16178566e-03f, 6.56922236e-02f, -5.78795001e-02f, 4.55545001e-02f,
  -1.17808459e-02f, -6.75942302e-02f, 6.48714900e-02f, 1.43305257e-01f, -1.90902963e-01f, -2.72148728e-01f, 7.15085417e-02f, -1.96408793e-01f, -1.43905476e-01f, -1.09494843e-01f,
  3.43550146e-01f, -1.88366041e-01f, -1.93524078e-01f, -7.44579211e-02f, -1.97017372e-01f, -2.04360094e-02f, -2.49121800e-01f, -1.51754254e-02f, -2.85750896e-01f, -1.41069802e-04f,
  -8.85760337e-02f, -1.22942097e-01f, 1.29214516e-02f, 1.95738743e-03f, 4.67702709e-02f, 6.70895427e-02f, 1.31723776e-01f, 2.13659674e-01f, 4.18162066e-03f, 1.32355720e-01f,
  -1.81492772e-02f, 1.37347311e-01f, -1.98651224e-01f, 3.27494889e-02f, 1.13068558e-01f, 1.70755073e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 14)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 14;
const float L1_fan_Bp_bar_data[] = {
  2.13644877e-01f, 6.32673427e-02f, -1.18505076e-01f, 9.67499614e-02f, 5.74596180e-03f, 2.14558810e-01f, 3.44189033e-02f, -8.65810364e-02f, 4.19896916e-02f, 1.91851839e-01f,
  1.07292235e-01f, 1.80772275e-01f, -4.22311313e-02f, 7.19440877e-02f
};

// L2_fan_Wp (Shape: 25 x 64)
const int L2_fan_Wp_rows = 25;
const int L2_fan_Wp_cols = 64;
const float L2_fan_Wp_data[] = {
  1.89744681e-02f, 9.70920920e-02f, -1.29944503e-01f, -5.88760264e-02f, 4.39058170e-02f, -1.22896992e-01f, -2.17316160e-03f, -2.20468137e-02f, 9.46635082e-02f, -1.11169688e-01f,
  -1.12254724e-01f, 5.56849316e-02f, 3.46084684e-02f, -7.99966529e-02f, 2.18567401e-02f, -6.59013912e-02f, -6.88047782e-02f, 3.24513614e-02f, -6.03259588e-03f, 1.16924874e-01f,
  -3.04290783e-02f, -1.40778748e-02f, -2.74823010e-02f, -1.69969574e-01f, -7.73257464e-02f, -6.77557886e-02f, 1.64564833e-01f, 4.25974354e-02f, 4.25827391e-02f, 1.57969758e-01f,
  4.60047238e-02f, 1.10385843e-01f, -8.78016725e-02f, 1.08567767e-01f, 2.71849692e-01f, -1.84226066e-01f, 6.64791241e-02f, 2.07869679e-01f, -1.45515412e-01f, 1.45506024e-01f,
  2.38745689e-01f, 1.06245883e-01f, -3.08747441e-02f, -9.62677598e-02f, -2.14715630e-01f, -1.04310252e-02f, -4.77361381e-02f, 5.66479191e-02f, 1.33010289e-02f, -1.07447997e-01f,
  -2.59419736e-02f, -4.54152860e-02f, 4.65389602e-02f, 1.05535865e-01f, 4.66615669e-02f, 2.82098413e-01f, 1.89503804e-01f, -4.29116413e-02f, 5.39579429e-02f, 5.99781796e-03f,
  1.40165955e-01f, -2.09183022e-01f, -1.36929736e-01f, -6.99387165e-03f, 5.41401543e-02f, -1.73481200e-02f, -1.09635048e-01f, 4.42301817e-02f, -7.68904835e-02f, 6.67919591e-02f,
  9.47952736e-03f, -2.41063118e-01f, -1.06400169e-01f, -3.07154679e-03f, -6.08180948e-02f, 1.11924121e-02f, -1.45944956e-04f, -1.12649962e-01f, 1.05663843e-01f, 8.91354680e-02f,
  2.75050811e-02f, -3.08197979e-02f, -1.01351991e-01f, 8.48643333e-02f, 9.97620746e-02f, 2.06707269e-02f, -1.17062889e-01f, -1.77526653e-01f, 4.93106134e-02f, 1.72273174e-01f,
  1.01092681e-01f, 1.01945817e-01f, -1.40614565e-02f, 4.73438799e-02f, -1.21275052e-01f, 7.91183859e-03f, 1.28809527e-01f, -2.20750030e-02f, -9.97938365e-02f, -1.82766914e-01f,
  -2.00367961e-02f, -5.64667322e-02f, 8.89497399e-02f, -1.08418703e-01f, -4.06304374e-02f, -1.44145966e-01f, 2.89299409e-04f, -1.55427456e-01f, 1.25076011e-01f, -1.01544023e-01f,
  -2.49545202e-01f, 1.65150806e-01f, 6.83287624e-03f, -6.26804307e-02f, 1.23440668e-01f, -2.74800714e-02f, 1.16353653e-01f, 1.53250247e-01f, -4.78694253e-02f, -1.51357666e-01f,
  1.82260945e-01f, -1.24969602e-01f, 8.59659612e-02f, -2.10486814e-01f, -1.65600464e-01f, -2.48652771e-02f, -4.99598049e-02f, -3.96550708e-02f, -1.44783467e-01f, 5.21494560e-02f,
  -7.44756386e-02f, 5.39292675e-03f, -6.77280128e-02f, 7.60199549e-03f, 9.38291773e-02f, -2.85456739e-02f, -1.01108178e-02f, 2.63722148e-03f, 7.68476585e-03f, 7.02143908e-02f,
  3.74645256e-02f, -7.13399844e-03f, -8.59487876e-02f, 1.31147861e-01f, 4.42407727e-02f, 2.05338094e-02f, -5.57092093e-02f, 1.05735809e-01f, -2.69340165e-02f, -8.66340399e-02f,
  3.12367715e-02f, -9.00149122e-02f, -5.58225475e-02f, 1.51342116e-02f, 4.00504284e-02f, 1.74624786e-01f, 6.40564710e-02f, 7.09927231e-02f, -1.11209117e-01f, -1.64682642e-01f,
  -3.89005020e-02f, -2.63759401e-02f, -3.33306901e-02f, -1.11160912e-01f, 1.52305707e-01f, -1.34075686e-01f, -2.84102768e-01f, 5.36928475e-02f, 8.47160593e-02f, -1.35204807e-01f,
  1.61637723e-01f, -1.45547360e-01f, 1.56619012e-01f, -2.41468064e-02f, -2.69781023e-01f, -1.04303539e-01f, 2.54571497e-01f, -1.22217111e-01f, 8.39385688e-02f, 4.40384224e-02f,
  1.05300009e-01f, 1.49462521e-01f, -5.91519661e-02f, -1.82847574e-01f, 3.33803557e-02f, 5.51494956e-03f, -1.82329342e-02f, -1.29813445e-03f, 1.78807899e-01f, 9.04093385e-02f,
  -1.27042592e-01f, -5.86390048e-02f, -6.68770894e-02f, 1.09790422e-01f, 1.13494925e-01f, 8.01800862e-02f, -5.42120598e-02f, 1.28136903e-01f, -5.81876701e-03f, -3.28094102e-02f,
  -2.01798037e-01f, 4.84935055e-03f, -1.17486706e-02f, -5.03743961e-02f, -7.81867430e-02f, -1.75843239e-02f, 9.69531760e-02f, -7.22247735e-02f, -8.38162303e-02f, 1.08036079e-01f,
  6.27213940e-02f, -1.61898941e-01f, -2.33308170e-02f, -5.98698780e-02f, 2.68064830e-02f, 7.56950900e-02f, -7.60200322e-02f, 5.71724549e-02f, 7.24105863e-03f, 2.80101108e-03f,
  -1.29683018e-01f, -1.80607334e-01f, 3.96757532e-04f, 1.89221144e-01f, 1.14898890e-01f, -2.42420539e-01f, 4.37063351e-02f, 1.25186756e-01f, -6.88771680e-02f, -2.68571287e-01f,
  -2.18309566e-01f, 9.59060267e-02f, -6.46937937e-02f, -1.82570636e-01f, 1.22922800e-01f, 1.43792620e-02f, 2.00681850e-01f, 1.19013591e-02f, -1.40544340e-01f, -2.41124660e-01f,
  5.82521372e-02f, -7.47326612e-02f, 6.20771646e-02f, -1.02116279e-01f, -1.65923201e-02f, -9.21540931e-02f, -1.01183951e-01f, -2.26068795e-01f, -1.09377563e-01f, -2.73830574e-02f,
  -4.87572514e-02f, 1.08626835e-01f, -1.06806330e-01f, 8.31224397e-02f, -3.25145945e-02f, -8.32647607e-02f, -9.26327258e-02f, -1.92759838e-02f, 2.41340652e-01f, 1.16231088e-02f,
  5.52237704e-02f, 2.27372758e-02f, -5.00240885e-02f, 9.01854932e-02f, 1.90502122e-01f, -7.68312290e-02f, 9.56172273e-02f, 1.69458553e-01f, 1.44910321e-01f, -5.87038621e-02f,
  8.04924220e-03f, -3.99774984e-02f, 1.70492798e-01f, 1.10749610e-01f, 3.47565673e-02f, 2.56959423e-02f, 1.09163903e-01f, 7.26857781e-02f, -5.24087436e-02f, 3.79208364e-02f,
  -1.06302805e-01f, 2.86603975e-03f, -8.81259069e-02f, 7.66449496e-02f, -1.53243333e-01f, 1.09961759e-02f, -1.11767009e-01f, -7.58119932e-05f, -3.31486911e-02f, 2.27895409e-01f,
  1.77867278e-01f, 1.21669605e-01f, 1.69561774e-01f, -1.31922245e-01f, -1.75855532e-01f, 1.65313303e-01f, 9.43306834e-02f, 2.36314461e-01f, -5.89349354e-03f, -2.09635310e-02f,
  -2.64461990e-02f, 1.75246805e-01f, 2.09525332e-01f, -3.00338835e-01f, -2.31776070e-02f, 5.01578450e-02f, 9.51885357e-02f, -7.84341171e-02f, 2.27460805e-02f, -3.56673859e-02f,
  8.02708566e-02f, 3.19800116e-02f, -2.75278568e-01f, 7.85368457e-02f, 1.29248947e-01f, 1.32969335e-01f, 3.58417816e-02f, -1.49291858e-01f, -4.26522456e-04f, -4.52703610e-02f,
  5.34324870e-02f, 1.85518190e-01f, 2.74258554e-02f, 7.33023211e-02f, -1.00270975e-02f, 6.44614175e-02f, -7.51948804e-02f, 3.25485994e-03f, 6.90191388e-02f, -1.39998067e-02f,
  -4.19835337e-02f, 1.14532106e-01f, -4.75582294e-02f, -1.47423357e-01f, 6.87334761e-02f, 9.65541899e-02f, 1.22709693e-02f, 7.20486864e-02f, 1.03597403e-01f, 9.45121348e-02f,
  1.21218145e-01f, -1.34850994e-01f, -2.83108726e-02f, 7.97541533e-03f, 5.19670732e-02f, -2.56636534e-02f, -1.04681171e-01f, 8.67505297e-02f, 5.56181557e-02f, 1.17962785e-01f,
  1.96227893e-01f, 7.20887333e-02f, -1.53769910e-01f, -1.34066477e-01f, 9.26399603e-02f, -2.33347770e-02f, 9.44200307e-02f, 2.24188361e-02f, 3.42974037e-01f, -2.21492827e-01f,
  1.88864335e-01f, 1.62437841e-01f, -2.44804248e-01f, 3.38736400e-02f, -1.69809937e-01f, -4.12622280e-02f, 9.57323646e-04f, 1.25137985e-01f, 4.34000827e-02f, 1.52291730e-01f,
  -2.23406451e-03f, -2.08856732e-01f, 1.25086494e-02f, -6.10847734e-02f, -1.94756687e-02f, 1.50359333e-01f, 1.89157113e-01f, 6.76414669e-02f, 4.54960428e-02f, -7.64753297e-02f,
  -1.05966315e-01f, -3.93840410e-02f, -9.86534357e-02f, -3.12768333e-02f, 3.52453627e-02f, -1.22656740e-01f, -1.66091863e-02f, 3.49633656e-02f, -9.55307707e-02f, 6.50341213e-02f,
  -9.09069553e-02f, 1.07620060e-01f, -1.31657869e-01f, -3.70677561e-02f, -1.36138014e-02f, -1.92890167e-01f, 7.67893940e-02f, 2.23324135e-01f, -4.14510742e-02f, 3.73422704e-03f,
  5.40158823e-02f, -3.02082207e-02f, 5.81120066e-02f, 7.75919631e-02f, -1.27820358e-01f, -1.59476012e-01f, 8.47788826e-02f, 1.10094957e-02f, -5.10278009e-02f, -2.34833643e-01f,
  1.55644834e-01f, -1.72371581e-01f, 1.05618246e-01f, -1.20820180e-01f, 7.89112151e-02f, 2.04510823e-01f, 4.10412513e-02f, -2.21370384e-01f, -8.20517913e-02f, 5.90081811e-02f,
  1.49601232e-02f, -1.21254358e-03f, 3.51889767e-02f, 1.58130825e-01f, 1.05207801e-01f, 3.03554647e-02f, 2.41417214e-01f, 1.29779130e-01f, 1.08339921e-01f, -8.34423676e-02f,
  -1.45299152e-01f, 6.65596873e-02f, -1.21897697e-01f, -5.32494634e-02f, -1.70543984e-01f, -1.84296221e-01f, -1.06371187e-01f, -1.04107581e-01f, -3.57074775e-02f, 1.33697048e-01f,
  -2.59484164e-02f, -5.33005074e-02f, -8.80568027e-02f, 5.35806157e-02f, -4.68734428e-02f, 2.30003133e-01f, -3.05301137e-02f, -8.19281936e-02f, -1.31450489e-01f, -7.56122693e-02f,
  8.71518627e-02f, 1.48008481e-01f, 1.55994311e-01f, -3.04343887e-02f, 1.07590765e-01f, 1.56694895e-03f, 5.25835156e-02f, 9.17294994e-02f, 3.37010846e-02f, 5.76444007e-02f,
  -1.29654452e-01f, 1.48380220e-01f, 1.66339148e-02f, 1.62291765e-01f, 9.75896195e-02f, 2.09778830e-01f, -9.27377492e-02f, 2.37802714e-02f, -2.29106173e-02f, -3.68259996e-02f,
  -1.12135999e-01f, 8.61048475e-02f, 6.76111504e-02f, -1.83143154e-01f, 1.93380997e-01f, -5.23139052e-02f, 2.00911164e-01f, 9.40690339e-02f, -1.42065138e-01f, 1.79217696e-01f,
  -6.10204879e-03f, 1.28074706e-01f, 2.28716433e-01f, 9.84378066e-03f, 3.10842749e-02f, -8.74808803e-02f, -2.84934133e-01f, 5.81065491e-02f, 5.02053276e-03f, 1.49277328e-02f,
  9.06345323e-02f, -1.22357912e-01f, 6.24128617e-02f, -1.01077892e-01f, -1.01909742e-01f, -6.98508546e-02f, 1.47769690e-01f, 3.08980141e-03f, 8.54481831e-02f, -8.35448280e-02f,
  3.36795337e-02f, -1.15136489e-01f, -1.31914809e-01f, 2.80426532e-01f, 7.08070621e-02f, -9.70480070e-02f, -1.13425832e-02f, -4.21934463e-02f, 1.37566894e-01f, -3.24821621e-02f,
  -2.42918521e-01f, -2.49930769e-01f, 5.44441268e-02f, 2.12194458e-01f, -9.91508663e-02f, 5.39780147e-02f, 8.37810263e-02f, -4.20072749e-02f, -6.11229576e-02f, -1.30350247e-01f,
  2.24658158e-02f, -8.85582063e-03f, 7.25793391e-02f, -4.66471501e-02f, 3.67433242e-02f, 2.80445553e-02f, 1.31280109e-01f, 1.16819695e-01f, -7.69325858e-03f, 3.37669812e-02f,
  4.47117053e-02f, 7.77113661e-02f, -1.14092464e-02f, 1.05772540e-01f, 1.53072849e-01f, -4.04044949e-02f, 4.82803360e-02f, 1.99674293e-01f, -2.01714963e-01f, -4.84370515e-02f,
  -1.17667876e-01f, -8.02501291e-02f, 1.24785453e-01f, 6.85008466e-02f, 2.56533325e-01f, 5.42454682e-02f, -1.22304469e-01f, -1.28951252e-01f, -6.66335896e-02f, -7.60608017e-02f,
  1.26309365e-01f, 2.72710528e-02f, -1.56685323e-01f, 9.44476053e-02f, -2.18058452e-02f, -2.43409917e-01f, 4.36994284e-02f, -1.33504197e-01f, -1.79084599e-01f, -2.91725360e-02f,
  2.02372774e-01f, 1.20876528e-01f, 6.46277517e-02f, 4.01380323e-02f, -5.14555909e-02f, 1.93913747e-02f, -1.30139723e-01f, -2.34087005e-01f, 3.14595819e-01f, -7.81996325e-02f,
  -3.59747857e-02f, -1.77812502e-01f, -2.91964766e-02f, 1.43714771e-02f, 2.36481160e-01f, 5.30851372e-02f, 6.07450232e-02f, 5.51497638e-02f, 1.50455445e-01f, 5.50042614e-02f,
  -6.79729655e-02f, 8.02422538e-02f, -1.13332244e-02f, 1.32353455e-02f, -7.31667653e-02f, 7.53964409e-02f, -1.30144507e-01f, 7.05767125e-02f, 3.63709889e-02f, -9.79858115e-02f,
  2.34272741e-02f, 7.35027343e-02f, -1.24298759e-01f, -3.00471392e-03f, 1.46817908e-01f, 2.88178194e-02f, 1.09253809e-01f, -4.49150056e-02f, 1.82367742e-01f, -3.02917510e-02f,
  8.29153284e-02f, -7.33286142e-02f, -4.62140590e-02f, 4.23114523e-02f, -7.85622671e-02f, 7.65025690e-02f, 6.56247288e-02f, -7.58934161e-03f, 6.29727542e-02f, -1.96381509e-01f,
  -7.06389844e-02f, 1.76105365e-01f, 3.38145941e-02f, -1.15398072e-01f, 1.86068431e-01f, -3.31192650e-02f, 1.72270656e-01f, -8.14257339e-02f, 1.03293180e-01f, -2.34690290e-02f,
  -4.96620946e-02f, 3.24232243e-02f, -2.00862288e-01f, -2.16885768e-02f, -4.11489457e-02f, 3.52735519e-02f, -1.23246029e-01f, -1.12748235e-01f, -6.69570714e-02f, 1.22637376e-02f,
  1.41905263e-01f, 5.26721254e-02f, 6.34243414e-02f, 8.18958730e-02f, 1.14602614e-02f, -1.39383703e-01f, -1.98922545e-01f, 2.21639782e-01f, -4.38737161e-02f, 4.32184562e-02f,
  -1.41298547e-01f, 8.66577402e-02f, -1.82128415e-01f, 8.66462216e-02f, -6.12250436e-03f, 1.09626122e-01f, -1.91626009e-02f, 9.36067998e-02f, 1.09848686e-01f, -1.24971807e-01f,
  6.84702545e-02f, 5.03730103e-02f, -2.71202214e-02f, -9.00876597e-02f, -5.93460537e-02f, 1.38266534e-01f, 3.94746549e-02f, 3.03078257e-02f, 7.97370076e-02f, 7.64139667e-02f,
  -1.12744600e-01f, 5.18953241e-02f, -4.33115475e-02f, -9.00504589e-02f, 8.43869820e-02f, -1.80844352e-01f, 1.20283194e-01f, 1.33985668e-01f, 1.41699061e-01f, -1.55511061e-02f,
  2.34695915e-02f, -2.49352232e-02f, 1.02957049e-02f, 2.20151633e-01f, 1.50644168e-01f, -1.62647039e-01f, -1.51446566e-01f, 1.90557569e-01f, -1.63692996e-01f, 8.56189579e-02f,
  1.54038087e-01f, -2.00372711e-02f, -1.64067581e-01f, -3.27960253e-02f, -1.70567423e-01f, 2.02398817e-03f, 1.24742486e-01f, 1.85230061e-01f, -1.80702791e-01f, -1.57902271e-01f,
  6.06295243e-02f, 1.86671942e-01f, 2.93380599e-02f, 4.56788763e-02f, -9.53867808e-02f, -6.11645989e-02f, -1.52839288e-01f, 2.21547596e-02f, -1.24685699e-02f, 7.38866478e-02f,
  3.24675947e-01f, -2.56304562e-01f, -1.51709557e-01f, 6.54825196e-02f, -9.81027354e-03f, 1.21057786e-01f, -1.69616994e-02f, 1.62707776e-01f, -7.98555687e-02f, 1.03345230e-01f,
  1.01718515e-01f, -1.36211336e-01f, -6.70774579e-02f, -2.55383868e-02f, -3.61796608e-03f, -1.56818144e-02f, -5.73494062e-02f, -3.16464491e-02f, 1.42510235e-01f, -4.95351739e-02f,
  -1.78777128e-02f, 4.09246869e-02f, -1.46630287e-01f, -1.28392577e-01f, -3.24360840e-02f, -8.45382959e-02f, 1.57523021e-01f, 8.03402141e-02f, 1.69251172e-04f, -1.00155666e-01f,
  1.99810132e-01f, -1.44545838e-01f, 1.36954725e-01f, -1.21057495e-01f, -7.06754159e-03f, -3.46828327e-02f, 2.15680286e-01f, 5.24572236e-03f, 1.79135382e-01f, -1.02793135e-01f,
  4.58105095e-02f, -4.44872566e-02f, -3.60497057e-01f, 2.52325267e-01f, -1.79554701e-01f, -7.37242103e-02f, 1.42276645e-01f, -1.05648622e-01f, 1.52410522e-01f, -1.58336163e-02f,
  -3.14760834e-01f, -1.04696527e-01f, 2.07118154e-01f, 5.35726249e-02f, 2.23865779e-03f, 1.67350933e-01f, 1.25249932e-02f, -1.82132330e-02f, -1.93652268e-02f, 1.57959107e-02f,
  4.06318791e-02f, -3.52534726e-02f, -5.14473058e-02f, 8.45736824e-03f, 1.28959060e-01f, 1.48072168e-01f, -9.58637372e-02f, -4.42678779e-02f, -9.61187705e-02f, -1.67756490e-02f,
  -1.43134955e-03f, -3.90444845e-02f, 2.71354914e-02f, -1.14630684e-01f, -4.10590917e-02f, 9.81468633e-02f, -3.05577051e-02f, 8.25610459e-02f, -3.47870626e-02f, -7.46554211e-02f,
  9.50980410e-02f, -8.77121389e-02f, 1.15963422e-01f, 5.30048311e-02f, 1.90688558e-02f, -3.70790251e-02f, 1.99996963e-01f, 1.87089399e-01f, 1.02326915e-01f, 1.62475273e-01f,
  -1.20640635e-01f, 1.03018560e-01f, -7.25450143e-02f, -1.59898803e-01f, 1.13847487e-01f, 1.64732680e-01f, -7.44116232e-02f, 1.92029759e-01f, 6.30115196e-02f, 1.50966778e-01f,
  -1.77318618e-01f, 7.64966980e-02f, 9.25133228e-02f, 1.87272921e-01f, -1.89800531e-01f, 1.86940461e-01f, 1.85723342e-02f, -6.89512119e-02f, 1.67045474e-01f, -7.99798518e-02f,
  -1.87148377e-01f, 1.57530144e-01f, -2.90787429e-01f, -7.54903555e-02f, 1.72625199e-01f, 9.47157964e-02f, -9.66683961e-04f, -1.96893647e-01f, -1.73868701e-01f, -1.32267103e-01f,
  5.44642238e-03f, -2.48411372e-02f, 5.51519878e-02f, 2.35239610e-01f, -1.14172343e-02f, -6.66708648e-02f, -1.14444599e-01f, -1.53459460e-02f, 1.35242417e-01f, 2.85995491e-02f,
  -1.60269290e-01f, 1.36961162e-01f, -9.37586725e-02f, -2.45943982e-02f, -2.78919544e-02f, -4.69992589e-03f, 1.13817863e-01f, -2.88307499e-02f, 1.37204543e-01f, 7.45775551e-03f,
  8.03146660e-02f, 5.36542200e-02f, -4.64982577e-02f, 1.60778880e-01f, -1.28943607e-01f, -2.69204415e-02f, 9.41855907e-02f, -3.84450108e-02f, -4.92879413e-02f, 1.33917168e-01f,
  -4.45441827e-02f, -1.56905785e-01f, -9.61691588e-02f, 6.48678541e-02f, -7.71096349e-03f, 6.34215325e-02f, -2.01113243e-02f, 1.11455485e-01f, -1.79704688e-02f, 7.94948041e-02f,
  4.98596579e-02f, -1.15639620e-01f, -1.05346285e-01f, -2.53521483e-02f, 1.77859575e-01f, 6.75164978e-04f, 1.07501462e-01f, -1.71754971e-01f, -5.10900095e-02f, 7.23746642e-02f,
  -2.44877830e-01f, 1.80296943e-01f, -1.82833076e-01f, 1.61032841e-01f, -3.90437655e-02f, -1.30625084e-01f, 1.63222864e-01f, 4.73330654e-02f, -1.24432601e-01f, -3.03258210e-01f,
  -7.95165170e-03f, 1.04783654e-01f, 1.23292729e-01f, 2.17428505e-01f, 1.06030062e-01f, -3.25226970e-02f, 5.19814081e-02f, -1.89768746e-01f, -1.28584489e-01f, -8.87938142e-02f,
  -1.14710242e-01f, -5.30030616e-02f, -4.20109294e-02f, -2.25846633e-01f, 2.18294308e-01f, 9.59181935e-02f, -1.72168449e-01f, -8.12364668e-02f, 1.08130693e-01f, -7.73086622e-02f,
  1.03070073e-01f, 1.06727302e-01f, -1.20552406e-01f, 1.24700226e-01f, -7.80847743e-02f, -7.42497668e-02f, -3.93208340e-02f, -1.96442187e-01f, -2.86517497e-02f, 9.92045030e-02f,
  2.02781111e-02f, 9.69976932e-02f, -1.97337151e-01f, -2.89063118e-02f, 9.22202095e-02f, -2.92188246e-02f, 7.33565837e-02f, 7.15112090e-02f, -2.00246982e-02f, -6.39057532e-02f,
  -1.14619501e-01f, -8.65198299e-02f, 2.38208622e-01f, -8.05572420e-02f, 1.66840747e-01f, 1.72177002e-01f, 2.73190066e-02f, -9.69206542e-03f, -2.25812525e-01f, -1.23351105e-01f,
  -9.13762208e-03f, 6.08617328e-02f, -2.25117892e-01f, -4.90409620e-02f, 3.86983603e-02f, -1.42430076e-02f, 2.30132923e-01f, -2.36372501e-01f, 5.18239290e-02f, 2.43500516e-01f,
  -3.01402994e-02f, -5.26662320e-02f, -5.13566360e-02f, 2.30746642e-01f, -7.53646418e-02f, -2.02150866e-01f, -2.08723590e-01f, -1.00275792e-01f, 5.30239083e-02f, -2.55534202e-02f,
  9.29097161e-02f, 6.78238878e-03f, -1.68513030e-01f, 1.60114057e-02f, -9.63118523e-02f, -6.08155988e-02f, 1.49546936e-01f, 1.80734172e-01f, -1.16388775e-01f, -2.91575771e-02f,
  3.57364081e-02f, -1.36074975e-01f, -5.80138117e-02f, -3.83116752e-02f, 7.89152980e-02f, 1.15513481e-01f, 1.07562944e-01f, 1.15164585e-01f, 6.88636824e-02f, -1.39409482e-01f,
  1.53414793e-02f, 5.40744886e-02f, -1.57169700e-02f, 9.91844237e-02f, 6.16447777e-02f, 1.49540588e-01f, -1.08720638e-01f, 1.13057189e-01f, -7.04529583e-02f, 1.21088378e-01f,
  1.73049141e-02f, -6.10540994e-02f, 1.82142034e-02f, -3.56187895e-02f, -8.60677585e-02f, -1.86361670e-01f, 1.64661780e-01f, 3.66290100e-02f, 6.46733940e-02f, -1.06025673e-01f,
  -5.67809381e-02f, 4.51288298e-02f, -1.69546247e-01f, 1.18294217e-01f, 1.81686446e-01f, -8.99184495e-02f, 5.84339760e-02f, -2.20285002e-02f, -3.45146984e-01f, 2.21555382e-01f,
  1.56488940e-01f, 2.20341645e-02f, 2.24568591e-01f, 1.29981712e-01f, 4.54696342e-02f, -8.22009966e-02f, 3.24668624e-02f, 1.26572121e-02f, 1.67385444e-01f, 4.91414182e-02f,
  1.87214017e-01f, -1.04010977e-01f, 5.51189408e-02f, 3.07819210e-02f, -1.45270422e-01f, 8.28579515e-02f, -1.44708812e-01f, -7.52134323e-02f, -4.64670323e-02f, -3.36508118e-02f,
  6.62036240e-02f, 1.51953712e-01f, -1.95655555e-01f, -1.15534119e-01f, -1.07527517e-01f, -1.65145993e-02f, 2.16462255e-01f, 5.53407297e-02f, -5.23575060e-02f, -2.03533415e-02f,
  1.07409410e-01f, 1.06969960e-01f, -1.87166154e-01f, -6.86698630e-02f, -1.21215224e-01f, -6.97465017e-02f, -1.42609686e-01f, 1.15601100e-01f, 4.06265631e-02f, 3.30904545e-03f,
  -8.52762610e-02f, 9.28392932e-02f, 1.11252919e-01f, 1.17921419e-01f, -4.37779091e-02f, -7.90598765e-02f, -4.72316109e-02f, -6.50862157e-02f, -6.51036501e-02f, -2.08683461e-01f,
  6.95428550e-02f, -1.17948748e-01f, -3.10117397e-02f, -1.78801790e-02f, 5.99394515e-02f, 2.50877261e-01f, -2.40531519e-01f, -2.39737585e-01f, -3.94878127e-02f, 1.85036764e-01f,
  -1.08180270e-01f, -5.59857255e-03f, 1.08707383e-01f, -7.04378560e-02f, 8.52449052e-03f, 1.43048903e-02f, 2.12367579e-01f, -2.83411890e-02f, -6.93296194e-02f, 1.17740534e-01f,
  -1.60747513e-01f, 1.17244631e-01f, -1.00629963e-01f, 1.24502152e-01f, -1.22212395e-01f, -1.51800707e-01f, -5.78485131e-02f, 8.40820521e-02f, 1.69384658e-01f, 1.71128273e-01f,
  -2.18460247e-01f, 2.61331126e-02f, -1.53000113e-02f, -3.38107236e-02f, 6.05635792e-02f, 3.51898037e-02f, -1.39539018e-01f, -1.47026405e-01f, 8.07922930e-02f, 6.39355183e-02f,
  3.00491769e-02f, -6.33069128e-02f, -6.86305091e-02f, 2.61470769e-02f, -8.15145224e-02f, -6.48967400e-02f, 4.46594954e-02f, -1.10740578e-02f, 4.69014198e-02f, -6.34860173e-02f,
  -1.27115771e-01f, 1.35341880e-03f, 5.03029525e-02f, -1.51376277e-01f, 2.52561811e-02f, 5.58620654e-02f, -1.81287885e-01f, -1.59490302e-01f, -3.75702009e-02f, -5.26763536e-02f,
  8.61649290e-02f, -6.88250437e-02f, -1.39805719e-01f, 2.61602223e-01f, -2.26896286e-01f, -2.12424668e-03f, -2.01425418e-01f, 3.57902013e-02f, -1.52292013e-01f, -1.37626633e-01f,
  -3.07160942e-03f, 2.13093355e-01f, 2.92185899e-02f, -1.29830629e-01f, 2.41536140e-01f, -1.21803664e-01f, -1.04269132e-01f, 2.51707938e-02f, -2.06558909e-02f, 7.93346241e-02f,
  -6.20747171e-02f, -1.62697554e-01f, 1.49069726e-01f, 9.05616209e-02f, 6.31200802e-03f, -2.29146495e-01f, -8.65181312e-02f, 1.99521258e-01f, 1.50392413e-01f, 1.25698164e-01f,
  -3.98895051e-03f, 6.65462911e-02f, 5.08051999e-02f, -2.06461415e-01f, 3.80488709e-02f, -2.34035123e-03f, 7.20123872e-02f, -1.03553936e-01f, -4.60057184e-02f, -1.25565648e-01f,
  1.06450804e-01f, 8.15776549e-03f, 2.00312808e-02f, 1.06868623e-02f, 3.54569890e-02f, 7.25030228e-02f, 5.63392080e-02f, -1.05345033e-01f, -5.01118489e-02f, 1.56662807e-01f,
  -1.09865502e-01f, 8.26937612e-03f, 1.03929192e-02f, 9.08656791e-02f, 1.48739710e-01f, -2.55582128e-02f, -1.29326701e-01f, -1.13649420e-01f, -1.81373768e-02f, -1.90543100e-01f,
  7.44149908e-02f, -4.27416526e-02f, 7.27595622e-03f, 6.08719289e-02f, 3.39927152e-02f, 1.31155133e-01f, -3.52067426e-02f, 3.62433009e-02f, -1.43433943e-01f, -1.92073956e-02f,
  9.94695649e-02f, 1.23769022e-03f, -1.19092934e-01f, -6.64916411e-02f, 5.71998879e-02f, -6.88724825e-03f, -7.46756941e-02f, 1.46093294e-01f, -2.52030075e-01f, 1.82643458e-01f,
  1.22045040e-01f, 4.83591147e-02f, -1.14421964e-01f, 9.08126086e-02f, -1.79834411e-01f, 1.83034971e-01f, -1.56087235e-01f, 7.79946372e-02f, 2.50207156e-01f, 1.28718823e-01f,
  -1.84331477e-01f, -1.10703647e-01f, -9.61202458e-02f, 8.26211050e-02f, 2.72661797e-03f, 8.23355094e-02f, -3.34127881e-02f, -1.29728675e-01f, -3.04420054e-01f, -7.03948066e-02f,
  -8.45859349e-02f, 1.04302347e-01f, 1.82548925e-01f, -1.09836645e-01f, -9.09903180e-03f, 2.95385689e-01f, 8.56004879e-02f, -1.18558250e-01f, 1.92943096e-01f, -9.42043811e-02f,
  1.44961942e-02f, 7.84857348e-02f, -2.60979291e-02f, -1.46232629e-02f, -1.24027714e-01f, 2.86512561e-02f, -8.67270008e-02f, -8.29905421e-02f, 7.66760111e-02f, 5.51069947e-03f,
  1.05280086e-01f, 3.73935531e-04f, -3.43509093e-02f, -8.59958753e-02f, -7.19968006e-02f, 6.50840998e-02f, -3.89750786e-02f, -4.90384735e-02f, -4.90803979e-02f, -3.24184820e-02f,
  -5.57308085e-03f, 7.73850456e-02f, -1.08291104e-01f, -2.05179885e-01f, -1.14191577e-01f, -2.14476302e-01f, -9.48144644e-02f, -4.69584987e-02f, 6.37847977e-03f, 4.01711464e-03f,
  -7.52437413e-02f, 1.89233065e-01f, 1.66828057e-03f, -1.36136189e-01f, -5.02264313e-02f, 1.53985798e-01f, -1.87819466e-01f, 6.00915961e-02f, 1.22261010e-01f, 3.99337709e-02f,
  -1.00939851e-02f, -4.93408889e-02f, 9.91661996e-02f, -1.75843164e-02f, -1.49793610e-01f, 8.47069770e-02f, -6.75923750e-02f, 1.37727931e-01f, 5.81478328e-03f, -1.50378361e-01f,
  1.05734512e-01f, -1.65464550e-01f, -2.82141954e-01f, 8.59058276e-02f, -3.93911526e-02f, 6.01726733e-02f, -1.85756862e-01f, 8.63730833e-02f, 1.74463376e-01f, 8.45205337e-02f,
  2.65766922e-02f, -1.30137846e-01f, -2.00173989e-01f, 3.95226181e-02f, 6.32255748e-02f, -1.16935901e-01f, -7.53990486e-02f, -4.33443934e-02f, 6.07485697e-02f, -7.37632513e-02f,
  -2.87973061e-02f, -4.67415117e-02f, -5.42205088e-02f, 7.11819343e-03f, 7.09919631e-02f, -1.33093148e-01f, -4.23413776e-02f, -6.18625320e-02f, 7.97510818e-02f, -6.11443482e-02f,
  6.37711883e-02f, 8.18703845e-02f, -7.14289993e-02f, 6.34515360e-02f, -1.27405584e-01f, -1.55422330e-01f, 7.64353387e-03f, 4.30722311e-02f, 2.61236485e-02f, 1.05726860e-01f,
  -1.18311599e-01f, -7.77536854e-02f, 1.59788787e-01f, 1.93435833e-01f, -1.35428756e-01f, -1.28393337e-01f, -1.14312969e-01f, 2.57048368e-01f, 1.68691933e-01f, 5.28859198e-02f,
  -7.39413947e-02f, 3.38547416e-02f, 1.62736699e-02f, 1.40481040e-01f, -7.06163514e-03f, -4.40013111e-02f, 2.74963260e-01f, 1.56207249e-01f, -1.34537980e-01f, -1.72998533e-01f,
  -2.47312009e-01f, 1.48270980e-01f, -1.24271862e-01f, 1.25185966e-01f, 8.76984224e-02f, -1.55508174e-02f, 1.52389277e-02f, 9.86507442e-03f, -5.00938818e-02f, 4.53862026e-02f,
  3.71425189e-02f, -6.93115145e-02f, -5.45614101e-02f, 2.27992445e-01f, -8.76319706e-02f, 1.41439214e-01f, 4.96720313e-04f, -1.87191628e-02f, -2.19768914e-03f, 1.40710667e-01f,
  3.34851518e-02f, -1.13572285e-01f, 3.90102863e-02f, 1.62742406e-01f, 1.28357977e-01f, 6.33928031e-02f, -1.13295004e-01f, 1.37898803e-01f, -4.20619287e-02f, 1.07902452e-01f,
  5.17419428e-02f, 1.04420021e-01f, 3.31037305e-02f, -6.85059950e-02f, -1.92525964e-02f, 3.03671136e-03f, 3.06134671e-02f, -1.11147568e-01f, 1.19044989e-01f, -1.43863574e-01f,
  1.35823637e-01f, 8.33886415e-02f, 1.71245456e-01f, -4.36006449e-02f, 1.02480032e-01f, 1.25879556e-01f, 1.21736228e-01f, -1.93044171e-01f, -5.18982336e-02f, -7.26516545e-02f,
  8.18484724e-02f, -2.43808683e-02f, -2.11147144e-01f, 2.31990237e-02f, -5.19190468e-02f, -8.87526348e-02f, 1.54145822e-01f, -5.36303855e-02f, 1.39125019e-01f, 5.54717444e-02f,
  -2.73479253e-01f, -3.81172635e-02f, 2.01179117e-01f, -5.60413711e-02f, 9.73056480e-02f, -1.07042408e-02f, 7.55024552e-02f, 1.71617255e-01f, -5.59795387e-02f, 6.48139194e-02f,
  4.43280041e-02f, -7.98052698e-02f, -1.53468121e-02f, -8.08305107e-04f, -1.03791217e-05f, 1.85936391e-01f, -1.30876526e-01f, -2.60371625e-01f, 9.46535543e-03f, 1.92924142e-02f,
  -1.25498265e-01f, 5.19889705e-02f, 2.25623734e-02f, 5.32011986e-02f, 9.21788439e-02f, -2.53761597e-02f, -4.74393321e-03f, 4.26956937e-02f, 4.09516692e-03f, 1.28666043e-01f,
  8.35490227e-03f, -1.12988707e-02f, -1.07589640e-01f, 2.57663336e-02f, 1.13882877e-01f, 1.24616779e-01f, 6.51450604e-02f, 1.14456028e-01f, 8.41262862e-02f, 1.87526613e-01f,
  -1.25672268e-02f, 3.17140147e-02f, 8.71052872e-03f, -2.36152057e-02f, 3.91281582e-02f, 1.79842040e-01f, -3.52082476e-02f, 1.13552332e-01f, -2.44447514e-02f, -2.94795066e-01f,
  4.83784229e-02f, 1.89576641e-01f, -1.85904294e-01f, -8.17385614e-02f, -1.54643610e-01f, 8.00461099e-02f, -1.60019677e-02f, 7.03008194e-03f, -1.07207773e-02f, -1.93687037e-01f,
  -4.92831580e-02f, 1.17769167e-01f, 3.54264751e-02f, -9.37390700e-02f, 5.29513955e-02f, 1.54639602e-01f, 1.01690650e-01f, -2.43535921e-01f, -7.42780119e-02f, 1.60862222e-01f,
  -6.11898340e-02f, 3.49270776e-02f, 4.67468761e-02f, -2.07766742e-01f, 9.68104452e-02f, -4.19334136e-02f, 6.12729453e-02f, 2.39574201e-02f, 1.86072081e-01f, -1.91667959e-01f,
  1.21431388e-01f, 2.61977226e-01f, 1.67482346e-02f, 8.47197399e-02f, -9.06301439e-02f, 1.65573079e-02f, 3.47029492e-02f, -3.83031219e-02f, -4.25336249e-02f, 1.18111774e-01f,
  -2.14304216e-02f, 7.70387352e-02f, -4.56848321e-03f, -2.02400461e-01f, -1.10212259e-01f, -1.04947217e-01f, -9.91584733e-02f, 1.68666184e-01f, -1.52322859e-01f, -1.09404020e-01f,
  6.82759658e-02f, -3.98624763e-02f, 1.19971260e-01f, 1.33388504e-01f, -7.41980150e-02f, 3.75668034e-02f, 4.15812625e-04f, -2.09656328e-01f, 3.98182459e-02f, -5.45946471e-02f,
  1.55225933e-01f, -6.23392873e-02f, 6.87299967e-02f, 8.67781416e-02f, -2.32741281e-01f, -1.35408446e-01f, 7.75303319e-02f, 3.19588627e-03f, -1.67020872e-01f, -4.98010265e-03f,
  -1.42411083e-01f, 1.57491624e-01f, -1.97601132e-02f, -1.96020246e-01f, 2.58219186e-02f, 2.26355210e-01f, -9.55771357e-02f, 1.33254319e-01f, 1.49932697e-01f, 2.58277088e-01f,
  -1.73451751e-01f, -1.82999745e-01f, -5.12548722e-02f, -1.12767220e-01f, -4.69644032e-02f, 2.44792514e-02f, 1.45694450e-01f, -2.07344424e-02f, -6.18959405e-02f, 1.41329467e-02f,
  -2.93520670e-02f, 1.32632270e-01f, 2.35413358e-01f, 1.36501975e-02f, -1.33719534e-01f, 3.83591130e-02f, -2.16642860e-02f, -1.21431917e-01f, -1.62085027e-01f, -6.28331527e-02f,
  -4.90046330e-02f, 1.73038039e-02f, 1.30233526e-01f, 1.21833101e-01f, 1.33301690e-01f, 7.91560560e-02f, -1.54745150e-02f, 3.32763083e-02f, 1.76003665e-01f, -5.67697212e-02f,
  8.18457454e-02f, -4.11488637e-02f, -5.15050739e-02f, 1.23163342e-01f, 3.86218764e-02f, 5.11661991e-02f, -8.47599357e-02f, 1.69320196e-01f, -4.41049561e-02f, -4.21205796e-02f,
  -1.00985453e-01f, 4.09999713e-02f, 2.23845406e-03f, 2.54219919e-01f, -7.10388422e-02f, 1.40495524e-01f, -1.51538476e-02f, -1.68601215e-01f, 3.53530683e-02f, 2.41541341e-01f,
  -1.92111582e-01f, -1.10710479e-01f, -1.97713658e-01f, 9.42144990e-02f, 2.66127139e-02f, -5.13673797e-02f, 3.14964466e-02f, -8.49042758e-02f, -2.26166949e-01f, 1.50957197e-01f,
  4.81692180e-02f, 1.03714131e-01f, 3.79857033e-01f, 2.09488586e-01f, -6.36941269e-02f, 2.58963145e-02f, -1.13428779e-01f, 5.36597939e-03f, -7.01081827e-02f, -1.28329292e-01f,
  -1.12497948e-01f, 7.52233937e-02f, -2.36620381e-01f, -9.51538682e-02f, 4.89289220e-03f, 1.17371358e-01f, 3.22330207e-01f, -1.57471731e-01f, 1.03884675e-01f, 2.00558722e-01f
};

// L2_fan_Wp_bar (Shape: 14 x 64)
const int L2_fan_Wp_bar_rows = 14;
const int L2_fan_Wp_bar_cols = 64;
const float L2_fan_Wp_bar_data[] = {
  1.89626589e-01f, 4.93523739e-02f, 6.75497483e-03f, 8.47221836e-02f, 1.97144791e-01f, 1.24554701e-01f, 1.61664307e-01f, -1.33931458e-01f, 1.05104253e-01f, 2.19115049e-01f,
  5.95027916e-02f, 4.25875932e-02f, 2.45337114e-01f, 2.28645597e-02f, 1.68860048e-01f, 1.30219564e-01f, 1.57340631e-01f, 2.78821178e-02f, -8.54171738e-02f, 9.94945504e-03f,
  1.03771642e-01f, 1.87062427e-01f, 6.54986547e-03f, 4.17000763e-02f, 2.80713737e-02f, 2.57416546e-01f, -3.23261052e-01f, 1.30161777e-01f, -3.08331698e-01f, 2.21223965e-01f,
  -6.55374452e-02f, -2.98670828e-01f, 2.50436570e-02f, 1.45815268e-01f, -1.64742410e-01f, -2.21702352e-01f, 1.11863263e-01f, -6.43915758e-02f, 3.86872411e-01f, -1.23463877e-01f,
  -1.32125132e-02f, 2.44232751e-02f, -2.96483338e-01f, -2.71774471e-01f, 1.25574404e-02f, -4.03543301e-02f, 9.35950503e-02f, 2.52183050e-01f, 8.25562701e-02f, 7.73568777e-03f,
  1.18417904e-01f, -3.69849196e-03f, 9.53778625e-02f, -8.76389258e-03f, 1.33317247e-01f, -1.38340235e-01f, 2.51864105e-01f, -9.94256437e-02f, -2.54356954e-02f, 3.38247493e-02f,
  -1.29182890e-01f, -1.40704542e-01f, 2.77572066e-01f, 3.50913316e-01f, 1.35846898e-01f, -2.07319371e-02f, -1.30055860e-01f, -8.49118680e-02f, -6.82869554e-02f, 1.57027528e-01f,
  -3.92581187e-02f, 8.59075487e-02f, 5.01941890e-02f, 8.81633610e-02f, 1.45256504e-01f, 4.41715941e-02f, 1.20796643e-01f, -2.59106811e-02f, 2.10206285e-02f, -2.20531784e-03f,
  5.60430400e-02f, -5.30781820e-02f, 1.46008119e-01f, 1.28798187e-01f, 8.23901519e-02f, 1.04158081e-01f, 6.74402863e-02f, 5.03391884e-02f, 1.44790843e-01f, 1.13355909e-02f,
  -1.84208810e-04f, 1.67090416e-01f, -1.62279055e-01f, 1.25883982e-01f, -3.66773903e-02f, -3.34862210e-02f, 2.83043087e-02f, 1.92013934e-01f, -1.53442785e-01f, -1.01624720e-01f,
  -1.17008030e-01f, 1.00171179e-01f, 2.07245603e-01f, -1.44038379e-01f, -3.58001539e-03f, 1.36330217e-01f, -2.77026027e-01f, -7.38044009e-02f, -7.48257041e-02f, 7.96278492e-02f,
  7.80528337e-02f, 2.01866612e-01f, 5.64636178e-02f, -1.05371580e-01f, -6.48764819e-02f, 9.84453484e-02f, -1.13589047e-02f, 4.22329046e-02f, 1.43534258e-01f, 5.07193170e-02f,
  1.53173804e-01f, -1.04191273e-01f, -1.10785417e-01f, -7.69101307e-02f, -6.91671669e-02f, -7.55091608e-02f, 1.66677549e-01f, 1.96914762e-01f, -4.78433371e-02f, 3.37168388e-02f,
  6.06302731e-02f, 6.78443313e-02f, -2.68061701e-02f, -7.42843077e-02f, -9.45636183e-02f, -4.08399776e-02f, -9.33002904e-02f, 2.00653337e-02f, 1.39969187e-02f, 1.14553690e-01f,
  9.21249613e-02f, -8.38636160e-02f, -1.82672124e-02f, -7.21331732e-03f, -4.11301702e-02f, -4.27382439e-02f, -4.54774313e-02f, -1.22251563e-01f, -7.30391685e-03f, -1.09173276e-01f,
  -3.33934650e-02f, 6.46259189e-02f, -7.39793777e-02f, -1.86552498e-02f, 9.08129811e-02f, -3.85047421e-02f, 5.17948084e-02f, -1.12201683e-01f, -1.60570990e-03f, 8.85158256e-02f,
  -5.93359284e-02f, 8.26469660e-02f, 1.22427018e-02f, 8.90734121e-02f, -1.00055724e-01f, 9.18403789e-02f, -1.97901614e-02f, -9.30225924e-02f, 7.03535676e-02f, -8.62242877e-02f,
  -1.17236689e-01f, 1.09278575e-01f, 7.46402293e-02f, 4.40408662e-02f, -1.55649269e-02f, 7.50070512e-02f, -3.25334622e-05f, 1.48506733e-02f, 3.77128646e-02f, -2.60436907e-02f,
  -2.60420539e-03f, -7.06471130e-02f, 4.80776951e-02f, -6.59651756e-02f, 5.71858324e-02f, 5.44991158e-02f, -1.54332106e-03f, -4.35734689e-02f, -2.39681583e-02f, -1.23777784e-01f,
  -7.46283680e-02f, 8.56357962e-02f, 2.92638540e-02f, -1.09771870e-01f, 8.24402794e-02f, -1.13051012e-01f, 1.02280825e-01f, -8.93481895e-02f, 1.14120357e-01f, -5.38421720e-02f,
  -5.22449911e-02f, 3.85982618e-02f, -8.48046020e-02f, -8.48763660e-02f, 3.79877165e-02f, -4.45140935e-02f, 1.11983463e-01f, 6.59924522e-02f, 1.06260940e-01f, -1.01709783e-01f,
  1.17188059e-01f, -7.86535591e-02f, -1.04195982e-01f, 8.11700597e-02f, -1.15058318e-01f, -9.82994884e-02f, 1.17497630e-02f, 7.47623891e-02f, 2.86471788e-02f, -1.92894302e-02f,
  -3.21866125e-02f, -7.16566443e-02f, -3.90454307e-02f, 1.20266341e-01f, -2.19510440e-02f, 1.18665643e-01f, 7.52227753e-02f, 2.35728994e-02f, 6.96225241e-02f, 5.58907650e-02f,
  7.78673887e-02f, -3.88333574e-02f, 8.86802152e-02f, 1.09992467e-01f, -1.17576830e-01f, 2.97423992e-02f, 2.40590200e-02f, 9.86330770e-03f, -8.99860635e-02f, -5.86327873e-02f,
  5.77893034e-02f, 2.14850400e-02f, -6.38182610e-02f, -1.00411460e-01f, 1.05590284e-01f, 6.05681650e-02f, -1.18891425e-01f, -1.03032947e-01f, -1.20035678e-01f, 9.51251239e-02f,
  4.59058732e-02f, -3.24487388e-02f, -1.02459773e-01f, 1.07640773e-01f, -4.38562073e-02f, -1.09809496e-01f, 1.60725504e-01f, -7.75391087e-02f, 9.07110870e-02f, -5.49273603e-02f,
  9.27478746e-02f, 9.21626911e-02f, -2.83774436e-02f, -2.06040367e-02f, 1.06681809e-01f, 8.08814913e-02f, -1.36062410e-02f, 1.05532654e-01f, 1.00304961e-01f, -1.18802041e-01f,
  1.55710235e-01f, -5.08768559e-02f, 6.84459135e-02f, -1.37690395e-01f, 1.19084697e-02f, 1.42602324e-01f, 3.89772318e-02f, -1.23480405e-03f, -8.52039829e-02f, 2.39163032e-03f,
  3.15181189e-03f, 1.04185818e-02f, -1.70914292e-01f, 8.72579962e-02f, -1.93590805e-01f, 5.77914994e-03f, -3.51304375e-02f, -2.73577985e-03f, -1.18577063e-01f, 1.67138353e-01f,
  1.85427666e-01f, -1.11161724e-01f, -2.73906216e-02f, 8.41417760e-02f, 1.33280247e-01f, -7.94145390e-02f, -9.22993496e-02f, 2.00279564e-01f, -2.57564873e-01f, 9.83157232e-02f,
  -2.11213976e-02f, 1.06690004e-02f, 1.92493081e-01f, 3.46795842e-02f, -2.03175962e-01f, 1.21344253e-01f, 1.02120548e-01f, 1.16530545e-01f, 1.18359976e-01f, -6.95641637e-02f,
  -8.79172832e-02f, 1.22807093e-01f, -1.93089589e-01f, -4.86533716e-02f, 8.31935480e-02f, 9.17211249e-02f, 9.77550298e-02f, -1.71214551e-01f, 1.28701314e-01f, 2.46787563e-01f,
  4.53412533e-02f, 7.01860785e-02f, 4.30609025e-02f, -5.24537414e-02f, -1.49133326e-02f, -4.05567884e-02f, -9.16523635e-02f, -7.18412101e-02f, -8.14604983e-02f, 6.40400350e-02f,
  -7.96327367e-02f, -3.59015763e-02f, 4.37353738e-02f, 3.83379944e-02f, -1.06773354e-01f, 4.05965708e-02f, -4.20668498e-02f, 9.85317379e-02f, -1.23317324e-01f, -1.95430554e-02f,
  -4.00691703e-02f, -5.77773266e-02f, -4.88446280e-02f, 5.99130578e-02f, -2.56601423e-02f, 4.10437882e-02f, -1.08609691e-01f, -4.16328721e-02f, -3.89004424e-02f, -6.72504753e-02f,
  -9.60740820e-02f, -9.16197076e-02f, -1.25867784e-01f, -8.36478174e-02f, 6.98657632e-02f, -4.60124388e-02f, -9.74678323e-02f, 1.24084398e-01f, 6.24469370e-02f, -9.58975777e-02f,
  -4.75573018e-02f, 7.99979940e-02f, 5.20044342e-02f, -5.25234616e-04f, -1.27520651e-01f, -6.44619167e-02f, -1.92343779e-02f, -7.75113478e-02f, -1.40068913e-02f, 1.09168679e-01f,
  1.10408738e-01f, 3.61964107e-02f, 1.30911963e-03f, -4.99213077e-02f, 1.18420206e-01f, 6.08355775e-02f, -5.70126697e-02f, 3.85016277e-02f, 4.61250097e-02f, -3.41028757e-02f,
  -7.77608678e-02f, 3.10686287e-02f, 6.40647560e-02f, -9.22250375e-02f, -2.87823658e-02f, 7.96327516e-02f, -6.94860443e-02f, 1.68815017e-01f, 2.23014280e-01f, 1.89023331e-01f,
  1.55648649e-01f, 3.25097889e-01f, -5.57864420e-02f, 1.39634656e-02f, 3.50275286e-03f, -1.75453305e-01f, 2.25760356e-01f, -7.78203085e-02f, 8.04322436e-02f, 2.71640658e-01f,
  -1.46206558e-01f, 1.46773100e-01f, 2.24977970e-01f, 4.55632284e-02f, 1.56510323e-01f, 2.28582725e-01f, -2.85687912e-02f, 1.56121090e-01f, 2.19705299e-01f, -2.23927706e-01f,
  2.83849776e-01f, 1.00986503e-01f, 1.73488725e-02f, 1.86671257e-01f, -2.58300616e-03f, 1.32635593e-01f, -2.04276338e-01f, -1.37143344e-01f, 1.93600357e-01f, 2.13827327e-01f,
  -3.39137554e-01f, 8.43144730e-02f, -9.90217254e-02f, 1.41059145e-01f, 2.09500149e-01f, -2.66459823e-01f, 5.05286790e-02f, 1.45463124e-01f, -1.89371947e-02f, 2.32386347e-02f,
  8.37562829e-02f, 9.19837654e-02f, 1.38224782e-02f, -2.08084241e-01f, -1.66707128e-01f, 6.32135794e-02f, 7.29947835e-02f, -2.05850750e-02f, -4.30552214e-02f, 2.15438321e-01f,
  3.00990660e-02f, 6.38840646e-02f, 8.51861611e-02f, 3.02351832e-01f, 3.04045677e-01f, 3.09170246e-01f, -1.61986828e-01f, 2.61233628e-01f, 1.04990274e-01f, 1.81642279e-01f,
  -1.17710587e-02f, 1.34269461e-01f, 1.19934261e-01f, -9.56303999e-03f, -1.20038033e-01f, 8.54895264e-02f, -1.54227957e-01f, 1.24634176e-01f, 5.57927340e-02f, -1.22073054e-01f,
  -1.21091574e-01f, 1.03776343e-01f, 1.84486866e-01f, 1.51054680e-01f, -6.31311759e-02f, 8.12452752e-03f, 1.63553715e-01f, -2.46202610e-02f, 1.72569975e-01f, 1.37615174e-01f,
  3.01980488e-02f, 5.29989451e-02f, 1.20332979e-01f, -2.48129517e-01f, 2.76393108e-02f, -1.08389318e-01f, 9.06373933e-02f, -5.30121848e-03f, 1.10204639e-02f, 2.23041981e-01f,
  1.81296900e-01f, -2.36946464e-01f, 1.22446962e-01f, 1.79160371e-01f, -1.74094737e-01f, -2.34423339e-01f, -1.92649923e-02f, 6.60163835e-02f, 2.86013708e-02f, -2.19456583e-01f,
  2.52632290e-01f, 2.11804248e-02f, 1.60164729e-01f, 6.99533448e-02f, -1.78773105e-01f, -1.87511817e-02f, 9.58174393e-02f, 1.26664400e-01f, 1.92844838e-01f, -1.38706595e-01f,
  8.84687901e-02f, 8.30202401e-02f, -4.60302345e-02f, 1.63513556e-01f, 1.27030388e-02f, -9.28974375e-02f, -7.45676225e-03f, 9.20614377e-02f, 8.76531452e-02f, 1.60995722e-01f,
  -7.02791885e-02f, -2.43553564e-01f, 2.16125205e-01f, 1.84599280e-01f, 1.14603683e-01f, 1.69500098e-01f, 9.85393599e-02f, -4.89149168e-02f, 8.46061707e-02f, 1.80188954e-01f,
  -1.28152415e-01f, -3.70937735e-02f, 1.32087439e-01f, 7.84671213e-03f, 2.42295247e-02f, 6.19809479e-02f, -7.28561804e-02f, 2.35883147e-02f, 2.10718047e-02f, -1.12867944e-01f,
  -2.24667247e-02f, -4.56450544e-02f, 1.50270969e-01f, 2.34351400e-02f, 1.10683456e-01f, 1.80924147e-01f, 1.07223839e-01f, 8.86451919e-03f, 1.53485890e-02f, -1.77820232e-02f,
  -2.02453673e-01f, -1.08472154e-01f, 1.57129332e-01f, 2.17060924e-01f, 6.47094175e-02f, -2.11651951e-01f, -6.21802211e-02f, 9.42988396e-02f, -1.86276972e-01f, -2.24297106e-01f,
  4.66138758e-02f, -1.62739139e-02f, -9.98724401e-02f, 1.21534996e-01f, 7.00488612e-02f, -1.98581573e-02f, 1.34240508e-01f, 1.45108119e-01f, -6.61127716e-02f, -1.10476196e-01f,
  -1.13205008e-01f, 1.85671210e-01f, 1.55093580e-01f, 5.63517585e-02f, 1.11279748e-01f, -1.19135454e-01f, 1.26416996e-01f, 7.15851411e-02f, -2.75824040e-01f, 6.61766827e-02f,
  4.38051298e-02f, 2.17444032e-01f, -1.55774832e-01f, 1.39480948e-01f, -1.97695177e-02f, 5.62623404e-02f, 2.34723948e-02f, 1.40857369e-01f, 2.22417518e-01f, 1.70041919e-01f,
  6.68414831e-02f, 8.43281299e-02f, 1.22918524e-01f, 3.18242200e-02f, -1.21896863e-01f, 1.37994990e-01f, 1.90134838e-01f, -4.44476567e-02f, -1.23544089e-01f, 8.62708613e-02f,
  1.67174801e-01f, 5.55518791e-02f, 9.03426390e-03f, 8.46020058e-02f, 2.62711078e-01f, -5.30702285e-02f, 1.62715495e-01f, 1.34186327e-01f, 1.71167508e-01f, 8.43078420e-02f,
  1.16248801e-01f, 6.58881366e-02f, -2.96989292e-01f, -2.07559705e-01f, -2.48335093e-01f, -3.31772357e-01f, -1.93242967e-01f, 1.69035003e-01f, 1.39403477e-01f, -9.62238088e-02f,
  -3.22023243e-01f, 8.89307037e-02f, -3.17011535e-01f, -2.01259121e-01f, 6.43164292e-02f, 7.75162131e-02f, -4.03872222e-01f, -2.01701280e-02f, 2.75690883e-01f, 9.09549519e-02f,
  3.49991679e-01f, 2.58675694e-01f, -1.48527101e-01f, -4.77553941e-02f, 1.86766330e-02f, 9.01231691e-02f, 7.98464641e-02f, 1.69948284e-02f, -6.40875921e-02f, -3.74977179e-02f,
  2.35438980e-02f, -2.44454667e-01f, -3.53614628e-01f, 7.22475424e-02f, -8.85287523e-02f, 1.91115141e-01f, 1.28945205e-02f, 5.13921715e-02f, 5.00078797e-01f, 2.38120154e-01f,
  1.77922711e-01f, 2.05916047e-01f, 1.59952641e-01f, 6.26567453e-02f, 3.95229496e-02f, -6.17919452e-02f, 5.73418811e-02f, -9.08101425e-02f, 1.79051459e-01f, 5.34233600e-02f,
  9.61532518e-02f, 1.21368654e-01f, 4.05059429e-03f, -1.18783233e-03f, 1.58729047e-01f, 1.13435641e-01f, 1.05177715e-01f, -6.55071437e-02f, -6.13158830e-02f, 1.98211819e-02f,
  9.66692343e-02f, -1.00237630e-01f, 9.00217146e-02f, -5.91358729e-02f, 9.02923197e-02f, 1.22434393e-01f, -2.58562109e-03f, 1.26094252e-01f, -1.99294418e-01f, 1.06375411e-01f,
  1.74070939e-01f, 8.91410708e-02f, -5.48019931e-02f, 3.03158853e-02f, 3.75751145e-02f, -1.37117282e-01f, 1.01223275e-01f, -1.17321573e-01f, 1.32089734e-01f, -3.40123802e-01f,
  -4.64056246e-03f, 9.85981897e-02f, -2.42336169e-01f, -2.99713969e-01f, 2.75632627e-02f, -3.52059938e-02f, -2.24704266e-01f, -1.38114119e-04f, 1.58791572e-01f, 8.27199668e-02f,
  1.30248725e-01f, -1.75254717e-01f, -7.27071315e-02f, 2.26031646e-01f, 3.51731963e-02f, 2.25393251e-01f, 4.51829046e-01f, -2.75076106e-02f, -1.03194393e-01f, -6.54607862e-02f,
  -4.83002700e-02f, 1.68269783e-01f, 9.34085175e-02f, 3.44134718e-02f, 1.04285479e-01f, 1.40474796e-01f, 2.04873145e-01f, 8.10715109e-02f, -2.05313340e-02f, 9.58068147e-02f,
  1.39446333e-01f, 4.35471460e-02f, 9.20326486e-02f, -1.01222575e-01f, 8.82634372e-02f, 1.55236304e-01f, -5.93055263e-02f, 8.18657726e-02f, 8.68193582e-02f, 4.20331024e-02f,
  1.74018905e-01f, 1.04443543e-01f, 5.37385978e-03f, 8.36894661e-03f, 1.27902016e-01f, 2.83340905e-02f, -8.72498453e-02f, 4.78342408e-03f, 2.62389760e-02f, -7.61209652e-02f,
  -4.60846769e-03f, -2.89723743e-02f, -1.01439711e-02f, 9.52442959e-02f, 8.40841234e-02f, 2.77542826e-02f, -1.34710491e-01f, 1.63078651e-01f, 3.58590335e-01f, -4.00908664e-02f,
  1.67011734e-04f, -1.40347809e-01f, -3.33542265e-02f, 1.85242370e-01f, 8.01425204e-02f, 1.54287531e-03f, 6.87930882e-02f, -1.20355383e-01f, -3.24277543e-02f, -2.95686871e-02f,
  5.62362596e-02f, -3.04116338e-01f, 9.18799341e-02f, 6.08408302e-02f, 3.30531508e-01f, 1.10944569e-01f, 6.48079365e-02f, -1.12460077e-01f, 9.75954458e-02f, 3.41947913e-01f,
  2.58554947e-02f, 7.47696217e-03f, 1.21266656e-01f, 1.79024845e-01f, 8.73336121e-02f, -5.07281832e-02f, -9.82876495e-02f, -1.92111924e-01f, 9.74367559e-02f, -2.26495396e-02f,
  8.29450265e-02f, -4.58641462e-02f, 6.60391152e-02f, -1.64490230e-02f, -1.15287833e-01f, -1.55205755e-02f, -9.30167455e-03f, 5.58750816e-02f, -1.14556365e-01f, -1.54657792e-02f,
  -8.93104896e-02f, 3.33904512e-02f, 1.51127324e-01f, -6.31252751e-02f, 6.66271374e-02f, 7.24377483e-02f, 1.45597756e-01f, 8.78179669e-02f, -9.08610746e-02f, 1.26179799e-01f,
  -7.98868313e-02f, 1.12548389e-01f, -5.85420579e-02f, -1.39551327e-01f, 1.24325804e-01f, -1.54094070e-01f, 7.29585215e-02f, -1.09555267e-01f, 1.28813252e-01f, 1.96735099e-01f,
  -1.86248407e-01f, -8.21356550e-02f, 1.42483473e-01f, 4.53939438e-02f, -8.67477208e-02f, -7.98339769e-02f, 1.24105714e-01f, -7.57722333e-02f, -4.37570140e-02f, 7.48448148e-02f,
  1.09566800e-01f, 1.01590008e-01f, -1.81667611e-01f, 8.69620740e-02f, 1.09270260e-01f, 5.50553873e-02f, -9.22668278e-02f, 8.81953817e-03f, 1.07941893e-03f, -3.58724669e-02f,
  -4.66965698e-02f, 2.09812839e-02f, 6.07655495e-02f, 1.72216669e-01f, -6.95605436e-03f, -2.14818362e-02f, 3.95852253e-02f, 1.03023686e-01f, 3.95034258e-05f, 6.05844818e-02f,
  -1.71638772e-01f, 3.78452661e-03f, 8.87448415e-02f, 1.32599413e-01f, 3.50451507e-02f, 1.74989849e-02f, 6.02486683e-03f, 7.56658912e-02f, 1.87495857e-01f, 1.20685406e-01f,
  6.25203401e-02f, 2.89084278e-02f, 1.75081447e-01f, 5.66102341e-02f, 1.64461195e-01f, 1.05653867e-01f, 1.16502590e-01f, 1.03246987e-01f, 7.15018287e-02f, 8.92115906e-02f,
  -4.20698784e-02f, 6.37032613e-02f, 1.17962487e-01f, 4.90789972e-02f, -7.26448745e-02f, 1.10076167e-01f, 4.33868989e-02f, 3.11716348e-02f, -4.25148606e-02f, 2.04105079e-02f,
  -1.93814024e-01f, 2.39886463e-01f, 1.21833079e-01f, 1.44416526e-01f, -2.09764361e-01f, -5.95345832e-02f, 5.52107878e-02f, -7.93920271e-03f, 2.10585864e-03f, -3.91800776e-02f,
  4.49441880e-01f, -1.51226819e-01f, 1.77236378e-01f, 1.01187624e-01f, -1.84236780e-01f, -9.10908952e-02f, -2.08342910e-01f, -2.01056693e-02f, 1.78624719e-01f, 2.82288581e-01f,
  -1.24504320e-01f, 5.59599176e-02f, -7.98276663e-02f, -6.41588867e-02f, -3.49679566e-03f, -6.06335215e-02f, -5.01187555e-02f, 4.28944796e-01f, 3.34653288e-01f, -1.16409682e-01f,
  -1.27366796e-01f, 9.73450840e-02f, -1.12492330e-01f, 2.26822436e-01f, -2.18483523e-01f, 1.23080201e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 14)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 14;
const float L2_fan_Bp_bar_data[] = {
  8.01805481e-02f, 5.55767454e-02f, -2.36662626e-02f, -4.92017567e-02f, -5.49850315e-02f, 1.90974977e-02f, 9.40264165e-02f, 7.03585371e-02f, 1.69461340e-01f, 1.55603468e-01f,
  5.59381582e-02f, 5.21261431e-02f, 1.50891200e-01f, 6.96472675e-02f
};

// L3_linear_W (Shape: 12 x 64)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 64;
const float L3_linear_W_data[] = {
  1.03501175e-02f, -1.08054779e-01f, -9.24022347e-02f, -1.87467381e-01f, 7.07888305e-02f, 5.23287617e-03f, -2.41678685e-01f, -1.37112156e-01f, 1.99847519e-01f, -9.77879614e-02f,
  2.66202629e-01f, -1.28405318e-01f, 1.71097502e-01f, 5.75007051e-02f, -3.38702761e-02f, -1.72149733e-01f, -1.16708159e-01f, -6.75063655e-02f, 8.62677172e-02f, 1.43173859e-01f,
  -1.80899188e-01f, -8.66413191e-02f, 1.31088302e-01f, -1.50122344e-01f, 1.19519472e-01f, -7.83060938e-02f, -2.79167295e-01f, -1.53161660e-02f, 3.75692397e-01f, 7.19138002e-03f,
  -3.60124484e-02f, 1.48017436e-01f, 5.94674237e-02f, -1.42495364e-01f, 2.37373680e-01f, -1.72242656e-01f, -2.53011808e-02f, 1.35572389e-01f, -2.63773739e-01f, 4.69530851e-01f,
  2.96931624e-01f, 5.11308670e-01f, -4.22767363e-02f, -1.56631336e-01f, 4.38034013e-02f, -2.88586110e-01f, 1.46072030e-01f, -4.03899968e-01f, 1.48873612e-01f, -2.37182543e-01f,
  -4.59473282e-01f, -3.16081613e-01f, -5.32071339e-03f, 1.10162549e-01f, -1.08840749e-01f, 9.47312266e-02f, 4.25244153e-01f, 4.98669207e-01f, 3.09219271e-01f, -7.28341490e-02f,
  -1.86107576e-01f, 7.10187703e-02f, 3.38692099e-01f, -1.72038540e-01f, -2.40252599e-01f, 4.15813960e-02f, 1.06951721e-01f, -2.73832202e-01f, 1.41293913e-01f, -3.19362916e-02f,
  9.81401503e-02f, 1.89124212e-01f, -5.96556552e-02f, 5.19072339e-02f, 1.91436708e-02f, -2.22456500e-01f, 1.68926958e-02f, 7.41989911e-02f, 9.26708505e-02f, -1.57404561e-02f,
  3.07699621e-01f, 3.12001616e-01f, 1.41958162e-01f, 1.35800004e-01f, 1.58706754e-02f, -9.24852788e-02f, 2.16352582e-01f, 2.60220617e-01f, -7.63990134e-02f, -2.01621383e-01f,
  -4.03293632e-02f, -1.54879168e-01f, 2.94825077e-01f, -1.73426300e-01f, -2.59258360e-01f, 3.47778231e-01f, -1.06552407e-01f, 1.75437525e-01f, 1.54624999e-01f, -2.40074471e-01f,
  1.19674228e-01f, -4.95212436e-01f, 2.43092790e-01f, -1.31219029e-01f, -1.24598727e-01f, 1.67144269e-01f, -2.71125976e-02f, -8.27532355e-03f, 2.75630713e-01f, -1.93703026e-01f,
  5.81088960e-02f, -1.15464397e-01f, 5.60535584e-03f, -3.75234187e-01f, -4.16931689e-01f, -3.05116922e-01f, 1.21073917e-01f, 2.38194540e-02f, -9.47629213e-02f, 1.10971540e-01f,
  -2.93081492e-01f, 3.61750036e-01f, 2.87454963e-01f, 7.45043218e-01f, -2.00739115e-01f, -1.24045029e-01f, 7.21506178e-02f, -4.74209130e-01f, 1.51263759e-01f, 8.49336945e-03f,
  -1.43096477e-01f, 7.51500651e-02f, 1.82813499e-02f, 1.13522083e-01f, -2.42628425e-01f, -1.10984169e-01f, -1.60409197e-01f, 1.03710763e-01f, 9.53965485e-02f, -3.19725692e-01f,
  -1.96672261e-01f, -3.57987821e-01f, -4.12124366e-01f, 7.33070150e-02f, -5.69499424e-03f, -1.56272754e-01f, -3.26225340e-01f, 2.13033378e-01f, -2.53280818e-01f, 3.36613320e-02f,
  4.15883623e-02f, -3.98674011e-02f, 7.67281279e-02f, 3.70585583e-02f, 2.11182401e-01f, 2.18552291e-01f, 2.83938229e-01f, 3.72495353e-01f, -2.11275384e-01f, -3.25201303e-01f,
  2.63295859e-01f, 1.63302541e-01f, -1.96546778e-01f, 1.52306315e-02f, 2.49776363e-01f, -2.05765694e-01f, 3.12022269e-01f, -7.25501329e-02f, 3.19338053e-01f, -1.34312958e-01f,
  3.70718598e-01f, -2.66243696e-01f, 7.84612000e-02f, -3.07950079e-01f, 2.00591132e-01f, -7.04443231e-02f, -3.36951971e-01f, -3.99427593e-01f, 1.23662725e-01f, -3.04814547e-01f,
  -1.69575959e-02f, 1.12815678e-01f, -1.21092182e-02f, 4.26664427e-02f, -4.23813820e-01f, 8.72210972e-03f, 9.35428813e-02f, 1.13871813e-01f, 2.43068844e-01f, 4.61800814e-01f,
  -7.06021627e-03f, -3.86225879e-01f, -1.69292793e-01f, -1.17323279e-01f, 1.41221270e-01f, -1.05882272e-01f, 1.64078981e-01f, 2.20362708e-01f, 1.41712904e-01f, -1.87339395e-01f,
  -3.90219577e-02f, 1.73719317e-01f, -3.28795403e-01f, 1.89808398e-01f, -3.53688091e-01f, 1.07712545e-01f, -2.90832408e-02f, -1.26623034e-01f, 2.47493520e-01f, -2.49659747e-01f,
  1.20512240e-01f, -9.50332433e-02f, -4.82889600e-02f, 2.03119382e-01f, -1.59131959e-01f, -3.54518950e-01f, -1.78880304e-01f, 2.85499007e-01f, -1.98452175e-01f, -1.41162634e-01f,
  -2.42969275e-01f, 8.04261342e-02f, -1.63841128e-01f, 6.24759644e-02f, 2.30530784e-01f, -5.49612701e-01f, -2.37357453e-01f, 2.75557905e-01f, -3.81062552e-02f, 7.98065960e-02f,
  -1.46878287e-01f, 3.87006938e-01f, 2.10384995e-01f, 1.52360052e-01f, -1.76070198e-01f, 2.10345760e-01f, -2.08187863e-01f, 3.16502243e-01f, -6.34051412e-02f, -8.77220277e-03f,
  2.68446773e-01f, 1.05452277e-01f, -3.49119693e-01f, -7.95731395e-02f, -2.50801127e-02f, 7.65824616e-02f, 2.18368750e-02f, 7.97708556e-02f, 4.97536808e-01f, -1.50846437e-01f,
  -3.69538963e-01f, -3.56379658e-01f, -4.43352252e-01f, 1.04001947e-01f, 2.03780025e-01f, 1.87120155e-01f, -4.44669984e-02f, 1.28598705e-01f, -4.33703139e-02f, 1.68000460e-02f,
  1.51783824e-01f, 7.10243657e-02f, 9.33323652e-02f, -1.45898283e-01f, 3.58207077e-01f, 6.04031757e-02f, 3.35276127e-01f, 7.76100308e-02f, -4.04245518e-02f, 9.87729952e-02f,
  3.91909689e-01f, 3.55724129e-04f, 1.36557102e-01f, -1.20114602e-01f, 4.26101126e-02f, -5.35653114e-01f, 2.08266824e-01f, -1.81166306e-01f, -3.90949361e-02f, 3.53359580e-01f,
  3.25260729e-01f, 4.73771781e-01f, 1.32369846e-01f, 3.21958542e-01f, -1.86916038e-01f, -2.29554623e-01f, 2.48568371e-01f, 8.48714188e-02f, 2.06307158e-01f, 1.95183083e-01f,
  3.88173461e-02f, 4.36245203e-01f, 1.40371069e-01f, 3.19641054e-01f, -6.55410960e-02f, 1.14059038e-01f, 2.41955161e-01f, -8.10074732e-02f, -1.25537917e-01f, -4.84425217e-01f,
  -2.44163826e-01f, -3.86819392e-02f, 2.80085593e-01f, 2.21964389e-01f, 7.86821619e-02f, 9.50730965e-02f, -4.19971794e-02f, 2.00947318e-02f, 4.97446842e-02f, -5.92398122e-02f,
  -2.37794310e-01f, 5.16501628e-02f, 2.65379250e-01f, 3.05998594e-01f, -3.21150154e-01f, -5.63123226e-01f, 2.33337224e-01f, 2.19557405e-01f, 1.13613129e-01f, 1.35202080e-01f,
  -1.97570592e-01f, 7.30542839e-02f, 1.72922537e-02f, 2.34986722e-01f, 5.78140840e-03f, 7.86369815e-02f, 6.03721961e-02f, 1.47916168e-01f, -6.46463111e-02f, -2.85138428e-01f,
  3.02473065e-02f, 2.76894271e-01f, 2.59428233e-01f, 5.50007187e-02f, 3.05330306e-01f, -6.22159131e-02f, 1.41283765e-01f, 3.42000159e-03f, 1.11888520e-01f, 2.06746936e-01f,
  2.27751628e-01f, 1.92892417e-01f, -4.68171462e-02f, 1.31909460e-01f, 3.03010404e-01f, -3.47837478e-01f, 2.27427855e-01f, -1.53168038e-01f, 1.61775857e-01f, -4.02734756e-01f,
  1.94545239e-01f, 2.84055397e-02f, -3.62630099e-01f, 1.90670684e-01f, 2.25909606e-01f, -3.71657670e-01f, -2.05297068e-01f, 1.64182037e-01f, -1.74351230e-01f, 1.31173521e-01f,
  -3.45499814e-01f, 1.45029038e-01f, -1.55375838e-01f, 3.62430662e-02f, -4.30391580e-02f, 1.56908818e-02f, 2.13257540e-02f, 1.87550545e-01f, 4.18415368e-02f, 1.91251174e-01f,
  2.22218424e-01f, 5.21004386e-03f, 1.19975947e-01f, -7.95514137e-03f, -2.65042126e-01f, 9.88105983e-02f, 9.12901163e-02f, 2.02458054e-02f, 1.20125711e-01f, 3.86025459e-01f,
  1.27663404e-01f, -4.90339816e-01f, 1.01177385e-02f, 2.65875846e-01f, 7.45211244e-02f, -1.57281011e-01f, 4.38883454e-02f, 1.46810710e-01f, 1.49051696e-01f, 8.31453130e-02f,
  -2.66167372e-01f, 1.92856848e-01f, -2.60717541e-01f, -1.08303048e-01f, 2.07470953e-02f, 1.73357502e-01f, 9.24880952e-02f, 8.34092796e-02f, -1.79208174e-01f, -8.81092325e-02f,
  -2.70552695e-01f, -1.10170238e-01f, -9.98111218e-02f, 3.56608517e-02f, 6.26989827e-02f, 2.06340477e-01f, -2.91823894e-01f, -1.43973738e-01f, 3.20195049e-01f, -7.58933499e-02f,
  3.40767324e-01f, 3.32044482e-01f, -1.14884786e-01f, -1.27833024e-01f, 2.46483594e-01f, -1.15468733e-01f, -1.94688052e-01f, -4.59290333e-02f, 1.38228938e-01f, -9.60044786e-02f,
  5.32220900e-02f, -3.28975141e-01f, 2.28357725e-02f, -1.71298951e-01f, -2.34717280e-01f, -5.16342707e-02f, 2.48926535e-01f, -3.33906174e-01f, -1.65887564e-01f, -1.20636061e-01f,
  5.84687442e-02f, 2.56160110e-01f, -2.70500690e-01f, -1.80173859e-01f, 7.01395750e-01f, 2.29822218e-01f, 7.37820715e-02f, 1.05352432e-01f, -6.37571067e-02f, -9.57297832e-02f,
  -5.71624458e-01f, -4.86874878e-01f, -2.94959724e-01f, -2.25685224e-01f, 3.94352823e-01f, -2.97900349e-01f, 7.84877688e-03f, -6.58702180e-02f, -2.89130155e-02f, -1.06904633e-01f,
  -2.21561417e-01f, -1.94326490e-01f, 3.14783305e-03f, -4.53897208e-01f, -1.41600445e-01f, 1.77676186e-01f, 9.96228531e-02f, -4.12965715e-02f, 2.48805014e-03f, -8.11069682e-02f,
  -2.74629533e-01f, -1.70125321e-01f, 1.05272554e-01f, -1.04788885e-01f, 5.77617474e-02f, -4.67009768e-02f, -7.33117387e-03f, -8.97399187e-02f, 1.48144946e-01f, 1.32237762e-01f,
  3.16481113e-01f, 4.45288308e-02f, -1.27605563e-02f, 1.53112650e-01f, -2.94956684e-01f, -3.19341123e-01f, -1.22013325e-02f, 3.64258140e-01f, 2.68405557e-01f, -7.31022358e-02f,
  -1.68433160e-01f, -2.54139155e-01f, 1.04016669e-01f, 2.47727230e-01f, -5.76546907e-01f, 1.92300722e-01f, -1.74930230e-01f, 6.29050732e-02f, -1.45044357e-01f, 1.39503017e-01f,
  -3.66039649e-02f, 2.90754855e-01f, 9.63560566e-02f, -5.90826683e-02f, -4.60135460e-01f, 1.28515856e-02f, 1.69879094e-01f, 1.28802091e-01f, 6.73346519e-02f, 7.01187328e-02f,
  -2.43258141e-02f, 2.40911767e-02f, 3.90551358e-01f, 6.28397800e-03f, 8.12014006e-03f, -1.86628178e-01f, 2.26154476e-01f, -2.92050123e-01f, 1.28700465e-01f, 1.64382502e-01f,
  3.18999708e-01f, 4.72701192e-01f, -1.99161768e-01f, 9.63022262e-02f, -6.30947435e-03f, -7.86920339e-02f, -1.76067755e-01f, 4.92713368e-03f, -8.21305364e-02f, 1.10621601e-01f,
  -1.90815073e-03f, 2.01631500e-03f, 5.36412075e-02f, 1.50934711e-01f, 1.79947779e-01f, -2.98892558e-01f, -3.39142263e-01f, -3.59770060e-02f, -2.09163666e-01f, -8.88179243e-02f,
  1.42791167e-01f, -4.35467549e-02f, 1.25214070e-01f, 1.48787245e-01f, -1.32206619e-01f, -1.62036717e-01f, -1.37719557e-01f, -3.28791082e-01f, -2.64453799e-01f, -2.41234705e-01f,
  -1.20964624e-01f, 4.51327384e-01f, -1.98656663e-01f, -1.03550650e-01f, -2.18088776e-01f, 2.47340709e-01f, -1.98183089e-01f, -8.41364190e-02f, -1.70399785e-01f, -2.04845101e-01f,
  6.93074092e-02f, -1.08617380e-01f, -2.01846704e-01f, -1.94221288e-01f, 3.39555949e-01f, 3.85454506e-01f, 4.89402771e-01f, 1.39363363e-01f, -3.12340349e-01f, -3.97930630e-02f,
  -1.57476097e-01f, 3.64371896e-01f, 3.85755002e-01f, 1.42114535e-01f, -4.02465239e-02f, 1.95312463e-02f, 3.43453169e-01f, -8.53179693e-02f, -3.96164894e-01f, -2.86017120e-01f,
  6.69523627e-02f, 4.49718386e-01f, -2.11768180e-01f, 7.75942951e-02f, -4.29396145e-02f, -1.36428088e-01f, 1.24652579e-01f, 9.97924730e-02f, 1.59933671e-01f, -4.18277830e-02f,
  8.64826143e-02f, -3.58052909e-01f, 1.46858245e-01f, -2.22568512e-02f, -1.80915222e-01f, -9.55241621e-02f, 4.70758742e-03f, 8.61515775e-02f, 2.34861195e-01f, 1.04280062e-01f,
  -9.73218903e-02f, 2.29135230e-01f, 3.29525210e-02f, 2.72611022e-01f, -3.72000545e-01f, -2.56073862e-01f, -1.41879730e-02f, -1.11276999e-01f, 3.41835767e-01f, -1.83676690e-01f,
  -1.85515583e-01f, 2.62668669e-01f, 1.01126812e-01f, 8.58329423e-03f, -9.27166361e-03f, -3.82036604e-02f, 3.31423730e-01f, 9.65943933e-02f, 3.25264871e-01f, 1.46259025e-01f,
  1.90238014e-01f, -3.95934284e-01f, 2.69306213e-01f, -2.67887861e-01f, -8.53004530e-02f, -3.96389097e-01f, -1.59769263e-02f, -1.24767922e-01f, 1.03180014e-01f, 1.10606318e-02f,
  -3.21850419e-01f, -2.34655246e-01f, 6.17059618e-02f, -3.42306942e-01f, -3.99954945e-01f, -3.26663017e-01f, -2.57437155e-02f, -1.73244953e-01f, -4.42398712e-02f, -2.32143030e-02f,
  -2.10014567e-01f, -5.73266819e-02f, -2.43876815e-01f, -1.44496029e-02f, -8.01815838e-02f, -4.93339211e-01f, 5.16693830e-01f, 1.83440208e-01f, -2.89528780e-02f, 4.35750902e-01f,
  1.53095797e-01f, -4.30959649e-02f, -7.82506168e-02f, 1.44600570e-01f, -2.02279221e-02f, -7.39006102e-02f, 1.64418459e-01f, 1.65605992e-01f, 3.88912976e-01f, 2.48163223e-01f,
  -1.44472182e-01f, -1.60142481e-01f, 3.35987687e-01f, 1.63023680e-01f, 3.40858519e-01f, 5.98269626e-02f, -3.00911590e-02f, 1.08917668e-01f, 1.50547996e-01f, 1.18719250e-01f,
  2.49959175e-02f, 8.48750547e-02f, -2.49855459e-01f, 8.20972696e-02f, -9.48884636e-02f, -1.26444340e-01f, -1.58748269e-01f, 3.05463731e-01f, 1.60408542e-01f, 1.80518180e-01f,
  -5.03716648e-01f, -1.64707080e-01f, 9.74253099e-03f, 1.18273897e-02f, -1.00563638e-01f, 4.96735454e-01f, 2.98057318e-01f, 1.52461946e-01f, 3.87332737e-01f, 1.57151029e-01f,
  1.55115053e-01f, -3.97266120e-01f, -1.34657621e-01f, 2.49465868e-01f, -1.63867205e-01f, 1.08550787e-01f, 2.21977487e-01f, 1.52951777e-01f, 3.97112340e-01f, 4.18284893e-01f,
  -1.73762143e-01f, -1.29943356e-01f, 9.54922214e-02f, 3.49013172e-02f, -9.55397189e-02f, -6.23802431e-02f, 4.64904219e-01f, 4.47332487e-02f, 7.30211362e-02f, 2.61655748e-01f,
  -3.77833188e-01f, -8.71486515e-02f, -7.68125355e-02f, -4.37506169e-01f, 2.36561954e-01f, 1.72632143e-01f, 1.92759559e-03f, -2.83441007e-01f, 3.09800301e-02f, -2.30379100e-03f,
  -2.13321030e-01f, 1.06894322e-01f, -1.65155321e-01f, 1.12038240e-01f, -1.68521162e-02f, 8.42303261e-02f, 8.78500193e-02f, 2.18671620e-01f, 4.00091819e-02f, -1.26560226e-01f,
  -4.06174749e-01f, 1.61147207e-01f, 1.77772474e-02f, -4.30495702e-02f, -2.64790505e-01f, 1.05990767e-02f, -4.46622670e-01f, 2.75145143e-01f, -3.46873224e-01f, 3.35816965e-02f,
  1.16760358e-01f, -2.09642604e-01f, -2.63892919e-01f, -3.33377957e-01f, 2.48564541e-01f, -1.80840015e-01f, -2.88898259e-01f, 1.81649297e-01f, -1.87802747e-01f, 4.01425809e-01f,
  -1.49959236e-01f, 3.55667531e-01f, -1.25060789e-02f, -3.02232236e-01f, -2.69808590e-01f, -1.36199921e-01f, -1.41181454e-01f, 3.49007875e-01f, -5.01605384e-02f, 3.42253655e-01f,
  -1.64720476e-01f, -5.21090776e-02f, 5.59100881e-02f, 3.25760841e-01f, 4.68874305e-01f, 3.41367155e-01f, -1.88533794e-02f, 1.74013209e-02f, 2.86785573e-01f, 5.98725714e-02f,
  4.19803821e-02f, -1.54716775e-01f, -2.91621834e-01f, -2.31989801e-01f, 6.92931265e-02f, -3.07667375e-01f, -3.62123512e-02f, 1.14740655e-01f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  3.81751992e-02f, -1.48080885e-02f, -4.35893703e-03f, 9.37224925e-02f, 1.20817229e-01f, -8.94402787e-02f, -5.79182133e-02f, 2.51096506e-02f, -1.45299196e-01f, 2.92266868e-02f,
  -3.06865647e-02f, -7.60804564e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 25, 14
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 25, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        64, 25, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        64, 12
    );
    }
    