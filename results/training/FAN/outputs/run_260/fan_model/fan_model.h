/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 9 x 120)
const int L0_fan_Wp_rows = 9;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  1.52796283e-01f, 4.34232205e-02f, 2.47565806e-01f, -1.77022606e-01f, 1.24773178e-02f, 6.89069554e-02f, -3.92890647e-02f, -3.35164778e-02f, -1.91709604e-02f, -1.03293717e-01f,
  -1.61266342e-01f, 2.66451567e-01f, 6.30824128e-03f, -3.49803746e-01f, -9.87332873e-03f, -3.04976087e-02f, -3.14478606e-01f, -1.00112960e-01f, 5.36944792e-02f, -4.84554358e-02f,
  -4.22200114e-02f, -3.83626848e-01f, -6.94388151e-02f, -9.77870971e-02f, -1.18799999e-01f, 1.29442737e-01f, -1.92787528e-01f, 1.94621921e-01f, -1.15916856e-01f, 1.30741885e-02f,
  1.15907870e-01f, -2.66891569e-02f, 6.69073910e-02f, -2.14748085e-02f, -3.85320038e-02f, 2.74169128e-02f, 1.82526819e-02f, 1.00303143e-01f, 7.25809336e-02f, 2.01141555e-03f,
  6.41431138e-02f, -3.81962284e-02f, -6.13836870e-02f, -1.31922709e-02f, -2.27747653e-02f, 8.20175186e-02f, 4.72639017e-02f, 2.44335327e-02f, 1.42039834e-02f, 7.02435896e-02f,
  7.62509927e-02f, -3.43600027e-02f, -5.46331480e-02f, -4.25291546e-02f, 4.19704951e-02f, -4.04877327e-02f, -1.13922739e-02f, 6.81423992e-02f, 2.78015714e-02f, 1.27646141e-02f,
  -4.13235873e-02f, 1.28403315e-02f, -2.34726071e-02f, -6.62038401e-02f, 4.31158999e-03f, -5.05499914e-02f, 5.83318761e-04f, 1.09306900e-02f, 9.58038401e-03f, -1.98562127e-02f,
  -7.35482620e-03f, -2.92281657e-02f, 7.65408762e-03f, -2.82217525e-02f, -4.96710800e-02f, -5.23498096e-02f, 3.97520214e-02f, -6.66708201e-02f, -9.36925784e-03f, -2.02131551e-02f,
  -2.00070906e-02f, 2.28285845e-02f, -3.42224315e-02f, -5.78929745e-02f, -4.33476530e-02f, -3.00518982e-02f, -3.77994888e-02f, 1.30405007e-02f, 1.62364244e-02f, 3.59772108e-02f,
  -1.45874470e-01f, -2.68012881e-01f, -4.77892085e-04f, 8.22140742e-03f, -3.79762193e-03f, 1.00858940e-03f, -1.80374719e-02f, -3.61623093e-02f, -1.22291576e-02f, -2.69345548e-02f,
  -3.72373350e-02f, -6.37851432e-02f, 2.95993164e-02f, 1.30306007e-02f, 1.93549860e-02f, -3.46084386e-02f, -8.72317404e-02f, -5.70989475e-02f, -6.29358962e-02f, -4.13547084e-02f,
  -2.50666328e-02f, 3.29350904e-02f, 7.28145093e-02f, -4.63041067e-02f, -3.04676257e-02f, -1.12906825e-02f, 8.74661654e-02f, 5.26709780e-02f, 2.20204275e-02f, 3.36178541e-02f,
  8.31931159e-02f, 2.75509149e-01f, 3.47573191e-01f, 5.19517288e-02f, -2.00167194e-01f, -8.82990472e-03f, 1.99291572e-01f, -2.62996107e-02f, -5.73640876e-02f, 1.38584614e-01f,
  -1.06623374e-01f, 1.86310619e-01f, 3.79600897e-02f, 7.44822472e-02f, -7.52785429e-02f, 6.39302284e-02f, -1.80270374e-02f, 2.49014925e-02f, -7.46289268e-02f, -1.90843027e-02f,
  -4.28741090e-02f, -1.59267664e-01f, 2.00633854e-01f, 3.19191478e-02f, 3.83589715e-02f, 3.24426144e-02f, -3.62449437e-02f, -3.97411920e-02f, -6.24987520e-02f, -3.25699113e-02f,
  -1.54069528e-01f, 9.47319865e-02f, -2.39478126e-02f, 8.45870674e-02f, -3.02430149e-02f, 9.22907367e-02f, -3.62529531e-02f, -9.91989579e-03f, -4.55481466e-03f, -4.96841921e-03f,
  2.54587494e-02f, 5.11824060e-03f, 5.06571084e-02f, 4.57276292e-02f, -6.15925379e-02f, 5.35923580e-04f, -3.10844686e-02f, -2.35371608e-02f, 3.95084545e-02f, -2.87562571e-02f,
  6.38247207e-02f, 9.77514591e-03f, -5.82113713e-02f, 6.86198380e-03f, -2.06152499e-02f, 2.42310334e-02f, 6.32478446e-02f, 1.61486808e-02f, -6.87132997e-04f, -1.55403912e-02f,
  4.87815365e-02f, -5.61126769e-02f, -5.43439901e-03f, -5.70569411e-02f, -1.97583176e-02f, 1.75600704e-02f, -3.32874544e-02f, 1.54499263e-02f, 1.24311503e-02f, -9.09715425e-03f,
  -4.11099903e-02f, -9.87589918e-03f, 4.96458588e-03f, 7.78841879e-03f, 4.45818417e-02f, 1.48731247e-02f, -4.23100218e-03f, 9.77440365e-03f, 3.23273987e-02f, -7.32401535e-02f,
  7.76348487e-02f, -3.11884601e-02f, 7.41725191e-02f, -9.47574619e-03f, -9.67393722e-03f, -1.75073743e-02f, 9.48102446e-04f, 5.86094009e-03f, 7.13846134e-03f, -2.47000903e-02f,
  -2.88111776e-01f, -6.61068410e-02f, -4.62828763e-02f, -4.63078395e-02f, -5.12027293e-02f, -9.90268514e-02f, 6.71771914e-02f, -1.28823109e-02f, 1.68178566e-02f, 7.08615500e-03f,
  1.26073677e-02f, 3.09642740e-02f, -1.77555718e-02f, -2.55238116e-02f, 5.17833568e-02f, -2.70058289e-02f, 3.40080820e-02f, 3.44367661e-02f, -3.05555109e-02f, 2.85489298e-02f,
  -1.60910413e-02f, -2.53801327e-02f, -1.41772414e-02f, 3.70541997e-02f, 6.00154325e-03f, -1.00134676e-02f, -6.42774552e-02f, 3.89886834e-02f, 6.36019930e-02f, 5.87375388e-02f,
  -4.38813061e-01f, 3.12944978e-01f, 3.19282144e-01f, -2.63570517e-01f, -2.37591356e-01f, 3.80097777e-02f, -1.24524951e-01f, -6.74017295e-02f, -6.58048391e-02f, 9.31052417e-02f,
  -5.38133793e-02f, 1.19457625e-01f, 5.95772974e-02f, -2.13424377e-02f, -2.10359573e-01f, 2.23021626e-01f, -1.20600417e-01f, 5.43504767e-02f, 1.19054765e-01f, -2.15078130e-01f,
  -7.92714283e-02f, -1.24522887e-01f, 1.18245460e-01f, -3.82364765e-02f, -1.29022256e-01f, 2.35703625e-02f, -1.70914948e-01f, 1.00056998e-01f, -3.29125002e-02f, 5.25508374e-02f,
  -6.89760819e-02f, -1.88463405e-01f, 8.24886039e-02f, 5.20173982e-02f, -2.94994637e-02f, -3.19318118e-04f, 7.57534243e-03f, 1.22706488e-01f, 4.59180698e-02f, -5.65379765e-03f,
  3.48173664e-03f, -1.41117871e-02f, 2.56087296e-02f, 5.95331304e-02f, 5.60382660e-03f, 2.21041795e-02f, -1.59239229e-02f, 3.35416533e-02f, 1.71334613e-02f, 1.83099825e-02f,
  9.53596979e-02f, 3.93909998e-02f, 2.71479264e-02f, 1.30463541e-02f, 6.92140823e-03f, 3.51099297e-02f, 3.51439863e-02f, 1.99838188e-02f, -8.14482346e-02f, -1.16187312e-01f,
  1.16399042e-02f, -5.27490750e-02f, 3.46850790e-02f, -4.14967574e-02f, -1.85727812e-02f, -4.35687080e-02f, 2.07254812e-02f, -4.43364382e-02f, 5.03692664e-02f, 2.63114169e-04f,
  -7.35062659e-02f, -5.20915873e-02f, -3.59070934e-02f, 6.56233430e-02f, 1.40478257e-02f, -3.43822613e-02f, -1.40694585e-02f, 2.00506579e-02f, -5.82338795e-02f, -1.03410864e-02f,
  2.12302227e-02f, -3.05811632e-02f, 5.06001012e-03f, -2.06423234e-02f, -7.25299167e-03f, 1.88930370e-02f, -2.50022253e-03f, 6.72065467e-02f, -8.91065784e-03f, -7.81661719e-02f,
  3.30080278e-02f, -2.44543031e-01f, -2.69413050e-02f, -4.32857722e-02f, 1.26711344e-02f, 5.23931533e-03f, 5.53213991e-02f, -2.31507290e-02f, 1.72046814e-02f, -1.07096648e-02f,
  -3.29153389e-02f, -5.76449335e-02f, -4.88360040e-02f, -3.81982364e-02f, 8.07736814e-02f, -3.48303355e-02f, -2.24919692e-02f, -8.43303185e-03f, -5.92740849e-02f, 2.54499279e-02f,
  -5.38730398e-02f, -7.04618469e-02f, 2.86807250e-02f, -4.33315299e-02f, -6.82285950e-02f, 1.96109992e-02f, -8.62945765e-02f, 3.02473549e-02f, 3.59877609e-02f, 4.20820676e-02f,
  -4.78693604e-01f, 9.23918039e-02f, -1.32855967e-01f, -2.27733195e-01f, -6.41187606e-03f, 2.88270950e-01f, 1.79256842e-01f, -2.67304368e-02f, 8.46092626e-02f, 2.14593217e-01f,
  7.44021386e-02f, -1.04323469e-01f, 1.44893676e-01f, -1.73254311e-02f, -2.75125384e-01f, 2.38700554e-01f, -5.69322407e-02f, 2.13810964e-03f, -6.28987476e-02f, -6.59259409e-02f,
  -1.71070516e-01f, -5.13679832e-02f, -2.24588871e-01f, -1.54507495e-02f, -5.23503199e-02f, -1.35159329e-01f, -7.69564137e-02f, -2.81550344e-02f, -1.57765001e-01f, -5.12644947e-02f,
  1.83063485e-02f, -2.79312432e-02f, -8.34088624e-02f, 2.03739796e-02f, 1.41779818e-02f, -2.49043312e-02f, 6.68473309e-03f, -4.99134138e-02f, -1.18011162e-01f, -8.76608863e-03f,
  3.87733132e-02f, -4.71718311e-02f, -1.89006422e-02f, -5.37793115e-02f, -2.15148106e-02f, -6.39954358e-02f, -7.82590359e-03f, 3.09515689e-02f, 4.45200056e-02f, -7.82513991e-02f,
  -7.91201554e-03f, -1.30154351e-02f, -4.38799895e-02f, 2.55419873e-02f, -4.58390228e-02f, -2.85340212e-02f, 4.82197292e-03f, -4.35349792e-02f, 5.89320846e-02f, -2.74801329e-02f,
  -1.38561474e-02f, 6.11497276e-02f, 2.20037214e-02f, 5.44648319e-02f, -2.48928256e-02f, 2.79216021e-02f, 7.14818574e-03f, -1.09096272e-02f, -6.46839961e-02f, 1.12108709e-02f,
  1.18353451e-02f, 2.10789917e-03f, -2.86027882e-02f, 4.87632304e-02f, -8.79784301e-03f, 1.92490034e-02f, -3.40978578e-02f, 2.19455566e-02f, -7.53865810e-04f, 8.66981037e-03f,
  6.23374097e-02f, 2.72651035e-02f, 1.20250471e-02f, 4.27780394e-03f, 8.17647800e-02f, -7.96819329e-02f, -9.88577306e-03f, -5.34397811e-02f, 1.24045582e-02f, 3.86524051e-02f,
  1.04798563e-01f, 3.28076258e-02f, 5.97682446e-02f, 1.94831155e-02f, 1.38691990e-02f, -2.30300496e-03f, -2.07860209e-03f, -2.42759921e-02f, 7.19215348e-02f, -6.42244425e-03f,
  -2.64395121e-02f, 2.52480377e-02f, 6.63824826e-02f, -3.09211388e-03f, -1.94639843e-02f, 6.75424784e-02f, 4.58706394e-02f, -8.83516222e-02f, -4.99392534e-03f, -2.88111288e-02f,
  -3.67220212e-03f, 3.39791998e-02f, 9.42450110e-03f, 5.81472740e-02f, -1.69852003e-03f, 3.42454091e-02f, 3.88505235e-02f, -3.60819288e-02f, 2.18716655e-02f, 7.24225789e-02f,
  -4.91949230e-01f, 1.60562262e-01f, -5.29340352e-04f, -1.06352165e-01f, -2.41116792e-01f, -2.34864317e-02f, 1.01699248e-01f, -6.39175028e-02f, -2.10518226e-01f, 1.41893104e-01f,
  1.22741796e-02f, -1.07128151e-01f, 3.30891609e-01f, 4.15845662e-02f, 3.43377218e-02f, 2.21585020e-01f, -3.97010148e-02f, -4.51631006e-03f, -6.98782504e-02f, 1.86719038e-02f,
  -5.93823567e-02f, 8.94615147e-03f, 7.92734772e-02f, 2.99907904e-02f, -1.39564753e-01f, -1.33846402e-01f, 1.29454017e-01f, 9.60466936e-02f, 2.47257613e-02f, 5.86876050e-02f,
  -6.57145083e-02f, 1.63562130e-03f, -5.53222299e-02f, 4.46484275e-02f, 1.73366219e-02f, -1.82710048e-02f, 4.11975896e-03f, 3.19149345e-02f, 8.92249169e-04f, 1.57960672e-02f,
  7.31182024e-02f, -5.78724546e-03f, -3.70510332e-02f, 1.88841224e-02f, -4.49514352e-02f, -3.85659225e-02f, -6.02821670e-02f, -7.79589117e-02f, -1.77467708e-02f, -1.85597725e-02f,
  -2.43432615e-02f, 1.41294778e-03f, -1.69634391e-02f, 4.69480008e-02f, -1.05312644e-02f, -1.23581756e-02f, 3.59897800e-02f, 4.56722118e-02f, -4.92842793e-02f, -1.24576653e-03f,
  -4.83579934e-03f, -8.04860424e-03f, 2.18758043e-02f, -2.52612475e-02f, -4.56754044e-02f, -6.08463101e-02f, -1.67459287e-02f, 6.83200732e-02f, -2.99289785e-02f, 7.29086343e-03f,
  -6.30214289e-02f, -1.00362115e-03f, 2.75668819e-02f, -3.50376628e-02f, -4.93455445e-03f, -2.66523380e-02f, 3.43166664e-02f, -2.33806279e-02f, -1.80554278e-02f, -4.33471911e-02f,
  2.53694765e-02f, -4.49487306e-02f, 1.89668313e-02f, 5.54916002e-02f, 5.36707975e-03f, -3.00409179e-02f, 5.06835952e-02f, -1.68510657e-02f, -3.37565318e-03f, 1.49403105e-03f,
  1.68700114e-01f, 1.94176868e-01f, -1.44507112e-02f, -3.53651978e-02f, 5.68417720e-02f, -1.47062074e-02f, 6.89306716e-03f, -1.88034605e-02f, 2.42554191e-02f, 1.57563947e-02f,
  1.32967327e-02f, -9.03257355e-03f, -1.25581026e-02f, -8.47828835e-02f, -1.85051784e-02f, 6.63101301e-02f, 5.27837016e-02f, -3.16658430e-02f, -2.65343906e-03f, -5.88152111e-02f,
  1.31224794e-02f, -1.10666789e-02f, 7.31805107e-03f, -7.13216811e-02f, -4.05987073e-03f, 2.26715244e-02f, -4.39335369e-02f, 6.39360631e-03f, 1.30847404e-02f, -2.21658424e-02f,
  -8.00410360e-02f, -4.15497988e-01f, 1.65012017e-01f, -2.00230747e-01f, 2.79679626e-01f, -1.17044769e-01f, -2.63040632e-01f, 1.33665502e-01f, -1.42703801e-02f, -2.87688643e-01f,
  -5.55893853e-02f, -3.26421887e-01f, -1.15201533e-01f, -2.58409679e-01f, -7.64297247e-02f, -1.97461203e-01f, -1.61704898e-01f, -1.46484897e-01f, 4.06369343e-02f, 1.88673027e-02f,
  5.42266406e-02f, -1.15976214e-01f, 5.40461168e-02f, 1.80613503e-01f, 8.89465213e-02f, 1.23123333e-01f, 1.86013296e-01f, 8.89426693e-02f, 1.71506032e-02f, -1.52882580e-02f,
  3.55905555e-02f, -1.58569142e-01f, 8.24564770e-02f, 3.12032904e-02f, 6.18224852e-02f, -1.44547215e-02f, 6.25902042e-02f, 5.47269769e-02f, 9.42341015e-02f, -3.22482325e-02f,
  -5.65171763e-02f, 7.99450499e-05f, 3.59578319e-02f, 1.33713884e-02f, -1.67554170e-02f, 5.58832102e-02f, -5.51898615e-04f, 6.51533604e-02f, 6.94799274e-02f, -5.49015440e-02f,
  -4.15544547e-02f, 4.93429676e-02f, 9.64828709e-04f, -3.43161486e-02f, 6.88732415e-02f, -4.22781520e-02f, 1.58905634e-03f, 1.54203987e-02f, 2.05680743e-04f, 2.01872041e-04f,
  7.80810742e-03f, 1.89133175e-02f, -2.82371566e-02f, 2.76063737e-02f, -6.36693165e-02f, 8.22183415e-02f, -6.42109290e-02f, 1.99274942e-02f, -9.00304038e-03f, -6.85261912e-04f,
  -3.85929877e-03f, -1.36646228e-02f, 1.41578205e-02f, -2.46407893e-02f, -1.97249521e-02f, -4.24063858e-03f, 3.26465964e-02f, 4.38987184e-03f, 4.38130759e-02f, 9.58669409e-02f,
  -1.84677336e-02f, -1.84695590e-02f, -3.92258577e-02f, 6.03904612e-02f, -1.79683845e-02f, -6.45669969e-03f, 2.27668812e-03f, 1.84630845e-02f, 9.28779989e-02f, -8.89458414e-03f,
  -1.87472090e-01f, -1.82009757e-01f, -3.34025212e-02f, 1.17501561e-02f, -3.73793431e-02f, -3.02049536e-02f, -3.31687480e-02f, -1.03594400e-02f, -8.78641829e-02f, 3.34669948e-02f,
  9.55993757e-02f, 7.73465410e-02f, -1.08849378e-02f, 1.40595436e-02f, -1.54856173e-03f, -3.17851342e-02f, 1.71346255e-02f, -1.84839852e-02f, -1.21854283e-02f, 8.96778796e-03f,
  8.89849886e-02f, -4.07222053e-03f, 3.49478945e-02f, 4.97441441e-02f, -4.31934409e-02f, 1.61600509e-03f, -3.80184874e-02f, 2.94379946e-02f, 3.83074507e-02f, -3.88213024e-02f,
  -6.77390158e-01f, -5.84296957e-02f, -5.09051681e-01f, -1.79875270e-01f, 6.41472116e-02f, 7.78231472e-02f, -1.23885229e-01f, -1.00600913e-01f, -2.68816084e-01f, 1.96523905e-01f,
  1.16872847e-01f, -1.84892640e-01f, -2.55694427e-02f, -5.60884946e-04f, -1.25672862e-01f, 7.50660449e-02f, 8.38983655e-02f, -4.42781337e-02f, -4.11736220e-02f, -1.09501094e-01f,
  -8.02106336e-02f, 2.19049856e-01f, -7.99367353e-02f, 2.70137578e-01f, -1.15559496e-01f, -1.11222669e-01f, 2.55862270e-02f, 3.23013477e-02f, 5.48117794e-02f, 8.58198479e-02f,
  -5.16457483e-02f, -2.04960883e-01f, -1.60574868e-01f, -1.22083209e-01f, -6.84050545e-02f, 2.02574115e-02f, -7.58900214e-03f, -2.22191978e-02f, -1.27541809e-03f, -3.11931758e-03f,
  -2.02888735e-02f, -4.81840894e-02f, 2.24445132e-03f, 5.91530576e-02f, -4.52687442e-02f, -4.64194175e-03f, 2.60063875e-02f, 3.50734070e-02f, -2.99362782e-02f, 4.44043167e-02f,
  1.13693764e-03f, -1.09333498e-02f, -3.52599472e-02f, 1.60531718e-02f, -4.11876850e-03f, 4.25557652e-03f, 4.73264307e-02f, 1.15223113e-03f, 5.82596799e-03f, -3.41341458e-02f,
  2.54037622e-02f, -4.73608226e-02f, 4.53434214e-02f, -2.19345000e-02f, 1.17995739e-02f, 8.34042430e-02f, 1.39984023e-02f, 1.52724134e-02f, -3.31430845e-02f, 4.68917564e-02f,
  1.53200831e-02f, -4.83357385e-02f, -4.71049845e-02f, -1.79748498e-02f, 3.38659994e-02f, -6.38321450e-04f, -3.04730069e-02f, 1.82551816e-02f, -2.75941268e-02f, -4.74550441e-04f,
  -3.90566327e-02f, -1.09757204e-02f, 1.71800293e-02f, 2.00914368e-02f, 3.69922398e-03f, -4.74143550e-02f, -3.53263989e-02f, -4.60693380e-03f, -1.25932777e-02f, 5.56567945e-02f,
  1.90531373e-01f, 1.24261692e-01f, 4.90570180e-02f, 1.48521047e-02f, 5.60523234e-02f, 8.83835740e-03f, 3.88662145e-02f, -2.26598401e-02f, 2.63883583e-02f, -1.57469716e-02f,
  1.55866216e-03f, 2.98192278e-02f, -1.12859886e-02f, 2.21737474e-02f, 4.41491865e-02f, -4.16263426e-03f, 2.23132204e-02f, -1.26249352e-02f, 2.45812982e-02f, 1.53226629e-02f,
  1.39479684e-02f, 2.46356744e-02f, -4.16697562e-02f, 5.49777895e-02f, 1.77148320e-02f, 1.03092110e-02f, -7.11435545e-03f, -3.20101492e-02f, 1.01928227e-01f, 3.16418409e-02f,
  -5.62569126e-02f, -4.16376740e-01f, 2.64814962e-02f, -6.52329773e-02f, 3.29920575e-02f, -4.65691416e-03f, 7.27949440e-02f, -3.88398916e-02f, -1.81128740e-01f, -1.54353589e-01f,
  9.66655463e-02f, -1.58174843e-01f, 6.92097992e-02f, -1.18698657e-01f, 4.20626611e-01f, -1.57793015e-02f, 4.12438437e-02f, -1.52468070e-01f, -5.29268570e-02f, -1.34352401e-01f,
  3.23008969e-02f, -1.25203341e-01f, 1.65804625e-01f, -4.08161320e-02f, -1.59853041e-01f, -1.40067786e-01f, 2.03615069e-01f, 2.58353166e-02f, -6.49888292e-02f, -1.57764014e-02f,
  3.27520482e-02f, -1.78977638e-01f, -5.77590279e-02f, 9.29354783e-03f, 2.23939493e-02f, 7.67917186e-03f, -1.03005748e-02f, 4.92699221e-02f, 9.27002952e-02f, 2.02954113e-02f,
  -1.25276363e-02f, -3.08453031e-02f, -5.74087761e-02f, -2.26251222e-02f, -3.78830768e-02f, -8.45933147e-03f, -5.31812059e-03f, 4.62091379e-02f, -9.19467583e-02f, -3.02339531e-02f,
  -6.42163167e-03f, 3.66679579e-03f, 3.39064747e-02f, -3.60257141e-02f, 6.50038794e-02f, -2.45670546e-02f, 4.18504477e-02f, 4.25739493e-03f, -7.62381256e-02f, -5.51099740e-02f,
  -7.39254653e-02f, 3.28494348e-02f, -1.12800198e-02f, 1.78076681e-02f, -4.16737609e-02f, 4.57412787e-02f, 6.36293292e-02f, -4.60944884e-03f, 1.57600883e-02f, 2.30287965e-02f,
  2.62446385e-02f, -1.62512101e-02f, 3.55855422e-03f, 1.11179315e-02f, 1.00514609e-02f, -4.75778282e-02f, 2.89877076e-02f, -8.82121734e-03f, -5.71847744e-02f, 3.70623432e-02f,
  2.47721784e-02f, -1.23640103e-02f, -3.76551338e-02f, 1.62010584e-02f, 1.03435842e-02f, 5.31814061e-02f, 2.42229588e-02f, 2.37697251e-02f, 3.53492945e-02f, 6.72186986e-02f,
  -4.81812842e-02f, -4.98724617e-02f, -9.14675090e-03f, -3.61737795e-02f, -1.62195750e-02f, 3.85639146e-02f, 3.05092838e-02f, -9.18582082e-02f, 2.36972095e-03f, 1.48941530e-02f,
  2.46336088e-02f, 4.53083776e-02f, -1.51525280e-02f, 2.38784356e-03f, 2.52389852e-02f, 1.43196934e-03f, 2.05135060e-04f, -1.85035747e-02f, 5.16517125e-02f, 1.80827603e-02f,
  3.70682683e-03f, -9.29727964e-03f, -3.16468030e-02f, 3.51745565e-03f, -7.14844139e-03f, 4.72219810e-02f, -6.83499128e-02f, -5.09064421e-02f, 3.25527638e-02f, 4.49189246e-02f,
  -7.86976442e-02f, -7.71981999e-02f, 6.55137300e-02f, 1.35617673e-01f, -6.70542940e-02f, 1.84441626e-01f, 1.68498695e-01f, -7.77406171e-02f, 1.47514924e-01f, -1.12627305e-01f,
  -8.47011879e-02f, -1.92286104e-01f, 9.84061882e-03f, -7.34451935e-02f, 2.80597776e-01f, 2.40750700e-01f, 1.46455064e-01f, -8.06374662e-03f, 1.34309717e-02f, -1.07548036e-01f,
  3.93473953e-02f, -4.81912168e-04f, 9.72281322e-02f, -1.20052211e-01f, -1.05818182e-01f, -5.30078784e-02f, -3.93314054e-03f, -3.44136283e-02f, -7.00660497e-02f, -8.15177560e-02f,
  -4.12305072e-03f, -1.64036855e-01f, -6.44645467e-02f, -9.99730267e-03f, -5.73401852e-03f, -4.55412678e-02f, 3.63488942e-02f, 1.18274624e-02f, -4.22574729e-02f, -1.32132089e-02f,
  -6.13880455e-02f, -3.81349102e-02f, 6.38711303e-02f, 1.54980132e-02f, 3.36233824e-02f, -4.12860066e-02f, -3.21221091e-02f, -2.11309064e-02f, -6.66683689e-02f, 1.79434172e-03f,
  2.80309860e-02f, -3.24322283e-02f, 6.30814508e-02f, 1.43672870e-02f, 6.84493259e-02f, -4.03573923e-02f, 5.51788956e-02f, -4.00988832e-02f, -3.39791961e-02f, 3.95130329e-02f,
  2.80329268e-02f, 5.49371988e-02f, 4.47967323e-03f, 2.64172489e-03f, -8.77412595e-03f, -4.77436632e-02f, -3.97478268e-02f, -4.05279957e-02f, -9.96663980e-03f, -2.76763085e-02f,
  -2.09314283e-02f, -9.38081648e-03f, -2.58303760e-03f, 8.51727203e-02f, -3.30720134e-02f, 1.91147067e-02f, 9.76681989e-03f, -5.70590459e-02f, 1.58367138e-02f, 4.62630624e-03f,
  2.78876126e-02f, 5.47284000e-02f, 4.76053990e-02f, 4.22394089e-02f, -3.55348899e-03f, -1.54305054e-02f, -2.80455314e-02f, 3.34057063e-02f, 4.70207781e-02f, 2.40270104e-02f,
  -9.23876911e-02f, -5.74825052e-03f, -9.63753555e-03f, -2.37433650e-02f, 2.51255208e-03f, 2.93535404e-02f, 3.36821340e-02f, -7.94774108e-03f, 6.17491044e-02f, 2.18882468e-02f,
  6.05973192e-02f, -5.47343912e-03f, 2.03238074e-02f, -3.49667184e-02f, 3.82705592e-02f, 2.27192435e-02f, 9.88520309e-03f, -3.44730378e-03f, 1.56663004e-02f, -9.75804329e-02f,
  -6.19437918e-02f, -1.51395947e-02f, 1.18813077e-02f, -2.91236788e-02f, 7.87316449e-03f, 3.06990370e-02f, 4.91836220e-02f, -4.42849025e-02f, -9.60629210e-02f, -2.71362029e-02f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  2.20097333e-01f, -3.21107566e-01f, -1.85919479e-01f, -2.95969427e-01f, -4.13111001e-02f, -2.59832412e-01f, -3.45118701e-01f, -1.33948237e-01f, -1.43559769e-01f, -3.68127301e-02f,
  -1.43242031e-01f, 4.11551073e-02f, 4.66296561e-02f, -3.41923147e-01f, -1.74985193e-02f, 4.56317216e-02f, -2.50174612e-01f, -3.05060297e-02f, 8.79877433e-02f, -1.70063972e-01f,
  -2.77054142e-02f, -3.01094383e-01f, -2.34977692e-01f, -5.94990179e-02f, -2.41881192e-01f, -5.65099455e-02f, 1.33237451e-01f, -6.83645755e-02f, -7.93703198e-02f, -3.53715103e-03f,
  5.04392013e-02f, 6.30269125e-02f, -2.47023702e-02f, 5.58092631e-02f, 3.23785134e-02f, 8.57197568e-02f, 1.76449418e-02f, 8.30392446e-03f, 5.31886630e-02f, 6.59485906e-03f,
  -1.76563766e-02f, 7.33922943e-02f, 2.95723379e-02f, -1.93586089e-02f, -1.01773940e-01f, -6.36410490e-02f, -5.92815727e-02f, -7.13720322e-02f, -7.53967240e-02f, 4.28136177e-02f,
  -1.64407194e-01f, -1.00262076e-01f, -1.00950189e-01f, 2.47020721e-02f, -1.40202965e-03f, -9.22165141e-02f, -3.52880061e-02f, -1.36025632e-02f, -8.14012736e-02f, -4.74465303e-02f,
  7.18999505e-02f, 3.99850775e-03f, 2.68357079e-02f, -3.23926006e-03f, -6.16615377e-02f, 6.50624037e-02f, -4.05747592e-02f, 2.46321354e-02f, -5.88829890e-02f, -1.96080394e-02f,
  4.37017418e-02f, -9.49186757e-02f, 6.31144037e-03f, 2.25584814e-03f, -8.43976066e-02f, 4.87322127e-03f, -3.84817235e-02f, -3.22172008e-02f, -3.58989090e-03f, -4.18868382e-03f,
  -5.62270114e-04f, 2.13977881e-02f, -3.12850773e-02f, 2.84522939e-02f, -1.02477334e-01f, 8.01786256e-04f, 6.95645288e-02f, -6.41445965e-02f, 5.71445338e-02f, -3.40050533e-02f,
  -1.50595918e-01f, 6.84409887e-02f, 9.73477867e-03f, -2.72706132e-02f, 2.12682132e-02f, 1.19095147e-02f, -3.59043293e-02f, -3.18865590e-02f, -3.55543830e-02f, -3.57479006e-02f,
  8.83902684e-02f, -2.80280542e-02f, 3.18823270e-02f, 2.54326779e-02f, -7.80693814e-02f, -1.31299198e-01f, 5.55509664e-02f, -1.55820092e-02f, -5.41195720e-02f, -5.59914112e-02f,
  1.32214953e-03f, -3.55757512e-02f, 1.65341571e-02f, 8.94144550e-03f, 6.49304269e-03f, 9.67486179e-04f, 5.92018291e-02f, 5.10561876e-02f, 5.80749176e-02f, -5.13152257e-02f,
  -3.21868777e-01f, 3.17866392e-02f, 1.41596720e-01f, -4.00761589e-02f, -7.39928707e-02f, 6.05449900e-02f, -2.88976356e-02f, -4.77743819e-02f, -2.47189939e-01f, -1.64706726e-02f,
  3.23085189e-02f, -1.63979799e-01f, 1.23776637e-01f, 6.75084740e-02f, 5.61053492e-02f, 1.62027970e-01f, 6.96327239e-02f, 7.39198029e-02f, 1.52311986e-02f, -5.76857291e-02f,
  8.66544992e-02f, 7.98078999e-02f, 3.45844179e-01f, 1.66407168e-01f, 5.67408688e-02f, 9.18183550e-02f, 9.36111882e-02f, 1.28288433e-01f, 1.08501703e-01f, 1.44195467e-01f,
  -1.01273306e-01f, -1.85705528e-01f, -1.44211546e-01f, -1.85197666e-01f, -1.01724647e-01f, -3.74719240e-02f, -6.83489367e-02f, 4.25892416e-04f, -2.57158764e-02f, -6.75629079e-02f,
  -1.31836563e-01f, -1.70251948e-03f, -5.67805171e-02f, -2.57492196e-02f, -1.20297842e-01f, 3.11841047e-03f, 9.73943970e-04f, -4.42956239e-02f, 2.11514607e-02f, -2.42797192e-02f,
  4.48337719e-02f, -3.18573937e-02f, 1.50743965e-02f, 3.33093554e-02f, 3.62182073e-02f, 1.37440497e-02f, -7.30490610e-02f, 3.10990307e-02f, -7.41723925e-02f, -1.35177895e-02f,
  -3.01747900e-02f, 5.26898727e-02f, -4.13509570e-02f, -2.29843762e-02f, -8.51340741e-02f, 7.73890018e-02f, -5.27302958e-02f, -6.37753541e-03f, -4.20044735e-02f, 9.46542248e-03f,
  2.91432068e-02f, 4.70446311e-02f, -7.22536221e-02f, -3.63091901e-02f, -2.23641861e-02f, -8.40368718e-02f, 2.87766941e-02f, -5.92611469e-02f, 5.01065217e-02f, 5.29628694e-02f,
  -4.31718715e-02f, -1.52637111e-02f, -5.23957573e-02f, -7.08245486e-02f, 5.69395795e-02f, -5.12643456e-02f, 3.92484702e-02f, -3.18974555e-02f, 2.80964449e-02f, 8.05889070e-02f,
  -8.78230184e-02f, -6.01350749e-03f, -1.09380437e-02f, -1.10133238e-01f, 5.68697192e-02f, -3.82746570e-02f, -9.79021005e-03f, -3.70446071e-02f, -7.38481581e-02f, -6.65881187e-02f,
  -1.01009659e-01f, 7.40270466e-02f, -1.24285631e-01f, 5.11276983e-02f, -2.05678819e-03f, 4.60861698e-02f, -3.56811397e-02f, -4.62447368e-02f, -1.12243198e-01f, 3.12204883e-02f,
  -5.84799377e-03f, -3.16919237e-02f, 2.93569919e-02f, 6.99627548e-02f, 6.12728484e-02f, -7.48831080e-03f, 3.22250053e-02f, -7.39047006e-02f, 7.69772828e-02f, -8.26926902e-03f,
  2.08634913e-01f, -3.68741482e-01f, 4.72385623e-02f, 7.67288590e-03f, 1.50531784e-01f, 1.71005040e-01f, 4.10639673e-01f, -2.83909738e-01f, -1.98432282e-01f, -2.65615255e-01f,
  -1.87754296e-02f, 4.09694165e-02f, 2.22413063e-01f, -5.70415743e-02f, 4.09981728e-01f, 9.98973846e-02f, 8.23640823e-02f, 9.98201296e-02f, -1.26163155e-01f, -7.28162080e-02f,
  -1.01614311e-01f, -9.82806906e-02f, -7.60980025e-02f, -2.45047286e-01f, 1.01716220e-02f, -2.61433393e-01f, -3.59878619e-03f, 6.69657588e-02f, -1.35801598e-01f, 1.32126182e-01f,
  -6.95556402e-02f, -1.28718212e-01f, -2.10875478e-02f, -6.18912168e-02f, -6.56056171e-03f, 7.29988376e-03f, 1.03170373e-01f, 1.47499070e-01f, -4.68464382e-03f, -8.12425688e-02f,
  6.03130460e-02f, 5.44331148e-02f, -7.84372464e-02f, 6.89771697e-02f, -1.03821039e-01f, -6.16615936e-02f, -3.41857560e-02f, -5.47671765e-02f, 2.34032441e-02f, -4.90432978e-02f,
  -6.31503388e-02f, -2.22732332e-02f, 1.15378946e-03f, 1.23614930e-02f, 2.70011947e-02f, 5.35964295e-02f, 3.22408080e-02f, 1.33492410e-01f, -2.21737213e-02f, -8.79806578e-02f,
  3.24431360e-02f, 3.80568951e-02f, 8.81220214e-03f, -7.15580285e-02f, 2.31940746e-02f, -6.31446764e-02f, 1.68885887e-02f, -3.16240564e-02f, 5.89578636e-02f, 5.58275320e-02f,
  -4.30299975e-02f, 5.15916850e-03f, 1.40085339e-03f, -2.45677680e-02f, 1.46142137e-03f, -1.23523269e-02f, -1.85922720e-02f, -1.17857810e-02f, -6.87875822e-02f, -8.53598770e-03f,
  7.78347626e-02f, 9.40562319e-03f, -6.71952218e-02f, 1.31501965e-02f, 3.61039937e-02f, 5.91319166e-02f, -8.98026302e-02f, -1.06941967e-03f, 5.13586849e-02f, 1.75274853e-02f,
  -9.98989120e-02f, -1.57020852e-01f, -2.96907662e-03f, 2.94195954e-02f, -5.50435223e-02f, -3.85672078e-02f, -3.89093272e-02f, -6.01605251e-02f, -3.79510522e-02f, -1.29684284e-02f,
  -6.60981536e-02f, -5.47706895e-02f, 1.44281529e-03f, 5.05969524e-02f, 2.06808913e-02f, -1.18894234e-01f, -1.62367113e-02f, -7.48670660e-04f, -4.74910112e-03f, -1.14789672e-01f,
  -2.81517860e-02f, 3.01503912e-02f, 4.92914096e-02f, -3.34248729e-02f, -5.26737869e-02f, 4.80523258e-02f, 4.80550826e-02f, -5.05029634e-02f, 4.51129302e-02f, -5.58866048e-03f,
  -3.31062406e-01f, -3.04291695e-01f, 2.67133355e-01f, -3.08386832e-01f, 1.67419866e-01f, 3.43308657e-01f, 1.57446474e-01f, -3.36499810e-02f, -3.70067954e-01f, -2.10244536e-01f,
  -8.29465017e-02f, -7.97190666e-02f, 1.17188737e-01f, -1.32998496e-01f, 1.89976051e-01f, 3.36723439e-02f, -9.84252393e-02f, -1.30792707e-01f, -9.62103456e-02f, -1.09914146e-01f,
  1.25709679e-02f, -9.77527872e-02f, 2.58145541e-01f, -7.36293420e-02f, -3.83056924e-02f, -1.99350372e-01f, -1.60579216e-02f, 1.79500267e-01f, 1.99014340e-02f, 1.59675121e-01f,
  -6.05813712e-02f, -1.73137173e-01f, -4.42896690e-03f, -2.85709798e-02f, 1.24753499e-02f, 4.24959436e-02f, 7.27468133e-02f, 1.52589351e-01f, -2.37412043e-02f, 3.51586267e-02f,
  -3.38465050e-02f, -2.33513061e-02f, -8.88043419e-02f, -7.00627491e-02f, -2.94576120e-02f, -1.33035053e-02f, 3.09505663e-03f, 6.57581612e-02f, 3.05943284e-02f, 1.35098875e-01f,
  2.66967248e-02f, 1.76407974e-02f, -3.24635059e-02f, 2.77170469e-03f, -3.00575774e-02f, -6.35841638e-02f, 5.82115538e-02f, 2.43356787e-02f, -1.15456330e-02f, -9.88567062e-03f,
  1.04145311e-01f, 5.52820824e-02f, 1.30837876e-02f, 1.45869730e-02f, 7.90067613e-02f, -1.96187496e-02f, -5.90490773e-02f, 2.65351981e-02f, -2.26770025e-02f, -5.98931052e-02f,
  3.80017944e-02f, 5.49092470e-03f, 6.78489916e-03f, -1.55554549e-03f, 3.36571393e-04f, 4.48842300e-04f, 1.39442477e-02f, 4.78766188e-02f, -2.07363022e-03f, -2.20070258e-02f,
  5.08421324e-02f, -9.85517539e-03f, 1.13436982e-01f, 6.74176440e-02f, -2.85299458e-02f, 7.56240487e-02f, -5.71601978e-03f, -6.03203475e-02f, -8.36781189e-02f, 7.05981106e-02f,
  -9.65538323e-02f, -1.99916631e-01f, -7.49759525e-02f, 4.28102054e-02f, -3.71955708e-02f, -4.48636860e-02f, 9.21064336e-03f, -6.20078482e-02f, -8.32383707e-02f, -4.60914522e-02f,
  4.30547073e-02f, -8.78047943e-03f, -1.51275545e-02f, -3.76169942e-02f, 4.46777344e-02f, -6.22451901e-02f, 3.47325057e-02f, -7.88658485e-02f, -4.48390394e-02f, -8.48053547e-04f,
  -6.43083081e-02f, -1.32772131e-02f, -3.81221622e-02f, -9.52519029e-02f, 5.91581967e-03f, 3.78850438e-02f, -2.00476218e-02f, 5.73551953e-02f, -1.53523041e-02f, 3.29390308e-03f,
  1.55559286e-01f, 1.15706194e-02f, 8.61501098e-02f, 2.62267619e-01f, 1.21315137e-01f, 8.68605748e-02f, 3.24204504e-01f, 2.67460078e-01f, 5.02897799e-01f, -2.62073632e-02f,
  -6.25421256e-02f, -5.90774603e-02f, 3.58385523e-03f, 1.80698615e-02f, -1.44089796e-02f, 6.55285493e-02f, 1.21048488e-01f, 9.98307392e-02f, 3.26760471e-01f, 1.06667131e-01f,
  2.28376552e-01f, 1.32122608e-02f, -1.46851182e-01f, -2.31374219e-01f, -1.42289713e-01f, -8.83701518e-02f, -2.55825251e-01f, -1.25584379e-02f, -2.67304987e-01f, -1.16491336e-02f,
  1.01111993e-01f, 2.20350131e-01f, -8.31823647e-02f, -4.51960117e-02f, 1.40392054e-02f, -2.65708882e-02f, -8.51515606e-02f, -1.89864542e-02f, 1.37456268e-01f, 1.39976405e-02f,
  -3.21214460e-03f, -1.06732808e-01f, 7.24388734e-02f, -5.14043532e-02f, 5.65785617e-02f, 5.48978299e-02f, -9.48851090e-03f, 2.10076030e-02f, -6.69328347e-02f, -6.28002360e-02f,
  -5.30109070e-02f, -4.01688404e-02f, 1.09904334e-01f, -4.00351584e-02f, 4.87648584e-02f, 2.98981345e-03f, 5.50988084e-03f, -4.58706431e-02f, -6.03854805e-02f, 3.63992341e-02f,
  -2.48871688e-02f, 9.67047364e-02f, -4.62090001e-02f, -6.04963824e-02f, -5.07916994e-02f, -2.57911459e-02f, -1.16696004e-02f, -5.01605906e-02f, 7.98148736e-02f, -1.22949637e-01f,
  7.24609047e-02f, -4.50537726e-02f, 1.28278378e-02f, 4.15863581e-02f, 7.79194832e-02f, -2.22161859e-02f, 1.11660978e-03f, 1.25941914e-02f, 2.01674495e-02f, -1.87518336e-02f,
  -2.08121538e-02f, -1.72284003e-02f, -6.84034228e-02f, -4.69279401e-02f, -5.03731109e-02f, 4.56602052e-02f, 2.60473806e-02f, -2.09256914e-02f, -5.11488225e-03f, 2.70853247e-02f,
  6.84105679e-02f, 2.38406867e-01f, 5.13951145e-02f, 1.32308016e-03f, 5.40398993e-03f, -3.63849699e-02f, 1.11026630e-01f, -3.84618528e-04f, 4.80827987e-02f, 7.41526037e-02f,
  6.64195716e-02f, 7.11522102e-02f, -7.23591596e-02f, -1.32570034e-02f, -1.27594210e-02f, -1.71304382e-02f, 7.87388012e-02f, 7.74447806e-03f, 6.38279319e-03f, -7.26708025e-03f,
  -4.18136083e-02f, 3.81724872e-02f, -6.74429685e-02f, -1.58551950e-02f, 6.69097528e-02f, 1.20144654e-02f, 4.74529080e-02f, 5.53635806e-02f, 1.17846243e-02f, 2.67843157e-02f,
  5.21056391e-02f, -1.58709422e-01f, -1.91631526e-01f, -1.86645508e-01f, 3.68816219e-02f, -4.97299694e-02f, -7.26629347e-02f, -7.19230948e-03f, -1.08368792e-01f, 8.14662650e-02f,
  1.70957133e-01f, -4.78351442e-03f, 2.65679341e-02f, -1.28382459e-01f, -1.66182324e-01f, -1.04906023e-01f, -2.98220068e-02f, -6.43059090e-02f, -2.29266230e-02f, 1.34304896e-01f,
  5.13603128e-02f, -4.40897606e-03f, 3.16707417e-02f, 3.57535668e-02f, -2.19491497e-02f, 1.25691921e-01f, 1.45687684e-01f, 1.96790487e-01f, 1.84917644e-01f, 2.67532822e-02f,
  -9.64938226e-05f, -6.56207427e-02f, -1.08424574e-01f, -4.60475981e-02f, -4.40934300e-02f, 1.25025669e-02f, -1.40928859e-02f, -7.03719556e-02f, -4.16318253e-02f, 3.48301418e-02f,
  1.84972100e-02f, -5.81331030e-02f, 3.43163945e-02f, 7.09707886e-02f, 2.39188783e-02f, 4.50968556e-02f, -3.73965092e-02f, -5.51496670e-02f, -7.52803981e-02f, -3.63558941e-02f,
  -9.98097211e-02f, -1.07310377e-01f, 4.50242236e-02f, -9.65473354e-02f, -1.53321205e-02f, 6.94728941e-02f, 1.25188027e-02f, 1.87292006e-02f, 3.64532731e-02f, -2.54574455e-02f,
  2.32020253e-03f, -4.55071703e-02f, -5.93364984e-02f, -3.51462364e-02f, -5.74555174e-02f, 4.46493132e-03f, 8.62325430e-02f, 4.09870073e-02f, -5.51630668e-02f, 4.70056050e-02f,
  1.32514257e-02f, -4.89091165e-02f, -2.24408396e-02f, 1.10780476e-02f, 6.12937696e-02f, -8.81991908e-02f, -1.08290166e-02f, 7.52834007e-02f, 5.24388114e-03f, -9.34901014e-02f,
  7.45357499e-02f, -5.98306349e-03f, 5.12245819e-02f, 8.57074782e-02f, -7.84177426e-03f, 1.72998328e-02f, -4.33553644e-02f, 3.41407508e-02f, 5.28916791e-02f, 9.27169695e-02f,
  -4.09985818e-02f, 2.75319256e-02f, 4.40442413e-02f, 5.77947646e-02f, 7.25921616e-02f, -4.44925725e-02f, -7.83389285e-02f, 7.04021454e-02f, 7.10339770e-02f, 5.00689410e-02f,
  5.53080589e-02f, 9.64453891e-02f, -2.72526685e-02f, 1.00707561e-02f, 5.34382761e-02f, 5.87417861e-04f, -4.12418731e-02f, -4.92232479e-03f, -1.22742811e-02f, 3.32625099e-02f,
  6.29787287e-03f, 1.83190499e-02f, -9.42289233e-02f, 8.03128257e-02f, -7.17151118e-03f, 2.60580960e-03f, 2.65797954e-02f, -4.35713818e-03f, 3.57620269e-02f, -5.78909218e-02f,
  -3.69377941e-01f, -5.85953966e-02f, -3.36814851e-01f, -3.42862755e-01f, 7.95478150e-02f, -2.81181544e-01f, -3.21311474e-01f, -3.80928186e-03f, -4.48429286e-02f, 8.42376351e-02f,
  3.57809588e-02f, -1.37564942e-01f, 2.41321847e-01f, -3.20587188e-01f, -3.31037015e-01f, -6.45086020e-02f, -4.48956162e-01f, -2.49164432e-01f, -4.41490598e-02f, -1.63484290e-01f,
  -1.93914250e-01f, -1.24383569e-01f, -2.55955398e-01f, 9.96661335e-02f, -1.77231565e-01f, -3.44796963e-02f, 1.85005546e-01f, 1.60577059e-01f, -1.53857887e-01f, -2.74268091e-02f,
  -1.81537956e-01f, 1.16762847e-01f, -9.08099264e-02f, 6.91318586e-02f, -5.39657027e-02f, -1.19583018e-01f, -8.26821104e-02f, 1.21705476e-02f, -2.27174796e-02f, -6.98908493e-02f,
  -6.32117242e-02f, 3.09193153e-02f, -3.80828790e-02f, 9.94985104e-02f, -3.29954666e-03f, 4.50964719e-02f, -1.70964189e-02f, -7.52082542e-02f, -4.50477423e-03f, -4.05151136e-02f,
  -9.29879919e-02f, -8.78583118e-02f, -8.36100727e-02f, 6.76014693e-03f, -6.98985606e-02f, -4.43095528e-02f, -8.44801366e-02f, 6.46860758e-03f, -5.52472658e-02f, 5.31444000e-03f,
  -7.89056905e-03f, 1.71089172e-02f, -2.59480141e-02f, 5.79815879e-02f, -1.81638878e-02f, -3.68669890e-02f, -1.90400090e-02f, 6.20840229e-02f, -1.42357070e-02f, -2.02526003e-02f,
  2.13220567e-02f, 2.94523016e-02f, 3.07911541e-02f, -1.29164398e-01f, -9.99816135e-02f, -2.17451937e-02f, -4.59042825e-02f, 2.30258536e-02f, -1.10454321e-01f, -4.73830737e-02f,
  6.83303252e-02f, -4.17194981e-03f, 5.05103096e-02f, -2.29610242e-02f, 3.43497507e-02f, 8.98041278e-02f, 1.20392605e-03f, -1.25400815e-02f, -2.46657357e-02f, -1.05391601e-02f,
  -8.35409239e-02f, -4.89571355e-02f, 1.37880035e-02f, 3.12390029e-02f, -5.18263690e-02f, 1.21425278e-02f, -6.39924332e-02f, -7.41215870e-02f, -5.95036484e-02f, -2.51061227e-02f,
  -3.53354961e-02f, 2.59141400e-02f, -3.42965918e-03f, -1.19112944e-02f, 2.02927552e-02f, -1.66427363e-02f, -4.18310948e-02f, -2.90331542e-02f, -6.04972430e-02f, 2.83698998e-02f,
  -3.78171690e-02f, 6.72008768e-02f, 7.73117393e-02f, -7.97593445e-02f, -4.41671312e-02f, 3.56628895e-02f, 4.36514653e-02f, -7.09007457e-02f, -8.17204714e-02f, 1.46116121e-02f,
  -5.79503877e-03f, 4.34674770e-02f, 1.55516103e-01f, 2.34238371e-01f, -5.44739552e-02f, -3.24982256e-01f, -1.23252578e-01f, 6.38872460e-02f, -1.54410198e-01f, -9.49494466e-02f,
  1.66165978e-01f, 1.02861263e-01f, -1.97705701e-02f, 2.51786768e-01f, 2.14843422e-01f, 5.31346537e-03f, 2.15657324e-01f, 2.93530785e-02f, -7.16101006e-03f, 1.47007063e-01f,
  1.93107590e-01f, 2.45591581e-01f, 2.99218595e-01f, 1.62759215e-01f, 1.61664546e-01f, 2.00539157e-01f, 3.11455518e-01f, 1.02787338e-01f, 2.73201585e-01f, 4.57497127e-02f,
  -5.36723621e-03f, 1.07486874e-01f, 2.69514658e-02f, 4.24612910e-02f, 1.10397367e-02f, -4.39318940e-02f, -4.59041679e-03f, 3.50636579e-02f, -1.99263822e-02f, -3.71332914e-02f,
  -1.66423582e-02f, 2.04071291e-02f, 1.89131568e-03f, 2.80631967e-02f, -4.83838953e-02f, 1.75026953e-02f, -1.66769139e-02f, 4.86219786e-02f, -3.94765139e-02f, -2.71787569e-02f,
  -3.87317352e-02f, -3.54291089e-02f, -1.02127101e-02f, -1.53451078e-02f, -8.71355087e-03f, -7.80809149e-02f, -7.82218203e-02f, 6.77912310e-02f, -4.12764885e-02f, -1.32788932e-02f,
  2.16960888e-02f, -9.03878175e-03f, -4.40993868e-02f, 2.75613684e-02f, 1.83054786e-02f, 2.74170507e-02f, 6.63955286e-02f, 1.40265645e-02f, 7.35627068e-03f, -1.99910030e-02f,
  3.40918750e-02f, -1.67931449e-02f, -3.12616117e-02f, -6.23290241e-03f, 4.70471848e-03f, 6.72191894e-03f, -3.24519612e-02f, 5.05172126e-02f, 5.40025830e-02f, -3.97496596e-02f,
  2.88982894e-02f, 1.92749277e-02f, -4.18839380e-02f, 4.86735590e-02f, -1.16195595e-02f, -1.06554879e-02f, 2.21959557e-02f, -8.09375271e-02f, 5.79282269e-02f, -1.22954911e-02f,
  9.21662301e-02f, 2.64128834e-01f, 6.30101860e-02f, -1.39953550e-02f, 4.16659862e-02f, 5.23244217e-03f, 2.29807626e-02f, 1.29764974e-02f, 6.98939189e-02f, -2.09691338e-02f,
  2.82321144e-02f, -3.40654403e-02f, -6.31055678e-04f, 6.28413782e-02f, 5.00745438e-02f, -4.52908501e-02f, 7.50618502e-02f, -2.47856248e-02f, 6.99495673e-02f, 1.51656240e-01f,
  6.25913171e-03f, -9.83910784e-02f, -5.30639552e-02f, -6.27902225e-02f, 3.44877653e-02f, -4.87855375e-02f, -2.43864325e-03f, -6.01644590e-02f, 1.04155585e-01f, 4.02275063e-02f,
  1.32742301e-01f, -3.61972064e-01f, -5.74505150e-01f, -1.29124254e-01f, 2.99500883e-01f, 2.48182327e-01f, -6.49148300e-02f, -7.98301995e-02f, -4.01202023e-01f, 1.92042798e-01f,
  1.32661358e-01f, -2.17163458e-01f, -2.48015717e-01f, 1.02260569e-02f, 5.03801219e-02f, -3.26208681e-01f, 2.31099337e-01f, 2.09446445e-01f, -2.01180786e-01f, 8.06966349e-02f,
  -8.86544958e-02f, 2.87804186e-01f, -2.57744163e-01f, 2.02996448e-01f, 1.29114702e-01f, 7.23807549e-04f, 3.12611818e-01f, -7.17920512e-02f, 3.64751875e-01f, 1.20196640e-01f,
  -1.53460316e-02f, -1.06363155e-01f, -1.38881505e-01f, -4.79511097e-02f, 1.06817588e-01f, 1.88908756e-01f, 8.92501324e-02f, 4.61569242e-03f, -7.82077294e-03f, -9.71284285e-02f,
  -5.19849099e-02f, -1.18598454e-02f, 7.39307106e-02f, -5.37570715e-02f, 8.87990966e-02f, 2.05131359e-02f, -4.16194908e-02f, -7.89203495e-02f, -1.39866680e-01f, -1.01872228e-01f,
  -6.76797330e-02f, -4.40383218e-02f, 4.28344049e-02f, -1.80502655e-03f, -6.84892088e-02f, -7.31333047e-02f, 1.31219681e-02f, -8.72246027e-02f, 4.26971493e-03f, 2.88831256e-02f,
  1.06230959e-01f, 5.50486036e-02f, 4.95261932e-03f, -6.73012529e-03f, -6.12504221e-02f, -4.69625182e-02f, 3.19322608e-02f, 1.25691518e-02f, -9.34165344e-02f, -1.47385206e-02f,
  5.00702905e-03f, -1.05356425e-02f, 3.27266529e-02f, 7.28192329e-02f, 7.39308670e-02f, -5.74543290e-02f, 6.53504357e-02f, 6.48503099e-03f, -2.44047940e-02f, -2.06331387e-02f,
  -3.28723453e-02f, 1.38119617e-02f, 9.29849164e-04f, 1.45017607e-02f, -5.17397448e-02f, -1.00929916e-01f, 2.92682946e-02f, -7.26383999e-02f, -9.09272134e-02f, 4.96962592e-02f,
  1.21836692e-01f, 6.32246360e-02f, -7.55890757e-02f, 1.33730853e-02f, -7.17006251e-02f, 1.18532866e-01f, -1.22349635e-02f, -1.63621071e-03f, -5.35944477e-03f, 1.99701898e-02f,
  1.61833391e-01f, 1.47475190e-02f, 2.05293708e-02f, 1.74078308e-02f, 2.24258471e-03f, 4.59429342e-03f, 5.61785772e-02f, -1.71453822e-02f, 1.10551447e-01f, 5.38907535e-02f,
  6.45792037e-02f, 5.41341789e-02f, 5.74862286e-02f, 3.39927785e-02f, 1.25396460e-01f, 9.87793058e-02f, 3.92828062e-02f, 4.94846702e-02f, 1.01572476e-01f, -1.75268836e-02f,
  -1.82246249e-02f, 5.35758259e-03f, -9.88672227e-02f, 1.27077699e-01f, -1.35967612e-01f, -2.75114745e-01f, -1.37197375e-01f, -9.49404314e-02f, -1.68831348e-02f, 8.04592296e-02f,
  9.55227315e-02f, 1.08857863e-02f, 1.41464859e-01f, 9.69424769e-02f, 4.86976169e-02f, 2.38730712e-03f, 8.25181454e-02f, 1.69842429e-02f, -1.16881691e-02f, 1.36489272e-01f,
  2.47879401e-02f, 9.81874205e-03f, 6.53209984e-02f, -5.18391083e-04f, 1.01650991e-02f, -4.47928570e-02f, 2.28638545e-01f, -9.92095098e-02f, 6.06029183e-02f, 4.66509573e-02f,
  -1.27998531e-01f, 2.65520029e-02f, 5.16296830e-03f, -5.39068654e-02f, 8.31396431e-02f, -1.82748307e-02f, -5.97191006e-02f, 2.78308056e-02f, 4.41030413e-02f, 5.49410842e-03f,
  8.16971660e-02f, -8.10862258e-02f, -7.70615265e-02f, -9.29674581e-02f, 2.75021270e-02f, -4.21035625e-02f, -5.20764142e-02f, 6.64010793e-02f, 4.95973155e-02f, 7.99720641e-03f,
  5.17247654e-02f, -7.39168702e-03f, 4.64722328e-02f, 6.09062761e-02f, -2.94701606e-02f, 2.33273059e-02f, 9.02562141e-02f, 4.86229314e-03f, 5.84101230e-02f, 7.44500058e-03f,
  7.79452850e-04f, 8.52820650e-02f, 7.50696287e-02f, 5.10868393e-02f, 5.47306314e-02f, -7.47956038e-02f, -5.18270321e-02f, 1.66356508e-02f, -2.88310777e-02f, 1.22838514e-02f,
  -6.76525012e-02f, 3.25405188e-02f, 1.39469211e-03f, -6.25453815e-02f, -1.57437325e-02f, -6.68879822e-02f, 8.03864002e-02f, 4.52691875e-02f, -2.99632959e-02f, 7.96470344e-02f,
  -3.67716327e-02f, -4.43007331e-03f, 8.04645643e-02f, -7.56604970e-02f, -3.63404825e-02f, 5.82901621e-03f, 3.77569161e-02f, -1.60518195e-02f, -4.46303263e-02f, 5.18839434e-03f,
  -2.70687416e-02f, 1.18268907e-01f, -2.67156065e-02f, -1.79965852e-03f, -3.94813381e-02f, 1.00539811e-02f, 7.46079236e-02f, -3.00701112e-02f, -3.55329849e-02f, -2.22792942e-02f,
  -3.82901952e-02f, -2.04700567e-02f, 6.95649087e-02f, -3.58839110e-02f, -5.52674718e-02f, -6.09918013e-02f, 8.62098411e-02f, -6.88919274e-04f, 4.52181809e-02f, 7.90404007e-02f,
  -8.10238644e-02f, -5.22987321e-02f, 8.57254192e-02f, -7.05787390e-02f, 6.96125068e-03f, 6.37923181e-02f, 6.94517717e-02f, -5.93405403e-02f, -4.61580604e-02f, -3.48837189e-02f,
  -4.10637170e-01f, 3.97005528e-02f, -1.44641027e-01f, -2.24908322e-01f, 1.69042796e-01f, -5.03657274e-02f, -6.92873588e-03f, 1.25955939e-01f, -1.24701679e-01f, 1.12755105e-01f,
  1.49594620e-01f, -2.04448849e-01f, 1.12325877e-01f, -1.11060530e-01f, -2.89785147e-01f, -2.80365068e-02f, -5.95524348e-02f, -9.19549167e-02f, -1.19972909e-02f, 2.03948803e-02f,
  -1.20426118e-01f, -2.29614098e-02f, -1.93935111e-01f, 2.62496233e-01f, -1.23944581e-01f, 5.61387464e-02f, 2.77191009e-02f, 6.98274896e-02f, -4.37324233e-02f, -7.56799728e-02f,
  -1.38177839e-03f, 2.45932606e-04f, -3.74295637e-02f, 3.68531421e-02f, 9.18964371e-02f, 5.77523187e-02f, 1.27594639e-02f, -5.16156182e-02f, 1.76633820e-02f, 3.21503766e-02f,
  3.34452800e-02f, -1.85842738e-02f, -7.20552653e-02f, 2.07950473e-02f, -1.41831180e-02f, -2.32140087e-02f, -5.71758859e-02f, 2.19620541e-02f, 2.11531594e-02f, -4.58020903e-02f,
  -2.49773692e-02f, -3.00176051e-02f, -7.06822872e-02f, -7.81340301e-02f, -1.23781282e-02f, 4.88818921e-02f, -1.04018845e-01f, -3.39286476e-02f, -7.87444636e-02f, 2.25860700e-02f,
  -1.08939428e-02f, 7.02758357e-02f, -3.58070321e-02f, 5.85100353e-02f, 4.46907245e-02f, 6.56157956e-02f, -2.44829096e-02f, -1.89002212e-02f, -1.83200017e-02f, 2.64115948e-02f,
  -5.30119427e-02f, -2.52251569e-02f, 9.02950838e-02f, 3.07723181e-03f, 5.53146005e-02f, 4.01239730e-02f, -1.95754524e-02f, 6.50860220e-02f, 7.48911407e-03f, -3.32283042e-02f,
  3.78843807e-02f, -2.95722540e-02f, -1.32916868e-01f, 1.91114023e-02f, -5.81895635e-02f, -6.31114915e-02f, 8.09917301e-02f, 7.47603318e-03f, -5.30530550e-02f, -4.85186875e-02f,
  2.84797810e-02f, 7.49464259e-02f, 8.16160217e-02f, -4.70495559e-02f, -8.07198137e-02f, 2.31560115e-02f, 5.61837740e-02f, -3.55692543e-02f, 5.69296107e-02f, 2.72229705e-02f,
  2.22708173e-02f, -2.77183112e-03f, -6.75116554e-02f, 5.51795177e-02f, 5.61914742e-02f, -5.31253852e-02f, -2.36416943e-02f, 9.62865055e-02f, 2.07093190e-02f, -3.67692895e-02f,
  7.68576488e-02f, 1.44144734e-02f, -2.28532515e-02f, -6.35422841e-02f, -5.23375385e-02f, -1.32597173e-02f, 8.85825139e-03f, 2.73562949e-02f, 6.02312759e-03f, -4.42081727e-02f,
  1.10772341e-01f, 3.24898330e-03f, -3.14748809e-02f, 1.37232110e-01f, -3.33229974e-02f, -2.33973600e-02f, 1.14113495e-01f, -3.33992094e-02f, -1.57451913e-01f, -1.66850518e-02f,
  7.78113082e-02f, -6.17375039e-02f, -1.82347745e-02f, 8.23946521e-02f, 2.46498674e-01f, -3.81402820e-02f, 5.34508862e-02f, -5.29143922e-02f, -7.28828087e-02f, 2.06692651e-01f,
  1.65754080e-01f, 9.12438184e-02f, 4.27198261e-02f, 6.58554733e-02f, 1.35148391e-01f, 1.79905668e-02f, 2.17645392e-01f, 1.42821008e-02f, 9.40895081e-02f, 1.49221763e-01f,
  4.98211905e-02f, 5.19729331e-02f, -2.24405006e-02f, -1.07940026e-01f, 1.41703129e-01f, 8.00424144e-02f, 3.46384086e-02f, -7.86060169e-02f, -4.39877175e-02f, 3.77927162e-02f,
  8.84421915e-02f, 5.49966544e-02f, 3.67409140e-02f, 6.48643598e-02f, 2.59189233e-02f, -4.29815836e-02f, -1.04014821e-01f, -8.60917121e-02f, 1.52262542e-02f, -3.31250206e-02f,
  -9.10142064e-02f, -3.07475142e-02f, -1.62087027e-02f, -1.28739789e-01f, -7.46636316e-02f, -2.96269879e-02f, -1.07229084e-01f, 1.06908657e-01f, -5.19167073e-02f, -7.54698142e-02f,
  3.97090539e-02f, -9.81875882e-02f, -4.31623310e-02f, 2.44933716e-03f, -1.08809434e-02f, -2.33938899e-02f, -1.03367381e-02f, 3.63872163e-02f, -2.07947958e-02f, 4.74742837e-02f,
  -8.46971013e-03f, 1.08207434e-01f, -4.93100248e-02f, -5.63387796e-02f, 1.09420968e-02f, -6.38445020e-02f, 6.57309443e-02f, 2.56290603e-02f, -1.27911291e-04f, -9.09883454e-02f,
  -5.11547253e-02f, -4.47736727e-03f, -4.28151824e-02f, 3.10670938e-02f, -2.76490320e-02f, -4.06774618e-02f, 9.99045372e-02f, 1.24501489e-01f, -2.19487194e-02f, 3.84624340e-02f,
  1.09446831e-01f, 1.54846340e-01f, 2.05265135e-02f, -8.91614035e-02f, -4.76295464e-02f, -2.72220206e-02f, -5.09418845e-02f, 4.92444411e-02f, 5.19816279e-02f, 1.03987560e-01f,
  5.01020206e-03f, 3.05392276e-02f, -5.37954643e-02f, -5.20066842e-02f, 4.54646237e-02f, 1.18200786e-01f, -5.70433214e-02f, 3.71258793e-04f, 9.62135866e-02f, 1.07461728e-01f,
  2.39523537e-02f, 2.13138741e-02f, 6.96838126e-02f, -7.35728219e-02f, -1.36486664e-01f, 5.32407612e-02f, -3.66559178e-02f, 3.70858647e-02f, -1.61494017e-02f, 5.19133247e-02f,
  -2.01323345e-01f, 1.53259516e-01f, -9.32918862e-02f, 2.24949196e-01f, -1.33913204e-01f, -2.08541065e-01f, 1.52275991e-02f, -2.19733510e-02f, -1.75078574e-04f, 2.42157415e-01f,
  1.16038635e-01f, 1.61253944e-01f, 3.31839942e-03f, 2.69686341e-01f, 1.60541534e-01f, 1.39591098e-01f, 2.98863500e-01f, 8.70863199e-02f, 6.28138334e-02f, 8.16662833e-02f,
  3.17788795e-02f, 2.09113747e-01f, 2.96720058e-01f, -2.26066243e-02f, 1.37389481e-01f, -9.94342752e-03f, 2.75350630e-01f, -1.01781726e-01f, 1.78192437e-01f, 6.89219013e-02f,
  -6.35308027e-02f, -7.69378915e-02f, 1.46345776e-02f, -4.79723007e-04f, -5.98261431e-02f, -1.04333526e-02f, 3.54114454e-03f, -7.36483708e-02f, -5.65839447e-02f, -9.31295231e-02f,
  -2.42420305e-02f, -1.01721779e-01f, -3.31224129e-02f, -1.65942181e-02f, -8.16561058e-02f, -2.73897965e-02f, 2.32987870e-02f, 3.96215022e-02f, -9.71218273e-02f, 1.03554744e-02f,
  -1.32608600e-02f, 3.06372978e-02f, 1.60097685e-02f, 4.60300036e-03f, -3.04668806e-02f, 8.23265873e-03f, -6.55823648e-02f, -1.83960027e-03f, 5.82590923e-02f, 4.87791486e-02f,
  -9.04546753e-02f, 1.13549102e-02f, 8.18408132e-02f, 1.80086598e-03f, -2.95547908e-03f, -5.39317466e-02f, 6.58343136e-02f, -2.51722820e-02f, 2.16353312e-02f, 4.47946265e-02f,
  1.36071211e-02f, 2.88488027e-02f, -1.71116106e-02f, -5.40475957e-02f, -4.33446281e-02f, 3.17849480e-02f, -1.03125088e-02f, -1.20481988e-02f, 2.43330132e-02f, -2.08137855e-02f,
  -3.40405740e-02f, 2.03498751e-02f, 4.38017137e-02f, -6.88161999e-02f, -5.40934615e-02f, 1.21933952e-01f, 5.64359576e-02f, 2.62638666e-02f, 2.22297618e-03f, -7.41922902e-03f,
  -4.10090759e-02f, 1.64182857e-01f, -5.83841018e-02f, -1.26657560e-01f, -3.43201049e-02f, 5.85294105e-02f, 3.25788669e-02f, 9.21698753e-03f, 2.23455839e-02f, 7.28809983e-02f,
  1.67768430e-02f, -7.08361017e-03f, 3.12341042e-02f, 2.35452559e-02f, -8.47079232e-02f, 1.01703167e-01f, 1.17355296e-02f, -2.39338330e-03f, 9.57621858e-02f, 5.81416488e-03f,
  5.23231663e-02f, 3.38515379e-02f, 3.11431829e-02f, -5.38969152e-02f, -9.85687133e-03f, 2.67240591e-02f, 4.72642817e-02f, 7.71925412e-03f, 1.13562876e-02f, 3.66792902e-02f,
  1.20496780e-01f, -1.41216844e-01f, -1.88137606e-01f, -6.67520612e-02f, -1.84688404e-01f, -5.59177458e-01f, -5.46669722e-01f, -9.14963707e-02f, -3.58894691e-02f, -1.16750002e-01f,
  -1.83067963e-01f, -1.07361622e-01f, 2.72163987e-01f, -2.57527947e-01f, 2.19290584e-01f, 3.29606235e-01f, -3.16450804e-01f, -1.69812843e-01f, 6.47655204e-02f, -1.00698054e-01f,
  1.93722621e-01f, -1.74832806e-01f, 1.13630474e-01f, -1.53403759e-01f, -2.79555053e-01f, -3.51488702e-02f, 2.70014614e-01f, -6.04958944e-02f, -1.40843585e-01f, -1.09532200e-01f,
  -1.14409193e-01f, 4.91155460e-02f, -7.77834952e-02f, -9.77780521e-02f, -5.82078844e-02f, -4.45909761e-02f, -1.95149109e-02f, -2.64738277e-02f, -4.32426631e-02f, 3.16252559e-02f,
  -2.88540497e-02f, 9.94994398e-03f, -5.43585373e-03f, -3.83078456e-02f, -5.91314696e-02f, -1.59996059e-02f, -7.26317801e-03f, -6.04778016e-03f, -1.06187910e-02f, -2.68694572e-02f,
  9.15991422e-03f, 5.46558835e-02f, -2.91106701e-02f, 4.28323895e-02f, 4.67606187e-02f, -7.45862573e-02f, -4.64610606e-02f, 1.31977081e-01f, -5.60681242e-03f, 2.36708205e-03f,
  5.10160662e-02f, 8.70497823e-02f, -7.50082508e-02f, -1.09647937e-01f, 6.93132961e-03f, -3.14963236e-02f, 5.25036938e-02f, -2.75239423e-02f, 3.63374762e-02f, 7.96014071e-02f,
  -4.61987108e-02f, 7.87558779e-02f, -3.87289003e-02f, -4.84981807e-03f, -1.52915930e-02f, 4.14892333e-03f, 1.74641889e-02f, 1.67865809e-02f, -6.10278994e-02f, -7.87763018e-03f,
  3.01902723e-02f, -6.30969480e-02f, -1.57562979e-02f, 1.47867789e-02f, 5.45866974e-03f, 1.05234370e-01f, -1.64502338e-02f, 3.82022746e-02f, 1.47538267e-05f, 2.18260102e-02f,
  -1.17786594e-01f, 1.07630052e-01f, -8.98538455e-02f, -1.10644989e-01f, 2.58008502e-02f, -8.16890150e-02f, -2.74942461e-02f, 5.90025708e-02f, 4.51324992e-02f, 3.59473042e-02f,
  -2.85684709e-02f, 5.04668616e-03f, -4.87395823e-02f, 3.20592672e-02f, 1.08176433e-02f, -4.08807732e-02f, 1.77975539e-02f, 8.88293833e-02f, -5.68713062e-02f, -3.32821421e-02f,
  3.50403264e-02f, -3.77077051e-02f, 3.57439034e-02f, 3.59632960e-03f, 5.19216210e-02f, -5.28017692e-02f, -6.01473302e-02f, 1.79404970e-02f, 1.30065605e-01f, 6.75914017e-03f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  -6.65143579e-02f, 2.62406081e-01f, 3.11661512e-01f, 2.11351514e-01f, 1.83554515e-01f, 1.18992150e-01f, 1.96515307e-01f, -1.33970482e-02f, 3.15340906e-01f, 7.36624524e-02f,
  1.58523068e-01f, 1.69316515e-01f, 1.52673379e-01f, 8.36919546e-02f
};

// L1_fan_Wp (Shape: 9 x 32)
const int L1_fan_Wp_rows = 9;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  -1.33417889e-01f, -7.58184195e-02f, 2.76875407e-01f, 2.84723252e-01f, 5.99596985e-02f, -7.93904718e-03f, -8.28961879e-02f, -1.12186551e-01f, 7.61631429e-02f, -1.84562549e-01f,
  1.87760845e-01f, 1.43223092e-01f, 2.72436291e-01f, 1.87457487e-01f, -6.39671743e-01f, 1.75964572e-02f, -4.94343847e-01f, -1.77812904e-01f, 3.97725046e-01f, -2.70616889e-01f,
  -8.47963989e-02f, -3.92717332e-01f, 9.83001515e-02f, -4.46428545e-02f, 1.71338901e-01f, -1.06868692e-01f, 9.05489698e-02f, 1.06753193e-01f, 5.84067777e-02f, 2.69539729e-02f,
  7.63656804e-03f, 2.57805306e-02f, 1.94883108e-01f, 1.02299303e-01f, -2.39401963e-02f, 4.02196124e-02f, -7.56926984e-02f, -3.59477580e-01f, 1.93670362e-01f, 2.93482959e-01f,
  3.06338429e-01f, -3.87251318e-01f, 4.96738330e-02f, -4.23729062e-01f, -2.82671422e-01f, -2.09389135e-01f, -4.78222281e-01f, -2.83959448e-01f, -1.42907903e-01f, 2.78688371e-01f,
  -2.87333220e-01f, -1.01301014e-01f, 1.50850862e-01f, -1.65475056e-01f, 3.46405715e-01f, 4.73106727e-02f, -3.49931985e-01f, -4.84323911e-02f, -2.96024494e-02f, -8.53830129e-02f,
  -1.11553464e-02f, 1.64057743e-02f, 5.85489869e-02f, -1.88335389e-01f, 5.23018800e-02f, -1.05948463e-01f, -3.41894567e-01f, -2.61851512e-02f, -1.99176401e-01f, -2.52798170e-01f,
  -4.27229417e-04f, 2.09931478e-01f, 8.06297958e-02f, -3.03965688e-01f, -4.28276628e-01f, -3.08297873e-01f, 1.46695316e-01f, -1.33154169e-01f, 4.60183173e-01f, 5.80568790e-01f,
  5.20692617e-02f, -5.77450916e-02f, -8.36304128e-02f, 3.15607246e-03f, -5.44736683e-02f, 9.89170447e-02f, -2.07658350e-01f, 1.99925765e-01f, 9.67730358e-02f, 4.24587764e-02f,
  3.87636304e-01f, 4.43371311e-02f, 2.42396683e-01f, -3.58483233e-02f, -2.64731675e-01f, -2.56857634e-01f, 4.08970937e-02f, 6.90613762e-02f, 1.69022046e-02f, -2.83088118e-01f,
  -3.09456766e-01f, -1.68638036e-01f, -5.67787290e-02f, 1.07031658e-01f, 4.58585694e-02f, -4.42196667e-01f, 4.35636304e-02f, -2.99538344e-01f, -8.62668678e-02f, -1.94006801e-01f,
  1.79065228e-01f, 1.83043908e-02f, 4.14075375e-01f, 2.33875215e-01f, -1.05243430e-01f, -1.02632993e-03f, 3.06180716e-01f, -8.95010456e-02f, 2.19934225e-01f, 9.31667443e-03f,
  -2.88963705e-01f, 2.18765154e-01f, 2.37166151e-01f, 1.25842482e-01f, -1.98803589e-01f, 1.73982844e-01f, 9.65101123e-02f, -2.23351747e-01f, -1.05599940e-01f, 2.76870895e-02f,
  -8.17938894e-02f, -3.93240720e-01f, -3.91800761e-01f, -2.57146925e-01f, 1.39932662e-01f, 8.46288130e-02f, -9.65706408e-02f, -5.66673398e-01f, -3.25774103e-02f, 3.54992032e-01f,
  -4.85594310e-02f, 1.18469283e-01f, -5.08889675e-01f, 4.20999795e-01f, 7.57504553e-02f, 2.59634793e-01f, 2.17115983e-01f, 1.03819996e-01f, -1.31108031e-01f, 1.59173291e-02f,
  -2.00818196e-01f, -2.05258772e-01f, -8.64168927e-02f, 7.87855312e-02f, 1.41533986e-01f, -1.64813787e-01f, -9.63111743e-02f, -1.69589117e-01f, 3.14417094e-01f, -1.84113104e-02f,
  1.40892625e-01f, -9.57382917e-02f, -5.28888181e-02f, 2.86398470e-01f, 2.40336120e-01f, -2.63707731e-02f, 9.08879470e-03f, -1.66374240e-02f, -1.05002135e-01f, 3.62729371e-01f,
  3.70659411e-01f, 4.96727496e-01f, 4.17246014e-01f, 4.90588486e-01f, -3.62833977e-01f, 1.27898395e-01f, -2.04788536e-01f, 3.02712500e-01f, 1.88971415e-01f, 1.55034125e-01f,
  7.53156468e-02f, 2.84731597e-01f, 9.85245928e-02f, -9.16911475e-03f, 3.61864530e-02f, -1.13791279e-01f, -1.78148434e-01f, -2.11798608e-01f, 1.01359315e-01f, 8.05734545e-02f,
  1.15080737e-02f, 2.23358154e-01f, 2.63451666e-01f, -3.00490279e-02f, 7.07557127e-02f, 2.65305340e-01f, -2.00297877e-01f, -1.11997038e-01f, -7.67306015e-02f, 3.29062752e-02f,
  1.64835732e-02f, 2.35301569e-01f, 1.49123937e-01f, -1.81107461e-01f, -1.67248800e-01f, -4.64156419e-01f, -6.27210513e-02f, -4.53792185e-01f, -8.40417296e-02f, 8.14191476e-02f,
  -1.07444301e-01f, -2.00471848e-01f, 2.17350915e-01f, -1.50037304e-01f, 2.67335266e-01f, -1.99366920e-03f, -1.92913532e-01f, -2.56302238e-01f, -1.72797833e-02f, -1.44810602e-01f,
  4.44648415e-02f, -8.69477168e-02f, -8.87558833e-02f, -2.58076876e-01f, 5.31439781e-02f, -4.97810990e-02f, -1.84790984e-01f, -5.95731549e-02f, -1.25361457e-01f, -1.31484106e-01f,
  -2.05115110e-01f, -1.45420879e-01f, -3.59214321e-02f, -1.75091922e-01f, -1.86868712e-01f, -5.19710742e-02f, -1.22021638e-01f, 8.10943767e-02f, 3.62318188e-01f, 1.62322015e-01f,
  -2.65089095e-01f, -1.77132219e-01f, 3.22410375e-01f, -8.55976623e-03f, -3.84227425e-01f, -1.66996285e-01f, -1.00779273e-01f, 2.22556606e-01f, 3.51360649e-01f, -7.97881186e-02f,
  1.06244817e-01f, 1.62231833e-01f, 1.97783545e-01f, -1.76902220e-01f, -8.38298574e-02f, 1.82922035e-01f, -2.97422521e-03f, 9.91857843e-04f, -2.54694875e-02f, 1.85583025e-01f,
  1.79924801e-01f, 1.36619300e-01f, -1.60168372e-02f, -1.81666881e-01f, 6.59838542e-02f, 5.60890973e-01f, 2.90527582e-01f, 2.35084385e-01f, -1.62775338e-01f, -2.65795588e-01f,
  3.54847126e-02f, -6.62303567e-01f, -5.83126135e-02f, -1.47200003e-01f, -2.02919945e-01f, 1.75553411e-01f, 6.44020513e-02f, 1.87285185e-01f, 9.61376131e-02f, -1.54840797e-01f,
  -2.69869715e-01f, 2.11361870e-01f, -3.67157012e-01f, 9.10348818e-02f, -2.77895719e-01f, -1.58358905e-02f, -3.94510701e-02f, -1.64743006e-01f
};

// L1_fan_Wp_bar (Shape: 14 x 32)
const int L1_fan_Wp_bar_rows = 14;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  5.00489235e-01f, 7.38992915e-02f, 1.52346611e-01f, -1.16358720e-01f, 2.59338737e-01f, -3.26218307e-01f, 4.10827577e-01f, 2.93075234e-01f, 2.43923999e-02f, -2.07375567e-02f,
  1.31154740e-02f, 3.03863198e-01f, 5.20496726e-01f, 2.38106161e-01f, -1.75494820e-01f, 2.87548870e-01f, -3.34741771e-02f, 3.34327161e-01f, -1.16427444e-01f, 1.70431197e-01f,
  1.66084945e-01f, 4.89329584e-02f, 2.69986629e-01f, 9.05609578e-02f, 2.64143884e-01f, -1.34294182e-01f, 7.19104614e-03f, 1.56668410e-01f, 2.42058799e-01f, -1.06172286e-01f,
  -6.89259022e-02f, -1.67239308e-01f, -4.60934918e-03f, 4.24718410e-02f, -8.48691314e-02f, 6.34725243e-02f, 3.31134349e-01f, -6.21417463e-02f, 1.24243833e-01f, 2.77759641e-01f,
  3.05618852e-01f, -4.06530976e-01f, -5.18883169e-01f, -1.69047043e-01f, 4.57361974e-02f, -2.78375149e-01f, 6.05841167e-02f, 5.67818165e-01f, 2.73856707e-02f, -1.07519120e-01f,
  2.93407440e-01f, 3.64102796e-02f, -4.83274348e-02f, 3.74173410e-02f, -2.67841488e-01f, 1.64195225e-01f, -1.27664998e-01f, 7.51264244e-02f, 9.19562161e-01f, 7.13992715e-02f,
  1.81838557e-01f, 2.26335675e-01f, 9.15885030e-04f, -2.04240948e-01f, -9.56115201e-02f, 7.52109736e-02f, 4.14578207e-02f, 1.18607722e-01f, -4.43103798e-02f, 1.34591326e-01f,
  -5.23394011e-02f, 1.81456000e-01f, 2.14644328e-01f, -2.65862923e-02f, 1.62787229e-01f, 4.25258368e-01f, 1.28855184e-01f, 3.79813343e-01f, 9.45383906e-02f, 3.47012311e-01f,
  3.39951485e-01f, 8.88694450e-02f, 2.02440366e-01f, 4.57414001e-01f, 2.77780563e-01f, 4.84709531e-01f, -2.29467005e-01f, -8.26052506e-04f, 2.67036915e-01f, -3.12792771e-02f,
  -5.91779314e-03f, 6.54663295e-02f, 2.66492039e-01f, -1.14171974e-01f, 6.07307777e-02f, 2.13959396e-01f, 1.15225486e-01f, 5.93340285e-02f, -1.14327721e-01f, -8.50502104e-02f,
  1.28581449e-01f, -1.74918681e-01f, -6.05913736e-02f, -6.16086125e-02f, -1.16119958e-01f, 7.77721703e-02f, 8.95436201e-03f, 2.15835601e-01f, 1.47350416e-01f, -3.24131139e-02f,
  2.23090753e-01f, 1.95587307e-01f, -1.35734975e-01f, -9.45732296e-02f, -1.27167970e-01f, 1.21741034e-01f, -6.18160814e-02f, 5.44798858e-02f, 5.38310520e-02f, 2.28707045e-01f,
  3.25421929e-01f, -1.19666345e-01f, 1.39818490e-02f, -7.08179921e-02f, 1.81534722e-01f, -1.28575951e-01f, -1.59133095e-02f, 1.23610958e-01f, -1.04870014e-01f, 2.67407689e-02f,
  1.33092374e-01f, 9.16886926e-02f, 7.34152570e-02f, 1.84710383e-01f, -6.18294673e-03f, 2.35334158e-01f, 1.18128143e-01f, 1.07471399e-01f, 7.63887390e-02f, 3.17762762e-01f,
  1.79409251e-01f, 1.34308338e-01f, -2.42587239e-01f, -2.06683446e-02f, 1.71717629e-01f, 1.05426349e-01f, 4.22583848e-01f, -2.10106105e-01f, -1.48408815e-01f, 9.00708213e-02f,
  -3.62565331e-02f, -1.54638618e-01f, 3.72463495e-01f, -2.33702455e-03f, -2.06186727e-01f, 7.25245401e-02f, -1.20368535e-02f, -2.12525770e-01f, 1.26773790e-01f, 3.97053421e-01f,
  -1.01622604e-01f, -1.54577881e-01f, -1.05342656e-01f, -5.09222895e-02f, 2.58675730e-03f, -1.06919855e-02f, 1.12925135e-01f, 1.22872770e-01f, -7.84117430e-02f, -3.98979895e-02f,
  -4.10574526e-02f, -1.80535257e-01f, -1.47363499e-01f, 1.72883153e-01f, -1.42784327e-01f, 1.42335296e-01f, 1.95196345e-01f, -2.89085805e-02f, 2.03033805e-01f, -9.31983292e-02f,
  -1.20561466e-01f, -1.93875566e-01f, 6.54477403e-02f, -8.05043802e-02f, 1.41596273e-02f, 7.41486624e-02f, -6.18207827e-02f, 6.16325662e-02f, 7.68942758e-02f, 1.04149215e-01f,
  3.16901088e-01f, 4.67103124e-01f, 4.30303484e-01f, 3.13450396e-01f, -2.74666756e-01f, 6.64374605e-02f, 2.30155736e-01f, 4.80976002e-03f, 3.52402836e-01f, 5.74424937e-02f,
  1.41042575e-01f, 4.08346988e-02f, 9.36874002e-02f, 3.55526209e-01f, 2.66525954e-01f, 2.88885832e-01f, 1.88371062e-01f, 1.62488177e-01f, -2.75623918e-01f, -4.25571240e-02f,
  4.55415212e-02f, 3.04006547e-01f, -2.94158489e-01f, 8.63993019e-02f, 1.32522985e-01f, -3.61142047e-02f, 5.22461772e-01f, 1.71835288e-01f, -3.60863805e-01f, -2.18409568e-01f,
  4.10233140e-01f, 7.42508322e-02f, -1.02848068e-01f, -1.15428038e-01f, 1.87178254e-02f, 9.99084488e-02f, -9.59727168e-02f, -2.99714684e-01f, -1.46501437e-01f, 2.99410578e-02f,
  -1.25006661e-01f, 2.93471082e-03f, 9.81266797e-02f, -6.47717789e-02f, -9.01388600e-02f, 2.25211039e-01f, 1.67476699e-01f, 1.58260256e-01f, -8.96049514e-02f, 1.71099324e-02f,
  -7.56292492e-02f, 6.23047762e-02f, -1.13490997e-02f, 1.39783084e-01f, -1.75179839e-01f, -1.22780837e-01f, 4.12282683e-02f, 6.15282729e-02f, 1.99306473e-01f, 3.42675626e-01f,
  -1.39993757e-01f, 2.67392009e-01f, -6.44618645e-02f, 1.67735651e-01f, 3.03372860e-01f, 3.52277756e-01f, -2.80917197e-01f, 1.73813432e-01f, 3.34244445e-02f, -3.90453637e-01f,
  2.70890683e-01f, 2.24648640e-01f, 3.27142805e-01f, 1.20115831e-01f, 1.49348006e-01f, -2.21247360e-01f, 3.03690117e-02f, -1.49679974e-01f, -2.92777628e-01f, 3.86863053e-01f,
  8.58385563e-02f, 1.13432622e-02f, 4.46101397e-01f, 2.32090682e-01f, 1.15746491e-01f, 3.05247575e-01f, 2.84231275e-01f, 1.71784982e-01f, -1.67928994e-01f, 2.00123470e-02f,
  -9.12676379e-02f, 7.36455858e-01f, 1.28379151e-01f, 2.91994780e-01f, -1.52658105e-01f, 3.73926818e-01f, 5.02518713e-01f, 5.88105857e-01f, 4.91056979e-01f, 3.18605214e-01f,
  1.93114504e-01f, 1.58614591e-01f, 1.16635151e-01f, -9.81772244e-02f, 1.20148204e-01f, 3.93539727e-01f, 1.81085616e-01f, 9.29444283e-02f, -3.09673995e-01f, -4.48904604e-01f,
  -2.45653152e-01f, -4.23178583e-01f, 5.55422962e-01f, 3.63888144e-02f, 2.81167716e-01f, 2.42323369e-01f, -2.73821820e-02f, -3.27789783e-02f, 1.35590479e-01f, 6.41579181e-02f,
  4.43557084e-01f, 6.49106503e-02f, 1.84727892e-01f, -1.96076244e-01f, 3.02102953e-01f, -7.59295672e-02f, -1.89511646e-02f, 1.21260680e-01f, -2.74516582e-01f, -8.08519125e-02f,
  -2.49860790e-02f, -9.19068679e-02f, -5.45564704e-02f, 1.19859613e-01f, 1.35770794e-02f, 3.94957773e-02f, -5.13606966e-02f, 1.51946858e-01f, -2.58817710e-02f, 3.24107148e-02f,
  -1.38934150e-01f, -2.59037733e-01f, -8.22306201e-02f, -4.67374064e-02f, 4.16348036e-03f, -1.68274447e-01f, -1.22082062e-01f, 1.41158268e-01f, 2.44709805e-01f, -1.17025889e-01f,
  9.72498357e-02f, -2.12574393e-01f, 2.56295383e-01f, 1.28193468e-01f, 3.35782953e-02f, -1.08954065e-01f, 1.41066790e-01f, 7.09017143e-02f, -1.54834449e-01f, 9.98540819e-02f,
  -1.69138201e-02f, 1.64424583e-01f, 6.45633712e-02f, 1.62236974e-01f, 3.12968413e-03f, 1.47519618e-01f, 4.72628862e-01f, 4.90821719e-01f, 1.22575291e-01f, -9.06750634e-02f,
  1.37374029e-01f, 3.13347399e-01f, -1.67798728e-01f, -3.07947278e-01f, -1.77398607e-01f, -1.96741089e-01f, 5.58052897e-01f, 7.31436759e-02f, 3.02397847e-01f, -2.05550209e-01f,
  1.18537866e-01f, 1.48220062e-01f, 6.24900758e-01f, 4.14295763e-01f, -3.75361890e-01f, 2.56833434e-01f, 4.34243977e-02f, 1.77731767e-01f, 3.62947762e-01f, -1.41406521e-01f,
  -8.65320638e-02f, 2.34316438e-01f, -4.04859670e-02f, -2.02137068e-01f, 5.29789738e-02f, 2.63056606e-01f, 3.95281315e-01f, 3.12890619e-01f, 1.52331233e-01f, -9.48978290e-02f,
  2.59355038e-01f, 3.25811148e-01f, -8.12872685e-03f, -2.58981436e-01f, -3.56863827e-01f, -1.55535281e-01f, 5.04709065e-01f, 3.62367690e-01f, -4.70213294e-01f, 4.76505458e-01f,
  -3.91409397e-01f, -2.31620267e-01f, 2.75146663e-01f, -7.35262334e-02f, -1.20051075e-02f, -3.25447410e-01f, 2.59003550e-01f, 1.18995458e-01f, 5.01996636e-01f, -1.44973069e-01f,
  1.20863035e-01f, 1.14257827e-01f, 3.31732988e-01f, 8.12925175e-02f, 8.68624002e-02f, 3.26588094e-01f, 1.14273325e-01f, 6.21218830e-02f, 6.02564253e-02f, -7.53059983e-02f,
  1.71953872e-01f, -4.62982766e-02f, 1.71602711e-01f, -3.26583907e-02f, 8.83062705e-02f, 3.35817749e-05f, -1.68332964e-01f, 7.48661011e-02f, -9.13280994e-02f, -7.83043057e-02f,
  1.32784918e-01f, -1.67077854e-01f, 3.37073475e-01f, 2.71590769e-01f, 6.93268329e-02f, -1.37962952e-01f, 4.02802140e-01f, 2.82706827e-01f, -1.46133289e-01f, 6.41719624e-02f,
  1.13026779e-02f, -9.57212225e-02f, 1.69828627e-02f, 4.59062820e-03f, 9.70158577e-02f, -7.78751150e-02f, -1.80904150e-01f, 3.42439525e-02f
};

// L1_fan_Bp_bar (Shape: 1 x 14)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 14;
const float L1_fan_Bp_bar_data[] = {
  3.19653541e-01f, 4.65572439e-02f, 3.10504168e-01f, 1.02602676e-01f, 5.63678658e-03f, 1.00763470e-01f, 3.14719439e-01f, 9.58500877e-02f, 1.20931797e-01f, 1.30970314e-01f,
  8.52370411e-02f, 4.11799729e-01f, 3.47371250e-01f, -5.48138060e-02f
};

// L2_linear_W (Shape: 12 x 32)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 32;
const float L2_linear_W_data[] = {
  2.60564443e-02f, 4.99019563e-01f, 3.57943535e-01f, 4.78457302e-01f, -6.88918531e-01f, -7.13480785e-02f, 1.32935449e-01f, 3.52678657e-01f, 1.52770385e-01f, 2.82323122e-01f,
  2.80197233e-01f, 8.91772006e-03f, 2.59817302e-01f, 7.85755455e-01f, 6.69801772e-01f, -5.65723717e-01f, -2.00456619e-01f, -4.97640550e-01f, 4.33470190e-01f, -1.08402021e-01f,
  5.12752771e-01f, -6.37304857e-02f, 1.05251838e-03f, 4.73156720e-02f, -6.21093251e-02f, 3.01956713e-01f, 1.07404009e-01f, -5.73763251e-01f, -2.72749335e-01f, -7.38535941e-01f,
  2.40536317e-01f, -2.26980045e-01f, 4.75095548e-02f, -3.98466706e-01f, 2.35794574e-01f, 1.77734867e-01f, 2.75259733e-01f, 6.20544970e-01f, 6.66235834e-02f, -4.69320007e-02f,
  -2.01234356e-01f, 7.07980990e-01f, 5.62661886e-01f, 7.35638559e-01f, 5.57371259e-01f, 3.39842975e-01f, -3.74398053e-01f, -2.59380460e-01f, -8.90534520e-02f, -5.97705424e-01f,
  -3.52564216e-01f, 8.39057505e-01f, -3.10765117e-01f, -2.16538221e-01f, -9.50637683e-02f, 1.76946908e-01f, -4.70837057e-01f, -2.27111921e-01f, 4.09983359e-02f, -2.00065464e-01f,
  2.40135431e-01f, -2.49247700e-02f, 4.19197232e-01f, -1.80081367e-01f, -2.33446211e-01f, -1.76356539e-01f, -5.70000350e-01f, -6.61650240e-01f, -3.17380428e-02f, -7.30556965e-01f,
  2.46607020e-01f, 2.10720107e-01f, -2.89229825e-02f, -5.15561819e-01f, 3.35196972e-01f, 5.05843222e-01f, 3.64816695e-01f, 3.94946218e-01f, -6.98289752e-01f, -2.64565676e-01f,
  1.80765122e-01f, -7.48089775e-02f, -6.51992634e-02f, 5.70140660e-01f, -3.84676717e-02f, -8.55632052e-02f, -2.46632591e-01f, -5.41154444e-02f, -1.44021004e-01f, -1.87804654e-01f,
  2.82106608e-01f, 2.67341346e-01f, -1.43688217e-01f, 4.85793084e-01f, -6.77556038e-01f, 1.24762515e-02f, -1.16668083e-01f, -3.56967032e-01f, 1.78028449e-01f, -7.88188100e-01f,
  -9.76885483e-02f, 4.25333828e-02f, -1.60021320e-01f, -4.26995158e-01f, 2.02522129e-02f, 1.89968154e-01f, -6.96847200e-01f, 3.00987661e-01f, -3.77532721e-01f, -1.33941948e-01f,
  2.42673531e-01f, -1.92119345e-01f, 8.37979376e-01f, -2.29987308e-01f, 2.64105111e-01f, -3.21542114e-01f, -3.84974182e-02f, 4.26288635e-01f, 5.59262820e-02f, -1.01187997e-01f,
  7.06081152e-01f, 7.50009939e-02f, -4.12937433e-01f, -2.84238875e-01f, -1.48181409e-01f, -2.64135480e-01f, 5.68259299e-01f, -1.34950384e-01f, -2.35394109e-02f, 4.18192297e-01f,
  3.78148824e-01f, 1.31629080e-01f, 3.86829048e-01f, -4.50310975e-01f, 3.03745806e-01f, 3.33742946e-01f, 5.95337391e-01f, -5.03129542e-01f, -7.27362335e-01f, -5.79435714e-02f,
  -7.92118251e-01f, -5.94491474e-02f, 4.17782575e-01f, -2.85664886e-01f, -3.14097255e-01f, 4.45810646e-01f, 2.73091674e-01f, -1.06481472e-02f, 4.70497400e-01f, -8.99922452e-04f,
  1.95887044e-01f, -1.78439543e-01f, 6.73417032e-01f, -1.92926303e-01f, -8.05629045e-02f, -8.69075581e-02f, -1.62065133e-01f, 1.04118213e-01f, -3.15886050e-01f, 1.46857738e-01f,
  -2.06607729e-02f, -7.01327443e-01f, 1.91031769e-02f, 5.71080267e-01f, 5.22183418e-01f, 1.20555826e-01f, 3.01027477e-01f, -7.14050904e-02f, 3.74208480e-01f, 4.35798585e-01f,
  6.30433023e-01f, -5.06824911e-01f, -2.52929945e-02f, 2.62916163e-02f, 4.14314836e-01f, 6.43445551e-01f, -5.72612405e-01f, 2.29677543e-01f, 6.80183887e-01f, -2.64386445e-01f,
  -5.54595351e-01f, -9.43513066e-02f, 5.42859372e-04f, -9.61318389e-02f, 1.60561383e-01f, -2.04728022e-01f, -1.91148132e-01f, 3.04180328e-02f, 1.31685138e-01f, -4.68949556e-01f,
  5.62621891e-01f, 1.05793506e-01f, 1.07771397e-01f, -5.68618059e-01f, 4.01130587e-01f, -1.48414195e-01f, -1.83897123e-01f, 2.35731587e-01f, -5.16296804e-01f, 1.69172287e-01f,
  3.68102878e-01f, -5.33806026e-01f, 6.01264298e-01f, 2.18027890e-01f, 7.51911819e-01f, -6.19678020e-01f, -4.82642949e-01f, 6.92840695e-01f, -3.84452045e-01f, 5.77686965e-01f,
  -1.91933379e-01f, -2.80618638e-01f, -3.20427090e-01f, -1.75821707e-01f, -1.52933031e-01f, -1.04097903e-01f, -1.25974774e-01f, -1.00880213e-01f, -4.73544091e-01f, 8.73817980e-01f,
  2.48028293e-01f, 1.12807453e-01f, -3.98867220e-01f, 2.15207133e-02f, -2.40892529e-01f, -3.18515807e-01f, -2.74872363e-01f, -4.70931083e-01f, -4.33271080e-01f, -1.46971226e-01f,
  -3.99905354e-01f, -3.32103938e-01f, -4.59961712e-01f, 1.85826957e-01f, -2.25881532e-01f, -3.20680290e-01f, -3.16670090e-01f, 2.88093805e-01f, -1.04648501e-01f, -2.58670688e-01f,
  2.87940115e-01f, -2.19445452e-01f, -1.71704680e-01f, -2.12613747e-01f, 3.19124103e-01f, -5.67269139e-02f, 7.14351892e-01f, 4.00799066e-01f, -1.61493495e-01f, 3.45578521e-01f,
  3.58300745e-01f, -1.27008259e-01f, 5.32348678e-02f, -3.78796846e-01f, 3.19065422e-01f, 1.20420545e-01f, 3.74149793e-04f, -8.17174986e-02f, 2.50440761e-02f, -3.68780017e-01f,
  -8.31771642e-02f, -7.45279565e-02f, -6.47894859e-01f, 5.22251725e-02f, 9.75603834e-02f, -2.82646418e-01f, -1.90092176e-02f, -2.24781439e-01f, 3.32370073e-01f, -8.77805799e-02f,
  -5.32742441e-01f, -5.18468440e-01f, -2.31235325e-02f, 2.05438927e-01f, -3.83282691e-01f, -1.49624750e-01f, -1.60473570e-01f, -9.67018772e-03f, -2.62271494e-01f, 3.13116312e-01f,
  6.15412034e-02f, 4.26838636e-01f, 1.05219650e+00f, -3.61139894e-01f, -1.52870163e-01f, -4.50829007e-02f, -2.46111512e-01f, -2.26060778e-01f, 4.20158021e-02f, 3.22391331e-01f,
  -9.23841894e-02f, 1.95781574e-01f, -2.71455616e-01f, 4.17978764e-02f, 1.46210387e-01f, -6.53419971e-01f, -2.18002126e-01f, -3.60149175e-01f, 2.05222797e-02f, -3.14994007e-01f,
  2.59611130e-01f, -3.17628592e-01f, 2.41859183e-01f, 1.89324528e-01f, -1.73779115e-01f, 2.79975682e-01f, -7.48873428e-02f, -3.07235807e-01f, 2.55506068e-01f, -1.99199423e-01f,
  -1.58832908e-01f, -1.11535549e-01f, -5.31336248e-01f, -2.19071750e-02f, 2.97481179e-01f, -5.82909919e-02f, -2.36729175e-01f, 8.91992033e-01f, -3.68547648e-01f, 4.79357302e-01f,
  2.06150576e-01f, 1.11100279e-01f, -4.69103932e-01f, 3.66690010e-01f, -6.50983527e-02f, 2.95643985e-01f, 1.40449032e-02f, -2.43344188e-01f, -4.07096803e-01f, 1.86380327e-01f,
  -7.01503277e-01f, 5.56209624e-01f, -2.83742011e-01f, -3.59609902e-01f, -3.00616622e-01f, -2.49267638e-01f, 8.69702458e-01f, -3.06569785e-01f, 8.01064447e-02f, 5.87244332e-01f,
  1.04650639e-01f, 1.28027648e-01f, -2.91775197e-01f, -2.66827613e-01f, -2.44732965e-02f, -2.22159758e-01f, -5.42605937e-01f, 4.07456189e-01f, -1.91396892e-01f, 2.86413133e-01f,
  4.70845431e-01f, 1.06250495e-01f, 2.53854275e-01f, 8.48710179e-01f, -2.66353041e-01f, 3.22052121e-01f, 4.69595641e-02f, 5.83619773e-01f, 2.47812137e-01f, 4.75588173e-01f,
  -3.24998200e-01f, 5.43681264e-01f, 7.68018737e-02f, -8.50876093e-01f, -8.72098505e-01f, -4.67904121e-01f, 3.82757336e-01f, 5.96500397e-01f, -3.70276809e-01f, 1.00759387e+00f,
  -5.46575189e-01f, -3.46335083e-01f, -1.49942964e-01f, -1.61785409e-01f, 1.19191900e-01f, -2.02329040e-01f, -1.12123430e-01f, -6.88949898e-02f, -4.89722431e-01f, -3.11508596e-01f,
  7.12624565e-02f, 1.09449148e-01f, -1.64544582e-01f, -3.40514451e-01f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  1.27087772e-01f, 8.62083882e-02f, 3.78290154e-02f, -1.36418894e-01f, 1.23807453e-01f, -3.23160887e-02f, 5.31954207e-02f, -1.76002041e-01f, -1.88942567e-01f, 7.93366060e-02f,
  -1.70896754e-01f, 6.07053041e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 9, 14
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 9, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        32, 12
    );
    }
    