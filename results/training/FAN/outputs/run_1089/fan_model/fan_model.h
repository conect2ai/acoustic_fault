/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 25 x 120)
const int L0_fan_Wp_rows = 25;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  3.91542792e-01f, 1.81703225e-01f, 1.86634175e-02f, 7.16889799e-02f, -2.61021405e-01f, -3.57041359e-02f, 2.14509070e-01f, 2.11497441e-01f, 1.86589465e-01f, 5.18013611e-02f,
  -5.66296726e-02f, -6.84522465e-02f, 7.52695501e-02f, 1.23554535e-01f, 2.50649542e-01f, 2.20347255e-01f, 2.10797578e-01f, 2.56883591e-01f, 2.62475640e-01f, 1.36566982e-01f,
  -3.77248717e-03f, 7.27050230e-02f, 1.90487415e-01f, 1.74849451e-01f, -9.00789052e-02f, -4.33672173e-03f, -1.19124083e-02f, -4.08968776e-02f, 7.37337098e-02f, 4.12272383e-03f,
  -8.41700062e-02f, 1.05364293e-01f, 7.98206031e-02f, 2.47741323e-02f, -9.48816687e-02f, 2.18638137e-01f, 1.15267843e-01f, 1.06044471e-01f, 1.36193484e-01f, 1.71350092e-01f,
  2.30812225e-02f, 8.04624632e-02f, 6.85397461e-02f, 4.89859208e-02f, 8.92642438e-02f, 8.64084810e-02f, 1.49239421e-01f, 1.94406375e-01f, 1.84155449e-01f, 2.55456213e-02f,
  2.92472392e-02f, -8.55743140e-02f, -3.42185572e-02f, 1.05527274e-01f, 1.08094648e-01f, -6.40824810e-02f, -1.42899982e-03f, 1.01409405e-01f, 2.06878379e-01f, 2.04905182e-01f,
  4.43834700e-02f, -1.32624447e-01f, -2.28352267e-02f, -9.95587856e-02f, -7.63483718e-02f, -1.02044776e-01f, -4.10484746e-02f, -1.73714355e-01f, -6.22849427e-02f, -1.40359759e-01f,
  -8.79773125e-02f, -1.25230655e-01f, -2.19426453e-02f, -9.08834785e-02f, -9.42915902e-02f, -1.57541156e-01f, -1.01851135e-01f, -1.30582705e-01f, -5.20880222e-02f, -1.49816245e-01f,
  -2.74480414e-02f, -1.35148495e-01f, -7.98409283e-02f, -2.35306900e-02f, -2.02575047e-02f, -1.45919025e-01f, -1.77820802e-01f, -6.33737147e-02f, -1.36324167e-01f, -1.53450072e-01f,
  1.38208270e-01f, 9.68966037e-02f, 1.71140581e-01f, 1.82697564e-01f, 1.38123184e-01f, 1.15375832e-01f, 5.95743731e-02f, 1.36206746e-01f, 1.00241685e-02f, 1.45576581e-01f,
  6.71068057e-02f, 8.53839293e-02f, 4.52673296e-03f, 7.63738453e-02f, 9.05928314e-02f, 1.13775112e-01f, -2.11201943e-02f, 8.52103457e-02f, 9.73731354e-02f, 9.15919393e-02f,
  1.41575769e-01f, 1.38463169e-01f, -7.04700723e-02f, 1.21981025e-01f, 1.14501892e-02f, 7.28488490e-02f, 6.39297217e-02f, 4.63745557e-02f, 1.45674914e-01f, 3.20993006e-01f,
  -6.83516145e-01f, -2.17270866e-01f, 1.45212308e-01f, -2.34525904e-01f, 1.24531008e-01f, 2.51341999e-01f, 3.64347011e-01f, 4.75134281e-03f, -9.47750211e-02f, -8.14411342e-02f,
  -1.66592389e-01f, -1.41930714e-01f, -1.22515917e-01f, 3.81187089e-02f, 7.93070346e-02f, 1.65862560e-01f, 1.11817412e-01f, 2.77036596e-02f, 4.01507244e-02f, 1.79732054e-01f,
  1.72242180e-01f, -9.95961577e-02f, -2.96348751e-01f, -3.94853242e-02f, -4.11407910e-02f, 3.16484794e-02f, 2.71127131e-02f, -5.65802827e-02f, 1.07940502e-01f, -2.33551450e-02f,
  -2.67421335e-01f, -2.16724902e-01f, 1.33508652e-01f, -1.68138612e-02f, -1.90063398e-02f, -7.51954988e-02f, -3.49024609e-02f, 1.29256479e-03f, -7.95474276e-02f, -4.44352068e-03f,
  -1.47056086e-02f, -1.23956113e-03f, 2.13821009e-02f, 3.36389467e-02f, 9.93460510e-03f, -2.54772231e-02f, -7.81034725e-03f, 2.38075703e-02f, 7.16434000e-03f, -6.25122292e-03f,
  2.84963734e-02f, -1.73855778e-02f, -1.11251093e-01f, 6.00750409e-02f, 1.00802235e-01f, 4.77197729e-02f, 7.23070204e-02f, 1.54072151e-03f, 9.17836502e-02f, -6.93632066e-02f,
  1.04575142e-01f, -2.11344119e-02f, -2.67294347e-02f, -7.52385408e-02f, -2.22222274e-03f, 1.85857564e-02f, 7.70349354e-02f, 3.04814521e-03f, 4.35585156e-02f, 9.04954225e-03f,
  4.75643203e-02f, 2.96351574e-02f, 5.96069731e-02f, -2.58641485e-02f, -4.98770922e-02f, 5.91649599e-02f, 6.53192308e-03f, -1.19605353e-02f, -3.97024713e-02f, 3.10234260e-02f,
  -1.94875579e-02f, -4.00090963e-02f, -6.96122721e-02f, 5.31212315e-02f, 3.97580676e-02f, 1.45250680e-02f, -2.11384729e-04f, -1.70444511e-02f, -1.37580596e-02f, 1.89804647e-03f,
  -1.63728237e-01f, 1.82359532e-01f, -1.08952731e-01f, 2.91935373e-02f, -1.16433933e-01f, 2.67400686e-02f, -1.62717476e-02f, -2.00393312e-02f, 6.42647827e-03f, -2.10004114e-03f,
  1.55463954e-02f, -5.11984006e-02f, -7.46995807e-02f, -2.77749822e-03f, 3.78803723e-02f, -1.01052718e-02f, -6.93539456e-02f, -2.26570517e-02f, 7.33297393e-02f, -1.12381995e-01f,
  -2.96971891e-02f, 1.07902542e-01f, 3.18737351e-03f, -4.67052087e-02f, -3.73575389e-02f, -5.30656055e-02f, -3.26643512e-02f, -1.11295797e-01f, 3.68429683e-02f, -3.25538684e-03f,
  -3.98623943e-01f, -1.22070976e-01f, 1.72777489e-01f, -9.33714882e-02f, -1.18615618e-03f, -2.56623719e-02f, -1.15189262e-01f, 8.94782692e-02f, 1.04307666e-01f, -8.97483602e-02f,
  -1.02934167e-01f, 5.39733246e-02f, -6.98775947e-02f, 5.89921176e-02f, -2.49514431e-02f, -1.47083580e-01f, -1.18657418e-01f, -2.08178088e-02f, 6.78646117e-02f, 2.03760967e-01f,
  1.17161743e-01f, 1.26029206e-02f, 1.21013500e-01f, 1.17755398e-01f, 2.93691847e-02f, 8.97470787e-02f, 1.73399150e-01f, -1.65719520e-02f, 1.80806100e-01f, -6.94328249e-02f,
  -3.06281913e-02f, -6.68503717e-02f, 7.27340877e-02f, 1.28006255e-02f, 9.97621268e-02f, 1.55041041e-02f, 3.52008902e-02f, 3.45131196e-02f, 8.67308229e-02f, 4.43469472e-02f,
  -1.55375665e-02f, -1.68465655e-02f, -9.57268178e-02f, 3.24207023e-02f, -2.24637538e-02f, 4.45072390e-02f, 6.09232001e-02f, -1.32190492e-02f, 1.09509058e-01f, 1.08862603e-02f,
  -3.29396036e-03f, -1.37902622e-03f, -1.12153336e-01f, 1.33193955e-01f, 8.17977116e-02f, 7.12957084e-02f, 7.76886716e-02f, 1.61846094e-02f, 1.44760922e-01f, 5.46337664e-03f,
  -5.94954425e-03f, -1.48041989e-03f, -1.59509778e-02f, 1.53520824e-02f, -6.39550108e-03f, -1.09261461e-01f, -4.65563089e-02f, -8.89630616e-02f, -1.35991154e-02f, 1.00059628e-01f,
  6.35152310e-02f, -2.66039353e-02f, 6.27398584e-03f, 6.45133778e-02f, 1.32975187e-02f, -5.41826338e-02f, 5.77937923e-02f, -2.91498601e-02f, 2.31976863e-02f, -8.50696340e-02f,
  2.12116521e-02f, 4.88873385e-02f, 7.28225559e-02f, 6.33701012e-02f, 9.60308239e-02f, 5.89138791e-02f, 7.88804293e-02f, 8.48667622e-02f, 8.84270370e-02f, 5.38748801e-02f,
  -7.05683008e-02f, 7.28207454e-02f, -5.08619547e-02f, -1.03643406e-02f, -8.76301993e-03f, 1.10454477e-01f, -9.58930627e-02f, -6.70536375e-03f, -2.41121165e-02f, 2.21192706e-02f,
  3.53938453e-02f, -4.26620692e-02f, -5.85607290e-02f, 6.22744299e-02f, -5.00917770e-02f, 1.38416626e-02f, 3.14197317e-02f, -6.77292719e-02f, 5.39263226e-02f, 3.52336466e-02f,
  1.21684194e-01f, -1.07816890e-01f, -7.72063062e-02f, -2.64606550e-02f, 2.01536785e-03f, -5.11927530e-02f, -6.67730197e-02f, 4.36083321e-03f, -6.06359057e-02f, -1.06167153e-01f,
  3.15604061e-01f, 4.29453641e-01f, -4.14019264e-02f, 7.66821429e-02f, -1.14805974e-01f, 2.06547789e-02f, 1.10100798e-01f, 2.86795586e-01f, 1.86712861e-01f, 3.40655334e-02f,
  -1.35940611e-01f, -1.58151656e-01f, -1.18555173e-01f, -4.33711372e-02f, 1.57603160e-01f, -2.33507585e-02f, 9.67806354e-02f, -9.15767327e-02f, -6.15453497e-02f, -8.86692703e-02f,
  -9.10403803e-02f, 2.12487459e-01f, 1.22487165e-01f, 2.44314913e-02f, 3.31294499e-02f, -4.03326042e-02f, 1.51657835e-01f, 1.06624663e-01f, -4.96926755e-02f, -1.45691290e-01f,
  -2.35686153e-01f, 2.75271803e-01f, -9.68649089e-02f, 1.09582596e-01f, 7.35373646e-02f, 1.66608810e-01f, 2.87791602e-02f, 1.40604287e-01f, 1.24930151e-01f, 4.45564948e-02f,
  2.09015347e-02f, -2.28482950e-03f, 1.15794599e-01f, 6.00251146e-02f, 1.68960854e-01f, 2.48323940e-03f, 1.71302125e-01f, 2.18015894e-01f, 6.84288517e-02f, 9.55905244e-02f,
  -6.28932267e-02f, 5.34594664e-03f, 1.43132582e-01f, 1.68217659e-01f, 2.50328034e-01f, 7.57601708e-02f, 1.68127269e-01f, 1.46873817e-01f, 1.84361145e-01f, 2.41559073e-01f,
  -1.99766457e-01f, -9.18151960e-02f, -2.84138899e-02f, -5.60545968e-03f, 4.80605960e-02f, 5.12818918e-02f, -3.66943292e-02f, -9.45052132e-02f, -1.28223941e-01f, 4.68478464e-02f,
  4.42674523e-03f, -1.33212507e-01f, -4.59616631e-02f, 4.81849201e-02f, -1.54336259e-01f, -8.61995481e-03f, -1.19653111e-02f, -3.72403078e-02f, -9.80062112e-02f, -2.77033057e-02f,
  -2.45438516e-02f, -7.56876469e-02f, 1.80301517e-02f, -2.08978560e-02f, -2.15007886e-02f, -4.34494615e-02f, -2.07407232e-02f, -4.59146425e-02f, -3.80466832e-03f, 1.71333160e-02f,
  1.63725883e-01f, 1.28468588e-01f, 3.25616002e-02f, 9.03404597e-03f, 7.10336640e-02f, 1.22667827e-01f, 1.02261566e-02f, 1.24046251e-01f, -1.79149602e-02f, -6.70547187e-02f,
  8.23831484e-02f, 1.14235274e-01f, 1.29173011e-01f, 4.73451708e-03f, 4.83991839e-02f, 1.83660872e-02f, 8.24972242e-02f, -1.95458811e-02f, 1.24604516e-02f, 8.79892781e-02f,
  1.84826896e-01f, 6.63096011e-02f, 4.81418800e-03f, 3.51125449e-02f, 7.43963569e-02f, -9.03971866e-02f, -2.79277889e-03f, 6.38105907e-03f, -2.69789379e-02f, 9.48869213e-02f,
  1.76136866e-01f, -1.23195387e-01f, 1.99090794e-01f, 2.37942606e-01f, -1.80599540e-02f, -1.56536009e-02f, -3.21653299e-02f, 8.45200419e-02f, -7.57749826e-02f, -1.20594785e-01f,
  2.81947087e-02f, 3.98217402e-02f, 2.50960588e-02f, 1.48230851e-01f, 1.23943277e-01f, 8.77815858e-02f, 2.14857668e-01f, 2.90784806e-01f, 1.64530665e-01f, 5.71169220e-02f,
  -4.10096571e-02f, 1.52577892e-01f, 2.11207151e-01f, 1.37378931e-01f, 6.73980266e-02f, -3.15918066e-02f, -8.98586586e-02f, 1.15690596e-01f, -5.80702350e-02f, 1.64676324e-01f,
  1.93519928e-02f, 3.53968404e-02f, 8.95970687e-02f, 6.98464066e-02f, 3.95832118e-03f, 1.51135158e-02f, 8.24910626e-02f, 4.46831658e-02f, 1.25993297e-01f, 2.51642242e-02f,
  5.73173873e-02f, 4.18868773e-02f, 1.42438710e-01f, 3.13758776e-02f, 1.39317170e-01f, -9.31596034e-04f, 1.17739223e-01f, 1.60638034e-01f, 1.23783641e-01f, -1.01743899e-02f,
  1.35959864e-01f, 8.39642808e-02f, 5.97016513e-02f, 5.00172228e-02f, 1.18624441e-01f, 1.02632746e-01f, 3.29938680e-02f, 5.53983934e-02f, 9.81795788e-02f, 4.56793122e-02f,
  -7.03928769e-02f, -1.38780117e-01f, -8.00206363e-02f, 1.27336604e-03f, 3.85323097e-03f, 1.96813568e-02f, 6.62068427e-02f, -2.14686580e-02f, 4.27473383e-03f, -1.41460076e-02f,
  1.08738519e-01f, 1.69361774e-02f, 7.83232599e-03f, 2.00144630e-02f, -7.80410841e-02f, 2.84665972e-02f, 2.44985968e-02f, -2.63635255e-02f, 3.17163914e-02f, -4.19212393e-02f,
  -3.94612504e-03f, -4.93031852e-02f, -6.77110478e-02f, 4.40591723e-02f, -1.60313211e-02f, 2.21191291e-02f, -5.99724688e-02f, -2.14922689e-02f, -8.90740082e-02f, -6.89184219e-02f,
  -5.57869151e-02f, 1.32075936e-01f, 2.73228623e-02f, 1.22068740e-01f, 3.17216441e-02f, -8.61087739e-02f, 7.06340298e-02f, 7.78622553e-02f, 6.46450520e-02f, -1.20633822e-02f,
  3.88224944e-02f, 4.95173596e-02f, 1.13934845e-01f, -5.08093089e-02f, 1.57529250e-01f, 8.78810976e-03f, 9.09769014e-02f, 1.20935343e-01f, 1.38785943e-01f, 5.52334078e-02f,
  1.05377927e-01f, 2.83995667e-03f, 2.87566781e-02f, 5.07099181e-02f, 1.02333277e-02f, 4.11795378e-02f, -6.36323094e-02f, 6.41328916e-02f, -3.51804011e-02f, -1.39372557e-01f,
  2.17278570e-01f, 6.27697585e-03f, 4.09728259e-01f, 1.97434172e-01f, 1.88873291e-01f, 1.99340627e-01f, 1.68740124e-01f, 7.01601580e-02f, -7.12652430e-02f, 4.23177220e-02f,
  1.61840245e-02f, -4.68565300e-02f, 4.22430448e-02f, 6.31988943e-02f, 1.84772760e-01f, 2.85386413e-01f, 3.11380684e-01f, 1.79030329e-01f, 1.01108029e-01f, 1.35424003e-01f,
  -8.63896161e-02f, 1.06183350e-01f, 8.27388838e-02f, 1.28058679e-02f, 2.79798489e-02f, 3.43100578e-02f, 1.28692687e-01f, 4.14317064e-02f, 5.37015684e-02f, 7.36387372e-02f,
  2.40664870e-01f, 8.82499218e-02f, 8.93573761e-02f, -6.74971342e-02f, -2.61502899e-02f, 5.30426130e-02f, 1.24738343e-01f, 4.18111049e-02f, -9.79136862e-03f, -3.19585539e-02f,
  -5.38299493e-02f, -6.17285036e-02f, -4.55695987e-02f, 6.25805035e-02f, 6.29651686e-03f, 1.90820303e-02f, 4.29706823e-04f, 3.63438614e-02f, 2.10543945e-02f, 9.92343277e-02f,
  -4.79070395e-02f, 1.46172000e-02f, 5.65638207e-02f, -6.93698302e-02f, 1.07091382e-01f, 4.56189662e-02f, -5.50801307e-02f, 3.00465710e-02f, -1.34925696e-03f, 3.77135091e-02f,
  -9.99630429e-03f, -6.44331276e-02f, -1.31626144e-01f, -6.56541437e-02f, -5.37834428e-02f, -9.72758159e-02f, -5.85119706e-03f, -5.62647879e-02f, -1.01087846e-01f, -3.93092670e-02f,
  -1.61806449e-01f, 5.16601577e-02f, -6.52988628e-03f, -7.54649416e-02f, 2.78039724e-02f, -9.64495018e-02f, 5.03813475e-03f, -1.37451813e-01f, -1.51127860e-01f, -5.86949699e-02f,
  -1.28217027e-01f, -4.07186560e-02f, -9.54296514e-02f, -4.23114039e-02f, -2.97730733e-02f, -7.05957860e-02f, -1.92079581e-02f, -1.01783596e-01f, 9.31265589e-04f, -5.38501926e-02f,
  -4.15995643e-02f, 6.64427727e-02f, 1.10985704e-01f, 2.62262430e-02f, 6.05994575e-02f, -3.33113261e-02f, 2.96758451e-02f, -1.42442519e-02f, 7.13153258e-02f, 1.86144143e-01f,
  1.40763685e-01f, 7.44415224e-02f, 1.07235387e-01f, 2.57517844e-02f, 6.65349141e-02f, 7.45039582e-02f, -1.76969245e-02f, 4.65803556e-02f, 5.54359145e-03f, -1.08709570e-03f,
  1.72439460e-02f, -2.16380879e-02f, -2.85653453e-02f, 6.39478713e-02f, 9.01461318e-02f, 6.85395375e-02f, -1.55309681e-02f, 8.21280256e-02f, 1.32258549e-01f, -3.91702838e-02f,
  -3.74728769e-01f, 1.29546851e-01f, 1.38427705e-01f, -2.53102519e-02f, 1.67115331e-01f, 2.80632466e-01f, 3.89423817e-01f, 1.01607785e-01f, -8.15659016e-02f, 1.06108919e-01f,
  5.49511649e-02f, -3.10489386e-01f, -3.33382308e-01f, -1.05346523e-01f, 1.76672041e-02f, 2.45929480e-01f, 1.66072607e-01f, -1.48301244e-01f, 4.85733226e-02f, 2.97510941e-02f,
  3.49660702e-02f, -1.08738475e-01f, -1.07831419e-01f, -1.08488388e-01f, -1.27553776e-01f, -2.01330066e-01f, 1.27857581e-01f, 9.95060802e-02f, 6.32626936e-02f, -2.33585551e-01f,
  -2.33459219e-01f, 9.09275189e-02f, -4.89756390e-02f, -2.70882761e-03f, 3.62881497e-02f, 1.31809916e-02f, -7.21127242e-02f, 4.45930697e-02f, -1.15275159e-01f, 5.29519329e-03f,
  -8.35385472e-02f, -3.16670723e-02f, -7.72943944e-02f, -3.94728743e-02f, 4.95122038e-02f, -6.96176812e-02f, -8.35793093e-02f, -2.79727578e-02f, -1.17454544e-01f, 4.74563204e-02f,
  -1.59133170e-02f, 6.91993237e-02f, 9.54173282e-02f, 1.67094916e-01f, 6.09641075e-02f, -1.34705395e-01f, 5.96231781e-02f, 4.41956557e-02f, 5.01234643e-02f, -1.44604146e-01f,
  5.46802767e-02f, 2.90243998e-02f, -5.67133958e-03f, 3.06247100e-02f, -3.80912013e-02f, 5.05001321e-02f, -3.59733775e-02f, -1.15452548e-02f, 2.97656897e-02f, -9.89946909e-03f,
  -2.00481117e-02f, -3.70106585e-02f, -5.22511676e-02f, 1.73201840e-02f, 3.72974202e-03f, -6.37662485e-02f, 8.71807188e-02f, -6.26800880e-02f, 5.43288663e-02f, -2.95026377e-02f,
  4.09713984e-02f, -5.41872270e-02f, 5.94014814e-03f, 1.02664204e-02f, -3.19405012e-02f, -1.90425701e-02f, -2.88288072e-02f, -1.41863031e-02f, 1.20185427e-02f, -1.22910604e-01f,
  -1.80606067e-01f, 1.91517234e-01f, -2.35636383e-01f, -1.32555813e-01f, 1.06265686e-01f, -4.49158205e-03f, -1.90706477e-02f, 5.19201020e-03f, 5.17683774e-02f, -1.63123440e-02f,
  -1.84771512e-02f, 1.78892799e-02f, -6.07578643e-02f, 3.45243141e-02f, -6.11784123e-03f, 3.42726633e-02f, 1.08539797e-01f, -3.17524932e-02f, 7.16874152e-02f, 3.79985422e-02f,
  7.13044265e-03f, 1.58669189e-01f, -2.66974308e-02f, 5.72558604e-02f, 1.59076601e-02f, 4.46584150e-02f, -1.79975375e-03f, -9.30645838e-02f, 6.37412444e-02f, 1.18756555e-01f,
  4.80533659e-01f, -7.52655119e-02f, 2.68244110e-02f, 1.09806675e-02f, -2.62245506e-01f, -1.99326333e-02f, -1.63640499e-01f, 2.40100920e-02f, 2.09615789e-02f, -1.18847884e-01f,
  -4.69001010e-02f, 1.34287179e-01f, 5.48500270e-02f, 4.65531722e-02f, 3.18351030e-01f, -5.69635592e-02f, -9.72953662e-02f, 2.22045630e-01f, 3.30726922e-01f, 1.85327888e-01f,
  -7.48114586e-02f, 1.45382583e-01f, 3.47159117e-01f, 2.52380252e-01f, -1.54391810e-01f, -6.33053631e-02f, -6.91169500e-02f, -1.00962810e-01f, -5.90505153e-02f, -1.05412051e-01f,
  -5.33807017e-02f, 1.10124029e-01f, 2.85741556e-02f, 1.12089351e-01f, 8.94648284e-02f, 2.05317467e-01f, 6.05193675e-02f, 1.09639935e-01f, 2.87705734e-02f, 1.19887337e-01f,
  -6.06218763e-02f, 1.52469203e-01f, 2.48513650e-02f, -2.37717237e-02f, 4.11550775e-02f, 6.16328269e-02f, 1.38207301e-01f, 1.75932035e-01f, 1.86243802e-01f, -5.05714826e-02f,
  -5.42219318e-02f, -4.43854295e-02f, 8.66520479e-02f, 4.73781535e-03f, 3.98575552e-02f, 4.40530432e-03f, 4.95549589e-02f, 4.52325009e-02f, 1.77716270e-01f, 9.25542265e-02f,
  -1.08283805e-02f, -7.54929557e-02f, 9.95061547e-02f, 4.56844680e-02f, -3.22707705e-02f, 4.86436812e-03f, -1.60737094e-02f, 2.63603553e-02f, 1.60424411e-03f, 5.00627374e-03f,
  -1.19129950e-02f, 3.27136219e-02f, 6.65338710e-02f, 8.45148861e-02f, -3.94859612e-02f, 6.23859875e-02f, -3.80150578e-03f, -2.48084944e-02f, 3.23610455e-02f, -1.28326360e-02f,
  -5.39416671e-02f, -2.73161568e-03f, -5.71315177e-02f, -1.21357227e-02f, 2.27235593e-02f, 9.29018855e-02f, 4.02533589e-03f, -1.03901938e-01f, 1.11363484e-02f, 4.23214138e-02f,
  -6.51504174e-02f, 9.41598192e-02f, -1.25997225e-02f, 2.40780953e-02f, 5.48559912e-02f, 2.12498363e-02f, -6.56870306e-02f, 1.16044685e-01f, 5.68404682e-02f, 2.48192274e-03f,
  5.33495583e-02f, 3.34759876e-02f, -1.50535675e-02f, 4.22705412e-02f, 8.44868794e-02f, 6.67905584e-02f, 4.75733131e-02f, -6.78481907e-02f, 1.72192663e-01f, -1.18256994e-02f,
  6.94484785e-02f, 9.18301791e-02f, 6.96909651e-02f, -5.51143773e-02f, 6.61671236e-02f, 9.74769667e-02f, 3.63710672e-02f, 5.54411076e-02f, 5.51232807e-02f, 2.62975767e-02f,
  2.61316687e-01f, 3.28397661e-01f, -8.24332610e-02f, 1.85012057e-01f, 2.62953877e-03f, -1.12079948e-01f, -9.16181132e-02f, -1.04120672e-01f, 1.47273773e-02f, 7.48496726e-02f,
  1.52794734e-01f, 6.88871648e-03f, -5.17502390e-02f, 2.17379872e-02f, 1.81177668e-02f, -6.25287443e-02f, -4.11793813e-02f, -9.78154764e-02f, -2.16460004e-01f, -8.99076462e-02f,
  -3.77859399e-02f, 1.06701247e-01f, -1.87039096e-02f, -8.02413747e-02f, 9.32955369e-03f, -1.31972596e-01f, -1.06022758e-02f, 5.22113778e-02f, -1.18616216e-01f, 1.41633049e-01f,
  1.30858496e-01f, 3.31975728e-01f, 1.03965551e-02f, 1.68500349e-01f, 1.19074963e-01f, 1.00120574e-01f, 9.30546969e-02f, 1.61023617e-01f, 9.67468992e-02f, 1.49238050e-01f,
  1.97195828e-01f, 1.21502943e-01f, 2.10446626e-01f, 1.10594571e-01f, 2.10868523e-01f, 1.37606725e-01f, 2.04935268e-01f, 1.73111469e-01f, 1.80856749e-01f, 2.21776858e-01f,
  2.97329634e-01f, 1.91637844e-01f, 1.26045883e-01f, 3.78934667e-02f, 3.16674598e-02f, 1.32946670e-01f, 9.60336551e-02f, 3.04233171e-02f, 9.43752229e-02f, -1.02154678e-02f,
  1.57743227e-02f, 5.00129573e-02f, -8.83184746e-03f, -5.89707047e-02f, -3.03874537e-02f, -2.42223442e-02f, 4.59204130e-02f, -5.49599566e-02f, 6.19448237e-02f, 4.21474539e-02f,
  1.54097322e-02f, -8.55062231e-02f, -4.75705117e-02f, 7.04132915e-02f, 3.61767896e-02f, 1.19894244e-01f, -2.23359410e-02f, 3.62645052e-02f, 5.00292666e-02f, -1.49757657e-02f,
  -1.28886607e-02f, -3.80227529e-02f, -5.15522575e-03f, 6.17965348e-02f, 1.85778160e-02f, 2.75499877e-02f, -9.92285088e-03f, -2.65876520e-02f, 1.68905985e-02f, -1.47473896e-02f,
  -1.67064145e-02f, 1.50799766e-01f, -1.66756473e-02f, 6.44066334e-02f, 1.10870257e-01f, 6.97907358e-02f, 1.57367334e-01f, 1.38764456e-01f, 9.64288712e-02f, 7.14222342e-02f,
  2.87144929e-02f, 5.81745617e-02f, 1.93618700e-01f, 9.99021381e-02f, 4.35149781e-02f, 9.54779014e-02f, 1.09599277e-01f, 5.59952706e-02f, -4.37833602e-03f, 1.24133907e-01f,
  1.53345779e-01f, -1.29216742e-02f, -7.16744438e-02f, -1.76599566e-02f, 3.32562067e-02f, -1.06114745e-01f, -1.31727889e-01f, 4.60891537e-02f, -1.36693746e-01f, -1.49471328e-01f,
  -5.74314415e-01f, -2.32433498e-01f, -2.36855727e-02f, -1.85773566e-01f, 9.24062282e-02f, 8.87998641e-02f, 1.73028529e-01f, 5.75022697e-02f, -1.41040519e-01f, -1.72458917e-01f,
  -2.05978036e-01f, -1.77809328e-01f, -1.46800086e-01f, -9.86680835e-02f, -4.74341251e-02f, 1.16895452e-01f, 1.31336883e-01f, 5.49200103e-02f, 9.39150229e-02f, -4.67828438e-02f,
  -3.66618223e-02f, -5.31612597e-02f, -2.38311976e-01f, -7.40346536e-02f, -7.01637864e-02f, 3.30532901e-02f, 1.29200920e-01f, -1.02853999e-02f, -6.94741830e-02f, -6.71330243e-02f,
  -2.58790344e-01f, -1.02222271e-01f, 1.03233829e-01f, 8.63501430e-03f, -2.57915519e-02f, -1.04833417e-01f, 2.20279805e-02f, 7.50029366e-03f, 6.59649447e-02f, 4.73191813e-02f,
  -1.11231714e-01f, -3.32167037e-02f, -1.46445408e-01f, -3.26611586e-02f, -2.35241698e-03f, 4.22471315e-02f, 6.33616596e-02f, 5.83372600e-02f, -6.84315572e-03f, -3.75473499e-02f,
  -2.40463763e-02f, -3.82435098e-02f, -7.51150995e-02f, -2.96420399e-02f, -2.59629618e-02f, -9.37088206e-02f, -3.77684757e-02f, -3.43979597e-02f, 2.83601577e-03f, -1.52643114e-01f,
  4.18158285e-02f, -5.85210510e-02f, -2.41244473e-02f, 2.87294816e-02f, -4.73952591e-02f, -3.51034105e-02f, -5.17276078e-02f, 1.49006685e-02f, 7.80312717e-03f, 3.81935351e-02f,
  -2.25117300e-02f, 2.54275613e-02f, -6.56508580e-02f, -2.58304030e-02f, 1.44912200e-02f, 1.78911369e-02f, 2.11806204e-02f, -3.34503390e-02f, 2.40703463e-03f, 2.99375653e-02f,
  -3.98713462e-02f, 5.07262237e-02f, 5.30422293e-02f, 1.01208635e-01f, 2.33414955e-02f, 1.09937927e-02f, 1.16211839e-01f, -2.48376206e-02f, 1.87751297e-02f, 3.21894046e-03f,
  -1.31661996e-01f, 3.18147875e-02f, -1.79730430e-01f, 4.02762890e-02f, 5.32730483e-02f, 8.18837136e-02f, -1.32810026e-01f, 4.77761496e-03f, 3.82194598e-03f, -8.28687325e-02f,
  -1.06362076e-02f, -9.88669097e-02f, -4.65018116e-02f, -4.87969108e-02f, -1.13101281e-01f, -3.22640687e-02f, -1.98640078e-02f, -1.03595173e-02f, 3.96775231e-02f, -5.64020127e-02f,
  -6.54405281e-02f, -6.22691214e-02f, -2.49134839e-01f, 4.21763211e-03f, -5.98679557e-02f, -9.25617814e-02f, -4.73890789e-02f, -5.56524359e-02f, -8.00507367e-02f, -7.20868930e-02f,
  -2.08048508e-01f, 2.00434685e-01f, 4.43041623e-02f, -1.99090600e-01f, 1.60514891e-01f, 3.09976578e-01f, 4.57835257e-01f, 5.35064526e-02f, -1.49916515e-01f, 9.54441950e-02f,
  1.38147637e-01f, -1.63966581e-01f, -4.98094559e-02f, -1.16572723e-01f, 8.37168396e-02f, 3.51697057e-01f, 2.03914002e-01f, -1.03443608e-01f, -8.71052071e-02f, 7.94237629e-02f,
  3.93930674e-02f, -1.22561976e-02f, -9.46659148e-02f, -5.52594550e-02f, 1.38952658e-02f, 1.42394036e-01f, 2.06535265e-01f, -3.51560041e-02f, 1.03595115e-01f, -9.99039263e-02f,
  9.60451737e-02f, -9.10748020e-02f, -5.71967922e-02f, -3.26601081e-02f, 2.26268880e-02f, 4.68158014e-02f, 2.91833170e-02f, -5.40688671e-02f, -1.16229868e-02f, -6.21251203e-02f,
  5.91315329e-02f, -7.28851110e-02f, 1.79939270e-02f, 1.07596945e-02f, 2.38531046e-02f, -1.66705679e-02f, -7.85123408e-02f, -1.40305385e-01f, -8.29729885e-02f, 7.67132660e-05f,
  1.09414697e-01f, -1.79647524e-02f, 1.26385316e-01f, 1.90188587e-02f, 8.61293972e-02f, -9.07247588e-02f, 9.39211622e-02f, -8.01489204e-02f, 3.30634750e-02f, -8.54121819e-02f,
  -1.02112303e-02f, -1.00546546e-01f, 1.24103315e-01f, 4.46863323e-02f, 4.01130244e-02f, -9.80833732e-03f, 2.65410244e-02f, 2.83618532e-02f, 1.74170174e-02f, 5.06446436e-02f,
  -1.09478347e-02f, 5.32959029e-02f, -5.80793526e-03f, 1.84650589e-02f, 4.15668674e-02f, 4.66507934e-02f, 1.12626038e-01f, 1.46838641e-02f, -7.36078173e-02f, -8.74877572e-02f,
  -2.83816494e-02f, 5.85775524e-02f, 7.39427581e-02f, -8.05791542e-02f, 1.35577872e-01f, -4.31440137e-02f, 1.06950574e-01f, 1.95483100e-02f, -2.38777902e-02f, -2.92764697e-02f,
  8.06997791e-02f, -1.86900385e-02f, -1.47374626e-02f, -4.83929962e-02f, -2.01172587e-02f, 2.24620700e-02f, 6.86139241e-02f, -8.60376656e-02f, 4.42149974e-02f, -4.39834483e-02f,
  5.15221246e-02f, 6.53606802e-02f, 8.31119716e-02f, -3.10921785e-03f, 1.25340568e-02f, 4.90494221e-02f, 1.32803530e-01f, -7.55474716e-03f, 6.87501281e-02f, 4.81207334e-02f,
  1.25185639e-01f, 7.80544952e-02f, 1.21703774e-01f, 1.54325232e-01f, 3.95916216e-02f, 1.20850809e-01f, 1.03117548e-01f, 1.60348460e-01f, 1.78313807e-01f, 3.26962352e-01f,
  2.69403700e-02f, 1.33925557e-01f, 2.25735337e-01f, 1.13460213e-01f, 1.45900667e-01f, 5.15481196e-02f, 1.35039270e-01f, -4.92106378e-02f, -3.09182634e-03f, 3.37300487e-02f,
  -1.15767919e-01f, -2.43232161e-01f, -1.75044343e-01f, -1.29893124e-01f, -1.24697737e-01f, 1.36927441e-01f, 2.54164457e-01f, -6.52633309e-02f, -2.08761036e-01f, -1.36681825e-01f,
  1.18109938e-02f, 1.07716151e-01f, -1.09684907e-01f, -8.99337903e-02f, 1.62547529e-01f, -1.39733583e-01f, 2.10024297e-01f, 1.32936895e-01f, 6.69492316e-03f, 2.72095352e-01f,
  1.38043806e-01f, 1.91041082e-01f, -1.18940450e-01f, -4.63998653e-02f, 5.43508083e-02f, -1.91826746e-02f, -4.71733101e-02f, 1.46896634e-02f, -1.08982682e-01f, 8.51083733e-03f,
  3.67059298e-02f, -9.41031892e-03f, -5.97547293e-02f, -7.88608659e-03f, 1.24906674e-01f, 9.21751279e-03f, 2.33564097e-02f, 5.50793298e-02f, -1.08536251e-01f, -6.19799159e-02f,
  -1.62813384e-02f, 4.87633422e-02f, 3.73895466e-02f, -3.39724012e-02f, 3.12836394e-02f, -5.00435978e-02f, 3.46169546e-02f, -9.14542377e-03f, -4.39891219e-02f, 1.09713785e-01f,
  -3.65460641e-03f, -1.10166527e-01f, 5.60953934e-03f, 8.94165635e-02f, -3.75734270e-02f, 5.17231487e-02f, 9.41698849e-02f, 2.95824162e-03f, -2.68723201e-02f, 1.28698125e-01f,
  5.96391261e-02f, 4.59258724e-03f, 1.15906231e-01f, 5.08215614e-02f, -3.78711987e-03f, 1.73174660e-03f, 1.20937482e-01f, -8.79070815e-03f, 1.72457043e-02f, -1.82113480e-02f,
  3.77408415e-02f, 4.31679413e-02f, 6.44253045e-02f, -3.90998051e-02f, 8.70183259e-02f, 6.22106530e-02f, -4.15502377e-02f, 8.43385793e-03f, 3.72048877e-02f, 7.73250312e-02f,
  -7.01569393e-02f, -2.00737670e-01f, -4.72078770e-02f, -3.06255352e-02f, 6.85038120e-02f, -8.28630254e-02f, -7.00845122e-02f, -1.83719754e-01f, 5.34751778e-03f, 9.37833544e-03f,
  -1.35919200e-02f, -1.35509362e-02f, -2.78292075e-02f, 3.02967168e-02f, -1.03687525e-01f, -1.17327720e-02f, 6.85687177e-03f, -5.27803004e-02f, -1.20311908e-01f, -8.11193287e-02f,
  -6.73434436e-02f, -1.19202241e-01f, -1.38084948e-01f, -1.41477779e-01f, -1.07043415e-01f, -1.33945584e-01f, -8.65624622e-02f, -4.75695133e-02f, -2.19157115e-01f, -1.19762927e-01f,
  -2.60174926e-02f, 2.29721814e-01f, 4.75367866e-02f, -4.18875627e-02f, 1.46636873e-01f, 1.09397180e-01f, 2.73547351e-01f, 5.73021062e-02f, 8.27543251e-03f, 1.65334508e-01f,
  4.44190390e-02f, -2.84081906e-01f, -7.00304508e-02f, -5.01922816e-02f, -1.22349665e-01f, 2.33732879e-01f, 1.28883719e-01f, 3.57134007e-02f, -2.55971819e-01f, -1.24390118e-01f,
  -4.06587496e-02f, -5.73857035e-03f, -4.11628447e-02f, -1.50315277e-02f, 1.91398993e-01f, -1.46453708e-01f, 8.98041129e-02f, 6.23742417e-02f, 1.20669417e-01f, 1.61448106e-01f,
  -9.13220868e-02f, 7.80479014e-02f, -2.06714839e-01f, -2.28339080e-02f, -3.76067460e-02f, -4.17156741e-02f, -8.67025629e-02f, -4.34589311e-02f, -7.44158030e-02f, -7.54950009e-03f,
  -1.54459132e-02f, -4.73854393e-02f, -1.91616658e-02f, -9.73040685e-02f, -5.00778891e-02f, -1.15612313e-01f, 2.64215190e-02f, -1.36854187e-01f, -3.66867110e-02f, -3.30991521e-02f,
  -7.23347962e-02f, 4.63945381e-02f, 3.18024904e-02f, -1.73665509e-02f, -1.27732188e-01f, 1.28180692e-02f, -7.11218342e-02f, -1.44564137e-01f, -3.22692432e-02f, 2.54083630e-02f,
  -8.77005011e-02f, -2.37955619e-02f, -4.63121198e-02f, 3.35697383e-02f, 5.23866042e-02f, -1.58793014e-02f, 2.13662311e-02f, -5.98198734e-02f, -1.10713560e-02f, -1.03399679e-01f,
  -4.66911234e-02f, -1.00680187e-01f, -8.01343694e-02f, -9.54295844e-02f, -7.47501329e-02f, 2.46307887e-02f, -5.84543049e-02f, -1.88430622e-02f, -1.96067840e-02f, -3.06707863e-02f,
  -3.37537341e-02f, -5.16080484e-02f, -4.18178029e-02f, -1.12099648e-01f, -2.48819888e-02f, 6.17603697e-02f, -9.83433053e-02f, -6.94225281e-02f, -5.37680499e-02f, 1.21923815e-02f,
  -1.98728904e-01f, -1.48850575e-01f, -3.62963136e-03f, 7.69242197e-02f, -4.47897725e-02f, -6.09337294e-04f, -1.55607641e-01f, -3.54137085e-03f, -4.26497161e-02f, -5.28661273e-02f,
  -4.56881933e-02f, -7.13689327e-02f, -3.64724174e-02f, -4.41468954e-02f, -5.00196479e-02f, -7.63110444e-02f, -6.39150757e-03f, -2.38673724e-02f, -4.11248431e-02f, -6.95772544e-02f,
  -5.81179000e-02f, -5.88838123e-02f, -4.40903716e-02f, -3.43383029e-02f, -4.40082625e-02f, -1.82868317e-02f, -6.51424229e-02f, 8.38184822e-03f, -7.41758421e-02f, -1.08591728e-01f,
  -1.38362944e-01f, 1.83265433e-01f, 1.79702818e-01f, -1.09150514e-01f, -1.17652766e-01f, 7.26076216e-02f, 3.31332058e-01f, 1.06485486e-01f, -3.11834980e-02f, 8.79471302e-02f,
  -1.49727255e-01f, -7.07217082e-02f, 1.19231001e-01f, -2.56415969e-03f, 3.12855542e-01f, 3.84688586e-01f, 2.96027422e-01f, 2.19557017e-01f, 1.47623584e-01f, 3.84888388e-02f,
  -9.83721912e-02f, -1.01768710e-01f, -7.79304281e-02f, -2.79822275e-02f, -9.21955183e-02f, 1.72283333e-02f, -9.11136270e-02f, -1.81974813e-01f, 4.37752269e-02f, 1.92852877e-02f,
  1.84160873e-01f, -9.49531049e-02f, 1.45279601e-01f, -6.52759820e-02f, 6.17671609e-02f, 4.70638350e-02f, 1.39575034e-01f, -3.04763615e-02f, -1.77976035e-03f, 1.38503239e-02f,
  -5.90483695e-02f, -8.69024172e-03f, 6.08846657e-02f, 4.44505438e-02f, -1.01569705e-02f, -5.21185882e-02f, -3.16150188e-02f, 4.78453971e-02f, 1.68055773e-01f, 6.12545088e-02f,
  1.22093298e-01f, -5.88845648e-02f, 9.75307822e-03f, 8.44979435e-02f, 4.64902408e-02f, 5.11531234e-02f, 1.94556098e-02f, -7.23482519e-02f, 4.95904386e-02f, 1.08842976e-01f,
  -5.78113124e-02f, 4.17307317e-02f, -1.05497658e-01f, -1.85732525e-02f, -8.52508694e-02f, -1.02356777e-01f, -1.89250503e-02f, -4.37921546e-02f, -1.89133063e-02f, -6.72552269e-03f,
  -9.61630195e-02f, -6.78637996e-02f, -1.12020478e-01f, 7.00281337e-02f, -1.04361549e-01f, -1.03227548e-01f, -7.07618846e-03f, -5.03097549e-02f, -4.58716042e-02f, -1.77300557e-01f,
  -5.14274500e-02f, -5.18155284e-02f, 5.54093719e-03f, 3.15195434e-02f, -9.45394635e-02f, 5.48096895e-02f, -9.21184644e-02f, -1.28379568e-01f, -4.29161526e-02f, -1.40983194e-01f,
  1.12762623e-01f, -8.22577477e-02f, 1.87836215e-01f, 9.70952436e-02f, 2.31173374e-02f, 2.48270854e-02f, -7.94769377e-02f, 3.16157229e-02f, 3.50801423e-02f, -5.38970949e-03f,
  -1.21198269e-02f, -1.65516175e-02f, 1.23255886e-01f, -5.55671453e-02f, 1.78985968e-02f, 6.54691234e-02f, 7.48167485e-02f, 2.08455771e-01f, 7.78193548e-02f, -2.40301099e-02f,
  2.47691032e-02f, 1.18644997e-01f, 1.54255956e-01f, 1.25563920e-01f, 1.96243227e-02f, 1.24574356e-01f, 1.68715671e-01f, 9.53735635e-02f, 4.81211692e-02f, 1.00753546e-01f,
  -3.76874626e-01f, -9.81961489e-02f, -2.05623493e-01f, -1.54802129e-01f, -7.16752722e-04f, 1.21041946e-01f, 3.13887268e-01f, 9.10031199e-02f, -7.28821754e-02f, 7.29785487e-02f,
  -6.48696497e-02f, -3.78102437e-02f, -4.85246778e-02f, 8.11102539e-02f, 2.15965629e-01f, 2.97973394e-01f, 2.15159386e-01f, 9.52027291e-02f, 1.93754688e-01f, 3.31256211e-01f,
  2.02205271e-01f, -9.38716624e-03f, -1.39301091e-01f, 1.41583562e-01f, -5.55911325e-02f, 8.05915669e-02f, -1.56936601e-01f, -1.19675487e-01f, -2.35838685e-02f, -2.56429583e-01f,
  -2.15482309e-01f, -1.94206908e-01f, 4.01545651e-02f, 6.24338612e-02f, -2.91870497e-02f, 1.48995630e-02f, 9.42712873e-02f, -8.57541040e-02f, 4.52792570e-02f, -1.33401724e-02f,
  -8.20557252e-02f, -6.10072389e-02f, -1.09306134e-01f, -5.04876934e-02f, -7.46480078e-02f, 5.87226003e-02f, -4.40220609e-02f, -1.47155644e-02f, -9.56486985e-02f, -4.88707311e-02f,
  -8.06935423e-04f, -1.39722526e-01f, -8.32130685e-02f, -3.64961512e-02f, -9.25379917e-02f, 7.78675228e-02f, -1.20334849e-01f, -4.26794849e-02f, -4.23257314e-02f, -3.02722566e-02f,
  6.41560778e-02f, -4.91315648e-02f, 1.98307857e-02f, 4.34661806e-02f, -3.47831026e-02f, -1.06129097e-02f, -3.62938121e-02f, 5.79929352e-02f, 6.42238334e-02f, -2.90953238e-02f,
  -2.85390206e-03f, 4.19957703e-03f, 3.53100412e-02f, -6.29765466e-02f, -4.03237622e-03f, -9.30045173e-02f, 1.54361865e-02f, 7.66441077e-02f, -8.79792571e-02f, -2.41951328e-02f,
  -4.70870472e-02f, -8.40253383e-02f, -6.31289184e-02f, -7.69553408e-02f, 4.60243821e-02f, 8.78529996e-02f, -8.82275309e-03f, -3.87451127e-02f, 1.75072365e-02f, 3.39481719e-02f,
  9.21725109e-02f, -1.41199594e-02f, 3.63111421e-02f, -1.78603083e-02f, -1.22194260e-01f, -3.99919488e-02f, -1.23605765e-01f, -2.60699517e-03f, 3.76574993e-02f, -4.80735712e-02f,
  -1.32350316e-02f, 7.02529624e-02f, -1.62056461e-02f, 7.90084805e-03f, 5.59711903e-02f, 1.65137071e-02f, -4.11923937e-02f, -3.82783227e-02f, 3.38287428e-02f, -4.10938263e-02f,
  4.98530902e-02f, 1.50590733e-01f, 4.63468768e-02f, 1.14270397e-01f, -6.34397194e-02f, 1.72498018e-01f, 5.00137582e-02f, -2.40376033e-02f, 8.19733143e-02f, 2.05458000e-01f,
  -1.29629001e-01f, 6.30847132e-03f, 1.04268119e-01f, -4.74277698e-02f, 4.17198017e-02f, 8.53064880e-02f, 3.37709367e-01f, 2.54358411e-01f, -8.95305723e-03f, 2.99567841e-02f,
  -1.20319277e-01f, -2.05213428e-01f, -6.86154813e-02f, 1.21206213e-02f, 2.54624188e-01f, 1.59649715e-01f, 3.53473067e-01f, 1.83098435e-01f, 1.05136961e-01f, 7.70032853e-02f,
  5.69669567e-02f, 2.33347639e-01f, 1.60442531e-01f, 1.16995811e-01f, 5.53525332e-03f, 1.47811454e-02f, 3.70213948e-02f, -2.89649181e-02f, 5.14552519e-02f, -4.51429524e-02f,
  -1.75495923e-01f, 5.65817580e-02f, 1.91410503e-03f, 4.32935096e-02f, -1.95329692e-02f, 1.11768514e-01f, -1.26287648e-02f, 8.81499052e-02f, 1.78219974e-02f, 4.42143939e-02f,
  -2.71632485e-02f, 9.79113802e-02f, 7.01766089e-02f, -6.04008674e-04f, 4.65196371e-02f, 6.25196546e-02f, 9.31103081e-02f, 2.93104956e-03f, -5.38068824e-04f, -3.50068174e-02f,
  -5.69827929e-02f, 2.70684045e-02f, -7.61300921e-02f, 1.29098549e-01f, 1.26801163e-01f, 9.87671465e-02f, -9.78471595e-04f, 3.33380736e-02f, 1.01484591e-02f, 8.28735828e-02f,
  1.42698914e-01f, -3.96806300e-02f, 5.05727483e-03f, 2.57659499e-02f, -3.86716425e-02f, -8.63155127e-02f, 4.27281344e-03f, 4.18224446e-02f, 5.25565371e-02f, 1.34270522e-03f,
  -7.19667375e-02f, -6.15606159e-02f, -2.64792591e-02f, -5.18206507e-04f, 2.59172842e-02f, 2.74963514e-03f, 3.68563831e-02f, 3.47251035e-02f, -4.32187505e-02f, 6.19814210e-02f,
  -9.15581509e-02f, -7.60879368e-02f, -4.45526429e-02f, -9.38724075e-03f, -2.19572745e-02f, 1.02104396e-02f, -1.81987730e-03f, -6.17810898e-02f, -1.06304094e-01f, 2.96110008e-02f,
  -7.29269981e-02f, -1.35762310e-02f, -1.14732511e-01f, 1.45215675e-01f, 4.60596606e-02f, 1.88354845e-03f, 1.14958100e-02f, 3.21493894e-02f, -8.20418298e-02f, 2.62745284e-02f,
  -8.89761373e-03f, 2.27738842e-02f, -4.04529124e-02f, -1.14801256e-02f, -1.66546907e-02f, 4.36275452e-02f, 7.63000995e-02f, -9.82127115e-02f, 4.36392576e-02f, -4.80806865e-02f,
  1.14378892e-01f, 6.91872090e-02f, -1.32852182e-01f, -5.97930849e-02f, 5.71491867e-02f, -4.00090069e-02f, -1.27195697e-02f, -8.09756294e-02f, 1.08273700e-01f, 1.09613568e-01f,
  -1.53866455e-01f, 4.54158969e-02f, -3.20854247e-01f, 1.27537429e-01f, -8.09671804e-02f, -1.52454332e-01f, -9.89601016e-02f, 8.31717923e-02f, 1.38280496e-01f, 1.41491026e-01f,
  1.35063723e-01f, 1.79023400e-01f, 1.30660176e-01f, 1.17093302e-01f, -2.62395535e-02f, -3.10110096e-02f, -1.19091429e-01f, -2.42253825e-01f, -1.80493578e-01f, 7.57876188e-02f,
  1.52334079e-01f, 1.45524025e-01f, -1.05878428e-01f, 1.38361156e-01f, 1.05304517e-01f, 9.91709977e-02f, 1.62846018e-02f, 8.56472775e-02f, 2.80866139e-02f, 8.72792229e-02f,
  -2.49274567e-01f, -2.40072176e-01f, -6.52646348e-02f, -2.96137575e-02f, -1.54421419e-01f, -9.26647708e-03f, -1.14455067e-01f, -8.69611502e-02f, -2.02898700e-02f, -6.59067929e-02f,
  -6.83009550e-02f, -8.02806169e-02f, -8.51866454e-02f, 5.35353944e-02f, -4.81109396e-02f, 1.16979219e-02f, -6.64576516e-03f, -3.67858075e-02f, 1.94938164e-02f, -4.04979400e-02f,
  5.61462268e-02f, -2.03581229e-01f, -1.55707046e-01f, 7.39258379e-02f, -1.15760505e-01f, -2.52124947e-02f, -3.40583250e-02f, -9.99659076e-02f, -3.14761624e-02f, 1.35143504e-01f,
  -4.03266847e-02f, -4.66569364e-02f, 5.49878366e-02f, 1.58379953e-02f, 1.39530346e-01f, 9.93772894e-02f, 9.34928656e-02f, 9.08764303e-02f, -1.47579480e-02f, 1.22975864e-01f,
  9.07596573e-02f, 8.26454982e-02f, -2.82923738e-03f, 5.20306677e-02f, 1.12730786e-01f, 3.53470854e-02f, 7.55072907e-02f, 5.86338975e-02f, 1.15745790e-01f, -3.26482840e-02f,
  2.28154138e-02f, -1.14313839e-03f, -2.34136195e-03f, 5.66293038e-02f, 1.10922083e-02f, -1.02472194e-01f, -5.41224778e-02f, -2.60716472e-02f, 1.06442474e-01f, -6.59611076e-02f,
  2.41754308e-01f, -3.16521853e-01f, -5.80637380e-02f, 3.84973511e-02f, -1.95060410e-02f, -2.88113598e-02f, -6.82153627e-02f, -2.43425667e-02f, -6.87495470e-02f, -1.54799558e-02f,
  -6.85851723e-02f, 1.02631226e-02f, 3.52634043e-02f, 4.37769964e-02f, 1.77304391e-02f, 9.51930732e-02f, 5.08029237e-02f, 1.75895710e-02f, -7.22151995e-02f, 2.14522183e-02f,
  8.17290768e-02f, -4.47097681e-02f, -1.75347030e-02f, 1.01764277e-02f, -2.33763270e-03f, -7.49576464e-02f, -9.55162337e-04f, 6.16236925e-02f, -6.20324090e-02f, 4.63911425e-03f,
  -1.20940045e-01f, -2.86869407e-02f, -1.47478364e-03f, -9.98175889e-02f, -6.99626356e-02f, 1.06016279e-03f, -5.23702241e-02f, -2.27958530e-01f, -3.59357029e-01f, -1.69309661e-01f,
  -1.01375639e-01f, -3.11324447e-01f, -1.73771039e-01f, -2.60691911e-01f, -1.63487121e-01f, -8.25322419e-02f, -9.94492993e-02f, -3.93613502e-02f, -1.50068671e-01f, -3.17105502e-01f,
  -1.96676925e-01f, -2.20334873e-01f, -2.79019952e-01f, -3.36788803e-01f, -1.58556074e-01f, -1.98064506e-01f, -9.16385725e-02f, -1.51323259e-01f, -4.68443967e-02f, 4.80280146e-02f,
  1.75211191e-01f, -1.04095982e-02f, -3.14118445e-01f, -3.08829397e-01f, -5.01376018e-02f, -1.61113471e-01f, -6.38745725e-02f, -6.54917657e-02f, -1.28907099e-01f, -1.01906642e-01f,
  -1.04276270e-01f, -1.81529790e-01f, -7.29599297e-02f, -1.47283241e-01f, -1.57409251e-01f, -1.00519992e-01f, -2.21337512e-01f, -2.75873572e-01f, -1.56155571e-01f, -1.01373747e-01f,
  -6.12094365e-02f, -7.98756108e-02f, -4.74550948e-02f, -2.05225557e-01f, -2.18293548e-01f, -9.29103345e-02f, -1.70568362e-01f, -1.67603105e-01f, -1.74334422e-01f, -2.05256179e-01f,
  -2.19451599e-02f, 8.45862255e-02f, 6.07220922e-03f, 5.19274622e-02f, 1.00466736e-01f, 5.49145527e-02f, 8.59346762e-02f, 4.95223850e-02f, -2.95549389e-02f, -1.18242353e-02f,
  3.65259573e-02f, 8.82129893e-02f, 2.32041962e-02f, -9.34413075e-03f, 7.25379074e-03f, 1.45463526e-01f, 5.17189167e-02f, 9.66372788e-02f, 1.37387767e-01f, 1.09124318e-01f,
  1.61851794e-02f, 6.91682100e-02f, 2.06212755e-02f, 2.52405796e-02f, 9.68327560e-03f, 4.50564288e-02f, 1.06906757e-01f, 1.02148667e-01f, -3.34611684e-02f, 1.26979545e-01f,
  -2.86017418e-01f, -1.92211404e-01f, -1.56809717e-01f, -3.12218487e-01f, -1.94216892e-01f, -9.11453664e-02f, -1.27750203e-01f, -1.50710642e-01f, -7.46026263e-02f, -1.76558286e-01f,
  -1.57163605e-01f, -1.53050870e-01f, -1.28502771e-01f, -1.70143023e-01f, -1.84029222e-01f, -2.09482908e-01f, -1.39974475e-01f, -1.82070553e-01f, -2.34085768e-01f, -1.72611266e-01f,
  -2.81171560e-01f, -2.15356946e-01f, -1.38910413e-01f, -2.55251229e-01f, -1.77180558e-01f, -1.00046344e-01f, -1.68920204e-01f, -1.66310534e-01f, -2.49215767e-01f, -2.34527826e-01f,
  -8.41205120e-02f, -1.72017887e-01f, -2.21298650e-01f, -3.63236338e-01f, -1.91588983e-01f, -2.40664408e-01f, -7.73180053e-02f, -1.85167983e-01f, -2.22090915e-01f, -8.19230899e-02f,
  -1.56458244e-01f, -4.91934791e-02f, -1.90938026e-01f, -1.75062642e-01f, -1.77024946e-01f, -2.08455935e-01f, -1.88098356e-01f, -2.56909817e-01f, -1.68138713e-01f, -2.29623839e-01f,
  -1.77532047e-01f, -1.26991302e-01f, -9.71987993e-02f, -1.51341811e-01f, -1.40941694e-01f, -1.35942087e-01f, -1.49253994e-01f, -1.49250180e-01f, -1.15498438e-01f, -1.37812421e-01f,
  -1.46635771e-01f, 1.01982336e-02f, -5.41088656e-02f, -1.35740981e-01f, 1.16732996e-02f, -9.80053246e-02f, -4.50672545e-02f, 2.45031714e-02f, -1.60247739e-02f, -6.83499724e-02f,
  -4.70525585e-02f, 3.23278783e-03f, -4.30626795e-02f, -3.46362181e-02f, -1.57258093e-01f, -1.43301189e-01f, -1.58393402e-02f, -1.38380289e-01f, -1.46441311e-01f, -5.43008670e-02f,
  -3.29249725e-02f, -2.64385846e-02f, -7.04313070e-02f, 6.25499561e-02f, 4.18691933e-02f, -7.45656565e-02f, -2.07561478e-02f, 8.31290148e-03f, 8.97299871e-03f, 4.94070910e-02f,
  -4.18934189e-02f, 8.41709673e-02f, 5.93422838e-02f, 7.78331682e-02f, 6.78831786e-02f, 1.12841137e-01f, 1.63602158e-01f, 1.25702307e-01f, 1.59167692e-01f, 1.25046685e-01f,
  5.62559552e-02f, 9.71177518e-02f, 4.07871753e-02f, 4.13752273e-02f, 1.25305772e-01f, 1.03290811e-01f, 1.40268147e-01f, 6.14070147e-02f, 1.43711418e-01f, 8.05227011e-02f,
  8.70880112e-02f, 1.53751373e-01f, 1.35563508e-01f, 7.24288821e-02f, 8.94725695e-02f, 9.70966592e-02f, 3.98306660e-02f, 5.16142137e-02f, 2.78975796e-02f, 6.31152168e-02f,
  -4.11723182e-02f, -9.64808613e-02f, -7.26525998e-03f, -1.87600148e-03f, 7.22067729e-02f, 6.40440732e-02f, -1.17901661e-01f, 2.74002533e-02f, -1.85634382e-02f, -7.73744434e-02f,
  6.28368976e-03f, -4.87228595e-02f, -6.15309440e-02f, 3.41441743e-02f, 8.07736907e-03f, -2.38772910e-02f, 8.11035838e-03f, -6.10682555e-02f, 1.43205794e-02f, -9.73867550e-02f,
  -5.29609323e-02f, 4.36809054e-03f, 9.05688778e-02f, -5.44382036e-02f, -1.89719927e-02f, -7.84498006e-02f, 2.76667364e-02f, 1.60959717e-02f, -1.96241904e-02f, 7.47141838e-02f,
  1.05916727e-02f, 2.52184570e-02f, 3.65044892e-01f, -4.39652726e-02f, -1.84158355e-01f, -2.30807081e-01f, -2.68020451e-01f, -8.58419389e-02f, -1.24734089e-01f, -5.88418804e-02f,
  -9.34229121e-02f, 1.00044213e-01f, 1.99643642e-01f, 5.77812605e-02f, 1.15008384e-01f, -7.98160117e-03f, 2.27181643e-01f, 3.15511823e-01f, 1.12933382e-01f, -1.76293239e-01f,
  -1.44200996e-01f, -9.22417194e-02f, 1.62108336e-02f, 1.49439611e-02f, 1.10062853e-01f, -1.24135017e-01f, 8.84754285e-02f, 7.15479180e-02f, -5.77025488e-02f, 1.87375993e-01f,
  2.39422590e-01f, 1.35515049e-01f, 1.19141765e-01f, 5.93872555e-02f, 6.75810575e-02f, 2.13304292e-02f, 7.41742551e-04f, 3.52926068e-02f, -4.85116020e-02f, 9.64762866e-02f,
  4.80325818e-02f, 9.42829549e-02f, 8.56383964e-02f, 3.27446423e-02f, -3.11454735e-03f, 9.25135985e-02f, 5.68336025e-02f, 2.93178558e-01f, 1.01570986e-01f, 1.33811712e-01f,
  -2.53749848e-03f, 7.01489821e-02f, 3.70365456e-02f, -3.51693295e-02f, 6.87682629e-02f, 9.86840129e-02f, 4.82308418e-02f, 6.75361231e-02f, 1.12689286e-01f, 4.61032651e-02f,
  1.99012067e-02f, -5.98802371e-03f, -7.44369477e-02f, -1.05087273e-01f, -2.20664870e-02f, 5.32032223e-03f, -1.36614153e-02f, -2.55359393e-02f, -4.48658131e-02f, -6.20577373e-02f,
  -2.63699349e-02f, 4.12006024e-03f, -2.48842537e-02f, -6.61431029e-02f, -3.94544676e-02f, -3.77638005e-02f, -8.41177478e-02f, -5.26333861e-02f, -8.91925208e-03f, -1.22624058e-02f,
  -2.14581639e-02f, 2.34191790e-02f, -1.49949700e-01f, 3.15036885e-02f, 8.82794894e-03f, 5.63259572e-02f, -4.28362787e-02f, -3.31097245e-02f, -8.84923264e-02f, -4.42730542e-03f,
  -2.08486557e-01f, 7.48763792e-03f, 9.31891873e-02f, 1.15112096e-01f, 1.15099527e-01f, 6.49871528e-02f, 3.01714186e-02f, 6.13300428e-02f, 1.84253883e-02f, 1.51245659e-02f,
  -1.97055042e-02f, -2.65331306e-02f, -3.21097975e-03f, 4.99504097e-02f, -2.63173003e-02f, -7.19317328e-03f, -3.49415913e-02f, 6.88724071e-02f, 6.01310767e-02f, 1.02570064e-01f,
  -6.78639710e-02f, -2.41618678e-02f, -7.13864043e-02f, -3.69067974e-02f, 3.29618268e-02f, -1.94819849e-02f, 6.37645423e-02f, 3.48690376e-02f, 2.77264453e-02f, -1.41045406e-01f,
  -3.14673930e-02f, -2.81925857e-01f, -1.29633367e-01f, -7.10750967e-02f, -1.97660863e-01f, -1.36583254e-01f, -1.88565448e-01f, 2.24979259e-02f, -3.42850536e-02f, -1.65038556e-01f,
  -4.22181301e-02f, 1.31052420e-01f, 2.33924463e-01f, 1.46288201e-01f, 1.03203431e-01f, -7.43085966e-02f, -1.77929446e-01f, -1.28258169e-02f, -7.66687542e-02f, -1.87801182e-01f,
  -4.48066741e-02f, -1.91242304e-02f, 1.64721627e-02f, 1.08004846e-02f, -1.06720626e-01f, -3.89638580e-02f, -8.04667324e-02f, -6.77180961e-02f, 3.52560543e-02f, -1.55424342e-01f,
  1.14186279e-01f, -1.36436805e-01f, 7.29219094e-02f, -1.70178153e-02f, -4.94638234e-02f, 7.30903819e-02f, -6.16300255e-02f, 9.83120780e-03f, 1.79438633e-04f, 7.03107044e-02f,
  -9.46517512e-02f, 5.08696400e-03f, -1.20737687e-01f, -1.11337356e-01f, -1.13100506e-01f, -9.93945971e-02f, -8.69284570e-02f, -9.66815930e-03f, 3.12525183e-02f, -5.77072650e-02f,
  -1.62949100e-01f, -3.32257617e-03f, -9.27295759e-02f, 3.96550484e-02f, -9.24948454e-02f, -3.62280458e-02f, -1.15175821e-01f, -1.45693406e-01f, 1.51902614e-02f, -9.45260450e-02f,
  1.73660964e-02f, 2.26585418e-01f, 4.59670760e-02f, -2.07883995e-02f, 3.03639844e-02f, 1.11866154e-01f, -1.99234914e-02f, -4.62110341e-02f, 1.77832730e-02f, 8.10797885e-02f,
  -6.28902614e-02f, 2.18954645e-02f, 1.18411612e-03f, -1.59095712e-02f, 9.73514244e-02f, -3.14431340e-02f, -5.83264558e-03f, -4.57207412e-02f, 5.98489977e-02f, 8.42672363e-02f,
  4.36856523e-02f, 1.29075915e-01f, 1.28335372e-01f, 7.90241733e-03f, 1.42672481e-02f, -8.13551620e-02f, 2.53174547e-02f, -1.70630012e-02f, 5.24249636e-02f, 6.44657612e-02f,
  1.76535785e-01f, 1.32583156e-01f, -3.03741768e-02f, 2.74877679e-02f, 1.92145985e-02f, 1.00898527e-01f, 9.03026462e-02f, 2.95064151e-02f, 1.07562989e-01f, 5.02627678e-02f,
  -7.77865946e-02f, 3.67281549e-02f, 2.46472144e-03f, 7.57065639e-02f, -2.56356969e-02f, 6.18062168e-02f, 1.11231491e-01f, -1.02581032e-01f, -4.31178417e-03f, 1.97808333e-02f,
  2.21130699e-02f, -3.44781578e-02f, 9.34622213e-02f, 1.08413417e-02f, 4.23361212e-02f, 1.71630412e-01f, 8.09977651e-02f, 3.86059992e-02f, 4.79846410e-02f, 9.33636278e-02f,
  9.33882073e-02f, 1.14755690e-01f, -2.71575544e-02f, 7.02385753e-02f, 2.41502300e-01f, 1.84415236e-01f, 2.81571478e-01f, 8.70193467e-02f, 2.45086513e-02f, 2.51977205e-01f,
  2.77976036e-01f, -2.94030774e-02f, -1.06468663e-01f, -1.86534777e-01f, -1.86307833e-01f, 6.92189187e-02f, 3.10605066e-03f, -3.82813513e-01f, -3.67395371e-01f, -1.44909695e-01f,
  -1.12726621e-01f, -9.29445177e-02f, -1.40543804e-01f, -1.26261413e-01f, -2.33551785e-02f, 2.35393571e-04f, 4.69105318e-02f, 9.69236121e-02f, 6.72055632e-02f, -1.01072751e-01f,
  1.27765596e-01f, 7.81129450e-02f, -1.87559083e-01f, -7.50621632e-02f, 3.31287761e-03f, -6.40391409e-02f, -3.73967625e-02f, -8.09848234e-02f, -4.85589541e-02f, 3.32487770e-03f,
  -4.32245284e-02f, -9.55550000e-02f, 1.20043727e-02f, -1.03000417e-01f, 3.03636841e-03f, 2.44836952e-03f, -1.28064230e-01f, -1.20385475e-01f, -5.88928424e-02f, -4.19446826e-02f,
  5.74032292e-02f, 9.93858576e-02f, 1.65637791e-01f, -7.79883638e-02f, -1.68199558e-03f, -1.49095863e-01f, 1.74813773e-02f, -7.54910186e-02f, -8.11575204e-02f, -3.27400304e-02f,
  -3.29995453e-02f, -1.98800322e-02f, 2.31415909e-02f, 3.43545079e-02f, 2.15527136e-02f, 4.74602729e-02f, -5.29798754e-02f, 6.76968843e-02f, -7.48631358e-02f, -4.93886694e-02f,
  9.01763588e-02f, 5.10479957e-02f, 2.82806233e-02f, 1.34239554e-01f, -8.99072737e-02f, -5.08648641e-02f, -1.07176164e-02f, -2.17315387e-02f, 1.49957286e-02f, -2.96542328e-02f,
  6.22072518e-02f, -1.65372007e-02f, 1.12964138e-01f, -3.12957913e-02f, 6.78438693e-02f, -4.71934117e-02f, -4.04610224e-02f, -3.09118871e-02f, 1.23671461e-02f, 2.41005868e-02f,
  8.73928831e-04f, -1.43475413e-01f, 1.16913550e-01f, 5.03179133e-02f, 5.31574525e-02f, -3.16559710e-02f, 3.93768288e-02f, -3.27716046e-03f, -2.59887520e-02f, -3.02631948e-02f,
  7.08255991e-02f, 1.29567506e-02f, 5.47184013e-02f, 1.77827338e-03f, 1.50097460e-02f, 1.01925641e-01f, 1.40440434e-01f, 6.83285436e-03f, -1.23958373e-02f, -4.91586737e-02f,
  2.84983851e-02f, 1.62183106e-01f, 1.14289045e-01f, 3.76804434e-02f, 4.47277054e-02f, 1.26088694e-01f, 1.24785773e-01f, 4.83822487e-02f, 1.40375108e-01f, 1.90417126e-01f,
  5.34386635e-01f, -1.39501825e-01f, -2.11059481e-01f, 1.97068259e-01f, -1.30887166e-01f, -1.89853311e-01f, -1.52824476e-01f, 1.34253288e-02f, 1.16770178e-01f, -1.90694407e-02f,
  -3.08892261e-02f, 7.85031840e-02f, 1.11215986e-01f, -4.85416083e-03f, -4.83549833e-02f, -1.67753324e-01f, -2.95187328e-02f, 1.92939192e-02f, 7.76857883e-02f, 1.07010268e-01f,
  -6.21127933e-02f, -8.22564736e-02f, 9.18665305e-02f, 7.50513971e-02f, 8.12489465e-02f, 1.96998850e-01f, -1.52080134e-01f, -1.83548350e-02f, -1.57315433e-01f, 6.19306825e-02f,
  2.06234798e-01f, 1.60330888e-02f, -1.20379142e-01f, 2.56544016e-02f, 8.46924260e-02f, 1.35723293e-01f, 1.70794174e-01f, 8.57219696e-02f, 5.65176904e-02f, 5.82033098e-02f,
  2.59150341e-02f, -1.81141198e-02f, -5.08365803e-04f, -7.28129148e-02f, 7.76748657e-02f, 1.83001608e-02f, -2.84648500e-02f, 1.22587644e-01f, 3.68861817e-02f, 9.28287730e-02f,
  -9.06829834e-02f, -8.04375410e-02f, 7.73000792e-02f, -4.75695953e-02f, 5.08955978e-02f, 9.19281542e-02f, 1.13933571e-02f, 6.44528717e-02f, 1.44423842e-01f, 1.97090700e-01f,
  8.14355612e-02f, 1.60437562e-02f, -7.75179341e-02f, 2.55394951e-02f, 9.87703353e-02f, -7.63695687e-02f, -2.05718670e-02f, 3.44209187e-02f, -1.19466633e-02f, 5.30000739e-02f,
  -5.62155321e-02f, 1.87456235e-02f, -4.06817719e-02f, 4.93885055e-02f, 6.69910237e-02f, -1.82026830e-02f, -1.49483951e-02f, -2.04593614e-02f, -8.02448094e-02f, -1.52318124e-02f,
  -2.24040188e-02f, -1.20692179e-01f, -7.83642754e-03f, -5.03040031e-02f, -4.87929508e-02f, 1.56005807e-02f, -2.38637310e-02f, -1.13530748e-01f, -6.56164959e-02f, 1.71213085e-03f,
  2.44060785e-01f, -3.54892075e-01f, 1.46784022e-01f, 1.65628747e-03f, 1.03423320e-01f, -6.84511662e-02f, 7.53694633e-03f, -4.23612036e-02f, 1.54404435e-02f, 3.46602090e-02f,
  -4.65299673e-02f, 1.11181222e-01f, -8.98177363e-03f, -4.34675813e-02f, 5.07116839e-02f, 1.79365389e-02f, -8.23071525e-02f, -8.11179448e-03f, 1.13325473e-02f, 3.79886366e-02f,
  -7.27880597e-02f, 1.48578912e-01f, 2.01043129e-01f, 3.62717845e-02f, 9.62120220e-02f, 1.45762295e-01f, 1.27096221e-01f, 1.30082056e-01f, 1.78729475e-01f, 1.96833268e-01f,
  -1.81071341e-01f, -3.90151769e-01f, -8.43426585e-02f, -7.02952296e-02f, -9.55442786e-02f, 9.84000117e-02f, -6.99199364e-02f, 8.02227259e-02f, 1.15595587e-01f, -1.25184059e-01f,
  -1.37103543e-01f, 8.98708254e-02f, 3.15451920e-02f, 1.28133953e-01f, 5.63319437e-02f, -8.70363563e-02f, -5.53704202e-02f, 1.99314728e-01f, 4.15248126e-01f, 2.31054336e-01f,
  3.88111584e-02f, -8.58877301e-02f, 1.35431007e-01f, 7.07557797e-02f, -1.48822397e-01f, 2.03076273e-01f, -1.60008371e-01f, -1.19584799e-01f, -5.81745692e-02f, -2.43359134e-01f,
  -6.11269362e-02f, -2.97277689e-01f, 1.13371834e-01f, -1.90321170e-02f, -5.77880107e-02f, 1.37117520e-01f, 8.96455646e-02f, -3.54087390e-02f, -5.41973859e-02f, -1.31512759e-02f,
  -1.03887193e-01f, 2.34512463e-02f, -5.53468205e-02f, 1.15897413e-02f, 4.04363411e-04f, 7.37585723e-02f, -2.98265629e-02f, -1.92766469e-02f, 5.74959256e-02f, -3.38295400e-02f,
  -4.41211537e-02f, -1.34535450e-02f, -6.61214590e-02f, -3.36215980e-02f, 3.59661132e-02f, 1.02205612e-01f, 1.25875627e-03f, -3.50681506e-02f, 3.96786928e-02f, -1.74217820e-02f,
  1.45521373e-01f, -5.25013730e-02f, -3.53193446e-03f, 3.43184099e-02f, -4.27006780e-05f, -4.68911007e-02f, 4.44729514e-02f, -2.15371363e-02f, 3.25296819e-02f, 1.12173352e-02f,
  5.97055592e-02f, 9.32749510e-02f, 1.52900547e-03f, 2.90407110e-02f, -2.29545534e-02f, 5.22880219e-02f, -5.49948774e-02f, 3.66109237e-02f, 3.08115464e-02f, -8.30721576e-03f,
  8.28126818e-03f, 2.31862814e-05f, -2.22373568e-02f, 4.80121858e-02f, 1.83325745e-02f, 8.86908248e-02f, -4.68688048e-02f, 3.64251323e-02f, 4.58349474e-03f, -9.42927320e-03f,
  1.36156812e-01f, -8.49338248e-02f, -8.11454840e-03f, 8.30624402e-02f, -5.46849100e-03f, 5.23645133e-02f, -4.12170254e-02f, 3.47899087e-02f, -1.00399606e-01f, 2.00597867e-02f,
  6.67756516e-03f, -4.20672586e-03f, -1.40159696e-01f, 3.04223667e-03f, 1.31475896e-01f, -7.60564283e-02f, -5.40121645e-02f, 1.01932980e-01f, 9.96161997e-03f, 8.35003145e-03f,
  1.49077103e-02f, 2.03073040e-01f, 3.34219158e-01f, 9.89614427e-02f, 9.35101584e-02f, 1.92545727e-01f, 1.24745704e-01f, 3.12167499e-02f, 1.88864157e-01f, 1.91315159e-01f,
  -1.16189666e-01f, -9.82787833e-02f, 1.53317437e-01f, -1.82895586e-02f, 4.67268489e-02f, -4.49141487e-02f, -1.09819397e-02f, -1.13760844e-01f, -2.04290241e-01f, -1.13949843e-01f,
  -1.93760619e-01f, -1.30400211e-01f, -2.18467694e-02f, 2.54885871e-02f, -4.49686944e-02f, 6.07440099e-02f, 6.49513155e-02f, 1.31865010e-01f, -1.13603048e-01f, -2.12546542e-01f,
  -5.43839745e-02f, -3.66575047e-02f, 1.77187398e-02f, -1.67047024e-01f, 1.33460477e-01f, 8.73257965e-03f, 1.54160485e-01f, 1.15785208e-02f, 1.17426947e-01f, 3.08333248e-01f,
  6.16645999e-02f, -5.99311143e-02f, 1.99238732e-02f, -8.47246349e-02f, 2.94104163e-02f, -8.84183571e-02f, -8.33811983e-02f, -4.46274392e-02f, 2.24430505e-02f, 1.35382637e-02f,
  -3.43807973e-02f, 1.87032800e-02f, 5.40663600e-02f, -7.34906718e-02f, -3.97654139e-02f, -1.53440386e-02f, -7.49265105e-02f, -7.61530772e-02f, 2.14915518e-02f, -7.76469335e-02f,
  -2.87376955e-04f, 1.06729656e-01f, 1.26780704e-01f, 1.83481816e-02f, 5.82677200e-02f, -3.69724408e-02f, 1.57828964e-02f, 6.77949414e-02f, -5.82165830e-03f, 1.02281407e-01f,
  -1.28531279e-02f, 1.84299678e-01f, 3.77886780e-02f, 6.41630739e-02f, 5.19392602e-02f, -1.20330276e-02f, 2.67172754e-02f, 1.70613170e-01f, 1.88759118e-02f, 2.66401339e-02f,
  1.08260356e-01f, -4.42580432e-02f, 1.41266957e-01f, -3.17804664e-02f, 7.55075663e-02f, 9.56679415e-03f, 1.04193032e-01f, 1.11272223e-01f, 3.48827429e-02f, -4.56092739e-03f,
  -2.29523592e-02f, 8.90444145e-02f, 7.50475004e-02f, 5.96120246e-02f, -2.40265601e-03f, 1.03364557e-01f, 4.69135456e-02f, 7.20438128e-03f, -2.12128665e-02f, -4.76534367e-02f,
  -2.53825128e-01f, -4.13718484e-02f, -7.02492008e-03f, 5.77975158e-03f, 7.21118897e-02f, 3.32122110e-02f, -2.60416046e-02f, -1.94104691e-03f, -7.02576116e-02f, -7.73381516e-02f,
  -8.24133307e-02f, -8.86738207e-03f, -8.04612488e-02f, 1.54367788e-03f, -3.24284844e-02f, -2.45196056e-02f, 6.66846661e-03f, -5.42920940e-02f, -2.18471163e-03f, -1.18474156e-01f,
  -1.49080597e-06f, -5.37331663e-02f, -4.91552204e-02f, 1.49804112e-02f, 3.14552225e-02f, -4.27783243e-02f, -6.97207684e-03f, -7.47094601e-02f, -7.67196715e-02f, -2.27229089e-01f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  4.18085903e-01f, -1.13619231e-01f, 4.30072069e-01f, 1.63293362e-01f, 2.39443541e-01f, 3.19428295e-01f, 4.74125028e-01f, 2.37176448e-01f, -5.92962429e-02f, -4.19420525e-02f,
  -1.70503020e-01f, -2.89822966e-01f, -2.34238371e-01f, -2.86980301e-01f, -9.39745083e-03f, 1.08543225e-01f, 1.18389450e-01f, 2.06221208e-01f, 2.91491747e-01f, 1.16966046e-01f,
  -1.71969205e-01f, 4.23610620e-02f, 1.10233240e-01f, 5.76303117e-02f, -5.89132793e-02f, -1.33699790e-01f, 6.92006499e-02f, 9.43451822e-02f, 1.48866810e-02f, -7.45795891e-02f,
  6.68432936e-02f, 1.85613602e-01f, -6.98960107e-03f, -1.30031049e-01f, 2.08741929e-02f, -7.52787478e-03f, 1.03914574e-01f, 1.71065237e-03f, -6.11421838e-02f, -4.46431078e-02f,
  -1.09853916e-01f, 1.45976832e-02f, 1.02341399e-02f, -2.10034531e-02f, 1.00569949e-01f, 2.04665177e-02f, -6.94085881e-02f, 1.41689911e-01f, 5.74204996e-02f, -3.60923656e-03f,
  -1.91433161e-01f, 8.33315998e-02f, 1.80773959e-01f, 2.18301527e-02f, -8.35742615e-03f, -2.98492108e-02f, 6.52936548e-02f, -3.26420292e-02f, -1.99091453e-02f, -5.02598248e-02f,
  -1.00908980e-01f, 7.43026361e-02f, 1.14137709e-01f, 1.60573106e-02f, -2.57785283e-02f, -8.30467418e-02f, 3.76133248e-02f, -1.92653816e-02f, 2.88953986e-02f, 1.40305571e-02f,
  1.22821718e-01f, 1.67711660e-01f, 1.01428404e-01f, 1.41945139e-01f, 1.38980253e-02f, 1.39532864e-01f, -5.79048647e-03f, -7.64753520e-02f, 8.89126062e-02f, 1.15176916e-01f,
  5.44943623e-02f, 8.45029801e-02f, 2.49527264e-02f, 4.58353907e-02f, 8.68449211e-02f, 3.94009538e-02f, -3.52748446e-02f, -5.59166335e-02f, 3.31669673e-02f, 1.16344966e-01f,
  -1.04427673e-01f, 1.50337473e-01f, -1.56856284e-01f, -8.15901309e-02f, -6.14904389e-02f, -9.23153460e-02f, 1.42589081e-02f, 1.82614438e-02f, -5.63883185e-02f, 2.23882571e-02f,
  -2.12064646e-02f, 9.07359179e-03f, 3.04783229e-02f, 4.31011841e-02f, 1.33069500e-01f, 5.15861884e-02f, -1.10265337e-01f, -7.00313151e-02f, -5.31111434e-02f, -1.13162473e-01f,
  -5.44476584e-02f, 1.56978574e-02f, 2.16201678e-01f, 9.97645780e-02f, 6.75067306e-02f, -1.00910300e-02f, -2.61863135e-02f, 9.84931067e-02f, 1.45088151e-01f, 1.84703618e-03f,
  3.41273934e-01f, 5.09237587e-01f, -1.68259460e-02f, -6.50103092e-02f, -2.38161847e-01f, -2.58542538e-01f, 3.57452482e-01f, 2.35196933e-01f, -1.49633229e-01f, 2.28296414e-01f,
  -5.88039160e-02f, -5.38167417e-01f, -2.18121842e-01f, -1.90783322e-01f, 1.55434102e-01f, 2.54331738e-01f, 1.96597189e-01f, -3.37183960e-02f, -3.55724961e-01f, -1.22475356e-01f,
  -1.66019816e-02f, 1.24578722e-01f, 2.20379889e-01f, 1.94290221e-01f, -3.60033177e-02f, -3.88466537e-01f, 5.87206855e-02f, 7.63422698e-02f, 1.15256280e-01f, 1.60928350e-02f,
  -1.74207643e-01f, 2.86686033e-01f, -3.46752584e-01f, -1.36662483e-01f, -1.80272460e-01f, -9.60547701e-02f, 1.36469200e-01f, -1.51361346e-01f, -2.01786552e-02f, 9.03077831e-04f,
  -1.98795021e-01f, -1.11773036e-01f, -2.43298069e-01f, -2.88359309e-03f, -2.21553311e-01f, -1.00992374e-01f, 1.74846902e-01f, 1.82423234e-01f, 4.78013046e-02f, 1.52177364e-01f,
  -1.59965813e-01f, -4.54581939e-02f, 9.62792896e-03f, 2.62796246e-02f, 1.07447922e-01f, -1.29224166e-01f, -8.89384672e-02f, -5.12464643e-02f, 4.61753495e-02f, 1.06801264e-01f,
  5.74182682e-02f, -7.38732237e-03f, -1.40389666e-01f, 9.45671871e-02f, 6.53773025e-02f, -5.69357947e-02f, -5.28559908e-02f, 1.75380394e-01f, -5.59165850e-02f, 9.74565148e-02f,
  -1.66806635e-02f, -4.85307351e-02f, -9.58873183e-02f, 7.61120543e-02f, 8.33661295e-03f, 7.50105502e-03f, -7.99625292e-02f, 1.24388710e-01f, 3.96580175e-02f, -6.68540271e-03f,
  1.22564472e-02f, -5.57256024e-03f, 6.29480705e-02f, -2.24699471e-02f, -5.22536971e-03f, -2.78823450e-02f, -3.47324274e-02f, 2.90069799e-03f, 7.29595870e-02f, -3.24397199e-02f,
  -1.88231289e-01f, -2.83454746e-01f, 1.14668652e-01f, -5.63381054e-02f, -4.36623245e-02f, -2.77293418e-02f, 1.48937935e-02f, -3.09250299e-02f, -7.33548449e-03f, 8.36982802e-02f,
  1.56884466e-03f, -4.81167324e-02f, 5.15084565e-02f, 9.88995060e-02f, -1.17664739e-01f, 3.18644792e-02f, 7.51998946e-02f, -1.02452055e-01f, 2.85365782e-03f, -3.08094677e-02f,
  2.11051047e-01f, 1.46999732e-02f, 2.77033783e-02f, -3.20371725e-02f, -6.82023019e-02f, -7.01489151e-02f, -5.03132641e-02f, -1.93259880e-01f, -7.16602197e-03f, 2.90853739e-01f,
  -8.47137451e-01f, 1.53389603e-01f, -1.55650318e-01f, -5.04955530e-01f, -1.06852964e-01f, -2.63941675e-01f, -1.04033418e-01f, -7.35729337e-02f, -3.11978430e-01f, -1.85330808e-01f,
  4.87045161e-02f, -8.14579614e-03f, -3.47391367e-02f, -1.07839433e-02f, -9.46365073e-02f, -1.97548702e-01f, -2.89597362e-01f, -3.39290112e-01f, -1.83797330e-01f, 3.20683941e-02f,
  1.97218806e-02f, -4.25331116e-01f, -4.88812864e-01f, -1.76893219e-01f, -1.14987874e-02f, -9.45371911e-02f, -2.64286250e-01f, -2.13193849e-01f, -3.29869203e-02f, -3.84050757e-01f,
  2.16381624e-01f, -1.06670335e-01f, -1.00962132e-01f, -1.76359370e-01f, -1.02241384e-02f, 2.62224562e-02f, -3.86148803e-02f, -7.95912817e-02f, 2.66238078e-02f, 1.28201872e-01f,
  -9.39995721e-02f, 2.09698662e-01f, 2.12909598e-02f, 8.42759088e-02f, -1.16866976e-02f, 6.81699160e-03f, -2.81217415e-02f, 3.10219452e-02f, 2.53668781e-02f, 2.03068167e-01f,
  2.16001496e-01f, -2.43638866e-02f, 6.88829944e-02f, 1.26667947e-01f, 8.40078220e-02f, 3.29820765e-03f, 1.73783451e-01f, 1.55165270e-01f, -4.57395017e-02f, 3.99780273e-02f,
  4.53091823e-02f, 1.51106745e-01f, 4.47283732e-04f, 1.17817298e-01f, 1.78893469e-02f, 6.29384443e-02f, -4.42970842e-02f, 6.13747425e-02f, 4.83499877e-02f, 7.53937475e-03f,
  9.90624800e-02f, -7.25571737e-02f, 6.74986988e-02f, -7.55848661e-02f, -5.09683490e-02f, -1.36636764e-01f, -1.12112746e-01f, 1.28698528e-01f, 6.11314215e-02f, -1.60846680e-01f,
  2.47465204e-02f, 1.01877814e-02f, 4.52125678e-03f, -2.63036061e-02f, -1.33261368e-01f, 6.59193099e-02f, 5.37280589e-02f, 6.26153350e-02f, 1.34233281e-01f, -1.91768557e-02f,
  -4.08461578e-02f, -2.49262199e-01f, -4.22386527e-02f, 8.12464580e-02f, 3.09429578e-02f, 1.05036855e-01f, -6.59110695e-02f, 4.81035747e-02f, 9.48626325e-02f, 1.17859073e-01f,
  2.43980493e-02f, 1.28385305e-01f, 3.14999111e-02f, -2.39623501e-03f, -1.99402850e-02f, 2.19351500e-02f, 6.23557344e-02f, -5.20923622e-02f, -4.18142453e-02f, 1.55394554e-01f,
  1.81841075e-01f, 1.27173588e-02f, 5.86896092e-02f, 1.13065206e-01f, 1.05430946e-01f, -2.53675804e-02f, 1.66912913e-01f, 1.53777182e-01f, -5.72384149e-02f, 2.38551944e-01f,
  -3.65859002e-01f, 3.72229628e-02f, 8.66482630e-02f, -2.99887598e-01f, 1.43771231e-01f, 2.86114395e-01f, -1.70244407e-02f, 5.90287335e-02f, -5.74013926e-02f, -7.57003501e-02f,
  2.57001817e-01f, 5.19925095e-02f, -2.92123735e-01f, -2.64265426e-02f, -1.67388707e-01f, -2.64358014e-01f, -2.70604104e-01f, -1.52430519e-01f, 1.64330229e-01f, 1.70121118e-01f,
  1.07780308e-01f, -1.22100770e-01f, -1.06396064e-01f, -1.85317576e-01f, -9.93129611e-02f, -1.42994642e-01f, -3.08997691e-01f, -1.34596691e-01f, -2.43652854e-02f, -4.08886135e-01f,
  6.05550446e-02f, 2.42738679e-01f, 1.96747303e-01f, -1.02064135e-02f, -9.51028615e-03f, -2.17912681e-02f, -1.88691393e-02f, -1.33303434e-01f, 1.23091064e-01f, -3.13129500e-02f,
  -1.32674277e-02f, 1.32737994e-01f, -6.53898716e-02f, 1.34891391e-01f, -1.38028786e-01f, -1.39632663e-02f, 2.20383666e-02f, 1.41816720e-01f, -3.50067690e-02f, 2.25434199e-01f,
  -1.17928244e-01f, -2.56129261e-02f, -1.52727082e-01f, -1.47613898e-01f, 1.29048437e-01f, -4.57017124e-02f, 6.02670945e-02f, 5.70498109e-02f, -7.96808451e-02f, -5.14925838e-01f,
  -4.19264957e-02f, 7.92075247e-02f, 2.22833991e-01f, 4.04532067e-02f, 1.74136646e-02f, 6.26220107e-02f, -7.36028478e-02f, 3.73826333e-04f, 5.91347814e-02f, -1.36622339e-01f,
  1.09456010e-01f, -1.99211482e-02f, -5.50854430e-02f, -1.16429761e-01f, -1.01740547e-01f, -3.33407870e-03f, 7.53335305e-04f, -1.22378968e-01f, -1.34479091e-01f, -3.72654088e-02f,
  -3.29963900e-02f, 1.09421223e-01f, -1.32562192e-02f, 1.10497072e-01f, 6.39115348e-02f, -1.54842466e-01f, 5.44851497e-02f, 4.33922932e-02f, 3.53134214e-03f, 1.59833729e-02f,
  -2.90768415e-01f, 1.62631840e-01f, -2.03361690e-01f, 1.26160771e-01f, 1.91605370e-02f, 1.65225808e-02f, 5.07256528e-03f, 1.10152178e-01f, 1.58703290e-02f, -7.31174415e-03f,
  9.19407755e-02f, -4.80011515e-02f, -2.47182637e-01f, 4.04974148e-02f, -4.98718359e-02f, -2.79398058e-02f, -8.29522312e-02f, -4.16509807e-02f, 1.24053061e-01f, 1.50148109e-01f,
  -1.45784870e-01f, -2.80733317e-01f, -3.09080184e-01f, -1.42160833e-01f, -1.73445721e-03f, -1.98143214e-01f, -1.89846084e-01f, -1.68130770e-01f, -2.34769464e-01f, -5.26926041e-01f,
  5.29486477e-01f, 1.98255599e-01f, 3.92105788e-01f, 3.99561197e-01f, 3.19398254e-01f, 3.76929402e-01f, 3.29907387e-01f, 2.43163228e-01f, 2.40083098e-01f, 2.23301262e-01f,
  1.39052585e-01f, 6.84248880e-02f, 1.60209179e-01f, 1.47593454e-01f, 9.07579288e-02f, 1.97202429e-01f, 1.11523442e-01f, 1.11267336e-01f, 2.15636089e-01f, 3.22266102e-01f,
  1.27119273e-01f, 3.30075696e-02f, 1.47164047e-01f, 9.79516357e-02f, -2.93532386e-02f, 4.69641648e-02f, 1.07559800e-01f, -1.97539590e-02f, 1.03835404e-01f, -8.28974321e-02f,
  1.32494926e-01f, 2.33154923e-01f, 2.91067101e-02f, -1.10430457e-01f, -1.70408338e-01f, -2.22150773e-01f, 9.55691654e-03f, -1.30149260e-01f, -6.70764521e-02f, -7.84667209e-02f,
  -3.90590131e-02f, -1.95546538e-01f, -1.71571761e-01f, -1.26917332e-01f, -5.72927296e-02f, -9.68440399e-02f, -5.84610850e-02f, 9.56832767e-02f, 1.79026514e-01f, -5.11928909e-02f,
  -1.73435491e-02f, 4.66330871e-02f, 4.12255265e-02f, 6.16857968e-02f, 1.22128017e-02f, -1.27782285e-01f, -8.27492252e-02f, -5.76270744e-04f, 7.31733516e-02f, 2.48967856e-02f,
  2.02614084e-01f, 1.09256990e-01f, 4.42910194e-02f, 1.96144674e-02f, 2.69307848e-02f, -4.88835163e-02f, -4.51048054e-02f, 1.21274054e-01f, 1.00337397e-02f, -5.91866933e-02f,
  -1.85460597e-02f, 9.18207169e-02f, -3.10996398e-02f, -7.93650094e-03f, 4.25533988e-02f, -1.05909118e-02f, -7.86132887e-02f, -6.96170330e-02f, -1.43051343e-02f, -1.32224532e-02f,
  -2.51985360e-02f, -8.61881748e-02f, 4.05334169e-04f, -1.77287385e-01f, -8.19872096e-02f, 9.27765518e-02f, 4.01487052e-02f, -4.09573726e-02f, -1.11680686e-01f, 3.31171565e-02f,
  -2.43566409e-01f, 3.66796777e-02f, -1.56920161e-02f, -2.55121123e-02f, -3.87678072e-02f, -1.84407607e-01f, 3.94703671e-02f, 7.10905865e-02f, -1.01885974e-01f, 3.10408566e-02f,
  1.35163656e-02f, -1.55259773e-01f, -1.59552023e-01f, -1.07836969e-01f, -6.71121776e-02f, -1.05905812e-02f, -1.09674074e-01f, 1.66996554e-01f, 2.63213851e-02f, 5.06012887e-02f,
  -1.29437819e-02f, 1.59665003e-01f, 1.39726311e-01f, 1.10348262e-01f, -1.94818694e-02f, 2.19328869e-02f, -6.83593377e-02f, -5.40225813e-03f, 9.48327407e-02f, -1.54398382e-01f,
  5.05591393e-01f, -3.70543540e-01f, -2.99300343e-01f, 1.37211025e-01f, -3.06628942e-01f, -6.55518100e-02f, -3.56554091e-01f, 9.78661329e-02f, 4.48561385e-02f, -3.93398613e-01f,
  -1.92331634e-02f, 3.92370254e-01f, 1.17123716e-01f, 1.27648920e-01f, 1.91337883e-01f, -3.11780334e-01f, -2.82409638e-01f, 1.49333224e-01f, 2.99578071e-01f, 1.71821550e-01f,
  2.50164159e-02f, 1.37769938e-01f, 2.64814347e-01f, 1.46526575e-01f, -2.27469802e-01f, -3.97517122e-02f, -3.70070487e-01f, -1.11769259e-01f, -2.01573759e-01f, -4.51884121e-01f,
  -2.11772248e-01f, -8.04707687e-03f, -5.36568649e-02f, 5.47243804e-02f, -1.54140770e-01f, -4.06718701e-02f, -7.84744397e-02f, -1.84807882e-01f, -1.18317276e-01f, -1.11931995e-01f,
  -6.74182698e-02f, 3.31348963e-02f, 1.54216811e-01f, 5.55211492e-02f, -1.82883616e-03f, 5.35977408e-02f, 3.21958475e-02f, 2.26825103e-02f, -4.99950014e-02f, -1.27516344e-01f,
  -2.47126054e-02f, -9.00771692e-02f, -8.23148414e-02f, -1.12841651e-01f, 1.28463492e-01f, 1.06024496e-01f, -1.90881029e-01f, 1.72125828e-02f, -3.18441652e-02f, -3.74169707e-01f,
  -5.13914153e-02f, -3.63455527e-03f, -1.02179281e-01f, 2.70820479e-03f, -3.06078908e-03f, -6.24764850e-03f, 9.66435391e-03f, 1.37329707e-02f, 4.54881787e-03f, -3.29615101e-02f,
  2.14873012e-02f, -1.23034589e-01f, -5.41285761e-02f, -2.87575684e-02f, 2.31279600e-02f, -7.16167782e-03f, 1.57911479e-02f, 9.97741800e-03f, 4.45109233e-03f, 2.83628376e-03f,
  1.95458215e-02f, 7.27646649e-02f, -3.50759178e-02f, 6.66148290e-02f, -1.10449575e-01f, -4.35398668e-02f, 1.83124263e-02f, 1.09742515e-01f, 4.06982303e-02f, -2.01538540e-02f,
  1.29471987e-01f, 4.89728972e-02f, -1.47824913e-01f, 9.60143507e-02f, -7.66793936e-02f, -1.00659192e-01f, -6.02491871e-02f, -6.01568371e-02f, 3.25290300e-02f, 5.65267242e-02f,
  6.47818893e-02f, 1.05574109e-01f, -2.95413360e-02f, -8.26021135e-02f, -1.29133180e-01f, -1.97942983e-02f, -2.06812415e-02f, 5.46764508e-02f, 5.45847081e-02f, 5.07299006e-02f,
  -5.59399985e-02f, -1.90980081e-02f, 1.88240066e-01f, 2.30447464e-02f, 1.69811502e-01f, 1.44039348e-01f, -9.77998003e-02f, -6.85833842e-02f, 1.61168620e-01f, -1.86258450e-01f,
  4.01871890e-01f, -1.78679958e-01f, -6.35610759e-01f, 1.27351314e-01f, -2.48783708e-01f, -1.71466067e-01f, -6.08698390e-02f, 2.40710691e-01f, 4.27005775e-02f, -2.07553014e-01f,
  -1.03633434e-01f, 1.54331774e-01f, 4.04910333e-02f, 3.33406180e-02f, 1.04088604e-01f, -3.01651180e-01f, -3.65530998e-01f, -1.29180282e-01f, 2.40200028e-01f, 7.47988373e-02f,
  1.04417533e-01f, 4.52495366e-02f, 1.79745793e-01f, 1.31019756e-01f, -2.41376221e-01f, -1.91349074e-01f, -3.43618810e-01f, -2.75358677e-01f, -2.24320963e-01f, -4.13621783e-01f,
  -5.03924966e-01f, -6.28945678e-02f, 1.20558843e-01f, 1.78762019e-01f, -3.25331278e-02f, 1.55564219e-01f, 1.04462214e-01f, 1.06702484e-01f, 1.63886070e-01f, 5.04295304e-02f,
  2.77115926e-02f, -4.12157737e-03f, 7.53938481e-02f, 2.89184246e-02f, 2.27826331e-02f, 4.66251485e-02f, 3.58678102e-02f, 3.12902890e-02f, -1.21023916e-01f, -3.54651250e-02f,
  -7.21145347e-02f, 2.79520340e-02f, -1.99390259e-02f, 3.01695662e-03f, 9.44765806e-02f, -5.00955060e-03f, -7.14035258e-02f, 6.57468215e-02f, -9.16884169e-02f, -7.05222413e-02f,
  3.77462469e-02f, -4.86535765e-02f, -7.43085593e-02f, 4.63979095e-02f, 7.01453686e-02f, 2.84944382e-02f, -7.46446326e-02f, -7.15571046e-02f, 6.29589483e-02f, -1.56051964e-02f,
  9.79361031e-03f, -2.72456892e-02f, 1.54268458e-01f, 3.22344946e-03f, -5.66534325e-02f, -6.50281385e-02f, -3.52880917e-02f, -7.52250552e-02f, -3.33110951e-02f, 7.28806853e-02f,
  9.20878127e-02f, -7.83838630e-02f, -1.17784359e-01f, 5.75657487e-02f, -1.59493253e-01f, 2.11761855e-02f, -1.40282035e-01f, 1.78063437e-02f, 8.97647068e-02f, -2.98199151e-02f,
  1.02426894e-01f, -1.11530954e-02f, -9.10744369e-02f, 1.40244171e-01f, 4.43595573e-02f, -2.90887840e-02f, -9.40615386e-02f, 2.39060707e-02f, -4.22345335e-03f, -2.37006391e-03f,
  -4.24316488e-02f, -4.67385277e-02f, -1.28827065e-01f, 8.35926831e-02f, 1.62307769e-01f, 5.17303450e-03f, -1.52641870e-02f, -3.13754529e-02f, -4.42199968e-02f, -1.94631264e-01f,
  -1.24672160e-01f, 1.75194114e-01f, 1.53920278e-01f, 4.28652577e-02f, -6.10683532e-03f, 6.56715259e-02f, -1.87202185e-01f, -5.34320772e-02f, -2.21717600e-02f, 7.58977905e-02f,
  -2.42311269e-01f, -1.85282547e-02f, -1.51833788e-01f, 2.97810167e-01f, 2.53731579e-01f, -4.01680853e-04f, -4.33643498e-02f, -1.10543907e-01f, 1.97540104e-01f, 1.33109927e-01f,
  1.19572505e-01f, 2.95967788e-01f, 2.34559700e-01f, 4.80321683e-02f, -2.93078244e-01f, 9.66881588e-02f, 1.56009436e-01f, -1.59695417e-01f, -2.46375397e-01f, -5.54439276e-02f,
  2.90450633e-01f, 2.58672126e-02f, -1.19973660e-01f, -8.74921978e-02f, 3.39117378e-01f, 2.95842975e-01f, 7.04082847e-02f, 2.79616378e-02f, 4.89430921e-03f, 2.90891647e-01f,
  -2.22233593e-01f, -2.03855351e-01f, -4.52848636e-02f, 2.92714208e-01f, -1.12806745e-02f, -3.37621331e-01f, -6.77893087e-02f, -1.88291460e-01f, -1.40128851e-01f, -6.23808242e-02f,
  9.08617675e-02f, -1.72554210e-01f, 1.80921733e-01f, -8.08117539e-03f, -1.65630847e-01f, -8.77791196e-02f, -1.50377601e-02f, -1.46549702e-01f, -2.72944629e-01f, -1.12854548e-01f,
  3.07966769e-01f, 1.71911523e-01f, -6.23765998e-02f, -8.50455984e-02f, -1.32460624e-01f, 2.23235965e-01f, -2.53773063e-01f, -4.73865345e-02f, -2.61311173e-01f, -1.43206343e-01f,
  1.67170748e-01f, -1.03214361e-01f, -6.84994310e-02f, -1.06437705e-01f, 1.16987504e-01f, 8.28748345e-02f, 8.48300606e-02f, 1.65082037e-01f, 4.98797409e-02f, 2.47960575e-02f,
  1.05526559e-02f, -1.24836937e-01f, -2.25963473e-01f, -5.83356358e-02f, 1.32559195e-01f, -6.88073933e-02f, -4.83301431e-02f, -9.80356559e-02f, 3.09268404e-02f, -8.03704336e-02f,
  7.27098063e-02f, -1.03063680e-01f, -1.17725469e-01f, 2.01086439e-02f, 5.63321859e-02f, -1.70214684e-04f, -7.51614422e-02f, -2.29658727e-02f, -8.47383961e-02f, 5.57945855e-02f,
  -1.61792144e-01f, -8.60825926e-02f, 1.06576025e-01f, 2.75729001e-02f, -1.07056752e-01f, -2.72801258e-02f, 6.70119524e-02f, 7.32912645e-02f, 8.00665244e-02f, 1.40209226e-02f,
  -5.56383990e-02f, -2.04819456e-01f, -1.82811096e-02f, 2.91831158e-02f, 7.35956058e-02f, -1.07429018e-02f, 1.22075275e-01f, 1.13993645e-01f, 9.68868211e-02f, -1.48972375e-02f,
  1.25420526e-01f, 1.68412109e-03f, -1.04216335e-03f, 7.00791702e-02f, 1.49050668e-01f, 7.94833153e-02f, -1.77595586e-01f, -4.97321747e-02f, -2.34769523e-01f, -2.30405241e-01f,
  8.58035564e-01f, -3.23806494e-01f, 2.40033358e-01f, 2.24699989e-01f, 9.64506641e-02f, 2.48719707e-01f, 1.11582875e-01f, -4.12513851e-04f, 8.67536571e-03f, 6.67430684e-02f,
  1.47928029e-01f, -9.41096433e-03f, 5.02067991e-02f, -8.66205394e-02f, 1.85761023e-02f, -1.89268023e-01f, -6.61074221e-02f, 6.64122999e-02f, 2.30158418e-01f, 6.05490915e-02f,
  -9.92576256e-02f, -9.03578848e-02f, 6.66408241e-02f, -6.51949868e-02f, -3.25338900e-01f, -5.52656278e-02f, -9.65167508e-02f, -2.22624362e-01f, -1.86306059e-01f, -4.57652777e-01f,
  -1.93473428e-01f, 2.39978358e-01f, 2.47609038e-02f, -1.45878643e-01f, 3.34626287e-02f, -3.17377783e-02f, 8.73914957e-02f, -6.32322431e-02f, -4.28697430e-02f, 5.92423342e-02f,
  -1.02174841e-01f, -1.67332083e-01f, 2.79435627e-02f, 6.25925288e-02f, 1.00245420e-02f, -9.32438523e-02f, -4.43344936e-02f, -3.32036661e-03f, 6.24793433e-02f, 2.92100850e-03f,
  -1.63339242e-01f, 1.25978356e-02f, 9.32795554e-02f, 9.50338468e-02f, 6.89344332e-02f, 1.67769551e-01f, 6.22933954e-02f, 7.86011666e-02f, 8.66635516e-02f, 1.36560813e-01f,
  3.33048403e-03f, 1.50604382e-01f, -1.55463405e-02f, 1.12284049e-01f, 1.56436324e-01f, 1.67124972e-01f, 6.97853342e-02f, 9.16224569e-02f, 8.14839005e-02f, 4.03491128e-03f,
  -5.14816642e-02f, 2.75157299e-02f, 4.96047176e-02f, -1.29745966e-02f, -1.07654862e-01f, -3.01846350e-03f, 1.89068597e-02f, -3.74923348e-02f, -4.25589979e-02f, -5.36350533e-02f,
  4.94201146e-02f, -1.21364202e-02f, -7.66971931e-02f, -8.22307542e-02f, -8.90195072e-02f, 7.18446672e-02f, -1.64743796e-01f, -3.20892930e-02f, -6.93581626e-02f, -7.21260384e-02f,
  -5.61160326e-01f, 2.02621296e-01f, 8.76363739e-02f, -1.27075255e-01f, 7.30651850e-03f, -1.00885995e-01f, 2.40041167e-02f, -4.38944846e-02f, -2.10196659e-01f, -7.95121491e-02f,
  8.46050829e-02f, 2.33341753e-02f, -1.03766873e-01f, 5.10874344e-03f, 1.11854866e-01f, 7.74147362e-02f, -4.86091822e-02f, 1.53362274e-01f, -6.70621246e-02f, -1.68195561e-01f,
  -1.47897378e-01f, 1.49292141e-01f, 1.39955685e-01f, 8.37695748e-02f, 5.63964024e-02f, 1.89136520e-01f, 3.54702324e-02f, 6.77827150e-02f, 3.69221456e-02f, 9.37311500e-02f,
  -6.17480576e-01f, -3.65341067e-01f, 1.59432903e-01f, -1.77904934e-01f, 1.79272592e-01f, -2.39968479e-01f, -4.72436249e-01f, -3.17405403e-01f, -5.29875495e-02f, -2.47624159e-01f,
  3.25102061e-02f, 1.67143449e-01f, 1.82335868e-01f, 1.42882153e-01f, -1.59433991e-01f, -6.93115219e-02f, 2.06740037e-01f, 8.52026269e-02f, -1.13926835e-01f, -7.61047080e-02f,
  2.27733076e-01f, 8.65176693e-02f, 1.63331237e-02f, 1.20030411e-01f, 1.22393325e-01f, 2.11055398e-01f, 2.56248981e-01f, 1.05339423e-01f, 1.14526980e-01f, 2.54123122e-01f,
  -1.74559265e-01f, -1.86653763e-01f, 3.12611349e-02f, -1.33166432e-01f, 3.28670405e-02f, -1.47478461e-01f, -1.53164044e-01f, 1.44141177e-02f, -8.68828408e-03f, 6.15024343e-02f,
  3.41391526e-02f, -1.69161260e-01f, 6.25725230e-03f, 1.95936095e-02f, -2.11853206e-01f, -1.46374807e-01f, -8.90593827e-02f, -4.78879176e-02f, -1.31357014e-01f, -2.60534793e-01f,
  -1.26235820e-02f, 4.60356139e-02f, -1.82584405e-01f, -4.42844490e-03f, -1.04766384e-01f, 1.52434886e-01f, -2.27133222e-02f, -5.84286964e-03f, 1.76937893e-01f, -4.91255336e-02f,
  5.36211170e-02f, 3.75535078e-02f, -1.02461465e-01f, -7.62793496e-02f, 2.28221826e-02f, 2.25129109e-02f, 6.59183338e-02f, -1.44869722e-02f, -2.06570104e-02f, -6.83430284e-02f,
  -4.55603823e-02f, -3.53338979e-02f, 1.56420037e-01f, 3.10385805e-02f, 1.04639813e-01f, 2.45613307e-02f, -1.37821421e-01f, 1.02909334e-01f, 7.49503681e-03f, 3.03760683e-03f,
  -9.82957408e-02f, -4.76750135e-02f, 9.06879231e-02f, -4.81351949e-02f, -9.13925096e-02f, -4.32662666e-02f, 2.60801092e-02f, -7.05214068e-02f, -8.83655846e-02f, 4.92727980e-02f,
  -6.86741844e-02f, 3.84437352e-01f, -1.48246944e-01f, -8.33053887e-02f, 1.17276236e-02f, -4.35191318e-02f, 4.43192981e-02f, 6.44595996e-02f, -1.56496003e-01f, -1.23453505e-01f,
  -5.86975403e-02f, -1.53853208e-01f, 8.44125375e-02f, -3.12014539e-02f, -2.46366054e-01f, 5.38724288e-03f, -8.26227367e-02f, -1.92501452e-02f, -9.66633707e-02f, -6.28030151e-02f,
  -1.29469827e-01f, -1.70527518e-01f, -2.99197465e-01f, -1.85162321e-01f, -8.13208222e-02f, -6.44086674e-02f, -1.89368948e-01f, -3.18345428e-02f, -1.40661702e-01f, -3.45112294e-01f,
  3.24829787e-01f, 1.83855683e-01f, 6.18549958e-02f, 2.66499281e-01f, 3.75304185e-02f, -1.69629276e-01f, -4.19246942e-01f, -2.66950041e-01f, 9.38863382e-02f, 1.92416981e-01f,
  9.75077078e-02f, 6.84480295e-02f, 3.46223526e-02f, -2.94259954e-02f, -2.14193389e-01f, 1.87052879e-02f, 5.81647791e-02f, -1.07686959e-01f, -2.35250488e-01f, -1.31352544e-01f,
  -3.91568579e-02f, 1.04859002e-01f, -4.55530547e-02f, -1.37007326e-01f, 2.48857662e-01f, 2.64590457e-02f, -5.74639030e-02f, 9.72166285e-02f, -6.91522583e-02f, 4.33634579e-01f,
  2.74238855e-01f, 2.37123013e-01f, -2.16363460e-01f, -3.37906950e-03f, 1.84736416e-01f, 1.07963294e-01f, -8.66036713e-02f, 1.33393317e-01f, 2.48459820e-02f, -4.02310006e-02f,
  1.81422040e-01f, 2.01643109e-02f, 1.68279946e-01f, -1.86766572e-02f, -4.46457714e-02f, -1.53193623e-01f, 8.37708414e-02f, -1.02459654e-01f, -7.67537430e-02f, 6.56984895e-02f,
  2.08938494e-02f, -1.17257394e-01f, -5.28034121e-02f, -2.48971984e-01f, -2.56046969e-02f, -9.44458097e-02f, -7.79711008e-02f, 8.13774094e-02f, -2.51260698e-01f, 1.33924693e-01f,
  -1.29611969e-01f, 9.68758315e-02f, 2.21631993e-02f, -8.76250044e-02f, -9.98686552e-02f, -8.34084079e-02f, -2.63746344e-02f, -6.61622509e-02f, -3.59335616e-02f, -6.50035664e-02f,
  -1.62134990e-01f, -7.77582228e-02f, 2.25494453e-03f, -1.50596341e-02f, -4.07885462e-02f, 1.33594610e-02f, 5.64469658e-02f, -2.27762517e-02f, -6.95542321e-02f, 1.46167027e-02f,
  2.12836098e-02f, 8.04943219e-02f, 1.31189659e-01f, -3.08581274e-02f, -4.05845046e-02f, -6.97044358e-02f, -6.10740185e-02f, -1.18899405e-01f, 5.93662448e-02f, -2.83055231e-02f,
  -8.83230567e-02f, -5.39416313e-01f, 5.08783832e-02f, 6.25146925e-02f, 1.17875654e-02f, 8.51612613e-02f, 1.73260659e-01f, 1.01602592e-01f, 1.05569042e-01f, -5.71430102e-02f,
  -5.88869043e-02f, 2.36343052e-02f, -1.44663462e-02f, 9.82212136e-04f, -1.07343704e-01f, -8.87228474e-02f, -1.81847401e-02f, -6.59542019e-03f, 6.41111210e-02f, 3.06293163e-02f,
  5.44636846e-02f, -1.39327437e-01f, -1.69931635e-01f, -1.41688302e-01f, -1.17149800e-02f, -1.73088029e-01f, -2.06675172e-01f, -1.24584451e-01f, -1.57255545e-01f, -1.23391181e-01f,
  1.36715710e-01f, 1.24172330e-01f, 2.25706086e-01f, -5.38340434e-02f, -1.20659135e-01f, -2.98160136e-01f, -2.31945977e-01f, -4.43835184e-03f, -6.83814064e-02f, 1.00656589e-02f,
  -5.72405942e-02f, 1.57974698e-02f, 5.50077222e-02f, 2.32782230e-01f, 1.24149129e-01f, 7.32714683e-02f, 3.73846263e-01f, 3.71873319e-01f, 1.55383930e-01f, 3.96122225e-02f,
  1.57308921e-01f, 1.58507869e-01f, 1.27480045e-01f, 4.80412208e-02f, 7.93178529e-02f, -3.93438078e-02f, 2.24965923e-02f, 8.41104388e-02f, -6.45452086e-03f, 3.65846634e-01f,
  2.54054308e-01f, 1.36437535e-01f, -1.03639223e-01f, 5.68418801e-02f, 1.52880866e-02f, -6.71959016e-03f, -4.04067822e-02f, 1.22240573e-01f, -8.17470998e-02f, 1.04640864e-01f,
  8.14096928e-02f, 3.51152532e-02f, -6.82160631e-02f, 1.01334698e-01f, 1.25477295e-02f, 1.11771189e-01f, 1.71982527e-01f, 8.55088457e-02f, 3.95104215e-02f, 5.69310933e-02f,
  8.37950185e-02f, 6.46588430e-02f, -5.73640130e-03f, -1.71363465e-02f, -8.00797194e-02f, 1.00614272e-01f, -1.91623196e-02f, 7.28544965e-02f, -3.76704261e-02f, 7.21918372e-03f,
  1.22603714e-01f, 1.76927894e-01f, 2.37707034e-01f, 2.27851048e-01f, 6.87682480e-02f, 9.66576673e-03f, 1.63994327e-01f, 3.47952954e-02f, 9.08932388e-02f, 1.25523791e-01f,
  -4.70737442e-02f, -4.12651673e-02f, -6.10115156e-02f, -5.51547408e-02f, -1.83486342e-02f, 2.77163144e-02f, 3.47772576e-02f, 1.28206044e-01f, -6.78505525e-02f, -5.29628433e-02f,
  1.98126305e-02f, -5.23516946e-02f, 4.19110106e-03f, -1.73263717e-02f, 7.26100579e-02f, 1.01472490e-01f, -8.58919346e-04f, -2.41309032e-02f, 8.91124234e-02f, 1.17842488e-01f,
  -3.26879382e-01f, -1.50342152e-01f, 6.22983873e-02f, -1.05069086e-01f, -3.54709886e-02f, -1.48814604e-01f, 2.64624227e-03f, -3.86982225e-02f, -2.70742141e-02f, -1.79690700e-02f,
  -2.82655120e-01f, -6.39961055e-03f, -1.42564237e-01f, -3.27653363e-02f, -2.45769266e-02f, -1.05626378e-02f, 1.57007545e-01f, 6.74940273e-02f, -7.18623176e-02f, 5.29270321e-02f,
  -1.33734629e-01f, -3.45264286e-01f, -2.60904282e-01f, -1.42771155e-01f, -1.03737131e-01f, -1.60261452e-01f, -1.54735997e-01f, -2.55577058e-01f, -3.37039441e-01f, -1.86279207e-01f,
  3.29976261e-01f, 3.99238110e-01f, 1.08657315e-01f, 8.34385231e-02f, -1.46852493e-01f, 4.62838411e-02f, -1.76314916e-02f, 1.33888826e-01f, 9.17008594e-02f, 1.55151725e-01f,
  2.62219697e-01f, 1.57528207e-01f, 7.15786591e-02f, 5.77409267e-02f, 1.40326113e-01f, -2.30577197e-02f, -7.71081075e-02f, 9.88315642e-02f, -1.04481436e-01f, 2.80406475e-02f,
  -4.62292358e-02f, -9.39540267e-02f, 1.91549376e-01f, -6.34088134e-03f, -5.75198270e-02f, -1.48896486e-01f, 3.70425396e-02f, -1.22757167e-01f, 1.04534803e-02f, 7.34190047e-02f,
  2.81698853e-01f, 2.00731814e-01f, 4.12266478e-02f, 1.22662298e-01f, 1.26922935e-01f, 1.41934708e-01f, 5.77421337e-02f, 1.22368917e-01f, 1.69240609e-01f, 2.09265992e-01f,
  1.45409599e-01f, -1.00467959e-02f, -1.06389001e-01f, -1.45899385e-01f, 7.26246387e-02f, -1.03318401e-01f, 6.80025965e-02f, 1.27994746e-01f, 8.15846324e-02f, 7.83462171e-03f,
  -9.13900957e-02f, -4.98396568e-02f, 1.18465088e-01f, -1.05559647e-01f, -2.95728743e-02f, -1.43455878e-01f, 4.70235460e-02f, 7.95946792e-02f, -3.22702602e-02f, 3.80462036e-02f,
  -8.19693208e-02f, -6.51616789e-03f, -3.11761107e-02f, -4.49454226e-03f, -1.08836100e-01f, -3.35618965e-02f, -4.04301845e-02f, -6.09459169e-03f, -8.88269767e-02f, -2.07666337e-01f,
  2.87184753e-02f, 3.66167389e-02f, 1.49946893e-02f, -6.82229474e-02f, 3.35566029e-02f, -1.90379433e-02f, 4.07799855e-02f, 1.54234573e-01f, 3.75537276e-02f, 6.35452792e-02f,
  -7.32222646e-02f, 6.01684451e-02f, 6.18045814e-02f, -1.24036156e-01f, 1.20689608e-02f, -3.34198810e-02f, -2.94146854e-02f, -4.03540619e-02f, -6.00581057e-02f, 3.41270752e-02f,
  2.31000856e-01f, 9.65013057e-02f, -5.81997111e-02f, 2.11206041e-02f, 9.02093947e-02f, 1.09810077e-01f, -1.10307205e-02f, 7.48657137e-02f, 2.08897695e-01f, 1.16229087e-01f,
  2.47911841e-01f, 1.07020073e-01f, 8.26358721e-02f, -1.03266180e-01f, -1.01083867e-01f, 7.28655607e-02f, 9.47737992e-02f, 1.22315278e-02f, 1.83462068e-01f, 1.56652555e-01f,
  6.30143881e-02f, 5.22507876e-02f, 5.21304552e-03f, 4.32118103e-02f, -4.17652689e-02f, -3.61778308e-03f, -2.85206605e-02f, -4.82609421e-02f, -2.47072671e-02f, -2.06265468e-02f,
  -6.09560251e-01f, -4.45376635e-02f, 2.22090006e-01f, -1.08216502e-01f, 1.92662850e-02f, -1.13647841e-01f, -1.12329900e-01f, -2.59804577e-01f, -2.94723511e-01f, -9.73981023e-02f,
  -2.99855415e-02f, 3.16720277e-01f, 3.74393433e-01f, 2.26691127e-01f, 1.00956306e-01f, 3.83792073e-02f, -1.03674501e-01f, 9.11528915e-02f, 1.89282045e-01f, -1.12150349e-01f,
  -4.15149629e-02f, -1.01491630e-01f, -2.87163019e-01f, -2.34799713e-01f, 7.57751763e-02f, 1.14549898e-01f, 8.63838047e-02f, -4.16801721e-02f, 1.40804633e-01f, 9.14478395e-03f,
  4.23628181e-01f, 5.73019162e-02f, -1.37924275e-03f, -3.00453722e-01f, -2.16168150e-01f, -4.17563319e-02f, 3.47616188e-02f, -8.73340666e-02f, -1.09269924e-01f, -3.81092392e-02f,
  -5.68647496e-02f, -1.23580061e-01f, 6.23186268e-02f, -1.56061769e-01f, -1.99804500e-01f, -2.00155944e-01f, -1.32524550e-01f, -4.84582409e-02f, -1.06299274e-01f, -1.22189708e-02f,
  -1.20141536e-01f, -1.00069299e-01f, -8.36949870e-02f, -6.56835213e-02f, 2.70865671e-02f, -5.74123301e-02f, 2.08657887e-02f, -2.33865660e-02f, 3.15259816e-03f, -1.29593359e-02f,
  9.12726298e-02f, -8.84684026e-02f, 2.88001774e-03f, 2.26887967e-02f, 9.15084779e-02f, 1.76374440e-03f, 1.31290510e-01f, -7.93381315e-03f, -5.42992726e-02f, 1.95989795e-02f,
  1.87339913e-02f, 1.00593328e-01f, 8.61079171e-02f, 4.03421640e-04f, -4.14971821e-02f, -5.66957109e-02f, -5.34353592e-02f, 4.60504815e-02f, 3.26084718e-02f, -4.93681384e-03f,
  -7.30332546e-03f, -1.04636803e-01f, -5.11547960e-02f, -1.04172453e-01f, -1.03863820e-01f, -1.71091795e-01f, -1.04711860e-01f, -7.47624561e-02f, -5.22888191e-02f, -1.33170588e-02f,
  2.39638567e-01f, 2.51919955e-01f, 2.46988043e-01f, 6.22527488e-02f, 3.30962911e-02f, -9.72066671e-02f, 9.47143063e-02f, 1.36358514e-01f, 4.19870801e-02f, 6.70024455e-02f,
  1.36434287e-01f, 3.94923612e-02f, 6.24944344e-02f, -3.83266211e-02f, 2.73808874e-02f, -4.22544032e-02f, -8.16276819e-02f, -3.61112989e-02f, 1.15596712e-01f, 2.72525623e-02f,
  -5.21401055e-02f, -4.80649695e-02f, 1.61737964e-01f, 1.57027245e-01f, 1.31189317e-01f, 2.45163575e-01f, 2.94854105e-01f, 3.72837931e-02f, 8.69265497e-02f, 1.52643681e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  3.22251976e-01f, 4.46985930e-01f, 2.88347036e-01f, -1.16970189e-01f, 2.82093167e-01f, 2.10260496e-01f, 1.47483364e-01f, 7.06312880e-02f, 1.83597684e-01f, 2.09728241e-01f,
  1.34406000e-01f, 2.22959742e-01f, -1.70494512e-01f, -6.07112795e-02f
};

// L1_fan_Wp (Shape: 25 x 64)
const int L1_fan_Wp_rows = 25;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  2.42125839e-02f, 1.45840600e-01f, 3.52870002e-02f, 8.87307748e-02f, -6.25569467e-03f, 3.92113142e-02f, 4.87024896e-02f, 4.49430160e-02f, -2.57863589e-02f, 1.47191301e-01f,
  3.11672240e-02f, 4.44258265e-02f, 1.77134752e-01f, 5.04750460e-02f, 5.32138236e-02f, -3.20109129e-02f, -7.69175217e-02f, 1.32332131e-01f, 6.90697581e-02f, 1.93066187e-02f,
  -3.15567493e-01f, -1.88826602e-02f, 1.17124312e-01f, 3.80221056e-04f, 2.93336473e-02f, 5.62562607e-02f, -2.53643066e-01f, -1.40468657e-01f, 8.23956504e-02f, -1.18064560e-01f,
  5.00679165e-02f, -2.12781057e-02f, -1.42541885e-01f, 1.62238598e-01f, -1.14850067e-01f, 4.59258594e-02f, 2.10532784e-01f, 8.09982941e-02f, -1.50446817e-01f, -2.61181444e-01f,
  -2.41603106e-02f, 6.96125403e-02f, 1.48832072e-02f, 1.35089517e-01f, -8.78446028e-02f, -5.63808009e-02f, 2.52122045e-01f, 1.42715856e-01f, -1.95591301e-01f, -2.22926727e-03f,
  -1.47456080e-01f, 3.86343688e-01f, -2.42670223e-01f, -1.58936441e-01f, -2.89171059e-02f, -1.46930128e-01f, -3.18372175e-02f, 1.07427448e-01f, -1.99052960e-01f, -5.53622236e-03f,
  4.56586421e-01f, 3.36568989e-02f, 5.06107584e-02f, 6.66577742e-02f, 1.46659641e-02f, 6.88690841e-02f, -7.61349499e-02f, 7.24920779e-02f, -5.25800399e-02f, 4.86721024e-02f,
  -7.79672638e-02f, -4.86225784e-02f, -1.13831908e-01f, 9.10276920e-02f, 7.53312483e-02f, -8.19172859e-02f, 2.30647549e-02f, 2.02444028e-02f, -1.35301858e-01f, -4.16455492e-02f,
  7.48671889e-02f, 1.52359933e-01f, -3.42297107e-02f, 2.93081962e-02f, 3.53824906e-02f, -1.00075848e-01f, -1.74112156e-01f, -7.58294016e-02f, 2.10966114e-02f, 5.53291552e-02f,
  3.35797876e-01f, 9.19083208e-02f, -5.26215211e-02f, 1.05589539e-01f, -4.05801497e-02f, 1.93741456e-01f, -1.19302832e-02f, -5.83987013e-02f, 6.35302812e-02f, -3.77011225e-02f,
  7.70118684e-02f, -4.97096851e-02f, -6.22370392e-02f, -9.02850181e-03f, 1.36775538e-01f, -1.85482487e-01f, 7.10317940e-02f, 9.25965607e-03f, 2.02854380e-01f, -4.92386147e-02f,
  -1.33998677e-01f, -1.21463478e-01f, -2.30572715e-01f, -1.09924469e-02f, 3.31648812e-02f, 3.39718670e-01f, -3.86311635e-02f, -6.01956770e-02f, -2.78301202e-02f, -1.91705331e-01f,
  1.07739463e-01f, 1.43391326e-01f, 2.34039742e-02f, 4.71121788e-01f, 1.26497895e-01f, 1.71635076e-01f, -1.43597320e-01f, -3.21098596e-01f, -3.96402255e-02f, 7.54267648e-02f,
  -9.04701501e-02f, 8.16724673e-02f, -3.05118989e-02f, -3.20307612e-02f, -1.57816410e-01f, 7.56005794e-02f, -6.12432584e-02f, 1.11367300e-01f, -8.24808031e-02f, -2.52470486e-02f,
  1.02751374e-01f, -5.13223186e-02f, 7.64539558e-03f, -9.94927436e-02f, 8.61798078e-02f, 6.87830970e-02f, 1.13033494e-02f, -1.75490435e-02f, 2.84077898e-02f, -9.10464749e-02f,
  4.84122150e-02f, -1.24526531e-01f, -4.10395395e-03f, 4.53624092e-02f, -5.59861865e-03f, 1.57546341e-01f, 1.20012969e-01f, -3.89014594e-02f, 2.63759959e-03f, 1.94687068e-01f,
  1.81527575e-03f, 2.93736942e-02f, -2.96148416e-02f, -1.79346785e-01f, 1.90524369e-01f, 9.88632664e-02f, -6.16676211e-02f, -3.89054447e-01f, -7.14283139e-02f, -1.27293309e-02f,
  1.22201405e-02f, 5.65530024e-02f, 2.68331140e-01f, -3.75626795e-02f, 5.31454943e-02f, -1.65451750e-01f, -2.34718591e-01f, 6.11520968e-02f, 1.68495849e-01f, 2.72384375e-01f,
  -6.95395917e-02f, 2.74824314e-02f, -1.87079981e-01f, -2.58932054e-01f, -1.53213311e-02f, -1.89717501e-01f, -2.01060176e-01f, 1.43684253e-01f, 3.58014435e-01f, 3.01316381e-01f,
  -2.10758727e-02f, 3.26705612e-02f, -8.53522797e-04f, 1.63373932e-01f, -7.37233981e-02f, 1.01808250e-01f, 3.12547125e-02f, -7.80905560e-02f, 9.24022645e-02f, -2.65083089e-02f,
  8.73104036e-02f, -3.78114842e-02f, -2.11270452e-02f, 8.65083560e-02f, 1.62555695e-01f, -5.19667231e-02f, 1.10401429e-01f, 7.19497576e-02f, 1.98544681e-01f, -4.79288660e-02f,
  4.34364527e-02f, -2.80599594e-01f, -3.63120437e-03f, -1.07671626e-01f, 1.94469631e-01f, 3.52708310e-01f, -4.80197594e-02f, 3.07352468e-02f, -3.90078872e-01f, -1.40962437e-01f,
  7.73352683e-02f, 1.22860529e-01f, -1.02879725e-01f, -3.94057244e-01f, 2.77273536e-01f, 2.73628905e-02f, -6.48167431e-02f, -1.46237493e-01f, -4.22023423e-02f, -2.23724484e-01f,
  -1.36603639e-01f, -7.67628336e-03f, 1.34227395e-01f, 1.56632558e-01f, -1.06201410e-01f, -9.93279144e-02f, -5.69420196e-02f, 1.49997324e-01f, -1.91768527e-01f, 1.27843246e-01f,
  2.47800186e-01f, 9.54636373e-03f, -2.23646343e-01f, 2.67436743e-01f, -2.60506630e-01f, -1.30403847e-01f, -1.66567817e-01f, 5.16309500e-01f, 3.98538798e-01f, -2.17615828e-01f,
  -2.28571728e-01f, 5.14681526e-02f, 1.03547119e-01f, 1.70754641e-01f, 4.30003367e-02f, -1.34769067e-01f, -1.70044135e-02f, 1.20125681e-01f, -1.03019126e-01f, 7.09557384e-02f,
  -2.98041888e-02f, -1.70905832e-02f, 1.17464684e-01f, -7.67977461e-02f, 1.09194815e-01f, -9.14163589e-02f, -8.58873054e-02f, -2.38807928e-02f, -1.46390311e-02f, 7.63061941e-02f,
  4.20699492e-02f, 6.44855574e-02f, 2.10305110e-01f, 1.14498973e-01f, 1.69817552e-01f, -5.79429492e-02f, -1.64108947e-01f, -1.38434991e-01f, 9.34548080e-02f, -7.65589327e-02f,
  1.70036569e-01f, -1.00724928e-01f, -1.12319693e-01f, -1.21318080e-01f, -1.52957842e-01f, 7.41678253e-02f, 1.93481937e-01f, -2.31924817e-01f, 7.34044164e-02f, -1.07322052e-01f,
  6.21045418e-02f, -1.87869877e-01f, 1.53770640e-01f, -1.27693236e-01f, 6.51341602e-02f, -1.09415084e-01f, -3.49837579e-02f, -1.38130644e-02f, -6.85327277e-02f, 9.62371565e-03f,
  3.00072823e-02f, 5.57379909e-02f, -2.64782459e-01f, -7.30160475e-02f, 9.03677344e-02f, 1.43898800e-01f, -4.42079157e-02f, -1.48951426e-01f, -2.33852044e-01f, -2.49000847e-01f,
  -1.90595072e-02f, 2.18446434e-01f, -8.15477520e-02f, 1.34135142e-01f, 2.53875200e-02f, 1.35591894e-01f, 1.40558645e-01f, 2.35997140e-01f, -3.27657908e-02f, 1.74076334e-01f,
  4.51560020e-02f, 5.37617318e-03f, 6.81213662e-02f, 4.07110564e-02f, 1.32766403e-02f, 3.43382023e-02f, -1.74628079e-01f, -3.81925292e-02f, -3.62704881e-02f, -9.62281227e-02f,
  2.87788250e-02f, -4.88567576e-02f, 6.13833703e-02f, 4.43646275e-02f, -3.62905674e-02f, -7.54665136e-02f, 4.46040323e-03f, 2.58232765e-02f, 8.09279382e-02f, -1.04380779e-01f,
  -6.42369464e-02f, -6.68520406e-02f, -9.39367190e-02f, -1.49326637e-01f, -3.54640000e-02f, -5.39230518e-02f, 1.01640835e-01f, -2.13793397e-01f, -1.17243230e-01f, 6.94837607e-03f,
  -2.41356138e-02f, 7.02838749e-02f, -2.36640163e-02f, -1.36590600e-01f, 2.84934975e-02f, 6.76060170e-02f, 1.15796283e-01f, -2.99418643e-02f, 9.64737460e-02f, 1.39470309e-01f,
  -1.36585861e-01f, 6.18871339e-02f, -3.30320885e-03f, -4.93945740e-02f, 1.24907807e-01f, -1.86275408e-01f, 9.77880582e-02f, 6.29995950e-03f, -8.34447742e-02f, 1.28866330e-01f,
  -1.54078677e-01f, 2.94692665e-01f, 3.87873761e-02f, -2.60634542e-01f, -1.79677129e-01f, -5.03293097e-01f, -2.62324512e-01f, 2.25970656e-01f, -2.42755070e-01f, 1.74868658e-01f,
  8.37705210e-02f, 1.76999435e-01f, 4.12601829e-02f, 3.20180863e-01f, -6.02959841e-02f, -1.21275976e-01f, -7.04637845e-04f, -6.38067573e-02f, -1.75995007e-01f, -2.83540208e-02f,
  -1.78821892e-01f, 5.06552262e-03f, 4.31666858e-02f, 1.13141881e-02f, -7.15057924e-02f, 8.55224091e-04f, -1.35315254e-01f, -9.75299105e-02f, -2.59890914e-01f, -1.42735139e-01f,
  6.24390543e-02f, 9.57199484e-02f, 6.86244741e-02f, 3.31036039e-02f, -5.09471297e-02f, -2.70183869e-02f, 2.20134556e-02f, -1.17490709e-01f, -1.04719959e-01f, -1.74158797e-01f,
  -6.48347363e-02f, -1.87991094e-02f, -1.72252413e-02f, -7.93094262e-02f, -8.95295218e-02f, 2.02162996e-01f, -1.90789595e-01f, 4.40051518e-02f, 1.83483008e-02f, -1.10871881e-01f,
  1.43375605e-01f, 1.15023561e-01f, -1.69926196e-01f, -1.56260028e-01f, -1.02512516e-01f, 6.59091324e-02f, -5.20121716e-02f, 6.39435947e-02f, 6.94257319e-02f, -1.04180753e-01f,
  7.71381855e-02f, -1.26597226e-01f, -3.45715225e-01f, 1.52032912e-01f, -1.15629114e-01f, 2.74942487e-01f, -2.46588420e-03f, 1.58989173e-03f, -7.04357997e-02f, -5.78495920e-01f,
  -2.76580930e-01f, 2.65436471e-01f, 5.52499257e-02f, 1.24095976e-01f, 1.30083784e-01f, 1.88208204e-02f, 2.05319285e-01f, 5.17708212e-02f, -5.11134937e-02f, -1.19049719e-03f,
  -1.12677060e-01f, -6.55353814e-02f, 1.60115942e-01f, -2.28623580e-02f, -7.15067901e-04f, 2.91779023e-02f, -1.32789567e-01f, 3.03579699e-02f, 8.87959823e-03f, 1.26549363e-01f,
  -5.48806600e-02f, -4.52549905e-02f, -5.42655028e-02f, -9.39263925e-02f, -1.21645622e-01f, -8.10218081e-02f, 3.51106785e-02f, 1.18875481e-01f, 5.65439761e-02f, -1.11694813e-01f,
  -6.06818311e-02f, 6.47865608e-02f, -3.43624875e-02f, 8.64233151e-02f, 3.56390439e-02f, 9.73102450e-02f, 1.07065476e-01f, -1.94053762e-02f, -1.41636983e-01f, 5.12906164e-03f,
  1.03031844e-01f, 3.94128375e-02f, -1.15917131e-01f, 8.74198526e-02f, -3.94343911e-03f, -2.37250533e-02f, -1.03232525e-01f, -7.24937245e-02f, 6.61967620e-02f, -1.43629853e-02f,
  8.10844731e-03f, 2.58290246e-02f, 1.17350584e-02f, -6.46246076e-02f, 4.80752774e-02f, 1.12120137e-01f, -8.57504606e-02f, -3.38193178e-02f, -1.73005369e-02f, 1.84034437e-01f,
  1.35917693e-01f, 1.55136585e-01f, -2.85502255e-01f, 2.04830877e-02f, 2.74147153e-01f, -1.83811665e-01f, -4.85767946e-02f, 1.20187998e-01f, 1.10151261e-01f, 2.55194516e-03f,
  2.13908404e-02f, -2.78840154e-01f, 1.11715356e-02f, 1.03728799e-02f, 6.23875335e-02f, 2.77842255e-03f, 1.10279985e-01f, -1.37998872e-02f, 1.44250482e-01f, -1.31698586e-02f,
  -3.33604217e-02f, 1.96516514e-01f, 7.16433227e-02f, 6.45784587e-02f, -1.15318358e-01f, 1.27435535e-01f, -3.95756364e-02f, -1.21118361e-02f, -1.38683423e-01f, 6.04090653e-02f,
  -4.03107926e-02f, 1.86947227e-01f, -1.30383238e-01f, 5.07945716e-02f, 5.17810928e-03f, -1.06951840e-01f, -6.82515353e-02f, 4.92034815e-02f, -5.09973057e-02f, -6.23009689e-02f,
  2.73837060e-01f, -1.22357450e-01f, -1.65466055e-01f, 3.28073114e-01f, -1.10898599e-01f, -1.74804274e-02f, -2.03172248e-02f, 1.99083611e-01f, -5.42768724e-02f, 3.74548882e-02f,
  -9.89230946e-02f, -6.24825433e-02f, -6.27898499e-02f, -1.43773153e-01f, -1.85740646e-02f, 1.08862415e-01f, -1.91590309e-01f, 1.11502916e-01f, 2.65730202e-01f, -2.06679255e-02f,
  -6.30764440e-02f, -4.57025366e-03f, 1.42102525e-01f, -1.52861327e-02f, 1.51914373e-01f, -1.23304993e-01f, 1.68022498e-01f, -1.53401569e-01f, -9.27881077e-02f, -1.64058805e-01f,
  2.02211127e-01f, -1.68233886e-01f, 5.15238848e-03f, -1.29603729e-01f, -9.41235721e-02f, 1.55549094e-01f, -5.47226928e-02f, -1.39757872e-01f, -5.55071346e-02f, -9.36006904e-02f,
  1.07624326e-02f, 1.57126382e-01f, -1.35028675e-01f, -9.81854275e-02f, -6.67218789e-02f, -5.29099517e-02f, -3.68485563e-02f, 9.30320844e-02f, -4.59502637e-02f, -2.20351815e-02f,
  -1.65295541e-01f, -2.52940170e-02f, 2.72790007e-02f, 6.87997788e-03f, -8.71291086e-02f, 8.33339915e-02f, 2.94378493e-02f, 1.94571372e-02f, 9.90352258e-02f, 1.04697794e-01f,
  2.94463914e-02f, -4.42685783e-02f, 1.70496166e-01f, 2.16325551e-01f, -6.88861012e-02f, 1.61572918e-01f, -1.29426524e-01f, -3.84957492e-02f, -8.52530897e-02f, 1.19532809e-01f,
  1.09003723e-01f, -6.70715943e-02f, -1.84509270e-02f, -2.24008802e-02f, -3.33929472e-02f, 7.24218562e-02f, 1.35312855e-01f, 1.17144600e-01f, 3.60957012e-02f, -2.56987344e-02f,
  1.10288963e-01f, 2.87881196e-02f, -7.54376352e-02f, -1.68596596e-01f, 1.23611450e-01f, 2.06078961e-02f, -9.24056545e-02f, -1.36807323e-01f, 1.47440195e-01f, 2.29401171e-01f,
  -7.85428137e-02f, -3.92179899e-02f, 7.67130628e-02f, 3.33773762e-01f, -6.49851486e-02f, 1.53042018e-01f, 4.79086190e-02f, 6.62519038e-02f, -2.14824229e-01f, -2.05901284e-02f,
  -1.72502827e-02f, 1.07069314e-01f, -5.24500571e-02f, -2.64969524e-02f, 9.97094531e-03f, 1.28368884e-01f, -7.22180456e-02f, -2.76537240e-01f, -3.49726826e-02f, -1.07226953e-01f,
  -1.60899073e-01f, -3.20181362e-02f, -7.03216866e-02f, -7.02557042e-02f, -1.49508640e-01f, -1.54146135e-01f, -1.20311379e-01f, -1.57480702e-01f, 5.80145828e-02f, 6.38269261e-02f,
  4.60151657e-02f, -2.48903185e-02f, -1.72085911e-01f, -3.81207019e-01f, -1.17379606e-01f, 7.73278251e-02f, 4.41160873e-02f, 6.10529706e-02f, -2.02114228e-03f, -4.29307185e-02f,
  -1.07122205e-01f, 1.24472097e-01f, 2.98054907e-02f, -1.80881917e-01f, 4.81800176e-02f, 1.79380223e-01f, 8.00357759e-02f, 2.04022191e-02f, 4.04494256e-02f, 5.13183884e-02f,
  -4.59610298e-02f, -6.76083118e-02f, 1.05438970e-01f, 1.03143029e-01f, -3.83824110e-02f, -9.61106047e-02f, -3.01585943e-02f, 1.82083115e-01f, -6.85637910e-03f, -1.55374315e-02f,
  -1.78088844e-02f, -7.66416565e-02f, 2.59290844e-01f, 4.49651629e-02f, -1.23259716e-01f, -1.37454197e-01f, -7.98453763e-02f, -3.75152856e-01f, 1.52467549e-01f, -6.33300915e-02f,
  -2.75110543e-01f, -1.14414193e-01f, -6.28593639e-02f, 1.30606458e-01f, -6.43286761e-03f, -6.76361024e-02f, -5.62247038e-02f, 1.09462574e-01f, -2.71024890e-02f, -3.75566930e-02f,
  -1.12280130e-01f, -8.77325386e-02f, -1.59968719e-01f, -7.12202415e-02f, -3.24939042e-02f, -5.29181138e-02f, 3.44818160e-02f, -6.68361597e-03f, 4.88834083e-02f, -6.52627423e-02f,
  1.12426981e-01f, -7.46375099e-02f, -1.90134556e-03f, 1.14125408e-01f, -1.54181391e-01f, 6.89398497e-02f, -3.47228386e-02f, -2.22243652e-01f, 1.61605984e-01f, 8.73504728e-02f,
  -1.35879472e-01f, -6.46100640e-02f, -2.54762053e-01f, 8.62586647e-02f, 1.06083058e-01f, -4.90408391e-02f, -1.65438741e-01f, 1.01961344e-02f, -1.42796740e-01f, 4.51995321e-02f,
  1.86041161e-01f, 1.01816557e-01f, 2.42753029e-01f, -9.34704673e-03f, -4.83135693e-02f, -7.55401924e-02f, -2.27240138e-02f, -1.72657464e-02f, -3.39220352e-02f, -1.96811408e-01f,
  -4.65416983e-02f, -2.23508459e-02f, -6.38843104e-02f, 2.09639952e-01f, -2.33351767e-01f, 1.28414214e-01f, -7.86819458e-02f, -4.03063416e-01f, -2.65490841e-02f, -2.30540380e-01f,
  -2.71545976e-01f, 7.98818842e-02f, 4.47865650e-02f, -2.11527184e-01f, 1.80889711e-01f, 1.07676171e-01f, 1.22848764e-01f, 2.75634408e-01f, -9.77275241e-03f, -2.01109901e-01f,
  -7.66165257e-02f, -1.48973256e-01f, 1.26269758e-02f, -6.67582154e-02f, -7.27538839e-02f, -7.10906610e-02f, -1.05410010e-01f, -3.38345766e-02f, -4.54412028e-02f, 1.81904599e-01f,
  1.06065394e-02f, -1.01082198e-01f, -1.38557881e-01f, 2.46800222e-02f, 1.00895728e-03f, 1.06532216e-01f, 7.55605847e-02f, -1.22233205e-01f, 1.00066764e-02f, 9.99527946e-02f,
  -1.03242295e-02f, 1.45087525e-01f, -4.17678915e-02f, 1.50915608e-01f, 1.60718799e-01f, 9.11858454e-02f, 6.49972036e-02f, -7.23153427e-02f, -2.69462820e-02f, 1.58685476e-01f,
  -7.38072395e-02f, -1.74030244e-01f, 7.70519227e-02f, 1.15287833e-01f, -7.19636232e-02f, 2.37073883e-01f, -3.36653516e-02f, 1.46143332e-01f, 2.04930127e-01f, 3.48046243e-01f,
  -1.03942662e-01f, -4.02984098e-02f, -1.05853006e-01f, 1.43670559e-01f, 1.78024545e-01f, -1.16037704e-01f, -7.20603019e-02f, -1.91649035e-01f, -2.42683485e-01f, 3.52589250e-01f,
  1.61558270e-01f, 1.73023179e-01f, 6.95170611e-02f, -1.48367435e-01f, 1.72688827e-01f, -5.74830845e-02f, -1.32355794e-01f, 5.11258766e-02f, -1.44634647e-02f, -2.49631047e-01f,
  -2.45978236e-02f, -2.36580983e-01f, -2.54746787e-02f, -2.75381212e-03f, 1.80252239e-01f, -6.81549981e-02f, 1.16299272e-01f, 7.32815415e-02f, 2.51944602e-01f, -6.16460815e-02f,
  3.58401798e-02f, -4.25354354e-02f, -5.11476584e-02f, -1.48754463e-01f, -3.82066704e-02f, 4.38247882e-02f, -9.84392501e-03f, 9.27872211e-02f, 3.46134193e-02f, -5.91077730e-02f,
  -1.28374085e-01f, 6.20970465e-02f, -1.88635103e-02f, -8.69680382e-03f, -1.06074974e-01f, 1.59541145e-02f, -6.12666905e-02f, -2.01725792e-02f, 2.55920738e-01f, 8.75292122e-02f,
  -4.01124619e-02f, 6.87450543e-02f, -1.06020011e-01f, 1.55197866e-02f, -6.58226609e-02f, -1.22355573e-01f, 2.10426390e-01f, 7.00478926e-02f, -3.00533324e-01f, 4.69666384e-02f,
  1.33115664e-01f, 2.69707173e-01f, 3.93576175e-02f, -1.15800664e-01f, 3.97202373e-02f, 1.08703400e-03f, -1.19102903e-01f, 1.20002232e-01f, -2.68441476e-02f, 7.69613087e-02f,
  2.45474458e-01f, -1.22522358e-02f, 1.78600587e-02f, -5.17840624e-01f, 2.42850799e-02f, 2.89314762e-02f, 1.51822194e-01f, 2.47437730e-01f, 2.43748620e-01f, 8.85772780e-02f,
  1.28050804e-01f, 1.18667111e-02f, -3.24356228e-01f, -8.13776255e-02f, -1.73756212e-01f, 1.35020092e-01f, 4.63473797e-02f, 3.58089283e-02f, 5.32778427e-02f, 1.64561719e-02f,
  -1.39282435e-01f, 3.58162485e-02f, -1.49405271e-01f, 5.89618422e-02f, 3.99190187e-02f, -2.15341330e-01f, -6.37582242e-02f, 1.34337172e-01f, 5.78240119e-02f, 7.69342035e-02f,
  6.86275261e-03f, 7.99412057e-02f, 1.98079616e-01f, 5.37518226e-02f, -1.29483482e-02f, 8.38540494e-02f, 1.52239114e-01f, -1.47831082e-01f, -1.26467228e-01f, 8.54804181e-03f,
  -8.90921652e-02f, -7.37869143e-02f, 2.87237037e-02f, -1.82687148e-01f, -1.34674221e-01f, 1.34626985e-01f, 1.58921957e-01f, -1.27541646e-01f, -1.47729293e-01f, 3.53558995e-02f,
  -2.01756865e-01f, 6.00604638e-02f, 1.27922311e-01f, -1.61838147e-03f, 1.37998030e-01f, 1.19633950e-01f, -7.01894388e-02f, 8.23790580e-02f, -1.22467475e-03f, -1.60243124e-01f,
  7.05032200e-02f, -4.22806218e-02f, 5.72124794e-02f, 9.47109684e-02f, -2.70687137e-02f, 2.74001993e-02f, 8.69059116e-02f, 3.98577601e-02f, -4.19460274e-02f, -1.27078697e-01f,
  -4.56191301e-02f, -5.09130657e-01f, -2.57081479e-01f, 2.28702232e-01f, 1.94317270e-02f, -6.58378825e-02f, 2.65865982e-01f, 3.14732254e-01f, -4.84559834e-02f, -2.71132458e-02f,
  -2.77017578e-02f, -5.11315614e-02f, 6.80960268e-02f, 2.46775046e-01f, 1.23462733e-02f, 2.11095656e-04f, 9.49280336e-02f, 8.04653615e-02f, -7.79261589e-02f, -2.24927198e-02f,
  1.51017711e-01f, 5.10820225e-02f, -5.18654287e-02f, 3.17006052e-01f, 1.33482302e-02f, 1.94046631e-01f, -9.43652317e-02f, -7.63161257e-02f, 6.49264827e-02f, 1.33231536e-01f,
  -1.86535850e-01f, -1.19625308e-01f, -1.22173317e-01f, 1.63753048e-01f, 8.57276283e-03f, -1.14511818e-01f, -6.58813789e-02f, -2.79018041e-02f, 7.64305443e-02f, 1.09864473e-01f,
  1.03989907e-01f, 2.46029004e-01f, 1.86338753e-01f, 2.67708451e-02f, 4.82288338e-02f, 1.76519051e-01f, -1.00299895e-01f, -6.89353719e-02f, 1.05983965e-01f, 2.13111624e-01f,
  6.56506941e-02f, -1.43808961e-01f, -3.02821957e-02f, 2.44143531e-02f, -1.95993688e-02f, 5.87357134e-02f, -3.76802147e-03f, 5.24089560e-02f, -9.29209124e-03f, 3.73963974e-02f,
  4.10764851e-02f, 4.11976725e-01f, 1.09066665e-02f, -2.08820596e-01f, -1.67339727e-01f, 1.25355914e-01f, 2.25792244e-01f, -2.30106667e-01f, 1.49960950e-01f, 2.30784155e-02f,
  -1.45900369e-01f, -8.49972293e-02f, 9.82918143e-02f, -1.87735498e-01f, 6.60251873e-03f, 1.09149918e-01f, 8.12733620e-02f, -8.02312791e-03f, -1.64599866e-02f, 8.58078673e-02f,
  9.04486105e-02f, -1.11249641e-01f, -8.10168684e-02f, -1.23050332e-01f, 2.27541570e-02f, -8.93518701e-02f, 3.62073854e-02f, 1.55962585e-02f, -6.52445853e-02f, -9.45946202e-02f,
  1.18181244e-01f, 5.80135584e-02f, 3.06795016e-02f, -9.46474671e-02f, -8.33426714e-02f, -5.78118004e-02f, -2.91705690e-02f, -1.39500294e-02f, 5.59191313e-03f, 5.35265729e-02f,
  -5.52041121e-02f, -1.77496523e-02f, -1.16794489e-01f, 2.35236272e-01f, 8.59675705e-02f, -3.16901505e-01f, 9.02131796e-02f, 2.27364786e-02f, 4.21268493e-02f, -2.43664216e-02f,
  5.94521910e-02f, -4.75446358e-02f, 7.11527318e-02f, -2.02929690e-01f, -7.39291906e-02f, -2.57561028e-01f, 4.04081047e-02f, 3.75875421e-02f, 4.49312329e-02f, -1.46795526e-01f,
  -2.64175385e-01f, 2.12717339e-01f, -5.95157593e-02f, 1.13063246e-01f, 1.54156104e-01f, -3.08792800e-01f, -5.98844625e-02f, -2.87738442e-01f, 9.57357362e-02f, 2.17351139e-01f,
  -2.55076829e-02f, -2.39747971e-01f, -7.09754939e-04f, -8.52366462e-02f, 3.39508951e-02f, 3.02887380e-01f, -1.72890812e-01f, 1.32365339e-02f, 1.28728837e-01f, 1.29049689e-01f,
  -1.22681379e-01f, -5.00079282e-02f, -1.22900903e-01f, -1.00772738e-01f, 1.87735781e-02f, -2.46305875e-02f, 8.52462873e-02f, -2.05414128e-02f, 3.04711647e-02f, 3.98292057e-02f,
  3.97039652e-02f, 1.84529215e-01f, 7.20251277e-02f, 2.53595039e-02f, 1.44420832e-01f, 1.17135579e-02f, 6.24732412e-02f, -7.51598701e-02f, 2.45744124e-01f, 6.22667521e-02f,
  -8.47190917e-02f, -1.54045969e-02f, -5.30278310e-03f, 1.14249811e-01f, 9.06138867e-02f, 9.95284915e-02f, -3.91722023e-02f, -1.01121567e-01f, -1.30782314e-02f, -1.64039508e-02f,
  2.47643935e-03f, -2.55493551e-01f, -8.96091536e-02f, 2.95344088e-02f, -1.23307288e-01f, -4.61734459e-02f, -6.95429370e-02f, 2.50456303e-01f, -9.60556343e-02f, 2.03425437e-01f,
  4.19020206e-02f, 1.40979350e-01f, 4.08268236e-02f, 2.56883055e-01f, 6.89756498e-02f, 1.38742089e-01f, 1.26858339e-01f, -1.50041357e-01f, -1.01522699e-01f, 1.23671882e-01f,
  7.52475932e-02f, 8.82799700e-02f, -1.41859367e-01f, -2.26698369e-01f, -3.73774499e-01f, -2.85232008e-01f, -1.24979712e-01f, 1.57375604e-01f, -1.15885660e-01f, -3.43104452e-02f,
  -2.11361542e-01f, 3.62928361e-02f, 1.11136295e-01f, 2.81638168e-02f, 1.17137700e-01f, 7.64989853e-02f, 1.39373960e-03f, -7.48483092e-02f, 1.09137788e-01f, 1.03320047e-01f,
  1.77224994e-01f, -3.06062540e-03f, 2.77714841e-02f, 1.12318038e-03f, -4.93341237e-02f, -1.56712607e-01f, -1.01500200e-02f, -1.74545944e-02f, 3.97354588e-02f, 3.73300985e-02f,
  -8.66148397e-02f, -7.24728927e-02f, -1.75786614e-02f, 2.90264115e-02f, 9.27571207e-02f, 8.76386017e-02f, 9.15626362e-02f, 9.67708230e-03f, -1.32722676e-01f, 1.37433307e-02f,
  1.35138169e-01f, -7.70386448e-03f, -1.43521139e-02f, -2.55399555e-01f, -4.26255502e-02f, 5.02994582e-02f, 4.08622362e-02f, -1.10719286e-01f, -1.29516259e-01f, 6.82487711e-02f,
  -5.75876012e-02f, 1.56103726e-02f, 3.18715498e-02f, 1.18260354e-01f, -9.97035950e-02f, -7.88975358e-02f, -7.51192262e-03f, 9.70755666e-02f, -9.67994928e-02f, 8.13671052e-02f,
  8.87664109e-02f, -1.06719643e-01f, -1.95123866e-01f, 9.71856862e-02f, 4.50591408e-02f, -2.26999484e-02f, -2.11063161e-01f, 4.11570460e-01f, 4.08646405e-01f, 1.06278025e-01f,
  -8.63118749e-03f, -1.84671823e-02f, -1.70592785e-01f, -7.99137354e-02f, 9.76919308e-02f, -5.00807911e-02f, -6.19114414e-02f, 7.79791549e-02f, -1.25633135e-01f, -4.11353586e-03f,
  -3.45542468e-02f, 8.48867670e-02f, 8.66586715e-03f, -5.83836483e-03f, -1.20594345e-01f, 1.00778364e-01f, -7.00209141e-02f, 5.24148829e-02f, -2.47538723e-02f, -2.21976843e-02f,
  1.56469062e-01f, 1.77821587e-03f, 1.11669473e-01f, 1.04234956e-01f, 7.81941712e-02f, 9.26763788e-02f, 2.29555264e-01f, -1.09650157e-01f, 1.87024362e-02f, -1.08227901e-01f,
  1.24189295e-01f, -9.60815176e-02f, 1.64487466e-01f, 1.60109505e-01f, -7.65870661e-02f, -1.45045176e-01f, -2.70854011e-02f, -8.76580775e-02f, -3.07601951e-02f, 2.80457642e-03f,
  -4.23351936e-02f, -1.66556507e-01f, -5.99964783e-02f, -1.56745896e-01f, -2.06894040e-01f, -1.82765722e-01f, -8.83519053e-02f, -4.61068228e-02f, -2.85089891e-02f, 1.24397479e-01f,
  1.27462581e-01f, -5.36491275e-02f, -1.79526638e-02f, -1.53154999e-01f, 2.79660169e-02f, -9.93581191e-02f, 6.35875314e-02f, -5.37617862e-01f, 2.31984816e-02f, 3.88894081e-01f,
  -3.35524857e-01f, 7.00866804e-02f, 7.93105736e-02f, 4.62238975e-02f, 5.45069799e-02f, 1.72101021e-01f, 1.24012820e-01f, 4.19043116e-02f, -1.68242425e-01f, 5.69667108e-02f,
  1.10364109e-01f, 4.77177240e-02f, 3.41479550e-03f, 1.40635014e-01f, 1.34802267e-01f, -1.80799335e-01f, -9.19573754e-02f, 1.34810194e-01f, 1.05668955e-01f, -1.23091422e-01f,
  -1.01371240e-02f, 4.02826183e-02f, 1.42524555e-01f, 1.04609139e-01f, 2.00018927e-01f, 1.37053639e-01f, -1.21807776e-01f, 7.88742211e-03f, 1.06947787e-01f, 4.15893421e-02f,
  1.70617610e-01f, -6.26732260e-02f, -1.08180135e-01f, 2.71979690e-01f, 3.56889628e-02f, 1.23948880e-01f, 1.15490481e-01f, -1.06258571e-01f, 1.87012970e-01f, -7.52712041e-02f,
  -4.09816504e-02f, 3.58304530e-02f, -2.16651894e-02f, -3.11069540e-03f, -1.20789409e-01f, 2.68220812e-01f, -4.29594005e-03f, 1.90534130e-01f, 9.67953131e-02f, 1.30433112e-01f,
  1.29344821e-01f, 1.08043134e-01f, -1.72931716e-01f, -2.90701035e-02f, -1.22148804e-01f, -5.68626784e-02f, 5.45245130e-04f, 8.34989995e-02f, 2.08725072e-02f, -6.87719136e-02f,
  1.97086781e-01f, 6.94915056e-01f, -1.83139194e-03f, 2.13508285e-03f, -5.63869551e-02f, -1.83687225e-01f, 1.67756662e-01f, -2.30671376e-01f, 1.62565929e-03f, -9.32353660e-02f,
  -8.11498687e-02f, -3.72904539e-03f, -3.78657989e-02f, -1.80940568e-01f, -5.99756576e-02f, -2.87702799e-01f, -3.88065986e-02f, -8.22185501e-02f, 1.43684939e-01f, -1.25967547e-01f,
  -1.71488523e-01f, 9.52214301e-02f, -1.45912558e-01f, -9.68007371e-02f, -1.53332517e-01f, -1.14414789e-01f, 6.51286691e-02f, 2.76808348e-02f, 3.26276235e-02f, 1.16251588e-01f,
  -2.29207519e-02f, -3.09549440e-02f, 7.00957626e-02f, -4.64661829e-02f, -3.31137911e-03f, 9.61267650e-02f, -3.27440053e-02f, 3.77554744e-02f, -1.47733182e-01f, 2.06781793e-02f,
  2.72035986e-01f, -2.44288016e-02f, 4.68673967e-02f, -5.61174862e-02f, -3.80460545e-02f, 2.79615849e-01f, -3.32609098e-03f, -2.30396949e-02f, 4.19593714e-02f, 3.62235717e-02f,
  -1.39961809e-01f, 9.19988204e-04f, 6.92893863e-02f, 3.01842064e-01f, 1.80956014e-02f, -3.59138362e-02f, 3.53866406e-02f, -7.96302855e-02f, -1.39596581e-01f, -7.17008673e-03f,
  -2.48741098e-02f, -5.75354323e-02f, 5.16547412e-02f, -4.98067476e-02f, 3.59465368e-02f, 3.17096710e-02f, 1.18228599e-01f, 1.11398838e-01f, 1.71664923e-01f, 1.92165393e-02f,
  1.02675170e-01f, -1.05480634e-01f, 3.01210489e-03f, -2.30068505e-01f, -1.39786109e-01f, -2.64558762e-01f, -1.24435037e-01f, -1.41594475e-02f, 5.52708767e-02f, 2.07098559e-01f,
  -5.51876053e-02f, -2.67752744e-02f, 1.84702024e-01f, 4.36552614e-02f, 1.21262483e-01f, -1.02676913e-01f, 8.83734301e-02f, 5.25004379e-02f, 7.13345129e-03f, -1.76639874e-02f,
  -2.08313093e-02f, 3.34419906e-02f, 1.00256272e-01f, -5.15539385e-02f, 1.05922230e-01f, -9.00209397e-02f, 2.43071001e-02f, -4.83451001e-02f, 6.30371198e-02f, 2.57896837e-02f,
  1.29816368e-01f, 1.05336465e-01f, -5.22065256e-03f, 3.94424014e-02f, -2.30151370e-01f, -1.66475475e-01f, 5.88050224e-02f, -2.44907066e-02f, -1.01421131e-02f, -2.64064193e-01f,
  -2.71511078e-02f, 1.33256108e-01f, -4.30957712e-02f, -9.40701216e-02f, 8.86855721e-02f, -1.88564241e-01f, -2.17079576e-02f, -3.46881241e-01f, -6.90638795e-02f, -6.69169500e-02f,
  1.29824117e-01f, 1.94473386e-01f, -8.19278602e-03f, 5.67251444e-02f, 7.06861764e-02f, 2.46692281e-02f, -1.61171496e-01f, 2.96858177e-02f, 1.04238838e-01f, 5.90468906e-02f,
  -1.47066593e-01f, 1.76984705e-02f, 7.06991032e-02f, 6.30248990e-03f, -4.01033573e-02f, -1.16414160e-01f, 1.66574895e-01f, -3.94066334e-01f, 2.50003278e-01f, 8.53263661e-02f,
  1.00323305e-01f, -1.27918199e-01f, -6.13363050e-02f, 7.50607476e-02f, -6.47458509e-02f, 1.94829658e-01f, -1.90125424e-02f, 9.81540978e-02f, -6.77272305e-02f, -2.53555551e-02f,
  -2.46301889e-02f, -7.27855042e-02f, -1.13936387e-01f, 1.17647141e-01f, -7.56936073e-02f, -2.38520317e-02f, -1.00399278e-01f, -3.21359262e-02f, -1.02404848e-01f, 4.52290401e-02f,
  -2.23552901e-02f, -7.06892554e-03f, -1.26747966e-01f, -1.83764964e-01f, -1.51930615e-01f, 2.65067555e-02f, -1.56994775e-01f, -3.34105939e-02f, 1.77336961e-01f, 9.83430892e-02f,
  1.71046481e-01f, 9.14783403e-02f, 1.85226113e-01f, -9.44025815e-03f, 4.25606780e-02f, 7.93047547e-02f, 1.90156922e-01f, 1.79929528e-02f, 9.99385417e-02f, -3.17402259e-02f,
  4.73350249e-02f, -7.75277019e-02f, 3.83415334e-02f, -1.63331166e-01f, 6.09474294e-02f, 2.07849368e-02f, 1.56924143e-01f, -4.52892259e-02f, -2.21957445e-01f, -2.38612846e-01f,
  -2.84404725e-01f, 1.26029640e-01f, -7.53936097e-02f, 1.38409495e-01f, -2.40008131e-01f, -1.69453830e-01f, -1.00675479e-01f, -2.77964711e-01f, -2.35484943e-01f, -1.15758821e-01f,
  -3.80909517e-02f, 2.38938823e-01f, 2.05631718e-01f, 3.62505823e-01f, -1.57728568e-02f, -3.84872295e-02f, 1.69862248e-02f, 2.02848300e-01f, 7.28177279e-02f, -1.93327218e-01f,
  -1.21963307e-01f, 1.99393168e-01f, 8.42405409e-02f, -9.88585576e-02f, 3.15295421e-02f, 1.55442953e-02f, -7.98329785e-02f, -4.01284099e-02f, 5.47094010e-02f, -8.75108391e-02f,
  -1.52825471e-03f, 3.13483179e-02f, 1.89180970e-01f, 1.00961745e-01f, 5.92688061e-02f, -1.70001671e-01f, 8.95208269e-02f, 4.99215685e-02f, 1.91927657e-01f, -4.24162261e-02f,
  2.55517047e-02f, -1.24950044e-01f, -3.80770981e-01f, -3.74465175e-02f, -2.41941631e-01f, 6.51218295e-02f, -1.55434817e-01f, -2.98505276e-01f, 1.16263926e-01f, 8.49192888e-02f,
  -2.26708204e-01f, -2.48444557e-01f, -6.08475646e-03f, -1.56101346e-01f, 2.09724270e-02f, -9.65108648e-02f, -1.57792345e-01f, 1.26823680e-02f, 4.59850095e-02f, 1.38860801e-02f,
  1.06096260e-01f, -1.24501243e-01f, -2.16571018e-01f, -1.12315910e-02f, 2.03559786e-01f, 1.14770755e-01f, -1.44661993e-01f, -5.53417861e-01f, 4.73653488e-02f, -6.05843328e-02f,
  -1.36910826e-01f, 2.35661045e-01f, -1.07722446e-01f, -9.41779185e-03f, -2.32285067e-01f, 1.11253202e-01f, -3.14801857e-02f, 8.76828730e-02f, -5.55281155e-03f, 2.40346909e-01f
};

// L1_fan_Wp_bar (Shape: 14 x 64)
const int L1_fan_Wp_bar_rows = 14;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  8.41487348e-02f, 9.39508453e-02f, 3.14114690e-01f, 2.21595496e-01f, 3.54887322e-02f, 1.12534739e-01f, 2.87539601e-01f, -5.60256988e-02f, 1.40206441e-01f, 1.16826177e-01f,
  2.55053993e-02f, 1.50558889e-01f, 5.21367118e-02f, -8.88449624e-02f, 1.33975610e-01f, 1.39598608e-01f, 1.39093725e-02f, 8.65385085e-02f, -9.26334560e-02f, 1.30728588e-01f,
  -1.14884831e-01f, 2.58095026e-01f, 1.46188438e-01f, 6.40609562e-02f, 9.50189531e-02f, 6.51987195e-02f, 1.53050393e-01f, -5.23961075e-02f, -2.12436527e-01f, -2.47717481e-02f,
  -1.76142573e-01f, -9.17279273e-02f, -9.10499692e-02f, 3.03748176e-02f, 9.31167789e-03f, -5.87112829e-03f, 3.56484093e-02f, 2.40968838e-02f, 1.34465322e-01f, 1.91560015e-01f,
  -7.99504220e-02f, -2.31416747e-02f, -5.09184524e-02f, -1.40015595e-02f, -7.06061721e-02f, -3.81421596e-02f, -1.06145926e-01f, 1.39828861e-01f, 1.84374705e-01f, -1.20811323e-02f,
  -1.20638132e-01f, -3.01496595e-01f, 4.83612150e-01f, 8.72953087e-02f, -4.96232696e-02f, -3.54188643e-02f, -1.65686205e-01f, 3.06464821e-01f, -2.85730273e-01f, -6.15926422e-02f,
  2.18577132e-01f, -1.11294381e-01f, -2.55665720e-01f, 2.97890753e-01f, 1.46980017e-01f, 6.99249506e-02f, 3.22949998e-02f, 2.79786080e-01f, 9.12523568e-02f, 2.83709522e-02f,
  1.80559084e-01f, 9.16937441e-02f, 6.14089519e-03f, 1.29279464e-01f, 1.86946869e-01f, 9.41883698e-02f, -8.92124232e-03f, 1.89472109e-01f, 1.20400444e-01f, 4.13830252e-03f,
  1.25061823e-02f, 4.66605872e-02f, 4.75846194e-02f, 1.72679797e-01f, -3.42158675e-02f, 2.00218633e-01f, 1.96268708e-01f, -1.38022527e-02f, 4.83286642e-02f, 8.42372924e-02f,
  -2.52847701e-01f, -2.06115142e-01f, 5.79392910e-02f, -1.87815338e-01f, 1.84367284e-01f, -1.36452705e-01f, 1.34731745e-02f, -3.00951605e-03f, -8.87732953e-03f, 1.40031828e-02f,
  2.27534808e-02f, -1.22869782e-01f, 1.30159736e-01f, 4.23494056e-02f, -1.79824233e-02f, -6.77559972e-02f, 8.61377120e-02f, 8.15577433e-02f, -5.96499704e-02f, 3.62387523e-02f,
  6.68056533e-02f, 1.66612178e-01f, 1.21559717e-01f, 3.33888717e-02f, 2.06406817e-01f, 1.18303739e-01f, -7.32369646e-02f, -3.71305048e-01f, 3.24014813e-01f, 2.72473812e-01f,
  1.19915932e-01f, -2.07508862e-01f, 2.94442892e-01f, -6.62147999e-01f, -2.80604828e-02f, 3.74823413e-03f, -2.42350232e-02f, 1.90182492e-01f, 1.01123989e-01f, 1.53148305e-02f,
  4.72076796e-02f, 2.48640656e-01f, 1.53537691e-01f, 1.58833936e-01f, -5.06801605e-02f, 9.35984254e-02f, 2.23196179e-01f, 1.21782966e-01f, 1.62227347e-01f, 2.14033604e-01f,
  1.37695089e-01f, 4.51317042e-01f, 2.48167127e-01f, 2.40192160e-01f, 1.47978052e-01f, 4.23932122e-03f, 1.50428191e-01f, 8.99916291e-02f, 1.72378972e-01f, -1.83728442e-01f,
  -8.05159211e-02f, 3.09379697e-01f, -1.43721802e-02f, 2.44113535e-01f, 4.12470937e-01f, -6.59164190e-02f, 3.41473997e-01f, -1.47781465e-02f, 2.28368137e-02f, 2.19732314e-01f,
  2.96368927e-01f, -1.82888582e-01f, 8.38429183e-02f, 1.17873743e-01f, 4.52685589e-03f, 1.58873186e-01f, 1.84644252e-01f, 3.24504852e-01f, -8.94464180e-03f, -1.52724562e-02f,
  1.43107057e-01f, 5.49862161e-02f, -1.38109237e-01f, 1.07885167e-01f, 1.60845630e-02f, -5.48605323e-02f, -1.13405343e-02f, 1.03383690e-01f, 2.83929288e-01f, 7.56493926e-01f,
  -6.29003495e-02f, 8.10296237e-02f, -1.13253959e-01f, -2.21330374e-01f, 1.49853989e-01f, -3.03905755e-01f, -6.86563030e-02f, 1.70508906e-01f, -3.01102072e-01f, -2.32475973e-03f,
  -4.44451086e-02f, -1.96897224e-01f, -6.02186145e-03f, 2.73538738e-01f, 2.70353500e-02f, -6.96026608e-02f, 1.54562429e-01f, -2.74091139e-02f, 2.50506043e-01f, 2.22506329e-01f,
  9.17058513e-02f, 9.01575908e-02f, 6.68160841e-02f, 2.44322076e-01f, 1.11001208e-02f, -5.46702333e-02f, 5.07279076e-02f, 1.50741965e-01f, 1.37058258e-01f, 1.60180464e-01f,
  -7.21476153e-02f, 2.10915133e-01f, 2.15649173e-01f, 2.38335654e-01f, 2.22873390e-01f, 1.12227730e-01f, 2.83611696e-02f, 7.41799921e-02f, -3.25486332e-01f, 6.26889104e-03f,
  9.95842665e-02f, -1.19947664e-01f, -1.08673617e-01f, -3.52549344e-01f, -1.87426340e-02f, 1.14624240e-01f, -7.15013817e-02f, -1.71312526e-01f, -1.84349537e-01f, -1.60021678e-01f,
  -1.44389361e-01f, -2.10036874e-01f, -1.63421724e-02f, 4.33189720e-01f, -1.05486579e-01f, 1.37748808e-01f, -1.19441234e-01f, 1.03212073e-01f, 2.12551385e-01f, 1.03385702e-01f,
  2.35862702e-01f, -2.78905600e-01f, -1.93288177e-01f, -6.76334128e-02f, 7.75174350e-02f, 1.28146531e-02f, -3.64183895e-02f, 4.16245282e-01f, 2.15697065e-01f, 2.10203484e-01f,
  -2.50540525e-01f, -1.93859357e-02f, 2.20522806e-01f, -1.90096349e-01f, -1.03549577e-01f, 1.29405141e-01f, 7.59909302e-02f, 1.12803161e-01f, 3.95132937e-02f, -1.45300254e-01f,
  1.00051433e-01f, 6.24983311e-02f, 1.55993938e-01f, 5.07026818e-03f, -1.87077709e-02f, 7.32751936e-02f, 7.84308761e-02f, 1.45483688e-01f, -3.99118960e-02f, 2.17376634e-01f,
  -9.21701416e-02f, 2.90938448e-02f, 5.04105091e-02f, 2.38693863e-01f, 8.23410526e-02f, 2.99135625e-01f, 4.48003374e-02f, 3.80894840e-01f, 1.74946830e-01f, -1.91628546e-01f,
  1.12225734e-01f, 2.04522498e-02f, -1.49842113e-01f, -8.49394575e-02f, 1.16980029e-02f, -2.94016004e-01f, -4.76153642e-02f, 9.96945351e-02f, -2.15312675e-01f, 1.59731343e-01f,
  -1.00214422e-01f, 2.02590168e-01f, 9.76564139e-02f, 9.02389660e-02f, -2.03081384e-01f, -2.39586458e-01f, -6.72311485e-02f, -8.28689188e-02f, 6.59204721e-02f, 2.22217903e-01f,
  -1.46834001e-01f, -1.80026919e-01f, 4.32451248e-01f, -2.52816528e-01f, -2.28170663e-01f, -6.89952821e-02f, 4.18555029e-02f, 5.26215173e-02f, 1.30472705e-01f, 1.04219064e-01f,
  2.96749115e-01f, -2.37685025e-01f, -2.78399736e-01f, 2.98197180e-01f, 3.02713364e-01f, -4.59623523e-02f, 3.58496398e-01f, 3.04651380e-01f, -1.46748707e-01f, 8.94037038e-02f,
  -4.46468666e-02f, -2.56556958e-01f, -1.18420169e-01f, 4.40883525e-02f, -4.07671034e-02f, 2.46746197e-01f, -1.59670841e-02f, -2.05441602e-02f, 1.31061217e-02f, -2.42947623e-01f,
  -5.92826605e-02f, 1.79707915e-01f, -2.20707967e-03f, -2.42130682e-01f, -2.05455989e-01f, -4.81713712e-02f, -1.29168242e-01f, 1.04313418e-01f, -2.32715592e-01f, -8.65856484e-02f,
  -3.07507366e-01f, 2.59891331e-01f, -1.07946806e-01f, 8.41672570e-02f, 3.52314077e-02f, -2.55614202e-02f, 5.09320378e-01f, -1.76030546e-01f, -2.32201397e-01f, 8.34840760e-02f,
  1.10185027e-01f, 2.31870502e-01f, -5.84593534e-01f, 3.32936123e-02f, 1.47606045e-01f, 3.77058029e-01f, -9.11187828e-02f, 1.74782097e-01f, 1.38447195e-01f, 4.31553990e-01f,
  1.82716593e-01f, 4.01864350e-01f, -6.28144965e-02f, -2.19667122e-01f, 6.23044893e-02f, -1.11420661e-01f, -1.48675665e-01f, -2.77344495e-01f, 1.18490502e-01f, 1.03516340e-01f,
  -9.29404944e-02f, 1.30115762e-01f, -4.83509719e-01f, -3.24934691e-01f, 1.77025609e-02f, -5.30302227e-01f, -1.96147069e-01f, 4.30733800e-01f, -1.25312567e-01f, 1.26657933e-01f,
  -6.68725595e-02f, 1.74363270e-01f, -3.96182746e-01f, -2.94095129e-01f, 1.54601231e-01f, 3.12611870e-02f, -5.58267981e-02f, 1.95757017e-01f, 1.97013557e-01f, -9.05660447e-03f,
  -2.73879785e-02f, 1.35680541e-01f, 6.77289888e-02f, 9.60826129e-02f, -4.64841165e-02f, 1.16222523e-01f, 8.51197094e-02f, 7.58593008e-02f, 1.16898552e-01f, 1.00866131e-01f,
  9.21074152e-02f, 1.81788936e-01f, 5.08893691e-02f, 5.09547852e-02f, 9.13919434e-02f, -3.69738676e-02f, 9.81863216e-02f, -4.81824391e-02f, 5.94561771e-02f, -1.64154664e-01f,
  1.67859972e-01f, 2.37736404e-01f, 2.49929819e-02f, 1.10105969e-01f, -1.62824720e-01f, 5.95222153e-02f, -1.47527575e-01f, 6.90452456e-02f, 1.62933782e-01f, -1.73256859e-01f,
  1.24171980e-01f, 5.84670082e-02f, -1.74317479e-01f, -4.15552378e-01f, -9.36942473e-02f, -8.76973495e-02f, 8.91335458e-02f, 3.53626371e-03f, 1.47817761e-01f, -2.00856850e-01f,
  -7.92585164e-02f, -2.96611756e-01f, -7.54471570e-02f, 7.96969384e-02f, -6.93565682e-02f, -7.14942217e-02f, 1.57204419e-01f, 3.18040669e-01f, -1.39171700e-03f, -1.25459954e-01f,
  -3.44793141e-01f, 1.60504743e-01f, -9.95321274e-02f, 5.19838989e-01f, 2.31411047e-02f, 2.67831385e-01f, 3.93038541e-02f, 1.34538010e-01f, 8.00990760e-02f, 1.85157835e-01f,
  2.13377059e-01f, 1.88999563e-01f, -6.20043278e-02f, 1.71272382e-01f, 1.44626975e-01f, 1.50782645e-01f, 1.21330842e-01f, 1.60371199e-01f, -2.80870385e-02f, 1.59482479e-01f,
  2.78538376e-01f, 6.53247088e-02f, 3.26979607e-01f, 2.41600543e-01f, 1.98695604e-02f, -7.70282000e-02f, 1.83324337e-01f, 2.60949936e-02f, 1.90737367e-01f, -6.19175620e-02f,
  1.16933687e-02f, 1.06162868e-01f, 1.12502858e-01f, -1.97442621e-01f, 5.71989000e-01f, 2.12161511e-01f, -1.79872647e-01f, 7.70065114e-02f, -1.14346333e-01f, 2.51799196e-01f,
  2.77853459e-01f, -4.32695955e-01f, 7.18983784e-02f, 1.70309529e-01f, -3.19791704e-01f, -1.37630522e-01f, 3.11996281e-01f, 5.23890555e-01f, -9.39803571e-02f, -3.24916244e-01f,
  -6.12839274e-02f, 4.98074181e-02f, 1.64100766e-01f, 3.19861174e-01f, -2.94219851e-01f, 1.17753062e-03f, 5.00518441e-01f, 4.16883901e-02f, 9.13646817e-02f, -1.83701620e-01f,
  2.16209054e-01f, 9.51775387e-02f, -3.85130644e-02f, 3.83554101e-01f, 1.31467730e-01f, -8.29176158e-02f, 1.47421747e-01f, 1.26929447e-01f, -4.42426205e-01f, -7.18758926e-02f,
  -4.41725641e-01f, 3.08099091e-01f, 1.09078005e-01f, 5.33763086e-03f, -1.55610487e-01f, 5.77486865e-02f, 5.23831807e-02f, 1.42086357e-01f, 4.03222665e-02f, 3.17105323e-01f,
  2.62580842e-01f, -3.07094287e-02f, 1.40976623e-01f, 2.28926107e-01f, 2.36748800e-01f, 9.61848274e-02f, 8.35338309e-02f, 1.55828610e-01f, 2.27344200e-01f, 4.22294550e-02f,
  2.35738475e-02f, 7.67896324e-02f, 4.68020141e-01f, 1.11077011e-01f, 1.68451607e-01f, 1.26193538e-01f, -1.82835773e-01f, 7.14456197e-03f, 1.60375431e-01f, 5.01252525e-02f,
  1.00887775e-01f, -2.52499580e-01f, -3.60519066e-02f, 4.59034666e-02f, -1.30249053e-01f, 1.70629725e-01f, -7.28908852e-02f, 2.79298169e-03f, -5.76247983e-02f, -6.25771880e-02f,
  -1.39870554e-01f, -3.06958500e-02f, -3.21138687e-02f, 2.31528893e-01f, 1.27157639e-03f, -8.83335769e-02f, -2.10092574e-01f, 1.26599014e-01f, 2.92689592e-01f, -5.26351631e-02f,
  -1.47254631e-01f, -3.51140410e-01f, -2.92798579e-01f, 1.40878603e-01f, 4.13814664e-01f, 3.56676847e-01f, -8.31610337e-02f, -2.38523990e-01f, 1.31780714e-01f, 9.09799412e-02f,
  -3.74560714e-01f, 3.40278834e-01f, 3.67857069e-02f, -2.10247666e-01f, -6.35147691e-02f, -8.19689110e-02f, 1.14989951e-02f, -1.67118713e-01f, -9.65351686e-02f, 1.44964039e-01f,
  4.75671887e-02f, 1.12605534e-01f, -1.39634982e-01f, 4.38145138e-02f, 9.12284777e-02f, -6.92059025e-02f, 1.45836890e-01f, 5.92558458e-02f, 1.89487293e-01f, 1.40411183e-01f,
  -9.18429568e-02f, 1.64852738e-01f, 1.65171787e-01f, 4.35048006e-02f, -5.90449758e-03f, 4.32941839e-02f, 1.81089222e-01f, 4.96404525e-03f, 1.72082093e-02f, 1.35390282e-01f,
  -7.18021616e-02f, -5.90338781e-02f, 4.30260748e-01f, 7.29646981e-02f, 2.04286501e-01f, -6.56427592e-02f, -6.20477013e-02f, 3.24602813e-01f, -1.21544503e-01f, 1.15130968e-01f,
  -6.61892863e-03f, -1.98893651e-01f, -2.14708045e-01f, 7.80662447e-02f, -1.75517052e-01f, 1.78541020e-01f, 3.13265353e-01f, -8.82074982e-03f, 5.13319373e-02f, 1.14857825e-02f,
  1.90948267e-02f, 1.41721681e-01f, -1.01669423e-01f, -2.94899106e-01f, -2.98774838e-01f, -2.25021783e-02f, -2.79975176e-01f, 9.80599523e-02f, 2.89476991e-01f, 3.74302328e-01f,
  2.80341897e-02f, -5.65668605e-02f, -3.50228772e-02f, 1.21681146e-01f, -1.45664349e-01f, 4.84509796e-01f, 2.27007495e-05f, -9.23898220e-02f, -9.46544334e-02f, -2.41957262e-01f,
  1.78110152e-01f, 3.23243916e-01f, 1.25367865e-01f, 2.62798190e-01f, 2.65753895e-01f, 4.51284088e-02f, -1.04827978e-01f, 2.05762774e-01f, 2.13953666e-02f, 1.01953387e-01f,
  1.28225714e-01f, 2.60599107e-01f, 1.50468960e-01f, 9.88800973e-02f, 2.85356313e-01f, 1.52515173e-01f, 4.11321595e-03f, 1.77726373e-01f, 3.79977942e-01f, 1.58048004e-01f,
  -1.09478258e-01f, -2.52035968e-02f, 1.78421676e-01f, -4.87162024e-02f, 2.74226010e-01f, -5.59225567e-02f, -1.49626821e-01f, -6.90955967e-02f, -2.74135172e-02f, -1.90207232e-02f,
  1.20954163e-01f, 1.09081976e-01f, 1.89246804e-01f, 9.52249020e-02f, 5.74189052e-02f, 3.06148566e-02f, 3.73120695e-01f, -1.18123489e-02f, 1.42314732e-01f, -1.76924437e-01f,
  7.99716935e-02f, -5.14488041e-01f, 5.63728390e-03f, -1.65584758e-01f, 3.75843227e-01f, -2.29861677e-01f, -4.81693335e-02f, 2.45688464e-02f, -2.87635744e-01f, 2.80699700e-01f,
  1.26942858e-01f, 6.37370348e-02f, -4.40843523e-01f, 6.79871114e-03f, 5.21625252e-03f, 8.64247009e-02f, -2.22993255e-01f, -5.97268343e-02f, 8.51102993e-02f, 2.89488077e-01f,
  4.73497391e-01f, 2.03929052e-01f, -1.88142359e-01f, -9.80353132e-02f, 5.68145290e-02f, 2.16948122e-01f, -5.96136041e-02f, 1.09334357e-01f, 4.58368585e-02f, -3.51234488e-02f,
  2.27024376e-01f, 1.14734344e-01f, 9.57353711e-02f, 6.34662881e-02f, -4.11829054e-02f, -4.99072624e-03f, 4.04853821e-02f, 1.38310254e-01f, 2.84419745e-01f, 1.00638449e-01f,
  -1.33004412e-02f, -4.08244431e-02f, 3.89861502e-02f, -2.03446537e-01f, -9.36726481e-03f, 1.08642951e-02f, 1.97433963e-01f, 1.49330407e-01f, 1.42156869e-01f, -9.90011320e-02f,
  -3.54848713e-01f, -1.10586630e-02f, 1.45941183e-01f, 1.19589046e-01f, -1.37005644e-02f, -2.66242653e-01f, 1.68786466e-01f, -1.91482194e-02f, -8.35446864e-02f, -1.93311155e-01f,
  -1.46000952e-01f, -1.38823614e-01f, -1.69783771e-01f, -1.72651261e-02f, -4.15827744e-02f, -1.07590305e-02f, -3.13632861e-02f, -2.95761917e-02f, -1.05965190e-01f, 1.00395098e-01f,
  -6.14395700e-02f, -9.01812315e-02f, 2.03680426e-01f, 2.24698298e-02f, -1.29654899e-01f, 1.15023345e-01f, -7.88693503e-02f, -3.21617387e-02f, 1.51990905e-01f, 5.11944175e-01f,
  3.59381795e-01f, -1.34086058e-01f, 2.18458608e-01f, 1.61145002e-01f, 5.87891638e-02f, 6.09972328e-02f, 1.88496754e-01f, -4.76875007e-01f, -2.14910787e-03f, 3.10866058e-01f,
  1.05813764e-01f, 8.75774100e-02f, -3.55870761e-02f, 2.09605977e-01f, 3.24356526e-01f, 1.68598384e-01f, 2.08424702e-01f, -4.52367440e-02f, 1.49748707e-02f, 1.10181101e-01f,
  1.42072931e-01f, 1.36391670e-01f, 1.51303872e-01f, 1.05398849e-01f, 2.65287668e-01f, 5.62707148e-02f, 1.22204728e-01f, -1.30632762e-02f, 1.80630848e-01f, -8.12079106e-03f,
  2.54181057e-01f, 2.62408167e-01f, 2.02260353e-02f, 1.19125828e-01f, -2.56467700e-01f, 4.80855294e-02f, -3.48942801e-02f, 2.17270255e-02f, -7.48244748e-02f, -5.76491475e-01f,
  -3.51743475e-02f, 1.39274299e-01f, -3.26140895e-02f, -2.37272844e-01f, -1.87941492e-02f, 3.38239339e-03f, 2.28406135e-02f, -9.08724442e-02f, -1.79149806e-01f, 3.46731544e-01f,
  -9.51379389e-02f, 2.71311626e-02f, -2.86268331e-02f, 2.10301220e-01f, -7.01385811e-02f, 1.56819880e-01f, -2.05708370e-02f, 6.50595129e-02f, -2.82199234e-01f, 1.19622745e-01f,
  2.10571513e-02f, -6.86637983e-02f, 8.87086913e-02f, 3.84607732e-01f, 1.95489317e-01f, 1.49075791e-01f, 9.42663625e-02f, 8.91916528e-02f, 2.05076501e-01f, 1.97906613e-01f,
  1.61659509e-01f, 1.13898264e-02f, 3.46629061e-02f, -8.56728256e-02f, -6.93552569e-02f, 1.22115053e-01f, -4.94518038e-03f, -7.54736364e-02f, 1.12160660e-01f, -4.67639901e-02f,
  3.98688167e-02f, 3.19570825e-02f, 3.73667513e-04f, -8.31255913e-02f, -2.42110148e-01f, -7.31104687e-02f, -1.12343272e-02f, 1.35247260e-01f, -5.33680245e-02f, -1.12717748e-02f,
  -8.01941101e-03f, -8.03973619e-03f, -1.16117746e-01f, 8.36178754e-03f, 5.33683114e-02f, -2.03802343e-02f, 1.50886318e-02f, 1.17183879e-01f, -1.11328699e-01f, -1.48925006e-01f,
  2.11266354e-01f, -4.41313237e-02f, 2.26594508e-01f, 1.15504973e-01f, -1.66324712e-02f, 3.41846384e-02f, -5.00150993e-02f, 1.11799583e-01f, 1.85963571e-01f, 2.11898580e-01f,
  1.02850318e-01f, -1.21333547e-01f, 1.78923327e-02f, -7.08315000e-02f, 1.12641275e-01f, -2.36257985e-02f, 1.83106557e-01f, -2.09039807e-01f, -1.50476515e-01f, 7.06291646e-02f,
  -2.64123410e-01f, 7.35565647e-02f, 9.67269689e-02f, 5.81807673e-01f, -3.03574979e-01f, -2.53762662e-01f, 6.26967847e-02f, -3.51619273e-01f, -4.02018040e-01f, -3.60490590e-01f,
  -3.38116735e-01f, -2.21559927e-01f, 1.98038548e-01f, -6.53785095e-02f, 2.18813345e-01f, -1.55262709e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 14)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 14;
const float L1_fan_Bp_bar_data[] = {
  2.07413703e-01f, -1.75379254e-02f, 2.06091687e-01f, 9.10411328e-02f, 2.60401577e-01f, 1.57693878e-01f, 5.21808676e-02f, 2.33755052e-01f, 5.48829362e-02f, 1.75733522e-01f,
  7.52735510e-02f, -1.75860934e-02f, 1.44257471e-01f, 1.51151225e-01f
};

// L2_fan_Wp (Shape: 25 x 64)
const int L2_fan_Wp_rows = 25;
const int L2_fan_Wp_cols = 64;
const float L2_fan_Wp_data[] = {
  7.61611834e-02f, 7.06626326e-02f, -2.00418517e-01f, 6.95593003e-03f, 3.00804287e-01f, -1.05434500e-01f, -1.76784277e-01f, -2.16750335e-02f, -1.91315666e-01f, 2.39006117e-01f,
  -1.09919086e-01f, 9.46536958e-02f, 1.06347591e-01f, 9.13747773e-02f, 1.77113920e-01f, 1.80009097e-01f, 4.02993679e-01f, 1.46052450e-01f, 2.39251275e-02f, 2.49789923e-01f,
  2.11726084e-01f, 7.94817731e-02f, -1.80714801e-01f, 8.45458806e-02f, -2.81965826e-02f, -2.23814938e-02f, -1.66198209e-01f, -1.41695350e-01f, -2.41278857e-01f, 1.59897283e-01f,
  -6.26985878e-02f, 3.05523992e-01f, -1.08495168e-01f, 1.33779436e-01f, 9.51405689e-02f, -9.56415758e-02f, -5.15399016e-02f, -3.51422727e-01f, 3.60549688e-01f, 4.27689292e-02f,
  -1.77180208e-02f, 6.49531260e-02f, -1.27001822e-01f, -3.27488869e-01f, -1.50180748e-02f, 1.56448055e-02f, 1.35879576e-01f, 5.44254519e-02f, -2.97187865e-01f, -1.40762394e-02f,
  1.00332210e-02f, 3.31958011e-02f, -1.35908023e-01f, 5.54224364e-02f, 3.01502883e-01f, 6.22767806e-02f, -2.22948968e-01f, 2.15470627e-01f, -2.55224317e-01f, -2.37045780e-01f,
  2.80588772e-02f, 4.02079336e-02f, -2.33544409e-01f, -6.64182305e-02f, 2.46118814e-01f, 9.78849754e-02f, -1.09026097e-01f, 1.90705210e-02f, 1.02248251e-01f, -5.06127030e-02f,
  2.79478412e-02f, 2.34579504e-01f, 1.20936722e-01f, -3.80268432e-02f, 1.19561858e-01f, 1.86067969e-01f, -2.36698091e-01f, 1.83487207e-01f, 1.87718555e-01f, -1.70830250e-01f,
  -2.56922394e-01f, -4.29230891e-02f, 2.25496478e-02f, -1.39947897e-02f, -1.36711821e-01f, -1.84675977e-01f, 2.79214650e-01f, -1.30850477e-02f, -8.54540467e-02f, -5.23147434e-02f,
  -1.51446581e-01f, -1.36309102e-01f, -6.68211132e-02f, -2.34369799e-01f, -1.56937212e-01f, -1.84577256e-01f, -1.76463258e-02f, 1.47651330e-01f, 2.10234225e-01f, 5.07096723e-02f,
  -9.30221081e-02f, 1.99256912e-01f, 1.27458781e-01f, -4.06205617e-02f, -3.75534222e-02f, -1.76088557e-01f, 3.50223750e-01f, 1.85370013e-01f, 1.10745184e-01f, 1.19010650e-01f,
  8.63833204e-02f, -1.64222136e-01f, -1.33459538e-03f, -1.42798096e-01f, 1.03891701e-01f, 8.57330952e-03f, -6.87502921e-02f, 7.62497261e-02f, 2.01347079e-02f, -1.27373219e-01f,
  -1.00321442e-01f, 6.63597956e-02f, 3.58559877e-01f, 8.26750696e-02f, -6.46260101e-04f, -2.44104460e-01f, -1.04372472e-01f, -1.29023060e-01f, -1.45313352e-01f, -1.77534133e-01f,
  -7.95027334e-03f, -4.42995839e-02f, -5.06186895e-02f, -1.58796199e-02f, -2.25171357e-01f, 2.06426769e-01f, -8.00767262e-03f, -1.55192345e-01f, 6.55268133e-02f, -8.12042803e-02f,
  5.55939339e-02f, -8.23979452e-02f, -1.20570637e-01f, -1.24715701e-01f, -2.44996652e-01f, 8.22483748e-02f, 1.88835561e-01f, 6.09337501e-02f, -1.37816265e-01f, -1.91300616e-01f,
  1.19158216e-01f, 2.14915723e-02f, -6.44824235e-03f, 1.92889795e-01f, -4.28922027e-02f, 6.16499893e-02f, 4.49342817e-01f, 2.68667042e-01f, -6.12882636e-02f, 2.34100930e-02f,
  -1.12368636e-01f, -3.14719379e-01f, -3.16183746e-01f, -5.03082909e-02f, -1.19543344e-01f, -8.88932787e-04f, 1.38640061e-01f, 1.21998712e-01f, 2.33212471e-01f, 2.22056299e-01f,
  -7.19675571e-02f, 1.81998953e-01f, -3.15261424e-01f, -4.87816259e-02f, -2.41009712e-01f, 2.34461337e-01f, 1.18009541e-02f, 5.30293547e-02f, -2.49535814e-01f, -9.61572956e-03f,
  7.66739175e-02f, 8.54052678e-02f, -2.87118375e-01f, 6.92874193e-02f, -2.02790841e-01f, 1.37575090e-01f, -6.28471840e-03f, -3.69780511e-02f, 1.65208563e-01f, 1.44283503e-01f,
  1.09041028e-01f, -1.55474469e-01f, -8.28956142e-02f, 6.68757632e-02f, -1.40762761e-01f, 9.11581144e-02f, -1.24691986e-01f, -1.92600727e-01f, 2.25684077e-01f, 1.54343084e-01f,
  9.88409370e-02f, -2.08158940e-01f, 2.32118800e-01f, 2.79934891e-02f, -1.41426697e-01f, -1.53594851e-01f, -1.71293821e-02f, -1.29088968e-01f, -4.55851294e-02f, 1.50967330e-01f,
  -1.27531394e-01f, -9.41500664e-02f, 1.27479091e-01f, -1.10510729e-01f, -1.99469417e-01f, -5.04548997e-02f, 1.60688356e-01f, 7.71041662e-02f, -1.68344676e-01f, 1.57945976e-01f,
  5.84399402e-02f, 2.04253107e-01f, -1.13132246e-01f, 1.69230163e-01f, -2.27957979e-01f, -9.81746092e-02f, 5.65707125e-02f, -1.85055137e-01f, -1.48535714e-01f, -3.06187242e-01f,
  3.31352204e-02f, 8.22052266e-03f, -6.57684123e-03f, 3.48238766e-01f, -4.70775925e-02f, -7.36457258e-02f, 2.48761937e-01f, 8.57210159e-02f, -2.27783442e-01f, 1.58911049e-01f,
  -4.35244180e-02f, 9.90869328e-02f, -2.54268944e-01f, -7.82139599e-02f, -5.40563129e-02f, 1.12133816e-01f, 5.94450571e-02f, -1.29540488e-02f, 9.44528505e-02f, -1.87969968e-01f,
  -1.01500519e-01f, -1.61382124e-01f, 1.68006524e-01f, 1.71379402e-01f, 1.20171346e-01f, -2.06838585e-02f, 2.87373751e-01f, -2.39388272e-01f, -9.70384032e-02f, 1.55665666e-01f,
  -3.58572155e-02f, -1.12397060e-01f, -3.00466269e-01f, -1.48956701e-01f, 3.90623808e-02f, -4.51704822e-02f, -4.49270420e-02f, 1.40036851e-01f, 2.79991366e-02f, -4.04508486e-02f,
  -8.62819888e-03f, 1.46411940e-01f, 9.24315974e-02f, 1.37048557e-01f, -4.15676320e-03f, 1.83116227e-01f, -2.58659888e-02f, 2.11826965e-01f, -1.86391585e-02f, -1.42152347e-02f,
  -1.96778178e-02f, -4.46598642e-02f, -2.81840384e-01f, -5.68428859e-02f, -1.67102650e-01f, 1.23361640e-01f, 3.07709202e-02f, 1.26999661e-01f, -2.44943514e-01f, 2.00461730e-01f,
  1.54959738e-01f, 2.54312307e-01f, -1.04940593e-01f, 3.45331132e-02f, 2.51899548e-02f, -1.45192116e-01f, -1.93024054e-01f, -1.57012288e-02f, 1.24216624e-01f, 5.63925207e-02f,
  -9.69388857e-02f, -2.21772179e-01f, 1.96677729e-01f, -9.86693725e-02f, -2.07986489e-01f, -3.26808244e-02f, 2.18799740e-01f, 2.18596622e-01f, -1.96076497e-01f, -8.77622366e-02f,
  9.63621661e-02f, 2.61686772e-01f, -5.24169244e-02f, 1.47290364e-01f, -3.26273441e-01f, -1.77300662e-01f, -4.96417768e-02f, -2.65408069e-01f, -5.77205718e-02f, 1.15337200e-01f,
  4.64340039e-02f, -2.37727374e-01f, 1.20458946e-01f, -5.74689582e-02f, 5.27960621e-03f, -1.65478468e-01f, -1.66568950e-01f, -1.65558338e-01f, 2.60941405e-02f, 2.92379297e-02f,
  3.27699445e-02f, -9.00172219e-02f, -3.86490300e-02f, -2.30960518e-01f, -2.51942605e-01f, -1.91376787e-02f, -1.13305628e-01f, 1.21910028e-01f, 2.30341315e-01f, 1.11720935e-01f,
  1.67534247e-01f, -3.52708041e-03f, -1.35132801e-02f, 7.46574700e-02f, -1.06877230e-01f, -2.50427634e-01f, 7.08167776e-02f, -1.06563449e-01f, 1.67690031e-02f, 2.58584917e-01f,
  1.70174345e-01f, -2.34067496e-02f, -1.72914535e-01f, -9.66546033e-03f, 6.36920184e-02f, -1.53270215e-01f, 1.41600266e-01f, -3.84237021e-01f, 1.51090682e-01f, 1.09566770e-01f,
  6.75576106e-02f, 4.15452570e-01f, -1.95029274e-01f, -7.27567822e-02f, -2.34225765e-02f, -2.31470615e-01f, 1.54678285e-01f, -2.07489595e-01f, -1.16244487e-01f, 6.98981583e-02f,
  1.33693695e-01f, 2.46383145e-01f, -2.22656988e-02f, -1.17504120e-01f, -9.30392742e-02f, 2.64936000e-01f, 6.50907233e-02f, 7.30909780e-02f, -1.26601353e-01f, -9.12939683e-02f,
  2.77797505e-02f, 2.37832069e-01f, -2.03504041e-02f, -1.57275423e-02f, -2.22771596e-02f, -1.93918291e-02f, 1.16896614e-01f, 8.59132223e-03f, -3.32648080e-04f, -6.32115975e-02f,
  -2.52289385e-01f, -1.37034461e-01f, -2.43589971e-02f, -1.49835214e-01f, -1.30844861e-01f, 2.27034479e-01f, -2.09073409e-01f, 2.86492527e-01f, 1.02129310e-01f, 1.64142594e-01f,
  -7.90046230e-02f, -2.60068178e-01f, -1.55712470e-01f, -2.21924871e-01f, -4.28966507e-02f, 6.89015090e-02f, 1.26903549e-01f, -3.24270241e-02f, -5.27694635e-02f, 9.97047722e-02f,
  -1.80885240e-01f, 2.08133440e-02f, 4.67961952e-02f, -2.08192900e-01f, 2.03540437e-02f, -1.55334949e-01f, 3.07429343e-01f, 1.37298152e-01f, 9.56336111e-02f, -1.15338571e-01f,
  4.00611088e-02f, 2.68789619e-01f, -5.06356321e-02f, 5.76344039e-03f, 1.42112777e-01f, -3.71780485e-01f, 2.25805059e-01f, -3.88323963e-02f, 7.46272430e-02f, 1.46135077e-01f,
  2.61355281e-01f, -1.47901475e-01f, 5.38392924e-02f, -1.18942233e-02f, -4.05773317e-04f, -8.51342753e-02f, 1.25333387e-03f, 1.81752726e-01f, 2.91646291e-02f, -1.14175990e-01f,
  -1.88874477e-03f, 1.07606679e-01f, 1.99921608e-01f, 2.02139810e-01f, -1.84993550e-01f, -1.50577417e-02f, -8.88813585e-02f, -1.36322170e-01f, 1.34242862e-01f, -1.95710212e-01f,
  7.65822604e-02f, -2.26200715e-01f, -3.63881476e-02f, 1.70352943e-02f, -9.00430307e-02f, -8.03411976e-02f, -8.18791315e-02f, 1.25709370e-01f, -6.63853437e-02f, -3.92800802e-03f,
  1.09462857e-01f, 6.19796403e-02f, 2.90700853e-01f, 3.36060643e-01f, 1.58651024e-01f, 3.72235663e-02f, 1.76266134e-01f, 1.03824772e-01f, 4.61885668e-02f, -1.39320940e-01f,
  2.75227100e-01f, 1.08915947e-01f, -1.55612364e-01f, -2.68830001e-01f, 1.08653627e-01f, -7.51409754e-02f, -1.61423519e-01f, 5.76888658e-02f, -2.56101061e-02f, 4.68285941e-02f,
  -1.22314230e-01f, 5.21788262e-02f, 1.14470467e-01f, 1.22358963e-01f, -1.85174718e-02f, 1.34417024e-02f, 1.31368220e-01f, -1.33759156e-02f, -1.37060404e-01f, -2.41556495e-01f,
  3.84857953e-01f, 1.10737085e-01f, 2.02780187e-01f, 2.77644210e-02f, 1.97575554e-01f, -1.42780423e-01f, 1.08911522e-01f, -9.31633338e-02f, 1.35981157e-01f, -1.11200146e-01f,
  1.37126073e-01f, -1.38412878e-01f, 1.41070858e-01f, 2.81196773e-01f, 4.54434268e-02f, 1.78108171e-01f, -3.41501199e-02f, -6.80706836e-03f, -1.21845379e-02f, -1.88138157e-01f,
  -1.40571862e-01f, -3.88676405e-01f, -3.33705954e-02f, 1.58560202e-02f, 1.03193827e-01f, 3.08638811e-01f, 2.01949671e-01f, -2.81212684e-02f, -2.68889338e-01f, 1.85634762e-01f,
  8.93261284e-02f, -1.88596264e-01f, 2.62405239e-02f, 3.04634452e-01f, 1.45380393e-01f, -4.43002358e-02f, 1.67991817e-01f, -1.37221590e-02f, -8.00964236e-02f, -1.11391060e-01f,
  1.49442047e-01f, -8.58145207e-02f, 3.04976702e-01f, 8.48543048e-02f, 1.99001893e-01f, 2.84031183e-01f, 9.40061212e-02f, 1.85537025e-01f, -1.96667556e-02f, 2.96658248e-01f,
  -1.18565366e-01f, 3.04685766e-03f, -1.90069359e-02f, 1.68942660e-01f, 4.32321541e-02f, 1.30264491e-01f, -2.62790471e-01f, -1.19612373e-01f, 1.55713055e-02f, 7.40695139e-03f,
  -3.76219720e-01f, 6.85535893e-02f, -7.36042634e-02f, -1.90323129e-01f, -2.28006691e-02f, -8.64127800e-02f, -4.05813307e-02f, -1.13486327e-01f, -7.98654333e-02f, 3.19610059e-01f,
  5.25793806e-02f, 2.18116611e-01f, 1.22346960e-01f, 6.25914633e-02f, -8.03707168e-02f, 2.32228218e-03f, 8.64547119e-02f, -2.62041986e-01f, 7.24491104e-02f, -1.75790668e-01f,
  -1.27064452e-01f, -5.93352690e-02f, 3.09386760e-01f, -1.42986938e-01f, -6.70966431e-02f, 5.28469495e-02f, 5.06676100e-02f, 4.30357829e-03f, -2.07514629e-01f, 1.75987810e-01f,
  2.13164911e-02f, -6.86191395e-02f, 1.71286672e-01f, 2.74169026e-04f, -4.31217439e-02f, -7.21188188e-02f, 7.19528571e-02f, 2.98812181e-01f, -1.43079400e-01f, -9.53552127e-03f,
  -6.20888621e-02f, -2.19703972e-01f, 1.15568172e-02f, 1.86330527e-01f, 1.83288287e-02f, 1.31360993e-01f, 1.14945330e-01f, -1.64470226e-01f, -1.14334017e-01f, 3.01899426e-02f,
  4.99558188e-02f, 2.53252871e-02f, -3.85937452e-01f, -3.69797200e-02f, 2.45515481e-01f, 6.98760003e-02f, 4.13671769e-02f, 1.46847665e-01f, -5.46915494e-02f, 1.16994968e-02f,
  7.31157343e-05f, -1.95007205e-01f, -1.87995031e-01f, -8.49177390e-02f, -8.32954869e-02f, -2.34066695e-02f, 6.75258264e-02f, 1.96931705e-01f, -4.60294485e-02f, 1.99422285e-01f,
  1.75525621e-01f, -3.32035460e-02f, -1.50360048e-01f, 9.48019475e-02f, -1.18845165e-01f, -5.37716262e-02f, -3.34692448e-02f, 8.18071067e-02f, -1.95461363e-01f, 1.62675336e-01f,
  1.46808788e-01f, -3.83702060e-03f, -7.83287585e-02f, -1.13838203e-01f, -2.57690959e-02f, -1.47085622e-01f, 4.72087413e-02f, 2.14879304e-01f, 1.56771109e-01f, -3.29514027e-01f,
  -3.17355096e-02f, -8.09721574e-02f, 1.03507280e-01f, 8.92753229e-02f, 4.75770980e-02f, -2.04775423e-01f, -1.82986289e-01f, -3.26022834e-01f, -5.27744703e-02f, -2.70936102e-01f,
  -8.10148269e-02f, -2.40098774e-01f, -1.34753093e-01f, -8.80112350e-02f, -7.22762123e-02f, -1.00509651e-01f, 1.72722906e-01f, -7.91283995e-02f, 5.09936921e-02f, -2.30539694e-01f,
  9.58544761e-02f, -7.38016069e-02f, 3.14498357e-02f, 1.93052933e-01f, -1.99651450e-01f, 5.00342883e-02f, 2.15867922e-01f, 1.45252883e-01f, 8.96108747e-02f, 6.10126182e-02f,
  2.65556365e-01f, 6.32481184e-03f, -1.41801730e-01f, -2.41087466e-01f, 2.63637006e-01f, -2.14186102e-01f, 1.01883821e-01f, -2.64008611e-01f, -1.76450923e-01f, 1.39235854e-01f,
  3.32526006e-02f, 2.26691812e-01f, -3.83011132e-01f, -2.66709328e-01f, -1.67321824e-02f, -7.22928494e-02f, 7.68321101e-03f, 3.98486480e-02f, 2.47101441e-01f, 2.21568882e-01f,
  -1.57064404e-02f, 1.14135407e-02f, -8.67158249e-02f, 8.57590213e-02f, -9.39471424e-02f, 3.94308150e-01f, 5.15898596e-03f, -1.25812106e-02f, -7.44837373e-02f, -3.96596044e-02f,
  9.92871523e-02f, 2.50514060e-01f, -4.99226488e-02f, 2.30624095e-01f, -2.97660213e-02f, 8.92121717e-02f, 1.21727385e-01f, 2.98534960e-01f, 2.21767709e-01f, 8.51329267e-02f,
  -1.61513850e-01f, -9.97351557e-02f, 8.07975233e-02f, -1.94392707e-02f, 8.26199427e-02f, 1.30674183e-01f, 2.24954169e-02f, 1.47521123e-01f, -2.08717771e-02f, 9.40747485e-02f,
  2.39160031e-01f, -6.45337254e-02f, -2.28265628e-01f, -3.83957289e-02f, 4.48311083e-02f, 1.22097187e-01f, -1.35125190e-01f, -1.11342914e-01f, 1.65825397e-01f, 1.63084209e-01f,
  -2.30524153e-01f, -2.28498518e-01f, 1.71751887e-01f, -6.78423345e-02f, 1.19083792e-01f, 2.09269792e-01f, 1.02978922e-01f, -1.22207077e-02f, -3.07768583e-01f, -2.39803288e-02f,
  2.12964386e-01f, 9.25815403e-02f, -1.90865278e-01f, -9.62230861e-02f, -1.59446865e-01f, -3.46566975e-01f, -4.20467779e-02f, 9.53551009e-02f, -1.06886148e-01f, -6.63683712e-02f,
  -3.83238262e-03f, 1.87868640e-01f, -1.98155046e-01f, 1.12245932e-01f, -1.20741814e-01f, 1.02472775e-01f, -9.94379073e-02f, 2.14721233e-01f, 6.35417849e-02f, -3.42184305e-01f,
  -6.66429475e-02f, -8.12339187e-02f, 1.72834210e-02f, -1.11541934e-01f, 3.70128872e-03f, 2.34235406e-01f, 4.68149297e-02f, 1.80837840e-01f, -4.39484715e-02f, 3.83554399e-02f,
  -1.09320007e-01f, 1.65547147e-01f, -1.72290027e-01f, 1.68201223e-01f, 3.76851529e-01f, 8.34096298e-02f, 8.05023313e-02f, 2.24264711e-01f, 2.99626086e-02f, -1.51263595e-01f,
  5.57559580e-02f, 4.48363610e-02f, 1.30260319e-01f, -2.02756524e-01f, -3.05173218e-01f, 6.05339892e-02f, 7.84590170e-02f, -1.17960759e-02f, -1.99193992e-02f, -7.03987554e-02f,
  -1.15847394e-01f, -2.29649972e-02f, 1.82933450e-01f, 1.37160684e-03f, -1.06053678e-02f, 1.61826968e-01f, 5.35128489e-02f, -3.53233851e-02f, 1.38418287e-01f, 7.83590600e-02f,
  -7.21003115e-02f, -1.60376891e-01f, -2.54995108e-01f, 3.78849283e-02f, -4.88409884e-02f, 8.07719231e-02f, -2.16572210e-01f, -8.22954103e-02f, 1.23221844e-01f, 5.69940545e-02f,
  -1.38339847e-01f, 4.47667658e-01f, -3.75358909e-02f, -1.35838032e-01f, -3.91008049e-01f, 1.32702351e-01f, 6.36544675e-02f, 1.82138100e-01f, -1.58735812e-01f, -1.24672316e-01f,
  -1.26927882e-01f, 4.81248051e-02f, -2.80996356e-02f, -1.23484999e-01f, 5.92955612e-02f, -2.89150834e-01f, -5.09191826e-02f, -5.50816441e-03f, -4.38241847e-02f, 1.70981772e-02f,
  2.69266456e-01f, -5.37322946e-02f, 4.25379816e-03f, -2.55378246e-01f, -4.00928929e-02f, -2.84245849e-01f, -4.76242229e-03f, -6.88652415e-03f, -2.22139835e-01f, -2.62035102e-01f,
  -1.23404376e-01f, 1.97970226e-01f, -2.02414662e-01f, 4.54880409e-02f, -1.87435944e-03f, 1.02197900e-02f, -7.31416643e-02f, 5.41551001e-02f, -2.35111222e-01f, 3.28380018e-02f,
  9.43787098e-02f, 1.58160597e-01f, 1.03972867e-01f, 1.98989257e-01f, 6.89974427e-02f, -1.95650160e-01f, -1.41796499e-01f, -2.54866421e-01f, -1.77003443e-02f, -2.72779554e-01f,
  6.71015233e-02f, 1.83014926e-02f, 1.41528934e-01f, -7.40403011e-02f, -8.18116516e-02f, 4.39612381e-02f, -2.16411084e-01f, -7.77305514e-02f, 2.92243570e-01f, -2.41093952e-02f,
  1.87273949e-01f, -4.90164980e-02f, 2.59180605e-01f, -1.10433973e-01f, -1.79702118e-01f, -1.87268630e-01f, -4.21296358e-01f, 4.37842309e-02f, 1.40860483e-01f, -2.04958752e-01f,
  -1.06818929e-01f, -1.18730247e-01f, 1.55566454e-01f, 2.01520115e-01f, -9.90906265e-03f, -1.06551256e-02f, -1.43062845e-01f, 1.54326886e-01f, -9.40457582e-02f, 7.48770609e-02f,
  -1.82223663e-01f, 3.15373130e-02f, -7.36455619e-02f, 2.72076186e-02f, -1.01123884e-01f, 2.52319202e-02f, 5.17926440e-02f, 8.34869221e-02f, -9.58515257e-02f, -1.91437736e-01f,
  -2.45861605e-01f, -2.58323967e-01f, -5.28987944e-02f, -4.31814492e-02f, 7.02240020e-02f, 4.72929589e-02f, -2.08683133e-01f, -1.25823691e-01f, -3.84887867e-03f, 1.39616042e-01f,
  -6.27523214e-02f, 2.71699190e-01f, -1.98674247e-01f, 1.17766485e-01f, -1.83675185e-01f, 1.02128379e-01f, -1.11051038e-01f, 1.23464353e-01f, -7.98139423e-02f, -8.94088820e-02f,
  -3.73809710e-02f, -7.61029199e-02f, 1.76444888e-01f, -6.91563189e-02f, 2.57575005e-01f, 1.30972816e-02f, -2.85985202e-01f, -4.59413588e-01f, 4.64923680e-02f, -5.58869876e-02f,
  -4.24910001e-02f, -8.70849751e-03f, -1.08742692e-01f, 4.48508784e-02f, 1.43857747e-01f, -5.57540618e-02f, 8.00641850e-02f, -2.25573219e-02f, 5.64374961e-02f, -3.55782092e-01f,
  -7.33979046e-02f, 5.96540123e-02f, 3.52627128e-01f, -9.26614106e-02f, 9.31399222e-03f, -1.88080475e-01f, -2.55758107e-01f, 6.52830601e-02f, 2.18998045e-01f, -1.31444067e-01f,
  1.04681412e-02f, -3.13709408e-01f, 2.82892417e-02f, 2.73097157e-01f, -2.11312231e-02f, -4.76029329e-02f, 9.42699537e-02f, 2.86053181e-01f, 1.06022656e-01f, 1.17257357e-01f,
  -5.74317062e-03f, 8.27054381e-02f, 2.67412961e-01f, 9.79418680e-02f, 5.25784008e-02f, 9.15337279e-02f, -2.39717234e-02f, -1.46101430e-01f, 7.90451616e-02f, -2.37396091e-01f,
  -1.77851804e-02f, 4.05576304e-02f, -3.81834395e-02f, 4.15389091e-02f, 7.67597854e-02f, 1.27367914e-01f, -9.85444188e-02f, -2.45871648e-01f, 7.77106434e-02f, -1.94542855e-01f,
  3.42161767e-02f, 7.93490410e-02f, 3.34331505e-02f, 2.26807088e-01f, -6.73387051e-02f, -8.60260874e-02f, 7.82036781e-02f, 1.51786402e-01f, -2.54679650e-01f, -1.53365478e-01f,
  -1.40184954e-01f, 1.37374982e-01f, -7.75831863e-02f, 5.99545203e-02f, -5.99564351e-02f, 1.54540436e-02f, 3.86355400e-01f, 9.36513394e-03f, -1.08777784e-01f, 7.02350168e-03f,
  -2.42128477e-01f, -2.99268991e-01f, -3.24261710e-02f, -3.03554505e-01f, -2.42555976e-01f, 1.21624172e-01f, 2.59340741e-02f, 5.11522628e-02f, 7.03366026e-02f, -1.03179999e-01f,
  5.22450171e-02f, 6.82931021e-02f, -1.08826563e-01f, -2.40894079e-01f, 2.33708113e-01f, 5.79389781e-02f, 5.57380877e-02f, -1.23025119e-01f, -4.83487733e-02f, 2.44348183e-01f,
  1.70161068e-01f, -2.57323474e-01f, -1.14237651e-01f, 1.48477137e-01f, -3.87998074e-02f, 2.74833888e-02f, 9.74838808e-02f, 9.43592191e-02f, 9.26955231e-03f, 6.59039197e-03f,
  1.46781266e-01f, -2.64841527e-01f, -1.54409576e-02f, -4.03974205e-02f, -5.33640608e-02f, 1.93401054e-01f, -1.22107841e-01f, 3.42246443e-01f, 9.72642973e-02f, 1.13759741e-01f,
  -9.47021991e-02f, -1.48951620e-01f, 1.86548010e-01f, -9.56623703e-02f, -1.05285265e-01f, 2.30800491e-02f, 3.83985877e-01f, 9.70088392e-02f, -6.21413961e-02f, -1.81640685e-02f,
  5.71175441e-02f, 9.34119672e-02f, 1.51676342e-01f, 2.36753058e-02f, 1.48878887e-01f, 2.87680656e-01f, 7.12973922e-02f, -1.49631158e-01f, 1.29833445e-03f, -1.09699545e-02f,
  -2.11808145e-01f, 2.26351470e-01f, -1.81338623e-01f, 5.59512973e-02f, 2.33799573e-02f, -2.03508094e-01f, 1.08705282e-01f, 1.08666576e-01f, 4.64165024e-02f, 6.82046339e-02f,
  6.72929287e-02f, -8.09915438e-02f, 8.03529099e-02f, 1.29428118e-01f, -1.76579636e-02f, -2.82225311e-01f, 2.13028714e-02f, 6.16538487e-02f, -5.53403571e-02f, -8.54602978e-02f,
  7.49296546e-02f, 6.66746451e-03f, 2.77088970e-01f, 2.78135628e-01f, 6.76859021e-02f, -3.69264148e-02f, -2.11354539e-01f, -2.21175149e-01f, -9.28939134e-02f, 2.05431521e-01f,
  1.13214564e-03f, 1.02951854e-01f, -2.35023305e-01f, -1.70505866e-01f, -2.87910439e-02f, -3.39655206e-02f, 6.48489743e-02f, 9.30071175e-02f, -1.31076083e-01f, -5.68474457e-02f,
  7.69289732e-02f, 1.78247228e-01f, -5.12697659e-02f, 5.99957220e-02f, 8.33117664e-02f, 1.16825864e-01f, -1.44990712e-01f, -1.56356633e-01f, 1.09843925e-01f, -2.52822787e-01f,
  -1.92745417e-01f, -1.40867114e-01f, 6.78479299e-02f, -6.52295649e-02f, -1.86308064e-02f, 8.59944299e-02f, 3.01826328e-01f, -1.17800698e-01f, -7.99265727e-02f, -4.77385558e-02f,
  3.11122090e-01f, -9.99822691e-02f, 1.71063364e-01f, 3.70012932e-02f, -5.89592643e-02f, 2.29015738e-01f, 1.19911551e-01f, 8.70124847e-02f, -2.34867096e-01f, -2.12318107e-01f,
  1.49127930e-01f, 1.14202453e-02f, 1.62869856e-01f, 1.23675883e-01f, 2.69345015e-01f, 2.33437009e-02f, 1.57286406e-01f, -2.05846339e-01f, -2.05709524e-02f, -1.02519147e-01f,
  1.02935815e-02f, -3.08178924e-02f, 3.99376452e-03f, -3.02801669e-01f, 1.27372695e-02f, -1.24311984e-01f, 1.48843661e-01f, 1.92103922e-01f, -7.02200457e-02f, 2.68587053e-01f,
  2.00696722e-01f, 9.25349891e-02f, 4.82553616e-02f, -6.55320138e-02f, 7.21116215e-02f, -2.90677864e-02f, -1.61870882e-01f, -1.55786211e-02f, 3.60251576e-01f, 2.88197100e-01f,
  3.78950536e-02f, 2.78037041e-01f, -1.09948225e-01f, -3.36902410e-01f, -1.06625095e-01f, 2.09510908e-01f, 1.30602106e-01f, -1.62746742e-01f, -1.67549569e-02f, 1.22989953e-01f,
  1.13785705e-02f, 5.15798517e-02f, -1.26382977e-01f, -5.84367774e-02f, 1.59229070e-01f, -1.46331862e-01f, 3.15032080e-02f, 1.98357534e-02f, 3.37309867e-01f, 7.93225616e-02f,
  1.26658991e-01f, -2.55387366e-01f, -7.25816190e-02f, -3.85957062e-01f, 7.08649009e-02f, 2.02320106e-02f, 1.07111201e-01f, -6.07476048e-02f, -5.20968251e-02f, 2.28281185e-01f,
  1.93921685e-01f, -5.41457906e-02f, 4.51308489e-02f, -1.46520242e-01f, 1.35425091e-01f, 2.92764902e-01f, 2.06488725e-02f, -5.44601381e-02f, -3.33171077e-02f, -3.45452800e-02f,
  1.35441527e-01f, -7.92266130e-02f, -1.86716050e-01f, -2.21945539e-01f, 1.34929419e-01f, -6.15590997e-03f, -6.02133665e-03f, -3.09683710e-01f, 1.04670435e-01f, -8.59428719e-02f,
  2.32808322e-01f, 1.74878836e-01f, -2.04725012e-01f, -2.32162550e-02f, 9.25200582e-02f, -8.76669306e-04f, -1.02099106e-01f, 6.10890724e-02f, -8.43124092e-02f, -6.91231266e-02f,
  -5.80182485e-02f, -2.59025674e-02f, 2.12480128e-01f, 9.75060165e-02f, -6.60935640e-02f, 1.53323606e-01f, -5.24667129e-02f, -5.25647104e-02f, 8.65768269e-02f, -1.54085577e-01f,
  -1.62178233e-01f, 1.17585296e-02f, 5.85992746e-02f, -6.99691623e-02f, -7.57509395e-02f, 1.31207585e-01f, -3.97580266e-02f, -7.57194757e-02f, -1.89934000e-01f, 3.38384472e-02f,
  5.09361911e-04f, -7.35729784e-02f, 1.79309115e-01f, 2.46010292e-02f, 2.59152763e-02f, 5.54156937e-02f, -1.72063440e-01f, 7.86001049e-03f, -1.57784939e-01f, 6.29378064e-03f,
  -2.18681887e-01f, -1.21032342e-03f, -3.44512075e-01f, -1.03312530e-01f, -8.46951231e-02f, -4.98115867e-02f, 1.23185888e-01f, 4.40117598e-01f, -2.10415110e-01f, -1.02490000e-01f,
  1.85947105e-01f, -1.59129187e-01f, -6.22775890e-02f, 1.29894793e-01f, 1.69770598e-01f, 5.68183046e-03f, -1.62433177e-01f, 1.99875981e-01f, -5.62607544e-03f, -1.70411125e-01f,
  -2.91422568e-02f, -2.56113976e-01f, 1.98649183e-01f, -5.36291488e-02f, -2.03151077e-01f, -2.69234747e-01f, 2.75604725e-01f, 1.35083273e-01f, 1.65119156e-01f, 1.95857450e-01f,
  -2.55401403e-01f, 2.25921139e-01f, -2.36826763e-02f, 9.02123526e-02f, -1.28511280e-01f, 8.95305946e-02f, 4.11508083e-01f, 2.31310144e-01f, 4.17655632e-02f, 1.51519492e-01f,
  1.24734029e-01f, -7.72381648e-02f, 4.19845991e-02f, -1.79522246e-01f, 5.25152907e-02f, -2.95444727e-01f, -2.58353539e-03f, -6.31868606e-03f, -5.40462695e-02f, -1.52826145e-01f,
  -4.15510610e-02f, -1.58298016e-01f, -1.21036559e-01f, 3.01110893e-02f, -8.18225741e-02f, -1.64109399e-03f, -1.05716519e-01f, 1.16009362e-01f, 2.10006177e-01f, -6.86330199e-02f,
  -1.70647837e-02f, -2.16699496e-01f, 1.79594368e-01f, -1.52586892e-01f, -7.86726028e-02f, -2.83424016e-02f, 2.60263104e-02f, 1.99985817e-01f, 2.44974978e-02f, -1.13196718e-02f,
  -1.40939713e-01f, 1.85811192e-01f, 2.82444134e-02f, 2.68055171e-01f, 1.60935134e-01f, 6.00839145e-02f, -2.56114453e-01f, 1.47197768e-01f, -7.78647186e-03f, 3.20487432e-02f,
  -4.42144796e-02f, -2.49821395e-01f, 3.71420458e-02f, 1.29128367e-01f, 5.10610379e-02f, -3.34762365e-01f, -6.74121752e-02f, -1.95361212e-01f, 3.00559074e-01f, 1.42005175e-01f,
  2.40913741e-02f, 1.44253671e-01f, 1.40172884e-01f, -1.82949938e-02f, -4.33554351e-02f, 2.98111364e-02f, 2.73575813e-01f, 1.87191681e-03f, 5.14136776e-02f, 7.99486265e-02f,
  -1.81641608e-01f, -1.92894503e-01f, 2.48992592e-02f, -1.45343095e-01f, 1.46738440e-01f, -1.40621096e-01f, -1.51666449e-02f, -6.39144331e-02f, 1.37269299e-03f, -8.27877894e-02f,
  6.69742748e-02f, -2.08320259e-03f, 1.64798230e-01f, -2.50080228e-01f, 7.61697516e-02f, 1.31223336e-01f, 1.65318117e-01f, 7.99041241e-02f, 2.18084473e-02f, -6.86635375e-02f,
  -1.67316169e-01f, 5.44778854e-02f, -2.08442032e-01f, -1.92316607e-01f, 2.34758466e-01f, 1.85961336e-01f, 9.17025134e-02f, -2.32510343e-01f, 3.16099972e-01f, -1.29524413e-02f,
  2.08512083e-01f, 9.16197598e-02f, 1.46739900e-01f, -5.98068647e-02f, -7.40861446e-02f, -1.97966263e-01f, 2.28089139e-01f, 1.49603978e-01f, 4.99359258e-02f, 9.90605950e-02f,
  1.67749189e-02f, 2.33680103e-03f, -5.87412119e-02f, -5.25032431e-02f, 2.34462142e-01f, -1.21732555e-01f, -8.20715949e-02f, 3.65410969e-02f, 3.61934374e-03f, 3.15510035e-01f,
  -2.51164809e-02f, 2.18223967e-02f, 1.99022263e-01f, 1.37204275e-01f, -1.58260301e-01f, -2.80055135e-01f, -9.83402580e-02f, -6.70657679e-02f, 1.56136647e-01f, -1.58891141e-01f,
  -6.64610043e-02f, 2.57693738e-01f, 5.66484146e-02f, -9.22690239e-03f, -1.05958492e-01f, 3.69554386e-02f, 1.13484770e-01f, 4.96977717e-02f, -7.65169114e-02f, 3.92366713e-03f,
  -1.83604747e-01f, 8.02007914e-02f, 6.10431917e-02f, -2.94764172e-02f, -1.91785753e-01f, 3.80050242e-02f, 1.19317748e-01f, -9.13247168e-02f, 4.11583744e-02f, -1.18449509e-01f,
  2.28083208e-02f, 1.70571297e-01f, 1.65870473e-01f, 2.03787953e-01f, 2.76905075e-02f, 9.71125290e-02f, 1.15679160e-01f, 1.90724626e-01f, 2.49300033e-01f, -3.31691690e-02f,
  2.61607580e-02f, -6.88727424e-02f, 1.56422243e-01f, -7.31406882e-02f, 4.94223684e-02f, -3.17318499e-01f, -3.19830269e-01f, 2.92154718e-02f, -1.80819467e-01f, -1.07524231e-01f,
  -1.01244941e-01f, 2.00004756e-01f, -3.21054682e-02f, -2.41686687e-01f, -1.84702203e-01f, -2.73962431e-02f, -2.80654971e-02f, 3.64072591e-01f, -1.89991450e-04f, -1.06821544e-01f,
  -8.24606046e-02f, 6.64500967e-02f, -4.35318761e-02f, 1.61849424e-01f, 8.02311301e-02f, -1.49387345e-01f, -3.68950255e-02f, -1.42299384e-01f, -7.58817280e-03f, -1.56942099e-01f,
  2.14101121e-01f, -2.77065020e-02f, 1.71056271e-01f, -2.04208151e-01f, -1.79876685e-01f, -9.51925740e-02f, 1.22175895e-01f, -6.67343512e-02f, 2.98535209e-02f, -1.92837790e-01f,
  -9.81775150e-02f, 8.47406760e-02f, 1.99148431e-01f, 2.18755394e-01f, 5.29615991e-02f, 1.92402285e-02f, -7.89568573e-02f, -7.72406608e-02f, -1.74115986e-01f, 1.93980798e-01f,
  2.64777482e-01f, 1.85384929e-01f, -1.98829830e-01f, -1.13832749e-01f, -3.41116972e-02f, -1.32991090e-01f, 8.56598467e-02f, 3.28225903e-02f, -3.52210343e-01f, -1.80042759e-01f,
  1.33244589e-01f, 1.03630051e-02f, -2.65603559e-03f, -4.89706397e-02f, -5.09158745e-02f, -2.46290844e-02f, 1.10894039e-01f, -2.96953935e-02f, -1.63224876e-01f, 9.35541391e-02f,
  3.49598616e-01f, 2.67618690e-02f, 9.39673185e-02f, 1.96945429e-01f, 1.25442818e-01f, 2.03872636e-01f, -2.29404494e-01f, -4.01073359e-02f, -1.44745380e-01f, -3.77191491e-02f,
  -1.95811152e-01f, 8.52050036e-02f, 1.37811348e-01f, 1.10734016e-01f, -1.01856200e-03f, 1.16996422e-01f, -4.97173481e-02f, 2.88652629e-01f, -8.36547613e-02f, 1.07623391e-01f,
  -2.04303741e-01f, -2.46823683e-01f, -8.73916149e-02f, 1.17443100e-01f, 2.46658102e-01f, -1.49745971e-01f, -1.11801624e-01f, 1.65650826e-02f, 1.57700330e-01f, 3.63598205e-02f,
  -1.32126331e-01f, 2.09419578e-01f, 1.07194841e-01f, 2.78407097e-01f, 1.59501433e-01f, 2.32221670e-02f, -1.31106466e-01f, -4.87266146e-02f, 3.57529521e-02f, 1.13976123e-02f,
  1.11078195e-01f, 5.63261770e-02f, -2.62311131e-01f, 2.01762356e-02f, 2.15264767e-01f, 1.50932044e-01f, -8.10483322e-02f, -2.76121199e-01f, 1.29061937e-01f, 1.60753503e-01f,
  8.70878249e-02f, 1.97227031e-01f, 9.92380828e-02f, 1.91360846e-01f, 2.17863947e-01f, -1.25626177e-01f, -1.83438838e-01f, -5.73860295e-02f, -6.25089630e-02f, -1.19886689e-01f,
  -2.81693816e-01f, -1.46677554e-01f, -2.54906863e-01f, 9.35460180e-02f, -1.86036333e-01f, -1.16559736e-01f, 2.58346051e-01f, 2.71153431e-02f, 8.62250477e-02f, 3.34573165e-02f,
  -2.84827232e-01f, 2.06155479e-01f, -6.78339303e-02f, 1.02662630e-01f, 1.68370575e-01f, -2.50332840e-02f, -1.70989826e-01f, -5.79082333e-02f, 2.90867269e-01f, -9.02507827e-02f,
  3.03152371e-02f, -3.88365179e-01f, -8.61353800e-03f, 2.20058430e-02f, 1.35422349e-01f, 5.31800985e-02f, 1.47699669e-01f, 3.55294831e-02f, -3.55315618e-02f, 4.76935273e-03f
};

// L2_fan_Wp_bar (Shape: 14 x 64)
const int L2_fan_Wp_bar_rows = 14;
const int L2_fan_Wp_bar_cols = 64;
const float L2_fan_Wp_bar_data[] = {
  1.32231757e-01f, -3.24489415e-01f, 7.48797804e-02f, -2.57623103e-02f, 4.94962558e-02f, -1.59498945e-01f, -3.44142467e-01f, -1.40927611e-02f, 1.08472340e-01f, -9.93420929e-02f,
  -1.47071085e-03f, -7.19961673e-02f, -2.00663820e-01f, -2.87200481e-01f, 2.59052087e-02f, -1.44440709e-02f, -4.09341574e-01f, -2.16684192e-01f, -3.56984660e-02f, -3.21267098e-01f,
  8.21855664e-02f, -1.65895984e-01f, 9.99567956e-02f, 2.41666380e-02f, 4.51733470e-02f, -6.73294440e-02f, -7.38189667e-02f, -2.41480380e-01f, -1.05403505e-01f, -1.09941415e-01f,
  2.67879486e-01f, -1.78860515e-01f, 4.56180237e-02f, -9.54728425e-02f, -1.47223473e-01f, 1.56335413e-01f, 1.94040030e-01f, -3.13570946e-02f, -6.14467338e-02f, -1.77258313e-01f,
  2.44612336e-01f, -2.50705868e-01f, 4.66822123e-04f, 2.67846733e-01f, -3.45517635e-01f, 1.58396572e-01f, -2.93885544e-03f, -1.27547815e-01f, -2.68437620e-02f, 2.22463608e-01f,
  1.55227497e-01f, 1.24101423e-01f, 1.00641258e-01f, -1.46246985e-01f, -1.88268185e-01f, 7.81425610e-02f, -1.38558634e-02f, -3.77110839e-01f, 1.34628505e-01f, -1.46809891e-01f,
  -5.71622066e-02f, -1.03551202e-01f, 2.58170739e-02f, 2.24473923e-01f, -6.85711354e-02f, 2.94963658e-01f, 1.97042897e-01f, 1.78256169e-01f, 3.29766393e-01f, 1.01175182e-01f,
  1.12250730e-01f, 3.41345668e-01f, -4.97874990e-02f, -1.38585672e-01f, 1.26924708e-01f, 1.15514621e-01f, 2.18867004e-01f, -7.31889252e-03f, 1.44926310e-01f, 9.53616723e-02f,
  2.27853313e-01f, -8.00370723e-02f, -2.20329955e-01f, 2.50514358e-01f, 1.10190278e-02f, 1.89121604e-01f, -2.33018422e-03f, 2.41747558e-01f, 2.50173155e-02f, 1.05384551e-01f,
  3.62922139e-02f, 1.21671990e-01f, -4.06040967e-01f, -1.79476395e-01f, -4.08428162e-01f, 4.91826460e-02f, 5.91501072e-02f, 3.91069919e-01f, -3.73513460e-01f, -7.43024200e-02f,
  -2.15581372e-01f, -2.57645920e-03f, -3.82048786e-01f, -7.43229091e-02f, 1.51320726e-01f, -1.35501385e-01f, -1.42595693e-01f, -2.31029898e-01f, -1.35546131e-02f, 1.04491413e-01f,
  -7.86402598e-02f, 2.64111757e-01f, -2.25007907e-01f, -1.39439821e-01f, -1.64473012e-01f, -5.58338016e-02f, 1.50738046e-01f, 6.91600367e-02f, 1.95305243e-01f, -2.87053108e-01f,
  3.04806828e-02f, -1.36594743e-01f, -3.96365151e-02f, -1.67234726e-02f, 2.42750674e-01f, -1.54851943e-01f, -2.94860810e-01f, -1.59016475e-02f, 7.64116049e-02f, 2.90417582e-01f,
  1.63248777e-01f, 1.09897323e-01f, 1.23845577e-01f, 5.69557905e-01f, 3.34391356e-01f, 4.58413899e-01f, -1.08746074e-01f, 1.93852887e-01f, 1.38551623e-01f, 1.58954576e-01f,
  6.16155379e-02f, 3.69756460e-01f, 5.84271431e-01f, 2.01745629e-01f, 3.43773872e-01f, 1.40373036e-01f, 3.60108763e-01f, 2.61062920e-01f, 3.46918069e-02f, 7.67661706e-02f,
  3.05310607e-01f, 1.98954746e-01f, -7.69160539e-02f, 2.25012287e-01f, 1.66628167e-01f, 3.54107231e-01f, -5.25208592e-01f, -2.11392537e-01f, -3.22686523e-01f, -1.92049406e-02f,
  -1.35847256e-01f, 2.22476482e-01f, -4.35062088e-02f, -9.76925567e-02f, -4.66961235e-01f, 6.69511706e-02f, -1.98838905e-01f, -1.10056601e-01f, -1.84755381e-02f, 1.42910173e-02f,
  2.98410207e-01f, -1.15498453e-02f, 4.37140435e-01f, 1.30272478e-01f, 4.76045348e-03f, -3.35843973e-02f, -8.29807594e-02f, 2.97797173e-02f, 2.82816648e-01f, -9.46294516e-02f,
  2.84868687e-01f, 3.52309318e-03f, 2.12556168e-01f, -4.74592894e-01f, 2.27729738e-01f, 2.89390355e-01f, 2.21062317e-01f, 1.45465717e-01f, 2.94714034e-01f, -4.18012738e-01f,
  -1.23810120e-01f, -3.73381555e-01f, 5.45510575e-02f, 1.03695542e-01f, 2.43592113e-01f, 5.17840534e-02f, 3.25114161e-01f, 2.92631328e-01f, -1.59538493e-01f, 1.30844891e-01f,
  1.00398980e-01f, -1.40630350e-01f, -2.44732663e-01f, 1.78032532e-01f, 2.85735607e-01f, -1.55250495e-02f, 3.03773701e-01f, 2.56020039e-01f, 4.37939279e-02f, 7.66648874e-02f,
  9.86882597e-02f, 1.07518032e-01f, 1.87076122e-01f, 1.87153921e-01f, -3.44425701e-02f, 1.17053106e-01f, 1.62682086e-01f, 1.24499120e-01f, 5.68452924e-02f, 8.19895267e-02f,
  -1.61100060e-01f, 1.57689273e-01f, 5.65768182e-02f, 3.06567192e-01f, -2.30528295e-01f, -1.15084350e-01f, -3.28433990e-01f, -4.31703264e-03f, 2.58123130e-01f, -3.14484268e-01f,
  -1.73929200e-01f, 1.47269085e-01f, 2.28191391e-01f, 1.18463807e-01f, -1.41880900e-01f, -2.50461906e-01f, -4.25254732e-01f, 2.33496547e-01f, -5.49100414e-02f, 3.03963900e-01f,
  1.32829100e-01f, -2.96236724e-01f, -4.34369624e-01f, 2.69000024e-01f, 4.57933754e-01f, -6.04416311e-01f, 2.12905481e-01f, 3.33842218e-01f, 2.14110091e-01f, 2.62322247e-01f,
  -6.21002257e-01f, -1.45397514e-01f, 4.48379457e-01f, -2.82933041e-02f, 9.04080346e-02f, 2.32870996e-01f, -1.06943212e-02f, 2.50887096e-01f, 7.41164386e-02f, 8.26761127e-02f,
  -1.32520854e-01f, -1.66101724e-01f, 1.63602596e-03f, -3.48025896e-02f, -1.24831744e-01f, 6.68232739e-02f, 3.39969724e-01f, 2.41030470e-01f, -1.76478624e-01f, -1.86463952e-01f,
  3.88813503e-02f, -2.00967178e-01f, 2.89739579e-01f, -5.23272529e-02f, 1.40182320e-02f, 1.50071889e-01f, 3.34741563e-01f, -1.09349340e-01f, 6.29315749e-02f, 8.28531533e-02f,
  1.45062981e-02f, -2.88401634e-01f, -4.37208146e-01f, -2.09633723e-01f, -2.15923950e-01f, 5.47049306e-02f, -3.73516530e-02f, 1.09766088e-01f, -1.48679420e-01f, 5.73898666e-02f,
  2.46199131e-01f, 1.71951354e-01f, 1.19544797e-01f, -2.09098399e-01f, 2.21695617e-01f, 1.09764107e-01f, -3.26270878e-01f, 4.68341261e-01f, -5.44858873e-02f, 1.09006979e-01f,
  4.99645263e-01f, -4.15313356e-02f, 1.45119995e-01f, -2.50247605e-02f, -2.66367674e-01f, 2.56567985e-01f, 4.08315957e-01f, 1.60013735e-01f, -4.90325451e-01f, 3.35454404e-01f,
  3.59286815e-01f, -2.14993283e-01f, 1.08377002e-01f, 2.92750299e-01f, -1.86244817e-03f, -2.37105399e-01f, 1.37231182e-02f, 5.23374975e-03f, 1.26891509e-01f, -2.74215251e-01f,
  1.35218650e-01f, -1.15779914e-01f, 1.96215317e-01f, 4.38388616e-01f, 1.76315516e-01f, 1.86843500e-01f, 1.43713489e-01f, -3.09499323e-01f, 2.05054790e-01f, -7.95827284e-02f,
  1.26788780e-01f, 1.06313214e-01f, 9.41148773e-02f, 2.89376348e-01f, 1.22328512e-01f, -1.31289348e-01f, 1.75801799e-01f, 2.67947733e-01f, 2.37674460e-01f, -2.23689582e-02f,
  2.64591992e-01f, -8.47216472e-02f, 3.20583701e-01f, 2.68877149e-01f, 1.92042455e-01f, 2.96846688e-01f, 2.36546189e-01f, 1.56261533e-01f, -3.60647947e-01f, 2.38285005e-01f,
  2.37224355e-01f, 5.53862393e-01f, 1.30362585e-02f, -1.66424066e-02f, 3.72006327e-01f, 1.14936158e-01f, -1.90469638e-01f, 5.23450226e-02f, -3.93699527e-01f, -1.44286856e-01f,
  -5.17566085e-01f, -1.37869388e-01f, -1.01529054e-01f, 1.94735125e-01f, 2.07911059e-01f, -4.63698745e-01f, -3.83621484e-01f, 2.35471334e-02f, -2.08213225e-01f, 2.09245995e-01f,
  1.32969975e-01f, -2.81426996e-01f, -4.75528419e-01f, 2.74330974e-01f, 1.74125984e-01f, 6.33006692e-01f, 2.30929539e-01f, -5.13765395e-01f, 3.01606178e-01f, 1.14821538e-01f,
  5.61025850e-02f, -3.14494431e-01f, 4.61754613e-02f, -2.50640154e-01f, -8.95053223e-02f, 3.72061431e-01f, 3.17228824e-01f, 1.80488586e-01f, -3.10604632e-01f, -7.12853074e-02f,
  2.84667730e-01f, 1.26470163e-01f, 2.00076804e-01f, 1.26545146e-01f, 9.89346132e-02f, -2.52751589e-01f, -7.40616396e-02f, 1.81287304e-02f, -2.49132186e-01f, 2.13781059e-01f,
  -3.95429060e-02f, 1.90013945e-01f, -1.09540746e-01f, -2.04211339e-01f, 3.56525242e-01f, -1.45149454e-01f, 1.83647290e-01f, 2.00877085e-01f, 1.36761352e-01f, -4.28043991e-01f,
  5.61691999e-01f, 6.37323260e-02f, 1.53685153e-01f, -4.15311679e-02f, 3.36229712e-01f, 3.08025569e-01f, 1.33226454e-01f, -4.49859172e-01f, 4.56027746e-01f, -1.05135694e-01f,
  7.36823082e-02f, 9.28763226e-02f, 8.30039233e-02f, 2.04795271e-01f, -3.08901191e-01f, -6.35984465e-02f, 1.77163363e-01f, -8.79797339e-02f, 3.06538790e-01f, 1.86507404e-02f,
  5.67867719e-02f, -3.15934211e-01f, 1.83494180e-01f, 9.01608244e-02f, 4.82944511e-02f, -5.16157269e-01f, -5.81979640e-02f, -3.61093879e-02f, 6.95517436e-02f, 5.63024879e-01f,
  3.76412839e-01f, 1.87231809e-01f, 3.13794643e-01f, 7.16256022e-01f, 1.59262300e-01f, -3.51332314e-02f, -5.03222458e-02f, -2.56123900e-01f, 2.69649357e-01f, 1.12241305e-01f,
  1.57186314e-01f, -8.84550437e-02f, 2.62010783e-01f, 4.49527860e-01f, 3.31292860e-02f, 2.31097072e-01f, 2.59121090e-01f, 2.51883745e-01f, -1.03949040e-01f, 8.78001451e-02f,
  4.00851846e-01f, 1.42954871e-01f, 3.15332085e-01f, 1.60399362e-01f, 7.25431293e-02f, 2.64347881e-01f, 2.37221271e-01f, 3.48363042e-01f, -2.89675683e-01f, 1.57035708e-01f,
  2.61753142e-01f, 1.70738157e-02f, 1.67816266e-01f, 3.28279048e-01f, -4.45907675e-02f, -5.25462925e-02f, 2.83860445e-01f, 2.18143880e-01f, -3.90180230e-01f, -1.75589755e-01f,
  -1.90762773e-01f, -8.26397985e-02f, -5.39589584e-01f, -4.80989665e-01f, -3.18803757e-01f, 9.84125361e-02f, 2.96686769e-01f, -3.60760242e-02f, 3.84618163e-01f, -2.08661884e-01f,
  -1.44574773e-02f, 4.34055552e-03f, -5.63187063e-01f, 3.06629866e-01f, -3.37558910e-02f, 1.21840231e-01f, 6.92856461e-02f, -4.62222517e-01f, -2.10907534e-01f, 8.10173228e-02f,
  7.43544340e-01f, -1.01029098e-01f, 3.54835242e-02f, 2.63139516e-01f, -7.31893703e-02f, 1.54631764e-01f, -2.40681600e-02f, 1.10662527e-01f, 3.58516574e-01f, 7.56616369e-02f,
  1.15706615e-01f, 2.48585597e-01f, -1.14545837e-01f, 2.04539374e-01f, 9.87063199e-02f, 1.32775888e-01f, 1.76684678e-01f, 6.32310137e-02f, 2.40148261e-01f, -2.10946113e-01f,
  1.64818481e-01f, -1.32145852e-01f, -1.13349244e-01f, 4.74370211e-01f, -3.88931595e-02f, 1.49346054e-01f, -7.36431479e-02f, 3.57150227e-01f, 2.64417231e-01f, -1.31493106e-01f,
  -1.23033009e-01f, -7.54798204e-02f, 2.36807287e-01f, 3.05455886e-02f, -4.37439054e-01f, 1.32864714e-01f, 4.08565961e-02f, 3.38027686e-01f, -2.03298733e-01f, 1.51638240e-01f,
  -7.27294758e-02f, 3.34152728e-01f, -2.45775059e-01f, 5.31171620e-01f, -4.14431989e-01f, -1.91400900e-01f, 1.08682796e-01f, -3.45989764e-01f, 2.25745082e-01f, -2.77442902e-01f,
  -2.41003394e-01f, 3.22485089e-01f, -3.24379534e-01f, 3.27640533e-01f, -4.51464146e-01f, -4.55930084e-01f, -1.60353661e-01f, 6.15267120e-02f, -1.33254334e-01f, 3.15073341e-01f,
  -1.20476007e-01f, -1.29478067e-01f, -2.91234583e-01f, -1.51343094e-02f, -7.44266436e-02f, 1.52647886e-02f, 4.03481156e-01f, 3.04160416e-01f, 2.54567266e-01f, -5.85645080e-01f,
  -4.36395109e-02f, -3.30755897e-02f, 4.09038663e-01f, 2.04221252e-02f, 1.63111508e-01f, 1.47453934e-01f, 2.23739371e-01f, -1.01326048e-01f, 2.47424349e-01f, -1.83774292e-01f,
  3.78630273e-02f, -1.55268878e-01f, -7.39950612e-02f, 1.95225760e-01f, 7.78750554e-02f, 2.42884271e-02f, 4.18370932e-01f, -1.89136058e-01f, -3.12452838e-02f, 1.31031364e-01f,
  5.83346188e-02f, 5.13834842e-02f, 6.04309747e-03f, 1.67122334e-01f, -7.99230579e-03f, -2.75802851e-01f, 2.14356095e-01f, 2.93750763e-01f, 2.53497243e-01f, -1.83682874e-01f,
  7.00707808e-02f, -5.10269284e-01f, 3.60783637e-02f, -3.11112791e-01f, -6.38776645e-02f, -3.00008748e-02f, -1.79617599e-01f, -4.42994177e-01f, 1.23445794e-01f, 2.16095857e-02f,
  4.43047255e-01f, -4.19012718e-02f, -1.38969064e-01f, 1.45319059e-01f, 4.75153118e-01f, -2.93788761e-01f, 2.03139782e-01f, 9.59307328e-02f, 3.76603901e-01f, 5.55312708e-02f,
  3.42926592e-01f, 2.58021027e-01f, 1.35789052e-01f, 1.07702962e-03f, -1.21040583e-01f, -1.59428120e-01f, 2.36677289e-01f, 4.40915264e-02f, 4.01650190e-01f, 2.09833950e-01f,
  -2.08731629e-02f, -8.16927403e-02f, 2.03201696e-01f, 7.42049396e-01f, 2.30717197e-01f, 2.29849920e-01f, -2.34280527e-02f, 3.49015445e-01f, 1.83990836e-01f, -1.77514330e-01f,
  -5.29263727e-03f, 2.06929352e-02f, 1.36697084e-01f, 2.81500012e-01f, -3.60136628e-02f, -6.42805547e-02f, -2.64743090e-01f, 2.72711515e-01f, -7.17870593e-02f, 2.32423782e-01f,
  5.22947758e-02f, 1.93341210e-01f, 5.42940944e-02f, -1.66670099e-01f, -1.26541883e-01f, 1.57661632e-01f, 1.79098621e-01f, 3.51919055e-01f, 1.02838114e-01f, -1.42340913e-01f,
  3.59941155e-01f, -1.66110545e-01f, 9.84094962e-02f, -7.07107708e-02f, 2.08928317e-01f, 6.49360800e-03f, 2.70583760e-03f, -6.52912110e-02f, 5.36309600e-01f, 3.74430716e-01f,
  6.10324681e-01f, -3.57685536e-02f, -6.65710494e-02f, -5.67803264e-01f, 4.97714669e-01f, -1.55185595e-01f, 4.22233999e-01f, -5.45062780e-01f, -1.31705087e-02f, 3.33547026e-01f,
  -2.68031687e-01f, 5.60882151e-01f, 2.15351265e-02f, 1.15444370e-01f, 5.56163251e-01f, -1.87940940e-01f, -2.95804739e-01f, 1.73572615e-01f, 3.25361580e-01f, 4.13198203e-01f,
  3.25330198e-01f, -3.04093324e-02f, -1.38072371e-01f, 2.83866793e-01f, -2.72843800e-02f, 2.00289115e-01f, 1.53620377e-01f, 4.09796566e-01f, -8.73562470e-02f, -1.16698332e-01f,
  2.22529426e-01f, 1.68591321e-01f, 4.41094816e-01f, -2.17727199e-03f, 2.18124524e-01f, 8.10911506e-02f, 1.67135894e-01f, -2.99802303e-01f, -1.47765890e-01f, 2.49416798e-01f,
  -7.55706057e-02f, 1.08805306e-01f, -9.17897969e-02f, 2.80182302e-01f, 7.29664182e-03f, 2.01762114e-02f, 1.61431983e-01f, -1.91292405e-01f, 3.03971976e-01f, 2.84231275e-01f,
  5.12052141e-02f, 4.62308787e-02f, 6.13810718e-01f, 2.16642573e-01f, -1.13612842e-02f, 7.91972801e-02f, 2.31602550e-01f, 7.33730495e-02f, -3.03981066e-01f, -4.23391253e-01f,
  5.90505823e-02f, -2.51159966e-01f, -6.73695505e-01f, 6.87098652e-02f, 3.53828430e-01f, -2.59369373e-01f, -3.86533082e-01f, 4.23961669e-01f, 1.58227026e-01f, 3.00446659e-01f,
  3.05747241e-01f, -2.30132602e-02f, 4.63137150e-01f, 1.16798781e-01f, -1.15983352e-01f, 1.31746292e-01f, 2.70407140e-01f, -3.60274464e-01f, 2.30300948e-01f, 1.35335356e-01f,
  7.36187100e-01f, -6.37246013e-01f, -1.44042924e-01f, -3.47173482e-01f, 3.54114443e-01f, 7.21801147e-02f, 2.51794517e-01f, -2.53481477e-01f, 1.29606441e-01f, 1.94970235e-01f,
  -7.18608573e-02f, 6.40049696e-01f, 1.07489489e-01f, -4.01061028e-02f, 1.96085824e-03f, -7.51269758e-01f, -5.95269024e-01f, -3.12870353e-01f, 2.66770542e-01f, -6.21630587e-02f,
  -1.36928156e-01f, -1.48565387e-02f, 1.79112494e-01f, -6.50385693e-02f, 3.21710378e-01f, -3.32136035e-01f, 2.43748069e-01f, 3.07198107e-01f, 8.72204453e-02f, 1.34170521e-03f,
  1.47664085e-01f, 3.96943033e-01f, -1.04331903e-01f, 1.95268810e-01f, 1.03433535e-01f, 1.22406162e-01f, 2.02556308e-02f, 2.70150602e-02f, -5.70986196e-02f, 5.42741716e-01f,
  -1.09467590e-02f, -3.10990751e-01f, -5.12153581e-02f, 8.51157829e-02f, -3.10921133e-01f, -3.01164955e-01f, 4.10797686e-04f, -2.30346024e-01f, -3.61192405e-01f, -8.15835744e-02f,
  2.19277963e-01f, 2.71933049e-01f, 1.60074800e-01f, -1.09761618e-01f, -2.29779050e-01f, 4.77724671e-01f, 5.92508614e-02f, -2.85581678e-01f, -1.33151412e-01f, -4.77423340e-01f,
  -9.33462381e-02f, -3.88484746e-02f, -7.50845447e-02f, 4.75759469e-02f, -2.08472222e-01f, -2.33054951e-01f, -1.64685234e-01f, -2.65975833e-01f, 5.09389758e-01f, 1.34788960e-01f,
  -1.42870530e-01f, 5.62289238e-01f, 3.73691291e-01f, 4.46419656e-01f, 9.31437761e-02f, -1.46916986e-01f, 4.28136349e-01f, 1.31840125e-01f, -6.09950781e-01f, 5.78166135e-02f,
  3.21575880e-01f, 4.61906381e-03f, 7.54111856e-02f, 1.66670725e-01f, 2.02461649e-02f, 5.24265729e-02f, 3.31662774e-01f, 5.95359281e-02f, 2.19917268e-01f, -8.09918158e-03f,
  1.38434291e-01f, -1.17777169e-01f, 1.03661641e-01f, 4.88017440e-01f, -7.02786595e-02f, 1.99277252e-01f, 2.34660909e-01f, 4.66984101e-02f, 2.04697177e-01f, -1.63024850e-02f,
  9.78977904e-02f, 3.15194130e-01f, -1.49764895e-01f, 1.88452557e-01f, 2.40080342e-01f, 1.57091677e-01f, -5.61415441e-02f, -1.04264602e-01f, -3.38803232e-01f, -1.14004076e-01f,
  -1.39787734e-01f, 1.25773251e-03f, -4.21542734e-01f, 9.89922136e-02f, 1.61520511e-01f, 5.08609593e-01f, -4.42332357e-01f, 1.03440844e-01f, -4.46641773e-01f, 1.52185500e-01f,
  1.63350701e-01f, -1.44217163e-01f, 1.59147114e-01f, 1.20205477e-01f, 1.56778190e-02f, 7.05413073e-02f, -2.18524233e-01f, 4.65474844e-01f, -8.06589704e-03f, 2.93086171e-01f,
  -3.57476175e-01f, -1.59472063e-01f, 2.01197892e-01f, 3.04640830e-01f, 1.03494324e-01f, 2.70018786e-01f, 5.25807858e-01f, -3.71032894e-01f, -9.52215940e-02f, -3.41616035e-03f,
  7.81303570e-02f, -1.26613423e-01f, -7.10768849e-02f, 8.70218128e-03f, 3.71563956e-02f, -2.31208876e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 14)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 14;
const float L2_fan_Bp_bar_data[] = {
  -5.53785823e-02f, 1.51748851e-01f, 1.91686004e-01f, 2.15655476e-01f, -8.66889954e-03f, -2.42471937e-02f, 1.11201502e-01f, 1.13293774e-01f, 1.53404444e-01f, 2.26415426e-01f,
  2.08746225e-01f, 1.46576986e-01f, 7.98545554e-02f, -3.93786021e-02f
};

// L3_linear_W (Shape: 12 x 64)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 64;
const float L3_linear_W_data[] = {
  2.32315380e-02f, 4.76026535e-02f, 3.49422783e-01f, -9.93542746e-02f, -2.65601665e-01f, 1.50947362e-01f, -4.69987988e-01f, 1.23799898e-01f, -4.37615156e-01f, 1.97932854e-01f,
  3.79321873e-01f, -5.62444553e-02f, -1.00347944e-01f, 3.25643808e-01f, -1.23817325e-01f, -3.35493714e-01f, -4.20035087e-02f, -2.81037152e-01f, -8.76246840e-02f, -2.55456090e-01f,
  -3.22269887e-01f, -2.26989076e-01f, 5.38167395e-02f, 1.47668570e-01f, -1.11309931e-01f, -2.92023659e-01f, 3.26699764e-01f, -2.39352643e-01f, -1.20391026e-01f, -1.71820134e-01f,
  2.11198479e-01f, 7.44128898e-02f, -2.76634485e-01f, -3.03370863e-01f, -3.25997639e-03f, 1.65507257e-01f, 3.10205907e-01f, -1.08006112e-01f, -7.98552260e-02f, 2.43169934e-01f,
  -2.17106059e-01f, 2.82448679e-01f, -5.33466041e-02f, 3.17732990e-01f, -3.23293895e-01f, 2.53331214e-01f, 3.41089964e-01f, -2.66204089e-01f, 2.58199900e-01f, -3.92788559e-01f,
  -3.81808311e-01f, -2.89864670e-02f, -5.99506855e-01f, -3.29564363e-01f, 1.55858755e-01f, -3.19686115e-01f, 2.32544228e-01f, -6.23357296e-01f, -2.18920887e-01f, 2.35981420e-01f,
  2.05488563e-01f, -3.11465383e-01f, 1.75842047e-02f, -3.49340081e-01f, -6.32519186e-01f, 1.71211988e-01f, -1.26786068e-01f, -1.87629983e-01f, 8.58794153e-02f, -4.07889396e-01f,
  1.94580257e-01f, 8.03397447e-02f, 2.05921918e-01f, -5.00270903e-01f, 3.01339179e-01f, -2.15717554e-01f, 4.51946035e-02f, 1.18552893e-01f, -3.92037660e-01f, -5.58467582e-02f,
  -4.05634314e-01f, 1.24031819e-01f, -1.86391070e-01f, -8.00173357e-02f, 9.16860178e-02f, -1.15854345e-01f, 3.71840671e-02f, -2.88489938e-01f, 8.37252364e-02f, 2.79327333e-01f,
  -4.54706967e-01f, 1.62469037e-02f, 3.74746501e-01f, 2.57318735e-01f, 3.01003993e-01f, -2.17352450e-01f, -2.50065863e-01f, -2.01955006e-01f, 1.76204711e-01f, 1.49270371e-01f,
  2.19413459e-01f, -3.32072407e-01f, 2.95304269e-01f, 3.49368274e-01f, 3.59019823e-02f, -2.48509943e-01f, 1.30423963e-01f, -4.12183136e-01f, 5.02070665e-01f, -2.35702947e-01f,
  -2.73911595e-01f, -1.39453128e-01f, 7.07327574e-02f, -3.28194529e-01f, -2.62104362e-01f, -2.40103096e-01f, -7.15533495e-01f, -2.33786479e-02f, 3.69486928e-01f, -5.46084702e-01f,
  -4.21709687e-01f, -1.98275685e-01f, 2.27660000e-01f, 1.08203530e-01f, 9.98288617e-02f, -3.89194399e-01f, 7.72995800e-02f, 3.31694067e-01f, -8.58878419e-02f, 5.14122605e-01f,
  1.77223980e-01f, 2.56929733e-02f, -1.61522314e-01f, -1.76996253e-02f, 2.86988467e-01f, -1.53896719e-01f, 4.73824114e-01f, 2.84429193e-01f, 2.03829139e-01f, 1.79533184e-01f,
  3.48570734e-01f, -1.16483472e-01f, -9.92599577e-02f, 6.40950650e-02f, -1.08641148e-01f, 1.05976023e-01f, -1.36916369e-01f, -8.68025795e-02f, 1.52352527e-01f, 1.53740555e-01f,
  1.87737286e-01f, 1.98338330e-01f, -2.02139318e-01f, -1.69019043e-01f, -2.70777971e-01f, 2.53492683e-01f, 3.30080837e-01f, -7.99441189e-02f, 5.09013198e-02f, -1.09682292e-01f,
  1.74875379e-01f, -9.12610888e-02f, 1.52625129e-01f, 3.95876989e-02f, -1.88188702e-01f, 2.22233117e-01f, -1.17876276e-01f, 5.51139772e-01f, -3.96404624e-01f, 2.39239842e-01f,
  3.55133325e-01f, 3.14241946e-01f, 5.45915365e-01f, 2.78130084e-01f, -4.06113654e-01f, 3.39625299e-01f, -7.54527673e-02f, 8.62875953e-02f, 2.90953010e-01f, -4.75548029e-01f,
  3.42573375e-01f, -3.97920571e-02f, -2.63327450e-01f, -1.93068296e-01f, 1.68851092e-01f, 2.04911008e-02f, -4.58203882e-01f, 2.11997166e-01f, 2.31530979e-01f, -4.47571397e-01f,
  -4.50785935e-01f, -5.55248201e-01f, -1.23515148e-02f, -1.35622457e-01f, -3.32129002e-01f, -4.45379972e-01f, 1.47295058e-01f, 9.73252505e-02f, -1.75693676e-01f, -4.46191192e-01f,
  -1.98934413e-02f, -4.70058650e-01f, -1.77195579e-01f, 2.69655306e-02f, -1.20175637e-01f, 2.26384029e-02f, 1.48756057e-01f, 8.88937060e-03f, -2.20161974e-01f, -1.25689939e-01f,
  -3.19058299e-01f, 1.05579048e-01f, 1.40562803e-01f, -6.65732250e-02f, -1.89514682e-01f, -3.90268974e-02f, -3.24926227e-02f, -2.05068842e-01f, -7.91708827e-02f, -6.39669001e-02f,
  -1.10433452e-01f, -3.10742676e-01f, -3.34548146e-01f, -7.21858218e-02f, 1.97388977e-01f, -1.92784235e-01f, -5.13920546e-01f, -1.94948912e-01f, -6.41933739e-01f, -2.08290100e-01f,
  -3.54005933e-01f, 1.70544654e-01f, 2.82244086e-01f, 3.85897718e-02f, 2.60223597e-01f, 2.66667604e-01f, 1.66722149e-01f, 1.23343736e-01f, -2.89242379e-02f, -2.19268471e-01f,
  -4.50750172e-01f, 2.68116593e-01f, -7.08931014e-02f, -1.18128821e-01f, 2.60391951e-01f, -2.55288422e-01f, -5.51932603e-02f, -1.92220569e-01f, 2.67740995e-01f, -2.08665192e-01f,
  -4.20202613e-01f, 5.80082051e-02f, -5.85780740e-01f, 4.56837416e-01f, -8.06757361e-02f, -1.44154638e-01f, 5.97232915e-02f, -2.54519671e-01f, -1.83868304e-01f, 1.82358786e-01f,
  2.74965912e-01f, -3.38731647e-01f, 1.13369711e-01f, 3.21866214e-01f, 8.51562694e-02f, 2.41212755e-01f, -5.98128438e-02f, 1.02690101e-01f, 1.97755858e-01f, -5.74909508e-01f,
  4.06249203e-02f, 4.03010517e-01f, -3.30422878e-01f, -1.83250815e-01f, -8.14753920e-02f, 1.30809192e-02f, -1.37051046e-01f, -8.45414819e-04f, 3.16609964e-02f, 2.27748662e-01f,
  2.75883853e-01f, -3.62377167e-01f, 2.22897917e-01f, -2.57968545e-01f, -9.36403498e-02f, -2.23408237e-01f, -3.47574681e-01f, 3.36986125e-01f, 2.27812946e-01f, 1.78633243e-01f,
  2.41529241e-01f, -3.77502531e-01f, 1.98072895e-01f, 4.36131924e-01f, 8.86108261e-03f, -5.54900646e-01f, -1.24986634e-01f, 4.06264663e-01f, 9.74303186e-02f, 6.44656718e-02f,
  -4.09617752e-01f, -2.28705332e-02f, 4.55078512e-01f, 1.39581829e-01f, 2.62920326e-03f, -1.27190873e-01f, 2.29419440e-01f, 2.32212599e-02f, 1.35014012e-01f, -8.53632167e-02f,
  1.67898124e-03f, 4.60365206e-01f, 6.93543553e-02f, -2.54855782e-01f, -2.92066991e-01f, -4.80243750e-02f, -1.97173923e-01f, -4.52474475e-01f, 2.25826189e-01f, 6.07852787e-02f,
  3.21416706e-01f, 4.24458459e-02f, 2.19097853e-01f, 2.29272619e-02f, 2.74823215e-02f, 2.64842868e-01f, -2.98696142e-02f, 1.69471651e-01f, 1.19449429e-01f, -8.31388310e-02f,
  -2.25995302e-01f, -2.67752498e-01f, 1.46904007e-01f, 9.24226940e-02f, -2.16827840e-01f, -3.31765443e-01f, 3.70418876e-01f, -2.05652267e-02f, 4.65057641e-02f, 2.98163444e-01f,
  9.03526042e-03f, 2.99347609e-01f, -2.76307203e-02f, -2.84074366e-01f, 7.06358179e-02f, 4.63696048e-02f, 4.23082650e-01f, 2.17872500e-01f, -1.72197640e-01f, -3.67790669e-01f,
  -5.04207790e-01f, 4.58707184e-01f, -1.31755145e-02f, -2.58974195e-01f, 3.92771214e-01f, -1.84142902e-01f, 3.38788599e-01f, 4.70754765e-02f, 1.49701342e-01f, 1.12053916e-01f,
  -3.21162581e-01f, -2.10194901e-01f, 4.16716099e-01f, 4.56433922e-01f, -2.91794717e-01f, 4.14646775e-01f, -2.36134544e-01f, -1.10029317e-01f, 2.65039623e-01f, 4.03615683e-01f,
  -3.08267981e-01f, -1.07160583e-01f, 3.43505490e-05f, -2.62350589e-01f, -2.60892034e-01f, -4.56854075e-01f, -6.26233399e-01f, 2.90762216e-01f, -2.72993185e-03f, 7.51546547e-02f,
  -3.04825157e-01f, -3.15831244e-01f, 3.09592038e-01f, 3.06123912e-01f, 2.04275087e-01f, -3.00190687e-01f, -4.49174605e-02f, -2.63099015e-01f, 6.93493709e-02f, 2.01896559e-02f,
  -2.67634571e-01f, -1.14718288e-01f, -1.91291988e-01f, 3.77317704e-02f, 1.36904538e-01f, -2.11602245e-02f, -2.13945702e-01f, 1.93229571e-01f, -1.89362973e-01f, 7.20733479e-02f,
  -2.13180780e-02f, 9.48999226e-02f, 8.92410800e-02f, 1.33549348e-01f, 2.18287140e-01f, -9.86902043e-02f, -2.69304924e-02f, 1.66222394e-01f, -2.77927220e-01f, -1.71278313e-01f,
  6.67358190e-02f, 4.91152823e-01f, 1.01765759e-01f, -2.53674805e-01f, 6.41050786e-02f, 2.64015973e-01f, -3.08332533e-01f, 2.29220733e-01f, 3.04275036e-01f, 2.88418651e-01f,
  2.90120356e-02f, 3.35940063e-01f, -2.38515422e-01f, 1.06206052e-01f, 3.23227644e-01f, -2.74607509e-01f, 1.55056655e-01f, -1.54564112e-01f, -2.62367725e-01f, 4.99907672e-01f,
  1.63480848e-01f, 3.58836770e-01f, -1.90668717e-01f, 1.70308068e-01f, -7.55282789e-02f, -1.98062584e-01f, -4.85137314e-01f, 3.25118840e-01f, -4.32866663e-01f, -5.55831730e-01f,
  -1.93907812e-01f, 3.42167526e-01f, 2.14743927e-01f, -4.48086977e-01f, 2.33756587e-01f, -8.90303552e-02f, -4.40294981e-01f, -3.47372502e-01f, 3.61936651e-02f, -1.49070501e-01f,
  -9.76211652e-02f, 3.31974328e-01f, 1.53005898e-01f, -1.43503860e-01f, 1.99598983e-01f, -1.83545157e-01f, 1.75545365e-01f, 1.17891438e-01f, -1.79694220e-01f, -1.65648013e-01f,
  1.07603639e-01f, 1.22902788e-01f, 1.07605733e-01f, -1.49478197e-01f, 9.71036106e-02f, 1.24785379e-01f, 1.08747676e-01f, 9.59117487e-02f, -4.33414549e-01f, -1.58403575e-01f,
  -1.33054564e-02f, 2.36539349e-01f, -1.71034336e-01f, 3.84041935e-01f, -2.82183439e-01f, -3.98469806e-01f, -1.97707951e-01f, 5.52903533e-01f, 2.39918858e-01f, -2.26656020e-01f,
  9.82162058e-02f, -6.88291937e-02f, -3.33586127e-01f, 3.23013365e-01f, -2.61792362e-01f, -4.97389019e-01f, 2.48120397e-01f, -5.08595467e-01f, 1.25017345e-01f, 9.14406925e-02f,
  -3.75227839e-01f, -2.87155002e-01f, -2.00531080e-01f, -3.45144987e-01f, 3.19040477e-01f, 1.58397913e-01f, -6.31330833e-02f, -4.78418201e-01f, -5.56489527e-02f, -2.74495363e-01f,
  -2.98490286e-01f, 9.69966352e-02f, -4.51340079e-01f, 3.86811852e-01f, 2.51242787e-01f, 6.25375053e-03f, 1.14515640e-01f, -2.06891134e-01f, -4.19751294e-02f, 6.62896633e-02f,
  1.78809285e-01f, -2.69168884e-01f, -1.08310312e-01f, 2.09201679e-01f, 3.28459412e-01f, 1.03846649e-02f, 2.34433934e-02f, -8.49690959e-02f, 5.54993413e-02f, -1.20618701e-01f,
  2.00734481e-01f, 1.13595128e-01f, -1.23551466e-01f, 1.12544648e-01f, -4.02063489e-01f, -1.60527021e-01f, -1.89683199e-01f, 3.42026323e-01f, -1.06288679e-01f, -9.47777480e-02f,
  8.00721422e-02f, 2.22432494e-01f, -2.47913897e-01f, 1.89641148e-01f, -3.97170752e-01f, 1.20642647e-01f, 1.15640134e-01f, -2.22874492e-01f, 1.65468931e-01f, 1.08239949e-01f,
  -5.44137299e-01f, 4.30943131e-01f, 3.26857209e-01f, -2.70595104e-01f, 4.63861674e-01f, 3.75799417e-01f, -1.07761189e-01f, -4.43180829e-01f, -7.86870122e-02f, 1.70476567e-02f,
  5.10599315e-01f, 1.15330024e-02f, 1.67783052e-01f, -3.39536041e-01f, -4.99303937e-01f, -1.86067820e-01f, 1.94897994e-01f, -4.25925672e-01f, -3.64649862e-01f, -8.20707604e-02f,
  4.43442672e-01f, 1.32324845e-01f, 1.71124712e-01f, 1.45800769e-01f, 1.61917940e-01f, 2.39402950e-01f, -5.85498102e-02f, -7.53876120e-02f, -5.59800684e-01f, 2.16478273e-01f,
  -5.07371724e-01f, -5.35689108e-02f, -5.42438984e-01f, 4.17138278e-01f, -4.36423630e-01f, 2.55541652e-01f, -5.57684526e-02f, -5.88025898e-03f, 1.99023709e-01f, -2.66893506e-01f,
  -4.53067347e-02f, 9.60651189e-02f, -9.98438075e-02f, 3.05127949e-01f, -2.94633389e-01f, -3.22438061e-01f, -6.53628334e-02f, 2.37207472e-01f, 3.00429333e-02f, -3.64256769e-01f,
  3.41717422e-01f, 1.25976905e-01f, 3.41752231e-01f, 9.46429372e-03f, 2.96255767e-01f, -1.46075174e-01f, 7.55111426e-02f, 3.09107304e-01f, -4.43500131e-01f, 4.57389280e-02f,
  2.42992267e-01f, -1.05886497e-01f, -2.38918677e-01f, 1.19467169e-01f, 3.42695415e-01f, 9.59063228e-03f, 7.65612349e-02f, -3.21685165e-01f, -3.39111239e-01f, 2.17948973e-01f,
  6.86454074e-03f, 8.41325372e-02f, 1.49848163e-01f, 3.80012542e-01f, -1.60189003e-01f, -6.42133176e-01f, 1.45960391e-01f, 2.12254003e-01f, -1.10045485e-01f, -2.30468035e-01f,
  4.29035366e-01f, -2.00397104e-01f, -3.42474043e-01f, 2.87184455e-02f, -2.42881849e-01f, 1.75468981e-01f, 3.76456469e-01f, -6.66714646e-03f, 1.69605419e-01f, -1.09466329e-01f,
  3.26319546e-01f, 4.34585661e-01f, 2.24824399e-01f, -4.03512537e-01f, 1.99233085e-01f, -6.09422028e-01f, 2.51355767e-01f, -5.77341467e-02f, -5.47596335e-01f, -1.71063051e-01f,
  -1.64068311e-01f, -1.25346959e-01f, -3.52345437e-01f, -3.54232222e-01f, -4.38860118e-01f, 1.87906008e-02f, -9.00156517e-03f, -2.72629440e-01f, 7.85402209e-02f, 9.75169241e-02f,
  -5.63608110e-02f, 2.29571998e-01f, -1.06694207e-01f, 5.62571883e-02f, 1.16163224e-01f, 1.28334984e-01f, 3.19266975e-01f, 1.47559270e-01f, 1.35454983e-01f, -1.29926234e-01f,
  1.07712768e-01f, 6.63236231e-02f, 6.82246685e-02f, -2.81292021e-01f, -2.28824876e-02f, 5.30204356e-01f, 2.26418182e-01f, -1.21618308e-01f, -1.64795250e-01f, 5.76905251e-01f,
  2.99974233e-01f, 4.40408289e-01f, 2.25771606e-01f, 1.44363463e-01f, -9.23450068e-02f, -8.07092637e-02f, 7.45509006e-03f, -1.82974681e-01f, 2.48638496e-01f, -3.92083138e-01f,
  -3.80013824e-01f, -2.78707504e-01f, -4.18754369e-01f, -3.25843573e-01f, -4.34130460e-01f, -3.67014140e-01f, 6.31269813e-01f, 5.03546819e-02f, 1.71200618e-01f, -3.69868696e-01f,
  -4.17733580e-01f, -3.76520514e-01f, 2.73921818e-01f, -6.95834219e-01f, 3.02304298e-01f, -2.29095504e-01f, -5.20116031e-01f, -4.76997524e-01f, -5.80844879e-01f, -6.04240894e-02f,
  3.79707403e-02f, 5.03606737e-01f, 3.42389643e-02f, 7.95201138e-02f, -1.92555144e-01f, -6.72876462e-03f, 9.76441130e-02f, 5.30678518e-02f, 1.49210721e-01f, 1.46911472e-01f,
  7.32612461e-02f, 3.73369120e-02f, -3.89654309e-01f, 1.21677443e-01f, 9.10738930e-02f, 2.26275455e-02f, 7.15897381e-02f, 9.64453891e-02f, 2.14223817e-01f, -3.72997433e-01f,
  9.96859670e-02f, 1.31337345e-01f, -7.03496858e-02f, -2.66045988e-01f, 2.67910480e-01f, -1.93364292e-01f, 4.80893925e-02f, -1.57480851e-01f, -2.96211466e-02f, 4.42440182e-01f,
  -1.82745665e-01f, -2.98356026e-01f, 1.90176487e-01f, -3.17364484e-01f, -3.79373580e-01f, -1.80826396e-01f, -2.83074349e-01f, -1.04638852e-01f, -8.93410295e-02f, -4.25963476e-02f,
  1.14727784e-02f, -3.58315796e-01f, -2.51501828e-01f, 2.59454608e-01f, -1.09418132e-03f, -7.45881945e-02f, -1.97025165e-01f, -5.07669747e-02f, 1.61030009e-01f, -1.33006334e-01f,
  -2.91700602e-01f, -3.99415344e-01f, -4.68433619e-01f, 3.49507868e-01f, -3.87046367e-01f, 4.94434118e-01f, 2.93877482e-01f, 2.13892043e-01f, -4.05270606e-01f, -3.10336262e-01f,
  -3.29028696e-01f, 9.46718603e-02f, 2.57369488e-01f, -4.98527229e-01f, -5.66431165e-01f, -4.68444467e-01f, -3.58448863e-01f, 1.83508828e-01f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  4.68662055e-03f, -4.68890294e-02f, -8.02440867e-02f, 7.59680644e-02f, 8.81422833e-02f, 8.11229944e-02f, 6.48698360e-02f, 3.90286557e-02f, -4.56879698e-02f, -1.01218112e-01f,
  1.88439637e-02f, -1.05847806e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 25, 14
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 25, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        64, 25, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        64, 12
    );
    }
    