/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 12 x 120)
const int L0_fan_Wp_rows = 12;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -2.87316442e-01f, 1.61881030e-01f, 2.35105470e-01f, -4.12137419e-01f, -1.87094867e-01f, 9.20774639e-02f, 3.43193054e-01f, -2.90565193e-01f, -1.00090042e-01f, -3.57101411e-02f,
  -2.76107073e-01f, 2.49478802e-01f, 3.19605172e-01f, -1.55076399e-01f, -3.19191851e-02f, 1.91357106e-01f, -2.51702875e-01f, -6.71056807e-02f, -7.42893368e-02f, -1.77033558e-01f,
  -2.56442696e-01f, -4.06384557e-01f, -1.42092735e-01f, -2.03389600e-01f, -1.95130304e-01f, -6.16666153e-02f, -1.82960823e-01f, 1.45291135e-01f, -9.64793935e-02f, 1.11389548e-01f,
  -6.41699731e-02f, -1.43647358e-01f, 7.49105364e-02f, -1.33601418e-02f, -1.69435680e-01f, 5.24968244e-02f, 4.88328487e-02f, 1.76534638e-01f, 4.83947806e-02f, -4.14516740e-02f,
  6.23901784e-02f, -1.37136877e-01f, -3.90698574e-02f, 8.84359926e-02f, -1.03660710e-01f, -6.03956468e-02f, -6.33872747e-02f, -3.51436958e-02f, -1.04598310e-02f, 6.50593489e-02f,
  5.09862043e-03f, -6.78490028e-02f, -1.00403249e-01f, -5.87191656e-02f, 3.79501284e-06f, 2.10220809e-03f, 7.42354020e-02f, 8.58335495e-02f, -2.93305833e-02f, -5.62728420e-02f,
  -6.92327097e-02f, -1.13294367e-02f, -2.56551336e-03f, -5.16709946e-02f, -6.42928034e-02f, -5.06693907e-02f, 4.06584106e-02f, 6.92245876e-03f, -7.24968081e-03f, -4.40844186e-02f,
  -1.26571774e-01f, -4.76147793e-02f, -1.48712784e-01f, -4.02105004e-02f, -4.83197235e-02f, -1.67726409e-02f, 1.08677208e-01f, -1.74260773e-02f, -1.11668922e-01f, -4.58396748e-02f,
  3.15008052e-02f, 1.31346984e-02f, -1.07074240e-02f, -7.52059519e-02f, 4.08908464e-02f, -4.17106599e-02f, -4.23238389e-02f, -1.64967626e-02f, 4.71054353e-02f, 5.32673262e-02f,
  -5.87501600e-02f, -1.10004365e-01f, 9.51694623e-02f, 3.32461819e-02f, 6.72434494e-02f, -2.89144199e-02f, 3.21109667e-02f, -1.32882940e-02f, 3.30548920e-02f, -2.04237457e-02f,
  -9.71172452e-02f, -3.67546901e-02f, -8.54464397e-02f, -2.22961139e-02f, -1.12742912e-02f, 1.31246746e-02f, 5.76372482e-02f, -6.16470128e-02f, -4.98134159e-02f, -7.78100491e-02f,
  -9.08122063e-02f, 2.51827259e-02f, 2.92101931e-02f, -1.68742120e-01f, -6.09299801e-02f, -3.38116959e-02f, 3.38255614e-02f, -2.73468941e-02f, -2.59490702e-02f, 3.20790522e-02f,
  5.30682802e-01f, -3.77277941e-01f, 1.20305330e-01f, -6.79504648e-02f, 6.59657493e-02f, 3.93297106e-01f, 2.28210613e-01f, -1.76102236e-01f, 2.10441306e-01f, -4.07309055e-01f,
  -1.93246156e-01f, 3.92199568e-02f, -7.08464533e-02f, -2.31628269e-01f, 6.52106643e-01f, 1.56478092e-01f, 1.52879849e-01f, 2.85867322e-02f, 8.75478834e-02f, -1.16441593e-01f,
  8.89805406e-02f, -1.32531449e-01f, -1.01174615e-01f, -1.23856023e-01f, -3.65183353e-02f, -1.33685514e-01f, -1.82990283e-01f, 3.92392129e-02f, -2.36217141e-01f, 2.41488442e-02f,
  -4.29685488e-02f, -2.38742724e-01f, -1.12343132e-02f, -1.46263968e-02f, 3.87444831e-02f, -9.66322348e-02f, 1.45588852e-02f, 1.13038734e-01f, 8.18032995e-02f, -4.36717384e-02f,
  4.63643819e-02f, 1.60169713e-02f, -4.35060672e-02f, 6.70962930e-02f, -2.78551262e-02f, -1.47120040e-02f, 5.19270496e-03f, -6.57545626e-02f, -2.22509298e-02f, -9.55627114e-03f,
  -1.25369094e-02f, -5.88077195e-02f, -2.14004330e-02f, -5.57759851e-02f, 4.18343581e-02f, 8.29297584e-03f, -6.53775642e-03f, 2.94027906e-02f, -3.68905701e-02f, 6.50149286e-02f,
  -6.07163347e-02f, 5.80191724e-02f, 1.50987254e-02f, -1.10216759e-01f, 1.15969107e-01f, -1.21201068e-01f, 1.50951101e-02f, -8.50154832e-02f, 1.14390746e-01f, 9.22368653e-03f,
  4.00039703e-02f, -4.78940234e-02f, -5.98856099e-02f, -4.69127744e-02f, -7.33272210e-02f, -1.58797968e-02f, -7.40099873e-04f, -8.46331939e-02f, 4.49710637e-02f, 3.59907374e-02f,
  -1.95232294e-02f, 4.15973412e-03f, -1.81332026e-02f, -6.74672872e-02f, -4.40389626e-02f, 8.74868128e-03f, -4.95284274e-02f, -4.00227569e-02f, -7.36166686e-02f, 8.05813372e-02f,
  4.63726446e-02f, -1.15031429e-01f, -1.75397377e-02f, -1.31399287e-02f, -7.14783669e-02f, 3.32343834e-03f, 2.41834708e-02f, -1.93361789e-02f, -1.76101532e-02f, -2.41714437e-02f,
  -8.09107497e-02f, -5.39543889e-02f, 2.95009203e-02f, -1.43314060e-02f, 7.13637620e-02f, -2.29757763e-02f, -5.57829887e-02f, 5.08966930e-02f, 2.79074796e-02f, -3.64473946e-02f,
  -1.36981793e-02f, 3.68310302e-03f, 5.41409403e-02f, 2.06666291e-02f, -7.53303319e-02f, 2.83623524e-02f, 7.29445647e-03f, 5.35804592e-02f, -1.39743404e-03f, 7.20929727e-03f,
  -6.00879751e-02f, -1.80467308e-01f, 6.38068328e-03f, 8.85942653e-02f, -2.99709588e-01f, 2.54226178e-02f, 2.23674893e-01f, -2.78822154e-01f, 2.03402668e-01f, -2.18291469e-02f,
  6.87892959e-02f, 9.07082111e-02f, 1.19115219e-01f, 3.31603557e-01f, 4.67186570e-01f, 4.86432999e-01f, 3.26054513e-01f, 1.78128973e-01f, 9.24663693e-02f, -9.23923776e-02f,
  -3.87128554e-02f, -1.41428337e-01f, -2.07226072e-02f, -3.72984886e-01f, -3.24308783e-01f, -3.92312378e-01f, -1.85449824e-01f, -1.51969984e-01f, -2.00110152e-01f, 2.44149938e-02f,
  2.23849714e-01f, 1.00680523e-01f, -4.02263664e-02f, 2.48240381e-02f, -1.14357732e-02f, -3.61893363e-02f, 5.33499867e-02f, 3.38229798e-02f, 8.97528082e-02f, 4.08634357e-03f,
  7.76480511e-02f, 1.01389680e-02f, -6.73403814e-02f, -6.81519881e-02f, -4.78993766e-02f, 7.53120482e-02f, 4.31758761e-02f, 6.41676560e-02f, -5.49340174e-02f, 3.64452153e-02f,
  4.70377766e-02f, 4.57311086e-02f, -1.02911759e-02f, 4.54911739e-02f, -5.16467318e-02f, 6.59829676e-02f, 3.97020914e-02f, -7.61988685e-02f, 5.47261536e-02f, -6.17189296e-02f,
  -6.79694414e-02f, -1.10597331e-02f, -4.31207232e-02f, 3.49262282e-02f, 1.33712590e-02f, -2.50654351e-02f, 6.31925464e-02f, 1.50662307e-02f, -3.09986267e-02f, 2.72246748e-02f,
  -1.40994554e-03f, -3.35894786e-02f, 3.39851491e-02f, 1.54947080e-02f, -3.77208143e-02f, 1.08373379e-02f, 1.02565456e-02f, -1.49284741e-02f, -3.66183408e-02f, -1.74155980e-02f,
  4.20846492e-02f, 3.12615186e-02f, -1.02243513e-01f, -8.04114621e-03f, 7.89463446e-02f, -5.71542978e-02f, -6.05497397e-02f, -4.80783656e-02f, 3.09487339e-02f, -8.13103467e-03f,
  -2.02561263e-02f, -2.90569246e-01f, -9.12111253e-02f, -9.24791151e-04f, 9.89674181e-02f, -1.79590248e-02f, 5.98017760e-02f, -6.31402805e-02f, -9.96589288e-02f, -1.62133994e-03f,
  -8.73241499e-02f, 3.09107769e-02f, -9.82337259e-03f, 4.71687876e-03f, 1.16437278e-03f, -7.28278011e-02f, 1.93054192e-02f, -2.25781668e-02f, -9.71090347e-02f, -3.54600772e-02f,
  -4.96294275e-02f, 7.85880089e-02f, 3.14506590e-02f, -1.31605998e-01f, -3.56249288e-02f, -2.81616934e-02f, -1.17992841e-01f, 5.54876663e-02f, 2.20911428e-02f, 1.21315591e-01f,
  1.91916019e-01f, 2.15003476e-01f, 3.76304239e-01f, 1.37029335e-01f, -2.05160335e-01f, -6.82022795e-02f, 4.07274030e-02f, -3.38788852e-02f, 2.32198313e-01f, -1.99814454e-01f,
  -2.45966852e-01f, 3.72439355e-01f, 7.69191608e-02f, -2.37568796e-01f, 3.81223172e-01f, 2.02020779e-01f, 2.56780274e-02f, -6.12289086e-02f, 1.22758687e-01f, -4.22390271e-03f,
  1.60273179e-01f, -4.41492110e-01f, 2.46749818e-01f, -2.21006677e-01f, -1.83222815e-01f, 5.37781157e-02f, -1.31702647e-01f, -6.79724813e-02f, -2.00642034e-01f, -5.01480103e-02f,
  -2.89645735e-02f, 1.12271197e-01f, 6.37476519e-02f, 1.55300125e-02f, 1.88983753e-02f, -1.33647174e-01f, -2.84614693e-03f, 9.85404849e-03f, 4.00553234e-02f, 3.92926671e-02f,
  -2.89549902e-02f, -9.00046676e-02f, -1.50329759e-02f, 6.85241586e-03f, -8.04544017e-02f, 1.01973843e-02f, 4.62557301e-02f, 3.45533453e-02f, -5.52082667e-03f, 5.90017475e-02f,
  7.23650232e-02f, -6.28551235e-03f, 4.22449149e-02f, 1.03143357e-01f, 8.32940489e-02f, 2.44492311e-02f, 1.13501422e-01f, 6.79196343e-02f, -7.84503936e-04f, 7.32036158e-02f,
  -1.79530699e-02f, 2.69726552e-02f, -1.91229116e-02f, -1.02429524e-01f, -1.98427178e-02f, -5.69686554e-02f, -1.80737916e-02f, -8.22892115e-02f, 1.28813669e-01f, -8.58237687e-03f,
  -3.08336001e-02f, 1.95688512e-02f, -1.36406004e-01f, -3.78472507e-02f, -6.16253391e-02f, 1.56460647e-02f, 3.58728841e-02f, 1.13089727e-02f, 4.13118824e-02f, 1.36707705e-02f,
  7.66680343e-04f, -4.08005603e-02f, 3.94751839e-02f, -6.22135699e-02f, -1.62691772e-02f, 4.82526347e-02f, -9.29594412e-02f, 7.20148608e-02f, 1.88451260e-02f, -2.86568701e-02f,
  -6.07540645e-02f, 2.06570938e-01f, 6.16655611e-02f, -7.01694265e-02f, 7.57844597e-02f, -7.75543228e-02f, 8.88329931e-03f, 7.93503970e-02f, -3.62090394e-02f, -3.76041122e-02f,
  -4.69199307e-02f, -4.61627841e-02f, 2.19902769e-02f, -2.62040384e-02f, 1.23093333e-02f, 6.09313743e-03f, -4.89117913e-02f, -2.33401190e-02f, 9.21334419e-03f, 4.57199775e-02f,
  -9.78339836e-02f, -2.50825156e-02f, -8.25271383e-03f, -4.37261770e-03f, -3.43712941e-02f, 6.26594294e-03f, -2.14805398e-02f, 4.19307612e-02f, -2.23164037e-02f, 2.64551286e-02f,
  8.01399127e-02f, 2.16235623e-01f, 1.35056064e-01f, 1.70898497e-01f, -2.76370227e-01f, -3.22117895e-01f, -8.61847848e-02f, 4.50070538e-02f, 2.62800694e-01f, -5.14078811e-02f,
  -1.23342127e-01f, 2.53524423e-01f, 7.27107003e-02f, -2.11779743e-01f, 3.13997597e-01f, 1.38915390e-01f, -1.46787554e-01f, -3.31421345e-02f, 5.10689467e-02f, 1.28981560e-01f,
  3.50331813e-02f, -1.49648428e-01f, -9.24581587e-02f, -5.35550378e-02f, -2.74676144e-01f, 7.97347575e-02f, 1.55432159e-02f, 1.66204736e-01f, -2.54807204e-01f, 6.56119287e-02f,
  -6.12619938e-03f, 5.74822500e-02f, -1.02585562e-01f, 1.02471467e-03f, -1.53418496e-01f, -1.39370069e-01f, 5.32593057e-02f, 1.40463367e-01f, 5.75489439e-02f, -2.13405136e-02f,
  3.69081721e-02f, -3.99421193e-02f, 1.80951264e-02f, 9.83527675e-02f, -4.08522971e-02f, 9.25135054e-03f, -1.03127941e-01f, -2.22309098e-01f, -7.31416047e-02f, -8.48028883e-02f,
  3.90412062e-02f, -4.74645309e-02f, -6.00137450e-02f, 1.77309494e-02f, 1.00800069e-02f, -5.23960264e-03f, -4.10273522e-02f, 1.76396295e-02f, -1.04381271e-01f, -6.88391253e-02f,
  -9.79217887e-02f, -2.29766555e-02f, -2.74061970e-02f, -3.24430130e-03f, 3.47236767e-02f, -8.13531280e-02f, -1.12050781e-02f, 1.01801055e-03f, 7.00153485e-02f, 5.41019579e-03f,
  -3.46660540e-02f, 6.17414638e-02f, -8.87833908e-03f, 2.10994706e-02f, -6.49797171e-02f, 1.54295871e-02f, 4.47530905e-03f, 5.29228374e-02f, -5.67676350e-02f, -8.56372938e-02f,
  4.39805388e-02f, 8.22366700e-02f, 8.48490298e-02f, -9.79823396e-02f, 2.75410917e-02f, 4.54442427e-02f, 6.11382946e-02f, -1.64939705e-02f, 4.67490219e-02f, 6.58897385e-02f,
  1.61407903e-01f, 3.53887409e-01f, 4.22018208e-03f, 3.76641634e-03f, 9.22542736e-02f, -1.16449771e-02f, 2.98738778e-02f, -3.30254696e-02f, 3.12244259e-02f, -6.80331215e-02f,
  3.95876402e-03f, -3.72514725e-02f, 1.73020829e-02f, -4.21309508e-02f, 7.71247670e-02f, -2.42586639e-02f, 1.17578439e-01f, 1.12305298e-01f, -3.74242081e-03f, -2.85397633e-03f,
  -1.08945277e-03f, -1.33331260e-02f, -3.48180649e-03f, -6.57293499e-02f, 1.56215988e-02f, -4.26201075e-02f, 1.61647260e-01f, -2.12456323e-02f, -1.27599547e-02f, -2.97039468e-02f,
  -3.92079324e-01f, 2.51392663e-01f, 1.05311573e-01f, 1.05180964e-02f, -2.81203330e-01f, -5.35518490e-02f, -1.71877041e-01f, -8.74678567e-02f, 1.10986479e-01f, 7.62475505e-02f,
  -4.48462106e-02f, -1.72715172e-01f, 2.47105196e-01f, 9.40531045e-02f, 1.92701697e-01f, 3.84190649e-01f, 1.55838117e-01f, 1.40299089e-02f, 1.09303854e-01f, -2.59652048e-01f,
  7.28750080e-02f, -2.50252873e-01f, 2.84870237e-01f, -9.55594629e-02f, -2.55643219e-01f, -4.97697257e-02f, -1.02727950e-01f, 2.69960649e-02f, -1.12592556e-01f, -7.38190413e-02f,
  -1.57518458e-04f, 6.75401790e-03f, -4.42122333e-02f, -1.03109507e-02f, -3.95755731e-02f, -2.42220461e-02f, -4.96220328e-02f, 8.48719850e-02f, 3.13199051e-02f, -1.16385398e-02f,
  -6.19916357e-02f, -2.13188753e-02f, -7.89433494e-02f, 4.21338156e-02f, -6.22052737e-02f, 2.91240737e-02f, 6.07573837e-02f, 3.56988348e-02f, -4.62713465e-02f, 2.62491554e-02f,
  9.76400450e-02f, 1.55610651e-01f, 3.94851491e-02f, 1.27145603e-01f, 5.41599914e-02f, 6.41307011e-02f, 1.39996316e-02f, -8.43227506e-02f, 2.51851007e-02f, -6.78213462e-02f,
  9.47295725e-02f, -3.80530581e-02f, 6.26041591e-02f, -6.10912628e-02f, 8.20209160e-02f, -1.04152858e-01f, 6.06377460e-02f, -6.82620797e-03f, 2.72526480e-02f, -7.03013241e-02f,
  -8.23392048e-02f, -1.41985239e-02f, -3.02836131e-02f, 5.70353828e-02f, 2.34887451e-02f, 1.25687942e-02f, 3.75589095e-02f, -4.99561206e-02f, -5.86486235e-03f, -1.28866162e-03f,
  6.98297657e-03f, 8.25741736e-05f, -4.42580581e-02f, -7.44473189e-02f, 5.71335107e-02f, -4.83045401e-03f, 9.86677036e-03f, 8.65015686e-02f, 4.57643755e-02f, -1.10575885e-01f,
  -1.88804150e-01f, 5.98165728e-02f, -1.87537465e-02f, 1.02054598e-02f, 2.56528903e-04f, 5.84597476e-02f, 1.47409245e-01f, -6.43927380e-02f, 6.34954944e-02f, -8.84397980e-03f,
  6.91961050e-02f, -5.82432039e-02f, -5.60708418e-02f, -6.14305064e-02f, 2.37929355e-02f, 2.89662182e-02f, -5.96030951e-02f, 1.64740975e-03f, -7.67605826e-02f, -3.99375893e-02f,
  -4.58547398e-02f, -8.00035670e-02f, 1.32124275e-01f, -1.11667000e-01f, -3.96467559e-02f, -7.95603916e-02f, -9.00375992e-02f, 1.19560309e-01f, 2.67226656e-04f, 8.09010193e-02f,
  -3.16951126e-01f, 1.83523819e-01f, 9.68203023e-02f, -3.25618684e-01f, 1.04634918e-01f, 3.01689923e-01f, 1.76609591e-01f, -1.27944663e-01f, -4.97625232e-01f, 2.20981598e-01f,
  2.54474491e-01f, 3.73299085e-02f, 2.43778661e-01f, 3.37732702e-01f, -1.83125526e-01f, 1.54331475e-01f, -2.48170202e-03f, -1.31518422e-02f, -2.27510184e-02f, -9.29630473e-02f,
  -1.03908785e-01f, 1.80375576e-01f, 1.69905141e-01f, 4.06939052e-02f, 2.02767760e-01f, -1.50003403e-01f, -7.45953768e-02f, 1.19740650e-01f, 3.44103463e-02f, 1.50709853e-01f,
  2.12490767e-01f, -6.31777644e-02f, 4.93531413e-02f, -1.00599760e-02f, -2.24927235e-02f, 3.07758152e-02f, 2.97535397e-03f, 2.01013207e-01f, 2.01908126e-02f, -7.68930018e-02f,
  2.99978256e-03f, -7.97617361e-02f, -3.37429680e-02f, -7.86318034e-02f, -1.90983906e-01f, -6.53430447e-02f, -1.67874321e-02f, -2.85260472e-02f, 6.30654953e-03f, -2.12885011e-02f,
  1.88138906e-03f, 4.65068966e-02f, -3.88274603e-02f, -5.82182268e-03f, -4.42087650e-02f, 1.67594943e-02f, 4.01614010e-02f, 2.60624196e-02f, -5.40207103e-02f, -9.51000527e-02f,
  -3.53359543e-02f, -6.59169927e-02f, -5.49671128e-02f, 4.15171962e-03f, 5.21707237e-02f, 2.83843074e-02f, -2.76115152e-05f, 9.39333588e-02f, 1.17279468e-02f, -2.07885373e-02f,
  -7.01310635e-02f, -4.98476475e-02f, 8.44367668e-02f, -5.21316146e-03f, -1.82241693e-01f, -6.41174018e-02f, -1.15295937e-02f, 1.09515652e-01f, -1.27959296e-01f, 2.90147383e-02f,
  2.84145158e-02f, 6.88529983e-02f, 3.66504937e-02f, -7.05302600e-03f, 1.62792690e-02f, -7.28973048e-03f, 1.97311603e-02f, 1.32734701e-02f, 8.86048004e-02f, 4.82471175e-02f,
  -6.64126053e-02f, -1.64171666e-01f, 1.07465327e-01f, 5.45731299e-02f, 1.75525658e-02f, -2.52021383e-02f, -8.19174200e-02f, 5.63682755e-03f, -3.96796353e-02f, 4.31891493e-02f,
  -1.13931291e-01f, -2.33036708e-02f, -7.94784203e-02f, 2.18291581e-02f, -4.21705581e-02f, 7.61917830e-02f, -1.65660884e-02f, -1.03016987e-01f, -1.12948176e-02f, -8.48461017e-02f,
  1.09664515e-01f, -3.30249369e-02f, 2.43506767e-02f, -1.09555740e-02f, -9.73646063e-03f, 4.69654761e-02f, -5.08683659e-02f, -1.93685852e-02f, 4.94237840e-02f, 3.84385809e-02f,
  -5.46441555e-01f, 2.43768975e-01f, 7.91394711e-02f, -4.13782299e-01f, 3.51447687e-02f, -4.13367987e-01f, -4.14530486e-01f, 1.19535476e-01f, -1.76064685e-01f, 1.30152717e-01f,
  -9.09559056e-02f, 1.31105408e-01f, 2.29408681e-01f, -3.00724149e-01f, -3.87045562e-01f, 1.26662076e-01f, -3.89560550e-01f, -2.21675634e-01f, 5.57398796e-02f, -2.66684014e-02f,
  -9.76628065e-02f, -1.31814733e-01f, 1.21671729e-01f, 2.16935307e-01f, -6.09052330e-02f, 5.38326502e-02f, 1.47053659e-01f, 2.42805853e-01f, -8.38527009e-02f, 6.30296618e-02f,
  -2.63145717e-04f, -1.30520046e-01f, 5.28776571e-02f, 5.05129993e-02f, -9.04307142e-02f, 3.18030491e-02f, -1.17906751e-02f, -5.09909494e-03f, -6.07489049e-02f, -1.94058605e-02f,
  1.19807664e-03f, -1.63765326e-02f, -6.79223016e-02f, -9.81828570e-03f, -6.90225363e-02f, 4.04991135e-02f, 4.30448446e-03f, -4.02961997e-03f, 1.07988127e-01f, -1.56461596e-02f,
  3.11695151e-02f, -5.27131036e-02f, -8.32824782e-02f, -6.43492565e-02f, -6.26235306e-02f, -8.44917446e-02f, 4.03016992e-02f, 5.66884466e-02f, 2.69253384e-02f, -1.09579228e-01f,
  6.16294274e-04f, -2.86695939e-02f, 7.03507364e-02f, 9.67809409e-02f, -4.06403393e-02f, 1.05996422e-01f, -2.43135020e-02f, 6.21071793e-02f, 1.78581662e-02f, -2.52034497e-02f,
  -2.32824441e-02f, -3.16627370e-03f, -3.55569273e-02f, -2.55489573e-02f, -5.61476573e-02f, -4.48272303e-02f, 3.33188437e-02f, 5.02562113e-02f, -5.49152531e-02f, 1.38754188e-03f,
  4.75654826e-02f, 3.05524617e-02f, 3.19335982e-02f, 2.52058450e-02f, -2.94980314e-03f, -2.96016373e-02f, -4.18874435e-03f, 3.58295180e-02f, 5.94930202e-02f, -1.24164075e-01f,
  -4.91200462e-02f, 6.11622073e-02f, 1.26121985e-02f, -4.58620209e-03f, 4.35929112e-02f, 4.76494730e-02f, 6.40490791e-03f, -1.16968211e-02f, -1.00913681e-02f, 1.43858818e-02f,
  -4.98518459e-02f, 2.06555855e-02f, 3.98035124e-02f, -3.38535085e-02f, -1.05296373e-01f, 7.23780394e-02f, -3.65824699e-02f, -9.17468313e-03f, -1.24779277e-01f, -4.50830124e-02f,
  -1.64690129e-02f, -1.04155848e-02f, -8.10076855e-03f, 4.50529456e-02f, -5.99768274e-02f, -4.11431566e-02f, -5.88456169e-03f, -6.88009411e-02f, -6.35179132e-02f, 2.24170573e-02f,
  -4.11464065e-01f, 4.13545609e-01f, -2.41585243e-02f, 1.60603896e-01f, 4.91729379e-02f, 1.29001010e-02f, -2.31136680e-01f, 2.18904600e-01f, -1.22720793e-01f, 2.77906448e-01f,
  1.68837801e-01f, -1.14335909e-01f, -1.19265735e-01f, 3.09433728e-01f, -2.56837755e-01f, -8.37892666e-02f, 6.33733869e-02f, 8.46802630e-03f, -1.15958869e-01f, 1.27003580e-01f,
  -1.18995555e-01f, 3.09098959e-01f, -1.81008838e-02f, 2.52401501e-01f, 1.32923545e-02f, 6.09124601e-02f, 1.29059568e-01f, -5.22455089e-02f, 2.77797371e-01f, -5.48475683e-02f,
  -6.40481561e-02f, 1.54619917e-01f, 2.00090520e-02f, -9.98091698e-02f, -7.10165426e-02f, 1.89234540e-02f, -5.46094254e-02f, -5.61949313e-02f, -6.59405142e-02f, 3.11418157e-03f,
  -2.93165278e-02f, -4.21167538e-02f, 7.21815601e-02f, 1.56905688e-02f, -1.08487578e-02f, 7.81861693e-03f, -2.74420474e-02f, 2.25575566e-02f, -5.54761989e-03f, -5.25958054e-02f,
  -1.92901101e-02f, 4.37124493e-03f, -6.44948520e-03f, -6.91530332e-02f, -8.83247256e-02f, -4.14135158e-02f, 3.09532564e-02f, -7.56365061e-02f, 2.82606073e-02f, -1.52061954e-02f,
  -8.49299952e-02f, 3.76823656e-02f, -2.70275977e-02f, 1.69553682e-02f, 4.26394306e-02f, 3.07355113e-02f, -1.15389600e-02f, -1.05438950e-02f, -3.15835811e-02f, 4.60401475e-02f,
  2.83424482e-02f, 4.73102219e-02f, 5.89435287e-02f, 2.58958805e-02f, 4.25744317e-02f, 1.04800332e-02f, -7.25676492e-02f, 9.23755988e-02f, -8.67458731e-02f, -6.01699762e-02f,
  9.04152461e-04f, -1.91728026e-02f, 2.66370196e-02f, -9.80070606e-02f, 3.25608514e-02f, -1.31597724e-02f, 9.02299136e-02f, -3.40681896e-02f, 4.00128663e-02f, -5.10016754e-02f,
  7.93922544e-02f, 1.96726188e-01f, -4.53242846e-02f, 6.51079342e-02f, 9.48182195e-02f, -2.73030587e-02f, -1.47071835e-02f, 1.52276540e-02f, 1.27718365e-03f, 6.54129535e-02f,
  -6.89578429e-03f, -3.58888246e-02f, -1.15905667e-03f, -2.32942477e-02f, -2.66209785e-02f, 6.44055661e-03f, -2.04622303e-03f, -4.18562666e-02f, 3.95817012e-02f, 3.61298434e-02f,
  7.67159611e-02f, -5.00346944e-02f, -1.09332547e-01f, 5.72937727e-02f, 5.56608401e-02f, -7.47641781e-03f, 3.84977683e-02f, 4.19370644e-03f, -5.91117376e-03f, -3.82503904e-02f,
  -5.13701998e-02f, -1.01028599e-01f, -2.83014983e-01f, 2.76445076e-02f, 4.51571554e-01f, -3.21619920e-02f, -4.27540131e-02f, 3.39821041e-01f, -1.31011188e-01f, 6.23874180e-02f,
  1.48544833e-01f, -4.99203563e-01f, -1.32219881e-01f, -4.58096303e-02f, -2.47207046e-01f, -3.26920182e-01f, -7.84801468e-02f, -8.40328634e-02f, -8.34990665e-02f, 2.18667895e-01f,
  8.47195648e-03f, 3.77829909e-01f, 4.50179540e-02f, 4.04184192e-01f, 2.90361851e-01f, 1.66923627e-01f, 2.50202686e-01f, 3.74278910e-02f, 2.33019233e-01f, -1.11260973e-01f,
  6.41988888e-02f, -1.71103794e-02f, 4.52043824e-02f, -7.07271025e-02f, 1.06547691e-01f, -1.04712307e-01f, -5.73821031e-02f, -1.26262024e-01f, 4.33815224e-03f, -2.50279112e-03f,
  -3.61638032e-02f, 1.91025250e-02f, -5.61176203e-02f, 5.39025106e-02f, 7.30026290e-02f, -5.94693497e-02f, -3.89252938e-02f, 1.34639472e-01f, -5.00124171e-02f, -1.12355843e-01f,
  -1.22933397e-02f, -1.32079750e-01f, -1.04748346e-01f, -4.89490554e-02f, -1.01856992e-01f, -5.13139600e-03f, -5.78322485e-02f, -9.42590684e-02f, -5.03937267e-02f, 4.89131473e-02f,
  -1.43696228e-02f, 2.41523571e-02f, -5.01074642e-02f, 2.91535072e-02f, 6.46128133e-02f, 3.98177542e-02f, -6.48157671e-02f, -1.45488614e-02f, -7.96696320e-02f, 1.77462201e-03f,
  1.21308893e-01f, -4.04812880e-02f, -1.58206411e-02f, 1.64133701e-02f, 5.95513126e-03f, 6.22744337e-02f, -2.33666245e-02f, -6.23927973e-02f, 1.02032594e-01f, 5.41404523e-02f,
  -4.33949046e-02f, -3.20875202e-04f, 1.14383042e-01f, 1.51100976e-03f, -5.56161478e-02f, -1.50383040e-02f, 2.83332821e-02f, 1.16406297e-02f, -1.09844459e-02f, -1.82724297e-02f,
  1.62547767e-01f, 1.88655972e-01f, 4.42802720e-02f, 7.08320215e-02f, 4.15557548e-02f, -1.83960591e-02f, -3.66460122e-02f, 1.23048602e-02f, -9.45766121e-02f, -3.62362452e-02f,
  4.35231067e-02f, 8.67939740e-02f, -2.65970714e-02f, -4.63879742e-02f, 1.84258297e-02f, 6.09220192e-03f, -1.94057804e-02f, 4.06456366e-02f, 4.20340756e-03f, 1.79472074e-01f,
  1.16135493e-01f, 2.38768272e-02f, -5.39666377e-02f, 1.09027378e-01f, 5.49834548e-03f, -3.41200642e-03f, 2.20078938e-02f, 2.11112108e-02f, -1.86956581e-02f, -5.41773764e-03f,
  -5.21047235e-01f, 3.99446309e-01f, 1.15826122e-01f, -1.56620398e-01f, -1.69630706e-01f, 1.82772294e-01f, 1.94924474e-02f, -1.29687437e-03f, 7.43917823e-02f, 3.54583740e-01f,
  -6.55151010e-02f, 1.06443234e-01f, 2.28756368e-02f, 1.57108635e-01f, -5.64068615e-01f, 6.12802245e-02f, 5.98617941e-02f, 9.90857482e-02f, 1.45797119e-01f, -3.50666046e-02f,
  -1.89455137e-01f, 1.90886781e-02f, -4.58913669e-02f, 1.54190719e-01f, 6.33458644e-02f, -5.54771051e-02f, -2.00167745e-01f, -6.96191043e-02f, -2.19565462e-02f, -6.31472841e-02f,
  -6.10180013e-02f, -6.11188076e-02f, 1.15132593e-01f, 7.66944662e-02f, -1.88168809e-02f, 5.32538630e-02f, -3.62078622e-02f, -7.65560269e-02f, -5.54923266e-02f, 4.46436219e-02f,
  8.26847702e-02f, -6.52550161e-02f, 6.79569021e-02f, -1.36800921e-02f, 9.67138633e-02f, 4.72898036e-02f, 9.26577523e-02f, 1.15169071e-01f, 4.15767245e-02f, -1.41979521e-02f,
  6.16405755e-02f, 4.56223451e-02f, 8.55720118e-02f, 5.18057272e-02f, -6.68775961e-02f, 9.91346762e-02f, 3.74880359e-02f, -3.48231532e-02f, -2.78374087e-02f, -4.60480154e-02f,
  1.08779475e-01f, -7.51721188e-02f, 1.46151902e-02f, 1.68914385e-02f, -4.98977825e-02f, -4.49458929e-03f, 7.34410509e-02f, -4.48425151e-02f, 4.67133969e-02f, -4.69222032e-02f,
  -7.12247491e-02f, 6.43565506e-02f, -6.42495509e-03f, -8.38628970e-03f, 4.59703291e-03f, 8.73363018e-02f, -2.04018448e-02f, 6.07100017e-02f, -1.79799479e-02f, -6.22824486e-03f,
  1.47641208e-02f, -8.20563138e-02f, -1.79092791e-02f, -4.03829031e-02f, 2.33168318e-03f, -4.64846492e-02f, -2.59790588e-02f, 4.36893739e-02f, 6.57994393e-03f, -1.73420459e-01f,
  -1.25005217e-02f, -2.66768098e-01f, 3.67353372e-02f, 6.71886234e-03f, 1.13472916e-01f, 7.00056553e-03f, -4.78272885e-03f, 1.22322924e-02f, -2.79555321e-02f, -1.45239048e-02f,
  3.46170142e-02f, 3.62256095e-02f, -5.52907735e-02f, 5.83464920e-04f, 3.18691209e-02f, -1.03578120e-01f, -1.00769892e-01f, -8.98089539e-03f, -5.78301176e-02f, 5.34482626e-03f,
  -2.71931961e-02f, -5.29114380e-02f, -4.65642102e-02f, -1.44795002e-02f, 2.81499177e-02f, -9.30616930e-02f, -8.76435488e-02f, 9.06747859e-03f, -5.91740534e-02f, 7.14521408e-02f,
  4.55820858e-01f, -3.75344813e-01f, 3.22493911e-01f, 4.63401794e-01f, -1.28377691e-01f, -5.02089024e-01f, -1.30685151e-01f, -2.78859019e-01f, -7.75009219e-04f, -4.32955325e-01f,
  -1.96093991e-01f, 2.08173096e-01f, -2.44352728e-01f, -2.49512479e-01f, 9.78869572e-02f, -6.62072077e-02f, -2.19314113e-01f, -8.78167972e-02f, -5.67446798e-02f, -1.74685568e-01f,
  9.09552723e-02f, -2.15987042e-01f, 1.01616062e-01f, -4.02863204e-01f, -5.02121039e-02f, 8.25496987e-02f, 6.73853755e-02f, 4.71595563e-02f, -1.32530779e-01f, -1.04497299e-02f,
  -3.86193953e-03f, 8.18445385e-02f, -1.29713621e-02f, 3.81260440e-02f, -2.68184952e-02f, -9.63640399e-03f, 1.27962315e-02f, 1.16809420e-01f, 1.19147636e-01f, -1.50515535e-03f,
  6.17185645e-02f, 5.29023558e-02f, -8.07663426e-02f, -1.64885249e-03f, 2.27175001e-02f, 8.73303413e-02f, 3.21071781e-02f, -1.90095585e-02f, -8.70890841e-02f, 8.23054090e-02f,
  6.64057909e-03f, -3.23221944e-02f, 1.74950417e-02f, -6.48536608e-02f, 3.92674245e-02f, 7.54658133e-02f, 3.15734670e-02f, -8.33322294e-03f, -7.36081377e-02f, -1.17674200e-02f,
  6.64540380e-02f, -5.63989878e-02f, 4.76657366e-03f, 1.09424721e-02f, 3.79615277e-02f, -9.61311813e-03f, 1.08250906e-03f, -4.04424705e-02f, 8.34753215e-02f, -2.84294747e-02f,
  -1.35041610e-03f, 6.33700192e-02f, -4.43715155e-02f, 6.18623383e-02f, 8.52025056e-04f, 2.93773320e-02f, 9.47651044e-02f, -5.08094057e-02f, 5.50280965e-04f, 7.91352591e-04f,
  3.90905961e-02f, -1.54843004e-02f, -1.86617114e-02f, -3.20694521e-02f, -4.20826226e-02f, 7.68470019e-02f, -6.97053075e-02f, 3.39056402e-02f, -4.15298827e-02f, 4.78062779e-02f,
  -2.01102644e-01f, -2.90195912e-01f, -6.88312650e-02f, -2.99923792e-02f, -2.06884928e-03f, 7.68791477e-04f, 4.80736420e-02f, -2.77871471e-02f, -9.45510436e-03f, -8.14463720e-02f,
  1.59926601e-02f, 7.83732440e-03f, -1.27533777e-02f, 2.80809402e-02f, 1.64643321e-02f, -1.07535228e-01f, -2.77531869e-03f, 1.61688942e-02f, -5.95207233e-03f, -1.01304621e-01f,
  5.44926114e-02f, 2.12988490e-03f, 3.28346454e-02f, -1.12128705e-01f, -2.81092152e-02f, 3.73568060e-03f, -5.23403324e-02f, 8.82694423e-02f, 6.08312003e-02f, -2.42182557e-02f
};

// L0_fan_Wp_bar (Shape: 40 x 120)
const int L0_fan_Wp_bar_rows = 40;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -2.98292249e-01f, 4.70082015e-02f, -2.33451158e-01f, -4.77828026e-01f, 2.57886976e-01f, 1.60651542e-02f, -7.78926834e-02f, 1.73627689e-01f, -2.16205657e-01f, 4.54630762e-01f,
  2.01518321e-03f, -3.37032348e-01f, -7.04021826e-02f, -4.87243742e-01f, -4.74266797e-01f, -3.60571384e-01f, -3.61082643e-01f, -3.18615288e-01f, -3.06518048e-01f, -7.12707266e-02f,
  -2.12709799e-01f, -2.38447472e-01f, -4.09344107e-01f, 2.64123470e-01f, 1.09099373e-01f, 2.89756328e-01f, 3.00499767e-01f, 2.08296016e-01f, -2.67370744e-03f, -8.34609419e-02f,
  -2.09058702e-01f, -1.72129795e-01f, 3.91604975e-02f, -1.12771586e-01f, 5.58594204e-02f, 2.80503958e-01f, 8.48853961e-02f, -1.15760952e-01f, -4.16216105e-02f, -5.84401144e-03f,
  9.17076319e-02f, 6.70980215e-02f, -1.17306069e-01f, -4.14899178e-03f, 1.80927753e-01f, 1.45469429e-02f, -1.83158144e-01f, 1.81112915e-01f, 9.41980910e-03f, -1.69954628e-01f,
  -8.29572603e-02f, -5.78133808e-03f, 1.28365964e-01f, -1.09165549e-01f, -4.15777005e-02f, 1.20653026e-01f, 7.71204457e-02f, 4.61664088e-02f, 4.45932709e-02f, 3.61408293e-02f,
  1.87306982e-02f, 1.38510600e-01f, -1.45600960e-01f, -1.25451386e-01f, -2.11243406e-02f, 5.97530901e-02f, 9.77477059e-03f, -2.29146648e-02f, -1.54038221e-02f, 3.06119919e-02f,
  1.01373069e-01f, 2.97479685e-02f, -6.21467493e-02f, -2.97259912e-02f, -2.82435417e-02f, -6.60540164e-02f, -1.92601476e-02f, -6.90672025e-02f, -8.43971968e-02f, 1.31698437e-02f,
  8.79909843e-02f, -1.16629779e-01f, -7.75205716e-02f, 4.39287908e-02f, 4.06567492e-02f, -3.12229060e-02f, 8.22516605e-02f, -9.29748341e-02f, 2.32607871e-02f, 5.85058704e-02f,
  8.48796144e-02f, 1.24275923e-01f, 5.78325093e-02f, -1.76079825e-01f, -6.86608851e-02f, 1.60545081e-01f, -7.38193095e-02f, -4.37874869e-02f, -2.23548617e-02f, -1.95692815e-02f,
  1.50336489e-01f, 1.68794557e-01f, 1.82481289e-01f, -6.52889535e-02f, 9.84829292e-02f, 2.02526256e-01f, 6.15602173e-03f, 1.00197233e-01f, 1.27115071e-01f, 3.62775028e-02f,
  1.71231806e-01f, -1.38253821e-02f, 1.52460411e-02f, -3.81000154e-02f, 2.47491300e-02f, 1.66835591e-01f, 1.06840134e-01f, 6.87587261e-02f, 7.34594464e-03f, -3.45735848e-02f,
  2.22790658e-01f, 8.25928375e-02f, 8.17977861e-02f, 4.22377199e-01f, 1.62616909e-01f, -8.79282132e-03f, 4.84371215e-01f, 2.09720448e-01f, 5.56363702e-01f, -7.98673108e-02f,
  -1.61377266e-01f, 1.12968832e-02f, 2.78105494e-02f, -3.04813497e-02f, -4.22352850e-01f, -1.04305118e-01f, -1.42115116e-01f, 2.11377367e-01f, 3.45097661e-01f, 3.65103148e-02f,
  -9.99579728e-02f, -2.61938155e-01f, -3.68555069e-01f, -2.23238617e-01f, -6.23860843e-02f, 1.65409282e-01f, -3.80389154e-01f, 3.25383365e-01f, -2.83413500e-01f, 8.41688439e-02f,
  1.71082988e-01f, 4.24824089e-01f, -9.36293378e-02f, 1.39510995e-02f, -3.34511511e-02f, -9.70013812e-02f, -2.53133429e-03f, 1.28475696e-01f, 2.00777069e-01f, 5.50897606e-02f,
  -1.66413188e-01f, -7.39530027e-02f, -7.07452558e-03f, 6.91718096e-03f, 3.90021764e-02f, -1.09028369e-01f, 4.75688092e-02f, -6.83085695e-02f, 5.31230792e-02f, -3.41068953e-02f,
  -1.09232485e-01f, 1.67831853e-02f, -1.23538524e-01f, 4.17716391e-02f, -1.44095346e-01f, 1.72212631e-01f, 6.35273010e-02f, -1.61427274e-01f, -5.67374006e-02f, 2.61455029e-02f,
  -1.22420870e-01f, 1.16867505e-01f, 4.58388552e-02f, 6.30741715e-02f, 4.34577353e-02f, -2.67215855e-02f, 7.16586187e-02f, 6.36695996e-02f, 8.99235979e-02f, -9.48520899e-02f,
  -1.16807921e-02f, 1.28863588e-01f, 1.36578903e-01f, -8.88994779e-04f, 5.59059791e-02f, 6.94216937e-02f, -1.72581285e-01f, 4.73369919e-02f, -4.15012799e-02f, -3.80753092e-02f,
  1.92880165e-02f, 1.16448864e-01f, 4.80768047e-02f, -1.86349899e-02f, 2.09906399e-02f, 1.30787743e-02f, -1.02237284e-01f, -9.85695980e-03f, 1.02565110e-01f, -1.39377624e-01f,
  1.12143934e-01f, 1.47994488e-01f, 1.19531885e-01f, 1.25999168e-01f, 5.88982552e-02f, -2.13189647e-01f, 7.48158917e-02f, -3.76768038e-02f, 2.82648429e-02f, -4.12997045e-02f,
  -1.56864360e-01f, 9.56528783e-02f, -6.14659153e-02f, 3.98119725e-03f, -1.88161120e-01f, -1.52382985e-01f, -3.30347158e-02f, 2.26729196e-02f, -6.39749765e-02f, -1.68596417e-01f,
  -1.75345719e-01f, 6.53326139e-02f, -6.32432327e-02f, -7.21628265e-03f, -1.05581850e-01f, -9.24788564e-02f, -6.21864281e-04f, 3.82841192e-02f, -1.49343908e-01f, -8.22531581e-02f,
  -1.36701092e-01f, 3.52809690e-02f, 5.15256584e-01f, -4.01183255e-02f, 3.33122164e-01f, 4.94434327e-01f, 1.20567448e-01f, 2.84355164e-01f, 3.60517979e-01f, -5.51323891e-01f,
  -2.47826055e-01f, -3.16068828e-01f, 1.95286840e-01f, -2.09551409e-01f, 3.63584518e-01f, 4.27865446e-01f, 9.95990261e-02f, -1.16547257e-01f, 2.96456605e-01f, -7.05617368e-02f,
  8.18063021e-02f, -4.02713448e-01f, 3.19668829e-01f, -1.78849384e-01f, -4.19938788e-02f, 3.91241349e-02f, -4.82048422e-01f, 1.68401077e-01f, -4.06603694e-01f, -4.48509194e-02f,
  8.93434063e-02f, 3.79080847e-02f, 1.95165500e-01f, 1.81056529e-01f, 1.92864135e-01f, -8.24199915e-02f, 5.49383573e-02f, 7.86164775e-02f, 1.56122044e-01f, -3.25606354e-02f,
  -8.23273137e-02f, -5.02000144e-03f, -1.52568042e-01f, -5.58415279e-02f, 1.89527705e-01f, 6.63948886e-04f, 2.14169472e-01f, 2.60599017e-01f, 6.44296855e-02f, 2.47449517e-01f,
  2.49665514e-01f, 2.28504255e-01f, 1.35131538e-01f, -1.00690305e-01f, 9.78891551e-02f, -6.88947458e-03f, 2.90739629e-02f, 2.08989973e-03f, -9.42156464e-03f, -6.69633523e-02f,
  2.03942023e-02f, 1.25378355e-01f, 1.92250498e-02f, -1.28089581e-02f, -3.44295166e-02f, -4.91345041e-02f, -1.04076583e-02f, -1.57574058e-01f, 6.64271007e-04f, 5.16193174e-02f,
  -9.35240313e-02f, 3.43407206e-02f, 1.47926539e-01f, 5.30168116e-02f, -1.12758584e-01f, -8.42624232e-02f, -3.55729349e-02f, 3.43060051e-03f, -5.19105867e-02f, -2.99492031e-02f,
  -7.59666264e-02f, 3.46540124e-03f, -9.63088050e-02f, -1.28085494e-01f, -5.84625974e-02f, 1.76309809e-01f, -1.13624312e-01f, 8.17626789e-02f, 9.58693773e-02f, 3.97268832e-02f,
  -8.94530043e-02f, -3.12954068e-01f, 1.00782879e-01f, -1.91124883e-02f, 7.21227601e-02f, -9.93063152e-02f, 2.73851920e-02f, -4.86133173e-02f, 1.34294061e-02f, -5.57326935e-02f,
  -1.03378862e-01f, -1.10598497e-01f, -2.59778220e-02f, 3.50702740e-02f, -7.05205929e-03f, -6.39460459e-02f, -1.18013300e-01f, -1.68376297e-01f, -1.14949904e-01f, -1.27289161e-01f,
  -5.06260544e-02f, -4.05106544e-02f, -1.27177522e-01f, -5.83991706e-02f, -8.04102793e-02f, -6.53519705e-02f, -1.29341155e-01f, 5.96640594e-02f, 8.42531025e-02f, 2.59579476e-02f,
  -2.04472661e-01f, 6.18663430e-01f, 6.49776995e-01f, 6.72321618e-01f, -5.66399693e-01f, -3.95439893e-01f, -3.01366985e-01f, -1.78222820e-01f, 1.55433387e-01f, -2.99859152e-04f,
  -2.00257942e-01f, 5.09009600e-01f, -2.72899300e-01f, 2.95976609e-01f, -3.95296402e-02f, -6.21346235e-02f, 3.04168731e-01f, 6.27012253e-02f, 9.81667265e-02f, 2.59206831e-01f,
  2.26683170e-01f, -2.40347505e-01f, 2.51135886e-01f, 8.42902660e-02f, 2.85629779e-01f, 4.86747056e-01f, 3.29092175e-01f, 2.14769050e-01f, 4.96599972e-01f, -1.81715026e-01f,
  -1.78503484e-01f, -5.13215596e-03f, 3.28963622e-02f, 1.41916439e-01f, -8.62304680e-03f, -6.40688166e-02f, 5.09878621e-02f, -1.27083927e-01f, -5.05923890e-02f, 1.31120622e-01f,
  -1.63893178e-02f, 1.33874947e-02f, 1.71439797e-01f, 8.42553389e-04f, -1.54705033e-01f, 1.10711545e-01f, 7.41880834e-02f, 4.63642478e-02f, 1.80649593e-01f, -8.10028240e-03f,
  1.17361829e-01f, 5.40143438e-02f, 3.07747051e-02f, 1.07893154e-01f, 1.68223217e-01f, -2.04585884e-02f, 1.45772815e-01f, 1.58469468e-01f, 2.30271339e-01f, 1.53701633e-01f,
  -2.12356657e-01f, 7.35463575e-02f, 1.60301790e-01f, 1.96991507e-02f, 1.08299600e-02f, -7.20784590e-02f, -2.18014116e-03f, -1.22085132e-01f, -4.81178723e-02f, 1.29989564e-01f,
  5.38623631e-02f, -1.69784622e-03f, -2.28286590e-02f, 4.82770614e-02f, -4.12844121e-02f, -6.07986562e-02f, -1.36230484e-01f, 2.35613622e-02f, 9.68657210e-02f, 5.85084185e-02f,
  -4.85943034e-02f, -4.01941948e-02f, 1.73304334e-01f, -2.09565796e-02f, -6.67606443e-02f, -2.51003448e-02f, 1.54248029e-01f, 1.80071834e-02f, -1.54513270e-02f, 3.85540095e-03f,
  1.19973101e-01f, 4.02089417e-01f, 1.06219672e-01f, -1.55644581e-01f, 3.37761305e-02f, 1.24357268e-02f, -3.45390029e-02f, 7.97342360e-02f, 2.47795030e-01f, -2.12632325e-02f,
  -1.81741521e-01f, 3.53519358e-02f, -7.93204270e-03f, -1.88380301e-01f, -6.41222149e-02f, 8.89104828e-02f, 2.93218094e-04f, 1.99968219e-01f, 3.29145752e-02f, 1.28757283e-01f,
  4.23791073e-02f, -2.00379804e-01f, 1.26175331e-02f, -2.42753346e-02f, -1.62779570e-01f, -2.44772527e-02f, -2.05840245e-02f, -1.91504955e-02f, 2.49949712e-02f, 1.64854467e-01f,
  4.23192829e-01f, -1.18911892e-01f, -3.11402738e-01f, -5.05080968e-02f, 1.27775908e-01f, -1.59046158e-01f, -5.97864330e-01f, 5.25245629e-02f, -5.40045738e-01f, -3.55571389e-01f,
  5.42920865e-02f, 1.55181345e-02f, -4.15713847e-01f, 4.51173484e-01f, 6.21253073e-01f, -6.00743406e-02f, 5.29686213e-01f, 2.56010354e-01f, 2.04615980e-01f, 1.65688455e-01f,
  3.64272326e-01f, 5.84353864e-01f, 3.05340618e-01f, 5.09635389e-01f, 2.88686663e-01f, 1.98124364e-01f, 3.45629573e-01f, -2.62248097e-03f, 2.63919145e-01f, 2.65362442e-01f,
  3.45103852e-02f, 3.41258384e-02f, 2.77489666e-02f, -5.90017177e-02f, 8.16321000e-02f, -1.52329234e-02f, 1.67058855e-02f, 8.04934278e-02f, -8.62711817e-02f, -6.24833368e-02f,
  -6.80788606e-03f, 2.24470288e-01f, 1.16434813e-01f, 7.85622373e-02f, -8.49613622e-02f, -1.16543146e-02f, -8.64361227e-03f, -7.34178200e-02f, -2.04916567e-01f, 6.99647516e-02f,
  -2.07011819e-01f, -6.11687377e-02f, -1.10238735e-02f, 2.39562448e-02f, -1.49875119e-01f, -1.02220319e-01f, -9.55736637e-02f, -1.10828027e-01f, -8.05923622e-03f, 1.70266684e-02f,
  1.06431700e-01f, -1.63003001e-02f, -9.24358610e-05f, 4.76448005e-03f, 4.24964838e-02f, -7.30336308e-02f, 3.77621129e-02f, 5.92579693e-02f, -5.44513483e-03f, -2.44830772e-02f,
  -2.08722040e-01f, 8.17622095e-02f, -7.36316144e-02f, -1.27168685e-01f, 1.64195284e-01f, 7.16907009e-02f, -1.61218885e-02f, 9.95431915e-02f, -2.00635478e-01f, 1.17650125e-02f,
  -1.06014356e-01f, -1.08707901e-02f, -1.23953126e-01f, 3.73806059e-02f, 2.99607981e-02f, -1.00883059e-01f, -8.16168264e-02f, 2.92388126e-02f, -8.61131474e-02f, 3.67065147e-02f,
  7.10484385e-03f, 2.50307173e-01f, -6.51213676e-02f, 4.20542508e-02f, 5.06420061e-02f, 8.96219090e-02f, 1.24072395e-01f, 5.37569188e-02f, 5.85791096e-02f, 1.14981137e-01f,
  6.55958578e-02f, 1.76773593e-03f, -1.60335586e-03f, -2.22037267e-02f, 7.79700726e-02f, -9.08788573e-03f, 1.37311723e-02f, -2.65268255e-02f, -4.28834297e-02f, 1.44202545e-01f,
  5.57141826e-02f, 2.51747798e-02f, 8.62035006e-02f, -1.90136433e-01f, -1.96095500e-02f, -8.75863805e-02f, 1.22661479e-01f, -9.29615051e-02f, 1.26988471e-01f, 9.27868299e-03f,
  6.64386094e-01f, -4.70255882e-01f, -1.63962647e-01f, 4.32285070e-01f, 3.97122234e-01f, -3.34490165e-02f, -3.26203704e-01f, 3.56572747e-01f, 1.14110783e-01f, -2.99475729e-01f,
  4.35118973e-01f, -3.36987883e-01f, -3.76534015e-01f, 5.67679524e-01f, 4.55080301e-01f, -2.44431853e-01f, 4.57036912e-01f, 8.95695612e-02f, 6.31777197e-02f, 3.66337955e-01f,
  3.68805468e-01f, 5.40571809e-01f, 9.09849554e-02f, 2.71059722e-01f, 3.73049051e-01f, 1.06877193e-01f, 5.25849424e-02f, -2.84672886e-01f, 2.80495971e-01f, -1.95665397e-02f,
  3.07564071e-04f, 1.07812643e-01f, 1.66710820e-02f, -1.44822866e-01f, 4.93605770e-02f, -4.96128295e-03f, -1.47545949e-01f, -1.74087942e-01f, 3.90908979e-02f, -9.71870869e-02f,
  -1.64098740e-01f, 7.35717686e-03f, 8.90098810e-02f, -9.93372574e-02f, 2.00808853e-01f, 3.75908501e-02f, 7.88997859e-02f, 2.25687325e-02f, -6.23408295e-02f, -6.28289208e-02f,
  3.27095874e-02f, 2.60294527e-02f, 1.65809616e-01f, -1.14262581e-01f, 7.11833760e-02f, 6.58127442e-02f, -1.04627617e-01f, -1.62878215e-01f, -6.46566153e-02f, -2.68709697e-02f,
  -1.97542794e-02f, -1.09827340e-01f, -1.00851757e-02f, 3.87504213e-02f, -6.55986443e-02f, 5.15232943e-02f, 8.88923109e-02f, 1.56882312e-02f, -4.09715846e-02f, -2.11832765e-02f,
  1.75201192e-01f, 7.28873312e-02f, 6.06753379e-02f, 3.26328166e-02f, 2.63409670e-02f, -2.77118571e-03f, -7.03012347e-02f, 4.99862656e-02f, 1.25772983e-01f, 8.03532917e-03f,
  -2.96985041e-02f, 4.44292203e-02f, -1.68362558e-02f, -5.56634106e-02f, -4.02732193e-02f, 1.68731399e-02f, 8.24785233e-02f, 7.96442330e-02f, -7.30096549e-02f, 2.45657433e-02f,
  2.68544294e-02f, -1.99794471e-02f, -9.14924443e-02f, 2.42265165e-02f, -1.25757650e-01f, 1.49488464e-01f, -5.42108230e-02f, 1.28817409e-01f, -4.68344092e-02f, 7.69708306e-02f,
  6.79952651e-02f, -1.74432453e-02f, -7.59898499e-02f, 1.01557620e-01f, -5.87519631e-03f, 1.13898404e-01f, -1.52633354e-01f, -1.04996324e-01f, 1.01266084e-02f, 5.92613034e-02f,
  -8.90710671e-03f, -2.89008152e-02f, -6.21048659e-02f, 2.63483431e-02f, 2.39207838e-02f, -3.46294791e-02f, 8.15675221e-03f, 2.91421078e-02f, 9.59402472e-02f, -1.32005773e-02f,
  -2.79446483e-01f, 5.69647193e-01f, 4.28868651e-01f, -3.15456212e-01f, 1.69946253e-02f, -1.18974678e-01f, -2.71426439e-01f, 3.18686187e-01f, 4.28274646e-02f, 3.60993207e-01f,
  -5.63561730e-02f, 4.06491727e-01f, -8.86749327e-02f, 9.20537785e-02f, -6.44596457e-01f, -3.52157414e-01f, -3.40049922e-01f, -1.52905926e-01f, -2.19287843e-01f, -6.99657202e-02f,
  -3.60806525e-01f, -3.68192047e-01f, -1.86275706e-01f, 8.61783475e-02f, 3.80423903e-01f, 2.67743886e-01f, -3.47426087e-01f, 1.94397956e-01f, 1.69584066e-01f, 8.12805141e-04f,
  3.19914334e-02f, 5.32133542e-02f, 1.72075361e-01f, 1.77188128e-01f, -7.77342767e-02f, 1.30224869e-01f, 1.76405147e-01f, -1.83992204e-03f, -1.12786457e-01f, 6.43593818e-02f,
  6.75541684e-02f, 1.71837267e-02f, 7.53751025e-02f, -8.93960893e-02f, 2.15823293e-01f, 1.37265980e-01f, 5.81587590e-02f, 1.37797311e-01f, 1.76952913e-01f, 6.49822056e-02f,
  1.12794034e-01f, 2.35414594e-01f, 2.55914149e-03f, -4.96724695e-02f, -7.62497857e-02f, 2.95901485e-02f, -1.06132217e-01f, 2.21109495e-01f, 3.97561789e-02f, 1.57777574e-02f,
  5.59790386e-03f, -1.65070787e-01f, 2.46143471e-02f, 7.98909068e-02f, -2.28073150e-02f, 2.19092015e-02f, -6.41223341e-02f, 1.73740815e-02f, -6.08606497e-03f, 9.30986255e-02f,
  -1.38637424e-01f, 1.17372833e-01f, -7.60808513e-02f, -4.46157902e-02f, -9.25013348e-02f, -7.85175115e-02f, 9.81213804e-03f, 2.57603060e-02f, -1.03245601e-01f, -4.87860218e-02f,
  -4.87588644e-02f, -1.13406517e-01f, 3.45820226e-02f, 2.72281077e-02f, -3.26989824e-03f, 7.10880831e-02f, 8.89587589e-03f, 1.99612096e-01f, 3.79541144e-02f, -5.50137796e-02f,
  -1.15830250e-01f, -3.03531170e-01f, -3.00132204e-02f, 3.72626521e-02f, -3.23579311e-02f, 4.54781577e-02f, -2.65363622e-02f, 1.52542070e-01f, -5.17933518e-02f, -8.61552209e-02f,
  7.54563883e-02f, -3.28254364e-02f, 5.33364713e-02f, 3.32332216e-02f, -1.52981058e-01f, -7.44764730e-02f, -1.07691854e-01f, -6.90378025e-02f, -4.03534286e-02f, 2.22605690e-02f,
  1.44492388e-01f, -2.34942194e-02f, -1.29298558e-02f, -1.03000447e-01f, 3.27824429e-02f, 3.72867957e-02f, -5.23546636e-02f, 5.36947735e-02f, -5.33107370e-02f, 3.90973203e-02f,
  -1.62870690e-01f, 3.28941464e-01f, -4.78336066e-01f, 2.01227769e-01f, -4.06767219e-01f, 6.13578975e-01f, 7.19223976e-01f, -8.13806504e-02f, 3.31187844e-02f, 5.30581653e-01f,
  1.71742156e-01f, 2.14590575e-03f, 2.05821469e-01f, 7.36824453e-01f, 1.12081796e-01f, 4.10677046e-01f, 4.85592455e-01f, 5.17992973e-01f, -7.50055015e-02f, 1.02559946e-01f,
  -1.10773243e-01f, 5.55272162e-01f, -1.67134106e-01f, -8.18480924e-02f, -1.86030194e-01f, -3.69892061e-01f, -2.91967690e-01f, -4.39267993e-01f, 1.13099210e-01f, 3.70232910e-02f,
  1.77764922e-01f, -4.18417901e-02f, -7.58496001e-02f, 8.53278190e-02f, 6.70415684e-05f, 6.33976236e-02f, 2.55385246e-02f, -1.04691692e-01f, -1.21732205e-01f, -4.35421690e-02f,
  2.35237498e-02f, -2.43479218e-02f, 1.26680180e-01f, -9.41839889e-02f, -4.82383138e-03f, -2.87357401e-02f, -4.62133028e-02f, -1.28851235e-02f, 1.05150066e-01f, -3.26919854e-02f,
  -8.30069631e-02f, 9.72635970e-02f, -5.82748763e-02f, 1.99434623e-01f, -1.69894099e-01f, 1.93275046e-02f, 2.69598395e-01f, -8.63497928e-02f, 6.57056049e-02f, 6.68381155e-02f,
  -5.66744469e-02f, 1.32171765e-01f, 1.39906406e-02f, -3.92319933e-02f, -2.33336017e-02f, 2.91133067e-03f, 2.14742813e-02f, -1.55973500e-02f, -9.22397003e-02f, 1.50995970e-01f,
  -9.91012752e-02f, -6.04386325e-04f, -1.20733064e-02f, 1.29006669e-01f, 1.04729228e-01f, 1.19586186e-02f, -9.56981033e-02f, -6.01725504e-02f, -6.75052070e-05f, -8.21634680e-02f,
  2.78447047e-02f, 1.55093685e-01f, -2.79534161e-02f, -9.63104423e-03f, 1.18620344e-01f, -2.17276067e-01f, 5.35524748e-02f, -2.62435023e-02f, -7.25689903e-02f, -8.34225863e-02f,
  1.43173382e-01f, 1.08085789e-01f, 8.76877829e-02f, 2.85900719e-02f, -3.81847695e-02f, -1.76015291e-02f, 3.64839919e-02f, -7.33244792e-02f, -2.13696379e-02f, -8.16288218e-03f,
  -7.55260438e-02f, 4.67297109e-03f, 5.98775893e-02f, -1.97360670e-04f, 6.02931902e-02f, 3.08175515e-02f, 2.25549817e-01f, 1.32009629e-02f, 1.10639788e-01f, -4.28830720e-02f,
  -1.60901099e-02f, -6.04455778e-03f, -7.60432035e-02f, 3.88208777e-02f, 1.19438507e-01f, 5.57068400e-02f, 7.95548186e-02f, -9.15139318e-02f, -5.52264322e-03f, 1.04801483e-01f,
  6.67474866e-01f, 2.96732754e-01f, 3.04741472e-01f, 6.06888175e-01f, 1.25285253e-01f, -4.96190816e-01f, 9.58326533e-02f, 2.44031236e-01f, 4.19108152e-01f, -1.84646443e-01f,
  -1.72079474e-01f, 2.89959162e-01f, -2.61672080e-01f, 2.48982772e-01f, -4.41549212e-01f, -4.59362715e-01f, 5.76260313e-02f, -5.22775613e-02f, 1.28696963e-01f, 1.37471184e-01f,
  2.82879680e-01f, -3.54967803e-01f, 1.72711521e-01f, -2.42510870e-01f, 3.69126350e-01f, 3.28059882e-01f, -1.75303146e-01f, -1.13902330e-01f, 1.46347424e-02f, -2.02615172e-01f,
  7.29729384e-02f, 4.24532175e-01f, 2.69752085e-01f, -1.17710359e-01f, 2.21948512e-02f, -1.80694424e-02f, 6.05341494e-02f, -1.76488996e-01f, 2.57982723e-02f, -9.59042646e-03f,
  2.92445067e-02f, -2.82794740e-02f, -5.04288562e-02f, -2.24834666e-01f, 2.06708759e-01f, 1.84585735e-01f, 1.18670508e-01f, 1.04019269e-01f, 2.42501915e-01f, 1.74357936e-01f,
  2.32409135e-01f, 1.16551772e-01f, 7.93327466e-02f, -2.40775615e-01f, 6.69657886e-02f, 9.64624956e-02f, -1.02883108e-01f, 3.40962484e-02f, -4.48262040e-03f, 7.24058002e-02f,
  -2.14244463e-02f, 2.26971749e-02f, 3.18767019e-02f, 3.25247757e-02f, -7.97992051e-02f, 1.46624789e-01f, -1.05972618e-01f, -1.02935188e-01f, 1.43756056e-02f, -7.12834969e-02f,
  -3.81554739e-04f, 1.57178551e-01f, 1.94887631e-02f, -1.14425244e-02f, 3.58252712e-02f, 1.58469468e-01f, -1.47347972e-01f, -1.99958131e-01f, 4.16311510e-02f, 3.78892981e-02f,
  8.79908539e-03f, -4.67978641e-02f, -2.31127758e-02f, 5.93582392e-02f, -6.69152811e-02f, -2.87633631e-02f, 1.32703990e-01f, 1.38480276e-01f, 1.21657670e-01f, -1.10136539e-01f,
  -4.13413972e-01f, -4.64420438e-01f, 1.02851111e-02f, -8.67125764e-02f, -5.19578941e-02f, -1.69587601e-02f, -9.14008007e-04f, -2.08731042e-03f, -2.40347143e-02f, -1.08952157e-01f,
  2.90825181e-02f, 8.64399597e-02f, -1.99814230e-01f, -5.70545755e-02f, -1.01057343e-01f, -8.61134902e-02f, -4.48981896e-02f, -1.09125264e-01f, -7.77019262e-02f, -1.12019785e-01f,
  -2.78089456e-02f, -1.21118702e-01f, 4.16200496e-02f, 1.44287556e-01f, 3.02179120e-02f, 7.22558238e-04f, -7.50842243e-02f, 8.40012543e-03f, -1.88180253e-01f, -8.41721520e-02f,
  -4.13536966e-01f, -4.38010097e-01f, 3.68175328e-01f, -4.21844333e-01f, 2.20385894e-01f, 3.49194735e-01f, 2.60514408e-01f, -1.65797323e-01f, -3.89694661e-01f, -2.90494591e-01f,
  8.32840651e-02f, -1.20616376e-01f, 2.89329201e-01f, -3.97770554e-01f, 3.53243113e-01f, -2.00473785e-01f, -3.91750634e-01f, -8.47327188e-02f, -1.42304953e-02f, 1.25418171e-01f,
  1.14761088e-02f, -2.62026429e-01f, 2.13784635e-01f, -1.85026273e-01f, -6.60226420e-02f, -7.82262236e-02f, 1.57149091e-01f, 4.50336397e-01f, -2.41639137e-01f, 2.97449697e-02f,
  -1.21872135e-01f, -2.40420029e-01f, -2.99380925e-02f, 1.58666559e-02f, 1.76707447e-01f, 1.34911597e-01f, 1.71917364e-01f, 1.80724114e-01f, 6.10193126e-02f, 2.20335973e-03f,
  5.97313885e-03f, 9.00908560e-02f, -2.87521005e-01f, 6.92487359e-02f, -6.70112446e-02f, -7.60532171e-02f, 1.07765302e-01f, -4.14600112e-02f, -6.03429042e-02f, 1.53931975e-01f,
  1.96959823e-01f, -7.46882260e-02f, -4.04367149e-02f, -8.41169506e-02f, 9.31058452e-02f, -7.53264204e-02f, -3.35451402e-02f, 1.18042871e-01f, -1.10349618e-01f, -1.22863524e-01f,
  4.89233322e-02f, -4.53200303e-02f, -2.30786391e-02f, -1.25833735e-01f, -8.32899436e-02f, -6.12289980e-02f, -3.30070034e-02f, -3.23672369e-02f, 3.77170257e-02f, 4.08974513e-02f,
  5.21923229e-02f, -5.59007227e-02f, -3.52601195e-03f, 8.78720805e-02f, -8.51848572e-02f, -1.68387964e-01f, 1.19042985e-01f, -5.00434153e-02f, 3.84547785e-02f, 6.43450068e-03f,
  -2.82696113e-02f, -2.04970855e-02f, 2.06246153e-01f, -2.77829953e-02f, -8.26999694e-02f, 1.00518137e-01f, 6.03688434e-02f, -4.04515443e-03f, 4.66579571e-02f, 1.62688628e-01f,
  1.12944329e-02f, -2.69205868e-01f, -8.54654461e-02f, -6.82213083e-02f, -2.50784997e-02f, 5.29101752e-02f, -8.68203938e-02f, -1.24153778e-01f, 9.84202605e-03f, 6.86021289e-03f,
  9.83927548e-02f, 1.12491496e-01f, -1.55829281e-01f, -1.89304575e-02f, 7.38046467e-02f, 6.84633553e-02f, -6.22595958e-02f, -4.83784266e-02f, -9.20403153e-02f, -3.22340056e-02f,
  -7.78907090e-02f, 8.92641023e-02f, 7.80444369e-02f, -5.08377291e-02f, -6.94042221e-02f, 6.37713354e-03f, -8.36847052e-02f, 2.86541544e-02f, 6.40544668e-02f, 2.67788880e-02f,
  4.33734059e-01f, -2.22229227e-01f, 4.87733126e-01f, 1.04804203e-01f, 3.60494792e-01f, 3.19623142e-01f, 2.87185133e-01f, 1.81490034e-02f, -1.16629571e-01f, -3.21178377e-01f,
  -3.10740322e-02f, 1.20020255e-01f, 7.49465376e-02f, -8.90846997e-02f, 6.73753098e-02f, -2.23987937e-01f, -8.27466473e-02f, -2.60958225e-01f, -7.47667626e-02f, -7.03677163e-02f,
  -1.60281546e-02f, -3.92190725e-01f, 1.83339089e-01f, -4.56076801e-01f, 1.77239135e-01f, -1.51282400e-01f, -2.85168290e-01f, -8.99136141e-02f, -1.12914063e-01f, 9.16418880e-02f,
  9.35093462e-02f, -7.92121515e-02f, 8.79932493e-02f, 7.94082880e-02f, -3.48491371e-02f, -1.23508822e-03f, 1.74519774e-02f, -2.18034219e-02f, 5.01387492e-02f, 6.86181635e-02f,
  -8.61398578e-02f, 7.61586726e-02f, -5.19346558e-02f, 2.21222732e-02f, 2.06456222e-02f, 8.99920240e-02f, 2.45767847e-01f, 1.31193176e-01f, 4.35326397e-02f, 2.58110762e-01f,
  1.93153769e-01f, 1.30071968e-01f, 2.07745165e-01f, -2.76205000e-02f, 1.72683224e-01f, 1.39807805e-01f, 1.83924526e-01f, 3.10151391e-02f, 5.68402261e-02f, 1.17605060e-01f,
  -3.12119216e-01f, -2.18238011e-01f, 1.34364227e-02f, 1.84616297e-02f, 2.83359680e-02f, 1.50160626e-01f, -5.36034182e-02f, -6.28645718e-03f, 2.20317040e-02f, -2.94823237e-02f,
  3.47448848e-02f, 2.18062066e-02f, -1.14006214e-02f, -5.76083688e-03f, 3.58655304e-02f, 1.26816392e-01f, 1.07020147e-01f, 2.62371707e-03f, 2.42723688e-03f, 6.02771938e-02f,
  6.78652013e-03f, -1.00033889e-02f, -3.29701826e-02f, 3.81649211e-02f, -9.13684368e-02f, -2.62776352e-02f, 9.17324517e-03f, 7.08318278e-02f, -3.93123329e-02f, -3.64751928e-02f,
  -3.95319641e-01f, -6.03273094e-01f, -1.25616550e-01f, 5.41076027e-02f, -9.51878428e-02f, -4.43042330e-02f, -1.04493767e-01f, 7.77598768e-02f, -1.29656479e-01f, -1.28135145e-01f,
  2.93580089e-02f, -1.88817494e-02f, -1.38372570e-01f, 6.12833863e-03f, -1.61408395e-01f, 3.58969681e-02f, -1.57041445e-01f, -6.96111843e-02f, -2.12613363e-02f, -1.16024427e-01f,
  2.78892349e-02f, -8.10231045e-02f, 1.60763357e-02f, -1.13793172e-01f, -1.58304185e-01f, -1.26976311e-01f, -6.65002167e-02f, -3.46950255e-02f, -6.39642328e-02f, -7.31132478e-02f,
  -6.75271034e-01f, 7.17440397e-02f, -5.18353209e-02f, -3.55431676e-01f, -7.55892545e-02f, -2.84722626e-01f, -2.50824779e-01f, 3.09931546e-01f, -1.61864355e-01f, 4.13120329e-01f,
  2.65197515e-01f, -4.54603493e-01f, 4.67892140e-01f, -3.32172453e-01f, -3.94031525e-01f, -2.01052800e-02f, -3.12750041e-01f, -3.12008619e-01f, -1.82709277e-01f, 6.48224652e-02f,
  -1.86834186e-01f, -5.77739105e-02f, 5.87245263e-02f, 2.90418535e-01f, -2.56761968e-01f, 1.10045724e-01f, 4.74172652e-01f, 2.11018488e-01f, -7.98668265e-02f, -2.24731937e-01f,
  4.65700962e-02f, 1.48214400e-01f, 1.45891026e-01f, -1.56685729e-02f, 1.85543314e-01f, 3.13984416e-02f, -3.97389308e-02f, -6.87829629e-02f, -5.31653315e-02f, -2.46008001e-02f,
  -1.23559676e-01f, -1.94979366e-02f, -1.81733415e-01f, -7.79627115e-02f, -1.23809874e-01f, -2.80464776e-02f, 4.53193933e-02f, -5.78900129e-02f, -4.99142632e-02f, -2.23792121e-01f,
  -5.29126301e-02f, -1.38562731e-02f, -1.20796621e-01f, 9.27123949e-02f, -1.31483927e-01f, -3.64337526e-02f, -2.51553562e-02f, 2.00880375e-02f, -2.46686973e-02f, -6.60936609e-02f,
  -1.23521730e-01f, -4.66085076e-02f, 2.93948743e-02f, 1.02546766e-01f, -2.62781885e-02f, 7.05719963e-02f, 3.52947228e-02f, 3.54388542e-02f, -6.91219121e-02f, 4.27892059e-02f,
  -4.62492146e-02f, -8.66417885e-02f, -4.24744328e-03f, -1.09317586e-01f, -1.13124073e-01f, -2.16852620e-01f, -2.31791642e-02f, 1.04188494e-01f, -1.59601122e-01f, 5.95724210e-02f,
  1.53232574e-01f, -1.72751397e-01f, 4.93777245e-02f, 8.76140296e-02f, 7.97961801e-02f, 8.34655315e-02f, -5.95754869e-02f, -8.59313086e-02f, 1.65126532e-01f, 5.13667287e-03f,
  2.35914052e-01f, 3.43682468e-01f, 1.51911572e-01f, 4.14987933e-03f, 5.15704788e-02f, 3.81401703e-02f, -6.02140091e-03f, -1.52142584e-01f, 5.78978881e-02f, -4.27125730e-02f,
  -5.61043471e-02f, -8.63717031e-03f, 1.44183651e-01f, -6.08362965e-02f, 4.06888500e-02f, 6.97080642e-02f, 1.12798795e-01f, 6.86650574e-02f, 1.92579404e-01f, 5.41908443e-02f,
  2.01201946e-01f, 4.96093296e-02f, -1.48909306e-02f, 1.14590488e-02f, -8.41646641e-02f, 1.39040843e-01f, -1.14551008e-01f, 2.70049684e-02f, 6.13112673e-02f, 1.46303490e-01f,
  2.34847918e-01f, -4.05014902e-01f, -3.49408656e-01f, -3.65698397e-01f, 2.31973603e-01f, 6.25647306e-01f, 4.68678772e-01f, -3.19547147e-01f, -5.65156102e-01f, 1.54496789e-01f,
  3.78617704e-01f, 6.19406579e-03f, 1.51668251e-01f, -1.45653442e-01f, 2.68477589e-01f, -2.49697626e-01f, -3.76250409e-02f, 9.22309607e-02f, -3.37243915e-01f, 1.97477415e-01f,
  7.50549883e-02f, 2.01016709e-01f, -3.52031514e-02f, -1.31735187e-02f, 3.22742254e-01f, -2.43661329e-01f, 1.21515274e-01f, 1.80111721e-01f, 1.16495520e-01f, 2.86028773e-01f,
  2.79573854e-02f, -8.64344388e-02f, 1.25386490e-04f, -6.36806116e-02f, 1.58475295e-01f, 1.45728692e-01f, 1.34732381e-01f, 9.03664678e-02f, -8.87337774e-02f, 2.80719716e-02f,
  7.91744888e-02f, -1.04593866e-01f, -1.44016355e-01f, -3.39077152e-02f, -4.91597876e-02f, -1.62738904e-01f, -2.01241598e-01f, -7.00677857e-02f, -1.13927506e-01f, 1.16069213e-01f,
  -2.64266822e-02f, -4.36764546e-02f, -6.86761588e-02f, -2.05875009e-01f, -1.07051663e-01f, -2.09766105e-01f, 1.67646073e-02f, 2.69777268e-01f, -1.35437503e-01f, -3.81116346e-02f,
  1.34313896e-01f, 1.02568023e-01f, 8.99867937e-02f, -3.76471467e-02f, 1.39302939e-01f, -6.48842752e-02f, 2.11201332e-04f, 3.54089290e-02f, -8.16772785e-03f, 1.20603330e-01f,
  -8.15825537e-02f, -8.08124021e-02f, -9.48514268e-02f, 1.25789689e-02f, 1.52012959e-01f, 2.25096755e-02f, 1.12602867e-01f, 1.14931002e-01f, -5.22131249e-02f, -9.06060115e-02f,
  -6.38910681e-02f, 5.69597110e-02f, 1.76572710e-01f, -3.87163162e-02f, -2.08422765e-02f, 8.33608508e-02f, -5.03141172e-02f, 2.59938706e-02f, -1.35839283e-01f, 1.65626004e-01f,
  3.48743647e-02f, 8.07339419e-03f, -4.11811471e-02f, -9.09871757e-02f, 2.31259037e-02f, 2.01700181e-01f, -1.19720019e-01f, -1.44967884e-01f, 1.30501613e-02f, 2.62313262e-02f,
  6.94757923e-02f, -3.59311141e-02f, 5.02243564e-02f, 7.23507032e-02f, -1.39880538e-01f, 3.40990759e-02f, 1.50814891e-01f, 2.03993991e-02f, -4.73378673e-02f, 4.01524194e-02f,
  -1.40603155e-01f, -4.15646955e-02f, -1.10967889e-01f, -4.64461409e-02f, -1.05097391e-01f, 1.39328778e-01f, 9.92312580e-02f, -7.32527748e-02f, -1.15573920e-01f, -2.40912899e-01f,
  1.33402929e-01f, 5.72252870e-01f, 1.52018085e-01f, 2.08182946e-01f, -3.41851056e-01f, 1.08445082e-02f, 4.66633625e-02f, 1.53607398e-01f, 4.94840816e-02f, 8.15296173e-02f,
  -1.21087126e-01f, 3.35989565e-01f, -1.17884174e-01f, 3.11419338e-01f, 4.65718240e-01f, 2.45062515e-01f, 4.61736917e-01f, 7.43051320e-02f, 3.61099988e-02f, 3.63117099e-01f,
  1.05295099e-01f, 2.55411327e-01f, 6.91806227e-02f, 7.87564889e-02f, -2.32969169e-02f, -1.87632553e-02f, 5.11434581e-03f, -1.36270255e-01f, 7.56873563e-02f, -2.96600461e-02f,
  -4.83344719e-02f, 8.02044794e-02f, -1.25255277e-02f, -1.23733683e-02f, -5.55874361e-03f, -3.03024389e-02f, -3.46312821e-02f, 3.16906795e-02f, -6.33011982e-02f, -1.86589590e-04f,
  3.25190537e-02f, 6.22018278e-02f, 1.76337987e-01f, 5.37635498e-02f, 2.32555643e-02f, -3.12849656e-02f, 3.80360559e-02f, -8.28961283e-02f, 5.93734868e-02f, 3.64529677e-02f,
  5.91120720e-02f, -1.55664729e-02f, 3.69561315e-02f, 1.18901312e-01f, -7.71103567e-03f, 1.60410449e-01f, 1.51121929e-01f, 6.50096536e-02f, 1.52450681e-01f, 1.29895806e-01f,
  3.82231697e-02f, -3.29024456e-02f, -5.57456873e-02f, -1.20772988e-01f, 1.49905518e-01f, -1.34083286e-01f, -2.49613076e-02f, -6.14069924e-02f, -2.31663976e-02f, 1.52934611e-01f,
  -1.66422933e-01f, -2.44578999e-02f, -8.86507109e-02f, -8.19007382e-02f, -2.76245400e-02f, 3.81497853e-02f, -4.02726643e-02f, 2.19005998e-02f, 1.28738012e-03f, -4.65622693e-02f,
  -1.30196199e-01f, 1.08273424e-01f, 3.87260579e-02f, -9.94368047e-02f, -8.08792189e-03f, -9.48403552e-02f, -5.74048497e-02f, -6.19908385e-02f, -7.72219300e-02f, 7.54235499e-03f,
  1.83901444e-01f, 4.35279965e-01f, 5.64730614e-02f, 9.93233058e-04f, 4.57992591e-02f, 1.22815207e-01f, 6.43280074e-02f, 1.94884226e-01f, 1.78853989e-01f, 3.94373424e-02f,
  1.19594283e-01f, 7.68903196e-02f, 5.45424893e-02f, -2.80764885e-02f, 4.37925309e-02f, 2.10609913e-01f, 3.83860283e-02f, -9.67068970e-02f, 1.82349578e-01f, 9.11589116e-02f,
  -3.81044410e-02f, 2.88653071e-03f, 8.64453316e-02f, -1.19205322e-02f, 1.11407124e-01f, 5.12253605e-02f, 5.81854433e-02f, 2.88139563e-02f, 3.25472541e-02f, 2.32004561e-02f,
  -5.40443957e-01f, -4.38376635e-01f, -1.11404777e-01f, 1.60472959e-01f, -1.29215717e-01f, 2.33670145e-01f, 5.37308633e-01f, -3.25224191e-01f, -4.25404608e-01f, -1.09370090e-01f,
  3.59783888e-01f, -4.26197378e-03f, 8.36425424e-02f, 3.34739655e-01f, 4.75800812e-01f, 9.84662473e-02f, 2.58670032e-01f, 1.93211615e-01f, -1.62192985e-01f, -2.47659907e-01f,
  -1.45474210e-01f, 1.88147202e-01f, 3.30383480e-01f, -2.33441457e-01f, -6.92267194e-02f, -2.21485078e-01f, 1.78036273e-01f, 2.95965932e-03f, 1.80902198e-01f, 2.34277070e-01f,
  -1.97881073e-01f, -5.23043990e-01f, 4.39120922e-03f, -2.57210694e-02f, -1.22368624e-02f, 3.35380323e-02f, 8.95706639e-02f, 1.07224621e-01f, -5.00677107e-03f, -1.77380405e-02f,
  4.05793488e-02f, -1.07451715e-01f, -2.53107101e-02f, 8.19848254e-02f, -1.29179150e-01f, -8.24628696e-02f, -1.08920574e-01f, 1.70361046e-02f, -9.30257812e-02f, -1.80989169e-02f,
  -1.26810148e-01f, -4.80681062e-02f, -2.97653843e-02f, 1.37719765e-01f, 2.25355122e-02f, -8.65225717e-02f, 3.78023386e-02f, -1.10953057e-04f, -7.50352070e-02f, -4.38959636e-02f,
  5.34835011e-02f, -2.84500569e-02f, -8.52477551e-02f, 3.58607024e-02f, -1.61456503e-02f, 9.12540555e-02f, 1.17476054e-01f, 8.56599361e-02f, -2.88909785e-02f, -2.27325391e-02f,
  -4.88938317e-02f, 1.25882570e-02f, -8.37542117e-02f, -9.12981760e-03f, 5.95874302e-02f, -5.64089417e-02f, 7.06486925e-02f, -4.15709652e-02f, -3.56060006e-02f, 2.35361382e-02f,
  -5.80778867e-02f, 4.12816741e-02f, 1.80871561e-02f, 5.37913479e-02f, -1.78477168e-02f, 9.62973386e-02f, -5.26302680e-02f, -6.72307238e-02f, 1.15518756e-02f, 1.06466472e-01f,
  -5.03292263e-01f, -4.94497389e-01f, -1.26018538e-03f, -5.44225536e-02f, 4.39426936e-02f, -7.52777904e-02f, -1.11060543e-02f, -1.31956354e-01f, -6.85421005e-02f, -4.94001135e-02f,
  -2.41566878e-02f, 7.05866069e-02f, -6.55701756e-02f, 4.73477878e-02f, 8.07354674e-02f, -1.39546886e-01f, 1.82980802e-02f, -3.79472459e-03f, 1.04094595e-01f, -6.72475249e-02f,
  -1.36325574e-02f, -6.61799684e-02f, 1.10144749e-01f, -1.34799615e-01f, -1.19393319e-02f, 1.22269370e-01f, -1.47383019e-01f, -6.67469949e-02f, 1.02543950e-01f, -1.17674675e-02f,
  1.84176773e-01f, -3.30939621e-01f, 2.69729048e-01f, 1.09290577e-01f, 4.31188792e-01f, 3.34200054e-01f, 2.91649550e-01f, 1.50513485e-01f, 2.30583206e-01f, -4.58665341e-01f,
  -2.64234602e-01f, -3.09439152e-01f, -1.60612717e-01f, -2.29361653e-02f, 3.99331033e-01f, -4.09147963e-02f, 3.08328122e-02f, -1.93131179e-01f, 1.90097034e-01f, -7.34873936e-02f,
  2.33787984e-01f, 1.53908566e-01f, 3.04707915e-01f, -1.96509995e-02f, 2.07831398e-01f, -5.83706833e-02f, -1.12680137e-01f, 2.96250641e-01f, -1.24041542e-01f, 2.78074831e-01f,
  -1.46347612e-01f, -1.47776201e-01f, 8.79771039e-02f, -1.23827212e-01f, -1.54553890e-01f, 2.33456139e-02f, -9.42435674e-03f, 1.09272182e-01f, 2.11463869e-01f, -2.25642696e-02f,
  -1.32016838e-01f, -1.20394435e-02f, -1.54746426e-02f, 1.48493618e-01f, 4.69566248e-02f, 4.91959741e-04f, -3.04850750e-02f, 8.63839127e-03f, 5.23509271e-02f, 2.77475733e-03f,
  7.13251904e-02f, -1.60049915e-01f, -6.04828410e-02f, -1.33759543e-01f, -8.41151981e-04f, -7.76345357e-02f, -3.37102115e-02f, -1.98259614e-02f, -6.07860424e-02f, -3.77688184e-02f,
  1.35402039e-01f, 1.47553220e-01f, -1.50187910e-01f, -1.01179406e-01f, -6.78690970e-02f, 2.06340314e-03f, -8.95090774e-02f, -1.24642022e-01f, -1.41285770e-02f, -5.32397591e-02f,
  2.55793310e-03f, 2.54862625e-02f, -2.15764213e-02f, 4.41872515e-02f, -2.52705086e-02f, -6.40834793e-02f, -1.57381203e-02f, -1.38699889e-01f, 2.30728034e-02f, 1.08430877e-01f,
  2.81078480e-02f, 7.66126662e-02f, -5.93943745e-02f, 3.25183384e-02f, -3.08546796e-02f, -8.65441784e-02f, -4.64938357e-02f, -7.07059577e-02f, 3.23692523e-02f, -3.20248865e-02f,
  -5.16344607e-01f, -4.84782696e-01f, 5.93147017e-02f, -5.00032268e-02f, -1.32951751e-01f, -3.52770835e-02f, 3.12226079e-02f, 7.23068863e-02f, -6.87555522e-02f, 2.23343764e-02f,
  -1.02012821e-01f, -9.14105102e-02f, -5.38963489e-02f, 1.65923703e-02f, 4.23543938e-02f, 2.66408268e-02f, -5.54059222e-02f, -1.22234933e-01f, -5.48192114e-03f, -1.55605376e-01f,
  -1.13898687e-01f, -9.92344916e-02f, 1.21011045e-02f, 1.16210379e-01f, -7.58428648e-02f, -6.55978024e-02f, -9.15894285e-02f, 9.12968889e-02f, -9.26407054e-02f, 7.04721585e-02f,
  -2.99097151e-01f, 4.95212674e-02f, -6.45664215e-01f, -4.91875336e-02f, 6.67332113e-02f, -6.53089762e-01f, -2.20233306e-01f, -2.20763862e-01f, 2.74770886e-01f, 1.28867224e-01f,
  2.10157216e-01f, 1.35929942e-01f, 3.49574089e-01f, -5.82350120e-02f, -4.42010373e-01f, 2.48086914e-01f, -5.45143664e-01f, -1.15606934e-01f, 1.25416413e-01f, -2.89279580e-01f,
  -1.37213513e-01f, 1.07658945e-01f, -1.51614726e-01f, 5.84801380e-03f, -1.02614596e-01f, -6.44271225e-02f, -5.03000431e-03f, 2.55967766e-01f, -4.27290320e-01f, -6.94954619e-02f,
  -2.47050777e-01f, 3.34590971e-01f, 1.96870849e-01f, -5.34241199e-02f, -3.35593641e-01f, -2.48347502e-02f, -1.01803571e-01f, 1.86528280e-01f, 2.18172297e-01f, -3.77165079e-02f,
  -1.98251270e-02f, 1.08813524e-01f, 7.97565654e-02f, 1.44869506e-01f, 4.35072146e-02f, 5.99598438e-02f, -3.13469060e-02f, -2.91409373e-01f, 1.07640773e-01f, -1.23388946e-01f,
  -1.77927746e-03f, -1.67663962e-01f, -1.52387068e-01f, 5.03725223e-02f, 4.90985736e-02f, 7.49316439e-02f, -1.76097959e-01f, -1.20602623e-01f, -1.04491152e-01f, 3.04444903e-03f,
  -2.34258808e-02f, 6.80702180e-02f, 9.12279263e-02f, 9.50810239e-02f, 5.50467223e-02f, 7.73744285e-02f, 8.42846856e-02f, 9.59698260e-02f, -2.10293476e-02f, -1.18376007e-02f,
  -5.93880564e-02f, 1.03384182e-01f, 8.38302523e-02f, -1.55961871e-01f, -1.84889838e-01f, 1.12239562e-01f, -6.70767128e-02f, 3.05089541e-03f, -1.17746465e-01f, -7.52924085e-02f,
  2.15251133e-01f, -3.31473053e-02f, 9.25566405e-02f, -4.45853062e-02f, -1.10952899e-01f, 8.28867778e-02f, -5.53567708e-02f, -1.65200293e-01f, 6.25121221e-02f, -1.95892915e-01f,
  -3.98648977e-01f, -1.36029005e-01f, 9.28378850e-02f, 6.17635623e-02f, 4.80611473e-02f, -1.77248076e-01f, -5.62344901e-02f, -1.16007082e-01f, 1.43870162e-02f, -2.23623756e-02f,
  -2.75811255e-01f, 2.13361643e-02f, -2.52125502e-01f, 3.60022634e-02f, -5.64919785e-02f, -1.56290025e-01f, -9.84414816e-02f, 1.85390245e-02f, -1.64471641e-01f, -1.72419056e-01f,
  -7.86708146e-02f, 1.42940851e-02f, -4.02418189e-02f, 1.90563891e-02f, -5.61966002e-02f, 3.99623662e-02f, -1.55117497e-01f, 6.18339591e-02f, -8.49403664e-02f, 1.80699751e-02f,
  6.96023464e-01f, 2.80689657e-01f, -6.77965302e-03f, 4.87656295e-01f, 1.54440075e-01f, 5.78288019e-01f, 2.53944695e-01f, 2.61912465e-01f, 5.88636696e-01f, 8.68614465e-02f,
  1.02171851e-02f, 1.82557926e-01f, -3.86439174e-01f, 3.28986257e-01f, -1.24540545e-01f, -1.46058261e-01f, 2.77032822e-01f, 2.85312593e-01f, 8.92718732e-02f, 1.81445003e-01f,
  1.20026283e-01f, -9.60360095e-02f, -3.04177105e-01f, -2.43433863e-01f, 2.31235415e-01f, -1.38608441e-01f, -4.55734670e-01f, -3.47626418e-01f, -1.93011433e-01f, -2.23162159e-01f,
  1.01708155e-02f, 1.39360607e-01f, 9.75509956e-02f, 2.45496854e-02f, -5.31672835e-02f, 1.43626824e-01f, -2.22715661e-01f, -2.20652714e-01f, -6.36401549e-02f, 8.63696560e-02f,
  3.37107182e-02f, -1.01105608e-01f, 2.54787296e-01f, -1.45755876e-02f, 2.91278344e-02f, 2.51164585e-02f, 2.42795609e-02f, 4.92424034e-02f, -2.95469374e-03f, 1.03828888e-02f,
  1.29850343e-01f, 1.03498884e-01f, 1.73204523e-02f, -3.70297171e-02f, 1.81565918e-02f, 1.99641678e-02f, 5.03038019e-02f, -3.67664620e-02f, 4.23387997e-02f, 1.10436030e-01f,
  9.59292576e-02f, 1.33280978e-02f, -1.75990490e-03f, 4.77278531e-02f, 5.60976416e-02f, -1.35494526e-02f, 6.65778965e-02f, -1.22499183e-01f, 4.90421765e-02f, -4.63224575e-02f,
  1.01987027e-01f, -5.04533388e-03f, 2.43094545e-02f, 7.95527026e-02f, 6.50826842e-02f, 1.25126556e-01f, -4.12041992e-02f, -1.79694686e-02f, 1.08231626e-01f, 2.40736734e-02f,
  -1.27865016e-01f, 8.64863917e-02f, 1.13081142e-01f, -8.78577121e-03f, -5.96538521e-02f, -6.92542493e-02f, 5.86063415e-02f, 6.74523115e-02f, -6.60395250e-03f, -6.22455552e-02f,
  9.10128653e-02f, 1.21697016e-01f, 5.32388575e-02f, -8.71865898e-02f, -1.45364925e-01f, 1.39038503e-01f, 1.31428689e-01f, 1.51278839e-01f, -5.41018136e-03f, 1.06226139e-01f,
  7.42953941e-02f, 1.08061001e-01f, 4.39641215e-02f, -4.30442989e-02f, -1.06381834e-01f, 2.80552685e-01f, -1.07672654e-01f, 2.30730348e-03f, -1.74278304e-01f, -9.59446728e-02f,
  6.31076396e-02f, 1.45281807e-01f, 2.67674681e-02f, 8.00622404e-02f, 1.16017982e-02f, -3.27251554e-02f, 1.27146035e-01f, -1.14043318e-01f, -1.06331855e-01f, 3.83669771e-02f,
  -3.76783341e-01f, 3.63892823e-01f, -6.90331161e-02f, 3.93298175e-03f, -3.71401936e-01f, -3.54613215e-01f, 6.12078272e-02f, -2.36364871e-01f, 1.36226192e-01f, 4.80232835e-01f,
  -2.67417375e-02f, 1.28002882e-01f, 1.02881707e-01f, 1.16629191e-01f, -5.14249206e-01f, 3.26486409e-01f, -1.40381046e-02f, 2.75629520e-01f, 1.54758729e-02f, -2.48045191e-01f,
  -2.78819293e-01f, -3.04711074e-01f, 1.63376722e-02f, -3.10983241e-01f, -1.87577814e-01f, 1.82111803e-02f, -1.05706431e-01f, -2.49369621e-01f, -4.03619520e-02f, -1.58496886e-01f,
  -4.09113318e-01f, -2.47423202e-01f, 4.82586212e-04f, 5.60828708e-02f, -5.18780462e-02f, 4.72765341e-02f, -4.76300642e-02f, 7.54753221e-03f, -1.56841576e-01f, 2.57200226e-02f,
  1.52240545e-01f, -4.53320518e-02f, -2.67747752e-02f, 6.08993098e-02f, -2.18919627e-02f, -1.07107297e-01f, -2.76607927e-02f, 9.30956453e-02f, -1.13071568e-01f, 1.40535031e-02f,
  1.19261585e-01f, -3.83513197e-02f, 4.69266325e-02f, 1.09734066e-01f, 1.36285610e-02f, -6.12272918e-02f, 8.65555257e-02f, 1.33822426e-01f, -6.05836930e-03f, -1.62780046e-01f,
  2.24580914e-02f, 5.24322689e-02f, 1.27346432e-02f, -4.98854704e-02f, -3.43847461e-02f, 5.37233576e-02f, 2.58366186e-02f, 4.56802994e-02f, 3.72822173e-02f, -6.09615520e-02f,
  1.35280797e-02f, 8.41428759e-04f, -1.33476838e-01f, -1.03570363e-02f, 1.42557010e-01f, 8.06301236e-02f, -1.46278897e-02f, -5.16674407e-02f, 9.24525633e-02f, 2.27900147e-02f,
  -3.48860808e-02f, -1.30157834e-02f, 9.78239626e-02f, 1.22978963e-01f, -4.91392314e-02f, -3.82429287e-02f, -4.81734015e-02f, 4.09712456e-02f, -1.09689884e-01f, -2.09885314e-01f,
  -5.29394329e-01f, -5.50745487e-01f, 3.08060292e-02f, -4.24299622e-03f, -4.91925478e-02f, -1.08565398e-01f, -5.20458817e-03f, -1.35572590e-02f, -1.23321623e-01f, -1.72551140e-01f,
  -7.01640174e-02f, 1.30569324e-01f, -1.22065023e-01f, 2.66881995e-02f, 3.14711966e-02f, -8.28042775e-02f, -2.79189404e-02f, 2.38507316e-02f, -1.93283916e-01f, 2.90191770e-02f,
  -4.91640940e-02f, -8.51937383e-03f, -9.72917210e-03f, -5.98719604e-02f, 1.05701163e-01f, -9.94993076e-02f, -1.47791624e-01f, 1.54292360e-01f, -1.26246005e-01f, 1.22461975e-01f,
  -5.91594100e-01f, -4.82196361e-01f, 3.30531865e-01f, 1.84410930e-01f, -1.93304732e-01f, -7.49480426e-02f, 2.77217478e-01f, -4.28315103e-01f, -4.86657679e-01f, -3.00022662e-01f,
  -4.79342975e-02f, -1.01630747e-01f, 1.58873826e-01f, 2.67802179e-01f, 4.23481643e-01f, 2.37121418e-01f, 2.16683730e-01f, 1.83422029e-01f, 1.53439984e-01f, 4.49918909e-03f,
  2.23219007e-01f, 2.28308976e-01f, 6.07172251e-01f, 7.02804253e-02f, -4.23877463e-02f, 2.57238932e-02f, 1.27870783e-01f, 2.73845106e-01f, 1.48677364e-01f, 9.90863666e-02f,
  -3.59066635e-01f, -1.89365625e-01f, 5.69401402e-03f, -7.57619962e-02f, -1.13561004e-01f, -4.42112498e-02f, 1.36345282e-01f, 1.76335841e-01f, 1.19357921e-01f, 2.67597958e-02f,
  -7.08865970e-02f, 3.37590240e-02f, 1.28220823e-02f, 6.92303386e-03f, -2.14191943e-01f, -1.59396455e-01f, -1.07442737e-01f, -4.89567965e-03f, 1.65984221e-02f, -1.16104186e-01f,
  -3.75078022e-02f, 2.01972313e-02f, 6.95767552e-02f, 2.38534808e-03f, 1.01243267e-02f, -1.27077326e-01f, 1.44445404e-01f, 1.11257114e-01f, -1.77647069e-01f, -1.36935577e-01f,
  -6.19193874e-02f, 7.41601512e-02f, -7.48445913e-02f, -1.71136955e-04f, -3.62587497e-02f, -6.83300023e-04f, 3.64051796e-02f, 8.00085962e-02f, 3.83008942e-02f, -1.17353551e-01f,
  5.08103818e-02f, 1.57233011e-02f, -6.70743063e-02f, -1.13286778e-01f, -1.97378732e-02f, 1.78915039e-02f, 2.00329527e-01f, -1.00774974e-01f, 2.05508783e-03f, 8.39445591e-02f,
  1.30134463e-01f, -9.99424383e-02f, -1.58227533e-02f, 8.66001099e-02f, -3.76407094e-02f, 2.79647093e-02f, -6.24094158e-02f, -1.43819731e-02f, 5.72627923e-03f, 1.73266292e-01f,
  -4.16113645e-01f, -1.67339042e-01f, -3.61802652e-02f, -1.07151054e-01f, 1.09320104e-01f, -1.16497308e-01f, -1.05256692e-03f, -1.31339237e-01f, -5.28610572e-02f, 3.38566266e-02f,
  -9.06479582e-02f, 6.50039241e-02f, -1.56514511e-01f, 3.01436521e-02f, 7.24111050e-02f, -8.98239911e-02f, -2.61259209e-02f, 7.95219466e-03f, -9.85892266e-02f, -4.98228483e-02f,
  4.14727554e-02f, -2.15802528e-02f, 7.98191801e-02f, 1.97829287e-02f, 1.45003691e-01f, 3.63644883e-02f, -6.36344850e-02f, -1.31676778e-01f, 8.10221508e-02f, 5.11193722e-02f,
  -9.94786561e-01f, 4.90907043e-01f, 3.78157258e-01f, -3.41934323e-01f, 1.80019110e-01f, 4.08503652e-01f, 1.06551439e-01f, 9.69541520e-02f, 2.97039258e-03f, 2.55512208e-01f,
  -1.33249328e-01f, -3.73438224e-02f, 4.24465448e-01f, 1.72858447e-01f, -1.57168955e-01f, 4.94137079e-01f, -1.39402494e-01f, -1.49133056e-01f, 1.60232276e-01f, -9.08890367e-02f,
  -1.68245688e-01f, 1.11011686e-02f, 9.28290933e-02f, 2.10264117e-01f, -2.92298406e-01f, -1.97354257e-01f, -3.49331111e-01f, 4.14658993e-01f, -2.01511860e-01f, 1.18651807e-01f,
  -4.67339516e-01f, -4.21582758e-01f, -4.36636090e-01f, -1.50172353e-01f, -2.15457782e-01f, -7.92022049e-02f, -2.54438698e-01f, -3.77746783e-02f, -9.45681334e-02f, 5.80763742e-02f,
  8.09063390e-02f, 2.46285889e-02f, -6.45589903e-02f, 2.03691237e-02f, -2.28177886e-02f, -5.34204543e-02f, 1.93843991e-01f, -2.75174361e-02f, 1.00462615e-01f, 9.79119465e-02f,
  1.91183716e-01f, 1.03786603e-01f, -1.27142906e-01f, -6.64468259e-02f, -2.66189054e-02f, 3.89282256e-02f, 8.31443146e-02f, -4.60738763e-02f, -1.90644890e-01f, -1.47653505e-01f,
  -4.28116135e-02f, 9.74558890e-02f, 3.07952240e-02f, 5.11329435e-02f, 1.09444596e-01f, 4.30838717e-03f, -1.29994974e-02f, 3.98947932e-02f, 6.23645149e-02f, 7.44603723e-02f,
  1.70664862e-02f, -1.55827969e-01f, -2.55629748e-01f, -9.82979685e-02f, 4.84817624e-02f, -3.25783864e-02f, -6.15691626e-03f, -8.02725628e-02f, -4.18866836e-02f, -1.50173649e-01f,
  1.84363648e-02f, -1.55290905e-02f, -2.18514577e-02f, -4.40628454e-02f, -1.79832101e-01f, -2.17933464e-03f, -5.48886061e-02f, -2.06432231e-02f, -1.64506152e-01f, -7.33563378e-02f,
  -4.48568612e-01f, -2.80211091e-01f, -3.76808606e-02f, -2.79876947e-01f, -1.55970916e-01f, -1.95070624e-01f, 1.36122122e-01f, -1.55010238e-01f, -2.40605101e-02f, -3.04758288e-02f,
  -9.46910679e-02f, -1.83831528e-01f, -1.20876320e-01f, 1.32379076e-02f, 1.63750470e-01f, 5.58682010e-02f, 1.33870825e-01f, -5.89415692e-02f, -8.59731734e-02f, -4.37750109e-02f,
  9.16482806e-02f, -9.17227343e-02f, 9.16715264e-02f, -1.66098371e-01f, -6.56383261e-02f, -1.89667910e-01f, 1.83575600e-02f, -1.46325910e-03f, 1.86185502e-02f, 9.03023407e-02f,
  3.50360751e-01f, -2.92162687e-01f, 2.72873878e-01f, 3.77132893e-01f, -1.95246488e-02f, -1.28183782e-01f, 2.30581015e-01f, -3.15823704e-01f, -2.26084113e-01f, -4.19715405e-01f,
  -3.40142757e-01f, 5.60749233e-01f, -4.26677525e-01f, 3.73789012e-01f, 9.84828323e-02f, -4.81678635e-01f, 4.23309989e-02f, 2.82836348e-01f, -1.75777033e-01f, -2.32951999e-01f,
  -8.78528208e-02f, -1.81117937e-01f, 9.35038999e-02f, -2.44317845e-01f, 1.88649207e-01f, 3.36832881e-01f, 1.52056545e-01f, 1.41810119e-01f, 4.98043150e-01f, 4.14686352e-01f,
  -6.92953318e-02f, -9.29989219e-02f, -3.55486125e-02f, 9.81858149e-02f, -8.88633654e-02f, 4.56491336e-02f, 1.01877742e-01f, 1.34884819e-01f, 2.81525254e-01f, 8.57126620e-03f,
  5.56697510e-02f, 8.60438943e-02f, 6.12222776e-02f, 4.99421731e-03f, 2.00268272e-02f, 5.25608845e-02f, 1.95065886e-01f, 6.04253449e-02f, 1.03677385e-01f, 6.59431368e-02f,
  2.80032810e-02f, -1.40690571e-02f, 7.17567876e-02f, 6.04664162e-02f, 2.14152057e-02f, 1.79024450e-02f, 2.20434278e-01f, 6.52654245e-02f, 1.36347022e-02f, 5.32886125e-02f,
  -2.47764401e-02f, -6.20807447e-02f, 5.39237261e-02f, 2.85401940e-02f, 7.08494782e-02f, 5.98671511e-02f, -7.41774514e-02f, 2.73103528e-02f, 1.52412996e-01f, -1.87372342e-01f,
  -1.51830250e-02f, -3.58553454e-02f, 2.69381683e-02f, 1.59634138e-03f, -6.93803877e-02f, 3.55468062e-03f, 1.29268646e-01f, 7.90478960e-02f, -1.86369538e-01f, -5.20947995e-03f,
  -6.45008907e-02f, 9.84766036e-02f, -4.70371209e-02f, 6.85375780e-02f, -9.59218293e-02f, -1.23152032e-01f, -7.93141648e-02f, 6.24028668e-02f, -9.06652510e-02f, 2.67330054e-02f,
  -6.00645721e-01f, -2.60056108e-01f, -1.78446189e-01f, 1.26843989e-01f, -9.97860283e-02f, 6.77095121e-03f, 9.74185988e-02f, 1.35411415e-02f, 1.31361664e-03f, -7.37607405e-02f,
  -3.84010896e-02f, 9.72175449e-02f, -3.10497209e-02f, 1.32462010e-01f, 1.26722842e-01f, -7.89214112e-03f, 4.75440640e-03f, -9.00342315e-02f, -7.60686994e-02f, 1.14012733e-01f,
  3.74296382e-02f, -2.43432168e-02f, 5.69564812e-02f, 5.19249700e-02f, -3.53768244e-02f, 4.53001782e-02f, -3.29646585e-03f, 1.04553528e-01f, -7.80859590e-03f, 6.58740401e-02f,
  -9.26072001e-01f, 2.37405628e-01f, -1.29449517e-01f, -1.84125006e-01f, -4.73445415e-01f, -1.38852894e-01f, -6.37615323e-02f, -1.27975205e-02f, 3.64259630e-02f, 3.59934449e-01f,
  3.45612019e-02f, -1.67176098e-01f, 4.04089391e-01f, 2.23206490e-01f, -4.08445209e-01f, 3.78279150e-01f, -8.52196440e-02f, 1.23351634e-01f, 4.43501472e-02f, -1.80645540e-01f,
  -8.40317011e-02f, -9.51548517e-02f, -1.29731139e-02f, 5.53991236e-02f, -4.60921317e-01f, -2.46904522e-01f, -8.41738805e-02f, -2.28803694e-01f, -1.92291036e-01f, -3.01633060e-01f,
  -6.09559238e-01f, -2.28237957e-01f, -2.44533509e-01f, -1.38560131e-01f, -1.67576298e-01f, -1.04957514e-01f, -1.00833297e-01f, -8.49340186e-02f, -7.58612826e-02f, -3.98375019e-02f,
  -8.89516771e-02f, 1.67467433e-03f, 1.57490205e-02f, 8.46990049e-02f, -1.31852478e-01f, -4.49597202e-02f, -4.86568548e-02f, -6.16101176e-02f, -8.00903141e-02f, -5.58625385e-02f,
  3.88011783e-02f, 1.82187036e-02f, -2.48090476e-02f, 5.71039729e-02f, -2.45410949e-01f, -1.49960786e-01f, -1.34235714e-04f, -2.59301085e-02f, -1.58175647e-01f, -1.78171664e-01f,
  5.07532135e-02f, 2.48307046e-02f, -3.61575373e-02f, -1.67960078e-02f, 2.44399961e-02f, -3.25497091e-02f, -3.62743661e-02f, 5.01678064e-02f, -4.62074615e-02f, -2.69811098e-02f,
  -6.41132295e-02f, -3.14074531e-02f, -1.17310509e-01f, 1.22696226e-02f, 1.57010574e-02f, 1.36624202e-01f, -7.86893442e-02f, -5.78884594e-02f, 1.40894517e-01f, -4.94043231e-02f,
  -2.53038350e-02f, 3.29535641e-02f, -5.02656400e-03f, 3.78857628e-02f, -4.47779149e-02f, -1.88163593e-02f, 1.36899278e-01f, 7.35588148e-02f, 6.86605182e-03f, -7.82098845e-02f,
  -6.52631700e-01f, -4.27760094e-01f, -6.79919869e-02f, -2.07941294e-01f, -6.38151765e-02f, 8.23372304e-02f, 7.59698153e-02f, -7.09332600e-02f, -1.67108104e-01f, 6.13328516e-02f,
  -4.45375190e-04f, 5.93799986e-02f, -8.86389166e-02f, 5.49389869e-02f, 9.80149508e-02f, 2.05055512e-02f, -1.74212866e-02f, -9.05800238e-03f, -1.95900589e-01f, -5.69143798e-03f,
  -2.41890866e-02f, 7.23403320e-02f, 9.93473828e-02f, -2.58126445e-02f, 1.71047840e-02f, -1.22708663e-01f, -2.50475612e-02f, -4.72187921e-02f, -1.62592202e-01f, 1.04253493e-01f,
  -5.42383254e-01f, -4.00607556e-01f, 9.28211957e-03f, -1.59758285e-01f, 1.92281306e-01f, 2.16438010e-01f, -1.56960174e-01f, -1.99206293e-01f, -2.06049591e-01f, -2.76860595e-01f,
  -2.15018734e-01f, -2.45506674e-01f, -5.54630816e-01f, -1.22017808e-01f, -1.50502980e-01f, -3.96281093e-01f, 2.62832075e-01f, 6.38126209e-02f, -5.03093451e-02f, -4.70046736e-02f,
  2.26443067e-01f, -1.05801389e-01f, -2.16258876e-02f, 2.68915653e-01f, -1.17484212e-01f, 4.69024628e-01f, 2.95235246e-01f, 2.58547664e-01f, 5.39499640e-01f, 2.64704257e-01f,
  4.56318557e-02f, -3.23533535e-01f, 2.85247825e-02f, 1.73543483e-01f, 5.97755611e-02f, 2.53182044e-03f, 2.47351781e-01f, -5.37926480e-02f, 1.84805170e-01f, -4.04921081e-03f,
  -6.58479035e-02f, 6.57411218e-02f, 5.97607438e-03f, 3.89361903e-02f, 5.27717359e-02f, 9.12213475e-02f, 1.51306689e-01f, -1.11194447e-01f, -2.99353851e-03f, -1.97152033e-01f,
  -1.25990197e-01f, -8.33432004e-02f, 1.18307963e-01f, 1.59104660e-01f, 2.14127481e-01f, 2.18725562e-01f, 9.69880223e-02f, 1.44502297e-01f, 1.18883654e-01f, 7.70999715e-02f,
  -3.99570949e-02f, 1.48334680e-03f, -1.17982596e-01f, -8.90475586e-02f, -1.30480513e-01f, 7.24706575e-02f, 6.02413267e-02f, -3.45018879e-02f, 5.58539815e-02f, -3.22364047e-02f,
  6.04619645e-03f, -2.11164728e-02f, 8.92737508e-03f, 1.40102997e-01f, -7.87639841e-02f, -1.31144896e-01f, 1.62686333e-01f, 9.18449461e-02f, -5.29143438e-02f, -1.92829207e-01f,
  -2.02611163e-01f, 1.88002318e-01f, -2.17373986e-02f, 1.08827399e-02f, -8.94057602e-02f, 1.29155489e-02f, 5.13966717e-02f, -1.43244296e-01f, -6.46635070e-02f, -2.81020831e-02f,
  1.73813418e-01f, 2.47320816e-01f, 9.15510021e-03f, 1.23033062e-01f, 3.85603048e-02f, -1.00741386e-01f, 6.05243444e-02f, 1.61348715e-01f, 2.00474694e-01f, -1.05073132e-01f,
  1.18030302e-01f, 1.11535221e-01f, -1.91493064e-01f, 1.22202225e-02f, 1.20454818e-01f, 1.53752766e-03f, 6.77545443e-02f, 9.49590430e-02f, 1.40138626e-01f, 1.01749979e-01f,
  -1.57459527e-01f, 9.45045203e-02f, -8.56562406e-02f, 1.95612162e-02f, -6.34500682e-02f, -7.10691661e-02f, -7.28720501e-02f, 1.57867506e-01f, -9.26524848e-02f, 3.72358635e-02f,
  3.92615348e-01f, -8.37496758e-01f, -5.92041910e-02f, 4.68057126e-01f, 3.47555846e-01f, -3.90618920e-01f, -2.26671487e-01f, -8.74737129e-02f, 3.98406506e-01f, -5.34787118e-01f,
  -6.38062358e-02f, -3.09301227e-01f, -4.68861133e-01f, -1.37274429e-01f, 5.28395951e-01f, -3.18706706e-02f, -1.09507389e-01f, -1.37954041e-01f, 2.44040534e-01f, -1.61419228e-01f,
  2.90003508e-01f, -9.90934819e-02f, -2.56319046e-01f, -2.78079510e-01f, -3.58034551e-01f, 8.78429115e-02f, 1.49339110e-01f, -2.58980513e-01f, -5.79109713e-02f, 6.98908344e-02f,
  -3.10829222e-01f, 9.91852358e-02f, -1.05720446e-01f, -1.19497083e-01f, -6.60796613e-02f, -1.09435491e-01f, -1.81635004e-02f, -2.67653130e-02f, -4.75701381e-06f, 1.45432606e-01f,
  -2.83216871e-02f, 2.09695902e-02f, 1.34959698e-01f, 4.65263017e-02f, -6.30893856e-02f, 7.57782832e-02f, 1.46075785e-02f, 3.57274227e-02f, -5.61959408e-02f, -6.34083301e-02f,
  -8.82882029e-02f, 1.18316211e-01f, 5.82194589e-02f, 2.18991544e-02f, 6.59928769e-02f, 1.65874343e-02f, 5.28706610e-02f, 8.51345956e-02f, -9.67626795e-02f, 4.96702977e-02f,
  -9.85343009e-02f, -1.54218720e-02f, -5.09416796e-02f, -8.73626675e-03f, -1.85244735e-02f, 1.61095500e-01f, 1.99485831e-02f, -4.26189080e-02f, 4.24568877e-02f, -3.59276906e-02f,
  2.30873954e-02f, -5.95985390e-02f, 5.51657602e-02f, 9.57872905e-03f, 1.07530452e-01f, 8.16574171e-02f, -1.91095322e-02f, 9.31517854e-02f, 4.63671144e-03f, -3.02361380e-02f,
  -1.06146440e-01f, -4.61395532e-02f, -1.10003293e-01f, -8.84163380e-03f, -1.88798338e-01f, -2.82542389e-02f, -1.55004516e-01f, 2.65248604e-02f, 1.05977722e-01f, 6.28535375e-02f,
  -9.87610817e-01f, -6.55122757e-01f, -7.75168464e-02f, 3.89045402e-02f, -1.39896870e-02f, -1.93779031e-03f, 4.39257771e-02f, 1.12433285e-01f, -2.27650642e-01f, -2.62664463e-02f,
  -6.37395084e-02f, 4.69422750e-02f, 7.43341306e-03f, 2.13291943e-01f, -7.34514073e-02f, -4.21046577e-02f, 3.21660489e-02f, -6.53858781e-02f, -1.47268632e-02f, -8.11173469e-02f,
  -1.35040075e-01f, -4.23920751e-02f, 6.72303066e-02f, 4.84672822e-02f, 6.53832629e-02f, -3.66291031e-02f, 1.52038276e-01f, 3.07350159e-02f, 2.07667910e-02f, 2.50383765e-02f,
  -4.79818463e-01f, 5.21723628e-01f, -6.34198338e-02f, -3.45943362e-01f, -4.53760065e-02f, -1.60458863e-01f, -3.04283708e-01f, 1.52172923e-01f, 3.91995050e-02f, 1.10360503e-01f,
  -1.51762366e-01f, 3.98444086e-01f, 2.54414767e-01f, -2.11257681e-01f, -1.41830042e-01f, 1.91830114e-01f, -3.96680117e-01f, -3.06853861e-01f, 3.22076440e-01f, -1.61862269e-01f,
  -1.70870662e-01f, -1.30948201e-01f, -1.39834464e-01f, 2.44209439e-01f, -2.83511698e-01f, -1.47763833e-01f, -3.71865004e-01f, 1.27619267e-01f, -3.60582918e-01f, 1.40748331e-02f,
  -1.16303973e-01f, -1.28959507e-01f, -1.38451532e-02f, -1.49582878e-01f, -7.62540698e-02f, -2.09429130e-01f, -1.88889697e-01f, -6.89018099e-03f, 1.11195058e-01f, -1.77366380e-02f,
  1.08278267e-01f, 9.33242515e-02f, 1.19768895e-01f, 2.18986571e-01f, -1.05573619e-02f, -9.74251051e-03f, 4.30777222e-02f, -1.79164708e-01f, 7.18258917e-02f, 3.18633206e-02f,
  1.43242195e-01f, 4.95916046e-02f, -1.40546501e-01f, -1.88459307e-01f, -1.25021055e-01f, -3.02325911e-03f, -2.08297253e-01f, -1.74573720e-01f, -1.01246022e-01f, 1.24759525e-02f,
  -6.01028986e-02f, -1.44092798e-01f, 2.48581804e-02f, -2.77881734e-02f, 3.75251397e-02f, 1.49867916e-02f, 8.80422443e-02f, -1.03273794e-01f, -3.38134207e-02f, -1.42983422e-01f,
  -1.94620743e-01f, -1.54472649e-01f, 5.49928024e-02f, -3.40968817e-02f, 1.16563803e-02f, 8.54876414e-02f, -5.50413206e-02f, -4.56955843e-02f, 1.95431951e-02f, 1.16606973e-01f,
  -3.49125750e-02f, 7.07370276e-03f, -3.30518261e-02f, -4.03688774e-02f, 6.81917593e-02f, 1.07120164e-01f, 6.78028166e-02f, -3.03169359e-02f, 5.01657315e-02f, -1.30850924e-02f,
  -3.81632984e-01f, -4.59980458e-01f, 2.19749869e-03f, 5.64117543e-02f, 7.82202333e-02f, 9.30262059e-02f, 2.77585839e-03f, 1.06616214e-01f, -2.78615076e-02f, 1.53464125e-02f,
  7.82630816e-02f, -7.32869208e-02f, -1.84231043e-01f, 1.34025118e-03f, 2.84863468e-02f, -1.05566876e-02f, -7.02949092e-02f, -1.48997679e-01f, -1.36669278e-01f, 1.06425602e-02f,
  -1.25509962e-01f, -9.09740850e-03f, 1.90162547e-02f, -1.56072546e-02f, -5.62849194e-02f, 2.49779411e-02f, -8.75135064e-02f, 8.11596364e-02f, -3.82462256e-02f, -8.99195522e-02f,
  -9.64635611e-01f, 3.63030076e-01f, 6.52886808e-01f, -1.20499201e-01f, -3.40162180e-02f, 8.53976667e-01f, 6.11649930e-01f, 2.50428736e-01f, 5.33743322e-01f, 2.32276306e-01f,
  1.01413496e-01f, 7.90991858e-02f, 2.04102904e-01f, 2.39175647e-01f, 5.31741321e-01f, 4.77277905e-01f, 3.35514843e-01f, 2.35973448e-01f, -7.99562410e-02f, -2.76551694e-01f,
  -4.07216214e-02f, -4.05591056e-02f, -1.35821864e-01f, -3.84905666e-01f, -3.00389707e-01f, -3.54076952e-01f, -4.69264299e-01f, 7.79374838e-02f, -9.95631292e-02f, 1.83942273e-01f,
  -2.00376153e-01f, -3.59430730e-01f, -3.14314157e-01f, 1.37550175e-01f, 7.56366625e-02f, -7.01289177e-02f, -3.27131487e-02f, 7.85741732e-02f, -1.14741832e-01f, -7.91938230e-03f,
  -9.15856808e-02f, -1.88805722e-02f, -1.79940381e-03f, 6.24410063e-02f, -1.54071429e-03f, -1.60336062e-01f, -7.64432400e-02f, 4.84667979e-02f, -1.81971435e-02f, -6.62440658e-02f,
  6.85060546e-02f, 7.00210081e-03f, -3.38640437e-02f, 2.57642083e-02f, 2.65249535e-02f, -5.78610525e-02f, 9.88574475e-02f, 3.74278091e-02f, -3.38900164e-02f, 5.37948832e-02f,
  5.57182841e-02f, 1.66505203e-01f, -1.63663719e-02f, 3.63589413e-02f, -2.88349669e-02f, -5.98783121e-02f, -3.33765596e-02f, 3.53307314e-02f, -2.60671228e-02f, -1.45351708e-01f,
  -5.36531992e-02f, -7.16290846e-02f, -4.24078405e-02f, -4.47591618e-02f, -1.14792725e-02f, -5.40513098e-02f, -3.00158150e-02f, -6.99446276e-02f, 1.06867418e-01f, -3.06068566e-02f,
  -4.01789248e-02f, 7.19660744e-02f, -7.06945956e-02f, -2.60803252e-02f, 4.66130413e-02f, -2.09015235e-02f, 3.43270460e-03f, 5.73076727e-03f, -3.00678518e-02f, 1.50276516e-02f,
  5.24563015e-01f, 3.73576045e-01f, -1.07230462e-01f, -3.13693173e-02f, 1.85418911e-02f, 7.96917155e-02f, 5.77230155e-02f, -8.65649953e-02f, 2.31898934e-01f, 4.00808230e-02f,
  -1.28753036e-01f, -1.50421886e-02f, -5.21943979e-02f, -6.69992715e-02f, 8.59346520e-03f, 1.03174329e-01f, -1.10147342e-01f, -1.58316700e-03f, 1.12855591e-01f, -1.08786784e-01f,
  -2.34729171e-01f, -5.14014550e-02f, 2.36963797e-02f, -8.64551067e-02f, -9.40756127e-02f, -6.69831485e-02f, -1.49553180e-01f, -8.78540277e-02f, -1.35952781e-03f, 2.12019179e-02f,
  -7.89448693e-02f, -3.91406238e-01f, -5.45922041e-01f, -2.14606300e-01f, 2.03999177e-01f, 4.54083294e-01f, -4.77188192e-02f, -1.87184244e-01f, -4.86242861e-01f, 4.07976836e-01f,
  3.20537359e-01f, -4.00978833e-01f, -3.60749155e-01f, 1.83286861e-01f, 2.77861618e-02f, -2.30884433e-01f, 4.70360786e-01f, 2.67563283e-01f, -1.09541066e-01f, -8.62186402e-02f,
  -1.85308494e-02f, 5.34492135e-01f, -2.53928959e-01f, 4.08696562e-01f, 2.62977272e-01f, -5.41949533e-02f, 3.01700741e-01f, -2.67218709e-01f, 4.11653668e-01f, 2.13449657e-01f,
  1.66811660e-01f, -8.40728730e-02f, -1.88960806e-01f, 4.10807366e-03f, 2.52722688e-02f, 2.59329706e-01f, 1.70970812e-01f, 4.80317920e-02f, -2.00359821e-01f, -1.40918270e-01f,
  2.31591091e-02f, -1.21960089e-01f, 5.43261468e-02f, -1.97282955e-01f, 3.68282348e-02f, 2.34344397e-02f, -1.15190245e-01f, -7.22102150e-02f, -1.96187258e-01f, -2.10220829e-01f,
  -2.89301127e-01f, 1.55819520e-01f, 5.79716936e-02f, 9.48158726e-02f, -1.41967088e-01f, 2.48412956e-02f, -3.78143042e-02f, -8.32523480e-02f, 1.48241609e-01f, 4.15141508e-02f,
  1.89913921e-02f, 1.51547819e-01f, 1.30224317e-01f, -2.52137128e-02f, -1.19333275e-01f, 7.57199675e-02f, 4.08204198e-02f, 6.06199428e-02f, -1.23922355e-01f, 1.60617512e-02f,
  1.03144944e-01f, -1.23737790e-01f, 2.83244550e-02f, 7.49618262e-02f, 1.00062728e-01f, 2.15458311e-02f, -3.44956480e-02f, -4.01777849e-02f, -3.26950811e-02f, 6.96431622e-02f,
  2.44653169e-02f, -1.74088534e-02f, -3.02720573e-02f, 9.62695926e-02f, 4.05600816e-02f, -9.20256542e-04f, 1.04797475e-01f, -3.15770879e-02f, -7.10417256e-02f, 4.64978665e-02f,
  5.95433265e-02f, -1.14316270e-01f, -9.47602466e-02f, 5.88557683e-02f, -8.13693833e-03f, 9.04590636e-02f, 8.78220890e-03f, 8.22293630e-04f, 1.65143665e-02f, 7.38770748e-03f,
  1.81715757e-01f, 8.78195763e-02f, 2.95498312e-01f, -1.17873654e-01f, 5.39570563e-02f, 2.94402335e-02f, 1.11007243e-01f, 2.95923501e-02f, 7.84487501e-02f, -1.87001321e-02f,
  9.78574604e-02f, 1.00314662e-01f, 3.51143740e-02f, 1.02127545e-01f, 1.97270140e-01f, 3.24730426e-02f, 4.82798219e-02f, -1.08639814e-01f, 2.38430157e-01f, 2.52894703e-02f,
  4.16036434e-02f, -1.73512608e-01f, 4.40517157e-01f, 1.24620637e-02f, 3.94047260e-01f, 2.54546493e-01f, 7.07785934e-02f, 1.96402505e-01f, 1.12135336e-01f, -3.28256816e-01f,
  -2.25204661e-01f, -1.85332462e-01f, -2.39604741e-01f, -4.91486676e-02f, 2.00496331e-01f, -1.84588358e-01f, 7.64834136e-02f, -2.39525124e-01f, 1.90573692e-01f, 9.20749903e-02f,
  1.60771996e-01f, -2.01704934e-01f, 1.96101010e-01f, 1.04261227e-02f, 2.38804758e-01f, 5.49336523e-02f, -3.29359949e-01f, 2.78858934e-02f, -1.53051853e-01f, 6.31699041e-02f,
  3.62772830e-02f, 4.08253595e-02f, -2.28628311e-02f, -9.24712569e-02f, 8.42681378e-02f, -1.68325976e-02f, -1.09463811e-01f, -5.48138097e-02f, -7.86167849e-03f, 6.23163804e-02f,
  -1.81021199e-01f, 9.14418101e-02f, 4.58391383e-02f, 3.60754207e-02f, 1.13798723e-01f, 1.65626988e-01f, 2.10676894e-01f, 8.87191892e-02f, -1.16226645e-02f, 1.12130724e-01f,
  1.89078405e-01f, 5.07865287e-02f, 8.84111747e-02f, 4.51815352e-02f, 8.30892995e-02f, 1.23041391e-01f, 7.72814006e-02f, -4.23039822e-03f, -4.25889855e-03f, 7.70456120e-02f,
  -8.34217109e-03f, -8.83869734e-03f, 8.44280645e-02f, 6.85701966e-02f, 3.18743773e-02f, 7.58974697e-04f, -2.95242615e-04f, 1.88794016e-04f, 4.92931493e-02f, -2.69658156e-02f,
  -9.79159847e-02f, 3.81270984e-05f, -6.47721672e-03f, -2.00651097e-03f, -2.01637461e-03f, -4.28509712e-02f, -6.25030100e-02f, -1.38376862e-01f, 2.21709930e-03f, 5.98952593e-03f,
  1.14469053e-02f, 6.78934008e-02f, 4.23330925e-02f, 8.59538838e-02f, 1.43547188e-02f, 9.59113799e-03f, -5.20181693e-02f, 9.86860096e-02f, 9.46893692e-02f, -1.51224315e-01f,
  -7.09635079e-01f, -5.51632047e-01f, -2.62594163e-01f, -7.20518008e-02f, -2.38519460e-01f, -2.78682820e-02f, -1.37245953e-01f, 5.27568087e-02f, -1.60712704e-01f, 2.60144658e-02f,
  5.46291377e-03f, -7.21355826e-02f, -1.05733626e-01f, 5.91903813e-02f, -9.61438864e-02f, 7.61416331e-02f, -1.83186397e-01f, -1.69765770e-01f, -1.59747005e-01f, -6.17990494e-02f,
  -8.64353701e-02f, -8.42789114e-02f, 1.77780055e-02f, 1.37903109e-01f, -9.08946246e-02f, -5.47421351e-02f, 1.49724130e-02f, -9.03117657e-02f, 7.53417835e-02f, -1.13717079e-01f,
  -2.60219067e-01f, 7.90410116e-02f, -2.76230901e-01f, -3.14313263e-01f, 3.15391034e-01f, -1.65880769e-01f, -2.47962207e-01f, 3.11508209e-01f, 2.81728834e-01f, 1.78814963e-01f,
  -3.49274687e-02f, 7.11355954e-02f, 3.64653081e-01f, -3.11307579e-01f, -3.90358269e-01f, -6.39277026e-02f, -5.23294389e-01f, -2.74807543e-01f, 2.20198438e-01f, -2.40791455e-01f,
  -9.97979790e-02f, -5.50491847e-02f, -4.20644701e-01f, 1.20655030e-01f, -1.97664410e-01f, -1.33057743e-01f, -4.08241928e-01f, 2.66398668e-01f, -4.94115353e-01f, 3.03570796e-02f,
  -1.25504524e-01f, 3.00248235e-01f, -4.33738939e-02f, 7.88337365e-02f, -1.45453542e-01f, -2.94984989e-02f, -1.93775132e-01f, -5.50195808e-03f, 3.50307263e-02f, 9.18174013e-02f,
  1.26108089e-02f, -6.37390558e-03f, 4.25544977e-02f, 1.08775347e-01f, 1.65459022e-01f, -4.87321652e-02f, -1.54545277e-01f, -3.17818746e-02f, 1.31000951e-01f, -1.31041288e-01f,
  -2.25228518e-01f, -7.50114620e-02f, -6.68987259e-03f, 1.76446233e-02f, -1.77780628e-01f, 6.14501908e-03f, -2.41623502e-02f, -1.83769211e-01f, -7.16558471e-02f, 2.42069047e-02f,
  5.21203987e-02f, 9.38313082e-02f, -8.31821337e-02f, 8.00197497e-02f, 3.38021815e-02f, 5.44872731e-02f, 1.19311642e-02f, -2.05681939e-02f, 7.45381713e-02f, -3.57910320e-02f,
  -4.96135540e-02f, 4.89793196e-02f, 6.42554983e-02f, -4.38449830e-02f, 6.06153198e-02f, 2.04373151e-02f, -6.49154186e-02f, 1.06538020e-01f, -1.52247041e-01f, -4.95209657e-02f,
  1.79579973e-01f, -3.77729605e-03f, 7.45732412e-02f, 3.38652655e-02f, -2.40002889e-02f, 4.40184772e-02f, -6.01090118e-02f, -1.89829189e-02f, -7.82937780e-02f, 1.42160818e-01f,
  -4.94510634e-03f, 1.88657567e-01f, -6.57316018e-03f, 5.12750112e-02f, 3.60821411e-02f, -1.17466256e-01f, 2.06102766e-02f, -6.57335594e-02f, -6.53633922e-02f, 8.87899995e-02f,
  -5.11826761e-02f, -2.11989526e-02f, -1.05699353e-01f, -2.61733066e-02f, -2.47949306e-02f, -2.35245347e-01f, -1.56488158e-02f, 8.46478418e-02f, 8.60233009e-02f, 9.37100425e-02f,
  3.42419259e-02f, 7.32141882e-02f, 5.06261811e-02f, 8.83802995e-02f, 7.24915490e-02f, -4.76332419e-02f, 4.15177055e-04f, -8.50590616e-02f, 7.46761709e-02f, 8.52143317e-02f,
  6.71260715e-01f, 4.06044990e-01f, 2.80012816e-01f, 4.56984848e-01f, -8.59287232e-02f, 3.95911425e-01f, 3.17590326e-01f, 2.34163001e-01f, 5.11117280e-01f, 1.22379800e-02f,
  -4.41619933e-01f, 4.80419874e-01f, -2.89458513e-01f, 1.81495234e-01f, 9.03902128e-02f, -3.93896773e-02f, 3.06561768e-01f, 2.43843615e-01f, 1.37772173e-01f, 3.57423574e-01f,
  9.20939818e-02f, -6.17728457e-02f, -3.65921229e-01f, -1.70271054e-01f, 7.15293456e-03f, 8.75956416e-02f, -4.31634963e-01f, -2.26604983e-01f, -1.74746156e-01f, -1.02551684e-01f,
  -1.62559986e-01f, 6.40018508e-02f, -8.15121010e-02f, 2.58477144e-02f, 9.19233933e-02f, -5.81226274e-02f, 4.99297641e-02f, -8.16785470e-02f, 3.55423465e-02f, 6.15967251e-02f,
  1.05475716e-01f, 7.11469352e-02f, 8.95461515e-02f, -7.50245526e-02f, 1.69174775e-01f, 2.13663168e-02f, -2.68993434e-02f, -8.34017098e-02f, 2.65812147e-02f, -1.17396154e-02f,
  5.37432209e-02f, -5.95065542e-02f, 1.71642322e-02f, -1.76567882e-02f, -4.25492711e-02f, 3.52846496e-02f, 6.25645593e-02f, 2.53139567e-02f, -2.86088735e-02f, 1.21294469e-01f,
  -6.26642108e-02f, 4.53725532e-02f, -6.13826513e-02f, -1.97193418e-02f, 6.87351450e-02f, -1.21088177e-01f, 5.58116334e-03f, -1.10831477e-01f, 7.56357387e-02f, 2.41796095e-02f,
  8.05998743e-02f, -2.16375049e-02f, 3.69956903e-02f, 4.53874730e-02f, 2.28157435e-02f, 4.20574397e-02f, -9.51939262e-03f, 5.32564968e-02f, 6.36389777e-02f, -8.61068442e-02f,
  2.32647043e-02f, 6.42638505e-02f, -1.43607825e-01f, -8.52321535e-02f, 1.75443944e-02f, -9.13453405e-04f, 1.11560998e-02f, 2.74826232e-02f, -1.11070648e-01f, -1.96117893e-01f,
  1.20106585e-01f, 3.66775244e-01f, -9.19672102e-02f, -6.17388114e-02f, 1.04462979e-02f, 8.29589516e-02f, 6.65963888e-02f, 9.23264697e-02f, 5.25112636e-02f, 1.26765847e-01f,
  9.40828957e-03f, -1.53541230e-02f, -4.56226803e-03f, -8.55059847e-02f, 3.45730186e-02f, -3.92177552e-02f, -1.72358677e-02f, 1.34899942e-02f, -2.66234539e-02f, -5.49735799e-02f,
  -2.26379633e-02f, 7.96832964e-02f, 4.17297743e-02f, 1.67978369e-02f, -2.52223760e-02f, -1.10588543e-01f, 2.06617028e-01f, -1.62876863e-02f, -1.25339538e-01f, 1.58470664e-02f,
  -6.50323480e-02f, 1.64948761e-01f, -3.31702501e-01f, 1.48994818e-01f, -7.83298835e-02f, 2.70874309e-03f, 6.21118367e-01f, -3.59245837e-02f, -2.40303725e-01f, 5.01557946e-01f,
  5.98913431e-01f, -3.55875790e-02f, 5.61265409e-01f, 6.67203128e-01f, 1.56643391e-01f, 5.25779724e-01f, 2.20318258e-01f, 1.99389577e-01f, -3.72060776e-01f, 5.18696941e-02f,
  -9.12161395e-02f, 4.55337703e-01f, 3.15691441e-01f, -1.97955400e-01f, 4.90311950e-01f, -3.30988258e-01f, 4.59388137e-01f, 6.55151829e-02f, 4.43159156e-02f, 1.27844200e-01f,
  1.33398861e-01f, 1.84453309e-01f, -4.30772789e-02f, -1.79312944e-01f, 1.48153715e-02f, -6.05684705e-02f, -3.63803515e-03f, 1.01115815e-01f, -2.66454816e-02f, 3.53250951e-02f,
  1.07747808e-01f, -1.85367420e-01f, -7.95117989e-02f, -7.29388222e-02f, -6.31463900e-02f, -9.03710797e-02f, -8.57545882e-02f, -9.94900838e-02f, -9.83172730e-02f, 1.02873862e-01f,
  -4.81945351e-02f, -6.43112212e-02f, 1.72286436e-01f, -1.38222976e-02f, 5.49207777e-02f, 1.15959812e-02f, -5.59559949e-02f, 3.97720709e-02f, -1.47296265e-01f, -1.14520468e-01f,
  4.08362933e-02f, 9.76754725e-03f, 1.66572277e-02f, 1.00424722e-01f, -8.49390998e-02f, -6.41598031e-02f, 1.16534300e-01f, 7.24236742e-02f, 2.29962468e-02f, 1.81281507e-01f,
  -1.57317147e-01f, -1.24563292e-01f, 7.33521283e-02f, 1.46174639e-01f, 1.34231457e-02f, 5.49244583e-02f, 1.31522715e-01f, 1.02911167e-01f, -1.36513740e-01f, -6.74669817e-02f,
  -2.32453477e-02f, -6.62046000e-02f, 9.17964950e-02f, 7.63511062e-02f, 3.08436789e-02f, 1.82627246e-01f, 6.44906089e-02f, 6.89819828e-02f, 2.18873799e-01f, -4.55130152e-02f,
  7.40051717e-02f, 3.34571570e-01f, -6.05474822e-02f, 5.00075100e-03f, -1.24864774e-02f, 1.92135677e-03f, 2.73340233e-02f, 1.33101624e-02f, 7.95103461e-02f, -5.70659973e-02f,
  -9.90453176e-04f, -3.52655239e-02f, -1.17563836e-01f, 4.30866964e-02f, -1.55914381e-01f, 1.20079659e-01f, 1.87900588e-01f, -1.72697142e-01f, 3.75221260e-02f, 3.55659239e-02f,
  7.52000511e-02f, -3.46963778e-02f, -4.07961644e-02f, -1.37217101e-02f, -1.27975240e-01f, 1.40673384e-01f, -1.91272914e-01f, -6.86626732e-02f, 1.24848217e-01f, -7.22481757e-02f,
  -5.62918246e-01f, 5.82299650e-01f, -5.15431054e-02f, -5.07020712e-01f, 1.04671262e-01f, -1.02519222e-01f, -3.51131469e-01f, 5.52932993e-02f, -3.20857763e-01f, -1.05504684e-01f,
  -3.09027135e-01f, -2.04513654e-01f, 1.55062839e-01f, -1.86907127e-01f, -4.62558717e-02f, 3.12160581e-01f, -3.00911486e-01f, -3.29118460e-01f, 2.59675711e-01f, -2.81662196e-01f,
  1.09351464e-02f, -9.92839113e-02f, 1.67936943e-02f, 3.34121644e-01f, -7.13437051e-02f, 4.17021140e-02f, 3.20019834e-02f, 1.47332311e-01f, -1.66987374e-01f, 1.21537909e-01f,
  -3.50887328e-01f, -3.61579955e-01f, -4.48749334e-01f, 7.18752714e-03f, -1.81566045e-01f, -1.82858229e-01f, -1.34034157e-01f, -2.74841003e-02f, -1.01703539e-01f, 1.10854261e-01f,
  -1.09889910e-01f, 1.20907411e-01f, 1.70128909e-03f, 4.95515428e-02f, -1.79161757e-01f, 4.22399081e-02f, 1.63692892e-01f, -7.59759992e-02f, 7.58480234e-03f, 1.59691796e-01f,
  -6.31374121e-02f, 2.22981155e-01f, -2.25496609e-02f, 4.15279418e-02f, 6.69753253e-02f, -3.14007066e-02f, 1.71744414e-02f, -6.30533602e-03f, 1.61103293e-01f, -3.58363613e-02f,
  3.35634612e-02f, -1.99108332e-01f, -3.08816060e-02f, -4.01049592e-02f, 8.84365942e-03f, 6.35374784e-02f, -1.12386078e-01f, 2.20836904e-02f, 4.37643602e-02f, 5.29656745e-02f,
  4.87282593e-03f, 4.19880589e-03f, 1.00963406e-01f, -5.06838262e-02f, -9.05572101e-02f, 1.20971734e-02f, -4.67766151e-02f, 7.32032524e-04f, 1.05538785e-01f, 2.85451151e-02f,
  -1.08257525e-01f, -8.28289092e-02f, 3.59694064e-02f, 1.00843802e-01f, -1.02144718e-01f, 2.98660733e-02f, 7.52671286e-02f, 7.31772184e-02f, -2.40139272e-02f, 4.72123511e-02f,
  -4.10442382e-01f, -4.02977765e-01f, -1.51781470e-01f, 5.99183515e-02f, -5.84586523e-02f, -1.62423849e-02f, -2.89224442e-02f, 5.69105968e-02f, -5.06511591e-02f, -8.82509202e-02f,
  3.13740969e-02f, -1.07557036e-01f, 6.87437281e-02f, -3.13820504e-02f, -7.46993497e-02f, -4.72039878e-02f, -1.80068210e-01f, -6.68956414e-02f, -1.81173339e-01f, 1.25414640e-01f,
  -1.44068478e-02f, 1.41838081e-02f, -4.58525084e-02f, 6.87393695e-02f, 1.78658683e-02f, -2.81893406e-02f, -4.85706553e-02f, 1.29269063e-01f, 9.78812873e-02f, 1.55064734e-02f,
  2.55585611e-01f, 1.67402849e-02f, 1.26822785e-01f, 3.31456125e-01f, -4.84373987e-01f, -2.23191977e-01f, -4.04568501e-02f, -2.91648954e-01f, 4.60815340e-01f, -2.36509033e-02f,
  -2.85630465e-01f, 5.01223505e-01f, -1.03471754e-02f, -2.77636260e-01f, -4.22316715e-02f, 2.69997686e-01f, -2.90486198e-02f, 2.82904714e-01f, 5.04688770e-02f, 8.50090161e-02f,
  -1.54590504e-02f, -2.23053440e-01f, -3.00225198e-01f, -2.78029382e-01f, -1.85820669e-01f, -1.17272168e-01f, -4.26797181e-01f, -1.95173696e-01f, -1.99756473e-01f, -2.52365649e-01f,
  -2.62611687e-01f, -1.36108413e-01f, 2.91181337e-02f, 4.30403836e-02f, -1.29234735e-02f, 8.37471262e-02f, -8.75319727e-03f, -6.24882290e-03f, -1.38161093e-01f, -1.95227396e-02f,
  2.02471882e-01f, -1.04285054e-01f, 2.73513533e-02f, -6.03976473e-03f, -1.80588607e-02f, -2.40547536e-03f, 7.54665881e-02f, -3.80186215e-02f, -8.41692537e-02f, -2.14805081e-02f,
  9.85103920e-02f, 4.64732014e-02f, -4.12512869e-02f, 1.41947959e-02f, -3.14905718e-02f, -1.81064215e-02f, 1.02338843e-01f, -5.36707342e-02f, 1.40947163e-01f, -2.25932840e-02f,
  -2.66045183e-02f, -5.37240990e-02f, -1.04233190e-01f, -2.46489160e-02f, -9.85940397e-02f, -1.06453680e-01f, 1.60618246e-01f, -6.15777075e-02f, 9.34250876e-02f, -1.40226573e-01f,
  -2.28561446e-01f, -1.42784610e-01f, 2.44187210e-02f, 1.14183262e-01f, -8.47964175e-03f, 1.74036980e-01f, 2.75785848e-02f, -5.71888722e-02f, 1.95485234e-01f, 5.05184904e-02f,
  -4.03581373e-02f, -9.83241647e-02f, 5.64488359e-02f, -1.94132309e-02f, -2.99971625e-02f, 9.94288623e-02f, -2.79991068e-02f, 4.26835194e-02f, 1.22979872e-01f, -8.32044110e-02f,
  -1.70044750e-01f, -4.12442461e-02f, -4.27826447e-03f, 3.15932147e-02f, 8.36813301e-02f, -2.28104163e-02f, 1.19177382e-02f, 6.35643229e-02f, -1.24340504e-02f, 1.07027031e-01f,
  1.05752535e-01f, -1.49403531e-02f, -1.46768307e-02f, -1.00539893e-01f, 1.01466335e-01f, -7.37723261e-02f, 1.20866112e-02f, 5.82324341e-02f, -7.54269511e-02f, -1.08229451e-01f,
  -4.77902545e-03f, 5.24625182e-02f, 3.01359105e-03f, -6.12667575e-03f, 5.77719025e-02f, 9.30278189e-03f, 1.67691544e-01f, -1.46971745e-02f, -1.61599386e-02f, 1.75538566e-02f,
  4.44101274e-01f, -1.58665389e-01f, 2.06821300e-02f, 4.19431597e-01f, 9.29073319e-02f, -1.23492209e-02f, 5.28890848e-01f, 2.57531330e-02f, 2.48218045e-01f, -4.41925451e-02f,
  -1.67512193e-01f, 2.76853800e-01f, 2.15417266e-01f, 7.61223286e-02f, 5.36404908e-01f, 2.46138170e-01f, 2.14231133e-01f, -1.14979684e-01f, 1.20092869e-01f, 2.31272444e-01f,
  1.89002827e-01f, 2.29143962e-01f, 1.59426078e-01f, -3.76308143e-01f, 1.11438386e-01f, -1.40627742e-01f, 1.48033798e-01f, -1.34148672e-01f, -4.28062171e-01f, 2.99855713e-02f,
  -3.04967333e-02f, 2.15831459e-01f, -8.23101848e-02f, -1.24612218e-02f, 5.65188937e-03f, -2.14634035e-02f, -3.04690916e-02f, 2.16959743e-03f, 5.13148196e-02f, 4.50695567e-02f,
  5.62211946e-02f, 2.04739179e-02f, 1.32537792e-02f, 2.22150218e-02f, 2.40381062e-03f, -1.08564481e-01f, -7.23865852e-02f, -1.45295829e-01f, 5.42059131e-02f, -2.49388181e-02f,
  -1.14610136e-01f, -1.38307676e-01f, 1.57675892e-02f, -9.00696740e-02f, 1.10984266e-01f, 3.32860127e-02f, -9.89804417e-02f, 2.37642732e-02f, 3.62180658e-02f, 1.80761665e-01f,
  1.51947096e-01f, -2.49846857e-02f, 1.00706063e-01f, -3.55658308e-02f, 3.73307988e-02f, 2.76650675e-02f, -2.58234665e-02f, -3.98678146e-02f, -6.21397831e-02f, 1.66855305e-02f,
  -2.81168744e-02f, -2.95567047e-03f, -9.47659556e-03f, -2.26136949e-02f, 1.46024466e-01f, -5.63341342e-02f, 2.24296208e-02f, -5.84329627e-02f, -3.08152661e-02f, -3.51140983e-02f,
  6.68435320e-02f, 2.48798896e-02f, -1.01557877e-02f, -1.19026385e-01f, -1.03246056e-01f, 1.43405274e-01f, 8.93625692e-02f, -2.06104107e-02f, -4.62126918e-02f, 6.56852648e-02f,
  6.11925730e-03f, 3.36292624e-01f, -2.52471026e-02f, -1.68348357e-01f, -9.59985405e-02f, -7.11076707e-02f, 3.31468582e-02f, 1.01555042e-01f, 2.33885095e-01f, 7.24735260e-02f,
  4.54509482e-02f, -4.08980995e-02f, -1.04139708e-01f, -1.57711003e-02f, -1.01160169e-01f, 2.07590520e-01f, 1.55331418e-01f, 3.27202082e-02f, 1.30782396e-01f, -1.09464958e-01f,
  -4.26732823e-02f, 7.76140019e-02f, 3.70537452e-02f, 1.16767259e-02f, 3.96451913e-03f, 1.27680821e-03f, 4.89017442e-02f, -1.16938025e-01f, 4.15528379e-02f, -1.52057158e-02f,
  6.60586059e-02f, 3.24207366e-01f, 1.42654508e-01f, 2.60086894e-01f, -1.43553182e-01f, -5.94318390e-01f, -4.68607247e-01f, -5.18959984e-02f, 5.31242266e-02f, 1.74083591e-01f,
  -1.58138856e-01f, 2.78681964e-01f, -2.96541341e-02f, -2.42237091e-01f, -6.29190564e-01f, -4.81609970e-01f, -1.76399723e-01f, -1.78958297e-01f, -5.61770611e-02f, 3.15764248e-01f,
  5.23274802e-02f, -3.32456410e-01f, 6.29181489e-02f, 1.88843295e-01f, 1.96408499e-02f, 3.95127475e-01f, 3.33522707e-01f, 9.37790200e-02f, 2.36107424e-01f, -2.68045872e-01f,
  -2.12835625e-01f, 1.20158151e-01f, 9.27137807e-02f, -1.85873788e-02f, 5.54913059e-02f, -1.45830577e-02f, 4.24922630e-02f, -1.38883501e-01f, -4.82109599e-02f, -1.61927603e-02f,
  1.22337520e-01f, -6.97605908e-02f, -1.47984689e-02f, -9.54827107e-03f, -1.13847069e-01f, 9.87045616e-02f, 1.01126410e-01f, 1.04672700e-01f, 3.89229544e-02f, 1.21432822e-02f,
  1.08752996e-01f, 3.08575742e-02f, 1.15770265e-01f, 1.16881527e-01f, 1.70807600e-01f, -8.67673755e-02f, -4.12566364e-02f, 5.85831776e-02f, 1.37590125e-01f, -9.27984901e-03f,
  6.28493950e-02f, -4.02546823e-02f, -4.80561517e-02f, -1.50688186e-01f, -3.91101576e-02f, 9.32698473e-02f, 3.18147335e-03f, 4.10971195e-02f, 4.52654846e-02f, 2.64456403e-03f,
  -1.81020815e-02f, 7.92075768e-02f, -1.15333162e-01f, -1.93254836e-02f, 9.97772366e-02f, 7.00520650e-02f, -1.01979887e-02f, 8.12102407e-02f, 8.59897286e-02f, 5.76978363e-02f,
  -2.38283742e-02f, -7.32587129e-02f, 3.76557074e-02f, 5.89540191e-02f, -2.32142285e-01f, 1.00278676e-01f, 7.11344630e-02f, 2.76752263e-02f, -8.31895918e-02f, 4.10491191e-02f,
  9.13157240e-02f, 3.40892226e-01f, 7.51291141e-02f, 4.16312218e-02f, -4.89985012e-02f, -7.36563653e-02f, -1.32421136e-01f, 1.11221910e-01f, 2.35852394e-02f, -6.50231093e-02f,
  4.07794192e-02f, 2.12283470e-02f, 9.38022956e-02f, -3.96686457e-02f, 3.82638583e-03f, -1.02640865e-02f, 6.35311976e-02f, 1.24076687e-01f, 1.39378518e-01f, 1.62647292e-01f,
  2.16323748e-01f, 7.55563669e-04f, -5.34644350e-02f, 1.42409857e-02f, 1.03669740e-01f, 1.13627449e-01f, -1.41167175e-02f, -1.50714852e-02f, 1.32456034e-01f, 7.27623701e-02f,
  -5.54631092e-02f, 2.29247943e-01f, 3.74912888e-01f, -4.62090045e-01f, -6.07666895e-02f, -1.09579936e-01f, -1.80915967e-01f, -2.64987856e-01f, -2.84727603e-01f, -2.09074646e-01f,
  -4.74590153e-01f, 5.25497973e-01f, 2.53147602e-01f, -4.21983719e-01f, -5.65056875e-02f, -8.66955742e-02f, -5.00805140e-01f, -5.04536703e-02f, 9.37190428e-02f, -1.12593830e-01f,
  -1.10042907e-01f, -6.04469776e-01f, -1.30039677e-01f, -4.07894790e-01f, -5.20403236e-02f, 5.45590334e-02f, -3.94468844e-01f, 2.46235058e-01f, -2.25657731e-01f, 6.34429976e-03f,
  4.26736213e-02f, -3.25886160e-01f, 2.07286879e-01f, 6.58917287e-03f, -1.66287333e-01f, 8.44632685e-02f, 2.21797243e-01f, 1.67916849e-01f, 1.32196816e-02f, 5.19729815e-02f,
  1.76446602e-01f, 8.05976093e-02f, -6.94002360e-02f, 1.33278519e-01f, 6.49315342e-02f, -3.22808512e-02f, 7.58916885e-02f, 9.23195183e-02f, 1.88833982e-01f, 7.13284537e-02f,
  1.41728427e-02f, 1.82384610e-01f, -1.75094292e-01f, 3.84231992e-02f, 1.80634782e-02f, -1.45479277e-01f, 1.33824825e-01f, 3.61270159e-01f, 3.83073837e-02f, -3.62532772e-02f,
  4.15257104e-02f, -7.22253993e-02f, 1.33007124e-01f, -2.60304078e-04f, -1.68776870e-01f, -4.68504056e-03f, 3.06638200e-02f, -3.08150481e-02f, -9.99902412e-02f, 3.50738242e-02f,
  -4.85209376e-02f, 1.73541829e-01f, -9.92085859e-02f, -2.05627516e-01f, -8.74818042e-02f, -1.31132960e-01f, 1.55995414e-01f, 4.47785389e-03f, 5.79406433e-02f, -1.71673708e-02f,
  -1.11815900e-01f, -4.91517708e-02f, -3.30374427e-02f, -2.18736045e-02f, 1.40268160e-02f, 3.11408434e-02f, -2.45492090e-03f, 1.67492509e-01f, -1.28160417e-01f, 2.88149882e-02f,
  -1.03130110e-01f, -5.25692999e-01f, -1.16931401e-01f, 7.49274418e-02f, 3.45208570e-02f, 1.20347954e-01f, -5.22346422e-02f, -1.86003223e-01f, -1.56218521e-02f, -1.48331940e-01f,
  -1.48757085e-01f, 4.11315411e-02f, -2.15731841e-03f, 1.97210126e-02f, -4.86897677e-03f, -8.59776065e-02f, -7.74429068e-02f, 2.91050095e-02f, -7.51926899e-02f, -4.33264412e-02f,
  -1.84569359e-01f, -6.49678856e-02f, 9.29891542e-02f, 1.29034799e-02f, -5.19017838e-02f, -1.04492389e-01f, -1.26694394e-02f, 3.81782800e-02f, 2.17389911e-01f, -5.71656227e-03f,
  4.27941233e-02f, -2.05355063e-01f, -6.19048141e-02f, 4.89511013e-01f, -1.63539813e-03f, -1.34845562e-02f, 4.78555292e-01f, 4.33666781e-02f, 4.01432633e-01f, 1.26358256e-01f,
  8.09359029e-02f, -1.66448504e-01f, 2.50570357e-01f, -2.14523554e-01f, -5.31524181e-01f, -2.42849380e-01f, 1.14682857e-02f, 1.13846727e-01f, 2.45565757e-01f, 2.27576166e-01f,
  -4.30913121e-02f, -2.00654522e-01f, -3.07429999e-01f, -1.50035679e-01f, -9.02425647e-02f, 2.76069760e-01f, -3.20899248e-01f, 2.32362017e-01f, -2.19023198e-01f, -2.06596524e-01f,
  6.16629682e-02f, 4.01303433e-02f, -1.95280924e-01f, -5.79538792e-02f, 1.53520897e-01f, 5.21193333e-02f, 1.22461885e-01f, -1.18438013e-01f, -9.49845463e-02f, 9.10568535e-02f,
  1.66155502e-01f, -1.18012048e-01f, -3.34559903e-02f, -6.76330477e-02f, 1.07211769e-01f, -5.85526414e-02f, 1.41049281e-01f, 6.95593283e-02f, -2.16186106e-01f, -1.08404130e-01f,
  4.48922738e-02f, 1.13597453e-01f, 1.17302448e-01f, 9.47937369e-03f, -1.09059669e-01f, 8.85733515e-02f, 2.05516666e-02f, -7.98147619e-02f, 3.06499172e-02f, -1.63632825e-01f,
  -8.91243219e-02f, -6.48131296e-02f, 5.22306412e-02f, 3.24837901e-02f, 1.73222963e-02f, 1.87804233e-02f, 2.30472721e-03f, -6.65158257e-02f, 2.47011796e-01f, -7.01969340e-02f,
  1.04369022e-01f, -1.32368859e-02f, 1.22424692e-01f, 3.30970320e-03f, 8.88487995e-02f, 1.81349725e-01f, -4.59474325e-02f, 9.58056971e-02f, 3.11867863e-01f, -1.09070294e-01f,
  5.09690819e-03f, -8.62374380e-02f, -6.38543442e-02f, 4.58370149e-02f, -4.06802185e-02f, 1.18959218e-01f, 7.98099861e-03f, 5.50890826e-02f, 1.26123196e-02f, 2.00184762e-01f,
  1.20760836e-02f, 1.44459352e-01f, 2.10493784e-02f, 4.84072343e-02f, 8.08614641e-02f, -1.56436354e-01f, -2.70488225e-02f, -1.50095358e-01f, -6.90039620e-02f, 7.81950168e-03f,
  9.91941616e-02f, 2.20183358e-01f, 1.15233704e-01f, -6.81232139e-02f, -3.43659557e-02f, -1.68662682e-01f, 2.05367535e-01f, 1.54758155e-01f, -5.96854091e-02f, -9.83034670e-02f,
  -2.52577080e-03f, 1.62523106e-01f, -5.31395115e-02f, 1.66532159e-01f, -1.21212928e-02f, -1.55227603e-02f, -8.44543204e-02f, -9.19771567e-02f, 9.91146341e-02f, 5.08969538e-02f,
  3.21309417e-01f, -4.00915951e-01f, -1.12435095e-01f, -3.00487131e-01f, 5.78384846e-02f, -8.56028125e-02f, -2.32004404e-01f, -3.74791831e-01f, -4.84264284e-01f, -2.23852336e-01f,
  -4.49464649e-01f, -2.01228768e-01f, 2.18593299e-01f, -4.46973354e-01f, 3.71657193e-01f, -1.02991186e-01f, -2.26073116e-01f, -3.23672742e-01f, -1.19263001e-01f, -3.22731942e-01f,
  -3.28847587e-01f, -5.66000521e-01f, -1.80470213e-01f, -3.23579311e-01f, -2.54761100e-01f, -1.49496660e-01f, 3.18565547e-01f, -3.12313493e-02f, -2.52270073e-01f, -2.37963676e-01f,
  -1.11635536e-01f, -1.62575781e-01f, -2.01783642e-01f, -1.36839807e-01f, 3.29200812e-02f, 1.59392789e-01f, 2.03132227e-01f, 1.20009296e-02f, -9.49882530e-03f, -7.68492883e-03f,
  1.66004315e-01f, -6.06539547e-02f, -9.09943357e-02f, -5.72189502e-03f, 3.13512497e-02f, -1.78061664e-01f, -3.79472524e-02f, 1.17532052e-02f, -5.53864948e-02f, -5.94309438e-03f,
  -4.32523675e-02f, 2.30434164e-01f, 2.16611810e-02f, 1.04119942e-01f, -1.12442113e-02f, 2.17871610e-02f, 1.05997689e-01f, 1.46301895e-01f, 9.16120037e-02f, -2.32796874e-02f,
  -5.10562360e-02f, 1.35572523e-01f, -5.46420785e-03f, -6.84712082e-02f, -6.87475502e-03f, -9.68545303e-02f, 1.01468869e-01f, -7.82774985e-02f, -1.44040901e-02f, 2.21904460e-02f,
  1.61669869e-02f, 9.95535776e-03f, -1.83224067e-01f, -6.95548486e-03f, 1.48601145e-01f, 1.11509211e-01f, -1.39595062e-01f, 9.84372646e-02f, -9.15613919e-02f, 1.06634334e-01f,
  -8.27720091e-02f, 5.80226034e-02f, -1.85914531e-01f, 1.42600179e-01f, 6.93039447e-02f, -3.22107673e-02f, -1.40643448e-01f, 1.33725196e-01f, 4.97541716e-03f, 8.60635489e-02f,
  6.34692833e-02f, -8.68871287e-02f, -2.06825480e-01f, -1.34571746e-01f, -2.39399839e-02f, 6.57069385e-02f, 1.64160237e-03f, -4.09970619e-02f, -7.78319016e-02f, -5.18630538e-03f,
  -1.95174217e-02f, 2.06492245e-02f, 2.40800053e-01f, -9.12419632e-02f, -1.40364081e-01f, -2.63626814e-01f, 3.79435681e-02f, -8.64800364e-02f, 7.17472956e-02f, 5.30640110e-02f,
  6.60896078e-02f, 1.76017940e-01f, 9.17019099e-02f, 5.12178242e-02f, -2.30573993e-02f, 2.64604658e-01f, 9.56948102e-02f, -1.45348668e-01f, 1.70069918e-01f, 2.93457434e-02f,
  3.00684065e-01f, -2.66098350e-01f, -4.83594835e-01f, -3.73202354e-01f, -2.75199890e-01f, -3.61217484e-02f, 2.37571672e-02f, -1.59244671e-01f, -4.81996052e-02f, 2.00415313e-01f,
  1.01056257e-02f, 5.25908321e-02f, 3.95569235e-01f, -6.50519207e-02f, 3.65404159e-01f, 4.93828028e-01f, 1.56408519e-01f, 1.00250304e-01f, -4.00351286e-02f, -1.37667045e-01f,
  7.90343657e-02f, 2.02111244e-01f, -1.14381559e-01f, -1.86319664e-01f, -2.11447790e-01f, -3.89728814e-01f, -7.33718202e-02f, -3.48536432e-01f, -2.67064780e-01f, -8.56552646e-02f,
  1.51287377e-01f, 4.68267277e-02f, -6.30756617e-02f, 5.26570044e-02f, -1.20624542e-01f, -9.60895047e-02f, -1.78848892e-01f, -1.18148424e-01f, 6.84396829e-03f, 1.65892486e-02f,
  7.71880671e-02f, 2.23698065e-01f, -1.38210095e-02f, 1.03901148e-01f, -7.81218857e-02f, -1.06351778e-01f, -6.65627001e-03f, 8.32836404e-02f, -8.68762359e-02f, 1.53350279e-01f,
  2.83442978e-02f, -6.26598224e-02f, -5.55471219e-02f, 4.29236144e-02f, -1.38530299e-01f, -7.17228726e-02f, 5.02197444e-02f, -8.56697559e-02f, 1.19540403e-02f, -3.04773264e-03f,
  -7.44314566e-02f, 5.31766787e-02f, 7.66793489e-02f, 4.00670469e-02f, 6.06257878e-02f, -4.35188673e-02f, 5.36537990e-02f, -1.97378919e-02f, -5.64909726e-02f, 5.32138497e-02f,
  1.16320355e-02f, -1.74195506e-02f, 1.44452691e-01f, 3.25653292e-02f, 6.17314391e-02f, 7.98174888e-02f, -1.02106435e-02f, -8.26995913e-03f, -1.17400967e-01f, -7.81677142e-02f,
  -5.23860119e-02f, 6.37885034e-02f, 7.66653419e-02f, -9.59227830e-02f, -5.50570972e-02f, 4.88487296e-02f, 1.13122836e-01f, 8.29567984e-02f, -5.18522002e-02f, 1.40619958e-02f,
  -8.42157565e-03f, -4.84233238e-02f, 8.05289522e-02f, 1.75654031e-02f, -8.52211267e-02f, 6.61042333e-02f, -4.53811139e-02f, -2.09658854e-02f, 4.33561541e-02f, -6.88726548e-04f,
  -1.17312238e-01f, 1.88902076e-02f, -9.01748240e-02f, -3.89484479e-03f, -5.93132824e-02f, 4.14217561e-02f, 1.72047261e-02f, 8.94356519e-02f, -1.35946363e-01f, -6.86465427e-02f,
  -1.38308108e-01f, 1.40860781e-01f, 7.01316074e-02f, 6.44250736e-02f, -1.99018329e-01f, 6.39781207e-02f, -1.22323662e-01f, -6.16777204e-02f, -1.65095031e-02f, -3.66671383e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 40)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 40;
const float L0_fan_Bp_bar_data[] = {
  5.08562326e-01f, 3.92362148e-01f, 5.79423130e-01f, 5.28545141e-01f, 4.73091185e-01f, 4.37882900e-01f, 4.83223677e-01f, 4.66790468e-01f, 4.08275694e-01f, 5.30688703e-01f,
  4.86801445e-01f, 5.94489157e-01f, 5.24538815e-01f, 4.59442586e-01f, 3.05931926e-01f, 5.12657344e-01f, 6.24500662e-02f, 4.77968752e-01f, 3.00002694e-01f, 3.32534790e-01f,
  3.84313524e-01f, 4.92810488e-01f, 3.17628711e-01f, 4.62828517e-01f, 3.87755066e-01f, 3.03995848e-01f, 4.39406216e-01f, 5.46692908e-01f, 4.01503146e-01f, 3.99977207e-01f,
  4.57295001e-01f, 4.37356383e-01f, 4.10288066e-01f, 5.29637456e-01f, 6.64311767e-01f, 5.75598955e-01f, 6.86951816e-01f, 4.86092567e-01f, 4.17027652e-01f, 3.17965835e-01f
};

// L1_linear_W (Shape: 12 x 64)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 64;
const float L1_linear_W_data[] = {
  3.90188806e-02f, -7.03369407e-03f, -3.95256817e-01f, -5.12017570e-02f, -1.24401040e-01f, -3.88764381e-01f, -1.69519737e-01f, 2.20534071e-01f, 3.97200026e-02f, 8.39823112e-03f,
  -4.37779099e-01f, -1.60179093e-01f, 8.86444002e-02f, -6.05331421e-01f, 3.11893493e-01f, -1.79130137e-01f, -2.09137425e-01f, 3.95303071e-01f, 1.65331513e-01f, 2.57497877e-02f,
  3.40885460e-01f, -2.21877307e-01f, 3.85699004e-01f, -1.45867020e-01f, -3.37859303e-01f, -1.41438335e-01f, -3.83610427e-01f, -9.21346620e-03f, -6.96972072e-01f, -5.57618797e-01f,
  -2.27622136e-01f, 4.75246578e-01f, -7.52844959e-02f, -4.58843350e-01f, -1.42686561e-01f, 2.53428966e-01f, -9.30243433e-02f, -1.02811456e-01f, 4.51791555e-01f, -5.51367223e-01f,
  1.36692360e-01f, -3.00735176e-01f, 6.20419681e-01f, 3.91401321e-01f, 1.84392631e-01f, -1.83438286e-01f, 5.90614855e-01f, -3.66091102e-01f, -4.97307181e-02f, -2.72017241e-01f,
  2.45335206e-01f, 2.43297875e-01f, -5.62811971e-01f, -6.32713497e-01f, -7.69467950e-01f, 4.60516721e-01f, -2.50962138e-01f, -8.62690657e-02f, -3.52623492e-01f, -4.47655708e-01f,
  -6.34080946e-01f, 1.22421324e-01f, -5.82902312e-01f, 2.21629545e-01f, 1.88301895e-02f, 8.52630064e-02f, 3.74804795e-01f, 1.39363483e-01f, 2.74177879e-01f, 2.34118089e-01f,
  5.73306307e-02f, -6.05443940e-02f, -8.53371620e-02f, 2.77873397e-01f, 3.19910169e-01f, -3.99501890e-01f, -4.86854553e-01f, -2.59794872e-02f, 1.13426022e-01f, -5.57178617e-01f,
  -2.89098948e-01f, -4.11038429e-01f, 2.80044287e-01f, -3.53357136e-01f, 2.54331559e-01f, 4.77889299e-01f, -5.83493710e-02f, -4.48603570e-01f, -9.35869887e-02f, -5.29303014e-01f,
  -6.04006588e-01f, -5.94398379e-01f, 4.12479818e-01f, 4.59451556e-01f, -1.38185859e-01f, 3.91155601e-01f, -4.75699157e-01f, -4.23969299e-01f, -2.09355354e-01f, -7.14121222e-01f,
  5.08972883e-01f, 1.82660490e-01f, 7.98323657e-03f, -3.50872785e-01f, -4.06861484e-01f, 3.94562632e-01f, -5.78777373e-01f, -6.15590751e-01f, -4.63348359e-01f, -5.45405269e-01f,
  -6.92674994e-01f, -6.01424634e-01f, -5.63205123e-01f, -5.02500713e-01f, 2.47476861e-01f, 4.43700254e-01f, -2.59752065e-01f, -2.94320732e-01f, 7.07139522e-02f, 4.58782196e-01f,
  -5.48335761e-02f, -7.61745334e-01f, 2.05307677e-01f, -5.86783469e-01f, -1.65839881e-01f, -5.43185472e-01f, 1.96554527e-01f, 3.61886412e-01f, -1.32271171e-01f, -6.50222134e-03f,
  -2.73788244e-01f, -2.65006632e-01f, -4.98319529e-02f, -2.92209655e-01f, 5.31594306e-02f, -1.31093413e-01f, -1.20377854e-01f, -6.39961436e-02f, -1.11350052e-01f, 2.29921669e-01f,
  -2.19383433e-01f, 1.87287301e-01f, 1.20440744e-01f, -3.08684945e-01f, -2.39197731e-01f, -2.24916503e-01f, -2.71216363e-01f, -2.28852868e-01f, 1.40836373e-01f, -1.63690597e-02f,
  -1.31737530e-01f, 2.92458117e-01f, -3.01802814e-01f, -4.30255920e-01f, -6.27913058e-01f, -2.97482222e-01f, 4.35070723e-01f, 4.48389649e-01f, -9.19915065e-02f, -8.77602994e-02f,
  -2.13413641e-01f, -4.10537481e-01f, -9.42514762e-02f, -3.05692524e-01f, -2.04891846e-01f, -1.06307745e-01f, 4.45990622e-01f, 2.49756545e-01f, -2.73886979e-01f, -3.92683089e-01f,
  -3.69729757e-01f, 4.12140727e-01f, -4.67448413e-01f, 5.27124584e-01f, -4.04351652e-01f, 6.55810952e-01f, 5.04859209e-01f, -1.00097917e-01f, -4.91931230e-01f, 4.47693110e-01f,
  2.02211868e-02f, -2.13315219e-01f, -2.87464261e-01f, -7.47110903e-01f, -1.40879169e-01f, -3.08938920e-01f, -4.37134415e-01f, -4.36389744e-01f, -3.13306510e-01f, -5.12977600e-01f,
  -6.09373569e-01f, -9.10160542e-02f, -1.75500795e-01f, -3.29654455e-01f, -1.37826741e-01f, -3.93569432e-02f, 3.11162304e-02f, 2.86815614e-01f, -6.17148951e-02f, -4.22752261e-01f,
  -8.55076462e-02f, 1.40742317e-01f, -2.38325775e-01f, -1.48200154e-01f, 2.30324835e-01f, -3.15305203e-01f, -4.86157924e-01f, -3.22497308e-01f, 1.94340259e-01f, -3.71221229e-02f,
  2.30510145e-01f, 2.65608951e-02f, 2.85623640e-01f, 3.60692769e-01f, 1.98183492e-01f, 2.19514482e-02f, 1.50290519e-01f, 4.12277550e-01f, -5.71675599e-01f, -4.32735920e-01f,
  -4.36877161e-01f, -1.25033960e-01f, 3.33631486e-01f, -5.68504035e-01f, -7.62886703e-02f, -1.95656285e-01f, -5.94248950e-01f, 3.75500560e-01f, -4.77871031e-01f, -3.69145811e-01f,
  -3.71638715e-01f, -1.03374042e-01f, 7.19002903e-01f, -4.94881719e-01f, 1.71452954e-01f, -3.71312022e-01f, 3.30384523e-01f, -3.51588726e-01f, 2.88250893e-01f, -4.86998677e-01f,
  -1.72468737e-01f, 4.33707982e-01f, -6.71319723e-01f, -7.60304451e-01f, -3.86881679e-01f, 5.43008685e-01f, -2.99931616e-01f, 9.03898999e-02f, 3.57383519e-01f, -1.53573364e-01f,
  -7.71590546e-02f, 6.75185025e-02f, 1.21895254e-01f, 1.56683818e-01f, -7.68006384e-01f, -3.97635609e-01f, 4.93416935e-02f, 5.08089900e-01f, 4.76089984e-01f, 2.89983362e-01f,
  -3.79345641e-02f, -2.28938848e-01f, 2.94122137e-02f, 1.96443200e-01f, 4.14018244e-01f, -4.26897686e-03f, 1.10456556e-01f, 2.27766618e-01f, 1.87231049e-01f, 3.10118288e-01f,
  2.15668425e-01f, 3.25318784e-01f, -2.77907878e-01f, 4.66495544e-01f, 3.67459089e-01f, 7.96993732e-01f, -1.40788719e-01f, -2.48377129e-01f, 5.33241808e-01f, -4.06832427e-01f,
  -1.12620518e-01f, -2.08816528e-02f, 5.75989604e-01f, -8.83464292e-02f, 3.24131280e-01f, -3.63138437e-01f, 2.90596962e-01f, -4.70239878e-01f, -1.76384911e-01f, 2.80026883e-01f,
  2.91507810e-01f, 2.10898668e-01f, 1.13004528e-01f, -1.34883061e-01f, -1.94666415e-01f, 2.39382088e-01f, -5.78468859e-01f, -2.72786707e-01f, -8.91419649e-02f, 1.66900069e-01f,
  5.01486123e-01f, -8.11037302e-01f, 1.38720304e-01f, 1.65013224e-01f, -3.66740733e-01f, 2.53496140e-01f, 3.78185362e-01f, -1.20350137e-01f, 4.08171356e-01f, -1.31513461e-01f,
  -4.18133497e-01f, -4.18946594e-01f, 5.05446136e-01f, -4.98311460e-01f, -7.47938871e-01f, -7.87007809e-01f, 1.49064496e-01f, -5.78871846e-01f, -2.66334191e-02f, -1.17720798e-01f,
  2.82009840e-01f, 7.31069818e-02f, 2.66276882e-03f, 1.45270452e-02f, 1.28166482e-01f, 1.19936936e-01f, 1.60131171e-01f, 1.04930528e-01f, 1.56246260e-01f, 8.51422548e-02f,
  1.41376793e-01f, 2.90820748e-01f, 3.36952239e-01f, 6.30326033e-01f, 2.86745101e-01f, 5.48699498e-01f, 6.04360104e-01f, 2.44527310e-01f, -4.30739820e-01f, -4.59742695e-01f,
  -1.94257110e-01f, -4.78644043e-01f, 8.02172497e-02f, -4.02363002e-01f, -4.78445083e-01f, 4.12149101e-01f, 2.33423665e-01f, 3.67782801e-01f, -4.84824628e-01f, -7.14577317e-01f,
  -6.23879731e-01f, 2.69541800e-01f, -4.35858935e-01f, -5.54649472e-01f, -5.60407043e-01f, -5.52298188e-01f, -3.66541952e-01f, 3.95033300e-01f, -4.70382631e-01f, -3.55929658e-02f,
  -2.81199098e-01f, 3.64956319e-01f, -1.76597103e-01f, -4.20242578e-01f, 1.11528940e-01f, 3.48551013e-02f, 1.39914542e-01f, 4.68227476e-01f, -3.94294798e-01f, 1.18716791e-01f,
  5.28295159e-01f, -3.94701332e-01f, -4.22221243e-01f, 2.99978733e-01f, 5.91125369e-01f, -2.79505402e-01f, -5.42564511e-01f, 4.58627552e-01f, 2.61838794e-01f, -1.11497253e-01f,
  -4.34482425e-01f, 3.18188965e-01f, -2.69612849e-01f, 1.34515896e-01f, 2.14516502e-02f, -2.04820901e-01f, -7.43675753e-02f, 3.22043002e-02f, 4.16307636e-02f, -5.01856320e-02f,
  -4.61793020e-02f, -2.81053096e-01f, -3.58512029e-02f, 2.83804219e-02f, 6.73407093e-02f, 1.49069294e-01f, -6.51966274e-01f, 2.80722469e-01f, -1.39739782e-01f, 6.53876364e-02f,
  -2.74598956e-01f, -2.14523226e-01f, -5.01051605e-01f, -3.90421115e-02f, -4.49454546e-01f, 4.61821914e-01f, -3.42916638e-01f, 3.52530003e-01f, 1.85377765e-02f, 4.20519590e-01f,
  3.94230187e-01f, -7.82122552e-01f, -4.65966851e-01f, 5.08290708e-01f, -6.02820098e-01f, -3.63639355e-01f, 7.12493062e-01f, -1.94317847e-01f, 3.94361824e-01f, -1.35439202e-01f,
  -3.85023087e-01f, -2.07346886e-01f, -4.08215195e-01f, 4.19795603e-01f, 1.09811507e-01f, 4.27691579e-01f, -4.62087005e-01f, -2.41352499e-01f, -6.94692791e-01f, -5.49481623e-02f,
  -3.63433540e-01f, -3.26696217e-01f, 5.93692243e-01f, -3.54159147e-01f, -3.13477218e-01f, -4.38331038e-01f, 4.53271925e-01f, -6.89576566e-02f, 2.83523649e-01f, -5.50218761e-01f,
  -9.50478539e-02f, 1.06510922e-01f, 1.37559548e-01f, -2.94089317e-01f, -6.81040883e-01f, 3.97305250e-01f, -3.58502626e-01f, -1.19605504e-01f, -1.81296930e-01f, 8.89308844e-03f,
  -2.93425061e-02f, -1.26628503e-01f, -3.24280411e-01f, -1.67396709e-01f, -2.63931721e-01f, -1.54235482e-01f, -4.43327338e-01f, -2.67868459e-01f, 1.17081068e-01f, -2.06286684e-01f,
  -1.16586611e-01f, 1.60481408e-01f, 2.61331648e-01f, 3.85253668e-01f, 3.57323378e-01f, 1.94831073e-01f, -5.34888208e-01f, 2.54633695e-01f, -3.82571101e-01f, -2.65553921e-01f,
  -5.90565920e-01f, 2.71027356e-01f, 1.24987038e-02f, -2.13389069e-01f, -2.71247402e-02f, -1.69001117e-01f, 9.88570973e-03f, -4.16517109e-01f, -6.28751338e-01f, -4.45553899e-01f,
  -2.34430760e-01f, -3.79441530e-02f, -3.22863191e-01f, 1.13649912e-01f, -3.17689717e-01f, -1.78041726e-01f, -4.49268073e-01f, -4.25923049e-01f, 3.23235303e-01f, -1.84155211e-01f,
  2.63834924e-01f, -3.55475962e-01f, -2.42794380e-01f, 8.26658159e-02f, 2.11434737e-01f, -1.14993736e-01f, 5.49849987e-01f, 2.87661314e-01f, -1.90530792e-01f, -1.70501377e-02f,
  -3.09738815e-01f, 2.32971847e-01f, -4.47335929e-01f, -4.10444081e-01f, 3.12272817e-01f, 3.66416305e-01f, 3.96969803e-02f, 6.29382282e-02f, 3.22525322e-01f, -4.09794807e-01f,
  4.42754865e-01f, 3.34912658e-01f, -3.19911689e-01f, -1.21665396e-01f, -1.91072732e-01f, 4.10680473e-02f, -5.85166886e-02f, 2.52800249e-02f, 4.87059914e-02f, 1.36018068e-01f,
  -2.97415227e-01f, -2.51344908e-02f, -1.63831547e-01f, 5.07450625e-02f, -2.90811568e-01f, -4.06128824e-01f, -3.80536348e-01f, 3.91023308e-01f, 4.39446896e-01f, 1.71292394e-01f,
  -3.28424692e-01f, 2.09942356e-01f, 2.94147849e-01f, 1.32400319e-01f, -3.48505378e-01f, 3.25886399e-01f, -3.34089369e-01f, -6.62343204e-01f, -1.12678285e-03f, 6.00442290e-01f,
  4.75687444e-01f, 4.12906796e-01f, -2.36621901e-01f, -5.40973365e-01f, 2.26775527e-01f, -1.97738007e-01f, -4.37073261e-01f, 2.01328561e-01f, -3.90056223e-01f, 4.13809836e-01f,
  -3.79992485e-01f, -2.83113927e-01f, -2.87456751e-01f, -1.46382377e-01f, -3.71761858e-01f, 2.96849877e-01f, -2.25656286e-01f, -5.12096286e-02f, -1.13986671e-01f, -7.81684667e-02f,
  -4.15497899e-01f, -2.78488457e-01f, -3.30675364e-01f, -4.75435644e-01f, -4.16211933e-01f, -2.34547600e-01f, 1.08936593e-01f, 1.94814041e-01f, -1.60139039e-01f, -2.49405697e-01f,
  3.28217119e-01f, 5.52850962e-01f, -3.70974481e-01f, -1.87338948e-01f, -2.52845883e-01f, -4.36147243e-01f, 3.37313162e-03f, -4.12067801e-01f, -2.03940481e-01f, -4.11120392e-02f,
  3.64582539e-02f, 1.03748709e-01f, 1.18775936e-02f, 2.21197367e-01f, -3.52324843e-01f, -1.33680388e-01f, -6.49656430e-02f, -3.95334885e-02f, 6.09121382e-01f, 1.28242120e-01f,
  3.27422529e-01f, 2.88526475e-01f, 1.53939381e-01f, -5.35857044e-02f, 2.44227231e-01f, -3.76059920e-01f, -4.04429495e-01f, -4.57841933e-01f, -3.54079872e-01f, 5.74292600e-01f,
  -3.60023767e-01f, -2.77455211e-01f, 2.51425087e-01f, -3.51177692e-01f, -2.81028211e-01f, -5.28093278e-01f, -2.96047390e-01f, -4.02195513e-01f, -4.00012583e-01f, 5.66397429e-01f,
  3.54340255e-01f, -6.86937988e-01f, 4.99350250e-01f, -4.35727715e-01f, 5.30018032e-01f, 3.12539369e-01f, -2.14197487e-03f, -4.64060962e-01f, -1.02057472e-01f, 5.37804425e-01f,
  1.29515175e-02f, 2.52065450e-01f, -5.69448769e-01f, -4.90090609e-01f, 1.10376224e-01f, -4.09160793e-01f, 1.45396650e-01f, -2.89099962e-01f, -6.23055222e-03f, -4.90727603e-01f,
  -4.33853596e-01f, 2.93822080e-01f, -7.20556915e-01f, -1.34202642e-02f, 2.15644583e-01f, -3.71723264e-01f, 4.13997322e-01f, -2.42163297e-02f, 5.19722998e-01f, 6.71042055e-02f,
  2.37122163e-01f, 1.09737314e-01f, -3.87053668e-01f, -1.51159942e-01f, 2.50006646e-01f, -5.61437607e-02f, 2.66010702e-01f, 1.48997754e-01f, 2.68222332e-01f, -2.44048908e-01f,
  3.31961066e-01f, 7.53047839e-02f, -2.54680932e-01f, -4.42753434e-01f, -2.38625243e-01f, -4.52946752e-01f, -2.36438274e-01f, -4.34416920e-01f, -2.09080160e-01f, 4.69018549e-01f,
  3.54074031e-01f, 3.13367605e-01f, -1.16523512e-01f, -5.19189894e-01f, 6.97893202e-01f, -4.45588320e-01f, -5.06848872e-01f, -1.29479960e-01f, -5.63630283e-01f, -3.32297146e-01f,
  1.44258603e-01f, -3.20524603e-01f, -4.68109816e-01f, 4.15240645e-01f, -3.04922640e-01f, 4.68164891e-01f, 3.97377998e-01f, -3.52536976e-01f, -2.61146218e-01f, -3.10776979e-01f,
  -5.38108170e-01f, -1.64532915e-01f, -5.47514200e-01f, -4.12244946e-01f, -4.75038797e-01f, -2.30145112e-01f, -4.26241875e-01f, 5.34167469e-01f, -1.44983530e-01f, -4.62604195e-01f,
  -2.86020964e-01f, 4.64430302e-01f, -3.47585469e-01f, 5.32569028e-02f, -4.19246316e-01f, -3.31433266e-01f, 5.46011254e-02f, -1.60116717e-01f, -4.32716519e-01f, 3.84556741e-01f,
  -8.41564015e-02f, 3.18247974e-01f, 4.54503477e-01f, -6.77637458e-01f, 1.49944082e-01f, 5.37450388e-02f, 1.74800575e-01f, -1.17562331e-01f, -9.24782306e-02f, -8.25638101e-02f,
  6.31626919e-02f, 2.19201177e-01f, 4.48063649e-02f, 1.22123502e-01f, -9.40524191e-02f, 1.37479126e-01f, 3.41114581e-01f, -3.85390908e-01f, -2.53258109e-01f, 2.58366048e-01f,
  9.48056113e-03f, -2.14292884e-01f, -5.37803657e-02f, 2.30833709e-01f, 5.25634736e-02f, -2.87689209e-01f, 3.73295605e-01f, 3.47226739e-01f, -8.44104812e-02f, 1.25422522e-01f,
  -1.87907070e-02f, 3.79553288e-01f, -4.74411637e-01f, -4.00182396e-01f, 5.89296460e-01f, -3.29416275e-01f, 6.89890623e-01f, -5.75516582e-01f, 3.36759329e-01f, -6.59690619e-01f,
  -1.06579848e-01f, -4.42862287e-02f, -2.42502421e-01f, -4.39638793e-01f, -1.56017259e-01f, 2.97974765e-01f, 4.14633036e-01f, -5.32568216e-01f, -4.12220299e-01f, 4.29534256e-01f,
  -4.58113790e-01f, -8.72262716e-02f, -4.19256806e-01f, 5.15272953e-02f, -5.13469934e-01f, -4.44899023e-01f, 2.55472511e-02f, -1.53703451e-01f, 3.67255986e-01f, -2.41644070e-01f,
  -3.12863946e-01f, 3.50072980e-01f, -4.68960404e-01f, 4.77810413e-01f, 4.37037587e-01f, 9.77892056e-02f, -5.43103479e-02f, -5.44741094e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  4.79671769e-02f, 1.89129308e-01f, -1.39426962e-01f, -1.76491402e-02f, -4.67057787e-02f, 5.57940304e-02f, -7.41269439e-02f, -1.92549542e-01f, -1.04209699e-01f, 3.87139339e-03f,
  5.16109541e-02f, -1.26351550e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 12, 40
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        64, 12
    );
    }
    