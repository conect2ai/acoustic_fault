/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 128 (x2)
    * Saída: 12
    * Buffer Máx: 128
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 128;
    const int FAN_MAX_BUFFER_SIZE = 128;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 51 x 120)
const int L0_fan_Wp_rows = 51;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -1.49548233e-01f, -1.39831394e-01f, -6.26869351e-02f, -1.09858960e-01f, 7.61433914e-02f, 6.54991940e-02f, 1.54648826e-01f, -1.29048033e-02f, -1.19418234e-01f, -1.66199759e-01f,
  -1.17902815e-01f, -1.13966770e-01f, -4.28342968e-02f, -1.32115260e-01f, 1.96692776e-02f, -1.45175708e-02f, 6.53877631e-02f, 2.17060689e-02f, 2.68811733e-02f, 9.19079259e-02f,
  -4.76125255e-02f, -1.41823396e-01f, -7.10976720e-02f, -7.22091198e-02f, -9.03504156e-03f, -5.42109944e-02f, -6.23220503e-02f, -5.00410050e-02f, -8.49703848e-02f, -1.22133225e-01f,
  -2.85258770e-01f, -1.80408359e-01f, 2.43006703e-02f, -1.48417205e-01f, -1.80460528e-01f, -1.07222944e-01f, -1.38087228e-01f, -1.04780681e-01f, -1.37502313e-01f, -8.36248696e-02f,
  -2.89221783e-03f, -3.14259902e-02f, -6.54031523e-03f, 9.61851981e-03f, -8.61893073e-02f, -1.20333105e-01f, -1.47785291e-01f, -1.07003450e-01f, -3.33501175e-02f, -1.01339534e-01f,
  -6.93429708e-02f, -8.52065384e-02f, -1.50650993e-01f, 7.32687954e-03f, -8.78600851e-02f, 1.68873481e-02f, -1.36771560e-01f, -9.56429169e-03f, -5.78980334e-02f, -2.14640647e-01f,
  -1.07925296e-01f, -7.18735857e-03f, 8.08216035e-02f, 4.52911779e-02f, 1.04277313e-01f, -1.33573078e-02f, 1.30245864e-01f, -4.34242152e-02f, 1.10217594e-01f, -1.94142964e-02f,
  4.10226993e-02f, -8.15066323e-02f, 6.10685833e-02f, 6.14809133e-02f, -1.42963408e-02f, -1.49644297e-02f, 5.14825620e-02f, 1.25806015e-02f, 4.48398897e-03f, 1.21041462e-01f,
  -9.34576429e-03f, 1.04210116e-01f, -1.04245342e-01f, 1.97933856e-02f, -2.46738223e-03f, 2.86645833e-02f, 7.54544511e-02f, -6.10238465e-04f, -7.24851266e-02f, 4.88261227e-03f,
  -1.53717518e-01f, 2.61708368e-02f, -1.42726183e-01f, 4.41113636e-02f, -9.73684639e-02f, -1.07065804e-01f, -1.51008010e-01f, -1.05152130e-01f, -3.77275012e-02f, -2.43036300e-02f,
  -3.81825864e-02f, -1.08194508e-01f, -4.26981263e-02f, -7.87464082e-02f, -8.80133137e-02f, -2.13745143e-02f, -9.31238905e-02f, -1.95577107e-02f, -4.70990241e-02f, -9.88586918e-02f,
  -7.82361031e-02f, 2.45245732e-02f, -7.42057860e-02f, -1.46646485e-01f, -1.14370592e-01f, 2.02445835e-02f, -9.54877585e-02f, -1.16378516e-01f, -1.28790781e-01f, -1.57716870e-01f,
  -3.50893170e-01f, -9.01547819e-02f, 8.27830099e-03f, -7.88595602e-02f, 1.39530972e-01f, 2.46853784e-01f, 3.48026186e-01f, 1.57676920e-01f, 4.84507047e-02f, 7.83175416e-03f,
  7.83580989e-02f, -1.22275718e-01f, -1.01563089e-01f, -5.53743988e-02f, 1.33313000e-01f, 1.85507759e-01f, 2.00160161e-01f, -9.34986621e-02f, 2.14064009e-02f, 1.79033160e-01f,
  1.37306124e-01f, -2.11763065e-02f, -1.61601707e-01f, -7.88461939e-02f, -1.28554493e-01f, 1.84528902e-02f, -1.06769443e-01f, -1.15792029e-01f, 3.61076072e-02f, -2.21272603e-01f,
  -3.00872415e-01f, -2.27799639e-01f, 7.61526031e-03f, -6.43945411e-02f, -4.11226563e-02f, -1.02090865e-01f, 4.62929159e-02f, -6.25262856e-02f, -1.03563638e-02f, -5.79299815e-02f,
  -5.47916330e-02f, -8.34159032e-02f, -9.98552442e-02f, -5.56501187e-02f, -8.28462653e-03f, -6.32520393e-02f, -6.89236522e-02f, -7.89994150e-02f, -1.08315952e-01f, -1.81634829e-03f,
  7.12004900e-02f, -2.10517682e-02f, -1.66582149e-02f, 9.85301137e-02f, 4.33582775e-02f, 4.22054678e-02f, -8.93054977e-02f, -6.23260736e-02f, 2.67861113e-02f, -4.50409502e-02f,
  -5.09418957e-02f, 1.77954622e-02f, 1.14628905e-02f, 6.19627647e-02f, 9.07110870e-02f, 9.44946110e-02f, 2.73080077e-02f, 3.26559716e-03f, 8.94330442e-02f, -1.75288450e-02f,
  8.01108852e-02f, -1.43842110e-02f, 6.05348349e-02f, 6.37918934e-02f, 6.14164732e-02f, 7.42133334e-02f, 8.48952681e-03f, 5.32351024e-02f, 1.63996720e-03f, 6.32538600e-03f,
  -1.93530302e-02f, 7.53880739e-02f, 1.40279671e-02f, 3.56387049e-02f, 4.27052937e-02f, 2.79787276e-02f, 2.60760020e-02f, 7.50253350e-02f, -3.49314176e-02f, 1.51773887e-02f,
  -8.00690353e-02f, 1.09903783e-01f, -1.32030115e-01f, -1.22733517e-02f, -3.29326615e-02f, -1.19423062e-01f, -6.05660714e-02f, -1.00205876e-01f, -1.53583318e-01f, 2.26058327e-02f,
  -9.93411988e-03f, -1.03793675e-02f, -5.57751283e-02f, -3.02861705e-02f, -1.50582138e-02f, -1.66399963e-02f, -1.67383917e-03f, -5.45170754e-02f, -1.06559470e-02f, 9.75345727e-03f,
  -9.12185875e-04f, 1.13304488e-01f, -6.32343292e-02f, 3.16378400e-02f, 1.79249689e-03f, -1.69691872e-02f, 3.16305570e-02f, 4.81468253e-02f, -4.72534597e-02f, 3.31066325e-02f,
  9.50379893e-02f, 7.10014105e-02f, -1.36061147e-01f, -1.40287444e-01f, -1.29924521e-01f, 2.49882210e-02f, 1.56493202e-01f, 5.26483767e-02f, -1.05528556e-01f, 1.49390399e-01f,
  -8.37399997e-03f, -8.07422698e-02f, -1.27388924e-01f, 1.14117865e-03f, 6.03216477e-02f, 1.23675361e-01f, 7.54203647e-02f, -5.71955752e-04f, -3.25962491e-02f, 3.75074372e-02f,
  1.30150588e-02f, -6.71034232e-02f, 4.67828773e-02f, -6.57096207e-02f, -6.27386570e-02f, -1.41778246e-01f, -1.65424839e-01f, -3.45801711e-02f, -2.44359393e-02f, -5.44671491e-02f,
  -8.97948965e-02f, -1.65873781e-01f, -1.29414365e-01f, -3.28924619e-02f, -8.73339176e-02f, -1.28959462e-01f, -1.91311851e-01f, -1.67652741e-01f, -1.34963065e-01f, -1.25349537e-01f,
  -1.44369051e-01f, -1.30479574e-01f, -1.39744714e-01f, -1.83409333e-01f, -1.18709214e-01f, -8.82983506e-02f, -3.60005796e-02f, -7.23710358e-02f, -5.19790687e-03f, -7.21452832e-02f,
  -1.53301820e-01f, -3.15828212e-02f, -1.25798866e-01f, -1.30885988e-01f, -1.96304753e-01f, -1.55458048e-01f, -1.06628343e-01f, -2.01475412e-01f, -1.51670456e-01f, -1.39874369e-01f,
  1.10756062e-01f, 1.62282988e-01f, 1.15954123e-01f, 1.14367738e-01f, 2.26492196e-01f, 1.31553993e-01f, 1.12179585e-01f, 1.86438009e-01f, 6.01352751e-02f, 1.77847743e-01f,
  1.80696100e-01f, 8.60277489e-02f, 5.55921458e-02f, 1.57765046e-01f, 9.87894610e-02f, 8.55004564e-02f, 1.71514049e-01f, 2.13158831e-01f, 9.30292159e-02f, 1.85736686e-01f,
  1.57459125e-01f, 9.87917837e-03f, 1.01062454e-01f, 1.50665015e-01f, 1.51493788e-01f, 2.03778267e-01f, 1.02280222e-01f, 1.80686533e-01f, 1.95516512e-01f, 1.39075473e-01f,
  -5.71678802e-02f, -9.91039276e-02f, -8.93509686e-02f, -1.24888018e-01f, -1.41813859e-01f, -1.92419812e-01f, -1.19313315e-01f, -6.59818873e-02f, -1.40739605e-01f, -5.07979989e-02f,
  -1.45618752e-01f, -5.00086360e-02f, -7.67908394e-02f, -1.96161374e-01f, -3.62874009e-02f, -8.69468227e-02f, -1.40601061e-02f, -1.61685228e-01f, -2.52863877e-02f, -1.83236271e-01f,
  -4.32348624e-02f, -1.60533339e-02f, -9.46363956e-02f, -1.62285179e-01f, -1.02788813e-01f, -8.53240490e-02f, -6.35756180e-02f, -1.02175638e-01f, -2.91865990e-02f, -9.84745994e-02f,
  2.91801155e-01f, -1.53220192e-01f, -2.80612618e-01f, -2.23738831e-02f, -1.71799242e-01f, -1.60713077e-01f, -1.40568763e-01f, 2.04267874e-02f, 1.73962578e-01f, -1.72588527e-01f,
  -1.28143460e-01f, 1.62904322e-01f, 9.29222777e-02f, 3.22300382e-02f, 1.17975920e-01f, -2.29721844e-01f, -1.79394200e-01f, 2.86473371e-02f, 1.56286240e-01f, 8.60084966e-02f,
  1.09430343e-01f, 1.25580162e-01f, 1.15887254e-01f, 1.63253903e-01f, -5.75536937e-02f, -5.95040619e-02f, -1.31825566e-01f, -7.99713433e-02f, 1.15431175e-02f, -2.38030151e-01f,
  -2.82390416e-01f, -9.43376869e-02f, 5.59164546e-02f, 2.76734284e-03f, -3.40294912e-02f, 1.63247678e-04f, -3.06245591e-02f, 2.60035787e-02f, -5.21023618e-03f, -6.39028996e-02f,
  -1.05865791e-01f, 6.17283285e-02f, 9.04318690e-03f, 4.72587235e-02f, -4.01564389e-02f, 3.09647359e-02f, 1.05999611e-01f, 6.53029904e-02f, 5.32739311e-02f, -7.37250596e-02f,
  -4.72944565e-02f, -8.79511014e-02f, 1.40968738e-02f, -7.78729841e-02f, -4.43021953e-02f, 3.90617922e-02f, -6.91970587e-02f, -1.06912732e-01f, -2.98974495e-02f, -6.94506094e-02f,
  -1.46584986e-02f, 3.26171368e-02f, 2.06673071e-02f, 7.00104469e-03f, 7.90881366e-02f, -4.18762341e-02f, -1.63054168e-02f, -8.56474116e-02f, 5.45071922e-02f, -2.61747465e-02f,
  4.51500416e-02f, 3.37743685e-02f, 1.53753569e-03f, -7.69530907e-02f, -4.54420298e-02f, -5.37569039e-02f, 1.74736138e-02f, -7.07556680e-02f, -9.65710916e-03f, 4.86332923e-02f,
  -1.36073697e-02f, -8.09170753e-02f, 3.36895399e-02f, 7.71285444e-02f, 1.30557334e-02f, -6.94175437e-02f, -7.09561184e-02f, 9.26247984e-03f, -5.02002500e-02f, 8.14773068e-02f,
  1.74359605e-01f, -2.71587539e-02f, -1.98569119e-01f, -2.51095518e-02f, -8.05272609e-02f, -5.48949130e-02f, -1.66761860e-01f, -6.87737465e-02f, -3.89796197e-02f, -8.71823058e-02f,
  -2.09359992e-02f, -8.29686746e-02f, -2.54128687e-02f, -7.10617602e-02f, -2.28695869e-02f, -2.63726562e-02f, -5.77531680e-02f, -9.70512554e-02f, -1.27856612e-01f, -5.65839037e-02f,
  -5.66455238e-02f, -1.22376896e-01f, -5.32960072e-02f, -5.69013953e-02f, -9.38835815e-02f, -3.95200327e-02f, -1.41074926e-01f, 4.67685051e-03f, 4.59235273e-02f, 2.08470114e-02f,
  -1.98545903e-02f, 3.75123993e-02f, -1.49235860e-01f, 6.48745969e-02f, -2.11252853e-01f, -3.07430118e-01f, -2.61391461e-01f, -5.43749928e-02f, -1.69246402e-02f, -5.17873950e-02f,
  9.19436142e-02f, 4.97589931e-02f, -1.43962482e-03f, 5.82394153e-02f, -1.16066523e-01f, -1.06183745e-01f, -4.51461338e-02f, -2.09232524e-01f, -2.23574787e-01f, -2.27314875e-01f,
  -1.21890806e-01f, -5.01496531e-02f, 1.03207208e-01f, -3.17387506e-02f, 5.74225672e-02f, 4.29304168e-02f, 3.58617748e-03f, -7.93168098e-02f, -1.10807620e-01f, 9.09329578e-03f,
  1.09839238e-01f, -6.92993682e-03f, -1.23246960e-01f, 2.20980868e-02f, 8.45584422e-02f, 2.03758944e-02f, -1.55839529e-02f, -9.76900570e-03f, -3.40608321e-02f, 3.46306674e-02f,
  -7.71148503e-02f, 5.00030071e-02f, -1.15169443e-01f, -7.40802959e-02f, -8.25716928e-02f, -9.17759538e-02f, -5.36416098e-02f, -8.69375244e-02f, 7.28592090e-03f, -6.95718378e-02f,
  -1.12091810e-01f, -1.78618237e-01f, -1.23491131e-01f, -1.06064484e-01f, -1.02813713e-01f, -6.31456450e-02f, -1.28216252e-01f, 2.90005971e-02f, -2.37876456e-02f, 1.02498382e-01f,
  6.78540766e-02f, -3.81447859e-02f, -5.09116650e-02f, -1.25736529e-02f, 4.71632294e-02f, 4.24088240e-02f, 1.01109028e-01f, 1.16927624e-01f, 4.32886556e-02f, 2.68130843e-02f,
  7.07253441e-02f, -1.39640132e-02f, 5.66551834e-02f, 2.91653685e-02f, 1.11519523e-01f, -5.88989537e-03f, -5.33409007e-02f, 1.28908172e-01f, 1.12960488e-01f, 8.43090117e-02f,
  7.54936710e-02f, 5.97563274e-02f, 1.15376294e-01f, -1.70834027e-02f, 5.15241176e-02f, 8.11615735e-02f, 9.61613357e-02f, 1.06366277e-01f, 9.61198956e-02f, 6.49544001e-02f,
  9.22487378e-02f, -1.75552323e-01f, -2.06329953e-02f, -7.00718462e-02f, -1.59760378e-02f, -2.70825028e-02f, -6.21322319e-02f, -7.81248510e-02f, 3.32907066e-02f, -4.65779901e-02f,
  -3.25663462e-02f, -1.07863076e-01f, 2.28274874e-02f, -8.52274895e-02f, -5.83637170e-02f, -1.33658312e-02f, 3.68108675e-02f, -6.68428093e-02f, -1.29027933e-01f, 3.87553684e-02f,
  -3.48265208e-02f, -1.29903048e-01f, -1.42294616e-01f, -3.30697484e-02f, -1.34947956e-01f, -6.47411346e-02f, -6.58074245e-02f, -5.18740080e-02f, -5.46825528e-02f, 6.98288716e-03f,
  -3.53715271e-01f, -5.10323271e-02f, -1.38895690e-01f, -1.63480490e-01f, -7.84025416e-02f, -4.37411293e-03f, 2.13860795e-01f, 1.30515307e-01f, 3.60045508e-02f, -2.55487375e-02f,
  -8.83020535e-02f, -3.79490443e-02f, 6.01477884e-02f, 2.71196738e-02f, 7.52910599e-02f, 2.37829424e-02f, -9.66789201e-02f, -2.04998583e-01f, -1.70712277e-01f, -8.64672065e-02f,
  4.40738536e-03f, -2.31452018e-01f, -2.58816004e-01f, -1.45193100e-01f, -4.59602475e-02f, -9.66095924e-02f, -2.73326151e-02f, -1.63372591e-01f, -1.25775248e-01f, -1.52767554e-01f,
  -1.72510773e-01f, -2.27829203e-01f, 3.02655678e-02f, -1.04976751e-01f, -5.75931035e-02f, -3.60332280e-02f, -8.86619985e-02f, -7.63551593e-02f, 2.11802553e-02f, -3.99620645e-02f,
  -4.98064011e-02f, -1.18232794e-01f, -1.40900403e-01f, -1.03821360e-01f, -9.49231237e-02f, -1.09068148e-01f, -3.98133025e-02f, -6.53454065e-02f, -1.98100321e-03f, 2.72571985e-02f,
  -1.76571235e-02f, -1.88684583e-01f, -8.05999339e-02f, 5.19597828e-02f, 2.24707834e-03f, 6.93722721e-03f, 1.44551443e-02f, -9.56379436e-03f, -7.88479522e-02f, -4.57997844e-02f,
  1.12402305e-01f, 9.82774701e-03f, -2.11706534e-02f, -5.30585200e-02f, 2.27527972e-03f, 2.21376084e-02f, -9.32123736e-02f, 2.67925337e-02f, 2.44836118e-02f, -7.82174319e-02f,
  -2.50592642e-02f, 3.64717618e-02f, -1.68018397e-02f, -8.50232840e-02f, -2.85084266e-02f, -1.28972769e-01f, -1.34656010e-02f, 1.02557587e-02f, -3.04743722e-02f, -9.58270282e-02f,
  -3.81274782e-02f, -3.08440607e-02f, -8.29505771e-02f, 5.93182305e-03f, -9.38421264e-02f, 4.19972874e-02f, -5.80996051e-02f, -1.13438275e-02f, -7.47938976e-02f, -9.33464468e-02f,
  -7.54681602e-02f, 1.68537851e-02f, -6.82910234e-02f, -4.17753570e-02f, 8.11996125e-03f, 6.11978695e-02f, -5.04863299e-02f, 5.96478730e-02f, -1.77479477e-03f, -8.04898441e-02f,
  -9.60237831e-02f, 2.95233279e-02f, -6.33516461e-02f, -9.34812725e-02f, -1.17951684e-01f, -2.22215634e-02f, 2.93991715e-02f, -8.12446177e-02f, 8.01054668e-03f, -1.58231109e-02f,
  5.70367910e-02f, -3.79492640e-02f, -7.05636665e-03f, 4.67019528e-02f, 9.58330482e-02f, -6.08715229e-02f, -9.42012295e-02f, 2.71826778e-02f, 7.84961060e-02f, 1.58153489e-01f,
  -2.75531173e-01f, -8.19597393e-03f, -2.86359608e-01f, -3.28117669e-01f, -3.37898284e-01f, -2.67117321e-01f, -6.07389696e-02f, -1.12641655e-01f, -7.28447214e-02f, 1.51557894e-02f,
  1.51528930e-02f, 8.65527019e-02f, 1.96372494e-02f, 2.40068603e-02f, 4.39026766e-02f, -1.06463253e-01f, -1.30491540e-01f, -8.20023715e-02f, -1.83148801e-01f, -5.89096434e-02f,
  2.57449392e-02f, -1.68727323e-01f, -1.10948771e-01f, -1.15209194e-02f, -1.89638376e-01f, -6.00890294e-02f, -1.16454422e-01f, -8.87192711e-02f, -2.83642840e-02f, -1.12843789e-01f,
  3.83212082e-02f, -2.19252005e-01f, -3.61539200e-02f, 1.14456363e-01f, 3.85315195e-02f, 2.54083779e-02f, 9.37783066e-03f, 5.75090572e-03f, 5.30515937e-03f, 8.28013793e-02f,
  -1.03721023e-01f, 6.72795773e-02f, -7.40341991e-02f, 7.32916892e-02f, 1.36090778e-02f, -4.14921120e-02f, 4.06593867e-02f, 8.83474723e-02f, 3.09240464e-02f, -3.02847996e-02f,
  -1.48990937e-02f, -6.51244819e-02f, -5.96900396e-02f, 1.18220448e-01f, 1.91038400e-02f, -2.98072752e-02f, -3.20209116e-02f, 1.41380476e-02f, 6.42446205e-02f, 6.23977855e-02f,
  7.05448464e-02f, 2.87245382e-02f, 6.92580640e-02f, 3.80637236e-02f, 1.11390688e-01f, 5.44856451e-02f, -1.71409559e-03f, 6.67549893e-02f, -3.85499001e-02f, 1.19544882e-02f,
  5.64081296e-02f, 5.70700876e-02f, -5.82849123e-02f, -4.10092399e-02f, -4.62282859e-02f, -1.15192533e-01f, 5.75539991e-02f, -3.28400061e-02f, 1.98274851e-02f, 8.30529481e-02f,
  -6.36761785e-02f, 1.70852207e-02f, -1.04561664e-01f, 7.84257948e-02f, 5.08161895e-02f, -4.71160412e-02f, -7.33388364e-02f, 8.10810830e-03f, 2.34993864e-02f, -1.11769177e-01f,
  4.70945574e-02f, 8.38014632e-02f, 7.09478408e-02f, 4.84811254e-02f, -8.62737074e-02f, 1.27170742e-01f, -2.58973390e-02f, 5.69617236e-03f, -6.49402887e-02f, -7.14046061e-02f,
  2.18654219e-02f, -2.06880383e-02f, -4.28713039e-02f, -1.02352966e-02f, -2.27177162e-02f, 1.17910476e-02f, 8.56515095e-02f, -8.76433998e-02f, 7.65962005e-02f, 3.04847546e-02f,
  -2.07344349e-02f, 5.88778034e-02f, -1.23432692e-04f, 3.07622496e-02f, -2.75304243e-02f, 1.92472506e-02f, -4.40156870e-02f, 2.86522391e-03f, 6.96295276e-02f, 1.17802382e-01f,
  9.90722980e-03f, 3.16472113e-01f, -8.26969557e-03f, 5.47061004e-02f, 1.48454413e-01f, -2.71056239e-02f, 8.70518833e-02f, -7.68682286e-02f, -1.15516573e-01f, 1.41487017e-01f,
  1.54232964e-01f, -1.23108469e-01f, -6.94734231e-02f, -1.43413886e-01f, -4.79516461e-02f, 1.09486848e-01f, 1.48836985e-01f, -1.92197815e-01f, -2.44809285e-01f, -1.21668726e-01f,
  7.37985000e-02f, -1.25851408e-01f, -7.47618079e-02f, -1.04780726e-01f, 1.28687248e-01f, -9.21414867e-02f, 3.03414427e-02f, 5.01143411e-02f, 1.72517262e-02f, 2.57011563e-01f,
  -7.28557110e-02f, 1.96872935e-01f, -1.23565853e-01f, -4.93533723e-02f, 6.78798929e-02f, -5.74758947e-02f, -5.13180308e-02f, -7.11086392e-02f, -4.70775142e-02f, 8.05011019e-02f,
  9.31904837e-02f, -1.22669162e-02f, -2.50833724e-02f, 3.32849324e-02f, 5.95897697e-02f, 3.68982218e-02f, -5.52759133e-03f, -7.69569352e-02f, -4.10414748e-02f, 7.15987608e-02f,
  1.63673714e-01f, 1.39100477e-01f, -2.43050046e-02f, -6.23042658e-02f, 7.51724392e-02f, -8.04910287e-02f, -9.27664265e-02f, -2.44097169e-02f, -1.09298825e-01f, -9.27058831e-02f,
  -1.00922860e-01f, -1.48711493e-02f, -5.59025370e-02f, 2.16018539e-02f, -9.61220264e-02f, -8.38196427e-02f, 3.29209380e-02f, 7.07266526e-03f, -4.11857553e-02f, -7.08658621e-02f,
  -6.23931140e-02f, 2.89761256e-02f, -1.12724930e-01f, -3.46529447e-02f, -6.17620125e-02f, -4.89671007e-02f, 2.24582665e-02f, -7.81259760e-02f, -2.41539963e-02f, -1.94871891e-02f,
  5.89143345e-03f, 1.69823561e-02f, -1.19296476e-01f, -2.36283038e-02f, 9.90915019e-03f, -6.15258375e-03f, -7.11454600e-02f, -5.90544604e-02f, -7.32729286e-02f, -7.11181527e-03f,
  -1.26992941e-01f, -1.16917752e-01f, -3.57579850e-02f, -3.22270356e-02f, -5.86786196e-02f, 9.08709504e-03f, -4.06517573e-02f, -4.33230065e-02f, 7.23912120e-02f, -5.26839308e-02f,
  3.65535356e-02f, -5.24872029e-03f, -3.17959748e-02f, -8.19093138e-02f, -1.18075639e-01f, -2.70952806e-02f, 7.94237554e-02f, -4.01186384e-02f, -5.88013940e-02f, 2.53842343e-02f,
  -1.66269038e-02f, -7.45867789e-02f, -3.80118415e-02f, -7.28613660e-02f, -2.36636512e-02f, -1.04603171e-01f, -1.67624354e-01f, -1.28361091e-01f, -1.89589366e-01f, -1.63373530e-01f,
  -3.65695506e-01f, -2.66604215e-01f, 8.15966949e-02f, -2.83769906e-01f, -1.15540437e-01f, 5.42942900e-03f, -9.61473510e-02f, -1.13329524e-02f, 2.24933606e-02f, -4.27672006e-02f,
  2.56840810e-02f, 3.42115271e-03f, 5.95625788e-02f, 1.55518159e-01f, 1.47111431e-01f, -8.72777700e-02f, -7.46523067e-02f, 8.14150348e-02f, 2.25589722e-01f, -1.12648150e-02f,
  -1.64584704e-02f, -6.61789700e-02f, -1.04583576e-01f, -2.59338822e-02f, -2.42929280e-01f, -8.99887681e-02f, -5.13888896e-02f, -8.04787502e-02f, 5.94299324e-02f, -2.16260776e-01f,
  1.51369587e-01f, 2.10621227e-02f, 1.65925175e-01f, -9.74637195e-02f, 3.77009809e-02f, -4.71288934e-02f, 8.81791301e-03f, 1.76660679e-02f, -1.83056779e-02f, -7.61935413e-02f,
  4.78990451e-02f, -1.49055310e-02f, 1.02306582e-01f, 3.10921278e-02f, 6.96214661e-03f, -2.15696674e-02f, 3.51982825e-02f, 1.57410651e-02f, 7.17760250e-02f, 4.62010987e-02f,
  -3.23099531e-02f, -3.27300699e-03f, 6.61960393e-02f, 1.45851016e-01f, 1.47934273e-01f, 7.19966963e-02f, 1.57240417e-03f, 1.18251115e-01f, 1.84603669e-02f, -1.11605681e-01f,
  -2.53092889e-02f, -6.07299358e-02f, -4.08452116e-02f, -3.78603302e-02f, 1.11523336e-02f, 8.12863782e-02f, 3.96918617e-02f, 2.84704994e-02f, 6.71882834e-03f, -4.86490354e-02f,
  1.03030972e-01f, 1.59346848e-03f, -9.79691185e-03f, -1.79831330e-02f, -5.16882585e-03f, 2.23551318e-02f, -1.41420336e-02f, 2.63658469e-03f, -6.46006269e-03f, 7.40894154e-02f,
  -4.17299084e-02f, 5.96879758e-02f, -1.45689992e-03f, -2.98904460e-02f, -2.45133322e-02f, 4.31443453e-02f, 1.52023450e-01f, 7.01918155e-02f, 4.65619788e-02f, 7.81323537e-02f,
  -2.75787003e-02f, 2.62138069e-01f, -2.60114446e-02f, -1.32126668e-02f, 1.60173811e-02f, 7.45981634e-02f, -8.11378360e-02f, 7.38693727e-03f, -4.09665331e-02f, -7.47832749e-03f,
  4.83524092e-02f, -3.35558094e-02f, -4.99803722e-02f, -5.16948514e-02f, 3.51618882e-03f, 5.02850078e-02f, -1.02988794e-01f, -8.67663920e-02f, -2.18992215e-03f, -5.47336154e-02f,
  -9.84470248e-02f, 7.21516740e-03f, 4.88541238e-02f, 2.54319049e-03f, 2.23605372e-02f, 6.42056093e-02f, 1.12000704e-01f, -1.54496953e-02f, 4.75675613e-02f, -1.56035289e-01f,
  4.15558577e-01f, -2.59475172e-01f, -2.97222346e-01f, 2.48698458e-01f, 8.24275911e-02f, -4.67331223e-02f, -1.83654815e-01f, 5.47411554e-02f, 2.91719586e-01f, -1.37353595e-02f,
  8.94090235e-02f, 2.17831939e-01f, 1.57845110e-01f, -5.29162921e-02f, -1.29488818e-02f, -2.06514627e-01f, -1.22224510e-01f, -3.07834223e-02f, 8.12136307e-02f, 7.89628923e-02f,
  1.36347786e-01f, 5.00824265e-02f, 7.32170865e-02f, -1.18086310e-02f, 3.03878989e-02f, 6.88826963e-02f, -1.77869424e-01f, -1.33494481e-01f, -1.01453505e-01f, -2.47402325e-01f,
  -9.06648412e-02f, -8.26823562e-02f, 1.69075489e-01f, 9.55858156e-02f, 1.05184745e-02f, 6.46996424e-02f, 1.07458733e-01f, 2.53221504e-02f, 7.48427883e-02f, 2.75434386e-02f,
  9.19996481e-03f, 1.29259422e-01f, 1.49418458e-01f, 6.95742816e-02f, 4.47190255e-02f, 7.69179314e-02f, 1.60351675e-02f, 5.09949364e-02f, -3.98450270e-02f, 2.76136976e-02f,
  3.49965468e-02f, 6.34650663e-02f, 1.13134228e-01f, 2.59103347e-02f, 5.44124693e-02f, 4.89288867e-02f, -4.62486558e-02f, 3.65943159e-03f, 8.18778574e-02f, 3.46857943e-02f,
  9.86931100e-02f, -7.43701160e-02f, -1.19809574e-02f, -9.93060544e-02f, -1.51743079e-02f, -5.92004247e-02f, -3.53937186e-02f, 3.27919275e-02f, -6.18177559e-03f, -1.07321516e-02f,
  5.89256687e-03f, -5.77595271e-02f, -3.82326567e-03f, 2.98140179e-02f, 1.44528253e-02f, -2.85693035e-02f, 3.06737404e-02f, -3.04995868e-02f, -7.05698207e-02f, -1.57695320e-02f,
  1.24715306e-02f, -9.51849967e-02f, 1.91812534e-02f, -9.45367590e-02f, -7.86584616e-02f, -4.67474349e-02f, 1.70300365e-03f, -2.86697340e-03f, -1.23462472e-02f, -1.83406938e-02f,
  3.06952447e-01f, -1.33518353e-02f, 1.41321883e-01f, 8.41089189e-02f, 5.31046204e-02f, 4.16758507e-02f, 8.43799561e-02f, 9.89020541e-02f, 1.14810299e-02f, 4.48430553e-02f,
  7.43539929e-02f, 3.14759873e-02f, 6.86189830e-02f, 1.29263930e-03f, 6.84453249e-02f, 4.63373959e-02f, 1.02445386e-01f, 1.11289538e-01f, 5.79793155e-02f, 8.49216990e-03f,
  5.33966068e-03f, 8.39125887e-02f, 2.47406125e-01f, 8.73154178e-02f, 1.10059962e-01f, 1.86865911e-01f, 9.96927544e-02f, 5.49382120e-02f, 1.06969409e-01f, 1.44695640e-01f,
  1.74310938e-01f, 1.12910405e-01f, 1.43699244e-01f, 1.09856293e-01f, -1.34740770e-01f, -2.40402430e-01f, -1.49976000e-01f, -1.27633378e-01f, 5.95100038e-02f, -4.33691032e-02f,
  5.85865453e-02f, 2.29287166e-02f, -3.42176892e-02f, 5.42035996e-05f, -1.24371663e-01f, -1.27427980e-01f, -7.86062554e-02f, -9.18295756e-02f, -1.24589987e-01f, -1.91335171e-01f,
  -6.88541681e-02f, 3.48291770e-02f, 1.55342951e-01f, 3.00749950e-02f, 1.19034857e-01f, 1.99151095e-02f, 1.56749517e-01f, 7.31946249e-03f, -6.50028363e-02f, 1.78627327e-01f,
  -1.47982286e-02f, 2.19397292e-01f, -5.19930385e-02f, -5.35652786e-02f, 9.84915197e-02f, 7.31588528e-02f, 3.71278003e-02f, 1.09040871e-01f, 5.34370057e-02f, -1.79449692e-02f,
  -3.87817696e-02f, 1.57903507e-03f, -9.25572664e-02f, 1.84332337e-02f, 4.31613810e-02f, 5.57993725e-02f, 1.47270858e-01f, 2.25757416e-02f, 5.10616042e-02f, 3.94813940e-02f,
  -1.08476197e-02f, -5.08890375e-02f, -1.05634157e-03f, -8.65041930e-03f, 1.56839169e-03f, -1.06814146e-01f, 6.22880310e-02f, 6.47793859e-02f, 4.23837751e-02f, 8.75943303e-02f,
  -6.93228021e-02f, 3.26044150e-02f, 4.16627117e-02f, -2.25345399e-02f, 4.46774177e-02f, 3.74971516e-02f, -8.14255401e-02f, -5.79972491e-02f, -8.82390961e-02f, 1.55454531e-01f,
  -2.09815856e-02f, 2.07038205e-02f, -5.78766093e-02f, 2.52391510e-02f, -1.10115737e-01f, -7.37087205e-02f, -4.25935686e-02f, -2.76848916e-02f, -5.75436912e-02f, 1.40432436e-02f,
  -3.78013700e-02f, -4.81956638e-02f, 1.53689027e-01f, -1.72398668e-02f, 1.69957743e-03f, 6.33610860e-02f, 7.35834539e-02f, -4.67588790e-02f, 7.86069781e-02f, 5.95521405e-02f,
  8.18286017e-02f, -7.55180493e-02f, -4.09922376e-02f, -5.50759062e-02f, 3.80850360e-02f, 6.44266605e-02f, 9.38923284e-02f, 1.02648631e-01f, 1.03635728e-01f, 5.54036396e-03f,
  2.47962195e-02f, 3.58790159e-02f, 6.93765953e-02f, 6.75769597e-02f, -3.50859598e-04f, 6.63347915e-02f, 8.76302272e-02f, -1.35367084e-03f, 3.27025950e-02f, 4.14516144e-02f,
  9.96655449e-02f, -2.13740934e-02f, -2.81930305e-02f, -2.50575319e-02f, -3.20590399e-02f, -1.64461493e-01f, -2.85905898e-02f, -3.00132483e-02f, -2.22095642e-02f, -4.31967229e-02f,
  -4.34956737e-02f, 4.40240502e-02f, 1.10072039e-01f, 5.00192679e-02f, -1.47925809e-01f, -2.51124978e-01f, -1.19462945e-01f, -1.04597792e-01f, -4.39071544e-02f, 1.03666462e-01f,
  -1.22079596e-01f, 1.60240231e-03f, 1.90053597e-01f, -2.99078785e-02f, 7.18543539e-03f, 1.25757515e-01f, -4.42563035e-02f, 1.05657004e-01f, -2.69264728e-02f, -1.83446154e-01f,
  -1.28945991e-01f, 2.49091187e-03f, 2.55788211e-02f, 7.84215797e-03f, -7.57019874e-03f, 2.58484893e-02f, 1.38649702e-01f, 7.33095631e-02f, -6.66200072e-02f, 1.34984523e-01f,
  1.32142857e-01f, -8.12483206e-03f, 3.29296030e-02f, 9.30425711e-03f, -3.65136601e-02f, -4.20835577e-02f, -4.25005332e-03f, -1.99943315e-02f, 3.36278081e-02f, 5.96647570e-03f,
  -6.02675676e-02f, -6.07667863e-02f, -6.29533753e-02f, -4.55935486e-02f, -2.74087097e-02f, -1.19605195e-02f, 4.17225733e-02f, -1.78928766e-02f, 1.60779804e-02f, -5.39705642e-02f,
  -4.33343574e-02f, -9.87069011e-02f, -7.68716186e-02f, -1.28373951e-01f, -1.39610458e-03f, 4.36510099e-03f, 6.12331321e-03f, 2.12090090e-02f, -1.00287735e-01f, 1.41484141e-01f,
  -9.68175158e-02f, 5.19343391e-02f, -2.48482195e-03f, -5.15753031e-02f, -3.81885469e-02f, 3.88921946e-02f, 9.35212821e-02f, 1.89961381e-02f, -2.49830373e-02f, 1.54827386e-01f,
  2.62005329e-02f, -1.77450869e-02f, 6.37066439e-02f, -1.68606583e-02f, 1.16829626e-01f, 1.29002258e-02f, 8.69663432e-02f, -1.36035364e-02f, -5.55780083e-02f, -5.24833947e-02f,
  -4.41023633e-02f, 1.09413661e-01f, 4.38697822e-03f, 1.07692806e-02f, -6.02633879e-02f, -7.41754472e-02f, 6.33972511e-02f, 9.11763012e-02f, 6.44060150e-02f, -7.62483291e-03f,
  1.88070461e-01f, -2.37264439e-01f, 1.21620055e-02f, -1.61992256e-02f, 9.69125777e-02f, -1.09488694e-02f, 7.40339309e-02f, -7.70473182e-02f, -2.50804108e-02f, -7.59525150e-02f,
  1.46443453e-02f, 6.44150674e-02f, 9.03283730e-02f, 3.60781886e-02f, 1.74721293e-02f, -7.55221769e-03f, -8.35548118e-02f, -6.03728369e-02f, 4.75246683e-02f, -1.75204109e-02f,
  -5.74119575e-02f, -3.33748423e-02f, 2.47141887e-02f, -4.06355335e-04f, -9.47953016e-03f, 6.39412459e-03f, 2.67570894e-02f, 4.05652113e-02f, 1.72580909e-02f, 1.57657385e-01f,
  -5.21888196e-01f, 2.18689218e-01f, -5.72241880e-02f, -3.58058214e-02f, 2.07394838e-01f, 1.95594162e-01f, 1.51792094e-01f, 3.78129855e-02f, -2.44355854e-02f, 8.18346739e-02f,
  -4.74546338e-03f, -2.79580783e-02f, -8.83507952e-02f, 1.46121904e-02f, -1.82859991e-02f, 9.45271105e-02f, 2.00503588e-01f, -1.79304630e-01f, -1.70927674e-01f, -5.62413521e-02f,
  4.86397892e-02f, -8.67538601e-02f, -2.19220683e-01f, -8.70775133e-02f, 1.47429198e-01f, -1.61108939e-04f, 4.37521264e-02f, 1.38069808e-01f, 2.11552605e-01f, 1.10858798e-01f,
  -2.01087773e-01f, 1.30874336e-01f, 6.07256927e-02f, -1.20444642e-02f, -1.25393542e-02f, 3.78871821e-02f, 1.33024856e-01f, -2.29499768e-02f, -1.03047481e-02f, 1.12309970e-01f,
  8.90037715e-02f, -2.52731461e-02f, 6.21786974e-02f, 7.56540671e-02f, 1.00349419e-01f, 5.47789037e-02f, 1.09384954e-01f, 2.19381936e-02f, 3.07060555e-02f, 1.31882401e-02f,
  1.59303397e-01f, 4.38617840e-02f, -6.05537295e-02f, 2.40043085e-02f, 1.41586125e-01f, -2.03938726e-02f, 7.14763179e-02f, -2.15461329e-02f, -7.48748034e-02f, 9.57439304e-04f,
  -5.61031774e-02f, -1.67668425e-02f, 2.12322660e-02f, -2.50049997e-02f, -4.01907526e-02f, 1.05943628e-01f, 7.68378563e-03f, 3.32679190e-02f, -9.42064077e-03f, -1.22672385e-02f,
  4.54863906e-02f, 1.33214202e-02f, 7.09628835e-02f, -6.40240833e-02f, 3.93918343e-03f, -2.04361882e-03f, 1.02109462e-02f, 9.32054743e-02f, -2.74930079e-03f, 2.15786155e-02f,
  -6.81623816e-02f, 3.09536234e-02f, -4.10254952e-03f, -4.25749123e-02f, 6.88447282e-02f, -2.22105756e-02f, -3.22933681e-02f, 2.00197287e-02f, -3.04627931e-04f, 3.90408784e-02f,
  -1.42569646e-01f, 5.07922694e-02f, -8.71632397e-02f, 3.58756222e-02f, -2.68915500e-02f, 9.16451029e-03f, -6.76056091e-03f, 3.86990868e-02f, 4.79436852e-02f, 2.26552179e-03f,
  -3.34704220e-02f, 3.25048193e-02f, -7.32722506e-02f, 8.27628896e-02f, -2.41433661e-02f, -3.20436694e-02f, 7.99456029e-04f, -2.86620483e-02f, -1.29436969e-03f, -3.32260807e-03f,
  7.57139549e-02f, 1.79209132e-02f, -1.43412381e-01f, -3.78197171e-02f, 4.90131304e-02f, -1.74932137e-01f, -3.65617536e-02f, -2.36213971e-02f, -1.26847951e-02f, -4.28539440e-02f,
  1.72826290e-01f, -5.69126122e-02f, -3.05759877e-01f, 1.06513165e-01f, -6.88172206e-02f, -2.61664987e-01f, -2.85540879e-01f, -9.02963355e-02f, 2.55603213e-02f, -1.44679442e-01f,
  -7.68978000e-02f, 7.94176683e-02f, 1.43562453e-02f, 1.02743529e-01f, 1.38382306e-02f, -1.86639145e-01f, -8.37493837e-02f, -1.11993045e-01f, -1.26918554e-01f, -1.59677356e-01f,
  -1.45789899e-03f, 7.79979602e-02f, 1.79294080e-01f, 8.86205360e-02f, -6.50217291e-04f, -5.22255749e-02f, -1.37254670e-01f, 6.05183933e-03f, 9.71293543e-03f, 3.52772251e-02f,
  -2.73692071e-01f, -1.85477093e-01f, -1.77396531e-03f, 8.58068317e-02f, -5.63069023e-02f, 6.20551109e-02f, -9.72325206e-02f, -5.20932004e-02f, 9.57260579e-02f, -8.71828273e-02f,
  4.79105674e-03f, 8.40991437e-02f, 1.21315964e-01f, 5.41107245e-02f, -2.08776426e-02f, -1.51605513e-02f, 8.97061676e-02f, 8.35962873e-03f, -4.07623984e-02f, -2.95228157e-02f,
  7.21330047e-02f, -1.84335802e-02f, -1.18130662e-01f, 5.07791946e-03f, 5.04246317e-02f, 7.34493956e-02f, 1.01199644e-02f, -6.02734983e-02f, -1.39582232e-02f, -2.76204925e-02f,
  3.04918606e-02f, -9.63568408e-03f, 1.03023671e-01f, 4.50406931e-02f, 1.51253521e-01f, 1.51865045e-02f, -3.45225423e-03f, -3.00629903e-02f, 9.36173350e-02f, 6.25350997e-02f,
  1.02745809e-01f, -1.08976297e-01f, 2.64395289e-02f, 2.12290417e-02f, 3.34330946e-02f, -7.24608302e-02f, 2.97538079e-02f, 4.33496721e-02f, 3.52870859e-02f, 2.69656964e-02f,
  1.12678483e-01f, 3.00256908e-02f, -3.36942226e-02f, 5.18825091e-02f, 1.31146079e-02f, -6.83931559e-02f, -1.73135847e-02f, 5.78774475e-02f, 4.41637188e-02f, -5.41760065e-02f,
  9.76923779e-02f, -1.67006161e-02f, -7.41297305e-02f, 1.06874205e-01f, -1.83685012e-02f, -3.74648571e-02f, -3.14553753e-02f, 1.99271347e-02f, 5.89639880e-02f, -9.46946889e-02f,
  -1.05940156e-01f, 8.56454857e-03f, -4.06092703e-02f, -5.72695099e-02f, -3.67550254e-02f, -4.77329344e-02f, 1.29643470e-01f, -6.87727556e-02f, -1.40421167e-02f, -5.21724038e-02f,
  4.07686643e-02f, 1.46283284e-02f, 5.48087340e-03f, -9.81481150e-02f, 9.46068466e-02f, 1.00344189e-01f, 1.12485411e-02f, 4.79550213e-02f, -9.00903866e-02f, 9.03118961e-03f,
  -3.75143111e-01f, -8.73056352e-02f, 1.61990598e-01f, -2.45011628e-01f, 1.26340225e-01f, 1.92179546e-01f, 1.76912874e-01f, -1.99017487e-02f, -1.21125445e-01f, -7.24444315e-02f,
  -1.71625569e-01f, -1.60989851e-01f, -1.65591493e-01f, -1.49307027e-01f, -1.30543881e-03f, 9.77964774e-02f, 8.73024985e-02f, -4.66731079e-02f, 1.10699460e-01f, 4.98000979e-02f,
  -5.04625961e-02f, -2.05813825e-01f, -2.65544504e-01f, -7.52049610e-02f, -8.97343233e-02f, -7.23660886e-02f, -2.80880090e-02f, -1.42232084e-03f, 5.76004609e-02f, -1.41755357e-01f,
  1.06587946e-01f, -2.06353933e-01f, 3.23348828e-02f, -2.19808400e-01f, -4.50927876e-02f, -8.75393450e-02f, -4.74769771e-02f, -1.17870994e-01f, -4.47547771e-02f, -1.06376216e-01f,
  -1.14868775e-01f, -5.70302503e-03f, -7.50898421e-02f, -1.58184897e-02f, -4.68052290e-02f, 1.00851199e-02f, -2.35385261e-02f, -6.12619109e-02f, -9.24077407e-02f, 9.73695796e-03f,
  -7.93256015e-02f, 9.96301882e-03f, 2.03212001e-03f, 2.08226242e-03f, 7.99914747e-02f, 3.60536687e-02f, -1.67202819e-02f, 1.81341004e-02f, 4.55447324e-02f, -1.26259759e-01f,
  1.24537237e-02f, 2.37293486e-02f, 1.10828713e-01f, -1.29071837e-02f, 6.05645254e-02f, 1.73106100e-02f, -6.44689128e-02f, 1.33991642e-02f, 7.80294975e-03f, 3.49246673e-02f,
  -1.43188722e-02f, 9.39705446e-02f, -3.17551345e-02f, 9.80942510e-03f, -2.11433806e-02f, 3.16209160e-02f, 4.20447253e-02f, -2.48245578e-02f, 3.85726839e-02f, 1.31544411e-01f,
  2.46812496e-02f, 4.00899835e-02f, -1.78326871e-02f, 6.36855587e-02f, 9.73883346e-02f, 4.57015373e-02f, 8.36672783e-02f, 4.43068258e-02f, -4.26863804e-02f, -2.55041067e-02f,
  -8.35154147e-04f, -5.51850200e-02f, -1.24757513e-01f, -8.97308737e-02f, -2.79519837e-02f, -9.38450247e-02f, -1.09389581e-01f, -7.42994025e-02f, -2.76396554e-02f, -4.06126939e-02f,
  1.53742833e-02f, -1.04757071e-01f, -1.01550758e-01f, -9.63790715e-02f, 9.89067275e-03f, -7.32574612e-02f, -1.09391876e-01f, -5.28468043e-02f, -8.08798075e-02f, 2.55910810e-02f,
  -3.61509733e-02f, -3.02502010e-02f, 9.77011323e-02f, -7.72070065e-02f, 1.97341060e-03f, 8.09750520e-03f, -9.49416030e-03f, -3.66408005e-02f, 8.19265768e-02f, 4.19637607e-03f,
  2.51017094e-01f, -2.42366314e-01f, 4.02767286e-02f, 3.65959369e-02f, -1.26148343e-01f, -3.39876972e-02f, -9.66009572e-02f, 3.89532633e-02f, 5.50998747e-02f, -1.50950268e-01f,
  -2.99335927e-01f, -2.33755067e-01f, -6.98877722e-02f, -1.39946908e-01f, 4.67278585e-02f, 1.91912912e-02f, 1.73477247e-01f, 1.94047004e-01f, 1.91496894e-01f, 1.80932845e-03f,
  4.90100794e-02f, 1.72564998e-01f, 1.41100913e-01f, 4.67813648e-02f, 9.52100456e-02f, 6.00460060e-02f, 1.17884107e-01f, 1.60294428e-01f, 4.89147455e-02f, 2.22391441e-01f,
  -8.85164887e-02f, -5.90398461e-02f, -1.93101447e-02f, -1.04157083e-01f, -8.70300978e-02f, 1.11014843e-01f, -4.31209318e-02f, 8.23705569e-02f, -3.08053810e-02f, -1.17714135e-02f,
  -1.25748338e-02f, 2.71542780e-02f, 2.43451186e-02f, 8.87017772e-02f, 6.10003918e-02f, 6.60088882e-02f, 5.68018965e-02f, 1.30983651e-01f, 5.30157313e-02f, -3.57511789e-02f,
  -5.81116825e-02f, -1.08173806e-02f, 5.15617318e-02f, 8.34315121e-02f, 1.11059047e-01f, 3.00311688e-02f, 8.05694163e-02f, 6.61485121e-02f, 7.58893862e-02f, 2.48167202e-01f,
  -5.95235825e-03f, -6.65751472e-02f, -1.89191904e-02f, -5.20039238e-02f, 1.92222726e-02f, 1.13819856e-02f, 3.21538113e-02f, 1.97674129e-02f, -1.95689276e-02f, 3.37920822e-02f,
  5.24431327e-03f, -3.71855348e-02f, 7.11589754e-02f, -8.90720859e-02f, -5.50276460e-03f, -1.86173674e-02f, 4.19658832e-02f, -2.91964915e-02f, 4.49235998e-02f, 4.85338183e-04f,
  -3.72890532e-02f, -3.39380950e-02f, 4.47505265e-02f, 2.55757552e-02f, 2.70421058e-03f, 4.11501527e-02f, 7.38761500e-02f, -5.50440587e-02f, -3.05412114e-02f, -1.33056967e-02f,
  -1.20084174e-01f, -1.67464703e-01f, 5.25527075e-02f, 1.77287102e-01f, 3.02184764e-02f, 8.21187124e-02f, 6.10123016e-02f, 8.30673277e-02f, 5.61423600e-03f, 7.82306399e-03f,
  9.77435410e-02f, 1.68272350e-02f, -7.36199766e-02f, 1.18571721e-01f, 8.40255022e-02f, 3.21750529e-02f, 3.61370631e-02f, 1.13068722e-01f, -1.33319665e-02f, 1.44231811e-01f,
  5.90138026e-02f, 9.11061540e-02f, 1.32212088e-01f, -1.31036388e-02f, -5.74465049e-03f, 1.77061744e-02f, 7.40703344e-02f, 1.72977537e-01f, 1.21633537e-01f, 1.99561194e-01f,
  -2.87484545e-02f, -2.98602842e-02f, 1.32504538e-01f, 7.58688599e-02f, -1.28644884e-01f, -1.12594903e-01f, 1.02059066e-01f, 6.02484718e-02f, -4.78599817e-02f, 7.55455270e-02f,
  -2.40937024e-01f, -2.85377264e-01f, -1.20888248e-01f, -1.08035050e-01f, 9.00765657e-02f, 2.03433722e-01f, 3.03199351e-01f, 1.20290644e-01f, 1.71748251e-02f, -4.46145162e-02f,
  1.02707185e-03f, 9.77282375e-02f, -1.03567056e-01f, -5.09439111e-02f, -5.94564937e-02f, -1.02423370e-01f, 2.06977148e-02f, -7.89012834e-02f, -2.16206294e-02f, 1.68402568e-01f,
  4.26836610e-02f, -2.06310809e-01f, -2.13481486e-01f, -1.53098032e-01f, -2.54613101e-01f, -1.33763030e-01f, -8.52567852e-02f, -1.34033844e-01f, -1.57018974e-01f, -1.11808687e-01f,
  -2.26134956e-01f, -1.65176049e-01f, -1.11987673e-01f, -1.04337364e-01f, -5.08903340e-02f, -1.42410830e-01f, -8.88867676e-02f, -4.17436138e-02f, -8.34982321e-02f, -9.03636292e-02f,
  -1.54148519e-01f, -1.85049817e-01f, -1.38149202e-01f, -1.08074494e-01f, -1.52876854e-01f, -2.21809000e-01f, -1.69685587e-01f, -1.47261754e-01f, -1.37093127e-01f, -3.52747031e-02f,
  1.30881920e-01f, 1.63178802e-01f, 8.37904587e-02f, 1.39812171e-01f, 8.52660537e-02f, 1.07562050e-01f, 3.97313051e-02f, 2.89266352e-02f, 8.59364569e-02f, 1.84907392e-02f,
  6.74293488e-02f, -1.01768726e-03f, 2.98073553e-02f, 4.86291423e-02f, 2.54545752e-02f, 6.62315637e-03f, 1.02100849e-01f, -3.03985700e-02f, -2.76072021e-03f, 2.47068889e-02f,
  8.49036723e-02f, 3.92562374e-02f, 4.43103574e-02f, 5.90152713e-03f, 7.16550276e-03f, 7.63034970e-02f, 5.37161268e-02f, 2.22273096e-02f, -1.65431052e-02f, 1.26870692e-01f,
  -1.87579691e-01f, -2.83606470e-01f, -4.31259908e-02f, -1.47507414e-01f, -1.64345339e-01f, -4.97130044e-02f, -1.77882031e-01f, -1.45806208e-01f, -2.00314566e-01f, -8.54950324e-02f,
  -2.09247425e-01f, -1.19745128e-01f, -7.02662095e-02f, 2.98450943e-02f, -8.79461914e-02f, -1.15927689e-01f, -5.92456907e-02f, -4.50511537e-02f, -1.67042345e-01f, -5.69631271e-02f,
  -5.42158745e-02f, -6.01937855e-03f, -1.59263670e-01f, -4.26412523e-02f, -1.33368641e-01f, -1.40721366e-01f, 2.26517837e-03f, -1.12676583e-01f, -4.17250507e-02f, 1.16366476e-01f,
  2.86805891e-02f, 5.38664870e-02f, 1.73570916e-01f, -7.00467154e-02f, -1.52760581e-03f, -1.29834667e-01f, -2.06292972e-01f, -2.02165142e-01f, -2.17387617e-01f, -4.58739102e-02f,
  -1.25144254e-02f, 4.01833877e-02f, 2.86530852e-02f, -2.90342644e-02f, -1.48455322e-01f, -3.96450460e-02f, 4.87792008e-02f, 1.26009896e-01f, -1.18876189e-01f, -6.04465380e-02f,
  2.43994012e-03f, 1.58563666e-02f, -6.07880838e-02f, -1.59011737e-01f, -2.94023938e-02f, -1.21069215e-01f, -2.99906284e-02f, -1.56052969e-02f, 4.74667884e-02f, 1.03567690e-01f,
  1.76354468e-01f, 7.72748962e-02f, -1.11501917e-01f, -7.00307116e-02f, -7.15326294e-02f, -7.08307475e-02f, -1.24077141e-01f, -4.97547872e-02f, -1.41958594e-02f, -1.02547899e-01f,
  2.32950598e-02f, -9.48922187e-02f, 3.79528999e-02f, -6.74947873e-02f, -7.91860968e-02f, -1.52857468e-01f, -8.56976956e-02f, 6.13192320e-02f, -8.30273926e-02f, -9.58202258e-02f,
  4.48520258e-02f, 1.01418711e-01f, 2.36845575e-03f, -9.01438296e-02f, -1.20564237e-01f, -1.15246020e-01f, -9.52445269e-02f, -1.05598487e-01f, -1.96923763e-01f, -1.59395203e-01f,
  -1.91491246e-02f, -5.83293922e-02f, -6.05639536e-03f, -4.82738204e-03f, 7.43922079e-03f, 8.30607489e-02f, 2.67541362e-03f, -2.70956326e-02f, -5.82672283e-03f, -4.63297628e-02f,
  -6.91263229e-02f, 1.25204287e-02f, 2.22804565e-02f, 8.04483332e-03f, 5.34412898e-02f, 3.90156806e-02f, -2.14568730e-02f, -5.70404567e-02f, -3.26413698e-02f, -4.66150045e-02f,
  5.01183607e-02f, 4.87345494e-02f, -6.44811466e-02f, -2.24139802e-02f, 6.35122210e-02f, 1.17635012e-01f, 1.63517445e-02f, -8.61274600e-02f, -1.46345928e-01f, 6.26273304e-02f,
  -1.62615359e-01f, 7.87036419e-02f, 7.50274360e-02f, 9.97285315e-05f, -1.96591895e-02f, -7.49348775e-02f, 7.10761622e-02f, 5.05839810e-02f, -4.51767370e-02f, 7.50536099e-04f,
  -9.11422912e-03f, -6.61796927e-02f, -1.71061121e-02f, 1.93011742e-02f, -1.27774522e-01f, -2.98984144e-02f, 4.82842512e-02f, 9.38977450e-02f, -1.17723122e-01f, -1.51617732e-02f,
  -1.38979763e-01f, -2.10089386e-01f, -1.69306681e-01f, -7.27983266e-02f, -1.44122288e-01f, -3.86138409e-02f, -1.20790921e-01f, -1.74755275e-01f, -1.58443272e-01f, -1.62440002e-01f,
  1.59202799e-01f, 1.65805414e-01f, -2.09116220e-01f, -4.76314463e-02f, 5.89405410e-02f, 3.40252928e-02f, 2.27533415e-01f, 8.26033056e-02f, -9.92131457e-02f, 4.32195179e-02f,
  1.72399599e-02f, -1.89933881e-01f, -2.00946450e-01f, -2.40916967e-01f, -1.42750338e-01f, -8.56675729e-02f, -1.18996479e-01f, -3.09288234e-01f, -2.17744336e-01f, -9.79092494e-02f,
  -9.32016447e-02f, -1.87485129e-01f, -1.21621773e-01f, -2.15270802e-01f, -5.40476032e-02f, -3.22337300e-01f, -2.24980071e-01f, -1.34565443e-01f, -1.70540631e-01f, -2.67389923e-01f,
  -1.44276917e-01f, 6.35447279e-02f, -1.45434350e-01f, -8.09356198e-02f, -1.24840982e-01f, -1.51575223e-01f, -4.10221964e-02f, -1.07947506e-01f, -1.33692883e-02f, -5.81091605e-02f,
  -1.92553997e-02f, -5.24030402e-02f, -4.43066508e-02f, -3.01237442e-02f, -3.44990268e-02f, -1.74866468e-02f, -3.54994386e-02f, -1.82073683e-01f, -9.06025544e-02f, -1.15256831e-01f,
  3.62349674e-02f, 4.97881770e-02f, -5.04889861e-02f, -7.56803080e-02f, -1.21397138e-01f, -1.65611953e-01f, -6.71871677e-02f, -5.81371598e-02f, -1.91852137e-01f, -3.01179811e-02f,
  1.24319129e-01f, 1.89012140e-02f, -1.82382353e-02f, 3.80008630e-02f, 5.82261663e-03f, 6.51329905e-02f, -7.74868354e-02f, 1.05756279e-02f, -2.16154978e-02f, -3.06737684e-02f,
  2.04763971e-02f, -2.58659199e-03f, 6.80637173e-03f, -1.65539759e-03f, -7.98250660e-02f, -1.80931240e-02f, -1.42025528e-03f, -1.66495312e-02f, 3.01867295e-02f, 1.50116731e-03f,
  -3.35501917e-02f, 5.82757499e-03f, -7.68573303e-03f, -1.64714511e-02f, -9.64876786e-02f, 4.05220278e-02f, -7.16018528e-02f, 1.84339471e-02f, -1.03293341e-02f, 1.02793284e-01f,
  -1.19107328e-01f, -1.54613256e-01f, -1.15574449e-02f, -1.21086016e-02f, -1.20979719e-01f, -1.04393877e-01f, -1.19205236e-01f, -9.09101367e-02f, -1.53897822e-01f, 8.97775218e-03f,
  -6.76411539e-02f, -1.05194598e-02f, -3.57790254e-02f, -1.31699994e-01f, -5.88126369e-02f, -4.65613790e-02f, -5.09568192e-02f, -4.82554510e-02f, -1.60573602e-01f, 2.35797446e-02f,
  -2.03434490e-02f, 5.57531230e-02f, 6.66376799e-02f, -1.10351145e-01f, -7.13556334e-02f, -5.03369328e-03f, -7.53190517e-02f, -9.55740362e-02f, -1.42710179e-01f, -4.12337258e-02f,
  1.72850206e-01f, 9.21861455e-02f, 1.82085872e-01f, 1.42645553e-01f, 1.27204970e-01f, 2.04457581e-01f, 6.29517362e-02f, 1.79685839e-02f, 9.18351710e-02f, 2.70596854e-02f,
  -8.62099789e-03f, 7.13516399e-02f, 1.55795394e-02f, -1.08089067e-01f, -1.85391039e-03f, -9.98229370e-04f, -1.12877730e-02f, -5.18320594e-03f, 6.15010709e-02f, 7.63118453e-03f,
  1.03446841e-01f, 1.15034878e-01f, 3.86716239e-02f, 4.20277528e-02f, 7.20289722e-02f, 6.63557574e-02f, 4.40112911e-02f, 1.27631128e-01f, 1.28394455e-01f, 4.69892286e-02f,
  2.93663919e-01f, 8.34126547e-02f, -1.15140662e-01f, -9.96134132e-02f, 7.49818534e-02f, -9.43511203e-02f, -3.01905181e-02f, -1.22011796e-01f, -1.30189061e-02f, -1.87611859e-02f,
  -5.27316667e-02f, -6.88742548e-02f, 3.60581316e-02f, -5.33253103e-02f, -4.47192565e-02f, 3.65328928e-03f, -5.93820140e-02f, -6.99391961e-02f, -1.24728449e-01f, -1.29526377e-01f,
  -5.94765358e-02f, -6.18996620e-02f, 2.26552300e-02f, -5.14568798e-02f, -1.86252524e-03f, 3.29736136e-02f, -3.52202766e-02f, 2.97383871e-02f, 2.84929741e-02f, -2.73394329e-03f,
  -8.66470933e-02f, -4.23664525e-02f, -2.00684480e-02f, -8.01306590e-02f, 6.33043945e-02f, 3.75455245e-02f, -8.43834504e-02f, -3.38549688e-02f, -4.88198642e-03f, 2.18008552e-02f,
  -2.37588435e-02f, 7.93252140e-02f, -2.29997300e-02f, -1.55503489e-02f, 6.02237135e-02f, -3.53942104e-02f, -4.32920493e-02f, -6.39572591e-02f, -1.08904257e-01f, -7.57875964e-02f,
  -6.20984770e-02f, -3.63059826e-02f, -3.85738350e-02f, -1.29602060e-01f, -4.93929163e-02f, -8.01509321e-02f, 3.86933200e-02f, -1.18235052e-02f, 2.47495677e-02f, 1.00700013e-01f,
  2.26008773e-01f, -1.08030848e-02f, 6.28244132e-02f, -8.41813833e-02f, -5.25925644e-02f, -9.32202712e-02f, -2.03518886e-02f, -1.13323353e-01f, -5.95417880e-02f, 3.53905302e-03f,
  -7.47694299e-02f, -9.04763341e-02f, 2.65761930e-02f, -9.59661901e-02f, 2.85532009e-02f, 1.69623550e-02f, -1.18524186e-01f, 8.89747683e-03f, -1.37246519e-01f, -1.19554773e-01f,
  -9.24185216e-02f, -6.18444309e-02f, -1.54861063e-01f, -2.34937705e-02f, -5.19173332e-02f, -4.35424000e-02f, -6.16151914e-02f, 1.31907910e-02f, -4.55173384e-03f, -8.05009380e-02f,
  1.46793257e-02f, 2.05450714e-01f, 2.15221673e-01f, 2.53776222e-01f, 1.45550072e-01f, 1.75364092e-01f, 1.55003607e-01f, 1.10726528e-01f, 1.16500750e-01f, 1.68618023e-01f,
  1.52733549e-01f, 2.91430652e-02f, 1.33980513e-01f, 4.84463722e-02f, 1.91042677e-01f, 1.61265090e-01f, 1.76666915e-01f, 1.06734894e-01f, -1.27598941e-02f, 3.41164470e-02f,
  7.58713111e-02f, 6.59791678e-02f, 3.33968713e-03f, -2.40338054e-02f, 1.11491106e-01f, 1.30902156e-01f, 1.73499838e-01f, 1.20411381e-01f, 7.43426532e-02f, 6.42377362e-02f,
  1.99966952e-01f, 6.66945726e-02f, 1.10716060e-01f, 1.24265663e-01f, 6.67260960e-02f, 8.45594238e-03f, 7.17529580e-02f, 1.11011162e-01f, 1.06810376e-01f, 8.63308609e-02f,
  2.25416459e-02f, 6.34245425e-02f, 9.95500088e-02f, -5.55777363e-02f, 4.48618904e-02f, 5.95533662e-02f, 6.40651118e-03f, 1.54210746e-01f, 1.50515303e-01f, 1.39638141e-01f,
  4.15609181e-02f, 1.78915203e-01f, 1.88728392e-01f, 7.02695549e-02f, 1.19771942e-01f, 1.02081865e-01f, 3.62209772e-04f, -1.34195788e-02f, 1.01126291e-01f, 9.84922722e-02f,
  -2.76249163e-02f, -1.17565505e-02f, 2.10146625e-02f, -1.13550007e-01f, -3.49360481e-02f, 6.22582585e-02f, -3.82852815e-02f, -1.33668343e-02f, -1.04791813e-01f, -4.86543365e-02f,
  -3.58945094e-02f, -9.32091102e-03f, -3.63711417e-02f, -1.77088398e-02f, -4.92448919e-02f, 5.45152240e-02f, -9.92852543e-03f, 5.11664115e-02f, 4.08456139e-02f, -2.81877033e-02f,
  -3.96844782e-02f, 3.68690267e-02f, 5.48869260e-02f, 3.79028618e-02f, 1.02334678e-01f, 1.24429949e-02f, -9.39971674e-03f, -3.89094278e-02f, -6.18826114e-02f, -9.93898362e-02f,
  2.33939633e-01f, -1.33397505e-02f, 8.37588459e-02f, 8.86851456e-03f, 7.77031630e-02f, 9.55419391e-02f, 3.65849063e-02f, 9.16062295e-02f, -3.60885970e-02f, 1.01365643e-02f,
  -1.85906712e-03f, 7.78612345e-02f, 4.62081172e-02f, -2.31461488e-02f, 1.35702919e-02f, -1.01875089e-01f, 8.11339095e-02f, -1.52976869e-03f, 1.73288789e-02f, 5.89829683e-02f,
  1.08605772e-01f, 6.56034574e-02f, 1.20719038e-01f, 8.42226744e-02f, 7.69649968e-02f, 1.17870159e-01f, 7.47355297e-02f, 6.06625229e-02f, 5.56798540e-02f, 1.87661648e-01f,
  -3.20137113e-01f, 2.28274360e-01f, 8.03992674e-02f, -1.55526996e-01f, 2.18450531e-01f, 2.29464754e-01f, 3.55750769e-01f, 9.20840725e-02f, 3.51318484e-03f, 1.12347215e-01f,
  -1.74526200e-02f, -2.33435839e-01f, -1.75301448e-01f, -1.74307078e-02f, 2.28619613e-02f, 2.74958938e-01f, 2.08273485e-01f, -6.15617372e-02f, -2.52137452e-01f, -4.78358380e-03f,
  2.56466642e-02f, -4.83781844e-02f, -1.66493833e-01f, -1.08059913e-01f, -5.37476316e-03f, 6.78106025e-02f, 1.42743722e-01f, -5.86536825e-02f, 7.23391920e-02f, 7.71507248e-02f,
  -1.13863155e-01f, -7.89194405e-02f, 1.22737419e-02f, 3.24540213e-02f, 3.30845974e-02f, -4.01091538e-02f, 2.13348437e-02f, -4.37075309e-02f, 1.98522042e-02f, -2.99776923e-02f,
  -4.48309891e-02f, -8.31390247e-02f, -9.77821946e-02f, 2.23212745e-02f, 4.49403487e-02f, -5.40299192e-02f, -2.71529425e-02f, -1.19535968e-01f, -7.01771826e-02f, -7.52143795e-04f,
  1.27292618e-01f, -1.00342400e-01f, -3.42019834e-02f, 1.00134052e-01f, 6.52024383e-03f, -1.08993717e-01f, 2.38578971e-02f, -7.17139989e-02f, -6.63124844e-02f, 9.79662612e-02f,
  7.29821771e-02f, -9.87555757e-02f, 1.78761035e-02f, -1.06634991e-02f, 3.42941135e-02f, 2.73194127e-02f, -8.40360075e-02f, -2.30781129e-03f, -7.90762976e-02f, 4.71576415e-02f,
  -8.65763426e-02f, -7.86423981e-02f, -7.04841083e-03f, -5.94574260e-03f, -6.95576370e-02f, 9.92860645e-03f, -7.42270704e-03f, -2.28967685e-02f, 3.17126438e-02f, 1.79046555e-03f,
  -6.08882308e-02f, 6.66625872e-02f, -8.64687487e-02f, -1.10269032e-01f, -4.46792170e-02f, -1.96172502e-02f, 1.59851648e-02f, -8.58413056e-02f, -8.81130323e-02f, -1.50963264e-02f,
  1.99776471e-01f, 6.31806478e-02f, -1.52771026e-02f, -7.48140388e-04f, 8.48509967e-02f, -3.26427259e-03f, 2.14912854e-02f, 1.03232451e-02f, -2.78787166e-02f, 3.42344795e-03f,
  -2.63679139e-02f, -8.01435858e-02f, -8.35555885e-03f, -8.35127942e-03f, 2.24114154e-02f, 9.22174603e-02f, 1.59519941e-01f, 5.88598326e-02f, 6.70121312e-02f, 3.24991941e-02f,
  1.62258446e-01f, 1.37507543e-01f, 1.32352144e-01f, 1.70623437e-01f, -5.17918076e-03f, 1.22777030e-01f, -6.93279842e-04f, 1.29550472e-01f, 5.11392355e-02f, 2.57862508e-01f,
  -1.45923346e-01f, 3.67408134e-02f, -2.47491464e-01f, -8.18751752e-02f, -1.15758352e-01f, -8.54487419e-02f, -5.43899275e-02f, 5.33222593e-02f, -8.82614031e-02f, 1.40095413e-01f,
  1.75496817e-01f, 2.08151117e-02f, -5.71358688e-02f, -1.47791654e-01f, -2.31831565e-01f, -2.67548084e-01f, -3.32003474e-01f, -3.51838261e-01f, -2.96884209e-01f, -5.85428067e-02f,
  -1.13402680e-01f, -1.47527680e-01f, -2.24816635e-01f, -9.18940455e-02f, 1.34137692e-04f, -1.70986742e-01f, -1.47308633e-01f, -1.20938815e-01f, -1.33914948e-01f, -1.15705013e-01f,
  -2.42863744e-02f, -4.71811369e-02f, -1.21769622e-01f, -1.57612935e-02f, -1.22295983e-01f, -8.11007395e-02f, -5.08954450e-02f, -3.07529885e-02f, -3.68585438e-02f, 1.22063970e-02f,
  -1.89854074e-02f, -3.31719704e-02f, -7.01879933e-02f, -4.36389595e-02f, -3.87964584e-02f, 4.09877524e-02f, -2.83204503e-02f, -1.72053412e-01f, -5.88141680e-02f, -2.13042963e-02f,
  -2.29841750e-02f, -7.16834888e-02f, -2.28219882e-01f, -7.90433735e-02f, -1.38476908e-01f, -1.27238736e-01f, -1.23923093e-01f, -1.35682775e-02f, -4.88971360e-02f, 1.29692852e-02f,
  6.78512305e-02f, 5.97060323e-02f, 5.01484703e-03f, 1.51886627e-01f, 1.12818614e-01f, 1.19844705e-01f, 1.36953324e-01f, 8.41914266e-02f, 1.21826485e-01f, 1.84485346e-01f,
  1.20404497e-01f, 1.22537017e-01f, 1.30471140e-01f, 1.71951666e-01f, 7.92170689e-02f, 9.46878791e-02f, 1.43098682e-01f, 1.01473317e-01f, 1.05370447e-01f, 8.29674229e-02f,
  4.11613435e-02f, 1.06415629e-01f, 1.49690971e-01f, 1.22399822e-01f, 7.46361464e-02f, 6.24881014e-02f, 1.78311467e-01f, 2.13559031e-01f, 1.47677407e-01f, 8.77655149e-02f,
  -4.53156307e-02f, -2.63200641e-01f, -1.10420063e-01f, -2.65907235e-02f, -2.12211832e-01f, -1.02269314e-01f, -5.37760071e-02f, -2.40419973e-02f, -4.70542796e-02f, 2.56557092e-02f,
  -2.76609678e-02f, -1.00271359e-01f, -4.78046201e-02f, 1.60222556e-02f, -1.42131284e-01f, -1.02032043e-01f, -6.05856031e-02f, -1.01803392e-01f, -1.82440266e-01f, 1.13453073e-02f,
  -6.55060709e-02f, -1.63802188e-02f, -1.74981281e-01f, -1.42694637e-01f, -1.83672130e-01f, -1.36851668e-01f, -1.65033817e-01f, -1.56499013e-01f, -1.40239283e-01f, -3.27994823e-02f,
  -3.42509925e-01f, 3.37176472e-02f, -4.99048159e-02f, -1.91487193e-01f, 2.99330771e-01f, 2.72289991e-01f, 2.33027220e-01f, -1.22939907e-01f, -1.09859765e-01f, 9.50037502e-03f,
  1.11448355e-01f, 4.72479053e-02f, -1.86059717e-02f, -6.30991235e-02f, -1.02658466e-01f, 1.12788372e-01f, 1.20913826e-01f, -1.13068866e-02f, 5.72755225e-02f, 1.48652375e-01f,
  2.18963817e-01f, 8.67582299e-03f, -1.78273961e-01f, 1.23817390e-02f, 8.58826637e-02f, 3.17298882e-02f, 2.76674274e-02f, 3.03129479e-02f, 2.25889102e-01f, 4.46425900e-02f,
  4.21998464e-02f, -4.40740883e-02f, -2.96871387e-03f, -3.92546095e-02f, -5.92299178e-02f, -1.19523555e-01f, -7.88338259e-02f, -1.32087559e-01f, -8.52339063e-03f, -1.23859487e-01f,
  5.24054207e-02f, 2.73534916e-02f, -2.66145859e-02f, -8.64531174e-02f, -3.90828960e-02f, -7.71293193e-02f, -1.07342035e-01f, -1.59799084e-01f, -1.12770766e-01f, -9.40759014e-03f,
  6.96795136e-02f, 1.09024994e-01f, 1.08450465e-01f, -5.03160618e-02f, 4.23427410e-02f, 9.69951153e-02f, 8.13328996e-02f, -3.02940520e-04f, -8.27295110e-02f, -2.02380568e-01f,
  -1.84257340e-03f, 9.40505639e-02f, 8.08121860e-02f, -8.12470040e-04f, 2.37530619e-02f, 4.77423780e-02f, 4.23455648e-02f, 7.86553174e-02f, -1.06765719e-05f, -1.44252891e-03f,
  -4.07333374e-02f, 5.96589148e-02f, 5.83407804e-02f, -5.98978885e-02f, 3.30322012e-02f, 5.20257466e-02f, 1.22067876e-01f, 1.98377334e-02f, -1.72064751e-02f, 5.46912439e-02f,
  3.71706784e-02f, -3.40070017e-02f, 2.88363770e-02f, 8.66584405e-02f, 4.78877127e-02f, 3.54051851e-02f, 2.07742117e-03f, 6.29746020e-02f, -7.74464756e-02f, 2.00205687e-02f,
  -2.20156878e-01f, 1.38946503e-01f, 2.53157802e-02f, -7.05715222e-03f, 7.60209188e-02f, -2.55722143e-02f, 1.27120391e-01f, -1.56951919e-02f, 8.18873718e-02f, -7.88349733e-02f,
  1.06607839e-01f, -5.34066185e-02f, 2.17065010e-02f, 5.22633642e-02f, 4.25549112e-02f, -3.82240932e-03f, 3.94702964e-02f, 1.25334039e-01f, 7.31864795e-02f, -2.44837292e-02f,
  1.31981249e-03f, 8.18376765e-02f, 1.10489875e-01f, 6.58313483e-02f, -6.10936852e-03f, 8.21375996e-02f, 2.50544716e-02f, 2.28822660e-02f, 1.31269574e-01f, -1.00832254e-01f,
  4.99879807e-01f, -6.91415966e-02f, -8.77493098e-02f, 1.33977696e-01f, -1.62604406e-01f, -5.70137203e-02f, -1.66063160e-01f, -1.30894743e-02f, 5.50421216e-02f, 5.06492816e-02f,
  3.59462835e-02f, 8.52510929e-02f, 2.66575404e-02f, 3.09214033e-02f, -2.18158737e-02f, -6.57529831e-02f, -1.27818301e-01f, -5.35839610e-02f, 5.26473373e-02f, 4.69420850e-02f,
  9.99318659e-02f, 6.44624792e-03f, 8.55690017e-02f, 2.34639905e-02f, 1.42551869e-01f, 2.14746296e-01f, -2.24416666e-02f, -6.61652237e-02f, 2.38816347e-02f, 1.51359037e-01f,
  2.21180722e-01f, -2.20005885e-02f, 1.02222137e-01f, 2.00451329e-01f, -1.53333880e-03f, 5.07093258e-02f, 5.17044812e-02f, 7.31414557e-03f, -1.92793533e-02f, 1.41771110e-02f,
  1.32264569e-01f, -1.20366756e-02f, -3.92708704e-02f, 2.25839075e-02f, 4.41135652e-02f, -1.64271276e-02f, -1.18756570e-01f, -7.81472921e-02f, -1.70242470e-02f, -7.33343288e-02f,
  -6.48372769e-02f, 7.29522333e-02f, 7.21515790e-02f, -7.81716779e-02f, -6.25732541e-02f, 8.58448371e-02f, 6.09416375e-03f, 1.06738187e-01f, 9.20671970e-02f, 2.35017031e-01f,
  1.91873852e-02f, -5.08085638e-02f, -1.12126887e-01f, -9.69154984e-02f, 2.05452554e-02f, -9.15349424e-02f, -7.21873939e-02f, 6.19724467e-02f, -1.01909362e-01f, -1.73791405e-03f,
  2.17805263e-02f, -5.24731576e-02f, -6.14230707e-03f, 8.40603635e-02f, -6.43108115e-02f, -4.39245403e-02f, 7.25379512e-02f, 8.80160704e-02f, -1.97222233e-02f, 4.95956354e-02f,
  2.05603894e-02f, 1.09609067e-01f, -9.08483937e-02f, 1.81974713e-02f, -3.36743966e-02f, -5.72531335e-02f, 3.25059034e-02f, 6.16843365e-02f, 2.68235784e-02f, -3.78690980e-04f,
  1.32762849e-01f, -1.93749130e-01f, 1.90067455e-01f, 1.30898640e-01f, 1.11956969e-01f, 8.49279836e-02f, 4.23183292e-02f, 8.11141133e-02f, 3.26299705e-02f, 6.92253634e-02f,
  -5.18914731e-03f, 7.06356391e-02f, 4.42870371e-02f, -5.51396832e-02f, 3.99832502e-02f, 2.23218873e-02f, -1.28017114e-02f, 1.33308470e-01f, -3.41791548e-02f, 5.72349876e-03f,
  4.63381857e-02f, 1.68903112e-01f, 2.22137302e-01f, 1.26507685e-01f, 4.17504124e-02f, 2.28554174e-01f, 1.67318329e-01f, 2.20848083e-01f, 1.07231602e-01f, 2.10206524e-01f,
  4.67871577e-01f, -2.65349805e-01f, 1.76190250e-02f, 1.98155046e-02f, -1.39947176e-01f, -9.65511128e-02f, -1.01319984e-01f, 1.41555697e-01f, 5.42720258e-02f, -1.25563681e-01f,
  -1.94604963e-01f, 5.58489263e-02f, -2.79257428e-02f, 1.20650016e-01f, 2.13014752e-01f, 6.57968670e-02f, 4.61322740e-02f, 1.62453800e-01f, 3.47294271e-01f, 6.27813339e-02f,
  -9.30412859e-02f, 9.59828272e-02f, 1.41627416e-01f, 9.37954336e-02f, -9.41456482e-02f, -4.62373160e-03f, -1.46757454e-01f, -1.35524571e-01f, -2.03651890e-01f, -1.63829118e-01f,
  -2.30882261e-02f, -1.71885028e-01f, 5.35255438e-03f, -7.52495974e-02f, -2.52658967e-02f, 8.97804499e-02f, 4.12240550e-02f, 5.49155474e-02f, -2.77934670e-02f, 2.12516803e-02f,
  -3.27596851e-02f, -4.21041623e-02f, 3.47196832e-02f, -3.73909101e-02f, -5.33233024e-03f, -4.08698665e-03f, 6.86488971e-02f, 9.95515585e-02f, 1.26413271e-01f, -1.22741319e-03f,
  -1.89936906e-01f, -1.37333333e-01f, -5.98392636e-02f, 1.82614662e-03f, 7.96966534e-03f, -2.93974187e-02f, -7.80748725e-02f, 1.13690468e-02f, 8.32815543e-02f, 4.58349437e-02f,
  3.82621549e-02f, -3.33947726e-02f, -3.26764509e-02f, -2.13984959e-02f, -4.75911982e-02f, -1.87844096e-03f, 3.37239243e-02f, -3.94350253e-02f, 3.06640621e-02f, -9.27765742e-02f,
  -5.16463034e-02f, -3.96328419e-03f, -5.49997240e-02f, -5.55942282e-02f, -3.10647711e-02f, -3.06179412e-02f, 3.96674164e-02f, -7.24264905e-02f, -5.70947342e-02f, 9.83433798e-03f,
  -3.12000215e-02f, 2.37519387e-02f, -6.01155013e-02f, 7.16597661e-02f, -6.24198653e-02f, 6.23519830e-02f, -4.34275018e-03f, -2.45679598e-02f, -3.22684855e-03f, -6.06498569e-02f,
  7.92292207e-02f, 8.56623352e-02f, 5.46575524e-03f, 7.01714829e-02f, -7.74572790e-03f, 5.06252283e-03f, -2.97273081e-02f, 1.10087416e-03f, -6.92145452e-02f, -4.20639338e-03f,
  -7.65989497e-02f, 8.98187533e-02f, -4.56188619e-02f, -9.53707565e-03f, 6.21383525e-02f, -4.92039733e-02f, -1.05878832e-02f, 9.80164856e-02f, -1.80810466e-02f, -3.75467055e-02f,
  8.39121863e-02f, 4.60380167e-02f, 6.87319785e-02f, 7.64219388e-02f, -7.65451714e-02f, 1.09178260e-01f, 2.23524794e-02f, -4.72556837e-02f, 1.38209149e-01f, 6.89465506e-03f,
  -2.99601108e-01f, 9.31826979e-02f, -1.69160396e-01f, 1.44333586e-01f, 5.22644371e-02f, -1.96254000e-01f, -6.47543073e-02f, -1.72097370e-01f, 9.86112356e-02f, -1.09591736e-02f,
  5.01979515e-03f, 6.74206018e-02f, 3.54864576e-04f, 6.55280948e-02f, -2.71817297e-01f, 6.41585141e-02f, 6.37755916e-02f, -2.39919692e-01f, -2.24347591e-01f, -1.72147676e-02f,
  6.31582290e-02f, 1.21512838e-01f, -2.15766862e-01f, -1.15140282e-01f, 3.35898936e-01f, 1.53062716e-01f, 2.35681787e-01f, 8.02365467e-02f, 5.34852408e-02f, 3.50677460e-01f,
  9.51247066e-02f, -1.66762263e-01f, -1.03102982e-01f, -7.50812739e-02f, -7.31329573e-03f, -7.88029730e-02f, -1.17922306e-01f, -1.49860149e-02f, -5.08150347e-02f, 3.62140946e-02f,
  1.02662154e-01f, 3.34480070e-02f, -5.56588620e-02f, 7.71564767e-02f, -3.22445147e-02f, -7.09987059e-02f, 5.42354546e-02f, -1.77663624e-01f, -8.28654766e-02f, -2.91567259e-02f,
  8.43379572e-02f, 2.02375315e-02f, -7.95124620e-02f, -6.77008405e-02f, -8.31912234e-02f, -5.12724556e-02f, -5.50053529e-02f, -6.68887887e-03f, -1.36920765e-01f, 1.63943022e-01f,
  -7.00714020e-03f, -2.21058633e-02f, -5.90141304e-03f, 1.13888688e-01f, 3.65438610e-02f, -5.14011011e-02f, 6.93946658e-03f, -1.57019012e-02f, 2.97770817e-02f, -1.06755979e-02f,
  -5.53870276e-02f, -2.16919072e-02f, -2.38982551e-02f, 2.23566797e-02f, 6.03436977e-02f, 2.19881367e-02f, -3.31930444e-02f, 8.68685320e-02f, 2.75783222e-02f, 1.97782423e-02f,
  -4.48447652e-02f, -5.37465960e-02f, 3.57486568e-02f, 3.60739306e-02f, -3.10059600e-02f, 1.26561197e-02f, 3.67618203e-02f, 5.03499107e-03f, -4.91729155e-02f, -1.10521011e-01f,
  2.96363801e-01f, -2.16483980e-01f, 1.31581232e-01f, 6.27676919e-02f, 2.72527300e-02f, 7.96253979e-02f, 9.88664553e-02f, 2.44875159e-02f, 6.02211617e-02f, 1.56515948e-02f,
  -8.94503370e-02f, -5.81207871e-03f, 3.02566215e-02f, 1.09997364e-02f, 7.04892278e-02f, 5.89407943e-02f, 1.28873035e-01f, 9.96611640e-02f, -1.14826262e-02f, 6.54503778e-02f,
  1.90206412e-02f, -3.69232669e-02f, 1.02872634e-02f, 1.00754872e-01f, -3.73557699e-03f, -5.10895550e-02f, 1.11728117e-01f, 1.34406105e-01f, -6.08930327e-02f, 6.61420375e-02f,
  9.28002819e-02f, -5.14624715e-02f, -2.93308705e-01f, 8.58828519e-03f, -7.01398700e-02f, -9.43717454e-03f, -1.65053830e-01f, -2.19093356e-03f, 1.07676491e-01f, -9.79037434e-02f,
  -7.17616901e-02f, 4.18830104e-02f, -8.66020620e-02f, -1.01798736e-01f, -7.73421302e-02f, -1.68832749e-01f, -8.05518776e-02f, -1.26288980e-01f, -2.04951659e-01f, -5.48575185e-02f,
  -6.73924461e-02f, -1.01203308e-01f, -7.28049427e-02f, -4.00239937e-02f, 4.49077152e-02f, -8.41195136e-02f, 6.48312620e-04f, -5.26964813e-02f, -4.59143445e-02f, -1.36495784e-01f,
  -2.74215341e-01f, 6.83303699e-02f, -1.02239080e-01f, 5.93936890e-02f, -2.60944348e-02f, -2.62668785e-02f, -9.48596671e-02f, -9.57627967e-03f, -2.32758895e-02f, -4.59779277e-02f,
  -3.40620168e-02f, -2.57671345e-02f, -8.66860673e-02f, -5.81755564e-02f, 1.16579456e-03f, -9.47080404e-02f, 9.50993299e-02f, 6.00401834e-02f, 2.17412282e-02f, -6.27629980e-02f,
  -1.08221183e-02f, -3.34909558e-02f, 9.18627065e-03f, -4.09876294e-02f, -7.47316778e-02f, -7.83659238e-03f, -5.17948717e-02f, -3.89434658e-02f, -3.19706462e-02f, 5.89848943e-02f,
  -1.83748081e-02f, 6.09177491e-03f, 8.03065896e-02f, 1.22049220e-01f, 3.65547393e-03f, 1.21965572e-01f, 5.84454611e-02f, 1.01832896e-01f, -2.35130507e-02f, 1.21339537e-01f,
  1.56355165e-02f, 4.50503826e-03f, 7.88637698e-02f, 2.79671624e-02f, 3.69727202e-02f, 5.56326210e-02f, 1.74867973e-01f, 4.19009710e-03f, 9.85930637e-02f, 6.56578839e-02f,
  3.38510983e-02f, 1.28318742e-01f, 4.49248441e-02f, 1.30581990e-01f, 6.84366301e-02f, 1.26213375e-02f, 3.49730514e-02f, 2.29765568e-02f, -2.64840648e-02f, 3.88056487e-02f,
  -9.56144184e-02f, 2.54954826e-02f, 4.88321856e-03f, -7.34586418e-02f, -6.22400865e-02f, 5.60917705e-02f, 5.01998048e-03f, -7.08874241e-02f, 4.72703800e-02f, -6.62573427e-02f,
  -3.03736102e-04f, 4.34309803e-02f, -2.32956614e-02f, 2.97481027e-02f, 1.86202824e-02f, -6.84636906e-02f, 3.05989273e-02f, -7.04017729e-02f, -5.45218997e-02f, 9.94444266e-02f,
  -1.54298712e-02f, 7.18317479e-02f, -8.09822902e-02f, 7.12757697e-03f, 3.71746719e-02f, -2.00353414e-02f, -1.87809821e-02f, -2.76161381e-03f, -2.74630953e-02f, 5.43901399e-02f,
  -5.42674512e-02f, 2.92536527e-01f, -8.13144892e-02f, 5.51153272e-02f, -1.13918617e-01f, -1.23577707e-01f, -2.01066002e-01f, -8.84470791e-02f, -2.11966634e-02f, 1.35408953e-01f,
  -1.29249424e-01f, -1.01801552e-01f, -1.52560249e-01f, -1.84566841e-01f, -1.14027955e-01f, 6.46501482e-02f, 8.06276873e-02f, -4.62596342e-02f, -2.72973448e-01f, -2.03826949e-01f,
  1.35485083e-01f, 1.63696244e-01f, 1.21111125e-02f, 1.16592962e-02f, 2.50858337e-01f, -1.80422317e-03f, 8.68194923e-02f, 8.10588300e-02f, 1.02800801e-01f, 2.93939322e-01f,
  -2.14371420e-02f, -5.44743724e-02f, -1.55704737e-01f, -3.83473150e-02f, -9.12557915e-02f, -1.17207035e-01f, -1.14493430e-01f, 6.19200654e-02f, -4.29036543e-02f, -3.26473117e-02f,
  -1.47005051e-01f, -3.76211256e-02f, -9.08025727e-02f, -3.34533155e-02f, -8.82178396e-02f, -5.59133962e-02f, -2.17145979e-02f, -9.05849263e-02f, -1.84553921e-01f, -1.33083209e-01f,
  -1.66050680e-02f, -1.34196311e-01f, -1.31480306e-01f, -1.29587844e-01f, -2.33245209e-01f, -1.73116803e-01f, -1.24394305e-01f, -1.77670851e-01f, -2.62161106e-01f, 1.10761292e-01f,
  1.93937812e-02f, 1.01083769e-02f, -6.92063421e-02f, 6.63174540e-02f, 2.27284301e-02f, -4.49761637e-02f, -2.97764428e-02f, 1.86372474e-02f, 2.58986764e-02f, 8.68442357e-02f,
  -2.56741531e-02f, -1.59339849e-02f, -1.46647850e-02f, 9.45682451e-02f, 5.38671799e-02f, -5.30960374e-02f, 7.43790567e-02f, 9.96774659e-02f, -6.28509820e-02f, -2.65834387e-02f,
  -5.82606830e-02f, -4.90473546e-02f, 5.00258803e-02f, 2.29803007e-02f, 3.36445384e-02f, 3.68557759e-02f, 3.60579826e-02f, -1.05606038e-02f, 1.02776773e-02f, 8.09799135e-02f,
  1.75015852e-01f, -2.91154087e-01f, -4.47481163e-02f, -5.52547462e-02f, -6.76686242e-02f, -6.34298176e-02f, -3.13840713e-03f, -1.50769964e-01f, -1.15811631e-01f, -2.35526320e-02f,
  -4.61410321e-02f, -1.53395623e-01f, -7.05587640e-02f, -1.64534375e-01f, -1.34835750e-01f, -1.75101057e-01f, -5.15006669e-02f, -1.44005446e-02f, -1.63835466e-01f, 1.04051903e-02f,
  5.48855141e-02f, -8.37232023e-02f, -9.38568711e-02f, -1.28750235e-01f, -1.48716003e-01f, -2.21305862e-01f, -1.19399838e-01f, -4.12154235e-02f, -2.38973767e-01f, 9.37192440e-02f,
  -2.04947487e-01f, 1.01455010e-01f, -8.97513032e-02f, 4.46575508e-03f, 1.75706819e-01f, -8.54487866e-02f, 7.34373406e-02f, -3.47282104e-02f, 8.49676579e-02f, 1.25865057e-01f,
  3.19951065e-02f, 8.10649619e-02f, 8.11377764e-02f, -4.44031321e-02f, -1.24658056e-01f, 1.21308312e-01f, 3.93480882e-02f, -6.88958615e-02f, -1.13583744e-01f, -1.07651249e-01f,
  1.50639877e-01f, 2.92555355e-02f, -1.11369886e-01f, -7.27557093e-02f, 1.79356813e-01f, 1.10305361e-01f, 1.81173950e-01f, 8.56579915e-02f, 7.73924589e-02f, 2.01940194e-01f,
  1.47809535e-02f, 1.35724654e-03f, 8.73728022e-02f, 1.21717982e-01f, 1.35737360e-01f, 7.37034157e-02f, 7.63855204e-02f, 7.44608641e-02f, 5.19341975e-02f, 6.52405918e-02f,
  1.03537746e-01f, -3.42734978e-02f, -1.74953900e-02f, 3.99450399e-02f, -2.69290842e-02f, -6.96604997e-02f, -6.18063360e-02f, -1.15291044e-01f, -1.78928468e-02f, 6.01087175e-02f,
  8.08300748e-02f, 4.50570844e-02f, -7.35346377e-02f, -5.85607020e-03f, 1.51844351e-02f, -2.11033020e-02f, 6.13064654e-02f, -7.91905262e-03f, -9.12571624e-02f, 9.19545442e-02f,
  6.19298965e-02f, 4.58538570e-02f, 5.68166794e-03f, -7.81925581e-03f, -2.95657162e-02f, 7.88971782e-02f, 3.81513201e-02f, -1.39389355e-02f, 1.75363030e-02f, -4.51583415e-02f,
  -1.17083872e-02f, 7.16032386e-02f, -8.87160748e-03f, -7.83572625e-03f, -7.20610321e-02f, -7.35955313e-02f, -6.18192740e-02f, -7.04440624e-02f, 7.34827593e-02f, 2.67808475e-02f,
  4.20292467e-02f, -3.82938422e-02f, -6.16345496e-04f, -7.98113644e-03f, 2.36504879e-02f, -9.32039842e-02f, -2.17405427e-02f, 3.37018892e-02f, -7.70634264e-02f, -1.15957797e-01f,
  2.19035447e-01f, -1.52734527e-02f, 1.93110570e-01f, 2.59307213e-02f, 1.04607977e-01f, 1.08722694e-01f, 1.08604573e-01f, 3.37677412e-02f, -2.81235296e-02f, -3.85333947e-03f,
  3.29793729e-02f, 2.46475264e-02f, -5.88973705e-03f, -6.16945252e-02f, 5.33465035e-02f, 4.37654778e-02f, 1.30146638e-01f, 9.85605791e-02f, 7.10794702e-02f, 4.56986390e-02f,
  9.61765796e-02f, 8.57808515e-02f, 2.84060463e-02f, 9.30504873e-02f, 9.36489329e-02f, 2.72696465e-02f, 9.67210084e-02f, 1.38758495e-01f, 4.38559763e-02f, 1.96203336e-01f,
  2.02120021e-01f, 3.15651327e-01f, -1.04101233e-01f, 4.44216393e-02f, -4.04228903e-02f, -2.29101941e-01f, -1.63067922e-01f, -1.12211630e-01f, -3.12971361e-02f, 7.78249502e-02f,
  9.65202451e-02f, 8.50738119e-03f, -3.50183509e-02f, -1.16186604e-01f, -5.88150546e-02f, -3.17051411e-02f, -1.03423201e-01f, -1.16641439e-01f, -2.96433479e-01f, -9.91014466e-02f,
  4.38505970e-03f, 3.69889662e-02f, 9.66894999e-02f, 4.89735119e-02f, 2.62409858e-02f, 3.65168713e-02f, 1.28010690e-01f, 4.99592163e-02f, -1.39855212e-02f, 7.88919702e-02f,
  1.53947935e-01f, 2.66891778e-01f, -2.07864448e-01f, -7.22032636e-02f, 1.05659083e-01f, 2.07944587e-02f, 2.85528973e-02f, -4.12851088e-02f, -4.93159480e-02f, 1.36693651e-02f,
  -6.32084832e-02f, -9.22377594e-03f, 2.82477513e-02f, -2.51111798e-02f, -6.07732832e-02f, -9.47310403e-02f, 2.26604473e-03f, 8.33372062e-04f, -5.93591183e-02f, 4.84593213e-02f,
  6.82728812e-02f, 4.50465307e-02f, -1.57439426e-01f, -6.38694838e-02f, -1.80126652e-02f, -1.53559133e-01f, 9.98728536e-03f, -1.09872129e-02f, -7.80688450e-02f, 1.39891535e-01f,
  1.08397774e-01f, -2.44365782e-02f, -4.75420840e-02f, -1.06088165e-02f, -2.15069167e-02f, -2.62212064e-02f, 3.69909592e-02f, -6.04451895e-02f, -7.92322978e-02f, 6.00661412e-02f,
  -9.33488831e-02f, -3.20579647e-03f, 7.28806928e-02f, -3.77133600e-02f, 3.63863930e-02f, -2.65710577e-02f, -7.70085678e-02f, 3.71384509e-02f, -4.50505912e-02f, -4.32233028e-02f,
  1.33447349e-02f, -8.06049164e-03f, -8.83120075e-02f, -5.25439233e-02f, -2.76107658e-02f, -5.70828877e-02f, -5.11426888e-02f, -7.41260573e-02f, 1.22448858e-02f, -5.12552559e-02f,
  9.85805243e-02f, -1.68547258e-01f, 2.35166457e-02f, -4.39756550e-02f, -1.90313030e-02f, -4.23812680e-02f, 3.39438580e-02f, -3.92287001e-02f, 6.12364244e-03f, 1.00648031e-02f,
  -4.65213060e-02f, -3.36959176e-02f, 4.54580784e-02f, -7.30766505e-02f, -1.28578208e-02f, -7.91104212e-02f, -8.60950723e-02f, -1.22701190e-01f, -1.19456924e-01f, -4.95410599e-02f,
  6.26054313e-03f, -1.63163483e-01f, -8.68694782e-02f, -1.32526338e-01f, -3.90679836e-02f, -1.38591036e-01f, 2.82063019e-02f, -1.08101398e-01f, -8.14143419e-02f, 4.70958278e-02f,
  1.03406750e-01f, 1.73927844e-01f, 2.02918872e-01f, -1.07524291e-01f, 6.21387735e-02f, 8.46902356e-02f, 2.64122754e-01f, 8.47724378e-02f, -9.20458436e-02f, 3.26398015e-02f,
  -1.32797807e-01f, -2.67591774e-01f, -1.13496624e-01f, -1.52779549e-01f, 1.79314520e-02f, 1.93387523e-01f, 1.71889123e-02f, -7.80010223e-02f, -2.18065083e-02f, -1.88682955e-02f,
  -1.53758958e-01f, -1.34250879e-01f, -9.95373204e-02f, -6.39476627e-02f, -7.53838941e-03f, -3.93441617e-02f, -6.07344545e-02f, -2.52396371e-02f, -6.20592684e-02f, -8.40577707e-02f,
  6.02934770e-02f, 1.50620103e-01f, 2.10652985e-02f, -9.13401097e-02f, 1.57557093e-02f, 4.37222421e-02f, -8.21205042e-03f, -9.42125544e-02f, 2.11263318e-02f, -5.59300482e-02f,
  -9.91112366e-02f, -5.36076389e-02f, -1.04205027e-01f, -5.67433536e-02f, 9.07681882e-02f, -4.87442762e-02f, -2.96503715e-02f, 1.76053029e-02f, 8.34718794e-02f, 8.90397653e-02f,
  -1.04740657e-01f, 1.00578606e-01f, 6.39797896e-02f, 3.59899327e-02f, 3.29150707e-02f, -8.94423127e-02f, 3.25739244e-03f, 2.25525331e-02f, -2.85124090e-02f, -1.93482451e-02f,
  7.14099333e-02f, -6.38246089e-02f, 7.44487345e-03f, -3.15602683e-02f, -1.30785098e-02f, -3.54155637e-02f, 2.12551635e-02f, -2.18691695e-02f, -6.58008233e-02f, 1.16549490e-03f,
  5.88034056e-02f, 1.11312762e-01f, -2.65954360e-02f, -3.48868631e-02f, -2.26305798e-02f, -1.14747114e-03f, -1.18264034e-02f, -4.39241566e-02f, 7.14217126e-02f, 2.14803480e-02f,
  -7.82437343e-03f, 1.21187149e-02f, 6.13546781e-02f, 5.52406581e-03f, 1.30427079e-02f, -4.77175117e-02f, -8.52761790e-03f, 1.79407019e-02f, -3.40654105e-02f, -5.79505078e-02f,
  1.53414011e-02f, 1.46034383e-03f, 4.87961024e-02f, 8.47138613e-02f, -3.21762823e-02f, -1.59858577e-02f, 3.94126587e-02f, 4.03562859e-02f, -3.92870829e-02f, 7.24541172e-02f,
  -4.54314277e-02f, -4.76785079e-02f, -1.88631006e-02f, -1.16616683e-02f, -3.26041952e-02f, 7.74116069e-02f, 1.01500386e-02f, -4.66984650e-03f, 1.36702955e-02f, -4.33447957e-02f,
  -3.81433405e-02f, 1.36179969e-01f, 1.08816475e-02f, 5.33354878e-02f, -8.54083002e-02f, -2.80383807e-02f, 1.05286799e-01f, 1.10165201e-01f, 1.26511171e-01f, 1.69767231e-01f,
  -6.65184036e-02f, 1.42487928e-01f, 2.73244023e-01f, 8.26490000e-02f, 2.23652378e-01f, 6.37087300e-02f, 1.08344868e-01f, 6.40882850e-02f, -5.00783809e-02f, 1.88258588e-01f,
  5.13491742e-02f, 1.28865652e-02f, 4.81901504e-02f, 9.06859934e-02f, 1.19313985e-01f, 1.62570119e-01f, 3.12313437e-01f, 2.26571187e-01f, 8.18487555e-02f, -2.91131041e-03f,
  -3.05267423e-03f, 5.58474436e-02f, 4.09248807e-02f, 3.99531797e-02f, 1.02217399e-01f, -2.63269674e-02f, 1.52204350e-01f, 2.24605780e-02f, 3.90105397e-02f, 1.90804929e-01f,
  2.85671026e-01f, 4.96195406e-02f, 7.01593757e-02f, -1.21563233e-01f, 3.41037363e-02f, -4.22070697e-02f, 2.45761089e-02f, 2.64451224e-02f, -1.37625411e-02f, 2.63388874e-03f,
  5.11303730e-02f, -6.89983070e-02f, -5.16009666e-02f, -3.24154161e-02f, 7.84796104e-02f, 2.15119980e-02f, 3.93539034e-02f, -3.92844044e-02f, 4.22784016e-02f, 5.42707331e-02f,
  6.57036901e-02f, 9.93664190e-03f, -3.07672862e-02f, -7.90612679e-03f, -5.61691746e-02f, -1.81292500e-02f, -1.93217266e-02f, 7.62881711e-02f, 7.88335875e-02f, -3.05421068e-03f,
  1.52395442e-01f, 7.31800450e-03f, 2.39253361e-02f, -3.53606045e-03f, -9.84350368e-02f, -1.04386717e-01f, 2.82781255e-02f, 3.30521874e-02f, -1.33222993e-02f, -2.59753503e-02f,
  3.74368764e-02f, 7.34015647e-03f, 1.81545373e-02f, -6.53821602e-02f, -5.10054491e-02f, 2.28468832e-02f, -5.50863259e-02f, 4.09083255e-02f, 6.59708157e-02f, -6.88186362e-02f,
  -1.20260091e-02f, -2.73446795e-02f, 9.66901332e-02f, 1.28524536e-02f, 1.74564179e-02f, 1.48021966e-01f, -1.87606085e-02f, -4.78101186e-02f, -2.41518095e-02f, -2.67597996e-02f,
  -8.07979405e-02f, 9.20312405e-02f, -2.75304411e-02f, 3.09999231e-02f, 5.57620376e-02f, -9.77199152e-03f, -2.18219459e-02f, 8.12381878e-02f, -4.15465347e-02f, 9.64381322e-02f,
  -4.16855738e-02f, -2.85954475e-02f, 2.57216301e-02f, -3.45435701e-02f, -7.01479837e-02f, -1.25752240e-02f, 1.39413886e-02f, -5.28081842e-02f, -5.12569025e-02f, -7.66645372e-02f,
  4.79670987e-02f, 2.26433873e-02f, -8.23746994e-02f, -4.10743477e-03f, -1.36961145e-02f, -7.43508413e-02f, -8.87677893e-02f, -1.04790449e-01f, -8.05649161e-02f, -3.03866416e-02f,
  -5.14313400e-01f, -1.37558207e-01f, 8.18335265e-02f, -2.13345572e-01f, 7.35787451e-02f, -1.00034721e-01f, -4.42635231e-02f, -2.61275023e-01f, -8.39083195e-02f, -3.63244638e-02f,
  -1.23431139e-01f, 1.43850176e-02f, 4.38664891e-02f, 1.20342024e-01f, -1.44031212e-01f, 8.36557299e-02f, 1.45257190e-01f, -1.13780601e-02f, 4.27980535e-02f, 1.18206479e-02f,
  1.03481449e-01f, -8.44733790e-02f, -1.98371381e-01f, 3.61796841e-03f, 5.49677312e-02f, 9.89001915e-02f, 1.91522598e-01f, 2.99004205e-02f, 1.60421342e-01f, 1.09274179e-01f,
  4.97585125e-02f, -1.47355810e-01f, 1.40143067e-01f, -9.67827626e-04f, 1.25967965e-01f, -6.35936633e-02f, 7.93825164e-02f, 8.96743312e-02f, 1.63665451e-02f, 4.08709347e-02f,
  9.49594751e-02f, -3.79268788e-02f, 6.57234192e-02f, 7.17601702e-02f, -3.08247022e-02f, -1.28837116e-03f, -2.94287056e-02f, 2.15249136e-03f, -5.09976484e-02f, 3.31186168e-02f,
  1.22050986e-01f, -6.13270560e-03f, -8.78612418e-03f, 5.84160648e-02f, -9.50560067e-03f, 9.07767490e-02f, 1.37738705e-01f, -1.33391861e-02f, -3.58551629e-02f, 3.26449275e-02f,
  9.35491920e-02f, -4.79563437e-02f, -6.67187051e-05f, -9.18465480e-02f, -1.13585775e-05f, -5.32801636e-02f, 5.02921715e-02f, -1.05126843e-01f, -3.21826451e-02f, 1.92347616e-02f,
  -3.23302555e-03f, -1.55594014e-02f, 3.09626963e-02f, -3.81775200e-02f, 4.90833931e-02f, -7.93070942e-02f, 7.67406449e-02f, -3.16417888e-02f, 4.51186597e-02f, 1.18850470e-02f,
  -2.22886670e-02f, -2.21794639e-02f, 4.89569940e-02f, 6.01969846e-02f, 4.27636690e-02f, 4.92034340e-03f, 8.52920413e-02f, -3.05568166e-02f, 1.99795850e-02f, 2.19432674e-02f,
  -2.36979693e-01f, 7.21635520e-02f, 5.52867502e-02f, 3.91906835e-02f, 6.74069487e-03f, 8.51697475e-02f, -5.40884137e-02f, -1.91906858e-02f, -3.87287214e-02f, 1.21139903e-02f,
  -6.20484650e-02f, -1.02894783e-01f, 6.49967929e-03f, 7.80044645e-02f, 3.81608196e-02f, -2.92584114e-02f, -4.70696725e-02f, -2.30085757e-02f, -3.78160812e-02f, -8.00628588e-02f,
  -3.80282626e-02f, -7.47075826e-02f, -1.81879446e-01f, -6.88246414e-02f, 7.68598691e-02f, -4.61081006e-02f, 1.22491634e-02f, 2.34834552e-02f, -8.19683895e-02f, -8.14076960e-02f,
  -2.72488505e-01f, 3.29904072e-02f, -2.26747304e-01f, 6.67104870e-02f, 1.40601501e-01f, -1.43013984e-01f, -2.47124240e-01f, -1.48069412e-01f, 1.80273578e-01f, 4.96118553e-02f,
  1.73126608e-01f, 1.54023468e-01f, -4.24699485e-02f, -6.25477806e-02f, -1.56667918e-01f, -1.85934246e-01f, -1.75346896e-01f, -2.97722667e-01f, -1.83815375e-01f, 1.59013182e-01f,
  1.04107864e-01f, 1.07325464e-01f, -8.94546285e-02f, -7.81038254e-02f, 1.85791522e-01f, 1.01836547e-01f, 4.26144563e-02f, 7.57681131e-02f, 1.39831051e-01f, 1.15702339e-01f,
  -7.56478161e-02f, -8.10825601e-02f, -3.93159362e-03f, 1.18605152e-01f, 6.88094832e-03f, -4.89079580e-02f, -1.30914494e-01f, -5.14384694e-02f, 4.95605357e-02f, 3.29081863e-02f,
  8.43287483e-02f, 6.38577789e-02f, -5.39733618e-02f, 2.65379790e-02f, 1.36512712e-01f, -1.88688226e-02f, 1.32911904e-02f, -1.02945112e-01f, -1.15738027e-01f, 4.14026082e-02f,
  3.60157825e-02f, -4.80633788e-02f, -5.67246862e-02f, 6.83232918e-02f, 3.12321428e-02f, 2.12191604e-02f, 4.29919288e-02f, 1.76295899e-02f, -6.95377961e-02f, -4.19042297e-02f,
  2.89683249e-02f, -6.84778839e-02f, 7.30198175e-02f, -1.68654043e-02f, 2.22047400e-02f, 3.18910368e-02f, -2.71790028e-02f, 6.62073568e-02f, 1.31663000e-02f, 4.32149461e-03f,
  2.58202814e-02f, 7.35141337e-02f, -6.55651614e-02f, 2.68426072e-02f, -3.05742864e-02f, -8.83243829e-02f, 2.16586776e-02f, -1.40476283e-02f, 1.11874402e-01f, -8.63981470e-02f,
  3.96584421e-02f, -1.36777731e-02f, 5.07587902e-02f, -6.52478039e-02f, -1.96254291e-02f, -3.08593661e-02f, 2.26652473e-02f, 2.53765117e-02f, 1.27485171e-02f, 6.88166842e-02f,
  3.14856954e-02f, -1.09015748e-01f, 1.87268257e-02f, -1.06305368e-02f, 1.91230681e-02f, 5.29233925e-03f, 7.18307272e-02f, 6.71155527e-02f, 1.67716052e-02f, -1.01143429e-02f,
  4.12723273e-02f, 1.39234094e-02f, 4.81037833e-02f, 3.49292234e-02f, 8.68341997e-02f, -8.49819090e-03f, 1.21844947e-01f, 2.26524901e-02f, 7.33668283e-02f, 1.29193410e-01f,
  1.61639661e-01f, 3.35235931e-02f, 4.70290966e-02f, 4.07099091e-02f, -1.18790865e-02f, -5.84666170e-02f, 5.18733338e-02f, 8.51914380e-03f, -1.31956607e-01f, -3.98749858e-02f,
  1.29711747e-01f, 2.28731647e-01f, 1.30899757e-01f, 1.97256550e-01f, -2.41335928e-02f, -1.27406746e-01f, -7.23023340e-02f, 4.41724714e-03f, 7.89803118e-02f, 1.44022465e-01f,
  -1.38794594e-02f, -7.36276945e-03f, 4.19054255e-02f, -1.22432271e-02f, -6.37667924e-02f, 3.91501263e-02f, 4.88999262e-02f, 9.46750492e-02f, -8.30784217e-02f, -9.16507989e-02f,
  -3.51752974e-02f, 1.37464777e-01f, 1.94603458e-01f, 3.02535128e-02f, 8.56897235e-03f, -2.90334411e-03f, 2.38099322e-01f, 6.37637451e-02f, -5.82513809e-02f, 1.10527188e-01f,
  2.35320270e-01f, 2.16138810e-01f, -6.33342490e-02f, -1.31384172e-02f, 7.69852549e-02f, 1.22311808e-01f, 1.06113426e-01f, 1.99387118e-01f, -1.16223209e-02f, 6.01783767e-02f,
  1.71951205e-01f, -7.24266982e-04f, 5.63840568e-02f, 7.88513571e-02f, 1.73197836e-01f, 6.80514723e-02f, 1.55337006e-01f, 1.49196625e-01f, 1.69403151e-01f, 6.52424768e-02f,
  4.92075458e-02f, 7.42552504e-02f, 5.55847883e-02f, 7.67162442e-02f, 1.52569890e-01f, 9.78513062e-02f, 1.07925065e-01f, 1.37598053e-01f, 7.12126791e-02f, 1.37463197e-01f,
  6.63184002e-02f, 8.42218380e-03f, -1.28143147e-01f, -9.70528275e-02f, -4.28134166e-02f, -1.32482782e-01f, -1.12940483e-01f, -1.25841469e-01f, -7.00727105e-02f, 3.03458311e-02f,
  -3.45449969e-02f, -1.03296146e-01f, -1.20127037e-01f, -6.25378788e-02f, -1.09793775e-01f, -5.67501374e-02f, -1.07743844e-01f, -9.30400491e-02f, -9.23519731e-02f, -2.37044157e-03f,
  -1.35730654e-01f, -1.51322577e-02f, -2.38587018e-02f, -6.51766360e-02f, -4.43996303e-02f, -1.26228616e-01f, -1.63783401e-01f, -1.04103955e-02f, -7.65907243e-02f, -7.09530935e-02f,
  1.13465257e-01f, 1.43885866e-01f, 1.04102686e-01f, 3.74362874e-03f, 1.21164881e-01f, 4.53876704e-02f, 1.19950641e-02f, 1.58954427e-01f, 4.49331924e-02f, 3.35791335e-02f,
  5.65827414e-02f, 1.41356960e-01f, 1.92235187e-01f, 1.35370076e-01f, 4.49813381e-02f, 1.00231998e-01f, 1.10659353e-01f, 1.91655271e-02f, 6.87422156e-02f, 1.37401819e-01f,
  1.71113059e-01f, -4.42606397e-02f, 5.39646260e-02f, 7.92035013e-02f, 1.53232381e-01f, 7.90058672e-02f, 6.54749796e-02f, 3.61119211e-02f, 7.56524429e-02f, 1.17166795e-01f,
  3.76504630e-01f, 2.00550497e-01f, -1.11481575e-02f, 8.76392648e-02f, -9.39311646e-03f, 4.41519395e-02f, 1.31256148e-01f, 5.13537005e-02f, -6.82699680e-02f, 1.80706620e-01f,
  -3.18361893e-02f, -8.98813978e-02f, -1.58944666e-01f, -2.62899727e-01f, -3.92077453e-02f, 1.86736751e-02f, -5.82863875e-02f, -1.26259148e-01f, -2.07433194e-01f, -2.42551379e-02f,
  -1.09413281e-01f, 3.18270884e-02f, 4.52309288e-02f, -1.43921509e-01f, 2.75376625e-02f, -6.14171624e-02f, 1.32011190e-01f, 1.24953568e-01f, -8.02687183e-02f, 1.27964839e-01f,
  1.72303647e-01f, 4.53334153e-02f, -1.53584301e-01f, -7.12225586e-02f, -9.60027985e-03f, 3.96054052e-02f, 9.87783894e-02f, 1.88729167e-02f, -2.59867329e-02f, 7.81435668e-02f,
  -1.90378539e-03f, -2.64983461e-03f, -4.76316037e-03f, -1.02282174e-01f, -3.82166654e-02f, -2.40188697e-03f, -1.72763303e-05f, -2.32645255e-02f, -1.41205549e-01f, -3.26814018e-02f,
  -3.29877529e-03f, 9.22107697e-02f, 1.15630835e-01f, -1.17729478e-01f, -8.79409686e-02f, -2.43198462e-02f, 3.32739502e-02f, -1.17799230e-02f, -4.88120876e-02f, 1.81328401e-01f,
  2.55591683e-02f, 7.99515005e-03f, -5.31431772e-02f, -2.65074223e-02f, -1.14929773e-01f, -1.22109838e-01f, -5.25129288e-02f, 3.69438494e-04f, -1.30469099e-01f, 1.31737394e-02f,
  -5.24233207e-02f, -3.33475065e-03f, -8.29130262e-02f, 3.12094186e-02f, -1.10559501e-01f, -6.11076877e-02f, 1.11232735e-02f, -8.14926773e-02f, -9.41502601e-02f, -7.07899556e-02f,
  -5.33731580e-02f, -4.77925502e-02f, -8.59357342e-02f, -4.13417779e-02f, -9.96703953e-02f, -2.56152134e-02f, 3.24465684e-03f, -4.17531505e-02f, 4.65029590e-02f, 9.79394764e-02f,
  -5.00511192e-03f, -4.67341915e-02f, 1.54843822e-01f, 8.31778254e-03f, 7.46085420e-02f, -1.15650818e-02f, -1.89310405e-02f, -1.21552413e-02f, 1.36081204e-02f, -4.91056181e-02f,
  8.53253976e-02f, -4.45079282e-02f, 7.76015446e-02f, -6.06204122e-02f, -2.52360161e-02f, 4.87593263e-02f, 2.40808036e-02f, -7.42422044e-02f, -4.96468619e-02f, 9.51946992e-03f,
  1.10386219e-02f, -6.28550351e-03f, -2.60608308e-02f, 7.30307847e-02f, 1.69599541e-02f, 3.53109799e-02f, 3.55281606e-02f, 1.23017840e-01f, 1.04349323e-01f, 2.31682688e-01f,
  -1.96779341e-01f, -1.10626128e-02f, -2.03275204e-01f, -2.07423009e-02f, 1.62746340e-01f, 8.15526322e-02f, 2.26587102e-01f, 1.69332013e-01f, 1.97974257e-02f, 1.02553345e-01f,
  -4.95076589e-02f, -7.80026019e-02f, -4.08619978e-02f, -1.99356318e-01f, -1.35546908e-01f, 6.60947487e-02f, -1.40051125e-02f, -2.13726297e-01f, -2.90534526e-01f, -7.03801820e-03f,
  1.04002893e-01f, 1.74669102e-02f, -1.05095573e-01f, -1.37115598e-01f, -3.19389328e-02f, -5.67552298e-02f, -3.48879322e-02f, -1.41910344e-01f, -1.85693711e-01f, -2.77490199e-01f,
  -4.08611447e-01f, -1.88902557e-01f, -6.63941875e-02f, -8.07613730e-02f, -1.79608911e-01f, -1.75761729e-01f, -7.17041716e-02f, -1.54791579e-01f, 1.46548981e-02f, -7.71962181e-02f,
  -1.04040848e-02f, -1.01738848e-01f, -2.26096530e-02f, -8.04678127e-02f, -7.66756311e-02f, -1.77086934e-01f, -5.57417832e-02f, -2.50259936e-01f, -1.62777320e-01f, -1.63981065e-01f,
  -4.23157960e-02f, -2.46238068e-01f, -3.25722098e-01f, -5.75629110e-03f, -5.20717762e-02f, -2.32459620e-01f, -2.03349277e-01f, -2.72301614e-01f, -2.00178370e-01f, -1.42273039e-01f,
  -3.75744514e-02f, -1.45814400e-02f, -5.85368052e-02f, -6.32172003e-02f, 9.03091803e-02f, 9.40616988e-03f, -2.35768054e-02f, -3.54517996e-02f, -1.92016561e-03f, -7.18360953e-03f,
  -1.05077565e-01f, -1.98424654e-03f, 3.24678198e-02f, -1.81957092e-02f, -2.05006469e-02f, -2.81477552e-02f, -8.21626857e-02f, -2.07726583e-02f, 1.43313746e-03f, -4.74514905e-03f,
  -1.58130948e-03f, -4.23278175e-02f, 6.43545687e-02f, -8.91026407e-02f, -3.88266183e-02f, -2.87944600e-02f, -5.38244583e-02f, 3.29579925e-03f, 4.59385067e-02f, 5.68949291e-03f,
  8.22803080e-02f, -4.32635993e-02f, -4.69119512e-02f, -1.51735738e-01f, -1.42368257e-01f, -1.25214770e-01f, -1.00599155e-01f, -6.45755380e-02f, -1.18287452e-01f, -5.83597720e-02f,
  -1.17616147e-01f, -1.86531004e-02f, 2.52245404e-02f, -7.55773857e-02f, -1.00459442e-01f, 2.74872966e-02f, -3.86326052e-02f, -4.17817049e-02f, -1.17593184e-01f, -4.43706252e-02f,
  1.11472532e-01f, -6.25902414e-02f, -1.69313625e-01f, -7.88420718e-03f, -7.17460662e-02f, -1.96776867e-01f, -1.04633197e-01f, -9.41120610e-02f, -1.22472279e-01f, 9.25405771e-02f,
  4.54355121e-01f, -3.66082400e-01f, -1.32679805e-01f, 2.32851863e-01f, -2.06545755e-01f, -2.42413118e-01f, -2.98048228e-01f, -1.32546604e-01f, 1.28360307e-02f, -1.16237819e-01f,
  -6.92934170e-02f, 2.53485173e-01f, 1.72340080e-01f, 1.19617976e-01f, 8.91799629e-02f, -2.06566632e-01f, -1.99719176e-01f, 1.73805475e-01f, 1.90554604e-01f, 1.20938770e-01f,
  -3.89115736e-02f, 7.54341250e-03f, 1.96766257e-01f, 1.25785545e-01f, -3.92401889e-02f, 7.16730729e-02f, -7.61367008e-02f, -1.54531673e-01f, -1.31856844e-01f, -2.07809001e-01f,
  -2.07499638e-02f, -1.15325071e-01f, 4.65740673e-02f, 1.03220504e-04f, -8.05268586e-02f, -3.72654758e-02f, 5.46480715e-02f, -2.07306072e-02f, 9.16601624e-03f, 1.30434511e-02f,
  -9.48976073e-03f, -1.10247105e-01f, -6.92501217e-02f, -1.03478558e-01f, -3.98836248e-02f, -1.43225575e-02f, -1.03521228e-01f, -2.88539659e-02f, -4.77027111e-02f, -1.66145131e-01f,
  -7.56077543e-02f, -1.01310425e-01f, -1.07612707e-01f, -1.15647554e-01f, -8.50182846e-02f, 2.72397064e-02f, -1.87406272e-01f, -2.02955138e-02f, -5.26090451e-02f, -1.66659921e-01f,
  2.43073180e-02f, -4.43782983e-03f, 1.51691278e-02f, 6.34264126e-02f, 5.40327840e-02f, -3.35758738e-02f, 3.35409604e-02f, 2.62410715e-02f, 5.56692109e-02f, -3.78050730e-02f,
  -2.77104229e-02f, 3.80476727e-03f, 2.15102229e-02f, -6.94129150e-03f, 3.42183672e-02f, -2.20202822e-02f, 7.46379653e-03f, -5.71889915e-02f, 8.95906985e-02f, -1.82348024e-02f,
  4.47802581e-02f, 2.79727615e-02f, 2.35336423e-02f, 6.78925514e-02f, -5.12742884e-02f, 4.62982729e-02f, 2.28519961e-02f, -6.35995716e-02f, 3.31408940e-02f, -5.20798787e-02f,
  8.77387822e-02f, -2.49605402e-02f, 5.59662320e-02f, 3.77064906e-02f, -5.64875752e-02f, -6.28164113e-02f, -7.74503276e-02f, 3.34116146e-02f, -1.04382046e-01f, -1.24431979e-02f,
  -2.99849194e-02f, 5.47261117e-03f, -1.26248570e-02f, -6.54210299e-02f, 3.59048732e-02f, 2.59656049e-02f, -1.09286666e-01f, 7.73886070e-02f, -6.04727566e-02f, -8.03047344e-02f,
  -7.58148059e-02f, -3.87753844e-02f, 1.29247755e-01f, 1.22417808e-02f, 4.23706602e-03f, 4.99279089e-02f, -9.15903151e-02f, -1.45307565e-02f, 4.04814780e-02f, -1.20019270e-02f,
  -2.92445183e-01f, 3.13268006e-02f, -6.48237094e-02f, -2.42897868e-01f, 4.61036228e-02f, 8.10592994e-02f, 1.93044379e-01f, 9.88255814e-02f, -2.54889484e-02f, 9.44888219e-02f,
  1.33124456e-01f, 8.81631151e-02f, 5.63780256e-02f, 7.69550055e-02f, -4.54048440e-02f, 1.34489849e-01f, 3.59544456e-02f, 3.91006172e-02f, -8.27250183e-02f, 1.19989693e-01f,
  7.56552592e-02f, -8.15807357e-02f, -2.82087982e-01f, -1.01561747e-01f, -1.64416522e-01f, 1.91285778e-02f, -1.58212751e-01f, -1.64424628e-01f, -7.81959221e-02f, -1.61402971e-01f,
  5.84820881e-02f, -2.30938166e-01f, -3.99297923e-02f, -1.04785316e-01f, -1.21344082e-01f, -1.25521317e-01f, -3.05164605e-02f, -7.96946883e-02f, -1.62929624e-01f, -5.67300431e-03f,
  -1.37027383e-01f, -2.08844356e-02f, -1.29965693e-01f, -3.08081433e-02f, -1.51738331e-01f, -1.17409714e-01f, -9.56236422e-02f, -2.05056235e-01f, -8.06374699e-02f, -5.28307036e-02f,
  3.84188816e-02f, -4.36948426e-02f, -4.78256233e-02f, -1.18779831e-01f, -6.83433339e-02f, -8.68310258e-02f, -6.97567388e-02f, -8.71477798e-02f, -1.00995831e-01f, -1.52430087e-01f,
  4.78125550e-02f, 3.21215317e-02f, 3.74419987e-02f, 1.72441721e-01f, 1.47062376e-01f, 1.32612213e-01f, 1.02216162e-01f, 9.35635641e-02f, 1.37054428e-01f, 1.06378943e-01f,
  9.19328034e-02f, 9.29453298e-02f, 9.80978906e-02f, 1.35627061e-01f, 1.62988812e-01f, 1.27216145e-01f, 6.61465973e-02f, 1.53045937e-01f, 2.48832256e-02f, 1.65364817e-01f,
  1.50439844e-01f, 1.08375944e-01f, 4.40988503e-02f, 1.02151677e-01f, 1.01756185e-01f, 1.08798385e-01f, 6.67994395e-02f, 8.35605264e-02f, 3.93426456e-02f, 1.62754387e-01f,
  5.21898493e-02f, -1.09501995e-01f, 4.69594821e-03f, -1.22471191e-01f, -9.14520025e-02f, -1.46410137e-01f, -3.91602889e-02f, -1.01569906e-01f, -1.79295510e-01f, 3.98181519e-03f,
  -8.41808468e-02f, -1.06133789e-01f, -4.66925278e-02f, -5.86790629e-02f, -1.02247283e-01f, -6.39471784e-02f, -4.99667646e-03f, 6.80925383e-04f, -4.74685282e-02f, -1.82071507e-01f,
  -6.22621365e-03f, -6.33716658e-02f, 2.37792134e-02f, 6.31237403e-02f, -4.40255925e-02f, -2.54592858e-02f, 4.02735174e-03f, 1.68024842e-02f, -7.69259930e-02f, -1.83708332e-02f,
  -1.21600151e-01f, -1.23125762e-01f, -2.72150934e-01f, -2.19376534e-01f, -2.24164575e-01f, -7.90391639e-02f, 3.42574082e-02f, 1.81360487e-02f, -4.59054299e-02f, -1.79447338e-01f,
  -1.66383430e-01f, -2.66768541e-02f, -7.36599192e-02f, 5.30957654e-02f, -1.20016068e-01f, -1.97269887e-01f, -1.91606626e-01f, -1.77153692e-01f, 6.76203668e-02f, 7.65491873e-02f,
  1.07839726e-01f, -5.39301895e-02f, -7.39382058e-02f, 2.22296081e-02f, 3.20664048e-02f, -6.77447394e-02f, -1.86724186e-01f, -8.87739360e-02f, -1.92845352e-02f, -1.61241576e-01f,
  -2.12204993e-01f, -5.50922789e-02f, -4.05956246e-02f, -3.60657577e-03f, -1.12704359e-01f, 2.79334094e-02f, 2.36287937e-02f, 4.24994901e-02f, -6.13960177e-02f, -3.10458010e-03f,
  -4.70791534e-02f, -9.74723324e-02f, -1.57063276e-01f, -5.14073931e-02f, -1.16734996e-01f, 7.14880005e-02f, 2.70354953e-02f, -3.65764499e-02f, 2.53366213e-02f, -2.89588235e-02f,
  -1.22074775e-01f, -2.84876581e-02f, -9.80551317e-02f, -4.83509526e-02f, -8.09246749e-02f, 5.51344231e-02f, 5.82715422e-02f, 4.46712673e-02f, 1.61806494e-02f, 4.51748110e-02f,
  -9.70168337e-02f, 1.79492543e-03f, -4.56820391e-02f, -1.89301316e-02f, -2.21686587e-02f, -6.74399659e-02f, -1.24685563e-01f, -1.15339465e-01f, 3.73815782e-02f, -1.87892113e-02f,
  -2.84165591e-02f, -5.23749106e-02f, 9.96975135e-03f, -1.04390696e-01f, -1.14715345e-01f, -5.52921146e-02f, -5.90420440e-02f, 7.30544096e-03f, 8.09038803e-02f, -2.17825808e-02f,
  8.72089490e-02f, 3.49024646e-02f, -8.20947886e-02f, -3.25580430e-03f, -3.71983759e-02f, -1.34411911e-02f, 7.58206397e-02f, 7.68577084e-02f, -5.09152226e-02f, 1.22895390e-01f,
  -9.12343524e-03f, 6.35527670e-02f, -9.00877640e-02f, 3.14429849e-02f, -5.89957014e-02f, -1.33126099e-02f, -1.96081176e-02f, -1.98580250e-02f, -6.01475453e-03f, 4.91817333e-02f,
  -2.25313250e-02f, -1.07685961e-01f, -8.12716857e-02f, 5.36621213e-02f, 3.69000584e-02f, 4.12783399e-02f, -1.04300752e-01f, -1.27187997e-01f, 1.70827210e-02f, -3.26483622e-02f,
  7.79485330e-02f, -5.08839078e-03f, 1.59609057e-02f, 9.36286300e-02f, 4.63657267e-02f, 1.04833357e-02f, 2.69201696e-02f, 1.07047863e-01f, -3.88654927e-03f, 1.18082926e-01f,
  -4.29704159e-01f, 1.15335606e-01f, -2.00003430e-01f, -1.51958212e-01f, 1.32571563e-01f, 1.64494395e-01f, 2.02897251e-01f, -2.88965404e-02f, -3.98738235e-02f, 7.95174837e-02f,
  4.57159095e-02f, 4.32858095e-02f, -6.96968287e-02f, 2.78428178e-02f, -2.07095101e-01f, 9.22198668e-02f, 2.55744569e-02f, -3.22625905e-01f, -2.07749978e-01f, 4.27337475e-02f,
  5.71864769e-02f, -1.52207136e-01f, -1.87365487e-01f, -1.08548015e-01f, 1.04332514e-01f, 5.49967811e-02f, -5.17641418e-02f, -9.11353081e-02f, 1.43924847e-01f, 5.04328795e-02f,
  6.11728057e-02f, -1.54207796e-01f, -1.35069892e-01f, -9.97585133e-02f, 2.72062514e-02f, -8.75511840e-02f, 4.80525419e-02f, -2.22938046e-01f, -1.47683948e-01f, -3.97203863e-02f,
  -5.57176918e-02f, -1.15319163e-01f, 3.31492373e-03f, 1.86525006e-02f, -3.39548178e-02f, -1.09194228e-02f, -1.53901652e-01f, -1.62083924e-01f, -1.27421513e-01f, 5.12380414e-02f,
  1.48949966e-01f, -3.02019008e-02f, -9.52984914e-02f, -1.34270918e-02f, -1.29541308e-01f, -3.52246352e-02f, -6.86063431e-03f, -1.42265810e-02f, -5.56145497e-02f, -2.86706258e-02f,
  4.05297130e-02f, 3.77487801e-02f, 4.63971607e-02f, 4.38477546e-02f, 1.21136844e-01f, 6.57723099e-02f, 1.11091577e-01f, 1.75932467e-01f, 1.51668414e-01f, 1.49657195e-02f,
  1.16485409e-01f, 7.93372095e-02f, 2.59073190e-02f, 7.07894377e-03f, 3.07813678e-02f, 2.94777360e-02f, 1.08229578e-01f, -1.60636380e-02f, 9.39427167e-02f, -2.00933702e-02f,
  4.17046808e-03f, 7.38146603e-02f, 8.50235745e-02f, 1.07604042e-01f, 4.52572554e-02f, 1.12306207e-01f, 2.48009749e-02f, 7.14081973e-02f, 1.09873988e-01f, 8.47742781e-02f,
  3.99096869e-02f, -4.95645776e-02f, 4.63688076e-02f, 9.48102493e-03f, -1.72175895e-02f, -7.66459107e-02f, 6.68047965e-02f, -8.00118446e-02f, 3.14975344e-03f, -8.85595381e-02f,
  4.98342514e-02f, -4.31647971e-02f, 2.76897922e-02f, -2.46463530e-03f, -3.38249728e-02f, 7.84583241e-02f, 1.42249251e-02f, -4.82256003e-02f, -1.13905579e-01f, -3.23559530e-02f,
  -8.94648861e-03f, -4.98460084e-02f, -1.01415761e-01f, 5.39273173e-02f, 4.91466001e-02f, -1.28697362e-02f, 1.52135780e-02f, 2.37738807e-02f, -9.54264477e-02f, 9.27768126e-02f,
  2.34248474e-01f, -2.79998511e-01f, -1.03338957e-01f, -3.85302007e-02f, -7.32230991e-02f, -2.06419546e-02f, -1.23259619e-01f, -9.29440707e-02f, -5.25357276e-02f, -8.89517814e-02f,
  -4.45572659e-02f, 2.55202025e-01f, -1.49429599e-02f, -4.70198272e-03f, 1.26154791e-03f, -2.17629150e-01f, -1.67869285e-01f, 2.64464766e-02f, 2.92339057e-01f, 1.91240788e-01f,
  5.70492633e-02f, -4.39233333e-02f, 4.67161797e-02f, -4.31359038e-02f, -1.23213060e-01f, 1.15192555e-01f, -1.05052032e-01f, -1.16821706e-01f, 2.63867285e-02f, -2.06905067e-01f,
  3.83007601e-02f, -5.18288985e-02f, 7.15001374e-02f, 1.54001102e-01f, 4.46642302e-02f, 4.58261184e-02f, 8.71541575e-02f, -1.33623645e-01f, -4.65453789e-02f, -5.54875582e-02f,
  8.62668175e-03f, 9.85875204e-02f, 4.01916280e-02f, 1.36050377e-02f, -8.05109963e-02f, 1.39699383e-02f, -4.33938392e-02f, -2.94036977e-02f, -3.67901661e-02f, -5.47887161e-02f,
  7.67148435e-02f, -4.87973392e-02f, 8.96469131e-03f, -9.37087536e-02f, 1.03490455e-02f, 1.76557153e-01f, -8.29734877e-02f, -3.85115519e-02f, 1.20547116e-01f, -1.34007916e-01f,
  3.39637846e-02f, -6.17761724e-03f, -7.94795975e-02f, -3.90630513e-02f, -4.39560041e-03f, -7.86990374e-02f, -1.86644662e-02f, -3.87788936e-02f, -3.92017178e-02f, -7.24647492e-02f,
  -8.33609235e-03f, -5.95833873e-03f, 4.98482259e-03f, -8.49250704e-02f, 9.66726616e-03f, -4.77963276e-02f, -5.12174331e-02f, -8.51964727e-02f, -1.66562814e-02f, -3.63856717e-03f,
  2.11771354e-02f, 3.91671881e-02f, -8.98252875e-02f, 1.70673318e-02f, -6.12762719e-02f, -1.02304192e-02f, 3.73700081e-04f, -7.86792370e-04f, -7.85510391e-02f, -5.13550341e-02f,
  2.59040203e-02f, 5.47969155e-02f, -1.50799863e-02f, 2.85951942e-02f, 2.32108887e-02f, 7.56238848e-02f, -7.35521608e-04f, 5.39014488e-02f, -3.33091207e-02f, 6.00368753e-02f,
  4.59724218e-02f, -3.85369919e-02f, -4.27448414e-02f, -2.99365185e-02f, 2.50261673e-03f, 1.42530529e-02f, 1.95103139e-03f, 3.39840911e-02f, 1.26211300e-01f, 8.55227560e-02f,
  4.80424240e-03f, 4.17911261e-02f, 1.27166629e-01f, -3.56270792e-03f, 3.61878867e-03f, 2.25579366e-01f, 6.03404045e-02f, 1.15386076e-01f, 1.10508934e-01f, -1.02472819e-01f,
  3.96829657e-02f, 4.94415089e-02f, 1.61553755e-01f, 1.79070473e-01f, -7.36485571e-02f, -1.25898123e-01f, -1.25384569e-01f, -2.38735769e-02f, -2.98825242e-02f, 6.59525990e-02f,
  -9.92120057e-02f, -1.10693462e-01f, -5.80174997e-02f, -7.36122653e-02f, 1.67290866e-02f, 7.77845159e-02f, 6.19185679e-02f, 5.42677864e-02f, -1.46841854e-01f, -5.37610911e-02f,
  6.50333166e-02f, -2.67596282e-02f, 1.15174681e-01f, 1.70328934e-02f, 8.00759867e-02f, 8.96752346e-03f, 2.72514168e-02f, -3.16000618e-02f, 4.62527946e-03f, 1.67338997e-01f,
  -1.27781555e-01f, 1.85578391e-01f, -2.82962713e-02f, 1.17874108e-02f, -3.42461318e-02f, -1.12013876e-01f, 3.56823485e-03f, 1.07277930e-02f, -9.62844640e-02f, 2.83335429e-02f,
  5.05353026e-02f, -1.64563730e-02f, -1.05199374e-01f, -1.67324580e-02f, 8.43595993e-03f, 2.79431660e-02f, -7.58566661e-03f, -1.10102333e-02f, 7.95349479e-02f, 5.88657558e-02f,
  2.07428765e-02f, -2.80461200e-02f, -1.35368347e-01f, -6.89791217e-02f, 1.09951481e-01f, -1.12844661e-01f, 2.50608549e-02f, 5.75452410e-02f, -1.12430595e-01f, -5.11049889e-02f,
  6.83695525e-02f, -1.06009886e-01f, -8.38841051e-02f, -5.49558960e-02f, 7.78920308e-04f, -8.94347504e-02f, -3.73095796e-02f, -4.28343238e-03f, 1.42647270e-02f, 4.11542505e-02f,
  8.53556022e-03f, 1.80224364e-03f, 7.70143643e-02f, -1.93844009e-02f, -5.66801615e-03f, -2.22320780e-02f, 5.38404360e-02f, 1.71276666e-02f, 3.40945311e-02f, 2.75202673e-02f,
  -9.90120918e-02f, -4.54759710e-02f, 2.83620749e-02f, -6.86705336e-02f, 6.72785044e-02f, -1.72825269e-02f, 1.56667326e-02f, -4.53490801e-02f, -3.27064283e-02f, -4.08541076e-02f,
  -1.11580640e-01f, -1.25785217e-01f, -4.47132103e-02f, -9.82427150e-02f, -9.77889746e-02f, -4.26637428e-03f, 7.66666681e-02f, 1.30666150e-02f, -2.90672053e-02f, -5.84886335e-02f,
  5.17903492e-02f, 3.53246694e-03f, -7.87056535e-02f, -5.92100993e-02f, -4.20782417e-02f, -3.56310979e-02f, -1.00265145e-02f, -5.51402234e-02f, -2.96041034e-02f, 9.66693610e-02f,
  -3.03287432e-02f, -8.52710605e-02f, -1.73722312e-01f, -2.08522171e-01f, -1.84229519e-02f, -1.34799734e-01f, -1.70275673e-01f, -9.08028930e-02f, -1.16427936e-01f, -5.44191152e-02f,
  -5.14701784e-01f, 7.38468841e-02f, 9.99215022e-02f, -1.60271242e-01f, 4.80737388e-02f, -7.32043162e-02f, 9.89061072e-02f, -4.19600271e-02f, -1.03008926e-01f, 4.63190563e-02f,
  2.23035808e-03f, -3.78450453e-02f, -5.41047305e-02f, -3.89948413e-02f, -1.62179451e-02f, 1.28248081e-01f, 9.72373709e-02f, -9.88460854e-02f, -5.35391122e-02f, -4.77258954e-03f,
  8.66017938e-02f, -1.00838453e-01f, -1.46763995e-01f, -9.27853063e-02f, 9.58161429e-03f, -2.92482357e-02f, 8.12817439e-02f, 3.75439450e-02f, 1.78403407e-02f, 1.54219300e-01f,
  3.53931040e-02f, -1.14252441e-01f, -1.56358834e-02f, -1.18757404e-01f, 9.07571018e-02f, 3.20195942e-03f, -2.64605656e-02f, -4.61867601e-02f, 2.81820949e-02f, -1.58361029e-02f,
  -7.88142830e-02f, 7.85171017e-02f, -2.78481282e-02f, -5.10531664e-03f, 3.20338048e-02f, 9.11033824e-02f, 9.61436704e-02f, -2.48005297e-02f, -7.02559799e-02f, 8.33356082e-02f,
  9.57450420e-02f, -1.79593777e-03f, -2.97425520e-02f, 3.29681709e-02f, 5.61015457e-02f, -2.40111034e-02f, -1.22170877e-02f, 6.19490109e-02f, -5.54717295e-02f, -1.65201630e-02f,
  -4.88869473e-02f, -6.21041236e-03f, 2.48808898e-02f, 7.86240306e-03f, -9.51052681e-02f, 1.20884581e-02f, 1.80205274e-02f, -5.31350784e-02f, -8.39057639e-02f, -8.43064040e-02f,
  -4.76862025e-03f, -3.28662395e-02f, 6.29023649e-03f, -1.15991235e-02f, 3.10304016e-02f, -5.01293577e-02f, -1.04283221e-01f, -1.39554385e-02f, -3.06692682e-02f, -5.73316850e-02f,
  -9.26402304e-03f, -6.70589581e-02f, -8.23183283e-02f, 4.65734489e-02f, 2.42082253e-02f, -3.42206731e-02f, -3.39283384e-02f, 1.03250574e-02f, -5.60673624e-02f, -5.53574190e-02f,
  -1.17159083e-01f, 6.37615174e-02f, -1.09116778e-01f, -9.14180093e-03f, 3.78109105e-02f, -3.33117843e-02f, -6.95481151e-02f, 5.39252758e-02f, -1.99735388e-02f, -4.68868539e-02f,
  -7.74325505e-02f, -7.12847337e-02f, 6.63997009e-02f, 1.10280119e-01f, 8.08650348e-03f, -2.40488816e-02f, 1.10656740e-02f, -3.24709564e-02f, 2.58568991e-02f, -5.62555576e-03f,
  -4.70900796e-02f, -8.74239728e-02f, -3.60947400e-02f, -6.58272058e-02f, -3.62715833e-02f, -9.23531577e-02f, -6.46599457e-02f, -5.77325672e-02f, -7.21345842e-02f, -1.01489708e-01f,
  -1.80635735e-01f, 6.76662996e-02f, 2.25642577e-01f, -1.82548016e-01f, -8.50076154e-02f, -1.08438190e-02f, 1.28461629e-01f, -9.78557095e-02f, -2.61376262e-01f, -4.63516712e-02f,
  -2.86258459e-01f, -3.41473043e-01f, -2.85438776e-01f, -1.33357093e-01f, -1.86776727e-01f, 6.98183328e-02f, 2.50434250e-01f, 1.58723354e-01f, -1.91422045e-01f, -1.58459187e-01f,
  -6.71432242e-02f, 7.39640743e-02f, -5.45142293e-02f, -8.79869238e-02f, 5.13517335e-02f, -8.08177665e-02f, 1.03965148e-01f, 5.76717295e-02f, 2.76028533e-02f, 1.75749123e-01f,
  -1.31828301e-02f, -8.28928575e-02f, -1.58886775e-01f, -1.07334167e-01f, -2.14142818e-02f, -8.55108872e-02f, -8.97327811e-02f, 1.47547352e-03f, -1.72579780e-01f, -3.44030447e-02f,
  -3.26429866e-02f, -3.92348617e-02f, -1.77975968e-01f, -1.05784260e-01f, -9.31975394e-02f, -2.24484093e-02f, 9.12125632e-02f, 5.77518977e-02f, -1.41717866e-01f, -4.76780385e-02f,
  -1.64664716e-01f, -9.91740748e-02f, -2.78365016e-02f, -1.36147633e-01f, -9.86818820e-02f, -2.17155084e-01f, -1.38308436e-01f, -2.82356218e-02f, -2.39771549e-02f, -5.04010879e-02f,
  2.38296315e-02f, 1.75249297e-02f, 1.02951661e-01f, 6.11364171e-02f, 4.68404107e-02f, 9.36825424e-02f, 8.85615200e-02f, 9.86702088e-03f, 4.38835621e-02f, 7.86983296e-02f,
  6.30815700e-02f, 1.65376216e-01f, 4.46605533e-02f, 9.36667919e-02f, 3.47279310e-02f, 1.45323709e-01f, 1.21408805e-01f, 1.18000433e-01f, 6.53855726e-02f, 1.65666640e-01f,
  3.91593613e-02f, 1.56952500e-01f, 1.13828972e-01f, 1.17998794e-01f, 1.91696227e-01f, 5.24398312e-02f, 9.57709849e-02f, 1.69217363e-01f, 7.43337870e-02f, 1.94677025e-01f,
  -2.10160464e-01f, -1.10587165e-01f, -3.44049148e-02f, -9.67665203e-03f, -7.47235417e-02f, -4.73266728e-02f, -7.65954033e-02f, -6.13929294e-02f, -1.19410113e-01f, -1.18331693e-01f,
  -1.05197027e-01f, -9.84776318e-02f, -2.30207294e-02f, -1.17305340e-02f, -4.61670607e-02f, -1.51564285e-01f, -1.05373330e-01f, -5.19632101e-02f, -6.65149540e-02f, -2.30055079e-02f,
  -2.90045161e-02f, -8.78827944e-02f, -2.13762909e-01f, -5.42720780e-02f, -9.34965536e-02f, -2.32803613e-01f, -1.65684819e-02f, -1.15812577e-01f, -5.75648062e-02f, -7.54742995e-02f,
  -9.68827903e-02f, 2.35025436e-01f, 2.15360060e-01f, -1.37854949e-01f, -1.13044210e-01f, 5.62926941e-02f, 1.22336529e-01f, 1.06719702e-01f, -1.30773922e-02f, 3.83391418e-02f,
  -4.52593388e-03f, -2.20823810e-01f, -1.26192942e-01f, -1.39243558e-01f, -3.47893238e-02f, 1.30541325e-01f, 6.43264204e-02f, -3.80481854e-02f, -6.60315081e-02f, -1.51051417e-01f,
  -1.69028103e-01f, 3.37146819e-02f, 7.17609236e-03f, -1.27867302e-02f, 1.95254963e-02f, -1.23987041e-01f, 1.13066867e-01f, 2.62114666e-02f, 7.07752556e-02f, -1.23027310e-01f,
  6.43772408e-02f, 7.06878901e-02f, -2.42810529e-02f, -7.79718235e-02f, 8.73455964e-03f, 9.14106704e-03f, 2.01299656e-02f, 9.76704434e-02f, 7.44959712e-02f, 6.23512156e-02f,
  -1.44166946e-01f, -8.38964526e-03f, -1.53414786e-01f, -1.43177621e-02f, 3.77124920e-02f, -2.37054899e-02f, 4.98139299e-02f, 3.98893468e-02f, -3.00082751e-02f, -7.22605661e-02f,
  -1.05197869e-01f, -9.08453837e-02f, 5.19459881e-02f, 2.77903620e-02f, 3.27857956e-02f, -1.82384506e-01f, -1.85460504e-03f, 5.06532192e-02f, 1.04346536e-01f, 1.02294423e-01f,
  4.01831381e-02f, -5.36335185e-02f, 2.21627112e-02f, 1.19102735e-03f, 4.78714965e-02f, 4.88662813e-03f, -3.24246176e-02f, -8.20962563e-02f, -4.66950610e-02f, -5.47524132e-02f,
  -4.17856015e-02f, 4.60536219e-02f, 2.51025632e-02f, -3.07275541e-03f, 1.67500600e-02f, -1.30662005e-02f, -1.27714239e-02f, 1.83772594e-02f, 4.47230265e-02f, 4.25524563e-02f,
  -9.69752856e-03f, -1.27226353e-01f, 6.18610010e-02f, -6.58554882e-02f, -3.07459757e-02f, -2.49186661e-02f, -5.91977015e-02f, -5.10542430e-02f, -3.45412688e-03f, 5.73362559e-02f,
  6.04703091e-02f, -4.13311273e-02f, 2.64272280e-02f, -5.73109910e-02f, -5.77727798e-03f, -3.72897275e-02f, -4.25487533e-02f, -1.48385614e-02f, -2.38652769e-02f, -1.01321839e-01f,
  -2.65277047e-02f, -7.69280046e-02f, -8.28144699e-02f, 2.63419300e-02f, 1.65197793e-02f, -2.08391249e-02f, 6.90823141e-03f, -8.00097138e-02f, -5.72679192e-02f, -1.79113783e-02f,
  -8.49968046e-02f, 4.28960845e-02f, 5.41432798e-02f, -1.70633837e-03f, 4.85572070e-02f, -5.30296415e-02f, 1.13732599e-01f, 5.82631379e-02f, 1.57664031e-01f, 2.41602555e-01f,
  -3.01165551e-01f, 1.20889239e-01f, 8.64267722e-02f, -4.04164381e-02f, 1.89202055e-01f, 2.62173861e-01f, 3.45081359e-01f, 8.31487253e-02f, -1.07435443e-01f, 1.06210381e-01f,
  2.23252121e-02f, -7.45482296e-02f, -4.89374734e-02f, 8.73472914e-03f, 4.94076870e-02f, 1.79698765e-01f, 6.64356425e-02f, -4.26071584e-02f, 3.09151853e-03f, 5.58385327e-02f,
  1.14559375e-01f, -7.65983164e-02f, -4.59418595e-02f, -5.29235564e-02f, -1.66933894e-01f, 8.46915506e-03f, -5.34107238e-02f, 6.59388723e-03f, 4.40647453e-02f, -2.85539687e-01f,
  -2.58781135e-01f, -3.66819389e-02f, 1.32011294e-01f, -9.85461324e-02f, -7.20374510e-02f, 6.14220975e-03f, 5.15146106e-02f, -2.17549317e-02f, 9.18314457e-02f, -8.17724504e-03f,
  -2.08295882e-03f, -7.07515925e-02f, 4.81348857e-02f, 4.74927835e-02f, 5.57798147e-02f, -4.62432429e-02f, -1.03730321e-01f, -4.76794206e-02f, -1.27692390e-02f, -9.50134844e-02f,
  -2.96136681e-02f, 7.40372986e-02f, 9.64903384e-02f, 7.46028349e-02f, -3.46492603e-02f, -3.50162387e-02f, 7.60349035e-02f, -8.93315077e-02f, 9.59768146e-02f, -1.60566702e-01f,
  2.51483489e-02f, 1.02471463e-01f, 2.12142877e-02f, -5.96808363e-03f, 3.92682366e-02f, -5.36793247e-02f, -3.96381915e-02f, 3.75686660e-02f, 5.03399828e-03f, 2.49194335e-02f,
  -5.69601282e-02f, -7.61227012e-02f, 5.81384301e-02f, 4.92116660e-02f, -1.07365884e-02f, 3.80883403e-02f, 5.52219115e-02f, -4.16923091e-02f, 9.45827365e-03f, -3.60427871e-02f,
  3.13706286e-02f, -7.47018978e-02f, -1.61773954e-02f, -8.27809051e-02f, -3.61375660e-02f, -4.84706797e-02f, 5.24296165e-02f, -3.39837484e-02f, 2.66540200e-02f, 8.94202068e-02f,
  -7.80738741e-02f, 8.88152719e-02f, -6.38174340e-02f, -1.05790332e-01f, -9.29590762e-02f, -3.36679034e-02f, -7.64636993e-02f, -4.07094955e-02f, -4.30097356e-02f, -1.01852395e-01f,
  6.08396046e-02f, 6.00453764e-02f, -6.32099584e-02f, -8.27884022e-03f, 7.94365257e-02f, -3.15224603e-02f, 7.27190673e-02f, 3.56564224e-02f, -4.09139656e-02f, -8.02748278e-03f,
  -2.16237945e-03f, 1.00569397e-01f, 7.13838041e-02f, 6.39911070e-02f, 1.91072021e-02f, 8.19227546e-02f, 1.23580694e-02f, 8.67625475e-02f, 8.63574892e-02f, 9.58329532e-03f,
  6.11413717e-01f, 3.31536718e-02f, -1.91491753e-01f, 1.28871650e-01f, 2.67528873e-02f, 6.70556501e-02f, 3.43368389e-02f, 7.95666303e-04f, -7.26927258e-03f, 5.47978841e-02f,
  7.74166808e-02f, 7.92495087e-02f, -3.95617113e-02f, -3.29842791e-02f, -9.17662308e-02f, -8.73211697e-02f, -1.98015675e-01f, -4.87750992e-02f, 4.84202243e-02f, 1.72124743e-01f,
  1.03746906e-01f, 5.25809154e-02f, 8.66178423e-02f, 2.62297485e-02f, 4.46843356e-02f, 5.28493226e-02f, -1.64791241e-01f, -1.01997092e-01f, -9.73830894e-02f, -1.31615624e-01f,
  5.10323681e-02f, 7.38970265e-02f, 1.06473923e-01f, 8.75133500e-02f, 3.08571830e-02f, 2.23467797e-02f, 1.16270952e-01f, -1.97027735e-02f, 3.92302424e-02f, -5.37540345e-03f,
  1.48814926e-02f, 8.77382904e-02f, -1.14924032e-02f, -5.75549118e-02f, 1.30237127e-02f, 6.80612307e-03f, 1.14877000e-02f, -5.55159226e-02f, -2.57521290e-02f, 2.72499248e-02f,
  -1.08437864e-02f, 1.49452269e-01f, 6.82199746e-02f, -9.37697887e-02f, -4.86778468e-02f, 6.64033294e-02f, 2.76713260e-02f, 2.38112397e-02f, 1.10809905e-02f, 6.81304783e-02f,
  -9.76484828e-03f, 1.85792409e-02f, -9.24994820e-04f, -5.59936054e-02f, 3.03402580e-02f, 8.03593639e-03f, -3.46704461e-02f, -1.36158867e-02f, -7.80027509e-02f, 2.47487575e-02f,
  -1.15468785e-01f, -1.50491185e-02f, -4.27933782e-02f, -2.63748989e-02f, 5.52926175e-02f, 2.29127444e-02f, -6.64609149e-02f, -1.18790392e-03f, -1.69988927e-02f, 7.89529756e-02f,
  -1.94341168e-02f, -8.16795379e-02f, -9.68191251e-02f, -7.67066628e-02f, -1.01948502e-02f, -2.44613364e-02f, -1.23714760e-01f, -2.54082792e-02f, -2.96513289e-02f, -2.46895608e-02f,
  3.05803776e-01f, -7.14491829e-02f, 1.52459621e-01f, 5.07297143e-02f, 1.14588670e-01f, -6.67419136e-02f, 7.51536787e-02f, -1.36579750e-02f, 1.15833335e-01f, 1.55387282e-01f,
  5.54521494e-02f, 1.32685810e-01f, 2.89876983e-02f, 6.00940399e-02f, 1.85346812e-01f, 1.34460852e-01f, -3.25403064e-02f, 1.05130002e-01f, 5.00638559e-02f, 3.28550749e-02f,
  -2.62534916e-02f, 1.31243110e-01f, 1.08561806e-01f, 7.16966465e-02f, 1.63234636e-01f, 2.08026811e-01f, 5.70465960e-02f, 1.75255716e-01f, 1.65910959e-01f, 3.71269822e-01f,
  -4.56091732e-01f, -9.31853577e-02f, -2.64429361e-01f, -9.51382220e-02f, -6.70369416e-02f, -2.71179110e-01f, -3.11845660e-01f, -2.51300812e-01f, -7.95808062e-02f, -1.00338019e-01f,
  -1.09742098e-01f, -4.08374518e-02f, -1.00329705e-01f, -1.50622174e-01f, -2.16987893e-01f, -1.36251539e-01f, -4.74308133e-02f, -2.35788301e-01f, -3.32033366e-01f, -2.17838615e-01f,
  -6.95973262e-02f, -9.24755782e-02f, -1.89701810e-01f, -8.56178850e-02f, -1.12017216e-02f, -1.27274483e-01f, -4.78610843e-02f, -1.63708314e-01f, 1.92463659e-02f, 1.20598845e-01f,
  5.59785729e-03f, -1.52380049e-01f, -2.43447080e-01f, -1.32681966e-01f, -6.02211021e-02f, -1.17165722e-01f, -2.08849013e-01f, -1.07029475e-01f, -2.06342623e-01f, -1.19071521e-01f,
  -1.40946180e-01f, -6.13852814e-02f, -9.47430953e-02f, -8.22915435e-02f, -2.21579596e-01f, -9.78440493e-02f, -1.35874152e-01f, -1.23235434e-01f, -2.37864107e-01f, -1.12792879e-01f,
  1.88626442e-02f, -1.63151458e-01f, -2.66567230e-01f, -2.38073424e-01f, -1.53995916e-01f, -9.26795155e-02f, -1.40153170e-01f, -5.38724065e-02f, -2.25928545e-01f, -1.39296696e-01f,
  1.12664349e-01f, 1.05758704e-01f, 8.21623281e-02f, 1.39639392e-01f, 1.06074043e-01f, 4.98388819e-02f, 8.51125494e-02f, 1.86952665e-01f, 1.03784710e-01f, 2.62226798e-02f,
  8.63548592e-02f, 7.31422454e-02f, 7.09208101e-02f, 1.15958974e-01f, 1.14351407e-01f, 1.18815176e-01f, 2.62472802e-03f, 1.32019252e-01f, 8.23149830e-02f, -1.81059132e-03f,
  8.47127959e-02f, 1.37806267e-01f, 1.85816363e-02f, 2.09864657e-02f, 4.99869622e-02f, 1.91747412e-01f, 7.41992891e-02f, 1.71731174e-01f, 1.81347370e-01f, 8.14270601e-02f,
  -1.01298988e-01f, -3.32088888e-01f, -8.35950896e-02f, -7.02833906e-02f, -1.79487109e-01f, -1.23332106e-01f, -3.92180122e-02f, -8.44865516e-02f, -1.25294209e-01f, -1.58557162e-01f,
  -1.67155489e-01f, -1.33938015e-01f, -1.38078541e-01f, -1.13239333e-01f, -8.48150551e-02f, -1.73459724e-01f, -1.44812688e-01f, -1.15130849e-01f, -7.00227022e-02f, -1.09333321e-01f,
  -1.16995022e-01f, -1.13604337e-01f, -1.84349582e-01f, -2.13577583e-01f, -1.64794669e-01f, -1.95259616e-01f, -1.70282289e-01f, -6.44392222e-02f, -2.16288179e-01f, -1.81979567e-01f,
  -1.13297194e-01f, -7.45688379e-02f, 3.31721634e-01f, -3.59706394e-02f, 3.60339247e-02f, -2.15573162e-02f, -2.50129640e-01f, -1.66925222e-01f, 5.52271376e-04f, -2.10106354e-02f,
  1.49077728e-01f, 1.01203203e-01f, 9.11901742e-02f, 9.27539021e-02f, 7.63738248e-03f, -1.84065737e-02f, 6.64449632e-02f, 7.88290203e-02f, 1.35753408e-01f, 2.96481270e-02f,
  -5.72304837e-02f, -3.19778211e-02f, -1.11286461e-01f, 6.07074797e-02f, 1.40094114e-02f, -1.18741184e-01f, -9.46039706e-02f, -5.54324351e-02f, -7.72442967e-02f, 6.65241107e-02f,
  3.31732422e-01f, 9.19673368e-02f, 1.58604711e-01f, 3.00207753e-02f, 1.25641242e-01f, 8.57023243e-03f, 5.80994703e-04f, 8.50832164e-02f, 1.12027191e-01f, -2.59714331e-02f,
  9.26227793e-02f, 1.06327511e-01f, -2.86817225e-03f, 7.17377141e-02f, -4.02300507e-02f, -5.22509925e-02f, -7.65719935e-02f, 6.36338443e-02f, 5.94915748e-02f, 7.79578164e-02f,
  -8.32693875e-02f, 1.05059601e-01f, 2.44232472e-02f, 1.76056884e-02f, -1.98930805e-03f, 9.70248207e-02f, 2.33738050e-02f, -7.84169659e-02f, 1.34440102e-02f, -8.05510655e-02f,
  -1.33983687e-01f, 9.81440395e-02f, 1.93297621e-02f, -1.18978105e-01f, -5.50683998e-02f, 2.01022271e-02f, 5.32798506e-02f, 2.89204121e-02f, 2.65132934e-02f, -4.58943546e-02f,
  -2.15108301e-02f, 8.48220587e-02f, 6.11080509e-03f, -3.45653929e-02f, 5.78064136e-02f, 4.04919758e-02f, 9.33089480e-03f, -4.95485179e-02f, 6.34343550e-02f, -3.90602946e-02f,
  1.66372564e-02f, 9.48277563e-02f, 4.14541811e-02f, 5.60061261e-03f, 9.19772089e-02f, -4.54887003e-03f, 5.55681884e-02f, 2.49743760e-02f, -1.58338845e-02f, 4.08375217e-03f,
  -8.34854767e-02f, 2.22625434e-01f, 4.31949198e-02f, -5.32082208e-02f, -9.03965067e-03f, -1.24050686e-02f, 5.81200868e-02f, 2.14176858e-03f, 1.92524955e-01f, -3.65487076e-02f,
  1.07414931e-01f, -2.95362659e-02f, 2.79669650e-02f, -3.65877971e-02f, 4.06092666e-02f, 3.16191316e-02f, -5.99538237e-02f, 2.44622044e-02f, 6.00910597e-02f, -4.48884927e-02f,
  -4.74334732e-02f, -3.84222083e-02f, -8.09315741e-02f, -5.28692417e-02f, -8.16971213e-02f, 1.64863598e-02f, -8.88046697e-02f, 1.75377987e-02f, -8.76004472e-02f, -2.63328731e-01f
};

// L0_fan_Wp_bar (Shape: 26 x 120)
const int L0_fan_Wp_bar_rows = 26;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  2.70634107e-02f, 3.78298461e-01f, 1.26052752e-01f, 6.60517961e-02f, 1.37668639e-01f, 1.94100186e-01f, 3.19802642e-01f, 1.80266261e-01f, 1.30007742e-02f, 9.20120999e-03f,
  -3.47806327e-02f, -9.76153463e-02f, 2.63333693e-03f, -2.84382906e-02f, 6.44553006e-02f, 2.35396057e-01f, 2.03622684e-01f, -2.25725025e-02f, -5.22028655e-02f, 1.01155169e-01f,
  -1.85012091e-02f, 4.96358834e-02f, -6.43130913e-02f, 6.46099001e-02f, 1.42162427e-01f, -1.91868201e-03f, 1.41823171e-02f, 1.52580068e-01f, 1.18468471e-01f, 2.01303869e-01f,
  -1.17378190e-01f, 1.77916288e-01f, -2.44805828e-01f, -1.19311601e-01f, -1.46457730e-02f, -1.38493687e-01f, -2.17420399e-01f, -5.47943600e-02f, -5.11922427e-02f, -5.44645451e-02f,
  -7.87226632e-02f, 5.31438068e-02f, 1.18893288e-01f, 5.34849614e-02f, -2.62973807e-03f, 7.00716600e-02f, 4.77671586e-02f, 3.35827805e-02f, -5.54102734e-02f, 9.97038186e-03f,
  8.67475346e-02f, -7.07941726e-02f, 8.59188661e-02f, 6.91965818e-02f, 1.96011484e-01f, -1.15135029e-01f, -5.78919202e-02f, 1.11124538e-01f, -5.34870028e-02f, -5.88498898e-02f,
  -2.93824464e-01f, -1.79976802e-02f, 2.10940838e-01f, -5.31103015e-02f, 3.20764519e-02f, -8.16462710e-02f, 7.58040398e-02f, 1.18247338e-01f, 1.72289029e-01f, 1.09064691e-01f,
  2.73415279e-02f, -1.07142963e-01f, -1.70523688e-01f, -1.05356447e-01f, -9.65697095e-02f, 2.87181791e-02f, -1.92832276e-02f, -4.09864783e-02f, -1.00505417e-02f, 1.80464908e-02f,
  6.13245219e-02f, 5.85090322e-03f, -6.91031888e-02f, 6.54511526e-02f, 4.60175015e-02f, -6.46706671e-02f, -4.88380529e-02f, -4.02128883e-02f, -2.38122162e-03f, -1.53939486e-01f,
  -2.31457874e-01f, -2.12138206e-01f, -2.29918763e-01f, 7.88035914e-02f, 7.05722272e-02f, -1.51331145e-02f, -1.63718760e-01f, -6.80631846e-02f, -8.20935890e-02f, -7.61722997e-02f,
  1.37208737e-02f, -8.86663944e-02f, 6.91274703e-02f, -3.39379646e-02f, -2.50062704e-01f, -1.57547012e-01f, -8.17670748e-02f, -5.30004017e-02f, 1.59165096e-02f, -9.16985143e-03f,
  -2.26561222e-02f, -1.78153679e-01f, -1.08120091e-01f, -7.17114955e-02f, -6.67043552e-02f, -2.43740648e-01f, -6.82479590e-02f, -1.30157813e-01f, -6.59609735e-02f, -6.45023435e-02f,
  4.37796980e-01f, -1.42596871e-01f, 1.60987392e-01f, 1.22998126e-01f, 1.27871260e-01f, 2.59918243e-01f, 9.07969698e-02f, 4.50859107e-02f, 9.99048874e-02f, -1.18669838e-01f,
  -7.19600990e-02f, -1.14389323e-02f, -4.88585904e-02f, -1.54111013e-01f, 3.21858525e-02f, -1.25130713e-01f, -7.08771823e-03f, 2.12171562e-02f, 1.37224644e-01f, 2.24787053e-02f,
  -1.58291236e-01f, -1.55693769e-01f, -2.98999883e-02f, -1.13326177e-01f, -1.71922252e-01f, -1.40861169e-01f, -1.39107049e-01f, 3.23555022e-02f, -1.35982707e-01f, -3.39570194e-01f,
  1.21317811e-01f, 2.33422726e-01f, 4.46666367e-02f, 3.07123251e-02f, 5.41114025e-02f, -3.45612355e-02f, 1.23744346e-01f, -3.02484538e-02f, 1.21221252e-01f, 3.40624638e-02f,
  -6.38877368e-03f, -4.51322459e-02f, -6.09722994e-02f, -3.58547382e-02f, -9.73397586e-03f, 2.82422377e-04f, 1.25045702e-02f, 5.20134810e-03f, -2.02110112e-02f, 8.20873678e-02f,
  1.38683384e-03f, 1.32039398e-01f, 1.91924781e-01f, 1.97075352e-01f, 9.59907696e-02f, 1.59860119e-01f, 3.81951854e-02f, 1.43227071e-01f, 1.60320222e-01f, 3.82443890e-03f,
  5.43778948e-02f, -8.05891603e-02f, 1.14090182e-02f, 1.51905149e-01f, 3.90523151e-02f, 1.75482154e-01f, 4.67421524e-02f, 3.86315770e-02f, 1.09505303e-01f, -6.75014034e-02f,
  -1.25861049e-01f, 1.55888975e-01f, 2.19457060e-01f, 1.18956298e-01f, -6.38381392e-02f, -1.64896511e-02f, -2.45215110e-02f, 9.51088220e-03f, -1.70096811e-02f, 6.58817291e-02f,
  1.60152867e-01f, 6.02344377e-03f, -7.66330436e-02f, -1.08532026e-01f, -4.87537384e-02f, 8.44092518e-02f, -2.60427268e-03f, 2.37181839e-02f, -8.47541094e-02f, -1.69354632e-01f,
  8.47138744e-03f, 2.77357668e-01f, 4.91852080e-03f, -1.42014503e-01f, -1.09357931e-01f, -8.17672983e-02f, -6.23892508e-02f, -4.48136553e-02f, -2.46327464e-02f, 5.66088930e-02f,
  -9.99332033e-03f, -1.19588993e-01f, -7.80263990e-02f, 3.64873111e-02f, 1.21280372e-01f, 1.23909354e-01f, -3.18172649e-02f, -1.01238422e-01f, -1.14800282e-01f, -9.33642779e-03f,
  -1.05734728e-01f, 1.45476907e-01f, 6.51065186e-02f, 8.69846642e-02f, 1.24710016e-01f, 1.08365938e-01f, 2.79130368e-03f, -4.98810923e-03f, 1.08847946e-01f, -6.38928637e-02f,
  3.48406643e-01f, 2.43187621e-01f, 2.57552356e-01f, 1.49022534e-01f, 2.40899220e-01f, 2.43523777e-01f, 3.97874832e-01f, 2.87802488e-01f, 7.32599348e-02f, 3.84953655e-02f,
  1.88809857e-02f, -7.06666708e-02f, -3.87150832e-02f, -1.14257820e-01f, 1.48800880e-01f, 1.29866555e-01f, 2.05392241e-01f, 1.06921628e-01f, 9.98180136e-02f, 1.76220853e-02f,
  -2.89820097e-02f, 7.03384876e-02f, -7.91752711e-02f, 2.22729873e-02f, -2.47228984e-02f, 3.15894671e-02f, 2.01989077e-02f, 7.85210505e-02f, 1.68035477e-01f, -7.51013905e-02f,
  -2.41063341e-01f, 8.67320821e-02f, -5.61047867e-02f, -1.63023576e-01f, -5.16582765e-02f, -6.32450134e-02f, -3.09112500e-02f, 7.87940342e-03f, -6.02452494e-02f, 6.72659054e-02f,
  -8.55190307e-02f, -6.11437634e-02f, 1.35018853e-02f, -6.06994517e-03f, 9.83169451e-02f, -6.05872758e-02f, -8.04393291e-02f, 4.76670079e-02f, -8.52246061e-02f, -4.56474908e-02f,
  -1.50311306e-01f, 1.10861145e-01f, 3.82521562e-02f, 3.21277380e-02f, 2.59248931e-02f, -1.05436504e-01f, 4.04702835e-02f, 3.42321210e-02f, 4.72069904e-02f, -6.23996370e-02f,
  4.80142143e-03f, -7.93359429e-03f, -1.45207688e-01f, -1.26618333e-02f, -4.83024083e-02f, -3.65257896e-02f, 2.93413817e-04f, 4.40866277e-02f, -2.55292654e-02f, -6.94589019e-02f,
  -1.25215292e-01f, -1.84630126e-01f, -4.89752591e-02f, -1.42149135e-01f, -9.42289084e-02f, -6.14003986e-02f, 6.01427369e-02f, -1.94388285e-01f, -1.75994173e-01f, -1.55846313e-01f,
  -9.42089558e-02f, 5.20946793e-02f, 2.06467193e-02f, -6.55940846e-02f, -1.78206697e-01f, -4.46017310e-02f, -2.60339789e-02f, -1.89104140e-01f, 4.95214537e-02f, 5.66324405e-02f,
  -2.92492598e-01f, -2.44691759e-01f, -2.44838491e-01f, 6.04381263e-02f, 3.78511734e-02f, -6.19294830e-02f, -8.88665617e-02f, 1.15673458e-02f, 6.21463358e-02f, -3.95203307e-02f,
  -4.47412468e-02f, -8.45737308e-02f, -3.82690690e-02f, -9.01545212e-02f, -2.32509002e-02f, -4.90048565e-02f, -6.41488703e-03f, 2.73338892e-03f, -4.07307558e-02f, -1.54068425e-01f,
  -1.06654122e-01f, 8.54418501e-02f, 1.99317336e-02f, 3.97085324e-02f, 1.85145009e-02f, -1.01488739e-01f, -3.21082063e-02f, 5.87854646e-02f, -6.92166761e-02f, -4.87388410e-02f,
  6.42508268e-02f, -4.88716513e-01f, 2.61691481e-01f, 6.71317056e-02f, 2.42882460e-01f, 3.20845246e-01f, 1.79452106e-01f, 2.45342925e-02f, -1.71448529e-01f, -1.56955674e-01f,
  -2.70975024e-01f, -2.94570267e-01f, -3.92685652e-01f, -2.62183100e-01f, -1.13625705e-01f, 1.73601702e-01f, 2.99850047e-01f, 1.66126058e-01f, 2.46982411e-01f, 1.30660444e-01f,
  -5.05093336e-02f, -8.77950788e-02f, -1.65381268e-01f, -4.62903194e-02f, -3.79271768e-02f, -1.77733023e-02f, 3.06258537e-02f, -1.39533477e-02f, -1.04726993e-01f, 1.16582392e-02f,
  4.36271690e-02f, -2.31767800e-02f, -1.52012100e-02f, -2.39263058e-01f, -7.14873970e-02f, -6.14546202e-02f, -5.44636995e-02f, -6.10496216e-02f, -2.00587269e-02f, 4.26921137e-02f,
  -3.02235801e-02f, -9.21406597e-02f, -6.36479259e-03f, 2.16121189e-02f, 9.31908265e-02f, 3.92500237e-02f, -4.54141498e-02f, 2.69536283e-02f, -2.25646924e-02f, -5.53343911e-03f,
  4.76362817e-02f, -7.46391490e-02f, 3.78750153e-02f, 7.81583413e-02f, -6.95361048e-02f, -5.34459688e-02f, 3.26750949e-02f, -8.72023106e-02f, -1.07861664e-02f, -5.89996278e-02f,
  3.66249345e-02f, 6.69782236e-02f, 7.31690824e-02f, -1.13248572e-01f, 5.31328656e-02f, -8.11104551e-02f, -7.16593256e-03f, -4.64206710e-02f, 8.55685100e-02f, 6.38318583e-02f,
  -1.44564512e-03f, -1.86463576e-02f, -1.12366244e-01f, -1.15083635e-01f, -8.66115093e-02f, -6.10010959e-02f, 7.21272305e-02f, -6.12351522e-02f, -6.56673461e-02f, -4.97207306e-02f,
  -1.32846922e-01f, -8.08508415e-03f, -7.35910162e-02f, 4.85729314e-02f, -3.30947973e-02f, 1.27760032e-02f, -4.37403657e-02f, 6.69757575e-02f, 4.45122756e-02f, -7.58714080e-02f,
  -1.61280051e-01f, -3.68035510e-02f, -1.20756477e-01f, -2.22957522e-01f, 1.15682930e-02f, -9.82409120e-02f, -1.04682699e-01f, -9.86818150e-02f, -7.35112503e-02f, -2.07051821e-02f,
  8.58315006e-02f, -1.86993182e-02f, -1.04867145e-01f, -5.13206013e-02f, 1.34745687e-01f, 1.59575552e-01f, -3.73155549e-02f, 3.09724603e-02f, -1.06545109e-02f, 4.92019206e-02f,
  3.10420319e-02f, 1.36035785e-01f, 3.62331010e-02f, -8.79962370e-02f, -6.04273751e-02f, -4.43251152e-03f, 1.47756413e-01f, 2.45908853e-02f, 2.63258237e-02f, 6.92467690e-02f,
  9.40594748e-02f, -3.21576089e-01f, -1.09905496e-01f, -1.95467547e-01f, -4.34465371e-02f, 1.66181307e-02f, 6.62906542e-02f, 3.46532725e-02f, -1.02541596e-01f, -1.64743334e-01f,
  -1.92393720e-01f, -8.13266411e-02f, -2.20790133e-02f, -1.15549760e-02f, -2.69430615e-02f, -1.10269822e-01f, -1.21936262e-01f, 5.82006723e-02f, 2.56680161e-01f, 2.05326289e-01f,
  9.88374278e-02f, 8.07599276e-02f, -4.31823917e-03f, -6.14958368e-02f, -1.36324003e-01f, 4.45885882e-02f, -1.55485660e-01f, -1.49172574e-01f, -1.59936875e-01f, -1.84853092e-01f,
  2.10604370e-01f, -1.74089223e-01f, 6.29337803e-02f, 3.50565673e-03f, -1.94015037e-02f, -5.13413362e-02f, 9.04771462e-02f, -1.29754022e-01f, -1.00384526e-01f, -2.01229546e-02f,
  -1.38142988e-01f, -9.13888663e-02f, -7.31472820e-02f, 1.87843796e-02f, 9.65530425e-02f, -8.75693783e-02f, -7.55585497e-04f, -4.10449952e-02f, -1.26057565e-01f, -7.66281113e-02f,
  -9.90591496e-02f, -7.34867379e-02f, 8.71946886e-02f, 5.70204817e-02f, 6.78394129e-03f, -4.90845479e-02f, -9.04525742e-02f, -1.19749792e-01f, -5.11954799e-02f, 1.59330224e-03f,
  8.21145251e-02f, 5.68332076e-02f, 3.32572870e-02f, 2.65053753e-02f, 9.61902738e-02f, 1.02566130e-01f, 1.87649235e-01f, 9.25839394e-02f, 9.50870663e-02f, -1.75158922e-02f,
  -1.03342533e-01f, -3.51595953e-02f, -4.16503660e-02f, 2.32213903e-02f, -7.66996518e-02f, -1.00397706e-01f, -1.66298598e-02f, 9.98104438e-02f, -6.86201965e-03f, -4.18890901e-02f,
  -3.73175628e-02f, -7.85675868e-02f, -8.60062316e-02f, -1.38670662e-02f, -1.52575910e-01f, -1.19219370e-01f, -1.11359440e-01f, 2.86274515e-02f, -2.81330198e-02f, -5.73771214e-03f,
  1.81565374e-01f, -6.15482293e-02f, 4.71396856e-02f, -6.87945541e-03f, -1.12355269e-01f, -1.03897668e-01f, -4.48808111e-02f, 2.53409054e-02f, 2.33502616e-03f, 9.49764475e-02f,
  4.96704550e-03f, 2.60867458e-02f, -5.31999804e-02f, -1.32007450e-01f, 1.48873702e-01f, 9.21127945e-02f, 6.85065985e-03f, -5.81210926e-02f, -6.03787787e-02f, -4.00339551e-02f,
  -1.08358867e-01f, 2.44622286e-02f, 1.68049246e-01f, 7.25665465e-02f, 6.42919317e-02f, 1.84413046e-01f, 9.31529105e-02f, 1.13286376e-01f, 7.81700611e-02f, 2.17296675e-01f,
  2.20938146e-01f, -2.39296809e-01f, -2.41589263e-01f, 1.74576879e-01f, 1.25417247e-01f, 2.35955015e-01f, 1.75249875e-01f, 1.15839347e-01f, 1.12504885e-01f, 2.69851796e-02f,
  -1.97097883e-01f, -2.24713147e-01f, -1.52777135e-01f, -2.08465785e-01f, -7.99040422e-02f, 1.49189368e-01f, 3.18569988e-02f, 1.67111009e-02f, 6.23894893e-02f, 1.86092556e-01f,
  1.15114279e-01f, 9.86456573e-02f, -4.91692033e-03f, 2.59488318e-02f, -6.40539527e-02f, -8.59588385e-02f, -7.61228427e-02f, -3.29274125e-02f, -1.22700647e-01f, -1.73430979e-01f,
  -1.65701807e-01f, -3.58336717e-01f, 1.27626717e-01f, -4.23102342e-02f, -1.12567134e-01f, -2.68848576e-02f, -5.60948886e-02f, -4.24107611e-02f, 4.49586809e-02f, 2.44900249e-02f,
  -1.48393409e-02f, -5.84696122e-02f, 5.96337691e-02f, -5.56431599e-02f, 1.90141559e-01f, 1.61956802e-01f, -1.06843457e-01f, -2.05182917e-02f, -6.20747954e-02f, -1.50165573e-01f,
  -1.78112239e-01f, -6.41625151e-02f, -4.54518534e-02f, -8.57578516e-02f, 1.90645130e-03f, -1.02000684e-02f, -6.67698458e-02f, -1.40213177e-01f, -1.19859681e-01f, 1.59043029e-01f,
  1.77117154e-01f, 4.66485834e-03f, -1.53298691e-01f, 7.92140898e-04f, 5.78019693e-02f, 1.11361653e-01f, 3.11467238e-03f, 9.88557041e-02f, -5.62723354e-02f, 1.24780558e-01f,
  1.76437609e-02f, -3.93722802e-02f, -1.64332047e-01f, -1.23594673e-02f, -1.27216533e-01f, -1.14963174e-01f, 5.05647846e-02f, -1.12719387e-01f, -7.41757527e-02f, -1.59926146e-01f,
  -9.78019759e-02f, -8.75700638e-02f, -1.81886517e-02f, -1.08952731e-01f, -2.36292928e-02f, 8.09551403e-03f, 1.23450328e-02f, -1.32269382e-01f, 4.56173159e-02f, -2.43436415e-02f,
  -1.08273156e-01f, -3.72439325e-01f, 1.13173664e-01f, -9.35854837e-02f, 1.21001974e-02f, -1.30533904e-01f, -2.98662901e-01f, -4.94513884e-02f, 3.85388806e-02f, -1.42735699e-02f,
  -3.04641034e-02f, 3.00527308e-02f, -7.53780501e-03f, 4.22823839e-02f, 2.48355687e-01f, 7.82536417e-02f, 2.44956426e-02f, 4.48691845e-02f, 3.17560658e-02f, -4.15146984e-02f,
  5.04563935e-02f, 1.56322792e-01f, 2.30009675e-01f, 2.75809243e-02f, 1.60618752e-01f, 1.69415057e-01f, 5.03431410e-02f, 1.47143230e-01f, 1.42305076e-01f, 3.85073006e-01f,
  -8.82041216e-01f, -1.86153099e-01f, -9.42267552e-02f, -1.15316259e-02f, 2.03535721e-01f, 3.78502905e-02f, 1.75453320e-01f, -1.37731293e-02f, -7.16244206e-02f, 1.61406416e-02f,
  1.09442249e-01f, 1.67790651e-01f, 5.63615561e-02f, 1.88939691e-01f, 1.25355616e-01f, 2.55089462e-01f, 2.40505829e-01f, -1.58018246e-02f, -1.04479581e-01f, 3.19439434e-02f,
  2.20618278e-01f, 1.34934634e-02f, -2.18080625e-01f, -9.13823396e-02f, 3.22158635e-02f, 6.57021627e-02f, 1.26787812e-01f, 3.61265838e-02f, 1.75555006e-01f, 1.80975050e-01f,
  3.91409338e-01f, -1.62605330e-01f, -6.13937969e-04f, -1.22149289e-01f, -1.23448528e-01f, -2.76300758e-01f, -1.09073415e-01f, -1.19101554e-01f, -3.71145159e-02f, 5.25825024e-02f,
  -7.17295408e-02f, -7.17761219e-02f, -5.33596091e-02f, -2.46059801e-02f, -3.00310552e-03f, -6.45635277e-02f, -7.10747167e-02f, 1.04893617e-01f, 6.59431666e-02f, 1.03435718e-01f,
  5.91088161e-02f, -3.12844217e-02f, 7.12222680e-02f, 4.73959930e-02f, -5.46111614e-02f, 1.84079837e-02f, -1.06265180e-01f, -8.61801729e-02f, -4.68776189e-02f, -1.76782608e-01f,
  -3.06030735e-03f, -1.01348765e-01f, -7.40838796e-02f, -3.18660550e-02f, -3.82221378e-02f, -4.14730655e-03f, 6.61322474e-02f, 2.72946805e-02f, 8.35731402e-02f, -3.12806033e-02f,
  9.70424935e-02f, 1.86151713e-01f, 1.97655708e-02f, -1.80833414e-02f, -7.85454810e-02f, -1.79422460e-03f, -5.98862320e-02f, 8.19125250e-02f, 3.29906791e-02f, 7.03338254e-03f,
  -2.93478537e-02f, 5.89979626e-02f, -1.38017222e-01f, -5.00043593e-02f, -2.45241623e-04f, -1.04797751e-01f, -1.71617884e-03f, 3.98612358e-02f, -1.26760557e-01f, -5.18699456e-03f,
  4.60750997e-01f, 2.52075344e-02f, 1.27034783e-01f, 9.71228629e-02f, -3.83623578e-02f, -1.70528412e-01f, 1.28703788e-01f, 1.37101680e-01f, 1.23445794e-01f, 1.03378348e-01f,
  2.98652407e-02f, -1.64888516e-01f, -2.17299515e-04f, -4.95381244e-02f, -3.30526084e-02f, -5.68703935e-02f, -1.71017945e-02f, 1.16827093e-01f, 8.53542462e-02f, 1.64896637e-01f,
  -9.76722240e-02f, -4.23314832e-02f, 6.75388128e-02f, 6.23873137e-02f, 5.51555939e-02f, 2.90257838e-02f, 2.88720503e-02f, 1.15077175e-01f, 1.01101652e-01f, -4.32774983e-02f,
  5.44804595e-02f, 4.74420004e-02f, 1.63927540e-01f, 2.62904972e-01f, 2.25986958e-01f, 2.72913903e-01f, 1.87181115e-01f, 1.24844603e-01f, 1.88092217e-01f, 1.90449163e-01f,
  1.66358426e-01f, 2.57417530e-01f, 1.55025721e-01f, 1.21856131e-01f, 1.24784857e-01f, 4.07060646e-02f, 1.02250658e-01f, 1.11419514e-01f, 7.90295675e-02f, 7.26828501e-02f,
  6.17242940e-02f, -6.70326278e-02f, 5.67396134e-02f, -2.95051113e-02f, 4.72673364e-02f, 1.85292348e-01f, 1.04414625e-02f, -1.59614310e-02f, 1.38559565e-01f, 8.17148015e-02f,
  1.62784010e-01f, 4.38364223e-02f, -8.65953788e-03f, -7.56028742e-02f, -1.16325974e-01f, -2.36051828e-01f, 3.97626422e-02f, -1.11315995e-01f, -8.06106552e-02f, -3.90176959e-02f,
  3.36334924e-03f, -1.88230172e-01f, -3.01155932e-02f, -2.30264142e-02f, -9.84556004e-02f, -1.61837578e-01f, -1.52437270e-01f, 4.13368382e-02f, 1.07267529e-01f, -3.24225100e-03f,
  -6.94796368e-02f, 6.06388189e-02f, 1.23929836e-01f, 9.43362042e-02f, 6.37683123e-02f, 6.41679242e-02f, 6.13013729e-02f, 5.19041084e-02f, 3.57549824e-02f, 3.10700480e-02f,
  3.41917932e-01f, 4.67687175e-02f, 5.38319796e-02f, 1.02404142e-02f, 8.64050388e-02f, 2.80735660e-02f, 3.76739204e-02f, 3.75640877e-02f, 1.15274131e-01f, 5.55015914e-02f,
  5.90468384e-02f, 1.08396046e-01f, -1.63171161e-02f, 4.94909361e-02f, 1.20421043e-02f, -9.28717665e-03f, -1.87686086e-02f, -1.91359334e-02f, -8.11828487e-03f, -9.35515575e-03f,
  1.23614155e-01f, -1.45148560e-01f, -1.04572192e-01f, -7.76427537e-02f, -8.56997911e-03f, 6.48814812e-02f, 3.24385017e-02f, -2.00551786e-02f, -7.78591335e-02f, -6.03378639e-02f,
  -6.97181001e-03f, 2.66818017e-01f, -3.39225680e-02f, -5.44726811e-02f, -1.16017461e-03f, -1.08413957e-01f, 7.97042400e-02f, -8.50782767e-02f, -1.74381420e-01f, -4.94279638e-02f,
  -4.11722213e-02f, -4.79042009e-02f, 1.82696097e-02f, -3.71398255e-02f, -1.05846927e-01f, -4.81597632e-02f, -5.85890859e-02f, 9.58637595e-02f, 4.31639627e-02f, -1.45963561e-02f,
  -1.27538830e-01f, 1.81380566e-02f, 8.28112885e-02f, 4.89136800e-02f, 8.85166675e-02f, 6.03216290e-02f, 2.66319979e-02f, -9.17755291e-02f, 1.10353433e-01f, -1.16079152e-01f,
  2.56402671e-01f, 5.53115532e-02f, 1.99596584e-01f, 1.14214472e-01f, -1.79549128e-01f, -1.30392984e-01f, -2.29192451e-01f, -1.93903446e-02f, -1.62951555e-02f, -3.39330994e-02f,
  -1.57219097e-01f, 1.28725260e-01f, 4.28772680e-02f, 2.54759938e-01f, 1.80833131e-01f, 2.37919584e-01f, 3.08274478e-01f, 3.81605685e-01f, 2.03541353e-01f, 1.22889258e-01f,
  1.46469072e-01f, 8.73638764e-02f, 1.64783522e-01f, 1.62504241e-01f, 2.42286012e-01f, 2.56115980e-02f, 2.03505829e-02f, 1.08236954e-01f, 9.52027291e-02f, 4.21194285e-01f,
  5.64346928e-03f, 1.82643831e-01f, 6.34932220e-02f, -2.60690041e-02f, -1.00741629e-02f, 2.36342568e-02f, -2.63854954e-02f, 5.63779622e-02f, -1.68582983e-02f, -5.56881092e-02f,
  -7.56765977e-02f, -3.92312296e-02f, 7.60208517e-02f, 7.50012472e-02f, 1.70430802e-02f, -4.43901643e-02f, 1.10337213e-01f, 7.07229078e-02f, 1.44559862e-02f, -6.54969364e-02f,
  4.15812954e-02f, -1.79969668e-01f, -1.57123253e-01f, -1.59389526e-01f, 9.08960626e-02f, 4.99642966e-03f, -3.54081504e-02f, 1.15846314e-01f, -5.63451573e-02f, 3.12998220e-02f,
  -6.50082715e-03f, -2.09256858e-02f, 8.26301724e-02f, 7.67644793e-02f, 1.05399117e-01f, 1.20538041e-01f, 2.39765700e-02f, -1.95965730e-02f, 1.33502066e-01f, 7.20665902e-02f,
  3.85921933e-02f, 7.42369518e-02f, 8.19529817e-02f, -9.25140679e-02f, -9.17858537e-03f, 2.59217545e-02f, -6.29568892e-03f, 3.13568525e-02f, -5.82011379e-02f, -1.35103250e-02f,
  -5.16306907e-02f, -3.67843434e-02f, 1.00556789e-02f, 9.92753133e-02f, -5.78681305e-02f, 1.27615988e-01f, -4.19289134e-02f, -6.04500063e-02f, 8.24406836e-03f, -6.84402958e-02f,
  -5.24777055e-01f, -1.96111143e-01f, 7.57982060e-02f, 1.20216571e-01f, 1.92830048e-04f, -9.97675657e-02f, -2.82273777e-02f, -1.15616679e-01f, -1.29556686e-01f, -3.19769159e-02f,
  -8.52524042e-02f, 6.59946958e-03f, -8.17310289e-02f, 4.23573516e-02f, -1.17441662e-01f, -3.33563462e-02f, 7.69729614e-02f, 7.06133842e-02f, -2.00916007e-02f, -1.49879396e-01f,
  -2.96440367e-02f, -1.31344125e-01f, -2.12766126e-01f, -1.75561458e-01f, -9.89416912e-02f, -1.27872556e-01f, -1.67961702e-01f, -9.90144610e-02f, -9.15055498e-02f, -1.41843900e-01f,
  -7.72695601e-01f, -5.21860979e-02f, 3.52782458e-01f, -4.54288185e-01f, -1.92334026e-01f, -2.27792904e-01f, -2.60008037e-01f, -3.03939909e-01f, -3.06729972e-01f, -1.04989290e-01f,
  1.52851984e-01f, 2.32873783e-01f, 1.88580647e-01f, 2.61756688e-01f, 1.94793474e-02f, -2.01011077e-01f, -1.43400326e-01f, -6.66405931e-02f, 1.80556718e-02f, -3.39264721e-02f,
  -2.77315617e-01f, -3.24807435e-01f, -3.90639782e-01f, -1.55793607e-01f, -8.58373009e-03f, -9.32764560e-02f, 4.68572900e-02f, -2.34074861e-01f, -3.50920670e-02f, -1.77622199e-01f,
  4.49265391e-01f, -1.28072083e-01f, -8.20010677e-02f, -2.36050814e-01f, 4.71167490e-02f, -1.04977056e-01f, -3.36443931e-02f, 4.24169265e-02f, -1.58737734e-01f, -2.77379099e-02f,
  3.03690066e-03f, 9.09766853e-02f, 1.17817670e-02f, -3.59589383e-02f, -1.25624882e-02f, -1.28792902e-03f, 4.88912798e-02f, 7.14183040e-03f, 4.86117341e-02f, 9.43348184e-02f,
  1.14583336e-01f, -1.11730576e-01f, 8.16840306e-02f, 5.18522635e-02f, 1.13842748e-01f, 4.58114445e-02f, 7.87046403e-02f, 7.22265318e-02f, 3.51457112e-02f, -5.20309918e-02f,
  2.99843568e-02f, 1.25614777e-01f, 7.58536309e-02f, 3.32557932e-02f, 2.86126342e-02f, 2.27483120e-02f, 2.21554562e-02f, 8.20852295e-02f, -9.33399517e-03f, -2.96945870e-03f,
  -8.55776202e-03f, 4.06194404e-02f, -3.15980799e-02f, -6.59577772e-02f, -5.52222840e-02f, 4.07958366e-02f, -8.26368295e-03f, 6.31291121e-02f, 1.19499518e-02f, -1.41352251e-01f,
  -2.52598966e-03f, -9.96296480e-02f, -1.37699954e-02f, -1.53768379e-02f, 8.45636148e-03f, -1.79639505e-03f, -1.65965538e-02f, 5.93543686e-02f, -4.71874401e-02f, -1.62364066e-01f,
  1.25739962e-01f, 2.12796070e-02f, -3.37869488e-02f, 3.63371484e-02f, -4.14518490e-02f, 1.25518013e-02f, 1.18335865e-01f, -8.99749324e-02f, -1.44725338e-01f, -9.51834116e-03f,
  3.24730761e-02f, 6.27441183e-02f, 2.44274661e-02f, 1.04377039e-01f, -8.96582380e-03f, 5.60437627e-02f, -1.00293063e-01f, -5.59349544e-02f, 5.17156580e-03f, 4.90817875e-02f,
  8.61897916e-02f, -1.02619357e-01f, 5.86118214e-02f, 1.05228528e-01f, 1.83387231e-02f, 4.23090011e-02f, 2.15737641e-01f, 1.54174389e-02f, 1.43833607e-01f, -9.47125331e-02f,
  3.23917091e-01f, 2.30106324e-01f, 1.43559843e-01f, 1.97428524e-01f, 2.40362570e-01f, 1.15906142e-01f, 1.54030517e-01f, -7.11528659e-02f, -7.70600736e-02f, 1.63869765e-02f,
  5.58024719e-02f, -4.73305434e-02f, -2.08131805e-01f, -1.66542590e-01f, -1.46219224e-01f, 8.18270538e-03f, -4.97936867e-02f, 5.84070459e-02f, 1.22172058e-01f, 1.22171476e-01f,
  3.85812484e-02f, 1.30107075e-01f, 2.93644756e-01f, 6.19305111e-02f, 1.40415683e-01f, -5.62108995e-04f, 1.27216280e-02f, 2.02867866e-01f, 1.01067565e-01f, -7.56572606e-03f,
  3.27246003e-02f, 2.36782596e-01f, -2.10028559e-01f, -4.31649163e-02f, 1.80136159e-01f, 6.22261055e-02f, 4.99092825e-02f, 7.77274594e-02f, 5.88359796e-02f, -1.05132565e-01f,
  -8.57281461e-02f, -8.48193187e-03f, 9.55897793e-02f, 1.62351474e-01f, 9.34646577e-02f, 5.87379299e-02f, -4.04876750e-03f, -7.89181739e-02f, -2.77183503e-02f, -7.02550113e-02f,
  4.18848246e-02f, 1.73175141e-01f, 8.94153491e-03f, -8.98616388e-02f, -7.80723020e-02f, 6.10320382e-02f, -2.52870712e-02f, -2.92032026e-02f, 5.76241836e-02f, 5.09972274e-02f,
  -3.28290276e-02f, 6.72983676e-02f, 1.18012674e-01f, 6.99683418e-03f, 1.37388915e-01f, 1.39422342e-01f, 1.12003740e-02f, 9.52796116e-02f, 1.72904313e-01f, 1.66140929e-01f,
  6.47813156e-02f, 1.45142883e-01f, 1.97504878e-01f, 1.03735059e-01f, 1.53132796e-01f, 2.02037513e-01f, 1.61739364e-01f, 7.58413076e-02f, 1.90697536e-01f, 1.67901620e-01f,
  6.74236566e-02f, 9.51895937e-02f, 5.41013330e-02f, 2.34399382e-02f, 1.11365430e-01f, 3.30535211e-02f, 1.30481511e-01f, 1.15480289e-01f, 1.58465534e-01f, 9.84750539e-02f,
  -1.02548160e-01f, 1.98670477e-02f, -5.26496060e-02f, -1.11455858e-01f, 7.94877112e-02f, 9.53361765e-03f, 7.16034919e-02f, -6.91245496e-02f, 5.83593436e-02f, -9.17995423e-02f,
  -3.07437144e-02f, 5.69036528e-02f, -1.63438171e-03f, 1.15178809e-01f, 1.65760377e-03f, 6.65166900e-02f, -1.44924130e-02f, 3.72255743e-02f, -3.51916663e-02f, -1.07027151e-01f,
  -3.99058126e-02f, -7.99010620e-02f, 3.70500050e-02f, -1.07313320e-01f, 4.19329517e-02f, 2.43261922e-02f, 3.78353186e-02f, -4.30204980e-02f, 2.04942492e-03f, 7.85357952e-02f,
  -5.72632253e-01f, -2.15866774e-01f, 2.05456898e-01f, -2.56776631e-01f, -5.53315915e-02f, -1.88409574e-02f, -1.81950748e-01f, -5.12355531e-04f, -2.00830117e-01f, -2.46838897e-01f,
  4.09145728e-02f, 1.32035524e-01f, 1.58064999e-02f, 1.96085751e-01f, 5.53740487e-02f, -3.38539541e-01f, -1.55327424e-01f, -3.72001156e-02f, 2.59707570e-01f, 2.65958726e-01f,
  -9.91532207e-02f, -2.11809069e-01f, -1.42360479e-01f, -5.12798466e-02f, -2.03061461e-01f, 5.40724881e-02f, -2.42759243e-01f, -1.04900017e-01f, -7.33200833e-02f, -3.76472265e-01f,
  6.79069292e-03f, 9.28243473e-02f, 1.69465765e-01f, 4.51504774e-02f, -9.30473059e-02f, 1.01545319e-01f, -6.09782431e-03f, -1.16258092e-01f, -8.85012373e-03f, -4.02349085e-02f,
  4.33963202e-02f, 1.59757566e-02f, -2.73482837e-02f, 7.57972151e-02f, 1.08370287e-02f, 1.16527854e-02f, -4.48156847e-04f, -1.86067075e-02f, -5.11438362e-02f, 8.80973712e-02f,
  -5.47408760e-02f, -1.70235932e-01f, 5.47254570e-02f, 5.78774177e-02f, 1.23599797e-01f, 4.76272665e-02f, 9.35295783e-03f, 1.61798432e-01f, 1.35476366e-01f, -2.65742391e-01f,
  -1.05697019e-02f, 5.60436398e-02f, 1.46323815e-01f, 3.09420452e-02f, -1.20030381e-02f, -8.26331079e-02f, -2.13074628e-02f, 3.64059210e-02f, 4.48695868e-02f, 1.53746316e-02f,
  1.62499063e-02f, -3.98208201e-02f, -3.61711979e-02f, -6.22042865e-02f, -2.61254832e-02f, -1.76275149e-01f, -1.49509877e-01f, -2.94285417e-02f, -6.49419650e-02f, -8.30356404e-02f,
  -2.27138661e-02f, -2.43609734e-02f, -1.26562029e-01f, 2.36992911e-02f, 4.73169722e-02f, -8.03612471e-02f, 8.00292790e-02f, 2.96495613e-02f, -1.21123120e-02f, 1.70574430e-02f,
  -2.18284167e-02f, 1.19810469e-01f, -1.44215196e-01f, 7.48755708e-02f, -4.09283154e-02f, -9.59311053e-02f, -5.09863719e-02f, -1.39796361e-02f, 4.96081542e-03f, 8.57475773e-02f,
  2.49516517e-02f, 6.80010766e-02f, -8.81711170e-02f, 2.34872606e-02f, 1.13315791e-01f, 3.63987200e-02f, -1.75282247e-02f, -1.12619765e-01f, -5.61915115e-02f, 7.87774008e-03f,
  -1.24785013e-01f, -1.29916236e-01f, -1.50934562e-01f, 1.16955210e-02f, -5.48698977e-02f, 4.67976481e-02f, -1.16621153e-02f, 3.31627242e-02f, 1.30394269e-02f, -2.05473006e-01f,
  2.95925856e-01f, 2.31115401e-01f, 1.47153810e-01f, 6.82266057e-02f, -2.48360902e-01f, -2.39359587e-01f, -2.75084019e-01f, -9.31964368e-02f, 1.11650266e-01f, 9.98761132e-02f,
  2.35314872e-02f, 1.22798197e-01f, 3.62226851e-02f, 4.29134779e-02f, 1.80117667e-01f, 1.74543727e-02f, -9.89965051e-02f, 1.88420728e-01f, -3.06775197e-02f, -1.49097353e-01f,
  -1.49873227e-01f, 6.36927187e-02f, 1.24306239e-01f, 7.48807937e-02f, 4.80650254e-02f, -1.12782024e-01f, 1.34240240e-02f, -1.17093287e-01f, -4.47980687e-02f, 2.20738322e-01f,
  3.26504111e-01f, 1.57357708e-01f, 1.78527579e-01f, 4.66159172e-02f, 6.41165376e-02f, 1.07427329e-01f, 8.42633098e-02f, 1.42094404e-01f, 8.86872709e-02f, 8.23465511e-02f,
  -3.68732587e-02f, 7.66381770e-02f, -1.38927102e-01f, -8.66030157e-02f, -6.27510101e-02f, -4.94677015e-02f, 6.22984506e-02f, 5.40551953e-02f, 6.49062619e-02f, -4.47270740e-03f,
  6.08495548e-02f, -9.82714742e-02f, -6.34280890e-02f, -6.11210279e-02f, -2.84132045e-02f, 9.40044131e-03f, -5.92655614e-02f, 2.78286170e-02f, 1.02141693e-01f, 1.27258986e-01f,
  -1.01769105e-01f, -6.44532144e-02f, 1.10831752e-01f, 5.71688935e-02f, -1.45504057e-01f, -1.72157842e-03f, 1.87500436e-02f, -2.97441650e-02f, -1.49200544e-01f, -5.48712946e-02f,
  -1.97092760e-02f, -1.91812553e-02f, -3.09902281e-02f, -5.03450930e-02f, 8.13888907e-02f, 1.39749544e-02f, -3.24647804e-03f, 5.78946657e-02f, 6.39098883e-02f, 7.06579164e-03f,
  -8.80422816e-02f, -7.93648418e-03f, 2.26221886e-02f, -7.62363300e-02f, 1.46737006e-02f, 2.60484405e-02f, -9.68476851e-03f, -1.60765555e-02f, -1.87447742e-01f, -1.28159383e-02f,
  1.55118242e-01f, -3.98413055e-02f, 1.45573437e-01f, 7.85713345e-02f, 1.38879135e-01f, 6.18054271e-02f, 1.33718833e-01f, 1.51000693e-01f, 6.82000741e-02f, 2.20503718e-01f,
  5.48285171e-02f, -1.64164905e-03f, -2.30641533e-02f, -2.43956279e-02f, -1.09831735e-01f, -2.32190173e-02f, 6.91292733e-02f, 1.34039834e-01f, 1.76450044e-01f, 2.05423743e-01f,
  7.78316706e-02f, -1.05224298e-02f, 4.34440896e-02f, 8.20524618e-02f, 3.64250802e-02f, -7.05906972e-02f, 4.08660583e-02f, 3.34646367e-02f, -6.89107031e-02f, -3.54515277e-02f,
  2.99722999e-01f, 5.20269126e-02f, 8.93826559e-02f, 1.92800432e-01f, 5.06458431e-02f, 2.10421942e-02f, 1.24482699e-01f, 9.69841406e-02f, 1.88313857e-01f, 6.51753172e-02f,
  1.01588450e-01f, 2.92618185e-01f, 2.85930872e-01f, 1.89301401e-01f, 9.64551046e-02f, -2.36673150e-02f, 9.43154991e-02f, 2.55997721e-02f, 6.78636134e-02f, 1.93627253e-02f,
  1.85893569e-02f, -1.51763363e-02f, 2.85432115e-02f, 6.37951493e-02f, -1.24526717e-01f, 8.57153684e-02f, -9.57729593e-02f, -3.04454193e-02f, 3.16491015e-02f, -5.60410097e-02f,
  -4.61960286e-02f, 4.75458205e-02f, 3.16004269e-02f, -1.18209347e-02f, -1.44476950e-01f, -1.66580483e-01f, -7.59354830e-02f, 5.84728504e-03f, -1.47826541e-02f, -1.49070576e-01f,
  -4.13159132e-02f, -8.19858760e-02f, -7.75082782e-03f, -1.45313859e-01f, -5.46682291e-02f, -7.21411034e-02f, -1.09550267e-01f, 1.29339239e-02f, 6.89875484e-02f, -3.86189036e-02f,
  4.92422795e-03f, 2.39401236e-02f, 1.91348810e-02f, 6.71134740e-02f, 2.63365661e-03f, 1.97212491e-03f, 6.08722940e-02f, -1.20185036e-03f, -2.70159859e-02f, 1.63877159e-02f,
  1.94318876e-01f, 1.67159721e-01f, 7.60725513e-02f, 9.20008421e-02f, -3.41988690e-02f, 6.59945533e-02f, -3.16878930e-02f, 2.19329726e-02f, 6.56483844e-02f, -9.61891189e-02f,
  9.18949395e-03f, 9.59851369e-02f, 1.78141207e-01f, 1.13919519e-01f, 5.84461652e-02f, 1.47881031e-01f, -1.09574087e-01f, -4.09182049e-02f, -4.92757484e-02f, -2.09582746e-02f,
  9.48659703e-02f, -1.01828605e-01f, -1.27515018e-01f, -1.61559388e-01f, -3.16908881e-02f, -4.65825200e-02f, -6.68403925e-03f, 5.70049174e-02f, -1.11507408e-01f, 3.09328618e-03f,
  3.74714732e-02f, 3.69189054e-01f, 8.95187631e-02f, 9.97814760e-02f, -6.15911819e-02f, -2.03546613e-01f, 1.02930479e-01f, -1.23408906e-01f, -1.18126541e-01f, -8.57008174e-02f,
  -9.96773224e-03f, -1.04288295e-01f, -4.52985475e-03f, -1.15227103e-01f, 2.15440672e-02f, -1.04245350e-01f, 2.59055942e-03f, 3.93503532e-02f, 1.54930234e-01f, -2.34172922e-02f,
  4.66772839e-02f, 1.45527452e-01f, 1.36105821e-01f, 1.84777737e-01f, -1.87573079e-02f, 9.51141790e-02f, 7.22174048e-02f, 6.17888942e-02f, 1.01956278e-01f, -5.68195991e-02f,
  -9.52137187e-02f, -1.15657188e-01f, -2.20747232e-01f, 1.66506976e-01f, 2.92310774e-01f, -8.98167342e-02f, -3.99884343e-01f, -2.80389227e-02f, 3.35546046e-01f, 3.76261771e-02f,
  2.61515200e-01f, 2.20949650e-01f, 3.76830399e-02f, -9.29787830e-02f, -4.72029507e-01f, -3.45688462e-01f, -4.11555797e-01f, -3.38269055e-01f, -1.72736391e-01f, 1.42828763e-01f,
  2.69957781e-01f, 5.84396236e-02f, -1.89363047e-01f, -4.55043651e-02f, 1.46595210e-01f, -1.24950670e-02f, -1.76170737e-01f, -2.32626637e-03f, -1.44782618e-01f, -8.19043145e-02f,
  -2.71444470e-02f, 2.88418774e-03f, 1.01526700e-01f, -4.17117141e-02f, 5.88807091e-02f, 4.94323187e-02f, 1.27696125e-02f, 6.07181899e-02f, 1.36408299e-01f, 5.72706722e-02f,
  1.24039859e-01f, 8.05688426e-02f, 1.22379482e-01f, 9.24041420e-02f, 5.79466000e-02f, -5.16637675e-02f, 6.97831111e-03f, -8.30152556e-02f, -2.45502234e-01f, -7.32158450e-03f,
  1.05283715e-01f, 1.01206002e-04f, -1.21569365e-01f, -2.03786477e-01f, -1.02503754e-01f, -7.97293559e-02f, 1.75471827e-02f, -1.21096624e-02f, -2.29414374e-01f, -2.01481000e-01f,
  2.84281988e-02f, 2.56075282e-02f, 1.28135860e-01f, -7.75272399e-03f, 5.63580953e-02f, 2.88634058e-02f, -1.95318125e-02f, -1.31576270e-01f, 4.18038759e-03f, -5.76197319e-02f,
  7.84083549e-03f, -2.21911054e-02f, -1.31150186e-01f, -1.83462709e-01f, -9.91063565e-02f, -8.69911443e-03f, -6.67081028e-02f, -2.57239133e-01f, -2.94942200e-01f, -3.43351886e-02f,
  -9.60068330e-02f, -2.55309474e-02f, 1.84554547e-01f, -3.39812636e-02f, -1.55027404e-01f, -7.04694390e-02f, 3.95720303e-02f, 8.11589658e-02f, 7.14714602e-02f, 4.93200421e-02f,
  8.06842297e-02f, -1.86001524e-01f, -9.27608386e-02f, -8.96195248e-02f, -7.50312358e-02f, 2.81954613e-02f, -8.57605487e-02f, -1.73740592e-02f, 5.58345616e-02f, -6.89778626e-02f,
  8.87036882e-03f, -1.26034021e-01f, 4.00701128e-02f, 2.97245756e-02f, 6.60996214e-02f, 8.91070440e-02f, -1.67650461e-01f, -1.52772978e-01f, -2.64590591e-01f, 1.89371184e-01f,
  -5.14639132e-02f, -3.38661015e-01f, -2.65180230e-01f, -2.63011694e-01f, -3.11750937e-02f, -1.69455439e-01f, -1.26948729e-01f, -3.51382582e-03f, -1.73385128e-01f, -3.15212816e-01f,
  1.36297956e-01f, -1.60632059e-01f, 9.73035991e-02f, 1.96304590e-01f, -3.00810803e-02f, 6.99038878e-02f, -8.66893679e-02f, -6.09587282e-02f, 1.09159395e-01f, 6.94778413e-02f,
  6.14501610e-02f, 1.50478423e-01f, 1.56719953e-01f, 2.26502955e-01f, 9.62191224e-02f, 1.69633403e-01f, 2.28745162e-01f, 2.60277718e-01f, 1.86549723e-01f, 4.42111716e-02f,
  1.66792467e-01f, 3.65287028e-02f, 2.81367898e-02f, 1.83838934e-01f, 1.87393859e-01f, 1.61736771e-01f, 2.61904728e-02f, 4.92922589e-02f, 1.19370066e-01f, 1.71076953e-01f,
  3.81497853e-02f, -4.16040048e-02f, 2.02948347e-01f, -7.37808198e-02f, -1.30975368e-02f, -7.64425546e-02f, -1.00828953e-01f, -1.32861197e-01f, -8.61283988e-02f, -2.24144924e-02f,
  -1.19157374e-01f, 5.78600587e-03f, 5.87265007e-03f, -8.44251588e-02f, -1.69248891e-03f, -7.13939965e-02f, 3.77712250e-02f, 3.92576419e-02f, 7.07301274e-02f, -3.22650536e-03f,
  7.47913942e-02f, -1.37750119e-01f, -1.16032831e-01f, -1.51561676e-02f, 1.18198924e-01f, 8.10127780e-02f, -6.57186955e-02f, 1.02066420e-01f, -3.48038375e-02f, 3.10144126e-02f,
  2.32506245e-01f, 2.83090994e-02f, 1.66618247e-02f, 6.54774979e-02f, 1.13958627e-01f, -2.07493920e-02f, 1.05146624e-01f, -7.52923116e-02f, 2.72584669e-02f, -1.33487999e-01f,
  3.74184898e-03f, 1.18514821e-01f, 2.72112451e-02f, 5.43430969e-02f, 6.54667020e-02f, 1.77794360e-02f, -5.63526005e-02f, -4.15271185e-02f, -3.64917032e-02f, -3.42433974e-02f,
  1.46224098e-02f, -1.01518564e-01f, -1.53095564e-02f, 4.68946397e-02f, 5.41632771e-02f, 3.94794866e-02f, -4.93453965e-02f, -8.12629536e-02f, -4.34211455e-02f, -7.91578069e-02f,
  -2.80824333e-01f, 8.23013708e-02f, 1.11477204e-01f, 4.76795360e-02f, -1.72077883e-02f, -1.18420899e-01f, 1.28617704e-01f, -6.46029338e-02f, -1.33345962e-01f, -7.02509061e-02f,
  -2.35457923e-02f, -2.78111603e-02f, -6.93804398e-02f, -1.08184226e-01f, -1.21435143e-01f, -6.68808073e-02f, 1.35180540e-02f, 8.19284543e-02f, -1.84730738e-02f, -1.01369806e-01f,
  -1.27972290e-01f, -1.27519488e-01f, -5.00285253e-02f, -2.81616058e-02f, 4.36839201e-02f, 2.15160605e-02f, -4.44303378e-02f, -1.09230153e-01f, -1.17264733e-01f, -1.73133582e-01f,
  2.36571953e-01f, 2.32382104e-01f, 1.31826140e-02f, -1.74955249e-01f, -6.14011660e-03f, 2.31994405e-01f, 3.35591435e-01f, 2.31257439e-01f, -1.42054081e-01f, 3.16433283e-03f,
  4.28067267e-01f, 6.16210029e-02f, -8.20699707e-02f, -1.34967521e-01f, 1.37752637e-01f, 5.41953035e-02f, -2.00746134e-01f, -1.20440975e-01f, -5.26500586e-03f, 1.93796605e-01f,
  -5.40964752e-02f, -3.47813545e-03f, 3.58233862e-02f, 3.31019312e-02f, -3.76869708e-01f, -3.37230891e-01f, -2.15128526e-01f, 6.58741733e-03f, 4.62769084e-02f, -5.06407261e-01f,
  1.30940333e-01f, 3.82655948e-01f, -1.80618003e-01f, -1.66208044e-01f, -1.02611326e-01f, -2.42712125e-02f, -5.34555279e-02f, -1.83564976e-01f, -1.04393654e-01f, -1.63753275e-02f,
  -1.10129699e-01f, 5.26878908e-02f, 9.04835528e-04f, 3.96735929e-02f, 1.66623387e-02f, 2.30178870e-02f, 9.74076018e-02f, 1.05399907e-01f, 4.60067764e-02f, 4.22386937e-02f,
  -1.34376630e-01f, 1.14547610e-01f, 2.27544695e-01f, 4.54890542e-02f, 3.08068823e-02f, -1.78228155e-01f, 1.11337662e-01f, 8.86897147e-02f, 1.43118173e-01f, -3.18516523e-01f,
  6.68630423e-03f, -5.47644533e-02f, 9.01993960e-02f, -3.48159745e-02f, 1.21456748e-02f, 4.05577291e-03f, -1.25843212e-01f, -1.04437359e-01f, -8.54830630e-03f, -9.73801017e-02f,
  2.94550657e-02f, 1.03182271e-01f, 1.32813230e-01f, 2.22288612e-02f, -1.55404344e-01f, -5.84466942e-03f, 1.00901224e-01f, 5.57143986e-02f, 6.92729875e-02f, -1.02517130e-02f,
  -2.58187074e-02f, 4.28585336e-02f, 1.69521291e-02f, 7.44006187e-02f, -1.85001474e-02f, 2.66745966e-02f, 4.07320308e-03f, -2.43660919e-02f, -4.09604460e-02f, 1.44760236e-01f,
  -1.69919193e-01f, 2.33079433e-01f, -2.07948953e-01f, 9.28073078e-02f, 4.22398187e-02f, 3.87491323e-02f, -1.85346194e-02f, 8.72936845e-02f, -8.27277638e-03f, 9.16196108e-02f,
  2.30919436e-01f, 3.94208878e-02f, 1.40221432e-01f, -1.43169574e-02f, 2.99992692e-02f, -1.02799699e-01f, 3.18675488e-02f, 7.44389296e-02f, -1.53818978e-02f, -4.46159653e-02f,
  -1.78520918e-01f, 3.86529528e-02f, -2.44560242e-02f, -1.45689532e-01f, -2.12789163e-01f, -2.35483512e-01f, -1.49602100e-01f, -7.43073747e-02f, 1.12769268e-02f, -3.33852142e-01f,
  -7.12735295e-01f, -1.38887674e-01f, -4.85352390e-02f, -6.19543493e-01f, -9.29525420e-02f, 1.49349272e-01f, -2.44752299e-02f, 5.94842210e-02f, -2.31556222e-01f, -3.47017050e-01f,
  -1.28097892e-01f, -6.52454123e-02f, -1.60458773e-01f, 1.33528545e-01f, 1.71449006e-01f, -2.12372899e-01f, -1.37522295e-01f, 8.98126736e-02f, 3.39887381e-01f, 3.58827949e-01f,
  7.51868561e-02f, -1.26883745e-01f, 4.56621610e-02f, 1.92627445e-01f, -1.03330456e-01f, 6.57439306e-02f, -5.99805042e-02f, -5.25700003e-02f, 1.26099035e-01f, -2.53062636e-01f,
  -2.64475971e-01f, -1.98299721e-01f, 1.27643630e-01f, -4.82272878e-02f, -9.20732915e-02f, -1.53662860e-01f, -1.42015353e-01f, -5.79230972e-02f, -3.07084713e-02f, -4.40943465e-02f,
  -7.64573738e-02f, 2.25572139e-02f, -2.18649819e-01f, -2.12854240e-02f, -8.54600519e-02f, -7.90811256e-02f, 1.02766469e-01f, 1.63963854e-01f, 1.62681773e-01f, 5.14072254e-02f,
  1.20557375e-01f, 9.13358554e-02f, -7.35656768e-02f, 1.58983395e-01f, 1.50201485e-01f, 5.65178953e-02f, 1.72153771e-01f, 2.20161483e-01f, 2.63301790e-01f, -8.17396119e-02f,
  1.29013091e-01f, -3.36175598e-02f, 1.34680122e-02f, -5.66508435e-02f, 3.30321379e-02f, -5.31014986e-02f, -5.20230755e-02f, -5.72680458e-02f, 4.26625051e-02f, 4.56388993e-03f,
  2.68519204e-02f, -2.93148011e-02f, 1.03221864e-01f, -4.62012514e-02f, 2.50859633e-02f, -3.51555608e-02f, 4.31026444e-02f, 1.01050340e-01f, 2.44237222e-02f, -1.03263088e-01f,
  8.91513154e-02f, -2.71409098e-02f, -8.60541612e-02f, 1.13291264e-01f, 6.93135262e-02f, -7.15803588e-03f, -7.39487559e-02f, 7.80252069e-02f, -7.10571855e-02f, -2.23840866e-02f,
  -2.87461340e-01f, 1.73763797e-01f, -3.02594095e-01f, -6.18627891e-02f, -4.80170622e-02f, 7.28899986e-02f, 2.46313438e-02f, 3.70713919e-02f, -1.58781797e-01f, -9.67917517e-02f,
  9.04576555e-02f, -1.74013693e-02f, -1.73546374e-01f, 4.46774028e-02f, -1.34361997e-01f, 6.15461580e-02f, -8.90189335e-02f, -1.42647579e-01f, 1.43307254e-01f, -2.91467179e-02f,
  1.28884017e-01f, 3.68218683e-02f, -2.33405620e-01f, -7.90748745e-03f, 3.96491401e-02f, -7.28119016e-02f, -1.73311140e-02f, 1.33914381e-01f, 2.06661209e-01f, -2.32467026e-01f,
  -4.87175852e-01f, 2.20328961e-02f, -8.67707655e-02f, -1.85890734e-01f, 4.08882946e-01f, 2.42315173e-01f, 1.42141655e-01f, -1.91746764e-02f, 1.37050180e-02f, 4.49082814e-02f,
  3.83908659e-01f, 1.62994802e-01f, -1.23884371e-02f, 1.57112643e-01f, -1.28911361e-01f, 1.50457636e-01f, 8.79471973e-02f, -8.41547027e-02f, -9.29561630e-02f, 1.87636286e-01f,
  2.87559927e-01f, -8.17758739e-02f, -2.15150848e-01f, -1.28035963e-01f, -1.33262888e-01f, -1.03970282e-01f, -1.13416739e-01f, -7.36346394e-02f, 8.72700810e-02f, -6.81184754e-02f,
  -1.07072532e-01f, -1.29700303e-01f, 7.73351416e-02f, 4.79482450e-02f, -2.43812930e-02f, -3.04384559e-01f, -1.13541365e-01f, -1.63676217e-01f, 6.11220673e-02f, -1.30514100e-01f,
  -8.47623870e-03f, 1.30512137e-02f, 2.49305852e-02f, 2.33421475e-02f, -3.45349498e-02f, -5.72897308e-02f, -4.08410169e-02f, -1.44827157e-01f, -2.85349727e-01f, -2.12452799e-01f,
  3.05534542e-01f, 3.62952590e-01f, -2.10398376e-01f, -4.98316139e-02f, -2.17056513e-01f, -9.83001217e-02f, -1.71212420e-01f, -3.04463685e-01f, -2.79598773e-01f, -3.89613032e-01f,
  -2.85984892e-02f, 6.25807643e-02f, -6.28696010e-02f, -7.21900463e-02f, -6.35298863e-02f, 7.94374049e-02f, 4.71786708e-02f, 1.29724205e-01f, 2.35105306e-02f, -7.44639039e-02f,
  -4.63447236e-02f, 3.74332480e-02f, -6.24157228e-02f, 1.65775102e-02f, -7.59923011e-02f, 4.85190973e-02f, 6.01206496e-02f, -1.06542528e-01f, -9.38287601e-02f, -6.89040720e-02f,
  -6.74541816e-02f, -8.09992701e-02f, 2.29776427e-02f, -3.62212993e-02f, 9.06662717e-02f, -2.28093145e-03f, 4.36576270e-03f, -6.86489372e-03f, -5.06602861e-02f, -4.84606735e-02f,
  -2.46011421e-01f, 6.56682104e-02f, -2.22965777e-01f, 9.55383107e-02f, 9.52697620e-02f, 1.66307036e-02f, -3.25584859e-02f, 4.48066257e-02f, 4.46643680e-02f, -5.26139475e-02f,
  -7.38020688e-02f, -7.93117732e-02f, -5.13645075e-02f, -3.00905649e-02f, 8.04289151e-03f, -7.89926648e-02f, -1.57002788e-02f, 1.74651012e-01f, -3.38868536e-02f, -3.29951174e-03f,
  -1.52876079e-01f, -1.62756160e-01f, -2.01207772e-01f, -1.85466349e-01f, -1.64885864e-01f, -1.08651735e-01f, -2.68580139e-01f, -2.49639526e-01f, -2.15146825e-01f, -3.91974330e-01f,
  5.86280167e-01f, 1.46694645e-01f, 2.50037909e-01f, 6.41998574e-02f, -7.27194622e-02f, 1.27826601e-01f, 2.04478621e-01f, 1.51059166e-01f, 8.41462836e-02f, 6.64937943e-02f,
  -4.95866649e-02f, -8.23568031e-02f, 4.85765934e-02f, -3.62523645e-02f, 1.42934367e-01f, 1.39949858e-01f, -2.33905651e-02f, 1.74142450e-01f, 1.80842429e-01f, 6.54589683e-02f,
  -3.98296230e-02f, 4.65133898e-02f, 5.19236177e-02f, 6.45805150e-02f, -1.02523223e-01f, 2.06130669e-02f, 7.31221214e-02f, -9.03018117e-02f, -4.59023565e-02f, 2.77600121e-02f,
  -1.96866781e-01f, 9.59108099e-02f, -1.07269056e-01f, -1.20241299e-01f, -7.29049817e-02f, 2.60796733e-02f, 8.57597739e-02f, -8.49135220e-02f, -2.62334142e-02f, -3.69802117e-02f,
  -2.27977503e-02f, -6.82755262e-02f, -5.33809140e-02f, 3.89338881e-02f, 1.51317017e-02f, 2.65463088e-02f, 1.98696856e-03f, 1.84105277e-01f, 1.36235982e-01f, -6.67894259e-02f,
  1.28854932e-02f, 5.83398342e-02f, -3.09185330e-02f, 7.84273744e-02f, 1.08936988e-01f, -2.19512135e-02f, 8.09757411e-02f, 9.77748632e-02f, 1.10019386e-01f, 7.17186406e-02f,
  5.58678806e-02f, 1.28972009e-01f, -2.67336257e-02f, -5.26638664e-02f, 1.90144603e-03f, -1.30072355e-01f, -1.34000136e-02f, 2.15747524e-02f, 1.53025702e-01f, 2.58676521e-02f,
  1.14638042e-02f, 7.56668150e-02f, 5.64080179e-02f, -7.14242831e-02f, -2.36500762e-02f, -4.68410514e-02f, 4.56473045e-02f, -1.41110480e-01f, -1.15280479e-01f, -7.94264749e-02f,
  -7.46449605e-02f, -7.77222542e-03f, -1.05273396e-01f, -6.31607994e-02f, 2.38047466e-02f, -5.27021252e-02f, -3.09994873e-02f, -7.45015144e-02f, 5.70195727e-02f, -7.03789070e-02f,
  -2.65419096e-01f, -1.35703683e-01f, -6.85722083e-02f, -7.17476308e-02f, 6.90672025e-02f, -8.29041228e-02f, 6.10970147e-02f, -5.55774868e-02f, -2.26437941e-01f, -2.76235398e-02f,
  2.54174732e-02f, -4.31515463e-02f, -1.13131002e-01f, 3.01544964e-02f, -1.18666710e-02f, -6.69874763e-03f, -5.66893555e-02f, 1.88233908e-02f, -1.50776897e-02f, -1.42653391e-01f,
  -8.71599242e-02f, 6.10403195e-02f, 1.30891027e-02f, 9.67654958e-02f, 5.04777022e-02f, -3.51116695e-02f, 1.49168456e-02f, -6.51804060e-02f, -4.31895517e-02f, 6.75493628e-02f,
  2.44016573e-01f, -3.73196423e-01f, -3.65155995e-01f, -1.68533236e-01f, -2.67285675e-01f, -1.37917832e-01f, -4.73567069e-01f, 4.40934151e-02f, 5.73764443e-02f, -4.11155939e-01f,
  -1.86489969e-01f, 2.33858198e-01f, -2.78564673e-02f, -3.15482877e-02f, 6.59425929e-02f, -4.56517488e-01f, -4.44486558e-01f, 2.63200477e-02f, 3.71824235e-01f, 7.86363706e-02f,
  -1.11512505e-01f, -4.79438938e-02f, 2.07350180e-01f, 3.33538540e-02f, -2.41363704e-01f, 1.27207600e-02f, -3.00802052e-01f, -9.54960659e-02f, -2.42281437e-01f, -4.23460782e-01f,
  -2.56919175e-01f, 6.15357161e-02f, 4.35950533e-02f, 1.71365499e-01f, -9.47372913e-02f, 1.36650443e-01f, -4.56668697e-02f, -1.66120395e-01f, 7.97327384e-02f, -9.38573331e-02f,
  2.17023730e-01f, 8.48086327e-02f, 1.88891202e-01f, -5.83221612e-04f, -6.53172433e-02f, 1.55410627e-02f, -1.82476137e-02f, -8.05209670e-03f, 2.48490907e-02f, -8.13727677e-02f,
  -3.85861993e-02f, 1.23340460e-02f, 1.12428129e-01f, -1.38650835e-01f, 8.57293829e-02f, 9.81796831e-02f, -5.68257421e-02f, 1.89233407e-01f, 8.29828903e-02f, -3.90562862e-01f,
  -1.23233698e-01f, -4.09671739e-02f, -3.46189714e-03f, -1.50485826e-03f, 1.26585543e-01f, -1.82471480e-02f, 1.32129759e-01f, 3.85840312e-02f, 4.90661077e-02f, 8.17222074e-02f,
  -5.73885888e-02f, -1.10516675e-01f, 2.09519733e-02f, 1.08396364e-02f, -6.49410635e-02f, 1.30557552e-01f, 2.40653241e-03f, -1.08502910e-01f, 3.51453051e-02f, -4.49404120e-02f,
  -7.30939733e-04f, 9.20697227e-02f, -6.47384524e-02f, -4.86934595e-02f, -1.60446629e-01f, -1.23500191e-01f, 3.36499773e-02f, -9.27970454e-04f, -4.69410680e-02f, 6.41890168e-02f,
  3.72983366e-02f, -1.01403743e-02f, -1.59746736e-01f, 1.14449687e-01f, 2.63071130e-03f, -5.90695068e-02f, -1.10122256e-01f, 1.33498199e-02f, 5.71813211e-02f, -8.28604177e-02f,
  5.15812300e-02f, -9.21087638e-02f, -8.28593299e-02f, 5.29977754e-02f, -8.41703266e-02f, 1.30694225e-01f, -4.80863079e-02f, -2.30619553e-02f, 4.60092425e-02f, -1.01867966e-01f,
  -1.51935622e-01f, -4.84495088e-02f, 5.32061383e-02f, -4.13607247e-02f, 2.06521451e-01f, 7.49235079e-02f, -6.21982515e-02f, -5.71031608e-02f, 4.16763835e-02f, -2.93065488e-01f,
  2.09250003e-01f, 3.22402805e-01f, 1.50508419e-01f, 7.25369528e-02f, 1.15047358e-01f, 1.27604872e-01f, 3.19529325e-01f, 1.67180449e-01f, 5.73220849e-02f, 1.72952816e-01f,
  2.45276049e-01f, 1.13888487e-01f, -1.48234330e-02f, 8.46174136e-02f, 1.06386058e-01f, -4.84494679e-02f, -9.16908607e-02f, -8.24912786e-02f, -4.28005941e-02f, 4.52021929e-03f,
  -9.41259637e-02f, 1.03236854e-01f, 1.03423692e-01f, 1.45116523e-02f, -8.72029886e-02f, -1.50992677e-01f, -2.05483101e-02f, 8.35918039e-02f, -1.20336632e-03f, -3.03204507e-01f,
  2.12272882e-01f, 2.07344040e-01f, -1.11399248e-01f, 5.12775593e-03f, 9.29710940e-02f, -5.93560822e-02f, 4.62095439e-02f, 9.99013409e-02f, 1.30751491e-01f, 2.16528662e-02f,
  9.01907403e-03f, 6.78866357e-02f, 3.87733057e-02f, 7.58528039e-02f, 1.40902892e-01f, 3.73659283e-02f, -2.85443757e-02f, -5.27940802e-02f, -1.97717198e-03f, 9.89878178e-02f,
  -7.21946061e-02f, -3.11397761e-03f, 1.56327263e-01f, 6.17350489e-02f, -1.02439068e-01f, 1.27346748e-02f, 2.78173611e-02f, -6.74811974e-02f, -5.09549491e-02f, -7.09241778e-02f,
  -3.06997132e-02f, 6.16808943e-02f, -3.10778114e-06f, -8.69038105e-02f, -7.94773549e-03f, -7.00329095e-02f, -7.67629221e-02f, -7.87010789e-03f, 4.06291559e-02f, -1.23556510e-01f,
  2.56372243e-02f, 1.83907617e-02f, 1.01443134e-01f, 6.55892566e-02f, 7.79878646e-02f, 7.79381662e-04f, -3.64980400e-02f, 5.89559078e-02f, 1.01806223e-01f, 1.11312367e-01f,
  3.45798768e-02f, -1.42184928e-01f, 2.76343599e-02f, -7.13012591e-02f, 4.49870192e-02f, 2.37686671e-02f, -1.08177513e-01f, 5.20364717e-02f, -7.43749505e-03f, -3.05340234e-02f,
  -3.45490761e-02f, 2.87240651e-02f, -2.63425201e-01f, -6.83333501e-02f, -9.97184440e-02f, 7.65478685e-02f, -2.03002542e-02f, -7.63092330e-03f, 1.06246747e-01f, 1.46581710e-03f,
  9.45928469e-02f, -8.55399668e-02f, 2.25718208e-02f, -2.27696449e-03f, -8.31902325e-02f, 1.84957962e-03f, -1.82263665e-02f, -1.10542677e-01f, 2.84883585e-02f, 1.56742372e-02f,
  -2.52173375e-02f, -8.37209001e-02f, -7.99809322e-02f, -2.41326280e-02f, -1.80926040e-01f, -7.38767609e-02f, -2.35710014e-02f, -1.11407682e-01f, -9.73236095e-03f, -4.31360267e-02f,
  -2.30534837e-01f, 2.89959908e-02f, -4.98823494e-01f, -8.74054655e-02f, -1.36976346e-01f, -1.82961270e-01f, -1.01200171e-01f, 6.45800009e-02f, 1.03856646e-01f, -1.00265644e-01f,
  -5.88328801e-02f, -1.08218729e-01f, -8.41833502e-02f, -2.59122491e-01f, -3.06000531e-01f, -3.86339158e-01f, -4.37371612e-01f, -4.72381115e-01f, -4.63971496e-01f, -1.62716761e-01f,
  -2.63651758e-01f, -3.94223273e-01f, -2.72899806e-01f, -2.31948003e-01f, 4.18517590e-02f, -1.89225510e-01f, -1.56188607e-01f, -2.33183101e-01f, -1.43918589e-01f, -1.93291381e-01f,
  -1.58059299e-01f, 9.21927206e-03f, 6.32074401e-02f, -1.92798935e-02f, 3.79671296e-03f, 1.06736846e-01f, 2.57332399e-02f, 1.77512169e-01f, 7.44274855e-02f, 1.49351463e-01f,
  -3.37672532e-02f, 6.61361739e-02f, -5.43051474e-02f, 3.32795009e-02f, 4.73399833e-02f, -1.62538644e-02f, 1.13611713e-01f, 1.47148017e-02f, 1.69115052e-01f, 1.06848620e-01f,
  7.78263286e-02f, 6.07097037e-02f, 6.73657432e-02f, 2.34199032e-01f, 2.04397127e-01f, 4.44609113e-02f, 1.47957027e-01f, 2.34582216e-01f, 4.68207374e-02f, 2.82887638e-01f,
  -2.17546839e-02f, 2.16524690e-01f, 1.68486387e-02f, 5.56299090e-02f, 9.95794237e-02f, 6.31829947e-02f, -1.16668083e-02f, 4.00666371e-02f, -3.56981754e-02f, 1.04274310e-01f,
  1.14007391e-01f, -5.03469966e-02f, 8.17424655e-02f, -4.15865257e-02f, -1.06793150e-01f, -3.97194736e-02f, -4.67607826e-02f, 4.66787368e-02f, 1.24908043e-02f, 1.11024253e-01f,
  3.95433605e-02f, 1.27665609e-01f, -1.07960716e-01f, 4.94688787e-02f, -8.88531804e-02f, 2.89703943e-02f, 6.58489615e-02f, -4.26228121e-02f, -1.86366886e-02f, -6.83902670e-03f,
  2.00001553e-01f, -3.27569544e-01f, -1.67258680e-02f, 2.00416539e-02f, 8.80804881e-02f, 3.62342335e-02f, -4.49169055e-02f, 1.99523624e-02f, -2.26567453e-03f, 1.41497329e-02f,
  1.59778185e-02f, -1.20043300e-01f, -7.38110244e-02f, 1.91201389e-01f, -5.94556220e-02f, -1.35345414e-01f, -2.79319426e-03f, 7.09772110e-02f, 5.55550531e-02f, 1.42148808e-01f,
  1.08451741e-02f, 8.34087208e-02f, 1.60815001e-01f, 6.95706308e-02f, 8.67983997e-02f, -9.85618904e-02f, 4.30650227e-02f, 1.17464848e-01f, -1.16104722e-01f, 4.62603308e-02f,
  4.05755013e-01f, 3.18374395e-01f, 1.66440412e-01f, 7.98149779e-02f, 7.71741644e-02f, -8.65838528e-02f, 9.11339149e-02f, -1.67310447e-01f, -1.45996988e-01f, 1.59078464e-01f,
  1.68331340e-01f, -2.66187668e-01f, -7.44000450e-02f, -1.85790926e-01f, -2.39511788e-01f, 1.68394204e-02f, 1.03390299e-01f, -1.94904521e-01f, -5.09602129e-01f, -4.30080891e-01f,
  -1.77051812e-01f, -4.68628667e-02f, -7.05857426e-02f, -1.51494637e-01f, 1.13750346e-01f, -1.18005022e-01f, 2.53119648e-01f, 1.40800908e-01f, 1.79733410e-02f, 2.99968481e-01f,
  3.03037077e-01f, 2.46459946e-01f, -5.94167635e-02f, 9.84164178e-02f, 7.88169727e-02f, -4.53631245e-02f, -1.87570695e-02f, 5.47756478e-02f, 2.74972115e-02f, 7.60970414e-02f,
  1.54870793e-01f, -1.93619095e-02f, -8.22643191e-02f, -3.55381295e-02f, -8.13973770e-02f, -8.03029314e-02f, 1.04649058e-02f, -7.42891207e-02f, -3.22498120e-02f, -4.99145277e-02f,
  5.43527231e-02f, 6.91692233e-02f, 3.17477621e-02f, -1.12287730e-01f, -6.65442422e-02f, -4.37967815e-02f, 4.39561531e-02f, -3.31784179e-03f, -1.09722830e-01f, 3.58229987e-02f,
  -2.04494707e-02f, 1.36360034e-01f, -2.66312901e-02f, 8.85882154e-02f, 9.14431810e-02f, 1.31141528e-01f, 8.21563900e-02f, 1.08217094e-02f, -3.53009477e-02f, 4.53289924e-03f,
  -1.60966571e-02f, -9.47907269e-02f, -4.29231040e-02f, 7.85760134e-02f, 4.82766964e-02f, 3.82399224e-02f, -3.04211751e-02f, -9.78585333e-02f, -7.25028515e-02f, 1.56299509e-02f,
  -1.41502917e-01f, -7.49326199e-02f, -6.48911595e-02f, -1.12784952e-01f, 3.05878855e-02f, 3.80490832e-02f, 1.36233252e-02f, -2.87509169e-02f, -9.27868932e-02f, 3.57687175e-02f,
  -1.54968202e-01f, -2.58771069e-02f, 6.48196563e-02f, -9.28865224e-02f, 7.83470497e-02f, 1.38628006e-01f, 1.14884544e-02f, -4.57631759e-02f, -9.30085406e-03f, -1.83207188e-02f,
  -3.88837382e-02f, 1.67122763e-02f, -2.30435524e-02f, -4.33043279e-02f, -1.07932352e-01f, -2.92365123e-02f, 1.16102517e-01f, -1.37141705e-01f, -8.89963806e-02f, 6.11199811e-02f,
  -2.55194623e-02f, -1.28128439e-01f, -1.12496369e-01f, -1.65912285e-02f, -3.12976427e-02f, -1.71787366e-01f, -6.97089359e-02f, -5.08526824e-02f, -1.72382370e-01f, 6.16924167e-02f,
  1.39754713e-01f, 7.91267604e-02f, 5.44401370e-02f, 1.46247864e-01f, 1.64139792e-01f, -3.01148146e-01f, -5.06108761e-01f, -2.55143613e-01f, 6.84245303e-02f, -3.16753658e-03f,
  2.41005216e-02f, 3.55399586e-02f, 1.75113112e-01f, -6.36442602e-02f, -3.41577172e-01f, -1.34260193e-01f, 9.62316096e-02f, -4.70565334e-02f, -3.64618361e-01f, -2.35397115e-01f,
  -3.11623812e-02f, 4.50231768e-02f, -5.00437170e-02f, -1.55474052e-01f, 3.08399469e-01f, 1.94191739e-01f, 2.86121339e-01f, 2.28916526e-01f, 1.85793623e-01f, 3.11705649e-01f,
  3.39189529e-01f, 2.38729000e-01f, -2.36336276e-01f, 1.27078712e-01f, 9.47074890e-02f, -3.07696350e-02f, -3.42109166e-02f, 1.26019999e-01f, -1.32073045e-01f, -1.28060626e-02f,
  5.21328896e-02f, -4.41922620e-02f, 1.54829353e-01f, -6.08544275e-02f, -1.11312337e-01f, -2.61717170e-01f, -9.97550562e-02f, -1.06084712e-01f, 8.05328190e-02f, -1.39649853e-01f,
  -8.69127661e-02f, 5.39908856e-02f, 1.28372461e-01f, -6.24005869e-02f, -2.81179529e-02f, 1.43431695e-02f, 7.84775168e-02f, 2.16303319e-01f, 1.11589683e-02f, 2.81526633e-02f,
  6.09130152e-02f, -5.36227748e-02f, 4.51713838e-02f, 1.32086938e-02f, -1.12689525e-01f, 2.47842260e-03f, 8.73552784e-02f, -3.77097093e-02f, -1.53368199e-02f, -5.92953786e-02f,
  -1.62916720e-01f, -2.75751147e-02f, 1.76175367e-02f, 9.08657610e-02f, 8.02931637e-02f, 9.79758799e-02f, 6.23263493e-02f, 2.11127754e-02f, -2.35661734e-02f, 3.56866345e-02f,
  6.78655282e-02f, 2.56525818e-02f, 6.08912818e-02f, -7.56145045e-02f, 4.67413478e-02f, -3.44193960e-03f, -7.58050829e-02f, 3.97915691e-02f, -2.67948899e-02f, 1.50936621e-03f,
  -9.54250917e-02f, -1.95499778e-01f, -1.44686056e-02f, -1.47019148e-01f, 1.05123810e-01f, 2.31446903e-02f, 1.73403472e-01f, -5.11102341e-02f, -1.88389122e-02f, -2.07513645e-01f,
  4.34326008e-03f, -3.74722257e-02f, 3.09221577e-02f, -1.40924111e-01f, -2.22203255e-01f, -6.01448724e-03f, -1.34626225e-01f, -5.27682528e-02f, -1.68553874e-01f, -3.25899012e-02f,
  -1.48844615e-01f, -2.55595952e-01f, -2.10123643e-01f, -2.61282146e-01f, 1.92319248e-02f, -8.21810514e-02f, -9.03652534e-02f, -1.21990889e-02f, -8.56425390e-02f, -2.36398757e-01f,
  -4.38591242e-01f, -3.30121845e-01f, 2.55410939e-01f, 1.84923410e-03f, 2.16263264e-01f, 1.48143068e-01f, 2.10479200e-01f, 2.70540845e-02f, 5.29247969e-02f, -4.06193882e-02f,
  -2.03243047e-01f, -1.82338700e-01f, -1.42937407e-01f, -1.27050310e-01f, -1.42231375e-01f, 1.12573765e-01f, 1.41449273e-01f, 2.13218644e-01f, 2.67732739e-01f, 1.90643206e-01f,
  5.19681759e-02f, 1.07836425e-01f, -1.01962954e-01f, 2.81704254e-02f, -4.34471341e-03f, 1.42506301e-01f, 7.25442395e-02f, 1.55919287e-02f, -8.37412998e-02f, -6.70421030e-03f,
  1.38574526e-01f, -2.99797058e-01f, 5.40912971e-02f, -2.39298016e-01f, -9.51098949e-02f, -9.70697701e-02f, -3.09921019e-02f, 2.94231400e-02f, -1.09900989e-01f, 8.98041129e-02f,
  -5.93889505e-02f, -1.59881208e-02f, -1.09032743e-01f, -6.89115822e-02f, 8.57330039e-02f, -2.25353055e-02f, -7.26272315e-02f, -1.24002248e-01f, -2.20910981e-02f, -1.19215436e-01f,
  -6.36228099e-02f, -2.43051294e-02f, 6.19726405e-02f, 8.92572477e-02f, -1.29859775e-01f, -9.76088420e-02f, -7.91747645e-02f, -7.89894462e-02f, -1.16305858e-01f, 4.16394807e-02f,
  -9.67337098e-03f, 8.07900168e-03f, -8.65851622e-03f, -9.57115740e-03f, 7.73538873e-02f, 4.03007865e-02f, 7.78397620e-02f, 1.15354396e-02f, 1.46528229e-01f, 8.89745131e-02f,
  2.61834767e-02f, 3.80567349e-02f, 1.17166631e-01f, 3.92453000e-02f, 4.07715775e-02f, 7.27593824e-02f, 1.75198223e-02f, -1.16136387e-01f, -6.68359697e-02f, -1.46649435e-01f,
  4.94736731e-02f, 7.46878162e-02f, -4.19782149e-03f, -1.12040518e-02f, 1.29292225e-02f, -3.05213202e-02f, -2.29039248e-02f, 8.75546858e-02f, -2.41877092e-03f, -1.20642595e-02f,
  1.89525545e-01f, -2.33287454e-01f, 7.35763758e-02f, -1.04087159e-01f, 4.27022018e-03f, -5.89961410e-02f, 4.06997055e-02f, -3.67944278e-02f, 1.08428568e-01f, 1.74160734e-01f,
  -6.33218884e-02f, -2.71716956e-02f, -9.02223885e-02f, 4.32719216e-02f, 1.37060061e-01f, 2.06414182e-02f, -2.13653058e-01f, 2.98785437e-02f, 9.33726579e-02f, -5.00886291e-02f,
  -6.92803413e-02f, 1.50315702e-01f, 1.45170838e-01f, 1.50184274e-01f, 8.78133848e-02f, 1.15694024e-01f, 1.99687406e-01f, 1.04768887e-01f, 1.77122772e-01f, 2.00375944e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 26)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 26;
const float L0_fan_Bp_bar_data[] = {
  1.12436794e-01f, 1.24528915e-01f, 1.95519906e-02f, 1.61891237e-01f, 1.36954695e-01f, 1.78691104e-01f, 3.33588064e-01f, 7.70613179e-02f, 1.39524892e-01f, 2.22368687e-01f,
  1.73268884e-01f, 2.33193561e-01f, -1.20199449e-01f, 1.08736046e-01f, 1.72022939e-01f, 1.24904893e-01f, 2.35881120e-01f, 2.97407210e-01f, 2.22809315e-01f, 5.08954786e-02f,
  8.18205848e-02f, -3.55102047e-02f, 5.40676340e-02f, 3.06402564e-01f, 2.13302404e-01f, -5.70321456e-03f
};

// L1_fan_Wp (Shape: 51 x 128)
const int L1_fan_Wp_rows = 51;
const int L1_fan_Wp_cols = 128;
const float L1_fan_Wp_data[] = {
  -4.81779017e-02f, 4.14022766e-02f, 5.42623103e-02f, -8.60765874e-02f, 3.16029266e-02f, 8.03936943e-02f, 7.38385394e-02f, -5.25683276e-02f, -5.28518446e-02f, 3.05062141e-02f,
  -6.78506643e-02f, 9.52217206e-02f, 7.24599436e-02f, -5.54595217e-02f, -4.57033962e-02f, -4.79764491e-02f, 4.65020388e-02f, 1.33054212e-01f, 1.21829055e-01f, 9.94702652e-02f,
  -6.58737682e-03f, 4.22385260e-02f, 2.07404699e-02f, 3.27061228e-02f, 2.01942604e-02f, -2.81740762e-02f, 1.36751290e-02f, 7.56378169e-04f, -4.14379761e-02f, 5.51116280e-02f,
  7.03790635e-02f, 7.90714845e-03f, 6.67900546e-03f, 6.66168556e-02f, 4.43560034e-02f, 4.13865894e-02f, -1.37359932e-01f, -1.30822808e-01f, -8.17469135e-02f, -1.70664899e-02f,
  -3.10496520e-02f, 1.43750951e-01f, -1.25660747e-01f, -1.57096550e-01f, 1.05488703e-01f, -8.92510638e-02f, 1.24567881e-01f, 1.28472885e-02f, 7.51251802e-02f, 1.22280784e-01f,
  1.61700491e-02f, 7.83619564e-03f, -8.37444961e-02f, 7.45885745e-02f, 6.94252849e-02f, -8.03819820e-02f, -1.91321641e-01f, -1.72349662e-01f, 2.45395564e-02f, 5.65119041e-03f,
  -1.84714034e-01f, 1.80120260e-01f, -6.65895119e-02f, -2.10898146e-01f, 1.46355674e-01f, -3.87532525e-02f, 8.89499933e-02f, 9.40307137e-03f, 1.56837329e-01f, -9.21850428e-02f,
  4.36330065e-02f, -7.91259855e-02f, -2.06923291e-01f, -2.93887239e-02f, -1.40088037e-01f, -7.69264176e-02f, 9.04438794e-02f, -1.39307037e-01f, -2.03515589e-01f, -6.14631474e-02f,
  -1.08529359e-01f, -1.08432636e-01f, -2.90002413e-02f, 1.53391138e-01f, -9.69503298e-02f, -1.16050564e-01f, 3.03402897e-02f, 1.21852927e-01f, -1.51380658e-01f, 1.68404594e-01f,
  -3.81058012e-03f, -2.31116608e-01f, -2.72258490e-01f, -2.86121154e-03f, 9.67471078e-02f, -1.76350355e-01f, 1.02613531e-01f, -5.67856506e-02f, -9.38288495e-02f, 3.26814279e-02f,
  -1.78862177e-03f, 1.59414515e-01f, 1.32602140e-01f, 1.25266880e-01f, 1.03000104e-01f, 1.02895968e-01f, 9.62621942e-02f, 4.02983278e-02f, -2.09614798e-01f, 7.98135772e-02f,
  1.62946254e-01f, -1.68770470e-03f, 5.09265661e-02f, 8.31371769e-02f, 3.16205323e-02f, 2.07537897e-02f, -2.73425460e-01f, 5.11345007e-02f, 7.58907720e-02f, -1.47192879e-03f,
  -2.18392402e-01f, 3.40137407e-02f, 1.63090825e-01f, 1.00522954e-02f, -1.69844478e-01f, -1.89272743e-02f, -6.55450076e-02f, -2.42847353e-02f, 1.70866423e-03f, 3.72262001e-02f,
  1.24434665e-01f, -4.58345339e-02f, -1.20662786e-01f, 4.58160117e-02f, -1.49093196e-01f, 3.71193103e-02f, 5.33529408e-02f, 5.19213118e-02f, -6.92789629e-02f, 1.13475963e-01f,
  -5.80525259e-03f, -3.14248800e-02f, -9.80591625e-02f, -3.88383865e-02f, -3.55609097e-02f, 4.70625162e-02f, 1.14307791e-01f, -8.29392523e-02f, 9.70803946e-03f, 2.89332569e-02f,
  1.21236727e-01f, -6.65962845e-02f, -6.41269833e-02f, 7.96139613e-02f, 1.25056207e-01f, 2.96855271e-02f, 1.36786690e-02f, -1.39876930e-02f, 7.27130147e-03f, 5.78616410e-02f,
  -5.00041321e-02f, 6.91536367e-02f, 8.98365676e-02f, -3.69267762e-02f, -6.50238618e-02f, 7.92258903e-02f, 2.72217188e-02f, -7.51059502e-02f, 7.11453855e-02f, 8.40761699e-03f,
  -7.87144974e-02f, 1.51488120e-02f, -1.93075091e-02f, -8.98312777e-03f, -8.79306048e-02f, 1.13646291e-01f, -1.09929435e-01f, -7.22350329e-02f, 3.22148241e-02f, 1.65173188e-02f,
  2.92838253e-02f, 5.95896766e-02f, -5.33588864e-02f, -2.77042091e-02f, -7.92338997e-02f, -2.40673259e-01f, 1.25201792e-01f, -9.57603306e-02f, 5.46705574e-02f, -5.12935407e-02f,
  -9.29937959e-02f, 3.23324874e-02f, -1.47100449e-01f, 6.29823804e-02f, 1.46482855e-01f, 5.67868836e-02f, -3.87161672e-02f, -1.41601980e-01f, -1.30257034e-03f, 3.88444141e-02f,
  -1.13324681e-02f, -3.78835620e-03f, -4.36972305e-02f, -1.89100876e-01f, 8.68669376e-02f, -2.73658067e-01f, 4.89720814e-02f, -6.21388778e-02f, -6.73976690e-02f, -4.20170948e-02f,
  1.35233030e-01f, 1.55823991e-01f, -2.05855407e-02f, -1.94064096e-01f, 3.36535275e-02f, 8.98990408e-02f, -5.18481918e-02f, 9.43282843e-02f, -1.69950668e-02f, -1.02963462e-01f,
  2.97028627e-02f, -1.96901988e-02f, 1.15660354e-01f, -7.30269700e-02f, 7.66301621e-03f, -5.76693565e-02f, -2.19597891e-02f, 2.46033184e-02f, -1.04297236e-01f, 4.00795341e-02f,
  6.33376092e-02f, -2.71899924e-02f, 1.46952309e-02f, 7.65380040e-02f, 1.65064801e-02f, -2.44461149e-02f, -1.34772614e-01f, -1.49667403e-02f, 5.72900958e-02f, -2.51780272e-01f,
  -1.96873508e-02f, 2.09942888e-02f, -4.09224145e-02f, -5.80818914e-02f, -1.76568940e-01f, 8.61547440e-02f, 2.47778669e-01f, 1.26448153e-02f, -1.59677759e-01f, 5.94714656e-02f,
  -4.27380316e-02f, 7.22131953e-02f, -2.12775037e-01f, 3.00246999e-02f, -2.24224433e-01f, -4.37448882e-02f, -9.95272864e-03f, 2.10988168e-02f, -5.48730120e-02f, -6.82169944e-02f,
  9.56617575e-03f, -9.75730922e-03f, -1.17103122e-02f, -2.88286880e-02f, 2.67142467e-02f, -1.28660068e-01f, -1.25326321e-01f, 7.29588345e-02f, 1.13185398e-01f, -1.86516661e-02f,
  -8.89387131e-02f, 3.72463390e-02f, 9.83109251e-02f, 6.29066303e-02f, -3.94579619e-02f, -7.52260238e-02f, -6.98135123e-02f, 7.55870296e-03f, 2.18486823e-02f, 1.30567905e-02f,
  -2.83881146e-02f, -2.37748660e-02f, 9.04859509e-03f, 2.95463455e-04f, -1.38912261e-01f, 1.18806437e-01f, -4.93163615e-02f, -5.73849455e-02f, -4.16306555e-02f, -7.95694143e-02f,
  -9.47460979e-02f, -8.69185776e-02f, -9.38545913e-03f, -5.89315109e-02f, -1.35011241e-01f, 1.10431045e-01f, -1.12338319e-01f, 7.71202222e-02f, -3.12094446e-02f, 6.52983561e-02f,
  -2.12215692e-01f, -6.67635798e-02f, 1.65086112e-03f, -4.84199598e-02f, -7.70091489e-02f, 1.14708468e-01f, -6.86425418e-02f, -3.71018723e-02f, 1.03534847e-01f, -1.20426767e-01f,
  1.32145643e-01f, -1.31893501e-01f, 7.29129836e-02f, 6.98283538e-02f, -1.67122968e-02f, 1.24910682e-01f, 1.06262870e-01f, -1.18815474e-01f, -2.56331325e-01f, -5.14891930e-02f,
  -1.49321891e-02f, -2.04796512e-02f, -2.57594407e-01f, -9.53082964e-02f, -8.09246954e-03f, 1.07719034e-01f, -5.59080206e-02f, -1.01980224e-01f, -3.67012434e-02f, 3.28281671e-02f,
  1.43700672e-04f, -9.22951177e-02f, 1.45364748e-02f, 2.33797240e-03f, 1.62470341e-02f, 1.20891922e-03f, -2.30071917e-02f, 7.28644729e-02f, -1.19411629e-02f, -7.52488747e-02f,
  -1.52557462e-01f, 1.50844917e-01f, -8.39644372e-02f, -1.30400255e-01f, 1.17019460e-01f, -1.44779934e-02f, 1.18298279e-02f, 3.95485498e-02f, 2.92356536e-02f, 1.15604617e-01f,
  -1.19532697e-01f, -8.80047977e-02f, -8.11821315e-03f, -8.36448446e-02f, -3.02698147e-02f, 9.69471261e-02f, -1.25373051e-01f, 9.43577103e-03f, -1.84139937e-01f, 8.36208463e-02f,
  7.16231465e-02f, -1.63798824e-01f, 6.03270419e-02f, -6.37754202e-02f, -2.06643522e-01f, 7.91323278e-03f, -1.54896706e-01f, 2.29732506e-02f, -5.86523190e-02f, -2.68848836e-02f,
  -2.75637526e-02f, 1.08800314e-01f, 2.81393766e-01f, -6.91879243e-02f, 1.54996365e-01f, 2.38565411e-02f, 1.21710815e-01f, 5.94562106e-02f, 1.96031123e-01f, 5.76118939e-02f,
  1.21667922e-01f, -2.18249127e-01f, -1.31260484e-01f, -9.68424231e-02f, 2.02809982e-02f, 2.00885488e-03f, 6.13030978e-03f, 1.40960384e-02f, -8.33640546e-02f, -4.33436409e-03f,
  -1.01092301e-01f, -9.36900526e-02f, 2.24676743e-01f, 3.32458224e-03f, -5.25288060e-02f, -2.16114521e-03f, 1.44319152e-02f, 3.00276969e-02f, -9.73060541e-03f, 8.12975168e-02f,
  1.68868934e-03f, -1.18118329e-02f, -9.17005315e-02f, -9.38273594e-02f, -1.30281681e-02f, 7.60658607e-02f, -5.66352420e-02f, -1.36390124e-02f, 6.91393688e-02f, 2.54845563e-02f,
  -8.97107571e-02f, -2.29808106e-03f, 7.47053185e-03f, 1.54898576e-02f, -3.81299108e-02f, -2.89083030e-02f, 2.12016311e-02f, 2.39104293e-02f, 6.90810531e-02f, 5.35945669e-02f,
  1.39608026e-01f, 3.80294584e-02f, 4.04625162e-02f, 7.05929622e-02f, 3.10880896e-02f, 2.70530526e-02f, 6.65958971e-02f, -1.21088875e-02f, 4.72833216e-02f, 7.31001869e-02f,
  1.13738291e-02f, -6.31795824e-02f, 4.54737321e-02f, -2.57450808e-02f, 1.05268762e-01f, -6.39501661e-02f, 1.46908820e-01f, -4.18071337e-02f, 1.54764513e-02f, 2.37565767e-02f,
  -9.95698050e-02f, -5.14745787e-02f, -6.27571531e-03f, -1.40832201e-01f, 9.52102840e-02f, -6.87107220e-02f, -1.66630931e-02f, -3.27302627e-02f, -6.71661645e-02f, 2.63840221e-02f,
  8.07609782e-02f, 5.30596077e-02f, 9.76021960e-02f, 8.02177563e-02f, 3.47357020e-02f, 1.22489758e-01f, 7.06696510e-02f, -8.32174160e-03f, 1.16482126e-02f, 1.29841879e-01f,
  7.03391060e-02f, -4.79264967e-02f, 1.09532431e-01f, 7.69357458e-02f, -2.50227954e-02f, -1.83778703e-02f, -1.08700611e-01f, -9.91750658e-02f, -3.65966298e-02f, 1.03907429e-01f,
  -4.51778844e-02f, 1.90549120e-01f, 1.01801671e-01f, -4.01626620e-03f, 7.85261393e-02f, -4.00467254e-02f, -7.78140873e-02f, -1.09750830e-01f, -4.45670225e-02f, -9.16382223e-02f,
  1.85200348e-02f, 1.54605702e-01f, -6.86054155e-02f, 1.78440645e-01f, -7.67819136e-02f, -1.62501410e-01f, 2.98654940e-02f, 1.49288505e-01f, 9.62888375e-02f, 2.00738475e-01f,
  5.81561290e-02f, 2.70824730e-01f, -3.06003075e-02f, 7.04108775e-02f, -2.34811127e-01f, -1.20660938e-01f, 2.52398133e-01f, -3.64084929e-01f, -4.13553007e-02f, -1.88501291e-02f,
  -2.35895626e-02f, -8.27698112e-02f, 8.74437019e-02f, -2.41718575e-01f, -5.41819260e-02f, 3.18315923e-02f, -7.23597854e-02f, 6.86722621e-02f, -8.90417024e-03f, 1.75985113e-01f,
  -1.62219673e-01f, 1.78336754e-01f, -4.75950278e-02f, 7.53297284e-02f, 7.72834644e-02f, 1.26241878e-01f, -1.02291889e-01f, -5.79036959e-02f, -5.04604988e-02f, 3.34709957e-02f,
  1.76928435e-02f, -6.20933361e-02f, 6.92433342e-02f, -2.26102825e-02f, 1.18609406e-02f, 1.08216152e-01f, -1.77906267e-02f, -7.95746520e-02f, 1.17536612e-01f, 1.12239420e-01f,
  -7.00786756e-03f, 7.99489394e-02f, 5.32256961e-02f, -7.43763521e-03f, 6.85809180e-02f, 4.41149548e-02f, 3.33105288e-02f, 6.82487488e-02f, 2.62990966e-02f, 1.70663953e-01f,
  5.55403419e-02f, 1.41644761e-01f, -1.26592934e-01f, 7.41730854e-02f, 2.65798829e-02f, 7.53829032e-02f, 3.96556184e-02f, -6.61252216e-02f, 3.22680771e-02f, -1.44108962e-02f,
  -1.67103745e-02f, -1.75739825e-02f, 1.47742048e-01f, -4.62136976e-03f, -3.03277802e-02f, -1.68688521e-02f, -1.78058118e-01f, -3.55691016e-02f, 6.98984489e-02f, -1.39771029e-01f,
  -8.32164213e-02f, -5.88004105e-03f, -1.83411211e-01f, 1.34486228e-01f, 1.39427232e-02f, 8.39735493e-02f, -8.75788108e-02f, -1.36826932e-01f, -1.23472452e-01f, -7.43325800e-02f,
  -1.19223677e-01f, -1.98605247e-02f, -2.87102997e-01f, 8.40693489e-02f, -5.99484555e-02f, -1.04117386e-01f, -8.25264007e-02f, 8.74813721e-02f, 2.43898071e-02f, 4.24154662e-02f,
  6.24145269e-02f, 7.75884232e-03f, -1.90274075e-01f, -1.01300776e-01f, 1.03752054e-01f, -1.86681617e-02f, -9.36606973e-02f, -6.87048212e-02f, 1.49987057e-01f, -2.55130172e-01f,
  -2.94274259e-02f, 3.15201692e-02f, -9.43344086e-02f, 4.80339192e-02f, 1.52240381e-01f, -7.57847773e-03f, -3.86773236e-02f, -2.25580528e-01f, 4.01556268e-02f, 8.82451311e-02f,
  -2.83025354e-02f, -1.62774101e-01f, 3.80826555e-02f, 5.46294684e-03f, -1.00264050e-01f, -1.66336060e-01f, 1.29388468e-02f, 9.02491137e-02f, 4.43845056e-02f, 2.68720269e-01f,
  7.62629732e-02f, -9.09089446e-02f, -8.27424154e-02f, 7.35110492e-02f, -2.43842229e-02f, 8.41322914e-02f, 6.83309585e-02f, 1.02399424e-01f, -9.12201498e-03f, 8.32377821e-02f,
  -1.75941810e-01f, -6.22938536e-02f, 1.49512604e-01f, -3.84405404e-02f, 3.47293615e-02f, -1.05355084e-02f, 3.27108316e-02f, -1.64760165e-02f, -1.96212634e-01f, -1.61209866e-01f,
  1.28129065e-01f, 1.70814827e-01f, -2.53181934e-01f, 2.05870986e-01f, -1.19820252e-01f, 5.04761748e-02f, 2.19381917e-02f, 8.56911466e-02f, -1.54514119e-01f, -2.05751494e-01f,
  -2.04305612e-02f, -8.13591853e-02f, 8.79718363e-02f, -4.34735082e-02f, -6.86971247e-02f, -1.32835219e-02f, -8.91118571e-02f, 4.37314548e-02f, -1.66785926e-01f, -9.43945795e-02f,
  -1.02224119e-01f, -2.47514155e-02f, 7.33010322e-02f, -3.55835855e-02f, -7.43385479e-02f, -1.45510614e-01f, -1.55764362e-02f, 8.78996253e-02f, 3.59528400e-02f, -5.60538135e-02f,
  -1.21223718e-01f, 1.73391365e-02f, 3.00730094e-02f, 5.72347865e-02f, 3.36101539e-02f, -3.09131444e-02f, 9.11518112e-02f, 3.54042053e-02f, -8.56583118e-02f, 5.77208661e-02f,
  -3.45223546e-02f, 6.66630566e-02f, -6.68744370e-02f, 1.00420244e-01f, -4.12879065e-02f, -6.35957196e-02f, 9.85087454e-02f, -6.12031780e-02f, -1.11693047e-01f, 2.66336761e-02f,
  -4.16381843e-02f, 2.63366941e-03f, -8.33633319e-02f, -7.71223335e-03f, -1.92392115e-02f, -1.06481582e-01f, 5.90671077e-02f, 8.29193927e-03f, 3.53966691e-02f, 1.36454599e-02f,
  -3.24933119e-02f, 1.00384932e-03f, 4.03133780e-02f, 2.36024763e-02f, -1.49444297e-01f, -7.72214234e-02f, -9.23322812e-02f, 6.82291435e-03f, -8.74614120e-02f, 9.00711492e-03f,
  -1.07309066e-01f, 3.16404998e-02f, -9.28401351e-02f, 3.78893465e-02f, -1.31402656e-01f, 1.47720888e-01f, 7.64941573e-02f, -1.45786582e-02f, -8.05403441e-02f, 3.68539803e-02f,
  7.30163902e-02f, 5.94191104e-02f, -6.63999468e-02f, 3.85829248e-03f, 2.12976411e-02f, -6.37999624e-02f, -8.11060145e-02f, -2.02938363e-01f, -3.13424803e-02f, 4.24524322e-02f,
  7.02517200e-03f, -4.44752686e-02f, 1.84620291e-01f, -2.94394288e-02f, -7.53960758e-02f, -1.05457038e-01f, -9.25355591e-03f, 3.17219831e-02f, -9.67577398e-02f, -1.72686532e-01f,
  5.62856197e-02f, 4.87227887e-02f, 8.98045301e-02f, 1.53686423e-02f, 4.23192084e-02f, 5.81841217e-03f, -2.86706872e-02f, 9.64096040e-02f, 1.33382529e-01f, 7.20284283e-02f,
  -4.48871665e-02f, -4.05895011e-03f, 1.35536611e-01f, 1.90427639e-02f, 1.70519307e-01f, 9.64511931e-02f, 1.78465620e-01f, 1.81097433e-01f, -1.86956003e-01f, -6.02032281e-02f,
  4.86980751e-02f, 1.68656390e-02f, -3.79911885e-02f, 1.24821335e-01f, -1.55981332e-01f, -2.07049564e-01f, -9.85872522e-02f, -1.75932363e-01f, 2.94539332e-01f, 1.91887781e-01f,
  -2.20185909e-02f, 3.41378860e-02f, -8.66455063e-02f, 1.18822639e-03f, -8.06936920e-02f, 2.30575651e-02f, -2.40803882e-01f, 1.27629608e-01f, 6.01003617e-02f, -5.44023812e-02f,
  6.99267676e-03f, -1.73647925e-01f, 4.94987369e-02f, -2.47803088e-02f, -9.28179920e-02f, 7.60822669e-02f, 1.10430017e-01f, -9.00598019e-02f, -1.86652634e-02f, -2.61233822e-02f,
  6.97493628e-02f, -1.06742315e-01f, -8.66064653e-02f, -5.03217615e-02f, -3.02975979e-02f, -7.21719563e-02f, 1.90131068e-02f, -5.58083728e-02f, -1.25670254e-01f, 8.33084062e-03f,
  1.87934618e-02f, -3.65753248e-02f, 5.01137748e-02f, 9.77186933e-02f, 3.13953534e-02f, -7.47582689e-02f, -4.88138832e-02f, -7.60379508e-02f, -6.00318075e-04f, -6.15932904e-02f,
  -4.80753146e-02f, -4.16833535e-02f, -9.50512011e-03f, -5.58430608e-03f, 5.93312234e-02f, 6.19799681e-02f, -8.00639689e-02f, 1.26106134e-02f, -1.08947322e-01f, 1.58831656e-01f,
  1.54172601e-02f, 1.82183944e-02f, -5.22174612e-02f, -8.45588073e-02f, 1.35156453e-01f, 4.66836616e-02f, -6.34763166e-02f, 6.32940009e-02f, 1.45197883e-01f, -1.13045789e-01f,
  1.53326448e-02f, -5.20200804e-02f, -2.03097593e-02f, 2.68248748e-02f, 8.78759399e-02f, -3.92101854e-02f, -7.18177333e-02f, -7.61550739e-02f, 2.81828791e-01f, -8.20035636e-02f,
  -7.71711990e-02f, -2.11238891e-01f, 4.08341698e-02f, -7.42518976e-02f, -6.96575865e-02f, -5.84237054e-02f, -9.19707417e-02f, 4.30524163e-02f, 3.22155617e-02f, -1.20431287e-02f,
  -6.72807395e-02f, 2.77039427e-02f, -8.77658948e-02f, 7.51494244e-02f, 9.11830813e-02f, -9.56820399e-02f, 9.74027365e-02f, -3.12559493e-02f, -5.73288240e-02f, -4.85923141e-02f,
  -4.24725004e-02f, -1.39677957e-01f, -2.03827038e-01f, 1.39709651e-01f, -3.58848684e-02f, 3.20771523e-02f, 5.17446361e-02f, 1.89595655e-01f, 8.93770978e-02f, 1.07752746e-02f,
  -2.98224911e-02f, 3.68227623e-02f, -9.27799046e-02f, -1.37107402e-01f, -1.03735998e-01f, -6.30484149e-02f, -1.54099211e-01f, 2.62745559e-01f, -6.80828467e-02f, -8.74616131e-02f,
  -1.37010843e-01f, 1.51658192e-01f, 1.38321757e-01f, 4.62907851e-02f, -6.51430786e-02f, -1.19984552e-01f, -1.63373537e-02f, 4.89216521e-02f, -2.64599562e-01f, -2.20267221e-01f,
  5.18505611e-02f, -4.83006015e-02f, -2.98154820e-03f, 1.62513122e-01f, -1.72390963e-03f, -7.72011504e-02f, 7.67812878e-02f, -8.46076235e-02f, -6.89588487e-02f, 8.67681578e-02f,
  3.09185505e-01f, 1.97946042e-01f, 1.70862128e-03f, -1.81652501e-01f, -2.33950272e-01f, -7.89610296e-02f, 4.61112820e-02f, -6.14996627e-02f, 1.02580905e-01f, 1.11796185e-01f,
  1.54974433e-02f, -1.37337493e-02f, -1.03190221e-01f, 1.83381047e-02f, -1.96841419e-01f, 6.63307607e-02f, -1.51571736e-01f, 3.52010094e-02f, -7.06419870e-02f, 9.56056416e-02f,
  -7.85200521e-02f, -3.52849588e-02f, 2.27488857e-02f, -9.96483266e-02f, -4.67254482e-02f, -4.02670242e-02f, -4.78568673e-03f, -6.86924234e-02f, -2.09094509e-02f, -4.77101244e-02f,
  -9.54086613e-03f, 2.54526306e-02f, 3.35367247e-02f, 1.45799980e-01f, -2.92668696e-02f, 1.66621467e-03f, -1.45691782e-01f, 4.29066420e-02f, 1.40004814e-01f, -7.54286908e-03f,
  -1.02175854e-01f, -5.89008778e-02f, 3.23518887e-02f, 5.73372729e-02f, -7.42804557e-02f, -3.27286161e-02f, 4.25341912e-02f, -4.91433963e-02f, 3.53409797e-02f, -9.63015854e-02f,
  -1.65348109e-02f, 1.61956586e-02f, 7.88125023e-03f, -5.04675992e-02f, -1.24167064e-02f, -6.59227818e-02f, -6.05718680e-02f, 9.96500067e-03f, 4.13999408e-02f, -5.91872633e-02f,
  -1.86812043e-01f, -4.03907970e-02f, -5.64461835e-02f, -1.59958377e-01f, 1.81627482e-01f, -8.11185315e-02f, -2.36981273e-01f, 6.27092049e-02f, -1.58812255e-01f, 4.05568928e-02f,
  -1.37810654e-03f, -2.41035596e-02f, 6.16572574e-02f, 7.83011690e-02f, 1.70847908e-01f, 8.97260010e-02f, 1.07827231e-01f, 6.91706985e-02f, 4.78336439e-02f, -5.02369478e-02f,
  2.13742137e-01f, 2.44339947e-02f, -2.53369957e-01f, 4.67157513e-02f, 4.19755727e-02f, -4.40001115e-03f, 6.09767325e-02f, -1.29032563e-02f, 7.20277429e-02f, -5.76482415e-02f,
  1.57910019e-01f, -7.24057481e-02f, 2.95848325e-02f, 6.68904185e-02f, -3.89765180e-03f, -2.00229272e-01f, -4.73921485e-02f, -5.67786135e-02f, 6.39125472e-03f, -5.42109609e-02f,
  1.28271759e-01f, 6.28877012e-03f, 3.00611332e-02f, -1.22053176e-01f, 3.41529176e-02f, -1.44899517e-01f, 9.27005932e-02f, -6.07356243e-03f, 1.94973260e-01f, -1.92908589e-02f,
  5.73161691e-02f, 3.04021444e-02f, -2.80226730e-02f, -3.98846045e-02f, -6.75330460e-02f, 2.88442839e-02f, 1.83610782e-01f, -7.76519999e-02f, 1.48907989e-01f, -3.16878431e-03f,
  -6.59060329e-02f, -7.37410411e-02f, -7.98219070e-02f, 2.73679923e-02f, 6.48105741e-02f, 6.87269196e-02f, 1.12988368e-01f, -2.96468232e-02f, -2.80976713e-01f, -5.51589243e-02f,
  -1.05361842e-01f, 1.56479001e-01f, 7.24245310e-02f, -3.76010388e-02f, 8.47985372e-02f, -4.95314710e-02f, 1.34325447e-02f, -8.79613385e-02f, -3.24697397e-03f, -2.38491744e-02f,
  1.21026047e-01f, 1.53962020e-02f, -2.03134008e-02f, 2.46754829e-02f, -2.01494828e-01f, -1.07111800e-02f, -4.30858061e-02f, 8.79901052e-02f, -9.17734280e-02f, 4.28872034e-02f,
  -2.96179913e-02f, -1.10928662e-01f, 5.89446053e-02f, 1.10901460e-01f, -3.18959877e-02f, -9.31431539e-03f, -2.99214683e-02f, 2.36695353e-02f, 4.63918298e-02f, -1.33171722e-01f,
  2.43285317e-02f, -7.06680492e-02f, -1.62990522e-02f, 6.82870075e-02f, -5.61253391e-02f, -4.25134674e-02f, -1.20608777e-01f, -1.97266817e-01f, 1.38674518e-02f, -9.03937221e-03f,
  -1.17135055e-01f, 1.89264417e-02f, -8.14871639e-02f, 2.89888754e-02f, -2.26457626e-01f, 1.65310837e-02f, -9.82080251e-02f, -3.95173952e-02f, 5.27195493e-03f, -5.11962213e-02f,
  -5.88544644e-02f, -8.07063282e-02f, -2.84015220e-02f, 1.09195039e-02f, 1.43043669e-02f, 9.39497650e-02f, -1.08136281e-01f, -4.45626974e-02f, 3.39263566e-02f, -1.94077175e-02f,
  -9.18367729e-02f, -8.46380293e-02f, 1.47508264e-01f, 2.58351658e-02f, 3.79683916e-03f, -1.01658404e-01f, -1.67038351e-01f, 5.99681847e-02f, 1.48675755e-01f, -5.59630580e-02f,
  6.83830231e-02f, -8.76817554e-02f, 5.78136370e-02f, -4.19901684e-02f, 9.65374187e-02f, -7.32521117e-02f, -1.99246854e-01f, 2.50736754e-02f, 5.52247539e-02f, 4.27968688e-02f,
  -7.52123892e-02f, 5.56488484e-02f, -1.67637944e-01f, -9.03557986e-03f, 7.99954459e-02f, 5.68113364e-02f, 5.00993542e-02f, 8.65325890e-03f, 3.23954672e-02f, 1.79128051e-01f,
  -1.00201845e-01f, -2.39514440e-01f, -1.23787142e-01f, -1.01038283e-02f, 2.49797921e-03f, 2.07466595e-02f, -5.64899892e-02f, 6.86004236e-02f, 1.17364429e-01f, 5.69058433e-02f,
  6.81720376e-02f, -2.73496509e-01f, -1.50205597e-01f, 1.84283964e-02f, 4.04364057e-02f, 5.70386983e-02f, 2.08648629e-02f, -2.39355043e-02f, -1.05274804e-01f, -7.15433210e-02f,
  2.00035218e-02f, -2.09801570e-01f, 3.42584923e-02f, 1.12737842e-01f, 2.46670291e-01f, -1.71261147e-01f, -2.89071836e-02f, 1.09403133e-01f, 7.04458728e-02f, 3.73162702e-02f,
  1.82876602e-01f, -1.24317324e-02f, -1.90427333e-01f, 5.13728149e-02f, 1.66583642e-01f, -7.07840994e-02f, 1.19358212e-01f, -1.12497963e-01f, -6.53539523e-02f, -1.20032042e-01f,
  1.06124267e-01f, -1.73027426e-01f, -4.92551774e-02f, 9.45855975e-02f, 6.26182631e-02f, -7.44051412e-02f, -7.54174143e-02f, -1.68093458e-01f, -1.63524806e-01f, 3.42398649e-03f,
  8.84633809e-02f, -1.09979324e-01f, 3.39913592e-02f, -2.46393727e-03f, 1.81725956e-02f, -9.74705070e-02f, -6.25652969e-02f, 3.28705180e-03f, -3.95842940e-02f, 3.34837548e-02f,
  -1.11453123e-01f, -1.88615307e-01f, -1.53705925e-02f, -2.66862474e-03f, -2.57937741e-02f, -8.83840248e-02f, 4.46133427e-02f, -3.79953347e-02f, 9.11431946e-03f, -5.64975925e-02f,
  -1.01745516e-01f, 2.49300245e-02f, 2.79292814e-03f, 4.52559488e-03f, -7.29287192e-02f, 1.58726186e-01f, 2.03966536e-02f, 5.22961244e-02f, 1.24382719e-01f, -6.11488661e-03f,
  4.90270853e-02f, 6.10907562e-02f, -8.78322218e-03f, 4.21104506e-02f, 5.81491031e-02f, 5.04495949e-02f, -1.03708990e-02f, 3.60301509e-02f, 1.21207144e-02f, 6.58691376e-02f,
  1.07056111e-01f, 2.28578169e-02f, 4.09388728e-02f, -5.71590960e-02f, -5.75079210e-02f, 6.80081546e-02f, 4.95312689e-03f, -4.21945304e-02f, -3.55570093e-02f, -1.08785093e-01f,
  1.36351600e-01f, -1.13279067e-01f, -4.47535254e-02f, 7.32395845e-03f, -5.78182936e-02f, -2.05662593e-01f, 6.91205123e-03f, -6.47379160e-02f, -6.81751966e-03f, 7.66166747e-02f,
  2.61134803e-02f, 8.36540088e-02f, 5.55162393e-02f, -7.90910572e-02f, -5.29500991e-02f, -9.93799046e-02f, 1.83099508e-02f, 8.76268148e-02f, 1.30144283e-01f, -1.15982004e-01f,
  -8.41528103e-02f, 1.94021519e-02f, -1.89164896e-02f, -5.19120730e-02f, 3.89041565e-02f, -4.61437069e-02f, -3.19691211e-01f, 4.94258851e-02f, 1.44240007e-01f, 2.78877169e-01f,
  -7.21841827e-02f, 1.34206995e-01f, 4.49468791e-02f, 5.67875709e-03f, -8.16078857e-02f, -3.78407724e-02f, -9.33206528e-02f, -1.36680320e-01f, 1.23324888e-02f, 2.18587257e-02f,
  -3.64944153e-02f, 1.05963007e-01f, 5.46508562e-03f, -1.08682048e-02f, 1.29016906e-01f, -7.25952610e-02f, 1.02347620e-01f, -1.04654748e-02f, 1.19630605e-01f, 3.15314025e-01f,
  -2.00978860e-01f, -5.53113930e-02f, -3.51445563e-02f, -1.34090871e-01f, 1.85412511e-01f, -2.23531008e-01f, -2.73211077e-02f, -5.51919788e-02f, -1.60770938e-01f, -4.56478037e-02f,
  6.79932395e-03f, -3.54006529e-01f, -2.17682421e-01f, 6.68153316e-02f, -1.02513164e-01f, 1.57586019e-02f, -7.91845024e-02f, 1.93974733e-01f, -1.08346455e-02f, 1.15703665e-01f,
  2.00085584e-02f, 1.15462303e-01f, -2.98113525e-02f, 5.54879308e-02f, -5.36366478e-02f, -1.15379080e-01f, -2.30872892e-02f, 8.10256749e-02f, 1.60772771e-01f, 8.96022841e-03f,
  -8.41848901e-04f, -3.39251980e-02f, 1.35433361e-01f, -7.00848177e-02f, 2.05163602e-02f, -1.34301379e-01f, -2.26194151e-02f, 3.39649874e-03f, -1.73292190e-01f, 2.68002935e-02f,
  2.11565737e-02f, 4.03243639e-02f, -2.30378136e-02f, -5.25644235e-02f, 6.94128871e-02f, 1.56207547e-01f, 9.53281522e-02f, -5.08218221e-02f, 2.97295880e-02f, -4.67682481e-02f,
  -6.46117851e-02f, 3.03905997e-02f, 6.71019778e-02f, -8.56288299e-02f, -1.44985402e-02f, 6.66662157e-02f, 1.59534365e-02f, -1.34172127e-01f, 1.59953177e-01f, -4.92447913e-02f,
  5.51933832e-02f, 1.69972200e-02f, 6.20881431e-02f, -6.73385011e-03f, 6.66001637e-04f, 7.13130087e-02f, -1.41336685e-02f, -3.13908458e-02f, 7.76956603e-02f, -7.41602033e-02f,
  -1.66068777e-01f, -8.30654129e-02f, -4.89929579e-02f, 2.80586462e-02f, 3.08528040e-02f, 9.07332078e-02f, -6.30232319e-02f, 3.86955924e-02f, 9.56506096e-03f, -1.00782096e-01f,
  5.40705547e-02f, 2.20151544e-01f, 1.85252249e-01f, -5.34072481e-02f, 4.15984094e-02f, 1.77646466e-02f, 1.18598551e-01f, 1.09392688e-01f, -1.83605537e-01f, 6.59429505e-02f,
  5.78962862e-02f, 1.89682730e-02f, -7.17386231e-02f, -4.00691777e-02f, -1.45896628e-01f, 3.45881693e-02f, -2.33917758e-02f, 3.03683907e-01f, 2.00361516e-02f, 1.72438949e-01f,
  1.21512555e-01f, 1.96367562e-01f, -7.15569556e-02f, 7.47084767e-02f, -8.29921514e-02f, 8.38128403e-02f, 2.72079501e-02f, 1.53969988e-01f, 1.17509849e-01f, 7.86848143e-02f,
  1.52377747e-02f, 1.10505402e-01f, 7.42791146e-02f, -1.47912249e-01f, 2.73862407e-02f, -1.16033420e-01f, 8.10186192e-02f, 9.72559154e-02f, -1.84430048e-01f, 3.32350954e-02f,
  2.30352655e-02f, -1.15768295e-02f, -7.22594112e-02f, -1.24689862e-02f, -9.60680321e-02f, -1.71120003e-01f, 3.83087061e-02f, 3.56616452e-02f, 2.66830232e-02f, -3.15626152e-02f,
  1.10122956e-01f, -1.57294869e-02f, -9.60710496e-02f, -6.66964278e-02f, 1.46839157e-01f, -5.49291521e-02f, 1.17463917e-01f, 1.15416441e-02f, -2.16379344e-01f, -2.72839576e-01f,
  -2.15954423e-01f, -7.89854228e-02f, -1.90337852e-01f, 4.33327304e-03f, 1.20438695e-01f, 6.78470731e-02f, 2.08597198e-01f, 8.88892561e-02f, -1.08015187e-01f, 4.54445407e-02f,
  -3.87651213e-02f, 1.28175870e-01f, 2.09215842e-02f, -1.07538857e-01f, 1.97342094e-02f, -3.75472084e-02f, 6.87612072e-02f, 9.31348056e-02f, 2.92651961e-03f, 4.73526344e-02f,
  3.62494518e-03f, -9.44052078e-03f, -2.19740476e-02f, -1.94269679e-02f, 3.83641794e-02f, -6.03827611e-02f, -5.10137156e-03f, -3.35319676e-02f, -2.31567826e-02f, -4.95039076e-02f,
  -1.13770261e-01f, 1.28842518e-02f, -8.24415013e-02f, 1.54247077e-03f, -1.21325217e-01f, -5.06218933e-02f, 1.28898889e-01f, 3.56676690e-02f, 1.09686323e-01f, 4.82284551e-04f,
  9.07833278e-02f, -3.92268561e-02f, -2.78102197e-02f, 1.28268609e-02f, -9.04424414e-02f, -6.08026283e-03f, 4.47191671e-03f, 5.19984774e-02f, -2.88393237e-02f, -1.20456979e-01f,
  8.00802857e-02f, 2.19506979e-01f, 1.06495908e-02f, 1.30936444e-01f, -9.20866728e-02f, 8.34665596e-02f, 8.90215300e-03f, 3.18804458e-02f, 1.00937512e-04f, 1.39531761e-01f,
  -3.89842875e-03f, -2.50297878e-02f, -1.01890922e-01f, 1.28468588e-01f, 6.84791505e-02f, 1.04788259e-01f, 7.51415789e-02f, 6.28163889e-02f, 1.40095949e-02f, -2.50302199e-02f,
  -6.81866556e-02f, 1.90906167e-01f, -1.31127119e-01f, 9.62565169e-02f, -9.19534564e-02f, -1.05930738e-01f, -3.01811378e-02f, 8.82630050e-02f, 3.74050178e-02f, -9.39796306e-03f,
  2.83649296e-01f, 4.19780053e-02f, 1.74318135e-01f, -6.82656392e-02f, -3.00064474e-01f, 2.61561811e-01f, 8.27539563e-02f, -1.43285887e-02f, 1.72291443e-01f, 6.94376230e-02f,
  -3.25535685e-02f, -7.46614933e-02f, 1.77716181e-01f, 1.03405610e-01f, 2.56256443e-02f, 6.59251064e-02f, 5.62687591e-02f, -3.72272611e-01f, 4.36341614e-02f, 3.43561135e-02f,
  1.40219659e-01f, -5.84145784e-02f, 9.94815901e-02f, 1.10417672e-01f, -2.98211873e-02f, 8.45039189e-02f, 1.56155825e-01f, -1.23601139e-01f, 1.20525375e-01f, -7.26051256e-02f,
  2.49772459e-01f, -1.67852063e-02f, -4.73755226e-02f, -1.01531826e-01f, -1.90011468e-02f, -4.25793640e-02f, 1.22345001e-01f, -1.62707046e-01f, -5.22773601e-02f, 1.13659553e-01f,
  1.68041233e-02f, -3.41098942e-02f, -8.76159221e-02f, -4.77239378e-02f, 2.29338825e-01f, -8.02706107e-02f, 8.20546895e-02f, -4.73994315e-02f, 2.75690794e-01f, -1.06698804e-01f,
  -2.82806426e-01f, 7.74727110e-03f, 2.10212871e-01f, 1.11119986e-01f, 9.31337625e-02f, -1.35246307e-01f, -5.69395348e-02f, -5.94771095e-02f, -1.09164082e-01f, 3.89013588e-02f,
  -2.63255350e-02f, -3.37215811e-02f, -1.18959747e-01f, -2.06992198e-02f, 7.00775161e-02f, -8.41486529e-02f, -1.79107618e-02f, -1.78806353e-02f, -3.72324847e-02f, 3.94751504e-02f,
  -1.70817614e-01f, 9.88703445e-02f, 3.17255668e-02f, 1.58204194e-02f, -2.52947789e-02f, -1.75515667e-01f, -5.23004942e-02f, 6.20295852e-02f, -4.63917181e-02f, 1.63793899e-02f,
  4.73016240e-02f, 8.77170563e-02f, 3.09505817e-02f, -4.20069322e-02f, -1.00344885e-02f, 2.85277963e-02f, -3.28902341e-02f, -8.12056586e-02f, 4.80578877e-02f, 3.60005982e-02f,
  -3.78420553e-03f, 7.33594969e-02f, 1.44868076e-01f, 1.87104568e-02f, -8.79073665e-02f, -9.69713461e-03f, -2.62853298e-02f, 6.54630065e-02f, 2.88426857e-02f, -6.59477860e-02f,
  -8.21001977e-02f, -3.54134999e-02f, -1.19705067e-03f, -4.70092744e-02f, -1.15576513e-01f, -1.03136346e-01f, 8.96093771e-02f, 4.66881283e-02f, -9.73628759e-02f, -3.73168034e-03f,
  1.09105833e-01f, 3.34548764e-02f, 1.89070888e-02f, -3.69009674e-02f, 5.24158739e-02f, -4.18968499e-02f, 1.65209889e-01f, -3.52159552e-02f, 1.42137587e-01f, -1.45058572e-01f,
  7.29671344e-02f, 1.57728642e-02f, -9.20189265e-03f, -3.93609852e-02f, -2.75417119e-02f, 9.55523252e-02f, 1.04965456e-01f, 8.18168148e-02f, 1.23052849e-02f, 2.34674737e-01f,
  -9.48403180e-02f, 1.88518390e-01f, -1.09007671e-01f, 1.12061024e-01f, 1.72359981e-02f, 1.28756851e-01f, 1.28878236e-01f, 1.31763905e-01f, -1.57311335e-02f, -7.42084309e-02f,
  -7.64588118e-02f, 4.98579592e-02f, -9.31816474e-02f, 1.06851414e-01f, 7.89364651e-02f, 2.05781072e-01f, 3.35915014e-02f, 1.35478154e-01f, 1.28854930e-01f, 8.88074785e-02f,
  -1.61126837e-01f, -2.02375511e-03f, -1.96208075e-01f, -1.47671159e-02f, -1.37488455e-01f, 1.96884498e-01f, 9.76350009e-02f, 6.41826540e-03f, -1.66444987e-01f, 3.53641324e-02f,
  -6.72160238e-02f, 3.11764255e-02f, -6.28627241e-02f, 8.94175544e-02f, -4.10037376e-02f, 1.79345813e-02f, -6.77561387e-02f, 7.69442553e-03f, 8.66038203e-02f, -7.15872943e-02f,
  4.98039462e-02f, 9.51365829e-02f, 1.56367585e-01f, 1.44592077e-01f, -2.91231006e-01f, -3.01756829e-01f, 5.16873896e-02f, -1.49255306e-01f, 6.53819293e-02f, 7.26988316e-02f,
  8.16201419e-02f, -8.34593624e-02f, -2.99873687e-02f, 9.06948820e-02f, -7.30658844e-02f, 6.65202886e-02f, 2.67297719e-02f, 1.88473277e-02f, 5.83558194e-02f, 3.51789929e-02f,
  4.06772410e-03f, 6.63260696e-03f, 2.99193598e-02f, 3.08430791e-02f, -5.97657822e-02f, 3.91636938e-02f, -1.14401720e-01f, 7.51020834e-02f, 9.17987749e-02f, -2.74459552e-02f,
  5.93519174e-02f, 1.73752364e-02f, 1.24829467e-02f, 7.46446429e-03f, -2.18247976e-02f, 2.30464470e-02f, -7.14259744e-02f, 9.89752542e-03f, -1.34458095e-02f, 7.08793243e-03f,
  6.53052554e-02f, 8.77902508e-02f, 1.68899726e-02f, 8.12934116e-02f, 4.39945497e-02f, -1.04390820e-02f, -7.36870915e-02f, 2.08483264e-01f, -1.31347580e-02f, 1.84123069e-02f,
  3.29541950e-03f, -6.72961771e-02f, 1.04409002e-01f, -4.46652249e-02f, 9.60768163e-02f, -8.28309804e-02f, -8.76066387e-02f, -2.61875317e-02f, 3.19394171e-02f, 4.26189229e-02f,
  -2.30543669e-02f, 4.66261879e-02f, -7.81630203e-02f, 2.01091189e-02f, -1.11682452e-01f, -3.22330892e-02f, 9.00627300e-02f, -8.59742612e-03f, -8.96341726e-02f, -2.75133923e-02f,
  -3.77476774e-02f, -1.04500517e-01f, -9.37833041e-02f, 4.00864258e-02f, -1.03398331e-01f, -5.62788360e-02f, 1.44991338e-01f, 3.57864983e-02f, -1.63310803e-02f, 4.70194872e-03f,
  1.05238006e-01f, 2.00465918e-01f, 4.78945225e-02f, -7.93248862e-02f, -1.47133414e-02f, -8.29284191e-02f, 3.43802497e-02f, 2.29673181e-02f, 9.81282666e-02f, -8.36120918e-02f,
  1.61238179e-01f, 1.17941394e-01f, -3.79432514e-02f, 1.06102727e-01f, 7.75281489e-02f, -6.07727990e-02f, 1.40953343e-02f, 1.00509748e-01f, 1.07018203e-01f, -1.81686282e-01f,
  -9.82106403e-02f, -7.98310712e-02f, -1.22295007e-01f, -2.16104537e-02f, -7.41004199e-02f, 2.27328278e-02f, 3.32603377e-04f, -3.28642242e-02f, 4.48140837e-02f, 1.30667565e-02f,
  1.44257590e-01f, 1.15066335e-01f, 1.06440164e-01f, -1.41990399e-02f, 4.07647751e-02f, -2.31992025e-02f, -2.68986868e-03f, -1.04066826e-01f, 2.16127187e-03f, 1.50372952e-01f,
  6.77359775e-02f, 1.75955132e-01f, 6.45831600e-02f, -3.11248116e-02f, 1.61437005e-01f, 1.77268088e-01f, -3.76298875e-02f, 6.77831545e-02f, -1.85605157e-02f, -4.65027429e-02f,
  -2.51904607e-01f, -1.76650044e-02f, -2.25096270e-01f, -9.46565252e-03f, -1.39193431e-01f, -6.72674999e-02f, -2.85392463e-01f, -1.48644403e-01f, -6.19269758e-02f, -1.16339326e-01f,
  -8.23707506e-02f, 1.76517516e-01f, -4.76493500e-02f, 4.33606543e-02f, 3.51843536e-02f, -1.03008367e-01f, 5.05255237e-02f, 1.83181819e-02f, 4.57240231e-02f, -1.32166609e-01f,
  -7.45826587e-02f, -9.38680209e-03f, -4.37002257e-02f, 5.27311601e-02f, -7.70877972e-02f, 4.50272858e-03f, 1.40985334e-02f, -4.52557430e-02f, 2.41751615e-02f, -9.93578695e-03f,
  -9.34124961e-02f, 1.91214960e-02f, -2.90136207e-02f, -8.01957995e-02f, 7.17206746e-02f, -9.86260734e-03f, 4.25114706e-02f, 4.50598039e-02f, -1.01296887e-01f, 3.01127904e-03f,
  -5.51018193e-02f, 2.32995655e-02f, 6.54864758e-02f, -7.92637914e-02f, -6.38602907e-03f, 1.67578168e-03f, -1.28299464e-02f, -2.96524186e-02f, -3.04375496e-02f, 7.18880743e-02f,
  -3.42130512e-02f, -2.89582950e-03f, 5.84978461e-02f, -9.82531309e-02f, -3.97312716e-02f, 4.31485176e-02f, 5.91347329e-02f, 3.07027195e-02f, 7.83411488e-02f, 4.28776778e-02f,
  1.13493642e-02f, -7.20184147e-02f, 2.32022516e-02f, -9.89270583e-02f, 1.31543234e-01f, 7.36950934e-02f, -1.71864688e-01f, -3.63692269e-02f, -3.71048413e-02f, -1.51197061e-01f,
  3.03016100e-02f, 9.62818339e-02f, -1.51193351e-01f, -1.02106169e-01f, -1.47984356e-01f, 1.30376607e-01f, -1.47930637e-01f, 1.71332911e-01f, -6.86140135e-02f, -7.32261315e-02f,
  9.45461318e-02f, -8.27344805e-02f, -8.22637752e-02f, 1.19487308e-01f, 1.18994445e-01f, -1.54208317e-01f, 1.81375906e-01f, -1.51488513e-01f, -2.12732598e-01f, -5.62415496e-02f,
  -1.26660228e-01f, -1.22343168e-01f, 6.38846382e-02f, -9.30120796e-02f, 8.64635408e-02f, 1.01465911e-01f, 2.13002950e-01f, -1.72464363e-02f, 5.23456968e-02f, 1.33481637e-01f,
  3.18361609e-03f, -1.85465857e-01f, 1.76701937e-02f, -6.87920526e-02f, -3.50667387e-02f, -2.52811331e-03f, -8.28505506e-07f, 1.30003497e-01f, 6.66943863e-02f, 1.00830659e-01f,
  1.53204799e-01f, -1.21161491e-01f, 9.22199786e-02f, -6.41242936e-02f, 1.56385615e-01f, -7.80646205e-02f, 9.96710956e-02f, 9.05078277e-02f, 5.13890944e-02f, 1.85816392e-01f,
  9.99228749e-03f, -1.38146535e-01f, 3.37424427e-02f, 1.18349649e-01f, 2.19197758e-03f, 1.64074689e-01f, -1.15716867e-01f, -1.32296607e-01f, -6.99706003e-02f, 9.55418404e-03f,
  8.92395005e-02f, 1.62892446e-01f, 1.19928099e-01f, -7.13221729e-02f, -2.01803029e-01f, -8.86075348e-02f, -1.77577496e-01f, 1.34780500e-02f, -4.31064777e-02f, 1.20569862e-01f,
  2.68600732e-02f, -3.19542363e-02f, -1.87223591e-02f, 2.05782488e-01f, 1.32848201e-02f, 9.03853625e-02f, 1.19713344e-01f, -5.04418351e-02f, -1.59158200e-01f, 1.36824876e-01f,
  8.24091882e-02f, -1.18393321e-02f, -2.63249055e-02f, 2.52265513e-01f, -8.70504975e-02f, 4.52060699e-02f, -2.80648703e-03f, -1.54493023e-02f, 1.29752621e-01f, -4.74787168e-02f,
  3.54145207e-02f, -1.02697410e-01f, 7.96436593e-02f, 1.14631340e-01f, -3.31644081e-02f, 3.25714834e-02f, 3.30738798e-02f, 1.57982111e-01f, -3.43517140e-02f, 7.67167881e-02f,
  6.92211613e-02f, 2.89906864e-03f, -1.23320306e-02f, -4.58927304e-02f, -1.16504326e-01f, 2.23026387e-02f, 2.31175534e-02f, 1.17041850e-02f, -2.28556581e-02f, -1.46681502e-01f,
  7.93447345e-02f, -3.25467624e-02f, -1.14684068e-01f, 8.94607082e-02f, -2.30983067e-02f, 1.31915733e-02f, -1.98362783e-01f, 8.31616446e-02f, 1.22476660e-01f, 9.55377966e-02f,
  -8.49775523e-02f, 4.53685820e-02f, 4.91053704e-03f, 1.66330840e-02f, -2.34669074e-01f, -1.08019933e-01f, -8.51076543e-02f, -5.33197001e-02f, 1.37860924e-01f, 2.61782631e-02f,
  -2.59927303e-01f, 1.24585547e-01f, -4.04748544e-02f, 8.22104688e-04f, -1.02293000e-01f, 3.08296401e-02f, -4.35586274e-02f, -9.36399177e-02f, 1.68290004e-01f, -1.20695852e-01f,
  2.03993879e-02f, -6.50224388e-02f, -8.98994282e-02f, 5.94124235e-02f, 2.09942967e-01f, -1.77342698e-01f, -1.94288075e-01f, -2.62087118e-02f, -1.68279648e-01f, 2.28970852e-02f,
  6.06378578e-02f, 5.36730066e-02f, 2.49050260e-02f, 1.49453320e-02f, 2.21793056e-01f, -4.03251220e-03f, 7.36256614e-02f, -1.91865623e-01f, -2.43002430e-01f, -2.44733229e-01f,
  5.98115213e-02f, 6.79674000e-02f, 2.68232618e-02f, -3.75347794e-03f, 8.50714147e-02f, 1.79321125e-01f, 5.68890646e-02f, -6.14332557e-02f, 1.18891388e-01f, -8.38433728e-02f,
  8.46993849e-02f, 1.63031891e-01f, 1.91335574e-01f, -1.64672032e-01f, 6.23373613e-02f, -9.56181884e-02f, -1.03797829e-02f, -5.21933213e-02f, 8.41585845e-02f, -2.84982752e-02f,
  2.39364773e-01f, 2.52141863e-01f, -9.71070826e-02f, 1.35033384e-01f, -5.48431054e-02f, -2.77922228e-02f, -2.36047041e-02f, -1.14316136e-01f, 3.81988026e-02f, 2.40012437e-01f,
  2.33829230e-01f, 1.02058081e-02f, -1.02116622e-01f, -1.54658124e-01f, 6.19266322e-03f, 2.03959309e-02f, 1.36015654e-01f, -1.13843032e-03f, 3.66428420e-02f, -3.17393392e-02f,
  9.00509879e-02f, -2.76057515e-02f, -9.70367994e-03f, -1.17193848e-01f, 5.61529472e-02f, 1.15458146e-01f, 1.83650088e-02f, 5.54006249e-02f, 2.20010169e-02f, -4.30097654e-02f,
  2.04679929e-02f, 1.79448090e-02f, 1.23722747e-01f, -1.09812780e-03f, 3.40917446e-02f, 7.12122396e-02f, 8.45477358e-03f, -9.08469632e-02f, 3.70209850e-02f, -8.95740464e-02f,
  -1.22320298e-02f, 1.31473780e-01f, -5.42650186e-02f, 4.02278267e-02f, 3.50367129e-02f, 3.61987054e-02f, 8.54707062e-02f, 6.58191442e-02f, 9.52102840e-02f, 1.00344896e-01f,
  1.22905634e-01f, 1.16847092e-02f, -3.32528283e-03f, -4.35314514e-02f, -4.87974249e-02f, -1.06731281e-01f, -7.06274360e-02f, 5.08540608e-02f, -8.04593563e-02f, -2.11899616e-02f,
  4.47015576e-02f, 9.51569453e-02f, -3.55756655e-02f, -5.66701926e-02f, -7.71211041e-03f, -1.04502432e-01f, -1.20105959e-01f, 1.56042933e-01f, -1.91695429e-02f, -5.69480918e-02f,
  5.45177534e-02f, 8.91282503e-03f, 1.50494456e-01f, -3.76192480e-02f, -1.09021030e-02f, 1.92132086e-01f, -1.71544313e-01f, 5.44145145e-02f, 8.48241225e-02f, 3.82642895e-02f,
  -1.24147795e-01f, 4.29733135e-02f, 1.80654719e-01f, -8.50236267e-02f, 1.75411273e-02f, -7.39085302e-02f, -1.04404286e-01f, -7.67551661e-02f, 5.65317720e-02f, -1.11693405e-01f,
  -1.91516371e-03f, 6.53190762e-02f, -6.05143271e-02f, -8.77329856e-02f, -4.19846997e-02f, -3.15599516e-02f, 1.34676218e-01f, 3.35246585e-02f, 6.27677655e-03f, 4.14226530e-03f,
  1.53748784e-02f, -7.04348385e-02f, -1.13355972e-01f, 5.11832237e-02f, 1.75352301e-03f, -1.74944341e-01f, 4.97749709e-02f, -9.13358927e-02f, 5.63876182e-02f, 6.47319332e-02f,
  -4.16569449e-02f, 2.84474250e-02f, -4.60145921e-02f, 6.21106252e-02f, 6.70417547e-02f, 1.77829564e-01f, 1.75396830e-01f, -8.99200980e-03f, -2.29607373e-02f, -8.59896615e-02f,
  -1.08333446e-01f, -4.98485565e-02f, -1.27774421e-02f, -5.54338880e-02f, -9.46047530e-02f, -5.59563413e-02f, -2.05263704e-01f, -2.24868685e-01f, -1.60447303e-02f, -1.15035325e-01f,
  -1.37896076e-01f, 7.01281726e-02f, 1.19036242e-01f, -1.87461391e-01f, 7.59082362e-02f, -7.59925768e-02f, 1.45259857e-01f, 3.69218051e-01f, 1.27592340e-01f, -6.87456131e-02f,
  6.92099929e-02f, -5.34339733e-02f, 2.22360671e-01f, -5.77866174e-02f, -7.54821599e-02f, -2.35275447e-01f, 1.01242932e-02f, 3.13951448e-02f, -6.85983449e-02f, 6.02959879e-02f,
  -1.98953412e-02f, -1.44841135e-01f, 1.02660090e-01f, -4.77223890e-03f, -3.86036299e-02f, -4.56935838e-02f, 1.32865503e-01f, 1.09313935e-01f, 7.24407434e-02f, 1.08742245e-01f,
  -3.69801186e-02f, -9.84985009e-03f, 3.79883833e-02f, -8.96143392e-02f, 3.82249281e-02f, 1.60172135e-01f, -1.39487246e-02f, -6.08254671e-02f, -3.71056534e-02f, -6.03248784e-03f,
  8.07850957e-02f, -2.87906397e-02f, -1.05832994e-01f, -3.85318808e-02f, -1.82251893e-02f, -9.11098346e-03f, -7.52457790e-03f, -8.36880505e-03f, 1.43843573e-02f, 1.34260386e-01f,
  -2.32928675e-02f, 7.43802115e-02f, 9.35409889e-02f, 5.08813523e-02f, 1.63106024e-01f, -7.06806825e-03f, 9.28957462e-02f, -1.84832066e-01f, 1.46710873e-01f, 6.18920326e-02f,
  1.18719071e-01f, 1.04088187e-02f, 9.99366678e-03f, -5.13858572e-02f, 1.25931025e-01f, 8.37356746e-02f, -1.15655035e-01f, -1.13470636e-01f, -4.26597223e-02f, 1.72396488e-02f,
  -9.76488963e-02f, 4.40553427e-02f, -2.01114342e-02f, 5.56710027e-02f, 5.49819991e-02f, -1.66988268e-01f, -2.30128262e-02f, 4.16241251e-02f, 6.69101402e-02f, 4.58249301e-02f,
  2.44965740e-02f, -1.59996673e-01f, -7.40309358e-02f, 1.07582621e-01f, 2.67455373e-02f, 1.54250056e-01f, 3.77700031e-02f, -5.13223521e-02f, 8.76217335e-03f, 8.40773210e-02f,
  5.89436106e-02f, 7.14846030e-02f, -1.10060029e-01f, 2.34367922e-01f, 7.00979307e-02f, 4.11474742e-02f, -1.09523616e-03f, 6.46151602e-02f, 2.91604493e-02f, -1.18845580e-02f,
  6.01489618e-02f, -6.79349806e-03f, 9.02031586e-02f, 6.77403361e-02f, -1.70262575e-01f, -1.68540508e-01f, 2.48621739e-02f, 1.52486607e-01f, -3.48550975e-02f, -1.52835950e-01f,
  -4.47899848e-02f, 1.97168011e-02f, 1.81513838e-02f, 2.07759038e-01f, -1.83490679e-01f, -8.83911029e-02f, 2.35470738e-02f, 1.33541925e-02f, 4.87178527e-02f, -1.52988970e-01f,
  -4.87086400e-02f, -1.19128071e-01f, -3.41946632e-02f, 1.00540802e-01f, 6.70113340e-02f, -6.77214488e-02f, 1.85917333e-01f, 2.21925512e-01f, 4.50600907e-02f, -9.26938951e-02f,
  4.47216034e-02f, -1.96840182e-01f, 4.57857316e-03f, -6.92808479e-02f, -6.02565110e-02f, -1.28671005e-01f, -1.81740046e-01f, 5.40280230e-02f, -2.89799362e-01f, 1.14054918e-01f,
  5.26104420e-02f, 3.17229033e-01f, 2.63937205e-01f, 1.93673931e-02f, 2.99195834e-02f, -1.12831534e-03f, 1.21443234e-02f, -8.33845437e-02f, 3.30961426e-03f, -3.92190628e-02f,
  2.48256475e-02f, 5.03040589e-02f, 5.92590533e-02f, -3.90767790e-02f, -2.81133200e-03f, 8.99889469e-02f, 5.56167625e-02f, -4.73803207e-02f, 3.25443782e-02f, 1.72002949e-02f,
  3.58586051e-02f, -1.90833374e-03f, 5.28539680e-02f, 8.29941630e-02f, -4.52776887e-02f, -1.34579074e-02f, 1.34058729e-01f, -2.70261373e-02f, 3.01992167e-02f, -1.41757995e-01f,
  1.96296582e-03f, 5.50783351e-02f, -3.16503607e-02f, 1.62341520e-02f, 1.64203197e-01f, -2.10358743e-02f, -8.67720414e-03f, -3.34141776e-02f, 6.22289516e-02f, -1.62180662e-02f,
  -8.98858008e-04f, 1.02724783e-01f, -1.22787155e-01f, -4.52743433e-02f, -5.72155714e-02f, -8.64295848e-03f, -1.52386073e-02f, 7.16272444e-02f, 8.77938978e-03f, -4.07835357e-02f,
  -3.49117741e-02f, 7.87285790e-02f, 5.67568541e-02f, 7.37421736e-02f, 9.82217714e-02f, 1.03397124e-01f, -1.37535036e-01f, 6.81896554e-03f, 8.40866491e-02f, 6.75074235e-02f,
  -1.17675178e-01f, -3.69650573e-02f, 4.04560603e-02f, -1.07646165e-02f, 3.10938861e-02f, -1.78801231e-02f, -1.42242849e-01f, -1.42378330e-01f, 1.80147007e-01f, -1.00450367e-01f,
  -7.47382119e-02f, -1.10668041e-01f, -4.26076986e-02f, 1.06563792e-02f, 9.00679007e-02f, -3.48349139e-02f, -1.40776381e-01f, -5.34605719e-02f, -1.58001445e-02f, 5.31998798e-02f,
  1.36665151e-01f, -5.61740175e-02f, 5.95726594e-02f, -6.24145307e-02f, -2.65952311e-02f, 6.13862760e-02f, -7.26469234e-02f, -1.74544808e-02f, -1.05492383e-01f, 2.65288563e-03f,
  -5.14895096e-02f, -8.97087455e-02f, -1.02804720e-01f, 4.79984358e-02f, -9.29560736e-02f, -2.49113198e-02f, -2.83432729e-03f, 1.42374381e-01f, 4.40470949e-02f, -9.71033573e-02f,
  -3.49124186e-02f, -2.40203321e-01f, -9.29172188e-02f, 1.05205506e-01f, 7.93848559e-02f, 7.11456686e-02f, -2.13663187e-02f, 1.58290695e-02f, -1.20902121e-01f, -1.05966054e-01f,
  -4.10995595e-02f, 1.06584840e-02f, -1.52602524e-01f, -3.41961905e-02f, 1.72736421e-01f, -2.43750408e-01f, 1.72257293e-02f, -4.62916940e-02f, 9.19596106e-02f, -4.31106016e-02f,
  5.13056181e-02f, 1.21978959e-02f, 2.01932162e-01f, 9.03869644e-02f, 1.08312815e-01f, -1.36491179e-01f, 2.16320515e-01f, 5.76191023e-03f, 2.79854946e-02f, -1.67253152e-01f,
  -2.40555909e-02f, -2.47348309e-01f, -3.36049646e-02f, 4.35580574e-02f, 7.98794478e-02f, -9.79619939e-03f, 3.04761175e-02f, -3.69441099e-02f, -1.13401301e-01f, -1.04511432e-01f,
  -2.06916198e-01f, -3.87788825e-02f, -7.74357170e-02f, -8.84895772e-02f, -1.33142084e-01f, 7.12903589e-02f, 1.84407234e-02f, -8.05941001e-02f, -7.87501037e-02f, -4.59206328e-02f,
  1.52299376e-02f, -1.57521054e-01f, -3.33253890e-02f, -1.33954324e-02f, 6.31625652e-02f, 2.64472589e-02f, -4.81192432e-02f, -4.33213636e-03f, 3.96685600e-02f, 5.98684959e-02f,
  -8.11473429e-02f, -4.19604369e-02f, -5.05067408e-02f, 7.98946545e-02f, 4.26237732e-02f, 2.17752196e-02f, 3.88611779e-02f, -4.71282899e-02f, 2.36964133e-03f, -7.91241676e-02f,
  -2.63420288e-02f, -4.89605777e-02f, -1.82669573e-02f, -1.30575404e-01f, 1.00855350e-01f, -2.06227228e-01f, -6.40586168e-02f, -7.46185407e-02f, 8.74070451e-02f, -1.27780631e-01f,
  -9.85278711e-02f, -4.41885293e-02f, -5.23999613e-03f, -2.93575320e-02f, 5.51067218e-02f, -3.91280763e-02f, -1.48830444e-01f, -7.49594271e-02f, 4.19567376e-02f, -1.08008653e-01f,
  4.91880924e-02f, 4.23173867e-02f, -1.45151734e-01f, -4.10421900e-02f, 5.01977876e-02f, 4.04474325e-02f, -6.68533146e-03f, 7.76711926e-02f, 1.11492328e-01f, 6.23094663e-02f,
  -1.67406276e-02f, 3.97576429e-02f, 1.91680416e-02f, -5.58867380e-02f, 1.13729879e-01f, -1.07555790e-02f, 1.25744015e-01f, 1.15030460e-01f, -2.88078375e-02f, -1.63179219e-01f,
  3.69883999e-02f, -7.23660216e-02f, 4.29039747e-02f, -8.92442390e-02f, 1.05997600e-01f, -1.35665350e-02f, -2.63744146e-02f, -6.08965084e-02f, -4.40381579e-02f, 9.68527496e-02f,
  -2.84343958e-02f, -1.09841406e-01f, 5.29709272e-02f, 1.06370738e-02f, 8.24654028e-02f, 1.97824482e-02f, -2.09842585e-02f, -4.89649028e-02f, 8.74222964e-02f, 1.25416249e-01f,
  1.04059041e-01f, -4.92292084e-02f, -4.86889249e-03f, -2.62336563e-02f, 1.07100055e-01f, -3.98310348e-02f, 1.97575480e-01f, 1.95619911e-01f, 3.62743251e-02f, 3.92621346e-02f,
  2.14275509e-01f, -4.15647142e-02f, 1.56968608e-02f, 4.44721505e-02f, -4.08750474e-02f, -2.46625300e-02f, -7.22950399e-02f, 8.32624082e-03f, -2.26444855e-01f, -4.89539094e-02f,
  -9.72477440e-03f, -1.37186140e-01f, -3.84476073e-02f, 2.16691643e-02f, -2.23401874e-01f, -7.68195316e-02f, -1.50285110e-01f, 1.15691856e-01f, -2.29722500e-01f, 2.45729730e-01f,
  2.42200587e-02f, 9.45410319e-03f, -3.17192040e-02f, -4.75257933e-02f, -2.70547718e-02f, 1.13076061e-01f, 1.21177785e-01f, 4.58436273e-02f, -6.44389167e-02f, -1.25450283e-01f,
  -3.58989127e-02f, -9.18056518e-02f, 4.84518744e-02f, 1.34768769e-01f, -1.50885116e-02f, 3.57989445e-02f, 5.88864870e-02f, 5.01735508e-02f, -1.15398038e-03f, -7.73901045e-02f,
  -6.08393140e-02f, 1.44367024e-01f, 1.28189534e-01f, 2.05884892e-02f, -6.87694252e-02f, 1.30571546e-02f, -1.84825975e-02f, 5.88717498e-02f, 8.60340055e-03f, 3.85402739e-02f,
  -6.21480541e-03f, -3.77110206e-02f, -8.12399313e-02f, 2.58130357e-02f, 7.43257478e-02f, 4.90541868e-02f, -1.14560686e-01f, 1.29145354e-01f, 2.57257130e-02f, -6.33896217e-02f,
  -1.14906184e-01f, -9.63131140e-04f, -7.96076134e-02f, 1.02604568e-01f, 1.64020136e-02f, -5.18267639e-02f, 6.13762625e-02f, 1.04900032e-01f, 3.33384089e-02f, 2.19341330e-02f,
  1.58464134e-01f, -1.05203852e-01f, -6.05020672e-02f, 7.86694218e-05f, 9.52002220e-03f, 4.93352152e-02f, 8.00898578e-03f, 1.71330541e-01f, -1.82665825e-01f, 1.40735298e-01f,
  2.20430702e-01f, -8.72967765e-02f, 5.75731741e-03f, -2.54228801e-01f, -4.42651547e-02f, -9.75205004e-02f, -1.19224600e-01f, -7.71996826e-02f, 4.61514108e-02f, -4.75068055e-02f,
  2.50566639e-02f, -1.10343366e-03f, -3.19011927e-01f, 4.03540023e-02f, -9.07979682e-02f, -6.96432730e-03f, 4.77239154e-02f, -2.03087613e-01f, -3.59017476e-02f, -4.58694957e-02f,
  5.05470857e-02f, 3.62919867e-02f, -1.01151846e-01f, 1.57780766e-01f, 1.59233347e-01f, -2.42685135e-02f, -7.83071890e-02f, -2.19017044e-01f, -6.87141642e-02f, 1.86701864e-01f,
  1.05671309e-01f, 2.27726679e-02f, -1.36516571e-01f, 1.70927180e-03f, 5.81734106e-02f, 4.94826511e-02f, -1.22756317e-01f, -1.81443453e-01f, -7.24226907e-02f, -6.62520677e-02f,
  -1.01975448e-01f, 1.31890103e-01f, -8.25194046e-02f, -1.73378825e-01f, -7.51218498e-02f, -7.68825179e-03f, 3.65871303e-02f, -3.51195633e-02f, 3.97331081e-03f, 3.04352660e-02f,
  5.24851568e-02f, 2.30605036e-01f, -1.58583820e-01f, 1.58952594e-01f, -1.39419079e-01f, -3.38222645e-02f, 1.73990354e-01f, 1.04705945e-01f, 4.58876640e-02f, 1.07786879e-01f,
  1.21860683e-01f, -1.47586763e-01f, 2.06437334e-01f, -4.62425798e-02f, 3.96157131e-02f, -1.80377185e-01f, -1.20311283e-01f, -1.58179209e-01f, 1.12546854e-01f, -1.29035592e-01f,
  2.11999621e-02f, 9.42511111e-02f, 1.01486102e-01f, 5.78002520e-02f, 5.49110696e-02f, 8.08263868e-02f, -1.28480807e-01f, -1.29939333e-01f, 2.64531411e-02f, 9.50669646e-02f,
  -7.77212828e-02f, 8.83206204e-02f, 1.57840997e-02f, -9.92659777e-02f, -3.91734811e-03f, -5.04930466e-02f, 1.57816336e-01f, 1.43376976e-01f, -6.63605779e-02f, 3.68431993e-02f,
  9.75072905e-02f, 2.97876876e-02f, 3.56047088e-03f, 1.98389869e-02f, 3.93614918e-02f, 1.22326456e-01f, 1.53336888e-02f, -5.17021418e-02f, 2.03051507e-01f, -2.51022819e-03f,
  5.21195494e-02f, -3.78477317e-03f, 8.56181756e-02f, 2.85359807e-02f, -1.27803177e-01f, -3.65294851e-02f, -4.69263718e-02f, 1.29463404e-01f, -1.13680579e-01f, -5.80619872e-02f,
  3.71136703e-02f, 2.74417400e-02f, -9.77512076e-02f, -1.85560808e-02f, -1.50838709e-02f, -1.12466291e-02f, -4.46357243e-02f, 1.48557663e-01f, -3.05132177e-02f, 6.14153668e-02f,
  -1.14898376e-01f, 2.34082062e-02f, -4.22252305e-02f, 6.12750016e-02f, -8.85798857e-02f, -6.69060573e-02f, 7.12386891e-02f, 9.80383456e-02f, -6.35208115e-02f, 4.76155840e-02f,
  1.76564399e-02f, 9.77752805e-02f, 5.14227413e-02f, -1.24242313e-01f, -5.10971136e-02f, 6.24292865e-02f, 1.11527681e-01f, 1.33011527e-02f, 4.33234591e-03f, -1.04060307e-01f,
  -9.24613476e-02f, -2.49759164e-02f, 5.76541722e-02f, -1.40157983e-01f, 9.54993591e-02f, -1.12566777e-01f, 1.63324997e-01f, -1.49555415e-01f, -1.55896455e-01f, -8.92686769e-02f,
  3.56084444e-02f, -1.47242192e-03f, 1.51333988e-01f, -4.90668677e-02f, 1.02005983e-02f, -2.35318854e-01f, -1.47885740e-01f, -1.39064817e-02f, -2.15225164e-02f, -9.55294743e-02f,
  -8.99431929e-02f, 8.03831667e-02f, 3.51014026e-02f, 3.89641188e-02f, 1.05130859e-01f, -8.51991400e-02f, -6.66373968e-02f, -9.09312144e-02f, 6.27611801e-02f, 1.30308613e-01f,
  1.08206354e-01f, 5.05344905e-02f, -1.94869179e-03f, -6.09539337e-02f, -9.47287530e-02f, -3.33480567e-01f, -9.35300589e-02f, -3.03761959e-02f, 1.39600664e-01f, -1.03753515e-01f,
  3.80023867e-02f, 9.88936499e-02f, 6.22636862e-02f, -2.58028158e-03f, 1.78242885e-02f, -3.76647823e-02f, 1.70703396e-01f, 1.23255208e-01f, 1.52383432e-01f, 7.21661970e-02f,
  1.91518247e-01f, 1.13631085e-01f, -7.30373040e-02f, -7.49814734e-02f, 1.96291953e-02f, -2.79094994e-01f, 1.12786153e-02f, 2.06202250e-02f, 2.33823750e-02f, -5.15720993e-02f,
  -3.24678570e-02f, -8.92928690e-02f, 7.45971724e-02f, -1.73975192e-02f, 1.17011718e-03f, 2.70155035e-02f, 4.86048013e-02f, 1.96835864e-02f, 1.06128231e-01f, -7.53769651e-02f,
  -1.43540613e-02f, 6.52849004e-02f, 7.92782232e-02f, 6.93704411e-02f, 4.82167713e-02f, 4.03175987e-02f, 1.94043517e-02f, -4.47246991e-02f, 1.05880341e-02f, -9.29930480e-04f,
  -2.22795829e-02f, -5.19401915e-02f, -4.71937060e-02f, -3.47391181e-02f, -9.87642109e-02f, 4.04038355e-02f, -3.08692139e-02f, -1.50459185e-01f, -7.36021921e-02f, -1.05936393e-01f,
  -5.75661100e-03f, -7.26598948e-02f, -1.46081438e-02f, -9.04542021e-03f, -2.95107123e-02f, -5.86324781e-02f, -1.15466677e-01f, 8.20051581e-02f, -4.07448374e-02f, -1.00760311e-01f,
  9.29087251e-02f, -9.47020482e-03f, -4.33494337e-02f, -2.60843690e-02f, -3.45799476e-02f, 1.28399894e-01f, 1.02991030e-01f, -1.27182245e-01f, -7.59863257e-02f, 2.94455886e-02f,
  2.33192611e-02f, -2.90939938e-02f, 1.27439927e-02f, 5.54181300e-02f, -3.35242450e-02f, -1.00298479e-01f, 1.20474882e-01f, -4.72178161e-02f, -2.06337478e-02f, -1.07314661e-01f,
  -6.25697151e-02f, -6.52271733e-02f, -3.16772051e-02f, 4.22573201e-02f, 1.27922685e-03f, 6.82357177e-02f, 9.99594666e-03f, 8.96193683e-02f, -1.82572752e-01f, 1.12141497e-01f,
  -3.36046107e-02f, 1.61547855e-01f, 4.32067998e-02f, 1.22850701e-01f, 2.14287210e-02f, -3.79455090e-02f, -2.75548529e-02f, 6.93954304e-02f, 1.83157288e-02f, 6.18392080e-02f,
  -1.23193868e-01f, 4.67787124e-02f, -2.37515364e-02f, 9.06742141e-02f, -1.05892075e-02f, 1.16641782e-01f, 3.71692963e-02f, -8.06301311e-02f, -3.46005894e-02f, -2.74540670e-02f,
  4.15383615e-02f, -3.08943372e-02f, -6.08529672e-02f, -2.53135450e-02f, -1.26719415e-01f, 2.66564459e-01f, 1.06609061e-01f, -2.81556770e-02f, -1.49181992e-01f, 1.17564760e-01f,
  1.32983336e-02f, -1.19111389e-01f, 4.52201217e-02f, 5.15029859e-03f, 2.61824150e-02f, -1.89985074e-02f, -3.92120853e-02f, -2.48327293e-02f, -3.36019844e-02f, -1.15052154e-02f,
  1.78755343e-01f, 3.95120792e-02f, 1.11012027e-01f, -1.52808158e-02f, 3.20287682e-02f, -2.60087345e-02f, -1.32367730e-01f, -1.34325763e-02f, 8.17860812e-02f, 3.40736210e-02f,
  2.53986835e-01f, -1.64378747e-01f, -7.09881783e-02f, 2.05885470e-02f, 2.17789169e-02f, 3.16069648e-02f, -8.46446678e-03f, -1.27359033e-01f, 1.53057296e-02f, 4.20150422e-02f,
  1.21955119e-01f, 6.19898587e-02f, -3.87102307e-04f, -9.60106105e-02f, -2.10537529e-03f, -1.44522171e-02f, -1.43437693e-02f, 8.41493756e-02f, 1.56842873e-01f, -4.77462076e-03f,
  3.58216241e-02f, 5.17148301e-02f, -1.08029395e-02f, -1.45718167e-02f, -2.23470293e-02f, 2.83066742e-03f, -1.63164362e-02f, -7.57433772e-02f, 3.17524001e-02f, -1.68411642e-01f,
  2.90274285e-02f, -1.16937101e-01f, 1.19425975e-01f, -7.49448463e-02f, 1.26610532e-01f, -4.66842353e-02f, -7.37333065e-03f, -6.67998642e-02f, -4.54032645e-02f, -6.95722997e-02f,
  -8.89124125e-02f, -5.95905744e-02f, -5.08046001e-02f, -5.94759174e-03f, -8.42007250e-02f, -6.56842366e-02f, -1.11710586e-01f, 5.69179878e-02f, -1.70077682e-02f, 1.96996201e-02f,
  -2.40019872e-03f, -8.26243684e-02f, -6.62600547e-02f, -4.24127188e-03f, 5.19974679e-02f, -4.84782010e-02f, 2.23864485e-02f, -5.66900000e-02f, 5.41858934e-02f, 1.11207195e-01f,
  1.06415138e-01f, 9.28637460e-02f, -1.67035267e-01f, 2.03024879e-01f, -2.58294418e-02f, -2.62155719e-02f, -1.06885120e-01f, 1.27822876e-01f, 8.03198665e-02f, -3.74138542e-02f,
  -4.12933975e-02f, -3.93409804e-02f, 4.33606915e-02f, -8.52277577e-02f, -5.61003722e-02f, -4.33588326e-02f, 3.27536874e-02f, -1.11292293e-02f, 6.86438568e-03f, -4.98829558e-02f,
  -1.75782330e-02f, 1.23691354e-02f, 6.00111559e-02f, -1.56280145e-01f, 1.18847139e-01f, 7.89260715e-02f, 7.13637844e-03f, 7.24022463e-02f, 1.15333110e-01f, 1.18282109e-01f,
  -6.34208918e-02f, -1.17527224e-01f, -3.73683199e-02f, 1.08610824e-01f, 6.37039542e-02f, 1.39179779e-02f, -4.05541360e-02f, 3.17168981e-03f, 4.06811871e-02f, -5.08226678e-02f,
  -1.17283715e-02f, 4.61890958e-02f, 5.50852828e-02f, -6.57003447e-02f, 6.54884353e-02f, -7.66266789e-03f, -7.68386126e-02f, -7.71881714e-02f, -1.38982341e-01f, -1.18495330e-01f,
  -6.87276423e-02f, -2.23075718e-01f, -2.41438970e-02f, -2.20369771e-02f, -6.91287294e-02f, 4.41226587e-02f, -1.69450164e-01f, 1.97766647e-01f, -1.24159105e-01f, 1.24977745e-01f,
  9.26228985e-02f, 1.35303706e-01f, -7.32480586e-02f, 2.53347248e-01f, 1.43885344e-01f, -6.50542378e-02f, 8.29679072e-02f, -5.27213737e-02f, 1.75624251e-01f, -2.30406851e-01f,
  -5.30354455e-02f, -1.01746865e-01f, 4.70955633e-02f, -3.65033969e-02f, 1.00781910e-01f, 6.12729490e-02f, 6.58473894e-02f, -1.95778664e-02f, 6.53485022e-03f, -1.39414638e-01f,
  -2.01748982e-01f, -1.06749527e-01f, -4.90165642e-03f, -5.72767481e-02f, 4.48008766e-03f, 7.02376850e-03f, -9.48368460e-02f, 1.48255602e-02f, 1.26423463e-02f, -4.83754687e-02f,
  5.08240871e-02f, 5.23245223e-02f, -1.36364371e-01f, 4.92072664e-02f, 8.24479461e-02f, 3.90280108e-03f, 4.42912467e-02f, 8.20715073e-03f, 5.58717847e-02f, 3.38954106e-02f,
  7.34130368e-02f, 9.97837540e-03f, -3.99137326e-02f, 8.10940377e-03f, 1.08185679e-01f, 1.77157223e-01f, 5.05121090e-02f, -4.99932505e-02f, 5.18359616e-02f, 3.16218249e-02f,
  -5.82684353e-02f, 5.22046573e-02f, 7.58293122e-02f, -3.88222225e-02f, -1.32166848e-01f, -5.43857701e-02f, -1.40915841e-01f, -4.23785150e-02f, 5.06583266e-02f, -6.19935244e-02f,
  -6.89857528e-02f, -7.56353587e-02f, -1.07511859e-02f, -6.79498166e-02f, 1.41385451e-01f, -7.29272217e-02f, -1.66521788e-01f, -5.84078394e-02f, -7.29602277e-02f, -4.20142226e-02f,
  -4.52634729e-02f, 8.24944749e-02f, -1.40406072e-01f, -9.85348076e-02f, -2.90318877e-02f, 1.10459760e-01f, -1.15577228e-01f, 1.34909838e-01f, -1.97100341e-01f, 4.79029976e-02f,
  1.12002544e-01f, 6.32612333e-02f, -4.12693880e-02f, 9.45757255e-02f, 2.26533681e-01f, -5.32732420e-02f, 1.49342373e-01f, 1.26048744e-01f, -1.54899925e-01f, -1.59989685e-01f,
  -3.13756987e-03f, -1.08529583e-01f, 6.22199327e-02f, -1.62221223e-01f, 1.45720497e-01f, -1.07642695e-01f, 2.74780462e-03f, -1.18613549e-01f, -1.06966384e-02f, 1.49886176e-01f,
  -2.40344889e-02f, -2.37505183e-01f, 5.93357682e-02f, 5.11450134e-03f, 8.41893405e-02f, 9.09627303e-02f, -1.98869370e-02f, 3.69334631e-02f, -5.75560033e-02f, 1.88091770e-01f,
  1.76395893e-01f, -3.69473360e-02f, -6.96227467e-03f, -3.66259404e-02f, 1.66961193e-01f, 1.90013666e-02f, 1.14823833e-01f, 6.70027435e-02f, 9.20603238e-03f, 7.85051286e-02f,
  5.25543578e-02f, -8.80616009e-02f, -1.10545874e-01f, 1.70266181e-01f, -1.36161514e-03f, 1.37344792e-01f, -2.08484724e-01f, -1.58706337e-01f, -2.02667072e-01f, -1.71147466e-01f,
  1.50530457e-01f, 2.85829455e-02f, 1.12294853e-02f, 5.48622757e-02f, -2.42230803e-01f, 3.17651704e-02f, -8.32019578e-05f, 1.22450098e-01f, -1.94228649e-01f, 7.49168620e-02f,
  -8.36711191e-03f, 1.73006451e-03f, -1.02963172e-01f, 3.71803530e-02f, 8.58789384e-02f, 6.24306826e-03f, 1.52805867e-03f, 7.16252029e-02f, -1.50168970e-01f, 2.33944715e-03f,
  -1.46583864e-03f, -1.25081360e-01f, -1.04749233e-01f, 1.28526334e-02f, -2.55089048e-02f, 1.07775487e-01f, -2.97627319e-02f, -8.46763179e-02f, -2.23744828e-02f, -2.29934435e-02f,
  4.93781008e-02f, 2.60465499e-02f, 9.00851116e-02f, -1.76656872e-01f, 3.16182859e-02f, -3.78040224e-02f, -2.70648953e-02f, -4.19060253e-02f, 2.52516717e-02f, -3.04310303e-02f,
  2.40843613e-02f, -6.06314698e-03f, 1.92533266e-02f, -5.48485778e-02f, 1.69263631e-02f, -2.36516427e-02f, 1.25743514e-02f, 5.01255020e-02f, -2.43642796e-02f, -1.58677343e-02f,
  2.86841765e-02f, 9.34351459e-02f, -8.15190747e-02f, -4.26662490e-02f, -1.21406466e-01f, 5.10566868e-02f, -3.89941297e-02f, 3.40356529e-02f, -9.94006097e-02f, -6.80367500e-02f,
  -5.60946837e-02f, 6.72189519e-02f, 7.54031166e-02f, -1.41663060e-01f, 4.23838906e-02f, -2.39436794e-02f, -4.92687663e-03f, -8.01589116e-02f, 4.41446453e-02f, -7.30611905e-02f,
  -3.46755087e-02f, -7.31651783e-02f, -1.39525279e-01f, 1.07556790e-01f, -3.47100608e-02f, -1.06719673e-01f, -1.07321190e-02f, -9.26794037e-02f, 1.61203280e-01f, 1.19202390e-01f,
  -6.13798834e-02f, -1.24114409e-01f, 6.75115883e-02f, 7.57390410e-02f, 3.47441226e-01f, -1.02521479e-01f, -1.79908544e-01f, -6.80851713e-02f, 5.04345633e-02f, -8.03226233e-02f,
  -2.74168444e-03f, 4.08442505e-02f, -1.10594392e-01f, 9.43218991e-02f, 3.78941745e-02f, 3.51822861e-02f, -1.41971409e-02f, -1.91276874e-02f, -2.59682313e-02f, -1.33092999e-02f,
  -5.86404689e-02f, -2.29792278e-02f, 9.77107063e-02f, -5.77277271e-03f, 2.63649374e-02f, 4.98817377e-02f, -5.09787463e-02f, 2.61784568e-02f, 1.12173721e-01f, -9.37678367e-02f,
  3.52313034e-02f, 5.67845106e-02f, 5.26457094e-02f, 3.76266949e-02f, 4.07645293e-02f, -1.52736381e-01f, -1.50261417e-01f, -2.24198148e-01f, 1.74803928e-01f, -3.54681313e-02f,
  -8.41764212e-02f, -1.35178447e-01f, 4.81973737e-02f, -1.16821021e-01f, 1.04707489e-02f, -7.22281411e-02f, -3.15171480e-02f, 1.43458275e-02f, 7.07706437e-02f, 1.94350872e-02f,
  1.52032942e-01f, -1.99961632e-01f, -6.69400394e-02f, 1.36569619e-01f, -1.27022877e-01f, 1.80411980e-01f, 1.75086707e-01f, -1.74690858e-01f, 1.65725406e-03f, -4.58952188e-02f,
  -7.42142182e-03f, -7.83972666e-02f, 2.71297395e-02f, 3.68663180e-03f, -7.47509897e-02f, -1.41029045e-01f, 5.97483218e-02f, 2.02286523e-03f, -2.65786201e-02f, -4.21992689e-03f,
  -6.26074001e-02f, -4.22965847e-02f, -8.72973800e-02f, -8.35520122e-03f, -4.68553789e-02f, 6.50604442e-02f, 3.98831628e-02f, -4.95877825e-02f, -3.23201306e-02f, 8.29707384e-02f,
  2.25022230e-02f, -3.74942683e-02f, 1.55083477e-01f, -5.44986278e-02f, -9.61573571e-02f, 2.94922516e-02f, -1.29025996e-01f, 5.80134690e-02f, -7.26027936e-02f, 1.69669520e-02f,
  -1.08965747e-01f, 2.90752966e-02f, -2.91392729e-02f, -1.63966343e-02f, -7.27569684e-02f, 6.89518675e-02f, 2.79246066e-02f, -3.82789336e-02f, -7.33864084e-02f, 2.98382179e-03f,
  -1.83225885e-01f, -7.33054876e-02f, 1.27085730e-01f, -7.49064535e-02f, -3.30032520e-02f, 3.91732622e-03f, 9.82060060e-02f, 4.13667150e-02f, 1.10012338e-01f, 7.49440715e-02f,
  -1.10137314e-01f, 7.31345965e-03f, -4.05900693e-03f, -7.93236196e-02f, -1.07367352e-01f, -6.21460155e-02f, -7.02197775e-02f, -9.42508727e-02f, 3.92241962e-02f, -4.87148650e-02f,
  -1.67582303e-01f, -2.14588657e-01f, -3.40726078e-02f, -4.77719232e-02f, 4.43092696e-02f, -1.03737622e-01f, -2.34458176e-03f, 1.11006172e-02f, 3.55522931e-02f, 1.33131165e-03f,
  -2.99662709e-01f, -2.92944685e-02f, 8.11081603e-02f, -3.29494476e-02f, 4.31966074e-02f, -1.24320731e-01f, -5.14604561e-02f, -4.14882153e-02f, -8.82373080e-02f, -1.05814025e-01f,
  -7.49717653e-02f, -1.86674986e-02f, -1.86959971e-02f, 3.75748053e-02f, -6.02822863e-02f, 1.11273535e-01f, -1.33422017e-01f, 1.30171806e-01f, -7.68832564e-02f, -1.62150949e-01f,
  -1.03814818e-01f, 8.47203285e-02f, 6.55739903e-02f, -1.71291068e-01f, 3.12253218e-02f, -1.52529567e-01f, -2.36530021e-01f, 3.12646367e-02f, 1.16400160e-02f, 1.00772604e-01f,
  9.08020213e-02f, 8.20650980e-02f, 2.90554110e-02f, 9.36783999e-02f, 8.38333219e-02f, 2.79521644e-02f, -8.28040838e-02f, 2.92417128e-03f, 7.26790428e-02f, -2.00098738e-01f,
  7.75166154e-02f, 8.21788236e-03f, 1.09166458e-01f, 1.89629523e-03f, -4.30348106e-02f, 4.22252603e-02f, 4.79821526e-02f, -1.09702379e-01f, -8.24411586e-02f, 6.80458918e-02f,
  2.96104252e-01f, -4.05181125e-02f, -2.20363915e-01f, -5.80942351e-03f, 4.81810346e-02f, -2.46345215e-02f, 2.01272266e-03f, -2.23031919e-02f, 6.01308122e-02f, 1.05877286e-02f,
  -6.41851947e-02f, 1.00762695e-01f, 3.53098214e-02f, 2.53685489e-02f, -4.98730019e-02f, -2.41698567e-02f, 8.79759789e-02f, -2.68769674e-02f, -6.40926957e-02f, -8.08831230e-02f,
  1.07518785e-01f, -1.48643464e-01f, 3.10034007e-02f, 1.84005778e-02f, -8.79241712e-03f, -2.82441042e-02f, -2.12597512e-02f, -3.84642221e-02f, -1.70714464e-02f, 6.04204126e-02f,
  -3.09584159e-02f, -1.86594389e-02f, -1.08646683e-01f, -4.15312089e-02f, 3.45649496e-02f, -5.08089066e-02f, 9.80511457e-02f, -1.28612623e-01f, -2.85807680e-02f, 5.10600619e-02f,
  1.91206206e-02f, -2.14699078e-02f, -3.33229303e-02f, 7.18000755e-02f, -1.19091772e-01f, -3.24301003e-03f, 1.49459755e-02f, -6.83107451e-02f, -6.60825148e-02f, 6.66688383e-02f,
  -1.24829682e-02f, 6.64672330e-02f, 8.21641609e-02f, 7.51823187e-03f, 2.86738537e-02f, 2.72385590e-02f, 8.45785514e-02f, 5.52574694e-02f, 2.96752565e-02f, -2.12807599e-02f,
  8.29499494e-03f, 4.17486243e-02f, 1.08499795e-01f, 1.63863197e-01f, -1.31653389e-02f, 1.49469122e-01f, -4.63603670e-03f, -1.24731652e-01f, 1.26122218e-02f, 3.19126323e-02f,
  -4.55957875e-02f, -1.22236703e-02f, -1.21186249e-01f, -7.38083497e-02f, -7.66953500e-03f, 3.85573171e-02f, 2.15362962e-02f, 3.17541324e-02f, 2.25979224e-01f, 6.75406829e-02f,
  1.39878262e-02f, 8.56829062e-02f, -5.75127602e-02f, 2.16769055e-02f, -1.73170790e-02f, 4.70015127e-03f, 6.46546334e-02f, -1.01317734e-01f, -5.91783179e-03f, -1.25167519e-01f,
  1.17572814e-01f, 7.47717097e-02f, -1.49127573e-01f, 8.34366772e-03f, 6.23712428e-02f, -1.26395538e-01f, 5.62477075e-02f, 6.13676012e-02f, 1.05065383e-01f, 1.51593853e-02f,
  -7.39353746e-02f, -1.17345266e-02f, -8.85360986e-02f, 1.03157043e-01f, 1.77620962e-01f, 4.21657600e-02f, -6.42245359e-05f, -1.33944020e-01f, 1.20282494e-01f, -9.12997499e-02f,
  -5.37148560e-04f, -4.01414633e-02f, 1.18977726e-01f, 1.76712394e-01f, 1.10600851e-01f, -2.20691599e-02f, -1.11237973e-01f, 1.32219195e-01f, -2.62762029e-02f, 8.21837932e-02f,
  -1.70349315e-01f, -6.29401579e-02f, 3.43734622e-02f, -2.47157216e-02f, 1.75707072e-01f, 3.73123288e-01f, 2.16531977e-01f, -8.12131539e-02f, 6.12956472e-04f, -1.86729096e-02f,
  9.47863832e-02f, -2.00412109e-01f, -1.61712319e-01f, 7.20866211e-03f, -1.02324106e-01f, 4.12963741e-02f, -5.09382188e-02f, 5.91163114e-02f, -1.34966686e-01f, 7.90101960e-02f,
  2.88835373e-02f, -3.78021970e-02f, -6.10014983e-03f, 7.68440366e-02f, 2.31954716e-02f, 3.99049446e-02f, 5.55905737e-02f, -9.33136269e-02f, -4.43734750e-02f, 1.67861432e-01f,
  9.43871066e-02f, -9.33262259e-02f, -1.43631533e-01f, -2.00473368e-02f, -3.31390835e-02f, -2.29668431e-02f, 1.05694504e-02f, -3.79559435e-02f, 8.46591368e-02f, 4.46882546e-02f,
  -8.61837193e-02f, 3.37743163e-02f, 1.25753105e-01f, -6.01200350e-02f, 6.62182942e-02f, -1.89577505e-01f, 1.52138704e-02f, -7.38627017e-02f, -1.21820226e-01f, 3.12848724e-02f,
  6.10999763e-03f, -4.55356762e-02f, 9.00915563e-02f, -5.40848635e-02f, 1.00692682e-01f, -4.63535599e-02f, 5.08473143e-02f, -3.27398628e-02f, 7.57594332e-02f, -8.79869424e-03f,
  -1.27114067e-02f, -7.90436342e-02f, -3.38411666e-02f, 1.16355613e-01f, 1.38434758e-02f, 1.71614483e-01f, 4.38096374e-02f, 6.70069084e-02f, 1.74291745e-01f, 8.08480307e-02f,
  5.84985912e-02f, -2.14708354e-02f, -4.30467464e-02f, -1.91997495e-02f, 1.62808791e-01f, 2.28396077e-02f, 1.65271327e-01f, -4.51808516e-03f, 1.40001565e-01f, -7.54503682e-02f,
  7.67583400e-02f, 1.00172110e-01f, -1.77398324e-01f, -1.94937006e-01f, -7.35659748e-02f, 4.98204380e-02f, 4.03969996e-02f, -2.31579468e-02f, -2.35939268e-02f, -1.18776068e-01f,
  7.03823417e-02f, 2.61457533e-01f, 7.28456229e-02f, 3.73545922e-02f, 1.10317260e-01f, -8.28356110e-03f, -1.23775005e-01f, 4.97316979e-02f, 4.21968997e-02f, 7.49033168e-02f,
  5.83421662e-02f, -8.73509049e-02f, 1.53880745e-01f, 9.04012918e-02f, -2.28341520e-02f, 8.56783018e-02f, 9.60453004e-02f, 4.69860584e-02f, 7.43610486e-02f, 3.48076113e-02f,
  -7.92571083e-02f, 3.30383219e-02f, 8.18921626e-03f, -3.10914554e-02f, 9.31610614e-02f, -1.46745265e-01f, -1.93432793e-01f, -2.28535174e-03f, 8.61333311e-03f, 9.06221122e-02f,
  6.56356141e-02f, 1.71876207e-01f, 2.42689610e-01f, 7.85305575e-02f, -5.22429086e-02f, -1.06423482e-01f, 1.12805571e-02f, -8.23037103e-02f, -5.35737211e-03f, 2.29219329e-02f,
  1.63464010e-01f, 1.97565377e-01f, -3.61146927e-01f, -2.78060995e-02f, 1.30782546e-02f, -1.46579072e-01f, -1.42661138e-02f, -1.26873450e-02f, 1.44569622e-02f, -1.13455370e-01f,
  -1.41350459e-02f, 3.07072639e-01f, -2.31127571e-02f, 1.00413598e-01f, -2.17262395e-02f, 1.05359973e-02f, 6.01101927e-02f, 7.97737911e-02f, 2.20212996e-01f, 1.92384087e-02f,
  1.27916515e-01f, 3.93987112e-02f, 1.22334091e-02f, -9.75218937e-02f, -4.65448983e-02f, 5.64463474e-02f, -1.45018110e-02f, 4.59842384e-03f, 1.28242329e-01f, -6.72021415e-03f,
  1.78783946e-02f, 4.73147109e-02f, 7.35161453e-03f, 1.14401139e-01f, -4.25835745e-03f, 1.32908393e-03f, -9.07697342e-03f, 3.65373455e-02f, 2.53449902e-02f, -1.77524872e-02f,
  5.84401861e-02f, -9.09568146e-02f, 1.54416994e-04f, -1.09159034e-02f, 6.59585297e-02f, -7.68523244e-03f, -1.33275121e-01f, 4.64940863e-03f, 2.78719980e-02f, -1.07932135e-01f,
  -1.78075675e-02f, 4.53223893e-03f, 9.39843655e-02f, -7.65061378e-02f, 5.94776310e-02f, 7.41526783e-02f, 7.54682571e-02f, 3.85430381e-02f, -5.77002130e-02f, 6.79197162e-02f,
  1.52717484e-02f, 2.07474194e-02f, -9.20346603e-02f, 1.07456406e-03f, -1.74562916e-01f, -9.69980955e-02f, -2.53793616e-02f, 2.07898095e-02f, 4.31103259e-02f, 2.60692611e-02f,
  1.78404581e-02f, 8.22948217e-02f, 2.62988973e-02f, 1.17104992e-01f, 1.09417289e-01f, 8.16431344e-02f, 1.18386924e-01f, 1.04279265e-01f, 7.48191774e-02f, -1.48189723e-01f,
  -5.93804382e-02f, -2.85413899e-02f, -1.26439720e-01f, -5.40260673e-02f, 6.45578429e-02f, -7.57898670e-03f, -3.49551849e-02f, -8.15999508e-02f, -8.18090513e-02f, 1.34324670e-01f,
  5.92839867e-02f, -7.40609318e-03f, -1.94747169e-02f, 1.67126775e-01f, 4.44500297e-02f, -5.66542074e-02f, 2.18981817e-01f, 4.61913720e-02f, -5.40522598e-02f, 1.82450507e-02f,
  9.07267332e-02f, -1.07773155e-01f, -1.07939832e-01f, -8.08938146e-02f, 7.79610276e-02f, -7.20814466e-02f, 3.36971059e-02f, -7.48174964e-03f, 1.34454995e-01f, 1.38921648e-01f,
  -2.67695989e-02f, -4.19208147e-02f, 1.20120376e-01f, 3.14681083e-02f, -1.54461116e-01f, 1.99205112e-02f, -2.56558537e-01f, -1.40469387e-01f, -1.13713279e-01f, -7.16528520e-02f,
  1.19667556e-02f, -8.17538202e-02f, -1.43863767e-01f, 1.33929655e-01f, -1.16605125e-02f, 3.05320136e-02f, 8.58385675e-03f, -1.77491307e-01f, 3.15502077e-01f, -1.46269366e-01f,
  -1.96245741e-02f, 6.27582371e-02f, 1.06368653e-01f, -1.33078948e-01f, -3.71481255e-02f, 1.72132012e-02f, 2.11420715e-01f, 3.55171859e-02f, 1.84320256e-01f, -2.99988408e-02f,
  -2.95045190e-02f, -2.99897026e-02f, -1.27850011e-01f, -3.88680212e-02f, 7.75219947e-02f, 4.69476916e-02f, 8.10052082e-02f, -7.58023560e-02f, 2.68838815e-02f, 8.33789036e-02f,
  -4.14362140e-02f, 1.68662593e-02f, -3.95333245e-02f, -9.00167525e-02f, 7.05678388e-02f, -2.71964371e-02f, 2.03797277e-02f, -1.10362507e-01f, -7.67679885e-02f, 9.75226983e-02f,
  -3.29379514e-02f, 1.58727914e-02f, -1.12422608e-01f, 7.51015395e-02f, -3.28224935e-02f, -2.51482632e-02f, 3.46894450e-02f, -1.26554281e-01f, -1.74510218e-02f, -9.61327031e-02f,
  -1.66804448e-01f, -5.30393086e-02f, -1.02813989e-02f, -1.49264380e-01f, -1.29974335e-01f, -1.55225256e-02f, -7.85431042e-02f, 3.29451673e-02f, 4.61633652e-02f, 6.70322403e-02f,
  2.79231220e-02f, -6.52279556e-02f, -4.58039716e-02f, 8.24778825e-02f, 4.93443608e-02f, 1.20349877e-01f, -1.95436731e-01f, -4.69287932e-02f, 5.80989309e-02f, -1.21548697e-02f,
  -1.02998033e-01f, 1.36346808e-02f, -1.32083088e-01f, -5.02907299e-02f, -6.70781285e-02f, 4.70643081e-02f, -9.29048732e-02f, -2.85547543e-02f, 1.68496624e-01f, 3.88717093e-02f,
  5.94946742e-02f, 1.05745532e-01f, 8.83086249e-02f, -8.02304968e-03f, -9.97763053e-02f, 6.83446927e-03f, 1.58646718e-01f, 6.18531257e-02f, 3.07859648e-02f, -8.74661189e-03f,
  1.57951061e-02f, -2.63417438e-02f, -1.42261878e-01f, -6.25036657e-02f, -2.32328940e-02f, 4.29601222e-03f, -1.26245469e-01f, 1.25600204e-01f, 1.37336235e-02f, 1.11344554e-01f,
  9.94236618e-02f, 1.16526065e-02f, -5.27154095e-02f, 1.23983473e-01f, 1.81232139e-01f, 8.47863704e-02f, 2.71534566e-02f, -4.99028489e-02f, -5.62471971e-02f, 3.11426762e-02f,
  -1.03217795e-01f, -7.97458459e-03f, 3.03149316e-02f, 3.61538604e-02f, 1.52260810e-01f, -1.83882248e-02f, 1.25955403e-01f, -1.08044818e-01f, -1.46514401e-01f, -1.74280331e-01f,
  1.19552568e-01f, 1.21901490e-01f, -9.99177918e-02f, -1.27198726e-01f, -1.53183639e-01f, -1.07285120e-01f, -9.46461633e-02f, -1.71793774e-01f, -2.09834799e-02f, -1.22617908e-01f,
  2.44194567e-01f, 7.05490038e-02f, -8.08719825e-03f, 6.26946241e-02f, 1.16137706e-01f, -9.98553261e-02f, 1.70008779e-01f, 3.44055891e-02f, -1.60323799e-01f, -1.23777241e-01f,
  -1.82198896e-03f, -1.08531699e-01f, 1.81033798e-02f, -1.25948831e-01f, -7.92466104e-03f, -8.42637755e-03f, 2.75473773e-01f, -2.14091185e-02f, -2.38367803e-02f, 4.65527698e-02f,
  -5.24402857e-02f, 1.13832295e-01f, 8.92303213e-02f, 9.88348573e-02f, -7.95504823e-02f, 2.46201288e-02f, -1.11037053e-01f, -1.41111165e-01f, -4.78834361e-02f, 2.96745375e-02f,
  -1.44642875e-01f, -1.40173256e-01f, -6.06508777e-02f, 3.06837782e-02f, 2.69205105e-02f, -1.53397806e-02f, -9.43301828e-04f, -3.08155231e-02f, -9.84313246e-03f, 1.37637049e-01f,
  -8.48107878e-03f, 4.97008266e-04f, -1.82468928e-02f, 5.51685654e-02f, 9.73372487e-04f, 1.19876291e-03f, -1.23402216e-02f, -4.27529737e-02f, 6.74458034e-03f, -8.96443501e-02f,
  -4.96390872e-02f, -4.51910682e-02f, 1.15894668e-01f, -7.16984719e-02f, -2.50987336e-02f, 2.66924351e-02f, -1.58361882e-01f, 4.23029363e-02f, 1.18455738e-02f, 1.06478827e-02f,
  -1.77198321e-01f, -3.18215345e-03f, -1.03268005e-01f, -2.72013899e-02f, -1.27744168e-01f, 1.14859447e-01f, 1.51586849e-02f, -7.82949105e-02f, 9.05980691e-02f, -2.14456134e-02f,
  1.53531330e-02f, 9.90457647e-03f, -5.85319214e-02f, -3.79580818e-02f, 4.64054011e-02f, -1.81192644e-02f, -7.99728557e-02f, 4.63416763e-02f, 7.92101473e-02f, -5.05142547e-02f,
  -7.07827322e-03f, 1.75390895e-02f, -1.55983150e-01f, 1.48123071e-01f, -8.24883580e-02f, 1.74938294e-03f, -2.09906301e-03f, 2.41345465e-02f, 6.07132167e-02f, 1.40931621e-01f,
  -4.13751267e-02f, 5.06373085e-02f, 6.30725548e-02f, 1.09594367e-01f, 1.07497118e-01f, -1.76948443e-01f, -5.11347204e-02f, -2.08477825e-01f, -1.26601443e-01f, -1.24975145e-01f,
  -5.70971482e-02f, 6.74720481e-02f, -5.77703007e-02f, -1.33748442e-01f, -3.55457775e-02f, -1.10045753e-01f, -4.49638674e-03f, 1.21561639e-01f, 1.67515427e-02f, 3.79283130e-02f,
  1.94130447e-02f, 1.64638296e-01f, -5.97938634e-02f, -1.40530929e-01f, -5.11213318e-02f, 1.40883597e-02f, 7.23253787e-02f, 2.85280254e-02f, -1.03789255e-01f, 9.66874659e-02f,
  -1.54508471e-01f, 9.44524258e-02f, -3.59800598e-03f, -1.14192143e-01f, 3.77062894e-02f, -4.42135669e-02f, 2.03391060e-01f, 6.81261793e-02f, -1.50908336e-01f, -2.29045320e-02f,
  -1.07813083e-01f, 1.79248899e-02f, 1.44459307e-01f, 8.30855444e-02f, -2.64637232e-01f, 1.71299593e-03f, -3.97272175e-03f, 2.89011132e-02f, 1.82563551e-02f, -4.84690368e-02f,
  2.33105391e-01f, -6.98477495e-03f, -8.78251418e-02f, -2.77013749e-01f, -4.01902735e-01f, 7.76154026e-02f, 1.18792772e-01f, -5.75065147e-03f, -7.93223158e-02f, -2.03427132e-02f,
  3.40476446e-02f, -3.54175419e-02f, 9.38067064e-02f, -5.46641499e-02f, -6.71348870e-02f, 6.11071885e-02f, -1.18125156e-01f, 5.50292432e-02f, 3.84563766e-02f, -3.67386341e-02f,
  1.01449564e-01f, -2.77425144e-02f, -5.44302650e-02f, -5.23710065e-02f, -1.12002222e-02f, -1.83557204e-04f, 1.04090488e-02f, 8.26736838e-02f, -8.74408185e-02f, -1.13142326e-01f,
  -7.17226788e-02f, -1.05393678e-01f, 6.19568899e-02f, -4.42442372e-02f, 3.82639840e-02f, 7.92815071e-03f, -1.07046962e-02f, -9.35834832e-03f, -8.69599134e-02f, 6.07174225e-02f,
  -7.44850263e-02f, -2.59988662e-02f, -9.75694656e-02f, 5.46512567e-02f, -8.84631723e-02f, -2.80636679e-02f, -1.55741170e-01f, 1.02990486e-01f, -2.23820582e-02f, -3.66353579e-02f,
  7.77801052e-02f, -3.59128378e-02f, -3.77917178e-02f, 5.51084355e-02f, 3.64356115e-02f, -8.12266320e-02f, 4.31025289e-02f, -7.62658492e-02f, -9.27765071e-02f, -7.48423114e-03f,
  9.42209214e-02f, 1.32791460e-01f, 6.33318648e-02f, 3.33740562e-02f, 8.96555930e-02f, 6.87021390e-02f, 2.64321685e-01f, 1.08018576e-03f, 3.05116214e-02f, 6.25368431e-02f,
  8.76706839e-02f, -2.20891029e-01f, -1.88848510e-01f, -1.01024866e-01f, -1.10585153e-01f, 1.48580864e-01f, -7.76208639e-02f, -7.50268996e-02f, -1.95894331e-01f, 1.94635603e-03f,
  -1.44694177e-02f, -5.70111126e-02f, 1.60227455e-02f, -5.92863820e-02f, -6.61769062e-02f, -5.93369864e-02f, 5.78087159e-02f, 8.90396982e-02f, -1.30468771e-01f, -1.57528788e-01f,
  1.39425788e-02f, 2.36410439e-01f, -6.23895936e-02f, -3.62874866e-02f, -3.92646678e-02f, 1.17661670e-01f, -9.16431546e-02f, 1.12272158e-01f, -2.75236946e-02f, 1.27480686e-01f,
  4.50374968e-02f, -3.02520320e-02f, -1.40665740e-01f, -1.81694269e-01f, -4.47073467e-02f, 3.92976701e-02f, 8.15109760e-02f, 1.28211915e-01f, -1.10838979e-01f, -3.64953466e-02f,
  -7.05133751e-02f, -1.73488095e-01f, -1.86800733e-01f, -1.27973735e-01f, -1.39284894e-01f, 1.04848824e-01f, -1.49674863e-01f, -1.49219826e-01f, 2.37496048e-02f, 9.49217528e-02f,
  -1.20194711e-01f, 8.89594331e-02f, 2.68939674e-01f, 9.15441215e-02f, 2.44870782e-02f, 3.81299928e-02f, 1.26599804e-01f, 1.17876986e-02f, 2.94204861e-01f, 4.86539491e-02f,
  2.27429136e-03f, 5.20205833e-02f, 2.38558099e-01f, -1.48747593e-01f, 7.24654049e-02f, 7.46380612e-02f, -4.59820665e-02f, 4.63443138e-02f, 2.22539026e-02f, -7.98828229e-02f,
  -2.50276346e-02f, -6.80052908e-04f, 1.56979829e-01f, 1.34339720e-01f, 2.98329666e-02f, 2.66553834e-02f, 5.62291257e-02f, -6.51970878e-02f, -6.15485162e-02f, -6.28403947e-02f,
  3.86605896e-02f, 5.08791544e-02f, 8.16530213e-02f, -2.09631976e-02f, 6.18952736e-02f, -6.18858151e-02f, -5.46567068e-02f, 3.77283320e-02f, -8.18773434e-02f, 6.65102005e-02f,
  9.78307724e-02f, -5.13180392e-03f, -2.53166864e-03f, 4.05407771e-02f, -4.86305021e-02f, 8.70718434e-02f, -2.80820318e-02f, 7.66055956e-02f, -7.54292980e-02f, 6.10515103e-02f,
  1.77104976e-02f, 7.55903348e-02f, 1.20554902e-02f, 9.43578556e-02f, 8.00957531e-02f, -2.29720697e-02f, 1.96407922e-02f, -8.88059009e-03f, -4.47898991e-02f, 6.31641820e-02f,
  -5.65900933e-03f, -8.66385028e-02f, 4.21334058e-02f, -3.40746492e-02f, 1.03918528e-02f, 1.25098363e-01f, -8.21899995e-02f, 5.14201298e-02f, -2.69163903e-02f, 3.75508480e-02f,
  -7.94653893e-02f, -2.19566852e-01f, -1.93779171e-02f, -1.30135566e-01f, -9.18888450e-02f, 8.94180983e-02f, 6.69120699e-02f, -7.31028095e-02f, -1.29775450e-01f, -7.40353912e-02f,
  2.85755028e-03f, 6.71648160e-02f, 7.44775236e-02f, 4.42914590e-02f, -9.84859616e-02f, 2.68875267e-02f, -1.93478748e-01f, -1.06692873e-01f, 7.68629136e-03f, -6.03725873e-02f,
  1.66825891e-01f, -1.87305480e-01f, -4.71454002e-02f, -6.64303675e-02f, -6.33327141e-02f, -5.97724244e-02f, 2.76124477e-03f, 4.49694134e-02f, 6.91062137e-02f, -1.40106812e-01f,
  1.23492837e-01f, 1.02070786e-01f, -3.11900396e-02f, -2.79496447e-03f, 2.77909543e-02f, -1.26712292e-01f, -6.65510744e-02f, -1.88556276e-02f, -2.24340465e-02f, 1.06490729e-02f,
  8.17757249e-02f, -2.75126304e-02f, -1.22728892e-01f, -1.30210206e-01f, -2.64878124e-02f, 9.07359123e-02f, 4.44236435e-02f, -8.92538170e-04f, 2.47200467e-02f, 2.53903389e-01f,
  2.23911610e-02f, -1.48024159e-02f, -2.80098021e-01f, -1.52159661e-01f, 2.36915380e-01f, -7.75475055e-02f, 4.34072576e-02f, -1.13209583e-01f, 1.36753440e-01f, -1.33069947e-01f,
  -1.66434318e-01f, 1.88390147e-02f, 4.04353533e-03f, -2.05915943e-01f, -1.93788975e-01f, -4.11578529e-02f, -6.36728704e-02f, -3.77247818e-02f, -1.72945410e-01f, 1.04805082e-01f,
  1.52267858e-01f, -1.09241739e-01f, -7.92268440e-02f, -5.29556945e-02f, -4.17806720e-03f, 1.72689259e-02f, -1.00050410e-02f, -5.07950298e-02f, -3.57753560e-02f, -1.29574150e-01f,
  -1.23362668e-01f, -1.07168652e-01f, -4.47555073e-02f, -3.47010456e-02f, -1.44045934e-01f, 1.65341198e-02f, -1.58546641e-02f, -8.01194832e-02f, 6.47172704e-03f, 9.54896025e-03f,
  -5.82960993e-02f, -1.09176494e-01f, 8.70728865e-03f, -3.42951305e-02f, -4.29866388e-02f, 1.21407509e-01f, -5.55838495e-02f, -1.15341665e-02f, -6.41312376e-02f, -2.46291030e-02f,
  -7.50036538e-02f, 5.77679239e-02f, 2.59354170e-02f, 4.96248417e-02f, -7.51842633e-02f, 5.71856201e-02f, -8.45899060e-02f, -7.72012724e-03f, 2.92206276e-02f, 2.32398156e-02f,
  5.92088476e-02f, 4.72661182e-02f, 4.09405082e-02f, -1.15779810e-01f, -3.79004292e-02f, -3.56171131e-02f, -3.41776200e-02f, 7.05721453e-02f, -1.06331013e-01f, -4.49068323e-02f,
  7.05597699e-02f, 7.48398528e-02f, 3.18928733e-02f, 9.81319249e-02f, 8.60511363e-02f, 5.78594953e-02f, -4.30897810e-02f, -5.24698496e-02f, -5.95962293e-02f, -1.81024477e-01f,
  -7.04667643e-02f, -1.08577281e-01f, -8.63253996e-02f, -1.01147167e-01f, 6.54037576e-03f, 3.85448672e-02f, -7.83307925e-02f, 9.60146189e-02f, -2.86028367e-02f, 7.00519159e-02f,
  -7.57547021e-02f, 6.65768329e-03f, 5.11635207e-02f, 8.06861930e-03f, 1.75068572e-01f, -4.88042310e-02f, 2.25368649e-01f, 2.48094182e-03f, -3.77497263e-02f, 6.04442470e-02f,
  1.68319643e-02f, 6.03104010e-02f, 8.16588849e-02f, -3.95524092e-02f, 3.05562094e-02f, -4.75414209e-02f, 1.18300602e-01f, 6.84632827e-03f, -7.63703212e-02f, -4.33763973e-02f,
  2.13492755e-02f, -2.08624646e-01f, 6.61279336e-02f, -5.32974452e-02f, -8.38285498e-03f, -8.72787610e-02f, -6.35437621e-03f, 8.11955705e-02f, 5.59379868e-02f, 8.68119672e-03f,
  8.09288099e-02f, 1.25828490e-01f, 1.26001880e-01f, -3.68565507e-02f, 1.28084496e-01f, -1.39282867e-01f, 5.92577234e-02f, 2.02282533e-01f, 1.13090761e-01f, 2.66082436e-01f,
  -3.08399908e-02f, -9.43801776e-02f, 1.85604334e-01f, 4.44235243e-02f, -1.93307921e-03f, -6.27647564e-02f, -5.91802150e-02f, -5.14369607e-02f, -2.18053490e-01f, -4.81338874e-02f,
  -1.83790013e-01f, 1.83567237e-02f, 8.45922809e-03f, -5.62181603e-03f, -2.78094560e-01f, -1.74794436e-01f, -3.54591422e-02f, -5.45173734e-02f, -2.57880330e-01f, 3.66724133e-02f,
  6.78121066e-03f, -9.05849114e-02f, 2.30458652e-04f, 2.67853625e-02f, -1.87055785e-02f, 1.97447408e-02f, 9.73708332e-02f, -5.94703620e-03f, 8.71673226e-02f, 8.28427300e-02f,
  -1.59528956e-01f, 1.82141736e-02f, 7.41457865e-02f, 1.05026230e-01f, 6.85212985e-02f, 2.41856277e-02f, 7.82774016e-02f, -1.12525605e-01f, -1.77518517e-01f, 4.91343997e-02f,
  3.54908444e-02f, 8.19004141e-03f, -1.52496621e-01f, -6.21076785e-02f, -1.25734717e-01f, -6.98361546e-02f, 1.02093279e-01f, -5.90651929e-02f, 1.45216912e-01f, -5.92341088e-02f,
  6.53028414e-02f, -1.31162018e-01f, 9.23360139e-02f, -9.54046845e-02f, -2.73574162e-02f, -3.89620438e-02f, -1.01421833e-01f, -4.81116399e-02f, 3.39771877e-03f, -1.38854280e-01f,
  2.84016803e-02f, 4.14938899e-03f, 1.32492214e-01f, 1.40049130e-01f, 2.76638847e-02f, 2.57475749e-02f, -7.08910152e-02f, 1.65712542e-03f, 3.23030464e-02f, -4.86283787e-02f,
  -6.58715889e-02f, -4.45286818e-02f, 2.02357192e-02f, -3.84269468e-02f, 5.49055971e-02f, 9.11888331e-02f, 6.43013418e-02f, 4.39328365e-02f, -1.95152499e-02f, 1.40547082e-01f,
  -9.86133218e-02f, -4.75231484e-02f, -8.87442902e-02f, 7.62956738e-02f, 2.05497593e-01f, 1.07515767e-01f, -1.53110579e-01f, -1.32839203e-01f, -1.04838668e-03f, -1.89230487e-01f,
  1.41691035e-02f, -6.67914525e-02f, 9.75045264e-02f, -2.76569766e-03f, 4.74666171e-02f, -9.49065387e-03f, -1.45765403e-02f, 1.82489723e-01f, -1.25166699e-01f, -3.28130275e-02f,
  4.93784845e-02f, -3.99832800e-02f, -1.22916967e-01f, -4.87410352e-02f, 1.59464270e-01f, 1.96617931e-01f, 3.89457494e-02f, -1.51247218e-01f, -1.08116437e-02f, -7.03467801e-02f,
  1.94940753e-02f, 1.00836530e-01f, 4.18635942e-02f, 4.38979790e-02f, 1.39569100e-02f, 1.10783905e-01f, 6.85662478e-02f, -3.04774903e-02f, 7.29365498e-02f, -2.52248585e-01f,
  1.57648131e-01f, 1.11865140e-01f, -1.38797820e-01f, -1.06644437e-01f, -4.56027538e-02f, -1.51526358e-03f, -6.53913468e-02f, -1.24824792e-01f, 2.42777675e-01f, -2.24820487e-02f,
  -8.79411921e-02f, 6.01032339e-02f, -9.33936760e-02f, 9.37588885e-02f, -8.26072022e-02f, 2.69269105e-02f, 2.94279069e-01f, 7.28508681e-02f, -2.20223248e-01f, 3.07337433e-01f,
  3.21274072e-01f, -1.55476749e-01f, -1.14224620e-01f, -8.69700760e-02f, 4.85725366e-02f, -7.10779130e-02f, 1.41960248e-01f, 6.10302463e-02f, -2.36447994e-02f, -2.95557920e-02f,
  -2.50265524e-02f, 3.22279148e-02f, 6.95175007e-02f, -1.49952844e-01f, 4.22522845e-03f, -4.76736762e-02f, -1.24170519e-01f, 1.39037475e-01f, -1.84750576e-02f, 2.34756637e-02f,
  -1.37955382e-01f, 2.48198714e-02f, 2.11887038e-03f, 8.84722024e-02f, -5.76519445e-02f, -5.69821261e-02f, -7.19839260e-02f, 2.16259826e-02f, -1.12653457e-01f, 5.01939235e-03f,
  1.40545480e-02f, 3.68384682e-02f, -9.50150117e-02f, 3.22673470e-02f, -9.24826786e-02f, -7.48203993e-02f, -3.79012339e-02f, 7.19831511e-03f, -8.40019137e-02f, 8.31195563e-02f,
  -2.14882810e-02f, -3.18797566e-02f, -1.21182553e-01f, -4.76444662e-02f, 5.15685230e-02f, -8.17916915e-03f, 9.51373726e-02f, 1.52398422e-01f, 5.35229854e-02f, -6.77393153e-02f,
  -4.78025936e-02f, 8.29738081e-02f, -1.40341192e-01f, 1.20741084e-01f, -1.50802881e-01f, -2.54145898e-02f, 1.17240092e-02f, -8.66754204e-02f, 4.84003127e-03f, 7.99493864e-02f,
  2.40911357e-02f, 4.59955446e-02f, -8.93379524e-02f, 1.67489680e-03f, -1.36757657e-01f, -3.87342088e-02f, 6.85287938e-02f, -1.49624810e-01f, -1.77560374e-01f, -1.34541830e-02f,
  -1.13599136e-01f, 2.67023683e-01f, -4.51036133e-02f, 3.63410935e-02f, -6.79816529e-02f, -8.39731563e-03f, 5.81252128e-02f, 9.69051495e-02f, 5.13892882e-02f, -6.21438771e-02f,
  2.01991573e-01f, 1.42579647e-02f, 2.04203114e-01f, -6.46087527e-02f, -2.61406749e-01f, 1.61045223e-01f, 4.72667702e-02f, 1.71291664e-01f, 2.30604410e-01f, 9.17475019e-03f,
  7.66593963e-02f, 6.67361915e-03f, 1.92092583e-01f, 1.39048263e-01f, -2.53750328e-02f, 6.10798299e-02f, 1.02166489e-01f, -2.83506721e-01f, -5.77807613e-02f, 1.33838251e-01f,
  4.47406024e-02f, -1.59903958e-01f, 1.65905729e-02f, 4.79677431e-02f, 2.25795247e-02f, -1.77317206e-02f, 6.33286312e-02f, -1.11117847e-01f, 1.15493320e-01f, -5.99553287e-02f,
  1.49084404e-01f, -1.39048249e-01f, -7.33149722e-02f, 3.64976712e-02f, -8.46473351e-02f, -1.72594481e-03f, 1.64808303e-01f, -1.10926390e-01f, -2.84624994e-02f, 1.25021100e-01f,
  1.11944405e-02f, -4.17972393e-02f, -9.63879004e-02f, 2.66390964e-02f, 1.96692616e-01f, -9.07633454e-02f, -2.04898596e-01f, -5.22163473e-02f, 1.83283865e-01f, -1.75124615e-01f,
  -1.96966469e-01f, -9.19335634e-02f, 1.04683802e-01f, 9.29887518e-02f, 1.92505568e-01f, 7.07344338e-02f, -7.79456241e-05f, 8.21531489e-02f, -4.04333957e-02f, 2.38356162e-02f,
  6.81521669e-02f, -5.84761836e-02f, 1.44064054e-01f, -1.00830488e-01f, -1.52988285e-01f, -5.29751703e-02f, -3.06036342e-02f, -4.09143930e-03f, -9.95915830e-02f, 3.52281108e-02f,
  -1.47412479e-01f, 1.96292400e-02f, -1.09775126e-01f, -2.23112144e-02f, -5.24441898e-02f, -5.15507422e-02f, -1.05534457e-01f, 3.54318395e-02f, -6.85919672e-02f, -3.38721760e-02f,
  -2.01255362e-02f, -6.72986731e-02f, -6.87286854e-02f, -6.81082858e-03f, -1.80280313e-01f, 1.81696843e-02f, -1.10902123e-01f, -6.96564987e-02f, -2.94121578e-02f, 4.00262922e-02f,
  -1.39927864e-02f, 1.06797041e-02f, -8.60907808e-02f, 2.71568447e-02f, -2.73004752e-02f, 4.79996800e-02f, -9.03314576e-02f, -3.64324339e-02f, 1.93887670e-02f, -3.62361521e-02f,
  -1.09124981e-01f, 1.01830900e-01f, -9.84800011e-02f, -5.50208502e-02f, -2.73637716e-02f, -2.63115726e-02f, -4.23706546e-02f, -2.12904308e-02f, -6.15100227e-02f, -1.15402311e-01f,
  -1.18317068e-01f, 1.18348550e-03f, -7.73603749e-03f, 2.44032126e-02f, 6.47581071e-02f, -4.64954451e-02f, -1.02066211e-01f, 2.19188873e-02f, -3.70090120e-02f, 1.28950819e-01f,
  8.83607417e-02f, -1.50863212e-02f, -8.03940296e-02f, -1.34048432e-01f, 6.07455969e-02f, -2.78514102e-02f, -8.18026811e-02f, -2.94268969e-02f, -9.25235599e-02f, -5.47795594e-02f,
  3.06349844e-01f, -5.69610260e-02f, -6.07635900e-02f, -6.15608692e-02f, -7.16694817e-02f, -5.70624648e-03f, 5.16843535e-02f, -1.14538474e-02f, -1.64768130e-01f, -3.00925672e-02f,
  1.47671044e-01f, 5.62372990e-02f, 5.29414415e-02f, -1.65195495e-01f, -1.52220070e-01f, -1.01832561e-01f, -1.53005213e-01f, 6.49184212e-02f, -9.23034325e-02f, -3.36662196e-02f,
  9.03258622e-02f, 7.11767003e-02f, -5.35219628e-03f, -6.82939664e-02f, -7.93271139e-02f, -5.72963431e-02f, 3.27953659e-02f, 1.11971200e-01f, 7.12676272e-02f, -7.21839517e-02f,
  4.31951582e-02f, 9.14260466e-03f, -1.36286005e-01f, -1.25104263e-01f, 1.07525118e-01f, -6.77421689e-02f, -4.18023765e-02f, 1.94904432e-02f, 5.98701797e-02f, -7.80145228e-02f,
  6.57996908e-02f, -1.03378050e-01f, 1.43849462e-01f, 4.77647036e-03f, 1.48834996e-02f, 3.85714769e-02f, 1.51068807e-01f, -1.55053765e-01f, -1.03281252e-01f, 7.64828036e-03f,
  -4.73401248e-02f, 1.34064749e-01f, 1.67271465e-01f, 2.15715617e-02f, -5.83862066e-02f, -2.47809533e-02f, -2.67866645e-02f, -1.41482934e-01f, -1.80327743e-02f, 6.72450811e-02f,
  -3.81834283e-02f, -4.62338999e-02f, -1.33147258e-02f, -1.13901906e-01f, -3.36792059e-02f, -7.90743902e-02f, -4.85517830e-03f, -1.14587426e-01f, 4.67300713e-02f, -2.69573461e-02f,
  -4.07363474e-02f, 7.15565123e-03f, 4.70121875e-02f, -1.68655273e-02f, -6.29065558e-02f, 1.00937709e-02f, -1.24425121e-01f, -8.97991583e-02f, 5.33983931e-02f, -4.68193069e-02f,
  7.83079788e-02f, -5.58459312e-02f, -1.98279433e-02f, 3.90687697e-02f, -1.86804533e-01f, -7.24989474e-02f, -1.02189280e-01f, -5.84894456e-02f, 2.99278344e-03f, -7.83671141e-02f,
  -1.10874127e-03f, -5.01322635e-02f, -1.62742794e-01f, -4.57103103e-02f, -2.42188334e-01f, 3.86401452e-02f, -1.68383360e-01f, -7.40142837e-02f, -7.63689354e-02f, -1.06168941e-01f,
  -1.20720044e-01f, 3.83934714e-02f, -9.21318587e-03f, -6.65704720e-03f, 4.98286933e-02f, -5.09714559e-02f, 1.33837104e-01f, -3.19572585e-03f, 1.25063270e-01f, -1.61300734e-01f,
  6.50994852e-02f, -8.38428214e-02f, -1.62731335e-01f, 5.86275011e-02f, 1.63326278e-01f, -6.76579261e-03f, -6.61889240e-02f, -8.06896463e-02f, -1.09974742e-01f, -6.92193434e-02f,
  4.76730913e-02f, -1.29875809e-01f, -7.48097226e-02f, -8.16347077e-02f, 1.95211405e-03f, 9.25071016e-02f, -8.94477218e-02f, -4.37331572e-02f, -5.91627844e-02f, -2.64002364e-02f,
  1.57734886e-01f, -1.05927832e-01f, 4.50454019e-02f, -1.37220040e-01f, -1.15853213e-01f, -1.44847751e-01f, -4.41403538e-02f, 6.17976766e-03f, 3.30787972e-02f, -5.38137704e-02f,
  -8.54313672e-02f, -3.04018855e-02f, 7.64719695e-02f, 1.67745128e-01f, -3.87961008e-02f, -1.02882043e-01f, 3.18446080e-03f, 1.68732792e-01f, -6.54654801e-02f, -6.27049506e-02f,
  -1.40286192e-01f, -9.14691761e-02f, 4.95624989e-02f, 1.55322433e-01f, -1.27784252e-01f, -6.55395836e-02f, -1.62169948e-01f, 6.62139207e-02f, 7.16714710e-02f, 8.85354578e-02f,
  4.24009515e-03f, -2.74002086e-02f, 3.40407491e-02f, 1.12224229e-01f, -1.93597600e-01f, -5.85354455e-02f, -7.69493952e-02f, 1.45036116e-01f, 3.57704721e-02f, 1.46908715e-01f,
  3.46165663e-03f, 5.22143506e-02f, 1.35824099e-01f, 2.27007508e-01f, -1.00058019e-01f, 3.27965580e-02f, 2.84600765e-01f, 4.43570055e-02f, -5.34005500e-02f, -2.80460536e-01f,
  -3.57332498e-01f, 9.34398323e-02f, -4.09005210e-02f, 7.21542835e-02f, -8.15120002e-04f, 1.82060644e-01f, 3.20912600e-02f, -3.07203140e-02f, -9.50207859e-02f, 3.02844364e-02f,
  4.17574830e-02f, 6.29308969e-02f, 2.46345121e-02f, -6.24414869e-02f, -3.73267829e-02f, 1.08645461e-01f, 1.47296026e-01f, -6.23634197e-02f, 1.48846075e-01f, 7.57333711e-02f,
  -1.59785785e-02f, 2.55969092e-02f, 1.21097557e-01f, 6.79262821e-03f, -4.92226854e-02f, 2.72477996e-02f, 4.10769805e-02f, 1.09264098e-01f, 1.18848562e-01f, 8.70189369e-02f,
  5.42874299e-02f, 2.42430400e-02f, 1.18693477e-02f, 1.81848809e-01f, 2.46227652e-01f, 2.01775189e-02f, 1.59420650e-02f, 7.92494323e-03f, 1.30063491e-02f, -1.34132385e-01f,
  1.90163389e-01f, -1.83217635e-03f, 1.36839613e-01f, -7.99194276e-02f, 2.22648978e-01f, -1.30579285e-02f, -4.27948385e-02f, 2.12960821e-02f, 1.11090906e-01f, -3.79843302e-02f,
  -6.35419274e-03f, 3.81491557e-02f, -1.86086521e-01f, 1.36700541e-01f, 9.32357311e-02f, 1.18927248e-02f, 3.82271633e-02f, 5.94443083e-02f, 1.45890117e-02f, 7.42495656e-02f,
  3.03449854e-02f, -8.44841599e-02f, -1.05552562e-02f, 1.52473599e-01f, 2.24146426e-01f, 9.42873210e-02f, -2.32555345e-03f, 1.67668372e-01f, 7.88362846e-02f, 5.54297231e-02f,
  -6.79912716e-02f, -1.65223658e-01f, -1.88888528e-03f, 3.85285690e-02f, 2.71073759e-01f, -1.30114511e-01f, -1.51515871e-01f, -9.74592566e-02f, 9.32646021e-02f, 2.76461452e-01f,
  -6.78396299e-02f, 1.04000680e-01f, 1.78268015e-01f, 5.40829971e-02f, 1.25715220e-02f, -3.32430331e-03f, 5.58625683e-02f, -5.87292425e-02f, 2.16872357e-02f, 5.99709153e-02f,
  1.26129657e-01f, 4.06182883e-03f, -1.39887454e-02f, 8.89469534e-02f, 8.31040367e-02f, -1.36321172e-01f, -8.10363665e-02f, -5.98047525e-02f, 1.09361915e-03f, 1.52034670e-01f,
  -8.78677219e-02f, -1.59860402e-01f, -5.23247349e-04f, -5.94615266e-02f, 3.34381200e-02f, -1.97227985e-01f, 3.35560665e-02f, 1.27530381e-01f, -1.29197612e-01f, -3.94520648e-02f,
  1.80863868e-02f, -5.94823062e-02f, 1.20743029e-01f, 5.74872680e-02f, 4.42954041e-02f, -1.62711907e-02f, -1.57173038e-01f, -4.61497009e-02f, 1.23657264e-01f, 5.85562587e-02f,
  -2.76164651e-01f, -1.35439672e-02f, -1.03353418e-01f, 3.55400890e-02f, -6.22699931e-02f, -4.37383689e-02f, -1.14598639e-01f, -1.84717830e-02f, -4.17250171e-02f, 1.46390200e-01f,
  1.32123483e-02f, 1.49460763e-01f, 2.05406267e-03f, 5.06097414e-02f, -4.33749985e-03f, -7.55964518e-02f, -1.44969421e-02f, -7.11852731e-03f, 1.32408574e-01f, 2.29018424e-02f,
  4.56165569e-03f, 3.89468744e-02f, 1.37812227e-01f, -1.04536876e-01f, -1.14897847e-01f, 1.14969574e-01f, -1.07772611e-02f, -5.76060191e-02f, -1.16486818e-01f, -1.33440301e-01f,
  4.18126993e-02f, 8.27829093e-02f, -8.38285908e-02f, -9.11453813e-02f, 9.08716694e-02f, 1.03996448e-01f, 7.65623003e-02f, -6.99281171e-02f, -8.16094950e-02f, 7.16101080e-02f,
  2.95271520e-02f, -8.82066786e-02f, -6.80939928e-02f, 6.47948310e-02f, 5.36177531e-02f, 3.45492549e-02f, 1.11512154e-01f, -2.32135076e-02f, 1.70458600e-01f, 1.59862656e-02f,
  1.97147392e-02f, 2.88444757e-02f, 1.83559403e-01f, 1.67886745e-02f, 1.21272609e-01f, -7.19374791e-03f, -3.71492142e-03f, -6.12665601e-02f, 8.01058710e-02f, -8.40709582e-02f,
  1.32245338e-02f, -1.57725573e-01f, -2.49075349e-02f, 1.25714555e-01f, -3.32789421e-02f, -3.67968604e-02f, -7.82904103e-02f, -1.72182843e-01f, -5.04080765e-02f, -1.92174524e-01f,
  9.20333490e-02f, -1.02612548e-01f, 5.89614920e-02f, -8.81046876e-02f, -9.55567509e-02f, -3.80304665e-03f, -5.97220846e-02f, 2.47905105e-02f, -2.58362275e-02f, -7.91388936e-03f,
  1.24129169e-01f, 7.90573284e-02f, -6.68731332e-02f, -2.34891549e-02f, 2.16044448e-02f, 6.85806945e-02f, -2.85809431e-02f, 6.84647709e-02f, -8.10641572e-02f, -6.57075783e-03f,
  -6.09420128e-02f, 1.95594653e-02f, 1.76422447e-02f, 8.23155791e-02f, -1.61149666e-01f, 6.57796860e-03f, 4.92337011e-02f, 2.31115192e-01f, 1.02839312e-02f, -2.70354152e-02f,
  7.61928484e-02f, -2.01038606e-02f, 5.55147119e-02f, 6.81367889e-02f, -6.50919899e-02f, 8.14033207e-03f, -5.79495579e-02f, 4.55272421e-02f, -5.04194796e-02f, 2.08010092e-01f,
  -5.39347641e-02f, 3.96792516e-02f, 2.00528605e-03f, -1.28629863e-01f, 1.53862298e-01f, 1.33258924e-01f, 9.86424983e-02f, 2.31110588e-01f, -5.73491305e-03f, -8.39207023e-02f,
  1.11919856e-02f, -4.83551808e-02f, 1.20332778e-01f, -2.05345258e-01f, -1.87211670e-02f, -4.81204316e-02f, 7.41240056e-03f, -1.38456076e-01f, -6.42176196e-02f, -2.58896917e-01f,
  -1.65028587e-01f, -1.19612262e-01f, -2.35278875e-01f, 4.86326031e-03f, -1.01532333e-01f, 1.36503026e-01f, 1.29950605e-02f, 3.27329934e-02f, 9.52054933e-02f, 1.02719024e-01f,
  9.26265419e-02f, 1.11811176e-01f, -1.07187606e-01f, -7.67925531e-02f, -1.45312592e-01f, 4.76838872e-02f, 7.67759457e-02f, 1.35159105e-01f, 1.09313637e-01f, 6.22682124e-02f,
  5.42168990e-02f, -9.47627574e-02f, 2.91658547e-02f, -3.50356959e-02f, 7.65069723e-02f, 5.02050109e-02f, 1.43920360e-02f, 1.00978494e-01f, 3.60940322e-02f, 4.30273563e-02f,
  -1.51438480e-02f, 1.30091965e-01f, 1.57294258e-01f, 1.37227431e-01f, 1.92371041e-01f, 6.92744255e-02f, 1.65400319e-02f, 5.29761910e-02f, 5.42285033e-02f, 2.15501133e-02f,
  -2.49118786e-02f, -1.02769192e-02f, 4.83939126e-02f, -7.55914971e-02f, 7.68990219e-02f, 2.71771755e-02f, 1.30357295e-01f, 8.29784945e-02f, 5.58781065e-02f, 4.84852679e-02f,
  1.51675761e-01f, -7.69451410e-02f, 1.27181649e-01f, 9.14504528e-02f, 1.17544480e-01f, -2.35870481e-02f, 2.74730828e-02f, -1.65964458e-02f, -1.51219149e-03f, -9.91071537e-02f,
  -4.00716215e-02f, 2.62762427e-01f, 1.26300052e-01f, 3.21576409e-02f, -4.34755385e-02f, 1.42671496e-01f, -8.00465718e-02f, -4.69845124e-02f, 5.12387566e-02f, 6.38097450e-02f,
  9.28524137e-02f, -1.78084940e-01f, -3.78746875e-02f, -1.44664412e-02f, 1.21849611e-01f, 2.18650982e-01f, -4.95982245e-02f, 2.97813918e-02f, 4.50065099e-02f, 7.63046145e-02f,
  -5.51767647e-02f, 1.50038034e-03f, -1.21025674e-01f, 1.26656666e-01f, 2.03912035e-01f, -1.36696607e-01f, 1.57485232e-02f, 6.77322969e-02f, -9.52884033e-02f, 1.78194027e-02f,
  7.24871010e-02f, -3.36290821e-02f, -7.89888501e-02f, -4.79840375e-02f, 4.33126576e-02f, 5.64278848e-02f, -8.88489857e-02f, 7.67245963e-02f, 1.47781685e-01f, 4.76258211e-02f,
  -1.05106711e-01f, 3.86880189e-02f, -1.13550812e-01f, -1.91940367e-02f, 7.43335951e-03f, 6.21440187e-02f, -1.21278003e-01f, 5.61202168e-02f, -1.63225904e-01f, -9.86453071e-02f,
  -4.24600467e-02f, 5.41308075e-02f, 1.45020083e-01f, 5.76273464e-02f, 1.10608980e-01f, 1.73983410e-01f, -1.78569816e-02f, 6.81921244e-02f, 7.34630525e-02f, -5.82305156e-02f,
  -3.06424685e-02f, -2.63528913e-01f, 6.67715073e-02f, 4.24630977e-02f, -1.76897824e-01f, 4.73861508e-02f, 1.26261115e-02f, -8.78172517e-02f, -3.82576287e-01f, 1.44381851e-01f,
  -9.92861763e-02f, 2.09210683e-02f, -1.89725667e-01f, 1.24450773e-01f, -5.60342707e-02f, 2.23934323e-01f, -3.17872614e-02f, -7.89606869e-02f, 4.22098339e-02f, -1.67047456e-01f,
  7.35304272e-03f, 2.08109498e-01f, 1.07137824e-03f, -1.17992545e-02f, 4.31414843e-02f, 5.83618023e-02f, 1.14071171e-03f, 1.15425646e-01f, -4.73169312e-02f, -6.79393858e-03f,
  2.56695524e-02f, 8.08846653e-02f, -2.15150401e-01f, -9.70091298e-02f, 4.60276306e-02f, 6.84385896e-02f, -2.15329379e-02f, 8.36303309e-02f, -8.58002082e-02f, 8.49241391e-03f,
  -3.95624973e-02f, 4.73444052e-02f, 9.39042047e-02f, -1.38440868e-02f, -4.67075631e-02f, 4.74368269e-03f, -1.64166555e-01f, -2.17579212e-02f, -7.29941018e-03f, -4.22969498e-02f,
  5.64520024e-02f, 5.92222214e-02f, -6.08257763e-03f, 1.37147829e-02f, -1.44300023e-02f, -6.86626732e-02f, -1.49115980e-01f, 1.05169281e-01f, -3.54556590e-02f, -1.18004084e-02f,
  9.55967456e-02f, -8.95685256e-02f, -1.01397559e-01f, -4.95899133e-02f, 3.14653963e-02f, -4.52609397e-02f, 1.24604747e-01f, 6.93412963e-03f, -1.29814550e-01f, 2.40706243e-02f,
  3.39351706e-02f, -6.32088706e-02f, -3.71460728e-02f, -4.85767350e-02f, -1.31076172e-01f, -3.62860709e-02f, -2.56116726e-02f, -9.07137543e-02f, -1.34514004e-01f, -9.34183598e-02f,
  -9.09299552e-02f, 4.20291089e-02f, 1.40469193e-01f, 3.98548059e-02f, 3.89455981e-03f, -1.36904314e-01f, 6.28705397e-02f, 1.91802625e-02f, -1.14006318e-01f, -2.95759160e-02f,
  6.91388324e-02f, -1.29962847e-01f, 1.40012443e-01f, -2.12106243e-01f, -7.02572986e-02f, -9.53527465e-02f, -8.13215971e-02f, -1.59786373e-01f, -2.72392660e-01f, 2.29044333e-02f,
  1.00194417e-01f, -2.89913770e-02f, -9.13255289e-02f, -8.12348723e-02f, -1.85844570e-01f, 1.73920199e-01f, -4.15303670e-02f, 2.57046372e-02f, -7.17049614e-02f, 8.48390311e-02f,
  3.23666073e-02f, -8.68561268e-02f, 2.99843643e-02f, -1.99155137e-01f, -1.29469380e-01f, -7.74184614e-02f, -5.75958528e-02f, 1.45255357e-01f, -1.44129500e-01f, -8.59887078e-02f,
  7.01943710e-02f, 1.92521080e-01f, -4.00766581e-02f, 6.90435153e-03f, -1.04785040e-02f, 8.84300843e-02f, 1.92820042e-01f, -7.67668635e-02f, 2.08320990e-02f, 5.34982532e-02f,
  -1.42519504e-01f, 9.07481685e-02f, -1.54446959e-01f, 2.05700010e-01f, -2.15980634e-01f, 7.34259114e-02f, 1.67135487e-03f, 5.21299690e-02f, 1.65617093e-01f, -9.25263911e-02f,
  -1.11256354e-01f, -2.92219460e-01f, -9.99907851e-02f, 1.72759786e-01f, 9.90284514e-03f, 3.28270718e-02f, 4.53080609e-02f, -8.36303979e-02f, -1.64339188e-02f, -1.68162078e-01f,
  -1.03497811e-01f, 1.55790031e-01f, 5.44051677e-02f, -7.17621073e-02f, 3.72413993e-02f, -1.22565627e-02f, 1.55916169e-01f, -1.03568276e-02f, -4.87343594e-02f, 5.40136248e-02f,
  2.47685108e-02f, -1.63112029e-01f, -4.82870825e-02f, -5.68247624e-02f, -3.75515074e-02f, 1.10016204e-01f, -1.13315340e-02f, -9.90202464e-03f, -8.27313587e-02f, 4.77665756e-03f,
  1.35011539e-01f, -9.86555964e-02f, 4.27710228e-02f, 3.02503239e-02f, -9.17019472e-02f, -1.00502774e-01f, 8.93841237e-02f, -3.82588319e-02f, -5.58350533e-02f, -4.55529355e-02f,
  7.02234730e-02f, 7.10011795e-02f, -1.34096630e-02f, 5.13417199e-02f, -1.17349885e-01f, 1.06378719e-01f, 2.59088036e-02f, 1.45799205e-01f, 6.26369864e-02f, 5.85327819e-02f,
  1.59476981e-01f, 1.44864926e-02f, -6.67156326e-03f, -8.57584402e-02f, 2.37947665e-02f, -2.35451031e-02f, 6.26890063e-02f, 2.12231334e-02f, 4.61125337e-02f, 5.57519197e-02f,
  -5.36199659e-02f, 1.10446669e-01f, 1.52002349e-01f, -8.22801664e-02f, 1.02226771e-01f, 1.45672774e-02f, -2.01548234e-01f, 3.24325711e-02f, 1.29564747e-01f, 2.64290278e-03f,
  -1.87580794e-01f, -1.00699358e-01f, -1.60237458e-02f, 1.38549745e-01f, 1.08159333e-01f, 6.40427321e-02f, 8.67859200e-02f, -7.51889125e-02f, 4.83295582e-02f, 3.57313454e-02f,
  -1.53557092e-01f, -1.00791171e-01f, 2.87293997e-02f, 1.19448662e-01f, 5.98860309e-02f, 1.16080299e-01f, -5.07638343e-02f, -2.16669798e-01f, 3.74764241e-02f, 1.91993728e-01f,
  -5.70089743e-02f, 4.21489999e-02f, 1.02828192e-02f, -8.44993964e-02f, 1.22359190e-02f, 4.25201617e-02f, 6.86998963e-02f, 2.74429638e-02f, 1.25664007e-02f, -9.64957848e-02f,
  -4.27377922e-03f, 3.92704867e-02f, 9.05698165e-02f, 1.19525015e-01f, -2.95115896e-02f, 6.41629845e-02f, -7.14133829e-02f, 6.87064007e-02f, 1.23227695e-02f, -1.94739122e-02f,
  -7.37676620e-02f, 1.29213527e-01f, -1.20141603e-01f, 6.36193305e-02f, -2.82888830e-01f, -2.29716688e-01f, 6.12107217e-02f, -4.33228575e-02f, -2.12316260e-01f, 4.17817105e-03f,
  2.21571207e-01f, -1.72128364e-01f, 9.94119421e-02f, 2.43300628e-02f, 2.18458995e-01f, -7.48377889e-02f, 1.93320513e-02f, 5.33036292e-02f, 2.46764198e-01f, 2.05186140e-02f,
  9.42926109e-03f, -6.65851086e-02f, 1.15886107e-01f, -2.26207823e-02f, 2.35874597e-02f, -6.86378479e-02f, -4.38601524e-03f, 1.45228073e-01f, -5.31560294e-02f, 6.76306412e-02f,
  2.76023060e-01f, 4.22886163e-02f, 8.05660188e-02f, 3.17370184e-02f, 5.18118776e-02f, -9.75688472e-02f, 2.61042137e-02f, 7.58530200e-03f, 5.37508316e-02f, -4.25234623e-02f,
  1.14666164e-01f, 1.10754296e-01f, 3.12579200e-02f, 7.81585574e-02f, 7.46521279e-02f, -6.05850704e-02f, 4.60639447e-02f, 2.36640107e-02f, 9.28840972e-03f, -5.14464080e-02f,
  -5.04688025e-02f, 5.39304838e-02f, -1.75784193e-02f, 2.44814549e-02f, -1.06308296e-01f, 5.32859303e-02f, 1.93037130e-02f, -6.64439052e-02f, 5.97543679e-02f, 9.45375338e-02f,
  4.06920239e-02f, 3.39105651e-02f, -2.02943925e-02f, 3.91076729e-02f, 5.80928624e-02f, -1.03589026e-02f, 5.26271109e-03f, -4.28307839e-02f, 6.94278702e-02f, -1.55983754e-02f,
  3.25481705e-02f, 4.28613387e-02f, 1.41140833e-01f, 4.54554707e-02f, -3.28737870e-02f, 1.28407720e-02f, 1.33046657e-01f, 1.05892420e-01f, -7.22295493e-02f, -5.46955727e-02f,
  -1.83058709e-01f, -7.32407421e-02f, 8.41845945e-03f, -1.17575349e-02f, 7.97787532e-02f, -2.09776342e-01f, 1.33442104e-01f, -8.64812657e-02f, 6.09482899e-02f, -2.96101384e-02f,
  -7.71081150e-02f, -7.61995688e-02f, -3.08990087e-02f, 8.32424685e-02f, 3.40614090e-04f, -5.50752394e-02f, -4.03498039e-02f, 7.77951851e-02f, 1.79107457e-01f, -7.12824836e-02f,
  5.13535663e-02f, 5.87928817e-02f, -4.54133227e-02f, -5.54525591e-02f, -2.96072159e-02f, 9.59448591e-02f, -6.44309744e-02f, -5.17244712e-02f, -8.31951573e-02f, 7.28674605e-02f,
  -4.61323856e-04f, 2.38189489e-01f, -2.54542027e-02f, 6.57064766e-02f, -1.63097531e-01f, 1.91274598e-01f, 1.65286120e-02f, -3.13832723e-02f, -2.13885643e-02f, -2.87728012e-02f,
  -1.67213917e-01f, 1.84744507e-01f, 8.53809703e-04f, 1.02978796e-02f, -1.47918761e-01f, 5.24354950e-02f, -1.77744385e-02f, 9.93458033e-02f, 1.27128795e-01f, 4.59113754e-02f,
  -7.58343711e-02f, 1.41909689e-01f, -2.56606806e-02f, -1.86351702e-01f, 1.94247410e-01f, -2.07000300e-01f, -2.04391349e-02f, 1.47518262e-01f, -4.38291393e-02f, 1.08012490e-01f,
  -2.33984083e-01f, 1.08688056e-01f, -1.98415399e-01f, 1.09144032e-01f, 1.77042812e-01f, 3.68743874e-02f, -1.21734589e-01f, -1.92884311e-01f, -1.64863810e-01f, 1.83980405e-01f,
  2.13626474e-02f, 3.08804493e-02f, 2.50015389e-02f, 3.13857384e-03f, -4.37221490e-02f, 3.18246680e-06f, -1.54014863e-02f, 5.19590937e-02f, -1.47790574e-02f, 3.05400360e-02f,
  5.79149351e-02f, 7.12502673e-02f, -2.91506257e-02f, 1.21990526e-02f, 8.49393830e-02f, -3.05820685e-02f, 5.85094765e-02f, 6.15302958e-02f, 2.38462351e-02f, -2.95571629e-02f,
  -6.02462282e-03f, -4.54264544e-02f, -4.04959358e-02f, -4.12312932e-02f, -4.51280735e-03f, 1.68433022e-02f, 4.49858680e-02f, -7.31951669e-02f, 5.84566742e-02f, 1.49489045e-01f,
  6.56596050e-02f, 4.16380093e-02f, -7.19194785e-02f, -4.24074568e-02f, 1.59805343e-02f, -1.59444176e-02f, 9.64438096e-02f, 2.15381179e-02f, 9.39601585e-02f, -3.43600512e-02f,
  -1.37697421e-02f, -7.58763403e-03f, 1.10245571e-01f, 6.15208149e-02f, -4.71174866e-02f, 1.27233535e-01f, 1.11239448e-01f, 8.47299322e-02f, -1.51105732e-01f, -4.69984449e-02f,
  -2.49794740e-02f, 9.51190740e-02f, 1.69440508e-01f, 8.28913320e-03f, 1.25995129e-01f, 1.95440520e-02f, 1.63856596e-01f, 2.96271220e-02f, -1.02426142e-01f, 9.44055468e-02f,
  1.67294770e-01f, -2.58871287e-01f, -7.53376782e-02f, 1.48135871e-01f, 1.67058203e-02f, 1.57060608e-01f, -4.56897030e-03f, 2.94325165e-02f, -1.52308419e-01f, 3.02731171e-02f,
  1.89527702e-02f, -2.10374389e-02f, 2.83343315e-01f, -1.84129134e-01f, 8.15317258e-02f, -2.62579508e-02f, 5.22049926e-02f, 4.76933718e-02f, 3.24733667e-02f, -8.45734589e-03f,
  5.40761687e-02f, -1.15079619e-01f, -1.00508714e-02f, -3.04506700e-02f, 6.19490519e-02f, 3.73271890e-02f, -6.88995197e-02f, -1.30606234e-01f, 1.38234869e-01f, -5.24256378e-04f,
  1.29674047e-01f, 7.44280070e-02f, 1.85395584e-01f, 1.21144548e-01f, -4.22555842e-02f, -4.09311205e-02f, 7.10751265e-02f, -1.10350065e-01f, 2.24211693e-01f, 7.16075301e-02f,
  1.13513872e-01f, -8.95385444e-02f, -1.80475786e-01f, 6.89140558e-02f, 4.52659056e-02f, 9.50233638e-02f, 1.58971220e-01f, 1.02033697e-01f, 9.57366675e-02f, -8.27555284e-02f,
  -7.70284683e-02f, -1.51494309e-01f, -1.57703847e-01f, 8.50400552e-02f, 4.89319898e-02f, 2.23591216e-02f, 1.82736114e-01f, -5.84543385e-02f, -4.48483974e-03f, 2.01554686e-01f,
  2.77129740e-01f, -7.68082812e-02f, 1.00759715e-01f, -7.72850960e-02f, 6.73863068e-02f, -1.90489978e-01f, -2.66554922e-01f, 1.72002807e-01f, -6.51183277e-02f, -9.04383585e-02f,
  9.18318331e-03f, -6.56028017e-02f, -3.55888829e-02f, 4.01350334e-02f, 6.76080883e-02f, -1.83637384e-02f, -1.84981544e-02f, 1.34978265e-01f, -5.28130829e-02f, -1.76725406e-02f,
  9.15474072e-02f, -6.87054843e-02f, -4.01410870e-02f, 7.08865561e-03f, -7.92484730e-02f, -2.02304572e-02f, -4.20904579e-03f, 1.24779239e-01f, 5.30448789e-03f, -7.62317851e-02f,
  -1.84551448e-01f, 1.98565107e-02f, -3.20335068e-02f, 1.70730911e-02f, 3.54664288e-02f, 1.03792615e-01f, -9.23741311e-02f, -3.47780734e-02f, -6.56163618e-02f, 1.02915047e-02f,
  -3.42494100e-02f, -2.30209045e-02f, 7.03663006e-02f, -3.78140882e-02f, -1.59343495e-03f, -1.45278826e-01f, 1.17062941e-01f, -3.61319780e-02f, 6.99042827e-02f, -7.95841441e-02f,
  4.90507446e-02f, 2.60693545e-04f, -8.31909105e-02f, -4.67477851e-02f, -6.92464933e-02f, -5.68732172e-02f, -4.19713818e-02f, -9.74697322e-02f, 3.19735780e-02f, 5.44593334e-02f,
  -2.21734475e-02f, 1.79554299e-02f, -8.01557451e-02f, 1.24503680e-01f, 6.33873865e-02f, 4.08831704e-03f, 1.34481490e-01f, 3.98433357e-02f, -1.15316644e-01f, 4.12534624e-02f,
  1.53137177e-01f, 9.93181020e-03f, 1.06993057e-01f, 6.47237897e-02f, 1.67326570e-01f, -3.11006270e-02f, 1.74268223e-02f, -1.09348029e-01f, -5.42327613e-02f, -6.17713183e-02f,
  4.37800847e-02f, -9.92416441e-02f, -2.21711211e-02f, -1.23558879e-01f, 1.56094283e-02f, 2.62923986e-01f, -1.49103627e-01f, 1.51798084e-01f, 2.29939967e-02f, 1.72491688e-02f,
  -1.12830043e-01f, 9.06103179e-02f, 2.82345582e-02f, -7.62080625e-02f, -5.62805496e-02f, -1.24127138e-02f, 6.37008389e-03f, 1.09091118e-01f, 6.14466406e-02f, 7.39325434e-02f,
  -4.00317162e-02f, -1.06686585e-01f, 7.51542225e-02f, 6.09346218e-02f, 9.30014998e-02f, -5.30837886e-02f, -2.30443507e-01f, -2.33047247e-01f, 3.77778746e-02f, 1.34592488e-01f,
  6.80175051e-02f, 5.93713857e-02f, 1.07674427e-01f, 1.57117605e-01f, -4.31190133e-02f, -3.67862694e-02f, -6.87492490e-02f, 2.16734931e-02f, 7.12512210e-02f, -2.07861900e-01f,
  -1.14315659e-01f, -1.36536837e-01f, 2.24613957e-02f, 3.24257389e-02f, -1.07265338e-01f, 1.42887622e-01f, -3.10275882e-01f, -1.78464249e-01f, -2.66992003e-01f, 1.36246696e-01f,
  -2.06055254e-01f, -2.27835774e-02f, -7.07246885e-02f, 6.53215824e-03f, -4.73232530e-02f, 2.76012301e-01f, -2.79393010e-02f, -2.61252187e-02f, 1.60809665e-03f, -2.21723706e-01f,
  -3.91596742e-02f, 8.23964030e-02f, 2.34456304e-02f, -9.46509540e-02f, -3.71751152e-02f, 5.98347224e-02f, -6.99688271e-02f, 1.29819717e-02f, -2.37324904e-03f, 6.15468845e-02f,
  -4.46065664e-02f, -2.69413032e-02f, 3.68075632e-02f, -4.09063883e-02f, 1.63205508e-02f, 6.41908497e-02f, -4.96922024e-02f, -2.18521785e-02f, 5.19507155e-02f, -9.51230079e-02f,
  -9.09489673e-03f, -1.76504087e-02f, -1.31891832e-01f, -2.06519011e-02f, 2.47005094e-02f, 2.67863479e-02f, -4.68235165e-02f, 5.12998365e-02f, -3.23131830e-02f, -1.34859949e-01f,
  -1.61209002e-01f, -1.08782190e-03f, 7.19571393e-03f, 9.63876620e-02f, -3.10315043e-02f, -1.93907991e-02f, -1.16429172e-01f, 1.36922710e-02f, 4.69206944e-02f, 3.62167992e-02f,
  2.84596104e-02f, -5.27701415e-02f, 1.26853585e-01f, -1.50407776e-01f, -3.52115631e-02f, 5.19560874e-02f, -1.17854908e-01f, 7.14766840e-03f, -6.17610514e-02f, -6.67154342e-02f,
  -5.00545055e-02f, -5.26597053e-02f, 9.91320089e-02f, 1.23421207e-01f, 1.66194320e-01f, -6.96449950e-02f, 1.47769069e-02f, 5.60974479e-02f, -4.63282801e-02f, 1.61002241e-02f,
  5.15308753e-02f, -1.63512155e-01f, -1.61822140e-01f, -1.10510550e-01f, 4.22661416e-02f, 8.63368362e-02f, -7.54509643e-02f, -3.42700519e-02f, 9.49974544e-03f, -6.44279793e-02f,
  3.72787789e-02f, -1.15099438e-01f, -2.10189447e-01f, 1.78901717e-01f, -1.91022661e-02f, 1.40636206e-01f, 1.01065867e-01f, 9.83901322e-02f, -1.08195255e-02f, -6.25728220e-02f,
  8.99803415e-02f, 1.43368870e-01f, -1.78404301e-02f, -6.95639700e-02f, -4.44345064e-02f, -6.97597414e-02f, 6.78297505e-02f, 8.37989450e-02f, 1.98428065e-01f, -2.49541568e-04f,
  1.49458237e-02f, 1.47223383e-01f, 3.39650875e-03f, -6.75843656e-02f, 2.67967619e-02f, -1.24226190e-01f, 4.44353884e-03f, 1.60803068e-02f, 6.56879991e-02f, -1.26947641e-01f,
  -2.61368454e-02f, -9.51915085e-02f, -1.41227931e-01f, -6.43654391e-02f, -2.13935673e-01f, 9.94976684e-02f, -6.01566508e-02f, -4.03280593e-02f, 7.07380548e-02f, 1.66371614e-02f,
  -1.63445085e-01f, -4.67268890e-03f, 2.85258770e-01f, 1.26738055e-03f, -1.89313535e-02f, 8.30311105e-02f, 2.66771197e-01f, 3.34467329e-02f, -1.55434981e-01f, -5.10873683e-02f,
  2.19067916e-01f, 6.87585101e-02f, 2.41006389e-01f, -4.11732160e-02f, -1.80141591e-02f, -3.29478784e-03f, 2.01053508e-02f, -4.37001139e-02f, 6.49459884e-02f, -4.00127508e-02f,
  6.95575848e-02f, -4.72406996e-03f, -7.58602992e-02f, -9.06008705e-02f, -4.41786982e-02f, -4.79010157e-02f, -1.81094185e-01f, 2.20921170e-02f, -2.45888196e-02f, -5.13106994e-02f,
  -8.82309377e-02f, -3.62406373e-02f, -3.47846821e-02f, -3.59744281e-02f, 1.00049293e-02f, 8.30712020e-02f, -6.41323477e-02f, -5.50163016e-02f, 2.70609912e-02f, -1.24979280e-01f,
  8.92643407e-02f, 1.14247231e-02f, 2.64292653e-03f, 2.88350526e-02f, -8.96629468e-02f, 4.74832952e-02f, -4.53690737e-02f, -5.64003326e-02f, -8.08696225e-02f, 3.36002279e-03f,
  -1.78202078e-01f, 3.53123173e-02f, -1.85063154e-01f, 4.01178561e-02f, -1.97400510e-01f, -2.65753474e-02f, -6.21970743e-02f, 2.17532236e-02f, -9.89830494e-02f, -1.52082533e-01f,
  -6.53958917e-02f, -4.12347056e-02f, -2.28377823e-02f, -2.28249040e-02f, 7.59129040e-03f, 2.13096081e-03f, -9.89477038e-02f, -2.91803037e-03f, 2.82250382e-02f, -3.06910854e-02f,
  -3.64746563e-02f, -2.02661939e-02f, 4.95767742e-02f, 3.00374031e-02f, -1.27658416e-02f, 5.23520671e-02f, -9.36617553e-02f, 8.14005919e-03f, -7.02345148e-02f, -6.55283704e-02f,
  5.00242878e-03f, -5.88089973e-02f, 4.47158106e-02f, 9.40580890e-02f, -5.18018566e-02f, 1.53865265e-02f, -9.73032266e-02f, 3.34685482e-02f, -1.48921227e-02f, -5.58385365e-02f,
  8.09921175e-02f, -3.67647186e-02f, 9.60999355e-02f, -1.19295744e-02f, -1.54876888e-01f, 6.71335682e-02f, 1.04649976e-01f, -8.44006520e-03f, -2.07429320e-01f, 1.75443776e-02f,
  -3.45672220e-02f, 8.73121768e-02f, -9.35143456e-02f, -1.40172401e-02f, -1.03776380e-01f, -8.46755132e-02f, -3.77615243e-02f, -2.16700789e-02f, -1.18084089e-03f, -6.52397797e-02f,
  5.99028431e-02f, -1.95491668e-02f, -5.59272170e-02f, -1.10379428e-01f, -1.12534329e-01f, -9.23221838e-03f, 4.85598743e-02f, 5.87880537e-02f, -1.12311244e-02f, -1.18754521e-01f,
  -1.63900971e-01f, -2.43513405e-01f, 6.88252784e-03f, 1.26551986e-01f, -1.70970157e-01f, -9.21436995e-02f, -3.52645181e-02f, -2.58357637e-02f, -1.43961958e-03f, 7.47358873e-02f,
  1.08572394e-01f, -5.58198914e-02f, 1.07049182e-01f, -3.75565141e-02f, -1.79265812e-02f, 1.74614298e-03f, 2.40543321e-01f, 6.55828267e-02f, 2.13637486e-01f, 1.31388143e-01f,
  1.45199761e-01f, -1.04330547e-01f, 3.71350646e-02f, 2.95356568e-02f, -5.46909450e-03f, 4.41677719e-02f, 3.51027362e-02f, 1.00316875e-01f, 1.12702511e-02f, -8.03342834e-02f,
  1.00200819e-02f, -1.80619732e-02f, 1.03240587e-01f, 6.17415011e-02f, -1.10126091e-02f, -2.57023033e-02f, 1.18298993e-01f, -8.36686697e-03f, 5.11481687e-02f, 1.05803572e-01f,
  -2.29913369e-02f, -8.75672847e-02f, 8.61344039e-02f, -5.34781534e-03f, 4.05207369e-03f, 2.34145820e-02f, 8.75366926e-02f, -6.09171856e-03f, 3.47473733e-02f, 1.09219834e-01f,
  5.10981902e-02f, 3.32632624e-02f, -1.02058109e-02f, 7.21175596e-02f, 1.18549928e-01f, 4.24507409e-02f, 1.38067350e-01f, -4.01717909e-02f, -7.85704106e-02f, 3.95482443e-02f,
  -1.50822373e-02f, 1.64193772e-02f, -1.37665225e-02f, 2.24319249e-02f, 2.91542839e-02f, 6.87536299e-02f, -8.71831458e-03f, -7.27344006e-02f, 2.49509066e-02f, 8.32898915e-02f,
  -9.03161094e-02f, 2.68646423e-03f, 5.84196337e-02f, -1.01963483e-01f, -8.71981960e-03f, 5.27013279e-02f, -3.03691607e-02f, -4.43038158e-02f, 8.73588249e-02f, 5.86230308e-02f,
  -6.88963011e-02f, 2.12250147e-02f, 5.69297485e-02f, 6.42603710e-02f, 2.32346356e-01f, -1.37700364e-01f, -2.99821584e-03f, -2.22989008e-01f, -1.46341309e-01f, 5.53798536e-03f,
  6.68644011e-02f, 1.12071425e-01f, -3.05935238e-02f, -1.84452031e-02f, -4.67958748e-02f, 3.17576565e-02f, -1.98295981e-01f, 7.88240284e-02f, 7.20131770e-02f, -5.77257648e-02f,
  1.11122824e-01f, 5.20766526e-02f, 1.06058074e-02f, -8.67614988e-03f, -2.24481001e-02f, -4.22581509e-02f, -2.95387417e-01f, -5.17041534e-02f, 1.61683336e-01f, 9.22208000e-03f,
  7.24228024e-02f, 1.91043392e-02f, 1.27388954e-01f, 1.21401241e-02f, -2.19286941e-02f, -1.77931756e-01f, -8.11863318e-02f, -8.55918676e-02f, -4.62607965e-02f, 1.57324940e-01f,
  -3.52175310e-02f, 3.85651104e-02f, -1.01333760e-01f, -7.86120519e-02f, 8.23045149e-02f, 5.31204082e-02f, 7.87846521e-02f, -1.96710393e-01f, -5.81750721e-02f, -1.18841186e-01f,
  -9.69605800e-03f, 1.78083852e-01f, -2.01123789e-01f, 8.43455642e-02f, -2.12469082e-02f, -6.37338609e-02f, -6.08086493e-03f, 1.57498747e-01f, -6.13573268e-02f, -7.28232414e-02f,
  5.30800037e-02f, -1.60338283e-01f, -2.09997267e-01f, 1.77488387e-01f, 6.00212738e-02f, 1.71707273e-01f, 2.68398076e-01f, 1.74659669e-01f, -3.71147543e-02f, -1.25718147e-01f,
  -2.55967788e-02f, 4.07087766e-02f, 8.07125494e-02f, -5.91654554e-02f, -2.03615353e-02f, 7.39695621e-04f, 2.75746230e-02f, -9.99729522e-03f, -4.24404293e-02f, 8.48885812e-03f,
  2.06329413e-02f, -8.27934518e-02f, 2.49004886e-02f, 4.44404259e-02f, -2.95139831e-02f, 4.01340239e-02f, 4.95441898e-04f, 6.24639727e-02f, 2.80255452e-02f, 7.60499435e-03f,
  -4.35281172e-02f, -1.04246803e-01f, 1.17937820e-02f, -2.76600961e-02f, -7.49277547e-02f, 4.88846377e-02f, 1.53158233e-02f, 1.71357747e-02f, 2.51921546e-02f, 6.50529936e-02f,
  6.96090683e-02f, 3.98657843e-02f, 1.29978105e-01f, -2.68249828e-02f, -2.36099735e-02f, -3.80309708e-02f, 1.94040742e-02f, 9.88436341e-02f, 9.82500985e-02f, 2.63103135e-02f,
  -4.19617482e-02f, 2.34378763e-02f, 2.61780005e-02f, 3.60337794e-02f, -2.32301559e-02f, -6.06158786e-02f, 8.20602756e-03f, -8.66661686e-03f, -1.03363611e-01f, 6.02314323e-02f,
  -6.07790649e-02f, 3.37819159e-02f, 4.75225970e-02f, -6.08845390e-02f, -1.20584801e-01f, -1.91350654e-01f, -1.71416011e-02f, -1.36702126e-02f, 1.08078681e-01f, -4.60500605e-02f,
  -6.04522228e-02f, -4.57778685e-02f, -1.33118629e-01f, 1.08551838e-01f, -7.77849869e-04f, 5.23051061e-02f, -5.58402017e-02f, -9.84591022e-02f, 6.16299771e-02f, -2.02431493e-02f,
  -6.33650869e-02f, 2.62643509e-02f, 5.64739257e-02f, -2.92542111e-02f, 1.86032102e-01f, 3.86085622e-02f, -1.40180305e-01f, 1.07465476e-01f, -7.58509561e-02f, 1.09075181e-01f,
  1.57278284e-01f, 8.48557130e-02f, -6.66736811e-02f, -1.12798037e-02f, 1.52068600e-01f, 7.69637227e-02f, -1.58130065e-01f, -3.00450046e-02f, 1.90340336e-02f, -1.17416382e-02f,
  3.47193964e-02f, 7.38791227e-02f, 1.47993356e-01f, -4.06087888e-03f, 2.96962485e-02f, 1.37643918e-01f, 7.99875930e-02f, -1.19600296e-01f, -1.48565779e-02f, -1.12333506e-01f,
  -4.08841521e-02f, -1.37009434e-02f, 1.82736460e-02f, -8.58558044e-02f, -4.16632034e-02f, 2.07232684e-02f, -6.81727454e-02f, 1.28525430e-02f, -2.10804358e-01f, 2.18258286e-03f,
  4.77205925e-02f, -1.22867361e-01f, 6.15602769e-02f, 7.98034668e-03f, -1.65083915e-01f, -4.54128021e-03f, 3.00809085e-01f, 3.17299552e-02f, 2.93011144e-02f, 1.24127693e-01f,
  2.85035521e-01f, 1.21463381e-01f, -1.36087105e-01f, -1.81667909e-01f, 1.61609367e-01f, 1.27632901e-01f, 2.09929213e-01f, -1.53114244e-01f
};

// L1_fan_Wp_bar (Shape: 26 x 128)
const int L1_fan_Wp_bar_rows = 26;
const int L1_fan_Wp_bar_cols = 128;
const float L1_fan_Wp_bar_data[] = {
  8.74283910e-03f, 2.09443625e-02f, 7.94505700e-02f, -1.05863668e-01f, 3.93062420e-02f, 8.17252249e-02f, -2.09256131e-02f, -6.26928955e-02f, 1.49700299e-01f, 4.19777781e-02f,
  8.34672228e-02f, -1.73729900e-02f, 3.43052261e-02f, -1.19527601e-01f, 3.04862531e-03f, 1.48882449e-01f, 6.85208291e-02f, -4.52157706e-02f, -3.49660125e-03f, -1.46973565e-01f,
  -1.27273286e-02f, 1.33440033e-01f, -5.02169356e-02f, 2.97901779e-02f, 8.07200298e-02f, -6.14354946e-02f, -4.64992300e-02f, -1.27949059e-01f, 6.27841800e-02f, 1.15825005e-01f,
  3.63809131e-02f, 3.55435163e-02f, -4.86953855e-02f, 4.97017018e-02f, 3.60010304e-02f, 2.88892561e-03f, -2.13208664e-02f, 1.34980813e-01f, -5.62080070e-02f, 3.96406604e-03f,
  -9.42896828e-02f, 1.44730851e-01f, 9.73759145e-02f, 5.96392434e-03f, 3.39829139e-02f, 5.32066450e-02f, -2.91605666e-02f, 1.55557692e-01f, 4.87980992e-02f, -3.93366329e-02f,
  8.13851058e-02f, -5.60701191e-02f, 2.18450222e-02f, 2.26152334e-02f, 2.50547118e-02f, -6.79534152e-02f, -1.94478855e-02f, 5.52549213e-02f, 3.19333784e-02f, 3.49413673e-03f,
  5.94469868e-02f, -7.25675672e-02f, -8.38241279e-02f, -1.74158618e-01f, 1.51376948e-02f, -1.44865541e-02f, -1.73777089e-01f, -1.37097582e-01f, 5.77080026e-02f, 1.80920303e-01f,
  -2.61284946e-03f, 5.54536246e-02f, -9.27648917e-02f, -5.01782894e-02f, 5.50071374e-02f, 3.39443982e-02f, -3.15007828e-02f, -5.89546561e-03f, 8.91412273e-02f, 2.72757169e-02f,
  7.11793229e-02f, 1.12520810e-02f, -2.06321720e-02f, -5.44490293e-02f, -2.66779810e-01f, 1.15755878e-01f, -3.98544520e-02f, 9.65958089e-02f, 6.24970533e-02f, 7.88776353e-02f,
  -2.89927442e-02f, -1.44967837e-02f, 1.06515877e-01f, 1.95624769e-01f, -2.06628125e-02f, -1.02498084e-01f, -9.91175547e-02f, -1.23227417e-01f, 3.89755629e-02f, 2.32394740e-01f,
  1.13357268e-01f, 9.62896422e-02f, 2.53372878e-01f, 1.97460339e-03f, 1.18731529e-01f, -9.25072357e-02f, 5.69352560e-05f, -8.10762122e-02f, -1.86413676e-01f, 7.25561902e-02f,
  -1.65640446e-03f, -1.59936935e-01f, 2.71265417e-01f, -2.78828979e-01f, -1.73476309e-01f, 9.19966102e-02f, 1.32493347e-01f, 3.86938341e-02f, 2.51276016e-01f, -1.25965416e-01f,
  -1.65531076e-02f, 8.74003172e-02f, 2.37928838e-01f, 1.27490208e-01f, 2.01765880e-01f, 1.11347899e-01f, -6.73467442e-02f, -1.84702784e-01f, 7.24820495e-02f, 1.11654490e-01f,
  1.05692205e-04f, 1.15659118e-01f, 1.15456343e-01f, -4.80858348e-02f, 5.22155873e-02f, 1.00053862e-01f, 8.61769766e-02f, 1.29989430e-01f, 1.28952816e-01f, 7.58894682e-02f,
  2.20266134e-01f, 9.23767388e-02f, 7.27298856e-02f, 3.51847485e-02f, 5.45292348e-02f, 7.58501366e-02f, -7.87471086e-02f, 6.19468242e-02f, 1.18794687e-01f, 1.15029685e-01f,
  -8.17822888e-02f, 5.63515946e-02f, 1.38430325e-02f, 1.92463562e-01f, 9.23230201e-02f, 1.06194496e-01f, 1.45237103e-01f, 2.60680206e-02f, 9.29407850e-02f, 1.15951106e-01f,
  4.70434129e-02f, 6.35700896e-02f, 5.20584062e-02f, 1.56610552e-02f, 8.95909518e-02f, 1.59044921e-01f, 2.37706229e-01f, 1.53654749e-02f, -3.18634361e-02f, 1.05104841e-01f,
  3.05155396e-01f, 2.24199608e-01f, 1.09002963e-01f, 5.05981743e-02f, 1.94276460e-02f, 1.33359358e-01f, 4.09370661e-02f, 4.91828769e-02f, -1.66008621e-01f, -1.12067744e-01f,
  1.40055586e-02f, -4.56879213e-02f, 9.60223675e-02f, 1.37231678e-01f, 1.11966254e-02f, 3.87948602e-02f, 4.91949692e-02f, -2.97040969e-01f, 7.65227899e-02f, 1.06701314e-01f,
  8.26553032e-02f, 1.74656242e-01f, 1.11128442e-01f, -1.75663874e-01f, -9.61044431e-02f, 5.29124364e-02f, -3.92336659e-02f, 1.06413744e-01f, -9.95621607e-02f, -1.04404807e-01f,
  1.20567821e-01f, 1.48426881e-02f, -1.13609500e-01f, 6.79872790e-03f, -2.28216797e-01f, 3.32628280e-01f, 5.60566634e-02f, 2.47176692e-01f, 6.50858805e-02f, 2.92594492e-01f,
  -5.57157472e-02f, -1.33141264e-01f, -1.46036251e-02f, 2.85941392e-01f, 4.39870767e-02f, 7.96786025e-02f, 1.55968606e-01f, -1.31080046e-01f, -5.46927154e-02f, 1.59809023e-01f,
  1.76367745e-01f, -5.68398945e-02f, 3.15876082e-02f, 1.12739436e-01f, -8.63264054e-02f, -9.20883752e-03f, -1.20645396e-01f, 4.85534593e-02f, 4.01933976e-02f, -5.06314412e-02f,
  8.38551819e-02f, -4.61415425e-02f, -7.15453103e-02f, -9.36438739e-02f, 3.23392227e-02f, -8.81690308e-02f, 4.06774506e-02f, -1.48156092e-01f, 1.07878774e-01f, -3.42562981e-02f,
  1.83200538e-01f, -1.14764482e-01f, -1.05719768e-01f, -1.80461735e-01f, 4.29324716e-01f, 7.19690137e-03f, 4.82820831e-02f, -1.81027874e-01f, 1.26729429e-01f, -1.96056366e-01f,
  -1.61667541e-01f, 4.96246852e-02f, 2.04077557e-01f, 3.08546811e-01f, 4.06667054e-01f, -6.84295520e-02f, 2.76902653e-02f, 1.94986477e-01f, 6.47628978e-02f, 2.03869298e-01f,
  1.94154344e-02f, 7.03479871e-02f, 5.73490970e-02f, 2.03295857e-01f, 6.98732659e-02f, 6.02533063e-03f, 1.38866171e-01f, 1.61051914e-01f, 2.09738627e-01f, 3.40518579e-02f,
  2.34648153e-01f, 4.12080102e-02f, -2.61222739e-02f, 1.00967497e-01f, -5.46244048e-02f, 2.11894348e-01f, 1.80144027e-01f, 1.55709475e-01f, 2.08076760e-02f, 1.53501183e-01f,
  1.47507921e-01f, 1.25734746e-01f, 1.58283472e-01f, -2.05666777e-02f, 8.48609954e-02f, 1.00224122e-01f, 4.01244126e-02f, 2.34371766e-01f, -4.31440100e-02f, 5.18001355e-02f,
  1.07990801e-01f, 1.11275442e-01f, 1.27803236e-02f, -3.80063057e-02f, 1.75999463e-01f, 3.30030099e-02f, -2.83548255e-02f, 9.31245014e-02f, 2.36038312e-01f, 2.89425366e-02f,
  1.85809642e-01f, 4.73681875e-02f, 1.21183693e-01f, 2.75782458e-02f, -5.02006151e-02f, 3.87477502e-02f, -2.31468007e-02f, -1.24793835e-01f, -1.42214254e-01f, 5.40796183e-02f,
  9.67914909e-02f, 8.22397172e-02f, 1.28040779e-02f, 2.48591155e-02f, -7.07963407e-02f, -2.18946308e-01f, -5.58907166e-02f, 1.93676934e-01f, 2.39250571e-01f, -1.42493725e-01f,
  4.90047187e-02f, -1.47718847e-01f, 2.86886934e-02f, 2.31543958e-01f, -5.94721474e-02f, 6.19137362e-02f, 4.00980935e-02f, -1.29852146e-01f, -1.72144756e-01f, -2.07430515e-02f,
  -4.01311815e-01f, -1.73762560e-01f, 1.43424004e-01f, -1.84656382e-02f, 1.61599934e-01f, 1.50966957e-01f, -5.33059910e-02f, 1.39341399e-01f, -1.26709700e-01f, -9.89990383e-02f,
  -1.42724469e-01f, -8.17637146e-02f, 7.69196302e-02f, 6.55526891e-02f, 2.98793763e-02f, 8.88818875e-03f, -2.55278081e-01f, -3.10485475e-02f, -2.16902718e-01f, -1.87113106e-01f,
  -8.61343741e-03f, -1.06893085e-01f, 2.29327288e-02f, 1.70527235e-01f, -2.50627071e-01f, -1.06051892e-01f, 1.29630882e-03f, -4.21912521e-02f, 2.07157865e-01f, -1.63605228e-01f,
  2.16747090e-01f, -1.44195572e-01f, -7.73751885e-02f, 4.54019830e-02f, -2.97361910e-01f, -4.71315123e-02f, 2.75554866e-01f, -1.98420938e-04f, 6.58473372e-02f, -1.05654947e-01f,
  2.01595008e-01f, 1.57341156e-02f, -4.04592864e-02f, -7.76616782e-02f, 1.45155847e-01f, -2.47833416e-01f, -3.54515016e-01f, 1.73297390e-01f, -3.64229293e-03f, 1.46602854e-01f,
  -2.28037406e-02f, 2.87051409e-01f, 2.66864628e-01f, -1.58034161e-01f, 6.25366196e-02f, 1.22176670e-01f, 3.78827974e-02f, -1.32227968e-02f, 1.20720804e-01f, 4.91011105e-02f,
  5.87265268e-02f, -6.60367459e-02f, 9.67374071e-02f, 2.39294708e-01f, 6.39208127e-03f, 1.56919956e-02f, 2.22830057e-01f, -5.61043099e-02f, -2.94347457e-03f, 1.73028484e-01f,
  1.39378011e-01f, 1.29000871e-02f, -1.72703657e-02f, 4.06899340e-02f, 2.03119740e-02f, 3.46902292e-03f, -9.21008140e-02f, 7.43425637e-02f, 7.82158226e-02f, 1.79415807e-01f,
  3.56229246e-02f, -3.54346074e-02f, 3.72794345e-02f, 4.57289629e-03f, -2.74534859e-02f, -8.59306678e-02f, 8.15736651e-02f, 1.34482279e-01f, 5.37515655e-02f, 7.87142739e-02f,
  1.99882668e-02f, 2.87127662e-02f, 1.85647666e-01f, 4.55877855e-02f, 6.71060309e-02f, 6.06276654e-02f, 8.22618231e-02f, 1.12495661e-01f, 1.31034970e-01f, 1.32490128e-01f,
  4.83388156e-02f, -5.91576360e-02f, 4.79425900e-02f, 1.32438606e-02f, 3.67569737e-02f, -9.69359130e-02f, -3.18282470e-02f, -5.94708063e-02f, -5.01681119e-02f, 8.64827819e-03f,
  2.67391000e-02f, -9.10262093e-02f, 3.31549197e-02f, -2.44604632e-01f, 1.67918876e-01f, -6.75325319e-02f, 9.89683047e-02f, -3.42271440e-02f, -3.49743664e-02f, 7.74500594e-02f,
  1.36672677e-02f, -2.95324763e-03f, 3.44443172e-02f, 7.38953501e-02f, -2.49942336e-02f, -5.20547212e-04f, 1.65845975e-01f, -6.87659755e-02f, 8.62943605e-02f, 3.56717631e-02f,
  -1.69836864e-01f, 2.52145022e-01f, -1.30529404e-01f, 2.19534725e-01f, 1.85223907e-01f, -2.01103762e-02f, -8.19309503e-02f, -5.92620596e-02f, 4.75797281e-02f, 1.21824510e-01f,
  2.54164031e-03f, 2.14127928e-01f, 2.01485232e-01f, 2.35243645e-02f, 4.03045528e-02f, 9.84772071e-02f, 8.08855221e-02f, 4.26678583e-02f, 3.18015851e-02f, 6.24062121e-02f,
  -5.87700978e-02f, 1.53971864e-02f, 6.00005593e-03f, 7.32431561e-02f, 6.17898703e-02f, -7.53714815e-02f, -7.27135241e-02f, 6.62643462e-03f, -1.34184495e-01f, 2.40281582e-01f,
  1.43769071e-01f, 1.50744960e-01f, 2.09543020e-01f, 1.98068656e-02f, -1.57826394e-01f, 2.23401845e-01f, 2.05907747e-01f, -1.17513537e-01f, -1.06424682e-01f, 5.60676716e-02f,
  1.78063199e-01f, -5.27646579e-02f, -2.54522085e-01f, -1.50538653e-01f, 2.49338791e-01f, -8.46306235e-02f, -1.85352355e-01f, -7.75094777e-02f, -6.32569194e-02f, 1.20721944e-01f,
  2.18583301e-01f, 2.86196649e-01f, 5.07848673e-02f, 2.78692711e-02f, -6.23570830e-02f, 1.25961617e-01f, 8.70066732e-02f, -2.95727029e-02f, 9.53670871e-03f, 1.34454137e-02f,
  -7.99557939e-02f, 7.31233954e-02f, -2.89868563e-02f, 5.79910493e-03f, -1.02843300e-01f, 5.42704426e-02f, -4.28249761e-02f, -5.04823662e-02f, 2.56223511e-03f, -7.61438534e-02f,
  1.49275148e-02f, 7.31742755e-02f, 8.08806792e-02f, 1.41441543e-02f, 5.56263328e-02f, 7.37834647e-02f, -5.15241455e-03f, -3.55655141e-02f, 2.62443833e-02f, -8.97006225e-03f,
  4.09408100e-03f, 5.14802001e-02f, -9.54384133e-02f, -1.68507397e-02f, 2.62127556e-02f, 1.95823070e-02f, 5.44180050e-02f, 1.11425206e-01f, 7.81979784e-02f, -1.94418095e-02f,
  -5.05073257e-02f, -1.06154144e-01f, -4.76903804e-02f, -2.41561569e-02f, 1.57921147e-02f, 5.60508296e-02f, -3.33680250e-02f, 6.95937052e-02f, 4.82921896e-04f, -2.79430617e-02f,
  1.18784411e-02f, -6.46964237e-02f, -6.29149228e-02f, 5.55578209e-02f, -1.85723566e-02f, -6.91912621e-02f, -1.83567926e-01f, 2.65553333e-02f, 3.94943282e-02f, 5.65273361e-03f,
  2.56804764e-01f, 4.95030871e-03f, -2.20364943e-01f, -5.61792478e-02f, -3.82141918e-02f, 1.63401410e-01f, 1.24869440e-02f, 2.02020649e-02f, -1.27223298e-01f, -2.65125129e-02f,
  2.57795621e-02f, 1.20471641e-01f, 8.54929760e-02f, 8.60177260e-03f, 1.43623739e-01f, 5.34109510e-02f, 2.64725268e-01f, 1.98101457e-02f, -1.55369282e-01f, 2.18250841e-01f,
  -1.76765397e-01f, 7.16140047e-02f, 1.24399185e-01f, 7.86743984e-02f, 3.69290188e-02f, -5.47017809e-03f, 9.03751776e-02f, 1.49944410e-01f, -9.46207419e-02f, -8.32978711e-02f,
  4.07231562e-02f, -1.77569389e-01f, 1.36309132e-01f, 1.27910927e-01f, 1.17953897e-01f, -1.14196710e-01f, 3.66757736e-02f, 1.32231116e-01f, 3.87966409e-02f, -1.12043187e-01f,
  4.09692302e-02f, -1.56921938e-01f, 1.64389506e-01f, 8.81864652e-02f, 7.76596963e-02f, -1.56597719e-02f, 1.63556170e-02f, -6.26747757e-02f, -5.71825653e-02f, -1.37663960e-01f,
  4.17650700e-01f, 2.47508079e-01f, 9.30984020e-02f, 2.15930253e-01f, -1.40183344e-01f, 4.50812802e-02f, -3.17139961e-02f, 1.88226864e-01f, 2.25765720e-01f, 1.91905513e-01f,
  -2.56666273e-01f, -4.48614098e-02f, 3.61383110e-01f, 1.92427244e-02f, -1.67302832e-01f, -8.61407518e-02f, -3.24725471e-02f, 3.33250850e-01f, 2.53981978e-01f, 2.35345811e-02f,
  4.64641079e-02f, -1.15909055e-03f, 1.17205992e-01f, -1.19535521e-01f, -3.26860212e-02f, 8.50899145e-02f, 3.13477553e-02f, 5.09643517e-02f, 1.81834638e-01f, -5.42305550e-03f,
  1.58009619e-01f, 1.61901981e-01f, 1.24799758e-01f, 2.00602133e-02f, 1.54971302e-01f, 1.40015885e-01f, 8.03197455e-03f, 1.42343730e-01f, 1.72421947e-01f, 1.97215769e-02f,
  6.62364960e-02f, 1.66722070e-02f, 1.27699688e-01f, 5.43284230e-02f, 1.76991433e-01f, -5.01258411e-02f, 1.00710392e-01f, -6.70818835e-02f, 4.62440737e-02f, 2.20827267e-01f,
  1.02884777e-01f, 1.71717897e-01f, -7.39117488e-02f, 3.27939317e-02f, 5.43651432e-02f, 9.10949260e-02f, 9.01039317e-02f, 1.76893860e-01f, -1.40883327e-01f, 5.62168993e-02f,
  -3.26605327e-02f, 8.24145824e-02f, 6.47912100e-02f, -1.44736962e-02f, 1.32708088e-01f, -1.53900050e-02f, 1.65737420e-01f, 1.00735307e-01f, 1.33650273e-01f, 9.18100476e-02f,
  1.32838264e-01f, -1.48581229e-02f, -6.43523633e-02f, -1.11948745e-03f, 2.44100004e-01f, -1.61067750e-02f, -1.56368483e-02f, 1.23312641e-02f, -6.56819493e-02f, 1.03806533e-01f,
  2.29609147e-01f, 3.79731692e-02f, -3.06406859e-02f, -2.71252990e-01f, 9.47548598e-02f, -1.59691513e-01f, 1.15579166e-01f, 4.84863408e-02f, -1.23020075e-01f, -1.12820148e-01f,
  1.42071679e-01f, 9.60198976e-03f, -2.47827336e-01f, 1.05115278e-02f, -1.49723068e-01f, 2.21313372e-01f, 3.73809338e-01f, -6.49817660e-02f, -1.15593612e-01f, -5.76014630e-02f,
  -6.85531497e-02f, -7.57875293e-02f, -3.97142731e-02f, 6.16959147e-02f, -1.16116159e-01f, -4.73278500e-02f, -1.21837243e-01f, -8.09909478e-02f, -5.70336878e-02f, 2.80281395e-01f,
  -5.38883880e-02f, -5.39277717e-02f, -5.06906584e-02f, 1.17078811e-01f, -5.44332527e-02f, -1.24528669e-01f, -3.83630767e-02f, -1.26468420e-01f, -1.49902450e-02f, 8.59585330e-02f,
  -3.76194157e-02f, 1.62997877e-03f, -1.09213069e-01f, 1.93913430e-01f, 3.83651778e-02f, -1.04179785e-01f, 1.29891843e-01f, 2.12831333e-01f, -2.69515544e-01f, -4.35476825e-02f,
  3.18693578e-01f, -5.00666127e-02f, -7.30861053e-02f, 5.82358837e-02f, 1.40888393e-01f, 6.27654716e-02f, 5.48775867e-02f, 1.83333591e-01f, -4.47019003e-02f, 5.36417961e-02f,
  -7.93783888e-02f, -3.03393626e-03f, 4.57147807e-01f, -1.57311782e-01f, 1.46213427e-01f, -3.95014942e-01f, -2.78570056e-01f, -7.39554912e-02f, 1.37791857e-01f, -1.10759912e-02f,
  5.55758886e-02f, -1.37441223e-02f, 6.12971894e-02f, 1.51598647e-01f, 1.46044523e-01f, 2.22573616e-02f, -9.82063636e-03f, 4.23481539e-02f, -2.95582460e-03f, -7.40016699e-02f,
  -1.88939512e-01f, 1.13549575e-01f, 9.42437723e-02f, 2.75314655e-02f, 1.04560889e-01f, 1.31326199e-01f, 4.59774099e-02f, 5.49999252e-02f, -5.34981154e-02f, -3.32467668e-02f,
  3.22506614e-02f, 1.98205877e-02f, -7.01064765e-02f, 1.04850836e-01f, 1.03797577e-01f, 7.60320500e-02f, 8.36549774e-02f, -2.45376509e-02f, 4.51316051e-02f, -1.27018066e-02f,
  -8.73690564e-03f, 8.17696750e-02f, 1.01233199e-01f, 4.00450975e-02f, 9.15598497e-02f, 1.60498872e-01f, 1.19144551e-01f, -1.87528618e-02f, 3.94539423e-02f, -2.12743469e-02f,
  -1.76499054e-01f, -2.50626560e-02f, 4.34757769e-02f, 1.23059720e-01f, 4.50657345e-02f, 2.89756954e-02f, 2.02784445e-02f, 4.60343948e-03f, 4.03295904e-02f, 7.62680918e-02f,
  1.33139968e-01f, -5.38766123e-02f, 5.67647889e-02f, -5.72659448e-02f, 3.40208784e-02f, 6.96329847e-02f, 3.33496258e-02f, 2.84067392e-01f, -5.74712493e-02f, -1.64561003e-01f,
  -4.53209281e-02f, 2.35159352e-01f, -6.23920150e-02f, 4.34446223e-02f, -8.67983233e-03f, -8.82531330e-02f, -7.49466047e-02f, -5.61188161e-02f, -1.74265712e-01f, 6.42302185e-02f,
  1.41238481e-01f, -2.59965081e-02f, 1.01097926e-01f, -4.58363816e-02f, 1.15036927e-02f, -2.75778007e-02f, -7.71171376e-02f, -1.64884046e-01f, -2.79046446e-02f, -1.32507950e-01f,
  -5.11994101e-02f, 9.44051147e-02f, 1.56533524e-01f, 5.01530394e-02f, -1.04316920e-01f, -2.48938605e-01f, 8.70186137e-04f, -5.50323166e-02f, 1.03439599e-01f, 3.55261527e-02f,
  2.26568237e-01f, 1.50709048e-01f, -4.05304544e-02f, 7.28716925e-02f, 5.13670184e-02f, -1.18369646e-01f, 1.41660616e-01f, -1.74707308e-01f, 4.28042859e-02f, 6.82812035e-02f,
  6.59491792e-02f, 1.63470015e-01f, -1.96522191e-01f, -2.65539866e-02f, 4.74937372e-02f, -1.22299798e-01f, 2.11768582e-01f, 2.37603948e-01f, 1.25913113e-01f, 2.42448673e-01f,
  -1.57133758e-01f, 3.00378293e-01f, 3.16323638e-02f, 1.15048528e-01f, 1.25118732e-01f, 2.39368767e-01f, -1.25432285e-02f, 5.84988594e-01f, 3.33046377e-01f, -4.44127209e-02f,
  2.63241112e-01f, -6.21613935e-02f, 1.03200652e-01f, -2.89481908e-01f, -1.89570084e-01f, 1.42245770e-01f, 5.33248782e-02f, -4.19839956e-02f, 2.46148556e-02f, -6.77701458e-02f,
  -5.12325987e-02f, 7.62994364e-02f, 1.97048653e-02f, -1.28727362e-01f, 4.55857143e-02f, 5.51864598e-03f, -1.41520635e-04f, 6.81337416e-02f, 5.68547752e-03f, 1.40701830e-02f,
  1.77847162e-01f, -1.07067209e-02f, -5.46296947e-02f, 8.09131563e-02f, 1.66869536e-02f, 7.10303560e-02f, 1.49537493e-02f, 2.19462835e-03f, 1.11739762e-01f, -2.52166297e-02f,
  -1.73344482e-02f, -9.33441967e-02f, 6.50162026e-02f, -2.65913587e-02f, 1.63550042e-02f, 6.58816919e-02f, -3.40794511e-02f, 1.22729897e-01f, 3.34277079e-02f, 4.01308797e-02f,
  -7.48157799e-02f, -2.44697527e-04f, -6.92275632e-03f, -6.03815801e-02f, -6.61244020e-02f, -8.53755623e-02f, -1.08976282e-01f, -8.78810976e-03f, -4.26647179e-02f, 1.07630253e-01f,
  -2.74403784e-02f, 5.18100485e-02f, -5.03034750e-03f, 6.66769743e-02f, 6.97110742e-02f, -5.29402457e-02f, 9.01763588e-02f, 7.12680593e-02f, 1.21274792e-01f, 1.17028631e-01f,
  -1.80825040e-01f, 7.85123091e-03f, -5.42385876e-02f, -1.29071593e-01f, 1.24143556e-01f, -9.22075659e-02f, -7.17431679e-02f, -8.26259851e-02f, -9.16270986e-02f, 1.10555641e-01f,
  -1.10086076e-01f, 2.00236980e-02f, -6.90541789e-02f, 5.43326437e-02f, 6.42290059e-03f, 3.43736000e-02f, 3.07230279e-02f, 1.08088531e-01f, -1.24920988e-02f, -2.60987063e-03f,
  6.29201308e-02f, 1.20668404e-03f, -2.53822077e-02f, -2.91278493e-02f, -2.33267546e-02f, -2.64119990e-02f, 5.66283008e-03f, 2.62231845e-02f, 1.07692391e-01f, 7.95922428e-02f,
  -1.36467725e-01f, -2.70091072e-02f, 4.20281179e-02f, 3.43113877e-02f, 5.86224496e-02f, 5.39620556e-02f, 1.08285606e-01f, -2.14453623e-01f, 1.70070529e-01f, -6.15603328e-02f,
  1.53760865e-01f, 1.91079881e-02f, 3.82235087e-02f, -1.11291073e-01f, 2.82676965e-02f, 2.65001934e-02f, -3.20290476e-02f, -1.64167672e-01f, 2.68948793e-01f, 1.77498925e-02f,
  7.71924807e-03f, -1.69283375e-02f, -8.21632966e-02f, -1.07347846e-01f, 1.85720682e-01f, 2.66176492e-01f, 1.83958083e-01f, -1.32554859e-01f, -6.38380507e-03f, -6.84110001e-02f,
  -6.57666773e-02f, 2.88245827e-01f, -8.02253038e-02f, 1.93210989e-01f, 1.45068780e-01f, -1.26812100e-01f, 7.99476355e-02f, 1.52268276e-01f, -3.44888121e-02f, 2.81610116e-02f,
  -3.61313075e-02f, 4.95421439e-02f, -1.33093670e-01f, -8.25451985e-02f, 7.60132521e-02f, 1.41200379e-01f, -3.02698724e-02f, 1.26687080e-01f, 1.11676797e-01f, -3.80285643e-02f,
  -2.62655839e-02f, 1.34204611e-01f, 1.82210058e-01f, 4.37836200e-02f, 1.77063361e-01f, 1.14285886e-01f, 2.24057451e-01f, -3.20852478e-03f, -3.07580885e-02f, 2.83480972e-01f,
  7.31660128e-02f, -6.38934448e-02f, -3.48547567e-03f, -1.51821211e-01f, 2.41467003e-02f, 1.03479937e-01f, 9.27002821e-03f, 1.28879957e-02f, 1.90728486e-01f, 1.13507800e-01f,
  1.15415700e-01f, -1.23040035e-01f, -4.27901279e-03f, 1.95924059e-01f, 1.64737627e-01f, -4.14318889e-02f, 1.49272010e-02f, 1.97176356e-02f, 2.05567256e-01f, 9.37960446e-02f,
  1.68023944e-01f, 1.24094203e-01f, 1.80278540e-01f, 2.13151388e-02f, -2.10507922e-02f, 1.33979142e-01f, 2.27731019e-01f, 1.43427372e-01f, -1.55465668e-02f, 6.37910217e-02f,
  1.40546663e-02f, 1.68928161e-01f, 4.73679006e-02f, 5.50031103e-02f, 6.52293414e-02f, -1.40905187e-01f, -3.66592593e-02f, 5.90395033e-02f, 2.04413086e-01f, 1.56910136e-01f,
  6.35365024e-02f, 1.25669032e-01f, -9.20026097e-03f, -3.01464200e-01f, 2.74959981e-01f, -1.45441413e-01f, 7.65790790e-02f, -1.95824996e-01f, 1.57470271e-01f, -1.81948572e-01f,
  -8.89504179e-02f, 1.44892052e-01f, -4.02182117e-02f, 2.47047782e-01f, 2.65432522e-02f, 5.66178076e-02f, 7.42090642e-02f, 7.69362003e-02f, 7.44963139e-02f, 3.83012950e-01f,
  4.74688150e-02f, 3.28808874e-01f, 3.33606414e-02f, 1.87976554e-01f, 1.29790738e-01f, 1.37382448e-01f, -1.56847581e-01f, -1.52783170e-01f, -2.36970678e-01f, 2.66299874e-01f,
  -3.80213186e-02f, 7.34715313e-02f, 1.79737806e-01f, 3.35121274e-01f, 1.27479240e-01f, 2.80776829e-01f, 1.87730283e-01f, 1.41605213e-01f, -1.28450572e-01f, -1.57355025e-01f,
  -2.05894202e-01f, -8.29660669e-02f, -1.99523363e-02f, 2.87355512e-01f, 6.34180440e-04f, -2.14443505e-01f, -1.60956919e-01f, -1.82681277e-01f, -1.92178607e-01f, -2.52650082e-01f,
  1.11283287e-01f, 2.49630675e-01f, 1.74073681e-01f, -4.03947197e-02f, -5.30497283e-02f, -1.40290752e-01f, 1.25602819e-02f, -3.65292698e-01f, -1.72389880e-01f, 1.43723572e-02f,
  2.36498371e-01f, 7.17299897e-03f, -1.21220201e-01f, -3.41646373e-01f, 1.75214261e-01f, -1.91844419e-01f, -1.44971550e-01f, 1.18670762e-01f, 1.67526409e-01f, -3.20302360e-02f,
  -9.39491764e-03f, -6.18882291e-02f, 2.76485234e-02f, 1.03089996e-01f, -8.72014388e-02f, 2.06903107e-02f, 9.81621072e-02f, 4.62097581e-03f, 1.74212515e-01f, 2.33701721e-01f,
  1.71647072e-01f, 1.65795878e-01f, 1.71819806e-01f, 1.96816981e-01f, 1.49011761e-01f, 1.30531356e-01f, 7.15904906e-02f, 1.70715287e-01f, 2.32955739e-01f, 3.60635519e-02f,
  -1.18545398e-01f, 1.05080254e-01f, 9.48553681e-02f, 1.32789075e-01f, -1.70257971e-01f, 8.40992667e-03f, 1.13626257e-01f, 1.52815416e-01f, 1.87635779e-01f, 7.94994533e-02f,
  2.14894161e-01f, 2.33971700e-02f, 1.80101976e-01f, -1.29435882e-02f, 2.08047614e-01f, -1.03488108e-02f, -8.11016466e-03f, 4.78756167e-02f, -9.39518735e-02f, 1.25615820e-01f,
  7.23177269e-02f, 1.65730026e-02f, 6.05214797e-02f, 7.81824738e-02f, 3.96052569e-01f, 3.25794429e-01f, 1.20430656e-01f, 1.66911587e-01f, 3.03431135e-02f, 1.64458230e-01f,
  8.92214924e-02f, 1.25725521e-03f, -1.76575348e-01f, 5.63173369e-02f, 2.84786317e-02f, -2.64489613e-02f, 2.21684471e-01f, 2.23839208e-02f, 1.06213950e-02f, 5.46124093e-02f,
  -4.65844348e-02f, 7.58112669e-02f, 1.66922398e-02f, 3.92960310e-02f, -1.71841398e-01f, 1.97056472e-01f, 2.38395154e-01f, -6.80016279e-02f, -8.75643268e-02f, -1.08454386e-02f,
  1.24722645e-02f, -7.06381872e-02f, -1.36975810e-01f, -1.37572885e-01f, 1.41667947e-01f, -9.80076268e-02f, 2.35621259e-02f, -2.83836991e-01f, -6.69880062e-02f, 1.95780337e-01f,
  6.08083084e-02f, -1.41225085e-01f, -4.90838811e-02f, 1.18462294e-01f, -4.84862505e-03f, -1.05705999e-01f, 1.32367939e-01f, 3.23873103e-01f, -1.21026710e-02f, -1.09519042e-01f,
  1.91202268e-01f, -6.86432570e-02f, -1.24287829e-01f, 2.63772517e-01f, -3.08786221e-02f, 2.71324404e-02f, 6.27708808e-02f, 2.06397906e-01f, -7.28422031e-02f, -3.57368290e-02f,
  1.18929848e-01f, -2.41498530e-01f, 1.66574139e-02f, 1.59341991e-01f, -2.25451693e-01f, -7.09016845e-02f, -1.07623145e-01f, -1.41153380e-01f, -2.16418058e-01f, 2.59312801e-03f,
  -1.86943978e-01f, -3.17944819e-03f, -2.15534374e-01f, -6.82175010e-02f, 1.10018253e-01f, 1.68711469e-01f, -1.42182618e-01f, -9.39307511e-02f, 5.75199306e-01f, 7.26128444e-02f,
  1.81050137e-01f, 4.11406428e-01f, 4.34497058e-01f, -1.44615352e-01f, -1.41219590e-02f, 1.09735809e-01f, 3.35531890e-01f, 6.91868365e-02f, 2.40239590e-01f, -1.92683600e-02f,
  -1.95182096e-02f, -4.30324152e-02f, 1.47894034e-02f, -6.08707927e-02f, -1.00323737e-01f, -2.52656955e-02f, -2.67224181e-02f, 1.29171506e-01f, 1.26860403e-02f, 1.49290189e-01f,
  7.31990710e-02f, 1.60510316e-01f, -4.66343760e-02f, 4.32412773e-02f, 9.87085998e-02f, -1.91414095e-02f, -1.36337832e-01f, 1.25395283e-01f, 3.64402309e-02f, 6.07772097e-02f,
  5.82702719e-02f, 3.00667472e-02f, -6.48498908e-02f, -4.71771788e-03f, -9.05341003e-04f, 1.73405275e-01f, 2.13203877e-01f, -8.58194008e-02f, 1.00892976e-01f, 3.56486477e-02f,
  2.08381079e-02f, 1.04170136e-01f, -1.09589927e-01f, -8.27488229e-02f, 2.98030376e-02f, 5.58510888e-03f, 1.60569981e-01f, -3.97346206e-02f, 1.08126938e-01f, -1.82481967e-02f,
  -6.87483326e-02f, 6.85117170e-02f, -1.28528371e-01f, -9.51578841e-03f, 1.26355998e-02f, -7.29583553e-04f, -5.56879230e-02f, 1.01490542e-01f, 1.40618077e-02f, -1.02201782e-01f,
  8.78752470e-02f, -4.59743552e-02f, 7.71316737e-02f, 6.49273172e-02f, 3.35665345e-02f, -3.02960984e-02f, 3.14550400e-02f, -4.24847715e-02f, -6.76822588e-02f, -4.95485477e-02f,
  3.49096842e-02f, -3.46466973e-02f, -6.77148700e-02f, -1.24766983e-01f, 8.73867795e-02f, -6.65300265e-02f, 7.71496519e-02f, -1.75369177e-02f, -1.05995074e-01f, 6.44297292e-03f,
  6.55604899e-02f, 9.35961232e-02f, -7.29538351e-02f, -1.40767932e-01f, -1.83738858e-01f, -4.31763604e-02f, 1.82093412e-01f, 9.89887044e-02f, -6.26832619e-02f, 8.68239328e-02f,
  -1.96946319e-02f, 7.59991035e-02f, -3.15538868e-02f, 8.14822465e-02f, -2.13537082e-01f, -7.05258846e-02f, -1.34513527e-01f, -5.96875809e-02f, -2.94006225e-02f, 1.05723619e-01f,
  7.52927661e-02f, -1.33157760e-01f, 2.10985959e-01f, -3.70883457e-02f, 3.41691040e-02f, -4.59928066e-02f, -2.63953023e-02f, -8.27124566e-02f, -1.60544321e-01f, -3.94220203e-02f,
  -1.86753944e-02f, -1.96541697e-01f, 2.47962162e-01f, -9.92062539e-02f, 4.23833616e-02f, -1.54406875e-01f, -6.33658329e-03f, -7.49910399e-02f, 9.71503481e-02f, -3.09507120e-02f,
  4.23493356e-01f, -4.50667106e-02f, -1.44320861e-01f, 6.36760816e-02f, 8.64535943e-02f, 2.85660680e-02f, 1.47512287e-01f, 2.17160434e-01f, -2.41249669e-02f, 9.22032446e-03f,
  3.76660824e-02f, 1.59309253e-01f, 2.99311042e-01f, -6.11046553e-02f, 3.87256294e-02f, -1.17093191e-01f, 9.12139844e-03f, -1.29444867e-01f, 1.34833455e-02f, -9.57827047e-02f,
  8.19221698e-03f, -3.93943628e-03f, 8.93208161e-02f, 2.33382925e-01f, 2.50822790e-02f, -3.44813578e-02f, -6.32417127e-02f, -7.40867853e-02f, 7.19900653e-02f, 2.62622237e-02f,
  -6.54814988e-02f, 4.32529412e-02f, -1.63012522e-03f, 1.08206116e-01f, 5.39314151e-02f, 1.58254951e-01f, 1.94688037e-01f, 7.26882219e-02f, -5.10550402e-02f, 9.54024792e-02f,
  7.02933371e-02f, -2.72612162e-02f, 1.01760332e-03f, 6.17762357e-02f, 1.01403877e-01f, 1.26390293e-01f, 5.18146008e-02f, 5.81714846e-02f, 1.68743879e-01f, -2.61025168e-02f,
  5.31143472e-02f, 1.49985686e-01f, 1.80509374e-01f, -3.48877013e-02f, 9.08460617e-02f, 1.50644675e-01f, -1.04444183e-01f, -5.80067672e-02f, -3.70194344e-03f, 3.01717427e-02f,
  -7.09672868e-02f, 2.25607585e-03f, 2.32252516e-02f, 5.12428395e-02f, 1.69518456e-01f, 3.54354754e-02f, 7.70949796e-02f, 7.15561956e-02f, 1.39024854e-01f, 3.39208432e-02f,
  3.50781232e-02f, -8.96664932e-02f, -2.69249409e-01f, -6.12189658e-02f, -1.41975563e-02f, -4.60067939e-04f, -2.52143610e-02f, 2.62670100e-01f, -1.57428116e-01f, -2.15007395e-01f,
  -8.93550813e-02f, -1.35476198e-02f, -2.06958294e-01f, 1.32973358e-01f, -2.01431081e-01f, -1.71521500e-01f, 1.35069015e-02f, 7.24828197e-03f, 7.15145320e-02f, 5.37713468e-02f,
  1.25046358e-01f, 1.24215007e-01f, 2.06086159e-01f, 1.93324890e-02f, -1.02086052e-01f, -3.33907336e-01f, -7.11869746e-02f, -2.29682446e-01f, -3.38637233e-02f, -1.41669437e-01f,
  1.15241408e-01f, 1.12858914e-01f, 3.13993730e-02f, -1.02791615e-01f, 1.01358490e-02f, -1.38099520e-02f, -3.53304595e-02f, -2.59559542e-01f, 2.85432994e-04f, 2.29993481e-02f,
  1.56713780e-02f, 6.60155490e-02f, -4.49554101e-02f, 8.04565102e-02f, -4.67324555e-02f, 6.38235509e-02f, 3.23701054e-01f, 6.81522787e-02f, -8.47581029e-02f, 9.80846733e-02f,
  2.85861403e-01f, 4.69769904e-04f, 4.40577269e-02f, 8.61614570e-02f, 1.36532918e-01f, -1.13647334e-01f, 2.30345339e-01f, 5.34762582e-03f, -1.08075932e-01f, 3.68512630e-01f,
  -2.68309959e-03f, 3.03996623e-01f, -2.63218731e-01f, -1.86976139e-02f, -2.78713722e-02f, 4.43288088e-02f, 4.51336175e-01f, 4.71495450e-01f, 2.40429863e-01f, -2.50483193e-02f,
  1.91267341e-01f, 1.32435307e-01f, -5.33082522e-02f, -7.12527568e-03f, -2.12212220e-01f, 9.86542553e-03f, 1.00587919e-01f, 5.67777716e-02f, 8.50110650e-02f, 1.83553398e-02f,
  7.83396736e-02f, -1.44247487e-01f, 8.03660825e-02f, -1.36804245e-02f, -2.73012314e-02f, 3.38186361e-02f, -4.66729254e-02f, 1.89924687e-01f, 1.46883935e-01f, -9.44964886e-02f,
  5.78426160e-02f, -6.71885163e-02f, -6.08472377e-02f, 3.88744734e-02f, 3.25258151e-02f, -3.03746723e-02f, -7.02774599e-02f, 7.81859756e-02f, -6.09739870e-02f, 1.24113910e-01f,
  -8.63143429e-03f, 8.57298728e-03f, 1.52885243e-01f, 7.89760519e-03f, -8.44013616e-02f, 3.41200735e-03f, -2.61245128e-02f, 2.85345465e-02f, -3.70395146e-02f, -3.22240368e-02f,
  -1.13409683e-02f, 5.86524904e-02f, 7.45907649e-02f, -5.45080267e-02f, 7.31161088e-02f, 2.00716648e-02f, -1.08736828e-01f, 1.41611740e-01f, 4.68251063e-03f, 3.39590237e-02f,
  -1.77842528e-02f, 3.80538404e-02f, -5.50140440e-02f, -6.23456351e-02f, 1.47714406e-01f, -9.93892457e-03f, 8.13385174e-02f, -9.27184746e-02f, -1.87239692e-01f, 1.84706356e-02f,
  -9.35741290e-02f, 3.44940908e-02f, -1.22794211e-01f, -1.39620394e-01f, 1.12130143e-01f, -1.81236938e-01f, -7.90290534e-02f, 1.57147035e-01f, -3.35022025e-02f, -4.91648726e-02f,
  -6.06758855e-02f, -2.06527039e-02f, 7.46166930e-02f, 4.65681851e-02f, 7.56791979e-02f, 2.59597749e-02f, 7.14947730e-02f, 3.45417112e-02f, -1.37689471e-01f, 1.28849251e-02f,
  -1.87217802e-01f, 3.08034718e-02f, -1.17697984e-01f, 1.03282779e-01f, 1.36403143e-01f, 1.20987050e-01f, 4.40718755e-02f, 1.51716128e-01f, 1.83643654e-01f, -9.73835811e-02f,
  -3.98452431e-02f, 6.47840975e-03f, 4.99182567e-02f, 6.79199174e-02f, -1.56076372e-01f, -9.03538764e-02f, -6.36121333e-02f, -1.68847684e-02f, -2.96122599e-02f, -1.31779328e-01f,
  9.10695493e-02f, 3.84194381e-03f, 2.04267234e-01f, 3.66750848e-03f, -2.00806722e-01f, 5.63083291e-02f, 1.44133149e-02f, 4.44795340e-02f, 8.67136270e-02f, -1.10425845e-01f,
  1.50690675e-01f, -5.68714701e-02f, -6.75304681e-02f, -1.64650992e-01f, -1.49873063e-01f, -1.24517120e-01f, 2.28753179e-01f, -2.78713778e-02f, 3.53217363e-01f, -2.67985631e-02f,
  1.90720662e-01f, -3.50678451e-02f, 1.13289721e-01f, 3.55367735e-02f, 3.03531319e-01f, -2.40546033e-01f, -2.01421022e-01f, -2.45412011e-02f, 4.71419580e-02f, -9.96948183e-02f,
  4.17818204e-02f, 2.89114445e-01f, 4.82542872e-01f, -7.83255249e-02f, 5.17585725e-02f, 5.65299019e-03f, 1.36676356e-02f, 1.40225619e-01f, 3.90202776e-02f, -2.36704461e-02f,
  8.82802065e-03f, -6.86988458e-02f, -7.99556226e-02f, 1.71204880e-02f, 7.76235163e-02f, 7.41440207e-02f, -6.39294162e-02f, 3.32028978e-02f, -1.30630061e-01f, 4.00935970e-02f,
  8.35629180e-02f, 7.29123130e-02f, 1.34992093e-01f, 5.76723330e-02f, 1.10311965e-02f, -1.19130164e-02f, 5.30270636e-02f, 7.37535730e-02f, -2.13950463e-02f, 1.65971205e-01f,
  -1.00251222e-02f, 7.46378750e-02f, -4.44913022e-02f, -4.11542319e-03f, 1.23483622e-02f, -3.83948572e-02f, 1.50824726e-01f, 1.22695506e-01f, 1.23674050e-01f, 2.79032085e-02f,
  1.39174387e-01f, -5.53272478e-02f, 3.37886512e-02f, 4.67123613e-02f, 1.46064103e-01f, 1.18853442e-01f, 1.46057699e-02f, 6.37127645e-03f, -3.98759469e-02f, 1.05863236e-01f,
  7.74220005e-02f, 1.72799304e-02f, 5.99370617e-03f, -4.02062647e-02f, 3.61343101e-02f, 5.67594208e-02f, 2.70849347e-01f, -5.17884567e-02f, -3.35925877e-01f, -1.00612365e-01f,
  -3.34420614e-02f, -1.47119820e-01f, -1.14084534e-01f, 1.14653967e-02f, -1.55915201e-01f, -2.48409376e-01f, -1.84484303e-01f, 2.18200624e-01f, -1.30786538e-01f, 2.00394168e-01f,
  -5.46077192e-02f, -1.45763829e-02f, -4.76792492e-02f, 6.45794645e-02f, -8.61037150e-03f, 5.13501689e-02f, 3.60703766e-01f, 2.97997333e-02f, 2.32490957e-01f, 1.81805473e-02f,
  -1.01193666e-01f, -2.78033972e-01f, -1.28777057e-01f, -1.04173683e-01f, 1.23675562e-01f, -6.12232275e-02f, 1.68850869e-01f, -2.61669084e-02f, 5.98286763e-02f, -1.86059386e-01f,
  4.75954488e-02f, 1.08871281e-01f, 5.16532026e-02f, -2.56136894e-01f, 9.66709778e-02f, -1.67340860e-01f, 1.07684396e-01f, -2.98618358e-02f, 2.17459276e-02f, 5.78977838e-02f,
  7.65470043e-02f, 2.38681406e-01f, 3.83999914e-01f, -1.40005648e-01f, -4.15548496e-02f, -9.49691236e-02f, 2.31277749e-01f, 7.56560862e-02f, 1.74499780e-01f, 3.15320343e-01f,
  8.16204548e-02f, 2.49355629e-01f, 1.71893775e-01f, -3.42937559e-02f, -1.91065088e-01f, 1.25147119e-01f, 2.14434430e-01f, 1.64656505e-01f, -1.75485969e-01f, 1.61264241e-02f,
  -8.10479745e-02f, -1.68554097e-01f, 3.55688304e-01f, 3.32898855e-01f, 2.26402417e-01f, -1.53139969e-02f, -1.80617884e-01f, 5.31127267e-02f, -7.18173906e-02f, 7.38164112e-02f,
  -2.30784968e-01f, 2.01292783e-01f, 1.82957590e-01f, 9.87750664e-02f, 2.67026313e-02f, 9.54392627e-02f, 1.67566493e-01f, -5.42658716e-02f, 2.63681877e-02f, 7.29655772e-02f,
  -6.97577074e-02f, 6.51571006e-02f, -5.86175248e-02f, 1.03926621e-01f, -5.70695661e-02f, 5.57545014e-02f, 6.58417419e-02f, 6.81293309e-02f, -4.95202988e-02f, -1.18849941e-01f,
  -3.24376263e-02f, 1.01801325e-02f, 1.80169925e-01f, 2.03283519e-01f, 2.36979797e-02f, 8.32428336e-02f, 2.19296515e-02f, 1.61438420e-01f, 2.03768969e-01f, -1.75129324e-02f,
  7.59867728e-02f, 7.87869021e-02f, -1.64092928e-02f, 4.02179211e-02f, 2.62372810e-02f, 1.48825556e-01f, 3.19040865e-02f, 1.90057009e-01f, -2.90381312e-02f, -5.93985319e-02f,
  1.13400422e-01f, 3.33938152e-02f, 4.24916595e-02f, 8.35028365e-02f, 7.96800554e-02f, -8.77945963e-03f, 3.49886976e-02f, 7.69704208e-02f, 4.67944331e-02f, 9.93476138e-02f,
  1.16170570e-01f, -5.02391160e-02f, -1.59389190e-02f, -1.36285335e-01f, -1.09981716e-01f, 1.87978819e-02f, -5.66780046e-02f, 9.23341215e-02f, -4.02295552e-02f, -1.57900423e-01f,
  1.58300743e-01f, -9.42939445e-02f, -1.55045405e-01f, 1.51428744e-01f, -2.64488393e-03f, 1.24611557e-01f, 1.25395045e-01f, -1.31741405e-01f, -3.71113867e-02f, 2.66285967e-02f,
  1.63943231e-01f, 4.02219556e-02f, 2.48752791e-03f, -1.18970461e-01f, -1.20823532e-02f, 4.05183323e-02f, 2.72188485e-02f, -8.59920308e-02f, -2.07147747e-01f, 1.68128550e-01f,
  -1.77567117e-02f, 1.41550615e-01f, 7.42561296e-02f, 1.96419552e-01f, -1.91028174e-02f, -7.66975880e-02f, 4.39626463e-02f, 8.11700225e-02f, 1.14268009e-02f, -4.38345671e-02f,
  -4.78685759e-02f, -8.03169981e-02f, -4.87852208e-02f, -9.55328718e-03f, -5.45652909e-03f, -2.07118079e-01f, 1.10364102e-01f, 3.70814092e-02f, 3.22141051e-02f, -7.91193992e-02f,
  -2.24158376e-01f, -1.92405358e-01f, 4.97260392e-02f, 1.18539575e-02f, 1.62928566e-01f, -2.27947488e-01f, 8.85179937e-02f, -3.55037898e-02f, -2.30468407e-01f, -1.88004375e-01f,
  2.65429378e-01f, 1.72191951e-02f, 5.52040003e-02f, -4.24654707e-02f, -7.29839457e-03f, -9.12693217e-02f, 1.24562114e-01f, 4.12475364e-03f, 2.30625853e-01f, 1.18382134e-01f,
  1.07457191e-01f, -2.56150484e-01f, 1.85498923e-01f, -5.64215593e-02f, -7.86264017e-02f, 2.79517360e-02f, -1.54412344e-01f, 4.25218940e-01f, 5.27639389e-01f, 2.98178680e-02f,
  1.22611620e-01f, 1.99843064e-01f, 7.29907006e-02f, 6.05970956e-02f, 2.55153533e-02f, 1.21121071e-01f, -7.78226703e-02f, 7.84418359e-02f, 1.42512113e-01f, 1.14061169e-01f,
  1.05657272e-01f, 7.27023631e-02f, 1.15300030e-01f, 1.38165737e-02f, -6.28908426e-02f, 1.43357128e-01f, 1.22383900e-01f, 1.24082267e-01f, -6.04175664e-02f, -1.09801907e-02f,
  -5.73271047e-03f, 1.03115559e-01f, -7.48138949e-02f, -1.25433821e-02f, 1.20353065e-01f, 1.40443414e-01f, -3.75285558e-02f, 3.15397158e-02f, 6.13634698e-02f, 1.10567279e-01f,
  -4.01267298e-02f, 3.69737372e-02f, 1.69615597e-01f, 1.05683416e-01f, 6.13133088e-02f, 5.18032312e-02f, 1.93563476e-02f, -8.61238986e-02f, 1.67535320e-01f, 1.95908412e-01f,
  1.31725863e-01f, 1.00510664e-01f, 1.90716356e-01f, 2.18356103e-01f, 1.66186124e-01f, 4.83930893e-02f, 7.96099678e-02f, -2.30005849e-02f, 3.40616032e-02f, 5.77608943e-02f,
  -4.38349470e-02f, 1.05468698e-01f, 1.83458462e-01f, 5.96510358e-02f, 1.12522990e-01f, -1.33775502e-01f, 1.02702295e-02f, -1.42408580e-01f, -9.59589109e-02f, -2.22332865e-01f,
  1.80479020e-01f, -1.04785122e-01f, -3.99942398e-02f, 9.91451144e-02f, 5.86985163e-02f, 2.32792556e-01f, 7.09728599e-02f, 7.63455704e-02f, -1.48149461e-01f, 2.91993562e-02f,
  1.69639867e-02f, 1.20254420e-01f, 2.51123726e-01f, -1.31239653e-01f, 7.37166852e-02f, -9.52944905e-02f, 3.45319994e-02f, -1.13973491e-01f, 5.12675848e-03f, 1.43290032e-02f,
  1.44608140e-01f, -5.35102040e-02f, -8.63939710e-03f, 3.51470783e-02f, -2.49212235e-01f, -4.23341803e-02f, 2.85085943e-02f, 1.35982260e-01f, 1.92832157e-01f, -9.59213171e-03f,
  6.99314028e-02f, 1.63183101e-02f, 8.67332518e-02f, -1.01913873e-03f, -1.99604500e-02f, -1.66123062e-01f, 6.05516247e-02f, 1.58768982e-01f, 2.38169327e-01f, 1.52931109e-01f,
  -1.66671574e-01f, -2.03808933e-01f, 4.66335453e-02f, -3.18979360e-02f, 1.47693366e-01f, 2.31978774e-01f, 9.64740962e-02f, 2.18775004e-01f, 1.90135136e-01f, 2.84715816e-02f,
  -3.21636915e-01f, -1.53853402e-01f, 1.81264043e-01f, -3.03683549e-01f, -8.07863921e-02f, -6.61568046e-02f, -2.99540665e-02f, -1.02415897e-01f, 1.61345422e-01f, -1.61408186e-01f,
  -4.52858023e-03f, 1.73516739e-02f, -9.27248597e-02f, 1.00877106e-01f, -3.14630605e-02f, 7.46094063e-02f, -1.96955949e-01f, 2.17399970e-01f, -2.13499144e-02f, 4.55036014e-02f,
  1.56525394e-03f, 5.96586652e-02f, 5.92444092e-02f, 7.75902346e-02f, 1.57256722e-02f, 1.84744447e-01f, 3.27867456e-02f, 6.11196235e-02f, 1.15413621e-01f, 7.46985525e-02f,
  -4.66278456e-02f, 3.13510783e-02f, 5.16880676e-02f, 8.13101083e-02f, 5.90511113e-02f, 1.57821640e-01f, 6.74215183e-02f, 2.73938961e-02f, 6.77006915e-02f, 2.72523426e-02f,
  -5.66064343e-02f, 5.13849258e-02f, 1.02457795e-02f, 7.58169293e-02f, 5.06670326e-02f, 1.85860634e-01f, 4.33619879e-02f, 2.16300674e-02f, -3.24366875e-02f, 7.98193961e-02f,
  -2.62760203e-02f, 1.24102183e-01f, 4.34972271e-02f, 3.77689563e-02f, 6.27262052e-03f, 8.72286931e-02f, 4.03406471e-02f, 1.15995318e-01f, -2.69562490e-02f, 1.45366073e-01f,
  5.82214929e-02f, 2.64315844e-01f, 1.33211881e-01f, 2.12853495e-02f, 7.79425129e-02f, 1.55449614e-01f, 2.30444614e-02f, 2.40988508e-02f, 2.23466791e-02f, 1.98277384e-01f,
  1.39962450e-01f, 1.20047569e-01f, 9.95317101e-02f, -1.06604889e-01f, -4.22818437e-02f, -9.29737017e-02f, -6.36657700e-02f, 6.54462725e-02f, 9.16116834e-02f, -1.68362334e-02f,
  -1.56438828e-01f, 2.71923006e-01f, 1.01997629e-01f, -7.28022382e-02f, 2.67932564e-02f, 7.48470612e-03f, -1.44334957e-01f, 6.62306696e-02f, -1.84050411e-01f, -1.92248765e-02f,
  1.29370853e-01f, -1.09376654e-01f, -6.94874898e-02f, -2.66088903e-01f, 5.59897944e-02f, -2.89235681e-01f, 1.13972053e-01f, -1.26066506e-01f, -1.63770244e-01f, -1.57835126e-01f,
  2.05742978e-02f, 5.73004298e-02f, -1.40944228e-01f, 6.67697703e-03f, -2.13660882e-03f, -9.32390466e-02f, 1.56037733e-01f, -6.58767447e-02f, -3.99031527e-02f, -1.70600981e-01f,
  -4.31089364e-02f, 1.55282365e-02f, 3.67584787e-02f, -5.75203821e-02f, -6.54030545e-03f, -6.07946143e-02f, 2.41251349e-01f, -1.42282220e-02f, -6.17453866e-02f, -4.15381007e-02f,
  1.65788099e-01f, 3.32497716e-01f, 1.45378977e-01f, 1.21249735e-01f, 6.89937687e-03f, 1.69657931e-01f, -2.90073574e-01f, -1.75681170e-02f, -1.27357826e-01f, -1.64123401e-01f,
  3.14248055e-02f, 7.65924826e-02f, 1.12069387e-03f, -5.79241812e-02f, 1.48859814e-01f, -9.29372832e-02f, 3.54602426e-01f, 2.54473031e-01f, 7.31888264e-02f, 1.35388955e-01f,
  2.97285467e-01f, 1.57749787e-01f, 3.82567823e-01f, -6.46872818e-02f, -1.47006720e-01f, 1.48080743e-03f, 4.89258906e-03f, 6.65700287e-02f, -3.20656970e-02f, 1.81798577e-01f,
  6.41130507e-02f, -1.73133258e-02f, 2.68793255e-02f, -7.42297713e-03f, -1.10778242e-01f, 4.50921878e-02f, 5.19434139e-02f, 7.14130476e-02f, 1.20341271e-01f, 2.01191396e-01f,
  -5.70302876e-03f, -1.30137861e-01f, 7.72152096e-02f, 1.19757071e-01f, -1.86952930e-02f, 4.14198935e-02f, -3.67114432e-02f, 1.72287244e-02f, 3.85485776e-02f, 7.45959654e-02f,
  -9.94701460e-02f, 1.81379035e-01f, 7.22357482e-02f, 5.84582835e-02f, 1.78280562e-01f, -1.01506919e-01f, 4.56028171e-02f, 7.69717172e-02f, 3.83202918e-02f, -1.18173764e-03f,
  4.55597648e-03f, 3.58498618e-02f, 5.12370095e-02f, 1.81084108e-02f, 1.33078158e-01f, 8.13175272e-03f, -2.14602798e-02f, 5.76144531e-02f, 1.05221972e-01f, -3.12910005e-02f,
  3.42718959e-02f, -6.64787786e-03f, 1.62339006e-02f, 9.40637439e-02f, 5.48056066e-02f, 1.00944981e-01f, 1.04669724e-02f, -1.25852332e-01f, 8.18062723e-02f, -1.36260882e-01f,
  -1.64066792e-01f, 9.61181894e-02f, 1.11224517e-01f, 2.96981275e-01f, -1.35060444e-01f, 1.19281888e-01f, -1.52540565e-01f, -7.56317377e-02f, 8.79396722e-02f, 1.33169562e-01f,
  -1.88505933e-01f, 1.50244489e-01f, -1.20204709e-01f, -1.29713535e-01f, -1.16974801e-01f, 3.15438285e-02f, -1.34351566e-01f, 4.38051000e-02f, 8.97964984e-02f, 6.78686751e-03f,
  5.36148213e-02f, 2.26066411e-02f, -2.28169695e-01f, 1.16510168e-01f, 1.26014441e-01f, -5.60653321e-02f, 3.87555771e-02f, 2.43986785e-01f, 1.68325216e-01f, -6.80667982e-02f,
  1.86195701e-01f, 4.40868773e-02f, 1.98044349e-02f, -6.45361235e-03f, -6.44342601e-02f, -4.00772274e-01f, 6.85860142e-02f, 9.41358805e-02f, 2.19618291e-01f, -3.81119661e-02f,
  -1.52439177e-01f, 1.31101593e-01f, -9.54128429e-03f, 3.15884054e-01f, -2.13723760e-02f, -4.47158469e-03f, 9.70297232e-02f, -6.39068137e-04f, 9.53548308e-03f, -1.13786586e-01f,
  -1.42493054e-01f, -1.29613966e-01f, 3.20188664e-02f, -2.28832960e-01f, 1.55628845e-01f, -4.90077361e-02f, -2.36922547e-01f, 4.01061118e-01f, -2.00199693e-01f, 4.36277121e-01f,
  -4.09539305e-02f, -4.92878892e-02f, 2.47073740e-01f, -2.88497925e-01f, 3.96601170e-01f, 3.93149048e-01f, 6.03404716e-02f, -3.78182605e-02f, 9.67360735e-02f, 1.35733068e-01f,
  4.91169602e-01f, 2.82756180e-01f, 2.42933124e-01f, -5.16005978e-02f, -2.66616084e-02f, 1.01384819e-01f, 3.82699370e-02f, 1.39897794e-01f, 5.37850894e-02f, 1.13925882e-01f,
  8.60658884e-02f, 5.02885617e-02f, 1.34337038e-01f, -2.63350084e-02f, 2.01060966e-01f, -5.67873865e-02f, -1.19480845e-02f, 1.81357175e-01f, 4.23254110e-02f, -2.95713823e-02f,
  7.70578459e-02f, 2.44419016e-02f, -7.85009637e-02f, 2.35580895e-02f, -4.79812324e-02f, -1.21138934e-02f, -1.92823652e-02f, -3.41671631e-02f, 7.42327273e-02f, 1.11757331e-02f,
  -9.08810273e-02f, 1.74698845e-01f, -7.67192170e-02f, 6.47521764e-02f, 3.87765169e-02f, 2.00675532e-01f, 5.60673960e-02f, 3.60760652e-02f, 7.71949887e-02f, 5.62549010e-02f,
  4.48012799e-02f, 5.57263568e-02f, 2.74978410e-02f, 8.63584206e-02f, 1.39323771e-01f, -6.85909465e-02f, 1.94292143e-01f, 1.27398193e-01f, 1.17766902e-01f, 5.67222387e-03f,
  1.69373035e-01f, 1.66571569e-02f, -2.07077358e-02f, 1.78063840e-01f, -7.59419128e-02f, -7.66934678e-02f, 2.17642281e-02f, 2.28418857e-02f, 1.20309353e-01f, -6.20903410e-02f,
  1.71587646e-01f, 2.23733574e-01f, -4.39955629e-02f, 3.14050764e-02f, -1.38140889e-02f, 1.14000835e-01f, 5.98320812e-02f, 1.66395046e-02f, 1.36643410e-01f, -1.04497127e-01f,
  -7.80397654e-02f, 1.15718700e-01f, -1.02306679e-01f, -4.09563184e-02f, -1.20445013e-01f, 5.85779026e-02f, 1.58935949e-01f, 8.28710943e-02f, -5.61745875e-02f, -1.01097040e-01f,
  -2.91426443e-02f, 3.12515721e-02f, 3.20057906e-02f, 1.19458996e-01f, 8.73725936e-02f, -4.13042195e-02f, -5.24148755e-02f, -1.23697430e-01f, -3.02953441e-02f, 5.48139289e-02f,
  1.14015071e-02f, -3.58030684e-02f, 5.81485182e-02f, 1.05943710e-01f, 5.80418902e-03f, 1.73160747e-01f, 7.17257010e-03f, -1.16791464e-01f, -1.28327623e-01f, 7.49371946e-02f,
  -4.09331173e-02f, 1.74829528e-01f, 1.45622730e-01f, -4.45537753e-02f, 4.04974772e-03f, -1.26693428e-01f, -1.49573997e-01f, 1.53016567e-01f, 1.08266100e-01f, 4.15670574e-02f,
  7.52188191e-02f, 3.02114964e-01f, -1.91169173e-01f, 6.53821006e-02f, -7.68831596e-02f, 1.50582716e-01f, 9.23644900e-02f, 1.90777257e-02f, 2.19013263e-02f, 1.05697945e-01f,
  4.15683389e-02f, -2.47060377e-02f, -2.21342176e-01f, 8.32765363e-03f, -1.51577950e-01f, 1.22823685e-01f, 2.40565408e-02f, 1.63900368e-02f, 2.94053018e-01f, -1.65838171e-02f,
  -6.36659116e-02f, 5.11011146e-02f, 9.71547216e-02f, 1.02222539e-01f, -1.06336717e-02f, 2.79233065e-02f, 7.33665824e-02f, 1.69392914e-01f, 4.50787656e-02f, -3.00153177e-02f,
  1.37552872e-01f, 7.28320703e-02f, 1.00656174e-01f, 7.81691074e-02f, 1.21432163e-01f, -4.66876030e-02f, -1.47316009e-02f, 1.60718635e-01f, 7.00455606e-02f, 1.28938660e-01f,
  7.55437613e-02f, -5.54166222e-03f, -2.88365819e-02f, 1.16373897e-01f, -3.20317410e-02f, 7.20707923e-02f, 4.14296426e-02f, 1.04162116e-02f, 8.17129090e-02f, 6.06515221e-02f,
  6.59444630e-02f, 6.58580139e-02f, -7.50809023e-03f, -5.70930429e-02f, -2.68165469e-02f, 2.21030235e-01f, 9.03719887e-02f, 4.03320082e-02f, 1.00783840e-01f, 1.59408823e-01f,
  6.33993521e-02f, -1.38664502e-03f, 8.15932229e-02f, 7.83396512e-02f, -6.74480572e-02f, -8.68602544e-02f, 1.34276688e-01f, 3.66370417e-02f, 3.84131148e-02f, 7.67371878e-02f,
  3.01690772e-02f, -3.12354788e-03f, 2.26702154e-01f, 2.36414839e-02f, -7.31357113e-02f, 1.08398400e-01f, -1.15599399e-02f, 2.88061462e-02f, -1.61199749e-01f, -2.91196704e-02f,
  -1.91450596e-01f, 2.64645606e-01f, 3.97549681e-02f, -1.85138062e-01f, 9.12651047e-02f, -2.08374962e-01f, -1.77359015e-01f, 1.03872851e-01f, 3.99860591e-02f, -2.61382498e-02f,
  1.09755397e-01f, -3.79379958e-01f, 1.19837016e-01f, 4.21734573e-03f, -2.39734188e-01f, 6.59435689e-02f, 5.07252924e-02f, 1.12186261e-01f, 2.88156480e-01f, -3.02766323e-01f,
  -9.98600274e-02f, -2.60031343e-01f, -1.87563132e-02f, -2.69618511e-01f, -4.22881022e-02f, 7.15513751e-02f, 1.49120167e-01f, -1.30189389e-01f, -9.41206962e-02f, -1.89515099e-01f,
  -2.59901196e-01f, 3.18128973e-01f, -1.94766838e-02f, -2.80696508e-02f, -1.87939748e-01f, 2.79107481e-01f, -8.21785852e-02f, -7.57823512e-02f, -3.23567986e-02f, -1.64973840e-01f,
  -1.61544397e-01f, 6.24435581e-02f, 6.56995103e-02f, 2.70244122e-01f, -2.40987673e-01f, 4.91344333e-02f, -6.81027547e-02f, 2.00007170e-01f, 2.32098103e-01f, 7.71833807e-02f,
  1.14238113e-02f, 7.72789419e-02f, 1.07260093e-01f, 1.97595924e-01f, -5.22919977e-03f, 3.10001194e-01f, -1.49099320e-01f, -7.11791217e-02f, 5.81679679e-02f, 1.19553991e-01f,
  -9.20170695e-02f, 2.04935268e-01f, 5.86799942e-02f, 7.36847753e-03f, 3.12142134e-01f, -1.35954589e-01f, -1.88910007e-01f, -3.35203528e-01f, -3.47317904e-02f, 1.26931876e-01f,
  -2.19618119e-02f, 6.28769025e-02f, 1.57972366e-01f, -7.50457216e-03f, 4.59557772e-02f, -9.60311517e-02f, -1.88769221e-01f, -9.25920978e-02f, 1.14217229e-01f, -1.56004623e-01f,
  1.13711044e-01f, -2.44565569e-02f, 2.89451610e-02f, -3.14745791e-02f, 7.76209384e-02f, 8.50172937e-02f, 8.63382667e-02f, 1.13115191e-01f, 2.29695246e-01f, -8.45450982e-02f,
  -1.46209393e-02f, 5.44877052e-02f, 1.50889978e-01f, -9.51505080e-03f, 2.03278922e-02f, -2.33609369e-03f, 9.47284028e-02f, 2.37980075e-02f, 1.02031063e-02f, 1.49611875e-01f,
  4.62220795e-02f, 1.04471155e-01f, -6.56116679e-02f, 1.23157322e-01f, 1.48611248e-01f, -2.93451715e-02f, 1.55115753e-01f, 1.12202592e-01f, -1.11014582e-01f, 2.88686231e-02f,
  -7.53667876e-02f, 6.93153590e-02f, 2.44228598e-02f, -1.90996546e-02f, -2.76482701e-02f, 3.49055715e-02f, 4.61398698e-02f, 6.54220283e-02f, -5.76317087e-02f, -1.90419592e-02f,
  2.49254629e-01f, -5.55296242e-02f, 8.93471017e-02f, -4.16604709e-03f, 9.58700776e-02f, -8.30275044e-02f, 6.68761432e-02f, 7.75578395e-02f, -5.79078421e-02f, 1.02905758e-01f,
  9.63824242e-02f, -1.97474495e-01f, -2.10692436e-02f, -1.81831881e-01f, -5.00308275e-02f, 2.59276037e-03f, -1.04851656e-01f, -3.44471447e-02f, -1.52434587e-01f, 1.55867204e-01f,
  1.19426258e-01f, 1.45993188e-01f, 9.93343219e-02f, 3.40170525e-02f, 6.64617717e-02f, 2.05252856e-01f, 9.44666117e-02f, -3.06766689e-01f, 1.04461297e-01f, -4.76456322e-02f,
  -6.59513175e-02f, -5.07191643e-02f, 1.18780784e-01f, -9.86766964e-02f, -2.47135118e-01f, -1.01139717e-01f, -3.88605893e-02f, 9.10062343e-02f, -3.77611630e-02f, 1.52533889e-01f,
  4.64463644e-02f, 1.37407973e-01f, 9.86050293e-02f, 3.16199809e-01f, -2.02069342e-01f, -2.02911437e-01f, -1.31035343e-01f, 6.61520138e-02f, 1.61987439e-01f, 2.99183190e-01f,
  -1.55526325e-02f, -2.67982930e-02f, 2.97336727e-02f, -4.42920625e-02f, 6.72920570e-02f, 3.55027169e-02f, 7.94973522e-02f, -2.20483951e-02f, -1.44939914e-01f, 1.80055499e-01f,
  8.75617862e-02f, 1.73471317e-01f, 3.60692590e-01f, 1.35918424e-01f, -1.99480638e-01f, 1.97521746e-02f, -1.25834823e-01f, 1.64884701e-01f, 3.07787180e-01f, 1.23347551e-01f,
  -8.86851251e-02f, 5.51325120e-02f, 2.87980795e-01f, 2.47414857e-02f, 6.65114373e-02f, -1.01999700e-01f, -4.74153668e-01f, 8.76580738e-03f, 1.28758535e-01f, -4.34592180e-02f,
  -7.46966228e-02f, 6.97857291e-02f, -5.22582829e-02f, -6.20475709e-02f, -2.77977251e-02f, -7.58881494e-02f, -8.27742890e-02f, -1.44223273e-01f, 1.00173458e-01f, 3.17070000e-02f,
  5.04379645e-02f, 9.64575633e-02f, 7.43841827e-02f, -3.82263061e-05f, -2.64057722e-02f, 4.02090736e-02f, 1.31871074e-01f, 8.77698604e-03f, 7.02802688e-02f, 9.04340595e-02f,
  5.27230278e-02f, 3.50774787e-02f, -1.31442651e-01f, -4.78684949e-03f, 9.91543680e-02f, 8.77738670e-02f, -1.11858107e-01f, 8.73387232e-02f, -2.73568314e-02f, 1.21313550e-01f,
  3.28485705e-02f, 7.08567947e-02f, -1.12549551e-01f, 3.19361774e-04f, 2.15833392e-02f, -1.04099073e-01f, -5.43597452e-02f, 6.60245633e-03f, -8.18678066e-02f, 1.54862225e-01f,
  -6.56304434e-02f, 2.11004633e-02f, -1.77176706e-02f, 3.52128707e-02f, -2.64456104e-02f, 2.22595092e-02f, -5.23613207e-02f, -2.73091681e-02f, 8.52492824e-02f, -6.97361231e-02f,
  -2.61824727e-02f, 4.91455011e-02f, -2.69489437e-01f, -6.32629544e-02f, -5.08815162e-02f, -1.21224403e-01f, 2.83059120e-01f, 2.31562778e-02f, -3.38774025e-01f, 3.19089815e-02f,
  -9.10304040e-02f, 1.07064866e-01f, -6.47070557e-02f, -2.51187459e-02f, -1.13048509e-01f, 9.42777260e-04f, 1.39758468e-01f, 2.11009935e-01f, 1.62527278e-01f, 7.66943842e-02f,
  9.93098095e-02f, -1.38975317e-02f, 6.93241358e-02f, 1.86942313e-02f, -1.84284687e-01f, -1.37481108e-01f, -1.18734010e-01f, -1.15384115e-03f, -7.05157518e-02f, 5.93355410e-02f,
  1.46840677e-01f, -1.14434352e-02f, -7.69530684e-02f, -3.75693217e-02f, 7.85155501e-03f, 5.59805036e-02f, -1.68944225e-01f, -2.01823637e-01f, 1.27931073e-01f, -7.42855966e-02f,
  6.50213510e-02f, -2.78530717e-01f, 1.05032258e-01f, 3.44087481e-02f, 5.63724898e-02f, -2.94934455e-02f, 4.17766869e-02f, -1.26967534e-01f, 5.91965653e-02f, -4.95164283e-02f,
  3.93416315e-01f, -3.61472666e-02f, 1.31733909e-01f, 7.33313384e-03f, -7.93409646e-02f, -1.10791013e-01f, 2.17800364e-01f, 3.03748488e-01f, 7.53359497e-02f, 2.30046455e-02f,
  2.32092496e-02f, 9.08997026e-04f, -6.35561645e-02f, 1.96418598e-01f, 5.52172400e-02f, 1.15938857e-01f, 3.43504488e-01f, -2.63254881e-01f, 2.01257080e-01f, 8.77953693e-02f,
  -1.41927681e-03f, -3.87147032e-02f, 4.67662327e-02f, 4.53520060e-01f, 2.98063129e-01f, -4.18480821e-02f, -1.01012327e-02f, 1.73274968e-02f, -4.13545109e-02f, -9.09534693e-02f,
  -1.76095515e-02f, 6.72418028e-02f, -1.54898642e-02f, -4.39182818e-02f, 2.41566256e-01f, 1.55579254e-01f, 1.81875035e-01f, 1.03831425e-01f, 3.26962732e-02f, 2.45472901e-02f,
  4.28598970e-02f, 2.32919589e-01f, 9.22907665e-02f, 1.08925462e-01f, 2.92655341e-02f, -4.39540930e-02f, -2.83220131e-02f, 8.69574696e-02f, 1.78675354e-02f, -1.31187337e-02f,
  1.11098342e-01f, 6.29019067e-02f, -5.94203062e-02f, -1.38040662e-01f, 8.13708901e-02f, 5.35362400e-02f, -1.71632320e-02f, 2.85004899e-02f, -8.59503262e-03f, -1.01934366e-01f,
  1.17893573e-02f, -2.52148299e-03f, 3.96625064e-02f, -2.12421222e-03f, 9.73701477e-02f, -1.03175774e-01f, -1.03445239e-01f, 4.23543155e-02f, -2.16860771e-02f, -6.05701189e-03f,
  8.40693787e-02f, 2.95643229e-02f, 6.76700696e-02f, 2.40828227e-02f, 8.00649077e-02f, -2.87316483e-03f, 9.56669971e-02f, 3.98607254e-02f, 7.81705752e-02f, 1.17982835e-01f,
  1.55658543e-01f, 7.08057582e-02f, 4.53258380e-02f, -2.35569589e-02f, -7.35351294e-02f, -1.08936556e-01f, 3.14492702e-01f, -4.54759076e-02f, 7.70122111e-02f, -1.16908714e-01f,
  1.00270972e-01f, -6.95262179e-02f, -2.92413384e-02f, -3.44317257e-02f, -1.64997205e-01f, 4.00849432e-02f, 1.24533325e-01f, 7.97963366e-02f, -1.27499774e-01f, -1.13003002e-03f,
  1.23789646e-01f, 2.44111106e-01f, 8.88825767e-03f, 2.96487629e-01f, -1.72260240e-01f, 8.90577137e-02f, 2.16087118e-01f, 1.50292367e-01f, -1.47315487e-01f, 3.11652329e-02f,
  -2.09611163e-01f, 1.56546593e-01f, 5.51035954e-03f, 6.50278181e-02f, 1.46852419e-01f, 2.69152045e-01f, 1.11805528e-01f, 8.28934684e-02f, 2.15618551e-01f, 8.27600211e-02f,
  1.61453942e-03f, -5.34761976e-03f, -1.90946639e-01f, -1.71877310e-01f, -1.25749886e-01f, 2.27117196e-01f, 1.08294137e-01f, -7.27195442e-02f, -8.71476624e-03f, -4.14933525e-02f,
  8.96450058e-02f, 6.87118471e-02f, 1.33098036e-01f, 1.29278883e-01f, 4.70228493e-01f, 2.12626576e-01f, 7.56674856e-02f, 3.64024797e-03f, -1.14852950e-01f, -6.07697573e-03f,
  8.68235808e-03f, 6.49963841e-02f, 3.49050224e-01f, 1.37548283e-01f, -2.96398401e-01f, -2.81597495e-01f, 1.97381735e-01f, 7.43926242e-02f, 2.34306723e-01f, -1.03259526e-01f,
  1.87048092e-01f, -1.61532998e-01f, 3.85430083e-02f, 2.38942072e-01f, 1.78395584e-01f, 8.59414861e-02f, 6.73342720e-02f, 1.29623935e-01f, 1.32609740e-01f, -9.02585313e-02f,
  6.62268177e-02f, 1.03497885e-01f, 4.67423443e-03f, 1.28746346e-01f, 4.88976762e-02f, 1.11351289e-01f, 7.73131624e-02f, 3.96285430e-02f, 1.98137350e-02f, 4.66085002e-02f,
  1.13701075e-02f, 6.69521019e-02f, 1.40313342e-01f, 1.15565002e-01f, 4.46538255e-02f, 2.20272411e-02f, 1.64575391e-02f, 1.41539007e-01f, 5.39167635e-02f, 8.33116993e-02f,
  8.12164843e-02f, 1.47776484e-01f, -8.56909493e-04f, 3.98513637e-02f, 1.59539059e-01f, -1.19502872e-01f, 1.77970111e-01f, 2.06410602e-01f, 1.81974828e-01f, 6.36865348e-02f,
  1.18772782e-01f, 1.22383721e-01f, -3.45106944e-02f, 1.00626059e-01f, 1.78752661e-01f, -5.78702055e-02f, 6.49279822e-03f, -7.28817210e-02f, -2.17829202e-03f, 6.81275129e-02f,
  1.09467424e-01f, 1.16687201e-01f, 1.06317535e-01f, 6.45010546e-02f, 1.30373582e-01f, -1.87654927e-01f, -8.20945054e-02f, -8.15142915e-02f, -5.62183466e-03f, -3.79494652e-02f,
  -1.66133881e-01f, 1.03269123e-01f, 9.26199108e-02f, 1.84627399e-01f, -1.72069132e-01f, -6.32477179e-02f, 8.87244493e-02f, -1.54596912e-02f, -1.26001969e-01f, 1.26288598e-03f,
  2.78597288e-02f, -7.94228390e-02f, 1.49755701e-01f, -2.89606333e-01f, 1.70285404e-01f, 2.44478043e-02f, -1.22432284e-01f, 1.45291761e-01f, 2.63423733e-02f, 1.86481681e-02f,
  1.84100866e-01f, -1.73954248e-01f, -9.36273113e-02f, -1.21809997e-01f, -6.31068498e-02f, 2.34813523e-02f, -1.75756086e-02f, 9.84154567e-02f, 4.26165581e-01f, -9.68347639e-02f,
  3.98071390e-03f, -1.55627862e-01f, -1.98881969e-01f, 1.13336416e-02f, -2.05204673e-02f, 1.10512383e-01f, -1.57742009e-01f, 2.24021494e-01f, 4.55302224e-02f, 9.69932526e-02f,
  6.44121170e-02f, 4.43691835e-02f, -1.16234623e-01f, -1.18870087e-01f, 2.97229439e-02f, 2.32010528e-01f, -1.90770272e-02f, 2.24617235e-02f, -2.85756558e-01f, 4.48795371e-02f,
  9.18212235e-02f, -7.58714825e-02f, -1.11072898e-01f, -1.21057257e-01f, 3.33128750e-01f, 2.10661516e-01f, 2.26310357e-01f, 2.94375688e-01f, 9.18952599e-02f, -6.15810528e-02f,
  6.62707239e-02f, 1.91927537e-01f, 5.77498265e-02f, 4.03956652e-01f, 6.53047711e-02f, -4.64765839e-02f, 1.43601164e-01f, -1.04142576e-01f, -2.07238019e-01f, -4.79338951e-02f,
  1.60939693e-01f, 3.43912356e-02f, -3.50582711e-02f, -1.12311371e-01f, -1.46519803e-02f, -1.22828625e-01f, -3.90084684e-02f, 1.94993958e-01f, 1.55344103e-02f, -1.11761972e-01f,
  6.97905719e-02f, -4.27802950e-02f, -4.69038673e-02f, -3.53605337e-02f, 5.17510250e-02f, 5.54131456e-02f, -2.46743462e-03f, -1.08710252e-01f, -4.77269515e-02f, 7.54091889e-02f,
  -6.86020553e-02f, 1.20391823e-01f, 7.99869187e-03f, -5.70639148e-02f, 5.55508472e-02f, 1.73249811e-01f, -1.57306418e-01f, -8.84553567e-02f, -3.68691608e-02f, 1.03915475e-01f,
  -7.98823386e-02f, -1.72596760e-02f, -1.46890864e-01f, 2.25921050e-02f, 1.50408015e-01f, -6.32526800e-02f, -1.40963197e-01f, -9.04113650e-02f, -6.18623830e-02f, 5.39626405e-02f,
  -9.45226755e-03f, -1.72313333e-01f, -6.06518649e-02f, 1.69765260e-02f, -8.48928019e-02f, -5.36375269e-02f, -4.20215279e-02f, 4.38194200e-02f, -5.08405007e-02f, 5.90591878e-02f,
  -2.13671513e-02f, -7.19418451e-02f, 9.50241983e-02f, 5.81418537e-03f, 9.63070467e-02f, 8.51052254e-03f, -1.18979529e-01f, -1.20281719e-01f, 1.22601680e-01f, 2.95066349e-02f,
  1.88696310e-01f, 9.64433476e-02f, -3.38625424e-02f, 1.84246972e-02f, -3.28780338e-02f, 4.55208682e-02f, 1.04449153e-01f, 6.66390061e-02f, 1.84904505e-02f, 8.20131376e-02f,
  -1.25519291e-01f, 7.07062287e-03f, 3.08492011e-03f, -1.54517833e-02f, 1.46016374e-03f, 7.60995150e-02f, -3.15519534e-02f, 6.28166497e-02f, -6.20961823e-02f, 1.41677320e-01f,
  -3.37586715e-03f, 8.95420983e-02f, 1.04886889e-01f, -5.92528246e-02f, 7.09345341e-02f, 2.22259555e-02f, 1.28117315e-02f, 1.02592424e-01f, 6.33455627e-03f, -1.25664085e-01f,
  -1.43703474e-02f, 2.32401993e-02f, 9.39565450e-02f, -1.92873895e-01f, 1.72814995e-01f, -1.80545431e-02f, 5.35287000e-02f, 8.93722028e-02f, 8.19879249e-02f, -3.42243500e-02f,
  5.21580651e-02f, -3.38658988e-02f, 1.39041990e-01f, -5.63244671e-02f, 5.87239079e-02f, -9.04931221e-03f, 1.36525100e-02f, 2.78229974e-02f, 8.51679686e-03f, 1.69911925e-02f,
  4.27054279e-02f, 2.40870953e-01f, 2.03331262e-01f, -6.85681105e-02f, 8.54332373e-02f, -7.12301396e-03f, -1.39191151e-02f, 3.16207796e-01f, 3.30324918e-02f, 2.31532812e-01f,
  -1.74791485e-01f, -8.53138044e-02f, 5.15473261e-02f, 5.44660985e-02f, -5.30093648e-02f, 2.73815822e-04f, -1.61468521e-01f, -1.07233025e-01f, -1.98896646e-01f, 9.77300853e-02f,
  -1.08200905e-03f, 1.19743660e-01f, 2.61073671e-02f, 8.12961012e-02f, 1.56820624e-03f, 2.56385595e-01f, -1.03485398e-02f, -1.23246543e-01f, 3.96055393e-02f, 6.34849817e-02f,
  5.69084361e-02f, 6.79457262e-02f, -5.87132312e-02f, -2.42268667e-02f, 2.22610738e-02f, 1.32643506e-01f, 3.14240530e-02f, 9.12759006e-02f, 6.31423369e-02f, 5.86282499e-02f,
  1.01621732e-01f, 4.49165590e-02f, 1.87297096e-03f, 9.77650434e-02f, 1.01175822e-01f, 4.92470451e-02f, -4.16835174e-02f, -5.75167884e-04f, 1.08175553e-01f, 4.80435640e-02f,
  -3.01466025e-02f, 5.99526092e-02f, 3.63003202e-02f, 1.08709648e-01f, 2.07433090e-01f, 5.59789874e-03f, 6.69969320e-02f, 1.47928551e-01f, 1.23213260e-02f, 6.08598553e-02f,
  9.04202759e-02f, -6.51653782e-02f, -6.98678121e-02f, -8.97010788e-02f, 9.25140977e-02f, 2.86667533e-02f, 1.90610457e-02f, 1.31168902e-01f, -9.95069928e-03f, -3.56534608e-02f,
  1.36644080e-01f, -1.22948606e-02f, 2.00584475e-02f, 4.97860909e-02f, -1.64732695e-01f, -1.58480182e-02f, 9.42961499e-03f, -1.78668350e-01f, 7.88356364e-03f, 2.52703190e-01f,
  -6.81923889e-03f, -4.60099727e-02f, 1.39983192e-01f, -2.11469889e-01f, -2.13690773e-01f, 1.35221750e-01f, 6.23517623e-03f, -4.67415303e-02f, 4.95492965e-02f, -7.72465914e-02f,
  1.31172180e-01f, 3.20990719e-02f, -5.68166152e-02f, 5.29442057e-02f, 6.66686893e-02f, 1.86110646e-01f, 2.11246774e-01f, -1.16445318e-01f, -1.17632680e-01f, -4.69905734e-02f,
  6.25364631e-02f, -2.46584639e-01f, 3.99609543e-02f, 1.60305277e-01f, -3.46243195e-02f, -2.15114772e-01f, 1.87781695e-02f, 6.38516620e-02f, -9.12797675e-02f, 8.03499147e-02f,
  1.01248115e-01f, -1.59680590e-01f, -1.96050145e-02f, 1.36161581e-01f, -6.54012635e-02f, -9.30429995e-02f, 4.49969433e-03f, 1.00953437e-01f, -5.28496727e-02f, 8.12579468e-02f,
  -2.23571144e-04f, 1.04909115e-01f, 1.35616153e-01f, 1.01052307e-01f, 3.20309959e-02f, 1.27739012e-01f, 1.78041071e-01f, 1.03663534e-01f, 2.22468168e-01f, 1.37538210e-01f,
  1.45093054e-01f, 3.91511023e-01f, 2.13983372e-01f, 1.86564252e-01f, -1.82325855e-01f, 1.07882001e-01f, -3.89940858e-01f, 1.90718576e-01f, -1.47812948e-01f, -4.10098732e-02f,
  -4.67866063e-02f, 5.56002334e-02f, 2.24325791e-01f, -1.04487710e-01f, -2.10138202e-01f, -6.38085157e-02f, -8.99776146e-02f, 1.35906398e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 26)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 26;
const float L1_fan_Bp_bar_data[] = {
  8.31119642e-02f, 6.40662163e-02f, 1.71180606e-01f, 7.67726079e-02f, 8.69532451e-02f, 8.49625692e-02f, 1.30181178e-01f, 1.47869848e-02f, 2.37701535e-02f, 9.15958285e-02f,
  3.55130956e-02f, 5.91879636e-02f, 3.93490903e-02f, 5.85111380e-02f, 2.00794086e-01f, 1.11046672e-01f, 2.89516989e-02f, 1.37169228e-03f, -3.20004509e-03f, 9.80883986e-02f,
  9.23562050e-02f, 1.26805753e-01f, -2.11388455e-03f, 7.44489878e-02f, 8.05139095e-02f, 1.36365429e-01f
};

// L2_linear_W (Shape: 12 x 128)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 128;
const float L2_linear_W_data[] = {
  1.22882217e-01f, -1.92146301e-01f, -3.54967296e-01f, -8.99552107e-02f, -3.58771920e-01f, 6.20205253e-02f, 6.32651821e-02f, -1.72969431e-01f, -2.59011686e-02f, -2.97045767e-01f,
  3.70356739e-02f, 2.23184362e-01f, 3.91321024e-03f, -3.28114420e-01f, 8.34083334e-02f, 1.97849199e-01f, -1.79162920e-01f, -7.85028040e-02f, -2.73911089e-01f, -1.76521793e-01f,
  -5.76778203e-02f, -4.57986556e-02f, -2.00984463e-01f, -2.42481768e-01f, -5.33911921e-02f, -1.06297746e-01f, 1.79201081e-01f, -2.68422455e-01f, -6.14245944e-02f, -2.72704422e-01f,
  1.19309425e-01f, 1.15839660e-01f, -2.60348916e-01f, -1.53928116e-01f, -1.75844699e-01f, -1.18657544e-01f, 6.04754016e-02f, -1.23311661e-01f, 5.61890006e-02f, 9.55839306e-02f,
  -2.54620433e-01f, 3.85775417e-02f, 3.59797627e-01f, -2.01157495e-01f, 1.78881094e-01f, -2.39118323e-01f, -2.32614815e-01f, 5.07405177e-02f, -1.46965116e-01f, 1.53766438e-01f,
  7.66411051e-02f, -1.39184237e-01f, -5.32024400e-03f, -6.47692084e-02f, -1.42204419e-01f, -1.44675478e-01f, 2.19216824e-01f, 3.27839047e-01f, 2.92206574e-02f, 2.98475951e-01f,
  -6.84115067e-02f, -2.08447158e-01f, 6.30608350e-02f, -2.90516820e-02f, -1.24414358e-02f, -4.43188958e-02f, 1.07005589e-01f, -2.29270291e-02f, -3.34129006e-01f, 2.35310525e-01f,
  3.24005246e-01f, 1.99219049e-03f, 2.47906700e-01f, 3.55869889e-01f, 9.70222279e-02f, -4.77317721e-02f, 4.22832463e-03f, -1.54534662e-02f, -5.62448753e-03f, 7.47209508e-03f,
  9.96254385e-02f, 1.38235196e-01f, -1.96546540e-01f, 2.47005880e-01f, 2.08821911e-02f, 1.08470544e-01f, 2.76061267e-01f, -2.04570442e-01f, -1.59458816e-01f, 3.56654763e-01f,
  -3.33439976e-01f, -5.80884032e-02f, -1.10528409e-01f, 2.58854330e-01f, -7.55971223e-02f, -8.30563381e-02f, -1.33040354e-01f, 1.75099045e-01f, 3.39050591e-01f, 8.73541757e-02f,
  -2.75993586e-01f, 1.93514660e-01f, -7.30935410e-02f, 3.00449058e-02f, -1.74339175e-01f, -1.22314379e-01f, -4.09660101e-01f, 1.94935679e-01f, 1.98440641e-01f, -1.20596409e-01f,
  -8.64492208e-02f, 9.61390957e-02f, 1.21213198e-01f, 1.97018273e-02f, -9.73061658e-04f, -1.37647435e-01f, -4.02879357e-01f, -2.65726268e-01f, 2.12392151e-01f, 6.27458170e-02f,
  -2.64369380e-02f, 1.70831040e-01f, -8.65751971e-03f, -4.89130676e-01f, 4.59875576e-02f, 7.15636183e-03f, -4.06013578e-01f, -3.99098873e-01f, -1.13192260e-01f, -1.65642142e-01f,
  -3.91482754e-04f, 5.33890575e-02f, -9.67361927e-02f, -4.70681787e-02f, -1.04757316e-01f, -3.68626043e-02f, 1.25547737e-01f, 2.33854800e-01f, 4.92923567e-03f, -2.32604459e-01f,
  -2.28991471e-02f, 1.20527729e-01f, -1.99859470e-01f, -3.12799588e-02f, -8.65543559e-02f, -6.01747148e-02f, -6.94977120e-02f, -9.83576030e-02f, -2.66466826e-01f, 2.99482316e-01f,
  -1.05829537e-01f, -1.89555492e-02f, -1.70865804e-02f, -2.21221209e-01f, -1.02319373e-02f, -1.19084306e-01f, 4.44771461e-02f, 2.03548726e-02f, -1.40514225e-01f, -1.39538616e-01f,
  6.49280986e-03f, 4.77003455e-02f, -1.66507035e-01f, -1.55529538e-02f, -3.00333530e-01f, -2.41539478e-02f, 3.08169965e-02f, -3.07719372e-02f, 1.42074795e-02f, 9.68293380e-03f,
  4.97444272e-02f, 2.19824374e-01f, -2.67754138e-01f, 1.09404005e-01f, -1.85327187e-01f, -2.58809149e-01f, 2.00552404e-01f, -2.65333235e-01f, -1.13553122e-01f, 1.90235585e-01f,
  9.50355604e-02f, 2.98132449e-01f, 5.70329353e-02f, -5.38551658e-02f, -2.27207243e-01f, 3.17953855e-01f, 1.08859047e-01f, -2.23417394e-02f, 1.04271015e-02f, -1.31457970e-01f,
  -3.02533388e-01f, 2.72828132e-01f, -2.80111194e-01f, -1.20058358e-01f, -1.86354905e-01f, -1.34856895e-01f, -2.67580509e-01f, 1.48401543e-01f, -1.77905753e-01f, 3.45240861e-01f,
  7.37407878e-02f, 4.37558204e-01f, 4.48411778e-02f, -1.19642302e-01f, -2.05180436e-01f, 7.58939087e-02f, 1.27606913e-02f, -1.14522770e-01f, -6.77864105e-02f, -1.83724687e-01f,
  6.06854856e-01f, 3.49401772e-01f, -1.35265663e-01f, -3.18960994e-01f, -1.44278988e-01f, -8.90361965e-02f, -1.74764737e-01f, 3.46781462e-01f, -4.13366050e-01f, -2.83191353e-01f,
  1.64600924e-01f, 2.31825247e-01f, -3.61239947e-02f, 6.39872700e-02f, -3.84761505e-02f, -1.94937550e-02f, -5.31401873e-01f, 2.11488694e-01f, 3.04834228e-02f, -4.52031523e-01f,
  1.27010703e-01f, -4.77961689e-01f, -3.66951600e-02f, -3.25967222e-01f, 6.17078692e-02f, 2.87076652e-01f, 2.41384711e-02f, 1.28336087e-01f, -8.10013618e-03f, -3.74786377e-01f,
  8.44827816e-02f, 5.52434027e-02f, -9.02604386e-02f, -2.19091788e-01f, -2.09777772e-01f, -1.75172627e-01f, 5.01119383e-02f, -1.80178195e-01f, 7.76237622e-02f, 2.75531024e-01f,
  2.87357956e-01f, 4.99192923e-02f, 6.05857633e-02f, -1.22759175e-02f, 1.37884229e-01f, 1.19418360e-01f, -3.38172615e-02f, 1.27588376e-01f, 1.46415621e-01f, 8.51141810e-02f,
  1.47492215e-01f, -1.69075727e-01f, 2.49475949e-02f, 1.60502955e-01f, 6.90629557e-02f, -3.37211639e-02f, -2.68259011e-02f, 6.69413656e-02f, -1.21232532e-01f, 1.11504260e-03f,
  1.15655094e-01f, -2.17110649e-01f, 1.94211781e-01f, 1.67211235e-01f, -7.29005858e-02f, -2.39424065e-01f, -2.59859324e-01f, -3.58012885e-01f, 1.35621494e-02f, 1.27793133e-01f,
  -2.17146784e-01f, 9.15765613e-02f, 2.11309250e-02f, 1.72785848e-01f, 1.17427573e-01f, 2.82296896e-01f, 2.52159715e-01f, -2.17939273e-01f, 1.17518917e-01f, 3.35640498e-02f,
  -2.26496100e-01f, -1.09134592e-01f, -1.55057207e-01f, 3.53672914e-02f, 5.72713614e-02f, 3.68139520e-02f, -6.72161505e-02f, 1.16298571e-02f, -3.77552003e-01f, -8.07224400e-03f,
  -5.77069521e-02f, 2.21747711e-01f, 5.88009395e-02f, -8.70131403e-02f, 2.96075288e-02f, 2.26662010e-01f, -1.71751648e-01f, 2.63594598e-01f, -1.38543663e-03f, -2.18837053e-01f,
  -2.02592656e-01f, 2.38814145e-01f, -1.69211298e-01f, -2.15004474e-01f, -1.12263411e-01f, 3.56351845e-02f, -2.44694129e-01f, -4.05519083e-02f, -2.64354289e-01f, -1.90638304e-01f,
  1.28659859e-01f, 1.60859916e-02f, 6.71802014e-02f, 2.17680633e-01f, -7.43803903e-02f, 2.22225338e-01f, -2.16353148e-01f, 3.39978874e-01f, 1.01700254e-01f, -5.05893707e-01f,
  1.53294936e-01f, -1.91519052e-01f, 3.18834605e-03f, 1.65076423e-02f, -8.64873305e-02f, 2.34805718e-02f, 2.62920499e-01f, 1.76732704e-01f, 1.00516174e-02f, 4.49750945e-02f,
  3.22919518e-01f, -8.86637047e-02f, 1.48501277e-01f, -3.26542646e-01f, 2.90726661e-03f, -1.37320664e-02f, 4.24216151e-01f, -2.78532445e-01f, 1.53287753e-01f, 3.92442495e-01f,
  -4.17022854e-01f, 1.79264992e-01f, 1.41855910e-01f, 1.50670931e-01f, 5.39893880e-02f, -1.30566999e-01f, 5.22083370e-03f, 6.17670715e-02f, -4.16879863e-01f, -5.60586825e-02f,
  1.24758944e-01f, -9.71282572e-02f, -1.81853086e-01f, 1.60748765e-01f, 9.01816413e-02f, -2.61381119e-01f, -4.18122649e-01f, 2.69977361e-01f, -9.48459879e-02f, 9.63518210e-03f,
  -1.66954860e-01f, -1.46935195e-01f, -9.83862877e-02f, -1.01585880e-01f, 1.07759625e-01f, -3.12260687e-01f, 6.84024915e-02f, 3.83393794e-01f, -4.54206437e-01f, -3.68894577e-01f,
  -2.82052904e-01f, 3.54101151e-01f, -2.16213733e-01f, 1.10576816e-01f, -5.82323149e-02f, -7.65992776e-02f, 1.11439139e-01f, 3.71588990e-02f, 1.61863938e-01f, -1.09350175e-01f,
  -5.63610457e-02f, 3.20094615e-01f, 9.31544900e-02f, -1.58015341e-01f, -5.29804006e-02f, -1.27612397e-01f, -8.93385429e-03f, 2.06629321e-01f, 1.36780282e-02f, -2.93133795e-01f,
  -1.72230840e-01f, 1.82849362e-01f, 8.68026093e-02f, 3.91898662e-01f, -1.28664477e-02f, -1.53335631e-01f, -5.61510958e-02f, -9.93222296e-02f, -8.89593139e-02f, 6.71610758e-02f,
  -3.77924949e-01f, -3.84373903e-01f, -5.43035083e-02f, 1.37237953e-02f, -9.22754481e-02f, 1.15828523e-02f, 2.82216936e-01f, -7.93459713e-02f, 3.49622756e-01f, -2.15848848e-01f,
  -3.13678458e-02f, 1.17504194e-01f, -1.21856807e-02f, 1.00008935e-01f, -1.92355692e-01f, -5.51844500e-02f, -6.81604668e-02f, -1.45640835e-01f, -1.91310510e-01f, -2.75981009e-01f,
  -1.16796248e-01f, 8.77645165e-02f, 1.58392459e-01f, 2.14015603e-01f, -1.61735058e-01f, -1.13393277e-01f, -1.76992103e-01f, 2.19903037e-01f, -1.92749605e-01f, 1.23810962e-01f,
  3.77750814e-01f, -1.66459620e-01f, 7.14241490e-02f, -2.40078956e-01f, -2.54017059e-02f, -5.03296673e-01f, -8.68398845e-02f, -2.63077140e-01f, -1.02930553e-01f, 3.58441055e-01f,
  6.07497105e-03f, 2.20628813e-01f, -3.45305428e-02f, -1.44365549e-01f, -2.15155348e-01f, -2.32965276e-02f, 6.96106479e-02f, -3.72194052e-01f, 1.14705935e-01f, 5.56334734e-01f,
  6.97480366e-02f, 3.63921537e-03f, 1.39964968e-02f, -2.95406580e-01f, 8.05401430e-02f, -2.02088773e-01f, -7.35072792e-02f, -2.79285815e-02f, 5.22627495e-02f, -1.39903292e-01f,
  1.02780081e-01f, 1.89809710e-01f, 1.01849057e-01f, -1.93625726e-02f, -2.17144892e-01f, -6.09002076e-02f, -6.46706745e-02f, -8.97667930e-02f, 2.87317872e-01f, 8.47701579e-02f,
  1.38951778e-01f, 8.93844962e-02f, 1.47343829e-01f, -5.17010465e-02f, -9.56882089e-02f, 9.26104710e-02f, -4.03317720e-01f, -1.85548747e-03f, -5.44314921e-01f, -1.72779381e-01f,
  1.02430508e-01f, -3.70274067e-01f, 2.00264588e-01f, -4.00750428e-01f, -2.04532549e-01f, 8.78591090e-02f, -4.43820596e-01f, 3.04379582e-01f, -4.59597945e-01f, 3.83046478e-01f,
  -1.18783057e-01f, -1.27498180e-01f, 3.72928679e-02f, 1.86424792e-01f, 3.40738962e-03f, -1.11968115e-01f, 9.67324972e-02f, 5.39148524e-02f, -5.70915639e-01f, 2.11363703e-01f,
  -6.17565632e-01f, -2.88577169e-01f, -5.75940982e-02f, -1.94397330e-01f, -3.71189718e-03f, 5.46585135e-02f, 1.79454070e-02f, 1.20792780e-02f, 1.08345374e-01f, 3.59286889e-02f,
  1.26626700e-01f, -6.35300055e-02f, 1.07997678e-01f, -3.28265786e-01f, -1.90399699e-02f, -5.54959849e-02f, 9.40733403e-02f, 8.02506953e-02f, 6.76699877e-02f, -1.46252234e-02f,
  2.07071885e-01f, -1.14108406e-01f, 4.35241237e-02f, 2.11373359e-01f, 1.98691785e-01f, 2.38974780e-01f, 2.17665419e-01f, 5.30337822e-03f, -1.44337043e-01f, 2.63460994e-01f,
  1.06829405e-01f, -3.14547628e-01f, 1.06763327e-02f, -8.62518474e-02f, -1.25257969e-01f, 1.67251974e-01f, -1.77949727e-01f, -1.01277888e-01f, 1.15210511e-01f, 8.12216029e-02f,
  -8.26078206e-02f, 6.91788793e-02f, -4.91936095e-02f, 1.67400599e-01f, -8.76866058e-02f, 1.37901872e-01f, -2.38000467e-01f, 1.97134644e-01f, -1.25639081e-01f, -1.22630551e-01f,
  -1.00432500e-01f, -2.76431553e-02f, 1.00787222e-01f, -3.21700513e-01f, 8.59452635e-02f, 1.92626595e-01f, -1.91694856e-01f, -6.18173033e-02f, -1.63078859e-01f, -3.98030937e-01f,
  -2.51043141e-01f, -1.69836402e-01f, -3.19985807e-01f, 3.39959979e-01f, 2.62074769e-01f, 3.06546185e-02f, -7.40465969e-02f, -1.81903854e-01f, 3.25206608e-01f, 2.00211883e-01f,
  1.81832597e-01f, -1.61450356e-01f, -6.26445338e-02f, -6.29906952e-02f, -1.43602313e-02f, -2.81484183e-02f, 2.01175049e-01f, -2.42572114e-01f, -2.01005265e-01f, -3.53339076e-01f,
  1.85238093e-01f, -2.26449426e-02f, -1.10284440e-01f, 3.88876289e-01f, -1.05832644e-01f, 5.90363368e-02f, -3.20788205e-01f, 1.27129287e-01f, 1.51666373e-01f, 3.10635477e-01f,
  1.26360223e-01f, -3.25811744e-01f, 3.72190699e-02f, -3.52853090e-01f, -3.80526811e-01f, -2.92811215e-01f, 6.00687750e-02f, -4.99827176e-01f, 1.26175150e-01f, -3.14028859e-01f,
  1.80963829e-01f, 2.26456538e-01f, 8.40412825e-02f, 2.07854912e-01f, -1.82791144e-01f, 2.03040451e-01f, 1.19346336e-01f, -5.92884980e-02f, 9.22224149e-02f, -2.81827748e-01f,
  -5.61144538e-02f, 8.00014660e-02f, -1.62697211e-01f, 8.18278417e-02f, -7.30053857e-02f, -2.22996622e-01f, 7.04177171e-02f, -3.96675110e-01f, 1.22855157e-01f, -1.43182635e-01f,
  -8.66459124e-03f, 2.04877242e-01f, 1.02304287e-01f, -1.14768483e-01f, -4.06624585e-01f, 3.76157798e-02f, -4.86690551e-02f, -1.86466858e-01f, 1.09205499e-01f, -2.97391504e-01f,
  3.96985635e-02f, 3.36857885e-02f, 7.38950297e-02f, -1.74830392e-01f, -1.38890613e-02f, 1.05532415e-01f, 2.27570720e-02f, 2.99035739e-02f, -1.50246158e-01f, 8.67933780e-02f,
  -1.20425485e-01f, 1.55780300e-01f, 6.65314216e-03f, 1.25965565e-01f, -6.50329068e-02f, -4.76056673e-02f, 1.56876653e-01f, 6.42286465e-02f, 4.13779765e-02f, 5.20632155e-02f,
  2.01801330e-01f, 4.84700501e-02f, 3.55804674e-02f, 1.99485302e-01f, 1.23630188e-01f, -7.78417364e-02f, 1.31897703e-01f, 1.04913861e-01f, 1.87149402e-02f, 2.40678759e-03f,
  -7.15598688e-02f, 2.09056363e-01f, 2.52537072e-01f, 9.89511311e-02f, 8.37164894e-02f, 1.26407877e-01f, 1.91836953e-01f, -2.34951466e-01f, 1.78015113e-01f, -5.61565571e-02f,
  2.14509759e-02f, -9.91112180e-03f, 8.21149498e-02f, -8.11569095e-02f, 4.24866527e-02f, -7.92391784e-03f, 1.71917558e-01f, 3.31252038e-01f, 1.75428391e-02f, -2.99337745e-01f,
  3.24830472e-01f, -2.48402327e-01f, -2.18598261e-01f, 1.49912089e-01f, 2.29842275e-01f, 5.23946919e-02f, -2.35056475e-01f, 2.66217738e-01f, -1.74289361e-01f, -2.49812990e-01f,
  2.77006179e-01f, 4.10166681e-01f, 1.13559864e-01f, 1.37632161e-01f, -1.27118468e-01f, -3.04415405e-01f, -3.62914354e-01f, 1.45922974e-01f, 1.58726349e-01f, 2.06014495e-02f,
  -8.27393532e-02f, -1.57901168e-01f, -2.08122134e-01f, 4.83295321e-03f, -2.64613956e-01f, -1.66552529e-01f, -7.19469553e-03f, -3.71030033e-01f, 1.04245253e-01f, 2.33989686e-01f,
  6.36019856e-02f, -1.45893723e-01f, -4.95700210e-01f, -1.91314518e-02f, -2.38716304e-01f, -1.89936236e-01f, 1.84138888e-03f, -2.42703438e-01f, -1.34198830e-01f, -2.00170606e-01f,
  3.62862974e-01f, 2.38390341e-01f, 4.89918143e-02f, -2.97086835e-01f, 3.74407411e-01f, 2.90037811e-01f, 9.13574621e-02f, -1.48927122e-01f, -1.15941040e-01f, -1.71827242e-01f,
  1.02856465e-01f, 9.49194804e-02f, 8.30316618e-02f, 2.23887861e-01f, 1.85506240e-01f, 7.52867758e-02f, -1.60796583e-01f, 1.20942155e-02f, -3.75768840e-01f, -9.05548334e-02f,
  4.41869348e-01f, 5.98352738e-02f, -5.20011038e-03f, -3.33046943e-01f, -2.04110488e-01f, -9.57368016e-02f, -9.22678337e-02f, 2.28160352e-01f, 1.18894190e-01f, -1.55640617e-01f,
  1.69527844e-01f, -2.98706830e-01f, -2.57064309e-02f, -1.80464134e-01f, 1.29501224e-01f, -5.22664487e-01f, -1.57686472e-01f, -2.64895111e-01f, -3.60853001e-02f, -1.45982513e-02f,
  -1.40351340e-01f, 1.92766622e-01f, 2.22931877e-01f, 2.43680909e-01f, 4.62047979e-02f, -4.77448571e-03f, 1.95704803e-01f, 5.92603050e-02f, 7.04719638e-03f, -2.35786736e-02f,
  1.87659729e-02f, 1.66773036e-01f, 8.06456581e-02f, 1.58835435e-03f, 3.21717262e-02f, -1.18355162e-01f, -2.91463230e-02f, 1.95923701e-01f, 1.75987825e-01f, -3.74398492e-02f,
  1.63198188e-01f, -1.52039424e-01f, 1.43000260e-01f, 1.86593458e-01f, 5.98903634e-02f, -8.27214941e-02f, 6.39413744e-02f, 2.19033938e-02f, 1.96654543e-01f, -1.80590991e-02f,
  4.73803096e-02f, -2.16049775e-01f, 1.98133036e-01f, -1.58663556e-01f, 9.90053788e-02f, 6.59026578e-02f, -6.83399215e-02f, -7.62015060e-02f, 8.65385905e-02f, -2.83455014e-01f,
  8.17314312e-02f, -2.15588138e-01f, 1.38239533e-01f, -1.49041966e-01f, 8.20791200e-02f, 2.56129980e-01f, 2.49529064e-01f, 1.02862522e-01f, 3.74423474e-01f, -1.15168437e-01f,
  2.27821916e-01f, 1.17642522e-01f, -1.20235989e-02f, 4.43743944e-01f, -5.60200624e-02f, -1.76734716e-01f, 1.42421708e-01f, 1.42515272e-01f, 1.79002002e-01f, 3.10424656e-01f,
  -2.77721465e-01f, -1.52941808e-01f, 3.99766304e-02f, -1.50738522e-01f, 2.23330587e-01f, 2.08853096e-01f, 8.10410082e-02f, 1.45614699e-01f, -1.08119637e-01f, -2.10812986e-01f,
  1.46242917e-01f, 1.44013345e-01f, -1.64631829e-01f, -2.22921655e-01f, -1.65691704e-01f, 2.16340810e-01f, -1.16396725e-01f, -2.01414719e-01f, -4.13606912e-01f, 2.30816111e-01f,
  -7.88063183e-03f, -1.50908455e-01f, 5.88848665e-02f, -1.56809583e-01f, -3.94097120e-01f, -2.16873601e-01f, -1.85174644e-02f, -4.91835997e-02f, 2.67885551e-02f, 1.21204667e-01f,
  -2.64652818e-02f, 1.29207239e-01f, -3.25338364e-01f, 9.54990312e-02f, 4.42862930e-03f, 3.30395699e-01f, -2.72565424e-01f, -1.70020953e-01f, 4.31247689e-02f, -2.96274610e-02f,
  -1.61565363e-01f, 5.96639663e-02f, 3.55227798e-01f, -1.76100180e-01f, -1.51045531e-01f, 6.53170887e-03f, -2.79668570e-01f, -6.87031746e-02f, -3.34980756e-01f, -5.52988231e-01f,
  2.44961560e-01f, -4.45232838e-01f, 3.05700421e-01f, -2.94234663e-01f, 2.25596815e-01f, -1.91216424e-01f, -1.65317491e-01f, -3.28898728e-01f, -2.06707805e-01f, -1.44415900e-01f,
  -1.93911627e-01f, -3.63968536e-02f, -1.76217437e-01f, 1.20715506e-01f, -1.49266258e-01f, 1.64046362e-02f, 1.42973632e-01f, 6.46945834e-02f, -1.28867477e-01f, 8.39566812e-02f,
  4.15674560e-02f, -4.12608013e-02f, -1.17470995e-01f, -1.56805262e-01f, 5.59319071e-02f, -1.18819438e-01f, 2.25747973e-02f, -1.91630483e-01f, 6.77023977e-02f, -5.41814119e-02f,
  -2.35014379e-01f, -1.11506574e-01f, -6.72740340e-02f, 6.15640543e-02f, 1.44390166e-02f, 3.02483235e-02f, 5.83622139e-03f, 3.60611007e-02f, -3.26188296e-01f, -4.15887199e-02f,
  1.18848570e-01f, 9.87545773e-02f, 5.66222630e-02f, -8.10448360e-03f, 6.13001101e-02f, 1.88527573e-02f, -7.70660564e-02f, 1.65352505e-02f, 1.06745690e-01f, 1.91860716e-03f,
  -2.20372304e-01f, 5.83304763e-02f, -2.21440122e-01f, 1.22958831e-01f, -3.89808565e-02f, -1.64298832e-01f, 1.43546507e-01f, 3.93146724e-02f, 7.85696581e-02f, 7.74700791e-02f,
  2.26625521e-02f, -7.26396292e-02f, 3.33698437e-04f, -6.67626783e-02f, -6.79397359e-02f, -8.89862925e-02f, -1.13198593e-01f, 3.95565256e-02f, 2.47623120e-02f, -2.16216087e-01f,
  2.45621777e-03f, -2.89816409e-01f, -9.20454785e-02f, -3.02773062e-02f, -7.87226483e-02f, 2.89579421e-01f, -1.96577072e-01f, -9.30173881e-03f, 9.18097645e-02f, -1.22295558e-01f,
  1.57596678e-01f, 3.11917216e-02f, -3.58485021e-02f, -2.23994181e-01f, -7.49433488e-02f, -1.54275313e-01f, 2.38556355e-01f, -1.34085268e-01f, -4.08974215e-02f, -2.16812462e-01f,
  -2.10681129e-02f, -1.17966741e-01f, 2.62954086e-01f, 3.84969711e-02f, 1.72661111e-01f, 1.26235440e-01f, -3.13184112e-01f, -8.55649784e-02f, -1.17234759e-01f, -2.18283281e-01f,
  -9.58349258e-02f, 2.38015369e-01f, -1.69148535e-01f, 1.85181394e-01f, 3.52213457e-02f, -1.55445904e-01f, 1.33654132e-01f, -2.27177784e-01f, -1.09786272e-01f, 1.18445590e-01f,
  -9.35352370e-02f, -6.54034019e-02f, 2.47223705e-01f, 2.36039713e-01f, 2.96615362e-01f, 5.07524721e-02f, 5.63051691e-03f, 2.09694263e-02f, -1.66295707e-01f, -2.69119181e-02f,
  -2.64425039e-01f, 7.84153268e-02f, 2.62351871e-01f, -3.34863931e-01f, 2.28814095e-01f, 1.32682160e-01f, -3.38696122e-01f, -2.12605298e-01f, 1.01886570e-01f, 1.92209497e-01f,
  -3.39549839e-01f, 1.92960829e-01f, 1.35128379e-01f, 2.67324429e-02f, -2.98416354e-02f, -2.58053064e-01f, -2.15737998e-01f, -3.74440819e-01f, -4.19581175e-01f, 1.04510792e-01f,
  1.99072525e-01f, -2.36402318e-01f, -1.61807076e-03f, 8.19560140e-02f, -3.77223156e-02f, 1.16667077e-01f, -1.76503077e-01f, -3.61555964e-01f, 7.39056766e-02f, 1.94319915e-02f,
  1.73097670e-01f, 1.54951513e-01f, -2.26041213e-01f, -4.76202592e-02f, 5.38520142e-02f, 4.37425822e-02f, -5.90822101e-03f, -5.70961386e-02f, 1.63359538e-01f, 5.31846918e-02f,
  -6.30806759e-02f, 1.12748213e-01f, -9.38134864e-02f, 5.77654643e-03f, 2.63823837e-04f, -9.81496274e-02f, 2.11480297e-02f, -3.23225737e-01f, -3.45209874e-02f, -2.52441108e-01f,
  1.56179622e-01f, 2.70632327e-01f, 6.83669671e-02f, 8.44585225e-02f, -1.31747988e-03f, -9.19564664e-02f, -2.63554662e-01f, 1.23183586e-01f, 1.97159454e-01f, 1.71230771e-02f,
  3.86281833e-02f, -6.36551827e-02f, 6.69906207e-04f, -1.07568592e-01f, -2.22348705e-01f, -2.87234306e-01f, -9.39013958e-02f, 6.93634152e-02f, -2.08061069e-01f, -2.48273090e-01f,
  1.82242975e-01f, -2.99311668e-01f, -3.13888013e-01f, 3.29261303e-01f, -2.99538355e-02f, 2.41372049e-01f, 1.84425205e-01f, -9.73890275e-02f, -6.28702864e-02f, 1.23071879e-01f,
  4.10190284e-01f, -1.03388950e-02f, -5.47934324e-02f, -1.79608792e-01f, 2.95905292e-01f, -3.49743515e-02f, -2.58097649e-01f, 9.48146079e-03f, 4.16305274e-01f, 3.12512726e-01f,
  -2.17063755e-01f, -1.24430887e-01f, -1.49253041e-01f, -2.76465297e-01f, 3.54279459e-01f, -4.04824376e-01f, -3.14000309e-01f, 7.48568773e-02f, -7.83489048e-02f, 1.87763870e-01f,
  -1.15653396e-01f, 1.78384900e-01f, 7.87929818e-03f, 2.94629335e-01f, -2.33773917e-01f, -8.27129930e-02f, 1.22409798e-01f, -1.92539379e-01f, 1.80032700e-01f, 5.46864450e-01f,
  -2.16765434e-01f, -9.36147198e-02f, -1.78637534e-01f, 1.10247172e-01f, 1.17105067e-01f, 2.56284714e-01f, -7.30091184e-02f, 2.52081543e-01f, 2.18745470e-02f, 6.99100867e-02f,
  2.00363621e-01f, 2.52652466e-01f, 1.01406097e-01f, -3.06822211e-01f, -8.62548947e-02f, -8.42042789e-02f, -2.58064568e-02f, -3.92706126e-01f, -2.18308434e-01f, 1.78508952e-01f,
  -1.97659537e-01f, -5.18490113e-02f, -1.23383038e-01f, -3.71800624e-02f, -3.22587669e-01f, -5.08694172e-01f, -2.97339946e-01f, 2.04900410e-02f, -1.23390807e-02f, 2.71234781e-01f,
  -2.27422014e-01f, 3.07956636e-01f, 4.68301475e-02f, -4.19700801e-01f, 4.81699370e-02f, 2.45332330e-01f, 1.62409171e-01f, -8.32558572e-02f, 2.75938828e-02f, 4.01364313e-03f,
  1.96471363e-02f, 2.17468664e-01f, 2.97176003e-01f, 4.59979847e-02f, -2.69618649e-02f, 2.05867082e-01f, -1.44166112e-01f, -3.95641446e-01f, 1.38386309e-01f, -2.87831039e-03f,
  -2.25670904e-01f, 1.78452909e-01f, -1.01027139e-01f, 1.31511897e-01f, 1.13680996e-01f, -8.08310434e-02f, 9.85283777e-03f, -6.45761415e-02f, 7.33856484e-02f, -1.80866018e-01f,
  -2.42765509e-02f, -1.11114219e-01f, -1.66287906e-02f, -3.68111804e-02f, -1.36037141e-01f, 5.24586588e-02f, -1.99151143e-01f, 1.25499234e-01f, 3.58367451e-02f, -3.02164182e-02f,
  1.70869797e-01f, 2.44513407e-01f, -1.08979400e-02f, -2.98142999e-01f, -2.64836967e-01f, 2.64126331e-01f, -7.68262707e-03f, 3.36879969e-01f, 9.47532803e-02f, 1.67387619e-03f,
  -1.39388368e-01f, -3.78735596e-04f, 2.95678414e-02f, 2.76362121e-01f, -5.72404861e-02f, 9.59308967e-02f, 1.54022738e-01f, 2.14048270e-02f, 1.69251025e-01f, -1.29275113e-01f,
  5.27713671e-02f, 2.57665187e-01f, -4.37718242e-01f, 2.27532580e-01f, -4.05543447e-01f, -3.46746653e-01f, -5.44055775e-02f, -4.20337200e-01f, -8.38446617e-02f, -1.91306800e-01f,
  1.07776962e-01f, 3.43953967e-01f, 7.61746541e-02f, 2.36368418e-01f, 2.88838357e-01f, 1.83691114e-01f, -1.43003613e-01f, -1.41421920e-02f, -9.39043388e-02f, -5.56432605e-02f,
  2.31038556e-01f, 2.89006740e-01f, -1.07972704e-01f, 5.76968584e-03f, 9.89579707e-02f, 7.71894380e-02f, -2.48391822e-01f, -1.13695621e-01f, 1.83313996e-01f, 3.84719610e-01f,
  -4.11342621e-01f, 1.06974460e-01f, 3.83612365e-01f, 4.03434217e-01f, 4.71235402e-02f, 2.96514899e-01f, 3.78662467e-01f, -1.33984312e-01f, 1.48221463e-01f, 2.87993133e-01f,
  4.16778624e-01f, 7.09051937e-02f, -2.86602944e-01f, 1.89138710e-01f, 1.57061607e-01f, -1.58839703e-01f, 1.45566612e-01f, 8.33251700e-03f, -3.36528748e-01f, 5.36416434e-02f,
  4.62656915e-01f, -9.32406262e-02f, -1.81523561e-01f, 1.28106087e-01f, 1.28966317e-01f, 2.15645432e-01f, -1.33249417e-01f, 2.88706928e-01f, 2.09545821e-01f, -1.32335559e-01f,
  -2.40999550e-01f, -1.89670414e-01f, 3.25519621e-01f, 3.51269916e-02f, -9.36049670e-02f, -3.09908450e-01f, 1.81276605e-01f, -4.01155025e-01f, 2.56962627e-01f, -3.04959536e-01f,
  -4.32714701e-01f, -3.64688307e-01f, -3.56234610e-01f, -5.17686792e-02f, -1.68723509e-01f, -6.32959902e-02f, 1.65378466e-01f, 1.74693868e-01f, -1.63299114e-01f, -1.63103908e-01f,
  1.35647869e-02f, -1.82984635e-01f, -1.99186411e-02f, 1.81510702e-01f, 1.18570803e-02f, 1.41883031e-01f, 3.07994690e-02f, -2.66163051e-02f, -1.85434908e-01f, -2.05926523e-02f,
  1.29873365e-01f, 3.06181755e-04f, 7.00302050e-03f, -1.88226327e-01f, 1.32889509e-01f, -2.78589949e-02f, 7.76694417e-02f, -1.70213088e-01f, -2.22795382e-01f, 1.14772648e-01f,
  4.18938324e-02f, -1.14702091e-01f, 6.35257363e-02f, 2.19747171e-01f, -2.94321738e-02f, -1.56141534e-01f, -7.12052509e-02f, -2.63025612e-01f, -3.60730541e-04f, 2.01590955e-02f,
  4.37372103e-02f, 4.05181088e-02f, -1.30412638e-01f, -1.05588086e-01f, 4.15225923e-02f, -8.61597806e-03f, 3.04524601e-02f, -7.66820237e-02f, 1.11811061e-03f, -8.50668103e-02f,
  8.20458829e-02f, 5.40594421e-02f, 3.43115255e-02f, -4.32660580e-02f, 2.26351246e-01f, 3.30622308e-02f, 4.27335948e-02f, 7.18414858e-02f, -3.10559630e-01f, 3.88963670e-02f,
  4.00287472e-02f, -2.41904989e-01f, -7.62737915e-02f, -1.92010060e-01f, -2.00515892e-02f, -1.59324184e-01f, -6.66747466e-02f, -3.05767715e-01f, -1.50428325e-01f, -9.99515057e-02f,
  -2.96004236e-01f, 2.21297517e-01f, 2.33632714e-01f, -2.84037385e-02f, 3.11941862e-01f, 2.50059903e-01f, 2.58765250e-01f, -3.72015983e-01f, 1.69714630e-01f, -2.53452450e-01f,
  1.20075800e-01f, 3.31307769e-01f, -2.37912238e-01f, 8.52264240e-02f, -1.86253507e-02f, 2.45966315e-01f, -1.40550867e-01f, -1.91082492e-01f, 1.35692015e-01f, 1.86586842e-01f,
  1.68045342e-01f, 4.64138016e-03f, 2.08423082e-02f, -2.26716191e-01f, -1.53622970e-01f, 1.00233130e-01f, 3.12928945e-01f, 2.47503817e-02f, 6.85354834e-03f, -7.01346546e-02f,
  1.33322582e-01f, 2.20229134e-01f, 1.69850990e-01f, -2.13846788e-01f, -4.80619609e-01f, 5.43082431e-02f, 8.57259110e-02f, -1.49982661e-01f, -2.70454496e-01f, -1.29875273e-01f,
  1.01300972e-02f, -2.00765878e-01f, -1.61072344e-01f, -1.79461855e-02f, -1.89108893e-01f, 2.32292548e-01f, 2.70583723e-02f, -2.70370930e-01f, 8.50744471e-02f, -3.01365912e-01f,
  9.03688073e-02f, -3.57675374e-01f, -1.94314942e-01f, 2.99563020e-01f, -2.79489338e-01f, 8.35051537e-02f, -1.94356173e-01f, -1.17106453e-01f, -6.01360679e-01f, 2.73924768e-01f,
  -3.11219916e-02f, 1.88086048e-01f, 7.82504156e-02f, -4.46716011e-01f, 1.74842402e-01f, 1.22009844e-01f, -4.12660480e-01f, 2.80410588e-01f, -1.56732097e-01f, -1.28325194e-01f,
  1.87274426e-01f, -2.35485524e-01f, -8.83324891e-02f, -5.06653078e-02f, -2.27230950e-04f, -4.29535396e-02f, -2.78234947e-02f, -1.77297443e-01f, 1.34727871e-02f, 8.50435942e-02f,
  -8.29659402e-02f, -9.27090719e-02f, -4.79050465e-02f, 8.11676234e-02f, 2.43932121e-02f, 7.65041858e-02f, 1.23206876e-01f, 4.99210097e-02f, -3.87770869e-02f, -3.71670201e-02f,
  5.09124547e-02f, -1.89802781e-01f, 1.32757694e-01f, 1.01789415e-01f, 3.35495989e-03f, 2.31795356e-01f, -3.29959542e-01f, 3.18548419e-02f, -1.43727213e-01f, 1.12178206e-01f,
  1.13614939e-01f, 1.72476955e-02f, 4.40105330e-03f, -2.27988511e-01f, 1.02029175e-01f, 2.33211145e-02f, 2.88540348e-02f, 9.11718979e-02f, 1.23474968e-03f, 3.87443155e-02f,
  1.69154987e-01f, 6.32527173e-02f, 1.25046864e-01f, 5.62163927e-02f, -9.60485935e-02f, 1.27289444e-01f, 1.90980554e-01f, -2.77658165e-01f, 9.00531784e-02f, 1.39529929e-01f,
  2.22110301e-01f, -1.01627588e-01f, 1.86589032e-01f, 2.05670998e-01f, 2.55264282e-01f, 1.91719428e-01f, 2.51053393e-01f, -3.08683574e-01f, 1.88665882e-01f, -3.72749448e-01f,
  2.43318245e-01f, -3.68392050e-01f, -3.40324700e-01f, 1.68313518e-01f, 1.80467859e-01f, -1.32424161e-01f, 1.45436861e-02f, 4.97907884e-02f, 9.32489783e-02f, -1.82335868e-01f,
  2.14720577e-01f, -1.40214741e-01f, 4.58444655e-02f, 3.34796071e-01f, 2.91271538e-01f, 2.28405878e-01f, -4.89055179e-02f, -2.62846917e-01f, 1.70088522e-02f, -1.19721398e-01f,
  -1.73339486e-01f, -2.08064597e-02f, 6.10061064e-02f, -9.01469216e-02f, -1.32279709e-01f, -1.17209673e-01f, 3.46367843e-02f, -8.93324167e-02f, -3.26654106e-01f, 2.05228359e-01f,
  9.43653211e-02f, -1.39190212e-01f, 1.40864342e-01f, -3.02626994e-02f, -3.88058722e-01f, -2.90111810e-01f, -1.27518907e-01f, 1.71031609e-01f, 1.01026312e-01f, -4.56495620e-02f,
  2.60122418e-01f, 8.04706812e-02f, 1.24981023e-01f, 2.10181829e-02f, -1.91674441e-01f, -4.44570333e-01f, -4.65216160e-01f, 7.32588843e-02f, -2.82399148e-01f, -2.71437950e-02f,
  -1.68436900e-01f, 3.41654003e-01f, 1.06858090e-01f, 2.74102271e-01f, 9.65984538e-03f, 1.28478661e-01f, 1.77422866e-01f, -6.29414991e-02f, -1.91558018e-01f, -3.86429399e-01f,
  1.32939711e-01f, 1.61610365e-01f, -4.18345958e-01f, -1.97031677e-01f, -2.52358943e-01f, 6.95757475e-03f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  -7.55115300e-02f, -9.91620775e-03f, 3.17361206e-02f, -6.30061552e-02f, 3.10207065e-02f, 5.30645289e-02f, 6.65500611e-02f, -4.06619124e-02f, 7.80278444e-03f, 6.29020631e-02f,
  -5.91044873e-02f, -5.81166260e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 51, 26
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        128, 51, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        128, 12
    );
    }
    