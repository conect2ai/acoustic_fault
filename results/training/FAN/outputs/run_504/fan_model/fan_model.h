/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  7.61733800e-02f, -7.46258488e-03f, -2.72417553e-02f, -6.72072079e-03f, -7.22777173e-02f, 2.53044307e-01f, 1.24092877e-01f, -5.13298362e-02f, 2.43293777e-01f, -5.10999225e-02f,
  3.85509729e-02f, -1.50450841e-01f, 3.99184860e-02f, 1.79725885e-01f, 4.56926506e-03f, 7.33637586e-02f, 1.07871838e-01f, 5.65357022e-02f, 6.73320740e-02f, -2.61109117e-02f,
  2.36819461e-02f, 7.67023191e-02f, -3.55949588e-02f, -7.98015296e-02f, -5.53131402e-02f, -1.65481135e-01f, -2.40796968e-01f, -1.07248619e-01f, -1.18506104e-01f, 1.36525063e-02f,
  1.33593187e-01f, 4.25594039e-02f, -7.52408728e-02f, 5.61037809e-02f, -4.05323617e-02f, -9.53091532e-02f, 5.06267473e-02f, -3.96738686e-02f, 6.94271252e-02f, 4.63854447e-02f,
  2.47683916e-02f, 3.62957790e-02f, 9.98336822e-02f, -4.67402600e-02f, 2.06166543e-02f, -2.89779585e-02f, 5.37900347e-03f, 2.51345374e-02f, -1.83656458e-02f, 1.72095113e-02f,
  1.32606048e-02f, 5.54440394e-02f, 2.32414622e-02f, -1.75154675e-02f, 3.93470190e-03f, 2.76922956e-02f, 1.03871441e-02f, -6.64672777e-02f, -1.69917792e-02f, -7.17441598e-03f,
  5.18044867e-02f, 7.97147956e-03f, -5.01566101e-03f, -1.86791308e-02f, 3.20588276e-02f, 3.71925742e-03f, 5.03343381e-02f, -1.24766156e-02f, -3.37332226e-02f, 3.78299430e-02f,
  -5.88565841e-02f, 5.52906878e-02f, 2.65176464e-02f, 7.75255412e-02f, -1.37546444e-02f, 1.64888315e-02f, -8.50368664e-02f, -1.19232550e-01f, -2.07716282e-02f, -7.48446723e-03f,
  8.48316923e-02f, 3.59256975e-02f, -1.26316890e-01f, -8.54417309e-03f, 4.76903953e-02f, -2.61543505e-02f, 7.32878689e-03f, 5.85363768e-02f, 2.79414505e-02f, -3.35515141e-02f,
  8.36888775e-02f, -6.72635576e-03f, -3.36990505e-02f, 4.69885021e-02f, -8.87140539e-03f, 3.54672447e-02f, 7.08122477e-02f, 1.17660593e-02f, 1.84037555e-02f, -3.31826098e-02f,
  -3.97793651e-02f, -6.10564351e-02f, -7.87024051e-02f, -1.91018861e-02f, 2.73041101e-03f, -5.90069294e-02f, -1.53786708e-02f, -5.84043413e-02f, 3.10020521e-02f, -1.50609976e-02f,
  -1.87988374e-02f, -5.39661832e-02f, -3.23088840e-02f, -5.40053286e-02f, 4.93309200e-02f, -1.24416932e-01f, -6.95857860e-04f, -4.63231467e-02f, -8.60340074e-02f, 1.38067896e-03f,
  1.05075859e-01f, 1.88885108e-01f, 1.56412479e-02f, -6.23020902e-02f, -1.11108683e-01f, 9.67006087e-02f, 1.66346729e-01f, -1.37595177e-01f, 7.41323009e-02f, 6.90345988e-02f,
  -1.73179463e-01f, 2.20619753e-01f, 8.10649171e-02f, -7.18194991e-02f, -1.27529696e-01f, 1.18123531e-01f, -5.08290529e-02f, 5.32015748e-02f, 9.74485010e-04f, -2.55741179e-02f,
  -8.51866230e-02f, -1.46830469e-01f, -7.52472430e-02f, -7.98643306e-02f, 9.62048173e-02f, 2.27279738e-02f, -1.21290505e-01f, 7.98502341e-02f, -7.85726309e-02f, 5.01405820e-03f,
  1.35808038e-02f, 4.76960689e-02f, 3.71561870e-02f, 5.02230860e-02f, 3.81657258e-02f, 8.65807384e-03f, 1.77936405e-02f, -2.47797165e-02f, -6.08256906e-02f, 1.00959223e-02f,
  2.24492475e-02f, -1.15091046e-02f, 3.87234353e-02f, 2.43448839e-02f, 5.57343438e-02f, -2.74440963e-02f, -6.02417905e-03f, -2.92670559e-02f, 9.73251555e-03f, 1.37475934e-02f,
  2.93971524e-02f, -2.32195668e-02f, -5.16575463e-02f, 2.20279265e-02f, 1.19062755e-02f, 1.71802305e-02f, -1.73665420e-03f, 5.34878410e-02f, -3.36234720e-04f, 1.37002841e-02f,
  5.79478852e-02f, -2.74249893e-02f, 2.97109783e-02f, -6.91267475e-02f, -1.84593163e-02f, -1.18554002e-02f, -4.70191129e-02f, 4.26895618e-02f, 1.70215182e-02f, -2.15930827e-02f,
  -6.62099198e-02f, -6.22786693e-02f, -3.26191224e-02f, -3.61603610e-02f, 2.01113336e-02f, 6.18469436e-03f, -6.10132404e-02f, 5.38209230e-02f, 3.16915894e-03f, -6.64193067e-04f,
  -5.98949380e-02f, 3.01283821e-02f, -2.31264308e-02f, 3.16661857e-02f, -9.47175920e-02f, -1.25377746e-02f, -6.98360987e-03f, 4.04073000e-02f, 4.53083823e-03f, -1.38233816e-02f,
  -2.95303613e-02f, 5.41703328e-02f, 4.55394424e-02f, -9.28401574e-03f, -1.08573688e-02f, -2.15383433e-02f, 3.34598608e-02f, -7.29982229e-03f, 5.68045191e-02f, -7.56062288e-03f,
  -5.54795302e-02f, -7.03832321e-03f, 2.04655342e-02f, -9.17484984e-02f, -5.19353524e-02f, -1.35075934e-02f, -9.82590718e-04f, -2.33053565e-02f, -8.19694530e-03f, 4.36674915e-02f,
  -1.49020888e-02f, 3.76301855e-02f, 2.51511857e-03f, -4.21954580e-02f, 1.48151377e-02f, 2.95961630e-02f, -3.50502767e-02f, 4.92146946e-02f, -6.18732385e-02f, 2.80336682e-02f,
  2.69140035e-01f, 5.19647524e-02f, 1.10225804e-01f, 2.22846135e-01f, -1.31252453e-01f, -1.26154125e-01f, -8.13158751e-02f, -6.89638853e-02f, 2.00036645e-01f, -8.81833211e-02f,
  -1.14690103e-01f, 4.10082266e-02f, -9.41972956e-02f, 3.76844555e-02f, 1.44406393e-01f, -1.10979207e-01f, 2.08234303e-02f, -6.37125075e-02f, -2.20330451e-02f, 7.40634557e-03f,
  1.15436383e-01f, -1.23335481e-01f, -5.58232740e-02f, -8.46181884e-02f, -3.68034467e-02f, 1.00034975e-01f, 5.60118482e-02f, -1.04175381e-01f, 5.21598430e-03f, -2.74237543e-02f,
  -8.09230208e-02f, 1.26263732e-02f, 4.79764957e-03f, 7.56270662e-02f, -1.98870748e-02f, -2.21007727e-02f, 3.30648944e-02f, -5.39424270e-02f, 4.96929884e-02f, -7.73383817e-03f,
  -6.25394359e-02f, 2.49568466e-02f, -6.88034222e-02f, 9.54470225e-03f, 5.18097356e-03f, 7.18254363e-03f, -4.62664068e-02f, 4.49106768e-02f, 4.62180451e-02f, 1.95241068e-03f,
  1.63996057e-03f, -4.76120822e-02f, 2.33781133e-02f, 2.36294456e-02f, 4.84907813e-02f, 2.40951963e-02f, 1.01878550e-02f, 2.54384940e-04f, -2.63955561e-03f, 4.61216494e-02f,
  2.85780933e-02f, 3.60459797e-02f, -6.13573156e-02f, 5.48908375e-02f, -3.50352377e-02f, -2.51809359e-02f, 9.32570081e-03f, -4.69193980e-02f, 3.38299312e-02f, 3.47464159e-02f,
  -2.93053910e-02f, 5.54735512e-02f, -5.45782037e-02f, 1.22557003e-02f, -3.60480621e-02f, -1.94372553e-02f, 5.77423237e-02f, -3.88075970e-02f, 5.26171103e-02f, 4.17248346e-02f,
  -2.18485408e-02f, 3.72114927e-02f, 1.85633730e-02f, -2.06366330e-02f, -2.25431193e-02f, 3.60678062e-02f, -1.47704314e-02f, -5.48942760e-03f, -4.44405302e-02f, -4.57023643e-02f,
  -5.81403486e-02f, 7.03828484e-02f, 5.88237420e-02f, -2.07498446e-02f, 1.79845665e-03f, 1.47736389e-02f, -5.81331290e-02f, 4.15227301e-02f, -4.09741066e-02f, -7.41732270e-02f,
  -1.48278316e-02f, 4.26212838e-03f, 2.75613777e-02f, 3.63541134e-02f, 5.82351424e-02f, -4.61792275e-02f, 2.93843336e-02f, 3.23853977e-02f, 1.72182992e-02f, -3.42763551e-02f,
  -4.78026308e-02f, 2.17252206e-02f, 3.02225798e-02f, 5.56902550e-02f, 7.89064728e-03f, 7.02464813e-03f, 1.22675989e-02f, 3.44076306e-02f, 2.32360605e-02f, 3.56050488e-03f,
  1.14324637e-01f, -1.37864664e-01f, -7.28638992e-02f, -6.99584512e-03f, 9.59371701e-02f, -1.39108762e-01f, -1.18221417e-01f, -6.99690506e-02f, 1.19681500e-01f, -8.68139789e-02f,
  5.40009327e-02f, -9.26443636e-02f, -4.29135710e-02f, -7.16023520e-02f, 1.67273819e-01f, -1.68121338e-01f, 8.03035498e-02f, 4.79634814e-02f, -2.28124093e-02f, 2.35410668e-02f,
  -8.10335502e-02f, 1.09876625e-01f, -1.13515273e-01f, 2.14871336e-02f, -1.70527510e-02f, -7.53137916e-02f, 1.37526214e-01f, -8.37156400e-02f, -1.25751803e-02f, 1.64797045e-02f,
  2.28702780e-02f, 2.26086024e-02f, 4.59883176e-02f, -8.26450437e-02f, 1.65278818e-02f, -5.46657145e-02f, 4.50649671e-02f, -1.00737438e-01f, 4.01991755e-02f, -6.06555343e-02f,
  1.39593026e-02f, 1.98419355e-02f, -8.59504472e-03f, 9.11594108e-02f, -1.22760684e-04f, -5.23860417e-02f, -1.33738592e-02f, -1.20057417e-02f, -5.39625287e-02f, -3.80499959e-02f,
  -7.44963512e-02f, 6.47726879e-02f, 6.59298152e-02f, -5.17946966e-02f, 9.33623537e-02f, -5.62950857e-02f, -1.29196839e-02f, 6.37993589e-03f, -3.88676934e-02f, -5.55145293e-02f,
  5.32511957e-02f, -2.91667692e-02f, 4.68810536e-02f, -3.60374562e-02f, 2.08974127e-02f, 3.38568985e-02f, 2.60952078e-02f, 6.64724484e-02f, 2.41783988e-02f, -3.20755900e-03f,
  3.98893543e-02f, -1.26976203e-02f, 5.87024093e-02f, 7.03113899e-02f, 2.21327730e-02f, 4.97909561e-02f, -2.83709336e-02f, -6.56827539e-02f, 4.50129472e-02f, -3.93113121e-02f,
  -8.07817429e-02f, -8.24163295e-03f, -1.15907937e-02f, -2.75256392e-02f, -6.41949028e-02f, 3.94916236e-02f, 3.14191282e-02f, -1.53860310e-03f, -7.17557296e-02f, 9.36790649e-03f,
  -7.41331875e-02f, 1.79658644e-03f, -1.04329437e-01f, -1.39158852e-02f, -4.95175421e-02f, -3.05386279e-02f, -2.77449423e-03f, -1.01749813e-02f, -4.24523540e-02f, 3.55658047e-02f,
  -3.31075639e-02f, 6.61460385e-02f, 9.40515101e-03f, 1.32007450e-02f, 6.47922382e-02f, 1.56272622e-03f, 2.46195607e-02f, -7.79157830e-03f, 2.25555357e-02f, 1.71152446e-02f,
  7.34779909e-02f, -3.71557623e-02f, 6.76846579e-02f, 1.03990743e-02f, 5.31335641e-03f, -5.79028204e-02f, 4.17556167e-02f, -7.71582350e-02f, -2.35654488e-02f, -4.70794179e-02f,
  5.78900799e-02f, -2.81744123e-01f, -2.37348869e-01f, 1.55878991e-01f, 2.05023102e-02f, -2.30368562e-02f, 1.63075611e-01f, -2.39178941e-01f, -2.36952882e-02f, -4.95963432e-02f,
  1.00322403e-01f, -7.95036256e-02f, -4.91560400e-02f, -1.81380678e-02f, 2.51550287e-01f, 1.03688769e-01f, 6.22243285e-02f, 7.33287334e-02f, -1.43808573e-01f, -2.66323648e-02f,
  3.15480195e-02f, 1.10860117e-01f, 3.39054503e-04f, -1.65215835e-01f, -5.30861467e-02f, -2.19896078e-01f, 1.47397429e-01f, -1.24008119e-01f, -2.37434022e-02f, 1.41427919e-01f,
  6.25890791e-02f, -9.18573886e-02f, -1.69864227e-03f, -1.25916731e-02f, 2.91188378e-02f, 5.46983257e-02f, -4.39572101e-03f, 5.05343005e-02f, 2.97465511e-02f, -5.77891544e-02f,
  2.95800343e-02f, -3.23967822e-02f, -6.52405843e-02f, 4.74297181e-02f, 5.43493815e-02f, -3.60526294e-02f, 3.52693051e-02f, 5.37783988e-02f, -2.66346354e-02f, -5.44153564e-02f,
  -3.47308293e-02f, -1.22342063e-02f, 1.68801099e-02f, -2.01464947e-02f, -1.21355047e-02f, 2.59312075e-02f, 4.81506065e-02f, 5.18939123e-02f, -4.03105021e-02f, -3.69444005e-02f,
  5.80736157e-03f, -5.72180040e-02f, -7.65188187e-02f, -6.54955283e-02f, 2.44201417e-03f, 4.01784433e-03f, -6.86704740e-03f, 1.15976864e-02f, 4.00900133e-02f, 2.21761893e-02f,
  -1.42971529e-02f, -4.62471358e-02f, -2.70151664e-02f, -3.21830213e-02f, -6.02605287e-03f, -2.07120087e-02f, -2.04680473e-04f, 1.05902432e-02f, 3.07281632e-02f, -5.29737491e-03f,
  1.93136297e-02f, 4.24838662e-02f, -3.06111649e-02f, 4.39968854e-02f, -2.99411640e-02f, -5.98222315e-02f, -5.32420017e-02f, -1.47277946e-02f, -3.98319587e-02f, 3.92278060e-02f,
  -2.30369847e-02f, -5.29084988e-02f, -2.45544650e-02f, -4.05238289e-03f, -3.75256129e-02f, 1.92453172e-02f, 2.46629789e-02f, -1.89429950e-02f, -4.27482501e-02f, -4.13867235e-02f,
  5.44568002e-02f, 2.09731292e-02f, 3.23497467e-02f, 3.27928625e-02f, -5.07945474e-03f, -6.21026754e-02f, 2.32612807e-02f, 2.76492462e-02f, -1.74843101e-03f, 7.12816883e-03f,
  -1.65201239e-02f, 4.06196527e-02f, 5.01583070e-02f, -1.10432720e-02f, -7.04860780e-03f, -2.74873506e-02f, -5.65299317e-02f, -5.77351861e-02f, 1.21110171e-01f, 1.12267071e-02f,
  -9.22787189e-02f, -4.06807326e-02f, 1.82334498e-01f, 4.76580188e-02f, 2.16952085e-01f, -8.33010525e-02f, -1.99098453e-01f, 1.23690628e-03f, -8.06131512e-02f, -2.00233117e-01f,
  -4.44286726e-02f, -6.54258281e-02f, -1.88153088e-01f, -1.15444012e-01f, -6.24017641e-02f, -1.52968347e-01f, -8.80026594e-02f, -8.45707804e-02f, 5.47184758e-02f, 1.38002131e-02f,
  7.40642250e-02f, -7.32192695e-02f, 3.36731412e-02f, 1.78650886e-01f, 1.18618585e-01f, 1.28011644e-01f, -4.56997789e-02f, 8.10773745e-02f, 1.30012751e-01f, 7.98847079e-02f,
  -8.91725626e-03f, -6.69450164e-02f, -5.04128300e-02f, 7.88709819e-02f, 3.00203394e-02f, -6.94856234e-03f, -2.63276380e-02f, -1.69040076e-02f, 5.33595495e-03f, -3.66403013e-02f,
  -6.51627779e-02f, 3.91330831e-02f, 7.63687938e-02f, -3.59905362e-02f, 9.40502584e-02f, 8.91572610e-02f, 4.39957865e-02f, -1.38033496e-03f, 2.60901786e-02f, -3.12771574e-02f,
  -8.14379603e-02f, 1.23277288e-02f, 8.38095620e-02f, -5.13930097e-02f, 9.02809277e-02f, 1.62008014e-02f, 3.59449722e-02f, 6.17842637e-02f, -2.37964410e-02f, -4.00585048e-02f,
  -7.94366226e-02f, 9.80222225e-02f, 8.73694718e-02f, 2.26459466e-02f, 3.06332926e-03f, 7.18286484e-02f, 3.94770280e-02f, 3.55770364e-02f, 5.50805740e-02f, 4.90237549e-02f,
  -5.60924895e-02f, 3.12541164e-02f, 5.39864898e-02f, -1.87807437e-03f, 3.25763524e-02f, -4.44905460e-02f, 2.41461094e-03f, -6.42421003e-03f, 1.46708852e-02f, 2.34569237e-02f,
  -2.48144027e-02f, 6.60418421e-02f, -5.88182062e-02f, -4.42674384e-02f, 5.85882051e-04f, 3.31226401e-02f, 6.86250925e-02f, -2.85716355e-02f, 4.59911488e-02f, -1.95887368e-02f,
  -9.47676674e-02f, -1.99259654e-01f, 2.35960111e-02f, -1.79491248e-02f, -4.83446345e-02f, -6.73455149e-02f, -2.73685977e-02f, 6.70634285e-02f, -8.57180059e-02f, -8.19153618e-03f,
  1.02763668e-01f, -3.66256759e-02f, -1.10190152e-03f, 3.37722301e-02f, -1.23760225e-02f, -4.90608141e-02f, -9.17004719e-02f, -2.12524906e-02f, 5.16345948e-02f, 6.79638460e-02f,
  1.17625939e-02f, -5.18347137e-02f, -4.54573445e-02f, 8.65042433e-02f, -3.78917269e-02f, 6.28061686e-03f, -5.35920374e-02f, 1.72638595e-02f, -5.60010725e-04f, 1.24299130e-03f
};

// L0_fan_Wp_bar (Shape: 52 x 120)
const int L0_fan_Wp_bar_rows = 52;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -9.17989016e-02f, -1.56863227e-01f, -1.65279165e-01f, -2.25081369e-01f, 2.08106682e-01f, 1.18734635e-01f, 5.82740940e-02f, -1.94663182e-02f, -2.19331548e-01f, 2.51339898e-02f,
  6.75095767e-02f, -8.02698880e-02f, -1.21771678e-01f, -1.01625569e-01f, -1.61215007e-01f, -1.75880492e-01f, -1.24206707e-01f, -1.13690384e-01f, -1.70868844e-01f, 3.29694413e-02f,
  4.18408541e-03f, -8.84934366e-02f, -1.48668706e-01f, 7.67163336e-02f, 6.60784990e-02f, 5.27710952e-02f, 2.00945482e-01f, 2.02466846e-01f, 8.21044967e-02f, 2.35050712e-02f,
  3.29187661e-02f, -1.50569946e-01f, -3.43021527e-02f, -3.44573185e-02f, 1.13920391e-01f, 1.54253706e-01f, -3.27744223e-02f, -7.41604939e-02f, 5.99953867e-02f, 9.51122958e-03f,
  4.41469699e-02f, 8.36947188e-02f, -5.19655161e-02f, -2.60304287e-02f, 2.38920818e-03f, -8.79538655e-02f, -7.60152638e-02f, 5.70499413e-02f, 3.20244171e-02f, -1.17122680e-01f,
  -1.13397785e-01f, -7.29684159e-02f, -9.20049474e-03f, -5.74688166e-02f, -3.03821489e-02f, -8.29346776e-02f, -3.44285034e-02f, 6.25940785e-02f, 1.20737270e-01f, -1.27728492e-01f,
  9.48452801e-02f, 4.88479920e-02f, -4.98396121e-02f, -5.84647022e-02f, -3.50328349e-02f, -6.06628787e-03f, 2.22205836e-02f, -3.25520858e-02f, 4.55986932e-02f, -3.81377041e-02f,
  -6.30382309e-03f, -8.32307786e-02f, -9.32375062e-03f, -7.31038377e-02f, -3.29355337e-02f, -1.60053540e-02f, -2.07547564e-02f, 3.48163769e-02f, 7.10271820e-02f, -7.11446851e-02f,
  -8.73585930e-04f, 3.34734446e-03f, 4.40674275e-02f, 9.70763043e-02f, -4.35703285e-02f, -2.08885781e-03f, -4.09535989e-02f, 1.95146557e-02f, -7.44358450e-02f, 5.87654226e-02f,
  -1.05423458e-01f, -8.10489357e-02f, 3.10939942e-02f, -2.34889556e-02f, 7.66920522e-02f, 4.85916398e-02f, -1.05394930e-01f, 5.37067018e-02f, -2.83446591e-02f, -5.74933775e-02f,
  3.76194715e-02f, -6.65940112e-04f, 1.40259087e-01f, -8.19138363e-02f, 9.50860456e-02f, 6.11146726e-02f, 6.37714341e-02f, 7.58523121e-02f, 1.59606561e-01f, 3.16201262e-02f,
  -6.52335063e-02f, 6.01565652e-02f, -9.31023359e-02f, -9.20927823e-02f, 9.10576805e-02f, 1.20731510e-01f, -7.27213621e-02f, 3.00809015e-02f, -3.73733938e-02f, 5.98705523e-02f,
  3.26511800e-01f, 6.60992553e-03f, 2.39936501e-01f, 3.24857324e-01f, 5.99075062e-03f, 7.08758831e-02f, 1.38212830e-01f, 1.06799118e-01f, 2.81418741e-01f, -1.52163818e-01f,
  -2.50056963e-02f, 6.95678070e-02f, 5.32766199e-03f, 1.02174118e-01f, -8.10657814e-02f, -1.11088686e-01f, 5.02505116e-02f, 1.76183999e-01f, 5.86871989e-02f, 1.82793349e-01f,
  1.35502415e-02f, -1.96509346e-01f, -5.32090813e-02f, -2.01503485e-01f, 1.20409772e-01f, 1.02767879e-02f, -1.97211280e-01f, -3.72816920e-02f, -1.75506875e-01f, -1.82316735e-01f,
  -2.40975190e-02f, 2.16144398e-02f, 2.95871422e-02f, -1.10254832e-01f, 3.42089608e-02f, -1.02553695e-01f, -1.79191038e-03f, -3.95305417e-02f, -1.19106220e-02f, -1.68289710e-02f,
  -1.57954358e-02f, -1.00384213e-01f, -2.96614356e-02f, 4.12641466e-02f, 9.76579934e-02f, 2.52604838e-02f, 1.87229328e-02f, 1.45772263e-01f, -4.57612239e-02f, 5.20924218e-02f,
  1.87129751e-01f, 1.44306496e-01f, 9.87928435e-02f, -4.89823706e-02f, 5.45897633e-02f, -6.57390477e-03f, -6.01842776e-02f, 9.38234758e-03f, -6.10125698e-02f, -4.72105667e-03f,
  -7.69609734e-02f, -6.39082789e-02f, 5.90094016e-04f, 1.55961756e-02f, 7.45883062e-02f, 3.82202081e-02f, 1.58066805e-02f, -3.07266880e-02f, 1.77519664e-01f, 4.05441932e-02f,
  4.23231870e-02f, -1.85048096e-02f, 7.52910227e-03f, 1.02490216e-01f, 7.44736493e-02f, 5.39913327e-02f, 4.82817367e-02f, 3.19151990e-02f, 7.59420022e-02f, 5.11404760e-02f,
  -5.07439673e-02f, -3.43640894e-02f, 1.78703610e-02f, -3.38574871e-02f, -5.01800701e-02f, -2.84997579e-02f, -1.72887649e-02f, 1.08474068e-01f, 2.57184710e-02f, -9.68080238e-02f,
  2.20545474e-02f, -4.62635718e-02f, -1.06838062e-01f, 4.30334732e-02f, -4.32695746e-02f, -7.10957050e-02f, 4.94208001e-02f, 9.04368311e-02f, 8.13812837e-02f, -1.14304289e-01f,
  -6.06989786e-02f, -6.05639582e-03f, 9.52144619e-03f, -5.86060770e-02f, -1.07185081e-01f, 2.65950360e-03f, 5.00637926e-02f, 5.63596897e-02f, -1.37302369e-01f, 9.38148890e-03f,
  2.14051474e-02f, 7.88610056e-02f, -3.86715345e-02f, 8.57134443e-03f, 7.86067322e-02f, -3.58612975e-03f, 1.37913795e-02f, 5.80667593e-02f, -2.82881260e-02f, -2.56728530e-02f,
  1.05705842e-01f, -2.91898906e-01f, -1.39793009e-01f, -1.74775366e-02f, -6.80914102e-03f, 8.98922682e-02f, 2.94531912e-01f, -2.23132923e-01f, -2.30226174e-01f, 6.35253359e-03f,
  1.42731696e-01f, 1.54407322e-02f, 1.04614481e-01f, 2.36615628e-01f, 3.09695423e-01f, 4.14737016e-02f, 1.15479998e-01f, 1.81260571e-01f, -1.49455056e-01f, -9.63771045e-02f,
  4.34202142e-02f, 8.50263536e-02f, 1.91695288e-01f, -1.87756196e-01f, 7.14129284e-02f, -1.64677173e-01f, -3.74849737e-02f, 4.15923744e-02f, 1.38327172e-02f, 9.59836915e-02f,
  1.29537076e-01f, -9.28580016e-02f, -1.72744486e-02f, -2.34003235e-02f, -1.31602539e-02f, 2.03505624e-02f, 1.22916929e-01f, 1.40884712e-01f, -3.33171822e-02f, -5.76386787e-02f,
  8.13305750e-03f, 4.14360799e-02f, -8.05678070e-02f, 5.38455136e-02f, -1.14585727e-01f, -1.23459250e-02f, -5.09471223e-02f, 3.26449201e-02f, -1.20705165e-01f, 2.50268774e-03f,
  1.90622006e-02f, -2.72678081e-02f, 3.05325966e-02f, 6.61130399e-02f, -5.12030609e-02f, -4.97179441e-02f, 5.71177565e-02f, 2.28460282e-02f, -5.75366132e-02f, -7.64292553e-02f,
  -1.63023975e-02f, -9.38286819e-03f, -3.65075958e-03f, 1.23646967e-02f, -4.85803746e-02f, -2.87302863e-02f, 5.19462004e-02f, -9.21921898e-03f, -6.38121739e-02f, -9.79112461e-03f,
  2.09938679e-02f, -4.91723828e-02f, 4.19679359e-02f, -4.09558415e-03f, 1.60911381e-02f, -4.68845479e-02f, 6.47285301e-03f, -1.12498272e-02f, 1.82553530e-02f, -1.74726211e-02f,
  4.08290364e-02f, 4.97085750e-02f, 4.38507646e-02f, 1.65625438e-02f, -4.44624433e-03f, 6.17266297e-02f, 6.52655661e-02f, 2.46881153e-02f, -5.09972461e-02f, 3.96283157e-02f,
  -5.57464249e-02f, -1.93777889e-01f, 4.72746752e-02f, 5.52859455e-02f, -9.61202160e-02f, -3.68400998e-02f, -7.02394098e-02f, -9.52507630e-02f, 2.17736959e-02f, 2.67766919e-02f,
  3.31605449e-02f, -3.11837774e-02f, -2.26001963e-02f, -1.40118646e-02f, -2.83727646e-02f, -3.04934271e-02f, 3.91784236e-02f, -1.46063529e-02f, -5.71365021e-02f, -5.07813506e-02f,
  6.08446170e-03f, -2.88254246e-02f, -8.92707240e-03f, -6.61483184e-02f, 3.46559137e-02f, 8.94533750e-03f, -6.91104159e-02f, -1.41496398e-02f, -2.71527525e-02f, -9.15845186e-02f,
  4.86153513e-02f, 7.56334960e-02f, 1.15871787e-01f, 1.98894948e-01f, 1.62344396e-01f, 2.45187178e-01f, 3.07935119e-01f, 1.41042382e-01f, 3.04381758e-01f, 8.39962214e-02f,
  -5.84470294e-02f, 5.48994094e-02f, -2.17658356e-02f, -2.03149077e-02f, 7.32885599e-02f, 9.82029811e-02f, 1.39421508e-01f, 1.55201659e-01f, 7.26048350e-02f, 1.39967844e-01f,
  1.62934437e-01f, 8.33568498e-02f, -1.92234725e-01f, -1.47774607e-01f, -6.32706508e-02f, -5.24988323e-02f, -2.46272266e-01f, -4.37722430e-02f, -1.23900481e-01f, 7.26560652e-02f,
  6.70510158e-02f, 3.36802825e-02f, -1.20880350e-01f, -8.05300847e-02f, -2.41863299e-02f, -6.66502267e-02f, -5.21620624e-02f, -5.57358842e-03f, -3.06318086e-02f, -2.59619523e-02f,
  5.63809462e-02f, 1.88508872e-02f, 5.55821210e-02f, -6.18018843e-02f, 7.39436373e-02f, 1.28732696e-02f, -8.02505165e-02f, -5.86746484e-02f, -7.07257316e-02f, -2.19517853e-02f,
  -7.03890920e-02f, -7.17583224e-02f, 9.19876024e-02f, -8.77824705e-03f, 2.71033552e-02f, 3.01178568e-03f, 3.29672396e-02f, -2.65007000e-02f, -3.69977430e-02f, 4.50738817e-02f,
  5.63687971e-03f, 8.32855031e-02f, 2.96252314e-02f, -5.75701445e-02f, -2.75766272e-02f, -6.47174381e-03f, -2.21619364e-02f, 4.82545031e-04f, 2.36431900e-02f, -1.79759078e-02f,
  -2.49519553e-02f, -2.54847128e-02f, -2.05166973e-02f, 4.50111851e-02f, 7.21186996e-02f, 8.75271261e-02f, 4.25596768e-03f, -1.44690340e-02f, 9.75405201e-02f, -7.84589052e-02f,
  4.83067483e-02f, 8.88861418e-02f, -3.10239606e-02f, 1.00933085e-03f, 4.29874882e-02f, -1.26065956e-02f, -4.61506359e-02f, 7.29425577e-03f, -7.46645555e-02f, 8.66081566e-02f,
  4.66824360e-02f, 2.20988721e-01f, -5.49273901e-02f, 3.70062469e-03f, 2.50544660e-02f, -6.64985329e-02f, 7.45467469e-02f, 1.15912825e-01f, 3.17965783e-02f, 7.51878619e-02f,
  5.07882535e-02f, 3.76055837e-02f, 7.76152825e-03f, -5.00810407e-02f, -5.79667389e-02f, 4.03261520e-02f, 6.23855367e-02f, 7.69681334e-02f, 1.01181328e-01f, -1.12754472e-01f,
  7.71021284e-03f, -1.24757420e-02f, -1.25508904e-02f, 1.14800576e-02f, -5.23920637e-03f, -5.15918620e-02f, -1.14150178e-02f, -4.44107652e-02f, -8.78852159e-02f, 6.24388233e-02f,
  -3.03174398e-04f, -9.59622338e-02f, -1.26240805e-01f, -1.68038070e-01f, -1.47755668e-01f, -1.80356219e-01f, -1.05849519e-01f, -3.64720039e-02f, -5.26023544e-02f, -1.42995581e-01f,
  -1.20036304e-01f, 9.72365029e-03f, 9.36883464e-02f, -2.82807887e-01f, 3.59533817e-01f, 3.37003082e-01f, -1.50378108e-01f, -1.68381751e-01f, 8.54450688e-02f, -1.03481926e-01f,
  1.32536948e-01f, -1.91631854e-01f, 1.04600564e-01f, -1.97373837e-01f, -2.13800609e-01f, -1.27968833e-01f, 3.26381437e-02f, -2.16406927e-01f, -2.08146721e-01f, -1.66649356e-01f,
  6.95048720e-02f, 5.13667166e-02f, -7.50226760e-03f, 4.86046821e-02f, -4.30716462e-02f, -8.28132778e-02f, -4.62494045e-02f, 3.68446670e-02f, 3.70930545e-02f, -6.19090348e-02f,
  5.36430860e-03f, 5.62138110e-02f, 7.18532549e-03f, -4.59349006e-02f, -1.40386513e-02f, -1.33520722e-01f, -2.65211109e-02f, -2.39885002e-02f, -6.94888309e-02f, -1.41385317e-01f,
  1.87424434e-04f, -5.40305600e-02f, -9.45057347e-02f, 1.33054450e-01f, -3.12427487e-02f, -9.54535976e-02f, 4.72134575e-02f, 2.62898244e-02f, -5.12010641e-02f, -7.31140599e-02f,
  -9.75022838e-02f, 4.01137164e-03f, -7.71202445e-02f, -3.98961864e-02f, 1.38931843e-02f, -2.27628276e-02f, -8.40939060e-02f, 5.28138727e-02f, -9.65350270e-02f, 3.37970257e-02f,
  1.13282770e-01f, 1.01613119e-01f, -2.69994307e-02f, -1.27494121e-02f, -1.65229544e-01f, 1.62337981e-02f, 5.40585853e-02f, -5.12036681e-02f, 3.14387935e-03f, 3.20006795e-02f,
  4.56161536e-02f, 2.42829192e-02f, -2.28984701e-03f, -1.17171917e-03f, -5.67635000e-02f, 8.75851139e-02f, -9.02078375e-02f, -1.01740835e-02f, 3.15058380e-02f, -4.42123413e-02f,
  9.07620322e-03f, 2.53533982e-02f, 6.17006347e-02f, 8.77423584e-02f, 3.81082557e-02f, -2.39637233e-02f, 7.44709224e-02f, 4.20177616e-02f, 8.76572952e-02f, 9.41326097e-03f,
  -1.20679460e-01f, 3.28018852e-02f, 8.69509652e-02f, -4.89142276e-02f, 1.14281662e-01f, -1.29502462e-02f, 4.53844927e-02f, 1.13038614e-01f, 1.01927020e-01f, -1.17267240e-02f,
  -1.05711043e-01f, -2.01578755e-02f, 3.56016867e-02f, -5.92689700e-02f, 1.68700106e-02f, -3.96151394e-02f, 9.70550776e-02f, 3.17883790e-02f, 1.50943706e-02f, 4.97054718e-02f,
  -3.04139376e-01f, 2.39626110e-01f, 1.67462453e-02f, -2.50390410e-01f, 8.27045813e-02f, -3.76351364e-02f, -1.27318025e-01f, 1.48132667e-01f, -1.21529199e-01f, 9.10292715e-02f,
  -7.77522707e-03f, -1.65828019e-01f, 2.88685262e-02f, -1.71978742e-01f, -3.42514992e-01f, -1.64745510e-01f, -2.79424310e-01f, -1.43210530e-01f, 3.30335624e-03f, -2.68216673e-02f,
  -2.96749640e-02f, -9.45897475e-02f, -1.03532895e-01f, 1.61403716e-01f, -6.70824200e-02f, -3.02555412e-02f, 4.07808758e-02f, 6.46799207e-02f, -6.28691912e-02f, -1.20686822e-01f,
  1.59303825e-02f, 1.05045632e-01f, 6.88488185e-02f, -4.47907001e-02f, -4.74130511e-02f, -1.82621472e-03f, 4.12879512e-02f, -6.31798357e-02f, 1.04604542e-01f, -9.62826908e-02f,
  -3.60010080e-02f, 4.87769246e-02f, -8.79664198e-02f, -3.47829014e-02f, 5.42817824e-02f, 7.65596628e-02f, 7.26502910e-02f, -1.68907829e-02f, -4.77555431e-02f, -3.61864641e-02f,
  -5.01170568e-03f, 3.61539386e-02f, 1.66687723e-02f, -9.63162482e-02f, -1.22109912e-01f, 5.99120744e-02f, -5.03855236e-02f, -2.36118399e-03f, -1.44663434e-02f, -9.19976160e-02f,
  -8.67359787e-02f, -9.15291682e-02f, 4.92184050e-02f, 1.60739385e-02f, -7.32824728e-02f, -7.44957849e-02f, -1.06642105e-01f, -6.16830923e-02f, 1.61741078e-02f, 8.05083811e-02f,
  6.10825419e-02f, 5.07094562e-02f, -4.60998192e-02f, -4.75083329e-02f, -6.45455942e-02f, -3.68735986e-03f, -3.02283335e-02f, -3.84324556e-03f, 3.39569263e-02f, 1.49182668e-02f,
  1.60670236e-01f, -2.27882341e-02f, -1.72026101e-02f, 8.32011849e-02f, -2.34322269e-02f, -4.69238460e-02f, -2.81239357e-02f, -3.73766869e-02f, -4.04122807e-02f, -6.66672587e-02f,
  1.24458045e-01f, 4.92735952e-03f, 4.79276404e-02f, 8.43653008e-02f, -4.58265916e-02f, 2.49854978e-02f, 7.55624548e-02f, -6.55627549e-02f, -5.64887114e-02f, -6.12042136e-02f,
  1.17611850e-03f, -2.29812022e-02f, 7.14008957e-02f, -4.61440943e-02f, -1.25947908e-01f, -4.43592891e-02f, 3.98942605e-02f, 4.89593446e-02f, 1.03663758e-03f, 3.55285630e-02f,
  3.34112607e-02f, 5.93228191e-02f, -7.22236931e-02f, 3.02330870e-02f, 5.43802567e-02f, 7.07562268e-02f, 4.92969900e-02f, 2.13176105e-02f, -1.73499901e-02f, -3.57594974e-02f,
  1.86615765e-01f, 1.82911396e-01f, 2.60059267e-01f, 3.52193862e-02f, 1.01117119e-01f, 2.72678077e-01f, 1.78077474e-01f, 1.37131751e-01f, 1.26275420e-01f, -7.85714835e-02f,
  -2.37504721e-01f, 1.22963473e-01f, -8.81858245e-02f, -3.17809619e-02f, -1.07466578e-02f, 5.33409882e-03f, 8.58290214e-03f, 2.09291670e-02f, 1.14007955e-02f, -9.58627909e-02f,
  4.41463722e-04f, -1.85109138e-01f, -3.71230878e-02f, -2.25763395e-01f, -7.82179758e-02f, 7.24381804e-02f, -2.53030479e-01f, 3.97972465e-02f, -7.25657791e-02f, 5.94361834e-02f,
  -1.55681565e-01f, 9.06284549e-04f, -7.48609845e-03f, 4.91735758e-03f, -6.86597452e-02f, 4.40649614e-02f, 1.25279337e-01f, 5.35991229e-02f, 7.12387636e-02f, 7.47397467e-02f,
  3.17594483e-02f, 9.78992507e-02f, -4.56401370e-02f, 1.81902591e-02f, 2.79221144e-02f, 5.08871786e-02f, -2.09786445e-02f, -6.74780309e-02f, 9.77843907e-03f, 7.92650655e-02f,
  4.10848595e-02f, 1.40934004e-04f, -5.08138305e-03f, 6.10943064e-02f, -1.16016408e-02f, -9.99480560e-02f, 1.42337471e-01f, 1.06086098e-01f, 8.68303478e-02f, 5.67378383e-03f,
  3.37662213e-02f, 1.19343407e-01f, -2.99504418e-02f, -7.21974522e-02f, -7.44732609e-03f, -8.38849787e-03f, -2.22802740e-02f, -5.74686565e-02f, 4.95444052e-02f, -5.01913503e-02f,
  3.68066654e-02f, 1.38116768e-02f, -1.01830577e-02f, -3.72130536e-02f, -1.37991205e-01f, -6.44277558e-02f, -1.02338769e-01f, 2.72896122e-02f, 1.93612522e-03f, -6.38529435e-02f,
  1.17426664e-02f, -1.57078076e-02f, -9.79250371e-02f, -1.48024913e-02f, -1.02959454e-01f, 1.67976487e-02f, -4.80711870e-02f, -2.95512658e-02f, -7.27367848e-02f, -1.26601502e-01f,
  -1.31875262e-01f, -5.34951128e-02f, -8.50862339e-02f, -1.09582655e-01f, -6.91423863e-02f, -2.33261175e-02f, 7.38951787e-02f, -7.39497691e-02f, 1.02622975e-02f, 1.96882803e-02f,
  7.07637938e-03f, -1.60412006e-02f, 4.03895378e-02f, 2.55020019e-02f, -6.47827983e-02f, -4.34867255e-02f, 4.27986458e-02f, -7.45318085e-02f, -1.10713147e-01f, -5.10315150e-02f,
  -1.43653005e-01f, 2.05205567e-03f, 5.75828552e-02f, -8.85847062e-02f, -1.26656732e-02f, -1.00499086e-01f, 7.15963393e-02f, -3.76958512e-02f, -2.23948597e-03f, 3.34388129e-02f,
  1.21324092e-01f, -8.01884085e-02f, 2.45063305e-02f, 1.18321903e-01f, 4.65442538e-02f, -6.80882558e-02f, -1.65444821e-01f, 1.36350811e-01f, -1.08303875e-01f, -1.11207135e-01f,
  3.58415209e-02f, -8.26393738e-02f, -1.14153042e-01f, 1.48583844e-01f, 2.01844767e-01f, -1.86362624e-01f, 1.26915500e-01f, 1.68789048e-02f, 8.13914761e-02f, 1.00853547e-01f,
  1.51586920e-01f, 2.03717470e-01f, 1.27344728e-01f, 1.56450465e-01f, 1.35572746e-01f, 1.72124594e-01f, 2.04953209e-01f, -8.34606439e-02f, 1.10511675e-01f, -1.78399812e-02f,
  -5.39447367e-02f, 4.97746877e-02f, 4.35255952e-02f, -3.85899446e-03f, 2.28404161e-02f, -9.81865600e-02f, -1.51427491e-02f, -5.30079082e-02f, 7.99788833e-02f, -7.72992522e-02f,
  3.43403127e-03f, 1.07532129e-01f, 4.34645750e-02f, -3.15683670e-02f, 3.99624817e-02f, 3.55451144e-02f, -3.11977859e-03f, -8.71895775e-02f, 4.65042703e-03f, 8.77380148e-02f,
  2.17228197e-02f, -4.70947772e-02f, -7.63227195e-02f, -3.97230545e-03f, 2.88608111e-02f, 1.07104555e-01f, -5.74181750e-02f, -5.03206328e-02f, -5.83185926e-02f, 9.72605369e-04f,
  5.94958067e-02f, -9.66675207e-02f, -4.95024510e-02f, -2.08612671e-03f, -4.58756536e-02f, 5.22640944e-02f, -1.02442279e-02f, 7.09939227e-02f, -1.79303344e-02f, -6.22806512e-02f,
  1.51238283e-02f, 1.39587730e-01f, 3.58311348e-02f, 2.87848860e-02f, -4.93433746e-03f, -4.04591300e-03f, -1.15543483e-02f, -7.73485750e-02f, -2.04409454e-02f, 6.58996329e-02f,
  5.91089055e-02f, 4.49863449e-02f, -9.05217305e-02f, 3.09127122e-02f, -2.09184326e-02f, -2.24208534e-02f, 8.11417103e-02f, 3.43498564e-03f, -3.58191468e-02f, -2.44130883e-02f,
  3.13866995e-02f, -7.94099346e-02f, 3.53308395e-03f, -4.51003611e-02f, -1.27967030e-01f, -1.68507453e-02f, -5.81805222e-02f, -2.28012465e-02f, 7.96416104e-02f, 7.23751709e-02f,
  -8.66191164e-02f, 5.00495844e-02f, 2.62703858e-02f, -3.84406676e-03f, -4.46199030e-02f, -7.68408403e-02f, 1.00042298e-02f, 3.60423140e-02f, -3.50235663e-02f, 9.98852700e-02f,
  -4.92026694e-02f, -1.30854115e-01f, -9.28353891e-02f, 1.97629780e-02f, 7.17411339e-02f, -2.12441199e-02f, -7.39470422e-02f, -8.74169404e-04f, 1.60440691e-02f, 3.06039769e-03f,
  -8.78039375e-02f, 5.05921394e-02f, -1.88424304e-01f, 5.55866249e-02f, 2.06300482e-01f, 3.46424729e-01f, 2.00719863e-01f, 1.52157262e-01f, 1.21810526e-01f, 1.11921504e-01f,
  1.45430341e-01f, -5.54878823e-02f, -9.24271718e-02f, 2.62839019e-01f, 1.81364566e-01f, 5.67599647e-02f, 2.75268435e-01f, 1.56162724e-01f, -4.47744764e-02f, 2.84258593e-02f,
  -1.61276847e-01f, 9.66096520e-02f, -2.34737396e-01f, -1.79167300e-01f, 7.88024347e-03f, -1.96269214e-01f, -1.15703881e-01f, -1.86996564e-01f, 4.28046025e-02f, 6.56579584e-02f,
  -4.01234552e-02f, -1.10236712e-01f, -5.96505478e-02f, -3.83578688e-02f, 4.65802150e-03f, -1.92498555e-03f, -1.13891043e-01f, -8.80747885e-02f, -8.33220705e-02f, 2.82281786e-02f,
  9.02453158e-03f, -1.47005357e-02f, 8.46673399e-02f, 5.02112135e-02f, -5.59002794e-02f, -1.41782872e-02f, 7.23702982e-02f, 6.87449705e-03f, 6.27707317e-02f, 3.90989743e-02f,
  -3.85404155e-02f, 1.27463760e-02f, -5.06451204e-02f, 1.17484048e-01f, -3.29408720e-02f, 2.22363118e-02f, -1.55258074e-01f, -9.57243592e-02f, 1.01982221e-01f, 5.63400760e-02f,
  -1.76203679e-02f, 1.07786413e-02f, -9.68561247e-02f, 1.92262344e-02f, -1.00948788e-01f, 3.21151270e-03f, 6.98750541e-02f, -4.41806316e-02f, 3.99090350e-02f, 5.43550216e-02f,
  8.79895315e-02f, -2.96582021e-02f, 7.94939101e-02f, -1.13929451e-01f, 2.85884123e-02f, 2.32341699e-02f, -2.60748789e-02f, -3.19834286e-03f, 2.61669029e-02f, 1.05394349e-02f,
  7.46861994e-02f, 1.15415324e-02f, -8.89676586e-02f, 1.82068236e-02f, -2.81857178e-02f, 6.58454432e-04f, 1.15256786e-01f, -6.12778626e-02f, -4.93439175e-02f, -4.70607765e-02f,
  1.19752407e-01f, 4.32247743e-02f, -1.58038121e-02f, -2.87838001e-02f, -7.11538494e-02f, 9.39831790e-03f, 4.70253639e-02f, -5.24011999e-03f, -8.35281760e-02f, -7.58976564e-02f,
  -8.98459107e-02f, -2.42826156e-02f, 8.83354843e-02f, -1.67914685e-02f, 1.08759962e-01f, -6.00057170e-02f, 1.52436551e-02f, 3.85757983e-02f, 9.14813727e-02f, -9.47798491e-02f,
  -2.63524055e-02f, -6.56257272e-02f, -4.48903106e-02f, 4.22454323e-04f, 1.18456788e-01f, -7.17365462e-03f, 4.49204668e-02f, -6.41531423e-02f, 1.29510537e-01f, 1.21841477e-02f,
  -6.87037855e-02f, -2.60641545e-01f, -1.38482600e-01f, 1.61100641e-01f, -9.04778764e-02f, -2.50322163e-01f, -3.32460642e-01f, -7.25375265e-02f, -4.26782146e-02f, -1.60545066e-01f,
  -4.34189625e-02f, -6.47233129e-02f, -2.29246333e-01f, 2.20677972e-01f, 9.82972160e-02f, 8.61265734e-02f, 1.74444839e-01f, 8.97430107e-02f, 1.05113573e-02f, -3.95581461e-02f,
  2.30511501e-01f, 2.35164702e-01f, 2.30419338e-01f, 1.96445227e-01f, 2.34984867e-02f, 1.92478299e-02f, 8.50405470e-02f, -4.44680685e-03f, 1.43572971e-01f, 4.23504710e-02f,
  -1.22782425e-03f, 1.30126715e-01f, -6.98466003e-02f, 1.08011395e-01f, 3.20044570e-02f, -6.05213977e-02f, -2.13713888e-02f, 6.46553338e-02f, -1.60154682e-02f, -1.02389306e-02f,
  3.74203026e-02f, 9.72102135e-02f, 8.63713399e-02f, 2.59011537e-02f, -7.14438707e-02f, 7.06804991e-02f, 7.24778548e-02f, -4.04662229e-02f, 1.01215206e-02f, -2.64192112e-02f,
  -4.05370332e-02f, -1.98416393e-02f, -1.40258577e-02f, -2.34660935e-02f, -1.12214722e-02f, -7.43017793e-02f, 2.48841941e-02f, 8.13627467e-02f, 5.83169051e-02f, 3.50807011e-02f,
  5.81665561e-02f, 3.45801207e-04f, 1.16494279e-02f, -3.93784232e-02f, 6.70737959e-03f, 3.69597040e-02f, -8.61751586e-02f, -7.84168467e-02f, -1.12500582e-02f, -1.20910499e-02f,
  -1.95540022e-02f, -5.99626973e-02f, 2.75551733e-02f, -2.32231095e-02f, 3.21218856e-02f, 3.61862481e-02f, 3.71300317e-02f, 1.36370376e-01f, 3.85366902e-02f, -1.51655320e-02f,
  2.20960807e-02f, -1.95461642e-02f, -6.68714270e-02f, 8.75174329e-02f, 3.05449381e-03f, 3.04829888e-02f, 7.78245851e-02f, -7.49167651e-02f, 7.17774257e-02f, 1.26968129e-02f,
  6.83423132e-02f, 4.07483578e-02f, -5.58464043e-02f, 7.09194839e-02f, -4.56352085e-02f, -1.32718729e-02f, 4.60560545e-02f, 1.03806801e-01f, -9.80110019e-02f, -5.00916578e-02f,
  -6.18698820e-02f, 1.46480566e-02f, -4.02355678e-02f, 6.80851042e-02f, -2.33903844e-02f, 3.74169797e-02f, -1.79218780e-02f, 1.14657611e-01f, 7.04360381e-02f, -4.57340330e-02f,
  -8.37822407e-02f, -9.04767364e-02f, 1.47819333e-02f, 1.37824612e-02f, -1.74570661e-02f, -1.93788242e-02f, -2.44477633e-02f, -2.09388174e-02f, 1.05029464e-01f, -5.28946295e-02f,
  2.70349473e-01f, 7.71320760e-02f, -5.65863922e-02f, 6.06092028e-02f, -2.27059245e-01f, -2.52696007e-01f, -2.83458620e-01f, -1.63505543e-02f, -1.21179707e-01f, -5.68950363e-02f,
  -5.01177087e-02f, 1.05834171e-01f, 1.42728295e-02f, 4.86308523e-02f, 1.26602739e-01f, 9.92305875e-02f, 8.54317322e-02f, 7.67981634e-03f, -5.42661883e-02f, 1.48350090e-01f,
  1.31060049e-01f, 1.62933916e-01f, 5.79947978e-02f, 1.55200377e-01f, 4.40485626e-02f, 1.53142065e-01f, 1.09201238e-01f, 9.08565987e-03f, -1.97072327e-02f, -1.22640412e-02f,
  -7.31771290e-02f, 7.92926848e-02f, -2.64334120e-02f, 1.33208018e-02f, 8.90180767e-02f, -6.70051947e-02f, 4.44040932e-02f, -7.67173246e-02f, -9.42292958e-02f, -2.02595033e-02f,
  7.93903843e-02f, 2.74470709e-02f, -3.65895405e-02f, -1.98942572e-02f, 2.09288839e-02f, -8.46665949e-02f, -1.92677211e-02f, 1.60464831e-02f, -8.73782486e-03f, 5.91556951e-02f,
  4.45347689e-02f, -1.34628722e-02f, 5.84895088e-06f, -1.00058846e-01f, -7.93448240e-02f, -7.38710538e-02f, -6.54518753e-02f, 1.83480307e-02f, -6.74366672e-03f, 3.03432308e-02f,
  7.65785798e-02f, 6.22512288e-02f, 6.74048737e-02f, 4.56719697e-02f, -5.58546325e-03f, -3.08970734e-02f, 3.57524604e-02f, -2.75327060e-02f, 3.17694410e-03f, -5.59656695e-02f,
  -1.09186128e-01f, -6.31825328e-02f, 1.26632885e-03f, 1.92317050e-02f, -4.40100655e-02f, 3.10150776e-02f, 2.67085228e-02f, 8.91043842e-02f, -6.74926266e-02f, -5.87198399e-02f,
  3.78030948e-02f, 3.70837413e-02f, 5.69289997e-02f, -2.58872081e-02f, -9.01887566e-02f, 4.87711281e-02f, 1.39082074e-01f, 7.45919570e-02f, -4.32684571e-02f, 7.49100149e-02f,
  -1.08673051e-02f, 1.79717958e-01f, -2.38303449e-02f, -9.20867827e-03f, 5.16484119e-02f, 1.29437312e-01f, 4.12918702e-02f, -1.63440290e-03f, 3.40216458e-02f, 9.55736190e-02f,
  1.70221135e-01f, -9.11437348e-02f, -3.91938239e-02f, -8.81123692e-02f, -4.36717533e-02f, 1.11398637e-01f, -6.30992791e-03f, -8.40993077e-02f, 2.70458125e-02f, 8.91064629e-02f,
  8.73888060e-02f, 2.99494863e-02f, -1.25392573e-02f, -1.35383725e-01f, 3.25930454e-02f, -6.21117167e-02f, -9.73078609e-03f, -6.86931834e-02f, -2.61431988e-02f, -3.58016454e-02f,
  -2.10841715e-01f, 1.42455518e-01f, -7.73745030e-02f, -4.36669867e-03f, 1.30047545e-01f, 3.31751734e-01f, 2.54185200e-01f, 1.64264441e-01f, 2.67837584e-01f, 1.83432564e-01f,
  1.16140462e-01f, 7.34567875e-04f, 2.13784769e-01f, 1.90673210e-02f, 1.53773442e-01f, 1.56007022e-01f, 2.58480787e-01f, 8.40438455e-02f, 1.28427729e-01f, -8.30444321e-02f,
  -1.07583672e-01f, -5.28846718e-02f, -2.60007471e-01f, -1.53940767e-01f, -6.30501583e-02f, -1.96797073e-01f, -8.37864354e-02f, -1.24819152e-01f, -8.84954706e-02f, 1.43289417e-01f,
  6.01920635e-02f, -2.02103890e-02f, -1.47272229e-01f, 4.66260966e-03f, -7.08168298e-02f, -3.73910926e-02f, -9.19657722e-02f, -9.40140113e-02f, -3.94622944e-02f, 8.80714972e-03f,
  -1.95917357e-02f, -9.47920009e-02f, -1.26171364e-02f, 1.48463070e-01f, 1.35725230e-01f, -6.08574040e-02f, -5.07577211e-02f, 1.24093127e-02f, 6.19290918e-02f, -3.41111161e-02f,
  -1.04148455e-01f, 5.29864132e-02f, -3.96041162e-02f, 9.10280086e-03f, -2.66565271e-02f, 1.10643677e-01f, 7.68800154e-02f, 1.02926380e-04f, 6.25286996e-02f, 5.46562970e-02f,
  1.17886342e-01f, 1.56847596e-01f, -6.95490316e-02f, -7.88547322e-02f, 7.16184005e-02f, -4.80008312e-02f, -5.61373681e-02f, -1.14017852e-01f, 4.15971801e-02f, -5.15728630e-02f,
  2.59979721e-02f, -5.88134266e-02f, -3.00335791e-02f, 7.36539885e-02f, -3.97413671e-02f, -4.26598713e-02f, -6.88938946e-02f, 8.43864530e-02f, -1.76131483e-02f, -1.33469135e-01f,
  1.28479004e-02f, 9.18181166e-02f, 1.26134539e-02f, 5.56850731e-02f, -1.64217539e-02f, 2.07152534e-02f, -4.64589410e-02f, -6.13859706e-02f, 2.10491549e-02f, 3.70121151e-02f,
  7.18829557e-02f, 1.74520984e-01f, 5.19166254e-02f, 3.02625336e-02f, -7.08303377e-02f, 5.74245304e-02f, 2.28027869e-02f, -3.34124230e-02f, 1.34239092e-01f, 1.18182436e-01f,
  -3.77181880e-02f, 1.57819118e-03f, 8.40897784e-02f, 1.73830905e-03f, 5.63021377e-02f, 7.23347962e-02f, 5.89948259e-02f, -2.44541909e-03f, -6.17982298e-02f, -3.47837210e-02f,
  -1.15984999e-01f, 5.78451119e-02f, -1.14451312e-01f, 6.19221106e-02f, -4.51245755e-02f, -2.50660311e-02f, 3.10928822e-02f, -6.31806776e-02f, 3.57229412e-02f, 4.68961559e-02f,
  1.42128766e-01f, -8.51141568e-03f, -9.37408283e-02f, -2.56100781e-02f, -4.11509201e-02f, 1.38554126e-01f, 1.26636311e-01f, -5.92558235e-02f, -2.35350668e-01f, -1.72064509e-02f,
  2.66442169e-02f, -1.18566096e-01f, -7.28215426e-02f, 1.57494023e-01f, 2.32589990e-01f, -6.12787679e-02f, 1.08627677e-01f, 2.44169738e-02f, -3.34029496e-02f, 2.14097336e-01f,
  -5.77812688e-03f, 2.29002565e-01f, 8.52002427e-02f, 2.02248111e-01f, 2.55523883e-02f, 1.40861049e-03f, 1.11742437e-01f, -2.01823823e-02f, 4.09451090e-02f, 1.09335043e-01f,
  -8.13976303e-02f, 4.40863259e-02f, 6.22886568e-02f, 1.77662130e-02f, 8.99213254e-02f, 2.53134109e-02f, 3.35711725e-02f, 9.78782624e-02f, -1.23946302e-01f, 1.71379950e-02f,
  4.38861288e-02f, 4.76561449e-02f, -1.56494714e-02f, 7.05814809e-02f, -5.71311973e-02f, -1.31423682e-01f, -9.40971151e-02f, -6.89967200e-02f, -1.22023888e-01f, 1.88267301e-03f,
  -1.06329054e-01f, -1.77221447e-02f, -4.76936623e-02f, -1.17771402e-02f, -7.17337132e-02f, 2.39001177e-02f, 8.17402080e-02f, -4.68705362e-03f, -1.34454697e-01f, 9.89812165e-02f,
  4.13923189e-02f, -8.60997885e-02f, 2.81689242e-02f, -1.79744512e-02f, -4.14133482e-02f, 3.26182321e-02f, -2.68467907e-02f, 6.13588169e-02f, 6.57955259e-02f, -2.53841318e-02f,
  -5.04196845e-02f, 8.16516504e-02f, 4.91917394e-02f, -1.31217027e-02f, 9.73497611e-03f, 2.55800169e-02f, 1.12846151e-01f, -2.67555267e-02f, -1.17139727e-01f, -1.14402242e-01f,
  1.35298329e-03f, -1.54225277e-02f, 5.86099029e-02f, -3.17722512e-03f, -3.64544094e-02f, -2.63566058e-02f, -2.65585575e-02f, 1.35504566e-02f, -7.44225681e-02f, 6.46612793e-02f,
  5.61567135e-02f, 1.05205020e-02f, 1.68624055e-02f, -9.87548530e-02f, 2.03655604e-02f, 3.79700866e-03f, -2.06218380e-02f, -2.56973263e-02f, 4.97702733e-02f, 3.15046087e-02f,
  9.25103202e-02f, 6.19342364e-02f, -8.73619169e-02f, 6.84615225e-02f, -1.24086387e-01f, 7.80673996e-02f, -7.30277896e-02f, -1.18853159e-01f, 3.34275067e-02f, 1.34076670e-01f,
  -3.43903787e-02f, 3.75976833e-03f, -5.99481501e-02f, -4.77484949e-02f, -1.05270401e-01f, 5.85405193e-02f, 3.56121622e-02f, -3.21342200e-02f, 2.90869679e-02f, -2.28381995e-02f,
  -5.23659661e-02f, 5.74143678e-02f, 7.05015212e-02f, -3.46336961e-02f, 9.71711352e-02f, -1.90613285e-01f, -1.26611561e-01f, -2.09987699e-03f, -6.67386204e-02f, 1.69454485e-01f,
  -1.06414393e-01f, 1.71623632e-01f, -3.45429853e-02f, -1.65130377e-01f, -3.58225524e-01f, -1.94367066e-01f, -4.97686304e-02f, -2.18003020e-02f, -5.25985891e-03f, 4.08622734e-02f,
  -1.08462535e-01f, -2.36794129e-01f, -2.21391439e-01f, 6.03953786e-02f, 1.53521314e-01f, 1.90340266e-01f, 8.98888633e-02f, -5.33005707e-02f, 1.56326383e-01f, -1.00019671e-01f,
  -1.07310034e-01f, 6.49505630e-02f, 1.16008595e-01f, -1.75487287e-02f, 5.14677539e-02f, 8.36946517e-02f, 2.02360153e-02f, -3.19692977e-02f, -3.54379378e-02f, 3.97290066e-02f,
  1.55233771e-01f, -1.17722452e-02f, 1.40636945e-02f, -4.64081690e-02f, 1.03780895e-01f, 8.49191472e-02f, 6.90286830e-02f, 8.14664513e-02f, 3.22571285e-02f, 7.23231630e-03f,
  -2.29033642e-02f, -5.12972614e-03f, 1.03835665e-01f, 6.13530651e-02f, 8.80969241e-02f, -1.38581945e-02f, 3.99111658e-02f, 8.36921111e-03f, -3.02917659e-02f, 9.27841961e-02f,
  7.37671042e-03f, -4.38069329e-02f, -8.71182159e-02f, 5.35783358e-02f, -1.38170794e-01f, 8.02479386e-02f, -1.08432367e-01f, -3.51305306e-02f, -2.80943718e-02f, 7.48313963e-03f,
  9.72599462e-02f, 9.99592170e-02f, 1.43250520e-03f, 5.36273234e-02f, 1.71639421e-03f, 3.88333872e-02f, -1.54282069e-02f, -5.86703457e-02f, -1.71668828e-02f, 1.63144134e-02f,
  6.86781034e-02f, -1.07201256e-01f, -1.13922479e-02f, 9.42848474e-02f, -1.46943301e-01f, 5.42031229e-03f, 2.82640383e-02f, -5.65115735e-02f, 1.64055265e-02f, 4.65088375e-02f,
  4.02421923e-03f, -3.51323858e-02f, -4.58723493e-03f, -8.02447367e-03f, 1.70236491e-02f, -1.85579900e-02f, 2.80578956e-02f, 1.49003239e-02f, -1.26405820e-01f, -7.95646608e-02f,
  8.59112591e-02f, 5.29182665e-02f, 8.27216282e-02f, -9.95313004e-02f, -3.41419429e-02f, -5.17734736e-02f, -7.80758858e-02f, 1.51036233e-02f, 7.73365647e-02f, 9.29665640e-02f,
  4.78315987e-02f, 1.48674808e-02f, 3.52943949e-02f, 8.83766823e-03f, 2.41459645e-02f, 1.03882201e-01f, 2.89034769e-02f, 7.68181309e-02f, 2.32608318e-02f, 5.26841879e-02f,
  -1.57412633e-01f, 1.56507075e-01f, 4.40427102e-02f, 2.28243858e-01f, -1.00930616e-01f, -1.08173937e-01f, 1.80710703e-02f, 1.22619912e-01f, 1.53822988e-01f, 5.65962419e-02f,
  1.67655766e-01f, -4.61187437e-02f, -2.63739638e-02f, 1.95477262e-01f, 2.05050781e-01f, 1.42793059e-01f, 2.02327937e-01f, 5.41320480e-02f, 1.11085568e-02f, 1.44269824e-01f,
  1.10153556e-01f, 7.85860717e-02f, 1.54791653e-01f, -1.23966509e-03f, 1.29599050e-01f, 1.41746953e-01f, 1.70468062e-01f, 3.44975218e-02f, 1.51859403e-01f, 7.29738176e-02f,
  -1.08139969e-01f, 1.00192003e-01f, -9.06313434e-02f, -1.40419036e-01f, -2.43326239e-02f, -1.26485944e-01f, 7.58790085e-03f, -1.01115122e-01f, -1.24610700e-02f, 9.89517197e-03f,
  -3.97879966e-02f, -7.87942633e-02f, 6.78789392e-02f, -8.45908821e-02f, 2.69544683e-02f, 1.05939610e-02f, 7.70732574e-03f, -1.26073491e-02f, 7.12347450e-03f, -9.22543779e-02f,
  -1.86606529e-04f, -9.29822028e-02f, -4.88294326e-02f, 2.63694078e-02f, -8.04186705e-03f, 1.84763689e-02f, 9.78864282e-02f, 4.23905738e-02f, -1.53928064e-02f, 1.42953992e-01f,
  2.36543063e-02f, -7.50359595e-02f, 5.05882800e-02f, 8.09294172e-03f, 2.13065688e-02f, -4.05834839e-02f, 8.57614353e-02f, -8.88641458e-03f, -5.51146306e-02f, 7.86870867e-02f,
  6.03389740e-02f, 5.87248467e-02f, 1.40897045e-02f, 3.18232775e-02f, 4.73973015e-03f, -4.35418598e-02f, -3.79094407e-02f, 7.72018358e-02f, 4.94559109e-02f, 2.60766689e-02f,
  9.19366106e-02f, 9.68103260e-02f, 4.47207764e-02f, -3.69029716e-02f, 1.35261584e-02f, -4.34869248e-03f, -7.00539649e-02f, 3.61109921e-03f, -4.96015623e-02f, -1.44156041e-02f,
  1.20525010e-01f, 1.20182462e-01f, 8.11029002e-02f, -9.60030332e-02f, 4.78466507e-03f, 1.09808482e-01f, 1.00430168e-01f, -4.85832170e-02f, 1.40604690e-01f, -5.02357818e-02f,
  -1.74008943e-02f, -6.96334690e-02f, 4.30350341e-02f, -3.15980986e-02f, -9.45360363e-02f, 9.68960822e-02f, 4.94378433e-02f, 5.02658337e-02f, 4.19925526e-02f, 7.46109411e-02f,
  -1.24513935e-02f, -6.27785502e-03f, 6.45449683e-02f, -8.24944451e-02f, -4.22956571e-02f, -9.65490714e-02f, -7.21032247e-02f, -7.76340142e-02f, -3.78864445e-02f, 1.11884102e-01f,
  1.42073318e-01f, -8.03231746e-02f, -1.82871893e-01f, -3.23398151e-02f, 3.00221499e-02f, 2.08810493e-01f, 7.40715042e-02f, -1.34392828e-01f, -1.77330643e-01f, 1.29633769e-01f,
  1.18559629e-01f, -1.07674100e-01f, -8.03729594e-02f, 2.37037152e-01f, 5.68672568e-02f, 1.09418549e-01f, 1.99428037e-01f, -1.55074056e-03f, -6.97397217e-02f, -4.12389934e-02f,
  -1.04616694e-01f, 2.56984532e-01f, -2.47032307e-02f, 1.78205386e-01f, 1.86825782e-01f, -1.80098861e-01f, -7.61452913e-02f, -6.69380501e-02f, 9.00103003e-02f, -2.48804223e-03f,
  1.13086797e-01f, 6.94813440e-03f, 2.17006076e-02f, 6.24805614e-02f, 4.58232835e-02f, -8.91576242e-03f, -8.78782943e-02f, 6.67444170e-02f, -2.34890375e-02f, -7.78638422e-02f,
  1.32935926e-01f, 4.53842618e-03f, -3.81941022e-03f, -8.41966867e-02f, -5.26196025e-02f, -6.41004741e-02f, -2.19035633e-02f, -2.44459528e-02f, -1.11037917e-01f, 1.22921012e-01f,
  -5.89525811e-02f, 3.34307514e-02f, -1.00036943e-02f, 6.10988645e-04f, -5.38889319e-02f, -1.02319214e-02f, -6.25700280e-02f, 1.95229314e-02f, -8.03540498e-02f, -2.68641650e-03f,
  6.51909485e-02f, 2.44586784e-02f, -1.52393337e-03f, 3.44227813e-02f, 4.71164808e-02f, 3.33984792e-02f, -3.48699018e-02f, -2.31653973e-02f, -2.99010538e-02f, 1.44131273e-01f,
  -2.27342220e-03f, 4.39643934e-02f, 1.87353175e-02f, -2.40987279e-02f, 7.07563609e-02f, 5.09507693e-02f, -4.63169031e-02f, -4.05252986e-02f, -9.16683972e-02f, -4.73135412e-02f,
  1.99977756e-02f, 8.80809799e-02f, -9.48523805e-02f, 3.29113044e-02f, 3.50553617e-02f, -1.14508942e-01f, 6.56741410e-02f, 4.98014726e-02f, -6.12402484e-02f, -5.94340414e-02f,
  -2.83994563e-02f, 3.66464965e-02f, -9.97702330e-02f, -6.79786950e-02f, -4.20221016e-02f, 1.07988723e-01f, 1.88258588e-02f, 7.80214444e-02f, -8.58839825e-02f, 5.65911718e-02f,
  1.26174688e-02f, -7.86333457e-02f, 2.99500767e-02f, 2.43619382e-02f, -6.96928129e-02f, 1.72000304e-02f, 3.28774974e-02f, -1.04270823e-01f, 5.38942963e-02f, 5.12103140e-02f,
  -1.20296720e-02f, 1.57382451e-02f, -6.93222284e-02f, -7.00022802e-02f, 4.81529832e-02f, 3.24860476e-02f, -3.37505974e-02f, -2.92400196e-02f, -4.41720374e-02f, -1.66744627e-02f,
  -1.58612967e-01f, 4.35187742e-02f, -2.04828188e-01f, -1.36539444e-01f, 6.52841777e-02f, -2.38789856e-01f, -2.06074297e-01f, 7.96436816e-02f, -2.02244129e-02f, 3.23853903e-02f,
  -1.22025371e-01f, 3.35553549e-02f, 1.25223890e-01f, -1.45969674e-01f, -8.75099003e-02f, -1.86730213e-02f, -2.18253911e-01f, -1.83164224e-01f, -2.21141800e-02f, -1.60804734e-01f,
  3.14311944e-02f, -5.46040982e-02f, -1.85055286e-01f, 3.38663943e-02f, -2.01732785e-01f, -7.95418397e-02f, 8.91767535e-03f, 2.09678367e-01f, -1.71941146e-01f, 3.11370660e-02f,
  -1.71267375e-01f, 2.46354043e-02f, 7.96236098e-04f, -9.23928767e-02f, -1.96887687e-01f, 1.53516680e-02f, -1.59667656e-01f, -3.10887266e-02f, -7.68698528e-02f, 1.82681736e-02f,
  7.83465710e-03f, 7.35001639e-02f, -7.96543062e-02f, 9.75190103e-02f, -6.03032932e-02f, -3.23662944e-02f, 5.68416454e-02f, -8.62944126e-02f, -1.11454222e-02f, -6.63783867e-04f,
  -5.26499636e-02f, -1.19815700e-01f, -1.23385131e-01f, -2.11304389e-02f, -5.91188818e-02f, -5.12518883e-02f, -1.36332244e-01f, 2.14618556e-02f, -1.15863986e-01f, -5.80568872e-02f,
  -3.83159183e-02f, 6.17925636e-02f, -6.08599558e-03f, 1.76178303e-03f, -7.27665499e-02f, 3.44276428e-02f, -1.32352021e-02f, -3.16444375e-02f, -4.61396277e-02f, 8.99642184e-02f,
  -6.36434257e-02f, 5.73623814e-02f, 6.14880361e-02f, -2.73276959e-02f, 6.24605007e-02f, 3.05924043e-02f, -1.07949130e-01f, 7.57745877e-02f, -1.32180363e-01f, -6.65100142e-02f,
  -3.92750055e-02f, -2.01334246e-02f, -2.95071695e-02f, -7.19879121e-02f, 1.35939671e-02f, -1.57155674e-02f, 3.35061774e-02f, 2.31386833e-02f, 2.17375103e-02f, -3.79604218e-03f,
  -1.80471703e-01f, -1.03060350e-01f, 7.82229900e-02f, 6.21705316e-02f, -1.89025309e-02f, -7.58499131e-02f, -8.81369691e-03f, 2.60713678e-02f, 6.07815012e-03f, 2.69917995e-02f,
  -2.75722109e-02f, 5.28805852e-02f, -2.11799871e-02f, -4.25517783e-02f, 3.26558365e-03f, -5.31328470e-02f, -9.33684409e-03f, 2.07364541e-02f, -7.76110068e-02f, -9.39425603e-02f,
  5.14910370e-02f, 9.15450454e-02f, 1.07684605e-01f, 1.55376261e-02f, 7.25247711e-02f, -3.47805321e-02f, -8.78488123e-02f, -5.69274202e-02f, 5.97041845e-02f, -7.43445307e-02f,
  2.93131322e-01f, -3.81732434e-01f, 1.12047166e-01f, 2.57967204e-01f, 2.14317605e-01f, 7.42033347e-02f, 2.55184919e-01f, 8.40860009e-02f, 1.43374771e-01f, -2.44743079e-01f,
  2.94881247e-05f, -1.12383761e-01f, -1.62681550e-01f, 5.66416755e-02f, 1.92713678e-01f, -4.85019423e-02f, 1.16746157e-01f, 1.97682362e-02f, 4.27357145e-02f, 2.16091052e-02f,
  1.01564422e-01f, 1.78317428e-01f, 5.33209369e-02f, -1.17001787e-01f, 7.60068372e-02f, -5.01107238e-02f, -1.06844371e-02f, -4.62531149e-02f, 2.57686544e-02f, 5.71116805e-02f,
  -2.24815439e-02f, 1.33470111e-02f, -3.61160338e-02f, -8.63434002e-02f, -4.92297336e-02f, -7.87734985e-02f, -7.18364716e-02f, 6.43098056e-02f, 1.15430459e-01f, 4.67538126e-02f,
  -7.10212141e-02f, -2.49752663e-02f, 1.04283225e-02f, 2.89244242e-02f, -6.06781710e-03f, 2.62801014e-02f, -1.40028708e-02f, -3.58910561e-02f, -2.11274941e-02f, 2.35028882e-02f,
  -4.30911630e-02f, -6.00058436e-02f, 3.99494655e-02f, -2.69939434e-02f, -1.33185321e-02f, 3.52700949e-02f, -3.15797818e-03f, -4.96131033e-02f, -6.18723743e-02f, 5.81321716e-02f,
  8.45077448e-03f, -1.21737383e-01f, -1.74634606e-02f, 5.26031218e-02f, -8.94350838e-03f, 3.06940768e-02f, -4.79773358e-02f, -2.88323686e-02f, 3.44392918e-02f, -4.04337142e-03f,
  -4.62368969e-03f, 2.48378273e-02f, -3.46802287e-02f, -4.80796658e-02f, 6.12345757e-04f, -1.03197005e-02f, -3.70225636e-03f, -1.70772094e-02f, -6.82966560e-02f, -2.54674181e-02f,
  -4.33767699e-02f, -4.69881073e-02f, -7.53360689e-02f, -1.69440284e-02f, 8.05569999e-03f, -2.14659572e-02f, -1.05490327e-01f, 5.76151051e-02f, 6.67242520e-03f, -8.50361437e-02f,
  -4.09703642e-01f, -3.16929907e-01f, 6.71302853e-03f, -2.90949736e-02f, -6.97571337e-02f, -3.50716747e-02f, -3.01345214e-02f, -1.30830351e-02f, -1.36422753e-01f, 7.82598630e-02f,
  5.74099040e-03f, 6.45853803e-02f, -4.20353562e-02f, 3.92092764e-03f, -8.84185638e-03f, -1.04209045e-02f, -5.98177360e-03f, -1.21115752e-01f, 1.21212834e-02f, -2.96069235e-02f,
  -3.90113778e-02f, 6.90577030e-02f, 3.03308852e-02f, -1.69146364e-03f, -6.51796609e-02f, -4.36481945e-02f, -6.56251505e-04f, 8.25946480e-02f, -2.87990235e-02f, -6.01062085e-03f,
  -1.63392931e-01f, -6.18400350e-02f, -3.80883068e-02f, -1.10101208e-01f, 1.76033348e-01f, 2.63493974e-02f, -1.09733045e-01f, 1.23456195e-01f, -1.27679944e-01f, 9.67611447e-02f,
  -6.86750039e-02f, -1.70186624e-01f, -8.53058472e-02f, -2.25415334e-01f, -1.76881894e-01f, -2.57695109e-01f, 2.71804817e-03f, -1.34828940e-01f, -8.98087770e-02f, 1.47304937e-01f,
  -4.13823649e-02f, -1.06021777e-01f, 2.03722324e-02f, 5.54862171e-02f, 1.60262197e-01f, 1.54879555e-01f, 1.01839617e-01f, 1.21220753e-01f, 7.02862069e-02f, -4.45041060e-03f,
  -6.33714944e-02f, -6.69491142e-02f, -8.02816451e-02f, 3.35835442e-02f, 6.43128753e-02f, 6.13025278e-02f, 1.61257498e-02f, -8.15988332e-03f, 2.66062357e-02f, -3.03221159e-02f,
  8.26747566e-02f, -5.66514358e-02f, -3.63739654e-02f, -5.74341118e-02f, 4.13121916e-02f, -2.07560956e-02f, -1.78146213e-02f, 9.77171957e-02f, 3.37705873e-02f, 4.03100401e-02f,
  -8.79357532e-02f, -5.23189381e-02f, 7.44942129e-02f, 6.04892382e-03f, 6.31721914e-02f, -4.52294499e-02f, 9.31804031e-02f, 6.95800856e-02f, 6.41150028e-02f, -5.81098832e-02f,
  7.42094778e-03f, 4.89110276e-02f, -1.30320014e-02f, -6.03649653e-02f, -5.31639643e-02f, 1.09024078e-01f, -1.23818330e-01f, 2.70612594e-02f, 2.10636463e-02f, 5.02443612e-02f,
  1.21311910e-01f, -1.99842285e-02f, 3.16034816e-02f, 1.22886881e-01f, 6.66439012e-02f, -2.71292701e-02f, 6.93360046e-02f, -4.78555746e-02f, -5.33738919e-03f, 3.95342382e-03f,
  6.77675158e-02f, 2.78515518e-02f, -4.46332209e-02f, 7.13054985e-02f, 2.99123786e-02f, -4.39329930e-02f, -4.42274772e-02f, 5.95397968e-03f, -3.61585692e-02f, -5.20254560e-02f,
  -2.68686600e-02f, 8.81719962e-02f, -4.83161137e-02f, -2.88265049e-02f, 6.58835471e-02f, 8.73911977e-02f, -3.12770680e-02f, -2.12920830e-03f, 1.04975998e-02f, 2.47570090e-02f,
  6.82366267e-02f, -1.54088503e-02f, 3.77883166e-02f, 4.43789773e-02f, 2.96970420e-02f, 1.90294217e-02f, 3.93924676e-03f, -1.47409244e-02f, 1.04708772e-03f, -2.58937795e-02f,
  1.65887058e-01f, 4.12809253e-02f, 7.90895745e-02f, -5.96868955e-02f, -7.39103854e-02f, -1.94845151e-03f, 2.59988774e-02f, -6.17358051e-02f, 4.56074290e-02f, -3.07136085e-02f,
  -7.82488137e-02f, -4.72842157e-02f, -2.47587979e-01f, -7.08249733e-02f, 9.07460824e-02f, -1.13151051e-01f, -1.31036237e-01f, -1.79275163e-02f, -1.02899551e-01f, 9.31645930e-02f,
  1.24466740e-01f, -6.13023378e-02f, 1.27621695e-01f, -2.58557320e-01f, -2.56196052e-01f, -6.08787388e-02f, -3.18341851e-01f, -5.19697294e-02f, -1.06772240e-02f, -1.49780393e-01f,
  -2.54558206e-01f, -9.71528422e-03f, -3.48953575e-01f, 3.69090736e-02f, 9.05645825e-03f, -5.35587780e-02f, 1.65954813e-01f, 1.86384544e-01f, -2.39781253e-02f, -1.11285709e-02f,
  -7.20605925e-02f, -1.15399016e-02f, 3.48049216e-02f, 2.25280561e-02f, -2.10503303e-02f, 5.84111847e-02f, -1.15419598e-02f, -3.74363475e-02f, 7.04010800e-02f, -1.16330311e-01f,
  1.78302545e-02f, -9.82834492e-04f, 1.21001257e-02f, 6.51140809e-02f, -3.24292220e-02f, 1.82175897e-02f, -4.34352122e-02f, -1.08551510e-01f, -3.43498699e-02f, -9.11583975e-02f,
  -1.58595130e-01f, -9.09962356e-02f, -1.62526704e-02f, 4.56885993e-02f, 8.18782151e-02f, -2.41233762e-02f, -2.49395985e-02f, 3.77482437e-02f, 4.99186777e-02f, -7.43674189e-02f,
  9.32252109e-02f, -5.06314673e-02f, -9.42206457e-02f, 4.98923175e-02f, 1.02137085e-02f, 4.73571382e-02f, 3.06294374e-02f, 1.48130566e-01f, 5.93681633e-03f, 4.61996384e-02f,
  -2.44039744e-02f, 3.56867760e-02f, 7.11458027e-02f, -6.23412728e-02f, 3.88209498e-03f, -6.08848333e-02f, -6.14954047e-02f, -1.10315695e-01f, -1.13977298e-01f, -2.34483052e-02f,
  1.06721751e-01f, 1.68932620e-02f, -7.07297996e-02f, 7.98893794e-02f, -5.25953472e-02f, 4.70137037e-02f, -1.95379313e-02f, -9.33894292e-02f, 7.89203495e-02f, -2.51292679e-02f,
  -1.65203899e-01f, 8.94617960e-02f, 5.92005961e-02f, 4.63942848e-02f, 1.23966187e-02f, 4.34981398e-02f, -4.80910167e-02f, -5.85058257e-02f, -3.07480758e-03f, -6.02261014e-02f,
  8.21631402e-02f, -2.50537385e-04f, -7.62950629e-02f, -4.36278526e-03f, -6.03218786e-02f, -1.03476703e-01f, 6.98824376e-02f, 1.84185319e-02f, -5.72951809e-02f, -1.48606170e-02f,
  7.47096390e-02f, 4.22818447e-03f, 1.19594999e-01f, 1.52815938e-01f, 7.48056099e-02f, -2.54987013e-02f, 2.23967545e-02f, -6.85417652e-02f, 8.99188221e-02f, 8.48479792e-02f,
  9.07443911e-02f, -1.50299281e-01f, 1.82528272e-01f, -1.03614494e-01f, 1.43464163e-01f, 6.84111342e-02f, 1.48399919e-01f, -9.89914015e-02f, -5.09733856e-02f, -2.49164969e-01f,
  4.29430138e-03f, 1.11911977e-02f, 1.34350836e-01f, -1.71465427e-01f, 3.97407532e-01f, 1.19113170e-01f, 1.28108962e-02f, -5.27699180e-02f, 2.27844808e-02f, -1.18433721e-01f,
  -1.32830948e-01f, -2.10016385e-01f, 1.02690030e-02f, -2.61785120e-01f, -6.26182333e-02f, -5.16298600e-02f, -1.14045948e-01f, 1.04654767e-01f, -2.06006095e-01f, 1.64940044e-01f,
  1.14038453e-01f, -5.19312285e-02f, -2.47023031e-02f, 1.11076489e-01f, 1.44830178e-02f, 1.88305322e-02f, 7.00029731e-02f, 1.77669898e-01f, 7.88880363e-02f, -8.06589350e-02f,
  -3.79112102e-02f, 5.20186722e-02f, -9.20877829e-02f, 1.12465238e-02f, -1.01057380e-01f, -7.53418580e-02f, -1.49578020e-01f, -3.31454328e-04f, -9.14047435e-02f, 1.29984543e-01f,
  1.10607475e-01f, -5.94360642e-02f, -7.52626583e-02f, -1.29822092e-02f, -5.88146448e-02f, 7.23996088e-02f, -8.69552717e-02f, 1.48580194e-01f, 1.53814238e-02f, -1.29098773e-01f,
  2.20120996e-02f, 4.52292822e-02f, 9.68808234e-02f, 2.19304617e-02f, 1.71421021e-01f, -4.00251113e-02f, 3.00078616e-02f, -3.04327765e-03f, 8.85233656e-02f, 9.61970165e-02f,
  8.83719698e-02f, 8.70762840e-02f, -3.13180722e-02f, -1.49778351e-02f, -8.29305202e-02f, -8.83808285e-02f, 1.07088052e-01f, -7.56005794e-02f, -5.97168580e-02f, -5.91002330e-02f,
  -1.11398332e-01f, 2.69042421e-02f, -4.51358855e-02f, 6.40594363e-02f, -2.52253152e-02f, 2.42155883e-02f, -7.90135413e-02f, -9.23929587e-02f, -1.21916801e-01f, -6.29991665e-02f,
  1.01005817e-02f, -1.20130755e-01f, 8.75806063e-02f, -3.72000113e-02f, 2.54485868e-02f, 5.68339508e-03f, 8.59882534e-02f, 1.75617766e-02f, -2.63294932e-02f, -3.20219360e-02f,
  -7.31792599e-02f, 1.53800240e-02f, -8.22130442e-02f, -2.82212459e-02f, -3.84995714e-02f, -4.12855707e-02f, -5.07400632e-02f, -6.00692630e-02f, -3.40940766e-02f, 3.18518355e-02f,
  6.86211586e-02f, -2.34808829e-02f, 1.11969866e-01f, 4.47388962e-02f, 1.42679713e-03f, 4.26894650e-02f, -6.60747886e-02f, 1.23251975e-01f, -1.53257856e-02f, 2.45806004e-04f,
  3.87877256e-01f, -9.38949287e-02f, 7.96882883e-02f, 2.63440937e-01f, 2.00983047e-01f, 2.75439098e-02f, 1.19067371e-01f, 2.05576897e-01f, 3.43338758e-01f, -2.42733568e-01f,
  -3.15939449e-02f, -1.48036852e-01f, -1.68149229e-02f, -2.44307816e-01f, 1.65678319e-02f, -9.16892663e-02f, 6.49536699e-02f, -3.94599177e-02f, 8.47591683e-02f, -1.56108916e-01f,
  1.78315341e-01f, -2.17740163e-01f, -2.04773005e-02f, -2.15930164e-01f, 2.32451633e-02f, -5.15583567e-02f, -2.63281673e-01f, -1.07138187e-01f, -3.09282064e-01f, -1.53585464e-01f,
  -9.52441394e-02f, 3.61144803e-02f, 5.24218082e-02f, -8.02938938e-02f, 5.75350896e-02f, -1.84548311e-02f, -1.22142687e-01f, -1.25116974e-01f, 3.35681029e-02f, -5.45958951e-02f,
  -1.64213236e-02f, -3.87046412e-02f, -4.67185527e-02f, 2.75179511e-03f, 6.01627082e-02f, 3.57825384e-02f, 4.19923216e-02f, 4.46369089e-02f, -4.48049158e-02f, 1.21154496e-02f,
  3.54700238e-02f, 4.79542427e-02f, 1.24122851e-01f, -7.29328096e-02f, 6.16020449e-02f, 6.47131056e-02f, 5.26453741e-02f, -8.18129554e-02f, -6.97980598e-02f, 3.88624184e-02f,
  4.86093201e-02f, 4.84172329e-02f, -2.17466317e-02f, -2.83731949e-02f, -8.72174352e-02f, 9.47634056e-02f, -8.39340240e-02f, -2.82691629e-03f, -5.14201224e-02f, 1.02955671e-02f,
  1.33711547e-02f, -1.91550907e-02f, 5.30938506e-02f, 6.80280924e-02f, 9.70119797e-03f, 1.14642441e-01f, -8.18439126e-02f, -5.62768504e-02f, -2.33478472e-02f, 1.02590501e-01f,
  -2.52264906e-02f, 4.17912044e-02f, -2.44021676e-02f, 2.65008416e-02f, 6.19847327e-02f, -1.03978468e-02f, 2.52125282e-02f, 5.33164963e-02f, 5.21176718e-02f, 4.25449573e-02f,
  -1.93605423e-01f, -1.74935624e-01f, -4.63772491e-02f, -7.93552324e-02f, -1.06233455e-01f, -5.51444739e-02f, -3.42106260e-02f, -6.84529468e-02f, -1.06181398e-01f, -8.42126552e-03f,
  -2.59701405e-02f, -8.06533173e-02f, -3.51952985e-02f, 4.02936526e-02f, -2.01207120e-02f, 5.47520891e-02f, -1.38627097e-01f, 2.35330444e-02f, -6.45157620e-02f, 3.83484066e-02f,
  -7.12297931e-02f, -7.49207735e-02f, -8.97485241e-02f, 2.42081340e-02f, -8.12244639e-02f, -1.38146430e-03f, -3.22992206e-02f, -3.01639363e-02f, 6.26291474e-03f, -3.81986424e-02f,
  2.15075910e-01f, -1.42017808e-02f, -9.71517935e-02f, -8.55547413e-02f, -1.21840447e-01f, 1.66632265e-01f, 1.20842122e-02f, 4.84951288e-02f, -1.18128724e-01f, 1.27079800e-01f,
  7.98181593e-02f, 7.70929605e-02f, -1.06155455e-01f, 9.23121497e-02f, 6.86408505e-02f, -2.48304196e-02f, 1.19637214e-01f, 6.73838556e-02f, -1.26627207e-01f, 2.22004905e-01f,
  3.37359123e-02f, 1.89304069e-01f, -2.65936494e-01f, -3.37284356e-02f, 9.07939821e-02f, -1.08282454e-01f, -8.83221030e-02f, -1.12229042e-01f, 9.12105739e-02f, 1.13559969e-01f,
  8.35842416e-02f, -5.02644992e-03f, 5.24065048e-02f, 6.95772842e-02f, 4.49959468e-03f, 3.08067240e-02f, -4.61036265e-02f, 2.12476663e-02f, 1.08892918e-02f, 6.52950257e-02f,
  -3.81918550e-02f, -4.51389328e-02f, 7.09261745e-02f, -7.68070295e-02f, 1.32231399e-01f, 4.75398377e-02f, 3.58305089e-02f, 2.71731731e-03f, -7.49782845e-02f, -3.44716534e-02f,
  2.54391953e-02f, -3.84889245e-02f, 5.84353656e-02f, -1.68860495e-01f, -9.86140445e-02f, -5.55905439e-02f, -6.31302595e-03f, -8.08959007e-02f, 9.46960822e-02f, 9.46352556e-02f,
  1.09268136e-01f, -2.88680345e-02f, -4.36598398e-02f, 5.04526943e-02f, 9.74054728e-03f, -3.04785892e-02f, -7.93877766e-02f, -7.08690807e-02f, -6.84988499e-02f, -3.41936909e-02f,
  -4.77040149e-02f, 4.72620986e-02f, 2.64661014e-02f, -2.95015797e-03f, 1.05909169e-01f, -2.22911574e-02f, 5.49002411e-03f, 1.00829042e-01f, 5.72812147e-02f, -1.27260014e-01f,
  -8.05145130e-02f, -8.95042419e-02f, -3.94791923e-02f, -1.17368847e-01f, -2.64044255e-02f, -1.08488426e-01f, 5.43996431e-02f, 1.19240753e-01f, -4.86197434e-02f, 7.21206516e-03f,
  4.63972278e-02f, -3.99746373e-02f, -5.30962413e-03f, 6.74450770e-02f, -1.32514341e-02f, 9.03096125e-02f, 1.97117049e-02f, -2.96208449e-03f, 3.53282429e-02f, 6.31736442e-02f,
  3.43531966e-02f, -4.56329323e-02f, -3.62323336e-02f, 9.18290857e-03f, 3.42802354e-03f, 1.27698541e-01f, 8.19543153e-02f, -5.92631251e-02f, 5.23532778e-02f, -5.95230125e-02f,
  -5.98440357e-02f, 2.35543624e-02f, 7.80593306e-02f, 6.01273328e-02f, -3.92498523e-02f, 2.01578625e-02f, 8.98531824e-02f, 7.43555799e-02f, 4.58919108e-02f, 2.17613373e-02f,
  1.31548524e-01f, 9.23435986e-02f, -3.70486677e-02f, -1.14063151e-01f, -9.07711759e-02f, -1.85711309e-01f, -2.38524616e-01f, 6.33753389e-02f, -4.63727601e-02f, 9.93674695e-02f,
  -8.15430563e-03f, 1.11247264e-02f, 2.01520529e-02f, -6.59198761e-02f, -2.99829930e-01f, -9.12022516e-02f, -2.47195408e-01f, -1.71899155e-01f, -7.50618875e-02f, -2.37657707e-02f,
  -1.93701118e-01f, -1.37460217e-01f, -2.89871037e-01f, 1.21808257e-02f, -6.90855607e-02f, 7.87652433e-02f, 1.19016934e-02f, 7.44693428e-02f, -1.28094211e-01f, -9.62888300e-02f,
  -1.00572419e-03f, 1.42790973e-01f, 1.45456240e-01f, -1.24188354e-02f, -7.66281337e-02f, -2.44293287e-02f, -3.14907394e-02f, 7.02442676e-02f, -2.06840076e-02f, 1.26658555e-03f,
  -7.79807866e-02f, 1.72230285e-02f, -6.10906631e-02f, 2.54799034e-02f, -2.64901239e-02f, 5.59401736e-02f, -8.49018022e-02f, 5.38461795e-03f, -2.25880183e-02f, -4.70144711e-02f,
  -8.21616203e-02f, -2.31967513e-02f, -2.95666847e-02f, -7.73906782e-02f, -1.22921847e-01f, 3.43574062e-02f, -8.33317563e-02f, 4.51082103e-02f, -8.22447687e-02f, 5.45168556e-02f,
  3.26152071e-02f, -6.67483509e-02f, -7.32355863e-02f, -6.88736513e-02f, 6.11363836e-02f, -3.22163478e-02f, 1.07080564e-02f, 2.51143798e-02f, -3.86379361e-02f, -7.87662566e-02f,
  -1.59167182e-02f, 7.82683771e-03f, -3.03275846e-02f, -3.42444107e-02f, -6.61063567e-02f, 9.46403891e-02f, 9.33634043e-02f, 8.09229612e-02f, -1.09711163e-01f, 1.46088414e-02f,
  -3.98735777e-02f, 4.74336706e-02f, -5.47864614e-03f, -3.71562392e-02f, -1.09463427e-02f, 3.24491896e-02f, -6.74480051e-02f, 2.10394301e-02f, -4.62280624e-02f, -5.17435707e-02f,
  -6.86690360e-02f, 9.69400406e-02f, 1.04907842e-03f, 2.84111872e-02f, 3.72346789e-02f, -1.96170360e-02f, -9.55061838e-02f, 1.98006090e-02f, -7.02234656e-02f, -2.09868830e-02f,
  -4.84399684e-02f, -7.56629854e-02f, -1.30098566e-01f, -2.45020464e-02f, 9.60049406e-03f, -8.76859128e-02f, -4.11289465e-03f, -1.20708577e-01f, -6.40147477e-02f, 6.00477941e-02f,
  -5.25842011e-02f, -1.63312312e-02f, -5.32515533e-02f, -1.29516736e-01f, -3.77555937e-02f, 1.23402970e-02f, 3.10256053e-02f, -1.20555693e-02f, 1.09342039e-02f, -9.56076384e-02f,
  -2.68296510e-01f, -2.12346226e-01f, 1.50899440e-01f, -3.31824683e-02f, -3.95945273e-02f, 1.21829577e-01f, 2.34424040e-01f, -2.15487391e-01f, -1.98991582e-01f, -1.00661658e-01f,
  -1.00142889e-01f, 1.94778536e-02f, 2.21212268e-01f, 3.18425260e-02f, 2.71427542e-01f, 1.45092875e-01f, -5.99840330e-03f, -7.05965534e-02f, -2.52533015e-02f, -7.47673437e-02f,
  3.10237166e-02f, -1.26620784e-01f, 1.62722573e-01f, -2.19230980e-01f, 1.74396541e-02f, -2.19772473e-01f, 1.16720665e-02f, 2.26966530e-01f, -9.00779143e-02f, 1.94542091e-02f,
  -1.93199515e-01f, -2.18702435e-01f, -9.45790559e-02f, -1.07665077e-01f, 5.14556691e-02f, -3.18075307e-02f, 1.80903263e-02f, 6.67251498e-02f, -4.76520583e-02f, 2.32300232e-03f,
  1.25072718e-01f, -3.32133397e-02f, -6.83057308e-02f, -3.30495089e-02f, -1.67413300e-03f, -1.68149229e-02f, -3.97778070e-03f, 7.20961690e-02f, 3.19298171e-02f, -2.10266653e-02f,
  7.80733675e-02f, 5.59786931e-02f, -1.48980878e-02f, -6.08883463e-02f, 1.03109062e-01f, -1.04934916e-01f, 7.23519474e-02f, 1.06320933e-01f, -1.26606843e-03f, 5.46646342e-02f,
  -1.09239005e-01f, 8.21081623e-02f, -6.72052875e-02f, -1.91238914e-02f, -2.10802145e-02f, -2.92839110e-02f, 5.07548936e-02f, 2.17794850e-02f, 3.81535254e-02f, -6.36135265e-02f,
  -7.26287207e-03f, -4.13514301e-02f, -4.74302936e-03f, -8.43814611e-02f, 4.78800945e-02f, 4.21135426e-02f, 1.69724971e-02f, -1.67799536e-02f, 7.47942552e-02f, -1.04787282e-03f,
  2.47877277e-02f, -5.09242862e-02f, -1.41186016e-02f, -4.83408831e-02f, -1.57108698e-02f, 8.72515738e-02f, -1.11233145e-01f, -1.17351346e-01f, -3.66883576e-02f, 8.77837315e-02f,
  -2.43621439e-01f, -2.12326780e-01f, -1.02835014e-01f, -1.46106124e-01f, -1.40608251e-02f, -4.72761281e-02f, 3.30994502e-02f, -5.00828540e-03f, 3.16676274e-02f, -2.96180435e-02f,
  1.15443289e-03f, 4.71840799e-02f, -1.96476039e-02f, -3.59427333e-02f, 4.88343053e-02f, -2.77724806e-02f, 4.61946428e-02f, 5.30451052e-02f, -5.47548793e-02f, -2.77736951e-02f,
  -1.45388870e-02f, -1.68982908e-04f, -2.47771125e-02f, -8.75379369e-02f, -5.27669564e-02f, 2.52330694e-02f, 4.48089913e-02f, -3.16278972e-02f, 3.24152745e-02f, -3.72527051e-03f,
  -2.74704695e-01f, 9.43559483e-02f, -1.55606449e-01f, -8.81696418e-02f, -2.42670804e-01f, -2.13058293e-01f, -7.88705945e-02f, -2.00682983e-01f, 1.44571275e-01f, 1.02379963e-01f,
  4.61169742e-02f, -1.02699824e-01f, 1.56811267e-01f, 5.55876605e-02f, -5.87032400e-02f, 2.84249336e-01f, -2.45695058e-02f, 5.52464128e-02f, 1.18755177e-02f, -5.96883334e-02f,
  -8.21605846e-02f, -1.41825333e-01f, 2.16536876e-02f, -9.46609825e-02f, -2.05732226e-01f, -1.25117034e-01f, -1.39688719e-02f, -1.44808948e-01f, -1.58371791e-01f, -1.08941205e-01f,
  -2.08561435e-01f, -1.95662409e-01f, -4.25355881e-02f, -3.39154480e-03f, -8.57373029e-02f, 6.33077770e-02f, -7.36358538e-02f, 2.15355493e-02f, 5.52511215e-02f, 7.25658759e-02f,
  5.42095304e-02f, -3.25613022e-02f, -5.79726472e-02f, 1.30917460e-01f, -5.06518558e-02f, 2.27753520e-02f, -9.07251984e-03f, -4.72940952e-02f, -5.15048467e-02f, -1.93466097e-02f,
  -3.28048952e-02f, -1.69328693e-02f, 2.90763266e-02f, 8.22197720e-02f, -4.92245555e-02f, -1.05207570e-01f, -5.90261109e-02f, -1.04452930e-02f, -4.76342104e-02f, -8.65528062e-02f,
  -1.43917194e-02f, 1.59116507e-01f, 1.59595683e-01f, 1.79521386e-02f, 4.29308647e-03f, -1.82499699e-02f, 2.78658606e-02f, 3.44766788e-02f, 1.15542859e-01f, -2.12463103e-02f,
  -2.15262664e-03f, -6.83051348e-02f, -1.05369382e-01f, 1.72691774e-02f, 2.32734811e-02f, 1.01584278e-01f, -1.86039712e-02f, 1.89728066e-02f, -2.87111476e-02f, -4.80333865e-02f,
  9.99871045e-02f, 4.03789058e-03f, -4.08942252e-02f, 2.67094672e-02f, 2.18930747e-02f, 1.25849573e-02f, -6.42409921e-02f, 9.09780636e-02f, -5.38153425e-02f, -7.58307576e-02f,
  -2.41051823e-01f, -2.74754643e-01f, 3.54177132e-02f, -1.98328383e-02f, 3.50778885e-02f, 7.40714790e-03f, 2.87219062e-02f, 2.57491712e-02f, -1.01879977e-01f, -6.68204650e-02f,
  4.74967994e-02f, 5.07300869e-02f, -1.09353788e-01f, 3.09339166e-02f, 2.00404525e-02f, -6.48660469e-04f, -4.88757081e-02f, 1.58325385e-03f, 5.55293774e-03f, 3.76380011e-02f,
  1.85400490e-02f, 7.09702373e-02f, -1.08315665e-02f, -3.20991464e-02f, 5.99992312e-02f, -7.92148709e-02f, -5.25452234e-02f, 9.72864628e-02f, -1.55547842e-01f, 1.36384182e-02f,
  -5.42632639e-01f, 2.23501235e-01f, -2.38280185e-03f, -1.50491118e-01f, 8.78566578e-02f, -3.95105183e-02f, -6.51355833e-03f, 8.25434253e-02f, 9.60317329e-02f, 1.99423432e-01f,
  1.03732549e-01f, -3.37495771e-03f, 1.61902115e-01f, 4.92172651e-02f, -3.02293807e-01f, 1.09735064e-01f, -3.26370522e-02f, 2.92945150e-02f, -9.61295050e-03f, -9.36651155e-02f,
  -1.15565419e-01f, 1.29794762e-01f, -9.30198506e-02f, 1.11651383e-01f, 6.41163066e-02f, -2.66935378e-02f, -9.65737849e-02f, -8.44735559e-03f, 5.09995036e-02f, 2.79969852e-02f,
  -2.37806723e-01f, -1.62044004e-01f, 1.98810007e-02f, -9.04918611e-02f, -6.35909848e-03f, -1.22239426e-01f, -6.90236036e-03f, -2.72666700e-02f, -7.83681646e-02f, -7.76206180e-02f,
  -2.54707858e-02f, -1.44348010e-01f, 4.46923412e-02f, 4.56976257e-02f, -3.80410603e-03f, 1.21686913e-01f, -7.74285272e-02f, 5.44492602e-02f, 1.57930236e-03f, 2.49069044e-03f,
  7.00551793e-02f, -6.68963883e-03f, 8.39055981e-03f, -1.11695956e-02f, 5.75601086e-02f, 5.71943521e-02f, 2.39397902e-02f, -5.19519709e-02f, 3.84774394e-02f, -2.06221566e-02f,
  -1.50140673e-02f, 3.98729108e-02f, -4.28981446e-02f, 7.31992200e-02f, 1.76927939e-01f, 1.37529984e-01f, 4.03227173e-02f, 8.25254619e-02f, -3.03464313e-03f, -5.92146739e-02f,
  -3.69471014e-02f, -2.63378639e-02f, -1.07691489e-01f, -4.66206111e-02f, -6.52697831e-02f, -5.56390956e-02f, 4.05179039e-02f, -1.22354820e-01f, 4.96014692e-02f, -1.95229962e-01f,
  -1.23456411e-01f, -4.98399921e-02f, 1.69361029e-02f, -1.07864393e-02f, 8.43442162e-04f, -1.28225278e-04f, 1.13325357e-01f, 5.46572134e-02f, -2.69495081e-02f, -8.68613496e-02f,
  -1.53467909e-01f, -1.47535786e-01f, 4.17523943e-02f, -3.96359302e-02f, -8.76839086e-02f, -2.72031538e-02f, -9.83979106e-02f, 2.29119249e-02f, -2.94053331e-02f, 8.22590590e-02f,
  -9.04833600e-02f, -7.38496259e-02f, -9.90107730e-02f, 6.11801147e-02f, 1.29121598e-02f, -9.23139229e-03f, 3.09557449e-02f, 2.72497721e-02f, -6.63807988e-02f, -4.77133878e-02f,
  2.04557255e-02f, 5.23194447e-02f, 3.18451039e-02f, 3.28966156e-02f, 2.32444312e-02f, 1.55324424e-02f, -7.54000247e-02f, -7.90166259e-02f, -4.99389842e-02f, 6.17397949e-04f,
  8.56500790e-02f, 1.40933827e-01f, 1.44849122e-01f, 2.20577180e-01f, -2.03811936e-02f, -1.98891416e-01f, -9.97816101e-02f, 1.33809984e-01f, 2.82503217e-02f, -1.20795511e-01f,
  2.37563020e-03f, 3.30696069e-02f, -3.29492018e-02f, 1.11117147e-01f, 1.00333013e-01f, -5.33824489e-02f, 1.32162422e-01f, 3.70176546e-02f, 4.82368022e-02f, 3.29712667e-02f,
  1.63067952e-01f, 7.96006024e-02f, 4.83505949e-02f, 1.48217782e-01f, 1.25669554e-01f, 8.95951465e-02f, 1.84218213e-01f, 8.88273865e-02f, 1.68222755e-01f, 7.79181998e-03f,
  -3.28871273e-02f, 5.75035028e-02f, 5.08363843e-02f, -7.71946833e-02f, -5.12842424e-02f, 6.89109638e-02f, -1.08307652e-01f, -8.44923127e-03f, -1.23471141e-01f, -7.39914849e-02f,
  -7.44433552e-02f, -6.44430891e-02f, -6.67771846e-02f, 7.65321106e-02f, -4.92863543e-02f, -2.80818120e-02f, -4.87195700e-02f, 8.24997202e-02f, 3.42250839e-02f, -8.59580189e-02f,
  1.31558537e-01f, -1.54304849e-02f, -1.67702083e-02f, -5.86794242e-02f, 1.20457383e-02f, 4.58719805e-02f, 4.92590219e-02f, 2.63112970e-02f, 3.48064452e-02f, 3.08406893e-02f,
  8.07222072e-03f, 9.99114066e-02f, -9.51655805e-02f, -3.18359546e-02f, 5.97320870e-02f, -1.63233485e-02f, -1.32408544e-01f, -8.71435180e-02f, -5.83171919e-02f, 5.77209108e-02f,
  -3.31125744e-02f, 3.59374695e-02f, 9.16381180e-03f, -7.92590752e-02f, 9.31434035e-02f, -7.37661868e-03f, -1.38378264e-02f, -2.55533364e-02f, 5.64922579e-02f, -3.71366590e-02f,
  3.52068767e-02f, 3.48955840e-02f, 2.57959180e-02f, 3.02768294e-02f, -1.08985025e-02f, -4.65213545e-02f, 1.11902438e-01f, -4.97112609e-03f, -2.15939879e-02f, 7.03589693e-02f,
  5.77472188e-02f, 1.76196069e-01f, 5.94809540e-02f, -4.00542840e-02f, 2.65212636e-02f, -7.46279359e-02f, -8.80420730e-02f, 8.71419385e-02f, 1.84251126e-02f, 1.23225255e-02f,
  1.07465506e-01f, 7.30278948e-03f, -8.75532180e-02f, -1.14523824e-02f, 3.42603214e-02f, -2.05003060e-02f, 7.32872635e-02f, -5.11695445e-03f, 1.45708576e-01f, 7.19524473e-02f,
  5.00652008e-02f, -2.14253105e-02f, -1.55349886e-02f, -3.94852683e-02f, 8.47302377e-02f, -6.14081919e-02f, 3.08070313e-02f, 3.31291705e-02f, 2.40359623e-02f, -5.62418159e-03f,
  8.92885122e-03f, 3.00958097e-01f, 1.34463951e-01f, 9.12533998e-02f, -8.14931169e-02f, -7.05195144e-02f, -2.60430008e-01f, 4.97189499e-02f, -1.92141354e-01f, 9.56318062e-03f,
  -3.23515832e-02f, 1.45699531e-01f, -1.07902460e-01f, -3.10857762e-02f, -1.06729187e-01f, -8.44081193e-02f, 1.43160477e-01f, -2.72062491e-03f, 2.35320684e-02f, 2.38359556e-01f,
  1.33136079e-01f, -8.79450049e-03f, 2.20489100e-01f, 2.49832552e-02f, 8.55655745e-02f, 1.28021210e-01f, 9.14928168e-02f, -3.39776091e-02f, 1.61774069e-01f, -9.62551609e-02f,
  -7.98216313e-02f, 6.30647987e-02f, -7.61159360e-02f, -5.18408194e-02f, 8.05723816e-02f, -1.48495892e-02f, -1.80956218e-02f, -4.34852652e-02f, -5.75154088e-02f, -7.21732304e-02f,
  -9.10014659e-02f, -7.52142891e-02f, -4.46299128e-02f, -2.49161362e-03f, -1.24555536e-01f, 2.62350067e-02f, 1.26485601e-02f, 5.02965525e-02f, 2.33805608e-02f, 9.70715657e-02f,
  5.83028495e-02f, 1.73671916e-02f, 5.67980260e-02f, 7.49598145e-02f, -1.48244826e-02f, 3.51541452e-02f, -5.68330511e-02f, 3.34473923e-02f, 4.95259166e-02f, -1.50794135e-02f,
  -7.74190649e-02f, -6.29564421e-03f, -7.13856816e-02f, -5.98942824e-02f, 4.89551155e-03f, -1.14215359e-01f, 1.25834867e-02f, 3.00547071e-02f, -2.68149618e-02f, -5.45729920e-02f,
  -6.45977929e-02f, 7.46401548e-02f, -1.14918403e-01f, 6.70081005e-02f, 4.91695888e-02f, 4.36425433e-02f, -7.67763853e-02f, -7.16723204e-02f, -4.27181507e-03f, -2.01661270e-02f,
  -8.21599960e-02f, -4.85702045e-02f, 7.86627680e-02f, -1.88121144e-02f, -1.58104032e-01f, -1.77903827e-02f, 5.08498996e-02f, 5.28338328e-02f, -6.39417395e-02f, 1.85848661e-02f,
  7.42488429e-02f, 2.31650665e-01f, 3.42234671e-02f, -9.24769193e-02f, -3.06516606e-02f, 3.50621864e-02f, 1.50828185e-02f, 1.30528212e-02f, 2.32366174e-02f, -2.40181312e-02f,
  1.93293695e-03f, -1.49301797e-01f, -9.78177339e-02f, -7.61006773e-02f, 4.95611206e-02f, 6.80317208e-02f, 1.97909977e-02f, -1.18949957e-01f, 3.36011127e-02f, 2.65775844e-02f,
  1.52935565e-01f, -4.73921634e-02f, -4.53035347e-02f, -5.03398292e-02f, 1.08764898e-02f, -9.14230496e-02f, -5.51361777e-02f, 3.75355370e-02f, 9.30409133e-02f, -4.46974002e-02f,
  1.30949542e-01f, 1.43808141e-01f, 4.64023044e-03f, 6.58243150e-02f, -1.91405445e-01f, -3.02688360e-01f, -1.03457980e-01f, -9.53017324e-02f, 5.08822650e-02f, 7.11348131e-02f,
  -1.22681029e-01f, 2.32839972e-01f, -5.90527654e-02f, -7.25234374e-02f, -1.17349707e-01f, 9.00291186e-03f, -1.93289652e-01f, -8.60558227e-02f, 5.57899028e-02f, -1.36378855e-01f,
  -1.38820857e-01f, -2.63948411e-01f, -1.11971326e-01f, -1.91657633e-01f, -7.12035745e-02f, 8.01481605e-02f, 2.76786573e-02f, -1.18541503e-02f, -3.05172354e-02f, 1.86387803e-02f,
  -9.19904858e-02f, 1.31891921e-01f, 1.51512958e-02f, 8.10612217e-02f, 2.02048346e-02f, -9.28100944e-02f, -4.07461040e-02f, -1.05117569e-02f, 4.38681580e-02f, 3.62602323e-02f,
  8.90877470e-02f, 7.42898881e-02f, 5.41842245e-02f, -2.12452840e-02f, 9.24632996e-02f, 1.13240652e-01f, 2.57444307e-02f, 3.57451029e-02f, 1.13848783e-02f, 7.25348741e-02f,
  -3.79827842e-02f, -2.96882913e-02f, -7.79652223e-02f, -5.28811011e-03f, 4.16643806e-02f, 5.63323789e-04f, -8.47210586e-02f, 4.24645916e-02f, 2.37394702e-02f, 7.37968087e-02f,
  7.38045052e-02f, -5.01762517e-02f, 3.03844400e-02f, 3.92207922e-03f, -2.27834489e-02f, 4.59096991e-02f, -3.07852984e-03f, 5.07850153e-03f, 7.19479993e-02f, -6.52922168e-02f,
  -6.34208992e-02f, -2.20114589e-02f, 5.11087850e-02f, -2.51404569e-02f, -4.10669949e-03f, -2.73007974e-02f, -7.13175982e-02f, 6.57009333e-02f, -6.81205420e-03f, -1.77716482e-02f,
  -8.48881714e-03f, -6.55257329e-02f, 2.67633749e-03f, 4.86381389e-02f, -2.40312191e-03f, -2.01934800e-02f, 8.57033581e-02f, 1.43472195e-01f, -7.03562647e-02f, -4.48467582e-02f,
  3.19011733e-02f, -2.13040225e-02f, -3.95631790e-02f, -4.40220907e-03f, -3.91929410e-02f, -4.26140763e-02f, -4.82539088e-03f, 1.01966411e-03f, -1.12248622e-02f, -2.16569062e-02f,
  -1.01296961e-01f, -3.08928229e-02f, -8.31047371e-02f, -3.02947173e-03f, -5.93636092e-03f, -2.74852328e-02f, 5.75983152e-02f, 5.08148260e-02f, 7.87518099e-02f, 7.68679306e-02f,
  7.27590919e-02f, -2.60052178e-02f, -1.18797040e-02f, 5.04632592e-02f, 4.47310582e-02f, 1.41520519e-02f, 3.21634859e-02f, -7.00578047e-03f, 1.86774675e-02f, 1.79908075e-03f,
  7.13822767e-02f, -2.40273103e-01f, -1.95051447e-01f, 2.16725352e-03f, 2.62265652e-01f, 1.68478489e-01f, 1.26538649e-02f, 6.60183132e-02f, -8.01107287e-02f, -3.98708433e-02f,
  5.13574444e-02f, -5.43730967e-02f, -2.38054484e-01f, 1.00893475e-01f, 1.18309423e-01f, -2.03284293e-01f, 1.25057042e-01f, 1.50498245e-02f, -1.61094874e-01f, -6.15098737e-02f,
  -4.61722575e-02f, 2.44892403e-01f, -9.92097557e-02f, 1.58221588e-01f, 1.24457926e-01f, -4.57894523e-03f, 7.24039646e-03f, -1.48360014e-01f, 1.08935967e-01f, -1.11905001e-02f,
  7.62703195e-02f, -8.10662210e-02f, -1.38176233e-01f, -1.42827667e-02f, 2.17153858e-02f, 3.09011210e-02f, -8.57047290e-02f, -1.88930072e-02f, -1.11645445e-01f, -2.18816623e-02f,
  -1.11051396e-01f, -1.96212586e-02f, 7.27880374e-02f, 5.96027588e-04f, 4.59687226e-02f, 2.27969931e-03f, -5.57663068e-02f, -9.16372910e-02f, -4.81886789e-02f, -5.83417043e-02f,
  -7.72027299e-02f, -6.84526563e-03f, -4.93741930e-02f, -3.19632143e-02f, 2.34372076e-02f, -8.33127126e-02f, -1.16763882e-01f, -4.28736880e-02f, 4.74216044e-02f, 2.85300575e-02f,
  3.85571979e-02f, 7.40717873e-02f, -4.15134989e-02f, -7.53164813e-02f, 2.54477113e-02f, -2.02302113e-02f, 1.52329411e-02f, -5.18726408e-02f, -3.51285823e-02f, 8.31832066e-02f,
  1.47921899e-02f, -5.03565222e-02f, -9.80439261e-02f, 1.31756946e-01f, 8.28413991e-04f, -2.11349055e-02f, -4.70105708e-02f, 3.02083511e-02f, 6.41451329e-02f, -5.36387190e-02f,
  -1.39350384e-01f, 9.62838978e-02f, 8.16471037e-03f, -1.10350654e-01f, 5.38796782e-02f, 9.32949483e-02f, 9.13225785e-02f, 6.26875386e-02f, 3.58850975e-03f, -5.99492621e-03f,
  7.51979947e-02f, 5.77829778e-03f, 1.28743192e-02f, 1.23080546e-02f, -5.80884283e-04f, 1.09740213e-01f, -2.86454074e-02f, -1.89511309e-04f, -7.33869299e-02f, -7.13810464e-03f,
  1.27588034e-01f, -2.41009574e-02f, 1.16861204e-03f, 1.87911764e-02f, 1.98290963e-02f, 7.91148171e-02f, 4.15854231e-02f, 3.90246250e-02f, -3.99742499e-02f, 1.03537142e-01f,
  1.59506314e-02f, 1.07393213e-01f, -2.35586008e-03f, 7.50922933e-02f, 1.08680062e-01f, -4.36578244e-02f, 5.99360950e-02f, -4.65204380e-02f, -2.65593380e-02f, -7.85842836e-02f,
  -4.87974584e-02f, 1.42279029e-01f, -1.43807322e-01f, -7.73022771e-02f, -1.77909821e-01f, 1.94090575e-01f, 1.28162131e-01f, -3.77778038e-02f, -1.54390991e-01f, 2.60291129e-01f,
  2.39466116e-01f, -7.67203718e-02f, 1.80239961e-01f, 2.39349052e-01f, -1.93504199e-01f, 9.12239626e-02f, 1.34093314e-01f, 7.13964477e-02f, -1.62082948e-02f, -4.46792059e-02f,
  -1.60975289e-02f, 1.57862842e-01f, -9.29028690e-02f, 1.05762601e-01f, 2.23499201e-02f, 4.06735949e-03f, 3.39496247e-02f, -4.23939191e-02f, 7.07463250e-02f, 1.06316835e-01f,
  7.62494728e-02f, 1.39143411e-02f, 2.17067613e-03f, -9.55875367e-02f, -7.90852830e-02f, -2.79732328e-02f, 3.81652527e-02f, 3.05169704e-03f, -7.59797320e-02f, 3.46928500e-02f,
  -1.73450005e-03f, -6.85557798e-02f, -4.06782776e-02f, -9.40240771e-02f, 2.84230951e-02f, -5.72293587e-02f, 1.32441437e-02f, 2.01672222e-02f, 2.24468727e-02f, 4.49369326e-02f,
  4.11188155e-02f, -9.71210897e-02f, -1.13572655e-02f, -4.88711223e-02f, -1.01412274e-01f, -5.45759574e-02f, 6.64747283e-02f, 1.55018792e-02f, -7.59804398e-02f, -9.56743658e-02f,
  -4.67164218e-02f, 1.26051620e-01f, -2.24957354e-02f, 4.38616946e-02f, 7.55056664e-02f, 4.26128358e-02f, 2.55457219e-02f, 1.31720409e-01f, -1.37507409e-01f, 9.38138813e-02f,
  -1.36680573e-01f, -2.26316438e-03f, -4.07936377e-03f, 3.79301496e-02f, -5.64492755e-02f, 8.33930597e-02f, 1.37916192e-01f, -6.98463321e-02f, 3.78239751e-02f, 9.02443379e-02f,
  -1.98970623e-02f, -3.09347864e-02f, -3.72310542e-02f, -9.26728621e-02f, 3.78062204e-02f, 9.15586725e-02f, 7.70567507e-02f, 3.91342230e-02f, -1.33736082e-03f, -9.80850905e-02f,
  6.78789467e-02f, -2.62716655e-02f, 1.69408973e-02f, 5.47376275e-03f, 8.46413970e-02f, -9.97665077e-02f, -1.01722693e-02f, 1.19225450e-01f, 8.33020639e-03f, 2.32365783e-02f,
  -8.41415897e-02f, -1.81408018e-01f, -6.08859062e-02f, 3.41407470e-02f, 2.29723323e-02f, 8.56647268e-02f, 1.52543085e-02f, -7.92931095e-02f, -7.08726197e-02f, -7.43191913e-02f,
  9.43783857e-03f, -4.98141572e-02f, 8.09269920e-02f, 8.98407679e-03f, -4.95641865e-02f, -3.89874727e-02f, -1.67017654e-01f, 7.12023824e-02f, -7.86527544e-02f, 5.40436357e-02f,
  4.11743894e-02f, -6.53145388e-02f, 1.03343248e-01f, 1.69610351e-01f, 7.74012059e-02f, -5.36921881e-02f, -5.59647307e-02f, 1.33918777e-01f, 1.01405047e-01f, 3.07455231e-02f,
  -9.34570283e-03f, -5.91382310e-02f, -8.80311057e-02f, 1.67177305e-01f, 5.18049784e-02f, -1.54051483e-01f, 3.87501903e-02f, -1.18177988e-01f, 2.83210315e-02f, 1.33629128e-01f,
  2.58018315e-01f, 1.38761222e-01f, 9.97908488e-02f, 1.57903761e-01f, 3.84098254e-02f, 1.29265875e-01f, 6.88197538e-02f, 1.08214267e-01f, 1.44423142e-01f, 3.95846739e-02f,
  -4.15180624e-02f, 7.46150734e-03f, 7.37558231e-02f, -4.14722525e-02f, 4.71498482e-02f, -5.64229600e-02f, -1.16291761e-01f, -7.63908848e-02f, -8.85068998e-02f, -9.27049015e-03f,
  -5.99661805e-02f, 1.07518360e-01f, -6.24976270e-02f, -8.16454366e-02f, -3.42617035e-02f, -1.47696864e-02f, 4.49167825e-02f, 6.50066733e-02f, -4.50473428e-02f, 2.41167285e-02f,
  -4.84868605e-03f, -1.31497741e-01f, 2.14759242e-02f, 1.00278333e-02f, -1.11679807e-01f, -1.39195668e-02f, 6.87693208e-02f, 2.25973828e-03f, -5.39257471e-03f, 1.23128489e-01f,
  -3.79704870e-02f, 3.66702750e-02f, -6.86761597e-03f, 4.31968570e-02f, 6.29097745e-02f, -1.71139427e-02f, -6.42404407e-02f, -9.13114548e-02f, 2.77367663e-02f, 4.53481786e-02f,
  7.11796284e-02f, -2.35351734e-02f, 6.79062754e-02f, -1.03106275e-02f, 5.10258460e-03f, -6.52966574e-02f, -6.18312657e-02f, -1.47890225e-02f, 4.76969639e-03f, 4.58038785e-02f,
  -1.23534434e-01f, -1.12092070e-01f, 6.13491721e-02f, -5.29337302e-03f, -4.09791097e-02f, -3.82745378e-02f, 8.02003518e-02f, -1.60334539e-02f, -5.96061684e-02f, -1.08479984e-01f,
  6.59422353e-02f, 1.53400049e-01f, -3.24760564e-03f, -9.72184390e-02f, -4.33488376e-02f, 4.60602529e-02f, -7.97929615e-03f, -8.61229524e-02f, -5.66147715e-02f, -3.44481617e-02f,
  4.48909029e-02f, 5.39510883e-02f, -5.39639220e-02f, 3.02974321e-02f, 3.14748585e-02f, -6.65120557e-02f, 5.45833632e-02f, 2.35642418e-02f, 1.02616034e-01f, 2.86600012e-02f,
  1.23663815e-02f, -1.12372048e-01f, 1.09079145e-01f, -7.38128349e-02f, -1.00563176e-01f, -1.01004429e-02f, 5.48666865e-02f, -2.56999675e-02f, 8.00368264e-02f, -5.03422581e-02f,
  -2.50751793e-01f, 2.64236003e-01f, -6.64364221e-03f, -6.89091831e-02f, -1.34701226e-02f, -4.24014442e-02f, -3.42938714e-02f, 3.44667071e-03f, 1.14021376e-01f, 8.95315781e-02f,
  -2.73913261e-03f, -1.35699332e-01f, 9.97657254e-02f, 5.34407347e-02f, -2.84223616e-01f, 1.17616028e-01f, -3.33913714e-02f, -1.59975991e-01f, -6.47584966e-04f, -6.74025714e-02f,
  -6.17827326e-02f, -4.45825160e-02f, -6.28142133e-02f, 1.21116504e-01f, -9.52440053e-02f, -6.21493198e-02f, -6.53888332e-03f, 1.33699998e-01f, -1.72026515e-01f, 3.16582583e-02f,
  -9.63795260e-02f, 3.31961885e-02f, -1.38900891e-01f, -1.05356254e-01f, -4.17699590e-02f, 5.24058715e-02f, -1.44532517e-01f, 5.43761216e-02f, 4.56819050e-02f, 4.60068090e-03f,
  1.42981112e-02f, -1.72510576e-02f, -7.53681064e-02f, 8.34810287e-02f, 2.28634030e-02f, 3.29989605e-02f, 8.45349580e-02f, -6.25358373e-02f, 8.56052190e-02f, -6.96721897e-02f,
  -1.10779265e-02f, -2.68752798e-02f, 2.46007051e-02f, -5.59408683e-03f, -6.79814667e-02f, 3.31447721e-02f, -1.30325869e-01f, -6.12775274e-02f, -9.20263976e-02f, -6.91762045e-02f,
  1.19535841e-01f, 4.09007855e-02f, 1.42832333e-02f, 3.62183563e-02f, 1.97100360e-02f, 2.57964954e-02f, 2.10555084e-02f, -1.06833674e-01f, 1.22598238e-01f, 9.72920284e-03f,
  -9.13477987e-02f, 3.38375531e-02f, -4.54906225e-02f, 3.78447734e-02f, -2.09702123e-02f, -1.99872899e-04f, -1.11631244e-01f, 7.75687248e-02f, -7.85708800e-02f, 2.00566128e-02f,
  -3.62071432e-02f, 6.91100135e-02f, 2.50897929e-02f, -4.00720462e-02f, 9.74343643e-02f, 1.62608258e-03f, -4.42687981e-03f, -1.72265936e-02f, -6.32988736e-02f, -9.78242382e-02f,
  -6.80100545e-02f, -1.81719765e-01f, -5.14211766e-02f, -5.02561126e-03f, -4.78116497e-02f, -9.77193639e-02f, -6.69215247e-02f, -5.71239442e-02f, 3.14415395e-02f, 7.05008507e-02f,
  -5.13903126e-02f, -8.71335808e-03f, -3.81470774e-03f, -2.91915704e-02f, 1.10975560e-02f, -4.17604223e-02f, 7.45768100e-02f, 4.69306111e-02f, -9.63023603e-02f, -3.12530585e-02f,
  1.11910021e-02f, 2.25274805e-02f, 7.85715953e-02f, -6.36016876e-02f, -8.29671100e-02f, -4.41320501e-02f, -1.66320175e-01f, 2.97327731e-02f, 5.85601628e-02f, 5.41358516e-02f,
  -1.90484568e-01f, 2.77208149e-01f, -1.91024229e-01f, 1.62086084e-01f, -1.46635041e-01f, 2.14320138e-01f, 3.38016838e-01f, 3.60311531e-02f, 8.43712986e-02f, 3.40021014e-01f,
  1.95771977e-01f, 4.88502309e-02f, 9.39639658e-02f, 2.01629341e-01f, 1.47028230e-02f, 2.47917145e-01f, 2.65487105e-01f, 2.38996997e-01f, -1.75595433e-01f, 7.52323074e-03f,
  -3.88076268e-02f, 2.24543601e-01f, 7.86772296e-02f, -8.45114514e-02f, 3.60078886e-02f, -1.20207675e-01f, -2.36374009e-02f, -2.36757144e-01f, 9.03011858e-02f, -5.73311634e-02f,
  9.18285027e-02f, -4.43573967e-02f, -5.88381402e-02f, -6.99191242e-02f, 2.49106996e-02f, -1.26799673e-01f, -5.36156893e-02f, -9.77197513e-02f, -4.75547239e-02f, -2.75816470e-02f,
  -7.64002651e-03f, 1.00855147e-02f, 9.04158130e-02f, -6.25959337e-02f, -1.31647378e-01f, -1.58508075e-03f, -6.16530515e-02f, 1.41335111e-02f, 5.02657741e-02f, -6.46557659e-03f,
  -6.11630380e-02f, 3.08132712e-02f, 6.32293224e-02f, 6.69856966e-02f, 5.46588004e-02f, 1.15483351e-01f, 5.73415942e-02f, -4.35012653e-02f, -4.27649431e-02f, 2.34544487e-03f,
  -1.88700892e-02f, 7.98773393e-02f, 1.78156756e-02f, 4.31821272e-02f, -9.64256153e-02f, 4.01288122e-02f, 1.89725645e-02f, 1.83332302e-02f, -3.75161471e-06f, 8.63137171e-02f,
  5.12346365e-02f, 7.79504925e-02f, 1.69429127e-02f, -3.87552306e-02f, 7.39786997e-02f, -5.05372807e-02f, -8.55893642e-03f, 1.99370887e-02f, 6.08576834e-02f, 5.97831644e-02f,
  3.44989002e-02f, -4.10339646e-02f, 1.64002962e-02f, 2.33105905e-02f, -1.08201161e-03f, -2.71241032e-02f, 9.44075808e-02f, 5.23297898e-02f, 1.04508705e-01f, -4.68103252e-02f,
  1.55809313e-01f, 1.45628497e-01f, -1.52257988e-02f, 1.81581713e-02f, 2.75384150e-02f, 5.06026521e-02f, 4.84679937e-02f, 3.64791090e-03f, -1.80167221e-02f, -6.24446273e-02f,
  5.33746369e-03f, -6.33139396e-03f, -3.11401431e-02f, -7.16649890e-02f, 6.59885118e-03f, 5.98817021e-02f, 5.57107776e-02f, 4.39920090e-02f, 6.93812743e-02f, -4.07279981e-03f,
  -9.28898342e-03f, -1.38741324e-03f, -2.90048290e-02f, -6.26408160e-02f, 4.21213284e-02f, 6.70722425e-02f, -1.20285535e-02f, -4.31295708e-02f, 3.66761051e-02f, -9.12484527e-03f,
  -3.73875469e-01f, -8.74947831e-02f, 2.35159412e-01f, -2.24192470e-01f, -6.73571751e-02f, 1.53212175e-01f, 1.77322850e-01f, -1.27666295e-01f, -1.72266513e-01f, -1.48462027e-01f,
  -2.99396310e-02f, 3.77389975e-02f, 1.79304391e-01f, -1.57028828e-02f, 2.46111289e-01f, 8.38311166e-02f, -1.51283249e-01f, 8.37908164e-02f, -3.01317796e-02f, -1.58787996e-01f,
  2.06413101e-02f, 1.06278891e-02f, 1.27690271e-01f, -2.00344339e-01f, -9.75954980e-02f, -6.35314509e-02f, 5.37563600e-02f, 1.61501635e-02f, -5.36763333e-02f, 9.96109769e-02f,
  -2.49063388e-01f, -1.36301324e-01f, -4.66186777e-02f, 6.28997907e-02f, -6.77087754e-02f, 5.04837558e-02f, 5.46596088e-02f, 1.41339332e-01f, -5.46974801e-02f, -5.71466573e-02f,
  -6.63271844e-02f, -6.92071617e-02f, -8.39726627e-02f, 1.23259537e-01f, -1.16940789e-01f, -2.27266084e-02f, 5.20596579e-02f, 2.18726490e-02f, 2.79733185e-02f, -7.34742265e-03f,
  -3.74583039e-03f, -5.85969649e-02f, 7.73562863e-02f, -7.88231418e-02f, 1.02432266e-01f, -3.12579460e-02f, -3.01833916e-02f, -1.00895483e-03f, 2.84911543e-02f, 4.91945306e-03f,
  1.21568076e-01f, 4.96021733e-02f, -4.37601656e-02f, -5.30101825e-03f, -1.04743978e-02f, -8.76319557e-02f, -4.59609777e-02f, 4.77479361e-02f, 3.43469158e-02f, 7.88604096e-02f,
  5.37921907e-03f, -7.56256059e-02f, -8.87748450e-02f, 3.94397527e-02f, 9.01559666e-02f, 5.35356365e-02f, 1.25016049e-01f, -1.04849666e-01f, 2.27143466e-02f, -6.10103644e-02f,
  2.24040486e-02f, 7.61961862e-02f, 3.25480290e-03f, -4.59059328e-02f, -7.03848898e-02f, 2.62267739e-02f, 2.81764362e-02f, 3.72736156e-02f, 8.05968493e-02f, 7.33921304e-04f,
  -2.53869802e-01f, -1.42681882e-01f, 5.55402879e-03f, -1.57879308e-01f, -2.58565918e-02f, 2.81770267e-02f, 6.46648258e-02f, -1.17898762e-01f, -1.01128131e-01f, -3.77804711e-02f,
  -5.65725788e-02f, -6.13812134e-02f, -7.03779534e-02f, -1.52736008e-02f, -2.79117525e-02f, -1.84785221e-02f, -3.84052023e-02f, -7.10675195e-02f, -4.84622121e-02f, 5.26489969e-03f,
  -1.99099779e-02f, 8.44535977e-02f, 1.36450484e-01f, -3.11245397e-02f, -3.18377726e-02f, -7.56431371e-02f, -1.40268400e-01f, 3.58543731e-03f, -5.88061614e-03f, 8.91909525e-02f,
  -2.73722380e-01f, 1.18512645e-01f, -8.32643062e-02f, 7.74644921e-03f, 3.09916562e-03f, -7.33461007e-02f, -7.70325959e-03f, 4.79101911e-02f, 8.71946812e-02f, 1.56553939e-01f,
  -1.67848710e-02f, -8.91622752e-02f, 8.95536542e-02f, -2.94076353e-02f, -1.95995137e-01f, 1.60253614e-01f, -8.20114762e-02f, -8.48484933e-02f, 6.91014677e-02f, -1.53018549e-01f,
  -6.38555437e-02f, 1.61799081e-02f, -8.21968019e-02f, 1.57339111e-01f, -1.53638631e-01f, 1.00279646e-02f, -1.24493793e-01f, -4.81106117e-02f, -1.54540136e-01f, -4.30176705e-02f,
  -1.47830606e-01f, -8.06979761e-02f, -1.61444917e-01f, -1.49034187e-01f, -2.03276306e-01f, -1.41935349e-01f, -8.99976864e-02f, -9.93824825e-02f, 6.96283020e-03f, -5.84603623e-02f,
  3.37096974e-02f, 5.50455488e-02f, 7.86012486e-02f, 1.24660447e-01f, -5.58357984e-02f, -6.09058999e-02f, -3.37440893e-02f, -2.58825999e-02f, -6.36272579e-02f, -3.84399444e-02f,
  3.22987214e-02f, -5.48305698e-02f, -1.27690405e-01f, 1.48247154e-02f, 1.66526195e-02f, -3.34315002e-02f, 5.83647601e-02f, -1.11726314e-01f, -1.09860063e-01f, -7.99855217e-03f,
  3.48449009e-03f, -2.73881592e-02f, 1.95558928e-02f, -1.05427532e-02f, 4.86774780e-02f, 1.61556359e-02f, 6.50786329e-03f, 1.61019918e-02f, 1.73909552e-02f, 1.45401582e-01f,
  5.36252633e-02f, -5.51292077e-02f, -3.77392545e-02f, 7.80078098e-02f, 9.62252766e-02f, 6.23555742e-02f, -5.17496094e-02f, 2.12952085e-02f, 1.53355956e-01f, -2.99330167e-02f,
  -1.67305209e-02f, -1.68511588e-02f, 2.84477472e-02f, 1.84830986e-02f, -1.17681853e-01f, -7.45762289e-02f, -5.22228330e-02f, -5.88385761e-02f, -4.78376709e-02f, -5.57549484e-02f,
  -2.72279769e-01f, -2.51257926e-01f, -4.41897660e-02f, -1.30554885e-01f, -5.88356368e-02f, -8.72065499e-02f, 4.21613231e-02f, -7.47414911e-03f, -3.03938761e-02f, -6.33002147e-02f,
  -4.28503938e-03f, -9.94078629e-03f, -1.45271540e-01f, -7.01845363e-02f, 1.03120342e-01f, 1.59309860e-02f, 1.21566176e-04f, -1.13316968e-01f, -1.61802903e-01f, -2.17963662e-02f,
  -1.34594381e-01f, -4.30270396e-02f, 9.89070535e-02f, 1.08995344e-02f, -7.44495988e-02f, -5.44236973e-02f, 3.01284790e-02f, 3.68438708e-03f, 4.20192704e-02f, 8.69143158e-02f,
  -2.03287095e-01f, 1.97319165e-02f, -2.64453590e-01f, 5.76202907e-02f, 1.97912548e-02f, 3.25505510e-02f, -7.38953203e-02f, -4.67526680e-03f, -1.24973387e-01f, 1.39878675e-01f,
  -4.33626445e-03f, -2.67692566e-01f, 2.48799361e-02f, 1.40420899e-01f, -1.04598112e-01f, -8.77558067e-02f, 1.45700186e-01f, 2.87543144e-02f, -9.66843814e-02f, -1.49842007e-02f,
  -4.49946569e-03f, 2.32799798e-01f, -1.48954868e-01f, 9.84700918e-02f, 3.15635838e-02f, 3.69255245e-02f, 1.26384258e-01f, -5.89638762e-02f, 8.11707526e-02f, 6.09450266e-02f,
  -1.86936073e-02f, -5.36206029e-02f, -6.36946335e-02f, -5.58320098e-02f, -1.17655903e-01f, 4.04351130e-02f, 4.26543131e-02f, -9.06450301e-02f, -2.40973663e-02f, -3.81204076e-02f,
  -1.13342978e-01f, 6.07317872e-02f, 1.59770012e-01f, -9.44731459e-02f, 5.94781451e-02f, -3.07937320e-02f, -7.76358619e-02f, -6.32192343e-02f, 7.15922415e-02f, -3.82584147e-02f,
  2.94024553e-02f, 9.86729711e-02f, 7.36719817e-02f, 5.58366701e-02f, -2.75150668e-02f, 6.26414940e-02f, 5.44109344e-02f, -5.24259135e-02f, 2.69089453e-02f, -5.71306497e-02f,
  5.01695760e-02f, -1.07680604e-01f, 1.18903652e-01f, -1.51709002e-02f, 1.31749688e-02f, 8.59027207e-02f, 9.38610807e-02f, 9.01960116e-03f, -7.46676922e-02f, 1.83205605e-02f,
  -4.23713364e-02f, 2.34067510e-03f, -4.38976102e-02f, -1.91010651e-03f, -4.23837639e-02f, 7.53354356e-02f, 2.63503026e-02f, 8.67480971e-03f, -4.48303670e-02f, 1.62106212e-02f,
  -7.81787783e-02f, -9.67001170e-02f, 5.09256609e-02f, 3.24248597e-02f, -6.40301928e-02f, -1.50237188e-01f, -7.12749511e-02f, -8.34260061e-02f, -8.04155320e-03f, 1.06497318e-01f,
  -2.64404286e-02f, -4.37331246e-03f, 3.13356034e-02f, 1.85864151e-03f, -6.56726817e-03f, 8.49780440e-02f, 9.73380171e-03f, 4.76044454e-02f, -3.39730307e-02f, -1.30323946e-01f,
  -9.81819183e-02f, 1.58513084e-01f, 6.68582767e-02f, -6.52136281e-02f, -8.61113518e-03f, -1.79263614e-02f, -2.21554358e-02f, -4.57142964e-02f, 3.10402345e-02f, 9.86337960e-02f,
  3.04659102e-02f, -2.28982288e-02f, -2.48015746e-02f, 2.94425990e-03f, 5.90417124e-02f, -1.04294121e-02f, -1.58262309e-02f, -1.07137561e-01f, 3.27992700e-02f, -3.12748104e-02f,
  -1.06988221e-01f, 1.00896554e-02f, -1.64246261e-01f, -1.29339039e-01f, -1.81503475e-01f, -2.94485271e-01f, -1.81700766e-01f, -5.05456254e-02f, -1.10130785e-02f, 2.06497967e-01f,
  -4.47146036e-02f, -2.14842129e-02f, 1.63449764e-01f, -8.57386552e-03f, -8.46289694e-02f, 2.33279273e-01f, -1.04143456e-01f, 1.46282874e-02f, 1.38196237e-02f, -1.66282788e-01f,
  -5.34804575e-02f, -1.00805201e-01f, 2.21666936e-02f, -1.34674117e-01f, -2.31982842e-01f, -7.19747320e-02f, 1.09923065e-01f, -1.21451490e-01f, -1.97695786e-04f, -2.74082366e-02f,
  -2.25541621e-01f, -1.06176876e-01f, -6.60674740e-03f, -4.01366800e-02f, -1.48534253e-01f, 4.77465279e-02f, -6.93869144e-02f, 5.08801639e-02f, -3.72261107e-02f, 1.88451558e-02f,
  5.61787263e-02f, -5.51416352e-02f, 6.36779740e-02f, -1.95069127e-02f, -7.83648044e-02f, -5.19379079e-02f, 2.47141626e-02f, -1.60078891e-02f, 2.97559076e-03f, -6.57283664e-02f,
  7.51102809e-03f, -1.02610715e-01f, -3.29281352e-02f, 4.44463044e-02f, -6.41302690e-02f, -3.59347537e-02f, 5.51408231e-02f, 2.46408023e-02f, -1.55082673e-01f, -7.09547177e-02f,
  6.31461963e-02f, 2.03231126e-02f, -3.72341014e-02f, 3.81300272e-03f, 1.13765569e-02f, -2.25010049e-02f, -1.08192667e-01f, 1.20044895e-01f, -2.40992662e-02f, -5.58380410e-03f,
  3.86013389e-02f, -4.32091020e-02f, 3.91695686e-02f, 1.16160177e-02f, -5.47106331e-03f, -2.88945511e-02f, -8.50957446e-03f, -5.99105991e-02f, -4.78587970e-02f, 5.63986339e-02f,
  3.23889330e-02f, 3.15071382e-02f, 8.02555401e-03f, -6.83705807e-02f, -6.46156967e-02f, 6.87151328e-02f, -6.72354177e-02f, -4.78185304e-02f, -5.22486344e-02f, -2.38372665e-02f,
  -1.81230560e-01f, -2.72814006e-01f, -4.97533800e-03f, -2.10606813e-01f, 9.64828506e-02f, -6.61469400e-02f, 4.72302958e-02f, -2.73660608e-02f, -6.50330037e-02f, -3.09964567e-02f,
  -2.39173211e-02f, -2.42536645e-02f, -9.67539251e-02f, 5.07230461e-02f, -7.86548555e-02f, -3.35154273e-02f, 5.44853583e-02f, 6.28017634e-02f, -1.08953819e-01f, -1.40727550e-01f,
  -2.57003549e-02f, -6.26892000e-02f, -6.36404753e-03f, -4.27841879e-02f, 1.72812603e-02f, 1.17845675e-02f, -5.23248920e-03f, 6.39810562e-02f, 1.04562491e-02f, -4.17888910e-02f,
  7.96070397e-02f, 1.49503142e-01f, 1.90156192e-01f, 5.68358265e-02f, -1.53460905e-01f, -3.92230563e-02f, -1.17826657e-02f, -1.18538648e-01f, 1.87229902e-01f, 8.94105062e-02f,
  -7.06643090e-02f, 2.68940389e-01f, -8.30341876e-02f, -9.58350524e-02f, -1.05364181e-01f, -4.77457456e-02f, -7.23049864e-02f, 1.18421204e-01f, -2.57115923e-02f, 4.05140547e-03f,
  -1.18597016e-01f, -2.72133201e-01f, -2.02886149e-01f, -9.11730975e-02f, 7.62809366e-02f, 1.71851724e-01f, -2.31397539e-01f, -8.54562670e-02f, 1.24701776e-01f, 1.64048113e-02f,
  -7.61026703e-03f, 2.59690210e-02f, 1.03778429e-01f, 7.94211254e-02f, -1.13088787e-02f, 8.21989961e-03f, -7.63030117e-03f, -2.08586678e-02f, -5.20027592e-04f, 4.28506956e-02f,
  3.76726016e-02f, 3.19050252e-02f, 8.18216056e-02f, -2.27743145e-02f, 4.89308015e-02f, 4.04628068e-02f, 2.92727593e-02f, -5.49328849e-02f, 2.06507340e-01f, 8.33726376e-02f,
  8.51331130e-02f, 6.22631647e-02f, 1.14791885e-01f, 3.86193395e-03f, 7.17403144e-02f, 9.28919092e-02f, -2.45098071e-03f, -2.18976708e-03f, 5.11808395e-02f, 3.33258286e-02f,
  -6.53986409e-02f, -1.12304680e-01f, -1.64708775e-02f, 5.76260611e-02f, 2.00789012e-02f, 9.35294759e-03f, 6.61745742e-02f, -8.64560902e-02f, -1.80662461e-02f, -1.65920258e-02f,
  8.51726346e-03f, -9.90383141e-03f, -6.82667345e-02f, 2.73118466e-02f, -3.17213088e-02f, 9.48061123e-02f, 8.56541544e-02f, -4.27706167e-02f, -1.99109465e-02f, -4.43265066e-02f,
  -3.42750885e-02f, 1.10334856e-02f, -6.66631162e-02f, -7.58761317e-02f, 9.29023325e-02f, 9.11100432e-02f, 4.00141301e-03f, 1.68971404e-01f, -4.87492979e-02f, -3.78990471e-02f,
  2.60576215e-02f, -4.85815927e-02f, 7.14464709e-02f, -1.61462631e-02f, 7.74552971e-02f, 3.34419608e-02f, -1.67651027e-02f, 1.35226864e-02f, 3.13925440e-03f, -2.82326359e-02f,
  -1.36379674e-02f, 6.52581230e-02f, 6.13469966e-02f, -6.45726398e-02f, -2.50396524e-02f, 3.04399803e-02f, -5.11681475e-02f, -2.98388046e-03f, 2.90122218e-02f, -1.32522449e-01f,
  -3.10407504e-02f, 6.16131648e-02f, 7.19305798e-02f, 3.91386934e-02f, 1.73663732e-03f, -1.11814039e-02f, 2.60146204e-02f, 5.80614135e-02f, -1.50796352e-02f, -1.40311550e-02f,
  1.98964283e-01f, -3.07693124e-01f, -8.95563513e-02f, 2.64678478e-01f, 7.02919215e-02f, 7.55546018e-02f, 3.79311889e-02f, 6.61813915e-02f, 2.06007630e-01f, -2.19742507e-01f,
  -7.16359392e-02f, -8.88763592e-02f, -2.12655485e-01f, 9.97581631e-02f, 2.31814206e-01f, -1.06882127e-02f, 1.48918211e-01f, -8.95729065e-02f, 1.03019774e-01f, -4.14669402e-02f,
  1.04563095e-01f, 1.38111979e-01f, -1.52612748e-02f, -1.48455445e-02f, 1.56060876e-02f, 3.65239717e-02f, -1.36161270e-02f, -5.14637679e-02f, -1.26230195e-01f, -3.79470252e-02f,
  -1.58708632e-01f, 8.15172940e-02f, 2.95488760e-02f, 1.92310959e-02f, -5.21935597e-02f, 3.77573469e-03f, -1.19255446e-01f, 4.07667607e-02f, 5.31027541e-02f, 1.94682013e-02f,
  -7.31049404e-02f, -7.33826011e-02f, 1.09081410e-01f, 4.22271043e-02f, 1.16260469e-01f, 6.72519282e-02f, -1.62359402e-02f, -2.12082658e-02f, -2.40026228e-02f, -1.03907831e-01f,
  -6.15675785e-02f, -2.44883578e-02f, 2.03860756e-02f, -2.52153538e-02f, 7.61450604e-02f, 8.48560967e-03f, 3.55003960e-02f, -9.42444429e-02f, -2.43189428e-02f, 1.24475040e-01f,
  3.45835369e-03f, 1.09228643e-03f, -3.27044725e-02f, -5.91062866e-02f, -4.94349152e-02f, 1.35878354e-01f, 1.02367694e-03f, -6.42998070e-02f, -1.16741762e-01f, -6.79470971e-02f,
  2.35650931e-02f, 7.69799277e-02f, 7.01324791e-02f, 6.06179982e-02f, 6.44839406e-02f, -1.76542019e-03f, -4.93485294e-03f, 9.68665257e-03f, 5.84871024e-02f, 1.36650598e-03f,
  -2.95327627e-03f, -1.79885060e-03f, -1.05123729e-01f, 3.96291167e-02f, -6.88039139e-02f, -4.86037396e-02f, -2.76396796e-02f, -7.30334083e-03f, 7.59378374e-02f, 1.64592604e-03f,
  -4.26400572e-01f, -2.27745801e-01f, -5.64178750e-02f, -7.30168596e-02f, -1.13192238e-02f, -3.31232995e-02f, 1.00334413e-01f, 2.17761546e-02f, -1.01721130e-01f, -3.13592218e-02f,
  -1.50878757e-01f, 3.62879187e-02f, -7.60075822e-02f, 1.47824520e-02f, 2.40402333e-02f, 4.36359607e-02f, -3.34083214e-02f, -1.10172540e-01f, 7.35262111e-02f, -6.30102353e-03f,
  -4.90151010e-02f, -3.71414423e-02f, 4.03550267e-02f, -5.90189993e-02f, -8.10153596e-03f, 5.36722969e-03f, 3.36561874e-02f, 4.34486307e-02f, -7.96285644e-02f, -3.63002047e-02f,
  -5.62456608e-01f, 1.46672390e-02f, 2.07714930e-01f, -1.15095057e-01f, -1.87494028e-02f, 2.47731775e-01f, 8.42542946e-02f, 1.79378003e-01f, 6.51875809e-02f, 1.77249193e-01f,
  9.52624306e-02f, -2.38003135e-01f, 6.32714555e-02f, 1.16176508e-01f, 4.53072088e-03f, 1.93765238e-01f, 1.73204273e-01f, 2.36690659e-02f, -3.40942852e-02f, -6.03146702e-02f,
  -5.27966954e-02f, 2.51680855e-02f, 2.44359702e-01f, 4.37077433e-02f, -3.30232307e-02f, -1.57640249e-01f, -8.01545605e-02f, -7.80955032e-02f, -2.78859157e-02f, 5.56453057e-02f,
  -1.81470305e-01f, -7.92149976e-02f, -7.29314387e-02f, 9.06846225e-02f, 1.42839914e-02f, 1.33073786e-02f, 6.06005490e-02f, 5.72003890e-04f, -6.36036098e-02f, -2.50920299e-02f,
  -1.31400049e-01f, 4.74608541e-02f, -8.59897733e-02f, 5.50770375e-04f, -1.26029188e-02f, -5.09322155e-04f, 3.01233865e-02f, 8.49867240e-02f, 6.62540421e-02f, -1.73614882e-02f,
  1.62937596e-01f, -2.73741712e-03f, 1.17270276e-01f, 1.05286889e-01f, 3.62464860e-02f, 3.43061648e-02f, 4.97589484e-02f, 1.15685677e-02f, -2.77166162e-02f, -7.95419235e-03f,
  1.63754970e-02f, -3.98122221e-02f, 8.17669109e-02f, -3.59213464e-02f, 3.85985477e-03f, 4.50389944e-02f, 7.52199953e-03f, -9.17641521e-02f, 2.09522303e-02f, 1.38871241e-02f,
  -7.00258883e-03f, 4.20331545e-02f, 9.30168405e-02f, 9.36177522e-02f, -4.50430363e-02f, 5.19727357e-03f, -4.68351766e-02f, 2.06508767e-02f, 5.08380532e-02f, 5.35684116e-02f,
  -6.23680688e-02f, -2.06526052e-02f, 9.25920010e-02f, 3.56305391e-02f, 6.58600479e-02f, 2.74271984e-02f, -4.88301627e-02f, 8.75778422e-02f, 7.87043106e-03f, -2.27661058e-02f,
  -2.26398468e-01f, -5.74413538e-02f, -6.26867358e-03f, 2.73195114e-02f, 2.13150661e-02f, -3.41036846e-03f, -1.27011105e-01f, -4.17649895e-02f, -3.51845846e-02f, -4.56478111e-02f,
  2.20994707e-02f, 4.77330759e-02f, -3.99264619e-02f, -1.53156305e-02f, 3.50368917e-02f, 1.03005625e-01f, -9.54546854e-02f, -8.61788094e-02f, 1.91490129e-02f, 7.81987533e-02f,
  -7.08708093e-02f, -6.24895841e-02f, 1.40464855e-02f, 5.98832145e-02f, 9.08777118e-02f, -1.45119876e-02f, -5.44288233e-02f, -3.34793851e-02f, 6.15254715e-02f, -1.75712425e-02f,
  -1.69235468e-01f, -1.36009857e-01f, -8.66230950e-02f, -2.39437476e-01f, 1.51153818e-01f, -6.59454837e-02f, 9.01211612e-03f, 2.52258517e-02f, -1.14145897e-01f, 9.68758538e-02f,
  4.38552015e-02f, 7.29273558e-02f, -5.72444834e-02f, -1.99445084e-01f, -1.43743187e-01f, -6.74347803e-02f, -1.66999429e-01f, -3.92289050e-02f, -3.03974673e-02f, -1.09356552e-01f,
  -5.64305335e-02f, -1.15244873e-01f, -1.00614130e-01f, 1.99251622e-02f, -8.38785321e-02f, 6.41175583e-02f, 5.60385399e-02f, 1.48436829e-01f, 1.16509115e-02f, 8.45169127e-02f,
  2.75789318e-03f, 6.05089851e-02f, 1.33292172e-02f, 1.11683734e-01f, -6.11284338e-02f, -1.84839237e-02f, 6.04372844e-02f, 4.82060276e-02f, 8.06116834e-02f, -1.14782136e-02f,
  2.78826207e-02f, -2.33328398e-02f, 5.87807819e-02f, -6.34164829e-03f, -2.77833212e-02f, -1.20370407e-02f, -6.12365678e-02f, -2.59767147e-03f, 3.84192951e-02f, -2.41275299e-02f,
  -1.08919842e-02f, 6.52502701e-02f, -6.28923103e-02f, -1.42675014e-02f, 2.78342213e-03f, 1.61884201e-03f, 3.68291810e-02f, -5.09921368e-03f, -8.10969248e-02f, -9.67878997e-02f,
  -9.22331065e-02f, -8.91144276e-02f, -5.81321046e-02f, -2.34376919e-03f, 8.90454277e-03f, 1.13687322e-01f, -1.04533665e-01f, 1.17177740e-01f, 3.37685235e-02f, -3.11209857e-02f,
  -9.27579850e-02f, 3.37339863e-02f, 8.45089257e-02f, -5.57968654e-02f, -4.25521880e-02f, 3.78649272e-02f, 8.97019729e-02f, 1.00370198e-01f, -1.39818326e-01f, 5.80850095e-02f,
  9.27209780e-02f, 4.08610180e-02f, 7.71646425e-02f, -2.90693361e-02f, 7.92556182e-02f, 5.66609716e-03f, 8.86590779e-02f, 1.36240914e-01f, 6.94131628e-02f, -3.89688835e-02f,
  -3.77288763e-03f, -5.34318909e-02f, -3.67269106e-02f, 5.34523912e-02f, 3.44909839e-02f, -1.07908770e-02f, -5.17627560e-02f, 4.95473854e-02f, 1.63939930e-02f, -7.48963188e-03f,
  2.98348702e-02f, 6.55355453e-02f, 6.06664643e-02f, 2.36816350e-02f, 8.45995247e-02f, 5.52255847e-02f, -3.40957008e-02f, -8.15135762e-02f, -3.99231678e-03f, 5.35853393e-02f,
  3.46034616e-02f, 7.84821436e-02f, -1.42130267e-03f, -6.27790540e-02f, -4.06245468e-03f, 1.17799630e-02f, 3.21508050e-02f, 3.69336568e-02f, -6.43046275e-02f, -5.12085203e-03f,
  3.29227708e-02f, -1.71727017e-01f, -1.48182526e-01f, 2.33474255e-01f, -1.97771154e-02f, -1.93831265e-01f, -1.79269433e-01f, 9.88768339e-02f, -1.33477032e-01f, -1.71283707e-01f,
  4.29878347e-02f, 6.08591363e-03f, -2.02539101e-01f, 1.87743351e-01f, 1.88556939e-01f, -1.03420869e-01f, 1.10010765e-01f, 6.70573860e-02f, -2.58843768e-02f, 9.36562270e-02f,
  9.84369442e-02f, 7.15259984e-02f, 5.89130484e-02f, 1.64075553e-01f, 3.22344974e-02f, 5.06347641e-02f, 4.63868417e-02f, -9.52747092e-02f, 1.67440906e-01f, 6.28280938e-02f,
  -2.46406663e-02f, -5.46727218e-02f, -7.12017575e-03f, -6.86929077e-02f, 5.45294918e-02f, -9.45074782e-02f, 1.03590144e-02f, 4.02022824e-02f, -2.11285260e-02f, -6.40761554e-02f,
  -1.17742501e-01f, 5.67560978e-02f, 1.20102674e-01f, 8.18005856e-03f, 7.78112337e-02f, -4.84426655e-02f, 5.62800206e-02f, 2.78984960e-02f, -4.85980995e-02f, -4.76150922e-02f,
  -2.81706322e-02f, -6.51439503e-02f, 8.58516991e-02f, 1.10156983e-02f, 7.98823833e-02f, 1.63270086e-02f, 8.02501943e-03f, 8.62684567e-03f, -8.93760938e-03f, 3.75834145e-02f,
  6.58480972e-02f, -8.58473182e-02f, -6.41420111e-02f, 3.89125384e-02f, 1.17887594e-02f, 8.70979801e-02f, -9.70362425e-02f, 2.14011334e-02f, -5.53829819e-02f, 2.43850537e-02f,
  -8.45742375e-02f, -5.01914546e-02f, -6.36020973e-02f, -1.30605564e-01f, 4.80863489e-02f, 1.87819153e-02f, 2.29324959e-03f, -8.44925921e-03f, 1.57143809e-02f, -1.09165311e-02f,
  -7.58525878e-02f, -4.82079647e-02f, 9.95052978e-03f, -2.77772676e-02f, -1.15930689e-02f, -9.16449539e-03f, -9.18460637e-02f, -1.73970927e-02f, 2.77080527e-03f, 3.09146196e-02f,
  -1.42733395e-01f, 2.42832936e-02f, -4.48275320e-02f, -2.44487133e-02f, -1.00804511e-02f, 8.35289359e-02f, 4.50770110e-02f, -5.53148473e-03f, 2.23541837e-02f, 2.32852548e-02f,
  -9.84684750e-02f, -6.28575981e-02f, -3.32141407e-02f, -2.94535402e-02f, 8.69244616e-03f, -4.28906549e-03f, -1.11768715e-01f, -3.65246423e-02f, 8.24093595e-02f, 5.57371229e-02f,
  3.93308923e-02f, 1.25270039e-02f, -6.27959371e-02f, 7.55337207e-03f, 6.87138587e-02f, 5.44607863e-02f, 7.69771561e-02f, 1.04462191e-01f, -4.48284186e-02f, 5.85432984e-02f,
  -1.58639789e-01f, -1.37676567e-01f, -1.59082994e-01f, -8.88300613e-02f, 1.33983955e-01f, 2.84286737e-02f, -1.28736317e-01f, 9.29196253e-02f, -5.24869226e-02f, -8.40688571e-02f,
  -6.60398528e-02f, -1.25731036e-01f, -1.90062970e-01f, -2.18577772e-01f, -1.03084259e-02f, -3.02154690e-01f, 3.87072526e-02f, -1.12722620e-01f, -1.83871150e-01f, -5.86093701e-02f,
  -6.85905963e-02f, 2.08114088e-01f, -1.35790259e-02f, 2.60616839e-01f, 1.16004266e-01f, 7.93632865e-02f, 6.60000220e-02f, 1.00927111e-02f, 2.11816102e-01f, 1.04477577e-01f,
  -1.62321737e-03f, -6.21803366e-02f, 3.03914901e-02f, -1.92247257e-02f, 1.27335684e-02f, 1.23573907e-01f, 1.07207343e-01f, 1.77699476e-02f, 1.08070813e-01f, -1.22088283e-01f,
  5.40823527e-02f, 8.51237997e-02f, -2.41586808e-02f, -1.02232501e-01f, -5.80665916e-02f, 1.10850774e-01f, -1.29336745e-01f, 1.04791775e-01f, -1.09854937e-01f, -1.56797007e-01f,
  -4.66264673e-02f, 2.72848789e-04f, -1.05437517e-01f, -1.93181355e-02f, -8.62293765e-02f, -9.58082825e-02f, -4.79719266e-02f, 2.24380046e-02f, -3.72626074e-02f, 3.44254710e-02f,
  8.47785361e-03f, 1.36010721e-01f, -8.02727416e-02f, 1.68203823e-02f, -2.45269798e-02f, -5.17214388e-02f, -1.26984596e-01f, 3.82213742e-02f, -3.51991840e-02f, 2.76049803e-04f,
  8.75952914e-02f, -1.12528436e-01f, -7.38864914e-02f, 1.70054853e-01f, -1.24316029e-02f, 2.92091928e-02f, 7.31447563e-02f, 2.25342773e-02f, 5.78110516e-02f, 3.11669242e-03f,
  3.06043569e-02f, 6.57141283e-02f, 6.24713153e-02f, -3.14297937e-02f, 6.72681304e-03f, 1.34503439e-01f, -5.21704964e-02f, 5.01172468e-02f, -5.16890883e-02f, 5.77664562e-02f,
  -5.14189787e-02f, -5.17445654e-02f, -4.43222336e-02f, 1.01735024e-02f, -9.74071324e-02f, -1.59041341e-02f, 2.77403463e-02f, 1.11018427e-01f, 3.62689309e-02f, 7.31308535e-02f,
  8.10503885e-02f, 5.63974418e-02f, -9.76443663e-03f, 6.47483254e-03f, -6.23757672e-03f, -1.24189164e-02f, -4.24750987e-03f, 4.72597629e-02f, 2.38237642e-02f, -1.89895835e-02f,
  3.08804438e-02f, 1.74448490e-02f, 1.35355452e-02f, 1.82690263e-01f, 1.02354191e-01f, -4.97236736e-02f, 3.74737680e-02f, 4.99294780e-04f, -9.24008787e-02f, 5.15462197e-02f,
  -3.29104692e-01f, 2.64334865e-02f, 1.55509561e-01f, -2.35059083e-01f, -9.89510864e-02f, 2.45396331e-01f, 1.46380082e-01f, -1.26635628e-02f, -2.78235406e-01f, -1.02377221e-01f,
  -6.51131570e-02f, -8.35720375e-02f, 1.93071544e-01f, -1.56908453e-01f, 2.19365105e-01f, 2.19653025e-01f, -2.38403827e-02f, 5.12625352e-02f, -3.69433127e-02f, 3.44528072e-02f,
  -9.77211148e-02f, 3.85283236e-03f, 2.02555627e-01f, 4.15516049e-02f, -1.03371210e-01f, -1.16023064e-01f, -7.47489706e-02f, 1.54590845e-01f, -1.42178565e-01f, -5.14378585e-02f,
  -8.47726762e-02f, -1.36661991e-01f, 9.25856084e-02f, -7.63701275e-02f, 3.73169109e-02f, -2.33482849e-02f, 3.41174304e-02f, -5.38146198e-02f, -6.65113553e-02f, -5.74651212e-02f,
  -4.26450707e-02f, 3.58130746e-02f, -4.28302437e-02f, 6.07483601e-03f, -1.13605047e-02f, -6.60039112e-02f, -1.52710587e-01f, -8.29110853e-03f, -1.20075261e-02f, 8.46211612e-02f,
  1.49108116e-02f, 2.10513249e-02f, 6.53589815e-02f, 2.87383981e-02f, -6.38422668e-02f, 8.81592035e-02f, 2.70543080e-02f, -4.84108850e-02f, 1.87415201e-02f, -5.74676953e-02f,
  3.43061164e-02f, -5.52552082e-02f, -2.24242788e-02f, -1.06471725e-01f, -7.26440698e-02f, 3.45279723e-02f, -4.45364043e-02f, -8.42535775e-03f, -1.71851106e-02f, -2.79490948e-02f,
  -9.66786966e-02f, -6.21010847e-02f, -2.43103085e-03f, 1.28062099e-01f, -8.24834928e-02f, -8.97674188e-02f, 1.13385908e-01f, -8.21469277e-02f, -7.93857723e-02f, -5.03485091e-02f,
  -2.97489613e-02f, 2.49655973e-02f, 1.98122375e-02f, 7.74091780e-02f, 5.53188436e-02f, 1.34975882e-02f, 6.49891347e-02f, 1.18105866e-01f, -3.86526063e-02f, 7.91041926e-02f,
  -1.82044357e-01f, -2.36953557e-01f, -5.93433902e-02f, -6.17637970e-02f, -7.10516470e-03f, 4.64445166e-02f, -5.65249696e-02f, 6.24901801e-02f, -8.19711983e-02f, -9.46142673e-02f,
  -9.04430076e-02f, 3.26347016e-02f, -5.76637611e-02f, 5.43745793e-02f, 6.13635853e-02f, 5.11610024e-02f, -5.70428967e-02f, -1.35068536e-01f, -5.73251657e-02f, -4.11053887e-03f,
  2.38463655e-02f, -7.38782287e-02f, 8.09232593e-02f, 1.36860842e-02f, -9.65184420e-02f, 1.46586224e-02f, -1.48505017e-01f, -9.97580681e-03f, -4.86390889e-02f, 9.51076895e-02f,
  3.01846772e-01f, 1.06178254e-01f, 7.97378048e-02f, 1.52805582e-01f, -1.20615870e-01f, -8.38118047e-02f, -4.65190113e-02f, 1.04768865e-01f, 2.35657588e-01f, -2.88252588e-02f,
  -1.83037706e-02f, 2.16101989e-01f, -1.70431674e-01f, 8.53208005e-02f, -9.75616276e-02f, -2.13632911e-01f, 2.20983997e-01f, 2.94579919e-02f, 2.96630599e-02f, 1.46233901e-01f,
  1.02024354e-01f, 4.50004004e-02f, 1.04305170e-01f, -3.81893292e-02f, 1.05349086e-01f, 4.94758189e-02f, -6.58243243e-03f, -6.20527901e-02f, 5.88273183e-02f, -6.10243045e-02f,
  -6.93619177e-02f, -4.72000195e-03f, 1.43105043e-02f, -6.08183481e-02f, 5.77772036e-03f, 1.19885683e-01f, 5.39836735e-02f, -1.17085373e-03f, 3.92426923e-02f, 4.84526008e-02f,
  7.96283036e-02f, 6.83098380e-03f, 1.38998389e-01f, 4.34024632e-02f, 1.49613023e-01f, 2.07267725e-03f, 3.78733687e-02f, -5.75266629e-02f, -4.77082394e-02f, 6.14724457e-02f,
  1.14518002e-01f, -1.64631326e-02f, 1.60150547e-02f, 8.58392566e-02f, -1.05333794e-02f, -7.50095695e-02f, 4.30933433e-03f, -1.34737790e-01f, 7.88778719e-03f, 9.25718844e-02f,
  -9.17541534e-02f, -5.30031137e-02f, 9.33554955e-03f, -3.32846167e-03f, -2.11271942e-02f, 3.64925228e-02f, -2.52854228e-02f, -6.98282197e-02f, 5.13292179e-02f, 2.09259335e-03f,
  1.60624068e-02f, 3.47884223e-02f, -2.10797880e-02f, -6.45136461e-02f, -2.26092506e-02f, 7.26743694e-03f, 7.68674389e-02f, -7.71208331e-02f, -2.37777364e-02f, 1.64301507e-02f,
  4.95672822e-02f, 3.21708843e-02f, 4.61259857e-03f, -1.21358737e-01f, -8.88014445e-04f, 2.39826944e-02f, -9.07011703e-02f, 1.33586274e-02f, 4.83371876e-02f, 3.54105905e-02f,
  2.92035230e-02f, 2.77259741e-02f, -1.43037522e-02f, -2.81365868e-02f, -2.61604507e-02f, 1.07171081e-01f, -7.71474391e-02f, 9.55166146e-02f, -6.06051162e-02f, 5.25800288e-02f,
  2.01257523e-02f, 8.84667262e-02f, 1.06639870e-01f, 4.98204567e-02f, -4.23676260e-02f, 3.86364236e-02f, 2.87089087e-02f, 4.59473096e-02f, -1.28197744e-01f, 6.19474240e-03f,
  7.65070245e-02f, 9.80890095e-02f, 1.33968052e-02f, -7.87665695e-02f, 2.96856854e-02f, -5.13607264e-02f, 8.85159001e-02f, -7.57009834e-02f, 5.57068177e-02f, -1.11492783e-01f,
  1.44419372e-01f, -1.85089916e-01f, -2.71064013e-01f, 4.50095199e-02f, 5.16711874e-03f, 2.12450013e-01f, 2.10763112e-01f, 5.81450388e-02f, 8.84682983e-02f, 1.28074631e-01f,
  1.50082931e-01f, -2.58121997e-01f, -1.32660568e-01f, -7.47481808e-02f, -1.28558472e-01f, -2.25546751e-02f, 4.15913761e-02f, 5.95921651e-02f, 2.85292254e-03f, 1.00916587e-01f,
  1.19102910e-01f, 7.66292363e-02f, -1.10904343e-01f, 1.94060411e-02f, 1.18692696e-01f, 8.61497819e-02f, 2.20528860e-02f, -5.57056703e-02f, -1.40212074e-01f, -1.58478364e-01f,
  7.38251284e-02f, -3.57703418e-02f, 1.00857718e-02f, 6.88623823e-03f, 6.66117370e-02f, 1.00205369e-01f, 2.45729089e-02f, -1.05618708e-01f, -9.62464139e-02f, 2.98856422e-02f,
  -9.86189395e-02f, -1.37547553e-01f, -5.54928482e-02f, -9.67282280e-02f, 1.14529818e-01f, -4.16756794e-03f, 7.56835788e-02f, 9.29628126e-03f, 4.28237505e-02f, -1.46563739e-01f,
  -1.06384471e-01f, -3.08850538e-02f, 9.65394750e-02f, -9.02538523e-02f, -6.80559650e-02f, 3.22417505e-02f, -4.26561646e-02f, -7.94444382e-02f, -4.88787964e-02f, -7.76372850e-02f,
  -9.45453420e-02f, 3.08328625e-02f, 1.13751613e-01f, 4.99654263e-02f, -4.00933437e-02f, -2.22333567e-03f, 4.22528833e-02f, 5.16941957e-02f, 1.02748394e-01f, -3.96462828e-02f,
  1.66862998e-02f, 4.24341187e-02f, -4.47232313e-02f, -3.54027376e-02f, 6.29695654e-02f, -3.28089967e-02f, 3.99577990e-02f, -3.90666872e-02f, 1.24004364e-01f, 7.01706782e-02f,
  1.64999964e-03f, 6.72675967e-02f, -2.05645617e-02f, -1.11320913e-01f, -5.02459332e-02f, 1.59137547e-02f, 8.41961205e-02f, 3.80472466e-02f, 2.40336973e-02f, 4.56545055e-02f,
  3.62086855e-02f, -2.06166357e-02f, -4.75422665e-02f, 1.19190721e-03f, -8.56088400e-02f, 9.03241336e-02f, -1.08346656e-01f, -8.07703361e-02f, -6.33962899e-02f, 4.96858805e-02f,
  2.25702580e-02f, -3.07922792e-02f, -3.73225845e-02f, -6.41155569e-03f, -4.81653959e-03f, 1.16023652e-01f, -5.18950447e-02f, 3.89348622e-03f, 1.22838497e-01f, -1.54008180e-01f,
  -2.68491246e-02f, 9.27510560e-02f, -6.92155883e-02f, 2.17562169e-02f, -7.91749638e-03f, 3.18728760e-02f, 4.85275406e-03f, -4.51887399e-02f, -5.75835556e-02f, -8.66176412e-02f,
  -9.74132121e-02f, 1.11616030e-01f, -2.11504340e-01f, -1.40416935e-01f, 1.49918422e-01f, 1.99104249e-02f, 1.12373337e-01f, 1.63508147e-01f, -2.13064656e-01f, 2.11684167e-01f,
  4.15606163e-02f, -1.31735474e-01f, -9.89645869e-02f, -3.69427465e-02f, -8.34285840e-02f, -1.78395472e-02f, 1.12235248e-01f, 9.90068316e-02f, -1.12540618e-01f, 6.23185448e-02f,
  -1.51965590e-02f, 2.00092643e-02f, -8.88943151e-02f, 1.10848425e-02f, 7.74500296e-02f, 7.66938413e-03f, 1.65190101e-01f, -8.38723034e-02f, 8.25936571e-02f, -1.12667233e-01f,
  2.40903329e-02f, -5.80479838e-02f, 3.50396335e-02f, -8.41349885e-02f, -4.06492092e-02f, -6.50111446e-03f, 8.57860446e-02f, -6.98304325e-02f, 2.38742530e-02f, 4.82422598e-02f,
  5.53173646e-02f, -1.91892255e-02f, 3.03469170e-02f, -1.88656449e-02f, 1.05494566e-01f, -8.33358616e-02f, -3.83192934e-02f, 1.11082233e-01f, -4.33212034e-02f, -5.01963608e-02f,
  5.10556586e-02f, 7.03954548e-02f, 1.59090474e-01f, -1.03923064e-02f, 9.65782329e-02f, 9.99954045e-02f, 1.03546232e-01f, 9.18734670e-02f, 3.21252756e-02f, 1.38719186e-01f,
  -1.00909543e-04f, 1.24781825e-01f, 1.61332116e-02f, -1.23853320e-02f, -4.12686579e-02f, -4.97409329e-02f, 4.62391675e-02f, -9.54221338e-02f, -4.31742966e-02f, -8.58653039e-02f,
  -7.68428817e-02f, -3.98444533e-02f, -9.30887833e-02f, -6.19121548e-03f, 1.19574703e-01f, 2.59889779e-03f, 1.21195717e-02f, 2.29718219e-02f, -9.52075645e-02f, -1.66480094e-02f,
  -8.56650621e-02f, -5.14251627e-02f, -6.35431558e-02f, 6.81234971e-02f, -2.94950567e-02f, 1.17203966e-02f, -4.57642339e-02f, 1.71911046e-02f, 1.23824187e-01f, -7.63716772e-02f,
  9.43894982e-02f, 1.78998113e-02f, -9.14636180e-02f, -4.99024019e-02f, -3.82891595e-02f, -9.02099758e-02f, -8.56252685e-02f, -2.50649750e-02f, -9.13530514e-02f, -5.65871857e-02f,
  9.27035362e-02f, 1.48144543e-01f, -4.91359942e-02f, -7.30022863e-02f, 9.06910188e-03f, 5.96566722e-02f, -1.96722206e-02f, -1.28712486e-02f, -4.30346280e-02f, -8.22682306e-02f,
  1.15322620e-01f, 1.89007357e-01f, -9.05966293e-03f, 5.80224171e-02f, 7.62290284e-02f, 9.98201594e-02f, 1.51370827e-03f, 6.18226677e-02f, -1.44321129e-01f, -2.10417043e-02f,
  -1.34694859e-01f, 7.19494745e-02f, -8.91332328e-02f, -2.04313189e-01f, -8.10599774e-02f, -8.70781094e-02f, -2.00496629e-01f, -7.60369375e-02f, 1.43750548e-01f, 1.11731149e-01f,
  -1.73249513e-01f, 7.05580637e-02f, 2.22187042e-01f, -6.70845881e-02f, -9.56183579e-03f, 2.48030663e-01f, -3.69290970e-02f, -6.67521683e-03f, 3.36957090e-02f, -4.62836213e-02f,
  -5.36088832e-02f, 1.92744248e-02f, 1.72364954e-02f, 1.16466999e-01f, -1.55658349e-01f, -7.54577443e-02f, -2.03603655e-01f, -8.59796926e-02f, -2.05244496e-01f, -1.90218568e-01f,
  -2.53916800e-01f, -1.97754964e-01f, -3.58262584e-02f, 2.89640259e-02f, -1.34422965e-02f, 1.23639908e-02f, -5.61357439e-02f, 5.16293896e-03f, -4.47861739e-02f, 1.09775864e-01f,
  4.37281467e-02f, 7.65430033e-02f, 1.89826600e-02f, -9.80781484e-03f, -2.36971937e-02f, 2.39703897e-02f, -8.58676359e-02f, -9.19075459e-02f, -5.37654981e-02f, -9.64368461e-04f,
  4.98616099e-02f, 6.58550188e-02f, 9.76486038e-03f, -6.03653006e-02f, -7.09360763e-02f, -1.02657467e-01f, -2.42132302e-02f, -5.80511093e-02f, -1.57302264e-02f, -8.44138023e-03f,
  8.98042247e-02f, -2.10715346e-02f, -8.71411636e-02f, -1.41363721e-02f, -3.03588714e-02f, 1.89229026e-02f, -2.11921502e-02f, -6.60947636e-02f, 5.68228327e-02f, -2.37171240e-02f,
  -1.05804339e-01f, -4.68654782e-02f, -2.58287555e-03f, -6.00122800e-03f, 4.28978391e-02f, 2.02516858e-02f, 3.95958461e-02f, -1.02600055e-02f, 5.57659566e-02f, 1.04529383e-02f,
  7.02521503e-02f, -8.43257904e-02f, 7.19893873e-02f, -5.26378378e-02f, -1.59418229e-02f, -8.42467621e-02f, 5.88700473e-02f, -6.73477352e-03f, 6.96264803e-02f, -8.32244158e-02f,
  -1.69216990e-01f, -8.00630227e-02f, 5.13049848e-02f, 4.50874679e-02f, 2.31502037e-02f, 3.07722725e-02f, -3.77580449e-02f, 5.02170697e-02f, -1.28016368e-01f, -9.62317456e-03f,
  -6.87292814e-02f, 6.40708432e-02f, -3.69776823e-02f, 2.28649303e-02f, 1.30205557e-01f, -8.77865106e-02f, -1.08423181e-01f, 4.87046316e-02f, -1.74347851e-02f, 8.08150470e-02f,
  3.39757912e-02f, -7.47919502e-03f, -2.66112550e-03f, 7.19104409e-02f, 6.66708732e-03f, -5.01309186e-02f, -4.99403626e-02f, 5.46394624e-02f, -1.12669021e-01f, -2.05339044e-02f,
  -3.70986789e-01f, 3.57184932e-02f, 2.82140970e-01f, -2.81366706e-01f, 2.13029653e-01f, 1.61028951e-01f, -1.09004201e-02f, 7.80536309e-02f, -4.40206937e-02f, -1.45524174e-01f,
  -1.63569078e-01f, 3.19015048e-02f, 5.66723831e-02f, -1.18012704e-01f, -1.14723928e-02f, -2.87409052e-02f, -6.99247718e-02f, -1.33917518e-02f, 1.78545173e-02f, 7.16979727e-02f,
  -2.28183642e-02f, -3.37373465e-02f, -1.19150719e-02f, 1.28642797e-01f, 1.49646578e-02f, -2.93107312e-02f, -1.69057727e-01f, 2.11539000e-01f, 6.70337677e-03f, 1.60119776e-02f,
  -2.22491503e-01f, -1.10938139e-01f, -1.37574553e-01f, 7.05414712e-02f, 1.77547410e-02f, -8.99555013e-02f, -4.23135608e-03f, 1.51452109e-01f, -7.38810971e-02f, 5.16324528e-02f,
  7.69994259e-02f, -3.75081506e-03f, -9.95670632e-02f, 1.69561077e-02f, 2.35966919e-03f, -6.51189638e-03f, 1.23977646e-01f, 6.97491691e-02f, 1.26580568e-02f, 1.61772922e-01f,
  1.41663730e-01f, 4.36444879e-02f, -1.51928067e-01f, -1.26164123e-01f, 1.94128081e-02f, -5.62071279e-02f, -7.63892531e-02f, 9.07081142e-02f, -4.44070473e-02f, -9.10684839e-02f,
  9.50343907e-02f, 2.98506318e-04f, 4.69539352e-02f, -1.76442899e-02f, -5.79610206e-02f, -4.44702283e-02f, -4.71852310e-02f, 1.40803903e-02f, -1.44294783e-01f, 1.33546703e-02f,
  -8.36776048e-02f, 4.38883491e-02f, -2.95398291e-03f, -2.97481865e-02f, -4.95979041e-02f, -8.13897550e-02f, 2.89747640e-02f, -5.02457982e-03f, -5.47333248e-02f, 4.55277003e-02f,
  -4.90386505e-03f, 4.84938882e-02f, 5.86073287e-02f, -7.67048970e-02f, 8.27606246e-02f, -6.87884018e-02f, -1.34708034e-02f, 8.26619938e-02f, 1.03063155e-02f, 8.51849467e-02f,
  -2.99428403e-01f, -2.03738406e-01f, -1.44635990e-01f, -1.07726932e-01f, -1.55473622e-02f, 6.38502389e-02f, -8.98427665e-02f, -9.19209346e-02f, -4.02593426e-02f, 3.92985828e-02f,
  -5.73328249e-02f, 2.64241770e-02f, 6.12310097e-02f, -2.95051523e-02f, -5.29292636e-02f, -7.94351920e-02f, -6.65021762e-02f, 2.04820409e-02f, -5.56547614e-03f, -1.14748068e-01f,
  -1.26051635e-01f, -1.32014409e-01f, -9.46798399e-02f, -9.05503929e-02f, 5.71220592e-02f, -1.20012514e-01f, 9.93992761e-03f, -8.55326951e-02f, 4.92687561e-02f, -8.17935541e-02f,
  -1.85985804e-01f, 1.43680319e-01f, -1.55729726e-01f, 3.39498073e-02f, -1.17055021e-01f, -1.36525810e-01f, -1.05219655e-01f, 1.35145131e-02f, -2.10656106e-01f, 8.87135118e-02f,
  1.07266672e-01f, -1.58782810e-01f, 1.61953121e-02f, 1.47671074e-01f, -7.96653181e-02f, -1.72959611e-01f, -2.78608166e-02f, 1.12579465e-02f, -1.99187081e-02f, 7.62324929e-02f,
  8.32156986e-02f, 2.08042681e-01f, -1.86088367e-03f, 1.09845214e-01f, 5.67532703e-02f, 1.00067399e-01f, 1.19356528e-01f, 6.78762496e-02f, 1.57068953e-01f, 4.61300276e-02f,
  6.30095899e-02f, 5.89006878e-02f, -1.04994446e-01f, -5.42808734e-02f, 4.92015034e-02f, 1.22758653e-02f, -7.18567222e-02f, -1.15216799e-01f, 3.34924832e-02f, 7.80259073e-02f,
  -4.08174992e-02f, 8.60370621e-02f, -2.95883548e-02f, 7.38285109e-02f, 1.07876956e-01f, -5.14798164e-02f, -5.86407296e-02f, -1.02598228e-01f, 3.28185968e-02f, 6.09944426e-02f,
  1.34126469e-02f, 1.50897540e-02f, -3.34280990e-02f, -6.26478642e-02f, -4.84881178e-02f, 4.30595912e-02f, 6.58472627e-02f, -4.76109609e-02f, 6.47034310e-03f, 4.12813313e-02f,
  1.02833346e-01f, -1.02372989e-01f, 7.65117854e-02f, -1.50144309e-01f, -6.37031393e-03f, -1.12911628e-03f, -2.14294158e-02f, -7.79069513e-02f, 2.76398230e-02f, 6.37617260e-02f,
  -7.51715014e-03f, 1.45709310e-02f, -4.46677096e-02f, -3.77975334e-03f, -3.87877114e-02f, 3.37874368e-02f, 3.64409164e-02f, 1.50315478e-01f, -7.45825693e-02f, -4.36784923e-02f,
  -4.07394348e-03f, 8.49521160e-02f, -4.24992181e-02f, -6.77171275e-02f, -6.23201281e-02f, 8.59172344e-02f, -2.77221799e-02f, -4.91717644e-02f, 5.18912822e-03f, -1.29994497e-01f,
  4.97971028e-02f, 1.34815186e-01f, 2.95347255e-03f, -4.06013317e-02f, 1.35443322e-02f, -5.21012805e-02f, -2.96466146e-02f, 2.97089554e-02f, 9.42644924e-02f, 2.14486979e-02f,
  1.12793297e-01f, 5.92451096e-02f, -5.62419533e-04f, 9.81314406e-02f, 7.74766952e-02f, 4.15456295e-02f, 8.05950761e-02f, -6.73175752e-02f, 2.36569420e-02f, 1.57697126e-01f,
  2.20475569e-02f, -3.88535410e-02f, 2.94058416e-02f, -1.42191216e-01f, -4.62633558e-03f, -5.06707467e-03f, 1.48581546e-02f, -8.16299114e-03f, 1.37260929e-02f, -2.64348760e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 52)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 52;
const float L0_fan_Bp_bar_data[] = {
  2.46274456e-01f, 1.16072148e-01f, 1.81399480e-01f, 1.58002585e-01f, 1.47530749e-01f, 2.64694542e-01f, 1.76607579e-01f, 1.47920445e-01f, 5.41172326e-02f, 1.51139736e-01f,
  1.38681396e-04f, 2.84963816e-01f, 2.59071440e-01f, 1.89462975e-01f, 1.81965366e-01f, 7.18746111e-02f, 1.66907355e-01f, 1.08760372e-01f, 1.51716232e-01f, 1.69457585e-01f,
  2.25237161e-01f, 2.17777878e-01f, 2.71627218e-01f, -3.11068352e-02f, 1.65665537e-01f, 1.62484452e-01f, 1.12307318e-01f, 5.81027605e-02f, 2.51687765e-01f, 1.65497512e-01f,
  1.48402020e-01f, 6.89557493e-02f, 1.53400704e-01f, 2.03843147e-01f, 9.21788663e-02f, 2.29348868e-01f, 1.91378057e-01f, 1.35110483e-01f, 1.13880113e-01f, 1.62260711e-01f,
  1.98740393e-01f, 9.87625346e-02f, 1.33619994e-01f, 1.64428875e-01f, 1.16576597e-01f, 2.11423531e-01f, 2.00986341e-01f, 2.98503339e-01f, 5.66347204e-02f, 6.28794730e-02f,
  1.86552942e-01f, 1.28542632e-01f
};

// L1_fan_Wp (Shape: 6 x 64)
const int L1_fan_Wp_rows = 6;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  1.00451510e-03f, 3.01303510e-02f, 1.44456457e-02f, -8.46607387e-02f, 1.46956548e-01f, 3.54750804e-03f, 6.83340356e-02f, -3.16921175e-02f, 1.73202157e-02f, -2.26975493e-02f,
  -2.26611540e-01f, -7.77321681e-03f, -1.44960836e-01f, 3.63544226e-02f, -3.26257974e-01f, 2.71522939e-01f, -3.60971577e-02f, 4.84362291e-03f, 5.97059838e-02f, -2.59805080e-02f,
  1.78190529e-01f, -1.35682479e-01f, 1.55825585e-01f, 1.98594868e-01f, 9.86818671e-02f, -1.97345152e-01f, 2.14001462e-01f, 3.12313326e-02f, -1.30674377e-01f, -1.50828853e-01f,
  6.30531386e-02f, -1.55205995e-01f, -1.56741813e-02f, -1.35935277e-01f, -9.69194919e-02f, -1.80299163e-01f, -1.85402155e-01f, -1.66961864e-01f, -9.52154547e-02f, 2.52229303e-01f,
  3.36971916e-02f, -2.52577420e-02f, -4.14541773e-02f, -2.83870045e-02f, 8.68419930e-03f, -2.53687259e-02f, 1.60347372e-01f, -8.69068727e-02f, -6.47879913e-02f, 1.00379393e-01f,
  -1.93582565e-01f, -1.56001568e-01f, -2.10790172e-01f, 6.60416782e-02f, -2.75215358e-01f, -1.25726620e-02f, 3.22588719e-02f, -9.64796245e-02f, 4.08319756e-02f, -1.44936563e-02f,
  3.50840613e-02f, -1.65296197e-02f, -1.27751142e-01f, -4.27842140e-02f, 6.78732693e-02f, 1.35026276e-01f, 6.89401105e-02f, 1.09582379e-01f, -7.62928352e-02f, -1.35456286e-02f,
  9.70512033e-02f, -1.37428939e-01f, -8.57738405e-02f, -7.42513910e-02f, 1.07516594e-01f, 1.99535047e-03f, 1.51306212e-01f, -1.20979577e-01f, 2.38687128e-01f, -1.18494317e-01f,
  -1.44620195e-01f, 3.11986543e-02f, -5.49931936e-02f, 3.31393518e-02f, -4.93497774e-02f, -8.21712464e-02f, -7.85624161e-02f, -2.77452637e-02f, 7.46884197e-02f, -1.09423734e-01f,
  -3.80478799e-02f, 1.77436456e-01f, 5.42609878e-02f, 9.11730826e-02f, 5.12317233e-02f, 3.89417820e-02f, 3.60629596e-02f, -1.12394042e-01f, -3.31527479e-02f, -7.64070824e-02f,
  2.39892453e-02f, 2.23658886e-02f, 1.21139750e-01f, -7.94034675e-02f, -6.10135049e-02f, -1.63372040e-01f, 1.19067945e-01f, 1.74490914e-01f, -2.35846918e-02f, 4.03569564e-02f,
  1.65955171e-01f, -1.60924941e-02f, -5.81324734e-02f, 2.02626646e-01f, 6.15201294e-02f, -1.77543730e-01f, 1.51618831e-02f, 2.02484682e-01f, -2.17280108e-02f, 4.14394774e-02f,
  7.54459202e-02f, -1.66788343e-02f, -2.18570203e-01f, 1.67374045e-01f, 1.58699289e-01f, -1.03500955e-01f, 8.58436674e-02f, -5.26613742e-02f, 1.13434605e-01f, 4.39756346e-04f,
  -4.55645360e-02f, -1.05753178e-02f, -7.81426430e-02f, -9.75463167e-02f, -1.32820427e-01f, 1.56717733e-01f, 1.92112222e-01f, -5.10474779e-02f, -8.75634104e-02f, -1.76218175e-03f,
  -6.87907934e-02f, 9.55859423e-02f, -1.33221328e-01f, 1.56896546e-01f, 1.59253001e-01f, -8.76313895e-02f, 2.19022840e-01f, -2.77075134e-02f, -1.14030361e-01f, -9.63952765e-02f,
  1.76600605e-01f, 2.81391609e-02f, 7.88277611e-02f, 9.54032093e-02f, 1.12263605e-01f, 1.05616208e-02f, -6.94776103e-02f, -2.65623212e-01f, -9.10332426e-02f, -1.86750144e-02f,
  -1.12719648e-01f, -6.62346557e-02f, -7.79545233e-02f, 1.24684898e-02f, -1.56560630e-01f, 9.61035639e-02f, -1.12524435e-01f, 3.11619528e-02f, 2.33342126e-01f, 1.68606400e-01f,
  -1.54912710e-01f, -3.48665230e-02f, -2.73591932e-03f, -9.87028033e-02f, -8.51870254e-02f, -1.75858736e-01f, -7.95377605e-03f, -2.02752754e-01f, -2.87112985e-02f, 6.50210753e-02f,
  -1.93678901e-01f, -3.00583038e-02f, -6.99334815e-02f, -1.96001250e-02f, -1.60436511e-01f, -4.75422181e-02f, 1.36713520e-01f, -1.58778951e-01f, -3.42930388e-03f, 1.55282900e-01f,
  9.33021754e-02f, 2.40296312e-02f, -7.45843956e-03f, 1.41226485e-01f, -2.76339408e-02f, 5.81920668e-02f, 1.21678993e-01f, -8.15181732e-02f, 4.80219275e-02f, 2.17225730e-01f,
  -8.19932073e-02f, -6.66863322e-02f, 7.33356625e-02f, -1.34139210e-01f, -1.68408945e-01f, -1.00264981e-01f, -1.79266244e-01f, 2.34817624e-01f, 1.00650124e-01f, 2.65604556e-02f,
  -1.47173926e-01f, -1.23243414e-01f, 1.21302851e-01f, -6.48838729e-02f, 2.10623696e-01f, 1.36471584e-01f, 1.27328292e-01f, -1.89534232e-01f, 2.03099459e-01f, 5.77063225e-02f,
  -1.14801034e-01f, -2.75925368e-01f, -1.01749882e-01f, -5.18775284e-02f, -1.63344100e-01f, -1.06273666e-01f, 9.66577530e-02f, 2.08381712e-01f, -2.02198595e-01f, 1.24037594e-01f,
  -1.50054827e-01f, 1.01869613e-01f, 2.43320376e-01f, 2.62329187e-02f, -1.97502170e-02f, 2.38348525e-02f, 6.59472197e-02f, 9.48428139e-02f, 2.83924192e-01f, -9.39152241e-02f,
  -8.50898549e-02f, -9.33352187e-02f, 2.27134243e-01f, -1.49740145e-01f, -1.60425216e-01f, -2.79088300e-02f, -1.44560829e-01f, -1.72697529e-01f, -2.26416886e-01f, -1.33688137e-01f,
  -9.52183232e-02f, 7.51341507e-02f, 1.78575322e-01f, 5.96475080e-02f, -2.98302948e-01f, 1.52113721e-01f, -2.47415397e-02f, -1.79551572e-01f, -1.33421244e-02f, 5.71634211e-02f,
  -1.26966476e-01f, -2.46741939e-02f, -1.25853986e-01f, 9.04009417e-02f, -6.53667003e-02f, 1.36473924e-01f, -6.40970096e-02f, -3.25117595e-02f, 2.09533926e-02f, -1.54986814e-01f,
  1.45695210e-02f, -1.07278690e-01f, -1.37962475e-01f, 1.53836519e-01f, -1.51046067e-01f, 2.41246466e-02f, 1.04060553e-01f, 5.92680126e-02f, 4.02398501e-03f, 9.82154459e-02f,
  7.17989057e-02f, 2.28472307e-01f, 1.01695292e-01f, -8.61022845e-02f, 9.48508829e-02f, -1.76522508e-01f, 1.58972725e-01f, 1.76432714e-01f, -1.69376284e-01f, -2.18670011e-01f,
  2.58618258e-02f, 2.64838021e-02f, -2.44791731e-01f, -6.10304996e-02f, 8.11961144e-02f, 8.06593969e-02f, 6.59286603e-02f, 2.50784699e-02f, 1.68105830e-02f, -1.85319036e-02f,
  -3.69958058e-02f, -5.25935814e-02f, 1.15130030e-01f, -5.81876747e-02f, 6.70591816e-02f, 2.10751936e-01f, -5.19507378e-03f, -1.52213857e-01f, -2.02728689e-01f, -1.41736746e-01f,
  1.36620447e-01f, -1.17773719e-01f, 1.16890468e-01f, -2.02056870e-01f, -2.50997525e-02f, -1.85404029e-02f, 2.04516768e-01f, -2.37939898e-02f, -3.60125862e-02f, 1.22930914e-01f,
  -9.20605510e-02f, -1.50202453e-01f, 6.48401007e-02f, -1.01875499e-01f, -1.69969171e-01f, -1.21949278e-02f, -1.09346241e-01f, -1.13207832e-01f, -1.19719848e-01f, 1.64034680e-01f,
  9.88103375e-02f, -8.61641318e-02f, 5.10122962e-02f, -6.36798888e-02f, 7.81388655e-02f, -1.99159503e-01f, 1.42928451e-01f, 1.81933224e-01f, -2.38038570e-01f, 3.31620313e-02f,
  4.83425185e-02f, 5.24600185e-02f, 1.84004784e-01f, -7.13994056e-02f, -8.57012197e-02f, -8.87959749e-02f, 2.32598230e-01f, -9.45850164e-02f, 1.90011188e-01f, -5.56286760e-02f,
  -1.67301372e-02f, 2.34410480e-01f, -1.47166908e-01f, -1.91833511e-01f, -1.30117252e-01f, 6.02476820e-02f, -3.27114426e-02f, 6.26075417e-02f, 1.71916530e-01f, 1.34672195e-01f,
  1.07048132e-01f, 1.48099348e-01f, -7.22597092e-02f, -9.14997682e-02f, 6.14118055e-02f, -4.94561009e-02f, 2.02491470e-02f, -6.27950653e-02f, 5.37459850e-02f, -3.37853469e-02f,
  2.53098071e-01f, -1.02498136e-01f, -4.23398521e-03f, -1.23912953e-01f, 1.52738169e-01f, 1.27749085e-01f, -1.86782658e-01f, -1.14823170e-02f, -6.57516122e-02f, -6.55223131e-02f,
  -2.98748426e-02f, 1.15497649e-01f, -1.07203163e-01f, 5.11550419e-02f
};

// L1_fan_Wp_bar (Shape: 52 x 64)
const int L1_fan_Wp_bar_rows = 52;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  1.35019690e-01f, 2.71985363e-02f, -1.61777306e-02f, 1.40678674e-01f, 1.52764097e-01f, 1.72756359e-01f, -2.10571826e-01f, 1.32259190e-01f, -1.77582249e-01f, 6.37977049e-02f,
  -3.08711946e-01f, 1.22631565e-01f, 2.71496236e-01f, 8.26902390e-02f, -9.97416154e-02f, -7.64399394e-02f, -1.03244275e-01f, 2.62369096e-01f, 1.00943767e-01f, -1.28636569e-01f,
  -1.70192361e-01f, -2.23429501e-01f, -1.89789623e-01f, 5.48872836e-02f, -1.80236235e-01f, 3.35970640e-01f, -2.61518121e-01f, -2.27134842e-02f, 1.46676958e-01f, -2.48581260e-01f,
  2.52337545e-01f, 2.14786589e-01f, -1.57910123e-01f, -2.12134361e-01f, -4.90036095e-04f, 1.72701403e-01f, -1.55736879e-01f, -3.25553771e-03f, 3.02922517e-01f, -1.45280361e-01f,
  1.74113959e-01f, 8.21980927e-03f, -1.18417479e-01f, -2.75118705e-02f, 7.60492235e-02f, 2.11866096e-01f, -3.54187131e-01f, -8.22241008e-02f, 7.63597786e-02f, 9.41976160e-02f,
  1.15439761e-03f, 2.28979528e-01f, -2.49711722e-01f, -8.95383880e-02f, 1.73467144e-01f, -1.36658013e-01f, 2.03242093e-01f, 9.23850089e-02f, 4.69275452e-02f, 1.53736264e-01f,
  3.31013352e-02f, 4.63616960e-02f, 2.47437030e-01f, 2.12491050e-01f, 2.69203573e-01f, 1.09226204e-01f, 1.97452307e-01f, 1.98999226e-01f, 2.43126564e-02f, 2.60710359e-01f,
  -2.58266240e-01f, 1.64645538e-01f, -1.19311757e-01f, 1.72659401e-02f, 2.78386086e-01f, 7.32129589e-02f, 3.08916867e-01f, 9.56413373e-02f, 1.87134877e-01f, -4.03207354e-02f,
  3.33899371e-02f, 1.29020423e-01f, -5.73401451e-02f, -4.79598455e-02f, 8.14730767e-03f, 4.94714864e-02f, 1.10589206e-01f, -3.58721912e-02f, 1.72475025e-01f, 2.43732154e-01f,
  -1.51226118e-01f, 7.10745156e-02f, 2.28631511e-01f, 5.60725480e-03f, 1.47063315e-01f, 3.73421639e-01f, 2.47237131e-01f, -3.50455344e-02f, 1.25036016e-01f, 2.24556416e-01f,
  1.78185910e-01f, -1.10890873e-01f, 2.12037176e-01f, -1.22705184e-01f, -5.63862771e-02f, 3.03378612e-01f, 1.72630668e-01f, 1.09190747e-01f, -1.29148975e-01f, -8.03400204e-02f,
  -1.67693138e-01f, 7.29239509e-02f, -5.47315590e-02f, 1.32282734e-01f, 9.97920781e-02f, 1.56360745e-01f, -3.43161747e-02f, -2.72935480e-01f, 1.95730448e-01f, 5.76840229e-02f,
  1.24418564e-01f, 8.30212012e-02f, 8.15974399e-02f, 1.58430308e-01f, 4.74071950e-02f, -1.11629412e-01f, 1.76015511e-01f, 1.27334431e-01f, 1.02530591e-01f, 1.98643357e-01f,
  3.15301642e-02f, 8.85774419e-02f, 1.79373503e-01f, 5.76406606e-02f, 1.51575208e-01f, -6.58764616e-02f, -2.50259131e-01f, -1.53537616e-01f, 9.83256474e-02f, -1.54663935e-01f,
  7.39683285e-02f, -1.22965440e-01f, 2.27607399e-01f, -1.20560601e-01f, 1.84691131e-01f, 1.70866579e-01f, 4.30522040e-02f, -2.72027142e-02f, -3.30477320e-02f, -6.98095560e-02f,
  -2.25893650e-02f, 1.95277259e-02f, 1.27197966e-01f, -2.02371657e-01f, -4.10106406e-02f, 1.77733451e-02f, -5.60735352e-02f, -1.18237190e-01f, -2.42604539e-02f, -2.19719827e-01f,
  1.30662486e-01f, -1.30503416e-01f, 1.84202641e-02f, -1.46670595e-01f, 3.53080332e-01f, 1.71271905e-01f, 2.19995007e-01f, -1.09658509e-01f, 5.64047880e-02f, -1.45548731e-01f,
  7.29390830e-02f, 2.04789504e-01f, -1.59111694e-01f, -1.84606966e-02f, 1.97948918e-01f, 2.83857256e-01f, 1.53722003e-01f, 8.25110301e-02f, 2.00830042e-01f, -7.54986033e-02f,
  -6.66362420e-02f, 3.24220181e-01f, -1.02678118e-02f, -9.01271179e-02f, -9.77274925e-02f, 2.91905820e-01f, -1.52493820e-01f, 3.10072117e-02f, 6.98881596e-02f, 1.12267382e-01f,
  1.52727887e-01f, 1.06080249e-01f, 8.85672197e-02f, 2.29685962e-01f, 2.19761908e-01f, 2.44896814e-01f, 2.25124452e-02f, 1.46306947e-01f, -2.02769905e-01f, -2.35359654e-01f,
  -6.18350459e-03f, 6.89152032e-02f, 7.14817643e-02f, 1.22035854e-02f, 8.30361843e-02f, -1.46646261e-01f, 9.95963216e-02f, -5.70004955e-02f, 2.52508342e-01f, 1.62751704e-01f,
  -1.50475189e-01f, 1.34577751e-01f, -6.63404614e-02f, 2.07781360e-01f, 2.19375536e-01f, 3.35164592e-02f, 7.58128054e-03f, -5.38367406e-02f, 2.18098700e-01f, -2.22863033e-02f,
  1.89419985e-01f, 5.19431494e-02f, 3.37183401e-02f, 3.13301414e-01f, 2.60062158e-01f, -4.46969233e-02f, -1.25967547e-01f, 2.71779805e-01f, 3.27752650e-01f, 2.32729256e-01f,
  5.77405244e-02f, 1.43601149e-01f, 2.27802321e-02f, 1.14108235e-01f, 1.13874115e-01f, 1.00172698e-01f, 6.01936504e-02f, 2.26354197e-01f, 1.17196210e-01f, 2.86090076e-01f,
  1.82464167e-01f, 1.26261666e-01f, 2.39278391e-01f, -5.18020615e-02f, 1.12183489e-01f, 1.30030319e-01f, 1.31122246e-01f, 2.09221631e-01f, 2.07760468e-01f, 1.18955977e-01f,
  -3.39558534e-02f, 2.87437774e-02f, -3.98929678e-02f, 2.40646675e-02f, 2.18480840e-01f, 2.65631437e-01f, 1.66666329e-01f, 7.85449520e-03f, 2.08860621e-01f, 1.53946608e-01f,
  4.59695198e-02f, -5.05181253e-02f, -2.82668718e-03f, -1.89503729e-01f, -2.31783506e-05f, 7.34417737e-02f, 2.66989112e-01f, -1.80101812e-01f, 2.76927888e-01f, -2.05738902e-01f,
  8.13408419e-02f, -4.50176671e-02f, 7.68803284e-02f, -1.03504814e-01f, -8.29208419e-02f, 2.13547409e-01f, 9.46837515e-02f, 1.85863540e-01f, 2.11556062e-01f, 8.21357518e-02f,
  4.91426066e-02f, 4.20084856e-02f, -8.83378088e-03f, 1.12054106e-02f, 2.38870725e-01f, -3.48951779e-02f, 3.43030021e-02f, 1.11055486e-01f, 4.81447577e-02f, -1.43113174e-02f,
  1.94484457e-01f, 9.66222212e-02f, -2.38929152e-01f, -1.06132254e-01f, 7.92862996e-02f, 8.33560899e-02f, -1.52630266e-02f, 6.19326904e-02f, 2.72235930e-01f, 1.15729123e-01f,
  -7.86673091e-03f, 9.06460881e-02f, 1.29982099e-01f, -8.64868015e-02f, 9.15670246e-02f, 2.24917382e-01f, 1.19734205e-01f, -2.07294390e-01f, -5.12993708e-03f, -1.62568748e-01f,
  9.91601944e-02f, 3.25133726e-02f, 4.96919565e-02f, 1.55210095e-02f, 9.45682824e-02f, -1.48113361e-02f, 3.73769179e-02f, 6.90342812e-03f, -1.16859883e-01f, 1.98111296e-01f,
  1.90737128e-01f, 1.47082344e-01f, 5.65190129e-02f, 1.00898091e-02f, 2.63357818e-01f, 1.63292170e-01f, 2.01634482e-01f, 1.60736412e-01f, -2.17059683e-02f, -6.61307722e-02f,
  2.44471893e-01f, -2.40310609e-01f, -7.44909793e-02f, -1.58632144e-01f, 7.83917978e-02f, 2.31246561e-01f, 2.43284643e-01f, -1.50698498e-01f, 1.75351009e-01f, -7.07323179e-02f,
  1.98090583e-01f, 3.79718617e-02f, 1.46550745e-01f, 2.89203674e-01f, 1.42367646e-01f, -2.01591581e-01f, 5.73058706e-03f, 8.07369500e-02f, 1.07521154e-01f, 9.54450574e-03f,
  -2.26344373e-02f, -1.20648146e-02f, 3.16819310e-01f, 1.19629413e-01f, 1.80964604e-01f, 1.44675508e-01f, 3.04876417e-01f, 1.03517704e-01f, -1.94427639e-01f, -5.54320030e-02f,
  -8.63856524e-02f, -3.31686139e-02f, -6.17847666e-02f, -4.01442088e-02f, -1.28885031e-01f, -1.79996304e-02f, 1.55385569e-01f, 2.36031219e-01f, 2.32290011e-02f, -2.15457737e-01f,
  7.72166774e-02f, -7.69126490e-02f, -6.86110780e-02f, 9.85700861e-02f, 6.27626404e-02f, -1.53248310e-01f, 2.57276613e-02f, 2.34775767e-01f, 1.03079900e-01f, -8.83963183e-02f,
  -1.17035545e-01f, 3.25969607e-03f, 1.15620330e-01f, -5.81599176e-02f, 1.38184205e-01f, 1.26618370e-01f, 1.32255614e-01f, 1.02774143e-01f, -2.66759917e-02f, 1.39799669e-01f,
  9.90701318e-02f, 7.69277336e-03f, -1.00875258e-01f, -1.46682054e-01f, -2.21974969e-01f, 1.29723221e-01f, -2.23662376e-01f, -1.12521369e-02f, -1.65864393e-01f, 7.91927986e-03f,
  5.66390343e-02f, 2.86759824e-01f, -1.78440325e-02f, -5.30142672e-02f, -1.68287367e-01f, 3.22082937e-01f, 1.22935325e-01f, 1.47151574e-01f, -5.27217537e-02f, 5.45914769e-02f,
  1.49188176e-01f, -1.17147647e-01f, 2.31569171e-01f, -7.71313608e-02f, -7.21123740e-02f, 3.25715579e-02f, -1.52077926e-02f, -8.95508528e-02f, 5.31324698e-03f, -2.23791646e-03f,
  9.14855450e-02f, 2.54627824e-01f, 2.47265607e-01f, -9.82987732e-02f, 1.35177225e-01f, 1.83724210e-01f, -1.92937359e-01f, 1.19335584e-01f, 1.19143151e-01f, 1.94548294e-01f,
  1.41578214e-02f, 1.09573357e-01f, 2.48633713e-01f, 1.13096692e-01f, 2.10687190e-01f, 6.44055903e-02f, -2.28933301e-02f, 1.23218387e-01f, 9.55497995e-02f, 8.55953917e-02f,
  -1.13179579e-01f, 1.69899523e-01f, -1.03165619e-01f, -1.44060150e-01f, -1.83730200e-01f, 2.33202741e-01f, 2.67795920e-01f, 1.71028078e-01f, 2.39457965e-01f, 1.93475023e-01f,
  1.07275560e-01f, 1.11354955e-01f, 5.14843278e-02f, 1.65730938e-01f, -5.18697426e-02f, 5.67692611e-03f, -1.91943735e-01f, 1.61562264e-01f, -5.18124178e-02f, 1.66201144e-01f,
  1.98514745e-01f, -1.76608041e-01f, 4.38860198e-03f, 5.21471119e-03f, -2.12708712e-01f, 9.33830068e-02f, -4.17990237e-02f, 3.76535580e-02f, 2.08145559e-01f, 4.58605960e-02f,
  1.64788719e-02f, 7.21541746e-03f, 2.47129515e-01f, 1.40932456e-01f, 5.48816249e-02f, 2.17309847e-01f, 1.12217247e-01f, -1.08934797e-01f, 2.07001835e-01f, 2.93847978e-01f,
  -6.84882104e-02f, -3.23405057e-01f, 1.78482696e-01f, 1.43205121e-01f, -1.03485242e-01f, -2.21877813e-01f, 2.16128707e-01f, 9.79196802e-02f, 2.36461405e-02f, -1.06494889e-01f,
  2.38192812e-01f, 1.79510295e-01f, 3.92092727e-02f, 1.29890680e-01f, 7.06137642e-02f, 1.38849793e-02f, 3.24196108e-02f, 1.76498830e-01f, -7.06342235e-02f, -1.82844281e-01f,
  -1.09579854e-01f, -3.34392339e-02f, 9.49603170e-02f, 1.35526270e-01f, 6.81428909e-02f, 8.62105116e-02f, 7.98995644e-02f, -4.62035750e-05f, 9.33632404e-02f, -8.34854096e-02f,
  1.70924500e-01f, 2.13977247e-01f, 1.20557798e-02f, 1.87950835e-01f, 1.94369659e-01f, 1.57079890e-01f, 2.49706954e-01f, 2.72145391e-01f, -7.56190643e-02f, 1.34212717e-01f,
  4.44859900e-02f, -2.57701408e-02f, -5.08500189e-02f, 2.15096205e-01f, 1.55943707e-01f, 4.14534897e-01f, -5.28574623e-02f, 4.28860299e-02f, -1.11948356e-01f, 2.10659653e-01f,
  2.90340245e-01f, 1.20041005e-01f, 6.08940795e-02f, -2.24304229e-01f, -1.59750193e-01f, -1.20840415e-01f, -2.80952780e-03f, 1.60236597e-01f, -7.83507824e-02f, -8.96364674e-02f,
  -8.30537975e-02f, 8.83730501e-02f, 2.67043829e-01f, -1.64931640e-01f, 8.59186798e-02f, 3.45092088e-01f, 2.34122500e-01f, -8.69632810e-02f, 1.04412496e-01f, -9.55367982e-02f,
  -5.95895387e-02f, -7.68345892e-02f, 3.10744382e-02f, 1.45046368e-01f, 1.35524403e-02f, -1.03315420e-01f, -1.08819138e-02f, 9.55448896e-02f, -1.86958581e-01f, 1.35897383e-01f,
  -1.17383845e-01f, 1.47439372e-02f, -2.33262852e-01f, 1.86025336e-01f, 6.89059943e-02f, 8.99600238e-02f, -7.75632784e-02f, -9.51765329e-02f, 1.41206369e-01f, 1.43227056e-01f,
  1.77412450e-01f, 2.51618415e-01f, 1.44019574e-01f, -7.79198706e-02f, 1.05280250e-01f, -2.92017907e-02f, -1.06760234e-01f, 6.24167584e-02f, 3.72700542e-02f, 6.58609578e-03f,
  2.08761171e-02f, -2.82526221e-02f, 1.52428463e-01f, -1.64555073e-01f, 2.36311287e-01f, 2.69093197e-02f, 5.20809032e-02f, 1.62779823e-01f, -3.51584814e-02f, 9.37259272e-02f,
  -9.76651758e-02f, 1.85742468e-01f, 5.38275540e-02f, -9.92346779e-02f, 3.19605730e-02f, 2.02780202e-01f, 1.18727505e-01f, 2.24226385e-01f, -1.97733846e-02f, 1.86844647e-01f,
  9.92154628e-02f, 1.99868269e-02f, 1.52596802e-01f, 4.91130836e-02f, -5.60633987e-02f, 1.07389838e-01f, 6.32382324e-03f, -1.77002817e-01f, -4.59034964e-02f, 2.92591035e-01f,
  -1.00784628e-02f, -2.21220613e-01f, -1.29879922e-01f, 6.32722210e-03f, -1.21202566e-01f, 7.82922581e-02f, -2.98393723e-02f, -1.65662076e-02f, 1.32191822e-01f, -8.29468854e-03f,
  2.32345387e-01f, -1.42946646e-01f, -6.71931133e-02f, -1.57939404e-01f, 1.28003180e-01f, 1.73215583e-01f, -1.38841063e-01f, -7.62625933e-02f, 2.99040943e-01f, -5.32024056e-02f,
  -1.20377712e-01f, 2.60069072e-01f, 2.65567571e-01f, -2.44606912e-01f, 1.93368599e-01f, 1.10908009e-01f, -4.33472134e-02f, -3.91411074e-02f, 3.44169438e-02f, -3.82901654e-02f,
  2.31287166e-01f, 2.16991961e-01f, 1.41374320e-01f, 3.05607580e-02f, 7.43006542e-02f, -3.79935950e-02f, 5.13302386e-02f, 8.45746994e-02f, -1.20749362e-01f, -1.50027722e-02f,
  1.41888589e-01f, -2.75826842e-01f, 2.04124451e-01f, 5.69052622e-02f, 2.39385188e-01f, 1.87018011e-02f, 6.58300817e-02f, -2.29916960e-01f, -1.48679689e-01f, 1.21942386e-01f,
  8.86817090e-03f, -3.19289565e-02f, 5.34190908e-02f, -9.73181799e-02f, 8.93499795e-03f, -2.48932287e-01f, 1.37125492e-01f, 2.58225739e-01f, 2.12287083e-02f, 1.10312492e-01f,
  -9.30530429e-02f, 1.52059823e-01f, 2.05127075e-01f, 6.05594320e-03f, 7.56534263e-02f, -5.90175427e-02f, 1.53477639e-01f, 2.18505383e-01f, -1.36299236e-02f, -1.39100477e-01f,
  4.12770957e-02f, -3.32374312e-02f, -2.92147342e-02f, 2.14119703e-01f, 5.78292012e-02f, 8.26634988e-02f, 3.16372007e-01f, 1.58231512e-01f, -2.05604471e-02f, 7.46233538e-02f,
  1.39600709e-01f, -2.12661207e-01f, -7.08113192e-03f, 1.33437687e-03f, -1.00272842e-01f, -3.39157842e-02f, -7.65224546e-02f, 1.37159154e-01f, -8.55590850e-02f, 1.91678852e-01f,
  2.04112917e-01f, -6.85288906e-02f, -8.67609978e-02f, 2.01650313e-03f, 1.30399689e-01f, 8.49158317e-02f, 1.92314740e-02f, 9.60640833e-02f, -6.78134710e-02f, 2.17545152e-01f,
  -3.27454835e-01f, -1.44606568e-02f, 4.36169095e-02f, 8.88334289e-02f, -2.51344293e-01f, 2.10339859e-01f, 1.54450476e-01f, 6.74975216e-02f, -2.54236549e-01f, -1.08893991e-01f,
  1.20754734e-01f, 1.29501328e-01f, -6.97440580e-02f, 7.26433992e-02f, -3.38613778e-01f, 4.91857491e-02f, -3.02184280e-02f, -1.79131895e-01f, -1.46778032e-01f, 3.23112339e-01f,
  -5.88240363e-02f, -2.75702745e-01f, 2.89252728e-01f, -2.77380407e-01f, 1.05158113e-01f, 3.05614889e-01f, -5.23984283e-02f, 3.62281650e-02f, -3.98872793e-02f, 5.89751080e-02f,
  -1.98700681e-01f, 8.68987888e-02f, 1.33989125e-01f, 1.24971829e-01f, 2.64059216e-01f, 2.57004082e-01f, -3.05137523e-02f, 2.17598490e-02f, 1.64796084e-01f, 1.88730881e-01f,
  -1.75748900e-01f, -3.62480283e-02f, 1.51584521e-02f, 1.27365679e-01f, 1.00239776e-01f, 2.11251944e-01f, -2.57581949e-01f, -2.19793215e-01f, 2.16856942e-01f, 7.52958432e-02f,
  6.60187006e-02f, 2.88522802e-02f, 1.72594979e-01f, 1.87579557e-01f, 5.02616577e-02f, 1.61808819e-01f, 6.87568709e-02f, 1.92749962e-01f, 2.48409912e-01f, 1.87452808e-01f,
  1.75275311e-01f, 2.16686204e-02f, 2.00309634e-01f, 4.77551073e-02f, 2.78045148e-01f, 2.30753660e-01f, -8.66059437e-02f, -1.25995427e-01f, 1.15011998e-01f, -7.34505802e-02f,
  5.07752337e-02f, -1.23095378e-01f, 2.12091282e-01f, 2.76355475e-01f, -1.34908808e-02f, -1.62126496e-01f, 1.83170363e-01f, 1.69251710e-02f, 2.60784030e-01f, 6.17901571e-02f,
  1.67210754e-02f, 3.10939401e-01f, 1.93152443e-01f, -3.14557165e-01f, -1.67333409e-02f, 2.19234020e-01f, -4.37224507e-02f, 3.17983888e-02f, -4.49800901e-02f, -1.71891719e-01f,
  1.74177274e-01f, -5.47049530e-02f, 1.44517228e-01f, -6.48287535e-02f, 1.54754773e-01f, 8.25199019e-03f, 1.33779824e-01f, -9.13780779e-02f, -7.59534389e-02f, -9.01661739e-02f,
  1.97155967e-01f, 2.16917709e-01f, 3.69172208e-02f, -6.78212941e-02f, 2.56066263e-01f, 4.59016720e-03f, 5.04760221e-02f, 7.39575177e-02f, -5.85014187e-02f, -9.72072557e-02f,
  6.76788092e-02f, 2.04972267e-01f, 1.50435828e-02f, -1.91272050e-02f, -3.38160582e-02f, 4.37167250e-02f, -4.15008552e-02f, 2.35774904e-01f, 7.68927708e-02f, 2.08279844e-02f,
  1.66344851e-01f, -7.77342170e-02f, -8.53068084e-02f, 1.36859879e-01f, -3.71244480e-03f, 1.42628238e-01f, 2.38849849e-01f, 1.36357874e-01f, -1.50881812e-01f, 1.94343477e-01f,
  2.68493623e-01f, 1.13641515e-01f, 1.30239427e-01f, -2.02250317e-01f, -2.11680323e-01f, 7.71637186e-02f, -1.19936682e-01f, 2.62566298e-01f, 2.92854458e-01f, -1.76419169e-01f,
  -1.44374296e-02f, 5.21340929e-02f, -3.19754556e-02f, 1.53903380e-01f, 1.01118810e-01f, 2.96692640e-01f, 8.19631573e-03f, 4.21050116e-02f, 1.78431287e-01f, 3.66930254e-02f,
  1.75124526e-01f, -2.47806951e-01f, -8.19809437e-02f, 6.87009245e-02f, 1.35224998e-01f, 1.92016974e-01f, 1.06302612e-01f, -2.13175286e-02f, -1.08297132e-01f, 6.32103086e-02f,
  -2.87191302e-01f, 8.71078968e-02f, 2.35940784e-01f, 7.99009427e-02f, -1.74091831e-01f, -3.65536697e-02f, 1.85012639e-01f, -1.12733003e-02f, 1.92324594e-01f, -9.13944244e-02f,
  1.33359106e-02f, -1.57499626e-01f, 1.08858094e-01f, 1.26585513e-01f, -9.79843512e-02f, -2.46184647e-01f, -8.48355219e-02f, 7.18757734e-02f, -9.54378620e-02f, 8.56860951e-02f,
  1.29658654e-01f, -7.70480931e-02f, -4.81961705e-02f, 2.59521455e-01f, -6.95120320e-02f, -1.39769316e-02f, 1.27217054e-01f, 1.99570969e-01f, 1.13351293e-01f, 9.85717624e-02f,
  1.87818892e-02f, 1.61730900e-01f, -1.16337962e-01f, 2.79809922e-01f, 3.30572784e-01f, 4.07261811e-02f, -1.11957997e-01f, 2.53628418e-02f, -1.81938276e-01f, 1.60021409e-01f,
  -2.25446805e-01f, 1.86062336e-01f, 2.03818753e-01f, -9.18459743e-02f, 1.34420857e-01f, 8.50475654e-02f, 6.13183752e-02f, 1.03170551e-01f, 5.10069616e-02f, 2.28240296e-01f,
  6.33313507e-02f, 4.14293893e-02f, 1.99847400e-01f, -1.06248774e-01f, 2.55831718e-01f, -1.66275084e-01f, 1.61872264e-02f, 1.80744484e-01f, -1.90070067e-02f, 4.70190980e-02f,
  8.86891186e-02f, 1.25610992e-01f, -1.70803249e-01f, 1.94176421e-01f, -3.74559201e-02f, 2.06519917e-01f, 1.13897696e-01f, 2.73968399e-01f, -1.88646123e-01f, -4.15409207e-02f,
  1.93977296e-01f, 3.69693078e-02f, 1.14312887e-01f, 2.47791521e-02f, 1.95757691e-02f, -1.13676570e-01f, 1.26523376e-01f, 1.72496080e-01f, 7.75261223e-02f, -2.96768188e-01f,
  4.97653149e-02f, 1.31298363e-01f, -1.71992853e-01f, -7.98334777e-02f, 2.52354980e-01f, 2.77485382e-02f, -1.40598923e-01f, 2.92131186e-01f, -5.68410158e-02f, 7.63936713e-02f,
  4.14912738e-02f, 1.13400005e-01f, 2.56668121e-01f, 1.15190275e-01f, 1.02449045e-01f, -3.43967453e-02f, -3.66520323e-02f, 6.99353665e-02f, -2.40502179e-01f, 2.97961570e-02f,
  2.00849220e-01f, -1.75514355e-01f, 1.02238968e-01f, -2.61783838e-01f, 9.06313807e-02f, -8.26355368e-02f, -2.43164718e-01f, 1.42816916e-01f, -1.39424980e-01f, 6.65598735e-02f,
  1.47615701e-01f, -1.02629848e-01f, -6.83255792e-02f, 1.93574175e-01f, 1.08274773e-01f, 2.12045964e-02f, -5.44946976e-02f, 2.85586149e-01f, -3.91410402e-04f, -4.13153815e-04f,
  -4.81130509e-03f, 3.14802796e-01f, 2.20718123e-02f, -3.23773086e-01f, 1.74149930e-01f, 6.02321588e-02f, -7.30231404e-02f, 5.85333705e-02f, 2.50548989e-01f, -1.21961199e-01f,
  -9.79155973e-02f, 6.61380738e-02f, 2.59279370e-01f, 2.87329942e-01f, 7.84201175e-02f, 1.34150963e-02f, 2.34447971e-01f, -2.85407491e-02f, 1.40845831e-02f, 2.56384373e-01f,
  -7.91438203e-03f, -1.63924277e-01f, 5.81127331e-02f, 1.13534801e-01f, 1.53131932e-01f, 1.36507615e-01f, 1.66522086e-01f, 5.00066858e-03f, 4.46953885e-02f, 1.31181642e-01f,
  2.48955473e-01f, -6.42237663e-02f, -1.74070373e-02f, 2.23021224e-01f, -8.27783048e-02f, 1.36494398e-01f, 2.03620926e-01f, 4.45809774e-02f, -1.91317685e-02f, 1.85257554e-01f,
  -1.20539948e-01f, -2.23212883e-01f, 2.13430777e-01f, 1.72199741e-01f, 6.94978908e-02f, 1.61647230e-01f, 9.72826332e-02f, 2.40129396e-01f, 1.10601753e-01f, -1.45470835e-02f,
  -6.16040453e-02f, -3.64111215e-02f, -1.76991045e-01f, 2.66860604e-01f, 1.91587601e-02f, 2.18994603e-01f, 1.50164276e-01f, -2.79056784e-02f, 1.73821226e-01f, 9.60858986e-02f,
  1.20558858e-01f, 9.99475922e-03f, -1.08514890e-01f, 2.86973357e-01f, 2.61308581e-01f, 7.65365735e-02f, -4.29816805e-02f, 2.02962860e-01f, 7.99210742e-02f, -1.33552760e-01f,
  -1.29843503e-01f, -1.06579371e-01f, -6.20023683e-02f, 2.28051841e-01f, 6.37659505e-02f, -1.31476313e-01f, 3.83029170e-02f, -5.09816930e-02f, 1.65781587e-01f, -2.37576421e-02f,
  -4.60767485e-02f, -1.49421275e-01f, -1.18874557e-01f, 1.20026041e-02f, -2.12937877e-01f, -1.29780829e-01f, 5.67780435e-02f, 5.69649674e-02f, -3.74575220e-02f, 9.99613553e-02f,
  1.89598337e-01f, -1.79007143e-01f, 9.36770365e-02f, 2.06469551e-01f, 4.04558778e-02f, -1.03234060e-01f, -7.02317059e-02f, 1.39100760e-01f, 2.07083941e-01f, 4.93609570e-02f,
  6.09631930e-03f, -9.00400579e-02f, -1.25686020e-01f, 9.45863780e-03f, -2.93117035e-02f, -1.11511916e-01f, -9.49290693e-02f, -1.04169644e-01f, -8.92111287e-02f, -3.54329795e-02f,
  -1.25711679e-01f, -2.74002254e-01f, -8.16726685e-02f, -8.33300576e-02f, 1.38297349e-01f, 1.90764114e-01f, -7.51355663e-02f, -7.78155401e-02f, -1.47598818e-01f, 1.91454530e-01f,
  -5.82535788e-02f, 4.81521934e-02f, 2.04893518e-02f, -7.47623071e-02f, 4.09874469e-02f, 1.01947390e-01f, 2.61894017e-01f, -1.37766391e-01f, -7.85542652e-02f, 1.09104507e-01f,
  -6.47666678e-02f, 3.45797138e-03f, -4.76121530e-03f, 2.27506414e-01f, 6.03943467e-02f, 2.20934719e-01f, 3.05803865e-01f, -1.21528342e-01f, -1.09006412e-01f, 1.31765261e-01f,
  -9.64189544e-02f, 4.89584617e-02f, 1.11796958e-02f, 2.68838167e-01f, -7.55396625e-03f, 1.63081646e-01f, 2.86406398e-01f, 5.39568858e-03f, 2.72312257e-02f, -8.22899267e-02f,
  -8.87181610e-02f, 1.84832990e-01f, 4.75748703e-02f, -5.89718185e-02f, 5.93514331e-02f, 1.88987821e-01f, -8.65670145e-02f, 3.50337252e-02f, -8.00138339e-02f, 9.88503620e-02f,
  2.07409024e-01f, 3.46299745e-02f, 2.18312964e-01f, 5.90922609e-02f, 1.42977998e-01f, 1.23788886e-01f, 1.98779181e-01f, -1.49886124e-02f, 7.45852888e-02f, 2.74973035e-01f,
  1.44596636e-01f, -3.58503401e-01f, -2.66165286e-01f, 1.06809542e-01f, -2.14652956e-01f, 3.10390498e-02f, -4.96255867e-02f, 1.04534112e-01f, 2.34409213e-01f, -4.59594317e-02f,
  1.45265177e-01f, 7.86938816e-02f, 2.39841193e-02f, 5.59278838e-02f, 2.56488118e-02f, 9.26130414e-02f, 1.74420998e-02f, 1.55052170e-01f, 7.90706426e-02f, 1.23611242e-01f,
  9.28272977e-02f, -1.37492239e-01f, -1.21210381e-01f, -9.80999991e-02f, -1.28408536e-01f, -3.22223306e-02f, 1.71794146e-01f, 3.97728831e-02f, -3.71099822e-02f, 2.53670961e-01f,
  1.12906791e-01f, 3.74247953e-02f, 1.93445563e-01f, 1.66483358e-01f, -1.29961401e-01f, 9.00566131e-02f, 1.23591170e-01f, 4.16623093e-02f, 2.58117050e-01f, -2.67951842e-02f,
  2.51406938e-01f, 1.14689942e-03f, 1.20696180e-01f, 1.75862581e-01f, -9.05772150e-02f, 1.37292400e-01f, -4.96382639e-02f, 7.02285469e-02f, -2.26702690e-01f, 1.80752069e-01f,
  1.96748286e-01f, 6.19185902e-02f, -1.63265988e-02f, 1.85644031e-01f, 1.01650916e-01f, 5.33166938e-02f, 2.31321272e-03f, 1.02533296e-01f, 1.43176287e-01f, 2.43576780e-01f,
  2.84847558e-01f, 1.51663110e-01f, 1.98389143e-01f, 7.67606273e-02f, 1.89611822e-01f, -7.17630759e-02f, -7.64713883e-02f, -1.18640080e-01f, -2.05655731e-02f, 1.93008095e-01f,
  -4.15372588e-02f, 1.11584917e-01f, 2.36752808e-01f, -4.93498445e-02f, 2.27752984e-01f, 2.33147331e-02f, -7.17052743e-02f, 3.18580903e-02f, -6.18874878e-02f, 2.28074923e-01f,
  9.18353070e-03f, 1.51198758e-02f, 1.18883006e-01f, -2.56854594e-01f, 1.46698222e-01f, 2.20771953e-01f, -8.25249683e-03f, -1.24278970e-01f, 1.47517726e-01f, 3.45537305e-01f,
  -1.18971489e-01f, 1.50427632e-02f, 1.69017185e-02f, 2.41023242e-01f, 6.79194257e-02f, 1.45622015e-01f, -4.71659377e-03f, 1.43317580e-01f, -1.20891996e-01f, 1.07438806e-02f,
  1.79969534e-01f, 1.73684627e-01f, 2.49199886e-02f, 1.54243067e-01f, 8.71130377e-02f, 5.90749877e-03f, 8.12411383e-02f, 1.35927841e-01f, 2.72576481e-01f, 3.31333838e-02f,
  -5.79296127e-02f, 1.21447846e-01f, 2.32815649e-03f, 1.98810533e-01f, 9.49126184e-02f, 6.38438240e-02f, -2.24786162e-01f, 2.79349595e-01f, 2.08207831e-01f, -1.27187982e-01f,
  9.47949588e-02f, 2.65680015e-01f, 9.60472748e-02f, 1.33312762e-01f, 2.28712261e-01f, 2.72948056e-01f, 9.90384072e-02f, -3.79948318e-02f, -4.68555205e-02f, 1.43561944e-01f,
  -1.06180027e-01f, 2.61170119e-01f, 2.37891316e-01f, 2.58453012e-01f, -9.94057488e-03f, 1.73222914e-01f, 9.17333961e-02f, 2.45567068e-01f, 2.59095579e-01f, -1.00448569e-02f,
  6.74633905e-02f, -1.37733579e-01f, -8.29084869e-03f, -1.15233501e-02f, 3.94580401e-02f, 6.73995987e-02f, -2.23913923e-01f, -1.82197288e-01f, 6.08685100e-03f, 2.53578275e-01f,
  2.36067772e-01f, 2.61468813e-02f, 2.42653191e-01f, 3.85290653e-01f, 1.56584769e-01f, -1.51921716e-02f, 2.08053157e-01f, 6.94260746e-02f, -7.86443008e-04f, 1.12803169e-01f,
  1.55143579e-02f, -9.22840461e-02f, 1.34135053e-01f, -1.32013693e-01f, 1.44228831e-01f, 9.62859318e-02f, -1.54590249e-01f, 1.42252937e-01f, 9.51448642e-03f, -1.87119156e-01f,
  -2.20057920e-01f, 1.70515522e-01f, 2.94591486e-01f, -1.85656864e-02f, 1.94663316e-01f, 1.95776802e-02f, 1.95421562e-01f, 1.39031127e-01f, 1.63720548e-01f, 2.20932230e-01f,
  -2.36255373e-03f, -6.45117015e-02f, 2.68382996e-01f, -1.48628846e-01f, 1.02412857e-01f, 6.03889562e-02f, 1.12772644e-01f, 3.03671509e-02f, 8.48723948e-02f, 9.71906539e-03f,
  -5.02687925e-03f, -2.09187716e-01f, 1.26889655e-02f, 1.30911261e-01f, 3.28836143e-02f, 5.34415357e-02f, 2.11732209e-01f, -2.11917162e-01f, 1.84766456e-01f, -1.35749683e-01f,
  -1.16667420e-01f, -5.56491241e-02f, -2.63154387e-01f, 5.84438071e-02f, 2.35043779e-01f, 4.28485312e-02f, -4.80334572e-02f, 1.10813774e-01f, 1.67020217e-01f, 9.91392136e-02f,
  1.19019903e-01f, 1.57492623e-01f, 2.64633391e-02f, -2.33188439e-02f, 1.88051417e-01f, 8.57148319e-02f, -5.41295521e-02f, -3.09764504e-01f, 1.50171608e-01f, 1.00663856e-01f,
  -1.89071625e-01f, -2.56172866e-01f, -1.31424218e-01f, 2.12040879e-02f, 1.67633697e-01f, -1.23496778e-01f, 2.10736945e-01f, 1.18881591e-01f, 1.33163080e-01f, -1.42456427e-01f,
  9.90463607e-03f, -2.36287609e-01f, -1.22780487e-01f, 2.37493187e-01f, -1.35359719e-01f, -2.77981520e-01f, 2.35194284e-02f, -4.88047823e-02f, -2.57131085e-02f, 2.02056214e-01f,
  3.05127412e-01f, -1.47108724e-02f, 1.43548757e-01f, 1.00471959e-01f, 1.62069097e-01f, -3.00377578e-01f, -1.52265429e-01f, 2.07507193e-01f, 6.54707104e-02f, 8.74192640e-03f,
  1.19546250e-01f, -2.74110343e-02f, 1.46011427e-01f, 7.54401758e-02f, 2.62281835e-01f, -1.13462329e-01f, -3.19082946e-01f, -2.87984282e-01f, -1.74774304e-01f, 1.42112628e-01f,
  8.72551352e-02f, -7.58192167e-02f, -1.66871190e-01f, -1.11037865e-01f, 1.83025375e-01f, 2.12643266e-01f, -9.38593689e-03f, -5.02892993e-02f, -6.22157827e-02f, 2.39830464e-02f,
  -1.21240363e-01f, 5.01750074e-02f, 1.61802575e-01f, -5.87111674e-02f, -8.30029249e-02f, 1.03612663e-02f, 1.82203092e-02f, 9.34413809e-04f, 8.46685022e-02f, -8.68947357e-02f,
  1.26889303e-01f, -1.13276169e-01f, 2.94672735e-02f, -4.84944023e-02f, 2.24083975e-01f, 1.45103410e-01f, 2.29344666e-01f, -9.53247920e-02f, -9.16823298e-02f, -1.88105300e-01f,
  -1.26992702e-01f, 1.23767219e-01f, 1.27913073e-01f, 4.05589268e-02f, 4.32177400e-03f, 4.44605350e-02f, 2.62090653e-01f, 2.51532532e-02f, 1.39877439e-01f, -6.97767660e-02f,
  4.57674861e-02f, 3.60778868e-01f, 2.34302968e-01f, -7.50909448e-02f, 1.20298443e-02f, 2.48831481e-01f, -1.62172481e-01f, 3.65441144e-02f, -8.77744704e-02f, 1.23836718e-01f,
  1.57285467e-01f, 1.85050309e-01f, 6.93504810e-02f, 6.09032698e-02f, 1.73813865e-01f, 1.42036960e-01f, 7.98974335e-02f, 2.34234780e-01f, -1.43890232e-01f, -1.43858448e-01f,
  -1.83617651e-01f, 2.34840568e-02f, 1.80287763e-01f, 1.90683037e-01f, 1.44780114e-01f, 1.06134802e-01f, 2.36779258e-01f, -9.91234705e-02f, 1.65089577e-01f, 1.85825974e-01f,
  4.96064313e-02f, -2.43788995e-02f, -1.27665788e-01f, -1.56421140e-01f, -1.29385218e-01f, -2.06474438e-02f, 1.43818676e-01f, 1.05104439e-01f, -2.52020936e-02f, 1.55250859e-02f,
  -2.51404569e-02f, 1.69240221e-01f, 3.48740928e-02f, -6.98278174e-02f, 3.12596589e-01f, 1.08253159e-01f, -1.02327034e-01f, -1.30166963e-01f, 3.12336594e-01f, -1.28914788e-01f,
  -1.14543878e-01f, -1.51211366e-01f, -3.73547822e-02f, -2.18848184e-01f, 2.22626757e-02f, 2.83867645e-04f, 2.87458804e-02f, -4.10309024e-02f, -2.96061605e-01f, 3.45167994e-01f,
  -2.12969601e-01f, -1.42076567e-01f, -5.70041463e-02f, -1.32496264e-02f, 1.59417897e-01f, 1.51923865e-01f, 1.92884833e-01f, -4.77818400e-02f, 1.02667613e-02f, 2.62258917e-01f,
  -1.57796755e-01f, 1.27874404e-01f, 1.42459841e-02f, -1.72347069e-01f, 2.90962815e-01f, -2.89685428e-02f, 7.75990821e-03f, -1.01079203e-01f, 9.27704722e-02f, -2.59406827e-02f,
  -9.94229391e-02f, -9.26797017e-02f, 3.88599001e-02f, -3.05578500e-01f, 7.20100701e-02f, 2.38617569e-01f, 2.18610719e-01f, 1.19512063e-02f, -4.47872393e-02f, 3.34677845e-02f,
  1.53936088e-01f, -1.51788771e-01f, -2.20625103e-02f, -1.58238083e-01f, -2.59886801e-01f, 2.83536345e-01f, 1.67035654e-01f, 2.84309298e-01f, 1.63058355e-03f, -4.09707464e-02f,
  4.99999151e-03f, -3.91257107e-02f, 1.76486656e-01f, 1.90831050e-01f, -1.89471141e-01f, 2.86013722e-01f, 4.65947203e-02f, -1.25215799e-01f, 1.18329041e-02f, 9.29510891e-02f,
  6.07263073e-02f, -4.71256822e-02f, -1.07951023e-01f, -1.24501280e-01f, -2.39484295e-01f, 1.37824297e-01f, 1.35607749e-01f, -3.32349166e-02f, 9.40527841e-02f, -3.50558348e-02f,
  1.29607454e-01f, -7.16320872e-02f, 2.79219318e-02f, -7.36302510e-02f, -1.72632128e-01f, 4.80480716e-02f, 1.77941360e-02f, -2.14033201e-01f, 2.54798651e-01f, -4.67498042e-02f,
  -7.65393078e-02f, 2.82627344e-01f, 1.50616929e-01f, -1.84969008e-01f, 1.91729695e-01f, -1.04747988e-01f, -6.33519962e-02f, -1.60335943e-01f, -5.83613105e-02f, 2.05237746e-01f,
  2.35068470e-01f, 1.16328992e-01f, 1.11308219e-02f, 2.04712644e-01f, 7.89240524e-02f, 1.88369811e-01f, -7.77699947e-02f, 1.50075316e-01f, 9.24882963e-02f, -2.54302353e-01f,
  -2.89063066e-01f, 1.09588332e-01f, -1.31134331e-01f, 5.95237650e-02f, -3.19485456e-01f, 1.93468400e-03f, -3.38678062e-02f, 1.09715171e-01f, 3.05644572e-01f, 1.06956653e-01f,
  -9.91419554e-02f, 1.74930289e-01f, 6.69819862e-02f, 1.61742344e-01f, -2.29446981e-02f, 1.65153757e-01f, 1.95720941e-01f, -9.13835019e-02f, 2.61545211e-01f, -2.62446553e-01f,
  -2.56616808e-02f, 1.02998927e-01f, -1.29956737e-01f, 1.63948923e-01f, 7.46470541e-02f, 2.06643716e-01f, -9.94703621e-02f, 2.16076285e-01f, 1.77078754e-01f, 2.09045097e-01f,
  3.32689285e-01f, 1.14888906e-01f, -3.03064808e-02f, -8.83058682e-02f, 1.37063265e-01f, 1.54445633e-01f, 1.23433806e-01f, -7.95344487e-02f, 1.50160804e-01f, -7.00878128e-02f,
  4.07030024e-02f, 2.31400743e-01f, -1.63881004e-01f, 3.53950113e-02f, 2.34652478e-02f, 5.93958795e-02f, -6.87022731e-02f, 1.53115079e-01f, 1.22490712e-01f, -2.56487038e-02f,
  4.86454777e-02f, 2.54993051e-01f, 1.88742191e-01f, 2.28252579e-02f, -1.55254021e-01f, 4.41744290e-02f, 1.42489985e-01f, 1.91988692e-01f, 1.80220500e-01f, 1.86463624e-01f,
  -1.75644413e-01f, -7.51113668e-02f, 2.09096059e-01f, 8.66303220e-02f, 1.33929387e-01f, 6.28411993e-02f, 1.86141908e-01f, 7.01869726e-02f, -8.86806473e-03f, -4.27387618e-02f,
  2.21006736e-01f, 2.60133413e-03f, 6.09760173e-02f, 1.35328487e-01f, -2.22917143e-02f, 2.07472950e-01f, 5.36050834e-02f, 1.54938260e-02f, -9.09821987e-02f, 1.84554070e-01f,
  5.26080169e-02f, -2.29799166e-01f, 1.81042388e-01f, 9.87057313e-02f, 1.76506028e-01f, 1.78110644e-01f, 1.64051428e-01f, 2.98143625e-01f, -1.23161860e-01f, -5.79753853e-02f,
  -5.39167076e-02f, 1.47980869e-01f, -1.14069857e-01f, 1.16409980e-01f, 1.53351530e-01f, -3.98618169e-02f, -1.14515098e-02f, -1.78965896e-01f, 2.00820312e-01f, 5.22312410e-02f,
  -5.05964756e-02f, -9.03104171e-02f, -2.24800352e-02f, 7.72945136e-02f, 1.38331547e-01f, -1.09983049e-01f, 2.76018351e-01f, -1.70926616e-01f, 6.26216680e-02f, 9.48744789e-02f,
  2.05071628e-01f, 8.88441876e-03f, 1.33109957e-01f, 1.14968248e-01f, 7.59540275e-02f, 1.41278014e-01f, -5.67677692e-02f, -5.52178845e-02f, 2.17135400e-01f, 2.30721220e-01f,
  1.01383165e-01f, 2.44952604e-01f, 5.64053357e-02f, 1.73244745e-01f, 1.03365242e-01f, -1.77010074e-01f, -2.26224408e-01f, -2.04391152e-01f, -2.71468729e-01f, 3.39132965e-01f,
  1.14586085e-01f, -8.21091384e-02f, 1.53605789e-01f, -1.66440561e-01f, -4.83871922e-02f, 1.08666062e-01f, 2.07042292e-01f, -8.93794652e-03f, 7.87589699e-02f, -1.09384581e-03f,
  6.05332442e-02f, 1.11941166e-01f, 2.05497086e-01f, 1.38715073e-01f, -3.68254296e-02f, 1.09788418e-01f, 1.14283063e-01f, -5.48150912e-02f, 1.14903197e-01f, -5.69836274e-02f,
  1.38136432e-01f, -1.30136654e-01f, 7.25683346e-02f, 1.38935866e-02f, 2.62543529e-01f, -2.01504812e-01f, -1.06272232e-02f, 8.50166157e-02f, 2.76916921e-01f, -5.33421664e-03f,
  5.20017892e-02f, -8.02626088e-02f, -7.97241367e-03f, 8.39958712e-02f, -1.83785304e-01f, 2.21563682e-01f, 2.51947460e-03f, 3.11846025e-02f, -2.06956580e-01f, 6.59565479e-02f,
  -4.24935631e-02f, 1.97818711e-01f, 1.60619933e-02f, -4.55974266e-02f, 1.03443787e-02f, 1.44588232e-01f, -2.02413294e-02f, -1.06879458e-01f, -6.45700563e-03f, -3.79207842e-02f,
  3.32944244e-01f, 5.75868413e-02f, 1.47538498e-01f, 9.96620655e-02f, 1.41735017e-01f, 1.15154281e-01f, 4.72243465e-02f, 1.65027812e-01f, 7.34253153e-02f, -2.04195067e-01f,
  -8.07254836e-02f, -3.70547622e-02f, -8.67967233e-02f, 1.46212310e-01f, 2.49753483e-02f, -2.00419948e-02f, 4.71814312e-02f, -4.14445344e-03f, -1.49683177e-01f, 1.48130938e-01f,
  -7.09174275e-02f, 2.00968191e-01f, 5.48872836e-02f, 6.25305995e-02f, 1.78446993e-01f, 1.25396088e-01f, 2.53687084e-01f, 1.32057592e-01f, 1.78029910e-01f, 1.77313149e-01f,
  -4.58026417e-02f, -1.82895586e-01f, 1.98348284e-01f, -2.30526440e-02f, 1.07347732e-02f, -1.83503598e-01f, 2.28682030e-02f, 1.66316479e-01f, -1.06494702e-01f, 1.71516873e-02f,
  1.99274182e-01f, -2.35209484e-02f, 3.08552772e-01f, -4.55835238e-02f, 5.39966039e-02f, 8.82127285e-02f, 1.47625625e-01f, 1.62446097e-01f, 2.47236893e-01f, -5.19347452e-02f,
  5.89324720e-02f, 1.98879987e-01f, -7.73607790e-02f, 3.97684649e-02f, 6.64288877e-03f, 5.66423126e-02f, 1.02941364e-01f, 1.52035892e-01f, 1.01773962e-01f, 7.23738894e-02f,
  -5.97963557e-02f, 1.37714013e-01f, 1.94255650e-01f, 4.63296250e-02f, 1.12726972e-01f, 2.57624179e-01f, 9.07772630e-02f, -5.77805005e-02f, -5.60718542e-03f, 2.76138000e-02f,
  -9.13285762e-02f, 2.92203631e-02f, 1.12965092e-01f, -6.56065121e-02f, -1.25192136e-01f, 3.48251946e-02f, 1.97925851e-01f, -2.31474504e-01f, -2.36829445e-01f, -2.52033062e-02f,
  6.45572916e-02f, -1.14003748e-01f, 2.45105609e-01f, 2.09840342e-01f, -2.16982380e-01f, -1.37025684e-01f, 5.19829653e-02f, 1.02609381e-01f, 9.60102826e-02f, 4.77888621e-02f,
  -1.93817914e-01f, -6.81032985e-02f, 7.76198283e-02f, -3.24551538e-02f, 1.95976630e-01f, -1.00873403e-01f, -8.71451944e-02f, 1.82681546e-01f, -2.21131980e-01f, -1.64612815e-01f,
  8.66417363e-02f, 4.86203544e-02f, 1.64764691e-02f, 3.47257525e-01f, 1.99754268e-01f, -4.12163809e-02f, -7.97182620e-02f, 6.10554926e-02f, -8.99461135e-02f, 8.12118873e-03f,
  -1.54356971e-01f, 2.07016543e-01f, 2.41563514e-01f, 6.49242699e-02f, 1.37350678e-01f, 2.22355857e-01f, 3.55956644e-01f, -6.68424647e-03f, 1.63151436e-02f, -5.13135344e-02f,
  2.13906229e-01f, 1.43333450e-01f, -1.37773126e-01f, -2.54174005e-02f, -1.61517233e-01f, -9.53890979e-02f, -5.06194793e-02f, 1.76154360e-01f, 3.18324156e-02f, 7.55620599e-02f,
  1.14559226e-01f, 1.10265262e-01f, 3.22840586e-02f, 1.54125363e-01f, 3.89777720e-02f, 1.63061246e-01f, 6.06847331e-02f, -1.54462606e-01f, -1.84993565e-01f, 1.41018346e-01f,
  -1.59713649e-03f, 5.60954362e-02f, 1.78100646e-01f, 1.51733264e-01f, -2.42131297e-02f, 1.96100414e-01f, -6.36860281e-02f, 2.75582492e-01f, -3.68415415e-02f, 1.62642375e-01f,
  1.41451374e-01f, 7.95201957e-02f, 1.90035105e-01f, 2.71220982e-01f, 5.50491139e-02f, 4.90256734e-02f, 7.03982264e-02f, 1.48130253e-01f, -5.13084978e-03f, 1.98824242e-01f,
  1.17442518e-01f, 3.34802754e-02f, 2.36838758e-02f, 1.47515759e-01f, 6.81312457e-02f, -5.05073555e-02f, -2.74464369e-01f, -1.70625120e-01f, 1.96101561e-01f, 1.86609969e-01f,
  1.67169571e-01f, -1.06289931e-01f, 2.21254542e-01f, 4.06635217e-02f, 5.98834902e-02f, 1.92655683e-01f, 3.90956365e-02f, -2.02380642e-01f, 1.01115435e-01f, 1.41579062e-01f,
  -8.79601985e-02f, -2.25342046e-02f, 1.68773532e-01f, 2.33240172e-01f, 7.86181167e-02f, 1.62615329e-01f, 2.95388579e-01f, -1.40666682e-02f, 7.51605183e-02f, 3.05417418e-01f,
  2.91557550e-01f, 3.62354666e-02f, 3.41307670e-02f, 2.33259514e-01f, 1.11946359e-01f, -9.40029621e-02f, 1.39150191e-02f, 1.13426976e-01f, 1.10230349e-01f, 5.72177917e-02f,
  3.18855196e-02f, -1.21097378e-01f, -1.36216506e-02f, 1.19519353e-01f, -1.23564407e-01f, -1.25473604e-01f, -1.44142225e-01f, -2.02320535e-02f, -2.32009292e-02f, 3.43182608e-02f,
  1.18621461e-01f, -1.63357869e-01f, -1.61377370e-01f, 1.67858452e-01f, 8.03965777e-02f, 2.20049381e-01f, 1.02773033e-01f, 1.12096034e-01f, -6.80809002e-03f, -1.39537916e-01f,
  2.39191890e-01f, 1.11130275e-01f, 6.94359764e-02f, 2.38329638e-02f, -3.66121419e-02f, -1.43421531e-01f, 1.32881468e-02f, -4.84719351e-02f, -3.82210352e-02f, 6.19516969e-02f,
  -9.07656178e-02f, 1.04785375e-01f, -3.11582796e-02f, 1.40476689e-01f, 2.60854065e-01f, 1.29721269e-01f, 2.32323796e-01f, 1.50487162e-02f, 2.04095796e-01f, -1.21145509e-01f,
  1.39374226e-01f, -1.37285039e-01f, -1.13958254e-01f, 3.79374400e-02f, 6.43581972e-02f, -1.69479549e-01f, 1.13049760e-01f, 7.93430116e-03f, -5.99112175e-02f, 2.35284328e-01f,
  1.18903751e-02f, -6.06914908e-02f, 9.76321399e-02f, -2.68132761e-02f, -1.43265026e-02f, -3.31916101e-02f, -3.61361466e-02f, 1.90441072e-01f, -4.48956154e-04f, 7.17525482e-02f,
  1.99080542e-01f, 1.25992283e-01f, 9.95179117e-02f, 1.63967177e-01f, -1.64208472e-01f, -1.79493174e-01f, -2.89140418e-02f, 2.09161460e-01f, 1.79172292e-01f, 2.79056281e-02f,
  2.40277141e-01f, -3.90530680e-03f, 9.02993008e-02f, 6.80724233e-02f, -1.35134488e-01f, 1.04112685e-01f, -3.55232149e-01f, 1.45144090e-01f, 2.65384942e-01f, -3.86525616e-02f,
  1.19491845e-01f, -3.98913361e-02f, 2.50403583e-01f, 1.08308941e-01f, 2.02241167e-01f, 1.31809548e-01f, -9.12552625e-02f, 7.89213777e-02f, 1.44527167e-01f, 1.93925753e-01f,
  1.39715234e-02f, -1.64141715e-01f, -4.96105663e-02f, -9.17034000e-02f, -1.80699036e-01f, -2.39492834e-01f, -8.66475329e-02f, 3.07292119e-02f, 2.00068250e-01f, -1.12683408e-01f,
  2.61781693e-01f, -1.39055774e-02f, 1.56154782e-01f, -1.41747147e-01f, 1.72394291e-01f, -1.71909690e-01f, -1.79786071e-01f, 2.32105583e-01f, -1.40518859e-01f, -1.64011627e-01f,
  4.87094633e-02f, -2.52454076e-02f, 1.06255285e-01f, 1.80879325e-01f, 1.72768623e-01f, -7.78218508e-02f, -5.73659353e-02f, 5.08184358e-02f, 9.97483060e-02f, -2.66358495e-01f,
  -1.90344915e-01f, 1.69659823e-01f, 1.37232587e-01f, 2.37245381e-01f, -4.24867449e-03f, 9.21976119e-02f, 1.86892644e-01f, 1.63957298e-01f, 6.45407215e-02f, 1.98968858e-01f,
  1.03222720e-01f, -1.96829066e-01f, -8.56939927e-02f, 1.11164548e-01f, 4.98415641e-02f, -1.23535357e-01f, 6.56146109e-02f, 3.28335576e-02f, 2.87766784e-01f, -1.10726682e-02f,
  3.41819286e-01f, 4.05092677e-03f, -1.11532882e-01f, 8.70680436e-02f, 1.62009850e-01f, 7.52153844e-02f, 5.98757416e-02f, 4.97974679e-02f, -1.33900821e-01f, -9.83737502e-03f,
  2.41921440e-01f, 6.09489344e-02f, -1.94931120e-01f, -5.09453341e-02f, 1.97992846e-01f, 4.80586179e-02f, 1.02137111e-01f, 2.25302815e-01f, 2.14136198e-01f, 5.85986190e-02f,
  6.35503903e-02f, -1.38054073e-01f, -4.76710498e-02f, 4.78250235e-02f, -1.19354703e-01f, 1.13493040e-01f, -5.12056686e-02f, 1.29312873e-01f, -1.98296160e-01f, 2.36542717e-01f,
  2.38597523e-02f, -2.41021425e-01f, 8.07194263e-02f, 7.93116018e-02f, 3.20377722e-02f, -2.56787799e-02f, 1.42579198e-01f, 1.52680308e-01f, -1.54348046e-01f, 1.16956778e-01f,
  2.90651526e-02f, -1.81961507e-01f, -1.90650523e-01f, 1.65297896e-01f, 2.76773751e-01f, -6.72798380e-02f, 2.10036024e-01f, 9.43155866e-03f, 6.86054006e-02f, 5.61128668e-02f,
  -2.45278347e-02f, -1.63139924e-02f, 4.62125950e-02f, 3.40893231e-02f, -2.23024413e-01f, -2.34831199e-01f, -1.33179188e-01f, 1.01612560e-01f, 6.08060602e-03f, -2.35042647e-01f,
  -1.72319606e-01f, -2.51620561e-01f, 1.05844595e-01f, 3.00014377e-01f, 1.26017734e-01f, -1.03428863e-01f, -1.06496647e-01f, 2.55573213e-01f, 1.06383096e-02f, 1.46345824e-01f,
  -1.40614942e-01f, 1.40965268e-01f, 1.09819144e-01f, -1.31505489e-01f, 9.63225290e-02f, -6.31905049e-02f, 5.88464290e-02f, 1.28687799e-01f, -5.36585264e-02f, -5.45839891e-02f,
  -8.44558105e-02f, 1.50814489e-01f, 4.47288230e-02f, 2.56351829e-01f, 3.17928374e-01f, -1.72782317e-01f, 5.94717637e-02f, 7.43601546e-02f, -1.69960260e-01f, 2.55112201e-01f,
  -2.25749053e-02f, 2.03879803e-01f, 1.02618396e-01f, 1.45787880e-01f, 3.16297472e-01f, 1.22724026e-01f, 1.53525695e-01f, -1.62515771e-02f, 3.82967889e-02f, 2.71995246e-01f,
  8.70278850e-02f, -6.69289082e-02f, -8.73159841e-02f, 8.84053111e-02f, -2.03356564e-01f, 1.10727616e-01f, 4.07349691e-02f, 1.04677469e-01f, 3.98177616e-02f, 1.28801435e-01f,
  7.42880255e-02f, 1.77608177e-01f, 1.41763389e-01f, 3.74080501e-02f, -3.60324159e-02f, 1.49477795e-01f, 4.87105846e-02f, -1.25297934e-01f, 1.55906215e-01f, 8.64528045e-02f,
  4.76049557e-02f, 1.72819734e-01f, 1.49892181e-01f, 1.49194635e-02f, -3.40716355e-02f, -3.78134549e-02f, 1.51519418e-01f, 2.72292703e-01f, -8.23766142e-02f, 9.29035097e-02f,
  -7.66275898e-02f, 2.17669651e-01f, -9.49665159e-02f, -5.05732279e-03f, -7.05698654e-02f, 1.29091695e-01f, 5.50192557e-02f, -1.22390643e-01f, 1.32465422e-01f, 1.60661608e-01f,
  1.00007012e-01f, 1.30217001e-01f, 1.70108289e-01f, 2.23947003e-01f, 3.78878787e-02f, 1.94019694e-02f, 8.83806273e-02f, 2.09332377e-01f, 1.74192581e-02f, 2.67781541e-02f,
  -1.05343364e-01f, 7.90014714e-02f, 1.86758637e-02f, -1.29227370e-01f, 2.13198476e-02f, -2.77949851e-02f, -8.50287154e-02f, -3.08681764e-02f, 1.59729272e-01f, 1.03699408e-01f,
  5.98147251e-02f, 2.14279100e-01f, 3.43153685e-01f, -6.60297796e-02f, 2.51768976e-01f, 2.18639076e-01f, 2.55135894e-01f, 5.71025386e-02f, 1.24685103e-02f, 2.04315364e-01f,
  4.05612551e-02f, 9.86662358e-02f, 4.82625291e-02f, 1.58269405e-02f, 2.13471919e-01f, -4.64860946e-02f, 1.08023137e-01f, 1.05974130e-01f, -8.86560231e-02f, -1.96172949e-02f,
  5.24080731e-02f, 1.46547243e-01f, 5.24552353e-03f, -4.19301949e-02f, -3.22782427e-01f, 2.59545237e-01f, -6.56013042e-02f, -2.33713631e-02f, -1.34691879e-01f, -1.67199001e-01f,
  3.61889079e-02f, 1.89689681e-01f, 4.61022630e-02f, -8.49177036e-03f, -3.06892991e-01f, 6.43143654e-02f, 6.81981295e-02f, 7.91167542e-02f, -1.05744101e-01f, 6.99249879e-02f,
  -8.24212804e-02f, -9.45574269e-02f, 2.43052393e-01f, -1.58759102e-01f, 1.11720353e-01f, 4.87476699e-02f, 3.75067107e-02f, 3.78843136e-02f, 8.82959515e-02f, 2.08211198e-01f,
  2.58532036e-02f, 1.24297418e-01f, 2.11742878e-01f, 5.50060309e-02f, -6.54367432e-02f, 1.14623800e-01f, -1.27954587e-01f, 5.33661656e-02f, -2.77954005e-02f, 4.48490046e-02f,
  -2.65122145e-01f, 7.87382498e-02f, 2.73818702e-01f, -2.39033401e-02f, 2.33406499e-02f, 9.90483835e-02f, -1.45680025e-01f, 1.92634463e-01f, 2.05293491e-01f, 5.33460006e-02f,
  -1.39029324e-01f, 4.72889617e-02f, 1.45490289e-01f, -1.60141617e-01f, -2.39654281e-03f, 1.92609075e-02f, 3.29267442e-01f, 1.02976233e-01f, 6.37726188e-02f, 1.28840432e-01f,
  5.46149835e-02f, 4.69018854e-02f, 2.28798375e-01f, -7.29473447e-03f, 2.17893600e-01f, 7.41700875e-03f, 1.35589212e-01f, -1.55170448e-02f, 1.16315573e-01f, -2.05935612e-01f,
  -2.05840524e-02f, 2.33224705e-01f, -3.06087825e-02f, 2.15080813e-01f, 1.33847043e-01f, -1.12655178e-01f, 2.01469108e-01f, 3.24884318e-02f, 1.46103874e-01f, -3.74262035e-02f,
  -1.94811419e-01f, 2.70500869e-01f, -2.33654920e-02f, -1.50368527e-01f, 1.16380274e-01f, 1.74703896e-01f, 1.93022564e-02f, 2.29675561e-01f, 7.42586851e-02f, -2.64713466e-01f,
  9.16615874e-02f, 7.44847581e-02f, 1.07490093e-01f, -2.25309372e-01f, 9.05386806e-02f, 1.53780773e-01f, 9.79956239e-02f, 1.84586551e-03f, -1.63028121e-01f, -1.03534415e-01f,
  1.91174731e-01f, 1.18771404e-01f, 1.69714004e-01f, -2.14501936e-02f, 2.17674166e-01f, 1.72004506e-01f, 1.83506787e-01f, 5.59145622e-02f, 5.78250214e-02f, 8.51516612e-03f,
  2.69639671e-01f, 1.84355766e-01f, -1.75023198e-01f, -8.50392953e-02f, 2.83549353e-02f, -4.05164016e-03f, 1.46699950e-01f, 2.55894303e-01f, 5.41664883e-02f, 1.54763043e-01f,
  -8.40671286e-02f, 2.73623671e-02f, 1.39382780e-01f, -1.94109678e-02f, 2.23843589e-01f, 1.57741502e-01f, 7.45616527e-03f, -1.73956454e-02f, -7.10733458e-02f, -1.76879495e-01f,
  -9.73414108e-02f, 1.11011848e-01f, 2.53808230e-01f, 9.82966833e-03f, 2.77442396e-01f, -2.24183857e-01f, 3.00779462e-01f, -2.13102013e-01f, -8.26469213e-02f, 2.05810368e-01f,
  -2.68720359e-01f, 1.16366692e-01f, 1.97760090e-01f, 1.98655739e-01f, 7.91606531e-02f, 1.23386621e-01f, 1.65003106e-01f, 6.42428175e-02f, 5.45710512e-02f, 2.09827945e-01f,
  1.44165352e-01f, -1.25980349e-02f, 7.86671340e-02f, 2.56673455e-01f, -4.09878604e-02f, -3.00071180e-01f, 1.66696116e-01f, 1.18153945e-01f, -5.93664646e-02f, -4.70820479e-02f,
  7.65303597e-02f, 3.56214936e-03f, 2.65983418e-02f, -9.42052826e-02f, 1.72849074e-01f, 1.00666553e-01f, 8.97150859e-02f, 9.96005088e-02f, 1.55444652e-01f, -5.43256439e-02f,
  -3.99846770e-02f, 2.98634887e-01f, 2.90952437e-02f, -3.13782603e-01f, -5.59541136e-02f, -6.94758743e-02f, 1.97571144e-01f, 4.47781421e-02f, 2.89704204e-01f, 3.98048721e-02f,
  9.47464257e-02f, 4.34693024e-02f, 2.85330027e-01f, -1.71385929e-01f, 8.40885378e-03f, 1.25156298e-01f, 6.72141761e-02f, -5.12261875e-03f, 6.79901689e-02f, 1.00228719e-01f,
  6.67142645e-02f, 1.18789226e-02f, -1.24767937e-01f, 1.87941138e-02f, 2.75619894e-01f, 1.06261700e-01f, 2.76809428e-02f, 1.82608500e-01f, -2.04408243e-01f, 1.81500241e-01f,
  -4.26693372e-02f, -2.55128145e-02f, 1.73800997e-02f, -2.32684724e-02f, 8.32629129e-02f, 8.48209485e-02f, -1.13648258e-01f, 1.39815092e-01f, 6.18989989e-02f, -2.39845276e-01f,
  1.35517910e-01f, 9.39521939e-02f, 2.33889356e-01f, -4.96666832e-03f, 3.98229770e-02f, 1.31490873e-02f, 4.33409624e-02f, -1.61799584e-02f, 3.20639610e-02f, 1.83180854e-01f,
  5.81458993e-02f, -1.24085516e-01f, -1.61517084e-01f, -7.00922310e-02f, -2.71282811e-02f, 1.78588793e-01f, 2.43130445e-01f, 1.64510921e-01f, -9.10546333e-02f, -7.71540329e-02f,
  1.16969243e-01f, -4.33868058e-02f, 1.22781051e-02f, -4.35375497e-02f, -1.11588880e-01f, 1.13091916e-01f, 1.45095125e-01f, 2.77310759e-02f, 1.34179324e-01f, -1.63224101e-01f,
  -1.47656687e-02f, 3.06419544e-02f, 1.70777347e-02f, -1.13498949e-01f, 2.28324026e-01f, -1.18262202e-01f, 6.24313205e-02f, -6.34136498e-02f, 9.21065658e-02f, 8.46683159e-02f,
  1.81775950e-02f, 1.24153212e-01f, 1.72730923e-01f, 2.54859418e-01f, 2.51535743e-01f, 1.91571057e-01f, -1.53617546e-01f, 4.91803177e-02f, 7.52492920e-02f, 1.26340026e-02f,
  -6.47660270e-02f, -1.96887255e-02f, 1.57831609e-01f, 2.15707496e-01f, -1.35689393e-01f, 1.90536112e-01f, 9.72237736e-02f, 6.27782792e-02f, 7.51762826e-04f, 8.08941796e-02f,
  4.01048772e-02f, 3.84518169e-02f, -1.90313887e-02f, 1.99249506e-01f, -5.11506461e-02f, 1.48895830e-01f, -1.62024386e-02f, -3.23739313e-02f, 1.32267594e-01f, -3.54469121e-02f,
  2.45495275e-01f, 2.16966316e-01f, -5.08970730e-02f, 3.20772856e-01f, 1.43023029e-01f, 2.12447912e-01f, -2.77491063e-01f, -8.28328207e-02f, -3.63406613e-02f, 1.08135685e-01f,
  1.62260830e-01f, 1.90019608e-01f, 9.58968624e-02f, -7.06757559e-03f, 2.22161070e-01f, 1.71359420e-01f, 3.09637133e-02f, -2.22191274e-01f, -2.56468188e-02f, 3.38373370e-02f,
  -4.00295965e-02f, 8.84153992e-02f, 1.24848425e-01f, -8.35119337e-02f, -2.51124464e-02f, -1.76619478e-02f, 3.39472666e-02f, -1.97533488e-01f, 2.08647162e-01f, 3.25536370e-01f,
  1.68940708e-01f, 2.06901938e-01f, 2.65971739e-02f, 6.17424920e-02f, 1.12624162e-04f, 6.40487745e-02f, 1.98673308e-01f, 1.62149668e-01f, 6.18623272e-02f, 1.83838129e-01f,
  -1.40059412e-01f, -5.49881272e-02f, 2.45544329e-01f, 1.26210243e-01f, 4.23111051e-01f, 6.46693408e-02f, 1.57625183e-01f, 5.01634590e-02f, 2.40123555e-01f, 8.11016560e-03f,
  1.94482267e-01f, -3.28935534e-01f, 1.33620575e-01f, -5.23732789e-02f, -1.72359318e-01f, 2.27173436e-02f, -2.10601225e-01f, -2.75993254e-02f, 7.11479504e-03f, 6.85110986e-02f,
  -5.96693754e-02f, 7.94082152e-05f, -3.81564945e-02f, 4.09956276e-01f, -6.16628081e-02f, 1.95062578e-01f, 3.25237781e-01f, 1.43619895e-01f, 7.18114898e-02f, -2.33865902e-01f,
  3.42200756e-01f, 8.35564733e-02f, -2.33852014e-01f, -4.15241159e-02f, -3.28071356e-01f, 8.31041858e-03f, 2.89573660e-03f, -1.21083155e-01f, 1.13735840e-01f, -1.62974119e-01f,
  -2.45669812e-01f, 8.44893008e-02f, -2.03171104e-01f, -1.06128141e-01f, -6.76606074e-02f, -6.97234273e-02f, 2.74561584e-01f, -1.37043029e-01f, 1.36018321e-01f, 1.11011215e-01f,
  1.36035517e-01f, 8.33383799e-02f, -4.12260853e-02f, 1.50396898e-02f, -1.93991825e-01f, -1.79278105e-01f, 1.12126447e-01f, -2.34550804e-01f, 1.88805208e-01f, 2.22084388e-01f,
  7.88766369e-02f, 3.42122316e-02f, 3.99287343e-02f, 1.28360078e-01f, 2.23587379e-01f, 5.08588366e-02f, -2.75385022e-01f, -1.83156937e-01f, -1.47730738e-01f, -9.15153027e-02f,
  5.01586264e-03f, -1.79978281e-01f, 2.11385354e-01f, -1.03398472e-01f, -8.16557780e-02f, 3.33667934e-01f, -1.87701210e-01f, -1.95332780e-01f, 2.50589520e-01f, 1.97613314e-02f,
  -1.08521648e-01f, 3.78274359e-02f, 6.27610385e-02f, -1.05231516e-02f, 1.74417228e-01f, 1.77600920e-01f, -3.71665806e-02f, -8.48215595e-02f, 8.60265121e-02f, 3.20819616e-02f,
  -1.76215261e-01f, -2.37274513e-01f, -3.40659320e-02f, -6.63797706e-02f, 2.38199741e-01f, 6.86504170e-02f, 2.67276525e-01f, -1.09781124e-01f, -1.16201140e-01f, -8.66099223e-02f,
  3.14668491e-02f, 3.13391447e-01f, 3.43154185e-02f, 1.66345328e-01f, 3.26458514e-01f, 2.17766836e-01f, 5.08967713e-02f, 1.67994797e-01f, 5.17043024e-02f, -4.17527892e-02f,
  -1.66109815e-01f, 2.34685406e-01f, 3.22036557e-02f, 1.92880891e-02f, 2.11468246e-02f, 1.32753313e-01f, -7.73841962e-02f, 2.52189517e-01f, 9.92467105e-02f, 4.65782359e-02f,
  1.17507480e-01f, 1.56699643e-01f, 1.50332332e-01f, 1.84722573e-01f, 4.41996641e-02f, 1.91279590e-01f, 2.52903197e-02f, 4.13026698e-02f, 1.91158429e-01f, 2.59071589e-01f,
  1.35850862e-01f, 3.15489830e-03f, -1.73052654e-01f, -5.93889318e-02f, -7.57016540e-02f, 3.89748633e-01f, -8.21523070e-02f, 1.34523362e-01f, -9.79860127e-02f, -1.75200760e-01f,
  1.69205949e-01f, 5.75104076e-03f, 2.34409764e-01f, -1.35673478e-01f, 1.53855905e-01f, 8.63832384e-02f, -1.78801883e-02f, 9.37366262e-02f, 8.58865678e-02f, 1.75329208e-01f,
  -1.96627542e-01f, 1.29337087e-01f, -5.81690967e-02f, -1.88371554e-01f, 3.81069556e-02f, 3.26927751e-01f, 8.04684013e-02f, 1.21889733e-01f, -2.99529761e-01f, -1.77101389e-01f,
  1.23814143e-01f, 1.25786707e-01f, 2.82979667e-01f, 1.36151984e-01f, 1.27966151e-01f, 4.88361567e-02f, 1.57689095e-01f, -6.99859634e-02f, 3.77803855e-02f, -2.90874571e-01f,
  6.22599311e-02f, 1.12739839e-01f, -4.38890383e-02f, 3.63513380e-01f, 2.88753957e-02f, -1.19658448e-01f, -2.56730378e-01f, -1.30229652e-01f, 1.87861361e-02f, -2.77559131e-01f,
  2.64989316e-01f, 2.79219091e-01f, 4.64359671e-02f, 1.34479135e-01f, -9.60023627e-02f, 5.14429733e-02f, 4.29364853e-02f, -1.58113111e-02f, 1.58250019e-01f, 1.82311162e-01f,
  -4.19753778e-04f, -8.03312212e-02f, 2.83389185e-02f, -1.97419345e-01f, 9.98403970e-03f, 1.01345256e-01f, 2.34686002e-01f, -1.11153036e-01f, 8.42311829e-02f, -7.15328008e-02f,
  2.58547008e-01f, -2.23911777e-01f, 1.17778592e-01f, 1.05245762e-01f, -2.02660054e-01f, 1.10479109e-01f, 6.41888529e-02f, 2.03926027e-01f, -3.88790183e-02f, 2.22270954e-02f,
  1.61586300e-01f, -4.11905721e-03f, 1.17536150e-01f, 4.71277460e-02f, 3.74561436e-02f, 1.58306032e-01f, 1.57842860e-01f, 2.36410633e-01f, -1.19557539e-02f, -1.29910618e-01f,
  4.40390455e-03f, -8.82838741e-02f, 1.70143042e-02f, 2.12570667e-01f, 7.81068131e-02f, 1.41313709e-02f, -7.36058429e-02f, 1.14392586e-01f, 2.46437430e-01f, 1.01554073e-01f,
  1.08178921e-01f, 9.61260051e-02f, 2.59162486e-01f, 1.80471525e-01f, 7.57218599e-02f, 1.28520831e-01f, 3.08821887e-01f, -1.56312630e-01f, 1.83418095e-01f, 1.79066002e-01f,
  6.89345598e-02f, 2.24876866e-01f, 1.62517861e-01f, 9.36904398e-04f, -1.12083750e-02f, 3.51061076e-02f, 3.37542146e-02f, -8.23573321e-02f, -2.13489085e-01f, 1.51592478e-01f,
  2.14444503e-01f, 1.63398266e-01f, 2.25083560e-01f, 2.56670386e-01f, 1.83903441e-01f, 4.21125926e-02f, 4.82422002e-02f, 3.45563859e-01f, 2.69079238e-01f, 7.57408096e-04f,
  -7.48001877e-03f, -2.82849073e-01f, 5.79506084e-02f, 2.54005671e-01f, 1.03768617e-01f, 3.69464725e-01f, -3.92870104e-04f, -2.58506626e-01f, 1.45050704e-01f, -1.29435465e-01f,
  2.28795424e-01f, -1.97040766e-01f, 1.73393682e-01f, 2.44785592e-01f, 1.15365274e-01f, 5.72596863e-02f, 1.06665798e-01f, 5.42255156e-02f, -8.32818374e-02f, -5.00820577e-02f,
  5.48552498e-02f, -1.29191549e-02f, 1.30414769e-01f, 8.70904028e-02f, 1.74897462e-01f, -1.10591687e-01f, 1.20786317e-01f, 1.64724246e-01f, -1.78389475e-01f, 6.07010461e-02f,
  -5.29650152e-02f, 1.86521083e-01f, 5.46042249e-02f, -6.88961670e-02f, -1.16484668e-02f, -2.68215369e-02f, 2.00085267e-01f, -2.97779776e-02f, 3.12393717e-03f, -8.28137547e-02f,
  1.11024164e-01f, 1.35084301e-01f, 8.44778568e-02f, -9.38155577e-02f, -1.17347827e-02f, -1.61713921e-02f, -8.35425854e-02f, 8.74101818e-02f, 2.91660637e-01f, 2.22212568e-01f,
  1.69909060e-01f, 3.18980068e-02f, -5.80207258e-02f, -1.90620348e-01f, 1.01582520e-01f, 1.44557044e-01f, 1.85833424e-01f, 1.33049965e-01f, 2.27864385e-01f, 7.58865029e-02f,
  2.09450036e-01f, 1.94745466e-01f, -2.11069167e-01f, -6.51279613e-02f, 1.46819189e-01f, -2.74350375e-01f, -1.79349314e-02f, -6.97626770e-02f, 1.65273845e-01f, 8.96294117e-02f,
  -1.32521093e-02f, 8.17455798e-02f, 7.48032182e-02f, -1.99109524e-01f, 8.36656988e-02f, -2.96807103e-03f, 7.87328929e-02f, 2.61180758e-01f, 1.49099395e-01f, -2.50646114e-01f,
  1.44891486e-01f, 1.84480876e-01f, 7.30861947e-02f, -7.90693313e-02f, -1.57776311e-01f, 1.26452103e-01f, 1.46322012e-01f, -1.85228541e-01f, -3.27168824e-03f, -3.23456675e-02f,
  9.19927657e-02f, 2.48610541e-01f, 2.12312013e-01f, -1.16720185e-01f, -5.41928522e-02f, 3.09174247e-02f, -3.86910103e-02f, 1.45594448e-01f, -1.21966265e-01f, 2.02697009e-01f,
  2.46711463e-01f, 2.43210733e-01f, 1.82412460e-01f, 4.09261249e-02f, 6.96041808e-02f, 3.92897315e-02f, 9.71212797e-03f, 2.05432355e-01f, -7.93370456e-02f, -3.84777486e-02f,
  -1.50670946e-01f, 2.37618104e-01f, -1.54605865e-01f, 1.52830318e-01f, 5.91157004e-02f, 1.59441829e-01f, 1.04824699e-01f, 6.31709844e-02f, -9.06425864e-02f, 6.71734512e-02f,
  1.48000136e-01f, 1.17788769e-01f, 4.69964668e-02f, -5.83210923e-02f, -3.80772464e-02f, -4.58901450e-02f, 1.12660751e-01f, 1.65004104e-01f, 2.78047137e-02f, 1.90583393e-02f,
  -5.41196503e-02f, 3.15376610e-01f, 4.47214842e-02f, 1.31228134e-01f, -1.29533783e-01f, -1.24837071e-01f, -7.02293590e-02f, 2.22491935e-01f, 8.15109164e-02f, 3.33668217e-02f,
  4.97140661e-02f, 1.66450500e-01f, 1.90111116e-01f, -3.04246508e-02f, 1.62325487e-01f, 1.29763782e-01f, -7.04076290e-02f, -1.52109545e-02f, -8.09991825e-03f, -6.83595389e-02f,
  8.59692991e-02f, 2.46604159e-01f, 5.08208126e-02f, 9.06252563e-02f, -2.43078277e-01f, -1.93933457e-01f, -1.17792942e-01f, 1.84596553e-01f, 2.04787686e-01f, 4.47124653e-02f,
  5.73018230e-02f, 5.89197837e-02f, 1.89748988e-01f, -7.00789317e-02f, 7.58910999e-02f, -2.35959426e-01f, -1.96697176e-01f, 1.39940023e-01f, -1.25009701e-01f, -1.14510141e-01f,
  1.12993024e-01f, 3.89787629e-02f, -8.15017745e-02f, 2.17242345e-01f, 1.79337189e-01f, -9.18801874e-02f, 1.80643335e-01f, 1.40814036e-01f, -5.41928969e-02f, -1.69607580e-01f,
  -1.54088855e-01f, 1.09739661e-01f, 1.08757146e-01f, 1.13477781e-01f, 1.82846189e-01f, 8.42817053e-02f, 6.31199554e-02f, 2.69022226e-01f, -1.24686569e-01f, 1.80868834e-01f,
  1.84911698e-01f, -2.10462391e-01f, -1.85817912e-01f, 2.07539797e-01f, -1.17109589e-01f, 1.56094939e-01f, 1.07107442e-02f, 1.98278978e-01f, 7.63634518e-02f, -5.95485009e-02f,
  1.83938235e-01f, -5.69125675e-02f, -6.23667501e-02f, -1.77492946e-02f, 1.31670743e-01f, 1.44264996e-01f, 3.89666334e-02f, 1.50973350e-01f, 2.22300455e-01f, -1.17359653e-01f,
  -9.16506872e-02f, -4.71871719e-02f, -3.96564491e-02f, -7.57762119e-02f, 2.41306618e-01f, 1.57575801e-01f, -2.39097737e-02f, -1.04610354e-01f, 2.40697414e-01f, 1.45516917e-01f,
  2.51098778e-02f, 1.99779510e-01f, 2.60924190e-01f, 1.84342265e-01f, -2.14874014e-01f, -4.26446721e-02f, 1.79868013e-01f, 1.09937787e-01f, -1.65363327e-02f, 3.12842101e-01f,
  4.67351675e-02f, -5.54150045e-02f, -3.76872756e-02f, 2.97469407e-01f, -4.84177656e-02f, 1.46863997e-01f, -2.78463513e-02f, 8.52453336e-02f, -1.88840762e-01f, 2.92534828e-01f,
  1.91431060e-01f, -1.33995682e-01f, -1.19016089e-01f, 1.82220235e-01f, 2.61718512e-01f, -7.76895583e-02f, 1.86867759e-01f, 1.55923739e-01f, 1.88063473e-01f, 1.95371523e-01f,
  1.41979143e-01f, -1.27932662e-02f, 1.71593323e-01f, 1.90817475e-01f, -1.48951977e-01f, 9.57119744e-03f, 1.11469537e-01f, -2.82329053e-01f, -8.84882361e-02f, -1.30335167e-01f,
  2.26589441e-01f, 1.24171875e-01f, 2.20229216e-02f, -8.05104598e-02f, -2.39246022e-02f, 9.35792476e-02f, 2.15955842e-02f, 1.32463321e-01f, 1.82787374e-01f, 8.59861001e-02f,
  8.60368162e-02f, -2.02560544e-01f, 2.42500424e-01f, 4.05856632e-02f, 6.57050088e-02f, 1.27569377e-01f, -9.70931575e-02f, -2.68535987e-02f, 1.00636572e-01f, 1.88849196e-01f,
  1.81228861e-01f, -1.09267056e-01f, 1.40250951e-01f, 2.03346670e-01f, 7.66655728e-02f, 8.51882249e-02f, -3.65632847e-02f, 3.20725739e-02f, 7.07343742e-02f, 2.70005375e-01f,
  1.62176117e-01f, -8.06609634e-03f, 3.49644154e-01f, 1.54257506e-01f, 3.57871130e-02f, 4.56486568e-02f, 8.15264732e-02f, -1.05072848e-01f, -1.37574658e-01f, 2.76786476e-01f,
  -1.66879222e-01f, -1.77586805e-02f, -8.13404843e-02f, 1.67778373e-01f, 4.35841415e-04f, 3.20123881e-02f, 8.45132917e-02f, 1.92497801e-02f, -2.99800523e-02f, 1.91097558e-02f,
  1.65843010e-01f, 2.10448965e-01f, 1.20712467e-01f, -4.80299536e-03f, -2.71955039e-02f, 1.65110007e-01f, -1.65743768e-01f, 1.40666232e-01f, -1.72212124e-01f, -1.09865218e-01f,
  -1.32504448e-01f, 2.86480576e-01f, 2.36212298e-01f, 2.20816676e-02f, -2.19289616e-01f, -2.13750914e-01f, 3.68517563e-02f, 2.64101118e-01f, 1.02003373e-01f, -1.66228503e-01f,
  -2.58143246e-01f, 4.65352423e-02f, -4.43119258e-02f, 5.04140072e-02f, -1.66068792e-01f, 2.23800704e-01f, -1.17096446e-01f, -1.85139865e-01f, 1.64359882e-01f, -2.03301355e-01f,
  9.85098910e-03f, 2.73195744e-01f, 1.23094702e-02f, 4.83978093e-02f, -1.14337318e-01f, 1.48480177e-01f, -3.83486114e-02f, 4.44574654e-03f, 2.11199686e-01f, -1.53999254e-01f,
  2.07480401e-01f, 2.21117452e-01f, -1.54351115e-01f, 5.24259964e-03f, 4.38015573e-02f, 1.24757253e-01f, -3.69334698e-01f, 1.94459096e-01f, 1.89334288e-01f, -6.21755607e-02f,
  9.32619199e-02f, 1.21409602e-01f, -6.93680719e-02f, 1.00283712e-01f, 2.55360037e-01f, -1.00533731e-01f, 1.04326628e-01f, 2.10174322e-01f, 1.43227398e-01f, 8.65187421e-02f,
  -3.17453477e-03f, 1.97003633e-01f, 1.59718007e-01f, 8.52429345e-02f, 4.94031794e-02f, 2.24717110e-01f, 6.00651838e-02f, 2.33609632e-01f, 5.67780323e-02f, 9.56987813e-02f,
  7.78734460e-02f, 6.56926483e-02f, 1.20821871e-01f, -1.51051611e-01f, -3.22688818e-01f, -4.59839404e-02f, -8.51093978e-02f, 1.38913468e-01f, -1.19552083e-01f, 5.22113368e-02f,
  -3.26772593e-02f, -7.47010037e-02f, 2.19074845e-01f, 1.74534187e-01f, 8.42240825e-02f, -1.40826646e-02f, 2.86333442e-01f, 1.62437141e-01f, 2.48486593e-01f, 1.32739723e-01f,
  2.32530177e-01f, 6.88028708e-02f, -1.53897600e-02f, -3.38382959e-01f, 1.19127728e-01f, -3.11976895e-02f, -5.28100207e-02f, -1.67020023e-01f, 1.24055482e-01f, 1.31357014e-01f,
  -1.69020757e-01f, -1.36657521e-01f, 6.31566206e-03f, 2.00393572e-01f, 1.70802280e-01f, 1.27549041e-02f, 9.65175256e-02f, 9.53088105e-02f, 8.58273208e-02f, -1.13901339e-01f,
  2.63145030e-01f, -4.46695946e-02f, -3.81252989e-02f, 1.66722015e-02f, -8.80276710e-02f, 1.55865863e-01f, -2.02943459e-01f, 1.11916713e-01f, -1.60409063e-01f, -5.54714799e-02f,
  -8.38607829e-03f, 2.10800007e-01f, 1.17698953e-01f, -7.08947703e-02f, 2.00956464e-01f, -3.93379666e-02f, 1.60602510e-01f, 1.85456112e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 52)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 52;
const float L1_fan_Bp_bar_data[] = {
  2.41349131e-01f, 5.37381545e-02f, -3.70427081e-03f, 2.30919033e-01f, -4.17848006e-02f, 1.13919169e-01f, 1.27044186e-01f, 2.20135078e-01f, 9.95480046e-02f, 1.40216649e-01f,
  -3.27642113e-02f, 1.83093756e-01f, 5.87734058e-02f, 3.99374627e-02f, 4.76139300e-02f, 1.52665406e-01f, -6.24199281e-04f, -7.48381168e-02f, 1.77694499e-01f, 7.15562403e-02f,
  9.27422568e-02f, -6.86562201e-03f, 2.25084409e-01f, 2.72530288e-01f, 1.88330904e-01f, 2.06435323e-01f, 1.82501942e-01f, 1.54486433e-01f, -1.32434350e-02f, 9.73005742e-02f,
  3.88485603e-02f, 1.83144867e-01f, -3.43702026e-02f, 1.09981894e-01f, 9.82877053e-03f, 2.08951160e-01f, 4.69768271e-02f, 5.37992306e-02f, 1.51731089e-01f, -1.71127953e-02f,
  2.53782600e-01f, 4.81791943e-02f, 1.84865385e-01f, 2.59108454e-01f, 6.70229495e-02f, 1.51348561e-01f, 1.82409659e-01f, 1.77684754e-01f, 2.56612241e-01f, 2.48953123e-02f,
  1.68834493e-01f, 2.37154335e-01f
};

// L2_fan_Wp (Shape: 6 x 64)
const int L2_fan_Wp_rows = 6;
const int L2_fan_Wp_cols = 64;
const float L2_fan_Wp_data[] = {
  7.98492953e-02f, -1.02477022e-01f, -3.21961418e-02f, -1.57657322e-02f, -9.13348198e-02f, -3.95627432e-02f, -1.30384132e-01f, 6.98760971e-02f, -7.07624033e-02f, -4.39786240e-02f,
  1.64013386e-01f, -9.43392217e-02f, -6.51392043e-02f, 6.33452088e-02f, -6.25757724e-02f, -1.64724253e-02f, 1.46494200e-02f, -1.08121604e-01f, 2.83742044e-03f, 5.82287870e-02f,
  1.93438053e-01f, 1.60046220e-01f, 5.15877232e-02f, 8.36384743e-02f, -5.43132648e-02f, -9.59984660e-02f, -2.10203826e-01f, -2.31716363e-03f, 1.14885911e-01f, -9.18544009e-02f,
  -1.24150798e-01f, -1.04901396e-01f, 1.79422814e-02f, 1.96536452e-01f, -3.78871895e-02f, -7.89311454e-02f, -2.20755879e-02f, -1.55181989e-01f, 1.73145935e-01f, -5.56814820e-02f,
  1.06611028e-01f, -1.58448458e-01f, -1.07253985e-02f, -1.52465150e-01f, 1.20984338e-01f, 2.15931647e-02f, -3.56742702e-02f, -8.85155201e-02f, 4.12220247e-02f, 9.92718264e-02f,
  1.22881137e-01f, -5.65129668e-02f, 3.48807350e-02f, 4.25160751e-02f, -8.25117454e-02f, 3.75113152e-02f, 6.52292371e-03f, 2.92131845e-02f, -1.58853039e-01f, 1.48378864e-01f,
  -1.30062193e-01f, 1.49831429e-01f, -5.55099808e-02f, -1.63441256e-01f, -1.61241572e-02f, -1.10271059e-01f, -1.38252497e-01f, -1.56334087e-01f, 9.62569416e-02f, 7.02626780e-02f,
  4.51144315e-02f, -3.54901701e-02f, -7.23225772e-02f, 4.67378162e-02f, 9.04223323e-03f, 1.00656591e-01f, -9.98063013e-02f, -1.48995267e-02f, 6.59855977e-02f, 6.02592307e-04f,
  4.04246487e-02f, -6.06477261e-02f, 9.39406157e-02f, -9.78803933e-02f, -1.35074377e-01f, -4.30367142e-02f, -2.08573863e-02f, -1.01741880e-01f, -5.61413504e-02f, -1.55403182e-01f,
  -1.48723766e-01f, 3.84010300e-02f, 1.13730520e-01f, -1.99572761e-02f, -9.09588560e-02f, -9.10553187e-02f, -1.62158102e-01f, 1.30658716e-01f, 9.87892449e-02f, -1.27075434e-01f,
  1.54404208e-01f, 1.80807859e-02f, 4.26219292e-02f, -6.10790625e-02f, 1.03608958e-01f, 1.51502013e-01f, 5.93702942e-02f, 1.03031270e-01f, 5.34350686e-02f, -1.02806419e-01f,
  -9.00882781e-02f, -9.43568815e-03f, -1.41971856e-01f, 1.88248307e-02f, 1.04895562e-01f, 1.12688646e-01f, -2.86209993e-02f, -2.91915057e-04f, 1.16713107e-01f, -6.11836053e-02f,
  1.77833259e-01f, -4.61432226e-02f, 4.05899659e-02f, -3.39629501e-02f, 1.03121232e-02f, 4.05470729e-02f, -5.52955829e-02f, 2.50341818e-02f, 4.69893068e-02f, -3.82377282e-02f,
  3.47805470e-02f, 4.18615080e-02f, 2.90591028e-02f, 8.75549689e-02f, 4.61704992e-02f, 1.24787875e-01f, -1.41315952e-01f, 1.76558152e-01f, 3.23920287e-02f, 8.64379108e-02f,
  -5.14939465e-02f, -7.01882392e-02f, 2.36162573e-01f, -1.09276205e-01f, 2.67004240e-02f, 1.41323924e-01f, 3.69651504e-02f, 2.10321993e-02f, 9.24987346e-03f, -1.50220945e-01f,
  -1.78904757e-02f, -1.13405406e-01f, 1.79570969e-02f, -2.12077983e-02f, -1.49521396e-01f, 6.06351346e-02f, 8.31966028e-02f, 1.74041409e-02f, -3.41849364e-02f, -1.29875809e-01f,
  -5.35557605e-02f, 2.12017134e-01f, 4.44970913e-02f, 7.63759539e-02f, 3.61715676e-03f, 1.70142716e-03f, -4.53308858e-02f, 5.64160794e-02f, 9.08920094e-02f, -5.75152375e-02f,
  7.87394494e-02f, 4.22291420e-02f, 1.56842649e-01f, -1.34061888e-01f, -6.28838241e-02f, -1.68900341e-02f, 1.27287032e-02f, -1.60991717e-02f, 4.28503938e-02f, -1.92806404e-02f,
  -1.13598801e-01f, -2.30122626e-01f, 1.48276776e-01f, 4.93653007e-02f, 1.63533632e-02f, -9.89484787e-02f, 7.40433186e-02f, 3.20307389e-02f, 3.78784128e-02f, -1.82623025e-02f,
  6.80307001e-02f, 1.64908499e-01f, 7.34184384e-02f, 4.10141647e-02f, 1.43867701e-01f, 9.18183997e-02f, -8.06323513e-02f, 5.76162077e-02f, 1.95807308e-01f, 1.16830699e-01f,
  1.29503071e-01f, 1.78107888e-01f, 5.74826524e-02f, -7.51513019e-02f, -7.74845928e-02f, -2.58331895e-02f, -8.64169598e-02f, -7.11624995e-02f, -1.71553204e-03f, 5.67700155e-02f,
  -8.04464221e-02f, -5.54140061e-02f, 2.27040276e-02f, -5.54009527e-02f, -1.38957426e-02f, -2.27918010e-02f, 8.29066616e-03f, 1.68906689e-01f, -1.31141543e-01f, 3.13487910e-02f,
  4.54694554e-02f, -1.01487964e-01f, 3.60553786e-02f, 4.34724279e-02f, 8.05827752e-02f, 8.26809257e-02f, -1.21117719e-01f, -3.05948332e-02f, -1.56077981e-01f, 5.11071980e-02f,
  -6.22460470e-02f, 2.19585244e-02f, -3.37495990e-02f, -1.03750631e-01f, -4.86072004e-02f, 1.17068358e-01f, 1.39932353e-02f, -7.40910396e-02f, -6.94996864e-02f, -1.98594600e-01f,
  -1.30149975e-01f, 8.27820823e-02f, -3.84415388e-02f, 2.68903114e-02f, 1.34853229e-01f, -6.71296120e-02f, -1.56994939e-01f, 1.92612126e-01f, -7.33633563e-02f, 4.63735498e-02f,
  4.46039438e-03f, 1.83941767e-01f, 1.22936755e-01f, 1.18139967e-01f, -2.75003631e-02f, 8.15239325e-02f, 7.64888003e-02f, 8.60506017e-03f, 1.25943184e-01f, -1.68135669e-03f,
  -1.19007535e-01f, -1.05754837e-01f, -7.87742287e-02f, 6.87478334e-02f, -1.72597006e-01f, 6.82973713e-02f, 1.80639595e-01f, 1.21885844e-01f, 5.53526469e-02f, -1.42063769e-02f,
  -1.17544614e-01f, -5.11153638e-02f, 1.48226261e-01f, -7.01684058e-02f, -2.79230792e-02f, -4.09191148e-03f, 3.38209160e-02f, 1.26828805e-01f, 8.71834829e-02f, 3.36106010e-02f,
  1.20114520e-01f, -1.17660888e-01f, 3.60519886e-02f, 1.91131487e-01f, -8.01441371e-02f, 9.49079469e-02f, -6.45365119e-02f, 2.08862312e-02f, 1.04284413e-01f, -1.07490733e-01f,
  1.13450028e-01f, -7.52003863e-02f, 3.25958207e-02f, -1.32261291e-01f, -1.35257155e-01f, -1.94440216e-01f, 4.79342230e-02f, 3.63684148e-02f, 1.88532010e-01f, -9.32244956e-02f,
  -9.14019644e-02f, -7.71553442e-02f, 1.16420723e-01f, -5.01973890e-02f, 1.04437321e-01f, 1.26987755e-01f, -1.79178156e-02f, -1.26618385e-01f, 2.12268785e-01f, -5.50512448e-02f,
  1.16248868e-01f, 1.29176170e-01f, -1.66648909e-01f, -6.46538138e-02f, 1.31084323e-01f, -5.00812382e-02f, -1.71341047e-01f, -1.03122383e-01f, -8.96034613e-02f, -6.31538033e-02f,
  3.31366919e-02f, 5.05708456e-02f, -1.68982763e-02f, -6.84535652e-02f, -1.40969142e-01f, -8.52980614e-02f, -1.61304057e-01f, -5.68986824e-03f, -1.25758067e-01f, -2.20297381e-01f,
  -1.35777190e-01f, -1.17122859e-01f, -1.91999003e-01f, 5.78783862e-02f, -4.90966514e-02f, -9.33622271e-02f, 3.58626433e-02f, 5.44337481e-02f, -1.23301737e-01f, 2.01747287e-02f,
  -1.20380521e-01f, -6.96517006e-02f, -1.92058235e-02f, -1.65258959e-01f, 1.07194863e-01f, -4.12315615e-02f, 2.25318540e-02f, 6.79176003e-02f, -2.86952443e-02f, -6.02015257e-02f,
  -3.23337018e-02f, -7.77961016e-02f, -1.03777889e-02f, 3.94080803e-02f, 2.93929800e-02f, 6.67436272e-02f, 1.67757094e-01f, -1.08872555e-01f, 5.75992949e-02f, 1.12289507e-02f,
  -1.26187950e-01f, -9.32117477e-02f, 2.69086584e-02f, -4.94741462e-02f, 4.28724326e-02f, 4.69880402e-02f, -1.61921948e-01f, -1.07521228e-02f, -8.64829719e-02f, 1.32618710e-01f,
  9.85250250e-02f, 1.17241405e-02f, -1.80123933e-02f, 2.18176812e-01f, -1.56808063e-01f, 8.58221203e-02f, 7.75250420e-02f, 5.62474020e-02f, -3.16948332e-02f, -3.17540765e-02f,
  -1.82001255e-02f, 7.00051114e-02f, -2.35214811e-02f, -1.70778751e-01f
};

// L2_fan_Wp_bar (Shape: 52 x 64)
const int L2_fan_Wp_bar_rows = 52;
const int L2_fan_Wp_bar_cols = 64;
const float L2_fan_Wp_bar_data[] = {
  2.79126968e-02f, 9.58426595e-02f, -1.75904259e-02f, 3.96145582e-02f, -6.23839237e-02f, -4.41231765e-02f, -2.30215251e-01f, 1.05576083e-01f, -2.46084884e-01f, -1.89652830e-01f,
  1.97734669e-01f, -2.32802685e-02f, 3.41735706e-02f, 2.65189439e-01f, 2.80883372e-01f, 2.45676979e-01f, 4.92974520e-02f, -5.13253026e-02f, 1.32966682e-01f, 6.63580149e-02f,
  -7.54236802e-02f, -2.65922397e-01f, 1.24616355e-01f, 1.43412665e-01f, -1.46917135e-01f, -1.93225503e-01f, -3.95348780e-02f, 1.90656647e-01f, -3.47096585e-02f, 6.78767264e-02f,
  -7.89250582e-02f, -1.02370262e-01f, 2.95293219e-02f, -1.13568157e-01f, 1.29618272e-01f, 2.43477032e-01f, -2.01389462e-01f, -8.07830989e-02f, -1.29116932e-02f, 9.87190306e-02f,
  -4.28631157e-02f, 2.24614769e-01f, -6.24107346e-02f, -1.50750265e-01f, -8.52181613e-02f, 3.21921855e-02f, 7.98539519e-02f, 1.82352215e-01f, 1.39588282e-01f, -1.63722381e-01f,
  3.92602496e-02f, -1.76908270e-01f, -9.99014243e-04f, 2.64544725e-01f, 2.54730940e-01f, -2.00020343e-01f, 1.91578284e-01f, 1.37131903e-02f, 1.61852598e-01f, -2.13713199e-01f,
  1.59159511e-01f, -2.90226080e-02f, 1.80092424e-01f, -1.20821394e-01f, 1.09271497e-01f, 1.54848993e-01f, 1.94625542e-01f, -3.08729429e-02f, 5.50376624e-02f, 1.58618251e-03f,
  2.48334453e-01f, 1.53030947e-01f, 5.42377718e-02f, 3.20872545e-01f, 9.19815153e-02f, -1.65006202e-02f, -7.49524757e-02f, -7.61215910e-02f, 8.04494619e-02f, 4.99804057e-02f,
  9.96005684e-02f, 8.72081518e-02f, 1.27380580e-01f, 2.98806787e-01f, -1.34899020e-01f, -2.63902415e-02f, 1.81522787e-01f, -1.62336096e-01f, 2.20423713e-01f, 2.55084425e-01f,
  2.19449252e-01f, 1.17144592e-01f, 6.13607243e-02f, -1.48806259e-01f, 9.46036875e-02f, 9.07615274e-02f, -1.70874834e-01f, 2.69665658e-01f, 6.71806559e-02f, -3.10585260e-01f,
  1.40861943e-02f, 1.51481509e-01f, -4.76575606e-02f, 2.57004760e-02f, 9.85642746e-02f, -7.47021213e-02f, 2.23015368e-01f, 1.99386030e-01f, 2.83405513e-01f, -4.99146655e-02f,
  -5.61898462e-02f, -2.19144344e-01f, -4.22675274e-02f, 2.28484534e-02f, 1.25184907e-02f, 1.38128206e-01f, -2.60329945e-03f, -3.76339465e-01f, 1.00230843e-01f, 1.07318357e-01f,
  1.80087797e-03f, 1.39541879e-01f, -1.96676981e-02f, 2.53921598e-01f, 1.80009991e-01f, 1.38190106e-01f, -1.21663779e-01f, 2.54787415e-01f, 1.29190505e-01f, 9.37607735e-02f,
  1.56318650e-01f, 3.21894586e-02f, 1.31408582e-02f, 3.82035375e-02f, 1.35789573e-01f, 1.34303182e-01f, -1.47902057e-01f, 1.33837655e-01f, -7.34318346e-02f, -1.53852254e-01f,
  -1.43959284e-01f, -8.77470747e-02f, 4.93037812e-02f, 1.90512419e-01f, -1.13321148e-01f, 3.31533909e-01f, -5.46147935e-02f, -2.16240987e-01f, 1.59921378e-01f, 1.88376456e-01f,
  1.84452116e-01f, -1.48138523e-01f, 7.32544810e-02f, 3.37099105e-01f, 2.20554516e-01f, -2.64805019e-01f, 1.08255491e-01f, -6.11074939e-02f, 6.60072044e-02f, 2.93733150e-01f,
  7.61394724e-02f, -8.34145844e-02f, -2.11816654e-02f, 2.99695194e-01f, -7.79981315e-02f, 1.15513438e-02f, 1.53774232e-01f, 1.57958731e-01f, -1.18482843e-01f, -2.34531071e-02f,
  1.96640417e-02f, -2.93505308e-03f, 8.58298466e-02f, 9.65805948e-02f, 5.88718615e-02f, -3.52631062e-02f, -1.38889164e-01f, 2.88943589e-01f, -4.15723547e-02f, -1.98747814e-02f,
  2.60978732e-02f, 2.15755016e-01f, -7.75417686e-02f, 2.86212508e-02f, 3.36320736e-02f, 3.18090528e-01f, 1.46806002e-01f, 6.36394173e-02f, 3.04579228e-01f, 2.63267398e-01f,
  -1.28847286e-01f, 1.31670246e-02f, 7.76186958e-02f, -3.69756073e-02f, 9.89815518e-02f, 1.79385185e-01f, 6.93021566e-02f, 2.14537159e-01f, 7.68811405e-02f, -5.45471236e-02f,
  3.96757238e-02f, 2.55213618e-01f, -1.09420910e-01f, -8.00592005e-02f, 1.67675182e-01f, -7.88444057e-02f, 1.23898208e-01f, 9.73091554e-03f, -1.51576921e-01f, -2.11373586e-02f,
  2.33715340e-01f, 8.22178498e-02f, 8.15173462e-02f, -8.75069425e-02f, 1.04047254e-01f, 3.41750681e-02f, 4.60390411e-02f, -4.49448936e-02f, -8.24013203e-02f, 1.23077527e-01f,
  -2.35325411e-01f, 4.41698404e-03f, 3.83077636e-02f, -8.96931626e-03f, 6.77131340e-02f, -1.13122240e-01f, 1.91021889e-01f, 6.37325421e-02f, -1.96310163e-01f, 2.26824820e-01f,
  1.29782811e-01f, 7.86189511e-02f, 5.31624965e-02f, 1.79225087e-01f, 1.81780219e-01f, 1.13303354e-02f, 3.28701851e-03f, -7.69658312e-02f, 2.78364718e-01f, 1.62439585e-01f,
  -6.40350878e-02f, 3.32684144e-02f, -1.07171148e-01f, -1.49680063e-01f, 1.05638362e-01f, -2.40492553e-01f, 1.91193864e-01f, 4.66010645e-02f, -5.30594215e-02f, 1.96403116e-02f,
  7.81059563e-02f, -2.56598908e-02f, 1.20217599e-01f, -1.49739282e-02f, 8.68024230e-02f, 1.10110722e-01f, -5.41024134e-02f, 1.84131145e-01f, 6.48873150e-02f, 1.98455259e-01f,
  -7.59489685e-02f, 3.35533172e-02f, 1.46039352e-01f, -4.35562059e-02f, 1.39899611e-01f, 2.10238695e-01f, 1.84383839e-02f, 2.69702841e-02f, 2.06602905e-02f, 2.70805448e-01f,
  -1.16412625e-01f, 4.15671505e-02f, 1.96023032e-01f, 8.39746818e-02f, 3.37436572e-02f, -9.12764866e-04f, -3.25288661e-02f, 1.70600787e-02f, -9.00440738e-02f, 1.21688969e-01f,
  1.05755189e-02f, 3.30882847e-01f, 3.74083936e-01f, 2.73622833e-02f, 6.96160458e-03f, -1.64562333e-02f, 1.02774464e-01f, 1.64118230e-01f, 9.74808037e-02f, 9.30508748e-02f,
  -2.46515408e-01f, -2.25486513e-02f, -6.05794229e-02f, 1.76543981e-01f, 2.89349198e-01f, -5.40292356e-03f, -1.89266335e-02f, -4.91555072e-02f, 3.08838040e-02f, 1.11236773e-01f,
  2.06330448e-01f, -2.56876945e-02f, -2.41092458e-01f, 1.36253729e-01f, -4.01888229e-02f, -1.50571791e-02f, -9.43891406e-02f, 2.27220193e-01f, 3.12261373e-01f, 3.01070094e-01f,
  -1.56873077e-01f, 1.75171420e-01f, -1.13068312e-01f, 2.82406867e-01f, 5.73084094e-02f, 2.19371572e-01f, 1.47290975e-02f, -4.06024493e-02f, 7.92919844e-02f, 4.60376740e-02f,
  5.00395335e-02f, 9.29684490e-02f, 1.59012020e-01f, 6.03374057e-02f, 1.40531927e-01f, 1.47939235e-01f, 1.33124813e-01f, 6.54874742e-02f, 3.46370302e-02f, -2.05184668e-02f,
  -3.11265022e-01f, -3.82307082e-01f, -1.70401428e-02f, 1.16365507e-01f, 5.64512312e-02f, -1.88334122e-01f, -3.89710143e-02f, 6.11797161e-02f, 9.46165249e-02f, -1.03960484e-02f,
  2.94996649e-01f, -1.12802483e-01f, -3.49585563e-02f, -1.18616894e-01f, 1.96486846e-01f, 1.21441737e-01f, 1.43082291e-01f, -4.86051664e-02f, -1.29003227e-01f, -1.52643710e-01f,
  1.96813360e-01f, 9.35802702e-03f, 1.21529736e-01f, 9.78541374e-02f, -2.22896226e-02f, 9.58786160e-02f, -1.03196315e-01f, 1.39778450e-01f, -1.83249697e-01f, 1.79030642e-01f,
  4.40851925e-03f, -9.47926342e-02f, 7.64095923e-03f, 1.15890857e-02f, 7.74950683e-02f, 2.27667734e-01f, -1.22528918e-01f, -1.65086344e-01f, 9.01952535e-02f, 1.86487645e-01f,
  -4.29220311e-02f, -1.09146409e-01f, 6.27802312e-02f, -3.48753408e-02f, 1.56184770e-02f, 3.05499017e-01f, -3.58906090e-02f, 2.85589963e-01f, 5.38191870e-02f, 1.54214585e-02f,
  1.42974392e-01f, 4.47029024e-02f, -7.98192024e-02f, 1.87587798e-01f, -1.16667725e-01f, -1.36412131e-02f, -1.91645905e-01f, -1.27248690e-01f, -1.23655442e-02f, -1.35694370e-01f,
  1.39498979e-01f, 7.17227980e-02f, -4.12730649e-02f, -7.48626739e-02f, 1.59822315e-01f, 2.39089921e-01f, 9.01805237e-02f, 1.61172390e-01f, 2.99921464e-02f, 1.92155316e-01f,
  1.97568774e-01f, -6.78400099e-02f, 1.58029154e-01f, 9.17162225e-02f, -4.03993607e-01f, 1.71275020e-01f, 1.15589023e-01f, 1.31253511e-01f, -5.15522528e-03f, 1.43211007e-01f,
  5.96155971e-02f, 1.71528965e-01f, 1.04777962e-01f, 8.09794068e-02f, -1.33684739e-01f, -2.38535628e-02f, -2.67694354e-01f, 2.52871305e-01f, -1.47900999e-01f, -3.00881624e-01f,
  3.18130583e-01f, 1.74144953e-01f, 2.59742904e-02f, 2.67154258e-02f, 2.33866610e-02f, 1.20248429e-01f, 1.01697527e-01f, 1.85942844e-01f, 8.30931365e-02f, 1.09329203e-03f,
  -4.85426895e-02f, -3.53371724e-02f, 6.51320741e-02f, -9.76350904e-02f, 1.96933910e-01f, 1.82637379e-01f, 9.83332098e-02f, -1.30160794e-01f, -8.36648047e-02f, -5.09679392e-02f,
  3.00202549e-01f, 7.42172673e-02f, 2.21263412e-02f, 5.82712367e-02f, -3.95802408e-02f, 1.64759174e-01f, -3.45860161e-02f, -5.61940260e-02f, 4.27472824e-03f, -4.30699512e-02f,
  8.78544375e-02f, -9.17582661e-02f, -2.79000006e-03f, 3.13895755e-02f, -1.64198890e-01f, 1.27975168e-02f, -1.06185623e-01f, -1.30494848e-01f, 2.43769333e-01f, 2.07724571e-01f,
  3.62544596e-01f, -9.64665040e-03f, 1.74081340e-01f, 1.98167801e-01f, 8.97354707e-02f, -1.75068215e-01f, 1.86247364e-01f, 2.17927679e-01f, 1.54625932e-02f, -2.15756759e-01f,
  -6.38381913e-02f, 3.19947511e-01f, 2.33420311e-03f, -2.18684644e-01f, 4.41966299e-03f, -6.64330507e-03f, 3.21581140e-02f, 3.11804861e-01f, 1.19834945e-01f, -2.33581625e-02f,
  7.50299077e-05f, 3.42419706e-02f, 9.08955410e-02f, -4.71358970e-02f, -8.14889371e-02f, 2.58083731e-01f, 6.22905605e-02f, 1.85629874e-02f, 1.52604178e-01f, 1.84192508e-01f,
  1.72331259e-02f, -1.92968808e-02f, 4.62672561e-02f, 6.17896728e-02f, 2.84319013e-01f, 6.39931709e-02f, 3.35142702e-01f, -1.86005026e-01f, 2.20789462e-01f, 1.00786285e-02f,
  5.79209663e-02f, -1.74594954e-01f, 3.11726987e-01f, -3.75138968e-02f, 3.88064347e-02f, -2.28879094e-01f, 1.60305321e-01f, 5.18788919e-02f, 1.11435711e-01f, 4.79682572e-02f,
  1.28826723e-01f, -4.51657139e-02f, 1.90323815e-02f, -1.02876075e-01f, 5.08514419e-02f, 1.60717472e-01f, 1.67630687e-01f, -1.16377957e-01f, -1.68189909e-02f, -1.09406941e-01f,
  1.12904206e-01f, 3.20018828e-01f, 1.37460142e-01f, 1.94273610e-02f, 1.21548720e-01f, 4.65271026e-02f, 1.56450346e-01f, -2.70738024e-02f, 1.33650795e-01f, 3.86622660e-02f,
  1.56243503e-01f, 4.99553569e-02f, -2.85048723e-01f, -5.77868074e-02f, 2.35278849e-02f, -2.31211483e-02f, 2.03533411e-01f, -1.53194079e-02f, 2.14119211e-01f, 2.21003711e-01f,
  -1.89960599e-01f, 2.27484480e-01f, 7.50886230e-03f, 1.44632876e-01f, -1.13688886e-01f, 2.63383873e-02f, 2.52528004e-02f, -2.66534746e-01f, -3.29699926e-02f, 1.56603768e-01f,
  -8.64647925e-02f, -1.45478800e-01f, 6.66446611e-02f, 3.32061708e-01f, 5.31293750e-02f, -1.19868346e-01f, 1.25440955e-02f, 8.06798413e-03f, 1.22931324e-01f, 1.17537662e-01f,
  1.39695480e-01f, 4.28452529e-02f, 1.03117019e-01f, -2.11323142e-01f, -6.61569182e-04f, -1.01264425e-01f, 8.46649706e-02f, 6.21943176e-02f, 2.39848167e-01f, 1.11640766e-01f,
  1.88393295e-01f, -1.69998016e-02f, 8.96963179e-02f, 1.93953604e-01f, 1.73332423e-01f, -8.51588920e-02f, 2.97139529e-02f, 1.45314947e-01f, 2.10065767e-01f, -5.91919236e-02f,
  7.57008567e-02f, 4.54510786e-02f, 7.07616806e-02f, 1.29052445e-01f, -1.97215945e-01f, -1.42024888e-03f, -1.78952485e-01f, -2.54331619e-01f, -2.07243085e-01f, -1.28459200e-01f,
  2.18027860e-01f, 9.44623128e-02f, 8.23582783e-02f, 3.11579220e-02f, 1.20056160e-01f, 8.82531554e-02f, 7.98959881e-02f, 2.14712560e-01f, 3.23239045e-04f, -3.03723305e-01f,
  3.72216731e-01f, -2.52573681e-03f, -1.09893031e-01f, 2.64014807e-02f, 2.04286650e-01f, -1.15586057e-01f, 1.74016520e-01f, 8.69300961e-02f, 1.66855976e-01f, -3.52276564e-02f,
  1.24177724e-01f, 5.73686324e-02f, 1.42556757e-01f, -8.13965648e-02f, -6.28135577e-02f, 2.69245237e-01f, 1.28950134e-01f, -1.56495169e-01f, 1.93191186e-01f, 1.97779730e-01f,
  1.68063775e-01f, -5.29341325e-02f, -2.54408792e-02f, -1.43699527e-01f, -1.11330405e-01f, 1.92060977e-01f, -9.41880047e-02f, 7.26346970e-02f, -7.38354251e-02f, -5.01492284e-02f,
  2.79035568e-01f, 9.44726244e-02f, 1.10701881e-01f, 5.07889204e-02f, 5.49718365e-02f, 8.96703750e-02f, 2.07584947e-02f, 1.24440238e-01f, -3.34957689e-02f, 2.80083179e-01f,
  1.45089000e-01f, -3.36446916e-03f, -6.99495822e-02f, 1.02321215e-01f, -4.14096117e-02f, 8.12822208e-03f, 8.89252312e-03f, 1.50101110e-01f, -2.12051243e-01f, -1.17502483e-02f,
  1.27433509e-01f, -9.93712572e-04f, 1.87873080e-01f, -8.37261379e-02f, -2.98562706e-01f, 3.47840860e-02f, 2.09867969e-01f, -1.44398183e-01f, -7.72315338e-02f, 2.34356783e-02f,
  1.71944574e-01f, 1.80284441e-01f, 8.21129605e-03f, 1.48422092e-01f, -1.94508806e-01f, 1.57410521e-02f, -3.42650227e-02f, 6.47331774e-02f, 2.45649695e-01f, -3.01993582e-02f,
  -1.82412609e-01f, 2.51821857e-02f, 2.04565406e-01f, 7.42211863e-02f, -1.07710488e-01f, 4.58510108e-02f, 1.56877950e-01f, -9.19970125e-03f, 1.80415317e-01f, 6.04238128e-03f,
  9.39816833e-02f, -1.19626097e-01f, 2.81825721e-01f, -4.17711996e-02f, 2.05245882e-01f, -2.06080630e-01f, -1.15766354e-01f, 1.40352845e-01f, -1.96883768e-01f, 1.29872978e-01f,
  2.03489587e-01f, 2.10852444e-01f, 2.72720814e-01f, 6.44448251e-02f, -3.57609242e-02f, 2.56682575e-01f, 1.01925991e-01f, -5.96993752e-02f, -1.68571651e-01f, 3.05735618e-01f,
  -5.13712689e-02f, 3.21037043e-03f, -1.36739761e-01f, -3.86273190e-02f, 1.06652766e-01f, -7.96537194e-03f, 1.37602806e-01f, -8.83346274e-02f, 6.67296723e-02f, -4.99941483e-02f,
  -1.22483447e-01f, 3.45370471e-02f, -7.30774477e-02f, 6.16478026e-02f, -1.42129492e-02f, 1.46068662e-01f, -1.57821879e-01f, -7.93229192e-02f, 1.71478912e-01f, 1.67729378e-01f,
  5.84230125e-02f, 2.00886011e-01f, -8.40618915e-04f, -1.98540211e-01f, -1.00975841e-01f, 1.39404252e-01f, -1.37976778e-03f, -3.72410677e-02f, 1.31568760e-01f, 1.35201395e-01f,
  -4.70757820e-02f, 1.81300174e-02f, -3.17688361e-02f, 2.46049035e-02f, 1.49485081e-01f, 2.32211649e-01f, 2.38337651e-01f, -1.89104334e-01f, 2.29545936e-01f, 2.17025831e-01f,
  -1.08052105e-01f, -1.47279655e-03f, 1.75821245e-01f, -1.24268256e-01f, -1.58524990e-01f, 3.61863188e-02f, -4.74830195e-02f, 7.39902556e-02f, -1.66918740e-01f, 1.20555028e-01f,
  1.25588074e-01f, 1.50576368e-01f, 1.59948226e-02f, 2.26746455e-01f, -7.64463097e-02f, -1.35431901e-01f, 1.12244047e-01f, 1.38629405e-02f, -3.85129936e-02f, -1.03413068e-01f,
  1.78055182e-01f, -6.93476200e-02f, 1.37164906e-01f, -1.29108623e-01f, -2.93172318e-02f, 5.15224831e-03f, -2.75208391e-02f, -1.10153414e-01f, 1.34899557e-01f, -9.99509543e-02f,
  -7.29351491e-02f, 1.22154400e-01f, 7.17924163e-02f, -3.90325184e-03f, -9.30998325e-02f, 1.52870774e-01f, -1.47456571e-01f, -1.28071606e-01f, 2.30654448e-01f, 8.19647908e-02f,
  2.72925526e-01f, 2.15563536e-01f, -9.47301611e-02f, -3.54614630e-02f, 2.58957833e-01f, -2.26375148e-01f, -1.21843241e-01f, 2.35467538e-01f, 1.87869057e-01f, 1.73027311e-02f,
  6.54343292e-02f, 1.53801098e-01f, -9.71668065e-02f, -1.84711203e-01f, 6.35166168e-02f, 2.44989783e-01f, 5.42447008e-02f, -1.26240596e-01f, -8.61441046e-02f, -1.53976604e-01f,
  9.66183667e-04f, 2.71330953e-01f, -3.99281159e-02f, -6.60849139e-02f, 1.69177711e-01f, 1.70781583e-01f, -4.36497806e-03f, 9.65905841e-03f, 3.68760563e-02f, -8.92852172e-02f,
  2.13016897e-01f, 8.35483074e-02f, 1.68392852e-01f, -8.65866095e-02f, 8.71417373e-02f, 1.82297193e-02f, -2.93464344e-02f, -5.34692444e-02f, 1.99741036e-01f, 8.78686085e-02f,
  8.36007893e-02f, -1.58525005e-01f, 8.99894238e-02f, 1.42489150e-01f, 6.45358488e-02f, 6.75341263e-02f, -1.48690298e-01f, 5.35760969e-02f, -1.59948692e-01f, -8.63073766e-02f,
  1.94240198e-01f, 1.54137030e-01f, -6.54992014e-02f, 4.55695912e-02f, 7.49645531e-02f, 4.08348674e-03f, -3.74180414e-02f, 1.38310477e-01f, -1.56525016e-01f, 1.74282029e-01f,
  -1.91586778e-01f, -7.69634619e-02f, -2.18927339e-01f, 1.38098672e-01f, -1.98704302e-01f, -3.06468420e-02f, 2.93602079e-01f, 2.75024563e-01f, 1.68065634e-03f, 1.32806763e-01f,
  2.85415202e-01f, -5.52210584e-02f, -1.64031565e-01f, -2.19181314e-01f, 2.87184328e-01f, -1.91937938e-01f, 2.67724525e-02f, -3.80863878e-03f, -1.01448558e-01f, 1.58566520e-01f,
  -2.59632051e-01f, 8.87929350e-02f, 2.19600260e-01f, 4.15306725e-02f, -1.10622570e-01f, -1.33798286e-01f, 2.58609802e-01f, 2.59035289e-01f, -3.40943448e-02f, 1.08113158e-02f,
  7.57695362e-02f, 2.47584850e-01f, -2.11896636e-02f, 1.37231931e-01f, -2.07532451e-01f, 1.00379802e-01f, -1.17068589e-01f, 2.09748775e-01f, 2.45240182e-01f, 8.58226568e-02f,
  1.81177765e-01f, 1.51394740e-01f, 8.05157721e-02f, -2.30347794e-02f, -2.60427445e-01f, 6.14624843e-02f, 1.19482391e-01f, -3.55592161e-01f, 1.94884866e-01f, -1.18410349e-01f,
  2.16844559e-01f, -2.30969205e-01f, 1.24790370e-01f, 1.58529609e-01f, 9.80240703e-02f, -4.35329303e-02f, -1.35984961e-02f, 1.38452858e-01f, 7.11107925e-02f, 3.75550985e-02f,
  9.66028310e-03f, 1.54817224e-01f, -7.02105537e-02f, -1.05909251e-01f, 1.23650588e-01f, 1.76757455e-01f, -1.30697772e-01f, -1.44494846e-01f, -1.73390090e-01f, 8.54070559e-02f,
  1.20350070e-01f, 3.86950970e-02f, -3.54590155e-02f, 2.57566243e-01f, 1.91986531e-01f, -1.90502748e-01f, -1.09475674e-02f, -2.67035458e-02f, 2.75209937e-02f, -1.34056702e-01f,
  1.78497583e-01f, 2.99991637e-01f, 1.68717921e-01f, -1.02998100e-01f, -1.08242355e-01f, 2.01329038e-01f, 2.93239087e-01f, 2.20003590e-01f, 7.92525560e-02f, -2.33976096e-01f,
  1.92323059e-01f, -1.25768080e-01f, -2.12023273e-01f, 7.64696077e-02f, 2.21175365e-02f, 3.30572128e-02f, 1.44536188e-03f, 2.18866140e-01f, 7.75199085e-02f, 1.32964894e-01f,
  -2.01892138e-01f, 1.93394914e-01f, 8.99074525e-02f, 1.28225833e-01f, -3.68706845e-02f, 2.01303348e-01f, -8.59496221e-02f, -2.23875735e-02f, 5.90492636e-02f, 1.02576546e-01f,
  6.21716529e-02f, 1.48816779e-01f, 3.22096143e-03f, 2.30413646e-01f, 2.61134297e-01f, -1.10800393e-01f, 1.94183171e-01f, 1.81726545e-01f, 6.65588304e-02f, 1.23089299e-01f,
  -1.62807405e-01f, 1.08493797e-01f, 3.14879306e-02f, -2.92703155e-02f, -8.43417943e-02f, -1.02470957e-01f, -8.41663182e-02f, 5.13964370e-02f, -1.61679357e-01f, -5.21924421e-02f,
  8.53477046e-02f, 8.55459943e-02f, 1.26512438e-01f, 2.83164591e-01f, -2.51437481e-02f, 1.04415506e-01f, 2.34747395e-01f, 2.40774512e-01f, -3.01223397e-02f, 1.60661221e-01f,
  -1.17586501e-01f, 6.24388792e-02f, 1.24960586e-01f, 1.55516490e-01f, 5.81388455e-03f, -2.30168477e-02f, 1.50325805e-01f, 2.13311434e-01f, -6.39368072e-02f, 1.05791926e-01f,
  -1.60983130e-01f, -9.02605355e-02f, 7.25863501e-02f, 5.42804040e-02f, -8.17194432e-02f, 2.03808725e-01f, 1.37901172e-01f, -2.50965238e-01f, 1.58768877e-01f, -7.32651502e-02f,
  -1.33474901e-01f, 1.07482821e-01f, -2.70421430e-02f, -6.99876845e-02f, 2.25500301e-01f, 1.62839025e-01f, -1.79032937e-01f, 8.32624882e-02f, -4.60433140e-02f, 1.16369307e-01f,
  1.97566569e-01f, -1.08118597e-02f, 1.69211790e-01f, 2.88805962e-01f, -5.91464117e-02f, -1.87821254e-01f, 1.33656681e-01f, 4.48873453e-02f, -5.94748966e-02f, 3.84013653e-02f,
  -1.80164486e-01f, -3.68839242e-02f, 2.05097035e-01f, -1.34698108e-01f, 8.82035121e-02f, -3.16348672e-02f, 1.15799114e-01f, 1.81686133e-01f, -3.99862304e-02f, 1.73488826e-01f,
  -1.39891565e-01f, -9.22129005e-02f, 1.80814847e-01f, 4.31544632e-02f, 1.11443073e-01f, 1.16290309e-01f, 7.48151541e-02f, 1.70566276e-01f, -4.11488935e-02f, 1.92482039e-01f,
  -8.13997090e-02f, -1.32014766e-01f, 2.08397418e-01f, 1.86622396e-01f, 1.48964435e-01f, -1.01724461e-01f, -1.50673345e-01f, 1.71445861e-01f, -2.17929214e-01f, 1.38348594e-01f,
  1.61534116e-01f, -1.30300015e-01f, -1.00486323e-01f, 7.90068582e-02f, 1.54013619e-01f, 5.80312274e-02f, 5.86012825e-02f, 7.31130838e-02f, 1.55819088e-01f, 2.46739104e-01f,
  -2.49406040e-01f, 2.23461613e-01f, 7.78303072e-02f, 1.13983735e-01f, 2.04758495e-01f, -1.33343622e-01f, 1.04293428e-01f, -9.10988525e-02f, -3.84584479e-02f, 9.89832729e-03f,
  2.44199514e-01f, 1.10487200e-01f, 2.36381590e-01f, -2.42840648e-01f, -6.99444488e-02f, 1.15809307e-01f, 1.14192583e-01f, -3.41819316e-01f, 2.58210283e-02f, 1.23601824e-01f,
  -9.07667819e-03f, 5.17181493e-02f, 2.12284047e-02f, -6.00394700e-03f, 2.24409595e-01f, 8.96460097e-03f, 3.07052612e-01f, 1.34866521e-01f, 2.02981174e-01f, 1.98609248e-01f,
  -2.50657666e-02f, 8.02067816e-02f, -1.78037153e-03f, 1.45880118e-01f, -3.78565699e-01f, 1.27196729e-01f, -1.26748890e-01f, -4.12529439e-01f, -5.15871160e-02f, -8.56107250e-02f,
  2.59648740e-01f, 2.54596680e-01f, 6.67122826e-02f, 3.53731588e-02f, -9.58416909e-02f, -1.33118078e-01f, 4.86608706e-02f, 1.83868445e-02f, 3.16825122e-01f, 7.63879269e-02f,
  -4.17239368e-02f, 1.17281191e-01f, 1.81224719e-02f, -2.22038120e-01f, -6.97507411e-02f, 1.17613040e-01f, -3.67749371e-02f, -1.15632072e-01f, -1.01970062e-01f, 1.21115148e-02f,
  2.85556316e-01f, 2.79477425e-02f, 1.19067110e-01f, 3.54688257e-01f, 1.44664392e-01f, -5.20782247e-02f, 4.80588600e-02f, 9.71012190e-02f, 6.01981767e-02f, -1.78573579e-02f,
  -8.49814042e-02f, -1.61902711e-01f, 1.07773341e-01f, 8.57205316e-02f, -4.36022654e-02f, 2.66302168e-01f, 2.85538137e-02f, -7.49109033e-03f, 1.21741220e-01f, 9.54963714e-02f,
  -1.71751268e-02f, 3.39454591e-01f, -9.83230248e-02f, 7.49981031e-02f, -6.89482838e-02f, -8.43653753e-02f, -7.32825920e-02f, -7.55585805e-02f, 2.57211089e-01f, -1.82783842e-01f,
  1.50715902e-01f, -6.49178922e-02f, 2.27325469e-01f, 5.59063666e-02f, 7.01634884e-02f, 1.86936390e-02f, 6.64797437e-04f, 1.20308399e-01f, -1.61093116e-01f, -5.59868738e-02f,
  -5.92160746e-02f, -3.16182405e-01f, 1.24014191e-01f, 1.44644424e-01f, 2.80358374e-01f, 8.31938237e-02f, -9.06689689e-02f, 7.56842643e-02f, 3.93448323e-02f, -2.07860515e-01f,
  2.76801307e-02f, 1.85049832e-01f, 1.93903744e-01f, 2.40952894e-01f, -1.92304775e-02f, 2.68394530e-01f, -1.68533951e-01f, -9.62221473e-02f, -1.87958255e-02f, -7.78584182e-03f,
  9.36189443e-02f, 1.93212017e-01f, -1.73323438e-01f, -4.90393490e-03f, 2.92208076e-01f, 8.65545943e-02f, 1.74894795e-01f, 2.16136232e-01f, 2.74693340e-01f, 1.45308778e-01f,
  3.90756205e-02f, 2.37346426e-01f, 2.33438313e-01f, -4.80761984e-03f, 2.31579915e-01f, 1.77511424e-01f, 2.51751930e-01f, -2.05664020e-02f, 2.07032524e-02f, 2.97824889e-01f,
  2.69665122e-01f, 1.73552670e-02f, 1.84505284e-02f, 1.10757045e-01f, 2.03798965e-01f, -1.05718903e-01f, -5.26821725e-02f, -2.88312417e-02f, 1.16232969e-01f, -1.15879551e-01f,
  -1.72075719e-01f, 1.50356323e-01f, -9.45849530e-03f, -1.98147297e-01f, 1.41510665e-01f, -4.52126674e-02f, 8.75557959e-02f, 1.16639838e-01f, 8.16056058e-02f, 8.43239874e-02f,
  -1.42237604e-01f, -7.82655627e-02f, 6.16867421e-03f, 1.33342102e-01f, -1.75849780e-01f, -1.79845214e-01f, 1.28913730e-01f, -3.59668545e-02f, 1.22574732e-01f, 2.03362294e-02f,
  -2.03988850e-01f, 1.87368482e-01f, 1.43316671e-01f, -1.49375752e-01f, -9.87287685e-02f, 1.40074238e-01f, -1.49288595e-01f, 8.23450089e-02f, 9.46336463e-02f, 2.05447853e-01f,
  4.44619991e-02f, 2.09216475e-02f, 1.20142223e-02f, 1.59191474e-01f, 1.96247429e-01f, -4.25507985e-02f, -2.91967541e-01f, -2.14450937e-02f, 6.09477311e-02f, 1.71920791e-01f,
  -1.62246734e-01f, 4.34391946e-02f, 1.58403233e-01f, 4.28142026e-02f, 9.70009714e-02f, 1.01308383e-01f, 1.31252497e-01f, -1.38018414e-01f, 9.07352641e-02f, 1.89521447e-01f,
  2.49596611e-01f, -1.01696476e-01f, -1.69362858e-01f, 1.20077573e-01f, -1.56457424e-01f, -6.28749207e-02f, 1.90508366e-03f, 1.90264925e-01f, 1.87736288e-01f, 1.10061496e-01f,
  3.72149684e-02f, 9.19920951e-02f, 2.26940438e-01f, -2.29928587e-02f, -1.02806702e-01f, 1.26516700e-01f, -1.21444546e-01f, 2.85097864e-02f, -4.03354913e-02f, 9.80168059e-02f,
  -2.09117755e-02f, -1.89612005e-02f, 9.74966772e-03f, -9.58144888e-02f, 7.84466416e-02f, -1.58405706e-01f, 3.75757813e-02f, -1.01342902e-01f, 1.02080666e-01f, 5.86136989e-02f,
  -1.24121774e-02f, 9.85410735e-02f, -4.66430746e-02f, 9.54763815e-02f, 3.06110363e-02f, 2.22220987e-01f, 1.74150988e-01f, 2.00729683e-01f, 2.57512122e-01f, -1.77294090e-01f,
  -3.69345546e-01f, 2.88536012e-01f, 5.74769787e-02f, 2.10084040e-02f, -5.35911359e-02f, 1.50543958e-01f, 2.48891070e-01f, -2.37977803e-01f, 1.73901364e-01f, 4.29226719e-02f,
  -2.44824942e-02f, 1.69407994e-01f, 3.25139947e-02f, -1.27945870e-01f, 3.09539847e-02f, 7.68201947e-02f, 3.73356432e-01f, 8.94045606e-02f, 1.33760348e-01f, 3.75675038e-02f,
  -1.21167354e-01f, 2.29304880e-01f, -4.48934212e-02f, 1.89793140e-01f, -5.48423640e-03f, 2.82636583e-01f, 9.94415879e-02f, 2.80847907e-01f, 1.02353670e-01f, -2.42598969e-02f,
  8.92163813e-03f, 1.92966580e-01f, -1.14102677e-01f, 1.70892030e-01f, -2.50762075e-01f, -2.58802682e-01f, 2.55457550e-01f, -3.84580456e-02f, -5.65777943e-02f, 1.34562910e-01f,
  2.13612452e-01f, 1.13748051e-01f, 1.15053676e-01f, -1.13199696e-01f, 2.37696290e-01f, 1.64322451e-01f, 4.07297798e-02f, 4.73953001e-02f, 8.39839503e-02f, 9.08029526e-02f,
  -1.11020796e-01f, 9.09319073e-02f, -1.18828498e-01f, -2.11397290e-01f, -1.68136343e-01f, -2.49606445e-01f, 4.50857952e-02f, 1.26839638e-01f, -3.27719152e-02f, 2.80539766e-02f,
  2.74973046e-02f, 3.13958377e-01f, -1.56389892e-01f, 1.01308487e-01f, 2.07234845e-01f, 5.79222105e-02f, -9.55887977e-03f, -3.16717952e-01f, 2.42953613e-01f, -3.90311070e-02f,
  -1.04126178e-01f, 1.56044751e-01f, 5.96951209e-02f, -1.66221529e-01f, 5.21118827e-02f, 1.62703201e-01f, 2.69342035e-01f, 1.76785961e-01f, 1.71000943e-01f, 3.05752546e-01f,
  -8.66865590e-02f, -1.08395264e-01f, -9.12491754e-02f, 2.85039455e-01f, 1.56361703e-02f, -2.73065805e-01f, 1.32933319e-01f, -6.26452565e-02f, -7.60227591e-02f, 1.76679149e-01f,
  -2.04072013e-01f, 5.22701815e-02f, -1.97642207e-01f, 1.87585711e-01f, 1.02398239e-01f, -1.94521338e-01f, -4.51570749e-02f, 2.32588947e-01f, -5.04034944e-03f, 9.07313973e-02f,
  -8.64689648e-02f, 2.78055906e-01f, 5.71932457e-02f, 4.69532683e-02f, 2.43584186e-01f, 1.63138241e-01f, 7.64722899e-02f, -2.80032288e-02f, -7.02504814e-03f, 1.24402992e-01f,
  -3.84166352e-02f, 1.04346476e-01f, 1.40550211e-01f, 6.16319850e-02f, 4.75088581e-02f, -2.36852765e-01f, 2.28449672e-01f, 1.27059579e-01f, 2.31155932e-01f, 1.62351340e-01f,
  2.57002354e-01f, 2.05122396e-01f, -2.31339544e-01f, 1.74424514e-01f, 2.00682282e-01f, -2.86357701e-02f, 1.25765681e-01f, 6.71961997e-03f, -5.97246587e-02f, -8.32737163e-02f,
  8.54054391e-02f, 2.32772887e-01f, 7.66969621e-02f, 3.23301613e-01f, 2.99209446e-01f, 1.39569060e-03f, -7.38283095e-04f, -1.88942552e-02f, 1.39009431e-01f, -1.14965744e-01f,
  -1.22387588e-01f, -3.29038091e-02f, -2.15570539e-01f, -2.20483422e-01f, -1.62323250e-03f, 2.02065587e-01f, -5.90122119e-02f, -1.15847081e-01f, 4.15157788e-02f, 9.41398889e-02f,
  -4.60184701e-02f, 1.25965491e-01f, -1.28744230e-01f, 1.36627093e-01f, 1.57347769e-01f, 7.22490922e-02f, 2.14220464e-01f, -1.27732828e-01f, 1.75047573e-02f, 1.95989981e-01f,
  2.22012922e-01f, -2.67021686e-01f, -1.15465127e-01f, 3.32754254e-01f, 2.24893191e-03f, 1.93786696e-01f, 1.87740698e-02f, 1.84295341e-01f, 1.21863730e-01f, -1.02426142e-01f,
  2.46862590e-01f, 1.15650244e-01f, 1.59910366e-01f, 4.89767343e-02f, -5.82208438e-03f, 1.89406410e-01f, -2.38864031e-02f, -4.80341949e-02f, 1.95935424e-02f, -1.21904708e-01f,
  -1.17871970e-01f, 8.67711660e-03f, 3.94400507e-02f, -6.13804013e-02f, 6.74654841e-02f, 2.20900886e-02f, -2.43444487e-01f, 1.52089268e-01f, 2.17958912e-01f, 8.22034548e-04f,
  -1.14882320e-01f, 6.16295710e-02f, 2.53268391e-01f, 2.18183056e-01f, -8.72091800e-02f, 2.10937157e-01f, -1.63602069e-01f, 1.98538154e-01f, 9.99374688e-02f, -4.09780815e-02f,
  2.64585495e-01f, -1.97701484e-01f, -3.72241884e-02f, 4.90598604e-02f, 7.96215162e-02f, 1.74723327e-01f, -1.03035979e-01f, -1.22808799e-01f, 2.35382557e-01f, 1.10371746e-02f,
  3.05645704e-01f, -1.12202317e-01f, 1.16372250e-01f, 3.01014166e-02f, 1.49473503e-01f, 1.58316642e-01f, 1.56346455e-01f, -9.43924189e-02f, 3.83019485e-02f, 2.19803322e-02f,
  -9.07812566e-02f, 7.23190606e-03f, 1.19148917e-01f, 9.83737707e-02f, 2.77038604e-01f, -7.62516558e-02f, -1.79632753e-01f, 1.42328858e-01f, 8.08962584e-02f, 1.84849858e-01f,
  -1.44463211e-01f, 1.51337877e-01f, -6.41021803e-02f, -2.71539502e-02f, 8.62583444e-02f, 1.74368620e-02f, 2.70023476e-02f, 7.42057413e-02f, 2.31508076e-01f, 1.60604611e-01f,
  -2.81390138e-02f, -5.63333090e-03f, 1.36548549e-01f, 4.57728915e-02f, -1.90818727e-01f, 9.42093879e-02f, -1.36639491e-01f, -6.47748215e-03f, 1.03854924e-01f, 2.09446028e-01f,
  1.51307791e-01f, 1.90657303e-01f, 4.86564226e-02f, 2.19082117e-01f, 2.26135597e-01f, 2.45048746e-01f, -1.35119230e-01f, -1.78727239e-01f, 9.65137035e-02f, 3.29522900e-02f,
  5.99541105e-02f, -1.16744667e-01f, 1.88314281e-02f, 2.80943979e-02f, -2.44288802e-01f, 2.44494498e-01f, -6.84074089e-02f, -4.63503413e-02f, -3.33172306e-02f, -1.24509700e-01f,
  2.26766482e-01f, 1.54750958e-01f, -1.22671977e-01f, -1.65735427e-02f, -2.18089312e-01f, 1.89191684e-01f, 8.99406746e-02f, -1.49550466e-02f, 6.81923926e-02f, -6.71769679e-02f,
  -7.60480985e-02f, 1.95306942e-01f, 5.03896102e-02f, -3.40559334e-02f, 1.64605439e-01f, 1.06880561e-01f, 1.28675416e-01f, -3.00149113e-01f, 8.22157413e-02f, -1.12570405e-01f,
  1.64589614e-01f, 1.94785576e-02f, -7.78882056e-02f, 1.00075148e-01f, 1.94541246e-01f, 4.86868396e-02f, 2.96579450e-02f, 1.85469836e-01f, 1.16615910e-02f, 5.51246181e-02f,
  1.04151227e-01f, 8.52331892e-02f, 2.38090292e-01f, 1.26399314e-02f, 3.15981284e-02f, 5.22857532e-02f, 1.09081946e-01f, 2.64333874e-01f, -2.83816248e-01f, -2.96542291e-02f,
  -2.22217694e-01f, -2.04817861e-01f, 1.30525678e-01f, -1.31604718e-02f, 2.97228724e-01f, 2.53501125e-02f, 1.08926818e-01f, 2.93276995e-01f, -5.39135607e-03f, 6.25236183e-02f,
  -1.40089348e-01f, -3.88425961e-03f, 7.68413991e-02f, -2.19982624e-01f, 2.98751593e-01f, -1.91443518e-01f, -6.18085824e-02f, 3.30835789e-01f, -2.98017357e-03f, 1.90080404e-01f,
  -9.60470885e-02f, -2.91989632e-02f, 1.49695277e-01f, 2.17920765e-01f, 2.09031805e-01f, 1.11711482e-02f, -1.81030706e-01f, -5.25191873e-02f, -1.30583122e-01f, 2.52325028e-01f,
  8.62724558e-02f, -6.60584345e-02f, 1.03945814e-01f, 1.81340408e-02f, 1.82790011e-01f, 9.63324681e-02f, 1.39586106e-01f, -3.78960408e-02f, 2.50634067e-02f, 1.10230967e-01f,
  1.97009236e-01f, -2.42845833e-01f, 1.14002116e-01f, -2.08144218e-01f, 3.32080930e-01f, -1.08997218e-01f, 1.26255795e-01f, 1.50236830e-01f, 2.58866400e-01f, -8.79749283e-02f,
  -6.45608529e-02f, 1.41497269e-01f, 6.15891218e-02f, 6.17033802e-02f, 1.07359864e-01f, 1.78870618e-01f, 1.36510029e-01f, 1.33671552e-01f, -8.96237567e-02f, 5.19315004e-02f,
  -2.26722330e-01f, 8.74473006e-02f, -2.52587209e-03f, -3.42254221e-01f, 1.10955700e-01f, -1.52055323e-01f, 2.89176077e-01f, 1.53392911e-01f, 5.05217984e-02f, 1.57698184e-01f,
  -1.34144470e-01f, 1.52302846e-01f, 2.28992581e-01f, 1.90652579e-01f, 2.16671526e-01f, -1.34870321e-01f, -9.90657732e-02f, 4.22669053e-02f, -1.46841690e-01f, -8.00694600e-02f,
  -1.00050427e-01f, -1.58611673e-03f, -1.96676582e-01f, 1.21787079e-01f, -1.13928974e-01f, 1.55810356e-01f, 2.79189378e-01f, -1.67667076e-01f, 1.37038141e-01f, 3.02926630e-01f,
  -1.18649706e-01f, 1.98324651e-01f, 8.51794705e-02f, 2.64435112e-01f, -7.89171159e-02f, -9.99623071e-03f, -8.86959434e-02f, -8.82733390e-02f, -1.83393866e-01f, 2.51097560e-01f,
  2.02323034e-01f, 9.86810848e-02f, 2.79584527e-01f, -2.36166269e-01f, 1.11469619e-01f, -2.01333743e-02f, 9.14195627e-02f, 2.38275319e-01f, 5.77264056e-02f, -1.23965189e-01f,
  2.73949932e-03f, -1.57070294e-01f, -7.82614350e-02f, -1.78230405e-01f, 2.25145206e-01f, -9.26133618e-02f, 3.20728153e-01f, -4.89161611e-02f, 9.47921425e-02f, 1.65741459e-01f,
  -6.13659713e-03f, 5.52226715e-02f, -1.47141730e-02f, -6.42135814e-02f, 1.03254758e-01f, 1.07309200e-01f, -2.20489338e-01f, -7.50542134e-02f, -8.36703479e-02f, -8.83971527e-02f,
  7.95924962e-02f, -6.21090904e-02f, -1.66304603e-01f, 1.78366587e-01f, 3.27648711e-03f, 4.44356389e-02f, -1.36981443e-01f, 5.78778982e-02f, 2.48220727e-01f, 1.04055338e-01f,
  2.07842179e-02f, 3.57795656e-02f, 1.84576362e-01f, 1.01814620e-01f, -7.28073791e-02f, 1.01193152e-01f, 2.81576008e-01f, -2.45911032e-01f, -2.07219776e-02f, 6.25427589e-02f,
  6.61898479e-02f, 1.45598754e-01f, -1.09801300e-01f, -7.43556023e-02f, 1.71168879e-01f, -1.81621313e-01f, 1.40202224e-01f, -1.68683559e-01f, -6.85878238e-03f, -2.97445549e-05f,
  2.51512557e-01f, 1.99283332e-01f, 1.39382616e-01f, -1.10616826e-01f, -6.57540187e-02f, 2.02401042e-01f, -1.42549947e-01f, 2.60556728e-01f, 1.73750848e-01f, -2.21170136e-03f,
  1.30156398e-01f, 8.59620348e-02f, -1.67246655e-01f, 1.32812127e-01f, 1.34950757e-01f, 1.17305584e-01f, 6.63256496e-02f, 2.69060224e-01f, -2.34741997e-02f, 1.49685889e-01f,
  -1.87360778e-01f, -7.31388479e-02f, -9.74634737e-02f, -2.39992272e-02f, -8.77051428e-02f, -5.28035760e-02f, 8.73687416e-02f, 3.28595340e-02f, -1.18352138e-01f, 2.03469560e-01f,
  -1.04247436e-01f, 1.22397251e-01f, 3.27120051e-02f, 7.13120401e-02f, -2.83661157e-01f, 2.00598493e-01f, 1.72099099e-01f, 2.05363095e-01f, 2.36547604e-01f, 1.52636379e-01f,
  -4.67955275e-03f, 9.63599160e-02f, -1.88658297e-01f, -1.67195294e-02f, 3.37142378e-01f, -1.78706571e-01f, 2.00555012e-01f, 1.10820226e-01f, -5.67194074e-02f, 6.98779821e-02f,
  1.12356417e-01f, -3.13826613e-02f, -2.21711583e-02f, -8.97554830e-02f, -8.54886621e-02f, 9.41130370e-02f, -9.45164710e-02f, 5.42505197e-02f, 2.84340113e-01f, -2.24250376e-01f,
  -6.43028766e-02f, -2.33732909e-02f, 2.73259997e-01f, 7.36152679e-02f, 1.50978178e-01f, 3.25612873e-02f, 2.45809183e-01f, 7.68571123e-02f, -1.30879164e-01f, -5.51851541e-02f,
  -8.85406509e-02f, 3.30069102e-02f, 3.21071744e-01f, 3.75103974e-03f, -3.84731293e-02f, 1.38920978e-01f, 2.58415908e-01f, -6.57070354e-02f, 2.37138718e-01f, -2.94509567e-02f,
  1.62604585e-01f, 1.73025236e-01f, -1.88471243e-01f, 2.53343910e-01f, -1.47361740e-01f, 2.29513809e-01f, 8.19711983e-02f, 1.84722498e-01f, 2.16767207e-01f, 1.30338237e-01f,
  1.93013221e-01f, 5.03586791e-02f, 5.08921258e-02f, 3.83958183e-02f, 9.24330875e-02f, -4.01300117e-02f, -1.38112068e-01f, -1.72826573e-01f, -7.52385631e-02f, 5.88502623e-02f,
  5.21215759e-02f, 1.01754829e-01f, -1.15029722e-01f, 1.71495043e-02f, -4.70978208e-02f, -4.94450852e-02f, 1.43390104e-01f, -1.16274439e-01f, 5.49571998e-02f, 1.54720023e-01f,
  8.32633525e-02f, 1.29213497e-01f, 1.17652453e-01f, -1.15267694e-01f, 1.52451143e-01f, -2.76105404e-01f, 1.42302155e-01f, 5.75974695e-02f, 1.46804109e-01f, -6.49260879e-02f,
  -1.39360294e-01f, 7.31001645e-02f, -6.89062923e-02f, 1.88152507e-01f, 1.24942154e-01f, 1.44088551e-01f, 1.21504970e-01f, -3.06397796e-01f, -1.66881919e-01f, 5.73961325e-02f,
  8.89123678e-02f, 1.67971924e-01f, -1.50170088e-01f, -2.49482244e-02f, -7.94031098e-02f, 7.46326521e-02f, -1.28489986e-01f, 2.17203096e-01f, 8.11647698e-02f, 3.01616210e-02f,
  -1.18026614e-01f, 7.32648373e-02f, -2.20948040e-01f, 1.50371656e-01f, 1.18653543e-01f, 9.26968008e-02f, 2.79709935e-01f, 1.28545716e-01f, 9.72586498e-02f, 1.55986905e-01f,
  1.00066565e-01f, 3.82275097e-02f, 1.42105252e-01f, 1.02412656e-01f, 6.26991615e-02f, -9.44574103e-02f, 1.21564254e-01f, -2.33060598e-01f, 2.47951865e-01f, -2.32703239e-02f,
  -1.65103702e-03f, -1.25222474e-01f, -1.52052850e-01f, -8.42655525e-02f, -1.55244291e-01f, -6.68378845e-02f, 1.13568082e-01f, -7.45352283e-02f, -4.35617007e-02f, -1.14751212e-01f,
  1.37475550e-01f, 3.09546977e-01f, -1.90311432e-01f, 1.60296455e-01f, -1.78923100e-01f, 3.28073710e-01f, 3.57582837e-01f, -2.51744479e-01f, 2.46881098e-01f, -1.47436842e-01f,
  1.99075937e-01f, 2.31120959e-01f, 1.43125057e-01f, 3.73760201e-02f, -1.73785508e-01f, -1.94427967e-01f, 1.45853966e-01f, 2.34429792e-01f, 3.01283002e-01f, -2.04253510e-01f,
  -6.19602948e-02f, 1.91255018e-01f, 9.52088237e-02f, 1.69491515e-01f, 4.39490676e-02f, -6.94246143e-02f, -2.33367831e-02f, 2.23289490e-01f, -3.58821601e-02f, 1.17340513e-01f,
  -3.67480218e-02f, 1.77985325e-01f, 2.16451570e-01f, 2.23937184e-02f, -2.64619052e-01f, 2.59880066e-01f, 1.44788370e-01f, 1.00224115e-01f, -1.25462726e-01f, 1.46714061e-01f,
  2.16430441e-01f, -9.80444029e-02f, -4.00732644e-02f, -4.11422700e-02f, 1.66761931e-02f, 1.72642827e-01f, 1.92708239e-01f, 9.78660956e-02f, -1.90995040e-03f, -5.06954603e-02f,
  1.17584519e-01f, -8.77154693e-02f, 1.86035693e-01f, 7.65406638e-02f, -3.07902545e-01f, -2.54476607e-01f, -2.50602782e-01f, 6.72909170e-02f, 5.45343719e-02f, -5.57861589e-02f,
  -1.28115892e-01f, 3.19764972e-01f, -8.14068094e-02f, -1.43394828e-01f, 1.77672416e-01f, 2.12834641e-01f, 2.06859857e-01f, -4.08906564e-02f, 5.23194894e-02f, 1.99811503e-01f,
  2.24237442e-01f, -8.02832544e-02f, -3.24283242e-02f, -1.24555208e-01f, 1.33540735e-01f, 2.41301790e-01f, 1.75677106e-01f, 1.90577190e-02f, -1.55251017e-02f, 1.80985838e-01f,
  -4.30745212e-03f, 4.78502028e-02f, 4.92483340e-02f, 7.66779780e-02f, -2.72754282e-02f, 3.41993757e-02f, 5.02094105e-02f, -4.00966220e-02f, -8.22565183e-02f, 2.55677223e-01f,
  2.28953827e-02f, 8.34798440e-02f, -4.25161794e-03f, 2.04293236e-01f, -2.08862841e-01f, -3.33174430e-02f, 2.04127535e-01f, -1.84168387e-03f, -1.72725562e-02f, 3.39594871e-01f,
  -1.53632239e-01f, 3.32555741e-01f, 2.10900679e-01f, 1.52460802e-02f, 1.81469753e-01f, 1.83917955e-01f, -1.81522816e-01f, 5.51729985e-02f, 1.45752907e-01f, 7.88732171e-02f,
  1.25380710e-01f, 2.02075452e-01f, 1.49587810e-01f, 1.53790534e-01f, -2.39424020e-01f, 1.51818711e-02f, -5.71654327e-02f, -1.98528096e-01f, -1.05979508e-02f, -8.09906945e-02f,
  4.56420928e-02f, 2.35858336e-01f, -1.79262720e-02f, 7.29970783e-02f, 5.89587055e-02f, 2.01425210e-01f, -1.95717871e-01f, -7.93322325e-02f, 3.12741458e-01f, 1.28877923e-01f,
  2.67510802e-01f, 9.70094875e-02f, 1.22455321e-01f, 1.20485865e-01f, 1.19317994e-01f, 3.72496247e-02f, 9.82568562e-02f, -3.04426521e-01f, 5.91177307e-03f, 1.18125767e-01f,
  2.23523587e-01f, -6.44028932e-02f, -2.11984646e-02f, 1.71490818e-01f, -5.70002990e-03f, -1.20269746e-01f, 9.86395478e-02f, -2.55549587e-02f, -1.18065797e-01f, -2.00082064e-01f,
  6.16397560e-02f, -1.93813324e-01f, 6.66046143e-02f, 2.05144405e-01f, -2.66297698e-01f, 9.37335193e-02f, -1.36298938e-02f, 2.44603202e-01f, 1.03427963e-02f, 8.86111110e-02f,
  9.50441435e-02f, 3.44436169e-01f, -1.84105933e-01f, 1.78335771e-01f, 3.70626664e-03f, 2.36346915e-01f, 8.48672092e-02f, -8.42576325e-02f, 1.37341112e-01f, 6.40891418e-02f,
  -6.22519292e-02f, -6.18299320e-02f, 7.67816901e-02f, 1.82875786e-02f, 1.79480091e-01f, 9.97569114e-02f, -4.73635122e-02f, 8.45420137e-02f, -4.05699201e-02f, 1.43712118e-01f,
  -1.37216672e-01f, -2.42853060e-01f, 3.35169807e-02f, -1.08358860e-01f, 1.41121969e-02f, 6.13178201e-02f, -1.27296582e-01f, 2.11828910e-02f, 9.25229117e-02f, 1.52842730e-01f,
  -2.50372827e-01f, 2.41884619e-01f, 2.40795910e-01f, 2.02954829e-01f, 2.22798623e-02f, -8.80637914e-02f, 1.93899095e-01f, 1.14735007e-01f, 8.01931322e-02f, 1.33573890e-01f,
  1.71052173e-01f, -2.75512248e-01f, -1.38198733e-01f, 6.57628924e-02f, 1.15674078e-01f, 7.65882730e-02f, 1.37704154e-02f, 3.89645956e-02f, 5.09988777e-02f, -1.41121373e-01f,
  1.98474884e-01f, 4.26750295e-02f, -8.41670632e-02f, 3.81710753e-02f, 2.25115314e-01f, 2.13920958e-02f, 4.82580625e-02f, 8.21016263e-03f, -2.20095754e-01f, 1.92000344e-01f,
  -2.49004841e-01f, 1.62783310e-01f, 3.51511464e-02f, -9.55480784e-02f, 1.00814328e-01f, 1.75772130e-01f, -4.30955403e-02f, 8.31419900e-02f, 1.50463998e-01f, 1.54496387e-01f,
  3.28593180e-02f, 8.08010846e-02f, -1.85898930e-01f, -3.61423679e-02f, -1.32306978e-01f, -1.47287160e-01f, -7.72781894e-02f, 7.46334577e-03f, -4.05970775e-02f, 1.44768581e-02f,
  1.30114704e-01f, 5.86984232e-02f, -2.07808055e-02f, -1.58820257e-01f, 1.42192975e-01f, 2.10448772e-01f, -8.19387063e-02f, 1.23339154e-01f, 1.88982226e-02f, 3.41981649e-02f,
  5.85323870e-02f, 8.74020532e-02f, 3.20887677e-02f, -1.14436530e-01f, 2.42984891e-01f, -6.51627555e-02f, -1.45279288e-01f, 9.33993049e-03f, -2.48745875e-03f, 2.33342856e-01f,
  -1.64059296e-01f, 1.74203470e-01f, 4.04627234e-01f, 2.06495784e-02f, -1.83061719e-01f, 1.15104377e-01f, 3.10960114e-01f, 1.27892092e-01f, 1.46516096e-02f, -3.29441428e-01f,
  1.70903042e-01f, -2.44875997e-01f, -4.84461300e-02f, 3.17644954e-01f, 8.70974138e-02f, 9.48199928e-02f, 7.84823596e-02f, 1.03147015e-01f, -4.18765768e-02f, 5.93615323e-02f,
  -2.62054741e-01f, 1.64498448e-01f, 2.85909265e-01f, 9.80283394e-02f, 6.47222102e-02f, 1.60966545e-01f, -3.77526786e-03f, 1.55637264e-01f, 1.99661344e-01f, -3.48559350e-01f,
  1.92140415e-01f, 1.30036309e-01f, -4.77025583e-02f, 9.59201902e-02f, -1.83918048e-02f, -9.98802856e-02f, 1.08868510e-01f, -6.95636347e-02f, 2.49094531e-01f, 4.38108742e-02f,
  6.68493286e-02f, -1.96920887e-01f, -1.61103942e-02f, -7.76635930e-02f, 2.27726195e-02f, -1.87761169e-02f, -1.41500637e-01f, 1.91735834e-01f, -1.47859260e-01f, -1.49510756e-01f,
  2.15626910e-01f, 1.72156483e-01f, 8.42493251e-02f, 1.15343496e-01f, 1.26919728e-02f, 1.27910033e-01f, 2.34471172e-01f, -1.38567939e-01f, 3.12222727e-02f, 1.92557976e-01f,
  -2.32804403e-01f, 1.38712958e-01f, 1.19028568e-01f, -3.16055156e-02f, 1.63590372e-01f, -2.65725881e-01f, -1.07676849e-01f, 2.44772419e-01f, 3.25611383e-02f, 1.54222950e-01f,
  1.58442575e-02f, 2.45411135e-02f, -1.82028681e-01f, 2.33262658e-01f, 5.42544685e-02f, -5.62636442e-02f, 2.51025140e-01f, -1.19606718e-01f, -1.19341679e-01f, -2.81979120e-03f,
  4.21571583e-02f, 2.44122073e-01f, 5.26264720e-02f, 1.31128982e-01f, 1.26614943e-01f, -2.24203646e-01f, 1.90555573e-01f, 2.63660364e-02f, -1.90299414e-02f, 9.22492221e-02f,
  2.10893854e-01f, -1.62799194e-01f, -1.37251735e-01f, -8.58028755e-02f, 1.82549581e-01f, -6.92092115e-03f, 3.17920566e-01f, -1.31637871e-01f, 2.01534525e-01f, 1.51291071e-03f,
  -2.34091863e-01f, -3.35707739e-02f, 1.45932846e-02f, -2.53247824e-02f, -6.02078363e-02f, -3.76282111e-02f, 7.40490854e-02f, -8.67964849e-02f, 1.41401738e-01f, -2.11572852e-02f,
  1.01525486e-01f, 9.18414593e-02f, 8.85631815e-02f, 3.20270479e-01f, 7.09635764e-03f, -4.98061115e-03f, -2.24722609e-01f, 9.89882275e-02f, 2.15074047e-01f, 3.18222821e-01f,
  1.03278145e-01f, 7.61904046e-02f, 6.16386831e-02f, 1.39223054e-01f, -3.14349204e-01f, 6.57578558e-03f, 1.99985996e-01f, -2.29613427e-02f, 8.96648541e-02f, 2.40145594e-01f,
  8.53968859e-02f, 1.55038431e-01f, -1.34778276e-01f, 1.67334318e-01f, 1.56680733e-01f, 1.31224841e-01f, -6.79187924e-02f, -8.50984529e-02f, 1.48441032e-01f, -1.22320674e-01f,
  3.44365425e-02f, -3.18555790e-03f, 1.30711600e-01f, 8.10977519e-02f, 1.33525133e-01f, 2.60259837e-01f, -1.23891756e-01f, 1.58768952e-01f, 1.00246392e-01f, 1.61933690e-01f,
  2.45639279e-01f, -1.23441242e-01f, -2.48384122e-02f, 9.00726691e-02f, 2.68861800e-01f, -2.12147199e-02f, 4.52567881e-04f, -2.06901208e-02f, 2.84245729e-01f, -2.72066653e-01f,
  2.87636012e-01f, 9.59879681e-02f, 2.91042298e-01f, -4.61192615e-02f, 9.87117216e-02f, 2.58530676e-01f, -6.46773353e-02f, 8.49489272e-02f, 1.76857531e-01f, 1.58108726e-01f,
  -1.21912405e-01f, 3.76886390e-02f, 6.55383803e-04f, 4.98979725e-02f, -2.44228125e-01f, -2.70938016e-02f, -2.05734409e-02f, -2.65157133e-01f, 8.65476727e-02f, -9.45111141e-02f,
  1.50442556e-01f, 1.57583937e-01f, -1.59792781e-01f, 7.41747767e-02f, -1.31239563e-01f, -2.26022542e-01f, 2.26405606e-01f, 5.32728136e-02f, 8.62596780e-02f, 2.47668535e-01f,
  -2.56351411e-01f, 2.13516057e-01f, -1.21454597e-01f, -2.70592660e-01f, 4.44697104e-02f, -2.58047301e-02f, 5.58832549e-02f, 1.92370266e-01f, 2.04968229e-02f, 1.36077523e-01f,
  1.15170635e-01f, 8.63190591e-02f, 4.26303819e-02f, 6.90541491e-02f, 1.93970844e-01f, 1.69702113e-01f, 1.34084657e-01f, 1.37414008e-01f, 1.11360379e-01f, 2.81058196e-02f,
  1.93812922e-01f, -6.57191640e-03f, -1.14377312e-01f, 1.53018504e-01f, 2.04095289e-01f, 1.80292368e-01f, 3.09082836e-01f, -3.18231210e-02f, -1.46153308e-02f, -2.03022081e-02f,
  1.11756697e-01f, -1.36904046e-01f, -4.91408817e-02f, 1.80806309e-01f, -6.34337266e-05f, -1.83911055e-01f, -3.71919312e-02f, 9.85480174e-02f, -5.03752613e-04f, -1.47520825e-01f,
  2.52192467e-01f, -4.63285446e-02f, -6.52406365e-03f, 1.37176082e-01f, 3.02965473e-02f, 3.59113589e-02f, 8.48522857e-02f, -8.32916275e-02f, -6.38335496e-02f, 3.13254707e-02f,
  -8.88062418e-02f, 7.17255399e-02f, -1.53135598e-01f, -4.99762110e-02f, -4.24567759e-02f, -1.15433909e-01f, 1.69050246e-01f, 1.78629994e-01f, -1.29277855e-01f, -1.69939455e-02f,
  1.93068534e-01f, -1.77137762e-01f, -2.30033785e-01f, 2.34535977e-01f, -2.77753137e-02f, 5.96069032e-03f, 7.34168664e-02f, 2.40260437e-01f, 1.68881744e-01f, -5.89224063e-02f,
  6.64002146e-04f, 3.11824381e-01f, 1.76095247e-01f, 2.68787563e-01f, 7.25446641e-02f, -2.83738941e-01f, 2.10543826e-01f, -1.78316951e-01f, -1.55437469e-01f, 1.71568677e-01f,
  8.14912468e-02f, -2.23735750e-01f, -1.08350649e-01f, 2.13534176e-01f, 1.56992003e-01f, -3.56399789e-02f, -2.11221740e-01f, 5.39350994e-02f, 3.03318560e-01f, 2.22103938e-01f,
  -4.92901774e-04f, 2.79255748e-01f, -1.92544863e-01f, 2.42378153e-02f, 2.14475855e-01f, -1.52483433e-01f, 1.31662130e-01f, 4.06212360e-02f, -3.48312035e-02f, -5.38881384e-02f,
  2.15847462e-01f, -1.23330981e-01f, -3.30404416e-02f, 1.81662709e-01f, 4.97084856e-02f, -9.97210890e-02f, 4.70489934e-02f, -8.93789902e-03f, -1.01058789e-01f, 7.37815723e-02f,
  -8.98555592e-02f, 1.25583753e-01f, -2.85827219e-02f, 2.11186975e-01f, -7.99970701e-02f, 3.35522220e-02f, 1.71656519e-01f, 1.85189873e-01f, 1.78977728e-01f, 1.88711137e-01f,
  9.50694382e-02f, 2.34009698e-02f, 1.11938596e-01f, 3.02016269e-03f, 5.82080754e-03f, 2.77779073e-01f, -1.97941288e-01f, -1.32476345e-01f, 3.63129191e-02f, 6.39183298e-02f,
  6.74346238e-02f, -1.61305115e-01f, -2.82590389e-01f, 3.16443920e-01f, 3.15840654e-02f, -5.74394949e-02f, -5.61043061e-02f, -1.95039541e-01f, -9.48072597e-02f, 2.37789348e-01f,
  -3.55909988e-02f, -2.75443904e-02f, -4.49872985e-02f, 3.07150744e-02f, -1.13631329e-02f, 8.40013195e-03f, 2.26688728e-01f, 2.10379884e-01f, 2.31279105e-01f, 1.02933571e-01f,
  2.77364224e-01f, -1.82679191e-01f, 1.37351587e-01f, 1.17675081e-01f, -3.00054029e-02f, 8.71586204e-02f, 2.54938930e-01f, -3.15570720e-02f, 2.00895593e-02f, -9.32345465e-02f,
  2.99619198e-01f, -1.51081130e-01f, 1.84635505e-01f, -1.58422496e-02f, 2.24908456e-01f, -1.06925435e-01f, -2.61773109e-01f, 1.04826935e-01f, 1.77445710e-01f, -9.72023308e-02f,
  -1.87948972e-01f, -1.54765651e-01f, -1.05286300e-01f, -7.65850488e-03f, -1.97285749e-02f, 2.95276679e-02f, -1.27188519e-01f, -1.55762240e-01f, -1.42026976e-01f, 5.50006889e-03f,
  2.53558040e-01f, 1.17539167e-01f, 1.02071069e-01f, 9.34113488e-02f, 6.32312447e-02f, 2.21476965e-02f, -1.20152133e-02f, 1.25039384e-01f, 1.87464267e-01f, -8.37056711e-02f,
  -3.12430054e-01f, -1.73618272e-01f, 2.22909287e-01f, 9.66478512e-03f, -1.04644388e-01f, 9.51379091e-02f, 1.82320625e-01f, 1.69040561e-01f, -1.90029368e-02f, 1.47827730e-01f,
  5.18244356e-02f, -6.37431964e-02f, -2.78356522e-01f, 8.15551504e-02f, -1.68521088e-02f, -1.23105451e-01f, -3.22218426e-02f, 1.58562005e-01f, -5.87928742e-02f, -1.11809164e-01f,
  1.77565694e-01f, 2.96577722e-01f, 2.10892241e-02f, 1.82789505e-01f, -1.16712302e-01f, 7.63421878e-02f, 2.19088241e-01f, -2.29303706e-02f, 4.30811010e-02f, -1.28944963e-01f,
  4.47722450e-02f, -8.46646652e-02f, 3.70286740e-02f, -1.70332313e-01f, 1.82077512e-01f, -8.54793191e-02f, 3.06690007e-01f, -8.06621462e-02f, 1.25779435e-01f, 2.88739335e-02f,
  4.54920940e-02f, 1.24812618e-01f, 9.14878920e-02f, 2.59358380e-02f, 1.70373634e-01f, 8.82636607e-02f, 4.71891724e-02f, 7.69724846e-02f, -5.08791581e-02f, 2.16319293e-01f,
  -2.90109426e-01f, 2.38313660e-01f, -1.75600156e-01f, -2.02751175e-01f, -1.63428560e-01f, -2.40469679e-01f, -1.32095650e-01f, 1.48966476e-01f, 3.25152129e-01f, 1.56197026e-01f,
  5.91798723e-02f, 7.89886639e-02f, -6.57591671e-02f, 7.39902183e-02f, 1.25095695e-01f, -5.76909184e-02f, 3.15697342e-01f, -2.07901955e-01f, 2.92672843e-01f, -1.98161781e-01f,
  -1.62268475e-01f, 1.07444711e-01f, 1.48124129e-01f, -2.28950158e-01f, -1.14617512e-01f, 1.72391921e-01f, 1.58951715e-01f, 1.00276798e-01f, 4.20792103e-02f, 3.17377299e-01f,
  -9.24312025e-02f, -1.63355276e-01f, 4.39658426e-02f, 6.92358389e-02f, -3.74526829e-02f, 2.17559785e-02f, 6.93821460e-02f, -1.52071744e-01f, 7.90289044e-02f, -5.77951856e-02f,
  -8.33766684e-02f, 1.46930158e-01f, -2.69866019e-01f, 1.92157820e-01f, 1.06276102e-01f, -3.44986580e-02f, 5.38940728e-03f, 3.17506462e-01f, 1.54015362e-01f, -1.81498364e-01f,
  2.59052604e-01f, 1.58315137e-01f, 1.97120428e-01f, -1.37626290e-01f, 8.06123093e-02f, 2.59600312e-01f, 3.95921394e-02f, -1.07613951e-01f, 5.39747514e-02f, 3.72089283e-03f,
  -8.12536404e-02f, 5.04398942e-02f, -2.50107106e-02f, -1.72188044e-01f, -2.71275014e-01f, 1.49752110e-01f, -1.77336916e-01f, -3.12305599e-01f, -1.36092687e-02f, 1.83764938e-02f,
  1.03370368e-01f, 6.88314661e-02f, -2.16773346e-01f, 8.73008184e-03f, -1.34887815e-01f, -1.59340054e-01f, 1.38163030e-01f, 4.99115288e-02f, 5.84989414e-02f, 1.85979083e-01f,
  -5.75216338e-02f, 3.93272974e-02f, -4.74956632e-02f, -2.16104776e-01f, 7.82939047e-02f, -2.11322397e-01f, 2.70500958e-01f, 1.06501013e-01f, 4.94362749e-02f, 1.19181551e-01f,
  1.24257177e-01f, -3.25270370e-02f, -3.80091108e-02f, 3.03958170e-02f, 2.33467460e-01f, -1.47403199e-02f, 1.23769948e-02f, 9.15930644e-02f, 1.14843972e-01f, -6.26916438e-02f,
  2.13378489e-01f, 1.02485437e-02f, -1.65318087e-01f, -1.25431838e-02f, 1.71281338e-01f, 8.16313401e-02f, 1.85402781e-01f, 1.20558336e-01f, 4.03558603e-03f, 1.49816170e-01f,
  5.68229631e-02f, 1.22656308e-01f, 5.45537248e-02f, 1.34775132e-01f, -5.98010793e-02f, -1.91087008e-01f, -4.48491201e-02f, 1.74934477e-01f, 9.10794288e-02f, -1.51640540e-02f,
  7.21698701e-02f, -1.60126567e-01f, -8.51836354e-02f, -3.13615128e-02f, -7.66979605e-02f, 1.03739975e-02f, -8.48784596e-02f, -1.83750633e-02f, 1.11495949e-01f, 9.50258523e-02f,
  -1.65474981e-01f, -1.39902338e-01f, 2.34839886e-01f, 3.16759199e-01f, 1.37536332e-01f, 1.12151794e-01f, -1.63660482e-01f, 1.11151747e-01f, 1.50038376e-02f, -1.86159194e-01f,
  7.97106847e-02f, 1.34309649e-01f, -7.50179365e-02f, 7.63599277e-02f, -1.88392118e-01f, 1.61155254e-01f, -1.10922776e-01f, -1.47725828e-02f, -9.06470045e-03f, 4.13677469e-02f,
  1.72568843e-01f, -8.28216299e-02f, -1.36373237e-01f, -9.77602229e-02f, 8.78852661e-05f, 2.17293259e-02f, 2.83057895e-02f, 4.66127545e-02f, 7.82927647e-02f, 1.22641763e-02f,
  1.75063238e-01f, 1.60476342e-01f, 3.90586210e-03f, -1.02167353e-01f, 1.52288575e-03f, 8.15472379e-02f, 1.80016905e-01f, -2.35833168e-01f, -2.26425659e-02f, 1.24753639e-01f,
  -9.87068191e-02f, -1.00408703e-01f, 1.66720703e-01f, 1.80702493e-01f, 3.01262829e-02f, -7.55617023e-02f, 1.34260148e-01f, -2.89500982e-01f, 1.78803399e-01f, -2.09708318e-01f,
  -2.01078087e-01f, 6.55223653e-02f, 5.55423424e-02f, -2.01887533e-01f, 1.78015709e-01f, 1.38157189e-01f, 1.54813111e-01f, -1.39060587e-01f, -1.64089784e-01f, 9.86481830e-02f,
  -1.55104265e-01f, -4.59205359e-02f, -3.91923040e-01f, 1.88382089e-01f, -1.57611176e-01f, -3.56076509e-01f, -5.44522628e-02f, 3.50681245e-02f, -2.96568591e-02f, 6.46582469e-02f,
  1.67257026e-01f, 1.45637259e-01f, -4.75494228e-02f, -9.24548879e-02f, -3.92362801e-03f, 2.48734299e-02f, 1.67669371e-01f, 1.80063412e-01f, 4.00343463e-02f, -9.46702659e-02f,
  5.45388162e-02f, -1.92438260e-01f, -3.02164823e-01f, 3.76491956e-02f, 2.54392564e-01f, -6.34060502e-02f, 2.80735437e-02f, -3.30223031e-02f, 8.31081122e-02f, 7.06861019e-02f,
  1.98659644e-01f, 2.19743192e-01f, 1.17564738e-01f, -1.24758817e-01f, 2.92894151e-02f, 1.34019703e-02f, 9.10511911e-02f, -1.90966986e-02f, 1.27132550e-01f, 5.22155240e-02f,
  4.57494098e-05f, -4.56382930e-02f, 1.23390066e-03f, 2.73472935e-01f, -1.82364762e-01f, 1.02080233e-01f, 1.29994839e-01f, -8.46999139e-02f, 4.22167685e-03f, 1.86513975e-01f,
  2.15502545e-01f, 7.41477385e-02f, 2.32039988e-01f, -1.20435625e-01f, 2.30983235e-02f, 6.10036626e-02f, 2.18872614e-02f, 2.55421014e-03f, -1.60124153e-02f, -8.44634771e-02f,
  3.98643091e-02f, -4.32742909e-02f, 1.57925978e-01f, 5.20296060e-02f, 2.39586413e-01f, 1.64936423e-01f, 5.41777685e-02f, -2.74722558e-02f, -4.46329936e-02f, 2.02635571e-01f,
  1.77250043e-01f, -9.79974568e-02f, 2.92438775e-01f, 1.08737729e-01f, 1.18804157e-01f, -2.11163275e-02f, -1.41904071e-01f, -1.34587944e-01f, 9.91744027e-02f, 1.98418170e-01f,
  6.80588409e-02f, -6.74564838e-02f, -3.48785892e-02f, 2.12288961e-01f, 4.45093848e-02f, -1.15192190e-01f, 8.53738710e-02f, 3.70318443e-01f, -2.02119374e-03f, -8.22220519e-02f,
  2.59445757e-01f, -9.33377221e-02f, -2.72825472e-02f, -7.53930137e-02f, 1.09765187e-01f, -1.81724191e-01f, -2.94405907e-01f, 3.30801666e-01f, -1.53808132e-01f, 2.43749484e-01f,
  1.41991600e-01f, -4.38786820e-02f, 1.44290850e-01f, -4.78314906e-02f, -2.75393389e-02f, -1.77707121e-01f, 1.38422310e-01f, -1.24130197e-01f, 1.06407627e-01f, 2.52487902e-02f,
  1.22353293e-01f, -6.88055828e-02f, 2.82924116e-01f, -3.61400902e-01f, 4.15214777e-01f, 3.09035838e-01f, -1.02923907e-01f, 6.98893294e-02f, 8.90067443e-02f, -3.45350504e-02f,
  1.98223352e-01f, 1.21692635e-01f, 1.07687250e-01f, 2.36162350e-01f, 1.24005616e-01f, 5.82644269e-02f, 1.57259122e-01f, 3.45904864e-02f, 2.42729396e-01f, 9.59002599e-02f,
  1.44465685e-01f, 9.70658511e-02f, 2.15370029e-01f, 7.35025853e-02f, 1.80443693e-02f, -7.78828934e-02f, -6.35724515e-02f, -1.55335024e-01f, 2.26604432e-01f, 8.21452066e-02f,
  1.47378340e-01f, 2.32512727e-02f, 2.41797194e-01f, 2.03176424e-01f, -2.23884843e-02f, 4.83015105e-02f, -4.32430580e-02f, -1.05462626e-01f, 2.09224910e-01f, -2.49618404e-02f,
  -1.69559326e-02f, 2.20095128e-01f, -8.58060271e-02f, 1.71346903e-01f, 3.92900944e-01f, -3.52471210e-02f, -1.64665058e-01f, 5.28372005e-02f, 1.36482436e-02f, -1.48446009e-01f,
  -9.10765529e-02f, 2.65841722e-01f, -2.55557001e-01f, 1.02305286e-01f, 2.86583185e-01f, 1.12504363e-02f, 4.91681807e-02f, 2.17616603e-01f, 1.34332711e-02f, 1.05428912e-01f,
  1.08035155e-01f, 9.79284104e-03f, 2.60498077e-01f, -2.31912620e-02f, -1.96369421e-02f, 1.08966775e-01f, -3.38005759e-02f, -3.87938380e-01f, 2.25175008e-01f, 2.76243091e-01f,
  -6.91389665e-02f, 1.24129839e-02f, 7.99176544e-02f, 1.95618659e-01f, 8.38381201e-02f, 1.74869984e-01f, 1.35107324e-01f, 3.13254595e-01f, 9.87215489e-02f, -1.41431481e-01f,
  8.38073120e-02f, -1.78830288e-02f, -9.12709087e-02f, -2.08162684e-02f, 1.74519882e-01f, -6.37788791e-03f, -4.05214354e-02f, 1.66762263e-01f, 1.00674234e-01f, -2.23711468e-02f,
  5.92987463e-02f, 1.38410091e-01f, -1.31588906e-01f, 3.46659770e-04f, 2.14791641e-01f, 2.23475024e-02f, -2.27329448e-01f, 1.51267767e-01f, 1.96500905e-02f, 1.46747649e-01f,
  1.50228202e-01f, 4.16870005e-02f, -3.24027892e-03f, -1.23115396e-02f, -8.09469670e-02f, 2.58402526e-01f, 1.81615144e-01f, -3.20633650e-01f, -3.64598893e-02f, -2.72217512e-01f,
  1.15771741e-01f, 2.15818509e-01f, -7.64211938e-02f, -1.32035896e-01f, 2.03088626e-01f, -1.37749270e-01f, -4.61375676e-02f, 1.62355676e-01f, 2.35365748e-01f, 2.39397157e-02f,
  2.71362782e-01f, 1.96513534e-01f, 1.68131277e-01f, -1.62515610e-01f, -1.45168588e-01f, 9.28697269e-03f, -1.87455133e-01f, -3.02994642e-02f, 2.49648735e-01f, -3.13134976e-02f,
  1.41784459e-01f, -2.38585308e-01f, -6.74272105e-02f, 1.61789596e-01f, 8.11875165e-02f, 3.99778448e-02f, 3.50868255e-02f, 2.54856050e-01f, -1.61945522e-01f, 1.48016289e-01f,
  -1.32221997e-01f, 6.00029640e-02f, 1.77564278e-01f, 1.65078655e-01f, 1.12245880e-01f, 1.05928950e-01f, 1.37352040e-02f, -4.50070687e-02f, -2.54864663e-01f, 4.26270291e-02f,
  1.51686653e-01f, -6.05299994e-02f, 1.14248805e-01f, -8.19758628e-04f, 2.29116395e-01f, 4.67111468e-02f, 1.32403046e-01f, 1.30029485e-01f, -3.61463837e-02f, -8.89047608e-03f,
  1.15850337e-01f, 1.89878672e-01f, 1.68960631e-01f, -2.59664744e-01f, -2.03940541e-01f, 1.06274694e-01f, -1.30361021e-01f, -9.08664539e-02f, 7.65656754e-02f, -3.88229303e-02f,
  -5.64557575e-02f, 2.01379344e-01f, 3.71563435e-02f, 8.49715397e-02f, 6.93279803e-02f, 8.69258866e-02f, 1.85210437e-01f, 1.60031587e-01f, -9.46896598e-02f, 2.58037984e-01f,
  5.13964556e-02f, 2.59395033e-01f, 4.68111075e-02f, -1.86828524e-01f, 1.17573515e-01f, -9.62415040e-02f, -3.43941711e-02f, 2.47350335e-01f, 1.79912850e-01f, 1.67701580e-03f,
  2.88743705e-01f, -2.64927238e-01f, 1.22261725e-01f, -9.63749364e-02f, 5.80674261e-02f, -1.48761556e-01f, 9.03859511e-02f, 2.80578015e-03f, -1.63697869e-01f, -2.23627061e-01f,
  -1.40549093e-01f, -1.75569430e-01f, 5.94833642e-02f, -2.72842109e-01f, 3.22904468e-01f, 2.16048345e-01f, 3.37399095e-02f, 1.20350882e-01f, 9.93526429e-02f, 4.26518992e-02f,
  -5.45552261e-02f, -7.67149851e-02f, -1.63316861e-01f, -1.33810058e-01f, 4.82476726e-02f, -2.87017345e-01f, 1.02701411e-01f, -9.01046619e-02f, 2.21982047e-01f, 1.04666322e-01f,
  -9.36616138e-02f, 1.07882120e-01f, 7.91586637e-02f, -1.08985133e-01f, 1.41527072e-01f, -9.92743578e-03f, 2.44093537e-01f, 1.36816397e-01f, -2.80666053e-01f, 2.72862613e-01f,
  -1.24529935e-02f, 4.16029356e-02f, 2.91624498e-02f, -1.19464621e-01f, 1.54349238e-01f, 2.87869032e-02f, 1.80738419e-01f, 1.57972589e-01f, 2.87894428e-01f, 2.12174412e-02f,
  1.80464491e-01f, -5.20275794e-02f, -1.05438363e-02f, 1.19024627e-01f, 2.10062310e-01f, 1.85144007e-01f, 4.04052511e-02f, 4.33389395e-02f, 1.96117535e-01f, 7.59612322e-02f,
  -7.34480098e-02f, 8.46853182e-02f, 1.02379173e-01f, 1.16102487e-01f, 2.50662386e-01f, -1.04458965e-01f, -1.05299130e-01f, 1.82397112e-01f, 1.97139785e-01f, -1.26655459e-01f,
  -1.23801261e-01f, 1.21528722e-01f, -2.11451307e-01f, -1.16720069e-02f, -1.32122755e-01f, 1.39712319e-01f, 1.44349143e-01f, -8.60531926e-02f, 2.84838110e-01f, 1.46924511e-01f,
  -1.59860119e-01f, 1.12460166e-01f, 1.10044114e-01f, 7.28054047e-02f, -2.58094892e-02f, -1.21052220e-01f, 1.36820138e-01f, -6.27635568e-02f, -1.84002683e-01f, 2.35914681e-02f,
  1.39355257e-01f, 2.49261871e-01f, 9.92651358e-02f, 1.48611426e-01f, -3.98480222e-02f, 2.09865436e-01f, 2.36315578e-02f, 9.83023867e-02f, 1.21023349e-01f, 1.80496141e-01f,
  -1.32687628e-01f, 5.70146702e-02f, -1.18349284e-01f, 2.70527061e-02f, -1.15149714e-01f, 1.70746908e-01f, 2.48155445e-02f, 1.25588059e-01f, 1.87150359e-01f, 2.01042175e-01f,
  -1.12977903e-02f, -1.16912887e-01f, -6.13001622e-02f, 1.58653021e-01f, 3.33868898e-02f, 1.65617410e-02f, 2.48312652e-01f, 4.04132381e-02f, 1.79752842e-01f, 1.63891345e-01f,
  1.43154040e-01f, 2.89689377e-02f, 2.13216990e-01f, 1.91113681e-01f, 1.61321327e-01f, 4.06463780e-02f, 8.15800652e-02f, 1.62359983e-01f, 1.25847399e-01f, -1.40023172e-01f,
  2.65480548e-01f, 9.11962986e-02f, -9.21539813e-02f, -1.80988759e-02f, -6.98020980e-02f, -2.50938833e-01f, 1.36585683e-02f, -2.74548620e-01f, -2.35253964e-02f, 1.01555556e-01f,
  -5.31618670e-02f, 6.52176812e-02f, 2.46132076e-01f, 7.24880472e-02f, 5.95474727e-02f, 5.99391200e-02f, 2.06171885e-01f, 1.25685126e-01f, 2.12446228e-01f, -3.96862216e-02f,
  2.60180235e-01f, -2.96371095e-02f, 3.38566974e-02f, 1.83592707e-01f, -2.29765877e-01f, -2.44192287e-01f, -2.45632499e-01f, -1.71299204e-01f, -1.86450630e-01f, 1.55469049e-02f,
  -1.41967051e-02f, 1.89396646e-02f, 4.95259725e-02f, 5.31732664e-02f, -2.31647510e-02f, 2.75945246e-01f, 7.74818659e-02f, -7.06902370e-02f, 1.10738143e-01f, 1.02646030e-01f,
  2.53915995e-01f, 9.89470556e-02f, 2.37316728e-01f, -1.94215834e-01f, 1.66473672e-01f, 1.45349413e-01f, -9.75713730e-02f, -1.80500280e-02f, 3.30518447e-02f, -2.27741778e-01f,
  2.33740047e-01f, 9.67267454e-02f, -4.23588604e-02f, -7.45662749e-02f, 2.23423928e-01f, 5.03837503e-02f, 1.29938751e-01f, 2.10339651e-01f, 7.82575086e-02f, 4.85938266e-02f,
  -7.75493830e-02f, -1.08821288e-01f, -1.82284445e-01f, 2.53350526e-01f, 1.26381531e-01f, 1.37413025e-01f, 2.48124480e-01f, -1.25816673e-01f, -1.70856670e-01f, 3.70561749e-01f,
  8.65903273e-02f, 1.99861214e-01f, -1.24440668e-02f, 2.82292068e-01f, 6.89515918e-02f, 7.16436952e-02f, -9.71365795e-02f, 2.56584316e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 52)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 52;
const float L2_fan_Bp_bar_data[] = {
  6.29965812e-02f, 1.74545750e-01f, 1.42029792e-01f, 1.07883953e-01f, 1.53642371e-02f, 2.14593962e-01f, -5.67799667e-03f, -6.15131445e-02f, -7.10490718e-02f, 1.78448841e-01f,
  3.42235938e-02f, -2.56043393e-02f, 1.56276271e-01f, 1.12341546e-01f, 7.57498369e-02f, -3.86757031e-02f, 1.90216631e-01f, 1.06288977e-01f, -3.11439596e-02f, 7.87303150e-02f,
  1.02495745e-01f, 1.96056604e-01f, 1.14726052e-01f, 1.67981848e-01f, -2.51773279e-03f, 1.03927858e-01f, 5.60300872e-02f, 1.49570122e-01f, 7.21249059e-02f, 1.55995592e-01f,
  1.36096731e-01f, 8.02586526e-02f, 1.24971099e-01f, 2.23243117e-01f, 1.33928478e-01f, 2.37190463e-02f, -7.86413327e-02f, -6.47686124e-02f, -5.24265841e-02f, 1.16021417e-01f,
  -1.18880264e-01f, 1.52433276e-01f, 4.13770452e-02f, 6.28912821e-02f, 1.03633277e-01f, 1.16704531e-01f, 2.68642977e-02f, 4.35167439e-02f, 9.08808261e-02f, 9.20387805e-02f,
  7.61439651e-02f, 1.50670841e-01f
};

// L3_linear_W (Shape: 12 x 64)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 64;
const float L3_linear_W_data[] = {
  1.04070194e-01f, -4.03871574e-02f, -8.40999410e-02f, -5.89384213e-02f, -1.18251100e-01f, -3.37584672e-04f, -2.43352037e-02f, 1.57840937e-01f, 4.96323518e-02f, -9.96353924e-02f,
  5.22139780e-02f, -4.19697277e-02f, 1.55173734e-01f, -7.74895772e-02f, 6.90459684e-02f, 1.97418183e-01f, -4.17266160e-01f, -1.17496252e-01f, -4.88348901e-02f, 1.11763716e-01f,
  2.13184267e-01f, 7.06893131e-02f, -2.82513469e-01f, 7.97871649e-02f, -1.68756530e-01f, 2.12734267e-01f, 5.26621826e-02f, -1.87073588e-01f, -1.17443465e-01f, -3.59362483e-01f,
  -3.98164213e-01f, -1.19652666e-01f, -2.11117610e-01f, -1.28692716e-01f, -2.62358755e-01f, -2.77914435e-01f, -1.66907478e-02f, 9.97339785e-02f, -3.02299917e-01f, -4.36059497e-02f,
  1.56074345e-01f, -3.59274030e-01f, -2.02998266e-01f, -2.82655656e-03f, -1.42607003e-01f, -1.36580199e-01f, 5.26611805e-02f, 2.49120131e-01f, 1.76296815e-01f, -3.48506182e-01f,
  1.47532314e-01f, 1.43648729e-01f, 2.39056602e-01f, 1.43991590e-01f, -2.31256917e-01f, -4.56483066e-02f, 1.36727378e-01f, 1.64772555e-01f, 1.31415442e-01f, -1.04864158e-01f,
  -2.48696774e-01f, -3.68435681e-01f, -2.03096479e-01f, -4.25909869e-02f, 1.43344551e-01f, 3.97307239e-02f, -2.00301811e-01f, -9.02274773e-02f, -5.25167771e-03f, 1.17573597e-01f,
  2.23537877e-01f, 2.26330459e-01f, 1.27750605e-01f, 2.22218707e-01f, 1.57178178e-01f, 2.25895703e-01f, -2.29958177e-01f, 1.85633555e-01f, -5.30997552e-02f, -1.90757945e-01f,
  8.50666985e-02f, 1.21573508e-01f, 1.40971914e-01f, -6.22570403e-02f, 8.75194594e-02f, 5.17418832e-02f, -1.25758331e-02f, -2.12384388e-01f, 1.64384469e-01f, -8.87082145e-02f,
  -1.57623604e-01f, 1.20055027e-01f, -2.14673311e-01f, -3.33670616e-01f, -1.20257102e-01f, 4.86863591e-02f, -2.44817078e-01f, 8.96884799e-02f, 1.09963536e-01f, 6.23059692e-04f,
  9.07085389e-02f, 1.56498834e-01f, -2.63121724e-01f, -8.42696615e-03f, 2.31242254e-01f, -8.90833288e-02f, -2.09880948e-01f, 1.06545712e-03f, -2.79168924e-03f, 8.17447901e-02f,
  -3.18097621e-01f, 1.11714497e-01f, 9.57438052e-02f, -3.29893798e-01f, -2.29150802e-01f, 1.28039300e-01f, -2.60359421e-02f, -2.11368930e-02f, -3.36178839e-01f, -1.96091533e-01f,
  -5.28647676e-02f, 3.81275304e-02f, 1.78797200e-01f, 2.60051906e-01f, -7.62508810e-02f, -2.06540987e-01f, 9.85920895e-03f, 8.99692327e-02f, -8.36051479e-02f, -1.75858706e-01f,
  2.17803125e-03f, -2.66675055e-02f, 8.31063837e-02f, 1.64387766e-02f, 1.03704765e-01f, 1.36731505e-01f, 1.40722871e-01f, -2.45456874e-01f, -7.19002634e-02f, 2.85153955e-01f,
  -4.87287641e-02f, -4.13942970e-02f, -1.19430125e-01f, -3.04565132e-01f, -5.54661825e-02f, -2.20812947e-01f, 1.56891987e-01f, -6.34717718e-02f, -9.89700556e-02f, 1.25978272e-02f,
  1.18310712e-01f, -1.10646836e-01f, 1.45374760e-01f, -9.55483839e-02f, -2.86850989e-01f, 1.55872047e-01f, -3.55083406e-01f, 1.64373308e-01f, 2.07477003e-01f, 1.57490879e-01f,
  8.12454820e-02f, 1.85765587e-02f, -2.94727653e-01f, 1.24861643e-01f, -3.31071019e-01f, 2.87957396e-02f, -1.95520446e-01f, 1.24474660e-01f, 6.29983991e-02f, -2.74280548e-01f,
  7.86506757e-02f, -2.42252260e-01f, -4.22318093e-02f, 2.28210419e-01f, -3.35191071e-01f, 2.34714210e-01f, -3.96661386e-02f, 8.46037790e-02f, -2.42126167e-01f, 8.40020627e-02f,
  -2.26590469e-01f, 4.10519093e-02f, 1.21778354e-01f, 1.09890550e-01f, 1.96810916e-01f, -4.31987703e-01f, -1.30820960e-01f, 3.90028879e-02f, -2.89810330e-01f, -6.21440262e-02f,
  1.03095219e-01f, 8.52597803e-02f, -1.46068245e-01f, -1.00279361e-01f, 1.37630269e-01f, -7.03864619e-02f, -1.71081856e-01f, 1.99416243e-02f, -2.43134156e-01f, -1.14601418e-01f,
  -2.15906993e-01f, 1.45582944e-01f, 1.82566568e-01f, 2.24915668e-02f, 1.63733751e-01f, -1.59531221e-01f, -3.86325002e-01f, -2.20819656e-02f, 1.15047637e-02f, -2.74516642e-01f,
  6.56462088e-02f, 1.63227141e-01f, 1.65233791e-01f, -3.08199108e-01f, -1.46166056e-01f, -1.02502473e-01f, 5.41495569e-02f, -7.52304215e-03f, -1.47911429e-01f, 5.83449230e-02f,
  2.65010353e-02f, 7.79784992e-02f, 9.44830254e-02f, -7.16722161e-02f, -3.52115892e-02f, -2.87766755e-01f, 1.07927181e-01f, -2.38023326e-01f, 1.54888898e-01f, -2.47961022e-02f,
  1.65921882e-01f, -4.09678221e-01f, -2.83620983e-01f, -3.14735740e-01f, -1.95073366e-01f, -2.70996481e-01f, -4.82662499e-01f, -3.82178456e-01f, 2.13390797e-01f, 1.38571739e-01f,
  3.40738073e-02f, 2.07423791e-01f, 1.11110948e-01f, 1.00021310e-01f, 1.23856999e-01f, -3.96204352e-01f, 2.20950633e-01f, -2.35582329e-02f, -9.92667526e-02f, 1.15529336e-01f,
  5.72518930e-02f, -2.73810267e-01f, 8.41271132e-02f, 3.08422614e-02f, 1.34248883e-01f, -2.85514623e-01f, -5.74824959e-02f, 1.07213728e-01f, 1.21679515e-01f, -1.01979133e-02f,
  -1.74960692e-03f, -3.17421779e-02f, -2.01093763e-01f, -2.34910890e-01f, 2.31514618e-01f, -2.93426663e-01f, 2.75649186e-02f, -1.55772746e-01f, 6.92165131e-03f, -4.72828038e-02f,
  -3.75091424e-03f, 1.97897658e-01f, -2.94593930e-01f, 1.11006297e-01f, -3.41352791e-01f, 1.16013415e-01f, -6.52916804e-02f, 1.23253353e-01f, -1.79389358e-01f, 6.97312206e-02f,
  -2.47510836e-01f, 1.58596203e-01f, -1.27559751e-02f, -2.22088456e-01f, 1.23541579e-01f, -1.42760975e-02f, 1.09962247e-01f, -1.64341792e-01f, -6.37780651e-02f, 1.69666424e-01f,
  -1.90880373e-01f, -3.48055869e-01f, 1.75771579e-01f, 1.90624774e-01f, 1.93860874e-01f, -3.43192101e-01f, -1.12842217e-01f, -1.62618631e-03f, -2.69028217e-01f, -6.11076970e-03f,
  -1.65384635e-01f, -3.14734638e-01f, -5.44724613e-02f, -1.80500627e-01f, -3.78886797e-02f, 1.18279703e-01f, 2.70866640e-02f, -1.03322349e-01f, -6.95849210e-02f, 3.56031321e-02f,
  8.51372704e-02f, -2.32729331e-01f, 6.85878098e-02f, 3.87383625e-02f, 1.87445939e-01f, -1.08186901e-01f, 2.15405658e-01f, 1.13385059e-01f, 3.75616513e-02f, -1.31884620e-01f,
  -1.23282969e-01f, 1.69736259e-02f, 2.22750038e-01f, -1.64894611e-02f, -6.47185650e-03f, 1.33217514e-01f, -2.76263654e-01f, -2.00207725e-01f, 7.83766136e-02f, 2.56832272e-01f,
  4.31242064e-02f, -5.80422804e-02f, -2.57120073e-01f, 1.55230045e-01f, 1.70502812e-01f, 1.89716578e-01f, 2.18030617e-01f, 1.89716503e-01f, -2.06099302e-01f, -2.64342427e-01f,
  1.14995599e-01f, 8.62130076e-02f, -1.34161934e-01f, 1.21777039e-02f, -3.39028537e-01f, -8.03675726e-02f, 8.54785740e-02f, -1.77997395e-01f, -9.77831259e-02f, -3.05734068e-01f,
  -4.28219676e-01f, -1.01963513e-01f, -5.91859221e-02f, 1.29391834e-01f, 7.39786774e-03f, -4.19286788e-02f, 8.97162855e-02f, 1.35442317e-01f, -2.54817754e-01f, 5.14528789e-02f,
  -1.25674024e-01f, 7.73558095e-02f, 1.35266185e-01f, 1.74853414e-01f, 5.95667027e-02f, 7.46231303e-02f, 1.30989969e-01f, -3.68216187e-01f, 1.20568216e-01f, -3.32888246e-01f,
  1.67068094e-01f, -1.65629700e-01f, -2.55764157e-01f, -2.65736766e-02f, -3.11082512e-01f, -4.39330377e-02f, -3.80609423e-01f, 3.91247198e-02f, 8.70014280e-02f, -1.39839739e-01f,
  -3.12684417e-01f, -1.10762946e-01f, -2.45215371e-01f, 2.16044694e-01f, -3.24947350e-02f, -3.72092724e-02f, -7.29940832e-02f, 9.50450599e-02f, 4.42500450e-02f, 8.63670558e-03f,
  2.91628212e-01f, -6.67680800e-02f, -2.23318547e-01f, 2.08941504e-01f, 3.29528898e-01f, 1.70305073e-01f, -2.39601195e-01f, -2.82278329e-01f, 1.94814175e-01f, -1.35581225e-01f,
  1.11463308e-01f, -1.27136649e-03f, -1.69027120e-01f, -1.05735920e-01f, -2.42728233e-01f, 7.77592659e-02f, 2.55358040e-01f, 7.44370893e-02f, 1.33183948e-03f, -3.39961618e-01f,
  -3.45673412e-02f, -1.80786718e-02f, -1.80437401e-01f, 1.98353305e-02f, 9.29253772e-02f, 4.65222299e-02f, -1.33249775e-01f, 3.63649279e-02f, -1.93067655e-01f, 1.58440769e-01f,
  -1.42268538e-01f, -6.46778941e-02f, -1.21024430e-01f, 2.26176530e-01f, -1.46529481e-01f, -3.59334908e-02f, 2.37606212e-01f, 1.47138238e-01f, 1.89610094e-01f, 1.56707421e-01f,
  -2.82963961e-01f, -2.44946048e-01f, -3.62379164e-01f, 3.68871316e-02f, 1.32257819e-01f, -2.54471421e-01f, -9.14223045e-02f, 1.32999346e-01f, 2.57505029e-01f, -1.59367785e-01f,
  1.15559749e-01f, -3.00973356e-01f, -3.52725595e-01f, -6.33312985e-02f, -2.49203131e-01f, 6.05052486e-02f, -2.42659107e-01f, 9.87234563e-02f, -4.77700159e-02f, 6.15416951e-02f,
  -1.32438332e-01f, -8.58631283e-02f, 1.52187760e-03f, -9.14048180e-02f, 7.04537984e-03f, 9.15603563e-02f, -1.26351789e-01f, -1.40032433e-02f, -1.79046437e-01f, 4.70774509e-02f,
  4.45641205e-02f, -1.76401496e-01f, -8.17607250e-03f, -1.89647879e-02f, 1.76102281e-01f, -2.25959733e-01f, 5.93914129e-02f, 7.91653991e-02f, 1.18354507e-01f, -3.31106752e-01f,
  -2.80728519e-01f, 1.96661755e-01f, -3.11727554e-01f, 1.17652588e-01f, 7.61645734e-02f, 2.12405056e-01f, 4.78083231e-02f, -2.01800078e-01f, -2.92394273e-02f, -1.97845563e-01f,
  2.63246298e-01f, -2.21681759e-01f, 1.28562257e-01f, 6.47573620e-02f, -2.33154707e-02f, -1.61190256e-01f, 3.53306010e-02f, -1.57084927e-01f, -2.92964000e-02f, -1.97788581e-01f,
  2.17072934e-01f, 3.90765332e-02f, -9.61161777e-02f, -4.58205864e-02f, 1.81495041e-01f, -2.19483331e-01f, 1.79608211e-01f, -2.07697395e-02f, 1.61262095e-01f, -2.20596522e-01f,
  1.63645715e-01f, -2.79585570e-01f, -1.70148686e-01f, -2.09774598e-01f, -2.41563216e-01f, -2.64396012e-01f, -8.14494714e-02f, -6.26996234e-02f, 6.43806858e-03f, 6.30189255e-02f,
  1.51908174e-01f, -1.67688847e-01f, -7.45546520e-02f, -6.21334612e-02f, -1.14542674e-02f, -1.13601238e-01f, -1.01183422e-01f, 2.25651748e-02f, -4.66992967e-02f, 1.03497595e-01f,
  1.47204772e-01f, 1.86811894e-01f, -2.22815380e-01f, -2.37199977e-01f, -2.23127112e-01f, 1.85837403e-01f, 1.28497645e-01f, -1.82450697e-01f, 1.58681229e-01f, -2.18427658e-01f,
  1.36829525e-01f, 3.70811224e-02f, -1.65170595e-01f, 3.62338647e-02f, 1.61637634e-01f, -2.53842682e-01f, 5.63407093e-02f, -1.64898440e-01f, -2.36353680e-01f, -1.94102585e-01f,
  9.77899060e-02f, -3.11896145e-01f, 1.30796835e-01f, 1.18669964e-01f, 1.23756282e-01f, -2.99463838e-01f, 4.02623788e-02f, 1.76258013e-01f, -2.08340019e-01f, -2.60069489e-01f,
  -2.52607226e-01f, 1.09606739e-02f, 6.22570254e-02f, 1.83857307e-01f, 2.07539096e-01f, -8.96814000e-03f, -2.66466767e-01f, -2.00184271e-01f, -1.12897065e-02f, -1.96512714e-01f,
  4.92573045e-02f, -1.41660079e-01f, -1.93224683e-01f, -1.46498114e-01f, -5.90802729e-03f, -3.86349797e-01f, 2.70130876e-02f, 1.60711899e-01f, -9.23597887e-02f, -7.18230009e-02f,
  6.02240451e-02f, 1.18559361e-01f, -8.01646113e-02f, 1.96891520e-02f, 1.81594342e-01f, 1.89180315e-01f, 2.35567857e-02f, 5.32832369e-02f, 1.16473079e-01f, 1.73872486e-01f,
  -4.89467233e-02f, -1.39850266e-02f, -1.62448078e-01f, -1.88587710e-01f, -1.40775964e-01f, -1.01909935e-01f, -1.08921245e-01f, 1.29292160e-01f, 2.40001217e-01f, -3.86708230e-01f,
  2.01023549e-01f, -1.69195846e-01f, 8.66320133e-02f, 6.26964271e-02f, -1.95193827e-01f, -1.22511312e-01f, -1.27314717e-01f, 2.51966640e-02f, -2.24904895e-01f, 1.50791565e-02f,
  -1.69065014e-01f, 1.92891404e-01f, -2.86140442e-02f, 2.09945649e-01f, -1.09661564e-01f, 2.11592540e-01f, -2.48966753e-01f, -4.63746116e-02f, -7.48822792e-03f, 1.96905509e-01f,
  -2.02116355e-01f, -2.86035508e-01f, 1.38706908e-01f, 6.08764179e-02f, 1.63081452e-01f, -9.30261388e-02f, 1.33054987e-01f, 1.73551440e-01f, -2.85245538e-01f, 1.16035335e-01f,
  2.11484149e-01f, 4.13897112e-02f, -3.50802869e-01f, -1.49373278e-01f, 7.64162317e-02f, -3.31374139e-01f, -1.45253703e-01f, -1.53698161e-01f, -1.58869684e-01f, 2.85373062e-01f,
  -8.69789124e-02f, -6.20123222e-02f, 7.61739686e-02f, -3.14789951e-01f, -2.83512414e-01f, -2.89694816e-01f, -1.59328803e-01f, -1.81425825e-01f, -1.71390474e-01f, -1.67508230e-01f,
  5.26077263e-02f, -2.27472018e-02f, -9.36381966e-02f, -2.44777966e-02f, 2.45967656e-02f, -1.07207485e-01f, 2.62951136e-01f, -3.68529162e-03f, 2.23082498e-01f, -1.80332929e-01f,
  2.23926723e-01f, -1.93705022e-01f, 1.23733141e-01f, -5.18617667e-02f, -2.27609307e-01f, 1.25145957e-01f, 7.90594295e-02f, -1.90075457e-01f, -1.06796071e-01f, 1.11747824e-01f,
  -8.36683251e-03f, -1.89133689e-01f, 1.96884513e-01f, -8.93455967e-02f, 2.28370100e-01f, -2.68418193e-01f, -3.55326504e-01f, 1.73356369e-01f, 1.63326710e-01f, 1.07980140e-01f,
  2.23678932e-01f, 8.04066733e-02f, -4.66674000e-01f, -4.78956737e-02f, -7.22813383e-02f, 1.42908856e-01f, -2.71539968e-02f, 7.84855634e-02f, 9.10521224e-02f, -1.63077079e-02f,
  -1.17906049e-01f, -1.70540139e-01f, -1.17824256e-01f, -2.95782477e-01f, -8.20674151e-02f, 5.30425422e-02f, -1.26029849e-01f, -4.68212217e-02f, -7.67928436e-02f, -1.55897122e-02f,
  -2.71750420e-01f, 1.89023957e-01f, -9.83748809e-02f, 7.16214627e-02f, -1.04324453e-01f, 2.14279607e-01f, 4.79938909e-02f, 1.11905880e-01f, -1.83390811e-01f, 6.40147701e-02f,
  1.48009390e-01f, 5.58908582e-02f, 1.21093117e-01f, -2.54671186e-01f, 9.17075053e-02f, -6.26749247e-02f, -4.28769551e-02f, 1.59732193e-01f, -4.20383289e-02f, -8.38951487e-03f,
  -1.49101332e-01f, -2.31600776e-01f, -1.27671868e-01f, 1.64411008e-01f, -2.24631727e-01f, -1.93577081e-01f, -1.45067573e-02f, -1.43382818e-01f, -1.11475073e-01f, 5.20018674e-02f,
  1.24893889e-01f, 2.27686450e-01f, -1.45807162e-01f, 3.21076028e-02f, -3.30691487e-02f, -2.00351983e-01f, -1.40151590e-01f, -3.62487882e-01f, 1.45981193e-01f, -2.44744003e-01f,
  -6.96608275e-02f, -2.51038313e-01f, 2.05154598e-01f, 2.14858368e-01f, 9.84724015e-02f, -1.12909898e-01f, -1.84624329e-01f, 2.67493371e-02f, 1.64735004e-01f, 8.12611729e-02f,
  -2.24571556e-01f, -3.58190238e-01f, 8.11544061e-02f, -2.57379681e-01f, -2.24258915e-01f, 1.96247295e-01f, 1.87874317e-01f, 7.97137097e-02f, 1.33031532e-01f, -2.16443330e-01f,
  2.20149547e-01f, -2.14635432e-01f, -3.49996150e-01f, 1.03949912e-01f, -2.33832806e-01f, -3.36989194e-01f, -7.13883489e-02f, -3.08906883e-01f, -1.14443386e-02f, -1.98679343e-01f,
  -1.39081135e-01f, 2.56581575e-01f, 1.31475747e-01f, -1.19211093e-01f, 1.25043795e-01f, 1.39336765e-01f, -2.45239288e-01f, -3.00279558e-02f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  8.22211802e-02f, -9.23638269e-02f, -1.28143623e-01f, 7.01814145e-02f, 1.25610813e-01f, 1.27099067e-01f, 9.45358425e-02f, 2.87862252e-02f, -1.10419407e-01f, 1.05786994e-02f,
  5.64665301e-03f, 1.84529554e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 52
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 6, 52
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        64, 6, 52
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        64, 12
    );
    }
    