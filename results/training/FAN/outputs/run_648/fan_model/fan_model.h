/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 3 x 120)
const int L0_fan_Wp_rows = 3;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -3.73100281e-01f, 3.52730870e-01f, 9.14307162e-02f, -7.81589299e-02f, 2.77990162e-01f, 5.33138588e-02f, 1.18274599e-01f, 1.22595383e-02f, -3.94002646e-02f, 1.75674379e-01f,
  2.92186383e-02f, -4.68624271e-02f, -2.90166605e-02f, -7.60144219e-02f, 1.94215414e-03f, 2.68935502e-01f, 1.89144939e-01f, -1.78213790e-02f, -1.73612550e-01f, 3.78036499e-02f,
  1.44717589e-01f, 4.22773138e-02f, -1.60065338e-01f, 2.53547858e-02f, 9.34527665e-02f, -5.49561568e-02f, 6.70387894e-02f, 1.63316682e-01f, 1.72078386e-01f, 2.87211329e-01f,
  -2.47488525e-02f, 9.44044515e-02f, 1.71874911e-02f, -9.09034442e-03f, 3.89447622e-02f, 6.23914115e-02f, 3.33912894e-02f, 2.66677365e-02f, 3.92885432e-02f, -4.62394161e-03f,
  1.13885336e-01f, 4.91344780e-02f, 1.19060883e-02f, 4.23807167e-02f, 1.10334314e-01f, 5.92374131e-02f, -4.78521734e-03f, 3.68700810e-02f, 7.77247921e-02f, 7.79821426e-02f,
  1.72733799e-01f, 1.61559999e-01f, 7.78975114e-02f, 1.51996538e-01f, 2.10861992e-02f, 1.04816616e-01f, 1.07627250e-02f, 8.15601796e-02f, 5.87360635e-02f, 1.48123056e-01f,
  -4.28015105e-02f, 2.95158364e-02f, 4.19041002e-03f, 1.65176031e-03f, -1.46402046e-02f, -2.94795558e-02f, -8.42604879e-03f, -4.44444269e-02f, -4.74399291e-02f, -5.63295856e-02f,
  4.48713042e-02f, -7.38910120e-03f, -2.52953973e-02f, -3.12310401e-02f, -4.65608016e-02f, -3.33988876e-03f, 3.68646719e-02f, -1.41445838e-03f, -5.67755327e-02f, 2.17677690e-02f,
  2.71457210e-02f, -3.76164652e-02f, 2.09417269e-02f, -4.76142354e-02f, 6.54243380e-02f, -4.34608087e-02f, 1.59763116e-02f, -4.24000528e-03f, -6.74251914e-02f, 8.54367856e-03f,
  -1.39403984e-01f, 9.22311395e-02f, 5.60716763e-02f, 4.73083109e-02f, 1.41602615e-02f, 6.94710435e-03f, 7.85674378e-02f, 7.95408785e-02f, 9.88054648e-02f, 1.35552883e-01f,
  3.16201942e-04f, 2.38308590e-02f, 7.52719678e-03f, 6.28110692e-02f, -3.22840884e-02f, 1.24753393e-01f, 8.66118670e-02f, 3.86543162e-02f, 1.16600897e-02f, 2.80023068e-02f,
  7.57619888e-02f, -1.76354460e-02f, -9.56477150e-02f, -1.54881203e-03f, 5.30478656e-02f, 6.34585321e-02f, 9.91664678e-02f, -5.07394373e-02f, -7.25338832e-02f, -1.26927659e-01f,
  -1.37541249e-01f, 1.97884023e-01f, -1.03534147e-01f, 6.46566674e-02f, -7.41376877e-02f, -8.00237432e-02f, 1.75678849e-01f, 1.31775275e-01f, 3.32360715e-02f, 1.08732685e-01f,
  -7.30621070e-02f, -2.15970308e-01f, -1.39508754e-01f, -9.37598869e-02f, -2.54611857e-02f, 3.67974229e-02f, 9.89101604e-02f, -1.23240925e-01f, -3.94686282e-01f, -2.60727424e-02f,
  1.30565733e-01f, 5.49883507e-02f, -1.61506474e-01f, -5.02082668e-02f, 1.93744123e-01f, -1.49473295e-01f, 4.29291166e-02f, 6.08357340e-02f, 6.16440848e-02f, 2.07079068e-01f,
  -3.04659039e-01f, 8.02116171e-02f, -1.41594455e-01f, -9.36578959e-02f, -1.74093440e-01f, -1.07185967e-01f, -1.61854923e-01f, -1.21833742e-01f, -3.91842648e-02f, -5.72122773e-03f,
  -1.11101847e-02f, -1.10385597e-01f, -8.70354921e-02f, -8.91711563e-02f, -9.52775553e-02f, -5.76545745e-02f, -1.77542493e-02f, -5.51093882e-03f, -1.20647669e-01f, -1.11872107e-01f,
  2.89637409e-02f, -1.02194734e-02f, -1.35598451e-01f, -3.45473457e-03f, 3.96034420e-02f, -1.34702459e-01f, -4.45853844e-02f, -6.48580864e-02f, -9.19737667e-02f, 7.27262497e-02f,
  -8.48703459e-02f, 9.64416116e-02f, 5.02710566e-02f, 1.29996032e-01f, 4.78010923e-02f, 4.98084798e-02f, 1.23762928e-01f, 5.23740686e-02f, 9.73667279e-02f, 6.20153919e-02f,
  4.47963066e-02f, -1.38536580e-02f, 4.58250903e-02f, 6.37063459e-02f, 5.21099269e-02f, 1.05066910e-01f, 1.26652336e-02f, 3.65547463e-02f, 1.11454763e-01f, 8.33598897e-02f,
  2.22978927e-02f, 3.02005187e-02f, 2.72165574e-02f, 7.15074241e-02f, 6.52433336e-02f, 4.50128652e-02f, 6.40242398e-02f, 6.40067458e-02f, -2.92275194e-02f, 5.29506393e-02f,
  -1.37385994e-01f, -1.18192725e-01f, -1.09769419e-01f, -1.29712746e-01f, -1.28992110e-01f, -6.28185943e-02f, -1.34122536e-01f, -8.54734704e-02f, -1.07645348e-01f, -6.42610192e-02f,
  -7.84020573e-02f, -1.06880374e-01f, -5.84978126e-02f, -7.62536377e-02f, -1.29321888e-01f, -9.86254290e-02f, -1.86790191e-02f, -6.23452030e-02f, -1.72657631e-02f, -1.29878283e-01f,
  -9.15405825e-02f, -7.51134828e-02f, -1.72819704e-01f, -1.11933604e-01f, -1.50525361e-01f, -2.64193028e-01f, -1.31742060e-01f, -1.12159491e-01f, -1.87283158e-01f, -1.36589259e-01f,
  -4.68845934e-01f, 1.13051765e-01f, -2.28439271e-01f, -2.10027602e-02f, 8.67325291e-02f, 1.36174202e-01f, 1.78204164e-01f, 1.35454640e-01f, 7.54435211e-02f, -2.38535851e-02f,
  8.65344405e-02f, -1.50327310e-02f, 4.12281341e-04f, -5.75887263e-02f, 3.96274962e-02f, 4.65434641e-02f, 5.53874299e-02f, -1.86337084e-01f, -1.02317639e-01f, 3.28402705e-02f,
  6.58991560e-02f, -1.01850145e-01f, -2.17012480e-01f, -3.50085832e-02f, 8.95978957e-02f, -4.13979068e-02f, -2.70072035e-02f, 1.10671341e-01f, 1.00374818e-01f, 7.71773234e-02f,
  -8.83413479e-02f, 5.30026779e-02f, 1.35400742e-01f, 8.47150460e-02f, 1.04811169e-01f, -4.08070385e-02f, 2.99660768e-02f, 6.94493949e-02f, 2.74942387e-02f, 8.50693285e-02f,
  2.23135054e-02f, 1.51406648e-02f, 4.24799584e-02f, 7.73582608e-02f, 1.11447852e-02f, 1.14462785e-02f, 5.81659824e-02f, -2.76035257e-02f, -1.61508862e-02f, 1.73295755e-02f,
  1.87474012e-01f, 1.22429937e-01f, 6.34548080e-04f, 1.99191034e-01f, 4.67068255e-02f, 1.27455458e-01f, 1.55323550e-01f, 1.38479427e-01f, 6.74973279e-02f, 4.37709838e-02f,
  -2.63889451e-02f, -1.27915218e-01f, -7.94784818e-03f, -1.40196541e-02f, -6.19255565e-02f, -1.47155399e-04f, -1.03828914e-01f, -8.98345709e-02f, -5.85944131e-02f, -1.24472216e-01f,
  -2.81988326e-02f, -1.09028004e-01f, -9.75449458e-02f, -7.90334195e-02f, -7.50942677e-02f, -6.20463677e-02f, -4.43858169e-02f, -9.38566104e-02f, -1.17439032e-01f, -1.45814225e-01f,
  -1.38201565e-01f, -6.46795332e-02f, -1.46535918e-01f, -7.11155683e-03f, -1.07832409e-01f, -9.54496041e-02f, -1.08609378e-01f, -1.29400462e-01f, -1.53815314e-01f, -1.43062457e-01f,
  -2.99619678e-02f, 2.92724278e-02f, 2.43449509e-02f, 1.32044032e-01f, -1.26217669e-02f, 3.81621830e-02f, 5.23588322e-02f, 5.23724966e-02f, 2.44420511e-03f, 3.77018452e-02f,
  3.42887379e-02f, -1.26644867e-02f, 4.96074632e-02f, -5.72415292e-02f, 2.23220643e-02f, 5.91829270e-02f, 4.12280811e-03f, 6.19616779e-03f, 1.31963044e-02f, -1.45908324e-02f,
  6.33685589e-02f, 5.51041923e-02f, -9.60313678e-02f, 1.61509085e-02f, 1.64874092e-01f, -6.91646785e-02f, 3.27023503e-04f, 1.83914527e-02f, 6.74715713e-02f, -5.79689629e-02f
};

// L0_fan_Wp_bar (Shape: 26 x 120)
const int L0_fan_Wp_bar_rows = 26;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -5.17188072e-01f, -1.65583417e-01f, -3.93546790e-01f, -1.62432656e-01f, 1.94366314e-02f, 7.30824918e-02f, 7.34055266e-02f, 2.24428743e-01f, -1.36189699e-01f, -2.45081320e-01f,
  -4.50056084e-02f, 1.33502588e-01f, -2.69951403e-01f, -2.44186800e-02f, -1.99324265e-01f, -3.25413555e-01f, -4.51264977e-01f, -3.08724701e-01f, 9.02376249e-02f, 4.70612109e-01f,
  2.44439259e-01f, 2.60906462e-02f, 3.37060839e-02f, 8.91828761e-02f, 1.14599779e-01f, 1.51782051e-01f, -1.38706952e-01f, 8.68910365e-03f, 6.69223070e-02f, -1.83080509e-01f,
  -3.44642460e-01f, -1.41967237e-01f, 1.27396628e-01f, 6.80266395e-02f, -1.44659519e-01f, 5.85596915e-03f, 6.50448631e-03f, -1.01069450e-01f, 3.48008685e-02f, -1.25575691e-01f,
  -1.19942306e-02f, 1.21185392e-01f, -8.76279324e-02f, 1.39106318e-01f, 8.98934677e-02f, 1.78960025e-01f, -9.24852043e-02f, -2.57859286e-02f, -8.74676779e-02f, -4.32466064e-03f,
  8.91822428e-02f, -8.30624811e-03f, -1.22781277e-01f, 2.31452152e-01f, 1.18425705e-01f, -9.26935971e-02f, 4.98549677e-02f, 1.64913639e-01f, -1.62635546e-03f, 5.61188348e-02f,
  7.53659084e-02f, 1.97793730e-02f, 7.44622499e-02f, 7.66428038e-02f, -2.86917593e-02f, -9.03744772e-02f, 6.95363246e-03f, 1.10540561e-01f, 4.84089814e-02f, -5.36258295e-02f,
  -5.85138127e-02f, -1.20601229e-01f, 3.63248922e-02f, -8.97494778e-02f, -5.08230478e-02f, -1.07702792e-01f, 3.92125500e-03f, 2.54939776e-02f, -8.58879387e-02f, -2.33868808e-02f,
  7.01952158e-05f, 7.04955012e-02f, -1.06339604e-01f, -3.10368538e-02f, -5.58911078e-02f, -8.51626024e-02f, -5.12351207e-02f, 1.63909987e-01f, 7.47415125e-02f, -3.73464078e-02f,
  -2.26847708e-01f, -2.32001871e-01f, -1.53800845e-01f, 2.14392394e-01f, -4.94072065e-02f, -1.59738630e-01f, -3.90797406e-02f, -9.40435473e-03f, -1.89313948e-01f, 1.14010148e-01f,
  3.66469920e-02f, -8.60649273e-02f, -2.19326392e-01f, 4.23691683e-02f, 1.87484428e-01f, 6.04123510e-02f, -4.84179258e-02f, 8.36023763e-02f, 1.18382290e-01f, -1.74446069e-02f,
  -5.78948148e-02f, 3.41258384e-02f, -7.24748671e-02f, -1.70284480e-01f, 8.25791806e-02f, -6.48274124e-02f, -1.72268286e-01f, -3.27160358e-02f, -1.06072702e-01f, -1.71872899e-01f,
  3.18526894e-01f, 3.00815016e-01f, 4.37250942e-01f, 3.44968379e-01f, 2.87526101e-01f, 4.06542063e-01f, 5.41534483e-01f, 1.52943790e-01f, -4.14315350e-02f, 1.06761761e-01f,
  -1.11979656e-01f, -3.39685380e-01f, -2.07295015e-01f, -1.45317703e-01f, 4.29184921e-02f, 1.74153894e-01f, 1.46048501e-01f, 8.29923823e-02f, -3.11306696e-02f, 3.07761580e-02f,
  -1.45603372e-02f, -1.31793991e-01f, -2.20709052e-02f, 9.56830308e-02f, 3.40532921e-02f, -9.76292863e-02f, 4.80930433e-02f, 7.17523843e-02f, 1.24509320e-01f, 7.68422782e-02f,
  -1.91068221e-02f, 1.81264982e-01f, -6.36018515e-02f, -1.54622301e-01f, -1.30389765e-01f, -1.87176645e-01f, -6.09459765e-02f, -1.34232476e-01f, -1.93596616e-01f, -2.60600317e-02f,
  -8.64567831e-02f, -6.12323696e-04f, 5.29401973e-02f, -3.79767306e-02f, -1.14055239e-02f, -3.08902212e-03f, -3.53669785e-02f, -3.08579300e-02f, 7.10577762e-04f, 3.47218104e-02f,
  -1.31607652e-01f, 5.62151186e-02f, 9.18616354e-02f, 2.44560349e-03f, 1.67184487e-01f, -9.01937783e-02f, 1.43273943e-03f, 7.66373649e-02f, 4.87646982e-02f, 6.58832490e-02f,
  -2.75669266e-02f, 7.68289492e-02f, 1.09582342e-01f, -4.79263254e-02f, -3.72367688e-02f, -9.59501266e-02f, 9.93400216e-02f, -9.08976514e-03f, 7.55500644e-02f, -3.47020589e-02f,
  -3.79994586e-02f, -6.06323518e-02f, -4.50193360e-02f, 1.04467779e-01f, -7.71181509e-02f, 1.36660919e-01f, 7.64268115e-02f, -9.69373435e-02f, 2.39301641e-02f, -7.45351240e-02f,
  2.05900148e-02f, 5.57407774e-02f, 8.50242153e-02f, -4.04795818e-02f, -9.18445736e-02f, 8.94574523e-02f, -1.42227337e-01f, -1.82981983e-01f, -2.49221623e-02f, -9.63278115e-02f,
  -3.38127255e-01f, -2.22081944e-01f, -3.12582031e-02f, -1.05500646e-01f, 1.24687906e-02f, -6.42376021e-02f, -7.41573796e-02f, -1.13127805e-01f, -1.13412589e-02f, 4.75734286e-03f,
  -2.60831937e-02f, 4.79355641e-02f, -1.86074583e-03f, 2.56313868e-02f, -1.17750481e-01f, -8.55565295e-02f, -6.07055165e-02f, 6.72846138e-02f, -2.17594624e-01f, -3.27959582e-02f,
  4.50817794e-02f, 4.51300852e-02f, -7.44701475e-02f, 1.59378201e-02f, -5.76273352e-02f, -6.85721561e-02f, -9.43309143e-02f, -1.12615325e-01f, -4.20184806e-02f, -1.08930133e-01f,
  -2.22704396e-01f, -4.79917824e-02f, 5.73903024e-01f, -1.09335497e-01f, 7.31866434e-02f, 3.58970894e-04f, -2.12437004e-01f, 2.27101650e-02f, 1.33791685e-01f, -1.04811817e-01f,
  2.57894188e-01f, -4.54003399e-04f, 7.37480028e-03f, 2.95328703e-02f, -9.35009271e-02f, -7.70899206e-02f, -1.45234361e-01f, 1.55469626e-01f, 4.24316451e-02f, -1.64661463e-02f,
  -5.95751815e-02f, 7.69923255e-02f, 2.16594964e-01f, 1.03460178e-01f, -3.44149560e-01f, -1.72459349e-01f, 7.50248786e-03f, -2.20826775e-01f, -2.22709179e-01f, -5.76717854e-01f,
  4.36880104e-02f, -2.40420952e-01f, 2.71236598e-02f, -1.84803918e-01f, 3.60830687e-02f, 2.07835995e-02f, -6.15246929e-02f, 1.89127594e-01f, 3.88086773e-02f, 7.72341937e-02f,
  -9.78329852e-02f, 7.15764146e-03f, 7.34799951e-02f, 1.49065694e-02f, 1.05229095e-01f, 2.52600480e-03f, 7.32396543e-02f, 1.22556966e-02f, -5.77169247e-02f, 2.37716939e-02f,
  -3.20437431e-01f, -4.70624724e-03f, -1.00870185e-01f, -1.19503029e-02f, -1.11041538e-01f, -2.37893071e-02f, -1.77456543e-01f, -3.19687784e-01f, 5.26437983e-02f, -6.04552090e-01f,
  4.41503860e-02f, 4.68533263e-02f, -1.38652197e-03f, 5.02508618e-02f, -1.33116275e-01f, 5.34439366e-03f, -6.58962354e-02f, -7.93377385e-02f, -1.36148334e-01f, -1.82196312e-02f,
  5.03253266e-02f, 1.24827281e-01f, 5.66166919e-03f, -1.04833789e-01f, -4.12213951e-02f, -5.00941798e-02f, -7.58771598e-02f, -1.41494468e-01f, -3.14947702e-02f, 2.06155647e-02f,
  4.17942777e-02f, -3.56123708e-02f, 7.71756545e-02f, -4.74177860e-02f, -2.21631780e-01f, -3.13658863e-02f, -9.73122939e-02f, -7.17755333e-02f, -1.65236935e-01f, 5.79174748e-03f,
  -1.11108527e-01f, 3.30503047e-01f, -2.47746438e-01f, -1.17377855e-01f, 1.06794640e-01f, -9.38983411e-02f, 4.03292403e-02f, 1.04698852e-01f, -1.48015013e-02f, 1.08786054e-01f,
  -1.06676072e-01f, -2.45578401e-02f, 1.11289784e-01f, -5.51769845e-02f, 5.62267937e-02f, -2.56706569e-02f, -8.32228735e-02f, -1.28506422e-01f, -4.93690185e-02f, -8.96555111e-02f,
  -1.78724602e-01f, -2.87410259e-01f, -3.86548907e-01f, -2.10143566e-01f, -2.92259306e-01f, -4.97787260e-02f, -2.06651658e-01f, -2.63537258e-01f, -2.17147797e-01f, -3.61210078e-01f,
  3.53816509e-01f, -5.56255579e-01f, -3.34055156e-01f, -1.15113273e-01f, -1.91003546e-01f, 3.82557288e-02f, -1.71241596e-01f, 3.24735083e-02f, 6.96824268e-02f, -3.86993647e-01f,
  -1.26113156e-02f, 3.30638558e-01f, 1.07648112e-02f, 1.86881423e-01f, 3.71252000e-01f, -3.89849573e-01f, -1.94721296e-01f, 2.22333372e-01f, 5.85869431e-01f, 2.93630987e-01f,
  -2.19779518e-02f, 6.53141588e-02f, 2.16721818e-01f, 1.76581070e-01f, -3.88856351e-01f, 1.43963337e-01f, -3.12537551e-01f, -2.11582229e-01f, -1.42203972e-01f, -5.41325986e-01f,
  -2.56136596e-01f, -5.53226247e-02f, 1.59967631e-01f, 7.15808943e-02f, -1.98711276e-01f, 4.47056405e-02f, 5.70203364e-02f, -9.56535786e-02f, -5.09498902e-02f, -1.97867841e-01f,
  -3.43443751e-02f, 4.89247479e-02f, -1.13285631e-02f, -4.28971238e-02f, -3.06074843e-02f, -9.45793912e-02f, -1.44783676e-01f, 1.05540201e-01f, 2.88639106e-02f, -1.43565908e-01f,
  -1.41879484e-01f, -1.17111161e-01f, -3.70279513e-02f, -1.20650940e-01f, 1.00372382e-01f, 2.37606868e-01f, -1.10847861e-01f, 2.39690649e-03f, 8.94048735e-02f, -4.38913137e-01f,
  -3.89465615e-02f, -1.04262643e-01f, -7.85038620e-03f, 2.34638457e-03f, -8.89904499e-02f, -1.58909895e-02f, 2.65003499e-02f, -5.71134016e-02f, 2.61490531e-02f, -1.27758104e-02f,
  -2.60675345e-02f, 2.89623588e-02f, 3.97849791e-02f, -1.60474971e-01f, -6.24903776e-02f, -2.51906384e-02f, -4.24020849e-02f, -4.86196019e-02f, 2.50382088e-02f, 4.47694026e-02f,
  1.42180547e-01f, 3.81210931e-02f, 2.26177946e-02f, 1.21483207e-01f, 2.11188290e-03f, 8.03700741e-03f, 1.39641147e-02f, 3.81689444e-02f, 7.86872879e-02f, 8.60861242e-02f,
  -1.50231600e-01f, 2.19382882e-01f, -1.83810934e-01f, 4.63352799e-02f, 2.50129290e-02f, 8.95883143e-02f, -5.38561642e-02f, -8.01878236e-03f, 5.53459711e-02f, 9.98688117e-03f,
  -1.75121520e-02f, 2.01939419e-02f, -1.17102921e-01f, -5.30709624e-02f, 7.07734600e-02f, 2.69348342e-02f, -2.07639858e-02f, 6.78964406e-02f, 2.04194412e-01f, -2.97462121e-02f,
  -7.30718970e-02f, 8.59891996e-02f, 1.75514519e-01f, 1.12140561e-02f, -1.23664916e-01f, 1.07866146e-01f, -1.08151227e-01f, 8.35744217e-02f, 2.32031688e-01f, -2.20249206e-01f,
  5.60162729e-03f, -6.45900071e-02f, -5.29194772e-01f, -1.02806330e-01f, -4.24379200e-01f, -1.12616569e-01f, -9.30555910e-02f, 8.68366435e-02f, -1.31089911e-02f, -7.10624233e-02f,
  -4.74969372e-02f, 2.25996479e-01f, 1.14771567e-01f, -3.62167992e-02f, 2.05531254e-01f, -2.62766212e-01f, -3.13831359e-01f, -2.22858667e-01f, 5.53785125e-03f, 8.69943798e-02f,
  -3.42371166e-02f, 4.74304892e-02f, 3.14670093e-02f, 8.38550553e-02f, -2.27129608e-02f, 9.27466229e-02f, -2.07743943e-01f, -8.35718736e-02f, -8.81666243e-02f, -1.81599721e-01f,
  4.02891077e-02f, -2.39778489e-01f, -8.91305730e-02f, 1.01643451e-01f, -1.60390083e-02f, -3.50085385e-02f, 1.01217777e-01f, -3.16723771e-02f, -1.08771585e-01f, -1.19187003e-02f,
  -1.16513684e-01f, -1.62219003e-01f, 1.36256069e-02f, -7.84978643e-02f, -4.06525768e-02f, -7.95687735e-02f, -1.45302340e-01f, -1.65660113e-01f, -9.39390287e-02f, -1.01922087e-01f,
  -2.30606645e-01f, -3.21477085e-01f, 2.87908278e-02f, -1.91310067e-02f, -1.12242974e-01f, -1.40282154e-01f, 2.53725471e-03f, -6.75318241e-02f, -3.75929810e-02f, 3.78475934e-02f,
  1.06938466e-01f, -1.30271204e-02f, -2.70835254e-02f, 9.47596282e-02f, -1.28894737e-02f, -9.57723707e-02f, 2.43473835e-02f, 4.73795198e-02f, 1.17148913e-01f, 1.32970199e-01f,
  -3.86632653e-03f, -8.04599077e-02f, 6.30656630e-02f, 6.34955615e-02f, -8.62300545e-02f, 1.14202714e-02f, 1.44289806e-01f, 7.83018470e-02f, 1.95736751e-01f, 1.18856914e-02f,
  2.38185227e-02f, -3.02791521e-02f, 2.13777944e-02f, 1.83964029e-01f, -6.91711828e-02f, -9.00259838e-02f, -1.23558573e-01f, 2.23030075e-02f, 1.13754801e-01f, -9.29824412e-02f,
  4.63816255e-01f, -1.76392376e-01f, 9.74066332e-02f, 9.87716839e-02f, 4.46121544e-02f, -9.04761329e-02f, 1.26487538e-02f, 6.47143424e-02f, -1.20828122e-01f, 1.84506893e-01f,
  -3.13009359e-02f, 5.76536730e-02f, 8.15945938e-02f, -1.70219496e-01f, 1.32493570e-03f, -7.34412074e-02f, -1.58308481e-03f, -7.36572072e-02f, 4.47089635e-02f, -3.16289850e-02f,
  -5.57092577e-02f, -2.28923354e-02f, 2.30818868e-01f, 9.45536047e-02f, -2.86708996e-02f, 3.67809497e-02f, 1.60073593e-01f, 1.45984322e-01f, 9.18057561e-02f, 4.00183529e-01f,
  -8.01339090e-01f, -3.32615413e-02f, 4.60870236e-01f, -5.69992781e-01f, -5.85267991e-02f, -5.53008988e-02f, 6.19110242e-02f, -2.82159865e-01f, -4.47046131e-01f, 1.08601391e-01f,
  -5.45525271e-03f, -8.55450630e-02f, 1.42574310e-02f, -4.77322191e-02f, -2.34605253e-01f, 4.36809547e-02f, -5.13398126e-02f, -1.98762253e-01f, -2.06807062e-01f, -2.82314330e-01f,
  -1.73751563e-01f, -4.02719975e-01f, -5.28124988e-01f, -3.40435266e-01f, 7.79744238e-02f, 6.92847669e-02f, 2.78705180e-01f, -1.62374098e-02f, 1.72790661e-01f, 2.20112339e-01f,
  3.82413179e-01f, -1.80340394e-01f, -5.28752282e-02f, -1.77613154e-01f, 1.00798212e-01f, -3.28963101e-02f, -1.02018952e-01f, -7.40919784e-02f, -1.14530899e-01f, -1.34559488e-02f,
  -8.60159397e-02f, -3.98876406e-02f, -1.83259740e-01f, -8.45192298e-02f, -2.12540641e-01f, -2.05340028e-01f, -7.55568594e-02f, -5.01959883e-02f, -3.65388356e-02f, 9.56909135e-02f,
  7.95539767e-02f, 6.79724850e-03f, 1.27679721e-01f, 2.35045049e-02f, 1.04042061e-01f, -6.93077967e-03f, 1.15272678e-01f, 8.80383477e-02f, 5.93058094e-02f, 1.04733393e-01f,
  5.99501505e-02f, -5.11576608e-02f, 4.88160588e-02f, 2.59640366e-02f, -2.18153037e-02f, -5.42571321e-02f, 1.44465053e-02f, 1.63835101e-02f, -8.62852409e-02f, -8.16158950e-02f,
  3.48357446e-02f, 1.19370155e-01f, -2.57720845e-03f, 3.87758091e-02f, -1.07330000e-02f, -2.01593935e-02f, -7.83880726e-02f, 7.77876005e-02f, 9.73830000e-04f, -1.18871875e-01f,
  -1.30870938e-01f, -3.39008793e-02f, 6.43435270e-02f, -5.09317257e-02f, 5.10544144e-03f, 6.34637102e-02f, 5.26532568e-02f, -6.04334064e-02f, 8.10061768e-02f, -6.69789463e-02f,
  1.88004109e-03f, -1.92401901e-01f, 1.50804606e-03f, 1.14022624e-02f, 3.59933451e-02f, 1.50186852e-01f, -8.21395777e-03f, -1.21006362e-01f, 2.14671604e-02f, 2.75540296e-02f,
  -7.04220543e-03f, 4.96359877e-02f, 7.32157901e-02f, 2.63560787e-02f, -1.03485391e-01f, 1.43275037e-02f, -3.52565050e-02f, 3.24832611e-02f, 7.45084956e-02f, -1.12518240e-02f,
  1.80186722e-02f, 2.22966969e-02f, -8.64362624e-03f, 1.53123543e-01f, 1.16756640e-01f, 1.05080061e-01f, 2.57984728e-01f, 1.89263463e-01f, 1.54307097e-01f, 2.63300896e-01f,
  3.29629689e-01f, 4.88887588e-03f, -5.25058985e-01f, 1.38232559e-01f, -3.76355201e-01f, -3.26308638e-01f, -4.27281648e-01f, -6.04169965e-02f, 1.59342915e-01f, -1.54275030e-01f,
  -1.36997834e-01f, 7.24240690e-02f, -9.84521285e-02f, -2.61652619e-01f, -3.66952062e-01f, -4.17326182e-01f, -3.83145690e-01f, -4.37209815e-01f, -5.30599952e-01f, -5.93085468e-01f,
  -4.68077540e-01f, -3.43936533e-01f, -1.85725659e-01f, -1.98607504e-01f, 7.84630030e-02f, 8.51605982e-02f, -7.19524501e-03f, -9.83505622e-02f, -2.77223915e-01f, -4.96839173e-02f,
  -3.82533252e-01f, 7.79944211e-02f, -7.21460730e-02f, 4.96028624e-02f, 1.01041142e-02f, 1.30597755e-01f, -5.85709102e-02f, 1.26792789e-01f, 1.50739208e-01f, 1.15884572e-01f,
  6.73143268e-02f, 3.14946808e-02f, -6.53866753e-02f, 5.32684997e-02f, -1.64032385e-01f, -1.17115766e-01f, 5.19740023e-02f, 2.94734426e-02f, 7.33459890e-02f, 4.12394963e-02f,
  -2.14467868e-02f, -1.63149625e-01f, 1.27997980e-01f, 1.89864442e-01f, 1.53459430e-01f, 3.00082602e-02f, 3.84021699e-02f, 2.35827297e-01f, 5.05610481e-02f, 2.35813171e-01f,
  -5.22718392e-02f, 1.51374459e-01f, 2.75336169e-02f, -1.99915506e-02f, -1.37108359e-02f, 4.58131954e-02f, -2.94256508e-02f, 2.97051165e-02f, -1.07767032e-02f, 1.02765951e-02f,
  1.12910040e-01f, 8.68919864e-02f, 1.10013105e-01f, -5.00556966e-03f, -2.39288062e-02f, -3.98590043e-03f, -1.76938425e-03f, -9.63483304e-02f, -1.04296751e-01f, 7.49721676e-02f,
  1.00862496e-01f, 1.15244001e-01f, 9.72629935e-02f, -8.87438655e-03f, -9.37184840e-02f, 1.04809441e-01f, 4.73981947e-02f, 1.09020233e-01f, 6.69625700e-02f, 2.01658830e-02f,
  1.38887614e-01f, -1.63716927e-01f, -4.69230786e-02f, 5.01750261e-02f, 3.06974594e-02f, 9.73073915e-02f, 1.33288518e-01f, -1.21687107e-01f, 3.56348790e-02f, -1.50874212e-01f,
  -1.02767736e-01f, 2.30757426e-02f, -6.86474070e-02f, 2.24179402e-02f, -4.94477525e-03f, 4.24628705e-03f, -6.46000132e-02f, -3.17552350e-02f, -8.38647336e-02f, -4.39135656e-02f,
  -9.19011533e-02f, -3.90718542e-02f, -1.57466587e-02f, 3.90373468e-02f, 3.72602954e-03f, -6.11748211e-02f, -4.88353148e-02f, -4.11299206e-02f, 1.92058608e-02f, 1.26414951e-02f,
  2.43156180e-01f, -3.99807878e-02f, -3.58081400e-01f, 2.06418574e-01f, -5.42113511e-03f, 4.21737544e-02f, 1.31211579e-02f, 1.99170727e-02f, 3.23027462e-01f, 2.67073035e-01f,
  3.23221058e-01f, 4.01027709e-01f, 3.03964138e-01f, 1.63307771e-01f, 9.74546596e-02f, 2.47063935e-02f, -5.41695096e-02f, -9.94018167e-02f, -6.70208931e-02f, 5.35008162e-02f,
  2.48075232e-01f, 1.73137203e-01f, 1.27194688e-01f, -6.75634146e-02f, -9.63606685e-02f, 3.33213508e-02f, -1.36244670e-01f, -8.16676095e-02f, -1.68909341e-01f, -3.49881500e-01f,
  -1.91126496e-01f, -2.73438334e-01f, -2.60059834e-02f, 5.24553768e-02f, 2.14642752e-02f, -7.69168288e-02f, 1.82805415e-02f, -2.32876867e-01f, -8.46488401e-02f, -1.22778356e-01f,
  -1.44620463e-01f, 5.00817830e-03f, -2.60915011e-02f, -1.01459615e-01f, 1.00256288e-02f, 8.27685669e-02f, -1.04122892e-01f, -2.04323530e-01f, -9.47612077e-02f, 5.94895557e-02f,
  9.35826600e-02f, 2.95568760e-02f, -1.98624488e-02f, 1.77408904e-02f, -2.47879818e-01f, 4.84377816e-02f, -1.84165716e-01f, -6.92593902e-02f, -1.24127559e-01f, -2.04686597e-01f,
  1.34963393e-01f, 2.70552218e-01f, 4.30291742e-02f, 5.62834255e-02f, 1.73767567e-01f, -4.48637009e-02f, -1.56205416e-01f, -6.69948459e-02f, 9.25190672e-02f, 1.41803240e-02f,
  1.27418628e-02f, 1.28434375e-01f, 1.09192453e-01f, 4.08171974e-02f, 2.04044178e-01f, -5.59695959e-02f, 6.74912781e-02f, 2.11517990e-01f, -9.54969302e-02f, -7.37403259e-02f,
  1.07266851e-01f, -2.55695153e-02f, 9.69986618e-02f, -9.09834877e-02f, -1.26798034e-01f, -1.08980266e-02f, 2.04338595e-01f, 9.39509794e-02f, 1.21335052e-01f, 2.98714098e-02f,
  7.19985589e-02f, 2.28299335e-01f, 1.34649411e-01f, -6.78951740e-02f, -1.09936245e-01f, 2.68064886e-02f, -2.08286066e-02f, 6.45774230e-02f, -1.04627371e-01f, -1.41993418e-01f,
  -7.94321224e-02f, -2.38595065e-03f, 4.36319187e-02f, -1.44696355e-01f, 2.21199393e-02f, 7.84835741e-02f, 1.69442892e-01f, 5.57787232e-02f, 8.37247521e-02f, -1.01257525e-02f,
  9.35274735e-02f, 1.07530251e-01f, 1.12995662e-01f, -1.08251432e-02f, -3.22700702e-02f, 2.14569315e-01f, 7.31851831e-02f, 5.39821610e-02f, 3.95700783e-02f, 1.19132861e-01f,
  5.25425851e-01f, 7.81349391e-02f, 3.98996621e-01f, 2.94931531e-01f, 6.31801039e-02f, 9.29111540e-02f, 7.60610253e-02f, 1.82878524e-01f, 7.37935305e-02f, 1.38214469e-01f,
  -6.11070581e-02f, -4.14577052e-02f, 1.82808280e-01f, 1.11643381e-01f, 1.83191285e-01f, 2.11365998e-01f, 2.81095237e-01f, 3.65460634e-01f, 3.47023904e-01f, 2.68131375e-01f,
  1.22029178e-01f, 2.32975602e-01f, 1.68996409e-01f, 1.39475867e-01f, 1.60347447e-01f, 6.64276704e-02f, 1.58353150e-01f, 2.31150270e-01f, 1.50632471e-01f, 2.54277170e-01f,
  -4.19292413e-02f, 2.05007166e-01f, 6.02376238e-02f, -9.81743559e-02f, -1.11830063e-01f, -4.39311974e-02f, -5.59626184e-02f, 1.93797015e-02f, -1.28104255e-01f, -5.98342717e-02f,
  -1.84908360e-01f, -9.14854854e-02f, -1.29287854e-01f, -3.69932353e-02f, -6.54509068e-02f, -1.04991689e-01f, 2.45562475e-02f, 1.71958804e-01f, -7.52265379e-02f, -5.84572069e-02f,
  -1.08936846e-01f, -9.27734226e-02f, -9.54078734e-02f, -1.01195410e-01f, 1.42616466e-01f, -2.61881202e-02f, 3.01558711e-02f, 6.21502586e-02f, -2.32001860e-02f, 1.05467467e-02f,
  9.78339538e-02f, 2.07901583e-03f, 1.38353914e-01f, 2.25172773e-01f, 3.65514159e-01f, 1.89196289e-01f, 1.94878280e-02f, 8.46422538e-02f, 8.08977485e-02f, 3.56671494e-03f,
  2.44464260e-02f, 8.93034041e-02f, -1.14630342e-01f, -2.94610881e-03f, 3.35890912e-02f, -7.50141144e-02f, -7.82347545e-02f, -1.54542267e-01f, -5.51426448e-02f, 6.72397465e-02f,
  7.10802376e-02f, -2.67140344e-02f, -1.16161825e-02f, 3.33219171e-02f, -2.09653378e-02f, -1.87867880e-02f, 1.11145742e-01f, -8.70511755e-02f, -2.17013042e-02f, 1.05771143e-02f,
  -3.33230883e-01f, -9.43284184e-02f, 1.07110687e-01f, -4.21716161e-02f, -5.88372163e-02f, -5.16276769e-02f, -8.23630914e-02f, 5.12909098e-03f, -9.14273933e-02f, 1.97905265e-02f,
  -3.13064903e-02f, 2.83725746e-02f, -1.49772003e-01f, 7.68276230e-02f, -5.34597551e-03f, 1.41140458e-03f, 2.99135279e-02f, -1.74347535e-01f, -1.61968693e-01f, -1.53388426e-01f,
  -1.51177093e-01f, -2.37869397e-01f, -2.68720269e-01f, -2.20941409e-01f, -1.53743401e-01f, -1.72302440e-01f, -1.26669660e-01f, -7.90167749e-02f, -1.15248092e-01f, -8.26196298e-02f,
  -7.26957545e-02f, -2.36264303e-01f, -3.37416619e-01f, -1.10953256e-01f, -4.00788993e-01f, -1.57367378e-01f, -1.70491710e-01f, -1.45069569e-01f, -1.27914444e-01f, -2.53196269e-01f,
  -1.92140937e-02f, 3.78989756e-01f, 1.88576072e-01f, 1.27039552e-01f, 3.57013673e-01f, -1.14155926e-01f, -3.17974091e-01f, 3.47499438e-02f, 2.37751842e-01f, 9.32539105e-02f,
  -1.17056060e-03f, 8.10950436e-03f, 4.31185439e-02f, 8.61250907e-02f, -1.19303502e-01f, 1.58580512e-01f, -3.22269201e-01f, -2.25130573e-01f, -2.63217002e-01f, -4.15230125e-01f,
  4.19188082e-01f, -3.11315715e-01f, -1.72965050e-01f, 2.25512628e-02f, 4.42989059e-02f, -2.90467218e-03f, 5.42246085e-03f, -1.59151956e-01f, -1.18536189e-01f, -9.84912366e-02f,
  -7.58060291e-02f, -1.00227840e-01f, 6.18378744e-02f, 1.53332859e-01f, 2.92931907e-02f, 7.00573549e-02f, -1.53748646e-01f, -4.42534573e-02f, -1.16501383e-01f, -5.98680638e-02f,
  -1.96515378e-02f, -7.08072409e-02f, 3.46341054e-03f, -6.36797696e-02f, -5.67334890e-02f, 3.72241847e-02f, 3.17405574e-02f, -9.15804952e-02f, -1.52330309e-01f, -5.68005815e-02f,
  -9.33007300e-02f, -2.20276751e-02f, 1.94027163e-02f, -1.91468615e-02f, 5.60933501e-02f, 2.99003832e-02f, 8.42433497e-02f, 4.47077528e-02f, -3.88802066e-02f, 3.16649489e-02f,
  -6.78614527e-02f, 4.02704999e-02f, 3.12441420e-02f, 6.78092316e-02f, -1.13105308e-02f, -9.14859325e-02f, -3.37256975e-02f, 4.31651473e-02f, -8.43331739e-02f, -7.66623467e-02f,
  -1.13543510e-01f, -1.83244601e-01f, -9.00640562e-02f, 6.09999374e-02f, -1.89413235e-01f, -1.94384642e-02f, -1.07809855e-02f, 3.23042981e-02f, 9.82986242e-02f, -4.32685204e-02f,
  5.71193159e-01f, -1.15691237e-01f, 1.25442967e-02f, 2.04499420e-02f, -1.33584082e-01f, -1.35893971e-01f, 6.54984862e-02f, -1.59275606e-01f, -3.44908647e-02f, -1.21561559e-02f,
  -4.06811610e-02f, 6.34911135e-02f, -2.75544114e-02f, -1.05492853e-01f, 4.89663221e-02f, -3.50515246e-02f, 2.46307310e-02f, 6.33394271e-02f, -7.20110983e-02f, -1.14017539e-02f,
  -6.49582893e-02f, 2.29458716e-02f, 2.66210049e-01f, 1.62201896e-02f, 7.23951682e-02f, 2.26953670e-01f, 1.62340522e-01f, 4.81400117e-02f, 1.15497343e-01f, 1.67070821e-01f,
  -3.95135134e-01f, -3.06091867e-02f, -4.23459262e-01f, 8.30507651e-02f, 2.59618193e-01f, 5.01116700e-02f, -1.05413742e-01f, -1.15940265e-01f, 1.71451792e-01f, 1.51168287e-01f,
  1.91858560e-01f, 3.10885221e-01f, 1.59561202e-01f, 5.54898605e-02f, -3.18018317e-01f, 2.13792957e-02f, 1.20848827e-01f, -1.76849887e-01f, -4.04165834e-01f, -1.70591641e-02f,
  2.34731570e-01f, -1.20987438e-01f, -4.38801289e-01f, -1.58840731e-01f, 3.56769353e-01f, 7.63901249e-02f, -9.97692645e-02f, -1.05569037e-02f, 9.71655846e-02f, 3.79436791e-01f,
  -3.71412374e-02f, -3.38177711e-01f, -5.64624481e-02f, 5.91376685e-02f, -4.59081270e-02f, 1.51929511e-02f, -1.71313342e-02f, -1.04978614e-01f, 9.46654230e-02f, -9.12136734e-02f,
  1.10106170e-02f, 4.09298800e-02f, 1.44066289e-01f, -3.02099884e-02f, -1.78328440e-01f, -1.83527693e-01f, -2.47365847e-01f, -3.90091002e-01f, -4.68882591e-01f, -1.89196348e-01f,
  2.70992875e-01f, 1.81949973e-01f, -3.11658978e-01f, -1.85774416e-01f, -1.48725823e-01f, -1.47910878e-01f, -2.15613574e-01f, 3.49387154e-02f, -3.70115578e-01f, -2.18979836e-01f,
  -5.38667217e-02f, -5.54141626e-02f, -2.00754032e-02f, -7.63512775e-02f, 4.37167212e-02f, 1.93001926e-01f, 1.57902238e-03f, 8.74296054e-02f, -3.16913426e-03f, -6.83779493e-02f,
  3.39390710e-02f, 5.43814488e-02f, -1.64687678e-01f, -1.48400307e-01f, 8.66378024e-02f, 5.01325401e-03f, -3.89792286e-02f, -1.74042627e-01f, -3.75852250e-02f, 1.39290482e-01f,
  -3.54575478e-02f, -1.79992989e-02f, -5.21397218e-02f, 2.33194456e-02f, -6.36828095e-02f, -2.16953129e-01f, 1.10745139e-01f, -6.61172569e-02f, -9.55741256e-02f, -1.15189858e-01f,
  -1.55071452e-01f, -8.62071365e-02f, 2.04598401e-02f, 5.43691069e-02f, 4.45379876e-02f, 1.95941254e-02f, 2.65040845e-02f, 1.29548702e-02f, 7.65946209e-02f, -1.69182867e-01f,
  -1.31140143e-01f, -8.04647878e-02f, -8.94246995e-02f, -5.55351414e-02f, -7.90365860e-02f, -1.98366772e-02f, -3.86230052e-02f, 8.07673782e-02f, -8.69106054e-02f, -3.60062383e-02f,
  2.93178987e-02f, -5.43385372e-02f, -2.33696669e-01f, -8.26140419e-02f, 4.18853238e-02f, -1.71564788e-01f, -1.04032435e-01f, -9.99521613e-02f, -1.80088297e-01f, -3.37140471e-01f,
  5.90178549e-01f, -3.51956099e-01f, 1.32091776e-01f, 1.12708375e-01f, -2.19608352e-01f, -1.00370340e-01f, -3.30385327e-01f, -1.69614270e-01f, 2.77946633e-03f, -9.13719609e-02f,
  -3.25104356e-01f, -2.57162094e-01f, -1.83485240e-01f, -2.30824053e-01f, -3.68235931e-02f, 6.94474131e-02f, 2.05380499e-01f, 3.29176217e-01f, 2.84129441e-01f, 9.34319645e-02f,
  -1.90050691e-01f, 2.05805406e-01f, 2.76076376e-01f, 1.29676476e-01f, -1.04486205e-01f, -1.23208001e-01f, -9.52338986e-03f, 2.64236674e-04f, -1.64652303e-01f, 6.62442818e-02f,
  -6.55020177e-02f, -1.65930927e-01f, -3.08160149e-02f, 2.28984300e-02f, -1.08112380e-01f, 3.81502248e-02f, -1.83392540e-01f, 7.16640130e-02f, -6.74894452e-02f, -8.90856758e-02f,
  -1.76536560e-01f, -3.04499380e-02f, -1.83919564e-01f, -1.51805446e-01f, -8.90292507e-03f, 6.91532791e-02f, 7.12721795e-02f, 6.54656887e-02f, 8.09721798e-02f, -1.54627472e-01f,
  -9.41585675e-02f, -1.33107230e-01f, 1.08512759e-01f, -1.07814081e-01f, -1.52449727e-01f, 5.20445034e-02f, -9.02798474e-02f, -1.02699332e-01f, -1.27533510e-01f, 1.84409648e-01f,
  -2.24918630e-02f, -6.94988593e-02f, -3.06440815e-02f, 1.37550279e-01f, -2.96117458e-02f, -1.34923130e-01f, -6.22872524e-02f, -4.71752770e-02f, -2.21159998e-02f, -2.23905072e-02f,
  1.96440257e-02f, 6.49125800e-02f, 3.19395550e-02f, 6.63680397e-03f, -1.33065552e-01f, 2.69145258e-02f, -7.42812306e-02f, 5.73016852e-02f, -9.27191824e-02f, -1.70469228e-02f,
  1.02297682e-02f, 1.70762781e-02f, -5.40998764e-03f, 6.16241731e-02f, 2.89689079e-02f, 1.23597525e-01f, -4.07745466e-02f, -4.00114991e-02f, -2.66414806e-02f, 7.41955861e-02f,
  -8.19541141e-02f, -2.05145940e-01f, 7.20621739e-03f, 1.05002351e-01f, -2.52766665e-02f, -8.67872089e-02f, -2.61476755e-01f, -5.02744652e-02f, -1.11713156e-01f, -1.43679499e-03f,
  -1.22136965e-01f, -9.64379311e-02f, -1.22895777e-01f, -5.65010421e-02f, 7.76558667e-02f, -8.80930573e-03f, -1.42120436e-01f, -7.52842147e-03f, 1.20273754e-02f, 5.76637425e-02f,
  8.31503421e-02f, 1.77866399e-01f, 2.84408242e-01f, 1.10176019e-02f, -5.06837815e-02f, -3.98139609e-03f, -6.69674017e-03f, 2.07895460e-03f, 1.51287373e-02f, 2.56382465e-01f,
  1.51085541e-01f, -1.51918635e-01f, 2.72799671e-01f, 3.48293871e-01f, -2.55332083e-01f, -5.37706316e-01f, -7.65894413e-01f, -5.83687246e-01f, -1.21470787e-01f, -6.33157492e-02f,
  -7.39224926e-02f, 7.01568276e-02f, 1.21500921e-02f, -1.47795141e-01f, -3.22488368e-01f, -1.30233943e-01f, 1.49149552e-01f, 1.38642788e-01f, -1.79256484e-01f, -1.98597312e-01f,
  -1.35369925e-03f, 1.51196241e-01f, 2.74619728e-01f, 7.06026927e-02f, 3.30977976e-01f, 8.54271725e-02f, 1.78590149e-01f, 1.58609763e-01f, 5.65468967e-02f, 4.75014478e-01f,
  4.02154297e-01f, 1.68097932e-02f, -1.59601420e-01f, 9.82556567e-02f, 1.38026938e-01f, -4.51827906e-02f, 8.06297511e-02f, 3.08510870e-01f, 3.60784158e-02f, 1.30300969e-01f,
  2.84342855e-01f, 1.03945918e-01f, 7.94879720e-02f, 1.56631880e-02f, 1.96328051e-02f, 1.19037749e-02f, 1.49623215e-01f, 9.76507589e-02f, 1.81043848e-01f, 2.12775379e-01f,
  -8.96643326e-02f, -8.67264271e-02f, -7.90836662e-02f, -2.66935825e-01f, -6.46818057e-02f, 1.33771539e-01f, -1.78712785e-01f, 1.33409323e-02f, -9.39743817e-02f, 3.69691774e-02f,
  -1.32466987e-01f, 8.49587247e-02f, -2.66833287e-02f, 3.39665599e-02f, -8.03777128e-02f, -6.88508824e-02f, 1.64288029e-01f, -2.29713935e-02f, -2.43095011e-02f, 4.17979695e-02f,
  -8.19998905e-02f, 5.79499006e-02f, 1.39391199e-02f, -1.55606233e-02f, 7.79687464e-02f, 2.00093031e-01f, 1.18801333e-01f, -5.29612824e-02f, 6.42177910e-02f, -2.46151220e-02f,
  -2.79992744e-02f, 3.16586830e-02f, 7.74486735e-02f, 6.19599856e-02f, -2.39890814e-02f, 9.25807506e-02f, 1.13168404e-01f, -6.58386946e-02f, 9.67803821e-02f, 3.17375995e-02f,
  -1.17807180e-01f, -7.05523938e-02f, 7.79317915e-02f, -2.79195458e-02f, 8.80135074e-02f, 1.12618189e-02f, 3.22295018e-02f, 1.61468312e-02f, 5.75556345e-02f, -8.69261920e-02f,
  -1.97424874e-01f, 4.28539328e-03f, 3.12799662e-02f, 2.05567153e-03f, -1.72444969e-01f, 7.86580443e-02f, -1.41276881e-01f, -1.01968430e-01f, 1.36023657e-02f, 1.50946572e-01f,
  -2.15975940e-01f, -3.17299128e-01f, -3.15912873e-01f, -3.19085598e-01f, -1.08705744e-01f, -2.59080052e-01f, -2.22172543e-01f, -2.67670333e-01f, -4.01710838e-01f, -6.01871431e-01f,
  7.54876316e-01f, 6.54430509e-01f, 1.55809313e-01f, 2.02134028e-02f, -3.27811420e-01f, -3.61294776e-01f, -1.83865771e-01f, 7.22875893e-02f, -2.12302711e-03f, 5.29295066e-04f,
  -3.33686955e-02f, -3.90542857e-02f, 6.80455416e-02f, 1.11605898e-01f, 1.45258889e-01f, 8.97557102e-03f, -3.30418535e-02f, 3.02371997e-02f, -5.72221428e-02f, -1.52088791e-01f,
  -2.12289378e-01f, 9.68763325e-03f, 2.20402002e-01f, 6.41693473e-02f, 1.37568995e-01f, -5.45275994e-02f, 5.60445599e-02f, -9.36835334e-02f, -1.90527979e-02f, 2.38465816e-01f,
  -1.13977835e-01f, 2.14063436e-01f, 5.29180467e-02f, 2.29491182e-02f, 4.96232845e-02f, 2.41618916e-01f, 8.35909843e-02f, 3.82578447e-02f, -3.55323963e-02f, -1.38942003e-01f,
  -9.75563973e-02f, 1.09997634e-02f, -6.78914860e-02f, -1.01396047e-01f, -1.45438299e-01f, -1.02025513e-02f, -6.31167665e-02f, -7.36427158e-02f, -2.93836612e-02f, 5.82173355e-02f,
  -3.24285552e-02f, -2.28849545e-01f, -2.36497596e-01f, -2.70457894e-01f, -1.63568139e-01f, -1.00249633e-01f, 1.69103276e-02f, 6.40223995e-02f, -1.02045462e-01f, 1.36165053e-01f,
  -7.33956993e-02f, -1.20746456e-01f, -2.41401028e-02f, -5.78205101e-02f, -1.81580395e-01f, -3.24801914e-02f, -2.03598976e-01f, -2.38334551e-01f, -1.78635180e-01f, -8.03332776e-03f,
  -1.04465187e-02f, -1.25727117e-01f, -2.75823176e-02f, -6.86762482e-02f, -5.58493584e-02f, -1.21998332e-01f, -8.42164923e-03f, 4.46661003e-02f, -1.11274324e-01f, 1.73636265e-02f,
  -1.50773615e-01f, -2.60814074e-02f, 5.29279038e-02f, -2.99695767e-02f, -2.50245258e-03f, -9.70096812e-02f, -5.82664423e-02f, -1.33552343e-01f, -7.97014236e-02f, -3.53761800e-02f,
  -1.38274819e-01f, -1.53152809e-01f, 9.83589366e-02f, 1.08392641e-01f, 1.27108291e-01f, 2.12570176e-01f, -5.74658923e-02f, 7.92708099e-02f, 1.70942068e-01f, -6.25059530e-02f,
  3.42497602e-03f, 4.42282343e-03f, -6.52874913e-03f, -1.09754175e-01f, -5.48579358e-02f, -1.24555580e-01f, 7.21284747e-02f, 2.05088519e-02f, 5.14598563e-02f, 1.07882127e-01f,
  1.31608946e-02f, -6.02425039e-02f, -1.31937429e-01f, -6.17553387e-03f, 4.16098982e-02f, -9.10702646e-02f, 5.29731158e-03f, -6.15360141e-02f, -9.45069566e-02f, 8.94280151e-02f,
  3.34899902e-01f, -5.37281215e-01f, 2.00478137e-01f, 1.77664578e-01f, 3.68294507e-01f, 4.31286752e-01f, 1.93825334e-01f, 1.68783844e-01f, 1.14051491e-01f, -1.85551837e-01f,
  -4.10591334e-01f, -4.49659199e-01f, -3.94386649e-01f, -3.28004926e-01f, -2.42834598e-01f, -4.52548638e-02f, 1.07881427e-01f, 1.76252216e-01f, 3.06088269e-01f, 1.14554331e-01f,
  -3.03354841e-02f, 1.04866989e-01f, 1.15574650e-01f, -1.93249136e-02f, -3.15218925e-01f, -1.31817237e-01f, -6.11555688e-02f, -4.96407077e-02f, -9.80395079e-02f, -3.97335172e-01f,
  -3.15286607e-01f, -1.02871157e-01f, 1.13629736e-01f, -9.32866782e-02f, -8.26377049e-02f, -1.53601440e-02f, 4.04117331e-02f, -2.04784051e-02f, -1.53760072e-02f, 8.83492827e-02f,
  3.21006924e-02f, -1.37777269e-01f, -1.24132685e-01f, -6.94605559e-02f, 4.24390547e-02f, 2.22262219e-02f, -1.23580247e-01f, -2.92756278e-02f, -2.14838684e-01f, -1.82607815e-01f,
  -2.90546298e-01f, 3.09848087e-03f, 1.51542112e-01f, -3.52826193e-02f, -1.72102019e-01f, 9.58774313e-02f, -7.42938742e-02f, -1.36828735e-01f, 7.14391023e-02f, -6.37362003e-02f,
  1.95494205e-01f, -5.62369032e-03f, -5.50078265e-02f, -8.73877034e-02f, 4.93743233e-02f, 6.40952587e-02f, 7.88454264e-02f, -1.66109167e-02f, 6.38783127e-02f, 2.78976001e-02f,
  -9.14328769e-02f, -6.07395545e-02f, -5.73482253e-02f, -5.31140789e-02f, -2.14157969e-01f, -8.87428224e-02f, -7.79545382e-02f, -8.63008201e-02f, -5.17133176e-02f, 6.58397516e-03f,
  -1.14357002e-01f, -9.09399893e-03f, 3.45944129e-02f, -2.00106785e-01f, -1.39888465e-01f, -1.09349750e-01f, -1.11982804e-02f, -1.74030721e-01f, 9.74491611e-02f, -1.76542066e-02f,
  -2.58549482e-01f, 6.35717735e-02f, 2.42758635e-02f, -9.27979797e-02f, 1.82100758e-01f, -3.96208018e-02f, -3.80285308e-02f, -4.31649871e-02f, -3.14325839e-02f, -2.32689846e-02f,
  -7.88022764e-03f, -1.22001003e-02f, -1.15079939e-01f, -9.51237679e-02f, 1.90707043e-01f, 1.28191456e-01f, -1.04832657e-01f, -1.73885953e-02f, -9.31663960e-02f, -9.10320655e-02f,
  -1.37668744e-01f, 1.14777908e-01f, 1.21050224e-01f, 2.63150986e-02f, 1.17508136e-01f, 2.68481523e-01f, 1.54034302e-01f, 9.40964594e-02f, 1.79499060e-01f, 1.45401224e-01f,
  9.55083311e-01f, -3.52058530e-01f, 1.49205565e-01f, 5.79176135e-02f, -2.06116855e-01f, -1.86223358e-01f, -3.07315528e-01f, -1.22467265e-01f, -2.97942348e-02f, -9.06166881e-02f,
  7.96829462e-02f, 3.28002959e-01f, 2.53925830e-01f, 1.21561021e-01f, 2.69509077e-01f, -1.19129762e-01f, -2.46953696e-01f, 3.00564498e-01f, 2.79326767e-01f, -9.20488313e-02f,
  -2.81310141e-01f, -1.65060908e-01f, 1.28860250e-01f, 3.85976210e-02f, -3.93678635e-01f, 4.86601591e-02f, -1.46194458e-01f, -5.08902222e-02f, -4.49988991e-02f, -4.05255079e-01f,
  1.70219421e-01f, 3.10783416e-01f, 1.63846552e-01f, 5.17652333e-02f, 5.74271567e-02f, -4.49566022e-02f, 2.14843079e-02f, -4.75309566e-02f, -4.77522574e-02f, -1.21499173e-01f,
  -2.21193079e-02f, -4.21117060e-02f, -1.24812182e-02f, -2.19312832e-02f, -1.29758045e-01f, 3.59135156e-04f, 9.70909446e-02f, 6.44802824e-02f, 4.12630439e-02f, 4.18785661e-02f,
  -3.42953019e-02f, 4.99573015e-02f, 1.51268402e-02f, 8.81144330e-02f, 1.55348942e-01f, 1.34990528e-01f, 6.29023015e-02f, 1.88476779e-02f, 2.30327025e-01f, -3.96219604e-02f,
  1.39581144e-01f, 1.73851788e-01f, 1.36701971e-01f, 7.42547810e-02f, 1.44484892e-01f, 1.03339434e-01f, 3.46198529e-02f, -2.82754581e-02f, 1.91707477e-01f, -2.39763875e-02f,
  -2.44520918e-01f, 1.05923891e-01f, 1.25271365e-01f, 5.76252444e-03f, -8.52341112e-03f, -2.17683855e-02f, -1.15677025e-02f, -2.52171922e-02f, 5.68058789e-02f, -1.82192270e-02f,
  -4.45492081e-02f, -1.35576772e-02f, 4.78602713e-03f, -1.55261010e-01f, -1.47323444e-01f, -3.32144373e-06f, -2.40867194e-02f, -7.58402720e-02f, -5.25242537e-02f, -1.48464084e-01f,
  -2.35383719e-01f, 5.18664718e-01f, -1.79004818e-02f, -3.35741751e-02f, -4.21471484e-02f, -6.50184453e-02f, 1.27507955e-01f, -2.87825316e-02f, -1.71768069e-01f, -1.42483458e-01f,
  2.17978135e-02f, 5.64010590e-02f, 8.05725809e-03f, -8.15311354e-03f, -5.59638534e-03f, -5.42319603e-02f, -3.07120569e-02f, 1.37909278e-01f, 8.02828744e-02f, -2.42634431e-01f,
  -1.18708372e-01f, 5.16153984e-02f, 1.00472391e-01f, 8.53339806e-02f, 3.68593819e-02f, 2.23196864e-01f, 1.54058787e-03f, -9.34019238e-02f, 1.45872384e-01f, -2.13404402e-01f,
  5.62455893e-01f, -7.03443736e-02f, 4.07547474e-01f, 6.47649243e-02f, 1.24173976e-01f, 1.42303348e-01f, 2.82889068e-01f, 1.97421595e-01f, -1.19433373e-01f, -1.85419675e-02f,
  -7.82934725e-02f, -2.16647223e-01f, -2.38047406e-01f, -1.97145075e-01f, -2.69868467e-02f, 5.26383966e-02f, 5.56931421e-02f, 2.36362249e-01f, 1.34811521e-01f, 8.87803286e-02f,
  -1.71965316e-01f, 2.34403275e-02f, 1.51343122e-01f, 1.09433644e-01f, -5.69659956e-02f, 2.33388552e-03f, 5.04724607e-02f, 1.15075320e-01f, 2.25308631e-02f, -1.52461678e-01f,
  1.77569792e-01f, 2.83563823e-01f, -7.93833062e-02f, -2.24251747e-01f, -9.14212838e-02f, -7.39325061e-02f, 1.33587420e-02f, -3.11707314e-02f, -5.22465073e-02f, 3.91921215e-03f,
  -3.69920209e-03f, 1.13007590e-01f, 3.95484790e-02f, 4.21505719e-02f, 1.74305990e-01f, -2.14686915e-02f, 1.48619667e-01f, 2.92096473e-02f, -3.70082185e-02f, -6.91390783e-02f,
  -8.45425501e-02f, 8.56285915e-02f, 1.76420972e-01f, 1.04432493e-01f, 8.27889964e-02f, 5.36484681e-02f, 2.16920357e-02f, 1.09057054e-01f, 4.96460013e-02f, 6.50681481e-02f,
  1.83255095e-02f, 2.29994357e-01f, 1.45519435e-01f, 2.60100830e-02f, 1.31865973e-02f, 9.72264167e-03f, 1.15675764e-04f, 5.87399304e-02f, 1.49389729e-01f, 2.30785847e-01f,
  1.12367876e-01f, 1.15870439e-01f, 1.76436335e-01f, 1.12330437e-01f, 1.15820942e-02f, 1.57050923e-01f, 1.32805184e-01f, -3.10971495e-02f, 9.61777195e-02f, -2.13117599e-02f,
  9.65593234e-02f, 1.16488695e-01f, 1.16401821e-01f, -2.29093321e-02f, 8.59167650e-02f, 1.77997023e-01f, 4.92796935e-02f, 5.40129691e-02f, 9.20517072e-02f, 7.32117668e-02f,
  -1.83619305e-01f, 5.72181083e-02f, 7.64738694e-02f, -1.00771315e-01f, 8.52224883e-04f, -5.59011661e-02f, 8.06760509e-03f, -1.68732122e-01f, -1.57463551e-01f, -8.45072344e-02f,
  6.21472448e-02f, 1.46704525e-01f, 1.61330476e-01f, 5.71851060e-02f, 1.82987884e-01f, 5.08530810e-02f, -1.68529674e-01f, -1.34676592e-02f, -1.22346312e-01f, -1.05745733e-01f,
  -4.97131310e-02f, 1.56064155e-02f, -5.28603494e-02f, 3.15108150e-02f, -5.66928871e-02f, 1.20110922e-01f, -1.04791010e-02f, 3.96156907e-02f, 1.06642127e-01f, 2.37688534e-02f,
  -5.21925867e-01f, -8.27858299e-02f, -1.39587954e-01f, 7.79444166e-03f, 3.39199334e-01f, -3.76144424e-02f, -2.49566734e-01f, -2.70631194e-01f, -7.90242031e-02f, 8.96725222e-04f,
  8.00270066e-02f, 1.38102993e-01f, -1.85200833e-02f, 2.92052235e-02f, -1.57620594e-01f, 4.36141044e-02f, 3.34912837e-01f, 1.34001032e-01f, -1.60959542e-01f, 1.86945274e-02f,
  3.32094610e-01f, 1.34750456e-01f, -1.80502757e-01f, -3.51822786e-02f, 2.49375045e-01f, 1.24282442e-01f, 9.85327363e-02f, 2.54815370e-01f, 8.12084526e-02f, 4.19268817e-01f,
  -1.80934057e-01f, -3.40572089e-01f, 1.12034962e-01f, 3.01117688e-01f, 1.17199443e-01f, -2.41450369e-01f, -7.22381473e-02f, -1.31021053e-01f, 1.70288943e-02f, -1.26757905e-01f,
  2.02182725e-01f, -6.00852966e-02f, 1.86381131e-01f, -1.04034208e-01f, -1.43933177e-01f, -1.71963140e-01f, -4.53883521e-02f, -1.98681146e-01f, -3.80599856e-01f, -2.08422899e-01f,
  4.11607236e-01f, 3.14647555e-01f, 2.75396630e-02f, -8.23718756e-02f, -2.81124532e-01f, -6.78615794e-02f, -2.49718130e-01f, -7.66906515e-02f, -3.39218199e-01f, -3.74371827e-01f,
  2.12964211e-02f, 1.25805467e-01f, -1.05381440e-02f, 3.96658778e-02f, -1.47237740e-02f, 6.17963262e-03f, 7.61358216e-02f, 5.15028536e-02f, 7.98813067e-03f, 4.08466645e-02f,
  -5.65057583e-02f, -2.80722007e-02f, -1.35607526e-01f, -1.31695479e-01f, -4.44511101e-02f, -9.79555473e-02f, 5.86366979e-03f, 2.39073411e-02f, 5.04104234e-02f, -3.99804451e-02f,
  4.15254645e-02f, 6.25526812e-03f, 1.25164121e-01f, -7.39354789e-02f, -3.76110151e-02f, -1.14409151e-02f, -4.90112305e-02f, -6.04910813e-02f, -1.40777016e-02f, -2.03037562e-04f,
  -3.10682833e-01f, 2.58137107e-01f, -2.23236382e-02f, -7.14534670e-02f, 1.15106255e-01f, 6.61297888e-02f, -1.47697246e-02f, -4.41542715e-02f, 6.17178492e-02f, -1.54231235e-01f,
  -2.05533445e-01f, -6.77385703e-02f, 5.00080362e-03f, 2.76221870e-03f, -1.38187513e-01f, 2.55595967e-02f, 1.95036799e-01f, 4.38654944e-02f, 6.22743703e-02f, -1.17219970e-01f,
  2.42874846e-02f, -6.24316074e-02f, -1.06505819e-01f, -1.81870192e-01f, -2.38790140e-02f, -1.54047664e-02f, -7.82008618e-02f, -9.35317576e-02f, -2.67890424e-01f, -3.64412218e-01f,
  -2.49585450e-01f, 6.49035037e-01f, 3.42144430e-01f, -4.45321769e-01f, 1.45902902e-01f, 2.80833095e-01f, 6.42191350e-01f, 1.52571321e-01f, -2.79980958e-01f, 2.41202369e-01f,
  3.24059010e-01f, -3.46528172e-01f, -2.13003397e-01f, -1.90285081e-03f, 1.41877145e-01f, 2.64552355e-01f, -4.09937315e-02f, -1.43141598e-01f, -1.31495446e-01f, -4.40442190e-02f,
  -1.81329623e-01f, -2.67455310e-01f, -1.90027833e-01f, -1.96533546e-01f, -2.34219804e-01f, -1.98729411e-01f, 3.61524150e-02f, -1.21713681e-02f, 2.54430175e-01f, -2.27115661e-01f,
  7.65651613e-02f, 3.15756977e-01f, -2.90066719e-01f, -1.42067015e-01f, 4.82460298e-02f, -9.26179066e-02f, -1.49283096e-01f, -7.41063878e-02f, -4.07573283e-02f, -4.96313535e-02f,
  -5.32081388e-02f, 1.36306196e-01f, 1.47224190e-02f, 4.21683155e-02f, 5.95194548e-02f, 6.87929839e-02f, 2.17653699e-02f, -2.42515709e-02f, 3.91234690e-03f, 1.94275871e-01f,
  -3.46881151e-02f, 1.25641450e-01f, 2.86944240e-01f, 1.34989336e-01f, 1.28442109e-01f, -7.38962069e-02f, 2.75953144e-01f, -8.11819360e-02f, 7.83993155e-02f, -2.45579436e-01f,
  -1.95920795e-01f, 1.95638258e-02f, 8.62024054e-02f, 6.67549204e-03f, 5.97123019e-02f, 5.88592254e-02f, 1.11787971e-02f, -5.44536635e-02f, 4.21590637e-03f, -5.91726713e-02f,
  -6.42185658e-02f, 1.52859807e-01f, 3.58275846e-02f, 2.55174078e-02f, -1.14746578e-01f, 2.83152983e-02f, 6.55469000e-02f, 4.29774001e-02f, 4.54966351e-02f, 9.09202397e-02f,
  3.35013159e-02f, 1.13778771e-03f, 8.91878903e-02f, -4.67974879e-02f, 6.56051412e-02f, -1.11025944e-01f, -1.62186280e-01f, 7.41420612e-02f, -1.08215235e-01f, 8.13025758e-02f,
  -3.57787997e-01f, 2.94966400e-01f, -2.67793894e-01f, 4.57407907e-03f, 1.49277925e-01f, 9.22653228e-02f, -2.69373395e-02f, 3.13583687e-02f, 1.05676070e-01f, -1.01743124e-01f,
  5.90812713e-02f, -8.40763748e-02f, 1.87114581e-01f, 5.73629364e-02f, -1.36884511e-01f, -4.07407582e-02f, 1.11564726e-01f, -8.08184668e-02f, 3.70911919e-02f, 1.08775320e-02f,
  -1.52120739e-01f, -6.29772991e-02f, -2.48217270e-01f, -1.33518904e-01f, -1.68271661e-01f, -2.53389031e-01f, -1.04724333e-01f, -1.80620059e-01f, -1.27257910e-02f, -1.62327573e-01f,
  3.79356116e-01f, 5.34671247e-01f, 2.45784387e-01f, 1.97887316e-01f, 7.63814058e-03f, 2.19410919e-02f, 2.41886839e-01f, 8.57554972e-02f, -8.64307582e-02f, 1.76227018e-02f,
  3.21412496e-02f, -2.30151579e-01f, -9.85003412e-02f, 6.58194488e-03f, 7.18480945e-02f, 1.67909950e-01f, 8.33841488e-02f, 5.84247597e-02f, -3.29653919e-02f, -5.63064329e-02f,
  2.93563097e-03f, -3.24134901e-02f, -5.50701050e-03f, -1.69198010e-02f, 2.25435600e-01f, 2.33927034e-02f, 7.21180812e-02f, 1.47423297e-01f, 1.46610336e-02f, 3.12924474e-01f,
  -7.06184059e-02f, 3.31375301e-01f, -4.46699291e-01f, -1.12036161e-01f, -2.39819661e-02f, -1.06919684e-01f, -4.81175184e-02f, -1.22623727e-01f, -7.38460347e-02f, -4.85611223e-02f,
  5.31184040e-02f, -1.48077473e-01f, -1.19142989e-02f, -6.83980286e-02f, -4.04167324e-02f, -3.76545563e-02f, -8.19077566e-02f, 8.40645507e-02f, -3.45489271e-02f, 5.86677380e-02f,
  2.08349638e-02f, -2.64223386e-02f, -8.30994621e-02f, -1.11371219e-01f, 6.93093166e-02f, -1.37688473e-01f, -1.55722555e-02f, -1.36291776e-02f, -1.51266262e-01f, 1.08218892e-02f,
  -2.76125908e-01f, 6.32027164e-02f, 1.01168461e-01f, -5.23936078e-02f, 1.19898636e-02f, -1.24605276e-01f, 6.25037029e-02f, 7.30505539e-03f, -3.79929319e-02f, -1.14560332e-02f,
  -2.05320597e-01f, -3.72306406e-02f, -9.72996950e-02f, -1.14820682e-01f, -1.08459897e-01f, 1.07754581e-02f, -2.92391609e-02f, 2.86557991e-02f, -6.91719279e-02f, -7.13782981e-02f,
  -6.69178069e-02f, -1.71802137e-02f, -4.84098978e-02f, 1.70286566e-01f, 2.03781575e-02f, -1.45415803e-02f, -3.88202518e-02f, -9.92070958e-02f, -1.10841833e-01f, -1.66516766e-01f,
  -1.29725441e-01f, -3.58371735e-01f, -8.55596811e-02f, 6.72457367e-02f, 4.36374806e-02f, -1.96472695e-03f, 5.97864352e-02f, 5.16805612e-02f, 6.85355440e-02f, -1.02101024e-02f,
  -6.77861087e-03f, 4.42842096e-02f, 6.50430769e-02f, -6.46199984e-03f, -2.28234395e-01f, -3.62048782e-02f, -1.79749168e-02f, 5.85011952e-03f, -5.94608262e-02f, 1.14985861e-01f,
  5.71360625e-02f, -1.56501025e-01f, -2.08758205e-01f, -1.28854349e-01f, -9.36873034e-02f, -2.72395641e-01f, -1.45177081e-01f, -2.17424855e-01f, -2.22057283e-01f, -2.29387194e-01f,
  -1.00187922e+00f, -4.56701107e-02f, 1.29147232e-01f, -3.16197634e-01f, -1.17631012e-03f, 1.76367655e-01f, 1.75935149e-01f, 4.88124304e-02f, -8.56968760e-02f, 2.57220659e-02f,
  1.57593787e-02f, -1.03072859e-01f, -4.17909548e-02f, 1.60154343e-01f, 8.12671036e-02f, 2.25643471e-01f, 1.65613562e-01f, 7.57043436e-02f, 5.11293449e-02f, 1.57671899e-01f,
  1.79733858e-01f, -1.77811831e-01f, -2.90753812e-01f, -1.26362294e-01f, 2.18912791e-02f, 3.82631570e-02f, 1.31908074e-01f, 7.36613646e-02f, 1.45606056e-01f, 7.49070495e-02f,
  3.60640526e-01f, -3.16105574e-01f, -4.10065167e-02f, -1.78438485e-01f, -3.06135546e-02f, -1.39981315e-01f, -7.75909871e-02f, -1.12595811e-01f, -1.30462751e-01f, -2.35894043e-02f,
  -1.36218131e-01f, -2.23956294e-02f, -1.36982113e-01f, 1.19023159e-01f, -3.14419605e-02f, -7.35227391e-03f, -3.78561988e-02f, -1.11410856e-01f, 8.78981054e-02f, 1.72224477e-01f,
  3.18320543e-02f, -1.04575016e-01f, 9.49165300e-02f, 1.04752593e-01f, -6.44953549e-02f, -4.69797254e-02f, 3.71753871e-02f, -7.39559904e-02f, 7.21541718e-02f, -8.18560086e-03f,
  1.72972009e-01f, 1.31563976e-01f, -1.00469306e-01f, -2.50629353e-04f, 1.46969721e-01f, 1.85296200e-02f, 5.90103902e-02f, 9.65575352e-02f, 1.03397839e-01f, -6.23930851e-03f,
  -5.27730547e-02f, 8.47932100e-02f, 1.32012025e-01f, -6.65948689e-02f, -6.52445108e-02f, -7.52894953e-02f, 7.13334978e-02f, 2.22308543e-02f, -1.05321325e-01f, 2.99140941e-02f,
  -9.62668434e-02f, -3.95166464e-02f, -1.23532578e-01f, 1.24156475e-01f, 2.76592039e-02f, -9.18453783e-02f, -1.71907675e-02f, -3.97639237e-02f, -7.11133182e-02f, 4.22967300e-02f,
  3.47729921e-01f, -1.21885598e-01f, 1.54886827e-01f, 1.84771754e-02f, -8.70246589e-02f, -1.68135673e-01f, -7.94803873e-02f, -5.02744839e-02f, -5.88446409e-02f, 2.77369339e-02f,
  -2.63915118e-02f, -9.81099755e-02f, 5.30324057e-02f, 4.92398143e-02f, 3.35512906e-02f, -1.23625644e-01f, -7.33404011e-02f, -4.87714224e-02f, 3.66609581e-02f, 7.05099851e-02f,
  -7.14299232e-02f, -2.11142539e-03f, 8.13492481e-03f, 1.11750640e-01f, -2.38118926e-03f, 9.07428637e-02f, 9.23553929e-02f, 4.01402377e-02f, 1.51272863e-02f, 2.15686709e-01f,
  -5.69691002e-01f, -1.22479714e-01f, 2.21805036e-01f, -5.48256278e-01f, -8.08831826e-02f, -4.88693602e-02f, -1.56660657e-02f, -1.70939580e-01f, -2.38860011e-01f, -5.13748117e-02f,
  1.18857905e-01f, -1.62199900e-01f, -1.92952931e-01f, 3.68439704e-02f, -3.64920348e-02f, -8.97044092e-02f, -2.87786890e-02f, -2.25300267e-02f, -5.23359794e-03f, 6.60873502e-02f,
  -2.06344407e-02f, -1.90121278e-01f, -1.28864363e-01f, 5.31319454e-02f, -1.71581089e-01f, -1.11273855e-01f, 5.01812771e-02f, -1.08198002e-01f, 8.58055428e-02f, -1.60719782e-01f,
  -5.20449504e-02f, -2.52338737e-01f, 3.51499349e-01f, -5.88025376e-02f, 1.02852518e-02f, 1.29217664e-02f, 2.63161175e-02f, 1.33374140e-01f, 8.36448222e-02f, -1.15778334e-02f,
  -2.43141368e-01f, 3.00511513e-02f, -1.36207849e-01f, -3.29502821e-02f, -1.23769857e-01f, 5.15540093e-02f, 2.15550270e-02f, 1.47723198e-01f, 1.51741073e-01f, 1.29578590e-01f,
  -1.34069324e-01f, 1.35431318e-02f, -9.83961225e-02f, 1.71109274e-01f, 1.24876583e-02f, 1.01067409e-01f, 1.57384276e-01f, 7.34558105e-02f, 1.95173949e-01f, -1.53507739e-01f,
  1.02615029e-01f, 1.08571917e-01f, 1.50974328e-02f, -5.70570752e-02f, -1.51103854e-01f, 7.66813979e-02f, 1.31394953e-01f, 5.09978905e-02f, 1.74306735e-01f, -8.67919773e-02f,
  6.90239668e-02f, 8.08360893e-03f, 4.26554456e-02f, -1.15166873e-01f, 1.91797665e-03f, -1.05486298e-02f, 2.44488847e-02f, 5.05861342e-02f, 1.10906482e-01f, 6.86166883e-02f,
  -1.18883394e-01f, -3.91000435e-02f, -1.22449823e-01f, -8.68439972e-02f, 1.53041124e-01f, 1.43459067e-01f, 1.72894284e-01f, 7.17815235e-02f, -5.86482286e-02f, 8.87721330e-02f,
  -6.00534022e-01f, 4.03190643e-01f, -1.51199818e-01f, 5.84102347e-02f, -7.76125938e-02f, 1.39446139e-01f, -1.06599994e-01f, 1.22174829e-01f, -2.43095174e-01f, -1.41785756e-01f,
  2.54345108e-02f, -7.82921836e-02f, -8.16135854e-02f, 3.75185087e-02f, 1.04631502e-02f, -1.04933232e-01f, -1.41205981e-01f, -6.39378056e-02f, 6.66747987e-03f, 1.27384085e-02f,
  -3.71567532e-02f, -1.60184175e-01f, -2.09853053e-01f, -1.82276338e-01f, -1.82362840e-01f, -9.46174189e-02f, -1.84378773e-01f, -1.49342686e-01f, -5.78802079e-02f, -3.58334512e-01f,
  -5.19353986e-01f, -4.42181826e-01f, 1.40395135e-01f, -4.84450489e-01f, -1.50453642e-01f, -8.30099061e-02f, -2.60218024e-01f, -1.52143657e-01f, -1.46782458e-01f, -4.17156726e-01f,
  -1.49423450e-01f, 8.28733668e-02f, -8.47549215e-02f, 1.43848106e-01f, 1.19416535e-01f, -2.57154614e-01f, -1.81145564e-01f, 1.73013508e-01f, 5.36703229e-01f, 2.42199004e-01f,
  -3.71345580e-02f, -9.01497807e-03f, 2.53181130e-01f, 9.16469544e-02f, -2.74387479e-01f, -2.58238148e-02f, -1.51916280e-01f, -1.40661597e-01f, -5.15634716e-02f, -4.09540802e-01f,
  6.14180751e-02f, -2.95614898e-01f, 1.96298510e-01f, -1.22428257e-02f, -2.11394399e-01f, 6.19029850e-02f, 1.37091167e-02f, -9.55872387e-02f, 6.97587356e-02f, -3.54351215e-02f,
  -8.49005580e-02f, 8.81087780e-02f, -1.74027961e-02f, -4.61058989e-02f, -8.90682712e-02f, -1.16686076e-02f, 3.44727724e-03f, 1.61069393e-01f, 6.97125271e-02f, -8.87562558e-02f,
  -2.60912567e-01f, -1.06394373e-01f, 1.01322696e-01f, -2.41732714e-03f, 1.28145423e-02f, 2.46445220e-02f, 5.77811301e-02f, 9.13305301e-03f, 1.76153764e-01f, -3.19883585e-01f,
  -7.00535700e-02f, -7.27966288e-03f, -5.62418140e-02f, -8.80958438e-02f, -4.75944802e-02f, 2.65851840e-02f, -2.84419744e-04f, -1.15767054e-01f, 9.11543667e-02f, -7.28614256e-02f,
  4.55716811e-02f, 9.12437215e-03f, 6.71808720e-02f, -1.35214433e-01f, 7.70847872e-02f, -2.13025913e-01f, -3.39207165e-02f, -6.18249588e-02f, 8.01099464e-02f, -2.32305527e-02f,
  5.72428480e-02f, 2.71943887e-03f, -4.40841801e-02f, 3.20888013e-02f, -2.44159754e-02f, 3.56623344e-03f, -2.99723335e-02f, 6.04315326e-02f, -4.41343375e-02f, -6.47549927e-02f,
  -3.07895932e-02f, 1.53042763e-01f, -2.58546829e-01f, -2.67624483e-02f, -2.63774563e-02f, -1.97039340e-02f, 2.44339909e-02f, 1.99520454e-01f, -5.96496873e-02f, 1.27732102e-02f,
  2.85735745e-02f, -6.23261370e-02f, -1.19499303e-01f, -3.58308405e-02f, 1.17648616e-01f, 3.24536338e-02f, -1.18162252e-01f, 1.35406982e-02f, 1.04447521e-01f, -5.99829201e-03f,
  -7.42349541e-03f, -4.58126664e-02f, -3.54410373e-02f, -1.34133115e-01f, -2.46986985e-01f, -4.24814373e-02f, 5.81495687e-02f, -5.51064768e-05f, 1.63187440e-02f, -1.68602020e-01f,
  -4.44703460e-01f, -4.96616848e-02f, 8.07532594e-02f, -1.89802974e-01f, 8.51135030e-02f, 1.57456949e-01f, 1.06223710e-02f, 6.93212524e-02f, -2.56036669e-01f, -2.67058730e-01f,
  5.09616546e-02f, -1.87871501e-01f, -2.82567233e-01f, -2.67469794e-01f, -2.13101730e-01f, -2.11075217e-01f, -2.01162815e-01f, -1.34017974e-01f, -5.04450314e-02f, 1.75406843e-01f,
  -8.58924445e-03f, -1.93134531e-01f, -2.22728491e-01f, -1.67860731e-01f, -1.40859380e-01f, -3.26401234e-01f, -3.63963038e-01f, -2.10645512e-01f, -1.54483721e-01f, -4.05174106e-01f,
  3.49185795e-01f, 3.27261150e-01f, 3.32730487e-02f, -6.96154460e-02f, 2.92587783e-02f, -1.13483883e-01f, -2.16481239e-02f, -8.47884938e-02f, -8.18564817e-02f, -4.88507189e-02f,
  -4.08419967e-02f, 6.98383749e-02f, -1.02880776e-01f, 9.00302678e-02f, 1.00099258e-01f, 1.22352391e-01f, 1.05428666e-01f, -5.80787584e-02f, 2.53199264e-02f, 4.07510437e-02f,
  1.10468566e-01f, 1.85520098e-01f, 1.60140976e-01f, 9.28562954e-02f, 1.87129781e-01f, -3.63612771e-02f, 1.63331345e-01f, 7.04082847e-02f, 1.72332861e-02f, -7.23082805e-03f,
  -4.30559926e-02f, -2.08957940e-01f, 2.42357682e-02f, -7.83167183e-02f, 4.88076583e-02f, 2.32933126e-02f, -7.81715438e-02f, -6.66218847e-02f, -3.39624323e-02f, -1.30255865e-02f,
  7.02936202e-02f, 1.10693768e-01f, -2.79652718e-02f, -1.49603292e-01f, 4.46969979e-02f, -3.56732868e-02f, -1.02635168e-01f, 5.35708927e-02f, 1.10330403e-01f, 4.33108732e-02f,
  7.06097037e-02f, 1.25151917e-01f, -3.83562557e-02f, 1.30066231e-01f, 7.39747435e-02f, 6.72535822e-02f, 8.63726735e-02f, 1.00989699e-01f, 9.09286514e-02f, 8.69779140e-02f,
  -9.40344632e-02f, 6.63829967e-02f, -2.69403666e-01f, 1.75496917e-02f, 3.56080718e-02f, 9.01058689e-03f, 6.18785387e-03f, -5.10434434e-02f, 5.16804792e-02f, 3.34927738e-02f,
  9.52805057e-02f, -8.63732621e-02f, -1.32578820e-01f, 6.33092076e-02f, -2.91703064e-02f, 2.84591522e-02f, 5.38635030e-02f, -1.82973251e-01f, -2.74328887e-02f, 9.06450450e-02f,
  1.33257022e-03f, -8.18207413e-02f, -2.17748638e-02f, -1.65512711e-01f, -6.92279786e-02f, -1.85522586e-01f, -8.32412764e-03f, 8.54440331e-02f, -8.17709044e-02f, -2.61238754e-01f,
  3.16324681e-01f, 1.05948441e-01f, -4.87995327e-01f, 2.90564567e-01f, 2.45701857e-02f, -1.00275986e-01f, -1.30249709e-01f, 1.57276407e-01f, 3.90819162e-01f, 1.51439413e-01f,
  1.14779972e-01f, -6.70962501e-03f, -7.00484961e-02f, -2.17511639e-01f, -5.66315591e-01f, -2.58880973e-01f, -3.23625952e-01f, -5.30910194e-01f, -4.89660144e-01f, -2.18672320e-01f,
  6.93800524e-02f, 8.18310454e-02f, 1.17169721e-02f, 5.70680313e-02f, 1.87743962e-01f, 6.43469617e-02f, 1.21745244e-01f, 6.81694075e-02f, -5.87734319e-02f, -7.55364001e-02f,
  -2.95357078e-01f, -5.25781177e-02f, -2.06095785e-01f, -9.56460610e-02f, -8.96657705e-02f, -1.02212757e-01f, -5.58479056e-02f, -1.22314423e-01f, -1.44424185e-01f, -1.41645283e-01f,
  -2.30811805e-01f, -1.36315078e-01f, -1.92656562e-01f, -7.48688430e-02f, -3.71278971e-02f, -5.86413555e-02f, -4.10355255e-02f, -3.34196806e-01f, -1.23190500e-01f, -8.65369588e-02f,
  -4.11576480e-02f, -2.38981158e-01f, -4.02113736e-01f, 3.28347124e-02f, -2.48984963e-01f, -1.01312302e-01f, -1.42143205e-01f, -1.72305584e-01f, -1.77249297e-01f, 2.02723116e-01f,
  4.07178998e-02f, -1.03401169e-01f, -3.69055308e-02f, 1.48639619e-01f, 2.08048433e-01f, 2.17052884e-02f, -7.85494298e-02f, 2.08787080e-02f, 3.59550454e-02f, 1.10730968e-01f,
  -1.64050255e-02f, -4.61308192e-03f, -4.38982621e-03f, -4.62453514e-02f, -1.26852132e-02f, -7.57306218e-02f, -7.06607327e-02f, -1.75204519e-02f, -1.43494979e-01f, 2.80634426e-02f,
  -1.03793107e-02f, -2.15324592e-02f, 3.04065477e-02f, -7.46122003e-03f, 1.05291847e-02f, -7.81437755e-02f, 2.30100118e-02f, -7.62006789e-02f, 1.12540470e-02f, -5.41670881e-02f,
  3.78032982e-01f, -1.32086590e-01f, -8.48022327e-02f, -6.43129647e-02f, -1.13154203e-01f, -2.98941252e-03f, 1.51491344e-01f, -6.65414631e-02f, -1.24068424e-01f, -2.87753064e-02f,
  -1.68374524e-01f, -7.18125477e-02f, 8.26331824e-02f, -1.56937148e-02f, -1.08319156e-01f, 9.29247066e-02f, -2.81804334e-02f, -1.15468100e-01f, -1.42766535e-01f, 2.69077416e-03f,
  1.87249243e-01f, 1.60538256e-01f, 4.91252579e-02f, -3.14037665e-03f, -3.40930670e-02f, -3.72824483e-02f, 9.05337557e-02f, 7.16502070e-02f, -8.35072249e-02f, 3.97941470e-01f,
  -2.05077082e-02f, -3.62382710e-01f, 1.94093168e-01f, 1.71683118e-01f, 2.23158300e-01f, 2.23803669e-01f, 1.55556381e-01f, -1.41090052e-02f, 1.63336694e-01f, -9.25189909e-03f,
  -7.18671456e-02f, 2.05671623e-01f, 9.81713906e-02f, 1.03420787e-01f, 1.11007661e-01f, 7.43161067e-02f, 1.08825944e-01f, 9.96677727e-02f, 2.41823986e-01f, 2.06658304e-01f,
  1.06444396e-01f, 1.99111365e-03f, -8.65691230e-02f, 2.47252695e-02f, -7.76448324e-02f, 1.78317040e-01f, 8.23544431e-03f, 3.39898281e-02f, 1.06611386e-01f, -2.94386093e-02f,
  2.78588146e-01f, -1.82644457e-01f, 2.24654555e-01f, -1.07280940e-01f, -7.94983655e-02f, -1.98834896e-01f, -7.18838871e-02f, -4.45001386e-02f, -1.02056533e-01f, -4.53512184e-02f,
  -6.03013001e-02f, -1.28828838e-01f, -1.77778110e-01f, -1.89437956e-01f, -1.35613635e-01f, -5.31237833e-02f, -1.52510703e-01f, 6.88057207e-03f, 1.12337679e-01f, -4.53693140e-03f,
  -1.24840714e-01f, -6.88426942e-02f, 2.24651992e-01f, 7.32189231e-03f, 3.50113250e-02f, 8.74890909e-02f, -1.02903321e-01f, -1.80239975e-01f, 8.62031132e-02f, 6.00498095e-02f,
  2.18480393e-01f, 1.37169166e-02f, -1.01916958e-02f, 3.13559063e-02f, 5.93193732e-02f, 7.73949251e-02f, 1.43740103e-01f, 1.48217306e-01f, 3.89448330e-02f, -1.48627892e-01f,
  1.03347972e-01f, 1.34259120e-01f, 1.38859972e-01f, 6.29475713e-02f, -1.24321721e-01f, -7.30247721e-02f, 2.95444438e-03f, -8.52160454e-02f, -5.40916733e-02f, -1.05947807e-01f,
  -3.24414135e-03f, -3.12743746e-02f, -2.37077937e-01f, -6.95874542e-02f, 6.23930804e-03f, 1.43131614e-02f, -2.02338975e-02f, -1.02697149e-01f, -1.94900170e-01f, -5.24627343e-02f,
  1.63282335e-01f, 2.46024579e-02f, 1.60435140e-01f, 6.38026819e-02f, -1.46987781e-01f, -1.90441310e-01f, -3.54277343e-02f, 1.37512043e-01f, 4.23780829e-02f, 5.46932667e-02f,
  3.87823358e-02f, -1.04806229e-01f, -1.48482710e-01f, -7.80782402e-02f, 3.51502150e-02f, -4.82263006e-02f, -7.15253577e-02f, 9.08821672e-02f, 1.43123195e-01f, 3.56021225e-02f,
  -4.70558777e-02f, 1.40045896e-01f, 3.04710150e-01f, 1.40811637e-01f, 1.70327127e-02f, 1.61061868e-01f, 5.99616058e-02f, 1.18407406e-01f, 7.08609894e-02f, 6.32315427e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 26)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 26;
const float L0_fan_Bp_bar_data[] = {
  -2.84381453e-02f, 2.87314475e-01f, 1.57899961e-01f, 2.05759019e-01f, 2.71347761e-01f, 1.94923788e-01f, 1.70615345e-01f, 5.37056506e-01f, 3.63383859e-01f, 3.79057258e-01f,
  1.20036818e-01f, 5.29445052e-01f, 4.05075192e-01f, 2.27591708e-01f, 3.80968183e-01f, 3.63941133e-01f, 3.05823863e-01f, 2.20928520e-01f, 2.87089735e-01f, 2.48874187e-01f,
  2.30283484e-01f, 2.34280735e-01f, 4.10008013e-01f, 5.65287024e-02f, 2.57005602e-01f, -4.02661413e-02f
};

// L1_fan_Wp (Shape: 3 x 32)
const int L1_fan_Wp_rows = 3;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  -1.52399987e-01f, 5.34583479e-02f, 1.24167159e-01f, -9.54644680e-02f, -5.42200468e-02f, -1.10662945e-01f, 1.86988488e-01f, 6.53651506e-02f, 2.19161138e-01f, 4.02718693e-01f,
  1.08854219e-01f, -6.73337504e-02f, -1.24727026e-01f, -1.22913765e-02f, -1.19929641e-01f, 1.51635587e-01f, 3.86482514e-02f, -7.13947937e-02f, -3.83890808e-01f, 1.21729769e-01f,
  2.78934389e-02f, 2.07710862e-01f, -1.28860459e-01f, -7.79218674e-02f, -1.17574252e-01f, -2.32687593e-01f, 1.45205855e-03f, 4.61218506e-02f, 3.24408859e-01f, -6.89394698e-02f,
  -1.97202623e-01f, 2.84540057e-01f, 1.15526453e-01f, -7.22973049e-02f, -7.25993887e-02f, 1.04023218e-01f, -1.64005935e-01f, -1.07076159e-02f, 3.44007492e-01f, 2.05853730e-01f,
  1.11933142e-01f, 5.14226377e-01f, -1.33215651e-01f, -1.26370892e-01f, -8.14752802e-02f, -2.85379607e-02f, 9.19948295e-02f, 2.57567391e-02f, 1.18077248e-01f, 2.25263014e-01f,
  2.00518090e-02f, -2.09003717e-01f, -2.70124916e-02f, 2.05305234e-01f, 8.92553627e-02f, 2.75581986e-01f, 1.16216414e-01f, 1.66573688e-01f, -1.36032060e-01f, 2.42244929e-01f,
  2.06669137e-01f, -8.48922655e-02f, -1.60453930e-01f, -2.00615227e-02f, 3.20195183e-02f, -3.61720502e-01f, -3.53897586e-02f, 3.52407217e-01f, 2.42304936e-01f, -3.27740572e-02f,
  -7.20830262e-02f, 5.24909124e-02f, -4.31672812e-01f, -4.04120654e-01f, -1.51729971e-01f, 1.38951361e-01f, -1.95145592e-01f, -1.30391851e-01f, -6.30490929e-02f, -1.09363109e-01f,
  1.39671519e-01f, 2.52727628e-01f, 3.11103344e-01f, 2.15021983e-01f, -1.05568856e-01f, -1.27620772e-01f, -8.93580243e-02f, 1.37349963e-01f, -8.22772384e-02f, -1.45347351e-02f,
  1.61853135e-01f, -1.93187267e-01f, -1.99069336e-01f, -2.80567378e-01f, 5.38660660e-02f, 1.59736246e-01f
};

// L1_fan_Wp_bar (Shape: 26 x 32)
const int L1_fan_Wp_bar_rows = 26;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  3.60037148e-01f, 2.70913631e-01f, 1.03341490e-01f, 9.76441428e-02f, 3.09655368e-01f, 1.03166655e-01f, 4.63309437e-02f, -4.24077123e-01f, 1.48898419e-02f, -4.00020540e-01f,
  5.80505021e-02f, 1.94035321e-01f, 2.14224860e-01f, 3.93007606e-01f, -8.72430950e-02f, -3.62823382e-02f, 2.86481768e-01f, -8.69292989e-02f, 3.25166017e-01f, -5.90004101e-02f,
  1.04545325e-01f, -5.90873241e-01f, -1.81847706e-01f, 1.09948106e-02f, -5.00880629e-02f, -1.09397016e-01f, 1.78857416e-01f, 2.02546626e-01f, -1.11285649e-01f, 1.50384873e-01f,
  4.39863145e-01f, -3.34723592e-02f, 1.98566183e-01f, 2.18928486e-01f, 1.17773831e-01f, -3.97065617e-02f, -1.21536091e-01f, -2.73080051e-01f, -5.23549795e-01f, 1.21380068e-01f,
  1.17736816e-01f, 2.74113476e-01f, 1.15281686e-01f, 5.26036024e-02f, 1.35868564e-01f, 1.86671123e-01f, 3.19723636e-01f, -1.90301668e-02f, -1.27899483e-01f, 2.58511424e-01f,
  2.94662505e-01f, 9.07295868e-02f, 8.72261170e-03f, 1.17230184e-01f, 2.67492294e-01f, -2.63126254e-01f, 3.57524127e-01f, 2.19756648e-01f, -4.49040264e-01f, -1.59791782e-01f,
  1.14427425e-01f, -2.38930866e-01f, -1.86870947e-01f, -1.07066400e-01f, 3.17754835e-01f, 2.05603242e-01f, 2.13548645e-01f, 1.37425348e-01f, -1.24377087e-01f, -1.39006348e-02f,
  1.90094233e-01f, 3.96630913e-02f, -1.93813443e-01f, 1.21493421e-01f, -1.15185775e-01f, 4.20520216e-01f, -3.25015843e-01f, 3.20749357e-02f, -1.26022324e-02f, -6.52647205e-03f,
  1.44684687e-01f, 3.84458214e-01f, 9.58334059e-02f, -5.22029579e-01f, 6.02256596e-01f, -3.38064939e-01f, 1.41710490e-01f, 5.47238708e-01f, 3.52618575e-01f, -7.19100311e-02f,
  3.44313890e-01f, 1.91961125e-01f, 1.85795361e-03f, 6.25665067e-03f, -5.44254892e-02f, 1.35612547e-01f, 3.58416885e-02f, 1.63759947e-01f, 1.70926645e-01f, -7.53843635e-02f,
  9.26267058e-02f, -2.12537199e-01f, -1.01218551e-01f, 6.51777014e-02f, -1.71255022e-01f, -8.91321003e-02f, -3.55124116e-01f, 8.25615823e-02f, -8.39098319e-02f, 1.84943248e-02f,
  -2.56908447e-01f, -2.75871128e-01f, -7.79701099e-02f, 2.43170083e-01f, 1.17117971e-01f, -4.35626619e-02f, 3.76203388e-01f, -1.99243456e-01f, 5.20590208e-02f, -1.42761618e-02f,
  -2.17889786e-01f, -3.98411542e-01f, 1.02512226e-01f, -2.23900363e-01f, -2.30803162e-01f, -1.40718162e-01f, -1.34249955e-01f, 2.80537546e-01f, -1.57026816e-02f, 1.43051922e-01f,
  1.79768458e-01f, 3.89756083e-01f, 1.62939608e-01f, 1.99554697e-01f, 3.12181056e-01f, 2.65353411e-01f, 3.83230925e-01f, 5.97930253e-02f, -1.46759421e-01f, 1.22549534e-01f,
  -3.81732993e-02f, 1.60781577e-01f, 2.61756536e-02f, -1.14352033e-01f, 3.02415490e-01f, -4.72557507e-02f, -2.29333103e-01f, -1.78573549e-01f, 5.69895059e-02f, -2.66859531e-01f,
  2.96164677e-02f, 2.51606703e-01f, 6.00516081e-01f, 2.85108965e-02f, 5.28270192e-02f, 5.45108795e-01f, 4.18627322e-01f, 1.34782925e-01f, -5.39341606e-02f, -1.34493068e-01f,
  3.21551979e-01f, 2.79939085e-01f, 2.82828152e-01f, -4.19352770e-01f, -1.28504634e-01f, -2.64039636e-01f, -1.17778003e-01f, -1.75170675e-01f, 2.07945302e-01f, 3.44633877e-01f,
  2.33457685e-01f, -4.16975498e-01f, 1.28269807e-01f, 3.30252707e-01f, 3.89925450e-01f, 3.53790224e-01f, 9.27318931e-02f, 4.36333358e-01f, 1.73215419e-01f, -2.01798052e-01f,
  2.07348272e-01f, -1.30042002e-01f, 7.49614462e-02f, 5.81303239e-02f, -5.91954231e-01f, -1.51363522e-01f, -2.73178786e-01f, -3.05934161e-01f, 8.26786924e-03f, -2.08264038e-01f,
  3.12782228e-01f, 3.29492688e-02f, 2.21975818e-01f, 1.83451727e-01f, 3.95615399e-01f, -2.09378041e-02f, 5.08860648e-02f, -8.81442875e-02f, 1.44498736e-01f, 3.20314229e-01f,
  -2.67360508e-01f, 2.79774338e-01f, 4.31122631e-01f, -1.61920283e-02f, 1.76639929e-01f, 3.62410396e-01f, 1.67892635e-01f, 3.77063692e-01f, -5.34458570e-02f, 2.50600427e-01f,
  -6.59812212e-01f, 9.67238545e-02f, 5.56975961e-01f, -1.79029390e-01f, 1.60409883e-01f, -1.90101668e-01f, -1.72858894e-01f, -1.01664579e-02f, 1.93289384e-01f, -4.25851911e-01f,
  2.29844414e-02f, 1.29461914e-01f, -1.27229571e-01f, -3.15692350e-02f, 1.69417843e-01f, 1.16290532e-01f, 1.76720902e-01f, -1.19113632e-01f, 1.51305825e-01f, -3.35096344e-02f,
  2.61605084e-01f, 1.60381570e-02f, 5.25608599e-01f, -1.07780285e-01f, -2.05306381e-01f, 3.86891156e-01f, 2.24033579e-01f, -2.02622250e-01f, -2.94637144e-01f, -3.13028127e-01f,
  2.41177484e-01f, -2.91209668e-01f, 3.12923670e-01f, 1.00997634e-01f, -1.70540348e-01f, 1.25544652e-01f, 9.57927201e-03f, 1.34834081e-01f, 6.07998729e-01f, 5.82420127e-03f,
  -6.06595799e-02f, 2.31731415e-01f, 3.32044125e-01f, 4.26924944e-01f, -2.05807835e-02f, 2.71300320e-02f, 1.21274263e-01f, -6.19175993e-02f, 1.49508238e-01f, 6.42449856e-02f,
  -2.40945280e-01f, -1.20414630e-01f, -2.61090487e-01f, -2.14470416e-01f, -3.50345410e-02f, -8.76699686e-02f, 3.77452075e-01f, 5.24097860e-01f, 6.24613501e-02f, 1.69091225e-01f,
  -1.45892158e-01f, 5.05488932e-01f, 5.48134521e-02f, -1.97079360e-01f, -1.81994095e-01f, -1.98638320e-01f, -1.49895832e-01f, -1.34594843e-01f, -3.50524932e-01f, -3.77121598e-01f,
  1.63316473e-01f, -2.25070670e-01f, 4.68236625e-01f, 2.66952097e-01f, 2.92052239e-01f, 6.73095733e-02f, 8.56532529e-02f, -1.61908954e-01f, 3.07061106e-01f, 8.60394463e-02f,
  2.81138748e-01f, -1.60885587e-01f, 7.92050511e-02f, -2.40063388e-03f, -5.18149734e-01f, 3.22151706e-02f, 8.70650709e-02f, -8.14094245e-02f, 1.18509255e-01f, 6.07560277e-02f,
  5.37974909e-02f, -1.19843837e-02f, -2.88657509e-02f, 4.79865186e-02f, -7.82433227e-02f, 3.88183862e-01f, 4.18662578e-01f, 2.96738297e-02f, 4.21614408e-01f, -1.43397316e-01f,
  3.41648430e-01f, -4.11876626e-02f, -7.22099245e-02f, -3.44034545e-02f, -2.90021356e-02f, -1.65437803e-01f, -7.04469308e-02f, -2.12168381e-01f, 1.68372348e-01f, -4.85455617e-02f,
  -1.52113587e-02f, 8.40077028e-02f, 1.11234695e-01f, -1.83448881e-01f, -2.20971107e-01f, -1.39319211e-01f, 6.19662255e-02f, 1.69204194e-02f, 2.16919426e-02f, 4.56725247e-02f,
  9.73184109e-02f, -2.54222840e-01f, 5.50328016e-01f, 2.35100567e-01f, 2.99799386e-02f, 1.98518019e-03f, 2.09923849e-01f, -5.00517040e-02f, 5.99843681e-01f, 7.73284212e-02f,
  -3.32566500e-01f, 3.17986727e-01f, -9.18232463e-03f, -6.49106354e-02f, -5.30785680e-01f, 7.35874400e-02f, -3.84190351e-01f, -1.95218161e-01f, -9.51827690e-02f, -5.94299175e-02f,
  4.47759300e-01f, 8.88712406e-02f, 1.98852047e-01f, 1.58873484e-01f, 1.16559796e-01f, -1.34922326e-01f, -9.93490294e-02f, 9.76383537e-02f, 2.32721552e-01f, 1.50512367e-01f,
  -4.91428412e-02f, 8.98887366e-02f, 4.36390251e-01f, -6.56444654e-02f, 1.10134535e-01f, 1.49031714e-01f, 8.24132860e-02f, 2.68853933e-01f, -8.14427901e-03f, 3.16121668e-01f,
  1.06673218e-01f, -1.00246094e-01f, -7.73235224e-03f, 4.90158908e-02f, -4.70742630e-03f, -1.20446719e-01f, -4.33530182e-01f, -2.95819730e-01f, 5.90386875e-02f, -1.37090325e-01f,
  2.32990161e-01f, 2.47045174e-01f, 1.29987895e-01f, -1.16824865e-01f, -7.09747374e-02f, 7.19299018e-02f, 3.84193957e-02f, -1.08293526e-01f, -1.44017398e-01f, -4.72812913e-02f,
  4.19447273e-01f, 1.74736679e-01f, -1.19573899e-01f, 5.09605050e-01f, 1.63572997e-01f, -1.49850368e-01f, 2.56868303e-01f, 4.00600992e-02f, 3.91138315e-01f, 2.49563586e-02f,
  1.67658493e-01f, 2.42239401e-01f, -5.44406831e-01f, -4.13925946e-02f, 2.40077674e-01f, 2.65534967e-01f, -8.26509073e-02f, -1.44009352e-01f, -5.21665752e-01f, 7.71382079e-03f,
  -4.57989499e-02f, -2.04053998e-01f, 1.58156306e-01f, -8.03812966e-02f, 3.18278372e-02f, 1.77456349e-01f, 1.56531408e-01f, 2.32265919e-01f, 3.37551743e-01f, -1.22061737e-01f,
  6.03200495e-02f, -2.11429119e-01f, -3.30166817e-01f, 3.61670941e-01f, 1.02290198e-01f, 3.70096743e-01f, 3.33165467e-01f, -3.67410660e-01f, 2.20965102e-01f, 4.23480794e-02f,
  4.34232116e-01f, 1.38445988e-01f, -5.42432070e-01f, 4.12795126e-01f, -2.43010238e-01f, 5.47547713e-02f, 2.64575273e-01f, 1.90801457e-01f, 1.81620196e-01f, -4.62293178e-01f,
  4.88258213e-01f, 3.19542766e-01f, -3.45823169e-01f, -1.81817740e-01f, -5.76702729e-02f, -5.75880855e-02f, -1.46347880e-01f, 9.93023440e-02f, 2.09288567e-01f, 1.52303502e-01f,
  2.25583389e-01f, 2.75956988e-01f, 1.05778456e-01f, -5.84974475e-02f, 1.15931854e-01f, 3.77532423e-01f, -3.23665559e-01f, -3.70804489e-01f, -1.77444994e-01f, 3.29262428e-02f,
  -2.65430897e-01f, 1.55452624e-01f, 5.36662415e-02f, 1.96024664e-02f, 3.97099674e-01f, 5.39383404e-02f, 1.25398964e-01f, -1.17227450e-01f, 2.71853775e-01f, -3.14502895e-01f,
  2.90755391e-01f, 3.23003739e-01f, 5.35043001e-01f, 3.93478930e-01f, 1.56933904e-01f, -2.09850878e-01f, -2.88322717e-01f, -1.42318821e-02f, -1.02208130e-01f, -1.94104075e-01f,
  1.66544303e-01f, 1.59501716e-01f, 1.00265697e-01f, 4.67669368e-02f, -5.40195685e-03f, -3.34672779e-01f, 8.77777264e-02f, 1.71186686e-01f, 3.86276469e-02f, 4.99406457e-01f,
  -1.63946152e-01f, -5.03606915e-01f, -7.34617934e-02f, -1.29258275e-01f, 2.23102346e-01f, 1.74949825e-01f, -1.15130357e-01f, 1.57166317e-01f, 5.89204133e-01f, 1.03022493e-01f,
  -1.84569687e-01f, 3.06911975e-01f, 1.65216878e-01f, 3.23342085e-01f, 1.47058144e-01f, 2.05636173e-01f, -2.05544621e-01f, 1.91759348e-01f, 4.99791503e-01f, 3.73996824e-01f,
  -1.61459550e-01f, -3.43502253e-01f, 2.28807211e-01f, -8.49173963e-02f, 1.77008510e-01f, -8.12377185e-02f, -1.86397862e-02f, -2.49585450e-01f, -3.54886979e-01f, -4.25459236e-01f,
  5.55974394e-02f, -2.96703041e-01f, -2.43450537e-01f, 1.93603158e-01f, 1.36186644e-01f, 1.06272195e-02f, -1.45895496e-01f, 6.37302781e-03f, 1.56521201e-01f, 9.08415765e-02f,
  4.89121616e-01f, 1.26393735e-01f, 1.11585498e-01f, 7.58552924e-02f, 1.05297245e-01f, 4.28615272e-01f, -2.04517499e-01f, -2.79071778e-01f, -1.39931023e-01f, 2.26762578e-01f,
  2.70718709e-03f, -2.60487050e-01f, 1.82971373e-01f, 1.06400341e-01f, -6.30254066e-03f, -1.92258477e-01f, 4.61014546e-02f, -2.63217777e-01f, -4.11993638e-02f, 6.93108737e-02f,
  5.29896975e-01f, -1.39200855e-02f, 4.96398397e-02f, 3.70772272e-01f, 1.32157966e-01f, -5.17799079e-01f, 7.91879967e-02f, -5.45317307e-02f, -3.77079636e-01f, 2.45886862e-01f,
  -6.40902966e-02f, 4.90397662e-02f, -2.93115955e-02f, -1.37600556e-01f, 1.21918157e-01f, -2.96619534e-01f, -1.50868267e-01f, -1.55811831e-01f, -4.05699193e-01f, -2.58802176e-01f,
  -4.09606934e-01f, -3.68220895e-03f, 2.03928500e-01f, 1.56201109e-01f, 1.97849736e-01f, -1.89370990e-01f, 1.77595720e-01f, 1.74953088e-01f, 1.46142364e-01f, -7.04417527e-02f,
  1.65585771e-01f, -1.12550996e-01f, -1.25103146e-01f, -2.66569912e-01f, -1.17157102e-02f, -8.37778151e-02f, 1.81745410e-01f, -2.72728562e-01f, 2.61181116e-01f, 1.32576898e-02f,
  1.97900787e-01f, -4.96718995e-02f, 1.20894816e-02f, 4.92752641e-01f, 4.99921441e-01f, 3.21025133e-01f, 3.32829237e-01f, -2.57479101e-01f, -7.47604147e-02f, 1.76655920e-03f,
  -4.23137665e-01f, -1.16508678e-01f, -1.31423265e-01f, 7.74587989e-02f, -1.08108059e-01f, -8.49474221e-02f, 2.63601094e-01f, -1.35169849e-01f, -9.49460175e-03f, 8.92846212e-02f,
  2.48581395e-01f, 1.26375020e-01f, -1.12019584e-01f, 1.87397131e-03f, -5.47458604e-02f, 2.13255659e-02f, 1.33829772e-01f, 3.53861630e-01f, -2.03291729e-01f, 3.17109734e-01f,
  -1.93649456e-01f, 6.33215830e-02f, 8.85657743e-02f, 8.05673152e-02f, 2.11742278e-02f, 1.84689417e-01f, 1.76892042e-01f, -2.50431955e-01f, 3.21764618e-01f, 1.13770790e-01f,
  2.44172111e-01f, 3.55404764e-01f, 3.79103214e-01f, 1.09454267e-01f, 2.68813521e-01f, 3.94275576e-01f, 4.02487069e-01f, 1.23593852e-01f, -2.05304608e-01f, 2.12794617e-01f,
  7.27095604e-02f, 1.36098936e-01f, -1.10367216e-01f, 3.23980838e-01f, 4.08756077e-01f, 3.40200603e-01f, 3.64114165e-01f, -9.43460166e-02f, 2.64338553e-01f, 1.24806510e-02f,
  1.72840953e-01f, -3.69523801e-02f, 1.36811987e-01f, 3.22984725e-01f, -4.84545454e-02f, -2.37364948e-01f, 3.46967280e-01f, 4.78368588e-02f, 8.16216916e-02f, -3.25820372e-02f,
  -2.65726354e-03f, -5.76190472e-01f, -1.15211949e-01f, 4.75895256e-01f, 1.35635674e-01f, -1.03578925e-01f, 1.63835689e-01f, 3.87996912e-01f, 6.50013313e-02f, 2.95138836e-01f,
  4.42697108e-01f, 9.63931531e-02f, 1.88268155e-01f, 2.20691621e-01f, 1.14772329e-03f, -1.29783107e-02f, -1.66410998e-01f, 3.32267672e-01f, 6.45492449e-02f, -2.97810882e-01f,
  2.36988813e-02f, -3.44441563e-01f, 1.73675567e-01f, 4.37986970e-01f, 3.14710647e-01f, 3.93157512e-01f, -8.26336667e-02f, 3.13411921e-01f, 4.87204999e-01f, -4.77607727e-01f,
  3.02389681e-01f, -2.66903460e-01f, -3.31945121e-01f, -6.56458735e-02f, -1.06124692e-01f, 3.94976526e-01f, -3.73665214e-01f, 4.89869937e-02f, 2.14187413e-01f, -1.64798051e-01f,
  -9.38179344e-02f, 1.24173976e-01f, 1.70042917e-01f, 1.39280846e-02f, 2.72339195e-01f, 4.41065058e-02f, -2.56725657e-03f, 3.21612149e-01f, 2.27110043e-01f, -4.52822214e-03f,
  -4.01578963e-01f, 1.02668768e-02f, 4.74801548e-02f, -6.84043825e-01f, -2.71187872e-01f, 4.33702797e-01f, 1.55991599e-01f, -1.34218082e-01f, 7.60778487e-02f, -1.07882962e-01f,
  2.61932373e-01f, -4.87111509e-02f, 5.59989154e-01f, 1.96772963e-01f, -3.03637415e-01f, -2.82607138e-01f, 1.74371883e-01f, -7.73261264e-02f, 3.40062410e-01f, 3.43933046e-01f,
  -1.47415295e-01f, -1.07208878e-01f, -2.02995669e-02f, -3.10917199e-03f, 1.57086536e-01f, -3.40861201e-01f, 3.34099084e-02f, 2.27779262e-02f, 8.12400952e-02f, 5.46779251e-03f,
  1.61205724e-01f, 1.79842874e-01f, 7.80772045e-02f, 5.98137565e-02f, -5.09035051e-01f, -3.10297191e-01f, -3.79970491e-01f, 1.58187319e-02f, -4.36239950e-02f, -3.47393788e-02f,
  3.36759806e-01f, -2.62295574e-01f, 6.79948568e-01f, 5.48287816e-02f, 3.02380621e-01f, 1.90963268e-01f, -4.17329639e-01f, -2.10908204e-02f, -9.32239369e-02f, 4.75275546e-01f,
  -4.82667565e-01f, 2.49744818e-01f, 3.31263602e-01f, -3.67743373e-01f, -4.58294004e-01f, -1.85933605e-01f, -4.17045131e-02f, 1.96005926e-01f, 1.50666058e-01f, -9.90907177e-02f,
  -1.37252122e-01f, 2.99461514e-01f, 2.54538208e-01f, 3.75630170e-01f, 4.06781107e-01f, 6.68014884e-02f, 2.76661158e-01f, 3.38866897e-02f, 3.77163112e-01f, -3.45282048e-01f,
  2.73162633e-01f, 3.10422629e-01f, 1.47194505e-01f, 1.00540817e-02f, 4.84545827e-01f, -3.18732023e-01f, -4.37706441e-01f, -1.14407413e-01f, 2.29964957e-01f, -5.37647307e-01f,
  -3.21621984e-01f, 2.79936582e-01f, -2.95945853e-02f, 1.94675326e-01f, -1.54460356e-01f, 4.36228933e-03f, 1.42854422e-01f, 1.81870714e-01f, 3.10008287e-01f, -2.10245371e-01f,
  4.68218952e-01f, 5.70245922e-01f, 2.90316850e-01f, -2.81559706e-01f, 2.18201801e-02f, -1.58581704e-01f, -4.21106309e-01f, -2.27103427e-01f, 1.17664151e-01f, -3.57147664e-01f,
  -4.62690853e-02f, 2.09373552e-02f, 3.15088779e-02f, 1.62399840e-02f, 1.10892422e-01f, -1.42927781e-01f, -1.81638733e-01f, 4.66943383e-01f, 6.74204946e-01f, -5.83806932e-02f,
  2.75871456e-01f, -1.73678905e-01f, 4.98740822e-02f, 9.83467028e-02f, -4.01232272e-01f, 5.49451541e-03f, 2.86546256e-02f, -5.21260053e-02f, 8.21641088e-02f, -2.35391408e-01f,
  2.35818386e-01f, -1.62399441e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 26)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 26;
const float L1_fan_Bp_bar_data[] = {
  2.85480112e-01f, 3.20738405e-01f, 4.88411970e-02f, -3.68099250e-02f, 2.14688629e-01f, 3.75624299e-01f, 6.44704625e-02f, 1.24106370e-01f, 2.96821654e-01f, 7.62853399e-02f,
  2.03344941e-01f, 1.60075605e-01f, -1.26879036e-01f, 1.25672579e-01f, 1.99638307e-01f, 1.91150948e-01f, 3.04707199e-01f, -1.73152164e-01f, 3.85195911e-01f, 1.10068716e-01f,
  4.29626077e-01f, 1.44081205e-01f, 2.40954638e-01f, 1.69579491e-01f, 1.82743326e-01f, 3.80869597e-01f
};

// L2_fan_Wp (Shape: 3 x 32)
const int L2_fan_Wp_rows = 3;
const int L2_fan_Wp_cols = 32;
const float L2_fan_Wp_data[] = {
  2.75068637e-02f, 5.32897897e-02f, -1.52570397e-01f, 4.57298338e-01f, 3.95210922e-01f, -7.93735981e-02f, -1.63004145e-01f, 1.60827979e-01f, -3.57348830e-01f, -3.19412827e-01f,
  -1.77979186e-01f, 2.25709409e-01f, -1.31865507e-02f, -9.86245349e-02f, -1.41980380e-01f, 5.02302274e-02f, 2.35765636e-01f, -8.18416402e-02f, -1.12267453e-02f, -7.89560229e-02f,
  -1.02832630e-01f, 1.04125433e-01f, 1.70851022e-01f, -2.95697320e-02f, 2.55717874e-01f, -1.00245021e-01f, 4.57307361e-02f, 1.64270431e-01f, 8.22129771e-02f, 2.50442196e-02f,
  -2.06416532e-01f, 4.29029353e-02f, -1.73725516e-01f, -4.69851680e-02f, 9.46936607e-02f, -2.25016162e-01f, 1.74491838e-01f, -2.71680593e-01f, 3.07976305e-01f, -1.89690478e-02f,
  -7.01482873e-03f, -4.88187708e-02f, 1.27778873e-01f, 2.48550754e-02f, -3.78488912e-03f, 2.47495592e-01f, -1.56578705e-01f, -8.67785215e-02f, 1.86676383e-01f, -2.63885334e-02f,
  -2.93774515e-01f, -1.33592844e-01f, -2.63796866e-01f, 2.05547541e-01f, 1.18604206e-01f, -1.44022882e-01f, 3.71065915e-01f, -1.27201661e-01f, -4.76205759e-02f, 1.12751305e-01f,
  4.10746560e-02f, -4.15380560e-02f, -2.12061822e-01f, 3.69752124e-02f, -1.32194489e-01f, 1.34204715e-01f, -2.25028753e-01f, -3.25108529e-03f, 1.39368638e-01f, -1.04775108e-01f,
  8.76448005e-02f, 1.25469014e-01f, -1.65309608e-01f, -2.87359267e-01f, 2.15078533e-01f, -2.56494969e-01f, -1.09769978e-01f, 1.38710633e-01f, 6.50887489e-02f, -3.98362838e-02f,
  3.93388383e-02f, 4.92938608e-02f, 2.47450888e-01f, 2.05351815e-01f, -1.27730742e-01f, 5.63280694e-02f, -9.46725905e-02f, -5.31484820e-02f, -3.00612509e-01f, 2.34575167e-01f,
  -8.19856972e-02f, 7.14276507e-02f, 1.83447540e-01f, -3.89834233e-02f, -1.71190068e-01f, -2.25883991e-01f
};

// L2_fan_Wp_bar (Shape: 26 x 32)
const int L2_fan_Wp_bar_rows = 26;
const int L2_fan_Wp_bar_cols = 32;
const float L2_fan_Wp_bar_data[] = {
  7.54431263e-02f, 1.86357066e-01f, 1.11078575e-01f, 2.66490906e-01f, 3.14148813e-01f, 3.80611718e-01f, -1.90510377e-01f, 1.34070814e-01f, 2.57828504e-01f, 1.42241001e-01f,
  -1.07324481e-01f, 1.40108868e-01f, 2.95198441e-01f, -3.54556024e-01f, 2.94746250e-01f, 1.61400020e-01f, -6.10391349e-02f, -1.06027395e-01f, 1.89292450e-02f, 2.27849603e-01f,
  5.67689121e-01f, -9.65337157e-02f, -3.46168399e-01f, -1.82477027e-01f, -4.60248947e-01f, 2.19257679e-02f, -1.09611653e-01f, 3.02505165e-01f, 1.93932399e-01f, 2.76547819e-01f,
  -5.39381914e-02f, -9.39531922e-02f, -1.29095288e-02f, 2.69624501e-01f, -2.54037499e-01f, -3.37113976e-01f, 8.97340477e-02f, 4.10206348e-01f, -4.67818556e-03f, 2.25911871e-01f,
  2.36895248e-01f, -4.69775163e-02f, 2.44226053e-01f, -3.29497367e-01f, -1.80289418e-01f, 1.58535421e-01f, 1.67458385e-01f, -2.05529749e-01f, -2.04655319e-01f, -3.61599177e-01f,
  -3.34445059e-01f, -1.41925355e-02f, 2.29161218e-01f, 1.87011547e-02f, 2.10407414e-02f, -2.14155182e-01f, 1.01228200e-01f, 6.72734678e-02f, 1.40589669e-01f, 2.90220324e-02f,
  4.36205178e-01f, 2.62883842e-01f, 2.92455107e-01f, -1.70567527e-01f, 1.62728190e-01f, 3.78213614e-01f, -1.15895800e-01f, -1.55579180e-01f, -1.31039858e-01f, 7.46938437e-02f,
  1.17571339e-01f, 1.90843925e-01f, 7.99474642e-02f, -1.88093577e-02f, 3.37032676e-01f, -3.32863569e-01f, -4.09699291e-01f, 2.48431325e-01f, 5.10904044e-02f, 1.26946285e-01f,
  1.48130178e-01f, -1.14545666e-01f, -3.31947297e-01f, -1.76849887e-01f, 1.23999380e-01f, -1.48175778e-02f, 1.38942167e-01f, -1.01149887e-01f, -4.88833845e-01f, 3.59260052e-01f,
  1.73272908e-01f, -5.87971732e-02f, 4.83306736e-01f, -9.79689807e-02f, 2.03429535e-01f, 6.79350644e-02f, 3.41447800e-01f, 1.01897478e-01f, 2.63880700e-01f, 1.84616342e-01f,
  3.86704892e-01f, -3.14922839e-01f, -1.62187368e-01f, 3.98346812e-01f, 1.32080674e-01f, -2.58143991e-01f, -2.47126788e-01f, 7.49072671e-01f, 1.01647474e-01f, -1.21995369e-02f,
  -3.71631205e-01f, 3.90947670e-01f, 2.53931880e-01f, 4.02266458e-02f, 5.37334718e-02f, 3.19363952e-01f, 1.82170630e-01f, 5.65079510e-01f, 2.46582389e-01f, 1.53944179e-01f,
  6.47467852e-01f, 9.47614908e-02f, 1.85570091e-01f, -7.22557604e-02f, 2.90939093e-01f, 7.41508827e-02f, -1.53208211e-01f, 7.37511277e-01f, 7.75452375e-01f, 7.58324470e-03f,
  -3.20148021e-01f, -2.28629485e-01f, -2.10855037e-01f, -7.29842961e-01f, 4.65280920e-01f, 2.05316752e-01f, -3.71793181e-01f, -3.84510219e-01f, 2.44504750e-01f, -7.47483298e-02f,
  -3.73901008e-03f, 3.06797594e-01f, 4.18056071e-01f, 3.26435417e-02f, 3.47604305e-01f, 7.06441626e-02f, -5.67923039e-02f, 2.48137325e-01f, -3.75099093e-01f, -1.06182555e-02f,
  1.50284335e-01f, -1.23151302e-01f, -9.32098264e-05f, -4.65218760e-02f, 2.13824674e-01f, 5.89987151e-02f, 2.43174303e-02f, -2.97402978e-01f, 6.56974614e-02f, 2.58810401e-01f,
  -3.02166432e-01f, 2.69036572e-02f, 4.41749185e-01f, 6.63906157e-01f, 1.48256242e-01f, -3.30842614e-01f, -5.15337214e-02f, 1.96720302e-01f, -3.16158921e-01f, -4.82616127e-01f,
  -1.61430612e-01f, 3.98398697e-01f, 1.61057368e-01f, -5.15662273e-03f, 2.74230391e-01f, -2.37367436e-01f, 1.96684554e-01f, 2.80162126e-01f, 1.21573873e-01f, -8.45303535e-02f,
  -9.90115404e-02f, 2.89339095e-01f, -9.30903703e-02f, 2.51079351e-01f, 4.85298894e-02f, -4.45534885e-02f, -5.31654991e-02f, 3.28505695e-01f, -5.39552629e-01f, 1.01854473e-01f,
  2.88426820e-02f, 3.91722545e-02f, -4.36900169e-01f, -6.13063909e-02f, -8.43791068e-02f, -1.60585672e-01f, 2.60550469e-01f, 3.30439866e-01f, 9.98055562e-02f, -1.04329996e-01f,
  8.02763477e-02f, -2.36901447e-01f, 1.85090870e-01f, -2.69903373e-02f, -2.17399240e-01f, 1.84841603e-01f, -1.56228095e-01f, 1.66829437e-01f, 2.72632003e-01f, 4.20496613e-02f,
  -1.13671817e-01f, -1.91508189e-01f, 2.76032416e-03f, 3.84545445e-01f, -1.08536571e-01f, 1.38448283e-01f, 1.49322316e-01f, -1.32674158e-01f, 1.86166108e-01f, -1.36188781e-02f,
  1.74295783e-01f, 9.63200107e-02f, -5.55864386e-02f, -6.96279556e-02f, 1.04038015e-01f, -1.23666674e-01f, 4.23514038e-01f, -4.37254161e-02f, -3.59375477e-01f, 1.67322278e-01f,
  1.24625541e-01f, 6.52595609e-02f, 7.20599055e-01f, 1.47782579e-01f, 1.55960694e-01f, 4.38926108e-02f, 3.21421146e-01f, 3.23848389e-02f, 3.93463135e-01f, 3.02375525e-01f,
  -1.20073482e-01f, 2.73898020e-02f, -1.12876259e-01f, -3.42174381e-01f, 7.03527555e-02f, -2.78363943e-01f, 4.33165312e-01f, -4.72028643e-01f, -3.86503264e-02f, 3.28557909e-01f,
  2.64035434e-01f, 4.11343098e-01f, -5.94644211e-02f, -1.51713163e-01f, -1.73917279e-01f, 2.70813644e-01f, 3.50074828e-01f, 2.64669925e-01f, -8.30915719e-02f, -6.58577502e-01f,
  -1.60292089e-01f, 3.26596946e-01f, 4.59529847e-01f, -1.19246259e-01f, 2.85865784e-01f, -1.16377927e-01f, -4.89301980e-02f, 1.05399579e-01f, -2.17861503e-01f, 2.07438141e-01f,
  -2.02716053e-01f, -4.33701575e-02f, 3.32137406e-01f, 2.71606743e-01f, -2.92628407e-01f, -2.88111359e-01f, 2.15658486e-01f, 1.21700540e-01f, 2.75943667e-01f, 2.33270720e-01f,
  1.79892946e-02f, 2.37556789e-02f, 2.63885677e-01f, 3.45574468e-01f, 1.82763278e-01f, 2.33644977e-01f, 4.43263948e-01f, 7.37175941e-02f, -3.63785148e-01f, -2.09977195e-01f,
  2.85730034e-01f, -1.11680940e-01f, 4.29698884e-01f, -2.71886915e-01f, -2.73278914e-02f, 4.15742621e-02f, 1.34738743e-01f, -2.11471990e-01f, 6.32111013e-01f, -2.11268857e-01f,
  1.92451671e-01f, 4.42084283e-01f, 2.09488925e-02f, -2.59447783e-01f, -7.73482546e-02f, 3.19427669e-01f, 3.46934907e-02f, 2.18995079e-01f, 2.61790790e-02f, 4.93595868e-01f,
  -2.11261019e-01f, 2.83904970e-01f, -2.80165941e-01f, 3.01210940e-01f, 1.20729983e-01f, 1.02996759e-01f, -1.06448486e-01f, -3.48302990e-01f, 8.66176412e-02f, -3.11652243e-01f,
  7.00584725e-02f, 1.05584621e-01f, 1.91136882e-01f, -3.55132855e-02f, -1.66272119e-01f, -2.16288671e-01f, 6.26967698e-02f, -1.15709163e-01f, 2.49309257e-01f, 9.45496187e-02f,
  -6.65562153e-02f, 2.39104673e-01f, 3.78804207e-01f, -3.16588245e-02f, -7.34346956e-02f, 8.93641710e-02f, 4.45233956e-02f, 2.05870822e-01f, 2.43227258e-01f, 1.24053299e-01f,
  1.02506705e-01f, -2.24394038e-01f, -2.82071710e-01f, 1.74268380e-01f, 3.32025796e-01f, -4.12806541e-01f, 2.47692689e-01f, 1.51623022e-02f, -4.96658504e-01f, 1.70540646e-01f,
  2.47068062e-01f, 6.23695105e-02f, -1.14863619e-01f, -2.71637112e-01f, 3.90990302e-02f, -8.14465955e-02f, 1.12697475e-01f, 3.38713288e-01f, -8.46605748e-02f, -2.19737023e-01f,
  2.78477401e-01f, 1.18892610e-01f, 3.47160876e-01f, -1.86971024e-01f, 2.40732938e-01f, 3.15192752e-02f, 8.29989091e-03f, -4.36446458e-01f, -5.53703383e-02f, -1.19508274e-01f,
  2.25404233e-01f, 1.36951148e-03f, 3.45979095e-01f, 1.56684995e-01f, -2.25208253e-01f, 2.63465524e-01f, -2.08703533e-01f, 2.74649650e-01f, 3.27039242e-01f, 2.52420250e-02f,
  -2.40431100e-01f, 2.70707428e-01f, 4.20681238e-01f, -6.29016459e-01f, 2.36902565e-01f, 4.27846611e-01f, 3.80734295e-01f, -1.27314806e-01f, -3.87083702e-02f, -3.72903466e-01f,
  -1.25405028e-01f, 4.59448062e-02f, 1.38059810e-01f, 1.48732215e-01f, -2.91817654e-02f, -4.79309782e-02f, 2.71703660e-01f, -8.25208873e-02f, -6.89789206e-02f, 2.66254425e-01f,
  -3.64945412e-01f, -1.48107946e-01f, -2.94938684e-01f, 2.82786667e-01f, 2.52403349e-01f, 1.03219800e-01f, -3.79746765e-01f, -2.14314535e-01f, 1.57240331e-01f, 3.71991396e-02f,
  3.84313636e-04f, -6.35065675e-01f, 1.60212949e-01f, -1.34087339e-01f, -1.35197937e-01f, 3.92529219e-01f, 5.32099187e-01f, 4.72217411e-01f, 2.49887094e-01f, 1.42321333e-01f,
  -5.21828413e-01f, -3.92805010e-01f, 2.55947918e-01f, -1.42409012e-01f, -3.02058935e-01f, -5.41929305e-01f, -2.14240938e-01f, 1.96278602e-01f, 1.61932155e-01f, -8.13507661e-02f,
  2.47692078e-01f, 4.80489023e-02f, 3.16990733e-01f, 3.77295077e-01f, -1.23039342e-01f, -3.19986753e-02f, 1.26445532e-01f, -4.66845006e-01f, 1.62545174e-01f, 6.46295771e-02f,
  2.11956084e-01f, -5.09480774e-01f, 2.82874882e-01f, 5.04468381e-01f, 2.64832914e-01f, -2.80560285e-01f, 2.11835742e-01f, 3.19850564e-01f, 4.60296273e-01f, 1.62116289e-01f,
  3.73283535e-01f, 4.77828860e-01f, -2.00398460e-01f, -6.52010500e-01f, -5.68242520e-02f, 1.71135917e-01f, -7.79710859e-02f, -3.05322260e-01f, -1.55342981e-01f, 4.25791711e-01f,
  2.73894519e-01f, -9.96911526e-02f, 1.87510461e-01f, 1.23737901e-01f, -1.70376524e-01f, 2.27860674e-01f, 2.28730053e-01f, 1.39208674e-01f, -5.89900017e-02f, 1.01182289e-01f,
  -1.97430059e-01f, 4.50726412e-02f, 6.29414544e-02f, -2.06601381e-01f, -1.00391187e-01f, 2.17138715e-02f, -2.06424788e-01f, -3.08564126e-01f, 1.68663636e-01f, 2.69546926e-01f,
  -1.54379457e-01f, -1.53450370e-02f, -8.90192911e-02f, 2.84407884e-01f, 4.37445432e-01f, 2.43703648e-01f, -4.36610550e-01f, 1.27322584e-01f, 3.72982532e-01f, -2.75515854e-01f,
  -2.78169364e-01f, -1.29440743e-02f, 4.37659085e-01f, -2.65336961e-01f, 4.67333138e-01f, 1.75708041e-01f, -1.30083561e-01f, 5.13560921e-02f, 1.51431262e-01f, 8.28851610e-02f,
  3.82851362e-01f, 3.58499661e-02f, -3.14210922e-01f, -1.21303484e-01f, 6.40650541e-02f, 7.23580047e-02f, -3.74045491e-01f, 2.23083999e-02f, 3.33139002e-01f, -1.16990127e-01f,
  -4.91089135e-01f, -4.21852432e-02f, 2.76908785e-01f, 9.12680328e-02f, -3.85586083e-01f, -2.38270402e-01f, 3.25072706e-01f, 2.90057287e-02f, 5.37037440e-02f, -1.37007460e-02f,
  -5.51244497e-01f, -2.36003753e-02f, 2.07373679e-01f, 1.37285203e-01f, 1.29980505e-01f, 2.33510956e-01f, 2.58321911e-02f, -7.21919090e-02f, 3.80735457e-01f, 1.63834542e-01f,
  2.48026639e-01f, 3.20483267e-01f, -1.89063981e-01f, -2.60181218e-01f, 8.79645646e-02f, 3.41042250e-01f, -3.73118781e-02f, -1.33584127e-01f, 1.42271463e-02f, 2.10198432e-01f,
  1.01371236e-01f, -1.51062354e-01f, 4.34650034e-01f, -2.69646734e-01f, -1.31541362e-03f, 1.83640391e-01f, 2.26049319e-01f, -4.49735165e-01f, -3.81544530e-02f, -2.27158010e-01f,
  -1.09593660e-01f, 2.25649461e-01f, -9.62490886e-02f, -3.96602839e-01f, 6.70061633e-02f, -9.08543393e-02f, 1.32511789e-03f, 2.00466573e-01f, -2.28179216e-01f, -1.47884116e-01f,
  -9.49318558e-02f, -2.44644899e-02f, -1.58288255e-01f, 1.39351383e-01f, 3.37076455e-01f, 2.65881926e-01f, -3.82843614e-01f, -8.63528773e-02f, -2.39999220e-01f, -8.20186883e-02f,
  9.81927812e-02f, -2.79400080e-01f, 2.95960754e-01f, -3.59701097e-01f, 5.57077006e-02f, -1.14669740e-01f, 2.34314814e-01f, 6.55651093e-02f, -1.66847482e-01f, 2.17291772e-01f,
  2.40634263e-01f, -1.99354097e-01f, 8.70173499e-02f, 1.55906752e-01f, -5.62169433e-01f, 1.85214385e-01f, 2.52717555e-01f, 2.32812718e-01f, 2.46323511e-01f, 1.90902412e-01f,
  5.12743033e-02f, -1.11421533e-01f, 1.68142430e-02f, -8.93706977e-02f, 3.00116688e-01f, 1.53984472e-01f, 7.49683827e-02f, -8.37376416e-02f, -3.48578691e-01f, 1.92840979e-01f,
  -2.15255216e-01f, 1.07519746e-01f, 3.13260198e-01f, -7.30686486e-02f, 2.81610433e-02f, 2.80584216e-01f, 3.42606336e-01f, -4.27678883e-01f, 5.14962375e-01f, 2.47609466e-01f,
  -3.76913100e-01f, -2.69100100e-01f, -2.08294868e-01f, 1.76537156e-01f, 1.51205197e-01f, 2.68581927e-01f, -3.35562199e-01f, -1.62520245e-01f, -3.61300677e-01f, 3.04223210e-01f,
  -1.85126200e-01f, 6.37858128e-03f, -1.47747815e-01f, 9.68201458e-02f, 3.68770152e-01f, -2.76596785e-01f, -1.66876212e-01f, -6.25865087e-02f, -1.18359193e-01f, 3.54953557e-01f,
  2.86286533e-01f, -2.63164252e-01f, 5.57894289e-01f, 4.06506173e-02f, 1.01478305e-02f, 1.77658379e-01f, 5.91186106e-01f, 2.73653060e-01f, 9.68703404e-02f, 5.04553914e-01f,
  5.31586885e-01f, 3.45138222e-01f, 3.60414803e-01f, 2.54415482e-01f, -6.28260821e-02f, -7.42703319e-01f, 1.20468132e-01f, 7.86275566e-02f, 5.22182941e-01f, 5.73082641e-02f,
  2.86560923e-01f, 2.64579803e-01f, 2.40245029e-01f, -8.42550676e-03f, 7.29760528e-02f, 1.90136880e-01f, -1.61172196e-01f, 7.78322443e-02f, -2.08378404e-01f, 6.63245320e-02f,
  -2.12560922e-01f, 2.26119943e-02f, 2.12035015e-01f, -3.30867320e-01f, 1.90836266e-01f, 2.50981688e-01f, 2.15420663e-01f, -2.02660814e-01f, -1.36930257e-01f, -5.35580099e-01f,
  -6.64628744e-02f, 2.71687508e-01f, -4.02897805e-01f, 2.08691340e-02f, -2.57558256e-01f, 4.67948228e-01f, 3.67536657e-02f, 4.62428004e-01f, -2.92091370e-01f, 1.71809390e-01f,
  -2.14095041e-01f, -1.07571281e-01f, -1.41417846e-01f, 3.07742953e-01f, 2.40333751e-01f, -2.45426595e-01f, 1.81725565e-02f, -1.24117166e-01f, 1.10471651e-01f, 3.31898689e-01f,
  2.46504351e-01f, 2.57139742e-01f, 1.70523793e-01f, 1.70681491e-01f, -1.52965888e-01f, 2.12729722e-01f, 9.18503702e-02f, 2.73547232e-01f, 2.57554173e-01f, -2.05823690e-01f,
  2.62970179e-01f, 3.74008983e-01f, 6.89092055e-02f, -3.87846321e-01f, 2.62637772e-02f, 1.08970590e-01f, 2.38831505e-01f, -2.36406416e-01f, 2.54370213e-01f, -1.35490179e-01f,
  -3.19549978e-01f, 1.24227963e-01f, -1.60556898e-01f, -5.33754826e-01f, 1.12295732e-01f, 2.52388790e-02f, -1.83225367e-02f, 1.43292263e-01f, -2.12690141e-02f, 2.02547722e-02f,
  -2.40919162e-02f, -2.20538557e-01f, -4.22221810e-01f, 7.96163157e-02f, 2.47524440e-01f, 4.19537365e-01f, 4.46017757e-02f, -2.40849182e-02f, 2.57973280e-02f, -2.04054336e-03f,
  -8.59688818e-02f, -3.72872293e-01f, 3.37200165e-01f, 7.89896995e-02f, -2.21706212e-01f, 2.99681515e-01f, -2.00409591e-01f, -2.66469777e-01f, 1.77949846e-01f, -4.57435288e-02f,
  -6.89807814e-03f, 4.54324871e-01f, 2.63690323e-01f, -2.90290505e-01f, 3.74395788e-01f, -4.83825803e-02f, 4.26534832e-01f, 3.87714468e-02f, -1.43489912e-01f, 2.85229802e-01f,
  2.67780691e-01f, -2.76623726e-01f, -2.84804069e-02f, 2.46480592e-02f, -7.54604936e-02f, -6.34212196e-01f, 1.38412863e-01f, 2.24034473e-01f, -5.49307540e-02f, 8.26688483e-02f,
  -2.75873989e-01f, 2.49730365e-04f, 4.09025043e-01f, 5.47061741e-01f, 7.23488480e-02f, 8.62448588e-02f, 1.89827532e-01f, 4.41815034e-02f, 9.89493579e-02f, 8.30185860e-02f,
  -2.20265716e-01f, -1.87610924e-01f, 5.77780157e-02f, 2.62467209e-02f, 3.07514191e-01f, -1.69372067e-01f, -2.12838516e-01f, -3.86110321e-02f, 1.17522560e-01f, -1.66661173e-01f,
  -4.50631917e-01f, 2.01881677e-01f, 3.74710299e-02f, -1.96096793e-01f, -2.35218942e-01f, -3.68153825e-02f, -1.66866422e-01f, -3.17769885e-01f, 1.68614134e-01f, -2.27570329e-02f,
  -1.73997223e-01f, -1.82306999e-03f, -7.25383461e-02f, -1.18976384e-01f, 3.45208049e-01f, 3.48949939e-01f, 4.21611071e-01f, 1.04232682e-02f, 2.98868597e-01f, -1.04392111e-01f,
  -8.08874071e-01f, -2.06215739e-01f, 2.49952659e-01f, 2.33107165e-01f, 2.15436950e-01f, -2.28357930e-02f, -3.46285313e-01f, -1.10803008e-01f, 4.15923625e-01f, -8.28447659e-03f,
  5.96418530e-02f, 2.15341404e-01f, 1.95871174e-01f, 2.56238878e-02f, -1.26463518e-01f, -2.07897909e-02f, 1.15787514e-01f, 2.86224067e-01f, 2.33477086e-01f, -3.69836986e-02f,
  -1.46563902e-01f, 3.77296180e-01f, -6.91725984e-02f, 3.47130418e-01f, 1.52205691e-01f, 2.72920907e-01f, 2.92220078e-02f, 5.81198409e-02f, -5.36696136e-01f, -2.88677573e-01f,
  1.09856173e-01f, 4.22788002e-02f
};

// L2_fan_Bp_bar (Shape: 1 x 26)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 26;
const float L2_fan_Bp_bar_data[] = {
  2.55548030e-01f, 1.97994679e-01f, 2.62044311e-01f, 1.63660854e-01f, 1.41151518e-01f, 5.60714304e-02f, -1.28178045e-01f, 2.90246755e-01f, 2.42244214e-01f, -4.37946729e-02f,
  2.50999779e-01f, 1.73095614e-01f, 2.43754283e-01f, 3.58664662e-01f, 1.34466439e-01f, 8.51969719e-02f, -1.02646556e-02f, 2.19534919e-01f, -8.23652372e-03f, 1.30810231e-01f,
  1.72631353e-01f, 1.07937828e-01f, -2.83296239e-02f, 8.22671950e-02f, 8.36498067e-02f, -5.84622249e-02f
};

// L3_linear_W (Shape: 12 x 32)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 32;
const float L3_linear_W_data[] = {
  -4.18815285e-01f, -2.94502050e-01f, -1.14696927e-01f, -3.48817967e-02f, 1.32584587e-01f, -1.12751022e-01f, -6.10604048e-01f, -4.66933966e-01f, -1.85978279e-01f, -2.12722883e-01f,
  9.59669948e-02f, 1.95294023e-01f, 2.15325639e-01f, -4.39815432e-01f, 1.25311881e-01f, 3.78913969e-01f, 3.46725792e-01f, 2.24098042e-01f, -4.93314385e-01f, 1.13510508e-02f,
  9.92045626e-02f, -2.42804870e-01f, 1.96702018e-01f, -1.43872257e-02f, 7.84857422e-02f, -2.36299500e-01f, -2.81854182e-01f, -3.57591398e-02f, 2.49208994e-02f, 2.41828755e-01f,
  1.44186663e-02f, 3.05187792e-01f, -3.53306293e-01f, -8.99422243e-02f, 2.96119332e-01f, 2.12677151e-01f, -4.49357361e-01f, 3.12559962e-01f, 1.91421136e-01f, -3.27265948e-01f,
  -8.30539465e-02f, 7.96753094e-02f, -9.23608318e-02f, 3.66263002e-01f, -1.33495867e-01f, -3.21790546e-01f, -4.84656304e-01f, -1.72756817e-02f, -3.66994995e-04f, -6.65057003e-02f,
  -1.84548631e-01f, -1.59362361e-01f, 1.39326602e-01f, 3.18861008e-01f, 1.60941780e-01f, -4.78989154e-01f, 3.14215481e-01f, -9.21068117e-02f, -9.82653648e-02f, 2.81939119e-01f,
  5.25520630e-02f, -3.30107749e-01f, -3.22792619e-01f, 1.39582157e-01f, -1.00551043e-02f, 8.73847604e-02f, 8.24765638e-02f, 1.19708180e-01f, 4.10517573e-01f, -1.82135031e-01f,
  -7.76630819e-01f, -4.84343618e-01f, 7.16368556e-02f, 2.78033227e-01f, 8.41176733e-02f, 2.41566673e-01f, -2.03721836e-01f, 1.36122569e-01f, -1.60173401e-01f, 2.35346645e-01f,
  -4.44982886e-01f, -2.68174261e-01f, -1.26694590e-01f, -8.52502644e-01f, 2.24364758e-01f, -2.54688144e-01f, -4.46700156e-01f, -1.81073695e-01f, -3.16458583e-01f, -2.10883934e-02f,
  4.61058140e-01f, -2.31432527e-01f, 5.64288795e-02f, -6.97258413e-02f, -3.54404598e-01f, 2.84785837e-01f, -2.13594645e-01f, 1.81449938e-03f, -3.82644027e-01f, 7.01301843e-02f,
  2.56990761e-01f, -1.77347258e-01f, -2.06358433e-01f, 2.64448464e-01f, 2.28283837e-01f, -8.41790199e-01f, 1.33748785e-01f, -4.19583738e-01f, -2.02681776e-02f, 1.98920354e-01f,
  -8.13036785e-02f, 2.23528504e-01f, -4.24339145e-01f, 2.04485804e-01f, -1.72527879e-01f, -2.01519102e-01f, -2.64754474e-01f, -1.87492043e-01f, 4.52534519e-02f, -2.37762675e-01f,
  2.28127703e-01f, -5.76831698e-01f, 2.17819661e-01f, -6.24357164e-01f, -4.51303095e-01f, 2.61566967e-01f, 1.57217875e-01f, -2.14662403e-01f, 3.40582401e-01f, -2.40626052e-01f,
  -1.63708523e-01f, -5.97901702e-01f, -3.48925024e-01f, 5.23435235e-01f, -2.29293600e-01f, -8.00377354e-02f, 2.33375028e-01f, -2.08050862e-01f, 2.60794044e-01f, -2.18720406e-01f,
  -5.11213206e-02f, -8.62495899e-02f, 1.89208016e-01f, -1.14907734e-01f, -3.16241533e-01f, -2.05738515e-01f, -3.43741365e-02f, 2.79512763e-01f, -1.74507760e-02f, -2.82894582e-01f,
  2.82574594e-01f, 3.46744388e-01f, 5.71509898e-02f, 2.80415684e-01f, -2.90689841e-02f, -1.30807877e-01f, -4.10788387e-01f, 8.50571766e-02f, 3.09472978e-01f, -1.76732481e-01f,
  4.76857007e-01f, 4.02525246e-01f, -1.10194139e-01f, 3.34663361e-01f, 4.84990358e-01f, -5.33833742e-01f, -1.27222985e-01f, -8.63294452e-02f, -4.14656907e-01f, 8.31373632e-02f,
  1.65519118e-01f, 1.11103162e-01f, -4.56016362e-01f, -3.60747650e-02f, 9.42180827e-02f, -5.53160071e-01f, 4.07906622e-01f, 1.49272069e-01f, 1.73457325e-01f, 4.33651447e-01f,
  3.48614514e-01f, -4.03858036e-01f, 1.02793075e-01f, -6.87737465e-02f, 1.98624030e-01f, 1.36488289e-01f, 3.21670383e-01f, -1.88305169e-01f, -3.28083903e-01f, -3.09527069e-01f,
  -3.86817634e-01f, -2.47595921e-01f, -3.69990975e-01f, 2.69315958e-01f, 1.14705943e-01f, 3.90464097e-01f, 1.89472839e-01f, -2.99287558e-01f, 7.92015865e-02f, 1.27162293e-01f,
  -7.40405917e-02f, 1.93409115e-01f, -1.83468759e-01f, -2.15660825e-01f, 1.83655575e-01f, -8.29471886e-01f, -5.85223027e-02f, -7.20648170e-01f, -2.04645276e-01f, -6.58265948e-01f,
  2.63251573e-01f, -1.05486609e-01f, -2.17421427e-01f, 1.15780205e-01f, -8.43481198e-02f, -1.61480099e-01f, -2.60082394e-01f, 3.62408578e-01f, -5.61067820e-01f, 9.79598984e-02f,
  2.80790359e-01f, -7.32367575e-01f, -1.07764058e-01f, -3.30271512e-01f, 1.24678560e-01f, 5.89656793e-02f, 1.27778530e-01f, -9.83930305e-02f, -4.66968924e-01f, -6.48824126e-03f,
  2.41849929e-01f, 2.45127112e-01f, 7.68552050e-02f, -3.36739928e-01f, -7.42095649e-01f, -1.69635937e-01f, -3.92264351e-02f, -7.68125877e-02f, 1.46356001e-01f, 3.05788182e-02f,
  -1.36402380e-02f, 4.43908602e-01f, -3.73342067e-01f, -3.37898046e-01f, -3.76823097e-01f, -3.09012145e-01f, -6.84173033e-02f, -3.25142927e-02f, 1.57175705e-01f, -1.74519151e-01f,
  -5.80451131e-01f, 1.94378033e-01f, -1.09053984e-01f, 3.09711903e-01f, 2.69642472e-01f, -5.83613813e-02f, 4.48433273e-02f, -1.44747406e-01f, -1.17106602e-01f, -3.15893352e-01f,
  -4.02938098e-01f, -2.83631802e-01f, 1.76772818e-01f, -1.57655448e-01f, -3.35443646e-01f, 1.02131121e-01f, -6.81274176e-01f, -5.03064990e-01f, -2.57532299e-01f, 3.36888105e-01f,
  -3.04304808e-01f, -3.08059931e-01f, 2.20620438e-01f, -2.56352752e-01f, 3.52146924e-01f, -5.45786321e-01f, 1.91060811e-01f, 3.30366731e-01f, -3.51720780e-01f, -2.23656893e-01f,
  -3.55436027e-01f, -3.41137052e-01f, 3.76125485e-01f, -6.83909655e-02f, -2.36814588e-01f, -2.30135098e-01f, -7.43599460e-02f, 2.78190911e-01f, 2.79489346e-02f, -1.76616430e-01f,
  -2.84259412e-02f, 3.87662113e-01f, 1.09004088e-01f, -3.32738429e-01f, 5.98475523e-03f, 7.86861256e-02f, 7.71644562e-02f, 1.27635449e-01f, -3.25321436e-01f, -5.36539732e-03f,
  3.71564329e-01f, 2.16487974e-01f, 3.47550720e-01f, -7.55494773e-01f, -9.60591063e-02f, -1.60563216e-01f, -5.18280506e-01f, 3.95333916e-02f, -4.62374151e-01f, -2.55379319e-01f,
  -5.12577832e-01f, -5.73932528e-01f, -5.46780169e-01f, 3.09277356e-01f, -3.57095808e-01f, -2.02185586e-01f, -5.53146936e-02f, 3.85590911e-01f, -2.44165957e-02f, -1.03212707e-01f,
  -1.07897416e-01f, 1.03768185e-01f, -3.94286327e-02f, -2.89942175e-01f, -4.51958552e-03f, 3.59460831e-01f, 1.81847528e-01f, -2.96531886e-01f, -3.56269330e-01f, -6.53225422e-01f,
  9.11572129e-02f, 3.85021776e-01f, -3.39876056e-01f, 5.14251530e-01f, -1.35215983e-01f, -5.82333431e-02f, 5.36089903e-03f, -2.85157591e-01f, -4.30316776e-01f, 3.57876241e-01f,
  2.59738535e-01f, 3.51290375e-01f, -3.53159249e-01f, -1.77037850e-01f, -4.26014543e-01f, -4.09814417e-01f, 7.59825408e-02f, -5.03172874e-01f, -9.20243785e-02f, 2.09888473e-01f,
  -2.43400797e-01f, -7.72122592e-02f, -8.39983821e-02f, -1.97562873e-01f, 7.86645859e-02f, -3.22645456e-01f, -3.43365788e-01f, 1.35511711e-01f, 1.54149070e-01f, 1.38011128e-01f,
  1.41145885e-01f, -5.16365021e-02f, -3.31006944e-01f, -4.41900641e-01f, -2.54717916e-01f, -2.03392744e-01f, -2.18262434e-01f, 4.01625812e-01f, -4.77270305e-01f, -1.20652884e-01f,
  3.49079102e-01f, -4.08611953e-01f, -8.01703259e-02f, 1.21367522e-01f, -4.57277715e-01f, 5.83872199e-01f, -7.88494647e-02f, -1.78553358e-01f, 1.36664525e-01f, -2.86427051e-01f,
  3.06895733e-01f, -4.11956400e-01f, -3.17704608e-03f, -4.42939132e-01f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  -8.66008550e-02f, -7.81512037e-02f, 2.10315790e-02f, -1.79065213e-01f, 2.46062428e-01f, 7.97996521e-02f, -1.31664723e-01f, -1.16257422e-01f, 1.46990016e-01f, 2.53458619e-01f,
  3.43235247e-02f, -8.54473263e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 3, 26
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 3, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        32, 3, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        32, 12
    );
    }
    