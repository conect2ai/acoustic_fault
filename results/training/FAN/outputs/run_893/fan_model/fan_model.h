/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 12 x 120)
const int L0_fan_Wp_rows = 12;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  2.75467724e-01f, -1.12657256e-01f, 2.70381896e-03f, 1.87621430e-01f, 7.93268383e-02f, 2.45093685e-02f, -2.12592095e-01f, -1.12736724e-01f, -7.93292094e-03f, -4.13266383e-02f,
  1.41247198e-01f, 1.60824493e-01f, 1.52823180e-01f, -2.09624674e-02f, -8.69476199e-02f, -3.31602007e-01f, -2.88297474e-01f, -7.92607814e-02f, 9.38704014e-02f, -8.99959058e-02f,
  -1.45299017e-01f, 2.72657373e-03f, -4.15542834e-02f, 6.83510974e-02f, 1.98329818e-02f, 6.01402968e-02f, 5.20658819e-03f, 3.27498838e-02f, 8.04342702e-02f, -1.41447678e-01f,
  1.10788465e-01f, 1.10091619e-01f, -5.14790379e-02f, 5.97415194e-02f, 8.68501440e-02f, -4.70246673e-02f, 1.16934754e-01f, -5.06922044e-02f, 9.17289555e-02f, -1.82381663e-02f,
  3.00126430e-02f, 2.04354636e-02f, 8.98483694e-02f, 2.61070188e-02f, -7.36178234e-02f, -2.99576931e-02f, 2.91771684e-02f, -6.30204845e-03f, -3.96057367e-02f, 2.66627762e-02f,
  -4.80954051e-02f, 1.08795032e-01f, 1.31749347e-01f, 2.15445757e-02f, -4.32314835e-02f, -4.03365633e-03f, 1.16736524e-01f, 1.10297583e-01f, -2.95245294e-02f, -1.37983844e-01f,
  -7.36787915e-02f, 5.18335029e-02f, -2.76799090e-02f, -5.07811643e-02f, 2.83144657e-02f, 3.56430039e-02f, 2.18384191e-02f, -6.78078011e-02f, 5.56714162e-02f, -7.21410010e-03f,
  3.01094516e-03f, -1.10868011e-02f, 2.87220366e-02f, -9.63367638e-04f, 2.87374519e-02f, -1.80158019e-02f, 4.92722094e-02f, -1.26547106e-02f, -1.45796984e-02f, -4.44899872e-02f,
  2.61770915e-02f, 5.34376763e-02f, 5.50485998e-02f, -2.64650341e-02f, -2.57988889e-02f, 1.33306785e-02f, -1.45847835e-02f, 2.05329116e-02f, -1.45370355e-02f, 1.44268312e-02f,
  7.86610227e-03f, 3.42224836e-02f, 1.68664046e-02f, -5.92516661e-02f, 4.75822873e-02f, -3.95272598e-02f, 4.13229093e-02f, -8.65594745e-02f, 9.64206364e-03f, -4.98198308e-02f,
  -4.98825014e-02f, 6.19608238e-02f, -8.44609290e-02f, -7.65366107e-02f, -8.55275150e-03f, 3.37176993e-02f, -9.92265493e-02f, 5.40973172e-02f, -8.40865001e-02f, 3.24820392e-02f,
  -4.83156368e-02f, -9.90626663e-02f, -4.59417759e-04f, -5.49832871e-03f, 5.75595014e-02f, 1.38731778e-01f, 6.20578267e-02f, -6.47373274e-02f, -1.98316928e-02f, -1.06808282e-01f,
  1.26089334e-01f, -1.50434822e-01f, 1.61370523e-02f, -1.04227448e-02f, -1.81094762e-02f, 3.96665838e-03f, -7.64885321e-02f, -7.86061808e-02f, 9.17366892e-02f, -2.93435510e-02f,
  -2.11555585e-01f, -1.31084040e-01f, 6.79636896e-02f, -4.07913588e-02f, 1.25692189e-01f, 3.18325125e-02f, 1.29085287e-01f, 1.57527938e-01f, 1.73927054e-01f, -9.47190635e-03f,
  1.16150570e-03f, 9.75915045e-02f, 1.65930182e-01f, -1.96941793e-02f, -5.70466109e-02f, -3.82446870e-02f, -1.81744918e-02f, 2.86174081e-02f, -5.10557406e-02f, 2.40331274e-02f,
  -1.44992217e-01f, -1.58500478e-01f, 2.85839178e-02f, -2.56040618e-02f, -1.22607924e-01f, 6.27472922e-02f, 2.34425534e-02f, 1.02938171e-02f, 5.72114773e-02f, 6.53921291e-02f,
  -1.19160429e-01f, -6.29971772e-02f, 5.06035164e-02f, -1.07211038e-01f, 7.46013224e-02f, -3.52548845e-02f, -7.68376514e-02f, 1.12840593e-01f, -2.73772068e-02f, -8.56809132e-03f,
  -8.03550426e-03f, -1.50657207e-01f, -4.09695394e-02f, 1.40305050e-03f, 6.06989255e-03f, 6.06441125e-03f, -1.57395974e-01f, -1.42279506e-01f, 6.83504622e-03f, 4.64773104e-02f,
  1.93072725e-02f, 3.85384001e-02f, -3.16067524e-02f, 6.39890730e-02f, 1.82678010e-02f, -4.63345833e-02f, 5.98655194e-02f, 5.34436069e-02f, 1.11461341e-01f, 6.39065877e-02f,
  -8.84663388e-02f, 3.32613848e-02f, -5.96506521e-03f, 7.77092129e-02f, 3.88816632e-02f, -7.83370584e-02f, -6.32915422e-02f, 4.64397259e-02f, -2.56960914e-02f, -1.26384208e-02f,
  -1.52656464e-02f, -7.23110363e-02f, -7.10332021e-03f, -3.40563711e-03f, -7.40721896e-02f, 5.07675670e-03f, -6.10965155e-02f, 5.96341975e-02f, -8.32730979e-02f, 1.62970219e-02f,
  1.28091231e-01f, -1.56744607e-02f, 1.80704650e-02f, 9.41959843e-02f, 6.69821538e-03f, -2.04510260e-02f, -2.82568540e-02f, -3.46066430e-02f, -8.36991817e-02f, 6.32724091e-02f,
  -3.49426009e-02f, 5.77526912e-02f, -8.50095078e-02f, 5.67616075e-02f, 3.25521193e-02f, 5.61585501e-02f, 8.44883267e-03f, -9.59396595e-04f, 7.18853101e-02f, -8.61328393e-02f,
  7.54870996e-02f, 1.19528010e-01f, 1.21777996e-01f, 5.30109368e-03f, -5.10057881e-02f, 1.04583882e-01f, 2.61758431e-03f, -6.28722310e-02f, 2.66746078e-02f, 1.98271975e-01f,
  4.66230690e-01f, 2.86660474e-02f, 4.11413088e-02f, 4.15840112e-02f, -4.51072492e-02f, 1.27500296e-01f, 1.01636924e-01f, 2.31132284e-01f, -6.16060272e-02f, -4.86288629e-02f,
  1.03492085e-02f, 8.64312500e-02f, 4.31604572e-02f, 1.36827245e-01f, 2.53874809e-01f, 5.36424518e-02f, -1.55973420e-01f, -2.80439407e-02f, 1.00841485e-01f, 1.03659600e-01f,
  -1.03905320e-01f, -6.69217333e-02f, 1.33775383e-01f, -4.83835749e-02f, -2.86086291e-01f, -5.69095127e-02f, -9.83525664e-02f, -8.16517323e-02f, -1.56067148e-01f, -2.74123281e-01f,
  -9.52181444e-02f, 7.35662803e-02f, 7.94152170e-03f, -2.15656981e-02f, -1.05045751e-01f, -2.12316727e-03f, 4.56389859e-02f, -4.49967831e-02f, -1.15881860e-02f, -7.05054589e-03f,
  -1.93337910e-02f, -5.27525395e-02f, -2.57590283e-02f, -5.40190414e-02f, 8.49532112e-02f, 7.63354003e-02f, -4.36364934e-02f, 7.77252987e-02f, 5.35329245e-02f, -6.74066991e-02f,
  -5.49270585e-02f, -4.97621149e-02f, 1.21689543e-01f, -2.53223581e-03f, 9.44699347e-02f, 2.51727290e-02f, -7.70149454e-02f, 2.18125638e-02f, 1.09449886e-02f, -9.16056111e-02f,
  -2.81436313e-02f, -1.23562813e-02f, 7.72789568e-02f, 1.98247973e-02f, 2.16765489e-04f, -1.36176813e-02f, -3.20757478e-02f, -5.03646508e-02f, 3.69791910e-02f, 1.70098082e-03f,
  6.16754964e-02f, -1.02314427e-02f, 2.42103897e-02f, -1.71620324e-02f, -4.55711186e-02f, -6.25923127e-02f, 3.93999107e-02f, -1.36567000e-02f, 3.57748978e-02f, -5.18249683e-02f,
  2.18936391e-02f, -2.25412976e-02f, -4.17824723e-02f, 2.80181151e-02f, 1.16760179e-03f, -3.18853110e-02f, -3.49353626e-02f, -4.21307655e-03f, -5.61329611e-02f, 4.33061123e-02f,
  7.88732395e-02f, 1.62214473e-01f, 6.33849204e-02f, 7.92399496e-02f, -6.30825907e-02f, -6.33411184e-02f, -3.44157368e-02f, 3.29051018e-02f, -2.49340367e-02f, 5.30112907e-02f,
  8.21548775e-02f, 8.90718326e-02f, 5.96029535e-02f, -2.11629942e-02f, -2.14481745e-02f, 1.76406559e-02f, 2.36531273e-02f, 2.92559434e-02f, 8.23775902e-02f, 3.16754468e-02f,
  -1.01588294e-02f, 3.86530347e-02f, 9.80214626e-02f, 1.10965647e-01f, 4.59352545e-02f, 8.28969404e-02f, 7.86838084e-02f, -4.92889918e-02f, 2.14633763e-01f, 1.78917766e-01f,
  -3.32776189e-01f, -2.73974627e-01f, 1.78831425e-02f, 7.13264570e-04f, -1.13915410e-02f, 4.08133259e-03f, -1.22887865e-01f, -1.06729530e-01f, 3.59616764e-02f, -9.88671109e-02f,
  6.53765425e-02f, 3.56496185e-01f, 2.02485725e-01f, 1.64112717e-01f, -1.40420441e-02f, -4.11219597e-02f, -6.54418543e-02f, 1.84091125e-02f, 1.75704554e-01f, 1.09234035e-01f,
  -1.50261205e-02f, 3.17569673e-02f, 2.92356852e-02f, 1.06468447e-01f, -3.66076566e-02f, 2.75927454e-01f, 1.60212826e-03f, 8.24918039e-03f, 6.20936081e-02f, 9.06220526e-02f,
  2.20937908e-01f, -1.95752144e-01f, 5.08125983e-02f, -1.32791445e-01f, 5.28515456e-03f, -8.09330717e-02f, 7.16743916e-02f, -5.59446681e-03f, -7.14483112e-02f, -1.15253441e-02f,
  6.95623830e-02f, -4.09210399e-02f, 7.44903013e-02f, -3.63016292e-03f, -7.50163272e-02f, -3.01817749e-02f, -4.51369062e-02f, -1.14220232e-01f, -1.09687306e-01f, 1.69747800e-03f,
  -4.36933525e-02f, 1.19871190e-02f, 5.80556802e-02f, -2.04525050e-02f, 6.31801132e-03f, 2.77168560e-03f, -6.75041154e-02f, 4.99762781e-02f, 1.25046764e-02f, -2.73606386e-02f,
  -5.55954017e-02f, 1.02945343e-01f, 1.79154389e-02f, 1.09010830e-03f, 1.15556992e-03f, 4.09853905e-02f, -5.10692643e-03f, 5.19589074e-02f, 6.39481172e-02f, -9.28179771e-02f,
  7.28287771e-02f, -8.75078980e-03f, 1.17442794e-02f, 4.46890481e-02f, 4.34205011e-02f, -5.17476909e-02f, -8.17719549e-02f, -2.65239738e-02f, 3.79014201e-02f, -1.61847621e-02f,
  1.39970547e-02f, -7.23163970e-03f, -1.79624930e-03f, -3.37740174e-03f, -7.06981421e-02f, 3.93346092e-03f, 6.62817359e-02f, 1.10986801e-02f, 3.86133082e-02f, -1.11895157e-02f,
  1.49796396e-01f, 1.75904669e-02f, -3.96729410e-02f, 8.64367262e-02f, -9.35687311e-03f, -1.56646091e-02f, 8.32726527e-03f, -1.06082730e-01f, -1.12511143e-02f, -6.12446740e-02f,
  4.69053313e-02f, 3.93755250e-02f, 5.48044667e-02f, 6.80828989e-02f, 7.01715872e-02f, -2.90063713e-02f, -4.10608724e-02f, 6.98023662e-02f, -5.43889403e-02f, -5.53242564e-02f,
  -4.30593230e-02f, 1.31982276e-02f, 5.14506251e-02f, -1.25028538e-02f, -6.36518141e-03f, 1.26242945e-02f, 1.19902857e-01f, 7.48858303e-02f, -2.15876494e-02f, -9.38882232e-02f,
  3.35277349e-01f, 5.63547388e-03f, 6.27438650e-02f, 3.59129965e-01f, 4.11450148e-01f, 5.46534918e-02f, 7.18694320e-03f, -4.46531875e-03f, 9.65768099e-03f, -4.83304262e-02f,
  -1.18116170e-01f, -6.25211969e-02f, -1.53978616e-01f, -6.46144450e-02f, -2.76405010e-02f, 6.09592386e-02f, 2.16176853e-01f, 1.70562357e-01f, 2.31766030e-01f, 1.64402872e-01f,
  2.72964358e-01f, 3.41758549e-01f, 3.02481174e-01f, 1.54962331e-01f, 1.33989811e-01f, 6.87267333e-02f, -6.32647276e-02f, 5.33054583e-02f, 8.70863795e-02f, 3.34765226e-01f,
  -1.12733625e-01f, 5.52011915e-02f, -1.16001498e-02f, 1.11506268e-01f, 5.82043603e-02f, -1.20197549e-01f, 4.80847992e-02f, 6.94547668e-02f, -1.42954541e-02f, -1.69668552e-02f,
  1.26443431e-01f, -1.21479839e-01f, -6.65980652e-02f, 3.34512219e-02f, -5.29194139e-02f, 8.57500508e-02f, 1.82506144e-02f, -2.64912024e-02f, -2.93351170e-02f, 4.53993166e-03f,
  6.10799268e-02f, 1.65085033e-01f, 6.69659078e-02f, -9.87469777e-02f, -7.02866241e-02f, 1.05222113e-01f, -7.97080547e-02f, 6.40674531e-02f, -1.40173897e-01f, -9.25246179e-02f,
  -3.36739309e-02f, -1.04478784e-01f, 2.19701901e-02f, 1.01614609e-01f, -3.62867862e-02f, 3.16362977e-02f, -6.89887791e-04f, -1.70377251e-02f, 3.23489606e-02f, 3.87840183e-03f,
  4.84606922e-02f, 2.46677194e-02f, -1.74712949e-02f, -1.97418407e-02f, -3.29282470e-02f, 7.82850832e-02f, 3.37824076e-02f, -5.52061759e-02f, -3.71721536e-02f, 2.14213841e-02f,
  4.74002212e-02f, -7.47333393e-02f, -1.37146590e-02f, -3.90590094e-02f, -2.63776779e-02f, 8.12114868e-03f, -2.64133103e-02f, 6.94167241e-02f, -6.56325519e-02f, 6.96840584e-02f,
  -8.81011710e-02f, -6.30299281e-03f, -3.17339529e-03f, -4.18807082e-02f, 3.54857137e-03f, -1.26783475e-01f, -1.50002912e-02f, -6.53114766e-02f, 7.00462162e-02f, 2.83347163e-02f,
  -3.62359569e-04f, -5.04899919e-02f, -1.99102536e-02f, -2.48639248e-02f, 8.62733349e-02f, 1.95375588e-02f, -8.92510489e-02f, 7.06383735e-02f, -4.16141842e-03f, -4.82874960e-02f,
  -6.64985031e-02f, 6.63884431e-02f, 8.64037406e-03f, -5.94718680e-02f, 3.51376657e-04f, 8.21599588e-02f, 7.79015245e-03f, -3.59707922e-02f, -2.78337393e-02f, -1.11940816e-01f,
  2.36747712e-01f, 1.30800590e-01f, 1.64856002e-01f, -2.54160631e-03f, 2.57744011e-03f, 2.38720197e-02f, 6.92028105e-02f, -1.11491203e-01f, -7.85726979e-02f, 1.04678728e-01f,
  -3.61339822e-02f, -1.61418810e-01f, -7.67380074e-02f, -2.41921738e-01f, -1.81471348e-01f, 8.04254189e-02f, -9.41413417e-02f, -2.11773794e-02f, -8.20874125e-02f, -5.29792607e-02f,
  -4.48990464e-02f, -7.70859001e-03f, -1.22274272e-01f, -7.79507607e-02f, 6.21855892e-02f, -9.14449692e-02f, 9.94806215e-02f, -7.65093137e-03f, -9.54578146e-02f, 1.66212976e-01f,
  3.28967601e-01f, 2.58594304e-01f, -1.75422966e-01f, -1.06865697e-01f, 5.80385588e-02f, 9.54312831e-02f, 6.87122941e-02f, 8.60996246e-02f, 1.89182843e-04f, 6.31237030e-02f,
  -7.64752030e-02f, 4.84236814e-02f, 1.26124071e-02f, -2.51544081e-03f, 7.32804686e-02f, 8.33929628e-02f, -5.50692044e-02f, 1.39818592e-02f, -8.70518535e-02f, 1.24304824e-01f,
  -5.97513653e-02f, -3.70385796e-02f, 8.15840662e-02f, -2.63258163e-02f, -7.62296468e-02f, -2.47974992e-02f, 1.59254782e-02f, 4.95571233e-02f, -9.35846791e-02f, 5.65871261e-02f,
  -4.34654839e-02f, 3.59913856e-02f, -1.15509070e-02f, 9.61920172e-02f, 7.27074163e-04f, 1.02492329e-02f, -3.69969150e-03f, 1.73369385e-02f, -2.98883636e-02f, 6.72044829e-02f,
  -9.49058086e-02f, -9.32022370e-03f, -8.76307767e-03f, -4.72905077e-02f, -4.25208174e-02f, 3.22680175e-02f, -8.32412615e-02f, -5.03612198e-02f, -2.62353085e-02f, 5.43264523e-02f,
  -6.76521275e-04f, -2.50800047e-03f, 4.39955965e-02f, -1.31730884e-02f, -3.46064642e-02f, -3.44564691e-02f, -8.60665645e-03f, -4.02496420e-02f, 2.33686976e-02f, 7.03186020e-02f,
  1.42330542e-01f, -2.69208997e-01f, 1.04651719e-01f, -2.72390917e-02f, 1.00606978e-02f, -9.12670195e-02f, 6.99454695e-02f, -6.37979731e-02f, 1.73052289e-02f, 3.01610883e-02f,
  1.34810880e-02f, -4.42781672e-02f, 6.34869114e-02f, -1.64333861e-02f, 3.44443284e-02f, 2.14955714e-02f, 1.14906291e-02f, -4.06534858e-02f, -6.69867843e-02f, -2.56711002e-02f,
  -8.18909556e-02f, -2.08973158e-02f, 5.14065735e-02f, -1.06961746e-02f, -1.20840883e-02f, 3.22510079e-02f, 4.54684123e-02f, 5.75100332e-02f, -1.05598764e-02f, 9.01288912e-03f,
  -2.74264723e-01f, -1.71436623e-01f, -9.35796797e-02f, -6.50522485e-02f, 1.45282358e-01f, 6.71014115e-02f, 1.72460094e-01f, 6.39596358e-02f, 2.51031779e-02f, 5.00833914e-02f,
  -5.52845523e-02f, 2.83221109e-03f, -2.92494781e-02f, 1.08356908e-01f, 5.15345633e-02f, 6.19418062e-02f, 1.77283175e-02f, 7.02309906e-02f, 8.88004303e-02f, 7.35745952e-02f,
  1.08696871e-01f, -1.36632950e-03f, -1.16765901e-01f, -6.46102950e-02f, -2.52932124e-02f, 1.18051223e-01f, -5.87343983e-02f, -1.49709031e-01f, -6.87514842e-02f, -2.09724709e-01f,
  -1.33529231e-01f, -3.06283027e-01f, 1.13659643e-01f, 2.93079317e-02f, -1.73849184e-02f, -1.04643870e-02f, 8.13395306e-02f, -1.93710830e-02f, 2.16987077e-02f, -4.68587615e-02f,
  -1.77159850e-02f, -5.20430095e-02f, -5.79168387e-02f, -3.10332570e-02f, -5.89789227e-02f, -8.86003580e-03f, -4.41426784e-02f, -7.05512911e-02f, -7.69674554e-02f, -1.22619733e-01f,
  -4.14434820e-03f, -3.62820104e-02f, -1.23427682e-01f, 5.89756332e-02f, -1.15300544e-01f, 2.41272599e-02f, -1.19746745e-01f, -2.32670717e-02f, 3.08481529e-02f, 1.33969365e-02f,
  5.65080903e-02f, -2.24150028e-02f, 1.55525962e-02f, -1.81644876e-02f, -1.53426845e-02f, 3.83563749e-02f, 1.93518251e-02f, 2.74927206e-02f, 3.38569656e-02f, -4.09356691e-02f,
  8.92330408e-02f, -1.08304881e-02f, -1.85691342e-02f, 4.83760908e-02f, 3.77222896e-02f, -3.17949057e-02f, 1.91029124e-02f, -5.33528998e-02f, 2.84831375e-02f, 4.84301001e-02f,
  -1.46946320e-02f, 4.70208796e-03f, 4.19928553e-03f, 4.26428067e-03f, -4.02149223e-02f, -1.01749618e-02f, -1.35105364e-02f, -4.18670811e-02f, -3.13275419e-02f, 1.74733512e-02f,
  5.48629612e-02f, 3.02124508e-02f, 5.79119809e-02f, 7.64542520e-02f, -6.32648543e-02f, -7.01639280e-02f, -4.08378579e-02f, 3.94407511e-02f, -1.07319662e-02f, 8.25877562e-02f,
  -5.06881736e-02f, -8.20965972e-04f, -2.86848750e-02f, -1.00927420e-01f, 3.51439901e-02f, -5.64696416e-02f, 4.19082530e-02f, -3.61729153e-02f, 1.79497600e-02f, -6.65944889e-02f,
  -2.78276969e-02f, 5.08218259e-02f, 1.00193106e-01f, 1.43209830e-01f, 7.38208815e-02f, 1.30101994e-01f, 9.19084996e-02f, -1.67370997e-02f, 1.42007187e-01f, 1.79461271e-01f,
  4.04320985e-01f, -2.32113246e-02f, 9.48840231e-02f, 1.44887283e-01f, -1.13620996e-01f, -1.19930223e-01f, -2.88488388e-01f, 3.95196192e-02f, 1.41569376e-01f, -4.78909314e-02f,
  -9.05782435e-05f, 4.10489663e-02f, 2.47971136e-02f, 7.13804318e-03f, -9.98573229e-02f, -1.56337768e-01f, -1.74906015e-01f, 4.13828790e-02f, -6.12080097e-02f, -1.16579130e-01f,
  -1.07661404e-01f, -2.48599760e-02f, 5.35451360e-02f, 5.37299849e-02f, -1.47034109e-01f, -1.68232873e-01f, -1.31940544e-01f, -9.50821768e-03f, -2.52093896e-02f, -3.77309136e-02f,
  -7.38956779e-02f, 2.59871602e-01f, -1.13412119e-01f, -1.58275981e-02f, 4.74271439e-02f, 1.09051302e-01f, -3.01278867e-02f, 1.67755876e-02f, -5.38334511e-02f, -4.52673342e-03f,
  2.97809821e-02f, 5.42000905e-02f, -1.65586360e-02f, -2.49589211e-03f, -1.56615209e-02f, 6.01171516e-02f, -8.18745419e-02f, 4.33732606e-02f, 5.69867268e-02f, -3.82685252e-02f,
  -3.58258039e-02f, 7.98087493e-02f, 1.18368432e-01f, -8.71738270e-02f, -1.36768948e-02f, 4.21148203e-02f, -6.90860972e-02f, -8.39515328e-02f, -9.34428573e-02f, -4.72031161e-02f,
  -6.69629127e-02f, 4.94254939e-02f, 4.36924212e-02f, 2.55747680e-02f, -2.72385087e-02f, 1.92794180e-03f, 3.51294838e-02f, -1.93596836e-02f, -2.05087420e-02f, -6.44907029e-03f,
  1.75136246e-03f, 2.32746359e-02f, 1.75831374e-02f, -2.86534540e-02f, -2.42075380e-02f, -3.75992991e-02f, -2.23369244e-02f, -5.08561730e-03f, -1.75722577e-02f, 1.77227017e-02f,
  4.13187966e-02f, 3.34965851e-04f, -3.88863720e-02f, -8.51804763e-02f, 4.47918773e-02f, 2.15041805e-02f, -3.06565259e-02f, 4.09688279e-02f, 2.28040386e-02f, 5.87838776e-02f,
  -3.76046710e-02f, 1.02294713e-01f, -6.56178147e-02f, -1.66596398e-02f, -8.28712881e-02f, -4.45259474e-02f, 8.61973614e-02f, -9.33787227e-03f, 6.20203838e-03f, -2.79564876e-02f,
  1.40754587e-03f, -4.12938856e-02f, 7.55549520e-02f, -2.41609141e-02f, -5.24305180e-02f, -4.05668765e-02f, -9.56581235e-02f, -2.44370140e-02f, -8.71300548e-02f, -1.13986082e-01f,
  1.00404471e-02f, -3.83621119e-02f, -9.06119943e-02f, -7.62783289e-02f, 1.64009386e-03f, -7.68579692e-02f, -8.67165104e-02f, -1.22701682e-01f, -1.11706585e-01f, -2.17165530e-01f,
  -3.62090766e-01f, -2.60478586e-01f, -1.18925851e-02f, -4.79747802e-02f, 5.21985404e-02f, 2.22105801e-01f, 9.59639177e-02f, 6.95911497e-02f, -8.39030892e-02f, -1.22033767e-01f,
  -4.53183427e-02f, 1.37283059e-03f, -5.90687711e-03f, 1.03467546e-01f, 9.98390988e-02f, -1.72340404e-02f, 2.26553939e-02f, 9.11277011e-02f, 3.41630399e-01f, 2.44867072e-01f,
  8.64497423e-02f, -6.61863685e-02f, -1.27643287e-01f, 7.00364262e-02f, -9.12676752e-02f, 1.05109893e-01f, -5.24604395e-02f, -1.26667514e-01f, -3.57535966e-02f, -2.70479470e-01f,
  3.33537906e-02f, -1.93269119e-01f, 1.04651406e-01f, -1.02471197e-02f, -1.12067014e-02f, 2.27382351e-02f, 1.74929835e-02f, -6.87385648e-02f, -4.39352281e-02f, -1.35045573e-01f,
  -2.23719627e-02f, 2.20095087e-02f, -1.49792889e-02f, 3.67729738e-02f, -1.06751338e-01f, 5.19988360e-03f, -1.24583513e-01f, -2.02910528e-02f, -6.03433214e-02f, 2.46660113e-02f,
  -7.20949098e-02f, -1.35282323e-01f, -4.89514470e-02f, -8.76522809e-02f, 2.48532575e-02f, 3.27393748e-02f, 7.30742738e-02f, -5.82699515e-02f, 9.23484638e-02f, -1.64868012e-01f,
  8.38144645e-02f, 2.52375044e-02f, 5.07470705e-02f, -2.36983150e-02f, -2.56770104e-02f, 4.61698510e-03f, -4.12756391e-03f, 5.58898179e-03f, -1.66035630e-02f, -6.42543882e-02f,
  3.41930538e-02f, -1.17492201e-02f, 4.31803279e-02f, -5.35397604e-02f, 1.93387009e-02f, -3.15747177e-03f, -3.04538030e-02f, 2.76365299e-02f, -9.78545099e-02f, -3.29807587e-02f,
  6.92281127e-02f, -4.60059904e-02f, -9.32003185e-02f, -2.75447480e-02f, -2.00738665e-02f, 1.37208654e-02f, 7.16713117e-03f, 4.82819863e-02f, 1.41458763e-02f, 7.31847016e-03f,
  3.59618217e-02f, 1.01114593e-01f, -7.31594265e-02f, -2.02793255e-03f, 2.55511161e-02f, 1.43927475e-03f, -5.94214303e-03f, 1.16495071e-02f, -6.63957885e-03f, -1.04342110e-03f,
  5.32085728e-03f, 4.27424423e-02f, -1.27400562e-01f, -9.18159634e-03f, 4.66625243e-02f, 7.51013756e-02f, -5.05881011e-02f, 8.00960883e-02f, 1.10836580e-01f, -7.33003318e-02f,
  -2.25802232e-02f, 1.49496511e-01f, 1.31699443e-01f, 6.31985515e-02f, 1.51175563e-03f, 2.24000841e-01f, 2.41715923e-01f, 9.35911015e-02f, 2.50643134e-01f, 2.48239443e-01f,
  -5.88919632e-02f, 3.31764035e-02f, -3.27690057e-02f, -1.82185292e-01f, -3.13770212e-02f, 2.25498043e-02f, 1.55403271e-01f, 1.31571516e-01f, -5.16955592e-02f, -2.32878402e-02f,
  -1.50673687e-02f, -1.05371051e-01f, -4.10237396e-03f, -4.04940872e-03f, 9.32817161e-03f, 1.15727549e-02f, -1.40139744e-01f, -2.29355823e-02f, 6.56895805e-03f, 4.35337946e-02f,
  -5.92366867e-02f, -1.54241294e-01f, -1.14068814e-01f, -6.95323199e-02f, -5.88825755e-02f, -5.43677285e-02f, 2.97329500e-02f, -2.92778946e-02f, 6.78764656e-02f, -2.49186531e-01f,
  -5.08038402e-02f, 2.17711348e-02f, 2.29245462e-02f, -3.83591764e-02f, 6.52834922e-02f, -8.81829932e-02f, -2.66242540e-03f, 4.64170985e-02f, 5.81542626e-02f, 1.24419490e-02f,
  2.92850174e-02f, -4.54843231e-02f, -1.11326098e-01f, 2.19214819e-02f, -6.92876726e-02f, 3.97448502e-02f, 3.66595536e-02f, -9.97785777e-02f, 1.03960626e-01f, -3.02869119e-02f,
  -6.56791870e-03f, -9.67228636e-02f, -3.63360271e-02f, 4.10846770e-02f, -4.05822061e-02f, -7.12640956e-02f, 3.94203188e-03f, 5.23409657e-02f, 2.91995425e-03f, -2.54849959e-02f,
  -2.30031312e-02f, 1.70701891e-02f, 3.90711203e-02f, 3.98348719e-02f, -2.10841503e-02f, -8.49677473e-02f, -8.89356583e-02f, 2.50397008e-02f, -9.47734118e-02f, 2.76529696e-02f,
  7.35249221e-02f, 3.46471695e-03f, -6.70366501e-03f, 4.45576832e-02f, 6.11578533e-03f, -2.77680978e-02f, -2.48265397e-02f, -7.92665184e-02f, 7.13704014e-03f, 6.07554428e-03f,
  -5.01551032e-02f, 1.47066759e-02f, -7.28963837e-02f, -7.05688586e-03f, 4.37843688e-02f, 4.28783558e-02f, 2.42562238e-02f, 8.53932723e-02f, -1.93457436e-02f, 6.85131475e-02f,
  -1.24316804e-01f, 1.83510154e-01f, -5.29494248e-02f, -9.74706560e-02f, 2.06515826e-02f, 3.65641192e-02f, -1.97015814e-02f, -5.58368675e-02f, 1.04839420e-02f, -1.28114477e-01f,
  5.57678975e-02f, -5.61462566e-02f, 3.71902362e-02f, 5.74227348e-02f, -4.28146273e-02f, 5.77103645e-02f, 9.40274820e-03f, -1.26087636e-01f, 3.99184898e-02f, 6.51052920e-03f,
  3.66051123e-02f, 3.00965998e-02f, 5.95523268e-02f, 5.22751696e-02f, 2.53410358e-03f, -1.09945852e-02f, -5.08241355e-02f, -3.19533087e-02f, 1.25749737e-01f, 5.15565947e-02f,
  2.56222904e-01f, -1.56072527e-01f, -6.56482801e-02f, 1.33049535e-02f, -1.68796793e-01f, -3.00196648e-01f, -3.41140360e-01f, -2.38613844e-01f, 9.00871456e-02f, -1.62108183e-01f,
  -1.83692686e-02f, 1.60019532e-01f, 1.19156800e-01f, 1.23306163e-01f, -2.40197629e-02f, -1.72645524e-01f, -3.26275900e-02f, 2.19493717e-01f, 1.43179879e-01f, -6.24073669e-02f,
  -5.44889532e-02f, 1.66555811e-02f, 2.48599246e-01f, 5.53939566e-02f, -4.00347076e-02f, -2.96348211e-04f, 5.82685843e-02f, -1.57563984e-02f, 1.00048661e-01f, 2.34491825e-01f,
  -4.80937585e-02f, 1.27109550e-02f, 9.49758962e-02f, -2.76827458e-02f, -2.00677868e-02f, -5.15489243e-02f, -6.53312951e-02f, 3.37447189e-02f, 3.37300003e-02f, 5.35266325e-02f,
  -6.64178422e-03f, 1.07161872e-01f, 2.63918191e-02f, -1.87192969e-02f, 5.04546836e-02f, -2.04739533e-02f, 1.01562694e-01f, 9.16888639e-02f, 5.47168218e-02f, -9.15885493e-02f,
  -8.00667703e-02f, 4.15082015e-02f, -5.05417995e-02f, 5.74208563e-03f, -5.23371398e-02f, 3.72487530e-02f, 3.01240254e-02f, 6.10645898e-02f, 1.17305085e-01f, 1.11685216e-01f,
  1.07814595e-01f, 1.22450301e-02f, 2.79856231e-02f, -6.98213056e-02f, -6.05588444e-02f, 5.10763302e-02f, -4.24471498e-02f, 4.99810465e-02f, 1.65393148e-02f, 8.73151887e-03f,
  7.72219971e-02f, -1.05308080e-02f, -4.79304530e-02f, -2.66754674e-03f, -1.60367899e-02f, 2.23028958e-02f, -4.55177017e-03f, 2.65344214e-02f, 8.29289202e-03f, 3.18720867e-03f,
  1.31641757e-02f, 4.74559106e-02f, -1.58752762e-02f, 5.23763038e-02f, 8.76347795e-02f, 5.34861274e-02f, -5.95410634e-03f, 2.25832257e-02f, 2.67769601e-02f, -3.32165919e-02f,
  -2.19615132e-01f, 2.28108298e-02f, -1.33119319e-02f, 1.70550663e-02f, 3.37977186e-02f, 4.03345115e-02f, -4.80515556e-03f, 6.14937255e-03f, 1.22519108e-02f, -6.89549372e-02f,
  -7.50302598e-02f, -6.09649494e-02f, -2.41941996e-02f, 3.21155302e-02f, 2.77306363e-02f, 3.38351056e-02f, -8.36499482e-02f, 9.79462359e-03f, 5.63901328e-02f, -3.91567461e-02f,
  -8.95943642e-02f, -9.38170254e-02f, -6.13953806e-02f, -6.50110096e-02f, -6.09436221e-02f, 7.53308982e-02f, -1.06742620e-01f, 2.93578859e-03f, -3.48055065e-02f, -4.74955253e-02f,
  8.00419599e-02f, 1.46100804e-01f, 1.13160372e-01f, -2.05448139e-02f, 4.45166454e-02f, 2.24309281e-01f, 4.46420640e-01f, 1.32574039e-02f, -6.49409592e-02f, 1.16333507e-01f,
  -1.96459204e-01f, -3.43061626e-01f, -2.69598871e-01f, -2.00363025e-01f, 1.86549388e-02f, 2.98692435e-01f, 2.48213068e-01f, -7.82603770e-03f, -9.33656320e-02f, 6.74596429e-02f,
  -7.16567934e-02f, -2.54077818e-02f, -5.64017035e-02f, 3.11044455e-02f, 1.19764060e-01f, -2.87311792e-01f, 6.20516092e-02f, -3.47862691e-02f, -7.58575648e-03f, 6.81411773e-02f,
  -1.09609962e-01f, 2.96801895e-01f, -1.53468668e-01f, -6.76039383e-02f, -5.23428433e-02f, -1.95946097e-02f, 7.24369660e-03f, -1.05391145e-02f, -5.05335853e-02f, 4.75492738e-02f,
  9.85329878e-03f, -4.35883626e-02f, 2.81053018e-02f, 1.74314808e-02f, 9.04126987e-02f, 6.96900487e-02f, 5.04579172e-02f, 4.74604294e-02f, 3.72330844e-03f, 6.96738884e-02f,
  -4.00070772e-02f, 1.31539673e-01f, 1.16352946e-01f, 5.74637614e-02f, 6.50970265e-02f, -1.79274142e-01f, 9.21692327e-02f, 1.03782237e-01f, 4.50612456e-02f, -3.36593352e-02f,
  -5.21306507e-02f, 9.19040591e-02f, -4.38266899e-03f, 5.37656946e-03f, -5.84835261e-02f, -6.95110038e-02f, 2.43247603e-03f, 2.01653522e-02f, -5.09103201e-03f, 1.13165490e-02f,
  -9.31142941e-02f, 3.29201259e-02f, 3.58032472e-02f, 4.00132872e-02f, -3.72236930e-02f, 1.20134279e-01f, -5.39889261e-02f, 7.64081925e-02f, -6.56791851e-02f, -1.69757102e-02f,
  -1.68238636e-02f, -1.34638939e-02f, -6.73673581e-03f, 2.23961612e-03f, -6.24921061e-02f, -5.80772664e-03f, 5.61702140e-02f, 7.63987843e-03f, -4.44374681e-02f, 1.07069016e-02f,
  -2.50407994e-01f, 1.59624126e-02f, -1.98716410e-02f, -1.04537252e-02f, 4.75582592e-02f, -4.14780378e-02f, -9.36178416e-02f, 8.74366891e-03f, -4.30344716e-02f, 3.11145447e-02f,
  1.01024918e-01f, 3.11719291e-02f, -2.60009374e-02f, 3.40551659e-02f, -6.67498633e-02f, 5.12300022e-02f, -9.55803413e-03f, 7.05065578e-02f, -2.20695343e-02f, -3.86541449e-02f,
  -1.54316612e-02f, 5.56259453e-02f, -1.00460641e-01f, -3.95969786e-02f, -6.15559556e-02f, -1.26654133e-01f, 4.89434674e-02f, 1.13611585e-02f, -7.01997504e-02f, 4.52972800e-02f
};

// L0_fan_Wp_bar (Shape: 40 x 120)
const int L0_fan_Wp_bar_rows = 40;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  1.81323346e-02f, 5.37551828e-02f, 2.89823450e-02f, 2.41243038e-02f, 7.83878379e-03f, 4.88077849e-03f, -3.11268400e-02f, 5.18607236e-02f, 5.23423515e-02f, 6.46292195e-02f,
  -3.71838920e-02f, 3.65057960e-02f, -1.13020772e-02f, 9.69618335e-02f, 5.40745370e-02f, 1.39456922e-02f, 1.38498321e-01f, 5.79147674e-02f, 2.69863885e-02f, 5.32744341e-02f,
  3.36982235e-02f, 1.50576225e-02f, 5.36437109e-02f, -8.41921754e-03f, 8.83693546e-02f, -5.17855734e-02f, -7.40187094e-02f, 5.41718155e-02f, 8.78698006e-03f, 6.17733598e-02f,
  2.95478702e-02f, -5.49568385e-02f, -6.10157289e-02f, 9.85219032e-02f, -6.08254932e-02f, -1.24433497e-03f, 3.79985794e-02f, 1.97195578e-02f, 3.67060527e-02f, -2.94196717e-02f,
  6.34719282e-02f, -7.01356828e-02f, 5.90806827e-02f, -6.68286905e-02f, 6.10239469e-02f, 2.80379374e-02f, -1.75278019e-02f, 5.47624193e-02f, 7.04531819e-02f, 3.43840532e-02f,
  7.33502805e-02f, -8.42054114e-02f, 2.51247026e-02f, 3.05275619e-02f, -4.09399085e-02f, -8.10438097e-02f, -5.37132174e-02f, 6.48975894e-02f, 4.11885120e-02f, 2.84355786e-02f,
  4.53932248e-02f, -3.88562009e-02f, -3.02562001e-03f, -7.46948719e-02f, 2.48390809e-02f, -5.30126970e-04f, -6.68579563e-02f, -5.80176599e-02f, -2.56950129e-02f, 1.28899701e-02f,
  4.87492755e-02f, -5.28449565e-02f, 8.19889605e-02f, 8.11647773e-02f, -4.45547514e-02f, -4.29976769e-02f, -1.66582763e-02f, -5.38008995e-02f, -4.22524847e-02f, -8.81739631e-02f,
  6.29069433e-02f, 5.98468352e-03f, 3.69217359e-02f, 7.75721595e-02f, -5.76305240e-02f, 5.02785333e-02f, -7.61515573e-02f, 8.64038467e-02f, 3.51705402e-02f, 1.97184202e-03f,
  -9.47259665e-02f, 6.02991227e-03f, 4.86829877e-02f, -3.74811850e-02f, -6.83513656e-02f, -6.71473145e-02f, 7.34235868e-02f, 7.14209005e-02f, -4.22200821e-02f, -7.85077512e-02f,
  3.51450779e-02f, -5.28384335e-02f, 2.16071662e-02f, -4.45520990e-02f, 7.15541914e-02f, -5.33527955e-02f, 5.33400439e-02f, -7.32739568e-02f, -3.29890114e-04f, -1.18611464e-02f,
  -5.24854995e-02f, 5.66944368e-02f, 5.85109219e-02f, -4.13980670e-02f, -3.81076001e-02f, -7.67538846e-02f, 4.39486429e-02f, -7.45299533e-02f, -6.09758385e-02f, 5.39642526e-04f,
  2.96646021e-02f, -2.28074551e-01f, -1.22419894e-01f, -9.37450230e-02f, -1.71150770e-02f, 7.94745162e-02f, -1.48065269e-01f, 8.11128318e-02f, 1.46190554e-01f, -1.57709435e-01f,
  4.82023973e-03f, 7.75532648e-02f, 6.23363964e-02f, 2.97183692e-02f, 8.36911201e-02f, -1.70718044e-01f, -2.64710397e-01f, 2.98649389e-02f, 2.16421559e-01f, 1.45340219e-01f,
  4.84270006e-02f, 1.50816478e-02f, 5.27927317e-02f, 1.22450769e-01f, -1.04951993e-01f, -4.98957708e-02f, -2.41154090e-01f, -2.18973666e-01f, -2.19830438e-01f, -3.33518267e-01f,
  -3.33416253e-01f, 1.21022716e-01f, 4.84696180e-02f, 3.36714014e-02f, -8.71568844e-02f, 4.49231341e-02f, 9.24777985e-03f, -4.91789840e-02f, 1.04799822e-01f, 5.10620698e-02f,
  -3.92245166e-02f, 7.88363721e-03f, -1.06584560e-02f, 4.41685840e-02f, 1.04473285e-01f, 2.15633102e-02f, 6.50823349e-03f, 6.53667701e-03f, -1.96121801e-02f, -4.47252765e-02f,
  -6.60278201e-02f, 3.95731181e-02f, -2.85616238e-02f, -3.71566378e-02f, -1.49126546e-02f, -7.34896362e-02f, -1.49448499e-01f, -8.61702412e-02f, -9.88859236e-02f, -2.76913315e-01f,
  -2.55342647e-02f, 1.85210556e-02f, -5.32699451e-02f, 6.42027780e-02f, 1.31158633e-02f, -4.79533337e-02f, -5.67996837e-02f, -2.52512470e-03f, -3.06124855e-02f, -5.06264344e-02f,
  -4.23569754e-02f, 4.57418449e-02f, -2.44017337e-02f, -8.74028802e-02f, -1.05247401e-01f, 4.68256772e-02f, 8.66805539e-02f, -1.10457562e-01f, 2.06920337e-02f, -3.10474131e-02f,
  1.24301258e-02f, -4.13830243e-02f, 5.53069040e-02f, 5.05641997e-02f, 2.75573488e-02f, -2.20487602e-02f, 2.42624152e-03f, 8.21089968e-02f, 9.94282588e-02f, 6.88322559e-02f,
  -6.40557408e-02f, 3.47835459e-02f, 3.39619932e-03f, 4.87948880e-02f, -1.00508025e-02f, -2.68216673e-02f, -1.16472892e-01f, 2.63000000e-02f, -3.20500284e-02f, 3.34885754e-02f,
  3.98191214e-02f, -3.49652506e-02f, -9.87647846e-02f, 5.10842875e-02f, 5.80489635e-02f, 1.29787084e-02f, 2.25913543e-02f, -1.15963342e-02f, 5.78086562e-02f, -2.85473000e-02f,
  -5.64708561e-02f, -4.20134105e-02f, 5.40057160e-02f, -9.76503417e-02f, -1.22562852e-02f, -5.97625859e-02f, -8.87563378e-02f, -1.00215614e-01f, 1.17274774e-02f, -1.85480207e-01f,
  -1.54561356e-01f, -1.73963651e-01f, -4.15659249e-02f, -9.08868536e-02f, -1.68637261e-02f, -9.17674452e-02f, -5.15576787e-02f, 6.51688427e-02f, -2.89213620e-02f, -7.94530660e-02f,
  -5.73809864e-03f, -7.90191144e-02f, -6.60271421e-02f, -4.24984694e-02f, -5.43799847e-02f, -1.92820460e-01f, -1.41153038e-01f, -1.27895027e-01f, 1.38884261e-02f, 1.21291161e-01f,
  -6.29107654e-02f, 3.83792855e-02f, -5.27724437e-02f, 5.64833432e-02f, -7.28347078e-02f, -1.02929823e-01f, -1.85477674e-01f, -5.32677723e-03f, -1.19361326e-01f, -1.62207559e-01f,
  -6.95264265e-02f, 9.67096444e-03f, -1.44392271e-02f, 3.53207514e-02f, 2.49878485e-02f, -2.66899564e-03f, -6.93733022e-02f, 4.53911386e-02f, 8.93953145e-02f, -2.01317593e-02f,
  6.84591830e-02f, 6.35553449e-02f, 6.94774697e-03f, -4.37749587e-02f, -5.36463484e-02f, -4.14483026e-02f, -1.96978403e-03f, 8.29195976e-02f, 7.16169626e-02f, -6.10047532e-03f,
  5.86617813e-02f, -5.07358313e-02f, 4.71197590e-02f, 5.95876984e-02f, -1.57589149e-02f, -1.11413993e-01f, -9.19283256e-02f, -5.78507707e-02f, 3.64150405e-02f, -8.11061934e-02f,
  -8.32859501e-02f, -1.10961106e-02f, -2.69545931e-02f, 6.73842430e-02f, 3.00338175e-02f, 4.00130525e-02f, -2.74303043e-03f, -6.98797852e-02f, 1.30419299e-01f, -5.67068085e-02f,
  6.37865737e-02f, -7.29042590e-02f, 8.93812701e-02f, 9.06788185e-02f, -6.57078317e-06f, -2.45566741e-02f, -7.64251426e-02f, 6.56427292e-04f, 1.48362629e-02f, 4.56754491e-02f,
  6.12126552e-02f, 9.31455493e-02f, -4.22945106e-03f, 8.33836794e-02f, -6.28490224e-02f, -5.63138574e-02f, -6.31806180e-02f, -3.85871790e-02f, 4.29857895e-02f, -7.72322640e-02f,
  7.40983263e-02f, -2.05312401e-01f, -6.19280450e-02f, 1.34634422e-02f, 1.04176151e-02f, 4.94748317e-02f, 4.70971949e-02f, 3.86531577e-02f, 1.82320289e-02f, -5.73157109e-02f,
  2.94509344e-02f, 3.59552167e-02f, 4.06642333e-02f, -7.78771117e-02f, 9.85569358e-02f, 7.17492327e-02f, 1.07478742e-02f, -7.48063773e-02f, 8.79473016e-02f, 1.14347570e-01f,
  -1.44391553e-02f, 2.56351456e-02f, -7.57240057e-02f, 1.93070099e-02f, -2.97752563e-02f, -2.31645126e-02f, -1.18880019e-01f, -2.79960711e-03f, 1.43085727e-02f, -4.28924449e-02f,
  2.82227807e-02f, -4.50146087e-02f, 9.48814675e-02f, 8.58705267e-02f, 9.62421522e-02f, 2.36072000e-02f, 8.65824427e-03f, -3.92912552e-02f, -4.87709232e-02f, -2.69165058e-02f,
  1.20512955e-03f, -9.71450284e-02f, -1.17026947e-01f, -1.20017849e-01f, 6.26141056e-02f, -4.92138192e-02f, 4.89977002e-02f, 1.01344228e-01f, 9.12688524e-02f, 1.04456216e-01f,
  6.64869770e-02f, 4.43724208e-02f, -1.53950881e-03f, 2.66318861e-03f, 2.45134868e-02f, -6.60778135e-02f, -9.23875533e-03f, -7.52866268e-02f, -3.99171822e-02f, -6.59913793e-02f,
  5.18074930e-02f, 4.80116233e-02f, 5.53953908e-02f, -4.19092588e-02f, -4.96356972e-02f, 3.84460273e-03f, 4.18588445e-02f, -7.67470747e-02f, 2.12324550e-03f, -6.47858903e-02f,
  -9.65719447e-02f, 6.73334971e-02f, -1.05784580e-01f, 4.27937992e-02f, 2.55147666e-02f, 6.32062182e-02f, 5.91141917e-02f, 3.03623583e-02f, 3.99719700e-02f, -2.73725428e-02f,
  -1.14892676e-01f, 5.30027226e-02f, 4.11216216e-03f, 7.30748894e-03f, -2.38274969e-02f, 4.79512960e-02f, 2.56667589e-03f, 6.06344268e-03f, -4.35689390e-02f, 7.51270950e-02f,
  -1.56724099e-02f, 4.69235219e-02f, -8.73836428e-02f, 2.94352714e-02f, 3.94422375e-02f, -6.66475743e-02f, 4.44017015e-02f, 6.15624450e-02f, 2.03784872e-02f, 8.28096569e-02f,
  1.02749059e-03f, -3.25925723e-02f, -7.08095655e-02f, -6.24659797e-03f, -6.54300451e-02f, 1.35932015e-02f, 4.14749570e-02f, -6.50769174e-02f, -4.78086770e-02f, -6.67852312e-02f,
  7.61655793e-02f, 5.19890562e-02f, -5.01058437e-02f, -4.04769331e-02f, -4.18155529e-02f, 3.54405269e-02f, -4.91184518e-02f, -9.86457914e-02f, 1.66558642e-02f, 4.89613004e-02f,
  8.85420665e-02f, 3.37288505e-03f, -3.57853761e-03f, -3.43712009e-02f, 1.36923999e-01f, -9.75786820e-02f, 9.01127327e-03f, 7.59938173e-03f, 3.36257890e-02f, -7.12858588e-02f,
  3.69862616e-02f, 8.79158676e-02f, 1.04281586e-03f, -4.30812463e-02f, 1.09178998e-01f, 4.51469123e-02f, 6.39232248e-02f, 7.23294690e-02f, -5.93182296e-02f, -3.09769418e-02f,
  -3.50593366e-02f, 1.02433212e-01f, 1.15250327e-01f, 4.46290411e-02f, 7.08120540e-02f, 2.93338690e-02f, 9.28092077e-02f, 3.86555381e-02f, -8.34997650e-03f, 1.85084313e-01f,
  9.62999761e-02f, -2.75676865e-02f, -5.82350418e-03f, 2.16604814e-01f, 4.60667117e-03f, -5.31578623e-02f, 3.09802294e-02f, 2.80842651e-02f, 1.36237219e-01f, 1.82029754e-01f,
  2.24156871e-01f, 3.03527892e-01f, 1.80815980e-01f, 2.21276522e-01f, 9.53098536e-02f, 3.44444290e-02f, 1.15757607e-01f, 1.33629546e-01f, 1.38309628e-01f, 1.40117869e-01f,
  9.81139243e-02f, -7.56504387e-02f, -2.16448940e-02f, -3.18220817e-02f, 9.75283012e-02f, 4.46636304e-02f, 7.74995759e-02f, -1.99297983e-02f, 7.40510076e-02f, 1.86740905e-01f,
  1.68158621e-01f, 6.53385147e-02f, 1.55521646e-01f, -4.12865309e-03f, -5.69055602e-02f, -8.57654661e-02f, 8.05559382e-02f, -1.92084393e-04f, -1.48099601e-01f, 1.81340501e-02f,
  3.88086662e-02f, -2.58425158e-03f, -1.26478255e-01f, -8.09612349e-02f, -5.33019081e-02f, -1.86202931e-03f, -6.81694970e-02f, 2.70959716e-02f, -4.46358845e-02f, 4.82795201e-02f,
  4.33328860e-02f, 7.78300092e-02f, -1.68243181e-02f, -8.98569822e-02f, 5.96012585e-02f, 5.00220293e-03f, -3.57537009e-02f, 3.35570499e-02f, -4.89931442e-02f, -7.41510168e-02f,
  3.37591469e-02f, 1.35549590e-01f, 5.87803908e-02f, -5.58394007e-02f, -1.46996304e-02f, -2.15399787e-02f, -4.99892496e-02f, 6.32116199e-02f, -1.15418900e-02f, -1.27992526e-01f,
  2.96056326e-02f, 6.18520863e-02f, 7.24048063e-04f, 6.37011826e-02f, 6.11378253e-03f, -4.26584445e-02f, -2.39872225e-02f, 1.08363912e-01f, 1.22710876e-02f, -8.37895088e-03f,
  -3.79695334e-02f, -3.74420322e-02f, -7.36325905e-02f, 5.60587421e-02f, 7.64702484e-02f, 4.60793674e-02f, -3.39330058e-03f, 3.35523821e-02f, -4.90481034e-02f, 4.75774333e-03f,
  -1.32727837e-02f, -9.86998528e-03f, 1.84780613e-01f, 8.21156651e-02f, 8.42335001e-02f, -9.47330985e-03f, 8.62564296e-02f, 2.03947183e-02f, 1.78616028e-03f, 3.77806760e-02f,
  -6.36331365e-02f, -4.48900275e-03f, 2.69878320e-02f, -5.88965835e-03f, -5.48551679e-02f, -1.31940702e-03f, -6.33418038e-02f, 6.95157945e-02f, 1.35345340e-01f, -3.91161330e-02f,
  -3.23397890e-02f, -5.23831882e-02f, 8.66295025e-02f, -1.04978867e-02f, -5.93531094e-02f, 1.62633918e-02f, -3.74711566e-02f, 1.77271441e-02f, -9.86896455e-02f, -3.89121845e-02f,
  -3.57136369e-01f, -2.26231068e-02f, 4.03591879e-02f, 4.49304394e-02f, 6.08556792e-02f, -2.06589513e-03f, -1.36099070e-01f, -1.32111460e-01f, -1.60505380e-02f, -3.99808660e-02f,
  -4.20128964e-02f, -1.08338356e-01f, -5.64698167e-02f, -6.12160675e-02f, -1.72818214e-01f, -1.42280653e-01f, -2.06582189e-01f, -1.73999414e-01f, -8.88939947e-02f, 6.15663640e-03f,
  -3.18224393e-02f, -1.69649988e-01f, -7.04002753e-02f, -6.36053532e-02f, 8.18182305e-02f, 1.35592252e-01f, 3.35332789e-02f, 2.95408294e-02f, 1.44856498e-01f, 1.24851679e-02f,
  -1.04163393e-01f, -7.48414695e-02f, -1.62841007e-02f, -7.67373294e-02f, 9.38936025e-02f, 5.37858307e-02f, -2.16687601e-02f, 7.86977485e-02f, -1.94449676e-03f, -6.76683113e-02f,
  5.29675139e-03f, -1.33083318e-03f, 1.03195766e-02f, -1.91946998e-02f, 6.59949612e-03f, 1.60598650e-03f, -6.11688104e-03f, -1.28449842e-01f, -1.14978300e-02f, 5.69429323e-02f,
  -4.15904783e-02f, -9.44607779e-02f, -8.22088867e-02f, -6.05998188e-02f, 9.92697701e-02f, 4.49138433e-02f, 2.85381228e-02f, 2.67157592e-02f, -4.41001449e-03f, -3.97621021e-02f,
  7.20783547e-02f, 3.74404620e-03f, 1.96486767e-02f, 4.43928353e-02f, -8.90531614e-02f, 5.99947311e-02f, 3.25132832e-02f, 7.56759895e-04f, -3.35826688e-02f, 3.75128649e-02f,
  -2.78079957e-02f, 8.89957175e-02f, 4.11509499e-02f, 3.45734544e-02f, 1.03749350e-01f, 3.28807309e-02f, -1.63526870e-02f, -2.88585983e-02f, -2.98108943e-02f, 3.91609222e-03f,
  -2.58497166e-04f, -7.35198334e-02f, -3.79252955e-02f, 6.92451596e-02f, 5.83707308e-03f, -1.58444904e-02f, 7.16023669e-02f, -8.07811096e-02f, -8.24350342e-02f, 4.55350280e-02f,
  -1.21540323e-01f, 9.39491466e-02f, -9.97742638e-02f, -1.02421202e-01f, 1.70291048e-02f, 6.27274159e-03f, 4.81968895e-02f, 9.75605194e-03f, 5.66214770e-02f, -5.62688103e-03f,
  -4.73867841e-02f, -2.93648569e-03f, -6.68699816e-02f, -3.95449847e-02f, -1.36128157e-01f, -3.83188352e-02f, -8.94985572e-02f, 2.49456912e-02f, -7.68574253e-02f, 8.60290304e-02f,
  -6.99029714e-02f, -1.96560144e-01f, -2.88909644e-01f, -1.24641605e-01f, -9.14033279e-02f, -1.47117734e-01f, -1.60454407e-01f, 3.54662389e-02f, -8.75297561e-02f, -2.17761561e-01f,
  -1.59688070e-01f, -5.24599617e-03f, 1.23858750e-02f, 9.89834778e-03f, 9.52529237e-02f, 1.02366388e-01f, 1.63060743e-02f, 9.24891233e-02f, 1.01616584e-01f, 3.67918573e-02f,
  5.28952517e-02f, 7.79264495e-02f, 8.81322846e-02f, -2.50596181e-02f, -1.54796494e-02f, 1.62684202e-01f, 8.72404948e-02f, 5.06874211e-02f, 7.36162066e-02f, 7.87355602e-02f,
  -3.72685790e-02f, -1.01878211e-01f, -7.05228448e-02f, 4.75163385e-02f, 6.39212206e-02f, 6.57706484e-02f, 8.35243240e-03f, -1.29862211e-03f, -8.00879672e-02f, 7.29124099e-02f,
  -9.54969972e-02f, -7.13292509e-02f, 1.34182483e-01f, 6.89643174e-02f, -1.84000563e-02f, -2.63997149e-02f, -3.18727903e-02f, -6.46522045e-02f, -5.82901947e-02f, 5.27570136e-02f,
  -1.95823070e-02f, -3.07995938e-02f, 1.01334579e-01f, -7.73670152e-02f, -8.35101604e-02f, -4.16290537e-02f, -8.87859985e-02f, 7.44553506e-02f, -2.51130722e-02f, -8.73082969e-03f,
  -5.25860265e-02f, -6.68279007e-02f, -5.35850227e-02f, -4.66775075e-02f, 5.56876138e-02f, 1.05865516e-01f, -5.99469393e-02f, -7.93616027e-02f, -1.10088857e-02f, -8.94280523e-02f,
  -6.44056723e-02f, -6.37807101e-02f, -7.47163147e-02f, -2.72963829e-02f, 1.90989841e-02f, -2.31588189e-03f, -1.93178598e-02f, -9.66932345e-03f, 2.34266520e-02f, 7.07170814e-02f,
  -7.91313574e-02f, 7.18854293e-02f, 1.84020065e-02f, -5.82157485e-02f, -4.94698584e-02f, 4.96191420e-02f, 3.55997644e-02f, -4.63157892e-02f, 6.25832528e-02f, 6.22970685e-02f,
  9.40352380e-02f, 2.47588605e-02f, 4.12391312e-02f, 5.96506521e-02f, 6.45632669e-02f, 2.62556262e-02f, -3.95278856e-02f, -7.96232745e-02f, 5.33443131e-02f, 4.30217236e-02f,
  -3.67830396e-02f, 1.11040637e-01f, 9.65785384e-02f, -2.94602234e-02f, -2.21170150e-02f, -7.86354020e-02f, -1.32518895e-02f, 3.73119116e-02f, -8.62945318e-02f, -9.13040712e-02f,
  -7.71354735e-02f, -1.42276976e-02f, 9.36787296e-03f, -9.04193148e-02f, 7.73338461e-03f, -6.77806605e-03f, 1.46989794e-02f, 9.88252014e-02f, 1.10145798e-02f, -3.60711738e-02f,
  4.68332693e-02f, 4.72644307e-02f, 1.15280785e-01f, 6.22921102e-02f, 1.08297370e-01f, -2.39972863e-02f, -2.24616006e-03f, -2.20013671e-02f, 4.80372719e-02f, 5.14046438e-02f,
  2.28293296e-02f, 5.58256842e-02f, -2.49674823e-02f, 1.12638995e-01f, -7.34933838e-02f, -2.58928649e-02f, -5.52594513e-02f, -6.05479442e-02f, 3.30159068e-02f, -6.30640015e-02f,
  7.76904225e-02f, 1.95590239e-02f, 1.21402599e-01f, 4.27032523e-02f, 1.07714705e-01f, -3.87393907e-02f, -7.34219626e-02f, -7.81807676e-02f, 3.18659805e-02f, 7.79356156e-03f,
  7.33619928e-02f, 1.49013093e-02f, -5.15108444e-02f, -9.23069119e-02f, -2.32008025e-02f, -9.14045889e-03f, -3.36440280e-02f, 2.19421927e-02f, -1.03912622e-01f, -6.08695187e-02f,
  7.80818835e-02f, 7.85996020e-02f, 8.85068923e-02f, 8.87076184e-02f, 2.00290531e-02f, 1.99683122e-02f, 5.70949540e-02f, -4.99082878e-02f, -2.76871063e-02f, -4.59260084e-02f,
  -6.33056238e-02f, 6.60924241e-02f, -7.10280538e-02f, -7.94174597e-02f, 4.55349237e-02f, 6.26838654e-02f, -6.22858889e-02f, 4.46862169e-03f, 2.40107439e-03f, 2.84710787e-02f,
  2.43691914e-02f, -9.10194870e-03f, 7.22694471e-02f, 1.14747308e-01f, 6.49545342e-02f, 1.06814779e-01f, 8.52533150e-03f, -2.20405962e-02f, 9.67565179e-02f, -6.95493519e-02f,
  -1.88948475e-02f, 9.48102493e-03f, 8.23748410e-02f, 2.56588198e-02f, 4.17123251e-02f, -9.93110426e-03f, -2.25168597e-02f, -1.00734439e-02f, 5.07447906e-02f, -5.88729270e-02f,
  6.53992295e-02f, -2.72362176e-02f, -8.21439624e-02f, 1.02843968e-02f, -4.73565422e-03f, -6.49733916e-02f, 5.72462892e-03f, 6.91448972e-02f, -6.99504316e-02f, 2.31894143e-02f,
  2.25805975e-02f, 1.86729792e-03f, 6.76229130e-03f, -5.73501885e-02f, -1.16041057e-01f, 4.73744571e-02f, 4.15621027e-02f, -6.07371815e-02f, -9.58137736e-02f, -1.01028800e-01f,
  1.17920097e-02f, 1.20965078e-01f, 4.61397022e-02f, 4.32415912e-03f, -4.23630746e-03f, 2.68917009e-02f, 9.53647196e-02f, 9.07646492e-02f, 2.13213600e-02f, 8.89768451e-03f,
  -5.38351834e-02f, 7.87458196e-02f, 9.52478498e-03f, -7.32150376e-02f, 5.62855862e-02f, 6.68553188e-02f, -8.23523998e-02f, 1.09813318e-01f, 1.17930479e-01f, -1.37722101e-02f,
  1.41314222e-02f, 2.39464249e-02f, 1.75484587e-02f, 1.10583305e-01f, 5.63793443e-02f, -1.30782602e-02f, 4.09631729e-02f, 4.42702360e-02f, -1.05512515e-02f, 8.04315284e-02f,
  -1.45888358e-01f, -5.64670470e-03f, 2.66686641e-02f, -7.21202567e-02f, 3.47652957e-02f, -3.86208519e-02f, -3.82744521e-02f, -2.68758368e-03f, 9.46280658e-02f, 7.37162158e-02f,
  5.43863252e-02f, 1.11419499e-01f, 9.57783428e-04f, -2.32358444e-02f, -5.92952482e-02f, -2.61570923e-02f, 1.63505264e-02f, 5.08734584e-02f, 4.42283191e-02f, 4.84637637e-03f,
  4.22254167e-02f, -1.25963107e-01f, 1.90882515e-02f, 4.85233404e-02f, -7.59776235e-02f, 7.31056184e-03f, -6.23309761e-02f, 5.75366840e-02f, 4.76076938e-02f, -1.42188758e-01f,
  5.95353618e-02f, 7.57259503e-02f, 3.70883271e-02f, -6.53186068e-02f, 3.43357213e-02f, 7.37551451e-02f, 6.23205602e-02f, 2.17389669e-02f, -1.05738612e-02f, 1.19360030e-01f,
  3.20164151e-02f, 4.23767120e-02f, 5.60180247e-02f, 7.81281665e-02f, 2.59996857e-02f, 4.93301637e-02f, -1.19538836e-01f, -6.16793986e-03f, -4.41647135e-02f, 6.57591298e-02f,
  -2.68061142e-02f, 1.25898510e-01f, 7.31801987e-02f, 1.57076158e-02f, -4.69257385e-02f, 8.93095508e-02f, 7.21466243e-02f, -2.10039057e-02f, 1.17210530e-01f, 6.13222495e-02f,
  -1.87011063e-02f, 2.53331810e-02f, -3.95151936e-02f, -5.64709567e-02f, 2.89519988e-02f, -2.24752035e-02f, 2.18589623e-02f, -3.89052741e-02f, -8.39039907e-02f, -1.42361922e-02f,
  -1.93201881e-02f, -1.39757700e-03f, 1.13376118e-02f, 4.15110327e-02f, -5.35785295e-02f, -2.86204685e-02f, 2.47070193e-02f, 3.67865041e-02f, -7.61962170e-03f, -6.48601726e-03f,
  -9.97219514e-03f, 7.07298443e-02f, -1.13010807e-02f, 3.39283645e-02f, 8.89289528e-02f, -7.25100376e-03f, -2.08232943e-02f, 3.68722109e-03f, -6.47822395e-02f, 5.36716916e-02f,
  7.25010186e-02f, 8.01127702e-02f, -7.20087020e-03f, 4.77797091e-02f, 2.49516051e-02f, -6.22402430e-02f, 3.10941711e-02f, 3.27841900e-02f, -4.87454049e-02f, -4.50362787e-02f,
  -2.76766419e-02f, -1.35268513e-02f, 4.42574024e-02f, 4.24159952e-02f, -5.72831929e-02f, 4.06598002e-02f, -2.42106691e-02f, 4.74692881e-02f, -1.24545826e-03f, 7.49279931e-02f,
  -5.12196124e-02f, -4.63596918e-03f, 7.85906762e-02f, 1.31202593e-01f, -4.53713760e-02f, 6.45619482e-02f, -3.19472738e-02f, 7.55354613e-02f, -3.99846025e-02f, -4.81001623e-02f,
  -2.81714886e-01f, 4.57176100e-03f, 2.89481636e-02f, -1.17496617e-01f, 4.37842729e-03f, 1.32551625e-01f, 1.60388499e-01f, 2.89432872e-02f, -5.24730571e-02f, -6.42924756e-02f,
  2.22209860e-02f, 9.20279790e-03f, 6.00830577e-02f, 8.79971012e-02f, 6.67110309e-02f, 9.23894942e-02f, -3.94153781e-02f, 6.59743473e-02f, -4.56288271e-02f, 8.52542669e-02f,
  -3.51386815e-02f, -6.97414130e-02f, 1.32514965e-02f, -6.96921628e-03f, 4.05782498e-02f, -6.18749931e-02f, -1.17475472e-01f, -6.52007610e-02f, -3.29569206e-02f, 1.72420889e-02f,
  -6.13920651e-02f, -1.12759367e-01f, 2.44103558e-02f, -4.05921675e-02f, 4.10251804e-02f, -6.16968162e-02f, -5.59105650e-02f, -5.17076179e-02f, 8.41301158e-02f, 8.79276097e-02f,
  -5.13764843e-02f, 5.83623908e-02f, -5.78738190e-02f, -6.50559515e-02f, -7.29095712e-02f, 1.97105575e-02f, 2.65918169e-02f, 3.33402702e-03f, -1.00122467e-01f, 1.85708813e-02f,
  -4.33072336e-02f, -1.03595734e-01f, -1.36115804e-01f, -8.53672624e-02f, 1.44883851e-02f, -7.68367127e-02f, -7.88683370e-02f, -6.78920224e-02f, -7.95760453e-02f, 3.12548550e-03f,
  -9.39463302e-02f, 6.51093125e-02f, 3.17692123e-02f, 3.46396603e-02f, 2.13368912e-03f, 3.39473560e-02f, -2.24478319e-02f, 8.08389857e-02f, 6.71170056e-02f, 4.52668518e-02f,
  -5.65307029e-02f, -8.76346976e-02f, -5.60758561e-02f, 4.46402952e-02f, 2.00082622e-02f, 1.71571765e-02f, 3.37897800e-02f, 3.58610712e-02f, -4.37655039e-02f, -1.17257219e-02f,
  -8.33746418e-02f, 4.65605184e-02f, -1.06469616e-01f, 7.16238841e-02f, -9.60607082e-04f, -2.69424114e-02f, -4.01752330e-02f, 8.28536451e-02f, -3.48549113e-02f, 2.33233757e-02f,
  4.22266237e-02f, 6.33145720e-02f, 4.88473214e-02f, -3.59747969e-02f, 3.33260037e-02f, -3.79962195e-03f, 3.34668569e-02f, -1.92851704e-02f, 3.14066336e-02f, 7.77013823e-02f,
  3.80454361e-02f, -3.32144797e-02f, 8.17214772e-02f, 7.91568030e-03f, 2.62074918e-02f, 8.28495398e-02f, 2.19227821e-02f, 7.69785419e-02f, -2.10812800e-02f, -4.10057344e-02f,
  4.34760051e-03f, -1.43788261e-02f, 2.57433578e-02f, 2.78771427e-02f, -7.31377453e-02f, 3.91766131e-02f, 1.20489765e-02f, -4.00399640e-02f, 7.23363757e-02f, 4.66512963e-02f,
  1.35708123e-01f, 7.13159293e-02f, -2.02244297e-01f, 8.67723897e-02f, -1.40054718e-01f, -1.62764713e-01f, -1.84108857e-02f, 8.24281946e-02f, -2.46137958e-02f, 4.57381783e-03f,
  -1.01768933e-01f, -7.81113207e-02f, -1.39774516e-01f, -5.43256029e-02f, -1.12587750e-01f, 3.33279893e-02f, 2.15360411e-02f, 1.59131140e-02f, -1.48074716e-01f, -1.15480572e-02f,
  -9.86540541e-02f, 5.09636551e-02f, 8.28251764e-02f, 1.80213973e-02f, -5.74058667e-03f, -1.30635992e-01f, -7.27093816e-02f, -5.11250235e-02f, -1.49802282e-01f, -1.49749219e-01f,
  -1.74650401e-01f, -8.53639543e-02f, -1.16729373e-02f, -2.35095490e-02f, -1.26191974e-01f, 3.78245637e-02f, -4.47481386e-02f, -1.20620146e-01f, -1.12237245e-01f, 1.09673222e-03f,
  -1.13779396e-01f, -4.79255468e-02f, 2.11514463e-03f, -4.93003763e-02f, -4.24366109e-02f, -7.23017082e-02f, 9.76133123e-02f, 4.74507064e-02f, 3.84984612e-02f, -3.39129902e-02f,
  -1.93430968e-02f, -4.81882319e-02f, -5.88770844e-02f, 4.94171418e-02f, -8.83726701e-02f, -2.88528539e-02f, 1.66818686e-02f, -1.02565274e-01f, 3.99623960e-02f, 2.27589738e-02f,
  -9.71614271e-02f, -1.12882890e-01f, 3.92017923e-02f, 9.69272107e-02f, 7.75204077e-02f, 9.73024871e-03f, 4.62821051e-02f, 5.41032068e-02f, -6.85524940e-02f, -3.41854356e-02f,
  6.84371218e-02f, 2.33714730e-02f, 3.33558507e-02f, 6.78193197e-02f, 4.07087095e-02f, 6.68832660e-02f, -3.36198919e-02f, 7.75676891e-02f, 3.59947644e-02f, -1.06172524e-02f,
  -9.17503890e-03f, -7.00513646e-02f, 1.89860836e-02f, -4.76104282e-02f, 1.40090836e-02f, -4.66747619e-02f, 4.96741161e-02f, -5.10331914e-02f, -2.62716431e-02f, -4.13910970e-02f,
  1.55347869e-01f, -1.14719920e-01f, -4.14566174e-02f, -5.58428019e-02f, -3.45274210e-02f, -8.35935175e-02f, -4.33601961e-02f, 6.24406561e-02f, -7.90872127e-02f, -7.64095783e-02f,
  -1.49465382e-01f, 3.46939974e-02f, -1.31140614e-03f, -4.82737161e-02f, 6.11917675e-02f, -9.42979306e-02f, 1.50964350e-01f, -7.48928711e-02f, -5.52144386e-02f, 7.16530113e-03f,
  3.88862602e-02f, 6.56718314e-02f, 1.14059038e-01f, -1.60332881e-02f, 2.88948305e-02f, 6.63159192e-02f, -1.70010850e-02f, -1.80410035e-02f, -5.96722700e-02f, 2.12152049e-01f,
  3.43006551e-01f, 2.23799963e-02f, 1.89699411e-01f, 2.06759050e-01f, 2.65891522e-01f, 3.29884797e-01f, 3.55894327e-01f, 1.61266327e-01f, 6.57790750e-02f, 1.59293249e-01f,
  -7.83304051e-02f, -6.12671524e-02f, -7.10590929e-02f, -8.26504081e-02f, 3.13901007e-02f, 8.72924998e-02f, 6.31892830e-02f, 1.52245685e-01f, 2.08763674e-01f, 1.70652419e-01f,
  -1.01891998e-02f, 1.45509511e-01f, 4.95884493e-02f, 4.12071273e-02f, 3.02697122e-02f, -2.32674461e-02f, 9.90897492e-02f, 9.64275151e-02f, -5.08885235e-02f, -1.07065566e-01f,
  -1.93033472e-01f, 1.85439810e-01f, 1.17028560e-02f, -1.53857812e-01f, -2.18425635e-02f, 3.48307379e-02f, 1.61642786e-02f, 3.02827526e-02f, 1.12788519e-02f, -4.52343151e-02f,
  -1.23314984e-01f, 4.23429869e-02f, -2.11911444e-02f, 2.83802394e-02f, 1.05932847e-01f, 5.63750509e-03f, -3.93777974e-02f, 4.86403257e-02f, 4.10057418e-02f, 1.88836902e-02f,
  -1.62357479e-01f, 2.80061830e-02f, 1.14662483e-01f, 1.24764591e-01f, 3.02462559e-02f, -3.36594321e-02f, -2.55769137e-02f, 4.31101546e-02f, 1.03072271e-01f, -3.63790654e-02f,
  -1.75223555e-02f, -9.63367149e-03f, 1.51202260e-02f, -8.32411461e-03f, -1.86493136e-02f, 7.02290311e-02f, -5.16845323e-02f, -1.43167656e-02f, -2.08454281e-02f, -4.12724428e-02f,
  7.83494581e-03f, 4.78229579e-03f, -4.89999838e-02f, -9.75376740e-03f, 2.59442795e-02f, -5.18652983e-02f, 3.85711435e-03f, 3.35834697e-02f, -6.25895802e-03f, 2.25673802e-02f,
  6.46617487e-02f, 9.57805440e-02f, 2.79326420e-02f, 3.69036607e-02f, -3.17428530e-05f, 2.97293868e-02f, -1.15261152e-01f, 4.19437233e-03f, 6.78675473e-02f, 1.22938687e-02f,
  -1.70185983e-01f, -3.65234800e-02f, -1.09138027e-01f, -3.37007754e-02f, 3.81345935e-02f, -8.42708200e-02f, -8.34569857e-02f, -1.27951622e-01f, 4.42660116e-02f, -5.02531864e-02f,
  3.28391232e-02f, -1.10853590e-01f, 1.31158140e-02f, -1.28425807e-02f, 1.17268652e-01f, 5.76592982e-02f, -1.14942268e-01f, -8.33297335e-03f, -1.04181215e-01f, -6.09569103e-02f,
  -9.88163427e-02f, 1.07972480e-01f, 8.82144719e-02f, 1.11697368e-01f, 9.90915112e-03f, 2.62648594e-02f, 5.67050837e-02f, 9.06488672e-02f, 6.72179321e-03f, 4.18609120e-02f,
  -3.28978628e-01f, -2.27407459e-02f, -1.77963138e-01f, -2.55810797e-01f, 1.55877415e-02f, 1.00422710e-01f, 1.89918324e-01f, 1.05773754e-01f, -5.30043319e-02f, -4.45866324e-02f,
  1.21807873e-01f, -3.98894325e-02f, -5.19630313e-02f, -8.49598050e-02f, -3.17856483e-02f, 3.89414430e-02f, -1.04863204e-01f, -1.93268239e-01f, 7.22762495e-02f, 1.17496230e-01f,
  -7.42633687e-03f, -1.59692451e-01f, -1.24795936e-01f, -7.01571926e-02f, -7.94994384e-02f, -1.60375670e-01f, -1.67873114e-01f, -1.01416565e-01f, 9.95535851e-02f, -1.57072052e-01f,
  -4.58147228e-02f, 4.26598415e-02f, 5.97512163e-03f, -7.22307935e-02f, 6.08201846e-02f, -5.09814769e-02f, -9.42371902e-04f, 1.09860552e-02f, -5.95611185e-02f, -7.94218481e-03f,
  -7.30543733e-02f, -5.65649243e-03f, 1.34854382e-02f, -5.66515513e-03f, -1.48624298e-03f, -7.14191720e-02f, -2.01861584e-03f, -7.59541616e-02f, 7.14935809e-02f, 7.35100359e-02f,
  1.16623424e-01f, -5.07047251e-02f, -9.34020951e-02f, 6.85492679e-02f, 3.97205986e-02f, 2.01817341e-02f, 1.00837238e-01f, -3.17290574e-02f, -2.04036292e-02f, -5.90733066e-02f,
  -1.59659628e-02f, 5.94635308e-02f, 3.14828008e-02f, -5.33588231e-02f, 3.95658128e-02f, 6.06618375e-02f, 2.77042319e-03f, 7.49398675e-03f, 5.68902455e-02f, -4.26095165e-03f,
  -4.25966978e-02f, 1.00588679e-01f, -2.61716489e-02f, -2.88335364e-02f, -6.67458307e-03f, -4.61015627e-02f, 8.56809691e-03f, 3.26906741e-02f, -1.03611723e-02f, -7.66589046e-02f,
  3.59790958e-02f, 8.00071508e-02f, -7.28074089e-02f, 5.61592821e-03f, 4.65941355e-02f, 3.29142101e-02f, 5.50507121e-02f, -1.95466764e-02f, -3.87816573e-03f, 3.34710851e-02f,
  -1.68967530e-01f, 2.73020118e-02f, -1.10603824e-01f, -8.81271716e-03f, -4.56522331e-02f, 9.35689360e-02f, 2.76715811e-02f, -4.25261594e-02f, -2.82164551e-02f, 5.04480749e-02f,
  3.06900814e-02f, 5.82075194e-02f, -4.23619673e-02f, 6.00936599e-02f, 7.25138653e-03f, -2.99933888e-02f, 3.59755754e-02f, -1.24925792e-01f, -7.49801612e-03f, 5.07977307e-02f,
  1.11459732e-01f, 4.95821377e-03f, -1.07649967e-01f, -1.01185381e-01f, -8.48935451e-03f, -9.57060605e-02f, -6.75528571e-02f, -2.90907118e-02f, -1.13824703e-01f, -1.46319985e-01f,
  -1.68466285e-01f, -8.39498118e-02f, 5.86741194e-02f, -5.78134544e-02f, 5.19436747e-02f, 1.97075531e-02f, -7.40184113e-02f, 6.37395978e-02f, 1.60873160e-02f, -5.74632734e-02f,
  2.94083524e-02f, -1.13597013e-01f, -8.57118443e-02f, -5.58470339e-02f, -5.64184822e-02f, -7.11618736e-02f, 4.42059524e-02f, -1.46724675e-02f, -4.87770550e-02f, 6.43637180e-02f,
  6.73496816e-03f, -5.03932647e-02f, 2.27567945e-02f, 7.32664019e-02f, -2.83207744e-02f, 9.72187519e-02f, -2.74902303e-02f, -5.47495931e-02f, -2.34180037e-02f, -1.00574903e-01f,
  -1.13273866e-01f, -5.19639030e-02f, 1.69159453e-02f, -1.06546832e-02f, -5.78596890e-02f, 2.68792771e-02f, -1.06822886e-02f, -1.56818330e-02f, -7.26749748e-02f, -8.21907073e-02f,
  -1.00677840e-01f, 3.81853580e-02f, -1.53139941e-02f, -3.90815251e-02f, 1.52726462e-02f, 3.23008485e-02f, -4.56784703e-02f, 8.05980489e-02f, 2.46024989e-02f, -7.13208737e-03f,
  9.30162370e-02f, 6.61640018e-02f, -3.07223350e-02f, -3.79832983e-02f, -1.22261029e-02f, -5.34760859e-03f, 7.40693063e-02f, -2.95396615e-02f, 1.08631765e-02f, 9.87228528e-02f,
  1.78344809e-02f, 7.97437225e-03f, -2.94670034e-02f, 7.06522688e-02f, -1.46054253e-02f, -9.01277214e-02f, -7.63422921e-02f, -3.26767825e-02f, -4.40544151e-02f, 5.83536066e-02f,
  -3.21496129e-02f, 3.31546180e-02f, 1.02402521e-02f, -3.65202166e-02f, -2.97080353e-03f, 5.23752347e-02f, -1.41792977e-02f, 9.61157531e-02f, 9.89657566e-02f, -6.15724362e-02f,
  -1.01316825e-01f, -4.03610989e-02f, -2.95586009e-02f, -2.84000430e-02f, -6.43865988e-02f, -9.70957335e-03f, -5.68208247e-02f, -4.91409265e-02f, 6.33880571e-02f, -8.23669806e-02f,
  5.79029247e-02f, -5.63403107e-02f, -7.29115456e-02f, -8.20208192e-02f, -2.29093293e-03f, 8.32404941e-02f, 2.48365607e-02f, 3.35700363e-02f, -4.90865111e-02f, -1.56615768e-02f,
  -3.18727195e-02f, -8.71342570e-02f, 1.15227094e-03f, 8.03636685e-02f, -5.07641323e-02f, -3.55993547e-02f, 2.39079557e-02f, 3.91660258e-02f, -4.99925064e-03f, 7.57993460e-02f,
  1.64660700e-02f, -1.14391163e-01f, -1.46727622e-01f, -1.06771402e-01f, -9.75986794e-02f, -6.52916431e-02f, 5.29522151e-02f, -9.99681950e-02f, 4.15820740e-02f, 4.35395129e-02f,
  -1.36948630e-01f, 4.60407324e-02f, 1.88961532e-02f, 2.94886939e-02f, 7.14942291e-02f, -5.94017915e-02f, -1.14662088e-01f, -6.41365498e-02f, -5.44918526e-04f, -4.76712883e-02f,
  -4.81697395e-02f, -6.54257881e-03f, 4.33811024e-02f, 7.37139136e-02f, 1.48101952e-02f, 4.16820012e-02f, 1.62752017e-01f, 1.02698155e-01f, -7.35685527e-02f, 6.56478927e-02f,
  4.87637259e-02f, 5.11543304e-02f, -7.31397569e-02f, 8.53405520e-03f, 1.52115196e-01f, -6.55208007e-02f, 9.17098671e-02f, -4.23070937e-02f, 6.90921268e-04f, 2.06400514e-01f,
  -1.44501133e-02f, -1.73828043e-02f, 3.18940310e-03f, 7.17277005e-02f, 8.94347504e-02f, -7.78134093e-02f, -7.14315698e-02f, 1.70883220e-02f, 7.80200809e-02f, 8.62568617e-02f,
  1.06676370e-01f, 9.74349901e-02f, 4.74388525e-02f, 5.63842170e-02f, 3.81055921e-02f, 1.46423122e-02f, 6.71214983e-02f, -4.49089333e-02f, 7.45986849e-02f, -6.00690432e-02f,
  8.27424675e-02f, -3.14401910e-02f, -1.31076455e-01f, -6.66830242e-02f, -1.71257574e-02f, -2.12906599e-02f, -1.30595431e-01f, 2.20334306e-02f, -4.92882123e-03f, -9.17366147e-02f,
  -6.74855113e-02f, 8.09130743e-02f, 3.33703980e-02f, 8.90974235e-03f, -7.77994543e-02f, -5.75697161e-02f, -4.98250797e-02f, 8.91234074e-03f, -8.44313055e-02f, -4.79706638e-02f,
  -3.48405018e-02f, 1.39542185e-02f, -7.89989233e-02f, 2.53276713e-02f, -9.97433662e-02f, -9.63235274e-03f, -6.29970059e-02f, -1.02233915e-02f, 1.64318252e-02f, -5.66107035e-02f,
  6.77452013e-02f, -6.58364519e-02f, 1.11105188e-03f, 6.58397302e-02f, -3.18087153e-02f, 9.66361631e-03f, -7.06904009e-02f, -8.48623365e-02f, -7.00311586e-02f, 5.43362163e-02f,
  2.33320706e-02f, -1.30072221e-01f, 9.97989401e-02f, 9.99775603e-02f, 1.30686145e-02f, 1.10765863e-02f, -5.02232537e-02f, 2.31738966e-02f, 7.53700687e-03f, -4.47544940e-02f,
  -6.44282848e-02f, 1.87810441e-03f, -5.39106280e-02f, 1.02608711e-01f, -3.03534735e-02f, 7.91841522e-02f, 3.97398919e-02f, 6.51728883e-02f, 6.57881051e-02f, 9.53897610e-02f,
  8.00496116e-02f, -7.19417678e-03f, -2.53940932e-02f, -7.31541663e-02f, -4.17684354e-02f, -9.85067338e-02f, -3.43061350e-02f, 3.69037278e-02f, -1.30412281e-01f, -1.01547927e-01f,
  4.49670479e-02f, -1.19537488e-01f, -1.89433798e-01f, -6.46707788e-02f, -2.43567210e-02f, 5.79602942e-02f, -5.28552718e-02f, 6.18021525e-02f, 1.09735793e-02f, -1.26228094e-01f,
  2.11010538e-02f, -6.42459234e-03f, 4.65906411e-03f, -1.98585466e-02f, 7.13278353e-02f, -1.64922237e-01f, -2.44803920e-01f, -1.25661865e-01f, 6.44282699e-02f, 7.84645602e-02f,
  -1.94353107e-02f, -5.55407032e-02f, 1.47359781e-02f, 4.46674265e-02f, 1.56705063e-02f, -5.01060821e-02f, -1.00631639e-01f, 3.91573226e-03f, -9.32266563e-02f, -2.59736776e-01f,
  -1.13127731e-01f, 5.03604524e-02f, -3.36542092e-02f, -2.76148468e-02f, -1.06456332e-01f, 2.85647567e-02f, -6.66776150e-02f, 9.46605299e-03f, 3.80218439e-02f, -9.08812881e-02f,
  -7.61579424e-02f, 9.59761515e-02f, 8.04532617e-02f, 1.50940325e-02f, -3.09676561e-03f, 3.54631692e-02f, -4.99752425e-02f, 6.67460188e-02f, 8.90172459e-03f, -2.87387371e-02f,
  4.40925471e-02f, -9.50327739e-02f, -4.81890738e-02f, 3.37930908e-03f, -4.15848903e-02f, -1.19521096e-02f, 8.36992189e-02f, 3.98626439e-02f, 2.08712164e-02f, -2.92238034e-02f,
  -4.18368652e-02f, -3.32640260e-02f, -9.08881649e-02f, -2.10493784e-02f, -1.88525151e-02f, -2.45920606e-02f, -4.40751575e-03f, -8.14120620e-02f, -3.91911753e-02f, 9.56215709e-03f,
  -3.98190506e-02f, 2.18486823e-02f, 1.12936862e-01f, -4.92473133e-02f, -1.48119092e-01f, -3.70725133e-02f, -9.15358067e-02f, -7.27107301e-02f, -8.73215050e-02f, 3.32018323e-02f,
  -5.38707562e-02f, -9.24203694e-02f, 4.88263136e-03f, 3.15000229e-02f, -1.02720462e-01f, -5.13884518e-03f, 6.61222711e-02f, -1.50527358e-02f, -2.93642399e-03f, -7.82066211e-02f,
  -2.74405070e-02f, -2.33494602e-02f, -2.00691782e-02f, 7.81799257e-02f, 8.71717837e-03f, -4.12418693e-02f, -6.01881072e-02f, 2.03229003e-02f, -8.14623609e-02f, 5.81762753e-02f,
  1.91352516e-02f, -5.33767454e-02f, -2.31604706e-02f, 8.88833031e-02f, 6.64768815e-02f, -2.46474463e-02f, -1.17399931e-01f, -1.82949286e-03f, 3.85189652e-02f, -2.72624046e-02f,
  -1.24966472e-01f, -1.10692292e-01f, 5.20474873e-02f, -2.78594382e-02f, 8.20621923e-02f, 4.40613441e-02f, -1.34653784e-02f, 1.18773304e-01f, -3.82139124e-02f, 1.53324781e-02f,
  -1.13516115e-01f, -1.26497835e-01f, -1.50083788e-02f, -4.33522873e-02f, 7.60234669e-02f, -7.12512657e-02f, -2.04753146e-01f, 5.44787720e-02f, 5.46959229e-02f, -1.48648784e-01f,
  5.06148860e-02f, -7.63996840e-02f, 1.71403456e-02f, -1.64778680e-02f, -2.11573899e-01f, -2.00593889e-01f, -2.10172787e-01f, -8.07658732e-02f, -9.43247750e-02f, -6.12167083e-02f,
  -6.19856268e-02f, -1.10523649e-01f, -5.28551638e-02f, 1.09851606e-01f, 7.79780224e-02f, -9.02968366e-03f, -7.63900056e-02f, -7.78077841e-02f, 7.62164965e-02f, -4.59445380e-02f,
  -2.32979000e-01f, 7.23161399e-02f, -6.16520755e-02f, -2.92421300e-02f, -4.52159680e-02f, 3.49551030e-02f, -8.59400257e-02f, 6.66923588e-03f, -5.15015097e-03f, -5.81390299e-02f,
  2.16808207e-02f, -5.84025942e-02f, 7.70061836e-02f, 3.80867114e-03f, 4.18352522e-02f, -2.59755068e-02f, 1.15318418e-01f, 1.15604326e-02f, 8.14750567e-02f, 1.14104688e-01f,
  1.44662410e-02f, 7.41325095e-02f, 4.61923033e-02f, -3.69349755e-02f, -2.87466478e-02f, 7.96422809e-02f, 9.99947935e-02f, 1.73466802e-01f, 1.29248351e-02f, 1.19116660e-02f,
  -2.18503233e-02f, 1.73923117e-03f, 1.89795550e-02f, -5.87289706e-02f, 1.84751563e-02f, 9.65340063e-02f, -4.92905751e-02f, 3.09028532e-02f, -2.65425276e-02f, 5.60683385e-02f,
  -3.42555679e-02f, -7.06726536e-02f, 4.88107977e-03f, 3.59747373e-02f, 5.19579463e-02f, 8.08415785e-02f, -5.67484163e-02f, -5.92644662e-02f, -4.56748493e-02f, 6.52245581e-02f,
  1.03768213e-02f, 5.62971979e-02f, 1.05313174e-01f, 1.22253429e-02f, -5.24707362e-02f, 3.06267645e-02f, -1.47075090e-03f, -5.12986779e-02f, 8.71923193e-02f, 5.64696006e-02f,
  -1.97491627e-02f, -9.45325196e-02f, -1.81739628e-01f, -4.19480875e-02f, 8.19177553e-02f, -2.65986733e-02f, 7.62721971e-02f, 3.48057896e-02f, 5.69076091e-02f, -1.06992193e-01f,
  5.97382635e-02f, 1.03152618e-02f, -4.36676368e-02f, 5.35699597e-04f, -7.57966638e-02f, 2.54605711e-02f, 8.39642510e-02f, 7.78561383e-02f, -5.80259832e-03f, 6.56275973e-02f,
  1.94167010e-02f, 3.08767986e-02f, -1.41445011e-01f, -2.89962739e-02f, 7.59945810e-02f, -9.14782062e-02f, -9.56706703e-02f, -1.61226057e-02f, -4.76955473e-02f, -1.32177770e-01f,
  1.22426286e-01f, 1.88430259e-03f, -7.08101764e-02f, 5.52562624e-02f, 5.14836647e-02f, 4.93055992e-02f, -1.02182301e-02f, 2.29267254e-02f, 7.01408088e-02f, -3.23373359e-04f,
  1.22025296e-01f, -4.33191881e-02f, -2.99358200e-02f, 7.80697837e-02f, -3.50883268e-02f, -5.09176627e-02f, -1.31201938e-01f, -9.62322429e-02f, 3.30694914e-02f, 3.68163697e-02f,
  -2.03692876e-02f, -9.49255824e-02f, 2.80445702e-02f, -8.27426985e-02f, -1.17423022e-02f, 5.70317544e-03f, 2.23061685e-02f, 6.68998109e-04f, 5.58058210e-02f, -6.84080794e-02f,
  -4.46300907e-03f, 1.54418334e-01f, 7.12290704e-02f, 2.59463750e-02f, -4.64033196e-03f, 7.72131607e-02f, 1.15663223e-01f, 4.15369906e-02f, 9.23737697e-03f, 3.26182656e-02f,
  -2.80970335e-02f, -5.18341437e-02f, 6.66872934e-02f, 2.65151579e-02f, -8.13882425e-02f, -5.28143309e-02f, 4.28303331e-03f, -8.87625292e-03f, -6.34632111e-02f, -7.73779536e-03f,
  -8.43267217e-02f, -4.33688574e-02f, 1.01987824e-01f, 6.24213892e-04f, -4.53486890e-02f, 4.62580398e-02f, -7.05341101e-02f, 1.56657919e-02f, -3.71552035e-02f, -6.75464720e-02f,
  -9.10112038e-02f, -5.63271763e-03f, -8.61679465e-02f, -4.61996160e-03f, -6.68919161e-02f, -2.75306217e-02f, 5.74408323e-02f, 7.43144471e-03f, 1.43331066e-02f, -8.63627642e-02f,
  -3.99672017e-02f, 6.46578148e-02f, -4.72304672e-02f, -2.79611954e-03f, 6.37293011e-02f, 1.12006739e-02f, -7.50012184e-03f, 1.76268779e-02f, -1.35338295e-03f, -9.00419801e-03f,
  -2.23800857e-02f, -6.83399960e-02f, -9.68403742e-02f, -1.37010431e-02f, -9.39372405e-02f, -8.95065069e-03f, -4.96465247e-03f, -2.71719825e-02f, -5.99985709e-03f, -6.61483556e-02f,
  -9.85884890e-02f, 1.58052966e-01f, 2.41019130e-02f, -7.82506689e-02f, 5.58868386e-02f, -6.85461462e-02f, 9.66929272e-02f, -5.27083650e-02f, 8.21954012e-02f, 2.10939557e-03f,
  1.47847002e-02f, 1.24595035e-02f, 3.72765469e-03f, -8.27489644e-02f, 8.76784772e-02f, 5.97316399e-03f, -4.51469095e-03f, 5.12693748e-02f, -7.18221515e-02f, 2.97504701e-02f,
  -9.41656604e-02f, 2.47630980e-02f, -3.26389191e-03f, -9.64749455e-02f, -7.96842482e-03f, 5.25682159e-02f, -8.39966908e-02f, 1.68990530e-02f, -7.81854708e-03f, -1.36473412e-02f,
  3.49447168e-02f, 1.87133268e-01f, 1.11050062e-01f, -4.54606153e-02f, -9.84220020e-03f, 1.66072249e-02f, 3.80630642e-02f, -7.88298398e-02f, -1.16046714e-02f, 1.00902297e-01f,
  1.24215029e-01f, 1.87413525e-02f, -9.20560285e-02f, -3.77553552e-02f, 9.61703155e-03f, 6.79877847e-02f, -6.89524636e-02f, -1.58065110e-01f, -3.88879627e-02f, -2.64625605e-02f,
  1.50054516e-02f, -6.43975735e-02f, -7.33609572e-02f, -1.08241074e-01f, 9.75985304e-02f, -6.80391630e-03f, 4.07116534e-03f, -7.03747422e-02f, -6.60457611e-02f, 1.19685642e-02f,
  2.06849109e-02f, 1.12420090e-01f, -1.05259396e-01f, -7.34084174e-02f, 7.69793466e-02f, -1.12639897e-01f, -1.39514059e-02f, -2.51655541e-02f, -3.06397360e-02f, -2.39869077e-02f,
  -6.81555048e-02f, 5.97110428e-02f, 7.24580064e-02f, -8.94734636e-03f, -7.34018236e-02f, -1.06001541e-01f, 2.93174572e-02f, -1.58376638e-02f, -8.40384662e-02f, 6.29894733e-02f,
  -5.61971776e-02f, -4.49770726e-02f, 5.92829771e-02f, 5.82255982e-02f, -1.65155176e-02f, -1.05229747e-02f, 3.10467510e-03f, -8.00465867e-02f, -8.13534036e-02f, 4.31066714e-02f,
  -4.44200560e-02f, -6.58657104e-02f, -3.14040855e-02f, -1.11011984e-02f, -5.37329502e-02f, -1.23642860e-02f, -3.85112055e-02f, -9.72670913e-02f, -1.99321602e-02f, -7.27446303e-02f,
  -7.79973948e-03f, -5.35225961e-03f, 3.92157733e-02f, 2.81827040e-02f, -4.78406325e-02f, 1.07306112e-02f, 4.60321084e-02f, -7.83228278e-02f, 3.42222489e-02f, -1.55905746e-02f,
  -6.16030581e-02f, 2.64750086e-02f, 4.48114015e-02f, 3.82807888e-02f, 3.66246165e-03f, 2.58520991e-03f, 5.87642491e-02f, -7.65423104e-02f, 5.74612916e-02f, -7.66744316e-02f,
  -1.59883529e-01f, -6.47520199e-02f, -9.03768092e-03f, 1.01441070e-02f, 7.25676194e-02f, -8.69128481e-02f, 3.45310606e-02f, -5.28782941e-02f, 3.07275876e-02f, 1.28317252e-02f,
  -5.27917920e-03f, 2.37284992e-02f, -4.62932624e-02f, -7.61374831e-02f, -5.59596978e-02f, 2.74452511e-02f, -1.06707208e-01f, -1.36322245e-01f, -1.06390320e-01f, 1.73236054e-04f,
  -4.46839742e-02f, -1.15066297e-01f, -6.21876270e-02f, -9.06023905e-02f, 6.22705035e-02f, -3.89831141e-02f, -5.26628196e-02f, -5.65064363e-02f, 1.53207071e-02f, -1.02398098e-01f,
  2.77969949e-02f, -3.37568484e-02f, -2.31853679e-01f, -1.10100903e-01f, 3.04782740e-03f, -5.75394602e-04f, -1.67296659e-02f, 3.23153809e-02f, -2.67228689e-02f, -1.36703074e-01f,
  -8.58606100e-02f, -7.28071406e-02f, -1.04540614e-02f, -6.87297806e-02f, -5.84340915e-02f, -3.66166085e-02f, -1.72899365e-01f, -1.22017730e-02f, 2.95368247e-02f, 1.31213451e-02f,
  9.83096845e-03f, -9.83367786e-02f, -1.85185149e-02f, 5.91498427e-02f, -1.25123328e-02f, -1.21946953e-01f, -1.79434776e-01f, -5.19862771e-02f, -9.05677006e-02f, -1.81746185e-01f,
  -1.24640234e-01f, 8.13524500e-02f, -2.12214608e-03f, 8.85352492e-02f, -4.07068431e-02f, 7.96649083e-02f, 7.17005655e-02f, 3.07765156e-02f, -4.79055122e-02f, -7.94594288e-02f,
  -4.84411512e-03f, 5.79998419e-02f, -8.50965157e-02f, -2.18727980e-02f, -9.25141294e-03f, 8.24321285e-02f, 4.47642356e-02f, 6.52466528e-03f, -3.87213305e-02f, 1.23355966e-02f,
  -2.55528279e-02f, 2.47457456e-02f, 1.84343755e-02f, 1.25366047e-01f, 2.31762119e-02f, 6.67496845e-02f, 7.47715384e-02f, 5.08397929e-02f, -4.62969057e-02f, 2.88056433e-02f,
  3.33096422e-02f, -5.55791371e-02f, 3.51260267e-02f, 3.72980759e-02f, 1.07871212e-01f, -3.76426391e-02f, -1.12067966e-04f, 5.74953817e-02f, 1.15182670e-02f, 1.81428418e-02f,
  -2.37155128e-02f, -5.48905768e-02f, 5.97489662e-02f, -5.91398105e-02f, -3.21701355e-02f, 5.84162064e-02f, -5.53192273e-02f, 1.18600102e-02f, 4.70477976e-02f, 6.01872504e-02f,
  -8.26585013e-03f, 8.87419283e-02f, -1.10528655e-01f, -3.96053791e-02f, 2.45257225e-02f, -2.42424347e-02f, -7.18719214e-02f, -1.85329914e-02f, -2.47750059e-02f, 7.38260522e-02f,
  -1.42898664e-01f, -8.90234485e-03f, -7.30298534e-02f, -2.55907569e-02f, -5.74180931e-02f, 9.80734453e-02f, 7.13851452e-02f, 2.44127810e-02f, 2.26527322e-02f, -3.83345559e-02f,
  5.31747602e-02f, 2.81329490e-02f, 1.07775526e-02f, 7.07718432e-02f, 2.93084737e-02f, 6.14318177e-02f, 8.58278275e-02f, -7.44564682e-02f, -5.99850677e-02f, -2.18930990e-02f,
  8.22618455e-02f, 1.54727474e-02f, 7.49034733e-02f, 6.53422549e-02f, -4.07014042e-02f, 3.15394402e-02f, 3.60283293e-02f, -8.15180764e-02f, -7.72171468e-02f, -5.00615984e-02f,
  2.55512130e-02f, -9.56406444e-02f, -1.97673038e-01f, 1.71381220e-01f, -6.43331185e-02f, 3.46778147e-02f, -1.59901202e-01f, 3.30631761e-03f, 1.66476995e-01f, -5.47327520e-03f,
  -1.24104824e-02f, 7.72207081e-02f, -2.75064707e-02f, -6.00201935e-02f, -2.30600294e-02f, -2.20238701e-01f, -1.39735669e-01f, 4.66673030e-03f, 7.71197677e-02f, 9.57916901e-02f,
  -2.23434567e-02f, 7.84823820e-02f, 3.45354788e-02f, 3.29697458e-03f, -7.32369721e-02f, 4.29203548e-02f, 3.98935564e-02f, -6.71960637e-02f, -2.15611290e-02f, -1.74282804e-01f,
  -8.65760148e-02f, -8.95984191e-03f, -8.24680552e-02f, 3.83243598e-02f, -5.36660552e-02f, 6.18940704e-02f, -8.25213790e-02f, 6.87451735e-02f, -2.80677434e-02f, -3.02770883e-02f,
  -1.13242250e-02f, -5.69430888e-02f, 1.13661967e-01f, 5.71185835e-02f, 6.34347945e-02f, -2.73042526e-02f, -5.77795058e-02f, -3.48724611e-02f, -1.15159256e-02f, -7.82930627e-02f,
  -9.92299523e-04f, -2.78720986e-02f, -6.25334606e-02f, 1.34384669e-02f, -3.17201391e-02f, -4.55922373e-02f, 3.28009799e-02f, -7.57245496e-02f, -2.55446858e-03f, -3.21131423e-02f,
  2.75678448e-02f, -8.79190862e-02f, -5.61959483e-03f, 4.34332229e-02f, -1.58032554e-03f, -4.91328910e-02f, -9.09146741e-02f, 3.21956463e-02f, 4.60274518e-02f, 6.13047108e-02f,
  4.09741364e-02f, -2.87314393e-02f, -3.09211332e-02f, 2.56990530e-02f, 4.23904918e-02f, -6.24251254e-02f, -7.21698925e-02f, 9.00468882e-03f, 4.11177836e-02f, -6.42843544e-02f,
  5.94280064e-02f, 3.49531174e-02f, -2.24999599e-02f, -2.10068226e-02f, -5.98295629e-02f, -1.38777075e-03f, 1.68641619e-02f, 5.55473976e-02f, -4.78204340e-02f, 6.28807470e-02f,
  1.04772165e-01f, -1.10130757e-01f, 2.14138739e-02f, -3.94667313e-02f, -3.07603623e-03f, 6.56222329e-02f, -2.52933078e-03f, 6.13876209e-02f, -8.67942497e-02f, -6.74857125e-02f,
  -5.85637568e-03f, 5.42680174e-03f, 4.17741053e-02f, -1.81916691e-02f, 2.17015464e-02f, 5.25351614e-02f, 5.98028563e-02f, -8.77479166e-02f, -3.24445702e-02f, -2.29907501e-02f,
  -3.39741074e-02f, -5.67049049e-02f, 8.58296547e-03f, -7.78822899e-02f, 6.58039972e-02f, -8.15977380e-02f, -1.58239380e-01f, -1.31577909e-01f, -4.78851469e-03f, -5.53279333e-02f,
  -3.43800873e-01f, -4.62010130e-02f, -3.00584664e-03f, -8.48793089e-02f, -6.14101961e-02f, -1.28609851e-01f, -9.65217799e-02f, 4.95491363e-03f, 4.27755564e-02f, -6.64800256e-02f,
  -8.69637132e-02f, -8.93395301e-03f, -1.44675430e-02f, -8.32756888e-03f, -3.34131457e-02f, -1.18090510e-01f, -2.33592927e-01f, -4.03000489e-02f, -1.28440738e-01f, 5.98704778e-02f,
  -1.24642842e-01f, -1.57117754e-01f, -9.75971818e-02f, 1.35384426e-02f, 1.04149818e-01f, 1.76086470e-01f, 9.37012583e-02f, 3.52475531e-02f, -4.41301428e-02f, -8.55871513e-02f,
  3.69747505e-02f, -5.34887500e-02f, -1.69553850e-02f, -1.04018629e-01f, 4.64974716e-02f, 2.96629108e-02f, -6.17221976e-03f, -2.38859709e-02f, 2.80451383e-02f, 1.17065348e-01f,
  -1.53758852e-02f, 3.76290306e-02f, -2.75451075e-02f, -2.16327701e-03f, -2.19621342e-02f, -3.62091698e-02f, 3.48575562e-02f, 5.79269230e-02f, -2.22145431e-02f, 5.33044301e-02f,
  -7.62068182e-02f, -1.09518450e-02f, 1.16184205e-01f, 1.05251782e-01f, 7.76571184e-02f, 8.01188424e-02f, 1.01635173e-01f, 5.04180044e-02f, 2.05040470e-01f, 1.49157703e-01f,
  -8.40516575e-03f, -6.09103357e-03f, 6.93229213e-02f, -1.56092774e-02f, -1.65761393e-02f, 3.85541208e-02f, 7.80640170e-02f, 4.01141047e-02f, 8.17755908e-02f, 3.27513404e-02f,
  5.83513677e-02f, 1.90538969e-02f, -2.07189098e-02f, -5.74527271e-02f, -5.47127277e-02f, -6.54116124e-02f, -1.94716710e-03f, 6.61458001e-02f, 1.21998684e-02f, -8.05275664e-02f,
  -6.76844153e-04f, 3.58641054e-03f, -3.11774779e-02f, 8.47682506e-02f, -6.14703558e-02f, -7.30052441e-02f, -6.98040351e-02f, 6.27236664e-02f, 5.98432645e-02f, -9.62911323e-02f,
  1.70006499e-01f, -1.86649725e-01f, -4.39189523e-02f, 6.29722849e-02f, -8.50969627e-02f, -9.58939642e-02f, 3.89191583e-02f, 6.04406446e-02f, -4.89958823e-02f, -3.26657631e-02f,
  7.52621442e-02f, 3.08018215e-02f, -1.12669626e-02f, 7.77047724e-02f, 1.22457989e-01f, 2.91475616e-02f, 3.94000672e-02f, -9.45771560e-02f, 2.23894995e-02f, 4.71495204e-02f,
  5.70510402e-02f, -5.72458431e-02f, 9.75147039e-02f, 9.53638181e-02f, -1.90340374e-02f, -1.11899374e-03f, 9.24130678e-02f, 1.62893966e-01f, -1.87880471e-02f, 1.87041402e-01f,
  -1.39780656e-01f, -3.24193239e-02f, -7.97952339e-02f, 8.74994174e-02f, 1.01013362e-01f, 8.60351846e-02f, 1.62339404e-01f, 1.67849660e-01f, 6.65456504e-02f, 1.26764894e-01f,
  1.44221455e-01f, 1.35764956e-01f, 8.39240700e-02f, 5.79280742e-02f, 1.45350546e-01f, 5.01891365e-03f, 1.83177203e-01f, -1.61053715e-04f, -6.64388668e-03f, -2.29552090e-02f,
  4.67259474e-02f, -3.44425850e-02f, -7.86181316e-02f, 3.10982075e-02f, 9.73558798e-03f, 4.52684499e-02f, -4.00651470e-02f, -7.65393674e-02f, 6.83275759e-02f, 1.22080445e-01f,
  -1.07450768e-01f, -9.60544720e-02f, 8.43522474e-02f, -2.55303066e-02f, 6.63145166e-03f, -8.64181593e-02f, 3.02131809e-02f, -7.11555332e-02f, 1.43773621e-02f, -2.44079903e-03f,
  -5.71664236e-02f, 3.91910225e-02f, 8.51438642e-02f, 5.14804237e-02f, -2.20077522e-02f, -9.87510085e-02f, 2.41266261e-03f, -7.11890385e-02f, 9.38435569e-02f, -6.42882101e-03f,
  -3.85045856e-02f, 4.46145311e-02f, 4.33349572e-02f, -8.13759714e-02f, -1.11648673e-03f, -5.91782220e-02f, -5.62457880e-03f, 2.18834989e-02f, 2.68004313e-02f, -8.87142718e-02f,
  3.47106392e-03f, -3.11327185e-02f, -8.73411149e-02f, 7.71873072e-03f, -1.30062038e-02f, -6.45105839e-02f, 2.39205901e-02f, 4.92164120e-02f, 2.33355677e-03f, -3.81776690e-02f,
  3.94906886e-02f, 8.60530287e-02f, -2.44010333e-02f, -2.61975732e-02f, -6.24345280e-02f, -7.01762214e-02f, -7.57644996e-02f, -6.56927302e-02f, 4.10263352e-02f, 3.73121048e-03f,
  3.25162485e-02f, -3.23364772e-02f, -1.07938275e-01f, -2.38607135e-02f, 5.92077151e-02f, 4.82840799e-02f, 1.78188030e-02f, 1.56261045e-02f, -7.74770230e-02f, -7.23429695e-02f,
  -1.43220660e-03f, 1.32917896e-01f, -3.56337391e-02f, 7.17858449e-02f, 4.09252662e-03f, 9.83016938e-03f, 6.66912971e-03f, 3.08194328e-02f, 5.85608445e-02f, 3.73608246e-02f,
  2.15102732e-02f, -5.70211075e-02f, 4.79898416e-02f, 1.63994562e-02f, -9.27824080e-02f, -2.36079600e-02f, -5.70690520e-02f, -4.72274423e-02f, -8.97751376e-02f, -9.65355188e-02f,
  -9.52738151e-03f, -8.14561099e-02f, 2.24513281e-02f, -1.12273417e-01f, -8.05804059e-02f, 7.79486671e-02f, -2.95600258e-02f, -2.87342407e-02f, 3.05658691e-02f, -1.67633906e-01f,
  -5.80448434e-02f, 4.55027558e-02f, -4.19720896e-02f, -1.78586226e-02f, 3.22216935e-02f, 2.89450083e-02f, 1.06074616e-01f, 3.09067685e-02f, -3.10142823e-02f, -8.80085379e-02f,
  -5.35059907e-02f, -1.65824629e-02f, -4.47486481e-03f, -2.67975908e-02f, -6.17097765e-02f, -1.12159647e-01f, -1.80007651e-01f, -1.85959056e-01f, -6.86830580e-02f, 7.82081857e-02f,
  -9.66608301e-02f, -8.43650326e-02f, -8.49334225e-02f, -9.17474478e-02f, -1.09738424e-01f, -1.18767112e-01f, 2.93573085e-02f, -5.26480190e-02f, 3.31516005e-02f, -9.19352397e-02f,
  -2.27566391e-01f, -7.04383347e-05f, -9.35218781e-02f, -8.52150284e-03f, 1.00244088e-02f, -2.17632111e-02f, 2.18425784e-02f, -7.37594813e-02f, 6.75833002e-02f, 5.62245697e-02f,
  -2.78832931e-02f, -7.17344359e-02f, 1.98149253e-02f, 4.79789190e-02f, 4.80228774e-02f, 4.46404926e-02f, -4.62992117e-02f, -1.81971341e-02f, -2.84318663e-02f, 1.20990589e-01f,
  1.20344527e-01f, 5.03950901e-02f, 7.02030200e-04f, 1.42652631e-01f, 1.44810036e-01f, -1.02423513e-02f, -3.50998826e-02f, 1.08687133e-01f, 4.12436128e-02f, -7.29574934e-02f,
  2.84618493e-02f, -1.10839140e-02f, -4.13440466e-02f, -3.99639504e-03f, 7.84559548e-02f, -4.75361757e-02f, -3.77995223e-02f, 1.51534779e-02f, 5.53497188e-02f, -5.57131413e-03f,
  9.83147472e-02f, 5.73633760e-02f, 1.93531197e-02f, -8.63562226e-02f, 6.75508678e-02f, -6.69191033e-02f, -7.56208897e-02f, -3.04101221e-02f, 3.28022391e-02f, -1.05839716e-02f,
  -2.72317976e-02f, 4.63428535e-02f, 6.55946806e-02f, -1.28067331e-02f, 4.39470671e-02f, 9.79006477e-03f, 8.15864503e-02f, 5.22053763e-02f, 1.02809649e-02f, 7.58235306e-02f,
  -7.61069451e-03f, -4.11981866e-02f, -1.15195155e-01f, -8.85724369e-03f, 3.86341251e-02f, 1.74306184e-02f, 1.50029117e-03f, -5.54043353e-02f, 1.08244687e-01f, 2.12161448e-02f,
  5.45282848e-02f, -1.35840299e-02f, -5.70055544e-02f, 3.93312946e-02f, 3.96544337e-02f, 6.55007735e-02f, 1.07590422e-01f, 4.11343463e-02f, -3.68447527e-02f, 1.58128396e-01f,
  1.51928812e-01f, 8.14056918e-02f, -6.22143634e-02f, -4.37955838e-03f, 2.29469202e-02f, -9.63637903e-02f, -7.71266595e-02f, -4.66031581e-02f, -1.07346317e-02f, 6.51445286e-03f,
  -1.58695102e-01f, -7.00319111e-02f, -2.10385658e-02f, -8.88028145e-02f, -2.82984762e-03f, -1.17159665e-01f, -3.88358496e-02f, -9.40349028e-02f, -2.58375648e-02f, 3.52799967e-02f,
  -9.61407647e-03f, 3.51599865e-02f, -5.77301905e-02f, -1.56583898e-02f, 9.65222493e-02f, 8.97519737e-02f, 2.38550797e-01f, 5.25795706e-02f, -1.02650084e-01f, 2.99371164e-02f,
  1.57354921e-01f, 1.26512750e-04f, -4.51269513e-03f, 9.80511159e-02f, 8.23932737e-02f, 9.88874584e-04f, -3.09260562e-02f, -5.59789166e-02f, 1.28942758e-01f, 2.49055386e-01f,
  -1.13968737e-01f, -5.87549321e-02f, -2.22194493e-02f, -9.46869478e-02f, -7.90599287e-02f, -6.77712783e-02f, -6.20986968e-02f, -8.24424997e-02f, -4.20596600e-02f, -6.24140240e-02f,
  7.42262900e-02f, -9.94110852e-02f, 4.11548838e-02f, 7.43415579e-02f, -1.16970502e-01f, 3.88267078e-03f, 4.55334820e-02f, -6.07828386e-02f, -2.94288937e-02f, -4.28321585e-02f,
  1.57587141e-01f, 3.94344665e-02f, -6.92387670e-02f, 2.22646594e-02f, -7.52870068e-02f, -9.95698497e-02f, 2.60293428e-02f, -3.00164279e-02f, -1.08853735e-01f, -8.64901021e-02f,
  -6.25549406e-02f, -4.83951382e-02f, 5.35932444e-02f, 7.07337782e-02f, 6.64062276e-02f, 6.28596991e-02f, 8.05013925e-02f, -1.18297106e-02f, -1.27876932e-02f, 4.22504209e-02f,
  -5.02997264e-02f, 1.40524982e-02f, -8.11978653e-02f, -6.65084168e-04f, -7.22287083e-03f, 4.93621305e-02f, 4.93589491e-02f, -3.19771841e-02f, -2.75893155e-02f, 4.83362563e-02f,
  -4.19750204e-03f, -1.12425173e-02f, 5.19976988e-02f, 5.10165542e-02f, 5.93732521e-02f, 1.75826382e-02f, 4.50425707e-02f, -1.24358922e-01f, -9.41487700e-02f, -1.90699250e-02f,
  -1.45437375e-01f, -2.37076022e-02f, 6.64793849e-02f, -1.64620597e-02f, 3.89016457e-02f, 5.74012846e-02f, -5.41228466e-02f, -7.45887309e-03f, -5.51952645e-02f, -5.16889915e-02f,
  -2.24252120e-02f, 1.53698409e-02f, -6.48131222e-02f, -7.64291408e-03f, -1.35666030e-02f, -7.88095817e-02f, 5.32578751e-02f, -8.53583589e-02f, -1.17889289e-02f, 3.05108377e-03f,
  -3.31389569e-02f, -1.35051757e-01f, -5.34914844e-02f, -8.16848427e-02f, -8.33422295e-04f, -1.37620911e-01f, -1.64620176e-01f, -1.19992808e-01f, -8.23335871e-02f, -2.39148550e-02f,
  3.57479990e-01f, 2.69018918e-01f, 3.39961201e-02f, 1.33667275e-01f, 9.33208168e-02f, 3.38220969e-02f, 2.50279069e-01f, 1.03483312e-01f, 1.21580027e-01f, 1.22397892e-01f,
  1.52739003e-01f, 1.83724612e-01f, 5.61342612e-02f, 1.07437633e-01f, 2.14040771e-01f, 1.03222542e-01f, -4.99746017e-02f, 5.74005805e-02f, 1.60965666e-01f, 1.11284398e-01f,
  1.10245891e-01f, 4.52290513e-02f, 1.24556925e-02f, 8.70207399e-02f, 1.51591897e-01f, 6.36982098e-02f, -1.82486586e-02f, 1.09473221e-01f, 9.41818878e-02f, 1.28039762e-01f,
  -3.15712020e-02f, 2.89555132e-01f, -1.71856165e-01f, 3.04547250e-02f, 9.19549316e-02f, 4.84282114e-02f, 1.69395357e-02f, -3.38410288e-02f, -1.79561730e-02f, 1.25307301e-02f,
  -6.88384846e-02f, 6.83280453e-02f, 1.12077795e-01f, -1.08874030e-02f, 5.57582453e-02f, 7.09527954e-02f, -4.51216251e-02f, 3.17781493e-02f, 4.15413231e-02f, 1.59282666e-02f,
  -3.88281196e-02f, -7.16355816e-02f, 1.13032855e-01f, 9.75721329e-03f, 4.98136133e-02f, -1.61872189e-02f, 1.01134889e-01f, 1.26612976e-01f, 1.89763820e-03f, -3.68053764e-02f,
  -1.07006848e-01f, 1.11566797e-01f, -4.84972894e-02f, 1.03081651e-01f, -4.86822911e-02f, -9.53140259e-02f, 1.42698111e-02f, 8.08823854e-03f, -2.66078245e-02f, 2.47990191e-02f,
  -3.82890143e-02f, 9.48417187e-02f, 3.20734568e-02f, 3.39616463e-02f, 1.22723747e-02f, -2.57389508e-02f, 4.17735195e-04f, 6.02373891e-02f, -2.67168786e-03f, 1.05898259e-02f,
  2.38897409e-02f, 2.48936727e-03f, -2.10329127e-02f, -3.29854563e-02f, 2.54605766e-02f, 7.34803220e-03f, -1.92941111e-02f, -3.10735703e-02f, 7.36601502e-02f, -1.47833461e-02f,
  -4.45420966e-02f, 6.80336133e-02f, -3.60313877e-02f, 2.54428852e-02f, -8.78701359e-02f, 2.75492407e-02f, -7.10060969e-02f, 4.13129777e-02f, -4.00705710e-02f, -7.02777281e-02f,
  4.18381914e-02f, 4.30790111e-02f, -7.92454332e-02f, 1.91637184e-02f, -2.22252496e-02f, -1.04084134e-01f, 2.49592550e-02f, -3.22056264e-02f, -9.10391957e-02f, -4.18109782e-02f,
  -4.43282425e-02f, -1.57031372e-01f, 2.25779396e-02f, -4.99505959e-02f, 6.15130588e-02f, 4.30726781e-02f, -1.20678701e-01f, -4.03632186e-02f, -8.04754794e-02f, -1.65039644e-01f,
  3.39755267e-01f, 9.02847499e-02f, 3.64966653e-02f, -1.94339566e-02f, -1.23198688e-01f, -5.82992844e-02f, -6.32937104e-02f, -1.12155922e-01f, -5.57584465e-02f, 2.99988184e-02f,
  6.45883232e-02f, 1.12435475e-01f, 4.67903838e-02f, 1.04038492e-01f, 7.45997950e-02f, 1.82836074e-02f, 4.75395210e-02f, 1.63713381e-01f, 1.20748371e-01f, 6.87896237e-02f,
  8.26035216e-02f, 2.89323051e-02f, 8.25702548e-02f, 1.07250549e-01f, 1.28215984e-01f, 7.36720413e-02f, -3.41660492e-02f, 1.92596968e-02f, 8.25102031e-02f, 1.69250786e-01f,
  6.39417768e-02f, 3.64336632e-02f, -1.25317439e-01f, 9.96257141e-02f, -2.41186214e-03f, 6.95440248e-02f, 7.67247751e-02f, 4.22104709e-02f, 3.42057698e-04f, -6.09236173e-02f,
  5.75479195e-02f, -2.23355163e-02f, -8.87411088e-02f, -4.71678423e-03f, -6.59447759e-02f, 6.27729818e-02f, 8.35358053e-02f, -2.48574503e-02f, 5.92535846e-02f, 9.53567922e-02f,
  -7.20274597e-02f, -4.89307567e-02f, 1.08556245e-02f, -9.63123068e-02f, 3.33442762e-02f, 7.30468333e-02f, 2.66841203e-02f, 1.45346045e-01f, 1.81231042e-03f, 1.50800094e-01f,
  1.70759540e-02f, -3.69477049e-02f, -2.24078121e-03f, 3.33204046e-02f, -4.96268421e-02f, -2.86638457e-02f, -1.73807833e-02f, -4.45207320e-02f, 5.93345650e-02f, 1.13934488e-03f,
  3.58522311e-02f, 3.87439430e-02f, -7.29016028e-03f, -3.94549221e-02f, -5.96797839e-02f, 4.97480854e-02f, -4.86097150e-02f, -7.08270967e-02f, 4.00639251e-02f, -6.10148832e-02f,
  8.14004615e-03f, 2.66411975e-02f, 9.35566276e-02f, -3.48264053e-02f, 3.97576578e-02f, 2.44073216e-02f, -6.52525434e-03f, -3.70817669e-02f, -3.84963080e-02f, 2.51385346e-02f,
  -1.16748214e-01f, -2.34710485e-01f, 1.00429721e-01f, -3.14169973e-02f, 7.25567713e-02f, 6.58392087e-02f, 7.55433971e-03f, 4.64452244e-02f, -4.22749557e-02f, -8.76912177e-02f,
  2.97597777e-02f, 6.23272397e-02f, -3.33635956e-02f, -6.99138828e-03f, -3.09253410e-02f, 2.15579011e-02f, 1.65892038e-02f, 7.64620230e-02f, -1.88083220e-02f, 3.21399122e-02f,
  -1.61397215e-02f, -5.81908226e-02f, -1.06588952e-01f, -7.09326267e-02f, -4.73468862e-02f, -7.07698837e-02f, -1.02587909e-01f, -2.81852614e-02f, -1.94550939e-02f, -3.25133353e-02f,
  -4.00856584e-02f, 1.47009790e-01f, -3.67100574e-02f, 6.33240864e-02f, 4.18242477e-02f, -3.30532007e-02f, 5.80579750e-02f, 4.26638238e-02f, 1.01536863e-01f, 1.02700993e-01f,
  1.27830282e-01f, 1.31793335e-01f, 3.20369452e-02f, 8.54651779e-02f, 6.73628226e-03f, 9.29693505e-02f, -3.79328765e-02f, 9.08468035e-04f, 8.40024650e-02f, -3.52864293e-03f,
  -3.92118245e-02f, -8.35015476e-02f, -8.64547491e-03f, 6.27253130e-02f, 2.32144091e-02f, 2.27094591e-02f, 1.22995516e-02f, -2.43355725e-02f, 5.40940464e-02f, 7.06449971e-02f,
  1.41434297e-01f, -1.54762380e-02f, 2.21407833e-03f, -8.12074691e-02f, -6.50320649e-02f, -8.56916383e-02f, -4.48355973e-02f, -8.69779214e-02f, -8.31199139e-02f, 2.96844617e-02f,
  5.25660813e-02f, -2.62362454e-02f, 3.40932868e-02f, 1.59008857e-02f, -1.07407860e-01f, -4.36478481e-02f, -1.01789959e-01f, 1.09960800e-02f, 1.00014970e-01f, 7.93285891e-02f,
  9.86270830e-02f, 1.25330359e-01f, 8.33673105e-02f, 2.88704466e-02f, 3.41779180e-02f, -6.75175190e-02f, 1.22563928e-01f, 2.39604432e-02f, -5.56359328e-02f, 2.09525730e-02f,
  -1.51248146e-02f, 4.79772780e-03f, 1.18177712e-01f, 7.48964250e-02f, 2.97905989e-02f, -5.25789671e-02f, 4.85060550e-02f, -6.68457672e-02f, -7.30583072e-02f, 1.94573570e-02f,
  5.23284860e-02f, 7.26017579e-02f, 1.14666438e-02f, -5.65848760e-02f, 1.21436361e-02f, 1.18040286e-01f, -8.59683321e-04f, 1.36235375e-02f, -2.66645588e-02f, -8.46451521e-02f,
  -4.66864333e-02f, -2.05606315e-02f, 5.34197781e-03f, 1.43790990e-02f, -6.29583150e-02f, 1.52715971e-03f, -6.59218952e-02f, 1.38246547e-02f, -7.61321783e-02f, -3.50079797e-02f,
  8.23937804e-02f, -5.62418588e-02f, -8.69225562e-02f, 2.77287513e-02f, -6.37200326e-02f, -7.32928794e-03f, -3.07809561e-02f, 1.70350671e-02f, 2.95403711e-02f, 2.49749143e-02f,
  5.06567070e-03f, -6.04641661e-02f, -1.83900557e-02f, -8.40651542e-02f, -4.57433574e-02f, 4.32980098e-02f, -7.42375031e-02f, 7.52647966e-02f, 1.00039206e-01f, 1.01622492e-01f,
  2.16569956e-02f, 7.61915967e-02f, 8.78340527e-02f, 6.21359982e-02f, 3.88918184e-02f, -5.97822107e-02f, 5.58764637e-02f, 9.42380130e-02f, -5.18003330e-02f, -6.30159304e-02f,
  9.73711684e-02f, 6.67769015e-02f, -2.50567608e-02f, 3.54488119e-02f, -1.07721686e-01f, -1.34272084e-01f, -5.48980869e-02f, -1.24255374e-01f, 1.92389712e-02f, 1.10703241e-02f,
  -3.82712786e-03f, -4.26280983e-02f, 8.43669251e-02f, 1.05443761e-01f, 1.15782954e-01f, -5.35023846e-02f, 4.32642410e-03f, 4.45149839e-02f, 1.30144730e-01f, 6.67756945e-02f,
  5.58132604e-02f, 1.38720265e-02f, 1.02622315e-01f, -4.59913798e-02f, 7.39675388e-02f, 8.54972452e-02f, 4.99215014e-02f, 7.64575154e-02f, -4.80890647e-02f, 4.24330309e-02f,
  1.18402742e-01f, -7.46773183e-03f, -6.72099739e-02f, 2.62542740e-02f, 5.00044748e-02f, -3.96516882e-02f, -3.95411700e-02f, -2.78380606e-03f, -1.12476647e-02f, -2.30028154e-03f,
  -6.08067997e-02f, 4.49568629e-02f, -3.70421000e-02f, -4.68809642e-02f, 2.08784882e-02f, -3.88487056e-02f, 1.64020285e-02f, -4.33563478e-02f, 2.23895367e-02f, -3.32870260e-02f,
  -9.40938219e-02f, 1.50773004e-02f, -3.52678560e-02f, 1.18693439e-02f, 2.16452216e-04f, -2.48357486e-02f, 1.53242899e-02f, -5.29809669e-02f, -4.39082421e-02f, 1.12956678e-02f,
  -1.74162965e-02f, -1.55045260e-02f, -3.97403054e-02f, 6.74769729e-02f, -7.38077462e-02f, 5.04566580e-02f, -2.54568346e-02f, -7.02251075e-03f, -6.36467040e-02f, 2.07511559e-02f,
  1.14733931e-02f, -2.08505569e-03f, 3.61492969e-02f, 9.00196806e-02f, 7.11623356e-02f, 1.04878808e-03f, -5.47924377e-02f, -2.24020351e-02f, 1.53332073e-02f, -3.56469043e-02f,
  5.92959635e-02f, 7.26319551e-02f, -8.38388652e-02f, 4.17150818e-02f, -6.15707189e-02f, -2.11841110e-02f, 1.04714960e-01f, 7.04460740e-02f, 1.07659390e-02f, -5.74766845e-02f,
  1.50159448e-02f, -4.03140895e-02f, 1.10128723e-01f, -8.06960613e-02f, -2.84109581e-02f, 4.63532424e-03f, -1.58349928e-02f, 3.54614407e-02f, -3.43131833e-02f, -4.89153750e-02f,
  -2.54870392e-02f, -6.58902824e-02f, 2.87483307e-03f, -2.01114640e-02f, 7.36534745e-02f, -7.02703372e-02f, -7.54352883e-02f, 5.61859198e-02f, -8.81858841e-02f, -1.81690939e-02f,
  4.74213921e-02f, -8.02647918e-02f, 1.24973673e-02f, -9.56938192e-02f, 5.88690527e-02f, 5.92769422e-02f, 2.35350132e-02f, -9.48572531e-02f, -4.86838585e-03f, -2.16558371e-02f,
  -7.96799082e-03f, 5.70436828e-02f, -7.70031288e-02f, 4.25943546e-02f, -6.60906658e-02f, -7.29514509e-02f, 2.76526734e-02f, -8.62955302e-02f, 3.61953899e-02f, 5.63262440e-02f,
  -9.11113769e-02f, -1.34434178e-01f, -2.00438462e-02f, 3.91267166e-02f, -8.80391002e-02f, 1.03232197e-01f, 7.86420144e-03f, -8.67186487e-03f, -9.99578908e-02f, -4.19741049e-02f,
  -7.05574825e-02f, 6.90192431e-02f, -1.51615217e-02f, -3.12145874e-02f, 5.91014884e-02f, -1.36032388e-01f, -7.24944845e-02f, 4.92103547e-02f, -1.15791313e-01f, 7.25715756e-02f,
  -1.31684507e-03f, -8.94070342e-02f, -7.01864958e-02f, 4.88265455e-02f, -5.60718365e-02f, 4.04110597e-03f, 3.75122614e-02f, 2.27874462e-02f, -5.38730156e-03f, -5.33931218e-02f,
  2.78611574e-02f, 1.42791467e-02f, -6.64993897e-02f, -1.02963015e-01f, -3.00617106e-02f, -9.97359827e-02f, -1.80223957e-02f, -6.24669045e-02f, -1.02318428e-01f, -3.11621875e-02f,
  -2.04475522e-02f, -3.55772227e-02f, 3.62710170e-02f, -5.56851290e-02f, -1.13375776e-01f, -1.10835368e-02f, 3.86429615e-02f, -3.34491432e-02f, -8.22576582e-02f, 3.20050046e-02f,
  8.90173018e-02f, -4.78656217e-03f, 6.78590462e-02f, 5.77620938e-02f, 9.48820412e-02f, 2.62741949e-02f, -1.68562531e-02f, 4.34410013e-02f, 8.66717249e-02f, 1.93843339e-02f,
  -1.05610099e-02f, -3.20475623e-02f, -8.63955840e-02f, -6.85403198e-02f, 6.84051961e-02f, -4.92152432e-03f, -1.47470972e-03f, -5.67335577e-04f, 1.32257529e-02f, -6.12198152e-02f,
  9.60876197e-02f, 2.74658706e-02f, 1.04425708e-02f, -1.74139477e-02f, 6.22280687e-03f, 7.29288980e-02f, -4.02079970e-02f, 4.80548590e-02f, 9.54934582e-02f, 3.14890444e-02f,
  -4.43672985e-02f, 6.97951205e-03f, 2.65106633e-02f, 6.51492700e-02f, -1.65715441e-02f, -7.23726302e-02f, 6.80825040e-02f, 5.67815965e-04f, 2.22712196e-02f, -7.66008869e-02f,
  -4.51288521e-02f, 2.60419864e-02f, -5.02990140e-03f, -4.06884477e-02f, 4.51227576e-02f, 9.62232240e-03f, 5.26161604e-02f, -8.72271881e-02f, 4.29719361e-03f, 8.06849003e-02f,
  -8.37854818e-02f, 4.90305871e-02f, 1.53991897e-02f, 7.48072192e-02f, 7.21353292e-02f, 3.91911007e-02f, -7.55382255e-02f, 2.67463773e-02f, -4.97529358e-02f, 1.09747592e-02f,
  5.38211353e-02f, 4.67383899e-02f, -2.64008064e-02f, 1.09219186e-01f, -9.94614977e-03f, 1.19422868e-01f, 1.48463950e-01f, 1.26196489e-01f, -7.22179487e-02f, 8.67508799e-02f,
  1.20019987e-02f, 8.84101973e-05f, 1.64750945e-02f, -6.26849309e-02f, 7.51763303e-03f, -3.20107974e-02f, -4.93933633e-02f, -1.38814759e-03f, 5.84353618e-02f, 6.76351860e-02f,
  -9.83486138e-03f, 9.55870971e-02f, 3.55457850e-02f, -3.78551073e-02f, -1.05716906e-01f, -1.11554340e-01f, 1.03202313e-01f, 3.76614705e-02f, -4.42679934e-02f, -1.16390005e-01f,
  -1.26134261e-01f, -7.47132301e-02f, -8.19517225e-02f, -8.81232470e-02f, 8.72200057e-02f, -7.00627491e-02f, 5.86353317e-02f, 1.98572595e-02f, -2.73726191e-02f, 7.58616328e-02f,
  1.81314126e-02f, -6.98522255e-02f, -8.20169449e-02f, 7.39851370e-02f, -4.27228957e-02f, 4.22386155e-02f, 5.91161884e-02f, 6.53320625e-02f, -2.45456621e-02f, -3.14949527e-02f,
  -1.24027140e-01f, -3.83119248e-02f, 5.48718274e-02f, -9.12278369e-02f, 1.78436637e-02f, 4.12426963e-02f, -6.56652302e-02f, -4.31689769e-02f, 5.86604141e-02f, -1.02958661e-02f,
  4.55808602e-02f, 6.47193342e-02f, -9.46162827e-03f, -3.09125427e-02f, -9.44835320e-02f, 6.78350255e-02f, 4.21529226e-02f, -1.90328974e-02f, -5.16982228e-02f, -5.81214614e-02f,
  3.75974700e-02f, 3.60306399e-03f, 2.99011078e-02f, -4.87142988e-02f, -1.07325390e-01f, -3.24205533e-02f, 4.50968668e-02f, -7.01225400e-02f, -1.98832881e-02f, 4.82879654e-02f,
  -4.39409874e-02f, -1.63038205e-02f, -6.55768737e-02f, -4.89481241e-02f, 4.43426035e-02f, 6.02924228e-02f, -2.91027036e-03f, 1.91210993e-02f, -5.40248416e-02f, -5.50382212e-02f,
  -3.44933337e-03f, -9.97499228e-02f, 1.19692245e-02f, 4.84690033e-02f, -7.31672021e-03f, 6.87168241e-02f, 2.00679656e-02f, -3.43324356e-02f, -4.75061983e-02f, -3.33077684e-02f,
  -1.98340230e-02f, -9.94099490e-03f, -6.21373206e-02f, 2.15170775e-02f, -6.06143400e-02f, 1.78402588e-02f, -5.20750582e-02f, 3.31038088e-02f, 2.19654180e-02f, 7.70818964e-02f,
  3.81938107e-02f, 1.11732550e-01f, -3.69606689e-02f, 6.49905875e-02f, 4.50652130e-02f, -1.58897843e-02f, -2.56610401e-02f, 6.54772371e-02f, 4.59830686e-02f, 1.41476959e-01f,
  -4.87610549e-01f, -6.92004263e-02f, 2.15763319e-02f, -1.36676088e-01f, 4.95402887e-02f, 1.30127892e-01f, 5.25826178e-02f, -5.64372391e-02f, -2.14567743e-02f, -3.00340317e-02f,
  -2.09337603e-02f, -1.70303900e-02f, -1.24930963e-01f, 1.08641209e-02f, 7.54679069e-02f, 1.97778791e-01f, 1.69272736e-01f, 1.28319988e-03f, -1.28399506e-01f, -8.23514983e-02f,
  1.10197924e-01f, -8.30856487e-02f, -2.51651675e-01f, 4.44218926e-02f, 1.14615135e-01f, -6.72710389e-02f, -2.52555348e-02f, 6.25970140e-02f, 6.02881275e-02f, 2.33721450e-01f,
  -1.16517149e-01f, -7.29562044e-02f, 2.14874139e-03f, -8.56584758e-02f, 2.77112750e-03f, -6.79686293e-02f, 5.42109311e-02f, -2.17165146e-02f, -4.56172749e-02f, -3.62596624e-02f,
  -1.15496606e-01f, 4.64739874e-02f, 1.90288071e-02f, -9.44751352e-02f, -2.44488046e-02f, -1.48665542e-02f, 1.67754963e-02f, 2.87174433e-02f, -6.01074845e-03f, 7.35053420e-02f,
  8.10405836e-02f, 4.02394757e-02f, -8.05828199e-02f, -3.27029526e-02f, -6.06052391e-02f, -3.60870287e-02f, -3.89412194e-02f, -3.26664224e-02f, -4.15905975e-02f, -6.27191216e-02f,
  6.13255985e-02f, -1.74234640e-02f, -4.08681780e-02f, -7.51158968e-02f, -6.28930926e-02f, -4.54373285e-02f, 7.89482594e-02f, 1.43377315e-02f, 1.93687733e-02f, -3.05571426e-02f,
  -7.44902471e-04f, -1.14301778e-01f, -1.02067143e-02f, -3.25304456e-02f, 7.42070377e-03f, -2.67744400e-02f, 6.66728336e-03f, 4.35408242e-02f, 2.74814721e-02f, 2.56781969e-02f,
  4.74167950e-02f, 5.52398264e-02f, -3.19929905e-02f, -3.54157276e-02f, 6.32498264e-02f, 3.14646997e-02f, -7.37324506e-02f, 6.06955960e-02f, -3.58013846e-02f, 1.05255321e-02f,
  -2.31957182e-01f, 1.29531085e-01f, 2.81366780e-02f, -7.68815354e-02f, -7.08593950e-02f, -1.43294223e-02f, 7.15539157e-02f, -1.24799810e-01f, -5.22906184e-02f, -4.75341342e-02f,
  -9.52977762e-02f, -2.49625836e-02f, -9.14357081e-02f, 3.90344858e-02f, -5.96162193e-02f, -8.71545821e-02f, -7.20108896e-02f, 3.16712447e-02f, 6.35948777e-02f, -8.25634003e-02f,
  2.10743174e-02f, -1.02499075e-01f, -1.46139950e-01f, 8.36146250e-03f, -3.02511789e-02f, -1.45445034e-01f, -8.77147987e-02f, -6.42766207e-02f, -1.81901321e-01f, -1.06973976e-01f,
  5.95997600e-03f, -1.47914728e-02f, -1.67865772e-02f, -1.48210246e-02f, -7.57321417e-02f, 9.93104130e-02f, 1.11009337e-01f, 1.06658660e-01f, 1.08917572e-01f, -6.40909672e-02f,
  -2.52951682e-02f, -1.93345714e-02f, 1.39465898e-01f, 8.03947151e-02f, 5.91118000e-02f, 7.45637715e-02f, 1.01690628e-01f, 7.91763067e-02f, 6.99848756e-02f, -1.74321495e-02f,
  7.75260329e-02f, -4.25608978e-02f, -7.53453076e-02f, 8.83378014e-02f, 2.42385529e-02f, 8.59317407e-02f, -3.92361172e-03f, -9.18606296e-02f, 5.33246361e-02f, 5.41799255e-02f,
  2.80378796e-02f, -5.56274876e-02f, 1.75377876e-02f, -1.42698279e-02f, 2.80775111e-02f, -7.28515759e-02f, -7.19034672e-02f, 5.11797704e-02f, -1.42553691e-02f, 5.42656891e-03f,
  4.74103773e-03f, -4.85000275e-02f, -6.04133047e-02f, 2.62633641e-03f, 2.90802792e-02f, -1.01055458e-01f, 5.91402426e-02f, 7.50695169e-02f, -4.27483283e-02f, -3.13075930e-02f,
  -4.69362922e-02f, -3.84828746e-02f, -1.04675539e-01f, -4.20796163e-02f, -7.14789927e-02f, 2.87513621e-02f, 9.18362988e-04f, -6.31383285e-02f, -1.59215368e-02f, -8.19720924e-02f,
  1.01677075e-01f, 3.48293893e-02f, 7.38860965e-02f, -1.41826058e-02f, 4.02320065e-02f, 4.89580669e-02f, -2.34936606e-02f, 4.81428765e-02f, 2.79207155e-02f, 5.68546429e-02f,
  -8.45216811e-02f, -7.00842068e-02f, 5.08009195e-02f, 3.68988253e-02f, 1.35330176e-02f, 1.33755580e-02f, 1.62850153e-02f, 1.01529695e-02f, 4.00253348e-02f, -4.97342832e-02f,
  -8.63295123e-02f, 6.57696696e-03f, 1.25139905e-03f, 6.19986467e-02f, -3.94445658e-02f, 2.31389422e-02f, -2.54832581e-02f, -8.07137042e-02f, -3.08781583e-02f, 5.10505866e-03f,
  -5.96270673e-02f, -1.42925070e-03f, -2.59260405e-02f, 6.23674802e-02f, -8.91408548e-02f, -1.12007126e-01f, 1.18393507e-02f, -8.96274075e-02f, 3.24884690e-02f, -1.07319064e-01f,
  6.53442442e-02f, 3.91784171e-03f, 6.44686669e-02f, -2.62399558e-02f, 4.05509546e-02f, 1.71613619e-02f, -2.39629988e-02f, -7.95379095e-03f, -1.18643502e-02f, 5.08607971e-03f,
  5.25356941e-02f, 2.00183950e-02f, 6.17055632e-02f, -3.53388861e-02f, 8.87131318e-02f, -2.52656192e-02f, 6.67193979e-02f, -4.12039831e-02f, -2.18675449e-03f, -2.75093969e-03f,
  1.05339237e-01f, 8.41949284e-02f, -4.75205332e-02f, 6.43579364e-02f, -1.52931213e-01f, -1.51445165e-01f, -1.38611840e-02f, -1.14730000e-01f, -3.06934156e-02f, -6.81272596e-02f,
  -7.92226195e-02f, 2.40472350e-02f, 8.58524814e-02f, -3.72455828e-02f, 1.20818559e-02f, 4.42886353e-02f, 5.58985863e-03f, 1.09284222e-01f, -3.13948654e-02f, 1.29942354e-02f,
  -5.16962595e-02f, 7.68030295e-03f, 7.78086632e-02f, 5.02924509e-02f, -2.35497635e-02f, -8.15411210e-02f, 5.65094687e-02f, -1.02148876e-01f, 1.47609245e-02f, 2.50228271e-02f,
  -2.12321542e-02f, -6.06638826e-02f, -2.16940828e-02f, 1.25472263e-01f, 7.19539747e-02f, -3.82629083e-03f, 6.02204762e-02f, 3.27406153e-02f, 3.61027382e-02f, 2.60825623e-02f,
  -3.12973037e-02f, -3.21030952e-02f, -4.29916792e-02f, -4.68344800e-02f, -5.52356057e-02f, 1.44636072e-02f, 6.71544820e-02f, -5.92587292e-02f, -3.59848961e-02f, -4.24930863e-02f,
  5.16892858e-02f, -2.49309782e-02f, -4.96019311e-02f, 5.73071986e-02f, -5.75285144e-02f, 4.59237806e-02f, 4.19506282e-02f, -4.44443198e-03f, 2.36501638e-02f, 4.98364158e-02f,
  -7.11863562e-02f, -3.06541137e-02f, 1.23571437e-02f, -6.45153970e-02f, 7.00005293e-02f, 3.88568155e-02f, -3.24664600e-02f, 1.70863513e-02f, -8.30122828e-02f, -2.38120221e-02f,
  3.86597365e-02f, -6.72673434e-02f, -1.09990472e-02f, -3.49256098e-02f, -1.47140853e-03f, 4.81273606e-02f, -9.31155384e-02f, -7.96285942e-02f, -7.20455423e-02f, -7.70716220e-02f,
  -3.36338840e-02f, 5.13453074e-02f, 5.78891337e-02f, 3.12694870e-02f, 5.15413247e-02f, 3.83046865e-02f, 4.03039120e-02f, -5.50181977e-02f, -2.83878855e-02f, 5.57195842e-02f,
  1.22384205e-01f, -8.03422779e-02f, 4.62368205e-02f, 4.64021154e-02f, 1.76554285e-02f, -3.06628104e-02f, 2.49225572e-02f, 9.11683813e-02f, 7.43972287e-02f, 4.03621495e-02f,
  3.42839770e-02f, 1.08268641e-01f, 8.21707770e-02f, -4.35040258e-02f, 8.71304572e-02f, 7.47202197e-03f, 3.14313099e-02f, -2.63978727e-02f, 2.56210901e-02f, -5.00491634e-02f,
  1.14076637e-01f, -1.61400381e-02f, 2.16266550e-02f, 7.59426057e-02f, 9.32344794e-02f, -2.09066775e-02f, -3.26740928e-02f, 8.17500576e-02f, 2.12529227e-02f, 1.18544102e-01f,
  -4.10441041e-01f, -8.15140158e-02f, 4.84575192e-03f, -7.82144070e-03f, 1.42100289e-01f, 1.87459037e-01f, 2.02758878e-01f, 7.80938640e-02f, 3.67550366e-03f, -3.70715782e-02f,
  1.63400769e-02f, -8.10375363e-02f, -5.02612740e-02f, -6.19071461e-02f, 1.27314059e-02f, 1.00188009e-01f, 1.75341323e-01f, -1.90120103e-04f, -7.81866983e-02f, -4.59072702e-02f,
  1.16004959e-01f, -4.24634255e-02f, -1.53042108e-01f, -8.02219585e-02f, 5.58065102e-02f, -1.68858003e-02f, -7.56443664e-03f, -4.82197180e-02f, 7.36399889e-02f, 9.70828310e-02f,
  -4.77659851e-02f, -1.38775930e-01f, -1.63626224e-02f, -1.34082109e-01f, 1.60333887e-02f, 6.70480402e-03f, -6.86132163e-02f, -1.09616987e-01f, 5.75435199e-02f, -7.33019924e-03f,
  -5.61262928e-02f, -2.82584690e-02f, 2.13002283e-02f, -8.24748054e-02f, 6.27154708e-02f, 1.23499371e-02f, -5.69548495e-02f, 2.40335129e-02f, 6.35780618e-02f, -7.58579373e-02f,
  4.69232947e-02f, -2.50440300e-03f, 4.35365662e-02f, 1.06613278e-01f, 2.95571107e-02f, 1.33544020e-02f, -4.15499974e-03f, -1.44497966e-02f, 2.23430675e-02f, -7.88272470e-02f,
  4.11014818e-02f, -5.05527705e-02f, -4.19207439e-02f, 2.11987309e-02f, 5.02323359e-02f, 5.38960891e-03f, 2.95253973e-02f, 2.78333272e-03f, 2.23239679e-02f, 1.10256169e-02f,
  -9.00925100e-02f, 8.28397125e-02f, 1.69760659e-02f, -8.58449265e-02f, 6.46376563e-03f, -7.47982785e-02f, 6.91535696e-02f, -3.46426331e-02f, -1.05297491e-01f, 1.89343728e-02f,
  -1.12051196e-01f, 2.06084526e-03f, 1.83427669e-02f, -6.27533533e-03f, -5.40734688e-03f, -7.96475634e-03f, -4.98609059e-02f, -1.89437587e-02f, 8.67338404e-02f, 4.42697741e-02f,
  -3.02329753e-02f, 5.93526773e-02f, -9.72807035e-02f, -5.36240824e-03f, -2.56879292e-02f, -8.05679262e-02f, -5.47551885e-02f, -5.72776981e-02f, -1.72494948e-02f, -8.91990867e-03f,
  -3.58834676e-02f, 3.94362882e-02f, 4.48626801e-02f, -5.86043345e-03f, 5.82132824e-02f, 4.80331779e-02f, -1.16052873e-01f, 8.41185451e-02f, 1.08534172e-01f, 1.15760081e-01f,
  5.04842512e-02f, 7.04236552e-02f, -5.97941987e-02f, -6.78274967e-03f, 3.02476473e-02f, 3.96775976e-02f, -3.88000868e-02f, 1.15252182e-01f, 8.57457146e-02f, 1.67936888e-02f,
  4.97409999e-02f, 7.51934573e-03f, 1.04517609e-01f, 2.56605800e-02f, -1.04466252e-01f, -1.25353754e-01f, -1.59374654e-01f, -4.28301953e-02f, 4.27949652e-02f, 6.19334988e-02f,
  -1.18712127e-01f, 2.94816364e-02f, -5.02543338e-02f, 5.91291077e-02f, -4.88052294e-02f, 5.61772510e-02f, 1.20477609e-01f, 7.06790946e-03f, -1.90297961e-02f, 4.16059652e-03f,
  1.02409594e-01f, 2.07243767e-03f, 8.15259814e-02f, 2.17983425e-02f, 5.27768210e-02f, 4.22482826e-02f, 6.13420755e-02f, -2.72050556e-02f, 6.27316758e-02f, -5.87446196e-03f,
  -6.38806522e-02f, -6.96710870e-02f, 5.33893146e-02f, -4.81306277e-02f, -7.52007738e-02f, -2.63891686e-02f, -1.07330151e-01f, 4.56350520e-02f, 5.16750216e-02f, 2.44562197e-02f,
  -9.11697522e-02f, -3.37936245e-02f, 9.54034328e-02f, 7.60009587e-02f, 8.26433748e-02f, 6.65483698e-02f, 9.12269056e-02f, 9.30231512e-02f, -5.80549724e-02f, -4.38392386e-02f,
  -9.52568203e-02f, -6.44313321e-02f, -1.00967869e-01f, -3.02080647e-03f, -3.10013928e-02f, 5.03662527e-02f, -1.03126638e-01f, -7.95109570e-02f, 5.67591824e-02f, 4.31518853e-02f,
  -1.30675603e-02f, 2.28424445e-02f, 1.84577797e-02f, -5.80526218e-02f, 6.67147115e-02f, 5.15181124e-02f, -3.44744734e-02f, -7.04889745e-02f, 5.63290752e-02f, -8.13390240e-02f,
  5.11597318e-04f, -8.29854831e-02f, 7.58536980e-02f, -2.04312336e-02f, 8.60166997e-02f, -2.62375083e-02f, -4.28907573e-02f, -7.66949803e-02f, 2.33455226e-02f, -3.30282263e-02f,
  -1.76068824e-02f, -9.35412794e-02f, -5.85928224e-02f, 2.49863043e-02f, -9.54318196e-02f, 2.42107641e-02f, -8.10753331e-02f, 3.50678973e-02f, 1.46099683e-02f, 4.70987968e-02f,
  -8.17716941e-02f, 1.37108034e-02f, -1.70046985e-02f, 2.63200868e-02f, 6.24388419e-02f, 4.49201167e-02f, 3.96479294e-03f, 9.45144668e-02f, 3.07250265e-02f, -2.30177175e-02f,
  -4.96182777e-02f, 7.19009265e-02f, -6.94848821e-02f, -2.51784623e-02f, 9.60626751e-02f, 5.72138466e-02f, -1.54042840e-02f, -3.71621433e-03f, 8.18704292e-02f, -9.34127048e-02f,
  -6.23955540e-02f, -6.47500753e-02f, 7.87728187e-03f, 7.50509277e-02f, -6.30187690e-02f, -2.03362089e-02f, -3.17205414e-02f, 5.81280738e-02f, 1.00133186e-02f, 8.93340707e-02f,
  -1.09150857e-01f, -1.24409728e-01f, -2.73518059e-02f, -3.42387222e-02f, 4.91614044e-02f, 5.72164170e-02f, -1.29420817e-01f, 4.43527065e-02f, -2.69456226e-02f, -1.25770241e-01f,
  7.10601434e-02f, -3.87983210e-02f, -1.02401614e-01f, 3.24759111e-02f, -1.08488142e-01f, -6.23176359e-02f, -1.61828905e-01f, -4.45371084e-02f, 7.35407323e-02f, 4.74870093e-02f,
  -4.73215356e-02f, -1.12633938e-02f, 4.53305356e-02f, -1.03179365e-02f, -5.23249730e-02f, 1.84803978e-02f, -4.47238348e-02f, 2.51764022e-02f, -5.09211677e-04f, -5.14254123e-02f,
  -7.45079443e-02f, 1.10988997e-01f, 1.09375287e-02f, 7.54696280e-02f, -1.11187398e-02f, 6.87967688e-02f, -3.94877000e-03f, 4.19858135e-02f, 4.86914963e-02f, -6.06246777e-02f,
  6.77803159e-02f, 2.02325340e-02f, 6.44667633e-03f, 6.66422099e-02f, -3.72657441e-02f, -7.82815218e-02f, 3.64992656e-02f, -5.45638874e-02f, -5.59913069e-02f, 1.24267302e-02f,
  -2.09137164e-02f, 4.16952856e-02f, -9.33727324e-02f, -1.72843051e-03f, -7.57583529e-02f, -4.87152375e-02f, 6.69593737e-02f, -2.37261690e-02f, -2.74473391e-02f, -6.03366829e-02f,
  1.15789287e-03f, 1.19901588e-03f, -3.80555503e-02f, -4.52306531e-02f, -7.24263340e-02f, -1.00594006e-01f, 8.36192220e-02f, 6.42691134e-03f, -6.68307543e-02f, -6.87703025e-04f,
  -3.01437136e-02f, -4.60872576e-02f, 4.14613411e-02f, -6.32947236e-02f, -8.24999511e-02f, 5.92743419e-02f, 1.21890660e-02f, -8.15510750e-02f, 5.68538234e-02f, 4.27027512e-03f,
  -4.35244367e-02f, -7.66144991e-02f, -5.42323217e-02f, 1.42595610e-02f, -7.87282512e-02f, -5.39420620e-02f, 4.34899814e-02f, -6.10555038e-02f, 2.18671318e-02f, 2.08573621e-02f,
  -1.40858248e-01f, 5.40378019e-02f, 4.82357712e-03f, 2.73767933e-02f, -6.55398965e-02f, -2.65779886e-02f, -1.57009903e-02f, 9.84864961e-03f, 7.64678717e-02f, 6.18481338e-02f,
  -4.53257039e-02f, -2.53954642e-02f, 4.87861224e-03f, 9.31984652e-03f, 9.10739303e-02f, 8.64347164e-03f, -2.76759099e-02f, -1.35504063e-02f, -1.05581678e-01f, 2.11816095e-02f,
  -1.36167660e-01f, -1.55647576e-01f, -1.68289378e-01f, -1.85464509e-02f, -7.97057226e-02f, -1.18156202e-01f, -1.21280894e-01f, -1.24503076e-01f, -1.52037516e-01f, -1.76805675e-01f,
  1.10872179e-01f, -2.48823106e-01f, -3.98767516e-02f, -4.45633642e-02f, -1.14776179e-01f, -1.23773165e-01f, -2.48019844e-01f, -1.42458692e-01f, 1.00932375e-01f, -1.54553548e-01f,
  9.60899070e-02f, 1.57934055e-01f, 1.95599318e-01f, 1.03004999e-01f, -3.37843150e-02f, -1.42802656e-01f, -1.76233158e-01f, 4.22950312e-02f, 6.82075098e-02f, 7.15759844e-02f,
  5.21449298e-02f, 5.01803048e-02f, 1.25506327e-01f, 5.80791989e-03f, 3.56141292e-03f, -5.86884841e-02f, -1.25705466e-01f, 6.25313371e-02f, -5.53955398e-02f, -1.35439143e-01f,
  -5.19843027e-02f, 1.11140512e-01f, -1.90655217e-02f, 3.39161418e-02f, -1.39637794e-02f, -6.14881329e-02f, -5.90447634e-02f, 6.36647791e-02f, -6.11244924e-02f, 6.50639459e-02f,
  1.46297976e-01f, -1.93526037e-02f, -3.30513939e-02f, -1.35539155e-02f, -2.78566033e-02f, 6.25547469e-02f, 4.01417315e-02f, -4.84127738e-02f, -7.84951150e-02f, 3.98284309e-02f,
  2.27836743e-02f, -5.35582080e-02f, -1.26262624e-02f, -6.72754226e-03f, -6.20564446e-02f, 1.96075626e-02f, -9.31919087e-03f, 3.14873233e-02f, 1.23862978e-02f, -3.82718481e-02f,
  -3.86239067e-02f, -9.69064515e-03f, -4.00928371e-02f, 4.15548831e-02f, 2.28410233e-02f, 3.01188231e-02f, 7.06442595e-02f, 1.83558930e-02f, 3.31651941e-02f, 9.75066889e-03f,
  -4.76630492e-04f, -8.13862160e-02f, 1.47236707e-02f, -7.65623003e-02f, 8.19361135e-02f, 3.34213525e-02f, 4.62074727e-02f, -5.21075446e-03f, -5.15316892e-03f, 3.81185226e-02f,
  6.55464653e-04f, 6.36610389e-02f, 1.29328133e-03f, -5.09757688e-03f, -2.57520564e-02f, -1.85468327e-03f, 1.58178098e-02f, 6.23654574e-03f, 1.93054732e-02f, -4.30900678e-02f,
  -9.90094393e-02f, 1.57384023e-01f, 8.59299004e-02f, 1.22300148e-01f, -3.15365158e-02f, -1.61014702e-02f, -5.39003573e-02f, -6.97458684e-02f, 1.22898780e-01f, 3.64073552e-02f,
  -1.59361903e-02f, -5.34789786e-02f, 3.37088085e-03f, -4.34962362e-02f, -5.35642765e-02f, 7.12411152e-03f, -7.55620515e-03f, 1.42115980e-01f, -1.06013902e-02f, -1.12936482e-01f,
  -1.41871855e-01f, 5.55682518e-02f, 3.20920497e-02f, -3.22312228e-02f, 1.05900049e-01f, 1.10225700e-01f, 6.90016448e-02f, -7.65811428e-02f, 6.78396598e-02f, -1.49165913e-01f,
  1.93756700e-01f, 7.08750039e-02f, -1.82882085e-01f, -1.15770690e-01f, -1.34030312e-01f, -2.12150533e-02f, 2.29865573e-02f, 4.42615077e-02f, -6.79294318e-02f, -1.05120547e-01f,
  -3.59761119e-02f, 2.58397916e-03f, -1.43320020e-02f, 3.42555679e-02f, 8.48763436e-02f, 1.28939403e-02f, -1.70407534e-01f, -6.85293376e-02f, 6.84686080e-02f, 5.15592918e-02f,
  -3.54143903e-02f, 1.62337329e-02f, 3.16031612e-02f, 5.20431437e-02f, -1.07759289e-01f, -2.60478240e-02f, -1.22033194e-01f, -1.11254044e-01f, -3.11907940e-02f, -8.71901289e-02f,
  -1.45690307e-01f, 1.05555810e-01f, 1.22333216e-02f, 1.40754715e-01f, -7.40832016e-02f, 6.78620934e-02f, -7.50268847e-02f, -3.66409421e-02f, -8.13342780e-02f, -4.99286242e-02f,
  -5.81749603e-02f, 2.81655639e-02f, 1.99750382e-02f, 3.07204351e-02f, 5.96659556e-02f, 3.06791700e-02f, 1.86984704e-04f, 4.17499542e-02f, -4.35602330e-02f, 4.72054780e-02f,
  6.51159650e-03f, 5.65453656e-02f, 5.95485382e-02f, 3.10224388e-03f, 6.52255490e-02f, -1.82506312e-02f, -2.02517696e-02f, -6.29483759e-02f, 8.83888900e-02f, 3.56897973e-02f,
  9.20281373e-03f, 3.19705680e-02f, -1.72632914e-02f, 6.23551197e-02f, 7.69886672e-02f, -1.68584753e-02f, 4.27005887e-02f, 2.98417080e-02f, -2.60087699e-02f, -8.07031337e-03f,
  -2.60702949e-02f, -6.30422458e-02f, 2.85807215e-02f, 7.82673955e-02f, 4.72008996e-02f, 4.38451245e-02f, 1.01706423e-02f, 1.17698796e-02f, 4.72021401e-02f, -1.91502292e-02f,
  2.65773870e-02f, -3.22640687e-02f, -1.11525275e-01f, -8.18266049e-02f, 5.14691845e-02f, 3.67880389e-02f, -1.64095424e-02f, -2.72001955e-03f, 2.26609968e-02f, -1.53564382e-03f,
  -6.21013716e-02f, 1.43310651e-01f, -1.53030502e-02f, 4.53875959e-02f, -9.19535756e-02f, -6.02638200e-02f, 1.03000542e-02f, 2.28918716e-02f, -1.07526548e-01f, -1.05962761e-01f,
  8.95375088e-02f, 2.09105220e-02f, -1.53567607e-03f, 3.75753269e-02f, -4.45588976e-02f, 4.19781805e-04f, 4.30446416e-02f, 8.62115808e-03f, 7.55506828e-02f, -1.70031264e-02f,
  1.61188748e-02f, 1.02684900e-01f, 1.59748986e-01f, -7.74041750e-04f, -5.70633635e-02f, -3.33054475e-02f, -9.29594114e-02f, -1.75097920e-02f, 1.16506219e-01f, 4.20042686e-02f,
  4.95928526e-03f, 3.17492820e-02f, 1.52529106e-02f, 2.95613296e-02f, -3.31232473e-02f, -1.81228332e-02f, -1.71130851e-01f, -8.01628381e-02f, 2.04996448e-02f, -8.62670094e-02f,
  -3.62221561e-02f, -4.94625233e-02f, 5.56463674e-02f, 4.87177074e-02f, -1.10121295e-01f, -9.32736769e-02f, -3.16395313e-02f, 3.06107514e-02f, -7.03358576e-02f, -8.23240802e-02f,
  2.43189689e-02f, -7.37677291e-02f, -3.96317840e-02f, -1.38478940e-02f, -5.98865636e-02f, -6.78209662e-02f, 5.92492931e-02f, 3.86298150e-02f, -1.00547694e-01f, -6.26171604e-02f,
  2.36532874e-02f, 7.83679169e-03f, 1.06332414e-02f, 3.63770407e-03f, -4.36711498e-02f, -1.00106020e-02f, -5.99246733e-02f, -7.15197921e-02f, -5.42888939e-02f, 6.30139485e-02f,
  -7.99400806e-02f, 3.38123478e-02f, 5.26826419e-02f, 8.08317065e-02f, -5.20693958e-02f, -7.37741441e-02f, 9.34522506e-03f, -6.12472696e-03f, -1.38087163e-03f, -6.30438402e-02f,
  -4.80452143e-02f, -6.90867677e-02f, 8.11758079e-03f, 6.39912114e-02f, -5.55044450e-02f, -7.03930808e-03f, 4.98692654e-02f, 1.59448739e-02f, -9.33161154e-02f, -7.15587521e-03f,
  -1.61504392e-02f, 4.64226939e-02f, 2.66699754e-02f, 3.93644683e-02f, -4.94142994e-02f, 3.71518061e-02f, -9.25207734e-02f, 3.42501700e-02f, -7.79984593e-02f, 7.65206441e-02f,
  -3.29583846e-02f, -1.00315891e-01f, 3.98492143e-02f, 7.26321116e-02f, -1.42483851e-02f, 8.36348683e-02f, -8.32659379e-02f, -2.17405483e-02f, 6.89243078e-02f, 5.71469497e-03f,
  -9.10666659e-02f, 5.34236953e-02f, -1.44651355e-02f, -5.64166866e-02f, -5.14287278e-02f, 7.12294951e-02f, -2.32825540e-02f, -3.23386490e-02f, 6.19719625e-02f, -8.90005007e-02f,
  2.49187648e-02f, -8.86248499e-02f, 9.74596571e-03f, 8.32479075e-02f, -3.28001380e-03f, 3.17531005e-02f, 1.56534780e-02f, -3.76035161e-02f, 8.54053572e-02f, 4.88372371e-02f,
  -2.82496493e-02f, -1.07345851e-02f, 1.65291633e-02f, -5.90252131e-02f, -4.37024273e-02f, -5.97763211e-02f, -5.19584976e-02f, 3.34817357e-02f, 7.32808560e-02f, -6.12629764e-02f,
  -3.00634336e-02f, -2.99506187e-02f, -2.77442336e-02f, 2.18109209e-02f, -3.55874598e-02f, 1.32809468e-02f, -5.30403554e-02f, -1.11429226e-02f, 8.00893232e-02f, -6.94549317e-03f
};

// L0_fan_Bp_bar (Shape: 1 x 40)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 40;
const float L0_fan_Bp_bar_data[] = {
  -3.11691891e-02f, 1.50450185e-01f, -1.22225545e-02f, -1.20517323e-02f, 1.11796997e-01f, 1.81329042e-01f, -2.55511012e-02f, -2.31135115e-02f, 5.26170097e-02f, 1.31356135e-01f,
  2.69693695e-02f, 1.78666770e-01f, 1.18546814e-01f, 5.45683652e-02f, 3.88172828e-02f, 3.87952663e-02f, 1.16280749e-01f, -3.43431835e-03f, 1.49108216e-01f, 5.63719459e-02f,
  3.71432081e-02f, 1.35952055e-01f, 2.16020346e-02f, 8.89820680e-02f, 1.39970079e-01f, 2.04614118e-01f, 4.23812345e-02f, 7.27883652e-02f, 4.42628842e-03f, 1.21002235e-02f,
  3.91414613e-02f, 2.24315777e-01f, -7.02183181e-03f, -2.24130433e-02f, 9.00943503e-02f, 1.06175810e-01f, 1.10766821e-01f, 5.02864011e-02f, 1.29239023e-01f, -7.58446380e-03f
};

// L1_fan_Wp (Shape: 12 x 64)
const int L1_fan_Wp_rows = 12;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  1.81827337e-01f, 1.22507282e-01f, 2.98574954e-01f, -7.67551884e-02f, 1.10448852e-01f, 5.58896773e-02f, -1.41121686e-01f, 7.04677999e-02f, -9.57434103e-02f, 2.20018793e-02f,
  1.25161320e-01f, -1.45520523e-01f, -1.87421441e-01f, -4.57740948e-02f, -1.36981597e-02f, -2.80532300e-01f, 2.09882408e-01f, 2.81006724e-01f, -7.28048384e-02f, 6.92902952e-02f,
  -2.68763721e-01f, -3.16101452e-03f, -1.15728825e-01f, 3.83012772e-01f, 8.09581671e-03f, -2.73967952e-01f, 1.72616169e-02f, 6.79303631e-02f, -1.76890716e-01f, -7.40814134e-02f,
  -1.81084663e-01f, -1.25933960e-01f, -7.56209577e-03f, 3.86131071e-02f, 1.80773392e-01f, 1.71454087e-01f, 1.22269437e-01f, 5.62914312e-02f, 9.00941044e-02f, -1.17990740e-01f,
  -4.50229533e-02f, -2.90818717e-02f, 4.53152470e-02f, 1.49604836e-02f, 1.67136341e-02f, -1.52680635e-01f, -5.90180568e-02f, 3.53532173e-02f, -5.02669998e-02f, 8.36212188e-02f,
  1.08136080e-01f, 2.37730960e-03f, 2.35606935e-02f, 4.52429578e-02f, 4.31394652e-02f, 1.26721442e-01f, -7.13776276e-02f, -3.82999075e-03f, -2.47617215e-02f, -9.54074040e-02f,
  -7.12082237e-02f, -2.08694741e-01f, 3.97936031e-02f, -1.47878155e-01f, 1.30486757e-01f, -1.05015278e-01f, 4.73487489e-02f, 8.78506154e-02f, 1.60608128e-01f, 5.20025678e-02f,
  8.13194439e-02f, 1.73499376e-01f, -4.20055240e-02f, -1.97713733e-01f, 2.44077723e-02f, 2.41507962e-02f, -2.16130227e-01f, 5.94440103e-02f, 6.98229745e-02f, -1.39371887e-01f,
  9.67256725e-02f, -8.82580727e-02f, 1.12990193e-01f, 1.51696935e-01f, -1.04320750e-01f, -1.03873201e-01f, -7.55389631e-02f, 2.49200493e-01f, 1.24191053e-01f, -1.96581364e-01f,
  -9.59836543e-02f, -5.91308586e-02f, -5.62140159e-02f, -9.14183483e-02f, 9.48863104e-02f, -4.00294513e-02f, 8.19445997e-02f, -3.05699725e-02f, -4.49436381e-02f, 9.73895043e-02f,
  9.47994515e-02f, 1.82459582e-04f, -1.20002748e-02f, -1.36572286e-01f, -1.88180953e-02f, 7.34944418e-02f, 6.61326759e-03f, 4.19414863e-02f, -2.05263793e-01f, -1.87297165e-01f,
  1.54371336e-01f, 3.67082730e-02f, 9.29934606e-02f, 2.19184265e-01f, -7.18071312e-02f, 2.21270118e-02f, 1.06361799e-01f, 3.86879258e-02f, 5.39894439e-02f, 1.08482264e-01f,
  5.69056114e-03f, 7.89606422e-02f, 1.60505056e-01f, -7.04024732e-02f, -4.30188095e-03f, -5.61910309e-02f, 1.16855115e-01f, -7.77767375e-02f, 1.78339351e-02f, 1.26852974e-01f,
  -7.67013803e-02f, -1.09001465e-01f, -1.59398392e-01f, 1.29047364e-01f, 1.16908409e-01f, 1.78270005e-02f, 2.12578326e-02f, -4.97962609e-02f, 6.70084506e-02f, 1.18072495e-01f,
  3.81434113e-02f, -1.95508376e-01f, -1.59887239e-01f, 3.12382758e-01f, -3.08685273e-01f, -1.26246303e-01f, 1.23234771e-01f, -1.07296251e-01f, 6.17151298e-02f, 1.02413364e-01f,
  1.32324733e-02f, -2.60624677e-01f, -1.16633803e-01f, 1.03143975e-01f, 3.23129520e-02f, -5.87554425e-02f, 4.87687141e-02f, -7.74773536e-03f, -4.61291932e-02f, -1.99677479e-02f,
  1.12532206e-01f, 4.65789363e-02f, -1.99213654e-01f, -2.33036608e-01f, 7.73681561e-03f, -6.64821118e-02f, -2.31766962e-02f, 1.54979050e-01f, 8.95139277e-02f, -8.15931559e-02f,
  -5.45643941e-02f, -8.21955279e-02f, 9.27466899e-02f, 1.72317207e-01f, -3.92423347e-02f, -3.01501751e-02f, -6.22052252e-02f, -1.76119998e-01f, -3.44914086e-02f, -6.64974153e-02f,
  -4.76608463e-02f, -1.13650836e-01f, -1.05704390e-01f, 7.01288730e-02f, -1.89903211e-02f, -1.66036338e-01f, 5.95831452e-03f, -6.53327629e-02f, 1.91227272e-02f, 2.08832368e-01f,
  -4.00485992e-02f, -6.32525161e-02f, -5.47258109e-02f, 6.67616725e-02f, -9.09800008e-02f, 1.47435039e-01f, 6.49248958e-02f, -3.53609547e-02f, -1.59377173e-01f, -9.69291031e-02f,
  -1.45758586e-02f, -6.30512536e-02f, 4.60491069e-02f, -1.49937168e-01f, 2.09081769e-01f, 1.79426059e-01f, 1.20359316e-01f, -1.34252325e-01f, 1.33841828e-01f, 2.47419551e-01f,
  -8.03124532e-02f, 3.13496619e-01f, -2.11528108e-01f, 1.78919286e-02f, 1.12734377e-01f, 1.26003832e-01f, -3.10638789e-02f, -3.71649303e-02f, -9.79437679e-02f, 7.42223933e-02f,
  1.03352606e-01f, -2.01530844e-01f, -1.59574822e-01f, 2.61808150e-02f, 1.11232206e-01f, -3.05425208e-02f, 2.35094000e-02f, 2.01867476e-01f, -2.05304608e-01f, -1.44195482e-01f,
  -5.05739041e-02f, -8.15241188e-02f, -1.51159633e-02f, 1.05632516e-03f, -2.50023846e-02f, -6.63043112e-02f, -9.25218761e-02f, -9.25448537e-02f, -1.57063097e-01f, -1.19055055e-01f,
  -9.07991305e-02f, 1.10529698e-02f, 1.64736509e-01f, -8.30083936e-02f, 9.50262770e-02f, 1.14035219e-01f, -7.79521987e-02f, -2.06746325e-01f, -7.60228112e-02f, 6.68187737e-02f,
  -1.91697720e-02f, -7.27439597e-02f, 4.77895997e-02f, 8.94137695e-02f, 2.91084014e-02f, 2.53698044e-02f, 1.42886192e-01f, -1.81884214e-01f, 9.18794945e-02f, -7.31350631e-02f,
  -1.71857193e-01f, 9.45868641e-02f, 1.20932713e-01f, -2.47731254e-01f, -9.29002985e-02f, 6.47071153e-02f, 2.98354626e-02f, 1.47795200e-01f, -2.66715009e-02f, -1.07177794e-02f,
  -1.94360673e-01f, 1.19435184e-01f, -2.02583835e-01f, 5.86002991e-02f, 1.79565296e-01f, -3.09983879e-01f, 1.01982318e-01f, -1.08204577e-02f, -2.34370127e-01f, -6.60537034e-02f,
  9.58082303e-02f, 7.14753866e-02f, 1.95429847e-01f, -1.01486377e-01f, 7.78634697e-02f, 3.16117913e-01f, 6.52451906e-03f, -6.66073188e-02f, 1.32679090e-01f, 1.59812391e-01f,
  5.77751212e-02f, 1.67837575e-01f, 9.24085081e-02f, 1.51894078e-01f, 1.16737317e-02f, 1.34758977e-02f, 1.68442398e-01f, -3.71496975e-02f, -1.41958678e-02f, -1.82707116e-01f,
  6.41117692e-02f, 2.07532912e-01f, -2.04501916e-02f, 1.04482457e-01f, 1.07137099e-01f, -2.24251807e-01f, -7.15127364e-02f, 6.39442876e-02f, -2.09167860e-02f, -3.58615965e-02f,
  8.83390233e-02f, 7.26350918e-02f, -6.06821217e-02f, -1.56702742e-01f, 2.38922507e-01f, -5.00720367e-02f, 6.57203272e-02f, -1.14205942e-01f, -2.05177814e-01f, 2.35162396e-02f,
  3.71736661e-02f, 2.29860786e-02f, 1.97732270e-01f, 6.49279207e-02f, -1.68266729e-01f, 2.51828730e-01f, 1.14261411e-01f, 1.48892114e-02f, -3.86065990e-02f, -4.83663790e-02f,
  1.37476683e-01f, 1.81052893e-01f, -3.34620059e-01f, 1.44647926e-01f, -2.84854501e-01f, -2.21492156e-01f, 2.13936239e-01f, -2.96394266e-02f, -8.01688954e-02f, -7.00047985e-02f,
  -1.34739324e-01f, -1.17500059e-01f, -5.31835929e-02f, 3.65494698e-01f, -8.89611617e-02f, -2.14250788e-01f, -7.89560676e-02f, 7.08663762e-02f, -2.71529734e-01f, 1.04737103e-01f,
  -6.54301792e-02f, -1.40364811e-01f, -1.64010912e-01f, 1.19434886e-01f, 1.44165009e-02f, 3.85531113e-02f, 6.06258921e-02f, -2.13836934e-02f, 2.55590588e-01f, -2.28310347e-01f,
  -3.64293419e-02f, -2.36469969e-01f, -2.28302181e-03f, -1.47194162e-01f, -1.67104512e-01f, 1.37156889e-01f, -8.09984934e-03f, -1.93339791e-02f, 2.51697570e-01f, -5.26755042e-02f,
  -1.33392997e-02f, -9.23421532e-02f, -9.03444737e-02f, 8.66294056e-02f, 2.40517482e-02f, 2.91715235e-01f, -8.22239928e-03f, 1.01660758e-01f, 2.11211458e-01f, 8.80477205e-02f,
  -8.36059600e-02f, -1.90583810e-01f, -1.81839183e-01f, 4.03989255e-02f, -1.26731813e-01f, -4.12973315e-02f, 2.22137362e-01f, -1.21506251e-01f, -1.09399915e-01f, 9.92403701e-02f,
  4.68205288e-02f, -6.16736375e-02f, -1.47569656e-01f, 1.41675666e-01f, 2.77441107e-02f, -6.66628554e-02f, -1.45462289e-01f, -1.29380807e-01f, -1.76383987e-01f, -1.36279687e-01f,
  -7.65813515e-03f, 7.57532865e-02f, 2.66294539e-01f, -3.08115870e-01f, 1.88726634e-01f, 7.45298788e-02f, -2.99627453e-01f, 2.01444134e-01f, 2.99010500e-02f, -1.94044650e-01f,
  2.26699635e-02f, 1.74468443e-01f, -1.91973239e-01f, -4.23906185e-02f, 1.93233237e-01f, 1.43254949e-02f, 1.19506463e-01f, 1.47675164e-02f, -7.97284022e-02f, 2.33038113e-01f,
  1.86247975e-01f, 2.22703479e-02f, -6.83266893e-02f, -1.69286191e-01f, -1.31824598e-01f, 2.55380198e-03f, 1.11544505e-01f, -9.37714279e-02f, -2.01207638e-01f, 1.85990185e-01f,
  -3.48635465e-02f, -2.39729229e-02f, 5.56665985e-03f, -5.27258730e-04f, -1.88071191e-01f, 4.92823273e-02f, -9.14059207e-02f, 1.19767174e-01f, 1.38113678e-01f, 1.89306632e-01f,
  4.04068679e-02f, 1.03078298e-01f, 1.59433395e-01f, 2.80619841e-02f, -1.79039642e-01f, -2.16482177e-01f, -1.16040133e-01f, -2.57759094e-02f, -4.04296070e-03f, -1.10954016e-01f,
  2.26951595e-02f, -1.73563018e-01f, 9.00209919e-02f, 8.77608582e-02f, 6.33408055e-02f, -5.67838252e-02f, 9.15760025e-02f, 5.68803586e-02f, 9.85622481e-02f, -1.22683728e-02f,
  3.97423394e-02f, -1.37341112e-01f, 1.22884743e-01f, -4.05312404e-02f, -2.23616853e-01f, -1.13493472e-01f, 7.04549253e-02f, 8.47104639e-02f, 1.93091169e-01f, 2.19998464e-01f,
  -2.81314760e-01f, -5.83527051e-02f, -6.70702532e-02f, 4.52873595e-02f, 1.08713336e-01f, -1.36076584e-01f, 4.75424342e-03f, -4.84187081e-02f, 1.91767979e-02f, 3.01294029e-02f,
  7.25421160e-02f, 9.06020477e-02f, 5.51629774e-02f, 1.04285087e-02f, 2.03038156e-01f, -9.69246030e-02f, -1.70129478e-01f, -1.12174703e-02f, 8.93254951e-02f, -1.58460941e-02f,
  1.08739525e-01f, 1.11243561e-01f, -4.13505584e-02f, 8.90503451e-02f, 1.04406141e-01f, 2.06163049e-01f, -1.14889547e-01f, 1.10205412e-01f, -4.52459455e-02f, 1.24501601e-01f,
  7.55875930e-02f, -1.14247561e-01f, -3.29828784e-02f, -1.67431775e-02f, 4.71986318e-03f, 1.17243128e-02f, 5.27168177e-02f, -6.00582846e-02f, 2.20303424e-02f, 5.01992330e-02f,
  1.36028588e-01f, 7.28123561e-02f, -1.09186061e-01f, -5.11289723e-02f, -6.55733608e-03f, -4.38164324e-02f, -1.14823103e-01f, -1.14981443e-01f, -4.34125848e-02f, -1.37904119e-02f,
  -9.31847021e-02f, -1.49255991e-01f, 5.44035919e-02f, -8.04791078e-02f, -1.12133719e-01f, -1.98042840e-02f, -2.08847612e-01f, -7.07432106e-02f, 3.25906314e-02f, 2.71473199e-01f,
  3.29398178e-02f, -1.16178103e-01f, -5.79874478e-02f, 6.92758933e-02f, -2.58528680e-01f, 2.90311217e-01f, 4.34116237e-02f, -5.49277999e-02f, -1.48223028e-01f, 1.30411819e-01f,
  -1.69420447e-02f, 1.27283201e-01f, -4.10352461e-02f, 5.36796488e-02f, 4.64926660e-02f, -3.00074415e-03f, -9.72814038e-02f, 6.26842901e-02f, 9.44588259e-02f, -7.14430884e-02f,
  -8.77463594e-02f, -1.99197724e-01f, -9.37747583e-02f, -9.91518274e-02f, 1.41114637e-01f, -1.19591668e-01f, -1.75147802e-01f, -5.17744273e-02f, -8.40265155e-02f, -1.12657566e-02f,
  3.93879488e-02f, 6.74810410e-02f, 1.25362769e-01f, 1.69808447e-01f, -1.01058394e-01f, 1.18299536e-01f, 9.89091545e-02f, 3.99050191e-02f, 4.70298789e-02f, -5.16985506e-02f,
  1.75685838e-01f, -1.76287442e-01f, -1.18293211e-01f, -2.42513165e-01f, -1.25317112e-01f, -7.10777789e-02f, 9.95001867e-02f, -3.68851572e-02f, 6.47887364e-02f, 5.73176742e-02f,
  -3.71180736e-02f, -6.28267601e-02f, 8.75107720e-02f, -4.99211513e-02f, -2.79693305e-02f, -5.49070016e-02f, 1.56367183e-01f, -7.42257088e-02f, -4.84193340e-02f, -9.74879116e-02f,
  2.03200638e-01f, -1.08572066e-01f, -6.63532540e-02f, 2.90309399e-01f, 6.84918324e-03f, -4.35647182e-02f, 1.36715069e-01f, -5.35463206e-02f, -2.57782549e-01f, 1.17387854e-01f,
  -1.06592789e-01f, -1.70190573e-01f, -8.09391588e-02f, 9.05665979e-02f, -1.45580441e-01f, -1.05114743e-01f, -2.13413239e-02f, 1.13677762e-01f, 3.97454500e-02f, -3.08942739e-02f,
  9.54911113e-02f, 8.68094265e-02f, 5.62361144e-02f, -1.12228524e-02f, -3.39596458e-02f, -1.33995339e-01f, -9.63378996e-02f, 5.58140352e-02f, 5.05295247e-02f, -9.31868851e-02f,
  -1.48271516e-01f, -4.87132780e-02f, 8.34505334e-02f, 2.78808083e-02f, -1.08296722e-01f, 3.06627192e-02f, -1.10814616e-01f, 1.14270009e-01f, -6.38231449e-03f, 1.34618327e-01f,
  -7.95922875e-02f, -6.02985546e-02f, -1.42357247e-02f, -5.61177209e-02f, 5.80270961e-02f, -9.00717303e-02f, -1.00079678e-01f, 3.98171321e-02f, 4.87867706e-02f, -1.70241054e-02f,
  -9.93891954e-02f, 8.10895935e-02f, 1.87723562e-01f, 5.35561368e-02f, -1.51413634e-01f, 8.90760124e-02f, -7.71122426e-02f, -7.34257102e-02f, 2.09849607e-02f, 6.68507665e-02f,
  4.93101664e-02f, -1.85228691e-01f, -2.07539335e-01f, 2.63088465e-01f, 1.15934975e-01f, -2.00754747e-01f, 1.08253449e-01f, 4.05722037e-02f, 2.05880284e-01f, -1.72859058e-01f,
  1.48867339e-01f, 7.89269581e-02f, -9.31168124e-02f, 1.86211556e-01f, 7.84307793e-02f, -1.68673828e-01f, 4.98088524e-02f, -3.16075422e-02f, 1.05856858e-01f, -2.66638458e-01f,
  1.24546640e-01f, 5.94690852e-02f, -4.61597815e-02f, -5.55777028e-02f, 1.82477802e-01f, 3.03045005e-01f, -1.29206672e-01f, -3.07018794e-02f, -7.03613386e-02f, -1.03468142e-01f,
  -2.26479456e-01f, -4.54090200e-02f, -9.53541920e-02f, -1.38712570e-01f, -1.07087657e-01f, -1.42075673e-01f, -1.37014072e-02f, -1.35464251e-01f, 4.47207429e-02f, 1.78667814e-01f,
  1.02963589e-01f, 5.01021110e-02f, 9.08971503e-02f, 1.64921671e-01f, 1.43827572e-01f, 4.70237024e-02f, 8.25027525e-02f, 8.34748000e-02f, -3.00880373e-02f, 1.39342546e-01f,
  -1.73033878e-01f, -1.26468927e-01f, 1.04740359e-01f, 3.29091102e-02f, -3.67506780e-02f, -1.50456965e-01f, -4.95251380e-02f, 6.36565611e-02f, 4.03982066e-02f, -2.04696041e-02f,
  -7.73337260e-02f, 3.15991826e-02f, -5.96136637e-02f, -2.25607812e-01f, -1.88927650e-01f, -1.41746461e-01f, -1.98748678e-01f, -2.17628554e-01f, -2.18508959e-01f, -2.27230236e-01f,
  1.64091349e-01f, -1.43521242e-02f, -1.50317743e-01f, 5.49322367e-02f, -3.99785370e-01f, -1.18807167e-01f, -7.81679451e-02f, 4.38136429e-01f, 3.05404440e-02f, -2.14965850e-01f,
  -2.22439632e-01f, -1.49965346e-01f, 4.00354788e-02f, 1.53247379e-02f, 2.28587706e-02f, -8.05007145e-02f, -6.65312260e-02f, -1.00311130e-01f, -3.13622840e-02f, -1.59025431e-01f,
  1.33973226e-01f, -5.78167923e-02f, 1.90799996e-01f, -1.71167567e-01f, -4.32166345e-02f, 8.02120939e-02f, 1.07882433e-01f, -1.41166672e-02f, 3.19934152e-02f, -7.77882412e-02f,
  3.07233315e-02f, 1.36370480e-01f, 1.08180970e-01f, 1.62320644e-01f, 1.78398281e-01f, -6.12269528e-02f, -9.24374461e-02f, -3.27756116e-03f, -7.78457820e-02f, 1.96586534e-01f,
  -3.73928808e-02f, -5.22471219e-02f, 1.41149670e-01f, -1.09503716e-01f, -2.06872933e-02f, 1.67570170e-02f, 9.60454904e-03f, -8.60846043e-02f
};

// L1_fan_Wp_bar (Shape: 40 x 64)
const int L1_fan_Wp_bar_rows = 40;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  -3.46893147e-02f, 9.17786136e-02f, 5.55473268e-02f, 1.12127438e-01f, -2.19195075e-02f, 1.30954191e-01f, -1.73996519e-02f, 4.56722863e-02f, 1.41492277e-01f, 4.25296687e-02f,
  -1.46603351e-02f, 2.37644181e-01f, -4.47063474e-03f, -3.06398179e-02f, -1.26778290e-01f, 6.67728037e-02f, 2.24616174e-02f, 3.27447727e-02f, -1.02058396e-01f, 9.53688845e-02f,
  -1.55009195e-01f, -7.54364282e-02f, -7.31555978e-03f, -6.48214370e-02f, 2.06218921e-02f, -5.48789538e-02f, 5.42296004e-03f, -2.62356382e-02f, 8.17354694e-02f, 1.52776942e-01f,
  -3.84799019e-02f, -1.01153314e-01f, 2.17947010e-02f, -2.20860075e-03f, 4.31063697e-02f, -1.42785490e-01f, 1.10324338e-01f, 1.20688781e-01f, -4.77532297e-02f, -4.77574132e-02f,
  -1.92803517e-02f, -1.36006912e-02f, 1.10792950e-01f, -9.81456414e-02f, -2.38084272e-02f, 9.71108079e-02f, -9.30483639e-02f, -9.47699323e-02f, 1.87703729e-01f, 4.83392663e-02f,
  4.56327200e-02f, -5.95618412e-02f, 1.39167175e-01f, 3.19577823e-03f, -1.41602904e-01f, 1.60639942e-01f, -6.40173107e-02f, 3.89485583e-02f, -1.13713622e-01f, 1.00262918e-01f,
  8.00167769e-02f, -4.85543609e-02f, -4.87233661e-02f, 9.92427245e-02f, -3.15543450e-02f, 9.43997875e-02f, 2.93273125e-02f, 1.44091859e-01f, 4.31884415e-02f, 6.20042114e-03f,
  2.40244657e-01f, 1.77004039e-01f, 1.48172826e-01f, -1.14489228e-01f, 1.42464563e-01f, 2.82451451e-01f, -2.95191079e-01f, 1.69823810e-01f, -1.01136342e-02f, -6.71231076e-02f,
  7.74573237e-02f, -2.44824842e-01f, 1.37153149e-01f, 5.00073768e-02f, 4.45376290e-03f, 7.21337050e-02f, 3.52964140e-02f, 4.55063172e-02f, -3.85376252e-02f, 1.02332838e-01f,
  -7.15104863e-02f, 7.60388002e-02f, 2.13044897e-01f, 9.07820016e-02f, 4.95975986e-02f, 2.40992177e-02f, 2.03911532e-02f, 1.32280543e-01f, 9.61497575e-02f, 5.07859290e-02f,
  1.33610725e-01f, 1.65641196e-02f, 1.02524243e-01f, -9.65131894e-02f, -7.37571716e-02f, 4.20367625e-03f, -1.04623638e-01f, -1.15116704e-02f, 4.00400423e-02f, -2.50405930e-02f,
  6.43858165e-02f, 8.75651464e-02f, 2.18524843e-01f, -2.55864840e-02f, 7.73865059e-02f, 8.18433538e-02f, 1.80679222e-03f, 3.42234746e-02f, 2.15968937e-02f, 2.72626817e-01f,
  -1.51574872e-02f, 1.45511299e-01f, 1.79747865e-01f, 1.62668020e-01f, 8.49868879e-02f, -1.47805288e-01f, 3.21264006e-02f, 6.82856962e-02f, 1.80964068e-01f, 9.16531533e-02f,
  2.16237709e-01f, 1.89381674e-01f, -4.84652035e-02f, 2.05481097e-01f, 1.09620661e-01f, 4.12984751e-02f, -4.78650406e-02f, 1.29093468e-01f, 1.17238201e-02f, -1.60749797e-02f,
  2.99959574e-02f, -7.75417760e-02f, -1.80344302e-02f, -8.85231718e-02f, 9.61293373e-03f, 1.96771458e-01f, -2.60837466e-01f, 2.34785661e-01f, -2.86578625e-01f, 7.82017261e-02f,
  2.39089727e-01f, 9.37106535e-02f, 3.96245047e-02f, -6.71366975e-02f, 5.45320380e-03f, -4.41422015e-02f, 4.01285775e-02f, 8.40506181e-02f, -1.38624132e-01f, -5.93504645e-02f,
  -9.76001397e-02f, -1.31237462e-01f, 1.31202534e-01f, 1.68123186e-01f, 6.89720586e-02f, 9.05420780e-02f, -3.23217995e-02f, -1.21690735e-01f, 3.17653641e-02f, -1.28764972e-01f,
  1.69405460e-01f, -8.15359801e-02f, -4.77407651e-04f, -1.15645275e-01f, -1.34668484e-01f, -1.09642588e-01f, 1.20563678e-01f, 1.73069581e-01f, 2.05564126e-01f, 8.86757001e-02f,
  -3.06512956e-02f, -2.73284242e-02f, 4.45716977e-02f, 1.12582743e-01f, -4.18376587e-02f, -1.09983876e-01f, -2.54582297e-02f, 1.29707187e-01f, -2.99410727e-02f, -3.44866849e-02f,
  1.02015518e-01f, 6.10987470e-02f, 4.58693318e-02f, 9.25331414e-02f, 3.66949849e-02f, 3.99920754e-02f, -9.19056758e-02f, 1.53931811e-01f, -5.73091321e-02f, -7.59177431e-02f,
  -3.93013433e-02f, 4.66503911e-02f, 8.10342506e-02f, 6.43329881e-03f, 8.10750574e-02f, 6.23261184e-02f, 1.35734737e-01f, 2.62662638e-02f, -2.40918249e-02f, -3.76827680e-02f,
  4.17567268e-02f, -9.80376638e-03f, -1.23549692e-01f, -1.48212343e-01f, 2.39807174e-01f, -7.45835155e-02f, -9.71959308e-02f, 1.83418065e-01f, 9.17912647e-02f, -4.42913249e-02f,
  1.55887067e-01f, -6.83116466e-02f, 8.73006880e-02f, -1.39689252e-01f, -4.60348986e-02f, -1.08151026e-02f, 1.10482506e-01f, -1.04656704e-01f, 4.99011166e-02f, -7.63161927e-02f,
  -1.44900726e-02f, 3.11210752e-02f, 2.64405217e-02f, -1.43836541e-02f, -6.84428662e-02f, 1.50658349e-02f, 1.09310172e-01f, -8.19114298e-02f, 1.09594025e-01f, 3.34789753e-02f,
  -8.97198543e-02f, 8.45469162e-02f, 8.24742019e-02f, -7.22056115e-03f, 4.87220511e-02f, 1.98877081e-02f, -1.06050596e-01f, -1.22127742e-01f, 5.81189990e-02f, 8.12153891e-02f,
  -2.71465275e-02f, 1.12330668e-01f, 3.02640330e-02f, 1.06725521e-01f, 1.18782528e-01f, 6.69602752e-02f, -4.23262455e-03f, -1.19051160e-02f, 2.31684484e-02f, -2.57283486e-02f,
  9.90835764e-03f, -6.28887564e-02f, -1.32187530e-02f, 1.17591143e-01f, 9.46588591e-02f, -6.07355833e-02f, 1.61269650e-01f, -6.56979084e-02f, -1.91572271e-02f, 6.58169687e-02f,
  1.64999202e-01f, 8.70729834e-02f, -1.10567167e-01f, 3.87610644e-02f, -4.05082591e-02f, -1.20994866e-01f, 7.48248249e-02f, -6.93770498e-02f, -5.37847988e-02f, 1.76916514e-02f,
  -4.64172475e-02f, -2.77920980e-02f, -2.63320729e-02f, 2.53218058e-02f, -1.10965453e-01f, 6.15614057e-02f, -9.05959830e-02f, 8.67461935e-02f, -1.00045130e-01f, 2.51402128e-02f,
  1.14189722e-01f, 1.32029235e-01f, 4.75844480e-02f, -1.06147543e-01f, -1.26412556e-01f, 1.26893312e-01f, 9.04322863e-02f, 9.15438458e-02f, -4.94025908e-02f, 1.91715360e-02f,
  1.07202016e-01f, 5.72403409e-02f, 6.71111196e-02f, 7.15274885e-02f, 9.67721343e-02f, -8.06719512e-02f, 1.05390608e-01f, 9.38334018e-02f, -8.35556723e-03f, 6.89440072e-02f,
  7.67916590e-02f, -1.61307901e-01f, 3.48289683e-02f, 2.71353684e-02f, 6.28716573e-02f, -1.08054243e-01f, -2.58853529e-02f, -7.51462281e-02f, 1.43004870e-02f, 6.69522360e-02f,
  1.52080253e-01f, 2.97489557e-02f, 7.56666344e-03f, -1.03357181e-01f, 2.50508897e-02f, 2.59591583e-02f, -1.03435934e-01f, -1.02148727e-02f, -1.33738577e-01f, 1.45581350e-01f,
  8.08067173e-02f, -1.95413530e-02f, 1.13284267e-01f, 1.29378900e-01f, 8.00334439e-02f, 7.51518980e-02f, 9.95903388e-02f, 1.33617178e-01f, 1.21975809e-01f, 7.88798705e-02f,
  -2.18574144e-02f, -2.04603244e-02f, -5.30844107e-02f, -2.93549839e-02f, -1.04986066e-02f, 1.09493703e-01f, -1.04139723e-01f, 4.66731079e-02f, 6.61391169e-02f, -8.53823721e-02f,
  -2.91061606e-02f, 3.23129483e-02f, 6.99440241e-02f, -2.74294093e-02f, 7.13612884e-02f, -4.21293825e-02f, -3.01681366e-02f, -1.01607498e-02f, -5.41836061e-02f, 9.65039581e-02f,
  -1.10569462e-01f, -1.10450059e-01f, -1.07423559e-01f, 6.22797683e-02f, 5.20377867e-02f, 6.13884479e-02f, -8.43867809e-02f, -7.05161989e-02f, -7.72658437e-02f, -4.09082770e-02f,
  -2.80553978e-02f, 1.00364462e-01f, -8.15901309e-02f, 9.03924033e-02f, -9.71694663e-02f, -7.99775049e-02f, -7.77760819e-02f, -1.24876529e-01f, -1.24938853e-01f, 6.87387884e-02f,
  1.10436879e-01f, -1.10035717e-01f, -2.98888348e-02f, 1.19978353e-01f, -3.94521281e-02f, 9.89060476e-02f, -2.18880009e-02f, -1.02336137e-02f, -3.70134898e-02f, -9.13189054e-02f,
  6.96250871e-02f, -1.09222054e-01f, -4.37049661e-03f, 1.41698286e-01f, -6.35748208e-02f, 7.50907511e-02f, 1.90807565e-04f, -7.46461153e-02f, -5.86605594e-02f, 5.63868880e-02f,
  -1.65178612e-01f, 4.18065079e-02f, -8.72123986e-02f, -4.53517102e-02f, -1.13025628e-01f, 6.11965060e-02f, 8.81354511e-02f, 6.77720085e-02f, -8.80010054e-02f, 1.52892023e-01f,
  -7.59349540e-02f, -2.53789928e-02f, 2.55352128e-02f, -6.72276542e-02f, -1.20522216e-01f, 8.86836648e-03f, -1.31762862e-01f, -6.56572878e-02f, 2.70548556e-02f, 1.24968365e-02f,
  7.55386725e-02f, -4.52848598e-02f, -3.99563909e-02f, -4.26946841e-02f, 1.36148542e-01f, 7.07728183e-03f, -6.85087740e-02f, 1.21058084e-01f, 3.90310064e-02f, 9.35527012e-02f,
  -1.20195940e-01f, 1.22232147e-01f, -1.38386652e-01f, -1.24582753e-01f, -9.52933654e-02f, 1.75507367e-02f, -5.78684211e-02f, -2.53148680e-03f, 9.51465592e-02f, -1.05549037e-01f,
  1.96630973e-02f, -1.13029487e-01f, 6.99739382e-02f, -1.13026075e-01f, -7.12674558e-02f, 4.09342982e-02f, -7.44483492e-04f, 1.17888659e-01f, 1.40194446e-01f, -4.30912599e-02f,
  -8.62935707e-02f, -2.60713622e-02f, 1.18888535e-01f, -5.32656834e-02f, -6.53607026e-02f, -2.23062560e-02f, -5.95226064e-02f, 1.47936612e-01f, -4.63370420e-02f, 2.19966564e-02f,
  1.08219348e-01f, 6.01005182e-02f, 1.94456801e-01f, -1.29811302e-01f, 2.70684585e-02f, 4.45660874e-02f, -2.25746650e-02f, -9.42761004e-02f, 5.53399371e-03f, 1.55351404e-02f,
  6.28116503e-02f, -1.09066345e-01f, 1.25944829e-02f, -8.60390514e-02f, 1.02634013e-01f, 9.34460536e-02f, 1.13143109e-01f, -1.14648722e-01f, 1.10174984e-01f, -3.40552405e-02f,
  -5.17305136e-02f, 8.65497887e-02f, -9.63652432e-02f, 1.90343350e-01f, -8.07639509e-02f, -1.25792176e-01f, -3.49549241e-02f, 1.01098202e-01f, 1.00630432e-01f, 3.19817066e-02f,
  8.08746740e-02f, -2.49774102e-02f, -5.05000390e-02f, -4.46874052e-02f, 1.28058165e-01f, 5.11098281e-02f, 8.49397853e-02f, 1.27987459e-01f, 1.36504635e-01f, 5.14031239e-02f,
  -2.68496331e-02f, 1.89430956e-02f, -1.61135811e-02f, -1.47197083e-01f, 6.05413951e-02f, -9.18381438e-02f, 3.85001078e-02f, 2.42128558e-02f, -1.37782604e-01f, -2.45698895e-02f,
  -3.39339953e-03f, 4.68239523e-02f, -6.26548678e-02f, 1.48722036e-02f, 1.00991376e-01f, -1.12487108e-01f, 1.51301965e-01f, 8.92574154e-03f, -8.76799151e-02f, 6.39132187e-02f,
  -1.68125350e-02f, 1.45989046e-01f, 4.30231914e-02f, 6.56468235e-03f, 8.48235935e-02f, -1.22517683e-01f, -9.51235667e-02f, -1.59817129e-01f, -3.40435095e-02f, 1.33763313e-01f,
  -1.18006751e-01f, -2.14679148e-02f, -1.25584304e-01f, -9.55141932e-02f, -1.00103818e-01f, 1.17132336e-01f, -8.42288062e-02f, -5.37334606e-02f, 9.58291069e-03f, 1.00144260e-01f,
  -7.04374090e-02f, -1.91220513e-03f, -1.25488341e-01f, 2.64058262e-02f, -6.03181869e-02f, -2.52992194e-02f, -1.06473893e-01f, 3.52049954e-02f, -1.10386647e-01f, 4.68947440e-02f,
  -2.86775120e-02f, 2.94549149e-02f, 1.12925060e-01f, 3.87131721e-02f, 5.44299558e-02f, 1.88484020e-03f, -4.88085113e-02f, -7.65659846e-03f, -1.54785991e-01f, -1.36508029e-02f,
  3.66683155e-02f, -9.72726718e-02f, -2.56777499e-02f, -6.02735430e-02f, 6.17043599e-02f, 5.17004691e-02f, 7.67169446e-02f, -7.44737610e-02f, -1.31267294e-01f, 4.36639600e-02f,
  3.18095908e-02f, 1.07094757e-01f, -6.88005686e-02f, -1.31364539e-01f, -6.96975961e-02f, -9.54945534e-02f, 7.61502087e-02f, -4.71805185e-02f, -5.07792309e-02f, 1.60260841e-01f,
  2.55048536e-02f, 1.21934138e-01f, -1.77536458e-02f, -9.13655907e-02f, 9.49983522e-02f, -1.05748288e-01f, 8.26714262e-02f, 3.48041169e-02f, 1.29444182e-01f, -1.69378042e-01f,
  9.48505551e-02f, 1.57535300e-01f, -2.07425077e-02f, -2.42874809e-02f, -1.18827529e-01f, -4.59397491e-03f, 3.08788922e-02f, -2.54350118e-02f, 1.50306493e-01f, -3.28144990e-02f,
  -4.65041846e-02f, 1.86532199e-01f, -5.55817224e-02f, -7.51302689e-02f, -3.06639746e-02f, 2.96777599e-02f, -5.86268269e-02f, -8.40381458e-02f, -4.81308810e-02f, -3.03181205e-02f,
  1.36302114e-02f, 1.16405897e-01f, -1.37375100e-02f, -4.82544228e-02f, 6.09541759e-02f, 1.62080765e-01f, 1.11414313e-01f, 6.35759011e-02f, 3.70542705e-02f, -9.92147904e-03f,
  -1.83947738e-02f, -1.23545408e-01f, 9.44664702e-02f, -8.37977529e-02f, 8.01071450e-02f, 1.83204949e-01f, 1.91088334e-01f, 2.23277919e-02f, 3.39970291e-02f, 9.63828862e-02f,
  -6.62564114e-02f, 7.88374152e-03f, -1.66434664e-02f, -9.16337296e-02f, -1.50341883e-01f, 6.92294762e-02f, -3.38512771e-02f, 1.94083497e-01f, 1.50323957e-01f, 1.11369275e-01f,
  1.19650647e-01f, -5.92376031e-02f, 5.61888441e-02f, 6.36970326e-02f, 6.91740438e-02f, -9.17744040e-02f, 1.26797304e-01f, -3.65226083e-02f, 1.50751889e-01f, -9.74141210e-02f,
  1.36595860e-01f, 1.88714355e-01f, 5.49551509e-02f, -8.62810090e-02f, -5.36501408e-03f, -1.26377061e-01f, -1.36969298e-01f, -9.84970704e-02f, 7.95372948e-03f, 2.65563205e-02f,
  1.22647904e-01f, 1.41665235e-01f, 7.96910301e-02f, -8.23505670e-02f, -6.47996664e-02f, 1.41202644e-01f, -6.88795140e-03f, 1.41192437e-03f, -3.19626182e-02f, 3.64932306e-02f,
  -7.34837800e-02f, -8.26554075e-02f, -8.89439881e-02f, -5.55820949e-02f, -8.42790976e-02f, -5.40958270e-02f, 1.32987544e-01f, 3.04192975e-02f, -7.69376615e-03f, 2.44527757e-02f,
  -1.95361786e-02f, -1.76940393e-02f, -4.07139026e-02f, -7.95069560e-02f, -8.51206407e-02f, -4.56452146e-02f, 9.24308077e-02f, 2.08557229e-02f, 4.58085164e-02f, -1.51085496e-01f,
  -7.86911696e-02f, -4.47569489e-02f, 1.89237520e-02f, -4.68253940e-02f, 1.28583740e-02f, 1.30834669e-01f, -1.15041688e-01f, -1.21873863e-01f, -8.78206939e-02f, 2.42927126e-04f,
  4.68854085e-02f, 7.67771602e-02f, 1.50082149e-02f, -5.40840253e-02f, 7.47669935e-02f, 3.87655050e-02f, 3.96418348e-02f, 9.06312168e-02f, 8.91088992e-02f, 5.48708392e-03f,
  8.82602111e-02f, 4.20351848e-02f, 9.51292142e-02f, 2.72738505e-02f, 1.30974967e-02f, 1.23233281e-01f, 1.25981465e-01f, -8.07944834e-02f, -1.43495083e-01f, -9.56755038e-03f,
  -2.55146548e-02f, -4.13415767e-02f, -7.49729350e-02f, 1.21886045e-01f, -2.37347782e-01f, 2.08947770e-02f, 4.38217372e-02f, -3.95759456e-02f, -1.05158776e-01f, 9.19528827e-02f,
  3.52247022e-02f, -1.16058446e-01f, -4.93773585e-03f, 2.17532441e-01f, -1.15293823e-01f, 8.95208269e-02f, 7.50168189e-02f, -1.46934643e-01f, -1.06195115e-01f, -4.95938165e-03f,
  4.95991204e-04f, 1.05743974e-01f, 1.41909942e-01f, 4.75087464e-02f, 1.01683505e-01f, -1.38089415e-02f, 1.32373109e-01f, -1.87213756e-02f, 9.77022052e-02f, 1.96254089e-01f,
  1.01665057e-01f, 7.11998269e-02f, 8.42820629e-02f, 1.10078916e-01f, 1.17598854e-01f, -9.30357650e-02f, -5.32005876e-02f, 8.89695138e-02f, -3.14043835e-02f, -2.00786218e-02f,
  -5.51932976e-02f, 1.07885152e-01f, -1.11788690e-01f, 9.33253989e-02f, -1.98983438e-02f, 1.36515036e-01f, -1.49478689e-01f, 7.30774403e-02f, 2.62747973e-01f, 1.26940971e-02f,
  2.09038988e-01f, -1.27845695e-02f, -1.52418688e-01f, 5.52448966e-02f, 1.83158889e-01f, 4.77684569e-03f, 2.27208123e-01f, 9.09287017e-03f, 2.01954693e-01f, 5.29222824e-02f,
  -1.14970980e-02f, -6.31639138e-02f, 1.10336766e-01f, -5.46731912e-02f, -2.75945902e-01f, -7.14205429e-02f, 7.37777501e-02f, -2.14876622e-01f, 1.06085479e-01f, 6.10131659e-02f,
  -2.39603475e-01f, -1.88133880e-01f, -4.01863083e-02f, 2.63111591e-01f, 2.07220495e-01f, -9.88612548e-02f, -6.83886334e-02f, 8.55784193e-02f, 1.81833860e-02f, -4.77754809e-02f,
  2.00545788e-02f, 1.55156955e-01f, 5.76047227e-02f, 4.06996831e-02f, 2.76895791e-01f, 1.82627141e-01f, -8.55552331e-02f, 1.97417587e-01f, 1.65264592e-01f, -1.13647103e-01f,
  -5.21254130e-02f, 9.87307578e-02f, 1.73518896e-01f, 3.05814475e-01f, -1.07739866e-01f, 1.62466124e-01f, -1.68495271e-02f, -1.15939945e-01f, -1.11951858e-01f, 6.46823049e-02f,
  8.53765234e-02f, 9.45837721e-02f, -6.68166205e-02f, -8.58248100e-02f, 5.86171001e-02f, 1.37947068e-01f, 8.09504315e-02f, -5.86705878e-02f, -7.19757145e-03f, -1.20721363e-01f,
  9.44148302e-02f, 6.18411899e-02f, 3.34887840e-02f, 1.28642106e-02f, 2.61984058e-02f, 1.34435579e-01f, -2.40266863e-02f, -5.93949594e-02f, 5.98436221e-02f, -4.93165329e-02f,
  -5.64331710e-02f, -2.97202193e-03f, 4.64547612e-02f, -8.84450227e-02f, -1.57559007e-01f, 1.95189044e-02f, -1.44650543e-03f, 1.57220334e-01f, 8.07879716e-02f, 7.13546425e-02f,
  4.22331393e-02f, -2.51529932e-01f, 1.95982203e-01f, 7.46794492e-02f, -2.21360475e-01f, 1.57121092e-01f, -6.14186227e-02f, 4.59238626e-02f, 2.94072516e-02f, -6.94321319e-02f,
  1.28103673e-01f, -6.97671250e-02f, 7.45291449e-03f, -6.96685240e-02f, 4.48664315e-02f, 1.67979360e-01f, 7.91684911e-02f, 1.04695126e-01f, -2.71322858e-02f, 1.16226785e-01f,
  -2.61765644e-02f, -8.77198502e-02f, -1.93783995e-02f, -1.46087676e-01f, 1.14318416e-01f, -1.33219525e-01f, 7.74633586e-02f, 1.25747681e-01f, 1.77010328e-01f, 5.08673191e-02f,
  1.79310277e-01f, 2.89422534e-02f, -1.16675593e-01f, 9.72609594e-02f, 8.12627673e-02f, 2.91707367e-02f, -5.44805638e-02f, 2.39119276e-01f, 8.75742063e-02f, -1.25446692e-01f,
  1.59879997e-01f, 7.22694397e-02f, -8.98088887e-02f, -1.18053429e-01f, -7.33990967e-02f, 1.05531685e-01f, -6.41288534e-02f, 1.70438811e-01f, 8.73727277e-02f, -3.77511792e-02f,
  -5.08203469e-02f, 9.51730758e-02f, 1.99611545e-01f, 8.49657808e-04f, 3.25360000e-02f, 1.22255124e-01f, 1.43899202e-01f, -8.65487009e-02f, -3.53298485e-02f, 1.05974145e-01f,
  1.12857707e-01f, -4.00079899e-02f, -6.90638870e-02f, -3.40237692e-02f, 1.14221126e-01f, 2.59364489e-02f, 1.73271358e-01f, -3.34409960e-02f, -1.32812902e-01f, -7.53590539e-02f,
  9.01914537e-02f, 1.21785924e-01f, -1.19769961e-01f, 1.32599592e-01f, 1.84377894e-01f, 8.66885707e-02f, 7.34591037e-02f, 1.20826863e-01f, 8.44797865e-02f, -4.78126593e-02f,
  8.03762525e-02f, 1.33844763e-01f, 8.88836458e-02f, -1.26780629e-01f, -1.43620655e-01f, -9.75284278e-02f, -6.26552943e-03f, -5.74055426e-02f, -1.04040980e-01f, -3.92631022e-03f,
  -8.03687721e-02f, 2.01091673e-02f, 1.90309986e-01f, -1.82765666e-02f, -1.11090332e-01f, 2.35785693e-01f, -4.83094677e-02f, -1.17099029e-03f, 4.20220848e-03f, -7.29369000e-02f,
  1.32345021e-01f, -7.74822012e-02f, 1.94097944e-02f, -6.30516699e-03f, 1.30983010e-01f, -7.38233374e-03f, -1.21369064e-02f, 5.05347922e-02f, 4.98023145e-02f, -1.51863005e-02f,
  -9.97048020e-02f, 6.55915737e-02f, 1.03164695e-01f, -4.40791734e-02f, -2.11498961e-02f, 1.46410823e-01f, -3.63411009e-02f, -9.45691168e-02f, -1.28267437e-01f, 1.42605349e-01f,
  -7.57034421e-02f, -1.29240736e-01f, -2.28361152e-02f, 7.43865594e-02f, 1.39371261e-01f, 1.07778711e-02f, 1.43737406e-01f, 1.74772609e-02f, -3.10256816e-02f, -1.61256552e-01f,
  -7.11407289e-02f, -7.74310669e-04f, -1.26821041e-01f, 7.56408647e-03f, -5.48895933e-02f, 3.57039869e-02f, -1.40796658e-02f, -6.10738434e-02f, 1.19685493e-01f, 5.59611358e-02f,
  -6.60082176e-02f, 3.34015414e-02f, 5.93336485e-02f, 1.18563622e-01f, 1.16868550e-02f, -3.76111381e-02f, 1.65483057e-02f, -1.01479953e-02f, 8.67637843e-02f, 2.36886311e-02f,
  -1.09169789e-01f, -5.63304611e-02f, -7.70282000e-02f, -2.28677318e-03f, 9.93008763e-02f, -5.06810881e-02f, 4.32433262e-02f, 3.07494905e-02f, 1.81117039e-02f, 8.76313075e-02f,
  8.93347040e-02f, 3.28997038e-02f, -1.17488630e-01f, -8.40444639e-02f, 1.06658846e-01f, 4.69070254e-03f, -9.64018106e-02f, -6.61394373e-02f, 9.00260508e-02f, -1.15161970e-01f,
  -6.85169622e-02f, -1.53887823e-01f, 1.25164194e-02f, -1.18924990e-01f, 1.60302714e-01f, 1.22453896e-02f, -3.58377099e-02f, 5.16686700e-02f, 1.09845109e-01f, -8.13452378e-02f,
  -7.51158074e-02f, 8.14702883e-02f, -3.98668200e-02f, 8.42809603e-02f, -5.55479340e-02f, 1.40000671e-01f, -5.80801591e-02f, 2.08849385e-02f, -2.97377426e-02f, -2.74100341e-02f,
  7.78085068e-02f, -3.34599838e-02f, -1.63789451e-01f, 1.60005867e-01f, 4.27922383e-02f, 4.06127237e-02f, 4.78271954e-02f, -6.31288439e-02f, 9.79584977e-02f, -8.04103762e-02f,
  -1.03349224e-01f, -1.36675471e-02f, -7.43690953e-02f, -1.24305934e-01f, -6.59430213e-03f, 1.24644332e-01f, -8.77171680e-02f, -1.09730110e-01f, 3.56479362e-02f, 1.74121074e-02f,
  -7.21293315e-02f, 5.68840839e-02f, -9.68102738e-02f, 4.89884131e-02f, 8.34550187e-02f, 1.25278205e-01f, 7.24370331e-02f, -6.06852658e-02f, 1.04837075e-01f, -9.01043862e-02f,
  5.16905226e-02f, 1.43358499e-01f, -4.96708490e-02f, 5.21251000e-02f, 1.46032140e-01f, -1.48129754e-03f, 1.20496593e-01f, 3.27009968e-02f, 8.49563330e-02f, 1.88354272e-02f,
  -1.14157163e-01f, 1.14841081e-01f, 6.24791160e-02f, -6.89970478e-02f, -1.40504744e-02f, 6.84988573e-02f, 1.38714299e-01f, -1.10814437e-01f, 1.18198566e-01f, -7.88250789e-02f,
  -1.06221400e-02f, 5.84864393e-02f, 3.19096446e-02f, 1.02628127e-01f, -4.29805703e-02f, -2.68008113e-02f, -6.02164343e-02f, 2.72397120e-02f, 1.15138792e-01f, 1.82870198e-02f,
  1.49805695e-02f, 6.06446862e-02f, 1.01329044e-01f, -1.82506423e-02f, 3.58584477e-03f, 1.50529116e-01f, -3.51407751e-02f, -6.33715764e-02f, -1.10979956e-02f, -8.60759243e-02f,
  -8.00936297e-02f, -5.94843030e-02f, -1.14118658e-01f, -1.02422029e-01f, -8.35815258e-03f, 2.65621650e-03f, -1.36133451e-02f, 1.57565653e-01f, -1.08654961e-01f, -6.08692318e-02f,
  -9.71513242e-02f, -8.97066444e-02f, 1.46893218e-01f, -1.11633301e-01f, 8.18678364e-02f, -1.10014990e-01f, 7.49985278e-02f, -7.82769993e-02f, 8.96175951e-02f, -2.04192214e-02f,
  4.64538597e-02f, 9.09645110e-02f, -1.81509256e-02f, 1.22802027e-01f, 6.80989325e-02f, 3.31141278e-02f, -3.32313590e-02f, -4.00516540e-02f, -4.80904169e-02f, -2.38528475e-02f,
  8.53915066e-02f, -4.39806208e-02f, 7.27281868e-02f, 8.07778686e-02f, -1.25581369e-01f, 5.10421209e-02f, 9.05454531e-02f, -8.86818543e-02f, 7.63849318e-02f, -1.34475514e-01f,
  -9.20333490e-02f, 7.97710642e-02f, 4.73618060e-02f, 1.29556417e-01f, 1.95655078e-01f, -2.32354216e-02f, 1.34200543e-01f, -8.43826309e-02f, 6.24505542e-02f, 4.30700704e-02f,
  6.39991090e-02f, 1.82325169e-01f, -3.45649496e-02f, -1.19613886e-01f, -7.25899115e-02f, 1.12159848e-01f, 7.12184682e-02f, -2.19913781e-01f, 1.71013325e-01f, 6.78785816e-02f,
  -6.99534267e-02f, -7.44160041e-02f, 8.56723934e-02f, 4.56732251e-02f, -9.35782045e-02f, 8.44270661e-02f, 6.21789806e-02f, 3.41404080e-02f, -6.94745332e-02f, 2.53295973e-02f,
  -1.44854203e-01f, -9.68936756e-02f, -4.09571752e-02f, 5.28841577e-02f, 7.78363198e-02f, -4.39871326e-02f, -6.87323287e-02f, 1.53985590e-01f, -1.32451966e-01f, -1.08338483e-01f,
  -7.08425939e-02f, -3.89508791e-02f, -1.19558768e-02f, -1.06068611e-01f, 1.34846002e-01f, 2.79045608e-02f, 2.61487942e-02f, -7.62150958e-02f, -1.42798588e-01f, 5.45513108e-02f,
  -1.18286863e-01f, 1.17742822e-01f, -1.93958636e-02f, -1.33293584e-01f, -4.73480374e-02f, -1.06622286e-01f, 1.31293595e-01f, 2.52833846e-03f, -9.37091559e-02f, -8.06453153e-02f,
  3.45751531e-02f, 1.37650967e-01f, -1.28325626e-01f, -7.00719431e-02f, -3.16887088e-02f, -3.80699560e-02f, 4.00909111e-02f, 1.23153336e-01f, 3.12992446e-02f, 2.30819538e-01f,
  6.54736161e-02f, -1.36990752e-02f, 1.97484255e-01f, -3.85406688e-02f, 1.18293576e-01f, 8.54135379e-02f, 2.43149117e-01f, 1.26502439e-01f, 2.12526232e-01f, -3.15637767e-01f,
  -1.77496120e-01f, -2.58031208e-02f, -1.89771280e-01f, -5.56196123e-02f, 5.19620068e-02f, 1.90129474e-01f, 5.70246996e-03f, 1.04725599e-01f, -1.90731466e-01f, 1.48561165e-01f,
  -1.02096140e-01f, 2.05904126e-01f, 1.44997939e-01f, -1.36906177e-01f, -5.01429737e-02f, 3.97433609e-01f, -1.34254426e-01f, -3.42611521e-02f, 9.88912210e-02f, -6.21089153e-02f,
  -1.17983028e-01f, -9.97202769e-02f, 2.85391003e-01f, 1.02734976e-01f, 5.42610288e-02f, 2.47879941e-02f, 3.00318629e-01f, 1.66017666e-01f, 1.74380317e-01f, 1.77458987e-01f,
  -1.43907480e-02f, 1.85761139e-01f, 4.46214005e-02f, 2.70424724e-01f, 1.09933339e-01f, 8.37306231e-02f, -1.15458794e-01f, 1.05222069e-01f, -1.67822644e-01f, -6.81486428e-02f,
  -9.84584168e-02f, 1.45761088e-01f, -8.67378488e-02f, -1.85568824e-01f, 4.32039611e-02f, 2.83780284e-02f, 3.08351815e-01f, 6.53045205e-03f, 3.71819995e-02f, -6.28395528e-02f,
  4.18899767e-02f, 1.57970518e-01f, -4.44651805e-02f, 1.86623052e-01f, 9.14593861e-02f, 7.72157311e-02f, 2.06907526e-01f, 7.88511634e-02f, 7.08159655e-02f, 1.03376031e-01f,
  2.08795875e-01f, 8.86091497e-03f, 1.59877479e-01f, -6.73641711e-02f, 2.46885866e-01f, -3.81139130e-03f, -3.00984025e-01f, -8.32360759e-02f, -4.01329622e-02f, 2.28059500e-01f,
  1.65862799e-01f, 8.95812139e-02f, 4.56720926e-02f, -1.12496488e-01f, -1.22038208e-01f, 3.48280579e-01f, 1.97355077e-01f, -9.02802497e-02f, -7.32225329e-02f, -1.17757335e-01f,
  -2.76015233e-02f, 1.69853747e-01f, -3.73481624e-02f, 9.64056700e-02f, 5.79604059e-02f, -2.05945056e-02f, 5.86735159e-02f, -1.12991177e-01f, -1.03711903e-01f, 2.24426225e-01f,
  6.56854585e-02f, 1.27808839e-01f, 9.35737193e-02f, 2.10135713e-01f, -2.62769163e-02f, 1.26121551e-01f, 2.77200546e-02f, 1.27100572e-01f, 5.64504750e-02f, 1.99047681e-02f,
  -1.17390327e-01f, 3.18654701e-02f, -1.25813618e-01f, -2.65085641e-02f, 1.46510854e-01f, -1.03050284e-01f, 9.15537626e-02f, 9.54586491e-02f, -3.64167914e-02f, -1.01696774e-01f,
  7.26342350e-02f, 1.37839764e-01f, 1.04549870e-01f, 2.27679368e-02f, 1.67149454e-01f, 2.43220646e-02f, 2.71760494e-01f, 1.75667033e-01f, -6.50894344e-02f, 1.81862134e-02f,
  -3.50791365e-02f, 1.98114425e-01f, 1.67199373e-01f, 2.10399538e-01f, 2.17478052e-01f, -7.09756017e-02f, -5.60459457e-02f, 6.38232306e-02f, 2.47345462e-01f, -2.11134925e-01f,
  1.59470931e-01f, 1.53389543e-01f, 1.63059741e-01f, -1.00917213e-01f, -4.61736731e-02f, -3.81221846e-02f, -1.02701001e-01f, 2.24695489e-01f, -1.14888899e-01f, -1.69278551e-02f,
  1.06420577e-01f, 1.70603797e-01f, -1.28857717e-01f, -1.06189959e-01f, 5.06776087e-02f, -1.61301941e-01f, 3.39615382e-02f, 1.15716130e-01f, 2.14880511e-01f, 2.95857936e-01f,
  -1.01447189e-02f, -5.93617782e-02f, -4.57266644e-02f, 3.42017822e-02f, -6.81863129e-02f, 4.01879102e-02f, 1.18140085e-02f, 1.41897455e-01f, -8.34777579e-02f, -2.31993608e-02f,
  -1.15420051e-01f, 6.14496239e-04f, -2.40177289e-02f, 4.47623926e-04f, 5.91336656e-03f, -4.68006879e-02f, -5.81592172e-02f, -1.15053570e-02f, 1.34415433e-01f, -1.35673657e-01f,
  1.05934851e-01f, 1.37417475e-02f, -1.76266651e-03f, -1.56717654e-02f, 7.01000467e-02f, -1.74581304e-01f, -4.63776998e-02f, -3.49397957e-02f, 4.35964242e-02f, 7.59971440e-02f,
  -4.28485386e-02f, 4.45858017e-02f, -4.36459146e-02f, -2.14611609e-02f, 1.82808176e-01f, -5.69984354e-02f, -7.53162354e-02f, 8.87854174e-02f, 1.62174143e-02f, 1.26994982e-01f,
  2.07888424e-01f, -1.48933336e-01f, -1.94692373e-01f, 2.50510294e-02f, 2.79941391e-02f, 1.83982939e-01f, -2.22667083e-01f, 1.22505210e-01f, -1.78748086e-01f, -1.00042336e-01f,
  -9.77174118e-02f, -3.82189564e-02f, 4.03936729e-02f, -2.12761145e-02f, 5.31512760e-02f, -1.05607264e-01f, 1.57754168e-01f, 1.71321437e-01f, -2.49191877e-02f, 6.40419051e-02f,
  8.89319852e-02f, -3.19418348e-02f, -6.70543164e-02f, -1.48836195e-01f, -6.38071671e-02f, 9.81228426e-02f, 9.63588152e-03f, -5.47468551e-02f, 2.15546489e-01f, 4.19318564e-02f,
  -3.06975730e-02f, 8.03114846e-02f, 3.34146544e-02f, -3.12379561e-02f, 6.33456931e-02f, 5.50306626e-02f, -4.46551591e-02f, 1.69568732e-01f, 4.11423743e-02f, 1.76881626e-01f,
  9.97153297e-02f, 8.10111463e-02f, -3.06655765e-02f, -7.12982193e-02f, 4.65159602e-02f, -1.37963638e-01f, -5.31151183e-02f, -3.54275852e-02f, 1.66544840e-01f, 9.70397368e-02f,
  -8.10219646e-02f, 6.18756795e-03f, 3.22692662e-01f, 2.02921003e-01f, 1.84285864e-01f, 1.10544123e-01f, 1.23051196e-01f, 2.73386300e-01f, 2.14918733e-01f, 1.96080238e-01f,
  9.93785635e-02f, 2.26206094e-01f, 8.36157799e-02f, 2.56450593e-01f, 1.16006821e-01f, 5.74219935e-02f, -1.72505334e-01f, -2.08524406e-01f, -3.93046550e-02f, 2.31095046e-01f,
  -2.85273850e-01f, 2.94801742e-01f, -3.98960024e-01f, -6.34080246e-02f, 2.25380912e-01f, -1.74041629e-01f, 9.79817007e-03f, -3.58919539e-02f, 1.77925453e-02f, 6.68942034e-02f,
  2.22116187e-01f, -1.69246439e-02f, -1.43988624e-01f, 6.87097618e-03f, -2.41695382e-02f, -1.98319733e-01f, 1.78859338e-01f, -6.99476749e-02f, -1.76591426e-01f, 4.28460725e-03f,
  5.12673222e-02f, 2.19757073e-02f, 9.48517695e-02f, -6.31746650e-02f, 4.78219613e-02f, 4.23421971e-02f, 6.97735995e-02f, -5.44562452e-02f, -1.00968771e-01f, 1.23420022e-01f,
  5.16014732e-03f, 2.49180377e-01f, 2.46938691e-01f, 7.43136033e-02f, 2.22749367e-01f, 1.51804358e-01f, 8.07599425e-02f, -1.80162072e-01f, 1.17991306e-02f, 5.69251068e-02f,
  -2.35054731e-01f, 1.39938071e-01f, -8.73758718e-02f, 2.85765436e-02f, -1.04591571e-01f, 1.38389289e-01f, 7.63705447e-02f, 1.36771783e-01f, 1.67337701e-01f, 1.13669865e-01f,
  1.37546211e-01f, 2.14019299e-01f, 1.82608813e-01f, 1.19168460e-01f, 1.71046361e-01f, -1.54514596e-01f, 3.83367129e-02f, 1.55165046e-01f, -1.45311013e-01f, -1.65592358e-02f,
  -3.01002562e-01f, -5.41203842e-02f, 1.42147511e-01f, -1.93464890e-01f, -6.85124705e-03f, -7.16773048e-02f, 1.29849866e-01f, -1.02004737e-01f, -5.42239659e-02f, 1.45971179e-01f,
  5.24484087e-04f, 1.42516851e-01f, -5.92878088e-03f, 1.78957265e-02f, -5.77676892e-02f, 1.47082418e-01f, 3.77808772e-02f, 4.18569259e-02f, -2.88360985e-03f, 3.88888456e-02f,
  -1.63537174e-01f, -1.61395594e-01f, 3.14527512e-01f, 5.62809110e-02f, 3.46841402e-02f, 3.35392766e-02f, -6.19521067e-02f, -5.95930107e-02f, 1.08557083e-01f, 1.26274511e-01f,
  -1.83259144e-01f, -8.82998761e-03f, 1.68351710e-01f, 4.74977046e-02f, 2.40567133e-01f, -4.28278558e-02f, 8.93379003e-02f, 1.56282529e-01f, -3.67698446e-02f, -1.78182591e-02f,
  -1.45288631e-01f, 4.02408600e-01f, 1.30558029e-01f, -3.41883046e-03f, 2.21016362e-01f, 4.77325879e-02f, 1.40664592e-01f, -2.68483963e-02f, -8.00420940e-02f, -1.32152051e-01f,
  1.59565076e-01f, 1.34978190e-01f, 3.17048639e-01f, 5.95174059e-02f, 3.61047909e-02f, 2.76191711e-01f, 1.00193836e-01f, 2.42313415e-01f, 5.08421287e-02f, 4.46170196e-02f,
  1.48072049e-01f, 9.24430694e-03f, 1.77942235e-02f, 1.89211089e-02f, 1.91459328e-01f, -1.01608567e-01f, 1.80002432e-02f, 3.50327678e-02f, 8.57110173e-02f, -1.43855974e-01f,
  2.23515704e-01f, 1.88138112e-01f, -2.65393704e-01f, 1.67568579e-01f, 8.79167840e-02f, -6.96312562e-02f, -9.66603011e-02f, 7.72946551e-02f, -1.78067803e-01f, -6.51009753e-02f,
  5.55232950e-02f, 4.49105613e-02f, -3.59310284e-02f, 1.46755740e-01f, -4.36021127e-02f, 2.97537655e-01f, 6.04757667e-02f, 1.40655488e-02f, -1.48508936e-01f, 1.07883297e-01f,
  1.74478628e-02f, 1.90120861e-02f, -1.20189525e-02f, -6.16272651e-02f, -9.44285318e-02f, 7.92825446e-02f, 1.25507697e-01f, 4.96421717e-02f, -6.90549091e-02f, 2.40625128e-01f,
  -8.13322738e-02f, -1.43552333e-01f, 1.67478574e-03f, -7.58925006e-02f, 1.54904753e-01f, -4.83318828e-02f, 4.24007364e-02f, -1.18616365e-01f, 1.83670968e-01f, 5.65347821e-02f,
  -5.08976169e-02f, -5.54217361e-02f, 5.60018886e-03f, 7.89251104e-02f, -8.38097371e-03f, 4.48179059e-02f, 2.15608086e-02f, 5.89420553e-03f, -1.03697784e-01f, -2.89713796e-02f,
  8.10055584e-02f, 1.45778432e-02f, 3.04933339e-02f, -4.12321463e-02f, 1.93792149e-01f, -1.37943953e-01f, 5.93190603e-02f, -5.77179249e-03f, -5.33845313e-02f, -6.47275522e-02f,
  8.42149258e-02f, 1.48258954e-01f, 1.40605018e-01f, -1.41012445e-01f, -4.74951081e-02f, -1.47676310e-02f, -1.85308158e-01f, -1.04973383e-01f, 5.62653923e-03f, 1.70871347e-01f,
  1.39227659e-01f, 1.42960712e-01f, -2.74196155e-02f, -1.73899326e-02f, -1.22441642e-01f, -1.07213542e-01f, 7.73604289e-02f, -3.70938033e-02f, 7.04174638e-02f, 2.34004315e-02f,
  1.75731763e-01f, 8.12857226e-02f, -1.97195001e-02f, -1.61794536e-02f, -3.40527482e-02f, -4.46907431e-03f, 6.45409338e-03f, 1.02348521e-01f, 1.34530321e-01f, 5.71557358e-02f,
  9.91026163e-02f, -1.32256206e-02f, 1.11884952e-01f, 1.15997270e-01f, -1.24766149e-01f, 1.52097285e-01f, -9.24015865e-02f, 4.76213843e-02f, 1.44529399e-02f, -1.34589434e-01f,
  -1.27618656e-01f, -1.19144768e-02f, -5.99589236e-02f, 9.04033035e-02f, -1.93513948e-02f, 6.27067536e-02f, -8.28217342e-02f, 1.52980434e-02f, 9.89826843e-02f, 1.09094121e-01f,
  2.72104084e-01f, 2.78686304e-02f, 6.53661266e-02f, 1.64446101e-01f, 5.11099026e-02f, 1.06653713e-01f, 1.16828777e-01f, 2.22556353e-01f, 1.59664184e-01f, 1.61039010e-01f,
  -9.81582254e-02f, 1.39394686e-01f, 2.08357304e-01f, 7.02576414e-02f, -1.36521995e-01f, 1.04117356e-01f, 2.69685924e-01f, -1.90452456e-01f, 1.34464219e-01f, -4.38816100e-02f,
  -9.31368768e-02f, 6.18201010e-02f, -9.74714905e-02f, 1.41872063e-01f, 4.52620164e-02f, 2.24397138e-01f, -9.48447287e-02f, -1.46018520e-01f, 4.37204055e-02f, 1.28415674e-01f,
  -7.53548592e-02f, 7.51043558e-02f, 2.46789306e-01f, 2.54633188e-01f, -4.44469750e-02f, 8.34352672e-02f, -1.41265690e-01f, 9.87106562e-02f, -8.79195482e-02f, 8.97216648e-02f,
  -1.23439655e-01f, 6.24976233e-02f, 6.56095520e-02f, 6.72331080e-02f, -8.22649151e-02f, -6.19317070e-02f, -1.48396298e-01f, -1.21546894e-01f, -1.39787242e-01f, -7.39296302e-02f,
  1.69747397e-02f, 4.22639325e-02f, -3.63574028e-02f, 1.61414370e-02f, -5.43854316e-04f, 5.87628856e-02f, 9.65324566e-02f, -3.51875760e-02f, -1.18365586e-01f, 3.76507901e-02f,
  1.12149820e-01f, -8.16523358e-02f, 3.84289995e-02f, -2.26129685e-02f, 3.23216394e-02f, 6.21235231e-03f, -4.25184891e-02f, 1.21475853e-01f, 1.44406825e-01f, -7.00453967e-02f,
  1.63580090e-01f, 2.31889151e-02f, -2.70466991e-02f, 1.52029330e-04f, 1.86734483e-01f, -8.47596824e-02f, 1.87572956e-01f, 2.07019195e-01f, -1.37382343e-01f, -1.87983200e-01f,
  8.54515657e-02f, 1.00967295e-01f, 2.04327613e-01f, -3.25529650e-02f, 5.38279079e-02f, -1.76356822e-01f, 3.29108387e-02f, 2.92267740e-01f, 1.77709356e-01f, 9.50621739e-02f,
  2.54239261e-01f, -8.18173960e-02f, -3.89335901e-02f, 8.67701843e-02f, 1.13311477e-01f, 7.35197542e-03f, -1.16997309e-01f, 1.52771562e-01f, 1.09266929e-01f, -7.09567964e-02f,
  -1.04357861e-01f, -1.43338935e-02f, 1.08858526e-01f, -1.37549581e-03f, 1.03218935e-01f, 8.36030394e-03f, 1.75855026e-01f, 1.40607968e-01f, 1.48529059e-03f, -7.76861683e-02f,
  -1.66829631e-01f, 1.99451089e-01f, -8.17665309e-02f, 1.83595017e-01f, -7.63931051e-02f, -8.65604430e-02f, -8.62701535e-02f, 1.24662630e-02f, 3.00047323e-02f, 1.84152983e-02f,
  -8.93728808e-02f, -6.06155917e-02f, -3.67568154e-03f, 8.11397880e-02f, 6.29233709e-03f, 7.98413232e-02f, -3.34601514e-02f, 1.21036440e-01f, 4.78399098e-02f, 1.79971024e-01f,
  -2.82470025e-02f, -8.66011903e-02f, 3.65919061e-02f, 8.57404321e-02f, -4.73389886e-02f, -3.42535526e-02f, -1.06394202e-01f, -7.67258331e-02f, -1.11666165e-01f, 8.47134590e-02f,
  7.69133195e-02f, -2.77263820e-02f, 3.42774093e-02f, -1.24848023e-01f, 3.05984467e-02f, 1.42540514e-01f, 1.38374105e-01f, -4.75696661e-02f, -5.22799231e-02f, -5.77380508e-02f,
  -3.59588377e-02f, 1.01492624e-03f, -7.12963492e-02f, -9.45831090e-02f, 1.15775064e-01f, -4.38186564e-02f, 4.80569713e-02f, -6.07968196e-02f, -2.59332042e-02f, 7.33547062e-02f,
  9.75953490e-02f, 2.13911873e-03f, -7.14763403e-02f, 5.11811338e-02f, 1.23472381e-02f, 1.09237693e-02f, 1.12589281e-02f, 1.05847148e-02f, -3.74626592e-02f, -2.10050039e-05f,
  4.36800495e-02f, -1.64995983e-01f, 5.33509720e-03f, -7.31349736e-02f, 7.43791414e-03f, 1.73332915e-01f, 6.97168941e-03f, 4.92139123e-02f, -7.66519979e-02f, 8.30588341e-02f,
  -1.10354893e-01f, 1.06867529e-01f, 1.44351840e-01f, 6.10640161e-02f, 8.31293240e-02f, 1.96128301e-02f, 1.04464024e-01f, 1.29672155e-01f, -4.48228791e-04f, -6.75924942e-02f,
  5.91285899e-02f, -5.08204624e-02f, 9.89789963e-02f, 1.07501678e-01f, 6.64079115e-02f, -4.65422608e-02f, -8.84093195e-02f, 6.78383745e-03f, -8.27039704e-02f, -5.82613349e-02f,
  7.40929097e-02f, -2.23498940e-02f, 8.13592076e-02f, -8.40957612e-02f, -1.37982117e-02f, -1.37388625e-03f, -2.59929225e-02f, -5.12245148e-02f, 6.27580285e-02f, -8.89202803e-02f,
  -7.60367587e-02f, -8.85241777e-02f, 5.33012562e-02f, 1.61554009e-01f, -3.89172807e-02f, 2.02242211e-02f, -2.83189565e-02f, 7.84068033e-02f, -1.40384987e-01f, -9.21962410e-02f,
  -3.96911092e-02f, 6.64547905e-02f, 2.02707145e-02f, -5.07235676e-02f, 1.80280618e-02f, 6.47751540e-02f, -1.26696005e-01f, 4.22335193e-02f, -6.41794503e-02f, 1.84023324e-02f,
  -4.43536643e-04f, -1.02249049e-01f, 3.66105363e-02f, 5.25442651e-03f, -8.48973617e-02f, -1.12668704e-02f, 1.04082227e-01f, -4.40165959e-02f, -7.75398463e-02f, -5.32318465e-02f,
  4.84970734e-02f, -6.95837438e-02f, 9.38739628e-02f, -1.24882292e-02f, 2.33301707e-02f, -6.13478720e-02f, -8.53406489e-02f, -5.44864088e-02f, 2.93315686e-02f, -1.37167117e-02f,
  -8.89454186e-02f, -9.50624794e-03f, 5.44387810e-02f, -1.03987180e-01f, 9.41711292e-02f, -1.58922803e-02f, 1.35271147e-01f, -5.12346141e-02f, 4.67184819e-02f, 4.34909388e-02f,
  1.10845983e-01f, 2.65192259e-02f, -7.50688389e-02f, 1.48817480e-01f, 6.03899024e-02f, 1.03393979e-01f, -1.14249505e-01f, 2.21146047e-02f, -3.31528150e-02f, 1.21056966e-01f,
  -1.10497721e-01f, -3.88353467e-02f, 5.99209853e-02f, 5.83346039e-02f, 1.32255018e-01f, -5.02556115e-02f, 3.85265909e-02f, -8.94813836e-02f, -5.33354692e-02f, -1.01773769e-01f,
  2.26372592e-02f, 8.14577639e-02f, -7.96995834e-02f, -3.42082488e-03f, 7.70533383e-02f, -9.79173258e-02f, -1.27628148e-02f, 5.57862259e-02f, -1.05474606e-01f, -7.67237321e-02f,
  -2.90112253e-02f, -3.92681845e-02f, -1.07963830e-01f, -6.40845997e-03f, -9.05162171e-02f, -1.29602954e-01f, 8.55935514e-02f, -4.82258871e-02f, 1.06946230e-02f, 6.06951602e-02f,
  -9.25847590e-02f, -7.74656981e-02f, 3.23930196e-02f, -8.18269849e-02f, -1.10265307e-01f, -7.22772703e-02f, -1.21344428e-03f, 6.69911504e-02f, 2.62570158e-02f, -1.70182493e-02f,
  3.23661529e-02f, 4.47569564e-02f, 2.62378361e-02f, -3.85778807e-02f, 9.50405970e-02f, -9.21520740e-02f, -1.28371954e-01f, 9.41039026e-02f, 1.31638214e-01f, 1.00617714e-01f,
  -8.09300095e-02f, 6.44923076e-02f, -1.08472049e-01f, -3.21118347e-02f, 1.28428498e-02f, 3.94837707e-02f, -1.17669515e-01f, -4.74923328e-02f, -6.62065893e-02f, -5.00124432e-02f,
  5.72086088e-02f, -1.12274989e-01f, -7.14932755e-02f, 8.78500491e-02f, -6.83620423e-02f, 1.27509490e-01f, -3.04668099e-02f, 1.14561394e-01f, -2.06860527e-02f, -3.89588773e-02f,
  1.61387593e-01f, -8.55186731e-02f, -7.87167028e-02f, 5.48959384e-03f, 6.65318668e-02f, -5.74608073e-02f, 8.82210582e-03f, -7.34535512e-03f, -8.05686638e-02f, 8.45940202e-04f,
  -8.79527926e-02f, -1.57379396e-02f, -9.09536555e-02f, -8.82404521e-02f, -1.21976823e-01f, -2.26928275e-02f, -6.16322644e-02f, -7.35874251e-02f, 1.18252233e-01f, -7.11278468e-02f,
  7.29124621e-02f, 2.66385153e-02f, -2.66912039e-02f, -5.07108085e-02f, -6.90305158e-02f, 4.29626182e-02f, 2.53019645e-03f, -5.54690175e-02f, 1.28121376e-01f, 4.55209985e-02f,
  -8.73037726e-02f, 3.81897837e-02f, -6.98837917e-03f, -4.03707288e-03f, -8.41715261e-02f, 5.91186136e-02f, 1.03246987e-01f, -8.37219357e-02f, 8.84000361e-02f, 1.50760710e-01f,
  -1.01624757e-01f, -4.23549674e-02f, 6.37876242e-02f, 4.04286534e-02f, -4.12854506e-03f, 1.60107221e-02f, 4.64011170e-02f, 2.45781932e-02f, -6.72271252e-02f, -1.11283787e-01f,
  -4.23804894e-02f, 5.23906760e-02f, 8.72968882e-02f, -8.55190083e-02f, 7.66345337e-02f, -1.77185103e-01f, -1.32761002e-01f, -1.24215029e-01f, 4.02993411e-02f, -9.81645286e-02f,
  3.61680090e-02f, 1.21472646e-02f, -5.31084500e-02f, -6.63748309e-02f, -2.71942690e-02f, 3.19751091e-02f, 8.01331550e-03f, -1.01808142e-02f, 7.89050981e-02f, 9.14704278e-02f,
  -9.25508663e-02f, 1.20970234e-02f, 4.88350317e-02f, 5.90477288e-02f, 6.88307658e-02f, 3.39714959e-02f, -3.90064460e-03f, -5.30061983e-02f, 1.76941335e-01f, 2.26447918e-03f,
  6.49354681e-02f, -6.37701675e-02f, -6.15273863e-02f, -3.21843997e-02f, 1.49057642e-01f, 8.58458579e-02f, -3.89660150e-03f, 1.17865279e-01f, 9.18974057e-02f, 1.37989715e-01f,
  1.18024014e-01f, 1.49458706e-01f, -1.13615029e-01f, -5.78404292e-02f, 4.85705249e-02f, 1.89814419e-02f, 3.42443511e-02f, 1.63295165e-01f, -2.24144734e-03f, 1.11078031e-01f,
  1.25210524e-01f, -1.35295495e-01f, 1.72232375e-01f, -3.88436392e-02f, -9.93442237e-02f, -8.02222714e-02f, 6.40180055e-03f, 5.66268303e-02f, 8.12284350e-02f, 9.68408883e-02f,
  8.28488767e-02f, 7.46547729e-02f, 1.83746845e-01f, 7.56803602e-02f, 3.96802463e-02f, -2.49084104e-02f, -5.31749800e-02f, 1.93205684e-01f, 3.76883820e-02f, 5.25745824e-02f,
  -2.12503001e-01f, 2.25735709e-01f, 2.57928282e-01f, -2.48572245e-01f, -9.66238752e-02f, -6.13652095e-02f, -1.44042507e-01f, -1.77221358e-01f, 1.29284889e-01f, 1.12581216e-01f,
  1.02915823e-01f, -4.05816510e-02f, 1.70072019e-02f, -5.54535501e-02f, 2.74332553e-01f, 1.79847460e-02f, 4.85531464e-02f, 1.22745410e-01f, -7.87548255e-03f, 1.47517085e-01f,
  -1.21504493e-01f, -4.42407131e-02f, 8.44376162e-02f, -6.94517121e-02f, 2.32686922e-01f, -7.83318654e-02f, 7.74827972e-02f, -7.16070607e-02f, -3.31637263e-02f, 1.21515356e-02f,
  -9.97891426e-02f, -1.47375360e-01f, 1.50659308e-01f, -1.05879657e-01f, 2.45911539e-01f, 1.33046716e-01f, 1.11516468e-01f, 1.31123051e-01f, 1.52163550e-01f, -6.20049909e-02f,
  1.93777066e-02f, 2.18620330e-01f, 1.77559271e-01f, 9.69157070e-02f, 1.15858249e-01f, -2.72444338e-02f, -5.83643056e-02f, 1.14423446e-01f, -3.26159894e-02f, 9.62759331e-02f,
  2.81161636e-01f, 1.63421392e-01f, 1.01377286e-01f, 1.80591881e-01f, 1.27690911e-01f, 5.17250784e-02f, 2.09001943e-01f, 2.93573856e-01f, 4.19140220e-01f, 5.44275194e-02f,
  2.62054831e-01f, 3.43908519e-01f, -5.06636910e-02f, 1.66843355e-01f, 3.25469464e-01f, -2.62127221e-01f, -8.39743838e-02f, -5.74321091e-01f, 2.32840583e-01f, 2.49694109e-01f,
  1.14562437e-01f, 1.60151705e-01f, 1.82980031e-01f, -1.54219940e-01f, -2.04259362e-02f, 4.09040779e-01f, 1.52080387e-01f, -9.79476236e-03f, -4.81628887e-02f, 9.17804614e-02f,
  -3.91862541e-02f, 6.00397848e-02f, -4.25481535e-02f, 3.60111869e-03f, 2.92905301e-01f, -6.83075860e-02f, 1.52869537e-01f, 1.79777116e-01f, -7.96351209e-02f, 2.58516334e-02f,
  1.00493766e-01f, 2.38382090e-02f, -1.41928136e-01f, 2.51036167e-01f, 1.84266999e-01f, -9.72497165e-02f, 1.05526047e-02f, 1.50220573e-01f, 2.97714584e-03f, 9.21838805e-02f,
  -1.76279858e-01f, -8.63272995e-02f, -2.52806451e-02f, 1.00946628e-01f, 1.75264433e-01f, -1.61504120e-01f, -9.07548070e-02f, -4.65376265e-02f, -1.19447552e-01f, 8.88047516e-02f,
  4.00969796e-02f, -8.19927752e-02f, 2.80660659e-01f, 4.39919718e-02f, -2.16954015e-02f, -1.18306719e-01f, 6.67195842e-02f, -5.77018037e-02f, 5.70978485e-02f, 4.44513373e-02f,
  -9.99008268e-02f, 4.14671749e-02f, -9.57077648e-03f, -1.12531252e-01f, 1.10614412e-01f, -5.71521856e-02f, -7.20810816e-02f, -1.41972288e-01f, 5.02677076e-03f, -3.74801755e-02f,
  -5.25156148e-02f, 1.20096929e-01f, -8.88657868e-02f, 1.31739080e-01f, -8.75334516e-02f, 1.22843748e-02f, -2.71739513e-02f, 6.14228323e-02f, -1.27832908e-02f, 4.31196950e-02f,
  -6.63920045e-02f, -2.14830488e-02f, 1.54182121e-01f, -3.99431027e-02f, 9.56070274e-02f, 5.30627035e-02f, 1.07824765e-01f, -5.72627299e-02f, 8.81106630e-02f, -7.42633343e-02f,
  1.05044268e-01f, -5.67694791e-02f, -1.23936929e-01f, -8.15905556e-02f, 3.96843217e-02f, 2.53648646e-02f, -7.75280921e-03f, 3.34903039e-02f, -2.88234744e-02f, 6.68044165e-02f,
  8.15992653e-02f, -5.44865094e-02f, -1.31708756e-01f, -4.95592915e-02f, -6.84691146e-02f, 1.09268837e-01f, -6.49856031e-02f, 1.06095290e-02f, 7.20469281e-03f, -4.27861437e-02f,
  -2.80158762e-02f, -1.05175354e-01f, 1.14337489e-01f, 6.42586350e-02f, 2.03429046e-03f, 1.29078403e-01f, 6.82278946e-02f, 2.87117455e-02f, -5.82928434e-02f, -8.36377516e-02f,
  2.60355212e-02f, 1.22759655e-01f, 1.55600205e-01f, -3.48068662e-02f, 3.69688720e-02f, 1.35261714e-01f, 1.77426919e-01f, 1.14006191e-01f, -1.16149951e-02f, -7.46298060e-02f,
  7.35593960e-02f, -7.42833987e-02f, 1.73758805e-01f, -1.60075620e-01f, -1.23069793e-01f, -4.71819639e-02f, 4.79909703e-02f, -3.02431248e-02f, 4.31970172e-02f, -1.84598193e-02f,
  -5.84485196e-03f, 4.32304479e-02f, -4.28301468e-03f, 6.94643781e-02f, -6.41574664e-03f, -8.43495652e-02f, -1.11085020e-01f, -5.57889044e-02f, 8.51541981e-02f, -7.21518397e-02f,
  1.04446478e-01f, -9.79418680e-03f, 1.37678698e-01f, 1.75779551e-01f, -7.87454173e-02f, -1.03585891e-01f, 7.85886273e-02f, 4.96035218e-02f, 2.22519208e-02f, 3.85475829e-02f,
  7.95827508e-02f, -2.11762488e-02f, -1.07142597e-01f, 1.24701589e-01f, -1.07164942e-01f, 4.54405844e-02f, -1.14763945e-01f, 1.36142503e-02f, 1.79718304e-02f, 3.24724540e-02f,
  -1.22197650e-01f, 6.23416975e-02f, -1.08725965e-01f, -1.05085289e-02f, 6.74734414e-02f, 8.04249197e-03f, -2.90557905e-03f, -3.86816263e-02f, -7.90895596e-02f, -1.21654712e-01f,
  5.29446155e-02f, 9.05712252e-04f, 6.01027757e-02f, 8.36004242e-02f, 1.42895743e-01f, 8.97091068e-03f, -4.50146943e-02f, 2.49337349e-02f, 6.25779554e-02f, -7.79199321e-03f,
  -4.68665585e-02f, 3.21093481e-03f, 5.62010743e-02f, -1.29978079e-02f, -4.06833626e-02f, -4.01971303e-02f, -7.43427351e-02f, -3.16045359e-02f, -5.60476594e-02f, -5.68532795e-02f,
  1.10061876e-01f, 1.81767996e-03f, 3.68363820e-02f, 1.00249805e-01f, 3.28643322e-02f, 4.51468304e-03f, 1.15238227e-01f, -9.79230702e-02f, -3.47978510e-02f, 1.00356631e-01f,
  -1.28622279e-01f, -1.37282446e-01f, -2.68317264e-04f, -1.29985124e-01f, -8.19980279e-02f, -6.44689798e-02f, 1.09063238e-01f, -6.68710992e-02f, -6.74312711e-02f, -7.51307979e-02f,
  9.92308781e-02f, -9.46916416e-02f, -1.56817183e-01f, -2.70561967e-02f, 8.14350918e-02f, 3.59507999e-03f, 1.64511651e-02f, 7.87363946e-02f, 1.38505086e-01f, 7.91594200e-03f,
  -4.03208807e-02f, -1.27268076e-01f, 1.69126224e-02f, -2.69825254e-02f, -7.91502073e-02f, -5.31729637e-03f, -2.91288942e-02f, -6.72089458e-02f, -1.97008327e-02f, -6.55201674e-02f,
  1.49041712e-01f, 9.27259251e-02f, -1.18784510e-01f, 6.37952313e-02f, 9.52037349e-02f, 1.03278711e-01f, 2.16908008e-01f, 2.07624257e-01f, 5.28066419e-02f, 1.22260749e-01f,
  -1.69591215e-02f, 1.30923301e-01f, -7.11375549e-02f, 1.18469901e-01f, 1.92589574e-02f, 1.46264210e-01f, 1.69098377e-01f, -1.22640669e-01f, -3.40174930e-03f, -2.06470966e-01f,
  -8.98175314e-03f, -2.88871765e-01f, 1.86202690e-01f, 1.07001156e-01f, -3.27710435e-02f, 1.29891008e-01f, -1.35011882e-01f, 3.84666887e-03f, -2.34376594e-01f, 3.19306940e-01f,
  1.16877118e-03f, -5.27741434e-03f, -3.09611503e-02f, -1.13186121e-01f, 9.97065306e-02f, -2.77104583e-02f, 5.72309969e-03f, -4.71434966e-02f, -1.09347135e-01f, 4.64826338e-02f,
  -1.79333426e-02f, 2.41573349e-01f, 9.15698260e-02f, 6.80571422e-03f, -1.06559537e-01f, 9.07028168e-02f, -7.75741860e-02f, 1.15854986e-01f, 1.55683309e-01f, 1.44103244e-01f,
  -1.02508791e-01f, -1.18700773e-01f, 1.52360842e-01f, 7.42905214e-02f, -7.06597790e-02f, 3.07137907e-01f, 8.62879828e-02f, 6.60407096e-02f, 2.52627507e-02f, 1.14124008e-01f,
  1.03172146e-01f, 6.79592649e-03f, 1.44496812e-02f, -1.41321033e-01f, -3.64500023e-02f, -1.79750502e-01f, -2.62418073e-02f, -7.44625628e-02f, 1.19767532e-01f, 7.71401301e-02f
};

// L1_fan_Bp_bar (Shape: 1 x 40)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 40;
const float L1_fan_Bp_bar_data[] = {
  6.09543994e-02f, 1.28332734e-01f, 2.49914862e-02f, 6.85767755e-02f, -3.64932814e-03f, 1.47151127e-01f, 6.51498735e-02f, 1.11611277e-01f, 1.56150088e-02f, 1.86553791e-01f,
  1.25322476e-01f, -6.27267221e-03f, 2.54862607e-01f, 1.21499404e-01f, 2.52384245e-02f, 1.03806488e-01f, -1.57045126e-02f, -9.50211585e-02f, 1.28445461e-01f, 9.32462588e-02f,
  1.27470911e-01f, 2.32216656e-01f, 2.31751442e-01f, 2.72745460e-01f, 3.25466022e-02f, 1.99017346e-01f, 1.18163995e-01f, 2.09408700e-01f, 1.69112444e-01f, 1.31970271e-01f,
  -8.08599666e-02f, -1.40799740e-02f, 1.48107320e-01f, -6.84411004e-02f, 1.90260068e-01f, 1.02212124e-01f, -7.75032938e-02f, 1.50673404e-01f, 5.37045076e-02f, 2.71590918e-01f
};

// L2_fan_Wp (Shape: 12 x 64)
const int L2_fan_Wp_rows = 12;
const int L2_fan_Wp_cols = 64;
const float L2_fan_Wp_data[] = {
  1.70993537e-01f, 1.83127448e-01f, 3.55225205e-02f, -1.81900814e-01f, -7.39311874e-02f, -1.40725806e-01f, -7.04323500e-02f, -1.18631780e-01f, 1.42056495e-01f, 2.99976971e-02f,
  -7.57868811e-02f, 3.09235905e-03f, -6.54090345e-02f, 1.42137170e-01f, 1.24009550e-01f, -1.42107829e-01f, 1.94154248e-01f, 1.80893585e-01f, 5.20508401e-02f, -4.17710794e-03f,
  9.98755097e-02f, -1.97993770e-01f, -1.04770474e-01f, 1.54858813e-01f, 9.50632170e-02f, 1.93276480e-01f, -6.10354505e-02f, -2.83827279e-02f, -3.22375633e-02f, 4.16126288e-03f,
  -2.74174614e-03f, -2.15242371e-01f, -3.71622890e-02f, 6.88135400e-02f, 1.11556657e-01f, -4.60567512e-02f, -8.04281831e-02f, -6.57861754e-02f, -2.40611695e-02f, -7.62545168e-02f,
  -2.39185691e-02f, -2.42005829e-02f, -6.72563165e-02f, 1.43412292e-01f, -8.33624676e-02f, -7.23242462e-02f, 9.38851908e-02f, -2.62641072e-01f, 3.36306870e-01f, -1.14234522e-01f,
  -1.58702776e-01f, -2.29285564e-02f, -8.75710025e-02f, -1.19047083e-01f, 2.81962752e-02f, 8.59696716e-02f, -5.73589429e-02f, 1.59889325e-01f, 8.27498883e-02f, -2.12363467e-01f,
  -9.85683203e-02f, -9.21860784e-02f, 9.59364176e-02f, -4.21954207e-02f, 9.30659566e-03f, 1.66530237e-02f, -1.95989683e-01f, -2.63119102e-01f, -1.38982609e-01f, 1.32693261e-01f,
  -1.01794034e-01f, -1.42867684e-01f, 1.31578878e-01f, -1.50315374e-01f, -1.66588258e-02f, -1.02237098e-01f, 8.33360478e-02f, 2.01014280e-02f, 5.29235378e-02f, 2.84285620e-02f,
  2.14553997e-01f, 9.34576318e-02f, 2.66194612e-01f, 1.20443821e-01f, 1.69623364e-02f, 2.67773062e-01f, 4.62987274e-03f, -5.73830381e-02f, -5.33931423e-03f, -1.43592864e-01f,
  -1.38135761e-01f, -1.40696153e-01f, 1.27058059e-01f, 4.41139787e-02f, 3.79166976e-02f, -6.74533695e-02f, 6.87938854e-02f, 6.70911372e-02f, -9.14327241e-03f, -1.35699511e-01f,
  1.41512334e-01f, 8.32601264e-02f, 4.38913383e-04f, -7.54871266e-03f, -7.49975368e-02f, 1.29099965e-01f, 1.50273472e-01f, 1.62754074e-01f, 1.40873834e-01f, 1.31418511e-01f,
  -1.54013708e-01f, -1.06897466e-01f, -4.67210002e-02f, 2.54917204e-01f, 6.87818006e-02f, 1.29931211e-01f, 4.92095388e-03f, -4.79389913e-02f, 2.04374529e-02f, -2.63957903e-02f,
  6.59977272e-02f, 2.69463137e-02f, -2.44831428e-01f, -2.84125935e-02f, -3.81383151e-02f, 8.94530416e-02f, 1.01162083e-01f, 1.45871431e-01f, -1.65044963e-01f, -1.03240490e-01f,
  -4.09870781e-02f, 5.48004098e-02f, -9.47085842e-02f, 1.64874233e-02f, 1.17913797e-01f, 8.43613371e-02f, -3.36334184e-02f, 9.68015660e-03f, 1.45210311e-01f, 4.23476435e-02f,
  2.81356037e-01f, 7.24070296e-02f, -1.65514424e-01f, 1.46332473e-01f, -8.66116583e-02f, 2.29067933e-02f, 7.62512982e-02f, -6.21885285e-02f, 9.36303288e-02f, 1.45026401e-01f,
  2.36299455e-01f, 3.45861651e-02f, -9.09333229e-02f, -2.82041490e-01f, 1.46827146e-01f, -1.36947669e-02f, -7.14571178e-02f, 1.35770947e-01f, 8.15702528e-02f, -5.46179153e-02f,
  2.02147394e-01f, 1.02951899e-01f, 2.76621785e-02f, -1.30501166e-01f, -7.56697729e-02f, -9.24306980e-04f, -3.71299051e-02f, 1.13087326e-01f, 1.24035487e-02f, -1.85706299e-02f,
  6.39714003e-02f, -2.10548207e-01f, -3.38656902e-02f, 1.99830160e-01f, 6.53901473e-02f, 3.02085057e-02f, -1.46128461e-01f, 2.05496103e-01f, -2.86296569e-02f, 1.65915713e-01f,
  -1.05569646e-01f, -1.20967209e-01f, -8.25965777e-02f, 8.36832598e-02f, 8.61954242e-02f, -1.18568167e-01f, -2.10209936e-01f, -2.94830054e-01f, -1.93768665e-02f, -8.67181644e-02f,
  5.44318231e-03f, 1.97178096e-01f, 1.62677616e-01f, 3.19427607e-04f, -3.94248441e-02f, -8.03959668e-02f, -9.13735330e-02f, 1.77338198e-01f, 4.75315563e-02f, -2.27636285e-02f,
  -1.20984033e-01f, -4.51442450e-02f, 3.26207168e-02f, -6.48615956e-02f, -2.10526828e-02f, -3.87424640e-02f, 1.86383754e-01f, -4.02782589e-01f, 3.69210392e-01f, 5.71789108e-02f,
  4.04602513e-02f, 1.37420997e-01f, -2.29821894e-02f, -9.03054550e-02f, -2.10808724e-01f, -2.56623596e-01f, 1.38163846e-02f, -4.90141325e-02f, -1.96468055e-01f, -2.22486369e-02f,
  1.27627090e-01f, -1.10435933e-01f, -4.15360928e-02f, 7.66068622e-02f, -1.22345828e-01f, -1.42530128e-01f, 1.49794966e-01f, 9.66217518e-02f, 2.26472631e-01f, 9.20365974e-02f,
  -4.47510295e-02f, 8.39142352e-02f, 3.28658931e-02f, 1.36148944e-01f, -1.30403265e-01f, 5.74249290e-02f, 1.29174381e-01f, -8.45277309e-02f, 1.33271560e-01f, -7.16792718e-02f,
  1.06088512e-01f, -4.38617021e-02f, 1.87324509e-01f, -7.38746896e-02f, 2.03944176e-01f, 3.81403230e-03f, -1.14196680e-01f, 4.57411408e-02f, -1.26733720e-01f, -7.46557340e-02f,
  4.07918096e-02f, 2.09546492e-01f, 3.69764492e-02f, -4.48824316e-02f, -7.15332404e-02f, -1.08004391e-01f, -9.24238786e-02f, 1.41949549e-01f, 1.16638020e-01f, 1.25753492e-01f,
  5.74784093e-02f, 6.60045892e-02f, 1.51664704e-01f, 2.19191253e-01f, 9.98233929e-02f, 1.72242105e-01f, 2.27248386e-01f, 1.24420702e-01f, 3.07667702e-01f, 1.05278589e-01f,
  -3.08874577e-01f, 3.19421142e-01f, -2.88345456e-01f, 3.07778805e-01f, 6.48869202e-02f, -2.67795742e-01f, 7.32576177e-02f, -6.58774674e-02f, 2.39697039e-01f, 1.55754760e-01f,
  -4.13275149e-04f, 5.49609140e-02f, 1.73746765e-01f, -9.30661485e-02f, -7.23794177e-02f, -1.28391042e-01f, -1.27629712e-01f, 6.25805184e-02f, 7.90911168e-02f, -5.48001602e-02f,
  8.00306967e-04f, -4.88107651e-02f, -1.10916473e-01f, 1.90657396e-02f, -1.72545120e-01f, 1.15968704e-01f, 2.58172257e-03f, 4.38350951e-03f, 4.27086353e-02f, -1.49648204e-01f,
  -2.99935509e-02f, 1.10138550e-01f, -5.21959588e-02f, -2.23036483e-02f, 1.25397593e-01f, 1.50393963e-01f, -9.44201946e-02f, 8.12112819e-03f, -3.28837246e-01f, 1.11377940e-01f,
  1.17353864e-01f, 5.16997688e-02f, -1.59784734e-01f, 1.17280809e-02f, -1.32802390e-02f, 3.85616831e-02f, -1.23336546e-01f, -2.57723853e-02f, 1.36404514e-01f, 1.16838865e-01f,
  -1.26842991e-01f, -9.34139565e-02f, 7.53134638e-02f, 1.16186902e-01f, 1.32932991e-01f, -3.50373401e-03f, 1.45456910e-01f, 7.51850456e-02f, 1.04885362e-01f, -2.25345575e-05f,
  1.63904116e-01f, -1.22530967e-01f, 2.51443475e-01f, 1.03516161e-01f, -1.82628661e-01f, -9.25146714e-02f, -7.31679350e-02f, 2.41510421e-02f, 2.79499590e-01f, 1.12810597e-01f,
  1.25521243e-01f, 2.62929559e-01f, 2.20007047e-01f, 1.12184025e-01f, -1.43792972e-01f, -1.00190658e-03f, -4.69287857e-02f, -7.73293003e-02f, 1.06392168e-01f, 2.41065435e-02f,
  -1.19400308e-01f, 6.05420629e-03f, 1.20333202e-01f, -2.23001596e-02f, -5.37446961e-02f, -1.17458783e-01f, 1.19424760e-01f, 2.01301202e-01f, -3.39032598e-02f, 3.82295214e-02f,
  -5.86867332e-02f, -6.51491284e-02f, 1.42210707e-01f, 5.56701794e-02f, -2.26618964e-02f, 2.47922033e-01f, -2.22178027e-01f, -2.89773583e-01f, 1.02673657e-02f, 2.60163695e-01f,
  8.66708085e-02f, 3.59602235e-02f, -8.82207006e-02f, 1.07959963e-01f, 1.28488958e-01f, 3.85153331e-02f, -1.29348487e-01f, 1.87172331e-02f, -1.75138161e-01f, -7.12391862e-04f,
  9.20216441e-02f, 1.88254669e-01f, 6.54542148e-02f, 2.26253718e-01f, 4.27137688e-02f, -3.84766795e-02f, 9.96591449e-02f, -1.02201127e-01f, -2.19417941e-02f, -1.16857953e-01f,
  -1.33899719e-01f, 1.20982170e-01f, -2.68559754e-02f, -1.22260332e-01f, 1.09086102e-02f, -3.64545360e-02f, 9.70233753e-02f, 1.27424940e-01f, -8.34733695e-02f, 3.34457397e-01f,
  -2.53594816e-01f, 9.28101689e-02f, -6.84287176e-02f, -2.31877342e-01f, 8.11379924e-02f, 3.13664153e-02f, 1.70265406e-01f, 1.88648999e-01f, -3.47796753e-02f, -2.42739040e-02f,
  1.43711686e-01f, -1.38976006e-02f, -1.40600696e-01f, 4.72714193e-02f, 3.28643620e-02f, -6.66697100e-02f, -6.00283220e-02f, -8.94938484e-02f, -1.13760076e-01f, -7.34397769e-02f,
  -2.24450082e-01f, 1.53154925e-01f, 1.93733964e-02f, 4.76100668e-02f, -5.64364530e-02f, -1.47571955e-02f, -1.04608238e-02f, -1.26395002e-01f, -2.51615644e-01f, -5.12339808e-02f,
  7.69891441e-02f, 1.36189744e-01f, 6.82922676e-02f, -3.78180593e-02f, -5.68411537e-02f, -2.07012773e-01f, -1.53066278e-01f, -3.69541231e-03f, 3.73308770e-02f, -1.16285220e-01f,
  -9.40255150e-02f, 4.97456975e-02f, 2.33303934e-01f, -2.71965146e-01f, 2.40411833e-02f, -1.38825461e-01f, -8.61506984e-02f, 1.06741808e-01f, -1.77220136e-01f, -5.78772165e-02f,
  -2.00853482e-01f, -8.14191401e-02f, -1.77319840e-01f, 6.27207384e-02f, -3.70839867e-03f, -6.57988340e-02f, 4.05998901e-02f, -8.52423832e-02f, -1.03226088e-01f, 2.96654869e-02f,
  -4.73693088e-02f, -1.38739198e-01f, -3.47799361e-02f, 2.68966723e-02f, -1.26075834e-01f, -2.47001082e-01f, -1.82098802e-02f, 1.98254630e-01f, 1.73188016e-01f, 2.10749075e-01f,
  -1.61192656e-01f, 2.01299548e-01f, -1.01372123e-01f, -1.94002658e-01f, -9.64555219e-02f, -8.85285735e-02f, -4.53590862e-02f, 1.58901196e-02f, 5.81406802e-02f, 8.62860307e-03f,
  2.14739870e-02f, 5.07061854e-02f, -3.79142910e-02f, -6.52459413e-02f, 2.25152099e-03f, -1.00362323e-01f, 1.32641748e-01f, 8.70818868e-02f, 7.20755607e-02f, 5.77816889e-02f,
  -4.86957841e-02f, 3.08470815e-01f, 3.07111561e-01f, 3.00670099e-02f, 2.07700357e-01f, -1.75079405e-01f, -1.77017719e-01f, -6.73288181e-02f, 6.47415742e-02f, -1.61485866e-01f,
  2.58175164e-01f, 5.13074063e-02f, -2.26802584e-02f, -1.12962335e-01f, 4.16148268e-03f, 1.67544961e-01f, -2.16609895e-01f, 3.41705121e-02f, 1.37063831e-01f, 9.75614861e-02f,
  -1.08863644e-01f, 2.51955837e-01f, -1.66149035e-01f, 7.98661485e-02f, -7.28518441e-02f, 1.56536758e-01f, 3.43641154e-02f, 1.34745032e-01f, 6.64169639e-02f, -2.83865500e-02f,
  -7.27809295e-02f, 5.26016951e-02f, 2.38471143e-02f, 1.03275530e-01f, 2.23000329e-02f, 1.22568294e-01f, -1.18148945e-01f, 3.91770929e-01f, -3.42901677e-01f, 5.63757755e-02f,
  -2.06705436e-01f, 1.90523937e-02f, -4.64554466e-02f, 1.49286762e-01f, 6.91901520e-02f, 1.81918144e-01f, -1.26427978e-01f, -6.14422411e-02f, 1.28933534e-01f, 6.32851645e-02f,
  5.80016188e-02f, 3.86622101e-02f, -1.08009391e-01f, 1.22825354e-01f, 1.24097794e-01f, 1.49430037e-01f, -1.76576637e-02f, -9.29417908e-02f, -2.64559627e-01f, -1.54955551e-01f,
  -8.12982544e-02f, -1.05300903e-01f, 1.70297906e-01f, 3.58644240e-02f, 1.38026386e-01f, -6.10492975e-02f, 1.64911021e-02f, 7.32711479e-02f, 1.09209448e-01f, 2.07703128e-01f,
  -9.86928493e-02f, 9.51565579e-02f, -1.08760990e-01f, 4.16212678e-02f, -1.53725147e-01f, -9.16802064e-02f, 2.35808492e-02f, -3.47547606e-02f, 8.77711996e-02f, -9.41105857e-02f,
  -1.50020152e-01f, 1.81346778e-02f, 3.43217663e-02f, 1.24997064e-01f, -4.73355465e-02f, 1.48494765e-01f, -8.01569149e-02f, -2.08539873e-01f, -1.89295724e-01f, 7.88946822e-03f,
  -1.18588097e-01f, -3.19834292e-01f, -4.74527813e-02f, -4.03620340e-02f, -2.28910208e-01f, 2.95192953e-02f, -1.94563761e-01f, -1.76672131e-01f, -3.81333113e-01f, 4.25425209e-02f,
  1.67476818e-01f, -6.31460324e-02f, 3.17285843e-02f, -4.23631638e-01f, 2.39947718e-03f, 1.98961556e-01f, 6.21220283e-02f, -6.20516539e-02f, 8.37993175e-02f, 8.33089426e-02f,
  -1.73098624e-01f, 7.62772420e-03f, -1.83908701e-01f, -4.01747338e-02f, -5.36047779e-02f, -6.29078224e-02f, 1.40467733e-01f, -2.89312024e-02f, -1.22176670e-01f, 3.47716324e-02f,
  -4.34410460e-02f, 2.71790046e-02f, -1.32270589e-01f, 7.30035678e-02f, 1.57542065e-01f, 1.46429166e-01f, -3.34949903e-02f, -1.63767889e-01f, -2.88446695e-02f, 1.75200015e-01f,
  1.25032112e-01f, -7.56960213e-02f, 1.31148890e-01f, -2.50642300e-01f, -2.79177185e-02f, 1.54950306e-01f, 3.65353785e-02f, -1.47678584e-01f, 2.73845941e-01f, 9.87029597e-02f,
  -2.88124196e-02f, -1.14209235e-01f, 5.55616617e-02f, -4.48752344e-02f, 1.53500587e-01f, 1.82484277e-02f, -5.22551239e-02f, 3.01042898e-03f, 5.15324101e-02f, 1.37491569e-01f,
  -2.53442317e-01f, -1.60325393e-01f, -1.71384275e-01f, -1.77010402e-01f, 3.31913531e-02f, -1.10749463e-02f, -4.73112166e-02f, -1.30365565e-01f, -1.94690898e-01f, -2.90015489e-02f,
  -7.81871192e-03f, 5.16508520e-03f, -1.44444376e-01f, -2.40928233e-01f, 2.99995929e-01f, -8.97739083e-02f, 1.25832930e-01f, -2.04285860e-01f, -1.81710660e-01f, 2.36729473e-01f,
  -5.75477406e-02f, -8.41465145e-02f, -3.58486205e-01f, -1.17677085e-01f, -3.84958722e-02f, -2.19169706e-01f, 1.51426703e-01f, 1.09471707e-02f, -2.62299757e-02f, 5.77360904e-03f,
  1.78474247e-01f, 9.99859646e-02f, 1.00779772e-01f, 1.23019926e-01f, 1.34218663e-01f, 6.68871775e-02f, 2.07312420e-01f, -7.62417018e-02f, -4.77314629e-02f, -8.71072710e-02f,
  -1.42486650e-03f, 7.03866500e-03f, 8.02509189e-02f, 1.03646137e-01f, 1.61455765e-01f, -2.15105399e-01f, 1.93136677e-01f, -2.97093415e-03f, -5.84401190e-02f, 3.22842896e-02f,
  -1.15366042e-01f, -1.40332878e-01f, 1.18525788e-01f, 4.83770967e-02f, 9.75166336e-02f, 1.16759233e-01f, -9.13380086e-03f, 9.18313637e-02f, -8.24999437e-02f, -3.98372114e-02f,
  6.44363612e-02f, 5.65971918e-02f, 2.33887415e-02f, -3.88300931e-03f, 1.35862917e-01f, -1.04923472e-01f, 3.22067030e-02f, -1.12442642e-01f, -8.69593695e-02f, -3.33704688e-02f,
  -3.37281339e-02f, -2.50933021e-01f, -3.50409262e-02f, -1.41589776e-01f, -8.04711729e-02f, 1.63469687e-01f, 2.76541431e-02f, 1.79272398e-01f, 9.51844081e-02f, -3.07242572e-01f,
  3.82344238e-02f, 1.14399523e-01f, -4.23172638e-02f, 1.30202085e-01f, -7.13339597e-02f, 7.59342965e-03f, 1.15687028e-02f, -7.34196901e-02f, -6.86261207e-02f, 2.67696857e-01f,
  -1.02930740e-01f, -1.36579171e-01f, -5.42941876e-02f, -1.28590286e-01f, 5.27097806e-02f, -1.41808376e-01f, -5.63368155e-03f, -3.13779265e-02f, 1.56761676e-01f, 5.88309057e-02f,
  1.09840147e-01f, -8.65662321e-02f, 8.90780762e-02f, 7.20275640e-02f, 4.95892540e-02f, -2.90969517e-02f, 2.45785806e-04f, -1.25645986e-02f, -4.79126256e-03f, -1.01840377e-01f,
  -9.85066742e-02f, -3.88346612e-02f, 2.32539564e-01f, -9.99840349e-02f, -1.23529524e-01f, -6.29777238e-02f, -1.35770455e-01f, 8.47073346e-02f, -1.24505065e-01f, 4.07692008e-02f,
  2.78976820e-02f, -1.56909972e-02f, 8.19224268e-02f, 1.89834818e-01f, 4.38563675e-02f, 3.37915830e-02f, -7.38644376e-02f, 2.40892544e-02f
};

// L2_fan_Wp_bar (Shape: 40 x 64)
const int L2_fan_Wp_bar_rows = 40;
const int L2_fan_Wp_bar_cols = 64;
const float L2_fan_Wp_bar_data[] = {
  9.27846357e-02f, 1.64407134e-01f, 8.73080343e-02f, -1.15375491e-02f, 2.19118878e-01f, -7.52298310e-02f, 3.03818192e-02f, -8.40899069e-04f, -1.96635291e-01f, 1.99510697e-02f,
  2.35465199e-01f, -7.98558295e-02f, -1.59151688e-01f, -4.55414839e-02f, -3.64055857e-03f, -2.08607376e-01f, -1.19371563e-01f, -2.20535725e-01f, -1.58428922e-01f, 2.00411230e-01f,
  -1.30074903e-01f, 2.98970509e-02f, 6.22504205e-02f, -1.88196346e-01f, -1.53693948e-02f, 6.93789124e-02f, -6.70441426e-03f, 1.56459827e-02f, 1.20232545e-01f, 1.18128836e-01f,
  4.30886149e-02f, 5.15908897e-02f, -2.96003968e-02f, 1.31956771e-01f, 6.30170479e-02f, 2.14435309e-02f, 2.81263608e-02f, 6.09533302e-02f, 1.06713645e-01f, -1.03045881e-01f,
  -3.18959542e-02f, -1.55534238e-01f, -5.50631583e-02f, -1.18036799e-01f, 3.08688104e-01f, -6.56733736e-02f, -6.14779741e-02f, 3.81731316e-02f, -1.43251106e-01f, -2.27939114e-02f,
  2.01245584e-02f, 1.92511767e-01f, 4.41413410e-02f, 6.54736236e-02f, -8.99825841e-02f, 5.80290630e-02f, -1.28124893e-01f, -9.58274677e-02f, -1.01701401e-01f, 5.13790548e-01f,
  -7.48451147e-03f, 7.64781758e-02f, 7.67728463e-02f, -8.50968584e-02f, 8.53021592e-02f, 3.71636339e-02f, 9.32413992e-03f, -5.39473817e-02f, 1.34126961e-01f, 1.20955080e-01f,
  1.41605169e-01f, -7.04707131e-02f, 1.83263093e-01f, 3.44010033e-02f, 5.13133258e-02f, 1.74029171e-01f, 1.44577801e-01f, 1.80166155e-01f, -2.46948120e-03f, 9.73173976e-02f,
  -1.94894195e-01f, -4.14445810e-02f, -1.10203139e-01f, -1.03597462e-01f, 1.64794996e-01f, -1.39409110e-01f, 7.01341480e-02f, 2.98512459e-01f, 1.67383596e-01f, 1.00456830e-03f,
  1.11339413e-01f, 6.45481050e-02f, 9.22043398e-02f, 9.18102339e-02f, -1.60963647e-02f, 2.30678413e-02f, -5.89617975e-02f, 1.44880954e-02f, -4.55017760e-02f, -8.36162418e-02f,
  -1.04592718e-01f, -1.10221148e-01f, -1.66556358e-01f, 3.65725942e-02f, 8.72886181e-02f, -5.42129502e-02f, 9.41955205e-03f, 1.72132533e-02f, -2.94773132e-02f, -1.24843955e-01f,
  1.62397072e-01f, 1.18382357e-01f, 2.01014087e-01f, -9.63351130e-02f, 3.83853279e-02f, -1.94982305e-01f, 3.96122448e-02f, 1.28716618e-01f, -1.25997528e-01f, 4.38433699e-02f,
  1.14140615e-01f, -2.95088552e-02f, 9.14235115e-02f, -6.22019283e-02f, 9.59736332e-02f, -8.52003470e-02f, -4.67048399e-02f, 1.21548228e-01f, -1.63631514e-01f, -1.02303764e-02f,
  4.04277295e-02f, 5.42415902e-02f, 2.05086358e-02f, -6.45347983e-02f, -1.72152027e-01f, 7.92544149e-03f, -5.89466430e-02f, 5.03496863e-02f, -1.75111994e-01f, -1.52983531e-01f,
  -6.27366230e-02f, -2.07604468e-01f, -1.22763880e-01f, 4.24691737e-02f, 4.13798764e-02f, -1.64605305e-01f, -1.98297426e-01f, -1.01581253e-01f, -7.08387420e-02f, -1.26741663e-01f,
  3.87049206e-02f, -1.14803329e-01f, -1.02189630e-01f, -1.48018107e-01f, 8.13280325e-03f, 1.50617436e-01f, -1.28929149e-02f, 6.45759702e-02f, 9.16193575e-02f, 1.14843808e-01f,
  -6.78539425e-02f, 1.48422018e-01f, -2.55329441e-02f, 6.31135628e-02f, 7.18690977e-02f, -1.49257526e-01f, 5.34635670e-02f, -2.20867917e-02f, 1.17298961e-02f, -1.48616180e-01f,
  1.15511782e-01f, 1.66700736e-01f, 2.63539702e-01f, 6.26282208e-03f, -8.72558355e-03f, 8.55229869e-02f, -4.02241722e-02f, -1.12277299e-01f, 1.03258371e-01f, 9.40659046e-02f,
  1.84930772e-01f, -1.14294209e-01f, -2.13789120e-02f, 5.26826382e-02f, 1.20706178e-01f, -3.49956751e-02f, 6.15353435e-02f, 2.67371178e-01f, 1.18400417e-02f, 7.18645602e-02f,
  6.26995862e-02f, -3.87562402e-02f, -7.47307250e-03f, -3.73345576e-02f, -4.15156931e-02f, -2.57313699e-02f, -1.14816688e-02f, -1.21487074e-01f, -4.61837649e-02f, -9.99245569e-02f,
  1.32197917e-01f, 5.77281825e-02f, -7.42668938e-03f, 8.48853439e-02f, 6.36188090e-02f, 7.46972784e-02f, -1.33569157e-02f, 1.60800263e-01f, -9.23248306e-02f, -9.81475487e-02f,
  -6.31828010e-02f, -5.49341477e-02f, 8.06683972e-02f, 5.38428612e-02f, 2.88264230e-02f, 1.43939421e-01f, 1.35969356e-01f, -9.78041068e-03f, 7.25324750e-02f, -4.40832339e-02f,
  2.84236409e-02f, -2.96269972e-02f, -1.19894795e-01f, 9.09576416e-02f, -9.57983360e-02f, 6.38633370e-02f, 6.74688518e-02f, -9.83289331e-02f, -7.72733912e-02f, -1.75306946e-02f,
  4.96766306e-02f, -4.00126427e-02f, 1.18331060e-01f, 3.20804454e-02f, 2.68139541e-02f, -5.45127541e-02f, 1.32917956e-01f, 7.30041638e-02f, -1.14904970e-01f, 2.11380161e-02f,
  1.32591963e-01f, -1.87475178e-02f, -6.44546598e-02f, 6.95870295e-02f, -4.81241383e-02f, 1.24974251e-01f, 9.30588990e-02f, 1.13409184e-01f, 9.75314993e-03f, -1.19653560e-01f,
  -7.41479620e-02f, 1.60726413e-01f, -6.44032210e-02f, 7.68605918e-02f, 1.21817321e-01f, 1.18447766e-01f, -1.37171494e-02f, 1.27212465e-01f, 1.92053407e-01f, -1.52047467e-03f,
  2.30723530e-01f, 2.77953558e-02f, 1.98617458e-01f, 7.91419372e-02f, 9.56143737e-02f, 8.23767930e-02f, 2.10218608e-01f, 1.52475074e-01f, -7.81588331e-02f, 1.97676539e-01f,
  -1.23660676e-02f, -9.12544280e-02f, -1.34913802e-01f, -1.63040847e-01f, -7.22521842e-02f, 2.51395721e-02f, 1.06750466e-01f, 8.36629942e-02f, -2.58623939e-02f, -7.40474984e-02f,
  8.61768499e-02f, -3.87643687e-02f, 4.59866524e-02f, 5.94213232e-02f, 3.84000205e-02f, 6.48938343e-02f, 3.73091809e-02f, 5.70991961e-03f, -6.04530275e-02f, -8.93993601e-02f,
  1.36900470e-02f, -2.11499073e-02f, 3.43782492e-02f, 3.95317934e-03f, 1.62744984e-01f, 4.00563590e-02f, 7.15815127e-02f, 2.21578050e-02f, 6.50973096e-02f, -6.72148019e-02f,
  1.81934699e-01f, 2.03234442e-02f, -6.88453913e-02f, -1.49525583e-01f, 4.07027081e-03f, 2.10091919e-01f, -6.35309443e-02f, 8.21877345e-02f, 3.70310037e-03f, -1.81175652e-03f,
  9.14527848e-03f, 4.47000936e-02f, -7.73788244e-02f, 9.21910331e-02f, -1.56497750e-02f, 3.78884971e-01f, 9.02940147e-03f, -1.96856577e-02f, 1.38036106e-02f, 2.27448180e-01f,
  2.58750562e-02f, -4.96395044e-02f, -1.01954989e-01f, -9.54678580e-02f, 9.04607102e-02f, 3.86731438e-02f, 9.57358163e-03f, 1.42052829e-01f, 5.60213439e-02f, 1.37827098e-01f,
  -6.00230135e-02f, -9.67448950e-02f, -6.04298804e-03f, 1.10970601e-01f, 1.15483664e-01f, -8.10518041e-02f, -5.37878238e-02f, -8.63927901e-02f, 1.60214424e-01f, 3.46880071e-02f,
  7.89454728e-02f, -7.69905932e-03f, -4.32787798e-02f, -1.93652399e-02f, -1.09268770e-01f, -1.07261956e-01f, 9.28253606e-02f, -4.34443392e-02f, 5.42504787e-02f, -5.34657575e-02f,
  1.04079451e-02f, 1.67344272e-01f, 8.15600827e-02f, -8.37929994e-02f, 7.00214580e-02f, 1.32966926e-03f, -1.04757562e-01f, 2.73599159e-02f, -1.13202306e-02f, 7.03252330e-02f,
  -4.32391316e-02f, -1.05046920e-01f, 1.65571153e-01f, -4.88408841e-02f, 4.30588573e-02f, -5.36187813e-02f, -6.78725764e-02f, 8.62321481e-02f, -4.48348075e-02f, 5.93561959e-03f,
  -1.27722204e-01f, 1.71729162e-01f, 3.60499136e-02f, -2.93617491e-02f, 8.70119184e-02f, 4.15054942e-03f, 3.81948985e-02f, -1.21813260e-01f, -9.96866897e-02f, -1.28568325e-03f,
  6.09497800e-02f, 1.10916555e-01f, -1.12675488e-01f, 1.51979953e-01f, 6.53569102e-02f, 1.37726262e-01f, 4.75534461e-02f, -4.73038852e-03f, 1.29316568e-01f, 1.33501878e-02f,
  -1.15849953e-02f, 8.48906301e-03f, -1.09137662e-01f, -5.82676567e-02f, -1.04136921e-01f, -8.85489658e-02f, 5.05062789e-02f, -1.11083046e-01f, 7.74533525e-02f, -8.03685784e-02f,
  1.50847346e-01f, -1.58380657e-01f, -5.37534170e-02f, 3.47077437e-02f, 5.62047400e-02f, 6.01555631e-02f, 5.21070771e-02f, -1.49100646e-01f, -2.57367417e-02f, -8.53777304e-02f,
  -8.64144191e-02f, 1.30138263e-01f, 7.64077082e-02f, 1.13468086e-02f, -4.95690629e-02f, -3.00464779e-02f, -3.92182209e-02f, 7.49032125e-02f, -5.10564484e-02f, 8.07674378e-02f,
  1.32589817e-01f, 8.95623416e-02f, -5.69924153e-02f, 2.71768551e-02f, 1.09314695e-01f, -5.02282977e-02f, -3.81809920e-02f, 1.75066113e-01f, 8.55206177e-02f, 1.00804128e-01f,
  8.47832561e-02f, -1.13725483e-01f, -1.37284309e-01f, 8.51879790e-02f, -7.47803971e-02f, 1.56472296e-01f, 3.33665647e-02f, -8.37154612e-02f, -3.62458192e-02f, 1.15152173e-01f,
  -1.08616270e-01f, 7.78092444e-02f, -1.33653626e-01f, 1.21953227e-01f, -8.07750877e-03f, 4.32383176e-03f, 2.22241245e-02f, 2.59134769e-02f, 6.95014223e-02f, 9.48116928e-02f,
  1.68283671e-01f, 8.87330547e-02f, 8.74905214e-02f, -1.24429971e-01f, -6.94419518e-02f, -7.80309364e-02f, 3.46353687e-02f, 7.34917000e-02f, -1.09264925e-02f, 5.85524924e-02f,
  -2.30217539e-02f, 1.43422678e-01f, -9.45381448e-02f, -1.46122668e-02f, -9.48379114e-02f, 1.99372485e-01f, -7.89529160e-02f, -3.79367769e-02f, 6.43695295e-02f, -5.29805496e-02f,
  -1.07322641e-01f, 5.29290643e-03f, 6.33054320e-03f, 1.67939827e-01f, -1.91435572e-02f, -1.12937421e-01f, -4.60883789e-03f, 3.64328325e-02f, -1.46352947e-01f, -9.85217169e-02f,
  -4.74297367e-02f, 1.26619488e-01f, -2.99671181e-02f, -1.88966896e-02f, -8.97425190e-02f, 7.88374990e-02f, 3.66972163e-02f, -7.33026713e-02f, 2.12543048e-02f, -3.15189883e-02f,
  -4.48441319e-02f, 2.06136763e-01f, 1.32314831e-01f, -8.13138783e-02f, 7.10348859e-02f, -1.55115679e-01f, 3.34606290e-01f, -3.62246344e-03f, -1.31668493e-01f, -9.04204473e-02f,
  -9.21146125e-02f, 1.39040411e-01f, 1.01061866e-01f, -3.65291908e-02f, 1.08218633e-01f, -2.08588727e-02f, 1.25600621e-01f, 1.21253587e-01f, 8.83316100e-02f, -3.86282653e-02f,
  1.18064927e-02f, 1.28157660e-01f, 1.72371447e-01f, 1.71920255e-01f, 1.93546060e-02f, 2.27088735e-01f, 1.76450729e-01f, 1.21963881e-01f, 1.64684758e-01f, 8.19745362e-02f,
  2.17904150e-01f, 1.87674120e-01f, 2.09830329e-01f, 8.55948776e-02f, 3.28523144e-02f, 1.09023474e-01f, -1.76355481e-01f, 3.97200286e-01f, -4.05515283e-01f, 1.54225111e-01f,
  -2.49396294e-01f, -1.31567851e-01f, -6.45457879e-02f, -1.29133061e-01f, -2.40941867e-01f, 1.97489709e-01f, 1.64384827e-01f, -7.87336752e-02f, 3.30240756e-01f, 8.93221200e-02f,
  -1.54634491e-01f, 1.14650093e-01f, -3.07861827e-02f, -1.12108283e-01f, 9.69859362e-02f, 1.71530485e-01f, 1.04323149e-01f, 2.59361804e-01f, -1.82414025e-01f, -1.85495779e-01f,
  -7.20160920e-03f, -3.39308865e-02f, 1.68412030e-01f, 2.01730039e-02f, 3.88469920e-02f, 1.14536673e-01f, 1.22113369e-01f, -3.66876572e-02f, 2.96251684e-01f, 5.35202622e-01f,
  -8.76018405e-02f, -1.90578088e-01f, -2.81099379e-02f, -2.02785894e-01f, -1.39554173e-01f, -3.76585796e-02f, 7.71377608e-02f, -2.74645630e-02f, 1.63094938e-01f, 7.87873939e-02f,
  8.66004601e-02f, -3.64180431e-02f, -4.09200452e-02f, 3.76628675e-02f, -7.31009021e-02f, 2.24201381e-01f, 5.87345622e-02f, 6.00301921e-02f, 6.93887472e-02f, 1.29021294e-02f,
  -9.96956751e-02f, -1.24166384e-01f, 2.10360065e-02f, 3.06692738e-02f, -8.90334472e-02f, -1.03758812e-01f, -8.11988488e-03f, -8.17713812e-02f, -5.04683703e-02f, 1.40515983e-01f,
  -1.91207658e-02f, -5.03867604e-02f, -5.96639328e-02f, -4.63649146e-02f, 5.91003783e-02f, -7.99874589e-02f, 8.66115242e-02f, -7.61051625e-02f, -2.51159854e-02f, 2.69790087e-02f,
  1.15590207e-01f, 1.17230870e-01f, -2.47576856e-03f, 4.69817482e-02f, 1.93291418e-02f, 9.22216475e-02f, 1.14587180e-01f, -5.31742238e-02f, 6.63104132e-02f, 7.32213780e-02f,
  -9.24313590e-02f, -9.72507596e-02f, -4.31208573e-02f, 9.08838958e-02f, -4.50826697e-02f, 5.88358343e-02f, -5.34821078e-02f, -1.94431413e-02f, 7.37837926e-02f, -7.66826123e-02f,
  3.72121669e-02f, 1.00527983e-02f, -9.97550711e-02f, 2.28701346e-02f, 8.22734386e-02f, -8.18885788e-02f, 1.64520666e-02f, 7.76525289e-02f, -1.30074337e-01f, -1.04683593e-01f,
  6.73275888e-02f, -1.22567847e-01f, 6.92786574e-02f, -3.40582058e-02f, -4.04539183e-02f, 5.65130226e-02f, 3.89678031e-02f, 1.17522813e-01f, 4.81349491e-02f, 2.25580614e-02f,
  -9.97596532e-02f, 4.75556999e-02f, -6.24485277e-02f, -1.02123708e-01f, 3.92974950e-02f, 7.29807466e-02f, 2.46157460e-02f, 8.92034266e-03f, 9.45382193e-02f, 9.76038799e-02f,
  -1.06952459e-01f, 1.01770736e-01f, -1.12840487e-02f, -8.40616599e-02f, 1.95609797e-02f, -3.22600012e-03f, -7.56151602e-02f, 7.94542730e-02f, 2.61165630e-02f, -1.30733177e-01f,
  -1.49499150e-02f, 6.34319521e-03f, 2.42641624e-02f, -8.67903382e-02f, -1.54087255e-02f, -2.87239905e-02f, -5.40586486e-02f, -5.48114032e-02f, -1.55699998e-02f, -1.66418236e-02f,
  -7.50338286e-02f, -1.36399180e-01f, 1.06923126e-01f, -2.48968182e-03f, -9.35205370e-02f, 1.23394057e-01f, 1.47972807e-01f, -3.94666418e-02f, -6.67408407e-02f, 6.17096871e-02f,
  -7.12185875e-02f, 1.18388832e-01f, 9.84065160e-02f, 7.37206191e-02f, -3.29724625e-02f, -2.54268441e-02f, -6.23753332e-02f, 8.36544186e-02f, -8.18668529e-02f, -1.34930134e-01f,
  4.15288992e-02f, -6.83306456e-02f, 1.02583081e-01f, -6.14985963e-03f, -2.79965308e-02f, -2.37842798e-02f, -4.31300178e-02f, 7.80337602e-02f, -9.54490751e-02f, -7.96991959e-02f,
  2.23359037e-02f, -4.67818836e-03f, -1.45723214e-02f, 3.65249105e-02f, 2.30822578e-01f, 1.58973455e-01f, 2.38392487e-01f, 1.47776499e-01f, 2.61959046e-01f, 3.31757218e-01f,
  2.81859845e-01f, 1.26265556e-01f, -7.68314525e-02f, 1.11145183e-01f, 1.60611257e-01f, 1.71452612e-01f, -4.54804488e-02f, 1.38751671e-01f, 6.08240478e-02f, -1.24261037e-01f,
  -1.03173971e-01f, -2.06087038e-01f, -4.85155344e-01f, 2.35813335e-01f, -2.57469863e-01f, -2.39966616e-01f, -3.36418658e-01f, -1.20737895e-01f, 3.37320343e-02f, 9.29657444e-02f,
  5.78657240e-02f, 1.62098050e-01f, 6.27284721e-02f, -1.16092034e-01f, 7.50164874e-03f, -7.85837919e-02f, -1.12158969e-01f, 1.68106750e-01f, 4.20039892e-02f, 1.77328736e-01f,
  -4.25827876e-03f, -1.85301557e-01f, 3.71347405e-02f, -1.53692931e-01f, -8.06455612e-02f, 6.60798997e-02f, -1.94679052e-01f, 1.59569889e-01f, 1.78387329e-01f, -2.17560962e-01f,
  8.96876603e-02f, 4.24740672e-01f, -1.84555762e-02f, -4.42097299e-02f, -1.20609239e-01f, -5.78621589e-02f, 3.84755433e-03f, 4.01009545e-02f, -6.89847618e-02f, -1.10365987e-01f,
  1.38620093e-01f, -1.28345609e-01f, 2.47695930e-02f, 3.21159840e-01f, -4.03149761e-02f, -8.28674901e-03f, -1.00781068e-01f, 3.29585858e-02f, 3.69570740e-02f, 1.06468141e-01f,
  -5.89867719e-02f, -3.31743248e-02f, -3.07277367e-02f, 2.33132951e-02f, 2.30083406e-01f, -5.56355678e-02f, 3.42461318e-01f, 1.00765847e-01f, 8.30771402e-03f, 1.90786779e-01f,
  6.55790195e-02f, -2.65761968e-02f, 2.73833930e-01f, -2.26908386e-01f, 1.37863740e-01f, 6.18189238e-02f, 2.54086643e-01f, 1.82341903e-01f, -1.26507739e-02f, 1.64105296e-01f,
  -1.15018159e-01f, 7.15894764e-03f, 4.21128934e-03f, -8.11018646e-02f, 1.33624211e-01f, -1.91256955e-01f, 2.37862058e-02f, -5.47779389e-02f, -2.32289471e-02f, 2.17013713e-02f,
  3.47215459e-02f, 1.07488986e-02f, 2.67410167e-02f, 5.09005114e-02f, 3.28590870e-01f, 1.03505686e-01f, -4.87892218e-02f, 1.20773338e-01f, -2.30689887e-02f, -3.00140213e-02f,
  -1.00537717e-01f, 4.47023034e-01f, 8.79716650e-02f, 1.58963799e-02f, 1.28834844e-01f, -1.26817375e-01f, 2.56167173e-01f, 1.50047407e-01f, 7.36747459e-02f, 8.66457969e-02f,
  7.35588605e-04f, -1.19778477e-01f, -5.64180464e-02f, -5.36614656e-02f, -2.83459332e-02f, 1.74745902e-01f, -5.93432412e-02f, -9.29836109e-02f, -6.03959635e-02f, 4.08007167e-02f,
  -9.89002809e-02f, 2.93581694e-01f, -8.71606693e-02f, 2.27024555e-02f, -7.62681961e-02f, 1.21103272e-01f, 1.38420895e-01f, 4.87870770e-03f, 3.65795568e-02f, 1.44064218e-01f,
  9.94951054e-02f, 2.04205647e-01f, 2.00565726e-01f, -2.64326632e-02f, -4.75173350e-04f, -5.14396988e-02f, -2.49460787e-02f, 7.47336373e-02f, -1.61624968e-01f, -1.94832180e-02f,
  2.64537558e-02f, 2.07516164e-01f, 1.09563537e-01f, 3.16797905e-02f, 4.61364118e-03f, -1.00853488e-01f, -7.33877569e-02f, -1.51359662e-01f, 1.73677713e-01f, 1.01532817e-01f,
  5.63483536e-02f, -5.30948788e-02f, 7.22059309e-02f, 1.44254670e-01f, -1.07884079e-01f, 3.50473188e-02f, -4.85606343e-02f, -1.19631201e-01f, 1.72142252e-01f, -3.87270227e-02f,
  1.32284805e-01f, 6.80959597e-02f, 5.01976274e-02f, -6.53442070e-02f, 1.10217892e-01f, -1.00122206e-01f, 2.02034265e-01f, 1.85856938e-01f, -1.22465543e-01f, 1.21284224e-01f,
  -1.53846532e-01f, 2.37210780e-01f, 7.02926517e-02f, 1.33929104e-01f, 1.40885472e-01f, -3.94647792e-02f, -4.90768626e-02f, -1.91503670e-02f, -2.64848284e-02f, -1.54660508e-01f,
  -1.74651623e-01f, 1.75255574e-02f, 4.25812081e-02f, 7.48185441e-02f, -3.57862264e-02f, 2.73003370e-01f, 1.95975155e-01f, 2.31465235e-01f, 1.26426704e-02f, 7.05877021e-02f,
  9.75515693e-02f, 9.58582684e-02f, 1.19598456e-01f, 9.35592949e-02f, 1.05575241e-01f, 1.39781192e-01f, 7.40640098e-03f, -1.55885205e-01f, 2.89690532e-02f, -1.41173240e-03f,
  2.16595791e-02f, -1.93726182e-01f, 1.20481208e-01f, -2.99220234e-01f, 2.04057783e-01f, 2.73486763e-01f, -3.36507708e-02f, 2.16495007e-01f, -3.06359289e-04f, -2.03706622e-01f,
  -1.49988413e-01f, -4.98713702e-02f, -1.46337271e-01f, -2.83140708e-02f, 8.99081528e-02f, 1.54052407e-01f, 5.88823855e-02f, 7.55634457e-02f, -6.73615709e-02f, 7.76954219e-02f,
  6.78282306e-02f, -2.07246467e-01f, 2.50732094e-01f, -5.32498285e-02f, 2.19434381e-01f, 3.72949243e-02f, -1.22538574e-01f, 1.18308283e-01f, 5.45169860e-02f, -4.63316925e-02f,
  1.41867414e-01f, 2.61924326e-01f, -1.39333634e-02f, -6.28542900e-02f, -1.47916600e-01f, 2.85721600e-01f, 1.34425536e-01f, 3.87296051e-01f, 8.29083554e-04f, 1.10788837e-01f,
  2.40112713e-04f, 2.63404138e-02f, -4.07141745e-02f, -1.51433647e-01f, -1.06971718e-01f, 1.45127967e-01f, -3.91298980e-02f, 4.94614094e-02f, 9.03083906e-02f, 1.22106567e-01f,
  4.87219356e-03f, -2.23408062e-02f, 4.79294583e-02f, 3.06694601e-02f, -8.65284577e-02f, 9.86007750e-02f, -9.85802338e-03f, 5.95568866e-02f, 1.23451434e-01f, 1.17517307e-01f,
  -9.84474644e-02f, -3.07737733e-03f, -8.55901167e-02f, -9.20619294e-02f, 1.96435004e-01f, -8.50709081e-02f, 1.56453952e-01f, 8.68789479e-02f, -8.77489150e-02f, 1.69575983e-03f,
  -9.53749642e-02f, -1.13311768e-01f, 1.11175776e-02f, -1.84273720e-01f, 5.10666445e-02f, -1.02114663e-01f, 1.63086578e-01f, -1.19617783e-01f, -4.96527515e-02f, -1.99303646e-02f,
  7.81171471e-02f, 6.33279085e-02f, -7.09718987e-02f, -3.68199944e-02f, -3.31788287e-02f, 1.59031942e-01f, -1.26637705e-02f, -1.19448528e-01f, 1.35959521e-01f, 1.03470691e-01f,
  -6.06299005e-02f, 3.03295497e-02f, -1.10084772e-01f, 1.58030495e-01f, 1.00217327e-01f, -1.37043729e-01f, 1.20020151e-01f, 1.54187113e-01f, 3.74346599e-02f, -6.16046228e-02f,
  1.80026237e-02f, -8.63193721e-02f, -4.78885509e-02f, -4.13368084e-02f, -7.41758049e-02f, 1.42453104e-01f, 1.39181748e-01f, -1.40180765e-03f, -6.31663902e-03f, -1.43706109e-02f,
  -7.94069022e-02f, 2.63571274e-02f, -2.59244535e-02f, -1.49961814e-01f, 1.56738892e-01f, 1.38728663e-01f, 4.34333086e-02f, 1.38958171e-01f, 2.29230104e-03f, -1.04498886e-01f,
  -5.34904189e-02f, 1.75595075e-01f, 2.08105311e-01f, 1.45313159e-01f, -5.02332039e-02f, -5.56436740e-02f, 1.66413501e-01f, -2.17813980e-02f, 7.49138817e-02f, -1.29052280e-02f,
  1.16985627e-01f, 2.16757581e-01f, 1.88195795e-01f, -1.31302491e-01f, 4.42169495e-02f, 5.77681251e-02f, 1.94870263e-01f, -7.79388994e-02f, 9.48173329e-02f, 1.87942192e-01f,
  1.05801642e-01f, -1.23685829e-01f, -4.44417894e-02f, 1.29446432e-01f, 1.11759357e-01f, 2.17628740e-02f, -1.08031839e-01f, -7.67507553e-02f, -6.78659901e-02f, -1.17984422e-01f,
  2.06975356e-01f, 1.38134524e-01f, -4.05635387e-02f, 2.50606295e-02f, 4.32279659e-03f, 5.51251657e-02f, 1.34053305e-01f, -7.89677724e-02f, -1.75196547e-02f, 2.13911742e-01f,
  -3.63706239e-03f, -1.01430625e-01f, 1.61884531e-01f, 1.44390181e-01f, -1.00264579e-01f, 1.92358673e-01f, -7.72157386e-02f, -2.36080494e-02f, -1.13437682e-01f, -5.98715656e-02f,
  8.13288614e-02f, -9.46528688e-02f, 7.70561323e-02f, -3.16637233e-02f, -1.05390050e-01f, 6.49492890e-02f, 9.94444862e-02f, -7.83254430e-02f, 2.29835510e-02f, 2.34089166e-01f,
  4.24430259e-02f, -4.72447183e-03f, 1.52178958e-01f, 4.32535857e-02f, 4.53900546e-02f, 6.14482649e-02f, -9.32978839e-02f, -3.94511223e-02f, -5.86314090e-02f, 2.53799766e-01f,
  1.40622370e-02f, 4.90325317e-02f, -7.95184076e-02f, -1.97901994e-01f, 4.25080545e-02f, -2.63070129e-02f, -2.29566589e-01f, 4.21191473e-03f, -2.10147426e-01f, -9.89065394e-02f,
  -1.61738962e-01f, -2.03896895e-01f, 1.32279292e-01f, 2.27139845e-01f, -9.16274786e-02f, 3.48332897e-02f, -1.26599222e-01f, -1.32085100e-01f, -1.00550450e-01f, 8.37276652e-02f,
  -1.17304102e-01f, -8.70452747e-02f, 1.24961764e-01f, 1.35655075e-01f, 3.57884914e-02f, -1.53018638e-01f, 6.91717118e-02f, -9.47816148e-02f, 1.20324835e-01f, 9.45139825e-02f,
  -4.54799831e-02f, 1.55073494e-01f, -1.86969470e-02f, -4.78121974e-02f, -1.05698749e-01f, 3.44492979e-02f, 4.41875495e-02f, 1.07540056e-01f, -1.04242258e-01f, 4.08097617e-02f,
  1.30004331e-01f, 9.73411202e-02f, 5.34264855e-02f, 7.54510015e-02f, -3.53676490e-02f, -2.61437595e-02f, 6.07260391e-02f, 4.66438532e-01f, -1.13752514e-01f, 1.66598260e-01f,
  -4.24206071e-03f, -1.30405203e-01f, 1.14048481e-01f, 3.39350589e-02f, 2.35674813e-01f, 1.81200013e-01f, 8.51303190e-02f, 3.91875058e-01f, 7.49740899e-02f, 6.89533725e-02f,
  2.39486665e-01f, 1.93521440e-01f, 8.99337679e-02f, 2.86267728e-01f, 5.66030443e-02f, -7.22723603e-02f, 1.47996157e-01f, -2.26235360e-01f, 2.73520112e-01f, 1.88470960e-01f,
  -5.31264022e-03f, 1.84738785e-01f, -8.08622316e-02f, -3.75395827e-02f, -1.69751465e-01f, -1.72022954e-01f, 7.95983672e-02f, -7.21776709e-02f, 1.72343135e-01f, -1.80937126e-02f,
  5.73803373e-02f, 7.56085217e-02f, -8.77143517e-02f, 1.28209502e-01f, 6.28793016e-02f, 4.04203571e-02f, 3.72853540e-02f, 1.43754750e-01f, 1.49012551e-01f, -1.15591064e-01f,
  2.77634021e-02f, 6.64486885e-02f, 5.59249148e-03f, 1.04144700e-01f, -6.41401708e-02f, 1.68012336e-01f, -5.47074936e-02f, 1.14925364e-02f, 1.46156356e-01f, 1.60481364e-01f,
  -1.32272854e-01f, 3.39674726e-02f, 9.09400433e-02f, -6.08903281e-02f, -6.55403510e-02f, -1.08251505e-01f, 8.56508091e-02f, 1.24494456e-01f, -8.57270658e-02f, 6.58446327e-02f,
  -1.66018128e-01f, -8.77224132e-02f, -3.96387503e-02f, 1.44792527e-01f, -3.30726877e-02f, 1.68025807e-01f, 1.28796995e-01f, 3.61030214e-02f, 6.43927604e-02f, -8.17847028e-02f,
  -5.96492402e-02f, -9.15913433e-02f, 3.97855192e-02f, 8.82325172e-02f, 6.01615198e-02f, 5.76594891e-03f, -8.51506591e-02f, 1.83943342e-02f, 4.73759063e-02f, 1.20394178e-01f,
  -1.48112535e-01f, 1.65291801e-01f, -1.55131683e-01f, -6.00977801e-03f, -5.56925870e-02f, -9.27296001e-03f, 1.16475672e-01f, -1.17817387e-01f, 1.12279586e-01f, 1.72767177e-01f,
  1.06113851e-01f, 1.31753162e-01f, 1.04151070e-01f, 1.87586695e-01f, -3.59774828e-02f, -8.61890838e-02f, -7.94646442e-02f, 1.27592966e-01f, -1.21577084e-01f, 4.55658957e-02f,
  -1.17558092e-01f, 1.06359959e-01f, -1.34473722e-02f, -1.59709696e-02f, 1.73037469e-01f, 7.01005533e-02f, 1.35991812e-01f, -4.34758589e-02f, 4.10088636e-02f, -1.39248371e-01f,
  1.02272578e-01f, -7.78784826e-02f, 5.67437522e-02f, 2.24240616e-01f, -8.39988291e-02f, 2.45215222e-02f, 2.30903141e-02f, -7.78637975e-02f, 1.35732204e-01f, 1.34953722e-01f,
  4.07240503e-02f, -8.28813538e-02f, 6.31972477e-02f, -2.44425633e-03f, 4.59120162e-02f, -6.73593441e-03f, -9.99458134e-02f, -2.31074188e-02f, -8.21636468e-02f, 1.09621674e-01f,
  7.87424520e-02f, -4.48563881e-02f, 7.95867108e-03f, 4.15655561e-02f, -1.34382639e-02f, -2.95888670e-02f, 1.12510636e-01f, -8.60617831e-02f, 5.16143888e-02f, -9.81393643e-03f,
  8.30666944e-02f, -1.25953436e-01f, -1.48393631e-01f, -2.84775831e-02f, 1.76056996e-01f, -5.36893569e-02f, 1.12437591e-01f, -5.75275756e-02f, 2.15773121e-01f, 1.18688621e-01f,
  -4.75678220e-02f, 8.62858295e-02f, 2.39161085e-02f, 4.29280587e-02f, 3.76568586e-02f, 1.51485885e-02f, -8.97702202e-02f, 4.69633378e-02f, -8.42957497e-02f, 1.07630836e-02f,
  -9.91867185e-02f, 3.99710760e-02f, 9.27694067e-02f, -1.16173275e-01f, 1.59339663e-02f, -1.35559216e-01f, 2.06503212e-01f, 1.49578735e-01f, -2.26095989e-02f, 7.09333867e-02f,
  -7.60684758e-02f, -1.07783273e-01f, 7.72045087e-03f, 2.08478093e-01f, -1.17540527e-02f, -5.37625067e-02f, 6.57037422e-02f, -1.95867479e-01f, 1.71244591e-01f, 1.66470543e-01f,
  2.74166744e-02f, 6.78495914e-02f, 1.01105601e-01f, -4.15707491e-02f, 6.01346157e-02f, 1.32465716e-02f, 1.00103833e-01f, -3.26233245e-02f, -3.31506804e-02f, -6.01326637e-02f,
  1.00883365e-01f, -8.08472186e-02f, 6.80439025e-02f, 3.20971645e-02f, -5.92953376e-02f, -2.35980190e-02f, 2.10023206e-02f, -6.98546916e-02f, 6.13759160e-02f, -3.66084725e-02f,
  2.40172625e-01f, -7.26760626e-02f, 1.85415268e-01f, 3.83258909e-02f, 3.65451351e-02f, 2.98293065e-02f, 2.36061409e-01f, 1.01152800e-01f, -2.06631958e-01f, 8.68196413e-02f,
  -2.18741968e-01f, -3.26172747e-02f, -4.13772985e-02f, -3.82022038e-02f, 1.42332077e-01f, 2.38422789e-02f, 1.79186210e-01f, 1.90955341e-01f, 4.97076064e-02f, -3.08953747e-02f,
  1.70338005e-02f, 5.78809381e-02f, 8.57129507e-03f, -9.86126438e-02f, 6.00951314e-02f, -6.05340488e-02f, -9.93116871e-02f, -1.02844546e-02f, -8.67024735e-02f, -4.45452072e-02f,
  -6.46859482e-02f, -7.34548941e-02f, -9.43214223e-02f, -1.66442357e-02f, -4.89527136e-02f, 9.64693725e-02f, 9.67959464e-02f, 3.19804884e-02f, -3.45306396e-02f, 7.46999905e-02f,
  3.18733193e-02f, 2.75121033e-01f, 9.90776420e-02f, -8.06358382e-02f, -8.58406648e-02f, -1.27549633e-01f, 4.50794362e-02f, 1.15613893e-01f, -8.34785625e-02f, -1.28386691e-01f,
  -4.77766469e-02f, -2.79570073e-02f, -4.56966683e-02f, 1.01868168e-01f, -7.72812068e-02f, 2.98804771e-02f, 6.61831424e-02f, 1.88138753e-01f, 1.34200215e-01f, -6.89741001e-02f,
  8.23001843e-03f, -3.70841250e-02f, -1.29215019e-02f, -4.94083948e-02f, -2.02810150e-02f, 7.25223273e-02f, 1.09552190e-01f, 3.05144191e-02f, -5.13059273e-02f, 8.45951065e-02f,
  7.01931119e-02f, -6.57860637e-02f, 4.10857126e-02f, 1.15151294e-01f, -1.57388538e-01f, 1.20730754e-02f, -1.39402688e-01f, -9.89757013e-03f, 7.33547732e-02f, -9.76556391e-02f,
  1.10772403e-03f, -6.84463382e-02f, 1.26856774e-01f, -8.33718181e-02f, 6.78184330e-02f, 1.64508782e-02f, 7.32873604e-02f, -2.62444206e-02f, 1.22081637e-01f, -3.32401097e-02f,
  7.95804188e-02f, 4.95390706e-02f, 3.63717265e-02f, 1.18011504e-01f, -9.04957857e-03f, 6.63744137e-02f, -1.08006053e-01f, 9.81070753e-03f, 1.16339475e-01f, 5.74183501e-02f,
  -3.09124067e-02f, 5.04082516e-02f, -4.46115546e-02f, 3.22496938e-03f, 1.11717977e-01f, -2.11578272e-02f, -7.34449700e-02f, 7.45158121e-02f, -4.52235490e-02f, -1.20140903e-01f,
  -1.09954417e-01f, 4.90282588e-02f, -6.55217767e-02f, -7.90796652e-02f, 7.36914799e-02f, 1.21870331e-01f, -8.82626101e-02f, 1.25428602e-01f, 9.46774408e-02f, -6.95359930e-02f,
  -1.10367216e-01f, -5.13179712e-02f, -7.03297108e-02f, 9.73466039e-03f, -8.38948712e-02f, -8.28693062e-02f, 2.12013185e-01f, 5.22742346e-02f, 1.38308313e-02f, 9.28885862e-02f,
  -2.08455116e-01f, -4.06853668e-02f, 1.65045962e-01f, -6.51780143e-02f, -1.73340231e-01f, -1.21911960e-02f, 4.10020985e-02f, 9.66824591e-02f, -1.77350700e-01f, -1.61994755e-01f,
  -1.90967426e-01f, 1.49141848e-01f, -1.43868431e-01f, 2.76597906e-02f, -8.86688754e-02f, -1.88102633e-01f, -8.93600732e-02f, 1.27336383e-01f, -8.14845935e-02f, 7.01976866e-02f,
  1.25220850e-01f, -8.89535844e-02f, 4.86448333e-02f, 9.75336730e-02f, -4.67195474e-02f, 8.29636902e-02f, 9.08876285e-02f, 6.11847639e-02f, 7.76344091e-02f, -9.36466530e-02f,
  1.29260018e-01f, -9.91662592e-02f, 9.25543159e-02f, -1.42070055e-01f, 4.04396653e-03f, 8.02713409e-02f, 2.27224007e-01f, 1.07437894e-01f, -1.26846626e-01f, 2.29845289e-02f,
  3.17017511e-02f, 1.93383358e-02f, -2.45092530e-02f, 5.63607030e-02f, 9.08178389e-02f, -2.80740913e-02f, 6.41081333e-02f, -1.21978506e-01f, -6.40095323e-02f, 2.89835725e-02f,
  -5.92757575e-03f, 4.11563367e-01f, -3.94518040e-02f, 4.97199111e-02f, 2.68969033e-02f, -4.34882790e-02f, 2.28152350e-02f, -7.22701997e-02f, 4.99464609e-02f, -6.63753524e-02f,
  4.03748378e-02f, -6.27854392e-02f, -6.06477186e-02f, 4.89765070e-02f, -9.19965133e-02f, -7.71995187e-02f, -1.78174734e-01f, -8.45015496e-02f, 2.89502759e-02f, -6.71968609e-02f,
  7.68652558e-02f, -6.12600446e-02f, 5.38821779e-02f, 5.05743688e-03f, 1.16232783e-01f, 1.30139753e-01f, -7.62476325e-02f, -1.90809090e-02f, 2.05668621e-02f, -7.84405321e-02f,
  5.52873947e-02f, 1.20916866e-01f, 4.36596312e-02f, 7.40969554e-02f, 1.28866369e-02f, -2.11235192e-02f, 2.58937944e-02f, 5.07150777e-03f, -3.30986120e-02f, 3.68114263e-02f,
  -9.01451632e-02f, 6.99307397e-02f, 2.12743476e-01f, -1.86694451e-02f, 1.56047478e-01f, -3.91780864e-03f, -9.83681157e-02f, -1.11570388e-01f, -1.30733818e-01f, 1.29142493e-01f,
  2.89448779e-02f, 6.16942607e-02f, -4.49386835e-02f, -1.05630018e-01f, -4.15996462e-02f, -3.58315967e-02f, 2.84417551e-02f, 1.52194500e-02f, 8.34562331e-02f, -7.94332027e-02f,
  2.45896857e-02f, 1.05339333e-01f, 7.78255910e-02f, -5.97278439e-02f, 1.42463401e-01f, -9.79421847e-03f, 7.11925048e-03f, -9.95708108e-02f, 4.28617969e-02f, -9.31447819e-02f,
  1.56782374e-01f, 9.75452065e-02f, 7.06703737e-02f, 9.75214019e-02f, 6.36238605e-02f, 3.43885779e-01f, 1.87602162e-01f, 2.02568635e-01f, 1.14966191e-01f, 2.13572174e-01f,
  2.20632002e-01f, -6.70707226e-02f, -1.10898666e-01f, -1.39216021e-01f, 2.59719104e-01f, -2.17821613e-01f, 1.55183315e-01f, -6.09414615e-02f, 7.11078122e-02f, 1.97938859e-01f,
  -1.20592155e-01f, 2.44542081e-02f, -2.14199588e-01f, -1.76257923e-01f, 1.69092596e-01f, -3.44589129e-02f, 9.85731035e-02f, -5.07358536e-02f, 9.33686420e-02f, 3.48976403e-02f,
  8.15555304e-02f, -8.21348354e-02f, 1.26904115e-01f, -1.46709755e-01f, -4.39318009e-02f, 1.32956833e-01f, 1.68321311e-01f, 3.36136110e-02f, -7.85842538e-02f, -5.02608940e-02f,
  2.87931636e-02f, -4.77979667e-02f, 5.33341616e-03f, 5.93365766e-02f, 1.39830053e-01f, -1.04089074e-01f, 7.48792291e-02f, 1.04941905e-01f, -4.45040315e-02f, -8.26260224e-02f,
  -1.03937101e-03f, -9.29780826e-02f, 1.30467862e-02f, -1.46056294e-01f, -2.10934430e-02f, 2.76029613e-02f, 1.26280561e-01f, -9.66506153e-02f, -9.28926915e-02f, -9.26742852e-02f,
  -7.52637759e-02f, 5.12781255e-02f, -7.84033351e-03f, -1.47563785e-01f, -5.11667915e-02f, -8.46150219e-02f, -1.32436186e-01f, -1.02955677e-01f, 5.48548587e-02f, -1.20872952e-01f,
  4.42026630e-02f, 3.48873921e-02f, -4.90687042e-02f, -3.25706601e-02f, 6.49880245e-02f, -1.06450068e-02f, 1.54887989e-01f, -1.94774624e-02f, -1.76775068e-01f, -4.65915632e-03f,
  4.05319817e-02f, 1.80506409e-04f, -8.23945478e-02f, 1.71137974e-02f, -9.18996707e-02f, -8.19934085e-02f, 1.20286040e-01f, 1.72923580e-01f, 2.04403251e-02f, -1.13413155e-01f,
  1.87404335e-01f, 5.84052093e-02f, 5.70908636e-02f, 3.24964635e-02f, -5.94188645e-02f, -5.91683798e-02f, 1.27644658e-01f, 4.22290862e-02f, -3.68217193e-02f, 9.95585173e-02f,
  -8.12515765e-02f, -5.94921559e-02f, -6.16830364e-02f, 4.44250740e-02f, 1.02455914e-01f, -7.81501308e-02f, -5.37087247e-02f, -5.03870659e-02f, 3.40240672e-02f, 1.59022294e-03f,
  -8.79492611e-02f, 1.52101070e-01f, -9.69303250e-02f, -9.31446534e-03f, -1.34499878e-01f, -7.52535686e-02f, 3.29002067e-02f, 1.00072198e-01f, -1.16192847e-01f, 8.18274990e-02f,
  -8.06868374e-02f, -1.30129442e-01f, 8.77964944e-02f, -8.36681351e-02f, 3.81257758e-02f, 1.90543495e-02f, -3.75259258e-02f, 9.55120921e-02f, 5.13404459e-02f, 3.56526137e-03f,
  6.93174917e-03f, 7.22525939e-02f, 4.11126725e-02f, 6.02274872e-02f, -4.46940325e-02f, 1.08182151e-02f, 2.25205324e-03f, 7.22523481e-02f, -1.63860485e-01f, -1.82143599e-02f,
  5.35167232e-02f, 5.92307486e-02f, -3.01501080e-02f, -6.63286969e-02f, -1.18136741e-01f, 5.90147674e-02f, 1.25613764e-01f, -3.57544869e-02f, -1.32355057e-02f, -5.04118167e-02f,
  -1.17712179e-02f, -4.22860645e-02f, -1.16597481e-01f, 1.16180830e-01f, 2.38308515e-02f, -2.03660894e-02f, 4.25907448e-02f, 2.76640505e-02f, -6.14026608e-03f, 5.02806269e-02f,
  -9.19250101e-02f, -3.64704691e-02f, 1.66273527e-02f, 4.86856401e-02f, 6.16255924e-02f, 1.69688687e-01f, 1.33915231e-01f, 9.64526236e-02f, -1.01446267e-03f, -7.63320029e-02f,
  -4.04422656e-02f, -6.74225241e-02f, -1.03153974e-01f, -6.35497347e-02f, 1.12420380e-01f, 1.48765985e-02f, -1.02922693e-01f, -8.77451431e-03f, -7.52609447e-02f, 3.77397798e-02f,
  1.44312069e-01f, 1.06061451e-01f, 1.07824624e-01f, -1.14687227e-01f, -2.83612683e-02f, 3.94514613e-02f, 1.73966885e-01f, -2.35143118e-02f, 4.81320312e-03f, 1.01696841e-01f,
  -5.65020703e-02f, -1.44034596e-02f, 3.14463563e-02f, 1.09663539e-01f, 1.12579301e-01f, 9.99850333e-02f, 1.13223851e-01f, -1.08642973e-01f, 9.06162933e-02f, 1.68028414e-01f,
  1.04293279e-01f, 7.00678909e-03f, -3.05174757e-02f, 7.13666435e-03f, 1.95918884e-02f, -1.37549475e-01f, 7.00769648e-02f, -5.79039492e-02f, 2.49974310e-01f, 1.90323830e-01f,
  2.74325788e-01f, 6.68748766e-02f, 5.54426461e-02f, -4.09376658e-02f, 1.58734009e-01f, 7.14102760e-03f, -5.35405725e-02f, 1.28853083e-01f, -7.75993764e-02f, 9.56114009e-02f,
  1.25225961e-01f, 8.17315578e-02f, 3.10136005e-02f, -9.00620073e-02f, -1.26601040e-01f, -5.91356903e-02f, 3.45066860e-02f, 5.32222539e-02f, 2.21410111e-01f, 2.67853469e-01f,
  1.51536122e-01f, -6.69315904e-02f, -1.08513772e-01f, 1.90011179e-03f, -1.48221673e-02f, 1.97267495e-02f, -5.94792934e-03f, 8.99867713e-02f, 4.06762213e-02f, -1.83309585e-01f,
  1.77019000e-01f, 1.95234552e-01f, 8.26036409e-02f, 1.10561825e-01f, -5.48038771e-03f, -7.34060677e-03f, 6.94956779e-02f, 5.21706715e-02f, -1.09160747e-02f, 1.52626589e-01f,
  3.82805541e-02f, -1.59315228e-01f, 8.09862744e-03f, -2.74962801e-02f, -5.42382104e-03f, 1.03819788e-01f, 1.15245534e-02f, -1.38987362e-01f, -7.93877542e-02f, -6.50308281e-02f,
  -1.01008199e-01f, 1.58261787e-02f, -1.02992341e-01f, -1.68758363e-01f, -2.50992482e-04f, -4.32975478e-02f, -9.75652710e-02f, 1.43772895e-02f, -2.96104234e-03f, -5.07340543e-02f,
  1.55455098e-01f, -1.27032802e-01f, 2.29676604e-01f, -1.56149074e-01f, -1.82777002e-01f, 1.57410994e-01f, -4.86371033e-02f, -6.59699515e-02f, 8.69477075e-03f, 4.20769230e-02f,
  4.28195596e-02f, 1.46489730e-02f, -4.13590053e-04f, 1.15456037e-01f, 5.06235193e-03f, -2.79604122e-02f, 5.41291498e-02f, 5.87710552e-02f, 1.13232709e-01f, -2.59919167e-02f,
  1.12925403e-01f, 1.61243901e-01f, 2.04784021e-01f, 7.84273073e-02f, 2.39836462e-02f, 7.39157125e-02f, 2.91096326e-02f, -7.37080052e-02f, 7.20451027e-02f, 3.55109930e-01f,
  1.14015535e-01f, 4.40932252e-02f, 1.03406377e-01f, -1.55380189e-01f, -1.12041660e-01f, -1.20616212e-01f, 1.51115686e-01f, -8.25648829e-02f, 1.97646469e-02f, -6.29079640e-02f,
  6.76442012e-02f, -1.22288942e-01f, 4.06608582e-02f, 5.91842784e-03f, -1.01538941e-01f, 2.03278065e-01f, 1.15812324e-01f, -1.03126138e-01f, -2.66371435e-03f, 1.29171059e-01f,
  8.52855295e-02f, 6.03324920e-02f, -5.71202934e-02f, -1.69256061e-01f, 6.62732646e-02f, 1.54790124e-02f, -5.68574527e-03f, -1.73633900e-02f, -1.56759396e-01f, 6.09015040e-02f,
  -1.94386840e-01f, 4.43324894e-02f, -1.35850459e-01f, -4.36003022e-02f, 2.13711351e-01f, -7.83723518e-02f, 7.07413107e-02f, -2.34819993e-01f, -1.91057459e-01f, 8.86063650e-02f,
  1.29170008e-02f, -4.89661284e-02f, -7.90792629e-02f, -1.52904108e-01f, -5.81431463e-02f, 1.19277552e-01f, 1.81222223e-02f, 5.21540754e-02f, -7.34559968e-02f, -2.39898451e-02f,
  -3.74303311e-02f, 2.30209995e-02f, -1.03449877e-02f, 1.48438469e-01f, 1.07436411e-01f, -7.12781921e-02f, 1.57652989e-01f, 1.11574531e-02f, -5.54637536e-02f, -1.82446670e-02f,
  1.16151266e-01f, -5.50616011e-02f, -1.00904159e-01f, 2.11195514e-01f, 2.77050763e-01f, -4.89224233e-02f, -7.85182044e-02f, -5.37414327e-02f, -3.24500985e-02f, 4.64826934e-02f,
  -9.07622576e-02f, -5.02445959e-02f, 2.48162657e-01f, 9.64388400e-02f, -4.47420822e-03f, -5.68756536e-02f, 5.10867126e-02f, -2.15699524e-02f, -8.10415894e-02f, 3.08388412e-01f,
  4.86922674e-02f, -4.10799757e-02f, -8.89250934e-02f, 5.22288866e-02f, -6.70671538e-02f, 1.54519333e-02f, 9.90367979e-02f, -3.57998721e-02f, 9.50430632e-02f, -4.93417121e-02f,
  3.59225199e-02f, 1.11602411e-01f, 1.53874695e-01f, 1.46661744e-01f, 3.88918109e-02f, 3.03014554e-02f, 2.28024751e-01f, 2.69913316e-01f, -2.78092682e-01f, 1.72619745e-01f,
  -1.55208051e-01f, 1.27340183e-01f, 1.54233545e-01f, 2.27744114e-02f, 6.98197260e-02f, 1.32359222e-01f, 2.03845501e-01f, 1.78119704e-01f, -5.45373857e-02f, 1.85898945e-01f,
  1.32373840e-01f, 4.30605039e-02f, -1.31305903e-01f, 1.54607967e-02f, -1.47506565e-01f, 1.13546193e-01f, 1.79660898e-02f, -4.27984446e-02f, -1.25450671e-01f, 7.92442486e-02f,
  -1.47266284e-01f, 2.28204519e-01f, 4.16702740e-02f, 1.58514470e-01f, 8.47759992e-02f, -4.09855358e-02f, -3.60796005e-02f, -7.63368085e-02f, -4.27278802e-02f, 5.38520664e-02f,
  3.87146138e-02f, -1.04484722e-01f, 6.70138821e-02f, 2.05103248e-01f, 2.29606964e-02f, 1.21331420e-02f, -1.39961347e-01f, -1.19795725e-02f, 1.18942507e-01f, 4.11848500e-02f,
  6.11287504e-02f, 1.14164948e-01f, 1.97171614e-01f, -9.17882323e-02f, -7.83786029e-02f, 6.44251034e-02f, -2.58866940e-02f, 3.18972915e-01f, 1.08134724e-01f, 9.58642289e-02f,
  7.39727393e-02f, -1.41740710e-01f, -4.17069681e-02f, -1.15652680e-02f, -8.51254016e-02f, -7.78626353e-02f, 9.68715772e-02f, -2.91114654e-02f, 7.17644319e-02f, 1.51698261e-01f,
  -8.39371905e-02f, 1.27410486e-01f, 2.42335368e-02f, -1.66986376e-01f, 2.48696089e-01f, 1.79848731e-01f, 1.05455235e-01f, 1.49053827e-01f, -1.02286950e-01f, 3.59385014e-02f,
  -1.14525342e-02f, -3.80961299e-02f, 4.02525850e-02f, 1.89997703e-01f, 1.23367952e-02f, -1.24465659e-01f, -5.95076233e-02f, -7.19992518e-02f, -9.69897658e-02f, -1.03428133e-01f,
  -1.00789182e-01f, 2.49146223e-02f, 1.58407822e-01f, 8.37749429e-03f, 1.73442647e-01f, 6.54125437e-02f, 6.34931996e-02f, 9.01054591e-02f, -1.12734735e-01f, -3.86867039e-02f,
  -1.02587506e-01f, 1.14939921e-01f, -3.12395524e-02f, 5.12977727e-02f, -9.61031485e-03f, -1.50414512e-01f, 2.62066931e-01f, 7.06073865e-02f, 1.11944139e-01f, 1.53571457e-01f,
  1.01168483e-01f, -2.98497938e-02f, -1.24817282e-01f, 2.25151554e-02f, 7.57942423e-02f, 8.56285840e-02f, 2.95276139e-02f, 1.20955715e-02f, 7.10480660e-02f, -9.28025693e-02f,
  3.97556052e-02f, 3.01788840e-03f, 8.60290676e-02f, 9.62773338e-02f, -6.01371937e-02f, -4.75856289e-02f, 6.11810870e-02f, -6.38934150e-02f, 8.97524040e-03f, -1.41718909e-01f,
  -4.26467992e-02f, -1.24003083e-01f, 5.74302077e-02f, -1.22290954e-03f, 2.40848418e-02f, 7.89072737e-02f, 8.81738961e-02f, 4.01589908e-02f, -7.42471814e-02f, -2.65157431e-01f,
  -7.50477239e-02f, 1.23889759e-01f, -9.14820805e-02f, 3.43821431e-03f, -1.00470789e-01f, 6.99982122e-02f, -1.54151037e-01f, -8.07042327e-03f, 1.26780281e-02f, -7.35707879e-02f,
  1.46350637e-01f, 1.09186232e-01f, -8.09795856e-02f, 9.32495594e-02f, -1.38965711e-01f, 1.10845290e-01f, 1.08884007e-01f, 5.63969612e-02f, 2.24128515e-01f, -1.47441790e-01f,
  -6.79303333e-02f, 1.15686869e-02f, 4.28250059e-03f, -2.62460019e-02f, 1.10210717e-01f, 2.15447426e-01f, 2.04746798e-01f, 1.30020052e-01f, -3.12662534e-02f, -7.51214325e-02f,
  1.22612648e-01f, -1.17251649e-02f, 5.42163588e-02f, -1.48559827e-02f, 2.27706656e-02f, -5.74801415e-02f, 7.42343962e-02f, -1.20989002e-01f, 4.00572270e-02f, 8.99226740e-02f,
  3.53092887e-02f, 3.02471310e-01f, -6.95877597e-02f, -2.26588510e-02f, -7.03396425e-02f, -1.34842831e-03f, 6.15332648e-02f, -3.05202790e-03f, 2.13268250e-01f, 1.07818328e-01f,
  -4.69341166e-02f, 1.28245518e-01f, 8.51372033e-02f, -6.99429214e-02f, 1.49646044e-01f, -2.50362307e-02f, -1.51246354e-01f, 1.88929945e-01f, 1.47768363e-01f, -7.60833248e-02f,
  1.03140377e-01f, -1.67412728e-01f, 1.46379501e-01f, 4.52471934e-02f, -2.02314645e-01f, -8.05362314e-02f, -9.87935215e-02f, -1.48521557e-01f, -2.38230243e-01f, -1.41837997e-02f,
  9.53662023e-02f, 6.76697344e-02f, 2.52944957e-02f, -1.50390655e-01f, 6.14727065e-02f, -4.40183580e-02f, 1.47349119e-01f, -1.25954360e-01f, -1.99067611e-02f, 1.39769346e-01f,
  -2.22132690e-02f, 1.63149074e-01f, 2.40261648e-02f, 8.45408514e-02f, -6.84286281e-02f, -1.24275297e-01f, -6.17875941e-02f, 4.15533260e-02f, -5.15657216e-02f, 3.91601324e-01f,
  -6.26114979e-02f, -9.12836790e-02f, 1.09904870e-01f, 2.26097986e-01f, 7.06089055e-03f, -1.43806532e-01f, -2.81729717e-02f, -1.23385087e-01f, 2.34308327e-03f, -1.56847000e-01f,
  1.56785790e-02f, -2.93165725e-02f, -7.13471100e-02f, -4.32856530e-02f, 4.58613634e-02f, 4.49814722e-02f, 5.11098187e-03f, -8.07105154e-02f, -1.33326203e-01f, 6.23286739e-02f,
  7.53526017e-02f, 7.15864748e-02f, 1.00340001e-01f, 1.78760774e-02f, -4.84651439e-02f, 7.88090751e-02f, -6.68830499e-02f, 8.81165490e-02f, 1.22849412e-01f, 5.27091473e-02f,
  6.16828585e-03f, 1.80716142e-01f, 1.72664389e-01f, 2.50130915e-03f, -4.94997986e-02f, 5.21832285e-03f, 7.40454048e-02f, 2.15431601e-01f, -1.18645400e-01f, 8.23595747e-02f,
  4.98091951e-02f, -1.30343474e-02f, -1.57379746e-01f, 3.92432809e-02f, -5.62335290e-02f, 3.75994742e-02f, 8.18506777e-02f, 5.14151417e-02f, -3.40546407e-02f, -1.15928873e-01f,
  5.05496375e-02f, -1.38671979e-01f, 9.11276937e-02f, -2.93316562e-02f, 1.21834971e-01f, 2.44198311e-02f, 1.34571241e-02f, -1.16712451e-01f, -4.33753058e-03f, -9.53120738e-02f,
  3.56114469e-02f, 5.47006391e-02f, 1.12621434e-01f, 3.41045648e-01f, -4.96477336e-02f, 8.49482697e-03f, -1.11763952e-02f, -3.21431085e-02f, 2.40731254e-01f, 6.65841326e-02f,
  1.09471679e-01f, -8.31235573e-02f, -6.11098185e-02f, 5.70187047e-02f, -5.47181964e-02f, -7.82497823e-02f, -7.95902386e-02f, 1.11052729e-01f, -7.46980458e-02f, 2.14777663e-01f,
  2.24637147e-02f, 8.63441601e-02f, 7.98746664e-03f, -4.47843783e-02f, -8.03332031e-02f, 1.20950088e-01f, -7.64082596e-02f, -7.99244866e-02f, -8.52719545e-02f, -3.51926312e-02f,
  -3.50010283e-02f, -9.92030650e-03f, 7.65784606e-02f, 6.17495552e-02f, -7.76344836e-02f, 4.68444824e-02f, -2.84190625e-02f, -5.99714257e-02f, -1.54688880e-01f, 1.96189106e-01f,
  -1.21144578e-01f, 1.18899278e-01f, -1.01370458e-02f, -1.10787749e-02f, 7.81377852e-02f, 6.05575591e-02f, 1.60121292e-01f, 8.27881768e-02f, 1.15036637e-01f, 1.50763318e-01f,
  1.36027187e-01f, 1.15393586e-01f, -9.35473293e-02f, -8.52995589e-02f, -6.96326569e-02f, 1.01724498e-01f, -7.21523911e-02f, 1.54832616e-01f, 9.02397186e-03f, -5.24122715e-02f,
  -1.84906386e-02f, 7.36289173e-02f, 5.71975261e-02f, 2.90447529e-02f, 7.01371208e-02f, 3.22196493e-03f, -3.95384058e-02f, 5.33722900e-02f, -1.49432058e-02f, 9.02891308e-02f,
  1.10997409e-01f, 1.17307954e-01f, 8.05281028e-02f, -3.56461182e-02f, -1.07777163e-01f, -1.20794781e-01f, 1.58884134e-02f, 9.05936509e-02f, -1.04905508e-01f, -1.09247193e-01f,
  6.88139126e-02f, -1.22074068e-01f, 2.03066498e-01f, -1.18564405e-01f, 9.24546719e-02f, 9.87291485e-02f, -3.60650048e-02f, 1.45492688e-01f, -6.75935522e-02f, -2.85155214e-02f,
  1.75300255e-01f, 1.54676661e-01f, 8.14614818e-02f, -7.42779523e-02f, -6.54919818e-02f, 6.80913478e-02f, 8.30500294e-03f, -3.52805890e-02f, 4.88446392e-02f, 1.12362832e-01f,
  1.31903142e-01f, 6.77427128e-02f, -5.12585118e-02f, 1.35966480e-01f, -1.37551799e-01f, 2.42692158e-01f, 6.27570320e-03f, -1.18478216e-01f, -4.65396009e-02f, 1.06790774e-01f,
  9.94413067e-03f, 2.67419249e-01f, -2.02318840e-02f, 8.44789390e-03f, 6.93860501e-02f, -1.06998608e-01f, -1.22073539e-01f, 2.26708520e-02f, 1.11753426e-01f, 8.17916989e-02f,
  5.30139962e-03f, -1.04447365e-01f, 3.71750519e-02f, 1.56153306e-01f, -1.40590340e-01f, -5.44172749e-02f, -1.30860582e-01f, 1.26382649e-01f, 8.67152885e-02f, -5.60056418e-02f,
  -4.44850065e-02f, -8.55627507e-02f, -8.61753076e-02f, 2.39657667e-02f, -8.96289712e-04f, 1.61685526e-01f, 1.18746497e-01f, -7.26681426e-02f, 4.15872969e-02f, -1.42382070e-01f,
  -4.73671295e-02f, 4.20930050e-02f, 9.55124944e-02f, -4.52263430e-02f, 1.36536464e-01f, 1.27872974e-01f, 2.36173481e-01f, -3.03087067e-02f, -4.20429967e-02f, -1.34169489e-01f,
  5.05313873e-02f, -7.84276146e-03f, 2.52937496e-01f, 5.54729663e-02f, 4.43860404e-02f, 9.83463749e-02f, 8.31764638e-02f, -2.07849368e-01f, -9.23347250e-02f, 1.37488917e-01f,
  -9.90813598e-02f, 2.07719117e-01f, 1.94235537e-02f, 7.11296350e-02f, -1.69606879e-01f, 8.82823691e-02f, 2.05945849e-01f, -1.09729037e-01f, -9.37632620e-02f, 4.44723628e-02f,
  2.61757709e-02f, -4.87017035e-02f, 2.19230335e-02f, -9.77532491e-02f, -7.98275545e-02f, -4.05151434e-02f, 1.24527924e-01f, 2.37413831e-02f, -3.30100320e-02f, -4.90235314e-02f,
  -5.41416518e-02f, -2.57912707e-02f, -1.11752458e-01f, -8.14489648e-03f, -7.56716356e-02f, 8.36618245e-02f, 4.25929762e-02f, -1.00502089e-01f, -1.07923694e-01f, 3.16165201e-02f,
  1.37387156e-01f, -8.53995681e-02f, -7.64338523e-02f, -5.91199920e-02f, -1.00891314e-01f, -6.12221509e-02f, 9.13558826e-02f, -1.24742366e-01f, 1.40178353e-01f, -2.92534437e-02f,
  2.93580890e-01f, 1.26630798e-01f, -1.40314624e-01f, 9.25278366e-02f, 2.20155925e-01f, 1.86003655e-01f, -1.36682734e-01f, 7.29934797e-02f, -6.05743658e-03f, -3.14201228e-02f,
  3.83513719e-01f, 4.34750244e-02f, -1.10876523e-01f, 3.06991581e-02f, 1.05323657e-01f, 8.70948657e-04f, 9.33684334e-02f, 1.28398657e-01f, 1.52084261e-01f, 1.36624292e-01f,
  1.07987463e-01f, 1.00547537e-01f, 1.91239491e-01f, 4.38289866e-02f, 4.63247113e-03f, 1.17805965e-01f, -5.18904552e-02f, 2.24515170e-01f, 2.16464117e-01f, 2.35273167e-01f,
  -1.95997387e-01f, 7.03433529e-02f, 1.58854470e-01f, 2.64869094e-01f, 1.27306864e-01f, -7.76193291e-02f, 2.90969256e-02f, 1.06172068e-02f, 2.43797496e-01f, -1.80032417e-01f,
  -1.58685997e-01f, 1.35208294e-01f, 8.62468034e-02f, -1.35256752e-01f, 1.17927231e-01f, 1.73809398e-02f, 3.07139866e-02f, -2.54795533e-02f, 5.01875356e-02f, -1.93467766e-01f,
  -9.91979800e-03f, -1.18873447e-01f, 4.34249677e-02f, -7.25654885e-02f, 1.93459719e-01f, 3.86048481e-02f, 5.24265580e-02f, 1.88235310e-03f, 2.68357068e-01f, 3.63482721e-02f,
  -1.33418828e-01f, 4.26275015e-01f, -1.65292919e-01f, 1.79426476e-01f, -1.06999383e-03f, 3.11360627e-01f, 1.11303039e-01f, 2.60086507e-01f, 2.73489896e-02f, -3.13518420e-02f,
  1.22469231e-01f, -3.95276882e-02f, -1.34962786e-03f, 8.97917373e-04f, -2.01147363e-01f, 4.12011862e-01f, -6.79061711e-02f, 9.44860652e-02f, 1.50397614e-01f, 1.96322203e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 40)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 40;
const float L2_fan_Bp_bar_data[] = {
  3.26200086e-03f, -4.06529158e-02f, -9.15107429e-02f, 1.51604041e-01f, 1.25223681e-01f, -5.95360138e-02f, -6.02620691e-02f, -1.54267587e-02f, 2.78149754e-01f, -1.10084884e-01f,
  -7.09089711e-02f, 1.47871122e-01f, 4.43934202e-02f, -8.68435763e-03f, 6.90035447e-02f, 5.79829477e-02f, 8.97575449e-03f, 7.79310018e-02f, 1.42519161e-01f, -4.90162782e-02f,
  8.26969370e-02f, 1.37803137e-01f, 1.13526613e-01f, 4.00946848e-02f, 4.88810800e-02f, 5.98576963e-02f, 6.95811911e-03f, -7.79233649e-02f, 1.64898410e-01f, 1.31650195e-01f,
  1.52924329e-01f, -1.47078363e-02f, -4.51086983e-02f, -2.62314342e-02f, 7.68773854e-02f, 6.44618347e-02f, 7.18520507e-02f, -5.53682121e-03f, 8.17629248e-02f, 1.11358449e-01f
};

// L3_linear_W (Shape: 12 x 64)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 64;
const float L3_linear_W_data[] = {
  -1.51870191e-01f, -1.12682797e-01f, -9.57035199e-02f, -1.03208423e-01f, -3.19150597e-01f, -3.11264008e-01f, -1.40995696e-01f, -3.48152667e-01f, -1.96495965e-01f, -1.91763848e-01f,
  -2.80094057e-01f, -7.47449771e-02f, -9.78726596e-02f, 6.88140243e-02f, 7.40346313e-02f, 2.96515506e-02f, 4.54168431e-02f, -2.43898109e-01f, -1.42317101e-01f, -7.27373660e-02f,
  -2.51528502e-01f, 4.27379876e-01f, -6.20598793e-02f, 1.15091927e-01f, 3.13485801e-01f, 2.56704036e-02f, 4.56756681e-01f, -1.94083750e-02f, -1.87416196e-01f, -5.07866554e-02f,
  2.67818183e-01f, -9.03713051e-03f, -2.89675117e-01f, -3.75167690e-02f, 1.02580905e-01f, -4.20077443e-02f, 5.84312938e-02f, -1.06140211e-01f, 1.24502361e-01f, 4.16262262e-02f,
  -1.72631413e-01f, 1.65503114e-01f, -2.70246416e-01f, 3.89011912e-02f, 6.55744970e-02f, -1.84381545e-01f, -4.34259791e-03f, 3.31513822e-01f, 2.01529622e-01f, -1.72023222e-01f,
  3.33440192e-02f, -5.25407828e-02f, -1.51702361e-02f, 4.58158135e-01f, 4.40626472e-01f, -2.36208830e-02f, 8.03964213e-02f, 3.83228242e-01f, 5.23680449e-02f, 9.54593271e-02f,
  -1.22127771e-01f, 4.14105542e-02f, -1.79321051e-01f, -2.37420142e-01f, -2.75080979e-01f, 2.61390209e-01f, 1.23467609e-01f, 1.91975340e-01f, 2.60439157e-01f, 3.25675994e-01f,
  5.00982553e-02f, 2.17386439e-01f, 2.38430396e-01f, 4.60404575e-01f, -1.67249516e-01f, 2.06666917e-01f, -3.77656221e-01f, -2.39696816e-01f, -3.18696052e-01f, 4.86561917e-02f,
  -6.12754107e-01f, -9.61352736e-02f, 1.93612240e-02f, 3.35301548e-01f, 2.78172970e-01f, 5.98607421e-01f, 3.33413571e-01f, -2.18418106e-01f, 4.68412966e-01f, 6.77843988e-02f,
  2.21708760e-01f, 1.53479606e-01f, 2.61696249e-01f, 1.70995906e-01f, 1.18967280e-01f, -8.83871391e-02f, -3.85831147e-02f, -6.26389608e-02f, -1.97533444e-01f, 3.60242188e-01f,
  -4.30826277e-01f, 3.69700789e-01f, 2.56255716e-01f, -1.83992550e-01f, -2.84615844e-01f, -3.71299358e-03f, -4.08406675e-01f, 1.92021072e-01f, -1.00347333e-01f, -6.28172308e-02f,
  -1.04292519e-01f, 4.48772699e-01f, -8.90844092e-02f, -8.83266255e-02f, 4.28234041e-02f, 4.46307510e-02f, -2.84043252e-01f, -6.00247085e-02f, 2.74828523e-01f, 1.64619625e-01f,
  -3.41716915e-01f, 1.63347840e-01f, -3.68917674e-01f, -3.64325821e-01f, 2.16031522e-01f, -2.28388771e-01f, 2.07508683e-01f, -2.23232746e-01f, 2.46957317e-01f, -1.63309932e-01f,
  -1.41147316e-01f, 2.74018228e-01f, 2.07449332e-01f, -8.51929560e-03f, 3.54987711e-01f, -2.01931715e-01f, 2.82047033e-01f, -3.47879678e-02f, 3.81072402e-01f, 1.82603654e-02f,
  -4.68098074e-02f, -4.29531574e-01f, -2.41647810e-01f, 5.37891746e-01f, 2.97094762e-01f, -5.58725536e-01f, -7.15494931e-01f, -1.57408863e-01f, -2.06400659e-02f, -2.30818287e-01f,
  9.49206129e-02f, 3.18135440e-01f, 9.37375277e-02f, -1.48494855e-01f, -3.85026820e-02f, -2.76825111e-02f, 1.54450595e-01f, -9.07985792e-02f, -1.80410638e-01f, 1.46118149e-01f,
  1.08974211e-01f, -1.08530000e-01f, 7.57460445e-02f, 5.48551917e-01f, -2.72048920e-01f, -1.81513861e-01f, -4.14320499e-01f, 9.10081267e-02f, -5.20748645e-02f, 5.15077412e-01f,
  3.33498940e-02f, -1.83116436e-01f, -1.39076248e-01f, -2.13576749e-01f, -2.34508328e-03f, 2.18615681e-01f, -1.40671179e-01f, 1.23157553e-01f, -1.23896740e-01f, -8.61425176e-02f,
  -2.35879034e-01f, -2.06926867e-01f, 6.35937005e-02f, -2.31688693e-01f, -4.28183489e-02f, -4.05128710e-02f, 1.29383519e-01f, 1.25199944e-01f, -2.14575976e-01f, -1.29539102e-01f,
  2.28721440e-01f, -2.81850901e-02f, -2.84607053e-01f, -1.47903383e-01f, -4.56874184e-02f, -2.51235664e-01f, 2.57748246e-01f, -1.06778170e-03f, -2.36939579e-01f, 1.23136332e-02f,
  -6.02951795e-02f, 1.39786899e-01f, 1.16031185e-01f, -4.15955871e-01f, 5.74000180e-01f, 2.51430064e-01f, 9.59845707e-02f, 4.80274819e-02f, -3.30731869e-01f, 1.21758416e-01f,
  -2.23380893e-01f, 1.68114826e-01f, -1.31990537e-01f, 6.57706559e-02f, 2.17164725e-01f, 2.52170503e-01f, -9.04602110e-02f, 1.63074285e-01f, -3.67270678e-01f, 1.34836301e-01f,
  1.27936855e-01f, 9.93102640e-02f, 4.21278439e-02f, 2.40369961e-01f, -3.08404148e-01f, -7.66043961e-02f, -5.36006130e-02f, -5.02881408e-02f, 5.12893856e-01f, -8.45191106e-02f,
  1.04655623e-01f, -1.59594893e-01f, 8.04986209e-02f, 1.69697016e-01f, -5.19669764e-02f, -2.39381015e-01f, 1.92070737e-01f, 5.21279983e-02f, -8.28126669e-02f, 1.03220185e-02f,
  -8.30665529e-02f, -1.95531130e-01f, 7.64763132e-02f, -6.63521141e-02f, 5.09531684e-02f, 1.02203667e-01f, 1.26623347e-01f, -9.51993316e-02f, 4.07788664e-01f, 2.36895218e-01f,
  8.15600231e-02f, 3.11314911e-01f, 5.38113527e-02f, -6.00235537e-02f, -4.96472977e-02f, 9.12054852e-02f, 2.26350009e-01f, 1.23629980e-01f, -1.07971869e-01f, -2.60368049e-01f,
  -1.73678219e-01f, -2.75087208e-01f, -4.63050425e-01f, -3.75195444e-02f, 1.83326349e-01f, 1.34577051e-01f, -3.10825348e-01f, 1.19416222e-01f, 2.39028618e-01f, -4.90408670e-03f,
  -1.96657658e-01f, 1.21625006e-01f, -4.42284137e-01f, -2.62284726e-01f, -1.43829823e-01f, 2.89046943e-01f, -2.19400555e-01f, 8.03036913e-02f, 3.23969632e-01f, 7.12686181e-02f,
  -3.13401312e-01f, -1.12991117e-01f, 3.77844870e-02f, -2.08115429e-01f, -2.72737741e-01f, -1.13870926e-01f, 3.53448987e-02f, -1.89495236e-01f, 1.84226796e-01f, 2.82348059e-02f,
  1.42626211e-01f, 3.44006687e-01f, 2.63513744e-01f, 1.11515878e-03f, -1.73597515e-01f, 3.27976972e-01f, -2.52300352e-02f, -2.74936818e-02f, 4.83276546e-01f, -9.02145505e-02f,
  -9.89220142e-02f, -1.34080157e-01f, 2.57552769e-02f, -2.37439051e-01f, 7.78778568e-02f, 4.12124991e-01f, 2.20319983e-02f, 1.14256844e-01f, -7.45357201e-02f, 2.67505199e-01f,
  9.03092325e-02f, -1.34555876e-01f, 4.49404679e-03f, -1.90123156e-01f, 4.38749194e-01f, 1.01585612e-01f, 1.17101245e-01f, 3.06650046e-02f, -1.11542575e-01f, -1.73593283e-01f,
  -2.84014970e-01f, 1.28949821e-01f, 1.04478247e-01f, -1.43340692e-01f, 3.06367368e-01f, 2.46182293e-01f, -2.50551462e-01f, 1.41069219e-01f, -3.17598507e-02f, -1.41305164e-01f,
  6.30226210e-02f, 5.06106578e-02f, -2.28051290e-01f, 1.92122180e-02f, -1.42453030e-01f, 1.43061489e-01f, 8.74902606e-02f, 1.82717502e-01f, -9.25626606e-02f, -1.73284650e-01f,
  -5.90676405e-02f, -3.57158303e-01f, -2.64369547e-01f, 2.79905409e-01f, 3.39066684e-01f, -1.14451393e-01f, -1.17422424e-01f, 3.03839128e-02f, 2.43345931e-01f, -1.33933753e-01f,
  5.57858236e-02f, -1.84300393e-01f, -1.45838648e-01f, 5.63304499e-02f, -7.13338405e-02f, 4.12531078e-01f, -1.44076377e-01f, 1.55902833e-01f, 1.91981643e-01f, -1.42794326e-01f,
  -2.94221714e-02f, 2.03265369e-01f, 2.09491760e-01f, 1.07310109e-01f, -1.70550749e-01f, 1.16449155e-01f, -3.13065276e-02f, 2.01615527e-01f, -8.24334100e-02f, 7.94165879e-02f,
  -6.66515231e-02f, -4.28658270e-04f, -1.45320341e-01f, -6.33095801e-02f, -9.08383802e-02f, -9.67695266e-02f, -7.45836869e-02f, 7.14887604e-02f, -9.91747305e-02f, 4.31240648e-02f,
  -1.14232592e-01f, -7.11864755e-02f, -2.63080597e-01f, 4.74992633e-01f, 7.19738379e-02f, -2.09123775e-01f, 2.51519680e-01f, -3.03367347e-01f, -4.72209424e-01f, 3.39477390e-01f,
  -1.09009728e-01f, -8.16625953e-02f, -2.47571290e-01f, -3.27482581e-01f, -7.82401487e-02f, 2.06971057e-02f, -9.53560024e-02f, -2.20560476e-01f, 4.17691976e-01f, -2.07888693e-01f,
  -3.77473123e-02f, -2.27520898e-01f, 3.43993813e-01f, -2.54557371e-01f, 2.57435739e-01f, -1.89049870e-01f, -2.03975052e-01f, -1.29875824e-01f, -2.68031776e-01f, 3.18988264e-01f,
  -3.11400518e-02f, 2.30756491e-01f, -2.89047390e-01f, -1.25014797e-01f, -1.79692507e-01f, -5.77287655e-03f, 6.20436609e-01f, 8.44387040e-02f, 8.79115537e-02f, -1.55177221e-01f,
  -3.85300338e-01f, -8.91765878e-02f, -2.28747144e-01f, -8.92928764e-02f, 8.38484168e-02f, -2.66366661e-01f, -4.04522985e-01f, 2.39502534e-01f, -1.58512369e-02f, 3.91432822e-01f,
  4.87537161e-02f, -1.57422841e-01f, -7.37288296e-02f, -2.83097327e-01f, 2.63343334e-01f, 5.44109568e-03f, -1.70267910e-01f, -1.45445675e-01f, -2.33902171e-01f, 2.43490994e-01f,
  -1.30032644e-01f, -1.52232885e-01f, -1.19102597e-01f, -6.11607581e-02f, 2.39866108e-01f, 3.43279928e-01f, -1.36935413e-01f, -1.35276690e-01f, 1.80326149e-01f, -1.16743119e-02f,
  -5.13591897e-03f, 8.12718570e-02f, -1.19858645e-01f, -5.20994067e-02f, 6.72569573e-02f, -3.79181243e-02f, 8.21530819e-02f, 2.52499461e-01f, -2.79948562e-01f, 1.89590082e-02f,
  2.82011688e-01f, -3.05088639e-01f, -1.58150598e-01f, -9.27084833e-02f, 3.52421999e-01f, 3.22332650e-01f, 4.42154646e-01f, -2.33667150e-01f, -4.05550063e-01f, 4.67333734e-01f,
  -1.05175972e-01f, 6.72032386e-02f, -2.39574701e-01f, 3.99710350e-02f, 1.04373358e-02f, 4.49403338e-02f, -1.34758623e-02f, -1.07551336e-01f, -4.53894101e-02f, 2.81837106e-01f,
  -2.15093404e-01f, 1.07133336e-01f, 5.33184484e-02f, -4.71737206e-01f, -2.16046651e-03f, -1.86398819e-01f, -2.50043124e-01f, -1.51923791e-01f, 2.75646478e-01f, -2.19058007e-01f,
  -3.55577260e-01f, 1.13994561e-01f, 2.00302467e-01f, 5.00767864e-02f, -5.58248647e-02f, -1.33019328e-01f, 1.14543304e-01f, -2.60059595e-01f, -1.43510461e-01f, 2.04607651e-01f,
  3.65482628e-01f, -1.25363674e-02f, -9.74656492e-02f, 4.47916418e-01f, 2.22095355e-01f, -2.08596617e-01f, -1.49566084e-01f, -1.61600523e-02f, 1.52726173e-01f, 2.10647598e-01f,
  4.16946262e-01f, -1.14944838e-01f, 7.51021653e-02f, 1.21125624e-01f, 7.90081769e-02f, 2.31234819e-01f, -5.47717847e-02f, -2.23749399e-01f, 2.97985762e-01f, -1.25030696e-03f,
  1.24802202e-01f, -1.73068374e-01f, -2.74706930e-01f, 8.16880539e-03f, -2.70783216e-01f, 2.65639633e-01f, 4.03911173e-01f, -1.09074675e-01f, 4.80442077e-01f, 2.12318689e-01f,
  -3.19380701e-01f, -3.93312782e-01f, 1.54339239e-01f, -2.74669468e-01f, -1.78968966e-01f, -2.53055662e-01f, -1.27781928e-01f, -3.05529892e-01f, 1.21582061e-01f, -2.47953068e-02f,
  1.97311249e-02f, 7.09637403e-02f, 7.23476186e-02f, -1.41733468e-01f, -4.07262743e-01f, -2.24736929e-02f, -2.57221493e-03f, -5.51512837e-01f, -1.73835531e-01f, 9.82343480e-02f,
  3.53810042e-01f, -7.38961995e-02f, 4.00333941e-01f, 8.31144955e-03f, 1.91673322e-03f, -1.77305207e-01f, -6.69002384e-02f, -2.38633245e-01f, 4.12315689e-03f, -1.09334342e-01f,
  -5.15434816e-02f, -2.56752670e-01f, -2.03492329e-01f, 7.67299011e-02f, 2.43159071e-01f, -1.25891402e-01f, -2.35151023e-01f, 1.04926303e-01f, 1.36559131e-03f, -2.31597930e-01f,
  -1.54228449e-01f, 1.76820476e-02f, -1.60875712e-02f, 1.91706121e-02f, -1.26396284e-01f, 6.23176515e-01f, 2.23416522e-01f, -1.44710660e-01f, 2.80063629e-01f, 5.73230147e-01f,
  6.49598464e-02f, -1.07350573e-01f, 4.48726624e-01f, 4.38960455e-02f, 1.15824282e-01f, -1.50293380e-01f, 1.32780552e-01f, 2.13040084e-01f, 2.03487962e-01f, -1.67723507e-01f,
  -3.91028196e-01f, -6.67832196e-02f, 4.27140951e-01f, -3.74588549e-01f, 4.19943839e-01f, -9.62424427e-02f, 3.95119041e-01f, -8.20745155e-02f, -1.21471256e-01f, -1.05029732e-01f,
  -2.71351874e-01f, 3.56003672e-01f, -5.21919541e-02f, -9.71967280e-02f, -1.32657304e-01f, -1.43967271e-01f, -1.42859995e-01f, 1.66334629e-01f, 6.50588334e-01f, -1.11767404e-01f,
  9.52264443e-02f, 3.95407379e-01f, 1.58493035e-02f, -2.20788598e-01f, -3.00348252e-01f, 1.04850698e-02f, -1.90586016e-01f, -1.39151469e-01f, 9.13226530e-02f, 5.16231731e-03f,
  -1.04247138e-01f, -6.08089268e-02f, 1.24431118e-01f, -1.28343984e-01f, -1.39644295e-01f, -7.55645037e-02f, -1.23333082e-01f, -1.03778422e-01f, -2.48869397e-02f, -1.97032630e-01f,
  -2.89983064e-01f, -2.20447645e-01f, -1.06343091e-01f, -1.13974929e-01f, 3.15685093e-01f, 1.42382503e-01f, 2.07222626e-02f, 2.65294582e-01f, 1.00187041e-01f, -5.29974163e-01f,
  2.21482441e-01f, -9.37881544e-02f, 3.23893815e-01f, -1.74453676e-01f, 3.46620142e-01f, 3.24035734e-01f, -3.22945714e-01f, 1.62976399e-01f, -1.18822947e-01f, 1.60257936e-01f,
  3.30680370e-01f, 2.84777164e-01f, -6.31710589e-02f, 2.35607520e-01f, 4.80712540e-02f, 5.13441801e-01f, -6.71034575e-01f, 1.89543709e-01f, -2.99273640e-01f, -5.08378893e-02f,
  -5.22421062e-01f, 1.16086537e-02f, 1.70953259e-01f, -1.65136203e-01f, 4.78159823e-02f, -1.47844240e-01f, -2.37005651e-01f, -7.43351057e-02f, -6.08944818e-02f, 3.63282673e-02f,
  1.10486120e-01f, -1.85475275e-01f, -5.06810665e-01f, -1.00143723e-01f, 7.52409175e-02f, -2.21530810e-01f, 3.45826417e-01f, 1.93936855e-01f, 5.32801509e-01f, 1.47602528e-01f,
  1.29018351e-01f, -2.86857903e-01f, 1.16651401e-01f, -2.14131609e-01f, 3.09794694e-01f, -9.50663537e-02f, -2.11382821e-01f, -9.21145007e-02f, 3.23813334e-02f, 4.15642709e-01f,
  -1.19710058e-01f, -2.52248533e-02f, 2.69247800e-01f, -1.41032860e-01f, -8.94128457e-02f, -2.27766663e-01f, 8.51680338e-02f, -1.98810130e-01f, -1.93504453e-01f, -2.17263505e-01f,
  -2.12681681e-01f, -8.92670155e-02f, 1.20433010e-01f, -2.63075113e-01f, -1.55867815e-01f, 2.54185289e-01f, -2.58055240e-01f, -9.95184109e-02f, -3.10474247e-01f, -3.55773062e-01f,
  3.04860443e-01f, 3.39862198e-01f, -2.92482823e-01f, 7.39956126e-02f, 2.12732568e-01f, -9.28979963e-02f, -3.75455678e-01f, 2.21766114e-01f, 4.12262022e-01f, -4.55066413e-01f,
  1.67529732e-01f, 5.17025888e-01f, 2.39142105e-01f, 5.32610416e-01f, 2.67651647e-01f, -7.27357939e-02f, -1.76065162e-01f, -2.48057336e-01f, -1.95840195e-01f, 6.77597746e-02f,
  -6.87659765e-03f, 7.93716982e-02f, 2.47512087e-01f, 1.17345884e-01f, -3.30633111e-02f, -2.54643243e-02f, 3.55487555e-01f, -3.18063684e-02f, 1.25328630e-01f, -1.89857259e-01f,
  1.99113861e-01f, 3.89647305e-01f, -9.28521752e-02f, -2.10914001e-01f, -1.33259088e-01f, -2.96560168e-01f, 1.91238448e-02f, -1.37028489e-02f, -8.75225291e-02f, 2.44653746e-01f,
  2.53092945e-02f, -1.03377946e-01f, -1.00408405e-01f, -1.07604347e-01f, 1.67314019e-02f, -2.75905263e-02f, -5.98932505e-02f, -1.58226728e-01f, -2.15505511e-01f, 3.25109601e-01f,
  -2.29809344e-01f, 1.67508365e-03f, -1.04920916e-01f, 1.72966570e-01f, -1.63088031e-02f, 1.17708936e-01f, -3.18962336e-01f, 2.23169297e-01f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  -7.57594556e-02f, -7.60090649e-02f, 8.54487717e-03f, -1.01859860e-01f, 9.86432508e-02f, -3.66702601e-02f, 9.04493779e-02f, 1.18363775e-01f, 1.69967964e-01f, -7.89491683e-02f,
  1.14823371e-01f, 1.49682155e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 12, 40
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 12, 40
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        64, 12, 40
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        64, 12
    );
    }
    