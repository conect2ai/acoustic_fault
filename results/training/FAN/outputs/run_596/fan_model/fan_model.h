/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 4 x 120)
const int L0_fan_Wp_rows = 4;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -8.63654375e-01f, 1.48275152e-01f, 1.64928496e-01f, -3.98695201e-01f, -9.39149857e-02f, 3.69736850e-02f, 3.37947607e-02f, -2.36031152e-02f, -8.09468701e-02f, -1.12832419e-03f,
  9.87205133e-02f, -3.85377444e-02f, 5.17834984e-02f, 6.95982389e-03f, -1.20476291e-01f, 1.61661938e-01f, -4.08435054e-03f, -4.45321389e-02f, -1.83434308e-01f, -1.64780885e-01f,
  -1.17767423e-01f, -3.55378956e-01f, -3.89157891e-01f, -5.38724512e-02f, -5.63788041e-02f, -9.69311669e-02f, 1.15597904e-01f, -2.82714944e-02f, 8.34035277e-02f, 7.77003239e-04f,
  5.28833047e-02f, 1.42632714e-02f, -4.72545363e-02f, 1.79990195e-02f, -6.80912985e-03f, 4.35793586e-03f, -7.93614537e-02f, -2.78016645e-02f, 8.98751765e-02f, 6.91461265e-02f,
  -3.32250670e-02f, 8.13266635e-02f, -5.88433146e-02f, 1.97641570e-02f, -1.54258057e-01f, 2.36590412e-02f, -3.67627293e-02f, -4.17198613e-02f, -2.86161136e-02f, -3.68021568e-03f,
  -1.81792174e-02f, 3.26728784e-02f, 8.16587657e-02f, 1.01914279e-01f, 3.57910730e-02f, -4.90028523e-02f, 7.33508496e-03f, -1.27457967e-02f, 1.15152359e-01f, 2.74828095e-02f,
  -3.72363925e-02f, 1.08512200e-01f, -3.76034044e-02f, 1.36126708e-02f, -5.46455421e-02f, 6.82729855e-02f, 1.07406387e-02f, 9.72293969e-03f, 4.34271097e-02f, 5.85234277e-02f,
  3.06292390e-03f, -7.37494603e-02f, 4.61341999e-03f, -3.72243300e-02f, 6.06572293e-02f, -6.50946274e-02f, -2.93268468e-02f, -2.24695373e-02f, 6.68621883e-02f, -3.27733420e-02f,
  -3.88448574e-02f, 4.97271493e-02f, -2.91232113e-02f, -2.49398760e-02f, -4.47850376e-02f, 2.66504940e-02f, -2.99802572e-02f, 5.56595884e-02f, -1.48956716e-01f, 5.13745509e-02f,
  -1.20625451e-01f, 8.73685852e-02f, -4.65676785e-02f, 1.02168940e-01f, 6.00720309e-02f, 4.75387126e-02f, 2.78938133e-02f, 1.03833310e-01f, 1.61244981e-02f, -1.01105133e-02f,
  3.19703072e-02f, -4.82327975e-02f, -5.46187162e-02f, 4.32160087e-02f, -2.64791455e-02f, 3.29320841e-02f, -2.26698294e-02f, -4.88353372e-02f, 3.99447419e-02f, 9.88306403e-02f,
  -4.33000661e-02f, 5.13288528e-02f, 1.76979415e-02f, 2.80965436e-02f, -4.32806183e-03f, -6.82407692e-02f, 6.64756522e-02f, 2.43876819e-02f, 6.37982562e-02f, -1.17791528e-02f,
  3.91188771e-01f, -2.06156626e-01f, 5.47294468e-02f, 1.68310866e-01f, 9.62567255e-02f, 3.68549190e-02f, 1.86539069e-01f, 7.27506429e-02f, 3.84232849e-02f, -1.20660886e-01f,
  -2.47542068e-01f, -3.68124932e-01f, -4.31040436e-01f, -3.25731546e-01f, -4.57721092e-02f, 7.47974813e-02f, 3.47976267e-01f, 6.37445301e-02f, 9.96380746e-02f, -6.93792924e-02f,
  -7.87709728e-02f, 2.28025839e-01f, 2.89085448e-01f, 1.25493079e-01f, -1.37998620e-02f, -4.15666215e-02f, 1.15520529e-01f, 1.24309853e-01f, -1.53453201e-02f, -7.15173185e-02f,
  -2.97463238e-01f, -6.70732856e-02f, -3.64374369e-02f, 2.55153179e-02f, -3.02911140e-02f, -7.27823470e-03f, 2.75179017e-02f, -2.47707055e-03f, -4.23482135e-02f, -6.67323917e-02f,
  -1.47931561e-01f, -8.08520764e-02f, -5.36124557e-02f, -1.44359395e-01f, 6.09175637e-02f, -5.92658930e-02f, -7.89001863e-03f, 4.54376899e-02f, -2.04509534e-02f, -1.24445602e-01f,
  -5.28207496e-02f, -1.01105362e-01f, -8.64833593e-02f, -9.68121663e-02f, -6.57954393e-03f, -8.34214911e-02f, -9.22244787e-02f, -1.03214681e-01f, 2.54821707e-03f, -5.44108450e-02f,
  -1.27794757e-01f, -1.03160255e-01f, 5.79672009e-02f, 5.29030934e-02f, -7.90309757e-02f, -5.49889281e-02f, 5.68165779e-02f, -1.00063592e-01f, -2.15620026e-02f, 1.92174353e-02f,
  1.21769598e-02f, 3.63873169e-02f, -9.44033358e-03f, 3.64174992e-02f, -7.36329108e-02f, 1.67437885e-02f, -8.85287207e-03f, -6.65947944e-02f, -1.09665640e-01f, 1.15319811e-01f,
  -8.04446191e-02f, 2.83004828e-02f, 7.66140819e-02f, -5.24181798e-02f, 6.47492632e-02f, -3.21771950e-02f, -1.24740275e-02f, -5.61804548e-02f, -3.82931251e-03f, 2.16091867e-03f,
  -4.43433411e-02f, 2.75488477e-02f, -7.93949962e-02f, -8.89286920e-02f, -4.25999947e-02f, 2.10534665e-03f, 8.02658382e-04f, 5.81234135e-03f, -6.69321865e-02f, -6.70030015e-03f,
  -9.50512290e-03f, -3.71354446e-02f, -7.08821341e-02f, -1.01357251e-02f, -2.72320490e-02f, -1.89542249e-02f, -9.37401429e-02f, -4.15212288e-02f, 1.78332999e-02f, 4.47710194e-02f,
  -5.19823097e-02f, 2.59813480e-02f, -1.52227702e-02f, -4.32848111e-02f, 2.55294759e-02f, -6.31238818e-02f, -6.79177418e-02f, -2.66884677e-02f, -9.65951160e-02f, 6.87949508e-02f,
  -3.52686375e-01f, -3.58898908e-01f, 2.77569192e-03f, -1.68638527e-01f, 2.01533213e-02f, -1.48407266e-01f, -5.07415295e-01f, -2.86319643e-01f, 4.88014966e-02f, -1.40690401e-01f,
  1.79277569e-01f, 5.18648088e-01f, 3.52876484e-01f, 2.80074060e-01f, -6.02699369e-02f, -3.69522959e-01f, -1.84395730e-01f, 1.05867498e-01f, 1.67871505e-01f, -8.74806941e-03f,
  1.23595744e-01f, -5.92761561e-02f, 1.05473318e-03f, 1.56846479e-01f, 1.28876135e-01f, 3.35395694e-01f, 8.95354599e-02f, 1.02789879e-01f, 1.93714932e-01f, 3.90735745e-01f,
  1.22102294e-02f, -1.28876343e-01f, 1.78965718e-01f, 8.60873535e-02f, 4.29180712e-02f, -2.48841736e-02f, -6.81058913e-02f, -7.32325809e-03f, 2.88355574e-02f, 4.87769209e-03f,
  1.47948503e-01f, -1.05209248e-02f, 7.51581937e-02f, 6.63960204e-02f, -1.28650656e-02f, -7.34586939e-02f, 4.80350899e-03f, -5.42343371e-02f, -2.99495608e-02f, -1.27021149e-01f,
  3.66311260e-02f, -7.81303495e-02f, -1.88474610e-01f, 1.11854458e-02f, -1.32388040e-01f, 6.86049461e-02f, 6.81666881e-02f, 7.36395940e-02f, 7.88852349e-02f, 7.19690025e-02f,
  -6.32262677e-02f, 3.82383168e-02f, -1.45556694e-02f, -6.72349706e-02f, -1.00639099e-02f, 5.57252057e-02f, 9.58410744e-03f, -2.22895928e-02f, 4.69693057e-02f, -3.19749210e-03f,
  1.77998804e-02f, -2.64771059e-02f, -1.24619296e-02f, -1.42971054e-03f, 7.92138502e-02f, -2.06430480e-02f, -5.58154844e-02f, 2.06956901e-02f, 2.24061199e-02f, -1.52110243e-02f,
  -9.80997644e-03f, 3.14670689e-02f, 1.12549454e-01f, -2.50718836e-02f, -8.55107140e-03f, -1.17290784e-02f, -1.00263311e-02f, 3.52218933e-02f, -1.50043741e-02f, -2.73047742e-02f,
  3.73111777e-02f, 5.13035394e-02f, -1.25169950e-02f, 6.97550401e-02f, 1.66321620e-02f, 5.05341105e-02f, 4.72763814e-02f, 3.93264219e-02f, 5.33026010e-02f, -1.13553209e-02f,
  -2.72314018e-03f, 7.61182513e-03f, 7.44733680e-03f, 2.68866401e-02f, 5.17697558e-02f, 7.10975379e-02f, -4.60118279e-02f, 1.52594037e-02f, -7.73959886e-03f, 1.05697056e-02f,
  -8.62274691e-02f, -6.91830665e-02f, -1.02664784e-01f, -5.66918822e-03f, -6.61296323e-02f, -6.90503120e-02f, -2.26627514e-02f, -1.32332221e-02f, -6.07944690e-02f, -3.11869919e-01f,
  -8.40086699e-01f, 5.70181645e-02f, -1.20520471e-02f, 8.40359554e-02f, 1.53589189e-01f, -3.26862842e-01f, -3.60623091e-01f, -2.02062085e-01f, 3.34490836e-02f, 1.33293616e-02f,
  1.53907929e-02f, -1.29214758e-02f, 2.12355256e-02f, 5.83786443e-02f, -1.07518904e-01f, -8.12229514e-02f, 8.79273936e-02f, 6.22090995e-02f, -2.66089469e-01f, -1.69006929e-01f,
  2.71090478e-01f, 1.35189652e-01f, 1.32854551e-01f, 1.29136756e-01f, 1.80222437e-01f, 3.34765725e-02f, 1.55294791e-01f, 1.03655644e-01f, 1.05637005e-02f, 2.01688692e-01f,
  -2.31094971e-01f, -1.62820697e-01f, 1.24990742e-03f, -9.09855496e-03f, 1.45728409e-01f, -1.15379244e-01f, -9.12886485e-02f, -4.90410440e-02f, 2.98075862e-02f, 4.72767092e-02f,
  1.26990313e-02f, -2.10746005e-02f, -1.54408708e-01f, -1.96585115e-02f, -9.96179655e-02f, -7.15748742e-02f, -1.68503239e-03f, -5.32336161e-02f, -2.25120503e-02f, -7.37773255e-02f,
  2.45482028e-01f, -7.81090409e-02f, -1.01115853e-01f, -3.17175835e-02f, -3.69361155e-02f, 1.06197186e-01f, -3.74018177e-02f, -9.59583819e-02f, 5.20959671e-04f, 5.89928180e-02f,
  3.16686593e-02f, 3.28328600e-03f, -5.66904508e-02f, 4.77821268e-02f, 1.02975562e-01f, -1.21602781e-01f, -2.75103077e-02f, -1.43108945e-02f, -5.20270020e-02f, -1.08554967e-01f,
  7.63921589e-02f, -1.97687950e-02f, 2.58951765e-02f, 3.03472858e-02f, 5.95138669e-02f, -1.79885812e-02f, -8.88486113e-03f, 9.21950936e-02f, 4.15959358e-02f, -2.92361360e-02f,
  -3.56748998e-02f, -5.96055239e-02f, -3.49371657e-02f, 5.20408303e-02f, 1.08010666e-02f, 1.86489206e-02f, -5.76377586e-02f, 4.76055034e-02f, 2.75394376e-02f, 9.95467827e-02f,
  -1.78677946e-01f, 1.95761204e-01f, -2.30637401e-01f, -1.54301330e-01f, -1.26308976e-02f, 3.80107015e-02f, 8.98643360e-02f, -2.34299060e-02f, -8.94403756e-02f, -1.00818418e-01f,
  -3.62565443e-02f, -1.63388222e-01f, 9.01817810e-03f, 1.73566192e-02f, -1.16073258e-01f, -9.58750322e-02f, -2.36159172e-02f, -6.48866072e-02f, -5.31367213e-02f, -1.15056895e-02f,
  9.83198956e-02f, -1.11605734e-01f, -1.69880778e-01f, -1.37347966e-01f, -5.14705330e-02f, -1.46178484e-01f, -5.06633148e-02f, -7.11670369e-02f, -1.60884157e-01f, -1.15741372e-01f
};

// L0_fan_Wp_bar (Shape: 8 x 120)
const int L0_fan_Wp_bar_rows = 8;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  3.35547686e-01f, 9.64941531e-02f, 2.28420392e-01f, 1.78292304e-01f, -4.79090869e-01f, -8.23280275e-01f, -7.86983550e-01f, -6.44109607e-01f, -1.13211542e-01f, 3.09637696e-01f,
  1.25402570e-01f, 2.40818694e-01f, 3.37601364e-01f, -9.99556668e-03f, -4.64802533e-01f, 1.78045496e-01f, 1.43976957e-01f, 6.20712638e-02f, -5.27893245e-01f, -3.67156178e-01f,
  3.70125510e-02f, 1.48344666e-01f, -4.17288207e-02f, -1.89132765e-01f, 5.39796770e-01f, -6.41529560e-02f, 2.57637650e-01f, 2.24225968e-02f, 7.20023066e-02f, 1.05025280e+00f,
  7.78527200e-01f, 1.28688321e-01f, -2.67097533e-01f, 7.33588710e-02f, 1.07821897e-01f, 8.79097655e-02f, 1.68930087e-02f, 1.70700192e-01f, -1.00890137e-01f, -8.77988618e-03f,
  7.60222152e-02f, -1.04341738e-01f, -1.54971644e-01f, 1.03308588e-01f, -2.41690744e-02f, -6.56611705e-03f, -5.71953133e-02f, 3.35825086e-02f, -5.18093035e-02f, 3.69033486e-01f,
  1.97083473e-01f, -2.84958375e-03f, -2.49444112e-01f, -3.44030827e-01f, 3.19826119e-02f, 1.07861515e-02f, -2.53498346e-01f, -3.66869010e-03f, -4.68018055e-01f, 3.02104115e-01f,
  -1.07202053e-01f, 6.15823232e-02f, -6.55587465e-02f, -3.50714736e-02f, -1.53803363e-01f, 1.24638729e-01f, 9.50610191e-02f, 2.16369517e-02f, -4.11167666e-02f, 7.29120150e-02f,
  -9.53722373e-02f, 6.82459176e-02f, -5.20846341e-03f, -5.20911440e-02f, 7.53896311e-02f, 8.29652324e-02f, 7.64021464e-03f, -1.05687650e-02f, -1.26565993e-01f, -8.26763585e-02f,
  -7.30835572e-02f, -9.01167840e-02f, 1.29468599e-03f, -1.97521821e-02f, -3.69728282e-02f, 2.75545735e-02f, -6.80754986e-03f, 2.07393132e-02f, -3.46104652e-02f, 7.04697073e-02f,
  1.03247724e-01f, -7.51838028e-01f, 4.45674270e-01f, 8.95235837e-02f, 1.27330780e-01f, 1.63726229e-02f, 1.47696823e-01f, -1.13744728e-01f, 1.08145058e-01f, -7.69407675e-02f,
  -1.01241041e-02f, 8.45560655e-02f, 7.66856372e-02f, -4.00036154e-03f, -2.31977403e-01f, -1.22373924e-02f, -2.06845384e-02f, -2.33315155e-02f, -9.26640555e-02f, 4.17918600e-02f,
  5.76912388e-02f, -2.43714318e-01f, -2.07846254e-01f, -1.45962089e-01f, 1.43347353e-01f, -8.75083804e-02f, 1.08959503e-01f, 2.10181866e-02f, -3.53306830e-01f, -1.68338165e-01f,
  -1.09225258e-01f, -4.35824692e-02f, -4.18409854e-01f, 7.21385419e-01f, 1.49162799e-01f, 4.17521782e-02f, 3.23279351e-01f, 5.39183140e-01f, 3.81859332e-01f, 2.79470176e-01f,
  -2.59143770e-01f, -4.34835494e-01f, -5.43663442e-01f, -3.65189493e-01f, -5.83495557e-01f, 5.28296120e-02f, -2.66754031e-01f, -6.04667604e-01f, -9.41125080e-02f, 3.13141733e-01f,
  3.69488686e-01f, 4.45273787e-01f, 5.20226546e-02f, -8.90140906e-02f, 4.24688309e-01f, 3.17476392e-01f, 1.48093417e-01f, 1.49160817e-01f, -1.90923393e-01f, -1.11800060e-01f,
  -1.46332934e-01f, -2.33259946e-01f, -1.02014735e-01f, -7.57174939e-02f, -5.74799106e-02f, -1.99226841e-01f, -1.00014724e-01f, -1.35033175e-01f, -1.86516136e-01f, 2.66295850e-01f,
  -1.89743891e-01f, -3.52802873e-01f, -3.38838935e-01f, 2.71231942e-02f, 1.79963931e-01f, -5.99114746e-02f, -2.31922805e-01f, -5.09160936e-01f, -3.45759302e-01f, -4.32686448e-01f,
  -2.72445858e-01f, -3.08020979e-01f, -4.85805839e-01f, -1.56261683e-01f, -5.15241623e-01f, -6.11977875e-01f, -9.25690904e-02f, -2.25493878e-01f, -4.93787795e-01f, 7.23891675e-01f,
  1.24235288e-03f, 3.88517417e-02f, -4.14488539e-02f, -4.27762568e-02f, 1.69353783e-02f, 3.81173473e-03f, -5.77406213e-03f, 1.06230028e-01f, -3.07233594e-02f, 2.14571729e-01f,
  2.32557431e-02f, -1.04984842e-01f, -9.28861773e-05f, 2.24874988e-01f, 4.31381389e-02f, -1.31140828e-01f, 1.53368600e-02f, 4.01975214e-02f, -3.67057137e-02f, -4.45981277e-03f,
  9.09748897e-02f, 9.41994116e-02f, 1.69651937e-02f, 6.47335202e-02f, -1.62473515e-01f, -1.57322392e-01f, 2.05861758e-02f, -5.05327247e-02f, -3.48057114e-02f, -1.49694502e-01f,
  6.09097600e-01f, -7.89256930e-01f, 8.37585777e-02f, 1.14628203e-01f, 2.46490370e-02f, -1.31251499e-01f, 4.74528074e-02f, 1.77758877e-04f, -1.12415068e-01f, 2.93201115e-02f,
  -1.01056077e-01f, -3.60160647e-03f, 3.84213626e-02f, 3.57901342e-02f, 2.11873025e-01f, 6.52285013e-03f, 3.68641056e-02f, 3.23989242e-01f, 8.71025920e-02f, 1.92366034e-01f,
  9.59486961e-02f, 3.62119526e-01f, 3.33136052e-01f, 2.74269819e-01f, 4.14305851e-02f, 6.70528859e-02f, 2.43293971e-01f, 2.80298054e-01f, -2.61422187e-01f, 1.03294659e+00f,
  -1.16185844e+00f, 5.44247814e-02f, 5.55872321e-01f, -3.09882224e-01f, -2.10668474e-01f, -4.21242386e-01f, -4.58399087e-01f, -3.28671485e-01f, -3.47912699e-01f, -2.22775534e-01f,
  -1.07095584e-01f, 9.80236009e-02f, 2.92748421e-01f, 3.30247283e-01f, 1.02144234e-01f, 1.74130965e-02f, 1.77488059e-01f, 2.92726785e-01f, 2.47365981e-01f, -8.78366381e-02f,
  1.13315610e-02f, 7.98143148e-02f, 1.02883227e-01f, 6.92227855e-02f, -1.40787940e-02f, 1.48899972e-01f, 2.41798416e-01f, 3.93189751e-02f, -9.96926278e-02f, 4.14138362e-02f,
  5.75460672e-01f, -3.37301940e-01f, 1.26696929e-01f, -3.07740755e-02f, 1.03531413e-01f, -1.09619640e-01f, -5.76722398e-02f, 3.42138261e-02f, -1.37204230e-01f, 4.05673571e-02f,
  4.76951785e-02f, -9.55251008e-02f, 3.65515128e-02f, -1.41125888e-01f, -5.79296090e-02f, -9.63710323e-02f, -1.47883803e-01f, 1.32202759e-01f, 2.45495632e-01f, 8.25486034e-02f,
  -2.26617306e-02f, -2.07920551e-01f, 1.88060626e-02f, 1.11188225e-01f, -3.23215164e-02f, -2.24100593e-02f, 1.55879468e-01f, -1.02944195e-01f, -2.05260161e-02f, -1.89663082e-01f,
  -9.47861597e-02f, -1.34679312e-02f, -4.46774326e-02f, 4.13825773e-02f, -3.99120115e-02f, -7.05312341e-02f, 6.07520491e-02f, -1.70498213e-03f, -5.83211258e-02f, -8.62115175e-02f,
  1.84186935e-01f, 2.16515977e-02f, -2.81534567e-02f, -1.22916706e-01f, -3.22118104e-02f, -3.29639353e-02f, -2.05337867e-01f, 6.08746968e-02f, 3.69403213e-02f, -3.94139327e-02f,
  -2.01679785e-02f, 8.56830403e-02f, -7.28345513e-02f, 2.15521660e-02f, -3.67744714e-02f, -2.81616766e-02f, -5.40800989e-02f, -1.09899461e-01f, -1.12155061e-02f, 4.04844359e-02f,
  1.39048204e-01f, 1.63792580e-01f, 3.72003429e-02f, 3.82183604e-02f, -8.59492347e-02f, 2.70856936e-02f, 3.51210348e-02f, 2.52104878e-01f, 1.95226043e-01f, 6.13900088e-02f,
  6.48092777e-02f, 6.50007874e-02f, 5.04653156e-02f, 2.92363502e-02f, -1.72333904e-02f, -2.79565509e-02f, -9.28378999e-02f, 1.06815316e-01f, 1.64300308e-01f, 2.46269315e-01f,
  1.14355452e-01f, -9.35957879e-02f, 1.07214406e-01f, 2.79072337e-02f, -1.16881639e-01f, 3.08120027e-02f, 1.70454770e-01f, 8.54872838e-02f, 4.16443776e-03f, -7.55014494e-02f,
  -1.82056189e-01f, 1.04148352e+00f, 5.42380273e-01f, -1.80721730e-01f, 2.92567611e-01f, 1.84071839e-01f, 5.22168696e-01f, -3.52371149e-02f, -3.23513538e-01f, 3.47437769e-01f,
  1.87101483e-01f, -4.95986611e-01f, -3.20495576e-01f, -4.15676296e-01f, -1.88516960e-01f, 2.92698681e-01f, 4.37385738e-01f, -6.84781000e-03f, -5.47428906e-01f, -2.87543386e-01f,
  6.30550086e-02f, 7.08714873e-02f, -6.55198246e-02f, 1.44115090e-02f, 8.17795992e-02f, -5.03711700e-01f, 6.09337874e-02f, 1.53934121e-01f, -4.86514270e-02f, 4.08589572e-01f,
  -9.53582227e-02f, 2.21961066e-01f, -5.84353745e-01f, -1.20423563e-01f, 2.30898842e-01f, -1.92506313e-01f, -9.47869718e-02f, 8.14157575e-02f, 7.51431063e-02f, 2.12844297e-01f,
  8.99047554e-02f, 5.58654629e-02f, 2.53329486e-01f, -2.51111574e-02f, 1.98613837e-01f, -1.34049669e-01f, 1.10302031e-01f, 2.58454829e-02f, -1.27575129e-01f, 3.12299822e-02f,
  1.49637505e-01f, 1.39390588e-01f, 7.92334229e-02f, 1.03463441e-01f, 1.00784175e-01f, -3.26038480e-01f, 1.76957160e-01f, -3.64194028e-02f, -2.06937909e-01f, -7.66295269e-02f,
  -6.72068074e-02f, 1.12621360e-01f, 4.92817760e-02f, -1.11479005e-02f, -7.93134645e-02f, -4.22889777e-02f, 3.17061618e-02f, -5.64868897e-02f, -3.60753201e-02f, 1.14174105e-01f,
  3.33820656e-02f, 7.53441360e-04f, -3.89976241e-02f, -8.64963233e-02f, -1.70941517e-01f, 5.51825240e-02f, -1.41014025e-01f, -8.01057443e-02f, 1.41061451e-02f, -9.18789431e-02f,
  -2.31504753e-01f, 7.09467661e-03f, -6.00537248e-02f, 5.66548035e-02f, -2.19971742e-02f, -4.12455983e-02f, -1.51232958e-01f, 1.58682868e-01f, 6.49021715e-02f, 1.97304130e-01f,
  -4.67895001e-01f, 1.67967882e-02f, -4.27410334e-01f, -2.12692782e-01f, 1.58429146e-01f, 5.64902723e-02f, 8.92399475e-02f, 3.08875423e-02f, 2.00764567e-01f, 9.19520482e-02f,
  8.54060892e-03f, -6.65181205e-02f, 1.00956902e-01f, -8.17863271e-02f, -1.27680540e-01f, -7.27508292e-02f, 2.35338658e-02f, -5.33995740e-02f, -2.08726242e-01f, 1.75116748e-01f,
  1.36786759e-01f, -4.43324387e-01f, -7.47060657e-01f, -2.18086898e-01f, -4.22109932e-01f, -8.85084927e-01f, -2.11656034e-01f, -4.00622129e-01f, -5.54884434e-01f, -3.91660959e-01f,
  1.70278597e+00f, -3.38581145e-01f, 8.69924277e-02f, 7.05455691e-02f, -5.52894533e-01f, -6.70767277e-02f, -2.33587071e-01f, 2.55920812e-02f, 6.79001734e-02f, 7.30827674e-02f,
  -4.86567654e-02f, 1.79282740e-01f, 2.87113875e-01f, 2.64267594e-01f, 5.03775120e-01f, -9.03909504e-02f, -2.05201969e-01f, 2.83573389e-01f, 4.20604199e-01f, 3.23057830e-01f,
  -2.49479815e-01f, -1.94159016e-01f, 3.30811739e-01f, 9.85432714e-02f, -2.38183782e-01f, 5.91070484e-03f, -9.90197212e-02f, -2.54200250e-01f, -1.81268930e-01f, -2.87215173e-01f,
  -2.47756988e-02f, 1.77680239e-01f, 3.57584395e-02f, -1.08607551e-02f, -2.00494334e-01f, 5.41085117e-02f, 8.00637901e-02f, 1.80154331e-02f, -1.61868567e-03f, -3.14523987e-02f,
  -1.20844476e-01f, -6.72086552e-02f, -1.76496059e-01f, -7.81517550e-02f, -1.19928740e-01f, -5.42433839e-03f, 2.77803652e-02f, 2.37849936e-01f, 3.57154086e-02f, 1.76948979e-02f,
  -1.51290357e-01f, -1.88379303e-01f, -6.03974313e-02f, 4.37233299e-02f, 1.09305434e-01f, -6.86004460e-02f, -2.12995678e-01f, -8.21245685e-02f, 4.76694405e-02f, 1.37650743e-01f,
  3.54962684e-02f, 1.71521634e-01f, -8.63140598e-02f, -4.60303901e-03f, 4.76903282e-02f, 2.65392493e-02f, 3.46682742e-02f, 9.96653214e-02f, 1.56771123e-01f, 5.07406592e-02f,
  -1.08976215e-01f, -1.65631827e-02f, -7.96885341e-02f, 1.24596529e-01f, -6.75878525e-02f, -1.22323424e-01f, -7.44624734e-02f, -3.13196294e-02f, -6.11242317e-02f, -1.30955622e-01f,
  7.46638104e-02f, 6.72118664e-02f, -1.24158777e-01f, -1.49154648e-01f, -1.25085250e-01f, 2.85607334e-02f, -4.62363586e-02f, -8.62225667e-02f, 4.38371487e-02f, 7.82317366e-04f,
  -2.78385460e-01f, -2.09558401e-02f, 1.36200562e-01f, 1.63439378e-01f, 5.81877530e-02f, 4.45928164e-02f, 7.20091090e-02f, -5.18926885e-03f, -2.58602470e-01f, -1.40395770e-02f,
  -2.88237091e-02f, 8.22119117e-02f, 3.08933649e-02f, 4.16602232e-02f, 1.05521843e-01f, 9.21952054e-02f, -1.74636096e-02f, 1.68329552e-01f, 1.93720702e-02f, -1.50884286e-01f,
  -1.34904638e-01f, 7.29296356e-02f, 2.07075447e-01f, 7.85588622e-02f, 7.14564025e-02f, 1.69689462e-01f, 2.14462560e-02f, 1.65875349e-02f, 1.14895351e-01f, 1.41117498e-01f,
  -1.31832278e+00f, 1.43407926e-01f, -6.50219321e-01f, -6.35190785e-01f, 3.60476255e-01f, 1.38937533e-01f, 1.72279283e-01f, -1.64353162e-01f, -2.47246802e-01f, -1.45646438e-01f,
  -1.88419577e-02f, 1.15119137e-01f, -8.38467479e-02f, 2.96297401e-01f, 1.79275215e-01f, 2.28580877e-01f, 2.81268626e-01f, -1.11021884e-02f, 1.48023099e-01f, 4.44535315e-01f,
  6.93670034e-01f, -8.21809992e-02f, -4.61001813e-01f, 3.58980447e-02f, -5.80667751e-03f, 1.11103661e-01f, -3.42951268e-01f, -6.35826588e-02f, 8.96205753e-02f, 8.89805034e-02f,
  -1.58690855e-01f, -4.29637700e-01f, -5.04446104e-02f, 1.03028841e-01f, 4.12946381e-02f, -3.12659174e-01f, 5.36492392e-02f, -3.83320779e-01f, -4.42178287e-02f, -1.33500293e-01f,
  -3.00212353e-02f, -7.29236528e-02f, -1.14213824e-02f, 2.43184328e-01f, -3.52935381e-02f, -4.80302460e-02f, -2.21727237e-01f, -3.04021508e-01f, -5.40214300e-01f, -1.24561265e-01f,
  4.54085082e-01f, 4.36950512e-02f, -3.82083684e-01f, 1.24511048e-01f, -1.34201810e-01f, -1.06216371e-02f, -2.32328642e-02f, 6.61343709e-02f, -2.46019274e-01f, -2.43484467e-01f,
  1.28255049e-02f, 2.51738895e-02f, -4.07847278e-02f, -6.09402284e-02f, 1.53182089e-01f, -6.07631393e-02f, 1.99258640e-01f, 2.68777758e-02f, 1.63181350e-01f, -9.64581668e-02f,
  5.01161888e-02f, -1.16414152e-01f, 3.35052498e-02f, -5.34605905e-02f, 4.89768088e-02f, -1.12696402e-01f, 1.94075614e-01f, -9.23653841e-02f, -8.55217502e-02f, -1.40327275e-01f,
  6.18649721e-02f, -1.44395707e-02f, -1.40514255e-01f, 7.78943151e-02f, -1.94520410e-02f, -9.54767019e-02f, -4.49510068e-02f, 2.86859404e-02f, -1.79926038e-01f, -1.11311011e-01f,
  -1.29234672e-01f, 1.32480348e-02f, -6.31394163e-02f, 2.15962082e-01f, -3.03768087e-02f, 1.82840109e-01f, -5.07235080e-02f, 2.26653907e-02f, -1.92738056e-01f, -8.70564058e-02f,
  4.40706732e-03f, 3.07089575e-02f, -6.01106659e-02f, 1.02451339e-01f, -9.91814062e-02f, 3.16501074e-02f, 1.86749443e-01f, 1.16361730e-01f, 1.25545174e-01f, 2.97422688e-02f,
  9.67915952e-02f, -1.63406730e-02f, -4.03654158e-01f, -1.01492882e-01f, 2.21705511e-01f, -1.99437350e-01f, -6.60306439e-02f, -7.75037706e-02f, -4.49030578e-01f, -2.94039696e-01f,
  8.56963158e-01f, 5.85211933e-01f, -1.31058276e+00f, 5.50125599e-01f, -5.35404205e-01f, -4.23077494e-01f, 9.03092548e-02f, 5.83995581e-01f, 3.06307375e-01f, 2.55872071e-01f,
  1.87785208e-01f, 2.13349443e-02f, -1.11236468e-01f, 3.96796390e-02f, -2.98876435e-01f, -2.32299238e-01f, -3.77071112e-01f, -8.10678899e-01f, -6.62415802e-01f, 3.12012359e-02f,
  1.05237618e-01f, -1.40804574e-01f, -7.41444528e-02f, 1.56322464e-01f, 1.40250370e-01f, -2.68344045e-01f, -2.59756356e-01f, -2.95454830e-01f, -2.69278049e-01f, -7.85105824e-01f,
  -6.51576698e-01f, 4.59609479e-02f, -3.12565327e-01f, 3.19834232e-01f, 6.06113225e-02f, 1.51572108e-01f, 2.26753950e-01f, 1.69076279e-01f, 4.47860248e-02f, 1.61399215e-01f,
  -6.45758510e-02f, 2.18761936e-01f, 1.26228541e-01f, -5.36739267e-03f, -3.13349478e-02f, 2.52448842e-02f, 2.60578513e-01f, -1.05698019e-01f, 1.04360193e-01f, -1.51138650e-02f,
  2.29506224e-01f, -3.97840261e-01f, -6.37937665e-01f, -2.81656487e-03f, -3.44646499e-02f, -2.79752642e-01f, -2.67024606e-01f, -2.73313642e-01f, -4.49247599e-01f, 1.24631509e-01f,
  -1.28939021e-02f, 1.08283557e-01f, -6.23721331e-02f, 1.01609036e-01f, 1.18205123e-01f, -5.05355522e-02f, 3.71122882e-02f, -6.49049953e-02f, -7.57782236e-02f, -6.02929033e-02f,
  1.68657571e-01f, -2.66784690e-02f, 3.98919173e-02f, 1.09708151e-02f, -9.73150581e-02f, -1.64399758e-01f, 2.91141812e-02f, 9.73065197e-02f, -8.21398422e-02f, 1.00067459e-01f,
  -1.43421546e-01f, -1.75808653e-01f, -1.30160809e-01f, -5.59972925e-03f, -3.71303000e-02f, 1.06729288e-02f, -6.65931702e-02f, 1.38212323e-01f, 7.92574883e-02f, 1.84940100e-01f,
  2.92947561e-01f, -4.78908084e-02f, 2.26907492e-01f, -2.07304895e-01f, -9.56953242e-02f, 7.69926980e-02f, -1.77268773e-01f, 1.10708117e-01f, 8.50967690e-02f, 6.12374246e-02f,
  -1.32200256e-01f, 3.17074023e-02f, -4.70786449e-03f, -1.40651271e-01f, -1.09951913e-01f, -1.24059178e-01f, 5.94693199e-02f, -1.00275472e-01f, 5.52003854e-04f, -7.62199610e-02f,
  5.08887134e-02f, 3.98569033e-02f, 9.72618386e-02f, -6.43679723e-02f, -1.66513383e-01f, -1.59829631e-01f, -1.42574966e-01f, -4.44311500e-02f, -1.37202963e-01f, 7.81969309e-01f,
  -5.87152362e-01f, 1.08652510e-01f, 2.70702630e-01f, -1.90500826e-01f, 3.64058584e-01f, 3.45105499e-01f, -5.46673596e-01f, 8.18390772e-02f, 1.44734919e-01f, -3.98540169e-01f,
  3.91675159e-03f, 7.73508102e-02f, -3.15642893e-01f, -9.85909477e-02f, -6.61743224e-01f, -8.35308671e-01f, -5.51001430e-01f, -3.32063019e-01f, 4.69099283e-01f, 3.79218429e-01f,
  2.14445353e-01f, 3.47698927e-02f, 7.57871121e-02f, 2.06556588e-01f, -3.41004014e-01f, -2.56281763e-01f, -3.80083263e-01f, -2.16947824e-01f, -2.41654977e-01f, -8.78333926e-01f,
  -3.27862263e-01f, 7.46712312e-02f, -1.85269833e-01f, -2.57535011e-01f, 3.24408084e-01f, -9.90326852e-02f, 2.33320966e-02f, -1.28637990e-02f, -4.11466882e-03f, -1.08076014e-01f,
  1.79641575e-01f, 2.47650251e-01f, 5.09222746e-02f, 4.84702624e-02f, 8.29507187e-02f, -3.89359266e-01f, 1.34186193e-01f, -5.83396293e-02f, -1.86490506e-01f, -5.22526130e-02f,
  -2.79529989e-02f, -1.71811786e-02f, -2.41614372e-01f, 8.49203318e-02f, 2.83222526e-01f, 2.08740994e-01f, 4.59692746e-01f, 5.70020974e-02f, 1.00948296e-01f, -5.91186404e-01f,
  -6.52305968e-03f, 6.83945045e-02f, 6.26555756e-02f, 1.22921588e-02f, -4.72031757e-02f, 5.34444600e-02f, -4.92611527e-02f, -1.12914272e-01f, -9.69764590e-02f, 2.89720111e-02f,
  9.08363163e-02f, 1.63114384e-01f, 4.77953479e-02f, -1.49383932e-01f, -1.39255017e-01f, 9.67396200e-02f, -1.58997297e-01f, -1.02200992e-01f, -2.46805996e-01f, -8.90591592e-02f,
  -9.86786708e-02f, 3.81835480e-03f, 3.28131989e-02f, -8.24921727e-02f, -1.21589236e-01f, -3.92994136e-02f, 2.18703210e-01f, 4.27110540e-03f, 2.27787644e-01f, 6.32619485e-02f,
  -3.62782806e-01f, 1.78862497e-01f, -5.27004004e-01f, 1.44641325e-01f, -5.35543784e-02f, 1.21483915e-01f, 8.59754655e-05f, 1.84074357e-01f, 8.88678581e-02f, 1.38672432e-02f,
  4.43031304e-02f, -1.40036076e-01f, -3.72537002e-02f, 6.77235648e-02f, -3.19295377e-02f, -6.01070672e-02f, -1.26749173e-01f, -3.88613380e-02f, -1.33699551e-01f, 3.05135459e-01f,
  -9.68039632e-02f, -5.13757885e-01f, -6.72956944e-01f, -3.93209964e-01f, -3.08687001e-01f, -5.22861481e-01f, -2.53440231e-01f, -2.60451555e-01f, -6.76383555e-01f, -9.52005267e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 8)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 8;
const float L0_fan_Bp_bar_data[] = {
  9.40591037e-01f, 1.26739538e+00f, 8.69740173e-02f, 1.04155278e+00f, 8.07912171e-01f, 5.07812619e-01f, 8.55439663e-01f, 6.63440749e-02f
};

// L1_fan_Wp (Shape: 4 x 16)
const int L1_fan_Wp_rows = 4;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  1.72950402e-02f, -2.89452583e-01f, -9.17025357e-02f, 2.49961913e-01f, 2.57326961e-01f, 5.69544137e-02f, -2.80781120e-01f, 1.25402018e-01f, 5.03559768e-01f, 2.81515688e-01f,
  -7.76862875e-02f, 1.40808642e-01f, -7.29891285e-02f, -1.28028989e-01f, 2.25789711e-01f, -5.38699150e-01f, -1.23843700e-01f, 1.45273522e-01f, 7.08988130e-01f, -1.49432167e-01f,
  9.61201668e-01f, -3.82021278e-01f, 3.73752981e-01f, 1.50462553e-01f, 3.47981989e-01f, -7.06188828e-02f, -3.59759256e-02f, 6.22071438e-02f, 2.04792380e-01f, -4.43655729e-01f,
  -2.05978230e-01f, 2.33753920e-01f, 1.33394390e-01f, 2.13635817e-01f, -1.28882974e-01f, 1.94814038e-02f, 2.03979030e-01f, 1.56708446e-03f, 1.18152238e-01f, 3.28274518e-01f,
  -1.91791162e-01f, 3.38288218e-01f, 3.66821915e-01f, -4.57814395e-01f, -2.15615854e-02f, -5.49205840e-02f, 2.76193153e-02f, 5.05478203e-01f, -4.22360778e-01f, -1.01884827e-01f,
  9.74056274e-02f, -2.89291721e-02f, -3.16967636e-01f, 8.41263831e-02f, 1.01666525e-01f, 2.82619059e-01f, 2.62535959e-01f, -1.29751891e-01f, -2.88294554e-01f, 4.26574349e-01f,
  -1.71896353e-01f, 2.17265144e-01f, -3.12286615e-02f, -5.01350701e-01f
};

// L1_fan_Wp_bar (Shape: 8 x 16)
const int L1_fan_Wp_bar_rows = 8;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  -1.08233690e+00f, 3.25941920e-01f, 4.72470909e-01f, 4.03562784e-01f, 1.22138047e+00f, -1.07236612e+00f, -4.07576382e-01f, -1.82349890e-01f, -5.52551866e-01f, 6.14244819e-01f,
  -7.35431314e-02f, 4.06874120e-02f, -6.85110033e-01f, 1.74272907e+00f, 1.15636611e+00f, 2.57561654e-01f, 1.03548384e+00f, -1.79483458e-01f, 1.41337767e-01f, 3.27009797e-01f,
  1.12054981e-01f, 7.75005594e-02f, 8.50132927e-02f, -3.31866801e-01f, 2.78421529e-02f, 1.58680904e+00f, -2.99360324e-02f, -1.16400898e+00f, 4.52043191e-02f, 9.68286842e-02f,
  4.67546254e-01f, 4.62744623e-01f, 8.25834394e-01f, 5.59349582e-02f, 3.62877667e-01f, 7.46533200e-02f, -1.05966419e-01f, 2.35029384e-02f, 2.72477955e-01f, 1.73660982e-02f,
  1.01382637e+00f, 7.97066808e-01f, 4.49828386e-01f, 4.22384769e-01f, -3.82390678e-01f, 6.55984461e-01f, -9.47683632e-01f, -9.37426507e-01f, 1.60722184e+00f, 9.50227022e-01f,
  -9.19347480e-02f, 1.79316089e-01f, -1.20311594e+00f, 7.19700038e-01f, 4.27032530e-01f, 3.84545863e-01f, 8.86607289e-01f, -7.51996517e-01f, -3.08565795e-01f, 1.14197636e+00f,
  -3.49844217e-01f, 2.59458065e-01f, -7.37310410e-01f, 3.32573533e-01f, -3.18578184e-01f, 6.39728904e-01f, -1.37972689e+00f, 3.04876179e-01f, 1.75814718e-01f, -5.88333666e-01f,
  2.35451758e-01f, 9.90205109e-01f, 1.06156361e+00f, 9.64355052e-01f, -1.44620025e+00f, -7.32033774e-02f, -1.35288882e+00f, 6.88216805e-01f, 1.03600037e+00f, 1.17843759e+00f,
  3.99481684e-01f, 3.97959530e-01f, 3.37015599e-01f, 1.35482833e-01f, -6.34177029e-01f, 4.30247068e-01f, -4.99424748e-02f, -2.65349567e-01f, -8.50616097e-02f, 4.02879208e-01f,
  -4.44949746e-01f, 2.06140339e-01f, 8.85593474e-01f, -8.86137128e-01f, 7.31013417e-01f, -1.02188957e+00f, 1.21254826e+00f, 2.56146193e-02f, -5.29768229e-01f, -1.52642271e-02f,
  -5.54899633e-01f, 5.93548059e-01f, -1.35919094e+00f, -5.25561690e-01f, -1.33179688e+00f, 1.13182116e+00f, -6.01653099e-01f, 9.17961836e-01f, -4.01942611e-01f, 2.97408938e-01f,
  -8.16825628e-01f, -3.66451353e-01f, 3.53556462e-02f, 2.10072935e-01f, 5.77621281e-01f, 2.38928795e-01f, 2.83665597e-01f, -2.68661175e-02f, -1.68890953e-01f, -5.02746165e-01f,
  1.84674299e+00f, 7.10014284e-01f, -5.31609535e-01f, 6.04072690e-01f, 3.33774686e-01f, -1.13640523e+00f, 4.80378151e-01f, -4.77661461e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 8)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 8;
const float L1_fan_Bp_bar_data[] = {
  9.72310722e-01f, 2.15586290e-01f, 5.48978269e-01f, 5.98668039e-01f, 4.99027640e-01f, 7.36772060e-01f, 9.22735214e-01f, 5.67340553e-01f
};

// L2_linear_W (Shape: 12 x 16)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 16;
const float L2_linear_W_data[] = {
  -6.52583003e-01f, 2.95268416e-01f, -3.23179781e-01f, -1.02733648e+00f, -9.39671457e-01f, -1.37043625e-01f, -1.08730876e+00f, 8.20905745e-01f, 3.31738621e-01f, 9.10807192e-01f,
  -3.06545794e-01f, -1.26467419e+00f, 4.07148570e-01f, -1.64356291e-01f, -6.00251675e-01f, -1.12481320e+00f, 7.43872643e-01f, 1.15348935e-01f, 6.59891665e-01f, 4.46533501e-01f,
  2.14788571e-01f, 5.20380616e-01f, -5.95598042e-01f, -8.17937136e-01f, -1.37615889e-01f, 2.12059066e-01f, -1.11141241e+00f, -5.18721521e-01f, -1.42852473e+00f, 7.60384858e-01f,
  -1.28507411e+00f, 6.35796607e-01f, 4.16150428e-02f, 4.55195457e-01f, -3.25438499e-01f, 9.79251504e-01f, -1.21174037e+00f, 6.30225897e-01f, 9.73223329e-01f, 1.33168161e-01f,
  -1.32031822e+00f, -3.44704360e-01f, 1.97691336e-01f, 1.34683847e+00f, -2.06705838e-01f, -4.79389518e-01f, -1.07215273e+00f, -1.09283388e+00f, -1.44243557e-02f, 7.48329639e-01f,
  5.84652960e-01f, 1.42778659e+00f, -2.13834614e-01f, 2.32865706e-01f, 1.06431377e+00f, 3.20134610e-01f, 8.60700428e-01f, -1.18692350e+00f, -8.58996987e-01f, -5.69134176e-01f,
  2.72524267e-01f, -1.22533655e+00f, -1.85866594e-01f, -1.86177576e+00f, 8.12066555e-01f, -1.03082013e+00f, -9.30312395e-01f, -1.04401581e-01f, 5.84624887e-01f, 6.33043528e-01f,
  9.33893085e-01f, -6.73690677e-01f, -2.24767551e-01f, -1.69633627e-01f, -8.53844136e-02f, -5.54175913e-01f, 7.53349245e-01f, -2.30754584e-01f, -1.08703113e+00f, 1.93662643e-01f,
  -1.16871512e+00f, 1.33323073e-01f, -2.85465181e-01f, 2.89314598e-01f, 2.23075971e-01f, -1.18881643e+00f, 1.69868451e-02f, 7.12119699e-01f, 5.83717339e-02f, 5.10751128e-01f,
  -7.86445677e-01f, -8.49665940e-01f, 2.11193874e-01f, 5.07912755e-01f, -2.40794361e-01f, 2.30994970e-01f, -1.23362672e+00f, -1.67503789e-01f, -6.50214255e-01f, -4.41017747e-01f,
  6.21272027e-01f, 2.49773324e-01f, -5.71851969e-01f, 3.53394486e-02f, -1.25386226e+00f, -6.45622194e-01f, 9.40017551e-02f, 2.50848174e-01f, -1.33350861e+00f, 1.68803707e-01f,
  -1.13516200e+00f, 9.16467011e-01f, -9.16004702e-02f, -1.54945493e-01f, 1.56795517e-01f, -9.47102904e-01f, -6.30775452e-01f, -6.40314519e-01f, 2.98666842e-02f, 1.90437227e-01f,
  1.40925199e-01f, -5.46026647e-01f, 7.77465463e-01f, -1.10340761e-02f, -1.69409916e-01f, -2.81483233e-01f, 6.49771333e-01f, -1.01223218e+00f, 3.63138348e-01f, 3.68356496e-01f,
  1.15402922e-01f, -5.64922631e-01f, 5.15268324e-03f, -5.53076982e-01f, 9.96732488e-02f, -4.38260496e-01f, -1.35753286e+00f, 4.81079936e-01f, -6.21987320e-02f, -1.06125224e+00f,
  -7.56913722e-01f, 7.06598535e-02f, 1.29479539e+00f, -2.03498546e-02f, 1.53255820e-01f, 7.38344729e-01f, 7.50986814e-01f, -7.75939643e-01f, 7.54480124e-01f, 2.32704878e-01f,
  -1.26236749e+00f, 8.60759735e-01f, -1.25851953e+00f, -4.03092384e-01f, 3.55454654e-01f, 2.95851111e-01f, 6.01647854e-01f, -9.94283855e-01f, -1.01633251e+00f, 9.46778655e-02f,
  -1.08188629e+00f, -6.60292208e-01f, 3.85439932e-01f, -6.73743337e-02f, 1.29094684e+00f, 6.45216525e-01f, 6.17845654e-01f, -7.88159966e-01f, 2.73965448e-01f, 7.63521731e-01f,
  6.96493804e-01f, -6.84288740e-01f, -9.59555745e-01f, -1.47941542e+00f, -2.06825539e-01f, 5.93110994e-02f, 6.21252418e-01f, -3.89747545e-02f, 1.93149149e-01f, 7.89867520e-01f,
  1.17720611e-01f, -5.47652483e-01f, -5.35267234e-01f, 3.17826495e-02f, -8.60258877e-01f, -1.17983806e+00f, -4.54473674e-01f, 6.48746490e-01f, -6.05288684e-01f, -1.67723343e-01f,
  1.23116148e+00f, -8.55661705e-02f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  7.52164423e-03f, -1.70535758e-01f, 3.63913238e-01f, 3.81301641e-01f, 7.66950488e-01f, -1.94016173e-01f, -2.60942519e-01f, -1.11097701e-01f, -6.40884712e-02f, -4.08280753e-02f,
  -3.02754283e-01f, -1.45545751e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 4, 8
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 4, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        16, 12
    );
    }
    