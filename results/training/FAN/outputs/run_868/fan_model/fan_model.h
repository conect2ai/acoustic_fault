/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 12 x 120)
const int L0_fan_Wp_rows = 12;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -6.31676614e-02f, -6.22675598e-01f, -8.21879432e-02f, -3.35838422e-02f, -8.61511454e-02f, -1.99989319e-01f, -5.40699959e-01f, -1.82110250e-01f, 2.61498988e-02f, -8.14826190e-02f,
  4.12319042e-02f, 2.40286961e-01f, 2.51120269e-01f, 1.95584819e-01f, -6.30155653e-02f, -3.36901456e-01f, -2.29488328e-01f, 1.22008868e-01f, 2.18109325e-01f, -2.22263355e-02f,
  -6.59130737e-02f, -1.09426729e-01f, 4.95996550e-02f, -4.02790681e-03f, -3.77727963e-04f, 2.45939672e-01f, 2.50438210e-02f, 3.90324406e-02f, -5.15241660e-02f, 6.19008280e-02f,
  1.68569803e-01f, -9.11347792e-02f, 2.29231045e-01f, 1.43405095e-01f, 1.05361663e-01f, 4.28657718e-02f, 4.78224456e-02f, 7.15017170e-02f, 6.87536364e-03f, -5.86158410e-02f,
  9.31754261e-02f, 5.78375012e-02f, 8.71748924e-02f, 4.40764166e-02f, -1.26414433e-01f, -2.00956818e-02f, -4.47612852e-02f, 4.97254431e-02f, -2.79290183e-03f, 2.75068320e-02f,
  -4.80946749e-02f, -1.79992765e-01f, -5.64540029e-02f, -1.15041748e-01f, 2.87484545e-02f, 3.34429890e-02f, -3.45876478e-02f, 1.33682579e-01f, 5.01447404e-03f, -1.04607724e-01f,
  1.76253635e-02f, 5.66056520e-02f, 6.36750907e-02f, 1.90746225e-02f, -6.94663525e-02f, -2.64920481e-02f, -3.39630409e-03f, -8.48030224e-02f, 6.18710183e-03f, -6.52736798e-02f,
  2.87549403e-02f, 4.70255986e-02f, -4.19390835e-02f, 2.93280315e-02f, 9.33771729e-02f, -6.36286288e-02f, 1.44056790e-02f, -7.08337054e-02f, -1.12291351e-02f, 7.97322951e-03f,
  7.61302039e-02f, 2.58207414e-02f, 2.55097542e-03f, 2.08553318e-02f, -5.17273461e-03f, -5.84092140e-02f, 4.77771722e-02f, -4.60992046e-02f, -3.25867301e-03f, -8.83266553e-02f,
  1.58159826e-02f, 3.23766768e-02f, 5.58275729e-02f, 2.72831116e-02f, 2.05604061e-02f, 7.88806938e-03f, 9.82051250e-03f, 7.84148872e-02f, 5.72431572e-02f, -5.78952301e-03f,
  -7.07961097e-02f, -4.28270921e-02f, -1.02421321e-01f, 1.28364684e-02f, -2.90421303e-02f, 3.13850492e-02f, -1.38923153e-01f, 4.96621616e-02f, -2.20663287e-02f, -5.45233823e-02f,
  -7.57166371e-02f, -8.05514902e-02f, -1.08241498e-01f, -9.57502127e-02f, -1.90460887e-02f, 6.67267069e-02f, -2.64214147e-02f, -7.23744137e-03f, -1.67424078e-04f, -2.83294618e-01f,
  -1.32615775e-01f, -2.47716203e-01f, -3.65822762e-01f, -3.18224013e-01f, -6.60813898e-02f, -1.36963893e-02f, -4.83970270e-02f, 9.49337408e-02f, 1.26343425e-02f, -1.47683576e-01f,
  1.29281729e-01f, 1.97277144e-01f, 2.74170846e-01f, 2.18908444e-01f, 1.22448318e-01f, -1.89983770e-01f, -2.37338871e-01f, -5.60315959e-02f, 3.03067565e-01f, 1.63270622e-01f,
  -2.56444141e-02f, -9.07234401e-02f, 4.12722528e-02f, -4.41057654e-03f, -1.74350679e-01f, 2.96423268e-02f, -2.18697622e-01f, -1.11113884e-01f, -1.43743515e-01f, -3.80012214e-01f,
  -6.46358728e-03f, -1.76685199e-01f, 1.72185704e-01f, 6.00225069e-02f, -1.70144043e-03f, 2.57245507e-02f, 5.40472418e-02f, 6.41900748e-02f, 3.84368524e-02f, -1.11231364e-01f,
  -1.21905275e-01f, -7.53220078e-03f, -7.06586540e-02f, 3.29185873e-02f, 1.38893975e-02f, 6.79510683e-02f, -7.15847686e-02f, -1.05088994e-01f, 8.09461325e-02f, -4.47362363e-02f,
  -1.59278512e-02f, -2.47068524e-01f, -1.80039987e-01f, 2.15625633e-02f, 3.90287787e-02f, 6.18907772e-02f, -3.51285972e-02f, -1.05413236e-01f, -3.82951126e-02f, -2.01667532e-01f,
  -1.65995117e-02f, -5.12078777e-02f, -5.24770394e-02f, -3.47201489e-02f, 4.01619077e-02f, -1.83028157e-03f, -3.93472202e-02f, -4.71573463e-03f, 2.90419627e-02f, -2.37584440e-03f,
  6.13006577e-02f, 9.56477877e-03f, -2.63426155e-02f, -4.09393981e-02f, -4.58523855e-02f, -3.08563579e-02f, -6.11978061e-02f, 5.96652832e-03f, 7.54811913e-02f, 1.01921773e-02f,
  5.27428240e-02f, -2.50120126e-02f, -3.24945850e-03f, -4.48249094e-02f, 4.82673058e-03f, -5.93787767e-02f, 8.95995796e-02f, 1.72280490e-01f, 7.56770968e-02f, 2.65071392e-02f,
  1.35840461e-01f, 9.21201259e-02f, 2.07523331e-02f, 9.25427116e-03f, -1.10752046e-01f, 5.03957383e-02f, -1.35170370e-02f, -5.48954457e-02f, -4.51784432e-02f, 6.80628465e-03f,
  4.55993786e-02f, 7.70557448e-02f, 1.15450509e-02f, -1.43571375e-02f, 2.23292224e-02f, -4.83419234e-03f, 1.92438420e-02f, -5.11245383e-03f, -1.01480568e-02f, -2.51162630e-02f,
  3.37240323e-02f, 5.07334545e-02f, 8.67367908e-02f, 7.86708370e-02f, 3.11421975e-02f, 4.37638909e-02f, 1.24143898e-01f, 9.23326835e-02f, 1.52485892e-01f, 8.67106169e-02f,
  8.90566409e-02f, -6.10703863e-02f, -5.26889153e-02f, 1.79407433e-01f, -5.15651740e-02f, -1.46939740e-01f, -4.32147980e-02f, 4.60189171e-02f, 2.19651058e-01f, -1.90552380e-02f,
  -1.74158067e-01f, -1.33444130e-01f, -1.44775167e-01f, -1.52333081e-01f, -1.48166403e-01f, 5.29141501e-02f, 3.18558700e-02f, -1.37400448e-01f, -9.65246558e-02f, -5.73889278e-02f,
  4.74299937e-02f, 2.06221923e-01f, 1.25156254e-01f, 1.49808899e-01f, 2.59555548e-01f, -6.46216469e-03f, 1.78766072e-01f, -3.49726677e-02f, -4.46170717e-02f, 9.12357047e-02f,
  5.06187715e-02f, -1.12526044e-01f, -5.58148287e-02f, -6.03235774e-02f, 1.31546818e-02f, 9.26883146e-02f, 8.84025469e-02f, 1.35375664e-01f, 2.62732413e-02f, 8.08139518e-02f,
  -1.46089224e-02f, -1.54543915e-04f, -1.14232779e-01f, 9.14274082e-02f, 2.99041495e-02f, 3.33180837e-02f, 3.12741916e-03f, 4.00148556e-02f, -4.09187190e-02f, 4.10245452e-03f,
  -2.16507376e-03f, -1.14288941e-01f, -1.87805414e-01f, -5.16449055e-03f, -1.93200782e-01f, -2.12055296e-01f, -1.13180965e-01f, -9.22169089e-02f, -4.87541333e-02f, 2.71000326e-01f,
  4.31137867e-02f, 4.19910178e-02f, -6.32567704e-02f, 5.73353767e-02f, -6.67555258e-02f, 1.74725242e-02f, 3.65271010e-02f, -4.39302251e-02f, -7.73571245e-03f, 1.06012151e-01f,
  -2.62634847e-02f, -6.78399485e-03f, 3.73209678e-02f, 9.43101593e-04f, 4.40342501e-02f, -6.85442537e-02f, -2.48691626e-02f, 2.77503356e-02f, -2.23085135e-02f, 1.41092520e-02f,
  1.17745893e-02f, -7.97459111e-02f, 8.16280693e-02f, 7.03421980e-02f, -4.45053056e-02f, -6.15905598e-02f, -2.49249935e-02f, -8.14565271e-02f, 5.57737541e-04f, 7.05896541e-02f,
  2.80321211e-01f, -3.30906332e-01f, 1.13679431e-01f, -1.99288055e-02f, 5.95699511e-02f, -8.21007229e-03f, -5.97887151e-02f, -7.05979317e-02f, -7.54024684e-02f, 3.94051857e-02f,
  -2.98647322e-02f, -9.00810678e-03f, 2.00385656e-02f, 1.47470525e-02f, 8.65058079e-02f, 1.34536792e-02f, -4.47423644e-02f, -7.26513043e-02f, -3.85413095e-02f, 4.34551574e-02f,
  1.87140517e-02f, 7.80348331e-02f, -5.02353497e-02f, 4.08528671e-02f, 6.00998895e-03f, -4.66245674e-02f, 7.30045363e-02f, 7.09856749e-02f, -9.24743786e-02f, 3.52095008e-01f,
  -1.59452766e-01f, -3.19487840e-01f, 4.09101605e-01f, -1.87058583e-01f, 9.89209190e-02f, 4.59075011e-02f, -2.12945193e-01f, -1.89733371e-01f, -2.28007421e-01f, -2.00573727e-01f,
  -9.37433839e-02f, 3.64991128e-02f, 7.26770684e-02f, -6.37179911e-02f, -1.52049184e-01f, -2.14769423e-01f, -1.27314121e-01f, 1.82331324e-01f, 9.71735492e-02f, -5.67568466e-02f,
  -9.34709087e-02f, -1.28114775e-01f, 5.27392104e-02f, -5.41392192e-02f, -5.38815325e-03f, 8.89831781e-02f, 3.99968810e-02f, 3.27386931e-02f, 8.91862437e-02f, 1.45757392e-01f,
  3.49487722e-01f, -9.47501287e-02f, 1.75071865e-01f, -2.04347521e-02f, 8.60031769e-02f, 6.83114678e-02f, -1.09308306e-02f, -1.77083649e-02f, -1.69460587e-02f, -5.67116104e-02f,
  -2.99741924e-02f, -3.08769867e-02f, -4.36442755e-02f, 8.71350020e-02f, -4.51036319e-02f, -1.02432712e-03f, -7.96496645e-02f, -9.09545496e-02f, -9.52740852e-03f, -6.43781200e-02f,
  -9.62656587e-02f, 7.76677951e-03f, 1.00780427e-01f, 4.17969041e-02f, -4.82222587e-02f, 9.36615244e-02f, 9.86163542e-02f, 1.22732855e-01f, 1.21098548e-01f, -9.57911238e-02f,
  -3.70091870e-02f, 5.34118153e-02f, -1.99239384e-02f, 1.43081825e-02f, -1.21670671e-01f, -8.30572285e-03f, 8.99662748e-02f, -5.41986637e-02f, -1.07569098e-02f, -1.32047506e-02f,
  -4.42787111e-02f, 5.15400209e-02f, -6.44508526e-02f, -4.76955110e-03f, 1.13755958e-02f, 4.13041376e-02f, -3.84469181e-02f, -4.41342257e-02f, 1.01232762e-02f, -1.45621235e-02f,
  9.51813068e-03f, -3.04438313e-03f, 4.53876145e-02f, 5.24406787e-03f, -4.93386425e-02f, -1.34435594e-02f, 1.46902716e-02f, 7.80117214e-02f, -3.62692513e-02f, 4.84944955e-02f,
  -1.63335040e-01f, 5.62410727e-02f, -6.89277309e-04f, -9.28822607e-02f, 5.32913245e-02f, -2.45683151e-03f, 5.53783141e-02f, 2.33704075e-02f, 1.59709360e-02f, -5.04943505e-02f,
  7.84500986e-02f, 3.15413252e-02f, 7.12752491e-02f, -2.66158711e-02f, 8.91949907e-02f, 4.55698371e-03f, -7.38754794e-02f, -5.56671666e-03f, 5.62892817e-02f, -1.79454088e-02f,
  -1.22040704e-01f, -9.24045667e-02f, -2.11539888e-03f, -2.23254878e-03f, -1.28762275e-02f, -1.48332054e-02f, 5.25574386e-02f, 5.91857582e-02f, 2.63948459e-02f, -1.20365776e-01f,
  5.02715886e-01f, -1.10324740e-01f, 2.43014004e-02f, 3.89758050e-02f, -1.11946270e-01f, 1.50043368e-01f, 2.73221314e-01f, 2.93862760e-01f, 7.15328828e-02f, -7.56874084e-02f,
  -9.18102488e-02f, -4.32829820e-02f, -4.57810946e-02f, 1.06210336e-02f, 2.79248625e-01f, 1.48601368e-01f, -5.40884957e-02f, 1.59055203e-01f, 1.47382975e-01f, 1.10257640e-01f,
  -1.40582204e-01f, -6.89513534e-02f, 6.30409718e-02f, 1.10126603e-02f, -2.47264564e-01f, -9.43481401e-02f, -1.69155061e-01f, -1.44751579e-01f, -1.53924718e-01f, -2.69071639e-01f,
  -3.09813738e-01f, 2.31316835e-01f, 2.05261521e-02f, -2.88064722e-02f, -1.87694356e-01f, -3.10469810e-02f, -5.91879040e-02f, -5.54227531e-02f, 1.20621333e-02f, 8.91898479e-03f,
  -9.54459310e-02f, -1.52381314e-02f, 1.08561814e-02f, -1.38701871e-01f, -3.16535681e-02f, -4.40956466e-02f, -5.52413613e-02f, 1.41956493e-01f, 4.14299145e-02f, 7.42722675e-03f,
  -1.57688469e-01f, -7.28499517e-02f, -3.53431026e-03f, -3.59188369e-03f, 1.28657416e-01f, -1.58533212e-02f, 9.12691746e-03f, 4.24717516e-02f, 9.38237160e-02f, -1.31537855e-01f,
  -2.95112263e-02f, -4.58436832e-02f, 4.49222773e-02f, 3.76866944e-02f, 1.44408876e-03f, -2.36445125e-02f, 1.32853640e-02f, -8.53591710e-02f, 3.21685188e-02f, -1.59624834e-02f,
  6.27741776e-03f, 1.94583442e-02f, 4.22084145e-02f, 6.16880432e-02f, -2.43171062e-02f, -7.64122084e-02f, 3.46417259e-03f, 6.64091762e-03f, -7.28384703e-02f, 7.13091940e-02f,
  -4.65989066e-03f, 2.55829226e-02f, -1.14732757e-01f, 1.29603753e-02f, 9.77133680e-03f, -1.22866984e-02f, 1.03744883e-02f, 5.81590272e-03f, -4.24927697e-02f, -2.03086045e-02f,
  -1.08280055e-01f, 2.53401875e-01f, -5.34415804e-03f, 6.27247766e-02f, -5.78809977e-02f, 8.16639289e-02f, 2.66721174e-02f, 6.40409067e-03f, -2.77635604e-02f, 3.40888128e-02f,
  5.02217598e-02f, 1.10515013e-01f, -2.37730332e-02f, 1.38422456e-02f, 1.89838558e-02f, 8.63651633e-02f, -3.95387933e-02f, -4.92377318e-02f, 1.02976926e-01f, -8.26647058e-02f,
  -6.12649918e-02f, 1.20708019e-01f, 8.06671306e-02f, 7.14881793e-02f, -7.54015297e-02f, 1.06575921e-01f, 3.20937857e-02f, 1.56250056e-02f, 2.49469668e-01f, 8.71872827e-02f,
  2.00701877e-02f, 6.60306364e-02f, -2.69687027e-01f, 2.14785011e-03f, -3.84911411e-02f, -1.92586303e-01f, -2.86561310e-01f, -1.09047621e-01f, 1.40139386e-01f, 2.49405745e-02f,
  8.09902623e-02f, 1.87834874e-01f, 4.91310768e-02f, 5.00264652e-02f, -2.28818119e-01f, -1.98296472e-01f, -2.13990211e-01f, -3.40813249e-01f, -2.24648640e-01f, -1.40738577e-01f,
  1.39792310e-02f, -8.10741633e-02f, -7.19188596e-04f, 1.06371343e-02f, 1.11975580e-01f, 1.23526528e-01f, 2.75899637e-02f, -4.54903878e-02f, 1.15384134e-02f, 7.43814334e-02f,
  -1.13834716e-01f, 1.19169161e-01f, -1.06118143e-01f, 4.40978259e-02f, 7.03607649e-02f, 2.64316425e-02f, -1.12153418e-01f, -7.13598579e-02f, -6.47802129e-02f, -5.15648015e-02f,
  5.51903620e-02f, -1.18151614e-02f, -2.70677134e-02f, 6.68494105e-02f, -9.85318273e-02f, -6.98493049e-02f, -3.63972895e-02f, -7.66388699e-02f, -4.03939746e-02f, -3.92044336e-02f,
  5.99591359e-02f, -1.62362158e-01f, -9.72220078e-02f, -1.13989353e-01f, 1.50795118e-03f, 6.27579121e-03f, 3.83184254e-02f, 5.75325117e-02f, -9.36976224e-02f, 8.76605511e-02f,
  -3.71151119e-02f, -7.19940104e-03f, -1.01443771e-02f, -1.68496389e-02f, 5.23384102e-02f, -4.91120890e-02f, 3.23139206e-02f, 4.54670712e-02f, -7.10759908e-02f, 1.99960824e-02f,
  8.26696828e-02f, -6.10521771e-02f, -2.46417783e-02f, -1.04079871e-02f, -2.17955504e-02f, -1.56017086e-02f, 5.69829484e-03f, -4.56466433e-03f, 3.33918706e-02f, 3.10007390e-02f,
  2.43996996e-02f, -2.46335790e-02f, -4.82207872e-02f, 9.05150920e-02f, 4.72734272e-02f, 1.15209278e-02f, -4.67459932e-02f, 4.64569181e-02f, -2.89416090e-02f, -1.91925950e-02f,
  2.80480951e-01f, -3.52001712e-02f, -3.40636261e-02f, -4.53369431e-02f, 1.78429950e-02f, 4.35279403e-03f, 1.18137106e-01f, -1.06541459e-02f, 5.38993478e-02f, -5.27563505e-02f,
  -3.41556258e-02f, -4.24753204e-02f, -8.07393692e-04f, -5.50696515e-02f, -7.99492560e-03f, 3.70819587e-03f, -7.31430128e-02f, -2.91321296e-02f, 4.25422192e-03f, 9.55649093e-02f,
  -1.92982261e-04f, -1.35446846e-01f, -1.50865242e-01f, -5.74726649e-02f, -3.61498557e-02f, -1.35150775e-01f, -1.11013740e-01f, -2.16044243e-02f, -4.06968072e-02f, -3.00824177e-02f,
  3.63263875e-01f, -2.92052105e-02f, 2.19021007e-01f, -1.31000997e-02f, 1.09884955e-01f, 9.90049765e-02f, 1.82652131e-01f, 2.43559596e-03f, -2.82351002e-02f, 1.52428355e-02f,
  -1.07744552e-01f, -1.76860541e-01f, -5.46283871e-02f, -3.59451398e-02f, 1.74374193e-01f, -1.81066822e-02f, 4.83887941e-02f, 2.26606488e-01f, 2.93836385e-01f, 9.74119753e-02f,
  1.30423093e-02f, 4.41169813e-02f, 1.84556484e-01f, 4.48173434e-02f, -1.73757344e-01f, -2.02710405e-01f, -8.50279331e-02f, -5.98041303e-02f, -6.76568747e-02f, -2.61078209e-01f,
  -1.30035788e-01f, 1.07588172e-02f, 8.30888301e-02f, 1.17556686e-02f, -3.13896164e-02f, -3.85795571e-02f, 9.70501304e-02f, 2.73128469e-02f, 5.51480316e-02f, -4.01399285e-02f,
  1.55981593e-02f, 4.21611071e-02f, -5.41296564e-02f, -1.26296520e-01f, -2.76062582e-02f, -4.34659570e-02f, -2.52928808e-02f, 1.63289923e-02f, -1.53008131e-02f, -2.20310166e-02f,
  5.50542725e-03f, 1.33545846e-01f, 2.08713382e-01f, -5.11283688e-02f, 2.57712211e-02f, 9.68018770e-02f, -7.08759651e-02f, -7.07693817e-03f, 5.74882627e-02f, -8.43409896e-02f,
  6.72778860e-03f, 4.49077301e-02f, -4.47185040e-02f, -1.27206454e-02f, -6.65173912e-03f, 9.46355425e-03f, -7.52206445e-02f, -2.17543193e-03f, -5.34271300e-02f, -3.12119462e-02f,
  -2.07250174e-02f, 7.00301165e-03f, 2.23419238e-02f, -6.30514277e-03f, -5.34094311e-02f, 1.77646317e-02f, 4.23557982e-02f, -5.53071648e-02f, 4.84103598e-02f, -4.28817095e-03f,
  -3.52224261e-02f, 6.63498789e-02f, -3.94885018e-02f, -4.23064381e-02f, 1.70894433e-02f, -2.42950842e-02f, -2.75948606e-02f, -9.05346647e-02f, -5.23125902e-02f, 9.19141024e-02f,
  -1.88011482e-01f, 2.50981033e-01f, -1.22477452e-03f, -8.53461400e-03f, -1.30507853e-02f, -4.58222218e-02f, -7.17235953e-02f, -8.74967221e-03f, -3.01109981e-02f, -4.31544846e-03f,
  -6.03306247e-03f, -1.17739048e-02f, 1.40057132e-02f, -2.67705508e-02f, 2.05444600e-02f, 9.88939311e-03f, -2.32843235e-02f, 5.26285879e-02f, 5.13020344e-02f, -6.89082965e-02f,
  1.95496343e-03f, 1.59787208e-01f, 1.85121864e-01f, 1.35415131e-02f, 4.52754162e-02f, 9.87606123e-02f, 5.34889139e-02f, 6.85155988e-02f, 1.33661792e-01f, 5.14694527e-02f,
  -6.08607590e-01f, -1.86520681e-01f, 2.78009865e-02f, -2.58524001e-01f, -6.96230233e-02f, -9.45567191e-02f, -1.85914993e-01f, -7.33549595e-02f, -2.31585056e-02f, -1.08833499e-01f,
  4.86507528e-02f, 1.32028490e-01f, 1.36176974e-01f, 1.03861831e-01f, 1.27490908e-01f, -1.53537706e-01f, 1.78641193e-02f, 1.29748490e-02f, 1.57359540e-01f, -4.60920073e-02f,
  -3.77345420e-02f, -8.18493143e-02f, -6.04194067e-02f, -1.07987188e-02f, -1.07058123e-01f, 5.61518408e-02f, 3.23231444e-02f, -5.37731424e-02f, 6.88922592e-03f, -1.05045386e-01f,
  -3.82412970e-02f, -2.83751398e-01f, 1.43742517e-01f, 2.94425413e-02f, 6.27167299e-02f, -6.25350326e-02f, -9.30895805e-02f, 3.54434699e-02f, 8.59014839e-02f, -9.70222130e-02f,
  8.02188441e-02f, -5.30760549e-02f, 2.40051374e-02f, -2.76287068e-02f, 4.29785401e-02f, -8.95844251e-02f, 9.69904009e-03f, 1.20664909e-02f, 1.49622736e-02f, 9.19043180e-03f,
  9.38228797e-03f, 9.25723091e-03f, -9.47605819e-02f, 1.77514125e-02f, 5.12356721e-02f, 3.98899429e-02f, -1.18031852e-01f, -1.51198879e-01f, -1.05982661e-01f, -2.97493130e-01f,
  -4.15642411e-02f, 1.17711453e-02f, 7.96123520e-02f, -8.98348168e-02f, -3.86125571e-03f, 8.50908533e-02f, 6.49142079e-03f, -4.25772965e-02f, 5.61158755e-04f, -6.56814838e-04f,
  5.26856668e-02f, 2.34422479e-02f, 1.07833243e-03f, -7.09639117e-02f, 8.78186375e-02f, -7.67278895e-02f, -1.19947996e-02f, 4.05855365e-02f, -7.75935454e-03f, 2.38453206e-02f,
  2.09552646e-02f, 4.09788266e-02f, 6.27130568e-02f, 8.75475034e-02f, 4.09474447e-02f, 3.57030332e-03f, -9.86571684e-02f, 1.92359947e-02f, 1.28764873e-02f, -3.25570405e-02f,
  -5.91846481e-02f, 2.75685579e-01f, -1.49742246e-01f, -2.39636060e-02f, -5.48383966e-02f, 4.70631905e-02f, 6.19160384e-02f, 2.16616900e-03f, 4.81694452e-02f, -7.28367493e-02f,
  5.72690293e-02f, -7.20947757e-02f, -7.82699957e-02f, 6.20267652e-02f, -4.78664227e-02f, 1.56652499e-02f, -1.04691528e-01f, -2.84935888e-02f, 1.11074992e-01f, -5.66310473e-02f,
  3.44424397e-02f, -3.99928950e-02f, -2.14228574e-02f, -3.55545357e-02f, -5.77666052e-02f, 5.07521555e-02f, -4.42532077e-02f, -4.91610430e-02f, -1.15144446e-01f, -2.61883318e-01f,
  3.96585673e-01f, 2.77293264e-03f, -5.68747520e-02f, 2.13730693e-01f, -2.42009178e-01f, -3.08959335e-01f, -3.03372622e-01f, 3.88275124e-02f, 2.02671289e-01f, -1.61631852e-01f,
  -1.93586871e-01f, -2.13855803e-01f, -1.65022939e-01f, -5.56692183e-02f, -5.97673543e-02f, 6.52369633e-02f, -2.83676982e-02f, 9.86130014e-02f, -6.11452051e-02f, -3.61468233e-02f,
  -1.51665673e-01f, 1.00868337e-01f, 1.96474493e-01f, 1.03879869e-01f, 2.04975620e-01f, -7.36736730e-02f, 6.67271614e-02f, -2.65532061e-02f, -2.76830886e-02f, 7.45653510e-02f,
  -2.59754449e-01f, 2.27511942e-01f, -6.48490787e-02f, -1.14923134e-01f, -6.50520772e-02f, -3.53403576e-02f, -5.43605611e-02f, -6.20492850e-04f, -3.84997539e-02f, 4.95317206e-02f,
  -1.40695199e-01f, -4.19576764e-02f, 5.65833151e-02f, 1.05868792e-02f, 5.19064851e-02f, -1.73430145e-02f, 1.16374008e-01f, 1.36747167e-01f, 1.03182212e-01f, -8.49121436e-02f,
  -1.39476210e-01f, -1.02591269e-01f, -7.86071196e-02f, 1.94048844e-02f, 1.22236237e-01f, -8.69563594e-03f, 1.69764925e-02f, 1.14489630e-01f, 3.26143056e-02f, 1.36141300e-01f,
  -2.12359447e-02f, 7.32415989e-02f, 1.34535087e-02f, -1.77631769e-02f, 3.80382501e-02f, -3.85086350e-02f, 2.40516290e-02f, -6.58874065e-02f, -5.60073853e-02f, 9.54192579e-02f,
  -1.64993778e-02f, -1.06035441e-01f, -9.29347996e-04f, 4.67891730e-02f, -6.81473000e-04f, 9.11048353e-02f, -1.04893804e-01f, 1.93019640e-02f, -3.74079347e-02f, -1.70051958e-02f,
  9.48532075e-02f, -1.84003916e-03f, -1.46405855e-02f, -2.58543883e-02f, -1.33557208e-02f, 4.08718884e-02f, 3.98693867e-02f, -1.04421545e-02f, 7.32148886e-02f, 6.63277432e-02f,
  5.75766824e-02f, -2.32325315e-01f, 7.52428500e-03f, 5.16349152e-02f, -2.71324534e-02f, 7.31656477e-02f, -1.21787250e-01f, 4.97403741e-03f, -2.68872431e-03f, -7.74668157e-02f,
  -9.18337777e-02f, 9.79875680e-03f, -3.76033112e-02f, -3.66612971e-02f, -8.40094835e-02f, -7.39666373e-02f, 4.23156423e-03f, -7.12434649e-02f, 9.83277615e-03f, 1.11849606e-02f,
  -1.33496360e-03f, -9.78875831e-02f, -9.95836686e-03f, -1.13494791e-01f, 4.59415391e-02f, -1.37663886e-01f, -7.06181973e-02f, -1.58312246e-02f, -5.31089418e-02f, -5.63068017e-02f,
  -3.77305239e-01f, -1.45573139e-01f, 2.97178626e-01f, -1.71177626e-01f, -8.85792896e-02f, 1.76346302e-01f, 1.76515743e-01f, 3.58249322e-02f, -1.35515809e-01f, 9.99362487e-03f,
  -2.01386660e-01f, -1.60322979e-01f, 2.19982509e-02f, -6.22452376e-03f, 1.30387217e-01f, 3.13775837e-01f, 2.93253332e-01f, 1.79819658e-01f, 1.00132287e-01f, -5.08891158e-02f,
  -1.09314956e-01f, -1.40377879e-01f, -1.23089984e-01f, 5.32697439e-02f, -1.20209746e-01f, -4.40191142e-02f, 5.14710434e-02f, -4.09814119e-02f, 9.12889838e-02f, 1.05745420e-02f,
  8.93258750e-02f, -3.01892370e-01f, 1.18754625e-01f, -2.10540012e-01f, 1.48377549e-02f, 6.07073233e-02f, 2.12260708e-02f, -1.73513293e-02f, -4.32617813e-02f, -2.38265153e-02f,
  -1.37451932e-01f, -5.42949103e-02f, -8.27224478e-02f, 7.04403175e-03f, -2.16552932e-02f, 5.04022613e-02f, 1.91677772e-02f, -6.29343465e-03f, 1.03670143e-01f, 1.69987027e-02f,
  -1.01617813e-01f, -1.86469257e-01f, 1.46333920e-02f, 9.22111515e-03f, 4.79722172e-02f, -1.64912436e-02f, 8.37911852e-03f, -4.09342907e-02f, 2.39500720e-02f, 1.80994030e-02f,
  2.95948912e-03f, 1.24616397e-03f, -1.25899781e-02f, -6.94521070e-02f, 5.16266115e-02f, -1.05822682e-02f, 3.36002558e-02f, -3.19256671e-02f, -4.40465882e-02f, -1.70144755e-02f,
  4.60597314e-02f, 4.38484251e-02f, 3.20369862e-02f, -2.54996102e-02f, 5.67127764e-02f, -8.12512264e-03f, 4.33910033e-03f, 7.58100450e-02f, 5.75658083e-02f, -8.34501535e-02f,
  5.20975236e-03f, 5.41190840e-02f, -6.24031648e-02f, 7.73836970e-02f, 7.87097737e-02f, 4.70920540e-02f, -2.10084319e-02f, -4.94289324e-02f, -8.46921429e-02f, 1.08908163e-03f,
  5.23531176e-02f, 1.39200598e-01f, -1.34562589e-02f, 2.11323518e-02f, 4.66606487e-03f, -1.16197327e-02f, 5.75511567e-02f, -5.90735748e-02f, -7.41108060e-02f, 9.72420126e-02f,
  -5.09884879e-02f, 1.16612259e-02f, 4.87492830e-02f, 3.77276652e-02f, 2.04440840e-02f, 2.36674417e-02f, -2.02841870e-02f, 3.30617316e-02f, 2.20294879e-03f, -4.90322299e-02f,
  -3.10058389e-02f, 8.84149596e-02f, 1.14356227e-01f, 6.86415657e-02f, 4.19965759e-02f, 1.54212400e-01f, 2.46399939e-01f, 1.42622188e-01f, 3.07834834e-01f, 2.35431686e-01f,
  -3.10060114e-01f, -2.31772527e-01f, -3.46323073e-01f, -1.10552356e-01f, 1.24675646e-01f, 9.53754708e-02f, 1.13654975e-02f, 1.20278396e-01f, 7.71428868e-02f, -1.00174360e-01f,
  -6.89913565e-03f, -5.11500053e-02f, -1.12222455e-01f, 3.97950113e-02f, -2.56125648e-02f, -1.94336995e-01f, -8.10286850e-02f, -6.03584908e-02f, 1.32631734e-01f, 2.25211129e-01f,
  2.26288229e-01f, 1.75894454e-01f, 4.20686603e-02f, 3.14560416e-03f, -3.67966294e-02f, 1.54631464e-02f, -1.04237035e-01f, -3.83500196e-02f, -7.90209770e-02f, 9.01347771e-03f,
  -3.20328236e-01f, -1.46670029e-01f, 1.06788136e-01f, 5.36260083e-02f, -2.71144621e-02f, -1.51410829e-02f, 2.26801471e-03f, -6.82448521e-02f, -7.17359036e-02f, -8.80369097e-02f,
  5.71694262e-02f, 7.40211606e-02f, 4.10342440e-02f, 5.80352060e-02f, 9.76458117e-02f, -1.69279017e-02f, 5.42007796e-02f, -7.35002160e-02f, -6.87468052e-02f, -3.27360928e-02f,
  1.05432875e-01f, -9.71575156e-02f, -1.72702491e-01f, 7.99199268e-02f, -5.89777268e-02f, -6.09441958e-02f, -1.11993343e-01f, 3.78055759e-02f, -3.83860841e-02f, -1.18737854e-02f,
  1.49577007e-01f, 1.98924970e-02f, 1.91588327e-03f, 3.38798650e-02f, -2.05454081e-02f, -1.31770119e-01f, 3.32988449e-04f, 7.95199908e-03f, 1.96761955e-02f, -1.45829944e-02f,
  -3.60182673e-02f, -5.19973114e-02f, -5.57868481e-02f, 7.41709769e-02f, -3.77318487e-02f, -3.48716304e-02f, 2.44384212e-03f, 2.59435009e-02f, -5.77071011e-02f, -2.67753955e-02f,
  4.34158556e-02f, -7.78151909e-03f, -3.08315153e-03f, -1.03266193e-02f, 2.83735432e-02f, -8.05801004e-02f, 6.18781447e-02f, -1.22407833e-02f, 2.08935812e-02f, -6.60252646e-02f,
  -2.03730706e-02f, -9.99626443e-02f, -5.53319342e-02f, -9.40265413e-03f, -2.52024699e-02f, 3.42177115e-02f, -7.15879211e-03f, 5.51004289e-03f, -2.38808692e-02f, 6.51495084e-02f,
  4.32420932e-02f, 2.87321862e-02f, -1.55016622e-02f, -6.98641874e-03f, 4.71528657e-02f, 7.26934075e-02f, 2.42749564e-02f, -5.31840473e-02f, -2.61203106e-02f, -8.20415467e-02f,
  8.22190642e-02f, 3.11909858e-02f, 1.77135300e-02f, -8.13341439e-02f, 3.95594612e-02f, -9.78217497e-02f, 3.71999368e-02f, 4.00932916e-02f, -3.99861336e-02f, 1.22208506e-01f,
  -2.55225599e-01f, -2.23543704e-01f, -2.92989314e-01f, -2.69750476e-01f, -6.90243989e-02f, -6.81986287e-02f, -7.04368651e-02f, -7.33400695e-03f, -2.13320982e-02f, -2.44455442e-01f,
  -1.10894926e-01f, 1.04669482e-01f, -3.72398384e-02f, 9.76971760e-02f, 1.91606060e-02f, -1.29809245e-01f, -1.34075686e-01f, 8.33177269e-02f, 1.89847350e-01f, 6.38548955e-02f,
  8.96111876e-02f, -3.59814093e-02f, 7.80595019e-02f, 6.03643507e-02f, -1.67227969e-01f, 3.96744087e-02f, -5.31153232e-02f, -4.84138168e-02f, -5.47558963e-02f, -2.36877024e-01f,
  -3.42145741e-01f, -1.99912712e-01f, 6.14868701e-02f, 8.58341157e-02f, 3.51759493e-02f, 5.58411367e-02f, -1.87438652e-02f, 1.10969111e-01f, 6.06300794e-02f, -1.18171662e-01f,
  -8.36248919e-02f, 8.14830735e-02f, 6.83550164e-02f, -4.80795093e-02f, -8.17118064e-02f, -7.29984120e-02f, 5.04192598e-02f, -5.12291044e-02f, -3.54640273e-04f, -8.53859782e-02f,
  1.24555845e-02f, 1.76408347e-02f, 3.59445252e-02f, 6.65076310e-03f, -4.17959690e-02f, 5.13521805e-02f, -9.55609232e-02f, -5.98831959e-02f, 4.71689329e-02f, -1.60880327e-01f,
  8.79561249e-03f, 9.92018078e-03f, 2.13810243e-02f, 6.10646829e-02f, 5.71783744e-02f, -1.28213298e-02f, -1.12292357e-02f, 2.20504552e-02f, -4.66455445e-02f, 9.73700732e-02f,
  -4.31322912e-03f, -6.54626042e-02f, -3.28276418e-02f, -2.10971758e-02f, -4.23591174e-02f, 4.63938713e-02f, -3.28841386e-03f, -6.95803016e-02f, 2.03180443e-02f, -4.17190865e-02f,
  2.22446378e-02f, 3.11976876e-02f, 3.17947306e-02f, -6.33020550e-02f, 3.52128297e-02f, -4.13468294e-02f, -3.58790047e-02f, 7.58004487e-02f, -1.39417183e-02f, 9.84062776e-02f,
  9.04860571e-02f, 2.51752585e-01f, -1.49717256e-01f, 1.09297018e-02f, -1.91635843e-02f, -5.06343842e-02f, -1.17416039e-01f, -6.01365138e-03f, -5.84900789e-02f, -7.98249617e-02f,
  5.21313362e-02f, -1.50354132e-01f, -7.17641562e-02f, -3.83614376e-02f, 9.15706083e-02f, -1.96150150e-02f, 1.91500597e-02f, 6.09399900e-02f, 6.77244291e-02f, -1.25420034e-01f,
  3.21759433e-02f, 1.05307676e-01f, 2.13410743e-02f, 3.26730907e-02f, 9.71412510e-02f, 1.62769496e-01f, 1.05122097e-01f, -1.91198271e-02f, 1.78317800e-01f, 1.20877922e-01f
};

// L0_fan_Wp_bar (Shape: 40 x 120)
const int L0_fan_Wp_bar_rows = 40;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  2.74219871e-01f, -5.86678740e-03f, -1.63282141e-01f, 1.56252012e-01f, -5.81926554e-02f, -1.97354287e-01f, -1.06108122e-01f, -1.25773638e-01f, 4.25172001e-02f, 1.39964283e-01f,
  1.36200041e-01f, 5.83970733e-02f, -4.85036671e-02f, -1.95487142e-02f, -1.33679390e-01f, -7.41412714e-02f, -1.15726506e-02f, 3.13803740e-02f, -3.14149968e-02f, 1.50153926e-02f,
  1.96051925e-01f, 6.95246011e-02f, 8.35976601e-02f, -3.95617634e-03f, 5.06831966e-02f, 6.08934984e-02f, -3.95392962e-02f, -2.93474295e-03f, 9.80243906e-02f, 2.78484404e-01f,
  1.73076123e-01f, 3.55747007e-02f, -1.27352089e-01f, 1.12693340e-01f, 1.49707766e-02f, -6.57373480e-03f, 3.59452516e-02f, -1.06147595e-01f, 1.93703305e-02f, 2.09974665e-02f,
  -1.64776817e-02f, -2.34196093e-02f, -9.75653902e-02f, -3.91794778e-02f, 7.08144382e-02f, -1.00026563e-01f, 4.63876985e-02f, -7.03222826e-02f, -8.04864317e-02f, 5.72332479e-02f,
  6.89210147e-02f, 1.58965901e-01f, -1.25739917e-01f, -1.61792979e-01f, -5.50655536e-02f, -8.99506509e-02f, -5.43644167e-02f, -6.78606033e-02f, -1.65869191e-01f, 1.29459515e-01f,
  -5.75813651e-02f, -7.78614497e-03f, 2.24199472e-03f, 5.94143458e-02f, -1.13478359e-02f, 4.76824753e-02f, -1.08345687e-01f, 4.66453433e-02f, -5.09605519e-02f, -3.81699987e-02f,
  -8.85491818e-02f, -8.19033310e-02f, -6.44546328e-03f, 1.26237562e-02f, 6.09040521e-02f, 4.75846902e-02f, -2.00935584e-02f, 3.03406850e-03f, 4.29539569e-03f, 5.49771227e-02f,
  8.73494148e-03f, -8.52729976e-02f, 7.28068724e-02f, -8.76725167e-02f, -2.24293512e-03f, -4.42936942e-02f, 2.55114995e-02f, 3.52337174e-02f, -4.50510010e-02f, 9.84430313e-02f,
  -3.06715053e-02f, -1.84924319e-01f, -4.49849758e-03f, -8.34894367e-04f, -5.61737269e-02f, 4.85082418e-02f, 3.14700902e-02f, 4.86681014e-02f, 3.58613841e-02f, -9.21964794e-02f,
  -3.10929250e-02f, 3.74142546e-03f, 3.58497947e-02f, -4.46595587e-02f, -4.74156160e-03f, 1.27992639e-02f, 1.33403437e-02f, 1.36684142e-02f, -6.25769794e-02f, 1.73772387e-02f,
  -2.36379337e-02f, -1.48394359e-02f, -1.10497810e-02f, -2.76429802e-02f, -1.17224883e-02f, -1.84262265e-02f, -2.23155878e-02f, -1.17803976e-01f, -8.37040320e-02f, 7.12646693e-02f,
  3.33831370e-01f, -1.62929413e-03f, -2.74267763e-01f, 1.53435484e-01f, -7.42855221e-02f, -1.82493806e-01f, -3.09387118e-01f, -9.78127420e-02f, 1.39427155e-01f, -8.46957639e-02f,
  6.09425008e-02f, -9.98180546e-03f, -6.94388002e-02f, -1.39470816e-01f, -1.46759570e-01f, -2.29335546e-01f, -1.58869565e-01f, -2.62962997e-01f, -1.57014742e-01f, -1.37430340e-01f,
  -1.10724278e-01f, -2.19823066e-02f, 3.95333320e-02f, 5.89213632e-02f, 9.14595425e-02f, 1.13237865e-01f, 1.33156367e-02f, -3.85956541e-02f, -8.52560773e-02f, 1.45506766e-02f,
  -8.93601552e-02f, 2.06222534e-01f, -5.72334304e-02f, 5.34875579e-02f, 8.75893980e-02f, 5.11139557e-02f, -4.53113765e-02f, 1.26204655e-01f, 7.68451951e-03f, 6.31797593e-03f,
  -1.82628687e-02f, 6.93656132e-03f, 3.86487842e-02f, 7.32732518e-03f, 5.24373986e-02f, -7.43349195e-02f, -3.51422727e-02f, -8.85782242e-02f, -9.51355249e-02f, -1.88011676e-02f,
  -6.31457865e-02f, 3.22020315e-02f, -7.29892552e-02f, 3.69161107e-02f, 2.74490137e-02f, 5.07791638e-02f, -2.91927438e-02f, -2.25660531e-03f, -9.24169347e-02f, 1.22996740e-01f,
  -1.34014711e-01f, -4.68638586e-03f, -1.08022736e-02f, -2.81521399e-02f, -1.74555220e-02f, 2.06450131e-02f, -1.49865204e-03f, -6.24904670e-02f, 2.29068752e-02f, -2.14001723e-02f,
  8.22763052e-03f, 5.00433482e-02f, 3.34671624e-02f, -4.68351543e-02f, -7.42144808e-02f, 3.54237147e-02f, -5.93303666e-02f, -1.12485856e-01f, -7.03311414e-02f, 1.84313357e-02f,
  1.96505263e-02f, 2.83791814e-02f, 8.31496194e-02f, -6.08323477e-02f, -5.67983650e-03f, -4.55289707e-02f, -8.32313970e-02f, 4.51451316e-02f, -2.64389887e-02f, 9.22343694e-03f,
  8.68674815e-02f, -1.69301420e-01f, -8.29936657e-03f, 8.64793584e-02f, -6.30513281e-02f, 3.76377553e-02f, 1.09794205e-02f, -4.39451747e-02f, 1.38322905e-01f, -2.91420538e-02f,
  -6.56251889e-03f, 2.73246481e-03f, 1.36492308e-02f, 4.98515740e-02f, -8.47451985e-02f, 1.69604807e-03f, 5.81664965e-02f, -3.82233970e-02f, -4.50699665e-02f, 4.18633642e-03f,
  4.30886410e-02f, -1.90174580e-03f, -5.60071468e-02f, 5.60194477e-02f, 7.36277327e-02f, -2.35618465e-02f, -2.02976372e-02f, -4.63471897e-02f, -6.08479045e-02f, -9.48234722e-02f,
  8.83271266e-03f, -1.45463794e-01f, -1.78434357e-01f, 2.55291760e-01f, 1.20822996e-01f, 1.19057193e-01f, -6.19973652e-02f, 7.09947646e-02f, 1.44458443e-01f, 1.94097638e-01f,
  1.89624444e-01f, 2.64249682e-01f, 1.55745149e-01f, 1.20492950e-01f, 8.49218741e-02f, 1.15046084e-01f, 1.02313515e-02f, 1.13761760e-01f, 1.02223769e-01f, 4.30298746e-02f,
  2.30456814e-01f, 7.53347129e-02f, -6.51537329e-02f, 5.22027500e-02f, 2.01325595e-01f, 1.38686121e-01f, -3.92913967e-02f, 9.03733373e-02f, -1.43342381e-02f, 2.24173799e-01f,
  1.18553620e-02f, -8.07544738e-02f, 1.48318484e-01f, 1.05862673e-02f, 7.34075159e-02f, -7.85984918e-02f, -1.04746848e-01f, -1.50016755e-01f, 1.98471323e-02f, -1.05818234e-01f,
  5.34703061e-02f, -3.28780040e-02f, -1.54740391e-02f, -1.14132322e-01f, -1.19033143e-01f, -3.62037867e-02f, -1.59597024e-01f, 1.03686936e-02f, -6.43075183e-02f, -3.56160541e-04f,
  1.70217350e-01f, -2.01407056e-02f, -9.65974033e-02f, -3.17074917e-02f, -1.13853747e-02f, 1.30945042e-01f, -1.56323880e-01f, 2.03648061e-02f, -1.65739104e-01f, 2.51990650e-02f,
  5.68936467e-02f, 3.58303450e-03f, 1.15885332e-01f, -5.91473170e-02f, 7.88213536e-02f, 1.88400336e-02f, 7.36672655e-02f, 4.22191247e-03f, -1.64905116e-02f, 5.95122762e-02f,
  8.31057690e-03f, 1.93069819e-02f, 2.47454103e-02f, 1.01799466e-01f, 1.49354590e-02f, 1.80639829e-02f, -2.84437314e-02f, -1.25198495e-02f, -3.18051875e-02f, -6.32186979e-02f,
  -4.06372845e-02f, 2.81371605e-02f, -1.71892643e-02f, -8.70216545e-03f, 1.74442101e-02f, 3.58064622e-02f, 1.45758456e-02f, -7.05052316e-02f, -2.66313683e-02f, 2.98884977e-02f,
  3.22959982e-02f, -5.06432168e-02f, 1.08327806e-01f, -4.46831025e-02f, -1.55783948e-02f, 3.82992849e-02f, 1.02332868e-01f, -7.49208853e-02f, 1.80814266e-02f, 1.10501610e-03f,
  -1.10606171e-01f, -6.07843511e-02f, -8.03963020e-02f, -3.40436175e-02f, -7.45683312e-02f, -7.12330714e-02f, -2.48272400e-02f, 3.59854922e-02f, 7.37737939e-02f, -8.75896066e-02f,
  -6.86283633e-02f, -6.82638660e-02f, -6.02182038e-02f, -4.66473661e-02f, 9.58268810e-03f, 1.47590652e-01f, -6.30128309e-02f, -1.00679509e-01f, -1.71936184e-01f, -1.16615459e-01f,
  1.98876530e-01f, 4.03837394e-03f, -8.11113566e-02f, 1.86120406e-01f, 2.50703227e-02f, -1.76349089e-01f, -8.52485970e-02f, -9.65910107e-02f, 4.84115705e-02f, 8.64844844e-02f,
  -1.20577849e-01f, 4.66146646e-03f, -9.66830105e-02f, -3.88843603e-02f, -1.12617455e-01f, -7.41062462e-02f, 9.79635790e-02f, 2.69932598e-02f, -1.45472556e-01f, -1.82782471e-01f,
  -1.16649203e-01f, -7.27305114e-02f, 7.21768886e-02f, -1.20703965e-01f, -6.21493533e-02f, 1.38217760e-02f, -1.19745275e-02f, -1.29977334e-03f, -1.33784518e-01f, 6.94082957e-03f,
  -2.03548625e-01f, -1.46495432e-01f, -3.52017507e-02f, -6.63937405e-02f, -6.67899847e-02f, 9.10612419e-02f, -1.08048907e-02f, 1.59616582e-02f, -7.49927983e-02f, 5.39670587e-02f,
  -1.23235889e-01f, -9.19964612e-02f, -6.80179894e-02f, -1.66535586e-01f, -8.49672183e-02f, 3.91304493e-02f, -1.42557099e-02f, -2.35372093e-02f, 1.21044100e-03f, -5.85551150e-02f,
  -1.27320275e-01f, -7.43515566e-02f, -7.09155947e-02f, -1.03400789e-01f, -5.40050939e-02f, -5.32618444e-03f, -8.58000591e-02f, -6.39612079e-02f, -7.05749616e-02f, 5.01353145e-02f,
  7.69500881e-02f, 1.09372877e-01f, -6.72162101e-02f, -8.83191228e-02f, 2.20815931e-02f, -3.86549011e-02f, -1.41858840e-02f, -7.63719017e-03f, 5.55812903e-02f, 9.58076268e-02f,
  -9.49735940e-03f, 1.49849812e-02f, -8.36494714e-02f, 7.59205967e-02f, 4.65843119e-02f, 2.35777125e-02f, 2.25624517e-02f, -4.54509109e-02f, 3.46653014e-02f, -6.78369030e-03f,
  -4.70486805e-02f, -3.84816155e-02f, 9.07343552e-02f, -3.15760784e-02f, -2.14262959e-02f, 2.62358654e-02f, 6.48977458e-02f, 1.98017415e-02f, -3.87740647e-03f, -6.94528446e-02f,
  1.51946470e-01f, 3.19273546e-02f, 1.64621230e-02f, 9.60283820e-03f, -4.36790399e-02f, -2.76368726e-02f, 5.39046749e-02f, -7.87389558e-03f, -5.51646985e-02f, 3.33558805e-02f,
  -4.97011654e-02f, -5.36168776e-02f, 1.93069484e-02f, -7.37035051e-02f, 8.22862461e-02f, -2.50477605e-02f, 1.13916509e-01f, 7.69180059e-02f, -9.47589502e-02f, -4.57604676e-02f,
  1.11725576e-01f, 1.30139917e-01f, 1.27683535e-01f, 8.39010328e-02f, 3.19942832e-02f, 4.43328246e-02f, 1.40945479e-01f, -3.99883538e-02f, 4.99675088e-02f, 3.29226911e-01f,
  1.27391323e-01f, -2.59682094e-03f, -9.01739150e-02f, 5.77836633e-02f, -1.67385817e-01f, -1.04168646e-01f, -1.18724301e-01f, -9.01560858e-02f, -2.74456516e-02f, -2.43032631e-02f,
  1.36407077e-01f, 2.09005669e-01f, 2.13744015e-01f, 1.62167430e-01f, 7.13434145e-02f, -8.24600831e-02f, -8.59455168e-02f, -1.68894511e-02f, 8.17591995e-02f, 7.00569525e-02f,
  -7.98354596e-02f, -4.69520967e-03f, -1.98012907e-02f, -7.67614841e-02f, -9.52077135e-02f, 8.84239282e-03f, -2.91905478e-02f, -5.70103116e-02f, 3.83529649e-03f, -7.11298659e-02f,
  3.32262009e-01f, -9.46904346e-02f, 1.03232987e-01f, -4.07080203e-02f, -9.67537686e-02f, 4.53335568e-02f, -4.09111120e-02f, -4.01353016e-02f, -9.16133448e-02f, -2.75632516e-02f,
  -1.25752063e-02f, -5.88216633e-02f, 7.07986057e-02f, -2.15181559e-02f, -4.84697260e-02f, -1.17472798e-01f, -2.75333244e-02f, -5.72144873e-02f, -1.05953865e-01f, -7.01934919e-02f,
  -7.04181939e-02f, -5.03275245e-02f, 8.19084793e-03f, -4.63119289e-03f, -6.79378211e-02f, 1.10446498e-01f, -3.69609334e-02f, 7.95698434e-04f, -7.25685954e-02f, -1.01956561e-01f,
  2.26434860e-02f, 1.20550185e-01f, 5.76431043e-02f, 2.88143400e-02f, -1.56750157e-02f, 2.89426427e-02f, 7.88294710e-03f, -5.44793569e-02f, -7.19239190e-02f, -6.94028735e-02f,
  3.61104421e-02f, -8.45659003e-02f, -3.25385714e-04f, 1.15800805e-01f, -3.25473472e-02f, -1.08573020e-01f, 1.88860316e-02f, 2.40520239e-02f, 4.76671085e-02f, -6.71660006e-02f,
  4.67486940e-02f, 3.07259597e-02f, -3.09421849e-02f, 1.42207956e-02f, -1.50598558e-02f, -2.75096297e-02f, -4.36743610e-02f, -5.83571866e-02f, -7.13692466e-03f, -7.57031671e-07f,
  2.45520100e-01f, 7.35342428e-02f, 1.20496556e-01f, 4.80933525e-02f, -9.09702107e-02f, -8.82296488e-02f, -2.77969940e-03f, -8.57390091e-02f, 4.34667766e-02f, 3.64990868e-02f,
  2.80700158e-02f, -1.12464689e-02f, 9.65665374e-03f, -6.83975369e-02f, 3.06537114e-02f, -1.87298778e-04f, -2.60457229e-02f, 9.62803438e-02f, 1.16858503e-03f, -2.39161551e-02f,
  -1.77286118e-01f, 9.76328179e-02f, 2.24457413e-01f, 1.34750336e-01f, 3.48680094e-02f, 1.71221569e-01f, 7.35804811e-02f, -2.84509640e-02f, 1.28321663e-01f, 6.76952079e-02f,
  1.77916899e-01f, 1.12795420e-02f, -2.42430404e-01f, -7.11376080e-03f, -7.59689882e-02f, -1.10204946e-02f, -1.46634266e-01f, -1.00593060e-01f, 3.97693701e-02f, 2.22372394e-02f,
  1.63834438e-01f, 1.00495599e-01f, -1.28496280e-02f, -9.83430445e-02f, -1.10154003e-01f, -1.30560352e-02f, -5.92725500e-02f, -1.50175810e-01f, -2.30585225e-02f, 2.37058606e-02f,
  1.72239125e-01f, 1.54132590e-01f, 1.08131636e-02f, -6.22684620e-02f, 1.29252836e-01f, 1.24202229e-01f, -3.32948975e-02f, 9.42941085e-02f, 6.11649780e-03f, -3.46267670e-02f,
  -2.34679226e-02f, -1.15680978e-01f, -4.34541851e-02f, 8.99688676e-02f, 7.45425373e-02f, -9.39198732e-02f, 1.00082373e-02f, -6.88829944e-02f, 5.10871485e-02f, -1.74650103e-02f,
  9.66784805e-02f, 5.91698699e-02f, -2.24663857e-02f, 7.43206292e-02f, 8.08162764e-02f, -3.96838039e-02f, -9.99957472e-02f, -1.82049632e-01f, -1.39016569e-01f, -2.57723667e-02f,
  5.58514707e-02f, 2.44054459e-02f, -9.68098119e-02f, -1.53035298e-01f, -1.21827953e-01f, 7.11164996e-02f, -3.32797468e-02f, -6.16514124e-02f, -1.62838906e-01f, 6.54363772e-04f,
  8.92711282e-02f, 1.81760788e-02f, -8.52723867e-02f, 1.99430306e-02f, 1.12951407e-02f, -4.62039374e-02f, -4.43820879e-02f, 9.26503316e-02f, 7.86585640e-03f, -2.79815421e-02f,
  9.57733672e-03f, -2.28412822e-02f, 4.93583642e-02f, -6.82204291e-02f, 9.00877360e-03f, 4.20453101e-02f, 1.06050381e-02f, 2.33553238e-02f, 3.88623103e-02f, 7.88695589e-02f,
  -8.59196298e-03f, 2.15032995e-02f, 5.48661649e-02f, -6.59227669e-02f, 2.14865319e-02f, -8.26007575e-02f, -3.44119370e-02f, 7.90503174e-02f, 2.39981730e-02f, 9.11606401e-02f,
  6.63963035e-02f, -9.30989310e-02f, 9.34343040e-02f, 4.32171188e-02f, -2.47684456e-02f, -2.40075942e-02f, 6.23329580e-02f, -3.82728688e-02f, 2.18957700e-02f, 2.79867761e-02f,
  -6.37593791e-02f, -1.99293457e-02f, 7.02658370e-02f, 4.30119177e-03f, 6.25078306e-02f, 4.27520238e-02f, 1.49660155e-01f, 1.64085422e-02f, -2.17176322e-02f, -2.35319827e-02f,
  -1.96570586e-02f, 4.05174884e-04f, 2.78337151e-02f, -1.00526728e-01f, -1.06568925e-01f, -1.35584222e-02f, -1.37214392e-01f, -6.53378293e-02f, -2.15081237e-02f, 5.90274818e-02f,
  9.32415202e-02f, 2.42487416e-01f, -4.79646660e-02f, -2.38395557e-02f, -1.32252306e-01f, -1.96736902e-01f, -6.24969043e-02f, 1.53193222e-02f, -5.95264509e-02f, 1.08108476e-01f,
  -5.24126925e-02f, -1.14279255e-01f, 1.86486659e-03f, -2.90085264e-02f, -3.44770625e-02f, 6.07762337e-02f, -8.25908966e-03f, -2.78171059e-02f, -2.27651596e-01f, -1.92006946e-01f,
  -6.70438483e-02f, -5.50747626e-02f, -2.30473420e-03f, -7.31593147e-02f, 1.19919263e-01f, 1.62878223e-02f, 5.91374598e-02f, 2.82848161e-02f, -6.01610467e-02f, 1.63520083e-01f,
  1.58919588e-01f, 3.12509686e-02f, -5.93623668e-02f, -2.78059803e-02f, 3.90315196e-03f, -3.52187939e-02f, -2.31372123e-03f, 2.22311057e-02f, -3.84132639e-02f, 3.84873599e-02f,
  -4.07321006e-02f, 7.54455850e-03f, -6.86280206e-02f, 1.62580749e-03f, -2.23518256e-02f, -1.16882827e-02f, -2.26070303e-02f, -5.28346300e-02f, -2.63956860e-02f, 5.43735698e-02f,
  6.87735528e-02f, -1.68284234e-02f, -7.41614699e-02f, -2.89349854e-02f, 3.66523229e-02f, -1.26775399e-01f, -4.89648990e-02f, 8.16231768e-05f, -5.23309037e-02f, 1.52576894e-01f,
  7.65516190e-03f, 1.34024844e-01f, -6.50936812e-02f, -3.06359753e-02f, -7.56885558e-02f, -5.83041720e-02f, -2.52489094e-02f, -1.01765767e-02f, -4.96605374e-02f, -3.47718485e-02f,
  1.05083406e-01f, 1.70543604e-02f, -7.08000138e-02f, 7.65914991e-02f, 3.96448821e-02f, 5.99577911e-02f, 3.00584864e-02f, 4.23848145e-02f, 6.98033068e-03f, -4.71528545e-02f,
  -6.90763677e-03f, 4.96596321e-02f, 2.67309025e-02f, -4.32586074e-02f, -2.41823420e-02f, -1.10276220e-02f, -2.64827013e-02f, -9.07521918e-02f, -8.42384771e-02f, 2.99026389e-02f,
  1.01841465e-01f, -2.83128977e-01f, 1.17648162e-01f, 9.14784521e-02f, 2.36217882e-02f, 1.08777266e-02f, -2.04722844e-02f, -8.69882235e-04f, 1.00346701e-02f, -4.34212238e-02f,
  -5.20590469e-02f, 3.03493906e-02f, 6.85938597e-02f, 6.93567768e-02f, -2.47336496e-02f, -6.76874593e-02f, 5.97937852e-02f, 6.54428378e-02f, 1.59644727e-02f, 7.15038106e-02f,
  9.32874829e-02f, 8.47574919e-02f, 6.17272146e-02f, -7.88664445e-03f, 4.73999344e-02f, -1.07194863e-01f, 4.24559377e-02f, -5.52532226e-02f, -9.43285897e-02f, 1.71869442e-01f,
  -3.23967487e-01f, -6.57695159e-02f, 3.32488976e-02f, 8.64709690e-02f, 1.14135295e-01f, 2.91700631e-01f, 1.68482035e-01f, 1.39906585e-01f, 2.04795688e-01f, -2.98645049e-02f,
  -8.29192698e-02f, 1.25010684e-01f, 1.10073596e-01f, 8.42195749e-02f, 1.60018191e-01f, 2.69099534e-01f, 2.95106053e-01f, 3.22471559e-02f, 2.58821100e-02f, 1.10536359e-01f,
  1.63606316e-01f, 7.93083906e-02f, -1.11905903e-01f, -1.52531033e-02f, 1.40541375e-01f, 8.89181122e-02f, -4.88155447e-02f, 1.01972260e-02f, -3.37604852e-03f, 6.57247379e-02f,
  -1.80484846e-01f, -2.75979042e-01f, 9.98371840e-02f, -3.37469317e-02f, -1.37225166e-01f, -1.10516243e-01f, -7.94707704e-03f, -8.35650489e-02f, -3.73084061e-02f, 1.01557046e-01f,
  -5.31307748e-03f, 6.00772118e-03f, 9.27452557e-03f, -1.88073404e-02f, -5.89319058e-02f, 1.76790461e-04f, -1.15557112e-01f, -3.14317606e-02f, 8.42445940e-02f, 5.85240237e-02f,
  9.19493672e-04f, -7.94420689e-02f, -7.16393515e-02f, 1.35248259e-01f, -3.92263569e-02f, 3.86228249e-03f, 4.62142117e-02f, -4.52894904e-02f, -6.70644194e-02f, 1.45949870e-02f,
  7.52196163e-02f, 5.75851696e-03f, -1.24223968e-02f, 8.05001184e-02f, -2.19868356e-03f, 7.72500113e-02f, 1.68740433e-02f, -1.14380019e-02f, 8.92934352e-02f, -3.49456072e-02f,
  -4.27985191e-03f, 4.10657935e-03f, -4.70461324e-02f, 4.80465367e-02f, 3.98009196e-02f, 4.48768362e-02f, -1.85015965e-02f, -4.09135409e-02f, -5.96138090e-02f, 2.38209628e-02f,
  3.34763639e-02f, -2.93548182e-02f, -1.42792329e-01f, 7.23142922e-02f, -2.90552266e-02f, -4.47613820e-02f, 3.10555920e-02f, -5.89567460e-02f, 3.75488251e-02f, -1.44653479e-02f,
  1.37088686e-01f, -2.70203017e-02f, 7.98377916e-02f, -2.42735501e-02f, 4.63330075e-02f, -9.37153026e-02f, -2.04193220e-02f, -9.82836913e-03f, 3.96232773e-03f, 6.20539337e-02f,
  -9.85739827e-02f, -8.94219726e-02f, -2.13908628e-02f, -3.18095125e-02f, 7.07964897e-02f, -4.48475778e-02f, -6.31190240e-02f, 3.13305520e-02f, -1.19902147e-02f, -6.69422373e-02f,
  1.36353239e-01f, 1.83693692e-02f, 5.31242006e-02f, 1.11797214e-01f, 4.12451988e-03f, 9.59259495e-02f, 3.11378017e-02f, -4.18169908e-02f, 5.85740432e-02f, 4.03898302e-03f,
  3.64924222e-01f, 3.07587445e-01f, 2.20641389e-01f, 8.41509104e-02f, 1.55305132e-01f, 3.54355156e-01f, 3.38404745e-01f, 1.69729099e-01f, -4.65260539e-03f, 1.19842798e-01f,
  2.01101631e-01f, -1.55826613e-01f, -2.29466110e-02f, -9.96511579e-02f, -5.12772575e-02f, -9.29495841e-02f, -2.05509155e-03f, -6.40257820e-02f, -1.66115817e-02f, 2.39242259e-02f,
  -1.18826978e-01f, 2.73644067e-02f, 1.16674751e-01f, 2.99798474e-02f, -1.40381098e-01f, -1.46035954e-01f, 5.46548441e-02f, 1.67965025e-01f, 3.82520519e-02f, -8.84389654e-02f,
  -2.05431897e-02f, 4.28585261e-01f, -1.98674217e-01f, -1.03619538e-01f, 1.36456519e-01f, -4.47837785e-02f, 5.60033619e-02f, -2.87474301e-02f, 5.14928550e-02f, -1.18840374e-02f,
  6.89917756e-03f, -6.19213209e-02f, 2.74735428e-02f, 1.61631517e-02f, 1.51770815e-01f, -3.92711675e-03f, 4.22544591e-03f, -4.14366834e-02f, -2.06021201e-02f, 2.39153914e-02f,
  1.33206192e-02f, 1.33653611e-01f, 2.00446934e-01f, 5.49901556e-03f, 4.80747484e-02f, 2.79383808e-02f, 1.57583579e-01f, 5.79539239e-02f, 1.08887106e-01f, -2.88565159e-02f,
  -9.24605727e-02f, 5.03138527e-02f, 1.09492324e-01f, -2.65924465e-02f, -8.76955222e-03f, -4.80502360e-02f, -4.85840440e-02f, -2.46144533e-02f, 3.14933173e-02f, 4.73797284e-02f,
  4.06239927e-02f, 2.48301448e-03f, 1.12838419e-02f, -3.75994295e-02f, -1.52523499e-02f, 7.14277774e-02f, 5.34394793e-02f, -1.37501722e-03f, 5.23328967e-02f, -1.83916162e-03f,
  9.23618525e-02f, -1.45023568e-02f, 1.31845891e-01f, 5.49602099e-02f, -4.68287840e-02f, -2.49835625e-02f, 1.62043832e-02f, -2.10944097e-02f, 1.53773297e-02f, 1.57789160e-02f,
  -2.46426929e-02f, 1.86022177e-01f, -2.51357257e-01f, -2.20875069e-01f, 6.36043176e-02f, -3.70043740e-02f, -3.27352695e-02f, 4.66945115e-03f, 2.58398429e-02f, -8.87254253e-02f,
  -1.37393770e-03f, -2.73830071e-02f, 3.06422859e-02f, -1.82764372e-03f, -2.77362112e-02f, -4.78969999e-02f, -5.10538183e-02f, 1.56293865e-02f, -4.46377248e-02f, -7.90133774e-02f,
  -2.78820265e-02f, -1.42786177e-02f, -8.89240801e-02f, -1.45655870e-02f, -1.48039043e-01f, -7.52639845e-02f, 1.29648000e-02f, -6.69556782e-02f, 5.20576760e-02f, -1.73047200e-01f,
  -2.35119872e-02f, -2.98664749e-01f, -1.64348751e-01f, -1.90476283e-01f, -1.16759710e-01f, -6.71641454e-02f, -1.66029751e-01f, -6.05364442e-02f, -1.15811564e-01f, -1.56421289e-01f,
  -1.80216029e-01f, -2.04265099e-02f, -2.23392844e-02f, 1.03898600e-01f, 1.16222844e-01f, -1.14551924e-01f, -4.72327657e-02f, 4.67282422e-02f, 2.05565959e-01f, 5.46273403e-03f,
  -3.61923613e-02f, -4.31679673e-02f, 1.70980260e-01f, 6.22701310e-02f, -1.78909600e-01f, -5.72132878e-02f, -1.62972629e-01f, -5.60540222e-02f, -7.25860596e-02f, -2.07720622e-01f,
  -9.92332771e-02f, -9.18009877e-02f, 9.68887061e-02f, 3.01139243e-02f, -5.83061501e-02f, -2.61616204e-02f, -5.91424629e-02f, 5.26125692e-02f, 9.39930826e-02f, -9.16747823e-02f,
  3.76184508e-02f, 1.43014370e-02f, -1.32095134e-02f, -6.60254732e-02f, 1.48577420e-02f, 1.85935963e-02f, -4.66974452e-02f, 6.90490473e-03f, 7.30740502e-02f, -4.55044098e-02f,
  -5.02180234e-02f, 6.97958050e-03f, -8.13673586e-02f, 7.20561817e-02f, 1.62700173e-02f, 1.04003012e-01f, -1.60153571e-03f, -5.59429601e-02f, 5.98086156e-02f, -1.55382127e-01f,
  -4.00099419e-02f, -2.97274478e-02f, -3.44846174e-02f, 4.27934295e-03f, -5.31747052e-03f, 2.33313302e-03f, -4.92115133e-02f, 8.57559219e-03f, 1.69055723e-02f, 1.46142645e-02f,
  3.21497326e-03f, -4.99417000e-02f, 4.70874757e-02f, -5.67346066e-02f, -1.87535658e-02f, 2.63983738e-02f, -5.72000630e-02f, 4.08005640e-02f, 5.57828248e-02f, 4.83920388e-02f,
  -3.94905172e-02f, -7.48785120e-03f, -4.33548875e-02f, 4.92984578e-02f, -3.29995900e-02f, -4.45139743e-02f, -1.88559946e-02f, 1.05895706e-01f, -2.17288872e-03f, 2.77990066e-02f,
  7.18672900e-03f, 1.69989541e-01f, -1.24770068e-01f, 9.65474844e-02f, 7.38346716e-03f, 5.67938350e-02f, -4.94176820e-02f, 2.27845565e-04f, -7.23401159e-02f, -3.89096476e-02f,
  8.71273316e-03f, 5.91364652e-02f, -1.14504881e-01f, 7.58757517e-02f, 4.74714898e-02f, 6.40203953e-02f, -9.04085860e-02f, -1.02529125e-02f, -3.85372117e-02f, -1.32356901e-02f,
  -8.18636641e-02f, -8.06084648e-02f, -3.33692618e-02f, -9.14310589e-02f, -6.79429248e-02f, -3.96182202e-02f, -1.05318382e-01f, -1.01890214e-01f, -7.61695951e-02f, -9.49497819e-02f,
  -1.79189458e-01f, -1.00314384e-02f, 2.90569812e-02f, 4.98542469e-03f, -7.28393942e-02f, -2.74927057e-02f, 3.14668827e-02f, -1.03099227e-01f, -9.52248648e-02f, -4.65858206e-02f,
  2.53506918e-02f, -4.91703562e-02f, 7.88523480e-02f, 5.12717338e-03f, -7.68627077e-02f, 2.59672683e-02f, 3.94672342e-02f, -2.52839201e-03f, 2.93626245e-02f, 3.84933166e-02f,
  -2.04286519e-02f, 5.21089844e-02f, -3.73389125e-02f, -1.23314857e-02f, 5.90036549e-02f, 1.05093196e-01f, 1.43599361e-02f, 1.04067877e-01f, 7.52139511e-03f, -2.18934193e-02f,
  1.50423005e-01f, -1.65778049e-03f, -5.25088534e-02f, -4.00445461e-02f, 5.91000170e-02f, -7.00645074e-02f, -2.90317312e-02f, -1.55485701e-02f, 7.50658289e-02f, 7.62953982e-02f,
  4.70868498e-02f, 4.58447114e-02f, -5.89749888e-02f, -2.95376237e-02f, 6.19870285e-03f, -1.04726665e-02f, 4.00691405e-02f, -1.19314082e-01f, -6.56880066e-02f, -5.89919882e-03f,
  2.54514683e-02f, 5.31819761e-02f, -2.11878605e-02f, 6.91397581e-03f, 5.75783737e-02f, -6.87000901e-02f, -2.36123316e-02f, 1.31610446e-02f, -3.62126678e-02f, 5.43322712e-02f,
  8.78532305e-02f, 3.89776975e-02f, 4.85193841e-02f, 9.61481556e-02f, 9.71754417e-02f, 4.97493939e-03f, -5.36308885e-02f, 3.63270752e-02f, 5.40869869e-02f, 8.48728865e-02f,
  -4.78727147e-02f, -2.64777578e-02f, 1.09652221e-01f, 8.32406804e-02f, 8.42481330e-02f, 6.11440726e-02f, -7.04302788e-02f, -3.70855108e-02f, 6.92091137e-02f, 7.38174021e-02f,
  -3.82111520e-02f, 1.51165444e-02f, -4.07320708e-02f, -4.41249423e-02f, -2.63255904e-03f, 1.56527981e-02f, 7.47152120e-02f, 3.03965323e-02f, 6.84052631e-02f, 7.51195103e-02f,
  9.29069892e-02f, -1.22688346e-01f, 4.36681621e-02f, -9.50779095e-02f, -1.47922048e-02f, 2.85942983e-02f, 3.52698639e-02f, -5.02469391e-02f, -6.26163408e-02f, 4.84316461e-02f,
  5.03304079e-02f, -1.87934504e-03f, 7.46074915e-02f, -6.95786700e-02f, -4.31844443e-02f, 5.60060181e-02f, -7.47453198e-02f, 6.33442998e-02f, -1.12933472e-01f, 6.62692338e-02f,
  4.43580598e-02f, -3.82501259e-02f, 5.39212972e-02f, 1.57149434e-02f, -5.47524691e-02f, -7.59548768e-02f, 6.22533225e-02f, -5.12095634e-03f, 1.69057101e-02f, -4.28526402e-02f,
  -5.19250035e-01f, 9.91405100e-02f, -1.13088779e-01f, 1.17152566e-02f, 3.35179597e-01f, 8.91564488e-02f, 2.12113217e-01f, 8.76390142e-04f, 6.63948664e-03f, 4.51839603e-02f,
  9.49515179e-02f, 1.52042452e-02f, 2.68146787e-02f, 5.22508398e-02f, -5.94535805e-02f, 5.96244223e-02f, 2.29077831e-01f, 9.01594851e-03f, -1.98586777e-01f, -1.45525560e-02f,
  2.12075800e-01f, -3.01378518e-02f, -1.38667434e-01f, -5.69234192e-02f, 2.08243132e-01f, 2.35344656e-02f, -4.53262068e-02f, 9.46546420e-02f, 9.98013690e-02f, 1.99422792e-01f,
  -2.85496503e-01f, -2.55827665e-01f, -5.50418869e-02f, 1.77200686e-03f, -4.57653664e-02f, -6.95902854e-02f, -1.21401250e-01f, -7.32613504e-02f, -5.03594615e-02f, -1.37923360e-01f,
  3.46013866e-02f, 1.77411176e-02f, 3.67471576e-02f, 1.36766266e-02f, -1.44021317e-01f, -3.62387076e-02f, -9.58041027e-02f, -2.13115454e-01f, -1.42078698e-01f, -5.61364107e-02f,
  1.07569844e-01f, 5.78644387e-02f, -1.75935209e-01f, -7.64490366e-02f, -1.42781809e-01f, -1.53017581e-01f, -7.72259459e-02f, -1.21956781e-01f, -2.44685233e-01f, -2.49023408e-01f,
  -2.50351187e-02f, 1.46043543e-02f, -7.64583200e-02f, -3.64656709e-02f, -1.17025636e-02f, 7.80633986e-02f, 9.45217311e-02f, 7.68812224e-02f, 2.67633260e-03f, -3.18142306e-03f,
  2.25969162e-02f, -5.59127331e-02f, 1.57085508e-02f, -5.52572086e-02f, 7.79702663e-02f, 1.63292827e-03f, 4.03540768e-02f, 7.22275153e-02f, -6.71634674e-02f, -5.73210604e-02f,
  1.72154810e-02f, -5.40618338e-02f, -5.10167815e-02f, 6.31911587e-03f, 5.27608991e-02f, -4.91416231e-02f, 4.74726185e-02f, -9.82234031e-02f, -7.67104924e-02f, -5.01734205e-02f,
  -1.97429493e-01f, -1.26903027e-01f, -1.47148818e-01f, 3.22183184e-02f, 3.55823226e-02f, -1.03957333e-01f, 3.74875255e-02f, -1.07689753e-01f, -4.52246666e-02f, -5.36372662e-02f,
  1.52862519e-02f, -1.15155578e-01f, -5.49906529e-02f, 3.36659364e-02f, -1.16683558e-01f, -6.82403073e-02f, 9.95080099e-02f, 2.23847665e-02f, -2.55229492e-02f, -5.15249409e-02f,
  -3.10579631e-02f, -4.81361747e-02f, -2.04111412e-01f, -1.22956291e-01f, -7.73494504e-03f, -3.43274698e-02f, -1.80414185e-01f, -2.35591024e-01f, -1.92945108e-01f, -2.20114306e-01f,
  9.63916779e-02f, -1.49509147e-01f, -3.85381142e-03f, 1.37722731e-01f, 2.50423193e-01f, 1.28638178e-01f, 8.23341236e-02f, 1.47468895e-01f, 1.25413880e-01f, -1.43627021e-02f,
  -8.83322675e-03f, -1.29821181e-01f, -2.69360300e-02f, -1.35319263e-01f, -1.36392117e-01f, 7.60365203e-02f, 1.17461979e-01f, 7.62037709e-02f, 1.28179535e-01f, 2.48567145e-02f,
  6.73040897e-02f, 2.10713204e-02f, 1.07963765e-02f, -7.84995686e-03f, 3.74998562e-02f, 6.07502759e-02f, 9.87547487e-02f, 3.94415446e-02f, 1.60248224e-02f, -1.11235017e-02f,
  -8.36019218e-02f, 1.82891209e-02f, 6.56521171e-02f, -1.24784775e-01f, 4.96498719e-02f, -1.08261190e-01f, 9.40910104e-06f, -6.11525327e-02f, -4.48613316e-02f, -9.80237871e-02f,
  5.26130237e-02f, 2.83514746e-02f, 9.24522243e-03f, -3.00187301e-02f, -3.23663093e-02f, -5.72964661e-02f, -1.26529187e-01f, 3.77677567e-02f, -8.82921889e-02f, -1.09651528e-01f,
  -1.32307597e-02f, -6.89952150e-02f, 2.76107676e-02f, -7.52585148e-03f, -9.64771658e-02f, -1.63498372e-02f, -1.01459101e-01f, -3.84604558e-02f, -5.44314794e-02f, -5.83708808e-02f,
  3.83037850e-02f, 2.45607048e-02f, 2.20343973e-02f, -7.70923942e-02f, -2.91264653e-02f, 9.85661224e-02f, 7.88488165e-02f, 5.79724498e-02f, 2.19168887e-02f, 8.79545510e-02f,
  3.63452621e-02f, -4.09412384e-02f, 6.82061911e-02f, 6.66994676e-02f, -1.53409112e-02f, 1.94831900e-02f, 4.72528674e-02f, -1.45636052e-02f, -3.04109920e-02f, -3.92306829e-03f,
  -4.74367104e-02f, -2.76895072e-02f, 1.04146870e-02f, -4.99541909e-02f, -7.34075606e-02f, 2.16938928e-03f, 2.98562590e-02f, 7.23109990e-02f, 1.52885625e-02f, -4.95747849e-02f,
  7.93286413e-03f, 6.51935041e-02f, 3.33116800e-02f, 4.31359783e-02f, 9.93030295e-02f, 1.02794804e-02f, 8.51180404e-02f, -7.44715752e-03f, -4.74420078e-02f, -4.44976501e-02f,
  6.04439527e-02f, -4.46833186e-02f, -7.88827389e-02f, -2.43949816e-02f, 1.83404554e-02f, 4.86273207e-02f, 6.25962168e-02f, -2.91177053e-02f, -5.94008975e-02f, -4.00718339e-02f,
  -4.10501398e-02f, 1.74791753e-01f, 1.24416001e-01f, -1.52380280e-02f, 1.06417332e-02f, 9.27977785e-02f, -2.81396136e-02f, 4.91178222e-02f, 1.25330508e-01f, 6.52335584e-02f,
  1.36247620e-01f, -2.15725884e-01f, -3.61514241e-01f, -1.39769837e-01f, -1.64939910e-01f, -2.94759244e-01f, -2.91235298e-01f, -1.04694404e-01f, -6.55663982e-02f, -2.24369839e-01f,
  -3.09181102e-02f, 1.25335038e-01f, 6.64507598e-03f, -9.48617086e-02f, -7.58587793e-02f, -3.33534747e-01f, -3.73366535e-01f, -2.53606766e-01f, -1.28061995e-01f, -9.80802476e-02f,
  -5.78121841e-02f, -1.12704478e-01f, -9.56548899e-02f, -1.91252723e-01f, -2.00238869e-01f, -1.15379609e-01f, -1.76740512e-01f, -1.55703127e-01f, -2.96451271e-01f, -3.69842529e-01f,
  -1.81297481e-01f, 3.47248912e-02f, 4.53668460e-02f, 7.17364028e-02f, -6.30011410e-02f, -4.17045802e-02f, 4.55364138e-02f, 2.19240412e-02f, 1.25718176e-01f, -6.86782524e-02f,
  1.58797309e-03f, 4.45911698e-02f, 2.40836828e-03f, -8.64350644e-04f, -4.79302704e-02f, -1.38419308e-02f, -3.24939638e-02f, -4.30142656e-02f, -4.18718755e-02f, 4.44752313e-02f,
  -8.99355486e-02f, -4.91429120e-02f, -2.82394402e-02f, -7.82506540e-02f, 4.61678766e-03f, 8.60178024e-02f, -1.05488144e-01f, 3.35104093e-02f, -8.09822325e-03f, -8.34519491e-02f,
  -8.11038315e-02f, -3.70626226e-02f, -3.00666504e-02f, -9.23884450e-04f, -5.00731915e-02f, -6.43664412e-03f, 3.82938869e-02f, 3.91007513e-02f, 8.52968469e-02f, -1.07888475e-01f,
  -2.35028677e-02f, -3.67040077e-04f, 9.86226369e-03f, 5.95439970e-03f, 2.48594768e-03f, 1.19666243e-02f, 3.59304771e-02f, 2.02718098e-02f, -3.66499908e-02f, 3.68725844e-02f,
  1.66148543e-02f, -2.75831670e-02f, -4.54349592e-02f, -3.14485431e-02f, -5.29560558e-02f, -8.95893648e-02f, -2.85616075e-03f, -1.20978644e-02f, -7.52423052e-03f, 9.41492170e-02f,
  1.82514638e-01f, 4.91716489e-02f, 9.56794713e-03f, 8.87560397e-02f, 2.04468537e-02f, 6.39333427e-02f, 3.53681371e-02f, -4.43023108e-02f, 5.41365519e-02f, 5.85894175e-02f,
  2.40162034e-02f, 6.00293092e-02f, 5.52993454e-02f, 5.44610210e-02f, -4.66943160e-02f, 4.43700701e-02f, -5.09533212e-02f, 1.63215213e-02f, 1.92807522e-02f, -1.71346255e-02f,
  -1.54892266e-01f, -1.60941891e-02f, 2.11762130e-01f, 2.29345355e-02f, 2.70322245e-03f, 9.98187885e-02f, 3.31434794e-02f, 1.12706646e-01f, 7.69156031e-03f, 1.06309257e-01f,
  6.20450042e-02f, -7.05362707e-02f, -2.13435218e-01f, 7.14111850e-02f, -4.56766710e-02f, -1.18307143e-01f, -1.45604894e-01f, -9.59458351e-02f, -7.00896755e-02f, -6.13050535e-02f,
  -5.60457148e-02f, -5.68782352e-02f, -9.13024992e-02f, -5.66897616e-02f, -1.95083112e-01f, -2.50518322e-01f, -2.29091480e-01f, -1.72253460e-01f, 3.37988846e-02f, 2.06472166e-02f,
  1.71337619e-01f, 1.46628097e-01f, 6.95903599e-02f, -5.13625145e-02f, -5.17414659e-02f, -4.25405204e-02f, -1.59856349e-01f, 1.99744254e-02f, -7.40611106e-02f, 8.90507363e-03f,
  -2.30160385e-01f, -1.24222234e-01f, 7.11803809e-02f, -2.15420919e-03f, -5.90843754e-03f, -3.53064723e-02f, -6.07356615e-02f, -5.59656844e-02f, -7.59955794e-02f, -1.31504640e-01f,
  -7.58550828e-03f, 4.95959036e-02f, -4.61104326e-02f, 4.91295978e-02f, -7.37396330e-02f, 5.86034879e-02f, -6.07228875e-02f, -1.51919559e-01f, -4.28436436e-02f, 4.91665415e-02f,
  6.70255795e-02f, -6.07796982e-02f, -7.15505183e-02f, -1.02847822e-01f, -1.50906056e-01f, -5.92211485e-02f, -1.32908866e-01f, -1.10189132e-01f, -1.40655026e-01f, 2.89597344e-02f,
  -2.07670182e-02f, 3.10829811e-04f, -5.08536100e-02f, -3.97879370e-02f, 8.19265470e-02f, -1.41271073e-02f, -4.60391976e-02f, 6.84937043e-03f, -4.60272208e-02f, 5.55796921e-03f,
  4.88538109e-02f, -4.02847640e-02f, 8.11741650e-02f, 2.24927645e-02f, -7.88920745e-02f, 8.66986997e-03f, -3.73216122e-02f, -3.60271446e-02f, -6.87425658e-02f, 3.94358719e-03f,
  -3.44024301e-02f, -6.59438297e-02f, 6.68500736e-02f, -2.85580289e-02f, 2.76090717e-03f, -7.35980347e-02f, -1.46810859e-02f, -3.14610936e-02f, 4.40222546e-02f, -9.65207294e-02f,
  -2.73851454e-02f, -2.96498165e-02f, -8.01018625e-02f, -1.01634026e-01f, 1.70855131e-02f, 3.19721252e-02f, 4.00102250e-02f, -4.88715693e-02f, -9.04946178e-02f, -9.33676213e-02f,
  1.45534435e-02f, -4.54617031e-02f, -4.65391651e-02f, 3.84852216e-02f, 2.71996334e-02f, -2.56783590e-02f, 7.91697279e-02f, -6.16638102e-02f, 4.05254290e-02f, -4.09501642e-02f,
  -3.83588225e-02f, -1.11165904e-02f, -1.18661627e-01f, -1.09299347e-01f, -4.99992296e-02f, -7.63908029e-02f, -1.34260818e-01f, -5.67778870e-02f, -6.23665601e-02f, 9.84704643e-02f,
  3.75154346e-01f, 6.37207776e-02f, -2.85460297e-02f, 1.27856642e-01f, -1.88193053e-01f, -9.89029035e-02f, -4.12476063e-02f, -4.41218950e-02f, -5.18097803e-02f, 1.35730401e-01f,
  7.49126971e-02f, 8.60545039e-02f, -6.03022799e-03f, 9.05914456e-02f, -6.29996285e-02f, 1.24613568e-02f, 2.86414158e-02f, 5.49379438e-02f, -9.96949673e-02f, 1.87408086e-02f,
  2.46244036e-02f, 4.67009917e-02f, 1.27736643e-01f, 9.72423777e-02f, -4.26751226e-02f, 8.20758194e-02f, -3.81836155e-03f, -4.44131233e-02f, 6.02266602e-02f, 1.72939286e-01f,
  3.97907523e-03f, 2.17610337e-02f, -1.44176528e-01f, 6.83312267e-02f, -3.96625511e-02f, 8.35613087e-02f, -5.05587012e-02f, -2.79137399e-02f, 7.23645985e-02f, 7.53979161e-02f,
  6.58829808e-02f, 5.56890853e-02f, -2.30627842e-02f, 1.40645085e-02f, -7.82477334e-02f, 1.57462489e-02f, -4.92052361e-02f, 7.60671347e-02f, 1.84016190e-02f, 1.15502536e-01f,
  -5.28571159e-02f, 7.06542144e-03f, -6.59552962e-02f, -8.01051408e-02f, -1.09576575e-01f, -9.40066278e-02f, -1.97791290e-02f, 7.41055757e-02f, -7.29713440e-02f, 1.65959954e-01f,
  1.06638245e-01f, -1.10929320e-03f, 7.82077238e-02f, 4.80398834e-02f, 7.42510185e-02f, 9.28500891e-02f, 5.53096533e-02f, 6.98252469e-02f, -2.95028165e-02f, 1.24662044e-03f,
  1.70246605e-02f, 8.22834074e-02f, 6.84022531e-02f, -5.92476018e-02f, -8.74532666e-03f, -1.33477710e-02f, 1.33995637e-02f, 9.58246514e-02f, 6.11511469e-02f, 2.55381819e-02f,
  3.67028713e-02f, -4.94627543e-02f, 2.55296994e-02f, 9.06045660e-02f, 6.65863557e-03f, 2.13205386e-02f, 5.18057980e-02f, 8.74249563e-02f, 1.08714983e-01f, 4.00313288e-02f,
  -9.52043310e-02f, -1.61575586e-01f, 1.26757994e-01f, 3.63682173e-02f, -3.85121070e-02f, 7.99003802e-03f, -2.60768663e-02f, 6.43310994e-02f, -6.42873645e-02f, -2.51586214e-02f,
  4.93875258e-02f, 4.78910878e-02f, 8.85271374e-03f, 6.66423514e-02f, -2.20823102e-02f, 6.14367649e-02f, -1.31252054e-02f, 5.68475276e-02f, -6.10983409e-02f, 6.46014884e-02f,
  -6.15734458e-02f, -8.92938823e-02f, -1.83362029e-02f, -7.80524537e-02f, -1.15648665e-01f, 5.41669019e-02f, 1.78184006e-02f, -9.28313583e-02f, -5.72863454e-03f, 5.56942895e-02f,
  -5.71415067e-01f, 8.62088799e-02f, 9.44396108e-02f, -3.90821368e-01f, -3.21417190e-02f, 1.31681517e-01f, 2.30207548e-01f, 3.43428291e-02f, -8.80424231e-02f, 8.15207586e-02f,
  1.39580248e-02f, -2.32340783e-01f, -7.24092871e-02f, -6.13882877e-02f, -1.18207894e-01f, 1.19114056e-01f, 6.40622824e-02f, -1.99258715e-01f, -3.09928864e-01f, -1.99391127e-01f,
  -2.33447760e-01f, -4.55415964e-01f, -3.26413125e-01f, -2.25345567e-01f, -1.62514925e-01f, -1.96844965e-01f, -8.29534456e-02f, -1.61931172e-01f, -2.23570857e-02f, 2.52171159e-02f,
  1.21143274e-01f, 5.01425788e-02f, -1.17551394e-01f, -1.06862478e-01f, -2.66020466e-02f, 2.78240573e-02f, -5.76121956e-02f, -9.68093053e-02f, 3.68555114e-02f, -9.91618261e-02f,
  -2.55618710e-02f, 2.96796318e-02f, -4.69700582e-02f, 3.11058667e-02f, -9.49829668e-02f, -1.01003431e-01f, -5.25320321e-02f, -8.63252357e-02f, -6.69147074e-02f, 1.25028461e-01f,
  7.43248910e-02f, -1.15406223e-01f, -1.03254221e-01f, 8.40708092e-02f, 2.98030470e-02f, -8.67063254e-02f, 7.67777264e-02f, -6.38037771e-02f, 4.01586331e-02f, -7.92523026e-02f,
  2.09240858e-02f, 5.46193272e-02f, 4.35131742e-03f, -6.30010217e-02f, -4.55773585e-02f, 1.28860958e-02f, 1.00478612e-01f, -8.85658190e-02f, -6.10155910e-02f, -8.27993825e-02f,
  -1.68859924e-03f, 1.10478327e-01f, -1.60350427e-02f, -1.48192151e-02f, -1.28342519e-02f, 9.39445198e-03f, 2.32125502e-02f, 7.53890648e-02f, 5.94865568e-02f, 1.76116508e-02f,
  -2.25327015e-02f, -1.64294466e-02f, -5.62679879e-02f, -1.97726991e-02f, 1.53850034e-01f, -4.41996567e-02f, 6.70235511e-03f, 1.86014231e-02f, -2.37510912e-02f, -2.06217915e-03f,
  -2.81902403e-01f, 1.57013550e-01f, -8.47345218e-02f, -9.55819488e-02f, -3.63321677e-02f, 4.39027324e-02f, 1.06157642e-02f, 3.64423133e-02f, -2.26854105e-02f, -3.19758765e-02f,
  4.98345010e-02f, -7.45083243e-02f, -6.43926710e-02f, 2.01564003e-02f, -8.68483037e-02f, 2.18919907e-02f, -9.13563296e-02f, -8.50937963e-02f, 6.81707710e-02f, 6.97704330e-02f,
  9.95234624e-02f, -1.28592029e-01f, -1.89693928e-01f, -6.52463287e-02f, -1.62167158e-02f, -1.36303544e-01f, 3.75684239e-02f, -4.11753133e-02f, -9.47751403e-02f, -2.35160470e-01f,
  2.18875363e-01f, 1.32360995e-01f, -1.17787458e-02f, 3.56887504e-02f, 4.06432711e-02f, -8.99246857e-02f, -2.21820444e-01f, -1.97953820e-01f, -4.26292419e-02f, -4.07410078e-02f,
  9.58261043e-02f, 1.52425021e-01f, -4.78141196e-02f, -8.15968364e-02f, -3.27338055e-02f, 2.73449067e-02f, 1.88803282e-02f, 6.71683401e-02f, 1.32448887e-02f, 9.64172333e-02f,
  7.22846985e-02f, 1.99447066e-01f, 1.69523910e-01f, 6.86549442e-03f, 1.32896766e-01f, 9.65218171e-02f, 3.97997536e-03f, 1.08549096e-01f, 1.44623965e-01f, 1.85925856e-01f,
  2.52021670e-01f, 1.35233626e-02f, -9.04901475e-02f, 5.21107242e-02f, 8.96552578e-03f, -4.43454906e-02f, 7.24497736e-02f, 5.31609394e-02f, 6.94306120e-02f, 7.19243214e-02f,
  -4.46755365e-02f, 6.91163242e-02f, 8.07172880e-02f, -5.77604249e-02f, 4.04085554e-02f, -8.20011571e-02f, -8.05895999e-02f, -8.94465223e-02f, -1.51404426e-01f, 8.24851543e-02f,
  1.26488611e-01f, 1.51535660e-01f, -1.09223492e-01f, -6.95904195e-02f, 1.54988505e-02f, 8.24998468e-02f, -1.03481092e-01f, -3.75415981e-02f, -1.29993245e-01f, 8.68430547e-03f,
  4.31337059e-02f, 4.80221882e-02f, -1.80254150e-02f, 4.32524458e-02f, -4.58985753e-02f, -5.25252484e-02f, 1.32666705e-02f, 1.09099252e-02f, -2.70663016e-02f, -1.82942941e-03f,
  -5.69839925e-02f, -2.33339928e-02f, 4.31593210e-02f, -4.92168032e-03f, 7.00646713e-02f, 3.36207002e-02f, -5.13555892e-02f, -2.22062320e-02f, 3.14575136e-02f, 8.54881387e-03f,
  2.07374953e-02f, 6.41339049e-02f, -1.96418595e-02f, -4.17246521e-02f, 9.09469463e-03f, 8.17431882e-03f, 3.19461129e-03f, 6.91135600e-02f, -6.08110502e-02f, 1.11638881e-01f,
  -7.20121665e-03f, -2.19351441e-01f, 4.05832119e-02f, 3.05458028e-02f, 8.54254737e-02f, -6.81702346e-02f, -2.07447521e-02f, -1.19559397e-03f, 1.80526711e-02f, 5.06826444e-03f,
  8.34611803e-02f, 4.72105742e-02f, -9.63623300e-02f, 8.95063858e-05f, -9.59938988e-02f, 1.35854520e-02f, 2.80798245e-02f, -6.09332696e-02f, -1.22944921e-01f, 5.55100739e-02f,
  -1.89206679e-03f, -4.80696931e-02f, -2.26259399e-02f, -1.07762486e-01f, -1.43932700e-02f, 6.04489772e-03f, -4.08869497e-02f, -5.96670918e-02f, -9.92075875e-02f, -1.07578114e-01f,
  -1.87141791e-01f, -1.54580206e-01f, 4.80331331e-02f, 2.32292861e-02f, -1.27184331e-01f, -8.41381587e-03f, -5.79409786e-02f, -1.95962619e-02f, -9.00056809e-02f, -4.43539433e-02f,
  5.52156242e-03f, 1.93177626e-01f, 6.01791032e-02f, 1.07544735e-01f, 7.37427995e-02f, -2.38755532e-02f, -5.40650673e-02f, -5.19712232e-02f, 8.14422313e-03f, -7.59423450e-02f,
  -8.52666572e-02f, -9.22381207e-02f, 7.99925358e-04f, 3.05078328e-02f, 5.99349812e-02f, 6.99246153e-02f, 5.34856506e-02f, 3.85968275e-02f, -5.64539023e-02f, -5.92771769e-02f,
  2.68411040e-01f, -8.76623690e-02f, 8.57764855e-02f, 3.57349031e-02f, 6.52890326e-03f, 1.40806590e-03f, 7.15172663e-02f, -9.44086909e-02f, -8.66705552e-02f, -3.03425547e-02f,
  2.66915355e-02f, 8.11142325e-02f, -5.88966720e-02f, -4.54097874e-02f, -7.72390328e-03f, -4.74279597e-02f, -4.07590084e-02f, -1.04502223e-01f, 2.91205384e-02f, 4.39745225e-02f,
  -6.04725108e-02f, -4.37805876e-02f, 1.29244942e-02f, 7.62839383e-03f, -3.28390487e-02f, 3.58632486e-03f, 4.06245403e-02f, 1.00134455e-01f, 8.80504698e-02f, 1.16948307e-01f,
  3.48983966e-02f, 7.03391880e-02f, 3.25836055e-02f, 7.87710175e-02f, 3.60349379e-03f, -3.73011567e-02f, 1.95100193e-03f, -2.13311911e-02f, 9.75144804e-02f, -3.46095674e-02f,
  2.55301420e-04f, -6.27139024e-03f, 6.44009933e-02f, -1.16870059e-02f, -4.48202677e-02f, -3.11242081e-02f, -2.30905581e-02f, 2.42138114e-02f, 4.17941697e-02f, -6.50402484e-03f,
  -7.72446543e-02f, 5.20027466e-02f, -4.66389470e-02f, 1.72273833e-02f, 1.35194976e-02f, -6.75216690e-02f, -6.15994483e-02f, -7.35366310e-04f, 4.07123566e-02f, 2.26464141e-02f,
  3.11264932e-01f, -9.58249252e-03f, 1.09764621e-01f, -4.34975438e-02f, 4.34469469e-02f, -1.23409726e-01f, 6.05061650e-02f, 1.75288115e-02f, 3.48410122e-02f, 2.80275643e-02f,
  6.70270920e-02f, 5.98129854e-02f, 3.72647122e-02f, -6.81292564e-02f, -2.02423031e-03f, -5.86145632e-02f, -1.22596309e-01f, -3.47297788e-02f, 5.43365302e-03f, -7.71471485e-02f,
  -1.39819801e-01f, -4.53516096e-02f, 1.25649258e-01f, 8.77432823e-02f, -6.58752099e-02f, 6.10088632e-02f, 5.08498065e-02f, 6.08531851e-03f, -5.81658271e-04f, 8.80765021e-02f,
  2.63249665e-01f, 1.35989174e-01f, 1.13195352e-01f, -5.90844415e-02f, -1.71074063e-01f, -1.59553856e-01f, 7.19344476e-03f, -7.59080648e-02f, -6.20232075e-02f, -4.37179208e-03f,
  -6.98380126e-03f, -6.97458982e-02f, 3.03412881e-02f, 7.36050606e-02f, 5.76427840e-02f, 1.67449855e-03f, 5.37227504e-02f, 1.47470832e-01f, 1.65970534e-01f, -9.31125693e-03f,
  9.29768234e-02f, 1.55546531e-01f, 2.09145129e-01f, 5.40306643e-02f, 2.90050674e-02f, 7.09973797e-02f, 9.64455679e-02f, 4.96088341e-02f, 1.41021073e-01f, 7.96768516e-02f,
  4.30669859e-02f, 1.03151284e-01f, -3.08498703e-02f, 2.18467079e-02f, 8.78888816e-02f, 8.24598297e-02f, 4.68457788e-02f, 9.88937840e-02f, -2.76531372e-02f, -6.35149404e-02f,
  5.51450104e-02f, 6.74438700e-02f, 3.89840603e-02f, -3.12517174e-02f, 5.67472391e-02f, 1.58194210e-02f, 1.24405675e-01f, 4.25602915e-03f, -2.03431044e-02f, 9.24591050e-02f,
  3.14251818e-02f, -2.64687501e-02f, -5.81019372e-02f, -6.54224381e-02f, 9.09900293e-02f, 2.75430307e-02f, 1.55547326e-02f, 9.36005637e-02f, -3.46107967e-02f, 1.21879183e-01f,
  -6.41328469e-02f, 3.08135804e-02f, 3.16727348e-02f, -6.54798076e-02f, -9.66790691e-03f, -7.68425241e-02f, -2.19493546e-02f, 3.56208831e-02f, -4.35536169e-02f, -5.16273715e-02f,
  -6.83079883e-02f, -4.99502905e-02f, -2.51270104e-02f, -9.33382586e-02f, 4.91968961e-03f, -4.40795012e-02f, -2.41252687e-02f, -1.69843528e-02f, -2.94671599e-02f, -2.02677455e-02f,
  -8.85584801e-02f, 7.05470517e-02f, -1.56179024e-02f, 6.80823699e-02f, -8.24174061e-02f, -9.30061266e-02f, -2.16472894e-02f, -5.69989793e-02f, 7.51855969e-02f, -5.65496907e-02f,
  -2.41199154e-02f, -1.29193231e-01f, -3.13564762e-02f, 3.71537656e-02f, -1.99445020e-02f, 1.25316203e-01f, 1.93123166e-02f, -1.42642483e-03f, 7.11478740e-02f, -1.90647226e-02f,
  9.79896486e-02f, 8.49349573e-02f, -2.21670908e-03f, 2.90857838e-03f, 4.21111248e-02f, -4.15595248e-02f, 5.31983038e-04f, 4.48114946e-02f, -2.46762373e-02f, 4.59991954e-02f,
  7.84275606e-02f, -7.02071860e-02f, -1.22004956e-01f, -8.52808058e-02f, 4.00703959e-02f, -1.30935162e-01f, -6.98075145e-02f, -8.12725574e-02f, -2.68265903e-02f, -1.11270964e-01f,
  -2.95594513e-01f, 1.58612635e-02f, -1.81763411e-01f, -1.58014774e-01f, 8.85104612e-02f, 1.68015510e-02f, -1.73019879e-02f, -3.99171636e-02f, -7.82704651e-02f, -4.63954210e-02f,
  5.62712969e-03f, -5.69665581e-02f, -1.94608986e-01f, -1.50010347e-01f, -1.59743398e-01f, -1.93262026e-01f, -1.89788923e-01f, -1.91266209e-01f, -2.34782562e-01f, -6.55448064e-02f,
  -9.19801891e-02f, -7.09287599e-02f, -2.16112241e-01f, -1.72618225e-01f, 1.98716745e-02f, -1.38472378e-01f, -1.32110000e-01f, -2.83016637e-02f, 2.40181275e-02f, 5.45208044e-02f,
  1.74881537e-02f, 2.50626970e-02f, -8.50617886e-02f, -6.87345192e-02f, 6.04502065e-03f, 3.77378576e-02f, 8.82038027e-02f, -1.27199635e-01f, 1.98266264e-02f, -4.25255578e-03f,
  -1.57246720e-02f, 4.00011539e-02f, -3.78119666e-03f, 4.67361473e-02f, 3.35708968e-02f, 1.10975383e-02f, -4.23810892e-02f, -1.70925647e-01f, -1.12264380e-01f, 3.03037930e-02f,
  1.17746875e-01f, -4.15546410e-02f, -9.13366005e-02f, -1.27483636e-01f, -5.54075502e-02f, -1.12660818e-01f, -5.17413318e-02f, -8.13463554e-02f, -1.60883352e-01f, 1.13421204e-02f,
  9.18019488e-02f, 8.12924728e-02f, 6.25963137e-02f, 9.68808588e-03f, -2.09286101e-02f, 4.34086062e-02f, 1.67912059e-02f, -1.91096999e-02f, 1.42213609e-02f, 3.65145281e-02f,
  -7.39474073e-02f, -3.08805257e-02f, 2.57159118e-02f, -9.39218402e-02f, 5.56979403e-02f, -4.29287776e-02f, 2.70488635e-02f, -5.24138846e-02f, -3.72165032e-02f, -5.56072183e-02f,
  -8.50615203e-02f, 6.96555898e-02f, -5.46928793e-02f, 7.28992149e-02f, -5.04212305e-02f, 3.74313109e-02f, -5.74505441e-02f, -8.87170807e-03f, -4.56558503e-02f, -7.38905221e-02f,
  -1.40156627e-01f, -5.54389767e-02f, 4.12254445e-02f, -8.75602886e-02f, -3.40918489e-02f, 6.18507154e-02f, -6.16882220e-02f, -4.85097356e-02f, 7.62916058e-02f, 3.72978449e-02f,
  5.67071848e-02f, -4.14595492e-02f, -1.32225519e-02f, -5.10036498e-02f, -2.02977136e-02f, 2.70287860e-02f, -5.88989817e-02f, -7.23223835e-02f, -1.51837006e-01f, -2.30541211e-02f,
  -1.25679001e-01f, -1.18964426e-01f, -2.92563170e-01f, -1.08865768e-01f, -2.70078592e-02f, -2.05846131e-01f, -6.68160990e-02f, -7.50674233e-02f, -2.64771760e-01f, -2.40981326e-01f,
  -1.35036141e-01f, -4.03946154e-02f, -2.83836335e-01f, -8.48339424e-02f, -6.33023456e-02f, 9.68861431e-02f, -1.40583245e-02f, 7.13746250e-02f, 8.17675889e-03f, -9.57216322e-02f,
  -6.99445978e-02f, -1.35293126e-01f, -1.45286649e-01f, -1.19652271e-01f, -1.33484095e-01f, -1.92158595e-01f, -1.81751311e-01f, -1.42320454e-01f, -2.19926655e-01f, -6.80249482e-02f,
  2.02630386e-02f, -1.92319900e-01f, -2.45464057e-01f, -1.70650154e-01f, -1.19235888e-01f, -2.61588395e-01f, -2.31744766e-01f, -1.93909898e-01f, -2.38700062e-01f, -1.37633026e-01f,
  -2.61732966e-01f, -9.17034410e-03f, 6.78137317e-02f, 3.21985707e-02f, -1.29228249e-01f, 5.05340658e-02f, 5.04137091e-02f, -7.96083733e-03f, -5.43898344e-02f, 4.58464846e-02f,
  -9.52587128e-02f, 6.29100157e-03f, 5.52063957e-02f, 1.68027375e-02f, -4.16838303e-02f, -3.61759625e-02f, -3.50235738e-02f, -9.49789397e-03f, -8.02021623e-02f, -2.55043320e-02f,
  2.10874900e-02f, -3.15102711e-02f, -5.44615537e-02f, 3.44167985e-02f, -3.43703255e-02f, -7.97612518e-02f, 4.16251719e-02f, -1.42166205e-02f, -8.81109089e-02f, -1.36613458e-01f,
  5.01150042e-02f, 4.18255553e-02f, -4.38115634e-02f, -3.42527367e-02f, 4.78674248e-02f, -3.19902450e-02f, 1.38145816e-02f, -1.38277123e-02f, -5.99429905e-02f, 1.82547681e-02f,
  -1.99196744e-03f, -4.57651680e-03f, 6.96215108e-02f, -3.51732597e-02f, -5.15308082e-02f, -3.62956487e-02f, -5.61992973e-02f, 8.94498453e-02f, 3.91952656e-02f, -1.48311043e-02f,
  -2.18454469e-02f, -5.26991971e-02f, 2.01149620e-02f, 7.68137798e-02f, 9.22795013e-02f, -8.48388590e-04f, 5.04996032e-02f, 6.90912381e-02f, -3.73819768e-02f, 1.27315119e-01f,
  -2.11718529e-01f, 5.23025449e-03f, 3.77574898e-02f, -9.21005830e-02f, -1.98880322e-02f, 1.70378964e-02f, 7.89724570e-03f, -6.15605377e-02f, 5.16023114e-02f, 2.77846027e-02f,
  8.96470323e-02f, 6.80724457e-02f, 2.64684912e-02f, -4.77877185e-02f, 7.99180120e-02f, -2.39851493e-02f, 2.97805257e-02f, -3.04326341e-02f, 4.40409929e-02f, 1.15127452e-02f,
  8.12440217e-02f, -5.90697937e-02f, -5.15473867e-03f, -5.90663999e-02f, 4.27083299e-02f, -1.22785665e-01f, -1.35624900e-01f, -8.76754820e-02f, -9.05211717e-02f, -8.46103430e-02f,
  -4.69127685e-01f, 1.33418277e-01f, 5.80882141e-03f, -1.74604073e-01f, -1.14361934e-01f, -9.96404439e-02f, 8.22810829e-02f, 2.38458142e-02f, -1.66612700e-01f, -5.58688752e-02f,
  6.30838349e-02f, 2.43374687e-02f, -3.72379310e-02f, 1.07384212e-01f, 4.74500284e-02f, 8.49307254e-02f, 1.67403556e-02f, -2.30721515e-02f, -1.10787220e-01f, 1.00988977e-01f,
  -5.52796526e-03f, -6.51994273e-02f, -9.03623775e-02f, -5.28961830e-02f, -2.40625348e-02f, -4.46467698e-02f, -6.87892660e-02f, -7.79629052e-02f, 3.41561250e-02f, -7.66041204e-02f,
  3.91864777e-01f, -2.07060859e-01f, 4.21167761e-02f, -1.76803600e-02f, 6.30305111e-02f, -3.72315608e-02f, 4.55570919e-03f, 8.54358170e-03f, 2.63110120e-02f, 7.16893002e-02f,
  -6.39723092e-02f, -9.64805856e-02f, -3.05865351e-02f, 3.00370026e-02f, 5.80549985e-03f, -7.20578581e-02f, 1.05361134e-04f, 5.79731204e-02f, 3.66837494e-02f, 1.37228668e-01f,
  2.46723872e-02f, -3.69749628e-02f, -4.32497710e-02f, 8.13970864e-02f, 4.35566902e-02f, -4.82086390e-02f, 2.94847935e-02f, 8.10236782e-02f, 5.61589636e-02f, 8.98963511e-02f,
  -3.08857877e-02f, -5.58430031e-02f, -4.46798978e-03f, -2.51055900e-02f, -2.88443305e-02f, 3.30381207e-02f, -4.96172383e-02f, -2.27960460e-02f, -5.30651063e-02f, 5.00904433e-02f,
  1.05834849e-01f, 3.77774285e-03f, 9.84090194e-02f, 5.17535731e-02f, -2.21483596e-02f, 5.73405176e-02f, -9.11400616e-02f, -5.82974963e-03f, 5.59321232e-02f, -4.00507189e-02f,
  -1.06926285e-01f, 6.51734173e-02f, -1.19496100e-02f, 2.35025268e-02f, -6.76125512e-02f, -1.78229492e-02f, -5.62447757e-02f, 7.00455606e-02f, 1.41377971e-02f, -3.00667994e-02f,
  3.66506636e-01f, -2.18669772e-01f, -4.73649167e-02f, -1.28256291e-01f, -1.54583901e-01f, 3.99443228e-03f, 1.36806152e-03f, -1.15109406e-01f, 3.37584838e-02f, -7.21608661e-03f,
  4.08218801e-03f, 8.88614636e-03f, 4.85232286e-02f, 5.62679060e-02f, -2.61728987e-02f, 4.15664949e-02f, 1.04023609e-02f, -9.89225507e-02f, 1.38334567e-02f, 1.07228413e-01f,
  2.51124948e-02f, 4.51906994e-02f, 8.55265334e-02f, 1.31492585e-01f, 7.81894848e-02f, 4.24021296e-02f, 1.05354436e-01f, 1.27813101e-01f, 9.76761244e-03f, 1.85866475e-01f,
  -5.16313910e-02f, -2.52633363e-01f, 1.19225845e-01f, -1.75677672e-01f, 6.27448782e-02f, 1.74845651e-01f, 1.28390267e-01f, -9.50883031e-02f, 1.47759998e-02f, -2.27842899e-03f,
  -1.99631318e-01f, -1.31646544e-01f, -1.97646812e-01f, -1.17814474e-01f, -4.67970707e-02f, -3.44857313e-02f, -2.97955722e-02f, 1.20277062e-01f, 1.82506889e-01f, 3.62968966e-02f,
  -1.02578767e-03f, -1.45610258e-01f, -1.19434521e-01f, -1.02616819e-02f, -1.02001987e-01f, -1.08725563e-01f, -5.21349385e-02f, -6.89389557e-02f, -2.11806800e-02f, -6.15698956e-02f,
  4.05812077e-03f, -9.51170623e-02f, 4.06514890e-02f, -1.18922837e-01f, 4.71873470e-02f, -2.03535575e-02f, 7.96024874e-02f, -9.99195501e-02f, -1.01721779e-01f, 4.14755940e-02f,
  -5.26112169e-02f, 1.09897100e-03f, 2.28934418e-02f, 3.72833498e-02f, -8.30276962e-03f, -5.94864041e-02f, -5.57014793e-02f, -8.57150480e-02f, 8.16321559e-03f, -2.13038493e-02f,
  -7.68363401e-02f, 3.90426703e-02f, 8.70418921e-02f, 6.48050159e-02f, -2.75757108e-02f, 9.46042091e-02f, -4.46734577e-02f, -4.01622504e-02f, 9.00132582e-02f, 7.58520467e-03f,
  5.94985113e-02f, 4.10695150e-02f, 5.01762554e-02f, -4.01115045e-02f, -4.32907939e-02f, -4.22975011e-02f, -2.40415297e-02f, 4.55077775e-02f, 2.61638872e-02f, 7.54376920e-03f,
  1.73905697e-02f, -5.17425244e-04f, -1.27813071e-01f, 8.31077527e-03f, -8.09966549e-02f, -2.11825483e-02f, 3.83567624e-02f, -1.05410159e-01f, 4.18881215e-02f, -1.75705403e-02f,
  6.59744516e-02f, -2.87312213e-02f, -1.83121115e-02f, -9.96769592e-02f, -7.99039528e-02f, 5.80010712e-02f, 1.47769274e-03f, -2.82253567e-02f, 2.01208796e-02f, 5.57686649e-02f,
  -1.05858967e-01f, 5.55531774e-03f, 3.70784476e-02f, 4.23814217e-03f, -3.29764821e-02f, 3.91407572e-02f, -1.06342092e-01f, 4.73918095e-02f, -1.91708710e-02f, 3.81457806e-03f,
  -5.62228262e-02f, -7.62792975e-02f, 1.08341202e-02f, -2.75691431e-02f, -1.75864231e-02f, 8.33287984e-02f, 3.22762467e-02f, -3.90178747e-02f, -1.16581675e-02f, 4.57326993e-02f,
  4.47291024e-02f, 1.39952466e-01f, 1.46047652e-01f, 2.38076430e-02f, 6.62685484e-02f, 1.32271588e-01f, 6.26630113e-02f, 1.25891715e-01f, 5.96513636e-02f, 3.39573584e-02f,
  1.48377821e-01f, -6.59061074e-02f, 1.11874595e-01f, 4.30596732e-02f, -1.30522728e-01f, 5.64725313e-04f, 9.31119993e-02f, 1.63290456e-01f, -2.33650692e-02f, 4.97969277e-02f,
  -2.66837806e-01f, -8.32393169e-02f, 2.24918756e-03f, 1.13262706e-01f, 8.45058411e-02f, 1.45653054e-01f, 1.63015425e-01f, 1.66320935e-01f, 2.33927622e-01f, 6.80324286e-02f,
  3.30727585e-02f, 1.58487745e-02f, 1.12419866e-01f, 1.76410824e-01f, 8.88957232e-02f, 6.54241219e-02f, 1.13228289e-02f, 1.79693084e-02f, 4.13533822e-02f, 1.58186570e-01f,
  -1.76626474e-01f, -2.23853048e-02f, 5.00849560e-02f, -1.19012654e-01f, -1.01398900e-01f, 8.46086293e-02f, -2.16744263e-02f, 1.70730278e-02f, -1.04744337e-01f, -3.29187624e-02f,
  -8.80789459e-02f, -6.01473637e-02f, -9.04041994e-03f, -5.51068261e-02f, -5.68798110e-02f, 8.05956498e-02f, 1.85511559e-02f, 1.83370307e-01f, 1.30951954e-02f, 5.31900562e-02f,
  -1.53709412e-01f, -1.35318622e-01f, 4.08313423e-03f, -4.87496816e-02f, 9.37442034e-02f, -1.33989349e-01f, -5.50809018e-02f, -2.01012548e-02f, 4.29099947e-02f, -2.14374699e-02f,
  -1.59649979e-02f, 2.28951313e-02f, 4.11667414e-02f, 3.17901708e-02f, -2.63835657e-02f, 1.37391416e-02f, -4.28995155e-02f, 1.82386059e-02f, 5.67619391e-02f, -3.04828733e-02f,
  7.11340383e-02f, 1.67594682e-02f, 5.51483035e-02f, 5.36435433e-02f, -9.67141166e-02f, -3.31914090e-02f, 1.29636358e-02f, -3.78603488e-02f, 4.07646261e-02f, 4.98029664e-02f,
  -8.20514932e-02f, 7.06791729e-02f, 5.48914187e-02f, -2.00419296e-02f, 7.75040090e-02f, -1.55343404e-02f, 9.37793851e-02f, 3.13624106e-02f, 2.65058633e-02f, -1.02086313e-01f,
  -1.50001138e-01f, -8.37251544e-02f, 8.56321678e-02f, 1.45877078e-02f, -8.85276124e-02f, 4.94316191e-05f, -8.08881223e-02f, 5.62327951e-02f, -8.65257680e-02f, 2.55225524e-02f,
  -6.09963611e-02f, -4.70459573e-02f, -9.73407254e-02f, 7.07120448e-02f, -3.50787379e-02f, 3.32323499e-02f, -2.78334715e-04f, 3.74387279e-02f, -3.50097641e-02f, 7.92791136e-03f,
  -4.44609262e-02f, 1.14871236e-02f, -1.07293829e-01f, 2.17373818e-02f, 4.48507722e-03f, -8.54197666e-02f, 7.52374297e-03f, -4.15813923e-02f, 6.76389933e-02f, 4.31493297e-02f,
  2.94066548e-01f, -1.09057091e-01f, 1.34214342e-01f, 4.54870947e-02f, -1.35135666e-01f, -3.10382307e-01f, -3.51072907e-01f, -2.05215544e-01f, -7.77876750e-02f, -5.87883515e-05f,
  6.41435534e-02f, 1.80624247e-01f, 7.28830695e-02f, 1.09758899e-01f, 1.12012722e-01f, 1.36065413e-03f, 6.99145943e-02f, 2.45309547e-01f, 1.72732145e-01f, -7.83761144e-02f,
  -6.32861406e-02f, 9.75961164e-02f, 2.14608237e-01f, 5.72877266e-02f, -3.37710194e-02f, 2.25420538e-02f, -2.57744547e-03f, -8.94533377e-03f, 9.74670723e-02f, 1.31392196e-01f,
  7.57366568e-02f, 1.17416039e-01f, 9.25064683e-02f, 1.62721515e-01f, 1.36971086e-01f, 5.77530414e-02f, -6.23760484e-02f, 7.07882084e-03f, -8.52996707e-02f, 1.34317009e-02f,
  3.27922516e-02f, 2.25796178e-02f, 1.68848243e-02f, 6.70086918e-03f, 2.66735330e-02f, 2.24783667e-03f, -1.92664564e-02f, 1.71407138e-03f, -1.81639928e-03f, -2.65863277e-02f,
  -4.59847134e-03f, -2.69840043e-02f, -2.09500715e-02f, -8.24583843e-02f, -6.54037222e-02f, 1.57578066e-02f, 4.75018099e-02f, 7.95064270e-02f, 7.44026527e-02f, -1.85414199e-02f,
  6.71906322e-02f, 7.15450048e-02f, 7.19113275e-02f, -3.85956317e-02f, -2.67029344e-03f, -4.04682057e-03f, -5.82977049e-02f, 1.16413012e-02f, 3.02057862e-02f, -2.34825052e-02f,
  1.36456296e-01f, 9.30061191e-03f, -5.43569699e-02f, -7.01887012e-02f, 7.37344672e-04f, 1.34086115e-02f, -4.52258438e-02f, 5.07493839e-02f, 2.71599647e-02f, 5.46270832e-02f,
  -3.29114050e-02f, 5.30767217e-02f, 5.03820293e-02f, 5.25377952e-02f, 9.42416023e-03f, 1.00875504e-01f, -3.13080586e-02f, 2.42643412e-02f, 1.81580484e-02f, 8.28559548e-02f,
  -5.14127947e-02f, 1.66151866e-01f, 3.12800668e-02f, -1.18372375e-02f, 3.01006567e-02f, 5.85370921e-02f, -1.39836641e-02f, 1.63106583e-02f, -9.53245535e-03f, -3.95100638e-02f,
  -6.11016415e-02f, 6.73047751e-02f, 1.59573951e-03f, -4.74152826e-02f, 1.20444950e-02f, -5.89328876e-04f, -6.54770732e-02f, 2.11042706e-02f, -3.61188911e-02f, -9.97234881e-02f,
  -1.29067838e-01f, -1.27816111e-01f, -1.00236591e-02f, -6.10241666e-02f, -7.16433227e-02f, 8.11921060e-02f, -1.06663868e-01f, -1.32340044e-01f, -6.28382084e-04f, -1.47091895e-01f,
  -1.67769894e-01f, 7.95739591e-02f, 2.19683081e-01f, -6.66818619e-02f, -6.17453642e-02f, 1.78736653e-02f, 2.75421198e-02f, -1.34137675e-01f, -1.10149801e-01f, -3.36598232e-02f,
  -7.17225075e-02f, -1.10223264e-01f, 1.65369920e-02f, 3.05003449e-02f, -8.79594460e-02f, -1.23446239e-02f, 2.54858527e-02f, 3.16447169e-02f, -6.37417808e-02f, -8.33494291e-02f,
  -7.40123615e-02f, -1.95278004e-01f, -1.49264827e-01f, -3.34950276e-02f, -1.70227870e-01f, -1.20838508e-02f, 4.31945361e-02f, -3.61753837e-03f, 4.11176495e-03f, -1.13594741e-01f,
  -6.03544749e-02f, 9.63729247e-02f, -1.25505358e-01f, -5.56531223e-03f, 7.89590776e-02f, -8.26944858e-02f, -1.93008245e-03f, 5.27325124e-02f, 4.41138931e-02f, 8.52997974e-03f,
  1.05262082e-02f, 1.21383201e-02f, -5.81773594e-02f, -3.55305187e-02f, -7.46332929e-02f, -6.50041401e-02f, 6.17526472e-02f, 6.75632730e-02f, -1.33496861e-03f, 2.76867002e-02f,
  1.52196400e-02f, 6.84734359e-02f, 5.31598330e-02f, 1.08477250e-01f, 4.08855453e-02f, 1.15060553e-01f, 2.27315314e-02f, -3.61754224e-02f, 1.14864953e-01f, -5.41269258e-02f,
  2.57844795e-02f, 9.72924940e-03f, -2.63537038e-02f, -5.95622137e-02f, 5.37472554e-02f, 3.00646387e-03f, -4.39816453e-02f, -4.13687192e-02f, -6.57278895e-02f, -4.24809232e-02f,
  -4.28729206e-02f, -4.91501354e-02f, 6.98585808e-02f, -1.59579404e-02f, -5.15684625e-03f, -4.01235223e-02f, -2.04526763e-02f, -7.04777539e-02f, -5.20342924e-02f, 4.46919724e-02f,
  1.17122568e-02f, -2.22885236e-02f, 7.57118165e-02f, -7.85747170e-03f, 5.99459372e-02f, -4.91288267e-02f, -5.54929674e-03f, -1.69898476e-02f, 2.10112706e-02f, 3.81469205e-02f,
  -8.53191018e-02f, 1.66136503e-01f, -9.06447396e-02f, -4.80977930e-02f, 5.97412102e-02f, 7.72910193e-02f, -3.21054645e-02f, 9.90375504e-03f, -1.68287568e-02f, -6.33804277e-02f,
  1.83896534e-02f, -1.27539993e-03f, -1.68107022e-02f, 2.81090736e-02f, -7.86586180e-02f, -1.03855975e-01f, -3.83419404e-03f, -3.09490655e-02f, 5.18670306e-02f, 5.32884002e-02f,
  -1.49949556e-02f, -4.05997336e-02f, -1.17093539e-02f, -5.03192507e-02f, -4.08867300e-02f, -5.91735132e-02f, -9.54076573e-02f, -2.77130655e-03f, 5.49976192e-02f, -1.97785825e-01f,
  1.37289718e-01f, 8.43057409e-03f, 2.23125860e-01f, 1.35409623e-01f, -8.91756713e-02f, -3.56984466e-01f, -4.28962588e-01f, -2.63137132e-01f, 9.71453935e-02f, -5.01697250e-02f,
  -1.14710167e-01f, -4.35361359e-03f, -3.58442441e-02f, 1.01280473e-02f, -2.04917431e-01f, -1.52141362e-01f, 4.04448155e-03f, -1.91855081e-03f, -1.83954000e-01f, -2.13063598e-01f,
  -4.82053347e-02f, -6.99852556e-02f, 9.44492221e-02f, 5.99656478e-02f, 1.84075296e-01f, 6.14968762e-02f, 2.46993273e-01f, 9.04736072e-02f, -2.67522689e-02f, 3.57598871e-01f,
  1.58769339e-01f, 1.38465241e-01f, -1.26067728e-01f, 2.73526330e-02f, 7.40496069e-02f, -3.65846120e-02f, 1.77904442e-02f, 1.46125466e-01f, -3.57561558e-03f, 5.55107705e-02f,
  4.20114733e-02f, 2.45263912e-02f, 4.35909256e-02f, -7.39200227e-03f, -1.84357055e-02f, 2.69992603e-03f, 9.10871383e-03f, 8.66857767e-02f, 1.00887284e-01f, -2.50348952e-02f,
  2.63112821e-02f, -3.70797478e-02f, -5.76634407e-02f, -1.44893274e-01f, 1.38142414e-03f, 3.85057926e-02f, 1.53601328e-02f, 7.39320889e-02f, -4.70083430e-02f, 8.76069814e-02f,
  -9.92933009e-03f, -2.76303720e-02f, -5.85671403e-02f, 2.23619509e-02f, -2.53201602e-03f, 1.03152050e-02f, 7.10671991e-02f, -1.09861486e-01f, -5.36023639e-02f, 1.89380217e-02f,
  -6.06845245e-02f, 8.34915414e-02f, -5.89098558e-02f, 9.57116410e-02f, -3.52517515e-03f, 3.72533016e-02f, -4.23948690e-02f, -1.83541875e-03f, -2.95925001e-03f, 8.41721296e-02f,
  -6.24736361e-02f, -7.96038657e-03f, 1.69483498e-02f, -5.51980250e-02f, 3.72113497e-03f, 9.72652249e-03f, 4.77825888e-02f, -3.99932861e-02f, -7.22968252e-03f, 6.15149364e-02f,
  4.63569276e-02f, -1.67342126e-01f, -1.78896019e-03f, -7.92816374e-03f, 5.48399389e-02f, 8.12131986e-02f, 6.45311400e-02f, 3.05840708e-02f, 1.04636744e-01f, -8.89348090e-02f,
  -6.48019239e-02f, -1.92144100e-04f, 5.13411388e-02f, -7.67973885e-02f, -1.49010614e-01f, -9.72303376e-02f, -1.86499372e-01f, 1.60109531e-02f, -3.54017317e-02f, -1.09000551e-02f,
  -4.15078327e-02f, -1.35049120e-01f, -2.11426482e-01f, -9.44044888e-02f, -5.58661669e-02f, -7.52638727e-02f, -1.27912879e-01f, 1.29631022e-02f, -2.10797831e-01f, -1.83574259e-01f,
  -6.46329299e-03f, -1.67604104e-01f, 7.29195401e-02f, 2.01195017e-01f, 1.05948478e-01f, 2.05335662e-01f, 1.48224890e-01f, 1.18008144e-01f, 8.67063552e-03f, -6.60620704e-02f,
  -8.68839771e-02f, -9.02036279e-02f, -7.49612274e-03f, -1.10506617e-01f, -7.16054514e-02f, -2.27939425e-04f, 3.04406267e-02f, 1.05400071e-01f, 6.61886036e-02f, 4.67454642e-02f,
  -5.54452091e-02f, -5.81922829e-02f, -2.01014336e-03f, 1.60269886e-02f, 1.13940670e-03f, 9.52446535e-02f, 4.82108630e-02f, -3.32246930e-03f, 3.40976790e-02f, 1.22332253e-01f,
  -1.74332961e-01f, -2.02015378e-02f, 2.31981315e-02f, 1.73643162e-03f, -5.86589463e-02f, -1.10315224e-02f, 3.98220569e-02f, -2.54862942e-03f, -9.69634391e-03f, 2.08998397e-02f,
  -7.93142840e-02f, -3.66542004e-02f, -1.13002755e-01f, 3.86962108e-02f, 9.37872902e-02f, 7.02347606e-02f, -4.89245839e-02f, 2.57952139e-02f, 1.55663053e-02f, -1.66238546e-02f,
  4.99152802e-02f, 9.92413536e-02f, 1.51801467e-01f, 1.00859344e-01f, 5.57253659e-02f, 1.22400850e-01f, 6.95261583e-02f, 4.13150266e-02f, 1.01188228e-01f, 1.89753518e-01f,
  4.46261168e-02f, -1.69372074e-02f, 1.41478423e-02f, 4.34457809e-02f, -1.03796069e-02f, -1.71501078e-02f, 5.98508306e-02f, 4.26971848e-04f, 9.03000459e-02f, -3.96019742e-02f,
  2.12164484e-02f, 2.83441097e-02f, 4.08195108e-02f, -2.52509862e-02f, -1.62331406e-02f, 7.93952309e-03f, 3.83701585e-02f, -1.06041227e-02f, -4.90059592e-02f, 2.00422760e-02f,
  -4.35957611e-02f, 1.02179259e-01f, 5.37668401e-03f, 1.48376590e-03f, 4.00424190e-02f, 5.23006432e-02f, -1.46377450e-02f, -1.30752446e-02f, 3.64319384e-02f, 5.81186777e-03f,
  -5.02146594e-02f, -6.48548454e-02f, -2.33939179e-04f, -5.56985177e-02f, -4.98262011e-02f, -2.56888196e-02f, -9.73513946e-02f, 6.53685629e-02f, 1.05360234e-02f, 7.81294852e-02f,
  -4.61572669e-02f, -3.13079357e-02f, -1.03714868e-01f, -7.66430516e-03f, 1.89230088e-02f, 2.14107130e-02f, -7.81650320e-02f, 1.02301732e-01f, 1.67992711e-02f, 1.14669828e-02f,
  6.64562881e-02f, 1.36579961e-01f, 1.62786365e-01f, 9.85925272e-02f, 4.71702889e-02f, 7.11656585e-02f, 4.94903997e-02f, 3.39211635e-02f, 3.11018769e-02f, 2.42326871e-01f,
  2.97281563e-01f, -4.67051606e-04f, -3.33987981e-01f, 1.89261436e-01f, -1.94907680e-01f, -3.25821012e-01f, -3.13556075e-01f, 6.64863549e-03f, 1.62537530e-01f, 2.43324190e-02f,
  -1.03769876e-01f, -4.69510183e-02f, 9.09855142e-02f, -1.12830922e-01f, -1.47460192e-01f, -2.46007249e-01f, -2.57131547e-01f, -2.12832093e-01f, -1.99602336e-01f, -1.46480724e-01f,
  -1.76434264e-01f, 9.24993977e-02f, 1.03887372e-01f, 4.20732833e-02f, -1.20764049e-02f, 7.76641071e-02f, -7.74160624e-02f, -1.22840777e-01f, -2.65487283e-01f, -1.11965902e-01f,
  -1.42513990e-01f, -1.64402843e-01f, -8.98908004e-02f, 8.37721005e-02f, -9.70132742e-03f, -1.12097692e-02f, -7.65886456e-02f, -2.75355484e-02f, 3.84356193e-02f, -8.97731073e-03f,
  -6.76425770e-02f, -6.34644702e-02f, -7.63015449e-02f, -5.36071248e-02f, 3.37612890e-02f, -1.23425409e-01f, -2.37495005e-02f, -3.47369388e-02f, -6.63100630e-02f, -1.77860200e-01f,
  -5.38911223e-02f, -2.16628432e-01f, -5.71658500e-02f, -3.94651517e-02f, -1.53318137e-01f, -1.27503723e-01f, -6.31498620e-02f, -9.70856100e-02f, -5.99345565e-02f, 1.14841856e-01f,
  -6.69076815e-02f, -6.30465969e-02f, 3.70001011e-02f, 5.31571954e-02f, 9.76613685e-02f, -1.91935373e-03f, 7.97030926e-02f, -2.48058494e-02f, -2.20688134e-02f, 1.73891224e-02f,
  9.75641795e-03f, 2.28627790e-02f, -1.56712737e-02f, 4.66301367e-02f, 4.20906246e-02f, -9.49641690e-02f, 4.62361649e-02f, 9.23202336e-02f, 1.14065846e-02f, -6.65280456e-03f,
  -2.16760207e-02f, -5.35247661e-02f, -2.01031659e-02f, -9.19554476e-03f, -5.09130210e-03f, -2.68945266e-02f, -5.85809685e-02f, 2.53403857e-02f, -5.68354949e-02f, 1.75951160e-02f,
  3.37877631e-01f, -1.48201525e-01f, 1.87038835e-02f, 5.49899824e-02f, -6.37142956e-02f, 8.89050588e-02f, 6.28190041e-02f, 4.73130643e-02f, 3.51915993e-02f, -7.82591775e-02f,
  -4.86028977e-02f, 6.25005038e-03f, 5.43714464e-02f, -8.61607864e-02f, -6.72670007e-02f, -8.48025754e-02f, 1.43631384e-01f, -8.40212405e-03f, -5.82454242e-02f, 5.74529022e-02f,
  7.89559111e-02f, 2.28159316e-03f, 2.52218187e-01f, 1.22145802e-01f, 4.62033972e-02f, 8.33043549e-03f, -4.84242514e-02f, 6.53568283e-02f, -7.14907572e-02f, 3.20900112e-01f,
  4.84481566e-02f, -2.88098961e-01f, 6.63362965e-02f, -3.05043105e-02f, -1.37442201e-01f, -2.71733135e-01f, -3.53195369e-01f, -2.45473742e-01f, -5.73679693e-02f, -2.85881341e-01f,
  -2.70351648e-01f, -1.08900167e-01f, 5.13342209e-02f, 1.35682881e-01f, 1.72448203e-01f, -1.03160916e-02f, 1.02088921e-01f, 3.67416054e-01f, 2.71550834e-01f, 2.49678865e-02f,
  -2.39857119e-02f, 8.96075591e-02f, 2.54676312e-01f, 2.29399532e-01f, -1.15262263e-01f, -3.99593711e-02f, -3.97273600e-02f, 9.87855867e-02f, -6.76288977e-02f, 1.15294948e-01f,
  -1.94626376e-01f, -1.39381468e-01f, 2.98583810e-03f, 8.02517161e-02f, -4.32862081e-02f, 4.78862524e-02f, -1.15734778e-01f, 1.21404780e-02f, -4.04689051e-02f, -5.75885288e-02f,
  -4.03463580e-02f, -7.53701031e-02f, -7.16089904e-02f, -2.74960529e-02f, -7.71045983e-02f, -2.76220366e-02f, 1.50260836e-01f, 2.51648515e-01f, 4.26577516e-02f, -4.14618080e-05f,
  -1.21213950e-01f, -2.20845565e-02f, -9.97849777e-02f, 3.68707106e-02f, 2.99988203e-02f, 9.68531519e-02f, -3.39390710e-03f, -5.36698736e-02f, 1.70897301e-02f, -1.01403207e-01f,
  2.45380145e-03f, 4.46827076e-02f, -9.61595215e-03f, -6.09962922e-03f, 1.91809032e-02f, -6.40010685e-02f, 9.47688296e-02f, 2.98807467e-03f, 3.27724740e-02f, 1.79593451e-02f,
  3.65578420e-02f, 5.59846610e-02f, -1.85849611e-02f, 5.57294115e-02f, -2.29388680e-02f, -1.47845503e-03f, 8.96931812e-02f, -1.67884398e-02f, 3.62950191e-02f, 4.95741330e-03f,
  2.39785500e-02f, -1.03444224e-02f, -5.98874278e-02f, 2.33266558e-02f, 1.44080790e-02f, 7.82862604e-02f, -1.91259310e-02f, -3.57299931e-02f, -7.72270709e-02f, -2.46701343e-03f,
  -1.03684396e-01f, 2.05167904e-01f, -2.29872212e-01f, -1.33941099e-02f, -7.56305307e-02f, 5.12728840e-03f, -1.12843253e-01f, 8.87485743e-02f, -4.62069083e-03f, 4.85349074e-03f,
  -6.65244507e-03f, 2.36971341e-02f, -6.37355223e-02f, 3.74750011e-02f, 3.93707938e-02f, -7.38361180e-02f, -7.13275671e-02f, 7.50222579e-02f, 2.85939630e-02f, -1.35624737e-01f,
  -9.43425298e-02f, -1.96629480e-01f, -1.79179773e-01f, -1.83917299e-01f, -1.49322763e-01f, -1.30702645e-01f, -1.16188690e-01f, -1.63124591e-01f, -1.02771610e-01f, -2.13846624e-01f,
  1.45644620e-01f, -2.56596923e-01f, 1.40006527e-01f, 3.87811773e-02f, 1.72893196e-01f, 1.74635753e-01f, 4.41591628e-02f, -7.31468434e-03f, -4.06770669e-02f, 6.37610629e-02f,
  -1.46322638e-01f, -5.29249646e-02f, -1.04440592e-01f, -5.89320017e-03f, 1.11873113e-02f, -2.70978883e-02f, 8.57113898e-02f, -4.76901550e-05f, 7.62773752e-02f, 1.43927813e-01f,
  -5.08127036e-03f, 5.24582826e-02f, 4.59519848e-02f, -7.46217147e-02f, -4.37077833e-03f, 7.72692263e-02f, -1.09361939e-01f, -9.50128585e-03f, -1.90685559e-02f, -1.18131191e-01f,
  2.65471727e-01f, -2.16789424e-01f, 7.18379617e-02f, -1.36480033e-01f, -7.99353048e-02f, -9.70046129e-03f, -2.80146468e-02f, 1.35315210e-02f, -6.69718683e-02f, 2.13431325e-02f,
  -6.78617209e-02f, -5.03850281e-02f, -4.55163382e-02f, -1.15306281e-01f, 4.79073189e-02f, 4.82150167e-02f, -1.62925303e-01f, -4.79132496e-03f, -1.51873156e-01f, -1.37973517e-01f,
  -1.54643357e-01f, -6.53128698e-02f, 5.71459197e-02f, -8.92080739e-02f, -1.78731695e-01f, -3.42299193e-02f, -6.73501268e-02f, -1.68313622e-01f, -1.32885939e-02f, -9.03106257e-02f,
  -9.76349134e-03f, 4.89367433e-02f, 1.22628864e-02f, -4.65842001e-02f, 6.66507855e-02f, 2.71560214e-02f, 1.23432361e-01f, 1.50829237e-02f, 4.78858054e-02f, -2.55657639e-02f,
  7.32551515e-02f, -1.74276512e-02f, 3.23027112e-02f, -2.47345585e-02f, 4.02404591e-02f, -6.88213529e-03f, 1.26988720e-02f, -6.50449321e-02f, -1.48867248e-02f, 1.65340789e-02f,
  -5.05201407e-02f, -7.25984275e-02f, -5.64970076e-02f, -8.98591727e-02f, -4.60749343e-02f, 5.08021470e-03f, -4.78169769e-02f, -2.10741665e-02f, 2.98865661e-02f, -6.80139363e-02f,
  2.47339457e-01f, -5.66587150e-02f, 1.64586648e-01f, -5.25054075e-02f, -4.91641201e-02f, -6.75421953e-02f, -9.19387266e-02f, -3.87522089e-03f, -8.41801465e-02f, 1.04978457e-01f,
  -6.67780489e-02f, 3.47412303e-02f, -2.48492528e-02f, -1.17913000e-02f, 1.70915052e-01f, 7.26409629e-02f, -8.72051194e-02f, 8.00381601e-02f, -3.04685850e-02f, -6.02304824e-02f,
  -4.00000103e-02f, 1.02528840e-01f, 2.81286031e-01f, 2.28047520e-01f, -6.57274108e-03f, 2.34616518e-01f, 2.49751434e-01f, 1.49720520e-01f, 2.07623750e-01f, 3.25015426e-01f,
  5.45920670e-01f, -1.90534472e-01f, 2.78462674e-02f, 1.55695844e-02f, -1.18430015e-02f, 8.80385190e-03f, -1.13149241e-01f, 5.87907024e-02f, -1.75208207e-02f, 6.77981600e-02f,
  7.96890818e-03f, 1.13410689e-01f, 1.14346869e-01f, 1.03139438e-01f, 4.61629443e-02f, -5.68965934e-02f, -4.81159873e-02f, 6.98456839e-02f, 2.69572616e-01f, 1.06316902e-01f,
  -1.40718535e-01f, -1.21757211e-02f, 1.20948017e-01f, 9.89680737e-02f, -9.54901949e-02f, 4.49634902e-02f, -9.18520316e-02f, 3.66137456e-03f, -1.88051313e-01f, -1.88859075e-01f,
  -2.72859689e-02f, -4.49206941e-02f, 1.24286942e-01f, 2.37692194e-03f, -1.34968698e-01f, 2.15689186e-02f, 1.60825234e-02f, -7.74988979e-02f, 6.21758681e-03f, -8.47913623e-02f,
  -1.03930663e-02f, -6.24541789e-02f, 2.97058504e-02f, -2.80253962e-02f, -3.02255549e-03f, 8.16519037e-02f, -1.77422222e-02f, 8.29483867e-02f, 3.07066701e-02f, -1.04373053e-01f,
  -8.11936855e-02f, 2.43878271e-02f, -5.45777613e-03f, 1.62033476e-02f, -7.05589205e-02f, 3.94792669e-02f, -1.41301811e-01f, -4.68672216e-02f, 1.13458365e-01f, 7.20717162e-02f,
  6.96995854e-02f, 5.11358455e-02f, -9.78894159e-02f, 2.95639951e-02f, -4.14153449e-02f, 4.76866104e-02f, -4.92206104e-02f, -3.91539633e-02f, -3.78132015e-02f, -1.29276300e-02f,
  -8.18720162e-02f, 5.86045533e-02f, 9.71281715e-03f, 3.24967550e-03f, 1.77930910e-02f, -1.46957263e-02f, -3.62829142e-03f, -1.38981258e-02f, 1.37368049e-02f, 2.49439403e-02f,
  7.76985735e-02f, 5.71244322e-02f, 3.93577069e-02f, -3.52920480e-02f, -6.34347275e-02f, 1.69961099e-02f, -3.43936719e-02f, -4.32517417e-02f, -2.33302489e-02f, 3.07792239e-02f,
  -1.92540586e-01f, -2.25290898e-02f, 5.74117079e-02f, 6.95612356e-02f, 1.00188665e-01f, -6.55230209e-02f, -2.51522511e-02f, -6.45068614e-03f, -9.89076588e-03f, -8.16394091e-02f,
  1.24393841e-02f, 1.19503783e-02f, -9.40309390e-02f, -5.50201014e-02f, 8.49103928e-02f, 1.37428818e-02f, 2.92861387e-02f, 3.62385176e-02f, -1.07456729e-01f, -7.01363012e-02f,
  -1.30101278e-01f, 1.02203280e-01f, 2.05010220e-01f, 9.74269211e-02f, 1.81985889e-02f, 1.75734729e-01f, -6.94705639e-03f, 1.05978493e-02f, 8.05948377e-02f, 1.34369969e-01f,
  1.41476572e-01f, 1.84304982e-01f, -2.34359801e-02f, 2.00556014e-02f, -1.85827896e-01f, -4.23969468e-03f, 4.51665698e-03f, 1.29570380e-01f, 1.39182761e-01f, 7.43743181e-02f,
  -5.93898073e-02f, -3.94865647e-02f, 1.48430824e-01f, 1.91831604e-01f, 1.44176155e-01f, 6.72077090e-02f, 1.35871738e-01f, 1.14013821e-01f, -3.18742245e-02f, 7.06714168e-02f,
  7.59903714e-02f, 6.51896074e-02f, 1.04801223e-01f, 1.91312004e-02f, 5.65701118e-03f, 1.26063615e-01f, 2.70562936e-02f, -4.48464602e-02f, 8.27634800e-03f, 1.75120682e-01f,
  -4.09822017e-02f, -4.06390056e-03f, 9.19227228e-02f, 3.05632800e-02f, -1.26695111e-01f, 9.41695198e-02f, 5.23032695e-02f, 3.89813967e-02f, 2.81319171e-02f, 3.65642942e-02f,
  1.90021540e-03f, -8.31658486e-03f, -3.91468257e-02f, 2.30706353e-02f, 4.04465534e-02f, 1.76946390e-02f, -5.15256375e-02f, 2.14648675e-02f, 9.91640314e-02f, 5.12961149e-02f,
  3.27536017e-02f, -1.39515800e-02f, -8.16263333e-02f, -7.05586001e-02f, 3.94438277e-04f, -1.67804696e-02f, -8.80000740e-02f, -7.33859986e-02f, 9.44971889e-02f, 9.56428498e-02f,
  3.16171274e-02f, -1.69078428e-02f, -6.63624629e-02f, -8.72080121e-03f, 1.87546480e-02f, -5.78535013e-02f, 6.27438948e-02f, 3.45632918e-02f, -1.48840901e-02f, -5.45675382e-02f,
  3.84465680e-02f, -4.17261049e-02f, -5.05648702e-02f, -3.62983681e-02f, 6.08066581e-02f, -9.45306495e-02f, -6.19000159e-02f, 4.54090759e-02f, 1.13939866e-02f, -2.89814025e-02f,
  3.71373855e-02f, -4.27856967e-02f, 4.67840862e-03f, 4.42029163e-02f, 1.32503640e-02f, -4.30860668e-02f, 3.72835100e-02f, -4.16833423e-02f, -2.99448986e-02f, -6.24790937e-02f,
  3.50462012e-02f, -1.40276790e-01f, 1.00840330e-01f, 5.92219792e-02f, -1.02149695e-01f, -3.08316723e-02f, -4.30203639e-02f, 1.42480340e-02f, -8.01650248e-03f, -2.29730625e-02f,
  -9.20825824e-02f, 7.30177686e-02f, -5.51321544e-03f, -1.79361552e-02f, -3.56647596e-02f, -1.06851436e-01f, -1.35657145e-03f, -2.80260900e-03f, 3.05027757e-02f, -8.63330811e-03f,
  3.26961428e-02f, 7.49976374e-03f, -3.54359075e-02f, 3.40673998e-02f, 4.97661754e-02f, -2.52366122e-02f, -6.36775494e-02f, -5.74644282e-02f, -4.14029099e-02f, 5.50132431e-02f,
  7.03396350e-02f, -9.03637186e-02f, -3.92300300e-02f, 5.40757086e-03f, -4.26484086e-02f, -6.54143691e-02f, -1.61137626e-01f, 5.25961397e-03f, -4.45236079e-02f, 2.23983917e-02f,
  -1.69462368e-01f, -9.63223055e-02f, 5.54588214e-02f, 5.17918393e-02f, -2.56866459e-02f, 2.13233083e-02f, -5.94696328e-02f, 4.12575714e-02f, 1.12078741e-01f, -5.26730455e-02f,
  -5.29077426e-02f, 8.87358412e-02f, 7.54186511e-02f, 3.75363864e-02f, -3.94200459e-02f, -2.63535026e-02f, 5.70818894e-02f, -8.71394575e-02f, -4.85776812e-02f, 2.88274996e-02f,
  -2.45743804e-02f, -6.26276899e-03f, 1.57156345e-02f, 6.86970800e-02f, 8.31912234e-02f, -2.47769188e-02f, 6.72193691e-02f, 8.19621757e-02f, -3.78222354e-02f, -1.77984070e-02f,
  -6.68147579e-02f, -1.91661529e-03f, 3.82736586e-02f, 7.03924149e-02f, 8.74809325e-02f, -4.71675508e-02f, 3.65188457e-02f, 1.11227922e-01f, 5.25278877e-03f, 2.88429428e-02f,
  -8.68023559e-02f, -1.12313509e-01f, 3.51817091e-03f, 2.33223452e-03f, 1.06766626e-01f, -7.31902868e-02f, 3.78434546e-02f, 4.93769348e-03f, -6.84789345e-02f, 1.33026335e-02f,
  7.31448159e-02f, 1.42524799e-03f, -3.36729251e-02f, -1.88961830e-02f, 2.36708932e-02f, 2.61169393e-02f, 3.58261652e-02f, -3.47911827e-02f, 8.15422088e-03f, 6.52275085e-02f,
  -7.18572512e-02f, -9.77470353e-02f, 4.91498411e-03f, -2.74764244e-02f, -3.83265577e-02f, -1.05856517e-02f, -6.72890395e-02f, 6.63925260e-02f, 6.34715483e-02f, -7.18181357e-02f,
  -1.93292964e-02f, 7.99289420e-02f, 8.97422284e-02f, 7.49309286e-02f, -3.75483595e-02f, 7.28787854e-02f, -9.74934474e-02f, 4.55056410e-03f, -3.02497353e-02f, 2.39031464e-02f,
  7.90119246e-02f, -3.17875743e-02f, 1.18950913e-02f, -3.68632562e-02f, 3.35765928e-02f, 3.82577851e-02f, -4.85539297e-03f, 5.66973165e-02f, -1.23573337e-02f, -1.77318547e-02f,
  7.26938248e-02f, 2.04936508e-02f, -3.61455278e-03f, -5.23621701e-02f, 9.68331471e-02f, 1.45536251e-02f, 4.50425670e-02f, -2.66918764e-02f, -1.64293796e-02f, -4.01643254e-02f,
  9.28694475e-03f, 3.95909958e-02f, -6.26683012e-02f, 3.16833518e-02f, 4.48033065e-02f, -9.86651853e-02f, -4.89340685e-02f, -9.78031196e-03f, -5.03334180e-02f, 2.84222271e-02f,
  -1.37009189e-01f, -4.44796495e-02f, -1.03540584e-01f, 3.25623564e-02f, 6.12162687e-02f, 8.23022723e-02f, 9.37812310e-03f, -1.10631146e-01f, 7.98705295e-02f, 9.92817134e-02f,
  1.12959534e-01f, 8.85386094e-02f, 1.34832010e-01f, 5.20277619e-02f, -6.24019355e-02f, 3.57846841e-02f, 3.82256024e-02f, -8.22306350e-02f, -2.86271702e-02f, -3.63067575e-02f,
  3.72804143e-02f, 8.12942311e-02f, 6.36665747e-02f, -2.02424880e-02f, 1.18964175e-02f, 1.18512124e-01f, -4.01325449e-02f, 7.79565610e-03f, 1.27018929e-01f, 3.98411863e-02f,
  -4.30212170e-02f, -8.78974888e-03f, -1.93370637e-02f, 7.98490793e-02f, -7.10073262e-02f, -1.60881784e-02f, 5.07225692e-02f, -2.40176357e-02f, -3.73526523e-03f, -6.67175576e-02f,
  2.34875679e-02f, 3.75932269e-02f, 5.31707294e-02f, -9.99007821e-02f, -6.18932806e-02f, 3.96215357e-02f, -1.15521394e-01f, -1.09494083e-01f, -6.23880029e-02f, -7.44154751e-02f,
  -3.47048230e-02f, 2.29743402e-02f, -1.15485433e-02f, -9.58060101e-03f, 2.19669659e-02f, -1.23768896e-02f, -9.76916924e-02f, -6.37469366e-02f, -1.43009778e-02f, -3.31241749e-02f,
  1.20568145e-02f, -5.23869917e-02f, -8.39814264e-03f, 5.40047549e-02f, 2.76859347e-02f, 7.31447386e-03f, 2.95691881e-02f, 7.03355297e-02f, -7.45178759e-02f, 2.27145832e-02f,
  4.28919345e-02f, -6.61916062e-02f, 6.11906610e-02f, -7.21115768e-02f, -6.05036989e-02f, 1.44463880e-02f, 8.99416208e-02f, -2.78765615e-02f, 5.23877889e-02f, -1.03662066e-01f,
  5.74373864e-02f, 6.71078591e-03f, 6.05265871e-02f, -1.65033992e-02f, 4.13101241e-02f, -8.40801969e-02f, 4.54611816e-02f, 1.22249899e-02f, -2.87028924e-02f, -8.61187726e-02f,
  9.04682726e-02f, -1.16089180e-01f, 7.93687105e-02f, 2.72113215e-02f, -1.54931471e-02f, 2.44473647e-02f, -3.25318836e-02f, 2.62519494e-02f, -3.53197493e-02f, -2.70099230e-02f,
  -4.04954478e-02f, 1.18012400e-02f, -3.38013358e-02f, 4.67878059e-02f, 9.25265700e-02f, -5.38203903e-02f, -6.42608618e-03f, 7.46344104e-02f, 6.04016855e-02f, -3.94191332e-02f,
  4.15433757e-03f, -5.60640991e-02f, 1.32604111e-02f, -9.49418545e-02f, 1.01606781e-02f, 1.27206801e-03f, -1.37541126e-02f, -5.32939695e-02f, -1.00714639e-01f, 5.82738221e-02f,
  8.61304030e-02f, 1.58465743e-01f, 2.95105502e-02f, -4.63586748e-02f, 1.31562904e-01f, 8.93503986e-03f, 1.98992655e-01f, 1.89845294e-01f, 6.25443533e-02f, 1.55558595e-02f,
  6.75856173e-02f, 7.29896426e-02f, -3.47572900e-02f, -6.90075010e-02f, 4.75653214e-03f, 1.30348876e-02f, 2.63738316e-02f, -1.66388795e-01f, -9.55672786e-02f, 4.59762029e-02f,
  -5.08162044e-02f, -7.20078871e-02f, 1.83539763e-02f, 6.00065440e-02f, -4.02211361e-02f, -9.60103571e-02f, -1.07308932e-01f, -9.39964876e-02f, 5.78256361e-02f, -1.13843761e-01f,
  -1.71711728e-01f, 9.96034667e-02f, -2.95005459e-02f, 5.00364462e-03f, 5.32246530e-02f, -1.07137114e-01f, -1.09231076e-03f, 1.34707680e-02f, -6.82803243e-02f, 2.43916083e-02f,
  2.19820105e-02f, -9.02197212e-02f, -3.78139764e-02f, -5.85019551e-02f, -2.86186673e-02f, 1.98749732e-02f, -2.14300212e-02f, -4.71141078e-02f, 7.93867279e-03f, 3.07246856e-02f,
  5.29442057e-02f, -5.39011881e-02f, 2.03795433e-02f, -9.28247347e-02f, -8.09776038e-02f, -8.07604119e-02f, 7.02319965e-02f, -6.27417564e-02f, 1.55541608e-02f, -5.28896116e-02f,
  1.94283621e-03f, -1.07506348e-03f, -6.09573573e-02f, -4.02862988e-02f, -7.76022021e-03f, 7.40165124e-03f, -6.03666380e-02f, 4.18388285e-03f, -1.46024991e-04f, 1.34345219e-02f,
  -8.33132304e-03f, 4.32957374e-02f, 5.38514880e-03f, -3.54038402e-02f, -4.26935703e-02f, 4.98364903e-02f, -1.55152371e-02f, -5.05900122e-02f, 5.80684375e-03f, -2.56233905e-02f,
  2.01951377e-02f, 7.59430528e-02f, -5.58301955e-02f, 1.91662591e-02f, -8.18801150e-02f, 9.20664519e-02f, -3.49819288e-02f, 8.45102668e-02f, 2.17477847e-02f, 1.12599678e-01f,
  -5.29299118e-02f, -8.59128982e-02f, -3.47704776e-02f, 6.68264702e-02f, -1.02827109e-01f, 4.64216992e-02f, -7.28221089e-02f, 6.55775219e-02f, -2.71274522e-02f, 5.36136553e-02f,
  -1.31928017e-02f, -7.15809241e-02f, 9.53276232e-02f, -7.73077458e-02f, -7.10418895e-02f, -2.46914309e-02f, -9.86343473e-02f, 1.10304623e-03f, 2.60299649e-02f, 2.56303512e-02f,
  -7.24335983e-02f, -3.52909565e-02f, -6.40704902e-03f, 3.01278550e-02f, -1.27845686e-02f, -1.13913529e-02f, -1.20317079e-01f, -1.00053221e-01f, -7.83497095e-02f, -1.11956075e-02f,
  9.34484676e-02f, -7.21881688e-02f, -2.02489868e-02f, 1.48630157e-01f, -6.14094809e-02f, 4.17178683e-02f, 2.56229937e-02f, -3.08989324e-02f, 6.60444871e-02f, 6.95539936e-02f,
  3.71036455e-02f, 1.95771039e-01f, 2.20885411e-01f, 4.17468213e-02f, 4.54840250e-02f, 1.84044931e-02f, -9.61008593e-02f, -4.62294146e-02f, 1.29820928e-01f, 1.03436515e-01f,
  1.02295950e-01f, -5.51695414e-02f, 8.04369748e-02f, 8.00627321e-02f, 4.03474905e-02f, 8.41585770e-02f, 2.75547281e-02f, -8.55448097e-02f, 4.12376411e-02f, -4.24553128e-03f,
  -5.41177727e-02f, 2.99661346e-02f, 1.67434067e-01f, 3.43962722e-02f, 9.84459184e-03f, 8.83339718e-02f, 1.31178424e-02f, -8.42282828e-03f, 4.69350815e-03f, -6.10625222e-02f,
  4.96392883e-02f, 1.35124817e-01f, 1.07294887e-01f, -1.67943491e-03f, 3.87750231e-02f, -3.32387388e-02f, 2.13473234e-02f, -5.95273376e-02f, -1.30321886e-02f, -4.58230935e-02f,
  6.98334128e-02f, 7.73856938e-02f, 4.14237678e-02f, -5.10167191e-03f, 8.74730647e-02f, 1.24589927e-01f, 4.23507988e-02f, 1.09678447e-01f, 7.15756267e-02f, 6.29127622e-02f,
  -6.59701377e-02f, -4.17263620e-02f, -5.62251098e-02f, 1.29939374e-02f, -2.02373322e-02f, 6.28458709e-02f, 4.44955491e-02f, -3.85908596e-02f, 7.18586147e-02f, -3.16728023e-03f,
  -3.19565088e-02f, 1.97967105e-02f, 3.66606563e-02f, -6.51265904e-02f, -4.41911211e-03f, -1.28698244e-03f, -8.87688920e-02f, -6.74194619e-02f, 6.72815293e-02f, 6.50393814e-02f,
  1.72140282e-02f, -1.06938235e-01f, -8.39852765e-02f, -1.39516173e-02f, 6.24691211e-02f, 7.39006177e-02f, -6.10425211e-02f, 3.67395282e-02f, 9.13797319e-02f, -8.96474272e-02f,
  -1.70148462e-02f, 2.10495323e-01f, 4.52656113e-02f, 8.29394385e-02f, -4.13010269e-02f, 7.87297040e-02f, -1.80745274e-02f, -1.24933606e-03f, -5.05392961e-02f, 1.93747110e-03f,
  -5.21138161e-02f, 5.61642982e-02f, -5.28014824e-03f, -2.07190942e-02f, 1.71141066e-02f, -1.49596967e-02f, -2.49616317e-02f, 1.93591155e-02f, -5.76127023e-02f, 3.82637093e-03f,
  9.12997872e-02f, -1.90734714e-02f, 5.95461251e-03f, 6.06958009e-02f, 1.20980255e-01f, 6.25987649e-02f, -3.36154625e-02f, -4.89158370e-02f, 1.01136133e-01f, -2.86409836e-02f,
  8.37999117e-03f, -2.59505898e-01f, -2.48963520e-01f, -2.76513211e-02f, -1.26618132e-01f, -8.31259191e-02f, -1.57181591e-01f, 9.04173404e-02f, 4.89101410e-02f, -1.33083299e-01f,
  -1.50233090e-01f, -5.92734814e-02f, 5.01095019e-02f, -6.78189695e-02f, -5.04217856e-02f, -1.76205456e-01f, -1.68237552e-01f, -1.12837538e-01f, 4.39247005e-02f, 7.91359171e-02f,
  -1.19736888e-01f, 2.26572677e-02f, 4.67136614e-02f, 9.72454026e-02f, -9.01506916e-02f, -1.12390652e-01f, -2.05206573e-01f, -1.47021981e-02f, -2.96568237e-02f, -2.64986694e-01f,
  -1.37517750e-01f, 3.59246954e-02f, 7.12422952e-02f, 9.70272124e-02f, -2.60759089e-02f, -3.68740447e-02f, -5.44905812e-02f, -1.20429983e-02f, 1.00629963e-01f, 2.67462637e-02f,
  3.04583460e-02f, 7.14640990e-02f, 7.28204250e-02f, -5.73833361e-02f, 9.99340490e-02f, 7.95503780e-02f, -2.51341909e-02f, -2.04523876e-02f, 1.00281782e-01f, 3.65309790e-02f,
  -1.34957312e-02f, -1.60010010e-02f, 8.24845731e-02f, 1.74416937e-02f, -4.27670740e-02f, -7.05061480e-02f, 1.96427237e-02f, -2.37297062e-02f, -4.91130464e-02f, -1.46228403e-01f,
  3.40678194e-03f, -7.15440698e-03f, -5.40302731e-02f, 9.57575962e-02f, -4.32320647e-02f, 4.25037444e-02f, 6.74170479e-02f, 2.18471643e-02f, 7.73700029e-02f, 2.61347499e-02f,
  1.63620599e-02f, 2.37176493e-02f, 1.69161279e-02f, -6.27337769e-02f, -1.16745830e-02f, 3.01978309e-02f, 6.04395457e-02f, -3.31772193e-02f, -5.08071780e-02f, -2.84285378e-02f,
  -4.54347432e-02f, 5.94495721e-02f, 2.50135027e-02f, 6.81530386e-02f, -7.77160525e-02f, -3.89855132e-02f, 3.20738964e-02f, 1.33866807e-02f, 7.41354600e-02f, -8.07625651e-02f,
  -6.72782212e-02f, 2.74947081e-02f, -1.00616897e-02f, 8.92051458e-02f, -9.49047208e-02f, 5.68722114e-02f, -5.25474921e-02f, 5.89323938e-02f, -2.67778262e-02f, -3.59508023e-02f,
  -4.97951247e-02f, -2.12411862e-02f, -3.11340746e-02f, -2.72313319e-02f, -7.27334023e-02f, -1.29275424e-02f, -9.40104723e-02f, -5.72560057e-02f, 7.79153556e-02f, 1.44789340e-02f,
  2.32138783e-02f, 6.43265322e-02f, 5.57524487e-02f, -8.05766694e-03f, -5.39909163e-03f, 8.68129730e-02f, -1.06713377e-01f, -7.91458637e-02f, -5.94723634e-02f, -1.39821380e-01f,
  1.53433224e-02f, 3.64734948e-01f, 4.49259043e-01f, -2.12243441e-02f, -7.92712048e-02f, -9.73312706e-02f, 6.89511141e-03f, -1.86459079e-01f, -8.77252445e-02f, 8.36753920e-02f,
  5.62569238e-02f, -1.69859082e-01f, -1.18258491e-01f, -7.89758861e-02f, -1.32684186e-01f, 3.27648595e-02f, 2.01266035e-01f, 8.77723098e-02f, -2.65372276e-01f, -2.79100299e-01f,
  -2.08979145e-01f, -2.32276451e-02f, 9.60025936e-02f, 6.24482781e-02f, -4.71077599e-02f, -1.31204575e-01f, 2.39034057e-01f, 4.28226516e-02f, 1.03891239e-01f, 1.35015920e-01f,
  1.94684267e-01f, 2.85192221e-01f, -1.97616205e-01f, -1.16783507e-01f, 1.30753592e-01f, 2.49738544e-02f, 9.56582930e-03f, 2.28630528e-02f, 6.59325421e-02f, 7.51872361e-03f,
  8.65277350e-02f, -3.51562873e-02f, 5.49286753e-02f, 1.68981142e-02f, -1.11849979e-03f, -2.18981579e-02f, 5.59213459e-02f, -1.70061067e-02f, -8.95304233e-02f, -2.38662418e-02f,
  -6.94763213e-02f, -6.71202317e-02f, -7.84951914e-03f, -2.80437600e-02f, 8.83009136e-02f, -1.55047208e-01f, 1.96590088e-02f, -4.75458428e-02f, 7.34802336e-02f, 8.12056363e-02f,
  -7.17592537e-02f, -2.78703682e-03f, -6.30029142e-02f, -3.69024836e-02f, -1.53745653e-03f, 3.94019485e-02f, 2.30848677e-02f, 2.40085982e-02f, -2.25885995e-02f, 3.35912704e-02f,
  -2.60627531e-02f, 3.36582251e-02f, -5.28851748e-02f, 5.36034256e-02f, -9.43133831e-02f, 5.58209307e-02f, -6.40313607e-03f, -6.91295564e-02f, 2.69561447e-03f, -4.73585241e-02f,
  -7.09397793e-02f, 5.13266809e-02f, 2.98115592e-02f, -9.91427526e-03f, 7.58171752e-02f, 4.48317416e-02f, -3.42551712e-03f, -1.03065940e-02f, -6.73764665e-03f, 3.44357453e-02f,
  -2.95862824e-01f, -5.20741306e-02f, -3.74971963e-02f, -1.39691621e-01f, 9.39483419e-02f, 1.08797587e-02f, 7.28580356e-02f, -2.55815070e-02f, 3.85542586e-02f, 1.60820186e-02f,
  1.05597097e-02f, -9.85477716e-02f, 2.45553404e-02f, -1.35461077e-01f, -1.92220643e-01f, -1.00707769e-01f, -5.43091930e-02f, -1.93940755e-02f, -9.12907943e-02f, -1.12757392e-01f,
  -5.16486168e-02f, -2.46484056e-01f, -2.84035444e-01f, -1.83359757e-01f, -1.09483421e-01f, -2.10205406e-01f, -2.19424099e-01f, -2.66867667e-01f, -2.77369499e-01f, -2.71229595e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 40)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 40;
const float L0_fan_Bp_bar_data[] = {
  9.19086337e-02f, 2.24287331e-01f, 4.36647348e-02f, 1.83004484e-01f, 1.53444797e-01f, 8.02160054e-02f, 1.83797076e-01f, 9.99544337e-02f, 1.65370151e-01f, 1.45245060e-01f,
  -5.47187887e-02f, 1.47999182e-01f, 6.91680834e-02f, 6.11363798e-02f, 9.82549936e-02f, 7.01804012e-02f, 3.72465067e-02f, 1.81249194e-02f, 1.66400820e-01f, 3.74685787e-02f,
  1.85290575e-01f, 1.54618942e-03f, 1.15956388e-01f, 2.54978985e-01f, 2.23727718e-01f, 2.42393702e-01f, 1.73665956e-01f, 1.84296906e-01f, 2.57829260e-02f, 2.80096680e-01f,
  2.75856853e-01f, 3.20830345e-01f, 2.92228669e-01f, 2.42183600e-02f, 7.11584017e-02f, 1.73629280e-02f, 2.13834159e-02f, -5.14507815e-02f, 1.27570480e-01f, 3.90537918e-01f
};

// L1_linear_W (Shape: 12 x 64)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 64;
const float L1_linear_W_data[] = {
  -5.33430278e-01f, -4.13285345e-01f, -5.38315699e-02f, 6.39382824e-02f, -2.84200371e-03f, -2.57928371e-01f, -1.00379601e-01f, -1.71829328e-01f, -5.00793010e-02f, -2.93170899e-01f,
  -4.60975677e-01f, -3.56886864e-01f, 2.06021011e-01f, 1.35019138e-01f, 4.79130968e-02f, -1.35903461e-02f, 2.27478191e-01f, -5.36806285e-02f, -1.92100808e-01f, 4.84567210e-02f,
  1.32374659e-01f, -3.47770721e-01f, 4.84846234e-01f, 1.99166298e-01f, -7.27506876e-02f, 2.71096796e-01f, 4.18629423e-02f, -2.40160242e-01f, -1.34112597e-01f, 9.40162688e-02f,
  -3.03482056e-01f, -2.61336595e-01f, 2.38256101e-02f, 4.56298590e-01f, -9.84696075e-02f, -2.66165584e-01f, -1.43668661e-02f, 5.66217363e-01f, 4.17789876e-01f, -1.86825648e-01f,
  -7.45773166e-02f, -1.34916678e-01f, 3.32590053e-03f, 1.32019833e-01f, 2.89797693e-01f, 4.90976751e-01f, -1.88677981e-02f, 3.66829783e-02f, -6.56182244e-02f, -1.92798585e-01f,
  -1.57007068e-01f, -2.82530397e-01f, 8.21499527e-02f, 1.38465255e-01f, 2.01036111e-01f, -2.64077395e-01f, -1.64737776e-02f, 2.80375313e-02f, 1.57592401e-01f, -1.77275315e-02f,
  1.16391756e-01f, 4.15691510e-02f, 5.53831160e-01f, -6.27209187e-01f, 2.32627273e-01f, -1.76377013e-01f, 1.28195181e-01f, 1.23884223e-01f, -3.35723907e-01f, 1.66835934e-01f,
  1.60436094e-01f, 2.09619895e-01f, -5.91420382e-02f, 1.64384335e-01f, 7.98868537e-02f, -5.77055991e-01f, 5.61821342e-01f, 4.71478671e-01f, -4.93331939e-01f, -5.14100045e-02f,
  5.95018744e-01f, -8.83732364e-03f, 4.02000040e-01f, 1.01325050e-01f, -2.54697680e-01f, 9.76679940e-03f, -3.38655472e-01f, 5.47341723e-03f, -7.70977065e-02f, 1.82265952e-01f,
  5.51778018e-01f, 2.16408625e-01f, 4.86614943e-01f, -1.94165874e-02f, -1.92461342e-01f, 6.65449202e-02f, 1.04727391e-02f, 2.37450913e-01f, -1.84850886e-01f, -2.04998910e-01f,
  4.84272055e-02f, 6.83499217e-01f, -1.77462518e-01f, 1.68580189e-01f, -2.65149951e-01f, 3.46568204e-03f, 4.90469225e-02f, -7.68964365e-02f, -4.53856170e-01f, 3.75275090e-02f,
  -5.08493483e-01f, 5.80951869e-02f, 6.59107789e-02f, 2.95239210e-01f, 2.84053758e-02f, -1.19208261e-01f, -8.82218406e-02f, 3.39924842e-01f, -5.07569537e-02f, 1.64330691e-01f,
  6.99423373e-01f, 1.07013315e-01f, 4.26900834e-02f, 7.56651908e-02f, -7.54395649e-02f, 2.90300131e-01f, 3.29800636e-01f, -4.78056222e-01f, -8.15059394e-02f, 5.42137742e-01f,
  1.73225939e-01f, -2.16301940e-02f, 2.16562822e-01f, 1.62770420e-01f, 2.78469205e-01f, -2.00755104e-01f, 6.23575076e-02f, 2.94309556e-01f, 2.03996748e-01f, 2.07446888e-01f,
  4.64362323e-01f, 1.13425665e-01f, -1.73916325e-01f, 4.36534166e-01f, -7.54716694e-02f, -2.57865917e-02f, 7.90185705e-02f, 6.62466884e-01f, 1.88577726e-01f, 1.19240582e-01f,
  5.54728955e-02f, 3.91511887e-01f, -2.38002807e-01f, -1.47910640e-01f, -1.84518665e-01f, 7.86290690e-03f, -1.27809182e-01f, -2.18491122e-01f, -2.37166047e-01f, -1.48640379e-01f,
  -1.38632059e-01f, 3.95250499e-01f, -5.79581074e-02f, -1.48204342e-01f, -1.15786858e-01f, -3.70066136e-01f, 1.13054499e-01f, -2.29533717e-01f, -2.67477274e-01f, -2.44195610e-01f,
  -4.03375402e-02f, 1.64095044e-01f, -2.62045801e-01f, -3.56467277e-01f, -1.47434669e-02f, -4.31671105e-02f, 5.73032536e-02f, 4.80233788e-01f, 2.06298858e-01f, 2.48576254e-01f,
  -1.39238626e-01f, -7.36418739e-02f, 9.80515599e-01f, -2.18900368e-01f, 2.76741814e-02f, 1.77285578e-02f, 2.16163486e-01f, -1.73071891e-01f, -1.96494818e-01f, 1.49683863e-01f,
  1.13084957e-01f, 1.90344855e-01f, 2.09854648e-01f, 1.59643620e-01f, -9.92991105e-02f, -4.06924449e-02f, 1.00895911e-01f, 1.75574213e-01f, 5.02151847e-02f, -2.66732484e-01f,
  1.17540553e-01f, 1.44106284e-01f, 1.64640456e-01f, -8.26075953e-03f, -4.83985543e-02f, 3.11913311e-01f, -4.98796403e-01f, 1.91741869e-01f, 5.60764037e-02f, -6.08293638e-02f,
  -1.98489800e-01f, 1.11059085e-01f, -5.72348654e-01f, 3.56975436e-01f, 4.74335104e-02f, 3.00688654e-01f, 2.65086489e-03f, -4.74126637e-01f, -2.14187950e-01f, -1.87202394e-01f,
  -3.17984074e-01f, -6.14887811e-02f, -7.39304675e-03f, -1.27257602e-02f, -1.23390287e-01f, 3.58590521e-02f, -1.01321965e-01f, 1.27303571e-01f, -1.17787816e-01f, -1.24152847e-01f,
  -7.90312067e-02f, -5.79048740e-03f, 1.08202660e+00f, -1.34968802e-01f, -2.18744174e-01f, -1.62731469e-01f, 4.66536462e-01f, 3.88615727e-01f, 2.09031686e-01f, 3.90364617e-01f,
  -1.75504580e-01f, -1.30085260e-01f, 2.81440854e-01f, -4.41605657e-01f, 2.06784815e-01f, -5.95945656e-01f, -9.62773561e-02f, -1.33934021e-01f, -6.95940899e-03f, -2.44969092e-02f,
  -1.68802291e-01f, -1.07292414e-01f, 2.08581146e-02f, -1.11763954e-01f, -1.89710185e-02f, 1.74198464e-01f, -3.29725325e-01f, 4.84327286e-01f, 3.47605580e-03f, -3.68769139e-01f,
  -2.77774692e-01f, -5.10597706e-01f, -4.79173273e-01f, -2.40131877e-02f, -3.73665877e-02f, 1.11619726e-01f, 2.61313111e-01f, 2.79463530e-01f, 1.25647962e-01f, 2.30648890e-01f,
  2.66644388e-01f, 7.70455003e-02f, -2.81067461e-01f, 3.10411245e-01f, -3.58586013e-01f, 1.34109095e-01f, 3.35796773e-01f, -2.07169697e-01f, -3.07248741e-01f, -2.03026921e-01f,
  -4.14889120e-02f, 4.56803113e-01f, -1.31069690e-01f, 7.98826069e-02f, -1.20053828e-01f, -9.27515402e-02f, 2.82352746e-01f, -2.85097044e-02f, 9.31000337e-02f, -1.79501668e-01f,
  9.74148586e-02f, -2.74257302e-01f, -4.98227961e-02f, 2.23206982e-01f, -1.10632673e-01f, 7.66139850e-02f, 4.80102718e-01f, -2.69935191e-01f, 1.94590032e-01f, -3.10280230e-02f,
  3.16236287e-01f, 2.13550195e-01f, -1.27493134e-02f, -1.06844522e-01f, -1.57463282e-01f, -3.96939740e-02f, 2.00680822e-01f, 6.34862304e-01f, 2.33116522e-01f, 1.89942285e-01f,
  -2.65550852e-01f, -1.84245571e-01f, -1.32920191e-01f, -3.44572142e-02f, 3.35494094e-02f, -2.28225328e-02f, 2.37584915e-02f, 4.87416610e-02f, 2.98810527e-02f, 4.33323562e-01f,
  2.65218973e-01f, 3.37745428e-01f, 6.09769067e-03f, -5.74411936e-02f, 2.36294642e-01f, 2.09943101e-01f, 2.30635375e-01f, 2.07439035e-01f, 9.85911340e-02f, 4.52819496e-01f,
  3.83063890e-02f, 2.58289427e-01f, -5.06344616e-01f, 3.40638846e-01f, 6.63969100e-01f, -8.09000671e-01f, 2.29126737e-01f, 3.32205087e-01f, -1.64389536e-01f, -4.77521688e-01f,
  1.84416473e-01f, -1.55055553e-01f, 1.43785626e-01f, 3.11547965e-01f, 2.66233802e-01f, 1.88197926e-01f, -9.89745837e-03f, 5.75933874e-01f, -4.07939255e-02f, 3.65852416e-01f,
  3.89297932e-01f, 4.66470718e-02f, -9.03035775e-02f, -1.81176916e-01f, -1.06350683e-01f, -1.58934563e-01f, 1.03327177e-01f, 1.56013757e-01f, 2.53524095e-01f, 1.65028468e-01f,
  -2.30276167e-01f, 6.90524839e-03f, -1.28948629e-01f, 1.23761175e-02f, -5.79280443e-02f, 2.04143465e-01f, 1.75711513e-02f, -1.23151310e-01f, -1.20869443e-01f, -1.80083826e-01f,
  -2.40587458e-01f, -2.10870132e-01f, 6.02246635e-02f, 8.51668358e-01f, -3.03374559e-01f, 8.99947807e-02f, 6.86228871e-02f, 2.28781477e-01f, 1.29895434e-01f, 5.10312654e-02f,
  7.39102364e-02f, -8.48728511e-03f, 4.03670929e-02f, -5.14148891e-01f, 3.35595936e-01f, -2.10545659e-01f, -7.33625069e-02f, 1.17369063e-01f, 3.79437208e-01f, 2.18513861e-01f,
  7.75324181e-02f, -1.98720433e-02f, -4.95347291e-01f, 1.33215010e-01f, -1.36714548e-01f, -2.02805623e-01f, -1.90694034e-01f, -4.23596650e-01f, 2.82852530e-01f, -8.27308670e-02f,
  4.96716201e-02f, -1.71419770e-01f, -3.24551277e-02f, -5.01735270e-01f, 5.22089779e-01f, -2.13171929e-01f, -2.07145944e-01f, -4.85390097e-01f, 2.20583394e-01f, 4.15879153e-02f,
  -1.45015612e-01f, -1.86141163e-01f, -3.63244824e-02f, -2.16237485e-01f, 2.70949066e-01f, -2.66231924e-01f, -1.48933068e-01f, -1.85106099e-01f, -8.62994790e-02f, -3.86939228e-01f,
  -2.76105344e-01f, -2.45808959e-01f, -2.91677892e-01f, 3.84299636e-01f, -1.13491364e-01f, 2.25114942e-01f, -1.93797052e-01f, 5.00905812e-01f, -3.92899007e-01f, -1.77942038e-01f,
  -1.58261791e-01f, -1.83935866e-01f, 4.09807980e-01f, 3.06163102e-01f, -1.94311365e-01f, 4.14329588e-01f, -2.89259642e-01f, -3.20451498e-01f, 4.31556314e-01f, -2.07062215e-01f,
  1.49676874e-01f, 3.69114071e-01f, 8.59358609e-02f, -1.76124632e-01f, -1.22528404e-01f, -1.50686100e-01f, -1.33927107e-01f, 4.70503360e-01f, -1.54882520e-01f, -1.45423040e-01f,
  -1.24385618e-01f, -2.40519181e-01f, 2.88004968e-02f, 1.26783341e-01f, 1.06131230e-02f, -1.75713357e-02f, -1.22303568e-01f, 4.47018817e-02f, -1.98188752e-01f, -1.70977116e-02f,
  -3.24142396e-01f, -2.56518453e-01f, -3.44308913e-02f, -2.60319650e-01f, -7.03510083e-03f, -5.36092520e-02f, -1.71782032e-01f, 2.92647690e-01f, -3.06418296e-02f, -1.14716804e-02f,
  4.11022455e-01f, 3.09380125e-02f, -1.06452733e-01f, -3.48148942e-02f, 3.42889518e-01f, -1.01590805e-01f, -1.52953327e-01f, -3.52876298e-02f, -1.89481471e-02f, 6.83421969e-01f,
  -2.78780282e-01f, -1.50101438e-01f, -2.56826798e-03f, 9.77209270e-01f, 7.76504502e-02f, -1.57947659e-01f, -9.63120237e-02f, -2.05762789e-01f, -3.05813514e-02f, -1.61012575e-01f,
  1.18681438e-01f, -1.23114064e-01f, -1.66965514e-01f, -1.41898602e-01f, 1.18954606e-01f, -1.71798721e-01f, 5.79160303e-02f, -4.02708739e-01f, -1.52973339e-01f, -1.94456428e-01f,
  7.88427368e-02f, -2.10591421e-01f, 5.07889898e-04f, -4.03436087e-02f, -2.86647737e-01f, 1.82423502e-01f, 1.21789584e-02f, 1.49425343e-01f, 1.18608356e-01f, -3.35457339e-03f,
  -7.84604177e-02f, -3.16040926e-02f, 8.91881511e-02f, 2.64654040e-01f, -2.73523084e-03f, 2.33141556e-01f, -1.18733376e-01f, -2.56253302e-01f, -1.62977338e-01f, 2.68057901e-02f,
  1.82870597e-01f, -2.09285989e-01f, 9.48638692e-02f, 2.37721384e-01f, -3.93722981e-01f, -1.90602303e-01f, 3.27917725e-01f, 3.11623991e-01f, 3.22210044e-01f, -5.37374377e-01f,
  4.35363173e-01f, -5.41606963e-01f, -1.30359143e-01f, 3.84116441e-01f, 1.86613407e-02f, 1.19156413e-01f, -1.78002883e-02f, -2.57265419e-01f, -7.77138993e-02f, 2.86884934e-01f,
  -2.19920259e-02f, -1.57424003e-01f, -1.96203887e-01f, 1.80646747e-01f, 3.97252552e-02f, -4.99426313e-02f, -1.53983301e-02f, -2.03074619e-01f, 4.89957422e-01f, -3.74799848e-01f,
  -1.62811145e-01f, -1.50174603e-01f, -2.15473652e-01f, -2.87197460e-03f, -1.08062238e-01f, -1.89911783e-01f, -1.58840120e-01f, -5.45386225e-02f, -3.56152087e-01f, 4.66329217e-01f,
  2.32297182e-01f, -2.36883208e-01f, -1.11268036e-01f, 1.90404914e-02f, 4.03485477e-01f, -1.31689638e-01f, -7.28858411e-02f, 7.68199980e-01f, 4.07227129e-01f, -1.99016586e-01f,
  6.08243160e-02f, 1.86478999e-02f, -1.43122166e-01f, -1.84930295e-01f, -1.13640442e-01f, -1.82457596e-01f, 2.45593384e-01f, 1.39336288e-01f, 6.46556839e-02f, 3.98589261e-02f,
  -4.77291524e-01f, -2.00436547e-01f, -4.91984263e-02f, 1.66222945e-01f, 3.53000522e-01f, -3.68997395e-01f, 2.13039964e-02f, 1.42448187e-01f, 5.70146739e-01f, -4.55787867e-01f,
  7.71278609e-03f, 2.33137310e-01f, -5.63183904e-01f, 2.33252883e-01f, -3.54829550e-01f, 7.37462044e-02f, 2.02913526e-02f, -5.12657702e-01f, 5.80358431e-02f, -2.89894938e-01f,
  5.61904013e-01f, 2.68364996e-01f, 3.59901577e-01f, -1.04931816e-01f, 8.00966546e-02f, 4.00087148e-01f, 1.08065614e-02f, -2.68165141e-01f, -1.18832409e-01f, -2.05242202e-01f,
  1.16263300e-01f, 3.11067700e-01f, 3.18177715e-02f, -2.75866687e-01f, 3.34024519e-01f, 2.27916047e-01f, -2.64426291e-01f, 5.61848640e-01f, -5.86304180e-02f, 1.59734681e-01f,
  2.41089910e-01f, -2.11239666e-01f, -8.97264406e-02f, -1.83912992e-01f, -4.75643307e-01f, 3.48859310e-01f, -1.45906568e-01f, 4.16584879e-01f, -1.21894240e-01f, -6.19870797e-02f,
  3.49834450e-02f, -5.84775917e-02f, -1.05857849e-01f, -9.22843814e-02f, -1.38879582e-01f, 1.58580288e-01f, -2.14863598e-01f, 1.13764547e-01f, -1.68611959e-01f, 1.00120418e-01f,
  2.26203963e-01f, -2.45342284e-01f, 5.03415875e-02f, -7.47755170e-02f, -2.75438000e-02f, 9.69930068e-02f, 1.31223515e-01f, 1.58602729e-01f, -1.00022703e-01f, -3.32120866e-01f,
  1.40135825e-01f, 1.72300532e-01f, 1.61581963e-01f, 4.18931067e-01f, 2.91486651e-01f, 4.36077505e-01f, -4.42229539e-01f, -7.41726607e-02f, -4.40283924e-01f, 2.08407521e-01f,
  -5.94967723e-01f, 5.03181219e-01f, 5.52761601e-03f, 1.58688873e-01f, -1.59492165e-01f, -3.04293722e-01f, -2.04283401e-01f, 1.75896212e-02f, 4.75168496e-01f, -2.22625788e-02f,
  1.84585318e-01f, 6.81232885e-02f, -2.21412957e-01f, -3.93299051e-02f, 2.07845047e-01f, -1.90889314e-01f, -1.41842261e-01f, 1.44508198e-01f, -2.21299112e-01f, -1.73016235e-01f,
  8.40561464e-03f, 3.60857025e-02f, 4.63404924e-01f, -5.42101227e-02f, -6.94687068e-02f, -3.24719965e-01f, 6.13563240e-01f, 7.16836900e-02f, -1.94549963e-01f, -1.81759685e-01f,
  -1.33022442e-01f, -1.26189232e-01f, -2.54976451e-01f, 6.93681911e-02f, -1.80543795e-01f, 5.64712882e-01f, -1.10394925e-01f, -3.48040871e-02f, -2.84485463e-02f, 7.63935819e-02f,
  1.65736750e-02f, -2.98343807e-01f, -1.01307474e-01f, -1.67783588e-01f, -4.37011361e-01f, -2.31446087e-01f, 1.71260089e-01f, 3.40387002e-02f, 7.45548978e-02f, 1.04398854e-01f,
  -1.05901565e-02f, 1.48686930e-03f, 2.85477400e-01f, 2.09579125e-01f, 3.18608172e-02f, 8.13930035e-02f, -5.61352491e-01f, -4.25291777e-01f, -4.48444784e-01f, -5.48308389e-03f,
  4.17111993e-01f, -3.37543368e-01f, 5.46979010e-01f, -3.33281666e-01f, -1.75065503e-01f, -3.78572285e-01f, -3.11992705e-01f, -3.79881889e-01f, -6.66792020e-02f, 4.86315638e-02f,
  -3.15380067e-01f, -1.33164838e-01f, -1.12262636e-01f, -4.29972224e-02f, -4.16147746e-02f, -2.61038125e-01f, 1.03744638e+00f, -1.45027727e-01f, 3.46058458e-02f, 4.51678522e-02f,
  4.88844179e-02f, -2.07777575e-01f, -1.46507487e-01f, -2.20205504e-02f, -3.24879284e-03f, -1.16137769e-02f, -7.10581690e-02f, 1.50086552e-01f, -4.20600213e-02f, 2.39684675e-02f,
  -1.73643887e-01f, -1.12232476e-01f, -1.45018548e-01f, -5.51347286e-02f, 1.89806119e-01f, -2.32682601e-01f, -1.23217657e-01f, -2.49725819e-01f, -2.28663638e-01f, -9.31307077e-02f,
  -5.98028302e-02f, -1.90918937e-01f, -1.05022579e-01f, -1.22555412e-01f, 2.64626324e-01f, -7.66955912e-02f, 7.30417445e-02f, 5.60388088e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -2.68248856e-01f, -1.24578342e-01f, 1.38603583e-01f, 8.45302828e-03f, -5.39966449e-02f, -1.92213468e-02f, -1.28388539e-01f, -7.06068873e-02f, -2.72040106e-02f, -9.60275158e-02f,
  4.72809263e-02f, 1.55326769e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 12, 40
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        64, 12
    );
    }
    