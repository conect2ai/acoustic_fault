/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  5.09303389e-03f, -3.59903998e-03f, 1.71149507e-01f, -5.35594905e-03f, 2.95129921e-02f, 1.56636894e-01f, 2.43907943e-01f, -4.17632870e-02f, -1.31866217e-01f, -9.98643935e-02f,
  -5.46809658e-02f, -1.56087764e-02f, -3.93768512e-02f, -6.06133696e-03f, 2.91050792e-01f, -1.13787979e-01f, 1.24121912e-01f, -6.49464428e-02f, -1.40509143e-01f, 2.86962148e-02f,
  -2.63383314e-02f, -9.79835168e-02f, 7.56994486e-02f, -1.43597156e-01f, 1.68509968e-02f, -5.39999045e-02f, -4.29499410e-02f, 7.80249611e-02f, -1.48746660e-02f, 2.22218689e-02f,
  8.55504572e-02f, -1.26826525e-01f, -1.06372526e-02f, -3.06560919e-02f, 1.35082304e-01f, 8.41134135e-03f, 7.26768672e-02f, 2.83818655e-02f, -2.77968328e-02f, 3.49854631e-03f,
  1.82599295e-02f, -2.97332406e-02f, 8.61976296e-03f, 2.48695407e-02f, -1.57009985e-03f, 1.57689694e-02f, 3.16767097e-02f, 2.19927970e-02f, 2.36366335e-02f, 2.63672927e-03f,
  -1.42432367e-02f, 2.45445054e-02f, -1.10015878e-02f, -1.60450395e-02f, 4.50942520e-04f, -7.72906840e-02f, 6.98171780e-02f, -2.33239611e-03f, 3.26292068e-02f, -1.77326538e-02f,
  3.19298077e-03f, -4.34570611e-02f, -3.22481096e-02f, -2.55191084e-02f, 4.29964326e-02f, 1.04397666e-02f, 3.52528282e-02f, -2.07507573e-02f, -1.80074740e-02f, -4.34606783e-02f,
  2.90077049e-02f, 1.26667938e-03f, -9.13097188e-02f, 1.57955959e-02f, -3.44110951e-02f, -2.23430013e-03f, 8.16005170e-02f, -5.39444908e-02f, 3.39664379e-03f, 5.02563082e-03f,
  -3.29181962e-02f, 2.63213422e-02f, 9.89235356e-04f, 8.12993646e-02f, -6.15469068e-02f, -1.96565706e-02f, -7.40771741e-02f, -4.21202034e-02f, 3.22448811e-03f, 6.89538717e-02f,
  -5.13891280e-02f, -6.55708835e-02f, 1.07011963e-02f, 8.04585665e-02f, 1.84336584e-02f, 9.32239965e-02f, -4.13520597e-02f, -1.78341977e-02f, -1.52589884e-02f, -3.32625806e-02f,
  -2.90598609e-02f, 1.90836452e-02f, -3.10900435e-02f, 4.12594341e-02f, 1.08256631e-01f, -2.93519907e-02f, 1.80406924e-02f, -3.67683023e-02f, 5.48973940e-02f, 4.48566936e-02f,
  6.76399991e-02f, 2.09877789e-02f, 2.84247305e-02f, 5.63793965e-02f, 1.47689609e-02f, 1.38398232e-02f, -5.21620251e-02f, -2.91597303e-02f, 3.96695323e-02f, -7.23579675e-02f,
  1.34670228e-01f, 8.88478383e-02f, 3.03018808e-01f, 8.27573091e-02f, -1.38992295e-01f, 9.74788070e-02f, 1.58047363e-01f, -9.14468020e-02f, -5.97382337e-02f, -1.81813493e-01f,
  -1.57415986e-01f, 2.86224335e-01f, 2.05255509e-03f, -9.69603807e-02f, 2.76441813e-01f, 1.00127086e-01f, 1.21467963e-01f, 4.62069176e-02f, 3.42294127e-02f, 1.36953779e-02f,
  9.72560123e-02f, -3.22240055e-01f, 1.22426100e-01f, -1.89248577e-01f, -1.74917541e-02f, 9.14541334e-02f, -1.21499322e-01f, 7.25215208e-03f, -2.71285456e-02f, 6.94701672e-02f,
  6.75762519e-02f, -1.25259683e-01f, -4.04500403e-02f, 9.12068859e-02f, 2.26627588e-02f, -2.95349192e-02f, 1.18754186e-01f, 2.39966903e-02f, -3.75295468e-02f, -6.09292313e-02f,
  2.08383985e-02f, -3.77697288e-03f, 3.15115303e-02f, -8.23599696e-02f, -6.48567453e-02f, -3.37310806e-02f, -5.33269346e-02f, 8.53513181e-03f, -1.17701199e-02f, 7.65677467e-02f,
  4.25584428e-02f, 5.12788817e-02f, 2.78515164e-02f, 2.01624905e-04f, 2.28776745e-02f, -6.83353934e-03f, 3.02629378e-02f, 3.19662653e-02f, -1.55492453e-03f, -4.79630083e-02f,
  -5.11140451e-02f, -4.52234596e-02f, 5.98775558e-02f, -3.20193172e-02f, -7.07964972e-02f, -2.52780505e-02f, -6.78972825e-02f, -1.50763420e-02f, 6.66560754e-02f, -8.78704246e-03f,
  2.06925347e-03f, 3.26824002e-02f, -4.49585132e-02f, 1.22183254e-02f, -3.13997902e-02f, -5.54419979e-02f, 6.90708160e-02f, 4.84958291e-02f, -3.84734268e-03f, 1.68081485e-02f,
  -1.73223335e-02f, 7.88363814e-02f, -1.33774774e-02f, -6.31558569e-03f, -2.00142674e-02f, -6.22980110e-03f, -5.89128919e-02f, 5.62436171e-02f, -2.06535161e-02f, 1.55272922e-02f,
  -2.43591387e-02f, -1.04088960e-02f, 1.09373750e-02f, -1.26166251e-02f, -4.83114682e-02f, -8.65657907e-03f, -1.53033864e-02f, 4.61632572e-02f, 4.30204868e-02f, -5.09299785e-02f,
  2.55017448e-02f, -2.83231474e-02f, -3.47519381e-04f, 3.67116258e-02f, 4.06119898e-02f, -4.24517365e-03f, 4.31862548e-02f, 6.08191006e-02f, 3.58797982e-02f, -7.82950968e-02f,
  -8.48212764e-02f, -8.31680968e-02f, 3.47321071e-02f, 6.42710272e-03f, -5.99818900e-02f, 8.56582969e-02f, 2.51435768e-02f, 7.73771666e-03f, -1.38560245e-02f, 2.68915650e-02f,
  2.54886776e-01f, -2.24420264e-01f, -1.77314699e-01f, -1.47053644e-01f, 1.42166346e-01f, 2.37615913e-01f, -7.79189989e-02f, 1.87748019e-02f, 6.21826090e-02f, -1.84524387e-01f,
  -1.61328446e-02f, -1.43308282e-01f, -1.51945695e-01f, -1.38849497e-01f, 2.41482586e-01f, 6.82010651e-02f, -1.55710652e-02f, -7.09422156e-02f, 3.71691957e-02f, -7.72633255e-02f,
  1.45455807e-01f, 8.39261189e-02f, -1.33339912e-01f, 1.10411085e-02f, -5.27820699e-02f, -1.85621023e-01f, -1.49272708e-02f, -1.40874222e-01f, -7.99709782e-02f, 2.03989334e-02f,
  2.15605721e-02f, -1.73619632e-02f, -6.92142546e-02f, 1.37259660e-03f, 2.36522481e-02f, -2.22009644e-02f, -5.96565045e-02f, -6.77479580e-02f, 6.27890751e-02f, -4.04353254e-02f,
  -4.39456739e-02f, 9.00826156e-02f, -4.43111826e-03f, -1.81243811e-02f, 4.68024164e-02f, 2.31946595e-02f, 2.13584248e-02f, 3.21135372e-02f, -5.14993668e-02f, 3.06482799e-02f,
  -6.17147274e-02f, -4.08534817e-02f, -6.96857413e-03f, -2.76930444e-02f, -3.61181051e-02f, -6.14990629e-02f, -1.67605598e-02f, 3.87582555e-03f, 2.21618600e-02f, 3.63588519e-02f,
  1.19694404e-01f, 7.53764762e-03f, -1.68391932e-02f, 1.53532336e-02f, 1.34111000e-02f, -4.77124378e-03f, -7.53499661e-03f, -2.25552246e-02f, -1.87871754e-02f, -2.36700121e-02f,
  2.55082324e-02f, -1.35175958e-02f, -1.79017968e-02f, 2.24506184e-02f, -3.61872055e-02f, -1.71669740e-02f, 2.93734763e-02f, -1.04491614e-01f, 4.76415195e-02f, -3.50605473e-02f,
  -5.75991459e-02f, 3.07724625e-02f, -8.38592052e-02f, -3.39018144e-02f, 4.46993522e-02f, 3.84465121e-02f, -2.56295465e-02f, -3.46908867e-02f, -4.72649150e-02f, -1.24619212e-02f,
  3.33419256e-02f, -1.02945194e-01f, 9.70988721e-03f, 2.27882583e-02f, -4.72469777e-02f, -5.58833033e-03f, -1.14134215e-02f, 7.46448934e-02f, -2.78267544e-02f, 7.94977918e-02f,
  -2.51254649e-03f, -3.46116200e-02f, -5.23278210e-03f, 5.46661727e-02f, 3.33266221e-02f, 2.60514244e-02f, -1.48528004e-02f, -5.92381284e-02f, 1.78657733e-02f, 3.06163095e-02f,
  3.62662040e-02f, 6.69195727e-02f, 6.51755184e-03f, 5.17431200e-02f, -4.58612991e-03f, 1.81995090e-02f, 5.22216000e-02f, -1.79845430e-02f, 2.51184050e-02f, 1.58261843e-02f,
  2.55745091e-02f, -1.87084720e-01f, -2.13261973e-02f, 9.49382596e-03f, 4.25100103e-02f, 9.48015079e-02f, 2.05510445e-02f, 1.11939553e-02f, 5.81892766e-02f, -1.55478224e-01f,
  9.67067182e-02f, -2.51191884e-01f, -4.10733186e-02f, -1.52552724e-01f, -5.81148118e-02f, -8.08957070e-02f, -5.58353141e-02f, -2.20266748e-02f, -5.12792133e-02f, -1.07085750e-01f,
  -1.92257166e-02f, -1.65518194e-01f, 1.90886166e-02f, -3.57434191e-02f, 1.36850588e-02f, 6.51616752e-02f, -7.15687871e-02f, 2.29100324e-02f, -3.47490907e-02f, -4.59302887e-02f,
  5.13927899e-02f, -1.37887552e-01f, 4.25488539e-02f, 1.89289299e-03f, 1.69032775e-02f, -4.06083055e-02f, 8.06375071e-02f, -1.03155086e-02f, 3.43062878e-02f, -7.69358352e-02f,
  -2.11500842e-02f, 2.77232416e-02f, -7.77884340e-03f, -5.58561571e-02f, 1.69668403e-02f, -1.84789877e-02f, 5.43399490e-02f, 1.18273988e-01f, -5.53843193e-02f, -1.16519686e-02f,
  4.21633124e-02f, 4.86278981e-02f, 9.45456624e-02f, -9.34211314e-02f, -5.44826593e-03f, 3.45498249e-02f, 2.80197356e-02f, 3.67843956e-02f, -3.18424590e-02f, -3.80499698e-02f,
  -4.30180244e-02f, 2.28199475e-02f, 3.38179991e-02f, 5.92524484e-02f, 2.51526391e-04f, 1.47728361e-02f, 2.68733539e-02f, -1.44056622e-02f, 7.01303827e-03f, -5.36560826e-02f,
  6.79661334e-02f, 3.83398309e-02f, -2.94881519e-02f, 1.66562106e-03f, -2.17923638e-03f, 1.02422535e-02f, 6.54244050e-02f, -4.89278026e-02f, 3.89815383e-02f, 1.07457571e-01f,
  -4.61927131e-02f, 3.00293658e-02f, -2.46307347e-02f, 8.63200948e-02f, 1.07974987e-02f, -7.51100928e-02f, -3.88637185e-02f, 4.56645004e-02f, 7.31361732e-02f, 7.20560104e-02f,
  -3.80180776e-02f, -3.26896429e-01f, -1.55180059e-02f, 3.87040339e-02f, -9.50656086e-02f, 6.09009666e-03f, -2.78398171e-02f, 4.29616310e-02f, -1.89823788e-02f, 7.26386625e-03f,
  3.93201015e-04f, 3.46863791e-02f, 2.71531977e-02f, 4.14057262e-03f, 3.66382822e-02f, 1.80528313e-03f, -5.61873354e-02f, -5.74449897e-02f, -1.91320460e-02f, -2.02775449e-02f,
  -3.83636216e-03f, -2.92465761e-02f, 3.19120213e-02f, 1.13826238e-01f, 3.94344181e-02f, -7.29182363e-02f, -4.05000970e-02f, -2.21521556e-02f, -6.23152293e-02f, 1.75123531e-02f,
  1.13702618e-01f, 6.89174086e-02f, -2.49982625e-01f, 4.32079621e-02f, 2.52439052e-01f, -1.97516561e-01f, -1.80898473e-01f, 2.43325368e-01f, 1.80254638e-01f, -1.68333039e-01f,
  -4.37775776e-02f, -5.27392477e-02f, -7.97298402e-02f, -2.79072355e-02f, 1.35237491e-03f, -1.68805927e-01f, -9.26673561e-02f, -1.17877223e-01f, 2.00323641e-01f, 1.52679324e-01f,
  1.17648058e-01f, 1.88103974e-01f, -1.94663942e-01f, 2.48638839e-01f, -3.93562056e-02f, 1.51655257e-01f, -7.79012684e-03f, 8.12545326e-03f, -6.67377561e-02f, 1.09741809e-02f,
  8.65618605e-03f, 1.73504446e-02f, 3.08128726e-02f, -1.31788151e-02f, 3.15617654e-03f, -8.40144157e-02f, -8.17150474e-02f, -1.91613305e-02f, 3.06728715e-03f, 1.71517313e-03f,
  -1.01357996e-02f, -3.60659212e-02f, 8.24440494e-02f, -2.29126140e-02f, 6.32978678e-02f, -3.95836197e-02f, -1.21958084e-01f, -6.73744157e-02f, 3.71279828e-02f, -8.56763199e-02f,
  -1.10821709e-01f, -1.02604583e-01f, -6.50388673e-02f, 2.39597671e-02f, 1.24286786e-02f, 2.48225704e-02f, -2.97781099e-02f, -9.47787091e-02f, -2.71000825e-02f, 9.03228298e-02f,
  -3.89840603e-02f, 8.47430527e-02f, -4.88199331e-02f, 7.67472684e-02f, 1.89648625e-02f, -2.04961728e-02f, -3.05255130e-02f, 1.72648989e-02f, -1.95085127e-02f, -1.16734700e-02f,
  6.71412423e-02f, 2.20140107e-02f, 3.19367237e-02f, -8.33331645e-02f, -4.05862331e-02f, 9.09644589e-02f, -2.46348828e-02f, 3.92495207e-02f, -7.87884369e-03f, 1.04349516e-02f,
  4.17042524e-02f, 7.78298359e-03f, -1.72894187e-02f, -1.53919579e-02f, 1.25675229e-02f, 1.32078221e-02f, -4.56927903e-02f, -8.05772990e-02f, -2.07597483e-02f, 3.04474891e-03f,
  1.72032461e-01f, 1.98645487e-01f, 6.00164942e-02f, 7.68706724e-02f, 2.72386577e-02f, 1.68864168e-02f, 3.23934183e-02f, -6.98719472e-02f, 4.13808823e-02f, 4.13572006e-02f,
  -2.11076625e-02f, -4.18283482e-04f, -2.95474939e-02f, -6.18544705e-02f, -5.49369082e-02f, 3.18326493e-04f, 5.93136251e-02f, -2.98266318e-02f, 1.09951176e-01f, 5.94933517e-03f,
  6.18682802e-02f, 3.80949825e-02f, -1.50585631e-02f, 1.18477277e-01f, -6.16961606e-02f, -3.36967744e-02f, 1.18402742e-01f, 4.36714962e-02f, -1.81447715e-02f, -3.18058208e-02f,
  -3.46984267e-02f, -1.04329482e-01f, 2.22464442e-01f, 6.78707957e-02f, -2.14040905e-01f, 7.98626691e-02f, -2.16728821e-02f, 4.08268832e-02f, 1.47068173e-01f, -1.17735907e-01f,
  -5.24426140e-02f, -1.84583873e-01f, 5.21576405e-02f, 2.09103487e-02f, 2.39907846e-01f, 1.62696660e-01f, 4.79170643e-02f, -4.26896065e-02f, 4.33025248e-02f, -3.34310941e-02f,
  1.94356218e-01f, -9.53577682e-02f, 2.93991536e-01f, -1.30720496e-01f, -2.30348166e-02f, 1.09923050e-01f, 5.68046756e-02f, -4.54501882e-02f, -1.39958143e-01f, -1.55361099e-02f,
  -1.52519986e-01f, 2.75157578e-03f, 3.97406854e-02f, 5.92940524e-02f, 6.82000443e-02f, 7.78863765e-03f, 2.66689323e-02f, 1.44078843e-02f, 9.11660790e-02f, -5.43783652e-03f,
  -5.46805048e-03f, 1.04849078e-02f, -4.64896411e-02f, -2.03220751e-02f, -7.41631687e-02f, 4.36034501e-02f, -3.90018243e-03f, 1.01934876e-02f, -4.46626097e-02f, 1.16974115e-02f,
  8.09742287e-02f, 1.14069708e-01f, 5.26366793e-02f, 1.94287114e-02f, 6.49663582e-02f, 9.12484620e-03f, 1.18972354e-01f, 3.74193043e-02f, -1.88689027e-02f, -3.92833399e-03f,
  3.38501669e-02f, -2.51569562e-02f, 4.37924415e-02f, -4.13114019e-02f, -5.42778336e-02f, 6.35667844e-03f, -2.85428055e-02f, -1.03218844e-02f, -5.86969480e-02f, -6.52441382e-02f,
  -1.87076628e-02f, -4.92289253e-02f, -2.32311245e-02f, 5.73156290e-02f, -5.03957234e-02f, 3.57907861e-02f, 3.92987169e-02f, -7.82751068e-02f, 2.97259018e-02f, 1.09718461e-02f,
  -2.05211081e-02f, 9.30343010e-03f, -5.27989604e-02f, -3.96210700e-04f, -2.39115003e-02f, 3.09433714e-02f, 2.10708417e-02f, 3.96948457e-02f, 4.28183489e-02f, 1.73067320e-02f,
  -1.94099605e-01f, -1.43419981e-01f, -1.19636655e-02f, -1.48196265e-01f, -6.46868050e-02f, -2.71910317e-02f, 2.57050768e-02f, 1.45321283e-02f, -4.82095629e-02f, 2.81632878e-02f,
  3.12207192e-02f, -6.36562333e-02f, -3.92027781e-04f, -5.86398728e-02f, 1.33049637e-02f, 2.12561581e-02f, 1.52678648e-02f, 9.87851713e-03f, -3.78861874e-02f, -1.41918957e-01f,
  -7.04695061e-02f, -6.30654842e-02f, 8.69056880e-02f, 5.41935628e-03f, -7.31622335e-03f, -6.11130148e-02f, -7.12098256e-02f, 1.16852140e-02f, -5.68966642e-02f, 1.55253569e-02f
};

// L0_fan_Wp_bar (Shape: 52 x 120)
const int L0_fan_Wp_bar_rows = 52;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  1.18155733e-01f, -1.85669228e-01f, -3.54932100e-01f, -1.99000284e-01f, -2.91049723e-02f, 1.08779162e-01f, 4.70453687e-02f, 8.19850434e-03f, -2.13805184e-01f, 2.88911432e-01f,
  3.28268826e-01f, -1.03774749e-01f, -1.00907115e-02f, 3.24213117e-01f, 1.21960901e-01f, 1.41257092e-01f, 3.31012160e-01f, 2.01309398e-01f, -1.29559219e-01f, 2.07053348e-02f,
  1.57532506e-02f, 4.04687405e-01f, -6.25173002e-02f, -1.19927106e-02f, 1.31216809e-01f, -1.38930768e-01f, 1.99762121e-01f, -2.17985317e-01f, 2.13909209e-01f, 1.46595418e-01f,
  5.02432056e-04f, -2.77586728e-02f, -7.58400932e-02f, -4.75196466e-02f, 1.29831256e-02f, 7.12445611e-03f, -8.81477892e-02f, -7.90890902e-02f, -1.04832679e-01f, -5.92457838e-02f,
  -1.27436101e-01f, -1.28273023e-02f, 3.64080667e-02f, -1.24892659e-01f, 5.49729913e-02f, -1.30084068e-01f, -2.67169587e-02f, -4.47179377e-02f, -1.33248985e-01f, 7.87621085e-03f,
  -9.54313949e-02f, -1.17184781e-02f, -7.65989646e-02f, -8.35215002e-02f, -1.11018335e-02f, -6.04798831e-02f, -1.16311476e-01f, -2.91829533e-03f, -3.76066640e-02f, 5.09892553e-02f,
  3.22048962e-02f, -6.16909703e-03f, 6.20305985e-02f, 6.32373907e-04f, -8.62455890e-02f, -2.52473191e-03f, 1.17458671e-01f, 2.43145209e-02f, -9.00628269e-02f, -3.87890637e-02f,
  -1.69044384e-03f, -4.22093552e-03f, 3.75256613e-02f, 5.26164360e-02f, 9.55201313e-02f, -4.32296330e-03f, -4.70278114e-02f, -8.34767986e-03f, 1.15479724e-02f, -1.73228011e-02f,
  -3.22644645e-03f, -8.63150507e-03f, 1.28341299e-02f, 3.17693106e-03f, 1.68032537e-03f, -3.75429098e-03f, 1.42717138e-01f, 1.01472005e-01f, -2.92900056e-02f, -2.59460304e-02f,
  9.04409364e-02f, -4.13724333e-02f, 5.67611232e-02f, -6.43408597e-02f, -1.26947984e-01f, -5.61654009e-02f, -1.00429198e-02f, -1.75817106e-02f, 4.72581536e-02f, 1.52065791e-02f,
  7.40574151e-02f, -4.65965867e-02f, -4.67766710e-02f, -3.25264782e-02f, -4.10078801e-02f, 2.11274009e-02f, -6.18595164e-03f, -5.61027378e-02f, 3.22954617e-02f, -3.45517285e-02f,
  -7.15210661e-03f, -3.23076881e-02f, 6.25692680e-02f, -1.20106965e-01f, -6.57183304e-02f, 4.39383164e-02f, -1.03751950e-01f, 2.43194178e-02f, 5.55684455e-02f, -1.89596545e-02f,
  -5.81264019e-01f, 3.38811725e-01f, 2.29610369e-01f, 5.45720309e-02f, -3.71599197e-02f, 4.05091256e-01f, 3.77692252e-01f, 1.29741803e-01f, 4.03402269e-01f, 1.44342631e-01f,
  -8.05878118e-02f, 1.31346345e-01f, 9.74087045e-02f, 1.78582415e-01f, -3.21236044e-01f, 8.99842680e-02f, 1.75866947e-01f, 1.14630364e-01f, 2.04346210e-01f, -8.81696120e-02f,
  -1.93947136e-01f, 3.08643337e-02f, -1.24010757e-01f, -1.67699363e-02f, -9.99354273e-02f, -2.82570645e-02f, -1.96637496e-01f, 2.17204615e-01f, -9.02907848e-02f, 1.42326444e-01f,
  -1.80504948e-01f, 2.36259606e-02f, -2.24373922e-01f, 2.80559883e-02f, -1.24038018e-01f, -9.89076495e-02f, -1.40309734e-02f, -1.12494798e-02f, -6.15503006e-02f, -7.45760426e-02f,
  -1.80957139e-01f, -1.38120636e-01f, 7.88503811e-02f, -1.58226136e-02f, 7.37668052e-02f, 6.93954304e-02f, 5.45678055e-03f, 6.01661317e-02f, 4.19437923e-02f, -5.92283644e-02f,
  1.13907931e-02f, 4.00052220e-02f, -1.16966799e-01f, 5.88052943e-02f, -9.17726904e-02f, 2.08849922e-01f, 1.79224148e-01f, 1.76380016e-02f, 9.57473740e-02f, 4.75246012e-02f,
  2.47233901e-02f, 8.49407688e-02f, -4.45262045e-02f, -6.84725447e-03f, 4.91301566e-02f, 1.05243344e-02f, 8.81529897e-02f, -1.58489928e-01f, -1.98381525e-02f, -9.84536931e-02f,
  -1.49729559e-02f, 8.26516971e-02f, 9.20028165e-02f, -5.91351129e-02f, 3.11102774e-02f, -7.78683200e-02f, -1.32138774e-01f, 8.50493833e-02f, -6.83778105e-03f, 5.98358922e-02f,
  6.32461607e-02f, 1.50035564e-02f, 5.23903109e-02f, -2.68397015e-02f, -4.03035991e-02f, 3.83364223e-02f, 4.48295027e-02f, -7.39545003e-02f, 3.91506925e-02f, -6.77140988e-03f,
  1.09024324e-01f, 2.05425799e-01f, -1.06417574e-01f, -1.15408935e-01f, -6.80494383e-02f, -4.10653315e-02f, -7.62931630e-02f, -1.67267367e-01f, 1.18383698e-01f, -7.58720562e-02f,
  -7.54931048e-02f, -1.16120532e-01f, -2.44292468e-02f, 1.92130380e-03f, -5.00454754e-02f, -1.08201326e-04f, -1.72993578e-02f, 2.35349089e-02f, 3.28939664e-03f, -7.72348940e-02f,
  -9.30369049e-02f, 2.72816475e-02f, -1.56700537e-02f, -6.48974329e-02f, -1.23767108e-01f, -2.46129781e-02f, -8.94288644e-02f, 4.08575721e-02f, -8.70939791e-02f, 1.48604393e-01f,
  -1.53259143e-01f, 3.18197012e-01f, -2.44842649e-01f, 2.38603028e-03f, 7.85945728e-02f, 4.21868742e-01f, 2.31144533e-01f, 2.18757927e-01f, 1.27948627e-01f, 8.30707029e-02f,
  2.06230953e-01f, -1.81574419e-01f, -3.24844685e-03f, 3.65105838e-01f, 1.90151393e-01f, 3.09352607e-01f, 3.48722458e-01f, 1.77849308e-01f, 1.68483406e-01f, 2.59377249e-02f,
  5.97160570e-02f, 2.69232124e-01f, -7.71348923e-02f, -6.74821138e-02f, 2.53067240e-02f, -2.93299735e-01f, -3.46793741e-01f, -1.05416961e-01f, -3.37171159e-03f, 1.56551301e-01f,
  5.35650216e-02f, -1.85528383e-01f, -1.41135961e-01f, -9.92142484e-02f, -1.22053735e-01f, -1.83435544e-01f, -1.72059894e-01f, -1.72150224e-01f, 2.25318242e-02f, 1.47987111e-03f,
  -4.68276329e-02f, -7.06407502e-02f, -2.16898303e-02f, -6.28043488e-02f, 2.96892747e-02f, 3.36638652e-02f, 1.02397256e-01f, 3.40568088e-02f, 2.36620586e-02f, 1.19760931e-01f,
  1.47196263e-01f, 4.22005244e-02f, 4.66301031e-02f, 2.03715578e-01f, 9.36396047e-02f, 1.23821676e-01f, -4.98300884e-03f, 1.10950612e-03f, 1.04779780e-01f, 4.73322440e-03f,
  -4.35460126e-03f, -2.65678968e-02f, -1.13274582e-01f, -9.03116912e-02f, 1.95462350e-03f, 3.01037636e-02f, 2.25115735e-02f, -7.26961270e-02f, 1.36032486e-02f, 9.42730308e-02f,
  6.81796744e-02f, -5.27271964e-02f, 3.05497535e-02f, 2.92658396e-02f, 4.15351689e-02f, 5.42552327e-04f, -1.03130750e-01f, 3.02306227e-02f, 8.06981511e-03f, 1.13670062e-02f,
  -1.04152925e-01f, 6.56782612e-02f, 5.18736057e-02f, -8.09202790e-02f, 9.39148068e-02f, -5.94581552e-02f, -4.17018831e-02f, -1.09221293e-02f, -5.92526495e-02f, -3.04519944e-02f,
  1.57799214e-01f, -6.95401570e-03f, -7.19190994e-03f, 1.22804210e-01f, -7.02355206e-02f, -7.56885931e-02f, -1.09286338e-01f, 8.14952627e-02f, 2.57355738e-02f, 5.35785668e-02f,
  -3.39176394e-02f, -4.04071249e-02f, -1.09379338e-02f, -8.34920630e-02f, 1.53603554e-02f, 1.62073031e-01f, -7.42855528e-03f, -3.14649381e-02f, 1.22744665e-01f, 5.77382073e-02f,
  -1.25152484e-01f, -6.75395355e-02f, -1.09788865e-01f, 7.33668804e-02f, -6.23616343e-03f, -8.30308795e-02f, -5.87374792e-02f, -6.03775680e-02f, 5.33592105e-02f, 5.27499989e-02f,
  -4.46058065e-02f, -3.19467098e-01f, -8.21987987e-02f, -1.43041000e-01f, -1.34503573e-01f, -9.09031034e-02f, 1.48065388e-01f, -2.84530878e-01f, -7.23252371e-02f, -2.61792857e-02f,
  -6.68703616e-02f, 7.99633265e-02f, 3.06580156e-01f, -2.72621542e-01f, 3.42526376e-01f, 2.34560698e-01f, -2.11872131e-01f, 7.53905848e-02f, -1.58710599e-01f, -2.28420869e-01f,
  -1.26483813e-01f, -2.17322141e-01f, 3.73488739e-02f, -3.25046241e-01f, -2.86396325e-01f, -1.59447610e-01f, 1.44430265e-01f, -3.17316502e-02f, -2.21685529e-01f, 1.63577013e-02f,
  -4.14537489e-01f, -2.88179606e-01f, -1.57330438e-01f, -8.89534205e-02f, -1.95682034e-01f, 3.28204520e-02f, 5.28343171e-02f, 2.01297775e-01f, 8.66459310e-02f, -1.14406966e-01f,
  1.28371492e-01f, -2.75208522e-02f, -1.41796291e-01f, 8.76753703e-02f, -1.12415656e-01f, -1.37230173e-01f, -4.03890153e-03f, -2.01791957e-01f, -7.50610530e-02f, -6.10402711e-02f,
  -1.89106353e-02f, -1.62452325e-01f, -1.15311004e-01f, -5.55447862e-02f, 6.16681650e-02f, -2.19646320e-02f, 1.59996524e-02f, 9.11697149e-02f, -1.94203854e-01f, -8.50093588e-02f,
  6.42277747e-02f, 1.34752214e-01f, -7.18000084e-02f, 7.45452344e-02f, 4.43636812e-02f, -4.53019738e-02f, -3.21417749e-02f, 8.36119950e-02f, 6.24654330e-02f, 7.22309500e-02f,
  1.01942616e-02f, -8.85367393e-02f, -1.35516785e-02f, -5.98873431e-03f, 1.24594457e-02f, 3.12058926e-02f, 1.50539994e-01f, -4.35338281e-02f, -8.21143910e-02f, -8.25704113e-02f,
  2.34316178e-02f, 7.84697756e-02f, 2.53651310e-02f, -2.93704700e-02f, -9.54175815e-02f, 1.22850992e-01f, -1.05254345e-01f, -7.82458186e-02f, -9.08878669e-02f, 1.31865427e-01f,
  -3.00082177e-01f, -2.56924093e-01f, 4.41232026e-02f, 5.85001940e-03f, 2.38495003e-02f, -3.39007638e-02f, 5.03305010e-02f, -1.41214222e-01f, -6.92690536e-02f, 3.83671112e-02f,
  -3.47667821e-02f, 1.56356152e-02f, 3.13247694e-03f, 6.45509660e-02f, 1.53906941e-01f, -4.33768108e-02f, 1.01743592e-02f, 4.34919354e-03f, -2.99529522e-03f, -1.87904574e-02f,
  4.89765853e-02f, 5.68106137e-02f, 1.93632245e-01f, -1.87727381e-02f, 9.04076993e-02f, 8.79716873e-02f, -2.17759386e-02f, 8.40450078e-03f, -7.47365355e-02f, -8.41491371e-02f,
  1.50664136e-01f, -1.21913776e-01f, -1.10922135e-01f, 2.16786042e-01f, 3.98914106e-02f, -9.36458856e-02f, -2.87636697e-01f, 9.72489715e-02f, 1.09450119e-02f, -2.08948553e-01f,
  6.48161396e-02f, 6.70150970e-04f, -1.65403947e-01f, 2.47307509e-01f, 2.94996858e-01f, -2.56603956e-02f, 1.78260371e-01f, -1.40536502e-02f, 6.26991391e-02f, 1.34044036e-01f,
  2.65142620e-01f, 1.57184526e-01f, 2.92004019e-01f, 2.78842211e-01f, 1.25117034e-01f, 7.24912062e-02f, 1.93148494e-01f, 3.76457497e-02f, 2.76048422e-01f, 1.14663757e-01f,
  -9.51318145e-02f, -6.14416339e-02f, -2.75730174e-02f, 3.78316897e-03f, -4.71797846e-02f, -1.85728278e-02f, -4.76847775e-02f, 5.08153392e-03f, -1.43032242e-02f, -6.56753555e-02f,
  -8.87618735e-02f, 6.45608827e-02f, 4.78704199e-02f, 4.51808684e-02f, -8.32648948e-02f, -4.29019006e-03f, 4.69787754e-02f, -7.16036409e-02f, 2.68720649e-02f, 6.14356175e-02f,
  -7.03191236e-02f, -1.80075895e-02f, -2.35368013e-02f, 6.42384589e-02f, 9.23475325e-02f, -8.51827264e-02f, -1.33938879e-01f, -5.05895242e-02f, -3.17278095e-02f, 1.04236454e-01f,
  -7.14994892e-02f, 3.17837521e-02f, 9.38525796e-02f, -1.85555685e-03f, 1.59685276e-02f, 8.73694047e-02f, 5.78442961e-03f, 3.65947261e-02f, -5.49810566e-02f, 2.28496827e-02f,
  6.15787879e-02f, -3.16470414e-02f, -7.57282376e-02f, 2.17368789e-02f, 3.20364423e-02f, -4.10627313e-02f, -2.66914293e-02f, 1.40450476e-02f, 6.84262067e-02f, 1.15295380e-01f,
  -3.07989568e-02f, 7.28928521e-02f, 2.81793121e-02f, -5.05899377e-02f, -1.23082578e-01f, -2.76535912e-03f, 6.74496368e-02f, -8.04901868e-02f, -1.08853471e-03f, 5.42653957e-03f,
  1.11432874e-03f, 1.75925687e-01f, -4.96470407e-02f, 3.80005781e-03f, -9.20250360e-03f, 1.34293484e-02f, 1.71570163e-02f, 1.11957863e-01f, -3.04500591e-02f, 1.12251647e-01f,
  1.77328419e-02f, -6.62366748e-02f, -8.39384645e-02f, 9.34908446e-03f, -1.35837297e-04f, 8.32303092e-02f, 7.30399089e-03f, 1.45516377e-02f, 2.33415943e-02f, 3.78701128e-02f,
  5.19903749e-02f, -1.35559082e-01f, -1.16578385e-01f, 8.90762638e-03f, 1.70838442e-02f, -7.26472028e-03f, -9.41040516e-02f, -6.30393326e-02f, -2.41092462e-02f, -4.84751351e-02f,
  4.25610766e-02f, 3.01868230e-01f, 2.93226123e-01f, 2.45848030e-01f, -1.47888020e-01f, -3.48527044e-01f, -2.25194052e-01f, 5.44492789e-02f, -1.62303001e-01f, 1.30553052e-01f,
  -4.87554781e-02f, 2.60454237e-01f, -2.68074200e-02f, 2.05235943e-01f, -1.11159995e-01f, -2.64834344e-01f, 1.61482599e-02f, -1.56147322e-02f, -1.13535076e-01f, 1.59938172e-01f,
  1.61383208e-02f, -1.40436113e-01f, 6.27985969e-02f, 8.40941537e-03f, 1.16761781e-01f, 2.16446921e-01f, 1.34002090e-01f, 2.16751248e-02f, 2.51648664e-01f, -1.07059106e-01f,
  -6.39320686e-02f, -5.44073386e-03f, 1.14759475e-01f, -1.12153128e-01f, 1.22835018e-01f, 1.04497466e-02f, 3.67148750e-04f, -3.60610597e-02f, -9.18585137e-02f, 4.16072123e-02f,
  9.22098160e-02f, 3.18882838e-02f, 5.22151329e-02f, -3.97467837e-02f, -3.33001837e-02f, 7.98800774e-03f, 1.18408531e-01f, 6.47828430e-02f, 1.07701913e-01f, 1.46721885e-01f,
  -4.88964329e-03f, 1.62631884e-01f, -1.26888286e-02f, 4.48396653e-02f, -1.30958878e-03f, -4.38093580e-02f, -1.47096589e-02f, 6.14104643e-02f, -6.99299425e-02f, 1.86644122e-03f,
  1.13347545e-01f, -1.48306176e-01f, -1.01973087e-01f, -5.11320867e-03f, -1.08608693e-01f, -8.31172615e-02f, -7.79460520e-02f, -2.71521173e-02f, -1.95002742e-02f, -2.62012258e-02f,
  -1.65353483e-03f, 1.35680750e-01f, -6.32554442e-02f, -6.64209807e-03f, 1.16316706e-03f, 1.47596132e-02f, 5.84195517e-02f, 4.80542183e-02f, 5.88220581e-02f, 8.39154795e-02f,
  -1.15616426e-01f, -6.13079034e-02f, 5.70859015e-02f, 2.96605732e-02f, -9.98338982e-02f, 4.64621186e-02f, 2.30936334e-02f, 6.80753738e-02f, 2.90606674e-02f, -1.06725851e-02f,
  1.48066565e-01f, 1.66233465e-01f, 7.16433078e-02f, 6.98682014e-03f, -7.91714638e-02f, 1.10903047e-02f, -1.36474194e-03f, -1.54781267e-02f, 6.78713545e-02f, -1.16278276e-01f,
  1.83510274e-01f, -2.31619291e-02f, 9.97537002e-03f, -3.46429162e-02f, 4.92474670e-03f, 7.23492801e-02f, -5.64585328e-02f, 8.04225877e-02f, -4.42079734e-03f, 1.59802333e-01f,
  5.55885471e-02f, -7.01806834e-03f, -3.51332710e-03f, 4.77177761e-02f, -4.48329151e-02f, 9.46207810e-03f, 4.16935757e-02f, 8.57719705e-02f, 6.44734725e-02f, 1.80287119e-02f,
  -3.67765278e-01f, 1.51753157e-01f, -2.23550007e-01f, 5.62712401e-02f, -9.83095542e-02f, -3.38012755e-01f, -1.53722122e-01f, -1.34017244e-01f, -1.42461091e-01f, 2.08429858e-01f,
  2.07208619e-01f, -1.41769394e-01f, 2.08601967e-01f, 8.23326930e-02f, -1.02738589e-01f, 3.97306740e-01f, -3.14377844e-02f, 1.02424353e-01f, 2.93126851e-02f, -9.04442817e-02f,
  -1.02371275e-02f, 5.30555509e-02f, 2.30021745e-01f, -7.68389925e-02f, -1.78994790e-01f, -7.69849196e-02f, 3.37403566e-01f, -1.35012567e-01f, -6.35271221e-02f, -1.66992307e-01f,
  3.61047976e-04f, -6.81284145e-02f, -5.75214112e-03f, -1.42868832e-01f, -1.28128184e-02f, -3.43498513e-02f, -1.28321000e-03f, -6.24639429e-02f, -8.24541301e-02f, -1.23559207e-01f,
  -5.68139963e-02f, 2.62609143e-02f, -1.03561051e-01f, -6.53563440e-02f, -7.90742561e-02f, 6.33240640e-02f, -8.34131017e-02f, 1.90489995e-03f, 2.09226715e-03f, 2.18176916e-02f,
  -2.77923550e-02f, -7.19965026e-02f, 1.33799851e-01f, 1.62172556e-01f, 2.63939314e-02f, -5.38459383e-02f, -1.33343386e-02f, -1.99460443e-02f, -7.31842313e-03f, -4.91543598e-02f,
  -1.04925275e-01f, 5.63162155e-02f, 1.81729272e-02f, -2.34388895e-02f, -6.92980811e-02f, 5.70721179e-02f, 8.83957818e-02f, -3.07285991e-02f, -3.50860432e-02f, 1.31854922e-01f,
  -6.86382204e-02f, 2.46301536e-02f, 1.19813252e-02f, -6.18492849e-02f, -9.27649438e-02f, -1.96545059e-03f, -9.69984531e-02f, 7.90467635e-02f, 1.05828736e-02f, 3.09788324e-02f,
  2.99737304e-02f, -8.70903134e-02f, -9.58596170e-03f, 1.70125902e-01f, 2.17885450e-02f, 6.02082796e-02f, 3.78994197e-02f, 1.08579181e-01f, 7.01366067e-02f, -1.12792403e-02f,
  -3.02695520e-02f, 7.82391801e-02f, 4.38291281e-02f, -5.74007556e-02f, 4.22750376e-02f, -1.07157446e-01f, 4.12328616e-02f, -4.13550921e-02f, 4.91751693e-02f, -1.87247604e-01f,
  -8.05906355e-02f, 5.69728725e-02f, 5.69831915e-02f, 4.72590551e-02f, -1.09160885e-01f, 5.77336084e-03f, 4.73521929e-03f, 7.06166998e-02f, -3.47266756e-02f, 1.11174971e-01f,
  4.80774418e-02f, 3.33440416e-02f, 6.39698505e-02f, -9.67557430e-02f, 1.97226256e-02f, 2.76557878e-02f, -4.08396013e-02f, -4.97544408e-02f, -8.54037702e-03f, 6.27127886e-02f,
  -4.77176636e-01f, 3.36239338e-01f, 2.64939725e-01f, -2.56455123e-01f, 2.14173183e-01f, 1.58709824e-01f, -2.03477070e-01f, 1.78277880e-01f, -1.21684633e-01f, 1.15674950e-01f,
  8.20565671e-02f, 1.03960270e-02f, 2.28165627e-01f, -8.76938999e-02f, -4.01168585e-01f, -1.44072101e-01f, -2.06605464e-01f, -2.06928357e-01f, -7.36348657e-03f, -2.63141673e-02f,
  -1.20907977e-01f, -2.38210887e-01f, -1.02633290e-01f, 2.28229120e-01f, 1.50971919e-01f, 4.08657826e-02f, -2.80995995e-01f, 2.38378868e-01f, -3.97455767e-02f, 1.22211449e-01f,
  -2.17232600e-01f, -6.96618482e-02f, -1.51975257e-02f, 3.50812413e-02f, 2.69123372e-02f, 1.35405764e-01f, -8.98062512e-02f, -2.23257337e-02f, 4.35033366e-02f, 1.40111029e-01f,
  1.12486430e-01f, 5.44961095e-02f, -1.64779499e-01f, 1.02180839e-01f, 3.50474156e-02f, 6.76389337e-02f, 1.33878410e-01f, 1.86497951e-03f, 2.30485704e-02f, 1.21473595e-02f,
  4.47208062e-02f, 3.74070928e-02f, 4.83348407e-02f, 4.38481756e-02f, -2.32503135e-02f, 8.40831846e-02f, 1.22750979e-02f, -2.75172777e-02f, 5.12510166e-02f, -9.15572941e-02f,
  5.47444820e-02f, -5.00556156e-02f, 7.22251683e-02f, 2.00421494e-02f, 4.26226072e-02f, 7.82506317e-02f, 3.85430045e-02f, -2.00903654e-01f, 2.24815719e-02f, 1.15935415e-01f,
  -1.57530054e-01f, -1.02957800e-01f, 5.96487336e-02f, 7.75668249e-02f, 2.50286851e-02f, 3.98314260e-02f, 9.28720161e-02f, -7.18038902e-02f, -1.44840717e-01f, 6.31533489e-02f,
  2.09299498e-03f, 5.13286702e-02f, -5.78916259e-02f, -1.00251034e-01f, 5.52652590e-02f, 6.49355352e-02f, -2.53060390e-03f, 1.00584991e-01f, -1.75768752e-02f, -9.79164019e-02f,
  -3.42800677e-01f, -1.87126547e-01f, 3.78251262e-02f, 9.06611606e-02f, 6.06649294e-02f, -4.41169254e-02f, -8.27121735e-03f, -4.35862020e-02f, -7.38211647e-02f, 2.95244362e-02f,
  1.61445156e-01f, 8.15438107e-02f, -1.80848941e-01f, -1.31246280e-02f, -3.22915753e-03f, 1.28690060e-02f, -1.89936459e-02f, -5.74330389e-02f, 4.55889013e-03f, 2.05031354e-02f,
  -7.72736669e-02f, -6.73975199e-02f, 6.57721683e-02f, 5.58228381e-02f, -3.21585685e-02f, -4.94333841e-02f, -1.11628368e-01f, 9.02988166e-02f, -2.73328461e-02f, 5.92970029e-02f,
  -6.16061985e-01f, -4.13362533e-01f, -6.34273589e-02f, -5.52851334e-02f, 1.06890678e-01f, 3.09472650e-01f, 1.66841015e-01f, -1.14533268e-01f, -3.54168534e-01f, -8.26510489e-02f,
  8.57116356e-02f, -1.87328592e-01f, -6.47438318e-02f, 1.48937821e-01f, 3.79907608e-01f, -8.66784528e-03f, 4.59494255e-02f, 1.36237398e-01f, -2.20760405e-02f, -1.41452864e-01f,
  4.67372639e-03f, 1.52169183e-01f, 2.62173057e-01f, 1.71886101e-01f, 3.89974266e-02f, -1.44295841e-01f, 6.18319325e-02f, 1.32015482e-01f, 2.95441508e-01f, 2.49561340e-01f,
  -5.02380021e-02f, -3.35309148e-01f, -1.83854192e-01f, -3.84748317e-02f, 4.34780829e-02f, -3.48380953e-02f, 8.08843300e-02f, 1.31413668e-01f, -7.83749446e-02f, 3.66442874e-02f,
  9.37175080e-02f, 8.06975644e-03f, 4.18611616e-02f, -4.41436097e-02f, -1.02340542e-01f, -2.55796406e-02f, -1.07094077e-02f, -7.67255053e-02f, -1.77853759e-02f, 1.02000693e-02f,
  -6.85446784e-02f, 8.71429220e-02f, -1.36100957e-02f, 1.44504443e-01f, 1.67581066e-02f, 4.59575281e-02f, 7.93476701e-02f, 4.71733771e-02f, -6.25820756e-02f, 8.21345747e-02f,
  3.50698866e-02f, 4.47537974e-02f, -5.23703806e-02f, -1.04984101e-02f, -7.64438063e-02f, 1.14030488e-01f, 4.56319787e-02f, 4.10048626e-02f, -2.34587360e-02f, 3.44770029e-02f,
  5.72360046e-02f, -9.84842405e-02f, -4.66873385e-02f, 3.73462471e-03f, -3.67270708e-02f, -3.69738825e-02f, 3.84106971e-02f, -6.51900545e-02f, 3.28127965e-02f, 8.18785504e-02f,
  -4.06480208e-02f, 5.42848483e-02f, 6.69568703e-02f, 1.82847399e-02f, -6.21035434e-02f, -8.74240771e-02f, -1.65772419e-02f, 4.02565580e-03f, -1.00146532e-01f, 5.83275333e-02f,
  -3.72092277e-01f, -3.79284114e-01f, -4.72031021e-03f, 4.91025066e-03f, 4.97290690e-04f, -1.47056967e-01f, 9.36865713e-03f, -1.33783326e-01f, -2.47199126e-02f, -1.49106860e-01f,
  6.07396886e-02f, 2.69253477e-02f, -2.80592702e-02f, -1.09738102e-02f, 9.81071070e-02f, -1.06199197e-01f, -1.33325860e-01f, -3.28983106e-02f, 3.67612694e-03f, -4.04655561e-02f,
  -2.24825181e-02f, -3.15868147e-02f, 3.97086553e-02f, -4.18820940e-02f, 1.43768182e-02f, 4.66133133e-02f, -1.93228081e-01f, -1.19132595e-02f, 1.20587930e-01f, 2.33868081e-02f,
  -1.17517583e-01f, 3.70918095e-01f, 3.03513736e-01f, -9.39643532e-02f, -2.37762630e-02f, 1.41406924e-01f, -1.36701509e-01f, 9.79181081e-02f, 6.02720194e-02f, 2.86155045e-01f,
  -1.20839320e-01f, 3.10755461e-01f, -1.16686836e-01f, -3.61913368e-02f, -2.82468110e-01f, -2.71520406e-01f, -2.44584069e-01f, -1.85759868e-02f, -1.25810251e-01f, 3.95978652e-02f,
  -1.16909675e-01f, -2.92795300e-01f, -1.15480870e-01f, -4.33722697e-03f, 1.37578234e-01f, 1.44167706e-01f, -2.04848796e-01f, -3.11066620e-02f, 7.87005872e-02f, -1.86069496e-02f,
  -4.74034175e-02f, 6.62997290e-02f, 1.92725807e-01f, 1.73100188e-01f, 4.70626168e-02f, 1.01939961e-01f, 9.02705118e-02f, -4.81761098e-02f, 6.57487363e-02f, 1.17435172e-01f,
  2.70692557e-02f, 5.72361536e-02f, 6.97597414e-02f, -5.67322597e-02f, 1.69117585e-01f, 1.07296176e-01f, 5.04796728e-02f, 6.30696714e-02f, 1.27447233e-01f, 1.27639115e-01f,
  9.37274769e-02f, 2.32062116e-01f, 8.49878043e-02f, 3.07846349e-02f, 2.71356199e-03f, 1.25105307e-01f, -9.71625932e-03f, 1.38898656e-01f, 9.98976752e-02f, 6.67767832e-04f,
  -6.52813017e-02f, -4.84617092e-02f, 3.60074937e-02f, 1.47898514e-02f, 1.43989560e-03f, 7.01827137e-03f, -2.08342038e-02f, -3.02616619e-02f, -4.00262438e-02f, -2.18742788e-02f,
  -2.82192770e-02f, 5.37366122e-02f, -2.66969483e-02f, 2.87535246e-02f, -4.85109538e-02f, 1.90524012e-02f, 1.31383736e-03f, 2.82856002e-02f, 5.25098518e-02f, -3.69772762e-02f,
  -2.28932276e-02f, -1.40393406e-01f, 2.84058359e-02f, -5.69109321e-02f, 8.98996070e-02f, 6.38752133e-02f, 3.28752995e-02f, 1.66951776e-01f, -1.02392435e-01f, -1.66427672e-01f,
  -1.89290643e-01f, -1.75225303e-01f, 1.93924177e-02f, 1.36286039e-02f, 2.23719571e-02f, 8.54650065e-02f, -1.21470504e-02f, 8.92596990e-02f, -1.14894949e-01f, -8.09135810e-02f,
  1.82829949e-03f, -2.15390306e-02f, 7.26323500e-02f, -4.93818298e-02f, -5.02932705e-02f, -1.02878727e-01f, -6.68563321e-02f, -2.03290693e-02f, 2.34686062e-02f, 2.04169732e-02f,
  7.64521807e-02f, -2.25460250e-02f, -5.73187284e-02f, 3.93581018e-03f, 1.62498411e-02f, 2.39124466e-02f, -9.29432511e-02f, 4.55863290e-02f, -8.39111879e-02f, 5.12755662e-03f,
  -3.14359277e-01f, 2.21686006e-01f, 1.75600171e-01f, -4.34050530e-01f, 1.76688895e-01f, 1.50243193e-01f, -3.33611131e-01f, -5.53647466e-02f, -3.30757201e-01f, -2.60361940e-01f,
  -2.66644597e-01f, -2.79505700e-02f, 2.03731835e-01f, -1.86330691e-01f, 4.21469137e-02f, 3.11452806e-01f, -1.00712530e-01f, -1.91529453e-01f, 2.64649391e-01f, -9.02331471e-02f,
  4.08295207e-02f, -7.27884099e-02f, 2.72347271e-01f, 1.06140748e-01f, -1.29008323e-01f, -1.12971902e-01f, -1.75900534e-02f, 1.58197388e-01f, -7.07922354e-02f, 9.66620743e-02f,
  3.13114002e-02f, -3.22033554e-01f, -3.49807180e-02f, -9.62473229e-02f, -1.16212226e-01f, -6.96121156e-02f, -1.03438221e-01f, -1.93167310e-02f, -1.07285492e-01f, -7.66943172e-02f,
  -1.02503642e-01f, 4.98907939e-02f, -5.97904287e-02f, 7.79042169e-02f, -4.59179766e-02f, -4.05545384e-02f, 1.07018992e-01f, 4.41129915e-02f, 5.95105663e-02f, 1.81152746e-01f,
  1.63364992e-01f, 1.00252498e-02f, 1.61605012e-02f, -1.08504757e-01f, 6.68737963e-02f, -1.69375539e-01f, -8.91381577e-02f, 6.78878054e-02f, 2.77279653e-02f, -1.02193445e-01f,
  -7.75959566e-02f, 9.60353911e-02f, 3.10753714e-02f, 9.25159827e-02f, -3.58266346e-02f, -1.14388600e-01f, 1.32291233e-02f, -1.32177956e-02f, -3.75444372e-03f, -8.91043171e-02f,
  1.47704482e-02f, 7.69834891e-02f, -5.06641530e-02f, -9.03387144e-02f, -1.32243074e-02f, -9.51726586e-02f, -7.02730715e-02f, 5.73037378e-02f, 2.43175924e-02f, -3.45487036e-02f,
  -2.37179324e-02f, -3.13328877e-02f, -9.54876244e-02f, 3.18274088e-02f, -4.34124544e-02f, -5.80364987e-02f, 2.26070769e-02f, 1.08832568e-02f, -4.28202115e-02f, 2.51541790e-02f,
  3.30482088e-02f, -3.20371956e-01f, 6.15335554e-02f, -7.95040429e-02f, 2.57505793e-02f, 5.65490462e-02f, 6.26875162e-02f, 3.09784636e-02f, 2.02201158e-02f, -8.39453191e-02f,
  -8.35687518e-02f, -3.98608483e-02f, -9.35515687e-02f, -2.19401531e-02f, -3.09113450e-02f, 1.68099105e-02f, -3.80835049e-02f, 1.84974521e-02f, -5.58866188e-02f, 2.68283691e-02f,
  -8.72949958e-02f, -5.76869352e-03f, 1.11023091e-01f, 1.52371470e-02f, 3.03721856e-02f, -1.64012872e-02f, 4.15006205e-02f, 2.99196038e-02f, 5.48265204e-02f, -2.07263194e-02f,
  2.26040855e-01f, 1.48717156e-02f, 7.17133507e-02f, -4.52704839e-02f, -2.51424879e-01f, 1.19121723e-01f, 7.10923299e-02f, -5.26983105e-02f, -9.92900208e-02f, -9.83117744e-02f,
  -3.22696656e-01f, 2.21047550e-01f, 4.88155261e-02f, -1.62342817e-01f, 2.88395196e-01f, 1.99089304e-01f, -4.29713279e-02f, 6.64888546e-02f, -7.65569359e-02f, -7.33468011e-02f,
  -1.26851052e-01f, -3.77160847e-01f, 1.96752208e-03f, -2.41370291e-01f, -1.40003338e-01f, -1.27621889e-01f, -2.17598870e-01f, -4.45727892e-02f, -1.83028504e-01f, -1.16689913e-01f,
  1.06061306e-02f, 6.92114234e-02f, 1.74404889e-01f, 2.15529308e-01f, 5.60439788e-02f, 7.68897086e-02f, 6.34942651e-02f, 1.51388705e-01f, 1.26038492e-01f, -8.72458983e-03f,
  6.57117367e-02f, 7.30891824e-02f, -7.32103409e-03f, -2.55023912e-02f, 1.31784948e-02f, -3.96523364e-02f, 8.28402117e-02f, 9.27546024e-02f, 1.71151129e-03f, -1.02797382e-01f,
  -9.17165950e-02f, 8.25956687e-02f, -1.09036379e-01f, 1.12649515e-01f, -1.08353563e-01f, 5.62145263e-02f, 3.53227407e-02f, 8.99984911e-02f, 5.88113293e-02f, 3.48243043e-02f,
  -1.38766348e-01f, -7.84556642e-02f, 4.58602495e-02f, -6.24379106e-02f, -4.01273146e-02f, -5.21838404e-02f, -5.65653965e-02f, -1.26727283e-01f, -3.99864800e-02f, 4.87117507e-02f,
  4.17686664e-02f, 2.99129784e-02f, -1.34820547e-02f, -7.15671182e-02f, -1.44965023e-01f, 8.05123597e-02f, -2.10595615e-02f, 2.17645168e-02f, -3.99447270e-02f, 8.82311445e-03f,
  -1.12181425e-01f, -4.73499931e-02f, 1.78084802e-02f, -1.25329541e-02f, 1.16597794e-01f, 3.51620652e-02f, -4.77615669e-02f, 6.37194514e-02f, -1.18141875e-01f, 2.02408824e-02f,
  3.98637988e-02f, 3.16243358e-02f, 1.00717776e-01f, 1.06122822e-01f, 3.40574682e-02f, 3.77264358e-02f, 1.08270004e-01f, 8.59630015e-03f, 5.47196232e-02f, 1.51348568e-03f,
  -1.16544344e-01f, 7.06840754e-02f, 2.99014952e-02f, -1.08859893e-02f, -5.18182991e-04f, 5.58590703e-02f, -3.59936035e-03f, 4.17399146e-02f, 2.74556410e-02f, -1.25196651e-01f,
  5.97826391e-03f, 3.55990529e-02f, 7.97061324e-02f, 6.47673607e-02f, -1.49348630e-02f, -1.41119072e-02f, 1.90773100e-01f, 8.44005272e-02f, -1.35419697e-01f, 6.73182234e-02f,
  -3.57263505e-01f, 1.10874109e-01f, -1.69138357e-01f, -1.88832477e-01f, 3.58365774e-02f, -3.45802724e-01f, -9.45939869e-02f, 9.47340205e-03f, 9.95256528e-02f, 1.84594721e-01f,
  2.28004262e-01f, -1.40108138e-01f, 2.20583409e-01f, -2.32779250e-01f, -2.34636173e-01f, -6.82680234e-02f, -3.51971716e-01f, -2.65328646e-01f, 5.72583638e-02f, -2.42854450e-02f,
  -2.12218508e-01f, 8.02887138e-03f, -1.67390257e-01f, 1.51851133e-01f, -2.04442993e-01f, 6.11781366e-02f, 1.32008493e-01f, 2.35490188e-01f, -2.33666599e-01f, 3.58863808e-02f,
  -1.07011266e-01f, 1.90657586e-01f, -2.27770638e-02f, -1.05474768e-02f, -6.43552989e-02f, -8.67867991e-02f, -3.85656068e-03f, 3.86391990e-02f, 6.85285032e-02f, -5.67885339e-02f,
  -3.13697159e-02f, -4.76640277e-02f, 8.98418352e-02f, 4.54032235e-03f, -4.34661023e-02f, -3.36037204e-02f, -7.90627673e-02f, -1.63879678e-01f, 1.29682451e-01f, -1.42318234e-01f,
  -1.18062645e-01f, -1.14525326e-01f, -3.35728601e-02f, -5.41987009e-02f, -5.24521694e-02f, 6.57724589e-02f, -1.06507123e-01f, -9.57032144e-02f, -1.52225494e-01f, 2.64329766e-03f,
  -3.42152920e-03f, -5.41010778e-03f, 2.86010653e-02f, 5.50797135e-02f, 6.01496734e-02f, 6.79804310e-02f, -6.03090934e-02f, 8.76804143e-02f, -9.83766094e-03f, -2.37634443e-02f,
  3.16776000e-02f, 8.29074532e-02f, 1.26258573e-02f, -9.10712928e-02f, -4.00204621e-02f, -7.75121078e-02f, 7.22331926e-04f, 2.80657448e-02f, -1.49602979e-01f, -4.20982763e-02f,
  1.44957826e-01f, 5.67826908e-03f, 5.78258187e-02f, 1.31455781e-02f, 3.76249067e-02f, -4.65062112e-02f, 4.09866422e-02f, 4.40488942e-02f, 4.23730463e-02f, 8.46556854e-03f,
  3.63612175e-02f, 2.34847337e-01f, 7.94457123e-02f, 1.12195127e-01f, -3.75587419e-02f, -5.63841350e-02f, 1.09551474e-02f, -1.22116674e-02f, 9.00848433e-02f, 2.99468823e-02f,
  -1.25982195e-01f, -2.10533757e-02f, -1.26885861e-01f, 7.81101137e-02f, 6.37082905e-02f, -3.42296846e-02f, 1.23485990e-01f, 8.70318040e-02f, -1.14896614e-02f, -1.61001622e-03f,
  -9.49591282e-04f, 4.09431942e-02f, -3.88053954e-02f, 4.88420390e-02f, -4.13695052e-02f, -3.50520052e-02f, 4.98572737e-03f, 4.74621216e-03f, -4.40262705e-02f, -4.56466712e-02f,
  2.02342849e-02f, 3.01866293e-01f, 4.69933115e-02f, 9.78911645e-04f, -2.68778533e-01f, 2.64978781e-02f, 8.68930947e-04f, -1.99356169e-01f, 2.13717684e-01f, 2.83606686e-02f,
  -3.15731823e-01f, 2.03285247e-01f, -8.88588428e-02f, -1.42088369e-01f, -4.04043011e-02f, 1.58880949e-01f, 4.20849351e-03f, 1.15404785e-01f, 9.63023677e-02f, -1.73367724e-01f,
  -5.44861704e-02f, -2.47600719e-01f, -2.57325977e-01f, -2.50951141e-01f, -2.14435145e-01f, 1.45712778e-01f, -8.12476501e-02f, -5.97408600e-02f, 1.42468497e-01f, 1.46340311e-01f,
  -1.11625515e-01f, -1.64977312e-01f, 1.27610182e-02f, 1.16702728e-01f, -5.33353128e-02f, -3.34411450e-02f, 9.37904418e-02f, 6.00558110e-02f, -6.50645792e-02f, -2.27615871e-02f,
  -4.44921711e-03f, 1.45733312e-01f, 8.34390819e-02f, 1.46625312e-02f, 2.21531913e-02f, 3.27420421e-02f, -5.21506332e-02f, -1.63431421e-01f, -8.85433853e-02f, -1.08049260e-02f,
  3.19375359e-02f, -1.42045990e-02f, -9.17414278e-02f, 1.66185781e-01f, 3.32146920e-02f, -1.76203400e-02f, 5.37461899e-02f, 1.85518265e-01f, 2.17317149e-01f, 1.45136803e-01f,
  -3.88471633e-02f, 1.10171214e-01f, -8.20313469e-02f, -7.60102868e-02f, -2.93021067e-03f, 2.50853654e-02f, 2.78852303e-02f, 1.56134814e-02f, -2.35879589e-02f, -4.87781167e-02f,
  -5.46359979e-02f, 1.27210785e-02f, -3.98935489e-02f, 1.02247976e-01f, 1.11580370e-02f, 5.58181033e-02f, 3.15661915e-02f, -1.22650936e-02f, 2.78095622e-02f, -7.82252625e-02f,
  -1.13218978e-01f, 1.00014068e-01f, 4.30312939e-02f, -1.85455661e-02f, -3.13119516e-02f, 8.19218159e-02f, 4.86423215e-03f, 5.36825843e-02f, -7.06421304e-03f, -4.22847793e-02f,
  -1.06587233e-02f, 2.18103737e-01f, 9.58077163e-02f, -2.70330440e-03f, 1.51496589e-01f, 8.21471587e-02f, 1.93651207e-02f, 3.21073234e-02f, 9.72869545e-02f, -3.14894803e-02f,
  1.56080518e-02f, 1.55502483e-01f, 4.84926105e-02f, -2.35125329e-02f, 2.77458765e-02f, -6.44383207e-03f, -5.63287027e-02f, 9.10036489e-02f, -5.67926019e-02f, -2.22386494e-02f,
  -1.46446198e-01f, 3.99193391e-02f, -5.28171211e-02f, -7.73355514e-02f, 7.13526756e-02f, -3.20848636e-02f, 1.00746810e-01f, 1.88405007e-01f, 4.38777767e-02f, 1.26834176e-02f,
  -7.80479237e-02f, 2.85650231e-02f, -2.06419230e-01f, 1.32143602e-01f, -2.84019887e-01f, 2.85745800e-01f, 5.46362936e-01f, -1.82708994e-01f, -1.74965709e-01f, 1.86714858e-01f,
  2.67533123e-01f, -5.41967154e-02f, 1.63666919e-01f, 3.31549793e-01f, 2.23467112e-01f, 1.95053354e-01f, 2.11236313e-01f, 3.07021409e-01f, -1.01961076e-01f, -1.01993456e-01f,
  -1.43219650e-01f, 2.31609687e-01f, 5.92795834e-02f, -2.34867558e-01f, -3.33125703e-02f, -2.34038845e-01f, 1.18861474e-01f, -7.26687685e-02f, 8.88462514e-02f, -6.15495781e-04f,
  -5.47006652e-02f, -4.69894223e-02f, 8.90426897e-03f, -4.43108156e-02f, -2.75494717e-02f, 1.50608597e-03f, 1.59397706e-01f, 3.48353423e-02f, -1.05991922e-01f, 7.02759251e-02f,
  6.01527058e-02f, -8.09932575e-02f, -1.17881291e-01f, 1.08718187e-01f, -8.81780386e-02f, -1.69740811e-01f, -1.78573921e-01f, -6.67992840e-03f, 2.93453746e-02f, -6.63831308e-02f,
  -8.68688002e-02f, 1.81905050e-02f, 3.18247341e-02f, -2.77565382e-02f, -4.60426956e-02f, 1.48922764e-02f, -3.01434239e-03f, 2.70955991e-02f, 1.86776207e-03f, -7.54645169e-02f,
  7.38874136e-04f, 1.01271225e-02f, 6.91024587e-03f, 1.38159931e-01f, -4.40750569e-02f, 6.41177669e-02f, 4.68734764e-02f, 1.42957428e-02f, -5.48986904e-02f, -5.73531017e-02f,
  -5.00610620e-02f, -6.54285550e-02f, 5.41362800e-02f, 9.25067812e-03f, -3.81861068e-02f, 1.08351298e-01f, 1.21093303e-01f, -6.31900728e-02f, -1.20940082e-01f, -7.13847484e-03f,
  8.75576362e-02f, -9.87291150e-03f, -6.51410744e-02f, 8.39896724e-02f, 6.20469749e-02f, -6.47578761e-02f, -8.15783441e-02f, 2.43981779e-02f, 1.86451450e-02f, 7.62555376e-02f,
  1.69290140e-01f, 1.40034044e-02f, -8.39731097e-02f, -4.23778184e-02f, 3.42930369e-02f, -8.48540068e-02f, 8.72717127e-02f, -9.99065116e-02f, -5.02093062e-02f, 2.71955598e-02f,
  5.00300974e-02f, 9.70284417e-02f, -1.50979668e-01f, -6.64810687e-02f, 4.85483669e-02f, -1.12831742e-01f, 9.78213027e-02f, 1.36824585e-02f, 7.59687349e-02f, -5.48343360e-02f,
  3.10021546e-03f, 3.27688865e-02f, 6.77004084e-02f, -2.43728589e-02f, 9.30134300e-03f, 8.56278017e-02f, -7.04830438e-02f, -9.08096284e-02f, 8.79156962e-02f, -2.16176026e-02f,
  2.31881440e-01f, -2.02968597e-01f, 2.80674640e-03f, 4.97989617e-02f, -1.01956926e-01f, -8.57008174e-02f, -2.91606644e-04f, -3.23695801e-02f, 1.48467198e-01f, -3.31967831e-01f,
  -1.93808243e-01f, 1.70515627e-01f, 3.14695299e-01f, -2.41691068e-01f, 4.34939951e-01f, 1.90863773e-01f, -4.91083693e-03f, 1.65410470e-02f, 7.48565188e-04f, 6.04155054e-03f,
  1.16750993e-01f, -3.15489411e-01f, 9.64285154e-03f, -2.62447715e-01f, -2.67950535e-01f, -2.18027651e-01f, -1.76335022e-01f, -1.34248659e-01f, -4.02615041e-01f, 3.18281017e-02f,
  -5.24991639e-02f, -4.61242907e-03f, -6.08134270e-02f, -3.75035517e-02f, 4.10661437e-02f, 4.50537875e-02f, -2.58472711e-02f, 5.45702700e-04f, -2.11377889e-02f, -5.40402867e-02f,
  3.58734019e-02f, -8.13794732e-02f, -2.15029083e-02f, 1.20959699e-01f, 2.22421102e-02f, -1.53509155e-01f, -1.02701724e-01f, -4.08650376e-02f, -8.13630149e-02f, 8.82580206e-02f,
  4.23083603e-02f, 4.06245515e-02f, -8.24753009e-03f, -3.21090221e-02f, 7.00903982e-02f, -6.26925975e-02f, 1.74284205e-02f, 9.09296721e-02f, 4.34070155e-02f, 4.75021489e-02f,
  -2.91727241e-02f, 1.21730566e-01f, 3.73889096e-02f, -1.55404359e-01f, 4.42571864e-02f, -1.45102695e-01f, -5.97239956e-02f, -6.40453324e-02f, 2.10481957e-02f, -6.37567714e-02f,
  3.59342806e-02f, 7.02979565e-02f, 5.33064790e-02f, 7.53494129e-02f, -7.27715641e-02f, 1.16510861e-01f, -4.05800045e-02f, -1.17549129e-01f, 3.69533449e-02f, -4.92961146e-02f,
  -7.32332328e-03f, 2.69448422e-02f, -5.15796728e-02f, -1.37398764e-01f, -1.14046670e-01f, 5.33416402e-03f, -2.33339611e-02f, 1.66049786e-02f, 3.40892747e-02f, 3.73914205e-02f,
  9.47440416e-02f, 9.31693316e-02f, 1.26452269e-02f, -9.10483301e-02f, -3.42064835e-02f, 3.60836498e-02f, -1.31793723e-01f, -1.18330285e-01f, -6.69853240e-02f, 3.17643187e-03f,
  -2.46992670e-02f, -4.00084667e-02f, -2.48182788e-02f, -6.08445555e-02f, 7.92707037e-03f, -2.59937830e-02f, 2.95818653e-02f, 5.44480197e-02f, 9.29330513e-02f, 3.73784788e-02f,
  2.19068639e-02f, 6.80176988e-02f, -1.47530194e-02f, -1.29943509e-02f, -2.66439226e-02f, 3.71497124e-02f, 5.73489480e-02f, -8.73614475e-02f, 1.11160494e-01f, 6.30041808e-02f,
  2.94009984e-01f, 3.69303763e-01f, 3.44826788e-01f, 4.29393530e-01f, -2.82208085e-01f, -2.37349212e-01f, -7.26295188e-02f, 5.20888530e-02f, 1.61106288e-01f, 3.21441181e-02f,
  -1.26130253e-01f, 3.50075990e-01f, -1.80731148e-01f, 2.69032381e-02f, -1.78308561e-01f, -2.14996263e-01f, 6.96026087e-02f, 1.27421498e-01f, 8.38688612e-02f, 1.78276882e-01f,
  1.29990742e-01f, -1.78700760e-01f, 1.56424671e-01f, -6.11245595e-02f, 3.09362650e-01f, 2.42005110e-01f, 4.62398604e-02f, -4.59267944e-02f, 1.00200646e-01f, -1.98924914e-01f,
  -1.57113448e-01f, 3.22869793e-02f, 1.32785827e-01f, 2.86539514e-02f, 1.94832459e-02f, -6.16781786e-02f, -4.14908044e-02f, -1.20595895e-01f, 5.27579663e-03f, 2.48535573e-02f,
  -8.88928585e-03f, -1.17496319e-01f, 1.55863855e-02f, 1.22323167e-02f, 3.02881235e-03f, 1.21595912e-01f, 6.16102479e-03f, 4.24581692e-02f, 9.53323096e-02f, 1.22261234e-02f,
  8.38924497e-02f, 7.65833398e-03f, -2.15040706e-02f, -9.66690630e-02f, 1.02317203e-02f, -4.77517992e-02f, -4.04624566e-02f, 2.41709594e-02f, 6.17110431e-02f, 3.34430411e-02f,
  -1.20486565e-01f, -2.86026318e-02f, 6.09252863e-02f, -4.89361875e-04f, 4.98025268e-02f, 6.12841770e-02f, 2.35981005e-03f, -2.14235783e-02f, 6.09232448e-02f, -6.32040873e-02f,
  -1.27598708e-02f, -1.06547354e-02f, -1.17600888e-01f, 4.96823639e-02f, 2.86058243e-02f, -6.78678101e-04f, -7.03974161e-03f, -1.35798439e-01f, 4.93683852e-02f, 2.75775865e-02f,
  1.65064931e-02f, -5.49491234e-02f, 2.63744611e-02f, 1.95150729e-02f, -9.11957249e-02f, -2.51887944e-02f, -7.24839885e-03f, 1.44834500e-02f, 1.44512001e-02f, 2.93821078e-02f,
  -1.22460365e-01f, 2.39724219e-01f, 8.55044462e-03f, -1.46357372e-01f, -1.21042296e-01f, -1.39796212e-02f, -8.01370814e-02f, -7.42046088e-02f, 5.09541593e-02f, -1.64309498e-02f,
  -1.25260456e-02f, 2.43721381e-02f, -5.51264640e-03f, -8.14871714e-02f, -9.97864157e-02f, -3.64314951e-02f, 1.13162976e-02f, 5.09795323e-02f, 5.68272546e-02f, 6.95157275e-02f,
  1.50458083e-01f, -1.00286882e-02f, 1.17674591e-02f, -1.65908840e-02f, 1.52138602e-02f, -7.60853812e-02f, 5.58862137e-03f, -4.32816967e-02f, 2.63809133e-03f, -2.64858920e-02f,
  3.40627581e-01f, 2.40226671e-01f, 1.32694960e-01f, 2.66902953e-01f, 2.53580492e-02f, -2.64965028e-01f, -1.76604182e-01f, 6.92090765e-02f, -2.70707905e-02f, 6.06112108e-02f,
  -8.36096331e-02f, 2.67583579e-01f, -1.81514651e-01f, -7.41901100e-02f, -4.20952022e-01f, -3.05381328e-01f, -4.56638560e-02f, 7.65005723e-02f, -7.99199864e-02f, 2.42957130e-01f,
  -7.35109895e-02f, -6.27735853e-02f, -1.09623753e-01f, 5.14815114e-02f, 1.08703837e-01f, 2.42303208e-01f, 7.89822266e-03f, 9.04585887e-03f, 2.10281864e-01f, -1.66063920e-01f,
  -8.22102726e-02f, -3.79954651e-02f, 4.29501124e-02f, -2.30452418e-02f, 6.08462729e-02f, 8.82769823e-02f, -5.10787033e-02f, -1.36999950e-01f, -1.55947357e-01f, -6.41395599e-02f,
  3.43255661e-02f, -3.25635262e-02f, 6.92882985e-02f, -6.71902150e-02f, 8.53749067e-02f, 1.13058090e-01f, 7.94055238e-02f, 3.92414443e-02f, -1.71104893e-02f, 1.48125235e-02f,
  1.31175861e-01f, -2.94520473e-03f, 1.25234112e-01f, 4.10547517e-02f, -9.12096575e-02f, -1.87215526e-02f, 6.81570843e-02f, 3.96582633e-02f, 1.13551699e-01f, -9.71139222e-03f,
  -3.73093854e-03f, 1.20898345e-02f, -4.73326072e-02f, 1.05623333e-02f, -8.44203383e-02f, -7.80295283e-02f, 4.85013612e-02f, -4.04968262e-02f, -3.32958177e-02f, -4.28217947e-02f,
  1.25122881e-02f, 8.94019753e-02f, -4.05309536e-02f, 4.52703331e-03f, -3.23015451e-02f, 6.57459209e-03f, -1.88976973e-02f, -7.52575025e-02f, 2.99146306e-02f, 1.98946111e-02f,
  -1.16226383e-01f, -3.84460427e-02f, 5.31513877e-02f, -1.10560074e-03f, -1.01100996e-01f, -7.67290965e-02f, -3.66624668e-02f, -7.37561285e-02f, 3.67001183e-02f, 3.30580920e-02f,
  7.12828264e-02f, -5.56073524e-02f, 8.49135444e-02f, -1.22734681e-01f, 7.66063556e-02f, -5.19463569e-02f, -6.02445006e-02f, 9.84820575e-02f, 1.74049176e-02f, 9.02285241e-03f,
  -4.47664745e-02f, -1.42946392e-02f, -6.41859369e-03f, -9.67750698e-03f, 3.81688289e-02f, -4.63485122e-02f, 7.12273568e-02f, 4.51995544e-02f, 3.88038531e-02f, -3.83438705e-03f,
  1.14941649e-01f, 3.21060754e-02f, 8.96726474e-02f, -3.03293258e-04f, 8.19576308e-02f, 9.73980501e-02f, 5.96812107e-02f, -4.11796793e-02f, -3.20430286e-02f, 1.30027893e-03f,
  9.36783403e-02f, -3.47449303e-01f, 2.28876248e-01f, 1.02868095e-01f, 4.88639660e-02f, 6.08394071e-02f, 2.66656667e-01f, -1.92693204e-01f, -2.80211955e-01f, -3.83921474e-01f,
  1.31429255e-01f, -3.49840559e-02f, 3.50198209e-01f, 2.71948520e-02f, 4.18453366e-01f, 1.62970960e-01f, 7.94654116e-02f, -5.29712252e-03f, 1.66569799e-01f, 2.48261988e-01f,
  1.23953380e-01f, -5.49463509e-03f, 2.86504000e-01f, -2.90528774e-01f, 1.43869370e-01f, -1.03606790e-01f, 5.06386273e-02f, 1.47439510e-01f, -2.08315924e-01f, 1.35977313e-01f,
  1.24375321e-01f, 2.92211566e-02f, 5.08134924e-02f, 1.97909996e-02f, 1.50334900e-02f, 5.66611253e-02f, 1.76511444e-02f, 1.31244719e-01f, 1.58778250e-01f, 3.80354077e-02f,
  -7.13705197e-02f, -6.61692466e-04f, -1.95717871e-01f, 5.32585979e-02f, -1.01339966e-01f, -9.62027237e-02f, 6.49907589e-02f, -1.31550319e-02f, -8.46647993e-02f, 1.13081597e-01f,
  1.41363129e-01f, -1.29714638e-01f, -1.99375395e-02f, -1.02029257e-01f, -3.37439254e-02f, -8.48027170e-02f, -8.01397413e-02f, 2.32339464e-02f, -4.30858880e-02f, -1.82296321e-01f,
  -9.02634412e-02f, -6.17193058e-02f, -4.91651334e-03f, 2.89735254e-02f, 3.93883511e-02f, 2.26063444e-03f, -1.25881851e-01f, -4.28354070e-02f, 4.92861159e-02f, -4.40024398e-02f,
  -6.11323714e-02f, 5.08100763e-02f, 6.29968643e-02f, -5.72432615e-02f, -8.27242620e-03f, -8.88732299e-02f, 8.61308277e-02f, -7.89417103e-02f, 3.45015004e-02f, 6.12026528e-02f,
  7.21925870e-02f, -9.06858817e-02f, 1.12308608e-02f, -3.01452447e-02f, -1.05398878e-01f, 8.36652145e-02f, -8.87478814e-02f, -6.75156489e-02f, 5.85830621e-02f, 5.61345331e-02f,
  8.50587860e-02f, -8.25297236e-02f, 7.73339421e-02f, -4.72269654e-02f, 9.94964689e-02f, 6.65554702e-02f, -3.76980901e-02f, -1.10930145e-01f, -3.78603861e-02f, 4.30129394e-02f,
  -1.00746388e-02f, 6.15006872e-02f, -3.26168239e-02f, -6.28565997e-02f, -6.72464818e-02f, 6.55090585e-02f, 1.01381533e-01f, -8.10609236e-02f, 4.36473377e-02f, -1.37801364e-01f,
  2.60531809e-02f, -1.07328668e-01f, -5.29464185e-02f, -2.19380856e-02f, -1.12953581e-01f, -1.30848169e-01f, -4.30919528e-02f, -5.78949228e-02f, -6.78781271e-02f, 2.74521858e-02f,
  -1.50279760e-01f, 1.23706616e-01f, 2.28287920e-01f, 1.25734255e-01f, 1.05230428e-01f, 4.18981582e-01f, 2.85878062e-01f, 3.19036126e-01f, 4.41085339e-01f, -3.77486609e-02f,
  1.82338264e-02f, -2.76270151e-01f, 1.21170022e-01f, 1.41757309e-01f, -8.35458487e-02f, 2.83556014e-01f, 2.11399660e-01f, 2.20063776e-01f, 2.22992688e-01f, -6.70972466e-02f,
  6.96336329e-02f, -1.33553520e-01f, -2.08138257e-01f, -2.45830312e-01f, -7.91509300e-02f, -1.42070949e-01f, -3.27614307e-01f, 2.86076758e-02f, -1.25831231e-01f, 9.68455374e-02f,
  -5.38965501e-02f, 7.37450272e-02f, -2.16790155e-01f, 2.13126969e-02f, 3.72890308e-02f, 6.66067153e-02f, -5.67976153e-03f, 4.92551066e-02f, 6.10310473e-02f, 8.39780942e-02f,
  -3.39855962e-02f, -1.05713792e-02f, -6.62822276e-02f, 4.51602899e-02f, 5.47914347e-03f, -2.47217696e-02f, -8.22419301e-03f, -2.02626251e-02f, -4.58662733e-02f, 4.81591560e-04f,
  -1.65671155e-01f, 6.96695223e-02f, 9.93445590e-02f, -7.60833640e-03f, -1.11407787e-01f, 6.44098893e-02f, 5.00912890e-02f, -3.75588387e-02f, -7.11599812e-02f, 1.63153894e-02f,
  8.73384625e-02f, 4.76222448e-02f, -8.87504071e-02f, -1.87823698e-02f, -7.48395249e-02f, -1.87289063e-02f, 3.22401859e-02f, -1.98726039e-02f, 5.67212999e-02f, -3.09538245e-02f,
  2.70737316e-02f, -3.47872823e-02f, 1.52150601e-01f, 7.46862823e-03f, 4.28192206e-02f, 2.68407837e-02f, -3.38567793e-02f, -2.74431631e-02f, 3.44938077e-02f, -7.44839385e-02f,
  3.23086493e-02f, 5.68330921e-02f, -1.24753065e-01f, -6.82237297e-02f, -8.22422355e-02f, 7.03841001e-02f, 5.85810989e-02f, 3.01609281e-02f, 1.34027600e-02f, -9.76979733e-03f,
  6.69321269e-02f, 1.27613097e-01f, -1.24907941e-01f, -5.34424074e-02f, -9.14311334e-02f, -1.11388445e-01f, 1.28075778e-01f, -6.05570748e-02f, -1.83478054e-02f, 4.09305282e-02f,
  1.59991663e-02f, 4.05370295e-02f, -3.97645757e-02f, 9.42746103e-02f, -7.18354583e-02f, -2.12745685e-02f, 4.54455316e-02f, 9.65017676e-02f, -1.05034918e-01f, -4.67524566e-02f,
  -1.34957716e-01f, 2.01462656e-02f, 1.80267226e-02f, -7.45625049e-02f, -1.11781235e-03f, -4.33245227e-02f, -4.33348045e-02f, -3.93182002e-02f, -9.96380225e-02f, -5.54614514e-02f,
  2.97629088e-01f, -2.99707353e-01f, -4.29253727e-01f, -1.76456682e-02f, 2.39987448e-01f, 1.39887929e-01f, -1.51521459e-01f, 1.25091136e-01f, -2.65475392e-01f, -7.04019070e-02f,
  3.29178758e-02f, -1.41504750e-01f, -2.27991953e-01f, 2.65506674e-02f, 1.85665444e-01f, -2.16738448e-01f, 1.42674685e-01f, -6.47949055e-02f, -1.35222301e-01f, 3.66073959e-02f,
  3.76092009e-02f, 2.33179137e-01f, -1.33753181e-01f, 1.45095184e-01f, 2.28244707e-01f, -1.29681528e-02f, 1.82242215e-01f, -9.24939290e-02f, 2.30758071e-01f, 1.98131323e-01f,
  2.53119059e-02f, -1.24478966e-01f, -1.31973386e-01f, 7.89466500e-02f, 5.47731929e-02f, 7.88435042e-02f, 2.97414861e-03f, -7.65576493e-03f, -6.13888726e-02f, -1.14566861e-02f,
  -5.62031604e-02f, -5.11460332e-03f, 8.81971344e-02f, 7.11589828e-02f, 1.06153302e-01f, -7.07383873e-03f, -1.16703339e-01f, 4.59840149e-02f, -1.32604882e-01f, -9.49572846e-02f,
  -1.73843995e-01f, -2.15347018e-02f, 1.40450314e-01f, 8.55813175e-02f, -1.83217123e-01f, -1.07210325e-02f, 2.56624054e-02f, -5.91413788e-02f, 8.42550248e-02f, -4.20706831e-02f,
  7.48485178e-02f, 1.33603998e-02f, 5.56968451e-02f, 1.05653256e-02f, 2.69324686e-02f, -3.37736867e-02f, 1.35169670e-01f, -1.27521023e-01f, 3.99053879e-02f, -4.88315150e-02f,
  -4.17678058e-02f, 7.75265619e-02f, -1.80659518e-02f, -1.14387162e-02f, -2.30723042e-02f, -3.32456566e-02f, -2.00139242e-03f, -2.51189061e-02f, -1.67349145e-01f, -4.77561019e-02f,
  1.00687230e-02f, 1.07038260e-01f, -1.02645621e-01f, 1.21511482e-01f, -1.11863520e-02f, 2.76361275e-02f, -1.43238958e-02f, -1.35584429e-01f, 2.89513208e-02f, 4.56132069e-02f,
  4.73060645e-03f, 3.63056432e-03f, 6.40513143e-03f, -2.68468205e-02f, -5.43817654e-02f, 3.37483548e-02f, 3.89475981e-03f, -6.43079877e-02f, 9.74956807e-03f, -7.16037601e-02f,
  -3.17049548e-02f, 1.10860139e-01f, 8.80867466e-02f, 4.68460433e-02f, 1.32708594e-01f, -5.42329103e-02f, 4.48916815e-02f, 6.33944348e-02f, 9.66713652e-02f, -8.91812667e-02f,
  -3.70341726e-02f, -3.17195281e-02f, 1.25631928e-01f, -2.16984972e-02f, -4.21334319e-02f, 8.86795446e-02f, 9.90985855e-02f, 4.19022655e-03f, -2.76969466e-02f, -4.92437482e-02f,
  2.06598863e-01f, -1.71729386e-01f, -1.74653068e-01f, -7.37973722e-03f, 9.36410502e-02f, 2.68054932e-01f, -7.67266471e-03f, -5.63319027e-02f, -2.90233791e-01f, -2.03585960e-02f,
  -2.21283175e-02f, 5.31446338e-02f, -1.16559707e-01f, 2.11893424e-01f, -9.84700955e-03f, -3.04202825e-01f, 1.12239763e-01f, 1.11121476e-01f, -1.68308184e-01f, 6.35590404e-02f,
  -2.35578492e-02f, 2.58138329e-01f, -8.46657306e-02f, 5.98380752e-02f, 1.29866019e-01f, 4.81825955e-02f, 7.87251592e-02f, -1.25527203e-01f, 2.21874565e-01f, 6.08853586e-02f,
  -2.73630600e-02f, -6.31180853e-02f, 9.12898108e-02f, -5.69651686e-02f, 7.38154352e-02f, 1.45452231e-01f, 3.60580124e-02f, 1.09160781e-01f, -3.02856322e-02f, -5.95429987e-02f,
  -5.50498813e-02f, 1.36300981e-01f, 3.29031907e-02f, -2.50843111e-02f, 5.34013100e-02f, 1.16695918e-01f, -5.23685254e-02f, 2.21342836e-02f, -6.76179864e-03f, -2.51292009e-02f,
  -1.07282124e-01f, -4.72437181e-02f, -1.10145830e-01f, 3.35654244e-02f, -7.77086467e-02f, -9.11582261e-02f, -3.56375851e-04f, -8.88475105e-02f, -8.87490716e-03f, 1.02577843e-01f,
  3.09419371e-02f, -2.13098358e-02f, 4.21998091e-02f, 4.36990149e-02f, -8.63910466e-03f, 3.78609784e-02f, 3.94500531e-02f, -5.78026175e-02f, -4.29133847e-02f, 4.52884659e-02f,
  2.23659296e-02f, 1.19214086e-02f, -7.42624477e-02f, -4.60652336e-02f, 1.40813857e-01f, 4.76985797e-02f, 3.49059962e-02f, 7.31867179e-02f, -6.18721321e-02f, -1.16516976e-02f,
  -1.16836950e-01f, -7.41080847e-03f, 3.10829636e-02f, -9.89485756e-02f, -5.48702106e-02f, -1.39851579e-02f, 1.64136216e-02f, 6.48868307e-02f, -4.38122787e-02f, 5.31527065e-02f,
  1.75446831e-02f, 2.33141496e-03f, -1.23196721e-01f, 3.05391569e-02f, -4.53582183e-02f, 1.63591415e-01f, -5.13968319e-02f, 3.71988900e-02f, -1.16068698e-01f, -1.10363476e-01f,
  1.62961364e-01f, -3.30903418e-02f, 6.56456202e-02f, 5.41548729e-02f, 2.17158515e-02f, 1.04363680e-01f, 4.55365218e-02f, -1.65048847e-03f, 7.12062940e-02f, 6.37360215e-02f,
  -8.47014859e-02f, 1.02746703e-01f, -4.11571115e-02f, 2.51930784e-02f, 9.89075080e-02f, -3.61174941e-02f, 1.89696699e-02f, 3.24076228e-02f, -5.07272221e-03f, -4.43390533e-02f,
  -9.89768207e-02f, -1.14434436e-02f, -2.41810471e-01f, -1.98860481e-01f, 7.95830861e-02f, -2.88911343e-01f, -2.61861712e-01f, -1.35412738e-01f, -2.25487307e-01f, 1.19081736e-01f,
  -1.66407540e-01f, 7.24593475e-02f, 8.58737007e-02f, -2.66538978e-01f, -3.76549751e-01f, 7.82602280e-03f, -1.67279378e-01f, -1.63085803e-01f, -5.07813692e-03f, -2.14569196e-01f,
  -4.54544052e-02f, -2.88493872e-01f, -2.67023414e-01f, 5.11198565e-02f, -1.99799523e-01f, 4.54930449e-03f, 6.04840592e-02f, 1.21385204e-02f, -7.93244168e-02f, -3.52297649e-02f,
  -1.19980713e-02f, -1.12426601e-01f, -7.24588335e-02f, 6.19260371e-02f, 2.87549030e-02f, 3.40861119e-02f, 5.40210083e-02f, 1.57521456e-03f, 1.00244768e-01f, -1.47307739e-01f,
  4.46753129e-02f, -8.43201764e-03f, -4.62051183e-02f, -7.00746030e-02f, -1.03054479e-01f, -5.85532822e-02f, 1.20211855e-01f, -8.68927687e-03f, -1.43037811e-01f, -1.09258413e-01f,
  -4.69513312e-02f, -2.57772505e-02f, -8.35680589e-02f, -8.01601708e-02f, 3.72146778e-02f, -5.51288500e-02f, 8.91568512e-02f, 7.04568699e-02f, -4.98336144e-02f, 3.77100185e-02f,
  7.87774622e-02f, -2.32493374e-02f, -8.54913816e-02f, -4.83523905e-02f, 8.29551183e-03f, 5.08826263e-02f, -6.64972663e-02f, 1.99491344e-02f, 5.04211001e-02f, 6.44414499e-02f,
  3.89794223e-02f, 3.28160971e-02f, 2.23859902e-02f, -6.95611537e-02f, -2.01010164e-02f, 2.65449602e-02f, 4.64301482e-02f, 1.13622677e-02f, -1.14476606e-01f, 4.66266200e-02f,
  1.05117954e-01f, -7.05862120e-02f, -3.02480422e-02f, 4.36151177e-02f, -1.68023959e-01f, -5.57762049e-02f, 2.27558222e-02f, -3.73693220e-02f, 3.39811705e-02f, -6.33497387e-02f,
  -2.57878960e-03f, -2.26515383e-02f, -4.35780035e-03f, -2.17678454e-02f, 6.96268976e-02f, 4.03524488e-02f, -7.35183200e-03f, -1.32509977e-01f, -1.29354224e-02f, -1.56445354e-02f,
  -1.40070813e-02f, 6.28495216e-02f, 6.53610602e-02f, -1.02329496e-02f, 2.45771054e-02f, 4.68102889e-03f, 1.69988468e-01f, 8.65543932e-02f, 2.56241276e-03f, 3.22827362e-02f,
  4.02559945e-03f, 8.66024867e-02f, -3.94077338e-02f, -4.46297936e-02f, -5.56269586e-02f, -4.16709390e-03f, 2.20012255e-02f, 9.32203755e-02f, 1.38375582e-02f, 3.20875384e-02f,
  -2.45451555e-01f, 3.20869349e-02f, -7.14537874e-02f, -3.29182386e-01f, 1.31418377e-01f, -1.47904575e-01f, -2.51917750e-01f, 2.04888374e-01f, -1.70673970e-02f, 4.67802882e-02f,
  5.44576198e-02f, -2.49852270e-01f, 1.40104517e-01f, -3.32567155e-01f, -1.68254107e-01f, -8.51339549e-02f, -2.80766666e-01f, -2.01919556e-01f, -5.00864983e-02f, 1.11018084e-01f,
  4.09541987e-02f, -8.72602537e-02f, 2.98938937e-02f, 1.64021209e-01f, 6.52400253e-04f, 1.66228890e-01f, 2.79299170e-01f, 1.60190210e-01f, 1.64948441e-02f, -1.26227126e-01f,
  -7.24113584e-02f, 7.09497407e-02f, -8.63992050e-03f, 2.98595019e-02f, 1.15874328e-01f, 1.33832553e-02f, -6.16104528e-03f, -3.40011902e-02f, -8.55327919e-02f, 5.38336672e-02f,
  6.98749814e-03f, 4.02097702e-02f, -9.51538309e-02f, 3.29988115e-02f, 6.79197311e-02f, -6.72263652e-02f, -7.10689323e-03f, -3.21190022e-02f, 1.18656233e-02f, -5.70436940e-02f,
  -6.16374835e-02f, -3.15083303e-02f, -5.00913598e-02f, 2.28047557e-02f, 1.66915003e-02f, -1.17745750e-01f, -6.98805824e-02f, 4.06761933e-03f, 3.26986015e-02f, 5.86212724e-02f,
  2.55196984e-03f, 2.24627424e-02f, -6.92279264e-02f, -1.74101405e-02f, -2.16349848e-02f, -9.81160812e-03f, 5.49309179e-02f, 7.12974072e-02f, -4.84153628e-02f, -1.56418420e-02f,
  8.84856004e-03f, -8.33217949e-02f, -3.71664613e-02f, 6.28005341e-02f, -1.24172419e-02f, -1.38137102e-01f, 7.10511871e-04f, 3.67826819e-02f, 2.49511041e-02f, 2.38453057e-02f,
  1.70167461e-02f, -5.50814196e-02f, -3.38454209e-02f, 6.87323511e-02f, -1.04685321e-01f, -3.59907225e-02f, -7.04027712e-02f, -8.84976238e-02f, -8.45187306e-02f, 6.31248131e-02f,
  9.07655507e-02f, 2.55151659e-01f, 1.31413415e-01f, -5.96606464e-04f, -1.45557206e-02f, 6.03590719e-02f, 5.36156446e-02f, 4.47184853e-02f, 3.53246443e-02f, -3.84901650e-02f,
  2.65038870e-02f, 4.47941944e-02f, 1.48199186e-01f, -7.58560970e-02f, 5.69471456e-02f, -1.16078341e-02f, 4.40220861e-03f, 5.89725897e-02f, 1.87549174e-01f, 1.18563525e-01f,
  7.34440759e-02f, -5.33638895e-02f, -7.56168067e-02f, -6.04822114e-02f, 1.07290059e-01f, 6.94948342e-03f, 6.02099337e-02f, 4.67522666e-02f, 4.66591828e-02f, 1.03668921e-01f,
  -8.04799944e-02f, -6.32456169e-02f, -3.57235700e-01f, -3.05005044e-01f, 6.45426437e-02f, 2.89117157e-01f, 8.72796699e-02f, -1.01332322e-01f, -2.88293153e-01f, 2.80858129e-01f,
  2.23653838e-01f, -2.52018273e-01f, 4.88450900e-02f, -9.75569636e-02f, -3.08772981e-01f, -1.50131658e-01f, 1.04216300e-01f, 1.27889767e-01f, -1.94715753e-01f, 1.28088951e-01f,
  -1.51661545e-01f, 8.73616263e-02f, -2.04227775e-01f, 1.51940823e-01f, 1.44548386e-01f, -5.59282070e-03f, 3.54296386e-01f, 1.09306581e-01f, 1.20596260e-01f, -1.32470846e-01f,
  9.27364081e-02f, -8.29337165e-02f, 4.47504856e-02f, -9.62805972e-02f, 1.38998494e-01f, 1.65537223e-01f, 1.16646066e-01f, -1.18510865e-01f, -1.29886016e-01f, -1.29494723e-02f,
  9.50032249e-02f, -1.61408663e-01f, -3.79069261e-02f, -1.11514956e-01f, -6.65316582e-02f, -5.22673391e-02f, -1.25350147e-01f, -1.64131764e-02f, -5.21349683e-02f, -4.42020670e-02f,
  -2.29073539e-02f, -6.40386790e-02f, -4.79177292e-03f, -1.47382673e-02f, -7.02808648e-02f, -4.99786772e-02f, 7.65098333e-02f, 8.42902288e-02f, -8.59222841e-04f, -4.87414934e-02f,
  1.22993030e-01f, 2.57748589e-02f, 4.14553620e-02f, -7.21803531e-02f, -1.70930438e-02f, 3.55193503e-02f, 1.17254639e-02f, -2.47022752e-02f, -1.68545414e-02f, 2.57197078e-02f,
  2.34921053e-02f, 1.14055602e-02f, -2.94010248e-02f, 9.00289565e-02f, 3.20125222e-02f, 4.51629050e-02f, 9.31199491e-02f, -2.85272039e-02f, 1.94622502e-02f, 4.74605039e-02f,
  1.31536252e-03f, 4.20212261e-02f, 7.78257623e-02f, 1.66813768e-02f, -4.97911237e-02f, -4.00203206e-02f, 3.48163806e-02f, -8.19265246e-02f, -8.06950331e-02f, 2.75848489e-02f,
  1.17040083e-01f, 1.87336490e-01f, -1.09419473e-01f, -1.06404833e-01f, 7.67609775e-02f, 1.54582113e-01f, 4.36714552e-02f, -5.00293449e-02f, -3.46879102e-02f, -4.21185093e-03f,
  1.18989542e-01f, -2.10168976e-02f, 1.58414766e-01f, -2.53859982e-02f, -7.43601024e-02f, 1.07189618e-01f, 7.90161639e-02f, -8.03267658e-02f, 7.90178478e-02f, 1.23332508e-01f,
  4.55235466e-02f, 5.53603992e-02f, -7.26277083e-02f, 8.28342438e-02f, 1.07804328e-01f, 1.18289448e-01f, 5.87929040e-02f, 9.97644477e-03f, 5.80261685e-02f, 6.66370690e-02f,
  7.35506266e-02f, 6.65059220e-03f, -2.07924455e-01f, -1.72625128e-02f, -9.66335461e-02f, 3.24558794e-01f, 2.32697129e-01f, -2.03591157e-02f, 1.75526157e-01f, 2.19441727e-01f,
  2.60786861e-02f, -7.56262615e-02f, -6.89791841e-03f, 1.27131119e-01f, -1.51938517e-02f, 2.34846711e-01f, 1.61742762e-01f, 7.26895258e-02f, 2.74892785e-02f, 3.21899652e-02f,
  -4.31186445e-02f, 6.60487711e-02f, -2.71918952e-01f, -9.30020772e-03f, -4.27153930e-02f, -8.60342458e-02f, -1.05643898e-01f, -2.10268587e-01f, -1.29010588e-01f, -1.98556796e-01f,
  8.13804716e-02f, 5.74185662e-02f, -2.96581443e-02f, 4.92987856e-02f, -3.04773189e-02f, 7.32583031e-02f, 5.09101637e-02f, -1.53239980e-01f, -1.37402087e-01f, 1.07981209e-02f,
  1.01943344e-01f, 4.40084084e-04f, 1.69550955e-01f, -2.84888204e-02f, -1.15874477e-01f, -8.18229914e-02f, -5.00811860e-02f, -6.60037249e-02f, -5.88538982e-02f, -8.99238512e-02f,
  -3.71331908e-02f, -8.64297897e-02f, 6.89198263e-03f, -2.85840295e-02f, -9.06506330e-02f, 2.67822538e-02f, 2.99834497e-02f, -1.31859750e-01f, 1.66979998e-01f, -2.27074474e-02f,
  -4.89406241e-03f, 1.14355043e-01f, 1.14668705e-01f, 9.05103832e-02f, 2.20052078e-02f, -7.53325447e-02f, -5.54332137e-02f, -7.29477033e-02f, 2.21792888e-02f, -9.37736928e-02f,
  1.17546268e-01f, -1.31181449e-01f, -1.03616536e-01f, 8.41738805e-02f, 6.27300292e-02f, -4.65827659e-02f, -1.31469727e-01f, -3.06331553e-02f, 9.15461108e-02f, -9.42671206e-03f,
  -1.22015914e-02f, 3.01016159e-02f, -5.85814416e-02f, 1.09720370e-02f, -1.41103575e-02f, -1.86389536e-01f, 3.15563977e-02f, 4.53257263e-02f, 2.35897377e-02f, 1.02198064e-01f,
  3.72501016e-02f, 9.16897506e-02f, 3.34495604e-02f, -5.00102118e-02f, 3.22124176e-02f, 1.44432902e-01f, 9.90563557e-02f, 9.96023715e-02f, -1.02874413e-01f, 7.28532374e-02f,
  8.45748410e-02f, 8.59307311e-03f, 1.65651560e-01f, -1.72900140e-01f, -1.37650296e-01f, 7.57680163e-02f, 1.32135615e-01f, 4.76822667e-02f, 5.36419339e-02f, 3.43937613e-02f,
  6.52981102e-02f, 1.09789178e-01f, 1.08052930e-03f, 9.08777341e-02f, -5.34010828e-02f, -7.35826194e-02f, 9.27983895e-02f, -1.40730187e-01f, 9.74664018e-02f, 5.52465431e-02f,
  1.12696044e-01f, 1.85036331e-01f, -1.33875757e-01f, -2.86097407e-01f, -2.38906235e-01f, 3.19278479e-01f, 1.53607875e-01f, -9.23418403e-02f, -2.84903884e-01f, 1.67926118e-01f,
  1.28835544e-01f, -1.52951345e-01f, 1.87699899e-01f, 1.69361159e-01f, 1.43882766e-01f, 3.34361583e-01f, 2.63000190e-01f, 1.13114744e-01f, 3.78339775e-02f, 1.79564282e-01f,
  -1.55472588e-02f, 2.43354097e-01f, 2.30386034e-01f, 2.35887736e-01f, 1.57600552e-01f, -2.07667127e-01f, -4.17887419e-02f, -1.22744434e-01f, 6.47028163e-02f, -4.04803734e-03f,
  5.91748431e-02f, 5.36158588e-03f, 1.16819954e-02f, 2.51611695e-04f, 1.70694947e-01f, -8.82640854e-03f, -5.21078072e-02f, 4.79781069e-02f, -1.48879483e-01f, -6.24043914e-03f,
  -9.45697799e-02f, -3.04569099e-02f, -1.63048115e-02f, -4.94257994e-02f, -7.63708055e-02f, -7.08247721e-02f, -4.91255242e-03f, -5.38832359e-02f, -9.87663567e-02f, 6.91315457e-02f,
  4.76230197e-02f, 3.86398435e-02f, -4.59923483e-02f, -1.16885565e-02f, -1.02062888e-01f, -1.34781227e-02f, -3.99463661e-02f, -1.40822381e-02f, -2.99500283e-02f, -3.41546014e-02f,
  2.68941768e-03f, 8.53101239e-02f, 5.89387640e-02f, 6.73082620e-02f, 2.18743328e-02f, 9.57874767e-03f, 2.60122176e-02f, -1.18955725e-03f, -6.40114397e-02f, 4.99453470e-02f,
  -2.96846386e-02f, -4.69531752e-02f, 2.09556404e-03f, 3.04172114e-02f, 3.81057933e-02f, -2.65907012e-02f, 5.27324416e-02f, 3.83726768e-02f, -4.99051958e-02f, -1.41399112e-02f,
  -1.30832940e-01f, 1.90586932e-02f, -8.13027397e-02f, -4.50171940e-02f, 5.24159856e-02f, -1.27042308e-01f, -5.35189919e-02f, -6.95037236e-03f, -4.47717309e-02f, -3.33649926e-02f,
  6.36768788e-02f, 6.92916363e-02f, 4.12350520e-02f, 1.02456696e-02f, 3.29933688e-02f, 1.83263391e-01f, 2.81003583e-02f, 6.18071556e-02f, 4.67265733e-02f, 3.76925990e-02f,
  -1.29913591e-04f, -1.59326252e-02f, 6.63536182e-03f, -8.39782283e-02f, -4.67489287e-02f, -5.50636463e-03f, 8.24549794e-02f, -4.67443131e-02f, -1.12293355e-01f, 1.29566222e-01f,
  1.30139384e-03f, -9.41389054e-03f, 3.65840420e-02f, -6.69601001e-03f, -8.48016813e-02f, -9.39382836e-02f, -6.27438398e-03f, -1.33001640e-01f, 5.64503521e-02f, -7.24734664e-02f,
  1.02737896e-01f, -6.57455847e-02f, -8.09986889e-02f, -3.63391601e-02f, -7.28506222e-02f, 1.88253038e-02f, -1.12623706e-01f, -2.70570014e-02f, -3.24371606e-01f, -1.11508153e-01f,
  -2.58740932e-02f, 1.00721620e-01f, -1.82162091e-01f, 1.66220963e-01f, 2.80606747e-01f, -1.82591900e-01f, 1.90755337e-01f, 4.04130220e-02f, -9.55197588e-02f, 1.42747983e-01f,
  3.41293029e-02f, 2.89971143e-01f, -1.29366489e-02f, 1.39861226e-01f, 1.83073282e-01f, 5.57415485e-02f, 3.10074776e-01f, -3.45603712e-02f, 1.61702380e-01f, 6.08978607e-02f,
  3.89669016e-02f, 2.38632914e-02f, -1.13810197e-01f, 4.72155809e-02f, -1.26929451e-02f, -1.74069628e-02f, 5.72935231e-02f, 1.39347002e-01f, 4.24865410e-02f, 1.98195372e-02f,
  1.22215077e-01f, 7.94726238e-02f, 1.37869760e-01f, -1.73460115e-02f, 1.37771621e-01f, -1.11970775e-01f, -1.90927200e-02f, -1.56996012e-01f, -6.76107481e-02f, 2.92574763e-02f,
  -7.67310560e-02f, 1.33998916e-01f, 6.46810830e-02f, -1.16240203e-01f, -2.13565510e-02f, -5.86466193e-02f, 7.70669952e-02f, -3.69391553e-02f, 7.86711648e-03f, -6.26848117e-02f,
  5.65728135e-02f, -1.00915423e-02f, 2.79187616e-02f, -5.41154072e-02f, -6.21891506e-02f, -8.67884457e-02f, 3.82519444e-03f, 5.61993830e-02f, -1.16405472e-01f, -6.08129427e-02f,
  -2.80700475e-02f, 5.10341078e-02f, -8.17377493e-02f, 1.34143028e-02f, 3.70773785e-02f, -7.73936063e-02f, 9.20899808e-02f, -2.98782587e-02f, -1.42339125e-01f, -4.16895784e-02f,
  -2.25992799e-02f, 9.81657356e-02f, -1.13199316e-01f, 5.68378754e-02f, 5.01946360e-02f, 2.36116033e-02f, -8.78418684e-02f, -4.11978774e-02f, -4.14333008e-02f, 7.64938593e-02f,
  5.52848950e-02f, 1.32763520e-01f, -4.72010598e-02f, -8.34582746e-02f, -1.10904805e-01f, 6.38800561e-02f, -5.93791045e-02f, 1.01706974e-01f, 4.18064781e-02f, 8.86441469e-02f,
  1.77316993e-01f, 8.53933990e-02f, 9.58959013e-02f, 2.79976148e-02f, 5.58640435e-02f, -6.58851489e-02f, -7.19402451e-03f, -1.38197601e-01f, -5.11809178e-02f, 1.53199151e-01f,
  7.28710145e-02f, -4.61661164e-03f, 3.61668020e-02f, -9.57626998e-02f, -3.36416736e-02f, -1.50748799e-02f, -8.82333238e-03f, -7.07057640e-02f, 1.42887533e-01f, -6.68033659e-02f,
  1.73631355e-01f, -3.98870081e-01f, 3.04821581e-01f, 1.66546106e-01f, 2.34278977e-01f, 1.71815783e-01f, 3.22137833e-01f, 1.15852766e-02f, -2.46350765e-02f, -3.49462032e-01f,
  -6.55375049e-02f, -7.95030873e-03f, -1.79582343e-01f, 1.47320656e-02f, 3.95833403e-01f, -3.43761444e-02f, 9.42794755e-02f, 8.03174078e-02f, -7.66134709e-02f, -9.87793356e-02f,
  4.60128635e-02f, -1.33183807e-01f, 1.18905492e-01f, -3.12383741e-01f, -7.82063697e-03f, -7.20839202e-02f, -1.09469727e-01f, 1.48666546e-01f, -7.53895426e-03f, 1.41522288e-01f,
  -1.03765763e-01f, -1.75483406e-01f, -1.50806814e-01f, -8.81656781e-02f, 5.24443400e-04f, -1.04361493e-02f, 1.05998211e-01f, 1.76557422e-01f, 1.00616239e-01f, 9.24398098e-03f,
  -7.13021457e-02f, 5.22379391e-02f, 5.01269400e-02f, -3.65135842e-03f, -7.95281827e-02f, -6.98694065e-02f, -3.58484946e-02f, -4.09558266e-02f, 3.59075889e-02f, 1.91358831e-02f,
  1.86995585e-02f, -8.41081962e-02f, 1.60855372e-02f, -1.26022324e-01f, 3.80534604e-02f, -2.03792807e-02f, 4.95556556e-03f, 1.33610219e-01f, -6.72505721e-02f, 1.67718437e-02f,
  -2.76292432e-02f, 2.38210279e-02f, -5.03845252e-02f, -6.75742254e-02f, -4.57540564e-02f, 2.32119765e-03f, -7.65132383e-02f, 4.52644564e-02f, -4.32993807e-02f, -6.16175681e-02f,
  -9.11000669e-02f, -1.91741120e-02f, -8.65456164e-02f, -9.68395248e-02f, -1.43076191e-02f, -2.55881529e-02f, 3.63884829e-02f, -1.32084088e-02f, 6.51350478e-03f, -3.91473658e-02f,
  -4.94337641e-03f, 3.00210938e-02f, -1.03789624e-02f, 1.26937717e-01f, 1.72820054e-02f, -4.20089774e-02f, -1.72789827e-01f, 3.23348902e-02f, -8.88033956e-02f, -9.81169380e-03f,
  -4.52883542e-01f, -2.13832945e-01f, -7.41598383e-02f, -1.03136614e-01f, -5.46922311e-02f, -9.81535986e-02f, 1.05245203e-01f, -1.11595057e-01f, -1.00107968e-01f, 4.28797267e-02f,
  -1.32576779e-01f, 1.97658800e-02f, -4.08597142e-02f, -3.44410874e-02f, -1.41738281e-01f, 2.65069380e-02f, -2.60798037e-02f, -9.38078165e-02f, 7.10249087e-03f, -9.86435339e-02f,
  -8.70526284e-02f, -1.80803903e-03f, 5.54015823e-02f, -1.35372460e-01f, -2.50971746e-02f, 1.37049761e-02f, 1.10240513e-02f, 3.30131091e-02f, 1.29900919e-02f, 6.63596094e-02f,
  3.87797773e-01f, -2.57458478e-01f, -1.03759430e-01f, 2.86281556e-01f, 2.44128585e-01f, 2.05511764e-01f, -6.75698891e-02f, 1.03303567e-01f, 9.17425677e-02f, -2.80557066e-01f,
  1.31100804e-01f, 3.26025747e-02f, -2.73578554e-01f, 1.96501106e-01f, 2.75606006e-01f, -2.98450083e-01f, 1.91194326e-01f, 4.25467975e-02f, -4.63192388e-02f, 1.28668442e-01f,
  1.50417566e-01f, 2.01760635e-01f, 1.94288567e-02f, 3.35098174e-03f, 1.35304868e-01f, 2.76710652e-03f, 5.65038733e-02f, -1.00735970e-01f, 1.81933075e-01f, -3.86805423e-02f,
  1.12668559e-01f, -4.72561233e-02f, 9.20109376e-02f, 2.01738570e-02f, -7.36079365e-02f, -3.10937315e-02f, 1.18855834e-02f, -7.16846511e-02f, 8.16281289e-02f, -1.77513361e-01f,
  -1.09489352e-01f, 2.55734492e-02f, -5.12494184e-02f, 6.78363219e-02f, 3.60696279e-02f, 5.71720414e-02f, -6.24221098e-03f, -1.34877022e-02f, -4.67271209e-02f, -2.58033779e-02f,
  7.68651813e-02f, 7.50207007e-02f, 1.36139229e-01f, 6.23510256e-02f, 8.04651752e-02f, 2.45259386e-02f, 2.24931296e-02f, -3.79731171e-02f, 3.35393623e-02f, 1.01838931e-01f,
  -5.07992357e-02f, -1.49167692e-02f, -9.81546864e-02f, 5.56803197e-02f, -1.32787768e-02f, 3.81756648e-02f, 6.42245710e-02f, 2.73199845e-02f, 1.08719254e-02f, 6.12152182e-02f,
  2.46221758e-02f, 5.36578149e-02f, 7.83357024e-02f, 1.15576670e-01f, -2.79431939e-02f, 6.02960326e-02f, 5.10216504e-02f, -3.78898531e-02f, -4.52124216e-02f, 7.26822317e-02f,
  -5.86679131e-02f, -2.04849150e-02f, 1.18465852e-02f, 3.57528105e-02f, -1.05464771e-01f, 7.36914799e-02f, -8.66911374e-03f, 1.85065549e-02f, 2.98801195e-02f, -1.78378318e-02f,
  2.74855923e-02f, -2.97414690e-01f, -2.80795339e-03f, -7.78016588e-03f, -1.44801304e-01f, 6.41232654e-02f, 3.91436256e-02f, -2.70899404e-02f, -2.00161580e-02f, 1.92247480e-02f,
  -7.86973070e-03f, -4.53826822e-02f, -1.15806669e-01f, 1.10248700e-01f, -2.61336975e-02f, -9.45132524e-02f, -1.51753828e-01f, 6.54911324e-02f, -8.37983117e-02f, 6.40648678e-02f,
  3.35776843e-02f, -4.61906791e-02f, -6.48160279e-02f, 1.20999917e-01f, 5.28397188e-02f, -1.84322037e-02f, 3.42693776e-02f, 3.30311507e-02f, -2.06868872e-02f, 1.20142475e-02f,
  -4.50407535e-01f, 1.63282692e-01f, 2.07658812e-01f, 2.17262790e-01f, -2.56710142e-01f, -9.59787443e-02f, 9.73907486e-02f, 1.56587530e-02f, -1.61544248e-01f, 1.24335423e-01f,
  1.58303052e-01f, -7.65992049e-03f, 3.10547799e-01f, 2.32422605e-01f, -1.38065293e-02f, 2.85025090e-01f, 1.60087556e-01f, 6.99929446e-02f, 4.88505932e-03f, 6.33012131e-02f,
  1.65384337e-01f, 4.86689135e-02f, 3.22495699e-01f, 2.31420975e-02f, 3.01442780e-02f, 1.60497129e-01f, 3.13446105e-01f, 1.43513113e-01f, 1.38803467e-01f, -1.00921378e-01f,
  -1.62116042e-03f, 1.52256116e-02f, -4.40829508e-02f, -8.56148526e-02f, 1.58685178e-01f, -3.89944320e-03f, 3.73688489e-02f, 5.95907271e-02f, 3.33671682e-02f, -3.39429565e-02f,
  -7.86051825e-02f, -6.36435747e-02f, 1.62091982e-02f, -1.40015274e-01f, -9.24178436e-02f, 3.87884751e-02f, 5.82086630e-02f, -7.04862103e-02f, 1.89726539e-02f, -1.33454740e-01f,
  4.21554744e-02f, 1.25874817e-01f, 1.11160681e-01f, 1.74067587e-01f, 7.90740326e-02f, 2.20151618e-02f, 3.40342782e-02f, 2.50641480e-02f, 9.49231815e-03f, -5.16498275e-02f,
  -1.05865955e-01f, 6.36282712e-02f, -4.37805541e-02f, 5.97768612e-02f, -1.86552238e-02f, 4.06303927e-02f, -2.05066111e-02f, -4.76188399e-02f, 2.37063393e-02f, 1.87698826e-02f,
  2.25321688e-02f, 3.05694006e-02f, -6.34491891e-02f, -6.15349226e-02f, -4.73385639e-02f, -7.37422854e-02f, -5.94273694e-02f, -6.27739653e-02f, 3.12069971e-02f, -2.14257501e-02f,
  1.06881941e-02f, -4.91577275e-02f, 3.92391607e-02f, 4.12073359e-03f, -8.60374570e-02f, 6.43576384e-02f, 1.26182050e-01f, -3.45024318e-02f, 8.45695511e-02f, 8.70633721e-02f,
  1.40764207e-01f, 2.60810375e-01f, 5.93222156e-02f, -8.43814239e-02f, 9.63606983e-02f, -4.84076403e-02f, 8.65058750e-02f, -1.12982392e-02f, 3.22135426e-02f, 8.92698765e-02f,
  6.68784901e-02f, 4.91528511e-02f, 2.36597732e-02f, -1.17512643e-01f, 8.19235519e-02f, 3.22521962e-02f, 1.10127330e-01f, 5.77208027e-02f, 2.95580197e-02f, 5.74690066e-02f,
  1.32695764e-01f, -5.10863541e-03f, -1.14596479e-01f, -6.12650327e-02f, -7.62902573e-02f, 5.99338152e-02f, -1.18288197e-01f, 7.47102052e-02f, -9.73801594e-03f, 1.30505502e-01f,
  -3.36932123e-01f, 2.97684282e-01f, -8.79977718e-02f, -3.16452384e-01f, 2.31343850e-01f, -1.62266955e-01f, -2.03513782e-02f, 2.30210289e-01f, -1.59687847e-01f, 2.40779504e-01f,
  -1.54285297e-01f, -2.06036076e-01f, 2.00737134e-01f, -2.44114950e-01f, -3.83719325e-01f, -2.12634251e-01f, -2.72782564e-01f, -2.81100363e-01f, 6.91691600e-03f, -1.03238799e-01f,
  -5.10662533e-02f, -7.83604831e-02f, -1.04602449e-01f, 3.55344206e-01f, 1.02213755e-01f, 1.65001079e-01f, 7.21497759e-02f, 3.23307276e-01f, -5.99164665e-02f, -5.27333356e-02f,
  -1.87214941e-01f, -7.34396726e-02f, 3.78027596e-02f, 5.13146957e-03f, -2.40452532e-02f, 6.84210956e-02f, 4.33998927e-02f, -3.42479385e-02f, -4.76876907e-02f, -1.58930838e-01f,
  -6.89019188e-02f, -2.53941920e-02f, -7.01747760e-02f, -3.13110687e-02f, 1.55757312e-02f, 2.80761756e-02f, -6.22218102e-02f, -3.32822688e-02f, -8.56738631e-03f, -1.06355004e-01f,
  -2.60081720e-02f, 2.11171880e-02f, 2.49837735e-03f, -5.61195873e-02f, -2.44407123e-03f, 4.56575975e-02f, -1.35477027e-03f, -1.18555594e-02f, -5.45845479e-02f, -1.26226395e-01f,
  -3.35184038e-02f, 5.54238120e-03f, 6.37122765e-02f, -1.32450238e-02f, -1.11767620e-01f, 8.83539617e-02f, -4.96595502e-02f, -1.61036453e-03f, 4.93786894e-02f, -1.75841041e-02f,
  3.21194939e-02f, -1.00473627e-01f, -2.76704915e-02f, 1.75235849e-02f, -4.77379151e-02f, 5.38875312e-02f, 2.24999096e-02f, -2.32610963e-02f, -4.28871699e-02f, -8.91294554e-02f,
  -4.24976647e-02f, -7.15286192e-03f, -5.14134541e-02f, 8.01947936e-02f, 2.14963444e-02f, 1.00071616e-02f, 1.00993849e-01f, -8.23112875e-02f, -3.21697704e-02f, 1.26811013e-01f,
  -7.39334598e-02f, 1.54407844e-01f, 2.71398704e-02f, -2.28536800e-02f, -1.10857263e-01f, -3.09667457e-02f, -7.06659406e-02f, 5.22066429e-02f, -4.31065075e-03f, 2.72726696e-02f,
  1.59150496e-01f, 7.34276846e-02f, 7.09884241e-02f, -4.64013666e-02f, -8.95084348e-03f, -7.53987953e-02f, -5.77837648e-03f, -3.79064493e-02f, 1.08591206e-01f, -1.70628857e-02f,
  6.85532540e-02f, 2.17066277e-02f, 8.80888104e-02f, 1.07756458e-01f, 4.53280993e-02f, 1.14563918e-02f, 5.12073375e-02f, -9.59152076e-03f, 5.14400564e-02f, -3.79818641e-02f,
  -3.51852737e-02f, 1.13982081e-01f, -7.73439109e-02f, -3.31203699e-01f, 2.65359074e-01f, 2.64197499e-01f, -2.88871825e-01f, 1.22440971e-01f, -3.35701346e-01f, -1.44102683e-04f,
  4.96211313e-02f, -3.15125555e-01f, -1.67464912e-02f, -1.98883563e-01f, 5.66223152e-02f, 1.97314575e-01f, -1.21732838e-01f, -2.88751602e-01f, -1.62481889e-01f, -2.49163762e-01f,
  -1.63775370e-01f, -8.12221766e-02f, 3.23313810e-02f, 2.06337884e-01f, -1.24868311e-01f, -1.91469312e-01f, -9.28341672e-02f, 7.10742399e-02f, -1.58517346e-01f, 2.63206717e-02f,
  -1.54534644e-02f, 1.24287687e-01f, 6.77026510e-02f, 5.51875979e-02f, 1.13250598e-01f, 9.69609767e-02f, -5.08931577e-02f, 4.78180945e-02f, 3.99676524e-03f, -3.94963771e-02f,
  -1.71742290e-01f, -1.94229558e-02f, -1.53910639e-02f, 4.87518013e-02f, -3.39776799e-02f, 1.44082196e-02f, -7.03596324e-02f, -1.66438166e-02f, -6.50488883e-02f, 1.12733385e-02f,
  1.17951427e-02f, 4.25308906e-02f, 8.90362775e-04f, -1.29294753e-01f, 4.50737029e-03f, -4.04216796e-02f, 3.78004611e-02f, -5.88152707e-02f, 8.40759873e-02f, 8.37726295e-02f,
  1.43917734e-02f, -2.27402337e-02f, 1.08094737e-01f, -7.48637691e-02f, 8.80584642e-02f, 1.51759051e-02f, -1.22346587e-01f, 9.82837752e-02f, -5.14046289e-02f, 1.30922765e-01f,
  -5.98695129e-02f, -1.19388126e-01f, 1.45959929e-02f, -1.66581735e-01f, -7.50602335e-02f, 4.42318805e-02f, 3.50539722e-02f, 2.81715002e-02f, -2.12238923e-01f, -1.06965333e-01f,
  -1.51616395e-01f, -4.80297115e-03f, 4.85832542e-02f, -3.25551606e-03f, 9.97530483e-03f, 3.99392135e-02f, 3.68953161e-02f, 1.33654699e-01f, 1.56440601e-01f, -5.35414368e-03f,
  1.00968629e-01f, -1.47434864e-02f, 6.94337115e-02f, -3.24541591e-02f, -1.31561561e-03f, 2.13508740e-01f, 4.63491902e-02f, 1.34528838e-02f, 6.86250180e-02f, 1.10043064e-01f,
  -2.60794163e-02f, -1.36901692e-01f, 1.30069256e-01f, -1.37643412e-01f, -1.74204946e-01f, 1.59624428e-01f, -1.68407559e-01f, -1.41229189e-03f, -1.14280522e-01f, 1.31601065e-01f,
  2.58249994e-02f, -8.13232327e-04f, -8.90596285e-02f, -2.13536695e-02f, -1.81801498e-01f, 2.29196390e-03f, 9.93504152e-02f, -1.24264993e-01f, -1.02308812e-02f, -8.50939006e-02f,
  -2.28302151e-01f, 3.10605794e-01f, -2.94998378e-01f, 1.13691101e-02f, -7.79013559e-02f, 3.95597219e-01f, 2.80898035e-01f, -1.49405897e-01f, 9.37926304e-03f, 3.13675314e-01f,
  1.58496946e-01f, -1.07267827e-01f, -7.31852427e-02f, 2.83091873e-01f, 1.48117304e-01f, 2.59631097e-01f, 3.00873995e-01f, 1.98945180e-01f, -9.05536339e-02f, -1.02452099e-01f,
  -9.55506563e-02f, 3.22151393e-01f, 2.74576098e-02f, -9.14636254e-03f, 8.52286592e-02f, -2.26794660e-01f, 7.17540085e-02f, -2.90234864e-01f, 2.34057516e-01f, 1.95796639e-01f,
  1.22168601e-01f, -5.87592553e-03f, -1.29243731e-01f, -1.39980987e-01f, 2.11946201e-02f, -6.86839893e-02f, -2.01626457e-02f, -3.43002826e-02f, -1.49329022e-01f, -9.32604894e-02f,
  2.41516121e-02f, -6.28779903e-02f, 5.65123260e-02f, -6.32204935e-02f, -8.87784548e-03f, 1.29175605e-02f, -5.50518930e-02f, -1.26429042e-02f, 5.89811169e-02f, -5.68450615e-02f,
  -4.98336479e-02f, 5.24863712e-02f, 5.46349175e-02f, 1.32441372e-01f, -7.62739182e-02f, -1.77444480e-02f, 1.81678366e-02f, 1.44509075e-03f, 1.48448601e-01f, 8.06911364e-02f,
  4.63127680e-02f, 4.45705205e-02f, 4.25208248e-02f, -2.80729514e-02f, 7.32105896e-02f, 9.61330459e-02f, 3.37230712e-02f, 4.02466543e-02f, -2.01922040e-02f, 5.93782514e-02f,
  -7.22928271e-02f, -4.24394906e-02f, 7.49127492e-02f, -1.39189065e-02f, 3.13016884e-02f, 6.09627105e-02f, -6.56546652e-02f, 2.94748284e-02f, -6.60175160e-02f, 1.23510789e-02f,
  -2.71489788e-02f, -1.37428595e-02f, 2.10078061e-02f, 3.79675739e-02f, 9.82304588e-02f, 9.91707481e-03f, 7.46116266e-02f, -9.29318275e-03f, -2.98562180e-02f, -5.66708948e-03f,
  1.88900888e-01f, 1.01036012e-01f, -7.25986436e-02f, -2.43421756e-02f, 6.30396381e-02f, 5.66999353e-02f, 2.89282333e-02f, 5.32973260e-02f, -8.76349211e-03f, 5.12173623e-02f,
  -7.84910917e-02f, 2.35475935e-02f, -1.39826033e-02f, -8.12177174e-03f, 8.72993544e-02f, 9.69084948e-02f, 5.41458931e-03f, -3.07082152e-03f, 4.09082174e-02f, 2.79235970e-02f,
  8.22076946e-02f, 1.13709318e-02f, -4.34278883e-02f, 4.20755707e-02f, 8.73282775e-02f, 9.08505544e-02f, 1.02747552e-01f, -1.53273195e-01f, -3.34241278e-02f, 8.34753662e-02f,
  -7.91173130e-02f, -1.31776258e-01f, -3.24103445e-01f, 4.78923740e-03f, 2.03557640e-01f, 6.57672063e-02f, 8.79372563e-03f, -3.55715379e-02f, -2.85174668e-01f, 1.64377257e-01f,
  2.02341214e-01f, -1.87366500e-01f, -3.83332670e-02f, 6.89845011e-02f, 1.02201350e-01f, -2.53379017e-01f, 7.11998343e-02f, 1.01732850e-01f, -1.83140993e-01f, 6.30586222e-02f,
  -2.42922921e-02f, 2.02364877e-01f, 3.94063331e-02f, 6.40601963e-02f, 6.90876171e-02f, -5.57752550e-02f, 2.73436725e-01f, 7.06998557e-02f, 2.71272629e-01f, 1.07506737e-01f,
  -4.56875563e-02f, -4.90051098e-02f, 1.12874778e-02f, -3.32813332e-04f, 1.80980489e-02f, 3.92515445e-03f, 1.09943608e-02f, 4.72259820e-02f, -3.34139504e-02f, -5.93030006e-02f,
  1.87522103e-03f, 4.31816466e-02f, -8.11299607e-02f, -6.00589029e-02f, -5.17762490e-02f, 1.57981571e-02f, -9.57869738e-02f, 9.56343338e-02f, -7.99780935e-02f, -5.38148172e-03f,
  -1.45751789e-01f, 4.20592390e-02f, 3.76122743e-02f, -5.24836145e-02f, -1.16526872e-01f, -4.16790247e-02f, -6.06201030e-02f, 2.46116165e-02f, -1.25942286e-02f, -1.11696266e-01f,
  -2.09979154e-02f, 2.39112601e-02f, -1.37946934e-01f, -1.31688103e-01f, 1.30371973e-02f, -4.22108220e-03f, -8.22875872e-02f, 1.13616958e-01f, -8.72316808e-02f, 5.19393720e-02f,
  -1.36389537e-02f, -1.05675325e-01f, 5.87390624e-02f, -2.73418892e-02f, -6.79991320e-02f, -6.04380891e-02f, -3.60564962e-02f, -3.32292495e-03f, 5.48441075e-02f, -3.44449617e-02f,
  -7.90342875e-03f, 3.99555638e-02f, 3.75970192e-02f, 8.45202878e-02f, 1.99894141e-02f, 9.52072367e-02f, 7.16597661e-02f, -4.56407443e-02f, -1.33757631e-03f, -1.30060995e-02f,
  -1.56667344e-02f, 6.68840259e-02f, -5.45203947e-02f, -7.03466237e-02f, 6.45853505e-02f, 2.84337979e-02f, -5.75334616e-02f, -9.68618020e-02f, 1.33415684e-01f, -2.22227611e-02f,
  1.47078827e-01f, 2.95250490e-02f, 1.10018879e-01f, 1.13087855e-01f, -4.56421124e-03f, 6.62973598e-02f, 7.22288340e-02f, 1.25131741e-01f, 7.70124793e-02f, 1.28571391e-01f,
  1.10552080e-01f, 3.48115228e-02f, -6.19391985e-02f, -3.55356894e-02f, 9.90390629e-02f, 8.31418037e-02f, 3.59317400e-02f, -5.74195907e-02f, 7.86408186e-02f, -4.49897759e-02f,
  9.90093425e-02f, -4.06809449e-01f, 1.77480072e-01f, 1.37900755e-01f, 2.99320638e-01f, 2.12566763e-01f, 3.01063299e-01f, -1.88051939e-01f, -2.14458644e-01f, -2.53101289e-01f,
  1.02710545e-01f, 9.49900374e-02f, 1.32352307e-01f, -8.23222995e-02f, 3.94581199e-01f, -7.40982220e-02f, -1.39239386e-01f, -8.71173888e-02f, 9.39622670e-02f, -5.72439693e-02f,
  2.72581121e-03f, -8.73236433e-02f, 1.40928581e-01f, -2.76940435e-01f, -4.17514555e-02f, -1.81922033e-01f, -8.95450115e-02f, 1.92485511e-01f, -1.53301552e-01f, 1.55791417e-01f,
  -1.39145270e-01f, -5.30110858e-02f, 1.40065804e-01f, -2.24924274e-02f, 1.77644826e-02f, 9.43165943e-02f, 5.87000959e-02f, 1.28135815e-01f, 1.66424394e-01f, -6.98050037e-02f,
  6.05413355e-02f, 2.30565127e-02f, -1.39013603e-01f, 4.39598337e-02f, -6.04497902e-02f, 7.33153522e-02f, -4.77460138e-02f, 2.53866557e-02f, 2.97660492e-02f, 1.62462860e-01f,
  7.46975616e-02f, -2.62556057e-02f, 9.40696150e-02f, -3.87960710e-02f, 9.56559330e-02f, -8.05899948e-02f, -7.29480432e-03f, 1.28038406e-01f, -2.93736532e-02f, 3.79151590e-02f,
  3.39384899e-02f, 4.78167646e-02f, 8.85850340e-02f, -6.84856623e-02f, 1.28445709e-02f, -7.48347165e-03f, 2.53472123e-02f, -1.35529712e-02f, -3.29610892e-02f, 3.21755633e-02f,
  -2.45760698e-02f, -4.43285368e-02f, 5.23277856e-02f, 3.47025867e-04f, 1.25389537e-02f, -2.18563434e-02f, 7.58172348e-02f, -1.33418478e-03f, 8.62308033e-03f, -4.64659482e-02f,
  -7.77374357e-02f, 2.56279502e-02f, 9.43412706e-02f, 1.95761360e-02f, 1.09133460e-02f, -6.39963057e-03f, -6.52743950e-02f, -7.87531305e-03f, 7.86075667e-02f, 3.85623127e-02f,
  -2.79518634e-01f, -3.32439572e-01f, -1.55584365e-01f, -8.35351348e-02f, -4.08661440e-02f, 3.76662463e-02f, -7.80229568e-02f, -2.16044169e-02f, 2.20073760e-03f, -3.98862138e-02f,
  -4.36265282e-02f, -1.16714351e-02f, -5.55212125e-02f, -9.20291692e-02f, -3.94410565e-02f, -6.22656904e-02f, 5.72963711e-03f, -1.81700271e-02f, -6.85844920e-04f, -6.98078647e-02f,
  -6.14148341e-02f, -6.99827895e-02f, -2.63222400e-02f, 1.01734381e-02f, -1.54251695e-01f, 5.84238730e-02f, 4.80091851e-03f, -1.09353382e-02f, 4.93057743e-02f, 5.59573881e-02f,
  4.46693227e-02f, -2.28173323e-02f, -1.69261917e-01f, -4.62977141e-02f, 6.07601646e-03f, -2.28676364e-01f, -2.65341848e-01f, 1.00816295e-01f, -2.32410640e-01f, -6.02704240e-03f,
  8.78083706e-02f, -1.80656493e-01f, -9.38595831e-02f, -5.30868769e-02f, 8.17681998e-02f, -3.01415384e-01f, 6.44896179e-02f, -3.67235132e-02f, -6.08988926e-02f, 2.02384010e-01f,
  1.22089617e-01f, 2.17928916e-01f, -3.05442065e-02f, 2.55972054e-02f, -4.30267751e-02f, 1.06080435e-01f, 2.94665337e-01f, -9.78252068e-02f, 1.78420901e-01f, -4.64286134e-02f,
  -2.68724635e-02f, -4.17990014e-02f, -9.73496679e-03f, -1.66716054e-01f, 1.28690928e-01f, 7.40302131e-02f, 7.34216645e-02f, -2.58358605e-02f, 1.83934793e-02f, 7.93026462e-02f,
  6.74198791e-02f, -1.73309352e-02f, 8.73113871e-02f, -8.08099657e-02f, -5.89449033e-02f, -6.05771728e-02f, -2.80240439e-02f, -9.00321826e-02f, -5.76856583e-02f, -3.68358828e-02f,
  5.61863035e-02f, 9.57489107e-03f, 4.08267900e-02f, 3.37582044e-02f, 1.10358171e-01f, 4.53343913e-02f, 1.37126492e-02f, 7.11491928e-02f, 5.71460230e-03f, 5.79010397e-02f,
  1.48437202e-01f, -9.13423523e-02f, 1.71772502e-02f, -3.21371555e-02f, 5.23978807e-02f, -6.65412191e-03f, -8.41341391e-02f, -1.26666436e-02f, -5.53506538e-02f, -1.94902644e-02f,
  -2.60656755e-02f, 7.22944513e-02f, -5.14161438e-02f, 3.30985673e-02f, 1.45218313e-01f, -8.88533890e-02f, -1.88725349e-02f, 9.88586619e-02f, -2.87611000e-02f, -3.81595455e-02f,
  -1.28736317e-01f, 1.52858999e-03f, -6.99164439e-03f, -4.27251309e-02f, -3.36486921e-02f, 2.68099084e-02f, -1.14644167e-03f, 2.30531879e-02f, 4.80056331e-02f, -1.37162879e-01f,
  9.22994539e-02f, 2.13020757e-01f, -1.22946613e-01f, -9.94768441e-02f, -3.28405052e-02f, 8.03052261e-02f, -1.02840357e-01f, 1.88154373e-02f, 1.04101799e-01f, -2.41954233e-02f,
  1.62834466e-01f, 8.30117241e-03f, -6.36954382e-02f, 1.01333253e-01f, -7.40213273e-03f, -2.61703832e-03f, -1.16141641e-03f, 2.72829216e-02f, 1.01642489e-01f, 8.64775106e-02f,
  1.38352334e-01f, 4.50984426e-02f, 4.84984256e-02f, -3.80436401e-03f, 1.37638599e-01f, 8.21912959e-02f, 6.16864190e-02f, 4.34292890e-02f, -1.43507989e-02f, 5.88398427e-02f,
  -2.77728558e-01f, -2.33192712e-01f, -9.22774822e-02f, 2.61858222e-03f, -3.99038233e-02f, -2.84671605e-01f, -4.38613892e-01f, -5.35716787e-02f, -1.59706637e-01f, -2.52891213e-01f,
  -7.55077824e-02f, 1.28570348e-01f, -3.28270406e-01f, 1.72929898e-01f, 1.44633442e-01f, -1.80459544e-01f, 3.30360502e-01f, 2.64933288e-01f, 1.32452086e-01f, 3.48999240e-02f,
  2.16062665e-01f, 2.95685858e-01f, 1.80610850e-01f, 1.37588665e-01f, 1.22918338e-01f, 1.61731154e-01f, 1.76536292e-01f, -4.45021391e-02f, 3.67819160e-01f, 1.98197275e-01f,
  -2.06086665e-01f, -1.02063641e-01f, -7.99678080e-03f, -2.13794243e-02f, -5.33696674e-02f, -2.94535104e-02f, -6.60037845e-02f, 4.30463031e-02f, -1.21942693e-02f, 4.46332730e-02f,
  -1.25925824e-01f, 5.77248931e-02f, 1.87806338e-01f, 1.61131732e-02f, -1.08133018e-01f, 1.31215975e-01f, -4.99225315e-03f, -6.78064972e-02f, 1.83649492e-02f, -8.95835310e-02f,
  -6.59741759e-02f, 7.49587268e-02f, -2.01840345e-02f, 4.86060865e-02f, 8.16392805e-03f, -2.65877862e-02f, 8.74391571e-02f, 1.05513558e-02f, 7.68493712e-02f, 4.39745076e-02f,
  7.83231780e-02f, -5.26269563e-02f, -4.83289920e-02f, -1.23272780e-02f, -4.58470471e-02f, 4.73694615e-02f, -3.94537598e-02f, 7.83390701e-02f, 4.64414917e-02f, -1.31939366e-01f,
  -9.59455408e-03f, 1.82509106e-02f, 1.16676256e-01f, -1.43189117e-01f, -4.45436276e-02f, 8.19870904e-02f, 1.49484584e-02f, 8.60428903e-03f, -6.23249775e-03f, 4.19360735e-02f,
  -6.71459362e-02f, -4.93441820e-02f, -5.00110239e-02f, -9.46431700e-03f, 2.25475617e-02f, -1.40433744e-01f, -3.80201899e-02f, -5.44052711e-03f, -2.42721532e-02f, -6.36047423e-02f,
  -3.66104364e-01f, -1.04271889e-01f, -7.74396807e-02f, 1.45634180e-02f, 7.30520114e-03f, 4.83690482e-03f, -1.93667859e-02f, 1.36465365e-02f, -6.47413060e-02f, -1.03131540e-01f,
  -6.37221932e-02f, 6.07279837e-02f, -5.19633852e-02f, -2.15402506e-02f, 4.01235148e-02f, -1.99561521e-01f, -1.13448165e-02f, -7.91157335e-02f, -2.18173098e-02f, 1.26666248e-01f,
  -1.37959551e-02f, 3.08593567e-02f, 1.05202101e-01f, 7.74357617e-02f, -1.69977546e-02f, -9.81091708e-02f, 5.28458543e-02f, -1.24691958e-02f, 9.33213010e-02f, -6.11220002e-02f,
  3.80972683e-01f, 1.74174756e-01f, 2.00955510e-01f, 2.95135707e-01f, 1.56017929e-01f, 1.79446384e-01f, 2.06005052e-01f, 1.62856817e-01f, 5.01073480e-01f, -8.26656967e-02f,
  -1.75687313e-01f, 1.40374929e-01f, -3.05145621e-01f, -2.80740415e-03f, 8.89243409e-02f, -9.40674320e-02f, 3.79186779e-01f, 3.35071385e-02f, 2.68849909e-01f, 1.73992634e-01f,
  2.54429519e-01f, -1.28175393e-01f, -3.45388263e-01f, -1.24905720e-01f, -4.32711691e-02f, 8.76227096e-02f, -4.01309669e-01f, -2.15104938e-01f, -3.45760465e-01f, -6.60350248e-02f,
  -3.22407600e-03f, 1.33577183e-01f, -6.91483542e-02f, -1.03807881e-01f, 1.07976720e-01f, -1.42420501e-01f, -4.01035435e-02f, -9.50685740e-02f, 5.58699248e-03f, 3.24871466e-02f,
  8.67845491e-02f, -6.40737563e-02f, -3.00138304e-03f, -1.72389492e-01f, 1.42641649e-01f, -3.69519554e-02f, 4.32044566e-02f, 5.02788760e-02f, 4.46704309e-03f, 2.65779831e-02f,
  1.51051238e-01f, 6.27995580e-02f, 1.32214770e-01f, -1.34613723e-01f, 5.57043739e-02f, -2.53494456e-02f, -6.76806495e-02f, -7.87169486e-02f, -1.54880926e-01f, 1.64065063e-01f,
  -1.02132298e-02f, 6.32466227e-02f, -7.02943504e-02f, -3.00124846e-02f, 2.68725269e-02f, 7.96103571e-03f, -7.66049549e-02f, -1.37498438e-01f, 1.20102674e-01f, 1.28720198e-02f,
  5.14116557e-03f, -7.11041912e-02f, 8.34547058e-02f, -9.57879648e-02f, 1.40445933e-01f, 1.03325181e-01f, -5.84760495e-02f, -5.50245009e-02f, 6.94389790e-02f, 6.41954422e-04f,
  3.76705043e-02f, 1.58441756e-02f, -1.07928179e-01f, 4.21642821e-04f, -3.15364525e-02f, -3.00603621e-02f, -4.24919054e-02f, 1.02494843e-01f, -4.00052890e-02f, -1.07714228e-01f,
  4.19298150e-02f, 1.83933482e-01f, 4.93616723e-02f, -7.36626610e-03f, 6.95675835e-02f, -2.80589890e-02f, 9.21333283e-02f, 3.51792537e-02f, 5.35328239e-02f, 1.36163495e-02f,
  9.94758978e-02f, 4.11666706e-02f, 3.37749161e-02f, -1.17257483e-01f, 1.70016848e-02f, -3.08260061e-02f, -5.44029288e-02f, 6.86492771e-02f, 7.73202702e-02f, -2.71665603e-02f,
  1.08122434e-02f, 5.99316470e-02f, 4.53115962e-02f, 7.81682506e-02f, 6.23280220e-02f, -1.25406101e-01f, 1.64399855e-02f, -9.64967906e-02f, 7.92306289e-03f, -1.94031391e-02f,
  -6.16926193e-01f, 2.68078744e-01f, -1.84199587e-02f, -3.70783001e-01f, 6.70613274e-02f, -2.14383215e-01f, -2.60187268e-01f, 3.27803157e-02f, -5.62760308e-02f, 2.44170308e-01f,
  2.52178730e-03f, 1.48498401e-01f, 2.53944606e-01f, -4.81222011e-02f, -1.60869732e-01f, 1.71976283e-01f, -1.85911581e-01f, -7.73255080e-02f, 2.60208566e-02f, -1.79793984e-01f,
  -7.13802576e-02f, 8.76806956e-03f, -1.01660676e-01f, 2.11924762e-01f, -9.18625966e-02f, -2.72285268e-02f, -1.87954366e-01f, 1.82006195e-01f, -7.73695335e-02f, -4.81735170e-02f,
  -3.94064337e-01f, -7.12605491e-02f, -1.58890143e-01f, -6.40230402e-02f, -2.20450863e-01f, -1.87462177e-02f, -1.99460551e-01f, -9.32390336e-03f, -1.00188106e-01f, 2.50108391e-02f,
  7.93598667e-02f, 1.28607348e-01f, -3.74589786e-02f, 7.41441250e-02f, -2.16975398e-02f, 2.66004493e-03f, 4.77625355e-02f, -1.03291102e-01f, 1.95991751e-02f, 4.13088277e-02f,
  1.46572307e-01f, 2.30004173e-02f, -1.50183514e-01f, -2.32195063e-03f, -9.15763974e-02f, -9.09672081e-02f, -6.97471797e-02f, -3.54423039e-02f, -1.46112546e-01f, -1.22984253e-01f,
  8.15556273e-02f, -7.75078163e-02f, -1.14633422e-02f, -3.48960310e-02f, 2.92086694e-02f, 5.60799651e-02f, 9.73127782e-03f, 4.76316549e-02f, -2.87550353e-02f, -6.83199987e-02f,
  -1.13198692e-02f, -7.42429122e-02f, -3.95927718e-03f, -1.13717519e-01f, -3.71619649e-02f, -6.18613735e-02f, 1.69585589e-02f, -4.88839895e-02f, -6.26000613e-02f, -7.01407567e-02f,
  1.70605313e-02f, -1.29537052e-02f, 1.51665419e-01f, -1.19808152e-01f, -2.63594221e-02f, 1.35211684e-02f, 1.77080312e-03f, 7.17411488e-02f, 4.19998839e-02f, -8.12449977e-02f,
  -5.00443101e-01f, -2.98361361e-01f, -1.33426011e-01f, -4.89691310e-02f, 3.63859758e-02f, -1.48179203e-01f, -6.82480037e-02f, -1.08956948e-01f, -1.61675662e-01f, 5.44294827e-02f,
  -1.08805306e-01f, -4.40638177e-02f, -6.71138465e-02f, -2.67311987e-02f, 4.15719822e-02f, -1.53670132e-01f, -1.09999798e-01f, -3.78681882e-03f, -7.18100369e-02f, -9.90972668e-02f,
  -3.43747996e-02f, -7.24562705e-02f, 3.83606628e-02f, -5.38780130e-02f, -1.06747821e-02f, -8.17966182e-03f, -1.24350540e-01f, -2.60171201e-02f, -9.93786231e-02f, 1.26937497e-02f,
  1.92632392e-01f, 5.87813742e-02f, -9.25971791e-02f, -1.45977214e-02f, -3.91620427e-01f, -2.42437005e-01f, -2.14731485e-01f, -1.87542856e-01f, 1.31683037e-01f, 3.01741868e-01f,
  -2.59508193e-01f, 2.01862827e-01f, 1.84583500e-01f, -2.46893272e-01f, 1.24115059e-02f, 2.23802164e-01f, -1.37294620e-01f, -1.09616250e-01f, 1.25935150e-03f, 4.91073169e-02f,
  -7.18021318e-02f, -1.21776283e-01f, -7.36093670e-02f, -5.57128526e-02f, -2.87722439e-01f, -6.03541620e-02f, -8.87096152e-02f, -1.68256685e-01f, -1.09040216e-01f, -4.52954546e-02f,
  -1.50528448e-02f, 2.15728924e-01f, 3.67565192e-02f, 1.40188590e-01f, -8.20295066e-02f, -6.20222203e-02f, -9.20989588e-02f, 5.30849397e-03f, 2.08851472e-02f, -1.82365272e-02f,
  1.48006991e-01f, 1.43474013e-01f, 4.85471003e-02f, 6.78164586e-02f, -7.97121301e-02f, 6.89809397e-02f, 1.80347729e-02f, -1.19164087e-01f, -3.45511083e-03f, -2.18232907e-02f,
  1.02445530e-02f, -1.04541466e-01f, -5.29672801e-02f, 1.17800288e-01f, 5.74064208e-03f, 2.42730742e-03f, 1.20775893e-01f, -6.63392320e-02f, 2.35652197e-02f, -3.19224969e-02f,
  9.36148763e-02f, -5.11799380e-02f, 2.34645000e-03f, -1.01455197e-01f, -1.34354904e-02f, -5.16783409e-02f, 8.07917342e-02f, 5.80436876e-03f, -3.90160792e-02f, -3.44678313e-02f,
  -4.34207618e-02f, -3.51326540e-02f, -1.64137706e-02f, -6.21187463e-02f, 1.54134212e-02f, 3.08091920e-02f, -1.55889534e-03f, 1.64551228e-01f, -1.30604962e-02f, -8.75510648e-02f,
  4.76052389e-02f, 1.02198884e-01f, 6.54165298e-02f, -6.97842687e-02f, -7.31523633e-02f, 5.85116330e-04f, -2.13218518e-02f, 7.94989336e-03f, -1.02056600e-01f, -1.45556897e-01f,
  -8.17728564e-02f, 2.46502221e-01f, 1.32327095e-01f, 5.09601533e-02f, -4.09123674e-03f, 7.92201832e-02f, -3.15163694e-02f, 7.42371753e-02f, 4.29725014e-02f, 1.79221164e-02f,
  9.36467797e-02f, 4.41947579e-02f, -1.21434731e-02f, -5.14662564e-02f, 8.47436190e-02f, -5.38019426e-02f, -3.64790857e-02f, 2.67950725e-02f, 1.74654946e-02f, 4.70456332e-02f,
  -3.42881749e-03f, 1.24546967e-01f, 2.07957476e-01f, 9.16781202e-02f, 2.75441799e-02f, 7.42082745e-02f, -7.83029497e-02f, 4.02514786e-02f, -3.47924680e-02f, -1.15027279e-01f,
  2.78737545e-01f, -2.24002734e-01f, -1.22716390e-01f, 2.68996954e-01f, 2.52436191e-01f, -5.02862297e-02f, 1.40605003e-01f, 1.87047780e-01f, 1.11641720e-01f, -4.71289493e-02f,
  8.24656859e-02f, -1.51797393e-02f, -1.39577702e-01f, -9.74276755e-03f, 1.43047974e-01f, -2.18992487e-01f, 2.99764037e-01f, -7.26377070e-02f, 2.77616475e-02f, 1.67109653e-01f,
  2.33159870e-01f, 8.02921206e-02f, -6.91630319e-02f, 5.33545092e-02f, 3.43343616e-02f, 8.33632126e-02f, 7.23108351e-02f, -7.26329163e-02f, 5.28702438e-02f, -1.26284406e-01f,
  2.97459979e-02f, -7.29448907e-03f, 1.82931386e-02f, -1.95185542e-01f, 3.69274430e-02f, 1.08325183e-01f, -9.43829399e-03f, -2.21606717e-01f, 3.75468470e-02f, -3.33653949e-02f,
  -4.71986346e-02f, 1.06548056e-01f, -7.77515024e-02f, -1.03074118e-01f, 1.07243001e-01f, 1.25556849e-02f, -1.01098418e-01f, -1.01879433e-01f, -4.10457253e-02f, -3.88122955e-03f,
  4.76114862e-02f, -2.70911809e-02f, 3.37726884e-02f, 1.42391492e-02f, -5.32382242e-02f, 1.73618034e-01f, 3.34216990e-02f, -8.14702734e-03f, 3.22065167e-02f, -3.16329412e-02f,
  7.83447549e-02f, 3.37019786e-02f, 4.58433330e-02f, -1.10504374e-01f, -7.41129369e-02f, 5.63651882e-02f, -6.13071471e-02f, 1.57290522e-03f, 1.03419703e-02f, 4.66300063e-02f,
  1.04133107e-01f, -5.24371415e-02f, -6.84433430e-02f, -2.00154036e-02f, 1.61444601e-02f, 5.45227341e-02f, 2.27606744e-02f, 4.71661687e-02f, 8.80788341e-02f, 6.48990087e-03f,
  -9.21742246e-02f, 4.60903645e-02f, 4.70310636e-02f, -1.38801128e-01f, -7.16752186e-02f, -2.42599212e-02f, -9.10415202e-02f, -3.40885334e-02f, 6.66081607e-02f, -3.49038616e-02f,
  5.88880144e-02f, -6.95292279e-02f, -1.03233280e-02f, -1.75127760e-02f, -5.26142865e-02f, 1.25592863e-02f, -6.47685006e-02f, -5.53486980e-02f, 6.24400936e-02f, 1.25383977e-02f,
  1.01705745e-01f, 1.30156890e-01f, 7.05536082e-02f, -1.86556838e-02f, -7.98901841e-02f, 9.29265544e-02f, 6.67847097e-02f, 4.74943072e-02f, 1.11328691e-01f, 6.00706190e-02f,
  7.35778511e-02f, 1.63689494e-01f, 9.11254261e-04f, 6.25278205e-02f, 7.26101175e-02f, 4.87461239e-02f, 1.17651381e-01f, 9.10432488e-02f, -1.05327005e-02f, -6.71467036e-02f,
  -2.76342154e-01f, 1.93308830e-01f, -1.46156907e-01f, 1.53196037e-01f, -6.19016923e-02f, 3.95131558e-01f, 2.86067158e-01f, 1.26669601e-01f, 3.53984982e-01f, 2.98152745e-01f,
  1.51412874e-01f, 7.67679960e-02f, 7.90040568e-02f, 2.14595705e-01f, 1.81284308e-01f, 2.69625306e-01f, 2.56705970e-01f, 2.43437231e-01f, -4.08065058e-02f, 1.66642107e-02f,
  2.66795829e-02f, 1.05842680e-01f, -9.89348963e-02f, -9.96890441e-02f, -5.25956340e-02f, -2.66652793e-01f, -2.40307972e-01f, -1.45971984e-01f, -1.47356823e-01f, -8.57177153e-02f,
  3.97570208e-02f, -6.84868172e-02f, -1.77169621e-01f, -9.08856168e-02f, 2.89518777e-02f, 2.07904540e-02f, -2.29839515e-03f, -5.30526191e-02f, -4.77129631e-02f, 2.51266994e-02f,
  -3.90453748e-02f, -4.72500585e-02f, -5.05665690e-03f, 5.59529848e-02f, 3.79148275e-02f, -6.66974485e-02f, 3.09348740e-02f, -5.37462682e-02f, 2.72797681e-02f, -4.01052944e-02f,
  1.81352645e-02f, -1.35224555e-02f, 5.70357256e-02f, 1.72434784e-02f, -4.48775217e-02f, 2.58195419e-02f, 1.14129059e-01f, 3.94348130e-02f, -3.17204297e-02f, 7.62770101e-02f,
  -7.00056460e-03f, 6.01206347e-02f, -6.41279854e-03f, -9.55472142e-02f, 1.41916587e-03f, -8.52059051e-02f, -1.04421619e-02f, 3.44669558e-02f, -2.03727912e-02f, 3.14759202e-02f,
  3.94567251e-02f, -3.67284678e-02f, 4.96883355e-02f, 5.63956909e-02f, 2.82969289e-02f, 8.12527463e-02f, 5.11779748e-02f, 3.79390530e-02f, 2.95100566e-02f, -6.13661632e-02f,
  5.66972084e-02f, 7.24856779e-02f, -9.83744040e-02f, -7.22960532e-02f, 2.30606456e-04f, -4.07730974e-02f, -1.81414895e-02f, 5.66013083e-02f, 4.36053760e-02f, -6.70348927e-02f,
  2.09762439e-01f, 2.46950239e-01f, 6.54651131e-03f, -1.17545269e-01f, -3.70372692e-03f, -2.92053074e-02f, -3.74483019e-02f, -1.53861996e-02f, 1.33729652e-01f, 1.10517956e-01f,
  -2.21603531e-02f, 3.36410031e-02f, 4.72746789e-02f, -7.88461193e-02f, 5.41613922e-02f, 4.76035327e-02f, -2.29037367e-03f, -2.80166361e-02f, 9.60297510e-02f, -7.78081939e-02f,
  -1.19083479e-01f, 6.69740140e-02f, -7.90558681e-02f, -2.60187723e-02f, -3.23075391e-02f, -3.05961352e-02f, -1.72688048e-02f, -3.89427766e-02f, -6.83638602e-02f, 8.93301219e-02f,
  -6.07926130e-01f, 2.30540514e-01f, -2.10552514e-01f, -1.46675393e-01f, -2.27150738e-01f, 1.91540327e-02f, 9.13275331e-02f, -1.00451328e-01f, 6.65332051e-03f, 2.01476634e-01f,
  1.88596889e-01f, -2.35843718e-01f, 2.06116438e-01f, 2.58047342e-01f, -1.91153437e-01f, 2.33187824e-01f, 1.28052518e-01f, 8.69553313e-02f, -6.48234263e-02f, -1.25518426e-01f,
  -1.15105353e-01f, 1.67841703e-01f, -1.33327227e-02f, 7.42160305e-02f, -2.31753021e-01f, -2.06965119e-01f, -1.68048758e-02f, -5.13951741e-02f, -3.56797799e-02f, -1.29627228e-01f,
  -3.81360084e-01f, -2.72918075e-01f, -5.94901033e-02f, -1.67692512e-01f, -1.57545641e-01f, -4.07393910e-02f, -8.83909464e-02f, -7.22042844e-02f, -1.11783519e-01f, -7.71226287e-02f,
  -6.96653649e-02f, -6.99213520e-02f, -3.30118686e-02f, 1.90564916e-02f, -8.88500959e-02f, -6.19973753e-06f, 7.30710998e-02f, -4.11813222e-02f, 2.76402701e-02f, 2.01907903e-02f,
  7.92905688e-02f, 4.67368774e-03f, -1.21203447e-02f, 9.34045091e-02f, -1.12774163e-01f, -3.11673358e-02f, 2.11112313e-02f, -3.16955633e-02f, -6.29481152e-02f, -1.20524205e-01f,
  -2.00727284e-02f, 7.13686347e-02f, 7.84410760e-02f, -1.16404854e-02f, 7.66169559e-03f, -2.02615894e-02f, 2.99550015e-02f, 6.26167729e-02f, -7.38085294e-03f, 5.43999560e-02f,
  -9.50656310e-02f, -9.40229446e-02f, -1.22410767e-01f, -3.49033512e-02f, 2.85972264e-02f, 5.24996482e-02f, 4.17066691e-03f, -1.08482897e-01f, 2.70133968e-02f, 5.20866252e-02f,
  -3.66620743e-03f, -4.56214659e-02f, -1.00233890e-02f, -2.00289954e-02f, 1.27444947e-02f, 1.03010368e-02f, -7.63667077e-02f, -4.42349166e-02f, -1.92476884e-02f, -1.44606009e-01f,
  -3.95908356e-01f, -3.63700747e-01f, 6.67116940e-02f, -3.39633040e-02f, 5.50327227e-02f, -3.81747670e-02f, -5.87946735e-02f, 9.20443051e-03f, -1.40664466e-02f, -4.77441065e-02f,
  2.51861773e-02f, 8.10894370e-03f, -1.33853018e-01f, 6.28754124e-02f, 6.39282465e-02f, 1.03585429e-01f, -5.94907328e-02f, 3.49369347e-02f, -7.21653849e-02f, -4.88774665e-02f,
  -2.61708964e-02f, -3.32216956e-02f, 9.27681997e-02f, 3.03392373e-02f, 6.63913116e-02f, 5.01114652e-02f, -1.19579524e-01f, 7.81823844e-02f, -4.54740524e-02f, 6.04579933e-02f,
  -1.68626592e-01f, 1.53986007e-01f, 1.32806793e-01f, -3.26773703e-01f, 7.73489028e-02f, -4.24895436e-02f, -2.14031443e-01f, 1.41340882e-01f, 6.27564713e-02f, -6.11127168e-02f,
  -2.17477947e-01f, 6.95097297e-02f, 2.02255651e-01f, -8.75306800e-02f, 6.08086251e-02f, 1.82025552e-01f, -1.40160918e-01f, -1.79992095e-01f, 1.57516018e-01f, -1.49397239e-01f,
  -1.68179974e-01f, -2.32684597e-01f, -1.06210239e-01f, -1.52438888e-02f, -2.17989907e-01f, -7.55153447e-02f, -2.64605254e-01f, 1.29849225e-01f, -8.61775875e-02f, 1.49480298e-01f,
  -2.55434126e-01f, -2.59432465e-01f, -2.67005265e-01f, -1.15895234e-01f, -1.47389178e-03f, -4.07663658e-02f, -3.66510898e-02f, 1.33768201e-01f, -7.10054636e-02f, 4.12747674e-02f,
  4.41123508e-02f, -6.41126111e-02f, -9.89657640e-02f, 1.29099324e-01f, 2.02633766e-03f, 1.40970265e-02f, -1.83875076e-02f, 2.83375755e-02f, 6.82140067e-02f, 1.63568154e-01f,
  9.31007564e-02f, -4.53863218e-02f, -1.41253591e-01f, -1.15789101e-01f, 9.43911001e-02f, -8.34750533e-02f, 9.85830743e-03f, 9.67040285e-02f, -4.70818728e-02f, 7.14892372e-02f,
  6.51787892e-02f, -1.07111400e-02f, -1.06020257e-01f, 2.88099814e-02f, 2.90873693e-04f, -1.11826025e-01f, -5.02739754e-03f, -8.85269865e-02f, -4.44143750e-02f, -3.76365185e-02f,
  -4.94747870e-02f, -1.32891372e-01f, -3.01067121e-02f, 3.57222371e-02f, -3.94466706e-02f, -6.03729039e-02f, -7.92578012e-02f, 3.76733951e-02f, 6.22516125e-02f, 3.58505063e-02f,
  1.42947827e-02f, 3.18830498e-02f, 7.82441068e-03f, -1.84960812e-02f, -2.26579490e-03f, 6.25430793e-02f, 5.40523864e-02f, -2.06860546e-02f, -2.91614849e-02f, 8.82505551e-02f,
  -3.46347153e-01f, -3.43626201e-01f, -2.35800609e-01f, -9.04429331e-02f, -5.22604920e-02f, -9.26459953e-02f, -3.83606255e-02f, 3.81430313e-02f, -1.42000038e-02f, -2.13103071e-02f,
  8.74475315e-02f, -5.26675582e-02f, 4.38480712e-02f, 2.01210193e-02f, 7.57932961e-02f, -1.35183027e-02f, -9.08800066e-02f, -6.85309097e-02f, -1.16181687e-01f, 1.02724560e-01f,
  -3.42164598e-02f, 4.94732289e-03f, -3.11127007e-02f, -7.05213845e-02f, 5.14789857e-02f, -8.73364955e-02f, -3.12435199e-02f, 3.35197300e-02f, 2.69556195e-02f, -3.61804292e-02f,
  4.87910926e-01f, -3.83474112e-01f, -9.77357104e-02f, 3.29677135e-01f, 3.16514522e-01f, 1.47038773e-01f, 6.25274107e-02f, 7.07978532e-02f, 3.07549775e-01f, -2.49116078e-01f,
  2.93907728e-02f, -3.21357936e-01f, -2.52166063e-01f, 8.88225958e-02f, 1.73760846e-01f, -2.37911969e-01f, 5.59527911e-02f, -6.09910190e-02f, 4.59415987e-02f, -9.45894718e-02f,
  1.78846627e-01f, 1.91222876e-01f, -1.16005339e-01f, -3.80619196e-03f, 1.99341014e-01f, 1.04958497e-01f, -6.76524360e-04f, -1.96479067e-01f, -7.91823715e-02f, -1.06702246e-01f,
  5.20994514e-02f, 7.53552467e-02f, 7.23308548e-02f, 2.95851976e-02f, 5.40167578e-02f, 5.01248576e-02f, -1.60176352e-01f, -8.13407823e-02f, 1.76606525e-03f, -6.17356710e-02f,
  -2.31895410e-02f, 6.05786555e-02f, 1.40760601e-01f, -2.05188878e-02f, 1.54012606e-01f, 8.42995867e-02f, 1.13604680e-01f, 6.41816184e-02f, -1.10762035e-02f, -8.80935509e-03f,
  6.16670027e-02f, 3.11877932e-02f, 1.21634938e-02f, -7.78921917e-02f, 6.87114894e-02f, 1.19277403e-01f, -7.53172040e-02f, -9.14986059e-02f, -1.56438388e-02f, 2.45201029e-02f,
  -9.47971866e-02f, -1.30088590e-02f, 3.79617214e-02f, 1.23989157e-01f, 5.50054461e-02f, 6.20257296e-02f, -1.30216014e-02f, -2.25200318e-02f, -5.50644065e-04f, -7.45362788e-02f,
  8.04039985e-02f, 1.14387639e-01f, 6.60903305e-02f, 8.46966878e-02f, -7.45207770e-03f, 1.34653151e-01f, -7.63745978e-02f, 1.18480688e-02f, 6.28637820e-02f, 4.96663265e-02f,
  -1.67338774e-02f, -3.05124559e-02f, -3.95816155e-02f, -4.76513151e-03f, -9.64862178e-04f, -2.14313697e-02f, 5.44544645e-02f, 2.55766250e-02f, 3.28612402e-02f, 2.34633393e-04f,
  -1.50065660e-01f, -3.20018470e-01f, -1.50270108e-02f, -3.08524910e-02f, -1.83721349e-01f, -3.65449041e-02f, -1.04371473e-01f, 4.68971170e-02f, -5.07232659e-02f, 5.75545356e-02f,
  -1.00303322e-01f, -2.53265370e-02f, -1.36528937e-02f, 5.69469295e-02f, -7.10262209e-02f, -4.54392619e-02f, -4.13708538e-02f, -1.02854632e-01f, -3.84155363e-02f, -7.21544474e-02f,
  -6.43917248e-02f, 1.30215688e-02f, -7.43891075e-02f, 4.46292572e-02f, 2.23074220e-02f, 1.90879330e-02f, -6.63397908e-02f, -6.21150173e-02f, -1.08550675e-02f, -1.18857428e-01f,
  2.66393185e-01f, 4.86208834e-02f, 1.21144084e-02f, 2.56016254e-01f, 8.33529979e-03f, -7.09941760e-02f, -3.71751785e-02f, -2.01811045e-02f, 5.66163920e-02f, -2.39131544e-02f,
  -1.20950118e-01f, 1.45794362e-01f, -1.17832072e-01f, 2.82201380e-01f, 3.46492440e-01f, -2.59626716e-01f, 2.28158683e-01f, 1.26908243e-01f, -8.89051780e-02f, 2.38143727e-01f,
  2.49981452e-02f, 2.76858509e-01f, 4.11454923e-02f, 1.78838596e-01f, 2.78399363e-02f, 9.12537277e-02f, 2.26082653e-01f, -1.38369337e-01f, 1.93532541e-01f, -3.62908165e-03f,
  -5.91532961e-02f, 1.38728870e-02f, 6.05523633e-03f, -1.87095590e-02f, 2.31728647e-02f, -4.09957282e-02f, 1.57269128e-02f, 3.47768739e-02f, 1.77220181e-02f, -7.79192746e-02f,
  1.57166868e-02f, 5.27213048e-03f, 1.17226198e-01f, -5.98707832e-02f, 1.26006827e-01f, 1.36399180e-01f, -6.34374237e-03f, -1.78789228e-01f, 1.63283609e-02f, -5.36418855e-02f,
  2.14976445e-02f, -1.48599237e-01f, 1.46566546e-02f, -3.12970467e-02f, 4.33789082e-02f, 9.62103531e-02f, 7.98707902e-02f, 5.27763031e-02f, 6.79743290e-02f, 1.88413933e-01f,
  2.53084656e-02f, -9.64357778e-02f, -5.03502460e-03f, 8.87196418e-03f, 2.63056811e-02f, -1.48839071e-01f, 5.35618514e-02f, -1.17111363e-01f, 2.40360759e-02f, -8.35101157e-02f,
  2.43749823e-02f, -1.41033167e-02f, 1.23806270e-02f, 4.33319286e-02f, -7.19487201e-03f, 2.99891382e-02f, -6.07125424e-02f, 3.18892277e-03f, 4.30670567e-02f, -2.91767647e-03f,
  2.67298874e-02f, -1.35888439e-02f, 7.61793600e-03f, -7.32495785e-02f, 4.56009731e-02f, -6.72184974e-02f, 1.00252964e-01f, 8.29715729e-02f, -8.65024552e-02f, -1.89214610e-02f,
  1.18579954e-01f, 2.00486213e-01f, -4.15580980e-02f, -4.41741310e-02f, 1.15449943e-01f, 2.82067992e-02f, -8.14359915e-03f, 8.75917822e-02f, 1.27224997e-01f, 7.52399787e-02f,
  2.23586876e-02f, -1.22531220e-01f, -8.23574141e-02f, -2.24637482e-02f, 4.47097197e-02f, 1.13862090e-01f, 7.23184422e-02f, -5.19250799e-03f, 1.04898445e-01f, 1.05361730e-01f,
  1.16158975e-03f, -8.47888589e-02f, 1.06899902e-01f, -5.23404293e-02f, 2.94869225e-02f, -5.13482466e-02f, -2.45329719e-02f, 5.61356135e-02f, 1.04080504e-02f, 8.88966396e-03f,
  -3.19624811e-01f, -1.91600412e-01f, -3.81634444e-01f, -2.35087976e-01f, 2.58451432e-01f, 2.01472759e-01f, -4.85335737e-02f, -4.88595404e-02f, -2.51921803e-01f, 1.26561448e-01f,
  2.75806189e-02f, -1.84172124e-01f, -1.61108807e-01f, -2.60569245e-01f, -2.94618309e-01f, -2.68207312e-01f, 4.32402501e-03f, -6.16272092e-02f, -2.25448966e-01f, 6.66671693e-02f,
  -1.26437172e-01f, 5.36102578e-02f, -2.13136032e-01f, 2.29964152e-01f, 2.75992360e-02f, -2.72460300e-02f, 3.04071099e-01f, 7.47948214e-02f, 2.73909450e-01f, 5.48689440e-02f,
  -5.15247881e-02f, -2.38231882e-01f, -4.19664904e-02f, -1.34089030e-02f, 4.56507169e-02f, 7.32045844e-02f, 1.38772130e-01f, -4.92707044e-02f, -2.58427300e-03f, -1.02235578e-01f,
  8.29653814e-02f, 1.75959338e-02f, -8.91890079e-02f, 2.72874068e-02f, -6.02869056e-02f, -5.90456836e-03f, -1.08143426e-01f, 5.22355251e-02f, -1.30882204e-01f, -6.01750351e-02f,
  -1.07334375e-01f, -6.52335659e-02f, -7.26856962e-02f, 5.66100478e-02f, 8.11099261e-03f, -2.06142478e-02f, -6.16665781e-02f, 9.85862985e-02f, 2.42470670e-02f, 5.53579591e-02f,
  4.82691228e-02f, 1.16653487e-01f, -7.95187578e-02f, -1.18801765e-01f, -1.69447493e-02f, 1.09460205e-02f, -8.13150406e-02f, 5.50449975e-02f, -5.57216927e-02f, 1.20448265e-02f,
  -3.98544259e-02f, -5.82811199e-02f, -5.37576415e-02f, 7.97153860e-02f, 6.81134164e-02f, -7.72455037e-02f, 4.88050915e-02f, 7.25384653e-02f, 1.28257096e-01f, 3.39876413e-02f,
  -2.28646938e-02f, 1.71894638e-03f, 1.13545224e-01f, 3.89111713e-02f, -8.63108635e-02f, 7.08105862e-02f, 8.79373252e-02f, -6.68236287e-03f, -4.07161079e-02f, 5.15254289e-02f,
  1.60109892e-01f, 1.38927326e-01f, -2.15398520e-02f, -2.72536986e-02f, -3.86176705e-02f, 4.28696573e-02f, -9.88139361e-02f, 2.04771776e-02f, -4.96179536e-02f, 2.33557429e-02f,
  1.35265648e-01f, 2.60876995e-02f, 1.23660423e-01f, -3.51265371e-02f, -3.35176326e-02f, 1.63195148e-01f, 1.24512650e-01f, 1.51187703e-01f, 7.02849999e-02f, -1.63957495e-02f,
  7.02593997e-02f, 9.99436677e-02f, 8.47426150e-03f, 6.17691651e-02f, 7.97616839e-02f, 8.34089965e-02f, -9.11187008e-03f, 5.55455126e-02f, -1.75130963e-02f, -2.98053604e-02f,
  -2.45881110e-01f, 1.27787948e-01f, -2.91642994e-01f, -2.11774066e-01f, -1.22498311e-01f, -3.59077513e-01f, -1.58477068e-01f, -1.38691887e-01f, 1.47948951e-01f, 2.10872158e-01f,
  9.89579856e-02f, -1.13595324e-02f, 3.04174393e-01f, -2.39462629e-02f, -9.60574448e-02f, 2.30927691e-01f, -1.57580629e-01f, -7.37731010e-02f, 1.12665603e-02f, -1.82828769e-01f,
  -6.70964271e-02f, -9.26226154e-02f, -1.96216181e-01f, -4.47053351e-02f, -3.00635785e-01f, 5.98730007e-03f, 6.10567965e-02f, -9.52056423e-02f, -1.86569482e-01f, -1.08078696e-01f,
  -3.81988585e-01f, -2.55583704e-01f, -1.96893364e-01f, -3.21927331e-02f, -1.34312466e-01f, 2.53267810e-02f, -1.69086412e-01f, 4.33935001e-02f, -4.19709384e-02f, -4.38325666e-02f,
  -9.84229967e-02f, -6.16561174e-02f, 8.62602238e-03f, 2.05003232e-01f, 5.02591655e-02f, -2.73452345e-02f, -5.53828143e-02f, -3.90976295e-02f, -3.35989818e-02f, 6.65913448e-02f,
  -7.84499347e-02f, 1.66310668e-02f, -1.06561527e-01f, 3.82053778e-02f, -1.27874687e-01f, -1.15398526e-01f, 1.89624168e-02f, -3.62939797e-02f, -4.56894897e-02f, -7.33272210e-02f,
  1.20183200e-01f, 1.06247663e-01f, -7.20080286e-02f, 4.66648713e-02f, -4.01196666e-02f, 5.88366799e-02f, -1.73221913e-03f, -1.98241826e-02f, 6.20118976e-02f, -5.88795133e-02f,
  -8.81718099e-02f, -5.71774133e-02f, -8.97224713e-03f, 2.66186129e-02f, 6.33189902e-02f, 3.83631811e-02f, 2.15686560e-02f, -4.70966995e-02f, 7.74217322e-02f, 1.54220294e-02f,
  -7.51610696e-02f, -1.02325782e-01f, 9.14400071e-02f, 5.60804382e-02f, -6.95518777e-02f, -8.70686676e-03f, 2.02621911e-02f, -3.54868770e-02f, -2.46748924e-02f, -8.66333991e-02f,
  -3.66615206e-01f, -3.58071506e-01f, 1.98482368e-02f, -5.09968475e-02f, -1.02439344e-01f, -1.39153041e-02f, -1.97371598e-02f, -5.19580282e-02f, -1.09388679e-01f, 1.75332632e-02f,
  9.72018316e-02f, -1.12552628e-01f, -9.38053504e-02f, 5.20546772e-02f, -3.42849120e-02f, 2.18261778e-02f, -9.43428278e-02f, 8.91686454e-02f, -1.86476052e-01f, -1.12545334e-01f,
  -1.40380919e-01f, 3.72239687e-02f, 2.08825003e-02f, 2.29379348e-02f, 2.13778801e-02f, -2.90145515e-03f, -1.09437153e-01f, -1.16517525e-02f, -7.58223161e-02f, -8.96400679e-03f,
  -1.10699888e-02f, -1.37785569e-01f, 1.49448186e-01f, 2.77857304e-01f, -8.87118578e-02f, -2.32355282e-01f, -1.79455385e-01f, 2.35238560e-02f, -2.63889749e-02f, -2.14670643e-01f,
  -1.69952586e-01f, 9.41052660e-02f, -2.52699703e-01f, 1.26178861e-01f, 1.56355128e-01f, 7.96195772e-03f, 2.26490527e-01f, 4.13615555e-02f, 1.08985111e-01f, 5.95874526e-02f,
  1.19604431e-01f, 1.93101168e-01f, 1.74932808e-01f, 1.43589631e-01f, 7.86657929e-02f, 1.34949729e-01f, 2.70483375e-01f, 1.15272060e-01f, 1.38697356e-01f, 1.44044682e-01f,
  4.09065448e-02f, 2.38714293e-02f, -2.96427645e-02f, 7.14232847e-02f, 4.36967891e-03f, -3.00113913e-02f, 8.07748735e-02f, 8.54159473e-04f, 3.96425910e-02f, -3.24023142e-02f,
  -6.89572543e-02f, 7.31437206e-02f, -3.05701587e-02f, 4.32672054e-02f, 4.25490588e-02f, 9.95477661e-03f, 3.40946093e-02f, 3.72169446e-03f, 8.67643356e-02f, -4.37424565e-03f,
  -6.00462966e-02f, -1.25695318e-01f, 8.83518625e-03f, 1.85635746e-01f, 2.98543163e-02f, 6.57678694e-02f, -7.93477520e-03f, 8.26004297e-02f, 1.02298975e-01f, 9.10343230e-02f,
  -3.93144861e-02f, -1.90906040e-02f, -9.78471115e-02f, -1.10668279e-01f, -1.29469018e-02f, 1.20935418e-01f, -3.18283886e-02f, 1.43404957e-03f, -2.06519067e-02f, -5.49400598e-02f,
  5.57370558e-02f, -9.25389491e-03f, 1.87122505e-02f, -3.38670351e-02f, 1.91602223e-02f, -5.60376756e-02f, 8.21672976e-02f, 3.71682434e-03f, 4.10046652e-02f, -5.99264167e-02f,
  4.91803885e-02f, 6.04767762e-02f, -3.21680866e-02f, -2.82053296e-02f, 1.32828634e-02f, -7.01335073e-02f, 3.31447348e-02f, 7.07689382e-04f, 2.73606107e-02f, 7.30107576e-02f,
  1.16468318e-01f, 1.84004366e-01f, -5.45976125e-02f, 1.01899631e-01f, 1.19787633e-01f, -9.07173008e-02f, 7.86577091e-02f, 1.07669212e-01f, 1.73587188e-01f, 3.58176939e-02f,
  -1.05162486e-02f, -3.52886709e-04f, -2.24445686e-02f, 1.20252166e-02f, 1.20595463e-01f, 5.88949285e-02f, 2.84828749e-02f, 1.59956738e-01f, 6.69719055e-02f, -4.96116318e-02f,
  -1.14001855e-02f, -1.10608965e-01f, 5.14552742e-02f, 8.02706704e-02f, 2.87116934e-02f, -4.63818153e-03f, 1.44763561e-02f, -3.71361598e-02f, 7.67726600e-02f, 9.06864628e-02f,
  5.67051843e-02f, -1.79449216e-01f, 5.86900152e-02f, -1.34458244e-01f, -9.13447514e-02f, -1.61428198e-01f, -2.31994279e-02f, -2.77481169e-01f, -2.47345671e-01f, -1.87665850e-01f,
  -2.25318179e-01f, 1.79851919e-01f, 2.26053506e-01f, -3.21225494e-01f, 4.40636188e-01f, 1.89842016e-01f, -1.84373274e-01f, -7.14553520e-02f, -1.59020871e-01f, -1.60944223e-01f,
  -1.31306276e-02f, -3.41005921e-01f, 3.40519771e-02f, -2.93256104e-01f, -2.43980780e-01f, -1.31616041e-01f, 5.17819598e-02f, 1.00260109e-01f, -2.65602797e-01f, -1.83808412e-02f,
  -8.95278063e-03f, -2.12810561e-01f, 5.65609708e-02f, -2.36860961e-02f, -1.43394947e-01f, -7.76310312e-03f, 2.27594748e-04f, 1.04753979e-01f, -4.46191611e-04f, 2.45717298e-02f,
  1.05937488e-01f, -4.49115364e-03f, -1.10186331e-01f, 8.70506018e-02f, -2.29931343e-02f, 4.34364052e-03f, 3.80176934e-03f, -1.38514806e-02f, 3.60252410e-02f, 3.30621451e-02f,
  1.18010364e-01f, -5.19077554e-02f, -8.95455554e-02f, 5.67004792e-02f, 1.34142116e-02f, -4.50978056e-02f, 1.00338057e-01f, 1.30834669e-01f, 1.21938452e-01f, -2.94021200e-02f,
  -1.12964816e-01f, -5.57152629e-02f, 3.48603982e-03f, -1.20676076e-02f, -1.13697536e-01f, -9.06226262e-02f, 5.03253005e-02f, -6.31948858e-02f, -8.93736631e-02f, -3.44125628e-02f,
  -1.85290184e-02f, -6.11170419e-02f, -5.22466637e-02f, -3.27632837e-02f, -7.57612363e-02f, 1.61138154e-03f, 4.61507067e-02f, -8.45562294e-02f, -6.31231293e-02f, -2.23117266e-02f,
  4.46654297e-02f, 2.55924985e-02f, -9.47141796e-02f, 3.58932279e-03f, -7.54441023e-02f, 1.17243387e-01f, -4.78253653e-03f, 1.31794428e-02f, -6.18332624e-02f, 1.30978227e-01f,
  -6.06571622e-02f, -2.31064007e-01f, -7.67038688e-02f, -5.74863032e-02f, -1.71974916e-02f, 6.74247220e-02f, -6.92753419e-02f, -8.77944753e-02f, -8.85915086e-02f, -1.19698368e-01f,
  -1.14256712e-02f, -2.43510753e-02f, 7.21786618e-02f, 2.13710982e-02f, -6.56351168e-03f, -6.22275285e-02f, 6.30473271e-02f, 1.13498174e-01f, 1.44007718e-02f, -1.14038736e-02f,
  -2.14662869e-02f, 7.70693645e-02f, 1.89636659e-03f, -4.07679081e-02f, -6.90945685e-02f, -1.40840989e-02f, 1.86268501e-02f, 3.59248137e-03f, 1.08126216e-01f, -1.16165532e-02f,
  -1.20179668e-01f, 3.85118499e-02f, -2.19969824e-01f, 2.34436858e-02f, -2.53117502e-01f, 2.49015629e-01f, 4.57426190e-01f, -1.48063287e-01f, -1.04396241e-02f, 3.80419463e-01f,
  4.11511362e-02f, 8.35921690e-02f, 2.74735004e-01f, 3.21290940e-01f, 3.45018320e-02f, 1.83678076e-01f, 1.71255708e-01f, 1.63288504e-01f, -6.66469187e-02f, -1.55022275e-02f,
  -5.15368395e-02f, 2.85060525e-01f, -1.43768251e-01f, -6.30817637e-02f, -1.95181221e-02f, -1.51018515e-01f, 2.11013984e-02f, -9.30849835e-02f, 1.44605011e-01f, 8.07206407e-02f,
  -1.32662719e-02f, 6.33292273e-02f, -7.61998966e-02f, 2.05281563e-02f, 2.04973645e-03f, -1.72994621e-02f, 3.13705020e-02f, -2.63577867e-02f, -5.80096915e-02f, 7.20501542e-02f,
  3.04325391e-03f, 6.98688030e-02f, 4.39065993e-02f, -3.85190509e-02f, -7.65602812e-02f, -6.97371438e-02f, -2.19665617e-02f, -6.11267835e-02f, -2.26306468e-02f, -1.54696899e-02f,
  -9.29861441e-02f, -4.98803668e-02f, 9.13473871e-03f, 2.91916579e-02f, -5.77293942e-03f, -4.89555858e-02f, 7.32678473e-02f, -6.34798631e-02f, 7.61213060e-03f, -6.14548363e-02f,
  -2.75711995e-02f, -5.43096922e-02f, 1.14528924e-01f, 1.41781336e-02f, 4.15465757e-02f, -9.42030922e-03f, 2.20276825e-02f, 3.04993968e-02f, -9.63797346e-02f, 1.19990729e-01f,
  3.98541540e-02f, -3.76709104e-02f, 3.81018147e-02f, 4.75750528e-02f, -5.97402468e-05f, -7.93087296e-03f, -6.92387447e-02f, -8.94896463e-02f, 4.54039276e-02f, -1.24306463e-01f,
  3.43408738e-03f, 2.30638105e-02f, 6.74859434e-02f, 2.62315143e-02f, -1.04012452e-02f, -9.15218052e-03f, -2.94137783e-02f, -1.08558908e-01f, -3.43316235e-02f, -2.35212911e-02f,
  1.49920792e-03f, 2.53955722e-01f, 4.95159440e-02f, 1.24345161e-01f, 4.82792147e-02f, 7.57057071e-02f, 1.06440865e-01f, -6.83071688e-02f, 1.01181597e-01f, -4.88893017e-02f,
  -1.01185404e-01f, 1.22746686e-02f, 2.53267456e-02f, -8.02405551e-03f, -2.20455769e-02f, 1.10685267e-03f, 7.58452937e-02f, 1.26054987e-01f, 1.13500934e-02f, 6.21877564e-03f,
  1.45374015e-01f, 2.75837239e-02f, 2.82410136e-03f, 4.02095951e-02f, 1.99600980e-02f, 2.64992528e-02f, -1.32967401e-02f, -9.23496708e-02f, -1.24588413e-02f, -4.67777066e-03f
};

// L0_fan_Bp_bar (Shape: 1 x 52)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 52;
const float L0_fan_Bp_bar_data[] = {
  8.15178454e-02f, 3.68393123e-01f, 3.87536108e-01f, 2.56781876e-01f, 2.23936677e-01f, 2.27074981e-01f, 1.86204940e-01f, 3.18621367e-01f, 3.75053555e-01f, 2.67218888e-01f,
  3.12882006e-01f, 3.69120330e-01f, 2.62060404e-01f, 3.35927129e-01f, 2.80163556e-01f, 2.74560958e-01f, 3.73760581e-01f, 2.79018134e-01f, 3.07548016e-01f, 2.20648900e-01f,
  3.30216259e-01f, 1.74878150e-01f, 2.65439898e-01f, 3.99354994e-01f, 3.18425417e-01f, 3.48534375e-01f, 3.18396568e-01f, 1.84892923e-01f, 4.29241508e-01f, 2.37624153e-01f,
  3.74425977e-01f, 3.36981565e-01f, 3.84887099e-01f, 1.74874291e-01f, 1.50439948e-01f, 1.65437564e-01f, 1.75972015e-01f, 7.81619698e-02f, 3.39223593e-01f, 2.34819934e-01f,
  3.01123485e-02f, 2.37614244e-01f, 2.78719246e-01f, 1.85378090e-01f, 3.50991845e-01f, 2.61869133e-01f, 2.35904559e-01f, 1.00325182e-01f, 3.68876569e-02f, 2.07202077e-01f,
  1.03053235e-01f, 2.13822663e-01f
};

// L1_fan_Wp (Shape: 6 x 64)
const int L1_fan_Wp_rows = 6;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  5.32846153e-02f, -1.85927421e-01f, 8.48456919e-02f, 8.24285001e-02f, 4.34325971e-02f, -1.25630945e-01f, 1.60577923e-01f, 5.47781475e-02f, 1.38937339e-01f, 1.90180466e-01f,
  8.90033990e-02f, -1.46453708e-01f, -2.33096462e-02f, 1.19296578e-03f, -2.59761691e-01f, 6.10909127e-02f, -9.65516940e-02f, -6.56124428e-02f, 2.23313551e-02f, 3.48188691e-02f,
  1.80573016e-01f, 7.77643472e-02f, 1.56977419e-02f, -2.70237792e-02f, 2.34568104e-01f, -5.44152074e-02f, 4.63878363e-02f, -5.97303957e-02f, -7.96390101e-02f, -7.88309276e-02f,
  1.82110891e-01f, 1.06039457e-02f, 1.74330641e-02f, -1.27673373e-01f, 9.30726156e-02f, 1.15848638e-01f, 7.27186799e-02f, -2.47682165e-02f, -1.07074730e-01f, -2.57153977e-02f,
  2.03169376e-01f, -3.02191805e-02f, -6.11478798e-02f, 3.02385777e-01f, -9.15571973e-02f, -1.66873291e-01f, 1.07389562e-01f, 2.93874562e-01f, -7.01831654e-02f, -6.98311999e-02f,
  -1.55883551e-01f, -4.69495170e-03f, -1.61392003e-01f, 6.49789646e-02f, -9.05651078e-02f, -1.53222740e-01f, 1.01604722e-01f, -3.44947763e-02f, -1.98135793e-01f, 2.51905471e-01f,
  -1.62513912e-01f, -1.13149457e-01f, -6.02011792e-02f, 1.42701576e-02f, -6.70459196e-02f, 1.11951560e-01f, -8.45733956e-02f, 6.02816194e-02f, 1.45696457e-02f, -1.23403974e-01f,
  8.51673707e-02f, -7.13899583e-02f, 7.59848952e-02f, 1.47115424e-01f, -2.09568799e-01f, 1.11632077e-02f, 1.48807362e-01f, 3.01362909e-02f, 4.06946838e-02f, -4.48854156e-02f,
  -6.26894310e-02f, -1.36553973e-01f, 1.42856792e-01f, 1.10279746e-01f, 2.18671486e-01f, 1.64862230e-01f, -1.49312085e-02f, -9.36398208e-02f, -1.90009952e-01f, -1.38481826e-01f,
  6.47863001e-02f, -1.95766225e-01f, -2.43573219e-01f, -8.22817236e-02f, 1.59506381e-01f, -1.35288745e-01f, 2.38633528e-02f, 2.05347523e-01f, -6.78721396e-03f, -1.03183232e-01f,
  9.57548246e-02f, -1.98148042e-02f, 1.16526261e-01f, 4.18188656e-03f, 6.95695654e-02f, -4.52101529e-02f, 4.85588796e-02f, -1.53348982e-01f, 8.36986899e-02f, 1.88078791e-01f,
  7.44661167e-02f, 1.22371070e-01f, 1.28664508e-01f, -3.81862149e-02f, -3.02400380e-01f, -4.50628959e-02f, -9.57191885e-02f, -4.31071259e-02f, -1.28677953e-02f, 1.32605791e-01f,
  -4.60254261e-03f, 1.36238113e-01f, -2.05820829e-01f, -3.77260931e-02f, -3.11178658e-02f, -1.24469250e-01f, 1.83889512e-02f, 6.15874492e-02f, -1.15851313e-01f, -6.30160496e-02f,
  -4.54535149e-02f, 3.94333992e-03f, -5.66354357e-02f, -6.90607205e-02f, -1.06047511e-01f, 1.59245715e-01f, -1.10928163e-01f, -1.72474727e-01f, -1.37288615e-01f, 3.84533778e-02f,
  -1.89665183e-01f, 1.22437626e-01f, -5.71743511e-02f, 1.39872074e-01f, -2.44289227e-02f, 3.03901080e-02f, 7.90337399e-02f, 7.74894431e-02f, 4.70871851e-02f, 2.18516469e-01f,
  1.66848898e-01f, -2.99381036e-02f, 3.70636173e-02f, 1.68248922e-01f, 1.44431423e-02f, 4.38003689e-02f, 2.09438369e-01f, -1.04975142e-01f, 1.60173159e-02f, -7.26305842e-02f,
  -1.24688014e-01f, -1.46775752e-01f, 9.93196368e-02f, -1.08896442e-01f, -1.08063392e-01f, -1.75234735e-01f, -1.33658215e-01f, -9.52957943e-02f, -6.82204589e-02f, -1.41431019e-01f,
  1.21407531e-01f, -1.36213169e-01f, -5.60653843e-02f, -1.46906069e-02f, -1.44481316e-01f, 7.80971125e-02f, -2.08896607e-01f, 5.39231561e-02f, -1.24392271e-01f, 2.50147909e-01f,
  1.62971452e-01f, -2.16560125e-01f, -1.76104039e-01f, 1.39271989e-01f, 1.29965320e-01f, -1.93343982e-01f, -5.17066717e-02f, -2.74571538e-01f, 2.71685366e-02f, 2.95924973e-02f,
  1.36035144e-01f, -1.34229556e-01f, -4.41628471e-02f, 1.07844837e-01f, 5.24623767e-02f, 7.96012506e-02f, -1.70121536e-01f, -3.11673209e-02f, 3.55859958e-02f, 3.58350426e-02f,
  -8.27796161e-02f, -3.49967033e-02f, -1.64672866e-01f, -9.49614774e-03f, 1.24288104e-01f, -7.16795251e-02f, -4.07167114e-02f, -1.80798724e-01f, -1.60483375e-01f, 1.84878483e-01f,
  6.64788559e-02f, 5.04092798e-02f, -5.18484153e-02f, 2.34704074e-02f, -1.92828719e-02f, -1.20558500e-01f, -1.19759202e-01f, 7.37127811e-02f, 4.16329838e-02f, -1.82783470e-01f,
  2.57664084e-01f, 1.67430103e-01f, -9.63225886e-02f, 2.79388651e-02f, -1.27620250e-01f, 4.86545675e-02f, 7.71038746e-03f, 7.80087486e-02f, 1.76447630e-01f, 1.75637901e-01f,
  1.30539194e-01f, -5.54095693e-02f, -2.00709626e-01f, -1.51969343e-01f, 2.33237460e-01f, 7.74360215e-03f, -1.68034241e-01f, 1.32408321e-01f, -7.76180020e-03f, -1.02262095e-01f,
  5.20463996e-02f, -2.42673472e-01f, 4.08146977e-02f, -1.95982039e-01f, -1.68651089e-01f, 8.62706378e-02f, 3.29024717e-02f, 1.34069666e-01f, -1.91826463e-01f, -5.55960275e-02f,
  -4.89216782e-02f, 1.34928465e-01f, -8.14365409e-03f, 1.60766933e-02f, -1.00512832e-01f, -6.88415021e-02f, 9.18053985e-02f, 1.63526088e-01f, 1.35209113e-01f, -1.84125789e-02f,
  1.09276019e-01f, 1.11546926e-01f, 2.27796361e-01f, -4.50827591e-02f, 1.23774983e-01f, 1.37493700e-01f, 1.31250590e-01f, 1.57052308e-01f, 1.71386767e-02f, -3.00603043e-02f,
  7.73353800e-02f, 1.18866704e-01f, 1.66685134e-01f, -1.23459622e-02f, 9.93856937e-02f, -9.48325545e-02f, 2.40121245e-01f, -1.26843065e-01f, 6.59046099e-02f, -2.82375906e-02f,
  -1.70579478e-01f, -5.79708815e-02f, 7.44469762e-02f, 1.41596943e-01f, -9.67621431e-02f, -2.16211185e-01f, 2.44773299e-01f, -4.16678935e-02f, 1.35275587e-01f, -2.75969952e-02f,
  1.66537315e-02f, 7.33753964e-02f, 4.36241999e-02f, -1.31911607e-02f, 2.59307981e-01f, 1.44166388e-02f, 6.74760565e-02f, 8.54701623e-02f, 6.04161210e-02f, -1.49861053e-01f,
  7.59424791e-02f, 2.14134991e-01f, 4.12894636e-02f, 4.83756736e-02f, -1.59260835e-02f, 9.52394307e-02f, -3.32800560e-02f, -1.99643627e-01f, 2.29058526e-02f, 1.73509806e-01f,
  1.40930966e-01f, 6.40718266e-02f, 1.02622405e-01f, 1.26469672e-01f, 1.26702279e-01f, 2.74250861e-02f, -8.17305688e-03f, 1.07529931e-01f, 3.68759558e-02f, -7.23943338e-02f,
  -1.39301658e-01f, -1.36254221e-01f, -1.89569265e-01f, -1.08789988e-01f, -8.39604959e-02f, -1.58586279e-01f, -1.69106826e-01f, -5.54249994e-02f, 1.31506428e-01f, -2.34485976e-02f,
  9.11594927e-02f, -1.95467677e-02f, 1.42710403e-01f, -4.31620032e-02f, 8.29095319e-02f, -2.52092153e-01f, 2.72879004e-01f, 1.50569454e-01f, -1.65280089e-01f, -2.39839777e-01f,
  -1.15179308e-01f, -7.83131644e-02f, -2.73896664e-01f, -1.43095225e-01f, -9.96120460e-03f, -1.73140690e-01f, -1.00013815e-01f, 5.36437631e-02f, 8.33241269e-02f, 8.13643560e-02f,
  -6.55749114e-03f, 2.32261047e-02f, 6.45241290e-02f, 1.02612846e-01f, -1.42398819e-01f, -1.14968931e-02f, -1.60439506e-01f, -3.14885974e-02f, 8.40232298e-02f, -8.08077585e-03f,
  -6.48419261e-02f, 8.18116814e-02f, -1.25375465e-01f, 2.28874777e-02f, 3.99959534e-02f, -1.59017276e-02f, -3.39592062e-02f, -1.64824352e-01f, 2.19133243e-01f, 9.40634459e-02f,
  1.14350952e-01f, -3.09239596e-01f, -2.32878570e-02f, 8.96625444e-02f, 1.59744218e-01f, -1.47392496e-01f, -1.37962237e-01f, 2.87651330e-01f, 5.61543889e-02f, -1.50023416e-01f,
  -5.63364886e-02f, 1.27034590e-01f, -1.50345668e-01f, -1.22394927e-01f
};

// L1_fan_Wp_bar (Shape: 52 x 64)
const int L1_fan_Wp_bar_rows = 52;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  1.80219695e-01f, 2.74208989e-02f, 5.94551787e-02f, -2.00020000e-02f, 5.62017970e-02f, 1.03872627e-01f, 1.78708911e-01f, 1.84723213e-01f, -2.10407272e-01f, -2.25610524e-01f,
  2.67776493e-02f, 9.02871862e-02f, 5.36705106e-02f, 1.45721167e-01f, 9.44250971e-02f, 3.72448295e-01f, 2.91388214e-01f, 2.40933806e-01f, 8.69117528e-02f, -2.68626988e-01f,
  -3.46196666e-02f, -2.00739548e-01f, -2.25944594e-01f, 3.86510640e-02f, -1.25384316e-01f, 1.15099661e-01f, 3.01093847e-01f, 2.52187371e-01f, 3.60828221e-01f, 1.16128158e-02f,
  2.80663878e-01f, 2.59978652e-01f, -7.69474776e-03f, 8.27124417e-02f, -2.75903821e-01f, -3.32029979e-03f, -1.01935200e-01f, 5.77189848e-02f, 1.01706289e-01f, 2.11152583e-01f,
  3.24106604e-01f, -1.32237002e-02f, 2.77394891e-01f, -2.06580386e-01f, -1.64056823e-01f, 1.11954287e-01f, 4.21168357e-02f, 1.83118075e-01f, 7.63559341e-02f, -8.38755295e-02f,
  2.01427802e-01f, -3.57930720e-01f, 1.58457935e-01f, 2.22809501e-02f, 4.14811283e-01f, -7.56930932e-02f, -1.37765303e-01f, -5.28862141e-02f, 3.16470265e-01f, -1.79745495e-01f,
  -5.41602075e-02f, 2.16575935e-01f, 2.68281847e-01f, 3.87388051e-01f, 3.81416194e-02f, 3.22996795e-01f, 2.61445582e-01f, 2.11854830e-01f, 1.85444474e-01f, 2.51200110e-01f,
  -3.03881010e-04f, 9.61486027e-02f, 1.26830965e-01f, -2.03288987e-01f, -1.97827250e-01f, -7.68536627e-02f, 2.01973602e-01f, 3.03035617e-01f, 2.93660611e-01f, 1.38843521e-01f,
  2.16307826e-02f, -7.25227594e-02f, 2.03179792e-01f, -1.73325181e-01f, 5.94527759e-02f, -1.80822968e-01f, 3.03364605e-01f, 1.51348695e-01f, -6.89342767e-02f, 2.40002096e-01f,
  2.56330431e-01f, 1.36407465e-01f, -7.88153410e-02f, -2.39504918e-01f, -8.20956379e-02f, 1.94336176e-01f, 8.41590017e-02f, -3.32219377e-02f, 1.17641836e-01f, 7.80928358e-02f,
  2.26214752e-01f, 3.07403624e-01f, 3.43524039e-01f, 2.38124400e-01f, -1.15705431e-01f, -1.94454521e-01f, 2.64198720e-01f, -3.67251188e-01f, 1.97517857e-01f, 3.72861654e-01f,
  7.92691484e-04f, -2.62406021e-01f, -3.23342793e-02f, -2.00931996e-01f, 1.05951782e-02f, 9.06914249e-02f, 1.16107456e-01f, 1.41819380e-02f, 3.26303333e-01f, 2.79406369e-01f,
  1.33229634e-02f, -2.93984503e-01f, -2.72071902e-02f, -1.20614678e-01f, -2.09082458e-02f, 1.17674038e-01f, 1.23143144e-01f, 3.13133627e-01f, 1.57952353e-01f, 1.21287167e-01f,
  2.60095090e-01f, 2.53687948e-01f, 3.50306779e-01f, 2.05011651e-01f, 1.53827146e-01f, -1.59255385e-01f, 2.35626549e-01f, 1.77434370e-01f, 3.55471879e-01f, -2.05684200e-01f,
  1.92056984e-01f, 6.70631900e-02f, 1.40418544e-01f, -1.78206384e-01f, 1.54764634e-02f, -9.87208337e-02f, -1.31785467e-01f, 4.28012162e-02f, 1.87605292e-01f, 5.90836369e-02f,
  -1.33946061e-01f, 9.66248810e-02f, 1.96068902e-02f, -1.86510663e-02f, 9.83988196e-02f, -1.28105253e-01f, -3.07562262e-01f, 8.17529187e-02f, -1.10897802e-01f, 9.80256647e-02f,
  2.55883515e-01f, 3.65163893e-01f, 1.44854307e-01f, 8.43541929e-04f, 2.91580319e-01f, 1.44775853e-01f, 2.06591845e-01f, 2.18460917e-01f, -3.56359519e-02f, 2.09972307e-01f,
  -2.55734265e-01f, 1.68302432e-01f, 1.00918151e-01f, 2.93673068e-01f, 2.48838469e-01f, -8.70368779e-02f, 2.93413512e-02f, -1.86668127e-03f, -5.53588979e-02f, -3.10267508e-01f,
  -1.08976312e-01f, 2.20137864e-01f, 5.72761036e-02f, -1.60458893e-01f, -2.29330003e-01f, 1.94295898e-01f, 1.67114332e-01f, 2.70671606e-01f, -1.78305626e-01f, -1.38515919e-01f,
  -7.08160698e-02f, 1.60331428e-01f, 1.77333027e-01f, 1.42377183e-01f, 1.42644301e-01f, 1.51279747e-01f, -1.28192119e-02f, 1.41341835e-01f, 8.48703831e-02f, 3.21095020e-01f,
  -3.16751838e-01f, 6.19150773e-02f, -4.21119928e-01f, 2.16834277e-01f, 2.23886445e-02f, 3.56648207e-01f, -7.72378370e-02f, 1.26307651e-01f, -2.71542668e-01f, 1.57063842e-01f,
  9.89659056e-02f, 3.12836975e-01f, 2.06544518e-01f, 4.33484256e-01f, 2.29276642e-01f, 1.28950641e-01f, -2.08362237e-01f, 3.86786491e-01f, -4.32272665e-02f, -1.89074606e-01f,
  1.84334487e-01f, 3.03660542e-01f, -2.34897528e-03f, 2.19618857e-01f, -4.50855970e-01f, 6.58655241e-02f, 1.29487589e-01f, -3.10792797e-03f, 3.29222269e-02f, 6.47499114e-02f,
  1.67930365e-01f, -1.72804594e-02f, 3.15187760e-02f, -1.87437639e-01f, 2.08434820e-01f, 3.25218178e-02f, 8.58088210e-02f, 1.62720278e-01f, -4.05296594e-01f, -2.69639552e-01f,
  -2.68469900e-01f, 2.27160901e-01f, 2.99901534e-02f, 2.39066958e-01f, 4.27378491e-02f, -2.34914169e-01f, 1.22514844e-01f, 2.89865106e-01f, 7.06829429e-02f, -3.36505741e-01f,
  -8.93283710e-02f, -2.62735456e-01f, 2.15616971e-01f, 1.88854620e-01f, 1.41032249e-01f, 1.10243417e-01f, 2.33844042e-01f, 2.46817574e-01f, 2.12452799e-01f, 1.29411116e-01f,
  1.18656576e-01f, 2.31581539e-01f, 2.45997742e-01f, 2.77053961e-03f, 2.43198961e-01f, 1.57464519e-01f, -4.24247682e-02f, 9.81712267e-02f, 1.20612852e-01f, 2.78373659e-01f,
  3.28480959e-01f, 8.22998881e-02f, -3.83906923e-02f, -1.42182812e-01f, -2.57065624e-01f, 2.12568846e-02f, 1.43955618e-01f, 1.69668142e-02f, 7.27515966e-02f, 1.37911281e-02f,
  -7.78713152e-02f, -4.50130180e-02f, 1.74087718e-01f, 1.74207687e-01f, -2.74067998e-01f, -2.13654399e-01f, 2.71470964e-01f, 2.70472169e-01f, 2.41763130e-01f, 1.83993757e-01f,
  -1.09689184e-01f, -2.24851146e-02f, 1.99843630e-01f, 2.92679995e-01f, 2.99024880e-01f, -4.57355045e-02f, 1.64028391e-01f, 1.72232091e-02f, -8.83793756e-02f, 6.26194105e-02f,
  2.74683386e-01f, 1.44394696e-01f, 1.14481233e-01f, 2.77549028e-01f, 2.23532561e-02f, -4.14319843e-01f, 2.95095712e-01f, -1.39307082e-01f, -1.80826232e-01f, 2.13184878e-01f,
  2.79783666e-01f, -8.74487162e-02f, 2.45428905e-01f, 1.93788469e-01f, 7.10790455e-02f, -4.07516994e-02f, -2.22244665e-01f, -2.47981235e-01f, -3.09127811e-02f, 1.09360488e-02f,
  6.01022802e-02f, 1.26697555e-01f, 1.70042068e-01f, 3.09900120e-02f, 2.75360495e-01f, 2.80654043e-01f, 1.98951364e-01f, 3.90033841e-01f, -2.38155022e-01f, -2.79206872e-01f,
  6.03528135e-03f, -2.38614082e-01f, -1.32333145e-01f, 2.16987818e-01f, 7.77089670e-02f, 6.06723391e-02f, 2.32390404e-01f, 2.67681420e-01f, -2.27491125e-01f, -6.37046844e-02f,
  -2.84617573e-01f, 1.87695414e-01f, -1.66810304e-01f, 2.36488432e-01f, -1.62547290e-01f, 3.61581445e-01f, 1.56313017e-01f, 7.22662592e-03f, 4.02562886e-01f, 3.58911395e-01f,
  -1.04662724e-01f, -2.14109663e-02f, -7.76115581e-02f, 1.60414666e-01f, -1.33510500e-01f, -1.59782559e-01f, -2.41538286e-02f, 3.27711068e-02f, 4.43901420e-02f, 1.97547674e-01f,
  6.30025119e-02f, 8.86637196e-02f, 4.01156507e-02f, -3.38725239e-01f, -2.24278271e-01f, 1.32339299e-01f, -1.28300875e-01f, -3.51362526e-02f, 8.77197385e-02f, -1.46054411e-02f,
  1.95170790e-01f, -1.23415560e-01f, 3.03355902e-01f, 3.10017299e-02f, 1.28190547e-01f, -2.16644615e-01f, -9.20615345e-02f, -1.81645826e-01f, 3.68077248e-01f, -1.95479706e-01f,
  -2.63008803e-01f, 2.66090393e-01f, 2.36254856e-01f, 2.22769350e-01f, 1.41429573e-01f, 1.42861277e-01f, 1.68385878e-01f, 1.90380588e-01f, -1.55804992e-01f, 1.72667131e-01f,
  1.94983199e-01f, 2.69820482e-01f, -2.01908365e-01f, 1.89806968e-02f, -2.36889273e-01f, 3.90592515e-01f, -1.08575866e-01f, 1.11303389e-01f, 5.69275953e-02f, 4.46064442e-01f,
  -7.49226063e-02f, -5.12517318e-02f, 3.05476785e-01f, 1.74322240e-02f, -2.42545735e-03f, -1.12425737e-01f, -2.04808414e-02f, 2.53689378e-01f, -1.01477124e-01f, 1.39870480e-01f,
  1.59283087e-01f, 1.45143524e-01f, -4.26107496e-02f, -2.17815191e-01f, 2.78107852e-01f, 1.45838916e-01f, -2.46655434e-01f, -2.73886502e-01f, -1.32377138e-02f, 9.87039320e-03f,
  2.79765506e-03f, 1.33279145e-01f, 9.95300040e-02f, -1.00658171e-01f, 7.97048509e-02f, -3.00362766e-01f, 3.51470411e-01f, -1.76373348e-01f, -1.44953296e-01f, 1.86814591e-01f,
  -1.86900258e-01f, 1.94892921e-02f, -1.18983954e-01f, 4.78869230e-02f, -1.24773070e-01f, 1.15363441e-01f, 5.23533970e-02f, -1.17162317e-01f, 2.38775060e-01f, 1.69018731e-01f,
  3.23654301e-02f, -8.68959129e-02f, -1.63383067e-01f, -1.87095299e-01f, 3.25027704e-01f, 1.26899511e-01f, 2.96731740e-01f, 6.07169569e-02f, 2.90037151e-02f, 3.08477506e-02f,
  2.02644050e-01f, 9.90933850e-02f, 4.56710858e-03f, 8.12506601e-02f, -7.05591738e-02f, -6.13935404e-02f, 1.27765238e-01f, 2.87030786e-01f, 9.95536968e-02f, 1.97974935e-01f,
  -9.26354751e-02f, -2.52977520e-01f, -2.25516647e-01f, -6.41755387e-02f, 1.49416849e-01f, 4.10297588e-02f, 7.64758587e-02f, -6.81546032e-02f, -2.08754614e-01f, -2.03482866e-01f,
  -1.97125360e-01f, -8.83285776e-02f, 2.69744426e-01f, -2.67474324e-01f, -1.13888226e-01f, 1.90973088e-01f, 2.31964976e-01f, 7.57319182e-02f, 2.37987965e-01f, 1.06541209e-01f,
  8.70236382e-02f, -1.29875362e-01f, -3.31608206e-02f, 2.26631731e-01f, 2.83115864e-01f, 1.54996261e-01f, -2.16693759e-01f, 2.61832066e-02f, 2.76729733e-01f, 2.75684267e-01f,
  2.82657981e-01f, 3.42804611e-01f, 4.09347191e-03f, -2.58835375e-01f, 1.24292657e-01f, 2.00258434e-01f, 1.54634193e-01f, 4.46930416e-02f, 2.06465155e-01f, -2.02188388e-01f,
  -1.09192081e-01f, 2.97837108e-01f, -3.61809433e-02f, -3.91910225e-01f, -4.45661321e-02f, 3.91287476e-01f, -5.41112125e-02f, 2.16184676e-01f, -2.05403477e-01f, 1.65589675e-01f,
  -2.35172465e-01f, -2.06203282e-01f, 6.02182113e-02f, 2.84577727e-01f, 5.94359525e-02f, 1.86520189e-01f, -1.96936339e-01f, 1.66788679e-02f, -3.56318504e-02f, -1.07185602e-01f,
  -3.15995872e-01f, 1.73678964e-01f, -2.54169315e-01f, 1.17161550e-01f, 2.80407935e-01f, 2.43362471e-01f, 2.72616118e-01f, -5.64555302e-02f, 2.10119426e-01f, 2.44819164e-01f,
  4.33765143e-01f, 6.23849183e-02f, 3.13482106e-01f, 1.03354812e-01f, -1.38358446e-03f, -1.83066562e-01f, -1.25697285e-01f, -9.27616805e-02f, 2.92372555e-01f, -3.31916332e-01f,
  1.39374688e-01f, 1.81952734e-02f, 1.45230159e-01f, -5.10685109e-02f, 4.96278778e-02f, 9.93783250e-02f, -3.57476287e-02f, 9.82415527e-02f, 1.83980569e-01f, 6.97719306e-02f,
  3.36785078e-01f, 5.27057610e-02f, -7.12627254e-04f, 1.21705599e-01f, 3.65516633e-01f, -4.55667265e-02f, -4.50890809e-02f, 2.31767714e-01f, 1.85131058e-01f, -1.88863367e-01f,
  1.18324928e-01f, 3.96170467e-01f, -3.39871585e-01f, 2.38645598e-02f, -9.72283185e-02f, 5.57467863e-02f, 2.01064259e-01f, 3.48694265e-01f, -2.26992205e-01f, -5.09511456e-02f,
  -1.49743678e-02f, 1.61416426e-01f, 1.83132485e-01f, 1.62796021e-01f, -3.04796398e-01f, 1.75899252e-01f, -4.19504233e-02f, -1.13587290e-01f, 3.29763182e-02f, -1.40043765e-01f,
  2.20858321e-01f, -2.81837955e-02f, -3.83348078e-01f, -2.68818200e-01f, -2.10513428e-01f, -1.85097530e-01f, 2.95689225e-01f, -1.07416995e-01f, 1.42657505e-02f, -1.24320932e-01f,
  -4.73556250e-01f, 1.40048444e-01f, 1.55244917e-01f, 2.17312917e-01f, 3.19534928e-01f, 7.33012035e-02f, -4.10806894e-01f, -1.68774843e-01f, 1.93819404e-01f, -4.16827239e-02f,
  4.20727491e-01f, 6.20841496e-02f, -6.44462556e-02f, 1.34208441e-01f, 3.19481999e-01f, 2.87120372e-01f, -1.11731969e-01f, -2.35374466e-01f, 1.49482042e-01f, -9.85369161e-02f,
  2.23823398e-01f, 3.76462191e-01f, 8.72879922e-02f, -7.85121918e-02f, -2.42931694e-01f, -1.74031537e-02f, -3.67037594e-01f, -1.03310898e-01f, 1.35052666e-01f, 3.12545329e-01f,
  6.77089170e-02f, -5.17991148e-02f, 1.78052083e-01f, -8.04808363e-02f, 2.72767901e-01f, 1.56711623e-01f, 1.54352173e-01f, 1.54810101e-01f, 2.20701352e-01f, 9.79111642e-02f,
  -1.69283777e-01f, 2.31192680e-03f, 1.48778781e-01f, -1.99033499e-01f, 2.15985969e-01f, 2.79838473e-01f, 3.59668553e-01f, 1.90980852e-01f, 4.31751832e-02f, -1.00844353e-01f,
  -1.74000144e-01f, -1.26975730e-01f, -1.89392611e-01f, -1.63768888e-01f, -1.56667363e-02f, -1.71804145e-01f, -2.38242537e-01f, -2.23478869e-01f, -7.42692202e-02f, -1.87074408e-01f,
  1.72976345e-01f, 4.33021784e-02f, -2.62055565e-02f, 2.29962915e-01f, 1.26675433e-02f, 3.25918496e-01f, -2.48804495e-01f, -1.32685810e-01f, 1.78011611e-01f, 2.63525158e-01f,
  -3.59490693e-01f, 4.32262104e-03f, 1.86021879e-01f, 1.20111264e-01f, 4.07088846e-01f, 3.56896780e-02f, 9.81980041e-02f, 1.29415020e-01f, 2.85492670e-02f, -3.22273411e-02f,
  -5.73347602e-03f, 7.39462487e-03f, -2.09765226e-01f, -2.66210198e-01f, 1.16932057e-01f, 1.43110678e-01f, -5.58455363e-02f, 1.17515013e-01f, 7.08327070e-02f, -1.81571662e-01f,
  -2.80452430e-01f, -2.34061226e-01f, -1.00028403e-01f, 8.06196332e-02f, 8.11588541e-02f, -1.37109563e-01f, -1.03724048e-01f, -7.27656260e-02f, 4.83922139e-02f, 2.91265473e-02f,
  -1.00328398e-04f, 3.16361785e-01f, 2.17089012e-01f, -4.08599749e-02f, 1.81547001e-01f, 2.16371357e-01f, 7.16265514e-02f, -5.83873652e-02f, -1.55009001e-01f, -1.29525065e-01f,
  3.44833016e-01f, 4.59155403e-02f, 1.62247151e-01f, 1.77769572e-01f, 1.57759696e-01f, 2.48965815e-01f, 2.23682836e-01f, 2.03990683e-01f, 4.17427458e-02f, 1.07865401e-01f,
  2.35188290e-01f, 2.61166215e-01f, -7.95132667e-02f, 1.65973514e-01f, -3.17178488e-01f, 2.34707624e-01f, -2.42003888e-01f, 8.30459073e-02f, -5.86800054e-02f, -7.93683380e-02f,
  3.84756252e-02f, 1.25242576e-01f, -1.49645627e-01f, 3.74818355e-01f, 1.30773872e-01f, 2.88774580e-01f, 3.42134535e-01f, 2.49684036e-01f, -4.05541472e-02f, -1.12349823e-01f,
  -1.80594951e-01f, -6.64730147e-02f, 3.42228472e-01f, 2.04146385e-01f, 3.36436927e-01f, 5.37285879e-02f, -1.19755872e-01f, -5.02499454e-02f, 9.90047399e-03f, -1.80048406e-01f,
  -6.97379932e-02f, -2.44851112e-01f, 1.05574086e-01f, -2.14037836e-01f, 2.85428524e-01f, 8.77000093e-02f, -5.72422333e-02f, 1.40718237e-01f, 2.63476908e-01f, -2.14977220e-01f,
  -2.40771145e-01f, 3.92851323e-01f, -2.84723848e-01f, 1.12201357e-02f, 1.36916548e-01f, 1.05504043e-01f, -1.93277553e-01f, -1.16694391e-01f, -1.81232736e-01f, 7.73819815e-03f,
  3.25076193e-01f, 1.89124107e-01f, -2.55781591e-01f, -2.05039740e-01f, -1.48832291e-01f, -2.76160419e-01f, 1.70692027e-01f, -2.67132849e-01f, -1.98686402e-02f, 2.95370314e-02f,
  1.68662041e-01f, 2.48168930e-01f, 6.48384392e-02f, -5.73783740e-03f, 2.41714686e-01f, 1.09539732e-01f, 2.98666090e-01f, -5.27931862e-02f, 1.42922908e-01f, -2.48464167e-01f,
  2.56727308e-01f, -2.08295748e-01f, 9.67377573e-02f, 1.47872299e-01f, 2.18166262e-01f, -1.25932917e-01f, -4.32070382e-02f, -8.64109248e-02f, 2.92693675e-01f, -8.31431746e-02f,
  2.21745059e-01f, 4.98512462e-02f, -2.88755476e-01f, -1.73625171e-01f, 9.00875255e-02f, 2.01436415e-01f, -2.55752414e-01f, -2.27202252e-01f, 2.50117421e-01f, -6.40344918e-02f,
  3.49026829e-01f, 2.81802028e-01f, -9.65772346e-02f, -9.92730111e-02f, 1.48855299e-01f, -1.77820563e-01f, 2.60536313e-01f, 2.88356930e-01f, 3.13009650e-01f, 2.10375309e-01f,
  -1.22381434e-01f, -2.15086728e-01f, 2.54204452e-01f, 2.04346374e-01f, 2.57532924e-01f, 1.60120741e-01f, -1.26344422e-02f, 1.86074954e-02f, -1.90644458e-01f, -7.85082281e-02f,
  -1.94832161e-01f, -5.96637791e-03f, 1.25015661e-01f, -6.45370260e-02f, -7.60028958e-02f, 9.92883146e-02f, -3.97970080e-02f, 1.48911551e-01f, -1.43238634e-01f, -9.02846009e-02f,
  1.65183797e-01f, -2.63001281e-03f, 1.74694061e-01f, 1.73822716e-01f, 1.76087648e-01f, -2.44706850e-02f, 2.25732297e-01f, 7.99195468e-02f, -1.91027280e-02f, -1.63447276e-01f,
  2.75857240e-01f, 1.05550334e-01f, 2.69244403e-01f, -6.83271885e-02f, 2.73922503e-01f, -3.37718338e-01f, 1.97369754e-01f, -2.91315734e-01f, 2.12504342e-01f, 9.03227404e-02f,
  1.56383011e-02f, 9.86093190e-03f, -1.66025832e-02f, -1.08644515e-01f, -2.49750316e-02f, -1.69623509e-01f, 8.45251046e-03f, -1.02320164e-01f, -4.90555167e-02f, -4.14067470e-02f,
  1.16053849e-01f, 2.22279385e-01f, -2.49104891e-02f, 1.74996510e-01f, 3.84922355e-01f, 1.32397547e-01f, 1.34237975e-01f, 1.92081481e-01f, 2.45294034e-01f, 1.89591721e-01f,
  -7.08831027e-02f, 2.30083212e-01f, 5.72674870e-02f, 3.05900186e-01f, 7.20337108e-02f, 2.80508548e-01f, 1.03239723e-01f, 7.96739087e-02f, 2.47735158e-01f, -6.62956238e-02f,
  3.77732217e-01f, 2.05480099e-01f, 2.81789988e-01f, -2.90668458e-01f, -2.15932325e-01f, 3.43542278e-01f, 1.02841593e-01f, -3.07225108e-01f, -1.45037383e-01f, 3.91941905e-01f,
  2.85248250e-01f, 2.94140249e-01f, -2.19635233e-01f, 2.16050550e-01f, -1.72334313e-01f, -1.20938025e-01f, 1.94072053e-01f, 1.89006522e-01f, 1.87246099e-01f, 2.06552833e-01f,
  -2.41323654e-02f, 1.47126913e-01f, 7.24426657e-02f, 9.75741521e-02f, 1.29342139e-01f, -2.07954913e-01f, 1.94907233e-01f, -8.78211036e-02f, 1.00658819e-01f, 2.53518283e-01f,
  3.50978374e-01f, -1.96510665e-02f, 7.65075684e-02f, -1.17091298e-01f, -1.50029078e-01f, -2.08996385e-01f, -1.48096224e-02f, -6.81654513e-02f, -1.95344254e-01f, 3.65990512e-02f,
  3.28836553e-02f, 1.75430611e-01f, 1.32922813e-01f, -7.48904645e-02f, -1.55241206e-01f, 3.64871733e-02f, 3.31382384e-03f, 2.21520275e-01f, 2.05064058e-01f, 1.04516439e-01f,
  -2.35611588e-01f, -3.00070852e-01f, -2.35426184e-02f, 2.29929686e-01f, 2.43132293e-01f, 2.63807103e-02f, 5.73727302e-02f, 1.47363394e-01f, -4.63969745e-02f, -1.65451124e-01f,
  -1.93032756e-01f, 1.74575076e-01f, 7.63139129e-02f, -2.59708345e-01f, -5.88673390e-02f, -6.28498569e-03f, 2.27538064e-01f, -5.64712957e-02f, 1.69193223e-01f, 1.92102328e-01f,
  3.45419675e-01f, 2.65981704e-01f, -1.12911485e-01f, 1.17180996e-01f, 1.40367538e-01f, -5.08818924e-02f, -8.40653554e-02f, 1.33825615e-01f, -2.25482419e-01f, 3.29215825e-01f,
  1.59535751e-01f, 1.76550910e-01f, 5.31025194e-02f, 1.64843842e-01f, 2.33007222e-01f, 1.56014875e-01f, 4.32363488e-02f, 8.78983084e-03f, 2.06226543e-01f, 2.46544614e-01f,
  1.34332264e-02f, 1.63842082e-01f, 7.01630041e-02f, 8.86647627e-02f, 2.46431842e-01f, -1.91890538e-01f, 2.16587707e-01f, -1.43868491e-01f, -2.41207242e-01f, 3.44752282e-01f,
  2.13777855e-01f, 2.00085016e-03f, 3.06580693e-01f, -6.27833381e-02f, 1.50027931e-01f, -1.75295159e-01f, -3.21520746e-01f, -1.13140970e-01f, -3.46459419e-01f, -2.13067472e-01f,
  2.07257301e-01f, 3.77087481e-02f, 1.43292829e-01f, 1.25433758e-01f, -4.78540808e-02f, 2.17677802e-01f, -1.96697220e-01f, -7.12648630e-02f, -6.25256856e-04f, 1.42751649e-01f,
  3.02466422e-01f, 3.22728336e-01f, -2.16437995e-01f, 2.68672407e-01f, 3.44608754e-01f, 3.25417751e-03f, 4.26926836e-02f, 2.24958301e-01f, -1.26675084e-01f, 3.64587247e-01f,
  1.56941757e-01f, 7.77160078e-02f, -3.38027954e-01f, 7.70213380e-02f, -1.47836953e-01f, 1.32708192e-01f, 1.18612796e-01f, 3.43240321e-01f, -5.16629294e-02f, 2.30347347e-02f,
  -3.20744328e-02f, 1.68102354e-01f, -2.11225137e-01f, -3.64752233e-01f, 1.50352880e-01f, 1.39266858e-02f, 2.54376065e-02f, 1.64405242e-01f, 2.06782937e-01f, 1.47473156e-01f,
  -2.96248436e-01f, -3.22093546e-01f, -1.55513538e-02f, -5.06414585e-02f, 1.49631664e-01f, -3.19543868e-01f, 3.01376313e-01f, 7.46998414e-02f, 2.18071625e-01f, 1.51517522e-02f,
  -3.74255069e-02f, 1.36100128e-01f, 3.96171182e-01f, 2.28357226e-01f, -2.06959248e-02f, 9.83382165e-02f, 1.31433263e-01f, -1.20490640e-01f, 2.38224790e-01f, -1.49446532e-01f,
  1.34760037e-01f, -3.92810963e-02f, -2.15638414e-01f, 1.92618623e-01f, 1.08238705e-01f, -9.69323590e-02f, 1.33122459e-01f, 2.44250834e-01f, 3.11129183e-01f, 1.05724163e-01f,
  1.70325711e-01f, 2.40345374e-01f, 1.25337213e-01f, -5.61631750e-03f, -3.98537904e-01f, -1.00569688e-01f, 1.44440368e-01f, 2.70700037e-01f, 8.49690065e-02f, 3.35096359e-01f,
  3.05629224e-01f, -2.89354920e-01f, 1.57304481e-01f, -1.35122389e-01f, -2.38541782e-01f, 1.38599023e-01f, -5.25290752e-03f, 4.31846268e-02f, 8.03962797e-02f, 3.35868031e-01f,
  -4.68351133e-02f, -8.43417570e-02f, -1.99849587e-02f, 2.91773528e-01f, 2.18397364e-01f, -2.82722354e-01f, -1.35963559e-01f, 3.02599847e-01f, 2.83575684e-01f, 3.71246576e-01f,
  3.16874951e-01f, 1.36081904e-01f, 1.07482418e-01f, 1.11093752e-01f, 1.42618343e-02f, 8.03776160e-02f, 7.10044578e-02f, 3.23743790e-01f, -1.82230011e-01f, 2.91482061e-01f,
  -3.04354519e-01f, 3.27477753e-02f, 9.45661291e-02f, -3.26259047e-01f, -2.84360116e-03f, 2.85120774e-02f, -2.05208734e-01f, 3.79906148e-01f, 2.21366897e-01f, 3.87543797e-01f,
  2.11734474e-01f, 1.35757431e-01f, -1.58053696e-01f, -4.71427180e-02f, -2.83795625e-01f, -2.19794318e-01f, 6.17336743e-02f, 2.40677781e-02f, -2.33631246e-02f, 6.22451082e-02f,
  2.04075500e-01f, -4.18145880e-02f, -8.37833527e-03f, 2.50717282e-01f, 2.70798981e-01f, 1.05368719e-01f, 1.08099692e-01f, -2.44026423e-01f, 1.18530452e-01f, 2.80028641e-01f,
  -1.10177100e-02f, 3.74783963e-01f, 2.80429870e-01f, -1.38684571e-01f, -4.62845191e-02f, 3.22379656e-02f, -9.90372673e-02f, 2.38336146e-01f, 2.38251194e-01f, 1.34164482e-01f,
  -2.85775840e-01f, 4.60013375e-02f, -7.18757510e-02f, -1.65794380e-02f, 1.80224150e-01f, 2.18878716e-01f, -1.61597356e-01f, 1.75252154e-01f, -4.14070301e-02f, 2.04330832e-02f,
  -2.50039190e-01f, -3.30419898e-01f, 6.63487911e-02f, 4.75242101e-02f, 9.55474675e-02f, 2.22258046e-01f, 1.74005046e-01f, 7.89977685e-02f, -5.81392124e-02f, 2.28213191e-01f,
  7.48268068e-02f, 1.55550793e-01f, -6.62588403e-02f, -1.66972578e-01f, -1.17748976e-01f, -1.46201834e-01f, -2.70411640e-01f, 2.03073785e-01f, -9.40560549e-02f, 2.19969377e-01f,
  -5.82883507e-02f, 6.67442679e-02f, 3.11112642e-01f, 2.53604561e-01f, 3.77787426e-02f, 1.97301880e-01f, -5.23599312e-02f, 3.51130396e-01f, 1.48700744e-01f, 8.66171941e-02f,
  8.94050151e-02f, 2.42701441e-01f, 6.10740297e-03f, -3.25506538e-01f, 2.35668004e-01f, 3.10308844e-01f, 3.93671960e-01f, -3.86582352e-02f, 5.34765869e-02f, 1.31833239e-03f,
  -2.42177561e-01f, 1.44821450e-01f, 2.37633511e-01f, 1.56799257e-01f, -2.62784332e-01f, 7.69184083e-02f, 1.08050238e-02f, -6.29987717e-02f, 4.16154563e-02f, 1.64582923e-01f,
  8.36855322e-02f, 3.67715329e-01f, 2.34671496e-02f, 9.02306437e-02f, 1.53366715e-01f, -1.09795295e-01f, -1.66715175e-01f, -2.31698498e-01f, 2.17820317e-01f, 3.58141959e-02f,
  3.51500772e-02f, 3.05634618e-01f, 6.16493896e-02f, 1.78077426e-02f, 2.50450790e-01f, -2.80219346e-01f, 1.80245414e-01f, -3.41032743e-02f, -1.20343082e-02f, 1.03924438e-01f,
  6.40406534e-02f, 1.89856648e-01f, 2.82414347e-01f, -6.72890572e-03f, 1.81991324e-01f, 3.27166826e-01f, -8.22398663e-02f, -3.23277488e-02f, 2.82561570e-01f, -1.31866261e-01f,
  2.32251495e-01f, 2.63560206e-01f, 3.44108716e-02f, 9.09826811e-03f, -2.97226161e-01f, -2.00677648e-01f, 2.34150380e-01f, -8.78626257e-02f, -2.31160954e-01f, 2.01424837e-01f,
  -2.97692001e-01f, -2.54395097e-01f, 2.02016070e-01f, 1.52303144e-01f, -5.72177395e-02f, 6.26946315e-02f, 2.89064229e-01f, -1.24875894e-02f, 4.44324940e-01f, 2.73164123e-01f,
  -1.96047783e-01f, -2.30210051e-01f, -6.69242209e-03f, 1.28082424e-01f, -2.28370726e-02f, 1.24276005e-01f, 2.65321642e-01f, 3.88108194e-01f, -4.19036686e-01f, -2.50421226e-01f,
  -1.33794680e-01f, 8.05120170e-02f, 1.08921871e-01f, 3.46662670e-01f, -7.99910456e-04f, 1.17809497e-01f, 7.91876242e-02f, -2.64059305e-01f, -2.30639547e-01f, 2.92724997e-01f,
  3.28889079e-02f, -2.49128759e-01f, -3.92363854e-02f, 2.49111906e-01f, -6.39771372e-02f, -5.51761985e-02f, -1.32484704e-01f, -9.72862020e-02f, 1.79186329e-01f, -1.51198544e-02f,
  2.98177242e-01f, 1.74905732e-01f, 1.42921880e-01f, 2.66942650e-01f, 3.15047592e-01f, 2.54751772e-01f, -1.41637743e-01f, -4.93479893e-02f, -9.55756530e-02f, 5.59680350e-02f,
  2.31766552e-01f, -1.11863747e-01f, -5.46797439e-02f, 8.50563794e-02f, 1.79232046e-01f, -1.91174686e-01f, 5.10107093e-02f, 2.52114743e-01f, 6.65490255e-02f, 2.02830091e-01f,
  -6.43272400e-02f, 2.62417257e-01f, 1.50650904e-01f, -6.53258637e-02f, 4.30385545e-02f, 6.45393804e-02f, -1.89075321e-01f, 5.85510805e-02f, 3.94492596e-01f, 3.01775247e-01f,
  1.07640453e-01f, 6.82575777e-02f, 2.51883771e-02f, 1.19352400e-01f, 1.39123186e-01f, 1.80452064e-01f, 2.62642741e-01f, 8.27273130e-02f, 7.51585811e-02f, -3.21194381e-02f,
  -1.35612071e-01f, 1.84962556e-01f, 6.53900802e-02f, 2.50017464e-01f, 4.30742614e-02f, -5.57805300e-02f, -1.50993504e-02f, 1.78894699e-02f, 1.42254114e-01f, -1.88455373e-01f,
  3.74333471e-01f, 8.65843445e-02f, 1.65668968e-02f, 2.14426979e-01f, 1.27606571e-01f, -2.05299318e-01f, -6.03846041e-03f, 2.00895891e-01f, 2.07430303e-01f, 2.38926355e-02f,
  -2.09005624e-01f, -2.62861382e-02f, -1.65603980e-01f, -2.27648243e-01f, 1.78356078e-02f, 1.98229849e-01f, 1.72894210e-01f, 2.50307262e-01f, -6.83832541e-02f, 6.86483234e-02f,
  -7.87185412e-03f, -2.70849764e-01f, -1.17303602e-01f, 1.28769964e-01f, -1.14545338e-01f, 2.61841208e-01f, 1.99899320e-02f, 1.26824588e-01f, -3.95627841e-02f, 3.36873502e-01f,
  -1.79171190e-01f, -1.96995780e-01f, 2.94195890e-01f, 3.97983909e-01f, 1.85037434e-01f, 1.82726294e-01f, 3.33103210e-01f, 5.58786131e-02f, 3.45210493e-01f, 9.53946337e-02f,
  -2.23740004e-04f, -9.99027938e-02f, -2.59826243e-01f, -1.47460133e-01f, 2.16282696e-01f, 8.35327134e-02f, -2.17994422e-01f, -2.48364329e-01f, 1.82160333e-01f, 3.31699073e-01f,
  2.28083223e-01f, -1.04936406e-01f, 1.92434546e-02f, -8.50660354e-02f, 2.13985279e-01f, -1.27975479e-01f, 2.87776202e-01f, 2.00065106e-01f, 2.28461012e-01f, 1.69182103e-02f,
  1.50391400e-01f, 3.19667578e-01f, -2.83878334e-02f, 1.21885754e-01f, -3.93136501e-01f, 3.35772127e-01f, -1.29083738e-01f, -2.63331413e-01f, -1.27687916e-01f, 3.57920468e-01f,
  2.22984523e-01f, -3.23932208e-02f, -3.30949783e-01f, 1.15099244e-01f, 1.92977905e-01f, -2.84885243e-02f, 1.59292206e-01f, 4.31414992e-02f, 5.60337082e-02f, -1.58376843e-02f,
  -2.35501584e-02f, -2.65807081e-02f, 3.07266088e-03f, 1.83179360e-02f, 7.23853782e-02f, 2.43098557e-01f, -5.48326001e-02f, -2.75892057e-02f, -1.24978863e-01f, 2.56968230e-01f,
  1.31486833e-01f, -1.01713397e-01f, 2.82427408e-02f, 1.97613969e-01f, 2.61749864e-01f, 2.94321984e-01f, 3.37332070e-01f, -1.87375452e-02f, 4.29513603e-01f, -1.68016538e-01f,
  4.30127293e-01f, 3.26511227e-02f, 8.58071595e-02f, -1.65028587e-01f, 1.51031107e-01f, 7.67907053e-02f, 1.18284047e-01f, -2.07504168e-01f, 3.44538689e-01f, -7.95515031e-02f,
  1.46566659e-01f, -5.82417957e-02f, 3.45549770e-02f, 8.81614536e-02f, -1.45908073e-01f, -5.18225580e-02f, 8.26857835e-02f, 2.00046211e-01f, 2.12341607e-01f, 1.05625037e-02f,
  3.84083390e-01f, -8.00618231e-02f, -7.76437521e-02f, 1.31066188e-01f, 3.16855013e-01f, 2.37256438e-01f, 1.77384928e-01f, 3.45819712e-01f, -3.52026820e-01f, 1.21176623e-01f,
  -1.70914859e-01f, 4.53968532e-02f, -2.06773877e-02f, 2.87183046e-01f, 1.35466307e-01f, -2.72947699e-01f, -8.12303126e-02f, -1.51624214e-02f, 3.65723297e-03f, 3.39358449e-01f,
  3.63657594e-01f, -2.80465111e-02f, 1.97468370e-01f, 9.61068124e-02f, 2.71829307e-01f, 2.67929345e-01f, 2.52055377e-02f, 1.94369048e-01f, 1.38850912e-01f, -1.96058884e-01f,
  6.85350597e-02f, 3.66665125e-02f, -6.87314719e-02f, 1.47645399e-01f, -1.05223455e-01f, 3.23587716e-01f, 2.49978215e-01f, -1.77431673e-01f, -3.33910286e-02f, -9.98667106e-02f,
  -4.74633723e-02f, 2.51222640e-01f, 1.74805790e-01f, 9.91498753e-02f, 7.68660009e-02f, -4.72952314e-02f, 2.29330674e-01f, -1.10771514e-01f, -4.94130552e-02f, -3.51696112e-03f,
  -1.42257720e-01f, -1.82632565e-01f, 2.36391351e-01f, 2.06158981e-01f, -1.67590380e-01f, -1.42975777e-01f, -7.89236277e-03f, 1.48128122e-01f, 1.45493969e-01f, 1.29497394e-01f,
  1.52730718e-01f, -2.68327296e-01f, 1.79250479e-01f, -1.11594256e-02f, 9.92571861e-02f, 1.97371900e-01f, 7.69086927e-02f, -1.07439704e-01f, -8.39844719e-02f, 2.23824218e-01f,
  -2.41623446e-01f, -2.58487672e-01f, 9.60518867e-02f, 2.53763139e-01f, -2.09778652e-01f, -6.82113022e-02f, 2.50241131e-01f, 2.08819285e-01f, 5.31806648e-02f, 2.76565284e-01f,
  -5.43234311e-02f, -1.55482993e-01f, 9.05169360e-03f, -2.01000106e-02f, -2.59003460e-01f, -1.16351098e-01f, 1.68918818e-01f, 1.36243239e-01f, 7.08361268e-02f, 4.39730287e-02f,
  2.25168899e-01f, 1.86209470e-01f, 1.00995138e-01f, 2.18563572e-01f, 3.14647108e-01f, -2.54318744e-01f, 1.98618412e-01f, -1.34552032e-01f, 1.38556167e-01f, -5.91077581e-02f,
  2.68016458e-01f, 4.87984754e-02f, 9.51146409e-02f, -3.67464349e-02f, -8.81096628e-03f, -2.63543010e-01f, -1.23410143e-01f, -7.73329362e-02f, 1.60782114e-01f, 1.59499243e-01f,
  -1.20865911e-01f, 2.18254805e-01f, 1.30859867e-01f, 3.05593997e-01f, -2.40712389e-01f, -4.37318981e-02f, 9.28629339e-02f, 5.22935912e-02f, 2.70260096e-01f, 1.05323814e-01f,
  2.22234190e-01f, -6.17868043e-02f, -1.38113037e-01f, 2.21658155e-01f, 2.06154242e-01f, 2.79152274e-01f, 3.26196626e-02f, 1.58663973e-01f, -2.88880169e-01f, -2.93037325e-01f,
  2.95880824e-01f, 1.22206002e-01f, 5.08681151e-05f, -2.26109013e-01f, 7.90516511e-02f, -3.76521572e-02f, 1.62652001e-01f, 1.24904208e-01f, 2.73978233e-01f, 6.05372153e-03f,
  2.83081234e-01f, -2.43271999e-02f, 2.02409208e-01f, 1.93853881e-02f, 3.92620377e-02f, -1.37285531e-01f, 1.41428873e-01f, 1.35921910e-01f, 3.09150934e-01f, 7.19170123e-02f,
  3.19297686e-02f, -1.77168846e-01f, -1.45747021e-01f, -4.84330878e-02f, -8.35897923e-02f, 4.15649787e-02f, 9.19166431e-02f, 7.16872662e-02f, -3.16598415e-02f, 1.17071040e-01f,
  -8.22582617e-02f, 1.03158928e-01f, -5.18408976e-02f, -3.37513894e-01f, -2.16131553e-01f, 5.06909847e-01f, 2.71981925e-01f, 1.49743304e-01f, 2.38308609e-02f, -9.58024636e-02f,
  3.84282112e-01f, -2.91601837e-01f, 3.21390741e-02f, -4.67914231e-02f, 2.68848419e-01f, 3.49095076e-01f, 1.14503093e-01f, 1.28852069e-01f, 3.29498947e-02f, -2.12083366e-02f,
  7.04505146e-02f, -3.10322046e-01f, 2.63554931e-01f, 2.78508570e-02f, 2.83664167e-01f, 2.36877888e-01f, -7.98175931e-02f, -9.29196775e-02f, -1.53793141e-01f, 1.28166616e-01f,
  3.30351293e-01f, 3.34999003e-02f, 1.51818991e-01f, -6.41541407e-02f, -3.86886187e-02f, -9.20197591e-02f, 3.00296992e-01f, 1.65320635e-01f, 2.11575627e-01f, 4.76806790e-01f,
  -2.54250735e-01f, -1.38715794e-02f, -4.69718268e-03f, 1.42677575e-01f, -2.07716018e-01f, -2.10103825e-01f, 1.50740057e-01f, -1.69147179e-02f, 1.86360285e-01f, 3.35816026e-01f,
  2.21586317e-01f, 2.38543049e-01f, 4.96837586e-01f, -6.33218363e-02f, 3.06184173e-01f, 2.13819221e-01f, 1.96450710e-01f, 3.02028865e-01f, 6.87503070e-02f, 3.20800155e-01f,
  1.29926279e-01f, 2.92536676e-01f, 1.30000427e-01f, 2.27460533e-01f, 6.24262877e-02f, 3.51595879e-01f, -4.00667012e-01f, 1.69019803e-01f, -8.38472508e-03f, 2.64717132e-01f,
  -8.89308378e-02f, -6.63561225e-02f, -3.31396699e-01f, 1.19648404e-01f, -7.25969002e-02f, 2.43370414e-01f, 2.05688626e-01f, 2.35966429e-01f, -2.56649047e-01f, 3.56753439e-01f,
  -1.77916586e-01f, 3.71867210e-01f, 3.30038816e-01f, 7.32159317e-02f, -1.50456317e-02f, 3.18923593e-01f, -4.00710702e-02f, -1.01120844e-01f, -1.52955800e-01f, -1.85207933e-01f,
  -2.99276888e-01f, 9.25314054e-02f, -5.66658154e-02f, -6.83164150e-02f, 3.56199294e-01f, 1.15713559e-01f, -2.39254683e-01f, -5.14110699e-02f, 6.72123358e-02f, -1.29717052e-01f,
  -3.80223393e-01f, 2.66460359e-01f, -2.59712160e-01f, -1.92526087e-01f, 4.27186847e-01f, -2.46971436e-02f, 1.92625329e-01f, 6.03121985e-03f, 2.22256988e-01f, -3.80506739e-02f,
  2.33197257e-01f, 2.21726552e-01f, 1.90552082e-02f, -4.03350353e-01f, 5.79969622e-02f, 1.01277001e-01f, 1.01849720e-01f, -8.37308988e-02f, 1.62738621e-01f, 1.22984067e-01f,
  1.19500890e-01f, 2.43469924e-01f, 2.88153261e-01f, 1.66445836e-01f, -2.45073973e-03f, 7.70648122e-02f, -3.48077230e-02f, -1.37903586e-01f, -1.15155533e-01f, 2.64170542e-02f,
  -2.84566671e-01f, 3.43441784e-01f, 2.45396178e-02f, 1.07475072e-01f, -1.56498253e-01f, 1.44869104e-01f, 1.38563618e-01f, 2.03503475e-01f, 1.29238337e-01f, 3.71169209e-01f,
  3.38726640e-01f, 1.91609472e-01f, 2.97410876e-01f, 4.04244959e-01f, -1.70102075e-01f, 7.03664869e-02f, 1.83842123e-01f, 1.85231902e-02f, -1.76264048e-01f, 2.87819624e-01f,
  -1.51855588e-01f, -3.67240123e-02f, 6.09049201e-02f, 4.19155583e-02f, -1.83955178e-01f, 4.88848202e-02f, -4.95687760e-02f, 5.19390032e-02f, -1.27820373e-01f, -1.03701584e-01f,
  1.68578759e-01f, 1.50769100e-01f, 2.76298612e-01f, -1.08697303e-01f, -2.91004539e-01f, -1.75379992e-01f, -6.55718893e-02f, 2.06935450e-01f, 7.37164468e-02f, 2.99794465e-01f,
  2.75889337e-01f, -1.69884518e-01f, 1.34724127e-02f, 1.41063243e-01f, 3.41844201e-01f, -3.73180002e-01f, -6.33208528e-02f, -3.21863294e-01f, 2.89787084e-01f, 1.58914160e-02f,
  1.27264634e-01f, 1.32028058e-01f, 1.99083522e-01f, 6.01431616e-02f, 2.07882717e-01f, 2.30397671e-01f, 6.21929020e-02f, 2.58612931e-01f, -2.30219975e-01f, -5.26740626e-02f,
  -2.96838861e-02f, -3.09468508e-01f, 1.29360199e-01f, -2.79643778e-02f, -1.46650091e-01f, 3.10267389e-01f, -1.03629239e-01f, 2.78585702e-01f, -1.62755311e-01f, -6.41751215e-02f,
  1.12660758e-01f, 2.76552379e-01f, -1.73139706e-01f, 2.31461860e-02f, 5.68156838e-02f, 1.73937142e-01f, 3.51573437e-01f, 1.99400425e-01f, 1.93374064e-02f, 2.87294574e-02f,
  2.61622190e-01f, 2.53395736e-03f, -2.41542220e-01f, 2.60696977e-01f, -3.55854750e-01f, -2.19641134e-01f, 3.10269669e-02f, -7.36183822e-02f, -7.40645677e-02f, 1.28920436e-01f,
  5.09382412e-02f, -2.11518914e-01f, -1.03992969e-01f, -2.77593851e-01f, -1.41288266e-02f, 1.38258904e-01f, -8.20607767e-02f, 5.63944355e-02f, -2.96270162e-01f, -3.27317774e-01f,
  -2.10274354e-01f, -4.10474949e-02f, 2.54089504e-01f, 2.05347598e-01f, 3.48087400e-01f, -5.30854613e-02f, 1.74255282e-01f, 1.35798886e-01f, 2.46087998e-01f, -2.31073841e-01f,
  4.72438186e-02f, -1.78150117e-01f, 3.60837907e-01f, 2.02202320e-01f, 1.22824505e-01f, 1.43815011e-01f, 1.94378734e-01f, 1.17721312e-01f, 7.41798729e-02f, 1.24449909e-01f,
  8.00372846e-03f, 1.09837510e-01f, -1.21465800e-02f, -1.67788699e-01f, 2.67511129e-01f, -1.04572121e-02f, 3.31125885e-01f, -1.64984345e-01f, 2.86443084e-01f, 4.19596396e-02f,
  2.24684566e-01f, -1.70890942e-01f, 1.99151829e-01f, -6.43412466e-04f, -1.87106162e-01f, -3.01488221e-01f, 1.95016321e-02f, -1.93675190e-01f, -1.81553468e-01f, 3.07018980e-02f,
  -7.59487003e-02f, -1.50547296e-01f, 1.60368644e-02f, -2.65725027e-03f, -7.41790384e-02f, -1.84841808e-02f, 1.83155730e-01f, 5.69902733e-02f, 1.76255301e-01f, 2.46911153e-01f,
  -3.10491741e-01f, -1.23694912e-02f, -3.29930261e-02f, -3.37553099e-02f, 9.49019194e-02f, 1.96418330e-01f, 1.21965431e-01f, 1.61182955e-01f, -3.31908673e-01f, 2.80431472e-02f,
  -1.36627883e-01f, 2.12605909e-01f, 1.32489204e-01f, 9.60549563e-02f, 2.30832919e-01f, 2.50795871e-01f, 3.53022069e-01f, -1.80956185e-01f, -1.22705199e-01f, 3.36564541e-01f,
  1.38813287e-01f, -1.03093401e-01f, -2.23018855e-01f, 4.05459672e-01f, 2.74574548e-01f, -4.72890921e-02f, -6.49615973e-02f, 2.25897074e-01f, -2.66356051e-01f, -1.62539557e-02f,
  2.77939320e-01f, 1.24556012e-01f, 8.98339897e-02f, 2.08242573e-02f, 1.77745953e-01f, 1.93839177e-01f, -6.13429397e-02f, 1.82998285e-01f, -3.09895039e-01f, -1.28620505e-01f,
  1.75059870e-01f, 1.70396566e-01f, -1.56021744e-01f, 2.91967422e-01f, -1.20028153e-01f, -2.55272448e-01f, 2.43550897e-01f, 3.29708010e-01f, 1.95747837e-02f, 2.88729727e-01f,
  -2.63624281e-01f, 2.03262657e-01f, 9.74713883e-04f, 9.45950672e-02f, 1.06111743e-01f, -2.51668133e-02f, -1.12544522e-01f, 1.05212331e-01f, 4.37758505e-01f, 3.56728405e-01f,
  1.17015268e-03f, 1.21717818e-01f, -1.65646240e-01f, -6.44954666e-02f, -1.45077407e-01f, 1.21635139e-01f, -2.13022187e-01f, -5.43213226e-02f, -1.50097862e-01f, 9.54986960e-02f,
  5.12996241e-02f, 2.12206542e-01f, 2.68740624e-01f, 3.06263149e-01f, -1.17142446e-01f, -1.40987173e-01f, -2.10780770e-01f, 3.65389325e-02f, -4.22103517e-02f, 1.38972923e-01f,
  4.59536582e-01f, 2.55147368e-01f, 2.55242407e-01f, 9.95986164e-02f, 3.13690417e-02f, -4.24149930e-02f, 1.17742841e-03f, 1.16197325e-01f, 2.69346267e-01f, -3.86938810e-01f,
  5.44418767e-02f, 1.02879539e-01f, -3.03078294e-01f, -1.04137950e-01f, 1.78023309e-01f, 1.97755501e-01f, 2.35253692e-01f, -3.97626013e-02f, -1.61567867e-01f, 1.81261346e-01f,
  1.03993326e-01f, 1.51653185e-01f, 1.56799614e-01f, 3.53399315e-03f, -3.14074785e-01f, 1.85100064e-01f, -4.32160348e-02f, 1.08489335e-01f, -5.56074940e-02f, 3.13496709e-01f,
  8.45113397e-02f, -2.13486016e-01f, 3.01746160e-01f, -1.66572973e-01f, 1.58509314e-01f, -2.27546036e-01f, 1.56435728e-01f, 2.89956301e-01f, 5.26778819e-03f, 3.10861140e-01f,
  1.12704985e-01f, 3.07985067e-01f, -1.23202384e-01f, -1.65029332e-01f, 2.61732608e-01f, 8.75821710e-02f, -6.15023002e-02f, -2.54016787e-01f, -4.26508598e-02f, -6.89219311e-02f,
  -1.92235157e-01f, 4.35584821e-02f, -8.73234570e-02f, -1.59178063e-01f, 3.26288998e-01f, -9.91378352e-02f, 2.86464304e-01f, -2.55325735e-01f, -9.05074626e-02f, 1.24000937e-01f,
  -1.37313619e-01f, 3.24650466e-01f, -1.67159766e-01f, -5.83801651e-03f, -5.48380951e-04f, 1.44020021e-01f, 1.26103267e-01f, -3.66512574e-02f, 1.85786769e-01f, 1.43711537e-01f,
  1.54598832e-01f, -2.42451318e-02f, -2.36844849e-02f, -2.82961577e-01f, 1.27515838e-01f, 2.54712343e-01f, 3.32541674e-01f, 2.03675956e-01f, 3.08053672e-01f, 1.66360974e-01f,
  2.14853927e-01f, 3.17198068e-01f, 9.60360467e-02f, 2.79065400e-01f, 2.36512467e-01f, 2.18060657e-01f, -6.22008070e-02f, 2.54154295e-01f, 2.19112281e-02f, -5.63473254e-02f,
  -2.03981176e-01f, -1.20172627e-01f, -2.37782106e-01f, 1.30503029e-01f, -1.75967917e-01f, 3.59710544e-01f, -1.00814447e-01f, -9.36382711e-02f, -1.59586608e-01f, 1.58896193e-01f,
  -8.70934799e-02f, 9.29664727e-03f, -3.83262895e-02f, 2.84630030e-01f, 1.33698791e-01f, 3.07215810e-01f, 3.84178549e-01f, 2.17034355e-01f, 1.41677797e-01f, 1.82851329e-01f,
  1.10667020e-01f, 1.86787602e-02f, 1.30236089e-01f, 1.97830066e-01f, 1.71570212e-01f, 3.33334893e-01f, -2.08051890e-01f, -1.01831011e-01f, 2.81419575e-01f, -7.56734610e-02f,
  1.62334695e-01f, 2.54046530e-01f, -1.12443723e-01f, -1.21753864e-01f, 1.84920609e-01f, 3.57470274e-01f, 2.39716202e-01f, -3.36231828e-01f, 4.16624874e-01f, -3.42507362e-01f,
  -8.67697001e-02f, 2.05756813e-01f, 8.98949206e-02f, -2.52187163e-01f, -8.41222256e-02f, 8.30004364e-02f, -9.35096517e-02f, 2.93134838e-01f, -1.82474121e-01f, -1.02795124e-01f,
  2.78262645e-01f, -6.37263656e-02f, 5.39670922e-02f, 1.73287988e-01f, 1.63207442e-01f, 1.18152365e-01f, -6.36521131e-02f, 7.94418231e-02f, -5.86061999e-02f, 1.20085195e-01f,
  -3.41100506e-02f, -7.56954998e-02f, -1.35614023e-01f, 2.17530817e-01f, 2.96138674e-01f, 2.50270125e-03f, 1.51741564e-01f, 2.41547257e-01f, 1.02768630e-01f, -3.85996215e-02f,
  1.75725654e-01f, -3.74172270e-01f, -2.16650546e-01f, -2.43124887e-01f, -1.26369134e-01f, 5.19339517e-02f, 3.41402590e-02f, 2.16332655e-02f, 3.42520326e-01f, 2.68558383e-01f,
  1.54496908e-01f, 6.33711591e-02f, 3.10563385e-01f, 2.21514076e-01f, -5.06478399e-02f, -4.02867235e-02f, -1.16365746e-01f, -1.22582883e-01f, -1.19013734e-01f, 9.94848832e-02f,
  2.54316181e-01f, 7.86361769e-02f, 1.80190712e-01f, -4.35184725e-02f, 3.18157643e-01f, -3.28679502e-01f, 5.47832586e-02f, 2.34218985e-01f, 2.93329880e-02f, 5.35095856e-02f,
  2.05075607e-01f, -2.05917299e-01f, 8.33649710e-02f, -2.95234844e-02f, 2.14821860e-01f, 1.98623553e-01f, 3.17992181e-01f, 1.76382169e-01f, -1.13233216e-01f, 1.58974096e-01f,
  2.39536077e-01f, -8.76801014e-02f, 2.15991646e-01f, 8.65736455e-02f, 2.80137897e-01f, 2.83492476e-01f, 2.53752381e-01f, 1.18208500e-02f, 1.77046701e-01f, 8.43376368e-02f,
  1.72088578e-01f, 1.21204361e-01f, 1.55952871e-01f, 1.26802564e-01f, -3.34761888e-01f, -4.94967811e-02f, -2.65563250e-01f, -2.79456645e-01f, -8.92864689e-02f, 1.39065295e-01f,
  -3.63562375e-01f, 8.66131708e-02f, -2.64912963e-01f, 3.80331129e-01f, 6.72909170e-02f, 1.69500872e-01f, 1.75154041e-02f, 2.51205921e-01f, 3.89288291e-02f, 7.68573508e-02f,
  -8.74314085e-02f, 1.37965769e-01f, 1.80530921e-01f, 4.44663167e-02f, 3.06326747e-01f, 2.26640284e-01f, 2.02039823e-01f, -1.44678846e-01f, 7.01767439e-03f, 8.67733508e-02f,
  1.38959035e-01f, 6.87071763e-04f, 2.88704783e-01f, -1.43997194e-02f, -2.04792812e-01f, 8.42347741e-02f, 1.49422318e-01f, -5.79348244e-02f, 2.97350287e-01f, 8.34681690e-02f,
  -5.15307523e-02f, -2.60398299e-01f, 5.40297553e-02f, 2.53068268e-01f, 8.50663781e-02f, -4.58702967e-02f, 4.57341634e-02f, 1.05505891e-01f, -8.68239179e-02f, -6.96258526e-03f,
  -1.95209295e-01f, -2.84378529e-01f, 6.00745156e-02f, -9.99935865e-02f, -2.72356141e-02f, 2.21964046e-01f, -2.32491478e-01f, -8.71156827e-02f, 2.03559890e-01f, -8.33172351e-02f,
  2.46019755e-02f, 5.19138202e-02f, 4.41784970e-02f, 6.95840567e-02f, 1.37288019e-01f, 9.04985070e-02f, -1.27219141e-01f, -1.52169198e-01f, 6.47612065e-02f, 3.15248990e-03f,
  2.65485168e-01f, -3.89413714e-01f, 2.35419169e-01f, -4.10967181e-03f, -1.76047795e-02f, -2.22131964e-02f, -2.24487796e-01f, -7.48077780e-03f, 2.03305766e-01f, 1.69860631e-01f,
  -2.84322917e-01f, 1.14275053e-01f, 7.45187104e-02f, -5.40161580e-02f, 3.31000894e-01f, 3.80371213e-02f, 1.83544189e-01f, -1.95255011e-01f, -5.43022640e-02f, 7.44262040e-02f,
  -9.77012888e-02f, -2.47012094e-01f, 2.69725591e-01f, 6.67284280e-02f, 2.12911487e-01f, 2.69716293e-01f, 3.24140906e-01f, 1.15168147e-01f, 5.48665375e-02f, 6.42717183e-02f,
  -3.07661563e-01f, -1.69855446e-01f, 6.13217354e-02f, 3.59442949e-01f, 2.15773255e-01f, 2.06159636e-01f, 2.72198260e-01f, -1.56187132e-01f, 2.21709251e-01f, -2.47744992e-01f,
  3.35069560e-02f, 1.52008869e-02f, -1.79862173e-03f, 1.57554865e-01f, -1.91150248e-01f, -1.22319534e-01f, 1.29479960e-01f, -2.74841278e-03f, -2.38303165e-03f, 3.02726060e-01f,
  1.42565325e-01f, -2.12696642e-01f, -1.60783067e-01f, 6.26563421e-03f, 2.80559450e-01f, 2.50109404e-01f, 1.32755548e-01f, 1.63218558e-01f, 1.32083029e-01f, 1.19057782e-01f,
  6.43763021e-02f, 8.72725341e-03f, 7.66078234e-02f, -5.87322116e-02f, 2.51901269e-01f, -1.16098247e-01f, -5.43681942e-02f, 4.05492960e-04f, 2.82816868e-02f, -2.14673281e-01f,
  2.49536708e-01f, 1.75366789e-01f, -6.15910627e-02f, -8.02441388e-02f, -3.23731899e-02f, -7.97065794e-02f, -1.84450611e-01f, -8.76086354e-02f, -5.64038157e-02f, 8.97092000e-02f,
  5.93025051e-02f, -1.50536180e-01f, 1.34678677e-01f, 2.66110718e-01f, -1.28808230e-01f, 2.24248394e-01f, 3.12096715e-01f, 2.55379766e-01f, 1.24778010e-01f, 2.65662491e-01f,
  1.19367063e-01f, 8.10971782e-02f, 5.62509410e-02f, 2.30096966e-01f, -1.52219161e-02f, 1.70669273e-01f, 2.13546634e-01f, 1.23738132e-01f, 1.18434746e-02f, 6.66869134e-02f,
  2.61415273e-01f, -2.65091598e-01f, 2.21266255e-01f, 1.31409198e-01f, 3.80756497e-01f, -1.42073959e-01f, 6.56068176e-02f, 1.70112252e-01f, 2.58084148e-01f, -1.50848791e-01f,
  -1.59135401e-01f, -1.18583329e-01f, 3.80750299e-01f, 4.04186606e-01f, -2.89537340e-01f, 2.38810509e-01f, -1.87051982e-01f, 1.12593979e-01f, 3.17808360e-01f, 1.22760773e-01f,
  3.49855199e-02f, 2.14669421e-01f, 7.40763992e-02f, 1.00446299e-01f, 2.65916854e-01f, 2.62349069e-01f, 7.48237967e-02f, 1.80429399e-01f, -1.61592230e-01f, 3.22972000e-01f,
  -2.33668849e-01f, -1.07981443e-01f, 2.01110952e-02f, 1.20407432e-01f, 2.27910653e-01f, 2.61923850e-01f, -2.09453374e-01f, 2.57922739e-01f, 3.62889588e-01f, 1.33762673e-01f,
  1.13694303e-01f, 1.65069073e-01f, -1.55281171e-01f, 1.74175963e-01f, -4.61245440e-02f, 1.78100139e-01f, 1.59289971e-01f, 2.21767426e-01f, 1.59965023e-01f, -8.45923740e-03f,
  1.52452230e-01f, 1.32416502e-01f, 3.34853567e-02f, 1.22142456e-01f, -1.19958758e-01f, -2.21491098e-01f, -2.41645187e-01f, 1.06932081e-01f, 2.66089112e-01f, 2.84022719e-01f,
  1.64138034e-01f, 6.08695745e-02f, -2.45383054e-01f, -5.79617918e-02f, 1.61046714e-01f, 4.08577055e-01f, 2.83722691e-02f, 1.17636606e-01f, 1.18479855e-01f, 6.37488440e-02f,
  -1.90511748e-01f, 1.64454848e-01f, -2.38189250e-01f, -1.58764869e-01f, 2.02306241e-01f, 1.98907837e-01f, 3.83579358e-02f, 8.13552812e-02f, -8.05698559e-02f, 3.15653533e-01f,
  9.06375498e-02f, -2.40986750e-01f, 2.29581386e-01f, 6.01147600e-02f, 1.67517424e-01f, 2.35237218e-02f, -1.42727431e-03f, 1.27988636e-01f, -4.10245173e-02f, -9.06248689e-02f,
  2.72415161e-01f, 2.39161104e-01f, 2.49047503e-01f, 2.65522957e-01f, -2.86792397e-01f, 1.78548723e-01f, 1.89963937e-01f, -2.48576209e-01f, 4.49806638e-02f, -3.42562586e-01f,
  -2.69121796e-01f, -1.30020633e-01f, -2.96831131e-01f, -1.90121099e-01f, -2.57791400e-01f, 1.79925188e-01f, 2.08909120e-02f, 2.16098260e-02f, -5.97069785e-02f, 1.15380846e-01f,
  5.63079417e-02f, 5.63670881e-03f, 5.35147265e-02f, 3.55996907e-01f, 3.44339609e-02f, -1.25954047e-01f, -3.22246671e-01f, 9.88811478e-02f, -2.25863501e-01f, 1.74168020e-01f,
  -7.28659853e-02f, -2.15525001e-01f, 1.14823334e-01f, 1.30736694e-01f, -1.51182815e-01f, 1.13526598e-01f, -9.50325951e-02f, -1.63922116e-01f, -4.18071985e-01f, -9.82350111e-02f,
  -3.98263298e-02f, -2.12641761e-01f, 3.19482833e-01f, -7.07002133e-02f, -2.71934774e-02f, 2.89931118e-01f, 2.41754413e-01f, -1.19579099e-01f, 1.48717538e-01f, 3.80259782e-01f,
  5.63813299e-02f, -3.10837626e-01f, 8.92322809e-02f, 1.92679256e-01f, -3.46328884e-01f, -3.02568320e-02f, 3.90327275e-02f, -4.82157543e-02f, 3.89219709e-02f, 4.43284698e-02f,
  -3.36126424e-02f, 1.37142450e-01f, 2.20228299e-01f, 8.74870922e-03f, 3.46715093e-01f, 4.08898294e-01f, 1.56197056e-01f, 2.84524769e-01f, -1.71742052e-01f, -2.49360576e-01f,
  -1.43693596e-01f, 2.44473606e-01f, 2.27520451e-01f, -2.51894861e-01f, -3.78575742e-01f, -1.27570510e-01f, 9.51058567e-02f, -2.34766260e-01f, -2.40055576e-01f, 8.12089518e-02f,
  -3.19451131e-02f, -1.11159645e-01f, 9.48866606e-02f, 2.98344284e-01f, 7.58401379e-02f, 4.22428995e-02f, 1.99106902e-01f, 2.76959110e-02f, 3.10826123e-01f, 8.29342157e-02f,
  -2.38106936e-01f, -9.17169899e-02f, -3.34780246e-01f, -1.86474510e-02f, -3.46589386e-01f, -4.58829999e-02f, 3.95723045e-01f, 4.36364263e-01f, -3.82405400e-01f, -2.27604099e-02f,
  -1.17585711e-01f, -2.38874301e-01f, 1.26884952e-02f, 3.52650493e-01f, -6.88743871e-03f, 2.26182863e-01f, 1.61643848e-01f, -1.13133281e-01f, -1.00208871e-01f, 2.59388626e-01f,
  -2.01716214e-01f, -1.06968187e-01f, -6.97340146e-02f, 4.78830427e-01f, 1.96387351e-01f, -4.94994111e-02f, -1.65812030e-01f, 1.80024952e-01f, 1.64021149e-01f, -1.07778572e-01f,
  -1.35897230e-02f, 1.03721760e-01f, 2.10362598e-01f, 1.04034863e-01f, 5.41954227e-02f, 1.36681378e-01f, -5.03224507e-02f, -2.12219637e-02f, -5.85906096e-02f, -3.66953830e-03f,
  -4.84807305e-02f, 2.13191241e-01f, 7.83194751e-02f, 1.49565518e-01f, 1.05946049e-01f, 5.99646792e-02f, 2.32385308e-01f, 1.11928932e-01f, 3.96398038e-01f, 1.95634484e-01f,
  1.66918591e-01f, -1.54660568e-01f, 4.35382545e-01f, 3.33612151e-02f, 1.30744278e-01f, 8.98993481e-03f, 1.44988939e-01f, 1.41287833e-01f, -5.54479212e-02f, -9.12801102e-02f,
  3.77963126e-01f, -1.40096337e-01f, -2.34617312e-02f, -1.13819890e-01f, 2.58815885e-01f, 2.58718550e-01f, 9.79707763e-02f, -9.22010019e-02f, 2.74902612e-01f, 4.26251218e-02f,
  5.70832789e-02f, -1.59740627e-01f, 4.03059870e-01f, 1.56429932e-01f, 3.69393766e-01f, 1.95845842e-01f, 1.23706251e-01f, 2.90160179e-01f, 2.12764323e-01f, 1.49790928e-01f,
  -2.19784901e-01f, 1.67177051e-01f, -7.60169327e-02f, -4.07405235e-02f, -9.75561291e-02f, 1.37013346e-01f, 1.61610946e-01f, -2.79307723e-01f, -1.49269804e-01f, -2.00364683e-02f,
  2.42945537e-01f, 1.68040588e-01f, 2.31496245e-01f, 5.13256676e-02f, -4.66207527e-02f, -2.43342994e-03f, 2.14178100e-01f, 1.24722511e-01f, 5.59789091e-02f, 1.16628088e-01f,
  5.03786206e-02f, -1.94374338e-01f, -2.33931825e-01f, 1.15229962e-02f, -2.46572599e-01f, -2.04743207e-01f, 7.61055797e-02f, 1.75688446e-01f, 1.75180331e-01f, 2.74885058e-01f,
  -3.38438936e-02f, -9.11079422e-02f, 1.65176913e-01f, 7.80212358e-02f, 4.16828990e-01f, 1.20295212e-01f, -6.82728961e-02f, -2.55531427e-02f, 1.24894030e-01f, 4.79460023e-02f,
  3.90330225e-01f, -1.70593932e-01f, -3.41512859e-01f, -1.35984063e-01f, 1.26473501e-01f, 8.52341950e-02f, -2.84345970e-02f, 1.53721020e-01f, 2.01037824e-01f, 2.18041018e-01f,
  3.62270325e-01f, 4.84708995e-02f, 1.88303962e-01f, 8.40488076e-02f, 2.12335721e-01f, -5.61985373e-02f, 3.26579839e-01f, 3.18246931e-01f, 1.34222899e-02f, 3.57958704e-01f,
  3.34122837e-01f, 1.84492260e-01f, -1.07105337e-01f, -1.30605087e-01f, -2.12738112e-01f, 2.34824002e-01f, -2.95411319e-01f, -5.28564341e-02f, 4.66758758e-02f, 3.24785888e-01f,
  -1.67699352e-01f, -8.20246562e-02f, -1.77943558e-01f, 4.00168628e-01f, 1.02081895e-01f, -8.72543734e-03f, -6.49129897e-02f, 3.39546710e-01f, 2.21839085e-01f, 2.36624181e-01f,
  2.81004161e-01f, 1.83134571e-01f, 1.78251609e-01f, 1.54389098e-01f, -1.63691819e-01f, 5.66504970e-02f, 1.15221106e-02f, -1.68888822e-01f, -9.04279063e-04f, -1.58399597e-01f,
  2.19325110e-01f, 4.37319338e-01f, 2.25366041e-01f, -3.61258984e-02f, -4.45793010e-02f, -1.41062498e-01f, 3.31143811e-02f, 1.63612142e-01f, -8.11854079e-02f, 2.98714787e-01f,
  2.08443061e-01f, 2.14462548e-01f, 1.85690165e-01f, 9.41980928e-02f, 8.46082624e-03f, -3.41704790e-03f, -2.92244367e-02f, 3.78998346e-03f, -8.89311135e-02f, 1.95266858e-01f,
  6.62702369e-03f, 5.06334901e-02f, 2.43899167e-01f, 1.51235461e-01f, 9.33545604e-02f, 1.95745990e-01f, 3.02541792e-01f, 1.25492103e-02f, -2.61842608e-01f, -1.02000915e-01f,
  2.87439972e-02f, 8.10207650e-02f, 1.61443472e-01f, 3.12680364e-01f, -9.89517048e-02f, -2.13368535e-01f, -8.41534808e-02f, 3.31836916e-03f, 2.86932234e-02f, 3.70774031e-01f,
  1.84091538e-01f, -1.22696474e-01f, 2.20246971e-01f, 2.93907672e-01f, 2.79796749e-01f, -1.09638184e-01f, -6.01988398e-02f, -1.27817821e-02f, 7.21871480e-02f, -9.57310647e-02f,
  1.07277714e-01f, 3.22315007e-01f, 1.50733590e-02f, 2.34710440e-01f, 2.24841252e-01f, 1.68803111e-01f, 1.55346170e-01f, 1.52322069e-01f, -1.36281833e-01f, -3.12574029e-01f,
  7.86712840e-02f, -4.42311950e-02f, 1.51955724e-01f, -2.29505077e-01f, 3.49615514e-01f, 1.61832035e-01f, 3.21137339e-01f, -2.26157919e-01f, 7.37457797e-02f, -2.53526092e-01f,
  -1.04675613e-01f, -2.58757532e-01f, 1.83461517e-01f, -2.06354350e-01f, -2.30707169e-01f, -9.48339254e-02f, -8.22896734e-02f, 4.43728501e-03f, 3.66116107e-01f, -1.59507409e-01f,
  -2.77487010e-01f, 7.95591846e-02f, -1.14242002e-01f, 6.31599128e-02f, 1.28162250e-01f, 3.53421450e-01f, -1.41152740e-01f, -4.64323908e-02f, 2.06129044e-01f, 2.95426011e-01f,
  1.29239470e-01f, 1.32791460e-01f, 9.95830297e-02f, 2.20004603e-01f, -1.91180959e-01f, 6.86683804e-02f, 1.02485679e-01f, 3.87286305e-01f, 1.21604308e-01f, -1.43155351e-01f,
  8.34775716e-02f, 9.44211259e-02f, 2.62950748e-01f, -6.50048256e-02f, -1.38296857e-01f, 2.19845831e-01f, 3.62266868e-01f, 9.82012972e-02f, -1.37416586e-01f, 3.50639164e-01f,
  2.45352089e-01f, 1.44359469e-01f, -4.54546660e-02f, -8.77430290e-02f, -2.60426581e-01f, 3.82386655e-01f, 1.63132146e-01f, 1.88666910e-01f, 2.72620171e-01f, 7.02904463e-02f,
  -1.05169863e-02f, 1.51656032e-01f, 2.97090918e-01f, 1.39929146e-01f, 1.14406563e-01f, 2.52772328e-02f, -9.23115760e-02f, 2.97768831e-01f, -1.97393388e-01f, 3.00111830e-01f,
  2.06472334e-02f, 4.60752845e-01f, -2.33553320e-01f, -6.75065070e-02f, -8.64324570e-02f, -1.44983083e-01f, 8.47987831e-02f, -1.99821666e-01f, -1.31354436e-01f, 2.09083930e-01f,
  -4.48714290e-03f, 2.59017527e-01f, 1.19070366e-01f, 3.09175521e-01f, -4.26555201e-02f, -2.18213901e-01f, 1.08492203e-01f, 2.06254482e-01f, -2.21662119e-01f, -4.39042822e-02f,
  -1.08931109e-03f, -1.80091858e-01f, -1.02067687e-01f, 1.57026932e-01f, 3.02267894e-02f, -1.96897909e-01f, 2.65666127e-01f, -1.06255092e-01f, 3.01011294e-01f, -2.72534937e-01f,
  -8.82054716e-02f, -2.59504095e-02f, -1.62026808e-01f, 1.45385593e-01f, -2.58946627e-01f, -3.03894669e-01f, 1.39072746e-01f, -6.89691380e-02f, 5.07733896e-02f, 1.26976185e-02f,
  1.36186823e-01f, 2.04490781e-01f, 1.54540747e-01f, 3.97848152e-02f, -4.49836999e-02f, -2.26876944e-01f, 1.55374613e-02f, 9.76998657e-02f, 3.13314021e-01f, 1.22581422e-01f,
  1.21257998e-01f, 9.08924714e-02f, 7.09625259e-02f, 2.23643050e-01f, 4.73492071e-02f, -1.15911327e-02f, -1.28795877e-01f, 2.62831170e-02f, -1.61853760e-01f, -1.45196319e-01f,
  1.89034924e-01f, 9.59714279e-02f, -3.30254942e-01f, 3.10894400e-01f, 2.00082272e-01f, 1.40684266e-02f, 6.91477433e-02f, -2.06744805e-01f, 3.45181562e-02f, 2.43633762e-01f,
  1.23568848e-01f, 7.37025291e-02f, 2.80532837e-01f, 4.75130044e-02f, 3.66311997e-01f, 2.08730906e-01f, 5.09539153e-03f, -1.88513726e-01f, -1.99809477e-01f, -9.96151865e-02f,
  -3.85608003e-02f, 3.27562064e-01f, -4.09547746e-01f, -3.97844702e-01f, 5.55178151e-02f, 1.60448834e-01f, -2.72985011e-01f, 7.62636438e-02f, 6.12883903e-02f, -2.30226561e-01f,
  -2.74601835e-03f, -1.83108017e-01f, 2.41959602e-01f, 1.87704355e-01f, 1.84877813e-01f, -7.87691250e-02f, -1.73142970e-01f, -1.29998341e-01f, -2.36178458e-01f, -1.74303423e-04f,
  2.13428214e-01f, 4.38631326e-01f, 1.88245058e-01f, -1.34597793e-01f, 2.79520005e-01f, 2.10325569e-01f, 3.16249460e-01f, -2.52441198e-01f, -6.57100976e-02f, -2.73545384e-01f,
  2.80560851e-01f, 1.21383280e-01f, -2.51745582e-01f, 1.58863097e-01f, 1.77588332e-02f, 1.98202115e-02f, 5.66658229e-02f, 1.71446756e-01f, 2.55921155e-01f, -8.14716052e-03f,
  -2.50302285e-01f, -2.61926740e-01f, -2.95649171e-01f, -5.22942953e-02f, 2.95001596e-01f, -2.47304499e-01f, 2.54448745e-02f, 1.38339162e-01f, -3.87471646e-01f, -4.18266207e-02f,
  4.25711237e-02f, 2.88425028e-01f, -4.08661552e-02f, 2.41423517e-01f, -9.63924155e-02f, 2.90496111e-01f, -2.68329438e-02f, -8.82109106e-02f, 2.17341557e-01f, 1.72799721e-01f,
  -1.78489774e-01f, -2.73960859e-01f, 2.70088792e-01f, 4.13774937e-01f, -1.87423453e-01f, -2.29565233e-01f, 8.35422575e-02f, 2.17346892e-01f, 2.25529999e-01f, 2.66069412e-01f,
  1.88998908e-01f, -7.06626847e-03f, -2.57056594e-01f, 2.02007946e-02f, -1.57536998e-01f, -2.98280027e-02f, -4.21123132e-02f, 4.09579694e-01f, -6.89766407e-02f, -1.40244827e-01f,
  1.48925036e-01f, -1.44831657e-01f, 1.05971240e-01f, 5.33234552e-02f, -6.09705634e-02f, 5.78487553e-02f, 4.18427400e-02f, 2.35495586e-02f, -3.12956035e-01f, 1.08284079e-01f,
  -4.66348790e-02f, -3.12474966e-02f, 2.41593458e-02f, 2.72223622e-01f, 4.88365553e-02f, -1.74659002e-03f, -3.28718126e-01f, 1.18644461e-01f, -1.20241836e-01f, 7.10371556e-03f,
  7.71519318e-02f, -6.67238608e-02f, 7.45518357e-02f, 8.77661929e-02f, -1.88743114e-01f, -2.28631482e-01f, 1.06759191e-01f, -7.22292513e-02f, 1.47800654e-01f, 1.98149141e-02f,
  1.91399939e-02f, -1.34443834e-01f, -1.78820893e-01f, 2.65142679e-01f, 1.97419301e-01f, -4.65760427e-03f, 1.89446285e-01f, 2.18227103e-01f, -2.38152891e-02f, -1.34184808e-01f,
  1.92183390e-01f, 3.02281603e-02f, 3.35007310e-01f, 1.93253443e-01f, -2.27650344e-01f, 2.55764484e-01f, 9.25943330e-02f, -1.20422088e-01f, 5.44774011e-02f, -1.94867715e-01f,
  1.60186112e-01f, -5.93045689e-02f, 2.78980285e-01f, 3.44602257e-01f, -1.04474947e-01f, 1.86430942e-02f, -2.79437691e-01f, -5.17985150e-02f, 3.00040934e-02f, -2.48481594e-02f,
  -6.52459040e-02f, 3.16088885e-01f, 2.90611118e-01f, -3.88857014e-02f, 6.75873179e-03f, 1.79273204e-03f, 1.74481660e-01f, 3.53024930e-01f, -1.47991538e-01f, 7.65801296e-02f,
  1.27248511e-01f, 5.32627515e-02f, -3.06096733e-01f, 8.06102678e-02f, 2.64424324e-01f, -1.72877893e-01f, 3.26583311e-02f, 1.14108421e-01f, 3.70158613e-01f, 2.45596811e-01f,
  1.16066702e-01f, -2.96349563e-02f, 2.87075549e-01f, 1.28338173e-01f, 1.99417591e-01f, 2.07907215e-01f, 1.54594958e-01f, 1.70985654e-01f, 6.97612241e-02f, 1.23906858e-01f,
  1.70037344e-01f, 1.65981427e-02f, -1.54642597e-01f, 4.13218766e-01f, -2.38495693e-01f, 1.45372435e-01f, 5.63339777e-02f, 4.33848053e-02f, 1.18417136e-01f, 1.80520251e-01f,
  -1.23675719e-01f, 1.88409895e-01f, -2.62588352e-01f, 3.03456515e-01f, 1.62860185e-01f, 3.47694039e-01f, -1.08029179e-01f, 3.05948257e-01f, -3.79198670e-01f, 2.80810624e-01f,
  3.68921518e-01f, 1.77386299e-01f, -4.69071083e-02f, 3.14576477e-01f, -4.46659029e-02f, -4.66434732e-02f, 7.63004497e-02f, 9.12253857e-02f, -1.97041318e-01f, 1.22262157e-01f,
  1.88725814e-02f, -2.27699116e-01f, 1.82416245e-01f, 1.62890762e-01f, -2.23813131e-01f, -1.11113511e-01f, 2.51983833e-02f, -2.31697291e-01f, -3.15268457e-01f, -3.63348536e-02f,
  -7.60568231e-02f, 1.40320286e-01f, 4.32654113e-01f, 1.70344993e-01f, 2.76258141e-01f, 7.29024634e-02f, 1.07549988e-01f, -1.71544790e-01f, 3.89677316e-01f, 3.61129284e-01f,
  2.55565881e-03f, -3.05733621e-01f, 1.82660058e-01f, 7.53669590e-02f, 1.51925400e-01f, -1.36531919e-01f, 1.99380562e-01f, 8.60823542e-02f, 1.82293430e-01f, 8.06789007e-03f,
  1.55941278e-01f, 1.17827348e-01f, 1.55726466e-02f, 2.64676690e-01f, -4.25052084e-02f, -2.06082240e-01f, 1.46145239e-01f, -1.33459240e-01f, -4.77430895e-02f, 1.34847477e-01f,
  2.51802355e-01f, -2.06039876e-01f, 2.69640356e-01f, 1.84955448e-01f, -5.57400770e-02f, -3.51434797e-02f, 1.89045504e-01f, 1.77694291e-01f, 6.12815358e-02f, 1.23724498e-01f,
  -1.31307453e-01f, 1.39750242e-01f, -9.05129761e-02f, 3.54821049e-02f, 2.23750532e-01f, 8.00333694e-02f, 2.16522515e-02f, 1.20146334e-01f, 2.08887056e-01f, 2.53728807e-01f,
  -1.90620013e-02f, 5.42626344e-02f, -2.23921582e-01f, -1.51617363e-01f, 2.05144718e-01f, 2.95838386e-01f, 8.35361797e-03f, 2.58056849e-01f, -5.43547198e-02f, -4.26840559e-02f,
  -7.26939691e-03f, 9.38695744e-02f, 4.31808643e-02f, -2.17579007e-01f, 1.49752796e-01f, 3.59585911e-01f, 1.41058505e-01f, 2.95601524e-02f, 7.59169385e-02f, 1.95454098e-02f,
  2.08429191e-02f, -1.29898950e-01f, -3.16056572e-02f, -1.15128821e-02f, 3.09162915e-01f, 6.67827055e-02f, -1.81168482e-01f, 2.36662060e-01f, -9.60569382e-02f, -6.43891469e-02f,
  2.94791870e-02f, -5.55273853e-02f, 8.94913301e-02f, 1.54402807e-01f, 3.91869769e-02f, 2.32651502e-01f, 2.95143187e-01f, 2.83804387e-01f, -2.14601215e-03f, -4.99365777e-02f,
  -1.27824143e-01f, 2.38347650e-01f, -8.47250447e-02f, 1.24068923e-01f, -5.42287752e-02f, 7.16991499e-02f, 2.21746206e-01f, 2.25249872e-01f, 6.02970691e-03f, 1.74087480e-01f,
  1.87431574e-01f, 5.40050231e-02f, 3.75180334e-01f, 8.07000026e-02f, 2.21763998e-02f, -1.99589673e-02f, -8.89955461e-02f, 1.26784459e-01f, 4.98359986e-02f, -1.83834046e-01f,
  2.63199270e-01f, -1.20624326e-01f, -1.60273593e-02f, 5.60689643e-02f, -2.19281197e-01f, 1.24141179e-01f, -1.44266620e-01f, -1.47251919e-01f, 1.24383852e-01f, 1.11747161e-01f,
  3.07011068e-01f, -3.53062190e-02f, 3.28595102e-01f, -1.34262145e-01f, 2.51662403e-01f, -1.87647954e-01f, 1.27062827e-01f, 3.52516741e-01f, 8.54761899e-02f, 2.67838776e-01f,
  -2.47751683e-01f, 5.16385809e-02f, -1.00013532e-01f, -1.81892261e-01f, -2.98781861e-02f, 1.62343867e-02f, 2.19192505e-01f, -2.08186179e-01f, 1.12654693e-01f, -1.09089501e-02f,
  -1.88316405e-01f, 1.92674071e-01f, 1.10987045e-01f, -1.47379532e-01f, 2.00909376e-01f, 1.19633980e-01f, 2.15120707e-02f, 1.11566976e-01f, 3.96521315e-02f, 6.36721477e-02f,
  -1.41643882e-01f, -1.38735026e-01f, -1.35406017e-01f, 1.17703833e-01f, 9.55834612e-02f, 7.70560056e-02f, -7.88245946e-02f, 1.03385299e-01f, -1.36122793e-01f, -4.71989848e-02f,
  -8.71714726e-02f, 1.17628900e-02f, 1.13204233e-01f, 1.93140894e-01f, 2.79279947e-01f, 3.38341802e-01f, 3.66154611e-01f, 6.34431839e-03f, 3.82081419e-01f, 2.62515470e-02f,
  -2.38530591e-01f, -1.91914231e-01f, 6.06009215e-02f, -3.07101421e-02f, 1.10093839e-01f, -5.55013604e-02f, -1.32982375e-03f, -2.62491107e-01f, 6.38760999e-02f, 1.56674579e-01f,
  -1.27112955e-01f, -2.06835046e-01f, -5.49897999e-02f, -2.68625706e-01f, 1.38676047e-01f, 2.87059154e-02f, 6.53899983e-02f, 2.60155916e-01f, 3.53621215e-01f, -6.71718493e-02f,
  -1.24194279e-01f, 2.00076085e-02f, -5.94337992e-02f, 2.09580027e-02f, -1.66350871e-01f, 3.91070157e-01f, 5.65386824e-02f, -9.37825367e-02f, -1.56526297e-01f, 1.00825347e-01f,
  2.83452451e-01f, 2.65693516e-01f, -1.30719975e-01f, -1.23019904e-01f, 2.26541862e-01f, -1.04935594e-01f, -9.36649442e-02f, -1.24307618e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 52)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 52;
const float L1_fan_Bp_bar_data[] = {
  7.24970549e-02f, 1.33573696e-01f, 1.16940640e-01f, 2.74034441e-01f, 2.78853774e-01f, 1.99399099e-01f, 7.83505291e-02f, 2.00521961e-01f, 2.98838969e-02f, 4.97735888e-02f,
  -7.47029483e-02f, 1.74218625e-01f, 1.44188568e-01f, 8.18510056e-02f, 1.70347333e-01f, 2.24219531e-01f, 1.82554469e-01f, 1.47830680e-01f, -2.26354375e-02f, 1.31369203e-01f,
  1.43525779e-01f, 2.33199894e-01f, 1.18928716e-01f, 1.27943620e-01f, 8.65812600e-02f, 1.59556549e-02f, 2.54651040e-01f, 2.83990413e-01f, 3.21510397e-02f, 1.49013132e-01f,
  2.67904222e-01f, 1.96588352e-01f, 2.75746107e-01f, 2.04037309e-01f, 5.42883947e-02f, 2.36649111e-01f, 1.82557568e-01f, 2.71020204e-01f, 1.52813662e-02f, 2.54257917e-01f,
  -2.09896415e-02f, 2.31832296e-01f, 2.71174461e-01f, 1.61801919e-01f, 2.04494461e-01f, 1.75496086e-01f, -1.81209464e-02f, 1.11906789e-02f, 1.40753210e-01f, 1.83319137e-01f,
  6.58484995e-02f, 1.37316257e-01f
};

// L2_linear_W (Shape: 12 x 64)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 64;
const float L2_linear_W_data[] = {
  -3.79423425e-02f, -1.51929036e-01f, 1.06476195e-01f, 4.70356829e-02f, 9.38201882e-03f, -1.49397492e-01f, -1.77656546e-01f, 2.58376539e-01f, -6.23916164e-02f, 3.53493929e-01f,
  1.06723227e-01f, 4.94397394e-02f, -1.37474099e-02f, 2.24133372e-01f, -7.42498040e-02f, 2.43962765e-01f, -6.08834401e-02f, -3.84075791e-01f, 2.87691832e-01f, -4.07739542e-04f,
  4.38480347e-01f, -1.46217093e-01f, 4.98887561e-02f, -2.72255778e-01f, -1.63676992e-01f, -2.83526450e-01f, 1.50350139e-01f, -4.35512006e-01f, 1.94544166e-01f, -2.32792899e-01f,
  -2.71464795e-01f, -2.56661803e-01f, -4.22072917e-01f, 1.77804187e-01f, 1.42547667e-01f, 8.42245296e-02f, -1.48345575e-01f, -1.73474938e-01f, -2.72767752e-01f, -1.33314624e-01f,
  3.39785293e-02f, -2.45589644e-01f, -2.79885769e-01f, 2.09976450e-01f, -2.40392089e-01f, 2.36690745e-01f, -1.63869977e-01f, -1.03334241e-01f, -2.10577637e-01f, -3.70692760e-01f,
  -1.55743614e-01f, -1.11188464e-01f, 1.35966405e-01f, 3.75800014e-01f, 7.58594498e-02f, 1.43810764e-01f, 8.02924484e-02f, 7.42035583e-02f, -2.24940479e-01f, -2.90849298e-01f,
  -4.10990000e-01f, -3.53801548e-01f, -3.30485940e-01f, -1.61589786e-01f, -8.57997015e-02f, 7.77870789e-02f, -1.31200403e-01f, 1.22390613e-01f, -1.56258672e-01f, 8.56966004e-02f,
  -2.77313262e-01f, 2.59295106e-01f, -1.15978464e-01f, 3.61601599e-02f, 7.60434568e-02f, 2.23758340e-01f, 4.58302163e-02f, 2.28235662e-01f, 3.28451425e-01f, -4.71289545e-01f,
  2.56783187e-01f, 4.66817692e-02f, -2.87537068e-01f, -3.06044996e-01f, 5.09361438e-02f, -4.58363518e-02f, -2.67593473e-01f, -1.06419370e-01f, 3.14578801e-01f, 1.57008499e-01f,
  2.22923338e-01f, -3.86970788e-02f, 2.26810783e-01f, -3.19945455e-01f, -1.82588860e-01f, 2.41826937e-01f, 7.88354874e-02f, -4.54845607e-01f, -1.67010739e-01f, -5.91483675e-02f,
  2.83421755e-01f, -3.83799255e-01f, -2.96781629e-01f, -3.36434692e-01f, -4.13740426e-01f, 2.11965635e-01f, -4.60102171e-01f, -2.22124949e-01f, -1.90734699e-01f, 1.41912788e-01f,
  -2.63273090e-01f, 8.65695179e-02f, 8.54091421e-02f, -4.40788925e-01f, -1.12883970e-01f, -3.19972545e-01f, -3.00015626e-03f, 2.54097246e-02f, 1.58045158e-01f, 3.16594601e-01f,
  -3.18276674e-01f, -2.19655886e-01f, -1.21560968e-01f, -1.38628826e-01f, -3.24259430e-01f, 6.30469024e-02f, -2.55732596e-01f, -2.71486431e-01f, 1.74194146e-02f, 1.68362129e-02f,
  -1.23200580e-01f, -9.36401114e-02f, -8.42880756e-02f, 1.61921456e-02f, 8.83786753e-03f, 9.24964920e-02f, 1.90105364e-02f, -2.34647527e-01f, -1.13098938e-02f, 1.35441154e-01f,
  -7.61696547e-02f, -3.17850590e-01f, 2.44186848e-01f, -1.19287841e-01f, -2.56288320e-01f, -5.82155064e-02f, -2.39702418e-01f, -8.18112865e-02f, 8.33146051e-02f, -1.89118996e-01f,
  9.93783921e-02f, -3.50340456e-01f, 1.92674786e-01f, 1.88916817e-01f, 1.29340127e-01f, 2.75130987e-01f, -3.51909310e-01f, 2.32543442e-02f, 3.02208990e-01f, 2.63172269e-01f,
  -2.25926891e-01f, -3.07672530e-01f, 1.56774953e-01f, -4.13273215e-01f, 1.26804113e-02f, 3.43546152e-01f, -2.53207594e-01f, -1.36194393e-01f, -1.14928782e-01f, 2.42509559e-01f,
  -2.94754028e-01f, 5.46978728e-04f, -2.76881993e-01f, -2.57072747e-01f, -2.22848102e-01f, -3.25694233e-01f, 1.31639883e-01f, 2.91778654e-01f, -1.87729299e-01f, 3.43401343e-01f,
  -3.13625634e-01f, 2.64620278e-02f, -3.81647378e-01f, 2.07836136e-01f, -3.05130512e-01f, -1.42667338e-01f, 7.63970912e-02f, 8.19925871e-03f, -3.47599506e-01f, 2.67628938e-01f,
  1.64433084e-02f, -3.86743098e-02f, -4.65828180e-02f, 2.96248738e-02f, 1.04342446e-01f, 1.10435158e-01f, -9.88174379e-02f, -3.68900001e-02f, 1.00878768e-01f, -1.72105417e-01f,
  2.66151369e-01f, -3.71830255e-01f, -2.16572136e-01f, 1.52829155e-01f, -2.89632659e-02f, -2.59811252e-01f, -2.32869908e-01f, -6.25436231e-02f, -5.34086943e-01f, -2.11811006e-01f,
  -2.91704535e-01f, -1.42546624e-01f, -3.37880671e-01f, 2.25310028e-01f, 4.64546531e-01f, 2.71791089e-02f, -2.29002923e-01f, -4.28129464e-01f, -8.65518898e-02f, 5.20498939e-02f,
  1.24655180e-01f, -1.46448255e-01f, -1.61081403e-01f, -1.06672853e-01f, 4.22996730e-02f, 2.61846781e-01f, -2.16881678e-01f, 2.17686817e-01f, -3.94870877e-01f, -1.59386024e-01f,
  -3.19745570e-01f, 2.13860422e-01f, 2.95384467e-01f, -1.38384566e-01f, 2.28948429e-01f, -4.10256118e-01f, -2.89472461e-01f, -2.94144124e-01f, -3.37686576e-02f, 1.84119612e-01f,
  -2.85876036e-01f, -3.93091321e-01f, -2.30437279e-01f, 2.13555489e-02f, 2.85263956e-02f, 1.25865832e-01f, 1.44227386e-01f, -2.13703483e-01f, -4.52259600e-01f, 3.05532426e-01f,
  2.46855110e-01f, 2.14224920e-01f, -1.47932380e-01f, -3.20363939e-01f, -2.20289901e-01f, 3.91275346e-01f, 1.21555753e-01f, 1.25539079e-01f, 1.14396475e-01f, 9.75649357e-02f,
  -2.19872855e-02f, -1.66208252e-01f, 2.32788231e-02f, 2.14535549e-01f, 2.49117509e-01f, -1.93995699e-01f, 1.12571634e-01f, -5.08490503e-02f, -5.55486858e-01f, 1.19685121e-01f,
  -3.04667037e-02f, 2.20578909e-01f, 1.65813908e-01f, -3.82275164e-01f, 5.28966561e-02f, -1.58769488e-01f, 1.01244394e-02f, -5.18840492e-01f, -1.65387690e-01f, 3.85359466e-01f,
  9.88371000e-02f, -1.96317747e-01f, -1.46538824e-01f, 3.45442802e-01f, -1.45673171e-01f, 4.20629531e-01f, -1.60982549e-01f, -4.16029632e-01f, 1.09865610e-02f, 2.55087763e-01f,
  1.90845460e-01f, 2.13912874e-01f, 1.97314657e-02f, -2.18705565e-01f, 1.56065032e-01f, 2.14114934e-01f, -6.31717965e-02f, -3.27340126e-01f, -9.78862569e-02f, 5.15600783e-04f,
  -1.58983961e-01f, -2.98331022e-01f, -1.22423142e-01f, -2.01897234e-01f, -2.06083864e-01f, 9.07760188e-02f, -1.29007682e-01f, -4.60694373e-01f, 2.67681092e-01f, -2.24100333e-03f,
  1.69375077e-01f, -3.12759370e-01f, -1.09581143e-01f, 1.91139445e-01f, -4.12220597e-01f, -1.35928243e-01f, 1.19302951e-01f, 3.02083232e-02f, 3.34414095e-01f, 2.15905547e-01f,
  -6.06338456e-02f, 7.06653148e-02f, 2.25274771e-01f, 1.89963207e-01f, 5.83123267e-02f, 7.94654991e-03f, -1.45440534e-01f, -2.44057491e-01f, -2.26528794e-01f, -6.70070052e-02f,
  2.66216487e-01f, -9.83072519e-02f, 1.87809333e-01f, 2.42270082e-01f, -2.09533609e-03f, 5.29604591e-02f, 6.67630062e-02f, 3.81377071e-01f, 1.36514783e-01f, -3.64027798e-01f,
  -2.97662437e-01f, -2.12041587e-01f, 9.20420289e-02f, -3.85702670e-01f, -2.62060434e-01f, -1.54407963e-01f, 2.79787868e-01f, -2.01448187e-01f, -3.07036251e-01f, -1.88763425e-01f,
  -2.46691748e-01f, -2.50587940e-01f, -4.96054441e-02f, -3.19611311e-01f, -3.15793663e-01f, 1.13995545e-01f, 1.50292620e-01f, -1.02449879e-01f, 2.98611790e-01f, 1.16786718e-01f,
  3.02079827e-01f, -5.35791516e-02f, 1.16777837e-01f, 1.60928085e-01f, 8.09616968e-02f, 1.52425274e-01f, -2.56168664e-01f, -2.91471004e-01f, 1.46248251e-01f, -1.65263191e-01f,
  3.20556104e-01f, -2.31981501e-01f, -3.43871832e-01f, -1.55408263e-01f, 9.14009437e-02f, 5.14912270e-02f, 2.89999008e-01f, 2.41393492e-01f, -2.15487927e-01f, -2.68841177e-01f,
  1.40760645e-01f, 8.05563107e-02f, -1.73780441e-01f, -3.97854567e-01f, 1.42715231e-01f, 4.30685841e-02f, -6.96980804e-02f, 6.00045361e-02f, -3.83269861e-02f, 1.72791049e-01f,
  9.60856527e-02f, 1.66478176e-02f, -1.55223653e-01f, -1.73441738e-01f, 1.23966344e-01f, 1.61911875e-01f, -3.45587991e-02f, -3.48410696e-01f, 2.04936545e-02f, -4.74728823e-01f,
  1.91162318e-01f, -3.19139808e-01f, -6.25768378e-02f, 3.67966831e-01f, -3.92076910e-01f, -5.92942089e-02f, -9.91306826e-02f, 1.79417402e-01f, -7.81439170e-02f, 2.32024685e-01f,
  3.69229503e-02f, 2.46063650e-01f, -2.45253369e-01f, 2.51316756e-01f, -2.62412161e-01f, 2.30491787e-01f, 1.42866299e-01f, -1.68334827e-01f, -4.17312026e-01f, 2.10369095e-01f,
  -6.57337382e-02f, -4.06387806e-01f, 2.96545088e-01f, -4.14201528e-01f, -3.31297994e-01f, 1.67555198e-01f, 1.55443296e-01f, 5.89150414e-02f, 1.92573085e-01f, 7.23230168e-02f,
  -3.89162183e-01f, -2.91942637e-02f, -1.41520232e-01f, 1.88348636e-01f, 4.77695256e-01f, 3.73959243e-01f, -4.32022452e-01f, -5.32950103e-01f, -2.98676819e-01f, 3.15222926e-02f,
  3.26879136e-02f, -1.12645358e-01f, -1.73232615e-01f, -1.48316219e-01f, 3.31098765e-01f, -1.25118837e-01f, -2.20935032e-01f, 1.63386747e-01f, -1.90599263e-03f, 8.43593758e-03f,
  -8.30282345e-02f, -9.56652239e-02f, -1.95334898e-03f, -8.20837840e-02f, -2.66181946e-01f, -1.81274638e-01f, 2.02239662e-01f, -7.93447644e-02f, 1.72292501e-01f, 1.01062484e-01f,
  -2.12916397e-02f, 1.08172439e-01f, -3.10313463e-01f, -3.17624509e-02f, -3.42165202e-01f, -1.17544346e-01f, 8.50760415e-02f, -1.31429404e-01f, -4.15409476e-01f, 2.15172604e-01f,
  2.73741871e-01f, -1.85598299e-01f, -1.22545823e-01f, -1.91722922e-02f, -2.34202281e-01f, -1.93718225e-01f, -1.58739630e-02f, -3.70515198e-01f, 1.87696472e-01f, -2.75902987e-01f,
  -2.15627536e-01f, 1.41288489e-01f, 1.20191745e-01f, -3.90505999e-01f, 2.92010039e-01f, 3.80589932e-01f, 6.10688701e-02f, 1.81632072e-01f, 1.69484496e-01f, -1.81487098e-01f,
  -3.28186482e-01f, 2.08195165e-01f, -1.15028329e-01f, 3.76855284e-02f, -3.17785025e-01f, -1.51917981e-02f, -1.52125448e-01f, -1.13283791e-01f, -8.46377537e-02f, -4.86665592e-02f,
  2.55401820e-01f, -3.54476541e-01f, 8.60852003e-02f, -1.79503456e-01f, -1.05850339e-01f, 2.41527725e-02f, -2.56784946e-01f, 3.51055533e-01f, 3.19041282e-01f, -1.02934465e-01f,
  -9.44320261e-02f, 4.29962836e-02f, -3.72888558e-02f, -5.69347851e-02f, -7.29595404e-03f, 6.48395484e-03f, -5.69042005e-02f, -2.01137085e-02f, -1.99196935e-01f, -2.19619319e-01f,
  3.45786884e-02f, 2.09294558e-01f, 7.19127208e-02f, 2.25523680e-01f, 3.61962497e-01f, -1.03308260e-01f, -1.70707941e-01f, -2.51972049e-01f, -4.19482529e-01f, 2.09841445e-01f,
  -1.05036944e-01f, 2.18083680e-01f, 1.62113398e-01f, 2.71176577e-01f, -4.40070368e-02f, -1.81894794e-01f, -1.77910417e-01f, 2.22529203e-01f, -1.03766538e-01f, -9.55321118e-02f,
  -1.23113409e-01f, -3.86719525e-01f, -2.75562495e-01f, -3.07410181e-01f, 1.68416679e-01f, -2.20229045e-01f, 2.71490872e-01f, -2.47713089e-01f, -1.56396806e-01f, 1.57805085e-01f,
  -3.44460428e-01f, -1.86562434e-01f, -1.09508552e-01f, 8.12191293e-02f, 3.44096750e-01f, -6.31772950e-02f, 4.36657108e-02f, 1.41022280e-01f, 5.39786965e-02f, -1.29505187e-01f,
  2.19936371e-01f, 1.09619766e-01f, -1.06253706e-01f, -8.02835524e-02f, 2.28782296e-01f, -2.74376780e-01f, -2.95100898e-01f, -1.69628844e-01f, -2.29863301e-01f, -6.57149777e-02f,
  1.81942116e-02f, 7.52874166e-02f, -1.61322057e-01f, 1.84117928e-01f, 3.01900685e-01f, -1.46487415e-01f, -1.18745230e-01f, 7.07586855e-02f, 1.64967358e-01f, 7.82890897e-03f,
  -9.08375382e-02f, -1.61122367e-01f, 2.50467628e-01f, 2.48729527e-01f, 1.37443602e-01f, -2.01436132e-01f, -6.22105412e-03f, -2.15488851e-01f, 2.36845315e-01f, -1.27458960e-01f,
  -1.18245997e-01f, -2.36275747e-01f, 1.39911965e-01f, -9.24634188e-02f, 1.45620301e-01f, -1.05356546e-02f, -3.43569040e-01f, -2.58499444e-01f, -1.36022568e-01f, 2.28715122e-01f,
  3.22960258e-01f, -4.50213999e-01f, -1.97522715e-01f, -3.80312391e-02f, -3.23837399e-01f, -3.00230920e-01f, 6.78611770e-02f, 3.18489343e-01f, -3.88035744e-01f, 1.36631727e-01f,
  2.69078583e-01f, 2.24074461e-02f, -3.27280425e-02f, 1.85855940e-01f, 1.41491875e-01f, -2.53510088e-01f, -2.96528190e-01f, -2.17706859e-01f, -4.76684183e-01f, 2.28830636e-01f,
  2.41596520e-01f, 1.41325563e-01f, 2.36368567e-01f, -8.76513198e-02f, -3.11157942e-01f, 2.68395960e-01f, -3.83605212e-01f, 2.14371219e-01f, 9.98506472e-02f, 1.75006524e-01f,
  -2.93673754e-01f, -3.03735048e-01f, 2.47691199e-01f, -2.90146738e-01f, -2.73211211e-01f, -9.86200795e-02f, -1.24673374e-01f, -2.71670222e-01f, 3.23230147e-01f, -5.81730269e-02f,
  -1.31920993e-01f, 1.11337639e-01f, -2.07237035e-01f, -4.07409258e-02f, 2.05390885e-01f, 6.48026615e-02f, 1.70672268e-01f, -8.11009780e-02f, -2.82296479e-01f, 2.21893430e-01f,
  -8.51917714e-02f, -1.51913166e-01f, -3.57905447e-01f, -1.41381815e-01f, 3.01527888e-01f, -1.70612440e-01f, -1.19171320e-02f, -3.68592322e-01f, -1.99245751e-01f, 2.76737154e-01f,
  -9.12383497e-02f, 1.75524846e-01f, -2.12036327e-01f, -3.99635017e-01f, -2.24220514e-01f, 2.78397232e-01f, -1.50740296e-01f, -3.81613672e-02f, 2.14992404e-01f, 2.13830471e-01f,
  6.83961362e-02f, -3.19239110e-01f, 2.51428813e-01f, 9.21244547e-02f, -2.56823391e-01f, -3.60452496e-02f, -3.20681006e-01f, 5.89568093e-02f, -2.07579806e-01f, -1.26644909e-01f,
  -1.68556705e-01f, -1.56227499e-01f, -2.06799403e-01f, -2.33327538e-01f, 3.36438745e-01f, -3.74558210e-01f, 2.24056780e-01f, 3.36759299e-01f, 2.42134109e-01f, -4.28213105e-02f,
  -1.04839191e-01f, -1.62044808e-01f, 3.30726020e-02f, 2.74668634e-01f, -2.65496727e-02f, 1.29313514e-01f, -1.68137863e-01f, -2.28560254e-01f, 1.93342835e-01f, 5.85207120e-02f,
  -3.23613137e-01f, -2.79096276e-01f, -3.37419063e-01f, -2.53577847e-02f, 1.40378967e-01f, 1.45649150e-01f, 1.27611399e-01f, 7.85296559e-02f, 1.03932954e-01f, 2.72896364e-02f,
  -1.90594077e-01f, -7.27452189e-02f, 2.55892187e-01f, 2.00796470e-01f, -1.75138980e-01f, -1.04263008e-01f, -9.57237631e-02f, -3.08519632e-01f, -4.33349833e-02f, 3.57874393e-01f,
  -3.47029299e-01f, 3.78263324e-01f, -1.64226413e-01f, -2.73509711e-01f, 3.20148957e-03f, -1.10512316e-01f, -2.10571796e-01f, 3.47570449e-01f, -3.13106894e-01f, -2.26077795e-01f,
  -1.06107891e-01f, -2.23472103e-01f, -7.79642761e-02f, 1.59021690e-01f, 2.74708211e-01f, 7.25375563e-02f, 2.66965121e-01f, -1.70755044e-01f, -3.07737917e-01f, -2.35711440e-01f,
  -1.27233446e-01f, -2.26481989e-01f, 2.19359219e-01f, 1.82791993e-01f, 3.89128849e-02f, -3.20432544e-01f, 3.24101746e-01f, -3.65838349e-01f, 2.64930844e-01f, -3.26631993e-01f,
  3.84799242e-01f, -5.86006530e-02f, -3.74615341e-02f, 2.03854308e-01f, -3.05848926e-01f, -8.25544447e-02f, -3.62772256e-01f, -3.67475778e-01f, 4.47467491e-02f, -1.74678817e-01f,
  -2.87012637e-01f, -1.54024094e-01f, 1.25562444e-01f, -3.67769063e-01f, 3.60379010e-01f, 1.02164380e-01f, -1.27332211e-01f, -3.11906636e-02f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  -1.07145414e-01f, 2.47548670e-02f, -5.40032573e-02f, 5.48008010e-02f, 1.16432555e-01f, -9.00108460e-03f, 5.83126396e-02f, -7.50080869e-02f, -1.09009609e-01f, 4.61659618e-02f,
  5.73413968e-02f, 5.78459585e-03f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 52
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 6, 52
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        64, 12
    );
    }
    