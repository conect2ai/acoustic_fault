/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 4 x 120)
const int L0_fan_Wp_rows = 4;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  4.51562494e-01f, -1.43481297e-02f, 4.08712998e-02f, 4.66563761e-01f, 1.60155863e-01f, -1.43408239e-01f, 1.29902095e-01f, -9.84470248e-02f, 7.62347430e-02f, 1.47912681e-01f,
  -8.30462610e-04f, 1.21559436e-02f, 1.43277973e-01f, -6.72687963e-02f, -1.20953180e-01f, 1.63575679e-01f, 6.06701374e-02f, 1.08793408e-01f, -7.31643885e-02f, -1.36884272e-01f,
  1.66946203e-01f, 2.03820869e-01f, -7.31501058e-02f, -1.17189392e-01f, 8.78726169e-02f, 9.37502161e-02f, 1.21640563e-01f, -1.53071445e-03f, -2.05700517e-01f, 1.59414262e-01f,
  1.06875643e-01f, -1.12833343e-01f, 1.32604942e-01f, 4.94357385e-02f, 5.61056845e-02f, -9.60926563e-02f, 3.05742510e-02f, -3.54903638e-02f, -3.52615630e-03f, -5.51792309e-02f,
  -1.52033448e-01f, -2.81618275e-02f, 3.43304202e-02f, -3.17104980e-02f, 1.77935306e-02f, -8.00464451e-02f, 2.02974025e-03f, 9.73591655e-02f, 1.17472075e-01f, -9.05938912e-03f,
  6.22749142e-02f, -8.19312334e-02f, -1.07606594e-02f, 4.65484895e-02f, -1.81275257e-03f, 1.59045942e-02f, -4.01584655e-02f, -9.13545862e-02f, -2.25466669e-01f, -5.13380654e-02f,
  1.25680089e-01f, 1.46078151e-02f, 2.52703167e-02f, 4.48500849e-02f, -1.09926946e-02f, 5.33477589e-02f, -3.75544578e-02f, 8.93314034e-02f, -7.58727938e-02f, -6.57612924e-03f,
  4.87967655e-02f, 2.68958975e-02f, -3.02287340e-02f, 5.36393523e-02f, 3.33570689e-02f, 3.47607248e-02f, -3.55483405e-03f, 5.71481921e-02f, -2.35056262e-02f, -7.67767504e-02f,
  -6.08117245e-02f, -4.93668579e-02f, -2.97510047e-02f, -7.04761446e-02f, 2.56922077e-02f, 9.08511132e-02f, -7.20440075e-02f, -6.23092912e-02f, 4.77627069e-02f, -8.69697407e-02f,
  1.20098606e-01f, 1.85915846e-02f, 1.09565370e-01f, -9.22012255e-02f, -4.17791568e-02f, 5.86418696e-02f, 3.17717604e-02f, 7.17528090e-02f, -4.36726771e-02f, 1.90441068e-02f,
  -1.19514823e-01f, 4.97612730e-03f, 4.46280763e-02f, -4.18254882e-02f, -2.93611139e-02f, -7.31807128e-02f, -2.40805205e-02f, 7.51439482e-02f, -1.00081176e-01f, -6.90396875e-02f,
  2.63337046e-03f, -6.47342131e-02f, 4.38131690e-02f, 6.39645755e-03f, -9.80053246e-02f, 1.10230029e-01f, -7.44080730e-03f, -2.14884691e-02f, -1.07004955e-01f, 1.07505567e-01f,
  2.70517379e-01f, 4.16866876e-02f, 1.75089553e-01f, -6.11012690e-02f, -2.08908111e-01f, -2.39917010e-01f, -2.65027493e-01f, -6.08442649e-02f, -3.84450927e-02f, -7.16028064e-02f,
  3.76051776e-02f, -1.22150727e-01f, -8.07373077e-02f, -9.19752046e-02f, -1.35092825e-01f, -3.03437740e-01f, -1.73641160e-01f, 2.01674595e-01f, -3.67285460e-02f, -2.13127598e-01f,
  -1.29538327e-01f, 2.51107603e-01f, 4.81727451e-01f, 8.28484595e-02f, 8.21391046e-02f, 2.43623890e-02f, 2.20434040e-01f, 3.22488457e-01f, 9.98700485e-02f, 2.30882227e-01f,
  1.09163888e-01f, 1.43086195e-01f, -1.52384222e-01f, -2.99659502e-02f, 3.32161086e-04f, 6.06120192e-03f, -4.63243462e-02f, 1.46108270e-01f, -6.34894148e-02f, 2.39407793e-02f,
  5.07455878e-03f, -9.77671966e-02f, 5.22882491e-02f, 1.33086890e-01f, 7.70415962e-02f, 6.08963557e-02f, 4.70061414e-02f, 1.06043145e-01f, -3.56959291e-02f, -8.71501043e-02f,
  -2.51520216e-01f, -7.02086762e-02f, 8.10419098e-02f, -4.32812274e-02f, -9.47020575e-02f, -6.85051158e-02f, 1.59290835e-01f, 1.00921787e-01f, 1.48878783e-01f, 1.82970718e-01f,
  -3.80523652e-02f, 2.81348471e-02f, 5.66313649e-03f, -7.43927509e-02f, -1.10193931e-01f, 6.31643012e-02f, 4.17663939e-02f, -1.35991927e-02f, 5.83540127e-02f, 3.80774178e-02f,
  -9.52719972e-02f, -5.03949448e-02f, -6.06694305e-03f, -3.08695938e-02f, 3.27011794e-02f, 1.40174041e-02f, -3.53842154e-02f, 2.84122862e-03f, 1.19282203e-02f, 1.95719730e-02f,
  -2.29521040e-02f, 4.88293767e-02f, -7.09208176e-02f, 8.06488916e-02f, -1.08969718e-01f, -3.23380753e-02f, -7.47598931e-02f, -2.99693104e-02f, -4.29179482e-02f, -1.97665300e-02f,
  4.04992811e-02f, 2.28794757e-02f, 6.51260018e-02f, 4.04773317e-02f, 2.98784766e-02f, -8.85545462e-02f, -1.85057465e-02f, 1.85280070e-02f, 4.52198014e-02f, -3.47782895e-02f,
  -4.72942516e-02f, 3.20796445e-02f, 4.52441201e-02f, 3.23224925e-02f, -4.84742299e-02f, -4.61963442e-04f, -4.67194282e-02f, 3.61025482e-02f, -2.95350533e-02f, -4.77458350e-02f,
  -3.18377763e-02f, -8.48884135e-02f, -1.04253843e-01f, -2.12971449e-01f, -3.16559859e-02f, -5.06137945e-02f, 7.76411518e-02f, 3.98429483e-02f, -1.37053579e-01f, -8.12581554e-02f,
  2.86772877e-01f, -4.01386589e-01f, 3.94552387e-02f, -3.94373685e-02f, -5.62082455e-02f, 8.99020955e-02f, -4.61960137e-01f, 6.71191886e-02f, 8.01291689e-02f, -1.76298141e-01f,
  4.70583402e-02f, 2.39635989e-01f, 3.21402371e-01f, 1.99623287e-01f, 2.50492066e-01f, -2.20457435e-01f, -3.00469190e-01f, 2.14178801e-01f, 2.62031943e-01f, 2.29177162e-01f,
  -1.41201675e-01f, -7.48775527e-02f, 1.31979793e-01f, 1.74908325e-01f, -1.96223512e-01f, 1.69525534e-01f, -8.93684030e-02f, -1.27154663e-01f, 1.33051023e-01f, -4.36402947e-01f,
  -4.26416583e-02f, -4.41022851e-02f, 1.17815755e-01f, -1.08952597e-02f, -1.15576975e-01f, -8.61100256e-02f, -1.19396158e-01f, -6.98990226e-02f, 1.63210277e-02f, -9.64377746e-02f,
  -1.01868987e-01f, -2.83837095e-02f, 3.44402753e-02f, -4.95607331e-02f, -9.84599218e-02f, 4.65149153e-03f, -1.36713207e-01f, 8.39896500e-02f, 4.56235036e-02f, -1.88056715e-02f,
  -8.85810331e-02f, -9.18729305e-02f, 1.04606546e-01f, 2.17877347e-02f, 6.38616011e-02f, 9.67303216e-02f, 3.95636745e-02f, 9.22582950e-03f, 9.37989503e-02f, -5.74211888e-02f,
  -1.59679893e-02f, 3.51318605e-02f, -8.43205396e-03f, -2.72612944e-02f, -1.81468502e-02f, 2.54633352e-02f, 1.01642134e-02f, 1.74733121e-02f, 3.10065318e-02f, -5.58455698e-02f,
  4.74100560e-02f, -4.36807200e-02f, -2.66065896e-02f, 9.41231940e-03f, 4.63511087e-02f, -2.98096631e-02f, -7.92890694e-03f, -2.61907056e-02f, 6.54705912e-02f, -3.10214609e-02f,
  3.99057716e-02f, 2.78844275e-02f, -3.38505581e-02f, -9.06665251e-03f, -2.95861810e-02f, 2.40582358e-02f, -8.99202824e-02f, -1.18613048e-02f, -5.02001196e-02f, -3.36374827e-02f,
  -4.21029255e-02f, 2.19859764e-01f, -2.16810554e-02f, 4.21374142e-02f, 4.44405563e-02f, 8.54259729e-02f, 1.20657692e-02f, 8.96900967e-02f, 2.53600557e-03f, 2.25765202e-02f,
  3.98681238e-02f, 5.48879430e-02f, 1.18772257e-02f, 5.95262833e-02f, 1.36663124e-01f, 5.13849221e-02f, 1.55922351e-02f, 5.84054478e-02f, 6.26081377e-02f, -4.63328324e-02f,
  -2.85646059e-02f, 4.48473506e-02f, 1.27272889e-01f, 3.88498008e-02f, -3.48145925e-02f, 7.83242583e-02f, 1.71951652e-02f, -8.56206845e-03f, 1.47318751e-01f, -1.66607797e-01f,
  1.07048422e-01f, 2.10517973e-01f, 3.75610203e-01f, 4.58026528e-02f, 7.41966665e-02f, -9.99647528e-02f, -1.29468560e-01f, -1.13434829e-01f, -1.66936040e-01f, 1.12837576e-03f,
  1.53833643e-01f, -1.15659028e-01f, 4.49095108e-02f, -4.33824062e-02f, -7.42179379e-02f, 6.07081801e-02f, 5.44796474e-02f, 1.58123761e-01f, -2.27757663e-01f, -6.43304288e-02f,
  -5.94199151e-02f, 5.06886430e-02f, 2.94100344e-01f, -1.16594307e-01f, 7.89334401e-02f, -3.65291148e-01f, 3.25372331e-02f, 2.99668640e-01f, -4.09737155e-02f, 1.81180954e-01f,
  1.33439630e-01f, 1.39366806e-01f, -2.27513105e-01f, -1.46649659e-01f, 1.44030482e-01f, -3.80336493e-02f, -5.56258634e-02f, 1.44575983e-01f, -5.00217788e-02f, 8.62126797e-02f,
  9.29755792e-02f, -7.30140805e-02f, 3.26933302e-02f, -8.72195438e-02f, -7.20456764e-02f, -8.71334523e-02f, 4.13501076e-02f, 1.33676410e-01f, -1.41572887e-02f, -5.63767180e-03f,
  5.39647453e-02f, 9.64046866e-02f, 8.80964175e-02f, -1.52806893e-01f, -5.27993999e-02f, -9.67353135e-02f, 6.49035722e-02f, -9.98425949e-03f, -5.09184040e-02f, 8.67331848e-02f,
  -3.57505716e-02f, 3.40270102e-02f, 2.46211365e-02f, 8.89412612e-02f, -4.35701981e-02f, -1.32843968e-03f, 1.28405467e-02f, 2.90109660e-04f, 4.39126529e-02f, 7.11168125e-02f,
  -3.82668152e-02f, -7.29441643e-02f, 5.31197861e-02f, -2.86765825e-02f, -8.63029882e-02f, 1.25813261e-01f, -4.39238995e-02f, -5.91540150e-02f, 1.20344408e-01f, -2.63770781e-02f,
  7.91938510e-03f, -1.74517538e-02f, -6.94548562e-02f, -7.04682525e-03f, -1.52994525e-02f, -9.97787807e-03f, -5.93361165e-03f, -9.37248394e-02f, 2.80009657e-02f, 6.46476895e-02f,
  -3.12617987e-01f, -4.97824438e-02f, -5.58485882e-03f, -1.12319902e-01f, -2.96671712e-03f, -5.06734401e-02f, -1.29884398e-02f, 2.51127277e-02f, 8.12527910e-02f, -5.66497035e-02f,
  -8.95914808e-02f, -1.81062929e-02f, -1.36636589e-02f, -1.97525714e-02f, 1.04513941e-02f, -8.42272565e-02f, 5.86740635e-02f, -1.02658860e-01f, -2.95438375e-02f, 1.83234662e-02f,
  -7.56435916e-02f, -9.52222124e-02f, -2.39439920e-01f, -3.57567593e-02f, -9.36273858e-02f, -2.61461079e-01f, -1.21669509e-01f, -1.75663054e-01f, -2.29931176e-01f, -2.91999757e-01f
};

// L0_fan_Wp_bar (Shape: 8 x 120)
const int L0_fan_Wp_bar_rows = 8;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -6.45294189e-01f, 4.02497321e-01f, -3.31808299e-01f, -6.76997960e-01f, -4.27153230e-01f, -1.04388483e-01f, 2.58250594e-01f, -2.72261441e-01f, -6.33796990e-01f, -6.81944862e-02f,
  1.66712180e-01f, 6.94966689e-02f, 6.12687431e-02f, 2.59193957e-01f, 1.89814866e-01f, 9.31126326e-02f, -1.52242288e-01f, -1.48311824e-01f, 4.81532402e-02f, -2.76341289e-03f,
  3.18329893e-02f, -4.02868003e-01f, -3.62921178e-01f, -1.47121221e-01f, -1.83908775e-01f, -4.35671173e-02f, -2.63286561e-01f, -3.74760985e-01f, 1.76300123e-01f, -1.97774559e-01f,
  2.64684707e-01f, -1.33087775e-02f, -1.29367143e-01f, -7.41953850e-02f, 2.14560814e-02f, 6.00604452e-02f, 1.06705911e-01f, 8.70508179e-02f, 4.67786491e-02f, -1.78378075e-01f,
  -5.86731136e-02f, 1.03157789e-01f, -9.16938558e-02f, 7.77391270e-02f, -1.59168378e-01f, 8.27338398e-02f, -4.62258570e-02f, 9.46061127e-03f, -1.80593040e-02f, 6.56731129e-02f,
  6.97695240e-02f, -1.66072920e-02f, -2.12610979e-02f, -4.87985387e-02f, 1.08286731e-01f, -1.06070399e-01f, 1.16444111e-01f, -5.73016740e-02f, -2.07052529e-02f, -7.27403536e-02f,
  4.77751791e-02f, 5.89331426e-02f, 5.98573945e-02f, 2.66599492e-03f, -6.90376572e-03f, -6.03287555e-02f, 1.51162790e-02f, 6.71507269e-02f, 8.73968005e-02f, -2.46991497e-02f,
  3.17492187e-02f, -1.14933364e-01f, 2.28278060e-02f, 4.02652733e-02f, 1.22356145e-02f, -1.64560556e-01f, 1.45173725e-02f, 1.85110830e-02f, 5.21892272e-02f, -8.83274004e-02f,
  -4.98140790e-02f, -7.56307319e-02f, -5.71748726e-02f, 1.41135633e-01f, -1.36736274e-01f, -2.91007273e-02f, -1.10677056e-01f, -3.81289492e-03f, -1.72877591e-02f, 3.53202224e-02f,
  -4.62049656e-02f, -3.42407487e-02f, -2.03478131e-02f, 5.38991801e-02f, -7.71733746e-02f, -4.43597063e-02f, -1.24595620e-01f, 8.64013359e-02f, -6.14184514e-02f, -1.23815455e-01f,
  -1.02993399e-01f, -2.32110135e-02f, 1.46950707e-02f, 4.82955133e-04f, -1.42475709e-01f, -8.38114619e-02f, 2.22547483e-02f, 2.92498786e-02f, -6.77684322e-02f, 5.77708823e-04f,
  -2.93935351e-02f, -1.80033012e-03f, 1.74133718e-01f, 6.93594441e-02f, -4.70332727e-02f, 1.63268685e-01f, 6.62574470e-02f, -8.73572826e-02f, 3.21501046e-02f, 9.07211304e-02f,
  -8.99862766e-01f, -3.08915913e-01f, 3.48071493e-02f, -1.14567682e-01f, 2.19678804e-01f, 2.27323472e-01f, -2.39660382e-01f, 1.56233773e-01f, 1.47374347e-01f, -2.94201553e-01f,
  -4.07104790e-02f, 8.35658237e-02f, -4.54127848e-01f, -1.13090806e-01f, -2.11251557e-01f, -5.73836982e-01f, -2.86045730e-01f, -6.95137084e-02f, 4.39413220e-01f, 4.91362870e-01f,
  1.27885863e-01f, -9.55459028e-02f, 4.50022928e-02f, 2.64974415e-01f, -1.38185024e-01f, -1.06229661e-02f, -3.08173746e-01f, -2.33165532e-01f, -9.11685154e-02f, -6.64763331e-01f,
  -3.23233068e-01f, 1.53498817e-02f, 2.20691741e-01f, -3.58955860e-02f, -7.11340411e-03f, -1.30249947e-01f, -4.53068428e-02f, -7.97762200e-02f, 4.69333790e-02f, -9.48740821e-03f,
  -8.72474462e-02f, 2.47719914e-01f, 6.43695071e-02f, 1.51503846e-01f, -8.26563034e-03f, -5.23777008e-02f, 2.00863872e-02f, -4.25164960e-02f, -1.86756849e-01f, -3.10905818e-02f,
  -9.80900717e-04f, -1.74263455e-02f, -1.96731836e-01f, 2.29354024e-01f, -5.39477263e-03f, 5.14933504e-02f, 2.34967028e-03f, 1.50367215e-01f, -1.01369008e-01f, -5.63702703e-01f,
  6.94918931e-02f, -5.15990183e-02f, 1.06375478e-01f, 3.36572565e-02f, -8.68502930e-02f, 3.94621044e-02f, -2.56812032e-02f, -2.56108157e-02f, 5.25914179e-03f, -5.97862788e-02f,
  3.81692722e-02f, 6.93812445e-02f, 8.61633718e-02f, -3.40817422e-02f, -2.58194096e-02f, 5.13052158e-02f, -2.77666021e-02f, 2.15641223e-02f, -5.79654658e-03f, -8.67306907e-03f,
  -6.81793392e-02f, -4.78661209e-02f, -2.91288644e-02f, 5.16710542e-02f, -2.94944365e-02f, -1.33197270e-02f, -8.38128179e-02f, 2.56941672e-02f, -8.54196027e-02f, -3.04754321e-02f,
  -2.10207388e-01f, 1.74535751e-01f, -2.30663970e-01f, -5.92797063e-02f, 5.71067594e-02f, -1.89635158e-03f, -6.63519427e-02f, 9.89492834e-02f, -3.56599391e-02f, 1.27715385e-03f,
  1.50663953e-03f, -1.89537480e-01f, -8.29686597e-02f, 3.30146253e-02f, 2.43363734e-02f, -4.24736470e-04f, -6.94836527e-02f, -3.97959240e-02f, -1.11468554e-01f, 7.09231496e-02f,
  -7.98134282e-02f, -1.38638809e-01f, -4.84744400e-01f, -2.07051516e-01f, -1.36452317e-01f, -1.58660591e-01f, -1.94871739e-01f, -1.07694052e-01f, -4.08562988e-01f, -5.79913259e-01f,
  -6.61927581e-01f, 4.07971926e-02f, -3.88701469e-01f, 1.23273902e-01f, 4.43958819e-01f, 5.63165657e-02f, -9.66335163e-02f, -3.05077940e-01f, 2.23364290e-02f, 8.16254616e-02f,
  1.19657211e-01f, 1.34991378e-01f, 2.89854228e-01f, 1.58530742e-01f, -3.65182877e-01f, -7.96521665e-04f, 2.88308173e-01f, -2.49047011e-01f, -5.76153219e-01f, -3.85722041e-01f,
  4.70546275e-01f, 6.21509785e-03f, -4.92718309e-01f, -1.83993042e-01f, 2.67485529e-01f, -4.77100834e-02f, 3.78601141e-02f, 1.00273721e-01f, 6.78397492e-02f, 5.49888194e-01f,
  -1.47372469e-01f, -1.60526022e-01f, -2.91216951e-02f, 1.25276655e-01f, 9.03602391e-02f, -6.46837875e-02f, -2.47964591e-01f, -1.57149304e-02f, -4.24558297e-02f, -4.87262383e-02f,
  1.39902622e-01f, 9.79766622e-03f, 2.11462095e-01f, 7.89879784e-02f, -7.07256421e-02f, -5.68335131e-02f, -2.10228950e-01f, -3.02190810e-01f, -2.95011938e-01f, -1.31194741e-01f,
  5.42852759e-01f, 1.38095871e-01f, -3.46373528e-01f, -1.87498182e-01f, -1.38151959e-01f, 3.53656784e-02f, -1.67163074e-01f, -2.68724680e-01f, -5.04399240e-01f, -3.82945806e-01f,
  -3.90812680e-02f, 4.06951830e-02f, 1.15527429e-01f, -6.17941022e-02f, -7.27704838e-02f, -2.89073423e-03f, 1.24834612e-01f, -1.34807182e-02f, 2.23235413e-02f, -4.09631468e-02f,
  7.59076625e-02f, -4.16565239e-02f, -1.99552868e-02f, -9.25368518e-02f, 1.19302198e-01f, 7.83605035e-03f, 1.91917345e-02f, -1.06931150e-01f, -2.05362123e-02f, -5.34535535e-02f,
  7.86108971e-02f, -6.42623156e-02f, 6.57363385e-02f, -6.69321641e-02f, 7.98478499e-02f, -9.44748893e-02f, 1.03528582e-01f, -1.20387696e-01f, 5.57094701e-02f, 3.80178429e-02f,
  -9.23272371e-02f, 2.22133562e-01f, -4.98379879e-02f, -3.32767367e-02f, 8.16161372e-03f, 3.74741443e-02f, 1.87972769e-01f, -1.89170316e-02f, 1.13532813e-02f, -1.05892867e-01f,
  -1.28131509e-01f, -9.02880207e-02f, 2.06522606e-02f, 6.84074312e-02f, 1.35008674e-02f, 1.56057507e-01f, 1.47492573e-01f, 5.15105901e-03f, -8.45197141e-02f, 4.50161137e-02f,
  -1.67518202e-02f, -1.49980128e-01f, -2.58260816e-01f, -4.58829962e-02f, 1.28529489e-01f, -1.93780318e-01f, -3.56555805e-02f, 1.05566960e-02f, -2.65106529e-01f, -2.97235757e-01f,
  6.30790114e-01f, -2.90113986e-01f, 2.50710607e-01f, 2.85815328e-01f, 8.54042768e-02f, 1.76312551e-01f, -1.12833932e-01f, -1.37960076e-01f, 3.29802535e-03f, -8.80466308e-04f,
  1.87155269e-02f, 2.75497809e-02f, -6.25278950e-02f, 3.26721370e-02f, -7.62818754e-02f, -7.17861503e-02f, 3.02486457e-02f, 5.94314933e-02f, 2.70848274e-01f, 9.12806615e-02f,
  -2.47156620e-02f, -1.16945714e-01f, -1.62382156e-01f, -1.37482345e-01f, -1.88545808e-01f, 1.18018053e-01f, 6.91824630e-02f, 1.23735564e-02f, -1.01905137e-01f, -1.71099871e-01f,
  5.13803124e-01f, 3.24089438e-01f, 2.84261078e-01f, 1.45805195e-01f, 1.08382210e-01f, -7.74576515e-02f, 5.80653958e-02f, -1.25848308e-01f, -1.22954026e-01f, -3.94333750e-02f,
  -4.64218445e-02f, -7.35336542e-02f, -7.41115585e-02f, -6.05421662e-02f, 6.36858940e-02f, 5.79818115e-02f, -1.08914427e-01f, -4.62065563e-02f, 1.67399610e-03f, 6.00813031e-02f,
  -7.33709037e-02f, -1.87459663e-02f, 1.98323011e-01f, 1.13056757e-01f, 1.58548169e-02f, 8.82135052e-03f, 1.96371339e-02f, -8.09222609e-02f, -3.45688984e-02f, 1.13651581e-01f,
  -9.59013402e-02f, -1.32965624e-01f, 8.81995931e-02f, 1.72031462e-01f, -2.39059199e-02f, 7.24858642e-02f, 7.38472268e-02f, 7.08657429e-02f, -1.62007958e-02f, -3.34906317e-02f,
  4.13699448e-02f, 2.29252018e-02f, -4.95238975e-02f, 6.46948814e-02f, -1.57647561e-02f, -8.87205452e-02f, 9.99073591e-03f, 5.04857861e-02f, 4.13352530e-03f, -6.41883686e-02f,
  3.76886204e-02f, -1.43060153e-02f, -7.02894852e-02f, -5.92348613e-02f, -1.17465697e-01f, 7.46438950e-02f, -4.64488938e-02f, -1.24528572e-01f, -7.36555979e-02f, -1.62220046e-01f,
  3.89291644e-01f, 8.96411240e-02f, 2.29156107e-01f, -1.31392315e-01f, -1.22905865e-01f, -1.55406386e-01f, -2.00969987e-02f, 3.33601125e-02f, -1.11351900e-01f, -1.52449846e-01f,
  5.20827947e-04f, -5.35956696e-02f, -7.34988824e-02f, -8.47849622e-02f, 8.63841847e-02f, 3.55427526e-02f, 6.34256676e-02f, 4.41219471e-03f, 3.83108296e-02f, 3.73056368e-03f,
  -1.44105271e-01f, 7.73249865e-02f, 3.09409350e-01f, 6.03393875e-02f, 5.52254803e-02f, 1.99744985e-01f, 1.09706305e-01f, 1.61597416e-01f, 5.78382462e-02f, 1.55396819e-01f,
  4.22524691e-01f, 3.75797339e-02f, -1.21456489e-01f, 1.09799288e-01f, 2.59384900e-01f, 3.45894903e-01f, 7.17268646e-01f, 2.32231766e-01f, -1.19093239e-01f, 2.26977199e-01f,
  1.11761875e-01f, -5.21830857e-01f, -5.48623681e-01f, -6.12089276e-01f, -1.11804925e-01f, 1.47792488e-01f, -1.61242336e-02f, -4.05343473e-01f, -2.01178044e-01f, -5.56009170e-03f,
  -2.53491253e-01f, 4.28429872e-01f, 2.18046263e-01f, -1.83639571e-01f, 8.07991810e-03f, -3.72185200e-01f, 1.82720602e-01f, 2.54482388e-01f, -2.64761627e-01f, -6.83119953e-01f,
  -2.15036586e-01f, 1.74620956e-01f, -3.57436538e-01f, -9.63863656e-02f, 4.36308794e-02f, -2.35426892e-02f, -1.64922960e-02f, 8.69128779e-02f, 9.04170647e-02f, 3.00293453e-02f,
  -1.07397452e-01f, 3.48783396e-02f, 1.36075960e-02f, 3.80135514e-02f, 2.61935622e-01f, 7.47017488e-02f, 9.03150216e-02f, -9.88623053e-02f, -6.32306039e-02f, -8.42722729e-02f,
  -2.33449832e-01f, 9.59917232e-02f, 8.61169547e-02f, 6.60906807e-02f, -5.92547171e-02f, -1.45775691e-01f, -4.69561629e-02f, -2.03224882e-01f, -1.49236724e-01f, -3.54731493e-02f,
  -1.46617576e-01f, -3.43635399e-03f, -6.64820820e-02f, 2.10779123e-02f, 5.40674031e-02f, -4.27124724e-02f, -7.28578717e-02f, 2.16289982e-02f, -6.49437085e-02f, -5.60004972e-02f,
  -2.95833610e-02f, -7.82006010e-02f, 3.91026810e-02f, 3.09293550e-02f, 2.12793015e-02f, 5.82380556e-02f, 9.66748485e-05f, 4.46059145e-02f, -2.23296322e-02f, 1.13891572e-01f,
  -8.63845553e-03f, -8.54167864e-02f, 1.02327056e-01f, 2.81803571e-02f, 2.13705227e-02f, -4.08426933e-02f, -1.65052906e-01f, -5.74358441e-02f, -9.87332910e-02f, -5.86780682e-02f,
  5.61345518e-02f, -1.10368326e-01f, -4.13535722e-02f, -1.35867104e-01f, 2.86036301e-02f, -3.05838808e-02f, -5.31036779e-02f, -1.87016115e-01f, 1.39334768e-01f, -3.11105140e-02f,
  -7.14841019e-03f, 4.91441861e-02f, 5.11651300e-02f, 2.64082011e-02f, -6.44060373e-02f, 6.42301440e-02f, 4.79954295e-02f, -2.55330831e-01f, 3.88093926e-02f, 1.03228264e-01f,
  -1.14691248e-02f, 1.79621782e-02f, -8.27449374e-03f, -5.81471473e-02f, 5.54559380e-03f, -4.08263057e-02f, 9.17313099e-02f, 3.62382233e-02f, 1.52644768e-01f, 2.85900265e-01f,
  -6.94328189e-01f, -1.49910882e-01f, 3.69185179e-01f, -3.16038400e-01f, 2.91324198e-01f, 3.10698152e-01f, 5.61693966e-01f, 2.78896261e-02f, -2.23730221e-01f, 2.47921601e-01f,
  -2.50527740e-01f, -3.21090341e-01f, -4.18838263e-01f, -2.34608874e-01f, -6.66528419e-02f, 5.78115582e-01f, 1.92256033e-01f, 2.45546754e-02f, 2.40403771e-01f, 2.84227550e-01f,
  2.16435492e-01f, -1.45320103e-01f, -4.03280377e-01f, -1.34243101e-01f, -3.69514562e-02f, 5.13189211e-02f, -2.23567300e-02f, -2.58138508e-01f, 1.55134931e-01f, -6.34414628e-02f,
  1.48351774e-01f, -3.37995261e-01f, 1.28894430e-02f, -2.42076471e-01f, -1.05439492e-01f, -8.81157592e-02f, -1.32659236e-02f, -4.61486354e-02f, -3.90258245e-02f, -3.61101851e-02f,
  -1.94100693e-01f, -6.59120083e-02f, -1.76856682e-01f, -2.44219974e-02f, -2.41187662e-02f, -2.56906915e-02f, -1.54140636e-01f, -1.69337049e-01f, -9.47328582e-02f, -7.41147101e-02f,
  -1.37714446e-01f, -3.61021794e-02f, -9.11102816e-02f, 7.71708190e-02f, -1.07257262e-01f, -9.74215940e-02f, -1.39419600e-01f, -2.24067509e-01f, -1.36392619e-02f, 4.62310202e-02f,
  6.91912882e-03f, 1.61929168e-02f, 2.21069902e-02f, 3.30611877e-02f, 5.72811579e-03f, 5.19192079e-03f, 1.54273491e-02f, 1.02024257e-01f, 1.58965327e-02f, 9.25948396e-02f,
  -2.40929667e-02f, 8.54826421e-02f, 5.36138900e-02f, -5.25440648e-02f, -4.65335771e-02f, 2.85371952e-03f, 8.70343018e-03f, -2.79829949e-02f, -3.82234342e-02f, -4.51800488e-02f,
  1.53142279e-02f, 4.39852960e-02f, -1.45332307e-01f, 1.53480787e-02f, 1.38017172e-02f, -4.37945016e-02f, 2.73833219e-02f, -1.92863140e-02f, 3.91408429e-02f, 1.12634897e-02f,
  1.32362157e-01f, -1.65023252e-01f, 4.04761173e-02f, 4.19333242e-02f, 5.63589334e-02f, -1.40214041e-01f, -6.46629781e-02f, 2.85723922e-03f, 7.95892403e-02f, 1.38758779e-01f,
  -7.32100662e-03f, 8.32842737e-02f, 8.10737461e-02f, -2.65215747e-02f, 2.20629320e-01f, 6.86428845e-02f, 2.92405728e-02f, 9.20315608e-02f, -2.57435143e-02f, -2.08729636e-02f,
  8.25257897e-02f, 1.11185521e-01f, 2.56748080e-01f, 8.91190469e-02f, -5.41807301e-02f, 1.14711680e-01f, 1.73412949e-01f, 7.35034645e-02f, 8.20276886e-02f, 3.81563574e-01f,
  8.71542275e-01f, 1.17853172e-01f, 7.03025818e-01f, 1.94483742e-01f, 2.27500334e-01f, 3.04490864e-01f, 3.73123616e-01f, 2.22585097e-01f, 8.23970661e-02f, 1.40213281e-01f,
  -7.14512467e-02f, -3.80217105e-01f, -2.99908161e-01f, -2.02926978e-01f, 3.71165574e-02f, 1.97766852e-02f, -7.67273828e-02f, 1.46744907e-01f, 3.35092872e-01f, 1.42453507e-01f,
  -1.91733107e-01f, 1.10305920e-01f, 1.94738537e-01f, -5.21251559e-02f, -1.00926064e-01f, -3.67610842e-01f, 6.65460974e-02f, -6.73130825e-02f, -1.44243926e-01f, -2.49744177e-01f,
  5.58191687e-02f, 3.09852958e-01f, -1.72152054e-02f, -1.37711003e-01f, 3.89509313e-02f, 4.60611172e-02f, 1.77411716e-02f, -1.76082123e-02f, -1.34321213e-01f, -1.41808107e-01f,
  -7.34404847e-02f, 3.56709510e-02f, 9.47577283e-02f, 2.81158257e-02f, 1.18791357e-01f, -1.97154395e-02f, 1.72843367e-01f, 5.82130477e-02f, 1.00703929e-02f, -6.79964721e-02f,
  -1.08704798e-01f, 3.13978978e-02f, 1.51205540e-01f, 4.31028605e-02f, -1.07947011e-02f, -5.06825075e-02f, 1.12041451e-01f, 4.06771004e-02f, -5.37321754e-02f, 1.49838179e-01f,
  -3.82655412e-02f, 2.13567793e-01f, 5.76302856e-02f, -3.37852612e-02f, -2.83863377e-02f, 8.39421526e-02f, 2.98203342e-02f, -1.72108021e-02f, 8.96977782e-02f, 4.23295647e-02f,
  5.92458881e-02f, 6.43263236e-02f, 3.91469225e-02f, 6.13985956e-03f, -3.67957205e-02f, -8.34870059e-03f, 2.52520628e-02f, -8.19999352e-02f, -1.44434258e-01f, 8.95579066e-03f,
  1.18874565e-01f, 7.57838711e-02f, 3.09357332e-04f, 1.18120760e-02f, 6.69653267e-02f, 5.71940355e-02f, 4.09122929e-02f, 6.16857840e-04f, 1.03040654e-02f, 1.62502825e-02f,
  -5.42946219e-01f, 6.06890880e-02f, -4.91346233e-02f, -6.27779812e-02f, 6.04997911e-02f, -6.99145421e-02f, -2.27835029e-02f, -1.24078274e-01f, -2.65477806e-01f, -1.27452582e-01f,
  6.71132281e-03f, -2.30180025e-02f, 5.56344427e-02f, 5.92312738e-02f, 6.58322498e-02f, 6.85776398e-03f, -1.43697232e-01f, 2.99220700e-02f, -1.60143360e-01f, -1.27791181e-01f,
  -9.45302173e-02f, 1.10018283e-01f, 3.43805514e-02f, 2.93209460e-02f, -1.73865288e-01f, -5.91449067e-02f, -1.71079822e-02f, 8.70031416e-02f, 1.29353300e-01f, 7.49834850e-02f,
  -3.17397565e-01f, -2.23517850e-01f, -7.02001750e-01f, 2.28827059e-01f, -7.14698732e-01f, -5.46883464e-01f, -7.16192007e-01f, 6.39476478e-02f, 3.49146396e-01f, -1.92138031e-01f,
  -1.05555244e-01f, 1.06639571e-01f, 6.98529258e-02f, -1.21455967e-01f, -1.89820334e-01f, -3.55587304e-01f, -3.39162052e-01f, -4.92265642e-01f, -4.25902218e-01f, -2.95364201e-01f,
  -1.30461380e-01f, -1.39004856e-01f, 3.81014422e-02f, 1.33258313e-01f, -2.73580283e-01f, -1.80015832e-01f, -1.72656819e-01f, -1.05342068e-01f, -4.09129620e-01f, -6.41308665e-01f,
  -4.09212232e-01f, -5.11419177e-01f, -1.26218259e-01f, 1.00505218e-01f, -2.31019914e-01f, 1.67904988e-01f, -1.08958744e-01f, -1.64427713e-01f, 7.53813311e-02f, 1.79245159e-01f,
  -1.96493119e-01f, -1.03798345e-01f, -7.36554414e-02f, -2.98768640e-01f, -2.29528978e-01f, -2.54267871e-01f, 1.45387337e-01f, -1.71773255e-01f, -3.70895304e-02f, 7.12534413e-03f,
  -2.61691143e-03f, -3.75657022e-01f, -2.00137407e-01f, 1.63668662e-01f, -9.69050974e-02f, -3.37547436e-03f, -2.43615881e-01f, -1.06483266e-01f, -1.46143571e-01f, 5.08324355e-02f,
  7.03649968e-02f, 1.16800666e-01f, -4.54611965e-02f, 8.35356489e-02f, 2.19012443e-02f, 1.62629038e-01f, -4.04354036e-02f, 5.73263206e-02f, 2.66904626e-02f, 1.39505416e-02f,
  6.11393601e-02f, -4.27407352e-03f, -8.66901055e-02f, 1.19448490e-01f, -3.39865386e-02f, -1.86268374e-01f, -1.52682504e-02f, -7.99073726e-02f, 3.04710884e-02f, -9.71140489e-02f,
  -3.73133905e-02f, 8.25119764e-02f, -6.51109442e-02f, -3.22682373e-02f, -1.89072967e-01f, -1.20984748e-01f, 8.15321878e-02f, 1.78020298e-01f, 5.92433661e-02f, 1.44874677e-01f,
  3.38151217e-01f, -1.37840077e-01f, -6.58508167e-02f, 3.81603166e-02f, -1.16765425e-01f, 5.63032627e-02f, 1.35612965e-01f, 6.56416360e-03f, 2.48789694e-02f, -1.95538327e-01f,
  -1.30057916e-01f, -8.74197185e-02f, 5.33818156e-02f, -4.72642444e-02f, 1.04162157e-01f, 3.73073965e-02f, 1.41259387e-01f, -6.73856139e-02f, -2.31370777e-02f, 1.31290048e-01f,
  2.53338963e-01f, 8.36602896e-02f, 4.42095324e-02f, 9.23732892e-02f, -8.72788131e-02f, -1.70931984e-02f, -7.30515569e-02f, -1.39707625e-01f, -6.67075589e-02f, 5.05234301e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 8)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 8;
const float L0_fan_Bp_bar_data[] = {
  2.26652279e-01f, -5.45958951e-02f, 7.87691027e-02f, 1.86963513e-01f, 6.93113983e-01f, 1.76670939e-01f, 2.53418118e-01f, 8.79330277e-01f
};

// L1_fan_Wp (Shape: 4 x 16)
const int L1_fan_Wp_rows = 4;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  1.64049238e-01f, 3.57785702e-01f, -3.37616444e-01f, -8.21416080e-02f, -1.97043389e-01f, 1.34768128e-01f, 6.31129503e-01f, -2.12224349e-01f, 3.52410316e-01f, -4.27922234e-02f,
  -7.05374897e-01f, 6.00119792e-02f, -7.83917606e-02f, 5.35519049e-02f, 1.74431071e-01f, -1.49399117e-01f, -1.23259462e-01f, 1.24777630e-01f, 4.78842370e-02f, 1.33328870e-01f,
  1.70524660e-02f, -1.23884678e-01f, 2.77227849e-01f, -3.22520018e-01f, 2.78543085e-01f, 3.00675601e-01f, -5.45899212e-01f, -2.22928852e-01f, 1.19563490e-01f, 1.39256611e-01f,
  -2.36047685e-01f, -1.02545500e-01f, -5.65730035e-01f, -3.05959076e-01f, -2.85431314e-02f, 7.61464387e-02f, -2.24211067e-01f, -1.28634885e-01f, -3.03365976e-01f, 8.50397870e-02f,
  -7.97486827e-02f, 4.87664074e-01f, 1.78008661e-01f, -2.54294276e-01f, -2.81275585e-02f, -1.89837500e-01f, -4.13726479e-01f, -1.65199861e-01f, 6.69415817e-02f, -1.77280590e-01f,
  2.20936872e-02f, -1.91813782e-01f, -6.63322210e-02f, 3.73446345e-01f, -3.79925370e-02f, 4.46593493e-01f, -4.29589182e-01f, 1.38483152e-01f, 1.17289498e-01f, -2.12003499e-01f,
  -1.43333480e-01f, -2.46830598e-01f, 3.64076719e-02f, -1.06840268e-01f
};

// L1_fan_Wp_bar (Shape: 8 x 16)
const int L1_fan_Wp_bar_rows = 8;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  -3.76527071e-01f, -8.75865072e-02f, 1.69427961e-01f, 2.46635869e-01f, -1.51787594e-01f, -1.35098934e-01f, 3.37530643e-01f, -3.03504854e-01f, 5.75979710e-01f, 4.06023353e-01f,
  -1.19885556e-01f, -1.31891713e-01f, 6.66918993e-01f, 2.90340394e-01f, 8.31559747e-02f, 5.99918365e-01f, 7.62613535e-01f, 3.34858805e-01f, 3.26382786e-01f, 5.42203337e-02f,
  3.99635881e-01f, 7.11659253e-01f, -1.52952746e-01f, 5.58665395e-01f, -3.22460830e-01f, 1.60660252e-01f, 1.00744717e-01f, 3.22336182e-02f, 4.16261345e-01f, -8.18900526e-01f,
  -1.78057879e-01f, 4.24909294e-01f, 4.04744387e-01f, 5.23237407e-01f, 1.91690341e-01f, 1.34695116e-02f, 3.62762153e-01f, -1.89377934e-01f, 4.80601825e-02f, -2.69761711e-01f,
  -6.03376850e-02f, -6.42701209e-01f, -5.66237748e-01f, -1.17008194e-01f, 6.83585286e-01f, 4.13612306e-01f, 3.16468626e-01f, 9.44913365e-03f, -2.36962214e-01f, 7.75577649e-02f,
  -1.56980693e-01f, 3.58971283e-02f, -2.83374518e-01f, 3.92941609e-02f, 6.16894960e-01f, -5.59231751e-02f, -1.74182832e-01f, 8.20226252e-01f, -2.32796103e-01f, 2.14939415e-01f,
  -2.64131755e-01f, -4.85039473e-01f, 2.32091293e-01f, 2.00985149e-01f, -2.77562346e-02f, 1.41442522e-01f, -3.04269195e-02f, -2.37607285e-02f, -6.30179271e-02f, -6.42579079e-01f,
  -6.41807541e-03f, 3.25550497e-01f, 4.58630919e-01f, 7.39118159e-02f, 9.40802991e-02f, 3.86929870e-01f, -8.82130489e-02f, 6.21317565e-01f, 1.10746682e-01f, -4.09477472e-01f,
  3.57435703e-01f, 5.95107079e-01f, 1.18690193e-01f, -5.55376038e-02f, -4.31650162e-01f, -3.05579424e-01f, 1.26226857e-01f, -4.25969899e-01f, 7.74054155e-02f, 1.50849730e-01f,
  -2.02205122e-01f, 9.12773982e-02f, 9.40721869e-01f, 3.98750268e-02f, 6.50866807e-01f, 7.24932790e-01f, 3.43869984e-01f, 1.28250927e-01f, 1.80717662e-01f, -4.69261378e-01f,
  7.12102801e-02f, 2.30590388e-01f, -4.09980148e-01f, 3.47813487e-01f, -4.27852064e-01f, -3.82119536e-01f, -6.19992256e-01f, 8.04322362e-02f, 4.96041626e-01f, 2.04895679e-02f,
  2.74978071e-01f, -7.39698946e-01f, 4.63405162e-01f, 5.83269477e-01f, 4.32624221e-01f, 2.47650117e-01f, 1.66821003e-01f, -8.73299688e-02f, -5.13768435e-01f, -4.81515676e-02f,
  5.75649202e-01f, -1.84544012e-01f, 6.35099947e-01f, -9.97916609e-02f, 5.85673749e-01f, 6.60757542e-01f, -2.49355108e-01f, 2.12608755e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 8)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 8;
const float L1_fan_Bp_bar_data[] = {
  2.30327040e-01f, 3.10329646e-01f, 4.14317131e-01f, 2.65081823e-01f, 1.06953308e-01f, -7.29186535e-02f, 2.21724838e-01f, -1.60627961e-01f
};

// L2_fan_Wp (Shape: 4 x 16)
const int L2_fan_Wp_rows = 4;
const int L2_fan_Wp_cols = 16;
const float L2_fan_Wp_data[] = {
  3.37272733e-01f, 2.43211582e-01f, 2.86485523e-01f, 7.96505287e-02f, 3.00014645e-01f, 4.15858626e-01f, -2.85457432e-01f, 9.28717256e-02f, 2.79143527e-02f, 3.40148121e-01f,
  2.23544072e-02f, 2.03357205e-01f, -2.07833320e-01f, -7.87777230e-02f, 1.62865594e-01f, -4.17291015e-01f, 5.27912416e-02f, 2.09752873e-01f, 7.24883825e-02f, -2.21217629e-02f,
  5.05349815e-01f, -3.86081375e-02f, 6.33323789e-02f, 3.61025572e-01f, 1.50494650e-01f, 2.28546217e-01f, 4.93687615e-02f, 1.96496233e-01f, 1.72369350e-02f, 1.71593890e-01f,
  6.87141657e-01f, -5.71923852e-01f, -1.29242688e-01f, 2.77539760e-01f, 3.64976972e-01f, 8.87123346e-02f, -1.69833258e-01f, -2.05543116e-01f, -5.42100705e-02f, 5.27787983e-01f,
  -1.50312155e-01f, 4.28881317e-01f, -4.58422929e-01f, 1.19438797e-01f, 2.40267381e-01f, -3.42972577e-01f, 1.00524887e-01f, 1.01843901e-01f, 2.59886950e-01f, 4.14656162e-01f,
  2.66745180e-01f, -6.59300294e-03f, 1.88813105e-01f, 3.12542558e-01f, 3.48858446e-01f, -3.11369747e-01f, 2.77674347e-01f, -6.12641156e-01f, -1.39274269e-01f, -3.13964903e-01f,
  1.28310934e-01f, -1.64152667e-01f, -1.41645521e-01f, 5.92448823e-02f
};

// L2_fan_Wp_bar (Shape: 8 x 16)
const int L2_fan_Wp_bar_rows = 8;
const int L2_fan_Wp_bar_cols = 16;
const float L2_fan_Wp_bar_data[] = {
  3.59139264e-01f, 3.86282355e-01f, -3.77738804e-01f, -3.34788859e-02f, -5.59991181e-01f, -5.61426163e-01f, -3.48800421e-01f, 1.35261565e-01f, -2.79684626e-02f, 3.61785777e-02f,
  5.94855905e-01f, -9.62018192e-01f, -4.13129449e-01f, 1.75088570e-01f, 5.12686670e-01f, -9.90445018e-02f, 5.35640776e-01f, 5.51741958e-01f, 4.24116313e-01f, 5.14824629e-01f,
  -8.02353978e-01f, -1.43370479e-01f, -3.50557655e-01f, 2.98109651e-01f, -2.31604315e-02f, 9.50964332e-01f, 5.33809364e-01f, -2.96950459e-01f, -1.25768626e+00f, 1.46231532e-01f,
  4.53298479e-01f, -2.66674235e-02f, 6.89781427e-01f, 1.66543841e-01f, 8.50041568e-01f, 2.06298992e-01f, -7.48365045e-01f, 5.02772689e-01f, 5.95918775e-01f, -4.81925815e-01f,
  4.87166524e-01f, 6.72124922e-01f, -1.93150207e-01f, 3.37395817e-01f, -2.89950669e-01f, 1.32197455e-01f, -7.93079078e-01f, 3.64913762e-01f, 3.45497280e-01f, 5.53108752e-01f,
  -2.60040909e-01f, 2.37069160e-01f, 3.75321776e-01f, -6.47436440e-01f, -5.83433092e-01f, 2.76621133e-01f, -1.99929010e-02f, 7.23731041e-01f, 9.07605886e-01f, -1.20768666e-01f,
  -3.12688202e-01f, 2.70368576e-01f, 5.77706456e-01f, -1.63967147e-01f, 4.82210964e-01f, 3.87552649e-01f, 1.80613831e-01f, 3.50882381e-01f, -8.86050463e-01f, -2.66936600e-01f,
  -1.63390607e-01f, 5.22706866e-01f, -2.61289254e-02f, 7.26320863e-01f, 3.29516977e-01f, -3.65066975e-01f, -5.78874588e-01f, -1.08891666e-01f, 4.92735803e-01f, 1.20201468e-01f,
  6.81238949e-01f, 2.55699575e-01f, 2.29365930e-01f, 4.13047224e-01f, 1.77970245e-01f, 9.35717881e-01f, 1.90916896e-01f, -3.95331502e-01f, 6.43941045e-01f, 7.46173933e-02f,
  1.16944671e-01f, 6.37469411e-01f, -2.37041712e-01f, 4.23976809e-01f, -9.75108072e-02f, -2.68141776e-01f, -1.13669425e-01f, -1.18461899e-01f, -3.33508058e-03f, 1.73741058e-01f,
  3.55470553e-02f, -2.06015125e-01f, -7.57633895e-02f, -1.08773723e-01f, -1.46778906e-02f, 1.46779522e-01f, -6.56844070e-03f, -1.71326734e-02f, 6.39187470e-02f, -8.92264247e-02f,
  1.90395501e-03f, 1.86158136e-01f, 1.42169490e-01f, 5.15863776e-01f, -7.05562770e-01f, -3.24396014e-01f, 4.17345524e-01f, 4.94189739e-01f, -5.42312980e-01f, -5.00646114e-01f,
  3.68925214e-01f, -1.66439444e-01f, 9.72469866e-01f, -5.41100204e-01f, 5.12437671e-02f, 3.93487126e-01f, 5.68178371e-02f, 9.87607479e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 8)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 8;
const float L2_fan_Bp_bar_data[] = {
  -2.36256361e-01f, 1.31228924e-01f, 2.81578928e-01f, 1.67639285e-01f, 2.97328886e-02f, 2.37070635e-01f, 6.55614063e-02f, 1.99720845e-01f
};

// L3_fan_Wp (Shape: 4 x 16)
const int L3_fan_Wp_rows = 4;
const int L3_fan_Wp_cols = 16;
const float L3_fan_Wp_data[] = {
  3.06206167e-01f, 1.57677159e-01f, -9.07371640e-02f, 1.09930754e-01f, 5.70343852e-01f, 1.02811800e-02f, -5.09213388e-01f, 3.37884367e-01f, -4.01275963e-01f, -1.41755715e-01f,
  1.86110679e-02f, 5.32026123e-03f, -3.73556495e-01f, 3.98960054e-01f, -3.71059147e-03f, -3.03033506e-03f, -1.07414424e-01f, -8.40080250e-03f, 2.59727746e-01f, -3.06335807e-01f,
  1.91728577e-01f, 2.49259457e-01f, -1.53489977e-01f, 2.67633408e-01f, -2.90745169e-01f, -2.89785892e-01f, 2.26397708e-01f, 2.26188488e-02f, -1.65967092e-01f, 3.50736260e-01f,
  7.64399618e-02f, -1.80741265e-01f, 5.05849004e-01f, 3.84000391e-02f, -5.52338421e-01f, -1.47408724e-01f, -2.44115978e-01f, 1.27648830e-01f, -5.14254749e-01f, -3.35867137e-01f,
  2.06906706e-01f, -5.24128452e-02f, -2.98935920e-01f, 1.70324907e-01f, -1.59484837e-02f, -2.42020130e-01f, 1.95967648e-02f, 2.35347912e-01f, -8.46038699e-01f, -2.65855134e-01f,
  -3.23899120e-01f, -2.07896397e-01f, 7.89473534e-01f, 4.06763367e-02f, 3.05532292e-02f, -3.84037822e-01f, -2.33582556e-01f, 1.68497771e-01f, -8.58676434e-02f, 3.48457724e-01f,
  1.87132768e-02f, -1.50700510e-01f, 1.13202296e-01f, -2.51218617e-01f
};

// L3_fan_Wp_bar (Shape: 8 x 16)
const int L3_fan_Wp_bar_rows = 8;
const int L3_fan_Wp_bar_cols = 16;
const float L3_fan_Wp_bar_data[] = {
  7.91992605e-01f, 1.09773231e+00f, -6.66791797e-01f, -4.20752764e-01f, 6.09588921e-01f, -2.80347854e-01f, -6.13475442e-01f, 3.52411032e-01f, -3.72164458e-01f, 2.75614798e-01f,
  8.07517409e-01f, -8.85143294e-04f, -9.73420814e-02f, 7.01811254e-01f, 1.08170472e-01f, 3.63491058e-01f, 5.40926337e-01f, 1.06989928e-01f, 1.27191283e-03f, 3.09168398e-01f,
  4.80130970e-01f, 9.19103742e-01f, 5.65525711e-01f, -5.65412998e-01f, 8.76469791e-01f, 1.28602803e+00f, 2.62627274e-01f, 6.66802287e-01f, 1.12502038e+00f, 7.88934603e-02f,
  -8.67976695e-02f, -7.52544105e-02f, 5.67805283e-02f, 1.13050878e-01f, 3.01063210e-01f, 1.89987555e-01f, 8.36185277e-01f, 4.17164087e-01f, -1.00281708e-01f, 3.01577985e-01f,
  -4.64127600e-01f, 2.93298334e-01f, 1.60007870e+00f, -4.66099024e-01f, -1.76958978e-01f, 8.84046435e-01f, 2.04239395e-02f, 1.23875521e-01f, -5.45394599e-01f, 8.11584294e-01f,
  4.16080624e-01f, 6.70637727e-01f, -1.03551400e+00f, -1.27639151e+00f, 1.50098875e-01f, 1.07529712e+00f, 7.16198012e-02f, 1.07917555e-01f, -7.23686740e-02f, -2.15180069e-02f,
  1.48288280e-01f, -1.78107306e-01f, 2.18300328e-01f, 1.07430470e+00f, -5.17714500e-01f, -2.64250219e-01f, 9.23633277e-01f, 3.37804854e-01f, 2.17249081e-01f, 6.66461110e-01f,
  -1.53543781e-02f, -6.21303320e-01f, 7.94949889e-01f, 9.41015303e-01f, -3.86773527e-01f, 9.45116878e-01f, 6.45807445e-01f, -4.77080792e-03f, -5.73889576e-02f, 2.93969035e-01f,
  1.03366561e-01f, -5.83516300e-01f, -7.85556078e-01f, 7.19556153e-01f, 2.80668408e-01f, 7.95951545e-01f, -1.11720467e+00f, -2.26400092e-01f, 1.95655957e-01f, -1.76040366e-01f,
  -5.50225139e-01f, 4.29169655e-01f, -5.70846975e-01f, 3.51428390e-01f, -3.48817632e-02f, 6.62785947e-01f, 2.44801164e-01f, 5.28323948e-01f, -5.22731543e-01f, -5.11154056e-01f,
  2.55280882e-01f, -1.72249693e-02f, 2.84686327e-01f, -6.42939687e-01f, 1.89089209e-01f, 4.16138649e-01f, 2.92488392e-02f, 3.50515306e-01f, 5.44100642e-01f, -6.41573310e-01f,
  1.68782830e-01f, -3.59544247e-01f, 9.26624358e-01f, 4.24157560e-01f, 6.89891517e-01f, -3.76783311e-01f, -3.76924902e-01f, -7.52257228e-01f, -9.20680642e-01f, 7.26543367e-01f,
  4.19612676e-01f, 3.09259802e-01f, -2.30741370e-02f, 6.99602142e-02f, 3.58669728e-01f, -1.20735355e-01f, -9.14398134e-02f, 6.09387577e-01f
};

// L3_fan_Bp_bar (Shape: 1 x 8)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 8;
const float L3_fan_Bp_bar_data[] = {
  -1.16989210e-01f, 4.28574681e-01f, 3.15105945e-01f, 1.37366161e-01f, 1.96536500e-02f, 1.52858451e-01f, 3.64411771e-01f, -1.03753433e-01f
};

// L4_linear_W (Shape: 12 x 16)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 16;
const float L4_linear_W_data[] = {
  4.10786986e-01f, -9.95793939e-03f, 3.86437535e-01f, 9.12017748e-02f, -8.41645822e-02f, -4.82324213e-01f, -1.41327530e-01f, 7.51552045e-01f, 4.68030840e-01f, 1.07673392e-01f,
  4.53014493e-01f, -9.03872550e-01f, -9.48941112e-01f, -8.13034773e-02f, -4.58375067e-01f, -4.88868117e-01f, -9.89234924e-01f, 4.86978382e-01f, 3.58401924e-01f, 7.64923811e-01f,
  3.54608327e-01f, 9.78586733e-01f, 7.15327621e-01f, -7.58592010e-01f, 2.27917507e-01f, -2.56192476e-01f, 4.63292040e-02f, -3.78187746e-01f, -1.05804607e-01f, 8.19784760e-01f,
  -4.33382362e-01f, -2.50524491e-01f, 6.64027214e-01f, 3.90786171e-01f, -5.97520173e-01f, -6.40528619e-01f, -7.05755055e-02f, 6.89963162e-01f, -4.99151856e-01f, 9.19551373e-01f,
  -1.50103241e-01f, 3.07949066e-01f, 3.27122509e-01f, -7.85311818e-01f, 3.64729881e-01f, -8.65452826e-01f, -3.68646234e-01f, -1.14749575e+00f, -5.78945339e-01f, -5.70199788e-01f,
  1.50736526e-01f, -8.35217178e-01f, 1.83456406e-01f, 7.84130514e-01f, -1.79288790e-01f, 4.47081178e-01f, 2.67053813e-01f, -1.16399109e+00f, 4.34205502e-01f, 4.04057205e-01f,
  -1.18067813e+00f, -4.64283705e-01f, -2.48312891e-01f, 9.49812084e-02f, -4.05770451e-01f, -3.98246855e-01f, -2.74695814e-01f, -3.36412698e-01f, 1.11759925e+00f, 1.02711582e+00f,
  -1.08060551e+00f, -1.11040854e+00f, 1.20028012e-01f, 1.44401908e-01f, 3.97216588e-01f, -8.41014683e-02f, -3.10448021e-01f, -1.18865323e+00f, -8.70753765e-01f, 2.48279586e-01f,
  8.15975130e-01f, -1.75804257e-01f, 3.54278386e-01f, 6.75581619e-02f, -9.79853496e-02f, -9.76315022e-01f, 7.87682593e-01f, -3.26335616e-02f, 7.78803155e-02f, 2.50672340e-01f,
  -6.88046739e-02f, 2.93104667e-02f, -1.36423027e-02f, -1.99413851e-01f, -6.43722177e-01f, 1.38712570e-01f, -2.49505296e-01f, -5.05835056e-01f, 3.15431952e-01f, -4.94703650e-01f,
  4.24054891e-01f, -1.28901139e-01f, 5.30256927e-01f, -2.90876180e-01f, -1.58749664e+00f, 4.39988375e-01f, -6.73294544e-01f, -1.06581640e+00f, 5.02324760e-01f, -2.69963324e-01f,
  2.74495602e-01f, -5.70376933e-01f, 6.58562005e-01f, 5.26500881e-01f, 5.26819885e-01f, 7.43687689e-01f, -6.87845230e-01f, -7.76459038e-01f, -1.21798563e+00f, -8.28200459e-01f,
  -4.04259771e-01f, -4.79557365e-01f, 9.09419656e-02f, 1.14437246e+00f, -2.51470745e-01f, -3.97134244e-01f, -3.95489961e-01f, -3.20645243e-01f, -3.38591129e-01f, -5.36718488e-01f,
  -3.41891855e-01f, -9.56231475e-01f, -7.50616431e-01f, 2.15847120e-01f, -5.26329279e-01f, -8.88969421e-01f, -4.04609025e-01f, -1.00733250e-01f, -8.48367035e-01f, 4.74983990e-01f,
  4.37078290e-02f, 6.69892013e-01f, -1.38245404e+00f, 3.53966057e-02f, -4.64697748e-01f, -4.63667303e-01f, 5.32178283e-01f, 8.32010746e-01f, -6.54138744e-01f, -8.74218524e-01f,
  7.13379920e-01f, 1.18614697e+00f, 3.11679244e-01f, 3.18049043e-01f, -4.82843459e-01f, -4.62851942e-01f, -8.67877454e-02f, -5.60220063e-01f, 6.62831426e-01f, -4.00080591e-01f,
  -1.37290582e-01f, -1.51015073e-01f, -5.55947125e-01f, -7.14181006e-01f, 6.72449231e-01f, -5.48957586e-01f, 7.74861038e-01f, 8.70703936e-01f, -1.45677710e-02f, -1.03761852e+00f,
  -2.74820179e-01f, 6.69075370e-01f, -6.26672208e-01f, 3.77360404e-01f, -4.87807430e-02f, 3.50440741e-01f, -2.80992955e-01f, 3.28424931e-01f, -8.89956653e-01f, 4.82594632e-02f,
  4.39214021e-01f, 1.40756071e-01f, 1.46895438e-01f, 6.80013597e-01f, -3.69967639e-01f, 1.13979355e-01f, -1.18444240e+00f, -2.90357530e-01f, 3.90766561e-01f, 4.80061211e-02f,
  -3.01477730e-01f, 4.17405576e-01f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  2.50808243e-03f, 7.81105980e-02f, -6.34685382e-02f, 4.53814864e-02f, 2.34639458e-02f, -2.53629595e-01f, -3.16729359e-02f, 3.48663330e-01f, -2.94355094e-01f, 3.55165035e-01f,
  -6.06059432e-01f, -5.62589943e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 4, 8
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 4, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        16, 4, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        16, 4, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        16, 12
    );
    }
    