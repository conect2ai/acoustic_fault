/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  2.91861370e-02f, 3.04762632e-01f, 2.63781935e-01f, 1.24785468e-01f, 1.86103389e-01f, 8.12056139e-02f, 1.02603339e-01f, 7.62140052e-03f, -1.32392392e-01f, -4.64977473e-02f,
  -5.50449453e-03f, -1.44811332e-01f, -1.31454691e-01f, 7.62333348e-03f, -3.80758569e-02f, 1.14781328e-01f, 1.69196084e-01f, 9.99937952e-02f, -1.07604869e-01f, 2.30779406e-02f,
  -1.37887061e-01f, -4.06770296e-02f, -1.61428675e-01f, -1.82517707e-01f, -7.41899246e-03f, -1.38040274e-01f, 3.37140709e-02f, -2.77099237e-02f, -3.39214578e-02f, 5.05769392e-04f,
  3.02490275e-02f, 4.51138951e-02f, -1.03184804e-01f, -2.81222705e-02f, -3.30288545e-03f, -8.76223743e-02f, 5.36334142e-02f, -2.09781434e-02f, -4.01280895e-02f, -2.94960849e-02f,
  -4.44644177e-03f, -7.58405849e-02f, -7.92012289e-02f, -1.02020524e-01f, -1.49735855e-02f, 2.71504512e-03f, -4.05439436e-02f, -1.16203770e-01f, -4.06150632e-02f, -2.31044181e-02f,
  2.71803103e-02f, 7.61012360e-02f, 5.32999672e-02f, -3.63500938e-02f, -2.49252990e-02f, -1.77927408e-02f, 4.30426262e-02f, -1.23283699e-01f, 2.22696667e-03f, -1.92696750e-01f,
  6.01502880e-03f, -6.58977451e-03f, -3.87890302e-02f, -1.03631429e-01f, -1.00444160e-01f, -5.95156886e-02f, -3.70183736e-02f, -7.90192783e-02f, -1.00802325e-01f, -9.48566422e-02f,
  -2.34585758e-02f, -1.27204638e-02f, -2.25414336e-02f, -1.73433989e-01f, -1.28928974e-01f, -9.86261666e-03f, -6.74198791e-02f, -8.46505836e-02f, -7.21599609e-02f, 9.55154840e-03f,
  -1.24277972e-01f, -7.48178065e-02f, 2.46416740e-02f, -1.07263975e-01f, 2.02980842e-02f, 2.27627847e-02f, -2.79836971e-02f, -9.21213180e-02f, -1.28091395e-01f, -6.09570742e-02f,
  -2.33473659e-01f, 1.16397597e-01f, -1.44512191e-01f, -5.53249791e-02f, -8.44426900e-02f, -6.71942905e-02f, 1.18510425e-02f, -7.22528100e-02f, -5.72051331e-02f, -3.11417319e-03f,
  6.08817115e-02f, -7.47569511e-03f, 1.61287549e-03f, -6.51069582e-02f, -9.18145105e-02f, -5.55582084e-02f, 5.89547530e-02f, -1.02920860e-01f, -2.35953424e-02f, 4.15282547e-02f,
  3.72287929e-02f, -7.50687346e-02f, -5.66928647e-02f, -7.04072490e-02f, -1.04166694e-01f, -2.36887913e-02f, -7.09988400e-02f, -2.00033672e-02f, -5.46746068e-02f, -1.01628803e-01f,
  3.93186837e-01f, -1.78533167e-01f, -1.70370474e-01f, 5.62576875e-02f, -2.04172194e-01f, -9.91247073e-02f, -2.44716808e-01f, -5.80916926e-02f, 1.57013256e-02f, -1.64531186e-01f,
  -1.85238704e-01f, 1.48799032e-01f, 7.58407637e-02f, 1.09619245e-01f, 1.71778604e-01f, -8.23778510e-02f, -3.62936184e-02f, 8.94296095e-02f, 1.69413865e-01f, -2.57881882e-04f,
  -8.30278993e-02f, -5.33588566e-02f, 1.18453346e-01f, 8.59168842e-02f, -7.13547990e-02f, 5.15745543e-02f, -1.90848753e-01f, -2.07417339e-01f, -2.33710021e-01f, -1.67552254e-03f,
  4.17878889e-02f, -9.61671099e-02f, -1.68385565e-01f, -1.33102126e-02f, -8.62002447e-02f, -6.52832314e-02f, -9.97755155e-02f, -6.41539469e-02f, -7.70622417e-02f, -2.12248955e-02f,
  -8.57710764e-02f, -1.22320570e-01f, -4.86616604e-02f, -9.25823152e-02f, -1.68737948e-01f, -1.12165794e-01f, -1.00284837e-01f, -3.25277299e-02f, 5.78970835e-03f, -7.38721117e-02f,
  -1.39414862e-01f, -7.61933774e-02f, -1.81684271e-01f, -1.48931578e-01f, -6.57100752e-02f, 3.53721268e-02f, -1.78749457e-01f, -9.08281356e-02f, -1.23311259e-01f, -1.07977189e-01f,
  7.53832376e-03f, 5.53657636e-02f, 1.37786880e-01f, 8.06637257e-02f, 4.99716327e-02f, 4.10880074e-02f, 9.52389166e-02f, 1.01399899e-01f, 3.89984436e-02f, 1.38344362e-01f,
  6.32441863e-02f, 4.21264321e-02f, 1.83881093e-02f, 1.19911529e-01f, 2.96528842e-02f, 2.45430749e-02f, 1.72422156e-01f, 1.44423127e-01f, 9.24022570e-02f, 1.93065014e-02f,
  3.87757495e-02f, 3.63252088e-02f, 4.25830483e-02f, 7.03217238e-02f, 9.80862230e-02f, 1.07999317e-01f, 9.07671303e-02f, 1.01673745e-01f, 8.75132754e-02f, 8.04516748e-02f,
  2.67532039e-02f, -1.33843929e-01f, 3.72723192e-02f, -2.30258346e-01f, -1.06509909e-01f, -9.06548649e-02f, -1.80532143e-01f, -1.09312497e-01f, -1.89486355e-01f, -1.09169289e-01f,
  -1.00816585e-01f, -1.33901983e-01f, -8.43467042e-02f, -1.76911488e-01f, -1.06889620e-01f, -3.29511762e-02f, -2.23605931e-01f, -9.42001194e-02f, -1.61864296e-01f, -7.55312443e-02f,
  -1.50586754e-01f, -1.01066701e-01f, -3.03197205e-02f, -1.02813996e-01f, -1.41457543e-01f, -5.43145975e-03f, -1.66206092e-01f, -1.85306087e-01f, 3.33201773e-02f, -1.87526971e-01f,
  -3.09872121e-01f, 7.33806416e-02f, 2.93997288e-01f, -4.03535999e-02f, 1.95590466e-01f, 1.43945366e-01f, 2.60382682e-01f, 1.12737797e-01f, -9.41205248e-02f, 1.41709492e-01f,
  -4.98810336e-02f, -2.09911391e-01f, -1.34593681e-01f, -1.29731987e-02f, 1.05666332e-01f, 2.76240826e-01f, 2.51143754e-01f, 1.75347105e-01f, -3.82089434e-04f, 8.85197297e-02f,
  3.89387347e-02f, -1.11263074e-01f, -9.43652075e-03f, 4.56599565e-03f, 1.38270706e-01f, 3.74137908e-02f, 7.39330277e-02f, 2.17797328e-02f, -2.46995613e-02f, 1.40750289e-01f,
  -7.66231343e-02f, 4.01148386e-02f, 3.74720432e-02f, -3.88415866e-02f, 3.88387926e-02f, -7.22768679e-02f, 3.15059647e-02f, 2.86676310e-04f, -8.55272785e-02f, 6.57305792e-02f,
  1.71544664e-02f, -7.61978403e-02f, -5.69231659e-02f, 7.60602653e-02f, 5.13059683e-02f, 1.10508474e-02f, 2.84774192e-02f, 2.21371967e-02f, 8.76854062e-02f, 1.76059734e-02f,
  2.00494155e-02f, 5.25611080e-03f, 4.72926125e-02f, 4.21683192e-02f, 1.38437524e-02f, -3.62745076e-02f, 8.84919912e-02f, 1.15781896e-01f, -1.31680211e-02f, 7.75825754e-02f,
  1.36469096e-01f, -7.06582889e-02f, 6.64572865e-02f, 5.80312610e-02f, 7.29484633e-02f, -5.57425171e-02f, -1.28167018e-03f, 6.92083314e-02f, 3.12927216e-02f, -1.16632268e-01f,
  8.25687870e-02f, 5.56209013e-02f, 1.04261197e-01f, 4.16732281e-02f, 7.64335785e-03f, 6.68343231e-02f, 1.77060626e-03f, 8.63443986e-02f, 1.44891098e-01f, 4.25445586e-02f,
  -1.03619292e-01f, -2.22060177e-02f, 9.58706066e-02f, 2.96888426e-02f, 1.15713038e-01f, 1.51612014e-01f, 6.89410605e-04f, -4.23810855e-02f, 1.69105437e-02f, -1.09009985e-02f,
  -2.48801917e-01f, 1.59911858e-03f, -6.93220794e-02f, -3.21443267e-02f, 1.00501567e-01f, -5.36648324e-03f, 4.36831489e-02f, 1.04153179e-01f, 5.65278791e-02f, 7.76503682e-02f,
  7.14964122e-02f, -4.67536878e-03f, 1.28557295e-01f, -4.04771790e-02f, 2.44913828e-02f, -4.72997390e-02f, 3.55909169e-02f, 3.22212204e-02f, 1.42649226e-02f, -5.97516336e-02f,
  3.43584344e-02f, -2.50311084e-02f, -1.12779096e-01f, -1.09241828e-02f, -5.15155829e-02f, -9.31161791e-02f, 3.06434613e-02f, -6.10089153e-02f, -3.92009951e-02f, 1.88656058e-02f,
  -1.87220603e-01f, 1.38493493e-01f, -3.09114512e-02f, 3.30907926e-02f, 1.63641989e-01f, 1.74387500e-01f, 2.94998169e-01f, 1.87234640e-01f, 2.08357990e-01f, 1.33818015e-01f,
  1.09173432e-01f, 1.05620503e-01f, 4.85452488e-02f, 9.44008455e-02f, 4.33482528e-02f, 2.05611184e-01f, -1.61916316e-02f, -4.41692583e-03f, 1.33787736e-01f, 1.76463544e-01f,
  1.26036674e-01f, -8.44546314e-03f, 2.24353950e-02f, 6.01785704e-02f, 2.73456499e-02f, 3.77025306e-02f, 1.07547551e-01f, -8.30658004e-02f, 1.46994228e-02f, 2.66215187e-02f,
  -2.18245294e-02f, -8.36629607e-03f, -6.23910222e-03f, -4.54068556e-02f, 2.89771538e-02f, -6.52854815e-02f, 8.30442607e-02f, 1.20551111e-02f, 5.89746870e-02f, 4.98198234e-02f,
  2.19131205e-02f, -1.70913599e-02f, -3.87785141e-03f, 1.47925317e-01f, -2.73855310e-02f, 1.16150998e-01f, 6.39215112e-02f, 1.06865875e-02f, 1.02237053e-01f, 1.48927703e-01f,
  8.20143074e-02f, -3.96761559e-02f, -3.75799946e-02f, 6.81367964e-02f, 8.01069755e-03f, -5.59415780e-02f, 1.06433228e-01f, 2.16234364e-02f, 6.79533184e-02f, -1.65772308e-02f,
  1.43946316e-02f, -3.25559527e-02f, -3.10551859e-02f, 1.87663324e-02f, 9.69860926e-02f, -4.23049964e-02f, -1.45822570e-01f, 1.00470237e-01f, 6.52878592e-03f, -5.22699878e-02f,
  1.59900542e-03f, 8.93098786e-02f, 1.52246758e-01f, -5.25651872e-03f, 6.48891553e-02f, 2.84457859e-02f, 1.96100352e-03f, 5.03109582e-02f, 1.26402944e-01f, 6.22941330e-02f,
  4.66877259e-02f, -2.90112086e-02f, 9.33451280e-02f, 4.97203767e-02f, 6.34645149e-02f, 5.32363877e-02f, 7.89438859e-02f, -4.53806631e-02f, 2.47471649e-02f, 1.29107181e-02f,
  1.71090782e-01f, -4.09688801e-02f, 2.22352240e-02f, 2.57057920e-02f, 4.80530635e-02f, 1.42010525e-02f, -5.21961227e-02f, 3.18611674e-02f, -2.99707102e-03f, 1.02087900e-01f,
  1.58030968e-02f, 3.01481560e-02f, 1.07918873e-01f, 9.96317901e-03f, -2.71289945e-02f, -4.23684046e-02f, 6.72112331e-02f, 2.21927930e-02f, 5.33474125e-02f, -2.99332161e-02f,
  4.22286205e-02f, 3.81745696e-02f, 1.07673511e-01f, 8.93586650e-02f, 3.95959951e-02f, 1.06552698e-01f, -5.21678850e-02f, 1.96188819e-02f, -5.81573509e-03f, 7.49949813e-02f,
  -1.66019469e-01f, -1.59542248e-01f, -4.59444672e-01f, 1.25257686e-01f, -2.06024479e-02f, -9.50025469e-02f, -2.00950995e-01f, -1.21064618e-01f, 6.99991509e-02f, -2.75129694e-02f,
  7.00260773e-02f, 1.12836532e-01f, -2.72149406e-03f, -2.39894427e-02f, -2.27863118e-01f, -2.03944042e-01f, -4.12377864e-02f, -1.48530111e-01f, -2.00389847e-01f, -3.18268202e-02f,
  1.36563897e-01f, -4.84448224e-02f, -6.77817911e-02f, 3.22645821e-04f, 8.69988576e-02f, 1.91994403e-02f, -1.84387475e-01f, -5.51376380e-02f, -1.72554195e-01f, 5.26977479e-02f,
  -3.54585409e-01f, -2.21191794e-01f, -1.76008075e-01f, -4.46527153e-02f, -6.30022734e-02f, -1.24294430e-01f, -4.96900193e-02f, -2.43514493e-01f, -1.36335820e-01f, -1.95698887e-01f,
  -4.81289253e-02f, -1.24363340e-01f, -1.01626456e-01f, -1.67740449e-01f, -8.87477696e-02f, -8.67485404e-02f, -1.16298862e-01f, -1.92067310e-01f, -1.80215180e-01f, -4.47084717e-02f,
  -4.15642336e-02f, -2.23839685e-01f, -2.55917042e-01f, -1.91371709e-01f, -1.61549434e-01f, -4.63275611e-02f, -2.28479400e-01f, -9.61998478e-02f, -1.12836421e-01f, -3.05335484e-02f,
  6.38542250e-02f, 6.70945644e-02f, 1.66719347e-01f, 8.38828385e-02f, 1.68002471e-01f, 3.97749208e-02f, 1.84008889e-02f, 1.43554553e-01f, 8.67657214e-02f, 4.46594097e-02f,
  1.33663788e-01f, 1.00741863e-01f, 4.62859012e-02f, 1.18844494e-01f, 9.38720480e-02f, 1.05136432e-01f, 6.23061024e-02f, 1.23235710e-01f, 5.51358461e-02f, 3.19186524e-02f,
  6.75961673e-02f, 8.31323788e-02f, 1.39585629e-01f, 1.19463198e-01f, 1.43552229e-01f, 2.74745543e-02f, 8.56196284e-02f, 1.53520137e-01f, 1.38592958e-01f, 6.74721673e-02f,
  7.91741237e-02f, -3.07550102e-01f, -1.05109490e-01f, -1.33406788e-01f, -1.64932296e-01f, -9.08996612e-02f, -1.16808809e-01f, -2.50165820e-01f, -1.23094030e-01f, -1.12680100e-01f,
  -1.23162545e-01f, -1.38125122e-01f, -2.22782969e-01f, -1.93552285e-01f, -9.35913250e-02f, -6.23035207e-02f, -9.18828100e-02f, -1.18205696e-01f, -1.55241027e-01f, -4.45168577e-02f,
  -7.58168697e-02f, -1.14892095e-01f, -1.82238892e-01f, -1.32689014e-01f, -7.62897730e-02f, -1.04662396e-01f, -1.68211341e-01f, -7.55196065e-02f, -2.65579879e-01f, -1.39804721e-01f,
  -6.74080551e-01f, 3.20019782e-01f, -1.22655191e-01f, -1.59699365e-01f, 2.58168757e-01f, 8.83910060e-03f, 3.19035500e-01f, 1.47879153e-01f, -1.36507198e-01f, 9.90764797e-02f,
  1.84483647e-01f, -1.44354731e-01f, -4.29066047e-02f, -4.83167320e-02f, -7.80622065e-02f, 1.02119058e-01f, 6.61254227e-02f, -2.67272949e-01f, -3.67161930e-01f, -6.08314853e-03f,
  8.73315930e-02f, -1.60977349e-01f, -1.74482480e-01f, -1.50247633e-01f, 2.52368040e-02f, -5.29726818e-02f, 1.14758104e-01f, 3.10691390e-02f, 1.69089913e-01f, -7.68073723e-02f,
  -1.52647465e-01f, -4.04558741e-02f, -1.32031709e-01f, -5.43728434e-02f, -2.25903634e-02f, -6.57682568e-02f, -1.16176985e-01f, -1.26068637e-01f, -4.53342199e-02f, 4.33223741e-03f,
  -8.01071897e-02f, 1.44750988e-02f, -7.67650679e-02f, 3.66784148e-02f, -5.86826317e-02f, 1.16476445e-02f, -4.99293655e-02f, -7.60302171e-02f, -9.59773883e-02f, -4.81409989e-02f,
  8.66189450e-02f, -4.56289984e-02f, -9.23822522e-02f, 1.01215594e-01f, -5.72844706e-02f, -8.95464867e-02f, -5.65374270e-02f, -1.51652396e-01f, -3.71115915e-02f, -7.03482404e-02f,
  1.57840177e-02f, -4.58121821e-02f, 7.28822779e-03f, 5.14353961e-02f, 6.86006621e-02f, -2.99264174e-02f, 4.82138358e-02f, 1.82020217e-02f, 2.78561078e-02f, 6.42160177e-02f,
  9.79707167e-02f, 3.24493907e-02f, -2.33135317e-02f, 1.13157995e-01f, 2.76128738e-03f, -6.90248562e-03f, 7.56189972e-03f, 2.61916108e-02f, -4.82891453e-03f, -2.96179149e-02f,
  -4.44340184e-02f, 6.47158995e-02f, 1.41240824e-02f, -7.72648975e-02f, 4.11001733e-03f, -6.83548450e-02f, -7.63579905e-02f, 8.34764913e-02f, 3.31150256e-02f, 2.25197803e-02f,
  -2.44560726e-02f, 5.47914021e-02f, -4.52401675e-02f, -1.21484296e-02f, -1.43639743e-01f, 8.46067816e-02f, -9.17952806e-02f, -1.01317674e-01f, -3.23767541e-03f, -8.77382532e-02f,
  -2.64311116e-02f, -1.51146993e-01f, -7.96230063e-02f, -5.00545949e-02f, -9.39411744e-02f, -1.11992367e-01f, 9.57442224e-02f, -7.71768540e-02f, -1.43759355e-01f, -1.23915859e-02f,
  4.11558375e-02f, 3.99012677e-02f, -2.09138803e-02f, -4.09584716e-02f, 2.58423444e-02f, -1.61210045e-01f, -1.65144261e-02f, 5.63451983e-02f, -1.81382392e-02f, 9.70343202e-02f
};

// L0_fan_Wp_bar (Shape: 52 x 120)
const int L0_fan_Wp_bar_rows = 52;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  1.24671392e-01f, -2.83614039e-01f, 2.32927218e-01f, -3.28607410e-02f, -5.28003871e-01f, -3.44303757e-01f, -4.12299067e-01f, 5.35447448e-02f, -7.93000460e-02f, -3.33098561e-01f,
  -3.29268396e-01f, -2.03302354e-01f, 1.00693241e-01f, 2.24134088e-01f, 3.77312809e-01f, -7.15350807e-02f, 4.69221994e-02f, 4.01957452e-01f, 3.43968540e-01f, -2.97107659e-02f,
  -2.55424887e-01f, 1.49503350e-01f, 3.47037226e-01f, 3.16150606e-01f, -1.04023382e-01f, -2.29120441e-02f, -9.99598298e-03f, -7.78914094e-02f, -8.97940472e-02f, 6.35213628e-02f,
  -1.65262103e-01f, 1.18501931e-01f, 7.13193268e-02f, -1.52733997e-01f, -1.82197526e-01f, -1.44777633e-02f, -6.96032643e-02f, 1.21001922e-01f, -5.89169040e-02f, 1.08624808e-01f,
  -1.56300411e-01f, -6.48355111e-02f, -8.43235701e-02f, -1.40728846e-01f, 4.46930900e-02f, 4.04663160e-02f, 1.59593090e-01f, 2.17812896e-01f, 1.40891165e-01f, -4.10744846e-02f,
  -3.31357658e-01f, -3.31434160e-01f, -9.12523940e-02f, -4.01553959e-02f, 1.57987386e-01f, -2.04839977e-03f, 8.34704414e-02f, 1.56251371e-01f, 1.51561543e-01f, -2.19841637e-02f,
  1.30201103e-02f, -6.49096891e-02f, -6.05284274e-02f, -4.54460159e-02f, 4.73644324e-02f, -1.16253002e-02f, -1.19176984e-01f, -1.06191998e-02f, -3.57098784e-03f, -1.29598398e-02f,
  -4.75913435e-02f, -2.84283757e-02f, 5.90375718e-03f, -2.43970975e-02f, -4.09059599e-02f, -2.77201962e-02f, 3.91783789e-02f, -3.79483476e-02f, -9.19234827e-02f, -2.23465152e-02f,
  -3.40019614e-02f, 3.50439665e-03f, -1.36637138e-02f, 1.23680338e-01f, 7.17131048e-02f, -6.52377084e-02f, -4.41227108e-02f, -1.09219834e-01f, 4.33622263e-02f, -1.78437717e-02f,
  -1.89683452e-01f, -9.58527550e-02f, -7.72887543e-02f, -2.57673431e-02f, -1.62332326e-01f, -3.10342647e-02f, -9.03661326e-02f, 4.77565080e-02f, -2.07297187e-02f, -9.98614281e-02f,
  -1.67240530e-01f, 9.38821211e-03f, -1.53831718e-02f, 3.40699963e-02f, 3.94190177e-02f, -1.17659889e-01f, -8.24458748e-02f, -5.45712672e-02f, 1.06370836e-01f, -4.41640541e-02f,
  -8.15173835e-02f, -2.33590633e-01f, -1.13124959e-01f, -1.44096404e-01f, -3.76304984e-01f, -3.77497189e-02f, -1.23755947e-01f, -4.84947823e-02f, -8.08307678e-02f, -1.95769057e-01f,
  2.36646622e-01f, -1.22103363e-01f, 1.79120049e-01f, 7.85992742e-02f, 1.73195124e-01f, 3.36502135e-01f, 3.93223375e-01f, 2.20267266e-01f, -3.09156124e-02f, -9.86237153e-02f,
  -2.47381553e-01f, -4.51829493e-01f, -2.80675739e-01f, -2.13423908e-01f, -7.56681040e-02f, -7.79939294e-02f, 6.12033457e-02f, 1.11082062e-01f, 4.48070168e-02f, 1.02870122e-01f,
  -8.72064829e-02f, 1.89669982e-01f, 1.38095140e-01f, -1.26047477e-01f, -1.38348401e-01f, -1.24020681e-01f, 1.05347596e-01f, 9.27679539e-02f, 2.97230389e-02f, -1.63294405e-01f,
  -8.09692591e-02f, 1.85176253e-01f, -7.44133592e-02f, -2.27352992e-01f, -8.18948895e-02f, 7.13855550e-02f, 7.70776570e-02f, 3.39627154e-02f, 2.93635251e-03f, 3.36085930e-02f,
  1.54314097e-03f, -1.20154269e-01f, -5.73698804e-02f, -5.92506118e-02f, 1.00443780e-01f, 6.45992085e-02f, 4.76277582e-02f, 7.72522241e-02f, -6.19621128e-02f, -7.07984716e-02f,
  -1.12315789e-01f, -3.36619839e-02f, 1.20335110e-02f, 6.19595777e-03f, -7.35039115e-02f, -5.85630462e-02f, -1.59620970e-01f, -5.92596196e-02f, -1.56372115e-01f, -8.90058279e-02f,
  -1.45365233e-02f, 1.09060332e-01f, -8.55154842e-02f, -5.02890609e-02f, 1.77781563e-02f, -2.39291806e-02f, 1.10102251e-01f, 3.78496796e-02f, -3.61766554e-02f, 1.77585080e-01f,
  9.72915515e-02f, 8.57272893e-02f, 9.31662247e-02f, 1.97296739e-01f, -3.81220765e-02f, 1.43078744e-01f, 1.95425689e-01f, 1.13366343e-01f, 5.56376539e-02f, 1.46299526e-01f,
  3.57764699e-02f, 1.23127446e-01f, 1.58479467e-01f, 5.04483506e-02f, 5.38976192e-02f, 1.58008277e-01f, 7.32524320e-02f, 9.86593440e-02f, 1.54570311e-01f, 8.77222046e-02f,
  -4.56667319e-03f, 1.24313571e-01f, -1.33991465e-01f, -2.05304831e-01f, 1.22486793e-01f, -2.91817505e-02f, 6.69177324e-02f, 5.70104681e-02f, -3.48921530e-02f, 9.69692841e-02f,
  2.37350240e-02f, 6.43306822e-02f, 1.40501544e-01f, 7.73092220e-03f, 1.44205764e-01f, 6.73267767e-02f, -5.45034418e-03f, 6.71759024e-02f, -9.32877585e-02f, -6.50601387e-02f,
  -6.86231032e-02f, 1.23594776e-01f, -1.29580069e-02f, -1.96269862e-02f, 1.41196221e-03f, -1.01959877e-01f, -7.48327896e-02f, 3.35807689e-02f, 1.15675397e-01f, 8.22355226e-03f,
  -7.86761343e-01f, -2.18749672e-01f, 3.56083483e-01f, -2.60835648e-01f, 1.05225548e-01f, 1.01241700e-01f, 2.60269046e-01f, -1.53333411e-01f, -2.88664311e-01f, 5.11219539e-02f,
  -5.16487807e-02f, -6.82269633e-02f, 2.11033691e-02f, -3.19616683e-02f, -6.14622049e-02f, 2.67033190e-01f, 2.35656112e-01f, -6.00923179e-03f, 1.07041173e-01f, 1.44210055e-01f,
  5.81543259e-02f, 2.53053047e-02f, -1.85697451e-01f, -2.04009458e-01f, -3.96387801e-02f, 1.35060074e-02f, 1.83989063e-01f, -4.49074432e-02f, -8.18562508e-02f, -1.77606381e-02f,
  2.48913527e-01f, -1.96151778e-01f, -1.22785039e-01f, -2.57403344e-01f, -7.07277581e-02f, -2.33142510e-01f, -3.59931849e-02f, -1.16222218e-01f, -1.85612902e-01f, 3.02917138e-02f,
  -7.11017922e-02f, -4.65308540e-02f, -2.15348806e-02f, 4.60630916e-02f, -5.97733147e-02f, -5.22470139e-02f, -3.13447416e-02f, -2.20142398e-02f, 3.17801535e-03f, 6.79396465e-02f,
  4.68738228e-02f, 2.92368885e-02f, 3.87728289e-02f, -9.54088941e-02f, 6.54108962e-03f, -9.48580578e-02f, 6.95293248e-02f, -8.62662047e-02f, -6.63420111e-02f, -2.80508101e-02f,
  -8.69837590e-03f, -1.01771683e-01f, 4.94750850e-02f, 1.00655727e-01f, 1.39782103e-02f, 8.39532316e-02f, 1.09552853e-01f, -2.08488735e-03f, 5.65437637e-02f, 6.97688479e-03f,
  8.19185898e-02f, 1.18823409e-01f, 1.67226810e-02f, 1.07960939e-01f, 3.76691706e-02f, -1.06840603e-01f, -7.01965839e-02f, -1.05023429e-01f, -3.83431688e-02f, -1.33320540e-01f,
  -8.84086788e-02f, -3.67969126e-02f, 2.54893806e-02f, -6.33306522e-03f, 1.95680410e-02f, -1.46759421e-01f, -7.49954730e-02f, -9.71763805e-02f, 6.97840378e-02f, -1.02652116e-02f,
  1.86357930e-01f, 2.87866537e-02f, 1.98311836e-01f, -2.22699158e-02f, 8.49384256e-03f, -1.38802409e-01f, -9.58377048e-02f, -9.59117152e-03f, 5.16465027e-03f, 1.37146637e-01f,
  -5.61124049e-02f, 6.97056130e-02f, 1.25254467e-01f, 7.93652907e-02f, 1.04778752e-01f, 1.03346901e-02f, -1.00168683e-01f, 1.83711834e-02f, 1.11632504e-01f, -4.36004475e-02f,
  1.18537629e-02f, 9.69333425e-02f, 6.09048828e-02f, 1.59507662e-01f, 1.10402137e-01f, 1.10530183e-01f, 1.51774362e-01f, 5.29068522e-02f, 1.36973336e-01f, 2.32928261e-01f,
  2.37542897e-01f, 9.17323902e-02f, 2.72443533e-01f, 1.20857909e-01f, -1.04414918e-01f, -3.95556122e-01f, -4.01642084e-01f, -3.51968557e-01f, -6.02054922e-03f, 1.19952872e-01f,
  -3.06051248e-03f, 1.00402847e-01f, 1.12902023e-01f, -1.63541749e-01f, -2.44156793e-01f, 7.54468739e-02f, 9.44914669e-02f, -2.38103680e-02f, -1.69611827e-01f, -2.48684928e-01f,
  -1.72080785e-01f, 1.41546249e-01f, 1.75292611e-01f, -5.01925237e-02f, 2.39143401e-01f, -5.84440632e-03f, 1.60540447e-01f, 2.62407511e-01f, 1.56064481e-02f, 2.92450637e-01f,
  4.45312053e-01f, 2.97693014e-01f, -1.13053404e-01f, -7.35064968e-02f, 1.35217592e-01f, 1.45730972e-02f, 1.19253479e-01f, 1.56979144e-01f, -1.49948016e-01f, -8.12619030e-02f,
  -4.45927214e-03f, -1.70323581e-01f, 3.95829827e-02f, 6.95416331e-02f, -8.78580660e-02f, -2.13528827e-01f, -1.29231974e-01f, -2.50220485e-02f, 5.51782958e-02f, -4.89994697e-02f,
  -1.42507613e-01f, -2.62287213e-03f, 2.90833898e-02f, -2.02894002e-01f, 1.71279106e-02f, 6.29846230e-02f, -8.91733691e-02f, -3.37414793e-04f, -1.67492300e-01f, 1.37054816e-01f,
  1.43540753e-02f, 1.55907711e-02f, -7.09120855e-02f, 4.80116755e-02f, -5.48390709e-02f, -1.55222435e-02f, 4.94600311e-02f, -6.60483679e-03f, -1.63287550e-01f, 3.64032527e-03f,
  -7.11063147e-02f, 1.75501585e-01f, 4.03005742e-02f, 6.38125115e-04f, 3.22359316e-02f, 1.09028183e-02f, -9.19116363e-02f, -1.18368100e-02f, 5.67556173e-03f, 1.01941789e-03f,
  7.16274157e-02f, -9.23931301e-02f, 6.03115745e-02f, -1.48918601e-02f, 1.12127937e-01f, -5.25113903e-02f, -4.59140763e-02f, -2.79979650e-02f, 1.57094628e-01f, 1.74472332e-01f,
  -5.17234094e-02f, -1.82933241e-01f, 2.02721149e-01f, 2.69914456e-02f, 3.09600383e-02f, 6.51613697e-02f, 1.20266698e-01f, -1.07101917e-01f, -8.20901841e-02f, -2.05323342e-02f,
  -1.21547565e-01f, 9.84597602e-04f, 1.73434138e-01f, -1.62397772e-01f, -1.29239768e-01f, -8.17201957e-02f, -1.30167440e-01f, -1.93385914e-01f, -3.25678289e-02f, 3.28749046e-02f,
  -5.48273511e-02f, -2.40822896e-01f, -2.42869169e-01f, -2.69620359e-01f, 9.75434184e-02f, -2.03348771e-01f, -5.68688624e-02f, -1.35871887e-01f, -2.74027497e-01f, -2.13778719e-01f,
  2.17067704e-01f, 3.19193125e-01f, 1.38185859e-01f, -2.94088479e-02f, 2.18508869e-01f, 9.94573087e-02f, 2.61776060e-01f, 3.69031467e-02f, -7.12560117e-02f, 4.01493646e-02f,
  1.46831617e-01f, -1.90563612e-02f, 2.30250880e-02f, -9.80326012e-02f, -3.60585153e-02f, -7.07315356e-02f, -5.47653511e-02f, -5.84924556e-02f, -9.27636474e-02f, -1.24283642e-01f,
  -1.20270317e-02f, -3.44493352e-02f, -1.66709676e-01f, -7.59853646e-02f, -5.28836623e-03f, -1.02028690e-01f, -1.31621644e-01f, -2.77790967e-02f, 7.57235661e-02f, -1.58175677e-01f,
  1.63846672e-01f, 2.70833433e-01f, -1.65352181e-01f, -7.43146017e-02f, 5.04796859e-03f, -1.72947109e-01f, -1.23889349e-01f, -1.25685826e-01f, -1.31848678e-02f, -1.77612826e-01f,
  -1.13652796e-01f, -3.35559174e-02f, 2.31108218e-02f, -7.18253478e-02f, -2.15633176e-02f, -1.05395339e-01f, -1.04302399e-01f, -1.73595831e-01f, -1.82303861e-01f, -1.26680061e-01f,
  -8.15211013e-02f, 4.73211519e-02f, 8.11099708e-02f, -4.41913046e-02f, -2.98812836e-02f, 9.44005847e-02f, 1.54296728e-02f, 6.70442544e-03f, 9.37122107e-03f, -1.13995284e-01f,
  1.03914723e-01f, 1.68680921e-01f, 1.05682909e-01f, -2.41709873e-02f, 6.83895424e-02f, 6.05921000e-02f, -1.41493931e-01f, -1.84269454e-02f, -5.26398569e-02f, 8.40941295e-02f,
  -2.31741015e-02f, -4.63964455e-02f, -1.37909144e-01f, 6.03703856e-02f, 5.55007048e-02f, 5.13181537e-02f, 7.62448981e-02f, -6.67409748e-02f, -6.58357441e-02f, 5.96706495e-02f,
  6.02121130e-02f, -6.70575500e-02f, 2.72071045e-02f, -1.56523257e-01f, -4.92679030e-02f, 8.08353350e-02f, -5.08719906e-02f, -9.23164934e-03f, -3.00347283e-02f, -3.47656123e-02f,
  -1.18499614e-01f, 2.59098887e-01f, -1.01075828e-01f, 1.28397988e-02f, 9.87587944e-02f, 1.16096437e-01f, -8.22406635e-02f, 1.90515351e-02f, 6.34972528e-02f, -4.52084243e-02f,
  1.17016630e-02f, 5.22398800e-02f, 6.84544519e-02f, -1.12865664e-01f, -1.51063055e-01f, -6.11386709e-02f, -1.22593068e-01f, -9.45574418e-02f, -7.32032135e-02f, 8.07869285e-02f,
  -1.50146008e-01f, -1.25670314e-01f, -1.17748156e-01f, 1.08260341e-01f, -9.59527194e-02f, -1.35303557e-01f, 2.56166444e-03f, -5.97307645e-02f, -6.97307512e-02f, -2.63747156e-01f,
  6.68435872e-01f, -1.28559455e-01f, -8.69947746e-02f, 1.28342420e-01f, -1.26025602e-01f, 3.48263495e-02f, -1.92954779e-01f, 7.03665763e-02f, 1.38757676e-01f, -1.48686051e-01f,
  1.45126253e-01f, 3.01616997e-01f, 2.48713017e-01f, 4.94138189e-02f, 1.60703599e-01f, -2.60836750e-01f, -2.83318162e-01f, 5.83741963e-02f, 3.10200781e-01f, -5.32891974e-02f,
  -1.77895620e-01f, -9.07327458e-02f, 5.23907915e-02f, 2.81430129e-02f, -2.94006377e-01f, 4.09281580e-03f, -2.59855062e-01f, -1.21761613e-01f, -2.09737405e-01f, -1.96816802e-01f,
  1.18841447e-01f, 2.74389982e-01f, 9.64056253e-02f, 1.60082653e-01f, -2.25509498e-02f, 1.47995064e-02f, 1.32333055e-01f, -4.49295677e-02f, 8.72418005e-03f, 3.70139852e-02f,
  5.24235032e-02f, -4.82745245e-02f, -7.39120096e-02f, -1.52529944e-02f, -1.66735705e-02f, 2.81461589e-02f, -8.69974270e-02f, 4.94012311e-02f, 7.04588667e-02f, -1.07863754e-01f,
  -3.01623996e-02f, 9.58411917e-02f, 8.94023180e-02f, 1.34854764e-01f, 1.42205790e-01f, 1.54535472e-01f, 6.22259192e-02f, 5.98378666e-02f, 1.97779775e-01f, 2.91528571e-02f,
  6.83070123e-02f, -2.50002369e-02f, 1.12033889e-01f, -3.81380366e-03f, 1.10314973e-02f, 2.76517700e-02f, 5.08447662e-02f, -1.62937231e-02f, 3.02769635e-02f, -1.49597093e-01f,
  -4.44692187e-02f, 6.56014457e-02f, 1.69335410e-01f, -3.49200144e-02f, 9.14004147e-02f, -6.69624954e-02f, 9.02509242e-02f, 5.67122437e-02f, 3.25948298e-02f, 1.20252281e-01f,
  8.92006606e-03f, -5.28325140e-02f, -5.30824400e-02f, -6.04668371e-02f, 7.75143504e-02f, -5.35935815e-03f, 3.69614288e-02f, 5.60930325e-03f, -1.24423623e-01f, -3.19245905e-02f,
  2.32176781e-02f, 3.05247456e-01f, 6.60916939e-02f, -1.05837204e-01f, -6.74879476e-02f, -2.42394693e-02f, 1.58485949e-01f, 3.64630185e-02f, -6.44947439e-02f, 7.69826323e-02f,
  6.25630841e-02f, 9.08784568e-03f, -4.89866547e-03f, -3.33675765e-03f, -1.11598581e-01f, 1.73485696e-01f, 8.11127648e-02f, 1.11138768e-01f, 3.35737169e-02f, -1.70299008e-01f,
  -1.56000122e-01f, 3.44397426e-02f, 2.18496874e-01f, 1.92501038e-01f, 8.21767077e-02f, 8.56635347e-02f, -7.49226287e-02f, -3.68521288e-02f, 1.00814641e-01f, -1.01093903e-01f,
  6.65502787e-01f, -2.44792566e-01f, 2.56231278e-01f, 2.37740487e-01f, 7.77403712e-02f, 1.74077570e-01f, 1.70748651e-01f, 6.83881640e-02f, 3.40454206e-02f, 8.84042010e-02f,
  -1.29174337e-01f, -1.00369640e-01f, -1.66294008e-01f, -1.36958230e-02f, -5.11758104e-02f, -1.88614503e-02f, 1.18678480e-01f, 2.26874486e-01f, 1.71105474e-01f, 9.66650918e-02f,
  -1.33336978e-02f, 4.51739505e-02f, 1.87275290e-01f, -4.72351834e-02f, -1.77199021e-01f, -5.01418933e-02f, 3.98181155e-02f, -1.58904806e-01f, -1.68589965e-01f, -5.01998328e-02f,
  -2.52596498e-01f, 7.18601346e-02f, 3.58780399e-02f, -2.30005950e-01f, -6.34603649e-02f, 1.57222524e-01f, -2.82268710e-02f, 2.65950076e-02f, -1.61473695e-02f, -8.26925486e-02f,
  -1.29772385e-03f, -7.01684728e-02f, -5.00669293e-02f, -2.33345311e-02f, -1.16727531e-01f, -3.96065190e-02f, -6.76346645e-02f, 1.80587042e-02f, -5.77119738e-02f, -4.13750038e-02f,
  -1.93528429e-01f, -1.45694733e-01f, -1.62911758e-01f, 5.72825484e-02f, 1.56059777e-02f, 3.94926034e-02f, -5.39434887e-02f, -1.15092792e-01f, 1.54072484e-02f, 4.10494283e-02f,
  9.21510905e-02f, 3.45557369e-02f, -1.27503678e-01f, -1.02401242e-01f, 5.92952259e-02f, 6.13285564e-02f, -3.34404260e-02f, 3.16226040e-03f, 6.21090233e-02f, -8.61212239e-02f,
  -1.81683362e-01f, 5.16799204e-02f, -1.18670002e-01f, -5.10142855e-02f, -1.05209187e-01f, -1.14443609e-02f, 4.34668213e-02f, -3.25227790e-02f, -1.93874575e-02f, -8.60249400e-02f,
  -2.45431904e-02f, 1.17513528e-02f, -1.61369536e-02f, -1.97895840e-01f, -1.40603185e-01f, -1.10939428e-01f, -1.03642948e-01f, -1.63156956e-01f, 2.92434711e-02f, -3.28907222e-02f,
  -4.92308646e-01f, -1.13229491e-02f, 1.83729917e-01f, -1.04999296e-01f, 7.17979372e-02f, 3.65010537e-02f, 1.23166321e-02f, -1.09089315e-01f, -5.76821864e-02f, 7.82065839e-02f,
  -2.53062081e-02f, 5.26911132e-02f, -8.54279995e-02f, 9.73972026e-03f, 1.04135066e-01f, 1.76742468e-02f, -1.44806534e-01f, 3.47817391e-02f, -1.43364951e-01f, -1.88985839e-01f,
  -1.13527648e-01f, 9.40337032e-02f, 1.25320986e-01f, 1.87535495e-01f, 1.57975212e-01f, 5.19155189e-02f, -6.39720168e-03f, 6.12827204e-02f, 8.55358541e-02f, 1.83526024e-01f,
  3.49827744e-02f, -2.29152128e-01f, -1.42692000e-01f, -9.62147675e-03f, 1.02123981e-02f, -2.60700524e-01f, -5.29957652e-01f, -4.00077254e-01f, 2.22651009e-02f, -1.14600971e-01f,
  8.71010721e-02f, 1.61936805e-01f, 1.01851262e-01f, -2.38111336e-02f, -2.32123628e-01f, -2.14723229e-01f, 8.54026079e-02f, 1.41435996e-01f, 4.17427644e-02f, -2.24927161e-02f,
  1.45053178e-01f, 1.24820337e-01f, 8.30092132e-02f, 1.51134208e-01f, 3.50630581e-01f, 2.75842696e-01f, -2.39344127e-02f, 1.06616989e-01f, 1.11212961e-01f, 3.51799399e-01f,
  1.25445006e-02f, 3.01386695e-02f, -6.21057600e-02f, 6.41475841e-02f, 1.04151718e-01f, 7.19138086e-02f, -1.26537994e-01f, -1.22155964e-01f, 7.44737834e-02f, -2.06930608e-01f,
  2.15178803e-01f, 9.68469456e-02f, -4.17167023e-02f, 9.41343419e-03f, -5.70471995e-02f, -7.46382475e-02f, -1.71163335e-01f, -4.70933318e-02f, -1.53884143e-01f, -7.49255791e-02f,
  1.54567793e-01f, -2.28017736e-02f, -1.66737705e-01f, -2.91659534e-01f, -8.99470896e-02f, 2.63926033e-02f, -6.53864816e-02f, 1.57072335e-01f, -7.46366307e-02f, 1.00867748e-01f,
  3.82232703e-02f, -3.71963009e-02f, 1.09579518e-01f, 9.96935815e-02f, 1.54517759e-02f, 3.21570411e-02f, 1.62307590e-01f, -1.32903587e-02f, 7.19508752e-02f, -7.53404498e-02f,
  -2.03076173e-02f, 3.75128388e-02f, -2.52346918e-02f, -8.98089111e-02f, 1.35391233e-02f, 1.61226228e-01f, 4.44276370e-02f, 2.69484594e-02f, 6.77997107e-03f, -2.13609617e-02f,
  1.56669226e-02f, -9.91361588e-02f, 3.20529155e-02f, -9.13322903e-03f, -2.86791120e-02f, 1.04651146e-01f, 6.98888302e-02f, 8.21404234e-02f, 1.05276600e-01f, 6.70933351e-02f,
  -1.01144329e-01f, -2.58511931e-01f, 1.16014928e-01f, 2.61828750e-02f, 2.60560345e-02f, 2.67903991e-02f, 1.22309454e-01f, 8.27052817e-03f, 5.86582497e-02f, -7.14715794e-02f,
  -2.45579556e-02f, 8.30502436e-02f, -1.86170623e-01f, -1.13553926e-01f, 5.75697832e-02f, -1.53544784e-01f, 4.38734218e-02f, -3.45152207e-02f, 1.34743303e-02f, 1.82996094e-01f,
  -1.51788488e-01f, -3.12137157e-01f, -1.28216714e-01f, -3.20974588e-01f, -1.25636071e-01f, -4.08184528e-02f, -3.30099128e-02f, 6.96152747e-02f, -1.16450273e-01f, -1.97287172e-01f,
  -7.38505125e-02f, -5.29936910e-01f, 4.28577483e-01f, 8.88801292e-02f, 1.20741382e-01f, 2.68684447e-01f, 3.44924033e-01f, -5.44405207e-02f, -1.09930992e-01f, -6.53036917e-03f,
  -2.52088308e-01f, -1.03253044e-01f, -1.54974043e-01f, -1.69033274e-01f, -1.21845618e-01f, 1.99329257e-01f, 1.00185409e-01f, 1.96651787e-01f, 3.66051823e-01f, 1.56237453e-01f,
  2.00281162e-02f, 7.61891622e-03f, -3.72061916e-02f, 1.34782381e-02f, -5.81593476e-02f, 4.09876481e-02f, 2.58179964e-03f, -8.55738595e-02f, -2.00332314e-01f, -4.50256355e-02f,
  1.48104310e-01f, -1.52375817e-01f, 8.45980421e-02f, -2.18416378e-01f, -7.59951770e-02f, -1.59718558e-01f, 9.60678905e-02f, -9.67179015e-02f, -3.91809307e-02f, 6.36772544e-04f,
  -1.08947940e-01f, -1.63664147e-01f, -3.20234522e-02f, 8.40738863e-02f, 9.23130214e-02f, 5.98328747e-03f, 5.10310605e-02f, -7.23008439e-02f, -2.34403968e-01f, -7.93523118e-02f,
  -6.33146092e-02f, -9.83418450e-02f, 5.98847717e-02f, 7.31416270e-02f, -7.19473660e-02f, 4.73301858e-02f, -1.13070257e-01f, -5.67979142e-02f, -6.02385029e-02f, -2.83484198e-02f,
  -5.82376644e-02f, 4.63975966e-02f, 2.97430307e-02f, 3.90150491e-03f, 1.04254134e-01f, 3.32056545e-02f, -6.97562471e-02f, 3.40782590e-02f, -1.32004634e-01f, -5.60857244e-02f,
  -4.76746485e-02f, 5.98130301e-02f, -1.36143103e-01f, -5.60860708e-02f, -9.56027061e-02f, -1.04174852e-01f, -9.34846420e-03f, 6.56457543e-02f, 2.23355088e-03f, 3.94944400e-02f,
  -1.03146791e-01f, -6.71011582e-02f, 4.84897234e-02f, 5.15081175e-03f, -8.06385353e-02f, -3.09514198e-02f, -1.16713315e-01f, -1.50919091e-02f, 7.03882845e-03f, -1.79491844e-02f,
  -2.06693597e-02f, -2.06216663e-01f, 1.71680719e-01f, -3.97292264e-02f, -1.05238911e-02f, -1.61274210e-01f, -5.55563942e-02f, -1.66548491e-02f, -7.59814978e-02f, 5.27559444e-02f,
  -1.04303107e-01f, -1.94443613e-02f, -5.26568107e-02f, -5.50412647e-02f, 1.79562613e-01f, -4.79765460e-02f, -1.62670791e-01f, -3.34657095e-02f, -1.33744953e-02f, -4.94489335e-02f,
  -6.22186624e-02f, 1.29911333e-01f, 1.04885101e-01f, 8.04555789e-02f, 6.94513693e-03f, 2.62975991e-01f, 2.56133914e-01f, 2.79203691e-02f, 1.22285532e-02f, 2.04273030e-01f,
  -1.05410971e-01f, 2.38118634e-01f, -6.69489130e-02f, 1.43318132e-01f, 8.08903649e-02f, -8.03666003e-03f, -1.80788085e-01f, -1.35245025e-01f, 2.26969440e-02f, -5.29350806e-03f,
  -4.96508144e-02f, 2.78555267e-02f, 3.53580080e-02f, 1.12705871e-01f, -4.63916250e-02f, 1.66613922e-01f, 1.64749920e-01f, 6.75835460e-02f, 3.65884267e-02f, -1.53253181e-02f,
  2.61511147e-01f, 1.09444112e-01f, -3.36782373e-02f, -3.39121111e-02f, 2.45285004e-01f, 1.05373055e-01f, -7.72242770e-02f, 1.55806005e-01f, 1.45431980e-01f, 3.76001656e-01f,
  -6.94820657e-02f, -2.61787057e-01f, -1.62836388e-01f, 8.37693959e-02f, 3.79493199e-02f, -8.57766196e-02f, 2.56019570e-02f, -2.92392429e-02f, -2.51072310e-02f, -5.57944365e-03f,
  3.61240655e-02f, 6.16800934e-02f, 1.26242116e-01f, -4.73310724e-02f, -1.00909255e-03f, -7.12743029e-02f, -4.58969884e-02f, -1.29744336e-01f, -1.55273583e-02f, 1.09616616e-04f,
  2.13927865e-01f, 5.35558797e-02f, -2.42055897e-02f, 2.44946796e-02f, -1.48759604e-01f, -7.67054558e-02f, -1.28371701e-01f, -3.48269311e-03f, -3.32834542e-01f, 5.72716109e-02f,
  2.90755089e-03f, 4.77677435e-02f, 1.87063720e-02f, 2.43470981e-03f, 9.92274359e-02f, 7.44536445e-02f, 6.33698106e-02f, -1.71903707e-02f, 1.00103505e-01f, 1.03460886e-02f,
  -4.52038236e-02f, -3.69071066e-02f, -4.78524948e-03f, -2.07124621e-01f, -1.12434007e-01f, 5.89604005e-02f, 4.05145809e-02f, 4.52699661e-02f, -1.29012063e-01f, -7.54635334e-02f,
  7.79460138e-03f, 1.28566204e-02f, -8.75936449e-02f, 8.91819969e-02f, -1.11028329e-01f, -7.12185949e-02f, -2.30048075e-02f, 9.86826643e-02f, -9.03857034e-03f, 3.22938412e-02f,
  -1.52824402e-01f, -2.63236731e-01f, -3.99186127e-02f, 1.91963557e-02f, -1.84292812e-02f, -5.42276166e-02f, 4.51436155e-02f, 9.20264348e-02f, 6.38297349e-02f, -6.96093515e-02f,
  3.05480789e-02f, -9.42644179e-02f, 1.93073228e-02f, -1.88068539e-01f, -2.18301844e-02f, -1.56872962e-02f, 7.23476410e-02f, 1.66268811e-01f, 5.58829983e-04f, 1.45243898e-01f,
  1.15929648e-01f, -1.81577578e-01f, -2.89713666e-02f, -1.37032002e-01f, 1.86621633e-04f, -1.25343606e-01f, -6.14655465e-02f, -1.44338459e-01f, -2.63058573e-01f, -1.93517357e-01f,
  -3.34271610e-01f, 2.31295586e-01f, -3.94045450e-02f, -1.88958392e-01f, 2.27160931e-01f, 1.43347621e-01f, 1.00499451e-01f, -4.19774242e-02f, -1.63457081e-01f, -6.04234543e-03f,
  6.21335246e-02f, 4.21400256e-02f, 4.60078232e-02f, 9.42047238e-02f, -5.71333133e-02f, 4.14544158e-02f, 5.65294884e-02f, 2.20850836e-02f, -1.06978297e-01f, -1.09724104e-01f,
  2.20048148e-02f, -5.96649423e-02f, -2.07699493e-01f, -1.69114470e-01f, 2.00308040e-02f, -1.62352938e-02f, 6.24656081e-02f, -3.19304317e-03f, 1.39032423e-01f, 1.66573301e-01f,
  6.33289739e-02f, 1.04666226e-01f, 6.08538091e-02f, 1.82053458e-03f, 1.15777865e-01f, -2.05096990e-01f, 2.47453968e-03f, 2.48908047e-02f, 1.50057124e-02f, -1.17796443e-01f,
  -1.09725175e-02f, 8.12155008e-02f, 8.79605263e-02f, -9.57152173e-02f, -1.92192614e-01f, -8.86878520e-02f, -5.85714169e-02f, -2.10206091e-01f, -2.93748111e-01f, -2.08638027e-01f,
  2.00719327e-01f, 1.92504168e-01f, 9.04547423e-02f, -1.01191834e-01f, -9.60575417e-02f, 4.74234074e-02f, -4.60248850e-02f, -6.33140653e-02f, -1.67463318e-01f, -2.42198661e-01f,
  2.68848017e-02f, 9.61287171e-02f, 7.96981528e-02f, -1.66376103e-02f, 1.77834425e-02f, 4.02996466e-02f, 1.48500904e-01f, 7.81311393e-02f, 1.95601992e-02f, 2.16404032e-02f,
  7.77446181e-02f, -9.88952070e-03f, 1.12607796e-02f, 1.56844519e-02f, 6.48396090e-02f, -3.46668810e-02f, -1.44711388e-02f, -2.83050463e-02f, 4.59603220e-02f, 1.43467430e-02f,
  1.27894925e-02f, 2.05897149e-02f, 2.88266800e-02f, -8.19171667e-02f, 9.38686579e-02f, -8.42678174e-02f, -6.60844594e-02f, -9.83727798e-02f, -2.38318685e-02f, -7.12181926e-02f,
  -2.09288970e-01f, 2.97957838e-01f, -1.66291386e-01f, -6.14162013e-02f, 7.78948143e-02f, 3.11662443e-02f, 5.49527258e-02f, -3.88069935e-02f, -8.16532671e-02f, -1.98197022e-01f,
  -1.07791007e-01f, -6.88935816e-03f, 3.34080309e-02f, -1.88790277e-01f, -1.32112414e-01f, -1.20973490e-01f, 5.19981794e-02f, -6.56011850e-02f, -3.17637026e-02f, -8.15349817e-02f,
  -8.96299556e-02f, -1.49462387e-01f, -1.47868618e-01f, -1.81608036e-01f, -5.34108877e-02f, -1.71869621e-01f, -5.10275625e-02f, -1.42364085e-01f, -1.15377471e-01f, -2.41000295e-01f,
  -3.52693915e-01f, 3.36529315e-01f, 3.26130629e-01f, -2.00034529e-01f, 1.11976132e-01f, 1.40558198e-01f, 1.82994276e-01f, 4.12579663e-02f, -1.06221721e-01f, 8.70128125e-02f,
  1.38473377e-01f, -1.49624437e-01f, -8.02962035e-02f, -8.15065764e-03f, -2.01248303e-02f, 1.10421441e-01f, -1.14793107e-01f, -1.23960778e-01f, -2.07135141e-01f, -3.24610859e-01f,
  -1.54691890e-01f, -2.76395559e-01f, -3.40626955e-01f, -1.00313179e-01f, -8.23546797e-02f, -1.86940312e-01f, 1.13882847e-01f, 5.01937307e-02f, -4.31143641e-02f, -3.02567761e-02f,
  2.42548838e-01f, 4.51159298e-01f, 3.74042094e-02f, -1.93233881e-02f, 9.32211131e-02f, -7.91336298e-02f, -9.39258933e-02f, 6.20663725e-02f, 7.19137490e-02f, 3.14075835e-02f,
  8.36852342e-02f, 2.07826957e-01f, -2.98138950e-02f, 1.67631149e-01f, 1.84438258e-01f, 1.04313135e-01f, -7.34193400e-02f, -6.05994388e-02f, -8.11110958e-02f, -5.02573550e-02f,
  -1.35645032e-01f, -1.14081316e-01f, -1.35825919e-02f, 6.58661500e-02f, -1.85050517e-02f, 6.07351866e-03f, 1.68606609e-01f, 1.07617170e-01f, -3.95100564e-02f, -6.30023405e-02f,
  -1.69181824e-01f, -9.37473588e-03f, 1.46995541e-02f, 6.34411117e-03f, -2.11595185e-03f, -7.63606206e-02f, -1.29217533e-05f, 2.00902089e-01f, -1.51227694e-02f, -5.41919544e-02f,
  1.30479589e-01f, -3.47194658e-03f, 2.04447657e-02f, 9.37440842e-02f, -2.97706388e-02f, 7.40550086e-02f, 1.11785397e-01f, 5.68360314e-02f, 9.01990756e-02f, 5.66722676e-02f,
  2.28655199e-03f, 8.34926516e-02f, 6.76058978e-02f, -4.37876806e-02f, 2.02699304e-01f, 1.54737011e-01f, 1.31283998e-01f, 8.41418430e-02f, -1.45788491e-02f, 1.10682517e-01f,
  2.32020505e-02f, 2.60820925e-01f, 7.38681033e-02f, -6.14525899e-02f, 6.08911440e-02f, 6.15122207e-02f, 8.61323625e-02f, 8.33643321e-03f, 1.81740493e-01f, 9.34654251e-02f,
  1.78978011e-01f, 3.29299122e-02f, 6.67273253e-03f, 5.93861230e-02f, 7.81669542e-02f, 6.94957450e-02f, -1.18752941e-01f, -8.41619372e-02f, -1.25012055e-01f, 6.21834397e-02f,
  -2.58700550e-01f, -2.22585082e-01f, -1.14041425e-01f, -4.71006706e-03f, 2.47172490e-02f, -5.41013069e-02f, 1.16770372e-01f, 2.87336558e-02f, 2.34223204e-03f, -5.72705641e-02f,
  7.26130068e-01f, -8.12845305e-02f, -5.51047958e-02f, 1.62188396e-01f, -2.24073157e-01f, -5.61216809e-02f, -2.22586930e-01f, 4.05608863e-02f, 1.50026724e-01f, -2.52199564e-02f,
  2.79645696e-02f, 2.18069956e-01f, 1.86630636e-01f, 2.21627876e-01f, 1.73582882e-01f, -7.98271522e-02f, -1.03126094e-02f, 2.13040039e-01f, 1.77967846e-01f, 5.54623753e-02f,
  -9.71379876e-02f, -8.59148130e-02f, 1.32638037e-01f, 6.24397062e-02f, -2.51384377e-01f, 1.01092964e-01f, -1.98680386e-01f, -1.32772014e-01f, -3.83073208e-03f, -1.10710025e-01f,
  8.09571669e-02f, 2.90190484e-02f, 1.54231945e-02f, -1.64576754e-01f, -1.13770418e-01f, -4.32383902e-02f, 4.89026960e-03f, -1.32722110e-01f, -5.20485640e-02f, -1.61756188e-01f,
  -4.46074978e-02f, -7.12421909e-02f, 2.34458297e-02f, -4.51739542e-02f, -1.57036498e-01f, -1.58130214e-01f, 4.94784722e-03f, 8.97160023e-02f, 7.96740409e-03f, -1.75160654e-02f,
  2.80297101e-02f, 5.79428952e-03f, -4.93630096e-02f, -4.78685163e-02f, 1.48771062e-01f, 2.04050057e-02f, -8.46714899e-02f, -7.08695725e-02f, 5.90966642e-02f, -5.24964835e-03f,
  6.88221455e-02f, 1.93310335e-01f, 1.01207800e-01f, 1.50468377e-02f, 4.53779250e-02f, 1.01738915e-01f, 4.68038842e-02f, -2.66858265e-02f, 3.47794630e-02f, -1.26784071e-02f,
  1.90172426e-03f, -5.16204629e-03f, 6.80277124e-02f, 4.02064435e-02f, 2.74768677e-02f, 4.22207862e-02f, -2.61753704e-03f, -2.31806468e-02f, 7.30153546e-02f, -7.31647462e-02f,
  3.00493371e-02f, -1.27865910e-03f, -7.00063035e-02f, 2.28362028e-02f, -9.66645852e-02f, 8.74457881e-02f, 3.39327613e-03f, 1.61182396e-02f, -3.34540047e-02f, -6.55655265e-02f,
  -3.12503129e-01f, 2.95796484e-01f, 4.89219017e-02f, -9.10616666e-02f, -1.73921630e-01f, 2.68324767e-03f, 6.86348453e-02f, -1.10976383e-01f, -1.08721539e-01f, -2.79837549e-02f,
  -1.02573909e-01f, 1.04367636e-01f, 6.24820627e-02f, 3.65307890e-02f, -2.33721565e-02f, -8.51668790e-02f, 1.34073431e-03f, 8.02449062e-02f, 4.70994301e-02f, -1.57412976e-01f,
  -7.18410015e-02f, 2.45743357e-02f, 6.80998340e-02f, 5.91320246e-02f, 2.06216648e-02f, 1.23865172e-01f, -4.15613353e-02f, 4.29070443e-02f, 1.98696315e-01f, 5.91477714e-02f,
  4.17390913e-01f, -1.62126184e-01f, -7.94935450e-02f, 3.05829495e-01f, 2.04861581e-01f, 2.20563099e-01f, 1.79922536e-01f, 1.16207875e-01f, 2.50375241e-01f, 4.68957126e-02f,
  -1.20481821e-02f, 8.14391151e-02f, 7.46252537e-02f, -5.36779314e-02f, 1.48545593e-01f, 6.37965277e-02f, 1.05510242e-01f, -7.94045813e-03f, 3.98263410e-02f, 8.02992210e-02f,
  1.83804378e-01f, 5.14877737e-02f, 4.57790382e-02f, 3.13239284e-02f, -2.86948793e-02f, 1.59482900e-02f, 2.00236160e-02f, 4.05426789e-03f, 2.17784778e-03f, -2.09038873e-04f,
  -2.61782706e-01f, -8.34316388e-02f, 1.55769810e-01f, -3.75256054e-02f, -1.31648317e-01f, -1.41941085e-01f, -3.33674252e-02f, -1.66463286e-01f, -1.82789385e-01f, -6.05952330e-02f,
  -3.07907853e-02f, -2.35410333e-02f, 6.61039874e-02f, -2.30158828e-02f, -1.11995615e-01f, 2.69247331e-02f, -1.05178118e-01f, 7.88101852e-02f, 1.14061989e-01f, -1.78489729e-03f,
  4.21830714e-02f, -4.03500423e-02f, 3.83164212e-02f, 1.77568883e-01f, 9.24106687e-02f, -3.08558811e-02f, -1.23057067e-01f, -7.47567117e-02f, 6.31300732e-02f, 1.59827873e-01f,
  2.92739391e-01f, 1.08939871e-01f, 1.57492951e-01f, 8.11024010e-02f, 6.48166100e-03f, -7.13515729e-02f, -1.25663856e-03f, 1.03844032e-01f, 1.87922060e-01f, 9.48538259e-02f,
  -1.30167946e-01f, 1.60750806e-01f, -1.05594754e-01f, 1.83527678e-01f, 9.60795581e-02f, -3.24760377e-03f, 8.64429772e-03f, -4.01759148e-02f, -1.28029600e-01f, 2.82344334e-02f,
  3.43169123e-02f, -6.21434860e-02f, -2.82225221e-01f, -1.89163312e-01f, -1.38419628e-01f, 1.63230617e-02f, 9.16841701e-02f, 3.25727016e-02f, -8.78396817e-03f, 1.63503550e-02f,
  -8.76082033e-02f, 3.69814895e-02f, 1.34899586e-01f, -4.29120734e-02f, -9.28092077e-02f, -1.59521073e-01f, 1.06447108e-01f, -8.82715210e-02f, -2.31473565e-01f, -1.74563676e-01f,
  -1.72935143e-01f, -6.03404455e-02f, -1.32342905e-01f, 1.19732469e-01f, -7.95536675e-03f, 1.75461918e-02f, -1.39412254e-01f, 3.99499107e-03f, 6.27210885e-02f, 1.56922471e-02f,
  -5.78035936e-02f, 1.91178530e-01f, 1.37357041e-01f, 5.45686893e-02f, 1.12843357e-01f, 2.09351808e-01f, 4.51220721e-02f, 2.06870195e-02f, 7.20040947e-02f, 1.51022330e-01f,
  3.48572046e-01f, 3.60275298e-01f, 1.19176745e-01f, 1.92832835e-02f, 1.32748693e-01f, 2.81690121e-01f, 3.55823398e-01f, 1.27377674e-01f, -9.68054123e-03f, 1.16558343e-01f,
  5.14238328e-02f, -2.37453222e-01f, -9.96593982e-02f, -1.42962649e-01f, 5.09035811e-02f, -3.46798114e-02f, -1.35737121e-01f, -1.23273447e-01f, -5.30517772e-02f, -1.76967103e-02f,
  -1.69087589e-01f, 9.00249407e-02f, 1.84277311e-01f, -7.79948011e-02f, 2.72138938e-02f, -1.55761063e-01f, 9.07375589e-02f, 2.09550768e-01f, 8.73462334e-02f, -2.06619129e-01f,
  -1.05337061e-01f, 4.49484974e-01f, -2.98582017e-01f, 7.18402565e-02f, 1.25663253e-02f, -1.02727301e-01f, -4.79747765e-02f, -1.54249175e-02f, 7.51044825e-02f, -4.85177673e-02f,
  1.83236524e-02f, 1.21684521e-02f, -3.14841084e-02f, -6.50229082e-02f, -4.45923358e-02f, 7.21369609e-02f, -3.39518744e-03f, 1.57161616e-02f, -6.67163506e-02f, -1.01987667e-01f,
  -1.95181027e-01f, 1.08696677e-01f, 3.44301909e-01f, 1.47444695e-01f, 8.98813084e-02f, -2.21658975e-01f, 1.73989370e-01f, 1.04526825e-01f, -4.47324179e-02f, -1.85241982e-01f,
  6.74761459e-02f, -1.44174267e-02f, 9.17965323e-02f, -2.31467132e-02f, -4.71368320e-02f, -8.41094777e-02f, -7.98712075e-02f, -6.81568310e-03f, 3.25768664e-02f, 6.15302958e-02f,
  -1.02087632e-01f, -7.22971633e-02f, -1.68292329e-01f, -1.22357374e-02f, -1.64809287e-01f, 1.49967177e-02f, 2.77127884e-02f, -4.09085723e-03f, 2.22466467e-03f, 7.53757954e-02f,
  1.61973934e-03f, -5.10352710e-03f, 7.41207451e-02f, -7.73234740e-02f, 9.92080290e-03f, -6.23984560e-02f, -1.15466930e-01f, -3.91879790e-02f, 3.42499875e-02f, 7.11714178e-02f,
  -1.84753463e-01f, 1.82875454e-01f, -3.77558172e-01f, -9.70595926e-02f, 1.08853854e-01f, -1.19884938e-01f, -1.39382794e-01f, -6.50756657e-02f, 6.27057180e-02f, -1.22453079e-01f,
  1.06396586e-01f, -1.65803820e-01f, -4.56724986e-02f, -8.62546563e-02f, -1.29600525e-01f, -1.27827138e-01f, 5.14544025e-02f, -1.03807002e-01f, -6.70316815e-02f, 1.66515878e-03f,
  -1.52765185e-01f, -4.15359437e-02f, -8.80957767e-02f, -2.90523116e-02f, -1.52294666e-01f, -2.50936121e-01f, 7.08668381e-02f, -1.39955813e-02f, 1.30512804e-01f, -5.59742674e-02f,
  4.19303089e-01f, -2.31324285e-01f, -3.28060597e-01f, 1.69923291e-01f, -2.00890273e-01f, -6.60108179e-02f, -2.16185763e-01f, 2.52569877e-02f, 1.10991448e-01f, -2.61741132e-01f,
  3.47853228e-02f, 2.01639578e-01f, 8.27582479e-02f, 1.52983025e-01f, 1.23972274e-01f, -2.79036522e-01f, -2.88583338e-01f, 6.29661605e-02f, 2.45897055e-01f, 1.41479626e-01f,
  1.14405365e-03f, 3.79910506e-02f, 7.79372454e-02f, 6.18135259e-02f, -1.48043498e-01f, -1.46951769e-02f, -3.21748734e-01f, -1.53061643e-01f, -1.65053755e-01f, -3.29351068e-01f,
  -4.67467979e-02f, 7.24417791e-02f, 6.21658601e-02f, -3.28506455e-02f, -5.79600669e-02f, 7.01966882e-02f, 2.95981709e-02f, -1.14457779e-01f, -7.84746408e-02f, -2.91967802e-02f,
  5.48912138e-02f, -3.12601626e-02f, 6.41940162e-02f, -1.33409739e-01f, -9.00833011e-02f, -2.88794339e-02f, -5.53048439e-02f, 8.51041228e-02f, -3.39697599e-02f, -5.44708185e-02f,
  -5.97196706e-02f, -9.52392593e-02f, -6.94900826e-02f, -7.31741562e-02f, -7.24418387e-02f, 1.23247895e-02f, -7.76134729e-02f, 1.02233021e-02f, -8.97683576e-02f, -1.82649180e-01f,
  6.45337328e-02f, 2.39463989e-02f, -3.03595643e-02f, 1.56349931e-02f, -5.60243130e-02f, 2.69537792e-02f, -5.82108572e-02f, -7.61581659e-02f, 5.67340106e-02f, 6.52763322e-02f,
  1.31610453e-01f, 4.70500477e-02f, 1.76225156e-02f, 6.23595081e-02f, -4.41347212e-02f, 6.95779100e-02f, 9.82460678e-02f, -2.64197146e-03f, -3.18868048e-02f, -5.56007437e-02f,
  6.52464479e-02f, 1.01572484e-01f, -9.42329168e-02f, 2.03527845e-02f, -7.70824924e-02f, 7.54958689e-02f, 6.70871735e-02f, 5.78828976e-02f, -4.79791984e-02f, -2.50881892e-02f,
  2.21462622e-01f, 1.63412645e-01f, -7.17240646e-02f, -4.17662226e-02f, 4.83506136e-02f, -1.17541542e-02f, 2.07130127e-02f, -2.00754274e-02f, -2.59110127e-02f, -1.90276243e-02f,
  5.44437692e-02f, 1.25727981e-01f, 1.66003667e-02f, 2.19364446e-02f, -5.25738299e-02f, 5.43392450e-02f, -1.56131744e-01f, 3.85423414e-02f, 5.25760278e-03f, 1.53227262e-02f,
  -7.02050030e-02f, 1.23372423e-02f, 5.15484959e-02f, 3.23271006e-02f, -1.77103393e-02f, 4.22676876e-02f, -6.84392750e-02f, -1.27175495e-01f, -2.97765788e-02f, -4.43460308e-02f,
  -3.59122008e-01f, -7.86970109e-02f, -2.21065328e-01f, -2.77472466e-01f, -9.45926309e-02f, 1.94218785e-01f, 1.15580425e-01f, 1.09877877e-01f, -1.40013501e-01f, -1.79259002e-01f,
  -8.37882161e-02f, -1.73087120e-02f, -1.74456820e-01f, -3.05063743e-03f, -8.73044804e-02f, -3.49447548e-01f, -2.11289525e-01f, -1.13907114e-01f, 1.75066084e-01f, 3.30850601e-01f,
  1.36001304e-01f, -6.69106748e-03f, -5.52753434e-02f, 1.31525338e-01f, -7.76081383e-02f, -7.09765553e-02f, -1.92993805e-01f, -1.17803216e-01f, 4.13474441e-02f, -2.37026960e-01f,
  -2.95348167e-01f, -3.68358381e-02f, 1.53588489e-01f, 2.48394087e-02f, -1.81401119e-01f, -1.14064202e-01f, -3.21751763e-03f, -1.01564087e-01f, -2.59850640e-02f, -6.04456626e-02f,
  -5.05912490e-02f, 7.22334310e-02f, -1.24959938e-01f, 2.79564899e-03f, -3.15493420e-02f, 3.14860083e-02f, -2.90175434e-02f, -2.64562257e-02f, -3.66157331e-02f, 8.53742883e-02f,
  6.19587712e-02f, 1.95656773e-02f, 8.28686506e-02f, 6.10092003e-03f, 8.33327398e-02f, 9.18743163e-02f, 1.10343009e-01f, 1.81847781e-01f, 1.18561193e-01f, -5.38314953e-02f,
  4.98072840e-02f, -1.55607507e-01f, -3.15678678e-02f, 1.50918454e-01f, 7.80322552e-02f, 1.82666201e-02f, -7.40376934e-02f, 3.77539732e-02f, -1.48113938e-02f, 1.60466321e-02f,
  -7.02349022e-02f, -8.53521302e-02f, -2.50758603e-02f, 5.22507587e-03f, 7.77228698e-02f, -4.43298034e-02f, -6.18356466e-02f, 2.94997133e-02f, 1.80117935e-01f, 1.30372085e-02f,
  1.11372881e-01f, 1.64095134e-01f, -9.20658559e-02f, -1.42968502e-02f, 8.46316516e-02f, -1.04256198e-01f, -3.48899700e-02f, 8.07760358e-02f, 6.54024407e-02f, -4.83164154e-02f,
  -4.49657679e-01f, 3.60706486e-02f, -3.25944573e-01f, 6.70074895e-02f, -4.13266383e-02f, 8.34195241e-02f, -6.88811019e-02f, -4.51624356e-02f, -1.83481291e-01f, 2.06727963e-02f,
  2.78566033e-01f, -3.11420225e-02f, -1.13631479e-01f, 6.17591031e-02f, -5.12954928e-02f, 1.27136111e-01f, -2.45222133e-02f, -1.27421990e-01f, 1.00979775e-01f, 6.25201538e-02f,
  5.63312247e-02f, 1.71639293e-01f, 1.09114703e-02f, -1.23242363e-01f, 8.59433487e-02f, -7.68732131e-02f, 4.95283119e-02f, 1.67950988e-01f, 1.45558089e-01f, -1.89463735e-01f,
  -1.47731185e-01f, -1.30621418e-01f, 2.50701934e-01f, 5.59873171e-02f, -7.79689103e-02f, -1.42078683e-01f, -3.59288692e-01f, -2.60667671e-02f, 1.14293508e-01f, 1.86232626e-02f,
  -1.57806801e-03f, 1.23315051e-01f, 8.92792568e-02f, 6.26912937e-02f, -1.21095451e-02f, -6.94429427e-02f, 5.42095257e-03f, -2.66655646e-02f, -1.32587537e-01f, -2.97347069e-01f,
  -1.29169315e-01f, 1.49555951e-02f, 1.07330389e-01f, -6.43374100e-02f, 5.31671941e-03f, 1.22544900e-01f, 3.13576996e-01f, 1.00955293e-01f, 3.86175662e-02f, -8.73403177e-02f,
  1.21051542e-01f, -1.65986627e-01f, 9.37025025e-02f, -1.28281564e-01f, 4.57827710e-02f, -1.75929710e-01f, -2.20471829e-01f, -4.64085909e-03f, 2.94654835e-02f, 1.31390048e-02f,
  -7.29080141e-02f, -2.30958655e-01f, -2.08607942e-01f, -6.86109066e-02f, 2.50630490e-02f, -2.16669351e-01f, -8.01433530e-03f, -1.08734146e-02f, 1.17964610e-01f, -8.95828381e-02f,
  -1.64601535e-01f, -2.49140739e-01f, -7.58553594e-02f, 1.22051379e-02f, -4.70438600e-02f, 6.00601919e-02f, -1.21343777e-01f, -1.73484623e-01f, 6.24671355e-02f, -1.28637061e-01f,
  -1.95904858e-02f, -2.20488682e-02f, -2.35982332e-02f, 3.97615060e-02f, -5.91793433e-02f, 2.41093691e-02f, -1.62233740e-01f, 6.08565547e-02f, 6.89526089e-04f, -3.30724008e-02f,
  -3.81916165e-02f, -6.00449219e-02f, 2.57798862e-02f, 5.01432121e-02f, -4.66476008e-02f, 1.14296647e-02f, 3.85421030e-02f, 6.15526317e-03f, -7.28309453e-02f, 1.28370255e-01f,
  7.57252276e-02f, -1.27040341e-01f, 8.69355649e-02f, -1.08566746e-01f, 8.33148807e-02f, -5.17876297e-02f, -1.85388159e-02f, 4.84676547e-02f, 1.02546185e-01f, 7.88247064e-02f,
  2.70681828e-01f, 2.48973906e-01f, 1.14021695e-03f, -4.83125299e-02f, -1.67502671e-01f, 2.22087167e-02f, 1.56430472e-02f, -3.85234915e-02f, 5.10018244e-02f, -1.07333206e-01f,
  -6.83723763e-02f, -2.42845297e-01f, -6.33300990e-02f, -5.95138855e-02f, -5.43205393e-03f, 2.17041895e-02f, -5.57185449e-02f, -2.90268231e-02f, 8.14796388e-02f, 1.31247267e-02f,
  8.27495679e-02f, -1.12743542e-01f, -1.15520291e-01f, 4.91907867e-03f, 2.54370142e-02f, 1.44727007e-02f, -1.69217721e-01f, -9.81705412e-02f, -2.22472847e-02f, -7.53120193e-03f,
  -2.26688355e-01f, -2.83572963e-03f, -1.24717034e-01f, 8.85872990e-02f, 2.18156278e-01f, -4.44158800e-02f, -2.75815189e-01f, -2.20335707e-01f, 1.08469566e-02f, -2.40778867e-02f,
  5.73796891e-02f, 1.84524268e-01f, 1.36664495e-01f, -9.43470076e-02f, -1.85500816e-01f, 1.91392694e-02f, 1.40599951e-01f, -1.23772822e-01f, -1.61196634e-01f, 3.16337794e-02f,
  2.12160870e-01f, 1.07342109e-01f, -1.37680396e-01f, 4.51266244e-02f, 2.00315580e-01f, 5.51048368e-02f, 6.49679750e-02f, 1.64901569e-01f, 1.19467326e-01f, 2.33223602e-01f,
  1.48092620e-02f, -3.03796768e-01f, -7.43249878e-02f, 6.05208166e-02f, -3.19577142e-04f, -1.16043776e-01f, 6.75245281e-03f, -9.40090604e-03f, -1.13147106e-02f, 1.77573171e-02f,
  1.63831890e-01f, -1.15234651e-01f, 1.01753592e-01f, -9.10479948e-02f, -9.34260786e-02f, -1.31892517e-01f, -2.24959016e-01f, -2.38200799e-01f, -2.61386871e-01f, -1.05676852e-01f,
  2.70004958e-01f, 2.03681231e-01f, -4.48561572e-02f, -2.00134501e-01f, -2.81683058e-01f, -4.62977402e-02f, -1.32615954e-01f, -1.74766973e-01f, -2.10031271e-01f, -1.56700224e-01f,
  -7.05791861e-02f, -6.09273054e-02f, -4.52571809e-02f, -4.62369472e-02f, -3.80272903e-02f, 1.15536034e-01f, 4.41439264e-02f, -1.56084877e-02f, -2.60057040e-02f, 1.44271329e-02f,
  -1.44825932e-02f, 4.26840000e-02f, 1.24540804e-02f, -1.52125001e-01f, -2.76036263e-02f, -1.21913459e-02f, 7.60662407e-02f, -2.53882501e-02f, -9.51565951e-02f, -1.74079947e-02f,
  1.79822877e-01f, -6.75561279e-02f, 3.44067924e-02f, -3.83031927e-02f, -2.92545874e-02f, -2.97843218e-02f, -4.35723774e-02f, -3.14740539e-02f, -9.77787375e-02f, -2.85617467e-02f,
  -6.45806119e-02f, 7.83176161e-03f, 7.69593045e-02f, -7.28701660e-03f, -2.30963919e-02f, -5.78485094e-02f, -2.49133650e-02f, 4.19546925e-02f, 7.49776885e-02f, -7.97559470e-02f,
  -6.58642799e-02f, -1.08837277e-01f, 2.30259206e-02f, -4.94128168e-02f, -8.28579739e-02f, -1.42843684e-03f, 4.62257378e-02f, 7.40263313e-02f, -2.45957985e-03f, -8.59109778e-03f,
  1.00810014e-01f, -3.86772081e-02f, 7.86441639e-02f, 2.34504677e-02f, 1.35142282e-01f, -3.80362421e-02f, -2.72423364e-02f, -8.94884989e-02f, -1.56914487e-01f, -1.38276309e-01f,
  1.98377132e-01f, 9.16642025e-02f, -5.10877073e-01f, 1.30267441e-01f, -2.86799967e-01f, -3.75225842e-01f, -3.67388219e-01f, 4.79852147e-02f, 1.44529954e-01f, -2.20894143e-01f,
  -1.10501364e-01f, 5.43038659e-02f, -1.08104320e-02f, -1.53056523e-02f, -7.05006358e-04f, -2.97803253e-01f, -3.06194574e-01f, -2.99002141e-01f, -1.92206293e-01f, -1.53072149e-01f,
  -4.63496242e-03f, -1.09353717e-02f, 1.72821000e-01f, 8.69644508e-02f, 3.33828218e-02f, 1.24870807e-01f, -9.76895094e-02f, 1.75649244e-02f, -6.83171749e-02f, -1.80028051e-01f,
  -3.14386487e-01f, -1.01051927e-01f, -9.51749161e-02f, 1.61758080e-01f, 1.33506030e-01f, -1.75526068e-02f, -3.30169536e-02f, 7.38386288e-02f, 1.53579250e-01f, 2.43316256e-02f,
  -5.23087978e-02f, 2.29219794e-02f, -3.39965895e-02f, -2.12213863e-02f, -2.48842919e-03f, -9.95160639e-03f, 5.19913286e-02f, 2.24711746e-02f, -2.83809304e-02f, 7.74264475e-03f,
  -1.23461336e-01f, -5.83755299e-02f, -1.20661110e-01f, 4.43003699e-02f, -1.60902023e-01f, -1.19885787e-01f, 6.09975830e-02f, 1.44181317e-02f, -1.26210824e-01f, 1.88430414e-01f,
  4.10085581e-02f, -2.28622346e-03f, -9.22572687e-02f, 2.70096678e-02f, 1.20797083e-02f, 4.84992601e-02f, 2.46666800e-02f, 1.39420673e-01f, 2.32353359e-02f, 8.05000886e-02f,
  5.65523617e-02f, 7.04079121e-02f, 7.83411339e-02f, 1.40385762e-01f, 5.82626723e-02f, 2.55314652e-02f, -7.87152648e-02f, 1.03215627e-01f, -8.31598509e-03f, -3.74685079e-02f,
  5.19343242e-02f, -4.22508866e-02f, -1.40569089e-02f, 4.58049029e-02f, 3.00940871e-02f, 1.19979670e-02f, -9.62789506e-02f, -3.24278809e-02f, 3.36179300e-03f, -5.16167507e-02f,
  1.95959508e-01f, -2.36652568e-01f, 1.28297552e-01f, 1.28640784e-02f, -2.35193260e-02f, -9.38445330e-02f, -8.83826390e-02f, 1.36336252e-01f, 7.66605586e-02f, -3.96823771e-02f,
  4.62541804e-02f, 4.10641916e-02f, 7.51118734e-02f, 1.16425209e-01f, 5.16240112e-02f, -5.85819073e-02f, -5.50786071e-02f, 7.73116052e-02f, 5.04137129e-02f, 7.61158690e-02f,
  6.12880960e-02f, 7.18082413e-02f, 6.40376061e-02f, 5.83929308e-02f, 1.32083893e-01f, -1.11842863e-01f, 3.30021940e-02f, 2.78828889e-02f, -1.07397446e-02f, 2.71194786e-01f,
  2.01324061e-01f, 1.52871013e-01f, -1.77731305e-01f, 1.13235645e-01f, -4.17148927e-03f, 1.30024955e-01f, 1.58665061e-01f, 1.67335615e-01f, 2.61914283e-01f, 1.13997728e-01f,
  1.48451164e-01f, 3.07446808e-01f, 3.14033180e-01f, 2.87789926e-02f, -5.05617559e-02f, 1.19402431e-01f, -4.99326997e-02f, -1.30573630e-01f, -9.15917382e-02f, 8.32889825e-02f,
  4.10910882e-02f, 9.09061655e-02f, 1.66198369e-02f, 1.26498761e-02f, -1.58929080e-02f, 3.18172611e-02f, -2.77382769e-02f, -2.62538791e-02f, -5.35610039e-03f, -2.88259774e-01f,
  -2.35346287e-01f, -4.16402109e-02f, 2.11666655e-02f, 4.49286811e-02f, -1.17829636e-01f, -9.44592133e-02f, 5.25087304e-02f, -1.40899971e-01f, 1.03104159e-01f, 5.41349268e-03f,
  3.96368317e-02f, -7.14320689e-02f, -4.45475831e-04f, 5.00967093e-02f, -2.24061739e-02f, -4.31528278e-02f, 5.20241866e-03f, -1.49282860e-02f, -9.98942405e-02f, -1.54596403e-01f,
  -6.69950545e-02f, -8.45120177e-02f, -1.80862218e-01f, 8.04756582e-02f, -4.69571240e-02f, 1.05389543e-01f, 1.94681026e-02f, -1.17334230e-02f, -2.81184055e-02f, -7.17057846e-03f,
  5.45391887e-02f, -1.30998209e-01f, -1.12982072e-01f, 3.31014618e-02f, 1.04023479e-01f, 6.73068538e-02f, -6.24241419e-02f, -6.01068102e-02f, 1.17450722e-01f, -9.04775858e-02f,
  2.97369261e-04f, -6.89092427e-02f, -2.55270749e-02f, 4.42134514e-02f, 2.56415904e-01f, -7.69414976e-02f, -1.11579143e-01f, -2.91985925e-02f, 1.85263157e-02f, 1.02608837e-01f,
  -5.06612705e-03f, -1.02526098e-02f, -7.80640766e-02f, -1.33786127e-01f, -1.44506004e-02f, 5.86289428e-02f, 1.49582662e-02f, -5.99262938e-02f, 1.28209457e-01f, 2.03662775e-02f,
  -1.02790833e-01f, 2.15091661e-01f, 1.53366895e-02f, -2.06355378e-01f, -2.13794082e-01f, -4.61581303e-03f, 3.58230248e-02f, -8.01438689e-02f, 3.67314629e-02f, 7.51887038e-02f,
  -5.78506887e-02f, -1.30623132e-01f, 1.92566998e-02f, 5.98287806e-02f, 9.28236991e-02f, 4.25704531e-02f, 2.96019427e-02f, -9.80959088e-02f, -3.81356440e-02f, -1.23831823e-01f,
  -9.68761593e-02f, 1.02794636e-02f, -1.99058458e-01f, 3.90063338e-02f, -4.52097841e-02f, 8.93188715e-02f, -3.90875107e-03f, 2.14670487e-02f, 1.54040037e-02f, 1.14099160e-02f,
  -4.02755439e-01f, -2.49691591e-01f, 1.27853498e-01f, 1.94644127e-02f, 1.02981851e-01f, 2.33835071e-01f, 3.50389928e-01f, 1.70022145e-01f, 1.28445074e-01f, 1.96458921e-01f,
  -8.85240436e-02f, 8.98936391e-03f, -2.11447794e-02f, -1.44407963e-02f, -5.31844683e-02f, 2.19973326e-01f, 2.47560054e-01f, 6.58504888e-02f, 2.32036442e-01f, 8.19363296e-02f,
  2.41848111e-01f, 3.15911658e-02f, -2.08805889e-01f, 2.30198093e-02f, 9.32991952e-02f, 5.51960208e-02f, 8.33668560e-02f, -2.24864960e-01f, -4.95143719e-02f, -3.17689329e-02f,
  -1.41373411e-01f, -3.43171000e-01f, 1.57341123e-01f, -1.71139106e-01f, -1.25126094e-01f, -2.92664543e-02f, 4.29578014e-02f, -1.08932570e-01f, -1.15317017e-01f, -5.02932034e-02f,
  -2.05955714e-01f, -2.15641886e-01f, -2.25573659e-01f, -7.05743581e-02f, 2.84035858e-02f, -1.03557356e-01f, -7.05644488e-02f, -1.63375840e-01f, -1.96334988e-01f, -1.32188722e-01f,
  -1.92280427e-01f, -2.53594041e-01f, -1.26343042e-01f, 1.92040950e-02f, -1.42439216e-01f, -2.88439915e-02f, -5.22425734e-02f, -1.01893619e-01f, -3.00205469e-01f, 4.25348000e-04f,
  -3.08897756e-02f, -1.13271289e-01f, -4.57820855e-02f, 7.16005266e-02f, 1.63388401e-01f, 7.20981276e-03f, -9.38502029e-02f, 8.33760425e-02f, 1.44144207e-01f, 1.03337485e-02f,
  -2.72222552e-02f, 9.38120037e-02f, 9.63663589e-03f, 2.92785955e-03f, 1.45906925e-01f, -7.21896300e-03f, 4.88768443e-02f, 1.06415391e-01f, 5.44340611e-02f, 1.44558474e-01f,
  1.37047797e-01f, 8.63845795e-02f, -3.16130966e-02f, 5.73502034e-02f, 9.79484394e-02f, 1.51957408e-01f, 8.73757303e-02f, 1.29867360e-01f, -4.49023396e-02f, -5.51403351e-02f,
  2.78231889e-01f, -1.18231751e-01f, 6.69663101e-02f, 2.10967548e-02f, -1.05360508e-01f, -5.43540567e-02f, -4.88297343e-02f, -2.55944487e-02f, -3.73522118e-02f, 9.95001942e-02f,
  -2.03838125e-02f, -1.03676803e-01f, -1.27731897e-02f, 5.18151224e-02f, 1.34424210e-01f, 2.67906170e-02f, 6.85653016e-02f, 1.54749960e-01f, 1.14090092e-01f, -3.52725573e-02f,
  1.82225317e-01f, 2.12244183e-01f, 1.48355722e-01f, 1.92143083e-01f, -4.05925810e-02f, 2.13798285e-01f, 2.46705532e-01f, 1.73936963e-01f, 9.34120715e-02f, 3.26126993e-01f,
  -7.49122381e-01f, 1.57034859e-01f, 2.21693441e-01f, -3.41832876e-01f, -1.09571710e-01f, -3.83930989e-02f, 1.19383231e-01f, -3.48006487e-02f, -1.84051812e-01f, 1.44778714e-01f,
  6.37835935e-02f, -6.36913925e-02f, 4.04654928e-02f, 6.40250295e-02f, -1.24451809e-01f, 8.97171870e-02f, 7.81496763e-02f, -2.29442552e-01f, -2.24718690e-01f, -3.15332204e-01f,
  -1.75470471e-01f, -4.03682590e-01f, -3.19891691e-01f, -2.50228465e-01f, -1.86835192e-02f, -1.17038876e-01f, 3.77874970e-02f, -1.89751565e-01f, 1.45237418e-02f, 3.53513844e-02f,
  2.94103831e-01f, -2.00749680e-01f, 4.62399311e-02f, -1.69831604e-01f, -9.56239253e-02f, -4.46137711e-02f, -1.93670437e-01f, 6.50766343e-02f, -4.34539504e-02f, 8.20987672e-02f,
  -1.17565818e-01f, 8.33852887e-02f, -1.33873206e-02f, -3.53715904e-02f, -2.03139380e-01f, -1.17005885e-03f, 1.05886668e-01f, -7.77421817e-02f, -1.44914547e-02f, 1.04250468e-01f,
  2.68952213e-02f, -6.50660396e-02f, 1.18320771e-02f, 1.24420911e-01f, 4.00872938e-02f, -7.47503340e-02f, 2.25688480e-02f, 3.08042089e-03f, 1.14404559e-01f, 7.66013712e-02f,
  -4.62511042e-03f, 9.74453762e-02f, 2.92818211e-02f, 2.13575028e-02f, 7.13099465e-02f, -4.06934181e-03f, 2.92335469e-02f, 5.39432056e-02f, -1.06787279e-01f, 3.49645573e-03f,
  4.02954221e-02f, 2.91134976e-03f, 9.09065083e-03f, -9.96316075e-02f, 7.06387609e-02f, -5.19311838e-02f, -5.16952202e-02f, 8.32829028e-02f, 5.50357960e-02f, -6.87512429e-03f,
  -1.98111944e-02f, -1.46442130e-02f, 7.14252051e-03f, 8.54223147e-02f, 3.35319480e-03f, 4.12050597e-02f, 3.62931080e-02f, 3.31478268e-02f, -6.48662224e-02f, -1.36755764e-01f,
  -2.98814755e-02f, -1.14847764e-01f, -3.04039475e-02f, 9.73802209e-02f, -1.23085072e-02f, 8.73283148e-02f, 5.03824763e-02f, 8.97930786e-02f, -7.62860179e-02f, 2.73497403e-02f,
  9.48692113e-02f, 5.22711091e-02f, 2.19464581e-02f, 1.26174480e-01f, -1.15911730e-01f, -3.75666730e-02f, 6.94837794e-02f, -1.12593859e-01f, -6.51163831e-02f, 1.66955501e-01f,
  8.68943110e-02f, 1.81534793e-02f, -6.20527528e-02f, 1.80752262e-01f, 5.36236651e-02f, -3.04228235e-02f, -1.52628021e-02f, 2.44121067e-02f, 7.95856938e-02f, 1.14848882e-01f,
  3.40146750e-01f, -1.20361209e-01f, 9.02099758e-02f, 2.57360816e-01f, -2.25661322e-02f, 1.48349479e-01f, 4.26589176e-02f, 1.25911206e-01f, 1.14223816e-01f, 1.80473357e-01f,
  9.29635614e-02f, 1.44565612e-01f, 2.23724306e-01f, 9.47897434e-02f, 3.38441469e-02f, 7.61573166e-02f, 4.91875000e-02f, 1.70105085e-01f, 2.55028784e-01f, 1.91177025e-01f,
  1.21285200e-01f, 1.24444693e-01f, 7.75611326e-02f, 1.75023615e-01f, 6.10185675e-02f, 1.93513289e-01f, -4.38244008e-02f, 1.11534344e-02f, -2.29456834e-03f, 1.06027164e-01f,
  5.66064194e-03f, 1.86239064e-01f, 1.09341219e-01f, 3.67216431e-02f, -1.71290115e-02f, 4.92175221e-02f, 1.69524439e-02f, -1.52123228e-01f, -4.85191159e-02f, -4.24125716e-02f,
  -7.14922175e-02f, -1.01935923e-01f, -1.03037231e-01f, -2.29149908e-02f, -3.22981961e-02f, -9.49594975e-02f, 6.40233457e-02f, -4.79898378e-02f, -2.01449897e-02f, 2.29155086e-03f,
  2.62047891e-02f, -1.47193164e-01f, -2.19135687e-01f, 6.13124780e-02f, 4.35194261e-02f, 1.19232886e-01f, -5.81226423e-02f, 1.19743481e-01f, 9.11598057e-02f, -2.57341261e-03f,
  3.91998067e-02f, -1.60668939e-02f, 7.06651583e-02f, 1.59938619e-01f, 2.29461938e-01f, 8.02622512e-02f, 3.69058736e-02f, -1.72998160e-02f, 1.54467776e-01f, 4.91155609e-02f,
  -1.70310959e-02f, 5.41607440e-02f, -2.12753797e-03f, 1.49177030e-01f, 2.08932087e-01f, -1.83565766e-01f, -1.56452805e-01f, -8.08625519e-02f, 2.13236902e-02f, -8.31040218e-02f,
  8.41491222e-02f, 6.12554476e-02f, -2.00940184e-02f, 6.61695525e-02f, -7.53867179e-02f, 1.65939778e-01f, 1.82450831e-01f, 9.12910514e-03f, -2.66387649e-02f, -4.27474221e-03f,
  -4.56822276e-01f, 4.13334556e-02f, 2.05620140e-01f, -1.08079672e-01f, -1.19122379e-01f, 1.02426512e-02f, 1.14923371e-02f, -9.58449692e-02f, -1.27906859e-01f, -9.00160670e-02f,
  -7.21703768e-02f, -9.67499167e-02f, -4.14380021e-02f, -1.02898821e-01f, -1.47822872e-01f, -9.38610137e-02f, -9.78364497e-02f, -4.48674411e-02f, -1.69139162e-01f, -1.25942037e-01f,
  -5.87668680e-02f, -2.52607703e-01f, -2.03999385e-01f, -4.92479019e-02f, -8.82936567e-02f, 4.96580638e-03f, -2.30142418e-02f, -9.03804079e-02f, -1.45148560e-01f, -1.05956391e-01f,
  -2.33177915e-01f, 3.07001900e-02f, -1.79562703e-01f, -1.97043940e-02f, 1.62864551e-01f, 6.30490631e-02f, 1.25763074e-01f, -1.77088846e-02f, 6.61702529e-02f, 8.86623412e-02f,
  -8.94112960e-02f, -9.29616988e-02f, -1.43847272e-01f, -2.91649457e-02f, 7.40895569e-02f, 1.36824906e-01f, 2.36406103e-01f, -5.97034693e-02f, -1.15314148e-01f, 7.72754103e-02f,
  2.12730050e-01f, 1.45605523e-02f, -2.05422938e-01f, -1.77871082e-02f, 6.38006628e-02f, -6.66291490e-02f, -1.47877261e-01f, -8.68911296e-02f, 6.07683212e-02f, 2.35519916e-01f,
  -3.46707076e-01f, -2.66371578e-01f, -3.69183393e-03f, -1.08065503e-02f, -3.81254889e-02f, -5.06759323e-02f, 7.55276829e-02f, -2.00971365e-01f, -1.21062435e-01f, -1.09910585e-01f,
  -1.47339582e-01f, -5.94895743e-02f, 1.09234899e-01f, -5.71666472e-03f, 3.04635260e-02f, -7.82868788e-02f, -3.93679589e-02f, -4.66643050e-02f, -2.08184853e-01f, 1.16000008e-02f,
  2.94738114e-01f, 8.03093389e-02f, -9.30931866e-02f, 1.89956874e-02f, -7.64626786e-02f, -1.14859514e-01f, -1.05935045e-01f, -2.20040772e-02f, -1.45616069e-01f, 8.10580403e-02f,
  5.14062643e-02f, -6.50709867e-02f, 2.33604535e-02f, 5.09806387e-02f, -2.26436574e-02f, -5.70542142e-02f, 1.46281958e-01f, 7.74265975e-02f, 1.31010205e-01f, -3.19681619e-03f,
  4.35526855e-02f, 7.05795661e-02f, 5.37899807e-02f, -9.16576758e-02f, -6.61809146e-02f, 2.21706973e-03f, 1.53139368e-01f, 5.64674363e-02f, -6.46881238e-02f, -7.12431148e-02f,
  -2.74880007e-02f, 3.12389750e-02f, -7.09528476e-02f, -6.63129985e-02f, 8.50938261e-02f, 2.38116905e-01f, 1.83632761e-01f, -4.09928039e-02f, -8.54164660e-02f, 2.42627058e-02f,
  2.83762105e-02f, -1.00069515e-01f, -1.10095832e-02f, 4.80464138e-02f, -1.98695138e-02f, 6.55173734e-02f, 6.36747200e-03f, 7.00071128e-03f, -1.28710523e-01f, -6.34825677e-02f,
  -1.27583757e-01f, -6.89163953e-02f, -5.49855828e-02f, -5.73370494e-02f, 8.74086022e-02f, -6.83692917e-02f, 1.42185064e-02f, 1.26952112e-01f, 5.90654835e-02f, -9.42349806e-02f,
  5.43176904e-02f, 1.65023535e-01f, -1.02878161e-01f, 9.07143280e-02f, 1.43124014e-01f, 7.39562586e-02f, -1.08636610e-01f, -8.09391215e-02f, -1.46896243e-01f, 3.60029340e-02f,
  -3.98954690e-01f, 1.15581959e-01f, 2.75549382e-01f, -3.09174865e-01f, 1.51587799e-01f, 7.42775202e-02f, 3.58980931e-02f, -1.32011786e-01f, -2.56639421e-01f, 7.10788667e-02f,
  7.79991820e-02f, -1.98264837e-01f, -9.29228440e-02f, -7.48366117e-02f, -5.64841963e-02f, -4.24298495e-02f, -1.60498749e-02f, -1.14839055e-01f, -1.35899931e-01f, -1.78395957e-02f,
  -6.94668591e-02f, -1.01788543e-01f, -2.39043504e-01f, -1.13934889e-01f, -1.02498226e-01f, -4.69316170e-02f, 4.42956984e-02f, -1.22806780e-01f, 1.65483207e-01f, -1.82005633e-02f,
  8.45952407e-02f, -5.62036559e-02f, 5.71523458e-02f, -1.90745264e-01f, 1.46962481e-03f, -4.81484085e-02f, 2.47038994e-02f, -3.58095393e-02f, 7.46753737e-02f, -5.07362783e-02f,
  -1.43740073e-01f, -7.70694092e-02f, -9.60821286e-02f, -8.15076679e-02f, -1.00354142e-01f, -1.46209314e-01f, 1.28361757e-03f, 8.59240741e-02f, -6.60868734e-02f, -2.73161661e-02f,
  8.70006382e-02f, 2.01992821e-02f, 4.16748878e-03f, 2.52106711e-02f, 1.06153123e-01f, 3.79669927e-02f, 1.11863218e-01f, 6.67278375e-03f, 8.42279270e-02f, -8.61714780e-03f,
  -3.78022343e-02f, -4.16558497e-02f, 1.55469805e-01f, -6.47893175e-02f, -1.13827631e-01f, -7.38765462e-04f, -7.30370283e-02f, -1.54926509e-01f, -4.13549989e-02f, -1.07862823e-01f,
  -8.08891878e-02f, -9.81750805e-03f, -1.50504932e-01f, -5.24912290e-02f, -5.07041439e-02f, -1.36997119e-01f, -4.25299220e-02f, -9.82159078e-02f, 1.59723476e-01f, 3.21102068e-02f,
  2.39223372e-02f, -3.68549824e-02f, -4.81284857e-02f, -4.92572505e-03f, -6.42244611e-03f, 5.80550591e-03f, -3.43906023e-02f, 7.85018429e-02f, 1.84077658e-02f, 2.37717517e-02f,
  -1.49029478e-01f, 2.93119878e-01f, -1.91105142e-01f, -1.66959673e-01f, -1.04577690e-01f, 6.14211559e-02f, 8.16997886e-02f, -5.66065758e-02f, -2.42902990e-02f, -3.33173424e-02f,
  -1.52293161e-01f, -1.17822424e-01f, -3.71891423e-03f, 8.72822627e-02f, -1.73232466e-01f, -9.32000056e-02f, -2.26000488e-01f, 3.72509584e-02f, 1.05466306e-01f, -4.42761071e-02f,
  -9.44860056e-02f, -1.62151843e-01f, -2.06601992e-01f, 1.23719893e-01f, -1.09214507e-01f, -5.41118495e-02f, -7.64325485e-02f, 2.94797216e-02f, -5.76827191e-02f, -2.64362961e-01f,
  -2.62150854e-01f, 6.60220534e-02f, 8.79346728e-02f, -4.78885397e-02f, 6.12275004e-02f, 5.90755865e-02f, 1.43070891e-01f, 3.44969407e-02f, 1.34066731e-01f, -2.79300194e-02f,
  1.14478022e-01f, -4.42233793e-02f, -6.89895079e-02f, -4.64200526e-02f, -1.54326027e-02f, -1.83008716e-01f, -6.32143840e-02f, -1.16162449e-01f, 8.12089890e-02f, 1.17039077e-01f,
  9.62291379e-04f, -7.29096010e-02f, 2.03876980e-02f, -9.00173038e-02f, -1.82468399e-01f, -1.02821685e-01f, -1.15818247e-01f, -2.15734184e-01f, -1.46981239e-01f, -3.01631629e-01f,
  -6.21745735e-02f, -1.20860979e-01f, 7.91860372e-02f, -1.57595456e-01f, -3.91960144e-03f, -1.58020761e-03f, -5.07728308e-02f, 1.14462182e-01f, 4.41986695e-02f, 1.18162900e-01f,
  3.01558413e-02f, 3.17823850e-02f, -9.05826390e-02f, 4.98831049e-02f, 7.41055142e-03f, 9.85009223e-02f, 2.39260212e-01f, 1.04686156e-01f, 1.06896877e-01f, -4.89212796e-02f,
  2.17193980e-02f, 1.29124016e-01f, -1.57952979e-02f, 7.00674811e-03f, -8.92632082e-02f, 2.86443867e-02f, 2.44557466e-02f, -1.48114115e-01f, -4.44985507e-03f, -2.93686122e-01f,
  1.19212575e-01f, -1.52018666e-01f, 1.40623137e-01f, -2.04038676e-02f, 5.27728163e-02f, 1.95709839e-02f, -4.78876755e-02f, -1.09876007e-01f, -1.69261626e-03f, 9.20162573e-02f,
  5.01903705e-03f, 1.31149456e-01f, 6.76633194e-02f, 2.34111827e-02f, -4.46948260e-02f, -4.55443077e-02f, -1.00523263e-01f, 1.71345416e-02f, -2.01866999e-02f, 2.37972662e-02f,
  -2.51514073e-02f, -6.45686537e-02f, 7.71584511e-02f, 1.43861510e-02f, 6.52681887e-02f, 4.97102644e-03f, 1.87035780e-02f, -8.76420066e-02f, -7.00628012e-02f, 4.66868542e-02f,
  -7.18515962e-02f, 1.52821884e-01f, -1.78397834e-01f, -2.77533475e-02f, -1.29672617e-01f, 1.41123394e-02f, -3.70147787e-02f, 5.89250140e-02f, -1.42493129e-01f, -8.09798911e-02f,
  -1.44469589e-02f, -3.78313512e-02f, -1.55370450e-02f, -1.14083216e-01f, 1.36827584e-02f, -1.37123451e-01f, 2.99277846e-02f, -5.74689880e-02f, 2.73208693e-02f, -5.20573594e-02f,
  -2.58710422e-02f, 9.19205099e-02f, -3.20937485e-02f, -7.72354081e-02f, -1.22952014e-01f, -8.03356990e-02f, -1.68896377e-01f, -2.40381271e-01f, -1.81487203e-01f, -1.68957829e-01f,
  -2.38706455e-01f, 7.08281249e-02f, -1.46406651e-01f, 9.09435824e-02f, 2.73161918e-01f, -1.08100913e-01f, -2.90372580e-01f, -3.34720522e-01f, 6.01932481e-02f, 1.00974806e-01f,
  1.42181382e-01f, 2.04407245e-01f, 1.60221487e-01f, 2.53272746e-02f, -3.25336576e-01f, -1.01650357e-01f, 1.16599903e-01f, -1.95932046e-01f, -2.78456718e-01f, -1.42683402e-01f,
  1.97609767e-01f, 1.24741279e-01f, -9.48694199e-02f, 4.65378985e-02f, 2.47060493e-01f, 1.59356534e-01f, 4.33867984e-02f, 1.83321163e-01f, 7.43107349e-02f, 2.14012727e-01f,
  3.94636951e-02f, -2.02568606e-01f, 2.73683891e-02f, 6.71799257e-02f, 1.17199250e-01f, -2.19979495e-01f, -2.82879523e-03f, -1.22052461e-01f, -5.81909018e-03f, -8.88670385e-02f,
  1.51384369e-01f, 1.34040061e-02f, 2.08263487e-01f, 2.31992006e-02f, -1.10180397e-02f, -1.83378577e-01f, -2.15038240e-01f, -1.38124287e-01f, -1.35251358e-01f, -1.38376102e-01f,
  1.71643406e-01f, 2.10137025e-01f, -2.07591727e-01f, -1.67833894e-01f, -1.96340472e-01f, 8.75637084e-02f, -2.39504024e-01f, -1.55236483e-01f, -2.70150989e-01f, -1.49529681e-01f,
  1.99134443e-02f, -8.31271186e-02f, -1.01634534e-02f, -5.38745150e-02f, -1.36906594e-01f, 1.04413107e-01f, 1.18126847e-01f, -3.63612138e-02f, 1.43474282e-03f, 3.55867185e-02f,
  -5.08110709e-02f, 8.34736042e-03f, -5.99878132e-02f, 1.71449147e-02f, -4.13859040e-02f, -4.08486277e-02f, -1.99397784e-02f, 4.92687114e-02f, -4.00595777e-02f, 1.41796935e-02f,
  2.04286024e-01f, 9.55013186e-02f, 2.08443478e-02f, -3.92613225e-02f, 6.54652249e-03f, -9.04577523e-02f, 3.57275121e-02f, -5.72331026e-02f, -5.75967915e-02f, 2.14329530e-02f,
  4.17797789e-02f, 1.20203875e-01f, 6.21104240e-02f, -7.32638314e-02f, -1.23490579e-01f, 1.20609058e-02f, 1.09096495e-02f, -4.95936833e-02f, 3.56888697e-02f, -5.21214791e-02f,
  -7.58120343e-02f, -1.78903997e-01f, 4.11997624e-02f, -6.81578442e-02f, -1.12439059e-01f, 9.27566960e-02f, -7.40427896e-02f, 7.05900639e-02f, -9.52220615e-03f, -1.47545533e-02f,
  -6.66880384e-02f, 3.43954265e-02f, -7.24112466e-02f, -1.03621528e-01f, 1.45346701e-01f, 1.16383303e-02f, -9.45557505e-02f, -9.22419056e-02f, -1.53095812e-01f, -2.79408514e-01f,
  1.97075546e-01f, -2.54335135e-01f, -8.27812329e-02f, -5.78404590e-03f, -1.02703400e-01f, -7.76952319e-03f, -2.45887041e-01f, 1.48371965e-01f, 8.24825242e-02f, -2.41886362e-01f,
  7.44861085e-04f, 2.69726694e-01f, 9.03275385e-02f, 2.26867929e-01f, 1.10963009e-01f, -2.76107162e-01f, -2.53686398e-01f, 9.03082788e-02f, 3.28012794e-01f, 2.48448744e-01f,
  3.61664072e-02f, -2.63584908e-02f, 2.39817396e-01f, 7.01732486e-02f, -2.59429574e-01f, -4.39533172e-03f, -2.00038925e-01f, -1.83862165e-01f, -2.03158051e-01f, -4.61895287e-01f,
  -1.73144564e-01f, -8.99046287e-02f, 6.03729822e-02f, 1.28552213e-01f, 2.08389740e-02f, 4.35157493e-02f, -4.88039479e-02f, -7.96229094e-02f, -1.22320494e-02f, -7.13562816e-02f,
  -4.92372550e-02f, 6.06623329e-02f, 8.21655169e-02f, -4.14427854e-02f, -2.93099973e-02f, 6.80288300e-03f, -2.30759103e-02f, 7.42347315e-02f, -6.74131280e-03f, -1.15361750e-01f,
  -2.19998956e-01f, -9.20155719e-02f, -1.09511718e-01f, -1.07226901e-01f, 1.32897094e-01f, 4.39454503e-02f, 5.92189096e-03f, 3.72728854e-02f, 3.26434933e-02f, -3.77319336e-01f,
  -8.64744633e-02f, -8.38699564e-03f, -5.88165596e-02f, 6.09458461e-02f, -6.92466721e-02f, -1.02458626e-01f, -6.77050948e-02f, 4.58292523e-03f, -2.46105623e-02f, 5.72550595e-02f,
  -1.76038668e-02f, -8.13568290e-03f, -3.13522629e-02f, -9.74003151e-02f, -8.54067579e-02f, -9.79894623e-02f, 5.82745224e-02f, -5.01947179e-02f, 7.93081969e-02f, -1.60025582e-02f,
  1.67611577e-02f, 8.79001021e-02f, -5.03071100e-02f, 1.60117850e-01f, -3.60636599e-02f, -2.00859569e-02f, 8.01331028e-02f, 5.73971607e-02f, 8.92830268e-03f, -3.02833952e-02f,
  6.83940724e-02f, 2.15899840e-01f, -9.97146517e-02f, 4.90609370e-02f, -2.06153301e-04f, -4.76377308e-02f, -2.13807281e-02f, -2.78381780e-02f, 1.33288698e-02f, -1.54389497e-02f,
  8.58288258e-02f, -3.55005972e-02f, -9.16307718e-02f, -4.58170436e-02f, 1.13321669e-01f, -4.38966677e-02f, -9.61195305e-02f, -5.09274043e-02f, 5.05414680e-02f, -1.10764943e-01f,
  -1.61100894e-01f, -1.18217357e-01f, 4.61328253e-02f, -6.29318878e-02f, -1.33813769e-01f, 8.50704461e-02f, -5.66829108e-02f, -7.34635666e-02f, -4.64512110e-02f, -2.41306975e-01f,
  -4.13991690e-01f, 1.13696828e-02f, 2.14426234e-01f, -3.58794510e-01f, -1.17433630e-01f, -9.97943357e-02f, -2.42028031e-02f, 2.93978304e-02f, -1.11074775e-01f, -1.06145106e-01f,
  6.32996485e-02f, -1.26331970e-01f, -5.72434179e-02f, 8.65455903e-03f, -6.16732500e-02f, -9.00112242e-02f, -1.72459289e-01f, -6.24862425e-02f, -1.54011621e-04f, 1.28420927e-02f,
  -9.23098251e-02f, -1.98968664e-01f, -1.93650380e-01f, -7.64739364e-02f, 4.74122055e-02f, -6.29131123e-03f, 1.19030632e-01f, -1.14198752e-01f, 1.17548324e-01f, -1.27375886e-01f,
  1.30142957e-01f, -4.35674116e-02f, 1.42426848e-01f, -1.35901406e-01f, 1.05904967e-01f, -3.02440003e-02f, 4.58709076e-02f, -1.24297589e-01f, 5.64925373e-02f, 1.80451535e-02f,
  -1.52758539e-01f, -8.64826888e-02f, -8.65429193e-02f, -1.36469603e-01f, -8.28614607e-02f, -1.34888202e-01f, -1.41371757e-01f, -8.95302817e-02f, 1.21522350e-02f, 1.82196215e-01f,
  -7.29301274e-02f, -8.61072093e-02f, -6.29011169e-02f, 1.93385303e-01f, 1.51818141e-01f, 3.40968743e-03f, 1.10677488e-01f, 6.61668181e-02f, 2.53736943e-01f, -1.26117453e-01f,
  9.61811244e-02f, -1.17665622e-02f, 3.13719176e-02f, -9.67098922e-02f, -1.30150884e-01f, 4.08392772e-02f, 4.63266782e-02f, -2.95272488e-02f, 1.06754050e-01f, 3.14464197e-02f,
  3.49871852e-02f, 8.12733471e-02f, -4.86532860e-02f, 6.03690464e-03f, 1.24000452e-01f, -7.22696036e-02f, 3.40815857e-02f, 1.54025089e-02f, 5.95180839e-02f, -1.97780598e-02f,
  -5.84781840e-02f, 6.82501122e-02f, 5.33038490e-02f, -6.44034520e-02f, -1.20706514e-01f, -4.09636041e-03f, -1.23016708e-01f, -1.00310408e-01f, 6.80974349e-02f, -1.59500852e-01f,
  -8.39046910e-02f, 2.02239439e-01f, -2.02415168e-01f, 8.27005729e-02f, -1.33485058e-02f, 3.34127783e-03f, 7.85811543e-02f, -1.04682393e-01f, -7.24298880e-02f, -6.03893511e-02f,
  -1.53504401e-01f, -1.19844526e-01f, -4.32951897e-02f, 1.74586698e-02f, -1.83111161e-01f, -1.38497993e-01f, -9.03586671e-02f, -1.19432874e-01f, -1.04893386e-01f, -2.09455505e-01f,
  -2.98577935e-01f, 1.23566501e-02f, -2.74630755e-01f, -2.08947733e-02f, 1.20158298e-02f, -1.29522607e-01f, 8.28254223e-02f, -8.42286199e-02f, 4.27289046e-02f, -1.12854235e-01f,
  -2.35404111e-02f, 3.11208993e-01f, -7.25285560e-02f, 7.16921687e-02f, 1.77393377e-01f, 1.17862470e-01f, 1.28857195e-01f, -1.35404952e-02f, -7.80274421e-02f, 1.48262847e-02f,
  -1.01603325e-02f, 7.72502348e-02f, 3.25266719e-02f, -9.43205580e-02f, 3.67097859e-03f, 5.10314181e-02f, 1.54481679e-01f, -5.03114462e-02f, -1.20362595e-01f, 2.74451561e-02f,
  2.02712461e-01f, 7.90569186e-02f, -9.65273604e-02f, -5.79343177e-02f, 1.50674134e-01f, -7.11063966e-02f, -1.10871159e-01f, 1.17110267e-01f, 1.50628239e-01f, 1.85399190e-01f,
  -9.57422704e-03f, -2.36542262e-02f, -1.03754625e-01f, 1.07021265e-01f, 9.89261456e-03f, -2.31781155e-01f, -1.61702469e-01f, -1.18032835e-01f, 1.04834497e-01f, -8.53126049e-02f,
  1.54237002e-01f, -5.75705431e-02f, 2.16495305e-01f, 1.97342448e-02f, 1.63744800e-02f, -1.07369252e-01f, -1.21320039e-01f, -1.74607128e-01f, -2.21050173e-01f, 1.56108197e-02f,
  2.16795757e-01f, 2.11258367e-01f, -4.78788763e-02f, -3.64661068e-02f, -9.03109908e-02f, 6.64913328e-03f, 4.34158519e-02f, 7.72750098e-03f, -1.19574636e-01f, -1.75079495e-01f,
  -7.96857476e-02f, 2.49055885e-02f, 6.17132820e-02f, -2.87447590e-02f, -4.14949134e-02f, 8.63746479e-02f, 1.53412730e-01f, 6.62797838e-02f, 1.21395610e-01f, 1.12995908e-01f,
  -3.65943238e-02f, -1.21856213e-01f, -9.96911377e-02f, -6.31133616e-02f, -1.48992613e-02f, 5.24176545e-02f, -1.00116199e-02f, -4.93976027e-02f, -3.24454866e-02f, -7.56786168e-02f,
  1.37245908e-01f, -7.54758343e-02f, -1.94039151e-01f, -9.39111710e-02f, 3.42712067e-02f, 2.84237321e-02f, -8.23222920e-02f, 3.98652479e-02f, -9.71693471e-02f, 3.09761707e-02f,
  -6.85297847e-02f, 1.52928205e-02f, -5.07580005e-02f, -2.61238683e-02f, 3.58371697e-02f, 2.04650275e-02f, -1.51020616e-01f, -3.07325628e-02f, 5.36833070e-02f, -6.97674081e-02f,
  7.97126733e-04f, -1.45436764e-01f, -6.78203776e-02f, -1.66739464e-01f, -2.04036072e-01f, -7.52901733e-02f, 3.30229141e-02f, 1.19264811e-01f, -1.38598606e-01f, 9.72938817e-03f,
  4.30071093e-02f, -7.19852000e-02f, 2.11913814e-03f, -2.18541808e-02f, 2.41993926e-02f, -1.74588323e-01f, -4.39976938e-02f, 3.38320546e-02f, -1.85880855e-01f, -1.55014649e-01f,
  3.97679240e-01f, 8.46377313e-02f, 4.92088258e-01f, 2.91186292e-02f, -2.09481344e-01f, 1.03271507e-01f, 1.70542791e-01f, 1.75789371e-01f, -1.13300994e-01f, -3.40787433e-02f,
  -1.30981430e-01f, -3.26484323e-01f, -2.36128703e-01f, -8.45211372e-02f, 1.78619862e-01f, 1.83922276e-01f, 9.46270823e-02f, 3.47251326e-01f, 3.64956737e-01f, 1.55842230e-01f,
  -2.05495596e-01f, 1.52532309e-01f, 1.50852174e-01f, 9.85405743e-02f, 6.72632158e-02f, -1.60803661e-01f, 1.20967545e-01f, 8.21161345e-02f, 1.14944493e-02f, 4.28134613e-02f,
  2.28778720e-02f, 3.24155450e-01f, -1.11452416e-01f, -1.83898389e-01f, -3.98680829e-02f, 6.75685257e-02f, 1.04310438e-02f, 9.64701734e-03f, -8.44627321e-02f, -3.18957418e-02f,
  -1.41473666e-01f, -1.93572380e-02f, -1.34794565e-03f, -5.81509843e-02f, 1.23349302e-01f, 5.49753606e-02f, 1.34158164e-01f, 2.27834508e-01f, 1.31738409e-01f, 3.55549715e-02f,
  -1.14472724e-01f, -1.62890349e-02f, 6.35600537e-02f, 6.49401248e-02f, 3.13299485e-02f, -1.83725312e-01f, -7.78730810e-02f, 1.18772693e-01f, 1.34058639e-01f, 1.49676576e-01f,
  -9.40329283e-02f, -1.47970682e-02f, -8.02995861e-02f, 1.42019793e-01f, 5.85260838e-02f, 9.65971947e-02f, 5.44871613e-02f, 3.39421928e-02f, 3.58546688e-03f, 5.30240275e-02f,
  3.67454737e-02f, 1.48749352e-01f, 5.31872511e-02f, 5.94849177e-02f, -1.31756783e-01f, 4.32105996e-02f, -1.41638415e-02f, -5.40763373e-03f, -3.16586383e-02f, 6.42430633e-02f,
  5.74324802e-02f, 1.40458912e-01f, 3.63981016e-02f, 5.84455878e-02f, 3.56073156e-02f, 4.32749204e-02f, 6.37613460e-02f, 5.36713842e-03f, -9.93294716e-02f, 3.12757045e-02f,
  -3.56037974e-01f, -8.79334658e-02f, 1.71760023e-02f, 2.87093706e-02f, 4.09986675e-02f, -3.06277238e-02f, -9.14881304e-02f, -1.00936115e-01f, -1.43187702e-01f, 2.78172884e-02f,
  -2.26515997e-02f, 1.28869832e-01f, 1.93842556e-02f, 9.95117724e-02f, 1.15141302e-01f, 9.30191600e-04f, -1.46702811e-01f, -8.31023008e-02f, -1.14410028e-01f, -7.54120722e-02f,
  -1.09173767e-01f, -1.04675524e-01f, -1.51842600e-02f, -3.98001298e-02f, -6.80461675e-02f, -1.36838242e-01f, -1.57192558e-01f, -1.44677265e-02f, 1.91142957e-03f, -1.03949986e-01f,
  1.81285292e-01f, -1.49687126e-01f, -4.26430434e-01f, 1.31612226e-01f, -7.65792727e-02f, -3.14650945e-02f, 8.34644511e-02f, 1.32195562e-01f, 1.26659736e-01f, 1.88304763e-02f,
  -3.97822410e-02f, -5.83174117e-02f, -6.92608505e-02f, -9.38633308e-02f, -5.70293292e-02f, -2.52282828e-01f, -2.61075526e-01f, -3.00055861e-01f, -1.56424850e-01f, 2.21475437e-01f,
  1.49224922e-01f, 1.65987894e-01f, 2.27797017e-01f, 1.69065669e-01f, 7.07184523e-02f, 1.05703063e-01f, -8.01811647e-03f, 6.45912886e-02f, -2.03358773e-02f, -3.28037500e-01f,
  -1.83424532e-01f, 2.94346064e-02f, -8.54623318e-02f, -7.47341514e-02f, -1.45736873e-01f, 4.83727194e-02f, -1.37538090e-01f, -3.72850299e-02f, -3.49971000e-03f, -8.60836655e-02f,
  -8.98458660e-02f, -7.11855888e-02f, -1.33514285e-01f, 2.25759726e-02f, 1.90315023e-01f, -8.44177604e-03f, -1.04757860e-01f, 7.00903451e-03f, -8.47967714e-03f, -1.21652827e-01f,
  -5.31503707e-02f, -1.34195313e-01f, -2.17778176e-01f, -7.87662193e-02f, -9.66615900e-02f, -1.88947782e-01f, -1.48824677e-01f, -9.52489674e-02f, -1.73013568e-01f, -1.21915946e-02f,
  5.82679510e-02f, -1.17820472e-01f, 9.66410059e-03f, 1.14619166e-01f, 9.32860598e-02f, 8.94914567e-02f, 5.05545689e-03f, 4.21106741e-02f, 6.61224350e-02f, -5.69672994e-02f,
  -1.43955216e-01f, 3.03220209e-02f, 4.57828380e-02f, 1.15797594e-02f, -1.82579774e-02f, -9.48387459e-02f, -2.12496910e-02f, 1.25510059e-02f, 7.54065514e-02f, 3.76002267e-02f,
  -3.84624954e-03f, -1.48929864e-01f, -1.94903817e-02f, -3.05731352e-02f, 3.20256613e-02f, -1.23295553e-01f, -4.61524278e-02f, 6.30923435e-02f, -1.06007151e-01f, -3.61396857e-02f,
  2.73725659e-01f, -2.13329300e-01f, 1.91103611e-02f, 4.05015238e-02f, -3.89401913e-02f, 1.85061656e-02f, -3.54285464e-02f, -1.24922886e-01f, -7.43736327e-02f, 1.97397787e-02f,
  -1.80482643e-03f, -1.37330696e-01f, -1.23075973e-02f, -1.62736438e-02f, 4.05371748e-02f, 3.73290367e-02f, 6.39322922e-02f, 6.23249821e-02f, 1.27884567e-01f, -1.52125088e-02f,
  6.63018078e-02f, 3.67757343e-02f, -1.02534005e-02f, -1.60028562e-01f, 1.06042475e-01f, -3.89238484e-02f, -5.12527935e-02f, 3.95968370e-02f, -2.17290036e-02f, 1.42641619e-01f,
  -8.75051543e-02f, -2.96583295e-01f, -2.18944266e-01f, -4.00075614e-01f, -1.20489307e-01f, 7.79403225e-02f, -3.01145809e-03f, 6.21077158e-02f, -9.10871848e-03f, -1.53017297e-01f,
  -6.59887716e-02f, 2.03863442e-01f, 3.58725265e-02f, 1.00431666e-01f, 1.58391356e-01f, -1.50098652e-01f, -2.87100613e-01f, 5.25133759e-02f, 3.41072172e-01f, 2.05413461e-01f,
  1.09908432e-01f, -2.98015103e-02f, 3.27685918e-03f, -3.92401591e-02f, -2.29382694e-01f, -7.41935074e-02f, -3.14785868e-01f, -2.16725901e-01f, 1.53778046e-02f, -4.72649455e-01f,
  -1.07432403e-01f, -1.97611988e-01f, 1.71000779e-01f, 7.33472705e-02f, -2.60005835e-02f, 5.18207364e-02f, -3.78208235e-02f, -1.30566970e-01f, -8.31729099e-02f, -6.94196718e-03f,
  -1.03048339e-01f, 4.91945026e-03f, 4.79318164e-02f, -8.79624113e-02f, -7.48673156e-02f, -6.61626831e-02f, -4.53425646e-02f, -4.21223752e-02f, -5.07812090e-02f, -9.41111520e-02f,
  -1.69118252e-02f, 1.32502783e-02f, 2.75518317e-02f, -5.63823320e-02f, 3.00073810e-03f, -4.04890673e-03f, -3.58474739e-02f, 2.82770786e-02f, 1.27066329e-01f, -3.22805643e-01f,
  -2.04586275e-02f, -3.17394128e-03f, 3.30938846e-02f, -2.08422039e-02f, -6.20718412e-02f, -4.25489657e-02f, -5.55065498e-02f, -2.20412519e-02f, 1.20582774e-01f, 1.97707973e-02f,
  7.18222633e-02f, -2.70693600e-02f, 8.17952007e-02f, -1.50199002e-02f, -7.53837973e-02f, -1.73192378e-02f, -2.46841664e-04f, -6.47075027e-02f, 2.90363133e-02f, 2.38108784e-02f,
  2.88774725e-02f, 6.08595498e-02f, 4.07124450e-03f, 1.30481184e-01f, 6.10439479e-02f, -7.25410581e-02f, 2.24673562e-02f, 1.25410020e-01f, -1.75346974e-02f, 1.48547664e-02f,
  -2.64387995e-01f, 2.91442782e-01f, -2.66940176e-01f, 3.08040958e-02f, -3.89858671e-02f, 8.03445466e-03f, 2.95919664e-02f, 4.72013839e-02f, -2.04476818e-01f, -1.84526630e-02f,
  4.12055925e-02f, -4.78904182e-03f, -2.10082605e-02f, -7.83649683e-02f, 4.60099317e-02f, 9.58442688e-02f, -1.08498476e-01f, 2.68941708e-02f, -3.56672588e-03f, 5.61634591e-03f,
  7.47556910e-02f, 5.40454946e-02f, 5.22008874e-02f, -1.66597310e-02f, 1.05990679e-03f, 1.28463954e-01f, 1.03442021e-01f, 5.50297052e-02f, 2.18571872e-01f, -2.46276915e-01f,
  -1.99406072e-01f, -6.72760233e-02f, -3.50241780e-01f, -2.74504542e-01f, -1.05660707e-01f, 1.10705510e-01f, 2.26004198e-01f, 1.65882394e-01f, -8.27584043e-02f, -4.34634909e-02f,
  9.50527787e-02f, -2.76323780e-02f, -1.99858487e-01f, -6.07684478e-02f, -4.97829765e-02f, -2.70669907e-01f, -2.26485357e-01f, -1.44651636e-01f, 1.04501076e-01f, 2.67401189e-01f,
  7.10892677e-02f, -1.52910814e-01f, -9.94724557e-02f, -1.97361961e-01f, -1.47044942e-01f, -2.30639771e-01f, -4.55831766e-01f, -2.98574835e-01f, -1.69857576e-01f, -4.74892855e-01f,
  -1.60819933e-01f, 1.56261310e-01f, 1.09571740e-01f, 1.43514499e-01f, -6.33464307e-02f, 1.45663144e-02f, 7.89306536e-02f, 1.05507329e-01f, 1.34413257e-01f, 4.32844652e-04f,
  -6.62556197e-03f, 1.31912520e-02f, 1.10091839e-03f, 6.84903562e-02f, -2.05668528e-02f, 1.48339331e-01f, 1.39846936e-01f, 1.09733880e-01f, 1.38395444e-01f, -3.03408988e-02f,
  1.09316982e-01f, 2.07005545e-01f, 1.80096596e-01f, 1.75097138e-01f, 1.36191964e-01f, 1.07170288e-02f, 1.47828028e-01f, 8.18292499e-02f, 7.17835501e-02f, -9.15045515e-02f,
  7.00609982e-02f, -1.04485331e-02f, -9.01367441e-02f, 2.02949550e-02f, 7.70900249e-02f, 4.24089022e-02f, -7.02864155e-02f, 6.44389493e-03f, -8.56828094e-02f, -3.88814993e-02f,
  9.00382847e-02f, 5.51407132e-03f, -4.70551439e-02f, -1.10320441e-01f, -1.91615000e-01f, 2.17712042e-03f, 4.81785573e-02f, -1.22147314e-01f, 5.87951131e-02f, 1.40851751e-01f,
  -1.56216128e-02f, 2.96817105e-02f, -1.92119643e-01f, -2.80603096e-02f, 9.14096758e-02f, -1.71060152e-02f, 7.00436831e-02f, 9.37884301e-02f, -7.14426562e-02f, 4.18396220e-02f,
  -1.88071966e-01f, 4.16037887e-02f, -8.64349902e-02f, 1.78200882e-02f, -1.61288291e-01f, -9.36263055e-02f, -1.23929612e-01f, -1.39282033e-01f, -5.71448822e-03f, -6.33381009e-02f,
  1.16135992e-01f, -5.74767105e-02f, -1.99331194e-01f, 8.75605643e-02f, -8.72643366e-02f, 4.89744991e-02f, 4.48243991e-02f, -2.82887202e-02f, 2.50064805e-02f, -1.97941437e-02f,
  1.87467020e-02f, 1.56110570e-01f, 3.80142890e-02f, 4.52087261e-02f, 2.38692313e-02f, -5.03094941e-02f, -1.49829149e-01f, -6.53429255e-02f, -1.33928463e-01f, -1.35053039e-01f,
  2.32349753e-01f, -1.45045191e-01f, -6.31779879e-02f, 1.46551237e-01f, -2.55185783e-01f, -1.20017275e-01f, -4.07305062e-02f, 7.27904215e-02f, 7.28411078e-02f, -4.71941642e-02f,
  8.96082446e-02f, 1.24531850e-01f, 8.10237452e-02f, -1.44826854e-02f, 1.78550616e-01f, -1.44071192e-01f, -1.99910209e-01f, 4.33541648e-02f, 1.31450415e-01f, 9.05591846e-02f,
  7.30228238e-03f, -2.78898720e-02f, 1.04933232e-01f, 9.94234011e-02f, -1.87458009e-01f, 4.99287806e-02f, -1.11695454e-01f, -1.09104618e-01f, -1.06468998e-01f, -2.39940241e-01f,
  2.34056652e-01f, -1.53352067e-01f, 4.40626368e-02f, 3.12042739e-02f, -1.59524754e-01f, -1.01307057e-01f, -1.12898715e-01f, -1.05478607e-01f, -2.44427528e-02f, 8.54300633e-02f,
  -2.07704678e-01f, -1.43520504e-01f, 4.53237966e-02f, -1.42546818e-01f, -1.05988003e-01f, -3.35181467e-02f, -8.25401247e-02f, -3.26326825e-02f, 9.38204899e-02f, 2.28716116e-02f,
  3.44696455e-02f, -2.13162601e-01f, -1.42590582e-01f, 9.78831388e-03f, -5.98502718e-02f, -1.09782606e-01f, -1.62920684e-01f, -1.87599152e-01f, -7.78023377e-02f, -1.18817352e-01f,
  -2.82529239e-02f, 2.65226737e-02f, -1.39454678e-01f, 1.19736440e-01f, 5.27425744e-02f, 4.85266522e-02f, -9.65589508e-02f, 4.96275537e-03f, 5.09602763e-02f, -1.46624640e-01f,
  -1.17797755e-01f, -5.24111316e-02f, -1.32641032e-01f, 7.57330433e-02f, 5.48994094e-02f, 2.71734013e-03f, 1.49298552e-02f, -6.40606284e-02f, 1.59461573e-02f, 5.45801297e-02f,
  1.02723673e-01f, -2.96346843e-02f, 1.04652066e-02f, -3.71273942e-02f, -1.37080118e-01f, -6.84751198e-02f, 8.29366744e-02f, 7.30166063e-02f, 5.16023189e-02f, -8.24721903e-02f,
  1.69455484e-01f, -3.35019007e-02f, 1.25039205e-01f, -1.58649579e-01f, -2.23011464e-01f, 1.26095071e-01f, 3.83587740e-02f, 1.31904352e-02f, 1.91525444e-02f, -7.91005418e-02f,
  -1.49868682e-01f, -2.05829628e-02f, 6.14452399e-02f, 2.98760869e-02f, 1.12160724e-02f, 1.61315262e-01f, -1.42793478e-02f, 1.33856647e-02f, 2.65190527e-02f, -9.28759649e-02f,
  5.83109818e-02f, -6.89355358e-02f, 5.14967404e-02f, 6.02437044e-03f, 1.42875537e-02f, -9.62851848e-03f, 4.42786003e-03f, 9.68331769e-02f, -2.45861448e-02f, 1.34911150e-01f,
  4.42668468e-01f, -3.36793810e-01f, -3.09663683e-01f, 1.00466669e-01f, -8.37156400e-02f, -1.48377761e-01f, -3.94439429e-01f, -1.46084055e-01f, 1.07312180e-01f, -2.77271509e-01f,
  -2.33232528e-01f, 1.33357406e-01f, 1.05110884e-01f, -2.51253438e-03f, 1.70290425e-01f, -3.64081323e-01f, -2.10376039e-01f, 1.12056099e-01f, 2.41638884e-01f, 6.66543245e-02f,
  -1.29078433e-01f, -3.88474599e-03f, 2.24040613e-01f, 1.18099011e-01f, -1.38925210e-01f, 1.58194751e-02f, -3.24384719e-01f, -1.19357519e-01f, -5.52056320e-02f, -3.33109528e-01f,
  -1.26646459e-01f, -7.67319351e-02f, 6.54960498e-02f, 6.84722885e-02f, -3.88835520e-02f, 1.55512094e-02f, -9.52187628e-02f, -1.37238547e-01f, -5.57170846e-02f, -7.44498596e-02f,
  -3.93709131e-02f, -1.32533416e-01f, 1.48717342e-02f, -1.55198071e-02f, 1.14474081e-01f, 1.12227676e-02f, -7.57122412e-02f, -3.52458470e-02f, 2.78922729e-02f, -1.82843119e-01f,
  -1.22690633e-01f, -6.20546378e-02f, 1.17449917e-01f, -2.10358649e-02f, 3.93092595e-02f, 1.60246104e-01f, -1.85432792e-01f, 8.25763866e-02f, 7.41140395e-02f, -2.33532667e-01f,
  -1.63096741e-01f, -1.39864936e-01f, -6.63140416e-02f, -4.24649268e-02f, -2.14936938e-02f, -2.02450366e-03f, 2.33278219e-02f, 1.56804070e-01f, 6.88329339e-02f, -7.06895664e-02f,
  3.30823846e-02f, 1.85864251e-02f, 9.86281876e-03f, 4.36045229e-02f, 3.24451365e-02f, -8.30805674e-03f, -2.72346474e-02f, -5.50913811e-02f, -7.34606199e-03f, 1.40454117e-02f,
  -2.20700123e-04f, -3.72425914e-02f, -3.00526842e-02f, 8.40992630e-02f, -7.32875541e-02f, -6.61747251e-03f, -1.16838084e-03f, 3.08568124e-02f, 1.95251212e-01f, 2.51457132e-02f,
  6.16355687e-02f, -6.96491869e-03f, -6.92189634e-02f, -4.92421761e-02f, 1.76940858e-02f, -8.11286047e-02f, -1.86468825e-01f, 6.07931241e-02f, 1.34055018e-01f, -1.03351906e-01f,
  7.23234862e-02f, 1.04393968e-02f, -5.57131171e-02f, -5.26555330e-02f, 1.05025411e-01f, 2.87656356e-02f, -9.08030570e-03f, 8.92001018e-02f, 1.44437328e-01f, 1.85762048e-02f,
  -9.17464420e-02f, -4.34474135e-03f, 2.32957795e-01f, -3.07747610e-02f, 9.54107046e-02f, 2.35886201e-01f, 8.59010313e-03f, 4.49915975e-02f, 2.06687942e-01f, -6.91754445e-02f,
  5.50230384e-01f, 3.32200021e-01f, -6.64299726e-02f, 9.32344943e-02f, -4.69107181e-03f, -3.84451672e-02f, 1.15850538e-01f, 4.16091494e-02f, 8.51244181e-02f, 2.82320201e-01f,
  3.52203958e-02f, -1.17924772e-01f, -1.09559447e-01f, -2.70717651e-01f, -1.71138406e-01f, 9.21854898e-02f, 8.64520893e-02f, -1.42607644e-01f, -2.86364794e-01f, -1.07878968e-02f,
  -1.27185255e-01f, 9.41504166e-02f, 1.38147309e-01f, -4.68200035e-02f, 6.13470711e-02f, -1.89598158e-01f, 5.14488518e-02f, 1.65867433e-01f, -6.30455241e-02f, 1.42409161e-01f,
  -1.43961713e-01f, 1.74201787e-01f, -4.88212079e-01f, -1.54494107e-01f, 4.48245034e-02f, 1.76156182e-02f, 1.90035012e-02f, 6.25720620e-03f, 6.29901141e-02f, 4.14531445e-03f,
  4.29340862e-02f, 1.20763972e-01f, 4.22996841e-02f, -8.90214741e-03f, 2.74303891e-02f, 5.03943749e-02f, 2.33325779e-01f, 6.83379397e-02f, -4.50303126e-03f, -2.22808030e-02f,
  -5.26797399e-02f, 8.80682766e-02f, 6.49134889e-02f, -7.78245181e-02f, 3.24341990e-02f, -1.08978145e-01f, 6.92510903e-02f, -2.43283007e-02f, -6.41067028e-02f, 1.32823750e-01f,
  -2.68299710e-02f, 2.08362024e-02f, 8.30218196e-02f, 3.62482630e-02f, 3.67473811e-02f, -9.86184776e-02f, 8.69606808e-03f, -5.66015169e-02f, 1.61786471e-02f, 2.31835209e-02f,
  -9.23204720e-02f, -5.25952615e-02f, -5.04875109e-02f, 5.26838340e-02f, -7.99256712e-02f, 2.60080807e-02f, -5.74566461e-02f, 8.85778517e-02f, -1.58551000e-02f, -1.76390763e-02f,
  -2.77647618e-02f, 2.68737487e-02f, -3.06688957e-02f, 3.55503894e-02f, -1.85509063e-02f, -3.72430533e-02f, -1.19588874e-01f, -8.80530924e-02f, 2.98114531e-02f, -6.07110448e-02f,
  -4.25920904e-01f, -4.11906481e-01f, -1.58539917e-02f, -2.09084094e-01f, -5.03097735e-02f, -7.84078985e-02f, -1.01217255e-01f, -6.10247739e-02f, 1.05971657e-01f, 5.33501878e-02f,
  -2.15988774e-02f, -1.01444526e-02f, -1.98579859e-02f, -8.13588575e-02f, -1.33282110e-01f, -1.49251029e-01f, 1.96696371e-01f, -1.58648863e-02f, -5.73020689e-02f, -1.73039529e-02f,
  2.59575620e-02f, 2.06532702e-02f, 6.27933443e-02f, -1.07419804e-01f, -7.93101937e-02f, -5.27507737e-02f, -3.82523052e-02f, -9.28086564e-02f, -1.80554509e-01f, 1.19827926e-01f,
  3.75447035e-01f, 1.26588300e-01f, 1.65416431e-02f, 1.05291799e-01f, 3.04279238e-01f, 1.51556730e-01f, 1.69335857e-01f, 1.00828975e-01f, 3.36403362e-02f, 6.77861972e-03f,
  1.46347862e-02f, -1.77990466e-01f, -2.67326415e-01f, -1.46153614e-01f, -1.56601444e-01f, -1.23165008e-02f, 1.27710123e-02f, -5.09283990e-02f, -9.43028629e-02f, -5.46431867e-04f,
  -4.69888076e-02f, 1.74340293e-01f, 1.11952074e-01f, -3.88015397e-02f, -6.09449260e-02f, -1.37307987e-01f, 5.32430522e-02f, 1.20800592e-01f, 4.77013625e-02f, -5.61628751e-02f,
  -5.04996553e-02f, 2.25250378e-01f, -1.16298899e-01f, -1.07481040e-01f, -4.28178012e-02f, -3.11769415e-02f, -5.05627804e-02f, -1.80815160e-01f, -1.06961891e-01f, 7.31147155e-02f,
  -4.32349518e-02f, 1.95394859e-01f, 1.73691306e-02f, 2.62186285e-02f, 4.09210622e-02f, -9.53855664e-02f, -3.45433094e-02f, 2.52197254e-02f, -1.18999645e-01f, -1.21642300e-03f,
  -5.40700853e-02f, 3.81438434e-02f, 6.01932406e-02f, 1.65805072e-02f, -1.28164798e-01f, -3.19442376e-02f, -7.26014599e-02f, 9.27085504e-02f, -8.73827711e-02f, 4.58804481e-02f,
  9.94185079e-03f, 4.71797027e-02f, -5.96357696e-03f, 8.02430883e-02f, 6.63610324e-02f, 1.26302242e-02f, 6.25011772e-02f, 7.23122805e-02f, 3.94251347e-02f, 1.21522576e-01f,
  -1.72710925e-01f, 4.66134734e-02f, -1.12641603e-02f, 1.53296757e-02f, 2.12687757e-02f, 2.99369618e-02f, 1.17242813e-01f, -3.84675860e-02f, -2.56168190e-02f, 6.18265197e-03f,
  1.50269270e-02f, -3.72442491e-02f, -5.00198975e-02f, -7.98180327e-02f, -5.26459143e-03f, 8.25329199e-02f, -4.70331870e-02f, 5.27635440e-02f, -1.39675178e-02f, 6.99510425e-03f,
  -7.18687251e-02f, -5.65518960e-02f, -1.22523218e-01f, -2.93674767e-01f, 3.18779089e-02f, -8.57573152e-02f, -2.54221857e-01f, -1.44301996e-01f, 1.07423656e-01f, 8.62609893e-02f,
  -4.55800258e-03f, -5.42064477e-03f, -1.30621925e-01f, -1.90990955e-01f, 4.66401279e-02f, 7.07695121e-03f, -5.55032156e-02f, -9.59046856e-02f, -3.92101221e-02f, 8.68101344e-02f,
  -5.63742891e-02f, 9.20404717e-02f, 1.29715763e-02f, -6.28977790e-02f, -5.13017029e-02f, -1.16363857e-02f, -2.94473413e-02f, 2.00639851e-02f, -2.80397814e-02f, -6.81078508e-02f,
  2.81915963e-01f, 1.32595703e-01f, 3.29706818e-02f, 1.48566356e-02f, 6.97635710e-02f, 1.27498373e-01f, 3.12019527e-01f, -2.03406382e-02f, -8.88347551e-02f, -9.33070201e-03f,
  -3.23397443e-02f, -1.53823242e-01f, -2.34702975e-01f, -1.41421348e-01f, 1.37382105e-01f, 1.32058427e-01f, 1.15148559e-01f, 9.82170776e-02f, -8.22900757e-02f, 8.98444578e-02f,
  -6.87346235e-02f, 1.25471607e-01f, -2.87943929e-02f, -5.84468693e-02f, -4.07168120e-02f, -2.03733578e-01f, -4.98673022e-02f, 8.56685936e-02f, 1.37532085e-01f, 1.19444713e-01f,
  1.75458819e-01f, 1.80172205e-01f, -2.90614754e-01f, -1.31405815e-01f, -3.02895028e-02f, 1.95086896e-02f, 1.12769656e-01f, -3.07263117e-02f, 1.35117024e-03f, 1.51759405e-02f,
  -9.23664775e-03f, 6.17898218e-02f, -1.89145748e-02f, 9.96850505e-02f, 1.49285004e-01f, -3.89791019e-02f, -6.91432282e-02f, 7.37221241e-02f, -1.90861560e-02f, 2.20720805e-02f,
  1.12092331e-01f, 1.88968450e-01f, 1.75712213e-01f, -1.46387052e-02f, -2.74519604e-02f, -7.67072812e-02f, 6.22243993e-02f, 2.74944603e-02f, -4.24376205e-02f, 7.34981298e-02f,
  -2.03135312e-02f, -9.66488495e-02f, -5.09638861e-02f, 1.26925111e-01f, 1.32765591e-01f, -6.45414665e-02f, -3.16275582e-02f, 1.24282345e-01f, 8.09430629e-02f, 1.16136428e-02f,
  -8.14647600e-02f, -1.01965712e-02f, 8.99694115e-02f, -1.09886561e-04f, -5.35014756e-02f, 1.12047911e-01f, -1.26109449e-02f, -5.84562570e-02f, -8.03575292e-02f, 8.47918689e-02f,
  4.55658510e-03f, 1.09084234e-01f, -1.43223822e-01f, 9.61840749e-02f, 3.39939296e-02f, 3.73477414e-02f, 5.77486567e-02f, -1.31655321e-01f, -3.15922648e-02f, -3.14707123e-02f,
  -1.83180213e-01f, -4.38563265e-02f, -3.99600863e-02f, -9.49295387e-02f, 3.19420211e-02f, -9.87734869e-02f, 6.99739009e-02f, 1.21907787e-02f, -8.05954784e-02f, -3.51356976e-02f,
  -1.12618329e-02f, -6.34834692e-02f, 7.75508434e-02f, 4.87388857e-03f, 2.34759748e-02f, -7.42169330e-03f, -6.99845403e-02f, 2.09521782e-03f, 2.83654667e-02f, 9.10721570e-02f,
  -4.09661978e-02f, -6.34146407e-02f, -1.28090113e-01f, -1.42417520e-01f, -1.61377400e-01f, -1.51430294e-01f, -3.49925905e-02f, 2.96357013e-02f, -1.10667787e-01f, -1.75859615e-01f,
  -3.68196666e-01f, -1.34872437e-01f, 9.96599272e-02f, -1.09601684e-01f, 1.16438851e-01f, -5.40757179e-02f, -1.18354484e-01f, 7.93262050e-02f, -3.16516683e-02f, -6.59324229e-02f,
  6.04212023e-02f, 3.02062910e-02f, -4.16818634e-02f, -5.91384200e-03f, -1.75172836e-01f, -2.30753049e-01f, -1.27722993e-01f, -1.05464838e-01f, 1.25236809e-01f, 1.95785239e-01f,
  2.65236758e-02f, -6.65767863e-02f, -1.10057928e-01f, 9.74695683e-02f, -8.32556840e-03f, 2.73195151e-02f, -5.77224977e-02f, -1.32309914e-01f, 3.25929932e-02f, -3.12575638e-01f,
  1.27943173e-01f, -4.49753925e-02f, 1.17228612e-01f, -2.34501213e-01f, 1.20107926e-01f, 3.22447065e-03f, -3.88103761e-02f, 4.71374132e-02f, 4.75196801e-02f, -8.56376663e-02f,
  -1.02820531e-01f, 1.12943217e-01f, 5.49175777e-02f, 5.20172976e-02f, -2.58188490e-02f, -3.22978124e-02f, -1.94863658e-02f, 4.85404162e-03f, 5.80554307e-02f, 6.21667057e-02f,
  -3.31482962e-02f, -8.69849417e-03f, -8.84684473e-02f, -2.71147266e-02f, 9.30984411e-03f, 2.01272666e-02f, 9.44921747e-02f, 6.68073818e-02f, 5.57608530e-02f, -3.51065695e-01f,
  1.64678600e-02f, -4.36394326e-02f, 1.22235149e-01f, 2.25231368e-02f, -1.31859303e-01f, 1.67152062e-02f, -7.39864334e-02f, -1.74371392e-01f, 1.05107024e-01f, 3.98837104e-02f,
  1.00474916e-01f, -4.59316224e-02f, -1.77295581e-02f, 1.02518030e-01f, -3.63403186e-02f, 5.94163546e-03f, 7.74995936e-03f, -8.41634944e-02f, 2.84543689e-02f, -9.09916833e-02f,
  -2.62418445e-02f, -1.39038846e-01f, -2.54500322e-02f, 7.58266076e-02f, -7.51569271e-02f, -2.78421473e-02f, -1.33986473e-02f, 4.92909104e-02f, 9.94661376e-02f, 3.63626331e-02f,
  3.16529013e-02f, 1.54942730e-02f, -9.78385881e-02f, -1.31006744e-02f, -1.19705237e-01f, 4.86249998e-02f, -5.55904582e-02f, -9.48399901e-02f, 2.02672258e-02f, -3.08939256e-02f,
  -1.34906232e-01f, -8.41636769e-03f, -1.33095440e-04f, -3.24599887e-03f, -7.14136958e-02f, 8.54301974e-02f, -3.17740798e-01f, 5.31849042e-02f, -4.19198945e-02f, -4.29850668e-02f,
  -2.40297526e-01f, -9.75332856e-02f, -2.30834275e-01f, -1.34697974e-01f, 3.43628488e-02f, -1.09892607e-01f, 1.30498618e-01f, 4.76513337e-03f, 6.20484352e-03f, -2.92125314e-01f,
  9.71861258e-02f, -5.70458956e-02f, -2.38140985e-01f, 3.18567127e-01f, 1.83780208e-01f, 5.60484454e-02f, -1.83704555e-01f, -1.11953594e-01f, 5.65888621e-02f, -1.63192544e-02f,
  1.22165591e-01f, 1.62955955e-01f, 1.29497737e-01f, -4.51576337e-02f, -8.39537010e-02f, -6.44570589e-02f, -5.42826718e-03f, -7.99470246e-02f, -1.57217719e-02f, 6.09662710e-03f,
  1.65515050e-01f, 1.70043528e-01f, -3.45372073e-02f, -2.57242341e-02f, 1.38853237e-01f, 2.49840572e-01f, -1.79846194e-02f, 5.04284836e-02f, -6.79394528e-02f, 9.32039097e-02f,
  1.34587035e-01f, -1.44794032e-01f, -4.86213155e-02f, 1.62630647e-01f, -2.00009206e-03f, -1.74646564e-02f, -1.34831131e-01f, -1.70128807e-01f, -3.27615556e-03f, -9.51977372e-02f,
  2.42868718e-02f, -8.37529078e-02f, 1.44319832e-01f, 1.48399726e-01f, -4.76317927e-02f, 9.97789297e-03f, -1.03914984e-01f, -1.37129053e-01f, -3.10348161e-03f, 1.85973831e-02f,
  1.52476996e-01f, 1.24646351e-01f, -2.33546093e-01f, 4.61182892e-02f, -1.63349226e-01f, -2.62444885e-03f, -2.83187985e-01f, -1.18644878e-01f, -1.77127481e-01f, -5.17027788e-02f,
  8.96844361e-03f, 7.86943585e-02f, -2.37952154e-02f, -1.38981745e-01f, 8.05881172e-02f, -2.45720651e-02f, 1.05931506e-01f, 1.06704384e-01f, 6.74832761e-02f, -9.60818678e-02f,
  5.53908236e-02f, -5.01720747e-03f, -5.83115406e-02f, -6.72558174e-02f, 6.06675595e-02f, 4.61506359e-02f, 3.33122984e-02f, -3.84747982e-02f, -7.83746168e-02f, -7.11587220e-02f,
  9.14174318e-02f, 1.17982663e-01f, -1.00062042e-01f, -6.22859132e-03f, 6.57349313e-03f, -7.40078976e-04f, 4.22320329e-02f, 5.73225245e-02f, -7.12709650e-02f, -8.85186568e-02f,
  1.20633721e-01f, -1.39510944e-01f, 1.56868637e-01f, 6.48834882e-03f, -6.47714436e-02f, 6.78824782e-02f, 1.11582009e-02f, 1.90286994e-01f, 2.97362041e-02f, 2.37878397e-01f,
  -1.06677286e-01f, 4.07823846e-02f, -8.81548375e-02f, -1.30973130e-01f, 3.22269537e-02f, -7.06750667e-03f, -1.29766837e-01f, 1.00809850e-01f, -1.09190218e-01f, 3.38392593e-02f,
  3.79601158e-02f, -1.16770633e-01f, 4.85987216e-02f, -7.31450319e-02f, -1.21021971e-01f, 1.16004825e-01f, -1.37473568e-01f, -2.08881497e-01f, -1.46523982e-01f, -2.14591950e-01f,
  -5.37900686e-01f, 9.00549665e-02f, 7.63700828e-02f, -2.70756155e-01f, 8.52201432e-02f, -1.25858158e-01f, -7.95482472e-02f, 9.98720527e-03f, -1.93604410e-01f, -1.52177587e-01f,
  -2.97857542e-02f, -1.49957657e-01f, -1.09138578e-01f, -1.68994173e-01f, -3.68102759e-01f, -2.93482393e-01f, -5.20151556e-02f, -2.17830971e-01f, -2.96208590e-01f, -1.71959504e-01f,
  -1.70586228e-01f, -3.05220962e-01f, -1.73720434e-01f, -1.78901121e-01f, 4.57662418e-02f, -5.37012741e-02f, 1.71361238e-01f, 1.54127525e-02f, 7.85365254e-02f, 1.22254297e-01f,
  -1.78447142e-01f, 5.51799126e-02f, -7.55716814e-03f, -6.21594228e-02f, -3.77419628e-02f, 1.61972344e-02f, -7.79380798e-02f, 3.62413079e-02f, 7.35461637e-02f, -1.37663424e-01f,
  -4.80301455e-02f, 5.03300279e-02f, -1.95118375e-02f, 6.68609375e-03f, -8.23050663e-02f, -1.78935423e-01f, 3.07216123e-02f, -2.04857320e-01f, 6.03479296e-02f, 1.40380710e-01f,
  9.81106833e-02f, 2.50478828e-04f, -8.73423293e-02f, 1.16656013e-01f, 1.04666501e-01f, -6.89398646e-02f, 1.09813064e-02f, 1.11255676e-01f, 7.98074007e-02f, 1.52381323e-02f,
  -2.32778285e-02f, 2.49732547e-02f, 5.07183895e-02f, -7.30069131e-02f, -1.03590436e-01f, 4.84906547e-02f, -5.21863699e-02f, 1.53323552e-02f, -2.21369206e-03f, -1.28583953e-01f,
  -2.28950679e-02f, -1.35287354e-02f, 6.39814660e-02f, 6.71602860e-02f, 6.90317079e-02f, -7.76513591e-02f, -2.76170354e-02f, 3.93821672e-02f, 8.20505843e-02f, -4.79509011e-02f,
  -1.04965150e-01f, 2.33960718e-01f, 3.24564092e-02f, -4.97465245e-02f, -8.19795504e-02f, -1.18970439e-01f, 1.34446821e-03f, -3.43310647e-03f, -1.08635813e-01f, -1.39687747e-01f,
  -1.35893643e-01f, -1.42031282e-01f, -1.93562791e-01f, 4.95250002e-02f, -1.22259021e-01f, 1.30853876e-01f, 4.49863747e-02f, 2.88467370e-02f, -1.53434381e-01f, -1.30576909e-01f,
  -1.41485766e-01f, 7.41363764e-02f, 3.78434695e-02f, 1.01683863e-01f, -1.16995517e-02f, -5.72390445e-02f, -3.63825671e-02f, -1.00556955e-01f, 1.40144318e-01f, 9.03901532e-02f,
  9.18888971e-02f, -5.67210913e-02f, -1.18052788e-01f, 8.68104547e-02f, 1.20244652e-01f, -3.34530398e-02f, -1.27454279e-02f, 5.34473434e-02f, -1.30604163e-01f, -7.45257363e-02f,
  -4.01387900e-01f, -3.49467576e-01f, 1.50790429e-02f, -7.20709190e-02f, 1.39964116e-03f, -3.15331966e-02f, -2.88916260e-01f, -1.78803820e-02f, -4.00754176e-02f, -3.25866938e-01f,
  -1.93555262e-02f, 6.57642409e-02f, -7.59020820e-03f, 1.68994173e-01f, 9.11100954e-02f, -2.44441420e-01f, -1.69029444e-01f, 1.57591343e-01f, 4.27955687e-01f, 3.81400496e-01f,
  1.92937419e-01f, 4.64709289e-02f, 1.59285024e-01f, 5.12468331e-02f, -1.54825628e-01f, 1.10887177e-01f, -2.16842979e-01f, -7.66979009e-02f, -9.60697457e-02f, -2.99451441e-01f,
  -2.11486772e-01f, -2.01535895e-01f, 1.20253183e-01f, 5.66299111e-02f, 8.76190513e-02f, -7.59041980e-02f, -1.07402569e-02f, -2.84700841e-02f, -2.23244224e-02f, -3.07814907e-02f,
  4.36684005e-02f, 1.93137154e-01f, 1.20417081e-01f, 3.35127302e-02f, -3.11189126e-02f, 3.12435385e-02f, -2.89789904e-02f, -9.12847966e-02f, -1.73513591e-01f, -6.58217445e-02f,
  -1.59128040e-01f, -9.65975821e-02f, -1.60204712e-02f, -3.41397859e-02f, -1.07504696e-01f, 8.26199129e-02f, 6.48657009e-02f, 1.65181294e-01f, -4.43459814e-03f, -4.06451821e-01f,
  -6.20690593e-03f, -9.28955004e-02f, 9.52586830e-02f, -1.20314183e-02f, 1.52007453e-02f, -4.02043238e-02f, 2.96826358e-03f, 1.55375563e-02f, 9.01261494e-02f, -3.75071466e-02f,
  1.26720574e-02f, 1.69815086e-02f, 7.47753605e-02f, -1.14445925e-01f, -4.70659770e-02f, 4.73735407e-02f, -1.03196591e-01f, 8.84522963e-03f, 4.55285572e-02f, 9.95079055e-04f,
  8.57624039e-02f, 1.13631934e-01f, -3.57297584e-02f, 2.88040079e-02f, -3.31237093e-02f, -5.79240955e-02f, -5.56626581e-02f, 1.04115335e-02f, -1.68506447e-02f, 5.28002903e-03f,
  -1.08947657e-01f, 1.40758157e-01f, -2.69385517e-01f, 3.37369600e-03f, 4.45936471e-02f, -5.56112416e-02f, -3.01681701e-02f, 2.77745854e-02f, -3.40787210e-02f, -9.79098305e-02f,
  -2.66395267e-02f, -5.82882129e-02f, -6.50977567e-02f, 4.32267115e-02f, 1.38631076e-01f, -8.46987963e-03f, -1.38372153e-01f, 8.96742791e-02f, -8.07110667e-02f, -8.50515161e-03f,
  -1.22597359e-01f, -7.77664185e-02f, -1.38803702e-02f, -2.31327683e-01f, -1.08425356e-01f, -5.11775911e-02f, -2.72204373e-02f, -1.70925036e-01f, -5.62453568e-02f, -4.51217800e-01f,
  -5.71411923e-02f, 2.17743188e-01f, -1.63236737e-01f, 1.35562822e-01f, -8.01885948e-02f, -2.67977744e-01f, -1.29030004e-01f, 5.22803888e-02f, 1.95155188e-01f, 1.58944979e-01f,
  -5.24759814e-02f, -2.41075307e-01f, -2.89481059e-02f, -1.91534847e-01f, -3.60764533e-01f, -5.24691641e-02f, -1.68617576e-01f, -3.71622384e-01f, -5.13720632e-01f, -3.29934686e-01f,
  -1.10016160e-01f, 1.67945381e-02f, -1.62606519e-02f, -2.67354213e-03f, 1.52338371e-01f, 3.28578986e-02f, 2.47738838e-01f, -8.66389554e-03f, -8.85566846e-02f, 1.04242757e-01f,
  -2.73748338e-01f, 8.07560682e-02f, -1.06401026e-01f, -2.70117447e-02f, 1.74470954e-02f, -1.00820065e-01f, -9.76859108e-02f, 7.58473398e-05f, 7.11522177e-02f, 1.92937106e-02f,
  2.71188263e-02f, -2.07325220e-01f, -1.66099116e-01f, -2.41792500e-02f, -8.37173387e-02f, -1.54506177e-01f, -1.27766971e-02f, -1.13341525e-01f, -1.97400570e-01f, -1.38653278e-01f,
  -1.29372671e-01f, -2.46421367e-01f, -1.28075555e-01f, -6.41711578e-02f, -1.47956446e-01f, -2.11366639e-01f, -5.24852835e-02f, -5.63374162e-02f, -1.12144239e-01f, 2.05666810e-01f,
  8.06817040e-03f, -4.21883538e-02f, 1.83293149e-01f, -5.78693561e-02f, 1.20927289e-01f, 5.20377159e-02f, -5.21076284e-02f, 1.06312379e-01f, -6.41802549e-02f, -1.15479633e-01f,
  1.68442745e-02f, -1.04979100e-02f, -5.65094016e-02f, 8.48221853e-02f, 5.11088222e-02f, -1.56549346e-02f, -3.94115672e-02f, 6.06140085e-02f, -1.85699295e-02f, -1.42648183e-02f,
  -8.73030052e-02f, -9.90558532e-04f, 4.11661603e-02f, 9.23528373e-02f, -2.82866824e-02f, -4.66194488e-02f, -7.16629550e-02f, 4.30009738e-02f, 1.42728752e-02f, -5.15874997e-02f,
  2.37984791e-01f, -1.20525062e-01f, 3.94532308e-02f, 1.39233574e-01f, -3.61340158e-02f, 6.26023673e-03f, -8.39991048e-02f, 2.15139110e-02f, 1.06283166e-02f, 2.63808426e-02f,
  -2.53781557e-01f, 1.16163371e-02f, -5.76658584e-02f, 4.16427702e-02f, -2.50308271e-02f, -2.81147957e-02f, 1.41030118e-01f, -4.88665178e-02f, -7.33119398e-02f, -2.26015281e-02f,
  3.12553905e-02f, 1.03979453e-01f, -1.15840258e-02f, 1.31825790e-01f, 7.14331716e-02f, -1.59862563e-02f, -3.83499116e-02f, 1.18423058e-02f, -4.03880328e-02f, 3.18891823e-01f,
  6.23765811e-02f, -1.18310511e-01f, -2.48425797e-01f, 3.09645921e-01f, 3.33899222e-02f, -1.14615694e-01f, -3.22734565e-01f, 9.03338715e-02f, 1.27716377e-01f, -1.61087096e-01f,
  7.36513808e-02f, 1.98667929e-01f, 5.81272580e-02f, -1.60204887e-01f, -9.55675319e-02f, -4.00527477e-01f, -2.20892698e-01f, -2.30597705e-01f, -6.04850724e-02f, 1.15107827e-01f,
  -1.00158438e-01f, -1.16306379e-01f, -2.25026309e-02f, 9.80210006e-02f, -6.74253190e-03f, 2.48151422e-02f, -1.97118327e-01f, -1.17502324e-01f, -2.91313797e-01f, -3.85869145e-01f,
  -2.79435068e-01f, -4.65766750e-02f, -3.21349539e-02f, -1.36207134e-01f, -7.48777948e-03f, 1.43088728e-01f, -5.15999272e-02f, 2.22821496e-02f, 1.41701058e-01f, -2.25406494e-02f,
  7.77215213e-02f, 1.23524345e-01f, 4.55392674e-02f, -5.79608232e-02f, 5.57351783e-02f, 2.48238295e-02f, -3.59197520e-02f, -7.78274611e-02f, 3.69682238e-02f, -4.42795716e-02f,
  -1.07045248e-01f, -3.39972191e-02f, -3.86221372e-02f, -7.37332776e-02f, 9.29682795e-03f, -1.38192669e-01f, -9.27915201e-02f, 7.08770454e-02f, -1.77582785e-01f, -1.30946919e-01f,
  -1.46872252e-01f, 7.85559937e-02f, -9.30705294e-02f, 5.78821003e-02f, 1.42361745e-01f, 1.26783373e-02f, 3.58310412e-03f, 6.57202229e-02f, 4.08318043e-02f, -3.28005776e-02f,
  2.27736980e-02f, -4.60862108e-02f, -4.04684711e-03f, -9.33635682e-02f, -1.48670062e-01f, -8.51416141e-02f, 1.82975444e-03f, -1.95817165e-02f, 9.00005847e-02f, 1.22240461e-01f,
  3.06463353e-02f, -3.19881481e-03f, 7.00779632e-03f, -2.34235805e-02f, -2.30090711e-02f, -8.50335211e-02f, -2.39277333e-02f, 1.15410760e-02f, 9.86490995e-02f, 5.22303917e-02f,
  5.42313159e-02f, -3.28383297e-01f, -8.93811136e-02f, 1.08555831e-01f, 2.54537202e-02f, 1.93902832e-02f, -5.34867942e-02f, -7.78497458e-02f, 9.15134512e-03f, 8.90709907e-02f,
  5.44981249e-02f, -1.49318036e-02f, 3.76581363e-02f, 8.51391330e-02f, 1.75756752e-01f, 1.19155003e-02f, -2.32510883e-02f, -1.02677934e-01f, 8.76151677e-03f, 1.44838825e-01f,
  1.24415144e-01f, -5.89229353e-02f, 5.69255054e-02f, -3.25273201e-02f, 4.15826514e-02f, -1.78061813e-01f, -1.63113385e-01f, -6.34926856e-02f, -2.43357077e-01f, -3.52233239e-02f,
  1.29990697e-01f, -1.88819245e-01f, 1.41024496e-02f, 1.32355422e-01f, -4.64086719e-02f, 1.17626272e-01f, -7.17168078e-02f, 1.30944610e-01f, 1.51831150e-01f, 7.90713131e-02f,
  -1.22161722e-03f, 1.96012557e-01f, 1.96716145e-01f, 1.31361872e-01f, 2.14701965e-01f, 1.06198452e-01f, 1.89521208e-01f, 1.36185929e-01f, 2.01990768e-01f, 4.49555106e-02f,
  9.00968611e-02f, -1.17163407e-02f, 9.57669318e-02f, 1.71132460e-01f, -7.53647974e-03f, 1.10760666e-01f, 1.17354788e-01f, -2.53677554e-03f, 5.22575974e-02f, 8.23180601e-02f,
  -3.00349742e-02f, 1.58681899e-01f, 1.62952781e-01f, 5.88799790e-02f, -6.84889331e-02f, -7.70391226e-02f, -4.88253534e-02f, -9.55424607e-02f, 8.36632028e-03f, 4.88239340e-02f,
  -1.32423654e-01f, -1.86902191e-02f, -6.27862886e-02f, -7.49320611e-02f, -5.35310470e-02f, -4.69475575e-02f, 1.14630617e-01f, 1.28277183e-01f, 9.17593390e-02f, 6.42903298e-02f,
  3.71302739e-02f, -2.25577466e-02f, -1.99463978e-01f, -6.85930699e-02f, 1.48899322e-02f, 2.55295169e-02f, 2.60352902e-02f, -2.00432222e-02f, -1.88697204e-02f, 2.84374747e-02f,
  -2.58949772e-02f, -6.02593347e-02f, 6.85805976e-02f, 3.04086953e-02f, 1.07499138e-01f, -2.40541883e-02f, 5.56263439e-02f, 1.68263867e-01f, 8.95975903e-02f, -5.38270436e-02f,
  1.28250957e-01f, 1.37570009e-01f, 5.76155409e-02f, 8.19955617e-02f, 1.14953399e-01f, -1.10603072e-01f, -5.64027876e-02f, 6.37875050e-02f, 2.46753935e-02f, -3.71973440e-02f,
  -4.05667387e-02f, 9.18176621e-02f, -4.21575941e-02f, 8.35757405e-02f, 8.39653835e-02f, 1.65826380e-01f, 1.13139236e-02f, -9.12177116e-02f, -4.28448021e-02f, -1.72085501e-02f,
  -2.26773068e-01f, 4.90800142e-02f, 5.89244664e-02f, 5.51595613e-02f, -6.45455569e-02f, -4.35183235e-02f, -2.03566849e-02f, -3.23920697e-02f, -1.65774778e-01f, -3.66434380e-02f,
  -2.84463055e-02f, -7.23371431e-02f, -4.58878378e-04f, -8.07835683e-02f, -1.02570660e-01f, -6.61128536e-02f, -1.34348169e-01f, -1.24240354e-01f, -1.53191715e-01f, -1.96070641e-01f,
  -9.76433605e-02f, -1.05963700e-01f, -1.24754861e-01f, 1.43235025e-03f, -1.52098909e-01f, -1.51600000e-02f, -9.29064378e-02f, -1.25265270e-01f, -9.42780003e-02f, -1.38109624e-01f,
  -1.95058361e-01f, 1.18391827e-01f, 2.79285517e-02f, -1.91970050e-01f, 2.24876076e-01f, 1.41359687e-01f, 2.31488600e-01f, -1.05605513e-01f, -6.99070394e-02f, 2.98882332e-02f,
  2.27410674e-01f, 1.59758061e-01f, 7.56768584e-02f, 9.46971476e-02f, -9.38616395e-02f, 3.20328847e-02f, 1.61490202e-01f, -7.34685361e-02f, -1.59319863e-01f, -5.57350256e-02f,
  2.19477341e-01f, -1.54309556e-01f, -2.45590478e-01f, -1.65262222e-01f, 3.00653558e-02f, 7.34488061e-03f, -3.99823263e-02f, 4.13404405e-02f, 1.43855751e-01f, 1.32052422e-01f,
  -1.66435629e-01f, -9.83854011e-02f, -1.61359161e-02f, -3.43961865e-02f, 7.85598010e-02f, -1.95291609e-01f, -1.17103765e-02f, -1.69778079e-01f, 9.50483009e-02f, -2.26658005e-02f,
  1.76632300e-01f, -5.13804033e-02f, 1.61568373e-01f, -8.74934776e-04f, -3.63583155e-02f, -1.02935411e-01f, -1.45363256e-01f, -1.50121525e-01f, -1.04534194e-01f, -1.61121652e-01f,
  1.57636985e-01f, -4.00002450e-02f, -6.81666806e-02f, -8.81284103e-02f, -1.01904899e-01f, -5.29297963e-02f, -1.56309724e-01f, -1.22882061e-01f, -1.10842235e-01f, -2.56368995e-01f,
  -1.20661538e-02f, -3.19918729e-02f, 5.37986271e-02f, -1.39060969e-04f, 7.81535283e-02f, 4.75744829e-02f, 7.46995658e-02f, -1.17329014e-02f, 1.46670954e-03f, -2.07090694e-02f,
  1.27952710e-01f, 7.25979656e-02f, -4.22716103e-02f, -8.94153491e-02f, -6.89433441e-02f, 4.48306203e-02f, -9.69007760e-02f, -1.85345575e-01f, -1.32519290e-01f, -6.43431470e-02f,
  -6.54583126e-02f, 2.63277497e-02f, -1.09145874e-02f, 3.05074602e-02f, -9.89602506e-02f, -1.03671499e-01f, -7.23827779e-02f, 5.29739037e-02f, -1.57509461e-01f, 7.09075903e-05f,
  -1.97373584e-01f, 5.41326143e-02f, -1.41685277e-01f, 5.79192489e-03f, 9.44505259e-02f, -7.08139241e-02f, 7.08611235e-02f, 3.62721011e-02f, -6.13228939e-02f, 1.34203255e-01f,
  -1.90137494e-02f, -2.27203313e-02f, -2.32284255e-02f, 5.45937903e-02f, 2.11919267e-02f, -3.30283456e-02f, 1.00605981e-03f, 1.45142674e-01f, -8.82020295e-02f, 5.48494831e-02f,
  -1.11166626e-01f, -2.24069834e-01f, -1.66102469e-01f, 3.86284776e-02f, -3.24681681e-03f, -1.82635620e-01f, -2.01517031e-01f, -1.67546973e-01f, -2.08093449e-01f, -2.48997852e-01f,
  -8.71338323e-02f, 1.77488282e-01f, 2.13597506e-01f, 2.96351135e-01f, 1.64711431e-01f, 2.10556030e-01f, 3.23161960e-01f, 2.79491454e-01f, 2.03254670e-01f, 6.05771057e-02f,
  4.22091112e-02f, 6.63565174e-02f, 1.41464293e-01f, 1.34669900e-01f, 1.19376443e-01f, 2.10903406e-01f, 2.16245160e-01f, 1.18558347e-01f, 1.39014885e-01f, 1.24248959e-01f,
  1.41710371e-01f, 1.24544799e-01f, 4.13903557e-02f, 1.31811783e-01f, 9.09706652e-02f, 4.56242934e-02f, 1.76346257e-01f, 1.98311850e-01f, 1.98027447e-01f, 1.77128494e-01f,
  2.87971109e-01f, 7.81256333e-03f, 1.51756657e-02f, -1.31911010e-01f, -1.20652422e-01f, -2.06658334e-01f, -1.35309845e-02f, -3.86097506e-02f, -5.75923957e-02f, 5.16651534e-02f,
  -1.36872724e-01f, -6.12355210e-02f, -1.41425416e-01f, -1.15323789e-01f, 6.98246956e-02f, -6.68709129e-02f, -1.51138291e-01f, 1.38607875e-01f, 1.75217137e-01f, 8.28608051e-02f,
  -5.25694527e-02f, -1.77791584e-02f, 1.65987760e-01f, 4.62425314e-02f, -1.53132267e-02f, 2.44517438e-03f, -8.36929083e-02f, 3.98529842e-02f, 8.93494338e-02f, -9.40734148e-02f,
  2.49760225e-01f, -5.88001236e-02f, 4.89320047e-02f, -1.45320460e-01f, -1.67293787e-01f, -9.97586027e-02f, -3.26304883e-02f, -7.36395866e-02f, -1.58959255e-01f, -2.92982966e-01f,
  1.39100971e-02f, 1.60887599e-01f, 3.27224247e-02f, 6.89109489e-02f, -1.59382775e-01f, 1.41984634e-02f, -5.24722449e-02f, -9.11848992e-02f, -1.12107687e-01f, 6.00287803e-02f,
  3.07974815e-02f, 1.22950621e-01f, 4.57752459e-02f, 1.27472717e-03f, 1.97159946e-02f, 1.69263855e-01f, -7.43077323e-02f, 2.40984503e-02f, -1.05868571e-01f, 1.06333438e-02f,
  3.74553472e-01f, -7.79002830e-02f, -1.03591666e-01f, -2.21058726e-02f, -5.47695719e-02f, -1.37525856e-01f, -5.03512062e-02f, 4.55395132e-02f, 5.05917408e-02f, 1.55338615e-01f,
  1.11785121e-02f, -1.81870431e-01f, -1.37722313e-01f, -9.29989964e-02f, -1.75337136e-01f, -1.34793818e-01f, -2.15126514e-01f, 5.66230677e-02f, 7.13135973e-02f, 1.22286975e-01f,
  -3.74213560e-03f, 1.02385715e-01f, 1.18517436e-01f, 1.72945391e-03f, -7.52118304e-02f, -7.18217939e-02f, -1.96738634e-02f, -6.05854578e-02f, 4.61817048e-02f, -6.16576038e-02f,
  -4.74495560e-01f, -1.78463105e-02f, -2.47118339e-01f, -2.52035588e-01f, 2.25960150e-01f, 3.73527944e-01f, 3.53999376e-01f, 6.97995722e-02f, -1.11726843e-01f, -3.84261161e-02f,
  1.57643110e-02f, 9.58259031e-02f, -8.71456861e-02f, 1.45081192e-01f, 1.40475467e-01f, 1.73264489e-01f, 1.82538792e-01f, -8.30058232e-02f, 6.22224957e-02f, 2.24310905e-01f,
  2.36972630e-01f, -4.64132801e-02f, -2.65496820e-01f, -1.21041410e-01f, -2.39697173e-02f, -1.66388839e-01f, -2.18354881e-01f, 2.46384274e-02f, 3.33088171e-03f, 9.27951746e-03f,
  -1.42414421e-01f, -2.55713195e-01f, 4.88964468e-02f, -4.19103764e-02f, -1.46880284e-01f, -2.65909210e-02f, -1.34520316e-02f, -1.70292392e-01f, -4.86404598e-02f, -2.15940163e-01f,
  -1.20194413e-01f, 5.44850761e-03f, -7.60451406e-02f, 2.63564158e-02f, 2.03473400e-03f, 5.82879260e-02f, -9.49358121e-02f, -8.62050131e-02f, 2.32462678e-02f, -5.86410463e-02f,
  2.49374285e-01f, 3.20042558e-02f, -1.81952268e-01f, 2.30496898e-01f, 4.91808020e-02f, -4.19990644e-02f, -4.86423075e-02f, -1.19169921e-01f, -3.56845073e-02f, -1.63125873e-01f,
  1.19340882e-01f, -7.98677001e-03f, 4.20532823e-02f, 1.93966422e-02f, 1.58362612e-02f, -1.63094234e-02f, 9.84041244e-02f, 1.41552478e-01f, 7.55523965e-02f, -1.46555647e-01f,
  1.70884356e-02f, 2.90524308e-02f, 1.06011465e-01f, -3.07501648e-02f, 2.09579114e-02f, 2.04875320e-02f, 7.33861700e-02f, 4.36060056e-02f, -5.90460934e-02f, -2.17804275e-02f,
  -1.92129798e-02f, -8.24754238e-02f, -1.85375884e-02f, 5.71011975e-02f, 1.65255815e-01f, -9.77340620e-03f, -1.27518848e-01f, -8.68409127e-02f, -8.44039470e-02f, 5.75185828e-02f,
  -3.54986310e-01f, 2.04076141e-01f, -1.77541316e-01f, 5.19987121e-02f, -6.51243851e-02f, -9.65621993e-02f, -4.93317097e-02f, -1.53870638e-02f, -6.20878264e-02f, -3.84892486e-02f,
  7.65161067e-02f, -2.56596156e-03f, -8.50299597e-02f, 9.40939486e-02f, 1.18440591e-01f, -4.48149629e-02f, 1.31263644e-01f, -7.64252990e-02f, 8.91291052e-02f, -8.63239169e-02f,
  -3.45427692e-02f, 7.25567192e-02f, -1.03424951e-01f, 1.50411408e-02f, 1.29158152e-02f, -8.08064714e-02f, -8.33365396e-02f, -2.04546764e-01f, -1.51899114e-01f, -1.20758384e-01f,
  -2.13277891e-01f, -4.07875538e-01f, 6.43852577e-02f, -3.84894088e-02f, 3.73330005e-02f, -2.64042497e-01f, -4.48999524e-01f, -2.70825267e-01f, -1.64867699e-01f, -1.89770177e-01f,
  -1.36834398e-01f, 9.34691504e-02f, 1.23859316e-01f, 7.68238828e-02f, 9.32626054e-02f, -6.71771690e-02f, 2.30369732e-01f, 3.66952568e-01f, 2.54138827e-01f, 1.52717128e-01f,
  1.50675297e-01f, 1.32728249e-01f, 2.63818204e-01f, 1.70556992e-01f, 2.07846742e-02f, 3.41559872e-02f, 4.48321216e-02f, 4.88314666e-02f, 1.51904412e-02f, 2.45923713e-01f,
  -1.40060723e-01f, -1.46149054e-01f, 6.91204052e-03f, 7.08900243e-02f, 5.54714240e-02f, -2.94535551e-02f, -1.46380901e-01f, -3.33732963e-02f, -2.88248956e-02f, 5.86822536e-03f,
  -1.24766454e-02f, 1.64491832e-02f, -9.81394798e-02f, 5.56472726e-02f, 6.87336177e-02f, 9.70729589e-02f, -1.76922102e-02f, 6.61715046e-02f, 3.74705382e-02f, -8.87478366e-02f,
  1.57324538e-01f, -2.63134651e-02f, -2.18593944e-02f, -1.68301597e-01f, -9.88930613e-02f, 1.79743618e-01f, -8.32675695e-02f, 4.67353985e-02f, -9.35459584e-02f, -2.31389031e-01f,
  1.86231863e-02f, 4.60944511e-02f, 1.11527644e-01f, -1.23437988e-02f, 3.43413278e-02f, -1.83815844e-02f, 5.20718098e-02f, 2.89414190e-02f, 1.08704157e-01f, -2.11286005e-02f,
  6.47994503e-02f, 4.17699665e-02f, -1.72657892e-02f, -4.62535843e-02f, 1.53090507e-01f, 7.92043731e-02f, -3.20557542e-02f, 9.32334661e-02f, 8.28760266e-02f, 8.94345418e-02f,
  1.05992943e-01f, 1.07545434e-02f, 9.60686207e-02f, 9.22585838e-03f, -7.68006220e-02f, 9.97231156e-02f, 3.57793495e-02f, -5.35836369e-02f, -1.17197990e-01f, 2.02184897e-02f,
  -2.77497977e-01f, 8.59804973e-02f, -2.68376693e-02f, 4.89989445e-02f, -4.65524942e-02f, -8.55259076e-02f, 8.40603188e-03f, 3.21534313e-02f, -5.14816381e-02f, -9.00550336e-02f,
  -1.71718210e-01f, -2.61240434e-02f, -1.93129838e-01f, -1.18126478e-02f, 1.28064386e-03f, -4.18977141e-02f, 7.34361485e-02f, 1.33743972e-01f, -1.36926413e-01f, -2.91211549e-02f,
  4.67042327e-02f, -7.13422969e-02f, -9.38491598e-02f, -1.77540034e-01f, -1.51624188e-01f, -9.97746959e-02f, -4.86404561e-02f, -2.05268279e-01f, -5.15248999e-02f, -3.46282303e-01f,
  2.47590795e-01f, -2.21840397e-01f, -3.60404581e-01f, 1.05956234e-02f, -2.66783446e-01f, 1.99756920e-02f, 9.08436775e-02f, -1.12202484e-02f, 9.62773431e-03f, -1.56719938e-01f,
  -5.22144511e-02f, 2.01632064e-02f, -9.20421183e-02f, -7.16684759e-02f, 9.51272920e-02f, -9.10022929e-02f, -1.83760207e-02f, 5.04657887e-02f, 6.84523433e-02f, -4.10641916e-02f,
  1.41713051e-02f, 1.89937115e-01f, 1.74215630e-01f, -2.00747401e-02f, -1.69990808e-01f, -5.29004857e-02f, -1.85072720e-01f, -6.82769492e-02f, -1.95747778e-01f, -1.99779540e-01f,
  -2.20840983e-02f, -4.14041221e-01f, -9.94259268e-02f, 1.05610378e-01f, -3.37446900e-03f, -4.32186807e-03f, -8.07903856e-02f, -3.38747422e-03f, -9.35213119e-02f, -5.66291697e-02f,
  -3.43675703e-01f, -2.15218574e-01f, -1.26532257e-01f, -1.93906724e-01f, -5.82995191e-02f, -6.15472905e-02f, 1.22942450e-02f, -3.64078097e-02f, -1.26168072e-01f, -8.13997611e-02f,
  -5.80822974e-02f, -1.55180067e-01f, -4.70233336e-03f, 1.26208756e-02f, -9.09483582e-02f, -2.93177459e-03f, -1.65134847e-01f, -1.36221096e-01f, -2.00282618e-01f, -8.09367746e-03f,
  4.31826375e-02f, -7.20038489e-02f, 6.25977246e-03f, 4.41802181e-02f, 1.45273134e-02f, 8.09179619e-02f, 1.23703694e-02f, 1.84488371e-01f, -3.75280827e-02f, 1.20641859e-02f,
  -6.73953146e-02f, 6.34035245e-02f, -5.75112663e-02f, -4.94359657e-02f, -3.45183834e-02f, -5.78117557e-02f, -3.76794674e-02f, 1.55547410e-01f, -1.83427520e-02f, 1.38740137e-01f,
  -8.21635779e-03f, -7.66169429e-02f, -2.36676298e-02f, -1.03956692e-01f, -6.72424808e-02f, 1.72529686e-02f, -2.04925034e-02f, 5.24310581e-02f, 4.28370479e-03f, 4.46535572e-02f,
  3.77813429e-01f, -1.51450485e-01f, 2.74281770e-01f, 2.14608833e-01f, 5.85656315e-02f, -4.37296480e-02f, 3.23795751e-02f, 6.44161403e-02f, 3.10976673e-02f, -7.91553259e-02f,
  -2.10802406e-01f, 3.51764448e-02f, -1.75860554e-01f, 1.31104738e-02f, 6.77375719e-02f, -5.99806793e-02f, 6.10774271e-02f, 5.71871027e-02f, -4.51968051e-03f, 8.63802135e-02f,
  1.36180580e-01f, 1.69619113e-01f, 2.88477391e-01f, 1.68967590e-01f, -3.98377366e-02f, 1.91999823e-01f, 1.99146390e-01f, 4.50444072e-02f, 1.31471276e-01f, 4.68553722e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 52)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 52;
const float L0_fan_Bp_bar_data[] = {
  1.16981536e-01f, 6.03508279e-02f, 1.74450278e-01f, 1.04236878e-01f, -3.68956812e-02f, -5.04728816e-02f, 1.84934393e-01f, 4.61246483e-02f, 1.19436480e-01f, -1.18347712e-01f,
  1.02262251e-01f, 3.73346731e-02f, 1.27742007e-01f, 2.35135540e-01f, 3.80767956e-02f, 9.95546281e-02f, 1.54999597e-02f, -3.83173749e-02f, -1.71214305e-02f, 1.05379127e-01f,
  -3.17077860e-02f, 2.00733274e-01f, 1.63193673e-01f, 6.21209778e-02f, -6.90356418e-02f, 1.03317007e-01f, -9.40203294e-02f, 3.55186872e-02f, 1.52684823e-01f, 5.21385893e-02f,
  -1.71683013e-01f, 9.60538834e-02f, -4.31614742e-02f, 1.65179729e-01f, -2.75041070e-03f, 1.07163765e-01f, 5.99805601e-02f, 1.59746900e-01f, 4.37719151e-02f, 1.20337129e-01f,
  5.23848012e-02f, -1.12017475e-01f, 1.52077287e-01f, 2.04708278e-01f, 5.54301888e-02f, 9.36234966e-02f, -4.86661047e-02f, 7.56075308e-02f, 2.34628394e-02f, 4.90884343e-03f,
  6.29189014e-02f, 1.50187463e-01f
};

// L1_fan_Wp (Shape: 6 x 64)
const int L1_fan_Wp_rows = 6;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  5.85099030e-03f, -6.00297702e-03f, -1.23461664e-01f, 3.21387611e-02f, 7.89996088e-02f, -2.80318520e-04f, -4.41759638e-02f, 2.68611368e-02f, 1.40073761e-01f, 5.24044130e-03f,
  -1.54838189e-01f, -2.87709206e-01f, 2.27273554e-01f, 1.66308023e-02f, -2.84452766e-01f, -7.42480308e-02f, 2.15522088e-02f, 1.37088329e-01f, -9.59156081e-02f, -9.55780502e-03f,
  -2.44283199e-01f, -1.75880902e-02f, -1.50028795e-01f, -2.20231026e-01f, 1.59617797e-01f, 2.26685125e-02f, -9.51573253e-02f, 2.32444406e-01f, -7.11159483e-02f, 1.59908850e-02f,
  -1.20387815e-01f, 2.79344805e-03f, -8.06330666e-02f, -2.12404668e-01f, -1.69462398e-01f, -8.56465381e-03f, -2.25486472e-01f, -5.31293787e-02f, -2.72312164e-02f, -1.79002926e-01f,
  1.99860945e-01f, -7.37968907e-02f, -1.30767718e-01f, 1.29386872e-01f, 7.97847733e-02f, 1.90767899e-01f, 1.25359520e-02f, 1.88018791e-02f, 1.99539721e-01f, 7.76762562e-03f,
  -4.96427668e-03f, 7.56039768e-02f, -3.64817642e-02f, -1.04782293e-02f, 2.59444211e-02f, 1.34797618e-01f, -1.61496177e-01f, -4.19200398e-02f, -2.81767827e-02f, -3.69936936e-02f,
  9.71050337e-02f, 3.47450562e-02f, -1.76021159e-02f, -1.08708881e-01f, 4.66693826e-02f, 1.26775935e-01f, -4.78147566e-02f, -4.37752577e-03f, -6.88313134e-03f, -5.50002828e-02f,
  -8.78567174e-02f, 5.19249700e-02f, -6.71492962e-05f, -7.29410127e-02f, 7.60899410e-02f, -3.55305262e-02f, 2.04674453e-01f, 1.69979855e-01f, -4.80311550e-02f, 9.64375213e-02f,
  3.04416288e-02f, 1.90739155e-01f, 9.30407122e-02f, 1.58804283e-01f, -1.00565232e-01f, 2.26942435e-01f, 1.30403284e-02f, -1.27874807e-01f, 1.30954489e-01f, -2.34481379e-01f,
  -1.49407923e-01f, 3.05430535e-02f, -2.84884751e-01f, -1.15029737e-02f, 1.12830043e-01f, -1.15584970e-01f, -7.52336904e-02f, -2.93422818e-01f, -2.01627240e-02f, -6.72277063e-02f,
  -4.71968576e-02f, -1.94450960e-01f, -7.98780769e-02f, 6.36524782e-02f, -1.39810875e-01f, -7.05823526e-02f, 1.34183452e-01f, -1.43699244e-01f, -2.12797076e-01f, -1.21132471e-01f,
  -3.17220539e-01f, 2.80647888e-03f, 8.25688690e-02f, 3.02050747e-02f, -1.16162701e-02f, 2.18280293e-02f, -1.92720756e-01f, 1.02578290e-01f, -2.80780774e-02f, -2.68210135e-02f,
  -1.77006811e-01f, -4.20068912e-02f, -4.22056913e-02f, 1.07445732e-01f, 2.24763677e-01f, -1.10884026e-01f, 1.48749679e-01f, -7.78022632e-02f, 1.00933671e-01f, -2.48799790e-02f,
  -1.70348078e-01f, 3.98856774e-02f, -1.41194239e-01f, 2.89930273e-02f, -1.22180935e-02f, -3.14960293e-02f, -5.94348367e-03f, -8.82603452e-02f, 6.69167787e-02f, -1.22315541e-01f,
  -1.96261957e-01f, 1.32057160e-01f, -8.99891704e-02f, -7.76753426e-02f, -1.30717635e-01f, 2.26465762e-01f, 1.19463161e-01f, 2.28576362e-01f, -9.67064947e-02f, 1.52008101e-01f,
  -1.67123675e-01f, -1.31124794e-01f, 1.89615548e-01f, 4.29956391e-02f, -2.99009651e-01f, 5.69682084e-02f, 2.72173416e-02f, -1.63103461e-01f, 3.58391739e-02f, 9.52277631e-02f,
  -3.54085006e-02f, -1.28193229e-01f, -1.61925599e-01f, 7.32676089e-02f, 1.65960267e-01f, -1.94924831e-01f, -1.48576692e-01f, 8.32077414e-02f, -1.12796627e-01f, -2.53744751e-01f,
  1.43267196e-02f, -1.54928297e-01f, 2.53146235e-02f, -2.75004413e-02f, -1.05723001e-01f, -3.91227379e-02f, 1.16731495e-01f, 5.72307110e-02f, 1.92745663e-02f, 6.78969175e-02f,
  -1.53965831e-01f, 1.80365190e-01f, -1.34784682e-02f, -2.20006585e-01f, -4.71527092e-02f, -7.27004483e-02f, -6.06206469e-02f, 5.83416037e-02f, 7.54721016e-02f, 1.48902252e-01f,
  -1.03770480e-01f, 3.91264148e-02f, -2.18716636e-02f, 5.74856848e-02f, -1.39046013e-01f, -1.11248335e-02f, -1.28237084e-01f, -3.69767137e-02f, 1.00684837e-01f, -1.01728648e-01f,
  -4.98022661e-02f, -1.48816511e-01f, 6.02442399e-02f, 1.63655907e-01f, -2.44380370e-01f, -2.37978008e-02f, -2.52477974e-02f, 4.28223275e-02f, 8.43122751e-02f, -1.36605889e-01f,
  -1.27381131e-01f, 1.29290044e-01f, -1.87048584e-01f, 1.60195798e-01f, 1.74439564e-01f, 1.48807272e-01f, 5.29645681e-02f, -7.55967246e-03f, 1.02132663e-01f, -1.41138986e-01f,
  1.31426290e-01f, -4.80846539e-02f, 6.77170306e-02f, 2.56734043e-02f, 3.26927602e-02f, -1.92392647e-01f, 4.62044813e-02f, 3.67818028e-02f, 2.43171640e-02f, 2.14581229e-02f,
  -1.55790718e-02f, 1.25046954e-01f, -1.91392407e-01f, 1.43189281e-01f, 3.00035086e-02f, -1.37393791e-02f, -4.51427102e-02f, -7.23356158e-02f, 1.73772797e-02f, -2.59309232e-01f,
  -2.71700025e-01f, 1.46186411e-01f, -7.02621927e-03f, 1.62139505e-01f, -7.33845681e-02f, 9.68809426e-03f, 1.26756266e-01f, 2.60643810e-02f, 7.51583371e-03f, -4.77196388e-02f,
  7.91699216e-02f, 1.37232691e-01f, -1.70553833e-01f, 6.62061274e-02f, -2.08098926e-02f, -1.79568544e-01f, -2.88913380e-02f, 1.61226969e-02f, 4.25478630e-02f, 4.71915379e-02f,
  1.56924114e-01f, -4.06885780e-02f, -3.33468132e-02f, 1.10546015e-01f, 3.56879905e-02f, 7.22282380e-02f, -3.01815066e-02f, 5.07000163e-02f, 2.46326074e-01f, -1.93642423e-01f,
  9.55462456e-03f, -1.00195922e-01f, 1.24187842e-01f, 1.54167920e-01f, 1.29471079e-01f, -2.17373490e-01f, -4.88181487e-02f, -1.79992795e-01f, 4.75970423e-03f, -1.69020649e-02f,
  1.22510225e-01f, -2.05883030e-02f, -1.24697976e-01f, 1.62692443e-01f, -2.70873923e-02f, 1.91514701e-01f, 3.22233252e-02f, -8.84524826e-03f, 4.90023242e-03f, -5.97764216e-02f,
  2.61255890e-01f, -6.84307888e-02f, -1.68281257e-01f, 1.74876377e-01f, -4.19294164e-02f, -5.71015999e-02f, 1.62401184e-01f, 1.63032562e-01f, -1.54934496e-01f, -1.99718550e-01f,
  -2.09280197e-03f, 1.07298478e-01f, 7.68422848e-03f, 1.50947005e-01f, 5.58569916e-02f, -3.06733370e-01f, -5.41566387e-02f, -1.17689013e-01f, 1.90697715e-01f, 8.45795870e-02f,
  2.51031965e-01f, 1.48590207e-01f, -9.55099799e-03f, 1.08040743e-01f, 1.50774894e-02f, 1.38031498e-01f, 1.86550573e-01f, 1.28270447e-01f, 2.44010519e-02f, -8.44703615e-02f,
  -1.06652625e-01f, 1.10319786e-01f, 8.03123489e-02f, 4.09735218e-02f, 2.16669366e-02f, 8.80394429e-02f, 9.05346349e-02f, -1.77656204e-01f, 4.11000401e-02f, 1.65878490e-01f,
  -1.67036559e-02f, 8.85653943e-02f, -2.07188040e-01f, 9.19852704e-02f, 1.91849813e-01f, 3.50215621e-02f, -1.75313652e-02f, -6.88126832e-02f, 1.73017651e-01f, -3.33190054e-01f,
  7.55423754e-02f, -2.07786709e-01f, -3.27165052e-02f, 3.99766415e-02f, -2.11583957e-01f, -3.64854448e-02f, 1.70128629e-01f, -1.39080748e-01f, -2.08813414e-01f, -1.49398064e-02f,
  -9.92233232e-02f, -1.49806282e-02f, -5.53900041e-02f, -4.41582641e-03f, 2.10696578e-01f, -2.13101193e-01f, -7.76225999e-02f, 1.52366623e-01f, 1.31979108e-01f, -1.33098468e-01f,
  -1.84590846e-01f, 1.18400650e-02f, 3.68629023e-02f, 6.31347969e-02f, 2.50110198e-02f, -1.55818149e-01f, 5.23965545e-02f, -7.64255151e-02f, -1.60799190e-01f, 1.84633419e-01f,
  8.47745091e-02f, 8.80321413e-02f, 1.61552310e-01f, -2.77841568e-01f, 1.13961451e-01f, -1.68945298e-01f, 1.58946842e-01f, -1.28150314e-01f, -1.62359059e-01f, -1.56824999e-02f,
  1.48415968e-01f, -2.22121343e-01f, -3.08610201e-01f, 3.50654833e-02f
};

// L1_fan_Wp_bar (Shape: 52 x 64)
const int L1_fan_Wp_bar_rows = 52;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  2.72249669e-01f, 6.37143925e-02f, -4.66279685e-02f, -4.06543128e-02f, 5.44216223e-02f, -8.96060765e-02f, 6.14576265e-02f, -6.85228482e-02f, 1.40852302e-01f, -7.88073540e-02f,
  -1.63500950e-01f, 2.06209332e-01f, 1.28928646e-01f, 3.25919624e-04f, 1.86583534e-01f, -2.88603990e-03f, 4.73691970e-02f, -1.59635678e-01f, -2.62546360e-01f, 1.52634978e-01f,
  -2.23871529e-01f, 6.99534714e-02f, 1.36882871e-01f, 6.10955656e-02f, 1.09050758e-01f, 3.13433148e-02f, -1.26381025e-01f, -1.62875146e-01f, 5.73604479e-02f, 1.69350579e-02f,
  1.42203132e-02f, -4.65863347e-02f, 2.82157212e-02f, -3.35546657e-02f, 2.04067543e-01f, -9.51966271e-02f, 1.04886800e-01f, 1.37085736e-01f, 1.76581025e-01f, -7.40314722e-02f,
  1.32756203e-01f, -1.06807783e-01f, -6.82514831e-02f, -2.35734120e-01f, -2.50066936e-01f, 7.45860860e-02f, -9.71927196e-02f, -2.84597158e-01f, -1.85436830e-01f, -3.41308489e-03f,
  -1.77408025e-01f, 4.50540148e-02f, 2.21759491e-02f, 1.30664092e-02f, -8.02081153e-02f, 1.42311737e-01f, -7.74515644e-02f, -1.89300060e-01f, -8.28467235e-02f, 2.05894202e-01f,
  -4.61759493e-02f, 1.44161224e-01f, 1.08540908e-01f, -1.88327789e-01f, 5.74967004e-02f, 1.25528937e-02f, 1.35151163e-01f, 7.70836025e-02f, 1.53145149e-01f, 1.54438347e-01f,
  -1.94012150e-02f, 1.90519363e-01f, -1.21953510e-01f, -1.22154437e-01f, 2.18536649e-02f, -2.38830134e-01f, 1.14600398e-01f, 1.44993320e-01f, 2.53700584e-01f, 8.41771737e-02f,
  -8.04581046e-02f, 3.91557217e-02f, 2.60319382e-01f, -8.47645998e-02f, 3.42809647e-01f, 1.78523079e-01f, -6.96863681e-02f, 3.09526944e-03f, 1.05197296e-01f, -5.56085370e-02f,
  -1.09425806e-01f, -7.47439638e-02f, -1.02519415e-01f, 1.23937309e-01f, 1.01178244e-01f, -2.65506834e-01f, -1.24372344e-03f, 1.83300063e-01f, 8.35755989e-02f, 1.05912425e-01f,
  -1.93883721e-02f, -6.07984960e-02f, -1.55643657e-01f, 4.56204787e-02f, 1.17604174e-02f, 8.90056863e-02f, -1.79519933e-02f, 1.01793543e-01f, -2.50535041e-01f, 6.65526614e-02f,
  -2.10638598e-01f, 9.33554098e-02f, 2.73954153e-01f, -2.08602294e-01f, 2.89774071e-02f, -1.06630936e-01f, -6.76879138e-02f, -5.03252707e-02f, 2.29904875e-02f, 5.75488508e-02f,
  -2.84148902e-01f, -2.02109262e-01f, -6.00276850e-02f, -1.33327827e-01f, -1.02437258e-01f, -2.84164310e-01f, 1.64275020e-01f, 1.73070714e-01f, -9.13983285e-02f, 1.88215837e-01f,
  1.22831222e-02f, -6.10603392e-02f, 1.70999318e-01f, 1.22730464e-01f, 1.89829186e-01f, 1.33214876e-01f, -1.54264241e-01f, -5.23035936e-02f, 9.37994272e-02f, -1.09750750e-02f,
  1.99914351e-03f, 1.81808934e-01f, -1.90003633e-01f, 4.35949147e-01f, 1.69410452e-01f, 1.27589315e-01f, -1.99831009e-01f, 1.09915242e-01f, -8.34617615e-02f, -9.94623527e-02f,
  9.19461846e-02f, 6.45028278e-02f, -2.03949019e-01f, -2.35088855e-01f, 2.90870696e-01f, -1.03786096e-01f, 4.94937859e-02f, 1.48959547e-01f, 9.13954899e-02f, 1.21862662e-03f,
  7.89165720e-02f, -3.80021989e-01f, -7.72281596e-03f, -9.24661532e-02f, -1.13477655e-01f, 1.44651935e-01f, -4.39968780e-02f, 3.48213613e-01f, -1.72025934e-01f, -6.58054575e-02f,
  4.84275408e-02f, -9.48498398e-02f, -2.07780581e-02f, -3.03444207e-01f, -1.18958600e-01f, -4.24184510e-03f, 2.29191355e-04f, 1.47596762e-01f, 1.85650989e-01f, 4.77544554e-02f,
  -7.13337585e-03f, 5.55637255e-02f, 2.09306568e-01f, 7.11801052e-02f, 5.33781685e-02f, 1.67928189e-01f, 2.38701142e-02f, 9.21456590e-02f, -3.78489378e-03f, -3.41083080e-01f,
  1.56707093e-01f, -2.03775913e-01f, -6.42369092e-02f, 1.21905610e-01f, 5.70601597e-03f, 1.50787637e-01f, 7.16313347e-02f, -8.73544589e-02f, 1.02812402e-01f, -2.97078848e-01f,
  1.56799629e-01f, 3.88118774e-02f, -6.93201274e-02f, 2.60827154e-01f, -3.49353522e-01f, 1.52183816e-01f, 7.45807961e-02f, -2.93074280e-01f, 3.25392425e-01f, -2.44925007e-01f,
  7.14427084e-02f, -3.91222179e-01f, -7.18508959e-02f, 4.76590209e-02f, 2.88128078e-01f, 1.74632981e-01f, -1.86849083e-03f, -7.85181299e-02f, 3.81273478e-01f, -2.00309455e-01f,
  1.56498432e-01f, 7.29440153e-02f, -1.30326942e-01f, -2.63802648e-01f, 4.33971472e-02f, 5.94903715e-02f, 6.20509237e-02f, 5.07125482e-02f, 2.85970257e-03f, 1.68963820e-01f,
  2.18087323e-02f, -1.27878904e-01f, -1.49523929e-01f, 1.19809888e-01f, 1.86464146e-01f, 8.63088593e-02f, -7.43988752e-02f, 1.54758781e-01f, 5.27798198e-02f, -1.05289534e-01f,
  -1.24506250e-01f, 4.20638509e-02f, 6.39875010e-02f, 1.17097236e-01f, -2.00874954e-02f, -7.06439018e-02f, 7.69210085e-02f, -2.84684952e-02f, -1.16605684e-01f, -3.06795210e-01f,
  6.87350333e-02f, 2.22178802e-01f, -1.70322612e-01f, 2.71021694e-01f, -3.25039625e-01f, 3.15656886e-02f, 1.22512572e-01f, 1.66095659e-01f, -1.53879508e-01f, -8.64862576e-02f,
  2.39135921e-02f, -1.49843708e-01f, 1.37839317e-01f, -1.11113237e-02f, -2.91035846e-02f, 1.03016041e-01f, -7.51255527e-02f, -1.23697713e-01f, -8.21478814e-02f, -2.49390081e-01f,
  1.10943541e-01f, 1.14613712e-01f, -1.05845742e-01f, 2.72359606e-02f, -2.05878034e-01f, 2.67548740e-01f, -1.83256999e-01f, 1.41506642e-01f, 1.86389416e-01f, -1.97930828e-01f,
  1.43129840e-01f, 2.23176718e-01f, -5.06618693e-02f, -4.94853221e-02f, -2.07717344e-01f, -1.10230058e-01f, 2.00380176e-01f, -1.21961888e-02f, 1.23122402e-01f, 1.25591323e-01f,
  -2.73699135e-01f, 8.66693705e-02f, 2.50885114e-02f, -1.25048324e-01f, -4.13494445e-02f, 1.21908426e-01f, -1.45839691e-01f, -2.33233854e-01f, 1.67180374e-01f, -2.19482616e-01f,
  -8.50811899e-02f, -5.33097029e-01f, -2.99306035e-01f, -5.42925000e-02f, -2.14088693e-01f, 1.74393579e-02f, -9.52097178e-02f, -2.27966029e-02f, 4.36248817e-02f, 1.90979615e-01f,
  -4.51580621e-02f, -1.03116997e-01f, 1.41950428e-01f, -7.29300007e-02f, 1.17739245e-01f, 3.01807523e-01f, 1.57275826e-01f, 1.70859322e-01f, -5.30041307e-02f, -1.77888095e-01f,
  6.55573308e-02f, 1.77183807e-01f, 3.49074677e-02f, 1.30990501e-02f, 8.43799412e-02f, 4.74646278e-02f, -8.30743983e-02f, 1.32478094e-02f, 1.15072116e-01f, -3.75182740e-02f,
  1.12115659e-01f, 6.41427413e-02f, -1.86488301e-01f, -2.44904101e-01f, 1.43246338e-01f, -1.21510498e-01f, 2.22674906e-02f, -1.56749740e-01f, -1.65821001e-01f, 1.88615963e-01f,
  1.02425739e-02f, 2.48889744e-01f, 2.18636710e-02f, -1.39844999e-01f, -6.32652193e-02f, -2.07330696e-02f, -1.98826239e-01f, 1.52991667e-01f, 3.36003035e-01f, -2.72102743e-01f,
  1.36059180e-01f, -7.38305300e-02f, -1.26282468e-01f, 2.21558884e-01f, -3.21664549e-02f, -1.03371188e-01f, 1.90816984e-01f, -7.92221799e-02f, -8.79780054e-02f, 2.17426285e-01f,
  -5.76095656e-02f, -1.11971991e-02f, -2.42724586e-02f, -2.60615408e-01f, -5.73432492e-03f, 5.26601896e-02f, 6.37669116e-02f, -2.15309247e-01f, 8.81502777e-02f, 7.19526708e-02f,
  -1.21292826e-02f, 7.52183869e-02f, 5.42507693e-02f, 7.44001567e-02f, 8.52534547e-02f, 1.72022611e-01f, -8.25625807e-02f, 3.12228687e-02f, 6.01992644e-02f, 1.35121837e-01f,
  -1.83408742e-03f, 3.52619916e-01f, -2.83982120e-02f, 3.61462608e-02f, 1.38625190e-01f, 1.62431449e-01f, 3.31729501e-01f, 2.29368687e-01f, -3.89938094e-02f, 2.18665764e-01f,
  3.52541171e-02f, -6.08053170e-02f, 1.64457247e-01f, -4.03477922e-02f, -9.41770822e-02f, 2.26785868e-01f, 9.35106799e-02f, 1.62547678e-01f, 4.02406275e-01f, -1.50708109e-01f,
  -4.75839153e-02f, -3.53614658e-01f, 1.39018083e-02f, 2.84569687e-03f, 1.05234824e-01f, 2.48219576e-02f, 1.25562429e-01f, -9.16007385e-02f, -6.30670562e-02f, -4.07290757e-02f,
  3.53139490e-02f, -9.87466946e-02f, 1.03087157e-01f, 2.69560274e-02f, 5.08608483e-02f, -2.55848795e-01f, -9.89163369e-02f, 9.89461169e-02f, 2.11863816e-01f, -2.23730300e-02f,
  6.96326271e-02f, 1.33227304e-01f, 2.59366855e-02f, -1.04603112e-01f, -9.22660232e-02f, 1.96598753e-01f, 9.44696646e-03f, 5.63632175e-02f, -7.56955743e-02f, 2.07859248e-01f,
  3.03502027e-02f, -6.36449829e-02f, -2.12406099e-01f, -9.60850269e-02f, 8.31634924e-02f, -1.16236337e-01f, -1.73374526e-02f, -6.16057254e-02f, 4.58672754e-02f, 1.04418479e-01f,
  -7.92602822e-02f, -2.34089792e-01f, -7.44864941e-02f, 2.89112814e-02f, 2.03966666e-02f, 1.86850667e-01f, 1.14462942e-01f, 1.30000129e-01f, 7.66403526e-02f, 7.87053704e-02f,
  9.89556406e-03f, -9.77546815e-03f, 1.10790720e-02f, 2.07482278e-02f, 1.38042241e-01f, 5.58898672e-02f, -2.33742036e-03f, -1.56102076e-01f, -2.70474404e-01f, -1.38589159e-01f,
  3.03430140e-01f, -6.80912659e-02f, -1.88969616e-02f, -2.30658486e-01f, 1.62917405e-01f, 3.58914316e-01f, -4.33750041e-02f, -3.12966555e-02f, -9.40331444e-02f, -2.33861446e-01f,
  1.63060188e-01f, 5.93696907e-02f, 2.36172870e-01f, -3.40293385e-02f, -1.02451675e-01f, 1.37426749e-01f, 8.39061476e-03f, 8.66737142e-02f, -2.24374756e-02f, -5.80025204e-02f,
  2.61753220e-02f, -2.55186200e-01f, -1.36509184e-02f, 2.21945956e-01f, -1.55083358e-01f, 1.10436128e-02f, 1.10230625e-01f, 1.11059509e-01f, 3.23224723e-01f, -2.60713249e-02f,
  -7.69453421e-02f, 1.49860054e-01f, -1.49257511e-01f, 2.56471664e-01f, -1.25991805e-02f, 1.53798580e-01f, 2.16318369e-01f, -5.08146822e-01f, -3.83883179e-03f, -1.28032103e-01f,
  1.03461649e-02f, -5.34995869e-02f, 4.60632797e-03f, 2.86370128e-01f, -2.68783212e-01f, -9.43470746e-03f, 1.66099489e-01f, -3.96822914e-02f, -1.45001411e-01f, 2.13646546e-01f,
  3.01904887e-01f, 2.96022650e-02f, 2.45864138e-01f, 9.12962109e-02f, 1.96200341e-01f, 1.45925343e-01f, 5.06356582e-02f, 2.77414441e-01f, -1.14124700e-01f, 1.14212222e-01f,
  -1.30833328e-01f, -1.01341933e-01f, -1.04566753e-01f, 1.89014658e-01f, -3.49184126e-02f, -2.15798393e-02f, 1.12712368e-01f, -1.44515261e-01f, 8.02053437e-02f, -2.36038193e-01f,
  -1.85365692e-01f, 1.30265146e-01f, -8.80438238e-02f, 8.24056417e-02f, -2.77644247e-02f, -8.77985358e-02f, -1.22170066e-02f, -1.34650826e-01f, -1.04382493e-01f, 1.94662474e-02f,
  -8.28375444e-02f, 1.28746122e-01f, 2.08344627e-02f, 2.00481385e-01f, 8.26843306e-02f, 7.39086345e-02f, 1.45351708e-01f, -3.51901986e-02f, -6.79999217e-03f, -1.31484896e-01f,
  -1.42625719e-01f, 1.98081553e-01f, 9.77635980e-02f, 1.06544413e-01f, 1.10344335e-01f, -3.43968302e-01f, 1.49219453e-01f, -1.04947664e-01f, -1.74337938e-01f, 2.14836761e-01f,
  4.11639921e-03f, 3.73808593e-02f, 3.48011069e-02f, -1.09280132e-01f, 1.14799090e-01f, 1.82879105e-01f, 1.42293975e-01f, 2.06392333e-02f, 1.04056671e-01f, 1.56407267e-01f,
  1.20339677e-01f, -1.20460823e-01f, -2.22351462e-01f, -7.57268593e-02f, 9.41528764e-04f, 8.66637565e-03f, 1.02348268e-01f, 1.11233868e-01f, 2.32068896e-02f, -9.61905420e-02f,
  9.62594748e-02f, 7.95128345e-02f, 6.61150739e-02f, 7.85921235e-03f, -5.68452962e-02f, -7.15767965e-02f, 9.42783430e-02f, -1.23460703e-01f, 2.03230605e-02f, -1.96379423e-03f,
  -1.74580395e-01f, -2.60323435e-01f, 9.02890936e-02f, 1.35474890e-01f, -1.47479966e-01f, 8.98601636e-02f, -2.57103473e-01f, -2.00189784e-01f, -1.03117988e-01f, -1.41448840e-01f,
  2.19217494e-01f, 6.54339045e-02f, 3.49777139e-04f, 2.62403041e-01f, 1.35559738e-01f, 6.64030239e-02f, -6.39167503e-02f, -8.08352232e-02f, -1.94569547e-02f, -5.53894415e-02f,
  -4.28547040e-02f, 1.03856586e-01f, -2.09718198e-01f, 8.74284729e-02f, 6.25170693e-02f, -3.58776599e-02f, 3.19264770e-01f, 1.37309670e-01f, 1.97745394e-02f, 4.53869328e-02f,
  1.92063302e-01f, 1.23538204e-01f, 2.47128949e-01f, 5.61752766e-02f, 2.59830743e-01f, -2.14486405e-01f, 2.03073248e-02f, -9.40635502e-02f, 1.60215423e-01f, 5.49279600e-02f,
  5.67019284e-02f, 3.05268884e-01f, -1.27664551e-01f, 1.16732910e-01f, 2.13687912e-01f, 1.42650962e-01f, 3.89180914e-03f, 2.08167911e-01f, 5.76781444e-02f, -1.11213587e-01f,
  -2.85531525e-02f, 1.19679064e-01f, -2.75777243e-02f, 1.95937395e-01f, 6.39862418e-02f, 1.93854962e-02f, 3.77293490e-02f, 4.02602218e-02f, 7.56613687e-02f, -4.10488434e-02f,
  8.16413090e-02f, 1.36420205e-01f, 8.72954801e-02f, -9.33044478e-02f, 1.64498061e-01f, -3.73663008e-01f, -1.03221625e-01f, 8.06344897e-02f, -2.99060553e-01f, -4.40664310e-03f,
  1.64359920e-02f, -3.27524357e-02f, -3.14113759e-02f, 8.40135887e-02f, -1.68060958e-01f, -1.20472565e-01f, -2.09202871e-01f, -6.56234771e-02f, 9.46402252e-02f, 3.33282948e-02f,
  8.41430277e-02f, -4.05864827e-02f, -1.31187886e-02f, 2.40191549e-01f, 8.34879652e-02f, 3.44074331e-02f, 8.19609500e-03f, 6.38269484e-02f, -6.82713091e-02f, 4.52149883e-02f,
  1.13433518e-01f, 1.47273317e-01f, -4.40554693e-03f, -1.15961164e-01f, 1.17387369e-01f, 1.95335060e-01f, 1.80748746e-01f, -8.22555050e-02f, -1.42015427e-01f, -4.15092021e-01f,
  7.81908184e-02f, 8.47997963e-02f, 5.10176979e-02f, -2.48889755e-02f, 1.18987173e-01f, 1.69408485e-01f, -1.50185913e-01f, -1.10198341e-01f, 2.07680583e-01f, 1.09078050e-01f,
  7.18526095e-02f, 3.34104329e-01f, 2.47626886e-01f, -7.20704272e-02f, 1.05739817e-01f, 1.33491576e-01f, 1.81936055e-01f, 2.64885183e-02f, 7.28331553e-03f, 2.33770977e-03f,
  -6.95101470e-02f, 1.33640785e-02f, -4.02269736e-02f, -8.11766833e-02f, -7.64716417e-02f, 1.24900220e-02f, -1.21883065e-01f, 2.09694013e-01f, -6.36256561e-02f, -1.81297198e-01f,
  3.89228649e-02f, -8.20182562e-02f, 2.46305481e-01f, -1.88724279e-01f, -4.53408472e-02f, -7.60488510e-02f, -1.65779516e-01f, -5.95775805e-02f, 1.69974491e-01f, 1.18745632e-01f,
  5.99703602e-02f, 1.72471032e-01f, -1.82203844e-01f, -9.25219133e-02f, 3.06110922e-02f, 5.35329320e-02f, 2.53554910e-01f, 1.08432800e-01f, -1.61371216e-01f, 1.56607345e-01f,
  -8.23276117e-02f, -3.10249329e-01f, -2.04445913e-01f, -7.19478652e-02f, 1.69204697e-01f, -7.75379986e-02f, -2.70811678e-03f, 1.50013462e-01f, 1.20904252e-01f, 6.68646842e-02f,
  1.36924803e-01f, 1.59551278e-02f, 1.56887487e-01f, 6.09153584e-02f, 1.78928390e-01f, 1.51582405e-01f, -1.52375847e-01f, 4.32395712e-02f, -9.99387056e-02f, -2.67990142e-01f,
  1.53588012e-01f, 1.84373483e-01f, 9.38417017e-03f, -2.55837768e-01f, 3.72357816e-02f, -1.97254658e-01f, -2.85883307e-01f, 2.44090602e-01f, 2.15943515e-01f, 1.61393955e-02f,
  1.10551797e-01f, 7.48905465e-02f, 1.36401296e-01f, -8.59945267e-03f, 9.90590528e-02f, -7.24848509e-02f, -3.57731432e-02f, 1.16112567e-01f, 1.82640806e-01f, 1.79092392e-01f,
  -1.46977261e-01f, -7.65018761e-02f, 1.61624551e-01f, -5.16694859e-02f, 2.00651467e-01f, -2.00180873e-01f, -2.89014697e-01f, -1.39283806e-01f, -8.27392638e-02f, -7.84238353e-02f,
  2.27532506e-01f, 3.03711802e-01f, 2.58790050e-02f, -9.08275619e-02f, 2.23585501e-01f, -1.13859467e-01f, 1.71338439e-01f, -8.79596844e-02f, 9.11324546e-02f, -5.17182164e-02f,
  1.75982580e-01f, 2.91846823e-02f, 2.13150710e-01f, 4.81166467e-02f, -7.15563446e-02f, 1.79973200e-01f, 6.63802773e-02f, 2.08475012e-02f, -2.18048859e-02f, 2.42968842e-01f,
  5.25935218e-02f, -9.45745260e-02f, -4.74069901e-02f, 8.11871812e-02f, 1.53958499e-01f, -8.22092369e-02f, -2.37118289e-01f, -2.34120972e-02f, 9.31128711e-02f, -8.13132059e-03f,
  1.09942041e-01f, 1.64538510e-02f, 2.30773479e-01f, -1.39400482e-01f, 1.64724380e-01f, 8.42591152e-02f, -1.04544260e-01f, 1.40659049e-01f, -1.18363664e-01f, 1.79634735e-01f,
  -1.44749731e-01f, 2.44632624e-02f, 7.99707919e-02f, 6.05772287e-02f, 3.93270701e-02f, 1.98341589e-02f, 3.39161195e-02f, 7.65028875e-03f, 1.32352626e-02f, -7.36923665e-02f,
  -1.04011245e-01f, 3.97682339e-02f, -1.64266322e-02f, 1.95731416e-01f, -1.08802378e-01f, -3.14876214e-02f, -7.32640252e-02f, 6.66063875e-02f, -5.16030304e-02f, -2.14298353e-01f,
  -1.61658734e-01f, 6.45868927e-02f, -4.43034843e-02f, 4.06221785e-02f, 9.50102955e-02f, 5.51508740e-03f, -2.80001640e-01f, 4.26802449e-02f, 2.67119538e-02f, 4.87796813e-02f,
  7.23536983e-02f, 5.96126691e-02f, 6.43839091e-02f, 2.46490806e-01f, 1.33296713e-01f, 1.07042424e-01f, 1.48994252e-01f, 7.12085515e-02f, 2.41490435e-02f, -6.84386194e-02f,
  1.46871418e-01f, 3.38920653e-01f, 3.67662385e-02f, 8.42417330e-02f, 6.18423559e-02f, -3.66209298e-01f, 3.40810627e-01f, -1.75824374e-01f, 1.68974102e-01f, 1.54580012e-01f,
  -4.56661433e-02f, 1.07145965e-01f, 1.28961399e-01f, -1.08176313e-01f, 4.60263751e-02f, 1.42245144e-01f, 1.10243931e-01f, 3.29535753e-02f, 3.22669595e-01f, 2.28709847e-01f,
  -2.70593520e-02f, 9.19558480e-02f, -9.00071040e-02f, -2.09806971e-02f, -1.50006330e-02f, -6.66358843e-02f, -7.83921331e-02f, 9.90262032e-02f, 5.64732514e-02f, -8.46279413e-03f,
  9.27582085e-02f, 2.57462356e-02f, 9.53556597e-03f, 2.51407991e-03f, 2.36566570e-02f, -5.28658479e-02f, 1.82673968e-02f, -2.13590294e-01f, 1.60191450e-02f, 2.25157514e-01f,
  1.08991280e-01f, 2.04642221e-01f, -4.67186756e-02f, -9.33681056e-02f, 1.12678513e-01f, 2.00738043e-01f, 2.09016949e-01f, 2.14993566e-01f, 1.49216011e-01f, 1.42269835e-01f,
  -1.13607466e-01f, 9.24294814e-02f, 6.57724440e-02f, -1.30634949e-01f, 7.20109884e-03f, -2.47920692e-01f, 1.19452722e-01f, -1.28710136e-01f, -2.22465754e-01f, 8.38824585e-02f,
  -3.40656817e-01f, -1.05063684e-01f, 1.30572036e-01f, -1.07085770e-02f, -1.41788587e-01f, 1.80225223e-01f, -1.64340526e-01f, -3.21641594e-01f, 1.88479442e-02f, 5.27152009e-02f,
  9.96326376e-03f, -6.54358342e-02f, -1.69035390e-01f, -2.03444019e-01f, 1.30406454e-01f, 8.29869285e-02f, -4.64364663e-02f, 8.37854743e-02f, -1.73268154e-01f, 3.73158678e-02f,
  -2.21288234e-01f, -1.14422336e-01f, -5.54969013e-02f, -3.86770442e-02f, -1.20243900e-01f, 1.32773817e-01f, 1.82209134e-01f, 1.37883246e-01f, 6.76323995e-02f, -9.81768519e-02f,
  2.25288700e-02f, 5.39541356e-02f, -5.93816601e-02f, 1.07436150e-01f, 1.86931759e-01f, -1.33965956e-02f, -4.45637330e-02f, 3.05427164e-02f, -1.66770816e-01f, 1.12907305e-01f,
  -1.58622034e-03f, -1.26390412e-01f, 2.58899312e-02f, -1.47739425e-01f, -1.92281440e-01f, 2.46688306e-01f, 2.87293009e-02f, -1.59983695e-01f, 5.77424355e-02f, 2.31477857e-01f,
  1.25604384e-02f, 1.00885071e-02f, -5.29455654e-02f, 2.15739924e-02f, 1.23494171e-01f, 5.86708002e-02f, -2.24701539e-02f, -1.91967979e-01f, 2.15746854e-02f, -2.06728205e-01f,
  -7.85377026e-02f, -8.10984746e-02f, 6.29721507e-02f, -3.07959199e-01f, -1.22170664e-01f, 1.53897420e-01f, -2.25234218e-02f, 5.66356741e-02f, -9.57549810e-02f, -1.34157732e-01f,
  -1.50558218e-01f, -1.81968406e-01f, 7.68751949e-02f, 9.43523347e-02f, -2.15552151e-02f, -7.41852149e-02f, -2.06803024e-01f, 6.74818456e-02f, -2.44871415e-02f, 1.71058938e-01f,
  1.29487934e-02f, 1.70523673e-01f, -7.64462575e-02f, 1.63010787e-02f, 6.24712184e-02f, -2.87615985e-01f, -1.86066508e-01f, 9.28856507e-02f, 7.71081373e-02f, 1.33942040e-02f,
  -7.75904432e-02f, -3.11404675e-01f, 5.76578639e-02f, 9.09708813e-02f, 9.73170064e-03f, 1.46947382e-02f, 2.31331646e-01f, 2.86050141e-01f, 1.34321079e-01f, 7.11216778e-02f,
  -3.81673798e-02f, 1.29268289e-01f, -1.95866570e-01f, -1.74147319e-02f, -1.18039288e-01f, -2.72867888e-01f, 2.12119982e-01f, 1.39545342e-02f, -2.77379274e-01f, -9.71788839e-02f,
  1.29898369e-01f, -2.12017626e-01f, 1.38867915e-01f, -4.87235095e-03f, 4.13397476e-02f, -3.86751629e-02f, -9.72048938e-02f, -8.72559771e-02f, 1.73716486e-01f, 2.93557905e-02f,
  2.79697049e-02f, 1.88586563e-01f, 1.04538955e-01f, 2.76482459e-02f, -2.05494061e-01f, 1.60370871e-01f, 1.57412454e-01f, 4.12370078e-02f, -1.32651940e-01f, 1.32076055e-01f,
  1.91330835e-02f, -3.58377062e-02f, 8.02379921e-02f, -1.71327502e-01f, 1.84080362e-01f, 6.43671677e-02f, -1.75505698e-01f, 7.20851794e-02f, 4.70025558e-03f, 2.11907580e-01f,
  -1.02924556e-01f, 1.37778834e-01f, 3.30272824e-01f, -1.76771834e-01f, 3.53660285e-02f, 5.98936900e-03f, -7.54225552e-02f, -5.88349290e-02f, -3.22398692e-02f, 1.97925314e-01f,
  9.41658020e-02f, -7.10859708e-03f, 2.14826003e-01f, -3.17589678e-02f, -6.92794994e-02f, -2.08583936e-01f, 9.69754457e-02f, 2.46514231e-01f, 9.87249911e-02f, 4.33098972e-02f,
  3.33319530e-02f, 1.13600440e-01f, -6.27697632e-02f, 7.68957585e-02f, 3.97021174e-02f, 8.16926435e-02f, -8.46147239e-02f, 2.90934052e-02f, 1.43780380e-01f, 9.92783681e-02f,
  -1.24551192e-01f, -7.31292441e-02f, -9.45325121e-02f, -2.14003876e-01f, 2.71853618e-02f, 1.44910375e-02f, -2.13102430e-01f, -3.48121044e-03f, -2.50156820e-01f, -3.43987271e-02f,
  -1.73708603e-01f, -1.54780865e-01f, 1.45230323e-01f, 2.42170021e-01f, 7.18760341e-02f, 2.20447049e-01f, 1.42522380e-01f, 3.86647768e-02f, -9.30351019e-03f, 1.47203013e-01f,
  1.33131435e-02f, 2.39444594e-03f, -1.42315263e-02f, 1.20583043e-01f, 1.46876857e-01f, 4.96747158e-02f, 6.63567632e-02f, 4.86763939e-02f, 1.74626887e-01f, 4.39255647e-02f,
  -3.42468470e-02f, -9.55536216e-02f, 1.05247021e-01f, -1.37395412e-01f, 2.40624860e-01f, 8.16102251e-02f, 1.60135716e-01f, -1.30043060e-01f, 3.84402759e-02f, -2.43426859e-02f,
  1.55499279e-02f, 2.17917994e-01f, -5.47464453e-02f, 4.17156480e-02f, 2.89881855e-01f, 1.16588995e-01f, 8.64133053e-03f, 4.41998951e-02f, 1.76308099e-02f, 1.72022536e-01f,
  -1.26610145e-01f, 7.76623562e-02f, 9.25274491e-02f, -3.18713747e-02f, 7.71873966e-02f, 1.31270111e-01f, -6.93178400e-02f, 2.15050876e-01f, -1.52490616e-01f, -5.50797731e-02f,
  -1.41835570e-01f, 1.31688356e-01f, -5.49670905e-02f, 1.92780554e-01f, -4.57830392e-02f, 1.10177517e-01f, 2.77483016e-01f, 1.61074534e-01f, 3.19234580e-02f, -2.74351776e-01f,
  -2.71552000e-02f, -2.02200547e-01f, 8.18270966e-02f, -1.95078552e-02f, -1.08519115e-01f, 5.18270880e-02f, -7.97316507e-02f, 7.72004724e-02f, 1.60368860e-01f, -1.10827245e-01f,
  -2.85885662e-01f, 8.25002715e-02f, 1.06256299e-01f, 3.13551687e-02f, 1.15713350e-01f, 1.32853076e-01f, 1.49726152e-01f, 6.12217635e-02f, 1.35298401e-01f, -4.26313393e-02f,
  4.82193679e-02f, 8.17866623e-02f, -6.72250167e-02f, 1.84046552e-01f, -5.09413891e-02f, -2.55118161e-02f, 1.88322842e-01f, -7.55256489e-02f, -2.28747159e-01f, 1.80677012e-01f,
  -1.29528955e-01f, 1.19237140e-01f, -1.07739784e-01f, -2.80292958e-01f, 1.71881586e-01f, 6.69900179e-02f, 6.93158656e-02f, -1.33574545e-01f, 3.13948125e-01f, 8.43584463e-02f,
  -7.73681253e-02f, -9.78887156e-02f, -1.61309883e-01f, -1.37054816e-01f, -2.71256179e-01f, 1.52855575e-01f, 1.07198790e-01f, 1.09788358e-01f, -1.60807505e-01f, 1.57431260e-01f,
  -7.69015355e-03f, -1.70644492e-01f, 3.55000347e-02f, 4.44228575e-02f, 9.41608548e-02f, -8.60337075e-03f, 4.30976674e-02f, -1.47705272e-01f, 8.70636702e-02f, -1.55975118e-01f,
  1.43380202e-02f, -2.01908857e-01f, -4.67426516e-02f, 1.03795920e-02f, -1.97497427e-01f, -3.56010646e-02f, -1.40448436e-01f, 1.48689851e-01f, 1.10295601e-01f, -2.51578689e-02f,
  1.13173887e-01f, 3.41949984e-02f, -4.49638776e-02f, 1.37876958e-01f, 3.91080640e-02f, 7.44579732e-02f, -1.51560977e-01f, 3.92844751e-02f, 6.46403804e-02f, -8.06983113e-02f,
  -2.61906870e-02f, 4.12798636e-02f, 9.55929309e-02f, -9.20224860e-02f, -5.47902547e-02f, -9.01500508e-02f, 1.37189835e-01f, -8.23140889e-02f, 9.33927819e-02f, 3.06247268e-02f,
  2.76032928e-02f, -3.21444497e-02f, 2.89694555e-02f, -2.84108333e-02f, 8.10850710e-02f, 7.53700919e-03f, -6.01966158e-02f, 8.82184580e-02f, -2.66396925e-02f, 5.91489412e-02f,
  -5.53806312e-02f, 6.74036443e-02f, 6.46458007e-03f, -1.60418171e-02f, -4.07436527e-02f, -5.11773713e-02f, 9.69515964e-02f, 2.23376274e-01f, -5.77226765e-02f, 7.42009953e-02f,
  1.73493519e-01f, -6.03811890e-02f, 1.88905045e-01f, 1.20119311e-01f, 1.53436810e-01f, -1.59889221e-01f, 3.81587632e-02f, -2.04517514e-01f, 1.46205783e-01f, -7.00982139e-02f,
  -1.16329372e-01f, 7.10656792e-02f, 1.31859034e-01f, 1.20869011e-01f, -7.73208365e-02f, -3.90168726e-02f, 9.84880105e-02f, -2.76163280e-01f, 1.42539769e-01f, -9.53936204e-03f,
  -2.99852341e-01f, -3.52059714e-02f, 2.74194658e-01f, 2.92891525e-02f, -3.09434623e-01f, -3.10374707e-01f, -7.88470507e-02f, 5.27041666e-02f, 1.61530375e-01f, -1.03204936e-01f,
  3.81247848e-02f, -2.09769532e-01f, -9.21801664e-03f, -3.47838819e-01f, 1.27007246e-01f, -2.45090201e-02f, -1.75367713e-01f, 2.94816524e-01f, 2.17558756e-01f, -3.38739194e-02f,
  2.08766505e-01f, 1.42992675e-01f, -8.43943730e-02f, -1.25084892e-01f, -1.31566077e-01f, 2.33265936e-01f, 1.37500852e-01f, -9.77478847e-02f, -1.88085139e-01f, -1.32640585e-01f,
  8.94568339e-02f, 3.97398956e-02f, 9.98099297e-02f, 5.76247498e-02f, 1.83201641e-01f, 1.14197969e-01f, 6.90174326e-02f, 5.00240773e-02f, -1.01103455e-01f, 1.04184859e-01f,
  -3.84845138e-01f, 1.71260625e-01f, 3.73007767e-02f, -2.85401613e-01f, 8.93738940e-02f, -9.06697009e-03f, 1.25215035e-02f, 8.67416114e-02f, 1.18380494e-01f, -4.80952263e-02f,
  1.07556410e-01f, 3.34044278e-01f, 5.06897606e-02f, 4.91642840e-02f, -1.13877747e-02f, -2.76638448e-01f, 3.85631889e-01f, -6.08108044e-02f, -8.12513977e-02f, 1.76716894e-02f,
  7.12659732e-02f, -9.19723660e-02f, 8.96500200e-02f, 6.67760968e-02f, 1.92409173e-01f, 3.90114710e-02f, -1.31889060e-01f, -1.39033541e-01f, 2.28425577e-01f, -7.53685534e-02f,
  -1.76721156e-01f, 1.26754835e-01f, -1.35665923e-01f, -1.53177693e-01f, -2.17959419e-01f, -1.27417520e-01f, 6.41690195e-02f, 9.27316099e-02f, 3.55453230e-02f, 3.07394534e-01f,
  -1.83220580e-02f, -3.73130262e-01f, -1.87929198e-01f, -2.34049559e-01f, 2.31863931e-01f, 2.57124491e-02f, -8.40504766e-02f, 2.19636276e-01f, -4.85448003e-01f, 1.79333597e-01f,
  -8.80892277e-02f, -1.41530391e-02f, 2.63377905e-01f, -1.31713718e-01f, -6.96942881e-02f, -8.99021700e-02f, 6.75773397e-02f, 2.34521069e-02f, -1.78112820e-01f, 1.35318831e-01f,
  -3.24024618e-01f, -1.04177587e-01f, 2.22333968e-01f, -2.88208336e-01f, -6.55503944e-02f, -1.58804387e-01f, 1.36242449e-01f, 2.54343208e-02f, 1.25540078e-01f, -1.67011581e-02f,
  1.06735177e-01f, 2.34480962e-01f, 1.83119521e-01f, 1.36916801e-01f, 1.50752366e-01f, 7.34918788e-02f, -2.06947420e-02f, -2.05362916e-01f, -1.86545223e-01f, -1.04892552e-01f,
  6.24554406e-04f, 2.78684407e-01f, -2.91425258e-01f, -4.32739370e-02f, 1.63895398e-01f, -2.09105462e-02f, 1.64142698e-02f, 7.59082958e-02f, -2.36282513e-01f, -4.92252596e-02f,
  -1.04807317e-01f, 2.38978444e-03f, 1.39389768e-01f, 1.95410058e-01f, 4.68366235e-01f, 1.53311402e-01f, 1.39464438e-01f, 6.52247518e-02f, -1.53410077e-01f, 1.09806836e-01f,
  7.37813190e-02f, -1.85289234e-01f, -1.58211559e-01f, 1.50536224e-01f, -1.51668623e-01f, -1.12212718e-01f, -2.04021446e-02f, -1.70727819e-02f, 1.02174096e-01f, -1.01100922e-01f,
  -4.37589333e-04f, 4.00327891e-01f, 1.05512552e-01f, 2.03939416e-02f, 1.53626293e-01f, 7.25663528e-02f, 7.96973929e-02f, 2.11917073e-01f, 4.03228253e-02f, 2.08916634e-01f,
  5.21288514e-02f, 1.86217681e-01f, -1.21477425e-01f, 3.42824012e-02f, 8.73379111e-02f, 1.05796121e-01f, -2.66158339e-02f, -1.42808169e-01f, -7.50311762e-02f, -1.01773061e-01f,
  -1.41584039e-01f, 2.56272823e-01f, 1.83222190e-01f, 8.61460119e-02f, -1.71625353e-02f, -5.01672924e-03f, 4.02872786e-02f, -3.91195118e-02f, 2.43303590e-02f, -1.11931235e-01f,
  -4.05040681e-02f, -1.12529308e-01f, -4.28800061e-02f, -2.54748836e-02f, -3.10388878e-02f, 8.02831128e-02f, 3.01407073e-02f, 3.92102338e-02f, -6.83240667e-02f, -2.61765331e-01f,
  -2.17143774e-01f, 2.13108718e-01f, -1.39112502e-01f, 1.57554299e-01f, 2.54528672e-01f, 3.07742715e-01f, -5.72323846e-03f, 1.83145516e-02f, -2.16590390e-01f, -1.83002781e-02f,
  -3.63608152e-02f, 1.02335818e-01f, 2.50695974e-01f, -2.37561911e-02f, -4.61963899e-02f, 8.35710391e-02f, 1.57371670e-01f, 1.62389278e-01f, 1.21953093e-01f, 1.80669338e-01f,
  -4.96587157e-02f, 1.92633554e-01f, 1.03085719e-01f, 4.91204150e-02f, 2.38360763e-01f, -3.07429284e-01f, -1.28060549e-01f, 1.35814652e-01f, -5.40670492e-02f, -1.92730427e-01f,
  -5.78180254e-02f, -1.39699966e-01f, -8.96209329e-02f, 8.25135335e-02f, 1.23995289e-01f, 1.27482355e-01f, 1.08658047e-02f, 3.16346645e-01f, -1.24683857e-01f, -3.16003114e-02f,
  1.01984255e-01f, 2.29288518e-01f, -1.83904305e-01f, 2.19997406e-01f, 1.36344254e-01f, -2.35388324e-01f, -1.25987709e-01f, 1.71298668e-01f, 1.66687705e-02f, 1.55449864e-02f,
  -1.10469833e-01f, -1.14456117e-02f, 1.05833486e-01f, -6.12185225e-02f, 6.80090040e-02f, 9.90106463e-02f, -4.99735661e-02f, 1.19551569e-02f, -3.34923834e-01f, 2.61706114e-01f,
  8.77024084e-02f, -3.47477883e-01f, 1.01710051e-01f, -5.57995439e-02f, -9.50758010e-02f, -3.15755635e-01f, 1.05162308e-01f, -1.27207078e-02f, 1.72240376e-01f, 1.03651151e-01f,
  9.18076187e-02f, 3.46070349e-01f, 1.46928683e-01f, 3.06231529e-01f, 5.95814474e-02f, -2.70625185e-02f, -2.65066437e-02f, -1.93108678e-01f, 7.41478577e-02f, 2.63634801e-01f,
  -5.76151535e-02f, 1.10137083e-01f, 2.21476570e-01f, 2.29662269e-01f, 2.01344982e-01f, -8.52541327e-02f, -1.40780628e-01f, 4.28470690e-03f, 1.28694670e-02f, 9.36683789e-02f,
  -3.85215022e-02f, -9.84101817e-02f, -8.98175910e-02f, 5.01471646e-02f, -2.19897032e-01f, 5.35156764e-02f, 3.47897857e-02f, 9.61551443e-02f, 5.10754138e-02f, -8.15516710e-02f,
  -1.07410252e-01f, 4.55271006e-02f, 8.67923722e-03f, -2.01237664e-01f, -8.89377147e-02f, 4.56056297e-01f, 2.41863072e-01f, 2.45173708e-01f, -3.27213220e-02f, -2.59091645e-01f,
  8.02994072e-02f, 4.19673175e-02f, 1.80654861e-02f, 5.24586029e-02f, 9.92649645e-02f, 4.67520542e-02f, 3.03293347e-01f, -1.46128729e-01f, -6.02247678e-02f, -1.27348900e-01f,
  -3.11864838e-02f, -4.68032919e-02f, 1.58067510e-01f, -1.07271619e-01f, 9.51626152e-02f, 1.92245454e-01f, 2.19769523e-01f, 2.59718555e-03f, -2.24535763e-01f, 6.01422265e-02f,
  -2.50991195e-01f, -3.21086980e-02f, 1.30880237e-01f, 2.07603574e-02f, 9.98543128e-02f, 3.97423580e-02f, 2.61681288e-01f, -1.12313323e-01f, -2.02709690e-01f, -8.07197988e-02f,
  -1.04027279e-01f, -4.98762801e-02f, 1.76930036e-02f, -3.57757568e-01f, -1.40013099e-01f, 1.21876458e-02f, -2.15077922e-01f, -6.74601784e-03f, -2.31389597e-01f, -1.99794158e-01f,
  -2.26588756e-01f, -2.92320549e-01f, 1.34372145e-01f, 2.24331096e-01f, -1.04554072e-01f, -4.22573954e-01f, -2.34459251e-01f, 1.25641227e-01f, -2.24126503e-01f, 3.94957155e-01f,
  3.31965722e-02f, 5.81585504e-02f, -7.69392103e-02f, -3.06967981e-02f, -2.30552718e-01f, -1.01325452e-01f, -9.83477160e-02f, -2.97644854e-01f, 3.11165508e-02f, 1.39133837e-02f,
  1.55127436e-01f, 3.96357775e-02f, -2.23791912e-01f, -2.71177441e-01f, 1.64560564e-02f, 1.39512926e-01f, 6.43054694e-02f, 9.61624980e-02f, 1.16738461e-01f, 2.91739047e-01f,
  -1.94462001e-01f, 1.44062817e-01f, -3.08830291e-01f, -1.42986804e-01f, 1.07224910e-02f, -1.28318250e-01f, 5.07563911e-02f, 1.18332133e-01f, -2.31853142e-01f, 5.29574044e-03f,
  -3.43388990e-02f, -8.27034488e-02f, -1.53155506e-01f, -2.48702262e-02f, -2.78058589e-01f, -1.61901623e-01f, -1.45528407e-03f, -1.56178534e-01f, 2.16869131e-01f, 1.41026691e-01f,
  -4.75247949e-02f, 2.51346886e-01f, -3.11894529e-02f, 2.05233291e-01f, 2.10037068e-01f, 3.40020955e-01f, 8.12010467e-03f, -1.98410153e-01f, -1.12610132e-01f, 2.21994426e-02f,
  5.75863533e-02f, -9.91169959e-02f, 1.47651210e-01f, 1.99159011e-01f, 3.48863974e-02f, 9.59353149e-02f, -1.78041041e-01f, -2.16886759e-01f, 3.50869149e-01f, -9.81173068e-02f,
  -7.86689818e-02f, 1.63732171e-01f, 1.46424755e-01f, 2.97718555e-01f, 8.94679278e-02f, -9.72635299e-02f, 1.14905201e-02f, 2.20570378e-02f, 4.71075140e-02f, 6.01439513e-02f,
  1.52563930e-01f, 1.83983698e-01f, -7.73843452e-02f, 2.74724085e-02f, -1.33841470e-01f, -1.88339472e-01f, -1.13468520e-01f, 1.43674240e-01f, 2.88650811e-01f, -1.13915829e-02f,
  -2.99991127e-02f, 1.09540433e-01f, 1.68423370e-01f, 1.02470137e-01f, 8.31090808e-02f, 2.43948638e-01f, 2.61398256e-01f, -2.69628584e-01f, -3.52267250e-02f, -5.41349113e-01f,
  5.10060370e-01f, -2.22898990e-01f, -2.60104954e-01f, 4.19391274e-01f, -4.02993746e-02f, 1.10535054e-02f, 9.73716937e-03f, 2.34201312e-01f, 9.44353044e-02f, 1.39034986e-01f,
  -2.85035511e-03f, -4.83193457e-01f, 4.90510389e-02f, -2.07653746e-01f, -4.57980968e-02f, -3.29056025e-01f, -2.83036321e-01f, 4.25431412e-03f, 8.40799138e-02f, -1.64153442e-01f,
  -2.55353242e-01f, -1.66696712e-01f, -1.91505060e-01f, 1.86412223e-02f, 4.61133313e-04f, 1.64626371e-02f, -6.97259083e-02f, -4.98450398e-02f, -2.42445812e-01f, -2.20587239e-01f,
  -3.39124799e-02f, 3.22896004e-01f, -1.30235374e-01f, -1.82880163e-01f, -1.90969676e-01f, 1.42106460e-02f, -1.60495520e-01f, 5.68181686e-02f, 3.64156999e-02f, 2.11178437e-01f,
  -1.25198647e-01f, 3.42284404e-02f, -2.19988510e-01f, 1.59981757e-01f, -1.83965951e-01f, -9.01301429e-02f, 2.58568712e-02f, -4.87819165e-02f, 3.34840342e-02f, -1.46310151e-01f,
  3.22525263e-01f, -7.06861690e-02f, 1.42247722e-01f, 5.21297287e-03f, 1.94645196e-01f, -3.62262465e-02f, 4.36920971e-02f, 2.82003898e-02f, 1.49733290e-01f, -1.39553398e-01f,
  8.77382383e-02f, -1.32961586e-01f, -1.67464107e-01f, -5.55361696e-02f, 1.70134440e-01f, 5.39672524e-02f, -2.47278452e-01f, 1.18097119e-01f, 2.41648592e-02f, -3.28500956e-01f,
  -2.19210967e-01f, 2.25914240e-01f, -2.28603855e-01f, 6.76023364e-02f, 7.19740018e-02f, 1.89253613e-01f, -1.97872400e-01f, -6.09217137e-02f, -2.17180908e-01f, 2.44547334e-03f,
  8.02981555e-02f, -1.10733798e-02f, 8.63395035e-02f, -8.24394524e-02f, -2.06070486e-02f, -2.03041822e-01f, -8.35860521e-02f, 1.65669784e-01f, 9.96085405e-02f, 2.38770813e-01f,
  9.90382582e-02f, 1.11538507e-01f, 1.92747518e-01f, 6.18505925e-02f, -3.53737213e-02f, -1.05784208e-01f, -5.79829887e-02f, 1.59202605e-01f, 7.14244694e-02f, -8.08659568e-02f,
  -3.90773900e-02f, -2.47466341e-01f, 1.02066331e-01f, 4.45004255e-02f, 1.42971769e-01f, 1.03738375e-01f, 1.16153039e-01f, 2.41540566e-01f, -2.14656055e-01f, -3.72902974e-02f,
  -2.15234943e-02f, 2.18212172e-01f, -2.38695994e-01f, 1.98768780e-01f, 3.83561224e-01f, -1.28486127e-01f, 2.01603159e-01f, 1.69627458e-01f, 1.98608145e-01f, 4.95787784e-02f,
  1.44587725e-01f, 2.58115046e-02f, 3.00064944e-02f, 1.19388290e-01f, 2.20056519e-01f, 5.26909716e-02f, -7.95581564e-02f, -2.05755547e-01f, 3.89265418e-01f, -7.44351447e-02f,
  2.04050660e-01f, 1.00969777e-01f, -2.38504913e-02f, -3.56414735e-01f, 1.06063962e-01f, 7.74740577e-02f, 3.20767909e-01f, 1.36625990e-01f, -3.12582292e-02f, -2.08143946e-02f,
  -3.59049849e-02f, 4.04331647e-03f, -1.35828555e-01f, -1.50012895e-01f, -2.16083646e-01f, 9.87221003e-02f, -1.90638155e-01f, -1.78059667e-01f, -1.41598821e-01f, 1.71448246e-01f,
  1.08379483e-01f, 8.22500139e-02f, -1.26940027e-01f, 1.03928201e-01f, -3.09893563e-02f, -2.29329646e-01f, -2.38189876e-01f, 4.13216390e-02f, -1.18214212e-01f, 2.40511462e-01f,
  -6.89030066e-02f, 1.51594803e-01f, -5.71177006e-02f, 3.72900143e-02f, 5.93246035e-02f, 1.14088841e-01f, -6.10314719e-02f, -4.60838340e-02f, 1.58501029e-01f, -9.46605504e-02f,
  -2.62322519e-02f, -8.29138532e-02f, -1.30504921e-01f, -2.39817426e-01f, -6.25244230e-02f, -2.70948648e-01f, -8.14119130e-02f, -3.47192556e-01f, 2.66622230e-02f, 1.60810962e-01f,
  -5.03669307e-02f, 5.74657368e-03f, 8.38262737e-02f, -3.61533388e-02f, 4.24778312e-02f, 1.38179109e-01f, 2.14813761e-02f, 3.55770104e-02f, -2.54145235e-01f, 5.60906231e-02f,
  1.10735841e-01f, -1.56907335e-01f, -1.81239128e-01f, 3.42718773e-02f, -2.37597927e-01f, 1.74345478e-01f, 3.03137600e-02f, 8.72786064e-03f, -2.42496684e-01f, 2.27214515e-01f,
  8.97985697e-02f, 2.29758307e-01f, -5.09545282e-02f, 1.26301557e-01f, -1.86268702e-01f, 1.72289997e-01f, -1.46114618e-01f, -1.23853512e-01f, 2.89573576e-02f, -8.32761526e-02f,
  1.56288281e-01f, 2.35954106e-01f, 8.16136897e-02f, 1.60165191e-01f, -2.30858207e-01f, 2.67351549e-02f, 1.79006830e-01f, -1.22731946e-01f, -7.13797212e-02f, 1.28363192e-01f,
  -2.64089704e-01f, -1.53793246e-01f, 1.34946316e-01f, -3.83154064e-01f, 3.75706563e-03f, -4.38319057e-01f, -5.33822365e-02f, -8.85907710e-02f, 2.16760356e-02f, -1.11026771e-01f,
  1.29420847e-01f, 2.11989842e-02f, -2.11768262e-02f, 1.49659127e-01f, 1.08896852e-01f, -8.77770316e-03f, 1.05739497e-01f, 1.18616804e-01f, -5.17885610e-02f, 2.40045622e-01f,
  -2.36318022e-01f, 1.48087740e-01f, 2.04338595e-01f, -4.25718166e-02f, -1.41475305e-01f, -7.59729892e-02f, -1.76307634e-01f, 6.87442254e-03f, -2.98541915e-02f, -2.18858826e-03f,
  -1.22581959e-01f, -2.92573664e-02f, -1.20935519e-03f, -8.58814735e-03f, 7.86402375e-02f, -3.33332777e-01f, 1.48898929e-01f, -6.58130869e-02f, -3.94112729e-02f, -1.32683739e-01f,
  -9.63920206e-02f, 1.83712393e-01f, -2.23413512e-01f, 1.99521646e-01f, 2.72407122e-02f, -1.43337533e-01f, -1.65425450e-01f, -4.47949916e-02f, 4.88519296e-02f, -2.89883792e-01f,
  -4.18044291e-02f, 5.43315411e-02f, 1.54926404e-01f, -1.84108783e-02f, -3.64880562e-02f, -8.73224158e-03f, -2.50172198e-01f, -3.48807186e-01f, -1.29707873e-01f, -1.29203096e-01f,
  -1.26908988e-01f, -1.12771034e-01f, -1.37670403e-02f, -1.27243608e-01f, 1.34027764e-01f, 1.25008160e-02f, -1.51513949e-01f, -4.40228470e-02f, 3.21131349e-02f, 2.54767358e-01f,
  4.39988188e-02f, -2.66203121e-03f, 4.06835556e-01f, -1.51093110e-01f, -3.54543515e-02f, 3.39098945e-02f, 1.83117062e-01f, -4.02474292e-02f, 5.39519936e-02f, 2.83964217e-01f,
  -1.40125066e-01f, 8.48023072e-02f, -2.40752190e-01f, -1.86605658e-02f, -3.72703344e-01f, 6.66650012e-02f, 2.18098640e-01f, 3.35470401e-02f, 8.17130804e-02f, 5.38607314e-02f,
  9.54713076e-02f, 2.67452925e-01f, 1.36409491e-01f, 1.51253209e-01f, -1.53409034e-01f, 1.42006978e-01f, -6.40736660e-03f, -1.49673074e-01f, -5.72934896e-02f, -1.61601305e-01f,
  5.46474233e-02f, 1.54946342e-01f, -6.84994832e-02f, 1.64965764e-01f, -9.77690816e-02f, -4.03456762e-02f, 2.42499113e-01f, -1.94526657e-01f, 2.10731626e-01f, -7.91838542e-02f,
  -1.44687086e-01f, 4.81825992e-02f, -1.62911881e-02f, 9.87985730e-02f, 8.62348527e-02f, 8.95853266e-02f, -1.73687965e-01f, -1.63156331e-01f, -9.86045823e-02f, -1.80196762e-02f,
  8.51435587e-02f, 2.33188257e-01f, 1.19318821e-01f, 1.28910199e-01f, -2.77641248e-02f, -2.19008282e-01f, 1.09909126e-03f, -1.11115329e-01f, -8.80899131e-02f, -8.75271335e-02f,
  -9.20368508e-02f, 4.24241275e-01f, 1.68834269e-01f, 1.45863131e-01f, -1.20444141e-01f, -2.63036005e-02f, -2.31567118e-02f, 2.04545766e-01f, 1.07453778e-01f, 3.35816555e-02f,
  -1.89901933e-01f, -1.18304700e-01f, -7.12188855e-02f, -4.53429341e-01f, 3.52965407e-02f, 1.28053337e-01f, 8.68837461e-02f, -2.47527808e-01f, -3.46542075e-02f, -2.89057761e-01f,
  -1.78401873e-01f, 3.05307984e-01f, -4.21435609e-02f, 9.28527787e-02f, 1.59950078e-01f, 1.53419077e-01f, 7.49976039e-02f, 8.37068353e-03f, 6.86189458e-02f, -8.89539272e-02f,
  1.79265454e-01f, -1.44543394e-01f, 1.24456733e-01f, 1.98909611e-01f, -1.21172585e-01f, -2.17451155e-02f, 1.35886252e-01f, -2.90473402e-01f, 1.08232513e-01f, -9.29609984e-02f,
  -2.06485853e-01f, -7.07757697e-02f, -7.90627077e-02f, -3.81390005e-02f, 1.26930147e-01f, -1.05744086e-01f, -5.35257496e-02f, 2.16157928e-01f, 3.71664874e-02f, -3.53300601e-01f,
  2.28953496e-01f, -4.01419442e-04f, 1.30720615e-01f, -1.09373266e-02f, 3.64383832e-02f, 1.49588883e-01f, 2.32645929e-01f, -8.70281532e-02f, 1.45154685e-01f, 1.38096690e-01f,
  8.23917836e-02f, 5.09424508e-02f, -2.18092605e-01f, 1.50756200e-03f, 5.62047698e-02f, -1.92375496e-01f, -2.84275055e-01f, 7.96030387e-02f, -6.34126067e-02f, -5.53588420e-02f,
  -2.98942596e-01f, -1.81840807e-01f, -6.70163780e-02f, -4.96438332e-02f, 5.30125089e-02f, -2.83017429e-03f, 8.16954474e-04f, -8.78784806e-02f, 5.48269004e-02f, -1.77767113e-01f,
  -1.77390873e-02f, 1.76071137e-01f, 9.23534576e-03f, 3.22410911e-01f, 4.45051640e-02f, -1.28159747e-01f, -8.06711093e-02f, -1.38612360e-01f, 1.38469664e-02f, 1.40263317e-02f,
  -1.48559362e-02f, 1.16071245e-03f, -1.22588366e-01f, 4.26053777e-02f, -1.94309130e-01f, -5.66130131e-02f, -5.55998795e-02f, 6.49035498e-02f, 8.76374692e-02f, -1.50888264e-01f,
  -1.22041203e-01f, -1.04911424e-01f, 8.59118327e-02f, 2.30540857e-01f, 1.33944765e-01f, -6.18683249e-02f, -1.21225014e-01f, -7.34845027e-02f, -2.78266162e-01f, -2.37243414e-01f,
  1.45323023e-01f, 9.24269184e-02f, 1.47208616e-01f, 1.92091808e-01f, 6.19564094e-02f, 2.45731343e-02f, 7.12533742e-02f, 2.12729856e-01f, 2.20605865e-01f, -1.10414684e-01f,
  6.42359182e-02f, 2.23857656e-01f, -1.23899132e-01f, 2.37428434e-02f, -2.77307965e-02f, 2.42536124e-02f, 2.40573063e-01f, 2.08830070e-02f, -8.13978091e-02f, -1.67331900e-02f,
  1.34479001e-01f, -1.78334936e-02f, 3.84717062e-02f, 1.16781659e-01f, 1.55746922e-01f, -3.40098470e-01f, -3.72556783e-02f, -9.65165496e-02f, 1.43348113e-01f, 1.83327571e-01f,
  -2.68694311e-02f, 4.93772961e-02f, 6.23165593e-02f, 3.99503335e-02f, 2.39067078e-02f, -9.03177783e-02f, -1.00320689e-01f, -9.46410447e-02f, -3.42116319e-02f, 1.06944486e-01f,
  -2.56646890e-02f, 9.52797569e-03f, 4.77547683e-02f, 1.38817504e-01f, -1.72995552e-02f, 1.21095873e-01f, -5.31149283e-02f, 1.59729987e-01f, -1.16489694e-01f, -1.65698081e-01f,
  1.28340209e-02f, 3.18609662e-02f, -2.27770835e-01f, 1.65682826e-02f, -4.25923228e-01f, -3.70934486e-01f, -1.84989143e-02f, -5.33704683e-02f, 1.09110191e-01f, -2.38134861e-01f,
  -2.42946409e-02f, 5.43557778e-02f, -2.37070829e-01f, -1.80412173e-01f, 1.31724536e-01f, 1.58885628e-01f, 9.84398797e-02f, 1.65692061e-01f, 3.68157141e-02f, 5.61345257e-02f,
  -7.46146310e-03f, 2.51798421e-01f, 2.35173509e-01f, 1.77040063e-02f, -5.71992695e-02f, 1.90525681e-01f, 4.96983305e-02f, -8.85550305e-02f, 5.70610119e-03f, -3.73836048e-02f,
  1.27128825e-01f, -1.03854604e-01f, 6.30919486e-02f, -1.07813947e-01f, 8.71063769e-02f, -1.82877388e-02f, 1.31318390e-01f, 2.09069654e-01f, 2.37118661e-01f, -2.58314889e-02f,
  1.43702598e-02f, -6.38711452e-02f, -2.64695764e-01f, 7.01036453e-02f, -2.06145714e-03f, -1.65424734e-01f, 2.02179641e-01f, 1.69550300e-01f, 1.61397472e-01f, -1.03134671e-02f,
  -1.30793124e-01f, -1.04173236e-01f, -1.40298814e-01f, 8.23284611e-02f, 2.54177123e-01f, 8.44478086e-02f, -1.28851105e-02f, -1.72788873e-02f, 1.05564602e-01f, 1.30653292e-01f,
  -7.28913918e-02f, 2.62906402e-02f, -9.11644846e-02f, -1.56695604e-01f, 7.92200118e-02f, -1.48525000e-01f, 3.90527956e-03f, -1.13083556e-01f, -5.42170741e-02f, -1.50692984e-01f,
  -3.81506346e-02f, 8.03371593e-02f, 9.91003662e-02f, 1.87496886e-01f, -4.88009341e-02f, 1.45084811e-02f, -1.45280302e-01f, -3.11925828e-01f, 6.43176734e-02f, 1.96179315e-01f,
  -2.16415048e-01f, 1.57604720e-02f, 5.39335869e-02f, -9.93311033e-03f, 1.67479113e-01f, 2.21690819e-01f, 8.14956278e-02f, -9.96598005e-02f, -1.40679315e-01f, 1.43524185e-01f,
  -1.63132176e-02f, -1.65321007e-01f, 6.34511486e-02f, 8.49913282e-04f, 1.77766994e-01f, -1.37914747e-01f, -1.53168738e-02f, 4.02076431e-02f, 1.09611139e-01f, 5.25224693e-02f,
  -1.05655519e-02f, 6.92392588e-02f, 3.33039969e-01f, 1.18764110e-01f, 1.03469096e-01f, 1.03725284e-01f, -8.52654725e-02f, 8.56809467e-02f, -6.32292479e-02f, 2.40878016e-02f,
  -3.78048904e-02f, 4.73615294e-03f, -2.11730376e-02f, 3.47421467e-02f, -3.54554653e-02f, 5.31361513e-02f, 5.01485839e-02f, 2.41231710e-01f, 1.49152145e-01f, 2.40345508e-01f,
  7.13843256e-02f, 4.88557927e-02f, 7.79721811e-02f, 2.48784968e-03f, 1.37304410e-01f, -2.33377386e-02f, 1.81723475e-01f, 4.15960923e-02f, -4.48802076e-02f, -1.56063616e-01f,
  3.08858216e-01f, 1.74039796e-01f, -3.92525047e-02f, 1.70363531e-01f, -2.68685445e-03f, -2.83098429e-01f, 1.35619625e-01f, -1.13520334e-02f, -5.68532944e-02f, 1.31810114e-01f,
  3.32526118e-02f, -5.64093925e-02f, -8.44008699e-02f, -1.59473345e-01f, 2.25629181e-01f, -1.78103834e-01f, -9.69069302e-02f, 2.20830500e-01f, -2.60063205e-02f, -2.46443540e-01f,
  -1.47589400e-01f, -2.22652435e-01f, -5.88457920e-02f, -2.81822812e-02f, -1.19741410e-01f, 6.00039549e-02f, 1.20692603e-01f, -3.13012190e-02f, 1.39199784e-02f, 3.07196099e-02f,
  -3.88413891e-02f, 3.24139506e-01f, 2.50170827e-02f, -4.88582961e-02f, -1.84906006e-01f, -8.31054747e-02f, 2.07726918e-02f, 1.22254916e-01f, 9.44523439e-02f, 1.25219584e-01f,
  -6.41784295e-02f, -4.47388478e-02f, -2.21414164e-01f, -5.56651056e-02f, -9.50499773e-02f, -1.28316715e-01f, 1.31354704e-01f, -1.05985701e-01f, -7.11911246e-02f, -1.79299712e-01f,
  1.91755489e-01f, 2.40499265e-02f, 2.52416670e-01f, 7.13267028e-02f, 2.25182757e-01f, 1.32853672e-01f, 1.27833769e-01f, 2.89561659e-01f, -4.87731583e-02f, 7.61717260e-02f,
  -1.84739456e-02f, 8.70148167e-02f, 1.73132792e-02f, 2.32888773e-01f, 2.92805526e-02f, 1.68626741e-01f, 4.52624783e-02f, 8.48462582e-02f, -5.48044480e-02f, -2.99499840e-01f,
  5.19147441e-02f, -6.63742945e-02f, 2.11108010e-02f, -9.57538337e-02f, -9.91775990e-02f, 1.29616514e-01f, -1.09432325e-01f, 9.44178849e-02f, -1.43398017e-01f, -4.40080836e-02f,
  -1.12642661e-01f, 1.96399599e-01f, 3.23856287e-02f, 2.79145926e-01f, 1.63092181e-01f, 1.78712070e-01f, 2.43512671e-02f, -1.11133203e-01f, -1.66554488e-02f, -7.95967877e-02f,
  5.16741946e-02f, 1.84263960e-01f, -1.26494408e-01f, -8.02595019e-02f, -8.50645304e-02f, -1.15889527e-01f, 4.39312793e-02f, -4.89643402e-02f, -2.74564058e-01f, 1.57864898e-01f,
  2.63675265e-02f, -1.62481293e-02f, 3.91761921e-02f, -1.93182454e-01f, -7.78180808e-02f, -9.85608101e-02f, 4.22282629e-02f, -1.29818218e-02f, 1.68543994e-01f, 4.96374965e-02f,
  -4.39126156e-02f, -2.16426387e-01f, -5.57934493e-02f, -1.91698983e-01f, 1.37046933e-01f, 4.99354638e-02f, 7.20630139e-02f, -8.13049823e-02f, -1.98164895e-01f, 1.11487340e-02f,
  -1.92954089e-04f, -9.76207927e-02f, -1.48736611e-01f, -1.26690805e-01f, 1.28991932e-01f, 3.85110490e-02f, -4.04109596e-04f, 7.44682997e-02f, -6.10508695e-02f, -1.13434076e-01f,
  2.37606257e-01f, -3.72508347e-01f, 1.96147040e-02f, 1.71096399e-02f, -8.09622258e-02f, -1.03077181e-01f, -1.22310333e-01f, 3.06838304e-02f, 1.31925479e-01f, -1.93514347e-01f,
  1.49767175e-01f, 1.90640211e-01f, -1.75482348e-01f, 2.42063910e-01f, 4.20920029e-02f, -2.67831329e-02f, 1.04420318e-03f, 2.31707413e-02f, 8.09657350e-02f, 3.84406894e-02f,
  7.79894143e-02f, 8.89113247e-02f, 4.24346738e-02f, -1.09171420e-02f, -2.96416250e-03f, 3.60943750e-02f, -1.04974851e-01f, 1.03526451e-02f, 2.02825200e-02f, 7.32009411e-02f,
  -1.01862401e-01f, -1.30774572e-01f, -2.13805407e-01f, 3.48275267e-02f, -9.35264751e-02f, -1.33906886e-01f, -1.52654052e-01f, -1.28658578e-01f, 2.76934970e-02f, 4.97518806e-03f,
  -4.10846211e-02f, 5.33764102e-02f, 1.22279070e-01f, -1.26076564e-01f, -5.28501496e-02f, 1.84382945e-01f, 2.74442971e-01f, 1.74302265e-01f, -4.33781650e-03f, -1.99594021e-01f,
  -7.72879198e-02f, -5.09387217e-02f, -6.41321540e-02f, -1.93540953e-04f, 2.24185213e-02f, 1.21126890e-01f, 1.38995633e-01f, 2.93376055e-02f, 8.86061192e-02f, 8.54503289e-02f,
  -6.16574213e-02f, -1.36704206e-01f, -2.18005210e-01f, 2.07554996e-01f, -2.53029972e-01f, 3.77167016e-01f, 3.12812686e-01f, 4.61558178e-02f, -8.01118389e-02f, -2.36557275e-02f,
  -2.36876592e-01f, 1.11988910e-01f, 2.66470462e-01f, 2.48694539e-01f, -4.70480882e-02f, -1.71739131e-01f, 1.80716470e-01f, 3.58056724e-02f, -9.32496265e-02f, -6.29725307e-02f,
  5.96950529e-03f, -9.63388383e-02f, 1.02247171e-01f, -3.98405939e-01f, 1.24583438e-01f, -1.50691405e-01f, -1.08174212e-01f, 9.56704244e-02f, 4.89484482e-02f, 6.98928162e-02f,
  -4.91762115e-03f, -6.89387769e-02f, 1.87296867e-01f, -3.16063762e-02f, 4.04349621e-03f, -1.84040070e-01f, 2.33732790e-01f, -4.08408679e-02f, -2.53518432e-01f, 3.45566243e-01f,
  2.20875517e-01f, 1.01409063e-01f, 1.57623053e-01f, -4.24179994e-02f, 1.34985819e-01f, -7.19917119e-02f, 1.26853108e-01f, 1.28564611e-01f, -1.62722737e-01f, 1.04900368e-01f,
  2.12844074e-01f, -1.94484293e-01f, -8.51513073e-02f, -2.82923371e-01f, 6.59369156e-02f, 6.27586916e-02f, 7.93156549e-02f, -3.98125127e-02f, 7.82825798e-02f, 2.11453244e-01f,
  -6.91577941e-02f, -1.26987770e-01f, -2.51850724e-01f, -1.61969550e-02f, 3.69028300e-02f, 1.04932249e-01f, -1.63355187e-01f, -1.95667163e-01f, 3.27395231e-01f, 3.49027187e-01f,
  5.42621315e-02f, -1.54941425e-01f, -2.10467592e-01f, 1.96703911e-01f, 1.93138912e-01f, -6.33360818e-02f, 1.45053521e-01f, 2.70456165e-01f, -4.30861115e-02f, -5.15011474e-02f,
  2.75433613e-05f, -6.12279586e-02f, -2.82932967e-01f, 8.99329260e-02f, 2.50684857e-01f, -1.01922154e-01f, 1.37464885e-04f, 1.85376823e-01f, 1.38035640e-01f, -1.63197026e-01f,
  -2.53326625e-01f, 9.55566466e-02f, -1.07474901e-01f, 1.59861550e-01f, -9.40399393e-02f, 2.09371865e-01f, -7.88065866e-02f, -2.33288109e-01f, -3.06444690e-02f, -1.69111878e-01f,
  -2.10717633e-01f, 1.73225969e-01f, -1.37056902e-01f, 7.40689859e-02f, -1.18200906e-01f, -1.42191201e-01f, 1.01094149e-01f, 1.08974569e-01f, 1.60379216e-01f, 3.46993282e-03f,
  1.53821975e-01f, -9.08304453e-02f, -1.53844520e-01f, 9.45696458e-02f, -9.53845605e-02f, -3.19242299e-01f, -1.19267568e-01f, -3.03756613e-02f, 1.80265993e-01f, 1.34632289e-01f,
  1.25358060e-01f, 4.11594249e-02f, 3.22963670e-02f, 1.73856646e-01f, 1.47198234e-03f, -5.28690442e-02f, 3.84932477e-03f, -1.66009337e-01f, -8.70934725e-02f, 2.05436215e-01f,
  2.74173111e-01f, -3.87257002e-02f, 7.82346353e-02f, 9.14134365e-03f, -3.26970443e-02f, -1.79973334e-01f, -7.11462274e-02f, 1.53064474e-01f, -9.42890942e-02f, -1.22084506e-01f,
  2.60151885e-02f, -3.46270800e-02f, -7.22229108e-02f, -2.28908196e-01f, -6.59828559e-02f, 1.41510651e-01f, 2.38794684e-01f, 1.75895929e-01f, 2.28023902e-02f, 2.30396390e-01f,
  -6.14438346e-03f, -9.92601141e-02f, 2.55376726e-01f, -1.18611902e-01f, -2.01398090e-01f, 1.14360005e-01f, 1.41429424e-01f, 5.66148423e-02f, 2.03941733e-01f, 1.97356358e-01f,
  -8.39400291e-02f, -9.56112221e-02f, -1.49627626e-02f, 1.33104417e-02f, 1.53224601e-03f, 3.36080827e-02f, 9.25390497e-02f, 4.05880623e-02f, 3.44762974e-03f, -8.58552828e-02f,
  5.56325428e-02f, -2.58132696e-01f, 3.27591926e-01f, 2.75787264e-01f, 1.80083975e-01f, 2.54921615e-01f, -3.22165340e-02f, 1.48151845e-01f, -2.85203815e-01f, 7.97859672e-03f,
  1.43740177e-01f, 1.14449583e-01f, 2.26565465e-01f, 2.79388577e-01f, 2.31855690e-01f, 8.32474753e-02f, 4.96927164e-02f, 2.63430595e-01f, 6.50533959e-02f, -3.29651982e-02f,
  -3.31481472e-02f, -9.21313614e-02f, 1.08210333e-02f, 4.24791537e-02f, -1.79173499e-02f, 1.95044458e-01f, 1.94832869e-02f, 2.80219287e-01f, -4.37759832e-02f, -3.45691532e-01f,
  1.94322705e-01f, 1.19687267e-01f, -1.00912467e-01f, -8.64053294e-02f, -1.08752228e-01f, -7.85887092e-02f, -2.15300713e-02f, 1.51021004e-01f, 1.38099313e-01f, -8.16318095e-02f,
  -2.94413894e-01f, 7.94229358e-02f, 1.72928333e-01f, 3.24972831e-02f, -8.59448779e-03f, 1.74523760e-02f, 2.94264164e-02f, 3.90465558e-02f, -7.92063624e-02f, -7.21423551e-02f,
  -8.24057218e-03f, 2.58013681e-02f, -6.76985234e-02f, -6.37524724e-02f, 1.28266858e-02f, 3.74182649e-02f, 1.03864729e-01f, -1.39459893e-01f, -1.80549309e-01f, -9.49801058e-02f,
  5.81960380e-02f, 4.15459394e-01f, 1.07526354e-01f, 8.47116262e-02f, -1.39231712e-01f, 8.04950818e-02f, 7.57019073e-02f, -2.25601241e-01f, 1.48198247e-01f, -5.71090057e-02f,
  2.07369756e-02f, -1.36228070e-01f, -1.84596643e-01f, -2.29101911e-01f, 8.58865678e-02f, 2.83442885e-01f, 1.30929992e-01f, 1.13196909e-01f, -1.06067866e-01f, 1.52869850e-01f,
  -4.21927907e-02f, 2.75528282e-02f, 2.05762219e-02f, -5.83752873e-04f, 7.25371018e-02f, -1.73306763e-01f, -6.27175197e-02f, -1.81192949e-01f, 3.82546127e-01f, -1.61133289e-01f,
  2.17334125e-02f, 1.56659588e-01f, -8.49805921e-02f, 9.78979021e-02f, -1.17292352e-01f, 2.19998091e-01f, -3.23436595e-02f, 6.78938702e-02f, 8.82764980e-02f, 3.74245457e-02f,
  1.69429451e-01f, -5.53957224e-02f, -2.69081414e-01f, -1.78395391e-01f, 1.50233969e-01f, 4.11416925e-02f, 4.79542557e-03f, -2.41224349e-01f, -1.36539996e-01f, -9.58006904e-02f,
  4.69913967e-02f, 7.98636302e-02f, -1.01026177e-01f, 2.09318131e-01f, 1.67835906e-01f, -1.69626504e-01f, 9.14117396e-02f, 1.07628390e-01f, -1.13303944e-01f, 2.31679343e-02f,
  -2.57929564e-01f, 2.45390944e-02f, -2.00030863e-01f, -1.49515003e-01f, 1.89844575e-02f, -2.24833176e-01f, -1.12295732e-01f, -4.42720912e-02f, -7.62552246e-02f, -1.13619514e-01f,
  9.32995081e-02f, 2.52745450e-01f, -1.41044587e-01f, -1.32060394e-01f, 1.99729323e-01f, 7.70238834e-03f, 4.15499695e-02f, 2.46623866e-02f, 1.63998887e-01f, -1.35314465e-01f,
  2.73947746e-01f, 5.99192530e-02f, 1.43662384e-02f, -2.24252753e-02f, 4.34314981e-02f, 3.58545817e-02f, -6.28237724e-02f, 1.12727307e-01f, -1.56252921e-01f, -8.41239095e-02f,
  -3.90004702e-02f, -5.52594848e-02f, 2.48595029e-01f, 2.65845153e-02f, -2.12465495e-01f, 4.09053624e-01f, 8.34341124e-02f, 2.19573174e-02f, 7.27099180e-02f, 1.63744595e-02f,
  -7.42337853e-02f, 3.08334790e-02f, -1.30408794e-01f, 1.29395172e-01f, 8.28713998e-02f, 9.65993404e-02f, -7.92592168e-02f, -9.94205102e-02f, -2.11753726e-01f, 2.87667364e-01f,
  5.15278941e-03f, 1.23653024e-01f, 3.93962562e-02f, -1.55977756e-01f, 1.33430496e-01f, 3.49676907e-02f, -1.00069031e-01f, 8.99446309e-02f, -8.25760588e-02f, 1.06607482e-01f,
  8.95006806e-02f, 8.57447982e-02f, -8.12232718e-02f, 4.68406528e-02f, -4.52040657e-02f, -2.00113803e-01f, -2.52321243e-01f, 7.02751055e-02f, -7.51704499e-02f, 1.18246116e-01f,
  -2.46783271e-02f, -1.18930168e-01f, 1.63025066e-01f, 8.65203515e-02f, 4.74723950e-02f, 3.73086240e-03f, 2.21023530e-01f, 6.71595782e-02f, 8.48946869e-02f, 3.71162631e-02f,
  -1.19597636e-01f, -3.22012067e-01f, 7.90584609e-02f, -1.40514029e-02f, 7.19231442e-02f, -9.72197577e-02f, -1.55495644e-01f, -1.99239813e-02f, 7.68416282e-03f, -4.00672071e-02f,
  -1.04830764e-01f, -1.37681007e-01f, 2.70679325e-01f, 1.09640427e-01f, -5.90465069e-02f, 4.47035544e-02f, -2.84306854e-01f, -2.15095490e-01f, 1.76159322e-01f, -8.54920447e-02f,
  1.17370397e-01f, 3.29558477e-02f, -8.87048617e-02f, 1.88547671e-02f, -1.20323479e-01f, 1.61533207e-01f, 2.07028240e-01f, -3.19040984e-01f, -4.31124344e-02f, -9.45982262e-02f,
  -1.31509647e-01f, -1.39767323e-02f, -3.39213222e-01f, 1.66989863e-01f, 2.07731441e-01f, 6.91550896e-02f, 8.19354653e-02f, 1.56873167e-02f, -1.20473117e-01f, 6.17918512e-03f,
  2.79779434e-01f, -7.08030239e-02f, -6.13492653e-02f, 2.78558940e-01f, -2.54137456e-01f, -1.84337959e-01f, 3.63746881e-02f, -8.96872431e-02f, -1.48743913e-01f, -4.51042145e-01f,
  -2.66055048e-01f, -1.69781461e-01f, -7.13289008e-02f, -7.01979771e-02f, 6.74272552e-02f, -5.68553098e-02f, 8.40718597e-02f, 1.32145479e-01f, -1.57002434e-01f, 6.88442886e-02f,
  2.75132395e-02f, -1.43582582e-01f, 1.68020934e-01f, 2.94942558e-01f, -1.14745356e-01f, 2.62968451e-01f, 1.22421026e-01f, -2.13581249e-01f, -8.62208530e-02f, -4.57387231e-02f,
  2.59173363e-02f, -5.27117774e-02f, -6.91006705e-02f, -8.41169655e-02f, 6.87439088e-03f, 2.65607554e-02f, 5.10266330e-03f, -1.01628955e-02f, -1.72479704e-01f, -6.89481124e-02f,
  -1.82666168e-01f, 1.78211182e-01f, -2.38886978e-02f, -8.39407146e-02f, 4.18448448e-03f, -3.15551944e-02f, -7.64588825e-03f, -1.72461212e-01f, 3.42282690e-02f, -4.78716418e-02f,
  1.23837441e-01f, -3.21362168e-02f, 2.85238743e-01f, 6.23957328e-02f, 1.37419134e-01f, 1.92254618e-01f, 2.09462434e-01f, -4.96103652e-02f, -1.30642384e-01f, -1.47664681e-01f,
  -1.07862614e-01f, -9.75478366e-02f, -2.50588179e-01f, -1.66414008e-01f, -6.04954846e-02f, 6.58939630e-02f, -1.49672031e-02f, -5.78487590e-02f, 6.17030524e-02f, -4.71848659e-02f,
  1.50224045e-01f, 8.24544728e-02f, -6.78606629e-02f, 1.01083346e-01f, -4.79499660e-02f, 1.61327347e-01f, 2.79377669e-01f, -2.70517655e-02f, 1.26052216e-01f, 1.71563044e-01f,
  -4.14809361e-02f, 9.05671790e-02f, -5.20778447e-02f, -8.71846899e-02f, -2.74468482e-01f, 1.95625108e-02f, -1.13366142e-01f, 1.23922788e-02f, -6.70842752e-02f, -2.17016786e-02f,
  -4.10523117e-01f, 1.00150138e-01f, 7.14317635e-02f, 7.27563128e-02f, 7.32039139e-02f, 1.87443107e-01f, -5.24732694e-02f, 2.90648993e-02f, 1.86817005e-01f, -1.01160653e-01f,
  -2.53421739e-02f, -9.00594220e-02f, 4.02664170e-02f, -5.80153279e-02f, 1.41739920e-01f, 1.13595508e-01f, -8.69845897e-02f, 3.18508089e-01f, 2.07093880e-01f, -6.30247295e-02f,
  -1.86827123e-01f, 1.88052952e-01f, -3.17412466e-01f, -5.48700318e-02f, 5.39469756e-02f, 1.55432835e-01f, -5.72343916e-03f, -2.24604651e-01f, 2.67920613e-01f, -1.58055261e-01f,
  6.43912703e-02f, 6.17548302e-02f, -7.85034895e-02f, -5.05481809e-02f, 4.46118861e-02f, -3.70941103e-01f, -9.24987495e-02f, 8.43810514e-02f, -2.06721630e-02f, 1.09760379e-02f,
  1.52584463e-01f, -6.28313795e-03f, 1.15196453e-02f, 3.97936366e-02f, 2.98376027e-02f, 2.82356769e-01f, 6.40445277e-02f, -1.07313499e-01f, -1.06199995e-01f, -1.16123706e-01f,
  -1.71933234e-01f, 1.98595956e-01f, 1.96199372e-01f, 1.95446149e-01f, 7.96614774e-03f, -3.84720154e-02f, -6.69631213e-02f, -5.43198362e-02f, -2.03795731e-01f, -1.04204714e-01f,
  -4.85633984e-02f, 1.18968710e-01f, -1.57160282e-01f, 2.12169532e-03f, 1.46229103e-01f, -2.13479131e-01f, -7.86957741e-02f, 9.78826433e-02f, -6.51605055e-03f, -1.50066717e-02f,
  -3.77275124e-02f, 1.25690192e-01f, -7.76733132e-03f, -1.76256254e-01f, -4.73829731e-02f, 1.04278000e-02f, 2.43886542e-02f, -2.71101985e-02f, -5.09579107e-02f, 6.91618919e-02f,
  1.98192131e-02f, 9.57549084e-03f, 2.01295570e-01f, -1.48457112e-02f, -2.05319688e-01f, 2.01880530e-01f, -1.51500136e-01f, -1.14998639e-01f, 6.20860271e-02f, 1.27058849e-01f,
  -7.81931579e-02f, -5.27238287e-03f, 1.26541452e-02f, -1.32099390e-01f, 3.37015212e-01f, 2.40659737e-03f, 2.05565561e-02f, -1.88977420e-01f, -2.07213983e-01f, -4.59372103e-02f,
  1.71353698e-01f, -4.45689149e-02f, -4.42767097e-03f, 7.31223524e-02f, 1.30328044e-01f, 1.90695703e-01f, 1.88531265e-01f, 1.52586132e-01f, 3.81851494e-02f, -1.25213861e-01f,
  1.49708807e-01f, 5.13870455e-02f, 1.71855673e-01f, -8.39563534e-02f, -1.08408511e-01f, -1.45921707e-01f, 3.27272080e-02f, 1.41978199e-02f, 2.42895842e-01f, 5.06251045e-02f,
  2.00937301e-01f, 3.74757558e-01f, 7.57741705e-02f, 1.19524859e-01f, -2.74579115e-02f, 7.71287009e-02f, 9.63197052e-02f, -1.45845652e-01f, 2.10798770e-01f, -3.09037089e-01f,
  1.71008125e-01f, 3.94011736e-02f, -6.60086721e-02f, 8.00211579e-02f, 1.44832060e-01f, 1.13365375e-01f, 5.69579937e-02f, -6.95142820e-02f, 1.42181665e-01f, -5.05784974e-02f,
  8.52261037e-02f, -1.81754753e-01f, 3.72999787e-01f, 2.15450704e-01f, -5.57027496e-02f, -5.42384796e-02f, 1.58350766e-02f, 8.72890949e-02f, 2.37145260e-01f, 3.16954055e-03f,
  1.67280689e-01f, -1.39305657e-02f, -1.28903657e-01f, -2.11566919e-03f, 1.12030812e-01f, 1.14962623e-01f, 1.65511534e-01f, -1.90402374e-01f, -1.15722284e-01f, -2.28768900e-01f,
  -1.29182026e-01f, -5.14682412e-01f, 4.44775000e-02f, 1.80736631e-01f, 9.38478671e-03f, 1.84438229e-01f, 3.94051075e-02f, -1.99577332e-01f, -2.84692913e-01f, -2.10374385e-01f,
  -2.18287781e-01f, 1.54722750e-01f, -6.21440485e-02f, 3.75745296e-01f, -8.01083744e-02f, 1.35765433e-01f, -2.21452340e-01f, -1.40326977e-01f, -6.63747117e-02f, -1.57412570e-02f,
  1.28339738e-01f, 2.91229580e-02f, -3.18597853e-02f, 9.29320045e-03f, -1.49365410e-01f, -3.74522567e-01f, -3.60896081e-01f, -1.70228824e-01f, 1.69964939e-01f, -7.10596517e-02f,
  -1.26722276e-01f, -6.65726587e-02f, -3.22149834e-03f, 3.33255455e-02f, -2.79758535e-02f, 2.48468131e-01f, -7.22158030e-02f, 2.20957682e-01f, 5.54578416e-02f, -3.72312255e-02f,
  1.23001665e-01f, -9.00989547e-02f, -1.32875726e-01f, 9.76269245e-02f, 8.59041363e-02f, 7.68998219e-03f, -2.49510214e-01f, 1.70205414e-01f, 1.83166325e-01f, -1.44849969e-02f,
  -4.27378621e-03f, -2.02158749e-01f, -1.56115815e-01f, 1.80878326e-01f, 1.22371808e-01f, 1.93809822e-01f, 1.40838906e-01f, 1.58849388e-01f, -2.39657849e-01f, 1.13526098e-01f,
  5.66659123e-02f, -1.44788429e-01f, 1.30556032e-01f, -2.13479921e-01f, 1.55960068e-01f, -2.13737309e-01f, -4.74719480e-02f, 8.63831118e-02f, -5.11046201e-02f, -1.24441326e-01f,
  -5.13854139e-02f, 1.21111445e-01f, 1.06972754e-02f, 1.70570359e-01f, -2.21576318e-01f, -3.95987481e-02f, 1.67333364e-01f, -1.62194237e-01f, 6.57486245e-02f, -2.10129887e-01f,
  -1.02225155e-01f, -1.31572142e-01f, 6.31861687e-02f, 1.31927818e-01f, 1.02806196e-01f, 1.49307445e-01f, -1.71474263e-01f, -6.13319082e-03f, -1.92795377e-02f, -1.14345849e-01f,
  -1.54811770e-01f, -1.63200065e-01f, -2.62872010e-01f, 1.81249127e-01f, 8.76315832e-02f, 6.93695247e-02f, 1.35577261e-01f, 4.07780856e-02f
};

// L1_fan_Bp_bar (Shape: 1 x 52)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 52;
const float L1_fan_Bp_bar_data[] = {
  1.46899194e-01f, -7.71451136e-03f, 1.53043270e-01f, -1.11895226e-01f, -2.16940607e-04f, -7.55048245e-02f, 2.31091723e-01f, -1.17527479e-02f, 1.25931859e-01f, -1.63695917e-01f,
  5.96331060e-02f, 1.58409640e-01f, 1.00159965e-01f, 1.04762323e-03f, 2.21973494e-01f, 1.72217324e-01f, 8.25533569e-02f, -1.47626093e-02f, 2.03172043e-01f, -1.02040581e-01f,
  1.74262166e-01f, 1.11756846e-01f, 1.19239040e-01f, -4.40155081e-02f, -1.23864459e-02f, 1.75640300e-01f, -4.28124629e-02f, 1.13618985e-01f, 1.09496489e-01f, 1.58435777e-01f,
  -9.50580463e-03f, -8.59375447e-02f, 3.01626083e-02f, 5.28699532e-02f, -1.97452545e-01f, 9.24000815e-02f, 7.13489503e-02f, 2.41993576e-01f, 1.81205235e-02f, -1.08794786e-01f,
  1.65446401e-01f, -3.02429926e-02f, 2.89125443e-01f, 1.15238123e-01f, 2.78149188e-01f, 5.66041395e-02f, -7.35050142e-02f, -1.18327267e-01f, 1.71009764e-01f, -1.86734438e-01f,
  -3.51833254e-02f, 5.96186444e-02f
};

// L2_fan_Wp (Shape: 6 x 64)
const int L2_fan_Wp_rows = 6;
const int L2_fan_Wp_cols = 64;
const float L2_fan_Wp_data[] = {
  -1.59948409e-01f, -1.74562305e-01f, 1.54574469e-01f, 8.85195099e-03f, 9.38616917e-02f, 6.01996556e-02f, 4.51267668e-04f, -1.06679022e-01f, 1.04233595e-02f, 4.33176272e-02f,
  6.22781292e-02f, -1.10997647e-01f, -2.00130939e-01f, 3.85987014e-02f, -8.74651670e-02f, -1.04441140e-02f, 4.17733267e-02f, -9.19207409e-02f, -2.14311019e-01f, -4.89642657e-02f,
  -1.98382866e-02f, -9.34184641e-02f, -2.34047756e-01f, 1.50580302e-01f, -4.80235601e-03f, -1.17917694e-01f, -8.35079029e-02f, -2.82658301e-02f, 1.34119287e-01f, -4.63590436e-02f,
  -1.21205367e-01f, 2.54816599e-02f, -6.61040619e-02f, 1.33703485e-01f, 2.51388520e-01f, -2.74594247e-01f, 5.70809580e-02f, 5.85470796e-02f, 8.19845311e-03f, 7.33234957e-02f,
  -1.58019125e-01f, -1.57670248e-02f, -2.67263800e-01f, -1.81953892e-01f, 1.62870526e-01f, -1.51331797e-01f, -4.00754763e-03f, 1.35933369e-01f, 8.07948560e-02f, 4.43132520e-02f,
  -5.49701788e-02f, -7.32343048e-02f, 8.25126618e-02f, 1.40765943e-02f, 9.43737105e-03f, -2.23186538e-02f, -4.81153466e-02f, 3.39555852e-02f, -3.89876842e-01f, 2.16762006e-01f,
  3.89148444e-02f, -6.40885904e-02f, 2.69382060e-01f, -1.38056651e-01f, 1.17684864e-01f, -5.87541237e-02f, -2.31300741e-01f, -9.73147750e-02f, -2.03730896e-01f, 6.55812174e-02f,
  -7.67593309e-02f, 4.05593663e-01f, 1.08096123e-01f, -1.54801190e-01f, 3.36177319e-01f, -6.13448443e-03f, -5.03883045e-03f, 1.65114269e-01f, -8.81663561e-02f, 7.18505308e-02f,
  8.72987416e-03f, 1.71715692e-01f, 6.78605512e-02f, 3.58655006e-01f, -1.32095609e-02f, -9.93186906e-02f, 2.46375382e-01f, -1.55677378e-01f, 2.81072911e-02f, -1.90474689e-01f,
  -1.13273837e-01f, 4.43449877e-02f, 5.59907332e-02f, -4.03474644e-02f, 6.66031092e-02f, -1.19072504e-01f, 6.21979795e-02f, 8.87162387e-02f, -7.97254667e-02f, 8.88788626e-02f,
  7.42555261e-02f, 1.08513683e-02f, -2.68940032e-01f, 6.20030463e-02f, 9.46412608e-02f, 3.74730416e-02f, -2.18218826e-02f, 2.45326608e-01f, -9.45612602e-03f, 9.74659175e-02f,
  -6.36939257e-02f, -1.12118818e-01f, -9.16944221e-02f, -5.49504496e-02f, -9.17780399e-02f, -9.64982137e-02f, -1.88055396e-01f, -1.01623878e-01f, -1.09543487e-01f, -1.30480155e-01f,
  3.94719169e-02f, -7.03338757e-02f, 1.12091534e-01f, -2.77301297e-02f, -1.99689806e-01f, -7.83927068e-02f, 1.14224769e-01f, 6.54845610e-02f, -2.48690266e-02f, -1.12437770e-01f,
  -3.45724961e-03f, 7.43581578e-02f, -1.62267670e-01f, 6.89288005e-02f, -5.58744557e-02f, -7.12402090e-02f, -1.37457848e-01f, 1.75721291e-02f, 5.53139858e-02f, 1.51444316e-01f,
  5.02667353e-02f, -1.29864588e-01f, 6.63576797e-02f, 2.68631458e-01f, -1.23641752e-01f, -1.94273740e-01f, -2.03977674e-02f, 2.03359157e-01f, -3.36712003e-02f, -1.11710437e-01f,
  1.92052633e-01f, -1.19381346e-01f, 5.31121641e-02f, 4.75590955e-03f, -2.10711583e-01f, -6.65171072e-02f, -4.24804278e-02f, -1.21611468e-01f, 1.66122690e-02f, -7.85296783e-02f,
  2.25574389e-01f, 1.98396984e-02f, 1.10902168e-01f, 3.25500295e-02f, -2.88485795e-01f, 1.12516351e-01f, -2.05705822e-01f, 9.69196782e-02f, 1.99210793e-01f, 3.68667096e-02f,
  6.37801783e-03f, -2.43534502e-02f, -2.20646307e-01f, -8.23066458e-02f, 7.94360321e-03f, 4.25559329e-03f, -1.46512374e-01f, 1.32133245e-01f, -4.66479076e-04f, -1.20731175e-01f,
  1.55105993e-01f, 2.36505885e-02f, 1.28517792e-01f, -1.80246700e-02f, -2.56414767e-02f, 5.12873046e-02f, -1.37668744e-01f, 4.64765169e-03f, 1.35373488e-01f, 1.59954011e-01f,
  7.57538080e-02f, 4.99732036e-04f, -2.40900889e-01f, 9.40975845e-02f, -6.21050484e-02f, 1.51784241e-01f, -2.41055675e-02f, -1.46158293e-01f, -2.76843086e-02f, -1.07499540e-01f,
  -2.34162822e-01f, 1.59114718e-01f, 9.32656303e-02f, -3.42099704e-02f, 8.07580873e-02f, -1.60089135e-01f, -1.57882825e-01f, -3.77863236e-02f, 7.09414184e-02f, 5.51697537e-02f,
  6.91216290e-02f, 7.77624696e-02f, 9.02499184e-02f, 7.52154961e-02f, -6.45279512e-02f, 1.66623726e-01f, 7.65731484e-02f, 1.88252404e-01f, -8.08288679e-02f, -5.78991435e-02f,
  1.37775997e-02f, 2.72361577e-01f, 8.97544548e-02f, 1.40319899e-01f, 1.05771966e-01f, -1.98884130e-01f, 2.34989673e-01f, -2.36467011e-02f, 4.89158258e-02f, 5.44542223e-02f,
  6.65320531e-02f, -2.73468703e-01f, -3.68872471e-02f, -1.30740300e-01f, -1.14378206e-01f, 4.21354286e-02f, 5.89570664e-02f, 6.45048916e-02f, 1.97681665e-01f, 1.39008701e-01f,
  -1.10277504e-01f, -1.25499845e-01f, -1.13234846e-02f, 8.90063569e-02f, 1.17076673e-01f, 1.48840889e-01f, 2.54558325e-01f, -9.48419720e-02f, -1.75076306e-01f, 4.92229648e-02f,
  1.34430498e-01f, 4.03120555e-02f, -1.10320099e-01f, 8.27454999e-02f, -1.42783880e-01f, -1.30567417e-01f, 1.65894963e-02f, 1.46379098e-01f, -1.16570368e-01f, 9.93788242e-03f,
  1.33815585e-02f, 1.40269116e-01f, 8.55905190e-02f, 9.06678438e-02f, -1.22266568e-01f, 1.52518153e-01f, 9.10336077e-02f, -1.76858395e-01f, 1.43180098e-02f, -6.18189499e-02f,
  -1.13228813e-01f, -1.06084526e-01f, -4.35923673e-02f, -2.02048942e-01f, -2.11822182e-01f, 2.70404160e-01f, 1.08245783e-01f, 2.90561795e-01f, 1.94177970e-01f, -8.33304375e-02f,
  -1.14057966e-01f, -1.00843079e-01f, -1.51399493e-01f, 1.14072291e-02f, 1.48645729e-01f, 1.10878628e-02f, -1.01623818e-01f, -4.67041396e-02f, -1.07373938e-01f, 2.95512050e-01f,
  1.08143635e-01f, -9.81165320e-02f, -4.66815988e-03f, 5.89555390e-02f, 5.37885353e-02f, 7.60292336e-02f, 4.52926159e-02f, -4.54423390e-03f, -9.49199349e-02f, 2.61962503e-01f,
  1.63119256e-01f, 1.88418739e-02f, 1.06182694e-01f, -1.05332606e-01f, 3.39645930e-02f, -2.06207633e-02f, -1.22363344e-01f, -1.44022023e-02f, -1.96570709e-01f, -1.47154465e-01f,
  6.64839968e-02f, -1.08184367e-01f, 1.21792659e-01f, 2.25874916e-01f, 6.13872893e-03f, -2.25171470e-03f, -4.25760746e-02f, 2.31841370e-01f, 6.72372505e-02f, -2.48761192e-01f,
  -1.10510491e-01f, 1.29943594e-01f, 9.29429308e-02f, 8.79495069e-02f, -2.07106080e-02f, -1.36192918e-01f, 5.01835793e-02f, 2.77353317e-01f, 1.07079804e-01f, -6.76252544e-02f,
  1.96279094e-01f, -6.44361321e-03f, -6.19392991e-02f, -1.12708542e-03f, -4.38947454e-02f, -1.82425961e-01f, -5.49321398e-02f, 6.56562904e-03f, 1.13373064e-02f, 2.94183463e-01f,
  9.10993200e-03f, 2.05906674e-01f, 1.10464513e-01f, -8.31928104e-02f, -9.34455022e-02f, -3.45039694e-03f, 2.66793333e-02f, -7.81359896e-03f, -3.94357592e-02f, 1.57941237e-01f,
  3.50603163e-02f, 7.48100206e-02f, -7.32365921e-02f, -9.04405769e-03f, 1.48829699e-01f, -9.55017880e-02f, 1.07447930e-01f, 1.15962103e-01f, 1.02846153e-01f, -1.58514410e-01f,
  2.80797877e-03f, -2.29406133e-01f, -2.46499386e-02f, 7.46316612e-02f, 1.67108923e-02f, -5.29595129e-02f, 9.78253856e-02f, 8.50136355e-02f, 1.40340000e-01f, -1.37443438e-01f,
  -1.53628826e-01f, 1.10353231e-01f, -5.74163496e-02f, -1.30876720e-01f, 7.79227242e-02f, -7.74552003e-02f, -6.22490160e-02f, -1.31235961e-02f, -1.04699992e-02f, 2.02401176e-01f,
  2.07510665e-02f, 8.33397657e-02f, -1.80671990e-01f, -1.55461514e-02f
};

// L2_fan_Wp_bar (Shape: 52 x 64)
const int L2_fan_Wp_bar_rows = 52;
const int L2_fan_Wp_bar_cols = 64;
const float L2_fan_Wp_bar_data[] = {
  2.02922404e-01f, 1.09305605e-01f, -1.49598092e-01f, 2.51122266e-01f, 2.22227842e-01f, 3.32399428e-01f, -3.17739874e-01f, -1.74473599e-01f, -1.14343874e-01f, -4.15907204e-02f,
  3.57559979e-01f, 1.96082946e-02f, 1.05816945e-01f, 2.18778625e-01f, 7.27343261e-02f, -2.85350293e-01f, -2.38264725e-01f, -8.50401372e-02f, -2.88129901e-03f, 1.01719387e-01f,
  -1.59804914e-02f, -1.49991125e-01f, -1.15141988e-01f, -6.07854016e-02f, 1.56722143e-01f, 4.22121473e-02f, -1.72482595e-01f, -2.21791137e-02f, -1.73314847e-02f, -4.69964966e-02f,
  3.52692567e-02f, -1.54867142e-01f, 1.41738713e-01f, 2.31637526e-02f, -1.80216417e-01f, 2.08434671e-01f, -2.97096133e-01f, -1.10135160e-01f, -2.53629889e-02f, -1.16399294e-02f,
  -2.52644485e-03f, 1.02728337e-01f, -5.68941012e-02f, -3.56820285e-01f, -1.60428748e-01f, -1.45189427e-02f, -1.38095498e-01f, -5.59716560e-02f, -8.35373551e-02f, 1.63123503e-01f,
  1.53053224e-01f, -1.59027651e-02f, -6.78922161e-02f, 2.79000938e-01f, 1.54905543e-01f, 2.21243531e-01f, 2.59328455e-01f, 2.04717651e-01f, -2.96205103e-01f, -2.68473953e-01f,
  -8.49611685e-02f, -4.67007235e-02f, -2.07652986e-01f, 1.04350805e-01f, -2.43950576e-01f, -1.16074912e-01f, 6.12017624e-02f, -1.40091851e-01f, -2.07029596e-01f, 7.13507086e-03f,
  -4.55467701e-01f, -2.60976791e-01f, -4.86997634e-01f, 2.62929291e-01f, 4.05995324e-02f, 3.28718811e-01f, -1.36792794e-01f, 2.14311499e-02f, 1.16013043e-01f, -9.86120403e-02f,
  2.56232545e-02f, 8.96563381e-02f, 1.03566470e-02f, 9.66588855e-02f, -4.10901271e-02f, 1.48943916e-01f, 1.32757472e-02f, 3.82024646e-02f, 2.41329730e-01f, -7.46181458e-02f,
  -4.04836517e-03f, -1.36463985e-01f, -1.56126022e-01f, 4.21944307e-03f, -5.74881770e-03f, 1.96913525e-01f, 1.22934081e-01f, -3.51203457e-02f, -1.55685693e-01f, -1.38991326e-01f,
  8.26422349e-02f, -1.20113213e-02f, 3.95665057e-02f, -2.49825135e-01f, -4.99157235e-02f, 2.16957238e-02f, -1.05722271e-01f, 1.42107487e-01f, 1.15304202e-01f, -4.84592468e-02f,
  -3.32174897e-02f, -2.26789400e-01f, -1.17380582e-01f, -4.90606874e-02f, 5.98055571e-02f, 1.06993318e-01f, 2.70156562e-01f, 1.00892253e-01f, 1.90926224e-01f, -2.21962109e-01f,
  -1.17290439e-02f, 1.33750275e-01f, -1.94332320e-02f, 1.06219664e-01f, -8.02469030e-02f, 1.48925796e-01f, 4.08768625e-04f, -8.05640593e-02f, 6.29008859e-02f, 2.85788119e-01f,
  2.24556193e-01f, 1.08929850e-01f, 1.12175450e-01f, -1.91440433e-02f, -7.58132786e-02f, 1.25427637e-03f, -6.71117455e-02f, -4.03609663e-01f, 1.46279961e-01f, 5.75612076e-02f,
  -1.05750244e-02f, 1.10270992e-01f, -3.29954475e-01f, -1.56779841e-01f, -2.34450832e-01f, -2.77430937e-02f, 1.18096381e-01f, 8.15569088e-02f, 2.39594117e-01f, -8.41994584e-03f,
  -1.44390352e-02f, 9.17899758e-02f, -1.01806417e-01f, -1.54232094e-02f, -1.14948124e-01f, 1.63379516e-02f, 2.04165235e-01f, 6.62223175e-02f, 9.66143161e-02f, -2.02469617e-01f,
  -2.53608137e-01f, 2.90819168e-01f, 5.20515665e-02f, -1.01628914e-01f, -1.92713588e-01f, -9.73258913e-02f, -2.55403034e-02f, 5.18094040e-02f, -1.72708377e-01f, 4.00455654e-01f,
  -5.81403673e-02f, 2.63832025e-02f, 4.28703167e-02f, 2.42069531e-02f, 2.87136566e-02f, 1.95045322e-01f, 1.13073580e-01f, 4.24396917e-02f, 2.65721232e-01f, -1.57560006e-01f,
  -3.61253798e-01f, -7.56762400e-02f, -1.29006170e-02f, 1.95112050e-01f, 4.02081609e-02f, 1.18319735e-01f, -9.14353579e-02f, -8.79542902e-02f, -1.96680963e-01f, -3.44605073e-02f,
  5.91625012e-02f, -1.83855873e-02f, 2.08555520e-01f, -2.34051496e-02f, 1.03994779e-01f, -8.19142610e-02f, 1.06282786e-01f, -2.11898442e-02f, -1.45968288e-01f, 3.55640769e-01f,
  4.84748363e-01f, -9.11986828e-02f, 2.96348128e-02f, -8.98226276e-02f, 1.45148844e-01f, -7.66868666e-02f, -9.19330791e-02f, -6.07435554e-02f, 6.00827225e-02f, 1.67372748e-01f,
  1.49106324e-01f, 1.20853499e-01f, -2.25846935e-02f, -3.68150580e-03f, 2.30904117e-01f, -1.66322052e-01f, -1.05959609e-01f, 1.39229238e-01f, 1.89901367e-01f, 2.47906297e-02f,
  -4.27187495e-02f, 6.47285059e-02f, -4.31799851e-02f, 1.13387883e-01f, 5.28865419e-02f, -7.65911341e-02f, -2.22865358e-01f, 3.05114120e-01f, -1.50907924e-02f, -4.16793860e-02f,
  9.83207393e-03f, 4.77917716e-02f, 2.67434657e-01f, -2.68241614e-01f, 2.81268150e-01f, 1.54022694e-01f, -1.68475255e-01f, 1.36926085e-01f, -1.39888331e-01f, -5.44444248e-02f,
  -2.89700031e-02f, -6.45356700e-02f, 1.16777167e-01f, 4.56799418e-02f, -1.63060918e-01f, 4.07661907e-02f, 1.68614797e-02f, 1.02411389e-01f, 1.84203029e-01f, -8.28835666e-02f,
  1.74948812e-01f, -2.00757861e-01f, -1.64044067e-01f, 9.21989083e-02f, -2.07204029e-01f, 1.25794783e-01f, -1.39759248e-02f, 1.32962123e-01f, -1.83131412e-01f, 1.27744898e-01f,
  1.65995378e-02f, -1.33762322e-02f, 1.80248886e-01f, 1.96350843e-01f, -3.73454504e-02f, -3.58426005e-01f, 3.35517615e-01f, -1.54651627e-01f, -9.80313867e-03f, 1.02166034e-01f,
  -1.42084761e-02f, 3.03881653e-02f, 6.90589398e-02f, 3.66426050e-03f, 3.03405393e-02f, 2.88589686e-01f, 1.58168033e-01f, 8.62864032e-02f, -3.87264006e-02f, 1.35267332e-01f,
  -1.57321408e-01f, 5.02032274e-03f, -1.72322854e-01f, 4.55900617e-02f, 1.68989331e-01f, 8.50527287e-02f, -7.64895380e-02f, -1.10026551e-02f, 6.99089542e-02f, 2.45899335e-02f,
  7.71390200e-02f, -2.72653019e-03f, 7.87995309e-02f, -5.58466278e-03f, 2.41430596e-01f, -8.76555070e-02f, 3.83152813e-02f, -1.94901064e-01f, -1.43142957e-02f, 2.09951848e-01f,
  1.03698671e-02f, 2.29769319e-01f, 2.21459612e-01f, 2.10357886e-02f, -1.58996992e-02f, 3.03728636e-02f, -4.09401730e-02f, -1.06198840e-01f, -1.87588081e-01f, -6.22900948e-02f,
  1.44771561e-01f, -1.17902920e-01f, 1.55361313e-02f, 5.52459154e-03f, -2.38913223e-02f, -1.21498384e-01f, -1.54867753e-01f, -3.34693268e-02f, 9.49386954e-02f, -1.16762914e-01f,
  5.80605529e-02f, 1.57175049e-01f, -1.92719117e-01f, -5.61330840e-02f, -1.00162670e-01f, -1.27449065e-01f, 4.63650435e-01f, 3.63107502e-01f, 2.67703801e-01f, -3.95105392e-01f,
  3.01282436e-01f, -2.13921845e-01f, -2.86458954e-02f, 7.96085149e-02f, -8.26399326e-02f, -2.00400293e-01f, -1.14012636e-01f, -5.94314411e-02f, -2.89514400e-02f, 1.41743824e-01f,
  -3.22911628e-02f, 2.05759078e-01f, 5.06012253e-02f, 7.79732093e-02f, -1.60310671e-01f, -9.69659016e-02f, 5.11503443e-02f, -2.65435558e-02f, 1.04896978e-01f, 5.12303002e-02f,
  -1.35361880e-01f, 6.13353513e-02f, 1.11822940e-01f, 6.64728135e-02f, 1.05158776e-01f, -1.34768158e-01f, -7.52259567e-02f, -5.93796419e-03f, 1.85703754e-01f, 1.66915521e-01f,
  3.56391035e-02f, 1.10436685e-01f, -3.70641723e-02f, 1.77155152e-01f, -5.97880334e-02f, -1.90945454e-02f, 1.06562987e-01f, 1.66437626e-01f, 2.15556309e-01f, 1.14931062e-01f,
  2.93037370e-02f, -1.65353753e-02f, -3.10995340e-01f, -1.70124367e-01f, 1.44336253e-01f, 6.46785572e-02f, 6.55362532e-02f, -1.55754378e-02f, -7.69511759e-02f, -9.40867513e-03f,
  -1.26129135e-01f, -1.06540285e-01f, 1.94336742e-01f, -1.52335346e-01f, 2.33200520e-01f, 1.36511788e-01f, 2.81724095e-01f, 1.94876611e-01f, 1.16346642e-01f, 5.04672676e-02f,
  -1.12624541e-01f, 4.07785997e-02f, 5.45671470e-02f, 2.37380981e-01f, -2.12730438e-01f, 1.90094307e-01f, 1.20078795e-01f, 7.47122839e-02f, 2.27614164e-01f, 6.39371276e-02f,
  -5.26378602e-02f, -7.65838847e-02f, 1.64340511e-01f, -4.33569551e-02f, 7.00607672e-02f, -9.05775875e-02f, -1.89911246e-01f, 4.56213728e-02f, 3.32736336e-02f, 5.62249087e-02f,
  1.12171993e-01f, 2.33747482e-01f, 1.05594046e-01f, -1.94372848e-01f, -5.02923578e-02f, -1.02788113e-01f, 2.98447348e-02f, 6.11545816e-02f, 2.83001572e-01f, 3.16213034e-02f,
  -2.23822057e-01f, 1.93162978e-01f, -5.38895018e-02f, 2.98567027e-01f, 1.01969369e-01f, 1.69799313e-01f, -5.08570336e-02f, -1.49367183e-01f, 6.31730258e-02f, -1.58104405e-01f,
  -2.37389371e-01f, -1.49489895e-01f, 7.27681890e-02f, 2.24818528e-01f, -1.87897813e-02f, -2.85210192e-01f, 7.42742419e-03f, 2.23378371e-02f, -1.91338763e-01f, 1.40562162e-01f,
  1.52929425e-01f, 7.10396916e-02f, -1.23208873e-01f, 5.22092059e-02f, 3.47457826e-01f, -3.10178474e-02f, -5.77772185e-02f, 2.51807928e-01f, 1.67726353e-01f, 1.25083804e-01f,
  1.32455617e-01f, 1.13506779e-01f, 2.04243630e-01f, 2.38640696e-01f, -4.34572279e-01f, -4.31988060e-01f, -1.35858282e-02f, -2.18056038e-01f, -3.39025185e-02f, 3.05050015e-01f,
  -7.65439719e-02f, -5.69658913e-02f, -4.00659777e-02f, 3.16813984e-03f, -1.30325243e-01f, 1.01205781e-02f, 1.55174419e-01f, -3.46972704e-01f, 5.57485558e-02f, -2.24052623e-01f,
  -1.60524920e-01f, -6.37336671e-02f, 9.73313376e-02f, 4.04062606e-02f, -1.71744998e-03f, -7.81566426e-02f, 1.15742967e-01f, 1.04346685e-01f, 2.41000041e-01f, -4.07429188e-02f,
  -1.93628937e-01f, -1.49167165e-01f, 1.05184674e-01f, -7.37016052e-02f, -1.15455717e-01f, -8.33189711e-02f, 1.08475611e-01f, -7.77381957e-02f, -7.52617791e-02f, 2.47657657e-01f,
  7.52416104e-02f, -3.04412067e-01f, 1.07542217e-01f, -1.04606211e-01f, 4.69039902e-02f, 3.38398963e-02f, 1.06194867e-02f, -5.72117455e-02f, 2.26263702e-01f, -1.58409402e-01f,
  -1.34250283e-01f, 1.90713689e-01f, -2.83673014e-02f, 1.28928125e-01f, -2.44253308e-01f, -1.12741664e-01f, -6.39679581e-02f, -4.75938097e-02f, -4.57883067e-03f, -1.93058565e-01f,
  -1.95877135e-01f, 1.72530692e-02f, 2.27403760e-01f, 2.33765572e-01f, 1.90125659e-01f, 4.34933126e-01f, 2.54440665e-01f, 1.37730703e-01f, -2.68941540e-02f, -2.56799102e-01f,
  -1.23471312e-01f, -4.51443568e-02f, 2.56869495e-01f, -1.87872037e-01f, -1.59630984e-01f, -2.14682832e-01f, 2.25969255e-01f, -1.52893350e-01f, -1.14893273e-01f, -1.89789217e-02f,
  -1.49317324e-01f, -2.56856084e-01f, 1.17152952e-01f, -4.45090644e-02f, -1.27530038e-01f, 1.10010773e-01f, -5.84207512e-02f, 2.22111031e-01f, -3.50957036e-01f, 7.23376498e-02f,
  1.57130569e-01f, 1.89114511e-01f, 3.67583707e-02f, -5.17553911e-02f, -2.63513178e-02f, -3.70472252e-01f, 2.36717597e-01f, -7.58149996e-02f, -1.42619118e-01f, -1.22098461e-01f,
  4.00591820e-01f, -5.91101646e-01f, 7.73032531e-02f, -2.91109588e-02f, 2.20431328e-01f, 3.16397548e-02f, -8.08283761e-02f, -1.56781092e-01f, 1.89305320e-01f, 9.11815241e-02f,
  1.13844173e-02f, -1.37445241e-01f, 1.26000404e-01f, -2.85401285e-01f, 3.35262786e-03f, -6.62574470e-02f, 1.90783665e-01f, 2.19361797e-01f, -1.46828189e-01f, 3.63501906e-02f,
  -1.73585013e-01f, 2.49659689e-03f, -2.22170562e-01f, 1.22997738e-01f, -3.78871679e-01f, -1.58634156e-01f, 4.90732789e-02f, -1.04710296e-01f, -1.06948018e-02f, 3.20364796e-02f,
  1.48983626e-02f, -3.45977247e-02f, -2.45209765e-02f, 1.90865934e-01f, 3.84229839e-01f, -6.52676001e-02f, -3.79573219e-02f, -1.51557148e-01f, 2.15286419e-01f, -1.83776990e-01f,
  -3.56970966e-01f, 2.24631160e-01f, 2.02070877e-01f, 2.26881638e-01f, 1.11128606e-01f, -2.41049677e-01f, 4.65297177e-02f, -7.18213245e-02f, 2.09625736e-01f, -5.66760525e-02f,
  2.11998254e-01f, 1.15799487e-01f, 5.21025211e-02f, -1.70947820e-01f, -1.43678233e-01f, 1.87954325e-02f, -3.65176238e-02f, -4.53369841e-02f, 7.56165609e-02f, -6.16385192e-02f,
  -2.53407151e-01f, 1.07387416e-01f, 1.64516509e-01f, -1.06224231e-01f, -2.17556745e-01f, -1.15957282e-01f, 7.65343755e-02f, -1.02237210e-01f, 7.00564384e-02f, 3.57189476e-02f,
  -7.83055499e-02f, 1.68428078e-01f, -3.92343044e-01f, 4.63015921e-02f, 1.99296512e-03f, -9.30632576e-02f, -5.79086132e-02f, 2.41362900e-02f, -9.29321870e-02f, -1.65010914e-01f,
  9.01713222e-02f, -1.41237244e-01f, -5.98403253e-02f, -3.16153288e-01f, 1.45034552e-01f, -9.15278122e-02f, -2.21656159e-01f, -1.40317352e-02f, -3.10792215e-02f, 1.97300926e-01f,
  -1.65578052e-02f, 2.75910459e-02f, 2.13997401e-02f, 1.90602705e-01f, -4.78190519e-02f, 2.22587045e-02f, -8.86702761e-02f, 1.48684263e-01f, -4.58143324e-01f, -1.63659021e-01f,
  4.44829792e-01f, 1.18653014e-01f, 2.04448551e-01f, 2.07238719e-01f, -7.96571299e-02f, 1.09388031e-01f, -4.46042120e-01f, 9.51977540e-03f, 2.31231928e-01f, 2.20086426e-01f,
  8.66246000e-02f, -1.20421192e-02f, 1.96412668e-01f, -1.98353946e-01f, 8.66972432e-02f, -2.03603879e-02f, -3.13305080e-01f, -8.19696262e-02f, -4.28998880e-02f, -4.65130024e-02f,
  2.01238528e-01f, 2.77780388e-02f, 1.50846943e-01f, 3.46773267e-01f, -2.28770569e-01f, 8.93005878e-02f, -1.76063970e-01f, -8.07285830e-02f, -2.16787398e-01f, 1.12701833e-01f,
  7.23559260e-02f, 2.89257854e-01f, -2.77353019e-01f, 6.31121844e-02f, -4.39569838e-02f, 1.35832936e-01f, -8.90095755e-02f, -3.34694117e-01f, -2.60989547e-01f, 3.36333364e-02f,
  1.16559520e-01f, -1.71054468e-01f, -1.82919204e-01f, 3.46579969e-01f, 1.95030764e-01f, -9.73163322e-02f, 1.98281497e-01f, 4.53099385e-02f, -4.13025618e-01f, -2.30351537e-01f,
  -1.83821525e-02f, 8.20406079e-02f, -2.59697977e-02f, -1.75822765e-01f, 1.11873403e-01f, -2.59610951e-01f, -2.60973155e-01f, -8.04795250e-02f, -6.10319572e-03f, 7.58069530e-02f,
  9.79076698e-02f, 1.62720174e-01f, -6.61631152e-02f, -1.05431631e-01f, -6.54775649e-02f, -3.90634090e-02f, 1.48059964e-01f, -9.27765816e-02f, -5.36158308e-03f, 3.21898550e-01f,
  -3.87148321e-01f, 5.09380326e-02f, 2.07745060e-01f, 1.09086581e-01f, 7.02207610e-02f, 1.61674678e-01f, 1.37912214e-01f, -2.01135784e-01f, 1.85769305e-01f, 5.23518287e-02f,
  -1.21036939e-01f, -1.64021291e-02f, 1.84152916e-01f, -3.68835591e-02f, -2.15593114e-01f, -1.70695055e-02f, 2.10335910e-01f, 1.20586365e-01f, -9.60043296e-02f, 4.07172628e-02f,
  -2.25875512e-01f, -1.38756737e-01f, 1.88592670e-03f, 1.23495109e-01f, 2.23614395e-01f, 4.79821637e-02f, -1.41957372e-01f, 9.54152644e-02f, -1.14215873e-01f, 2.83688337e-01f,
  -1.51474237e-01f, -1.36291772e-01f, -1.06522299e-01f, 7.49708861e-02f, -4.09041643e-02f, -3.65155846e-01f, -7.97823519e-02f, -2.39069819e-01f, 2.27392733e-01f, -1.78099439e-01f,
  1.78876501e-02f, -1.38210520e-01f, -2.99981683e-01f, 2.27682348e-02f, 7.27129951e-02f, 1.53065369e-01f, 3.62749733e-02f, -2.47696713e-01f, 1.25265613e-01f, 1.39384434e-01f,
  -9.46861110e-04f, 6.39734566e-02f, -2.31405012e-02f, 1.70301914e-01f, 2.71913279e-02f, -1.51771620e-01f, -3.65448803e-01f, -1.24579191e-01f, 3.46482486e-01f, -4.07843962e-02f,
  -6.22023717e-02f, -4.21228446e-02f, 2.13358566e-01f, -3.73084933e-01f, -2.95811921e-01f, -1.29874302e-02f, 1.41611874e-01f, 1.89812388e-02f, 8.17466974e-02f, 4.35237736e-02f,
  9.83653292e-02f, -2.29082048e-01f, 5.03851585e-02f, 3.60592864e-02f, -2.37391114e-01f, 8.65786076e-02f, 1.51799545e-01f, -2.76763458e-02f, 1.57633737e-01f, -4.43713255e-02f,
  1.66959986e-01f, 1.90238714e-01f, -1.31724477e-01f, 1.84166789e-01f, -3.42686325e-01f, -1.33322969e-01f, -3.09937336e-02f, 5.30884936e-02f, 2.41034217e-02f, 1.35776058e-01f,
  -1.25084281e-01f, 2.06679359e-01f, -1.61261410e-01f, -1.21066302e-01f, 3.21200863e-02f, -1.41176000e-01f, -2.19462618e-01f, 5.29661849e-02f, 1.51952744e-01f, -1.74815297e-01f,
  4.58734930e-02f, 1.75028116e-01f, 1.72089159e-01f, -1.82256438e-02f, 1.38967171e-01f, 1.24514550e-01f, -1.08544193e-01f, 3.70859914e-02f, -9.47825494e-04f, 1.21673398e-01f,
  -1.27534226e-01f, -1.36995718e-01f, 9.49564949e-02f, 1.86435103e-01f, -3.71910771e-03f, 7.40134642e-02f, 1.81649208e-01f, 2.66635895e-01f, 4.74062860e-01f, 4.25125003e-01f,
  1.18801638e-01f, -1.74867045e-02f, 2.75793493e-01f, -1.80668369e-01f, 2.35874340e-01f, 1.15879580e-01f, 6.21883422e-02f, -2.45231092e-01f, 1.18433692e-01f, -1.78674906e-01f,
  -1.24757327e-01f, 3.71780932e-01f, -8.13520923e-02f, 8.18558596e-03f, -7.83498883e-02f, -2.45868787e-01f, -1.68262929e-01f, -2.13668719e-01f, -1.99387949e-02f, 1.33527324e-01f,
  1.64392188e-01f, -1.41092718e-01f, -3.26346964e-01f, 1.84014097e-01f, 1.08005121e-01f, 2.90875942e-01f, 1.50915474e-01f, 7.01299310e-03f, -9.89089534e-02f, 3.33514661e-02f,
  3.03860866e-02f, 3.48059535e-01f, 2.20262170e-01f, 1.98783740e-01f, -3.80539261e-02f, 3.93296155e-04f, -3.90485451e-02f, 5.65546267e-02f, 8.09346959e-02f, -1.62324697e-01f,
  -3.12671699e-02f, 2.06764087e-01f, -7.17848092e-02f, 4.64906357e-02f, -1.40349701e-01f, -2.73489598e-02f, -7.03310082e-03f, 3.05047967e-02f, 2.55551070e-01f, 1.28227741e-01f,
  -6.39621913e-02f, 2.45054811e-02f, 2.77699500e-01f, -1.19126245e-01f, 4.11183126e-02f, -1.08756982e-01f, -8.18901062e-02f, 7.76369423e-02f, 4.89490330e-02f, 5.26858866e-03f,
  -6.60076598e-03f, -7.07337633e-02f, 6.41162321e-02f, -5.44287339e-02f, -9.32428017e-02f, -8.22602361e-02f, 4.46279906e-02f, -1.18109830e-01f, -3.89775890e-03f, 1.83448382e-02f,
  3.33420373e-02f, -1.97736830e-01f, -3.67927402e-02f, 2.93592513e-02f, -1.21554554e-01f, -5.79492897e-02f, 1.35557488e-01f, 1.66668653e-01f, -1.13203257e-01f, 1.39381394e-01f,
  -6.89417273e-02f, 6.86847046e-02f, -1.69552445e-01f, 8.85418355e-02f, -2.19596387e-03f, 9.68804508e-02f, 6.96923137e-02f, -1.14273548e-01f, 1.04950167e-01f, -5.31700924e-02f,
  1.18787915e-01f, -7.39373118e-02f, 4.02255803e-02f, -3.26179080e-02f, 1.50140733e-01f, -4.47314650e-01f, -3.23690288e-02f, -1.95724532e-01f, 3.31478417e-02f, 5.86903654e-02f,
  -6.34496585e-02f, -1.55572742e-01f, 1.47144929e-01f, 6.05448857e-02f, 5.63618764e-02f, -2.76482135e-01f, 3.76763334e-03f, 9.42189321e-02f, 1.54266255e-02f, 1.75009463e-02f,
  2.40343913e-01f, -8.45771690e-04f, -8.13754126e-02f, 1.39249057e-01f, -3.79347913e-02f, 5.53308353e-02f, -2.46085465e-01f, 7.68797174e-02f, 3.17076733e-03f, 8.97007901e-03f,
  4.87664714e-02f, -2.69136727e-01f, -3.20136435e-02f, 1.11397177e-01f, 6.75546378e-02f, 1.11272424e-01f, -1.52652934e-01f, 9.76381637e-03f, -3.36297154e-01f, 2.31809225e-02f,
  2.43238017e-01f, -3.41065824e-02f, -4.60363366e-02f, -8.01381245e-02f, -2.08098143e-01f, 1.19563892e-01f, -1.58191830e-01f, 1.62361637e-01f, 2.53377199e-01f, -1.23651542e-01f,
  1.18771449e-01f, 1.02868557e-01f, 1.85809180e-01f, -3.80067453e-02f, 2.35910535e-01f, 1.95913151e-01f, -1.83744833e-01f, -7.88886473e-02f, 9.81561542e-02f, 1.03365332e-01f,
  1.02730639e-01f, -1.67013500e-02f, 3.28755617e-01f, 1.16009019e-01f, -2.03229655e-02f, 6.69823289e-02f, -1.48886114e-01f, -1.33364290e-01f, 3.63864973e-02f, 1.37242705e-01f,
  1.87089965e-01f, 4.78051193e-02f, -1.66470408e-01f, 7.54578039e-02f, -1.80655941e-01f, 1.74189016e-01f, -8.39956626e-02f, -4.43061953e-03f, -2.07407251e-01f, -5.05929179e-02f,
  -2.36812033e-04f, -1.11687258e-01f, -1.00534014e-01f, 1.86953042e-02f, 1.14685498e-01f, -1.82757005e-02f, 9.83769447e-02f, -3.63956355e-02f, -3.23078692e-01f, -1.49369046e-01f,
  7.82194063e-02f, 1.22684591e-01f, 1.02868788e-01f, 1.66223180e-02f, -3.00386641e-02f, 9.11809504e-02f, 9.13784131e-02f, 1.32781029e-01f, 2.30227634e-01f, 1.13693371e-01f,
  -4.33497190e-01f, -1.49031565e-01f, 5.39289825e-02f, -7.36444443e-02f, -2.40669362e-02f, 4.92337160e-02f, -5.08398339e-02f, 1.46610945e-01f, 1.28292590e-02f, -2.33416229e-01f,
  -2.72521786e-02f, -8.03669915e-03f, 6.27012625e-02f, -2.22544581e-01f, 2.61260629e-01f, -1.53408602e-01f, -4.35079746e-02f, 3.60266934e-03f, 1.75048426e-01f, 4.86298539e-02f,
  4.31786440e-02f, -2.37862915e-02f, 1.04252502e-01f, 1.09391190e-01f, 2.64819473e-01f, -1.27099212e-02f, -7.39095435e-02f, 4.76606190e-02f, -1.76468328e-01f, 1.78259775e-01f,
  -6.65318891e-02f, -1.61493853e-01f, 3.77195179e-02f, 5.54659851e-02f, 1.16566531e-01f, 1.66809052e-01f, 1.12846337e-01f, -1.42668426e-01f, 5.83754890e-02f, 2.08748266e-01f,
  -1.36928916e-01f, 4.26612757e-02f, 1.16647743e-01f, -1.21564262e-01f, 1.90266743e-01f, -9.99065116e-02f, -3.13326180e-01f, 3.92144412e-01f, 2.13684258e-03f, 3.64684649e-02f,
  -5.06568514e-02f, -5.43761775e-02f, -4.96940538e-02f, 1.28043620e-02f, -2.00711206e-01f, -4.02729288e-02f, -1.77071542e-01f, 1.86106220e-01f, 3.12885754e-02f, 1.96236730e-01f,
  1.58655897e-01f, 4.49233837e-02f, 1.48297012e-01f, -1.07018456e-01f, -1.14147395e-01f, -2.88651496e-01f, 6.16182052e-02f, -2.72993296e-01f, 2.76420593e-01f, 2.74113324e-02f,
  -5.76152140e-03f, 1.14115097e-01f, -8.16156864e-02f, -5.73292971e-02f, 2.36728899e-02f, -8.51019025e-02f, -8.31437632e-02f, 8.17224383e-02f, 1.38019234e-01f, 3.43117714e-02f,
  -9.82797667e-02f, 1.50683358e-01f, -1.43732578e-01f, -5.55106476e-02f, -1.25346884e-01f, -5.12536988e-02f, 1.52575359e-01f, -1.12232640e-02f, 1.97864041e-01f, -1.05076514e-01f,
  -2.37485334e-01f, 1.13574371e-01f, -5.43227606e-02f, -1.17686860e-01f, -1.93532351e-02f, -1.07583553e-01f, 1.37380838e-01f, -3.18280935e-01f, -2.84308821e-01f, 2.23503187e-01f,
  8.19756556e-03f, 1.68623216e-02f, 7.93283954e-02f, -1.13429315e-02f, 2.42436081e-02f, 4.73847613e-04f, 8.94300342e-02f, -5.86546697e-02f, 2.47922644e-01f, -8.14186558e-02f,
  -4.20645386e-01f, 5.52502386e-02f, 5.49166761e-02f, 2.08166823e-01f, -1.56295136e-01f, -7.04512931e-03f, -4.26242575e-02f, 1.51717907e-03f, -3.64479184e-01f, -1.23153776e-01f,
  -6.77376613e-02f, 7.62708485e-02f, 1.03870086e-01f, 6.91464096e-02f, 1.01576276e-01f, -8.37535132e-03f, 3.25222522e-01f, 3.78114015e-01f, 3.76989037e-01f, 5.71016848e-01f,
  5.49005270e-01f, -5.00628650e-01f, 3.10435832e-01f, -1.99754704e-02f, 1.83908150e-01f, -1.23378150e-01f, -1.93397105e-01f, -2.37873897e-01f, 1.74619019e-01f, 1.96259364e-01f,
  -1.97195890e-03f, -2.10615009e-01f, -3.32293063e-01f, -1.66328192e-01f, -1.17381684e-01f, -1.40300840e-02f, -5.07329404e-03f, -1.01475403e-01f, 3.85856219e-02f, 1.39450252e-01f,
  -6.37952015e-02f, -8.75357480e-04f, -1.94120973e-01f, 6.37757704e-02f, -1.08641438e-01f, 2.34966978e-01f, -2.21661761e-01f, 1.21597424e-01f, 1.19894966e-01f, 2.32037634e-01f,
  -1.05605684e-01f, 5.78023866e-02f, 6.83818758e-02f, -5.15340455e-02f, -7.04348609e-02f, -4.25936043e-01f, -1.37199098e-02f, 1.86383471e-01f, -1.31585836e-01f, 1.95057333e-01f,
  -1.36229694e-01f, -3.60835642e-02f, -1.28386483e-01f, 1.89610094e-01f, -6.20346935e-03f, 7.97666684e-02f, -4.85234976e-01f, -1.00515462e-01f, 2.28175625e-01f, 1.02326415e-01f,
  1.25507236e-01f, -2.16463089e-01f, -3.15096080e-02f, -7.26397857e-02f, 1.17117614e-02f, 2.13907748e-01f, -5.04757203e-02f, 9.22171250e-02f, -4.77450527e-03f, 7.75543973e-02f,
  1.16572464e-02f, -9.24181268e-02f, 1.78526983e-01f, -1.14384152e-01f, 3.43193173e-01f, -3.57580036e-01f, 2.48173699e-01f, -2.03575283e-01f, -2.39492908e-01f, 9.84384585e-03f,
  -2.12028190e-01f, -2.37435415e-01f, -6.73296256e-03f, -1.04040399e-01f, -4.18190584e-02f, 2.78845057e-02f, 1.39423013e-01f, -3.50230485e-02f, -1.72946349e-01f, 2.65621692e-01f,
  -1.65737681e-02f, -2.90609077e-02f, 1.52337268e-01f, 7.54921362e-02f, 1.83454044e-02f, 2.96266135e-02f, 1.21772684e-01f, 2.94156913e-02f, -3.73283625e-01f, -4.27045785e-02f,
  2.41081044e-01f, -4.62210119e-01f, 8.10758397e-02f, -3.70684639e-02f, 6.93447739e-02f, -3.36992055e-01f, -4.19475555e-01f, -7.44447485e-02f, -9.59667638e-02f, 1.42897010e-01f,
  -7.85763375e-03f, 5.59929721e-02f, 1.07584940e-02f, 1.91259056e-01f, 1.21788338e-01f, -1.49920776e-01f, 2.24722356e-01f, 2.06322316e-02f, -2.53848523e-01f, -2.55387396e-01f,
  1.23908721e-01f, 1.57723755e-01f, -9.79054794e-02f, 1.01593301e-01f, -1.08558886e-01f, 1.39642656e-01f, -3.86359662e-01f, -1.69737160e-01f, 1.23405904e-01f, -2.03044396e-02f,
  -4.20932844e-02f, 1.13724217e-01f, 1.70704156e-01f, -2.59774434e-03f, 2.19156548e-01f, 5.14151715e-02f, -2.63023496e-01f, -1.47663414e-01f, -2.62274802e-01f, -2.55650580e-01f,
  1.69955999e-01f, 2.55284727e-01f, -2.23310083e-01f, 1.80486783e-01f, -4.97245103e-01f, -1.58922359e-01f, -2.21566394e-01f, 1.31992072e-01f, 1.99001923e-01f, -1.81948975e-01f,
  1.74153864e-01f, -6.72251955e-02f, 1.41816884e-01f, 1.58822894e-01f, 1.06772572e-01f, 1.25636026e-01f, 7.09547922e-02f, 3.86998132e-02f, 1.51153564e-01f, -3.88541371e-02f,
  2.19145060e-01f, -1.81615740e-01f, -1.50408387e-01f, 1.61012977e-01f, -6.67289644e-02f, -1.69047579e-01f, -9.55196917e-02f, -2.28050873e-01f, -8.92237276e-02f, -3.50179002e-02f,
  -4.91522640e-01f, 3.15904051e-01f, -5.08834496e-02f, -1.88407063e-01f, 1.26797482e-01f, 8.48302543e-02f, -1.58001244e-01f, 7.64619783e-02f, -7.76787177e-02f, -1.14128413e-02f,
  1.01035573e-01f, -1.03202179e-01f, -4.88595068e-01f, 3.33902031e-01f, -4.86977049e-04f, 4.76028956e-02f, -2.37187464e-02f, -2.47287050e-01f, -4.35696207e-02f, -1.87975526e-01f,
  -3.12102228e-01f, -7.21127167e-02f, 2.12772369e-01f, -2.50322726e-02f, 3.23574871e-01f, 1.85490415e-01f, 1.66530609e-01f, -2.46961974e-02f, 1.37842402e-01f, 2.12418228e-01f,
  -2.58030981e-01f, -1.20342888e-01f, 1.22790754e-01f, -1.56572741e-02f, 6.49888068e-02f, 5.41723333e-02f, 7.37410411e-02f, -1.87880784e-01f, -1.12026399e-02f, 3.22035462e-01f,
  -7.63656348e-02f, 1.58855971e-02f, 2.05818161e-01f, -8.84209648e-02f, 3.18589583e-02f, -4.28185472e-03f, 3.89114469e-02f, -1.45127950e-02f, 2.32815698e-01f, 1.62138730e-01f,
  -3.59013379e-02f, -3.99967022e-02f, 6.69664191e-03f, 1.02959640e-01f, 2.01477273e-03f, -5.77710681e-02f, 2.60398239e-01f, -1.78624108e-01f, 3.41232121e-02f, 1.08818509e-01f,
  -9.04176086e-02f, 8.19907337e-02f, -3.34397145e-02f, 6.10031709e-02f, 6.84286430e-02f, -1.65604517e-01f, -1.49124991e-02f, -2.86477715e-01f, -9.11350623e-02f, 2.85150707e-01f,
  -1.89002827e-01f, 1.75714716e-01f, 2.29412578e-02f, 1.17541879e-01f, -1.81169789e-02f, -1.97593421e-02f, -4.75082695e-02f, -8.32470208e-02f, 1.40461951e-01f, 1.55857364e-02f,
  -2.06012502e-02f, -9.52472091e-02f, 7.41436705e-02f, -8.22867826e-03f, 7.74784610e-02f, 4.85248342e-02f, -6.61402419e-02f, 1.44878909e-01f, 2.99052715e-01f, -5.83147220e-02f,
  1.10882670e-01f, 3.60414088e-01f, 3.02194953e-01f, 2.60155916e-01f, 1.45385608e-01f, 2.87345529e-01f, 4.68122154e-01f, -1.19394206e-01f, 1.08296201e-01f, -2.78268278e-01f,
  3.12097408e-02f, -5.99855296e-02f, 2.59536922e-01f, -5.43346703e-01f, 4.42223474e-02f, 1.34360269e-01f, -1.12794891e-01f, -5.52325621e-02f, 1.35180041e-01f, 1.18371040e-01f,
  -2.35214084e-01f, -2.12547824e-01f, -9.93746147e-02f, 1.46474376e-01f, -6.10540714e-03f, 2.56849706e-01f, 4.10297737e-02f, 1.13397717e-01f, -1.05192505e-01f, 1.24511667e-01f,
  -1.31429657e-01f, 1.37545075e-02f, 1.55213535e-01f, -2.50396188e-02f, -2.27032363e-01f, 6.68743104e-02f, 2.82672763e-01f, 3.52670282e-01f, 1.21250562e-01f, 1.19848862e-01f,
  3.11592728e-01f, 2.41522212e-02f, -8.51630941e-02f, -2.39819959e-01f, -4.10206839e-02f, -6.90186545e-02f, 2.30031937e-01f, 2.02225849e-01f, 3.69154140e-02f, -1.42228052e-01f,
  -6.07109442e-02f, -6.08167313e-02f, 3.12018637e-02f, 2.14673251e-01f, 1.83709815e-01f, 2.77714759e-01f, -1.81123301e-01f, -1.81398138e-01f, 1.56756595e-01f, 9.76407900e-02f,
  -1.42031506e-01f, 1.17373310e-01f, 3.90565544e-02f, -1.55203510e-02f, 1.87250208e-02f, 1.07845739e-01f, 1.41247720e-01f, 5.48835173e-02f, 7.50830695e-02f, -1.89928692e-02f,
  -4.92110401e-02f, -1.47576854e-01f, 2.71721184e-01f, -2.34678492e-01f, 7.68164312e-03f, -7.42460564e-02f, -2.16811165e-01f, -2.51286328e-01f, 6.17868379e-02f, -1.77552521e-01f,
  -2.30428666e-01f, 1.05612382e-01f, 1.27160072e-01f, -1.43487632e-01f, -5.94289452e-02f, 1.05414260e-02f, -2.33752847e-01f, 7.35981315e-02f, 2.14845072e-02f, 8.76609534e-02f,
  1.56027690e-01f, 4.85399738e-02f, 8.19598213e-02f, -4.74992245e-02f, -1.22105457e-01f, 1.23263896e-01f, 2.70262826e-02f, -1.36544704e-01f, -2.92073525e-02f, 7.32501820e-02f,
  1.63438737e-01f, -1.27113521e-01f, -1.38114274e-01f, -1.94453567e-01f, -1.67321637e-01f, 2.15662252e-02f, -6.03607111e-02f, -1.60838231e-01f, 7.13960975e-02f, 1.75779209e-01f,
  -6.88688364e-03f, -8.00958648e-02f, 3.39340977e-02f, -4.23771404e-02f, -3.86402994e-01f, -6.44161403e-02f, 7.98404589e-02f, 3.15767229e-02f, -9.54639260e-03f, 1.54298127e-01f,
  -1.48284525e-01f, -2.67620057e-01f, -1.78254142e-01f, -4.66984808e-02f, -4.97185327e-02f, -1.38492212e-01f, 1.81192622e-01f, 2.52954513e-02f, 1.15296088e-01f, 2.73437053e-01f,
  1.41843975e-01f, 1.91730067e-01f, -2.92684644e-01f, -2.21316919e-01f, 7.34213460e-03f, -2.02811316e-01f, -7.71731436e-02f, -8.41475651e-02f, 7.05202222e-02f, 5.05200624e-02f,
  -4.75744642e-02f, -3.87965441e-01f, -8.60334467e-03f, -1.44624978e-01f, -6.90317200e-03f, -7.85316452e-02f, 6.25558989e-03f, -5.44266682e-03f, -1.07154706e-02f, -2.29592435e-02f,
  -1.38353094e-01f, -1.28294956e-02f, -3.03460062e-02f, -7.16050193e-02f, 2.60354602e-03f, 4.16724160e-02f, 1.84144408e-01f, -1.60837948e-01f, -1.58365577e-01f, -1.66762382e-01f,
  -3.17505077e-02f, 1.72080606e-01f, -3.58976752e-01f, -2.16003194e-01f, 9.66430753e-02f, -1.14164494e-01f, 7.85971284e-02f, -4.18886868e-03f, 1.00813322e-01f, -1.87475756e-01f,
  -1.03712223e-01f, -2.57410631e-02f, -7.21652582e-02f, 7.91239440e-02f, 1.28427461e-01f, 1.14495113e-01f, 1.05117887e-01f, -1.02983966e-01f, -2.37874508e-01f, 2.07207724e-01f,
  6.36982471e-02f, 2.42077708e-01f, -4.20998875e-03f, 1.56464949e-01f, -1.30536109e-01f, -3.28952134e-01f, -3.50290537e-02f, 8.44035521e-02f, -2.91271150e-01f, -1.50254607e-01f,
  2.32647136e-01f, 1.22764735e-02f, 3.85443777e-01f, 2.04157755e-01f, 3.32049340e-01f, 1.40489116e-01f, 6.36417940e-02f, 1.21828824e-01f, 8.09715912e-02f, 9.67503935e-02f,
  -2.28829905e-01f, -1.22254066e-01f, 3.34032811e-02f, 8.21048915e-02f, 4.23628613e-02f, -1.68409377e-01f, 6.28241748e-02f, 7.00269789e-02f, 1.01131618e-01f, -7.55103864e-03f,
  -2.05649793e-01f, -2.14371711e-01f, -2.07887903e-01f, -1.52372897e-01f, -2.20969886e-01f, -1.83240935e-01f, 1.59058481e-01f, 1.75012276e-01f, 1.53713509e-01f, -2.31284022e-01f,
  5.81100956e-02f, 3.62917292e-03f, -1.35897949e-01f, 1.14775799e-01f, -7.26696253e-02f, 1.28421143e-01f, -2.13002607e-01f, 2.13954091e-01f, -1.93982586e-01f, 4.42079574e-01f,
  3.05006444e-01f, 1.31399065e-01f, 1.42672330e-01f, -9.81567129e-02f, -1.27453757e-02f, -1.32066682e-01f, -1.85682669e-01f, -1.95325732e-01f, 1.88016333e-03f, 2.80020624e-01f,
  -2.02852432e-02f, -2.38472134e-01f, 3.59273627e-02f, 8.21005404e-02f, -2.82414377e-01f, 1.90134823e-01f, 1.48279220e-01f, 4.51478222e-03f, -6.23381510e-02f, -1.60644606e-01f,
  1.42755747e-01f, -2.96621341e-02f, 1.28369138e-01f, 1.52783781e-01f, 2.13391140e-01f, 2.43482336e-01f, -1.18761942e-01f, 1.37977719e-01f, 9.46753249e-02f, 7.57220164e-02f,
  3.16000581e-02f, -1.76168427e-01f, -1.62707984e-01f, -6.52998313e-02f, 2.62327582e-01f, -6.09011613e-02f, 4.02398454e-03f, 1.11255243e-01f, 6.28617927e-02f, -1.63377315e-01f,
  -8.17856193e-02f, -9.26404372e-02f, -1.83406398e-01f, -2.62394279e-01f, 1.00976355e-01f, 1.78957544e-02f, -3.20170999e-01f, 9.47951600e-02f, -3.06521133e-02f, 1.78527161e-01f,
  -1.21605722e-02f, 6.02946058e-02f, 7.09878951e-02f, -1.13945648e-01f, -5.62050194e-03f, -1.31562203e-01f, -1.28872115e-02f, 5.01406863e-02f, 2.46729672e-01f, -1.55629173e-01f,
  2.12566212e-01f, 1.56913176e-01f, 1.30232826e-01f, -3.47186416e-01f, -6.86160028e-02f, -3.15681934e-01f, 1.01781517e-01f, -1.09366350e-01f, 6.92402245e-03f, -5.22754267e-02f,
  -7.63839530e-03f, 8.99549574e-02f, -1.63718373e-01f, -2.93923281e-02f, -1.25942960e-01f, 3.59143429e-02f, 6.96065351e-02f, 2.33701259e-01f, 9.95721817e-02f, 2.06636816e-01f,
  -2.34527200e-01f, -2.10679006e-02f, -1.76683366e-01f, 1.30933151e-02f, 9.64891538e-02f, 8.63042753e-03f, -9.51306745e-02f, 3.25367115e-02f, 4.00911272e-02f, -2.07587555e-01f,
  1.27914120e-02f, 1.92316487e-01f, 1.22567609e-01f, -6.06144704e-02f, 2.58431733e-02f, 1.31725594e-01f, 3.84158880e-01f, 8.13003778e-02f, -2.23831795e-02f, -2.19863951e-01f,
  -7.02228099e-02f, -3.73113751e-02f, -2.22177640e-01f, -1.72018260e-01f, 3.51180434e-01f, 1.92994639e-01f, 1.97678238e-01f, -2.33359978e-01f, 2.38600701e-01f, -1.05881184e-01f,
  2.38307640e-01f, 1.27933621e-01f, -2.27807015e-02f, 6.78985864e-02f, 1.44130483e-01f, 1.50630446e-02f, 7.77739212e-02f, 4.22674827e-02f, 5.29255196e-02f, 2.34178990e-01f,
  -1.53419286e-01f, -1.35070626e-02f, -2.30076909e-01f, 6.29394129e-02f, 1.38268605e-01f, 2.42328674e-01f, 2.70786732e-01f, -1.00901559e-01f, -3.84328067e-02f, -2.40079314e-01f,
  2.54274815e-01f, 7.05348402e-02f, -3.54294255e-02f, 1.58407956e-01f, 1.56699717e-01f, 6.53882921e-02f, 1.88979596e-01f, -1.45345047e-01f, 2.19188500e-02f, 2.29794860e-01f,
  -6.07074834e-02f, -9.67766196e-02f, -6.99587241e-02f, -3.63294072e-02f, 1.12688616e-01f, -5.52306250e-02f, 2.81958580e-01f, -1.47566482e-01f, -2.68900186e-01f, -2.24307310e-02f,
  -2.11249515e-01f, 6.40186891e-02f, 1.20223001e-01f, 9.20095965e-02f, 2.09949598e-01f, 1.64565206e-01f, 8.38730037e-02f, 7.18099400e-02f, 4.25721258e-02f, -1.42078668e-01f,
  -1.65933490e-01f, -2.60737777e-01f, 1.73551112e-01f, 2.51431346e-01f, -8.15618485e-02f, 2.52884626e-01f, -2.72513628e-01f, -3.23748887e-02f, -2.50258148e-01f, 4.11879234e-02f,
  2.53379107e-01f, -2.51274586e-01f, 1.04569301e-01f, -1.97030097e-01f, -1.93061233e-02f, 1.79989159e-01f, 3.66249345e-02f, 3.37849669e-02f, 1.95737451e-01f, 1.42891005e-01f,
  2.52069354e-01f, -1.09276041e-01f, 2.58252323e-01f, -6.61324337e-02f, -3.28885257e-01f, 1.48240387e-01f, 1.44973189e-01f, -2.09242076e-01f, 1.91073269e-01f, -8.63603875e-03f,
  6.12021238e-02f, 7.00220689e-02f, -2.69564420e-01f, 3.75219703e-01f, -1.58276379e-01f, -2.54750878e-01f, 2.90804863e-01f, -1.98522061e-01f, -1.16702225e-02f, 1.64781615e-01f,
  4.03605625e-02f, 3.66209969e-02f, 1.49970233e-01f, -1.38807029e-01f, 1.85864849e-03f, 1.15862228e-01f, -3.08906590e-03f, 1.90698311e-01f, -2.23294795e-01f, 1.71063155e-01f,
  -1.38614535e-01f, 9.97833535e-02f, -4.89117876e-02f, -1.25579551e-01f, 1.78663030e-01f, 1.92773417e-01f, 1.14307910e-01f, -6.03020713e-02f, 2.36564070e-01f, 5.96838351e-03f,
  6.07605986e-02f, 1.20931208e-01f, 3.11347038e-01f, -1.23486646e-01f, -3.64688337e-02f, -6.15290999e-02f, 6.15814850e-02f, 7.15867653e-02f, -2.55518127e-02f, -1.29956350e-01f,
  3.91023979e-02f, -2.43900381e-02f, -7.90055767e-02f, -2.42183700e-01f, 4.07781824e-02f, -5.90732833e-03f, -1.05824031e-01f, 4.90296260e-02f, -1.30535603e-01f, 4.51111645e-02f,
  -2.74287701e-01f, -1.86326310e-01f, 1.48502201e-01f, 1.43699020e-01f, 1.25394091e-01f, 1.26424849e-01f, -5.74733168e-02f, 1.54438093e-01f, -2.38298312e-01f, 1.20441698e-01f,
  6.37362599e-02f, -3.05907965e-01f, 3.19827229e-01f, 2.24510074e-01f, 2.19506368e-01f, -3.82958278e-02f, -1.92104012e-01f, 1.11386545e-01f, -3.18835646e-01f, -1.65349334e-01f,
  2.32415900e-01f, 1.06742466e-02f, 1.00745454e-01f, 1.82871982e-01f, 7.39639550e-02f, 2.32365653e-01f, 7.21655041e-02f, 1.27426684e-01f, -1.85676794e-02f, -3.39017928e-01f,
  -1.03310511e-01f, 1.53420210e-01f, -1.59044322e-02f, -5.10903001e-02f, -2.72405386e-01f, 6.56482354e-02f, -5.64381666e-02f, -2.30473101e-01f, 2.17821226e-01f, -4.39553484e-02f,
  2.21120089e-01f, -2.54036319e-02f, 1.37836546e-01f, 3.10524940e-01f, 3.50847065e-01f, 3.15902054e-01f, 1.10693395e-01f, 3.74719262e-01f, 2.82631189e-01f, -6.62447736e-02f,
  3.83842811e-02f, 9.22719948e-04f, 3.95924374e-02f, -1.28590599e-01f, 1.51066920e-02f, -3.37110430e-01f, 7.71093145e-02f, -3.02985787e-01f, -7.42409453e-02f, -3.54954422e-01f,
  -4.07926977e-01f, -1.89113468e-01f, -3.11601073e-01f, -2.70336214e-03f, -5.90965413e-02f, -1.52239233e-01f, -5.53729236e-02f, 2.51697570e-01f, -2.06217729e-02f, 4.73649129e-02f,
  1.54628686e-03f, -7.08523765e-02f, -4.76804256e-01f, 1.68905452e-01f, -1.21520191e-01f, -7.64497593e-02f, -1.51858866e-01f, 8.64295736e-02f, -2.97988981e-01f, 1.55953303e-01f,
  -6.45917729e-02f, 2.21186295e-01f, 2.38135271e-02f, -4.82127905e-01f, 8.00506100e-02f, -2.27157056e-01f, -2.75822043e-01f, 7.67592620e-03f, 7.79156312e-02f, 5.86941130e-02f,
  -1.91043988e-01f, -1.72706053e-01f, 9.53351110e-02f, -3.77959423e-02f, -6.32911384e-01f, -3.05478480e-02f, 1.39614478e-01f, 8.01369846e-02f, -2.69093871e-01f, -1.39456661e-02f,
  6.96841627e-02f, -3.17037821e-01f, 2.31935889e-01f, -7.01137632e-02f, -1.56457081e-01f, -5.65939806e-02f, 2.11610794e-01f, -1.51835278e-01f, -1.08113997e-01f, -3.35673273e-01f,
  6.65418431e-02f, -5.79891205e-02f, 2.58209910e-02f, 9.06440318e-02f, -1.94369689e-01f, -1.60259485e-01f, -1.18803963e-01f, -1.44328192e-01f, 7.73289474e-03f, 1.62646156e-02f,
  3.22732754e-04f, 1.51624054e-01f, -1.05020339e-02f, 2.01446787e-01f, 5.54118231e-02f, 2.11848691e-01f, 7.69682676e-02f, 2.78037284e-02f, -6.49134591e-02f, -2.38895677e-02f,
  -3.67943168e-01f, 2.63258610e-02f, 1.93613634e-01f, 4.12284173e-02f, -1.38503417e-01f, 6.13491517e-03f, -1.25419319e-01f, -2.41406132e-02f, 3.52080725e-02f, -1.81660041e-01f,
  -3.29806190e-03f, -9.24890395e-03f, 9.41463709e-02f, -2.24021912e-01f, 5.19688763e-02f, 3.30622457e-02f, -5.36592305e-02f, 2.73462236e-01f, -3.57544124e-01f, 1.15515999e-02f,
  2.31214345e-01f, 1.34164002e-02f, 1.18505754e-01f, -2.91874260e-01f, 9.62588750e-03f, -1.72047377e-01f, -1.94409490e-01f, -1.74909100e-01f, 1.03129245e-01f, -1.96570024e-01f,
  -1.06976628e-01f, -2.78024942e-01f, 8.91234353e-02f, 9.09610912e-02f, -1.66706920e-01f, 8.64108205e-02f, -9.48082656e-02f, -8.97871181e-02f, 4.71116155e-02f, 2.32336789e-01f,
  -7.61031285e-02f, 1.02364168e-01f, 1.13585375e-01f, -4.78354432e-02f, -3.83515321e-02f, 7.42955506e-02f, -8.14598054e-02f, -1.67499900e-01f, 1.14751101e-01f, -8.18130523e-02f,
  5.48378825e-02f, -8.89004692e-02f, -1.33601144e-01f, -4.20187414e-03f, -4.09136474e-01f, 4.73975055e-02f, 1.97693318e-01f, 1.61140546e-01f, 1.38227835e-01f, 1.56298742e-01f,
  1.58106327e-01f, -4.65641133e-02f, 2.16624409e-01f, 1.01011977e-01f, -1.48824066e-01f, -9.19260159e-02f, 1.61747307e-01f, 1.48620099e-01f, 4.05416638e-02f, -1.08639998e-02f,
  3.98097992e-01f, 7.79948458e-02f, -4.74586040e-02f, 2.46010292e-02f, -2.43329536e-02f, -5.26862256e-02f, 2.00511381e-01f, -1.70024320e-01f, 3.71436030e-02f, -8.05227458e-03f,
  -9.89382043e-02f, -2.62154043e-02f, -7.50422105e-02f, 1.26937643e-01f, -2.04570889e-02f, 1.11182339e-01f, -4.59305681e-02f, 1.28685236e-01f, 5.82516640e-02f, -2.04213202e-01f,
  -1.16478033e-01f, -1.69244751e-01f, 2.51192540e-01f, -2.90035456e-02f, 7.91855454e-02f, 6.79218695e-02f, -2.19202027e-01f, -1.59962296e-01f, -2.30257064e-01f, 1.98001452e-02f,
  1.09219790e-01f, -6.89049885e-02f, 4.77804430e-03f, -9.95180458e-02f, -7.46112177e-03f, -2.08564565e-01f, -1.30374953e-01f, -8.21029618e-02f, 2.36124486e-01f, 2.98291206e-01f,
  2.32105151e-01f, -2.07738236e-01f, -3.57207805e-02f, -1.48173302e-01f, -1.07498817e-01f, -2.19412595e-02f, -1.37317032e-01f, -5.25994562e-02f, 1.78669780e-01f, 1.94540441e-01f,
  -4.45971452e-02f, 4.89785448e-02f, 1.44299939e-01f, 9.55858976e-02f, -8.65382105e-02f, -7.64820576e-02f, -1.19861066e-01f, 2.36784341e-03f, -1.47529349e-01f, 9.21747983e-02f,
  4.69171889e-02f, 1.07828341e-01f, -2.86628336e-01f, 6.69507822e-03f, -3.54917930e-03f, 4.97781038e-02f, -9.21939164e-02f, -8.70451927e-02f, 5.34461178e-02f, 1.33364126e-01f,
  3.00456826e-02f, -9.15375352e-02f, 5.04085515e-03f, -1.16002448e-01f, 4.48013283e-02f, 3.60414118e-01f, -2.50444543e-02f, 3.54095688e-03f, 1.27895951e-01f, 1.00760035e-01f,
  1.37296095e-01f, -1.48275167e-01f, -1.22417495e-01f, -6.97490349e-02f, -1.28752306e-01f, -2.38841504e-01f, 6.15023263e-02f, -1.95355177e-01f, 1.03050150e-01f, -4.47276309e-02f,
  1.61643952e-01f, 1.12355180e-01f, -1.34796752e-02f, 3.89046408e-02f, 8.22608620e-02f, -6.34200945e-02f, 7.36407042e-02f, 9.95290875e-02f, 1.61152139e-01f, 2.32312791e-02f,
  9.61505696e-02f, 1.80093676e-01f, 1.20393082e-01f, 2.03159764e-01f, 4.77382571e-01f, -3.37100178e-01f, 6.48531169e-02f, -1.53000444e-01f, 4.58633937e-02f, 2.53913403e-01f,
  2.85518114e-02f, -3.44411403e-01f, 2.62847487e-02f, -7.15877637e-02f, 1.46330371e-01f, 1.11404937e-02f, -1.51722178e-01f, 1.34852156e-02f, 5.20790853e-02f, -4.97787297e-02f,
  -4.41024333e-01f, -1.49261773e-01f, 1.47244008e-02f, 2.58384719e-02f, 5.30114919e-02f, 7.52511546e-02f, -1.83494627e-01f, 2.31418293e-02f, -1.34091824e-01f, 1.26795501e-01f,
  -1.13588490e-01f, 1.12339146e-02f, -2.25844413e-01f, -1.38676420e-01f, -6.06127344e-02f, 2.55333781e-01f, 1.35127246e-01f, 7.99079239e-02f, -2.77684070e-02f, -2.43298933e-01f,
  1.19805932e-01f, 8.53612572e-02f, 4.28993404e-02f, -1.31246045e-01f, 1.40970722e-01f, 2.35063791e-01f, 2.11157024e-01f, -1.95857346e-01f, -2.10104465e-01f, -2.49942780e-01f,
  -5.30759208e-02f, 1.45937458e-01f, 5.00878878e-02f, 1.05235599e-01f, 1.79801807e-02f, -8.35943818e-02f, -1.60305560e-01f, -9.27087590e-02f, 5.84384501e-02f, -6.01968654e-02f,
  7.63698071e-02f, 1.91078976e-01f, 7.55011067e-02f, 2.40622774e-01f, -4.68634907e-03f, 1.97568424e-02f, -1.34570375e-01f, -1.85226470e-01f, -4.73737977e-02f, -8.07562377e-03f,
  -1.50957808e-01f, -7.36710578e-02f, -5.00486568e-02f, -1.24256589e-01f, 1.84890971e-01f, -3.89126599e-01f, 7.17925951e-02f, -4.83766310e-02f, -8.22729394e-02f, 2.48261243e-02f,
  1.98650490e-02f, 1.56709969e-01f, 8.95267725e-02f, 7.87223428e-02f, -2.29268875e-02f, 2.34286621e-01f, 1.63622238e-02f, 5.03202938e-02f, 4.91339602e-02f, 1.01191066e-01f,
  -2.97727752e-02f, 6.95659667e-02f, -3.64422053e-02f, -1.36609524e-01f, 1.95812657e-01f, -8.76954719e-02f, -1.32100701e-01f, -1.83399275e-01f, 3.68454278e-01f, -1.86944276e-01f,
  9.29104984e-02f, -2.32650906e-01f, 2.65004814e-01f, 2.94911653e-01f, -9.31660458e-03f, -2.06657842e-01f, 1.64329901e-01f, 8.94161984e-02f, -2.73818057e-02f, 3.28953527e-02f,
  1.24838836e-01f, 3.94262411e-02f, 9.67373997e-02f, -3.61806005e-02f, 1.96636185e-01f, 4.91842628e-02f, 5.14416769e-02f, 1.15096673e-01f, -1.42346427e-01f, 1.30316047e-02f,
  -1.55722857e-01f, 1.31708339e-01f, -3.24548393e-01f, -1.98201627e-01f, 3.15190345e-01f, 2.67595887e-01f, 1.31377757e-01f, 4.65147227e-01f, 2.67294437e-01f, 3.44542086e-01f,
  -1.98564306e-01f, -7.22107589e-02f, -2.30596274e-01f, -9.87382531e-02f, 2.52133310e-01f, 1.35512864e-02f, -4.26322073e-02f, -1.19105764e-01f, 1.92452639e-01f, -7.68875331e-02f,
  -2.20155954e-01f, -3.10598433e-01f, 1.04021825e-01f, -6.24951720e-02f, 6.21125661e-03f, -4.23095841e-03f, -1.22871570e-01f, -1.02165639e-01f, 2.95316335e-02f, 1.00525282e-02f,
  -1.23689063e-02f, 1.19576834e-01f, 1.27257347e-01f, -1.04873814e-02f, 4.72308621e-02f, 4.88604940e-02f, -3.82697359e-02f, -1.42573163e-01f, 1.86372280e-01f, -2.14401931e-01f,
  -1.96905419e-01f, 1.27503246e-01f, 4.53210250e-02f, 3.65775898e-02f, 1.19729489e-01f, 4.08789283e-03f, -2.86900520e-01f, -1.96418092e-01f, -4.01431285e-02f, -3.37062366e-02f,
  -1.47561476e-01f, 3.00056506e-02f, -1.22928791e-01f, 2.09581420e-01f, -6.29447773e-02f, -3.53905052e-01f, 1.65233582e-01f, -8.11420605e-02f, -1.86450481e-02f, 1.59556687e-01f,
  1.15136504e-01f, 1.03933010e-02f, -2.50421137e-01f, -1.70232654e-01f, 2.31477246e-01f, -2.12358624e-01f, -2.41353805e-03f, -1.01888083e-01f, -2.77995989e-02f, -7.12847039e-02f,
  1.22722045e-01f, -8.43637064e-02f, 7.12579936e-02f, -1.76751055e-04f, -1.44013733e-01f, 6.03785627e-02f, 1.06010616e-01f, -3.40816230e-02f, -2.45576128e-01f, -2.33997390e-01f,
  -5.10873878e-03f, -1.80714577e-02f, 7.43547752e-02f, -1.06780559e-01f, 1.96954589e-02f, 9.84114856e-02f, -4.65492113e-03f, 1.66259389e-02f, 1.44594848e-01f, 7.15372637e-02f,
  -1.45303560e-02f, -1.73313454e-01f, -2.86951568e-02f, -8.46650102e-04f, -7.36832172e-02f, 1.10721491e-01f, 1.42090008e-01f, 4.11047637e-02f, -2.22893685e-01f, -1.14434823e-01f,
  -2.13912651e-02f, 5.36797568e-02f, -6.10436685e-02f, 2.22836018e-01f, -1.44294783e-01f, -1.14201516e-01f, 1.55102521e-01f, 2.92524509e-03f, 1.32111713e-01f, -1.67733446e-01f,
  1.75642103e-01f, 1.79051265e-01f, -3.01475495e-01f, 1.06509179e-01f, -6.23917766e-02f, -3.48637928e-03f, 3.30106951e-02f, -1.08583532e-01f, -5.06395996e-02f, -1.90523982e-01f,
  2.48314766e-03f, 9.76626724e-02f, 6.96238130e-02f, -1.21139646e-01f, 1.62713021e-01f, 6.76294342e-02f, 1.62351802e-01f, 1.18692815e-01f, -2.37919111e-02f, -1.14972882e-01f,
  -2.17333853e-01f, 8.89745355e-03f, 1.53218180e-01f, 1.14077039e-01f, 4.36237454e-01f, -2.99067702e-02f, 2.45089248e-01f, -7.50936493e-02f, -7.72865266e-02f, 7.13585913e-02f,
  2.57046130e-02f, 3.09006155e-01f, -3.38261962e-01f, 2.61288255e-01f, 1.21431239e-01f, 3.72121669e-02f, 9.99620855e-02f, 1.21688947e-01f, -7.33882636e-02f, 1.95772015e-02f,
  -5.86257055e-02f, -1.93066001e-01f, -2.20499367e-01f, -1.22036278e-01f, -1.68075442e-01f, 1.14651129e-01f, -1.43372165e-02f, -2.25653842e-01f, 1.98961586e-01f, 8.30561295e-02f,
  1.44738898e-01f, -1.30167216e-01f, -9.90473852e-02f, -2.09394153e-02f, -1.93192363e-01f, 2.99972557e-02f, 2.58189917e-01f, 3.27655189e-02f, 6.16701506e-02f, 2.67595142e-01f,
  -3.30405235e-01f, 2.07894802e-01f, -6.56998381e-02f, 2.74290442e-02f, 1.38220675e-02f, -3.89868170e-01f, 1.28911778e-01f, 1.32294476e-01f, -4.71103966e-01f, -7.62192383e-02f,
  -1.46103814e-01f, 2.27306485e-01f, 7.38842711e-02f, -2.13236377e-01f, 2.47151718e-01f, 9.83659625e-02f, -5.40719926e-01f, 5.87107204e-02f, -1.15086891e-01f, -1.09897710e-01f,
  1.01852320e-01f, 2.23617747e-01f, 1.34088889e-01f, 1.05344756e-02f, -9.99913272e-03f, 2.53704309e-01f, 1.05920807e-01f, 1.11242957e-01f, 1.44664526e-01f, 1.16119340e-01f,
  8.87238458e-02f, -1.16017647e-01f, -4.40867245e-01f, -1.90552160e-01f, 1.43704042e-01f, 3.85533065e-01f, -2.78873980e-01f, 1.25369340e-01f, 1.15945758e-02f, -2.18376547e-01f,
  2.90401489e-01f, 1.63757458e-01f, 2.28069603e-01f, 1.70809567e-01f, -2.04127595e-01f, -1.87017605e-01f, 1.66231394e-01f, 8.87266248e-02f, -7.07338303e-02f, 4.81106974e-02f,
  1.21448144e-01f, 1.59858376e-01f, 5.31142857e-03f, 7.78771266e-02f, 1.29955476e-02f, 5.90832308e-02f, -7.28261471e-02f, -1.79370847e-02f, 8.17753971e-02f, -1.20559752e-01f,
  1.50901482e-01f, 5.00513688e-02f, 1.87890559e-01f, 3.38648781e-02f, 3.05794716e-01f, -1.26309365e-01f, 1.18104853e-02f, -1.94296107e-01f, 3.03369194e-01f, 9.39934924e-02f,
  -7.55241290e-02f, 6.20531701e-02f, -1.27789587e-01f, 1.26753384e-02f, 1.57005355e-01f, 4.50371243e-02f, -1.89603493e-02f, -5.11799604e-02f, 3.32417965e-01f, 1.45979241e-01f,
  1.11057632e-01f, 1.12094201e-01f, -2.04166874e-01f, 7.43607357e-02f, 1.98272228e-01f, 2.57086121e-02f, 4.75887246e-02f, 1.31771281e-01f, -1.50935158e-01f, 1.51134282e-01f,
  2.30083019e-01f, -1.09820291e-02f, 4.28929329e-02f, 2.00124145e-01f, 2.06003234e-01f, 2.74045527e-01f, -3.37904066e-01f, -4.50506091e-01f, 1.38547691e-02f, -8.94142240e-02f,
  -4.16155122e-02f, 6.84893951e-02f, 1.13643989e-01f, -1.01684928e-01f, 8.58773142e-02f, -2.41107941e-01f, -3.13346773e-01f, -7.31345788e-02f, 6.20334707e-02f, -2.95026630e-01f,
  1.57442108e-01f, 3.47199570e-03f, -5.81231788e-02f, 9.33335498e-02f, -7.89321773e-03f, 2.34683588e-01f, -2.72198915e-01f, 5.41935377e-02f, -6.21280037e-02f, 3.86225171e-02f,
  9.77444500e-02f, 4.51662503e-02f, 2.86115650e-02f, -2.42792025e-01f, 2.92302538e-02f, -1.29927248e-01f, -2.73243397e-01f, -9.91100967e-02f, 3.63845415e-02f, -2.80885279e-01f,
  -9.56940651e-02f, -1.74662769e-02f, 7.21551105e-02f, -3.78712982e-01f, 1.06755979e-01f, -3.66173200e-02f, 3.15887295e-02f, 8.15151036e-02f, -9.23623666e-02f, -1.43024877e-01f,
  7.17931911e-02f, -1.47741199e-01f, 1.88382626e-01f, 2.22595468e-01f, 1.26250371e-01f, 6.56524971e-02f, -2.32688278e-01f, 1.34945527e-01f, -1.94714203e-01f, -3.21226045e-02f,
  -1.34156674e-01f, -6.21997304e-02f, -2.84834176e-01f, -4.74827597e-03f, 2.92502716e-02f, 2.96626016e-02f, 2.38469653e-02f, -1.36612970e-02f, 1.64226089e-02f, -2.49751657e-01f,
  4.65517789e-01f, 3.68162334e-01f, 1.37060434e-01f, -2.10561812e-01f, 1.11087508e-01f, -2.12563753e-01f, -7.33048543e-02f, -2.06812561e-01f, -1.72456697e-01f, -2.02785552e-01f,
  1.32669389e-01f, 4.00722809e-02f, 8.58891197e-03f, 4.94492389e-02f, -1.18457712e-01f, 1.86800137e-01f, -2.47647036e-02f, -1.93901677e-02f, -4.29824227e-03f, 2.39903834e-02f,
  -1.44130841e-01f, 7.55168870e-02f, 1.31759956e-01f, 1.44333601e-01f, -2.93067306e-01f, 6.08916059e-02f, -1.41618438e-02f, 1.66059658e-01f, 1.16016015e-01f, -7.41359219e-02f,
  5.58148250e-02f, 7.48815760e-02f, -8.14837292e-02f, 1.90524936e-01f, 1.07161969e-01f, 1.76507328e-02f, 7.80202970e-02f, 2.71566033e-01f, -3.63236740e-02f, -7.38827810e-02f,
  1.38354242e-01f, 2.83673238e-02f, 1.15649566e-01f, -1.20695084e-01f, 3.71853970e-02f, -1.01598747e-01f, -2.45471314e-01f, -8.14256147e-02f, 4.93800901e-02f, -6.36392161e-02f,
  6.55235127e-02f, -1.87541872e-01f, -6.28741551e-03f, -4.58034985e-02f, -1.17011489e-02f, 5.50083257e-02f, 5.61839268e-02f, -1.01401031e-01f, 1.40352026e-01f, -1.07929945e-01f,
  5.11649586e-02f, 5.12280799e-02f, 9.56549942e-02f, 5.42405471e-02f, -3.28436971e-01f, -4.14934270e-02f, 7.52647147e-02f, 9.65948626e-02f, -6.26419261e-02f, -1.06497541e-01f,
  4.26314166e-03f, 2.95728236e-03f, -5.48179336e-02f, -1.31932823e-02f, 1.40445918e-01f, 3.31219912e-01f, -6.15859367e-02f, -1.66661039e-01f, 1.76959813e-01f, -2.29732338e-02f,
  1.12264091e-02f, -1.15909558e-02f, 2.99273562e-02f, 2.71897018e-01f, -1.36042247e-02f, -2.73600165e-02f, 5.14517426e-02f, 1.66400656e-01f, -4.35461774e-02f, 2.28006057e-02f,
  1.32397041e-01f, -8.66692215e-02f, 1.24474250e-01f, 2.66722083e-01f, -1.55904382e-01f, -5.81457540e-02f, 2.05668807e-02f, -5.02415970e-02f, 1.94277972e-01f, -2.99561862e-02f,
  3.21768880e-01f, -7.17903972e-02f, -1.69237331e-01f, 8.32865983e-02f, -1.63133591e-01f, 1.34680092e-01f, 7.39710927e-02f, -2.29406804e-02f, 1.49020657e-01f, -9.90976170e-02f,
  -2.81227729e-03f, 1.01527579e-01f, 1.22580953e-01f, 7.87067339e-02f, -1.17223039e-01f, -5.17359264e-02f, 2.49725223e-01f, -7.32945800e-02f, -3.71372402e-02f, 1.05215974e-01f,
  -1.95036843e-01f, 1.34976923e-01f, 3.48380566e-01f, -7.35223293e-02f, -1.39360521e-02f, 1.37283757e-01f, 1.26538754e-01f, 2.44188115e-01f, 4.26444449e-02f, 3.52831453e-01f,
  1.63414776e-01f, -9.40876529e-02f, 2.24106863e-01f, -1.84786528e-01f, 9.51206610e-02f, -3.04499660e-02f, 1.88359365e-01f, -3.03683281e-01f, -2.94240676e-02f, -6.44641295e-02f,
  -1.05441459e-01f, 1.72620773e-01f, 7.05162529e-03f, -2.52882168e-02f, 1.07503477e-02f, -2.18938038e-01f, 8.46552998e-02f, -5.49231619e-02f, 1.84987888e-01f, 1.78828090e-01f,
  -6.25042394e-02f, -1.39939755e-01f, -1.61316946e-01f, -6.73048496e-02f, 2.53550380e-01f, 5.77971376e-02f, -8.11918974e-02f, 2.38481402e-01f, -3.05025578e-01f, -2.25738324e-02f,
  -7.90736545e-03f, 2.66252607e-01f, 2.31140107e-01f, 1.00637712e-01f, 1.13272578e-01f, -6.22884519e-02f, -2.69991249e-01f, -8.80879164e-02f, -8.33117664e-02f, -2.75586665e-01f,
  -8.15073699e-02f, 2.34024189e-02f, 5.41230179e-02f, -8.80209357e-02f, 5.43362796e-02f, 8.73034596e-02f, 8.75701010e-02f, 5.49778109e-03f, 2.68948257e-01f, 1.50517941e-01f,
  -1.63545385e-02f, -1.65168628e-01f, 3.63001525e-02f, -2.26159915e-02f, -4.44051847e-02f, 7.59588033e-02f, 2.25748792e-01f, 2.75043070e-01f, 9.41313803e-02f, 3.06177258e-01f,
  1.30254418e-01f, 2.77751476e-01f, -2.95000762e-01f, -2.06870496e-01f, -7.07269162e-02f, -1.21316470e-01f, 2.19018444e-01f, -1.01675428e-02f, -1.90926448e-01f, -1.58484563e-01f,
  1.68610752e-01f, -3.21175426e-01f, -8.82254615e-02f, 6.88995793e-02f, -5.42686619e-02f, -2.08251044e-01f, 3.32720205e-02f, 7.70828053e-02f, -8.03155228e-02f, -2.21780594e-02f,
  6.11998215e-02f, 2.45139822e-01f, -2.40400836e-01f, -3.66468281e-02f, -3.72741669e-02f, -1.85516980e-02f, 2.47794703e-01f, 1.21121071e-02f, -9.83857885e-02f, -3.96872252e-01f,
  1.48732126e-01f, -1.10386699e-01f, -9.73410085e-02f, -3.16111356e-01f, 1.97589606e-01f, -4.28307086e-01f, -4.12890688e-02f, -2.61791609e-02f, 1.77054554e-01f, 6.24023145e-03f,
  2.41519567e-02f, -1.95085332e-01f, 1.06428728e-01f, -1.92926694e-02f, -1.58271529e-02f, -7.28747174e-02f, 1.84848130e-01f, -1.20905012e-01f, 1.30804256e-01f, 1.77846730e-01f,
  1.80395335e-01f, 1.91046804e-01f, -1.22754671e-01f, 1.91814214e-01f, -2.57173739e-02f, 2.79049892e-02f, -1.42479599e-01f, 6.38764948e-02f, -2.72197604e-01f, -1.45004466e-01f,
  2.59420693e-01f, 1.22822791e-01f, 1.57350317e-01f, 8.58909544e-03f, 1.34246752e-01f, 8.70587751e-02f, 9.94544327e-02f, -2.17995286e-01f, 1.28960967e-01f, -3.72964770e-01f,
  2.35341758e-01f, -2.42975146e-01f, -2.40239397e-01f, -6.77104667e-02f, -2.41498336e-01f, -4.63208824e-01f, -3.40718739e-02f, -1.15231268e-01f, -8.57316628e-02f, -1.24628000e-01f,
  3.39437788e-03f, -1.53377578e-02f, -1.33555770e-01f, 1.24722995e-01f, -1.54221594e-01f, -4.04576026e-02f, 1.01222433e-01f, 1.89426672e-02f, 1.14801981e-01f, 8.56078565e-02f,
  1.23755343e-01f, 5.72931916e-02f, -3.85021061e-01f, 1.91018581e-01f, 1.12392642e-01f, -3.77933115e-01f, -7.47870654e-02f, -9.32716653e-02f, 1.50184274e-01f, 1.61816150e-01f,
  -1.43923789e-01f, 2.20485002e-01f, -7.52932131e-02f, -1.60282776e-01f, 1.23956591e-01f, -1.85358837e-01f, -4.57286648e-02f, 1.82306051e-01f, 1.64582565e-01f, 1.52631819e-01f,
  1.88030586e-01f, -2.28522703e-01f, -1.27816349e-01f, -1.01197638e-01f, -4.06665020e-02f, 8.76038000e-02f, -2.18187839e-01f, 9.36999992e-02f, -2.16266006e-01f, -1.25333130e-01f,
  2.86429878e-02f, -2.73711056e-01f, 1.47352248e-01f, 2.66034100e-02f, -2.35962961e-02f, 5.28472587e-02f, 5.49984910e-02f, -4.36204486e-02f, 1.63759124e-02f, -5.27531281e-02f,
  2.56237477e-01f, 2.53725499e-01f, 1.43677652e-01f, -3.19076538e-01f, -8.96533951e-02f, -1.04534075e-01f, -2.00203508e-01f, -9.15496051e-02f, -1.62169129e-01f, -1.82347655e-01f,
  1.21429220e-01f, 1.89076528e-01f, -1.54822454e-01f, 1.79853082e-01f, 6.08159006e-02f, 1.23263404e-01f, 7.46650696e-02f, 7.63668586e-03f, 4.36472483e-02f, 1.64297715e-01f,
  -1.14207678e-01f, 8.96370932e-02f, 1.43576890e-01f, 1.17579818e-01f, -1.40158370e-01f, -4.90221679e-02f, 6.12038225e-02f, 1.38597980e-01f, 2.73025751e-01f, -1.16924435e-01f,
  -3.41984518e-02f, 3.31750698e-02f, 2.28810579e-01f, -1.90461412e-01f, -1.21651448e-01f, -2.37414971e-01f, -1.17014073e-01f, 1.69399425e-01f, -2.23552715e-02f, 2.62014382e-02f,
  2.20658720e-01f, 5.12582771e-02f, 1.94640726e-01f, -2.87604868e-01f, 1.85509995e-01f, 2.64265500e-02f, -1.06920801e-01f, -1.28088549e-01f, 8.05415735e-02f, -1.53311640e-01f,
  -1.86879963e-01f, -2.43912652e-01f, -1.38461307e-01f, 6.64993376e-02f, -1.56782493e-01f, -7.85986613e-03f, 1.07321329e-01f, -2.07508773e-01f, -1.41552210e-01f, -2.62487028e-02f,
  -1.59433279e-02f, -1.26636595e-01f, 1.57386884e-01f, -1.08255640e-01f, 4.66904789e-02f, 1.19382516e-01f, 2.43934751e-01f, -4.73692715e-02f, 1.09597109e-01f, -2.22929627e-01f,
  2.46712547e-02f, 1.58738747e-01f, -1.29461512e-01f, -2.01999515e-01f, 2.90184736e-01f, 2.67798036e-01f, -5.62202260e-02f, 6.42785057e-02f, -1.10455774e-01f, 7.06573501e-02f,
  1.98570155e-02f, 7.78670609e-02f, -9.08244699e-02f, 2.77446769e-02f, 8.91516060e-02f, 2.41499189e-02f, 1.37496650e-01f, 2.59890668e-02f, 2.70210039e-02f, 7.61989504e-03f,
  -2.63297141e-01f, -2.07778793e-02f, 1.10504448e-01f, 1.32548526e-01f, 3.95866521e-02f, 2.16760069e-01f, 1.38460219e-01f, -9.84828472e-02f, -6.53991997e-02f, -1.21166736e-01f,
  4.82221097e-02f, 2.32606724e-01f, -4.55532484e-02f, 1.29365847e-01f, 2.32790019e-02f, 1.24474093e-01f, 1.16407439e-01f, -2.67828286e-01f, -9.87884104e-02f, 1.44507557e-01f,
  -1.71439856e-01f, -1.35514855e-01f, -5.09449691e-02f, 1.29983630e-02f, 1.78573549e-01f, 1.09833755e-01f, 1.72270641e-01f, -3.51983234e-02f, 2.55561136e-02f, 1.07159324e-01f,
  2.27701887e-02f, 7.88991824e-02f, -7.93631282e-03f, -1.49231672e-01f, -6.21904433e-02f, -4.07047607e-02f, 3.22669446e-02f, -1.44717366e-01f, 1.34667113e-01f, 2.28383496e-01f,
  3.59867960e-01f, -1.31897673e-01f, -8.46595243e-02f, -7.56899938e-02f, 1.41923930e-02f, -1.82447955e-02f, -1.21361047e-01f, 1.09627455e-01f, 2.01542422e-01f, 1.89848170e-01f,
  6.91682622e-02f, 5.22093326e-02f, 5.21007031e-02f, 1.30186722e-01f, 2.70309925e-01f, 4.48557399e-02f, -5.82501385e-03f, 9.25828293e-02f, 3.18317674e-02f, -6.71259239e-02f,
  -1.20961234e-01f, 1.08756840e-01f, -1.83102235e-01f, 1.48796946e-01f, 1.41469240e-01f, -9.28230584e-02f, -4.33581620e-02f, 1.34411603e-01f, 7.65040293e-02f, 7.96729922e-02f,
  -1.03413410e-01f, 6.95507452e-02f, -5.61018810e-02f, -2.91971654e-01f, 1.61977708e-01f, 2.29602933e-01f, -1.89850137e-01f, 1.18606187e-01f, 5.26793562e-02f, -3.98561843e-02f,
  3.47855352e-02f, -1.65421173e-01f, -3.74663770e-02f, -2.16673667e-04f, -1.11820824e-01f, -2.39493161e-01f, 7.40011558e-02f, -1.96761061e-02f, -3.40944231e-02f, -2.92809010e-01f,
  1.77646801e-01f, 9.47599187e-02f, -1.43130153e-01f, 1.30371843e-02f, -1.46545172e-01f, 7.02037849e-03f, 1.59918398e-01f, 4.66723405e-02f, 1.79555804e-01f, -3.41626815e-02f,
  -1.36375532e-01f, -1.94797561e-01f, -2.07336903e-01f, -1.05155380e-02f, 1.46018729e-01f, 2.58513629e-01f, -1.69894785e-01f, 2.46930152e-01f, -1.15901732e-03f, -2.69520819e-01f,
  -5.55309430e-02f, 3.83167893e-01f, 1.07557878e-01f, 5.53201213e-02f, 1.60165042e-01f, -9.09914747e-02f, -8.16288292e-02f, 1.52946785e-01f, 7.75348395e-02f, -1.61708556e-02f,
  2.46013224e-01f, -6.44556992e-03f, -6.24690345e-03f, 1.09412879e-01f, -1.00711301e-01f, 1.32749259e-01f, 1.12464324e-01f, 5.41108772e-02f, 1.92285195e-01f, -1.10759452e-01f,
  -4.09746282e-02f, -3.19491439e-02f, 2.02069983e-01f, 2.71485031e-01f, -1.58690929e-01f, -2.15391725e-01f, 1.58448696e-01f, -2.09255219e-01f, -6.08154759e-03f, 2.63713729e-02f,
  -4.69701743e-04f, 1.60726100e-01f, -2.98619479e-01f, 1.28578439e-01f, -1.83845893e-01f, -5.09552658e-02f, -7.86085799e-02f, -9.12562683e-02f, 2.10306630e-01f, -2.17847034e-01f,
  -6.61524981e-02f, 1.08650304e-01f, 8.33031163e-02f, -1.38640970e-01f, 8.01483989e-02f, 1.47086769e-01f, 3.34090404e-02f, 2.05841050e-01f, -1.16853900e-01f, 1.45897195e-01f,
  1.46025524e-01f, 2.91104198e-01f, 1.07108168e-02f, 5.76860458e-02f, 1.30328879e-01f, -1.42659813e-01f, 2.51132511e-02f, 1.63102373e-01f, 1.46949068e-01f, 3.77669409e-02f,
  1.33478045e-01f, -2.48186648e-01f, -7.14260805e-03f, 1.40594691e-02f, -9.33980644e-02f, -1.44246817e-02f, 2.54238307e-01f, 3.39848213e-02f, -5.06114699e-02f, 8.06147531e-02f,
  -1.09354436e-01f, -1.15621295e-02f, -7.09441304e-02f, -4.09885608e-02f, 5.15750796e-02f, -9.20314342e-02f, 4.15307134e-02f, -9.97296050e-02f, -4.06751968e-02f, 1.21061306e-03f,
  -2.00361028e-01f, 3.02366260e-02f, -1.02329746e-01f, 3.52238901e-02f, 8.95446762e-02f, -1.56281665e-02f, 1.12553462e-02f, -1.19460025e-03f, 9.51312333e-02f, -2.14522392e-01f,
  -1.56880289e-01f, -1.73762679e-01f, 1.41233414e-01f, 5.24918325e-02f, -1.81582987e-01f, 2.44279549e-01f, -3.03728469e-02f, 6.64101243e-02f, 1.98719860e-03f, -5.52431718e-02f,
  -1.30120106e-02f, -3.32052223e-02f, -5.25067486e-02f, -4.89977375e-02f, 1.11814857e-01f, 1.03242218e-01f, -1.13818618e-02f, 1.54997865e-02f, 1.15356654e-01f, -5.22506274e-02f,
  -4.01802473e-02f, 1.24877621e-03f, -2.12389812e-01f, 1.43874034e-01f, 6.05649054e-02f, 2.97191650e-01f, -7.88524151e-02f, 1.10694595e-01f, 1.09607831e-01f, 2.52278686e-01f,
  -1.14684030e-01f, -4.52624589e-01f, -3.51133883e-01f, 1.98535505e-03f, 5.40366888e-01f, 7.71987066e-02f, 1.15960553e-01f, -5.41287363e-02f, 1.92537397e-01f, -4.41137254e-02f,
  -4.68217522e-01f, -1.38244987e-01f, 1.38962060e-01f, 2.52019260e-02f, 4.38533463e-02f, -5.19165285e-02f, -1.11698344e-01f, -1.06963359e-01f, 1.60703257e-01f, 5.64698838e-02f,
  -4.81015325e-01f, -5.68485148e-02f, 8.65492523e-02f, 1.77563298e-02f, 1.86663449e-01f, -1.21387072e-01f, 1.48274675e-01f, -4.74043600e-02f, 2.55389716e-02f, 1.29875869e-01f,
  -3.90279964e-02f, -3.93660396e-01f, 2.04438604e-02f, -2.20199041e-02f, -4.43734042e-02f, 1.27116889e-02f, -2.98042953e-01f, -1.46814182e-01f, -1.78928301e-01f, 1.05399854e-01f,
  6.53917715e-02f, -5.64429052e-02f, -2.05544323e-01f, 3.08343321e-02f, 1.00065991e-01f, 4.29017432e-02f, 1.02452986e-01f, 3.42390209e-01f, 3.84748727e-02f, 6.09254837e-02f,
  6.61161020e-02f, 2.11317152e-01f, -2.53549397e-01f, -2.61169016e-01f, -1.82877526e-01f, 5.29140458e-02f, -6.57362789e-02f, -2.02548742e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 52)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 52;
const float L2_fan_Bp_bar_data[] = {
  1.40521348e-01f, -3.16816452e-03f, 1.02653392e-01f, 5.57555668e-02f, -8.99895206e-02f, -7.08241388e-02f, 5.11253439e-02f, 7.40741044e-02f, -2.74827853e-02f, -2.13703793e-02f,
  -5.02224173e-03f, -6.38104007e-02f, -1.13101438e-01f, 2.04243839e-01f, 6.86834101e-03f, 2.99388915e-02f, 1.01539433e-01f, -6.17127120e-02f, 1.55370176e-01f, 1.00987256e-01f,
  1.41941875e-01f, 4.59321514e-02f, 1.30056575e-01f, -1.20100565e-01f, -3.06588877e-02f, 1.41321227e-01f, 1.27650448e-03f, -3.12576964e-02f, 3.10281478e-02f, -5.39311813e-03f,
  1.48392931e-01f, -1.00763269e-01f, -1.58044383e-01f, -1.29293680e-01f, 2.29970843e-01f, 6.39538467e-02f, 2.51101285e-01f, 3.70752476e-02f, 1.77476257e-01f, -7.40196854e-02f,
  4.57584783e-02f, -2.22092167e-01f, 6.11832179e-02f, 8.72513056e-02f, 2.90052984e-02f, 1.87653080e-01f, -1.51746362e-01f, 1.25985313e-02f, 3.84471156e-02f, 4.26971726e-02f,
  3.89154069e-02f, -5.53673785e-03f
};

// L3_fan_Wp (Shape: 6 x 64)
const int L3_fan_Wp_rows = 6;
const int L3_fan_Wp_cols = 64;
const float L3_fan_Wp_data[] = {
  -3.34707946e-02f, -2.98911519e-03f, 2.05942476e-03f, 8.04664046e-02f, -1.33587644e-01f, -2.00008824e-02f, 4.07018289e-02f, 1.83945209e-01f, -2.62002815e-02f, 3.07703733e-01f,
  1.55162990e-01f, 2.45785899e-02f, 9.21059698e-02f, -7.07812980e-03f, 1.99575737e-01f, -1.25112265e-01f, 2.01380044e-01f, 2.09621087e-01f, 1.11012729e-02f, 1.30607635e-01f,
  -6.16014674e-02f, 1.42159387e-02f, 9.14511755e-02f, -1.44418523e-01f, 7.90861771e-02f, 1.76624715e-01f, 1.28814116e-01f, 4.61199842e-02f, 1.69471242e-02f, 8.60662684e-02f,
  -8.16824809e-02f, 2.72125215e-03f, 1.81490764e-01f, -1.00779966e-01f, -8.08894262e-02f, 1.71194568e-01f, -2.38016862e-02f, 6.32470027e-02f, 4.25608717e-02f, -8.28972906e-02f,
  1.75909683e-01f, 1.15973547e-01f, 1.40303656e-01f, 9.73828658e-02f, -1.76529065e-02f, 1.52382359e-01f, 9.67845321e-02f, -8.94284397e-02f, 5.17603429e-03f, -1.49895668e-01f,
  -1.62786826e-01f, -1.70911729e-01f, 5.49076460e-02f, -6.70177490e-02f, 5.88854551e-02f, -6.63531153e-03f, 7.65517280e-02f, -9.59593058e-02f, 5.38310595e-02f, -1.73314475e-04f,
  -5.79191446e-02f, -1.49226770e-01f, -7.27080628e-02f, 4.12254110e-02f, -9.15376842e-03f, -9.08751637e-02f, 1.59978837e-01f, 2.84377366e-01f, 8.19123462e-02f, -7.78702796e-02f,
  -1.78605229e-01f, 1.51836783e-01f, -1.48510858e-01f, -2.69343048e-01f, -1.42067477e-01f, -7.33101964e-02f, 2.08385400e-02f, -2.82194078e-01f, 1.57229919e-02f, 8.18703100e-02f,
  -4.56017628e-02f, 1.49426922e-01f, 4.88344096e-02f, 7.20020533e-02f, 3.18200625e-02f, -9.93636847e-02f, -5.17065041e-02f, 3.90011445e-02f, -4.29245122e-02f, 4.53113243e-02f,
  5.79453632e-02f, -6.02018498e-02f, 8.14928561e-02f, 1.54935494e-01f, 1.61746904e-01f, -6.21195287e-02f, 1.28066361e-01f, -7.14921132e-02f, 2.05977470e-01f, -3.32869366e-02f,
  3.86720151e-02f, 1.75950438e-01f, -1.01743191e-01f, -2.27002144e-01f, -2.73067690e-03f, -5.87431863e-02f, 1.26205802e-01f, 1.29662722e-01f, -8.05889815e-02f, -1.87882204e-02f,
  1.64854258e-01f, -1.54937372e-01f, 2.63685100e-02f, 1.71315484e-02f, 5.23260571e-02f, -9.89549085e-02f, -8.11105147e-02f, -7.04135522e-02f, 4.71332669e-02f, 9.22811106e-02f,
  -1.15359038e-01f, 6.11482933e-02f, 2.72486135e-02f, -1.16525039e-01f, 1.28022656e-01f, -1.38340354e-01f, 4.05844040e-02f, -1.29952505e-01f, 1.66560765e-02f, 3.17794204e-01f,
  1.20051861e-01f, -9.69299600e-02f, -2.87481006e-02f, 3.48351263e-02f, 1.88441306e-01f, -1.10728489e-02f, -3.08819059e-02f, 1.27102956e-01f, -9.56317708e-02f, -1.57091483e-01f,
  -1.43647864e-01f, 7.31341168e-02f, 9.06010196e-02f, -1.83746427e-01f, 8.02270249e-02f, 8.04392397e-02f, 1.49113417e-01f, -2.07877666e-01f, 1.06692016e-01f, -9.89966616e-02f,
  4.48725000e-02f, -5.90696894e-02f, 1.16768494e-01f, 2.30919272e-01f, 6.82677776e-02f, -6.42848611e-02f, -2.91782737e-01f, -1.32293567e-01f, 1.89539328e-01f, -7.68480003e-02f,
  -8.67412761e-02f, -2.44070236e-02f, 5.99002838e-02f, -3.93298492e-02f, -1.11095294e-01f, 1.60650879e-01f, 1.50111228e-01f, -2.70011485e-01f, 7.57538825e-02f, -4.02809530e-02f,
  3.56707186e-01f, 8.75341371e-02f, -4.10393141e-02f, 5.19658625e-02f, -2.15242133e-01f, 7.02081695e-02f, 8.75973143e-03f, 8.74389485e-02f, 1.88370332e-01f, 2.70142946e-02f,
  -1.40598593e-02f, 6.86810762e-02f, -7.00457692e-02f, -5.83154196e-03f, -2.19130814e-02f, 5.18584140e-02f, 1.05543755e-01f, 1.04964256e-01f, 1.59411859e-02f, -1.38925895e-01f,
  2.73687374e-02f, 1.17330745e-01f, 1.13356411e-01f, 5.83168902e-02f, 3.47052306e-01f, 2.61606812e-01f, -1.50760571e-02f, 4.91278246e-03f, -2.57291466e-01f, 3.09694469e-01f,
  -1.10855751e-01f, -5.93445078e-02f, -1.07556701e-01f, 6.01859093e-02f, -1.43802524e-01f, -6.62918314e-02f, -1.35099320e-02f, 1.88769668e-01f, 7.60353878e-02f, -2.73943809e-03f,
  -3.93854417e-02f, 1.30189909e-02f, -1.19188756e-01f, 2.51138180e-01f, -1.54335395e-01f, -3.25787105e-02f, -1.03906810e-01f, -1.98231414e-02f, -1.76151525e-02f, 6.28086478e-02f,
  6.07391335e-02f, 1.60393074e-01f, 3.88400257e-02f, 2.26145491e-01f, 1.05451765e-02f, 8.81005898e-02f, -9.90680903e-02f, -8.32569227e-02f, -1.96197927e-01f, -5.17893694e-02f,
  -1.66430980e-01f, 3.74732986e-02f, 9.17489827e-02f, -1.27878323e-01f, -6.29060119e-02f, 6.18933924e-02f, 1.22791238e-01f, 1.33223966e-01f, 1.33699670e-01f, 1.97821315e-02f,
  -1.86045095e-01f, 5.97696379e-02f, -2.57952977e-02f, -8.71725157e-02f, -1.85588434e-01f, 7.76607394e-02f, -9.08113047e-02f, -7.05009177e-02f, -4.32037711e-02f, -9.09028277e-02f,
  8.56940299e-02f, 2.83533055e-02f, 5.32582700e-02f, 1.97478130e-01f, -3.17736268e-02f, -1.56858474e-01f, 4.06595841e-02f, 1.11214258e-02f, -2.13979512e-01f, -1.61833763e-01f,
  -6.14932477e-02f, -1.79315597e-01f, 8.94935653e-02f, -4.72930968e-02f, 2.19987690e-01f, 9.55703706e-02f, -1.54371932e-01f, -3.80466506e-02f, -1.50251374e-01f, 9.58014354e-02f,
  -6.28781319e-02f, -1.83564965e-02f, 1.01901039e-01f, -7.71644041e-02f, 1.56960990e-02f, -4.34065722e-02f, 1.03837565e-01f, 7.42204934e-02f, -1.87635928e-01f, 6.93688393e-02f,
  6.87904432e-02f, -1.45081520e-01f, 1.16920777e-01f, -2.20643785e-02f, -8.63145441e-02f, -1.22015374e-02f, -3.14303562e-02f, -3.94950807e-02f, -1.43598393e-01f, 3.88306193e-02f,
  -8.30957070e-02f, 1.37770921e-01f, -6.96960017e-02f, -1.37287766e-01f, 6.66314363e-02f, 1.38334602e-01f, 7.55046681e-02f, 6.01327643e-02f, -5.03044240e-02f, 1.53858647e-01f,
  8.83673653e-02f, 8.42432305e-03f, -2.65393734e-01f, 2.01791346e-01f, -1.40847480e-02f, 8.23846608e-02f, 4.62171473e-02f, 1.11913957e-01f, 7.71159083e-02f, 4.15126607e-02f,
  -6.63380101e-02f, -4.93014194e-02f, 3.15500647e-02f, -1.30628347e-01f, 1.68451235e-01f, 8.70412439e-02f, 2.22076893e-01f, 1.36306882e-01f, 1.54248610e-01f, 1.75259821e-02f,
  8.04508403e-02f, 1.26945034e-01f, -1.29368864e-02f, 1.48494378e-01f, -7.90477395e-02f, 1.89696282e-01f, 1.24605067e-01f, 5.77578284e-02f, 1.22505590e-01f, 2.03233168e-01f,
  3.55832092e-02f, -1.92219481e-01f, 9.88168865e-02f, -1.44232616e-01f, 8.98084491e-02f, -3.19753438e-02f, -1.80953115e-01f, 1.01466905e-02f, 1.88228011e-01f, 5.99991865e-02f,
  -8.75517130e-02f, -7.96419382e-02f, 7.87092522e-02f, -1.76832944e-01f, -1.32907182e-01f, 2.71474458e-02f, -1.90864757e-01f, -1.41501203e-01f, 7.46189579e-02f, -3.63667458e-02f,
  -1.04294747e-01f, -2.96168607e-02f, 8.96714511e-04f, -1.37307867e-01f, -2.32146338e-01f, 2.00871415e-02f, 8.73143673e-02f, -9.89713296e-02f, 7.72874150e-03f, -3.37085724e-01f,
  1.30240694e-01f, -7.02229813e-02f, -1.37604028e-01f, -1.98421687e-01f, -4.18221466e-02f, -5.21302707e-02f, 8.51884112e-03f, -2.35592201e-01f, -4.51369770e-03f, -3.77364568e-02f,
  6.53729811e-02f, -1.31036088e-01f, -3.46871354e-02f, -8.92091691e-02f, -8.87148231e-02f, 4.16775886e-03f, -1.82875320e-01f, 8.64473954e-02f, -2.63813138e-01f, -1.63842544e-01f,
  -2.24395961e-01f, -4.39436324e-02f, -1.15462221e-01f, 6.85126707e-02f
};

// L3_fan_Wp_bar (Shape: 52 x 64)
const int L3_fan_Wp_bar_rows = 52;
const int L3_fan_Wp_bar_cols = 64;
const float L3_fan_Wp_bar_data[] = {
  -2.66376704e-01f, 1.35028616e-01f, -1.89656660e-01f, -3.49156618e-01f, -3.46214116e-01f, -3.09242874e-01f, 2.27597386e-01f, 3.15777004e-01f, -4.15364653e-02f, -7.76753053e-02f,
  -7.60527477e-02f, 9.95761305e-02f, 9.17221420e-03f, 1.73338562e-01f, -9.11722798e-03f, -1.11507088e-01f, 1.94192931e-01f, 9.65692922e-02f, 4.35307994e-02f, -3.06912422e-01f,
  5.91848120e-02f, -2.90708482e-01f, -1.20930418e-01f, -3.72105348e-03f, 7.46239424e-02f, 7.75027201e-02f, 1.87639549e-01f, -6.65875226e-02f, -1.09157003e-01f, -5.50356843e-02f,
  2.48352736e-01f, -3.71791027e-03f, -1.82799265e-01f, -2.59199828e-01f, 5.28740585e-02f, 1.48908749e-01f, -1.84161320e-01f, -9.67468470e-02f, -2.70212386e-02f, -1.85236242e-02f,
  -6.14583753e-02f, 1.26180246e-01f, 3.00333291e-01f, 1.03660755e-01f, 1.91598956e-03f, 1.34725988e-01f, -5.15164547e-02f, -7.36498535e-02f, -9.95775908e-02f, 1.43362945e-02f,
  -3.83640267e-02f, 2.42174491e-02f, -2.41073966e-01f, 1.01450957e-01f, -9.99310017e-02f, -2.20544301e-02f, 5.57340421e-02f, -1.09898582e-01f, 3.78722064e-02f, 1.81791544e-01f,
  2.23952420e-02f, 9.59921107e-02f, 7.19659403e-02f, 3.41322161e-02f, 1.59187496e-01f, -1.80022838e-03f, 4.67393994e-02f, 2.38303006e-01f, -3.87271345e-02f, 1.70681745e-01f,
  6.40408099e-02f, -1.53429747e-01f, 2.05531254e-01f, 3.03536296e-01f, 2.90582359e-01f, -3.92276123e-02f, 1.78348124e-02f, -4.39580455e-02f, 1.36176452e-01f, 9.13310125e-02f,
  -2.76602246e-02f, 2.25818694e-01f, -1.26070559e-01f, 1.78229269e-02f, 2.97715962e-01f, -7.93233067e-02f, 6.53401762e-02f, 1.13643259e-02f, 1.23214945e-01f, 8.72016922e-02f,
  1.21495456e-01f, -5.59721887e-02f, 1.57742038e-01f, 2.47766256e-01f, -5.45030273e-02f, 6.67061517e-03f, 1.05700359e-01f, -1.06350616e-01f, 2.12810814e-01f, 2.19600990e-01f,
  1.31022543e-01f, -3.64642683e-03f, -1.35663122e-01f, 3.96075100e-02f, 1.49322748e-01f, 1.05356447e-01f, -2.33450737e-02f, 2.06735536e-01f, 1.24792069e-01f, -4.95661190e-03f,
  2.61510760e-01f, 7.86782056e-02f, 1.42551780e-01f, 6.82834070e-03f, -1.63721249e-01f, -2.55544186e-01f, 1.17997229e-01f, 1.42220989e-01f, 2.43045799e-02f, -2.37970831e-04f,
  2.14893326e-01f, 1.73329502e-01f, 3.33681017e-01f, 6.08939826e-02f, 3.65599319e-02f, -2.62414545e-01f, 9.40800160e-02f, -1.68168005e-02f, 2.10722536e-01f, 1.86610222e-01f,
  1.05764262e-01f, 1.57346964e-01f, -1.53099634e-02f, -6.47784397e-03f, -3.53076249e-01f, 1.24195918e-01f, -1.99541494e-01f, -1.10487618e-01f, -2.05165565e-01f, -8.70666802e-02f,
  -1.18743172e-02f, -1.29531547e-01f, -2.65441328e-01f, 1.64922699e-01f, -7.53679797e-02f, -1.29799232e-01f, 1.26575038e-01f, 1.78324245e-03f, 1.10805660e-01f, 1.82236224e-01f,
  -4.06680644e-01f, -2.50766963e-01f, -4.40517180e-02f, -3.73613462e-02f, -1.98237047e-01f, -4.17026997e-01f, 6.75598904e-02f, 6.60533234e-02f, 1.72174975e-01f, -5.25810756e-02f,
  -4.45596308e-01f, -6.21244982e-02f, -3.83767560e-02f, -1.05694480e-01f, 1.12040564e-01f, 5.96166290e-02f, -6.28183857e-02f, 2.86313921e-01f, -1.50445327e-01f, -7.92715475e-02f,
  4.16244380e-02f, -2.04887673e-01f, -2.40327343e-01f, 1.30075946e-01f, 8.62077549e-02f, 6.35044798e-02f, -4.40312736e-02f, 1.46573819e-02f, 1.30474512e-02f, 2.37147033e-01f,
  -1.53967276e-01f, 8.28702673e-02f, 2.40319893e-01f, 6.49011508e-02f, -1.98746979e-01f, -1.67821646e-01f, -2.87786871e-01f, 1.47294685e-01f, 2.38599926e-01f, 1.96958199e-01f,
  3.81231718e-02f, -2.91907459e-01f, 1.99028403e-01f, -9.27004740e-02f, 3.28388035e-01f, 1.91222489e-01f, 1.44192740e-01f, 7.11894855e-02f, -9.32205170e-02f, 1.83654994e-01f,
  6.04978539e-02f, 6.96842447e-02f, 1.47137269e-01f, -1.70768350e-01f, 2.95291632e-01f, -2.19708189e-01f, 7.02318251e-02f, 5.95969409e-02f, -1.47011513e-02f, 3.31223048e-02f,
  6.06114417e-02f, 2.28797927e-01f, -2.56055612e-02f, -1.63561031e-01f, 9.23912302e-02f, -1.07625768e-01f, -3.57097350e-02f, 2.26965427e-01f, -5.52002899e-02f, -3.75072397e-02f,
  2.04991028e-01f, 1.38553336e-01f, 8.24947134e-02f, 1.20303251e-01f, 2.41075262e-01f, -1.44955181e-02f, 1.89037293e-01f, 1.76713020e-01f, 1.89329550e-01f, -1.84728224e-02f,
  -1.03098284e-02f, 3.48972045e-02f, -1.50895789e-02f, -1.41652331e-01f, 1.33342788e-01f, -6.60372674e-02f, -9.24129337e-02f, 1.75473653e-03f, 4.04659718e-01f, -9.42391232e-02f,
  1.51095688e-01f, 3.22934166e-02f, -1.13035060e-01f, -3.12847912e-01f, 1.46065932e-02f, -7.95486495e-02f, -3.07827089e-02f, 2.64991134e-01f, 1.44986615e-01f, 1.30879477e-01f,
  -8.46273154e-02f, 1.15993254e-01f, -1.76747903e-01f, -2.47785896e-01f, 1.22063592e-01f, 2.25051433e-01f, 1.54354330e-02f, 4.89023924e-02f, 1.28065571e-02f, 7.45136216e-02f,
  -1.49458200e-01f, 2.72764504e-01f, 1.49947703e-01f, 4.09448333e-02f, -3.07884306e-01f, 2.09208190e-01f, -9.64438170e-02f, 2.17864901e-01f, 6.10214006e-03f, 1.34586364e-01f,
  -1.09104648e-01f, -5.27087890e-04f, -1.91525221e-01f, -3.75938416e-01f, 2.18499824e-03f, 2.98711471e-02f, -2.12858588e-01f, 3.05670559e-01f, -4.71637920e-02f, 1.87004492e-01f,
  -1.24570802e-01f, -8.96961242e-02f, -1.43531314e-03f, 5.41419871e-02f, -7.48752728e-02f, -1.14311397e-01f, -8.91365260e-02f, -2.03071032e-02f, 7.17526451e-02f, 1.39934987e-01f,
  -2.13517308e-01f, -1.58105373e-01f, -1.59636840e-01f, 1.82315223e-02f, 3.42590958e-02f, -5.05366130e-03f, 6.45664036e-02f, 1.72709435e-01f, 2.55319364e-02f, -2.68384665e-01f,
  1.60052523e-01f, -1.14923663e-01f, -5.58009632e-02f, -1.06770612e-01f, -1.42157422e-02f, -7.12925196e-02f, 1.59445852e-01f, 1.44673139e-01f, 6.03018887e-02f, -1.70755580e-01f,
  1.24217615e-01f, -9.34678689e-02f, -1.21311136e-01f, 1.71399638e-01f, -4.51003373e-01f, -1.62594318e-01f, 3.30725573e-02f, 3.72433633e-01f, 1.51140779e-01f, 1.27095357e-01f,
  1.37500614e-02f, -9.44852978e-02f, -2.29077980e-01f, 1.90929815e-01f, -1.22864619e-01f, 1.27458572e-01f, -2.11289853e-01f, 1.51703000e-01f, 4.13314581e-01f, -7.42358342e-03f,
  -1.48337394e-01f, -2.92990446e-01f, 3.05587679e-01f, 8.02365094e-02f, 2.62840223e-02f, 1.52269065e-01f, 1.26204148e-01f, -8.36892053e-02f, -1.19483255e-01f, -1.13406412e-01f,
  -2.11183518e-01f, -1.49315178e-01f, 5.27497768e-01f, 1.06198736e-01f, 3.17690790e-01f, 2.00354874e-01f, -9.59354565e-02f, 1.86573882e-02f, 2.42126748e-01f, -6.01727627e-02f,
  -9.72271115e-02f, -3.15733612e-01f, 2.07588419e-01f, 1.26914501e-01f, -1.59267575e-01f, 1.31233558e-01f, 4.43827510e-02f, -1.49503490e-02f, 7.69286007e-02f, -3.97525519e-01f,
  -1.10582441e-01f, -2.34505266e-01f, -2.22651020e-01f, -1.96646973e-01f, -1.14543783e-02f, 9.21732858e-02f, 4.97981273e-02f, 5.20371869e-02f, 1.19335249e-01f, 2.37471938e-01f,
  -2.43556976e-01f, -1.44489959e-01f, 5.03674261e-02f, 8.04154277e-02f, 9.46160778e-02f, 2.21412972e-01f, -2.09933072e-02f, -1.80118650e-01f, -6.47010207e-02f, -2.25214332e-01f,
  -2.04967991e-01f, 1.46089613e-01f, 5.94480261e-02f, 1.60097212e-01f, 1.62388802e-01f, 2.38275751e-01f, -9.44648758e-02f, -2.86347419e-01f, -1.81857012e-02f, -1.19928442e-01f,
  2.04962254e-01f, 8.91287345e-03f, -3.91128600e-01f, -2.93355007e-02f, 7.20513659e-03f, 7.84958601e-02f, -2.53954262e-01f, 1.57986954e-01f, 1.83649793e-01f, -1.44918850e-02f,
  -3.26384418e-02f, 3.43435630e-02f, -5.17387092e-02f, 5.27954176e-02f, -9.64770187e-03f, 1.02165677e-01f, -3.97835493e-01f, -3.53333056e-01f, -1.78085074e-01f, 4.25459892e-02f,
  2.91447397e-02f, -2.79442757e-01f, -1.53570950e-01f, 2.49263719e-01f, 2.13092476e-01f, 2.09628060e-01f, 1.63774744e-01f, -2.44636416e-01f, -4.86474074e-02f, 1.55754283e-01f,
  4.65069562e-02f, 1.30102681e-02f, -6.50672764e-02f, 4.31208797e-02f, 2.50272244e-01f, 4.21862692e-01f, 2.36776650e-01f, 1.46676283e-02f, -4.03566323e-02f, 4.22476791e-02f,
  1.29486695e-01f, 6.54229745e-02f, 5.87602817e-02f, -1.02876693e-01f, 1.14950456e-01f, -1.62096828e-01f, -2.12037116e-01f, 5.84843010e-02f, -3.51141810e-01f, -5.90626486e-02f,
  -2.27852911e-01f, 2.58818060e-01f, -5.21760248e-03f, 1.06585532e-01f, 8.71155113e-02f, 5.77202067e-02f, -3.27024423e-02f, -1.85829028e-01f, 1.27832323e-01f, 5.84389223e-03f,
  6.32748902e-02f, 3.46839517e-01f, 4.30385815e-03f, 7.56435022e-02f, -2.28738502e-01f, -4.87202965e-03f, -6.85339496e-02f, -1.66192755e-01f, -2.26336420e-01f, -2.27196231e-01f,
  -2.21838001e-02f, -3.35604697e-01f, -2.86674857e-01f, 2.21932128e-01f, 5.14486292e-03f, 7.14560598e-02f, 1.08199969e-01f, 1.08824410e-02f, -1.59666911e-01f, 8.52113366e-02f,
  -1.76241070e-01f, -1.48187652e-01f, -1.41553789e-01f, 5.86784929e-02f, -2.46245325e-01f, -1.52524576e-01f, -1.31211821e-02f, -5.41135818e-02f, -6.86201751e-02f, -1.26820073e-01f,
  -2.82887876e-01f, 1.12669513e-01f, 1.19203900e-03f, -9.62961763e-02f, 1.31309256e-01f, 1.09620206e-01f, 7.53313079e-02f, -2.17133053e-02f, -9.74183902e-02f, -1.00288920e-01f,
  -1.55399859e-01f, -1.91769749e-01f, -2.30155393e-01f, 4.22020210e-03f, -1.22627534e-01f, -1.41227752e-01f, -5.55699058e-02f, 1.25776604e-01f, 1.65909022e-01f, 2.56194681e-01f,
  3.39973457e-02f, -6.46153688e-02f, 1.96616352e-01f, 9.03714672e-02f, -1.57269150e-01f, -2.34158203e-01f, 1.26805469e-01f, 3.78723107e-02f, 8.58233497e-03f, 1.53593257e-01f,
  2.90449914e-02f, -2.52158910e-01f, 1.46700427e-01f, 2.51697779e-01f, 3.89951080e-01f, 1.94940805e-01f, 3.68531533e-02f, 1.80049673e-01f, -2.35957399e-01f, 2.28728309e-01f,
  -3.40931535e-01f, 1.38073951e-01f, -1.64603934e-01f, 2.36744955e-02f, 1.16435578e-02f, 8.97020921e-02f, -1.20383359e-01f, 1.21718094e-01f, -7.22889006e-02f, -1.76637411e-01f,
  -2.40814015e-02f, 1.47535622e-01f, 8.59126002e-02f, 2.56342515e-02f, -2.85690397e-01f, -4.59151417e-01f, -2.67094821e-01f, 2.83970777e-02f, -2.08316699e-01f, -1.70231536e-01f,
  -6.88816309e-02f, -5.76287471e-02f, 4.38815624e-01f, -6.64513037e-02f, -2.17249811e-01f, -1.75585635e-02f, 2.58230329e-01f, 1.93249006e-02f, -1.16561204e-01f, 1.76890403e-01f,
  7.74137899e-02f, 3.35998654e-01f, -5.25298342e-02f, 7.52304941e-02f, 2.41808265e-01f, -1.25229374e-01f, -3.20628285e-01f, 1.09522738e-01f, -1.32198662e-01f, -4.96878065e-02f,
  -1.03120707e-01f, 9.70853791e-02f, -4.68858182e-02f, 8.62324685e-02f, -2.39116251e-02f, -2.62423549e-02f, 9.40009803e-02f, 6.96568936e-02f, -1.22276336e-01f, 8.20322894e-03f,
  -1.57640994e-01f, 2.33712614e-01f, 7.71828219e-02f, 1.05622202e-01f, 1.96873203e-01f, -2.39150122e-01f, 9.71817300e-02f, 6.52326047e-02f, 2.03259081e-01f, 1.39651418e-01f,
  1.15147464e-01f, 1.44091040e-01f, -1.29495382e-01f, 1.35826515e-02f, 4.59211692e-02f, 3.50025535e-01f, 2.65811849e-02f, 3.27750325e-01f, 7.61437938e-02f, -1.92743436e-01f,
  2.60303617e-02f, -3.52783734e-03f, 7.46363401e-02f, 1.19912632e-01f, -1.82664543e-01f, 1.37460619e-01f, 2.04299733e-01f, 8.02637935e-02f, -3.12612444e-01f, -1.97437540e-01f,
  -3.88214923e-02f, -3.97412889e-02f, -2.69782450e-02f, -1.32761985e-01f, 5.12663424e-02f, 1.26020387e-01f, -7.31367245e-02f, 2.49370247e-01f, -3.94879915e-02f, 9.38503295e-02f,
  1.64678127e-01f, 1.76636100e-01f, 5.38891330e-02f, -1.83015317e-01f, -2.41176803e-02f, 2.38744885e-01f, 9.84279141e-02f, -3.61406840e-02f, -1.38335094e-01f, -9.18123201e-02f,
  8.55845436e-02f, -1.50164515e-01f, -1.47510013e-02f, 6.97648376e-02f, -3.13765295e-02f, 5.50434440e-02f, -2.63819218e-01f, -1.09701781e-02f, -3.11877225e-02f, -9.71775651e-02f,
  4.91119735e-02f, -1.85945496e-01f, 2.74940245e-02f, 1.29183695e-01f, -2.37631821e-03f, 4.23427932e-02f, 1.17112733e-02f, -5.38977273e-02f, -2.50278469e-02f, -1.49001837e-01f,
  -3.65672782e-02f, 2.02641040e-02f, -6.95730001e-02f, 3.33256096e-01f, -1.20308526e-01f, 6.54178411e-02f, 1.28528863e-01f, -9.20871496e-02f, -1.81163813e-03f, 4.46472794e-01f,
  -7.67921358e-02f, 1.07197657e-01f, 5.38817700e-03f, -1.65825143e-01f, 2.64304113e-02f, 2.96745226e-02f, 1.66255370e-01f, -2.67141964e-03f, -8.06605518e-02f, -2.53343601e-02f,
  1.14887252e-01f, 1.83476359e-01f, -1.39632806e-01f, -4.30918932e-02f, 6.13430738e-02f, 6.49268776e-02f, 6.19644746e-02f, -1.86227679e-01f, -1.42143425e-02f, 1.12291276e-01f,
  3.84488367e-02f, 2.41008729e-01f, -1.48819000e-01f, 4.45479080e-02f, 5.59383333e-02f, 2.06443295e-01f, 1.76957503e-04f, -1.36208043e-01f, 1.90525129e-01f, 2.11185500e-01f,
  2.75113545e-02f, 1.03161626e-01f, -1.51992247e-01f, -1.96892023e-02f, 5.74736372e-02f, -3.48437093e-02f, -1.75267369e-01f, 1.02317065e-01f, 1.75285533e-01f, -8.60527083e-02f,
  -2.67673861e-02f, -7.61135072e-02f, -1.09927550e-01f, 1.65944532e-01f, -9.28473994e-02f, -2.03526333e-01f, 1.87570229e-02f, 1.83325429e-02f, 1.53504565e-01f, 2.24301200e-02f,
  -3.16217169e-02f, -6.42266050e-02f, 1.87173903e-01f, 1.31546021e-01f, 8.73548985e-02f, -2.69924644e-02f, 1.08470999e-01f, -9.86424834e-02f, -3.31339352e-02f, 1.52080461e-01f,
  -3.80893648e-02f, 1.54107869e-01f, 3.07437591e-02f, 2.37802729e-01f, 1.25540242e-01f, -8.49282220e-02f, 2.47014210e-01f, 6.16865605e-02f, -1.09704614e-01f, -1.08390622e-01f,
  -4.01434936e-02f, -3.76950860e-01f, -1.45199552e-01f, 9.42706540e-02f, -4.13863035e-03f, -3.98103371e-02f, 3.73853028e-01f, 1.67009413e-01f, 1.42534956e-01f, -8.99803638e-02f,
  -7.38451025e-03f, 2.14462548e-01f, 3.08206119e-02f, -6.41920045e-02f, -3.31724733e-01f, -3.83291543e-01f, 3.82693410e-02f, 3.83027159e-02f, -1.84374690e-01f, -2.96565108e-02f,
  9.74148791e-03f, -2.57788867e-01f, 5.02956063e-02f, -2.41671905e-01f, 4.02365774e-02f, -2.86911428e-01f, -6.69697672e-02f, -2.27534637e-01f, -6.89248042e-03f, -2.54138768e-01f,
  -2.50369132e-01f, -1.57898754e-01f, 1.38205066e-01f, 1.92296486e-02f, -1.24158733e-01f, 5.65993972e-02f, 6.80155084e-02f, -5.38235195e-02f, 1.38400584e-01f, 9.65573788e-02f,
  1.34803221e-01f, -1.57184258e-01f, -3.24624091e-01f, -3.28111261e-01f, -2.98843905e-02f, 3.46424244e-02f, -7.07274526e-02f, 1.75384909e-01f, -1.98217537e-02f, -1.08473986e-01f,
  2.45299518e-01f, 2.29173705e-01f, 1.57708287e-01f, -1.06116205e-01f, -9.24379602e-02f, 3.26219052e-01f, -2.20346197e-01f, 7.69130737e-02f, 1.27926856e-01f, -6.25546509e-03f,
  6.30621910e-02f, -1.34072259e-01f, 1.89373307e-02f, 1.06847733e-01f, 4.00245041e-02f, -1.04034739e-02f, -6.28395053e-03f, -2.49180049e-01f, -2.73127973e-01f, 3.28703672e-01f,
  1.72577530e-01f, 2.09882319e-01f, -1.04803845e-01f, 3.86552364e-02f, -2.40670532e-01f, 1.51486754e-01f, -1.55420611e-02f, -2.13963851e-01f, 1.77287653e-01f, 6.24148361e-02f,
  6.48217127e-02f, 1.91799223e-01f, -2.71264642e-01f, -2.92567294e-02f, -5.11270277e-02f, -1.23590186e-01f, -2.17952684e-01f, -6.89739063e-02f, -7.71729574e-02f, 4.87690717e-02f,
  -1.02431662e-01f, -1.78901792e-01f, 6.91582114e-02f, 2.38797199e-02f, 5.58616780e-02f, -1.01011224e-01f, -2.22073436e-01f, 4.55664881e-02f, -5.21026626e-02f, -4.55090404e-02f,
  -1.85213834e-01f, -9.55601931e-02f, 1.65332168e-01f, 5.89569509e-02f, -2.55355716e-01f, -1.25680819e-01f, -1.49996623e-01f, -2.57757381e-02f, 6.47118986e-02f, 1.90370485e-01f,
  -1.37278589e-03f, -6.40964285e-02f, 4.49888669e-02f, 1.16147950e-01f, -4.36436050e-02f, -1.17036141e-01f, 1.83968991e-01f, 2.35381573e-01f, -2.11130515e-01f, -8.72941017e-02f,
  8.79637599e-02f, 2.96058536e-01f, 2.29388937e-01f, 3.27067040e-02f, 2.51650453e-01f, 1.25533482e-02f, 3.09008043e-02f, -2.13341136e-02f, 1.89158984e-03f, -9.70385000e-02f,
  -3.50053459e-02f, 2.95133531e-01f, 1.86850831e-01f, -2.02392533e-01f, 3.59146819e-02f, -5.75629510e-02f, -1.81780308e-02f, -3.00695628e-01f, -5.95029593e-02f, 1.20306268e-01f,
  8.65490884e-02f, 7.71559104e-02f, 1.88679658e-02f, 3.01810540e-02f, 1.16679996e-01f, 1.44593874e-02f, -5.45198545e-02f, 2.05558971e-01f, 1.77643239e-01f, -3.95958424e-01f,
  5.35806343e-02f, -1.39942735e-01f, 8.48725513e-02f, -2.02391565e-01f, -1.77644432e-01f, -3.00948620e-01f, 5.52932061e-02f, -2.14181662e-01f, -1.44634590e-01f, 2.96342950e-02f,
  7.33841360e-02f, -2.86029242e-02f, -3.84418935e-01f, 5.20635583e-02f, 1.48368999e-01f, -2.52262414e-01f, -9.00965035e-02f, -2.98806075e-02f, 1.64829612e-01f, 2.37137899e-02f,
  -8.59066322e-02f, -2.97794700e-01f, -3.64323705e-01f, -2.07179919e-01f, -2.59406175e-02f, 2.81239271e-01f, -1.27200022e-01f, 1.70298025e-01f, -1.36863673e-02f, 6.14175461e-02f,
  -1.32519946e-01f, -2.41559759e-01f, 2.75150746e-01f, 1.39940917e-01f, 1.17112640e-02f, 2.82999258e-02f, -1.97449401e-01f, -1.27982274e-02f, -1.74911067e-01f, -2.48171650e-02f,
  6.24017194e-02f, -1.47247493e-01f, 6.36536554e-02f, 1.14287488e-01f, -1.01983927e-01f, -7.45545551e-02f, -7.32088089e-02f, -8.11394081e-02f, -1.84137058e-02f, 1.09894700e-01f,
  1.31654784e-01f, 2.49114968e-02f, 8.91925469e-02f, 2.90804543e-02f, -1.67762429e-01f, 1.43343844e-02f, 1.62190974e-01f, 1.52363881e-01f, 1.26758605e-01f, -6.73425868e-02f,
  -3.60366469e-03f, 1.13569774e-01f, 2.73197033e-02f, -5.64337038e-02f, 1.63650230e-01f, -1.32014334e-01f, 4.62412275e-02f, 3.91216803e-04f, 1.52296722e-01f, 2.91774154e-01f,
  2.15110555e-02f, 1.66379094e-01f, -1.83719650e-01f, 5.37829921e-02f, -4.63443436e-02f, 1.32866412e-01f, 2.25773081e-02f, -9.35224444e-02f, -1.45460501e-01f, 1.74329624e-01f,
  -8.54798686e-03f, -1.19958110e-01f, -6.57939464e-02f, -6.11068867e-03f, 3.19807947e-01f, 4.01049852e-02f, 7.95537420e-03f, 9.65085477e-02f, -9.60936248e-02f, -1.35574773e-01f,
  -7.86417052e-02f, -3.24720740e-02f, 1.09783702e-01f, 6.66637197e-02f, -5.09127192e-02f, -1.66972145e-01f, -7.97624961e-02f, 5.18241286e-01f, -1.00096852e-01f, -6.51776865e-02f,
  1.37459099e-01f, -2.03959301e-01f, 1.37102619e-01f, -1.14708744e-01f, 1.63449094e-01f, 3.74690928e-02f, 4.46461849e-02f, 2.01357827e-01f, 3.99659202e-02f, -6.80568963e-02f,
  -2.09180176e-01f, 2.77497135e-02f, 1.74842775e-01f, -1.13410331e-01f, 8.21542144e-02f, 1.52403459e-01f, 1.57204065e-02f, 1.54448338e-02f, 1.24107435e-01f, 1.41238600e-01f,
  2.70864189e-01f, 1.52053863e-01f, 1.72500134e-01f, 2.32568234e-02f, 1.22690760e-01f, 1.10570751e-01f, -1.61098409e-02f, 2.65612304e-01f, 3.05694435e-02f, -2.09695101e-02f,
  3.98292299e-03f, -1.54536501e-01f, 1.56472549e-01f, 9.17655677e-02f, -1.08906090e-01f, 2.70057619e-01f, 1.40515625e-01f, 4.97419424e-02f, -1.72608182e-01f, 1.14844210e-01f,
  5.50415507e-03f, -2.20355213e-01f, -3.32125217e-01f, 1.60005435e-01f, -1.20335683e-01f, 2.30153009e-01f, -1.57310903e-01f, 1.59896016e-02f, 4.23221998e-02f, 5.56416921e-02f,
  1.97364300e-01f, -2.09383920e-01f, 2.67835874e-02f, -1.02372915e-01f, 4.14237045e-02f, -4.85673659e-02f, -1.98929325e-01f, -4.71315533e-02f, -2.15617999e-01f, -7.45725557e-02f,
  7.21219778e-02f, 1.23381436e-01f, -8.96563977e-02f, 5.23409061e-02f, 1.81290522e-01f, 4.46024770e-03f, 4.39793356e-02f, 1.05343401e-01f, 7.51987696e-02f, 1.04314312e-01f,
  1.50014251e-01f, 1.86468437e-01f, -7.88107067e-02f, -9.99425054e-02f, 1.53770953e-01f, 1.25781626e-01f, -1.50842983e-02f, -9.66981202e-02f, 6.17142580e-02f, -7.98643157e-02f,
  7.62190530e-03f, -1.58607394e-01f, 3.34097631e-02f, 1.67686179e-01f, 1.73757687e-01f, 9.35526639e-02f, -1.55878231e-01f, -1.17824033e-01f, 2.87250038e-02f, 4.44912836e-02f,
  -2.27735136e-02f, -1.63957655e-01f, 2.56253444e-02f, 1.07593387e-01f, -3.58663239e-02f, 8.25481713e-02f, -1.06140919e-01f, 1.90658286e-01f, 1.25678238e-02f, -2.28343587e-02f,
  1.54566109e-01f, -5.54708913e-02f, -3.28001790e-02f, 6.90575764e-02f, -9.25060734e-02f, -4.13715765e-02f, -2.62122929e-01f, 4.23038751e-02f, -1.21777222e-01f, -8.90318677e-02f,
  -1.80556476e-01f, 1.38614744e-01f, 7.59660751e-02f, 7.73219392e-02f, -8.45373049e-03f, -6.42241612e-02f, 1.06110960e-01f, -1.15586422e-01f, -1.82333663e-01f, 1.56124473e-01f,
  3.97471972e-02f, 8.01338702e-02f, -1.47141322e-01f, 2.61210296e-02f, -9.35853571e-02f, -1.73272062e-02f, 5.45752905e-02f, 2.62314558e-01f, -1.30930766e-01f, -1.85219005e-01f,
  1.05647035e-01f, 9.67420172e-03f, -1.59978941e-01f, -2.27927323e-02f, 1.05147451e-01f, -1.19085804e-01f, -3.15355629e-01f, 1.64665714e-01f, 1.89848289e-01f, -1.51436463e-01f,
  1.93834960e-01f, 1.88607797e-02f, 2.14481249e-01f, -1.49849519e-01f, 2.16514757e-03f, 9.01903883e-02f, 1.28482074e-01f, 1.28072232e-01f, -1.35188699e-01f, -1.92102328e-01f,
  9.62996855e-02f, -3.50542367e-02f, -3.75024937e-02f, 8.28725249e-02f, 1.42100468e-01f, -5.88875890e-01f, 2.12758332e-01f, -5.49275279e-02f, 2.68721790e-03f, -2.69530088e-01f,
  -1.07800879e-01f, 1.99161008e-01f, 9.83292758e-02f, -9.47914198e-02f, -3.20345461e-01f, 1.87888339e-01f, -5.05044451e-03f, 1.18439607e-01f, -1.62955776e-01f, -2.33271793e-02f,
  5.83261214e-02f, 3.59370224e-02f, 7.00801015e-02f, -1.85516588e-02f, 2.90612012e-01f, -2.11479247e-01f, 2.66913902e-02f, -9.37233269e-02f, -1.64661378e-01f, 3.62313241e-02f,
  7.97348917e-02f, 2.60746628e-01f, 6.09727986e-02f, 1.73232287e-01f, 1.60545260e-01f, 4.44918834e-02f, 5.85878007e-02f, 1.68823078e-01f, 8.42154175e-02f, 2.16806129e-01f,
  -2.42925197e-01f, -1.83338057e-02f, -1.95790708e-01f, -1.26988709e-01f, -9.14157704e-02f, -2.23238066e-01f, -1.50887226e-03f, 1.82138637e-01f, 4.36388180e-02f, -3.51549573e-02f,
  9.87948850e-02f, 9.84832868e-02f, 3.68506670e-01f, 1.63572356e-01f, -5.16227186e-01f, -1.76137686e-01f, -1.75908223e-01f, -5.66647314e-02f, 7.82279223e-02f, -8.37835148e-02f,
  9.94539112e-02f, 7.57401250e-03f, 3.95418853e-01f, 5.46805654e-03f, -1.87231805e-02f, 2.96929851e-03f, 2.57887125e-01f, 1.09277919e-01f, 1.05565064e-01f, 2.82070064e-03f,
  2.36983716e-01f, 2.84990013e-01f, 1.01552866e-01f, 1.48278430e-01f, 1.07697859e-01f, 1.92742735e-01f, -5.67329414e-02f, 5.44575155e-02f, -7.41966590e-02f, 1.93804130e-01f,
  6.21463507e-02f, 9.27157253e-02f, 1.44568071e-01f, 3.26037526e-01f, 4.34818901e-02f, 2.03809794e-02f, 2.00957939e-01f, -3.48559953e-02f, 3.75051573e-02f, 6.80851787e-02f,
  1.51553050e-01f, 1.91487789e-01f, -2.88697444e-02f, 1.52395740e-01f, -1.70013662e-02f, -3.71218883e-02f, -8.08214117e-03f, 3.22417080e-01f, 2.48415381e-01f, 2.87347883e-02f,
  2.98594028e-01f, 3.36460143e-01f, -2.00907573e-01f, 5.89953735e-02f, 2.93018341e-01f, -1.05790049e-01f, -5.08333445e-02f, -1.23966999e-01f, 2.69340962e-01f, -1.41004905e-01f,
  -2.62265801e-01f, -4.16359343e-02f, -2.27503702e-01f, -1.41666710e-01f, 2.82687187e-01f, 3.22384089e-02f, 9.88036469e-02f, -2.58040428e-01f, -9.31690857e-02f, -8.55322853e-02f,
  7.37110674e-02f, 2.49718726e-01f, -1.62870213e-01f, -1.83790728e-01f, -2.10581973e-01f, -3.52635711e-01f, 2.34099641e-01f, -1.39756396e-01f, -4.11959350e-01f, 1.50082201e-01f,
  3.04931432e-01f, 1.12645580e-02f, 8.28951132e-03f, 1.61197886e-01f, -1.30121857e-01f, -2.64307708e-01f, -1.64187536e-01f, -5.64894788e-02f, 3.19302708e-01f, -5.87359630e-02f,
  -8.21120143e-02f, -5.16996831e-02f, 2.40115654e-02f, -7.11021423e-02f, 1.71070665e-01f, -4.60739098e-02f, 1.33259535e-01f, 1.23979338e-01f, 1.02023654e-01f, 1.12544261e-01f,
  -1.59733608e-01f, 3.12407970e-01f, 1.38308063e-01f, -1.41561925e-01f, -1.44613177e-01f, -3.82447913e-02f, -2.25375623e-01f, 7.21103549e-02f, 3.30106057e-02f, -6.72801072e-03f,
  3.22704986e-02f, -1.19921900e-01f, 1.92075633e-02f, 7.93038756e-02f, 1.45527095e-01f, 8.20174739e-02f, 5.62269660e-03f, -1.60237297e-01f, 3.21496159e-01f, 2.07812741e-01f,
  -5.11247478e-02f, 7.01991469e-02f, 8.00668970e-02f, -2.09483411e-02f, 4.27450314e-02f, -4.51432839e-02f, 4.65994850e-02f, -4.97510377e-03f, 1.04708299e-01f, 2.40321040e-01f,
  3.18486243e-01f, -2.25805774e-01f, 1.75942048e-01f, -4.04013060e-02f, 1.99558005e-01f, -1.82951465e-01f, 1.91713601e-01f, 6.97245523e-02f, 8.89874697e-02f, 7.22483993e-02f,
  -5.63302673e-02f, -1.32169709e-01f, 2.12398395e-01f, 1.16674751e-01f, 7.24832118e-02f, 8.61234814e-02f, 1.06321052e-01f, -1.90783031e-02f, 1.31404638e-01f, -5.15735969e-02f,
  7.98646361e-02f, -8.66635293e-02f, -1.14842743e-01f, 4.71470170e-02f, 3.19372416e-02f, -7.02762306e-02f, -2.25595355e-01f, 2.36458313e-02f, 2.60549963e-01f, 1.09487593e-01f,
  1.44605592e-01f, 2.03831688e-01f, 2.75191665e-01f, -1.10742703e-01f, 1.79255158e-01f, -1.31142557e-01f, 2.38735080e-01f, -9.40296575e-02f, -8.90897214e-02f, -8.89723301e-02f,
  -1.27603531e-01f, -9.74219367e-02f, -9.66738462e-02f, 1.10553205e-01f, 6.75199255e-02f, -1.43066913e-01f, 1.52630836e-01f, -6.11181147e-02f, 2.44836867e-01f, 8.25084224e-02f,
  -1.20554328e-01f, -2.03835145e-01f, 4.64768223e-02f, 1.30569667e-01f, 4.25943509e-02f, 1.34605348e-01f, 2.65127301e-01f, -1.12504363e-01f, 1.48925319e-01f, -7.49434233e-02f,
  -9.90004465e-02f, -2.93603450e-01f, -3.01798098e-02f, 2.74401635e-01f, 1.35893524e-01f, -4.12056893e-02f, 1.76825654e-02f, -1.02311529e-01f, 1.32718563e-01f, -8.41469616e-02f,
  -1.02841422e-01f, 1.29341900e-01f, 2.55246222e-01f, 1.63361549e-01f, -1.03063792e-01f, 6.87375739e-02f, 1.76340222e-01f, 1.41920030e-01f, 3.83190885e-02f, 3.63422707e-02f,
  6.11851783e-03f, -9.00919735e-02f, 7.22792000e-02f, -5.97840250e-02f, 1.64919212e-01f, -2.33022943e-02f, -2.74568111e-01f, -2.43741825e-01f, 5.68811744e-02f, -3.01442266e-01f,
  1.18674882e-01f, 8.73368904e-02f, -3.34839299e-02f, -9.82027221e-03f, -1.06526516e-01f, 2.72103138e-02f, 3.96385103e-01f, -2.66815275e-01f, 2.00524479e-01f, -1.20268360e-01f,
  1.18336558e-01f, 2.56647170e-01f, -7.91306198e-02f, -2.43367627e-01f, -1.11143328e-01f, -1.39273450e-01f, -8.97064656e-02f, 1.66192591e-01f, -1.48104817e-01f, 3.01534440e-02f,
  1.63120851e-01f, 1.27322078e-01f, -1.13307916e-01f, -2.48709157e-01f, 7.78875574e-02f, 2.00227015e-02f, 1.22378379e-01f, -1.13817997e-01f, -2.65709937e-01f, -1.19729772e-01f,
  -1.45457894e-01f, 5.32542206e-02f, -2.50460226e-02f, 1.36357889e-01f, -2.42589004e-02f, 4.17417772e-02f, -1.92773029e-01f, -2.11788967e-01f, 4.21038382e-02f, 2.67492890e-01f,
  1.30087256e-01f, 2.04890326e-01f, -9.20739844e-02f, -7.90410861e-02f, 1.14124380e-01f, 7.85093084e-02f, 5.74770942e-03f, -1.60110161e-01f, -2.32581459e-02f, 2.16186661e-02f,
  2.35219356e-02f, 2.75053587e-02f, -1.75013006e-01f, 3.94309275e-02f, 6.41244231e-03f, 5.29258624e-02f, -1.54431388e-01f, -5.34577221e-02f, -8.07151124e-02f, -1.92688778e-01f,
  2.02662777e-02f, 3.29867393e-01f, 1.55599430e-01f, 1.60653010e-01f, -2.05224276e-01f, 2.38850117e-02f, -2.24920154e-01f, -1.49528766e-02f, 5.71186244e-02f, -3.67375230e-03f,
  3.07383575e-02f, 1.91353351e-01f, 1.48744404e-01f, 1.84191354e-02f, -1.42351925e-01f, -2.41785139e-01f, 2.98067659e-01f, -1.30522817e-01f, 1.95066512e-01f, 6.60684612e-03f,
  4.59943786e-02f, 6.69609709e-03f, 9.16737840e-02f, -3.26590016e-02f, -1.86755568e-01f, 1.88883264e-02f, -1.25894591e-01f, 1.95193321e-01f, -8.61040503e-03f, -2.74605662e-01f,
  1.01339653e-01f, 3.92215580e-01f, 2.17546731e-01f, 7.65620396e-02f, 7.40911663e-02f, 1.42183900e-01f, 1.11344308e-01f, -1.39898747e-01f, 2.83152033e-02f, 1.68267071e-01f,
  -7.03462958e-02f, -1.57815129e-01f, 1.54117763e-01f, -2.23532230e-01f, 1.14914298e-01f, -1.97267234e-02f, 1.78694487e-01f, 1.00073561e-01f, 1.46035030e-01f, -9.44856852e-02f,
  -8.79608244e-02f, -1.03884168e-01f, -9.19893309e-02f, 1.59838215e-01f, -2.63641387e-01f, 9.63444933e-02f, 7.74660632e-02f, 4.70988713e-02f, 2.29701102e-02f, -9.63592380e-02f,
  6.39689788e-02f, -9.81542692e-02f, -1.27443165e-01f, 1.95016071e-01f, -4.58239280e-02f, -1.01738051e-01f, 1.22379914e-01f, 1.13397479e-01f, -2.36445349e-02f, 1.55466110e-01f,
  1.61596090e-02f, -1.20704092e-01f, -1.51838869e-01f, -1.10708669e-01f, 9.56292078e-02f, 1.49795622e-01f, -1.32666409e-01f, 6.11940213e-02f, 7.52901956e-02f, 1.42837375e-01f,
  -5.30619100e-02f, 6.52914718e-02f, 4.23828550e-02f, -2.94224191e-02f, -3.20923924e-02f, 2.08302274e-01f, 1.62298039e-01f, 3.32676135e-02f, 1.06030963e-01f, 4.70962077e-02f,
  1.97786242e-01f, 3.66708040e-01f, -2.67945319e-01f, 7.10193068e-02f, 3.04025084e-01f, -1.63971901e-01f, 1.76826805e-01f, 9.33612362e-02f, 1.63836315e-01f, -5.34915924e-03f,
  7.26496987e-03f, 1.91202536e-01f, 2.86508203e-02f, 4.26164195e-02f, 3.20130587e-01f, -7.75663778e-02f, -1.34647861e-01f, -1.03953741e-01f, 1.02643363e-01f, 1.31891459e-01f,
  1.37144387e-01f, 1.91378504e-01f, -1.21532746e-01f, 4.36888672e-02f, -9.23197195e-02f, -2.85407186e-01f, 4.28742766e-02f, -3.28558564e-01f, -3.60572308e-01f, 2.88832515e-01f,
  2.41326243e-01f, -8.95692110e-02f, 1.08794510e-01f, 2.61139363e-01f, -7.20497407e-03f, -2.93647975e-01f, -1.22295126e-01f, 1.40689649e-02f, 2.41064891e-01f, -1.80158228e-01f,
  -4.77112904e-02f, -1.67422146e-01f, 5.88283613e-02f, 2.67149415e-02f, 2.53647476e-01f, 1.51116163e-01f, 5.70536554e-02f, -5.70229702e-02f, -6.15318455e-02f, 1.32045671e-01f,
  -2.18499694e-02f, 3.50239277e-01f, -1.08715892e-01f, -1.69439897e-01f, -1.70006678e-01f, -2.18334198e-01f, -1.53780043e-01f, 1.45675436e-01f, -8.37507918e-02f, 1.16095223e-01f,
  1.38403505e-01f, 2.67563667e-02f, -8.96838494e-03f, 4.52572778e-02f, 6.19464256e-02f, -1.50296716e-02f, -2.29717493e-01f, -1.85525209e-01f, 1.26985088e-01f, -1.74091503e-01f,
  2.08134532e-01f, -6.24758787e-02f, 1.77673861e-01f, -5.30281030e-02f, -4.64809239e-02f, 2.73055017e-01f, 5.80880530e-02f, 1.87186256e-01f, -5.31485491e-02f, -1.46464586e-01f,
  1.46644306e-03f, 1.09747268e-01f, -8.00555199e-02f, 1.57103792e-01f, 1.92137778e-01f, 6.82997480e-02f, 4.82327379e-02f, 3.01222503e-02f, -1.42587602e-01f, -2.17927098e-02f,
  -1.44261152e-01f, -2.09778383e-01f, -3.27132463e-01f, -9.46994405e-03f, 2.98099697e-01f, 3.96558084e-02f, 1.49708003e-01f, 2.05993593e-01f, -1.51362970e-01f, 2.35577524e-02f,
  -2.91429281e-01f, -1.36280015e-01f, -5.85751384e-02f, -1.57053590e-01f, 7.65034780e-02f, 1.11288195e-02f, 2.87519157e-01f, 2.03557044e-01f, 9.32914317e-02f, 1.84981097e-02f,
  -8.48845616e-02f, 2.73585226e-02f, 5.47351725e-02f, 7.65047446e-02f, 1.51771665e-01f, 2.55876780e-01f, -5.09451367e-02f, -2.41417497e-01f, -1.53282627e-01f, 9.77412146e-03f,
  1.74658462e-01f, -1.47473412e-02f, 4.63818982e-02f, -3.89368795e-02f, 7.14003146e-02f, -1.99996650e-01f, 8.13907385e-02f, 1.19157203e-01f, -1.93593383e-01f, -1.31303325e-01f,
  -1.24031985e-02f, 2.93642610e-01f, -5.99602908e-02f, -1.30927503e-01f, -3.59982923e-02f, 5.19683883e-02f, -7.16116279e-02f, -9.48659703e-02f, 7.01724216e-02f, 9.71705392e-02f,
  1.20713562e-01f, 2.20504433e-01f, -1.15022413e-01f, -3.43212456e-01f, -1.26836076e-01f, 2.46839076e-01f, -6.90733790e-02f, 1.14958741e-01f, 9.99986678e-02f, 1.47461280e-01f,
  -8.25311169e-02f, -2.18546338e-04f, 3.07314098e-03f, 3.13070603e-02f, 2.11511284e-01f, 1.58591330e-01f, -1.00638419e-01f, 5.28976582e-02f, 1.13870567e-02f, 1.43752456e-01f,
  3.92408073e-02f, -1.90101102e-01f, -8.47016275e-02f, 1.68145895e-02f, -1.88076973e-01f, 6.60448447e-02f, -2.23969877e-01f, 2.61612087e-01f, 1.02509715e-01f, 3.83659303e-02f,
  9.57292169e-02f, 1.30738243e-01f, -2.30878145e-01f, 1.38043001e-01f, -8.74951109e-02f, -1.28651336e-01f, -1.12399861e-01f, 1.05218396e-01f, -1.24475854e-02f, 5.11896424e-02f,
  -2.02544823e-01f, 1.39988735e-02f, 5.42488620e-02f, 1.16029732e-01f, 1.15417220e-01f, 1.82250962e-01f, 1.37533337e-01f, -3.14914063e-02f, -9.66400802e-02f, 2.03264747e-02f,
  -1.77429214e-01f, -8.92162323e-02f, -1.30894706e-01f, 8.19847509e-02f, -1.24665692e-01f, -1.28182163e-02f, -8.48123431e-02f, -2.23104464e-04f, -1.08466856e-01f, -1.31759286e-01f,
  1.35837719e-01f, 1.85378656e-01f, -2.75044709e-01f, 1.71152741e-01f, -3.11697535e-02f, -6.91288561e-02f, -6.72079548e-02f, -2.46455923e-01f, 1.96768180e-01f, 4.99215908e-02f,
  -4.05412680e-03f, -6.21293299e-02f, 7.61862099e-02f, 7.63662085e-02f, -1.33272503e-02f, 5.56766167e-02f, 4.70098853e-02f, -3.53405140e-02f, 1.90367371e-01f, -1.75022200e-01f,
  -3.16564858e-01f, -1.88683122e-02f, -1.83068383e-02f, -4.17253301e-02f, 4.37166318e-02f, -1.28894076e-01f, 1.07842632e-01f, 7.77022988e-02f, -3.14169109e-01f, -9.45179835e-02f,
  2.98968982e-03f, -1.08428448e-01f, 9.00710076e-02f, -1.76542271e-02f, -1.69709653e-01f, 1.81119233e-01f, -5.92256058e-03f, 8.13348964e-02f, 1.70345590e-01f, 2.58314580e-01f,
  4.74058501e-02f, -7.92212598e-03f, 2.44960144e-01f, 1.51152849e-01f, 6.52912259e-02f, -2.41314396e-01f, -8.70326459e-02f, 8.96502435e-02f, 1.41450703e-01f, 2.54306108e-01f,
  1.53854772e-01f, 1.50980577e-01f, 6.79631904e-02f, 8.61004591e-02f, -1.33068159e-01f, 1.43282175e-01f, 2.25990981e-01f, 3.28990996e-01f, 3.28663170e-01f, -1.68983653e-01f,
  -6.97346926e-02f, 1.25208527e-01f, -7.63692632e-02f, -1.07911885e-01f, 1.95801571e-01f, 1.41038731e-01f, 1.19878426e-01f, -1.90131381e-01f, 3.69920917e-02f, 1.09069115e-02f,
  1.84980765e-01f, 3.18986148e-01f, 1.01387128e-01f, -8.89230743e-02f, 4.21036743e-02f, -1.74265891e-01f, 1.43031582e-01f, -9.64896381e-02f, 1.41160756e-01f, -6.67627677e-02f,
  1.01695500e-01f, 2.54505575e-01f, 8.37681070e-02f, 2.32174590e-01f, 8.80874619e-02f, -8.52362886e-02f, 1.41185313e-01f, 1.72316939e-01f, 2.15770125e-01f, -5.82110286e-02f,
  3.05284768e-01f, 3.22698243e-02f, 3.04364145e-01f, 2.21044064e-01f, 8.42594504e-02f, 2.10226029e-02f, 1.09074168e-01f, -2.11276025e-01f, -6.64904937e-02f, -4.32930626e-02f,
  2.56711900e-01f, -1.43261671e-01f, 1.10818252e-01f, -1.41589254e-01f, 9.90949422e-02f, -1.38185278e-01f, -1.15483940e-01f, -1.31377935e-01f, 1.81380942e-01f, 2.22380891e-01f,
  -1.33248091e-01f, 6.69338480e-02f, -2.22586334e-01f, -8.17529708e-02f, 1.03610143e-01f, 1.28798664e-01f, 9.87776294e-02f, 1.88683700e-02f, -8.34411234e-02f, 2.11136863e-02f,
  -1.39120338e-03f, 2.12334022e-01f, -3.89230996e-01f, 1.58532202e-01f, 1.54066339e-01f, 7.83587396e-02f, 1.18106976e-01f, -6.75264373e-02f, 2.70817459e-01f, -8.40217769e-02f,
  -1.08283430e-01f, 9.88103300e-02f, -1.27268247e-02f, -6.14679046e-02f, 1.53749719e-01f, 3.93796787e-02f, -2.04120353e-02f, -1.73669696e-01f, 1.90183967e-01f, 8.30508396e-02f,
  1.48353711e-01f, 2.24195763e-01f, 2.12031454e-02f, -5.03165685e-02f, 1.75650001e-01f, -4.86363433e-02f, -8.01681429e-02f, -3.70902658e-01f, -1.58470636e-03f, -3.60921808e-02f,
  -4.56400029e-02f, -1.64385632e-01f, 4.51275371e-02f, 1.87073246e-01f, 4.93768677e-02f, -1.66258484e-01f, -1.72948271e-01f, -1.37230352e-01f, -7.58271143e-02f, -2.01900527e-01f,
  -5.46749383e-02f, -5.18222116e-02f, 1.20550834e-01f, -8.22861046e-02f, 4.94561531e-02f, 5.16942367e-02f, -2.00818509e-01f, 4.64810617e-02f, 1.17005378e-01f, -1.59742847e-01f,
  1.75205544e-01f, 3.60668629e-01f, -1.91181153e-02f, -3.66156250e-01f, -3.13655496e-01f, -8.30920190e-02f, -2.09423885e-01f, 9.78582911e-03f, -2.87957247e-02f, 2.22519845e-01f,
  3.12316995e-02f, 6.50676563e-02f, -1.37988910e-01f, 8.15813467e-02f, -1.56029046e-01f, 3.72581929e-02f, 1.28469661e-01f, 1.30979449e-01f, -1.37850761e-01f, 1.94516569e-01f,
  -1.10994384e-01f, 8.26675594e-02f, -1.28444657e-01f, -1.37214288e-01f, 9.73285064e-02f, 1.53164983e-01f, 8.63501355e-02f, 2.15278253e-01f, -2.11835295e-01f, -9.27396119e-02f,
  1.79807812e-01f, 3.04129541e-01f, -1.76461153e-02f, 1.98183566e-01f, 3.64313908e-02f, 5.68062328e-02f, 3.27350870e-02f, 2.11549066e-02f, 1.81063963e-03f, 1.42511547e-01f,
  2.44417638e-01f, 3.23923379e-01f, -2.99240705e-02f, 1.20767578e-02f, -6.96570724e-02f, -1.33126527e-02f, -7.82663375e-02f, -1.03384338e-01f, 2.23837629e-01f, 1.48242801e-01f,
  1.74550951e-01f, 6.93723932e-02f, -2.02665746e-01f, 3.56471092e-01f, 8.30301344e-02f, -6.32147416e-02f, 9.51226726e-02f, -1.50891924e-02f, 8.44146032e-03f, 1.29722625e-01f,
  5.02296211e-03f, -7.52460286e-02f, -5.67161962e-02f, 9.16379094e-02f, 1.84887387e-02f, -1.22768894e-01f, -1.28508314e-01f, 1.89998299e-01f, 3.05151284e-01f, 1.19664773e-01f,
  1.80702031e-01f, 8.20284709e-02f, 1.26863480e-01f, -8.10118020e-02f, 4.00045887e-03f, 6.45878166e-03f, 1.22702137e-01f, -2.95761563e-02f, 8.91205370e-02f, 8.70611966e-02f,
  7.14582717e-03f, -3.24571617e-02f, -9.82349180e-03f, -2.09979683e-01f, -2.44205400e-01f, -2.02798739e-01f, 1.10429823e-02f, -3.84734087e-02f, 8.86983424e-02f, 3.53685096e-02f,
  -2.30824485e-01f, -1.36232302e-01f, 2.42450461e-01f, 2.68057108e-01f, -3.92736541e-03f, -2.23002322e-02f, -1.75988019e-01f, -2.29598179e-01f, 2.85204314e-02f, -6.92758486e-02f,
  -1.58359826e-01f, -1.06279051e-03f, 1.33064151e-01f, -3.02361101e-02f, -1.81328341e-01f, 3.14408801e-02f, 1.64026618e-01f, -1.04763843e-02f, 9.64144915e-02f, -4.11118083e-02f,
  4.64043627e-03f, -3.78578976e-02f, 1.36562288e-01f, -1.90198258e-01f, 9.47160497e-02f, 1.30682275e-01f, 9.14830640e-02f, 2.39138398e-02f, -1.98833063e-01f, -1.78726509e-01f,
  -4.55404855e-02f, -1.13404363e-01f, 1.01684712e-01f, -3.78702022e-02f, 1.97691932e-01f, 1.27179787e-01f, 1.46008089e-01f, 5.37891909e-02f, 7.07781836e-02f, -9.33254212e-02f,
  -6.35766611e-02f, 9.88261551e-02f, -1.90465763e-01f, -1.70636177e-02f, 6.62669423e-04f, 8.66085142e-02f, 2.54439563e-02f, -6.55345470e-02f, -6.18575811e-02f, -3.20379287e-01f,
  1.69782303e-02f, -1.75795063e-01f, 1.85302705e-01f, -4.30028215e-02f, 5.19663654e-02f, -8.13738853e-02f, -1.14994861e-01f, -4.95821796e-02f, 1.51934013e-01f, -8.21430162e-02f,
  1.65537998e-01f, -5.73004968e-02f, 1.07811972e-01f, 1.13454983e-01f, -1.30808782e-02f, 1.75856158e-01f, -1.34118153e-02f, 2.43399799e-01f, -1.18711963e-01f, 5.45275137e-02f,
  3.57422441e-01f, 1.93249047e-01f, -3.36419269e-02f, 8.07339922e-02f, 5.00979461e-02f, 2.29289141e-02f, 8.63585025e-02f, 8.21473822e-02f, -1.92932129e-01f, 2.44188663e-02f,
  4.04945970e-01f, 4.52887639e-02f, -1.02480546e-01f, 1.82187129e-02f, -8.75941962e-02f, 4.35434617e-02f, -8.55104849e-02f, -3.13239813e-01f, 1.21929422e-01f, -6.63871616e-02f,
  -1.58065975e-01f, -1.80486813e-01f, 7.33706355e-02f, -7.80695900e-02f, 2.72942901e-01f, -1.61226422e-01f, -7.09311441e-02f, 6.39838651e-02f, -1.54092312e-01f, -2.81804115e-01f,
  1.66242003e-01f, -8.96102414e-02f, -7.00180084e-02f, 1.55221224e-01f, -1.44510806e-01f, 2.73438454e-01f, -2.37854809e-01f, -2.09118977e-01f, 1.50929801e-02f, 7.86675215e-02f,
  -1.06942840e-01f, 6.78648725e-02f, 1.94534406e-01f, 1.26500979e-01f, 2.95483440e-01f, 3.15117925e-01f, 1.92580074e-01f, 2.60653287e-01f, -5.36049567e-02f, -1.30325288e-01f,
  -1.13594279e-01f, 1.17780916e-01f, 1.89803615e-02f, 1.47128180e-01f, 7.20824748e-02f, -3.23126733e-01f, 8.28683898e-02f, 7.30458796e-02f, -2.01185923e-02f, 1.24787122e-01f,
  1.97569564e-01f, 1.08929425e-01f, 7.11394772e-02f, -6.16677254e-02f, -4.56841469e-01f, -3.91657203e-01f, -8.88212696e-02f, 2.29804367e-01f, 9.50176045e-02f, -3.67390752e-01f,
  2.59110378e-03f, -6.07624836e-02f, 1.85378775e-01f, 2.02056944e-01f, -1.45716906e-01f, 6.29391596e-02f, 3.05653989e-01f, 1.56454206e-01f, 1.60119489e-01f, 1.73667774e-01f,
  1.06421504e-02f, -6.61983415e-02f, 2.83352174e-02f, 1.02746189e-01f, 3.04023623e-01f, -3.97070833e-02f, -6.27470836e-02f, 3.41892205e-02f, 8.57477337e-02f, 2.87999511e-02f,
  2.26315394e-01f, 1.54026188e-02f, 1.99032456e-01f, -5.27700596e-03f, -9.87122282e-02f, 8.28552023e-02f, -2.04835474e-01f, 4.78575528e-02f, 1.08477250e-01f, 2.30186030e-01f,
  3.10461707e-02f, -8.68809521e-02f, -3.89794409e-02f, -9.67871100e-02f, 1.40657648e-01f, -2.44291291e-01f, 1.34891257e-01f, -1.07899711e-01f, -1.72514305e-01f, -8.43715295e-02f,
  9.70009528e-03f, -1.30495682e-01f, 2.29399666e-01f, 1.07960694e-01f, -1.01737469e-01f, 8.31774846e-02f, 1.77197322e-01f, -3.99392061e-02f, 7.31911436e-02f, -6.99729025e-02f,
  2.62893677e-01f, 4.83018681e-02f, 5.81634380e-02f, 1.85681790e-01f, -6.38345405e-02f, -3.33999172e-02f, -8.68411362e-02f, 1.75092444e-02f, 1.34213731e-01f, -2.17865989e-01f,
  -1.28286272e-01f, 2.42956486e-02f, 1.68392167e-03f, -1.03562102e-01f, 9.80130509e-02f, 1.66404143e-01f, 9.38838422e-02f, 1.69874653e-01f, 2.31980056e-01f, 2.29468197e-02f,
  -7.52637386e-02f, -1.23337074e-03f, 6.81174397e-02f, -1.46204699e-02f, -3.65550630e-02f, 2.76849300e-01f, 1.98014438e-01f, 1.61470667e-01f, -6.01051040e-02f, -1.42574817e-01f,
  4.17505465e-02f, 6.40911609e-02f, 2.30558127e-01f, -1.07937761e-01f, -1.25970647e-01f, 1.21540740e-01f, -5.78975305e-02f, -6.70556650e-02f, 8.64594728e-02f, 1.00089915e-01f,
  -6.85029626e-02f, -4.74111065e-02f, -1.01102039e-01f, 1.20108217e-01f, -7.15641538e-03f, 1.31229997e-01f, -6.50885329e-02f, -8.82954225e-02f, 8.53456184e-02f, 1.01151504e-01f,
  4.14892426e-03f, -7.46357664e-02f, -4.05471846e-02f, 9.51293483e-02f, 2.85732239e-01f, 4.37701270e-02f, -1.75163850e-01f, -1.41209349e-01f, 2.97617298e-02f, -2.09065020e-01f,
  1.82649240e-01f, 7.11717680e-02f, 7.31041729e-02f, -2.50077657e-02f, 4.22137193e-02f, 1.77070096e-01f, -7.08032865e-03f, -3.63074765e-02f, -2.86345854e-02f, -8.63693506e-02f,
  1.85712993e-01f, -1.89272881e-01f, -1.63605213e-01f, -3.25645655e-02f, 3.02604400e-02f, 1.45349428e-01f, -6.36665672e-02f, -2.41709873e-02f, -1.10584563e-02f, -1.28134176e-01f,
  -1.12074003e-01f, -1.92894578e-01f, -2.18990460e-01f, -3.61838937e-02f, 2.38215432e-01f, 3.60013843e-02f, -7.05772117e-02f, 1.15269102e-01f, -1.02177016e-01f, 6.19902974e-03f,
  -1.61422715e-01f, -2.51960248e-01f, 1.14639260e-01f, 9.99525934e-02f, 1.70902442e-02f, 5.58274575e-02f, 1.39379472e-01f, 1.80468723e-01f, -2.38975324e-02f, 5.28506041e-02f,
  -1.54059008e-02f, 1.67450588e-02f, -7.96393678e-02f, 1.81183159e-01f, 1.18356459e-01f, 3.10358793e-01f, 1.88074097e-01f, -1.14648230e-01f, 1.09895460e-01f, -8.76866728e-02f,
  1.07570209e-01f, -1.25661315e-02f, -6.92880303e-02f, 3.33549920e-03f, 2.85631448e-01f, 1.56750113e-01f, 2.40003631e-01f, -1.16956979e-02f, 2.53509700e-01f, 2.93348670e-01f,
  -8.24650228e-02f, -2.49194011e-01f, 1.22736897e-02f, 2.80751288e-01f, 2.45891973e-01f, 2.06658497e-01f, 1.33189052e-01f, 1.91587985e-01f, 1.31108657e-01f, 6.48481678e-03f,
  9.44680050e-02f, -3.13796178e-02f, -1.11265719e-01f, 1.44903868e-01f, 2.42917717e-01f, 1.41061336e-01f, 2.29591519e-01f, 2.42437780e-01f, 1.64217949e-01f, -3.51552427e-01f,
  1.38759688e-01f, 2.07366288e-01f, 1.53141215e-01f, -6.59222901e-02f, -2.66214490e-01f, 6.38169572e-02f, 1.16132423e-01f, 1.20093241e-01f, -2.24573076e-01f, -1.72710847e-02f,
  5.57728149e-02f, -2.70437658e-01f, 8.58359635e-02f, 1.61383137e-01f, 7.64240846e-02f, 1.00158490e-01f, -2.53272086e-01f, -1.00693122e-01f, 1.13560073e-01f, -3.75722833e-02f,
  -1.22303709e-01f, 1.41819790e-01f, 2.07289651e-01f, 1.96636170e-02f, -3.49162787e-01f, 1.28622964e-01f, 2.19515502e-01f, -1.16763666e-01f, 1.01270042e-01f, -1.13296710e-01f,
  2.10773245e-01f, -1.52174057e-02f, -6.36688322e-02f, -1.44667029e-01f, -1.92313865e-02f, 1.36598065e-01f, 3.56280449e-04f, 7.13831708e-02f, -6.31349683e-02f, 6.03924431e-02f,
  6.84900284e-02f, 1.81194007e-01f, -1.28971152e-02f, 7.29051456e-02f, 6.03891211e-03f, -5.73903285e-02f, -7.36010224e-02f, -8.93891379e-02f, -2.11530134e-01f, -6.81503490e-02f,
  1.51924007e-02f, 3.50167267e-02f, 1.15513429e-01f, -6.28858060e-02f, -1.03974089e-01f, -2.37828165e-01f, 1.91012591e-01f, 2.29641140e-01f, -4.78805393e-01f, -1.07279308e-01f,
  1.28906846e-01f, -9.23232064e-02f, -7.97911808e-02f, 1.65442690e-01f, -2.66770720e-01f, 4.73343469e-02f, 1.18063554e-01f, 5.87762380e-03f, -1.32621080e-01f, -1.65531978e-01f,
  2.74717599e-01f, 3.99958007e-02f, -1.98687792e-01f, -1.94370195e-01f, 6.78031817e-02f, 1.83361545e-01f, 7.55513236e-02f, -1.65554076e-01f, 2.60669082e-01f, 1.21591859e-01f,
  -5.76189421e-02f, -2.26474926e-01f, -3.60096991e-02f, -1.36224568e-01f, -1.15730092e-01f, -4.00143147e-01f, 1.85384780e-01f, -2.10618928e-01f, 2.42860824e-01f, -4.28823829e-02f,
  -4.84423116e-02f, -7.27191418e-02f, -3.47087495e-02f, -1.09822072e-01f, -2.21666157e-01f, 9.56209749e-02f, -3.34057868e-01f, -1.19051844e-01f, -1.42396912e-01f, 1.94931298e-01f,
  4.67242710e-02f, 1.94520038e-02f, 1.01009095e-02f, -1.46616995e-01f, 7.69353434e-02f, 6.51741475e-02f, 4.54881368e-03f, -3.71219292e-02f, -1.53131643e-02f, 1.57142177e-01f,
  2.10680708e-01f, -3.57284136e-02f, 4.27030176e-02f, 4.54132669e-02f, -7.42177516e-02f, -1.22913174e-01f, 7.55228549e-02f, 6.59182519e-02f, 1.60643816e-01f, 2.53101319e-01f,
  5.83725311e-02f, -3.15230966e-01f, -2.55874880e-02f, -1.00187354e-01f, -2.39704568e-02f, 2.24547014e-01f, 1.14663258e-01f, 2.40680873e-01f, -5.74425422e-02f, -4.08975743e-02f,
  -1.69083238e-01f, -1.19532615e-01f, -1.09038979e-01f, -7.02611282e-02f, -1.45108923e-01f, -8.02221671e-02f, 7.85245299e-02f, -4.88325693e-02f, -7.72572681e-02f, 1.90714106e-01f,
  7.55689517e-02f, -1.55519247e-01f, -1.85354128e-01f, -1.32088348e-01f, -3.15757021e-02f, 1.62546411e-01f, -7.45903142e-03f, 1.45801410e-01f, 1.39623389e-01f, 6.16989424e-03f,
  9.92104486e-02f, 1.18965723e-01f, 1.31324995e-02f, 4.63253409e-02f, -9.08135846e-02f, 1.63350493e-01f, 1.15598060e-01f, 4.56264466e-02f, 3.16776782e-02f, -1.30063379e-02f,
  2.44895026e-01f, -1.05408065e-01f, 1.67427808e-01f, -1.05865307e-01f, 8.20464417e-02f, -5.39848320e-02f, 5.65215126e-02f, 8.26784000e-02f, 1.13669828e-01f, 1.88344106e-01f,
  3.10222041e-02f, 5.97532131e-02f, 1.73815235e-01f, 1.90960132e-02f, -3.45170163e-02f, -2.45816652e-02f, -1.33966571e-02f, -7.36754164e-02f, 3.08088940e-02f, -1.21184766e-01f,
  1.98236629e-01f, -1.26738340e-01f, 1.39352411e-01f, 2.02389453e-02f, 1.51672408e-01f, -1.09528601e-01f, -2.63349980e-01f, -2.66072065e-01f, 8.84941742e-02f, 1.55568883e-01f,
  8.29331204e-02f, 2.48626545e-01f, -2.05227546e-02f, 1.39940202e-01f, -3.61739963e-01f, 6.55791014e-02f, 1.35014085e-02f, -1.87831949e-02f, -1.53785823e-02f, 7.79889226e-02f,
  7.58340731e-02f, 1.46112442e-01f, -1.68886825e-01f, 1.11945085e-01f, -1.24012427e-02f, -3.63636881e-01f, 9.93752778e-02f, 2.58482248e-01f, 2.43057415e-01f, -2.41009761e-02f,
  2.07309335e-01f, -1.08941063e-01f, 1.33195203e-02f, -1.68655381e-01f, 2.11734369e-01f, -2.47548774e-01f, 8.48631784e-02f, -3.11403126e-01f, -3.30888659e-01f, 1.10690221e-01f,
  -2.55713552e-01f, -9.31490436e-02f, -2.17197537e-01f, 1.41650841e-01f, -3.04357614e-02f, -4.17037979e-02f, -2.57305056e-01f, 1.43820653e-02f, -1.15428708e-01f, -7.91798159e-02f,
  -5.54685742e-02f, -2.25738764e-01f, -1.97703391e-01f, -3.38930972e-02f, 2.16535807e-01f, 2.99628168e-01f, -1.12418428e-01f, -1.56666890e-01f, 5.26196472e-02f, 5.10152057e-02f,
  1.88301414e-01f, 2.85086542e-01f, 1.58475250e-01f, -3.52201574e-02f, -3.24190892e-02f, 1.39895976e-01f, 5.92606217e-02f, 1.05081476e-01f, 1.90410344e-03f, -1.87670894e-03f,
  9.23809260e-02f, -2.75906492e-02f, 5.09565063e-02f, 3.07500988e-01f, 4.08393033e-02f, -1.21505320e-01f, 4.94324900e-02f, 9.53631401e-02f, 1.79702222e-01f, -7.94547871e-02f,
  -1.50588751e-01f, -1.75062478e-01f, -3.88085432e-02f, 1.74646124e-01f, 1.35395065e-01f, 2.04356797e-02f, 2.24472135e-01f, -3.00164092e-02f, 2.41441242e-02f, -5.59867583e-02f,
  -1.41320497e-01f, 1.46806706e-02f, -2.77414113e-01f, -9.42976549e-02f, 2.31705934e-01f, -1.71420276e-01f, 1.44502968e-01f, 8.51499438e-02f, 9.70401838e-02f, 1.11155078e-01f,
  -1.37622178e-01f, 6.53716102e-02f, 2.32415080e-01f, 1.11246938e-02f, 2.21728221e-01f, 1.13566078e-01f, 2.71468878e-01f, 8.41646120e-02f, -1.13776691e-01f, -1.91486329e-01f,
  -2.02163327e-02f, -7.45459795e-02f, 2.35764049e-02f, 2.86826402e-01f, 2.93528270e-02f, -2.02196725e-02f, -1.71481922e-01f, 9.32568237e-02f, 1.17388638e-02f, 4.15002443e-02f,
  9.44791883e-02f, 1.56619444e-01f, -2.17499658e-01f, -3.75964969e-01f, -9.31306109e-02f, -1.46898240e-01f, -1.19576491e-02f, 1.36854067e-01f, 2.17253551e-01f, 1.29349694e-01f,
  -4.74522673e-02f, -4.76874113e-02f, 2.87137609e-02f, 1.07750721e-01f, -3.83032173e-01f, -7.56132305e-02f, 3.63113731e-01f, -6.85379654e-02f, 1.15410117e-02f, -8.36248621e-02f,
  -1.13973198e-02f, 1.90521568e-01f, 8.48085880e-02f, 5.16720954e-03f, -1.44516215e-01f, 1.13762379e-01f, 3.51349294e-01f, -7.44598582e-02f, -2.60742843e-01f, -7.61620607e-03f,
  -5.63235395e-02f, -6.43394664e-02f, 1.54050618e-01f, -2.64188945e-01f, 2.68610299e-01f, 9.35990550e-03f, -1.26857996e-01f, -2.13470548e-01f, -2.36955330e-01f, 1.01354368e-01f,
  7.05555454e-02f, -4.13000613e-01f, -6.90989122e-02f, -1.59567535e-01f, 1.91340268e-01f, 1.39111355e-01f, -7.65378997e-02f, -2.28734016e-01f, -6.28428999e-03f, -1.17432795e-01f,
  -2.68601686e-01f, -6.49136491e-03f, -1.69456348e-01f, -1.31055675e-02f, 2.12385294e-05f, 2.14800015e-01f, -5.08280061e-02f, -1.38312960e-02f, -2.16522850e-02f, -1.10927738e-01f,
  1.88349071e-03f, 3.32817167e-01f, -1.13680102e-01f, 1.06547475e-01f, -1.97324932e-01f, -2.46233165e-01f, 2.95298159e-01f, -1.29240319e-01f, -1.42572736e-02f, 1.03536889e-01f,
  -3.63984816e-02f, -1.52687848e-01f, -3.32688577e-02f, 1.01572119e-01f, 2.46259868e-01f, 1.62881672e-01f, 1.45401061e-01f, 2.61525344e-02f, -2.07749963e-01f, -3.35895419e-02f,
  -8.29116702e-02f, 5.49971499e-02f, 1.35464460e-01f, 1.72475100e-01f, -5.08552827e-02f, -6.70193806e-02f, -2.02190384e-01f, -1.55046776e-01f, -3.58043134e-01f, -2.09623694e-01f,
  -3.16198140e-01f, 1.38704255e-02f, -3.77599406e-03f, -1.43231392e-01f, 1.15833007e-01f, 6.19409122e-02f, 3.45832370e-02f, -2.28862271e-01f, 4.57807966e-02f, -3.45270820e-02f,
  -1.64339393e-01f, 1.12819788e-03f, 8.78696963e-02f, -3.33965011e-03f, -1.88730825e-02f, 1.38835341e-01f, 2.67070651e-01f, -1.56708248e-02f, 1.19308159e-01f, 1.42121166e-01f,
  -1.10799141e-01f, 1.03151821e-01f, 1.91800073e-02f, 2.71951593e-02f, -1.34879351e-01f, -1.83486119e-01f, 1.69104591e-01f, 2.27698088e-02f, -8.60221013e-02f, 1.09334290e-01f,
  1.20401820e-02f, -1.09033383e-01f, 1.60885349e-01f, 3.33577543e-01f, 1.74153760e-01f, 1.85527623e-01f, 8.00505504e-02f, 1.01934969e-02f, -4.83359732e-02f, -1.51416436e-01f,
  -2.63183385e-01f, 1.30584493e-01f, 8.13087896e-02f, 2.45045647e-01f, -8.07338580e-02f, 1.34321004e-01f, 3.87174785e-02f, -2.75895625e-01f, 5.30317426e-02f, 9.31851491e-02f,
  -5.54790348e-02f, 5.60503118e-02f, 7.21212104e-03f, -1.16328904e-02f, -1.16856471e-01f, -1.33176491e-01f, -5.64797707e-02f, 1.22076787e-01f, -4.47324067e-02f, -6.63335668e-03f,
  -2.33080760e-01f, 7.41660446e-02f, 7.10636899e-02f, -1.27990013e-02f, -3.41743343e-02f, -1.52678862e-01f, 1.01980262e-01f, -1.08362585e-01f, -2.23062605e-01f, 1.78928986e-01f,
  -2.32108057e-01f, -5.05397469e-02f, 1.11861192e-02f, 1.61839947e-01f, 6.18486926e-02f, -6.09103218e-02f, 2.05460023e-02f, -2.34779082e-02f, 8.88794884e-02f, 3.64911035e-02f,
  1.74015775e-01f, -2.53773421e-01f, -8.42900723e-02f, -3.04015458e-01f, -6.35102242e-02f, 7.90044889e-02f, -3.50186378e-01f, 7.41451681e-02f, 1.26060367e-01f, 2.22160563e-01f,
  -7.98674673e-02f, -4.02545221e-02f, -1.40257657e-01f, -1.56841785e-01f, -8.50473791e-02f, -1.60948277e-01f, -8.00445974e-02f, 3.17059726e-01f, 2.49546468e-01f, -3.08141131e-02f,
  2.37112343e-01f, 4.49259162e-01f, -6.88675568e-02f, -1.35708228e-01f, 3.78950685e-02f, 1.86307117e-01f, 8.01126063e-02f, -2.28398480e-02f, 1.63693085e-01f, 1.57676395e-02f,
  -7.23141655e-02f, -1.35065362e-01f, -1.62234545e-01f, -1.35697752e-01f, 1.66912153e-01f, 1.91854537e-01f, 2.09300905e-01f, -2.10767373e-01f, 1.22150637e-01f, -2.36785129e-01f,
  8.71956423e-02f, 1.15342446e-01f, -1.40589457e-02f, -8.84593353e-02f, -1.89386886e-02f, -1.11248359e-01f, 4.30032127e-02f, -2.38785028e-01f, 8.59466195e-02f, 6.38533235e-02f,
  4.31611612e-02f, -8.69141817e-02f, -3.13105397e-02f, 1.32793292e-01f, 1.23234414e-01f, -1.42155886e-01f, 1.24433905e-01f, 1.52734056e-01f, 1.93782955e-01f, -7.05282167e-02f,
  -1.06855288e-01f, -1.71629548e-01f, -1.08652525e-01f, 1.62154390e-03f, 2.06952214e-01f, -1.92871884e-01f, 7.83647820e-02f, 1.43585697e-01f, 2.18724474e-01f, -2.01155275e-01f,
  7.38293827e-02f, 8.36357325e-02f, 2.14685604e-01f, 3.40752676e-02f, -2.67119944e-01f, -2.45670170e-01f, -2.13285699e-01f, 1.54872283e-01f, 4.99807075e-02f, 1.87503397e-01f,
  1.83840692e-02f, -9.22516640e-03f, 1.91142395e-01f, 1.55547485e-01f, 1.41151503e-01f, -1.54211640e-01f, -1.32945240e-01f, 1.27785519e-01f, -9.47575793e-02f, -4.00828093e-01f,
  -1.92676410e-01f, -2.62842119e-01f, 1.79093748e-01f, -4.16374244e-02f, 2.21900001e-01f, 2.59883046e-01f, -1.72158539e-01f, -3.27380374e-02f, 3.90735753e-02f, 1.67188659e-01f,
  -3.09416324e-01f, 3.79071325e-01f, 9.41431373e-02f, 4.21010032e-02f, -3.19861695e-02f, -2.65607946e-02f, -6.08610399e-02f, 4.26716497e-03f, 3.04605395e-01f, 1.50993511e-01f,
  1.63727909e-01f, 8.10082927e-02f, 4.40330327e-01f, 1.42089993e-01f, -8.05801675e-02f, -1.79239452e-01f, 9.76065844e-02f, -1.64905284e-03f, -1.87371984e-01f, 7.90767074e-02f,
  1.33304134e-01f, -8.58836472e-02f, 3.49031352e-02f, -9.91560146e-02f, -5.00880852e-02f, -1.28207162e-01f, 1.94180340e-01f, -3.20596486e-01f, -1.85146391e-01f, -6.02488965e-02f,
  -9.76646245e-02f, -1.50062487e-01f, 1.05230376e-01f, -1.08623177e-01f, 5.51961772e-02f, 9.50383916e-02f, -1.39206037e-01f, 7.35653937e-02f, -2.90741753e-02f, -4.59460430e-02f,
  1.05336055e-01f, -2.88592791e-03f, -1.21992260e-01f, 8.02167319e-03f, 2.06616536e-01f, -3.28462154e-01f, 1.46709383e-01f, 1.59338176e-01f, 2.94152740e-02f, 1.17443614e-01f,
  -1.14267483e-01f, -8.36899802e-02f, 1.32859334e-01f, -1.38493717e-01f, 4.15762849e-02f, 6.57652318e-02f, 1.61861017e-01f, -1.73180252e-01f, 1.47068366e-01f, 6.87584206e-02f,
  1.38254344e-01f, 4.72160242e-02f, 1.22771412e-01f, 2.62550086e-01f, -1.07900172e-01f, -1.26017973e-01f, 1.73724383e-01f, 8.55982155e-02f, 4.91504967e-02f, 3.62841114e-02f,
  -5.24200834e-02f, 2.00601548e-01f, 9.84596387e-02f, 8.74880049e-03f, -4.52953130e-01f, -2.00408623e-02f, -1.10974126e-01f, 1.34440050e-01f, 2.69828625e-02f, 1.15276717e-01f,
  5.28924353e-02f, -1.99227154e-01f, 2.68075317e-02f, -6.80382773e-02f, -9.24336165e-02f, -3.81047837e-02f, -3.52055877e-01f, -2.70704806e-01f, 1.27104864e-01f, -9.65332165e-02f,
  4.93123569e-02f, -8.56221989e-02f, 1.73790827e-01f, 3.97588760e-02f, -8.70926231e-02f, -3.49128023e-02f, 2.67688394e-01f, -7.20065683e-02f, 6.86396733e-02f, 8.57736468e-02f,
  -5.88384345e-02f, -3.76498364e-02f, -1.30884657e-02f, -5.79833053e-02f, 7.29834288e-02f, 1.82061136e-01f, 9.31129158e-02f, 1.54016130e-02f, -2.07136758e-02f, 1.87169705e-02f,
  5.37025183e-03f, -3.57557237e-02f, -4.92152758e-02f, 9.90090221e-02f, -2.12650567e-01f, 1.20498046e-01f, -1.15209699e-01f, 5.49496934e-02f, -1.39141411e-01f, -6.48543686e-02f,
  -6.23677508e-04f, -2.75497884e-02f, -1.88216537e-01f, 1.45105496e-01f, -3.22048776e-02f, -2.84590811e-01f, -1.85987204e-02f, 4.24643531e-02f, -8.75158533e-02f, 2.16203809e-01f,
  1.05844485e-02f, -2.23923206e-01f, 2.00896244e-02f, 8.43293071e-02f, -1.47159562e-01f, -1.31575152e-01f, 1.81209415e-01f, 3.82178929e-03f, 1.71746492e-01f, -2.71215379e-01f,
  -1.34053692e-01f, 1.80811480e-01f, -4.31728949e-06f, -1.47409871e-01f, 1.03622250e-01f, -5.78259826e-02f, 6.93243444e-02f, 1.07607305e-01f, -8.50044042e-02f, -2.88545173e-02f,
  -4.68500145e-02f, -2.68906295e-01f, -7.07524568e-02f, 6.14751838e-02f, 4.43768017e-02f, 1.47440778e-02f, -1.95930660e-01f, 7.74021149e-02f, -9.31419879e-02f, 1.81887478e-01f,
  1.39431924e-01f, 1.47734266e-02f, 1.83701850e-02f, 2.00510710e-01f, 6.70892075e-02f, -1.76878303e-01f, -1.64319411e-01f, 1.64922457e-02f, 1.07709497e-01f, 1.65858239e-01f,
  7.42182955e-02f, 1.07925504e-01f, 1.15652941e-01f, 1.32499794e-02f, 1.29091054e-01f, 5.96115775e-02f, 1.60777822e-01f, 2.29451037e-03f, -1.94705889e-01f, -6.89196438e-02f,
  -1.73266262e-01f, -2.02002287e-01f, -1.40666559e-01f, 4.69638929e-02f, 6.35583550e-02f, -1.56897753e-01f, 8.84631947e-02f, 2.39627242e-01f, -1.56095996e-01f, 5.66021837e-02f,
  8.94534439e-02f, 9.40867588e-02f, -8.60576406e-02f, 2.43039113e-02f, -2.78535843e-01f, -2.83387512e-01f, -1.71579286e-01f, -1.29819989e-01f, 1.81661285e-02f, -2.83234775e-01f,
  -1.95457470e-02f, -3.53250392e-02f, -1.09289721e-01f, 1.01418279e-01f, -2.46267213e-04f, 4.05973420e-02f, 1.38737708e-02f, -1.66893303e-02f, 1.14121914e-01f, 6.73864735e-03f,
  -3.13686207e-02f, -8.13492686e-02f, -7.09792152e-02f, 8.77784193e-02f, -2.26259530e-01f, -1.56098604e-01f, -2.19940051e-01f, -3.05203479e-02f, 1.06396474e-01f, 1.02931835e-01f,
  -4.20316681e-02f, 9.36090201e-02f, 2.32019257e-02f, -1.00723505e-02f, 8.28400552e-02f, -4.66002412e-02f, 3.25605534e-02f, -1.99034698e-02f, 7.57382764e-03f, 6.40230328e-02f,
  -9.33649614e-02f, -3.43160629e-02f, 1.65512711e-01f, -2.88663507e-02f, -1.24087585e-02f, -2.31459394e-01f, 5.93033805e-03f, -7.06970738e-03f, -1.81609526e-01f, -1.70998186e-01f,
  1.43027738e-01f, 1.44567087e-01f, -2.42838442e-01f, -1.57492220e-01f, 1.14736855e-01f, -1.54940471e-01f, -1.22391656e-01f, 6.02097288e-02f, -6.17449433e-02f, 9.43741649e-02f,
  1.43647119e-02f, 3.31946947e-02f, 4.51295823e-02f, 3.88896056e-02f, -6.24173991e-02f, 1.45501465e-01f, 2.56342530e-01f, -1.64072990e-01f, -2.07480699e-01f, -1.06273212e-01f,
  1.15002669e-01f, -5.62270172e-02f, 8.12927186e-02f, -1.00871041e-01f, 1.30838767e-01f, 8.39451700e-02f, -9.83176827e-02f, -1.13445982e-01f, -1.18547797e-01f, -2.16389280e-02f,
  1.20363750e-01f, 1.14786133e-01f, 1.59693837e-01f, -8.41229558e-02f, 1.35191038e-01f, 1.21089660e-01f, -6.57838956e-02f, -4.89199683e-02f, -1.31403310e-02f, 1.30985126e-01f,
  -2.34970301e-02f, 1.42719194e-01f, -2.58599650e-02f, 2.17693686e-01f, -2.28885766e-02f, 1.84543505e-01f, -1.58146426e-01f, 2.03071073e-01f, 2.31398210e-01f, 5.84132336e-02f,
  1.85006261e-01f, 1.36318192e-01f, 1.84641957e-01f, -2.24130124e-01f, 1.40288591e-01f, 1.72439758e-02f, 6.30035177e-02f, -6.84915930e-02f, 7.92560205e-02f, -2.67074220e-02f,
  1.41196832e-01f, 2.32938841e-01f, 1.82669684e-01f, 1.99848890e-01f, 1.49887830e-01f, 3.52826715e-02f, -7.42826462e-02f, -5.19843213e-03f, -1.36614889e-01f, -4.75643247e-01f,
  -2.76019603e-01f, -5.73301949e-02f, -3.65688503e-02f, -2.61414051e-01f, 9.93523374e-02f, -1.36230486e-02f, -3.76164347e-01f, -6.31059259e-02f, 2.98493832e-01f, 8.53462666e-02f,
  -1.05127459e-02f, -3.53540182e-02f, -4.76460636e-01f, -4.00721967e-01f, -2.92491406e-01f, 8.26017261e-02f, -1.62541151e-01f, -3.67010713e-01f, 5.06637990e-02f, -8.56888443e-02f,
  1.28845051e-01f, -8.82351324e-02f, -3.99103463e-02f, -1.04690976e-01f, 2.18788534e-01f, -4.96834368e-02f, -3.76792960e-02f, 2.52651960e-01f, 4.64494936e-02f, -3.58528756e-02f,
  1.41854942e-01f, 1.01543956e-01f, 3.14747840e-01f, -1.87458813e-01f, -4.56936747e-01f, 5.62749850e-03f, 2.76627064e-01f, -2.31091261e-01f, 1.23072706e-01f, -2.38985911e-01f,
  3.33794594e-01f, 6.60634413e-02f, 1.45404845e-01f, 2.55783685e-02f, -6.50993288e-02f, 1.95940718e-01f, 5.39867505e-02f, 2.58459039e-02f, -1.56909347e-01f, -6.60792291e-02f,
  -1.44855961e-01f, 3.56095135e-02f, -5.42816781e-02f, -3.60925376e-01f, -8.11839327e-02f, 1.06232464e-01f, -1.61281750e-01f, -2.11613923e-01f, -8.66272151e-02f, 1.75390691e-02f,
  1.39615573e-02f, -4.25191671e-02f, 1.40843436e-01f, 1.15160279e-01f, 3.23969752e-01f, 2.19991922e-01f, 1.67392164e-01f, 7.07282126e-02f, -4.34581637e-01f, 1.36495396e-01f,
  -6.10312670e-02f, -2.55810679e-03f, -3.01556021e-01f, -1.47387624e-01f, 9.45971254e-03f, 3.54577228e-02f, 4.33285944e-02f, 1.72695190e-01f, 4.44141068e-02f, -2.15829730e-01f,
  8.06780457e-02f, 1.58732727e-01f, -1.22518398e-01f, -2.36211300e-01f, 6.54163770e-03f, -2.24195138e-01f, -2.74088562e-01f, 2.31142804e-01f, -1.32875547e-01f, -1.37225181e-01f,
  2.58123912e-02f, -2.89008200e-01f, 1.03447437e-01f, 9.70862210e-02f, -5.53863525e-01f, 3.85770798e-02f, -3.69761065e-02f, -2.02984691e-01f, 1.11388229e-01f, 8.03546514e-03f,
  -1.73764125e-01f, -1.19703617e-02f, 8.09191987e-02f, 3.13000269e-02f, -1.81396410e-01f, 2.74460942e-01f, 6.31442368e-02f, -3.28196003e-03f, -3.49654593e-02f, 7.65192322e-03f,
  1.30547499e-02f, -4.23460573e-01f, -1.75981313e-01f, -2.62096804e-02f, 1.47996515e-01f, 1.79583013e-01f, 2.04085350e-01f, 2.02958077e-01f
};

// L3_fan_Bp_bar (Shape: 1 x 52)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 52;
const float L3_fan_Bp_bar_data[] = {
  -1.86137259e-02f, 1.67287275e-01f, 1.83624905e-02f, 5.52605391e-02f, -1.90170109e-02f, -8.39667115e-03f, 8.53601843e-02f, 1.08724207e-01f, 2.66509116e-01f, -6.19246997e-03f,
  -4.78221029e-02f, -6.12258390e-02f, -3.35741118e-02f, 6.32674247e-02f, -1.08109616e-01f, 4.70971921e-03f, 3.52788530e-02f, 3.77314650e-02f, 3.83497551e-02f, 2.37865642e-01f,
  1.51965618e-01f, -3.10479552e-02f, -1.83640823e-01f, -7.40407314e-03f, 1.43800393e-01f, -7.25196153e-02f, -7.88893923e-02f, -1.21812537e-01f, 8.52990821e-02f, 1.28941789e-01f,
  -1.67092860e-01f, 1.32203214e-02f, 8.10588337e-03f, 1.72046155e-01f, -1.00190781e-01f, 5.39916847e-03f, 7.07933679e-02f, 1.50135040e-01f, 2.77250241e-02f, 1.55650645e-01f,
  4.76421490e-02f, 1.82689391e-02f, 1.40873075e-01f, 1.62012592e-01f, 1.02854997e-01f, 1.01501599e-01f, 1.37158215e-01f, -6.49482757e-02f, 1.15908399e-01f, -1.06899463e-01f,
  2.17062142e-02f, -5.76874986e-02f
};

// L4_linear_W (Shape: 12 x 64)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 64;
const float L4_linear_W_data[] = {
  -7.65831694e-02f, -1.54978661e-02f, -3.79511379e-02f, 3.71765122e-02f, -1.35034859e-01f, -7.61801973e-02f, -9.16093290e-02f, -1.68752834e-01f, 1.93817914e-01f, 4.86091338e-02f,
  -4.58752885e-02f, -1.49840876e-01f, 1.49108723e-01f, 5.97906522e-02f, -3.18203598e-01f, -1.48040995e-01f, -2.43520573e-01f, 5.76613657e-02f, -5.73081136e-01f, -1.00456990e-01f,
  -5.25725901e-01f, -3.46790403e-02f, -3.78063822e-04f, -5.78293838e-02f, -5.42838238e-02f, -5.65474220e-02f, 1.65178910e-01f, 5.62280118e-02f, 1.19312312e-02f, 1.65424183e-01f,
  6.68662554e-03f, -1.92053065e-01f, 1.22263893e-01f, -1.64558962e-01f, 1.93355098e-01f, 5.10402173e-02f, -2.16246516e-01f, 1.21081136e-01f, 1.05601341e-01f, 1.55628130e-01f,
  -3.67410332e-02f, -1.96020588e-01f, 1.25752836e-01f, -1.13388471e-01f, -2.60187447e-01f, -1.74390525e-01f, -1.66729853e-01f, 1.50634229e-01f, 2.42242645e-02f, -1.30937606e-01f,
  1.56922713e-01f, -2.34791592e-01f, 1.30796507e-01f, -6.74899071e-02f, 7.72178844e-02f, -1.28332451e-01f, -2.98369944e-01f, -1.44155085e-01f, -1.13274127e-01f, -7.94756189e-02f,
  -2.66767174e-01f, 1.48590475e-01f, 2.03476772e-02f, 6.33141324e-02f, -1.48347262e-02f, 1.35789976e-01f, -2.96628363e-02f, 1.21922582e-01f, -8.45517218e-02f, -8.58545676e-02f,
  5.59643134e-02f, -1.02411129e-01f, 1.97523698e-01f, 2.13620113e-03f, 1.40497729e-01f, -1.83936909e-01f, 1.62500277e-01f, 1.13989569e-01f, -1.83473304e-02f, 9.84986573e-02f,
  -1.59977466e-01f, -3.84997696e-01f, 1.23247869e-01f, -3.41738202e-02f, 2.44794786e-02f, 8.63856152e-02f, 1.94357157e-01f, 7.09699914e-02f, 5.18744253e-02f, -1.03858195e-01f,
  1.79381624e-01f, 1.79867625e-01f, 1.42494813e-01f, -5.75605668e-02f, 1.15892954e-01f, -1.34449288e-01f, -3.39004874e-01f, -1.73295572e-01f, 3.54056843e-02f, 1.27877340e-01f,
  -4.60397780e-01f, -1.40097812e-01f, 1.01707973e-01f, -1.48626760e-01f, 1.02512054e-01f, -2.23712161e-01f, 2.09766582e-01f, -1.29431471e-01f, -1.29912838e-01f, 4.32941280e-02f,
  1.71415627e-01f, -1.44651309e-01f, -3.66821408e-01f, -1.43214479e-01f, 7.94430599e-02f, 4.98904735e-02f, -2.55368829e-01f, -1.00794107e-01f, -8.48421901e-02f, 6.96310475e-02f,
  -2.44804218e-01f, -1.72650486e-01f, -3.47285628e-01f, -9.02579203e-02f, -8.93365443e-02f, -6.49840087e-02f, -6.55825958e-02f, -3.55450548e-02f, 9.63450447e-02f, -5.05147316e-03f,
  1.08007297e-01f, -2.17837337e-02f, 8.51536095e-02f, 2.14050082e-03f, 1.50802612e-01f, 3.27236831e-01f, -2.10881740e-01f, 3.76705118e-02f, 1.07759925e-05f, 5.65186515e-02f,
  -1.41141951e-01f, 1.32268831e-01f, -5.03044724e-01f, 1.74401373e-01f, -3.28780144e-01f, 2.44313210e-01f, -1.05490282e-01f, -2.03585729e-01f, -5.77986479e-01f, 3.43189389e-02f,
  1.07875235e-01f, -3.02390009e-01f, 7.19652399e-02f, -2.33079314e-01f, -1.56218514e-01f, 1.38649002e-01f, 2.73735151e-02f, -3.47844392e-01f, -4.43064392e-01f, 1.06113555e-03f,
  -4.20038968e-01f, -1.93514436e-01f, -9.21422541e-02f, 1.74914047e-01f, 2.09492326e-01f, 1.86078593e-01f, 1.21720552e-01f, -1.45988211e-01f, -7.09020570e-02f, 2.39988729e-01f,
  -9.25159454e-02f, -2.28109851e-01f, 1.82082325e-01f, 7.62847951e-04f, 1.03980340e-01f, 8.29208940e-02f, -5.03609300e-01f, -1.53239782e-03f, 1.76788732e-01f, 1.76246002e-01f,
  1.03409044e-01f, 1.04714166e-02f, 1.83040708e-01f, 1.21425159e-01f, -1.31007060e-01f, -1.14806276e-02f, 2.25671023e-01f, -1.92423612e-01f, -1.79144237e-02f, -1.00966133e-01f,
  -2.84107149e-01f, -7.52701685e-02f, -9.03015882e-02f, 4.41022664e-02f, 6.37689531e-02f, 1.90776344e-02f, 6.92989230e-02f, -1.67203486e-01f, -1.20377755e-02f, 2.84018740e-02f,
  -4.07528505e-02f, 3.66438366e-02f, 2.65656710e-02f, -5.63563704e-02f, -7.57840052e-02f, -4.09892291e-01f, -1.36321202e-01f, -3.71679634e-01f, 3.06520522e-01f, 1.41801089e-01f,
  -4.76756513e-01f, -9.44092348e-02f, -3.93083602e-01f, -3.39236617e-01f, -2.71258682e-01f, 1.92458421e-01f, 2.35027790e-01f, 1.09374933e-02f, 4.12196340e-03f, -2.84227073e-01f,
  -2.76174486e-01f, -3.94707397e-02f, -3.38901818e-01f, -3.06290984e-01f, -1.10448323e-01f, 5.84976636e-02f, 1.35521367e-01f, -7.59504512e-02f, 7.64900967e-02f, 3.96005660e-02f,
  6.47894219e-02f, 9.71006230e-02f, -4.61755157e-01f, 1.28005877e-01f, 2.04829406e-02f, -7.26385564e-02f, 1.18472487e-01f, -1.18377894e-01f, -2.21440524e-01f, -1.23578543e-02f,
  1.36307687e-01f, -7.77773485e-02f, 1.39221791e-02f, -6.62873611e-02f, 1.30437374e-01f, -5.21650277e-02f, -1.29021823e-01f, -5.95694482e-01f, -1.95847467e-01f, 5.65360859e-03f,
  1.11811265e-01f, 3.88013646e-02f, -1.51045755e-01f, -1.63471758e-01f, -1.08383797e-01f, 2.22542122e-01f, -5.48033156e-02f, -3.10205132e-01f, 1.30865261e-01f, -3.63675207e-02f,
  -1.59464672e-01f, -2.30674192e-01f, -2.96399415e-01f, -1.02156878e-01f, -1.81057945e-01f, -9.55760926e-02f, 5.99121824e-02f, 2.19258249e-01f, 1.55743137e-01f, -6.19630031e-02f,
  5.07641733e-02f, -6.79639727e-03f, -9.38285608e-03f, 1.33607745e-01f, 2.02268854e-01f, -2.35855877e-01f, -2.10470054e-02f, -1.74691573e-01f, -8.31184387e-02f, 1.48770481e-01f,
  -3.41748178e-01f, 1.91251189e-01f, -9.66742262e-02f, -1.12532303e-01f, -8.65350757e-03f, 1.76911578e-01f, -5.39018959e-02f, 3.67899728e-03f, 1.45158097e-01f, 9.45976973e-02f,
  -2.29267195e-01f, 9.69838575e-02f, 3.05714738e-02f, 4.73281518e-02f, -5.76374643e-02f, 1.87771738e-01f, -1.06169386e-02f, 2.15999231e-01f, -1.19840704e-01f, -1.03685990e-01f,
  -5.35794795e-02f, -2.71466136e-01f, 5.31351864e-02f, 3.48078758e-02f, 4.44053374e-02f, -2.74397075e-01f, 1.15001164e-02f, -5.16362786e-02f, 1.63077354e-01f, -2.88705707e-01f,
  -4.89747114e-02f, 4.68284776e-03f, 8.54244679e-02f, -3.48749131e-01f, -4.12312634e-02f, 1.13845924e-02f, -2.18612291e-02f, 9.02094692e-02f, -3.13820511e-01f, 1.97708890e-01f,
  1.35532364e-01f, -1.74979754e-02f, 1.51182041e-01f, 8.13445821e-02f, 1.15333356e-01f, 2.47470707e-01f, -1.59941629e-01f, -2.81507432e-01f, -1.68766342e-02f, -2.33163208e-01f,
  1.46252692e-01f, -1.58510387e-01f, -2.83173919e-01f, 1.71746746e-01f, 1.12188138e-01f, 1.81018516e-01f, -4.22771275e-02f, -1.52472764e-01f, -9.65885760e-04f, -2.18365774e-01f,
  2.11023935e-03f, 1.22106276e-01f, 9.45533738e-02f, -1.52095601e-01f, -2.16583937e-01f, 1.96403727e-01f, -7.45699108e-02f, -1.68609083e-01f, -2.23459620e-02f, 1.32161891e-02f,
  1.23771966e-01f, -2.92631388e-01f, 1.00732379e-01f, 2.58349597e-01f, -4.41488661e-02f, 8.12285468e-02f, -3.91423255e-01f, -6.17970712e-02f, -1.48105308e-01f, -8.07020068e-02f,
  1.99948862e-01f, -2.60684997e-01f, -8.44360888e-03f, 6.59364089e-02f, 2.42858790e-02f, 4.51791137e-02f, 8.78061205e-02f, -1.73588470e-02f, 1.32333905e-01f, -1.92468733e-01f,
  -5.99142388e-02f, -2.38243803e-01f, 1.19382285e-01f, -1.98615506e-01f, -2.26177990e-01f, 3.48852277e-02f, 2.62591578e-02f, -8.70371088e-02f, 1.00350149e-01f, -2.37560228e-01f,
  9.23219100e-02f, 5.10760695e-02f, -1.32904753e-01f, -2.70127863e-01f, -1.58015937e-02f, 2.42922325e-02f, 9.51105729e-02f, 1.09485395e-01f, 2.31054015e-02f, 1.65737689e-01f,
  8.66305530e-02f, -8.42399001e-02f, 1.96926534e-01f, 2.79922038e-01f, -2.01865882e-01f, -7.55351782e-02f, 8.77538323e-02f, 7.53894225e-02f, -9.25346240e-02f, 1.43047452e-01f,
  -2.02628002e-01f, -4.00520951e-01f, 9.22259688e-02f, -1.97013438e-01f, 4.54911105e-02f, -4.61722799e-02f, -1.47901818e-01f, -2.10158110e-01f, -1.00264601e-01f, -1.52018964e-01f,
  -2.05882102e-01f, 9.67110172e-02f, -1.24446146e-01f, -1.52415037e-01f, 3.58735886e-03f, 2.47028947e-01f, -4.00273234e-01f, -2.07698733e-01f, -7.44749531e-02f, 5.50789312e-02f,
  1.46960765e-01f, -2.08534021e-02f, -2.44971886e-01f, -3.91530186e-01f, 2.07723714e-02f, -3.78892571e-02f, -3.74364078e-01f, 3.81405465e-02f, -1.78703636e-01f, 1.76143512e-01f,
  -1.06035590e-01f, 8.60788301e-02f, 1.44341826e-01f, -3.81863618e-04f, 8.70192572e-02f, 2.21048892e-01f, -2.20128968e-01f, -4.05121058e-01f, -5.91097660e-02f, 3.05043072e-01f,
  1.41672879e-01f, -2.14018952e-02f, -4.11544740e-01f, -3.15823436e-01f, -7.69581238e-04f, -2.22717062e-01f, 2.56567806e-01f, -9.49867368e-02f, -8.60492885e-02f, -1.75985098e-02f,
  8.24126005e-02f, -1.51640981e-01f, 9.40149873e-02f, 7.94813111e-02f, -1.41020611e-01f, -2.93092709e-03f, -6.57168031e-02f, 1.45792201e-01f, -1.02907807e-01f, -2.72464991e-01f,
  -4.53438386e-02f, -1.67868972e-01f, 1.89715698e-01f, -4.33991969e-01f, 1.81991667e-01f, -1.49943694e-01f, 1.14892222e-01f, 1.36039793e-01f, 1.67035431e-01f, 2.89994851e-02f,
  3.78981382e-02f, -1.83012456e-01f, 1.49401933e-01f, -1.95740834e-01f, -1.72943294e-01f, -5.93436398e-02f, 6.62215939e-03f, -2.96677679e-01f, 8.36458504e-02f, -1.11706086e-01f,
  -2.25128636e-01f, -1.69103608e-01f, 1.36623561e-01f, -8.69507715e-02f, -1.65214658e-01f, -3.42683271e-02f, 9.82768163e-02f, 1.30830199e-01f, -1.47971898e-01f, -1.67222664e-01f,
  4.48731147e-02f, -1.10210679e-01f, -1.06060341e-01f, -9.02171358e-02f, 6.75151944e-02f, -6.27962798e-02f, -1.27157003e-01f, -1.80461258e-01f, -3.58410716e-01f, -3.34534556e-01f,
  -9.27652791e-02f, -1.01325838e-02f, -3.38883638e-01f, 6.80848062e-02f, 8.05046689e-03f, 9.53804702e-02f, -1.80547804e-01f, 1.50242224e-01f, 7.39547089e-02f, 8.75495534e-05f,
  -4.59209345e-02f, 7.80389830e-02f, 8.60836655e-02f, -5.78063913e-02f, 3.04766037e-02f, -7.70111233e-02f, -1.61375359e-01f, 4.94894236e-02f, 2.09082022e-01f, 2.40078717e-01f,
  -1.77695036e-01f, 2.68803090e-02f, -3.98774117e-01f, 6.65001944e-02f, -7.59544433e-04f, -3.57271545e-02f, -4.79640253e-02f, 1.67819679e-01f, 1.48828387e-01f, -2.23535657e-01f,
  2.50643045e-01f, -1.11620694e-01f, -1.57158643e-01f, -1.43690169e-01f, -1.65477440e-01f, -1.83165044e-01f, 1.76989622e-02f, -1.99591026e-01f, 5.65412715e-02f, 1.42481163e-01f,
  -6.23663142e-02f, -3.81958663e-01f, 1.89168826e-02f, -3.55712384e-01f, -1.12286150e-01f, 1.03256606e-01f, -5.54518849e-02f, -2.69091547e-01f, -3.99044722e-01f, -3.27018350e-01f,
  -4.66201976e-02f, -3.32510509e-02f, 1.55163944e-01f, -2.64980674e-01f, -4.24666069e-02f, 1.67155191e-01f, 1.46156847e-01f, -2.30554491e-02f, 1.57585397e-01f, -7.82511607e-02f,
  -2.96459347e-01f, 1.70233339e-01f, -1.31476611e-01f, 4.56125177e-02f, -3.65634292e-01f, 3.26674193e-01f, -1.13387972e-01f, -2.47460082e-02f, 5.32259494e-02f, 2.24020645e-01f,
  -1.83915600e-01f, -1.19577907e-01f, 1.44783929e-01f, -3.90369803e-01f, 1.58249319e-01f, -3.87924403e-01f, 5.80689311e-02f, -5.92331477e-02f, -1.17539766e-03f, -1.09643951e-01f,
  4.15990576e-02f, 1.65241100e-02f, -1.25693619e-01f, 3.68079633e-01f, -1.57793537e-01f, 1.24934375e-01f, -3.48509490e-01f, 1.11862540e-01f, -5.38067147e-02f, -3.92984748e-02f,
  1.66956514e-01f, 1.10588871e-01f, -4.35082853e-01f, -1.10022640e-02f, -2.49887764e-01f, 1.97007239e-01f, 9.70982462e-02f, 5.30303903e-02f, -1.97935790e-01f, -1.35935023e-01f,
  9.34021994e-02f, -7.86502585e-02f, -2.37199515e-01f, 1.42005339e-01f, -6.73347041e-02f, -8.71974528e-02f, 1.06681600e-01f, 1.60141274e-01f, -5.77442050e-02f, 6.18740804e-02f,
  -8.64664912e-02f, -1.94135591e-01f, 1.54406056e-01f, 1.76283181e-01f, 1.91886928e-02f, -4.10033390e-02f, -1.31442368e-01f, 1.38470843e-01f, -1.68235168e-01f, 6.68891892e-02f,
  -2.42768660e-01f, 1.08713038e-01f, -6.51967898e-02f, 1.29516140e-01f, -3.74620616e-01f, -6.30774945e-02f, 1.42966062e-01f, -2.24745989e-01f, 6.52552815e-03f, -2.24881202e-01f,
  4.03173603e-02f, -1.28839508e-01f, -2.58829165e-02f, 7.28731677e-02f, -2.61374023e-02f, 6.71565393e-03f, 1.51913583e-01f, 1.21482134e-01f, 1.30732954e-01f, -3.67891550e-01f,
  3.24295424e-02f, 9.36268345e-02f, -3.88744734e-02f, 3.81508432e-02f, -1.73719198e-01f, -1.04396664e-01f, 1.97230056e-01f, -1.66500345e-01f, 8.62242877e-02f, -1.63668916e-01f,
  -4.96360175e-02f, 1.17801420e-01f, -1.18659198e-01f, 2.46353261e-03f, -7.59239942e-02f, 1.85607180e-01f, -5.85499555e-02f, 2.61772573e-01f, -1.70233980e-01f, -1.11483984e-01f,
  -2.01576397e-01f, -2.34487087e-01f, -2.75440186e-01f, 2.23016605e-01f, -7.14958012e-02f, 1.79068625e-01f, -7.36591965e-02f, 1.00898303e-01f, -2.59633690e-01f, 1.13912083e-01f,
  -3.67350906e-01f, -3.70041877e-01f, 1.97161794e-01f, 1.95927545e-01f, -1.11346126e-01f, -3.43418628e-01f, -2.03607723e-01f, -2.79147118e-01f, -3.47297281e-01f, -9.32110846e-02f,
  4.60325927e-02f, 1.40144140e-01f, -3.94439399e-01f, 9.84332860e-02f, 1.32524699e-01f, -3.49372476e-01f, 5.09808138e-02f, -3.53229761e-01f, 9.73240659e-02f, 1.39861867e-01f,
  -1.61608234e-01f, -6.17106967e-02f, -1.47929545e-02f, 1.67562112e-01f, -3.53518158e-01f, -3.19478601e-01f, 1.00602567e-01f, 2.41791680e-01f, 2.63308305e-02f, -1.67283528e-02f,
  -2.82850802e-01f, -1.95019946e-01f, -3.69625390e-01f, -2.21349508e-01f, -3.37028913e-02f, 2.15357319e-02f, -1.33904815e-01f, 1.79198831e-01f, 2.49850713e-02f, -3.09344567e-02f,
  -1.13011166e-01f, 8.46106485e-02f, 7.93915838e-02f, 3.56702739e-03f, 4.33902532e-01f, 2.45749965e-01f, -7.53943846e-02f, -2.32600003e-01f, 4.91234511e-02f, -7.96213299e-02f,
  2.28584886e-01f, -1.52710542e-01f, -3.03885117e-02f, 1.72409683e-01f, 2.32284982e-02f, -3.93139601e-01f, 1.42251775e-01f, -1.08997613e-01f, -4.80195731e-02f, -2.91310519e-01f,
  -1.56835057e-02f, -2.28626862e-01f, -2.35252008e-01f, -1.70322686e-01f, 1.09448053e-01f, 1.14339672e-01f, 1.29363060e-01f, -9.42925140e-02f, -8.13014060e-02f, -2.17116401e-01f,
  7.09603652e-02f, -3.86649519e-01f, -1.51906818e-01f, -9.22864601e-02f, 1.13477543e-01f, -1.93003908e-01f, -1.37456134e-01f, 2.16929913e-01f, -3.54189366e-01f, 1.38959348e-01f,
  -2.19523147e-01f, -2.74719179e-01f, -2.14937404e-01f, 2.10933864e-01f, 1.43585319e-03f, 1.29518136e-01f, -2.83558220e-01f, -5.39337583e-02f, 2.70547092e-01f, -2.01409534e-02f,
  2.04511017e-01f, -3.32514495e-01f, 9.05494988e-02f, -1.09716713e-01f, 5.04423231e-02f, -2.29560360e-01f, 1.41420767e-01f, -4.51006740e-02f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  3.04673705e-03f, 6.16625808e-02f, 1.13415301e-01f, -1.16016947e-01f, -4.21205116e-03f, 1.26826838e-01f, 1.73062712e-01f, 3.98133136e-03f, -1.17816746e-01f, 3.99692431e-02f,
  -7.81244859e-02f, -9.77870822e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 52
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 6, 52
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        64, 6, 52
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        64, 6, 52
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        64, 12
    );
    }
    