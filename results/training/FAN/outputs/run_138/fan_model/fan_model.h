/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 19 x 120)
const int L0_fan_Wp_rows = 19;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  3.70641705e-04f, 1.24993756e-01f, -1.19170763e-01f, -4.02612351e-02f, -1.84514642e-01f, 6.93256559e-04f, 2.88789496e-02f, -2.05297142e-01f, -2.09458321e-01f, -8.08836371e-02f,
  -2.13117212e-01f, 3.76407243e-02f, -5.85158467e-02f, 1.00200869e-01f, 3.44861187e-02f, 2.38855883e-01f, 1.22782953e-01f, 8.79807025e-02f, 7.96530694e-02f, 1.16485670e-01f,
  6.61749616e-02f, 1.73242405e-01f, 1.60978869e-01f, 7.74193704e-02f, -5.26188221e-03f, 2.78691365e-03f, 3.14629488e-02f, -4.96909171e-02f, 1.20889672e-04f, -1.92330509e-01f,
  1.54456934e-02f, -1.81168288e-01f, -8.46966654e-02f, -5.27791344e-02f, 6.32463843e-02f, 5.09741157e-02f, -1.58226304e-02f, -2.82289013e-02f, -2.84292400e-02f, -3.32811736e-02f,
  9.04992446e-02f, -5.67967705e-02f, -3.47232223e-02f, -1.06748464e-02f, 2.06778198e-02f, -8.67757797e-02f, 4.09115404e-02f, -3.69835608e-02f, -4.35290672e-02f, 5.51125873e-03f,
  1.06446087e-01f, 1.74182430e-02f, 8.39849636e-02f, 1.22885928e-01f, -1.25422943e-02f, -9.45921093e-02f, 4.77625541e-02f, 5.27446680e-02f, 2.64355671e-02f, -5.19349724e-02f,
  -4.14639860e-02f, 3.19675952e-02f, -4.98028509e-02f, 4.02673287e-03f, -9.46986601e-02f, -7.56159425e-02f, 5.91741987e-02f, -1.05228990e-01f, 9.88045707e-02f, 1.82016462e-01f,
  -5.72624356e-02f, -4.08850759e-02f, -2.62351893e-03f, 2.32789382e-01f, 6.30638227e-02f, 6.70691282e-02f, 4.85391244e-02f, 7.76688606e-02f, 1.82377622e-02f, -4.85108197e-02f,
  -5.08765876e-02f, -9.92027894e-02f, -7.62666343e-03f, 1.11506470e-01f, -4.94546369e-02f, 9.54594463e-02f, 1.32445127e-01f, 3.49608958e-02f, -1.18588321e-01f, -1.88378133e-02f,
  -8.98964703e-02f, -1.73770338e-01f, -1.60301328e-01f, -1.86123680e-02f, -4.33022529e-02f, 1.07662622e-02f, -5.92005178e-02f, 4.63896468e-02f, -2.41049100e-02f, -3.97722349e-02f,
  -3.57046071e-03f, 3.00891660e-02f, 8.87804925e-02f, 3.54258306e-02f, 1.35499522e-01f, 3.80888605e-03f, -1.84437726e-02f, 7.18565509e-02f, 1.58973653e-02f, 8.05840418e-02f,
  1.76233370e-02f, -1.22437172e-01f, 2.32512560e-02f, 2.84237992e-02f, 6.07550442e-02f, -2.27771048e-02f, -4.91602384e-02f, 7.89289642e-03f, -4.82602557e-03f, 7.59932175e-02f,
  -3.10826749e-01f, 2.72043079e-01f, -1.07984513e-01f, -8.65151063e-02f, -6.11299947e-02f, -1.86065599e-01f, -1.97131023e-01f, -5.92034683e-03f, 4.78687324e-03f, 6.63900822e-02f,
  -1.52027681e-01f, -5.78066595e-02f, -4.12218273e-02f, -7.51203597e-02f, -2.22791165e-01f, 3.17957141e-02f, -1.15541637e-01f, -4.79670092e-02f, -3.10173873e-02f, 6.84275031e-02f,
  -2.77674068e-02f, -1.11626655e-01f, -1.01011790e-01f, 5.00702485e-02f, -7.74156228e-02f, -4.12044162e-03f, -8.55949521e-02f, -3.55965234e-02f, -5.10102138e-02f, -1.06788769e-01f,
  3.43832234e-03f, 6.43173829e-02f, 6.59241527e-03f, 2.21084002e-02f, -1.37148857e-01f, -8.59901309e-02f, -1.59479026e-02f, -9.82324705e-02f, -3.27703431e-02f, -3.48141231e-02f,
  -9.71615613e-02f, -5.79085527e-03f, 2.38221299e-04f, -1.16088400e-02f, -1.24669436e-03f, -7.39466324e-02f, 6.29543215e-02f, -2.92703528e-02f, -1.69423893e-02f, 5.72864003e-02f,
  5.52474298e-02f, -7.89232031e-02f, -1.07906302e-02f, -5.85662536e-02f, -9.56522152e-02f, -4.70377281e-02f, -2.48830933e-02f, -5.47141358e-02f, -3.31364833e-02f, 1.20981038e-02f,
  -8.61026868e-02f, 9.47539508e-02f, 6.53096735e-02f, -9.15497616e-02f, 9.21575446e-03f, 1.16964402e-02f, -6.58507124e-02f, 3.72533128e-03f, -6.23456063e-03f, 3.61775942e-02f,
  -4.95456681e-02f, -4.22142856e-02f, 2.70874444e-02f, 2.15737727e-02f, -1.07965484e-01f, -1.21835917e-02f, -6.66745082e-02f, 4.47571427e-02f, -8.14973190e-03f, -2.06564628e-02f,
  9.81354248e-03f, -5.51013611e-02f, 1.06436266e-02f, -1.11604407e-02f, 4.01617847e-02f, -4.17645127e-02f, 2.39251070e-02f, -2.31062956e-02f, -5.41728339e-04f, -1.10897340e-01f,
  2.99244523e-02f, 2.33224422e-01f, 4.75432072e-03f, 9.27174743e-03f, 8.11438188e-02f, -3.03639565e-02f, -6.39499575e-02f, -7.84416962e-03f, 9.01066884e-03f, 4.74294554e-03f,
  -7.04386309e-02f, 4.46658991e-02f, 6.54206574e-02f, -1.02009244e-01f, -5.97213134e-02f, -3.16278301e-02f, 7.29215192e-03f, -7.13377893e-02f, -4.15661484e-02f, 5.99779002e-03f,
  -3.33292931e-02f, 1.66341774e-02f, -6.36250377e-02f, -7.08907396e-02f, -2.86942068e-02f, 1.28052607e-02f, -2.51315418e-04f, 1.60889626e-02f, -4.68955748e-02f, -1.03952806e-03f,
  -5.47426999e-01f, 7.96911120e-02f, 5.45166759e-03f, -7.34577104e-02f, -1.31458089e-01f, 1.44603774e-01f, -3.04961149e-02f, -9.77587886e-03f, 1.48289055e-01f, 9.80391428e-02f,
  -4.09856774e-02f, -3.35056894e-02f, -1.71464961e-02f, -8.04694649e-03f, -1.62341028e-01f, 5.74370958e-02f, 3.30494018e-03f, -8.22542235e-02f, 5.40178157e-02f, -2.69684829e-02f,
  7.06663132e-02f, -4.16301284e-03f, 5.23102097e-02f, 9.76888910e-02f, -1.37725294e-01f, -6.51536882e-02f, -7.52716437e-02f, 8.15963894e-02f, -4.74453382e-02f, -1.04752079e-01f,
  -1.49491787e-01f, -2.22864747e-02f, 2.60818545e-02f, 4.14002240e-02f, 1.91418659e-02f, 2.01243479e-02f, 3.46114375e-02f, -9.15959254e-02f, -4.44532111e-02f, 5.41112423e-02f,
  -3.90070528e-02f, -5.49956188e-02f, 4.32208041e-03f, 4.10292000e-02f, 1.26886889e-01f, -1.62813452e-03f, 2.70886403e-02f, -5.24756052e-02f, -6.96999133e-02f, -4.24079038e-02f,
  8.19485411e-02f, 4.69538458e-02f, 4.76650745e-02f, 3.85264754e-02f, 4.35316190e-02f, -2.34791063e-04f, 3.70429480e-03f, 9.99064278e-03f, 5.05808406e-02f, -4.47844667e-03f,
  6.25065938e-02f, -8.80295318e-03f, 1.68498475e-02f, 4.06014733e-02f, 1.62225738e-02f, -4.49679047e-02f, -4.36524265e-02f, -3.50543410e-02f, -2.44059209e-02f, -1.33805042e-02f,
  -5.01991771e-02f, -1.81210153e-02f, 2.96624377e-03f, 1.09636813e-01f, -1.21314479e-02f, -1.45818945e-02f, -6.52132034e-02f, 6.73051132e-03f, 6.85519278e-02f, -4.97305254e-03f,
  -6.29516691e-02f, 1.11704355e-03f, 2.68004555e-02f, 3.77488509e-02f, -1.63753401e-04f, 3.44220959e-02f, -1.17622074e-02f, 7.78612643e-02f, 2.12573390e-02f, -4.69565801e-02f,
  8.85837451e-02f, 6.68822303e-02f, -1.71490237e-02f, 9.03957188e-02f, 4.45753038e-02f, 4.54387031e-02f, 2.43266989e-02f, 4.43287902e-02f, 1.01557180e-01f, 9.67846438e-02f,
  2.14739144e-02f, -4.44526924e-03f, -8.20723772e-02f, 8.42663869e-02f, 2.24294085e-02f, 9.03431401e-02f, -1.30585849e-01f, 7.68872723e-02f, 3.57201025e-02f, 2.04373784e-02f,
  -6.95704445e-02f, -8.74918848e-02f, -3.90714929e-02f, -3.13416421e-02f, 6.46685832e-04f, -9.04388577e-02f, -3.98530401e-02f, -3.19892494e-03f, 4.67526987e-02f, 3.94626074e-02f,
  -2.26251423e-01f, 2.90394332e-02f, 2.11786963e-02f, -6.40088618e-02f, -1.18560687e-01f, -1.71434194e-01f, -8.00795257e-02f, -2.19257489e-01f, -5.63538522e-02f, -5.46132401e-02f,
  -9.55161527e-02f, -2.60489471e-02f, 1.32293254e-01f, -9.85551700e-02f, 1.09980285e-01f, 1.53736979e-01f, -7.99236819e-02f, -1.27840126e-02f, 2.02802680e-02f, -1.93260208e-01f,
  5.20568993e-03f, -1.15306310e-01f, 7.75047317e-02f, -1.10560685e-01f, -8.84319618e-02f, 8.48148920e-06f, 6.64684996e-02f, 9.86172110e-02f, -6.35153651e-02f, -2.64176689e-02f,
  -9.42007676e-02f, -1.47108585e-01f, 5.09380773e-02f, -3.42262089e-02f, -1.41271532e-01f, -6.70493394e-02f, 4.05893549e-02f, 4.94076051e-02f, -1.41195972e-02f, -8.05017278e-02f,
  5.89695647e-02f, -9.78027377e-03f, -8.19519237e-02f, 9.08262059e-02f, 2.98483297e-02f, -1.65883526e-02f, 2.97215600e-02f, 2.96172872e-02f, -1.48899574e-03f, 6.50769398e-02f,
  -7.64115900e-02f, 1.80758927e-02f, -1.59519948e-02f, 8.59773383e-02f, -3.96580212e-02f, -8.84375647e-02f, -2.65910979e-02f, 7.55208021e-04f, 1.05238277e-02f, -5.97325061e-03f,
  -7.84917995e-02f, 3.43045443e-02f, 8.37631375e-02f, 9.42241922e-02f, -1.56884303e-03f, -8.46413616e-03f, -6.67170435e-02f, 9.20056552e-03f, 5.06417155e-02f, 4.41698655e-02f,
  -2.33677477e-02f, 1.78728160e-02f, -8.72653350e-02f, -1.12733804e-02f, 5.22686401e-03f, 7.37536326e-03f, 3.49416509e-02f, -2.86971126e-02f, 5.05613089e-02f, 6.22099079e-02f,
  1.09213695e-01f, -2.73586530e-02f, -6.91966414e-02f, 3.10182814e-02f, -5.89321181e-03f, 6.62748069e-02f, -3.79536953e-03f, 2.15473846e-02f, -4.35636677e-02f, -2.97515374e-02f,
  -6.57842308e-02f, -1.95927426e-01f, 3.39680202e-02f, -1.43017722e-02f, 4.17139828e-02f, 5.94827756e-02f, 6.95450455e-02f, 1.83290765e-02f, 5.94829693e-02f, -9.02676955e-02f,
  2.02859230e-02f, 9.74121168e-02f, -2.02899680e-01f, 1.27027584e-02f, 1.02721974e-01f, -1.20832007e-02f, -4.28568870e-02f, -2.29460113e-02f, -5.18134646e-02f, 1.79699734e-02f,
  -3.52277793e-02f, -4.48624119e-02f, 4.93204817e-02f, -2.35167239e-02f, -6.63183331e-02f, -1.08724097e-02f, -6.51859716e-02f, -3.78138036e-03f, 9.62239653e-02f, -7.46911615e-02f,
  1.55690312e-01f, -1.02167279e-01f, 5.91358170e-03f, 1.30989298e-01f, -3.09830182e-03f, 1.56706497e-01f, 1.53764680e-01f, 1.64436609e-01f, 7.45438263e-02f, -2.73442984e-01f,
  -1.97702587e-01f, -1.75261676e-01f, -1.14576168e-01f, 3.38811912e-02f, 2.43341461e-01f, 8.63987803e-02f, 2.02219933e-01f, 1.00313447e-01f, 1.77282214e-01f, 1.35825604e-01f,
  1.81148678e-01f, 8.57396051e-02f, 1.47305414e-01f, 1.83697790e-02f, -5.11945821e-02f, -5.92667125e-02f, -8.13355297e-02f, -1.02784252e-04f, -7.46627226e-02f, 4.66035418e-02f,
  1.31135568e-01f, -7.55682960e-02f, 3.79139967e-02f, -7.63407052e-02f, -1.76179465e-02f, -8.93125013e-02f, -8.84627625e-02f, -2.79418174e-02f, 7.12684616e-02f, -8.27121660e-02f,
  -9.82320011e-02f, 3.33345160e-02f, -3.29117174e-03f, 6.19377904e-02f, 2.29891077e-01f, -4.83761579e-02f, 6.13587499e-02f, 2.01147646e-04f, 3.89462225e-02f, 2.61126366e-02f,
  7.53240362e-02f, 1.70422778e-01f, 8.45426172e-02f, 6.82066008e-02f, 7.69897848e-02f, 2.92281043e-02f, -8.17117095e-02f, 4.92523350e-02f, 7.02011064e-02f, 6.01704046e-02f,
  5.04106544e-02f, -1.55755663e-02f, -1.65709052e-02f, -2.43162792e-02f, 4.28630598e-03f, 6.11607954e-02f, 1.51779605e-02f, -7.71642383e-03f, -4.91166785e-02f, 8.33184719e-02f,
  -4.02808115e-02f, -6.37044534e-02f, 1.04070403e-01f, 1.29760519e-01f, -6.66361824e-02f, -4.57110927e-02f, 6.05966933e-02f, -9.11741033e-02f, -2.39535701e-02f, -4.11717519e-02f,
  1.49790794e-02f, 2.57011373e-02f, -8.22234824e-02f, -1.10718235e-01f, 5.18572964e-02f, 2.42583808e-02f, 4.35762852e-02f, 3.99842262e-02f, -1.14549100e-02f, -4.66917176e-03f,
  -5.54596968e-02f, -1.04661815e-01f, 2.35139616e-02f, 4.45362553e-02f, 1.72011536e-02f, -1.11129731e-01f, 9.34360698e-02f, 5.23530021e-02f, 7.59817362e-02f, 2.33801287e-02f,
  -1.06656507e-01f, -1.49897896e-02f, -2.89597195e-02f, -3.05295028e-02f, 1.42391622e-01f, -2.42163762e-02f, 4.40350827e-03f, 8.42912216e-03f, 1.25763360e-02f, -2.97554173e-02f,
  1.01456186e-02f, -6.49740845e-02f, 2.79409587e-02f, -2.28466536e-03f, -9.77921262e-02f, -6.45546243e-02f, 1.22934086e-02f, -3.00379302e-02f, 7.68488720e-02f, 4.12214436e-02f,
  1.27062425e-01f, 6.62794337e-02f, 4.96665481e-03f, 2.09818576e-02f, -4.12845239e-03f, -1.20180272e-01f, -1.06608555e-01f, 1.04318291e-01f, -7.05689862e-02f, -2.06426368e-03f,
  1.10216262e-02f, -8.47846195e-02f, -6.33250736e-03f, 1.13448568e-01f, 9.34942439e-02f, -2.37897262e-02f, 1.95528954e-01f, 5.75149953e-02f, 5.95647432e-02f, 1.17742255e-01f,
  -3.22550978e-03f, 1.84386998e-01f, 6.70063645e-02f, 1.45288467e-01f, 1.64173394e-01f, 6.52283281e-02f, 2.16648072e-01f, -2.96197478e-02f, 7.98229221e-03f, 2.48511732e-02f,
  3.15901786e-02f, 4.57576066e-02f, 1.13411397e-02f, -7.99535289e-02f, -3.96889984e-04f, 7.34670162e-02f, -4.22794037e-02f, 8.27909186e-02f, -5.59141859e-02f, -2.70320531e-02f,
  1.97523031e-02f, 1.18716329e-01f, -4.44806628e-02f, -8.84054694e-03f, 4.28278632e-02f, -1.28687903e-01f, 1.75179320e-03f, -1.23617470e-01f, 2.94315722e-02f, 5.91689534e-02f,
  -6.28117546e-02f, 5.75433932e-02f, -1.16697587e-02f, -9.01094358e-03f, -7.95811340e-02f, 3.74957137e-02f, -5.42177185e-02f, -3.06838900e-02f, 5.89164607e-02f, -1.15744350e-03f,
  -2.07172800e-03f, 2.60633975e-02f, 8.58644545e-02f, 4.67844307e-02f, 4.90734018e-02f, -2.40373146e-02f, 1.24266967e-01f, 4.38087173e-02f, -7.25385174e-02f, 9.34815779e-02f,
  -1.64644402e-02f, -1.27121191e-02f, -1.11683430e-02f, -8.47641844e-03f, 4.10930477e-02f, 5.74574918e-02f, -8.14318284e-02f, 3.61981662e-03f, -1.54329315e-02f, -1.77260749e-02f,
  6.50060326e-02f, 4.85232510e-02f, 2.09698211e-02f, -3.59617895e-03f, 2.79317200e-02f, -3.31093483e-02f, 9.90064368e-02f, 1.77300174e-03f, -7.20222220e-02f, 3.99922282e-02f,
  1.01127088e-01f, 1.62718743e-01f, -4.96557765e-02f, 4.89575043e-02f, -9.80582237e-02f, -2.06956938e-02f, -4.80699632e-03f, 6.13854490e-02f, 4.47773980e-03f, 9.91027337e-03f,
  1.28978305e-02f, 1.18118441e-02f, 2.85923257e-02f, -2.48721838e-02f, 7.64634162e-02f, -7.51757547e-02f, 3.76295708e-02f, -1.23938628e-01f, 4.66253608e-02f, 1.00889318e-01f,
  9.48500092e-05f, -5.11354432e-02f, -3.08888126e-02f, -8.86264220e-02f, -9.59450938e-03f, -3.47991213e-02f, -7.48500675e-02f, 2.02943012e-02f, 9.06592458e-02f, -8.85958411e-03f,
  -1.74122497e-01f, -7.60606006e-02f, -2.09794849e-01f, -2.45436475e-01f, 1.51225761e-01f, 6.74204901e-02f, 1.23393498e-01f, -1.06269084e-01f, -2.45198533e-01f, 1.20482922e-01f,
  1.20407134e-01f, -2.41569206e-01f, 1.94298234e-02f, -1.35524794e-01f, -2.28441119e-01f, -1.38022438e-01f, -7.56899491e-02f, -2.76376326e-02f, -1.15139127e-01f, -3.29793543e-02f,
  -8.59358534e-02f, 1.38879037e-02f, -3.06727022e-01f, 1.28090814e-01f, -2.91489679e-02f, -7.55541548e-02f, 5.23049980e-02f, 3.16489749e-02f, 6.57920837e-02f, 4.96543199e-02f,
  -2.48584654e-02f, -1.19197331e-02f, 1.23487050e-02f, -9.29003283e-02f, -3.92059162e-02f, -1.51875860e-03f, 2.89398450e-02f, 7.27066025e-02f, 6.77715894e-03f, -5.95467770e-03f,
  3.23624723e-02f, -3.56328003e-02f, 7.35333934e-02f, -2.68673282e-02f, -3.66866514e-02f, -5.42867519e-02f, 5.99692389e-02f, -2.96589900e-02f, -6.58471659e-02f, -7.35270903e-02f,
  4.41519264e-03f, 3.23007889e-02f, -3.46250925e-03f, -1.08288676e-02f, -4.13205549e-02f, 1.28985774e-02f, -3.49327251e-02f, 9.65689719e-02f, 7.36360922e-02f, -1.14202708e-01f,
  1.61770597e-01f, -3.23867686e-02f, -4.64358442e-02f, -2.70424522e-02f, -1.77244004e-02f, -1.23884734e-02f, 2.34126225e-02f, 9.81239751e-02f, -3.54446657e-02f, -4.38666381e-02f,
  2.88771112e-02f, -7.50330091e-02f, 3.34605761e-02f, -6.36296347e-02f, 1.05030611e-02f, 1.95510010e-03f, 6.84030503e-02f, 1.03911646e-02f, -8.41268450e-02f, -2.52476782e-02f,
  -3.66495028e-02f, 2.52026189e-02f, -6.65829284e-03f, 1.14871554e-01f, 7.03197196e-02f, 2.57718470e-02f, 5.98260574e-02f, -2.39802897e-02f, -6.34974837e-02f, 1.11368984e-01f,
  3.50396372e-02f, 6.16043014e-03f, -8.54485109e-03f, 1.88554823e-02f, 2.24819165e-02f, -2.88533140e-02f, -4.52727862e-02f, -7.75928050e-03f, -6.80812001e-02f, 6.11194372e-02f,
  4.24376549e-03f, 2.16040555e-02f, 3.00707407e-02f, 1.13066826e-02f, -5.22766821e-02f, 3.06473654e-02f, 2.36402713e-02f, -5.58204353e-02f, 5.66450357e-02f, 3.98001708e-02f,
  1.96673617e-01f, -5.86575782e-03f, 1.79433115e-02f, 3.15162018e-02f, 3.36364545e-02f, 2.26665903e-02f, 2.14208160e-02f, -1.14035355e-02f, 9.39114988e-02f, -9.36990008e-02f,
  2.52203703e-01f, -8.89134333e-02f, -4.66855951e-02f, 1.92344144e-01f, -3.52129824e-02f, 2.17287511e-01f, 2.89217234e-01f, -5.21964207e-02f, -5.73467314e-02f, 1.04361124e-01f,
  4.25178334e-02f, 5.79830743e-02f, -8.36833119e-02f, 8.56181532e-02f, 1.83738396e-01f, -1.18937179e-01f, 2.28691533e-01f, 1.26001552e-01f, -1.28981262e-01f, 2.35514730e-01f,
  1.65033750e-02f, 1.54268205e-01f, -7.20640644e-02f, -5.10728098e-02f, 6.85388371e-02f, -6.34381399e-02f, 1.51633635e-01f, -6.61155581e-02f, 1.32029355e-01f, -5.41112199e-02f,
  -4.68087308e-02f, -1.00330539e-01f, -5.29206805e-02f, -1.10723138e-01f, 1.16050214e-01f, 5.88604948e-03f, -8.96720681e-03f, -6.09327033e-02f, -8.13667625e-02f, -2.04809643e-02f,
  1.06698990e-01f, -5.94987310e-02f, -1.23855202e-02f, -7.45182112e-02f, 3.33617032e-02f, -7.25480774e-03f, -3.79028991e-02f, -1.41247302e-01f, 3.10640223e-02f, 7.77036026e-02f,
  -1.46222338e-02f, -2.85998285e-02f, 1.01978697e-01f, 1.04157059e-02f, -6.21291436e-02f, -2.72779469e-03f, -1.19117582e-02f, 8.26459229e-02f, 1.35631459e-02f, 4.76728529e-02f,
  9.41670015e-02f, 4.74850200e-02f, -1.13824919e-01f, 4.47054300e-03f, -5.63243888e-02f, 1.72761306e-02f, 1.22511778e-02f, 6.08020611e-02f, -2.39168815e-02f, -3.74045931e-02f,
  5.69338687e-02f, -6.77038133e-02f, -1.49034313e-03f, 3.24284546e-02f, 5.65501973e-02f, 6.71523483e-03f, 7.36341774e-02f, -9.94491130e-02f, 8.56457353e-02f, -1.26811460e-01f,
  5.98875657e-02f, 7.49703869e-03f, -1.02070272e-02f, 2.51255669e-02f, 1.07654231e-02f, 1.69710198e-03f, -3.04471664e-02f, 8.65674019e-02f, 5.78886233e-02f, 5.05838208e-02f,
  7.48529285e-02f, 9.06134620e-02f, 2.30052751e-02f, 4.59457427e-04f, -7.51863560e-03f, -2.39279903e-02f, 9.47133731e-03f, 4.32206951e-02f, 4.40304540e-02f, 1.86732337e-02f,
  7.94862956e-03f, -1.46660232e-03f, 3.42120863e-02f, -1.40594859e-02f, 2.35188492e-02f, 2.47961562e-02f, 3.98958698e-02f, 1.36319064e-02f, 4.64918427e-02f, -4.87886481e-02f,
  1.62579231e-02f, -4.01686020e-02f, 3.05045042e-02f, 5.41769229e-02f, 4.18422744e-02f, -1.14913983e-03f, 2.53698998e-03f, 9.40537974e-02f, -5.76482192e-02f, 1.86901856e-02f,
  8.99635628e-03f, 1.65391579e-01f, 1.61655620e-01f, 1.53958365e-01f, -3.24418843e-02f, 7.05084577e-02f, 1.27518028e-01f, 6.32530749e-02f, 1.56162456e-01f, 1.21759817e-01f,
  5.33739701e-02f, 1.83986366e-01f, -1.45877560e-03f, -1.99554637e-02f, -1.43221095e-01f, -2.30514601e-01f, 4.89419028e-02f, -4.22907025e-02f, -1.04224943e-01f, 7.40745515e-02f,
  3.05523118e-03f, -1.18145689e-01f, -8.65114108e-02f, -8.16839784e-02f, 7.16858823e-03f, 6.09270334e-02f, -3.07199322e-02f, -2.66945618e-03f, 1.37314782e-01f, 9.26181749e-02f,
  -7.89268613e-02f, -1.05774023e-01f, 8.12368393e-02f, -1.69494543e-02f, 3.82398404e-02f, -2.85834651e-02f, -3.43213864e-02f, 2.44372226e-02f, -1.73204914e-01f, 8.17992166e-02f,
  -5.63149862e-02f, -3.06431223e-02f, 1.51161373e-01f, -1.02554429e-02f, -1.73783302e-02f, 3.96333300e-02f, 7.00593442e-02f, 7.85537064e-02f, -1.19904801e-02f, 1.44365981e-01f,
  3.41355838e-02f, 1.10176064e-01f, 6.76213726e-02f, -4.90580648e-02f, 4.58516665e-02f, 1.35340786e-03f, 6.53904900e-02f, 6.34731129e-02f, 2.69527882e-02f, -8.18999931e-02f,
  -7.46300668e-02f, -8.10449645e-02f, -7.70240650e-02f, -3.87372002e-02f, 1.58990379e-02f, 6.60810247e-02f, 6.66572154e-03f, -3.73991467e-02f, 1.21805873e-02f, 5.28565198e-02f,
  8.44331160e-02f, 3.25140506e-02f, -1.74181014e-02f, -1.23164631e-01f, 2.86822990e-02f, 3.22723947e-02f, -3.71451713e-02f, 7.17365043e-03f, 7.47590959e-02f, -1.70871429e-03f,
  -8.46573934e-02f, -6.52851537e-02f, -1.18120862e-02f, 1.25854596e-01f, 7.44108064e-03f, -4.98837791e-02f, -3.05756256e-02f, -5.77651486e-02f, -2.44348682e-02f, -1.09582031e-02f,
  -1.44838855e-01f, -1.95092514e-01f, -6.04914576e-02f, 1.08889826e-02f, -5.14446795e-02f, -6.93317577e-02f, 4.82918695e-02f, 3.69506665e-02f, -1.02653906e-01f, -4.24748138e-02f,
  -4.74908352e-02f, 4.37466055e-02f, -6.31055459e-02f, -1.18023671e-01f, -2.67973337e-02f, 7.72174969e-02f, 2.90574338e-02f, -7.24132061e-02f, -5.40921241e-02f, 1.12475432e-01f,
  4.33826596e-02f, -3.45360450e-02f, -1.85400955e-02f, -4.93665263e-02f, 2.70401561e-05f, 1.19339742e-01f, 3.35227549e-02f, -7.57288514e-03f, -1.18453510e-01f, -4.72343788e-02f,
  -2.67878860e-01f, 8.52852613e-02f, 7.47294724e-02f, -1.57744642e-02f, -1.39934495e-01f, 1.36122480e-02f, 1.01977058e-01f, -4.73532081e-02f, 1.17495701e-01f, -6.73828050e-02f,
  6.79089203e-02f, 6.46648705e-02f, 3.06739718e-01f, -5.43578975e-02f, -3.07009220e-02f, 2.47503519e-01f, -6.97653741e-02f, 1.99691132e-02f, 9.49225053e-02f, -3.39458287e-02f,
  -4.56935838e-02f, -3.20033580e-01f, -8.34399834e-02f, -2.90402442e-01f, -2.14105695e-01f, -9.26401243e-02f, -2.73595512e-01f, 2.59243418e-02f, -3.08859766e-01f, -1.12661533e-01f,
  -2.37022564e-02f, 2.41283327e-02f, -4.16960604e-02f, -3.97408195e-02f, 2.48901956e-02f, -6.12937212e-02f, 7.50324875e-03f, -1.93372425e-02f, -1.39425471e-02f, -3.87504771e-02f,
  3.97461839e-02f, 9.83061548e-03f, -6.10097051e-02f, -3.24946791e-02f, 3.22151035e-02f, -7.25257117e-03f, -5.04992045e-02f, 2.87212245e-02f, 3.17851715e-02f, 4.83741276e-02f,
  1.08254366e-01f, -4.69955523e-03f, -3.39141898e-02f, -5.78794703e-02f, 7.15401918e-02f, -9.14575532e-02f, -4.36418280e-02f, 4.55177249e-03f, -1.51736677e-01f, -9.09642549e-04f,
  -1.94674898e-02f, 3.01080700e-02f, 1.37423817e-02f, 5.76871214e-03f, 7.93362185e-02f, 7.48622557e-03f, 6.66465834e-02f, 2.24528126e-02f, 1.11373350e-01f, 7.51519203e-02f,
  -6.76331222e-02f, -2.30467860e-02f, 1.85113493e-02f, 5.63662462e-02f, 2.52742488e-02f, 3.02695646e-03f, -3.57007086e-02f, -2.41463743e-02f, 6.89979717e-02f, 7.27385953e-02f,
  7.78931193e-04f, 2.81988531e-02f, 3.41874808e-02f, -5.01764193e-02f, -2.34322790e-02f, 5.25344685e-02f, -3.74651551e-02f, -5.24016209e-02f, 2.39639562e-02f, 5.47023900e-02f,
  6.15546778e-02f, 2.55617835e-02f, 1.13168433e-01f, -5.58000281e-02f, 2.87421122e-02f, -1.08518396e-02f, -4.62436676e-03f, -2.66995728e-02f, 2.96117608e-02f, -3.63299400e-02f,
  -5.19872159e-02f, 2.34722700e-02f, -1.24313042e-01f, -1.66681018e-02f, -4.27251644e-02f, -6.91515133e-02f, -4.23763059e-02f, -7.08269281e-03f, -5.28169684e-02f, -2.68131793e-02f,
  -9.26273167e-02f, 5.04122451e-02f, -3.49980034e-02f, -1.21487249e-02f, -8.91610887e-03f, 1.02063389e-02f, -3.39463837e-02f, -3.03876363e-02f, -5.30337393e-02f, 1.22670688e-01f,
  -2.92051822e-01f, -2.32753634e-01f, -1.15553178e-02f, 6.75714761e-02f, 2.01361984e-01f, 3.72313231e-01f, 2.05268323e-01f, 1.56486128e-02f, 2.14117840e-01f, -3.47662419e-02f,
  1.33284509e-01f, 6.10984899e-02f, -3.34131531e-02f, 6.56044558e-02f, 2.09373370e-01f, 7.58818630e-03f, 9.61720720e-02f, 6.61229044e-02f, -7.18655735e-02f, -7.59435445e-02f,
  8.56667906e-02f, 1.24432430e-01f, 9.72200069e-04f, -1.72471866e-01f, -1.34182081e-01f, -3.23046625e-01f, -1.35756865e-01f, -1.02985591e-01f, -1.01842918e-01f, 9.35579836e-02f,
  -4.89378422e-02f, -8.89985263e-02f, 3.29603255e-02f, 1.07731679e-02f, -1.22036390e-01f, -4.66182195e-02f, -2.09735986e-02f, 3.03588435e-02f, -2.56113932e-02f, 4.07597087e-02f,
  -3.73790786e-02f, -1.07787931e-02f, -6.06053462e-03f, -1.38828382e-02f, -5.22212237e-02f, 9.33245569e-02f, 4.82433569e-03f, 1.38695457e-03f, -5.12053780e-02f, -2.92981658e-02f,
  -2.92662694e-03f, -6.09296486e-02f, -7.23087341e-02f, -6.83802813e-02f, -8.08566064e-03f, -6.34314641e-02f, -1.09982669e-01f, -8.99049342e-02f, -2.98636407e-02f, -3.17755193e-02f,
  -4.89322208e-02f, 7.08890185e-02f, 8.05452913e-02f, 9.82336234e-03f, 2.62234434e-02f, -1.10506285e-02f, 1.71548761e-02f, 6.54357299e-03f, -4.59706448e-02f, 1.47982575e-02f,
  1.36361662e-02f, 1.40267788e-02f, -3.11798062e-02f, 6.51573390e-02f, 3.06052491e-02f, 4.29855520e-03f, 5.45461150e-03f, -6.94083124e-02f, 4.11148332e-02f, -3.85429412e-02f,
  1.43876627e-01f, 4.19207923e-02f, 2.64620353e-02f, 1.61511153e-02f, 4.59917709e-02f, 7.37471059e-02f, 5.91751225e-02f, -1.78806428e-02f, 6.72053471e-02f, 5.93189374e-02f,
  -1.11381188e-01f, -1.37760639e-01f, 1.11959219e-01f, 7.45647550e-02f, 3.23399752e-02f, 4.55533974e-02f, -4.90213186e-03f, 1.05296947e-01f, 7.37342536e-02f, -4.85488586e-03f,
  2.39302684e-02f, 2.66995691e-02f, -6.82470724e-02f, -3.42133641e-02f, 3.27956267e-02f, 6.93972409e-02f, -7.00564217e-03f, 5.76444678e-02f, -5.84797189e-02f, -1.78852901e-02f,
  -4.85691838e-02f, -5.12914993e-02f, 1.20800197e-01f, -2.78398930e-03f, 5.17697148e-02f, -3.03883851e-02f, -1.14976659e-01f, -9.90999788e-02f, -2.19015833e-02f, 5.93522564e-02f,
  -6.18416294e-02f, 1.58925816e-01f, -2.66940355e-01f, -2.98115343e-01f, 6.82477467e-03f, -4.88092229e-02f, -2.71196701e-02f, -1.01991922e-01f, -9.88380685e-02f, 1.83032602e-01f,
  6.56571239e-02f, 9.69256163e-02f, 7.68221766e-02f, -3.92960832e-02f, -9.51937288e-02f, -9.31754187e-02f, -9.40473229e-02f, -3.68575915e-04f, -7.14077130e-02f, 1.41963571e-01f,
  -5.17263710e-02f, -9.69124138e-02f, -1.21714942e-01f, 1.73470154e-02f, 5.00757098e-02f, -5.53280152e-02f, -8.84382501e-02f, -8.66615027e-03f, 1.81097556e-02f, -2.68358551e-02f,
  1.02308609e-01f, -1.35833640e-02f, 1.06904268e-01f, 2.52328403e-02f, 5.64386398e-02f, -1.43384608e-03f, -2.53697159e-03f, -1.20106392e-01f, -7.54849687e-02f, -8.28009173e-02f,
  2.66410839e-02f, 8.71379375e-02f, -2.67474353e-02f, -7.83649683e-02f, 9.37432945e-02f, 3.85975130e-02f, -5.50651886e-02f, -4.80756201e-02f, 5.37041239e-02f, 7.52473995e-02f,
  -9.26234480e-03f, 3.47617939e-02f, -3.64281200e-02f, -8.36161524e-02f, -8.13752860e-02f, -7.54157305e-02f, -6.23155609e-02f, 6.01716526e-02f, 7.53828362e-02f, -3.96604724e-02f,
  -4.60291617e-02f, 1.41803548e-01f, 3.97379175e-02f, 3.15653756e-02f, 4.06602435e-02f, 1.98832043e-02f, 1.80732012e-02f, 6.64184541e-02f, -8.23693350e-03f, 1.55673288e-02f,
  2.86358241e-02f, -3.39323701e-03f, 4.11424339e-02f, 7.47302622e-02f, -5.90348728e-02f, 2.19617672e-02f, -1.18286246e-02f, 3.74708846e-02f, 5.50023280e-02f, -2.98645739e-02f,
  -5.57757244e-02f, 4.45640422e-02f, 5.58862649e-02f, -7.97884464e-02f, 2.08938052e-03f, 2.76404852e-03f, 8.58736634e-02f, -3.95417027e-02f, 1.23837162e-02f, 1.07160889e-01f,
  2.42532060e-01f, 6.15444556e-02f, 4.83042635e-02f, 7.37995133e-02f, -2.53196787e-02f, 4.63793911e-02f, -1.19226286e-02f, 9.03996546e-03f, 4.50388901e-02f, 4.16175388e-02f,
  8.46226234e-03f, -1.55175105e-02f, 7.22204819e-02f, -5.07624038e-02f, -6.96049631e-03f, 5.67791015e-02f, 1.86013579e-02f, 4.70124092e-03f, 1.01511873e-01f, 6.23495877e-02f,
  5.94898909e-02f, -4.28431779e-02f, -2.89259832e-02f, -9.08138752e-02f, 4.35973294e-02f, -2.64565870e-02f, -6.04697540e-02f, -4.51991148e-02f, -4.98478068e-03f, 8.24953988e-02f,
  1.32597491e-01f, -3.39875311e-01f, 2.17051893e-01f, 6.53455630e-02f, 1.10607333e-01f, 5.15578091e-02f, 4.40016985e-02f, -1.33584902e-01f, 7.64931366e-03f, -1.56294763e-01f,
  -1.26795411e-01f, 4.04601507e-02f, -1.90888986e-01f, -2.50351103e-03f, -1.24886796e-01f, -1.24610409e-01f, -5.41296452e-02f, -4.05328907e-02f, -4.72398065e-02f, 5.04821278e-02f,
  5.00959195e-02f, 5.33655062e-02f, 7.35728070e-02f, -8.14336545e-06f, 7.48495385e-02f, 1.10462986e-01f, -4.67795283e-02f, 5.31667843e-02f, 7.74835572e-02f, 3.30446102e-02f,
  7.57665858e-02f, -6.79960921e-02f, 1.35603789e-02f, 7.71856355e-03f, -3.34383063e-02f, 1.72316190e-02f, 7.48688653e-02f, 6.10168464e-02f, 4.29958478e-02f, 1.04352862e-01f,
  1.92320663e-02f, 7.50916004e-02f, -1.78993884e-02f, 5.20928577e-02f, 4.46926355e-02f, 5.07111251e-02f, 4.39073369e-02f, -3.05279847e-02f, 1.70773059e-01f, 9.57172588e-02f,
  8.83481055e-02f, 4.51227799e-02f, 2.35478263e-02f, 3.80723774e-02f, 1.10156178e-01f, 1.17601849e-01f, -6.50039921e-03f, 1.10651158e-01f, 8.35973695e-02f, 3.56662162e-02f,
  -5.71699329e-02f, -8.19372535e-02f, -7.84277450e-03f, 2.55815629e-02f, -4.70075086e-02f, -1.28034211e-03f, 2.97210012e-02f, 2.68969070e-02f, -3.30553167e-02f, 4.28118370e-03f,
  3.56897861e-02f, -2.06940062e-02f, -4.32646647e-02f, 8.08696076e-02f, -1.48891155e-02f, -9.31006484e-03f, -3.02285403e-02f, 7.65151009e-02f, -5.15508726e-02f, -5.04141226e-02f,
  -7.60592073e-02f, -3.64429578e-02f, -5.11501767e-02f, 8.31847489e-02f, -5.80451377e-02f, 2.64914408e-02f, 9.22389925e-02f, 1.05983810e-02f, 5.79712875e-02f, -9.25949961e-02f,
  -1.92966953e-01f, -3.88903409e-01f, -7.24705532e-02f, 8.43475312e-02f, -1.21534906e-01f, -4.20218445e-02f, -3.10766604e-02f, -2.43920367e-02f, -1.39479050e-02f, -5.82316220e-02f,
  1.11380657e-02f, 1.62504297e-02f, -8.61671790e-02f, 5.93487360e-02f, -4.74212095e-02f, -8.66864622e-02f, -6.07510097e-03f, -1.76725775e-01f, -7.10644275e-02f, -6.14742748e-02f,
  1.96467042e-02f, -2.30619293e-02f, 1.57256108e-02f, 5.23450635e-02f, -3.34789194e-02f, 5.68079948e-02f, -3.10593303e-02f, -8.52312706e-03f, -1.21241212e-02f, -1.11860763e-02f,
  1.05280444e-01f, -4.35081959e-01f, -7.37049133e-02f, 1.03320405e-01f, 1.61081493e-01f, 1.39014781e-01f, 2.05204204e-01f, -6.63129985e-02f, 1.52345002e-01f, -1.90276787e-01f,
  4.55748430e-03f, -6.38083071e-02f, -7.20904469e-02f, 7.45371655e-02f, 3.16726357e-01f, 5.80463484e-02f, 5.71516789e-02f, -4.50507440e-02f, -2.56891623e-02f, 2.55511440e-02f,
  -1.21131307e-02f, 1.76500484e-01f, -5.18455766e-02f, -1.51143149e-01f, -7.70752430e-02f, -1.53315961e-01f, -3.99748273e-02f, -1.36696085e-01f, -1.06627136e-01f, -1.98079143e-02f,
  -1.21628761e-01f, 7.36255571e-02f, 2.37197075e-02f, -5.55334315e-02f, -7.74234608e-02f, -4.75729778e-02f, 2.11055540e-02f, -8.47874768e-03f, -1.30616138e-02f, 6.76687434e-02f,
  -4.73290421e-02f, -7.47074485e-02f, -1.34129534e-02f, 1.82981882e-02f, -1.93484444e-02f, -5.03307767e-02f, 6.87385201e-02f, -1.34896887e-02f, 3.07526197e-02f, -7.62365852e-03f,
  -2.80030258e-02f, -9.40128192e-02f, -5.97194433e-02f, -6.07282631e-02f, -8.72196332e-02f, 1.56300634e-01f, 2.33956575e-02f, -1.00287944e-01f, -7.84459338e-02f, -4.71009043e-05f,
  5.20711914e-02f, -5.84661029e-02f, -1.42226508e-02f, -6.09135367e-02f, -2.29688850e-03f, 1.68915093e-02f, 2.93719284e-02f, 2.34407373e-02f, -9.51754749e-02f, 1.78983025e-02f,
  -3.49126346e-02f, -1.32501349e-01f, 1.40184518e-02f, -1.52865564e-02f, 7.08081201e-02f, 9.86374989e-02f, -5.00043817e-02f, -9.39553883e-03f, -1.36935443e-01f, -4.51459475e-02f,
  2.50529721e-02f, 6.56020492e-02f, -6.72101453e-02f, -8.38180073e-03f, -2.33407058e-02f, -5.29797096e-03f, -5.08265793e-02f, -3.58058065e-02f, 3.09482440e-02f, 6.46335408e-02f,
  -2.10733756e-01f, -6.54806271e-02f, -2.59365775e-02f, -5.38505651e-02f, -7.13845249e-03f, 3.70357372e-02f, 1.11363558e-02f, 5.22894692e-03f, -8.63780901e-02f, 5.22473827e-03f,
  -7.93604851e-02f, 2.29293816e-02f, -2.04905644e-02f, -4.04882524e-03f, -6.01570569e-02f, 4.92241643e-02f, -1.40556600e-02f, -8.97445828e-02f, -1.62066016e-02f, -1.67511981e-02f,
  -7.73131028e-02f, 8.57984573e-02f, -8.23788941e-02f, -2.15519704e-02f, -7.06360734e-04f, 5.07386625e-02f, 3.74801047e-02f, -2.77448092e-02f, 3.93333323e-02f, -2.10942943e-02f,
  -1.60995930e-01f, -5.16141355e-02f, 6.81901798e-02f, -1.91484585e-01f, -7.38165751e-02f, -1.08604439e-01f, 7.49224946e-02f, -1.23016290e-01f, -5.53685129e-02f, -2.69828830e-02f,
  -1.57626629e-01f, 9.14925616e-03f, 6.02357984e-02f, -3.34508002e-01f, -1.79985017e-01f, -4.54671867e-02f, -2.10815519e-01f, -4.27269004e-02f, -9.99557450e-02f, -2.95787901e-02f,
  -1.19759105e-01f, -1.52439848e-01f, -4.64396589e-02f, -1.67474933e-02f, -9.93155763e-02f, -7.64944358e-03f, -5.11332881e-03f, 4.35880721e-02f, -1.30685359e-01f, 6.23680800e-02f,
  -2.29412108e-03f, 1.08001985e-01f, 9.03173760e-02f, 1.01227565e-02f, -7.93117657e-02f, 9.58236381e-02f, 1.10853694e-01f, 2.69803982e-02f, 1.09553477e-02f, -3.59932594e-02f,
  3.62752937e-02f, 1.11241434e-02f, -1.05197392e-01f, 2.30654161e-02f, -5.55626713e-02f, 6.26635328e-02f, 6.46317154e-02f, -2.62515130e-03f, 3.42592821e-02f, 3.02692801e-02f,
  -3.93600203e-03f, -1.81327593e-02f, 5.11578135e-02f, -3.89154218e-02f, 4.82394267e-03f, 2.16567814e-02f, 9.31962505e-02f, 7.99317509e-02f, -1.75815672e-02f, -2.33585574e-02f,
  -5.51634841e-02f, -4.58188215e-03f, 5.75136673e-03f, 3.31917964e-02f, -7.24089099e-03f, -5.50929457e-02f, 1.31897992e-04f, -7.22629577e-02f, 6.18308969e-02f, 1.09135341e-02f,
  -6.02080561e-02f, -5.53513505e-02f, -3.43847349e-02f, 4.24551405e-02f, -9.72329732e-03f, 3.99821326e-02f, 1.56113170e-02f, -8.05446729e-02f, -1.26683116e-02f, 4.54528742e-02f,
  4.83401958e-03f, 3.95776733e-04f, 3.97928692e-02f, 4.19492787e-03f, -3.20011214e-03f, 8.37155208e-02f, -6.54854625e-02f, 7.28638992e-02f, 3.47291119e-02f, 1.17688216e-02f,
  -7.02424943e-02f, -8.43893066e-02f, 2.53973845e-02f, 2.46471260e-02f, 8.52835272e-03f, 1.45295653e-02f, -1.59826828e-03f, -6.10482134e-02f, -3.45127210e-02f, 7.71659166e-02f,
  6.38999641e-02f, 1.59918852e-02f, -6.36320636e-02f, 9.30012111e-03f, -3.33924294e-02f, -2.78176628e-02f, -1.09406142e-02f, 6.61793770e-03f, 5.88218449e-03f, -6.64811358e-02f,
  5.45789525e-02f, -5.67576624e-02f, 5.84502555e-02f, -2.05326192e-02f, -1.26233712e-01f, 1.43611971e-02f, 1.20478354e-01f, 7.66557381e-02f, -8.81570280e-02f, 3.88857946e-02f,
  3.38562310e-01f, -1.86962217e-01f, 1.81925461e-01f, 1.54103888e-02f, 4.33351509e-02f, 5.91671541e-02f, 2.19647706e-01f, -1.19284298e-02f, -1.12891162e-03f, -1.89372823e-01f,
  4.69003245e-02f, 1.45408124e-01f, -1.43440515e-02f, -6.64827898e-02f, 2.06513271e-01f, -8.83705616e-02f, -4.43896763e-02f, -6.16250448e-02f, -2.67660692e-02f, -4.27270606e-02f,
  3.06186434e-02f, -2.35246457e-02f, 1.14748515e-01f, -2.06191197e-01f, -1.32108992e-02f, -4.36170250e-02f, -2.07729787e-02f, -5.29567711e-02f, 6.89989282e-03f, 8.27345178e-02f,
  7.45258182e-02f, -8.76068976e-03f, 1.06163576e-01f, -3.81883676e-03f, 1.55338332e-01f, 6.14855774e-02f, 9.94120166e-02f, 8.03788938e-03f, 5.32218590e-02f, 3.17290947e-02f,
  7.70260999e-03f, 1.55313369e-02f, -5.96588105e-03f, -2.11950578e-03f, -8.70730802e-02f, -6.22253194e-02f, -6.52549490e-02f, -1.41747547e-02f, 3.42803821e-02f, -6.54652864e-02f,
  -5.88821508e-02f, 1.27960928e-02f, -1.24594674e-01f, -7.52405822e-02f, -2.37048138e-02f, 6.49170652e-02f, 7.42093893e-03f, 4.09720512e-03f, 2.15051565e-02f, 1.45166097e-02f,
  -6.55607507e-02f, -5.48229739e-02f, -6.70229420e-02f, -9.67977345e-02f, -3.57700102e-02f, -4.36958112e-02f, -2.91892588e-02f, 1.20972621e-03f, -5.85355796e-02f, -9.50570628e-02f,
  -4.49940637e-02f, 5.01656458e-02f, 1.37541965e-02f, 6.20797761e-02f, -6.79283887e-02f, 4.18950506e-02f, 1.65116489e-02f, -6.43621311e-02f, 4.22610864e-02f, -5.20954542e-02f,
  -3.41696553e-02f, -3.68733667e-02f, -5.65718859e-02f, 6.58668205e-02f, -1.38287637e-02f, 7.91228712e-02f, 4.78461385e-02f, -8.11194256e-02f, 7.00521022e-02f, 8.89765099e-02f,
  1.89856421e-02f, 3.63986543e-03f, 3.21069099e-02f, -6.53254939e-03f, 5.72425425e-02f, 4.22691442e-02f, 1.03002235e-01f, 1.88325997e-02f, 2.95122527e-02f, 1.12229235e-01f,
  2.55391952e-02f, -2.46429071e-03f, 1.19967207e-01f, 6.25093505e-02f, -1.12435095e-01f, -8.91517997e-02f, 4.78707291e-02f, 2.32979842e-02f, 8.65701288e-02f, -9.05911103e-02f,
  2.88799349e-02f, -1.31304767e-02f, -6.57473728e-02f, -1.31882597e-02f, 1.38395056e-02f, -4.30786945e-02f, 3.17160822e-02f, -5.55506088e-02f, -2.60892026e-02f, 6.87845722e-02f,
  -2.33676553e-01f, 2.83070356e-02f, 1.88111380e-01f, -6.70764521e-02f, -1.64849818e-01f, 8.56632963e-02f, 1.29458904e-01f, -2.77425319e-01f, -1.22496873e-01f, -5.81160933e-03f,
  -7.73854032e-02f, 1.88234553e-01f, 2.91176923e-02f, -4.12853174e-02f, 8.16292018e-02f, 7.92956725e-02f, -6.78023770e-02f, -3.43632814e-03f, -1.33517444e-01f, -1.48997426e-01f,
  -1.08522885e-01f, -9.51416865e-02f, 7.27417395e-02f, -7.67208412e-02f, 3.54436808e-03f, -1.22889161e-01f, 2.99606621e-02f, 2.26069465e-02f, -1.26837213e-02f, 1.32510066e-01f,
  -3.26897912e-02f, -6.19237237e-02f, -5.08687273e-02f, -5.19221202e-02f, 1.01536335e-02f, 9.53047127e-02f, 9.53249559e-02f, 1.37171894e-01f, 1.70665123e-02f, -3.60699147e-02f,
  1.01161219e-01f, -3.53505015e-02f, 9.10610519e-03f, -1.13908062e-02f, -1.77745782e-02f, 2.00572386e-02f, 2.06813868e-02f, 1.21859163e-02f, -5.41782565e-02f, -7.46677537e-03f,
  2.63765231e-02f, 7.20119029e-02f, 7.52106011e-02f, -1.49068679e-03f, -8.94896407e-03f, -4.85895351e-02f, 3.63234803e-02f, 6.49529770e-02f, 2.13477015e-02f, 7.69965630e-03f,
  -4.54222076e-02f, 6.36015162e-02f, 6.38867775e-03f, -7.68804597e-03f, 6.26914129e-02f, 4.25652452e-02f, 4.46469970e-02f, 4.74568270e-02f, 6.72783256e-02f, 4.34341654e-03f,
  -2.13585384e-02f, -2.14312039e-02f, -6.28060102e-02f, 1.92903168e-02f, 9.53585934e-03f, -8.74794573e-02f, 4.83596586e-02f, 1.75728872e-02f, 1.38651906e-02f, -4.32607159e-02f,
  4.38818559e-02f, 1.72648183e-03f, 1.24071799e-01f, -3.34540233e-02f, -3.71859074e-02f, 1.14743978e-01f, 8.89760777e-02f, 3.05447332e-03f, -6.51723370e-02f, -6.38003228e-03f,
  -1.81047276e-01f, -2.08041400e-01f, -4.36797030e-02f, -1.70874968e-03f, -6.80431724e-02f, -2.83959527e-02f, -6.60161078e-02f, -4.03527319e-02f, 3.81202362e-02f, 4.06356119e-02f,
  7.71838287e-03f, 4.81348205e-03f, -1.70235254e-03f, 5.02565987e-02f, -1.32430810e-02f, -5.68474345e-02f, -1.41203636e-02f, 2.26009879e-02f, -1.21700957e-01f, -2.71592499e-03f,
  -1.53528294e-02f, -8.80392492e-02f, 1.34066362e-02f, -3.88267301e-02f, -2.27994751e-02f, 4.11007479e-02f, -8.69485587e-02f, -3.67611349e-02f, 7.42121413e-02f, 1.67482588e-02f,
  8.44000280e-02f, 3.17757651e-02f, 1.92833185e-01f, 1.62439644e-02f, -5.34231961e-03f, -3.62216793e-02f, 3.08538729e-04f, 2.51386911e-01f, 4.50511664e-01f, 9.52748060e-02f,
  -2.06138730e-01f, -3.22586522e-02f, -3.22023146e-02f, -1.16029598e-01f, -2.79837489e-01f, -1.57299429e-01f, -1.13528129e-02f, -5.99653721e-02f, 1.05129465e-01f, 1.70548245e-01f,
  2.26065926e-02f, -2.38865137e-01f, -3.86033028e-01f, -1.13041349e-01f, -8.17771330e-02f, 1.36375383e-01f, -1.05476305e-01f, 1.39918346e-02f, -8.66190717e-02f, -7.09215254e-02f,
  -4.47703749e-02f, 6.72136694e-02f, -1.30089894e-01f, 2.45990492e-02f, -3.96786034e-02f, -4.59938571e-02f, -2.78208461e-02f, -7.65528083e-02f, -2.12081224e-02f, 8.80542323e-02f,
  5.20074479e-02f, -6.09134659e-02f, -1.69489104e-02f, 4.75319996e-02f, 1.13821484e-01f, -2.02108193e-02f, -4.15618755e-02f, -1.12024546e-02f, 2.99700741e-02f, 3.91361974e-02f,
  -5.51867597e-02f, -2.59843208e-02f, 1.04319766e-01f, 1.61120847e-01f, -3.05724200e-02f, 1.94104910e-02f, -9.07221530e-03f, 2.69517358e-02f, -1.18089803e-01f, -5.05138226e-02f,
  4.45611887e-02f, 1.04546361e-02f, 4.47326340e-02f, -3.18822339e-02f, 1.60448514e-02f, 2.19320506e-02f, -4.49820124e-02f, -5.05223610e-02f, -1.69013161e-02f, 1.84260607e-02f,
  -3.25597674e-02f, -7.32121617e-02f, 1.04591615e-01f, -4.58356105e-02f, 7.75273442e-02f, 1.80437719e-03f, 2.96073202e-02f, 4.83262725e-02f, -5.61362617e-02f, -1.62878469e-01f,
  -1.13306502e-02f, 4.04077433e-02f, -7.50112161e-02f, -1.29403761e-02f, 8.44244063e-02f, 6.07423931e-02f, -5.63073941e-02f, 5.83057813e-02f, -7.22412169e-02f, 1.86579674e-02f,
  2.67072525e-02f, 2.68773794e-01f, -2.42450666e-02f, -8.80207941e-02f, 1.40957162e-02f, -6.31567463e-02f, 6.63952017e-03f, 9.95297506e-02f, 6.99239895e-02f, -2.80241650e-02f,
  2.38146614e-02f, 8.17113032e-05f, 3.02790515e-02f, 3.51673029e-02f, -2.97055934e-02f, -9.06650499e-02f, 6.56980425e-02f, 6.78600669e-02f, -6.85969740e-02f, 4.93290462e-02f,
  -9.39489082e-02f, -5.32571711e-02f, 8.50950852e-02f, -1.20607734e-01f, -9.91168767e-02f, 1.63650796e-01f, -1.52165936e-02f, -7.81158358e-03f, -2.78271865e-02f, -2.13038903e-02f,
  1.91101745e-01f, -1.63640901e-02f, -1.42555296e-01f, 1.49477452e-01f, -7.98046589e-02f, 6.31184876e-02f, -4.45402972e-02f, 3.54957581e-02f, 3.49945396e-01f, 1.69794232e-01f,
  -2.86600785e-03f, 3.11014168e-02f, -5.38731627e-02f, 3.12283665e-01f, 2.17590526e-01f, 3.58539075e-01f, 2.10316911e-01f, 4.00119573e-02f, 1.80103883e-01f, -7.01825917e-02f,
  7.81424493e-02f, 1.88027605e-01f, -8.13647509e-02f, -4.62703817e-02f, 1.49986073e-02f, -1.12538680e-01f, 3.29323150e-02f, -1.17002025e-01f, -8.65349546e-02f, -1.95613224e-02f,
  4.60282192e-02f, 1.24278307e-01f, -6.48278967e-02f, -4.79579670e-03f, -5.66088036e-02f, -1.09926119e-01f, -1.30036697e-01f, -4.93125543e-02f, -5.82689494e-02f, 9.72689420e-04f,
  -7.22266361e-03f, 1.29256710e-01f, 9.87857208e-02f, 2.74079945e-02f, 6.95899501e-02f, -1.12663381e-01f, -6.37701079e-02f, -7.41932765e-02f, -2.42422372e-02f, -1.69406682e-02f,
  -9.45892930e-02f, 1.32602826e-02f, 5.54241836e-02f, 3.28575112e-02f, -2.17234269e-02f, 3.78182866e-02f, 8.33235681e-02f, -4.99158502e-02f, 8.59925896e-02f, 1.19575359e-01f,
  -6.43025106e-03f, 2.59785373e-02f, -3.30284387e-02f, 2.35216599e-02f, 1.59050487e-02f, -3.91752124e-02f, 2.92863976e-02f, -3.12649459e-03f, -4.89556603e-02f, -6.60414249e-02f,
  -4.38056216e-02f, -1.04679763e-01f, 4.46322337e-02f, -7.70327002e-02f, -2.99459007e-02f, 6.89673424e-02f, -1.12611771e-01f, -2.64662672e-02f, 5.04535586e-02f, -6.85033156e-03f,
  -9.98308733e-02f, 1.04080131e-02f, 5.78595214e-02f, -4.62310351e-02f, 2.83075795e-02f, -7.92024955e-02f, 3.59655097e-02f, 3.54463123e-02f, -3.93467620e-02f, 1.54509833e-02f,
  3.93491052e-02f, 1.01194218e-01f, -1.08503010e-02f, -1.04515925e-02f, 3.38343792e-02f, -3.47157381e-02f, 2.87862401e-02f, 3.95338424e-02f, 4.97049801e-02f, -3.97189371e-02f,
  -8.67696628e-02f, 5.91259822e-02f, 8.92646536e-02f, 2.35774741e-02f, 4.83957902e-02f, 5.37161604e-02f, 5.14209904e-02f, 4.39545996e-02f, 8.51134807e-02f, 4.37857024e-02f,
  -1.28152564e-01f, 2.95344163e-02f, -2.50350032e-02f, -3.71140204e-02f, -3.63676958e-02f, 4.04563360e-02f, 5.72341420e-02f, -4.58165146e-02f, 5.29851438e-03f, 1.67535260e-01f
};

// L0_fan_Wp_bar (Shape: 26 x 120)
const int L0_fan_Wp_bar_rows = 26;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -1.73847809e-01f, 1.75002173e-01f, -2.02799410e-01f, 9.37874764e-02f, 8.78951922e-02f, 1.38006315e-01f, 9.95746702e-02f, -2.61807378e-04f, -6.28898144e-02f, 2.16833383e-01f,
  1.37078092e-01f, 1.01359606e-01f, -4.48823683e-02f, 2.07998574e-01f, 3.81385535e-02f, 7.70785809e-02f, 1.96667641e-01f, 6.61774650e-02f, -2.96911672e-02f, 1.06266975e-01f,
  -1.96304526e-02f, 2.66460240e-01f, -9.72705111e-02f, 2.88586710e-02f, 1.62080690e-01f, -1.63708925e-01f, 1.76932439e-01f, -7.04364330e-02f, 5.61275929e-02f, 8.77932608e-02f,
  -1.27944453e-02f, 3.92453074e-02f, -3.85959409e-02f, -9.27999467e-02f, 1.20499969e-01f, 1.19539341e-02f, 5.06368168e-02f, -4.14110497e-02f, -1.25197276e-01f, 1.15621552e-01f,
  4.91079465e-02f, -6.93118498e-02f, 6.86177984e-03f, 3.93367596e-02f, -3.13037932e-02f, -1.14250056e-01f, -2.63025239e-02f, -1.03242788e-02f, -1.00123264e-01f, -3.86016481e-02f,
  3.10088992e-02f, 8.23960733e-03f, 6.26736414e-03f, 1.25571634e-04f, -2.88527869e-02f, 1.82007421e-02f, -2.84301508e-02f, 1.21328412e-02f, 1.56730443e-01f, 7.53735825e-02f,
  9.91680771e-02f, 6.00886680e-02f, 8.51883665e-02f, 6.23276457e-02f, 4.66044247e-03f, -4.97105271e-02f, -1.08106844e-02f, -1.20408773e-01f, -4.17929552e-02f, -1.54312644e-02f,
  -1.49129536e-02f, -5.51479049e-02f, 4.46588695e-02f, 4.98784222e-02f, 3.23380693e-03f, 9.15977508e-02f, -1.40494242e-01f, -7.52018718e-03f, -1.75219309e-02f, -7.14260563e-02f,
  -2.04223003e-02f, -4.88560610e-02f, 6.62629381e-02f, -2.44052839e-02f, -2.38857046e-03f, -5.79369441e-02f, 3.19770575e-02f, 3.36658731e-02f, 3.99608444e-03f, 2.03914717e-02f,
  2.00014383e-01f, 1.56125948e-01f, -4.28721728e-03f, 7.98083395e-02f, -1.56657689e-03f, 1.51205093e-01f, 8.70081037e-02f, 8.75915587e-02f, -3.22658643e-02f, 3.58812697e-02f,
  1.92280747e-02f, -2.04415452e-02f, 1.88787207e-02f, 1.32640237e-02f, -3.12190223e-02f, 1.89606056e-01f, 2.80697388e-03f, -8.95624161e-02f, 4.46707272e-04f, 8.37013274e-02f,
  3.05515211e-02f, 7.24600852e-02f, -9.98848602e-02f, -7.28238896e-02f, 2.32764240e-02f, 7.95012489e-02f, -3.66238542e-02f, 1.16250552e-01f, 9.40715894e-02f, 2.15548761e-02f,
  -1.96809784e-01f, 1.02045983e-01f, 5.44406064e-02f, -8.29851534e-03f, -1.43090218e-01f, -9.47806835e-02f, -1.97151564e-02f, -5.64478859e-02f, 1.14672028e-01f, 1.03991061e-01f,
  8.48410069e-04f, -9.25978571e-02f, 8.33543316e-02f, 4.11531366e-02f, -6.11296929e-02f, 1.03490613e-01f, -2.08417550e-02f, -1.11771664e-02f, -4.46642488e-02f, -6.22207150e-02f,
  -5.68140522e-02f, -9.88886580e-02f, -1.01663634e-01f, -6.58753216e-02f, -1.22636251e-01f, -4.29543890e-02f, 7.93709010e-02f, -7.97997266e-02f, -5.49633801e-02f, 1.72373913e-02f,
  1.89826507e-02f, 1.52584717e-01f, -4.69290987e-02f, 4.04753350e-02f, -3.53491446e-03f, -7.97757432e-02f, 4.16879952e-02f, -3.58530022e-02f, -3.50187719e-02f, 8.92589539e-02f,
  -1.54214324e-02f, 5.73657826e-02f, 8.36121216e-02f, -2.09656879e-02f, -6.22179098e-02f, -3.03180087e-02f, 4.86450717e-02f, 6.75940420e-04f, -1.61198407e-01f, -1.24713510e-01f,
  6.17933911e-05f, -1.62495486e-02f, -1.41677372e-02f, 9.73084792e-02f, -4.24562395e-02f, -5.69628598e-03f, 2.87054665e-02f, -6.58436343e-02f, 5.49375825e-03f, 2.37028748e-02f,
  2.20252834e-02f, -7.89799318e-02f, 4.67572585e-02f, -4.43408005e-02f, 1.16694845e-01f, 2.85241706e-03f, -6.87606111e-02f, -1.01374695e-02f, 6.40131682e-02f, 3.21464948e-02f,
  6.65638447e-02f, 2.84180753e-02f, -3.28004807e-02f, -7.12616146e-02f, 2.82274093e-02f, 1.25414491e-01f, -7.81676173e-02f, -4.91312593e-02f, -3.55991423e-02f, -2.73300298e-02f,
  -2.45360099e-02f, 9.39535946e-02f, 9.91946682e-02f, -3.88630629e-02f, -5.97151481e-02f, 4.30288259e-03f, 1.34586366e-02f, -1.02690849e-02f, 6.37098700e-02f, -2.42663920e-02f,
  -8.32506493e-02f, 7.23106861e-02f, -6.25444502e-02f, 1.38738863e-02f, 2.93992776e-02f, -4.07099351e-02f, -1.27329084e-03f, -8.37700590e-02f, 1.20609753e-01f, 3.73845696e-02f,
  -7.34208198e-03f, 8.24061502e-03f, -2.20054601e-04f, -7.58928061e-02f, -1.02741003e-01f, -7.66067356e-02f, 7.73189813e-02f, 1.68393441e-02f, 3.15388739e-02f, -4.32450585e-02f,
  -9.42533538e-02f, 5.43907769e-02f, 4.37341221e-02f, -9.45330784e-02f, -4.94848080e-02f, 3.19543779e-02f, -6.50483742e-02f, 7.09744915e-02f, 1.16550148e-01f, 5.26277274e-02f,
  -6.71274304e-01f, 1.63560972e-01f, 2.57656634e-01f, -3.05345774e-01f, 1.17864341e-01f, 1.19584188e-01f, -5.02419621e-02f, 1.24986552e-01f, -1.73758548e-02f, 2.15574987e-02f,
  -1.86641258e-03f, 3.61760706e-02f, 1.81784526e-01f, -4.89899740e-02f, -1.22342281e-01f, 2.59177200e-02f, -1.22789130e-01f, -1.47755310e-01f, 8.47376511e-02f, -4.46578860e-02f,
  -6.19561933e-02f, 7.93901756e-02f, -2.40907725e-03f, 3.11054885e-01f, 5.67095615e-02f, 2.02097604e-03f, -3.80373187e-02f, 1.75773099e-01f, 2.46824734e-02f, 1.18073009e-01f,
  -2.10098356e-01f, -1.00565016e-01f, -1.68245062e-01f, -4.71009947e-02f, 3.43885552e-03f, -6.99505359e-02f, -7.61376917e-02f, -4.85552661e-02f, -1.12061001e-01f, -1.88882593e-02f,
  2.27349401e-02f, 9.52819958e-02f, 2.67731538e-03f, 1.30754607e-02f, 2.20689755e-02f, 1.60712767e-02f, 8.35588127e-02f, 2.88305357e-02f, 1.85717884e-02f, 5.33907712e-02f,
  1.32320419e-01f, -1.99912824e-02f, -6.73604235e-02f, -7.08174631e-02f, 6.96545318e-02f, -6.64329827e-02f, -5.85921369e-02f, -1.23904578e-01f, -5.73975593e-02f, -3.71321291e-02f,
  8.44395831e-02f, 5.04122116e-02f, 2.70857681e-02f, 6.87605664e-02f, 7.96663687e-02f, 1.25580300e-02f, -5.59209734e-02f, -2.01204326e-02f, 8.72944202e-03f, 7.03618377e-02f,
  -5.44606633e-02f, -8.27420577e-02f, -3.64399105e-02f, -1.14395499e-01f, 3.25347260e-02f, 5.71961887e-02f, 1.62341166e-02f, -6.09805062e-02f, -8.02335155e-04f, -5.26615679e-02f,
  -1.15166390e-02f, -2.72069201e-02f, 4.61419709e-02f, -8.72471184e-02f, 7.98938423e-02f, 4.45970334e-02f, 4.63401824e-02f, 1.48782358e-02f, -4.62273993e-02f, -2.26598307e-02f,
  -4.14441675e-01f, -2.82161385e-01f, -1.66239254e-02f, -1.06832087e-01f, -1.03996158e-01f, -7.20462650e-02f, -5.20138303e-03f, 5.01648113e-02f, -9.54065286e-03f, 5.22721671e-02f,
  8.16586986e-03f, -1.59179568e-02f, 5.14701661e-03f, -1.04307272e-02f, 2.61258334e-02f, -5.86609915e-02f, -4.53324653e-02f, -7.47426823e-02f, -2.33422313e-02f, 4.09084931e-02f,
  2.07854416e-02f, 2.01841816e-02f, -4.42872122e-02f, 1.07363593e-02f, -2.50459053e-02f, -4.86081727e-02f, -5.76026551e-02f, -2.63975598e-02f, 6.04635179e-02f, -8.23670591e-04f,
  1.32870689e-01f, 2.30984896e-01f, 2.71123469e-01f, 1.34310231e-01f, -1.39773518e-01f, -3.90196264e-01f, -2.87399113e-01f, 1.46537885e-01f, 7.34758005e-03f, -1.19458489e-01f,
  -1.37378022e-01f, 2.84566432e-01f, 8.63328874e-02f, 9.34954919e-03f, -7.45415315e-02f, -3.16945054e-02f, 1.38595998e-01f, -3.66777405e-02f, 1.75268546e-01f, 2.17103548e-02f,
  7.41224140e-02f, -1.11090757e-01f, 2.32622072e-01f, -1.15278289e-02f, 2.74621751e-02f, 1.40082300e-01f, 2.16598570e-01f, -1.67737659e-02f, -5.11698909e-02f, -5.79201467e-02f,
  -3.58710848e-02f, 7.71308020e-02f, 1.09497570e-02f, -7.56821558e-02f, -1.53867770e-02f, -8.52142870e-02f, 9.63495374e-02f, -1.14792459e-01f, -3.13315727e-02f, -4.26449813e-02f,
  2.11764816e-02f, 4.64418866e-02f, -3.34364325e-02f, -7.24169537e-02f, -1.06249563e-01f, 2.53699571e-02f, 1.74060270e-01f, 7.37565830e-02f, 1.54638831e-02f, -1.43523922e-03f,
  1.74028471e-01f, -5.07874340e-02f, 2.56534596e-03f, 2.61854287e-02f, 2.34721340e-02f, 4.14327458e-02f, -1.92421861e-02f, -6.21780753e-03f, 8.98133740e-02f, 6.32998869e-02f,
  2.40738913e-02f, -5.31098992e-02f, -4.27150242e-02f, -5.97739890e-02f, -4.25264202e-02f, -9.91570018e-03f, 1.60894133e-02f, 2.51972545e-02f, -5.43828979e-02f, -9.12124589e-02f,
  2.60135741e-03f, -9.38847836e-04f, -1.26342773e-01f, -5.08523956e-02f, 3.09889242e-02f, -7.90189672e-03f, -5.05378880e-02f, -5.07533364e-02f, 2.08290629e-02f, 1.29861429e-01f,
  9.56774354e-02f, -4.24077585e-02f, -9.36815795e-03f, -3.39335836e-02f, -7.72467852e-02f, -3.59658897e-02f, 1.25836045e-01f, -8.30291887e-04f, -2.94812378e-02f, -5.81606291e-02f,
  3.69013436e-02f, 1.59467176e-01f, -2.28757747e-02f, -1.03062294e-01f, -6.57535121e-02f, -7.82952979e-02f, 3.45792249e-02f, 5.39680272e-02f, 1.33587681e-02f, 1.18040536e-02f,
  -2.48130469e-04f, 2.92530097e-03f, -8.72302726e-02f, 7.61932805e-02f, -1.22312531e-02f, -1.04743429e-01f, 4.65393886e-02f, 5.49010374e-02f, -2.52546426e-02f, 4.88398820e-02f,
  1.20497808e-01f, -2.13466510e-02f, -1.35952353e-01f, -1.13512531e-01f, 2.78572179e-02f, 6.30160645e-02f, 8.09445977e-02f, -1.52024357e-02f, 1.39905801e-02f, 7.82735497e-02f,
  -1.07000671e-01f, -2.70195484e-01f, 2.20106900e-01f, -1.33272991e-01f, 2.00624511e-01f, 1.44602209e-01f, 2.87125796e-01f, -4.64167558e-02f, -2.79888988e-01f, -3.27111483e-01f,
  -1.16111256e-01f, -7.23881871e-02f, 7.37353042e-02f, -9.42873508e-02f, 3.11875999e-01f, 1.45535218e-02f, 3.46873328e-02f, -6.05391040e-02f, 6.95771426e-02f, -5.82759976e-02f,
  6.29743487e-02f, -1.59453917e-02f, 2.66782969e-01f, -1.05940804e-01f, -6.68590292e-02f, -9.14485604e-02f, -9.42768529e-03f, 2.11428225e-01f, -1.29264757e-01f, 9.61538926e-02f,
  3.69388685e-02f, -1.41878098e-01f, -3.93598946e-03f, -3.55200246e-02f, -2.24733632e-02f, 1.60880815e-02f, 1.82058699e-02f, 1.42477110e-01f, -3.75280641e-02f, -2.08388716e-02f,
  -1.03872664e-01f, -7.34526850e-03f, 3.24686803e-02f, -1.22515317e-02f, 5.60357198e-02f, -1.49353025e-02f, 4.64872979e-02f, -4.89962213e-02f, -5.61212786e-02f, 4.27695923e-02f,
  -2.70477924e-02f, -2.29506777e-03f, 6.54332116e-02f, -1.39059396e-02f, 5.81252687e-02f, -6.26065359e-02f, 7.24095106e-02f, 8.89204890e-02f, -7.99176376e-03f, 2.68337503e-03f,
  8.58254656e-02f, 3.17885876e-02f, -1.75712276e-02f, 6.88345432e-02f, -3.76343355e-02f, -2.95904465e-02f, -4.40979712e-02f, -4.91447598e-02f, -8.85932520e-03f, -3.37792607e-03f,
  3.35446335e-02f, -1.54157234e-02f, -7.60455010e-03f, -3.07666045e-02f, -9.79214683e-02f, -1.21910259e-01f, -2.00741813e-02f, 1.64297794e-03f, 6.86930418e-02f, 6.07381612e-02f,
  6.40153838e-03f, -2.07476635e-02f, 2.37559434e-02f, 1.22501768e-01f, -1.10416971e-02f, 7.20745027e-02f, -8.58284882e-04f, -7.69074857e-02f, -4.33827117e-02f, 7.06221387e-02f,
  -3.00513566e-01f, -2.74528861e-01f, -2.35780310e-02f, -1.14250630e-01f, -3.75613533e-02f, 3.14329639e-02f, 5.29056564e-02f, -7.24506229e-02f, -3.48544009e-02f, 1.88175272e-02f,
  3.18853594e-02f, -2.37542689e-02f, 9.59220435e-03f, -5.43530732e-02f, -4.25362736e-02f, 2.68438589e-02f, 2.53902730e-02f, 5.32100582e-03f, -7.49191344e-02f, 3.01205199e-02f,
  4.79082763e-02f, -4.37339097e-02f, 3.76414917e-02f, -9.27426890e-02f, -1.90320574e-02f, 8.98104906e-02f, -2.18127365e-03f, -2.55274866e-02f, 2.50042286e-02f, -1.42981894e-02f,
  -2.93880105e-01f, 4.54459153e-02f, -1.91067085e-01f, 1.20154442e-02f, -2.46614605e-01f, -9.25252065e-02f, 8.75963271e-02f, -9.81269926e-02f, -2.06436850e-02f, 2.98338443e-01f,
  3.07022870e-01f, -1.18912227e-01f, 1.71639577e-01f, 3.12765628e-01f, -2.34016463e-01f, 2.19827294e-01f, 8.95343497e-02f, 6.71884492e-02f, -6.23605326e-02f, 1.72065683e-02f,
  -4.11036424e-02f, 2.21184015e-01f, 6.04219884e-02f, 4.75012399e-02f, 5.68774641e-02f, 5.05169630e-02f, 2.21559443e-02f, -9.30558220e-02f, 4.71970141e-02f, -9.48274434e-02f,
  3.75595875e-02f, 6.94863312e-03f, -1.00467399e-01f, -7.43768662e-02f, 4.94862385e-02f, -3.78303975e-02f, 7.38941729e-02f, -2.41487194e-02f, -5.76542318e-03f, -5.94132915e-02f,
  -1.24271326e-02f, -4.65088226e-02f, 3.92824449e-02f, -5.28961001e-03f, -4.54743765e-02f, -6.32081032e-02f, 4.37111370e-02f, 3.00854840e-03f, -6.75377622e-02f, -8.14384595e-03f,
  -3.49148773e-02f, -8.15369412e-02f, 3.10763456e-02f, 3.42231281e-02f, -1.32663220e-01f, 2.81742830e-02f, 2.20755097e-02f, 2.82419901e-02f, -4.56411652e-02f, -3.42702083e-02f,
  -9.96488258e-02f, 1.29034877e-01f, -2.82474458e-02f, -8.51259939e-03f, -7.67821893e-02f, 1.18278032e-04f, 2.74465289e-02f, -5.28697707e-02f, -5.05136810e-02f, 8.71075504e-03f,
  1.40607972e-02f, -5.83101399e-02f, -2.31390018e-02f, 1.23724099e-02f, 3.29732187e-02f, 4.71788011e-02f, 3.72574851e-02f, 2.15619933e-02f, -5.37779778e-02f, 2.29045562e-02f,
  -2.68590148e-03f, -2.69913562e-02f, 2.12330241e-02f, 7.94121847e-02f, -3.82120125e-02f, 9.50398520e-02f, -1.86143145e-02f, 1.89330149e-02f, 1.29849231e-02f, -1.56229530e-02f,
  4.80511524e-02f, -1.06570683e-01f, -3.07890344e-02f, -1.22359460e-02f, -3.93304341e-02f, -4.87567112e-02f, -4.29365933e-02f, -3.06382831e-02f, -3.63832936e-02f, -1.28753737e-01f,
  9.71250329e-03f, -2.89830547e-02f, -6.31753821e-03f, 4.41288948e-02f, -3.99463587e-02f, 2.00433694e-02f, 1.56131592e-02f, -2.53210105e-02f, 4.42604870e-02f, 7.73792341e-03f,
  -2.76741050e-02f, -9.01281387e-02f, 1.47662936e-02f, -3.41832563e-02f, -1.25527820e-02f, 6.81960955e-02f, -1.19652577e-01f, -2.41331998e-02f, -6.17015995e-02f, -3.99347804e-02f,
  -4.58658963e-01f, 9.07540321e-02f, 8.78137872e-02f, -1.91921413e-01f, -8.90018940e-02f, -4.66419049e-02f, -1.63505584e-01f, 3.73603255e-02f, -8.65841061e-02f, -3.26516144e-02f,
  6.33108094e-02f, -1.49595886e-01f, 2.09505513e-01f, -3.94883305e-02f, -7.44370818e-02f, -4.71266359e-02f, 6.26059175e-02f, -6.34334758e-02f, -4.94692810e-02f, -3.20341587e-02f,
  -1.50318697e-01f, -3.28215063e-02f, 6.27777651e-02f, 5.36693074e-02f, -8.44267756e-02f, 4.78431536e-03f, -7.83789009e-02f, -8.33576079e-03f, 1.79715324e-02f, -2.69267894e-02f,
  -1.59900084e-01f, -1.30408809e-01f, 9.23675075e-02f, 1.61595959e-02f, -1.84091385e-02f, 7.35924616e-02f, 2.08778307e-02f, -1.31924162e-02f, -2.81934571e-02f, -1.93433964e-03f,
  -3.71729536e-03f, 1.85555462e-02f, -3.52433361e-02f, 7.26699084e-02f, 4.87063006e-02f, 1.28601611e-01f, -6.50707446e-03f, 3.66645008e-02f, -1.59205962e-02f, 7.87770972e-02f,
  2.89031360e-02f, 9.66886953e-02f, 5.11960611e-02f, -2.85295472e-02f, 8.29771757e-02f, -3.13780420e-02f, -1.21241286e-02f, 6.17855303e-02f, -7.49415308e-02f, -2.78532058e-02f,
  4.22347970e-02f, -7.81041058e-03f, -3.12898941e-02f, 2.85875015e-02f, -1.20173031e-02f, 3.31970630e-03f, -2.85237506e-02f, -8.30419809e-02f, -2.26501878e-02f, 4.43569496e-02f,
  -8.54300857e-02f, 2.59917676e-02f, 5.73418438e-02f, 3.87374312e-02f, -5.31746373e-02f, -5.45134582e-02f, 1.14352055e-01f, 2.95128059e-02f, -7.36035630e-02f, 8.03955365e-03f,
  1.28730431e-01f, 3.51168886e-02f, -3.83663140e-02f, 6.24703914e-02f, 1.14099951e-02f, 5.88566028e-02f, -2.59995763e-03f, 1.86690986e-02f, 5.70315309e-02f, -7.35411644e-02f,
  -2.58489162e-01f, -2.11207733e-01f, 4.07153890e-02f, 7.52221271e-02f, 1.82643756e-02f, -5.83433583e-02f, -1.62550583e-02f, -1.72346141e-02f, -8.35858136e-02f, 1.00788303e-01f,
  -3.30005251e-02f, 8.87090713e-02f, -1.27242774e-01f, -1.12263877e-02f, 1.67210307e-02f, 5.18839397e-02f, -1.57366861e-02f, -6.39456660e-02f, -1.23214470e-02f, 4.78508659e-02f,
  -8.77903178e-02f, -6.72506392e-02f, 7.51447282e-04f, 8.79436806e-02f, 4.49252911e-02f, -9.84595716e-03f, -8.41931030e-02f, 5.64869344e-02f, -3.94718768e-03f, 4.54091094e-02f,
  -5.41536547e-02f, -1.65042445e-01f, -1.51140496e-01f, -9.81769040e-02f, -5.22035584e-02f, -1.72858551e-01f, -2.50630289e-01f, -9.47123840e-02f, 2.12452235e-03f, -1.58233315e-01f,
  -2.37300962e-01f, 1.17295869e-01f, 9.64491516e-02f, -2.30949134e-01f, 1.51531070e-01f, 1.86800823e-01f, -2.19986036e-01f, -1.32774547e-01f, 1.32357880e-01f, -2.36777425e-01f,
  4.19950709e-02f, -1.98703125e-01f, 4.36253175e-02f, -8.86826590e-02f, -3.10990036e-01f, -9.85668134e-03f, 2.79333703e-02f, -1.10925585e-02f, -1.05960876e-01f, -9.24917832e-02f,
  -1.59028061e-02f, -1.33553028e-01f, -1.33170545e-01f, -2.96048429e-02f, 3.74601549e-03f, 5.62462807e-02f, -6.51346967e-02f, 3.92803773e-02f, 6.50673583e-02f, -5.65611608e-02f,
  -2.58451719e-02f, 9.81489494e-02f, -2.75277123e-02f, -8.61528888e-03f, -5.50546274e-02f, -3.18079419e-03f, 9.85949636e-02f, 6.21311441e-02f, -1.92691628e-02f, 4.06138524e-02f,
  -9.86150280e-03f, 3.94707359e-02f, -8.88472795e-02f, 1.76491216e-02f, 9.12191346e-02f, -7.63184503e-02f, 4.51290868e-02f, -3.43616940e-02f, 7.41254762e-02f, -2.21892875e-02f,
  3.91287096e-02f, -4.16613147e-02f, -4.96865809e-02f, -1.02792516e-01f, -5.73291555e-02f, -2.56762002e-02f, -9.93001536e-02f, 6.67545125e-02f, 1.59048811e-02f, -4.59975004e-03f,
  1.24938618e-02f, -9.97383427e-03f, -1.91017725e-02f, -4.62293392e-03f, -1.10428128e-02f, 2.46261004e-02f, -6.90391958e-02f, 1.87997539e-02f, -4.24464382e-02f, -4.98109460e-02f,
  3.26945037e-02f, -9.26128477e-02f, -4.92335074e-02f, 7.77391344e-02f, -8.52644518e-02f, 1.31877109e-01f, -6.29262403e-02f, -1.59662112e-03f, -9.61505622e-02f, -1.81985330e-02f,
  -2.15965658e-02f, -7.54102021e-02f, 3.89941111e-02f, -7.72082359e-02f, 3.04099265e-02f, 9.26095992e-02f, -2.19781715e-02f, -5.41527569e-02f, -4.26628627e-02f, -6.36776462e-02f,
  -1.77008823e-01f, 1.81319993e-02f, 9.11022648e-02f, 4.99455072e-02f, -7.90641308e-02f, -8.69663060e-02f, 2.47185081e-02f, 7.76218176e-02f, -1.04163559e-02f, -1.01022199e-01f,
  3.90694253e-02f, -7.38974148e-03f, 4.55173366e-02f, -8.72477517e-02f, -2.86382958e-02f, -7.63869584e-02f, -1.79939047e-02f, 6.56970888e-02f, -1.32777859e-02f, 2.49083210e-02f,
  -2.23692700e-01f, -8.83598626e-02f, -2.02945411e-01f, -1.46420762e-01f, 5.69457747e-02f, -1.93827495e-01f, -2.07289904e-01f, -1.69314146e-02f, 1.06426209e-01f, 1.15117922e-01f,
  -3.02330609e-02f, 5.68682738e-02f, 3.43470462e-02f, -2.38188609e-01f, -1.59911245e-01f, -1.00261755e-01f, -1.86227277e-01f, -4.64521572e-02f, 1.37687191e-01f, -1.54008409e-02f,
  5.60300685e-02f, -1.07108802e-01f, -2.22385243e-01f, 3.68005522e-02f, -9.48864594e-02f, 9.57805570e-03f, 1.04521126e-01f, 1.41376212e-01f, -5.45695089e-02f, 6.48758337e-02f,
  -1.93739712e-01f, -8.53319392e-02f, -5.15991747e-02f, 1.88795161e-02f, -6.21084906e-02f, -4.16651182e-02f, 2.39381175e-02f, -2.62143835e-02f, 4.31637801e-02f, -8.46889243e-02f,
  3.79119962e-02f, 7.40340129e-02f, -5.89926820e-03f, 6.58686832e-02f, 1.61771383e-02f, 1.14488348e-01f, -5.47849461e-02f, -7.16587901e-02f, -6.04554713e-02f, -7.88078457e-02f,
  6.90969778e-03f, -4.74930294e-02f, -1.38956800e-01f, -8.79449844e-02f, 6.11683074e-03f, -4.83737960e-02f, 3.17034759e-02f, -1.10271208e-01f, 3.17598321e-02f, 6.70383265e-03f,
  1.79120172e-02f, 3.49771455e-02f, -5.51498085e-02f, 3.89520302e-02f, -8.35041422e-03f, -1.93820801e-02f, -8.26071389e-03f, 4.03435081e-02f, 1.03662454e-01f, 1.56697258e-02f,
  2.10746005e-02f, 8.17088038e-02f, 8.22497997e-03f, -1.87741369e-02f, 2.12060641e-02f, -4.57696021e-02f, -2.44117845e-02f, 2.07682364e-02f, 6.66069835e-02f, -4.89598885e-02f,
  -6.84576621e-03f, 1.89828519e-02f, -1.38460901e-02f, -1.71746910e-02f, -1.01790559e-02f, -1.85861881e-03f, -1.79754421e-02f, 6.80671781e-02f, 1.08070476e-02f, 8.03810824e-03f,
  1.46981021e-02f, 3.46774012e-02f, -3.08943987e-02f, -7.60109648e-02f, 5.16589358e-02f, -1.38445534e-02f, 1.42657068e-02f, -2.09362209e-02f, 5.43748364e-02f, 9.35403481e-02f,
  4.40943576e-02f, -1.88486818e-02f, -6.47446960e-02f, 9.26526487e-02f, -1.73546502e-03f, -3.60946432e-02f, 2.01013335e-03f, 7.49857724e-02f, -3.32051367e-02f, -6.97925165e-02f,
  -6.39672065e-03f, 1.21797860e-01f, -1.12720742e-03f, 3.25744711e-02f, 9.97678787e-02f, -4.81398106e-02f, 2.65014172e-02f, -6.20001107e-02f, 2.30865199e-02f, 4.99044098e-02f,
  -2.23834023e-01f, 2.13780016e-01f, 2.46488139e-01f, -1.17420897e-01f, -2.14958474e-01f, 1.72149822e-01f, 1.64999157e-01f, 3.04417182e-02f, 1.15885928e-01f, 1.37919158e-01f,
  -1.65040120e-02f, 4.68262359e-02f, 3.34128179e-02f, -2.78360732e-02f, -4.39831428e-02f, -1.90187413e-02f, -2.87283715e-02f, 2.95277070e-02f, 5.07086962e-02f, -2.26434857e-01f,
  -1.41076297e-01f, -8.30396637e-02f, 1.29351765e-01f, -1.26265958e-01f, -7.94582888e-02f, 2.81720348e-02f, -1.13724791e-01f, -7.59699643e-02f, -8.33236650e-02f, 8.87031257e-02f,
  6.08648621e-02f, 1.27204776e-01f, 1.06210105e-01f, 1.33529693e-01f, 5.19053340e-02f, -4.57112901e-02f, 7.49977008e-02f, 5.49847409e-02f, -7.75863091e-03f, -4.10187691e-02f,
  -5.54521428e-03f, -5.52566499e-02f, 4.70163934e-02f, -8.93344477e-05f, 6.51181191e-02f, -8.35149288e-02f, -8.91080722e-02f, 1.23338185e-01f, 3.04164067e-02f, -2.94542611e-02f,
  4.78193536e-02f, 3.51326689e-02f, 4.13461216e-02f, 3.05952113e-02f, 5.54504357e-02f, 1.34923249e-01f, 8.41168314e-02f, -6.76590875e-02f, 4.70859110e-02f, -7.10447552e-04f,
  -2.26214360e-02f, -9.44105312e-02f, 1.88026726e-02f, -8.45668539e-02f, -6.78486330e-03f, 5.46493009e-03f, -9.23152640e-02f, 6.93285912e-02f, -4.53793257e-02f, -1.25984112e-02f,
  5.07694595e-02f, 3.84108834e-02f, 1.13531083e-01f, -7.28968829e-02f, -7.59266317e-02f, -1.55310929e-02f, -1.33079067e-01f, 1.14295855e-01f, 8.87394696e-03f, 4.55724001e-02f,
  -6.71231560e-03f, -1.04449987e-02f, 5.64208925e-02f, 5.06593026e-02f, 1.12222679e-01f, -6.09126650e-02f, -1.19630322e-01f, -1.98474969e-03f, 7.57382736e-02f, -9.06061903e-02f,
  1.19983889e-02f, 2.30967775e-02f, 1.34000435e-01f, 1.36098102e-01f, 3.04513369e-02f, 7.68698612e-03f, 5.25917150e-02f, -9.53204110e-02f, -2.50962703e-03f, -1.54899433e-02f,
  -5.30110672e-02f, 3.93844359e-02f, -4.99046408e-02f, -2.71536577e-02f, 1.97808146e-02f, 1.19115196e-01f, 1.10251158e-02f, -8.59765522e-03f, 1.85840353e-02f, 5.88150993e-02f,
  -4.49256748e-02f, 6.83431625e-02f, -8.23906958e-02f, 7.03173131e-02f, -1.11010987e-02f, 3.12846005e-02f, 8.83370191e-02f, 5.36891185e-02f, -9.82624814e-02f, 7.74152763e-03f,
  -3.40595283e-02f, -1.45163789e-01f, -2.39752874e-01f, -2.57471502e-01f, 4.88743931e-02f, -2.27920651e-01f, -1.39383167e-01f, -7.49817565e-02f, 2.32383087e-02f, 2.44094014e-01f,
  4.85377610e-02f, -2.94017456e-02f, 7.80243203e-02f, -3.65228504e-01f, -2.74489105e-01f, -1.38318226e-01f, -3.14975798e-01f, -1.14007816e-01f, -3.50334831e-02f, -8.62659961e-02f,
  -1.67689100e-01f, -1.25791848e-01f, -2.86187559e-01f, 3.40961069e-02f, -2.24997118e-01f, 1.82898659e-02f, 6.59173355e-02f, 5.50308377e-02f, -3.26372534e-02f, -1.40377437e-03f,
  -8.46103206e-02f, 7.62504861e-02f, 3.23847979e-02f, 1.17442105e-02f, 5.23515604e-03f, 3.06309983e-02f, -1.16367370e-01f, -5.25010191e-02f, -3.01830447e-03f, 3.51574384e-02f,
  4.03014980e-02f, -5.72600327e-02f, 6.22698218e-02f, -5.78017011e-02f, -3.50454226e-02f, 1.86971892e-02f, 2.70715132e-02f, 1.30880056e-02f, 2.45706365e-02f, -2.98253819e-02f,
  -3.97453457e-02f, -9.44228098e-03f, -1.20116077e-01f, 3.05021163e-02f, -5.03445230e-02f, 2.85195690e-02f, -3.69973108e-02f, 4.90575889e-03f, 6.81088353e-03f, -1.48841990e-02f,
  1.50956690e-01f, -7.73980990e-02f, -7.65927508e-02f, 9.61034931e-03f, -5.09056263e-03f, 3.60593311e-02f, 2.92885602e-02f, -1.63155608e-03f, 1.04691843e-02f, -2.51735616e-02f,
  6.45620450e-02f, -4.95620025e-03f, 1.98944844e-02f, -6.13658130e-02f, 1.67992916e-02f, -6.41225278e-02f, 2.67050657e-02f, 4.36055213e-02f, -2.75255032e-02f, -5.81862777e-02f,
  -2.66109593e-02f, -1.95242371e-02f, 4.60820869e-02f, 4.69213212e-03f, 4.94896062e-02f, 5.50286993e-02f, 7.35190064e-02f, -9.27586555e-02f, -2.60263658e-03f, 6.56833053e-02f,
  3.27050686e-02f, 2.01290250e-01f, 8.05875808e-02f, -2.54681576e-02f, 2.68969219e-03f, -3.86407003e-02f, -1.15062751e-01f, -8.87924805e-02f, -2.29549520e-02f, -4.35386412e-02f,
  -7.07759580e-04f, 6.62982166e-02f, 3.93261435e-03f, 7.49914199e-02f, -2.12013479e-02f, 5.31714335e-02f, 9.04580206e-02f, -6.96275942e-03f, -4.69946377e-02f, 6.77955225e-02f,
  -3.16092074e-02f, 6.57874420e-02f, 1.62796993e-02f, 8.39597639e-03f, 5.74515574e-03f, 7.79809132e-02f, 5.65500930e-02f, 3.36650982e-02f, -8.28009378e-03f, 2.21796539e-02f,
  3.84740561e-01f, 1.04474194e-01f, 2.57849246e-01f, 3.13065171e-01f, 8.71613547e-02f, -4.26974855e-02f, -1.52577963e-02f, 3.09198839e-03f, 3.03229809e-01f, -3.35168354e-02f,
  -1.15671061e-01f, 2.10259721e-01f, -1.49286643e-01f, 1.19233556e-01f, -3.18782479e-01f, -1.78640962e-01f, 5.21655269e-02f, 8.70770812e-02f, 3.32673825e-02f, -1.03812413e-02f,
  1.16495520e-01f, -2.27846473e-01f, -4.61286940e-02f, -1.45535812e-01f, 1.58410802e-01f, 8.68760124e-02f, -2.91489422e-01f, -1.65920004e-01f, -5.14985323e-02f, -1.58079788e-01f,
  5.42873815e-02f, 6.35914411e-03f, -4.55251783e-02f, 1.06590772e-02f, -4.12571989e-03f, 8.18673074e-02f, -5.70854954e-02f, -1.28553376e-01f, 7.57672219e-03f, 2.97987852e-02f,
  1.08430274e-01f, 2.52212733e-02f, -4.88700457e-02f, -8.05803537e-02f, 6.27815127e-02f, 7.69932121e-02f, 6.93497509e-02f, 1.80994794e-01f, 8.90150964e-02f, 7.83194304e-02f,
  1.55121177e-01f, 1.94239810e-01f, -1.25099011e-02f, 1.17699476e-02f, 5.38913570e-02f, 9.97186266e-03f, 1.82677787e-02f, 2.47115511e-02f, -2.27711257e-02f, -4.36931513e-02f,
  -5.23245297e-02f, -4.37203683e-02f, 7.86839426e-03f, 4.22411822e-02f, -4.79627065e-02f, 5.77146634e-02f, -3.15088630e-02f, 3.95343900e-02f, 1.58335138e-02f, 4.14859131e-02f,
  -1.63614340e-02f, 1.57475527e-02f, -2.44405624e-02f, 1.22276291e-01f, 1.00820504e-01f, 9.60904807e-02f, 2.21171658e-02f, -8.94378498e-03f, 9.17769596e-02f, 3.73039469e-02f,
  -1.04123667e-01f, 3.08519769e-02f, -5.24877757e-03f, 3.47090103e-02f, -2.98530757e-02f, 3.25912014e-02f, 3.75183634e-02f, 4.68122810e-02f, -1.20414514e-02f, -8.32392797e-02f,
  -3.17445472e-02f, -1.44176602e-01f, 4.70225997e-02f, -8.01123213e-03f, 8.96241423e-03f, -2.07625963e-02f, 2.19637174e-02f, 9.79995131e-02f, 1.29467221e-02f, -5.48180342e-02f,
  -6.58682957e-02f, 7.87280500e-02f, -2.24737413e-02f, 2.90482100e-02f, -3.29126418e-02f, -1.04923733e-01f, -1.89770926e-02f, -4.32408080e-02f, -7.94849023e-02f, -4.64115059e-03f,
  2.78340559e-03f, -7.25121796e-02f, 7.46158585e-02f, 9.68487859e-02f, 7.29265064e-02f, -5.98657690e-02f, -7.86625370e-02f, 2.97939144e-02f, -7.35358428e-03f, -3.92652303e-02f,
  4.28967059e-01f, -3.38038057e-02f, 1.20091878e-01f, 3.04763287e-01f, 8.69330764e-03f, -5.76327071e-02f, 6.48489520e-02f, 8.06849599e-02f, 1.54122606e-01f, -6.58131167e-02f,
  -1.21126905e-01f, 1.24863617e-01f, -1.44734114e-01f, 1.10215381e-01f, -1.13978684e-01f, -1.95633948e-01f, -2.86894627e-02f, 4.26161382e-03f, 1.72078554e-02f, 3.26951519e-02f,
  2.60471720e-02f, -1.40671328e-01f, -6.89726844e-02f, -1.55046374e-01f, 1.93169668e-01f, 5.57587761e-03f, -2.36026660e-01f, -1.03222348e-01f, -8.55576396e-02f, -2.03291342e-01f,
  8.34991559e-02f, 1.64671689e-02f, 9.56955776e-02f, 1.65709984e-02f, 7.58583322e-02f, 1.17656179e-02f, -6.49009049e-02f, -1.70302466e-01f, 1.97235625e-02f, -5.01199765e-03f,
  -7.00361654e-02f, -3.80812846e-02f, 4.32326086e-02f, 4.24963199e-02f, -7.95225892e-03f, 3.91519256e-02f, 5.21786213e-02f, 6.19843900e-02f, -5.11109903e-02f, 1.92600116e-02f,
  5.18466979e-02f, 3.62010971e-02f, 5.67245930e-02f, -1.17172539e-01f, -2.99433488e-02f, 5.99866435e-02f, -4.85145114e-02f, -4.62299474e-02f, 7.74308220e-02f, 3.85694243e-02f,
  -9.83221643e-03f, -1.25633746e-01f, 1.53908255e-02f, 1.05617978e-01f, 2.75629219e-02f, -1.19550906e-01f, -7.19557181e-02f, -6.95782676e-02f, 1.48752693e-03f, -3.53232324e-02f,
  5.12971804e-02f, -2.09539942e-02f, -1.17570143e-02f, 2.98734158e-02f, -5.28132506e-02f, 4.55832109e-02f, -2.29966547e-02f, -1.28981963e-01f, 1.22523103e-02f, 3.35956216e-02f,
  5.88669553e-02f, -9.24110487e-02f, 1.52999442e-02f, 5.54109626e-02f, -4.04473841e-02f, 2.56066546e-02f, -3.53728384e-02f, 5.73865958e-02f, -3.06112058e-02f, -4.27507795e-02f,
  -7.15848058e-02f, -3.07777047e-01f, -9.27612558e-03f, -4.87241708e-02f, 5.00235660e-03f, 4.67777215e-02f, -1.38698310e-01f, -1.49443373e-02f, 4.85954387e-03f, 5.39053697e-03f,
  -1.66880190e-01f, -4.16299365e-02f, 7.87575990e-02f, -3.01766042e-02f, 3.28543363e-03f, 6.13655038e-02f, -3.84491608e-02f, -6.02568053e-02f, -7.73012042e-02f, -2.09070891e-02f,
  -4.09322493e-02f, -1.41460463e-01f, 2.17858818e-03f, -1.00859813e-02f, -5.84385991e-02f, -5.49352579e-02f, -5.20695746e-03f, -7.18420325e-03f, -8.48414600e-02f, -4.94685546e-02f,
  1.05457090e-01f, -1.90803990e-01f, -3.05474326e-02f, -1.05019689e-01f, 1.48959244e-02f, -8.13298896e-02f, 4.28506993e-02f, -1.96688846e-01f, -2.04585373e-01f, -1.65692568e-01f,
  4.95389402e-02f, 9.53383092e-03f, 2.24373907e-01f, -1.71695933e-01f, 1.76456973e-01f, 9.76441130e-02f, -2.31813401e-01f, 2.04109401e-02f, -6.82389513e-02f, -2.65317298e-02f,
  -4.55054417e-02f, -9.72289816e-02f, 1.59389600e-01f, -2.05904469e-01f, -1.46796703e-01f, -8.60492289e-02f, -1.61189269e-02f, -1.33444602e-02f, -1.93057716e-01f, -4.02261354e-02f,
  1.35570839e-01f, 1.13217212e-01f, -8.17468762e-03f, 5.97761124e-02f, 1.99731626e-03f, 2.68929619e-02f, 4.73302454e-02f, 6.31245747e-02f, -3.01118586e-02f, -3.19470954e-03f,
  -3.01744174e-02f, -7.89318681e-02f, -1.43908886e-02f, -8.24727193e-02f, -1.09792575e-01f, 4.76815626e-02f, -7.66812712e-02f, -3.83250266e-02f, -2.51712772e-04f, 4.68315221e-02f,
  -1.11281043e-02f, 1.00601368e-01f, -1.66190714e-02f, 5.39621105e-03f, -8.21668655e-02f, 2.35233717e-02f, 5.73669150e-02f, 7.62094259e-02f, 1.10950023e-02f, -7.43476823e-02f,
  8.02555531e-02f, 3.50148743e-03f, 5.93914166e-02f, 1.80343799e-02f, 9.08273757e-02f, 3.72125651e-03f, 5.67163937e-02f, 6.64657801e-02f, -9.03610811e-02f, -2.94975862e-02f,
  -6.42484426e-03f, -3.54404724e-03f, 2.15567667e-02f, -5.74522801e-02f, -4.76518124e-02f, 5.18642068e-02f, 9.89234969e-02f, 1.05879933e-01f, -1.11892462e-01f, -1.27052739e-02f,
  3.78052592e-02f, -1.35963997e-02f, -2.11538207e-02f, 5.51703572e-02f, 7.23831654e-02f, -1.94780231e-02f, -3.26394662e-02f, 4.71085049e-02f, 2.28952114e-02f, 6.61103651e-02f,
  -3.79222482e-02f, -9.86342225e-03f, -2.70924754e-02f, 1.41931814e-03f, -2.83345915e-02f, -7.84530193e-02f, -3.53418775e-02f, -4.69096899e-02f, -6.44143373e-02f, 6.32285178e-02f,
  9.43013560e-03f, -1.83224659e-02f, -4.25051451e-02f, -1.30176172e-01f, -1.25042349e-01f, -8.86022002e-02f, 3.35052460e-02f, 2.05580909e-02f, -5.93068972e-02f, 3.53843085e-02f,
  3.47468928e-02f, 7.28872642e-02f, 1.43669434e-02f, -1.91864055e-02f, -6.68500215e-02f, -4.57714051e-02f, 8.66164453e-03f, 8.93881842e-02f, -6.38223067e-02f, -6.91116750e-02f,
  1.51564870e-02f, 4.09016572e-02f, 1.04238905e-01f, 3.47047120e-01f, -3.55625451e-02f, -2.32380420e-01f, -1.86816394e-01f, 1.02797441e-01f, -5.47581771e-03f, -1.20407738e-01f,
  2.30176616e-02f, -5.56384660e-02f, -1.86374504e-02f, 1.66767180e-01f, 2.39269018e-01f, -2.66617835e-02f, 4.09099311e-02f, -1.05991550e-01f, 5.00344150e-02f, 6.90387562e-02f,
  2.58653194e-01f, 1.63674533e-01f, 1.87409416e-01f, 1.34433776e-01f, -4.38095033e-02f, 1.96846962e-01f, 1.29717797e-01f, 5.86899556e-02f, 2.12169439e-01f, -1.40996017e-02f,
  -5.86986318e-02f, 2.63228621e-02f, 3.15817595e-02f, -6.35983273e-02f, -1.97777245e-02f, -8.95912722e-02f, -2.52484176e-02f, 1.70479957e-02f, 1.11772522e-01f, 4.21181507e-02f,
  2.25414755e-03f, 9.79395136e-02f, -7.04618497e-03f, 2.20417175e-02f, -7.50331506e-02f, 4.09437045e-02f, -1.39391627e-02f, 7.38144293e-02f, -3.68404239e-02f, 9.03000757e-02f,
  7.20125064e-02f, -8.48402157e-02f, 5.53739034e-02f, 7.00252205e-02f, 7.05896989e-02f, 1.46856122e-02f, -3.19722705e-02f, 1.84786431e-02f, 1.06410449e-02f, -1.06840357e-02f,
  -1.93140879e-02f, -1.21637695e-02f, -6.77548274e-02f, 3.25789414e-02f, 1.05675451e-01f, 4.92811762e-02f, -8.72617140e-02f, 4.79991101e-02f, 7.23965093e-02f, 3.71329975e-03f,
  5.60711175e-02f, -7.01941550e-03f, -4.12099808e-02f, -4.51121815e-02f, -6.27476303e-03f, -5.87747730e-02f, -8.55971426e-02f, 4.94873859e-02f, -2.42047990e-03f, 9.01577901e-03f,
  1.02928234e-03f, 7.38389194e-02f, -1.84038635e-02f, -1.05748110e-01f, 5.95993325e-02f, -4.99351369e-03f, -8.34452547e-03f, 2.48025712e-02f, -3.94644514e-02f, -1.02727011e-01f,
  -8.07957724e-02f, 1.13853060e-01f, 6.53974339e-02f, -5.73231876e-02f, 9.36061591e-02f, -2.90502273e-02f, -2.57185921e-02f, -5.26238419e-03f, -3.80478166e-02f, 8.45062062e-02f,
  3.67209017e-02f, -7.52794668e-02f, -5.54542616e-02f, 1.97631400e-02f, 1.89684670e-05f, 8.93246662e-03f, 2.70676296e-02f, 1.02942474e-01f, 2.15478595e-02f, 4.70083281e-02f,
  2.24126168e-02f, -1.25193253e-01f, 1.91753749e-02f, -7.59822142e-04f, 3.54890674e-02f, -5.76655306e-02f, -5.52060492e-02f, -5.98306656e-02f, 4.78664860e-02f, 2.84802373e-02f,
  1.43400788e-01f, -4.81518172e-02f, -8.43868703e-02f, -1.81061909e-01f, -7.85718933e-02f, -1.11788593e-01f, -9.35865492e-02f, -1.04218513e-01f, -2.42654413e-01f, -9.58230644e-02f,
  4.62478250e-02f, -9.43503976e-02f, 1.56327963e-01f, -1.06667161e-01f, 7.56872222e-02f, 1.09519370e-01f, -1.07579306e-01f, -1.31160337e-02f, 8.65624174e-02f, 6.36535883e-02f,
  -4.96935695e-02f, -9.87854227e-03f, 8.01881701e-02f, -1.09890271e-02f, -3.96347456e-02f, -6.13688305e-02f, 5.21151125e-02f, 5.24852499e-02f, -1.36756659e-01f, -9.23179537e-02f,
  7.00775012e-02f, 1.93988115e-01f, -7.93499351e-02f, -2.19922997e-02f, -9.65129770e-03f, 5.26467003e-02f, 5.11046760e-02f, 8.10031816e-02f, -3.73256579e-02f, 1.99263748e-02f,
  6.31123781e-02f, 6.01524748e-02f, 3.55690229e-03f, -8.58869702e-02f, -1.61393955e-02f, -2.08063778e-02f, 8.37976933e-02f, -9.35501829e-02f, 5.06535694e-02f, 1.83392167e-01f,
  1.74116604e-02f, 7.30229169e-02f, -9.00915191e-02f, 2.82495040e-02f, -5.16420864e-02f, 3.12516019e-02f, -2.78188102e-02f, 2.22952142e-02f, 3.68396789e-02f, 8.34370479e-02f,
  9.43626687e-02f, 6.03913628e-02f, 6.40387386e-02f, -5.93374893e-02f, -2.86887307e-02f, -4.69219387e-02f, -3.14588286e-02f, 8.87251496e-02f, -1.27956286e-01f, 5.52372001e-02f,
  -2.43285615e-02f, -1.80966835e-02f, 5.08693643e-02f, -6.14357069e-02f, 7.76308076e-03f, -2.49714144e-02f, 4.31700889e-03f, 5.63955903e-02f, -1.44021884e-01f, -6.03463091e-02f,
  4.76703942e-02f, 2.98303906e-02f, -1.90867186e-02f, 6.09142408e-02f, 1.21655747e-01f, -1.20973453e-01f, 7.78579852e-03f, 1.59643199e-02f, -1.11603200e-01f, 4.51029353e-02f,
  6.38125017e-02f, 3.17974798e-02f, -7.56127909e-02f, -4.94754389e-02f, -5.82362711e-03f, 2.28646714e-02f, -6.85314089e-02f, 9.07287560e-03f, -1.54706508e-01f, 3.40966806e-02f,
  8.03730711e-02f, -7.45457560e-02f, 9.04528052e-02f, -7.75363892e-02f, -5.10736667e-02f, -5.15959337e-02f, 9.70851630e-02f, -5.98365031e-02f, -4.61883657e-02f, 5.50727770e-02f,
  -1.95070412e-02f, 3.57278474e-02f, 5.50469793e-02f, -7.79942647e-02f, 2.94997524e-02f, 7.08156079e-03f, -7.90562779e-02f, 7.33751729e-02f, 2.83140931e-02f, 9.88861918e-03f,
  -2.82024980e-01f, 1.22458383e-01f, -1.39651507e-01f, -2.15429917e-01f, 2.97159385e-02f, -1.43792093e-01f, -2.11153567e-01f, -1.09622158e-01f, -1.51655108e-01f, -3.18255350e-02f,
  -4.43497226e-02f, 6.64935559e-02f, 9.33886692e-02f, -5.69567345e-02f, -1.52062908e-01f, 1.36471137e-01f, -2.16565475e-01f, -7.72128031e-02f, 1.02367990e-01f, -1.49086211e-02f,
  -8.60599279e-02f, 6.27230331e-02f, 1.39210224e-01f, 4.46993373e-02f, -4.56172973e-02f, 4.84006070e-02f, -2.39240333e-01f, 2.90679745e-02f, -1.71259463e-01f, -1.11625798e-01f,
  6.56080395e-02f, 1.72175914e-01f, 1.20769806e-01f, -1.05708456e-02f, -1.00754410e-01f, -2.95994692e-02f, -4.81277667e-02f, 6.20639063e-02f, 9.27699078e-03f, -1.21704690e-01f,
  -3.60563621e-02f, -4.17583069e-04f, 1.93568803e-02f, -1.20914532e-02f, -1.04551382e-01f, 3.44593376e-02f, 1.67054962e-02f, 7.74419904e-02f, 1.66366398e-01f, 1.16310213e-02f,
  -8.32243077e-03f, 2.43363231e-02f, -8.11588764e-02f, -1.59332454e-02f, -5.74294701e-02f, -6.49408996e-02f, -4.94030192e-02f, -2.78749522e-02f, -6.44633323e-02f, -2.90315505e-02f,
  -6.73635826e-02f, -2.64740922e-03f, -7.88317621e-03f, 2.76630502e-02f, -7.82025233e-02f, 6.66650832e-02f, -1.54951392e-02f, 9.95974094e-02f, -8.66698995e-02f, 4.37959395e-02f,
  -1.67859178e-02f, -1.95740331e-02f, 3.49014699e-02f, -1.38011664e-01f, -1.54809788e-01f, -6.04819171e-02f, 7.45423362e-02f, 5.50002083e-02f, -6.48792461e-02f, 8.22454393e-02f,
  -4.21965681e-03f, -7.20101744e-02f, -1.00162096e-01f, 2.34491425e-03f, 5.09480983e-02f, 1.57667790e-02f, 1.01622976e-01f, 3.62515487e-02f, -4.37585674e-02f, -3.65366787e-02f,
  -7.03182593e-02f, -1.62567794e-01f, 1.13968156e-01f, -4.07946892e-02f, 6.83536753e-03f, 6.00313488e-03f, -6.52543679e-02f, 2.95868069e-02f, -1.75646156e-01f, -1.28109425e-01f,
  -1.95072591e-01f, -1.02018211e-02f, -4.00998667e-02f, -3.45092360e-03f, -4.71691526e-02f, -1.52673339e-02f, -8.48294720e-02f, -9.61502921e-03f, -1.64943002e-02f, -8.52955952e-02f,
  9.35783163e-02f, 1.20216057e-01f, -7.00414106e-02f, 4.93411720e-02f, -1.06020026e-01f, -2.39539463e-02f, 3.28819677e-02f, 3.85702029e-02f, -1.48638099e-01f, -4.04463895e-02f,
  9.26033407e-02f, -2.17373163e-01f, -4.52393517e-02f, 1.85643435e-01f, -9.50049050e-03f, -9.37857777e-02f, -2.96238542e-01f, 1.04364149e-01f, -1.42503351e-01f, -1.78602058e-03f,
  1.88038737e-01f, -6.46248013e-02f, -1.79142833e-01f, 2.52712339e-01f, 2.64656454e-01f, -7.97159001e-02f, 1.99301437e-01f, 3.84464040e-02f, 6.71256557e-02f, 1.03974856e-01f,
  1.91230759e-01f, 2.31837258e-01f, 2.33103052e-01f, 2.25919813e-01f, 1.50395453e-01f, 1.13914326e-01f, 1.77747503e-01f, -6.15312858e-03f, 2.42669433e-01f, 1.90341324e-01f,
  1.56349852e-03f, 2.76163071e-02f, -5.50255459e-03f, -3.45919020e-02f, -2.94237267e-02f, -7.98719749e-02f, 1.56508591e-02f, -4.87241261e-02f, 5.39161414e-02f, -5.15410081e-02f,
  -8.03298056e-02f, 7.12235272e-02f, -2.02103127e-02f, -5.04919700e-02f, 9.42359045e-02f, -2.03745123e-02f, -1.59966033e-02f, 8.15566070e-03f, -6.95638955e-02f, -2.24398766e-02f,
  -1.87136486e-01f, -5.72817214e-03f, -1.23263439e-02f, 7.61767616e-03f, -2.32072137e-02f, -3.20112929e-02f, -4.80087660e-03f, -7.86938369e-02f, -9.99993980e-02f, 5.98247163e-03f,
  -7.38699362e-02f, -5.52699901e-02f, -2.69651935e-02f, -1.45508386e-02f, -7.37119885e-03f, -4.25284030e-03f, 5.11521026e-02f, 6.23054686e-04f, 6.48778081e-02f, 3.20451930e-02f,
  3.05969846e-02f, 5.78406230e-02f, 9.25240591e-02f, -1.24495681e-02f, -8.80783610e-03f, -4.20759209e-02f, 6.98847324e-02f, 9.63591784e-02f, -1.07898042e-01f, -9.20697302e-03f,
  3.40344049e-02f, 4.15049046e-02f, -4.89394218e-02f, -2.27630045e-02f, 7.17788413e-02f, -2.17063036e-02f, 1.52525797e-01f, 3.08180060e-02f, 2.60564815e-02f, -4.85163294e-02f,
  3.96371528e-04f, -3.92272808e-02f, -5.80922253e-02f, 1.76733416e-02f, -1.94061175e-02f, 3.65751237e-02f, -2.97973081e-02f, 5.59934229e-02f, 3.53010036e-02f, -7.59064257e-02f,
  -1.23162726e-02f, -5.80371246e-02f, 7.03526586e-02f, 4.19488400e-02f, 4.40914296e-02f, 1.05973780e-02f, -4.34098579e-02f, -3.42622846e-02f, -3.75846699e-02f, 4.29164656e-02f,
  4.01761010e-02f, -9.97894406e-02f, 6.18567951e-02f, -6.90774694e-02f, -2.95620458e-03f, -1.01010501e-01f, -4.11226004e-02f, 2.17866413e-02f, -2.24575191e-03f, 6.26266329e-03f,
  2.90973455e-01f, 5.30676544e-02f, 1.78330541e-02f, 1.48046196e-01f, -1.00217231e-01f, -1.34180427e-01f, -1.26557380e-01f, 5.28850257e-02f, -1.00618251e-01f, -8.87565613e-02f,
  1.06157981e-01f, -2.31491446e-01f, 2.96040382e-02f, 3.68055142e-02f, 3.46637145e-02f, -8.72875601e-02f, 3.01492419e-02f, -1.42708257e-01f, -5.18515743e-02f, 5.76598570e-02f,
  1.11868963e-01f, 5.41926175e-02f, 7.16298595e-02f, 1.17321931e-01f, 7.62929618e-02f, 6.23120926e-02f, 1.59241647e-01f, 8.76213089e-02f, 4.97839507e-03f, -1.14409529e-01f,
  4.19970192e-02f, 4.30660583e-02f, -6.98844865e-02f, -6.16472811e-02f, 9.17000398e-02f, 4.71854545e-02f, 2.31277309e-02f, -5.74923493e-02f, -2.82742009e-02f, -7.02646896e-02f,
  -8.87188688e-02f, -1.61286853e-02f, -5.58535755e-02f, 5.03850617e-02f, 1.86117310e-02f, -2.37836526e-03f, -6.22109435e-02f, -1.55483847e-02f, -9.68783163e-03f, 1.31016448e-01f,
  7.69819170e-02f, 6.96681440e-02f, 2.15097629e-02f, 3.37486272e-03f, -3.75514245e-03f, -9.44785848e-02f, 3.30815761e-04f, -8.36628675e-03f, -1.02106063e-03f, -8.89722854e-02f,
  1.23704575e-01f, -2.09936853e-02f, 2.66455906e-03f, -1.07580505e-01f, -1.09817553e-02f, 1.76159758e-02f, -1.69701427e-01f, -9.51232389e-03f, -8.70240629e-02f, 1.00019798e-01f,
  -2.31641307e-02f, 2.74349637e-02f, -5.55298105e-02f, -5.56794368e-02f, -1.03834923e-02f, -2.98847333e-02f, 3.97969149e-02f, 5.51016591e-02f, -7.64889526e-04f, 2.77358200e-03f,
  -2.96968035e-02f, 1.29208237e-01f, 3.44849043e-02f, 1.02095930e-02f, -7.35372975e-02f, 1.08131602e-01f, -2.82349158e-02f, 3.04455347e-02f, -9.72027630e-02f, -5.59714101e-02f,
  6.45735906e-03f, 1.85167789e-01f, -9.77674723e-02f, 4.96412022e-03f, -5.99965006e-02f, 1.33959493e-02f, -4.97564338e-02f, -6.10083118e-02f, 1.58750396e-02f, 2.21256763e-02f,
  -2.31266450e-02f, -6.56667948e-02f, 1.38517283e-03f, 1.02267049e-01f, -5.38785234e-02f, -2.23511104e-02f, -3.45289260e-02f, -5.10453358e-02f, -9.04293358e-02f, 3.25505473e-02f,
  1.32262588e-01f, 6.93272054e-02f, -1.21129096e-01f, -9.59522724e-02f, 1.34829469e-02f, -3.91010046e-02f, -3.72925289e-02f, -8.09067339e-02f, 6.39803782e-02f, -4.42788303e-02f,
  -4.76562291e-01f, 2.58316219e-01f, -2.48120874e-01f, 2.04481632e-01f, -1.37463987e-01f, 3.20545286e-01f, 3.53081524e-01f, 9.75261182e-02f, 5.32072932e-02f, 3.28375906e-01f,
  1.39883131e-01f, -1.17357925e-01f, 6.89595342e-02f, 3.64094049e-01f, -6.40477762e-02f, 1.29574776e-01f, 2.35645816e-01f, 1.37230143e-01f, -6.36274070e-02f, 1.47816852e-01f,
  -1.41330808e-01f, 1.96441993e-01f, -4.27973159e-02f, -2.91457307e-02f, 1.86768994e-02f, -2.24251524e-01f, -6.52580261e-02f, -2.04767719e-01f, 8.01103488e-02f, -3.06441654e-02f,
  5.15923575e-02f, -6.87887296e-02f, -1.92136467e-02f, -4.84418683e-02f, 2.47197021e-02f, -7.81782146e-04f, 3.33492504e-03f, 3.19796167e-02f, -1.32132713e-02f, 9.20906514e-02f,
  -6.91718534e-02f, -1.40085462e-02f, 1.15627870e-01f, -1.04100872e-02f, -7.78638572e-03f, 3.77146862e-02f, 5.15547395e-02f, -7.63033424e-03f, 5.22171222e-02f, -1.04408398e-01f,
  3.93268988e-02f, 3.42067666e-02f, 1.44221401e-02f, 1.53842727e-02f, -1.12037629e-01f, 2.80357935e-02f, 2.60686353e-02f, -1.22423425e-01f, -3.64775280e-03f, 1.31129827e-02f,
  -3.13232914e-02f, -4.49146070e-02f, 1.20734880e-02f, -1.10551693e-01f, -7.74999931e-02f, -2.30812356e-02f, 7.64604285e-02f, -4.93606403e-02f, -3.81752849e-02f, 5.51528074e-02f,
  5.01857251e-02f, 3.98951061e-02f, -6.53300434e-02f, 1.96428914e-02f, -1.89327914e-02f, -1.85963102e-02f, -8.32637176e-02f, 1.81974284e-02f, 4.57573347e-02f, 1.35073308e-02f,
  2.17877757e-02f, -1.20052127e-02f, 6.79286756e-03f, 1.85681935e-02f, 1.65215228e-02f, -6.84568360e-02f, -9.43495426e-03f, -2.01369487e-02f, 1.61361974e-02f, -6.68547228e-02f,
  1.45880580e-01f, 6.71352595e-02f, 9.62896198e-02f, -3.20129804e-02f, -5.45707121e-02f, -1.94697976e-02f, 2.23030075e-02f, -7.78725743e-02f, 2.44511350e-04f, 9.66543704e-02f,
  -2.64073703e-02f, 5.08622453e-02f, -3.91395949e-02f, 3.78583893e-02f, -4.57700267e-02f, 3.49413715e-02f, 4.71716225e-02f, -1.92027073e-02f, 1.15225613e-02f, 1.49759802e-03f,
  1.44650340e-02f, 6.87633529e-02f, -2.41858102e-02f, 4.87184860e-02f, 9.55720916e-02f, 2.86951568e-02f, 6.18143333e-03f, 4.54242863e-02f, -1.40153676e-01f, 3.51673253e-02f,
  2.62419820e-01f, -1.15495674e-01f, -1.85849249e-01f, 1.38308465e-01f, -2.89899595e-02f, -8.02316740e-02f, -1.36448890e-01f, 9.34332758e-02f, -1.37608752e-01f, -2.46039461e-02f,
  -4.05504853e-02f, -1.07232980e-01f, -2.15025693e-01f, 1.00778073e-01f, 2.57668763e-01f, -1.92802146e-01f, 1.26309931e-01f, -2.34520193e-02f, -1.03315987e-01f, -5.94801921e-03f,
  1.24297999e-01f, 2.25890800e-01f, 1.81893826e-01f, 2.95063555e-01f, 1.10254101e-01f, 9.80496630e-02f, 1.92118317e-01f, -1.82703026e-02f, 2.94962108e-01f, 1.94774032e-01f,
  1.11533226e-02f, 2.63268650e-02f, 6.11367486e-02f, -4.90331799e-02f, 8.06103349e-02f, 1.19655602e-01f, -1.71605721e-02f, 2.53728759e-02f, -1.46998987e-02f, -8.93485919e-02f,
  -6.83205649e-02f, 6.00409433e-02f, 2.67292485e-02f, -1.04375305e-02f, 9.62786078e-02f, -2.42138803e-02f, -4.49310392e-02f, -2.44986545e-02f, -6.76022395e-02f, 2.26618256e-02f,
  -3.64243239e-02f, -3.15313623e-03f, -7.88060427e-02f, -2.50123465e-03f, -2.11274512e-02f, 1.86264776e-02f, -3.16833518e-02f, 3.20563056e-02f, 7.38830492e-03f, 4.55385186e-02f,
  -5.91201857e-02f, 2.08355412e-02f, -6.13956386e-03f, 2.54835747e-02f, 9.89802778e-02f, 1.66617204e-02f, -4.66303825e-02f, -2.60449387e-02f, 3.95170785e-02f, 3.58689539e-02f,
  4.16933559e-02f, -2.27674469e-02f, 2.52551157e-02f, -2.11955514e-02f, -2.24313363e-02f, -5.50396368e-02f, -1.57788265e-02f, 5.17420210e-02f, -5.74143454e-02f, -2.14085542e-02f,
  -4.29114588e-02f, 3.86001803e-02f, -1.83080379e-02f, 6.85745627e-02f, 2.22425647e-02f, -2.16653701e-02f, 5.86416647e-02f, 3.63246687e-02f, 2.86865942e-02f, -2.90229041e-02f,
  2.44655702e-02f, 2.13565156e-02f, -4.16439809e-02f, 1.26522155e-02f, -2.64175050e-02f, 5.98434582e-02f, 4.73780930e-02f, 6.38884455e-02f, -5.62781878e-02f, 3.97861525e-02f,
  8.97708386e-02f, -9.60320234e-03f, -6.74207956e-02f, 1.22705042e-01f, 8.82514194e-02f, -2.89599486e-02f, -7.85735622e-02f, 1.21533431e-01f, 1.02687687e-01f, -9.45777632e-03f,
  -5.49562015e-02f, -5.14946282e-02f, 4.07438502e-02f, -1.41593227e-02f, -6.35454506e-02f, -8.52091424e-03f, -2.11733244e-02f, -4.55851294e-02f, 7.40461005e-03f, -1.04172841e-01f,
  -2.23854348e-01f, -8.97496119e-02f, -1.61575064e-01f, -1.35322988e-01f, -1.37320727e-01f, -2.53019273e-01f, -2.10329235e-01f, -1.97785035e-01f, 3.15061258e-03f, 3.92355658e-02f,
  -1.53773218e-01f, -8.87601450e-02f, 1.23571679e-01f, -6.12954572e-02f, -4.60144840e-02f, 2.46503472e-01f, -9.62819755e-02f, 2.29120273e-02f, 1.51359271e-02f, -1.42715663e-01f,
  6.46077888e-03f, -1.60542727e-01f, 1.14382818e-01f, 2.60966760e-03f, -1.37269288e-01f, -8.36514160e-02f, 4.96072285e-02f, -1.12221137e-01f, -6.13710470e-02f, -3.93228941e-02f,
  -2.10071206e-01f, -1.67957947e-01f, -5.35978004e-02f, -3.56240980e-02f, -1.15786903e-01f, -6.93205595e-02f, 1.79824885e-02f, -2.98470799e-02f, 5.11909053e-02f, -1.22988231e-01f,
  -4.61502150e-02f, -3.57249826e-02f, 1.88625511e-02f, 7.38625303e-02f, 2.28660163e-02f, -9.29507241e-02f, -4.18992422e-04f, -5.54934815e-02f, -5.52122109e-02f, -8.46659541e-02f,
  -1.36858718e-02f, 3.71189341e-02f, 1.19931698e-02f, 1.94964856e-02f, -5.27124926e-02f, -6.30407855e-02f, -1.58048160e-02f, -6.87751621e-02f, -1.05458058e-01f, -6.41351044e-02f,
  -4.86352481e-03f, 1.03570178e-01f, -2.51415744e-02f, 3.59620899e-02f, -8.31198096e-02f, -5.99402972e-02f, 2.35176161e-02f, 1.94473956e-02f, 4.60505811e-03f, -1.34654045e-02f,
  2.98071140e-03f, -6.12885132e-02f, -5.08253016e-02f, 5.11812046e-02f, -1.79724600e-02f, -1.07984282e-02f, 5.75030893e-02f, -7.31937215e-02f, 5.29851541e-02f, 4.01712097e-02f,
  -3.92691195e-02f, -3.42973694e-02f, 9.42625105e-02f, -6.12702295e-02f, -5.09830825e-02f, 9.04380381e-02f, -4.78341244e-03f, -4.94724251e-02f, 2.31356453e-02f, -1.03100099e-01f,
  -2.37414151e-01f, -2.39946470e-01f, 1.76439751e-02f, -7.02371597e-02f, 1.11027237e-03f, 4.40656282e-02f, 4.70150150e-02f, -1.11124426e-01f, -1.10674016e-01f, 7.96086807e-03f,
  -3.97822335e-02f, 1.17867664e-02f, -1.13224506e-01f, 7.86464885e-02f, 5.02820499e-02f, -4.55702506e-02f, -4.46855556e-03f, -9.75859165e-03f, -5.60931191e-02f, -3.82991415e-03f,
  -7.44227022e-02f, 2.20374260e-02f, 5.19517250e-03f, 7.78685361e-02f, 7.41984248e-02f, -6.74738660e-02f, -5.11859134e-02f, -3.30824964e-02f, -1.62222923e-03f, 7.62624368e-02f,
  1.21798903e-01f, -2.96705756e-02f, -1.30383536e-01f, -1.54577017e-01f, -1.20091364e-01f, -1.51207194e-01f, -1.46802053e-01f, -8.34707618e-02f, 1.03772849e-01f, 1.12455107e-01f,
  -2.18519256e-01f, 2.56809946e-02f, 4.18365933e-04f, -2.70149082e-01f, 7.09044859e-02f, 1.18429534e-01f, -8.37208703e-02f, -4.36507538e-02f, 1.53657012e-02f, -1.83817551e-01f,
  -2.78743375e-02f, -1.96153909e-01f, -1.38883039e-01f, -5.78564629e-02f, -1.59554690e-01f, -1.34747013e-01f, -8.28985032e-03f, -4.75345850e-02f, -1.09911844e-01f, -4.80418615e-02f,
  -7.75522366e-02f, -5.67532927e-02f, 4.19672132e-02f, 4.76207118e-03f, -3.10226362e-02f, -1.56001868e-02f, 1.05810817e-02f, -6.84555843e-02f, 2.51803715e-02f, 8.99173394e-02f,
  2.77348305e-03f, 7.84098059e-02f, 7.21179694e-02f, 6.84972666e-03f, -1.31916991e-02f, 7.14196637e-02f, 3.10581978e-02f, -4.39438336e-02f, -5.20517230e-02f, -1.12699233e-02f,
  -8.95925239e-02f, -5.71758375e-02f, -1.76835302e-02f, 8.03162381e-02f, 2.32488606e-02f, 1.15965813e-01f, -3.96584310e-02f, 4.50835302e-02f, -1.63746718e-02f, 8.06226283e-02f,
  3.02271415e-02f, -1.82637237e-02f, -4.37439457e-02f, -1.24633936e-02f, -7.32041150e-02f, -8.29774663e-02f, -1.15154516e-02f, -1.75356064e-02f, -5.08558638e-02f, -7.05942810e-02f,
  -1.81683786e-02f, -6.65432885e-02f, -1.06726855e-01f, -6.58490211e-02f, -3.10098869e-04f, 2.24396307e-02f, -5.16185388e-02f, -5.42073213e-02f, -6.31470755e-02f, -3.30181941e-02f,
  -3.96992378e-02f, -5.01344614e-02f, 2.73809396e-02f, -1.04999363e-01f, -1.57654837e-01f, 3.90892737e-02f, 1.78907439e-02f, -3.22647989e-02f, -1.13142729e-01f, -2.89537329e-02f,
  4.38140109e-02f, 1.85758341e-02f, -1.90995391e-02f, 4.63293269e-02f, 5.70310503e-02f, -1.19398097e-02f, 1.81862265e-02f, 4.46080714e-02f, 2.91973352e-02f, 1.47069702e-02f,
  -2.09136065e-02f, 1.20699480e-02f, 1.21491469e-01f, -3.80281010e-03f, -2.65131351e-02f, -6.63143173e-02f, -5.20081772e-03f, -2.66296305e-02f, -1.28739206e-02f, 1.41173089e-02f,
  -5.39372154e-02f, 5.28246649e-02f, 5.81552275e-03f, -1.63041968e-02f, 1.28249824e-01f, 1.47498623e-01f, 4.24317122e-02f, 7.02020228e-02f, 1.84178073e-02f, 7.68798590e-02f,
  -2.47091413e-01f, -4.08404395e-02f, -5.35090491e-02f, -3.88558656e-02f, -1.34962723e-01f, 2.14646652e-01f, 3.21226448e-01f, -4.22172658e-02f, -2.49851525e-01f, 1.61107987e-01f,
  3.24064523e-01f, -8.84567127e-02f, 2.07974270e-01f, 3.58812779e-01f, 1.05853483e-01f, 1.71214610e-01f, 1.62364781e-01f, 1.70102820e-01f, -1.73510790e-01f, 5.01785129e-02f,
  -6.57104701e-02f, 2.03271106e-01f, 3.54760528e-01f, -6.33429736e-02f, 2.19684511e-01f, -9.22755823e-02f, 8.53993185e-03f, 7.27362260e-02f, 1.14493087e-01f, 1.25712007e-01f,
  7.92440400e-02f, -8.78427476e-02f, 4.52127820e-03f, 5.53522538e-03f, 5.85152535e-04f, -2.32584421e-02f, 8.10668096e-02f, 5.00916541e-02f, -4.93267514e-02f, 1.88050903e-02f,
  -4.17233855e-02f, -1.96348708e-02f, -7.40639567e-02f, 3.24805714e-02f, -1.52486369e-01f, -9.58246365e-02f, 3.23352814e-02f, 3.30021977e-02f, 4.40182388e-02f, 4.10240479e-02f,
  7.00019524e-02f, 1.70933940e-02f, 9.85577703e-02f, 2.59664711e-02f, 2.40494609e-02f, 7.14132609e-03f, 2.45454777e-02f, 3.15470770e-02f, -7.33467191e-03f, -5.71469516e-02f,
  1.13979131e-02f, 7.83117209e-03f, -7.32112397e-03f, 1.16254771e-02f, -4.64446358e-02f, -1.00318424e-03f, 1.51369005e-01f, 4.64413241e-02f, -4.61746156e-02f, 7.17927963e-02f,
  -3.47972251e-02f, 5.63734286e-02f, -3.39253806e-02f, -1.59999263e-02f, -2.40682345e-02f, 8.04511085e-02f, 4.10486981e-02f, 3.46162841e-02f, -1.67630315e-02f, 3.80312587e-04f,
  -1.98190380e-02f, -5.12177236e-02f, -3.67160663e-02f, 6.16309382e-02f, 1.23456478e-01f, -2.75780242e-02f, -2.97343787e-02f, -2.62177028e-02f, -4.71523032e-02f, 6.92673996e-02f,
  1.25857159e-01f, -1.74903661e-01f, -4.71429825e-02f, 2.21403204e-02f, 5.68223149e-02f, -1.01696094e-02f, -3.43654267e-02f, -3.59085202e-02f, 4.54934640e-03f, -6.64035976e-02f,
  -5.21312281e-02f, -6.29432686e-03f, -4.51199748e-02f, 1.83349347e-03f, 1.60869006e-02f, -6.18147803e-03f, 8.41367915e-02f, -7.79385492e-02f, -2.13598125e-02f, 7.45277405e-02f,
  5.16102184e-03f, -4.99947183e-02f, -9.13113132e-02f, -1.70020647e-02f, -8.14761445e-02f, 6.75804988e-02f, -7.52193928e-02f, -3.78412418e-02f, -4.05338071e-02f, -5.64626604e-02f,
  1.55997768e-01f, 1.70889407e-01f, 1.87973961e-01f, 2.45525613e-01f, 4.86164354e-02f, -3.58437002e-01f, -1.97065249e-01f, 3.95766422e-02f, -1.88618124e-01f, 7.01994225e-02f,
  -7.20256045e-02f, -1.83723997e-02f, -5.89415021e-02f, 1.57079712e-01f, 1.56285271e-01f, -1.45142809e-01f, 1.42611220e-01f, -2.14907080e-02f, -9.40790027e-03f, 1.18634671e-01f,
  4.55472246e-02f, 6.15630895e-02f, 2.37337351e-01f, 1.15284503e-01f, 1.58700012e-02f, 4.14827876e-02f, 1.95529640e-01f, -7.48421939e-04f, 2.27037407e-02f, 8.80201682e-02f,
  -6.66327775e-02f, 1.29471971e-02f, 6.94691539e-02f, -4.05291747e-03f, 5.65111265e-02f, -4.51351143e-02f, 1.62378214e-02f, 1.34254238e-02f, -4.75903861e-02f, -3.53169143e-02f,
  -4.03025672e-02f, 4.75651734e-02f, -1.07317893e-02f, -2.21491139e-02f, 4.89403643e-02f, 6.75676484e-03f, 1.09874327e-02f, 6.75477982e-02f, -4.07117531e-02f, 7.10388273e-02f,
  6.06850907e-02f, 4.84835636e-03f, 2.49847565e-02f, -5.91981749e-04f, -2.12594261e-03f, 8.19221977e-03f, -9.30548366e-03f, 1.56528637e-01f, 6.44573271e-02f, -2.80907229e-02f,
  5.57178147e-02f, 3.98179051e-03f, -6.23713546e-02f, -2.62557268e-02f, 5.45819700e-02f, -1.09300278e-02f, -6.34108707e-02f, 3.90519127e-02f, 1.51836826e-02f, -1.86069980e-02f,
  4.94257882e-02f, -1.07790932e-01f, -9.07916427e-02f, -5.23425750e-02f, -2.74183485e-03f, 4.11072606e-03f, -1.09890170e-01f, -3.29422429e-02f, -2.81694252e-02f, 1.26215238e-02f,
  -2.44863033e-02f, -3.69645841e-02f, 1.01602571e-02f, -1.12075806e-01f, 1.52365966e-02f, 6.56446591e-02f, -8.22987407e-03f, -3.70467603e-02f, -5.58637176e-03f, -6.11330308e-02f,
  -8.09060484e-02f, 7.68167078e-02f, 5.74564636e-02f, -2.14260910e-03f, 2.67154519e-02f, -7.50085013e-03f, 3.65087483e-03f, 3.65394615e-02f, 3.13404314e-02f, -7.64040574e-02f,
  9.49617624e-02f, -7.66401365e-02f, -4.61028237e-03f, -4.46218289e-02f, 5.53262830e-02f, 9.57374647e-03f, 9.74988099e-03f, 7.21540079e-02f, 6.19342923e-02f, 1.37612611e-01f,
  -1.21749518e-02f, -1.32522499e-02f, 9.39393789e-02f, 3.10241375e-02f, 1.62157360e-02f, -9.37869623e-02f, -1.16432592e-01f, -5.37232570e-02f, -7.14796036e-03f, 3.31456843e-03f,
  -1.01695128e-01f, -1.33928970e-01f, -1.17496192e-01f, -6.54559806e-02f, 3.54927331e-01f, -2.02883869e-01f, -3.78128365e-02f, 7.11879730e-02f, 1.21329138e-02f, 2.44216751e-02f,
  -5.17241135e-02f, -2.50775993e-01f, -7.14455470e-02f, -2.21336424e-01f, -4.13232148e-01f, -3.74294758e-01f, -1.98606953e-01f, -2.07436472e-01f, -1.03796504e-01f, -6.81713521e-02f,
  -1.51954554e-02f, 1.22636870e-01f, -8.90975073e-02f, 3.43373567e-01f, 1.81874171e-01f, 2.05961883e-01f, 2.61202693e-01f, 2.92335063e-01f, -2.70479266e-02f, 2.18652692e-02f,
  -6.81621395e-03f, -1.59607455e-01f, 1.68739315e-02f, -5.08334227e-02f, 3.07538640e-02f, -3.04898527e-02f, 1.79424416e-02f, -2.60998379e-03f, 7.93993324e-02f, -7.08930567e-02f,
  -8.26191828e-02f, -6.58859387e-02f, -9.09002684e-03f, 1.42570332e-01f, 1.05520785e-01f, -1.61310174e-02f, -6.62470683e-02f, 4.59284410e-02f, -6.09286167e-02f, -1.59991011e-01f,
  -7.28128701e-02f, -3.14744040e-02f, 7.71716237e-02f, 5.13803065e-02f, -4.94139530e-02f, -3.34333107e-02f, -7.32453316e-02f, 2.89825187e-03f, -2.45660022e-02f, -3.63285094e-02f,
  -6.03622235e-02f, 6.92743510e-02f, 4.54638619e-04f, 6.57488033e-02f, 2.20062826e-02f, 1.59199070e-02f, -1.07142711e-02f, 1.16285840e-02f, 1.25981823e-01f, -2.07685567e-02f,
  1.70544013e-01f, 2.23361189e-03f, 5.15608788e-02f, 1.09419547e-01f, -5.08772302e-03f, 5.05983904e-02f, 7.29411170e-02f, -1.04229353e-01f, -2.99195666e-02f, -3.91115993e-02f,
  6.25303611e-02f, -6.37283409e-03f, 6.48000836e-03f, 7.27032796e-02f, -5.00978790e-02f, 7.69607201e-02f, -6.82860613e-02f, -2.59070564e-03f, -8.60638451e-03f, -4.34664525e-02f,
  4.62832004e-02f, -1.56751662e-01f, 3.62049676e-02f, 5.75565845e-02f, 3.33325192e-02f, -5.58395237e-02f, -8.09712633e-02f, 4.60548763e-04f, -7.89994653e-03f, 1.46607226e-02f,
  -2.29320135e-02f, 6.69073388e-02f, 9.59617719e-02f, 6.79956973e-02f, 3.69444233e-03f, -7.82422815e-03f, -8.19958467e-03f, 8.68911818e-02f, 2.73500346e-02f, -6.19601943e-02f,
  3.86368409e-02f, -6.05808124e-02f, 3.50781195e-02f, 9.24558043e-02f, 5.03891632e-02f, 3.23531422e-04f, -1.09379090e-01f, -5.86724505e-02f, -1.17773883e-01f, 4.47045220e-03f
};

// L0_fan_Bp_bar (Shape: 1 x 26)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 26;
const float L0_fan_Bp_bar_data[] = {
  3.82994637e-02f, 8.36784914e-02f, 9.36600193e-02f, -9.00432933e-03f, 1.79819763e-01f, -7.65522048e-02f, 6.70243986e-03f, -1.52646810e-01f, 1.03699163e-01f, 1.22005679e-01f,
  9.39599276e-02f, -4.47956380e-03f, 8.29247683e-02f, -2.22750194e-02f, -8.92651305e-02f, 7.70862773e-03f, 5.11094229e-03f, -5.27451821e-02f, -2.03287117e-02f, 5.57529554e-02f,
  6.80850297e-02f, -7.27173835e-02f, 1.19948974e-02f, 8.02365765e-02f, -7.55024329e-02f, 1.49692431e-01f
};

// L1_fan_Wp (Shape: 19 x 64)
const int L1_fan_Wp_rows = 19;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  -1.95594221e-01f, 1.89613793e-02f, 9.95166153e-02f, -6.47382364e-02f, -2.58972626e-02f, 9.11513809e-03f, 3.60136926e-02f, -1.24579921e-01f, 4.21465114e-02f, 5.24972519e-03f,
  5.20761237e-02f, -1.20362369e-02f, 6.43710420e-02f, 2.25455269e-01f, -1.43688604e-01f, 7.26780072e-02f, 8.81614611e-02f, -1.84188318e-02f, -8.89011472e-02f, -6.38233945e-02f,
  5.67960143e-02f, 1.67231739e-01f, -1.22871846e-01f, -1.12955622e-01f, -3.62729058e-02f, 5.79494126e-02f, -1.19319870e-04f, -1.12731094e-02f, 8.53580236e-02f, 6.10642247e-02f,
  2.67487690e-02f, -1.01934902e-01f, -5.17957546e-02f, -7.48388842e-02f, -4.06557620e-02f, 7.62414187e-03f, 1.36174798e-01f, 1.09531097e-01f, 2.05422878e-01f, 2.16155853e-02f,
  -1.18046533e-02f, -1.22805677e-01f, -1.99054912e-01f, 1.55406967e-01f, 1.38504086e-02f, 7.01471945e-05f, 1.40231103e-01f, 5.86164109e-02f, 9.30356160e-02f, -4.12108786e-02f,
  -7.18259960e-02f, -1.66195020e-01f, -1.01315208e-01f, -5.45457415e-02f, 1.14663973e-01f, -2.01824263e-01f, -8.34808499e-02f, 2.80459583e-01f, -1.95389345e-01f, 1.82505755e-03f,
  -4.70653288e-02f, 2.84558330e-02f, -1.59801960e-01f, 1.54461665e-03f, -1.25127390e-01f, 2.09708307e-02f, 4.01644260e-02f, -8.70383382e-02f, -1.57346774e-03f, 5.94165735e-02f,
  8.77871886e-02f, -9.13502276e-02f, -7.24083334e-02f, -5.78119867e-02f, 9.54155400e-02f, 1.05793066e-01f, 3.69811337e-03f, 7.22174942e-02f, -7.68280914e-03f, -6.78012967e-02f,
  5.03899939e-02f, -1.15789268e-02f, 9.58189219e-02f, 8.29564780e-02f, 1.01683214e-01f, 1.57978404e-02f, 1.31936818e-01f, -2.29523685e-02f, -2.91514359e-02f, -1.93862513e-01f,
  -1.22364111e-01f, -4.82621789e-02f, 9.92085040e-02f, 7.52605572e-02f, -4.11612801e-02f, -1.11372672e-01f, 1.10047221e-01f, -3.26051153e-02f, 1.71232391e-02f, 9.94226038e-02f,
  5.26299924e-02f, 6.73177838e-02f, -2.59252209e-02f, 1.55864432e-01f, 2.19501406e-01f, 7.66630471e-02f, 9.20684710e-02f, 6.60390779e-02f, 1.50367260e-01f, 1.87263295e-01f,
  3.11667565e-02f, 5.05135879e-02f, 7.07810819e-02f, 6.57916884e-04f, -8.58965889e-02f, 1.67980880e-01f, 8.31682086e-02f, 3.89831364e-02f, 2.28407562e-01f, 6.97396696e-02f,
  6.80095889e-03f, -2.02205330e-02f, -8.77562910e-02f, 2.36893654e-01f, 4.10749018e-02f, 5.02179787e-02f, 7.78734265e-03f, -1.86063230e-01f, -1.08662628e-01f, -4.71265465e-02f,
  -6.39164522e-02f, 1.53353617e-01f, -1.06214043e-02f, 9.86724049e-02f, 8.48640501e-02f, -6.21085800e-02f, 3.61859277e-02f, 2.86756232e-02f, 1.78097114e-01f, 2.72692069e-02f,
  5.38639463e-02f, 6.72969446e-02f, 3.16834114e-02f, -1.31502047e-01f, -1.16137611e-02f, -6.10431135e-02f, 3.88821401e-02f, 6.13513254e-02f, 2.71514226e-02f, 1.23657010e-01f,
  -3.77773494e-02f, 1.31743541e-02f, -7.29530528e-02f, -3.97923961e-02f, -5.52513339e-02f, 1.79818824e-01f, 1.83235124e-01f, 9.15152729e-02f, -1.81516424e-01f, 6.32707998e-02f,
  1.07354596e-01f, 2.06558537e-02f, -5.58233038e-02f, 1.03549659e-01f, -3.22305039e-02f, -5.17714433e-02f, -4.68541915e-03f, 1.21925987e-01f, 2.64569134e-01f, -1.76880062e-01f,
  5.29744886e-02f, 1.54180646e-01f, 6.32954538e-02f, -1.23801790e-01f, -7.06637055e-02f, 1.34364843e-01f, -1.97413191e-02f, -1.05056226e-01f, -2.67410520e-02f, -1.52549580e-01f,
  -2.91111693e-02f, -1.68991968e-01f, 2.16029570e-01f, 7.53970584e-03f, -2.16689020e-01f, 1.39550656e-01f, -8.33113641e-02f, -4.13546599e-02f, -1.94452807e-01f, 1.06567621e-01f,
  -1.93834543e-01f, 1.87422305e-01f, -1.92378625e-01f, -1.02741033e-01f, -1.16759144e-01f, -8.08565542e-02f, 1.10150562e-04f, -9.26841144e-03f, -2.13903319e-02f, -8.87124240e-02f,
  -2.11767722e-02f, -2.85371058e-02f, 1.59140155e-02f, 9.28099900e-02f, -5.97379766e-02f, 7.36654177e-02f, -6.31752163e-02f, -3.79723758e-02f, -4.62665260e-02f, 3.32680531e-02f,
  1.14237905e-01f, 3.71307470e-02f, 4.19030674e-02f, -1.48043809e-02f, 1.19793415e-01f, 6.90386980e-04f, -2.50110812e-02f, 5.34336157e-02f, -1.28026396e-01f, -8.49884972e-02f,
  1.55857597e-02f, 1.24674208e-01f, -9.52024609e-02f, -3.43947858e-02f, 2.03017537e-02f, 4.51817922e-02f, -9.66304764e-02f, 1.10271625e-01f, -1.58149526e-01f, -9.11892727e-02f,
  1.88878048e-02f, -1.05005270e-02f, 1.50413036e-01f, -7.18937144e-02f, 7.49413371e-02f, 1.12797484e-01f, 7.74727613e-02f, 1.97283074e-01f, 5.35874218e-02f, 2.61936039e-02f,
  -6.06055781e-02f, -2.41815686e-01f, -1.63586751e-01f, 1.00759402e-01f, -6.96164593e-02f, 5.69441840e-02f, 1.16000310e-01f, 1.39164999e-01f, 6.14496134e-03f, -2.05631810e-03f,
  3.70176472e-02f, 1.80379316e-01f, -1.40364561e-02f, 5.30049987e-02f, -4.78537828e-02f, -5.97831346e-02f, -2.93333381e-01f, -6.52160794e-02f, -1.93765538e-03f, -5.69085181e-02f,
  -1.18595608e-01f, -5.69492094e-02f, -2.47918647e-02f, -1.84120655e-01f, 3.82497348e-02f, 3.43757533e-02f, 1.52992964e-01f, -1.59782674e-02f, 6.07211180e-02f, 1.90127060e-01f,
  -1.53622078e-02f, -8.74873325e-02f, 4.50182892e-02f, -6.96942657e-02f, 2.80846152e-02f, -2.85085682e-02f, 7.28237778e-02f, 1.82393000e-01f, 3.99182513e-02f, -7.32132792e-02f,
  1.29983891e-02f, 1.61267407e-02f, 5.67362690e-03f, -1.72358155e-02f, 5.78471906e-02f, 9.58677381e-02f, 2.63963128e-03f, -1.20332807e-01f, 2.23880764e-02f, -5.04314899e-02f,
  -1.10737398e-01f, 2.18861494e-02f, 5.53273670e-02f, 1.26647726e-01f, 3.67913246e-02f, 4.93257158e-02f, 1.09996460e-01f, -1.90323107e-02f, -5.88290580e-02f, 1.29748017e-01f,
  1.50247365e-01f, 1.43591896e-01f, 1.20527968e-01f, 1.15700282e-01f, 6.91275224e-02f, -1.98927209e-01f, -1.48256943e-01f, -5.21779284e-02f, -8.96654949e-02f, -9.24278423e-02f,
  1.67350590e-01f, -9.58607793e-02f, -9.15539116e-02f, 6.30175248e-02f, -9.86871570e-02f, 1.28371358e-01f, 1.32880481e-02f, 3.26496251e-02f, -1.20569177e-01f, 4.21569496e-02f,
  -1.02516375e-01f, 1.61039457e-02f, 6.94801006e-03f, 7.80938566e-02f, -2.47651953e-02f, 9.20748455e-04f, 1.38018951e-01f, 5.29229678e-02f, 6.14509061e-02f, 6.89231679e-02f,
  1.13372743e-01f, 9.75191593e-02f, 5.86229563e-03f, 1.31961823e-01f, 1.28304027e-02f, 3.52673829e-02f, 4.56050262e-02f, -6.20497279e-02f, 6.90239146e-02f, 5.36537580e-02f,
  -1.68783702e-02f, 9.47303250e-02f, -2.87277475e-02f, 1.62577808e-01f, 1.86785385e-02f, -1.49089605e-01f, 7.98162539e-03f, -1.36461973e-01f, 1.97608188e-01f, 1.92857638e-01f,
  -1.83846548e-01f, -5.01344949e-02f, 1.89903468e-01f, -7.56054148e-02f, 1.51440669e-02f, 1.54076412e-01f, -7.81391636e-02f, 7.72456899e-02f, 4.54169437e-02f, -1.59144346e-02f,
  1.26813740e-01f, -9.06552449e-02f, 1.79812521e-01f, -1.21058500e-03f, 2.99158692e-03f, 1.27846405e-01f, -1.11053325e-01f, 2.10348144e-01f, -1.27016410e-01f, -2.00743884e-01f,
  -7.24768937e-02f, 4.81584668e-02f, 7.55884200e-02f, 1.05216570e-01f, 4.45150100e-02f, 2.20621172e-02f, -6.01879023e-02f, 3.12051829e-02f, 7.38117695e-02f, 2.26999056e-02f,
  -2.25075595e-02f, 1.13707066e-01f, -8.18142369e-02f, -5.39891236e-02f, -6.65424205e-03f, 4.20544483e-02f, 1.06100075e-01f, 1.41317248e-01f, -1.03475928e-01f, -1.75447948e-02f,
  5.53739741e-02f, -1.89276449e-02f, 1.64228156e-01f, -4.70625795e-02f, 2.03492880e-01f, 9.08422098e-02f, 9.88335460e-02f, 1.32367432e-01f, -3.68303135e-02f, -9.80674177e-02f,
  -2.99422201e-02f, 4.02083062e-02f, 1.91422001e-01f, -4.47610859e-03f, 1.99816730e-02f, 1.68088689e-01f, 6.77070543e-02f, 8.73396322e-02f, -3.87971336e-03f, 1.76665168e-02f,
  2.03119721e-02f, 4.09267144e-03f, 1.68379799e-01f, 1.81120500e-01f, -2.05957189e-01f, 2.77724024e-02f, 1.14604220e-01f, -8.18943381e-02f, -1.15351006e-01f, 4.88844924e-02f,
  6.85289428e-02f, -4.05730074e-03f, 3.42903174e-02f, 1.22968238e-02f, 2.38392279e-01f, -2.24057332e-01f, 1.42928392e-01f, 1.41619593e-01f, 1.09513350e-01f, 3.77637073e-02f,
  7.00016245e-02f, -2.01747604e-02f, -1.08728267e-01f, -1.37673542e-01f, -1.00482792e-01f, -3.07918400e-01f, 7.79852793e-02f, -3.31384838e-01f, 4.39477451e-02f, 2.04116795e-02f,
  -2.32126758e-01f, 1.62667766e-01f, -1.22554630e-01f, 5.46881510e-03f, -1.36222810e-01f, -2.12101899e-02f, -1.09537639e-01f, 1.44971505e-01f, -6.31385017e-03f, 2.21466529e-03f,
  2.17159069e-03f, 5.24523929e-02f, 1.12375200e-01f, -5.41409589e-02f, -9.54023525e-02f, 8.74132067e-02f, 8.50680470e-02f, -1.38959199e-01f, 3.21499014e-04f, -5.34334444e-02f,
  -5.11690415e-02f, 3.81332659e-03f, -1.18016392e-01f, 7.33688921e-02f, -4.05621901e-02f, -5.31127304e-02f, -3.68397757e-02f, 4.64665778e-02f, 2.84251720e-02f, -1.69799407e-03f,
  -1.70237478e-02f, 7.91250467e-02f, 2.67785974e-02f, -1.13892756e-01f, -1.03634056e-02f, -5.73738627e-02f, 9.20712110e-03f, 6.28629997e-02f, -1.06980428e-01f, -1.29200801e-01f,
  1.32127047e-01f, -5.91645762e-02f, -7.81122595e-02f, 6.14163186e-03f, -5.76899126e-02f, 1.32392183e-01f, 1.63617715e-01f, 6.60403967e-02f, -1.96191326e-01f, 5.52267022e-02f,
  -4.13466021e-02f, 1.03699207e-01f, -7.26018921e-02f, 1.30951554e-01f, 1.17332349e-02f, -2.15418935e-02f, -2.70258207e-02f, -1.41834840e-01f, -1.56162992e-01f, 9.18312836e-03f,
  1.15417279e-01f, 1.07874453e-01f, -8.81271809e-02f, 2.07508460e-01f, 1.67331789e-02f, 2.03083977e-01f, 9.92715657e-02f, 3.20743956e-02f, 7.37039670e-02f, 6.20361269e-02f,
  8.18873867e-02f, -2.59409267e-02f, 4.01888303e-02f, 1.10780999e-01f, 4.34499197e-02f, 2.22585741e-02f, 3.64676565e-02f, -7.34028667e-02f, -1.94081590e-01f, -7.84917735e-03f,
  3.68252844e-02f, -3.12259141e-03f, 1.57711104e-01f, 4.42933440e-02f, -1.90238003e-02f, -2.29454450e-02f, 1.10775989e-03f, 1.18218824e-01f, 1.76355131e-02f, 2.86812279e-02f,
  -1.75734162e-01f, -8.72541964e-03f, 9.16563720e-02f, -2.57020276e-02f, 1.10154398e-01f, -5.39496988e-02f, -2.49140449e-02f, -1.34447068e-01f, -1.27202019e-01f, -2.40078241e-01f,
  -1.45727387e-02f, -1.78930178e-01f, -3.07919495e-02f, -3.37708332e-02f, -1.43918887e-01f, 1.90680735e-02f, 2.49759257e-02f, -1.29786298e-01f, 3.06403518e-01f, 3.48046646e-02f,
  -1.05020002e-01f, 1.51101783e-01f, 1.07404165e-01f, 3.11137587e-01f, -1.21717125e-01f, -2.33572930e-01f, 3.78025137e-02f, 1.21088043e-01f, 1.21183120e-01f, -7.65770152e-02f,
  1.48943111e-01f, 1.78311467e-01f, -1.29626766e-02f, 1.24052186e-02f, 2.04499394e-01f, -6.60164803e-02f, -3.21104713e-02f, -6.75219074e-02f, -8.39147717e-02f, -2.94878811e-01f,
  -1.08828209e-01f, 1.21341981e-01f, 1.87199578e-01f, -2.90870756e-01f, 1.49969682e-01f, -3.67223285e-02f, -1.34104759e-01f, -3.71117480e-02f, -3.91491205e-02f, -1.20169781e-01f,
  1.05709076e-01f, -1.66382313e-01f, -8.31660032e-02f, 9.56320539e-02f, -3.17217931e-02f, -1.04777455e-01f, -9.96138379e-02f, -3.05841845e-02f, -6.18865713e-02f, 6.94573224e-02f,
  -1.58017478e-03f, -4.73145992e-02f, -7.97474757e-03f, -1.13945901e-02f, -8.47335998e-03f, 1.02431558e-01f, -3.05011892e-03f, -6.42483383e-02f, 1.07089840e-01f, 6.23058006e-02f,
  6.92249835e-02f, -1.53282270e-01f, -3.63801904e-02f, -7.35274628e-02f, -9.56354514e-02f, 5.63161857e-02f, -5.26800156e-02f, -1.22217655e-01f, 1.07130066e-01f, -3.32337022e-02f,
  -8.78783911e-02f, -6.18528873e-02f, -5.67442887e-02f, 1.32374447e-02f, 5.82114235e-02f, -3.04691941e-02f, -2.56069630e-01f, 1.18834831e-01f, -2.87489761e-02f, 1.75644055e-01f,
  -5.46151884e-02f, 2.32394695e-01f, -1.60925183e-02f, -1.37959495e-01f, 2.21233554e-02f, -1.24804221e-01f, -8.93916190e-02f, 1.05694689e-01f, 8.13423395e-02f, 1.03714779e-01f,
  -8.96077901e-02f, 1.03800029e-01f, 1.35573700e-01f, 1.27403498e-01f, 3.73187810e-02f, 1.87204942e-01f, 6.27911463e-02f, 1.53498545e-01f, 1.30259365e-01f, -2.43790194e-01f,
  4.46981378e-02f, -4.19890322e-02f, 7.69417435e-02f, -9.58919153e-03f, 7.68330768e-02f, 5.83383515e-02f, -5.93226664e-02f, -5.68617061e-02f, 1.25220373e-01f, -3.53706181e-02f,
  -1.66254751e-02f, 3.37431841e-02f, 5.90296276e-02f, -5.40140867e-02f, -6.30790442e-02f, 1.08165376e-01f, -1.85405314e-02f, 1.16548635e-01f, 2.55177096e-02f, -1.22031763e-01f,
  1.33559741e-02f, -1.09538063e-01f, -1.30396277e-01f, -8.27473253e-02f, 7.68578723e-02f, 2.38726497e-01f, 1.44672036e-01f, 5.83786666e-02f, -1.99913800e-01f, -1.83513641e-01f,
  1.01331666e-01f, 8.15545917e-02f, -1.94155544e-01f, -1.20779863e-02f, -9.04083923e-02f, -1.37130693e-01f, -7.68522769e-02f, -9.24118757e-02f, 5.78158163e-02f, -1.64237842e-01f,
  -2.32691616e-02f, -2.53519565e-02f, -1.36082426e-01f, -2.04427075e-02f, -9.69721824e-02f, -1.55189559e-01f, 8.48367065e-02f, -2.40113750e-01f, -2.52643377e-02f, -1.24248683e-01f,
  -5.57289049e-02f, -9.25881192e-02f, -6.34888709e-02f, -5.75660076e-03f, -1.14075683e-01f, 1.43102184e-01f, 8.53362158e-02f, -1.81785394e-02f, 8.80100206e-02f, -9.66304094e-02f,
  -1.72439769e-01f, 2.86920778e-02f, 6.32203519e-02f, 2.45179608e-01f, -1.74388215e-01f, -7.84798414e-02f, -1.17668554e-01f, -1.49741126e-02f, -1.35506853e-01f, 4.70401794e-02f,
  6.17413074e-02f, -2.56302878e-02f, -1.23173362e-02f, -3.53351384e-02f, -1.03528807e-02f, -6.23439588e-02f, -9.09334794e-02f, 4.16433401e-02f, -6.38767183e-02f, -1.16725914e-01f,
  2.61385962e-02f, -3.80976647e-02f, -1.94865912e-02f, 4.08240082e-03f, 3.94808948e-02f, 6.74049333e-02f, 3.33303027e-02f, -8.51075873e-02f, 1.15918266e-02f, 1.01898044e-01f,
  -9.33788866e-02f, -1.08481832e-01f, 8.06174502e-02f, 1.59904063e-01f, 3.82991359e-02f, -2.54832115e-02f, 7.56081343e-02f, -5.99976107e-02f, -1.47557065e-01f, 1.26685295e-02f,
  -5.46777919e-02f, -4.28962186e-02f, -4.66272198e-02f, 3.64721343e-02f, 2.34989777e-01f, -2.43375763e-01f, 1.01635523e-01f, 1.26224130e-01f, 1.35561660e-01f, 2.48797014e-02f,
  1.20579042e-02f, 2.19992474e-02f, 1.03887692e-02f, -1.96239382e-01f, -1.43474653e-01f, 7.52853230e-02f, -1.31026611e-01f, 6.10403754e-02f, 1.32444516e-01f, 5.79946674e-02f,
  1.30794859e-02f, 1.11479394e-01f, 6.71143979e-02f, -2.42678262e-02f, -1.27649277e-01f, 8.38128552e-02f, -7.93766752e-02f, -5.03522567e-02f, 1.28477052e-01f, 4.42849211e-02f,
  1.16583474e-01f, 2.36474331e-02f, 1.05175927e-01f, 5.97327054e-02f, 1.61922649e-02f, -2.11628713e-02f, 1.74795464e-02f, -1.35902584e-01f, 1.21855633e-02f, -8.47903863e-02f,
  1.97244566e-02f, -5.25713302e-02f, -4.74063633e-03f, 1.19249463e-01f, 2.91434806e-02f, 7.87940398e-02f, -5.17102145e-02f, 7.52135832e-03f, -4.39865291e-02f, -1.47581443e-01f,
  5.15590012e-02f, -2.20199693e-02f, -6.79077432e-02f, -8.16601068e-02f, 1.21341944e-02f, 1.45142537e-03f, 3.40177976e-02f, -9.41694304e-02f, -1.51654342e-02f, 7.01480880e-02f,
  -6.46306248e-03f, -2.88559515e-02f, 1.06619939e-01f, -5.76072792e-03f, 8.56741592e-02f, 7.03053698e-02f, -7.90363774e-02f, 2.03714287e-03f, -1.59168482e-01f, 1.64035529e-01f,
  -1.00933895e-01f, -7.29851797e-02f, -6.20435104e-02f, 5.48116080e-02f, -2.18055174e-02f, 2.66793091e-02f, -6.45371005e-02f, 2.39417806e-01f, 1.25158072e-01f, -5.26357442e-02f,
  9.98652354e-03f, 1.54974060e-02f, -1.57472312e-01f, -5.13288714e-02f, -3.65144946e-02f, -8.90700519e-02f, 7.31725991e-02f, 2.84655355e-02f, 2.14968383e-01f, -1.36923119e-01f,
  1.59711212e-01f, -2.54316051e-02f, -1.26639232e-01f, -9.47927404e-03f, -5.61502203e-02f, -1.19435102e-01f, 1.01725720e-01f, 7.53803179e-02f, 1.05115339e-01f, 5.12079000e-02f,
  -1.80901259e-01f, 1.16270788e-01f, -5.35618290e-02f, 1.19263262e-01f, 2.41509285e-02f, 1.07700951e-01f, 2.39984114e-02f, -1.52124107e-01f, 7.27295829e-03f, 3.37600568e-03f,
  -2.15757899e-02f, 1.98763862e-01f, -7.35881105e-02f, 5.00822440e-02f, 1.76593289e-01f, -1.68828726e-01f, -4.78990041e-02f, 5.07110134e-02f, -2.45382152e-02f, 2.74197627e-02f,
  6.74359202e-02f, -2.49214992e-02f, 1.42552271e-01f, -5.90545982e-02f, -1.23204291e-01f, 8.59121606e-02f, 6.18409403e-02f, 2.45767280e-01f, -5.58749586e-02f, -2.13682696e-01f,
  -5.96137382e-02f, 6.22718744e-02f, 2.20585302e-01f, -2.91259866e-02f, 1.21637501e-01f, 1.01231329e-01f, 2.21751109e-01f, 1.73906118e-01f, -5.91980107e-02f, 1.34078324e-01f,
  2.78209522e-03f, 4.16032113e-02f, 1.42660469e-03f, 2.11121976e-01f, -1.23775162e-01f, 1.15869865e-01f, 2.58551955e-01f, -1.56172901e-01f, -7.10813031e-02f, -1.70513391e-01f,
  -1.59649864e-01f, 2.26584107e-01f, 1.20309375e-01f, 1.54413238e-01f, 1.65978377e-03f, -2.56521791e-01f, 2.41096821e-02f, 1.13733388e-01f, 3.31404917e-02f, -1.51871215e-03f,
  -7.37433657e-02f, 1.21020228e-01f, -2.15885751e-02f, 2.20589433e-02f, 8.10658708e-02f, 1.08247168e-01f, 1.51076376e-01f, 3.92015725e-02f, 1.27714276e-02f, -3.11534237e-02f,
  3.99314165e-02f, 1.37216702e-01f, 1.04135633e-01f, -5.18090501e-02f, -8.37913007e-02f, -1.03267349e-01f, 7.53146484e-02f, 2.80383751e-02f, 4.39734794e-02f, -1.62073001e-02f,
  -9.27298814e-02f, -1.02451388e-02f, -1.19413532e-01f, -8.69878829e-02f, 7.55454367e-03f, -2.07676023e-01f, 1.41941339e-01f, 1.17429659e-01f, -8.27797130e-02f, 9.22987089e-02f,
  -2.27355384e-04f, -1.14975050e-01f, 2.75697201e-01f, -3.61521542e-02f, -1.02371231e-01f, 3.77085693e-02f, 8.82526934e-02f, -3.18969041e-02f, -3.90142761e-02f, -1.23041175e-01f,
  8.92814398e-02f, 9.22785923e-02f, 1.62186727e-01f, -3.00396979e-02f, 2.40978613e-01f, 2.15901241e-01f, 1.75789028e-01f, 6.32384270e-02f, -2.19679773e-01f, -8.63533374e-03f,
  1.42312888e-02f, -2.37637743e-01f, -1.12687953e-01f, -1.56543911e-01f, -1.51724175e-01f, 1.67889878e-01f, 1.78158209e-01f, -2.68873304e-01f, -1.24324650e-01f, 2.24068835e-01f,
  -1.75338775e-01f, -9.11289826e-02f, -1.16950467e-01f, -4.03203368e-02f, -1.42585402e-02f, 3.87984104e-02f, -3.07750255e-02f, -9.89811309e-03f, 4.76229144e-03f, 6.99116811e-02f,
  -1.34974401e-02f, -4.46486063e-02f, 8.93295482e-02f, 1.76031992e-01f, -5.30936383e-02f, -9.50445607e-02f, 2.03336012e-02f, 2.74638627e-02f, -6.85272068e-02f, -1.89240910e-02f,
  -5.13931885e-02f, 5.11258543e-02f, -2.45961659e-02f, -1.67878300e-01f, 3.93253658e-03f, 3.98622751e-02f, 9.56889167e-02f, -1.25409039e-02f, -6.00192584e-02f, 6.00821041e-02f,
  1.65732652e-01f, -2.68755294e-02f, -5.64097576e-02f, 7.83094913e-02f, 7.17970952e-02f, 2.18624552e-03f, 4.64079119e-02f, 5.36062308e-02f, 1.34453893e-01f, -4.98700589e-02f,
  6.67734593e-02f, -6.19840696e-02f, -1.43429041e-01f, 1.35982305e-01f, 1.01518653e-01f, 1.39750883e-01f, 1.49541855e-01f, -3.20799556e-03f, 1.79542288e-01f, -4.69605485e-03f,
  -7.41050243e-02f, 6.05882145e-02f, -1.95714489e-01f, 1.25836447e-01f, 1.44813254e-01f, -1.74654365e-01f, 5.37863858e-02f, 1.08454660e-01f, -9.28864703e-02f, 1.36399299e-01f,
  8.17909911e-02f, 4.38405052e-02f, -1.54519677e-01f, -1.69752702e-01f, -1.08171612e-01f, 9.52347592e-02f, 9.95869637e-02f, 8.76886025e-02f, -7.31541216e-02f, 9.38537717e-02f,
  1.40593290e-01f, 3.09756622e-02f, -7.02821836e-02f, 1.77966297e-01f, 3.92799675e-02f, 3.25942151e-02f, 8.55514333e-02f, 1.10384703e-01f, 1.17323153e-01f, -2.04906464e-02f,
  -8.36408418e-03f, 6.71046674e-02f, 3.01741473e-02f, -4.64660823e-02f, 3.26194689e-02f, 6.57228678e-02f, 4.68858629e-02f, -9.51511636e-02f, -5.39647974e-02f, 5.93378507e-02f,
  -1.05403736e-01f, -6.61380775e-03f, -9.74352807e-02f, -8.83073881e-02f, 1.55708447e-01f, 5.95336892e-02f, -8.76659974e-02f, 1.50123704e-02f, 6.71885535e-03f, 1.55430930e-02f,
  2.11047634e-01f, -9.77374315e-02f, -1.45752475e-01f, 2.03815904e-02f, 1.94596946e-01f, 2.08859053e-02f, 3.12538110e-02f, -1.75092161e-01f, 1.41068831e-01f, 8.28806870e-03f,
  6.74141571e-02f, 9.18626785e-02f, 1.99453384e-01f, 1.11166738e-01f, 8.21714848e-02f, -5.75363301e-02f, -1.39300376e-01f, -1.27924323e-01f, 6.06842078e-02f, -2.43976012e-01f,
  -1.24725588e-01f, -1.76156878e-01f, -5.62617145e-02f, 5.41869272e-03f, 8.47498029e-02f, -1.53458983e-01f, 2.98417304e-02f, 3.30080336e-04f, -2.29078636e-01f, -8.40343162e-02f,
  -1.13538556e-01f, -5.72673082e-02f, -1.11422390e-02f, -7.67883509e-02f, -4.85793315e-02f, -1.58417653e-02f, -1.00841038e-01f, -8.26566219e-02f, -3.12128514e-02f, -3.74120772e-02f,
  -3.67750376e-02f, 8.67402107e-02f, -1.33100273e-02f, -1.25560567e-01f, -1.83199830e-02f, 1.71432644e-02f, -3.23207639e-02f, 4.57972772e-02f, -3.33809033e-02f, 1.23497941e-01f,
  4.71823923e-02f, -5.63760987e-03f, -1.45108793e-02f, -1.15723200e-02f, -5.89947701e-02f, -9.53631178e-02f, 3.31171155e-02f, 5.80758303e-02f, -5.70207313e-02f, -4.44633514e-02f,
  1.13287136e-01f, 2.20505595e-02f, 1.35040749e-02f, 5.26625328e-02f, 5.47145531e-02f, -1.38964783e-02f, 5.78340366e-02f, 6.44057617e-02f, -1.00432485e-02f, -1.09829359e-01f,
  -5.63108735e-02f, 5.37517332e-02f, 9.02776495e-02f, 2.67574430e-01f, 8.79013985e-02f, 5.33716753e-02f, 3.29306610e-02f, -1.03568405e-01f, -9.81791466e-02f, 1.00676388e-01f,
  -1.00516275e-01f, 1.59542024e-01f, 1.06725574e-01f, -1.37430355e-02f, -5.37485033e-02f, 8.15620273e-02f, -3.56760696e-02f, 1.53793916e-01f, 8.25840458e-02f, 2.60880981e-02f,
  -1.49530947e-01f, -1.11365288e-01f, -1.06403213e-02f, 4.65792082e-02f, 1.27110362e-01f, 1.29489928e-01f, 2.68360320e-02f, 1.01989396e-01f, 1.04584582e-01f, 9.34010074e-02f,
  6.45655096e-02f, 8.29429477e-02f, 1.77199051e-01f, 1.18927792e-01f, 5.87982358e-03f, 7.33690336e-03f, 1.29072025e-01f, -1.27950519e-01f, 1.09052978e-01f, -1.06265813e-01f,
  1.03104882e-01f, -7.98090771e-02f, -1.02211069e-02f, 1.22852929e-01f, 8.71659666e-02f, 2.53400244e-02f, -2.20947433e-02f, -6.28007278e-02f, -7.19119422e-03f, -1.00728180e-02f,
  1.73848405e-01f, 1.55098796e-01f, -1.99511826e-01f, 1.22348547e-01f, 3.80993783e-02f, 7.22286627e-02f, -3.57212801e-03f, 9.50001851e-02f, 1.50800198e-01f, 1.82465911e-02f,
  -4.66616079e-02f, 1.66118115e-01f, 1.92212150e-01f, -1.09816879e-01f, 1.31584167e-01f, 9.00254920e-02f, 2.07067542e-02f, -7.24802464e-02f, 1.07376268e-02f, 2.21592560e-01f,
  3.01933885e-02f, -1.43846720e-02f, 6.90092333e-03f, -4.73504327e-03f, 5.22641242e-02f, -1.77556556e-02f, 1.71488047e-01f, -6.80978298e-02f, -8.61972719e-02f, 6.86283857e-02f,
  -3.37154269e-02f, 2.61272267e-02f, 5.23207933e-02f, 2.05214769e-02f, -1.04621068e-01f, 4.74863052e-02f
};

// L1_fan_Wp_bar (Shape: 26 x 64)
const int L1_fan_Wp_bar_rows = 26;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  3.38706858e-02f, -3.76066752e-02f, -2.02560890e-03f, 5.74738085e-02f, 2.09125485e-02f, 1.94172159e-01f, 1.06468298e-01f, -5.95776457e-03f, -1.28316041e-02f, -2.41487212e-02f,
  1.82791516e-01f, -2.16869414e-02f, 2.62792464e-02f, 1.09878927e-03f, 3.53627466e-02f, -1.86249129e-02f, -7.01419264e-02f, 4.69162408e-03f, 1.71475783e-01f, -2.17371155e-02f,
  -1.46184027e-01f, -7.75007755e-02f, -3.21772210e-02f, 2.37352282e-01f, -4.77116406e-02f, -2.22196467e-02f, 6.64653676e-03f, 7.50920996e-02f, 1.79966986e-01f, 2.16977030e-01f,
  -2.32502967e-01f, 2.14498088e-01f, 2.79998243e-01f, 5.18054329e-02f, 1.17278196e-01f, 1.25503033e-01f, -9.80248004e-02f, -3.96689549e-02f, -1.54151663e-01f, 2.07800660e-02f,
  2.15618327e-01f, -1.98484033e-01f, 3.48579258e-01f, -2.56020963e-01f, 3.43451537e-02f, -4.79208827e-02f, -7.33355433e-02f, -3.98464948e-02f, -1.59355447e-01f, -1.01623259e-01f,
  2.33360585e-02f, 1.06401540e-01f, -1.53602604e-02f, 2.15460230e-02f, 5.38122132e-02f, 1.11909375e-01f, -1.62079290e-01f, -1.90859899e-01f, 1.05042361e-01f, 3.48152928e-02f,
  -1.02072440e-01f, -9.83417779e-02f, -5.53179942e-02f, 1.79047242e-01f, 3.70338149e-02f, 8.10743496e-03f, 9.18191895e-02f, 2.62520537e-02f, 8.76853764e-02f, 9.35673341e-02f,
  -2.49547581e-03f, 1.04461797e-01f, 4.90969308e-02f, 5.20079695e-02f, -2.33120378e-02f, -2.06029266e-02f, 1.25329286e-01f, 1.65714636e-01f, 5.76998815e-02f, 1.28412411e-01f,
  7.44122788e-02f, 1.06565095e-01f, -8.33970904e-02f, -2.93787685e-03f, 1.45880701e-02f, 2.06043780e-01f, -2.90749092e-02f, -1.52267858e-01f, -5.11107072e-02f, 6.29020855e-02f,
  8.21824595e-02f, -7.49314278e-02f, -4.24771868e-02f, 7.81130716e-02f, 2.75873482e-01f, -1.93451971e-01f, -1.03020169e-01f, 9.53098480e-03f, -1.37797266e-01f, -1.10460050e-01f,
  1.78606007e-02f, 1.11264400e-01f, 2.39998937e-01f, 1.82565041e-02f, 5.71712777e-02f, -1.00882918e-01f, -2.18599975e-01f, 1.53548270e-01f, -1.26903318e-03f, -6.78078979e-02f,
  1.58383965e-01f, 3.47074941e-02f, 1.01550318e-01f, -1.18628815e-01f, -1.13337837e-01f, -4.00687680e-02f, -6.64293617e-02f, 1.34139076e-01f, 1.78135987e-02f, -5.28685190e-02f,
  7.36226235e-03f, 2.56299555e-01f, 1.04108239e-02f, -1.88823938e-02f, -1.38066307e-01f, 1.54617801e-01f, -4.40501496e-02f, 8.88787508e-02f, -1.34603113e-01f, 2.45195478e-02f,
  2.84447018e-02f, -1.81435235e-02f, 4.43331897e-02f, 1.74343232e-02f, -1.63181522e-03f, -4.82933819e-02f, -3.92360128e-02f, 4.71836627e-02f, 1.35202616e-01f, 6.40306473e-02f,
  1.93265714e-02f, 8.21618065e-02f, -3.04041672e-02f, 1.19951554e-02f, 5.75735047e-02f, -6.02769759e-03f, 3.37676518e-02f, -4.43613082e-02f, 8.98194015e-02f, 1.56519338e-02f,
  8.84518549e-02f, -3.60952094e-02f, -1.36925653e-02f, -5.03134951e-02f, -8.12365487e-02f, -1.08829960e-01f, -1.33025926e-02f, 1.59805287e-02f, -4.66633253e-02f, -1.42058386e-02f,
  -2.83412896e-02f, 2.36860123e-02f, -4.46597412e-02f, 8.78855363e-02f, 1.86410397e-02f, -7.25662783e-02f, -4.22526784e-02f, 1.85281076e-02f, 7.03613833e-02f, 8.13888386e-02f,
  7.56517723e-02f, -6.63337931e-02f, 9.12508145e-02f, 2.22755089e-01f, 9.26385820e-02f, 2.23448575e-02f, 4.84149083e-02f, -5.06719463e-02f, -5.97492382e-02f, 9.09698829e-02f,
  -6.43407032e-02f, -3.86728393e-03f, 9.57281739e-02f, -3.14210579e-02f, -1.17042944e-01f, -5.48612177e-02f, -1.29180467e-02f, 1.28438324e-01f, 1.00725204e-01f, -1.05761411e-02f,
  -4.30211276e-02f, -8.52960497e-02f, 1.76015645e-01f, 1.60931677e-01f, 1.87252373e-01f, 4.61257994e-02f, 1.22898698e-01f, 1.48304313e-01f, 1.53124509e-02f, 1.14094332e-01f,
  6.61549345e-02f, -1.86610185e-02f, -9.20590237e-02f, 8.49091262e-02f, 1.04003111e-02f, 4.99500185e-02f, 2.00103270e-03f, 9.70898047e-02f, 1.48124071e-02f, 1.75559238e-01f,
  -2.67199576e-02f, -1.27583563e-01f, -2.20298562e-02f, -6.96956068e-02f, -1.69712320e-01f, 5.45763969e-02f, -2.30541695e-02f, -4.03332664e-03f, 1.53286606e-01f, 8.34741965e-02f,
  -9.38528553e-02f, -8.00053924e-02f, 2.38288678e-02f, 3.92959490e-02f, -1.28491685e-01f, -2.34412756e-02f, 1.11400425e-01f, -9.41806138e-02f, 4.74790223e-02f, 3.26960199e-02f,
  1.25749186e-01f, -8.83030593e-02f, -2.02698588e-01f, 1.62822664e-01f, -4.14989069e-02f, -5.14407679e-02f, -1.56481758e-01f, -1.96446553e-01f, -5.09044826e-02f, -8.24397281e-02f,
  1.53558969e-01f, 2.18089744e-01f, 1.80279195e-01f, -7.70174041e-02f, 9.73510295e-02f, -1.40748955e-02f, -1.32550314e-01f, 1.14522107e-01f, 3.21571231e-02f, -1.02317585e-02f,
  9.31489617e-02f, -2.00628936e-01f, 7.12383166e-02f, -2.65510231e-02f, 2.05138594e-01f, 1.81591555e-01f, -1.28771111e-01f, -2.36045308e-02f, 1.18545249e-01f, 9.87990126e-02f,
  -1.23250879e-01f, 8.33293945e-02f, 2.35157758e-02f, -6.08736016e-02f, -1.74334347e-02f, 1.33797556e-01f, 1.34354517e-01f, 5.29457368e-02f, 4.49835137e-02f, 4.34848852e-02f,
  4.10738662e-02f, -3.17464620e-02f, 1.05048120e-01f, -4.20048200e-02f, 5.83894402e-02f, -3.63967754e-02f, 2.36767784e-01f, 2.18174875e-01f, 2.75098663e-02f, -1.23722121e-01f,
  1.59743410e-02f, 2.53876984e-01f, -2.49090612e-01f, -1.16782613e-01f, 3.19478326e-02f, -1.10266700e-01f, 1.54897138e-01f, -1.57465637e-02f, -1.66777283e-01f, 8.73402357e-02f,
  -2.38175422e-01f, -9.49552953e-02f, -1.31875621e-02f, -1.78527460e-01f, -6.28920086e-03f, 6.33136928e-02f, 4.12812024e-01f, -1.10128626e-01f, 7.63097778e-02f, -1.82159105e-03f,
  2.32900903e-01f, -8.25942531e-02f, 1.83562487e-01f, 5.19786365e-02f, 2.26344615e-01f, -1.75701797e-01f, -1.69705957e-01f, -1.48637928e-02f, -1.15059704e-01f, 3.61015946e-02f,
  1.77659050e-01f, -2.29525920e-02f, 5.58884107e-02f, -1.09096445e-01f, -6.12260178e-02f, 3.09900790e-02f, -1.01401731e-01f, -1.56515375e-01f, -7.39642605e-02f, 2.81520307e-01f,
  2.75039431e-02f, 4.03799675e-02f, -8.05913731e-02f, 9.16432887e-02f, 3.07613611e-02f, 9.77995917e-02f, 1.08529016e-01f, 8.01841095e-02f, -4.63082194e-02f, 7.44253993e-02f,
  1.17332995e-01f, 1.49775624e-01f, 5.91107234e-02f, 6.85261488e-02f, 3.59571986e-02f, -1.34423733e-01f, 4.75273877e-02f, -6.29420504e-02f, 1.21250644e-01f, 1.07238792e-01f,
  -7.75630623e-02f, 6.70579299e-02f, 5.79936244e-02f, 8.25292990e-02f, -3.35157737e-02f, -5.00207171e-02f, -2.08842102e-02f, -3.65028083e-02f, 1.61015660e-01f, 1.60170853e-01f,
  -8.10222775e-02f, -2.40543336e-02f, 8.80680233e-02f, -7.14887958e-03f, 8.21475983e-02f, 1.60233676e-01f, -3.48933823e-02f, -8.19105282e-02f, 7.92818144e-02f, 2.40580309e-02f,
  7.12778345e-02f, -1.55274853e-01f, 1.48679242e-01f, 1.11405991e-01f, 7.97786564e-02f, 1.36656076e-01f, -8.61496404e-02f, 1.31356761e-01f, -1.13231167e-01f, -1.89310193e-01f,
  -8.90696943e-02f, 2.39207819e-02f, -9.20821950e-02f, 1.10041693e-01f, 1.42826632e-01f, 3.00422367e-02f, -1.02201611e-01f, 5.45680560e-02f, 9.27150436e-03f, 5.69060259e-02f,
  -5.28534204e-02f, 2.34188765e-01f, -7.10691661e-02f, -1.78109705e-01f, 2.83817705e-02f, -4.14113887e-02f, -6.01755083e-02f, 2.55442206e-02f, 2.34034523e-01f, -8.14086990e-04f,
  1.10876419e-01f, 1.26939237e-01f, -8.06729272e-02f, 1.73388496e-01f, -3.42572443e-02f, 1.79169029e-01f, 2.21989048e-03f, -4.65738634e-03f, 6.29192293e-02f, 3.92402373e-02f,
  4.67504747e-02f, -1.89825166e-02f, 9.98974144e-02f, 9.74191278e-02f, -2.64060069e-02f, -1.49289772e-01f, 1.50443971e-01f, -1.38509199e-01f, -4.78610881e-02f, -2.75929812e-02f,
  2.75518019e-02f, 3.57534140e-02f, 8.50180984e-02f, -2.80397832e-02f, 6.68927154e-04f, 8.54306594e-02f, -1.85021516e-02f, 1.10813238e-01f, 9.78418142e-02f, 2.56273687e-01f,
  -1.61618933e-01f, -2.55674034e-01f, 2.27051172e-02f, -3.29385046e-04f, -3.22629549e-02f, 1.41916081e-01f, 1.66415766e-01f, 1.21266074e-01f, 9.27181095e-02f, 2.47777373e-01f,
  1.70102399e-02f, 1.35490432e-01f, -3.55200991e-02f, 6.56588376e-02f, 5.23178503e-02f, 2.16557384e-01f, -7.09485337e-02f, -9.85374954e-03f, 6.46290705e-02f, -2.79491041e-02f,
  -1.29961431e-01f, 4.84556109e-02f, -1.12328976e-01f, 1.11450113e-01f, 6.72831759e-02f, 2.39159480e-01f, 1.41143007e-02f, -3.17659229e-01f, -1.53225601e-01f, 4.77228500e-02f,
  1.06127858e-01f, 4.48242621e-03f, -6.62333518e-02f, 9.99922678e-02f, 1.29839256e-01f, 3.51773202e-02f, -9.41215307e-02f, 9.02773663e-02f, 1.24552496e-01f, 1.09939232e-01f,
  -3.77396471e-04f, 1.09811261e-01f, 3.44452970e-02f, -5.95197305e-02f, 9.03910175e-02f, -5.39671890e-02f, 1.77534688e-02f, 5.63010164e-02f, 2.00624764e-01f, 1.84285477e-01f,
  4.65858877e-02f, -1.33983102e-02f, 4.29738872e-02f, 3.90538424e-02f, -1.81329325e-01f, -5.42698838e-02f, -9.80173796e-03f, 2.24000285e-03f, 2.84975283e-02f, 2.07602209e-03f,
  -1.14600793e-01f, 3.89565639e-02f, -1.23484664e-01f, 3.31631787e-02f, 1.14479154e-01f, -9.70322937e-02f, 2.94245631e-02f, 2.54356153e-02f, 3.14775765e-01f, 6.06092550e-02f,
  -2.43495987e-03f, -3.36311087e-02f, 1.18334651e-01f, 4.35410179e-02f, 1.10178046e-01f, 1.26589686e-01f, 1.49515778e-01f, -1.81772057e-02f, -5.36403805e-03f, -8.49920884e-02f,
  -7.42729604e-02f, 1.27481343e-02f, 2.51785487e-01f, -3.78104113e-02f, -7.20761791e-02f, 9.89510771e-03f, -4.04090099e-02f, 8.41931626e-02f, 3.70683149e-02f, -6.89919144e-02f,
  -3.58573422e-02f, 1.41941838e-03f, 2.19401821e-01f, 1.16554117e-02f, 1.42103165e-01f, 1.11922354e-01f, 2.80403392e-03f, 8.50300193e-02f, 3.50773670e-02f, 1.13755651e-01f,
  1.58200651e-01f, -1.17484100e-01f, -1.22357607e-01f, 1.70839615e-02f, -1.77300051e-02f, 7.08797947e-02f, 6.67908713e-02f, 1.34808630e-01f, -6.28686175e-02f, 1.16289720e-01f,
  -2.28699595e-02f, -2.21132599e-02f, -1.38592541e-01f, 3.50480750e-02f, -1.42835274e-01f, 1.49603292e-01f, -4.01563831e-02f, -1.46374786e-02f, 7.47652724e-02f, 7.49081448e-02f,
  -9.94484988e-04f, 2.44992636e-02f, -1.14974506e-01f, -9.85422358e-02f, 7.03997090e-02f, -1.71461806e-01f, -4.06077839e-02f, -1.48434833e-01f, -7.59811923e-02f, 1.69778109e-01f,
  1.24931082e-01f, 3.61901410e-02f, -2.06266627e-01f, 4.94070202e-02f, -8.86583179e-02f, 1.02334440e-01f, -1.06199108e-01f, -6.41977862e-02f, -6.55330494e-02f, -1.41905313e-02f,
  -7.84197822e-02f, -6.18811511e-02f, 7.22239316e-02f, -3.73063399e-03f, 1.27461210e-01f, 7.19978213e-02f, -2.03272149e-01f, 2.60109812e-01f, 1.94098651e-01f, 2.13717595e-01f,
  2.51676887e-01f, -1.12082712e-01f, -9.14737061e-02f, 7.49850422e-02f, 8.28597173e-02f, 1.54017627e-01f, 6.29366115e-02f, 1.68564320e-01f, 1.42834455e-01f, 1.53297752e-01f,
  -2.77323741e-02f, 1.67350784e-01f, 1.33054554e-01f, 1.26512930e-01f, 5.50921299e-02f, 4.07520495e-02f, 1.21338502e-01f, 5.39233573e-02f, -5.17832674e-02f, 4.57181558e-02f,
  2.91596144e-01f, 1.97905406e-01f, 9.36257839e-02f, 9.69735032e-04f, -5.69093451e-02f, -1.33679315e-01f, 9.89983417e-03f, 3.40593122e-02f, -4.42369953e-02f, 1.33571938e-01f,
  -1.22492135e-01f, -3.30733001e-01f, -3.78240049e-02f, 1.46594733e-01f, 3.60166728e-02f, 8.69860724e-02f, -1.28900126e-01f, -1.03265960e-02f, 1.32849917e-01f, -7.82385617e-02f,
  1.84321240e-01f, -1.48754105e-01f, 4.71946806e-01f, 3.24248552e-01f, -1.75333470e-01f, 9.41040963e-02f, -4.33471799e-02f, 8.65878016e-02f, 1.97850093e-02f, -1.32037044e-01f,
  -7.80853704e-02f, -1.29881039e-01f, -7.41119534e-02f, 2.28467956e-01f, 4.56150807e-02f, 4.72034842e-01f, 3.48104179e-01f, -2.35501602e-02f, -7.64874592e-02f, -1.33763492e-01f,
  -1.06628790e-01f, -4.07977551e-01f, -1.10926768e-02f, -4.91403267e-02f, -9.14134309e-02f, -1.11633614e-01f, 2.22074211e-01f, -3.59813184e-01f, -1.83129322e-03f, -6.14096336e-02f,
  2.10097253e-01f, 8.81087705e-02f, 1.67380139e-01f, 1.12152457e-01f, -3.12283691e-02f, 1.12336218e-01f, -2.67749019e-02f, 6.67514727e-02f, 1.54323742e-01f, -1.67194441e-01f,
  1.20090125e-02f, 1.02113392e-02f, -5.70500977e-02f, -1.63701475e-01f, 2.01071263e-03f, 1.37315407e-01f, -1.45220116e-03f, -7.75213912e-02f, 1.06044576e-01f, -2.77676843e-02f,
  -2.20242999e-02f, -1.36071399e-01f, 2.24402342e-02f, 1.97333366e-01f, -7.90343562e-04f, -8.24668929e-02f, 9.23618823e-02f, 3.50343343e-03f, 5.01494892e-02f, -1.02034016e-02f,
  -2.62370706e-01f, 9.20494720e-02f, 1.11458018e-01f, 2.64925752e-02f, 1.43601909e-01f, -3.14211175e-02f, 7.72857517e-02f, 4.48480695e-02f, -8.80335420e-02f, 1.28203392e-01f,
  -1.24465413e-02f, 1.24862149e-01f, 6.35705218e-02f, -1.55917525e-01f, -1.11535311e-01f, -9.54891816e-02f, -5.27202897e-02f, 1.12066520e-02f, -7.72369951e-02f, 1.37782916e-02f,
  3.90119962e-02f, -1.31247938e-02f, 9.65334550e-02f, -7.94735104e-02f, -1.73581868e-01f, 2.01939568e-01f, 6.20542914e-02f, -7.82675818e-02f, 1.96999282e-01f, -6.44553602e-02f,
  1.95264295e-02f, -1.19229211e-02f, 9.89695489e-02f, 1.94618583e-01f, 7.21945092e-02f, 1.33965090e-01f, 1.73536077e-01f, -4.46639583e-02f, 2.77956277e-02f, -7.04412237e-02f,
  -2.13811845e-01f, 3.60854007e-02f, 8.01041350e-02f, 1.83866650e-04f, 1.31372482e-01f, -2.36459486e-02f, -2.92499941e-02f, 7.80012310e-02f, -3.36455815e-02f, 2.92319320e-02f,
  2.19438579e-02f, 1.84888884e-01f, -1.05586208e-01f, 1.11078508e-02f, 1.99209705e-01f, -2.69200150e-02f, 1.36876240e-01f, -1.94200739e-01f, 1.01071589e-01f, -1.39696756e-02f,
  2.92642973e-02f, -2.82778978e-01f, -1.47811681e-01f, -2.95765132e-01f, 1.41264349e-01f, -1.51213229e-01f, -2.56741285e-01f, 5.45496829e-02f, -8.16562772e-02f, -6.55002445e-02f,
  9.85998139e-02f, -1.54935628e-01f, 1.89731382e-02f, -1.96056273e-02f, -9.83678326e-02f, 3.20334285e-01f, -2.11504400e-01f, -8.50019976e-03f, 1.20097145e-01f, 2.06110537e-01f,
  1.87028825e-01f, -2.46352658e-01f, 2.27103099e-01f, -1.38389528e-01f, -1.62923336e-01f, 8.31172764e-02f, 1.51082918e-01f, 9.37202200e-02f, -6.36485368e-02f, 6.95938021e-02f,
  6.11097924e-02f, -2.49078378e-01f, 3.97865139e-02f, 1.12926304e-01f, 1.75976291e-01f, -1.75472394e-01f, 1.26387164e-01f, 1.08878426e-01f, 7.71852955e-02f, 8.65799654e-03f,
  9.44579616e-02f, -3.54070100e-03f, 3.26445810e-02f, 1.14415780e-01f, 2.02603370e-01f, 1.13837466e-01f, 1.05712645e-01f, 1.40208751e-01f, -6.63111336e-04f, 9.64517519e-02f,
  1.30626574e-01f, -1.45957664e-01f, 6.33822083e-02f, -3.00221760e-02f, 3.74619775e-02f, -8.76259641e-04f, 1.96998343e-01f, 2.41567623e-02f, -1.37900516e-01f, -1.25040561e-01f,
  7.90776983e-02f, 1.05536081e-01f, 5.84141202e-02f, -1.10159181e-02f, -5.97791858e-02f, 1.14844099e-01f, 1.29918203e-01f, 2.16932017e-02f, -1.98627293e-01f, 2.23569050e-01f,
  5.44196256e-02f, 4.65482846e-03f, 2.41963446e-01f, 8.81204307e-02f, -5.92126921e-02f, -3.30008119e-02f, -1.45594880e-01f, -4.80438396e-02f, 1.62632689e-01f, -1.23310067e-01f,
  3.34725618e-01f, -1.60546318e-01f, 8.68923217e-02f, -1.11366928e-01f, -8.98857117e-02f, 4.15029451e-02f, -1.65584207e-01f, 1.79269686e-01f, 2.20875874e-01f, 1.20318659e-01f,
  -3.57298553e-02f, 5.77412620e-02f, 1.29570767e-01f, -5.30564040e-02f, -7.90700912e-02f, -3.12901676e-01f, -3.16228494e-02f, -7.05482438e-02f, 9.73881781e-03f, 4.17242236e-02f,
  -5.91573790e-02f, 8.68347362e-02f, -2.95365732e-02f, -4.49145213e-03f, 1.79818482e-03f, 3.42427380e-02f, 1.23927884e-01f, 1.19842969e-01f, 1.88727871e-01f, 3.65373418e-02f,
  -4.64445651e-02f, 9.53574106e-02f, 1.90582518e-02f, 9.69080403e-02f, 6.88995942e-02f, 1.02413796e-01f, 9.59023237e-02f, -1.18131213e-01f, -6.19223006e-02f, 8.78830329e-02f,
  8.02742615e-02f, 1.24278568e-01f, -1.18827626e-01f, 3.61893885e-02f, 4.56354916e-02f, 4.77659702e-02f, 5.63896820e-02f, 4.31664549e-02f, 6.69995695e-02f, 1.14768960e-01f,
  1.41106293e-01f, 2.46889457e-01f, -2.44077742e-02f, 1.52391847e-03f, 3.98011953e-02f, 4.12733145e-02f, 3.69688608e-02f, 1.93715036e-01f, -1.50821358e-01f, -1.02403294e-02f,
  1.03415191e-01f, -5.91290779e-02f, 1.87646583e-01f, -2.06386775e-01f, 2.37932757e-01f, 1.40604869e-01f, 4.68132868e-02f, -3.70040862e-03f, -1.34398535e-01f, 1.27855852e-01f,
  -6.70863986e-02f, -1.97283328e-01f, -5.14923446e-02f, 1.50073573e-01f, -4.50970195e-02f, 1.75863624e-01f, 1.26898110e-01f, 9.58759636e-02f, 2.79205088e-02f, 7.85348639e-02f,
  1.15377188e-01f, -3.49511988e-02f, -1.35204837e-01f, 2.05438972e-01f, -6.20809607e-02f, -3.44252326e-02f, -9.24435630e-02f, 1.15636423e-01f, 7.19409734e-02f, 1.47681043e-01f,
  1.23791695e-01f, 1.00877494e-01f, 1.07637048e-01f, 5.65217957e-02f, -3.39979902e-02f, 4.53824401e-02f, 8.33337978e-02f, 6.27634302e-02f, 3.91032547e-02f, 1.89478695e-01f,
  1.15132250e-01f, 1.28561007e-02f, -5.92875015e-03f, -1.48047283e-02f, -2.16535758e-02f, 1.38721541e-01f, 6.26330897e-02f, 2.12719381e-01f, 1.26867173e-02f, 1.11905143e-01f,
  -3.70004214e-02f, -1.46525711e-01f, -7.96595402e-03f, -4.08640914e-02f, 1.97000772e-01f, 1.22667164e-01f, -1.62398577e-01f, -1.03598595e-01f, 3.84252705e-02f, 1.93876792e-02f,
  -4.90217935e-03f, 1.92178831e-01f, 1.26654744e-01f, -4.13441248e-02f, -1.93402190e-02f, 6.53937533e-02f, 2.16507927e-01f, -9.35556889e-02f, 5.60412146e-02f, 1.98077485e-01f,
  8.64850208e-02f, 9.16252434e-02f, -7.61393011e-02f, 2.11217821e-01f, -1.47543207e-01f, -1.14341915e-01f, -1.09937526e-01f, -6.54542353e-03f, -5.11559844e-02f, 3.98879731e-03f,
  8.31097066e-02f, -8.12016726e-02f, -1.53332815e-01f, 2.02637166e-01f, -9.95538086e-02f, 1.86792370e-02f, 5.48384152e-02f, 1.18763573e-01f, -1.13849424e-01f, -2.45320097e-01f,
  -5.91752417e-02f, 5.76569177e-02f, 1.11742899e-01f, -1.15844026e-01f, 1.36753554e-02f, -7.53263831e-02f, -8.62719491e-02f, -3.25544272e-03f, -3.30094583e-02f, 9.28965956e-02f,
  -3.97819765e-02f, 5.27062900e-02f, 6.37409762e-02f, 9.87208039e-02f, -5.79248592e-02f, -5.09913173e-03f, -1.36814425e-02f, 7.05134645e-02f, 6.43593520e-02f, 4.47270721e-02f,
  -2.11797636e-02f, -3.28760073e-02f, 5.60252033e-02f, -1.27864107e-01f, 6.61223307e-02f, 6.72396272e-02f, -2.99825910e-02f, -1.27223223e-01f, -1.10790826e-01f, -6.65690079e-02f,
  1.12575531e-01f, -1.30414277e-01f, -9.68624949e-02f, 2.72511132e-02f, -1.42593071e-01f, -6.98051527e-02f, -6.57231957e-02f, 1.60798095e-02f, 1.29040346e-01f, 8.04708451e-02f,
  -7.12681860e-02f, 1.97521850e-01f, -1.84620902e-01f, 1.54904842e-01f, -2.34644320e-02f, 1.35458887e-01f, 1.11304089e-01f, -1.21701494e-01f, 3.05913184e-02f, -1.81728080e-01f,
  -9.21169668e-02f, 7.82388672e-02f, 1.19647481e-01f, 1.82900205e-01f, -1.75042730e-03f, 1.00816719e-01f, 7.43808970e-02f, 1.95769086e-01f, 4.37466837e-02f, 1.40015349e-01f,
  1.10273138e-02f, 1.66018531e-01f, 1.09237127e-01f, 6.62713358e-03f, 1.58504188e-01f, -1.08709577e-02f, 1.15704402e-01f, 1.94843784e-02f, 1.94625825e-01f, 1.03523374e-01f,
  7.33553767e-02f, 1.25222743e-01f, -9.19798017e-02f, 1.61674276e-01f, -9.78438407e-02f, 1.47331938e-01f, 1.50059357e-01f, -2.00922295e-01f, 1.24767646e-01f, 1.63136180e-02f,
  -7.72359893e-02f, 1.03830755e-01f, 1.24251999e-01f, 1.16373941e-01f, -1.21581361e-01f, -2.69328296e-01f, 1.55295044e-01f, -1.38414472e-01f, -7.49716684e-02f, 3.96555737e-02f,
  1.13907561e-01f, 2.03628987e-01f, -6.89203897e-03f, -1.06646299e-01f, 1.87816471e-02f, 2.04745680e-01f, 1.77513827e-02f, 1.98794529e-02f, 1.90941066e-01f, 1.80558488e-01f,
  -5.46526052e-02f, -1.03130482e-01f, -1.81007415e-01f, -2.14012619e-02f, -1.41386256e-01f, 1.05251692e-01f, 1.40577674e-01f, -8.59499350e-02f, -4.16963845e-02f, -2.82492843e-02f,
  -1.03037663e-01f, -4.04491648e-02f, 5.17524080e-03f, 2.56624609e-01f, 1.61187470e-01f, 9.54896882e-02f, -1.50701851e-01f, -2.42576208e-02f, -3.44120972e-02f, -1.38391435e-01f,
  -3.80006768e-02f, -2.67934084e-01f, -1.53784052e-01f, -5.01538403e-02f, 1.23699956e-01f, 8.82393122e-02f, 2.42063198e-02f, -1.68182194e-01f, -1.15186982e-01f, 1.18719146e-01f,
  2.05170482e-01f, 1.13417074e-01f, -1.42559260e-02f, 3.22901569e-02f, -2.98476014e-02f, 1.97056960e-02f, 7.37511516e-02f, 2.00765610e-01f, 1.45849511e-01f, 1.63668528e-01f,
  6.91004470e-02f, 1.07328624e-01f, 2.92569585e-02f, 1.25975326e-01f, 1.20795786e-01f, 4.97040376e-02f, 2.06537470e-02f, -7.15379417e-02f, 1.97406352e-01f, 1.11523308e-01f,
  5.06401546e-02f, -1.48149133e-01f, 4.38477024e-02f, -7.63892755e-02f, -7.95718953e-02f, -8.74879733e-02f, -7.30477497e-02f, -1.52037382e-01f, -1.92427095e-02f, -7.23794103e-02f,
  -1.27788633e-01f, 2.84115560e-02f, -5.64970635e-02f, -2.94905510e-02f, 2.03552410e-01f, -1.02621779e-01f, 4.11143489e-02f, 9.21200812e-02f, 1.39935628e-01f, 2.64850646e-01f,
  -1.06239796e-01f, -1.22701330e-02f, 1.37600988e-01f, 9.46493447e-02f, 1.84079841e-01f, 5.70314080e-02f, 1.92301482e-01f, 9.04468819e-02f, 9.62295756e-03f, -1.17671870e-01f,
  8.63314718e-02f, 4.43724282e-02f, 6.90903962e-02f, -8.44392404e-02f, -9.23597906e-03f, -4.86681387e-02f, -1.09204873e-01f, 7.66959563e-02f, 8.55261013e-02f, -5.47988005e-02f,
  1.80384710e-01f, -1.72287710e-02f, 2.86028564e-01f, 1.69540778e-01f, 1.54702187e-01f, 4.23965603e-03f, 7.60285035e-02f, 1.67741235e-02f, 7.49988528e-03f, 1.19845659e-01f,
  1.60971805e-01f, -1.67637974e-01f, 4.91967872e-02f, 2.11887117e-02f, 1.15311444e-02f, -1.45484116e-02f, 5.84655516e-02f, 1.31148294e-01f, 4.06655930e-02f, 1.25895321e-01f,
  -4.23950441e-02f, -1.66878000e-01f, -1.11163542e-01f, -7.92735368e-02f, -1.21493161e-01f, 1.54461816e-01f, 2.03760788e-02f, 4.76287603e-02f, 1.35269314e-01f, -5.34350164e-02f,
  -5.56622744e-02f, -5.96488267e-02f, -1.00868605e-01f, -3.37877460e-02f, 1.72706470e-01f, -1.00153103e-01f, 2.99340542e-02f, -2.16765657e-01f, 2.94746868e-02f, 8.67153034e-02f,
  1.71039365e-02f, 4.92024608e-02f, -1.61862463e-01f, -4.04809415e-02f, 2.27068663e-02f, -8.43449011e-02f, -1.34604231e-01f, -1.06644332e-01f, -1.01367924e-02f, -1.02605440e-01f,
  6.44298494e-02f, -2.14666761e-02f, 3.11877206e-02f, 8.05665646e-03f, 2.01194510e-01f, 4.19910140e-02f, -2.41656110e-01f, 2.01813325e-01f, 8.23921040e-02f, 5.77971116e-02f,
  2.26565182e-01f, -1.37415782e-01f, 1.88541058e-02f, 2.39251424e-02f, 1.39718488e-01f, 2.13417143e-01f, -1.97641060e-01f, 5.13632260e-02f, 5.14731631e-02f, 6.03826530e-02f,
  -1.12168454e-02f, 8.06969181e-02f, 5.24318442e-02f, -5.49158864e-02f, -5.24246469e-02f, 1.89404339e-01f, 1.73198193e-01f, 1.66487768e-01f, 1.12551205e-01f, 2.16173202e-01f,
  1.40928730e-01f, 1.22163862e-01f, 1.87669113e-01f, -7.21224584e-03f, 1.02304267e-02f, 8.09435993e-02f, 2.20483348e-01f, 1.02611274e-01f, 7.91858509e-03f, -1.48713872e-01f,
  -9.23975930e-03f, 3.09825204e-02f, -1.38363093e-01f, 2.80882679e-02f, 1.20531884e-03f, -4.01108339e-02f, 7.46250059e-03f, -6.97441399e-02f, -1.26848534e-01f, 3.51969292e-03f,
  -1.61171138e-01f, 6.28541559e-02f, 1.52951851e-01f, -2.51331329e-02f, 7.48441741e-02f, 1.29201055e-01f, 1.64397463e-01f, 4.78873737e-02f, -6.90751076e-02f, 1.02777183e-01f,
  1.90211922e-01f, 1.05299406e-01f, 1.48748502e-01f, 1.42707720e-01f, 1.39429182e-01f, 5.47278970e-02f, -5.48371598e-02f, -9.53086689e-02f, -1.48008570e-01f, 1.00806765e-02f,
  2.03550041e-01f, -5.11234552e-02f, -7.37166181e-02f, 1.47443756e-01f, -9.25987586e-02f, 1.84843883e-01f, 9.49151367e-02f, 7.67637193e-02f, -4.22322452e-02f, 3.84595655e-02f,
  8.03045854e-02f, 2.56405808e-02f, 3.52137610e-02f, 6.87926961e-03f, -6.47844523e-02f, 7.94211179e-02f, 6.96461722e-02f, -2.96376646e-02f, 4.45194691e-02f, -4.40278240e-02f,
  5.47994711e-02f, -3.17232385e-02f, -5.61460219e-02f, -1.07513860e-01f, -1.46855759e-02f, -7.88047444e-03f, -6.10502288e-02f, -7.71832019e-02f, 1.57255977e-02f, -5.65164164e-02f,
  -2.32177414e-02f, -9.46225300e-02f, -8.36567134e-02f, 1.45076171e-01f, -3.62256728e-02f, -3.22362371e-02f, 4.06118482e-02f, 4.07221392e-02f, 6.21386953e-02f, 5.61639778e-02f,
  -1.49834871e-01f, 1.29864410e-01f, 1.86223119e-01f, -5.35573885e-02f, 1.15628064e-01f, -8.25704932e-02f, 5.37438504e-02f, 1.54316217e-01f, -4.83243428e-02f, 3.39381620e-02f,
  -3.85656618e-02f, -9.78181958e-02f, 7.55952448e-02f, -7.29528964e-02f, -1.02824740e-01f, -8.82648528e-02f, -8.60298127e-02f, -4.26313318e-02f, -3.64047512e-02f, 9.07352716e-02f,
  1.47065192e-01f, 7.13341013e-02f, -1.14004815e-03f, -4.66141254e-02f, -7.28650317e-02f, -5.31708123e-03f, -5.94660044e-02f, -5.03223762e-02f, 5.71465977e-02f, -3.72775160e-02f,
  1.89210828e-02f, -7.25496262e-02f, -6.97349012e-02f, 1.42591730e-01f, -1.22861899e-01f, 7.42059425e-02f, 1.33683354e-01f, 1.00467242e-01f, -7.40935877e-02f, 5.39639369e-02f,
  -9.15749595e-02f, -6.81121647e-02f, 9.37189832e-02f, 1.83285758e-01f, 9.34439301e-02f, 2.97825634e-02f, 4.55336832e-02f, 3.22917812e-02f, -3.03642340e-02f, 1.13206290e-01f,
  5.41890338e-02f, 6.32557943e-02f, -1.11922130e-01f, -3.81483510e-02f, 1.50330111e-01f, 2.20892113e-02f, 5.28517403e-02f, -2.65714288e-01f, 1.00369155e-02f, 1.86780602e-01f,
  -6.87187314e-02f, -1.31976843e-01f, -1.45611107e-01f, -3.34699869e-01f, 1.46736071e-01f, 2.02552956e-02f, -1.06418245e-01f, 1.35256112e-01f, -1.44372657e-01f, -4.27186936e-02f,
  5.84937520e-02f, -1.60813436e-01f, 4.13053334e-02f, -3.17842849e-02f, 1.03817075e-01f, 4.72876467e-02f, -8.97333920e-02f, -7.01060751e-03f, 5.16572557e-02f, 6.29867613e-02f,
  2.39143640e-01f, -7.32133538e-02f, 2.62900531e-01f, -8.92898366e-02f, -1.26381323e-01f, -4.58598079e-04f, -1.46030679e-01f, -6.22638129e-02f, 1.08075500e-01f, -1.46671385e-01f,
  -3.04207802e-02f, -2.03636989e-01f, -4.57362682e-02f, 1.03563353e-01f, 2.71692295e-02f, -1.45021692e-01f, -6.61528856e-02f, 2.44019002e-01f, 2.47031581e-02f, 2.32531875e-03f,
  3.93220633e-02f, -1.11934312e-01f, 9.86742079e-02f, 4.82200310e-02f, 8.10282677e-02f, 1.00922808e-01f, 5.27296588e-02f, -3.53248119e-02f, -1.32243723e-01f, 3.52847092e-02f,
  1.35308481e-03f, 4.76595722e-02f, -4.50299159e-02f, -7.07473932e-03f, 5.03398329e-02f, 7.04443082e-02f, 5.61742261e-02f, 6.09813519e-02f, -5.71160279e-02f, -2.16914583e-02f,
  3.24278213e-02f, -2.17349678e-02f, -6.41145110e-02f, -3.46446633e-02f, 1.10252693e-01f, 1.36297066e-02f, 1.20397483e-04f, 1.19133733e-01f, 9.74183455e-02f, -9.29533169e-02f,
  4.12634900e-03f, 6.51175063e-03f, 3.81219126e-02f, 6.88240007e-02f, -1.67423710e-01f, 2.73869019e-02f, 1.56367421e-01f, -6.72587939e-03f, -2.39278242e-01f, -5.31366691e-02f,
  3.23392376e-02f, 8.88758898e-02f, -6.39981106e-02f, 1.87345058e-01f, 4.92568128e-02f, 4.01188526e-03f, -1.39002292e-03f, -1.28577515e-01f, -5.89751042e-02f, 1.40829220e-01f,
  -9.98107865e-02f, 1.27237901e-01f, -1.07295755e-02f, -1.91707462e-02f, -2.87454929e-02f, 1.14806630e-01f, 1.83292422e-02f, 1.42179221e-01f, 4.20836285e-02f, 2.34297559e-01f,
  -2.23696884e-02f, -1.93539098e-01f, -2.23451674e-01f, -3.12718600e-02f, 3.00306175e-02f, 4.51171175e-02f, 2.34155152e-02f, -5.10956384e-02f, 3.67443115e-02f, -5.54641411e-02f,
  4.64928988e-03f, 1.28680125e-01f, 2.05103159e-02f, 8.67568403e-02f, 6.27736747e-02f, 1.22215174e-01f, -3.99386436e-02f, -5.11901788e-02f, 7.79690221e-02f, 3.61495577e-02f,
  9.39012170e-02f, 1.04017146e-01f, 8.63053501e-02f, 5.60741760e-02f, 8.34272429e-02f, -1.51601937e-02f, -1.16204899e-02f, 2.41525322e-02f, -1.10881858e-01f, -5.92632666e-02f,
  -7.41834519e-03f, -3.49061638e-02f, -8.95436332e-02f, -2.51301005e-02f, 1.01905894e-02f, -1.10150734e-03f, -6.66450933e-02f, 1.96958762e-02f, -6.89771473e-02f, -3.89021039e-02f,
  1.07283190e-01f, 5.27086221e-02f, 7.46715814e-02f, 5.51634617e-02f, 7.28189945e-03f, 2.02784732e-01f, 6.97635859e-02f, 1.77419215e-01f, 1.54875383e-01f, -2.57410631e-02f,
  2.19291411e-02f, -8.12335089e-02f, -8.03597793e-02f, 3.30056548e-02f, -9.90899950e-02f, 3.22702080e-02f, 2.09613308e-01f, 2.18217308e-03f, -7.73059428e-02f, 1.20861679e-01f,
  -6.15706854e-02f, 2.33532667e-01f, 2.44956240e-02f, 1.43592626e-01f, -4.55680639e-02f, 1.72244105e-02f, 1.66851714e-01f, 1.53067723e-01f, -1.07123945e-02f, 8.58355835e-02f,
  8.12584981e-02f, 1.33801410e-02f, -2.94662714e-02f, 5.03586978e-02f, 7.47637376e-02f, -2.10218549e-01f, -8.17397311e-02f, -1.04630165e-01f, 1.01419076e-01f, 1.79017097e-01f,
  -5.54702915e-02f, 8.22446942e-02f, 9.80739892e-02f, 7.56697953e-02f, 6.01761229e-02f, 9.56344306e-02f, -2.95005720e-02f, 1.55568589e-02f, -1.28154442e-01f, -5.46532050e-02f,
  -4.55401242e-02f, -4.27317135e-02f, 1.22371845e-01f, 8.46778881e-03f, -8.95866677e-02f, 6.37574866e-02f, -5.03753312e-02f, -1.83373556e-01f, 1.14124514e-01f, -1.69115171e-01f,
  1.81664694e-02f, -6.17843345e-02f, -1.57250911e-01f, 1.65197536e-01f, 1.89484641e-01f, 8.77040476e-02f, -3.45207959e-01f, 4.83700894e-02f, -2.22295761e-01f, 1.19111694e-01f,
  -1.42852413e-02f, 6.12092391e-02f, 1.40351743e-01f, -9.26214680e-02f, -1.20329773e-02f, -1.65566280e-01f, -2.00395808e-01f, 4.74479981e-02f, 9.36988145e-02f, 9.19683948e-02f,
  -1.19602285e-01f, 2.83352137e-01f, 1.45160154e-01f, 2.87839413e-01f, 2.02283636e-01f, 1.00068882e-01f, 1.35421932e-01f, 2.05317929e-01f, 1.03401043e-01f, -8.28514844e-02f,
  2.52557285e-02f, 1.08698159e-01f, 1.15653634e-01f, -1.84777263e-03f, 5.68469279e-02f, 6.15127347e-02f, -4.63791750e-02f, 1.56134218e-01f, 7.75602758e-02f, 7.43439123e-02f,
  -8.22002515e-02f, 3.03853825e-02f, 1.28433332e-01f, 1.49787650e-01f, 1.38286039e-01f, 1.82175264e-01f, 1.70540616e-01f, 9.00617763e-02f, -1.02990888e-01f, 5.38373506e-03f,
  3.59228589e-02f, 1.72550380e-01f, -6.04178831e-02f, -2.15988755e-01f, -4.15636450e-02f, 1.03949182e-01f, 2.14422435e-01f, -6.85954988e-02f, -1.34029716e-01f, -8.65556952e-03f,
  3.20184469e-01f, -2.80288279e-01f, -5.45850061e-02f, -5.54781929e-02f, -6.71617761e-02f, -1.15215465e-01f, 1.12973094e-01f, 1.81186721e-01f, 2.51457125e-01f, 5.36209196e-02f,
  -2.03119978e-01f, -9.39480141e-02f, -3.56074303e-01f, 1.78006887e-01f, -6.47590682e-02f, -6.15614802e-02f, 2.13907823e-01f, 7.91406780e-02f, 1.89013556e-01f, -1.26387849e-01f,
  -1.96315527e-01f, 6.79405928e-02f, -3.92375700e-02f, 1.26286313e-01f, -2.07228344e-02f, -1.05816081e-01f, 4.21980657e-02f, 3.00660342e-01f, 6.72459677e-02f, -1.68515686e-02f,
  6.65346235e-02f, 7.49716396e-03f, -1.44678112e-02f, 7.69713596e-02f
};

// L1_fan_Bp_bar (Shape: 1 x 26)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 26;
const float L1_fan_Bp_bar_data[] = {
  1.29480451e-01f, 1.22943491e-01f, -1.31347440e-02f, 8.37953016e-02f, 5.21069095e-02f, 7.57389069e-02f, -1.78045165e-02f, 4.69674617e-02f, 1.15569495e-01f, 3.96655053e-02f,
  1.22520782e-01f, 3.58495302e-02f, 2.49969196e-02f, 5.87968826e-02f, 1.97017845e-03f, 2.85111740e-02f, 4.02131826e-02f, 7.82178044e-02f, 9.80933830e-02f, 1.05346657e-01f,
  1.31607186e-02f, -1.26047432e-02f, -1.70268416e-02f, 4.36846819e-03f, 6.51760101e-02f, 9.99565646e-02f
};

// L2_fan_Wp (Shape: 19 x 64)
const int L2_fan_Wp_rows = 19;
const int L2_fan_Wp_cols = 64;
const float L2_fan_Wp_data[] = {
  1.26457876e-02f, 2.67948955e-02f, -6.06645073e-04f, 8.13246295e-02f, 7.46141151e-02f, 4.25202474e-02f, -4.82322872e-02f, 6.44976944e-02f, 2.27666050e-02f, 9.50493217e-02f,
  4.82835434e-02f, 8.05401877e-02f, -8.38958658e-05f, -2.85108704e-02f, 5.91489375e-02f, 4.49959785e-02f, 5.52726761e-02f, 8.06861222e-02f, -2.77826469e-02f, -9.97934341e-02f,
  7.04938173e-02f, -3.69552430e-03f, 3.23449895e-02f, -7.03646615e-02f, 1.07851729e-01f, -2.96418890e-02f, 8.17148946e-03f, -7.97802061e-02f, 6.37577251e-02f, -8.50813538e-02f,
  5.02082333e-02f, -1.85574349e-02f, 5.70976734e-02f, -8.91351476e-02f, -7.39730382e-03f, -4.62949686e-02f, -2.31129080e-02f, -1.34967528e-02f, 1.63324907e-01f, -2.46522538e-02f,
  7.21631050e-02f, 3.62560637e-02f, -1.46281794e-01f, 1.30513445e-01f, 1.44493893e-01f, -3.96837406e-02f, 2.56962073e-03f, -1.05121367e-01f, 2.70853881e-02f, -1.63681105e-01f,
  1.33241743e-01f, 1.31144181e-01f, 8.62553716e-02f, -5.86741641e-02f, 6.95842579e-02f, -3.73801701e-02f, -2.05425341e-02f, -6.92119002e-02f, 7.60622136e-03f, -1.61964029e-01f,
  1.30606055e-01f, -3.44538800e-02f, 9.90779847e-02f, -1.37271225e-01f, 6.81490302e-02f, -3.76518294e-02f, 8.55729282e-02f, 3.34871896e-02f, 1.22699246e-01f, 3.39114070e-02f,
  1.04174539e-01f, 6.10007308e-02f, 1.21078722e-01f, 1.08240165e-01f, 1.28318295e-02f, -2.99958456e-02f, -4.40905103e-03f, 1.92496348e-02f, 1.26690656e-01f, 7.69145340e-02f,
  -1.57874078e-02f, -8.46626610e-03f, -3.13167423e-02f, -3.13897245e-02f, 9.29674059e-02f, 5.13993436e-03f, -4.64100800e-02f, -8.49986300e-02f, 7.77402595e-02f, -1.22266285e-01f,
  4.66782562e-02f, 7.10030198e-02f, -1.89595912e-02f, -1.72198519e-01f, -1.26722291e-01f, 1.60384834e-01f, 2.49508452e-02f, 1.16349809e-01f, -8.22208524e-02f, 2.51967572e-02f,
  9.24077909e-03f, -1.84952281e-02f, -5.00071533e-02f, -1.63430702e-02f, 6.66264519e-02f, 1.27774224e-01f, -1.12284631e-01f, -3.42304334e-02f, -1.55345425e-02f, 1.35206641e-03f,
  -2.37967167e-02f, 2.99574912e-01f, 8.82343426e-02f, -6.44921511e-02f, -5.30661345e-02f, -7.23959729e-02f, 2.98474543e-02f, -9.50991139e-02f, 1.36293480e-02f, 4.78456654e-02f,
  5.75221553e-02f, 2.83901412e-02f, 2.18564570e-02f, -1.17109537e-01f, -5.94198592e-02f, -7.78675526e-02f, -3.05399429e-02f, -9.37607139e-02f, 1.05130076e-01f, 8.40976238e-02f,
  1.28586739e-01f, 8.64602905e-03f, 7.90534541e-02f, 3.22145857e-02f, 8.86304490e-03f, 2.65559163e-02f, 1.97585121e-01f, 9.31454003e-02f, 8.54797065e-02f, 3.60255800e-02f,
  -1.09198876e-02f, 5.96125200e-02f, 8.18697587e-02f, 1.27915636e-01f, 2.63422113e-02f, 8.57302472e-02f, 1.12888059e-02f, -5.89082502e-02f, 1.05670899e-01f, -3.14046368e-02f,
  -7.13234618e-02f, -2.40206774e-02f, -1.21263629e-02f, -2.95540728e-02f, -9.76310447e-02f, -2.39550844e-02f, -5.68668619e-02f, -6.79661855e-02f, 3.62458937e-02f, -6.68867156e-02f,
  1.16808638e-01f, 1.52736783e-01f, 6.82067946e-02f, 1.18162088e-01f, -1.47102436e-03f, 6.54437542e-02f, 4.90536913e-02f, 8.53819959e-03f, -3.57600264e-02f, 4.97761257e-02f,
  1.34678096e-01f, -2.75352467e-02f, -3.82013991e-03f, 5.89180589e-02f, -1.27792107e-02f, 1.73510462e-01f, -3.10671218e-02f, -9.71293449e-02f, 1.26780525e-01f, -2.25141481e-03f,
  5.35483882e-02f, -4.98079024e-02f, 1.14795446e-01f, 4.48843464e-02f, -1.03285201e-01f, -3.27825621e-02f, 1.61556583e-02f, 2.30825674e-02f, -6.79260045e-02f, -6.26910180e-02f,
  -1.94582239e-01f, -3.31480578e-02f, 9.00840610e-02f, -2.97363251e-02f, -1.90696623e-02f, -1.02131320e-02f, 1.99705028e-04f, 1.76086519e-02f, 2.64384001e-02f, 3.26793529e-02f,
  1.45017495e-02f, -2.93031074e-02f, 1.59972459e-02f, 3.30793150e-02f, -5.43562956e-02f, 9.11413413e-03f, -6.45296797e-02f, 6.13910854e-02f, -6.92271069e-02f, 4.88946475e-02f,
  4.74536568e-02f, -9.33585614e-02f, 1.12315835e-02f, -5.00734597e-02f, 1.05191702e-02f, -3.72946914e-03f, -1.28423870e-01f, -3.08386050e-02f, -1.04992345e-01f, 8.47461894e-02f,
  -8.69365782e-02f, 9.40576270e-02f, -3.42756696e-02f, -9.30672698e-03f, 2.22959056e-01f, 1.70764357e-01f, 4.60356921e-02f, 1.89635932e-01f, -4.02151309e-02f, 3.39394249e-02f,
  6.14906996e-02f, -3.33092734e-02f, 9.93191153e-02f, 6.42160624e-02f, 1.98385417e-01f, -4.68300618e-02f, 8.81148651e-02f, 1.08595677e-01f, -1.78747818e-01f, -1.56518016e-02f,
  -1.13365240e-01f, 8.20924863e-02f, -1.65872648e-02f, -4.53308225e-02f, -9.71256122e-02f, -4.61534224e-02f, 1.50288403e-01f, 6.42986149e-02f, -5.07216230e-02f, 6.04379512e-02f,
  -5.55594750e-02f, 2.26617500e-01f, -2.26991507e-03f, 2.72337673e-03f, -1.89385355e-01f, 5.26571982e-02f, -5.15236333e-02f, -4.12538320e-05f, -9.23872367e-02f, 5.41482270e-02f,
  -3.52494195e-02f, -1.39785483e-02f, -5.33336177e-02f, -1.05381357e-02f, -8.71408880e-02f, 2.04251148e-02f, 2.50271037e-02f, 3.95973437e-02f, -1.26528740e-02f, -2.17240304e-02f,
  5.19805253e-02f, 1.24074481e-01f, -3.05124726e-02f, 3.64374951e-03f, 2.51811519e-02f, -4.34396714e-02f, 2.39920281e-02f, -1.03586227e-01f, 6.50384426e-02f, 1.23081356e-03f,
  2.95030866e-02f, -7.77635574e-02f, -1.19445421e-01f, -2.05466244e-02f, 8.73208940e-02f, -5.83080389e-02f, 7.43232071e-02f, -8.91462192e-02f, 2.87960231e-01f, -7.24065932e-04f,
  1.57918751e-01f, 1.34482637e-01f, 7.11256415e-02f, 5.59747685e-03f, 8.80459324e-02f, 7.05364645e-02f, 1.25574529e-01f, -7.56007880e-02f, 3.46054859e-03f, 1.36906505e-01f,
  2.48094678e-01f, 3.53358872e-02f, -8.88826624e-02f, -1.18709125e-01f, -1.75730720e-01f, 1.97425820e-02f, 8.06328207e-02f, 7.99986273e-02f, 1.02345929e-01f, 6.43058866e-02f,
  1.58336192e-01f, -3.24267969e-02f, -1.76064596e-01f, 1.30752534e-01f, -8.54218751e-02f, -4.11781780e-02f, 1.10277347e-01f, 1.15479045e-01f, -3.18880267e-02f, -1.04082618e-02f,
  -1.20794199e-01f, -5.55420592e-02f, -5.79314642e-02f, 2.08358106e-04f, -9.08668339e-02f, 4.86427620e-02f, -9.17596593e-02f, -9.36176479e-02f, -1.84648260e-01f, -8.39233994e-02f,
  -3.63479964e-02f, 4.66603339e-02f, 2.07840074e-02f, 4.68062982e-02f, -1.77156478e-01f, -1.03197739e-01f, -9.96364057e-02f, 2.37623584e-02f, 7.08281547e-02f, 1.07070111e-01f,
  -6.87664971e-02f, 9.67179611e-02f, 4.78899963e-02f, -1.71963274e-02f, -3.26615386e-02f, 8.06633905e-02f, 2.51945648e-02f, 4.40969598e-03f, -1.69205305e-03f, 2.31243640e-01f,
  7.78522864e-02f, -1.61767051e-01f, -1.88672885e-01f, -1.47569686e-01f, 5.53000793e-02f, -1.68136626e-01f, 1.76468622e-02f, -3.68071198e-02f, 7.68462243e-03f, 2.70032696e-02f,
  -8.62909406e-02f, 4.13196012e-02f, 1.28341794e-01f, -2.68045422e-02f, -1.60674840e-01f, 4.23240662e-03f, 1.77439690e-01f, -2.92328566e-01f, 4.62407582e-02f, 8.95744041e-02f,
  -2.02674568e-01f, -8.66284072e-02f, -1.86955139e-01f, 1.43097267e-01f, -2.38722637e-01f, 5.59745356e-02f, -1.51521107e-02f, 3.00311986e-02f, -4.60275933e-02f, 1.55136481e-01f,
  -4.68740165e-02f, 8.49410146e-02f, 1.93090439e-01f, 1.39619663e-01f, -2.69332826e-02f, 7.39633068e-02f, -8.42089429e-02f, -3.35569754e-02f, -3.11718602e-02f, 1.08212363e-02f,
  -8.49985890e-03f, -9.14653167e-02f, -6.78039119e-02f, -1.20406076e-01f, 4.86258417e-02f, -5.31603135e-02f, -5.81493974e-02f, 8.62001851e-02f, -9.65550914e-02f, 3.42809148e-02f,
  -1.00954130e-01f, -3.66420229e-03f, 4.22742590e-02f, 1.33003563e-01f, -8.93531889e-02f, -2.74549267e-04f, -1.63747258e-02f, 1.13276010e-02f, -8.64975974e-02f, 3.81888300e-02f,
  -1.13235489e-02f, 5.47734462e-02f, 1.71568114e-02f, 1.81800425e-01f, 2.91063059e-02f, -6.80560470e-02f, 1.29443668e-02f, -8.62292126e-02f, 5.20083234e-02f, 5.74091822e-03f,
  -6.91625029e-02f, 3.57664772e-03f, -1.81002349e-01f, 6.14053719e-02f, -2.46859174e-02f, 3.42890173e-02f, 3.81366573e-02f, -9.32251438e-02f, -4.80526537e-02f, 5.09807020e-02f,
  -3.26290205e-02f, -1.48578972e-01f, -9.49399471e-02f, 2.02533394e-01f, -7.12674931e-02f, -4.66291457e-02f, -7.94999450e-02f, 1.35054037e-01f, -1.42536834e-02f, 1.27193853e-01f,
  8.89770873e-03f, 7.37081319e-02f, -1.09010749e-01f, 1.53442040e-01f, -4.25273404e-02f, 6.40309677e-02f, -1.24793164e-02f, 2.08172500e-01f, -6.19482882e-02f, 4.21637855e-02f,
  1.15950830e-01f, 1.12868823e-01f, -1.60393119e-02f, 5.60912788e-02f, 9.57600772e-02f, -3.10508953e-03f, 1.24473244e-01f, 5.56384120e-03f, -7.30563048e-03f, 7.94723108e-02f,
  3.75537276e-02f, 3.01668122e-02f, -4.27833851e-03f, -1.92612074e-02f, -2.11796071e-03f, 7.03683048e-02f, 5.48478290e-02f, -1.90532923e-01f, 2.20078677e-02f, 8.04715902e-02f,
  8.25058371e-02f, -1.18889622e-01f, -4.82632890e-02f, 2.75758132e-02f, 2.45571546e-02f, -6.06444152e-03f, -5.57011701e-02f, 1.14838757e-01f, 9.53624304e-03f, -2.05520485e-02f,
  2.42296630e-03f, -5.02157621e-02f, -1.70584902e-01f, -7.44371265e-02f, -1.26218155e-01f, 3.80478315e-02f, 1.55621752e-01f, -5.34418691e-03f, -3.51610519e-02f, 8.75487253e-02f,
  8.52493197e-02f, -5.78826480e-02f, -9.51976329e-02f, 4.26001027e-02f, 1.09075479e-01f, -1.20580718e-01f, 1.34197235e-01f, -2.81367507e-02f, 1.94456220e-01f, 7.29436278e-02f,
  -2.07179915e-02f, -6.00953922e-02f, 2.05022469e-02f, 3.91487963e-03f, 1.84803650e-01f, -3.60420980e-02f, 1.66988708e-02f, 1.80024095e-02f, -1.45312026e-01f, -7.72274956e-02f,
  -7.73657579e-03f, -2.11405694e-01f, 8.81978199e-02f, -3.23014148e-02f, 7.60971978e-02f, -6.40808884e-03f, 2.05331445e-02f, 1.20765850e-01f, 2.17024803e-01f, -2.99226381e-02f,
  -6.89962730e-02f, -6.61725970e-03f, -2.64169779e-02f, -5.78428768e-02f, 7.21039018e-03f, -3.82034970e-03f, -4.18924130e-02f, -3.77270617e-02f, 6.63975999e-02f, -9.01895463e-02f,
  8.22977796e-02f, -9.09498930e-02f, 1.03148529e-02f, -1.02909192e-01f, -8.77463818e-02f, -1.12460047e-01f, -4.12504710e-02f, -7.28792250e-02f, 1.31049640e-02f, 1.68034196e-01f,
  2.96305530e-02f, -5.80601431e-02f, -1.44645736e-01f, 1.32525295e-01f, -5.69897629e-02f, 1.10265039e-01f, 1.41290156e-02f, 8.31404999e-02f, -3.53260599e-02f, -1.58235058e-02f,
  -1.23130664e-01f, -2.54852939e-02f, 2.14052876e-03f, 9.42224413e-02f, -5.77090643e-02f, -1.17001623e-01f, 7.18089193e-02f, -3.89516987e-02f, 3.89488488e-02f, 2.31773630e-01f,
  3.56338806e-02f, 1.06230155e-01f, -3.44812647e-02f, -1.81090757e-01f, -9.89117548e-02f, 6.87556490e-02f, 1.13708042e-01f, 1.44277737e-01f, 2.83776112e-02f, -3.68711054e-02f,
  4.41956930e-02f, 2.76593566e-02f, 3.90288495e-02f, -3.34776193e-03f, 3.02024670e-02f, -5.97754717e-02f, -5.07934615e-02f, 3.78565490e-03f, -9.78353992e-02f, 4.28161286e-02f,
  6.17821561e-03f, -9.26438943e-02f, -3.88504080e-02f, -1.16244727e-03f, -3.15433485e-03f, -8.89612269e-03f, -2.87446938e-02f, -8.14972743e-02f, -6.60226643e-02f, 7.76006281e-02f,
  -4.13723849e-02f, 4.82775718e-02f, -6.20058551e-02f, 4.49219979e-02f, -5.43620735e-02f, 1.64214462e-01f, -1.80857927e-02f, 1.86898112e-02f, 2.87175979e-02f, 1.04621015e-01f,
  -9.13027748e-02f, 2.19772942e-02f, 1.18548619e-02f, 1.78749766e-03f, 4.62430269e-02f, 9.42424238e-02f, 3.64062525e-02f, -8.70466605e-02f, 1.42196506e-01f, -1.16551127e-02f,
  5.77334352e-02f, 4.74263206e-02f, -1.69557184e-02f, -1.20997475e-02f, -7.11169392e-02f, 7.56752416e-02f, -4.22297977e-02f, -6.73380569e-02f, 6.00043349e-02f, 2.09590215e-02f,
  8.55399296e-02f, 5.26214242e-02f, -4.06443514e-02f, -2.00764149e-01f, -1.28207371e-01f, 1.00563258e-01f, -1.14218593e-01f, 3.36344391e-02f, 1.33194551e-01f, 8.04848373e-02f,
  3.91980484e-02f, 5.93915917e-02f, -8.71620402e-02f, 7.03918561e-02f, -1.26169533e-01f, 5.90693057e-02f, -2.76835505e-02f, 5.65827787e-02f, -3.54956277e-02f, 3.14628482e-02f,
  7.00567430e-03f, -1.24843745e-02f, 1.07553527e-01f, -1.04262913e-03f, 8.65617469e-02f, 6.19094111e-02f, 1.39218956e-01f, 1.80897936e-02f, 1.38776898e-01f, 4.52177115e-02f,
  -4.52280715e-02f, -1.76119097e-02f, 1.53148388e-02f, -5.73726222e-02f, 1.36993472e-02f, 6.01029545e-02f, 4.50930446e-02f, 3.54215465e-02f, 5.17919064e-02f, -1.35877624e-01f,
  1.97166353e-02f, -2.36363355e-02f, -2.29474325e-02f, -1.43785894e-01f, -3.06166448e-02f, -6.55360520e-02f, 5.95480911e-02f, 5.56247775e-03f, -6.90441057e-02f, -1.13697117e-02f,
  -1.23241954e-01f, 5.57126291e-02f, -2.27832352e-03f, 8.86222199e-02f, -1.23403825e-01f, -6.71119019e-02f, -8.76756757e-02f, 9.32258181e-03f, 1.11262701e-01f, -2.41047349e-02f,
  -7.13336421e-03f, 1.30124226e-01f, -5.98119088e-02f, -5.03386110e-02f, 8.58939290e-02f, -8.02477077e-02f, 1.34037975e-02f, -9.22544394e-04f, 2.36319155e-01f, 4.28184494e-02f,
  4.82448973e-02f, -4.46891598e-02f, -1.21595897e-03f, -1.00943521e-01f, 3.95615846e-02f, 6.31393567e-02f, 1.27076611e-01f, -2.43674796e-02f, 3.00043984e-03f, 1.35835167e-02f,
  -5.55096380e-02f, -6.16945773e-02f, -1.96172111e-02f, -8.83046389e-02f, 8.36529955e-02f, 3.21237631e-02f, 8.16640779e-02f, -6.32154793e-02f, 1.08941728e-02f, -1.34130809e-02f,
  8.64192992e-02f, -6.36666790e-02f, 1.80629641e-01f, -2.26272307e-02f, 2.53020395e-02f, -4.20170650e-02f, 1.34266373e-02f, 6.90014586e-02f, -1.87344532e-02f, 8.04641172e-02f,
  -7.14795962e-02f, 1.78672113e-02f, -7.13163838e-02f, 5.42551205e-02f, -2.66315751e-02f, -1.68585796e-02f, -1.50832728e-01f, -1.05650062e-02f, -6.98569864e-02f, 5.30256368e-02f,
  -1.36352956e-01f, 1.07972600e-01f, -1.86484843e-01f, 4.65153530e-02f, -7.19403997e-02f, -4.85360017e-03f, 4.56938595e-02f, 1.75656468e-01f, 1.70273408e-02f, 1.56154260e-01f,
  -9.26659107e-02f, 7.02783689e-02f, -6.55822828e-02f, -2.61768699e-02f, -1.55992033e-02f, -8.95486865e-03f, 1.77129954e-01f, -5.28797060e-02f, -1.19586498e-01f, 8.89727622e-02f,
  -1.76281378e-01f, 2.60201633e-01f, -2.36465950e-02f, 1.45565970e-02f, 7.47068822e-02f, -5.38120903e-02f, -3.50871915e-03f, -1.64343402e-01f, -2.10460275e-03f, 1.23223446e-01f,
  -6.51867762e-02f, 5.43169193e-02f, -3.05813365e-02f, 1.91947684e-01f, -1.45738453e-01f, -8.55946764e-02f, -1.09992392e-01f, 3.27315554e-02f, -1.23984050e-02f, 6.28387406e-02f,
  -6.65075183e-02f, 7.91443810e-02f, 2.44066697e-02f, 1.12787690e-02f, -3.80680338e-02f, -4.70945686e-02f, -1.17426321e-01f, -6.70627207e-02f, -6.28855377e-02f, 8.41865316e-02f,
  -3.35515626e-02f, -2.55662370e-02f, -1.59980416e-01f, -3.91278081e-02f, -2.85526421e-02f, -1.39808841e-02f, 4.25220467e-02f, 1.68356493e-01f, -1.34181589e-01f, 2.32392065e-02f,
  8.88007730e-02f, 5.00276275e-02f, -1.08133711e-01f, 9.74755213e-02f, 2.19814721e-02f, -2.77924147e-02f, 3.63859301e-03f, 2.59121895e-01f, 1.19596027e-01f, -1.82281822e-01f,
  -1.76602185e-01f, -9.58346501e-02f, 7.80771626e-03f, -9.33314934e-02f, -6.36288077e-02f, -9.07882899e-02f, -5.92946522e-02f, 1.61237612e-01f, -1.10678840e-02f, 3.19774263e-02f,
  1.25559419e-01f, -1.17787756e-01f, -2.31450632e-01f, 4.65006046e-02f, 1.83110833e-01f, -3.23640853e-01f, 4.50361855e-02f, 8.82496014e-02f, -1.21348761e-01f, -1.27863511e-01f,
  -1.32645845e-01f, 6.75785914e-02f, -2.57940024e-01f, 2.32110731e-02f, 2.42985636e-02f, 8.96754768e-03f, -1.02995872e-01f, 1.74637139e-01f, -6.88269660e-02f, 1.40881585e-02f,
  1.38151377e-01f, 1.32667527e-01f, 6.58326522e-02f, -1.17498279e-01f, 4.05681506e-02f, -8.50509629e-02f, 2.01351196e-02f, 5.38473204e-02f, 2.14089543e-01f, 2.20094342e-02f,
  -4.10102420e-02f, -9.74096451e-03f, 4.41662408e-02f, -9.06665102e-02f, -4.92537096e-02f, -7.37971216e-02f, -1.08789004e-01f, -1.26339436e-01f, 3.53213772e-02f, -1.21403188e-01f,
  1.05457902e-01f, -4.36185636e-02f, -5.04769161e-02f, -7.34937787e-02f, -2.98126955e-02f, -6.88025206e-02f, -4.28579338e-02f, -4.90490086e-02f, 3.05701047e-02f, 1.28312767e-01f,
  1.85864344e-02f, -4.16215993e-02f, -1.49623662e-01f, 1.40045613e-01f, -1.99808508e-01f, 1.03445858e-01f, -8.44860226e-02f, 5.95620126e-02f, 3.94330919e-02f, 2.47392338e-02f,
  -8.62890482e-02f, -1.18334249e-01f, 7.43657723e-02f, 8.00214261e-02f, -1.37774974e-01f, -8.85266289e-02f, -6.05603829e-02f, -1.89757198e-02f, -3.65946181e-02f, 2.07126513e-01f,
  6.12332374e-02f, 1.51157498e-01f, -2.41853707e-02f, -1.02592409e-01f, -1.45548373e-01f, -1.62147463e-03f, 6.06862940e-02f, 1.39900401e-01f, 7.64663666e-02f, -4.23938297e-02f,
  4.85327505e-02f, -1.17946956e-02f, 2.06381977e-02f, -3.72805893e-02f, 2.53135841e-02f, 1.60215218e-02f, 1.96543485e-02f, 7.04030022e-02f, 2.14289259e-02f, -5.02031632e-02f,
  -2.89833862e-02f, 1.13075413e-01f, 9.84563306e-02f, -1.21982358e-01f, -5.66905849e-02f, 1.64160691e-02f, -1.00765906e-01f, -8.38798732e-02f, 5.36054745e-02f, -5.68487234e-02f,
  -6.16155900e-02f, -1.40972480e-01f, -1.24203920e-01f, -6.16190955e-02f, 1.16892971e-01f, -7.46256113e-02f, -9.03411061e-02f, 1.01237111e-02f, -5.91756515e-02f, -4.90072481e-02f,
  -3.13355401e-02f, -1.46625249e-03f, -1.62018482e-02f, -6.80565508e-03f, -4.41947114e-03f, 1.03017844e-01f, -1.63547590e-03f, 8.83098766e-02f, -2.13997111e-01f, 1.18097536e-01f,
  -4.73640598e-02f, -4.34478559e-02f, -7.49603137e-02f, 3.83319221e-02f, 8.27008113e-02f, -1.69281214e-01f, -7.46063441e-02f, 6.26586005e-02f, 4.97549735e-02f, -2.03674197e-01f,
  -2.26475671e-01f, -2.29147039e-02f, 9.45506841e-02f, 6.66423887e-02f, 1.70471013e-01f, 4.64224853e-02f, -1.26203476e-02f, -2.17116952e-01f, -1.21565320e-01f, -1.11558391e-02f,
  -1.48119003e-01f, -2.30089109e-02f, 1.33419022e-01f, 3.03968899e-02f, 6.71733543e-02f, 9.19983983e-02f, -2.05051526e-01f, -3.12656574e-02f, -3.00249606e-02f, -1.49963066e-01f,
  9.04615596e-02f, -8.72244537e-02f, 1.12168811e-01f, -9.90995392e-02f, 9.98449177e-02f, 1.09857671e-01f, 2.21668810e-01f, -4.27951477e-02f, -4.96458672e-02f, 2.68622115e-02f,
  -1.64231975e-02f, -9.54553261e-02f, -5.63689210e-02f, 1.80097632e-02f, 1.69640053e-02f, -1.89967938e-02f, 9.48016047e-02f, -2.43793055e-02f, 1.43741354e-01f, -6.08444102e-02f,
  -1.25631273e-01f, -1.72667697e-01f, -1.19549192e-01f, -1.45022005e-01f, -8.58217254e-02f, -8.86294395e-02f, -9.12291743e-03f, 1.28709689e-01f, 3.53067629e-02f, 2.79966351e-02f,
  -1.74517199e-01f, 1.39291897e-01f, -6.45560920e-02f, 1.24732956e-01f, -2.87904739e-02f, 6.21452965e-02f, -2.57904660e-02f, -4.21835333e-02f, -1.44720554e-01f, 4.79961857e-02f,
  7.49558285e-02f, 8.22138563e-02f, -2.05403909e-01f, -5.75665832e-02f, 1.13361068e-01f, -9.62580815e-02f, 1.90626662e-02f, 1.49549812e-01f, -2.76378859e-02f, 1.99054211e-01f,
  -1.90866124e-02f, -1.35963112e-01f, -4.34994102e-02f, 7.45356008e-02f, 2.08165675e-01f, -7.59632699e-03f, 5.49289435e-02f, 1.98085397e-03f, -2.16199178e-02f, 3.31080146e-02f,
  1.03300519e-01f, -5.97640499e-02f, -4.69250940e-02f, 5.83848134e-02f, 5.99713139e-02f, 4.88004088e-02f, 6.44361824e-02f, 6.94980100e-02f, 2.21085958e-02f, 4.29380275e-02f,
  -8.94384533e-02f, 9.80920345e-02f, 1.17302142e-01f, 6.66140318e-02f, 2.52691768e-02f, 1.13979489e-01f, 9.33477357e-02f, 2.48710997e-02f, 1.39157176e-01f, 5.70756458e-02f,
  4.01505306e-02f, 8.85889158e-02f, 1.45921493e-02f, -1.12094611e-01f, 1.16439583e-02f, 2.72107068e-02f, 2.84492839e-02f, -8.44641775e-02f, -6.78045722e-03f, 4.71322164e-02f,
  -4.61438484e-02f, -1.49836466e-01f, -6.26669675e-02f, 6.04696237e-02f, 6.26006797e-02f, -9.55641493e-02f, 5.30245937e-02f, -5.68599515e-02f, -4.26399410e-02f, -8.17992259e-03f,
  -8.99990946e-02f, -2.97629088e-02f, 2.38434300e-01f, 5.21361269e-03f, -6.95421547e-02f, -3.95111069e-02f, 7.70183206e-02f, 3.35737765e-02f, -1.09705692e-02f, -8.05733446e-03f,
  -6.91051111e-02f, -6.67816252e-02f, 5.95802115e-03f, -1.55969247e-01f, 1.41949072e-01f, 1.79494321e-01f, -3.18216048e-02f, -4.79098558e-02f, 3.54293287e-02f, -1.89052165e-01f,
  6.33776486e-02f, -8.69058818e-02f, 6.82003647e-02f, -3.84312384e-02f, -6.34929016e-02f, -6.69005886e-02f, -6.82745874e-02f, -6.68750554e-02f, -8.01004469e-02f, 1.50415704e-01f,
  4.50360440e-02f, 1.38115078e-01f, 4.11049053e-02f, 1.11672776e-02f, -6.71540722e-02f, -3.12580243e-02f, -6.69271350e-02f, 6.64554909e-02f, 3.06218155e-02f, 1.12874784e-01f,
  6.26808181e-02f, -2.37581786e-03f, 7.30762333e-02f, -3.11637297e-02f, 7.40387440e-02f, 7.29583502e-02f, 2.22389884e-02f, 5.75396977e-03f, 6.39618933e-02f, 1.17431358e-01f,
  6.72402233e-03f, -5.50701134e-02f, 4.77833264e-02f, 1.22017920e-01f, 5.03154024e-02f, -9.03809890e-02f, 1.47185512e-02f, -2.91873664e-02f, 2.83777937e-02f, 1.35394521e-02f,
  -1.97426323e-02f, -1.49864227e-01f, 1.35980844e-02f, -1.29665837e-01f, -2.17462983e-02f, 4.63409387e-02f, 6.37062788e-02f, -1.42755620e-02f, -4.91364449e-02f, 7.32519776e-02f,
  -1.61177710e-01f, 5.26446775e-02f, 9.52017084e-02f, -9.42585021e-02f, 2.00577080e-01f, -1.67015731e-01f, 1.31393909e-01f, -1.12107761e-01f, -2.99894288e-02f, 1.38152152e-01f,
  1.15785822e-01f, 2.93217748e-02f, 8.54303017e-02f, -5.81466928e-02f, 5.66404760e-02f, -7.61887431e-02f, -1.01433089e-02f, -1.70238480e-01f, 1.52233019e-01f, -4.67154523e-03f,
  1.67098671e-01f, 7.41553027e-03f, -1.77638531e-02f, 9.84099135e-02f, 5.29758036e-02f, 1.04424581e-01f, 2.11132932e-02f, 3.33224679e-03f, -5.71856685e-02f, 2.80792881e-02f,
  1.06172964e-01f, 7.54811615e-02f, -1.71544235e-02f, 6.48636371e-02f, 4.44827564e-02f, 1.90625899e-02f, 7.90041164e-02f, 5.26969321e-02f, 6.79755956e-02f, 3.87482531e-02f,
  2.73999963e-02f, -2.83946097e-02f, -4.91834730e-02f, 2.91817877e-02f, 3.64798796e-03f, -1.00741349e-01f, 5.54449446e-02f, 5.60787208e-02f, 2.08197106e-02f, -1.90399662e-01f,
  3.52629535e-02f, 1.68697443e-02f, 3.69756781e-02f, -5.48465252e-02f, -7.98716396e-02f, -1.14365093e-01f, -4.54335921e-02f, -8.23716372e-02f, -3.45132090e-02f, -2.66410895e-02f,
  1.73668116e-01f, -1.04679605e-02f, -4.83212583e-02f, -4.01214808e-02f, -8.63170847e-02f, 7.51388445e-02f, -3.05792391e-02f, -8.76800194e-02f, 4.73292805e-02f, -9.07860398e-02f,
  1.42571134e-02f, -7.67310560e-02f, 1.24197572e-01f, 1.38909400e-01f, 2.43041124e-02f, 2.08365098e-02f, -1.62226036e-02f, -1.96978912e-01f, 9.76448655e-02f, -1.84742048e-01f,
  4.04438861e-02f, -1.17806256e-01f, -2.33468115e-02f, -7.14254454e-02f, 3.45372111e-02f, -7.93070048e-02f
};

// L2_fan_Wp_bar (Shape: 26 x 64)
const int L2_fan_Wp_bar_rows = 26;
const int L2_fan_Wp_bar_cols = 64;
const float L2_fan_Wp_bar_data[] = {
  -3.16808186e-02f, -2.64325980e-02f, 1.50362983e-01f, 1.63346734e-02f, 1.37917825e-03f, -4.47042510e-02f, 7.65406266e-02f, 6.04909770e-02f, -3.24770324e-02f, 4.69323471e-02f,
  3.42386076e-03f, 1.16786435e-01f, 2.45527644e-02f, -1.59430280e-01f, -1.90001354e-02f, -1.00617066e-01f, 4.93697934e-02f, -5.79794273e-02f, -3.53591517e-02f, -3.40457737e-01f,
  -2.65876055e-02f, 6.30714670e-02f, 9.10360813e-02f, -1.94650963e-01f, 1.12017803e-01f, 4.48015295e-02f, -9.73160472e-03f, -6.62830546e-02f, -9.19081569e-02f, -4.98401150e-02f,
  -4.16999422e-02f, 6.71616122e-02f, -1.01561934e-01f, -6.52498612e-03f, -1.03525035e-01f, -5.62437400e-02f, -4.58989926e-02f, 3.57962549e-02f, 3.51286530e-01f, -2.84371614e-01f,
  -1.38993387e-03f, -1.83063913e-02f, -8.46113041e-02f, 1.05073333e-01f, -5.12115983e-03f, -2.06698433e-01f, -3.67233455e-02f, -1.28525674e-01f, 2.66684681e-01f, -1.36628449e-01f,
  2.41125047e-01f, 4.57224250e-02f, -2.15751499e-01f, -1.15801573e-01f, 1.89856529e-01f, -2.60010213e-01f, 2.13195503e-01f, -2.57616222e-01f, 1.96282551e-01f, -6.44882349e-03f,
  6.21595643e-02f, -5.80591857e-02f, 4.59724814e-02f, -3.52327198e-01f, -8.66424013e-03f, 8.27985853e-02f, 9.93023720e-03f, 1.77747719e-02f, 9.36162993e-02f, -1.67244729e-02f,
  -2.72129089e-01f, 8.81509483e-02f, 1.71131536e-01f, 8.72981921e-02f, 8.50310773e-02f, 4.66998927e-02f, 7.34883174e-02f, 1.42657131e-01f, 2.50125676e-01f, 1.42594740e-01f,
  2.00686440e-01f, 1.80496514e-01f, -1.55822828e-01f, 1.98746338e-01f, 3.69405821e-02f, 2.12660328e-01f, -1.00651309e-02f, 1.27131343e-01f, 1.38108119e-01f, 1.04930922e-01f,
  2.37682965e-02f, -2.56330878e-01f, 3.08436248e-02f, -1.61564156e-01f, 1.11100458e-01f, -7.33101787e-03f, -1.99174248e-02f, -3.98719423e-02f, 8.82820189e-02f, -4.85388897e-02f,
  -2.18857303e-02f, 8.09315145e-02f, 4.62325402e-02f, 1.34849012e-01f, -1.27681077e-01f, -4.30865586e-03f, -1.59198552e-01f, 2.41126016e-01f, 4.04923894e-02f, -3.99307534e-02f,
  2.39835501e-01f, 1.41541138e-01f, -2.99018584e-02f, -3.77553940e-01f, 8.51912573e-02f, 1.71634480e-01f, 3.23270380e-01f, -5.56582250e-02f, -1.60654441e-01f, -1.15674704e-01f,
  6.61411583e-02f, 3.50921750e-02f, 8.53073746e-02f, -2.59114712e-01f, 1.05363943e-01f, -1.45588368e-02f, 1.59644380e-01f, 1.52581990e-01f, 7.87156299e-02f, 6.05591759e-02f,
  4.67596091e-02f, -4.57536429e-02f, 4.38506529e-02f, -7.60980994e-02f, -4.38328870e-02f, 2.30860729e-02f, 2.53189087e-01f, 7.28116632e-02f, 6.24031797e-02f, 1.47340307e-02f,
  5.24498895e-02f, 6.52889237e-02f, 1.08618125e-01f, 1.26092643e-01f, 8.04968253e-02f, 2.12597735e-02f, -9.95157659e-02f, 5.15041314e-02f, 1.42228872e-01f, 7.76585639e-02f,
  -1.36518121e-01f, 5.16437329e-02f, 5.97352833e-02f, 1.12601453e-02f, -3.66138779e-02f, 6.90768659e-02f, -4.61657718e-02f, -2.78213382e-01f, -7.24316090e-02f, 1.63590431e-01f,
  4.58565243e-02f, 1.21672176e-01f, -6.04752190e-02f, 1.48605138e-01f, 6.11026995e-02f, 6.09748773e-02f, 1.10196739e-01f, -7.58956969e-02f, 2.34058369e-02f, 7.01863542e-02f,
  -8.89380574e-02f, 6.12834878e-02f, -3.12567502e-03f, 4.55913395e-02f, -2.38129217e-02f, 4.55260158e-01f, 3.51101011e-02f, -1.85255691e-01f, 1.14342831e-01f, -4.49596532e-02f,
  2.10376754e-01f, -1.14543155e-01f, 3.83116975e-02f, 7.09894225e-02f, -9.42471474e-02f, 8.71700570e-02f, 5.67731112e-02f, -1.83173552e-01f, -9.44135711e-02f, -9.63847563e-02f,
  -1.31451115e-01f, -6.78019226e-02f, 1.74789242e-02f, 3.39156576e-02f, -8.92743841e-02f, -1.21572393e-03f, -4.63976264e-02f, 2.14142371e-02f, -9.61263552e-02f, 6.75437152e-02f,
  -7.87108839e-02f, -1.32968351e-02f, -1.84457712e-02f, 1.09251574e-01f, 3.26978154e-02f, 2.23353896e-02f, -8.38141739e-02f, 6.16470873e-02f, -3.92048769e-02f, 9.54867229e-02f,
  -4.02604304e-02f, 1.27947181e-01f, -8.15017596e-02f, 4.96172272e-02f, 2.39852946e-02f, 1.49250299e-01f, -1.84019934e-02f, 1.05955407e-01f, -3.70642357e-02f, -3.60439979e-02f,
  -3.77604626e-02f, 1.12547457e-01f, 1.16523348e-01f, -1.90387696e-01f, 5.30020613e-03f, 2.19206214e-02f, 9.69810858e-02f, 3.26156951e-02f, 4.26599942e-02f, 8.02881178e-03f,
  -6.80329790e-03f, 2.23190293e-01f, 4.38842922e-02f, 1.20494133e-02f, 3.20734352e-01f, 1.74297336e-02f, -7.73456693e-02f, 1.16636790e-01f, 4.58480641e-02f, -2.27153435e-01f,
  -1.20221250e-01f, 1.17893793e-01f, -5.50883031e-03f, 1.31255090e-01f, 2.66525559e-02f, 9.22162309e-02f, -1.42270386e-01f, 4.64062877e-02f, 2.02919450e-02f, 1.60760939e-01f,
  -2.38819849e-02f, 2.58717239e-01f, 6.90287650e-02f, 1.24580912e-01f, 8.78082290e-02f, 1.73973992e-01f, 4.36441265e-02f, 1.43400079e-03f, 4.99229915e-02f, -7.97982290e-02f,
  -4.22057770e-02f, 2.32212916e-02f, 1.34541597e-02f, 6.35316595e-02f, 9.29486156e-02f, 7.70105347e-02f, 1.20722845e-01f, -7.57931173e-02f, 9.50152986e-03f, -7.32359216e-02f,
  -4.18576784e-02f, 8.59728232e-02f, -6.51317835e-02f, -6.10199682e-02f, 5.50659187e-02f, -2.77881652e-01f, 1.02678135e-01f, 4.03373763e-02f, 2.04675831e-02f, -1.50883466e-01f,
  -1.40460595e-01f, -1.58312753e-01f, -2.67491758e-01f, 1.01622187e-01f, -1.53929755e-01f, 1.28432270e-02f, -7.47042522e-02f, 3.53074335e-02f, 2.73245782e-01f, 1.62522137e-01f,
  -6.77903220e-02f, 1.49553061e-01f, -1.54361561e-01f, 8.53940547e-02f, 1.34146124e-01f, -1.11923173e-01f, 5.72645897e-03f, 8.39002207e-02f, 1.33898575e-02f, 7.30454847e-02f,
  2.24564746e-01f, 1.72314309e-02f, -1.76592737e-01f, 1.65308625e-01f, 3.83269996e-03f, -6.02495596e-02f, 2.67570078e-01f, 5.76679334e-02f, -8.91625043e-03f, -7.39984140e-02f,
  3.83295238e-01f, 1.25314638e-01f, -1.31860346e-01f, 7.10555986e-02f, 1.00214025e-02f, -1.37040224e-02f, -1.11637577e-01f, 1.29111577e-03f, -3.06837946e-01f, -2.77952433e-01f,
  1.15867086e-01f, 5.75368144e-02f, 1.81459516e-01f, -2.22615479e-03f, 5.44475242e-02f, 7.62370378e-02f, 2.36710921e-01f, 1.12371314e-02f, 1.55293822e-01f, 5.97045012e-02f,
  4.06664051e-02f, -1.80105641e-02f, 1.29652351e-01f, 1.04637265e-01f, 5.26641309e-02f, 4.01414670e-02f, 1.00805186e-01f, 3.09170154e-03f, 6.29470870e-02f, -8.00888520e-03f,
  -1.26562357e-01f, -1.87886134e-02f, -1.62561610e-01f, -1.80176541e-01f, -5.69564924e-02f, 3.08417771e-02f, -1.00598037e-02f, 5.73178940e-02f, -9.77638587e-02f, 6.01256974e-02f,
  -1.75021961e-01f, 1.58842012e-01f, -1.91879466e-01f, 9.92208496e-02f, -8.09043050e-02f, 6.02321047e-03f, -9.65041742e-02f, 4.24077921e-02f, 3.19012180e-02f, 4.07391135e-03f,
  -9.05474350e-02f, 2.47587845e-01f, -1.78346366e-01f, -1.11010067e-01f, 1.40108122e-03f, -1.14008695e-01f, 2.13324532e-01f, 2.40258664e-01f, 1.92184240e-01f, 2.57907212e-02f,
  3.71940956e-02f, -2.43048016e-02f, -3.92626300e-02f, -4.13698293e-02f, 1.61681697e-01f, 4.41048108e-02f, 1.80375800e-01f, -5.31917997e-02f, 6.06524609e-02f, -2.92670019e-02f,
  3.21058818e-04f, -1.12461329e-01f, 9.66742188e-02f, 7.84144849e-02f, -3.43848877e-02f, -1.31127136e-02f, -8.34705308e-02f, 5.43998294e-02f, 1.03285089e-01f, -1.05802141e-01f,
  -1.33027375e-01f, 3.86605561e-02f, 8.49141926e-02f, 2.40099132e-02f, 1.68636978e-01f, 8.72893557e-02f, 7.00579956e-03f, -6.94276243e-02f, 6.89605847e-02f, 6.03149273e-02f,
  -5.10867946e-02f, 1.49361745e-01f, -1.69230595e-01f, -2.37314682e-02f, 2.84749091e-01f, 9.41573232e-02f, 7.32983351e-02f, 1.40854120e-01f, 1.71897843e-01f, 3.27952728e-02f,
  2.47867079e-03f, 1.28169563e-02f, -1.25082180e-01f, -1.75296754e-01f, 1.11079343e-01f, -7.70743936e-02f, 2.09076911e-01f, -3.07263210e-02f, -1.96768753e-02f, 3.30473296e-02f,
  7.67203271e-02f, 1.35681078e-01f, 2.61685938e-01f, 9.66486558e-02f, 1.01175472e-01f, -1.88866362e-01f, 1.69030815e-01f, 1.16892666e-01f, 3.28342281e-02f, 1.74398780e-01f,
  -8.07035640e-02f, -4.92893457e-02f, 8.46648216e-02f, -1.88615650e-01f, 8.31885114e-02f, 2.35542372e-01f, 1.26513481e-01f, -1.38413263e-02f, -7.47948959e-02f, 1.63317993e-01f,
  -4.11207192e-02f, 8.76635835e-02f, -2.59593874e-02f, -8.28547329e-02f, 2.45458763e-02f, 8.13584849e-02f, -2.18219757e-01f, -1.84042677e-01f, -8.93447101e-02f, 4.79690917e-02f,
  -4.27704751e-02f, 9.24633667e-02f, -4.45606699e-03f, -1.43262011e-03f, -1.85170710e-01f, 1.15273200e-01f, -2.23037407e-01f, 5.46486564e-02f, 2.35121567e-02f, 1.03908151e-01f,
  4.83652055e-02f, -4.59844656e-02f, 7.26701021e-02f, -4.00427021e-02f, 6.17195629e-02f, 1.13311917e-01f, 3.96706313e-02f, -3.83914495e-03f, -5.75924367e-02f, 5.03196605e-02f,
  1.16840765e-01f, -4.33600973e-03f, 7.75234178e-02f, 1.13271445e-01f, 3.82091962e-02f, -2.30387732e-01f, 8.55705962e-02f, 2.31570993e-02f, 1.20233886e-01f, -7.05655143e-02f,
  1.66854739e-01f, -2.38481015e-01f, 1.06074408e-01f, -1.16731189e-01f, 4.20229360e-02f, 1.04702692e-02f, 1.59718931e-01f, 1.44593686e-01f, 2.73568574e-02f, -3.40819731e-02f,
  -2.06676230e-01f, 2.42407516e-01f, 3.43395889e-01f, -1.07736908e-01f, 8.37608129e-02f, -3.73366356e-01f, -5.18680140e-02f, -8.50709602e-02f, 1.27284169e-01f, 3.00976157e-01f,
  2.14016184e-01f, 6.03557117e-02f, 9.66687649e-02f, -1.53952852e-01f, 4.85614724e-02f, 4.16629091e-02f, -5.63059784e-02f, -1.70755982e-01f, 2.09688544e-01f, 1.83271915e-01f,
  2.32426047e-01f, 8.08842778e-02f, 1.01034204e-02f, 6.62505552e-02f, 4.10898812e-02f, -3.55175957e-02f, -3.91861275e-02f, 6.54163361e-02f, 1.40209213e-01f, -5.25917038e-02f,
  -9.23523009e-02f, -7.59696439e-02f, -8.01779404e-02f, -6.16124198e-02f, -2.27067601e-02f, 7.88669437e-02f, -2.45771185e-01f, 5.97338229e-02f, -7.63172433e-02f, -4.25752811e-02f,
  1.01114795e-01f, 6.71989769e-02f, -1.55327111e-01f, -1.20552577e-01f, -1.29725952e-02f, -1.82554275e-02f, -2.10271642e-01f, -5.92295937e-02f, -5.68944663e-02f, 1.77247286e-01f,
  1.40191885e-02f, 2.15072259e-01f, -7.69606978e-02f, 1.04092117e-02f, -6.67626411e-03f, 5.86143471e-02f, 4.91981842e-02f, 9.18407887e-02f, -6.08220734e-02f, -3.71492840e-02f,
  -2.27741852e-01f, 1.22117028e-01f, 4.21098918e-02f, 1.71131283e-01f, 1.24694571e-01f, -1.84219405e-01f, 5.47547005e-02f, 9.07514766e-02f, -3.91692482e-02f, -2.33520921e-02f,
  -5.15461946e-03f, 2.91203558e-01f, -6.37374371e-02f, -1.13789484e-01f, -1.25570953e-01f, 1.77554756e-01f, 8.29863846e-02f, 1.90638527e-01f, -3.33239846e-02f, 1.37158558e-01f,
  -1.55483633e-01f, 2.89257139e-01f, 2.37261262e-02f, 4.06120494e-02f, 1.25905663e-01f, 2.12331638e-01f, -2.06884779e-02f, 5.68317696e-02f, -8.05382058e-02f, 3.84603366e-02f,
  3.23636234e-02f, 1.29356489e-01f, 1.25922725e-01f, 3.12856175e-02f, -1.31175458e-01f, -5.80895226e-03f, 2.39620451e-02f, 5.01295738e-02f, 1.43616229e-01f, 7.80347288e-02f,
  -1.18285231e-01f, 2.15682248e-03f, 6.41909912e-02f, -6.76917359e-02f, 1.70596674e-01f, 3.98218781e-02f, -1.19146354e-01f, -1.45553201e-01f, -1.28051965e-02f, -8.23264942e-03f,
  -8.00175890e-02f, 2.58150119e-02f, 1.41376004e-01f, 1.34053603e-01f, 1.53490856e-01f, 2.04387009e-01f, -1.25774994e-01f, 4.36586887e-02f, -1.71870738e-01f, -1.45540625e-01f,
  1.63959730e-02f, -5.49172424e-02f, -7.50622004e-02f, -9.23342258e-03f, -1.76964059e-01f, 2.41074666e-01f, 1.12900645e-01f, 2.54526526e-01f, 3.65369879e-02f, -8.78859907e-02f,
  -3.00134830e-02f, -4.12583277e-02f, 7.22902790e-02f, -2.46012598e-01f, 3.43119092e-02f, 3.66148025e-01f, -2.40300715e-01f, 4.28679772e-02f, -7.56906718e-02f, 2.13772207e-01f,
  -4.66061234e-02f, 8.19642693e-02f, 2.47584924e-01f, 5.92717826e-02f, -1.65187076e-01f, 1.04311056e-01f, 1.57597706e-01f, 4.03454751e-02f, 1.34276316e-01f, 2.26461977e-01f,
  1.97669074e-01f, 3.34550180e-02f, 1.91109553e-01f, -1.71461180e-02f, 1.01255454e-01f, 9.11915675e-02f, 8.81191120e-02f, 4.60184179e-02f, 2.65481502e-01f, 6.07285723e-02f,
  -1.88006256e-02f, 1.13811187e-01f, 6.45626932e-02f, 8.58339593e-02f, 6.63401559e-02f, 1.68192565e-01f, 7.62367025e-02f, 6.08621761e-02f, 1.03657441e-02f, 1.39040008e-01f,
  -9.29920748e-02f, 1.24565072e-01f, -2.18340620e-01f, 6.32994622e-02f, -8.90300497e-02f, 1.22418150e-01f, -1.09211788e-01f, -5.07161058e-02f, -2.60183364e-01f, 8.43270496e-02f,
  -2.57726591e-02f, 1.52860358e-02f, -2.28706613e-01f, 2.68399358e-01f, 5.96396066e-02f, 1.75506473e-01f, -1.14486493e-01f, 1.16474822e-01f, 4.18118350e-02f, 1.40173659e-01f,
  -1.34720981e-01f, 9.33572277e-02f, 2.70928144e-01f, -1.14557542e-01f, -2.56366968e-01f, 4.56719585e-02f, 5.19431233e-02f, 2.93935329e-01f, 4.22305129e-02f, -1.08238153e-01f,
  6.46448284e-02f, -9.76423249e-02f, -8.75561014e-02f, -1.00986101e-01f, -1.15576215e-01f, 4.26698327e-02f, 1.01251744e-01f, 1.19487263e-01f, 8.03516135e-02f, 1.42900616e-01f,
  -7.07387030e-02f, -6.73236325e-02f, -1.82822213e-01f, 7.92151690e-02f, 3.99443246e-02f, 1.55639723e-01f, 1.54422343e-01f, 1.63423404e-01f, 1.33741722e-01f, 4.87162322e-02f,
  1.59450829e-01f, 1.39249131e-01f, 7.93439820e-02f, 1.03143407e-02f, -3.41061875e-02f, 1.07893184e-01f, 6.49878159e-02f, 2.86946483e-02f, 6.86805770e-02f, 8.16322118e-02f,
  7.43685514e-02f, 5.32765798e-02f, 4.61239666e-02f, -6.76331157e-03f, -1.80209845e-01f, 3.48111279e-02f, -1.31026536e-01f, -1.37018770e-01f, 1.33479647e-02f, 1.50624126e-01f,
  8.02576914e-02f, -1.44775763e-01f, -5.89056574e-02f, 1.80161536e-01f, -7.21267760e-02f, 1.57898385e-02f, -2.40554705e-01f, -1.60297245e-01f, -7.28052929e-02f, -2.96087842e-02f,
  -1.04575962e-01f, -2.00803466e-02f, 1.73302181e-02f, 1.75489485e-01f, -1.11084528e-01f, 2.34353900e-01f, 5.95612125e-03f, -2.37647053e-02f, -1.45938605e-01f, -1.40424922e-01f,
  2.53155500e-01f, -7.78998882e-02f, 4.07326110e-02f, 7.44263232e-02f, -8.03209990e-02f, 1.14238180e-01f, -1.43191338e-01f, 2.49101836e-02f, -7.38779083e-02f, -9.98453498e-02f,
  2.79551446e-01f, -1.87897831e-01f, 5.47937080e-02f, -3.54837440e-02f, 1.05487496e-01f, -1.47577778e-01f, 2.38421097e-01f, 7.67948478e-02f, 4.26859391e-04f, 1.01391956e-01f,
  -3.10961325e-02f, 1.62072275e-02f, -1.36399195e-02f, -8.03463161e-03f, -1.18752159e-01f, 4.21244279e-02f, 1.67881057e-01f, 6.41647056e-02f, 5.91663271e-02f, 1.37965024e-01f,
  1.34968236e-01f, 2.12483883e-01f, 8.50133225e-02f, 1.12846658e-01f, 7.09481314e-02f, 1.65445119e-01f, -7.29951188e-02f, 2.74212599e-01f, -8.99759755e-02f, 1.22095063e-01f,
  -1.57878101e-01f, 1.38777167e-01f, -1.01503208e-01f, 1.77250028e-01f, -3.68383303e-02f, -8.99724588e-02f, -1.12159275e-01f, 8.40268359e-02f, 2.83977259e-02f, -9.09155793e-03f,
  -1.13076232e-01f, 4.24532183e-02f, 1.23569846e-01f, 6.09424561e-02f, -7.18529671e-02f, 2.95797009e-02f, -1.14669889e-01f, 2.87178606e-01f, -1.10512838e-01f, 1.28315374e-01f,
  1.64241269e-01f, -1.30670238e-02f, -2.13525280e-01f, 1.04138382e-01f, 6.38599992e-02f, 2.68755883e-01f, -1.09571397e-01f, -8.42854977e-02f, -1.57311156e-01f, 4.99248393e-02f,
  1.38953701e-01f, -1.84332399e-04f, -1.70251459e-01f, -3.10774148e-02f, -1.69413555e-02f, 1.58984393e-01f, -4.73414361e-02f, 7.58408606e-02f, -4.68940362e-02f, -2.52805799e-02f,
  5.36927879e-02f, 2.94857293e-01f, -4.16520343e-04f, 1.69948339e-02f, -1.17742822e-01f, 1.44357577e-01f, 2.99346298e-02f, -4.11785245e-02f, -2.01172471e-01f, 5.78587912e-02f,
  2.21549589e-02f, 1.13691233e-01f, 1.12743922e-01f, 9.99013558e-02f, 3.63790579e-02f, 1.08065657e-01f, 6.17520586e-02f, 2.84175798e-02f, 5.47030605e-02f, 6.79268539e-02f,
  -1.21340647e-01f, 1.47152767e-01f, 1.77958429e-01f, 1.56302631e-01f, 1.59911849e-02f, 2.12912098e-01f, 2.15659663e-01f, 1.36324272e-01f, 6.88235685e-02f, -1.82203531e-01f,
  1.06051899e-01f, -6.64048418e-02f, 1.48730487e-01f, -6.86315596e-02f, 2.04356626e-01f, -1.55508175e-01f, 1.43777654e-01f, -1.07422601e-02f, 5.99707663e-02f, 5.56380786e-02f,
  3.34712863e-02f, 2.08406553e-01f, 4.09992151e-02f, -8.70737880e-02f, 5.59555590e-02f, 2.03309551e-01f, 1.72646716e-01f, 1.10086590e-01f, 6.12331815e-02f, -6.07749969e-02f,
  -1.01798370e-01f, -1.36625186e-01f, 4.10430739e-03f, 1.75194725e-01f, 2.27158859e-01f, 1.22572035e-01f, -7.68442228e-02f, -2.08382425e-03f, -3.05045675e-02f, 2.65924513e-01f,
  -5.45373000e-02f, -9.74262953e-02f, 1.86413139e-01f, 1.51285872e-01f, 1.09415367e-01f, 4.48605232e-02f, 1.14349358e-01f, 1.41088352e-01f, 1.54765412e-01f, -2.14145128e-02f,
  1.01113185e-01f, 2.83164233e-02f, 6.48734020e-03f, 7.13794827e-02f, 2.67804891e-01f, 5.28147183e-02f, -3.67383962e-03f, 2.74768844e-02f, 1.55590093e-02f, -2.73933611e-03f,
  -8.54191557e-03f, 8.62410069e-02f, -5.81164844e-02f, 1.33525968e-01f, -3.78430379e-03f, 2.56542694e-02f, -8.37168097e-02f, 1.69846028e-01f, -1.20037496e-01f, 1.32451523e-02f,
  -1.17747851e-01f, 2.24266797e-02f, -1.99752957e-01f, -8.91973358e-03f, -3.01531881e-01f, 9.78869721e-02f, -1.08615980e-02f, -2.78606196e-03f, 5.61464056e-02f, 2.29217097e-01f,
  -6.72228038e-02f, 1.98691726e-01f, -9.09758210e-02f, 8.87827873e-02f, 9.86652225e-02f, 3.44294980e-02f, -5.12648597e-02f, 1.06878355e-01f, 2.79014945e-01f, -6.40904456e-02f,
  -1.41172498e-01f, 9.57009718e-02f, -1.14690155e-01f, 1.59521699e-01f, 4.98564467e-02f, -1.42732546e-01f, 1.83980659e-01f, 4.45208922e-02f, -3.25019681e-03f, -1.06635161e-01f,
  3.83014716e-02f, 9.56448987e-02f, 9.36475769e-02f, 1.12699911e-01f, 2.83410661e-02f, 1.64868847e-01f, -1.89332694e-01f, -5.83455861e-02f, -2.37432420e-01f, 3.94757662e-04f,
  9.39877555e-02f, -1.43990427e-01f, -6.51678517e-02f, -5.90798333e-02f, -3.35016958e-02f, 3.07884719e-02f, 5.47495522e-02f, 1.26960613e-02f, -7.41802007e-02f, -1.12040089e-02f,
  4.96373996e-02f, -2.71854401e-02f, -2.56104507e-02f, -3.57069075e-02f, -1.02595381e-01f, -2.56725438e-02f, 2.04046369e-02f, -3.28201577e-02f, 1.42547092e-03f, 1.53884560e-01f,
  6.04797937e-02f, -6.02041371e-02f, 4.42883670e-02f, 1.48864925e-01f, 2.58322004e-02f, 2.84138657e-02f, 3.16570401e-02f, 1.80325553e-01f, 6.72375336e-02f, -1.06240146e-01f,
  4.72741108e-03f, 3.34634632e-02f, 5.78778572e-02f, 1.15615062e-01f, 1.01123601e-01f, 1.09567024e-01f, 1.12240799e-01f, 7.20562935e-02f, -1.00774080e-01f, 1.67770445e-01f,
  1.60112366e-01f, 2.87488420e-02f, 1.80518270e-01f, 2.60345396e-02f, 1.00712799e-01f, 1.83906376e-01f, -9.17420164e-03f, 1.51947737e-01f, -3.32151242e-02f, 2.76461095e-01f,
  -1.44488558e-01f, -1.88938975e-02f, 7.85159692e-02f, 8.79347250e-02f, -7.87794590e-02f, 2.89097667e-01f, 1.38030108e-02f, 3.05353582e-01f, -5.44399656e-02f, 2.02758297e-01f,
  9.86882970e-02f, 1.76337004e-01f, 1.61664188e-01f, 1.05065681e-01f, 2.63627619e-02f, 6.60355687e-02f, -1.53147494e-02f, 1.09398089e-01f, -4.16687615e-02f, -2.55334321e-02f,
  -7.37355975e-03f, -5.38409688e-02f, 5.29639237e-02f, 5.05022332e-02f, 1.07163809e-01f, 2.82137655e-02f, -1.03821037e-02f, 2.91659241e-03f, 2.08236114e-03f, 1.09741010e-01f,
  -1.31482393e-01f, 8.88413414e-02f, 2.09960751e-02f, -9.60727409e-02f, 1.18125811e-01f, 7.33214021e-02f, 2.22371109e-02f, 2.10409872e-02f, -1.35311067e-01f, -7.80806765e-02f,
  -1.44498572e-01f, 1.03684291e-01f, -1.63316756e-01f, 1.28819719e-01f, 2.94872355e-02f, -7.54729360e-02f, 2.82495171e-01f, 6.81318417e-02f, -2.04349458e-02f, 1.54283509e-01f,
  -9.34410915e-02f, -7.34834606e-03f, 5.66298366e-02f, -2.24167127e-02f, 3.10931131e-02f, 7.66352192e-02f, 1.86635703e-01f, 6.10101558e-02f, 2.09813491e-01f, 1.83128715e-01f,
  -1.23301871e-01f, -1.70819506e-01f, -5.41178212e-02f, 9.07415524e-02f, 2.38267154e-01f, 1.64354250e-01f, -3.33020501e-02f, 2.37258561e-02f, 2.44988337e-01f, 1.71683341e-01f,
  -1.68754309e-01f, 1.84378743e-01f, -7.43829161e-02f, 1.86204612e-01f, -3.37953009e-02f, 7.66516104e-02f, -2.64187038e-01f, -1.00254506e-01f, 1.49161249e-01f, 4.72135954e-02f,
  1.72535717e-01f, 1.04354329e-01f, 7.29022101e-02f, -1.84769705e-02f, 2.28601359e-02f, 5.76979518e-02f, 3.44367683e-01f, 1.86348706e-01f, 5.49037866e-02f, 1.09122023e-01f,
  1.37951136e-01f, -5.86466119e-03f, 6.99975640e-02f, 1.74009860e-01f, -2.10905783e-02f, 5.58820292e-02f, -8.41501206e-02f, -1.09874174e-01f, 5.56973629e-02f, 1.13651328e-01f,
  -1.31845791e-02f, -8.07356164e-02f, 4.52916287e-02f, 4.99879792e-02f, -1.02016076e-01f, -3.04835197e-02f, -1.73569173e-01f, -1.23639718e-01f, -3.47975530e-02f, 4.00823131e-02f,
  7.72278234e-02f, 1.96555793e-01f, -1.11301288e-01f, 1.91353604e-01f, -1.00896299e-01f, 5.91103099e-02f, 3.52554649e-01f, 4.51125726e-02f, 7.75422007e-02f, -1.90367382e-02f,
  1.97314337e-01f, 4.03112806e-02f, -6.16873801e-02f, 1.07203119e-01f, -1.08584305e-02f, 2.49115333e-01f, 2.33734176e-01f, -1.46298379e-01f, 3.10849607e-01f, 7.21475631e-02f,
  6.88465312e-02f, -1.29238203e-01f, 4.64683510e-02f, -1.67975556e-02f, 5.26668653e-02f, -1.21650053e-02f, 1.02751195e-01f, 4.72393073e-02f, -1.62678391e-01f, -6.63285777e-02f,
  -2.22972021e-01f, -1.66323513e-01f, -2.00047921e-02f, 5.31104533e-03f, -4.04436104e-02f, 5.45858173e-03f, -7.23163784e-03f, -1.26761720e-01f, -1.63376510e-01f, 3.96841578e-03f,
  8.40355456e-02f, 3.61267999e-02f, 7.40497410e-02f, -6.54633045e-02f, -4.47573960e-02f, 1.92298610e-02f, 5.82181998e-02f, 5.31075746e-02f, -5.54621816e-02f, 9.07832161e-02f,
  -9.26190764e-02f, 1.73624918e-01f, 1.59939259e-01f, 9.91460457e-02f, 6.39705136e-02f, 1.59612894e-01f, 1.20534487e-01f, 8.26712102e-02f, 4.76262681e-02f, 1.43256783e-03f,
  -4.42668386e-02f, -1.82730600e-01f, 7.90342093e-02f, -5.74742183e-02f, 7.93125629e-02f, 5.99465286e-03f, 5.59927225e-02f, 6.40094280e-02f, 6.01230189e-02f, 6.63567930e-02f,
  1.09422524e-02f, 8.22725371e-02f, 2.25194041e-02f, -1.12387054e-01f, 1.57848641e-01f, 1.14244267e-01f, -2.02496126e-02f, 1.50415406e-01f, -1.96412876e-02f, 8.21028650e-02f,
  3.16682346e-02f, -1.41105935e-01f, -3.74918953e-02f, 1.27097175e-01f, 2.25917801e-01f, 4.69936989e-02f, -1.71108723e-01f, 1.16900221e-01f, -7.97411576e-02f, 2.04722777e-01f,
  -6.34558871e-02f, 3.06597557e-02f, -5.92143759e-02f, 9.11787078e-02f, -1.05098672e-01f, 5.66847324e-02f, 8.26999471e-02f, 1.06965981e-01f, 8.11664090e-02f, 9.67289135e-03f,
  7.67248729e-03f, 5.33667579e-02f, 2.38485813e-01f, 6.94453940e-02f, 1.47524681e-02f, 6.85042962e-02f, 3.52133363e-02f, 2.69125476e-02f, 2.28079334e-02f, -7.72621203e-03f,
  -2.26538908e-02f, -3.73991430e-02f, -3.55277434e-02f, -2.86276229e-02f, 6.24656193e-02f, -1.42032981e-01f, -1.12160392e-01f, -4.33991812e-02f, -7.46149719e-02f, -1.50054798e-01f,
  -3.55883352e-02f, -3.28577086e-02f, -4.98882495e-02f, 4.37672734e-02f, -1.07768606e-02f, 1.11423522e-01f, -1.41214177e-01f, 9.62309390e-02f, -9.05124620e-02f, 3.74714807e-02f,
  -1.45288169e-01f, -4.49651107e-02f, -1.14413686e-01f, -3.86374258e-02f, 4.22445647e-02f, 6.20197952e-02f, -2.42119525e-02f, 1.96822718e-01f, -1.55044749e-01f, -9.29786488e-02f,
  1.48620591e-01f, -1.46843910e-01f, 2.05660358e-01f, 8.84210244e-02f, 1.34135798e-01f, 1.24829777e-01f, 1.38029397e-01f, 4.29512337e-02f, -1.07486539e-01f, 9.37010571e-02f,
  2.10801840e-01f, 7.25937188e-02f, 5.86286783e-02f, -5.76342791e-02f, 5.57617322e-02f, 1.51935024e-02f, 1.97892543e-02f, -7.80822039e-02f, 1.46053312e-02f, -1.44904247e-02f,
  1.77311689e-01f, 8.07150230e-02f, 1.22671038e-01f, 5.67210503e-02f, 1.00832157e-01f, -1.84595771e-02f, 8.02021548e-02f, 6.07437193e-02f, 2.42136374e-01f, 7.71784633e-02f,
  1.65105667e-02f, 9.78090614e-02f, 9.52792987e-02f, 4.19171900e-02f, 1.11939400e-01f, 7.75333941e-02f, 3.25275660e-02f, 2.69119646e-02f, -4.98993844e-02f, -1.23521434e-02f,
  -9.71618593e-02f, 8.26731548e-02f, -1.21023610e-01f, -6.99448436e-02f, -5.34024276e-02f, 2.82984208e-02f, -6.43170550e-02f, -4.51015122e-02f, -1.15631931e-01f, -2.77973972e-02f,
  -2.51522325e-02f, 5.42394407e-02f, 1.06838392e-02f, 8.88572484e-02f, 3.36039141e-02f, 9.12863165e-02f, -3.29754986e-02f, 2.19349051e-03f, 5.24670556e-02f, 9.99297798e-02f,
  -3.39557305e-02f, 2.95617655e-02f, -2.04348676e-02f, 2.16577519e-02f, -6.38620229e-03f, -6.59755468e-02f, -1.88657567e-02f, 2.23891884e-01f, 5.41433729e-02f, -1.42282948e-01f,
  1.04989029e-01f, -1.30690755e-02f, -3.59704085e-02f, -1.62764445e-01f, 1.14064872e-01f, -1.15653150e-01f, 7.64917657e-02f, -4.52047996e-02f, 2.24806219e-02f, -2.25526746e-02f,
  8.75985436e-03f, -1.25786230e-01f, 3.34447180e-03f, 8.77404436e-02f, 4.65879813e-02f, -4.84945700e-02f, -9.47452039e-02f, 4.49795723e-02f, 1.67467874e-02f, 6.97010756e-02f,
  9.29431766e-02f, 9.71880183e-02f, -8.35262761e-02f, -3.88598740e-02f, -3.62709388e-02f, -4.54911254e-02f, 6.99659064e-02f, 1.13523640e-01f, -5.87133951e-02f, -3.83464731e-02f,
  1.29642665e-01f, 4.27228399e-02f, 4.28432636e-02f, 2.08309382e-01f, -5.69209503e-03f, -6.70311004e-02f, -5.53040542e-02f, 1.16044700e-01f, 6.35284260e-02f, 8.75204653e-02f,
  8.94591957e-02f, 1.78521305e-01f, 1.27157286e-01f, 3.47687900e-02f, -2.15308145e-02f, -3.57083976e-02f, 6.33508340e-03f, 8.33664834e-02f, 9.69451293e-02f, 9.00136381e-02f,
  4.06889394e-02f, 2.35885717e-02f, -2.43570745e-01f, 2.42035106e-01f, 6.97707310e-02f, 4.15885635e-02f, 5.88104688e-02f, -4.45350930e-02f, -2.68617794e-02f, 5.44174202e-02f,
  1.58664763e-01f, 4.76214848e-02f, -3.04081962e-02f, 3.66941631e-01f, -1.72396317e-01f, -4.69737649e-02f, 7.48206452e-02f, 2.59810120e-01f, -9.88470018e-02f, 2.76911497e-01f,
  2.33523976e-02f, 2.16799170e-01f, -1.12503581e-01f, 1.96964055e-01f, 7.26355389e-02f, 1.38263538e-01f, 2.35631004e-01f, 2.93591887e-01f, 3.99965458e-02f, 1.41025051e-01f,
  1.31788939e-01f, 7.73292184e-02f, 9.43275690e-02f, 3.37434076e-02f, 1.32555261e-01f, 5.39007336e-02f, 4.83789928e-02f, 7.27868155e-02f, -8.70397240e-02f, 1.00170724e-01f,
  1.16309777e-01f, -1.01208314e-02f, 4.94918525e-02f, -1.93348341e-02f, 1.62575707e-01f, 6.67003989e-02f, 3.54445502e-02f, 1.45461466e-02f, -9.60928127e-02f, 8.18480328e-02f,
  -1.40263498e-01f, -9.87133160e-02f, 7.63241053e-02f, 1.60654977e-01f, 1.11358248e-01f, -8.32417682e-02f, -3.80727462e-02f, 3.44210118e-02f, -7.29041249e-02f, 1.99708268e-02f,
  -2.89278746e-01f, -1.56612679e-01f, -8.73802975e-02f, -1.79107159e-01f, -2.54321918e-02f, 1.47373565e-02f, -1.82432774e-02f, 1.36343643e-01f, -8.35476443e-02f, 1.58281535e-01f,
  -1.75509289e-01f, -3.41230631e-03f, -6.86919317e-02f, -1.69241458e-01f, 2.23623499e-01f, 8.11787769e-02f, 9.76363793e-02f, 8.25575069e-02f, -7.09657893e-02f, 9.93870348e-02f,
  -5.11247944e-03f, 9.35486704e-02f, -1.58405483e-01f, -7.56513029e-02f, 3.04041624e-01f, -7.30965659e-02f, 5.61205037e-02f, -9.43369493e-02f, 1.64124481e-02f, -4.03801128e-02f,
  2.96477348e-01f, 1.48636445e-01f, -1.06064014e-01f, -1.66346598e-02f, 9.61999595e-02f, 8.80133286e-02f, -7.19874948e-02f, 6.74578473e-02f, 9.30774808e-02f, -5.15193157e-02f,
  -1.48240896e-02f, 3.70248891e-02f, -4.39414643e-02f, -4.49221693e-02f, 5.09840436e-02f, -1.08054169e-01f, -3.58336568e-02f, -1.60806507e-01f, 3.48127745e-02f, -8.17541778e-02f,
  2.74782460e-02f, -1.79947272e-01f, 4.08796482e-02f, 1.04478180e-01f, -2.34164502e-02f, -1.39452770e-01f, 1.23285010e-01f, 8.79251882e-02f, 1.46683976e-01f, -3.83999269e-03f,
  2.54330933e-02f, 5.67255393e-02f, -1.16453759e-01f, 4.08196338e-02f, -2.07007691e-01f, -1.25298604e-01f, -2.40484416e-01f, -1.84339210e-01f, -2.18399558e-02f, -5.57338782e-02f,
  1.62543878e-01f, -1.04568027e-01f, -2.52576452e-02f, 4.36151214e-02f, -1.39889389e-01f, 1.80425905e-02f, -1.04852028e-01f, -9.02802423e-02f, 2.32681990e-01f, -5.71150221e-02f,
  2.53315896e-01f, 6.49671257e-02f, 3.82875800e-02f, 8.85437126e-04f, -1.09122954e-01f, 8.47637653e-02f, -1.13885157e-01f, 7.03069661e-03f, 1.77931324e-01f, -8.62894580e-02f,
  1.32708922e-01f, -1.22378312e-01f, -8.84062946e-02f, -4.92876209e-03f, 1.73948467e-01f, -2.06019789e-01f, 8.66887793e-02f, 8.89372230e-02f, 1.72288284e-01f, 3.75519991e-02f,
  3.42673101e-02f, 1.10993899e-01f, 2.19137296e-01f, 1.83278159e-03f, 1.54040515e-01f, 9.13802087e-02f, 3.65838222e-02f, -1.31039619e-02f, 6.95767179e-02f, 1.29191309e-01f,
  6.09105676e-02f, 8.43958035e-02f, 7.94020109e-03f, -2.22493093e-02f, 1.40922712e-02f, 2.89960373e-02f, -1.47426859e-01f, 6.33409545e-02f, -2.16639578e-01f, -1.32481724e-01f,
  -2.94209309e-02f, 5.99206649e-02f, -2.35422961e-02f, 8.18241462e-02f, -8.44422281e-02f, 7.39148781e-02f, -1.42233491e-01f, 1.01201072e-01f, -1.57894507e-01f, 1.19163394e-01f,
  -4.96704914e-02f, 7.82117769e-02f, -1.34026378e-01f, 3.41400951e-02f, -1.11977927e-01f, 4.15817164e-02f, -1.03810906e-01f, 2.94489831e-01f, -1.03160277e-01f, -1.41499490e-01f,
  -7.48879835e-02f, -1.17196143e-01f, 1.33322462e-01f, 3.08227628e-01f, 1.63694307e-01f, 3.12752016e-02f, 5.53414784e-02f, -1.10363975e-01f, -9.60031226e-02f, -9.35696065e-02f,
  1.25422820e-01f, 7.55619928e-02f, 2.18348190e-01f, -4.69974838e-02f, 4.28954437e-02f, 2.92562116e-02f, -4.31810543e-02f, -1.41897723e-01f, 1.02208257e-01f, 1.70408592e-01f,
  -9.62119550e-02f, 4.69995476e-02f, 3.85332070e-02f, 8.78053308e-02f, -2.93162968e-02f, 1.14296846e-01f, 2.80135386e-02f, 6.24123141e-02f, -1.42842403e-03f, 3.39854285e-02f,
  4.60239574e-02f, 1.36696517e-01f, 9.00876001e-02f, -8.68249163e-02f, 4.17019613e-02f, -2.52652401e-03f, 4.47531044e-02f, -1.11059267e-02f, 6.85673729e-02f, -2.49593839e-01f,
  -4.95910831e-02f, -5.95168732e-02f, 1.82626322e-02f, -2.64340013e-01f, 2.36079842e-02f, 4.78884168e-02f, -2.39953659e-02f, -7.87134841e-02f, 7.46754650e-03f, 9.94612128e-02f,
  -7.62569010e-02f, 3.92606445e-02f, -8.78103003e-02f, -1.42864645e-01f, -1.14938915e-01f, -1.46388754e-01f, -4.35427390e-02f, -3.94095220e-02f, 1.74632326e-01f, -3.80683951e-02f,
  -4.77929153e-02f, 1.07929781e-01f, -2.15744048e-01f, 7.50927329e-02f, 1.26052499e-01f, -2.29364067e-01f, 1.83634713e-01f, -2.22567230e-01f, 1.69489712e-01f, -1.02275591e-02f,
  2.40693480e-01f, 1.88800856e-01f, -2.05446050e-01f, 6.90626130e-02f, 2.18153894e-01f, -2.34459639e-01f, 9.44203213e-02f, -2.85169214e-01f, 8.89532045e-02f, -1.21064886e-01f,
  8.91974419e-02f, -7.35297948e-02f, 1.07462123e-01f, -1.36952117e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 26)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 26;
const float L2_fan_Bp_bar_data[] = {
  -1.49307260e-02f, 3.60402875e-02f, 3.13101569e-03f, -8.68360698e-03f, 5.00188358e-02f, 6.83844686e-02f, -4.67197876e-03f, -8.97602923e-03f, -3.08635868e-02f, 5.53034917e-02f,
  4.24443670e-02f, 1.41990587e-01f, 8.59029964e-02f, 5.41274576e-03f, 8.58214945e-02f, 1.46786468e-02f, 1.06278859e-01f, 1.28029898e-01f, 6.97929189e-02f, 1.30831897e-01f,
  -1.10841002e-02f, 9.41096526e-03f, 1.82678141e-02f, 6.11486025e-02f, 4.29604994e-03f, -1.09517062e-02f
};

// L3_fan_Wp (Shape: 19 x 64)
const int L3_fan_Wp_rows = 19;
const int L3_fan_Wp_cols = 64;
const float L3_fan_Wp_data[] = {
  5.90656698e-02f, -5.23137450e-02f, 4.26184796e-02f, 2.82014944e-02f, -2.07501277e-02f, 1.59586087e-01f, 5.63281253e-02f, -3.88706587e-02f, 2.50467286e-02f, -7.42020085e-02f,
  4.84683886e-02f, 3.70693691e-02f, 1.63780376e-01f, 1.42229386e-02f, 4.00097445e-02f, -5.66741778e-03f, -2.79753245e-02f, -2.57780887e-02f, -9.22262017e-03f, 1.40140265e-01f,
  3.26369777e-02f, 2.62439507e-03f, -4.59244549e-02f, -3.82820517e-02f, -1.15016595e-01f, -1.40935794e-01f, -8.58321190e-02f, 1.42071210e-02f, 1.50623256e-02f, -3.95262726e-02f,
  1.85925849e-02f, -1.17409423e-01f, 2.55712681e-02f, -3.04760039e-02f, -3.53782997e-02f, 5.06700724e-02f, -2.13071182e-02f, 3.10181417e-02f, -2.13730522e-02f, 1.26318619e-01f,
  5.84119037e-02f, -1.02821961e-01f, -8.63825083e-02f, 2.08249576e-02f, 9.96714234e-02f, 3.65399718e-02f, -1.84143722e-01f, -7.26165026e-02f, -9.51744542e-02f, -1.11343391e-01f,
  1.08025253e-01f, 7.81941190e-02f, 4.85169664e-02f, 2.98046526e-02f, -1.04882017e-01f, -2.41259690e-02f, 1.05417237e-01f, -7.96930566e-02f, -1.40876826e-02f, -1.03881069e-01f,
  7.27881491e-02f, 1.29603604e-02f, -3.06174662e-02f, -6.33181408e-02f, -9.96323675e-02f, -3.87149304e-03f, -1.83077306e-02f, 1.68276764e-02f, 7.90815279e-02f, -6.75848080e-03f,
  -3.17832790e-02f, 6.39722198e-02f, 2.32441816e-02f, 9.34272818e-03f, 3.25162336e-02f, 3.09902243e-02f, -7.60861300e-03f, 2.13877596e-02f, 3.07301525e-02f, 6.59597339e-03f,
  -2.32484881e-02f, -7.08222240e-02f, -5.25364503e-02f, 1.42082549e-03f, -7.71223828e-02f, -3.16528417e-02f, -4.79889885e-02f, 7.13283569e-02f, -8.52411985e-03f, -3.94472806e-03f,
  -1.42060956e-02f, -5.61993346e-02f, 2.54248705e-04f, -5.61290905e-02f, -5.77663211e-03f, 1.82687212e-02f, -1.07505888e-01f, -7.93515742e-02f, -1.36763543e-01f, -4.50616367e-02f,
  4.42853896e-03f, 5.83438054e-02f, -1.41589016e-01f, -1.47017213e-02f, -8.90190676e-02f, 1.09284155e-01f, -1.03277370e-01f, -2.50120554e-02f, -6.00583386e-03f, 7.92461038e-02f,
  8.22371021e-02f, 3.18512879e-02f, -4.79356833e-02f, 3.71068120e-02f, 1.32124856e-01f, 9.56902876e-02f, 7.75198489e-02f, 5.20639867e-02f, 6.49731383e-02f, 1.38241537e-02f,
  1.62075505e-01f, -1.48023054e-01f, -6.68422431e-02f, 1.00220129e-01f, -3.85764502e-02f, -9.48892161e-02f, -9.70993340e-02f, -1.27554730e-01f, -8.04729164e-02f, 1.57664809e-02f,
  3.13058011e-02f, 5.09871617e-02f, -1.28913507e-01f, 6.53165430e-02f, 5.09439483e-02f, -1.30737433e-02f, 1.23807080e-01f, -4.15631048e-02f, 5.40291369e-02f, -2.20059883e-02f,
  1.45813212e-01f, 1.98547146e-03f, -3.20702679e-02f, 3.22749726e-02f, 1.35218306e-02f, -2.88950149e-02f, -2.79207318e-03f, 1.22934587e-01f, 6.79435860e-03f, -3.12563255e-02f,
  -9.17478204e-02f, -6.00603856e-02f, -5.19772060e-02f, -7.81290680e-02f, -1.14353187e-01f, -7.07388073e-02f, 5.96244121e-03f, -6.32517189e-02f, 8.78795865e-04f, -8.92850906e-02f,
  -8.28917399e-02f, -3.42919081e-02f, -9.18772668e-02f, 8.61165151e-02f, -8.73423442e-02f, 1.45949289e-01f, -1.06703881e-02f, 1.85105324e-01f, 1.28556117e-01f, -8.27597978e-04f,
  -1.01581424e-01f, -1.72185972e-02f, 1.04000650e-01f, -1.45434169e-02f, -1.32215723e-01f, -3.31007466e-02f, -3.09052598e-02f, -1.33860456e-02f, 1.25623830e-02f, 1.28856048e-01f,
  2.04808023e-02f, 8.30159616e-03f, -5.46178184e-02f, 6.78351372e-02f, 1.37236610e-01f, -7.51798078e-02f, 4.45937999e-02f, -1.03165977e-01f, -3.93775329e-02f, 6.01993985e-02f,
  2.07186933e-03f, 7.67818838e-02f, 7.97933191e-02f, -7.08126947e-02f, -2.41568498e-02f, 7.04968572e-02f, -7.80065283e-02f, 2.98526045e-02f, 2.03918871e-02f, -3.31502073e-02f,
  -3.18096466e-02f, -9.75293759e-03f, -7.79997278e-03f, 1.23031385e-01f, 9.11113471e-02f, -2.21352670e-02f, -1.09811975e-02f, -5.93916960e-02f, -3.37329768e-02f, 6.99939281e-02f,
  1.67935621e-02f, 7.04406649e-02f, 8.37572142e-02f, -3.44160348e-02f, 8.78504440e-02f, 4.92847115e-02f, -1.73428893e-01f, -3.10011841e-02f, -5.37789278e-02f, -3.58482413e-02f,
  -4.49225828e-02f, -2.98233666e-02f, 8.82080197e-02f, -1.58569038e-01f, 1.89253688e-02f, -3.98631953e-02f, -4.22028042e-02f, -1.03833061e-02f, 5.63905500e-02f, -6.16098680e-02f,
  -3.83118801e-02f, 1.25063166e-01f, 7.53009617e-02f, -3.80688049e-02f, -8.50232095e-02f, 1.37206959e-02f, 1.06083065e-01f, 8.39772299e-02f, -2.08078162e-03f, -1.31637603e-01f,
  -1.33600146e-01f, -1.45905867e-01f, -1.12695113e-01f, 1.14698969e-01f, -7.46519491e-02f, 4.76647131e-02f, 1.59774348e-02f, -4.06223908e-02f, 1.53552496e-03f, -1.11098729e-01f,
  -4.42380793e-02f, -5.52845858e-02f, -2.17963336e-03f, -1.16502628e-01f, -2.02715192e-02f, -1.79820791e-01f, 5.87581284e-02f, -1.27224186e-02f, 8.30762461e-02f, 3.55846211e-02f,
  5.97298658e-03f, 2.84599885e-03f, -4.64929640e-02f, 6.29344070e-03f, -3.55004966e-02f, -3.42094786e-02f, 9.16395411e-02f, 1.76324360e-02f, 4.79479656e-02f, -1.00585530e-02f,
  2.71343254e-02f, -1.87780447e-02f, 1.33442255e-02f, 1.31065145e-01f, 8.34522843e-02f, -1.23933302e-02f, 3.72627676e-02f, 5.54951653e-02f, -1.06504816e-03f, -7.42933899e-02f,
  -8.19105506e-02f, -1.18052587e-02f, -6.70951046e-03f, -9.28675698e-04f, 5.32885902e-02f, 6.54070601e-02f, 9.12140682e-02f, -2.89624780e-02f, 7.67271593e-03f, 1.07326694e-01f,
  1.00729860e-01f, 5.89417890e-02f, -1.11992145e-02f, 1.59397256e-02f, -1.36524681e-02f, -1.33583071e-02f, -1.96459815e-02f, 2.65349541e-02f, 3.66385207e-02f, 8.77767801e-02f,
  -1.55803904e-01f, -7.82298818e-02f, -3.15438323e-02f, -1.03000343e-01f, 2.19739377e-01f, 3.92510975e-03f, 9.85739604e-02f, -1.40762642e-01f, 9.72102582e-02f, -4.50643711e-02f,
  -8.29338953e-02f, 6.16357885e-02f, -6.53609540e-03f, -3.23228315e-02f, 8.43315721e-02f, -7.48019516e-02f, -5.46488017e-02f, -7.66129047e-02f, 8.36010277e-03f, -1.18753523e-01f,
  -4.36972380e-02f, -1.04507379e-01f, -4.11102436e-02f, 1.99057274e-02f, 9.28436294e-02f, 4.99025695e-02f, -7.46833384e-02f, -2.84451414e-02f, 1.08719707e-01f, -9.51216817e-02f,
  -8.69594291e-02f, -4.41972129e-02f, 1.25638004e-02f, 6.51590303e-02f, 8.88224393e-02f, 4.88653705e-02f, 1.48698371e-02f, 3.48045002e-03f, 4.17257920e-02f, -8.54282081e-02f,
  -6.01226650e-03f, 4.94669452e-02f, -4.43349555e-02f, -1.05369717e-01f, 3.07839527e-03f, 2.38566101e-02f, -5.73166721e-02f, 4.77389731e-02f, 6.53604642e-02f, -1.21724032e-01f,
  1.56745896e-01f, -2.45494377e-02f, 3.12710702e-02f, 5.30433133e-02f, -2.90097408e-02f, -2.59967875e-02f, 3.67147401e-02f, 9.37925726e-02f, 3.28916982e-02f, 9.37783048e-02f,
  4.35833745e-02f, 1.14908524e-01f, -1.63758636e-01f, -8.58802050e-02f, -1.09429896e-01f, -5.34900688e-02f, -8.02971423e-02f, -1.54260606e-01f, 9.40381959e-02f, -1.19903073e-01f,
  1.85638025e-01f, 8.70302320e-02f, 8.19201693e-02f, 1.87358055e-02f, -1.25258625e-01f, -1.63930077e-02f, 1.06075451e-01f, -1.04694389e-01f, 3.98906060e-02f, 1.10215701e-01f,
  3.11098788e-02f, -4.40899469e-02f, 6.95190653e-02f, -7.18774647e-02f, 2.43330840e-02f, 6.15116842e-02f, -1.29716229e-02f, -1.41033800e-02f, -4.72010486e-02f, 2.78969556e-02f,
  1.05167411e-01f, -3.41342352e-02f, -1.54689983e-01f, -2.34346720e-03f, -9.44947451e-02f, 1.17242053e-01f, 4.46275361e-02f, -1.17909782e-01f, -1.28586948e-01f, -1.42447785e-01f,
  -4.39559063e-03f, -4.15804461e-02f, -2.42340807e-02f, 4.77940589e-02f, 1.86365340e-02f, -5.86513914e-02f, 6.64166966e-03f, 5.32264151e-02f, 6.55856505e-02f, -2.20623463e-02f,
  -1.68065559e-02f, 5.48123978e-02f, -5.58602028e-02f, 6.66065663e-02f, -1.10407956e-01f, 9.17731691e-03f, 1.09723233e-01f, -1.55713912e-02f, 1.37119843e-02f, -6.45622537e-02f,
  -6.73831478e-02f, 4.08468992e-02f, -6.78366050e-02f, -2.41852477e-02f, -7.27795735e-02f, -2.08146516e-02f, -2.11330317e-02f, -1.70617085e-02f, 6.05636910e-02f, 2.90956646e-02f,
  6.77232668e-02f, 4.87121269e-02f, -2.25276992e-01f, -1.87328123e-02f, -1.99401617e-01f, 6.71520680e-02f, -1.51624545e-01f, 7.74522945e-02f, 4.64492925e-02f, -1.51063204e-01f,
  3.66542414e-02f, 3.34050097e-02f, -5.00035770e-02f, -3.28848581e-03f, 2.77041532e-02f, 1.02014452e-01f, -8.71039480e-02f, -7.27763027e-02f, 1.29449487e-01f, 4.98459078e-02f,
  -2.12243460e-02f, 3.17745246e-02f, 2.10711695e-02f, 3.63826416e-02f, 1.00606583e-01f, 6.92244396e-02f, -1.26916498e-01f, 1.31052658e-01f, 4.76240329e-02f, 3.89495073e-03f,
  3.18087190e-02f, -8.00756067e-02f, 2.43405234e-02f, -1.21723019e-01f, 9.27125011e-03f, 1.17257692e-01f, 9.28369164e-02f, 1.67113930e-01f, -7.13835880e-02f, 6.50079772e-02f,
  7.69476667e-02f, 7.12208673e-02f, -1.25714794e-01f, 4.60400097e-02f, -4.74759452e-02f, 1.80347543e-02f, -3.05234920e-02f, -3.87754254e-02f, -5.18305488e-02f, -1.17648415e-01f,
  -2.21549207e-03f, 1.78033933e-02f, 9.72575098e-02f, -1.40976598e-02f, -3.34311463e-02f, -1.82952229e-02f, -2.21539244e-01f, 9.86633897e-02f, -6.25116825e-02f, 8.22491199e-03f,
  1.82383224e-01f, 4.90668975e-02f, -6.40275404e-02f, 1.80827692e-01f, 1.23913996e-01f, 2.95082014e-02f, -1.13784216e-01f, -8.79857242e-02f, -3.20316330e-02f, 8.39887932e-02f,
  -9.39936563e-02f, -1.16846198e-02f, -7.50016561e-03f, -1.26777008e-01f, -6.39241636e-02f, 6.01753555e-02f, -2.01250669e-02f, -4.53968719e-02f, -1.36408001e-01f, -8.90449733e-02f,
  5.02763502e-02f, -2.22560652e-02f, 5.88949919e-02f, 4.86104041e-02f, -2.47772201e-03f, -4.01687697e-02f, -1.28973782e-01f, 8.61952752e-02f, 2.70747636e-02f, -7.14049712e-02f,
  -8.70546699e-02f, 6.95378482e-02f, 3.09776906e-02f, 5.74088804e-02f, 3.03847641e-02f, -1.93459019e-02f, -6.81215078e-02f, -6.79654554e-02f, 3.53666246e-02f, -3.31337787e-02f,
  2.56999377e-02f, -1.74191948e-02f, -1.49336874e-01f, -8.86918753e-02f, -2.50793770e-02f, 5.28181903e-02f, 1.93683282e-01f, 7.94244856e-02f, -9.97124836e-02f, -5.43883331e-02f,
  9.54915211e-03f, -1.03993781e-01f, -1.66298464e-01f, 1.82474986e-01f, 1.84647664e-02f, 6.01193123e-02f, -4.20439392e-02f, -6.33695796e-02f, 1.53027689e-02f, -1.86228920e-02f,
  -1.62197966e-02f, -8.52771252e-02f, -2.13939309e-01f, 7.47278035e-02f, -1.10703051e-01f, -7.10436031e-02f, -8.48547220e-02f, 5.47359809e-02f, 1.59985632e-01f, 1.89974040e-01f,
  -4.70370650e-02f, -1.18664447e-02f, 3.73138413e-02f, 2.29175184e-02f, -6.18239231e-02f, 1.03753835e-01f, 6.53480645e-04f, -6.91023022e-02f, -3.54144610e-02f, 1.15862954e-02f,
  -1.14411898e-01f, 9.89487395e-02f, -2.31757737e-03f, 1.07865676e-01f, -1.30309716e-01f, 3.98927741e-02f, -1.30732715e-01f, -9.31929499e-02f, -5.91397323e-02f, -9.66853499e-02f,
  9.58263874e-03f, -1.16649359e-01f, -8.45787078e-02f, -9.98990312e-02f, 1.15102410e-01f, -1.40830979e-01f, -3.38796936e-02f, -1.21442035e-01f, -3.48429382e-02f, -1.88570227e-02f,
  -7.54775926e-02f, 1.03769474e-01f, -9.69391912e-02f, -1.45705462e-01f, -8.45624432e-02f, -2.70070992e-02f, -2.12692786e-02f, -6.10602014e-02f, -9.63314548e-02f, -7.69972205e-02f,
  3.41465138e-02f, -4.34187092e-02f, -1.13756493e-01f, 2.94781774e-02f, 9.60060954e-03f, -2.17400994e-02f, -1.31089151e-01f, -4.17457931e-02f, 2.83469982e-03f, 2.87715252e-03f,
  1.86660197e-02f, 4.53902707e-02f, -8.61282181e-03f, 6.56471923e-02f, 1.06220432e-01f, 1.10383451e-01f, -8.86838883e-02f, -4.14615534e-02f, -9.67803150e-02f, -4.73935679e-02f,
  -1.19798161e-01f, -3.73665281e-02f, -1.00158103e-01f, -7.43762180e-02f, -1.33261964e-01f, 3.82609330e-02f, -1.49821371e-01f, 2.37761587e-02f, -1.29534125e-01f, 6.08488545e-02f,
  -1.73818484e-01f, -1.72089845e-01f, -1.38285860e-01f, 5.72780818e-02f, -3.08992211e-02f, -5.13622304e-03f, 7.70987868e-02f, 1.34332493e-01f, -9.62572768e-02f, 1.44549698e-01f,
  3.21591715e-03f, 3.92880924e-02f, 2.76175793e-02f, 6.61622882e-02f, -2.30897833e-02f, 7.77031928e-02f, -1.08781112e-02f, -3.84254456e-02f, 2.66769137e-02f, 1.78816670e-03f,
  2.87608933e-02f, 1.06489427e-01f, -6.02180399e-02f, 4.40785065e-02f, 6.60373867e-02f, 2.87503507e-02f, -6.14279471e-02f, 7.75436871e-03f, -3.02956272e-02f, -5.17585389e-02f,
  -8.72665942e-02f, -5.85736632e-02f, -1.53120952e-02f, 3.36776823e-02f, 9.31974202e-02f, 9.78590176e-02f, 3.71311456e-02f, -2.60320250e-02f, 8.07127431e-02f, -9.36248153e-02f,
  5.52546419e-02f, 5.34761250e-02f, -3.81408222e-02f, -1.98893249e-02f, 2.97874473e-02f, -6.32586004e-03f, 2.14634892e-02f, 1.23681277e-02f, -1.18949898e-01f, 4.03407924e-02f,
  -6.52890280e-02f, 1.48740038e-01f, -1.33670673e-01f, -9.81419757e-02f, 8.78698975e-02f, 1.66743919e-02f, -3.39757800e-02f, 5.65000214e-02f, 6.66186437e-02f, -1.84852313e-02f,
  8.49988237e-02f, 3.88721898e-02f, 5.63377626e-02f, 1.06605709e-01f, 5.02481163e-02f, -1.11395912e-03f, -1.84918474e-03f, -5.03133945e-02f, -4.84101027e-02f, 1.07912362e-01f,
  -9.89405513e-02f, -9.25295800e-02f, -6.42188489e-02f, -4.27241437e-02f, 2.26453114e-02f, 5.86123355e-02f, -5.68381175e-02f, -4.60696667e-02f, -6.07361645e-03f, -4.99899387e-02f,
  -3.34855504e-02f, -1.30363386e-02f, 2.67392839e-03f, -2.30571963e-02f, -1.91442147e-02f, -5.13005778e-02f, -1.00669518e-01f, 3.77161428e-02f, 9.31784045e-03f, 5.99898621e-02f,
  -1.21661648e-01f, 1.52968066e-02f, -5.20797819e-02f, -7.96239078e-02f, 5.71801327e-02f, 1.09345131e-01f, 9.52773616e-02f, -3.14772055e-02f, -7.50605389e-02f, -1.14625551e-01f,
  1.33080289e-01f, -1.37353977e-02f, -3.96733619e-02f, 4.14230935e-02f, 9.45049971e-02f, -1.08943157e-01f, -4.92945276e-02f, 3.67242433e-02f, -1.03576861e-01f, 6.78445250e-02f,
  -4.82372865e-02f, 8.80883038e-02f, 1.78070113e-01f, 1.17940344e-01f, 9.00424272e-03f, 2.26353575e-02f, 1.38168126e-01f, 2.25895476e-02f, 5.42637073e-02f, -1.06482536e-01f,
  -1.03082754e-01f, -2.35014439e-01f, 1.03923611e-01f, -1.14470169e-01f, -8.51911977e-02f, -5.31772077e-02f, 1.08717456e-01f, -5.88087887e-02f, -1.16195926e-03f, 1.98720306e-01f,
  3.99588943e-02f, 8.14081286e-04f, 1.38986379e-01f, -2.15945587e-01f, -1.15739079e-02f, 3.74130253e-03f, 2.50852760e-03f, 6.06278377e-03f, 1.01335682e-02f, -6.65953457e-02f,
  -1.93679556e-02f, -5.41751385e-02f, 6.26853928e-02f, 1.30362809e-01f, 1.07592955e-01f, 6.76384941e-02f, -5.47540076e-02f, 6.80851489e-02f, 5.90776429e-02f, 1.39487907e-01f,
  7.72713497e-02f, 3.76436375e-02f, 2.75664665e-02f, -5.00342026e-02f, 3.42494845e-02f, -9.85828787e-02f, -7.68652633e-02f, 3.21774147e-02f, 6.69630989e-02f, 8.40200111e-03f,
  3.28097194e-02f, 1.02587342e-01f, -1.53760170e-03f, 3.97563763e-02f, -1.82366110e-02f, 1.15648136e-02f, -1.04559533e-01f, -3.14754285e-02f, -4.93078008e-02f, 1.12294434e-02f,
  -2.80402713e-02f, -1.57990500e-01f, 3.59792672e-02f, -2.42493879e-02f, 4.53221649e-02f, -2.80645136e-02f, -1.52694449e-01f, 6.48693815e-02f, 1.59119237e-02f, -4.45531644e-02f,
  5.78842536e-02f, -2.92904750e-02f, -1.06128611e-01f, 1.08939260e-01f, 4.82500764e-03f, 9.82390940e-02f, -1.44836172e-01f, -4.78087254e-02f, 5.16697951e-02f, 8.98859054e-02f,
  -1.20681062e-01f, -2.44264845e-02f, 2.04864200e-02f, -9.58548263e-02f, 2.07046475e-02f, 4.81673814e-02f, -5.99932969e-02f, 1.07126020e-01f, -2.02917345e-02f, -1.05907701e-01f,
  1.14335474e-02f, 7.05154762e-02f, -2.55838949e-02f, -4.20709662e-02f, -9.92688816e-03f, -2.48964373e-02f, 2.33464278e-02f, -4.03462015e-02f, 9.27511416e-03f, 5.42977527e-02f,
  2.33745500e-02f, -1.30296543e-01f, 1.51096787e-02f, -3.18189971e-02f, -5.02408855e-02f, -5.04714176e-02f, 2.97403103e-03f, 3.51750739e-02f, 3.17901373e-02f, -1.11591972e-01f,
  2.80945841e-02f, -8.41606408e-02f, -8.15379396e-02f, 2.58565098e-02f, -1.37320861e-01f, -4.33253832e-02f, 8.53074640e-02f, 5.43104410e-02f, 1.23018380e-02f, 2.70302948e-02f,
  5.88606708e-02f, 1.27893139e-03f, -8.72642547e-02f, 5.09399697e-02f, -6.33423179e-02f, 1.13693075e-02f, -2.39274595e-02f, -1.74590200e-02f, -4.58332039e-02f, 2.39075664e-02f,
  1.30907595e-01f, -3.46752070e-02f, -8.05442259e-02f, -1.13917254e-01f, 5.06348759e-02f, 6.84508458e-02f, -7.83518888e-03f, -7.23053291e-02f, 5.09722233e-02f, 5.38175786e-03f,
  -3.92340326e-07f, 1.33264765e-01f, 5.31097613e-02f, -9.06610116e-02f, -1.16476260e-01f, -5.45334676e-03f, 2.12891623e-02f, -5.76730818e-02f, -7.24589825e-02f, 1.29175186e-02f,
  2.70464038e-03f, -1.07152991e-01f, 1.14746965e-01f, 3.90418842e-02f, 7.54041746e-02f, 8.00727978e-02f, 7.14978576e-02f, -4.39780205e-02f, 2.57821265e-03f, -2.27031428e-02f,
  3.50757828e-03f, -5.03864698e-02f, 3.30893099e-02f, 1.64007042e-02f, 1.94402449e-02f, 7.43260086e-02f, -2.88640428e-02f, 4.45135590e-03f, -9.00435299e-02f, 5.53832296e-03f,
  2.41719391e-02f, -5.94425723e-02f, -2.49342024e-02f, -5.05288653e-02f, -1.42271174e-02f, -1.51687339e-01f, -3.35597768e-02f, -1.00759275e-01f, -3.36102769e-03f, -4.80850413e-02f,
  1.47624969e-01f, 1.05134554e-01f, -2.32301615e-02f, 4.63784039e-02f, 3.84375490e-02f, 1.53623866e-02f, 1.76344402e-02f, 8.94043297e-02f, 7.67234191e-02f, -3.56804095e-02f,
  1.35723084e-01f, -1.53142020e-01f, -4.97368127e-02f, -1.45899087e-01f, -1.41259924e-01f, -1.94378033e-01f, -1.36695832e-01f, 6.54452443e-02f, -1.90654904e-01f, -3.67860869e-02f,
  -1.54452950e-01f, -8.39817822e-02f, 9.15405080e-02f, 1.27185047e-01f, 5.94045743e-02f, -4.07135338e-02f, -1.05565690e-01f, -6.71856403e-02f, -1.32509232e-01f, 4.50679995e-02f,
  -1.29570007e-01f, -1.40877470e-01f, -9.08901636e-03f, 6.45484822e-03f, -8.30916613e-02f, 7.69034773e-02f, 6.31577000e-02f, 7.51950741e-02f, 3.26328799e-02f, -1.12130173e-01f,
  4.02801037e-02f, -9.73077044e-02f, 1.66522525e-02f, -4.67519052e-02f, 3.92270386e-02f, -1.15106978e-01f, 2.34624762e-02f, 3.49060632e-02f, -2.44473349e-02f, -1.77668128e-02f,
  -5.74802868e-02f, -7.62881245e-04f, -4.06281613e-02f, -1.63932983e-02f, -4.68721353e-02f, -1.15287594e-01f, 9.70693957e-03f, 1.82750672e-02f, -2.75137164e-02f, 8.90290961e-02f,
  7.33725578e-02f, 9.72025916e-02f, -3.90067883e-02f, -9.13835317e-03f, -1.36757001e-01f, -4.86961231e-02f, -1.93913672e-02f, 3.28020118e-02f, -7.72296339e-02f, 3.81130725e-02f,
  1.20277800e-01f, -1.57752395e-01f, 2.80988365e-02f, -2.30331440e-02f, -4.68717627e-02f, 2.90692225e-02f, -1.80183258e-02f, -1.57356635e-02f, -5.00917360e-02f, 1.40115142e-01f,
  8.65849704e-02f, -8.02001357e-02f, 7.44976252e-02f, -1.86660588e-02f, 6.65822718e-03f, 4.75808978e-02f, -6.23019077e-02f, -7.97294229e-02f, 3.10507193e-02f, -7.04896599e-02f,
  8.04811046e-02f, 4.51789796e-03f, 1.37439594e-02f, 1.10396305e-02f, 4.54604886e-02f, 1.63086094e-02f, 1.03676938e-01f, -8.45301375e-02f, 8.89278278e-02f, -6.34553879e-02f,
  -9.94927287e-02f, -1.01997353e-01f, -6.27920106e-02f, -1.82941079e-01f, 5.29749729e-02f, 8.29040334e-02f, -6.83789235e-03f, 3.59099731e-02f, -1.15314536e-02f, 3.08572799e-02f,
  5.15030921e-02f, 4.20908630e-02f, -1.19161252e-02f, 7.90022090e-02f, 8.25823918e-02f, 1.75177362e-02f, 2.06080191e-02f, 2.11382415e-02f, 2.86860075e-02f, 1.50818506e-03f,
  5.22062294e-02f, 1.15137003e-01f, 1.02739401e-01f, 2.55756285e-02f, 2.89300401e-02f, 2.68424824e-02f, 1.36364415e-01f, 1.10002220e-01f, -1.05698280e-01f, 6.83690533e-02f,
  -6.34463097e-04f, -4.74348739e-02f, 1.37342568e-02f, 4.21082452e-02f, 1.21982209e-01f, -7.60927796e-02f, -7.81104416e-02f, -1.30931213e-01f, -7.54393041e-02f, -5.99603206e-02f,
  7.57338060e-03f, -1.11648902e-01f, -1.71397120e-01f, 9.86706000e-04f, 8.75912085e-02f, -4.14469168e-02f, -1.48142502e-02f, -5.74603491e-02f, 2.07263321e-01f, -1.26684466e-02f,
  6.36602640e-02f, -8.63828510e-02f, -4.83609550e-02f, -1.67859271e-01f, 7.93576911e-02f, 1.80432767e-01f, 1.67522535e-01f, 1.15634792e-01f, 1.65507779e-01f, 1.42477915e-01f,
  1.29644275e-01f, -9.08681005e-02f, 1.61279179e-02f, -2.97550242e-02f, -1.55294672e-01f, -1.05856217e-01f, 5.16776741e-02f, -1.03423759e-01f, -5.12161441e-02f, -5.59365936e-02f,
  3.13997976e-02f, -8.88698325e-02f, -1.51474446e-01f, 3.73259000e-02f, 4.57810275e-02f, -7.62355030e-02f, -5.14688008e-02f, 6.08891174e-02f, -8.18741694e-02f, -4.87108044e-02f,
  8.31430405e-02f, -1.35721684e-01f, -4.04801313e-03f, -9.26897898e-02f, -2.20483802e-02f, 4.08960367e-03f, 1.00985589e-02f, -7.92006999e-02f, -5.33622690e-04f, 5.85023984e-02f,
  7.94884339e-02f, 8.77138898e-02f, -4.25790660e-02f, 6.28047585e-02f, 6.14409372e-02f, 1.38218720e-02f, -4.04906496e-02f, 1.61083834e-03f, 3.19383182e-02f, 8.29898752e-03f,
  -3.14272903e-02f, -1.55319031e-02f, -2.56095696e-02f, -3.61088254e-02f, -8.89096484e-02f, 4.14530747e-03f, -5.44694886e-02f, -1.09544963e-01f, 6.64346525e-03f, 5.44661805e-02f,
  8.76549706e-02f, -1.38590351e-01f, 1.49209142e-01f, -7.51404464e-02f, 1.16100952e-01f, -2.44188365e-02f, -7.68932328e-02f, -1.08372085e-01f, -5.82726719e-03f, -4.57343161e-02f,
  3.58524583e-02f, -3.67332324e-02f, 1.04869835e-01f, 6.40918408e-03f, 1.08906567e-01f, -2.94616669e-02f, -1.06306396e-01f, 5.00147324e-03f, -1.01729473e-02f, -4.84125316e-02f,
  -1.35806680e-01f, -1.73033044e-01f, -1.86377000e-02f, -1.08089736e-02f, 2.54483391e-02f, 3.94457057e-02f, 3.59858833e-02f, -4.51605879e-02f, -3.39317694e-02f, 7.07515180e-02f,
  -2.13571079e-03f, 3.12429871e-02f, 4.77954671e-02f, 5.81749231e-02f, -4.02331389e-02f, 3.06407791e-02f, -3.11834126e-04f, -4.76144850e-02f, 1.68508627e-02f, -5.67748770e-02f,
  6.51367754e-02f, -8.63389224e-02f, -1.32988796e-01f, -8.91461000e-02f, -6.04059398e-02f, -4.00006883e-02f, 2.54299063e-02f, 1.23126201e-01f, -6.13545999e-02f, -1.98335443e-02f,
  5.55350743e-02f, -3.65274847e-02f, -9.78213921e-02f, 8.89343023e-02f, -1.95145421e-02f, -6.91826940e-02f, 5.82382232e-02f, 4.05301228e-02f, -2.39664689e-02f, -1.11527527e-02f,
  -2.02750459e-01f, 6.81261048e-02f, -1.27085403e-01f, -4.61797491e-02f, -1.88637689e-01f, -5.06809540e-02f, -1.92101449e-01f, 4.57969569e-02f, 9.67672244e-02f, 1.40044898e-01f,
  -1.88902780e-01f, 5.31209260e-02f, -5.32475747e-02f, -7.28755891e-02f, -5.52203171e-02f, 9.50778648e-02f, -7.34694749e-02f, -6.87076449e-02f, -6.89859763e-02f, -7.36424653e-03f,
  -1.09807722e-01f, 1.70530766e-01f, 3.49956974e-02f, -5.29707931e-02f, 1.44366613e-02f, -6.93675503e-02f
};

// L3_fan_Wp_bar (Shape: 26 x 64)
const int L3_fan_Wp_bar_rows = 26;
const int L3_fan_Wp_bar_cols = 64;
const float L3_fan_Wp_bar_data[] = {
  6.41158298e-02f, -4.12300341e-02f, 5.59405945e-02f, 7.56992698e-02f, 9.94536504e-02f, -6.69167191e-02f, 1.15035422e-01f, 2.29987428e-01f, -4.97756042e-02f, 8.32883045e-02f,
  7.78105631e-02f, -5.53982072e-02f, -4.45166305e-02f, 7.39763230e-02f, 6.62156865e-02f, -1.31297261e-02f, 1.03969462e-01f, 6.17329217e-02f, 1.40488982e-01f, 1.32926181e-01f,
  6.30910024e-02f, 1.35670573e-01f, -1.79888699e-02f, 1.08148023e-01f, -2.34813586e-01f, 1.54841517e-03f, 1.21495910e-01f, -4.71023144e-03f, -4.99067754e-02f, 2.90289167e-02f,
  1.46366298e-01f, -2.31038272e-01f, -4.55437191e-02f, -6.43513799e-02f, 7.61238039e-02f, 4.00245711e-02f, 1.37901396e-01f, 7.07568079e-02f, -4.92401347e-02f, 1.90125957e-01f,
  2.87417978e-01f, -4.04401645e-02f, 3.12380612e-01f, 1.73672348e-01f, 7.54296854e-02f, -5.51231652e-02f, 7.35611245e-02f, -1.42626971e-01f, 1.13637887e-01f, -7.09888786e-02f,
  1.69692561e-01f, 2.16055498e-01f, 2.41611183e-01f, -5.74346446e-02f, 2.41168201e-01f, 1.63483277e-01f, 1.93349242e-01f, 1.00963958e-01f, 2.27684841e-01f, 5.37398346e-02f,
  2.66209058e-02f, -2.18297988e-01f, 1.97737500e-01f, -3.21016125e-02f, -4.96803634e-02f, -2.31312569e-02f, -3.24386582e-02f, -5.16779423e-02f, -1.06893800e-01f, -3.44673693e-02f,
  -5.85613698e-02f, -1.88107297e-01f, -4.51905020e-02f, -9.06855091e-02f, -1.18021414e-01f, -5.88370115e-03f, 5.89378774e-02f, -5.35043180e-02f, -7.65813664e-02f, -2.12880541e-02f,
  -8.79302099e-02f, -1.15199521e-01f, -7.06707314e-02f, -3.35389487e-02f, 4.38545607e-02f, -7.50355944e-02f, -1.14858009e-01f, -1.54573247e-01f, 7.88915008e-02f, -7.66531080e-02f,
  8.14142451e-03f, 5.26185893e-02f, -2.88481228e-02f, 8.90910178e-02f, -1.36174470e-01f, 5.96552789e-02f, 1.22678973e-01f, 1.72385469e-01f, -5.54731973e-02f, -4.62341355e-03f,
  -6.15417436e-02f, -1.34351794e-02f, 2.43944019e-01f, -1.46314010e-01f, -5.58407344e-02f, -1.45354509e-01f, -9.81067866e-02f, 1.68193236e-01f, -1.55210886e-02f, -9.49020758e-02f,
  -5.66825783e-03f, 2.22962182e-02f, -9.20249447e-02f, 7.29452819e-02f, -1.58702686e-01f, -1.08422972e-01f, -1.22056112e-01f, -1.19294167e-01f, -1.37702480e-01f, 3.85023579e-02f,
  -1.34422988e-01f, 7.45090619e-02f, -1.08089797e-01f, -6.63584024e-02f, 1.01268455e-01f, 3.02185655e-01f, 1.06556639e-01f, 8.22061524e-02f, 4.56756650e-04f, -5.70298992e-02f,
  -4.74310368e-02f, -2.43356284e-02f, -5.09148091e-03f, -4.30158637e-02f, -3.29398401e-02f, -5.00745550e-02f, -4.43325788e-02f, -3.94332893e-02f, -7.41867200e-02f, -1.97883938e-02f,
  -3.97128053e-02f, -5.49068712e-02f, -1.87833030e-02f, -3.52941491e-02f, -2.42418749e-03f, -2.69642286e-02f, -1.57194752e-02f, -1.07940054e-02f, 5.25042007e-04f, -3.11551988e-02f,
  -3.02864127e-02f, -1.73455775e-02f, -9.78519861e-03f, -3.59380478e-03f, -2.01502945e-02f, 2.46723667e-02f, 1.10819796e-02f, -8.32188316e-03f, -2.89134551e-02f, -8.67639389e-03f,
  2.20036283e-02f, 1.03078477e-01f, 6.74118008e-03f, -5.91965653e-02f, 1.83240287e-02f, -2.64597218e-02f, -5.56510054e-02f, 4.77950089e-02f, -1.97608173e-02f, 1.13155469e-02f,
  -9.42103863e-02f, -8.53991881e-02f, -1.85277835e-02f, 7.57934377e-02f, -1.72873307e-02f, -8.35153367e-03f, -9.46674496e-02f, -3.83312441e-02f, 1.42381461e-02f, 6.85250312e-02f,
  -9.20694470e-02f, 2.59609241e-03f, -8.00962821e-02f, -1.17674448e-01f, 2.55258214e-02f, -7.81157315e-02f, -3.36901061e-02f, -5.31591754e-03f, -2.35949289e-02f, -4.47672457e-02f,
  -8.31850097e-02f, -6.96491674e-02f, -1.23416632e-01f, 7.40568936e-02f, 4.00417857e-02f, 1.21714599e-01f, -7.64816478e-02f, -1.02509409e-02f, -1.17233746e-01f, -1.30209681e-02f,
  1.43702880e-01f, -9.90734100e-02f, 4.22306824e-03f, 7.72256702e-02f, 3.90472114e-02f, 3.88394557e-02f, -5.80368713e-02f, 1.06139533e-01f, -9.51917991e-02f, 4.46163714e-02f,
  4.21558805e-02f, 3.92760411e-02f, 1.17497094e-01f, 6.77191839e-02f, -9.13357213e-02f, 1.39831658e-02f, -1.53103352e-01f, -2.13274807e-01f, 7.31440857e-02f, -7.04876259e-02f,
  -9.27800387e-02f, 1.25159562e-01f, 9.42083597e-02f, -8.42143148e-02f, -6.36961833e-02f, -2.20160484e-02f, -3.13313715e-02f, 1.71680704e-01f, 7.63819441e-02f, 1.19518012e-01f,
  3.62451762e-01f, 2.61651814e-01f, 1.71059355e-01f, -2.11185724e-01f, 1.07445801e-02f, 1.91976242e-02f, 1.99729994e-01f, 6.03824183e-02f, -3.83440286e-01f, -2.50699669e-01f,
  6.62108064e-02f, 8.39778185e-02f, -4.48057167e-02f, 4.61246856e-02f, 1.73520401e-01f, -1.94668293e-01f, -9.67396365e-04f, 3.97079617e-01f, 9.31288227e-02f, 1.09647345e-02f,
  1.31166473e-01f, -1.56564176e-01f, 7.09066764e-02f, 1.38026848e-01f, 1.22485362e-01f, 2.36852720e-01f, 1.13377096e-02f, -2.40100604e-02f, -1.05960537e-02f, 9.57279727e-02f,
  -2.88087595e-02f, -2.90659517e-02f, 3.96128558e-02f, -3.87581661e-02f, -4.88482453e-02f, -1.47249326e-02f, 4.75543039e-03f, 6.38092458e-02f, 2.09540073e-02f, -2.21058186e-02f,
  -9.18397680e-02f, -1.58807752e-03f, 3.08756959e-02f, 1.14465185e-01f, 1.15890890e-01f, 5.49477488e-02f, 1.48619756e-01f, -9.92971379e-03f, -4.46648970e-02f, -1.03893422e-01f,
  -1.23644888e-01f, -2.74561327e-02f, 1.20928949e-02f, 1.78308725e-01f, -3.94643173e-02f, 1.26451463e-01f, 8.30666423e-02f, -1.26193345e-01f, 2.00235754e-01f, 1.83078483e-01f,
  1.84655651e-01f, -8.89775380e-02f, 1.33113131e-01f, -3.90180014e-02f, 1.22467391e-02f, 1.21172599e-03f, 1.79377094e-01f, -6.99253902e-02f, -4.83503565e-03f, 2.15691060e-01f,
  -6.61694780e-02f, -1.85914546e-01f, 4.92725782e-02f, 1.15832597e-01f, 1.01012118e-01f, -4.14604321e-02f, -5.19788750e-02f, -1.54688552e-01f, -4.90920320e-02f, 2.40312323e-01f,
  -1.58301473e-01f, 1.59727596e-02f, -1.97109375e-02f, 1.66335285e-01f, 5.57985753e-02f, 2.23124161e-01f, 5.84123917e-02f, 1.54850498e-01f, 1.97192058e-01f, -3.00079994e-02f,
  1.54069707e-01f, 2.86993018e-04f, 9.45124552e-02f, 9.00327403e-04f, -4.71267514e-02f, 9.35248062e-02f, 7.76823685e-02f, -8.84069409e-03f, -4.09610011e-02f, 1.85799785e-02f,
  -2.06971250e-04f, 7.28117675e-02f, 2.42826819e-01f, -4.69636507e-02f, 6.95718676e-02f, -1.12037979e-01f, 8.15775394e-02f, 1.23969823e-01f, 6.96226731e-02f, 8.04783553e-02f,
  1.09359972e-01f, 5.56473620e-02f, -7.33265746e-03f, -4.48771901e-02f, -1.95229366e-01f, -1.18518926e-01f, -6.59681782e-02f, -3.45880799e-02f, 4.20479628e-04f, -8.18108767e-02f,
  1.22477502e-01f, -2.73483753e-01f, 7.97702521e-02f, -6.13415241e-02f, -4.93776519e-03f, -1.05107576e-01f, -3.07191201e-02f, -6.03408627e-02f, -2.01703906e-01f, 1.55721068e-01f,
  2.25835234e-01f, 6.42434061e-02f, -1.57155842e-01f, -2.99612619e-02f, 2.04583228e-01f, -2.18475938e-01f, 3.85296084e-02f, -9.94245857e-02f, 6.58988878e-02f, -2.44925886e-01f,
  1.29129738e-01f, 1.80770084e-01f, -3.15008834e-02f, 3.30584407e-01f, -9.65203568e-02f, 1.38793513e-01f, 2.99581230e-01f, -2.20308214e-01f, 1.48299225e-02f, 2.11877927e-01f,
  -2.54202969e-02f, -9.53834504e-02f, 5.92162609e-02f, -3.74842018e-01f, 4.68327366e-02f, -8.85397866e-02f, -1.04240969e-01f, -4.14789878e-02f, 3.33634950e-02f, -3.36388350e-02f,
  -3.59271280e-02f, -5.83937652e-02f, -1.03253268e-01f, -1.38400435e-01f, -1.22243099e-01f, -1.23061657e-01f, -8.28690007e-02f, -7.57806748e-02f, 6.30465299e-02f, -8.93391892e-02f,
  4.01126733e-03f, 1.42052844e-01f, 4.49129827e-02f, 9.94468778e-02f, 1.13555446e-01f, 5.65220006e-02f, 7.42984861e-02f, -2.45185271e-01f, -4.48260196e-02f, -7.79481977e-03f,
  1.05705135e-01f, 2.54526287e-01f, -2.54929885e-02f, 1.34398058e-01f, 1.05720185e-01f, -9.48612913e-02f, 2.98902899e-01f, 3.69649231e-01f, 1.80027381e-01f, -7.82977715e-02f,
  9.38480943e-02f, -8.00964758e-02f, 4.93095838e-04f, -2.70342469e-01f, 1.37793615e-01f, -8.91236067e-02f, 1.38575166e-01f, 2.41659805e-01f, -1.87438607e-01f, -4.77442950e-01f,
  1.34337202e-01f, 1.55479640e-01f, 1.53243765e-01f, 7.88006335e-02f, 2.76796408e-02f, -4.21128809e-01f, 1.10326424e-01f, 1.64007526e-02f, -1.99565012e-02f, 8.85758027e-02f,
  -1.71951681e-01f, 2.52033770e-01f, -9.80841089e-03f, 5.06098829e-02f, 3.49910706e-02f, 1.10047400e-01f, 2.11894229e-01f, -6.46985620e-02f, -1.09716877e-01f, -6.25546277e-02f,
  -4.71809320e-02f, -1.93717331e-02f, -9.28078964e-02f, -8.77738185e-03f, -7.45197907e-02f, -8.63239616e-02f, 5.88272177e-02f, -1.68667540e-01f, -3.40521596e-02f, -1.20212825e-03f,
  6.64183646e-02f, 4.04772088e-02f, -8.63561332e-02f, 1.31768972e-01f, -7.08419271e-03f, -7.62639195e-02f, -1.58850115e-03f, 1.06722735e-01f, 9.60237458e-02f, -3.11087351e-02f,
  -1.69300109e-01f, -1.10664614e-01f, -3.96546349e-02f, -1.58966824e-01f, -1.86134167e-02f, 1.56229008e-02f, -1.77877452e-02f, 5.25071993e-02f, -2.75515430e-02f, -2.83810087e-02f,
  7.18064085e-02f, 1.38349816e-01f, -5.13845943e-02f, 2.68573556e-02f, 4.20326255e-02f, 1.15668543e-01f, 2.50766665e-01f, 1.19579181e-01f, 1.18358240e-01f, -1.40220165e-01f,
  -1.31738454e-01f, 1.74207404e-01f, 4.49559279e-02f, -4.84076068e-02f, -1.83019057e-01f, 7.42011666e-02f, 1.03305459e-01f, 2.08851770e-01f, -6.32057041e-02f, -4.16104421e-02f,
  -4.66108397e-02f, -8.32898766e-02f, -1.75683185e-01f, 1.69709459e-01f, -3.09951440e-03f, 1.83249235e-01f, -2.43222825e-02f, -1.58389449e-01f, 2.58283764e-01f, 3.06196541e-01f,
  1.21845812e-01f, 1.37013569e-01f, -3.74971218e-02f, 1.10532358e-01f, 1.28688335e-01f, 8.02706778e-02f, 1.40735522e-01f, 1.27999723e-01f, 2.28252355e-02f, 1.21219501e-01f,
  2.11472794e-01f, 1.13864474e-01f, 1.07609332e-01f, 5.37794791e-02f, -7.98407644e-02f, 1.24815919e-01f, 1.55428782e-01f, 2.03485504e-01f, 1.46979004e-01f, 2.56735981e-02f,
  5.32491915e-02f, -8.27624574e-02f, -1.04868442e-01f, -6.48552105e-02f, -5.17274402e-02f, 1.40143204e-02f, 1.11201014e-02f, 5.42386919e-02f, -9.34973508e-02f, -1.07956447e-01f,
  3.16309929e-02f, -4.71719690e-02f, 1.84945554e-01f, 6.03444278e-02f, -1.14568599e-01f, -1.55091003e-01f, 9.81211849e-03f, -1.72739364e-02f, -4.36708964e-02f, 7.28135109e-02f,
  -2.74672061e-01f, 1.38341188e-01f, 3.32632214e-02f, 2.89486766e-01f, -3.70383114e-01f, 5.73644899e-02f, -6.59842119e-02f, -5.75053394e-02f, 1.70316607e-01f, 1.77310243e-01f,
  2.60135531e-01f, 1.78812623e-01f, 3.24800104e-01f, 2.08424196e-01f, 2.01380309e-02f, 2.71673083e-01f, -1.63705707e-01f, -1.51376843e-01f, 8.19974691e-02f, -1.37952939e-01f,
  1.36577323e-01f, 3.37939799e-01f, 9.40105319e-02f, -2.02173963e-01f, 3.75363939e-02f, -1.75696701e-01f, 1.09288646e-02f, -2.96229981e-02f, 2.10964233e-02f, -9.56722200e-02f,
  2.17106510e-02f, -4.83079441e-03f, 1.13779930e-02f, 8.53862241e-03f, -8.97687674e-03f, 7.86193684e-02f, -2.33550631e-02f, -9.95213836e-02f, -3.33946757e-02f, 1.51967152e-03f,
  5.26308641e-02f, -1.23876423e-01f, 4.11864147e-02f, 5.13692088e-02f, -1.00857906e-01f, -1.10408612e-01f, -5.68250455e-02f, 4.42702062e-02f, 2.30945632e-01f, 1.02801561e-01f,
  6.93971440e-02f, 1.40162036e-01f, 1.61769334e-02f, 7.76835158e-02f, 7.57389516e-02f, 4.86712344e-03f, 8.06196481e-02f, 5.75302392e-02f, 5.02943769e-02f, 3.57463514e-03f,
  4.05860282e-02f, -9.43326503e-02f, -1.98807001e-01f, -1.66225329e-01f, -2.20031321e-01f, -2.96440095e-01f, -3.94395292e-02f, 2.53095955e-01f, 1.92845896e-01f, -3.39429304e-02f,
  4.55285609e-02f, -1.42035097e-01f, 3.47033173e-01f, 9.12938267e-02f, 1.36327833e-01f, -2.43369579e-01f, 1.43719569e-01f, 3.00664604e-02f, 2.52761543e-01f, 4.04563606e-01f,
  4.03695554e-01f, 8.11203495e-02f, 1.28983319e-01f, 7.42885936e-03f, -3.48568484e-02f, 2.13750005e-01f, -2.04238564e-01f, -2.36950397e-01f, 1.14380062e-01f, -2.87318677e-01f,
  4.69530560e-03f, 2.34660879e-02f, 1.00843333e-01f, 4.63645011e-02f, 8.31323713e-02f, 1.79716572e-02f, 8.13113749e-02f, 1.75187275e-01f, -4.32971353e-03f, -4.72169043e-03f,
  1.30520537e-01f, -3.62104960e-02f, 1.06422082e-01f, -6.23471960e-02f, 2.14617234e-02f, 3.56531739e-02f, 8.19219053e-02f, 7.76540535e-03f, 8.44741911e-02f, 4.51735929e-02f,
  -1.03260338e-01f, 1.18911356e-01f, -8.77667591e-02f, 4.47844565e-02f, -4.50214520e-02f, -4.43329476e-02f, 7.71510303e-02f, -9.56478640e-02f, 1.04779407e-01f, -4.98687625e-02f,
  1.11558914e-01f, -5.27732298e-02f, -2.02640384e-01f, -1.29229575e-01f, -1.63531020e-01f, 3.16475108e-02f, 6.52160570e-02f, 1.31262079e-01f, -8.74435678e-02f, 3.14611644e-01f,
  8.98817033e-02f, 2.10692823e-01f, 5.14433123e-02f, -1.36912778e-01f, 1.94819137e-01f, 6.86375871e-02f, -1.45974845e-01f, -1.30878448e-01f, 1.72719076e-01f, 1.34928793e-01f,
  2.62629867e-01f, 2.41573468e-01f, 1.26507685e-01f, -1.01911746e-01f, 1.10763460e-01f, 1.18243568e-01f, 2.04068661e-01f, -1.14669479e-01f, 1.08223036e-02f, 1.02922909e-01f,
  9.67558026e-02f, -2.56277975e-02f, -3.92256044e-02f, -8.02505948e-03f, -1.47842860e-03f, 1.40124662e-02f, 2.96163782e-02f, -5.08103818e-02f, -3.14205512e-02f, 5.06118648e-02f,
  6.50886819e-02f, -1.94011368e-02f, -1.35411382e-01f, -3.97982448e-02f, 4.04899679e-02f, -1.20229751e-01f, 7.23588392e-02f, -1.52758852e-01f, -6.32293299e-02f, -1.24008007e-01f,
  8.16641375e-02f, 5.84362354e-03f, 2.77873538e-02f, 5.75960949e-02f, -1.45611331e-01f, -1.35295941e-02f, 1.24658812e-02f, 6.80065826e-02f, 1.44910058e-02f, 2.07633860e-02f,
  -1.72991138e-02f, -8.54797661e-02f, 1.76877216e-01f, -1.52880058e-01f, -7.04888627e-03f, -2.94599961e-02f, -1.19386308e-01f, 8.01174119e-02f, -2.11403593e-01f, -4.20695394e-02f,
  -4.39375527e-02f, -4.49485630e-02f, -1.01846963e-01f, 1.93877324e-01f, -5.59035577e-02f, 2.18080655e-01f, 2.59545781e-02f, -2.66851664e-01f, 2.57690459e-01f, 3.81822847e-02f,
  -7.25330971e-03f, -1.94967344e-01f, 3.77923883e-02f, -1.71437234e-01f, 8.58717412e-02f, 1.56444445e-01f, 1.61735624e-01f, 1.16031714e-01f, 2.10764214e-01f, 4.29808954e-03f,
  1.64626345e-01f, -2.72848487e-01f, -9.20621380e-02f, 2.26061717e-02f, -2.13801518e-01f, -3.06744035e-02f, -2.02585548e-01f, -1.42899200e-01f, 8.88470188e-02f, 3.09693199e-02f,
  -4.91376147e-02f, -3.18887755e-02f, 1.12918597e-02f, 1.20124333e-02f, 4.57528904e-02f, -1.29638659e-02f, 1.57796927e-02f, 1.01297267e-01f, 8.33952278e-02f, 1.96836460e-02f,
  -2.98078507e-02f, 1.64741732e-03f, -6.11660164e-03f, 7.59843662e-02f, -4.95250262e-02f, -3.41591090e-02f, 1.46675771e-02f, -8.98582209e-03f, -1.21469274e-01f, -1.05917834e-01f,
  -1.01642944e-02f, -3.58359925e-02f, 1.49071127e-01f, 1.19277380e-01f, 4.69024479e-02f, 3.07597034e-02f, -3.11499760e-02f, -4.12555300e-02f, -1.39196828e-01f, 1.18875086e-01f,
  -1.44788241e-02f, -9.78808776e-02f, 6.03887960e-02f, 3.41426283e-02f, 2.95756329e-02f, 4.47112210e-02f, -1.75984222e-02f, 6.06162138e-02f, -2.74534672e-01f, 1.15787782e-01f,
  1.67228300e-02f, -4.48850542e-03f, -1.62309781e-01f, 1.24352597e-01f, 1.93992451e-01f, 3.34204465e-01f, -1.67468041e-01f, 1.58484966e-01f, -1.52448297e-01f, -2.36376747e-03f,
  -1.66773334e-01f, -2.06540525e-02f, -9.72596928e-03f, -2.22022548e-01f, -1.56487808e-01f, 1.04616240e-01f, -8.55432674e-02f, 2.06018791e-01f, 1.39350891e-01f, 1.64619967e-01f,
  7.84212649e-02f, 2.21817553e-01f, -1.80739257e-02f, 1.19887114e-01f, 3.81976292e-02f, 4.32473011e-02f, -7.19363987e-02f, -5.18705547e-02f, -2.40319706e-02f, 7.91432634e-02f,
  2.92862952e-02f, 8.09207410e-02f, 2.93107629e-02f, -8.39649215e-02f, -7.20726103e-02f, -9.26193316e-03f, 5.81384934e-02f, -8.08794647e-02f, -2.91744899e-02f, 3.42740193e-02f,
  -4.19401787e-02f, -1.44796148e-01f, -1.28019765e-01f, 7.48316422e-02f, 8.24741423e-02f, 1.66668549e-01f, 1.29758343e-01f, 1.38323069e-01f, 1.06135570e-01f, -5.62113598e-02f,
  7.70269334e-02f, 2.41974685e-02f, 1.78467929e-02f, 1.11408576e-01f, -1.09718442e-01f, -8.05137083e-02f, -8.39195848e-02f, 1.98369697e-02f, -1.35773197e-01f, -5.40154502e-02f,
  8.08855370e-02f, -1.35830700e-01f, 2.53086891e-02f, 2.66107172e-01f, 1.10475257e-01f, -1.40480295e-01f, 2.53721207e-01f, -9.86036137e-02f, 4.72284444e-02f, 5.50444089e-02f,
  1.36251956e-01f, -6.55269772e-02f, 9.20943692e-02f, 1.42507762e-01f, 2.30081573e-01f, 1.41801521e-01f, 1.77743822e-01f, 2.19020352e-01f, 1.30767405e-01f, -1.87980860e-01f,
  -7.05162734e-02f, 1.20136395e-01f, -2.28973895e-01f, -5.66829555e-02f, -1.93039700e-01f, -2.79078130e-02f, -2.65501179e-02f, 3.00439633e-02f, 6.16356544e-02f, -6.06190041e-03f,
  1.63781159e-02f, 4.72576730e-03f, -2.24836841e-02f, -4.42044251e-02f, 6.10707700e-02f, 1.69874262e-02f, -3.56359482e-02f, 3.18973102e-02f, -1.13618001e-01f, -3.19778137e-02f,
  6.15463927e-02f, 1.26940653e-01f, 1.36379376e-02f, -1.01370022e-01f, -3.32138091e-02f, -8.92944485e-02f, -1.28767893e-01f, -1.16885699e-01f, -9.42971110e-02f, -8.01025257e-02f,
  1.20953284e-01f, 4.85379919e-02f, -4.93756384e-02f, -4.61913943e-02f, 1.10871159e-02f, -6.48470297e-02f, -5.09497337e-02f, 1.18218251e-01f, 3.68850143e-03f, 8.01840201e-02f,
  3.37353535e-02f, -7.88085610e-02f, -6.93958020e-03f, 1.30860759e-02f, -6.75922930e-02f, 1.20882265e-01f, -1.40446484e-01f, 2.48745069e-01f, -3.58789742e-01f, 7.25916773e-02f,
  -1.15197971e-01f, 2.58586258e-01f, 2.11386204e-01f, 3.37096721e-01f, -7.90424943e-02f, 1.51575789e-01f, 1.15271442e-01f, 1.92777827e-01f, -2.31869724e-02f, 1.63370222e-01f,
  -6.03380799e-02f, -2.38490656e-01f, 8.17308296e-03f, 4.18893509e-02f, -8.85624290e-02f, 3.29878479e-01f, 3.01553994e-01f, 1.45266697e-01f, 6.46518171e-02f, 2.51729526e-02f,
  -1.23489782e-01f, 6.14687167e-02f, 6.04041405e-02f, 7.26949722e-02f, -6.16989583e-02f, 2.36988552e-02f, -4.50520813e-02f, -7.04893172e-02f, 5.39180934e-02f, -8.09690729e-02f,
  -8.26482661e-03f, 1.13940291e-01f, 1.01725556e-01f, 3.65947513e-03f, -3.46127488e-02f, 1.47953302e-01f, 7.58040522e-04f, -1.06730424e-01f, 1.60069987e-02f, 1.32568166e-01f,
  7.42007652e-03f, -9.34193954e-02f, -1.54062405e-01f, -9.40968618e-02f, -6.74136952e-02f, -2.11703509e-01f, -7.16932043e-02f, -2.14005977e-01f, -4.51336149e-03f, 2.60594673e-02f,
  -7.67499879e-02f, -5.63656799e-02f, -1.31312162e-01f, 5.19121140e-02f, -1.79265007e-01f, 2.28845745e-01f, 1.11148052e-03f, 1.51078925e-01f, 3.73749584e-01f, 5.27663827e-01f,
  1.07295096e-01f, -4.16107522e-03f, -1.38501883e-01f, 1.01219438e-01f, 1.39596716e-01f, 4.82025176e-01f, -3.28334928e-01f, -7.31894150e-02f, -2.65626889e-02f, 1.80240363e-01f,
  8.29283074e-02f, 2.65034616e-01f, 1.70673449e-02f, -1.65281415e-01f, -1.87656179e-01f, 2.35889673e-01f, 1.08816609e-01f, 6.01176620e-02f, 1.67048067e-01f, -1.71271220e-01f,
  2.48689085e-01f, 2.12787047e-01f, -7.91893527e-02f, 2.22964495e-01f, -6.65266663e-02f, -1.47190794e-01f, -1.04009369e-02f, -1.68532372e-01f, 2.62952503e-02f, 5.24623021e-02f,
  -9.99393836e-02f, -7.22128674e-02f, -1.85985286e-02f, -2.12245241e-01f, -1.40739292e-01f, -1.13406919e-01f, 2.99841259e-03f, -4.43329588e-02f, 4.31533456e-02f, -9.86944810e-02f,
  7.02475831e-02f, -1.47147521e-01f, -1.18394189e-01f, -4.08768244e-02f, -9.75416824e-02f, -6.19764253e-02f, -1.33047611e-01f, -1.98154107e-01f, 1.59135878e-01f, -1.45474803e-02f,
  -1.66659355e-02f, 2.37149950e-02f, 5.35496138e-02f, -2.81844456e-02f, -2.29209259e-01f, 1.73037291e-01f, 7.67878518e-02f, 2.94154674e-01f, -7.74787664e-02f, -1.11185955e-02f,
  -9.10195932e-02f, -5.27873784e-02f, 9.77929533e-02f, -2.49904790e-03f, -1.73754975e-01f, 9.73170623e-02f, -3.65031213e-02f, 1.38441548e-01f, -1.00224607e-01f, 9.54944268e-02f,
  1.57498285e-01f, 1.49927169e-01f, 1.02072977e-01f, 1.45371988e-01f, 1.48643225e-01f, 2.20173243e-02f, 1.72387436e-02f, 1.65192083e-01f, -7.10937232e-02f, -1.54284805e-01f,
  5.35852350e-02f, 5.95165230e-02f, -7.78534040e-02f, 9.15302336e-02f, 1.58128440e-01f, 2.10947290e-01f, 1.27544463e-01f, 9.59174184e-04f, -2.03587823e-02f, 3.49504352e-02f,
  -4.06069569e-02f, 6.41710162e-02f, -7.33351931e-02f, 7.40463220e-05f, 9.08330008e-02f, 6.66343700e-03f, 3.43631282e-02f, 7.14353248e-02f, 1.28212273e-02f, 9.47229378e-03f,
  1.13947215e-02f, -1.98947522e-03f, 3.69092785e-02f, 1.56979170e-02f, -1.15516230e-01f, 1.26552016e-01f, -6.50701895e-02f, 6.12493567e-02f, -4.04884182e-02f, 1.33701816e-01f,
  2.33498871e-01f, 2.14655086e-01f, -1.34773940e-01f, -5.64836301e-02f, 9.57681388e-02f, 1.99801046e-02f, -4.16763537e-02f, 8.85134265e-02f, 6.81085810e-02f, -1.27319813e-01f,
  1.33062880e-02f, -2.56207943e-01f, -4.86475974e-02f, 1.30962983e-01f, -4.70442884e-02f, 4.21924107e-02f, 2.76647598e-01f, -1.82232872e-01f, 1.28825590e-01f, 5.63987643e-02f,
  4.40652370e-01f, 9.05774534e-04f, 2.39003092e-01f, 3.66236456e-03f, 7.05499575e-02f, -3.46930884e-02f, -1.05419375e-01f, -2.40738899e-01f, -2.26590917e-01f, 2.85521280e-02f,
  9.34199914e-02f, 2.05573857e-01f, 3.13583404e-01f, 2.38801867e-01f, 3.10832299e-02f, 3.07942275e-02f, 1.09471031e-01f, 1.90593693e-02f, -2.68606991e-01f, 4.64154262e-04f,
  -8.05575028e-02f, 2.18873635e-01f, -2.92979237e-02f, 1.59109179e-02f, 1.14485130e-01f, -3.53722163e-02f, 6.03223220e-02f, -1.49127450e-02f, -5.27281091e-02f, -3.91180590e-02f,
  4.45352159e-02f, 6.45874068e-02f, 7.18858242e-02f, 1.20111957e-01f, 4.03558761e-02f, 3.97145674e-02f, 9.15405527e-02f, 1.19638517e-01f, -4.62138578e-02f, -1.85024217e-01f,
  -5.39794676e-02f, -1.26067683e-01f, -1.15828007e-01f, -7.72284195e-02f, -9.34019759e-02f, 1.23314947e-01f, 1.79651305e-01f, 6.88375980e-02f, -5.58176935e-02f, -2.20802695e-01f,
  -4.74292263e-02f, -1.25251368e-01f, -1.09622486e-01f, 1.52130082e-01f, -1.84637666e-01f, -2.85364687e-01f, -1.75754979e-01f, -2.29383279e-02f, -7.97413737e-02f, 4.38516494e-03f,
  1.02731735e-01f, 5.73446415e-02f, -7.61800483e-02f, 1.90395579e-01f, -9.09706205e-02f, -7.11786970e-02f, 2.74728704e-02f, 2.29974955e-01f, 3.60467173e-02f, 1.94845527e-01f,
  -1.43439353e-01f, 4.69825231e-02f, 1.59017682e-01f, 2.84511477e-01f, -9.00895074e-02f, 1.98088028e-02f, 1.11006737e-01f, -3.55788544e-02f, 1.43882796e-01f, -1.75890867e-02f,
  6.95398450e-02f, 1.85985819e-01f, 4.06455919e-02f, 4.41083163e-02f, -3.17318141e-02f, 9.62753892e-02f, 8.90924633e-02f, -1.86235756e-02f, 4.91291545e-02f, 7.01312274e-02f,
  7.60419667e-02f, -5.07961437e-02f, 1.00332022e-01f, 9.23778042e-02f, 2.40964927e-02f, 8.76118913e-02f, 3.51782851e-02f, -1.60373580e-02f, -5.15739433e-03f, 6.62948266e-02f,
  -8.24759621e-03f, 3.69359478e-02f, 1.41966507e-01f, 6.99366406e-02f, 1.29239753e-01f, 7.82289803e-02f, 1.62590131e-01f, 1.49540221e-02f, 1.94769092e-02f, -1.80818292e-03f,
  -8.03699791e-02f, -5.05778342e-02f, 3.52745838e-02f, 1.48898244e-01f, -6.20702133e-02f, 1.65288866e-01f, 2.63868395e-04f, -1.20103896e-01f, 8.68395418e-02f, 8.88015404e-02f,
  1.56220824e-01f, -1.13532037e-01f, 1.08637661e-01f, -9.68543962e-02f, -7.45317293e-03f, -5.97288720e-02f, 1.80426210e-01f, -4.43850942e-02f, 1.51084557e-01f, 3.55732471e-01f,
  -5.79319149e-02f, -9.76013318e-02f, 2.45991647e-02f, 1.58479139e-01f, 1.15593523e-01f, 1.19710259e-01f, -5.00105508e-02f, -1.29110038e-01f, 1.28339514e-01f, 2.64967140e-02f,
  1.40573075e-02f, 8.30596909e-02f, -1.02965701e-02f, 2.38272384e-01f, 1.96244642e-01f, 1.63147658e-01f, 1.60018295e-01f, 2.75859945e-02f, 3.36182505e-01f, -2.16934606e-02f,
  1.89690426e-01f, -2.87637915e-02f, -4.66650613e-02f, -2.96604764e-02f, -1.60460442e-01f, 3.91398259e-02f, 1.33619368e-01f, -2.59470008e-02f, -8.95333588e-02f, 8.92904922e-02f,
  1.93110537e-02f, 1.55800715e-01f, 1.18481964e-01f, -7.73965791e-02f, -2.50029713e-02f, -8.84096250e-02f, -8.91061574e-02f, 1.65254669e-03f, -2.28794012e-02f, 8.31100792e-02f,
  -1.14848595e-02f, -1.53674588e-01f, -4.03608056e-03f, -6.23308728e-03f, -1.15249595e-02f, 1.04089290e-01f, -5.32748513e-02f, 1.24629743e-01f, -1.21748028e-02f, -9.62442905e-02f,
  -8.44371468e-02f, 1.32809244e-02f, 1.48683012e-01f, -4.84053269e-02f, 1.38508320e-01f, -1.42052412e-01f, 2.74222959e-02f, -7.33833238e-02f, -1.26372904e-01f, -5.56578636e-02f,
  -1.36587977e-01f, 1.27099484e-01f, -2.95002982e-02f, -5.27895428e-02f, -5.07750027e-02f, 2.58186370e-01f, 8.67566019e-02f, 3.06215286e-01f, -4.90189016e-01f, 4.05816324e-02f,
  -1.34882525e-01f, 1.38195381e-01f, -4.06140506e-01f, 2.87457943e-01f, -6.08261563e-02f, -4.40139681e-01f, 3.38747501e-02f, 2.69290637e-02f, -1.88379332e-01f, 3.27993959e-01f,
  1.35290518e-01f, 6.18764535e-02f, -1.40436158e-01f, 1.01760030e-01f, -3.40312906e-02f, -4.13474105e-02f, -3.91157307e-02f, 1.09997682e-01f, -1.92197815e-01f, -8.04712102e-02f,
  -8.84617120e-02f, -7.22754523e-02f, -6.38524294e-02f, -1.06471926e-01f, -1.08800061e-01f, 2.55036261e-02f, -1.42176986e-01f, -3.83046046e-02f, -1.29880413e-01f, 5.96872065e-03f,
  -7.85120577e-02f, 2.56859651e-03f, 4.47364450e-02f, -6.80150986e-02f, -1.18895490e-02f, 6.24679849e-02f, 2.25767959e-02f, 9.49868932e-02f, -3.40037420e-02f, -7.17624277e-02f,
  3.63962092e-02f, 4.65857908e-02f, 2.77038179e-02f, 1.99341797e-04f, 3.78522351e-02f, -1.05196752e-01f, -4.63665798e-02f, 7.06433654e-02f, -4.45621051e-02f, 8.67387503e-02f,
  4.37713042e-02f, 4.66673933e-02f, 2.29501277e-01f, 1.81297824e-01f, 5.45497686e-02f, -6.84895436e-04f, 2.48228908e-01f, -6.46682084e-02f, 2.53274620e-01f, 3.51708412e-01f,
  -1.48597717e-01f, -1.72430068e-01f, -1.79649368e-01f, -1.20094158e-01f, -3.53366509e-02f, 1.36760071e-01f, 9.06631444e-03f, -5.31460717e-02f, 1.35547966e-01f, 1.04633786e-01f,
  7.35056214e-03f, 3.53032798e-02f, -2.59298738e-02f, 5.74379053e-04f, -6.19491674e-02f, -2.74744332e-02f, -6.14696927e-02f, 1.39631361e-01f, 1.80001650e-02f, 9.90618542e-02f,
  9.20593590e-02f, -1.26533173e-02f, 1.58644080e-01f, -2.26994250e-02f, 2.49646250e-02f, 1.90798715e-01f, 1.22340783e-01f, 3.52433547e-02f, 5.33600003e-02f, 6.92039821e-03f,
  -7.14889094e-02f, 1.49751052e-01f, 1.23388693e-01f, 1.59735963e-01f, 1.13776602e-01f, 3.11218835e-02f, 5.97618967e-02f, -2.24385224e-03f, -2.37649260e-03f, 1.31225482e-01f,
  4.18042429e-02f, 5.79541102e-02f, 1.48766087e-02f, 1.00498646e-02f, 1.23765424e-01f, -9.64229330e-02f, -4.12622318e-02f, 9.63698421e-03f, 9.77671295e-02f, 2.86205709e-02f,
  -1.86479017e-01f, -1.66178465e-01f, -4.17991318e-02f, 1.13249213e-01f, -3.97969643e-03f, 5.94640933e-02f, -6.42064214e-02f, 1.67214740e-02f, 3.11321355e-02f, 3.48026045e-02f,
  6.37531728e-02f, 1.58805937e-01f, -3.42794731e-02f, -1.19051233e-01f, 8.63833800e-02f, 1.62059695e-01f, 2.68206000e-01f, 2.45954499e-01f, 2.34071389e-01f, -1.28296301e-01f,
  3.13400716e-01f, -1.73775911e-01f, 1.61800265e-01f, 2.17995584e-01f, 3.00008375e-02f, 4.16300967e-02f, 1.99638367e-01f, -5.99701256e-02f, 1.09723046e-01f, -8.35732371e-02f,
  1.95819110e-01f, 5.11233732e-02f, 1.09213293e-01f, -4.74702753e-02f, 1.78031493e-02f, 8.70842412e-02f, 1.59070015e-01f, 7.99553916e-02f, -4.88816500e-02f, 1.21748053e-01f,
  2.95616277e-02f, -3.11647467e-02f, 7.09093437e-02f, -1.94076188e-02f, 2.61128880e-02f, 2.58838441e-02f, 8.57633725e-02f, 5.61396740e-02f, 8.09409246e-02f, 7.29492903e-02f,
  7.36744180e-02f, 1.15596265e-01f, 1.45749375e-01f, 9.64844450e-02f, -7.02545941e-02f, -1.37933329e-01f, -1.23444274e-01f, -3.60215604e-02f, 6.39991686e-02f, 1.18693687e-01f,
  2.35175826e-02f, 2.62348517e-03f, 1.87510431e-01f, -1.17614098e-01f, 9.55909342e-02f, 9.76494625e-02f, 1.05207764e-01f, 2.55656075e-02f, 1.08943574e-01f, 3.88182327e-02f,
  -8.27569515e-02f, 2.89198942e-02f, 7.24031702e-02f, -3.47854500e-03f, 2.99715977e-02f, 2.65816867e-01f, -6.39620498e-02f, -2.88118899e-01f, 9.13793370e-02f, 7.69538581e-02f,
  3.22865188e-01f, 1.25216052e-01f, 2.26426244e-01f, -1.71915948e-01f, 1.65338069e-01f, 6.62918910e-02f, -1.69166505e-01f, 1.20498881e-01f, -5.86519688e-02f, 7.38520026e-02f,
  9.07212049e-02f, 7.41415098e-02f, 1.08088128e-01f, -4.29447219e-02f, 2.74336368e-01f, -2.46053748e-02f, -4.08651643e-02f, 1.02455452e-01f, 3.76232937e-02f, -2.58474778e-02f,
  4.63307723e-02f, -7.92779401e-02f, -2.17610430e-02f, 2.90429071e-02f, 2.75141355e-02f, 8.54915455e-02f, 1.83179695e-02f, 4.84620705e-02f, -1.04524314e-01f, 4.90211211e-02f,
  7.27585927e-02f, 6.19245619e-02f, -1.81209650e-02f, -9.89236161e-02f, -6.67571425e-02f, -1.22313313e-01f, -4.84771617e-02f, -9.90423858e-02f, -3.04006040e-02f, -4.53488082e-02f,
  1.80582434e-01f, 3.53448614e-02f, 4.55188379e-02f, -7.33311772e-02f, -4.50630952e-03f, 7.66333118e-02f, -1.16879903e-01f, 1.97343737e-01f, -1.15650557e-02f, -4.47451510e-02f,
  2.59015535e-04f, -2.23694667e-02f, -9.32354629e-02f, 5.89893200e-04f, 1.06266536e-01f, 7.22028688e-02f, -1.46167174e-01f, 1.13284528e-01f, -1.41479030e-01f, 1.56790078e-01f,
  -8.15566704e-02f, 1.14337124e-01f, 7.88429752e-02f, 2.74123013e-01f, -6.01718239e-02f, 2.54876524e-01f, -1.21890809e-02f, 2.36312337e-02f, -1.09496459e-01f, 9.54861492e-02f,
  -4.89984220e-03f, -7.84479901e-02f, -1.66908540e-02f, 7.53991902e-02f, 1.11555189e-01f, 1.56456038e-01f, 2.63958573e-01f, 1.68641463e-01f, 1.37649134e-01f, 1.35648876e-01f,
  1.59004033e-01f, -1.76780224e-02f, 4.56641465e-02f, 6.99707195e-02f, -3.67943058e-03f, 1.06936276e-01f, 1.66191712e-01f, 3.14721577e-02f, -9.48829949e-02f, 1.64608788e-02f,
  2.36751400e-02f, 7.88947046e-02f, 2.23022029e-01f, -5.86789884e-02f, 1.81621071e-02f, -6.23548590e-02f, 1.05589166e-01f, 8.34109262e-02f, 1.10093467e-01f, 1.94125369e-01f,
  1.04701638e-01f, 6.37800321e-02f, -1.37210861e-01f, -3.83973606e-02f, -3.03685486e-01f, -1.59917697e-01f, -1.62076592e-01f, -4.02497947e-02f, -3.29295057e-03f, -4.62944098e-02f,
  3.89357768e-02f, -2.96265751e-01f, -3.18516046e-02f, 1.60369817e-02f, -1.38498843e-01f, -7.88305998e-02f, 1.19523883e-01f, -4.69436683e-02f, -2.87224233e-01f, 3.83600205e-01f,
  2.30483845e-01f, 1.06018013e-03f, -1.69171378e-01f, -9.32157487e-02f, 1.44295946e-01f, 4.62761261e-02f, -1.42411947e-01f, -7.37492591e-02f, 5.98574206e-02f, -6.02471605e-02f,
  3.03584158e-01f, 2.84648538e-01f, 1.59108546e-02f, 1.38286307e-01f, -1.08746186e-01f, 4.19824459e-02f, 1.73735797e-01f, -1.92194179e-01f, 4.02176101e-03f, 1.33415937e-01f,
  -2.55827978e-02f, -9.37217027e-02f, -1.36964954e-02f, -3.52548808e-01f
};

// L3_fan_Bp_bar (Shape: 1 x 26)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 26;
const float L3_fan_Bp_bar_data[] = {
  1.18682429e-01f, 3.60023826e-02f, -2.73789689e-02f, 3.40678096e-02f, 7.13210925e-02f, 2.13683993e-02f, -3.26622576e-02f, 1.41043160e-02f, 5.14223846e-03f, 1.72814205e-02f,
  2.41097696e-02f, -9.22182389e-03f, 1.69456638e-02f, 7.77072236e-02f, -1.27447601e-02f, 6.32038713e-02f, 1.84287748e-03f, 1.45481631e-01f, -5.28798476e-02f, 7.77284205e-02f,
  4.19053473e-02f, -1.83678437e-02f, -8.00479665e-06f, -1.17957992e-02f, 4.93812636e-02f, 8.19400623e-02f
};

// L4_linear_W (Shape: 12 x 64)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 64;
const float L4_linear_W_data[] = {
  -3.16683799e-02f, -2.46564392e-02f, -1.13615535e-01f, -3.77968177e-02f, -9.72652361e-02f, -1.25364661e-01f, 8.39277804e-02f, -1.16212159e-01f, 6.34297282e-02f, 7.35443756e-02f,
  -1.32507877e-02f, 1.17753774e-01f, -3.98214012e-02f, -6.27594963e-02f, -1.25010610e-01f, -1.86210170e-01f, -2.61617750e-02f, 5.65863550e-02f, 1.03009649e-01f, 1.07245266e-01f,
  1.39621086e-02f, 8.48063007e-02f, 1.55610770e-01f, -8.98182858e-03f, -6.80432022e-02f, 2.11973991e-02f, 8.27245787e-02f, -5.06610088e-02f, 2.75587514e-02f, 6.85312748e-02f,
  -1.03717417e-01f, 4.92727943e-02f, -1.13136105e-01f, -1.27182007e-01f, 4.47626449e-02f, 8.73616561e-02f, 2.53560133e-02f, 9.40545946e-02f, 7.28814751e-02f, 6.35971054e-02f,
  1.22193456e-01f, -1.84846580e-01f, -1.44370690e-01f, 1.72386020e-02f, -3.05561237e-02f, -1.66136593e-01f, -1.62403216e-03f, -1.76363990e-01f, 1.39928907e-01f, 2.12489396e-01f,
  -7.96816722e-02f, -1.01275064e-01f, 1.93066463e-01f, 1.60085008e-01f, 1.67429820e-01f, -2.73153216e-01f, 4.88681272e-02f, -3.99788320e-01f, 1.67529777e-01f, 2.88005382e-01f,
  -3.09267104e-01f, -3.93072069e-01f, -1.90889090e-01f, 3.00548971e-01f, 1.76703587e-01f, -6.62118010e-03f, 2.20534757e-01f, -1.02414124e-01f, -9.90197137e-02f, 1.92997918e-01f,
  -1.09379232e-01f, 3.75164971e-02f, 6.92508295e-02f, 1.27178878e-01f, 1.30407944e-01f, -1.15058990e-02f, -6.45635575e-02f, -6.29899874e-02f, 1.22814752e-01f, 7.49462470e-02f,
  -1.01087198e-01f, -1.51996082e-02f, -2.58640144e-02f, 9.10433456e-02f, 1.48852319e-01f, 4.78334166e-02f, 2.08126823e-03f, -1.26670554e-01f, 4.92766313e-03f, -1.83505297e-01f,
  9.44561809e-02f, 2.19240889e-01f, 1.34237200e-01f, 1.08495187e-02f, -1.63170993e-01f, 1.45722002e-01f, 1.60965234e-01f, -1.16277725e-01f, -4.85436879e-02f, -1.23327814e-01f,
  5.52599020e-02f, 1.60017297e-01f, -2.25654952e-02f, -3.44462097e-01f, -6.52140453e-02f, -1.61888018e-01f, -3.00156355e-01f, -4.12254840e-01f, -3.17820817e-01f, -8.52320492e-02f,
  1.33711323e-01f, -4.16264385e-01f, 1.02284253e-01f, -2.74565101e-01f, 2.47550681e-01f, -2.38374725e-01f, 1.59926265e-01f, 5.44156320e-02f, 2.34650206e-02f, -5.53671531e-02f,
  2.31744796e-01f, -1.35305285e-01f, 9.95351672e-02f, -1.77229106e-01f, 1.56575277e-01f, -2.40103416e-02f, 1.21658966e-01f, -1.50888294e-01f, 1.32415310e-01f, -1.44081846e-01f,
  7.60546997e-02f, -9.20123383e-02f, 5.97047843e-02f, 1.02547957e-02f, -1.75748274e-01f, -1.47842675e-01f, 7.72754624e-02f, -4.81389612e-02f, -2.01945692e-01f, 1.75713778e-01f,
  -4.11739871e-02f, -5.35141006e-02f, 1.14850104e-01f, -1.39286861e-01f, -8.35728459e-03f, -6.23279549e-02f, -1.04752362e-01f, -5.86152002e-02f, -1.53371558e-01f, -1.07724778e-02f,
  1.16818368e-01f, -2.16682449e-01f, -2.15261549e-01f, -6.00208007e-02f, -3.07981903e-03f, 2.05267772e-01f, 2.64925778e-01f, -6.79556727e-02f, 1.13950305e-01f, -1.65923670e-01f,
  3.62844352e-04f, -1.05500408e-01f, -8.25168565e-02f, 3.49173844e-02f, 9.68022123e-02f, -2.29774147e-01f, -4.70010638e-01f, 2.60169923e-01f, -1.94700658e-02f, 1.36524990e-01f,
  -1.06292531e-01f, -3.13528478e-02f, -1.82884634e-01f, 2.52691120e-01f, -4.66838509e-01f, 1.81355700e-02f, -2.62318760e-01f, -7.88011309e-03f, -2.74729673e-02f, -7.05797598e-02f,
  -8.10528174e-02f, 3.12697560e-01f, 2.33825952e-01f, -2.87760586e-01f, -1.45064015e-02f, 1.66199226e-02f, -4.59342957e-01f, -9.66432914e-02f, 2.81295851e-02f, -1.16700120e-01f,
  1.63912073e-01f, -4.75927144e-02f, -7.43007660e-02f, 3.32026295e-02f, 5.21526970e-02f, 2.18069833e-03f, -2.15320010e-02f, -2.25524962e-01f, 2.32113972e-02f, -4.17398810e-02f,
  5.72186597e-02f, -1.08136170e-01f, 3.47875580e-02f, 1.34297386e-01f, -1.73203181e-02f, 1.40639514e-01f, 1.86384395e-01f, 1.24359138e-01f, -1.60157546e-01f, -4.04939316e-02f,
  -2.66637490e-03f, -7.44307712e-02f, -1.30470648e-01f, 1.22565672e-01f, -1.77428558e-01f, -1.85047872e-02f, -5.47838099e-02f, -1.05255537e-01f, -2.60600716e-01f, 1.36053994e-01f,
  -7.20143020e-02f, 4.74598557e-02f, -9.81290173e-03f, 4.83980030e-02f, 5.29129766e-02f, -1.07498825e-01f, -3.47848833e-02f, 5.07573634e-02f, 1.64798275e-01f, -7.67628476e-03f,
  5.00655659e-02f, 4.03675064e-02f, -1.38035910e-02f, -4.35787380e-01f, -2.79880047e-01f, 9.74545479e-02f, -3.09355885e-01f, -8.22105724e-03f, 9.74031389e-02f, 2.24351808e-01f,
  1.27644330e-01f, 2.41131112e-01f, -4.29516435e-01f, 2.68080592e-01f, -7.25308210e-02f, -4.49604303e-01f, 9.98721644e-02f, 1.43603206e-01f, 1.38271928e-01f, -2.63225704e-01f,
  -2.97855854e-01f, -2.30244994e-01f, -2.80606356e-02f, -1.45234063e-01f, -1.63337067e-01f, -1.05737977e-01f, 1.74299881e-01f, 1.22326247e-01f, -1.66785091e-01f, 1.37007192e-01f,
  1.02691472e-01f, 1.78082734e-01f, 1.27972409e-01f, 6.62787408e-02f, 5.17605804e-02f, -1.47501931e-01f, -1.73426408e-03f, -6.85379878e-02f, 4.11695503e-02f, 5.32462150e-02f,
  -8.09932798e-02f, 4.10013609e-02f, 6.50505424e-02f, 2.13385418e-01f, -1.68975681e-01f, 1.33301154e-01f, 2.70248473e-01f, 4.55042347e-02f, 1.70272633e-01f, -3.62089425e-02f,
  -7.31368409e-03f, -1.67279243e-02f, 2.32274145e-01f, -1.72540843e-01f, 7.20118657e-02f, 2.09687799e-01f, 8.01018998e-02f, -2.67864987e-02f, -1.85767040e-01f, 3.55887413e-02f,
  -9.93431211e-02f, -1.02531299e-01f, 2.37396359e-01f, -1.09922945e-01f, 1.51859343e-01f, 1.54881999e-02f, -9.45306867e-02f, 7.89892524e-02f, -2.50959963e-01f, 2.35076219e-01f,
  -2.60574907e-01f, -3.60567778e-01f, -1.30473927e-01f, 5.42376051e-03f, 2.26258442e-01f, 3.00224453e-01f, 9.71803367e-02f, 2.29476586e-01f, -3.01291466e-01f, -3.05566937e-03f,
  -4.96847749e-01f, 3.10451567e-01f, -8.07557702e-02f, -1.58420712e-01f, -4.88648824e-02f, 9.26860645e-02f, -1.41316811e-02f, -1.90111458e-01f, -4.32018787e-01f, 1.88263357e-01f,
  2.67535280e-02f, 8.48390758e-02f, -1.59121096e-01f, 1.53030396e-01f, 5.85702620e-03f, -4.63710316e-02f, -2.56935544e-02f, 3.00914496e-02f, 3.43621485e-02f, 9.66384187e-02f,
  2.02230111e-01f, 1.93181813e-01f, 7.23288357e-02f, 6.62511736e-02f, 3.25733982e-02f, -1.23547681e-01f, 5.95603883e-02f, -1.81834683e-01f, 1.97674945e-01f, 2.62836754e-01f,
  1.17780482e-02f, 1.29743934e-01f, -5.74919954e-02f, -2.10686121e-02f, 2.25017980e-01f, 1.34071499e-01f, -1.35099757e-02f, -2.40006134e-01f, -2.99000055e-01f, -1.21944705e-02f,
  -7.50574619e-02f, 1.18047722e-01f, 1.21326625e-01f, -1.56903535e-01f, 2.08604589e-01f, 2.46260971e-01f, -1.39143899e-01f, -2.07595259e-01f, 1.53448120e-01f, -2.65556633e-01f,
  -1.26246260e-02f, 8.12656283e-02f, 9.75519568e-02f, 2.46868595e-01f, -1.30216286e-01f, -2.12285388e-02f, 2.06193343e-01f, -3.34317774e-01f, 9.65645090e-02f, -2.07799509e-01f,
  -3.02503884e-01f, -2.19290361e-01f, -6.51261657e-02f, 9.32350680e-02f, -6.65204078e-02f, -3.85059476e-01f, 7.33483233e-04f, 1.15104057e-01f, -3.33643705e-01f, -2.39234686e-01f,
  1.06675334e-01f, 1.52441353e-01f, -5.08509465e-02f, 3.15192133e-01f, 9.86741111e-02f, -1.68743730e-01f, 1.09248757e-01f, -1.31478205e-01f, -3.99074405e-02f, 2.03932673e-01f,
  1.55334502e-01f, -4.10544872e-02f, -1.20438367e-01f, 1.20933644e-01f, -6.60676286e-02f, -2.49656051e-01f, -2.48334289e-01f, 3.73532213e-02f, -8.62991214e-02f, 1.83891103e-01f,
  -1.16686262e-01f, -2.04469070e-01f, 9.83078331e-02f, -1.22808367e-01f, -6.11713454e-02f, -1.55592614e-04f, -3.09819262e-02f, 2.92350709e-01f, -1.78873792e-01f, 5.72385676e-02f,
  -2.02298120e-01f, 3.10128368e-02f, -6.69996515e-02f, -1.23711094e-01f, 4.07091603e-02f, 3.46468128e-02f, 9.72246111e-04f, 2.83807274e-02f, 5.32055721e-02f, -1.53895929e-01f,
  -4.35186811e-02f, 7.77329579e-02f, 6.70099705e-02f, -1.09511567e-02f, 4.90467772e-02f, 2.14267045e-01f, 2.19545767e-01f, -2.86145508e-01f, 3.14280689e-01f, 2.42402777e-01f,
  -3.22201252e-01f, -4.72446233e-01f, -2.12144703e-02f, -6.10321797e-02f, -3.08530658e-01f, -2.77434051e-01f, -4.37915385e-01f, 6.70287833e-02f, 2.34302450e-02f, -1.41045721e-02f,
  -5.41464508e-01f, 1.01939209e-01f, -1.12048574e-01f, 3.22980843e-02f, 4.21192087e-02f, 2.08176360e-01f, -1.89598933e-01f, -1.63172975e-01f, 9.06699896e-02f, -4.23120745e-02f,
  1.14831105e-01f, 1.41225517e-01f, -1.53581217e-01f, -1.02150179e-01f, 5.84124103e-02f, -2.14274507e-02f, -9.66353621e-03f, 1.50878161e-01f, -1.47726927e-02f, -8.64915997e-02f,
  -1.81161806e-01f, 1.16790151e-02f, 8.07402730e-02f, 8.19947943e-02f, 1.51324198e-01f, 6.96181953e-02f, -1.57949522e-01f, -1.48777496e-02f, 6.73417896e-02f, -1.19465664e-01f,
  5.13408594e-02f, -5.24954833e-02f, -4.44217548e-02f, 1.93973780e-01f, 3.70792486e-02f, -4.78786491e-02f, 7.64617622e-02f, 7.85358027e-02f, -1.12557307e-01f, 9.04781073e-02f,
  -1.73086897e-01f, 2.44020924e-01f, -1.30179733e-01f, 5.47520854e-02f, 1.37023076e-01f, 1.19472310e-01f, -2.18482971e-01f, -5.54852374e-02f, -2.85909735e-02f, -5.42420931e-02f,
  4.50022370e-02f, 1.60025552e-01f, -2.06588030e-01f, -1.46144345e-01f, 1.14462294e-01f, 1.51017547e-01f, -4.04251873e-01f, -2.04874024e-01f, 4.05665450e-02f, -7.08807409e-02f,
  1.82016850e-01f, -3.50573987e-01f, -6.85194368e-03f, 1.30294323e-01f, 8.67277682e-02f, -1.61245406e-01f, 3.87585312e-01f, -1.77408203e-01f, -4.34102446e-01f, -2.66261160e-01f,
  -1.93065535e-02f, -1.05176166e-01f, -8.68854821e-02f, -7.32426867e-02f, -2.10022673e-01f, -2.60479040e-02f, -8.46039429e-02f, -1.16543330e-01f, 2.05882534e-01f, -6.14155531e-02f,
  -1.48015603e-01f, 6.91969320e-02f, -7.65320882e-02f, -6.93069845e-02f, 1.04627378e-01f, 1.00570560e-01f, -1.24432966e-01f, -6.30350634e-02f, 1.40274405e-01f, -4.22562286e-02f,
  -3.01626846e-02f, 3.56240086e-02f, -1.04323782e-01f, -7.92058334e-02f, -7.86731765e-02f, -1.00263998e-01f, -5.43305501e-02f, 8.60121474e-02f, -1.26136258e-01f, 2.97264569e-02f,
  7.63607919e-02f, 1.13084309e-01f, 1.33410230e-01f, 5.16068935e-03f, -3.83273289e-02f, 2.32914373e-01f, -1.69722587e-02f, 3.93017009e-02f, -2.04944551e-01f, 2.03026369e-01f,
  -3.42317492e-01f, 2.09682792e-01f, 4.36183512e-02f, -4.46898580e-01f, 2.46661529e-01f, -1.18771702e-01f, 2.51220286e-01f, 9.31842774e-02f, -2.37512648e-01f, -1.73954517e-01f,
  -3.49144042e-01f, -2.84810632e-01f, 2.05859870e-01f, -1.76941529e-01f, 1.12265736e-01f, -3.05472553e-01f, 7.18057677e-02f, -4.86141443e-02f, -9.61400717e-02f, 1.67569458e-01f,
  2.10049912e-01f, 8.75433628e-03f, -1.75972700e-01f, -1.70990974e-02f, 1.36575818e-01f, -7.98350107e-03f, 5.01328148e-02f, 2.97100488e-02f, 6.98375553e-02f, 2.34669119e-01f,
  7.64514506e-02f, -3.74321491e-02f, -1.90223292e-01f, 1.17187567e-01f, -9.52896327e-02f, -5.93310632e-02f, 1.30258515e-01f, -1.33612141e-01f, 8.46543536e-02f, -1.54316008e-01f,
  1.45295486e-02f, 9.63849872e-02f, 1.72002599e-01f, 6.68025538e-02f, -1.83753520e-01f, -5.81145659e-02f, -2.00447917e-01f, -3.02802352e-03f, -7.92938620e-02f, -1.08621195e-01f,
  -2.16616556e-01f, -1.67709533e-02f, -1.03434704e-01f, -1.19115636e-01f, -9.14416835e-02f, -1.31658912e-01f, -2.30797678e-02f, -2.22328037e-01f, 1.28990084e-01f, -6.22160845e-02f,
  1.49598643e-01f, 6.76783249e-02f, -3.35752033e-02f, 8.81168467e-04f, 1.74519598e-01f, -2.42852345e-01f, 3.29091866e-03f, 2.99543530e-01f, -1.56618863e-01f, -4.09143180e-01f,
  -3.81033599e-01f, -9.32467952e-02f, -2.45220006e-01f, -2.74304450e-01f, 5.22087514e-02f, -2.71138489e-01f, -2.41231974e-02f, 4.70949411e-02f, -1.92197368e-01f, 1.43414840e-01f,
  -3.18000436e-01f, 3.60833824e-01f, 8.04603323e-02f, 3.35413814e-02f, -6.07633181e-02f, 4.09039646e-01f, 7.59726018e-02f, -1.81158498e-01f, -3.37731838e-02f, -5.01336634e-01f,
  -1.57363951e-01f, -1.14243202e-01f, -1.02205575e-01f, -2.05943629e-01f, 7.56326392e-02f, 4.11200859e-02f, -1.68099299e-01f, -2.30866224e-02f, 4.69960272e-02f, -7.94440508e-02f,
  2.17335951e-02f, 1.57310054e-01f, 1.90320387e-01f, 4.09621261e-02f, 9.73431841e-02f, 1.12178661e-01f, 1.07033260e-01f, 2.11044610e-01f, 1.14577800e-01f, 1.63158178e-01f,
  1.91459730e-01f, -6.76655099e-02f, 2.40027040e-01f, 2.72269070e-01f, 2.78796285e-01f, -1.22809492e-01f, -2.14923009e-01f, 1.52894482e-01f, -2.03085795e-01f, 2.22840995e-01f,
  -1.81847170e-01f, -1.67198002e-01f, 2.09940627e-01f, 1.54379338e-01f, -1.95348561e-01f, -1.86210722e-01f, 5.75703161e-04f, 2.13886052e-01f, -3.54968086e-02f, -2.62184262e-01f,
  5.65416813e-02f, -1.29017994e-01f, 5.39780222e-02f, -1.59771398e-01f, 1.30140975e-01f, -3.51372421e-01f, 2.18219951e-01f, 1.70036107e-01f, -1.39879391e-01f, -2.10130036e-01f,
  -1.25964925e-01f, 5.65170571e-02f, 1.12094641e-01f, -3.33340645e-01f, 7.88559839e-02f, -3.68021756e-01f, -6.58897832e-02f, 1.40638322e-01f, -4.16622549e-01f, 3.64973024e-02f,
  1.55705854e-01f, 9.91436914e-02f, 9.22213420e-02f, -4.02747005e-01f, -1.81110859e-01f, 4.43835519e-02f, -1.07123524e-01f, -7.64947757e-02f, 8.47010389e-02f, -4.65443246e-02f,
  -8.24088231e-02f, 7.10698590e-02f, 9.72370654e-02f, -1.01754256e-01f, -1.34513140e-01f, -1.46506424e-03f, 1.84376672e-01f, -1.30814150e-01f, 9.05866027e-02f, -1.65977981e-02f,
  5.70546314e-02f, 1.12596042e-01f, -1.76896110e-01f, -1.87584028e-01f, -2.83476382e-01f, -2.51407325e-01f, -5.70956431e-02f, 1.97943226e-01f, -2.84722179e-01f, -2.56483972e-01f,
  3.63403976e-01f, -2.31413066e-01f, 2.43485570e-02f, -1.94789171e-01f, 1.04088865e-01f, 3.39986719e-02f, 8.31860900e-02f, -1.07117154e-01f, 1.29112050e-01f, -2.13713184e-01f,
  4.82716151e-02f, -1.80682868e-01f, 2.52403557e-01f, -1.04004577e-01f, -3.30477692e-02f, -2.22397685e-01f, 1.48130149e-01f, -4.99977991e-02f, 3.29350084e-01f, -2.42486537e-01f,
  -3.88156146e-01f, 2.59965003e-01f, -2.99034715e-01f, -2.55723130e-02f, -1.95751593e-01f, -2.17393532e-01f, -4.58926648e-01f, -3.62256020e-01f, 9.10159647e-02f, 2.12318525e-01f,
  -2.47752503e-01f, 3.06838632e-01f, -4.89321910e-03f, -1.91627800e-01f, 1.14871241e-01f, 1.14301346e-01f, -1.28590479e-01f, -2.56681293e-02f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  3.04667111e-02f, 7.10258484e-02f, -6.35040849e-02f, -1.30418032e-01f, -7.49400333e-02f, -9.04138014e-03f, -6.78471103e-02f, -3.89207676e-02f, 5.95710846e-03f, 2.42578536e-02f,
  8.68238583e-02f, 3.85892950e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 19, 26
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 19, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        64, 19, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        64, 19, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        64, 12
    );
    }
    