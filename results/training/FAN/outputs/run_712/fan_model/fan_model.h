/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 12 x 120)
const int L0_fan_Wp_rows = 12;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  4.99486215e-02f, 4.20701087e-01f, -2.02412009e-01f, -3.86897125e-03f, 1.18382722e-01f, -1.78425729e-01f, 9.15542543e-02f, -1.22966468e-02f, -3.32013518e-02f, 1.68993831e-01f,
  2.38985330e-01f, -7.38154948e-02f, -4.03694510e-02f, -1.75993517e-01f, -2.35525385e-01f, 1.28775030e-01f, 1.01546742e-01f, -2.72042960e-01f, -3.32493275e-01f, -2.24301010e-01f,
  6.90047890e-02f, 3.76156010e-02f, -3.96647565e-02f, 6.85613789e-03f, 1.99544907e-01f, -9.18485448e-02f, 1.08446769e-01f, 1.79348022e-01f, 1.57267749e-01f, 3.51143271e-01f,
  -1.32054180e-01f, 2.74706215e-01f, -1.24786392e-01f, 9.15107951e-02f, 2.17298232e-02f, 2.84320004e-02f, 4.59343428e-03f, 4.08398882e-02f, 1.18210159e-01f, 9.17880908e-02f,
  1.04929194e-01f, 5.80524951e-02f, -6.49695545e-02f, 7.27534369e-02f, 4.19910811e-02f, 5.03612086e-02f, 1.66215628e-01f, 2.61232164e-02f, -1.01117536e-01f, 3.97332534e-02f,
  1.78016007e-01f, 1.06046870e-01f, 7.63410926e-02f, -4.77942936e-02f, 5.67732612e-03f, -2.47556251e-02f, 1.43708527e-01f, 1.02610253e-01f, -3.39710936e-02f, 2.28624910e-01f,
  -1.20612420e-02f, -3.55823934e-02f, -6.85991272e-02f, -1.90895107e-02f, -9.30433103e-04f, 3.11835855e-02f, 5.01336604e-02f, 5.88779226e-02f, -2.48054955e-02f, 1.29025862e-01f,
  7.92268515e-02f, 1.68645717e-02f, 2.18975209e-02f, 8.58564973e-02f, 3.96894775e-02f, 6.61352053e-02f, 6.28346996e-03f, -8.14321265e-03f, 1.86440535e-02f, -8.86205211e-03f,
  2.09118854e-02f, 6.76672459e-02f, 1.60449767e-03f, 1.68180969e-02f, 1.24152951e-01f, 3.43193971e-02f, -6.40936336e-03f, -2.44866181e-02f, 6.56975340e-03f, 3.62530351e-02f,
  -1.93242170e-02f, -8.97542909e-02f, -3.14769633e-02f, 5.98631352e-02f, -4.27570269e-02f, 2.69800518e-02f, -6.20666705e-02f, 1.20583668e-01f, 5.32301748e-03f, 1.15355499e-01f,
  7.68860057e-02f, -3.71875204e-02f, 4.10781652e-02f, 8.13890292e-05f, 3.85709517e-02f, 5.41063994e-02f, 5.45429476e-02f, -3.41893523e-03f, 5.60439518e-03f, 2.44708844e-02f,
  1.08718842e-01f, -7.44122788e-02f, -1.51728153e-01f, -8.29449147e-02f, 3.66636639e-04f, -1.47860914e-01f, -6.75425008e-02f, -1.20404087e-01f, -9.51389447e-02f, 4.96335328e-02f,
  -1.58609271e-01f, 3.16799611e-01f, -2.34918028e-01f, 6.17349744e-02f, 2.10736245e-01f, -4.35106568e-02f, 6.94872364e-02f, -5.60772419e-02f, 1.05424948e-01f, 1.25891373e-01f,
  2.05686569e-01f, 1.12484552e-01f, -9.35790017e-02f, -3.50384042e-02f, -2.01936424e-01f, -6.07776307e-02f, -2.51101971e-01f, -3.23632747e-01f, -2.49714747e-01f, 2.89837960e-02f,
  1.37238190e-01f, 1.97875705e-02f, -1.01977356e-01f, 4.61828336e-02f, 1.08401410e-01f, -4.61660773e-02f, 1.55304551e-01f, 4.63807806e-02f, 1.56425253e-01f, -5.99949919e-02f,
  -6.41568378e-02f, 3.71592566e-02f, 3.15493718e-02f, 8.05753842e-02f, 4.44815382e-02f, -8.10881406e-02f, -3.38249989e-02f, -1.01352088e-01f, -8.88525993e-02f, 1.29059404e-02f,
  5.11617474e-02f, 2.63826903e-02f, -6.82793558e-02f, 3.07250163e-03f, -4.19360474e-02f, 5.50451502e-02f, -2.54923198e-02f, -2.71536876e-03f, -1.34614632e-01f, -3.94676328e-02f,
  1.14279166e-01f, 5.19858934e-02f, 2.96947975e-02f, 5.78241087e-02f, -1.16216592e-01f, -1.40394541e-02f, 1.58257753e-01f, 1.47176459e-02f, -2.88727526e-02f, -1.81562211e-02f,
  1.29567203e-03f, -1.07520700e-01f, -1.08907647e-01f, -3.13124880e-02f, -4.40968238e-02f, 2.51263753e-02f, 5.68796508e-02f, -2.37800134e-03f, -1.05225697e-01f, -3.33372690e-02f,
  7.71351308e-02f, -8.35588649e-02f, 3.94142978e-03f, -3.16721611e-02f, 2.96790861e-02f, -5.52514456e-02f, -1.72206536e-01f, -9.91880335e-03f, 4.56443764e-02f, -9.53988433e-02f,
  -1.61738712e-02f, -1.23522907e-01f, -3.61499265e-02f, -1.03662297e-01f, -4.12511751e-02f, -1.11832924e-01f, -9.70320478e-02f, -1.04553282e-01f, -1.31389499e-01f, 1.50013333e-02f,
  1.24932438e-01f, -1.30137652e-01f, 2.49191243e-02f, -5.69514222e-02f, 3.98620917e-03f, 4.39576581e-02f, 5.84626794e-02f, 7.61700124e-02f, 5.49482144e-02f, -4.72429842e-02f,
  1.13039454e-02f, -8.14628750e-02f, 1.15661388e-02f, -6.50933459e-02f, 4.37621176e-02f, 2.67773215e-02f, 6.02533221e-02f, 2.89820749e-02f, -8.05398542e-03f, 1.02033012e-01f,
  -1.79602187e-02f, -7.54357642e-03f, 2.09891982e-02f, 1.14383906e-01f, 3.50760967e-02f, 6.43897206e-02f, -1.56792242e-03f, 6.78460747e-02f, -3.63509506e-02f, 4.34919037e-02f,
  3.27123672e-01f, 4.92311232e-02f, 1.68693721e-01f, 2.28779197e-01f, 7.88015425e-02f, 9.19072516e-03f, 7.83735514e-02f, 9.59062874e-02f, -3.28069776e-02f, 1.04764532e-02f,
  -7.90231377e-02f, -3.00256073e-01f, -1.67405203e-01f, -5.38346693e-02f, -9.49168950e-02f, 1.61639094e-01f, 1.75881073e-01f, 7.55388290e-02f, 6.92385212e-02f, 7.02164918e-02f,
  6.57337531e-02f, 1.26369476e-01f, 1.45125091e-01f, 4.93424051e-02f, 1.43697321e-01f, -9.86034423e-02f, -2.40596700e-02f, 1.26927778e-01f, 5.20370081e-02f, 1.60110980e-01f,
  -3.84880486e-03f, 1.73399940e-01f, -8.55959766e-03f, 5.62813394e-02f, 4.36739847e-02f, -7.33417124e-02f, 1.45952282e-02f, 2.65071844e-03f, -8.27833414e-02f, -5.94418542e-03f,
  -5.00940271e-02f, -6.21389635e-02f, -4.25573960e-02f, -1.38339971e-03f, 1.33536607e-01f, -3.17132883e-02f, 1.01607889e-01f, 9.01646391e-02f, -3.94238606e-02f, -4.10039537e-02f,
  -9.52104405e-02f, 1.02444127e-01f, 3.53776477e-02f, -6.81104288e-02f, -5.95691577e-02f, -2.84106191e-02f, -5.04033789e-02f, 9.08264443e-02f, -6.35738522e-02f, 3.83454747e-03f,
  3.93167697e-02f, -1.64843746e-03f, -2.76401769e-02f, 5.38575165e-02f, 7.52223134e-02f, -5.81087684e-03f, 9.80600938e-02f, -6.88743638e-03f, 2.34708395e-02f, -2.20731962e-02f,
  4.87354621e-02f, 7.12967217e-02f, -2.75428258e-02f, 7.16983974e-02f, -5.91893010e-02f, 4.56689112e-02f, -5.07897809e-02f, 4.59333956e-02f, 1.34441052e-02f, 3.46375182e-02f,
  -6.64069280e-02f, 6.11152053e-02f, 5.85814640e-02f, -2.92421412e-02f, 7.87766092e-03f, -3.04094441e-02f, 4.03209329e-02f, -5.18700778e-02f, 1.53218741e-02f, -3.31433304e-02f,
  -7.16778412e-02f, 3.62249985e-02f, -1.93338394e-02f, -3.71129066e-02f, 3.23544033e-02f, -6.08864762e-02f, -1.56868137e-02f, -7.31428564e-02f, -8.94438401e-02f, 9.84318741e-03f,
  -7.58648035e-04f, -5.73033430e-02f, 4.84193340e-02f, -2.44542938e-02f, 4.37668748e-02f, -3.79367033e-03f, -7.77426735e-02f, -5.65165430e-02f, -2.73984279e-02f, 6.04859591e-02f,
  -6.63393736e-02f, -3.04836500e-02f, -1.53273255e-01f, -5.40702492e-02f, -6.84052333e-02f, -8.05208161e-02f, -1.63679466e-01f, -8.99314955e-02f, -5.85304424e-02f, -1.22896761e-01f,
  -2.78645426e-01f, -1.17773272e-01f, 2.00006351e-01f, -1.67720973e-01f, -1.33652270e-01f, 1.23507924e-01f, 3.25195283e-01f, 7.59208649e-02f, -1.13838851e-01f, -1.46994770e-01f,
  -1.37791529e-01f, -1.41890183e-01f, -4.75007668e-02f, -1.92437321e-02f, 1.72992811e-01f, 3.28428596e-01f, 3.06524485e-01f, 1.52027190e-01f, 6.98160380e-02f, -1.04475252e-01f,
  -8.15967470e-02f, -7.60574788e-02f, -9.89867095e-03f, -1.06230989e-01f, -1.26599580e-01f, -2.98825130e-02f, 2.85969069e-03f, 1.75033826e-02f, -2.39360370e-02f, 1.19451411e-01f,
  2.66233999e-02f, -1.94085270e-01f, 5.34977280e-02f, -2.10985422e-01f, -8.71976018e-02f, -5.78344706e-03f, 4.10609134e-02f, -2.69879270e-02f, 5.78134097e-02f, -5.06115034e-02f,
  -5.97783141e-02f, -1.24844998e-01f, -7.93133825e-02f, -1.59730744e-02f, -7.50150857e-03f, -3.98991816e-02f, -4.52747606e-02f, -2.73955669e-02f, 6.25189319e-02f, -4.73183952e-03f,
  -1.35173708e-01f, 2.23259665e-02f, 1.19456761e-01f, 1.08886041e-01f, 9.59483758e-02f, -2.86384095e-02f, 5.85031845e-02f, -1.19618978e-02f, 6.93793818e-02f, -2.83647813e-02f,
  -1.16825685e-01f, 2.82231364e-02f, 1.00757092e-01f, -2.33937539e-02f, -1.71858519e-02f, 1.58222057e-02f, -1.58069842e-02f, 7.28426948e-02f, 1.33957475e-01f, -7.18959942e-02f,
  9.25673824e-03f, 1.33553264e-03f, 3.56045626e-02f, -2.65608523e-02f, -4.44702245e-02f, 5.17491139e-02f, 1.24179712e-02f, 5.63180149e-02f, 5.29933460e-02f, 3.20955552e-02f,
  8.76562372e-02f, -1.67732872e-02f, 4.42093909e-02f, 6.76718578e-02f, 5.99748679e-02f, 2.40344703e-02f, 8.98396522e-02f, -1.31439511e-02f, 5.89023791e-02f, 1.48528151e-03f,
  -8.65310654e-02f, 6.54516518e-02f, -2.91838832e-02f, -1.27636313e-01f, -2.09290162e-02f, -2.93764565e-02f, -8.73165354e-02f, -8.46543238e-02f, -2.13262662e-02f, -3.30965593e-02f,
  -1.03766344e-01f, 4.27895337e-02f, -7.57529661e-02f, -1.27020264e-02f, -4.84257527e-02f, -1.37889273e-02f, 1.34924613e-02f, -3.93884480e-02f, 1.18260272e-02f, -3.82463112e-02f,
  2.26803608e-02f, 1.06545230e-02f, 4.94577810e-02f, 5.04559763e-02f, -1.02030806e-01f, -4.98119965e-02f, 1.26668736e-01f, 5.01193777e-02f, -5.39137982e-04f, 1.03985496e-01f,
  -1.43677622e-01f, -2.13997409e-01f, -2.40969583e-01f, -1.52524278e-01f, -4.75054681e-02f, -2.13968605e-01f, -3.24139386e-01f, -1.96148247e-01f, -1.33449882e-01f, -1.77453339e-01f,
  2.13754520e-01f, 2.44141638e-01f, 1.34294972e-01f, 1.51358262e-01f, -1.51153788e-01f, -2.56662577e-01f, -2.48511836e-01f, 6.99750090e-04f, 5.84240593e-02f, 7.29306340e-02f,
  8.74083415e-02f, 9.10630152e-02f, -3.21336687e-02f, -6.05935752e-02f, -2.62604300e-02f, 1.25548810e-01f, 1.72302891e-02f, -1.31164948e-02f, 1.26319185e-01f, -1.10592451e-02f,
  7.69602656e-02f, -1.56931072e-01f, -1.17825791e-02f, 3.46931890e-02f, 1.90520976e-02f, -1.18260585e-01f, 9.76533629e-03f, -8.00417364e-02f, 2.52631139e-02f, -1.57428816e-01f,
  4.57959659e-02f, -6.08434016e-03f, 2.05204058e-02f, 5.80000132e-02f, 4.31354009e-02f, -8.55594799e-02f, -1.25368848e-01f, -1.79677635e-01f, -1.23343341e-01f, -1.21068060e-01f,
  3.31893750e-02f, 3.74728418e-03f, -1.13754407e-01f, -1.17612861e-01f, -9.64106172e-02f, -5.59768267e-03f, -5.98126538e-02f, -5.01144901e-02f, -1.44956067e-01f, -1.19984224e-02f,
  9.91856232e-02f, -5.02509363e-02f, 5.43105043e-03f, -3.59187573e-02f, 2.35811193e-02f, -4.30683568e-02f, -8.30106088e-04f, 1.22713849e-01f, 1.92269906e-02f, -3.43965180e-02f,
  -5.06058261e-02f, -3.32257412e-02f, 4.04738039e-02f, -5.48323467e-02f, -3.02633140e-02f, -1.12678008e-02f, -2.54658703e-02f, -9.63151571e-04f, 2.41864808e-02f, -2.71121021e-02f,
  3.67564633e-02f, 3.73927429e-02f, 4.39680144e-02f, 1.19057797e-01f, -8.49689543e-03f, -5.52220903e-02f, 3.52722816e-02f, 6.31581694e-02f, -3.97478230e-03f, -2.59994697e-02f,
  7.23172277e-02f, -1.05598859e-01f, 7.76002854e-02f, -1.68927293e-02f, -6.20602220e-02f, 5.37124288e-04f, -7.06174374e-02f, -7.35318214e-02f, -1.16385948e-02f, -6.51340485e-02f,
  3.69346254e-02f, 4.44926918e-02f, 1.88495722e-02f, -3.70165445e-02f, -3.65985706e-02f, -6.93740845e-02f, -3.61048765e-02f, 1.00179993e-01f, -7.29836002e-02f, -9.36906487e-02f,
  -1.07849181e-01f, -1.48358226e-01f, 1.74118504e-02f, -6.22339249e-02f, 2.94250175e-02f, 1.68863591e-02f, 5.88144995e-02f, 2.71801688e-02f, -5.72858155e-02f, -5.64715341e-02f,
  1.56550154e-01f, 1.09198734e-01f, 2.19952196e-01f, 9.57191586e-02f, -6.15040585e-02f, -1.68336332e-02f, 1.95678920e-01f, -1.16784252e-01f, -1.69355035e-01f, 2.47068442e-02f,
  -1.01474840e-02f, -1.37702108e-03f, -2.65837088e-02f, 4.77950387e-02f, 1.44685134e-01f, 1.74782664e-01f, 2.39526957e-01f, 1.47982717e-01f, -5.58587126e-02f, -4.08847816e-02f,
  -1.92659155e-01f, -6.38166592e-02f, -4.82966267e-02f, -4.66381125e-02f, -2.27113683e-02f, -5.55204712e-02f, -4.25402746e-02f, 2.31811628e-02f, -3.19711380e-02f, 1.43719628e-01f,
  3.82716179e-01f, 1.62024513e-01f, 4.83915620e-02f, -1.21984944e-01f, -4.56483923e-02f, 8.29655081e-02f, -4.20258753e-02f, 2.24660505e-02f, 3.02635189e-02f, 2.26080678e-02f,
  9.48672742e-02f, 1.79164973e-03f, 3.55264880e-02f, 5.14783449e-02f, 7.36082718e-02f, 1.19121885e-02f, 1.63540151e-02f, -7.77439727e-03f, -3.54940258e-02f, 4.45191115e-02f,
  5.34204058e-02f, 4.73553538e-02f, 1.36299491e-01f, -1.14192940e-01f, -5.82329780e-02f, 3.11483853e-02f, 4.15851437e-02f, 3.21238600e-02f, -7.96968043e-02f, 8.71272832e-02f,
  -1.40814215e-01f, 6.59262240e-02f, -3.96562703e-02f, -3.26131471e-02f, -1.68632269e-02f, 5.62751628e-02f, 4.02293392e-02f, 1.34518845e-02f, 1.30134039e-02f, -1.72836035e-02f,
  -4.84549329e-02f, 1.80646144e-02f, -6.94791749e-02f, 2.14124266e-02f, 8.08143290e-04f, 1.45098930e-02f, -1.90010630e-02f, 1.65684652e-02f, 6.67515993e-02f, -1.93632487e-02f,
  -1.03983944e-02f, 7.63124973e-02f, 4.82105501e-02f, -3.34254727e-02f, 1.45684071e-02f, -8.13501794e-03f, -3.87103856e-02f, 2.89788586e-03f, -1.13558322e-02f, 4.60807607e-02f,
  4.48225550e-02f, -4.07819971e-02f, 6.78289160e-02f, 9.59292636e-04f, 7.69911557e-02f, 7.15860724e-02f, 5.83252050e-02f, -3.41899097e-02f, 9.81954858e-02f, 1.16859935e-01f,
  1.51287392e-01f, 3.42001617e-02f, 1.19517170e-01f, 5.11098206e-02f, 5.44320419e-02f, 4.12805639e-02f, -9.37373936e-03f, 1.60046622e-01f, 5.15546277e-02f, 9.29565653e-02f,
  5.73022738e-02f, 1.78124364e-02f, 1.70468464e-01f, 1.55832589e-01f, 1.59737598e-02f, 7.30933025e-02f, 1.31393865e-01f, 1.09388486e-01f, 1.12654299e-01f, 6.34777993e-02f,
  4.75242585e-01f, 1.92226302e-02f, 5.25554195e-02f, 3.69262546e-01f, 1.78139150e-01f, 2.10932326e-02f, 2.82199949e-01f, 1.83001414e-01f, 1.64977729e-01f, 1.01123445e-01f,
  -2.33920947e-01f, -2.00503841e-01f, -1.83361650e-01f, -2.28950813e-01f, -6.01695925e-02f, 1.68173164e-01f, 1.76359251e-01f, 9.25058424e-02f, -5.81776835e-02f, 1.63368493e-01f,
  -4.35888022e-02f, 3.08225363e-01f, 1.10092290e-01f, 4.29975055e-02f, 1.19339310e-01f, -1.06372967e-01f, 5.55948876e-02f, 4.34116088e-02f, -6.48676306e-02f, 1.02861114e-01f,
  -1.09297186e-01f, 2.37947747e-01f, -7.66879767e-02f, -1.47698760e-01f, -1.01050287e-01f, -4.62076478e-02f, 8.53264779e-02f, 8.15196708e-02f, -1.26079753e-01f, -2.94262823e-02f,
  -1.38752684e-01f, -1.48912638e-01f, -1.83324106e-02f, -3.81649621e-02f, 4.45163362e-02f, 1.07880346e-01f, 2.74646133e-02f, 9.40552875e-02f, -4.72229645e-02f, -3.56702842e-02f,
  2.35897442e-03f, 4.60351910e-03f, 2.39988323e-02f, 5.05978316e-02f, 4.44888361e-02f, -4.53346930e-02f, 1.07628573e-02f, -1.31058590e-02f, -1.87907308e-01f, 4.96742651e-02f,
  -1.71545103e-01f, -9.65008810e-02f, 1.04740173e-01f, 2.45343726e-02f, -1.43554648e-02f, -2.28886101e-02f, -9.27805156e-02f, -2.16273237e-02f, -6.69132452e-04f, 5.24135605e-02f,
  -9.53080505e-03f, 2.15003695e-02f, 5.02930991e-02f, 3.92516814e-02f, 2.15895586e-02f, 5.46937138e-02f, 4.66318103e-03f, 2.42616832e-02f, -1.55888889e-02f, 5.89348376e-02f,
  -7.07195550e-02f, 1.01423655e-02f, 7.71496072e-02f, -3.78050543e-02f, -2.48615351e-02f, 1.70172006e-02f, -4.35790755e-02f, -2.32405104e-02f, -3.90954204e-02f, -4.05701473e-02f,
  7.72362649e-02f, -2.10568115e-01f, -4.53331769e-02f, -8.29798803e-02f, -4.00284417e-02f, -1.16647795e-01f, -3.23340781e-02f, -9.05336514e-02f, -6.53638318e-02f, -8.63825604e-02f,
  -3.78321670e-02f, 3.08048259e-03f, -1.78153459e-02f, 1.00551322e-01f, -4.90022413e-02f, 3.29123400e-02f, 7.11266175e-02f, -7.97557831e-03f, -3.35380100e-02f, 4.60310392e-02f,
  -3.28232534e-02f, 4.76350822e-02f, 1.11832187e-01f, -6.78074658e-02f, -1.21112302e-01f, -9.99365821e-02f, -4.78851283e-03f, 2.96510570e-02f, -7.60442168e-02f, 9.36506987e-02f,
  -3.59766424e-01f, 2.45667085e-01f, 1.38941661e-01f, -6.64136782e-02f, 1.92796990e-01f, 8.75464007e-02f, 1.41500399e-01f, -9.70483050e-02f, -4.08573523e-02f, 2.14712888e-01f,
  1.35843307e-01f, -1.27486423e-01f, -4.99028042e-02f, -7.44641796e-02f, -1.58961758e-01f, 6.65413588e-02f, -7.87866041e-02f, -2.11127922e-01f, -3.00912470e-01f, -5.72544560e-02f,
  2.38033012e-02f, -1.39618352e-01f, -6.74397349e-02f, -6.84280097e-02f, 1.82913110e-01f, -1.92948955e-03f, 2.25317672e-01f, 1.88959181e-01f, 1.73115924e-01f, 2.21907675e-01f,
  2.46078208e-01f, 1.59127899e-02f, -4.31557521e-02f, 8.70798454e-02f, 6.68603852e-02f, -9.50867981e-02f, 4.38688044e-03f, 7.46068498e-03f, -1.09960418e-02f, 7.27571398e-02f,
  8.38523582e-02f, 4.24023392e-03f, 1.37571141e-03f, 1.28193088e-02f, -8.41096602e-03f, 7.26269111e-02f, 9.88535807e-02f, -6.49078786e-02f, 6.57736212e-02f, 6.74132705e-02f,
  1.47392049e-01f, 1.37368262e-01f, 4.37935740e-02f, 6.18634634e-02f, 3.72946784e-02f, 5.51065989e-02f, 1.29626974e-01f, -9.54365451e-03f, 1.00457050e-01f, -9.55499429e-03f,
  3.44972350e-02f, -9.05903429e-02f, 5.52895591e-02f, 2.49043144e-02f, -3.65911052e-02f, -1.75613128e-02f, -9.23272595e-03f, -2.10842001e-03f, -2.71495134e-02f, -9.10829101e-03f,
  -1.72524173e-02f, 8.83714408e-02f, -4.98374924e-02f, -2.54464190e-04f, 1.41622238e-02f, 4.26645689e-02f, 6.39137998e-03f, 1.08699678e-02f, 6.48164824e-02f, 3.09095122e-02f,
  2.59747286e-03f, 2.29380839e-02f, 8.64009187e-02f, -9.27847698e-02f, 4.55657020e-02f, -7.32999891e-02f, 4.70738336e-02f, -5.29160947e-02f, 3.12253535e-02f, 1.05326340e-01f,
  5.57926390e-03f, 1.08523093e-01f, -3.89012098e-02f, 3.90749834e-02f, 5.00387251e-02f, 6.14917576e-02f, -1.70673300e-02f, -2.14984976e-02f, 5.25229163e-02f, -5.50797842e-02f,
  1.12004196e-02f, -2.11465242e-03f, -4.93975095e-02f, 5.41221127e-02f, -2.39254255e-02f, -3.26935723e-02f, 2.61669252e-02f, 2.33058408e-02f, 8.62162188e-03f, 3.54207344e-02f,
  -6.31600842e-02f, -3.34374495e-02f, -9.27982628e-02f, -5.06772250e-02f, -5.77307157e-02f, -1.53624773e-01f, -2.48128567e-02f, 7.93202370e-02f, -1.88564807e-02f, -1.36559263e-01f,
  -3.06106582e-02f, 2.93200970e-01f, -1.63886324e-01f, -1.42982841e-01f, -2.31489073e-02f, 8.26984122e-02f, 2.48710871e-01f, 3.74808684e-02f, -1.01178929e-01f, 7.21643567e-02f,
  8.21026489e-02f, -1.57088235e-01f, -2.08687887e-01f, -5.62401898e-02f, 1.69582427e-01f, 7.19780400e-02f, 1.39210314e-01f, -8.49795491e-02f, -7.83535466e-02f, 5.81641234e-02f,
  1.29664674e-01f, 5.22960387e-02f, -1.05884358e-01f, 4.51675430e-02f, -1.84538942e-02f, -1.74008504e-01f, -4.46589440e-02f, 7.59001076e-02f, 9.46922824e-02f, 4.20325883e-02f,
  -2.49005854e-01f, 5.14316820e-02f, 6.85883015e-02f, 4.16586660e-02f, 5.68779446e-02f, -5.82002215e-02f, -3.95337045e-02f, -4.99593355e-02f, -1.79154668e-02f, -9.55851078e-02f,
  -2.98862718e-02f, 3.74350324e-02f, 3.57813202e-02f, 1.69132557e-02f, 4.61371206e-02f, -2.40988079e-02f, -2.06756294e-02f, -3.89625505e-02f, -3.35457921e-03f, 9.48877782e-02f,
  4.84322719e-02f, 5.26853651e-02f, 7.16981590e-02f, 5.26434332e-02f, 7.59794787e-02f, -9.85668749e-02f, 5.83561249e-02f, 3.47580537e-02f, -5.13549931e-02f, 3.13456841e-02f,
  1.26253083e-01f, -1.59572326e-02f, -2.88016349e-02f, -1.43701890e-02f, -5.35415113e-02f, -9.18480307e-02f, -1.16410263e-01f, -8.64120722e-02f, -3.17480937e-02f, -8.38220268e-02f,
  -5.50912917e-02f, -1.24308042e-01f, -6.66993484e-02f, -3.24465148e-02f, -8.20579082e-02f, 1.84333585e-02f, -8.71342644e-02f, -4.56053391e-02f, -4.99859080e-02f, -4.90827560e-02f,
  -4.90991920e-02f, -6.66585937e-02f, 2.63901497e-03f, -8.52173567e-02f, -6.20204955e-02f, -1.56616151e-01f, -8.52597803e-02f, -1.37826027e-02f, -1.35971427e-01f, 3.17742713e-02f,
  -2.56953239e-01f, 1.45465732e-01f, -2.22099293e-02f, 1.15201548e-01f, 4.48260866e-02f, -2.42579374e-02f, 5.04513793e-02f, 5.46841174e-02f, -1.37764988e-02f, -7.65921781e-03f,
  8.35976973e-02f, -5.24254255e-02f, -1.41124213e-02f, -5.80087584e-03f, -1.51694920e-02f, -5.69620281e-02f, 9.27950665e-02f, 8.17392953e-03f, 1.06453843e-01f, -3.26445065e-02f,
  5.98749518e-02f, 1.21859066e-01f, -6.52781203e-02f, 4.99390252e-02f, 2.37383265e-02f, -4.97248918e-02f, 3.21644433e-02f, -6.13287278e-02f, 6.16101809e-02f, 1.15836496e-02f,
  -2.66641706e-01f, -6.09004386e-02f, -1.24548055e-01f, -4.72878553e-02f, 1.07085623e-03f, -9.48180780e-02f, -1.29119113e-01f, -4.60927226e-02f, -5.35083376e-02f, 8.63122419e-02f,
  1.82131261e-01f, 8.48421678e-02f, 6.59523979e-02f, 1.77111216e-02f, -2.34745115e-01f, -2.41381854e-01f, -3.49893212e-01f, -2.77114302e-01f, 4.95238369e-03f, 2.11769164e-01f,
  5.37313744e-02f, -1.18795380e-01f, -3.41914818e-02f, -9.93198752e-02f, 7.65857249e-02f, 1.31407082e-01f, -1.43103367e-02f, 5.10816947e-02f, 1.31755739e-01f, -6.82966262e-02f,
  1.77672282e-01f, 4.31132838e-02f, -4.69647534e-02f, 8.43395218e-02f, 6.87683523e-02f, -1.03899151e-01f, -3.66127379e-02f, -6.06168807e-02f, -2.66067255e-02f, 2.96891704e-02f,
  1.47140026e-01f, -1.57248825e-02f, -1.21524207e-01f, 9.67870429e-02f, -1.91204455e-02f, -3.60862985e-02f, -1.05591714e-01f, -8.54266062e-02f, 4.76714186e-02f, 8.77408758e-02f,
  1.03101745e-01f, 4.35597077e-02f, 5.75019307e-02f, 9.32984476e-05f, -1.51556591e-02f, 4.36392128e-02f, 1.35616526e-01f, 6.12711646e-02f, -5.51795289e-02f, 1.70993935e-02f,
  9.29952562e-02f, 1.87913068e-02f, -9.22010317e-02f, -7.47733191e-02f, 2.60242708e-02f, 5.07865213e-02f, -3.68644260e-02f, -9.82055366e-02f, -2.01445296e-02f, 4.05103317e-04f,
  -3.17938626e-02f, -6.22981600e-02f, 9.75514296e-03f, -1.13324277e-01f, -2.11858526e-02f, -2.58467975e-03f, -8.48783702e-02f, -8.51176083e-02f, -2.18711291e-02f, -2.43459735e-02f,
  5.86893111e-02f, -4.33796532e-02f, -3.50672565e-03f, 5.64722754e-02f, -1.08101234e-01f, -1.77276402e-03f, -3.36862020e-02f, 6.68281689e-02f, -9.10319574e-03f, 2.74451654e-02f,
  -3.34515162e-02f, -1.55809075e-01f, 3.96927930e-02f, 5.17661162e-02f, 8.99215713e-02f, 2.73989700e-03f, -5.48216626e-02f, -1.14390515e-02f, -3.36350799e-02f, 2.18689945e-02f,
  3.72189246e-02f, 2.40053292e-02f, -2.24974807e-02f, -3.79767385e-04f, 8.14799964e-02f, 5.12095243e-02f, 4.55028303e-02f, 1.47920847e-02f, -3.25248428e-02f, 7.89265335e-02f,
  5.12482934e-02f, -3.63353221e-03f, -4.14031222e-02f, 3.37738544e-02f, 3.22210081e-02f, 6.38593826e-03f, -4.36177999e-02f, 1.25803486e-01f, -7.29753152e-02f, 6.54765666e-02f,
  -8.60965624e-02f, 4.43918258e-02f, -6.51493818e-02f, 4.04719636e-02f, 1.96200162e-01f, 1.68859184e-01f, 1.88857287e-01f, 1.76028624e-01f, 3.25713679e-02f, 7.40977526e-02f,
  1.17401600e-01f, 1.54038817e-01f, 2.55037844e-03f, 1.26676530e-01f, -6.23936988e-02f, -6.51791841e-02f, -2.76315838e-01f, -1.93025008e-01f, 2.91329492e-02f, 1.62303373e-01f,
  1.55384362e-01f, 3.93527821e-02f, -3.87150911e-03f, 7.14111254e-02f, -1.65830359e-01f, 2.46289186e-03f, -1.55372486e-01f, -1.12357877e-01f, -5.47670908e-02f, -3.06948662e-01f,
  -1.23115256e-01f, 1.62122309e-01f, 1.59979254e-01f, 1.19301781e-01f, 1.79127410e-01f, 2.86144149e-02f, 1.75275445e-01f, 4.77862023e-02f, 1.76190615e-01f, 8.68318900e-02f,
  1.94997620e-02f, 5.04023209e-02f, -1.71840452e-02f, 8.22034702e-02f, 1.16317809e-01f, 5.68982847e-02f, 2.31768936e-02f, -6.80375695e-02f, 3.44225205e-02f, 1.42095899e-02f,
  5.53373843e-02f, 6.50423393e-02f, -1.17708491e-02f, 2.72068530e-02f, 1.72516853e-02f, -5.05932644e-02f, 6.80986838e-03f, 5.20626642e-02f, -4.97453883e-02f, -1.87778309e-01f,
  -2.27897033e-01f, -1.22172676e-01f, 7.06651956e-02f, 2.86572333e-02f, -7.13201016e-02f, -2.61001419e-02f, -6.99865222e-02f, -1.18285112e-01f, -9.76293609e-02f, 4.04325314e-04f,
  -5.35158850e-02f, 4.98618484e-02f, -2.78100129e-02f, -2.64356174e-02f, -7.78619274e-02f, 1.26454839e-02f, 4.20344695e-02f, -8.17430913e-02f, -7.62202218e-02f, -9.21543539e-02f,
  5.97527390e-03f, -1.91862658e-01f, -3.79742719e-02f, -5.52196652e-02f, -1.55517578e-01f, -1.66241303e-01f, -1.21843278e-01f, 5.66598438e-02f, -1.06889948e-01f, -9.37897991e-03f,
  -3.37128416e-02f, 1.77959517e-01f, 6.40179068e-02f, -1.19473133e-02f, 3.00526042e-02f, 7.52807129e-03f, 2.91836374e-02f, 8.69026110e-02f, 1.36834711e-01f, 2.40232926e-02f,
  1.79070279e-01f, 7.89860263e-02f, 1.58184379e-01f, -2.83071324e-02f, 8.38303044e-02f, 6.27335310e-02f, 8.55410844e-02f, 1.02008335e-01f, 7.66482726e-02f, 9.15731192e-02f,
  9.58278179e-02f, 9.51756984e-02f, 6.01201840e-02f, 1.18715271e-01f, 6.18348531e-02f, 4.79897000e-02f, -6.85997913e-03f, 1.14848455e-02f, 7.27731660e-02f, -4.55561839e-02f,
  -2.27322802e-01f, -2.12587982e-01f, 1.33538861e-02f, -1.76388726e-01f, 1.08682616e-02f, 8.85458887e-02f, 8.29081982e-02f, 1.67565808e-01f, 1.24134041e-01f, 1.23372570e-01f,
  1.71785057e-02f, -5.79946041e-02f, 1.32278770e-01f, -5.01797674e-03f, -1.37345437e-02f, -7.18328133e-02f, -1.75595302e-02f, -1.46795556e-01f, -2.50910129e-02f, -2.14019720e-03f,
  -7.15912804e-02f, -1.61581844e-01f, -2.25928366e-01f, -1.29699662e-01f, -1.40756428e-01f, -1.82043819e-03f, -1.06869722e-02f, -2.02590495e-01f, -4.06544581e-02f, -2.60597885e-01f,
  5.03909290e-02f, -2.78391719e-01f, 4.39782739e-02f, -5.08319512e-02f, 5.59694041e-03f, -1.02061313e-03f, -9.03260633e-02f, -7.53137022e-02f, -3.45518366e-02f, 2.55821720e-02f,
  -1.06035344e-01f, -2.74457242e-02f, -1.34217069e-02f, -9.54881310e-02f, 1.91265810e-02f, 1.98473427e-02f, 3.41929458e-02f, -1.19751301e-02f, -8.44979472e-03f, -3.90806757e-02f,
  -2.17729181e-01f, -1.91993952e-01f, -1.08105086e-01f, 4.32752892e-02f, -9.19122994e-02f, -5.73202819e-02f, 6.53581098e-02f, -6.15055626e-03f, 7.17257056e-03f, -3.33233550e-02f,
  -4.26159985e-02f, 1.67523287e-02f, -2.24832958e-03f, 9.38444287e-02f, -3.54821384e-02f, -8.05633981e-03f, 6.65271953e-02f, -4.30934951e-02f, 1.40546961e-02f, 2.95732189e-02f,
  5.03895022e-02f, 1.06854495e-02f, 9.59857330e-02f, 8.91810730e-02f, 1.19219102e-01f, -3.95621639e-03f, 8.88369679e-02f, 1.49073787e-02f, 3.41712460e-02f, 1.57801360e-01f,
  2.14217529e-02f, 1.15119450e-01f, 6.72424287e-02f, 1.46473303e-01f, 6.70025423e-02f, 1.39362561e-02f, 9.48500261e-02f, 1.45331351e-02f, -6.43591862e-03f, 3.34654413e-02f,
  1.27950788e-01f, -1.83795355e-02f, 1.48552060e-01f, -8.67132992e-02f, 2.35409103e-02f, 4.97797877e-02f, 8.10490847e-02f, 4.84580807e-02f, 2.62636282e-02f, 5.56891300e-02f,
  -1.43160792e-02f, 3.20494287e-02f, -1.47007108e-02f, 7.88475797e-02f, 1.34632051e-01f, 8.24495032e-03f, 5.68519570e-02f, 6.87679090e-03f, 3.64541113e-02f, 3.36130150e-04f,
  1.05863564e-01f, 2.58278046e-02f, -2.81370468e-02f, 4.64318953e-02f, 6.45933161e-03f, 1.17069885e-01f, 7.78290555e-02f, 2.27551851e-02f, 6.02175370e-02f, 2.08472058e-01f
};

// L0_fan_Wp_bar (Shape: 40 x 120)
const int L0_fan_Wp_bar_rows = 40;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -5.20234346e-01f, -1.37752533e-01f, -2.10388098e-02f, -1.66376010e-01f, 1.58586025e-01f, 2.39268214e-01f, 3.83707821e-01f, 7.80904219e-02f, -1.42952174e-01f, 6.51402175e-02f,
  2.85286531e-02f, -4.68394831e-02f, -1.31048271e-02f, 2.33511049e-02f, 2.37416521e-01f, 9.66499373e-02f, 1.31018147e-01f, -7.00159445e-02f, 1.01958320e-01f, 3.13789010e-01f,
  1.91678092e-01f, -8.99363533e-02f, -2.07445651e-01f, -6.27851114e-02f, -7.44396299e-02f, -1.57076597e-01f, 5.36395349e-02f, -2.03423072e-02f, 9.34708267e-02f, -1.22774199e-01f,
  -1.96566805e-01f, -1.77771688e-01f, 1.70589671e-01f, -1.28707901e-01f, -6.37590140e-02f, 4.11297455e-02f, 1.11579761e-01f, -5.46624176e-02f, -1.02606360e-02f, 2.07485165e-02f,
  -9.26062837e-02f, 2.76115369e-02f, -5.99751025e-02f, -1.16808675e-01f, -3.24074551e-02f, 4.45115454e-02f, 2.43773293e-02f, 1.59547180e-02f, -1.80437341e-02f, 2.41566543e-02f,
  1.25324309e-01f, 2.82932352e-02f, -1.27167441e-02f, 5.66285402e-02f, 5.67743257e-02f, 1.95541475e-02f, 1.29110262e-01f, 4.88269217e-02f, 3.05990763e-02f, -2.46939406e-01f,
  -2.72396486e-02f, -2.70667393e-03f, 4.26536426e-02f, 1.17778100e-01f, -4.72420454e-03f, 1.17243547e-02f, -2.94935852e-02f, 9.43614729e-03f, 1.11624375e-01f, -1.06619447e-01f,
  1.76947806e-02f, -6.58045039e-02f, -5.11416122e-02f, 7.21376576e-03f, -3.67147811e-02f, -1.48275094e-02f, -7.07135424e-02f, 3.14641967e-02f, 4.59618196e-02f, -4.06808965e-03f,
  -6.11176416e-02f, 1.32593093e-02f, 4.40911502e-02f, -6.28086701e-02f, 1.90459788e-02f, 3.16953138e-02f, -1.50846960e-02f, 5.78125156e-02f, -3.48356478e-02f, -3.67881469e-02f,
  -3.53657156e-01f, 4.34167571e-02f, -1.02561817e-01f, -2.95874029e-02f, 7.04088956e-02f, -3.09032556e-02f, 3.99488471e-02f, -9.00602620e-03f, -1.55566588e-01f, 3.30823809e-02f,
  1.47825703e-01f, -8.58649760e-02f, -9.00274888e-02f, -1.99785195e-02f, 3.59695069e-02f, -3.61628234e-02f, 1.95400044e-02f, -8.22841302e-02f, 9.70554352e-02f, 1.02031782e-01f,
  7.18793795e-02f, 1.65499210e-01f, -1.35393873e-01f, 2.31270771e-02f, -1.28973141e-01f, -1.08425081e-01f, -9.04474035e-02f, -8.80065411e-02f, 1.05621452e-02f, -2.38124162e-01f,
  -2.08540753e-01f, 2.46904477e-01f, -2.35103726e-01f, 1.10556103e-01f, 1.86078414e-01f, 2.09372923e-01f, 3.24098021e-01f, 1.24453716e-01f, 2.26005390e-02f, 1.67860419e-01f,
  6.36089221e-02f, 1.04868837e-01f, 3.38753723e-02f, 1.65758520e-01f, 2.20358372e-01f, 2.73966193e-01f, 1.64702982e-01f, 3.63018960e-02f, -1.25476494e-01f, 9.69232768e-02f,
  1.38219669e-01f, -3.11886985e-02f, -8.61711279e-02f, 3.53305563e-02f, 1.31610632e-01f, -1.10641646e-03f, 7.98456594e-02f, -3.32470313e-02f, 3.65052335e-02f, 9.54781026e-02f,
  -1.32803798e-01f, 4.09041420e-02f, -4.80183885e-02f, 2.43188045e-03f, -1.28919050e-01f, -1.84881762e-01f, 8.22511762e-02f, -6.80859685e-02f, -3.81597616e-02f, -4.23902720e-02f,
  -5.74857928e-02f, -8.31110552e-02f, 1.54314600e-02f, -4.16130982e-02f, 8.34265165e-03f, 5.37163429e-02f, -1.51669141e-02f, -9.39445943e-02f, -2.35611305e-01f, -2.23461449e-01f,
  5.30443378e-02f, -3.69165912e-02f, -4.65865433e-02f, -3.20311375e-02f, -9.45798010e-02f, 4.34912294e-02f, -1.47486374e-01f, -3.93445045e-02f, -8.66635591e-02f, -1.33232623e-01f,
  -1.10705271e-01f, 1.02935262e-01f, 4.98843305e-02f, -6.72095828e-03f, -1.05475500e-01f, -3.39923948e-02f, 9.36107263e-02f, 5.55172302e-02f, 2.03531403e-02f, -6.82225227e-02f,
  1.46951154e-03f, -5.09338900e-02f, 1.43103162e-02f, -1.25729525e-02f, 7.67913684e-02f, 1.03552431e-01f, 5.18361432e-03f, 2.29791235e-02f, -1.04116090e-02f, 7.24923611e-02f,
  -2.61315554e-02f, -6.82562813e-02f, 1.65172219e-02f, -3.73029597e-02f, 8.00395757e-02f, 8.05428401e-02f, -7.39908665e-02f, -1.42256794e-02f, -1.35452002e-02f, 4.68759090e-02f,
  8.52076858e-02f, 9.17525962e-02f, -1.07610799e-01f, 5.75192347e-02f, 3.25159244e-02f, 2.31246501e-02f, 3.50501500e-02f, 7.98204821e-03f, -4.14805412e-02f, -7.29144365e-02f,
  -6.85054064e-02f, 6.05138391e-02f, 5.36607578e-02f, 1.93622038e-02f, -1.00805566e-01f, 4.06099707e-02f, 8.89116246e-03f, -5.05011193e-02f, -1.58466417e-02f, -1.94894686e-01f,
  1.36012599e-01f, 5.25151612e-03f, -8.87118503e-02f, -2.51927506e-03f, -1.64771408e-01f, 9.98660102e-02f, -3.56644951e-02f, -8.46511200e-02f, -6.80838004e-02f, -1.62224486e-01f,
  5.93946517e-01f, -3.25673372e-01f, -4.21483129e-01f, 1.27387702e-01f, 2.57264613e-03f, 5.31696267e-02f, -7.23017082e-02f, 2.27508530e-01f, 2.75250763e-01f, -1.86917875e-02f,
  2.89091431e-02f, 1.51686475e-01f, -9.57285911e-02f, -1.05587482e-01f, 6.10470697e-02f, -2.85832196e-01f, -3.40618104e-01f, -2.32952029e-01f, 1.50587067e-01f, 1.96785450e-01f,
  1.65621623e-01f, 6.25775158e-02f, 1.85918566e-02f, 9.25224498e-02f, -1.01069734e-01f, 9.63292196e-02f, -2.44884267e-01f, -8.42322856e-02f, -1.60040513e-01f, -3.08306396e-01f,
  -3.24305803e-01f, 3.96169685e-02f, 1.61657348e-01f, 8.53116959e-02f, -7.73962364e-02f, 1.60692126e-01f, 6.63954392e-02f, -1.84263121e-02f, 4.76142503e-02f, -9.73107517e-02f,
  -7.31400624e-02f, 1.22040603e-02f, -7.48547539e-02f, 1.64091028e-02f, -1.42054411e-03f, -1.72759239e-02f, -3.35678272e-02f, 3.80220450e-02f, -1.04205675e-01f, -1.37594327e-01f,
  -4.76441532e-02f, 4.99953404e-02f, -6.95176870e-02f, 1.44367635e-01f, 1.58097312e-01f, 6.84823170e-02f, -5.08391410e-02f, 9.40218195e-02f, 1.34499907e-01f, 2.16438845e-01f,
  -6.46402836e-02f, -4.58519012e-02f, 8.44065100e-02f, 1.18912935e-01f, 8.84899497e-02f, 1.02074824e-01f, -6.37267679e-02f, 3.84495663e-03f, 8.31542164e-02f, 3.19767632e-02f,
  -1.12452321e-02f, -8.25593993e-02f, 4.07408886e-02f, -5.16695157e-02f, 1.45170698e-02f, -3.01461970e-03f, -3.49003635e-02f, -6.05730973e-02f, 3.32532972e-02f, -5.45348562e-02f,
  -1.07943401e-01f, -2.57623456e-02f, -5.54051362e-02f, 6.25177100e-03f, -1.28181502e-01f, 2.46655326e-02f, -8.27945471e-02f, 4.09413986e-02f, 5.39196841e-02f, -2.10730303e-02f,
  -3.30903754e-02f, 2.22019386e-02f, -4.49978784e-02f, -1.11021567e-03f, 2.53349263e-02f, -9.49457213e-02f, 5.61371958e-03f, -4.77930494e-02f, -9.30380821e-02f, -7.16045126e-02f,
  -4.92447540e-02f, 7.73111219e-03f, -1.48675770e-01f, -2.08590291e-02f, 6.56466335e-02f, 8.94072205e-02f, 7.68516362e-02f, 9.61200297e-02f, -9.67597216e-03f, -7.75375739e-02f,
  -5.37285544e-02f, 8.01482126e-02f, 1.57207698e-01f, 2.90815607e-02f, 5.62160388e-02f, 3.01549071e-03f, -7.59073198e-02f, -7.63466358e-02f, 8.35490376e-02f, 2.34004825e-01f,
  -1.76690787e-01f, -1.53441414e-01f, -8.96530300e-02f, -1.11166269e-01f, 1.63562775e-01f, 3.63188311e-02f, -9.32567194e-02f, -7.55913779e-02f, 8.86387900e-02f, 5.27360477e-02f,
  1.47803009e-01f, 4.31734398e-02f, -1.70586389e-02f, -3.90481181e-03f, -1.37493283e-01f, -3.24128903e-02f, -1.30343124e-01f, -1.76393330e-01f, 4.12221067e-02f, 2.94351518e-01f,
  1.97188675e-01f, -5.38578928e-02f, -6.64017648e-02f, 1.27635617e-02f, -4.66549024e-02f, -7.54075572e-02f, -1.12491563e-01f, -7.31839659e-03f, 1.16646215e-01f, -8.66312385e-02f,
  -6.54313993e-03f, -9.18392912e-02f, 5.87119944e-02f, 5.16226515e-02f, -3.05289272e-02f, -1.29426032e-01f, -6.48865849e-02f, -8.66205469e-02f, 3.03881746e-02f, 1.17482683e-02f,
  1.55432448e-01f, 1.13317661e-01f, -4.63806577e-02f, 1.32101059e-01f, 5.46537787e-02f, 4.68356609e-02f, -9.70105976e-02f, -6.02955110e-02f, -2.68882602e-01f, 3.97579744e-04f,
  6.50505424e-02f, 9.68384966e-02f, -1.84921771e-01f, -2.02476919e-01f, -1.58439562e-01f, -7.48634562e-02f, -1.98175520e-01f, -1.25104412e-01f, -2.37815425e-01f, -4.38056201e-01f,
  -7.21112490e-02f, 9.63755921e-02f, 9.04622152e-02f, -6.47641197e-02f, -4.67565916e-02f, 3.55913155e-02f, 2.59834491e-02f, 5.22357263e-02f, 3.13321203e-02f, -4.75905910e-02f,
  2.16565952e-02f, 7.08415955e-02f, -6.08932078e-02f, -7.49296919e-02f, 1.24915458e-01f, 3.61706801e-02f, 1.45430595e-01f, -1.72691703e-01f, 3.32524651e-03f, 1.04900502e-01f,
  4.31071147e-02f, 3.28140222e-02f, 5.30835316e-02f, 4.16906066e-02f, 4.70074117e-02f, -2.89240275e-02f, 7.16627985e-02f, 1.53259680e-01f, 8.54912922e-02f, -2.35463982e-03f,
  -2.23324895e-01f, -9.93503537e-03f, 3.81124765e-02f, 1.31462859e-02f, -6.06005415e-02f, -1.35464678e-02f, 4.08685505e-02f, 4.47836816e-02f, 1.62294880e-01f, -3.17691453e-02f,
  2.49418188e-02f, -1.15501910e-01f, -8.97380263e-02f, -3.92103978e-02f, 9.43330117e-03f, -4.41954797e-03f, -1.08362474e-01f, 9.76297036e-02f, 1.65952854e-02f, 3.34532373e-02f,
  -1.61732927e-01f, -1.54815719e-01f, -1.59654900e-01f, -1.94106311e-01f, 1.86744258e-02f, -1.16695911e-01f, -2.06471339e-01f, -2.89015435e-02f, -3.28573495e-01f, -3.46671969e-01f,
  3.34795564e-01f, -6.89617172e-02f, -3.37433457e-01f, 2.71425724e-01f, -1.11322720e-02f, -9.26156640e-02f, -1.14999600e-01f, 2.84986287e-01f, 2.19854221e-01f, -2.10813284e-02f,
  9.19989645e-02f, 2.76483834e-01f, 1.51929766e-01f, 4.10461538e-02f, -5.86907081e-02f, -1.32495582e-01f, -2.19609365e-01f, -6.01410866e-02f, 8.27714354e-02f, 8.77812803e-02f,
  4.90515307e-02f, 5.04057184e-02f, 7.93398768e-02f, 7.89635852e-02f, -1.39257357e-01f, -6.70410916e-02f, -2.55438328e-01f, -2.09944412e-01f, -3.12469900e-01f, -4.08412039e-01f,
  -2.12483063e-01f, -5.61435968e-02f, 9.13065299e-02f, -4.64603193e-02f, 6.46863459e-03f, 1.07572466e-01f, 8.05147216e-02f, 1.25466347e-01f, 1.12385586e-01f, 1.17451832e-01f,
  4.25267359e-03f, 6.94134012e-02f, -2.92015802e-02f, -6.13089986e-02f, -1.65778473e-02f, 4.13974151e-02f, 1.23734459e-01f, 6.62525818e-02f, -1.09447770e-01f, 3.49791050e-02f,
  4.25049923e-02f, -4.28605545e-03f, -1.06361859e-01f, -1.19310394e-02f, 1.52937742e-02f, 2.49777641e-02f, -1.00703336e-01f, -1.83462933e-01f, -2.47865915e-01f, -2.16970727e-01f,
  3.55579369e-02f, -8.42028558e-02f, -8.20263848e-02f, 1.39646173e-01f, 7.29468614e-02f, -2.01300662e-02f, -7.99376518e-03f, 2.68432572e-02f, -9.48025882e-02f, -6.41618595e-02f,
  7.20432699e-02f, -7.87324458e-02f, -5.56232519e-02f, 1.20770028e-02f, -5.48497289e-02f, -7.61304647e-02f, -8.74292403e-02f, 3.08934953e-02f, 7.10749552e-02f, -1.43890884e-02f,
  1.38107851e-01f, -1.29204392e-01f, -1.46584557e-02f, 2.77402792e-02f, -8.84283185e-02f, 1.04633003e-01f, 2.07595024e-02f, -6.95320778e-03f, 9.57785100e-02f, -1.38532734e-02f,
  6.94932342e-02f, -1.06604643e-01f, 1.58785563e-02f, 1.67195722e-02f, -3.85078378e-02f, 8.59996527e-02f, 2.25051828e-02f, -2.17220411e-02f, -1.35064786e-02f, 7.65074641e-02f,
  -7.89405853e-02f, -7.87439272e-02f, -2.23369207e-02f, -6.07682690e-02f, 4.69151251e-02f, 4.18481044e-02f, 9.84343588e-02f, -4.31471467e-02f, -4.87999022e-02f, -3.84535268e-02f,
  -5.39804883e-02f, 9.96580906e-03f, 4.66874614e-02f, -6.12790883e-02f, -1.15641624e-01f, 5.62894158e-02f, -1.91554204e-02f, -1.95143849e-01f, -2.05597356e-01f, -4.22742032e-02f,
  4.30644512e-01f, -1.64849222e-01f, 1.80280909e-01f, -1.05692759e-01f, -4.77294683e-01f, -3.39040548e-01f, -3.83831441e-01f, -7.05892965e-02f, -5.21708019e-02f, -2.68519551e-01f,
  -2.83089250e-01f, -6.80814311e-02f, 7.22329738e-03f, 4.42943163e-02f, 2.19720289e-01f, 1.25081539e-01f, 1.62881687e-01f, 4.34947133e-01f, 2.17347443e-01f, -1.57310590e-01f,
  -9.63394493e-02f, 1.98632419e-01f, 2.49484465e-01f, 1.02066189e-01f, -8.03520828e-02f, -5.22443652e-03f, -7.29394332e-02f, 4.29028310e-02f, -3.00108665e-03f, 2.06475645e-01f,
  -3.60409245e-02f, 6.60386831e-02f, 7.49362260e-02f, 4.61101569e-02f, -8.43290612e-02f, 6.35119677e-02f, 1.05335964e-02f, -6.11046404e-02f, -9.38229859e-02f, -4.10353951e-02f,
  -1.06858224e-01f, 5.45804575e-02f, -9.25268338e-04f, -4.88657281e-02f, -1.56412527e-01f, 9.96930245e-03f, -4.32107709e-02f, 1.57730430e-01f, 2.56685987e-02f, -5.37212379e-02f,
  -6.96528181e-02f, -4.93005030e-02f, -9.16969031e-02f, -1.35058984e-01f, -1.20300334e-03f, 4.09103408e-02f, -1.46754250e-01f, 4.48905453e-02f, 3.30440924e-02f, -3.79309058e-02f,
  7.55534461e-03f, 3.14866155e-02f, -1.06386505e-01f, -1.06344819e-01f, -2.13954002e-02f, -2.01095697e-02f, -6.05090596e-02f, -5.51054329e-02f, -5.82050830e-02f, 5.73264062e-03f,
  -1.31142482e-01f, -2.13618088e-03f, -7.24758301e-03f, -9.56879780e-02f, 7.81534761e-02f, 1.67013761e-02f, -9.89882573e-02f, -9.11350101e-02f, 5.08647226e-02f, 8.51247981e-02f,
  -8.09618621e-04f, -1.01378433e-01f, -2.07439717e-02f, -1.73335653e-02f, -3.37611288e-02f, -9.10239667e-02f, -7.73031265e-02f, -8.68537202e-02f, 9.81331319e-02f, -2.10938584e-02f,
  -3.18486452e-01f, 2.61510164e-01f, 1.20316714e-01f, 2.50901461e-01f, 7.80289248e-02f, 1.24915298e-02f, 1.42699089e-02f, 7.65202492e-02f, 8.83850828e-02f, 7.12661669e-02f,
  6.48862496e-02f, 7.20451549e-02f, -4.84643839e-02f, -9.99759883e-02f, 1.36453174e-02f, 7.55411685e-02f, -5.86013272e-02f, 8.75263959e-02f, 7.10213706e-02f, -1.39695928e-01f,
  -1.07713759e-01f, -1.39540853e-02f, 1.20923528e-02f, -2.64723189e-02f, -2.65074745e-02f, 1.07970841e-01f, -6.36580167e-03f, -1.39390668e-02f, 3.61639187e-02f, -1.91850364e-01f,
  2.77256310e-01f, -1.18513271e-01f, -5.17437041e-01f, 1.19368136e-01f, -1.27683029e-01f, -1.92493930e-01f, -1.83900550e-01f, 1.95367351e-01f, 1.04867019e-01f, -8.10552686e-02f,
  -2.44845301e-02f, 1.48766801e-01f, -3.69018316e-02f, -3.34971547e-02f, 1.25135705e-01f, -2.97278076e-01f, -1.75641790e-01f, -5.62076941e-02f, 5.08842580e-02f, 2.83193588e-01f,
  1.52078062e-01f, 1.94594264e-01f, 2.30870247e-01f, 1.32464454e-01f, -1.38144061e-01f, 8.62704813e-02f, -2.66391098e-01f, -1.71207953e-02f, -2.22177923e-01f, -2.79313296e-01f,
  -3.26702148e-01f, -2.00721473e-01f, 8.61334056e-02f, 1.03597216e-01f, -1.18378997e-01f, -6.51154518e-02f, -4.04103287e-02f, 8.51913169e-02f, 5.38180657e-02f, -2.22913623e-02f,
  -4.26215157e-02f, -1.85714511e-03f, 8.40402469e-02f, -3.90367992e-02f, 1.42819143e-03f, 5.03374524e-02f, 7.90923461e-02f, -1.11388400e-01f, -1.75931960e-01f, -1.73989497e-02f,
  -2.50772797e-02f, -8.65049064e-02f, -1.11950524e-01f, -1.09631950e-02f, -1.78349674e-01f, -1.27788529e-01f, -7.28811100e-02f, -3.02648135e-02f, -2.13898778e-01f, 1.53497159e-02f,
  -7.59631768e-02f, -4.70190272e-02f, 8.56772214e-02f, 2.43937001e-02f, 3.53541486e-02f, -9.43397172e-03f, 3.35809626e-02f, 3.85282040e-02f, 1.22964285e-01f, -3.13952519e-03f,
  4.61933017e-02f, -2.21304614e-02f, 5.14798686e-02f, 2.16654446e-02f, -3.58030349e-02f, 2.99137644e-03f, -1.14183258e-02f, -8.67936909e-02f, 2.49674134e-02f, 9.82872397e-03f,
  -1.66279748e-02f, -1.71061996e-02f, -4.45471294e-02f, 3.40518840e-02f, -7.78407604e-02f, -8.69732872e-02f, -6.28064349e-02f, 1.10852607e-01f, 1.39891192e-01f, -7.19860122e-02f,
  1.99628472e-01f, -9.21391845e-02f, -3.13596986e-02f, 1.09134354e-01f, -4.89748009e-02f, -1.25101591e-02f, -8.01318698e-03f, 3.40470523e-02f, 8.53966027e-02f, -4.53133360e-02f,
  5.00847697e-02f, 4.09972370e-02f, -5.79531193e-02f, -6.04535080e-02f, 1.55389100e-01f, 6.62616789e-02f, -3.71718477e-03f, -9.41857249e-02f, 7.04531297e-02f, -8.18527639e-02f,
  1.14972010e-01f, 1.20754749e-01f, 4.41725850e-02f, -5.99871278e-02f, -4.46845852e-02f, -6.75010448e-03f, -1.02017000e-02f, -7.46116266e-02f, 3.26344930e-02f, 2.01068953e-01f,
  4.93546218e-01f, 3.44215222e-02f, -5.77558242e-02f, 2.61641264e-01f, -3.85940447e-03f, -6.84331581e-02f, -1.56252474e-01f, -6.42094985e-02f, 8.65651220e-02f, 1.91175446e-01f,
  1.95736811e-01f, 3.83540839e-01f, 3.60380441e-01f, 1.43039301e-01f, 9.70951989e-02f, -5.28819598e-02f, -5.17743938e-02f, 5.73759004e-02f, 1.48402050e-01f, 1.16560929e-01f,
  -3.12929191e-02f, -5.77828363e-02f, 5.23933135e-02f, 1.31316772e-02f, -6.81773126e-02f, 3.48761715e-02f, -1.20131690e-02f, 2.51591485e-03f, 7.40986988e-02f, -8.21007863e-02f,
  -1.52967870e-01f, 4.63998206e-02f, 1.23102143e-01f, 3.64008620e-02f, -8.56220648e-02f, -5.00059836e-02f, 1.42122211e-03f, -2.17965394e-02f, -6.47216886e-02f, -1.19985618e-01f,
  -7.54716201e-03f, 8.11214224e-02f, 9.18856412e-02f, -1.55913860e-01f, -1.66605815e-01f, -1.70504317e-01f, 6.69189403e-03f, -3.15051004e-02f, 7.07397759e-02f, 2.86931787e-02f,
  -3.70513164e-02f, 1.18444927e-01f, 8.74174014e-03f, 3.87047902e-02f, 9.48689803e-02f, 1.44838527e-01f, -8.77452940e-02f, -8.38955641e-02f, 4.90060858e-02f, 1.29890060e-02f,
  2.06967890e-01f, 6.71792552e-02f, 1.07646197e-01f, 5.56011312e-03f, 4.65629585e-02f, -8.20604190e-02f, -3.82343568e-02f, -6.82603493e-02f, 1.88740548e-02f, -1.62256017e-01f,
  -3.94163793e-03f, 1.12413773e-02f, -2.45558340e-02f, 1.09486908e-01f, 1.59412161e-01f, -3.28034647e-02f, -2.14069337e-02f, 1.33048475e-01f, -4.73285140e-03f, -5.79604022e-02f,
  -1.06713660e-02f, -7.99319670e-02f, -1.45433649e-01f, -1.22960918e-01f, 3.32764462e-02f, 5.33366501e-02f, 4.00780551e-02f, 3.00718620e-02f, 4.42343056e-02f, -7.68960826e-03f,
  -9.74660814e-02f, 3.15184951e-01f, 1.05439886e-01f, -1.08736314e-01f, -6.39570728e-02f, -3.02825347e-02f, 1.66965097e-01f, 1.96808367e-03f, -1.87430099e-01f, -2.88702026e-02f,
  -6.72607869e-02f, -2.45570038e-02f, 1.27754919e-03f, -1.87142819e-01f, -5.68252914e-02f, -1.80330783e-01f, 1.32111087e-01f, 1.10514358e-01f, -4.27427702e-02f, -2.23209515e-01f,
  -1.08125262e-01f, 5.92584349e-02f, 1.57102883e-01f, -9.56821442e-03f, 4.28672247e-02f, 9.34986323e-02f, -4.62425351e-02f, 5.79574611e-03f, -3.84923769e-03f, -6.54224530e-02f,
  1.99426696e-01f, -2.75144041e-01f, 1.63883924e-01f, 1.27398511e-02f, -2.48094544e-01f, -6.93379194e-02f, -3.11497450e-01f, -1.21455133e-01f, -1.24441639e-01f, -2.15737998e-01f,
  -1.81191832e-01f, 2.88091183e-01f, 2.56669492e-01f, 7.34643042e-02f, 3.13495964e-01f, -1.34244815e-01f, -5.61659336e-02f, 3.15285861e-01f, 3.73652846e-01f, -7.64624104e-02f,
  -1.85941592e-01f, 8.32606852e-02f, 2.62751967e-01f, 1.97737217e-01f, -2.86299378e-01f, 8.61444473e-02f, -8.87039900e-02f, -6.09358633e-03f, -1.17142692e-01f, -2.12583825e-01f,
  -8.69340301e-02f, -1.18462712e-01f, -1.01371676e-01f, 8.60397667e-02f, -8.00018292e-03f, 2.18470450e-02f, -1.85453057e-01f, -1.16679827e-02f, 4.94524278e-02f, -1.02507271e-01f,
  -1.09371908e-01f, -9.20470506e-02f, 9.55085531e-02f, 5.43358065e-02f, -7.89983198e-02f, 5.82494475e-02f, 1.37799993e-01f, 1.47772998e-01f, 1.35598918e-02f, -1.10797603e-02f,
  4.50306851e-03f, -4.88330796e-02f, 2.69943234e-02f, -5.39713763e-02f, -1.19296037e-01f, 1.86880812e-01f, -1.92164063e-01f, -1.08748242e-01f, 5.32473326e-02f, -2.69044459e-01f,
  -5.45432717e-02f, 9.15104821e-02f, -1.06954955e-01f, -1.37490943e-01f, -3.86906154e-02f, -6.96473271e-02f, 4.70687486e-02f, 3.92513350e-02f, -4.98961657e-03f, 3.72904874e-02f,
  1.23255644e-02f, 1.28886262e-02f, -1.05027743e-01f, 1.63388625e-02f, -6.63444027e-02f, 1.85058266e-02f, -3.32560539e-02f, -1.32757274e-03f, -1.61061853e-01f, 1.48758506e-02f,
  5.87831624e-02f, -9.48975906e-02f, -5.51360771e-02f, 1.23270668e-01f, 5.30957803e-03f, 8.70115906e-02f, 1.07887976e-01f, 1.29867509e-01f, 2.86119953e-02f, -6.09761290e-02f,
  6.58033565e-02f, 2.35611960e-01f, -1.39697552e-01f, -2.18919404e-02f, 3.39989066e-02f, -1.26940086e-01f, -1.70259058e-01f, 8.35318491e-02f, 7.87883624e-02f, 2.77623516e-02f,
  8.50864127e-02f, 2.00399980e-02f, 2.39572804e-02f, -3.15172337e-02f, 1.20329663e-01f, -5.03747053e-02f, -2.16672495e-02f, 6.85012788e-02f, -8.55924487e-02f, -4.64711487e-02f,
  -7.04093724e-02f, 6.53399006e-02f, -2.63501965e-02f, 7.21921027e-02f, -1.28196001e-01f, 1.82396144e-01f, -1.14387631e-01f, -7.67434463e-02f, 1.63644344e-01f, -1.50060520e-01f,
  5.47093511e-01f, -1.87457904e-01f, 1.19964421e-01f, 8.64059255e-02f, -1.48836792e-01f, -1.80605844e-01f, -2.59920776e-01f, -4.87784222e-02f, 9.32251811e-02f, 4.36329879e-02f,
  -5.20978011e-02f, 1.39103293e-01f, 1.93776250e-01f, 1.76256493e-01f, 1.89745411e-01f, 1.04818761e-01f, 3.56412753e-02f, 4.03209984e-01f, 3.43209803e-01f, 1.22493573e-01f,
  -4.38062102e-02f, -3.69097628e-02f, 2.55880922e-01f, 1.18004404e-01f, -1.89483501e-02f, 6.80579841e-02f, 7.00570196e-02f, 2.88356352e-03f, -4.92868982e-02f, 2.10260943e-01f,
  1.40138209e-01f, 2.38174245e-01f, 9.50470641e-02f, -3.10328584e-02f, 1.20203895e-02f, -4.33665141e-02f, -7.62793794e-02f, 1.45902941e-02f, -6.41006008e-02f, -9.20846611e-02f,
  -1.28712997e-01f, -5.11280894e-02f, -1.29605189e-01f, -9.17329565e-02f, -1.20780431e-01f, 1.57095883e-02f, 6.26196936e-02f, 1.30342111e-01f, 9.83623415e-02f, 9.41246524e-02f,
  -7.40507320e-02f, -1.66722700e-01f, -1.10161178e-01f, -2.64345482e-02f, 5.33650406e-02f, 2.46923044e-02f, 2.69576907e-02f, 2.22366471e-02f, 2.56898161e-02f, 1.00428574e-01f,
  1.08413033e-01f, 2.89353747e-02f, 7.70066082e-02f, 1.63888156e-01f, 5.36378957e-02f, 1.39088482e-01f, 7.44240358e-02f, -2.27837432e-02f, -1.77285206e-02f, 7.08111227e-02f,
  6.82519153e-02f, 3.55195254e-02f, 1.93089209e-02f, 6.90190271e-02f, -2.33288575e-02f, -1.25140068e-03f, -4.08624671e-02f, -1.09008871e-01f, -4.48107608e-02f, -1.13409601e-01f,
  2.89953174e-03f, 8.15037731e-03f, 8.43252614e-02f, -5.52571528e-02f, -1.20783541e-02f, -1.46607859e-02f, 9.66330175e-04f, -5.31885438e-02f, -8.00381973e-02f, -7.80795366e-02f,
  -4.34646517e-01f, 7.33549073e-02f, 5.91348298e-02f, 2.41868626e-02f, -2.91171316e-02f, -5.82645275e-02f, -2.39548311e-02f, -2.66544204e-02f, -8.49574655e-02f, -1.37263864e-01f,
  -7.08841085e-02f, -2.00094488e-02f, -2.46831700e-02f, 4.29794565e-03f, -3.71011570e-02f, 1.71729457e-02f, 1.43487275e-01f, 5.06929010e-02f, -1.17306456e-01f, -3.44851986e-02f,
  -2.21275948e-02f, -1.17550373e-01f, -1.74961373e-01f, -1.56094611e-01f, -6.55316934e-02f, -7.57255927e-02f, -5.37284724e-02f, -2.95434408e-02f, -1.42166406e-01f, -1.85635015e-02f,
  5.02213597e-01f, 9.65592638e-02f, -3.28500539e-01f, 1.87103808e-01f, -1.08693533e-01f, 2.65272260e-02f, -1.29212122e-02f, 1.54973105e-01f, 1.50151715e-01f, -1.05642840e-01f,
  -1.85319468e-01f, 1.35274930e-03f, -3.34817804e-02f, -1.57893628e-01f, -5.46915419e-02f, -9.27874744e-02f, -3.69143933e-02f, -1.40272439e-01f, -4.82727662e-02f, -1.05093919e-01f,
  -4.14322615e-02f, 1.88203841e-01f, 1.67425990e-01f, 2.85103507e-02f, -1.56711683e-01f, -1.31063983e-01f, -1.13294333e-01f, 1.06052272e-02f, -1.75554886e-01f, -2.43261978e-01f,
  -2.27931723e-01f, -7.93407708e-02f, -1.66249499e-01f, 2.62875501e-02f, 6.00875281e-02f, -3.97368670e-02f, -1.58237040e-01f, 1.38167467e-03f, -7.47981519e-02f, -1.51455984e-01f,
  -1.33043036e-01f, -1.59658551e-01f, -1.77572832e-01f, -1.06030338e-01f, -7.43645849e-03f, 7.87928700e-02f, 7.32764276e-03f, -1.15555458e-01f, 3.86098847e-02f, -4.04347330e-02f,
  -1.10838644e-01f, -1.74167067e-01f, -2.11035870e-02f, -1.32440999e-01f, -2.57752687e-02f, -9.77488700e-03f, -2.06093043e-01f, -2.31590569e-01f, -8.47946703e-02f, -2.05170531e-02f,
  -1.81643143e-02f, -4.39614244e-02f, -1.38770297e-01f, 1.96924135e-02f, 7.52490386e-02f, -1.28289714e-01f, -3.14592533e-02f, 5.59895411e-02f, 2.13380624e-02f, -3.74754635e-03f,
  -9.44956318e-02f, 1.38132676e-01f, -5.78311346e-02f, 5.97460754e-02f, 7.20428210e-03f, -2.94223428e-02f, 3.26274037e-02f, -4.01809141e-02f, -9.97516606e-03f, 6.84685558e-02f,
  6.78741038e-02f, -9.12425946e-03f, -1.54865636e-02f, 3.17887068e-02f, -6.80221274e-05f, 2.24367362e-02f, 1.23990618e-01f, -7.65076727e-02f, 6.00916781e-02f, -9.74376500e-03f,
  2.69693196e-01f, -1.76385179e-01f, -7.96437962e-04f, 1.45490050e-01f, -7.53561929e-02f, 1.42191313e-02f, -3.68767828e-02f, -6.87657669e-02f, 4.07035202e-02f, -1.05345659e-01f,
  -1.95646375e-01f, 3.98147441e-02f, 2.98508909e-03f, -4.74252999e-02f, 2.86427140e-02f, -6.76492229e-02f, 1.16264736e-02f, 9.99284629e-03f, -2.91716680e-02f, 9.33784693e-02f,
  1.43515721e-01f, 6.64642379e-02f, 1.59027129e-01f, 4.40812930e-02f, 1.98444739e-01f, 2.33253449e-01f, 1.62875056e-01f, 3.77537273e-02f, 1.60354093e-01f, 2.50327736e-01f,
  -2.91372985e-01f, 2.91320793e-02f, 2.59954296e-02f, -2.42618039e-01f, 7.63166547e-02f, 9.28522870e-02f, -9.97208897e-03f, -2.46287864e-02f, -3.74748483e-02f, -1.24987334e-01f,
  9.63843763e-02f, -1.38329610e-01f, 2.25183945e-02f, 4.47275639e-02f, -1.28081199e-02f, 1.38526440e-01f, -1.01694994e-01f, -1.21415881e-02f, 4.00896482e-02f, 2.26857916e-01f,
  2.36161482e-02f, -2.41614401e-01f, -2.18149841e-01f, -9.05945972e-02f, -2.01900035e-01f, -2.11060643e-01f, -1.45367989e-02f, -9.10192579e-02f, -3.23697440e-02f, -2.13755429e-01f,
  7.17278048e-02f, -9.87599939e-02f, 5.07892407e-02f, -1.40746862e-01f, 3.55726411e-03f, -9.21413600e-02f, -3.63896042e-02f, -4.92977276e-02f, -3.82996611e-02f, -8.79246369e-02f,
  -5.25093675e-02f, 9.91250426e-02f, 4.74536186e-03f, -9.00982171e-02f, -2.62118271e-03f, 1.96875948e-02f, -9.43386331e-02f, 1.19127914e-01f, 4.56667170e-02f, 4.56586629e-02f,
  -3.88423516e-03f, -2.74624266e-02f, 8.79793148e-03f, 5.79555444e-02f, -5.12598567e-02f, -1.44947976e-01f, -8.62249359e-02f, -5.66237746e-03f, 9.25607234e-03f, -2.48860165e-01f,
  1.70685370e-02f, -7.28211552e-02f, 1.40766367e-01f, -4.25296947e-02f, -1.63025912e-02f, -8.86804704e-03f, -7.38329366e-02f, -9.85158011e-02f, 9.26715061e-02f, -8.60601962e-02f,
  1.02632850e-01f, 1.39826700e-01f, 9.63141117e-03f, -4.19281647e-02f, -7.64355734e-02f, 3.29432562e-02f, -4.03496623e-02f, -1.04995422e-01f, 3.20364535e-02f, -3.36693265e-02f,
  3.67413945e-02f, -4.17768732e-02f, -3.11886203e-02f, -3.58866975e-02f, 5.77624589e-02f, 5.37130702e-03f, 1.32499365e-02f, -2.23333985e-02f, -4.58282158e-02f, -1.50316237e-02f,
  -1.40177935e-01f, 1.58752352e-01f, -7.20070601e-02f, -8.17919746e-02f, -5.87064885e-02f, 1.10403657e-01f, 6.19250387e-02f, 5.79852611e-02f, -8.20541158e-02f, -6.40616789e-02f,
  -7.66699342e-03f, -1.61883608e-01f, -5.02213687e-02f, -1.04132563e-01f, -5.66383563e-02f, -5.22669638e-03f, 3.70984785e-02f, -6.30799383e-02f, 2.00566068e-01f, -6.67019840e-03f,
  7.12306648e-02f, 1.06470194e-02f, -7.63371736e-02f, -1.21212371e-01f, -5.05950153e-02f, -1.66333333e-01f, -2.44494662e-01f, -1.21043034e-01f, -1.33576274e-01f, -4.11831111e-01f,
  -3.89651269e-01f, -5.55152148e-02f, -1.68203622e-01f, -1.52659208e-01f, 3.14129703e-02f, 4.98292781e-02f, 1.27577424e-01f, 1.58450171e-01f, -9.35273990e-02f, -1.14776939e-02f,
  9.23475251e-02f, -1.97677031e-01f, -2.07610101e-01f, -8.77111256e-02f, 1.00090675e-01f, 9.03763846e-02f, -1.26066862e-03f, -5.71557172e-02f, 2.40980126e-02f, 2.54772812e-01f,
  2.72220910e-01f, -1.13359228e-01f, -3.74392271e-02f, 1.34480909e-01f, -7.86175504e-02f, -1.01962090e-01f, -1.00775048e-01f, -3.05513162e-02f, 1.50976166e-01f, -2.08418474e-01f,
  -3.04463714e-01f, 5.35150664e-03f, 7.69628882e-02f, -2.49331649e-02f, -8.16087425e-02f, -5.07229120e-02f, -3.61683741e-02f, -6.30372539e-02f, -4.17870097e-02f, -1.13600664e-01f,
  -1.06141344e-01f, 2.89297309e-02f, -1.21871166e-01f, -2.05908548e-02f, 1.95892528e-03f, -3.30677517e-02f, 3.04792598e-02f, -6.24727532e-02f, -1.45988077e-01f, 1.08036816e-01f,
  7.27858767e-02f, -1.02354161e-01f, -5.30556142e-02f, 1.10128775e-01f, 5.62953949e-02f, -1.99855790e-02f, 7.36374781e-02f, 6.81153405e-03f, 1.65439080e-02f, -8.76292959e-02f,
  2.62973487e-01f, -6.74041212e-02f, 4.72557731e-02f, -1.91366617e-02f, -5.23879416e-02f, -1.22572571e-01f, 5.17589599e-02f, 1.26448855e-01f, 6.61877170e-02f, -1.29402116e-01f,
  -8.81469175e-02f, -1.34945419e-02f, 9.12116095e-02f, 5.04635759e-02f, -4.62140739e-02f, 1.58920828e-02f, 3.78589518e-02f, 5.06064668e-02f, 2.21089665e-02f, 2.34276522e-02f,
  -5.69356158e-02f, -4.28515524e-02f, -1.81089491e-02f, -1.33701097e-02f, 1.04660057e-02f, -2.16224045e-02f, 8.73663798e-02f, 1.02039218e-01f, 5.02090491e-02f, 1.37868747e-01f,
  -1.92254618e-01f, 9.46008265e-02f, -1.50500044e-01f, 1.15843892e-01f, -2.42887028e-02f, -5.38076237e-02f, 5.50589189e-02f, 1.45491838e-01f, -1.09727733e-01f, -1.37553038e-02f,
  1.15074076e-01f, 1.61637470e-01f, -4.30052765e-02f, 2.97105536e-02f, 5.15323728e-02f, 1.24088638e-01f, 1.41116515e-01f, 3.53967920e-02f, 2.22922545e-02f, 4.10113111e-02f,
  -4.25150730e-02f, 2.66284402e-02f, -7.59931579e-02f, -1.90752119e-01f, -1.30767226e-02f, 2.47568153e-02f, -1.18679307e-01f, 9.29636508e-02f, -1.64218768e-01f, -3.74000892e-02f,
  -4.23717707e-01f, -1.76060781e-01f, -3.59001666e-01f, -2.25942239e-01f, -2.21388936e-01f, -1.92168862e-01f, -2.15580717e-01f, 3.98640707e-02f, 2.87374090e-02f, -3.35894376e-01f,
  -1.07524447e-01f, -1.73472852e-01f, -8.51740018e-02f, -5.63630722e-02f, -7.39783123e-02f, -3.43041450e-01f, -3.96434814e-01f, -2.77072042e-01f, -1.50443405e-01f, 8.18065479e-02f,
  -1.64772391e-01f, -1.81985021e-01f, -8.00755173e-02f, -6.17462061e-02f, -2.48193555e-02f, 8.07905048e-02f, -1.23592809e-01f, -3.79904290e-03f, 6.36779442e-02f, -2.39515200e-01f,
  -4.81005199e-02f, -1.58442989e-01f, 4.80396906e-03f, 2.65240055e-02f, -1.14108853e-01f, -8.23042095e-02f, -1.18003853e-01f, 6.87117968e-03f, 7.78515115e-02f, 3.76040339e-02f,
  -1.12928592e-01f, 2.74688881e-02f, -1.19612299e-01f, 1.07102476e-01f, -7.63261225e-04f, -8.29297751e-02f, 5.62691353e-02f, 7.88512547e-03f, -5.66026755e-02f, 4.70068529e-02f,
  -2.71246321e-02f, -6.10661739e-03f, -3.82358045e-03f, 2.04762712e-01f, 1.59739256e-01f, 2.19425354e-02f, 2.02032760e-01f, 1.09907575e-01f, 1.86404824e-01f, 2.34415159e-01f,
  5.09299189e-02f, -7.00156093e-02f, -4.82943095e-02f, 2.27549616e-02f, -1.98170934e-02f, -3.77438180e-02f, -3.24931704e-02f, 1.52019300e-02f, 1.20981196e-02f, -1.98319145e-02f,
  -2.14389935e-02f, -2.92625334e-02f, -4.23634499e-02f, 5.26755117e-02f, 8.51849746e-03f, -6.55776933e-02f, -5.78554086e-02f, 9.16969478e-02f, 7.72449747e-02f, -4.27180342e-02f,
  1.77271720e-02f, 1.26667574e-01f, -4.04560864e-02f, 2.84432843e-02f, -1.18988324e-02f, -2.74324846e-02f, 3.98855247e-02f, -3.34049501e-02f, -7.46727958e-02f, -7.54473582e-02f,
  -6.72980547e-02f, -2.08708365e-02f, -2.77376100e-02f, 1.30469874e-01f, 1.20612560e-03f, 2.23579146e-02f, 4.93911952e-02f, 7.97314867e-02f, -1.63756311e-02f, 1.34666068e-02f,
  4.73539904e-02f, -7.10798949e-02f, -1.11504555e-01f, 4.65855785e-02f, -8.43818635e-02f, 1.09847952e-02f, 5.58948517e-02f, 3.22220773e-02f, 1.04268156e-01f, 9.05780718e-02f,
  7.72000775e-02f, 6.97938949e-02f, 1.34769142e-01f, 7.53212199e-02f, 8.80279317e-02f, -1.25119358e-01f, 8.77473652e-02f, 1.42073050e-01f, -2.92605292e-02f, 1.08580008e-01f,
  7.38313273e-02f, -1.09237410e-01f, 1.81844726e-01f, 8.42264220e-02f, -1.21409528e-01f, -1.10640608e-01f, -2.42849424e-01f, -6.06212467e-02f, -6.03275076e-02f, 2.94658486e-02f,
  1.26083091e-01f, 3.18692416e-01f, 2.93009877e-01f, 2.42571399e-01f, 1.96860686e-01f, -1.44103430e-02f, -6.25755042e-02f, 2.00628653e-01f, 2.62954772e-01f, 9.92200226e-02f,
  -1.00532554e-01f, -9.59047079e-02f, 1.15273930e-01f, -3.82356951e-03f, -1.63465351e-01f, -2.10418762e-03f, -1.97450351e-02f, 1.50913745e-02f, -4.32417393e-02f, 4.33994085e-02f,
  2.29677811e-01f, -2.19767690e-02f, 9.80051309e-02f, -2.53535509e-02f, -5.43255769e-02f, -4.87331413e-02f, 7.51848295e-02f, 7.68617028e-04f, -1.05378240e-01f, 2.54409648e-02f,
  3.11591811e-02f, -8.32427200e-03f, -7.51475543e-02f, -1.36402445e-02f, -6.29278719e-02f, -1.04994908e-01f, -1.75635621e-01f, 7.82601461e-02f, 1.49389565e-01f, 8.28921422e-03f,
  -5.82536543e-03f, -1.12051852e-02f, 1.00168519e-01f, 3.24228592e-02f, 7.61562288e-02f, 4.47584409e-03f, 8.09655711e-03f, -4.64783609e-02f, 5.85845113e-02f, -9.30006057e-02f,
  1.38419211e-01f, 6.63647503e-02f, 7.19608814e-02f, 4.15213518e-02f, 1.15959775e-02f, -3.95405442e-02f, 2.08205096e-02f, 8.08345377e-02f, 2.78232358e-02f, -1.03719488e-01f,
  -2.68350039e-02f, 1.63643315e-01f, 1.00161098e-01f, -1.41418343e-02f, 8.60199407e-02f, 1.00194402e-01f, 7.97586516e-02f, -2.43227370e-02f, -6.14813566e-02f, -3.14278826e-02f,
  8.36382285e-02f, -1.96513869e-02f, 6.89882040e-02f, -2.64729913e-02f, -6.62814826e-03f, 4.60509993e-02f, -1.36996498e-02f, -3.55714373e-02f, -8.46350044e-02f, 2.07298412e-03f,
  6.14857934e-02f, 1.73246771e-01f, 3.11830677e-02f, 1.14317007e-01f, -3.15205120e-02f, -5.81045598e-02f, 4.66291979e-02f, 5.56565486e-02f, -4.94864509e-02f, 6.77344278e-02f,
  -1.10594325e-01f, 3.78811397e-02f, -4.01042998e-02f, -1.78651169e-01f, -1.99450374e-01f, -1.42887637e-01f, -8.08411539e-02f, 1.40648514e-01f, 7.31548443e-02f, 7.01642260e-02f,
  -8.49657804e-02f, -1.22958375e-02f, 2.07131043e-01f, -1.28403893e-02f, -5.07680662e-02f, 4.59286608e-02f, 9.09511093e-03f, -9.12793949e-02f, 5.58827557e-02f, -5.46585843e-02f,
  -4.64716852e-01f, 6.98566064e-02f, -2.45709568e-01f, -1.35694861e-01f, 1.38382003e-01f, 2.56260246e-01f, 2.34561712e-01f, 3.61997518e-03f, -6.69567334e-03f, 1.98171157e-02f,
  1.19182952e-02f, -1.64528750e-02f, -1.23409042e-02f, 1.76125899e-01f, 2.32649297e-01f, 2.92098939e-01f, 2.45467559e-01f, -2.90467385e-02f, 4.79747448e-03f, 9.37378109e-02f,
  2.26518303e-01f, -8.72772112e-02f, -2.71909744e-01f, -8.63242969e-02f, -1.13284372e-01f, -7.90477991e-02f, 4.73343283e-02f, -3.90642174e-02f, 1.99633151e-01f, -1.18895724e-01f,
  -2.03438982e-01f, -1.86983868e-01f, 1.05901711e-01f, 5.51437843e-04f, -4.96795513e-02f, -1.93727121e-01f, 8.93321633e-02f, -1.51335955e-01f, 4.48127538e-02f, -7.21676499e-02f,
  -2.59901807e-02f, 2.82807574e-02f, 5.39586227e-03f, -9.26956162e-02f, -7.22245798e-02f, -2.67510712e-02f, -5.64444959e-02f, -1.23559475e-01f, -9.08572972e-02f, -1.13430113e-01f,
  8.36876109e-02f, -6.79852441e-02f, -2.11060196e-01f, -9.81439203e-02f, -1.62110701e-01f, -1.53857730e-02f, -8.84045735e-02f, -1.38067618e-01f, 2.97159310e-02f, -2.58186996e-01f,
  9.36527476e-02f, 1.09002613e-01f, -4.97527495e-02f, 9.54398289e-02f, -4.01186123e-02f, 8.54797587e-02f, 1.66749209e-01f, 1.16529934e-01f, -4.79889028e-02f, -3.24257975e-03f,
  -3.29467021e-02f, -5.43650910e-02f, 9.46768001e-02f, 5.64251505e-02f, 1.08012468e-01f, -3.67696248e-02f, 7.59784579e-02f, -1.81761291e-02f, 5.85514680e-02f, 6.08425550e-02f,
  1.05360009e-01f, -1.51986748e-01f, -9.25499797e-02f, -2.74261292e-02f, 2.74967775e-02f, 8.01213607e-02f, -9.49576572e-02f, -6.82770982e-02f, -5.92326075e-02f, -1.73943248e-02f,
  -3.55027728e-02f, 2.31274396e-01f, -2.38787755e-02f, -3.74000147e-02f, -1.11799411e-01f, -3.49670462e-02f, 3.07838023e-02f, -9.02882591e-02f, -8.46026540e-02f, 4.20894101e-02f,
  1.09789066e-01f, 8.52454640e-03f, 1.27351165e-01f, -8.10379609e-02f, -2.67459471e-02f, 8.05993304e-02f, 1.48743525e-01f, -1.07115857e-01f, -6.62150756e-02f, -1.02302164e-01f,
  -6.58927113e-02f, -6.01197314e-03f, -1.84732810e-01f, -2.98389569e-02f, -1.77575678e-01f, 8.05378705e-02f, -6.44043386e-02f, -9.49912705e-04f, 1.22391470e-01f, -2.61893608e-02f,
  3.22673768e-01f, -4.85212952e-01f, -3.76590192e-02f, 3.92957628e-02f, 2.45114163e-01f, 3.30336243e-01f, 2.39774570e-01f, 6.32820800e-02f, 2.16523513e-01f, -3.42415310e-02f,
  -3.27065140e-01f, -1.85630798e-01f, -2.57877707e-01f, -1.93709984e-01f, -7.40288198e-02f, -1.82295963e-02f, 5.89709058e-02f, 2.04708889e-01f, 3.43630880e-01f, 1.25445724e-01f,
  -9.07911509e-02f, 8.70774686e-02f, 1.31058749e-02f, 8.01017787e-03f, -2.16824636e-01f, -6.58724681e-02f, -1.90071970e-01f, -8.03563837e-03f, -2.60538667e-01f, -9.21270773e-02f,
  4.33594622e-02f, -1.17064394e-01f, 1.86132267e-01f, -7.37991929e-02f, -8.97093192e-02f, -1.38094248e-02f, -2.88253259e-02f, -7.13576525e-02f, 4.18360205e-03f, 3.91494073e-02f,
  1.12400437e-02f, -1.09840959e-01f, 3.05620264e-02f, -1.45542130e-01f, 1.51813924e-01f, 8.69613364e-02f, -1.05367564e-01f, -9.42671373e-02f, -1.53410524e-01f, -1.12037569e-01f,
  -2.59828776e-01f, -4.70827334e-02f, 1.15220316e-01f, 1.45539185e-02f, -8.53512138e-02f, 8.36123005e-02f, -1.71603501e-01f, -1.00310974e-01f, -3.93515937e-02f, 7.34818429e-02f,
  6.73481375e-02f, 3.54457572e-02f, -5.42767979e-02f, 7.41621107e-02f, -5.18875197e-02f, -5.36488742e-03f, 1.51020437e-01f, 2.71343887e-02f, 6.79839849e-02f, 5.47775179e-02f,
  9.09478292e-02f, -1.07629195e-01f, -1.20458439e-01f, 4.88169305e-02f, -5.59533089e-02f, -1.12915039e-01f, 2.06946451e-02f, -4.47789803e-02f, -8.86241943e-02f, 2.83394903e-02f,
  -7.49039799e-02f, -9.44616366e-03f, 5.19389212e-02f, -1.67118862e-01f, -1.12506069e-01f, -9.35018435e-02f, -3.93669903e-02f, -1.72767848e-01f, -2.48588976e-02f, 2.48561166e-02f,
  -1.53427258e-01f, -1.11963153e-01f, 1.46038741e-01f, -5.51022328e-02f, 6.09821780e-03f, -1.23371564e-01f, -1.23653300e-01f, -5.33303879e-02f, -1.05474167e-01f, -1.67499147e-02f,
  7.43129179e-02f, 6.82231635e-02f, -1.27214238e-01f, -3.57372351e-02f, 1.93647325e-01f, 9.05195475e-02f, -1.41664043e-01f, 5.08965403e-02f, -9.76469740e-02f, -1.20562218e-01f,
  -7.08875305e-04f, 2.07180321e-01f, 1.36695206e-01f, 1.13410726e-01f, 1.65195376e-01f, 2.75319695e-01f, 9.68952551e-02f, 1.46637052e-01f, 1.47425830e-01f, 2.95244366e-01f,
  -3.68720680e-01f, -1.97632927e-02f, -7.15159699e-02f, 1.64328113e-01f, 4.03586328e-02f, 3.42616066e-02f, -8.66548195e-02f, -1.05049714e-01f, 1.07595161e-01f, 3.01370136e-02f,
  -2.41190970e-01f, -1.21961078e-02f, 1.33905262e-01f, 2.89606526e-02f, -2.39454396e-02f, 1.56608716e-01f, 2.42127702e-01f, 9.48037505e-02f, 8.66936669e-02f, 1.77883897e-02f,
  2.26052105e-01f, 2.19969839e-01f, -3.76937017e-02f, 5.38002886e-02f, 1.26357481e-01f, 1.87947243e-01f, 4.40617241e-02f, 5.24807535e-02f, 1.20900288e-01f, 3.03290397e-01f,
  -1.20811090e-01f, -1.98941946e-01f, 4.45912331e-02f, 1.79027917e-03f, -1.66962780e-02f, -3.21941189e-02f, -1.13354377e-01f, -6.50063008e-02f, -1.23422034e-01f, 7.24464208e-02f,
  5.43079281e-04f, -1.04107246e-01f, 1.19914271e-01f, 1.02910161e-01f, -5.68210008e-03f, -5.24457470e-02f, -7.34487874e-03f, -2.80691031e-03f, -1.16298966e-01f, -1.82546392e-01f,
  2.18898609e-01f, -1.40133770e-02f, -2.78114200e-01f, -4.35770079e-02f, -3.46564837e-02f, 1.30022913e-01f, -7.30602816e-02f, -1.66909158e-01f, -1.45858958e-01f, -9.11864825e-03f,
  -9.24034268e-02f, -7.55518377e-02f, -3.32332514e-02f, -5.50668798e-02f, 2.06172280e-02f, 7.06881583e-02f, 2.20320802e-02f, 4.13603242e-03f, -1.78993568e-02f, -1.16493804e-02f,
  4.39788103e-02f, -1.50684398e-02f, 5.11468910e-02f, -1.63206011e-02f, 8.14025700e-02f, 5.32214604e-02f, -1.83103960e-02f, -8.24488848e-02f, -5.46530113e-02f, 2.23266464e-02f,
  7.69997314e-02f, -1.23135829e-02f, 6.91492409e-02f, -1.25283806e-03f, 1.10614346e-02f, -1.40852015e-02f, 5.86881898e-02f, -4.10324149e-02f, -8.76981393e-02f, 4.28362526e-02f,
  -1.04003120e-02f, 4.04853858e-02f, -1.08875237e-01f, -1.54105769e-02f, 4.32284661e-02f, -1.76730245e-01f, -9.27923527e-03f, 1.47111202e-02f, 4.82671894e-03f, -2.19073892e-02f,
  -9.32229832e-02f, -1.16773464e-01f, 2.52242852e-02f, 5.76351173e-02f, -5.66030703e-02f, -4.38374095e-02f, -2.54757218e-02f, -7.71336583e-03f, -4.56122309e-02f, -1.50044218e-01f,
  7.11245313e-02f, -8.04283619e-02f, -1.71957418e-01f, -1.23172551e-01f, -9.43647400e-02f, -3.84971760e-02f, -1.18794411e-01f, -9.45669189e-02f, -1.64861947e-01f, -2.54706293e-01f,
  -1.09171623e-03f, 2.57750660e-01f, 3.37026298e-01f, -1.35654688e-01f, 1.26442313e-01f, 2.39361107e-01f, 1.67856410e-01f, 4.13125120e-02f, -1.23065360e-01f, 1.37969747e-01f,
  3.00890416e-01f, -2.78439671e-01f, -2.87448335e-02f, -8.36506188e-02f, -2.70776302e-02f, 1.14416294e-01f, -1.71413600e-01f, -1.36799499e-01f, -3.13657254e-01f, -7.78892785e-02f,
  -2.29232937e-01f, -2.31358364e-01f, -3.16308856e-01f, -2.01860636e-01f, -1.02478862e-02f, -7.11963549e-02f, 1.13497011e-01f, -3.70304077e-03f, 9.40900669e-02f, -5.63285388e-02f,
  8.02254677e-02f, 2.44549200e-01f, -7.05192760e-02f, -1.97214946e-01f, 1.33056983e-01f, -2.04632521e-01f, -1.59710012e-02f, 6.67808875e-02f, -3.45802680e-02f, -9.38775092e-02f,
  2.90693156e-02f, 1.73852332e-02f, 3.58048566e-02f, -9.36509818e-02f, -1.25028165e-02f, -1.57617722e-02f, -2.52569653e-02f, -8.11079890e-02f, -2.08264172e-01f, -3.35931331e-02f,
  -5.32903969e-02f, 9.88399237e-02f, 1.50167033e-01f, -2.00825967e-02f, -3.43880919e-03f, -2.02457413e-01f, 1.43892929e-01f, 4.04186919e-02f, 8.87156725e-02f, -3.22717279e-02f,
  6.49419706e-03f, -8.38866364e-03f, 1.06201895e-01f, 6.20141253e-02f, -4.11474220e-02f, -3.51044834e-02f, 4.77465615e-02f, -1.14506669e-01f, 2.45229341e-02f, 1.17377872e-02f,
  3.00654657e-02f, 3.19530405e-02f, 2.54101809e-02f, 9.18545723e-02f, -2.39580367e-02f, 5.58727533e-02f, -1.91050451e-02f, -4.83503826e-02f, 4.64734435e-02f, -5.16952761e-02f,
  -2.81901434e-02f, 3.27573344e-02f, -1.83968954e-02f, -1.50089756e-01f, 5.57089299e-02f, 7.50899613e-02f, -7.27071834e-04f, 4.87275887e-03f, -2.14132154e-03f, 1.05840974e-01f,
  -2.62322694e-01f, 1.98214054e-01f, -1.19056828e-01f, -1.09541729e-01f, 3.61817293e-02f, -2.69880518e-02f, -4.01788298e-03f, 4.97590527e-02f, 1.38065383e-01f, -3.34056560e-03f,
  -4.49903719e-02f, 6.73584417e-02f, 9.43497643e-02f, -1.51613891e-01f, -1.43413514e-01f, -3.99107812e-03f, -1.19122304e-01f, -1.00511461e-01f, -1.02539204e-01f, -2.18222350e-01f,
  -1.29514888e-01f, -1.39642969e-01f, -1.35188207e-01f, -5.05761877e-02f, -1.04534045e-01f, -8.40058923e-02f, 1.54144382e-02f, -8.65543336e-02f, -6.20785654e-02f, -3.88914198e-02f,
  -2.72507250e-01f, -2.58925349e-01f, -1.82820767e-01f, -1.44129977e-01f, -1.33622795e-01f, -5.52891530e-02f, -9.52737629e-02f, 8.74413326e-02f, 4.20774482e-02f, -3.00902337e-01f,
  -1.42975807e-01f, -3.39513682e-02f, -2.61178851e-01f, 4.60395264e-03f, 5.10892160e-02f, -1.80515304e-01f, -2.40074039e-01f, -1.22624375e-01f, 2.34018505e-01f, 1.92621619e-01f,
  -5.42500839e-02f, -1.49503902e-01f, 2.19215788e-02f, 1.98140651e-01f, -4.84515950e-02f, -1.38184905e-01f, -2.56045997e-01f, -7.29273781e-02f, 4.66865115e-03f, -3.83415520e-01f,
  -1.50390580e-01f, 8.59599486e-02f, -5.34865111e-02f, 6.92661330e-02f, -5.11319228e-02f, 1.29247591e-01f, -5.78476526e-02f, 8.30062758e-03f, -4.54983488e-02f, -2.83225495e-02f,
  5.28746806e-02f, 4.25245613e-02f, 8.90891254e-02f, 1.77597941e-03f, -4.70304303e-02f, 1.11590564e-01f, -5.61180003e-02f, -5.48618212e-02f, -3.97539698e-03f, -3.40818539e-02f,
  3.57457101e-02f, 2.14559752e-02f, 7.74998665e-02f, -2.90029682e-02f, 1.76345259e-01f, -1.58673048e-03f, -5.42649999e-02f, 9.40541625e-02f, 9.16384459e-02f, -1.79817587e-01f,
  -5.62121421e-02f, -3.84438038e-02f, 1.61507037e-02f, -2.77906824e-02f, -8.72941688e-02f, -4.40125689e-02f, 3.05116456e-03f, -1.03336550e-01f, 4.46701758e-02f, -1.89418674e-01f,
  -8.84937942e-02f, -7.76603371e-02f, 2.43164692e-02f, -4.42281878e-03f, 2.34511569e-02f, -3.21789831e-02f, 2.75428575e-02f, -4.85519692e-03f, 5.10142520e-02f, -2.78369635e-02f,
  -1.13799488e-02f, 3.11431498e-03f, -8.79063159e-02f, 6.87111169e-02f, -1.24846185e-02f, -6.24998659e-02f, 2.15601958e-02f, 9.59007367e-02f, 3.64773348e-02f, 6.06133379e-02f,
  -2.04564825e-01f, 9.00011584e-02f, -1.38898939e-01f, 6.55006990e-02f, -6.90673292e-03f, 7.20156878e-02f, -8.54611620e-02f, 1.79178622e-02f, -1.99705940e-02f, 4.37015761e-03f,
  1.16142504e-01f, -5.94617687e-02f, -6.38263077e-02f, -8.53607133e-02f, -1.63855385e-02f, -5.32402482e-04f, -1.33579774e-02f, -1.10049099e-01f, 1.84869766e-01f, 1.03245385e-01f,
  -8.65942463e-02f, 2.01599021e-02f, -4.07591537e-02f, -8.19833726e-02f, -6.05569640e-03f, -3.94861884e-02f, -4.40746434e-02f, 1.00543357e-01f, 1.01026148e-03f, -3.17997485e-01f,
  -4.61145252e-01f, 2.31430139e-02f, -3.65172094e-03f, -9.45007652e-02f, 1.01690359e-01f, -6.31032279e-03f, 5.39117306e-02f, -5.56313656e-02f, 4.83068638e-02f, -1.35976031e-01f,
  -2.82059282e-01f, -6.51575672e-03f, 1.67121768e-01f, 2.32177064e-01f, 1.33598238e-01f, 1.10162549e-01f, 2.87217289e-01f, 2.33241439e-01f, 4.15293314e-03f, 2.91692130e-02f,
  4.28736098e-02f, 2.31508147e-02f, -8.33367705e-02f, -1.32953487e-02f, 5.52277341e-02f, 3.33597586e-02f, -1.88342929e-02f, 3.46943103e-02f, -1.44553222e-02f, 3.37835431e-01f,
  -8.21590349e-02f, -1.22913957e-01f, 4.83979173e-02f, -7.05792382e-02f, -4.57831100e-02f, -1.85051002e-02f, -6.37091249e-02f, 5.86322658e-02f, -1.79232359e-02f, -3.21443565e-02f,
  2.13891007e-02f, 5.22010215e-03f, 2.90823337e-02f, 5.21129146e-02f, 1.36818653e-02f, -1.06957786e-01f, 6.44394234e-02f, 5.56163825e-02f, -6.32455051e-02f, -4.43965271e-02f,
  8.64915475e-02f, -1.24626771e-01f, -4.17658091e-02f, -3.69560458e-02f, 2.79318839e-02f, 3.31602804e-02f, -1.51868993e-02f, -9.44254324e-02f, -6.30114228e-02f, -4.77698743e-02f,
  -3.09183765e-02f, 5.08114919e-02f, 8.96005109e-02f, 3.53496186e-02f, 8.95732343e-02f, 4.24932037e-03f, 1.29136920e-01f, 1.01244472e-01f, 7.04665557e-02f, 3.64856906e-02f,
  2.25445274e-02f, -2.17198536e-01f, 9.86324921e-02f, -1.03129260e-02f, -9.90900025e-03f, -6.67520836e-02f, 9.97568443e-02f, 1.03482688e-02f, -5.04145585e-02f, 2.71776803e-02f,
  1.03701815e-01f, 2.75813090e-03f, -8.29623314e-04f, 1.57101527e-01f, 4.22926024e-02f, 6.08444959e-02f, 6.03317842e-03f, -1.13513425e-01f, -9.92260203e-02f, 3.98404151e-02f,
  -5.32508790e-02f, 1.17082208e-01f, -5.49836792e-02f, -1.85430963e-02f, 1.11618778e-02f, -1.16843777e-02f, -5.91344424e-02f, -5.63255548e-02f, -2.28222590e-02f, -6.43951893e-02f,
  -1.30218431e-01f, 4.87546297e-03f, -3.50396410e-02f, -7.79811144e-02f, 2.12876219e-02f, -5.02336137e-02f, 7.30955973e-02f, 3.13411816e-03f, -3.51761766e-02f, -2.59458013e-02f,
  -5.38179993e-05f, -6.94345459e-02f, -2.26494342e-01f, -4.67053875e-02f, -2.05639139e-01f, -1.87339425e-01f, -1.35262713e-01f, -6.73448741e-02f, -1.38762429e-01f, -2.74269134e-01f,
  -3.59012008e-01f, -9.50333029e-02f, 8.61804932e-02f, -1.55403376e-01f, 2.24760860e-01f, 2.90408492e-01f, 4.09663022e-01f, 8.48130602e-03f, -4.63420227e-02f, -5.05779497e-02f,
  -9.71537158e-02f, -1.71175927e-01f, -1.14767872e-01f, -6.19582534e-02f, 1.57521099e-01f, 2.01596215e-01f, 2.69123226e-01f, 7.31361797e-03f, 6.83564693e-02f, -2.10322198e-02f,
  1.79189220e-01f, 3.78666446e-02f, -1.55466974e-01f, -6.64027035e-02f, 4.60618455e-03f, -1.49483696e-01f, 7.22539574e-02f, 1.71254873e-02f, 3.34603302e-02f, -1.09838760e-02f,
  -4.42487225e-02f, 1.21312868e-02f, -6.52596653e-02f, -1.71599656e-01f, 6.26393780e-02f, -1.71635989e-02f, 5.73609723e-03f, -2.23160386e-01f, -1.90509126e-01f, 3.85659300e-02f,
  -1.81214035e-01f, -8.29863027e-02f, 2.10853815e-02f, 5.46670798e-03f, 4.94597442e-02f, -1.28563434e-01f, 2.09434945e-02f, 4.73718829e-02f, 1.13259126e-02f, -1.01205386e-01f,
  -1.65543873e-02f, 6.07439056e-02f, 8.09995756e-02f, 1.20265819e-01f, 1.17374361e-01f, 7.10192369e-03f, 5.60035836e-03f, 6.77487347e-03f, 6.03924319e-02f, -7.36689791e-02f,
  9.46295410e-02f, -4.04652804e-02f, -1.25206336e-01f, 1.29110619e-01f, 9.55843553e-02f, 8.21816698e-02f, -1.09158056e-02f, -4.54979725e-02f, 7.55460858e-02f, 5.19146882e-02f,
  1.36386737e-01f, 1.09037742e-01f, 8.60897265e-03f, 5.20214140e-02f, -6.71106800e-02f, 3.89492065e-02f, 9.35311094e-02f, 2.25333050e-02f, -1.07739024e-01f, 6.10216409e-02f,
  5.55023365e-02f, 1.45731330e-01f, 2.93504503e-02f, 6.40113950e-02f, 1.11649193e-01f, -2.17444319e-02f, 6.10672263e-03f, 6.73171356e-02f, -7.52432272e-02f, 1.86950713e-01f,
  5.56116961e-02f, 2.27447644e-01f, -1.60686731e-01f, 1.14216626e-01f, -5.70605025e-02f, -1.29885226e-01f, -8.39750618e-02f, -1.06944323e-01f, 4.49310206e-02f, -6.80673718e-02f,
  1.21612689e-02f, 1.16998803e-04f, 1.01580902e-03f, -1.00324325e-01f, 3.67745664e-03f, -1.41736427e-02f, 1.69562101e-02f, 5.17500676e-02f, 1.53685436e-01f, 5.77795319e-02f,
  2.05588043e-01f, 1.16023228e-01f, 4.83658761e-02f, 9.67771921e-04f, 9.53467041e-02f, 9.46634933e-02f, -6.17501400e-02f, 2.63085421e-02f, -2.52560228e-02f, -7.54158050e-02f,
  -8.73423740e-03f, -1.60326347e-01f, -3.76293778e-01f, -1.31294593e-01f, -2.03862816e-01f, 9.36678145e-03f, -1.04513131e-01f, 4.61442163e-03f, 2.68386062e-02f, -1.44618303e-01f,
  -1.19574890e-01f, -7.84648508e-02f, -1.48427293e-01f, -6.85551539e-02f, -7.97669366e-02f, -2.32289091e-01f, -2.88448811e-01f, -1.27088130e-01f, 2.07534563e-02f, 8.71902555e-02f,
  -1.60328418e-01f, -2.91973263e-01f, -1.38824970e-01f, -7.08792955e-02f, -8.85798857e-02f, 4.10895795e-02f, -1.11955546e-01f, -7.15106055e-02f, -2.22874749e-02f, -2.51748979e-01f,
  -1.58259422e-01f, 1.52071074e-01f, 6.28304556e-02f, 1.00204408e-01f, 7.04963356e-02f, 6.65721148e-02f, 7.36029521e-02f, -5.68712056e-02f, 1.04757398e-01f, 1.49946138e-02f,
  5.31860627e-02f, 8.85522831e-03f, 7.93973729e-02f, 6.06666319e-02f, 2.68317759e-03f, -5.57035729e-02f, 4.32817079e-02f, 8.22319761e-02f, 7.28469267e-02f, 9.12460089e-02f,
  -2.80372947e-02f, 1.19670583e-02f, 1.63159281e-01f, 2.08500609e-01f, 2.20681205e-01f, 1.43984720e-01f, 1.28848031e-01f, 2.02749416e-01f, 1.43561125e-01f, 1.84274614e-01f,
  -2.30794661e-02f, 1.66923832e-02f, -2.27580480e-02f, -2.16599740e-02f, -5.11357300e-02f, 5.82341552e-02f, 2.52540521e-02f, 5.79148047e-02f, -4.31500077e-02f, -6.32060040e-03f,
  6.99254870e-02f, 3.60000357e-02f, 1.27416417e-01f, -2.61141341e-02f, -1.12159722e-01f, -6.47754446e-02f, -9.51934457e-02f, 1.36571471e-02f, 2.64397766e-02f, -4.36706692e-02f,
  1.32845148e-01f, 1.24429993e-01f, -5.55293150e-02f, 9.52510536e-02f, 8.86476785e-02f, 7.94615820e-02f, -3.69819403e-02f, -3.23471986e-02f, -4.00656508e-03f, -8.72593150e-02f,
  1.95343550e-02f, 1.60279781e-01f, -1.42573658e-02f, 7.44380429e-02f, -1.53034301e-02f, 3.67794260e-02f, -7.37127662e-02f, -4.43170555e-02f, 1.11902989e-02f, 4.03588228e-02f,
  -5.24122827e-02f, 9.82547645e-03f, -7.65189528e-02f, 8.85162503e-02f, 3.05145960e-02f, -5.22343852e-02f, 1.34297954e-02f, -1.64581642e-01f, -1.88954789e-02f, -4.27302644e-02f,
  4.36337516e-02f, -1.08026434e-02f, 1.01629205e-01f, 6.06535077e-02f, 2.57675666e-02f, -3.11396755e-02f, 2.63274927e-02f, 6.34942353e-02f, -4.60407883e-02f, -5.26001118e-02f,
  2.54642606e-01f, 7.04384968e-02f, 1.95445746e-01f, 2.35055178e-01f, -1.40536770e-01f, -3.16594422e-01f, -3.96956086e-01f, -2.91581452e-01f, 5.09198233e-02f, 7.66494498e-02f,
  -4.65273112e-02f, 4.94747981e-02f, -1.52983079e-02f, -1.02740429e-01f, -1.68636099e-01f, 5.65856695e-02f, 1.71156883e-01f, 9.90710258e-02f, -1.31081507e-01f, -2.92349160e-01f,
  -3.53715941e-02f, 7.33198132e-03f, 1.52507603e-01f, -9.79139060e-02f, 3.98094393e-02f, 6.39630556e-02f, 1.15876481e-01f, 9.79208499e-02f, 1.11860421e-03f, 2.88983077e-01f,
  2.18225703e-01f, 2.40414903e-01f, -1.68354854e-01f, 2.63167769e-02f, 6.32812083e-02f, 4.54281159e-02f, 6.30497327e-03f, 2.13370308e-01f, 8.38674083e-02f, 6.91390708e-02f,
  8.42314139e-02f, -1.66871771e-02f, 1.25231326e-01f, 1.40403077e-01f, -1.82184279e-02f, 1.52865574e-02f, -2.18488872e-02f, -4.09842581e-02f, 1.90049574e-01f, 1.14212327e-01f,
  3.20811197e-02f, -5.80325499e-02f, -7.05899857e-03f, -1.37127534e-01f, 3.50772627e-02f, 1.61645457e-01f, -3.75603512e-02f, -4.08322178e-02f, -7.10105225e-02f, 9.66329277e-02f,
  -6.51547834e-02f, -1.14641711e-01f, -6.99610934e-02f, -2.60256808e-02f, -1.82368588e-02f, 1.50127351e-01f, 1.04218341e-01f, 2.45828908e-02f, -1.44060448e-01f, 8.93670470e-02f,
  5.39171025e-02f, 2.23733112e-02f, -3.61713730e-02f, -2.41609681e-02f, 7.41661564e-02f, -1.30511103e-02f, -5.82172461e-02f, 6.81039765e-02f, 7.25624785e-02f, 7.85693079e-02f,
  -3.44569609e-02f, -5.65211549e-02f, -2.13292744e-02f, -3.24691795e-02f, 2.29086783e-02f, 1.46411052e-02f, 2.29068883e-02f, -2.03131232e-02f, 7.72892162e-02f, 1.48476273e-01f,
  -1.29196361e-01f, -1.74195379e-01f, 1.12329936e-02f, -2.80044004e-02f, 2.92178290e-03f, -7.35980049e-02f, 1.85877439e-02f, 2.84674135e-03f, 3.90021205e-02f, 3.13568152e-02f,
  -9.25146267e-02f, 9.46741831e-03f, -6.95450380e-02f, -9.47768912e-02f, -5.12955710e-02f, -4.69926521e-02f, 1.90593451e-02f, -5.40034547e-02f, -1.93450879e-02f, 3.46310362e-02f,
  8.54845345e-03f, -3.02377343e-01f, -9.68339667e-02f, -6.98895976e-02f, -3.13581973e-02f, -2.11252168e-01f, -1.30494535e-01f, -2.35729188e-01f, -2.31453165e-01f, -1.67203411e-01f,
  -7.19330668e-01f, -8.94172266e-02f, 5.42993695e-02f, -1.46197500e-02f, 5.60493730e-02f, -3.06504257e-02f, 6.99253008e-02f, -1.14361703e-01f, -7.37578720e-02f, -8.64941180e-02f,
  6.24631755e-02f, 1.17225237e-01f, 1.19624212e-01f, 2.49550596e-01f, 1.26173258e-01f, 1.69268757e-01f, 7.84937479e-03f, 6.41905740e-02f, 2.70866096e-01f, 1.76572070e-01f,
  8.11917111e-02f, 8.88592005e-02f, 6.63386018e-04f, 3.56894992e-02f, 8.36356878e-02f, 1.36463180e-01f, 2.90213246e-03f, 4.70338389e-02f, 1.98822141e-01f, 1.95809320e-01f,
  6.20206594e-01f, -3.06394905e-01f, 1.96788032e-02f, -1.84934080e-01f, -1.00639053e-01f, -2.20286712e-01f, 4.01853994e-02f, -2.50127405e-01f, -1.54237390e-01f, -8.89219046e-02f,
  2.62921099e-02f, -4.36856225e-02f, -2.09202748e-02f, 1.82207138e-03f, -7.46689215e-02f, -6.33451389e-03f, -1.18273310e-01f, -9.78043377e-02f, -3.10599394e-02f, -4.06679884e-02f,
  4.05629352e-02f, -1.40282407e-01f, -5.08091524e-02f, 2.44155098e-02f, -1.08448781e-01f, -4.20532860e-02f, -1.14316188e-01f, -1.15205660e-01f, -1.14723563e-01f, -1.58449963e-01f,
  1.71420842e-01f, 7.74237812e-02f, -8.79114419e-02f, 7.19795190e-03f, 1.56277213e-02f, -9.35960636e-02f, -5.16003976e-03f, 1.98075939e-02f, 7.89510459e-03f, -1.12826608e-01f,
  -6.49346858e-02f, 3.65207158e-02f, -3.21747921e-02f, -3.60038392e-02f, -5.94409704e-02f, -7.16363117e-02f, -8.68835747e-02f, 2.93167378e-03f, -1.39079899e-01f, -6.42481074e-02f,
  -7.23870546e-02f, -1.71219744e-02f, -1.29291296e-01f, -4.24851626e-02f, -1.11343622e-01f, 2.69543915e-03f, 2.76931878e-02f, -3.66634689e-02f, -6.82779402e-03f, -9.14415494e-02f,
  3.37720513e-01f, 5.76045625e-02f, 2.00154245e-01f, 6.11387156e-02f, -1.67153124e-02f, -1.49930194e-01f, 5.79837151e-02f, -5.52691519e-02f, 6.22746758e-02f, 6.72270870e-03f,
  8.83601680e-02f, 8.24959856e-03f, 4.03351560e-02f, 1.26873674e-02f, 7.09384158e-02f, 1.72221497e-01f, -9.67232510e-02f, 1.67045090e-02f, 4.81790937e-02f, 2.72512087e-03f,
  -3.36192548e-02f, 4.90716361e-02f, 2.12348342e-01f, 6.77405000e-02f, 6.03366159e-02f, 1.80622458e-01f, 1.85823858e-01f, -1.98538043e-02f, 1.04745939e-01f, -9.83094424e-03f,
  -5.29500544e-01f, -1.76179811e-01f, 2.42215656e-02f, 4.05021310e-02f, 3.81323136e-02f, -6.01541512e-02f, -2.42776573e-01f, -2.42328301e-01f, -7.94400796e-02f, -5.76766282e-02f,
  -2.17479184e-01f, 7.13483319e-02f, 2.10946426e-01f, 1.07938081e-01f, 1.01365454e-01f, 2.70595048e-02f, 2.26695523e-01f, 1.80208847e-01f, 4.62570749e-02f, -5.99948093e-02f,
  2.03363895e-01f, 1.56590343e-01f, 1.74501836e-01f, 3.84401120e-02f, 2.05855221e-02f, 2.27290511e-01f, 2.12526917e-01f, 7.73821399e-02f, 4.21111323e-02f, 1.89522266e-01f,
  -2.22577915e-01f, -2.97161490e-01f, 2.26098418e-01f, 1.07922480e-01f, 9.44688618e-02f, -1.35557368e-01f, -2.12617397e-01f, 8.62737074e-02f, -9.13510993e-02f, -7.80993626e-02f,
  1.17826918e-02f, -1.59227297e-01f, -5.33149689e-02f, 8.90968442e-02f, -1.17106199e-01f, -1.67101920e-01f, 1.47575900e-01f, -3.84015217e-02f, 3.58131155e-02f, -1.57305822e-01f,
  1.95343912e-01f, 1.35380238e-01f, -1.43062130e-01f, 3.84103581e-02f, -1.54933020e-01f, 2.22762361e-01f, -1.93979949e-01f, -2.11657390e-01f, -1.00443825e-01f, -1.83803931e-01f,
  1.31694740e-02f, -1.08696975e-01f, 2.05893964e-02f, -6.00954592e-02f, -1.46343768e-01f, -8.57405663e-02f, 5.93268313e-02f, 6.11060150e-02f, 6.14920072e-02f, -2.19801720e-02f,
  9.08025950e-02f, -7.96354190e-02f, 3.75365391e-02f, -6.11764640e-02f, 1.72948256e-01f, 9.05946568e-02f, -4.57385331e-02f, 4.41372097e-02f, 3.29196788e-02f, 3.75180133e-03f,
  -1.67579837e-02f, -1.44284610e-02f, 3.13036740e-02f, -5.70901930e-02f, -2.85369828e-02f, 3.26138958e-02f, 4.20417786e-02f, 1.74127501e-02f, 6.46685809e-02f, -4.52267937e-02f,
  1.73339266e-02f, 3.15730423e-01f, -2.33717546e-01f, -2.96705589e-02f, 6.56379610e-02f, -8.13228562e-02f, 5.02467863e-02f, -5.03687412e-02f, -5.89498207e-02f, -6.80231601e-02f,
  -7.92983025e-02f, -2.74129003e-01f, -7.31782168e-02f, -1.02627734e-02f, -4.43839394e-02f, 1.24813234e-02f, 1.25601470e-01f, 2.47121863e-02f, 8.10422301e-02f, -2.17611000e-01f,
  -1.43628167e-02f, -4.71703187e-02f, -1.99671432e-01f, -1.04859322e-01f, 8.70470330e-02f, -1.36789056e-02f, -1.80221811e-01f, -1.63387462e-01f, -9.18295085e-02f, -2.38810435e-01f,
  -2.56077468e-01f, 5.43671809e-02f, -2.09206283e-01f, 1.40608981e-01f, 1.42017484e-01f, 7.81547055e-02f, 1.31493673e-01f, 2.01811790e-02f, 1.38310060e-01f, 1.32234409e-01f,
  2.23423019e-01f, 5.02778925e-02f, 1.20640919e-01f, 1.27727538e-01f, 1.33382708e-01f, 1.78602844e-01f, 9.00642127e-02f, -1.08772129e-01f, -1.81953590e-02f, 3.71546894e-02f,
  2.16492295e-01f, 5.61117716e-02f, 6.77800849e-02f, 3.09529509e-02f, 1.94161367e-02f, -1.60285085e-02f, 7.30123669e-02f, 2.64225185e-01f, 2.55961895e-01f, 5.99756390e-02f,
  1.87407043e-02f, -5.85297775e-03f, -2.00187922e-01f, 5.24511561e-02f, -1.20209791e-01f, -1.22847766e-01f, -1.53044760e-01f, -4.28107008e-02f, 9.90195479e-03f, -1.43991485e-01f,
  5.84172606e-02f, 8.58252794e-02f, 3.93160172e-02f, 7.88219720e-02f, -1.78327281e-02f, -9.87616777e-02f, 3.87257785e-02f, 1.26371503e-01f, 1.96731716e-01f, -7.42196850e-03f,
  9.09251049e-02f, 1.93092644e-01f, 1.68670341e-01f, 4.72533479e-02f, -7.83117372e-04f, 6.71439338e-03f, 7.55410641e-02f, 6.53573894e-04f, -4.34910618e-02f, -9.42074135e-03f,
  1.17054552e-01f, -7.65958205e-02f, 6.46946952e-02f, 5.92063405e-02f, -2.99548507e-02f, -1.17862284e-01f, 7.21220532e-03f, 7.08701983e-02f, 2.68022269e-02f, -5.70459291e-02f,
  1.01059861e-01f, 7.36597553e-02f, 6.20195568e-02f, -5.14575727e-02f, 1.45984266e-03f, 6.39536306e-02f, 4.38638255e-02f, -9.80268116e-04f, 1.80336624e-01f, 1.59724355e-01f,
  1.16375312e-01f, 2.18537059e-02f, 1.64596923e-02f, 1.39915003e-02f, 1.70172393e-01f, 6.96935356e-02f, 1.32665187e-01f, 7.37318844e-02f, 9.94745567e-02f, -9.30875260e-03f,
  2.52987742e-01f, 2.51440346e-01f, -1.14164926e-01f, 1.79080859e-01f, -8.37149769e-02f, -5.31687438e-02f, -2.50883605e-02f, 6.88970927e-03f, 1.08474623e-02f, -9.22973379e-02f,
  -7.84258321e-02f, -2.19490454e-01f, 5.25818802e-02f, 2.06030719e-02f, -2.22765982e-01f, 4.92885755e-03f, 1.40902400e-01f, 1.64598837e-01f, 1.31532386e-01f, -6.09714203e-02f,
  -1.08097689e-02f, 2.68868413e-02f, 9.51431468e-02f, -2.76277959e-02f, 1.02896420e-02f, -2.21217284e-03f, -1.42781094e-01f, -3.79468277e-02f, -9.41324886e-03f, -1.04194209e-01f,
  3.14906776e-01f, -5.84604666e-02f, 5.07214144e-02f, 1.03960469e-01f, 4.45220852e-03f, 1.43785328e-01f, -2.62046717e-02f, -2.40129475e-02f, 1.01269163e-01f, 6.85480312e-02f,
  -3.14776576e-03f, 1.65127173e-01f, 9.19924527e-02f, 1.46941796e-01f, 1.77586615e-01f, -2.19266694e-02f, -2.27678865e-02f, 5.04162721e-02f, 4.83741947e-02f, 5.14861792e-02f,
  -1.66148409e-01f, -2.15024307e-01f, -9.00335889e-03f, -9.08272266e-02f, -9.20972899e-02f, 3.76232602e-02f, -8.69331211e-02f, -1.09336294e-01f, -2.95954701e-02f, -8.50875303e-02f,
  2.60921597e-01f, 1.47079825e-01f, 1.51042059e-01f, 9.84665155e-02f, -7.25982785e-02f, 2.95330621e-02f, 2.04493925e-02f, -5.16659357e-02f, 1.79463122e-02f, 8.53855386e-02f,
  3.26894708e-02f, 5.91221382e-04f, -2.38433518e-02f, -9.43732560e-02f, -2.71914471e-02f, 2.32003722e-02f, -3.41764949e-02f, 1.90941221e-03f, 6.25547394e-02f, -5.66394106e-02f,
  -5.88678708e-03f, 1.31812826e-01f, 1.38094068e-01f, 1.60766710e-02f, 5.18146381e-02f, 1.30476698e-01f, 2.39960421e-02f, 6.06972016e-02f, 6.04641810e-02f, -8.94040540e-02f,
  3.77848484e-02f, -2.96979789e-02f, 5.38846403e-02f, 6.47859089e-03f, -1.01616003e-01f, 7.31614679e-02f, 2.42449231e-02f, -1.12854093e-01f, -4.23798151e-02f, -9.18254778e-02f,
  -1.01202555e-01f, 5.60666285e-02f, 1.05738863e-01f, -1.64380949e-02f, -2.57170908e-02f, -5.33208400e-02f, 3.17372531e-02f, 8.51142257e-02f, -1.35321608e-02f, -3.30119953e-02f,
  -6.30439818e-02f, -1.14649879e-02f, -5.26300557e-02f, -6.04467355e-02f, 7.07401335e-02f, 2.75071673e-02f, 3.68968770e-02f, -1.43379897e-01f, -1.13722041e-01f, -1.62957579e-01f,
  2.17728436e-01f, 2.01388046e-01f, 1.07984327e-01f, 7.12434724e-02f, -3.32340188e-02f, 1.37352012e-02f, 4.02075537e-02f, 4.58562607e-03f, 3.01886909e-02f, 8.26700067e-04f,
  2.12668516e-02f, 4.67669731e-03f, -8.18523765e-03f, 3.18117975e-03f, 6.03778008e-03f, 9.88042057e-02f, 3.39083672e-02f, 2.38829762e-01f, 9.63021815e-02f, 1.26265496e-01f,
  -7.94509277e-02f, 1.94731653e-01f, 2.31823400e-01f, 1.91644937e-01f, -6.09201156e-02f, 1.91331267e-01f, 8.13835231e-06f, -2.03612354e-02f, 1.07747175e-01f, -5.28594628e-02f,
  4.01268564e-02f, -2.67741829e-01f, 3.27922195e-01f, 7.50117144e-03f, -1.32041082e-01f, -1.24016397e-01f, -8.75820518e-02f, -5.10094948e-02f, -1.73102673e-02f, -3.83096822e-02f,
  3.87298092e-02f, 7.80953541e-02f, 1.31549701e-01f, 1.62957102e-01f, 1.62654012e-01f, 9.52327549e-02f, 6.78404570e-02f, 1.92389369e-01f, 3.79654258e-01f, 1.28665015e-01f,
  -2.26130318e-02f, -3.78477834e-02f, 1.16895698e-02f, 4.64629233e-02f, -1.19214177e-01f, 1.34412155e-01f, -2.04754248e-02f, -1.49293706e-01f, -4.26626466e-02f, 8.26032236e-02f,
  4.10169661e-01f, 7.55989701e-02f, 1.60913095e-01f, 4.50987555e-02f, 5.79496175e-02f, 8.23843013e-03f, 8.18908494e-03f, -1.04967639e-01f, -1.29733190e-01f, 8.78595635e-02f,
  -4.17808667e-02f, -2.34737694e-02f, 2.67099142e-02f, 3.23983841e-02f, 5.75887691e-03f, -3.90216969e-02f, -3.58807780e-02f, -3.15050110e-02f, 8.85141864e-02f, -8.32998082e-02f,
  -1.41452894e-01f, -8.96948576e-02f, 3.14245261e-02f, 6.40347898e-02f, 9.35474113e-02f, -2.51338948e-02f, 1.32224197e-02f, 5.85018359e-02f, 9.78118181e-02f, 8.27951450e-03f,
  4.15334292e-02f, 6.06560409e-02f, 1.50410205e-01f, 2.32814439e-02f, -1.47396354e-02f, -7.87526816e-02f, 3.95894125e-02f, 7.66466632e-02f, 1.12042138e-02f, 7.92903230e-02f,
  -2.71138866e-02f, 1.30178884e-01f, -1.02491893e-01f, -3.71057950e-02f, 4.80135009e-02f, 2.66301576e-02f, 1.26561210e-01f, 1.36274084e-01f, -3.43851782e-02f, 5.05823493e-02f,
  -6.21054247e-02f, 6.06723577e-02f, 1.27958786e-02f, 5.01890220e-02f, 3.94460671e-02f, 9.63939279e-02f, -9.57804732e-03f, 7.49812797e-02f, 1.19621933e-01f, -1.40521796e-02f,
  -2.35771775e-01f, 1.58405807e-02f, 1.41337320e-01f, -9.28643439e-03f, -4.52473387e-02f, -1.36320591e-01f, 7.83104263e-03f, -5.74906133e-02f, -2.18994930e-01f, -3.32585312e-02f,
  -3.76136340e-02f, 6.67772070e-02f, -6.99435696e-02f, -1.15586969e-03f, 2.33135168e-02f, -1.21545836e-01f, 2.55677495e-02f, 1.49711221e-02f, -1.32346138e-01f, -2.10431188e-01f,
  -1.57165512e-01f, 3.50197665e-02f, 1.49057060e-01f, 2.15140590e-03f, 2.00826265e-02f, -3.81399207e-02f, 4.26261574e-02f, -1.12514384e-02f, 5.38502932e-02f, -5.40974662e-02f,
  8.92267004e-02f, -3.26414049e-01f, -2.55984545e-01f, -4.51036505e-02f, -1.58546641e-01f, 6.28138427e-04f, -3.73812586e-01f, 1.04210235e-01f, -3.52839968e-04f, -4.17897403e-01f,
  -1.25865832e-01f, 1.25490502e-01f, 1.41171053e-01f, 1.30180404e-01f, 4.04109955e-02f, -3.05054069e-01f, -2.05820590e-01f, -3.97166610e-02f, 2.66736150e-01f, 1.08789101e-01f,
  -6.01471290e-02f, -4.21374716e-04f, 1.41564801e-01f, 9.63325799e-02f, -1.64639488e-01f, 9.36633795e-02f, -2.30288699e-01f, -3.21859419e-02f, -1.36087865e-01f, -4.24016178e-01f,
  -1.56859353e-01f, 1.00457780e-01f, 1.22486120e-02f, 8.39707404e-02f, 3.95255396e-03f, 2.89299935e-02f, -8.56631622e-02f, -1.84727907e-02f, 9.91487950e-02f, -5.99770620e-02f,
  1.24408782e-01f, 1.29778787e-01f, 2.25889146e-01f, 1.05659157e-01f, -5.44271953e-02f, -8.62586796e-02f, -7.95761868e-02f, -1.28610320e-02f, -7.08788410e-02f, -2.78285295e-01f,
  -6.25298023e-02f, -8.35604817e-02f, 1.04541533e-01f, -2.05392465e-02f, 3.64129059e-02f, 1.59477562e-01f, -8.39505196e-02f, 1.12847470e-01f, 1.37379721e-01f, -3.22498441e-01f,
  -1.43349618e-01f, 1.57976768e-03f, -6.79927766e-02f, 3.88405882e-02f, 1.25305820e-02f, -9.72900093e-02f, 6.54994026e-02f, -7.77376294e-02f, 1.46548655e-02f, -3.61943655e-02f,
  1.00005381e-01f, -5.92978932e-02f, 6.08665459e-02f, -6.30053654e-02f, 4.44479585e-02f, 6.29030913e-02f, -6.57627657e-02f, -4.32792166e-03f, -6.32862002e-02f, 3.56169380e-02f,
  1.14512280e-01f, 4.84281182e-02f, 6.09328747e-02f, 4.15291227e-02f, -4.38771844e-02f, -9.95919295e-03f, 6.39191568e-02f, 9.39302966e-02f, 3.71136516e-02f, 2.80937292e-02f,
  -7.15689221e-03f, 1.10487334e-01f, -1.53366253e-01f, 7.15309009e-02f, -4.82826903e-02f, -1.01808302e-01f, -4.65376787e-02f, -5.57151996e-03f, 3.03353928e-02f, -4.90844138e-02f,
  1.62618086e-01f, -7.20246807e-02f, 4.88935560e-02f, -1.35127440e-01f, -7.24979043e-02f, -1.16140291e-01f, -4.31768931e-02f, -1.89305271e-03f, 8.51298943e-02f, -3.97278508e-03f,
  -2.35114515e-01f, -6.85069039e-02f, -5.47399819e-02f, 9.34335291e-02f, 8.31894055e-02f, 2.07357198e-01f, -2.39110980e-02f, -4.51371558e-02f, -3.07750888e-02f, -2.65727192e-01f,
  -1.08240552e-01f, 9.36283395e-02f, 1.91287454e-02f, 9.49532241e-02f, 2.29470536e-01f, -1.46000102e-01f, -1.21508233e-01f, -2.21170381e-01f, -1.36330023e-01f, 1.40734956e-01f,
  2.93303490e-01f, -8.58598650e-02f, 1.15136523e-03f, -3.18679921e-02f, -2.03074008e-01f, 9.47747752e-02f, 8.45851898e-02f, -1.11326933e-01f, -3.54259580e-01f, -2.71842927e-01f,
  7.73562789e-02f, -8.14719722e-02f, -2.68786430e-01f, -9.43616703e-02f, 1.12449460e-01f, -4.10631746e-02f, 2.31253594e-01f, 6.43754900e-02f, 9.15340185e-02f, 3.44863981e-01f,
  1.61448762e-01f, -9.02638882e-02f, 6.04216978e-02f, 1.39408141e-01f, 1.20294370e-01f, -1.43838510e-01f, -1.35542035e-01f, 2.84585059e-02f, 4.98927198e-03f, -3.43868434e-02f,
  6.84309900e-02f, 1.40410319e-01f, 1.38528813e-02f, -2.38974273e-01f, -6.23586401e-02f, -2.72051692e-01f, -2.63087779e-01f, -1.78390041e-01f, -3.01844299e-01f, -5.79393096e-02f,
  1.46569997e-01f, 9.75236148e-02f, -6.46248180e-03f, -1.11256525e-01f, -3.16676795e-01f, -9.01156738e-02f, -1.71139807e-01f, -1.89444304e-01f, -2.26024359e-01f, -7.40666762e-02f,
  -7.13690147e-02f, -2.79217158e-02f, 2.95291077e-02f, 1.24288134e-01f, 4.62801643e-02f, 6.59056380e-02f, 4.50348221e-02f, 8.10462907e-02f, 5.04743904e-02f, -8.45273510e-02f,
  -3.28736976e-02f, -4.34738994e-02f, -7.63706192e-02f, 1.65818688e-02f, 1.36304915e-01f, -4.64308832e-04f, -6.94387183e-02f, -9.94902849e-03f, 4.30112481e-02f, 1.96858998e-02f,
  -6.18513599e-02f, -6.40595555e-02f, 4.94858064e-02f, -7.45602744e-03f, 5.54939732e-02f, 9.81886014e-02f, -8.09736103e-02f, -9.30807367e-02f, -1.69441372e-01f, -8.45410004e-02f,
  -2.91031711e-02f, -2.16037929e-02f, 1.10508084e-01f, -5.58450632e-02f, 7.49344751e-02f, -2.84124650e-02f, 2.35328395e-02f, -3.67805921e-02f, 1.49319619e-01f, -1.87239274e-01f,
  -1.64562136e-01f, -1.28795519e-01f, 1.47174805e-01f, -1.15129441e-01f, -1.22219220e-01f, -5.25080338e-02f, -4.85400036e-02f, -9.30156335e-02f, -1.75949693e-01f, -1.07998304e-01f,
  -4.91891392e-02f, -1.22649930e-01f, -5.72157092e-03f, -1.10794142e-01f, 6.42726570e-02f, -8.24918747e-02f, -1.05467349e-01f, -9.85892117e-02f, -1.81549713e-01f, -9.97438580e-02f,
  2.30733663e-01f, 2.54379034e-01f, -9.53939464e-03f, 5.83218783e-02f, -9.09185559e-02f, -2.96447203e-02f, 2.18369029e-02f, 8.50794017e-02f, 1.30358726e-01f, 1.27633467e-01f,
  -2.71235406e-01f, -1.78371608e-01f, 2.68322751e-02f, -8.46214294e-02f, 1.82398722e-01f, 1.78738385e-01f, 1.99447870e-01f, 3.07252761e-02f, -1.47205740e-01f, -1.36543751e-01f,
  -7.09866509e-02f, 9.84306857e-02f, -8.17909557e-03f, 6.54845610e-02f, 1.40456170e-01f, -6.52968138e-02f, -5.95509447e-02f, -1.36865363e-01f, -1.28003387e-02f, 2.82444298e-01f,
  -1.04887456e-01f, -3.57267968e-02f, -8.00513923e-02f, -3.67749184e-02f, -6.37852475e-02f, 1.36903198e-02f, -1.68581791e-02f, 1.08557247e-01f, 3.61001231e-02f, -3.12364977e-02f,
  1.92934126e-01f, 6.90619498e-02f, -9.10854869e-05f, 2.96079498e-02f, -1.80934556e-02f, 3.30203772e-02f, 5.36442362e-02f, 2.12630749e-01f, -8.24124261e-04f, 2.18533389e-02f,
  2.19007488e-02f, -1.32678866e-01f, -9.00284201e-02f, -7.48275444e-02f, -1.58098002e-03f, -1.87479123e-01f, -1.48244783e-01f, 1.56944897e-02f, -1.31359890e-01f, 1.29185751e-01f,
  -1.96021035e-01f, -5.58717102e-02f, 2.22256761e-02f, 1.14177156e-03f, -1.28461748e-01f, -6.59189746e-02f, 6.65049907e-03f, -2.00933479e-02f, -5.02995625e-02f, 1.00084893e-01f,
  -8.77785683e-02f, -5.53577319e-02f, -6.87575862e-02f, -3.86521369e-02f, 2.24948768e-02f, 2.71042641e-02f, -6.54525682e-02f, -4.60197730e-03f, -8.67650807e-02f, -1.08537011e-01f,
  -6.16651811e-02f, 1.84067264e-02f, 7.56173162e-03f, 1.18762366e-02f, -6.49081618e-02f, -7.38349259e-02f, 7.13694561e-03f, -8.99936631e-02f, -1.43966213e-01f, -5.30505590e-02f,
  1.16097024e-02f, -2.48878494e-01f, -4.52420898e-02f, 1.52052820e-01f, -2.79957242e-02f, -7.01170182e-03f, -1.91041175e-02f, -1.41172290e-01f, -5.13337031e-02f, -6.73449263e-02f,
  8.85388553e-02f, -5.16783558e-02f, 2.66085044e-02f, -7.88590685e-03f, -9.82054994e-02f, -5.59558161e-02f, 5.82579933e-02f, 4.01108526e-03f, -1.26055941e-01f, -6.78238124e-02f,
  9.62417647e-02f, -1.22684024e-01f, -1.05245881e-01f, -1.97049230e-02f, 1.63554680e-02f, -1.72109589e-01f, -1.11895591e-01f, -8.01752955e-02f, -1.17743857e-01f, 4.18049991e-02f,
  2.54358556e-02f, -2.92132050e-01f, 1.58966213e-01f, 1.09684439e-02f, 5.25816716e-02f, 1.34691373e-01f, 4.36890032e-03f, -5.01193590e-02f, 1.02292210e-01f, 4.43815626e-02f,
  1.29977345e-01f, 1.42597899e-01f, 1.36169061e-01f, 1.29220098e-01f, 3.79460640e-02f, 6.25019073e-02f, -3.41571681e-02f, 1.35141879e-01f, 2.51055360e-01f, 9.48609635e-02f,
  -5.23084030e-03f, -7.95043707e-02f, -1.32509738e-01f, -9.82295908e-03f, -1.04483061e-01f, -2.75780130e-02f, -1.34654418e-01f, -1.31641299e-01f, 1.26299243e-02f, -1.33433938e-01f,
  2.80127376e-01f, -2.45234370e-01f, 1.27202526e-01f, -2.16300581e-02f, -2.23191917e-01f, -5.49045168e-02f, 1.09178834e-02f, -1.75652474e-01f, -2.72813849e-02f, 5.77648431e-02f,
  -2.00181082e-03f, -4.18914706e-02f, -1.36437669e-01f, -6.31153956e-02f, -8.67874846e-02f, -6.19966574e-02f, -7.77752921e-02f, -1.17438875e-01f, 3.41367684e-02f, 9.65402126e-02f,
  -5.45900688e-02f, 1.35362089e-01f, 2.21121401e-01f, 1.22711040e-01f, 1.65368877e-02f, 9.62606221e-02f, 1.47208944e-03f, 1.95144769e-02f, 6.25510588e-02f, -9.39802602e-02f,
  1.57117285e-02f, 6.51101694e-02f, 7.32462332e-02f, -4.88499887e-02f, 5.43035045e-02f, 1.36767536e-01f, 6.96393922e-02f, 2.39559100e-03f, 5.75843379e-02f, -1.09768219e-01f,
  9.16371308e-03f, 7.69296214e-02f, 6.94152564e-02f, 9.05818120e-03f, -4.34078872e-02f, 2.18455251e-02f, -6.13046065e-02f, 1.19420355e-02f, 2.85511967e-02f, -2.34495066e-02f,
  5.93003444e-02f, -3.69263371e-03f, -8.18786584e-03f, -8.76487121e-02f, 5.07693589e-02f, -4.59060026e-03f, 6.78481162e-03f, -2.46908795e-02f, -5.31169325e-02f, -2.43835561e-02f,
  2.02881694e-01f, 6.42312765e-02f, 5.43223470e-02f, -6.08042702e-02f, -1.42458200e-01f, -9.25550535e-02f, 2.82593234e-03f, 1.98668037e-02f, -1.35068465e-02f, 1.28233597e-01f,
  1.66680023e-01f, -8.93562473e-03f, -1.43029779e-01f, -8.84808674e-02f, -2.63796337e-02f, 1.00828715e-01f, -6.50046021e-02f, 4.33630636e-03f, 1.20623335e-01f, 1.03068314e-01f,
  -2.24242266e-02f, 1.54741690e-01f, 1.46385640e-01f, 1.94566503e-01f, 3.05736549e-02f, 5.74243106e-02f, -2.71002855e-02f, -3.48700546e-02f, 1.30428270e-01f, -9.47713479e-02f,
  3.19280237e-01f, 6.06357604e-02f, -2.79252622e-02f, 1.33937240e-01f, 1.68068156e-01f, -1.37022063e-01f, -2.11798653e-01f, -1.61890790e-01f, -6.99699968e-02f, 2.23124288e-02f,
  1.15302116e-01f, 5.89401424e-02f, -2.15161704e-02f, -8.92855898e-02f, -9.38921720e-02f, -1.21952780e-01f, -1.90502536e-02f, 4.10276689e-02f, -2.01519176e-01f, -2.23856062e-01f,
  -1.60978809e-02f, 4.15847860e-02f, 1.06607126e-02f, -8.93129185e-02f, 1.83674514e-01f, 6.36063740e-02f, -8.68029147e-03f, 3.03275913e-01f, 1.43210217e-01f, 3.35163772e-01f,
  2.11706489e-01f, 2.40708977e-01f, -1.71926424e-01f, 1.64570048e-01f, 1.64009526e-01f, 2.17720643e-02f, 4.75636609e-02f, 4.90163602e-02f, 4.55317646e-02f, -7.41257519e-02f,
  2.61878252e-01f, 1.59792662e-01f, -9.17036459e-02f, 4.67115156e-02f, 8.15129466e-03f, -3.81121598e-02f, -7.53880292e-02f, -3.83942835e-02f, -1.40386641e-01f, -8.42022151e-02f,
  1.61787823e-01f, 2.13607505e-01f, 6.78887125e-03f, -1.27883226e-01f, -1.31734803e-01f, 1.58222482e-01f, -4.75561768e-02f, 1.03132896e-01f, -1.72328800e-01f, 1.25110716e-01f,
  -4.74843867e-02f, 4.89092944e-03f, 9.92535725e-02f, 1.52573109e-01f, 7.06802607e-02f, -6.35110736e-02f, 5.20804338e-02f, 1.35561582e-02f, -3.50150354e-02f, 7.37313507e-03f,
  1.18634002e-02f, -3.38099487e-02f, 1.60434656e-02f, 6.23683631e-02f, -2.83888113e-02f, 1.19589612e-01f, 4.36692052e-02f, 5.14312908e-02f, -1.01065151e-01f, 1.17496051e-01f,
  -5.48255667e-02f, -2.89169028e-02f, 1.10320270e-01f, -4.25220616e-02f, -1.15911020e-02f, 5.34629524e-02f, 1.34967685e-01f, 9.23587307e-02f, -1.30925430e-02f, 6.35597557e-02f,
  -1.44370839e-01f, -1.93573192e-01f, 1.04430728e-01f, -1.76594040e-04f, -3.05020958e-02f, -2.25533340e-02f, -1.45136574e-02f, -9.32893232e-02f, 1.28843278e-01f, -1.18098766e-01f,
  -1.98703948e-02f, 6.74318969e-02f, 2.83953901e-02f, -1.29603550e-01f, -9.56119746e-02f, -5.72611801e-02f, 1.43959885e-02f, -9.75240245e-02f, -9.94386002e-02f, -1.80525947e-02f,
  -1.52500346e-01f, -2.58367002e-01f, -2.27353156e-01f, -2.79540300e-01f, 2.89036464e-02f, 3.10343280e-02f, -6.59687221e-02f, -3.00843399e-02f, -1.85804442e-01f, -2.21722171e-01f,
  4.57805127e-01f, -2.38546699e-01f, 2.51137435e-01f, 1.63844422e-01f, 3.06322157e-01f, 4.02480960e-01f, 2.45511368e-01f, 1.62769392e-01f, 2.97250390e-01f, 6.81773499e-02f,
  -1.88472569e-02f, 6.02776036e-02f, 1.17154904e-01f, 5.69826690e-03f, -5.61722182e-02f, 8.06559622e-02f, 1.83970138e-01f, 1.25991881e-01f, 1.61524683e-01f, 2.33221054e-01f,
  1.65126622e-01f, 5.44610471e-02f, -1.42648578e-01f, 3.26623023e-02f, 9.77492146e-03f, -1.98673015e-03f, -1.71677060e-02f, -1.81812152e-01f, -2.93104835e-02f, -1.97835729e-01f,
  -3.21265072e-01f, -1.45585686e-01f, -2.05662120e-02f, -1.37537494e-01f, -1.74913526e-01f, -8.01137611e-02f, 1.29868910e-01f, -1.36920005e-01f, -1.00573577e-01f, -8.29575509e-02f,
  -1.28062651e-01f, -2.09078968e-01f, -3.96104380e-02f, 4.13526129e-03f, 2.16376502e-02f, -1.04669251e-01f, 3.24640721e-02f, -3.97373829e-03f, 4.37574275e-02f, -1.06713608e-01f,
  1.30334226e-02f, 1.20680206e-01f, 5.54511286e-02f, 1.38032004e-01f, 3.40624712e-02f, 1.06685534e-01f, -8.57429951e-02f, 5.67302145e-02f, 1.25841901e-01f, 1.18437082e-01f,
  4.13456149e-02f, 8.25469196e-02f, -1.30589521e-02f, -1.80290416e-02f, -7.13991821e-02f, 9.06568989e-02f, -5.61328961e-05f, -2.53238734e-02f, 1.09392904e-01f, -1.25173880e-02f,
  -7.72545412e-02f, 4.49207760e-02f, 1.04110748e-01f, 1.09194741e-01f, 9.86202434e-02f, 3.41350920e-02f, 5.73525168e-02f, -5.72901629e-02f, -1.88027829e-01f, -1.36211902e-01f,
  -6.25236109e-02f, 1.34215243e-02f, -1.17685860e-02f, -6.93235621e-02f, 2.40501910e-02f, 4.90276851e-02f, 1.14955120e-01f, -1.03824645e-01f, -6.06828257e-02f, -2.77253855e-02f,
  -2.05270141e-01f, -7.64243864e-03f, 6.81524491e-03f, -1.81350082e-01f, -6.29723119e-03f, -1.04161747e-01f, -1.47973113e-02f, -5.06467535e-04f, -1.38519347e-01f, 4.22465764e-02f,
  2.72151772e-02f, -9.22054648e-02f, -1.49837136e-01f, 3.37554030e-02f, 4.21511121e-02f, -4.35952321e-02f, -7.57484958e-02f, 3.30532826e-02f, -2.53850594e-02f, -1.44606335e-02f,
  8.12645629e-02f, 2.23213911e-01f, 1.12401076e-01f, 1.93205610e-01f, 4.00169678e-02f, 7.46780708e-02f, -1.60214938e-02f, -1.03527829e-02f, 9.10586193e-02f, 2.45706812e-01f,
  -5.50689884e-02f, 3.03152174e-01f, 1.79227829e-01f, -2.53192604e-01f, 2.21935827e-02f, 2.69613862e-01f, 4.71035570e-01f, 1.18727431e-01f, -7.08392486e-02f, 1.31474510e-01f,
  1.39370441e-01f, -1.20444015e-01f, -1.40209854e-01f, 5.60902543e-02f, 4.90525663e-02f, 2.06650212e-01f, 1.88464811e-03f, -1.07288949e-01f, -3.77801433e-02f, -2.14921720e-02f,
  -1.09353065e-01f, -1.59261599e-01f, -1.09357677e-01f, -2.65254974e-01f, -2.48353958e-01f, -3.04752141e-01f, -1.20958500e-02f, -2.83094728e-03f, 2.10362859e-02f, -2.12957785e-01f,
  -5.07138595e-02f, 2.17060864e-01f, -1.72628239e-01f, -1.25917820e-02f, 2.38356311e-02f, -5.06857634e-02f, -9.90013871e-03f, -8.27904791e-02f, 3.41608673e-02f, -2.43506916e-02f,
  1.14052380e-02f, 3.59166116e-02f, 9.13881883e-02f, -2.11168565e-02f, 2.11577415e-02f, 9.00441781e-02f, 4.43528965e-02f, 4.72359806e-02f, -3.72932628e-02f, 6.03986681e-02f,
  -5.76576218e-02f, 8.88018385e-02f, 1.23792335e-01f, 1.29045891e-02f, 5.01692714e-03f, 8.41114856e-03f, 1.54566571e-01f, -6.25306368e-02f, 1.03403188e-01f, -7.10640475e-02f,
  -2.00543515e-02f, 7.11598545e-02f, 1.06221184e-01f, 2.08709054e-02f, -9.97645780e-03f, -1.04761655e-02f, -1.96692869e-02f, -5.01169749e-02f, -3.45495231e-02f, 2.62988787e-02f,
  -1.39788184e-02f, -1.31599121e-02f, -8.10969844e-02f, -4.30761538e-02f, -1.60613626e-01f, -5.62052149e-03f, -5.55580761e-03f, -8.35848674e-02f, 7.66285360e-02f, 4.09294330e-02f,
  -2.89087985e-02f, 6.17429428e-03f, -3.35432328e-02f, -6.60256743e-02f, 3.03559601e-02f, -5.21642296e-03f, -1.23047113e-01f, 8.17763284e-02f, 8.99847373e-02f, 7.55878761e-02f,
  -2.24915951e-01f, 1.26404092e-01f, -2.85026073e-01f, -9.66811255e-02f, -1.04423128e-02f, -4.13252832e-03f, -1.69706225e-01f, 1.28512019e-02f, -6.42719567e-02f, -1.02576427e-01f,
  2.16101203e-02f, -9.53681543e-02f, -4.39595021e-02f, -9.07780156e-02f, -1.18112266e-02f, -5.20880148e-02f, 3.81455682e-02f, -9.85364690e-02f, 1.02525624e-02f, -9.30325612e-02f,
  -1.25346661e-01f, -1.35523975e-01f, -1.41200036e-01f, -9.64329541e-02f, -2.57695735e-01f, -1.70115799e-01f, 2.35318635e-02f, -1.03166670e-01f, 3.40008922e-02f, -4.74167094e-02f,
  4.19331700e-01f, -2.73525655e-01f, 1.32947966e-01f, 1.10261207e-02f, -2.21472364e-02f, -2.70931441e-02f, -1.31695569e-01f, -3.28695998e-02f, 1.34274706e-01f, 5.16979843e-02f,
  1.31547540e-01f, 3.26024801e-01f, 3.17273080e-01f, 1.91667020e-01f, 1.11453839e-01f, -1.30151868e-01f, -1.33086992e-02f, 1.67920500e-01f, 3.48721206e-01f, 2.11475044e-01f,
  -1.54983595e-01f, -2.56329942e-02f, 1.22089595e-01f, -8.53396505e-02f, -9.55482274e-02f, 1.24505706e-01f, -6.86690286e-02f, -1.41850665e-01f, -1.91269387e-02f, -2.67491132e-01f,
  -1.08372082e-03f, 1.12636609e-03f, 1.52391657e-01f, 8.85151550e-02f, -7.47850984e-02f, -1.33399054e-01f, -1.69157684e-01f, -1.53450772e-01f, -1.57405019e-01f, -1.14446208e-01f,
  -3.97186540e-02f, -6.14430383e-02f, -6.97669014e-02f, -8.36798623e-02f, -1.36887610e-01f, 6.29508868e-02f, 1.10911196e-02f, 1.71438139e-02f, -1.12000763e-01f, -7.80788511e-02f,
  4.94937003e-02f, 1.06779300e-02f, 1.57034591e-01f, -3.17084491e-02f, -8.54776949e-02f, 4.61561754e-02f, -1.33389622e-01f, 2.31457632e-02f, 8.99285153e-02f, -1.98453784e-01f,
  -6.26179874e-02f, -7.53961578e-02f, 5.05553670e-02f, -9.73522365e-02f, -2.31318418e-02f, 1.36672165e-02f, 8.94217342e-02f, -2.78871413e-03f, 8.11038166e-02f, 4.56195436e-02f,
  1.14258662e-01f, 1.12784982e-01f, -1.28780876e-03f, -3.85402925e-02f, 5.21833710e-02f, -2.51930319e-02f, -3.53171267e-02f, -1.28946900e-01f, 5.93627729e-02f, 5.02031371e-02f,
  9.32920948e-02f, 1.53517369e-02f, 1.74630317e-03f, -2.42930334e-02f, 3.78316976e-02f, 3.25829536e-02f, 4.09342870e-02f, 3.45151089e-02f, -7.53829926e-02f, 3.98691110e-02f,
  -3.61348718e-01f, 1.63350180e-01f, 5.09442575e-02f, 1.48428589e-01f, -8.65854695e-02f, -1.41426444e-01f, -5.67475408e-02f, -9.49363336e-02f, -2.21864745e-01f, -7.80418292e-02f,
  1.13262765e-01f, 1.03655137e-01f, 3.39236227e-03f, -1.16922423e-01f, 1.10026643e-01f, 9.03683901e-02f, -1.49941975e-02f, 4.41670828e-02f, -1.12398721e-01f, -1.03839479e-01f,
  -1.38842732e-01f, 1.02868475e-01f, 7.73964897e-02f, 1.04795992e-01f, -4.83829528e-02f, 4.47190888e-02f, -4.02754582e-02f, -1.24669084e-02f, 1.39670921e-02f, -1.74578741e-01f,
  -1.06337547e-01f, 2.90513989e-02f, 1.55765237e-02f, 5.40081523e-02f, 1.34867787e-01f, -2.02980191e-01f, -2.74113297e-01f, -1.29669651e-01f, 3.92985344e-02f, -1.24505321e-02f,
  1.11848265e-01f, 2.01857969e-01f, 1.47391051e-01f, 2.73724627e-02f, -2.72978753e-01f, -1.60002381e-01f, -3.21171552e-01f, -1.65535346e-01f, -7.80084729e-02f, 2.49033235e-02f,
  2.06973255e-01f, 6.92081302e-02f, -2.65457276e-02f, 6.53380230e-02f, 9.76208895e-02f, 1.38004959e-01f, 1.39328361e-01f, 5.29069267e-02f, 3.50035317e-02f, -6.65841475e-02f,
  9.63664502e-02f, -1.56497970e-01f, -7.34901056e-02f, 3.97077994e-03f, -8.21722895e-02f, -7.02855960e-02f, -1.58067748e-01f, -2.82411873e-01f, -2.68038720e-01f, -9.23696905e-02f,
  -7.21590891e-02f, -7.03488067e-02f, -1.16268262e-01f, 9.61511284e-02f, 1.04867527e-02f, -1.36930952e-02f, -1.31777167e-01f, -1.85857400e-01f, -1.06425151e-01f, -1.11976579e-01f,
  4.30964194e-02f, -4.13177833e-02f, -1.23774111e-01f, -3.30988853e-03f, -2.57521182e-01f, -2.76153628e-02f, -1.08212642e-01f, -2.14876354e-01f, -1.23013370e-01f, -5.64572811e-02f,
  -1.06968068e-01f, -3.28615919e-04f, 1.63532961e-02f, -3.00236177e-02f, 2.07340103e-02f, 1.09686656e-03f, 4.34292899e-03f, 1.69560071e-02f, 1.10328775e-02f, 4.19765040e-02f,
  -1.18431002e-02f, -3.53109799e-02f, 4.65814732e-02f, -1.17692731e-01f, -6.00974914e-03f, -7.37640336e-02f, -1.01243719e-01f, -1.74053475e-01f, -3.35159600e-02f, -5.87735437e-02f,
  -1.15517974e-01f, 3.66043835e-03f, 1.33894473e-01f, -2.03677356e-01f, -3.85823026e-02f, -1.85092106e-01f, -3.29313464e-02f, -4.09756452e-02f, -4.93164174e-02f, -9.15090591e-02f,
  2.01114461e-01f, -2.79383622e-02f, 7.67712072e-02f, -5.42314490e-03f, -5.11224046e-02f, 4.48107757e-02f, -6.15359955e-02f, -1.45571098e-01f, -1.88047793e-02f, -5.49275689e-02f,
  -1.15434095e-01f, -5.48998751e-02f, 1.46913782e-01f, 1.04491621e-01f, -2.56041475e-02f, 2.64975354e-02f, -5.92725314e-02f, 3.16694714e-02f, -1.17097020e-01f, 1.78187899e-02f,
  2.58145910e-02f, -1.40568420e-01f, 1.09776311e-01f, -2.21722182e-02f, -1.66406885e-01f, 1.35394216e-01f, 7.66876414e-02f, 8.98774788e-02f, -6.74461154e-03f, 1.84460506e-01f,
  -2.68007696e-01f, 2.38075763e-01f, -2.80661762e-01f, -1.34766335e-02f, -4.53299135e-02f, -6.29898012e-02f, 2.80446142e-01f, 3.75146084e-02f, 5.01716658e-02f, 1.81125954e-01f,
  5.30648194e-02f, -2.44191140e-01f, -3.08576394e-02f, -2.18232926e-02f, -9.53043848e-02f, 2.70348281e-01f, 2.97193229e-01f, -1.98780134e-01f, -4.87135023e-01f, -1.18351430e-01f,
  8.50904062e-02f, -4.70673069e-02f, -1.85347989e-01f, -1.71311885e-01f, 4.90173362e-02f, -1.49901271e-01f, 3.54291755e-03f, -9.81175825e-02f, -7.93480948e-02f, 1.79023743e-01f,
  -3.22649270e-01f, -3.71393353e-01f, 5.19588217e-02f, -4.66600060e-02f, -4.11545336e-02f, 2.63682175e-02f, -8.20367038e-02f, -1.28025964e-01f, -6.16627000e-02f, 6.76247105e-02f,
  -2.48268396e-02f, -1.15563378e-01f, 4.41612452e-02f, -1.59647807e-01f, -1.17773376e-01f, -1.14451341e-01f, 3.50930430e-02f, -6.77411631e-02f, 1.88144222e-02f, -3.39326486e-02f,
  6.19488247e-02f, -6.46447241e-02f, -2.07710907e-01f, 6.91446513e-02f, 4.54905704e-02f, -1.27909765e-01f, -6.88627362e-02f, -2.25585118e-01f, -4.12363186e-02f, 1.11068763e-01f,
  1.52409747e-01f, 8.45979229e-02f, -7.47638643e-02f, 5.74911684e-02f, 5.31139039e-02f, -2.31572594e-02f, -9.64867324e-02f, 1.95730524e-03f, 1.53049026e-02f, 3.31941061e-02f,
  -2.06144876e-03f, 9.51016769e-02f, -5.59759280e-03f, 4.04576771e-02f, -8.92264247e-02f, -4.78357747e-02f, 1.32997186e-04f, 1.03913769e-01f, 7.48844759e-04f, -1.79066714e-02f,
  8.62726718e-02f, 5.76694682e-02f, -9.80537087e-02f, -9.36879143e-02f, -6.07417664e-03f, 1.51518909e-02f, 7.78092584e-03f, -8.50410834e-02f, -1.63608994e-02f, -4.89810482e-02f,
  -1.47297457e-01f, -2.92149007e-01f, 1.34477660e-01f, 2.37713996e-02f, -3.49597931e-02f, -3.34471911e-02f, -9.41066667e-02f, 4.37474586e-02f, 6.41373768e-02f, 1.35481432e-01f,
  -2.16985106e-01f, 1.94250066e-02f, 4.62951027e-02f, -2.96528614e-03f, 2.28001969e-03f, -3.49709764e-02f, 1.63694277e-01f, 3.16206156e-03f, -6.03579581e-02f, -2.66289022e-02f,
  2.02877164e-01f, 3.88354100e-02f, 3.20878811e-02f, 1.08418979e-01f, 2.18877763e-01f, 1.66874826e-02f, -8.51651356e-02f, -1.30159020e-01f, 8.55577271e-03f, 2.73870945e-01f,
  2.35558860e-03f, -9.36588868e-02f, -1.34202600e-01f, -9.31848884e-02f, -1.74154446e-01f, -1.69491962e-01f, -2.23770186e-01f, -3.88598852e-02f, -8.36230069e-02f, -1.47402316e-01f,
  3.93961929e-02f, 2.18163729e-01f, -5.94692363e-04f, 8.43412802e-02f, 9.68292952e-02f, -2.49007449e-01f, -1.23848945e-01f, -3.48815806e-02f, 2.00145096e-01f, 6.21658489e-02f,
  3.32703963e-02f, 1.50315076e-01f, 8.62693638e-02f, 3.42436507e-02f, -1.02233447e-01f, 6.16731346e-02f, -1.36460140e-01f, -3.33453491e-02f, -7.63269141e-02f, -2.69022644e-01f,
  3.94480675e-02f, -2.30109170e-01f, -2.45307192e-01f, -1.04826987e-01f, -1.28975570e-01f, -4.38190512e-02f, -3.66533101e-02f, -1.10385798e-01f, -5.72784245e-03f, -1.10318139e-01f,
  -2.21182941e-03f, 7.96863288e-02f, -3.33272591e-02f, -4.73953858e-02f, 2.76809484e-02f, 1.47323040e-02f, 9.04415327e-04f, -4.53653857e-02f, -1.66351661e-01f, -8.57228506e-03f,
  -2.97092143e-02f, -1.50458425e-01f, -9.34800729e-02f, -5.53307161e-02f, -9.90050435e-02f, 1.94484182e-02f, 6.15768135e-02f, -1.21683199e-02f, -1.08735308e-01f, -3.03378012e-02f,
  8.43005702e-02f, -8.74100998e-02f, -3.54468822e-02f, 9.39724296e-02f, 9.18670744e-02f, 6.76890388e-02f, 6.97943494e-02f, -1.18544549e-02f, 6.33102953e-02f, 1.40875384e-01f,
  2.48027332e-02f, -1.10381894e-01f, -3.24285211e-04f, 3.35182482e-03f, -9.16381925e-02f, -2.07082797e-02f, -3.25964950e-02f, 1.13025578e-02f, -5.55475578e-02f, 8.25131908e-02f,
  1.28223315e-01f, -2.34427489e-02f, 1.33077651e-01f, 8.34252387e-02f, 8.84152204e-03f, 3.31913009e-02f, 8.02131463e-03f, -7.48148635e-02f, 3.91095877e-02f, -6.09062379e-03f,
  3.23658437e-01f, -2.25074425e-01f, -1.37345925e-01f, 8.31640605e-03f, -2.80572884e-02f, -9.96733680e-02f, 1.06415346e-01f, -6.76388592e-02f, 2.79721078e-02f, 1.62092340e-03f,
  6.82761595e-02f, 1.45116746e-01f, -5.40663255e-03f, -6.38020709e-02f, -5.51076867e-02f, -1.32840693e-01f, -3.30829620e-02f, -1.06150404e-01f, 3.42322849e-02f, 6.96375072e-02f,
  2.06168704e-02f, 5.91125414e-02f, 1.47953406e-01f, 1.31340533e-01f, -1.25232479e-02f, 1.05547585e-01f, 3.77199277e-02f, 1.67030603e-01f, 7.18481839e-02f, 1.75833613e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 40)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 40;
const float L0_fan_Bp_bar_data[] = {
  1.17209211e-01f, -4.06378284e-02f, 1.23998940e-01f, -8.27822983e-02f, 1.21416904e-01f, 2.15124801e-01f, 3.35236415e-02f, 6.99949116e-02f, 1.06445320e-01f, 1.17107548e-01f,
  -5.15069626e-02f, -8.38703215e-02f, 1.71162814e-01f, 1.59109980e-01f, 9.19104367e-02f, 2.24209558e-02f, 1.10029839e-01f, -2.58232672e-02f, 1.29543796e-01f, -5.22214323e-02f,
  1.01688571e-01f, 1.51865199e-01f, -2.20262185e-01f, 1.47713795e-01f, 6.40911683e-02f, 4.87599298e-02f, 1.68258436e-02f, -2.23146886e-01f, 2.43223920e-01f, 1.70289576e-01f,
  1.40106037e-01f, 1.03476249e-01f, -5.51566258e-02f, 8.63660797e-02f, 5.73621914e-02f, -9.46305618e-02f, 1.05402291e-01f, 1.66996107e-01f, 3.64359915e-02f, 1.69114411e-01f
};

// L1_fan_Wp (Shape: 12 x 64)
const int L1_fan_Wp_rows = 12;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  8.90210620e-04f, -1.18571274e-01f, 5.70335388e-02f, 1.31226718e-01f, 2.27824926e-01f, 2.91395426e-01f, -1.41086459e-01f, 3.29468325e-02f, -7.63061345e-02f, 2.52833497e-02f,
  8.78410041e-02f, 1.60132293e-02f, -1.05767302e-01f, -1.15855582e-01f, 1.86683595e-01f, 1.48928851e-01f, -2.04516664e-01f, 7.64032230e-02f, 2.62442291e-01f, -1.52890906e-01f,
  1.31686002e-01f, -3.51896018e-01f, 9.38537437e-03f, 2.71356832e-02f, -1.27321094e-01f, 2.90434837e-01f, 8.45638067e-02f, -3.43260646e-01f, 6.00630157e-02f, 1.83769882e-01f,
  -7.49002919e-02f, 8.46524090e-02f, 8.46266840e-03f, 1.85266003e-01f, 1.18065896e-02f, 2.43015010e-02f, -8.76923501e-02f, -1.01445921e-01f, 1.07488930e-01f, 2.38831546e-02f,
  1.88868850e-01f, -8.69699791e-02f, -7.78406411e-02f, 7.57938484e-03f, 1.20019637e-01f, -2.66807601e-02f, 2.64181286e-01f, -1.03953183e-01f, -3.33081752e-01f, -8.06282386e-02f,
  1.20509349e-01f, 2.44260177e-01f, 7.44659901e-02f, -3.23846079e-02f, -6.75322488e-02f, 9.98139083e-02f, -6.65072650e-02f, -2.01351061e-01f, 2.09214970e-01f, -7.44355097e-02f,
  3.61728296e-02f, -2.09195003e-01f, 1.71907812e-01f, -2.14959174e-01f, -3.03044412e-02f, 3.84113118e-02f, 1.04342110e-01f, 3.23640965e-02f, -6.53553456e-02f, 1.26258582e-02f,
  -2.27812864e-02f, -1.41049057e-01f, 9.80404615e-02f, 2.08879765e-02f, 6.40844107e-02f, 1.41506596e-02f, -4.51731160e-02f, 1.29351094e-01f, 8.58423635e-02f, -5.63590787e-02f,
  2.36012172e-02f, -1.85394734e-01f, -1.11628525e-01f, -1.78231802e-02f, 7.91580528e-02f, 6.38056621e-02f, 5.28208539e-02f, -4.12427448e-02f, 1.11728676e-01f, 4.53443453e-02f,
  1.38874687e-02f, 2.07129538e-01f, -5.15421741e-02f, -2.09105626e-01f, 1.77613541e-01f, 1.12669148e-01f, 3.03268130e-03f, 2.30233725e-02f, -1.53542057e-01f, 2.32256025e-01f,
  2.16351241e-01f, 2.05221057e-01f, -3.03838868e-02f, 2.05377921e-01f, -2.59603828e-01f, -7.91083127e-02f, 2.14943513e-01f, 1.17040545e-01f, 3.28064561e-02f, 4.68763821e-02f,
  4.48961779e-02f, -1.41966760e-01f, 2.10609317e-01f, 2.35404391e-02f, 2.00084686e-01f, 2.98237633e-02f, -1.51838632e-02f, 1.64174691e-01f, 5.11917882e-02f, -2.52176017e-01f,
  2.86270678e-02f, 3.80502790e-02f, -1.34898394e-01f, 8.80536512e-02f, 3.22463997e-02f, 2.61080921e-01f, -6.39127940e-02f, 5.71523830e-02f, -9.00347310e-04f, -1.78845152e-02f,
  6.79951236e-02f, -1.20741976e-02f, 4.94051119e-03f, -8.73217285e-02f, -9.80676040e-02f, 2.12727189e-01f, -7.46240914e-02f, -5.67170605e-02f, 5.72581179e-02f, -1.07716583e-01f,
  3.30528885e-01f, 7.94064812e-03f, 1.72184959e-01f, 9.39727575e-03f, -6.19319566e-02f, -1.40179433e-02f, 2.51872063e-01f, -1.27146423e-01f, 1.14066951e-01f, -9.72475484e-02f,
  -1.74455449e-01f, -7.53443390e-02f, -2.80716509e-01f, -1.64849952e-01f, 2.35149011e-01f, -3.24029058e-01f, -3.75913158e-02f, 5.96957840e-02f, 3.69232781e-02f, -8.48010406e-02f,
  -1.73039615e-01f, 1.25384629e-01f, 2.11163118e-01f, -2.57005155e-01f, -4.22790498e-02f, 6.70510717e-03f, -8.83563235e-02f, -3.32899421e-01f, 3.37685466e-01f, -4.56290543e-02f,
  5.94137721e-02f, -2.40047738e-01f, -8.49557221e-02f, 1.64970219e-01f, -1.11976191e-01f, 1.36431053e-01f, -1.28810197e-01f, -1.12262994e-01f, 9.84905660e-02f, -6.85579404e-02f,
  -6.77369814e-03f, -2.75972545e-01f, -1.08584315e-01f, 2.01256141e-01f, -1.82833999e-01f, 1.68634385e-01f, -5.82037345e-02f, 1.05693594e-01f, -6.39940053e-02f, -1.37520745e-01f,
  1.04208097e-01f, -2.71078050e-02f, 1.20735489e-01f, 6.40700907e-02f, 8.43777061e-02f, -5.63416295e-02f, 1.52781636e-01f, 3.49828927e-03f, 9.65114981e-02f, 1.76114798e-01f,
  1.02490686e-01f, -6.58269376e-02f, 1.23034660e-02f, 6.37027696e-02f, 1.16251141e-01f, 1.51504025e-01f, 1.36219733e-03f, -8.55129734e-02f, 1.65772870e-01f, -6.32392466e-02f,
  1.10134199e-01f, -1.77579429e-02f, -1.78716276e-02f, -5.44735864e-02f, -1.92322563e-02f, -2.51931213e-02f, 3.12707610e-02f, 1.48121595e-01f, 2.19584003e-01f, -1.09042833e-02f,
  1.97440431e-01f, -1.11933332e-02f, 3.09387565e-01f, 1.31942064e-01f, 6.90673338e-03f, -1.16578609e-01f, 9.99472961e-02f, -3.39839645e-02f, 9.14098769e-02f, 8.15566406e-02f,
  1.46396738e-02f, 2.30246022e-01f, -5.61613701e-02f, 4.81098657e-03f, -1.20177247e-01f, -5.93709908e-02f, 4.52460349e-02f, -2.32115015e-02f, -3.10933869e-02f, -1.43362403e-01f,
  -4.25749179e-03f, 1.95135385e-01f, -2.67013488e-03f, -1.26388058e-01f, -4.58044410e-02f, 3.93553488e-02f, 7.09564909e-02f, -2.42206715e-02f, -7.41290674e-02f, -1.47474244e-01f,
  -3.93298529e-02f, 9.05511603e-02f, -2.08911881e-01f, -5.51864617e-02f, 1.12294480e-01f, 1.76213607e-01f, 1.99127629e-01f, 1.08714718e-02f, -9.68853235e-02f, -1.22688068e-02f,
  -6.21431395e-02f, 1.29406959e-01f, -1.02875911e-01f, -9.98794213e-02f, -1.61532894e-01f, -1.38199657e-01f, -7.49180838e-02f, -1.33613050e-01f, -2.84547769e-02f, 6.47494420e-02f,
  -6.21167310e-02f, 1.72738191e-02f, 2.16356870e-02f, -1.04036383e-01f, 1.46478683e-01f, -1.10023081e-01f, 1.44320637e-01f, -3.48938815e-02f, -1.80282574e-02f, 6.07988238e-02f,
  2.29878455e-01f, 2.01678067e-01f, 4.56139334e-02f, 6.42643124e-02f, 9.47199687e-02f, -9.98316780e-02f, 1.95503041e-01f, -4.11111414e-02f, -2.38813311e-01f, -2.77885646e-01f,
  1.87576506e-02f, 6.86415583e-02f, 1.84882730e-01f, 2.34011173e-01f, -6.15389496e-02f, 2.82175839e-01f, 2.05725641e-03f, 1.44558206e-01f, -1.86636243e-02f, -8.94862115e-02f,
  8.17495808e-02f, 1.40413627e-01f, 1.28383562e-02f, -2.72775292e-01f, -2.11767983e-02f, 2.15912953e-01f, 1.37028188e-01f, -1.51151836e-01f, -1.49218783e-01f, -2.08828270e-01f,
  -1.00458086e-01f, 2.16785353e-02f, -1.70796126e-01f, -1.24296613e-01f, -7.41527379e-02f, 7.39818886e-02f, -1.17049441e-01f, -4.13461179e-02f, 1.82464942e-01f, -7.47504532e-02f,
  6.14080671e-03f, 7.55996630e-02f, 7.64284506e-02f, -9.84165519e-02f, 1.57225244e-02f, -2.99995635e-02f, 1.37943448e-02f, 1.10626422e-01f, -1.00366242e-01f, -4.35953140e-02f,
  2.57208701e-02f, 1.74978394e-02f, 2.74780273e-01f, 2.01445043e-01f, -1.04699977e-01f, -1.58605173e-01f, -4.65507731e-02f, -1.80687487e-01f, -7.60153159e-02f, 2.28588551e-01f,
  -8.67023133e-03f, 1.06172375e-01f, 1.64508045e-01f, 1.43460140e-01f, -9.39526595e-03f, -1.55811295e-01f, -5.97296022e-02f, 1.53331477e-02f, -5.37429415e-02f, -3.62360924e-01f,
  -6.36996999e-02f, -9.28983986e-02f, -3.26451689e-01f, -1.56913579e-01f, 1.42509937e-01f, 7.65576884e-02f, 1.52437598e-01f, -1.33396551e-01f, -4.24507596e-02f, -1.12227894e-01f,
  -5.90315573e-02f, -1.10716000e-01f, 3.50421935e-01f, -5.37116788e-02f, -3.03414345e-01f, 4.69545349e-02f, -6.17900640e-02f, -1.50059015e-02f, -3.87631319e-02f, -1.05070837e-01f,
  8.52545053e-02f, -1.79173738e-01f, 1.46803530e-02f, -1.35425344e-01f, 1.59197643e-01f, -6.84208646e-02f, -4.10662591e-02f, -9.91604384e-03f, 5.30803092e-02f, 3.01335782e-01f,
  -1.01563483e-01f, 2.59633511e-01f, 1.11552209e-01f, 9.88992527e-02f, 6.84968904e-02f, -1.17034232e-02f, 9.72084294e-04f, 1.41790643e-01f, 5.94977476e-02f, 1.58074796e-01f,
  2.74144083e-01f, -1.93939116e-02f, -6.29873872e-02f, 2.64422745e-02f, 1.25535848e-02f, 6.19976074e-02f, -5.05539738e-02f, -3.81269567e-02f, 5.76399118e-02f, -4.55982313e-02f,
  7.84881040e-02f, -5.90686016e-02f, 1.44168153e-01f, -1.78105861e-01f, -1.35356868e-02f, -1.45679548e-01f, -1.09847724e-01f, -6.56631738e-02f, -2.72969693e-01f, 1.80061191e-01f,
  -1.04826517e-01f, -2.74321765e-01f, 3.05015985e-02f, -8.51870235e-03f, -6.01622229e-03f, 1.13377698e-01f, 3.51869352e-02f, 1.63495198e-01f, 3.16149920e-01f, -1.04988962e-01f,
  -1.75313428e-01f, -1.83454737e-01f, -7.15757767e-03f, -7.22536491e-03f, 5.96496649e-02f, 7.16265365e-02f, -2.90801376e-01f, -8.91154408e-02f, 1.25019863e-01f, 9.15411413e-02f,
  -1.36016076e-02f, 2.26205513e-01f, 9.18692723e-02f, 1.57025486e-01f, 2.61725001e-02f, -8.73953477e-02f, 5.20186238e-02f, -1.19648241e-01f, 5.93429133e-02f, 1.29989520e-01f,
  1.12402858e-02f, 3.94613780e-02f, 7.79342055e-02f, -2.06901729e-01f, 2.02282429e-01f, -1.02861844e-01f, 8.62511247e-02f, -1.07250318e-01f, -1.93964411e-02f, -1.50944486e-01f,
  -7.91326240e-02f, -1.08160041e-01f, 4.87764599e-03f, 1.00285180e-01f, -1.24460384e-01f, -1.40756220e-01f, -1.30836517e-01f, -1.11316808e-01f, 1.02295205e-01f, 1.21885106e-01f,
  1.22393239e-02f, 2.50061527e-02f, -3.13554481e-02f, 1.08696423e-01f, -1.85674336e-02f, -1.16305716e-01f, -1.68997850e-02f, 7.57481605e-02f, 1.94310501e-01f, -3.05831023e-02f,
  7.32578859e-02f, 7.11948192e-03f, 2.02096239e-01f, 2.02800289e-01f, -2.52598077e-01f, 9.48890746e-02f, -2.16143727e-01f, -2.99335063e-01f, -2.43607476e-01f, -7.55799562e-02f,
  -4.03267413e-01f, -3.51522356e-01f, -3.92240494e-01f, 1.73368528e-01f, -2.96816472e-02f, 2.63349228e-02f, 4.97564562e-02f, 3.48642349e-01f, -3.63093913e-01f, 1.04939930e-01f,
  1.13086410e-01f, 4.93953861e-02f, 1.88071012e-01f, 1.62039399e-01f, 9.96106490e-02f, -4.17840660e-01f, -5.42170042e-03f, -2.22415775e-02f, 1.31640717e-01f, 1.02870809e-02f,
  -3.05990636e-01f, -1.63574010e-01f, -2.73399288e-03f, -4.25929576e-02f, -4.08408828e-02f, -1.77185312e-01f, -5.53191751e-02f, 1.08308993e-01f, -1.98228776e-01f, -8.38938877e-02f,
  2.35503212e-01f, -3.14866424e-01f, 3.12382989e-02f, 2.94740442e-02f, -1.89309418e-01f, -5.67044541e-02f, 5.15536927e-02f, 1.94239821e-02f, -1.01194687e-01f, 9.16469023e-02f,
  -3.77259068e-02f, -1.23993466e-02f, 1.00014128e-01f, -1.52539283e-01f, -2.23399863e-01f, -7.50637660e-03f, 2.19885376e-03f, -7.21135410e-03f, 1.59754887e-01f, 2.28388697e-01f,
  -2.22905010e-01f, -1.43468276e-01f, -4.79735769e-02f, 8.10640305e-03f, -3.72815848e-05f, -1.43793553e-01f, -3.99612151e-02f, 2.01630481e-02f, -1.76600784e-01f, -1.34449229e-01f,
  -1.13371588e-01f, 1.28091335e-01f, -1.62733033e-01f, -1.15768217e-01f, 2.55734086e-01f, 6.30780756e-02f, -7.31193647e-02f, -2.35417619e-01f, -1.66100234e-01f, -8.47938135e-02f,
  2.03007817e-01f, 2.89746691e-02f, 1.10265367e-01f, 2.72342861e-01f, -2.71492004e-01f, -1.11844189e-01f, 1.78925812e-01f, 1.12946391e-01f, -6.73992112e-02f, -4.20763530e-02f,
  2.52861679e-01f, 9.54328924e-02f, -1.34092532e-02f, -4.21061255e-02f, 8.23397711e-02f, 5.80639541e-02f, -1.28877401e-01f, -1.10039525e-02f, 1.37431651e-01f, -8.48776922e-02f,
  -5.55997565e-02f, -3.60376298e-01f, 1.75446421e-01f, -1.55035779e-01f, -6.78382441e-02f, 6.07613437e-02f, -4.73423712e-02f, 3.19718383e-02f, -6.54078871e-02f, 4.44367249e-03f,
  7.03351106e-03f, 8.21375921e-02f, -3.02640069e-02f, 1.06625492e-02f, -4.73795645e-03f, -1.25148073e-01f, -4.85788099e-02f, -1.01216389e-02f, 2.28098005e-01f, 1.39802292e-01f,
  2.02615976e-01f, 2.97243781e-02f, -5.71508296e-02f, -4.17900421e-02f, 3.08905900e-01f, -6.70302957e-02f, 1.54940650e-01f, 8.60112719e-04f, -1.17145196e-01f, -1.01953857e-01f,
  4.76460420e-02f, 1.90779522e-01f, -1.17662236e-01f, -1.08057477e-01f, -1.33736253e-01f, 2.66525801e-02f, -7.75620416e-02f, -4.06132340e-02f, -2.01335579e-01f, 2.43844222e-02f,
  1.41550630e-01f, -1.95580758e-02f, -8.86844620e-02f, -2.77803779e-01f, -1.29171103e-01f, -8.77318010e-02f, 4.33868319e-02f, 1.24166794e-01f, -4.33785729e-02f, -4.84381132e-02f,
  6.26214445e-02f, 5.79518452e-02f, 1.12294093e-01f, 1.85680076e-01f, 8.97129327e-02f, -6.32229075e-02f, -1.16996663e-02f, 8.98115858e-02f, -4.36417721e-02f, -1.78134590e-01f,
  6.56138286e-02f, 9.42138210e-02f, -8.29956308e-02f, 9.09614488e-02f, -1.47445813e-01f, -6.62280545e-02f, -1.71989620e-01f, -1.42857134e-02f, 2.98717409e-01f, -1.64996132e-01f,
  -7.88086057e-02f, 4.67586853e-02f, -1.19927404e-02f, 1.82196304e-01f, -3.78312655e-02f, 5.63442968e-02f, -1.01977997e-01f, 3.84791344e-02f, -1.05898634e-01f, 7.23374039e-02f,
  -5.37590645e-02f, -6.65378349e-04f, 8.12126603e-03f, -1.45291433e-01f, 1.43956095e-01f, 2.79664516e-01f, -1.09336093e-01f, -1.95409302e-02f, 1.14573948e-01f, 2.10989922e-01f,
  1.02461375e-01f, -5.17488159e-02f, -1.35888621e-01f, -1.69443584e-03f, 1.41982332e-01f, 2.10338328e-02f, -1.64770827e-01f, 1.39998132e-02f, -2.28260085e-01f, 1.26522064e-01f,
  -3.56690556e-01f, -1.94296643e-01f, -6.38050213e-02f, -4.38465513e-02f, -2.81451106e-01f, -3.67634334e-02f, 1.33576751e-01f, -5.76755665e-02f, -1.25338167e-01f, 1.37204483e-01f,
  2.58741796e-01f, -2.96607893e-02f, 1.98788494e-02f, -7.27313533e-02f, 1.49495348e-01f, 9.30404961e-02f, 5.82467951e-02f, -6.21489361e-02f, -8.85295048e-02f, 1.21032409e-01f,
  -1.17698222e-01f, -6.16755523e-02f, 1.93513468e-01f, -1.07170172e-01f, 5.26500233e-02f, 1.56867951e-01f, 1.46716237e-02f, -3.75905894e-02f, -4.14710641e-02f, -9.47109237e-03f,
  -1.21577851e-01f, -7.39354789e-02f, 2.61458993e-01f, -9.22595337e-02f, 4.81457748e-02f, 2.24578176e-02f, 8.83520842e-02f, -1.58112034e-01f, -1.07798293e-01f, -1.27708301e-01f,
  5.74533604e-02f, -1.29908234e-01f, 4.06529903e-02f, 1.02740126e-02f, -5.96020408e-02f, 1.15950607e-01f, 2.24765062e-01f, 9.46618468e-02f, 8.51287022e-02f, -1.20616190e-01f,
  8.38058293e-02f, -1.20443881e-01f, 2.61961855e-02f, 1.94751862e-02f, 1.74554646e-01f, 4.64470359e-03f, 2.92210579e-02f, -2.27566697e-02f, -1.29242390e-02f, 9.57851484e-02f,
  2.06154570e-01f, 1.37004405e-01f, 1.20789587e-01f, -1.05958834e-01f, 1.18221022e-01f, 1.61661342e-01f, -1.52878702e-01f, -1.42848007e-02f, -3.19402963e-02f, 3.05231512e-01f,
  8.01604986e-02f, 1.01688296e-01f, 2.58749481e-02f, 2.33901907e-02f, -2.83870250e-01f, -2.34247386e-01f, 3.35739791e-01f, 2.10233539e-01f, -1.71287775e-01f, -1.07250012e-01f,
  1.26290932e-01f, -8.14846456e-02f, -1.17413096e-01f, -1.84517026e-01f, 7.75523707e-02f, 1.56395286e-01f, -5.63552640e-02f, 1.58159465e-01f, 4.55276892e-02f, -7.25405067e-02f,
  5.08580655e-02f, -2.98556667e-02f, 3.42565123e-03f, 2.73856938e-01f, -2.86163902e-03f, 1.03055499e-01f, -1.56357676e-01f, -1.86865941e-01f
};

// L1_fan_Wp_bar (Shape: 40 x 64)
const int L1_fan_Wp_bar_rows = 40;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  -4.86555845e-02f, 4.71731685e-02f, 9.74061266e-02f, 1.54520189e-02f, 6.76508471e-02f, 1.05801575e-01f, 2.37839967e-01f, 9.26851928e-02f, 2.64622271e-02f, 1.45296395e-01f,
  -1.38159424e-01f, 2.14848176e-01f, -7.58817643e-02f, 2.32509952e-02f, -2.68793970e-01f, 5.76432385e-02f, 2.94824213e-01f, 5.31479232e-02f, -4.68154430e-01f, 1.17026187e-01f,
  -1.11169122e-01f, 3.27450484e-01f, -7.83879906e-02f, -2.89686732e-02f, -2.96771497e-01f, -2.12813064e-01f, -4.49965626e-01f, 8.11703801e-02f, -7.47915208e-02f, -9.23572704e-02f,
  -2.33813763e-01f, 2.23940075e-03f, 1.07952125e-01f, 1.45518199e-01f, -3.54273804e-02f, 1.39108840e-02f, -2.17409462e-01f, 6.05231188e-02f, 1.07228734e-01f, -1.47207707e-01f,
  -1.87959313e-01f, -6.30284473e-02f, 7.91685134e-02f, -6.13100491e-02f, 1.04950398e-01f, -1.78441778e-01f, -2.36575902e-01f, 3.55420142e-01f, 2.26292610e-01f, 1.77739084e-01f,
  1.32965371e-01f, -5.14946245e-02f, 2.11153820e-01f, 1.04577437e-01f, 2.16477722e-01f, -7.17282295e-02f, 5.40205985e-02f, 4.91553992e-02f, -5.15117496e-02f, -4.40896936e-02f,
  2.00178400e-01f, 2.61632979e-01f, -5.18484600e-02f, 9.25770402e-02f, -1.01945540e-02f, -2.39405017e-02f, 1.15322158e-01f, 6.75948039e-02f, 1.94519326e-01f, 5.34849167e-02f,
  2.32889771e-01f, 1.09757632e-01f, -7.27168918e-02f, 2.56441534e-04f, 7.00886846e-02f, 1.33156270e-01f, -1.15438558e-01f, -1.10527225e-01f, -1.29059538e-01f, -8.48381668e-02f,
  5.74808270e-02f, 1.28640354e-01f, -8.13482702e-02f, -2.10735276e-01f, -1.84145749e-01f, -1.49614736e-01f, 8.17717984e-02f, 2.09525861e-02f, -7.69519359e-02f, 4.49504368e-02f,
  2.19782844e-01f, 8.05822760e-02f, 3.02223563e-01f, -4.01524231e-02f, 2.59799331e-01f, 1.28398031e-01f, 2.55975932e-01f, -1.06410973e-01f, 1.92395940e-01f, 3.36410776e-02f,
  -4.84200157e-02f, 2.85221022e-02f, -2.33727861e-02f, 1.73208117e-02f, 7.68322358e-03f, -3.77450399e-02f, -1.29355744e-01f, 8.50599185e-02f, -4.82567437e-02f, -1.97658479e-01f,
  -5.05945757e-02f, 3.65085080e-02f, -3.63865495e-02f, 1.12547837e-01f, -1.01992309e-01f, -1.65446222e-01f, 1.35058397e-02f, 2.56498873e-01f, -1.00611404e-01f, 4.40587625e-02f,
  -1.18245617e-01f, -5.01307286e-02f, -9.39326882e-02f, -3.13095488e-02f, -2.16767192e-02f, 1.20975815e-01f, 5.18251257e-03f, 8.74464512e-02f, 8.02465603e-02f, 8.65522325e-02f,
  6.71821237e-02f, 7.18473420e-02f, 1.86091036e-01f, 8.45344737e-02f, 1.68590173e-01f, -1.07894227e-01f, 1.23378955e-01f, 2.04670839e-02f, 7.83775076e-02f, 9.61059984e-03f,
  -1.05776623e-01f, -1.22081295e-01f, -1.59372181e-01f, 8.59135762e-02f, 1.76218227e-02f, -9.80459377e-02f, -1.69706836e-01f, -3.90645340e-02f, 2.44600270e-02f, 2.53119320e-02f,
  4.41377843e-03f, 8.29532966e-02f, 2.69899845e-01f, -4.47971933e-02f, 1.62126482e-01f, 2.46058509e-01f, 2.86258124e-02f, 1.57474205e-02f, 7.39844367e-02f, -8.23906437e-02f,
  2.68123060e-01f, 4.55990322e-02f, 1.65054016e-02f, 2.37692773e-01f, 1.50432453e-01f, 2.35281050e-01f, -3.47207673e-02f, 1.60946131e-01f, -2.17855662e-01f, -7.83993900e-02f,
  1.57316532e-02f, 2.61231244e-01f, 1.26833424e-01f, -4.54832204e-02f, 2.25264519e-01f, -7.64474273e-02f, -3.73735160e-01f, 1.59925058e-01f, -3.31288874e-02f, 4.18796428e-02f,
  -1.96584165e-02f, 2.50486284e-01f, 6.16289377e-02f, -1.25800475e-01f, 1.39240967e-02f, -1.92896158e-01f, -2.50142455e-01f, 7.07901716e-02f, 1.20748475e-03f, 1.57165557e-01f,
  -1.78289246e-02f, 1.27035789e-02f, 6.40944531e-03f, 2.64253654e-02f, -5.04077831e-03f, -1.03398852e-01f, -1.09595142e-01f, 1.83164328e-02f, -1.48308173e-01f, -2.78898273e-02f,
  7.03060627e-02f, -2.19440535e-02f, 4.97633889e-02f, 9.38025415e-02f, -1.01852879e-01f, 6.03045747e-02f, -8.04483369e-02f, 9.47124958e-02f, 3.71638429e-03f, -1.44540250e-01f,
  3.66339236e-02f, -1.43364891e-01f, -2.04348750e-02f, 4.47213463e-03f, 1.36056870e-01f, -1.93956241e-01f, 3.86724919e-01f, 6.27787337e-02f, -3.76426131e-02f, 5.87237589e-02f,
  -6.86500371e-02f, -1.76908791e-01f, -2.34592613e-02f, -2.12349489e-01f, -1.52707219e-01f, -3.08574200e-01f, -3.35732996e-01f, 6.34519607e-02f, 2.09791496e-01f, -3.71782035e-02f,
  -5.99473529e-02f, 2.74205476e-01f, 3.76393870e-02f, 2.65864700e-01f, -2.08512619e-01f, 9.44842920e-02f, 2.53209949e-01f, 2.58985221e-01f, 3.33542633e-03f, -2.59230137e-01f,
  1.76520482e-01f, 2.09447652e-01f, -1.69664845e-01f, -5.08706784e-03f, -2.60261178e-01f, 1.52156562e-01f, 9.18935984e-02f, -7.95952380e-02f, 8.53135586e-02f, -1.73157424e-01f,
  1.91993311e-01f, -2.79954728e-02f, -2.27908373e-01f, -1.28544614e-01f, 1.60563454e-01f, 1.89155079e-02f, 6.24486282e-02f, 4.32709195e-02f, 1.61033511e-01f, 1.23824328e-01f,
  7.04054683e-02f, 4.21825871e-02f, 1.27286375e-01f, 7.56433457e-02f, 7.33397827e-02f, 9.54066142e-02f, 6.93821013e-02f, -6.66377246e-02f, -9.06744450e-02f, -5.64975962e-02f,
  5.08609302e-02f, -4.38440405e-02f, 1.99272186e-02f, 1.05360702e-01f, -2.75099844e-01f, -1.68339357e-01f, 7.79734924e-02f, -6.29042313e-02f, -8.89166147e-02f, 9.21864435e-02f,
  -1.53288886e-01f, 1.36278560e-02f, 2.17920765e-01f, 2.24191118e-02f, 6.05674610e-02f, 3.79214436e-01f, 6.87321201e-02f, 1.41607121e-01f, 1.69598341e-01f, 3.84336710e-01f,
  2.47883126e-01f, -1.20545343e-01f, -2.57691611e-02f, -5.22463918e-02f, 1.42377034e-01f, -1.16266623e-01f, 1.80834219e-01f, 5.89237399e-02f, -1.38160482e-01f, 6.03301032e-03f,
  1.62867047e-02f, -3.81566323e-02f, 3.69749144e-02f, 9.31823328e-02f, -9.27583575e-02f, 1.14506893e-01f, 1.35600558e-02f, -6.80815578e-02f, 2.82276779e-01f, 2.08008766e-01f,
  9.16215256e-02f, -3.76997963e-02f, -5.45049943e-02f, -1.15246773e-02f, 1.76894777e-02f, -2.31515631e-01f, 2.03560308e-01f, -1.01299338e-01f, 5.24032721e-03f, 1.99236736e-01f,
  2.59405762e-01f, -1.04020499e-01f, 1.09310634e-01f, 1.59711778e-01f, -1.79017894e-02f, 5.74053824e-02f, 1.16613500e-01f, 7.75485113e-02f, 1.46596462e-01f, -1.11580128e-03f,
  -5.57007093e-04f, -1.33474236e-02f, 3.58322948e-01f, 1.80618331e-01f, -1.09041214e-01f, -2.80578416e-02f, 1.15130991e-01f, -3.13914806e-01f, 8.22795108e-02f, 3.68141249e-04f,
  8.75857621e-02f, -1.31893665e-01f, -8.20272267e-02f, -1.09080479e-01f, 1.28517210e-01f, 1.67760238e-01f, 8.77197385e-02f, 1.85324550e-02f, 2.24289596e-01f, -3.32336426e-01f,
  2.23830640e-01f, -1.00946613e-02f, -1.04700662e-01f, -2.80486286e-01f, 8.82321852e-04f, 5.13108894e-02f, 1.47206813e-01f, 3.24725918e-02f, -2.05282688e-01f, 3.46984774e-01f,
  -1.49923852e-02f, 2.77793497e-01f, -1.81721553e-01f, -3.76798436e-02f, 3.01295649e-02f, 1.83778465e-01f, 1.63430706e-01f, -2.13714942e-01f, -2.23282918e-01f, 2.73438603e-01f,
  8.46621245e-02f, -9.18455329e-03f, -1.21897832e-01f, -3.36173117e-01f, 1.47319093e-01f, 7.81018361e-02f, -2.51489788e-01f, -4.14882638e-02f, -5.42378835e-02f, 3.43842199e-03f,
  -1.64296299e-01f, 6.30567297e-02f, 4.17816043e-01f, 7.39512220e-02f, 9.96556804e-02f, 2.75659859e-02f, 1.36313424e-01f, 1.58580720e-01f, -6.57349080e-02f, 6.26333579e-02f,
  -7.42105348e-03f, 2.60879606e-01f, 2.36159444e-01f, 1.31908730e-01f, 1.53262123e-01f, -9.97500122e-02f, -7.70247877e-02f, 2.53790677e-01f, -8.51644278e-02f, 1.87407807e-02f,
  2.23533824e-01f, 2.46470988e-01f, -8.84126872e-02f, 1.47777200e-01f, -1.90622360e-01f, 1.06554493e-01f, -5.35373688e-02f, -2.41107531e-02f, -6.53742254e-02f, -2.54519060e-02f,
  4.77639074e-03f, 1.58307150e-01f, -6.24829791e-02f, 5.35036549e-02f, -2.63000101e-01f, 1.57976702e-01f, -1.05927072e-01f, -1.72242817e-05f, -5.25947250e-02f, -6.00229725e-02f,
  -4.55164127e-02f, -1.47772327e-01f, 1.15989245e-01f, -1.38359461e-02f, 1.85643792e-01f, 3.48377898e-02f, 4.55973223e-02f, -1.32781893e-01f, -1.17043890e-01f, -5.03075309e-02f,
  -6.68480322e-02f, 1.09969191e-01f, 3.58903199e-01f, -1.27381831e-01f, -1.33015811e-01f, -1.78972248e-03f, 8.44534934e-02f, -6.09442666e-02f, 2.14866966e-01f, 3.74957696e-02f,
  5.23854233e-02f, 1.19720288e-01f, 1.16989166e-01f, 5.70594659e-03f, -3.37481312e-02f, 1.14982255e-01f, -5.61679620e-03f, 7.15412199e-02f, 1.32820368e-01f, 5.19226529e-02f,
  -4.89680562e-03f, 3.47700752e-02f, 1.87846020e-01f, 2.90533900e-01f, -1.34327605e-01f, -4.14672941e-02f, 5.07526286e-02f, 7.22347796e-02f, 1.67223990e-01f, 5.80743924e-02f,
  6.71404749e-02f, -1.48496479e-02f, 2.85330657e-02f, 1.44969940e-01f, -7.52885733e-03f, -1.46245643e-01f, -3.38865630e-02f, 6.75707385e-02f, 2.04216495e-01f, -1.26263797e-01f,
  -1.92950264e-01f, -1.26401842e-01f, 3.76363918e-02f, 1.14440098e-01f, -1.48749053e-01f, -1.44232869e-01f, -1.42183483e-01f, -2.61385627e-02f, -1.59971058e-01f, -8.78094658e-02f,
  -3.34562324e-02f, -2.60942280e-02f, -1.13919899e-01f, -3.89139727e-02f, 2.22734492e-02f, 5.42451777e-02f, 1.23312476e-03f, 1.26969188e-01f, -5.79014048e-03f, 3.96177061e-02f,
  1.97891101e-01f, 5.47610447e-02f, -4.65254709e-02f, 1.89353958e-01f, -9.24496800e-02f, -1.13504725e-02f, -2.38862604e-01f, 7.64616504e-02f, -2.77785063e-02f, -1.49347067e-01f,
  1.76964253e-02f, 2.51763556e-02f, 9.85694975e-02f, 2.31937561e-02f, -8.81406590e-02f, -3.53307426e-02f, 8.07104334e-02f, 8.11470523e-02f, -1.90152004e-01f, -1.03671618e-01f,
  2.52482325e-01f, -8.29833969e-02f, 1.22478977e-01f, 9.67358425e-02f, 1.27394229e-01f, 1.01141721e-01f, 7.74257258e-02f, 5.66647202e-02f, 8.17343146e-02f, 1.05136447e-01f,
  2.06067950e-01f, 2.91674972e-01f, 1.64518833e-01f, 2.77842861e-02f, 7.59336026e-03f, 5.85273914e-02f, -1.82731122e-01f, 1.39361307e-01f, 7.51574934e-02f, 1.56058431e-01f,
  6.28881305e-02f, -2.19708577e-01f, -3.10948566e-02f, -2.20063310e-02f, -4.96297739e-02f, 1.77497849e-01f, -1.03491902e-01f, -9.56538785e-03f, 4.07539085e-02f, -3.49741995e-01f,
  6.49433732e-02f, -1.59556568e-02f, 2.30718821e-01f, 1.06717825e-01f, 1.88073859e-01f, 1.20646134e-01f, 2.92238653e-01f, -2.28707716e-01f, -1.15130268e-01f, 1.04825893e-04f,
  -6.93572909e-02f, 1.33931071e-01f, 2.49202654e-01f, 2.32946530e-01f, -4.45604652e-01f, -1.82047576e-01f, 6.22802377e-02f, 1.15015604e-01f, -1.91333890e-01f, -6.98361024e-02f,
  -6.35099858e-02f, 1.55900335e-02f, -4.43522781e-02f, -2.07256824e-01f, 2.42471948e-01f, -1.94239274e-01f, 1.44537818e-02f, 1.70301303e-01f, -7.29212612e-02f, 2.06720814e-01f,
  2.05167368e-01f, -1.12460323e-01f, 2.67081298e-02f, 1.03580981e-01f, 2.90914565e-01f, 2.18221575e-01f, 1.75565165e-02f, -7.45522305e-02f, 1.08256407e-01f, -4.71060909e-02f,
  -3.92110348e-02f, 3.28933559e-02f, 7.33667761e-02f, 1.32230118e-01f, 5.51412739e-02f, 8.48959088e-02f, 8.87959972e-02f, 1.10480897e-01f, 2.59002298e-01f, 2.39664316e-01f,
  -3.11132837e-02f, -8.36011171e-02f, 1.40309304e-01f, -1.21178798e-01f, 1.93085894e-01f, 5.46023808e-03f, -2.47537643e-02f, 1.48877338e-01f, 7.63249397e-02f, -1.23186164e-01f,
  1.76818550e-01f, 1.68628410e-01f, -5.61196804e-02f, 2.23946437e-01f, -3.88708338e-02f, -1.54318348e-01f, -3.03003006e-02f, -3.42478827e-02f, -2.61220723e-01f, -1.80753112e-01f,
  8.05489048e-02f, 2.03350410e-01f, 1.73542976e-01f, 1.46537319e-01f, -1.60065815e-01f, 2.11612850e-01f, -1.97158918e-01f, 8.27937126e-02f, 2.22560033e-01f, 1.42968848e-01f,
  8.08245614e-02f, 1.91796795e-01f, 6.94420114e-02f, 4.97466996e-02f, -8.40493944e-03f, 3.21714804e-02f, -4.10404317e-02f, -1.33309305e-01f, -1.36211157e-01f, 5.22624590e-02f,
  1.73429877e-01f, 1.12995263e-02f, -1.95326656e-02f, 2.52066046e-01f, 8.63057747e-02f, 1.84811518e-01f, -3.31305712e-02f, 1.60999671e-01f, 2.98300106e-02f, -4.37781326e-02f,
  -1.19571043e-02f, 1.36726024e-02f, 3.38016078e-02f, -5.23030199e-02f, 1.52654096e-01f, -5.49413413e-02f, 8.13164935e-02f, 6.89979047e-02f, -1.88800059e-02f, 2.23396942e-01f,
  -1.38117522e-01f, -2.65289005e-02f, 2.75041431e-01f, -1.34280369e-01f, 6.21611141e-02f, 5.65860979e-02f, -1.00303985e-01f, -4.15216982e-02f, 1.17307082e-01f, -1.26077414e-01f,
  -1.31340686e-03f, 3.02510895e-02f, -2.52795398e-01f, -4.88905385e-02f, -1.82587430e-01f, -1.51262745e-01f, -6.76395893e-02f, 2.08948385e-02f, 1.43005857e-02f, 1.87881395e-01f,
  1.38868660e-01f, -7.33822957e-02f, -1.23877145e-01f, 2.77770549e-01f, -2.23663040e-02f, -1.63997799e-01f, 1.01472877e-01f, -1.82595283e-01f, 7.32103921e-03f, -2.32386723e-01f,
  -3.16562772e-01f, 1.02253832e-01f, 5.31707853e-02f, 5.85346147e-02f, 2.02524546e-03f, -1.96898341e-01f, 1.83104619e-01f, 2.11354852e-01f, 3.46488878e-02f, 8.85434300e-02f,
  1.94170460e-01f, -1.07247867e-01f, 1.37886658e-01f, 1.02117062e-01f, 1.41946480e-01f, 2.55505383e-01f, -1.38005465e-01f, 2.30878681e-01f, -1.10213369e-01f, -1.15961567e-01f,
  -1.22984558e-01f, 7.71258026e-03f, 1.23721600e-01f, -1.68263674e-01f, 9.24710929e-02f, 1.38774768e-01f, 2.08210610e-02f, 1.92030013e-01f, 1.46670654e-01f, 1.24115393e-01f,
  7.95472264e-02f, 6.99254945e-02f, 8.96199644e-02f, 9.52213723e-03f, 1.02587827e-01f, -4.76152226e-02f, -3.46817940e-01f, -9.39171854e-03f, -7.68640488e-02f, 1.38795465e-01f,
  -5.29438704e-02f, 2.75582355e-02f, 2.23654751e-02f, -3.23868766e-02f, -1.79449111e-01f, -3.60884964e-02f, 1.26782820e-01f, 3.23365778e-02f, 7.58603439e-02f, -9.53638032e-02f,
  3.14964324e-01f, 7.83093423e-02f, 9.36063230e-02f, -1.31246578e-02f, 1.26691952e-01f, 2.45543346e-02f, 2.01925442e-01f, -5.26001826e-02f, 2.52798110e-01f, 6.24240674e-02f,
  1.57245412e-01f, 2.13687003e-01f, -1.08301574e-02f, 1.59579128e-01f, 2.79715002e-01f, -5.74029312e-02f, -1.18610635e-01f, 1.25468075e-01f, -1.13001041e-01f, 3.73516232e-02f,
  1.78789437e-01f, -1.78620607e-01f, 6.17460832e-02f, 3.38509828e-02f, -1.44669443e-01f, -9.55032185e-02f, -3.39920893e-02f, 4.61612977e-02f, 3.34168188e-02f, 2.61842702e-02f,
  3.32765318e-02f, -1.88391328e-01f, 1.92270830e-01f, 6.23121895e-02f, -1.10209156e-02f, 1.29172221e-01f, -1.07814007e-01f, 1.59598932e-01f, -2.09872960e-03f, 6.97595924e-02f,
  9.33457315e-02f, -2.74802577e-02f, -1.08186444e-02f, -1.44829020e-01f, 7.92961270e-02f, 1.36343539e-01f, 7.35843107e-02f, 1.30020574e-01f, -1.09826978e-02f, 3.87443677e-02f,
  2.04897448e-01f, -3.97585072e-02f, 1.01989262e-01f, -1.12899654e-01f, 8.83340165e-02f, -5.24017885e-02f, 1.24488048e-01f, 1.20704085e-01f, 4.06067334e-02f, -1.22751966e-01f,
  -6.43395707e-02f, 1.11589447e-01f, 5.56349615e-03f, 1.73384547e-01f, -2.09952116e-01f, 6.76680207e-02f, -1.01899542e-01f, 1.74873382e-01f, -1.63970768e-01f, 1.28766790e-03f,
  -2.35266499e-02f, 1.43354043e-01f, -1.35763630e-01f, 2.07335338e-01f, 3.48327123e-02f, -5.69451861e-02f, 6.98769614e-02f, -9.34650078e-02f, 1.11381263e-02f, -7.64184147e-02f,
  2.48251483e-01f, -4.93574105e-02f, 1.62135109e-01f, 1.04465775e-01f, -1.53895780e-01f, 2.45146498e-01f, -1.84721220e-02f, 5.91075309e-02f, 2.12605938e-01f, -9.57400817e-03f,
  -1.39441609e-03f, 9.09408741e-03f, 2.99571872e-01f, 1.33481219e-01f, 7.03003332e-02f, 2.60046512e-01f, -6.39036521e-02f, 1.42808616e-01f, -2.62354463e-02f, -6.25720546e-02f,
  -1.22040033e-01f, -9.02840272e-02f, 9.67239812e-02f, 1.78660125e-01f, -3.83627973e-02f, 6.94273338e-02f, -9.56287235e-03f, 7.06979409e-02f, 5.96813448e-02f, 3.79693955e-02f,
  1.93877578e-01f, 1.27789706e-01f, 3.99397761e-02f, -2.80094631e-02f, -1.40166432e-01f, -1.11725479e-01f, 9.21454355e-02f, -1.20150894e-01f, -1.52800098e-01f, 9.88559797e-02f,
  2.23389845e-02f, -1.00236952e-01f, 2.43913621e-01f, -6.54861331e-02f, -6.89991489e-02f, -1.17222764e-01f, 3.18868048e-02f, 1.03818968e-01f, 3.78834367e-01f, -8.57303068e-02f,
  1.09432757e-01f, 2.88579136e-01f, 1.94367439e-01f, 2.02050820e-01f, 1.55158311e-01f, 3.07262361e-01f, 2.03176722e-01f, 2.12644096e-02f, 1.04173645e-01f, -1.31187707e-01f,
  7.42062703e-02f, 1.05493955e-01f, -4.67269048e-02f, 5.60269170e-02f, -1.36328623e-01f, 2.16259986e-01f, -4.54622507e-03f, 5.69252372e-02f, 1.96588039e-02f, 3.80072109e-02f,
  -2.08105206e-01f, -5.31900637e-02f, 1.26765799e-02f, -8.24421719e-02f, -3.85060646e-02f, 1.29799262e-01f, -1.09614491e-01f, 8.74346718e-02f, -1.26846656e-01f, -6.90568686e-02f,
  2.72782087e-01f, -7.93321878e-02f, 1.01617821e-01f, -2.09180623e-01f, -1.32413775e-01f, -1.38230231e-02f, 2.72938199e-02f, -9.49585587e-02f, 3.97503637e-02f, -1.51037142e-01f,
  2.21835241e-01f, 5.75989671e-02f, 9.14347246e-02f, 1.13163270e-01f, 8.13926011e-02f, 1.19173720e-01f, 4.15157666e-03f, 1.68456152e-01f, 5.83514646e-02f, 3.27049531e-02f,
  1.01131707e-01f, -5.62584810e-02f, 2.38029342e-02f, 1.56494036e-01f, 1.71194047e-01f, -2.51782499e-02f, -8.36957619e-02f, -4.77948859e-02f, -3.42215667e-03f, -1.96959481e-01f,
  -1.16776759e-02f, -1.37562573e-01f, -1.47162110e-01f, -1.27341792e-01f, -4.07846272e-02f, -8.74616653e-02f, 3.82629968e-02f, 1.48621514e-01f, -1.47428945e-01f, 1.58307239e-01f,
  -2.00177610e-01f, -1.58077795e-02f, -1.70439303e-01f, -2.99643964e-01f, 1.80073470e-01f, -9.83299166e-02f, -1.87894091e-01f, -3.51646394e-02f, -2.74104327e-02f, -6.06368110e-02f,
  -1.68577775e-01f, -2.27426320e-01f, -5.25768697e-02f, -1.08963577e-02f, 1.02814220e-01f, -2.88287848e-01f, 1.25357017e-01f, 1.40186206e-01f, 9.34204906e-02f, -9.51188132e-02f,
  -1.03446260e-01f, -5.69805130e-02f, 1.18910201e-01f, -9.77653265e-02f, 5.08784391e-02f, -2.40086108e-01f, 7.18684494e-02f, -1.31566033e-01f, -1.42799973e-01f, -1.72100261e-01f,
  1.46347374e-01f, 5.75144887e-02f, 2.29572296e-01f, -7.81468451e-02f, 1.43126370e-02f, 6.06863089e-02f, -2.04186123e-02f, -5.31896688e-02f, 1.37845114e-01f, 1.64962471e-01f,
  1.82789721e-04f, 1.13117893e-03f, -9.45214704e-02f, -1.01961404e-01f, 9.36933607e-02f, -7.94107765e-02f, 4.56181914e-02f, 2.23410018e-02f, 1.45870999e-01f, -4.26399000e-02f,
  -1.59181934e-02f, -2.75435578e-02f, -3.15547399e-02f, 9.58240181e-02f, 2.21085429e-01f, 2.02603955e-02f, 2.76164562e-01f, 6.83579175e-03f, 6.48770705e-02f, -2.45393962e-01f,
  1.28024921e-01f, -1.77700311e-01f, -7.80131295e-02f, -1.02805063e-01f, 9.77850333e-02f, 1.29946113e-01f, 1.12501182e-01f, -2.19416603e-01f, -1.38835594e-01f, 9.87592638e-02f,
  3.88604730e-01f, 1.93607002e-01f, -1.56255245e-01f, 7.50846788e-02f, -2.12276410e-02f, 3.19797434e-02f, -7.39443302e-02f, -2.14144230e-01f, 2.63539124e-02f, 1.22260503e-01f,
  -1.39600888e-01f, 1.20030671e-01f, -2.72997953e-02f, 1.68848468e-03f, -1.69341639e-02f, 1.40610412e-01f, 1.11743081e-02f, -6.07422926e-02f, 2.06428662e-01f, -1.47368789e-01f,
  -1.27977222e-01f, -8.28850269e-02f, -5.07192798e-02f, -7.33466446e-02f, 8.66410509e-02f, 6.25393167e-02f, 4.88946810e-02f, 3.61690745e-02f, 6.44833371e-02f, 6.40471727e-02f,
  9.88412127e-02f, 6.56049103e-02f, -1.45907113e-02f, -1.04282118e-01f, 1.89977869e-01f, 1.21549601e-02f, -3.59146893e-01f, -1.77902043e-01f, -1.43008441e-01f, 1.12630203e-01f,
  4.38019959e-03f, 5.54714277e-02f, -2.25327671e-01f, -1.85892284e-01f, 5.04722372e-02f, -1.17303342e-01f, 2.13439073e-02f, 2.35183407e-02f, 1.10344999e-01f, -6.25910535e-02f,
  3.86984468e-01f, -3.07070538e-02f, 6.86930567e-02f, 6.10992312e-02f, 2.41109908e-01f, 8.12747926e-02f, 1.82296336e-01f, 4.79366332e-02f, -5.93308965e-03f, -6.37252629e-02f,
  -9.36703011e-02f, -5.35976961e-02f, 5.24743274e-02f, -1.01028614e-01f, 2.04011202e-01f, -8.32468420e-02f, -2.34439388e-01f, 1.26236215e-01f, 3.24142948e-02f, -7.86412433e-02f,
  1.53550819e-01f, -1.70491338e-01f, -1.85083583e-01f, -7.55964667e-02f, -4.33014035e-02f, 2.26989426e-02f, -5.56824952e-02f, 2.55956501e-01f, -1.57793358e-01f, -9.67700407e-02f,
  4.87113446e-02f, 4.52773906e-02f, 2.65121043e-01f, -8.66722018e-02f, 3.07794958e-01f, -5.77856451e-02f, -3.28676283e-01f, 1.14845999e-01f, 3.39271165e-02f, 1.19744316e-01f,
  4.81268438e-03f, 6.95271567e-02f, 7.10353851e-02f, -2.29970887e-02f, 9.51231346e-02f, 5.58453240e-02f, 1.29046574e-01f, 1.74838901e-01f, -9.52522606e-02f, -5.82667515e-02f,
  1.78989217e-01f, -2.55601138e-01f, 1.95788071e-01f, 6.25347160e-03f, 6.72651157e-02f, -9.98366922e-02f, 4.89707440e-02f, -6.83276951e-02f, 3.88101228e-02f, -8.51938594e-03f,
  -1.95047840e-01f, -1.43313929e-01f, -1.64674446e-01f, 1.12295695e-01f, -1.64750263e-01f, -2.07660031e-02f, -5.32435291e-02f, 4.57017690e-01f, 1.28739625e-01f, 4.10513766e-02f,
  1.66346833e-01f, 1.22471623e-01f, -2.91362256e-01f, -1.49134472e-01f, -1.51795253e-01f, -2.90407926e-01f, 1.85476281e-02f, -2.54944682e-01f, -4.20557186e-02f, 1.36771038e-01f,
  -1.40101358e-01f, -5.37025891e-02f, 2.04524308e-01f, -2.33293578e-01f, -1.73888773e-01f, 2.12942690e-01f, -8.16089660e-02f, -4.39003818e-02f, -1.85071751e-01f, 1.23537220e-01f,
  4.75187600e-02f, -3.94712575e-02f, 9.05454010e-02f, 6.95403591e-02f, -1.70217231e-01f, 2.04028487e-01f, -3.56920242e-01f, -2.97948956e-01f, -6.92402869e-02f, -7.21481293e-02f,
  -2.37791628e-01f, -3.98873948e-02f, 7.53198266e-02f, 1.94628432e-01f, -4.57482189e-02f, -3.58902998e-02f, 3.24573703e-02f, 2.47563675e-01f, 4.81540716e-04f, 2.28366166e-01f,
  1.20962724e-01f, 1.68717265e-01f, 3.93319167e-02f, -1.30150124e-01f, 2.70730823e-01f, 2.04290122e-01f, 8.89553204e-02f, -2.97451462e-03f, 9.90369543e-02f, 7.82481767e-03f,
  2.14234740e-01f, -1.16854452e-01f, 1.99685931e-01f, -6.17679879e-02f, 9.60566252e-02f, -1.29367098e-01f, -5.72609603e-02f, 1.41786337e-01f, 9.72635001e-02f, -7.59473592e-02f,
  -1.01332135e-01f, -1.96155384e-02f, 2.20934510e-01f, 3.92614026e-03f, -1.34268045e-01f, -1.15226232e-01f, 1.53366521e-01f, -2.03856826e-02f, 1.47616819e-01f, -5.41686118e-02f,
  -1.38852954e-01f, 1.97917536e-01f, -4.24211435e-02f, 1.69749707e-01f, 1.23848483e-01f, -1.17784552e-01f, 4.60191863e-03f, 1.90387219e-01f, -8.76290724e-02f, -9.59959775e-02f,
  -1.05499886e-02f, 6.12251200e-02f, 6.52015582e-02f, -9.21342894e-02f, -1.70966029e-01f, -1.64488077e-01f, 1.82289824e-01f, -1.34716621e-02f, -2.81402349e-01f, 1.30333140e-01f,
  -3.78328487e-02f, 2.29937091e-01f, 1.03348661e-02f, 5.83296716e-02f, 3.47736597e-01f, 9.91799086e-02f, 1.98315486e-01f, -5.31424172e-02f, -1.92906463e-03f, 1.13572478e-01f,
  1.03378497e-01f, 1.05217963e-01f, 1.95346385e-01f, 4.12440412e-02f, 1.09931998e-01f, 6.96239099e-02f, -6.06502183e-02f, 1.39806107e-01f, -1.08403146e-01f, -2.77324945e-01f,
  -3.40576619e-02f, 3.67691249e-01f, -2.17118543e-02f, -3.32215458e-01f, -2.49152049e-01f, -1.48721980e-02f, 3.40994671e-02f, -2.51528919e-01f, -3.17349076e-01f, -1.16735891e-01f,
  1.78332224e-01f, -3.82062271e-02f, -3.40526998e-01f, 2.55481172e-02f, -7.70228058e-02f, 2.89930522e-01f, -4.52100262e-02f, -2.06878722e-01f, 3.18874270e-01f, 1.79391548e-01f,
  -1.84861645e-01f, 1.78468287e-01f, 8.80515203e-02f, -6.98674023e-02f, 3.70285772e-02f, 1.40496701e-01f, -3.30229163e-01f, 2.92952001e-01f, -8.59147757e-02f, -1.02121346e-01f,
  2.60923445e-01f, 1.38152361e-01f, -1.15183145e-01f, 1.79742828e-01f, -1.17935464e-01f, 4.11791086e-01f, -4.92427535e-02f, -2.38206863e-01f, -5.77153377e-02f, -9.18512270e-02f,
  1.84269011e-01f, -3.35536078e-02f, -2.32376337e-01f, -6.27605021e-02f, -1.11636773e-01f, -1.89751372e-01f, -2.20131442e-01f, 5.25384098e-02f, 2.89040774e-01f, -2.53261328e-02f,
  1.86401397e-01f, 1.32623151e-01f, 1.76037028e-01f, 4.95619699e-02f, 8.09151679e-02f, 6.48019910e-02f, 1.12595059e-01f, 4.14185114e-02f, 5.55794761e-02f, 2.33276896e-02f,
  1.31002441e-01f, 6.63514286e-02f, -6.21229671e-02f, 9.91445482e-02f, -5.08537553e-02f, -5.67904636e-02f, 1.80886462e-01f, -1.10508271e-01f, -2.10608840e-01f, -2.52294932e-02f,
  5.12223225e-03f, 1.39287218e-01f, -9.79899312e-04f, 2.61703301e-02f, -6.06238283e-02f, 9.41963773e-03f, -9.68451947e-02f, 5.36292046e-02f, 2.22232610e-01f, -1.59402966e-01f,
  1.31280363e-01f, -3.81918177e-02f, 2.12259635e-01f, -5.86291291e-02f, 8.09162706e-02f, 1.55500889e-01f, 6.99980780e-02f, 3.60125750e-01f, 1.57005452e-02f, 5.38449213e-02f,
  -9.56696644e-02f, 1.83770210e-01f, 3.34385820e-02f, 4.30161133e-02f, -5.88272884e-03f, -1.02364495e-01f, 2.18632102e-01f, -1.79137643e-02f, -3.36533599e-02f, 2.39342391e-01f,
  -1.44564360e-01f, 1.70136373e-02f, 2.91696191e-02f, 9.72054526e-02f, 8.42625871e-02f, -4.37802263e-02f, 1.00820120e-02f, -3.42748538e-02f, -2.01870993e-01f, -6.85333610e-02f,
  5.70509247e-02f, 2.39181355e-01f, 3.28820497e-02f, 2.44740307e-01f, -4.88924086e-02f, 5.40477782e-02f, 7.32814074e-02f, 7.53620043e-02f, -5.23098297e-02f, -1.33879066e-01f,
  -1.31107166e-01f, 1.44886702e-01f, 9.93829500e-03f, 6.10765927e-02f, 5.20401224e-02f, 1.61212191e-01f, 2.96756923e-02f, 1.92332089e-01f, 8.22550207e-02f, -2.31252596e-01f,
  3.34559344e-02f, 6.43432140e-02f, 2.07784578e-01f, -2.72422992e-02f, 5.00093028e-02f, 1.34088576e-01f, 1.37038156e-01f, -1.67943630e-02f, 2.25890383e-01f, 2.77016610e-01f,
  3.25546637e-02f, 2.49144271e-01f, -3.05434149e-02f, -1.90202147e-01f, 1.38191849e-01f, -4.92400452e-02f, -2.08617538e-01f, -1.73562527e-01f, -1.90523252e-01f, 1.54783666e-01f,
  1.02040105e-01f, 1.15771070e-01f, -8.86073411e-02f, 3.11941296e-01f, -3.24336797e-01f, -5.78097031e-02f, 1.68533757e-01f, 2.15939835e-01f, 1.37197778e-01f, 1.47103235e-01f,
  6.85508475e-02f, -1.34521663e-01f, -1.08187988e-01f, 1.95849631e-02f, 1.86645523e-01f, -1.07002817e-01f, 6.57303706e-02f, 1.81791022e-01f, -2.03049965e-02f, -5.90296537e-02f,
  -9.53320134e-03f, 6.20455183e-02f, 6.00782260e-02f, 1.40495911e-01f, 1.98411658e-01f, 6.81048632e-02f, -7.49767572e-02f, -3.90172116e-02f, 3.03621572e-02f, -1.22146845e-01f,
  2.14171335e-01f, 1.58163264e-01f, 1.30819708e-01f, 2.41182204e-02f, 3.31845462e-01f, -1.77985411e-02f, -7.40112215e-02f, 9.92510095e-02f, 6.64097667e-02f, -4.24630642e-02f,
  -5.04226834e-02f, 7.12879226e-02f, -1.79641977e-01f, -4.53554094e-02f, 1.82783097e-01f, -1.86596453e-01f, -2.76468992e-01f, 1.03729084e-01f, 2.15351768e-02f, 9.73508582e-02f,
  -1.22941114e-01f, 2.17142813e-02f, -3.25602710e-01f, -1.18513621e-01f, -2.18123958e-01f, -5.99412657e-02f, 6.80987537e-02f, 1.88769400e-01f, -1.02945436e-02f, 1.24728300e-01f,
  1.21112138e-01f, 1.02716543e-01f, 3.25195901e-02f, 1.02818906e-01f, -1.24224104e-01f, 2.09449716e-02f, 1.94865331e-01f, -2.80949950e-01f, -1.34752616e-01f, 1.26152709e-01f,
  -9.70528051e-02f, -4.13181707e-02f, 2.24831477e-02f, -1.58132404e-01f, -1.13688096e-01f, 3.81285071e-01f, 8.69670585e-02f, 2.14939281e-01f, -1.50621347e-02f, -1.25787407e-01f,
  1.63887963e-01f, 1.18550742e-02f, 4.45671864e-02f, 5.78734744e-03f, -5.57375103e-02f, 2.29775727e-01f, -1.85390785e-01f, -1.35983929e-01f, 7.75098354e-02f, 1.53431324e-02f,
  1.06783576e-01f, 1.21133085e-02f, 7.47644156e-02f, 4.56554815e-02f, 1.82794765e-01f, -5.26897125e-02f, 3.98949496e-02f, 5.28888181e-02f, -4.14057262e-02f, -2.25754492e-02f,
  8.70181471e-02f, 5.66950776e-02f, 6.53727055e-02f, 1.03899881e-01f, 3.08666471e-02f, -2.69148424e-02f, 6.72083944e-02f, 9.93466154e-02f, -1.89974189e-01f, -1.47735476e-01f,
  3.21039230e-01f, 6.07753219e-03f, 8.00637081e-02f, -1.70861259e-01f, -3.43641229e-02f, -6.71126507e-03f, 6.80138450e-03f, 1.07965194e-01f, 2.87044086e-02f, -1.18483178e-01f,
  -3.25193226e-01f, -7.58088455e-02f, 2.05020495e-02f, -6.24159873e-02f, 3.13749574e-02f, -1.51307270e-01f, -5.16239330e-02f, 5.44545241e-02f, 2.15672478e-01f, -1.21522129e-01f,
  -2.87979767e-02f, 1.53231889e-01f, 1.48874834e-01f, 1.04561426e-01f, 9.77730677e-02f, 5.74854128e-02f, 1.25151053e-01f, 1.67249307e-01f, 1.21307233e-02f, -2.01014310e-01f,
  7.90952146e-02f, 6.39617618e-04f, 2.41385296e-01f, -4.90199812e-02f, -1.70975208e-01f, -1.22240677e-01f, -3.59922126e-02f, 4.34443466e-02f, 1.15529492e-01f, -9.96672511e-02f,
  1.94942042e-01f, 1.68319326e-02f, -1.36297688e-01f, -3.92601527e-02f, 1.15340181e-01f, -5.92647977e-02f, 1.46696223e-02f, 9.64871123e-02f, 1.17124178e-01f, -3.19598988e-02f,
  1.22736394e-01f, 1.49828419e-01f, 2.79873043e-01f, 1.98144555e-01f, -2.35635578e-03f, 2.14215487e-01f, 6.24392107e-02f, 5.46522662e-02f, 4.84946549e-01f, 2.31355175e-01f,
  1.88573673e-01f, -1.70611069e-01f, 1.69828996e-01f, -4.99925055e-02f, 8.98106694e-02f, 2.43238043e-02f, 1.06178381e-01f, -1.82466060e-02f, -2.24647328e-01f, -9.55023840e-02f,
  -1.85019121e-01f, 1.37565002e-01f, -6.78182393e-02f, 3.65138985e-02f, 5.68259321e-02f, -2.41170563e-02f, 1.05635516e-01f, 1.04325384e-01f, -1.17981799e-01f, 1.27816603e-01f,
  2.23307580e-01f, -8.07178766e-02f, 8.01026598e-02f, 2.88484828e-03f, -7.47250915e-02f, -1.78768083e-01f, -3.50513943e-02f, 1.21169470e-01f, 4.45301980e-02f, -1.28184885e-01f,
  6.90150931e-02f, -2.05613494e-01f, 3.04215085e-02f, 2.42186159e-01f, -1.58872515e-01f, 8.43664929e-02f, 2.16686423e-03f, -2.44536370e-01f, -1.03873402e-01f, -2.09553689e-01f,
  2.77875960e-01f, 6.38052123e-03f, -1.69480845e-01f, 2.57741213e-01f, -6.59147557e-03f, -1.98604777e-01f, -1.33157238e-01f, 1.33840889e-01f, 3.32448810e-01f, 7.27207065e-02f,
  -1.46642596e-01f, 4.41719331e-02f, -4.54167984e-02f, 6.61166683e-02f, 6.70893639e-02f, 4.16981168e-02f, -2.92089134e-02f, 3.29399593e-02f, 5.18816262e-02f, 7.25624934e-02f,
  1.72233030e-01f, 1.08449869e-01f, -3.58957142e-01f, -1.98639676e-01f, -3.28325659e-01f, 8.77968967e-02f, 3.25795978e-01f, 9.80063155e-02f, -4.35505241e-01f, -6.33398890e-02f,
  -9.40478668e-02f, 5.78979924e-02f, 1.04171500e-01f, 9.20533482e-03f, -1.52879402e-01f, -1.67566031e-01f, -1.25335261e-01f, -2.93609649e-01f, -6.74811676e-02f, 3.57012957e-01f,
  4.78150658e-02f, -1.04665972e-01f, 2.58583128e-01f, -1.62434191e-01f, -1.02931224e-01f, -3.03495407e-01f, -7.56913200e-02f, -9.46718752e-02f, -9.32708848e-03f, -9.57628414e-02f,
  3.73822525e-02f, -5.80028594e-02f, -8.06922242e-02f, -3.88714522e-02f, -1.11633375e-01f, 1.54833660e-01f, 2.06421725e-02f, -2.27166966e-01f, 2.85038680e-01f, -7.52129033e-02f,
  1.72651827e-01f, 4.39776145e-02f, 2.40717724e-01f, 2.35045761e-01f, -1.86606392e-01f, -3.93028051e-01f, 2.20720172e-01f, -2.76307076e-01f, -1.43213511e-01f, -1.58218190e-01f,
  1.71437785e-01f, -6.56941757e-02f, -2.55788386e-01f, 9.70706791e-02f, 1.58483833e-01f, 1.38867617e-01f, -2.70145833e-02f, 1.33457094e-01f, 4.82389443e-02f, 2.86618937e-02f,
  -1.12946115e-01f, 4.31601219e-02f, -1.90125201e-02f, 1.15918256e-01f, 3.54306810e-02f, -2.09961161e-02f, 3.50874990e-01f, 4.03797664e-02f, 1.04453459e-01f, 5.40712997e-02f,
  1.19144872e-01f, -6.82554692e-02f, 4.12321314e-02f, 5.99455312e-02f, 1.49410367e-01f, -2.84566381e-03f, -8.32426548e-02f, -2.10270524e-01f, 1.24146305e-01f, -2.41845641e-02f,
  -3.00911427e-01f, -1.89839564e-02f, -7.67207071e-02f, 2.57546097e-01f, -1.00077555e-01f, -4.44537327e-02f, -9.79177207e-02f, 4.54843678e-02f, -1.37688771e-01f, 8.63341838e-02f,
  1.36839777e-01f, -1.13491990e-01f, 3.50271389e-02f, 1.21042818e-01f, -1.94833845e-01f, -1.42629887e-03f, 8.37950781e-02f, -4.39484194e-02f, 1.85579985e-01f, 1.42116426e-02f,
  -1.11337639e-01f, 5.45243621e-02f, -1.73569605e-01f, 1.32793084e-01f, 1.87744536e-02f, -1.80388078e-01f, 8.10697004e-02f, 4.33722287e-02f, 2.59884179e-01f, 1.01068750e-01f,
  -2.53738135e-01f, 2.44393677e-01f, -1.68985482e-02f, 2.28858113e-01f, -5.85369132e-02f, 4.49060742e-03f, 1.55327275e-01f, -7.12548522e-03f, 1.67346016e-01f, -5.29721268e-02f,
  1.45233143e-02f, -7.95563310e-02f, -5.67971803e-02f, -8.00374057e-03f, 3.78319211e-02f, -4.72867414e-02f, -7.21906796e-02f, 7.27803409e-02f, -2.44588796e-02f, 1.44356089e-02f,
  -1.51179701e-01f, 1.05093487e-01f, 1.92511752e-01f, -1.25534356e-01f, -2.82379165e-02f, 3.49598238e-03f, 1.63537040e-01f, 2.58805156e-02f, -1.49351120e-01f, 6.22026771e-02f,
  3.71859819e-02f, -4.83534783e-02f, -1.42045289e-01f, 1.78606614e-01f, -1.13627046e-01f, 9.63321403e-02f, 5.37882410e-02f, -8.59619230e-02f, -1.43817216e-02f, 2.34506667e-01f,
  -9.72776711e-02f, 2.00569332e-01f, -1.77612871e-01f, -7.43166059e-02f, -1.93735749e-01f, -2.50751913e-01f, 1.71395555e-01f, 1.85689509e-01f, -1.46777779e-01f, -5.35611548e-02f,
  -8.98249894e-02f, -1.52541697e-01f, -1.88582446e-02f, -2.67004102e-01f, -2.68658608e-01f, -8.47249776e-02f, 5.86320870e-02f, 4.37106863e-02f, 2.12799758e-02f, 1.44886538e-01f,
  3.76918241e-02f, -2.47487962e-01f, 1.38479620e-02f, 3.14732753e-02f, 9.28726606e-03f, 7.78337419e-02f, -5.91339776e-03f, -2.03489587e-01f, -5.32300435e-02f, 2.31340155e-02f,
  -1.09328695e-01f, -1.35060340e-01f, 2.35070549e-02f, 2.38825772e-02f, 4.14669467e-03f, -4.89926105e-03f, 8.56518075e-02f, 2.19746605e-01f, 8.02500024e-02f, 1.26875430e-01f,
  -6.40320480e-02f, 1.72803506e-01f, 1.35333836e-01f, 2.70868301e-01f, 2.08788082e-01f, 4.23317514e-02f, 6.44344240e-02f, -1.00214183e-01f, 6.06018789e-02f, -8.85328278e-02f,
  -9.89864171e-02f, 2.53663331e-01f, 2.21837059e-01f, 9.64239091e-02f, 1.45893469e-01f, -4.46022041e-02f, 1.04249399e-02f, 7.77470693e-02f, -1.37922317e-01f, 1.27607659e-01f,
  1.45012941e-02f, -7.30817160e-03f, -4.21420205e-03f, -8.28347728e-02f, -1.22662187e-01f, -8.23362395e-02f, 1.01112358e-01f, -1.53248999e-02f, -5.68973683e-02f, -6.79960996e-02f,
  7.23988265e-02f, 4.93506668e-03f, -9.41896960e-02f, -8.59298632e-02f, 1.79111496e-01f, -7.23253936e-02f, -6.59347326e-02f, 7.35336319e-02f, -1.36403292e-01f, 3.09204888e-02f,
  -1.64703012e-01f, 3.71338092e-02f, 6.72641071e-03f, 7.29202805e-03f, -4.34516333e-02f, -4.27982733e-02f, 2.39925355e-01f, -1.34465724e-01f, -2.84363725e-03f, 1.13498747e-01f,
  -1.80516079e-01f, 1.48695409e-01f, 4.02806923e-02f, 4.38717566e-02f, 1.88951984e-01f, -1.71164069e-02f, -1.07688889e-01f, 1.02725677e-01f, 2.62082983e-02f, 3.62853259e-02f,
  -1.99339278e-02f, 3.37373540e-02f, -5.35408445e-02f, -4.10010442e-02f, -2.90435646e-02f, 4.75990288e-02f, 3.91425565e-02f, 9.70129147e-02f, -5.79359999e-04f, 1.54630383e-02f,
  1.01297602e-01f, -3.99814686e-03f, -9.02393237e-02f, 1.40572250e-01f, 1.66652992e-01f, 1.59855604e-01f, -4.54331301e-02f, -2.23066472e-03f, 2.08709314e-01f, 7.97861665e-02f,
  1.32072970e-01f, 1.06032677e-01f, -1.84644163e-01f, 1.67520270e-01f, -1.42603382e-01f, -6.04946762e-02f, -1.64784238e-01f, -8.98652226e-02f, -1.39773324e-01f, -1.11171357e-01f,
  -1.87404871e-01f, 2.35207900e-01f, 1.16651177e-01f, 7.95774385e-02f, 5.34587819e-03f, 6.09858595e-02f, -1.15353540e-01f, 2.41308343e-02f, 2.50453383e-01f, 1.63505554e-01f,
  1.06754474e-01f, 1.74884304e-01f, 5.09806648e-02f, -7.80582353e-02f, 4.54043932e-02f, -2.63956845e-01f, 2.19342768e-01f, -3.18194628e-02f, 2.18688603e-02f, 2.70694215e-02f,
  1.70676097e-01f, 1.44615278e-01f, 8.21628198e-02f, 3.27693261e-02f, 1.89203754e-01f, 1.82374299e-01f, 1.94894359e-01f, -1.01719506e-01f, 1.25053912e-01f, -8.73281732e-02f,
  -2.67656930e-02f, -1.01721637e-01f, -6.90509379e-02f, 1.78954862e-02f, 1.14096783e-01f, 8.52764547e-02f, 1.67063043e-01f, 7.70076439e-02f, 1.12884909e-01f, 1.30623400e-01f,
  2.66756415e-01f, -1.60365775e-01f, 3.06566637e-02f, 1.06823578e-01f, -7.35981017e-02f, -2.41882019e-02f, 1.96809322e-01f, 8.65164027e-02f, 2.66449042e-02f, -1.14794143e-01f,
  1.34356499e-01f, -5.48451021e-02f, -1.13712765e-01f, -7.95773491e-02f, -1.41986847e-01f, 5.54582663e-02f, 8.20474476e-02f, -1.50349900e-01f, 1.69126555e-01f, 2.19958067e-01f,
  1.85836494e-01f, -1.55387610e-01f, 1.29840687e-01f, -1.27690241e-01f, 2.93494612e-01f, -1.89444095e-01f, 1.04059046e-02f, -3.13934349e-02f, -2.02654246e-02f, 1.76273525e-01f,
  1.88302025e-01f, 3.65916729e-01f, -3.44661415e-01f, 4.99047106e-03f, 2.11682513e-01f, -1.12395369e-01f, 1.11441493e-01f, 1.24614745e-01f, 3.25110495e-01f, 3.43146473e-01f,
  -1.22432157e-01f, 5.79209365e-02f, 1.64770469e-01f, 8.54208842e-02f, -6.78535625e-02f, 1.45985559e-01f, -4.71150354e-02f, 2.32508868e-01f, -2.91418821e-01f, -4.28276837e-01f,
  -1.12414613e-01f, 1.24616124e-01f, 2.57557303e-01f, 1.89308390e-01f, 1.43120572e-01f, 1.45432994e-01f, 8.86126086e-02f, -1.38852308e-02f, 4.07542735e-02f, 9.47213918e-02f,
  2.32356116e-01f, 2.45433878e-02f, 9.19747725e-02f, 1.25999108e-01f, -1.29514799e-01f, 2.24812806e-01f, 2.60156989e-01f, 3.09430808e-02f, 2.22422592e-02f, -1.44618869e-01f,
  1.39969870e-01f, -1.61846101e-01f, -2.08777294e-01f, 1.50226027e-01f, -1.94595009e-01f, 2.54826546e-01f, 5.60515095e-04f, -2.11586710e-02f, -2.88317185e-02f, -1.21773360e-02f,
  1.43940359e-01f, 2.44971827e-01f, 2.83146232e-01f, -1.76080689e-01f, 1.98724449e-01f, -9.05852485e-03f, -1.05380557e-01f, -1.42093748e-01f, 2.89051384e-01f, -8.11036304e-02f,
  9.57480967e-02f, 2.84783721e-01f, -2.66959239e-02f, 4.68373410e-02f, -4.42684926e-02f, 1.69261977e-01f, -8.63147378e-02f, 7.66449273e-02f, -1.57614812e-01f, -2.23237947e-01f,
  4.79816226e-03f, 7.81167597e-02f, -4.85506766e-02f, 1.57876611e-01f, 5.89839257e-02f, -1.22005671e-01f, -1.42736509e-01f, -1.51582628e-01f, 2.43860617e-01f, -1.06780946e-01f,
  3.69824544e-02f, 2.11660378e-02f, -5.74779622e-02f, -1.10218585e-01f, -2.78970972e-02f, 1.88904151e-01f, 2.95096844e-01f, -1.62216406e-02f, 9.05570015e-02f, 1.90877914e-01f,
  -1.07281290e-01f, -2.74103116e-02f, 1.00302562e-01f, 2.31968805e-01f, -5.37895188e-02f, 7.38576949e-02f, 4.90334397e-03f, 1.06216595e-02f, -1.54755386e-02f, -5.71703492e-03f,
  2.83634581e-04f, -1.30133227e-01f, -1.25790723e-02f, 1.63392991e-01f, 1.28975715e-02f, -3.50747630e-02f, -3.49271782e-02f, 1.64851099e-01f, 2.51098543e-01f, -1.26959488e-01f,
  -1.67858098e-02f, -1.84039563e-01f, 2.20028788e-01f, -1.18161673e-02f, -2.30350152e-01f, -1.26109615e-01f, -2.31400520e-01f, 2.24490181e-01f, 1.23648932e-02f, -9.08203721e-02f,
  8.84977169e-03f, 1.12891704e-01f, -1.93467975e-01f, 1.08168267e-01f, 2.00175896e-01f, -1.15458250e-01f, 5.65177947e-02f, 1.09783635e-01f, -6.24134168e-02f, 2.08275225e-02f,
  1.96365714e-01f, 9.34600234e-02f, 1.37825027e-01f, 2.28515923e-01f, 5.32134622e-02f, -1.20909147e-01f, -5.07474598e-03f, 3.65520045e-02f, -5.38108945e-02f, -4.85407300e-02f,
  6.00015409e-02f, -9.35680121e-02f, 1.17331028e-01f, 1.87628374e-01f, -2.41270304e-01f, -2.03134660e-02f, -3.97953950e-02f, 2.10714236e-01f, -2.91178711e-02f, -2.02792004e-01f,
  2.39115357e-01f, 3.13064270e-02f, 1.11068353e-01f, 5.43398373e-02f, 1.46639004e-01f, 6.01672009e-02f, 9.01433304e-02f, 1.25337079e-01f, 2.40920112e-02f, 1.16964653e-01f,
  2.18608454e-01f, 1.70609266e-01f, -4.80017737e-02f, 1.67732283e-01f, -2.00716600e-01f, -3.07520270e-01f, 1.61229866e-03f, 1.84248850e-01f, -2.27114782e-01f, -7.03045577e-02f,
  1.96767136e-01f, -2.37077639e-01f, 5.28746732e-02f, -3.71723741e-01f, -1.38048500e-01f, 3.95843387e-02f, 7.99006671e-02f, 2.69303042e-02f, 3.65319371e-01f, -1.91025138e-01f,
  2.71364376e-02f, 1.51535168e-01f, 4.47158873e-01f, -1.08435579e-01f, 3.65659833e-01f, 1.55043244e-01f, 2.23208666e-01f, -1.08622611e-02f, 7.40873814e-02f, -1.03316829e-01f,
  1.77869033e-02f, -1.65254533e-01f, 2.45990977e-01f, 6.18722215e-02f, -3.37267131e-01f, 8.52634236e-02f, 3.11211646e-02f, -2.78766360e-02f, 2.22670287e-02f, 1.01334639e-01f,
  -3.65577191e-01f, 9.79681406e-03f, -2.28215933e-01f, -1.77282408e-01f, -4.96233851e-02f, 1.08610325e-01f, -1.99835137e-01f, -3.36450487e-02f, -9.84009430e-02f, -1.14198573e-01f,
  1.43754154e-01f, -2.27947198e-02f, -1.87265068e-01f, -3.83624830e-03f, -4.34917472e-02f, 1.13117702e-01f, 1.24953970e-01f, 4.45702747e-02f, -1.07607739e-02f, 4.18527424e-02f,
  1.93912953e-01f, 1.86301127e-01f, -1.53020039e-01f, 3.51991542e-02f, -1.03511596e-02f, 1.47860393e-01f, 7.08462000e-02f, 1.08151294e-01f, 1.08820148e-01f, 4.11430895e-02f,
  6.14760816e-02f, 1.11882769e-01f, 5.37422672e-03f, -2.07602635e-01f, -1.05943121e-01f, 2.66816765e-01f, 1.68837517e-01f, -5.60170412e-02f, -2.47411486e-02f, -1.22640237e-01f,
  9.10530612e-02f, 1.06629893e-01f, -2.67938524e-01f, -1.03818737e-01f, -8.41812566e-02f, 2.59525418e-01f, -2.47745395e-01f, -4.51984778e-02f, 7.97185972e-02f, 2.61823554e-02f,
  -2.02623844e-01f, 5.45017757e-02f, 8.87713656e-02f, -1.08177789e-01f, -5.53449392e-02f, 7.55442902e-02f, -1.16512418e-01f, -1.59348063e-02f, 1.79605395e-01f, 1.16666526e-01f,
  1.83218017e-01f, 1.68438748e-01f, 1.11361943e-01f, 1.88769192e-01f, -2.23022148e-01f, 4.39670160e-02f, 1.61861926e-01f, -1.12701952e-01f, -3.76901329e-02f, -8.04444551e-02f,
  2.38678996e-02f, 9.98682529e-02f, -2.09934011e-01f, 1.67000219e-01f, -1.78128913e-01f, 2.30738372e-01f, -2.63363346e-02f, 1.38208702e-01f, -1.21586323e-02f, -4.83844019e-02f,
  1.10752016e-01f, -2.10683476e-02f, -1.54444158e-01f, 2.06582341e-02f, 8.80990401e-02f, -2.55384259e-02f, -4.63218652e-02f, -7.71202520e-02f, -2.34846165e-03f, -7.77484430e-03f,
  2.91427840e-02f, -5.79265617e-02f, 1.01700366e-01f, -2.08764315e-01f, 2.58142333e-02f, 5.75083978e-02f, -1.78527713e-01f, -1.30541325e-02f, -5.62197939e-02f, 7.22812563e-02f,
  1.85803339e-01f, -1.69027224e-01f, 1.97875619e-01f, -5.50509021e-02f, 1.44150689e-01f, 4.93896902e-02f, -1.71483234e-01f, -1.95817009e-01f, 9.92927980e-03f, -1.39271095e-01f,
  -1.35685727e-01f, -1.70777857e-01f, -1.86241046e-01f, -6.84089437e-02f, -1.25011414e-01f, 1.57396588e-02f, 4.82323915e-02f, 1.53033137e-01f, -1.08497046e-01f, 6.13279156e-02f,
  -1.18031964e-01f, -1.14531249e-01f, 3.15697551e-01f, 4.17771004e-02f, -1.62234921e-02f, 1.43690288e-01f, 2.47843415e-01f, -6.07683398e-02f, -4.28214259e-02f, -1.01888768e-01f,
  4.88476902e-02f, -5.23847416e-02f, -1.31999701e-01f, 1.60179357e-03f, -2.61912644e-02f, 1.72259137e-01f, -4.36928542e-03f, 5.66722127e-03f, 4.27443301e-03f, 3.35757822e-01f,
  -1.12564720e-01f, -7.51727223e-02f, -1.24133587e-01f, -9.05471966e-02f, -3.38145904e-02f, -6.25134557e-02f, 2.30730802e-01f, 1.23025507e-01f, 9.40224901e-02f, 5.36305383e-02f,
  2.04413101e-01f, -3.91484983e-02f, 5.77512421e-02f, 1.35433331e-01f, -6.83342293e-02f, 2.23583058e-02f, 2.09878251e-01f, 2.00114429e-01f, -3.45563889e-02f, -1.43654272e-01f,
  1.75003007e-01f, -3.83578800e-02f, -1.16730042e-01f, 1.06026031e-01f, -2.03348529e-02f, 9.28164721e-02f, 6.10695183e-02f, -1.91988423e-02f, -1.40837058e-01f, 1.38422206e-01f,
  1.50852120e-02f, 1.81131631e-01f, 2.74948955e-01f, 8.90138596e-02f, -5.63384071e-02f, 1.86072305e-01f, -1.72537155e-02f, 2.08434060e-01f, -3.37464400e-02f, 2.53558811e-02f,
  -4.45903204e-02f, 1.22621626e-01f, 1.51449628e-02f, -2.01714095e-02f, -2.38948300e-01f, 1.81074321e-01f, 2.01357648e-01f, -4.03188989e-02f, 1.68966189e-01f, -2.29375124e-01f,
  1.32845147e-02f, 3.18577021e-01f, 1.64680909e-02f, 2.15136766e-01f, 1.09808959e-01f, -1.27987981e-01f, 1.46998823e-01f, 8.63175839e-02f, 2.74740398e-01f, 1.66373730e-01f,
  -2.95649972e-02f, 3.75620216e-01f, -6.44553825e-02f, -1.14671178e-01f, 1.46982685e-01f, 1.45318955e-01f, 1.25709862e-01f, 3.10945604e-02f, -5.63693307e-02f, 1.04292586e-01f,
  1.08526997e-01f, 4.27083159e-03f, 2.87218136e-03f, -3.66402082e-02f, -8.22440255e-03f, -7.15175271e-02f, -4.55289707e-02f, -1.22632556e-01f, 7.99644440e-02f, 1.07585043e-01f,
  -3.03701401e-01f, -1.14121653e-01f, 2.11527124e-02f, -6.57451227e-02f, -9.15349871e-02f, 6.23231642e-02f, 2.49334611e-02f, -7.75656179e-02f, 7.64944181e-02f, -1.13942184e-01f,
  -8.42239410e-02f, -1.30074397e-01f, 7.15321749e-02f, -6.24466967e-03f, 1.30835041e-01f, 1.35182306e-01f, -9.57880691e-02f, 9.94561613e-02f, 4.94012162e-02f, 2.59193182e-01f,
  2.82366157e-01f, 1.39097080e-01f, -1.24684393e-01f, 8.16902444e-02f, 1.44803986e-01f, -4.35022339e-02f, 1.06949545e-01f, 1.77136064e-01f, -2.48743325e-01f, 8.40840340e-02f,
  -1.81976795e-01f, 1.51844561e-01f, 1.49688289e-01f, -7.76986405e-02f, 8.81277844e-02f, -1.65758431e-01f, 2.95515545e-02f, 1.38940126e-01f, 1.50106162e-01f, 1.56680003e-01f,
  -8.43775123e-02f, 2.53937870e-01f, -2.13732153e-01f, -4.57800105e-02f, -4.54893187e-02f, -7.54930899e-02f, -5.76295750e-03f, -8.11679065e-02f, 3.23751085e-02f, 3.78193781e-02f,
  -7.76632130e-02f, 3.77656072e-02f, 4.21261080e-02f, -5.40144257e-02f, 1.12064824e-01f, -6.97271749e-02f, -1.83690097e-02f, 2.81797852e-02f, 1.52508020e-01f, 6.67824894e-02f,
  2.51328409e-01f, 9.42064896e-02f, -5.17879911e-02f, -7.29384366e-03f, -9.89139900e-02f, 3.13395225e-02f, -1.36848046e-02f, -4.23677787e-02f, -8.61457661e-02f, -2.43354496e-03f,
  -1.15780756e-01f, -1.40084192e-01f, 1.10556684e-01f, 8.28215480e-03f, 1.34717703e-01f, 5.62121458e-02f, 1.97455838e-01f, -2.48344056e-02f, 2.89983749e-01f, 1.64405376e-01f,
  1.69791758e-01f, 7.34903514e-02f, 1.93668172e-01f, 1.04308516e-01f, 1.03986062e-01f, 1.30328327e-01f, -1.63168069e-02f, 2.11785331e-01f, 1.14029273e-02f, 1.91533417e-01f,
  -8.70217159e-02f, 3.54378857e-02f, -1.36617020e-01f, -3.40998406e-04f, 7.58461133e-02f, 2.38294885e-01f, -8.21411237e-02f, 2.77670100e-02f, 1.57991529e-01f, -1.79461390e-01f,
  -2.89606184e-01f, -1.01801015e-01f, 6.06872663e-02f, -8.83903727e-02f, 7.25213513e-02f, 1.90285921e-01f, 5.36345430e-02f, -7.54048005e-02f, 6.43533766e-02f, -1.97851971e-01f,
  2.23002225e-01f, 8.54996294e-02f, 1.57156870e-01f, 1.27067238e-01f, 1.63896158e-02f, 1.80556495e-02f, 1.04930550e-02f, 4.95224595e-02f, -4.32855226e-02f, 9.06575620e-02f,
  -2.03941837e-02f, -8.36422592e-02f, 1.00805871e-01f, -1.16582818e-01f, 1.00981528e-02f, 1.78536758e-01f, 4.28850055e-02f, 5.64797670e-02f, -9.64116082e-02f, 4.49671112e-02f,
  -9.58858058e-02f, -1.21783391e-01f, 9.66115966e-02f, -1.87828764e-02f, -1.77601099e-01f, -1.54969931e-01f, -6.82054646e-03f, -4.58920654e-03f, 1.29697949e-01f, -4.04343084e-02f,
  1.11605413e-01f, 1.05662271e-01f, -4.72803973e-02f, 1.00046612e-01f, -3.48978713e-02f, -1.27612099e-01f, 1.44143522e-01f, 1.97337344e-01f, 1.51706487e-01f, 3.35934125e-02f,
  1.23633761e-02f, 4.66068834e-02f, 6.98117465e-02f, 1.33104756e-01f, 4.31218594e-02f, 4.87552695e-02f, -2.24021047e-01f, 7.67021403e-02f, 6.03632741e-02f, 2.36728370e-01f,
  3.31502110e-02f, -9.82191935e-02f, 3.33881308e-03f, -7.80812129e-02f, -2.46731248e-02f, 1.96051821e-01f, -5.48173524e-02f, 4.37812358e-02f, -2.03292742e-02f, 2.73797512e-01f,
  -4.05125841e-02f, -1.98312253e-01f, 6.94205165e-02f, -7.90910199e-02f, -8.37176666e-02f, 4.39885706e-02f, 1.87824294e-01f, 9.48981643e-02f, -2.10212186e-01f, -2.32964251e-02f
};

// L1_fan_Bp_bar (Shape: 1 x 40)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 40;
const float L1_fan_Bp_bar_data[] = {
  1.10295899e-01f, 1.23841716e-02f, -6.73822984e-02f, -7.45048700e-03f, -3.94113064e-02f, 1.04880460e-01f, 1.18333392e-01f, -2.66985316e-02f, 1.74875364e-01f, 1.02137342e-01f,
  3.66904996e-02f, 7.10670277e-02f, 1.03228159e-01f, 7.37172216e-02f, 2.55137496e-02f, -2.27979501e-03f, -1.66564152e-01f, 2.07975447e-01f, 4.71703149e-03f, 1.27161294e-01f,
  -4.50526588e-02f, -5.74856475e-02f, -6.38226420e-02f, 1.98023543e-01f, 5.05530499e-02f, -5.50091229e-02f, 2.05787197e-01f, 2.29553767e-02f, -3.75742428e-02f, 6.89916238e-02f,
  1.26598716e-01f, 1.05365794e-02f, 1.67897701e-01f, 3.45124379e-02f, 1.00114122e-01f, 1.10509433e-01f, 2.09886983e-01f, -1.65109858e-01f, 1.68623984e-01f, 7.59697929e-02f
};

// L2_fan_Wp (Shape: 12 x 64)
const int L2_fan_Wp_rows = 12;
const int L2_fan_Wp_cols = 64;
const float L2_fan_Wp_data[] = {
  -1.44410491e-01f, -2.41012927e-02f, -2.51910180e-01f, -1.27973944e-01f, -1.85309555e-02f, 7.05620050e-02f, 6.70791417e-02f, -4.30489555e-02f, -1.64112777e-01f, -1.36795208e-01f,
  -1.69661075e-01f, -1.91379171e-02f, 6.51142672e-02f, -1.48899332e-02f, -1.97347313e-01f, 1.88505188e-01f, 4.13145162e-02f, -1.17480256e-01f, 1.13163963e-01f, 5.40208770e-04f,
  1.24805525e-01f, -1.53584987e-01f, 5.17056659e-02f, 1.70789376e-01f, 2.13173181e-02f, 1.42912179e-01f, 6.61330149e-02f, -9.00519416e-02f, -1.15849458e-01f, -5.80218583e-02f,
  1.03614561e-01f, 2.03745924e-02f, -7.57893920e-02f, 3.15838270e-02f, -2.24787578e-01f, 1.02607533e-01f, -5.36804534e-02f, 1.10177815e-01f, 8.56909826e-02f, -1.02545125e-02f,
  8.43086615e-02f, -1.73332840e-01f, -7.82787725e-02f, 1.66191645e-02f, 1.12049766e-01f, 5.44622121e-03f, 6.27935529e-02f, 1.02941960e-01f, -2.78381824e-01f, 3.05833649e-02f,
  -1.70427576e-01f, 3.04511748e-02f, -1.36581093e-01f, 1.75641268e-01f, -1.16064675e-01f, 3.25168744e-02f, -1.37519598e-01f, -3.28559764e-02f, -1.36356995e-01f, -1.31133899e-01f,
  -6.53950721e-02f, 1.85801134e-01f, 1.73293635e-01f, 8.51595923e-02f, 1.73523258e-02f, 1.76958337e-01f, 2.26730630e-01f, 6.69749156e-02f, 2.46891100e-02f, -2.16035455e-01f,
  1.44319221e-01f, 1.04267068e-01f, 1.59007832e-02f, 2.22903624e-01f, -5.83885610e-02f, -6.44879863e-02f, 4.68315482e-02f, -9.28139016e-02f, -1.39101654e-01f, 9.31177884e-02f,
  -4.33872789e-02f, 3.96267623e-02f, -3.09768077e-02f, -3.41533452e-01f, 3.36595833e-01f, -4.14199010e-02f, 1.59041792e-01f, -1.81404606e-01f, 5.32623678e-02f, 9.68125165e-02f,
  1.15064019e-02f, -7.26827160e-02f, 1.28313139e-01f, -4.53388272e-03f, 1.22059919e-01f, 2.78520305e-02f, 6.96887374e-02f, -6.65879399e-02f, 1.21412784e-01f, 1.63435861e-01f,
  3.70990671e-02f, 1.10689841e-01f, -5.81056140e-02f, 2.17146277e-02f, 1.17866900e-02f, 1.74850091e-01f, -7.31172189e-02f, 1.03928976e-01f, -1.07621662e-01f, -2.60609329e-01f,
  9.30979475e-02f, -1.13377251e-01f, -2.98940577e-02f, 5.10597751e-02f, -7.97388479e-02f, -5.81650883e-02f, -6.84261099e-02f, -1.34792253e-01f, -8.97092968e-02f, 5.30730002e-02f,
  -1.25546649e-01f, 2.39051804e-01f, 4.70281690e-02f, -1.57919452e-01f, -1.42049789e-01f, -6.10222807e-03f, 5.34266122e-02f, -1.43819690e-01f, 6.48516864e-02f, 6.50612339e-02f,
  1.03309520e-01f, 7.32955858e-02f, 5.74288666e-02f, -1.17242903e-01f, -6.30883574e-02f, 1.75700232e-01f, -4.91353758e-02f, -2.15256587e-01f, -1.54850200e-01f, 1.00336947e-01f,
  7.24153873e-03f, -4.72036824e-02f, -1.67429477e-01f, 1.16311282e-01f, -7.17285946e-02f, -2.68901139e-01f, 9.48571041e-02f, -1.85019657e-01f, -3.23092118e-02f, -7.45818317e-02f,
  -2.35653501e-02f, 2.49141574e-01f, -1.90001410e-02f, 8.99251178e-02f, -5.21903858e-03f, -1.35177046e-01f, 1.14299081e-01f, -1.43986762e-01f, 9.87203047e-02f, -1.42358571e-01f,
  -1.52115896e-01f, -2.24148463e-02f, 6.04484454e-02f, 1.19485237e-01f, -5.88462353e-02f, 1.60342127e-01f, 1.05209000e-01f, 2.54887789e-02f, 1.31942213e-01f, 3.49652544e-02f,
  -6.76432699e-02f, -2.09752440e-01f, 3.93610727e-03f, 9.77727026e-02f, 9.46162865e-02f, -9.85907242e-02f, -1.25720158e-01f, -3.49137895e-02f, -1.50634721e-01f, 1.88279152e-01f,
  -4.52822186e-02f, 1.25206903e-01f, -8.08406696e-02f, -3.43135595e-02f, -1.28340304e-01f, -6.29539713e-02f, -1.43931404e-01f, -3.08906697e-02f, 7.87940621e-02f, 2.70496886e-02f,
  1.35389239e-01f, -1.82438530e-02f, 7.32881501e-02f, 4.39929329e-02f, 7.84244910e-02f, 2.00454071e-01f, 3.23435254e-02f, 3.13929543e-02f, 7.94337168e-02f, 3.06771565e-02f,
  5.89738460e-03f, -3.95191908e-02f, 1.05329461e-01f, -1.76810697e-02f, -7.62513727e-02f, 7.91659802e-02f, 3.22891325e-02f, 1.22485749e-01f, -4.40298617e-02f, -4.16123457e-02f,
  -8.15172568e-02f, 1.82616055e-01f, 1.53347135e-01f, -5.10992333e-02f, -6.93248212e-02f, -3.21259573e-02f, 1.49472132e-01f, 1.34908155e-01f, 7.91708305e-02f, -1.84111018e-02f,
  -6.83567524e-02f, -1.42343178e-01f, 6.75977468e-02f, -1.18139163e-02f, -1.04182169e-01f, 1.28633350e-01f, -3.48826423e-02f, 2.00202316e-01f, -1.60489246e-01f, -8.95833597e-02f,
  -1.51668176e-01f, -2.07046270e-01f, -2.00212091e-01f, -6.96181208e-02f, -1.37100056e-01f, -1.91660859e-02f, 8.88618529e-02f, 8.66606832e-02f, -1.34579152e-01f, -1.20236322e-01f,
  -1.60811707e-01f, 9.50523168e-02f, 5.87663502e-02f, -1.78701028e-01f, 6.28298670e-02f, 2.76557934e-02f, -7.32113644e-02f, 6.60634115e-02f, 6.43803850e-02f, 1.88320592e-01f,
  1.89772055e-01f, 2.26492479e-01f, -9.44105349e-03f, -1.86336432e-02f, 1.96207881e-01f, 5.31810988e-03f, -4.52517904e-02f, -2.13581845e-02f, -1.29383326e-01f, 2.12747939e-02f,
  -2.77798735e-02f, 5.40084764e-02f, -3.19027971e-03f, 1.13904938e-01f, 4.98924516e-02f, -3.57701518e-02f, 1.77207366e-01f, -1.75382465e-01f, -1.50212005e-01f, 1.15553237e-01f,
  -1.85802326e-01f, -2.37829480e-02f, 1.05444349e-01f, 1.75255582e-01f, -3.01738143e-01f, -2.39229679e-01f, 2.78127700e-01f, -1.67571884e-02f, -1.99450180e-01f, -2.23734438e-01f,
  5.39824292e-02f, -7.09896311e-02f, -6.88377619e-02f, -1.35962486e-01f, -4.14509438e-02f, -3.87709700e-02f, -4.23388965e-02f, 1.19293090e-02f, -8.47267956e-02f, -6.24680556e-02f,
  1.25521690e-01f, -8.51526186e-02f, 3.06289718e-02f, -1.60283223e-01f, -3.51422913e-02f, -6.77096248e-02f, -2.02936418e-02f, 3.23619217e-01f, 1.06725276e-01f, 1.12551250e-01f,
  -9.35064331e-02f, -1.22680902e-01f, 1.35107428e-01f, -2.09407285e-01f, 9.13954675e-02f, 4.42833938e-02f, 1.17603503e-01f, 5.60331717e-02f, 4.59951833e-02f, -1.75196096e-01f,
  5.47779091e-02f, 2.23260769e-03f, -1.32196601e-02f, -2.49188513e-01f, 1.34345502e-01f, -7.93433841e-03f, 1.24537647e-01f, -1.83878526e-01f, -1.46089569e-01f, 6.88000843e-02f,
  1.45462215e-01f, 8.42021182e-02f, 1.84218183e-01f, -4.20554504e-02f, 4.15367298e-02f, 1.94560856e-01f, 1.90050736e-01f, -1.21193834e-01f, -1.44785106e-01f, 2.10236236e-01f,
  1.03939794e-01f, 3.18429582e-02f, -1.43427595e-01f, -7.52549842e-02f, 9.97486562e-02f, 6.80257529e-02f, 1.21017531e-01f, 8.05005953e-02f, 2.31301144e-01f, -1.71426117e-01f,
  -3.96689475e-02f, 8.77645239e-02f, 8.19597617e-02f, -1.98776364e-01f, -1.17705874e-01f, -9.95097458e-02f, -1.15721524e-01f, 1.12754293e-01f, 2.54766885e-02f, 1.93581164e-01f,
  1.75190523e-01f, -6.80203587e-02f, 2.16731414e-01f, 1.03232190e-01f, 1.14222728e-01f, 2.19876990e-02f, 2.33866498e-02f, -1.15377888e-01f, -2.08933979e-01f, 1.26629233e-01f,
  -5.30006327e-02f, 1.02019548e-01f, 5.67444637e-02f, 8.44792724e-02f, -1.21617913e-01f, -1.20627753e-01f, -4.14748453e-02f, 9.83171538e-02f, 1.88030168e-01f, -1.71939015e-01f,
  3.21506821e-02f, -4.60834801e-02f, 2.98973415e-02f, 4.68539782e-02f, 1.81018934e-01f, -7.05886483e-02f, 6.84862956e-02f, -3.89073901e-02f, -1.50781805e-02f, -1.61735807e-02f,
  -1.06687667e-02f, -1.61127329e-01f, -1.24551147e-01f, -1.85049117e-01f, 3.04986294e-02f, -6.97772130e-02f, -1.38674080e-01f, -2.18471989e-01f, -1.66941166e-01f, -5.65978400e-02f,
  2.42123261e-01f, -1.81811973e-01f, -3.07895485e-02f, -1.15515897e-02f, -1.59330643e-03f, -5.34666590e-02f, 1.46882519e-01f, 1.03155874e-01f, -1.53969591e-02f, -4.92019206e-02f,
  2.78726872e-02f, 6.47143498e-02f, 9.00213793e-02f, 1.55973181e-01f, -3.21019083e-01f, -6.62383810e-02f, -7.27338046e-02f, 7.33279362e-02f, -2.46111071e-03f, -1.32069811e-01f,
  -1.43820385e-03f, -1.58628356e-02f, -3.03918812e-02f, 1.85395658e-01f, -1.72820538e-01f, 7.17039779e-02f, -9.29495692e-03f, -4.51009199e-02f, 2.52124339e-01f, -1.56146556e-01f,
  -1.54203763e-02f, -7.01837614e-02f, 1.03613891e-01f, -3.58274765e-02f, -1.52118817e-01f, 9.73570347e-02f, 9.84173268e-02f, 2.30336234e-01f, -1.14326909e-01f, -4.04159538e-02f,
  1.08839460e-01f, 1.65839866e-01f, 2.69410342e-01f, -1.04589224e-01f, 1.01747215e-01f, 1.99963525e-02f, -8.33905861e-03f, -2.02632602e-02f, -5.90669364e-02f, -4.54126708e-02f,
  2.72149611e-02f, 1.17851719e-01f, 1.58092722e-01f, 1.21364385e-01f, 1.57380372e-01f, 1.35008339e-02f, -6.84794709e-02f, -3.06812283e-02f, 1.77935474e-02f, -6.81728274e-02f,
  -1.11272909e-01f, 2.32256576e-01f, 8.42929929e-02f, -2.49261662e-01f, 9.97756124e-02f, 2.96602398e-01f, 3.97336707e-02f, 1.20908454e-01f, 1.46549314e-01f, -4.83613461e-02f,
  -9.32790115e-02f, 2.34021768e-01f, -9.67435688e-02f, -1.34137928e-01f, -1.44879311e-01f, 9.12683755e-02f, -1.28489152e-01f, -2.63750479e-02f, 1.91825584e-01f, -9.48159546e-02f,
  -9.87840518e-02f, 4.67520468e-02f, 3.08598369e-01f, -1.21631779e-01f, 1.39631614e-01f, -5.31365722e-02f, -4.54644933e-02f, 7.84153398e-03f, 1.50998402e-02f, 2.08749548e-02f,
  -7.31108189e-02f, -8.20378214e-03f, -1.42937806e-02f, -1.06126957e-01f, 1.12116560e-02f, -2.48820439e-01f, -5.81025295e-02f, -2.10204065e-01f, -2.64147490e-01f, 1.25622511e-01f,
  -1.84200689e-01f, 1.74557120e-01f, 7.41696283e-02f, 5.14057614e-02f, 2.47905463e-01f, -8.10320750e-02f, -3.44677493e-02f, 1.01734087e-01f, 1.02332301e-01f, 2.00247355e-02f,
  -9.71442834e-03f, 1.93214137e-02f, 6.32665008e-02f, 1.22238025e-01f, 9.75956097e-02f, -1.71488449e-01f, 4.31048051e-02f, 1.82868987e-01f, 2.31597610e-02f, -3.18561755e-02f,
  -1.36344448e-01f, -5.28960340e-02f, -2.78160423e-02f, -5.72198257e-02f, 3.36462259e-02f, 3.49345729e-02f, -8.05741474e-02f, -1.66263580e-01f, 4.03958820e-02f, -5.24867401e-02f,
  -1.26835331e-01f, -2.62561202e-01f, -9.88881961e-02f, 9.21196118e-02f, -3.10145348e-01f, -1.57893389e-01f, -1.26018137e-01f, 2.00850759e-02f, -1.57384351e-01f, -1.98593110e-01f,
  -2.27815270e-01f, -2.49988008e-02f, 3.32855672e-01f, 7.97953904e-02f, 2.30589136e-01f, -3.26653957e-01f, 1.32657304e-01f, -5.49416766e-02f, 3.59892473e-02f, 2.20093414e-01f,
  1.59014076e-01f, -1.27384467e-02f, 5.54109253e-02f, -1.43466145e-01f, -1.11432606e-03f, -1.24197684e-01f, 2.75948346e-01f, -3.57389376e-02f, 1.07360892e-02f, 7.32268915e-02f,
  1.93852842e-01f, 4.12579998e-02f, 2.78191585e-02f, 2.23855034e-01f, -1.08559705e-01f, 8.74075890e-02f, -8.04401860e-02f, 2.52013206e-02f, 4.79578152e-02f, -3.43503393e-02f,
  -1.05642118e-01f, 4.42184031e-01f, 3.63834426e-02f, 1.75657406e-01f, -1.57623649e-01f, 8.51559415e-02f, 1.82363898e-01f, -1.36500314e-01f, -1.68371975e-01f, -2.61378378e-01f,
  -7.66020417e-02f, -2.57940620e-01f, 3.25547755e-02f, 2.74285078e-01f, -9.97349694e-02f, 8.50837827e-02f, -4.22065854e-02f, 1.39382839e-01f, 8.31037462e-02f, 1.99325949e-01f,
  6.12950213e-02f, -1.92836091e-01f, -9.64525267e-02f, 1.45724624e-01f, 5.66728935e-02f, -1.81069702e-01f, 2.68849432e-02f, 7.12420568e-02f, -7.04523101e-02f, -8.64161327e-02f,
  -5.85076250e-02f, -2.13367064e-02f, -9.36271474e-02f, 1.14655279e-01f, 1.07241049e-01f, 1.10969000e-01f, 4.26568210e-01f, -1.48625709e-02f, 2.86000371e-01f, -1.66738883e-01f,
  8.08882788e-02f, 7.21504912e-02f, 6.66312575e-02f, 1.72241684e-03f, 1.00363247e-01f, -2.05283403e-01f, 5.46882078e-02f, -3.78967030e-03f, 2.76272986e-02f, -1.86552510e-01f,
  -1.00607596e-01f, 6.71915710e-02f, -5.95277883e-02f, 4.80682738e-02f, 1.05920658e-01f, -1.22059353e-01f, 2.17209414e-01f, 2.93888468e-02f, -1.94218367e-01f, 3.82271931e-02f,
  -7.92289451e-02f, -1.27887711e-01f, 2.53619757e-02f, -2.36962214e-02f, -2.70671248e-01f, 1.42416880e-01f, -2.63318103e-02f, -3.25809866e-02f, -1.52622432e-01f, -1.64995473e-02f,
  -5.15388474e-02f, -2.04718962e-01f, -3.86484480e-03f, -1.50990877e-02f, -1.67478383e-01f, 5.63624166e-02f, -5.32066217e-03f, 9.41820443e-02f, 5.34031354e-02f, 1.98656041e-02f,
  -1.03785641e-01f, -2.87198611e-02f, -4.15965430e-02f, -1.48465514e-01f, -2.51405351e-02f, 2.96411306e-01f, -2.97312319e-01f, -2.72654772e-01f, 9.52661857e-02f, -1.69800654e-01f,
  -6.93869516e-02f, -1.72897831e-01f, 2.46330164e-03f, -1.91395849e-01f, 2.73453891e-01f, -4.19318676e-02f, 1.93639979e-01f, 2.65019804e-01f, -5.64237386e-02f, -3.62131745e-02f,
  3.28393234e-03f, -5.51330158e-03f, 2.32024387e-01f, -1.59295052e-01f, -1.27087221e-01f, -1.03474416e-01f, -6.06170762e-03f, 3.22506398e-01f, -7.09180608e-02f, 2.31557041e-01f,
  7.74358958e-02f, 7.49163404e-02f, 1.51786864e-01f, 1.14376828e-01f, -2.26518121e-02f, 1.01213656e-01f, -1.74364686e-01f, 6.49642721e-02f, -2.40888476e-01f, 1.22044519e-01f,
  -6.08431399e-02f, -1.96149573e-02f, 1.13554180e-01f, 1.25781551e-01f, -7.32873008e-02f, 2.01207642e-02f, -2.78191805e-01f, -1.80646144e-02f, -1.15468457e-01f, -3.25943708e-01f,
  1.71450481e-01f, -2.48818696e-01f, -1.53289378e-01f, -4.99392115e-02f, -1.46966809e-02f, 1.04345374e-01f, 2.29969382e-01f, -5.12364991e-02f, -9.50658545e-02f, -6.96123913e-02f,
  -1.18181221e-01f, -1.29057854e-01f, 8.27642232e-02f, -1.60125792e-02f, 9.90576968e-02f, -2.56653316e-03f, 1.20167360e-01f, 5.11305220e-02f, 1.13136910e-01f, -6.33573830e-02f,
  1.73279807e-01f, -1.68294518e-03f, 1.13934442e-01f, -7.80852363e-02f, -4.59667034e-02f, 1.00663692e-01f, 5.44511415e-02f, 2.10504085e-01f, 2.00133063e-02f, -9.90111232e-02f,
  5.28280325e-02f, -8.70706514e-02f, 6.60404563e-02f, -3.85774486e-02f, -8.55132788e-02f, -5.95677458e-02f, -1.25830233e-01f, 2.30904460e-01f, -6.34499043e-02f, 2.20777288e-01f,
  2.02821404e-01f, -6.27156720e-02f, -1.09216578e-01f, 3.78591456e-02f, -2.80789495e-01f, 8.72004107e-02f, 5.22132739e-02f, -4.44836803e-02f, 7.13826418e-02f, 1.01762399e-01f,
  -1.50560379e-01f, -2.41944082e-02f, -1.24186389e-01f, -2.26895288e-01f, 9.13243648e-03f, 8.05947781e-02f, -4.95161153e-02f, -1.24464937e-01f, 3.73157747e-02f, -7.75387883e-02f,
  -4.16682400e-02f, -2.39483401e-01f, 6.47958815e-02f, 1.69501230e-01f, 5.86345270e-02f, -1.99721277e-01f, 6.79238066e-02f, -1.76853120e-01f, 1.28784567e-01f, 1.98901758e-01f,
  -1.36134222e-01f, 1.13937505e-01f, 7.80257210e-02f, 2.40833655e-01f, 3.84123884e-02f, -1.35666788e-01f, 2.02411816e-01f, -6.17246889e-02f
};

// L2_fan_Wp_bar (Shape: 40 x 64)
const int L2_fan_Wp_bar_rows = 40;
const int L2_fan_Wp_bar_cols = 64;
const float L2_fan_Wp_bar_data[] = {
  1.92625403e-01f, -1.52365103e-01f, -1.76998138e-01f, -1.47137836e-01f, -1.40340209e-01f, -1.63015574e-01f, -5.41353822e-02f, -1.77781612e-01f, -1.89310815e-02f, -1.47609234e-01f,
  1.77073367e-02f, -1.17533207e-01f, 4.55526561e-02f, -1.53784424e-01f, -2.07760893e-02f, -1.32752387e-02f, 1.22919500e-01f, -2.03076392e-01f, 4.29307185e-02f, 2.34831527e-01f,
  -2.10032910e-01f, -6.70139790e-02f, 1.20277911e-01f, 2.42844209e-01f, -1.94213670e-02f, 8.25012401e-02f, 1.07510261e-01f, 3.10014188e-01f, -1.11274481e-01f, 9.71301645e-02f,
  -8.11800361e-02f, 1.41380643e-02f, 5.89708053e-02f, 1.75033629e-01f, -3.46867479e-02f, 7.97756538e-02f, -7.47784898e-02f, -6.65079951e-02f, 9.42309126e-02f, 1.21486425e-01f,
  1.51673317e-01f, -3.29463214e-01f, 5.89835718e-02f, 7.49836266e-02f, 9.32104513e-02f, 6.68554008e-02f, 2.49225125e-02f, 1.53945804e-01f, -2.59626079e-02f, -6.44749450e-03f,
  -1.38240710e-01f, -8.85304809e-02f, -7.92432278e-02f, 3.82021256e-02f, -4.93170060e-02f, 2.12482467e-01f, 9.66328904e-02f, 2.40618065e-01f, 4.28994596e-02f, 7.03909323e-02f,
  4.83261161e-02f, 9.65019166e-02f, 1.07245669e-01f, 6.11885749e-02f, -1.06773749e-02f, 1.80183854e-02f, -1.00116968e-01f, 6.17826730e-02f, -2.75874287e-01f, 4.94774617e-03f,
  -1.84216350e-01f, -2.54082739e-01f, 2.05011755e-01f, -1.56952277e-01f, -2.88661569e-02f, 4.67460230e-02f, 9.86565650e-02f, 1.05867729e-01f, -5.52808456e-02f, -3.78575586e-02f,
  3.39221776e-01f, 3.36119980e-02f, 8.58647674e-02f, 6.73670888e-01f, -3.76032218e-02f, -9.13971886e-02f, 3.91485482e-01f, 5.83290011e-02f, -1.91515386e-01f, -2.48121798e-01f,
  -1.31308716e-02f, 4.46073860e-01f, -2.32080296e-01f, 1.99621648e-01f, -3.48815098e-02f, 1.52046740e-01f, 8.97239968e-02f, 6.77429661e-02f, -1.27463639e-01f, 4.43825610e-02f,
  -1.49656281e-01f, -5.66822179e-02f, -1.48657426e-01f, 2.31605535e-03f, -8.72892514e-02f, -1.44008115e-01f, 1.96480677e-01f, 1.65095225e-01f, -4.46316935e-02f, 1.69750705e-01f,
  -2.95902491e-01f, 2.67023221e-02f, -1.97629422e-01f, -6.60338402e-02f, 9.18471292e-02f, -1.55582801e-01f, 1.25661969e-01f, 1.55977950e-01f, 3.51595208e-02f, -2.52062082e-02f,
  1.89978540e-01f, -1.49976060e-01f, 2.31419683e-01f, 1.05450884e-01f, 5.23024276e-02f, -1.37862578e-01f, -5.26438840e-02f, -9.40522030e-02f, 1.70513918e-03f, 6.75180331e-02f,
  -8.55505019e-02f, -2.42905319e-01f, -6.83144927e-02f, -5.62887453e-02f, -8.95072054e-03f, -1.84182987e-01f, -3.19028236e-02f, 5.42397648e-02f, -1.04842171e-01f, -8.10749978e-02f,
  9.08919871e-02f, -1.67267278e-01f, 1.32265791e-01f, -9.08493549e-02f, 8.44278708e-02f, -1.23800583e-01f, 8.58722478e-02f, 2.13070154e-01f, 2.37443343e-01f, 1.64966926e-01f,
  -3.10689323e-02f, -1.32096738e-01f, 5.30345850e-02f, -2.37250358e-01f, -2.32160270e-01f, 4.47519094e-01f, -7.88948759e-02f, 1.87144011e-01f, 7.60371387e-02f, 4.37229797e-02f,
  9.20533463e-02f, 2.21307166e-02f, 1.40581712e-01f, -1.51142389e-01f, 8.09400976e-02f, -2.79228371e-02f, 1.49359420e-01f, 1.45308182e-01f, -1.03156246e-01f, 1.15255885e-01f,
  6.42321557e-02f, 1.34592667e-01f, -2.96209276e-01f, -1.65084377e-01f, -4.82518189e-02f, 9.01613533e-02f, 1.87168911e-01f, 7.48977512e-02f, 7.21190423e-02f, 7.53282234e-02f,
  -5.92872389e-02f, 1.13383397e-01f, 1.05561979e-01f, -2.95290109e-02f, 5.80936298e-02f, -8.81011423e-04f, 4.24401201e-02f, -2.98352212e-01f, -9.71886367e-02f, -5.34589810e-04f,
  -3.51525515e-01f, -5.16905300e-02f, 7.08542243e-02f, 8.05573165e-02f, -1.05263870e-02f, -1.03103377e-01f, -1.36381567e-01f, -9.06957313e-03f, -2.41659626e-01f, 1.01317577e-01f,
  1.83119550e-01f, -2.62197345e-01f, -8.69218446e-03f, -2.49427155e-01f, 5.47980256e-02f, 1.70723036e-01f, -1.20538592e-01f, -1.30887022e-02f, 1.15459710e-01f, 3.92444879e-02f,
  -6.05266988e-02f, -1.40239345e-02f, -1.10291734e-01f, 1.55059367e-01f, -1.67905673e-01f, -1.82562303e-02f, -7.82085061e-02f, -7.29685137e-03f, 5.27454121e-03f, 2.10099798e-02f,
  -2.88974177e-02f, -4.81709726e-02f, -3.36920507e-02f, 4.05930099e-04f, -1.92016922e-03f, 4.35650162e-03f, -1.03083104e-02f, 1.55830216e-02f, -1.20119825e-01f, -2.38205940e-01f,
  9.32191312e-02f, 1.01067677e-01f, -3.57862934e-02f, 4.70732786e-02f, 5.33535960e-04f, -9.12530450e-05f, 9.03316587e-02f, 5.40090725e-03f, 2.00471911e-03f, -8.51687193e-02f,
  4.40551812e-04f, 1.33157402e-01f, 3.62640349e-05f, 2.65729334e-02f, -1.56783052e-02f, -1.40433192e-01f, 2.18883008e-01f, -5.01129366e-02f, -4.10753824e-02f, -7.70012895e-03f,
  2.71076579e-02f, 7.84898698e-02f, -1.21456623e-01f, 3.76927704e-02f, -1.28660277e-01f, 5.69060780e-02f, 1.50323644e-01f, -1.51142821e-01f, 1.25040412e-01f, -3.91542256e-01f,
  -1.69925168e-02f, -8.17142148e-03f, -2.81513692e-03f, -6.45988807e-02f, 6.22425899e-02f, -8.75811279e-02f, -3.72966826e-01f, -1.27489537e-01f, 7.43831769e-02f, 1.79167300e-01f,
  -1.28765494e-01f, 1.04022183e-01f, -2.82500833e-02f, -2.64478594e-01f, 3.04847836e-01f, -9.53610465e-02f, -1.10508539e-01f, 3.23143452e-02f, -1.97981790e-01f, 3.00811380e-01f,
  -7.36204814e-03f, 1.20949641e-01f, -1.16153145e-02f, 6.67046681e-02f, 7.75260478e-02f, 1.59282014e-01f, 1.24661401e-01f, -1.64531082e-01f, 5.79243042e-02f, 1.70356799e-02f,
  -4.14764229e-03f, -7.41781965e-02f, 3.26549411e-02f, 1.48530051e-01f, 1.15054667e-01f, 2.01088879e-02f, 7.02578723e-02f, -1.01840921e-01f, 2.52243113e-02f, -9.82527714e-03f,
  1.66423339e-02f, 6.16006181e-02f, 9.42079946e-02f, 2.94557977e-02f, 8.15574527e-02f, -1.54553711e-01f, -1.55812934e-01f, 1.65857106e-01f, -7.95779526e-02f, -1.18489049e-01f,
  5.43971993e-02f, 1.02154598e-01f, -1.77747115e-01f, 1.00636452e-01f, -1.14695035e-01f, -1.04618214e-01f, 2.78926510e-02f, 1.58002794e-01f, 6.09849840e-02f, 1.30140111e-01f,
  -2.59989221e-02f, 3.03789824e-02f, 5.04808091e-02f, 1.49262339e-01f, -8.00489411e-02f, 2.00557616e-02f, 1.78540349e-01f, -1.19160414e-01f, 2.61449695e-01f, 4.82207760e-02f,
  3.10235620e-01f, 5.72413541e-02f, 1.07580461e-01f, 8.49821866e-02f, 1.55218348e-01f, 2.38093373e-04f, -1.84366509e-01f, 4.76300232e-02f, 2.89690364e-02f, 7.59938806e-02f,
  -1.71970636e-01f, 1.24592006e-01f, -7.28065521e-02f, 1.78570703e-01f, 4.52391841e-02f, -1.18805543e-02f, 1.21951224e-02f, -1.88998178e-01f, 5.57557121e-02f, 1.65336102e-01f,
  9.36388690e-03f, 1.96711287e-01f, -1.11025386e-01f, 7.26521164e-02f, 1.73140407e-01f, -2.50789285e-01f, 2.19087064e-01f, 1.05996102e-01f, -1.43434569e-01f, -5.63084818e-02f,
  -2.88977265e-01f, 5.23963630e-01f, 7.04922751e-02f, 3.75783086e-01f, 5.06025041e-03f, -7.85568133e-02f, 7.58523569e-02f, 1.95743814e-02f, 2.23583788e-01f, -4.64502238e-02f,
  3.25631976e-01f, -2.12174475e-01f, 1.58018842e-01f, 5.80340773e-02f, 3.73648629e-02f, 1.17907278e-01f, 1.40812650e-01f, 9.48614441e-03f, 2.24098653e-01f, 9.66415629e-02f,
  1.61241621e-01f, -1.67445391e-01f, -1.33573845e-01f, -8.90402570e-02f, 3.54821563e-01f, 2.96797365e-01f, 2.82152325e-01f, -1.82928175e-01f, 3.99187207e-02f, 2.73760203e-02f,
  1.54861003e-01f, 5.04089287e-03f, -2.03321263e-01f, 1.54941767e-01f, 5.42492457e-02f, 1.20603770e-01f, 1.44409552e-01f, 1.22700617e-01f, -7.97539502e-02f, 1.89068228e-01f,
  2.38906428e-01f, -1.33289024e-01f, 3.34219426e-01f, -3.39519642e-02f, 2.39638478e-01f, -1.62489653e-01f, 1.04561679e-01f, -3.49171609e-01f, 5.14112636e-02f, 1.65381894e-01f,
  1.18370563e-01f, -1.42090201e-01f, 8.81592184e-02f, 1.32512033e-01f, -1.07411563e-01f, -1.41758714e-02f, 2.80817449e-01f, -2.47922257e-01f, -1.30181670e-01f, 1.91510752e-01f,
  -2.12099388e-01f, 8.55995640e-02f, -2.46821195e-01f, -1.30610429e-02f, 8.11337531e-02f, -1.35042876e-01f, 1.28024802e-01f, 7.87636563e-02f, 4.98312246e-03f, -1.90288916e-01f,
  1.23829462e-01f, -9.00751874e-02f, -1.21791855e-01f, 8.63892585e-02f, -1.75160840e-01f, -1.76090039e-02f, -1.22239888e-01f, -8.96142423e-02f, 2.10865334e-01f, 1.00259900e-01f,
  -4.91179675e-02f, 1.79516330e-01f, -1.60897136e-01f, -1.38885170e-01f, -7.98058435e-02f, 3.04795839e-02f, 4.19107415e-02f, 2.55457312e-03f, 1.22150838e-01f, 1.69366375e-01f,
  -1.45309092e-02f, 5.35174087e-02f, -2.84499109e-01f, -3.41235429e-01f, -1.40571535e-01f, -2.70375669e-01f, 1.01086445e-01f, -2.36140773e-01f, -2.54261404e-01f, -5.71174994e-02f,
  2.37486959e-01f, -1.68946579e-01f, -8.97093415e-02f, -2.11296380e-01f, -3.18484008e-01f, -2.80060530e-01f, 1.06881350e-01f, 1.44193664e-01f, 3.04378361e-01f, 1.02980547e-01f,
  1.35370165e-01f, -3.75901490e-01f, 9.27693918e-02f, 3.42576019e-02f, 1.56562150e-01f, 3.76012117e-01f, 1.04769506e-01f, -1.66090834e-03f, -1.25215044e-02f, 1.24823697e-01f,
  5.07132076e-02f, -1.51732340e-01f, -5.92604838e-02f, 5.60557330e-03f, 4.19885367e-02f, -8.05902630e-02f, 3.30587737e-02f, 1.65278673e-01f, 1.00682102e-01f, 8.45731497e-02f,
  -1.94472726e-03f, 1.91487625e-01f, -5.08206114e-02f, -6.56502470e-02f, 5.42089380e-02f, 1.30396426e-01f, -1.38894066e-01f, 2.08412766e-01f, 1.31899863e-01f, -1.12110257e-01f,
  3.02668214e-02f, 9.58306268e-02f, 5.99794611e-02f, -1.22746430e-01f, 6.81235790e-02f, 3.03287119e-01f, 9.88337323e-02f, -2.02088475e-01f, -3.32737691e-04f, 4.10997105e-04f,
  -4.17227000e-02f, -3.08357142e-02f, -3.16105597e-02f, 6.76567480e-02f, -8.91493708e-02f, -1.26462787e-01f, -2.04691499e-01f, -3.60068411e-01f, -1.21069513e-01f, 6.96336478e-02f,
  1.12548582e-01f, -1.48014566e-02f, -1.94263667e-01f, 2.15718225e-02f, 1.73091173e-01f, 7.92697910e-03f, -1.18596017e-01f, -1.88282922e-01f, -3.89643043e-01f, -1.58562735e-01f,
  1.48640022e-01f, 7.06917187e-03f, 2.61405468e-01f, 1.40831307e-01f, 8.20474476e-02f, -6.67875931e-02f, -2.54420884e-04f, 3.66939344e-02f, 9.61656962e-03f, 7.42910132e-02f,
  3.56767625e-02f, -7.38354549e-02f, -4.29004803e-02f, -7.34240562e-02f, 6.01874329e-02f, -1.33306328e-02f, 1.41722098e-01f, -1.86064705e-01f, 1.20478407e-01f, 1.44702703e-01f,
  1.44130364e-01f, -1.31086975e-01f, 1.12007037e-01f, 1.89847037e-01f, 2.47292761e-02f, 1.53829515e-01f, -6.43288856e-03f, -7.32477605e-02f, 2.45195374e-01f, 4.80514094e-02f,
  -2.36376747e-02f, -5.59847839e-02f, 1.08164012e-01f, 3.63296419e-02f, -1.03944898e-01f, -5.51119111e-02f, 1.56690449e-01f, -2.10123193e-02f, -5.40852435e-02f, 1.23644300e-01f,
  1.34108558e-01f, -1.88241810e-01f, 1.41421184e-01f, 1.87243357e-01f, 5.14266789e-02f, -2.93544959e-02f, 4.24961224e-02f, 2.64151633e-01f, 1.49435803e-01f, 5.22397384e-02f,
  -8.43063891e-02f, 1.68650270e-01f, -1.42533192e-02f, -2.56032776e-03f, 2.97943074e-02f, -2.92692333e-02f, -2.30917633e-02f, 1.08876333e-01f, 5.66071086e-02f, -1.21926531e-01f,
  -9.88974497e-02f, 4.01683040e-02f, 1.56786844e-01f, -8.03199708e-02f, 2.96293292e-02f, -2.92034056e-02f, -1.34708900e-02f, -8.34691748e-02f, 7.04382062e-02f, -1.31630465e-01f,
  -1.93360269e-01f, 1.50029004e-01f, 8.50906894e-02f, 2.02703804e-01f, 9.53262448e-02f, 1.49652049e-01f, 2.36212760e-02f, 1.77544758e-01f, 2.79619098e-01f, -2.87030190e-02f,
  -3.13002765e-01f, 2.89546043e-01f, -3.75325531e-02f, -4.84512746e-03f, -1.76271543e-01f, 3.07708800e-01f, 2.89062172e-01f, -3.32959116e-01f, 1.40995942e-02f, -4.42658737e-02f,
  7.74369761e-02f, 8.46186280e-02f, -2.02813908e-01f, 1.83390111e-01f, -1.95432752e-01f, 4.72529046e-02f, 3.00889313e-02f, -1.21223547e-01f, -9.46813300e-02f, 5.04476726e-02f,
  1.11098327e-01f, 1.06287345e-01f, 2.19842970e-01f, 3.10289830e-01f, -4.90452833e-02f, -2.88726520e-02f, -9.89171639e-02f, -7.58585632e-02f, 9.90980417e-02f, -1.09520651e-01f,
  2.41736248e-02f, 1.40362233e-02f, 7.83042088e-02f, 1.58023730e-01f, 3.35228682e-01f, 8.66489783e-02f, -1.13072051e-02f, 1.11288637e-01f, 7.61198103e-02f, -1.94155842e-01f,
  -1.78210139e-01f, 5.32704443e-02f, -1.40485391e-01f, 8.99501219e-02f, -1.21219277e-01f, 2.14539766e-01f, -1.03323944e-01f, -7.02831596e-02f, -2.76580244e-01f, -2.10212991e-01f,
  9.61191133e-02f, -8.13195482e-02f, -8.00346062e-02f, 1.12640701e-01f, -5.40877730e-02f, 1.77448317e-01f, -1.40128320e-03f, 9.37855467e-02f, 2.20052332e-01f, -7.57708475e-02f,
  2.20107853e-01f, -1.99394912e-01f, 3.46411839e-02f, 8.69416222e-02f, -2.87489384e-01f, 4.30302918e-02f, -1.64807200e-01f, 2.00901896e-01f, 5.46408892e-02f, 1.24187343e-01f,
  1.04282834e-01f, -4.11088139e-01f, -1.76313177e-01f, -3.91590953e-01f, 2.39573587e-02f, 3.60666141e-02f, -7.28348643e-03f, -1.84682071e-01f, -2.54138738e-01f, 4.50488664e-02f,
  -3.84746529e-02f, 6.54688627e-02f, -1.12452276e-01f, -4.38563228e-02f, 1.34697616e-01f, 1.17011487e-01f, -2.29657173e-01f, -1.38035551e-01f, -2.66882032e-01f, -1.47075027e-01f,
  2.42622402e-02f, -5.27065843e-02f, 1.57302804e-02f, 6.75171837e-02f, -2.64584213e-01f, -1.96285583e-02f, 2.83357799e-01f, 1.46306381e-01f, 3.75061542e-01f, 3.11079226e-03f,
  1.53822660e-01f, 2.34792903e-01f, 1.99780837e-02f, 3.47849995e-01f, 2.68408597e-01f, -7.32044503e-02f, -7.51559287e-02f, 2.73243964e-01f, 1.39374524e-01f, -8.58994201e-02f,
  -1.08793959e-01f, 2.92670429e-01f, -1.27940118e-01f, -4.14611816e-01f, -1.20655261e-01f, 1.03363723e-01f, -1.99093893e-01f, 4.28362191e-01f, -1.22167721e-01f, 8.10113773e-02f,
  1.38997827e-02f, -4.27843302e-01f, 4.05145623e-02f, -5.02149761e-02f, -2.18131151e-02f, -9.73182991e-02f, 1.02587692e-01f, -1.15215331e-02f, 2.08054975e-01f, -6.40672520e-02f,
  5.92343882e-02f, 3.84853035e-02f, -8.58901814e-02f, 3.41405235e-02f, -2.54922420e-01f, 1.96342856e-01f, 1.83868781e-01f, -1.92284614e-01f, -2.48458330e-02f, 1.10065654e-01f,
  -1.96215580e-03f, -1.37956396e-01f, 2.60750115e-01f, 2.73882288e-05f, 6.78499117e-02f, 9.98493955e-02f, 1.04377680e-01f, 4.38358672e-02f, 2.43709013e-02f, -7.03314394e-02f,
  -2.48791035e-02f, -1.28038362e-01f, 3.95299047e-02f, 2.06162229e-01f, 1.42267600e-01f, -5.76676540e-02f, -7.74139091e-02f, -7.61261629e-03f, 2.56281316e-01f, 2.41054632e-02f,
  -1.08319201e-01f, -3.78844351e-01f, -1.76351011e-01f, 2.38194034e-01f, -2.45109171e-01f, -1.13150105e-01f, -4.26954813e-02f, -7.73062035e-02f, -1.64748579e-01f, 7.53415301e-02f,
  6.50562113e-03f, -2.75731701e-02f, 1.24990366e-01f, 1.23767130e-01f, 4.49896395e-01f, -6.06330968e-02f, 2.63837218e-01f, 1.90632120e-01f, -8.45643207e-02f, -9.23819561e-03f,
  1.21115409e-02f, 3.61196473e-02f, -1.48573950e-01f, 3.39298062e-02f, 7.29376003e-02f, 2.77529925e-01f, -6.42804876e-02f, 1.65066034e-01f, -4.48392890e-02f, 6.22541718e-02f,
  1.72901824e-01f, 5.77560589e-02f, -1.55096665e-01f, 7.90512189e-02f, -1.56199872e-01f, 1.09469751e-02f, -5.44103608e-02f, 1.19372711e-01f, 3.13493684e-02f, -1.44244790e-01f,
  2.05011114e-01f, 2.16989666e-02f, 5.66083528e-02f, 7.11974204e-02f, -1.70464009e-01f, 4.86023277e-02f, 1.06661674e-02f, -1.71042264e-01f, -3.19858529e-02f, -3.09771392e-02f,
  -5.69956377e-02f, -5.79865091e-02f, 7.28842542e-02f, 6.43348023e-02f, 8.53949934e-02f, 1.04622424e-01f, -8.43646973e-02f, 4.20515649e-02f, -6.67336956e-03f, -2.17868481e-03f,
  3.92558947e-02f, 1.98516175e-02f, 1.90762326e-01f, -4.13092040e-02f, 2.43817031e-01f, 3.05809766e-01f, 6.62831888e-02f, 9.39543918e-02f, 2.34473392e-01f, 1.59335449e-01f,
  -9.21503156e-02f, 8.06070343e-02f, 2.83821702e-01f, 3.05120230e-01f, -3.56961071e-01f, 3.22563291e-01f, -1.30770832e-01f, -9.94044021e-02f, -1.94396153e-01f, 1.67996630e-01f,
  2.46212929e-02f, -4.28326577e-01f, 4.90521431e-01f, -1.41777217e-01f, -1.46019936e-01f, -3.71038675e-01f, 3.10046107e-01f, -3.70548144e-02f, -2.29362044e-02f, -3.55907291e-01f,
  1.96835786e-01f, -1.44888371e-01f, 1.92807138e-01f, -1.33672692e-02f, 1.33284107e-01f, 1.07294153e-02f, 2.63107438e-02f, -3.62199433e-02f, -3.67558636e-02f, -2.31016517e-01f,
  -2.56570637e-01f, -1.40840650e-01f, -3.34803644e-03f, 1.53272778e-01f, -7.97387511e-02f, 1.36098430e-01f, 2.03468278e-01f, -1.17373399e-01f, 3.19705546e-01f, -1.23893894e-01f,
  1.28186673e-01f, 3.51076454e-01f, 1.08166963e-01f, -3.13747674e-01f, -1.84770767e-02f, -1.50574550e-01f, 1.82201937e-01f, 2.69737989e-02f, 8.70383680e-02f, -1.05608396e-01f,
  -1.38918906e-02f, -1.12682857e-01f, 1.62862256e-01f, -1.27898321e-01f, -6.64387718e-02f, -2.39513461e-02f, 1.19393922e-01f, -1.09261893e-01f, 2.01630980e-01f, 1.01440109e-01f,
  1.24854051e-01f, 1.96370333e-02f, 3.33393365e-01f, 1.15871355e-01f, -2.13442314e-02f, 1.10304236e-01f, 1.98310912e-01f, 6.05540648e-02f, -2.32915118e-01f, 4.07195657e-01f,
  -2.99853772e-01f, 7.49154240e-02f, 1.98692195e-02f, -8.59228671e-02f, -3.47537287e-02f, 1.28235156e-02f, 1.17666423e-01f, -1.54981941e-01f, -1.48351967e-01f, 1.67804405e-01f,
  9.63047817e-02f, 6.18900098e-02f, 6.96664825e-02f, -2.72132576e-01f, 8.89352411e-02f, -1.43357441e-02f, 9.66607779e-02f, -9.13990065e-02f, -5.11387624e-02f, 1.07602634e-01f,
  -4.82028611e-02f, 9.37792286e-02f, 1.19822174e-01f, 9.09829959e-02f, -8.84849355e-02f, -2.14293897e-01f, -5.62878735e-02f, -1.38690859e-01f, -6.90598860e-02f, -7.36157671e-02f,
  9.78456065e-02f, 1.67860001e-01f, 1.58265412e-01f, -7.69948661e-02f, -7.20529929e-02f, -1.78042471e-01f, 1.90301966e-02f, 9.16420817e-02f, 9.66910496e-02f, 9.75677446e-02f,
  -1.70405909e-01f, 7.68366754e-02f, -3.70509215e-02f, -2.01156393e-01f, 1.02473289e-01f, 2.48476714e-02f, 2.08474889e-01f, -3.06201130e-02f, 1.06727071e-01f, 8.32095817e-02f,
  7.01187178e-02f, -1.03666797e-01f, 1.22379258e-01f, -1.83289379e-01f, 1.50084957e-01f, 8.30323696e-02f, 4.53797802e-02f, 1.27579778e-01f, -5.40956147e-02f, 2.86013745e-02f,
  5.09162396e-02f, -2.40153950e-02f, -4.01376396e-01f, 3.05609792e-01f, -1.60575762e-01f, 1.81822330e-01f, 1.14252247e-01f, 1.16578989e-01f, -7.84952417e-02f, -1.00326143e-01f,
  -1.94963783e-01f, -1.48903504e-01f, -3.09593439e-01f, 2.39542112e-01f, 2.21380368e-01f, 1.80702507e-01f, 2.67724544e-01f, -2.04377353e-01f, -7.10395873e-02f, 2.53217787e-01f,
  -5.81559390e-02f, 3.83590274e-02f, 2.84246858e-02f, 2.23114312e-01f, -8.01429376e-02f, 1.22069016e-01f, 6.63212501e-03f, 1.26465661e-02f, -1.38648301e-01f, 4.92511205e-02f,
  -1.33790215e-02f, -1.06132299e-01f, 7.10274726e-02f, 9.11181718e-02f, 2.79642373e-01f, 1.30713850e-01f, 2.21899033e-01f, 1.23032732e-02f, 1.74443051e-01f, -2.20924854e-01f,
  -2.55345907e-02f, -5.97495958e-02f, 1.34008853e-02f, -4.66533229e-02f, 6.61117882e-02f, 1.99849263e-01f, -8.56167004e-02f, -1.33805558e-01f, 7.87909031e-02f, 2.81567220e-02f,
  2.26258114e-01f, -6.16932996e-02f, 1.15402862e-01f, 1.09624632e-01f, 1.74149588e-01f, 1.54642805e-01f, 2.37152457e-01f, 8.98647904e-02f, 2.64394641e-01f, 2.19935700e-01f,
  1.22292541e-01f, 2.35476151e-01f, 6.10827841e-03f, 2.75990218e-01f, 4.48228307e-02f, 1.33390218e-01f, -2.40783393e-01f, 3.50151509e-01f, -2.01931283e-01f, 3.33280675e-02f,
  1.60442278e-01f, 1.54610842e-01f, 6.28260598e-02f, -3.11462581e-01f, 6.37480095e-02f, -2.38351792e-01f, -2.38379538e-01f, -2.14992851e-01f, 2.31371716e-01f, 6.17973767e-02f,
  -9.92432460e-02f, -2.30590686e-01f, -3.16152796e-02f, 1.34802490e-01f, 4.48587686e-02f, -1.44806117e-01f, 1.71043560e-01f, -1.13493331e-01f, -3.10707390e-02f, 8.57389644e-02f,
  -1.41671523e-01f, -5.59588782e-02f, -3.25746715e-01f, -2.33161017e-01f, -1.12175584e-01f, -9.78283212e-03f, 1.73066124e-01f, -7.67265484e-02f, 2.70269513e-01f, -7.17679933e-02f,
  1.98068142e-01f, -2.02207997e-01f, 1.28663495e-01f, 7.79598905e-03f, -1.34584680e-01f, -1.71072081e-01f, 8.28193277e-02f, -9.73219797e-02f, 2.44416058e-01f, 2.07710207e-01f,
  -6.62408769e-02f, -2.45984659e-01f, -1.55985951e-02f, 9.92867574e-02f, 1.27042070e-01f, -1.76355481e-01f, -7.43378103e-02f, 8.16845223e-02f, 2.20282555e-01f, 1.00159362e-01f,
  2.27900594e-01f, -6.64322972e-02f, 9.02798586e-03f, 8.07909016e-03f, 1.76488847e-01f, 4.96523343e-02f, 1.40316188e-01f, 4.34760362e-01f, 9.06710029e-02f, 7.98282251e-02f,
  3.98896813e-01f, 1.89654395e-01f, -9.32715759e-02f, -5.14261751e-03f, -1.59842134e-01f, -9.82742608e-02f, 3.67581695e-01f, 1.57021627e-01f, 2.43639976e-01f, -5.72679192e-02f,
  -9.89680812e-02f, -1.53598279e-01f, 1.63977444e-01f, 8.24486651e-03f, -1.45852193e-01f, -6.55035451e-02f, 1.11768588e-01f, 1.05951145e-01f, 2.87759274e-01f, 2.29512770e-02f,
  1.14579022e-01f, 4.70343567e-02f, 2.75597926e-02f, -4.06793840e-02f, 1.85866952e-01f, -6.94121420e-03f, -9.74953175e-02f, -1.65311128e-01f, -9.04616714e-02f, 2.90100664e-01f,
  1.62762523e-01f, 3.38845789e-01f, 8.68551880e-02f, -1.66739956e-01f, 2.34765589e-01f, 2.87323296e-01f, 6.91140145e-02f, 3.35909761e-02f, 2.43730396e-01f, 2.17260122e-02f,
  1.72621638e-01f, -9.93518531e-02f, 2.42545292e-01f, -8.18473846e-02f, 2.24930793e-01f, 2.25533918e-01f, 2.14821815e-01f, 5.21796197e-02f, -8.27172324e-02f, 7.44808614e-02f,
  -1.53406531e-01f, 5.88953383e-02f, 1.77210569e-01f, 1.80416793e-01f, -7.41800964e-02f, -1.26793176e-01f, -2.93218661e-02f, -1.70070797e-01f, -1.30887195e-01f, 6.82795197e-02f,
  1.84539743e-02f, 2.00805478e-02f, 5.76610379e-02f, -5.38641997e-02f, 1.06698386e-01f, 8.19676965e-02f, -6.09026738e-02f, 1.07975394e-01f, 1.55086771e-01f, -4.36151363e-02f,
  1.86751634e-01f, -4.65327017e-02f, -2.07166165e-01f, -1.24972679e-01f, 1.20817274e-01f, -1.65391251e-01f, 3.46619487e-02f, 9.32409018e-02f, 3.36789429e-01f, 1.25424027e-01f,
  2.08138585e-01f, 8.78149495e-02f, -1.96916744e-01f, 3.91406640e-02f, -6.98636621e-02f, -6.51271362e-03f, -1.52592614e-01f, 9.58483070e-02f, -1.79210588e-01f, 7.02262670e-02f,
  -1.27822116e-01f, 9.89901796e-02f, 2.99096197e-01f, -1.36420727e-01f, -2.05425590e-01f, 1.99736357e-01f, 1.38707235e-01f, -3.57361813e-03f, -8.89394432e-03f, -3.00349109e-02f,
  -4.94209453e-02f, -6.33308887e-02f, -1.47257581e-01f, -1.93504214e-01f, -1.31915435e-01f, -1.35725319e-01f, 9.52870324e-02f, 5.52726984e-02f, 1.12627976e-01f, 3.71751100e-01f,
  1.92798711e-02f, 1.47058561e-01f, 2.40714550e-02f, 1.30866900e-01f, 1.48048520e-01f, 1.62088156e-01f, -1.22465067e-01f, -1.23517737e-01f, -1.22450285e-01f, -6.33243173e-02f,
  2.50531873e-03f, -1.39259547e-01f, -3.51287052e-02f, -2.33285204e-01f, 1.69244170e-01f, -3.76895696e-01f, -2.38147363e-01f, -1.82962082e-02f, 9.35097784e-02f, 4.55790907e-02f,
  -2.16791615e-01f, -7.10966438e-02f, -1.97083697e-01f, -2.11356610e-01f, 9.10949036e-02f, 4.10945117e-02f, 2.15131104e-01f, 9.32363607e-03f, -1.00303821e-01f, 1.59807932e-02f,
  -7.25096604e-03f, -7.29047135e-02f, 2.09463924e-01f, 1.23076634e-02f, 1.65390939e-01f, -1.51673019e-01f, 2.69664060e-02f, -4.84480336e-02f, -4.05971706e-02f, 5.24500664e-03f,
  5.64933009e-02f, 1.78327190e-03f, 2.09026877e-02f, 2.52681255e-01f, -4.11036536e-02f, -3.09964139e-02f, -2.95571554e-02f, 2.40087971e-01f, -8.93198177e-02f, 8.87279138e-02f,
  -9.29933712e-02f, 3.18252221e-02f, 5.81040829e-02f, -1.25206664e-01f, -7.50629278e-03f, 1.71682108e-02f, 1.01159634e-02f, 3.97686288e-02f, -6.10951819e-02f, -5.66954501e-02f,
  1.69401377e-01f, -1.46113262e-01f, 2.15067025e-02f, 1.12368308e-01f, 1.28740087e-01f, -2.42243320e-01f, 1.81309298e-01f, 1.37919456e-01f, 1.32557839e-01f, 5.37032727e-03f,
  1.01528607e-01f, 1.56793445e-01f, 2.03858227e-01f, 5.65150045e-02f, 1.84198812e-01f, 3.88273678e-04f, 2.69729972e-01f, -4.65915306e-03f, 1.25122622e-01f, 7.92726427e-02f,
  8.53947923e-02f, -5.49871214e-02f, 2.18011409e-01f, 1.38372630e-02f, 2.68529832e-01f, -2.27687377e-02f, -2.26175621e-01f, -1.76218212e-01f, 2.82042436e-02f, 1.10295907e-01f,
  -4.87196781e-02f, 2.48076648e-01f, -3.31397206e-01f, 2.17791513e-01f, -1.02349639e-01f, -2.46008813e-01f, -2.86601126e-01f, -3.92770395e-02f, 3.10561340e-02f, 1.28577843e-01f,
  1.31475583e-01f, -2.01122873e-02f, 1.16701342e-01f, 2.08588079e-01f, 1.67481005e-01f, -4.39412624e-01f, 2.91474666e-02f, 6.58065677e-02f, 1.22229330e-01f, -4.79393043e-02f,
  -1.98631749e-01f, 2.34242141e-01f, 2.56708324e-01f, -1.20027557e-01f, -2.87167817e-01f, 1.99978083e-01f, 1.86095200e-02f, 6.53184950e-02f, 2.44795680e-01f, 1.74779326e-01f,
  2.11059973e-01f, 1.09826520e-01f, 1.24447523e-02f, 8.82351995e-02f, 1.61120370e-01f, -4.76781726e-02f, 5.51257171e-02f, -2.04503477e-01f, 1.07622594e-01f, 8.30008015e-02f,
  2.21815016e-02f, 1.87606923e-02f, -2.31175855e-01f, -1.68659464e-01f, 1.50090093e-02f, -2.18769252e-01f, -6.63621351e-02f, 6.47581741e-03f, -5.12696169e-02f, -8.96358043e-02f,
  2.75445133e-01f, 2.96417177e-01f, -1.21437786e-02f, 1.58382609e-01f, 1.27027631e-01f, -4.76413555e-02f, -4.85531501e-02f, 3.11997980e-01f, -2.46483967e-01f, -2.47469246e-01f,
  8.86687078e-03f, 1.59427702e-01f, -2.93645442e-01f, 8.55522752e-02f, 9.73823145e-02f, -1.47466110e-02f, -1.20780401e-01f, 2.40271538e-01f, 1.91956177e-01f, -3.46474163e-02f,
  -1.12405777e-01f, 3.39817964e-02f, -8.83795321e-02f, 3.89113538e-02f, 1.18251123e-01f, 1.05210245e-01f, -4.46106493e-02f, 2.17375562e-01f, 4.96670455e-02f, -1.74844444e-01f,
  1.23367831e-01f, -2.03952920e-02f, 1.34621426e-01f, -1.69909060e-01f, -9.38166752e-02f, -4.71097454e-02f, 5.78388982e-02f, -2.60378029e-02f, -3.13978568e-02f, -2.50020903e-02f,
  1.83418244e-02f, 1.62464246e-01f, 1.00163795e-01f, -1.31276757e-01f, 5.13237789e-02f, 5.08116670e-02f, -7.76868388e-02f, 1.96511582e-01f, 3.26583982e-02f, 1.36615708e-01f,
  -2.71649491e-02f, -4.44408119e-01f, -6.85932022e-03f, -1.88179743e-02f, -4.49250825e-03f, 1.81530088e-01f, 1.16538301e-01f, 5.34733161e-02f, 1.72531896e-03f, -9.29513723e-02f,
  -1.27429059e-02f, 1.34419948e-02f, -2.15723980e-02f, -6.10865206e-02f, 2.98366547e-01f, 4.44103517e-02f, 1.38642117e-01f, -5.92791522e-03f, 1.65622130e-01f, 1.18396364e-01f,
  1.23558737e-01f, -1.41405478e-01f, -2.01146733e-02f, 1.01676621e-01f, 6.50257468e-02f, -6.49756342e-02f, 9.90600809e-02f, 5.12700081e-01f, -7.17177540e-02f, 3.77132669e-02f,
  1.86287954e-01f, 3.68742287e-01f, -9.75224152e-02f, -1.04249664e-01f, 8.25066641e-02f, 2.27884069e-01f, -2.89168000e-01f, 3.16767469e-02f, -5.74078858e-02f, 1.61455840e-01f,
  -1.26480877e-01f, 2.07993507e-01f, -2.25378975e-01f, -2.74287537e-02f, 3.33974175e-02f, -2.65455768e-02f, 4.13169190e-02f, 1.11330777e-01f, -3.86873595e-02f, -8.17844793e-02f,
  1.26780286e-01f, 4.80874181e-02f, 1.76708415e-01f, 2.33255833e-01f, -3.26290190e-01f, 1.64838150e-01f, -2.22656786e-01f, -4.03777175e-02f, 5.64570688e-02f, 1.27447676e-02f,
  -2.21473388e-02f, 2.09648490e-01f, -7.07254708e-02f, -1.11373477e-02f, 1.90463483e-01f, 2.49059522e-03f, 1.37228683e-01f, 9.55565274e-02f, -8.10589641e-02f, 1.23505771e-01f,
  1.21572446e-02f, 2.07899332e-01f, -1.89100474e-01f, 2.07715780e-02f, 2.80760735e-01f, 3.94965142e-01f, 1.47617400e-01f, -1.28320009e-01f, -8.05485025e-02f, 9.17354897e-02f,
  1.99675694e-01f, 1.22621708e-01f, -1.39948661e-02f, 2.83248216e-01f, 2.17671558e-01f, -3.23794156e-01f, 1.39802039e-01f, -2.28808045e-01f, -3.82206470e-01f, -2.08104655e-01f,
  -9.23772976e-02f, -1.73960045e-01f, 1.41452074e-01f, -7.44915456e-02f, 3.41366202e-01f, -1.53111637e-01f, 9.98712629e-02f, 4.83653471e-02f, -2.38824651e-01f, 9.30275396e-03f,
  1.19313255e-01f, -2.59250313e-01f, 1.82655409e-01f, -4.33172695e-02f, 3.02126437e-01f, -3.30836847e-02f, 1.24382451e-02f, 2.85918474e-01f, 1.86012790e-01f, 2.73328364e-01f,
  3.98919173e-02f, 2.26252362e-01f, 2.72754312e-01f, -1.84455961e-01f, 1.00426167e-01f, -3.16554546e-01f, -1.99687496e-01f, 1.41385600e-01f, -1.39855772e-01f, 2.25537285e-01f,
  -1.12825543e-01f, 1.60026878e-01f, -3.56018133e-02f, -8.87279212e-02f, -9.05522257e-02f, 2.59362638e-01f, -6.50127009e-02f, -1.77115440e-01f, -8.32309946e-02f, 3.98918539e-01f,
  4.43774760e-02f, 9.25632659e-03f, -1.40789390e-01f, -1.49481427e-02f, 2.47228205e-01f, -6.24867603e-02f, 2.58421302e-01f, 1.80331886e-01f, 1.76192269e-01f, -1.68189630e-02f,
  2.11859167e-01f, 1.68923721e-01f, 3.03075284e-01f, 1.27107650e-01f, -7.97949880e-02f, 2.33917624e-01f, 9.84005909e-03f, -3.98886427e-02f, -6.83965236e-02f, 2.91576266e-01f,
  -2.50807256e-01f, 9.06705037e-02f, 2.15071410e-01f, -3.27351457e-03f, -3.91848339e-03f, -2.68606454e-01f, -4.34415452e-02f, -2.89359003e-01f, -2.09084257e-01f, -6.36989772e-02f,
  2.31678396e-01f, 1.04902484e-01f, 1.42378407e-02f, -3.09154838e-02f, 6.80514202e-02f, 2.05411896e-01f, 1.33253098e-01f, -5.89541756e-02f, 1.99936450e-01f, -1.21557051e-02f,
  -1.43313900e-01f, 1.75998136e-01f, -2.81150341e-02f, 9.40795690e-02f, -1.83312446e-01f, -9.02151465e-02f, -4.46850844e-02f, -1.09064810e-01f, 6.51671924e-03f, 1.63023144e-01f,
  2.40940303e-01f, -9.13779065e-02f, 1.69257253e-01f, -2.20240820e-02f, -1.03466079e-01f, -3.47563714e-01f, -4.97506410e-02f, 9.11946744e-02f, 1.09366111e-01f, -8.94354433e-02f,
  7.24270642e-02f, 3.05924863e-01f, -1.55243546e-01f, 3.43753654e-03f, -2.94022821e-02f, -5.78262098e-02f, 1.11087188e-01f, -2.80431542e-03f, 1.82038620e-01f, -8.20966717e-03f,
  8.24392363e-02f, 2.58127570e-01f, 1.69055119e-01f, -6.85167359e-03f, 4.12626415e-02f, 2.92766184e-01f, 1.21897750e-01f, -9.53726918e-02f, 9.87405851e-02f, 1.68792680e-01f,
  1.83546320e-01f, 1.01227216e-01f, 4.11024541e-01f, -9.53075290e-02f, 3.54933470e-01f, 1.47320941e-01f, 6.63581342e-02f, -7.74026960e-02f, 3.29558820e-01f, -4.17664982e-02f,
  -6.54237941e-02f, 6.68634251e-02f, 1.70780569e-01f, -9.27149206e-02f, -1.23131610e-01f, -7.90015329e-03f, -7.09009096e-02f, 4.36592214e-02f, 5.68979308e-02f, 2.70639420e-01f,
  1.07380927e-01f, 1.48319259e-01f, 1.96927235e-01f, 5.37860356e-02f, 2.66675413e-01f, 1.24382228e-01f, 4.65313792e-02f, 1.05361044e-01f, -1.73802510e-01f, 1.27038568e-01f,
  -3.15784626e-02f, 2.33573169e-01f, 2.60820866e-01f, 2.74429649e-01f, -2.11748004e-01f, -2.62682047e-02f, 6.84943050e-02f, 2.18481869e-01f, 2.19333202e-01f, -1.23564474e-01f,
  1.10336274e-01f, -1.06272146e-01f, 1.88385583e-02f, -3.36956717e-02f, 6.15817606e-02f, -8.44053552e-02f, 2.75602996e-01f, 2.93773502e-01f, 1.16204657e-01f, 1.67872399e-01f,
  -7.05083832e-02f, -1.34661913e-01f, -8.40228889e-03f, -8.54097679e-02f, 1.63114339e-01f, 2.02036705e-02f, 1.57433048e-01f, -2.18105212e-01f, 2.18589321e-01f, 1.43555209e-01f,
  1.80655181e-01f, 9.83356535e-02f, -1.71880737e-01f, 1.81012824e-01f, -5.83922751e-02f, 1.55410711e-02f, -2.51905620e-01f, 2.26152271e-01f, -1.89913213e-01f, 2.39204362e-01f,
  2.76481301e-01f, -3.39122838e-03f, 1.36639997e-01f, -3.39973301e-01f, -2.37307608e-01f, -4.88706455e-02f, -2.09861904e-01f, 7.23445788e-02f, 5.34793511e-02f, 1.98224589e-01f,
  1.15946218e-01f, -2.69757897e-01f, 1.32612526e-01f, 2.32261315e-01f, 4.85884659e-02f, -9.67991129e-02f, 1.45276770e-01f, -4.52095419e-02f, 5.30021861e-02f, 1.05640195e-01f,
  -3.54310982e-02f, -1.59846675e-02f, 1.02860786e-01f, -1.52670041e-01f, 1.57137383e-02f, -4.52023484e-02f, 1.75748631e-01f, 2.81413011e-02f, 2.56660551e-01f, 1.64200872e-01f,
  9.04099345e-02f, -3.84885296e-02f, 3.86126377e-02f, -4.08441156e-01f, -1.47809044e-01f, 1.93908066e-02f, 2.86408365e-02f, -4.10023853e-02f, 2.27723494e-01f, 2.90222108e-01f,
  -2.31607705e-01f, -6.94643613e-03f, -1.55308560e-01f, -2.32809603e-01f, 2.00142741e-01f, -1.56276263e-02f, 1.07733592e-01f, 9.82265249e-02f, -3.20748538e-02f, -7.38116577e-02f,
  -7.46922791e-02f, 3.21910560e-01f, 1.47202745e-01f, -2.09529251e-02f, 9.54674035e-02f, -1.92926768e-02f, 4.25387025e-02f, 8.11685324e-02f, 2.73557693e-01f, -1.89090177e-01f,
  -4.76807803e-02f, 8.68185833e-02f, -6.98879808e-02f, -1.25770926e-01f, -4.06812802e-02f, -3.41707766e-02f, -2.90093511e-01f, 1.04615159e-01f, -3.56874049e-01f, -2.96707954e-02f,
  -1.01771146e-01f, 4.11534995e-01f, 5.64235076e-02f, -7.86271170e-02f, 2.07196400e-01f, -2.74363067e-03f, -1.82679757e-01f, 5.45735508e-02f, -1.10204689e-01f, 1.71507388e-01f,
  -3.00470978e-01f, 2.34611034e-01f, 1.65505223e-02f, 6.49082363e-02f, -2.94104428e-03f, -3.83040383e-02f, -8.44064802e-02f, -1.23842157e-01f, -1.89895079e-01f, -2.28225380e-01f,
  -3.12580206e-02f, 7.47379065e-02f, -2.36688890e-02f, 8.20493773e-02f, -1.43404454e-01f, 1.31565243e-01f, -1.21899851e-01f, -8.70595202e-02f, 1.04697831e-01f, -2.35122189e-01f,
  8.16422254e-02f, 2.51920611e-01f, -3.62603456e-01f, 1.33691415e-01f, 2.27085315e-02f, -8.40883479e-02f, 3.27643037e-01f, 1.34680063e-01f, 1.38627097e-01f, -1.55937344e-01f,
  1.34660155e-01f, 1.46827027e-01f, -1.59385726e-02f, 4.75837439e-02f, 2.33911783e-01f, 6.07497804e-02f, 1.56930596e-01f, 2.14957848e-01f, 9.34665725e-02f, 2.84393549e-01f,
  5.66858724e-02f, 3.75912860e-02f, 2.07085647e-02f, 5.47289252e-02f, -1.15613744e-01f, 1.78233981e-01f, -1.83827817e-01f, 3.78336608e-02f, -1.23076878e-01f, 1.60669878e-01f,
  -1.24424763e-01f, -4.51854676e-01f, 2.01143682e-01f, -1.42966375e-01f, -2.09271789e-01f, -9.64544788e-02f, 1.30751759e-01f, 3.56294401e-02f, -1.63778797e-01f, -3.28154534e-01f,
  9.72161666e-02f, -5.90299442e-02f, 2.81351209e-01f, -9.48218107e-02f, 1.83595002e-01f, 8.99675563e-02f, 6.38899356e-02f, 6.03239946e-02f, 1.09209679e-02f, -3.72379087e-02f,
  -1.38373151e-01f, -3.61575186e-02f, 7.05917031e-02f, 8.87323990e-02f, 1.15805700e-01f, -1.42218173e-01f, 3.55622428e-03f, -9.90456641e-02f, 1.25886992e-01f, 4.96834964e-02f,
  1.24507055e-01f, -6.50887266e-02f, -6.65461868e-02f, -9.61029083e-02f, -2.09743790e-02f, 4.24926654e-02f, 2.21692920e-01f, 1.16589978e-01f, -4.39829752e-02f, -5.28422892e-02f,
  -3.86977307e-02f, -3.57647240e-02f, 1.37477323e-01f, -2.00330585e-01f, 3.48203033e-02f, -8.79475102e-02f, 1.91587016e-01f, 1.15100779e-01f, -7.04506487e-02f, 1.89726934e-01f,
  1.14111425e-02f, -7.25086331e-02f, 3.37057620e-01f, 9.80105847e-02f, 5.54269105e-02f, 3.78473103e-01f, 3.48021746e-01f, 2.19087955e-02f, -9.70190540e-02f, 1.07080869e-01f,
  7.38795921e-02f, 6.42508864e-02f, 1.17474925e-02f, 1.89244039e-02f, -1.88367367e-01f, 3.46500635e-01f, -1.43953145e-01f, -9.71283615e-02f, -1.45696467e-02f, 3.78910869e-01f,
  1.56170532e-01f, -8.40384886e-03f, 4.83800098e-02f, -1.92550272e-01f, -2.11126655e-01f, -4.36242595e-02f, 1.27174884e-01f, -2.85512209e-02f, -1.35866329e-01f, 2.22100571e-01f,
  -5.02761975e-02f, -1.55172087e-02f, 1.59152791e-01f, -1.97787151e-01f, -2.05708595e-04f, -2.03706503e-01f, -2.38035545e-02f, 6.35360274e-03f, 2.13987634e-01f, -6.12215847e-02f,
  -1.57127324e-02f, 9.05024726e-03f, -1.86914504e-01f, 1.50540948e-01f, 7.23339394e-02f, 2.83166111e-01f, 2.30789945e-01f, -1.57784317e-02f, 1.66239604e-01f, 2.24957213e-01f,
  -1.19720779e-01f, -7.59179741e-02f, 1.67979077e-01f, -3.19459468e-01f, 2.22246155e-01f, 2.89785087e-01f, 1.06720962e-02f, -1.34014208e-02f, 1.32131368e-01f, 3.91098484e-02f,
  5.98150014e-04f, 1.18745737e-01f, 9.19580385e-02f, 2.63816893e-01f, 4.41909991e-02f, -2.31830657e-01f, -3.04726902e-02f, 2.32249200e-02f, 1.91545501e-01f, -2.29322705e-02f,
  3.39164808e-02f, -7.47092441e-02f, 2.82164887e-02f, 2.03346550e-01f, -2.30913296e-01f, -7.03555346e-02f, -3.77055913e-01f, -2.46638045e-01f, -1.93377078e-01f, -1.24292091e-01f,
  3.59023064e-01f, -4.90136445e-04f, -4.45567854e-02f, -3.30412202e-02f, 2.18149528e-01f, -4.70185615e-02f, 2.81822998e-02f, -1.83724031e-01f, 2.58837759e-01f, -2.19175279e-01f,
  6.86889142e-02f, -1.28830120e-01f, 1.38831273e-01f, -1.87254861e-01f, 2.11460203e-01f, -9.77378041e-02f, 2.12271377e-01f, 1.27696216e-01f, -6.03624955e-02f, -2.09264815e-01f,
  1.78216159e-01f, 2.17866585e-01f, -5.95848523e-02f, 2.26114225e-02f, -4.24691699e-02f, -1.53656125e-01f, 7.06017315e-02f, -6.71058968e-02f, -5.07572778e-02f, 2.81977773e-01f,
  -1.02215474e-02f, -5.79424873e-02f, -2.52485182e-02f, 1.70315236e-01f, 1.79150179e-01f, -3.92114930e-02f, 3.90408374e-02f, -7.18032271e-02f, 1.43422365e-01f, -7.27701783e-02f,
  2.52251834e-01f, 5.84783629e-02f, -3.79960239e-02f, 8.88259187e-02f, 1.24902420e-01f, 3.04848224e-01f, 1.15409158e-01f, -2.40246411e-02f, -7.47815445e-02f, 2.32029743e-02f,
  -7.46029392e-02f, -2.40217313e-01f, 2.00793341e-01f, 1.37937814e-01f, 1.72562972e-01f, -3.47612277e-02f, 7.38349035e-02f, -1.54438913e-01f, 2.74473667e-01f, 9.00871679e-02f,
  1.23259194e-01f, 1.24758773e-01f, 2.24237785e-01f, 2.32631072e-01f, 1.54609547e-03f, 1.68203250e-01f, 4.95025590e-02f, 5.20034134e-02f, -6.60333708e-02f, -1.80947185e-01f,
  1.52287548e-02f, 3.02171797e-01f, -7.81643763e-02f, 1.17101066e-01f, 6.70145899e-02f, 5.14402501e-02f, 6.33692294e-02f, 1.34861127e-01f, 1.45443827e-01f, 5.31191938e-02f,
  -3.16563174e-02f, 4.82101478e-02f, -7.73590058e-02f, 1.42973393e-01f, -2.71698050e-02f, 3.42330575e-01f, 2.04742208e-01f, 9.67462361e-02f, -5.43868393e-02f, -9.60902125e-02f,
  -1.51821926e-01f, 1.11167029e-01f, 2.02206284e-01f, 1.43411858e-02f, 1.49025738e-01f, 3.15233432e-02f, 4.46488820e-02f, 1.43852714e-03f, 1.90677837e-01f, -4.10919264e-03f,
  1.40764728e-01f, -2.05666814e-02f, 7.04049915e-02f, -7.03763822e-03f, -6.25631586e-03f, 5.61589226e-02f, -1.20688915e-01f, 5.37707433e-02f, 2.53655110e-02f, -1.94764584e-01f,
  8.61001909e-02f, 1.08040988e-01f, 1.68569535e-02f, 2.31935665e-01f, -8.51407647e-03f, -5.56165464e-02f, -1.63488567e-01f, 1.60504833e-01f, 4.93386127e-02f, -3.54290381e-02f,
  -1.54177502e-01f, 2.26439238e-01f, 6.70402497e-02f, 7.36432755e-03f, 3.80253419e-02f, 1.81721166e-01f, -2.34804422e-01f, -9.34786722e-02f, -4.35766011e-01f, -1.95038086e-03f,
  -2.43289918e-01f, 2.28859380e-01f, 6.32974952e-02f, 6.30427524e-02f, 1.41109481e-01f, -1.06408164e-01f, -6.97383508e-02f, 1.26736775e-01f, -3.18145715e-02f, 1.07662432e-01f,
  -4.01774123e-02f, 2.58090913e-01f, -6.79830834e-02f, 1.66840628e-01f, 7.08166957e-02f, -1.14449404e-01f, -1.67849258e-01f, 9.41593125e-02f, -1.89897537e-01f, -7.82125369e-02f,
  1.21868491e-01f, -1.25423828e-02f, 2.22221911e-02f, 1.63694426e-01f, -1.54692829e-02f, -4.20856886e-02f, 2.03681052e-01f, -4.73931938e-01f, 1.42073512e-01f, -4.79823165e-02f,
  1.23595551e-01f, 5.86954877e-02f, 1.09474184e-02f, 1.98465526e-01f, 4.15740050e-02f, -1.59347132e-01f, -2.11095959e-02f, 2.37683393e-02f, 2.08980337e-01f, -1.23210721e-01f,
  5.78065589e-03f, -4.74655516e-02f, -1.00058794e-01f, -6.48499802e-02f, -1.31543398e-01f, -5.24393953e-02f, 1.24112695e-01f, 5.41986637e-02f, -5.15567251e-02f, 9.45151970e-02f,
  -3.05087995e-02f, -2.03243151e-01f, 3.58999670e-02f, 4.96414565e-02f, -2.00468630e-01f, 2.15306580e-02f, -7.86245614e-02f, 8.86529535e-02f, 1.27560034e-01f, -2.83274911e-02f,
  -1.20504640e-01f, -7.45293349e-02f, -1.70293137e-01f, 2.41193082e-02f, 1.75382607e-02f, 1.63760513e-01f, 6.46554902e-02f, 1.06071696e-01f, 1.39325067e-01f, 8.71632993e-02f,
  -6.33349270e-02f, 8.07214379e-02f, 6.48489594e-02f, -5.33530638e-02f, 2.99602561e-02f, 2.73182780e-01f, 5.12571111e-02f, 9.07906145e-02f, -2.73935813e-02f, -2.53935717e-02f,
  -1.79298408e-02f, 7.11693242e-02f, 6.51836721e-03f, -4.70587835e-02f, -9.73336864e-03f, -1.68870404e-01f, -3.80454548e-02f, 1.00012701e-02f, -1.80323441e-02f, -1.15266435e-01f,
  1.05326198e-01f, -7.38248304e-02f, 3.87510173e-02f, 1.61522686e-01f, -1.11453727e-01f, 8.77338946e-02f, 2.02845652e-02f, 1.87409803e-01f, -2.48940900e-01f, -1.38493538e-01f,
  -1.78498596e-01f, -6.35620579e-02f, 2.04057679e-01f, 2.06611026e-02f, 1.91231191e-01f, 1.48043498e-01f, -1.63328871e-01f, 9.71191525e-02f, -8.41515586e-02f, -2.35229447e-01f,
  9.08673927e-02f, -2.68713608e-02f, -5.41886576e-02f, 1.53914988e-02f, 6.26343042e-02f, -1.51842967e-01f, 8.60409737e-02f, -2.85585523e-01f, -1.06240306e-02f, 9.90730599e-02f,
  1.49884438e-02f, 1.07911848e-01f, 9.28188339e-02f, 1.50174022e-01f, -3.68652582e-01f, 1.49473548e-01f, 2.24234369e-02f, 1.96916789e-01f, -2.53207594e-01f, -7.18187988e-02f,
  -5.64235635e-02f, 5.02763800e-02f, -8.21741074e-02f, 3.35083723e-01f, -1.08319640e-01f, 1.23680823e-01f, 1.73627153e-01f, -6.09019138e-02f, -3.15363288e-01f, -1.19219720e-01f,
  -9.20293927e-02f, -1.05624124e-02f, 3.02961189e-02f, -2.51404017e-01f, 1.45357877e-01f, 3.21726531e-01f, 7.93618560e-02f, 5.23424037e-02f, 1.26136234e-02f, -2.74314303e-02f,
  8.34835917e-02f, -2.83575922e-01f, -1.36586890e-01f, -3.07495501e-02f, -1.86658843e-04f, 2.69337833e-01f, -1.37362443e-03f, 1.50563613e-01f, 1.65157601e-01f, -9.15387869e-02f,
  5.29267006e-02f, -5.55374324e-02f, -1.02812625e-01f, -2.10552767e-01f, -1.93611398e-01f, -2.90918909e-02f, -2.64904886e-01f, 1.88010722e-01f, -2.01104552e-01f, 1.45780757e-01f,
  -1.32075697e-01f, 1.24504052e-01f, 1.19832516e-01f, -8.54998175e-03f, 7.16304481e-02f, -1.38718203e-01f, 1.01340048e-01f, -8.56666043e-02f, -2.88389660e-02f, 8.82347971e-02f,
  -3.12700331e-01f, 7.77651966e-02f, 3.73022318e-01f, -3.23606208e-02f, -1.03113130e-02f, 5.63662648e-02f, -1.60952479e-01f, -2.14386970e-01f, 2.28696510e-01f, -1.48208931e-01f,
  -2.22639237e-02f, 1.15060017e-01f, -8.38659555e-02f, 1.69582576e-01f, -9.02676359e-02f, 9.21500102e-02f, -6.35714531e-02f, 1.15739696e-01f, 1.77624017e-01f, 1.42883912e-01f,
  7.06894472e-02f, -7.33689442e-02f, 1.70443252e-01f, -3.28788944e-02f, 1.18168071e-01f, -1.20235167e-01f, 2.03750539e-03f, 2.64449686e-01f, 7.30711967e-02f, 1.96189374e-01f,
  1.19288854e-01f, 8.63751620e-02f, 1.64379701e-01f, 1.15150385e-01f, -1.14083350e-01f, -1.61054030e-01f, 2.52429093e-03f, 1.84559017e-01f, 2.78139621e-01f, -1.12740882e-01f,
  3.88455167e-02f, 2.98504308e-02f, -1.80052482e-02f, 1.56192132e-03f, 6.53191507e-02f, 1.98897813e-02f, -1.68351457e-02f, 3.03694874e-01f, -6.83752969e-02f, -1.39570460e-01f,
  1.88216537e-01f, 1.47994161e-01f, 7.48575490e-04f, -2.40861960e-02f, 3.01693613e-03f, -1.63630366e-01f, -1.39313951e-01f, -3.63788337e-01f, -1.89825654e-01f, 3.54208291e-01f,
  -1.23918913e-01f, -1.12114839e-01f, -1.18161693e-01f, -2.98376083e-02f, -1.00099795e-01f, -7.84787722e-03f, -1.89749822e-01f, -8.61158296e-02f, 8.76166020e-03f, 9.93303433e-02f,
  1.78413585e-01f, -3.33247446e-02f, -5.77572286e-02f, 6.21011183e-02f, -1.72072932e-01f, 6.57880260e-03f, -7.26967454e-02f, 7.26372898e-02f, -6.29492197e-03f, 5.27265109e-02f,
  1.21913910e-01f, 3.07726562e-01f, -1.46604165e-01f, 2.21096858e-01f, -2.37532388e-02f, -2.18770262e-02f, 3.96795571e-02f, 1.89178109e-01f, 1.31871715e-01f, 1.50892287e-01f,
  -1.02262624e-01f, 3.42938937e-02f, -4.38771769e-02f, 2.38448922e-02f, -1.88453212e-01f, -1.89931262e-02f, -2.35900143e-03f, 6.15888573e-02f, 5.80885671e-02f, 1.75398901e-01f,
  -1.11311842e-02f, -7.72008896e-02f, 1.29504874e-01f, -3.53163391e-01f, -4.66413088e-02f, 2.78611984e-02f, -9.18469056e-02f, -8.82097334e-03f, 9.68264341e-02f, 6.18456304e-02f,
  -6.74871132e-02f, 3.54778431e-02f, -9.74300057e-02f, -2.29397252e-01f, 9.80291888e-02f, 2.15543453e-02f, 1.30553931e-01f, -7.23819658e-02f, 2.95385476e-02f, -1.68632627e-01f,
  8.14372860e-03f, -1.66150272e-01f, -1.19941384e-01f, 1.49125516e-01f, -2.51805574e-01f, -6.03174269e-02f, 8.77247229e-02f, -3.96068513e-01f, -3.50340843e-01f, -1.42603546e-01f,
  -2.16074381e-02f, -1.20760575e-01f, -5.23725385e-03f, 1.66401476e-01f, 1.69967741e-01f, -2.06435919e-01f, 2.44744137e-01f, -1.02327526e-01f, -2.27741122e-01f, 3.70928422e-02f,
  -5.75633571e-02f, 7.39140809e-02f, -1.93577260e-01f, 2.70645116e-02f, 1.52765572e-01f, -5.43293394e-02f, 1.43137574e-01f, -1.04321629e-01f, -1.37496561e-01f, -2.29216099e-01f,
  -2.59417202e-02f, 9.95139331e-02f, -1.59742236e-01f, 5.23552448e-02f, -1.26621783e-01f, 2.06749290e-01f, 1.78024285e-02f, 1.05152331e-01f, 2.03325436e-01f, 9.48689654e-02f,
  -8.52958187e-02f, -2.42964864e-01f, 1.20762780e-01f, 6.82527721e-02f, -1.22689798e-01f, -8.86128545e-02f, -8.10158774e-02f, -1.22950319e-03f, -2.36117154e-01f, 2.12031193e-02f,
  -1.85768977e-01f, -1.41194448e-01f, 2.19994664e-01f, -6.29117340e-02f, -2.22077668e-01f, 2.01652497e-01f, -2.91477174e-01f, -5.91981709e-02f, 2.32948754e-02f, 2.47584179e-01f,
  -4.75292392e-02f, 1.54391408e-01f, -7.64087364e-02f, 1.69320494e-01f, 3.19526613e-01f, 2.80771434e-01f, 7.60902613e-02f, -7.72041082e-02f, 4.12192404e-01f, 2.06738994e-01f,
  2.38414541e-01f, 4.29306179e-01f, 2.96473913e-02f, -2.04083651e-01f, 5.14536917e-01f, 1.65097028e-01f, -3.43064852e-02f, -2.69319743e-01f, -2.90602982e-01f, -1.69625878e-01f,
  2.32964858e-01f, -1.03703747e-02f, 2.06448853e-01f, 6.20075911e-02f, -2.53011912e-01f, 2.69136995e-01f, -1.59409419e-01f, -2.31376477e-02f, -8.33807737e-02f, -1.48445413e-01f,
  2.46838834e-02f, -1.01075787e-02f, 3.84641029e-02f, 4.54320125e-02f, 5.50250104e-03f, 5.59294485e-02f, -3.76144284e-03f, 4.64533307e-02f, 7.74152949e-02f, 2.00606897e-01f,
  3.69747207e-02f, -3.90037335e-02f, 1.25182709e-02f, -8.59887991e-03f, 1.55722126e-01f, -2.58394092e-01f, -2.69504607e-01f, 1.94453105e-01f, -2.44317397e-01f, 1.04741134e-01f,
  -7.80366883e-02f, -4.67698574e-02f, 4.68708277e-02f, 1.33055961e-02f, 4.76980992e-02f, 1.10718012e-01f, -1.74616680e-01f, -3.44439149e-01f, 1.61951408e-01f, 2.95175493e-01f,
  1.36506766e-01f, 3.28288764e-01f, -3.33458185e-02f, 7.78550701e-03f, 9.12102461e-02f, 7.11990346e-04f, 8.85017663e-02f, -1.16048023e-01f, -5.50463833e-02f, 7.37825632e-02f,
  3.24244867e-03f, -3.00414916e-02f, 2.40231678e-01f, 8.66904333e-02f, -8.88487995e-02f, 1.86717376e-01f, 5.06190434e-02f, -9.09036174e-02f, -5.67976423e-02f, 6.19596206e-02f,
  -7.04531791e-04f, 2.54267752e-02f, 8.52266699e-02f, 2.86946911e-02f, -9.16064307e-02f, 3.12156081e-01f, -1.07580855e-01f, -7.83926696e-02f, 1.80151910e-02f, 2.83418357e-01f,
  4.27302569e-02f, -3.69834937e-02f, 4.93681394e-02f, 3.04197103e-01f, -7.55435452e-02f, 1.08839892e-01f, 8.25739000e-03f, 7.81166703e-02f, -1.47060245e-01f, 1.67721286e-01f,
  -1.55560881e-01f, -5.81150502e-02f, 4.67807846e-03f, -3.63628119e-02f, -6.67792037e-02f, 4.15527038e-02f, -2.35251170e-02f, -1.54100731e-01f, 7.47284889e-02f, 7.23661482e-02f,
  3.28483712e-03f, 7.81185254e-02f, -1.23093441e-01f, 1.09494023e-01f, -6.27672113e-03f, -6.85118958e-02f, 6.94279596e-02f, -5.45610078e-02f, 2.10951474e-02f, 9.68226343e-02f,
  -6.68364018e-02f, 4.36518639e-02f, 6.39724955e-02f, -1.43843770e-01f, 1.41448691e-01f, 1.21021986e-01f, -2.52537499e-03f, -3.65328789e-02f, -3.18897627e-02f, 6.98507875e-02f
};

// L2_fan_Bp_bar (Shape: 1 x 40)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 40;
const float L2_fan_Bp_bar_data[] = {
  2.11276095e-02f, -5.98684847e-02f, 2.47296616e-02f, -2.39896402e-02f, 2.38950141e-02f, 1.50493518e-01f, -2.40705013e-02f, -1.05805911e-01f, -2.44026557e-02f, -1.72093359e-03f,
  1.38131067e-01f, 2.37999022e-01f, -3.97549048e-02f, 1.13887921e-01f, 7.54641835e-03f, 1.74293533e-01f, -2.21863780e-02f, 4.36095037e-02f, 1.41200600e-02f, -1.16234787e-01f,
  1.94087401e-01f, 1.25803268e-02f, 1.36164781e-02f, 2.89740432e-02f, 5.50315864e-02f, 1.77003786e-01f, -1.71463247e-02f, 3.06364074e-02f, 1.19836725e-01f, 1.11277848e-01f,
  1.96555570e-01f, -8.43019187e-02f, 8.29475671e-02f, 5.56156263e-02f, 7.17501342e-02f, 2.70865615e-02f, -4.06013466e-02f, 2.39257123e-02f, 2.24502519e-01f, -2.62037888e-02f
};

// L3_fan_Wp (Shape: 12 x 64)
const int L3_fan_Wp_rows = 12;
const int L3_fan_Wp_cols = 64;
const float L3_fan_Wp_data[] = {
  1.18133828e-01f, -4.61379401e-02f, 3.03595737e-02f, 6.68196827e-02f, -3.75697166e-02f, 1.04012467e-01f, 2.70950496e-01f, 1.15699276e-01f, 3.93281579e-02f, 9.77065265e-02f,
  5.47983963e-03f, 4.76052091e-02f, 4.05031368e-02f, 1.94256678e-01f, 1.83284283e-01f, -1.65946335e-01f, -2.70886943e-02f, 1.51603967e-01f, 2.26467922e-02f, -5.52638248e-03f,
  -2.64496088e-01f, 6.28698468e-02f, 5.01909144e-02f, -3.93143818e-02f, -9.62102413e-02f, -2.88861781e-01f, -1.32444993e-01f, -1.89678341e-01f, -1.80342346e-02f, 1.30840037e-02f,
  1.79499716e-01f, -3.32719088e-02f, 1.40828297e-01f, 1.92915427e-03f, -1.19877622e-01f, 6.85355514e-02f, 4.21525305e-03f, -3.84527706e-02f, -3.04736476e-02f, -7.41375908e-02f,
  1.03376922e-03f, 1.64966583e-01f, 1.08592436e-01f, 1.88119672e-02f, -1.91859916e-01f, 3.92187461e-02f, -2.52643824e-02f, 1.20053641e-01f, 8.41014087e-02f, 1.04290619e-01f,
  1.24433875e-01f, -1.85302123e-01f, 1.29041746e-01f, -1.47752121e-01f, -6.84063360e-02f, -9.62159336e-02f, -1.88649818e-02f, -1.46594018e-01f, -2.90511250e-01f, 7.02597201e-02f,
  1.19088128e-01f, 2.67315041e-02f, 2.08788559e-01f, -4.94420454e-02f, -2.57463679e-02f, -1.93972830e-02f, -1.05437316e-01f, 1.09046705e-01f, -1.09230235e-01f, -1.79017752e-01f,
  2.46527437e-02f, 1.81908160e-01f, -1.06699131e-01f, -7.47939423e-02f, -2.25174934e-01f, 1.50167182e-01f, -4.06392291e-02f, -2.30545551e-01f, -7.02891573e-02f, -3.52947600e-02f,
  -1.26709118e-01f, -1.18806601e-01f, 2.29438907e-03f, -1.61411703e-01f, 9.13438667e-03f, 1.07379414e-01f, 2.78538525e-01f, -1.18592694e-01f, 8.17805305e-02f, 1.64057851e-01f,
  2.61331219e-02f, -2.01599345e-01f, 1.61336288e-01f, 2.80615943e-03f, 1.08709022e-01f, 3.15496176e-02f, 8.02819133e-02f, 5.21182381e-02f, 2.06297953e-02f, -2.57425219e-01f,
  -4.55816798e-02f, 3.56590888e-03f, 1.14915408e-01f, -1.13162205e-01f, 4.39963043e-02f, -1.05292220e-02f, -1.04693584e-02f, -4.83383611e-02f, 6.25126734e-02f, 1.82089835e-01f,
  2.45957091e-01f, 8.26149434e-02f, -9.50630233e-02f, -1.62012234e-01f, -7.85631165e-02f, 2.09474284e-02f, -6.80934116e-02f, 1.51764244e-01f, 8.20814967e-02f, -1.57426707e-02f,
  -4.31243405e-02f, -1.11767188e-01f, 2.89221946e-02f, 2.22886670e-02f, -2.91538215e-03f, 4.08572033e-02f, 1.22921996e-01f, 9.65938568e-02f, 6.65119588e-02f, -1.13513671e-01f,
  -1.10491097e-01f, -8.95290598e-02f, -2.66084850e-01f, -2.06302747e-01f, -1.15848221e-01f, -8.26223865e-02f, 9.21599120e-02f, -2.07776278e-01f, -6.84948564e-02f, 8.71310011e-02f,
  -8.62539485e-02f, -4.01095785e-02f, -4.71828692e-02f, 5.51519729e-02f, -4.87414422e-03f, -2.38825470e-01f, -1.46729767e-01f, -1.91572651e-01f, 7.75182620e-02f, 1.28446251e-01f,
  1.80998281e-01f, 8.19376484e-02f, 4.88540791e-02f, 8.76568854e-02f, -1.83624048e-02f, -1.65790494e-03f, -4.49463315e-02f, -1.67971432e-01f, -8.52721259e-02f, 1.29899502e-01f,
  -2.79538371e-02f, -2.17202250e-02f, 3.15948278e-02f, 2.66954862e-02f, -4.40562032e-02f, -7.28415847e-02f, 2.59479927e-03f, -4.72403876e-02f, -5.98539524e-02f, 1.04942331e-02f,
  1.54213831e-01f, -2.24479940e-02f, -7.40281940e-02f, -3.95900793e-02f, 1.94072008e-01f, 9.13879722e-02f, 4.45405468e-02f, -1.44576803e-01f, -8.12889356e-03f, 1.87361777e-01f,
  -1.33978250e-02f, -1.26776204e-01f, -6.05424233e-02f, 3.91111560e-02f, -1.19163990e-02f, 9.34339687e-02f, -1.60805598e-01f, -1.26478836e-01f, 9.36174765e-02f, 9.30831432e-02f,
  -7.66147599e-02f, 3.73646207e-02f, -5.09946346e-02f, -8.59996974e-02f, 7.82171171e-03f, 3.90290208e-02f, 5.95843047e-02f, 8.04418623e-02f, 8.25969800e-02f, 6.10694056e-03f,
  6.51199371e-02f, -1.70048520e-01f, -1.41980395e-01f, -1.45901918e-01f, -6.02027476e-02f, 3.26600783e-02f, -2.99587310e-03f, 8.85253251e-02f, 8.69402215e-02f, -2.86797255e-01f,
  -2.55899485e-02f, 2.39496857e-01f, 7.29546556e-03f, 2.20308304e-01f, -2.64564604e-01f, -1.93752032e-02f, -3.88386920e-02f, -1.73067808e-01f, -1.25124887e-01f, -1.45644397e-01f,
  5.15479781e-02f, 1.14076138e-02f, 5.62196113e-02f, 1.07374387e-02f, 9.73638296e-02f, -1.53546602e-01f, -4.26082611e-02f, -3.04267406e-02f, -2.01256089e-02f, 1.85874268e-01f,
  6.89176992e-02f, -2.52588019e-02f, 2.03782290e-01f, 1.90654006e-02f, -2.96834596e-02f, 7.79801160e-02f, -2.10451871e-01f, 2.56587844e-02f, -1.91142336e-02f, -2.67021675e-02f,
  1.30699769e-01f, -6.86456934e-02f, 4.24069613e-02f, 6.22036792e-02f, 2.07885858e-02f, 4.98853251e-02f, 1.12089120e-01f, -1.96599409e-01f, -7.80900568e-02f, -3.20559517e-02f,
  -2.09408611e-01f, 7.19763339e-02f, -1.18671738e-01f, -1.67853191e-01f, 1.43987477e-01f, -1.01697654e-01f, 1.50280088e-01f, 4.28896993e-02f, 9.27102789e-02f, -1.15423873e-02f,
  1.08699895e-01f, -1.14610367e-01f, 5.12825437e-02f, -4.56030890e-02f, -6.72414079e-02f, 6.90662637e-02f, 8.38007480e-02f, 2.35357329e-01f, 1.68862134e-01f, -3.87468487e-02f,
  3.06651630e-02f, -3.27540338e-02f, 1.90929592e-01f, -2.80451439e-02f, -1.53362259e-01f, 1.23055808e-01f, 2.09898040e-01f, -4.88087349e-02f, 7.97875598e-02f, -1.15192518e-01f,
  -7.97408633e-03f, 2.19059121e-02f, 8.76687765e-02f, 5.81081621e-02f, -1.00201942e-01f, 5.15111051e-02f, 2.42948253e-02f, 1.26800597e-01f, -8.53929445e-02f, -5.30560464e-02f,
  -4.69067469e-02f, -2.42328234e-02f, 3.20801139e-02f, 1.33891404e-01f, -1.04644664e-01f, 2.83454778e-03f, -6.13863859e-03f, 3.05266809e-02f, -1.74042568e-01f, 1.23743564e-02f,
  6.90252706e-02f, 1.58045456e-01f, -4.94683860e-03f, 6.28701299e-02f, -3.78673826e-03f, 1.12815835e-01f, -1.26073556e-02f, -2.58964207e-02f, 1.01112492e-01f, 4.36695665e-02f,
  -3.59193645e-02f, 1.00071784e-02f, -1.51142823e-02f, -6.19633123e-02f, 9.24292356e-02f, -9.97615308e-02f, -5.10595851e-02f, -1.68962032e-01f, -1.11933209e-01f, 5.87149672e-02f,
  -1.00630060e-01f, -1.60493687e-01f, 5.27376011e-02f, 2.72020549e-01f, -7.13752508e-02f, -4.91260067e-02f, -1.33426741e-01f, 5.24981469e-02f, 5.77032492e-02f, 1.44639947e-02f,
  -2.29341295e-02f, 8.23344737e-02f, -1.63978189e-01f, -7.54479915e-02f, 7.92893209e-03f, 1.03834547e-01f, -5.31974956e-02f, 3.17095429e-01f, 4.66495790e-02f, -1.11106664e-01f,
  -6.18158234e-03f, -1.88755706e-01f, 1.93949193e-01f, 2.42712647e-01f, 1.43372687e-03f, 3.56333666e-02f, 6.01024888e-02f, 2.62065371e-03f, 8.20784643e-03f, 5.64616825e-03f,
  -6.02905042e-02f, 2.92418394e-02f, -8.90164077e-02f, 8.30225367e-03f, 2.50783879e-02f, 3.86393778e-02f, 4.25803177e-02f, -5.76888546e-02f, -1.20139636e-01f, -1.97000280e-01f,
  -1.59646958e-01f, 2.12905500e-02f, -6.05010502e-02f, -1.53925523e-01f, 9.63377133e-02f, -1.68242887e-01f, 1.47471651e-01f, 3.06618176e-02f, -1.27436340e-01f, 1.24362931e-01f,
  -1.19044788e-01f, -1.17498651e-01f, -6.93345964e-02f, 1.12323113e-01f, -4.77904379e-02f, 4.87756617e-02f, 3.85522619e-02f, 7.19633177e-02f, 1.17687002e-01f, 8.31159353e-02f,
  -2.26636194e-02f, 2.13768780e-01f, -1.55253455e-01f, -9.56958681e-02f, -7.37658739e-02f, 2.71871328e-01f, 4.64758836e-02f, 1.86751828e-01f, 9.76355970e-02f, 5.00254482e-02f,
  6.23709857e-02f, 9.67682600e-02f, -4.75956611e-02f, -1.49307594e-01f, 1.52844749e-02f, -9.25969109e-02f, -9.53854993e-03f, 1.80140406e-01f, 7.35659674e-02f, 2.86323391e-02f,
  -4.31109555e-02f, -7.21247867e-02f, -1.19342864e-01f, -3.26290354e-02f, 2.00600624e-01f, 2.50150543e-02f, -1.20856561e-01f, -1.37620717e-01f, -1.23655237e-01f, -9.77031440e-02f,
  -1.32941306e-04f, -7.04896520e-04f, 1.55591210e-02f, -8.42161197e-03f, -5.81472591e-02f, -1.11978408e-02f, -8.63544419e-02f, -5.04740067e-02f, 1.66890174e-01f, 9.75333452e-02f,
  -1.14536472e-01f, 1.23907924e-01f, 4.08013649e-02f, -8.26098397e-02f, 1.13142639e-01f, 1.65143441e-02f, -1.65574461e-01f, 3.36266980e-02f, 5.94973564e-02f, 1.22485317e-01f,
  -1.19945273e-01f, 1.55058861e-01f, -6.13290630e-02f, 2.30321400e-02f, 8.51474181e-02f, -2.03719195e-02f, 1.79889947e-01f, 1.60253510e-01f, 1.68371379e-01f, -1.72523633e-01f,
  -2.82814559e-02f, 6.41548559e-02f, 1.41538724e-01f, 3.24923880e-02f, -6.41718833e-03f, -6.46447614e-02f, 9.26329345e-02f, 1.88442264e-02f, -1.79466065e-02f, 1.88406572e-01f,
  -1.57216758e-01f, -1.00769633e-02f, -7.79473260e-02f, -9.81033873e-03f, 8.94906819e-02f, -8.91289711e-02f, 2.15557694e-01f, 2.32020300e-02f, -1.93691656e-01f, -7.57175311e-02f,
  -9.21497047e-02f, 2.00531036e-02f, 8.72058049e-03f, -3.77980098e-02f, 8.76616389e-02f, -3.16140741e-01f, -1.13637233e-02f, 1.28269903e-02f, 2.66133752e-02f, 1.68803744e-02f,
  -2.96165109e-01f, -1.15527146e-01f, -3.53193693e-02f, -3.40900458e-02f, 3.96335591e-03f, 4.09514196e-02f, 2.24093303e-01f, -3.44931521e-02f, -7.55951107e-02f, -3.10255773e-02f,
  1.12276278e-01f, -1.34161815e-01f, -1.81003325e-02f, 1.61535889e-01f, -1.64727960e-02f, -2.83755511e-02f, 9.85174775e-02f, 2.75381021e-02f, 9.55317914e-02f, -4.65787128e-02f,
  4.64685913e-03f, 1.05128521e-02f, 1.09684113e-02f, 9.63641033e-02f, -3.78355198e-02f, -5.46592399e-02f, 1.14944838e-01f, -9.59097967e-02f, 1.51783898e-01f, -6.52294829e-02f,
  -3.47518772e-02f, -1.66303128e-01f, 1.30926236e-03f, -3.71158086e-02f, -4.43496667e-02f, 5.79195060e-02f, 1.38993636e-01f, 1.38120040e-01f, -7.09220171e-02f, 1.17623068e-01f,
  1.17587551e-01f, -5.09311557e-02f, -6.23272397e-02f, -1.08521134e-01f, -4.58044149e-02f, -1.19936965e-01f, 8.19599181e-02f, -5.74720092e-02f, 1.44759670e-01f, 8.28845575e-02f,
  -2.58974824e-02f, 5.88962622e-02f, -1.96068641e-02f, 5.30954301e-02f, 3.11165489e-02f, 1.33615583e-01f, -1.07669786e-01f, -1.50025591e-01f, 9.07779932e-02f, -1.93232298e-01f,
  1.51102170e-01f, 1.42568469e-01f, -1.17636994e-01f, -2.15073958e-01f, -8.22034013e-03f, 4.88838330e-02f, 1.03479773e-01f, -1.95428124e-03f, -2.08857544e-02f, -1.03012649e-02f,
  1.63272351e-01f, 1.14258684e-01f, -8.52274820e-02f, -1.11258812e-02f, 8.80748555e-02f, -2.60208696e-01f, -9.25008804e-02f, 7.89068714e-02f, 3.68687995e-02f, -3.85067202e-02f,
  1.11705184e-01f, -7.35332370e-02f, -1.75608426e-01f, -6.52620420e-02f, -1.41816691e-01f, 2.27478407e-02f, 1.07395954e-01f, 8.07455182e-02f, -1.52910436e-02f, 6.48218244e-02f,
  -1.38604254e-01f, -1.49093017e-01f, -5.36247753e-02f, 1.71198428e-01f, -8.75176340e-02f, 3.71047817e-02f, 2.02696845e-01f, 9.85684097e-02f, 1.61340043e-01f, 1.27156958e-01f,
  -9.29211900e-02f, -8.31854641e-02f, 1.44606024e-01f, -1.40357390e-01f, 2.03509346e-01f, -1.71013437e-02f, -8.18681195e-02f, 1.38705829e-02f, -9.81346965e-02f, -1.28364637e-01f,
  1.86534539e-01f, -1.83783457e-01f, -1.77883267e-01f, 1.44050755e-02f, -1.27789199e-01f, 9.55428481e-02f, -2.78040301e-02f, -1.70427829e-01f, 1.41820282e-01f, -5.93592674e-02f,
  1.23414062e-01f, 4.49627498e-03f, -5.23764193e-02f, -2.24151954e-01f, -1.30241901e-01f, -1.45707265e-01f, 2.10488230e-01f, 1.68120921e-01f, 2.32919957e-02f, -2.96108872e-01f,
  -9.74016860e-02f, 1.16565354e-01f, 1.73632532e-01f, 2.38435224e-01f, 1.59813985e-01f, -9.43301171e-02f, -1.22807749e-01f, 8.84596929e-02f, 2.67492197e-02f, 5.30778021e-02f,
  2.78291792e-01f, -2.32551638e-02f, -9.25647169e-02f, -2.29327023e-01f, -8.60293880e-02f, 2.76090242e-02f, -6.70536049e-03f, -7.24871084e-02f, 6.29476234e-02f, 5.71604483e-02f,
  -1.23999948e-02f, -3.92564349e-02f, 7.21459910e-02f, -9.37320143e-02f, -1.34260967e-01f, 7.82198831e-02f, -7.40286782e-02f, -1.05017997e-01f, -1.19551830e-01f, -8.47651809e-02f,
  -3.26631442e-02f, 5.11028469e-02f, 6.48251781e-03f, 5.82756028e-02f, 3.58880073e-01f, 7.47595727e-02f, 8.61926079e-02f, 1.08431533e-01f, -3.75327952e-02f, -1.89102069e-02f,
  -1.68327689e-01f, 4.04295512e-02f, -1.35121435e-01f, -1.33091956e-01f, -5.06200902e-02f, -1.91080198e-01f, -1.22359255e-03f, -2.17605665e-01f, -4.39498462e-02f, -7.70977363e-02f,
  -1.10410221e-01f, -9.10106376e-02f, -1.65224433e-01f, 2.73318752e-03f, -5.29981740e-02f, -1.24711365e-01f, 4.54541780e-02f, -3.55722755e-02f, -1.92554578e-01f, 3.47860195e-02f,
  2.24635944e-01f, 2.36579329e-01f, -5.23211285e-02f, 1.91650227e-01f, 8.64108931e-03f, -1.22180633e-01f, -1.29854381e-01f, 1.34054869e-01f, -1.76005380e-03f, -5.91162825e-03f,
  8.66620243e-02f, 6.43017963e-02f, 1.53953478e-01f, 1.20436121e-02f, -1.64290739e-03f, 5.27166575e-02f, -6.83003217e-02f, 1.40837312e-01f, 2.63356119e-02f, 1.08965993e-01f,
  9.19260383e-02f, -6.52941242e-02f, 6.59530312e-02f, 1.21741585e-01f, -8.01221430e-02f, -4.56669880e-03f, -6.01282492e-02f, -1.41321728e-02f, 1.01768538e-01f, -1.84140965e-01f,
  3.82294245e-02f, -1.03427909e-01f, -1.85389295e-02f, -1.11314788e-01f, 1.25866175e-01f, 5.70661463e-02f, -4.00290005e-02f, 7.96866193e-02f, 1.03616379e-02f, -6.49584830e-02f,
  -9.34707895e-02f, 1.32393405e-01f, 4.62785624e-02f, 9.06488821e-02f, 3.30783390e-02f, 1.31803304e-01f, -7.76346261e-03f, 1.86272021e-02f, 1.04604915e-01f, -1.35072932e-01f,
  1.29059643e-01f, -7.58200511e-02f, 7.00981095e-02f, 5.26407547e-02f, -1.67087302e-01f, -5.89793883e-02f, -1.00900583e-01f, -2.49711767e-01f, 1.19114920e-01f, 1.61827300e-02f,
  2.37219945e-01f, -2.40717039e-01f, -9.67917293e-02f, 5.33417836e-02f, 2.29504377e-01f, 9.49349850e-02f, -3.06409568e-01f, -1.17709823e-01f, -8.28155950e-02f, -3.64827998e-02f,
  -1.88617397e-03f, 8.97082984e-02f, -9.62328445e-03f, 3.17723230e-02f, -1.37849033e-01f, 4.33397852e-02f, 1.02571227e-01f, -2.32416928e-01f, 9.10114273e-02f, 4.89455424e-02f,
  -4.46334369e-02f, 3.41670029e-02f, -5.55444546e-02f, 1.05678119e-01f, -6.14338592e-02f, 4.32476588e-02f, 7.25451857e-02f, 2.22013414e-01f, 3.96484062e-02f, 1.07814170e-01f,
  -9.66328010e-02f, -8.11446607e-02f, -3.05479579e-02f, -2.83894390e-02f, -2.23514321e-03f, 1.16498247e-01f, -6.96272999e-02f, -1.50892332e-01f, 1.47695437e-01f, -7.05249533e-02f,
  -1.03606306e-01f, -1.28776347e-02f, 1.10927239e-01f, 5.95787540e-02f, 5.19627444e-02f, 2.09956616e-01f, -4.41370942e-02f, 5.66318370e-02f
};

// L3_fan_Wp_bar (Shape: 40 x 64)
const int L3_fan_Wp_bar_rows = 40;
const int L3_fan_Wp_bar_cols = 64;
const float L3_fan_Wp_bar_data[] = {
  2.95528352e-01f, -4.66301665e-02f, 2.32569471e-01f, 8.12137350e-02f, 1.36504183e-02f, 5.63727655e-02f, 2.02507954e-02f, -4.86031771e-02f, 4.64711525e-02f, 2.61006467e-02f,
  2.76975721e-01f, 1.71629474e-01f, 3.57189365e-02f, 3.00743967e-01f, 7.53336623e-02f, -1.33265972e-01f, 1.24319986e-01f, 3.82319629e-01f, -1.88864201e-01f, -1.36302814e-01f,
  -7.51555711e-02f, 1.35263965e-01f, 3.06377746e-02f, -1.87540784e-01f, -1.06105387e-01f, 9.00623351e-02f, 1.63888559e-02f, -1.18826836e-01f, -2.54032612e-01f, 9.35481116e-02f,
  -9.74470004e-02f, 1.45066932e-01f, 1.33776761e-04f, 2.66400278e-01f, -6.08555563e-02f, 1.73732638e-01f, -4.19031084e-02f, 1.74172521e-02f, -1.54006585e-01f, -4.69673187e-01f,
  -6.53009936e-02f, -1.38693666e-02f, -5.12333214e-02f, 4.99609597e-02f, 9.56920758e-02f, -1.81440227e-02f, 2.88162883e-02f, 3.74114484e-01f, -2.22437978e-01f, 2.05782637e-01f,
  -5.03818750e-01f, 3.79624128e-01f, 1.08195171e-01f, 2.17630461e-01f, 3.39476876e-02f, 1.03480339e-01f, -1.93242311e-01f, -2.97233641e-01f, -3.92653227e-01f, 1.38935134e-01f,
  -3.51036519e-01f, -1.15688935e-01f, 2.81413794e-01f, -1.23407409e-01f, 5.91430813e-02f, 1.04852028e-01f, 3.35102677e-01f, 1.11218445e-01f, 4.05505955e-01f, 1.25146821e-01f,
  1.89416617e-01f, 1.62540048e-01f, -3.01780086e-02f, 1.94545984e-01f, 1.34589985e-01f, -3.02501419e-03f, -1.15495235e-01f, 1.33397400e-01f, 6.68462887e-02f, -1.71111047e-01f,
  -1.18263876e-02f, 1.85907602e-01f, 2.70893089e-02f, 1.71179846e-01f, -1.08145528e-01f, 1.16315916e-01f, -2.25965247e-01f, 1.21064465e-02f, 4.66783345e-03f, -2.15165243e-01f,
  1.63590252e-01f, 1.07579499e-01f, 5.43812513e-02f, 8.54867846e-02f, 6.66993391e-03f, -2.76843552e-02f, -5.62298633e-02f, -1.13536611e-01f, 9.46502388e-02f, 4.56633866e-01f,
  6.54149503e-02f, 2.77692050e-01f, -8.57067928e-02f, 6.00728057e-02f, 2.11654782e-01f, 2.30442673e-01f, 5.62210754e-02f, -6.48322478e-02f, 3.14995557e-01f, -9.69585963e-03f,
  -2.14717254e-01f, -1.43898964e-01f, 3.84623520e-02f, 3.08003575e-01f, 1.80616006e-01f, -1.08136937e-01f, 2.62871712e-01f, -1.14256501e-01f, 2.62371339e-02f, 2.05540150e-01f,
  -4.72869948e-02f, -9.41274967e-03f, 3.00767869e-01f, 1.28578275e-01f, 1.17716037e-01f, 1.96257815e-01f, 1.92452949e-02f, -1.20133460e-01f, 3.89182121e-02f, 9.89661142e-02f,
  -7.24274814e-02f, 2.00842261e-01f, 1.83668155e-02f, 1.07519478e-01f, 1.10106088e-01f, 3.12726587e-01f, -2.17484728e-01f, 1.28042832e-01f, 3.67969684e-02f, 1.50841624e-01f,
  2.95985155e-02f, -1.89471260e-01f, -3.66737470e-02f, -1.82236716e-01f, -2.10458457e-01f, -1.16443120e-01f, 9.29716453e-02f, -2.08582416e-01f, -3.91134582e-02f, -1.81429237e-02f,
  1.27881750e-01f, -5.34979925e-02f, 1.89503327e-01f, 4.08950061e-01f, 3.39394882e-02f, -2.34815273e-02f, 1.54207766e-01f, -6.75386414e-02f, 1.25332609e-01f, 1.37200356e-01f,
  5.43301832e-03f, 3.44410539e-01f, -5.39751351e-02f, -5.88311926e-02f, 2.77801394e-01f, -2.88261205e-01f, 3.33553068e-02f, 1.41861573e-01f, 3.01560154e-03f, 4.81850021e-02f,
  1.67313069e-01f, -5.36615476e-02f, -6.05608113e-02f, -2.05535032e-02f, 2.73910046e-01f, -3.23951393e-02f, 1.52086943e-01f, 9.52515304e-02f, 2.10442051e-01f, 9.72717181e-02f,
  -1.35049820e-01f, 5.37897348e-02f, -1.75770983e-01f, 1.14188299e-01f, -1.58430473e-03f, 3.68573070e-02f, -4.61999960e-02f, 6.64495602e-02f, 1.37949482e-01f, -5.45672737e-02f,
  2.94629872e-01f, 1.31886855e-01f, 1.14791803e-01f, 4.97717187e-02f, 8.70285854e-02f, 1.16891578e-01f, -9.03856680e-02f, 9.48587283e-02f, 9.47526172e-02f, -3.08563262e-01f,
  1.59089565e-01f, -2.40678396e-02f, 1.11905202e-01f, -1.23571739e-01f, 1.42423183e-01f, 1.40729427e-01f, 1.13830611e-01f, -3.67947333e-02f, 6.65664002e-02f, 1.06602579e-01f,
  -6.20097108e-02f, -1.24539413e-01f, -2.01506376e-01f, 5.15647642e-02f, 1.77838630e-03f, 2.14915857e-01f, 5.56502454e-02f, -1.49772331e-01f, -1.08069777e-02f, 1.65470123e-01f,
  1.34378016e-01f, 1.06522910e-01f, 1.93880722e-01f, 1.41915530e-01f, 1.21775560e-01f, 9.17073339e-02f, 1.47775725e-01f, -2.07699016e-02f, 4.74511087e-02f, 1.80273637e-01f,
  -9.03098360e-02f, 2.64560163e-01f, 1.97280720e-01f, 1.16349719e-02f, 1.36980176e-01f, 8.93099383e-02f, -1.78528517e-01f, 1.70657471e-01f, -7.53833279e-02f, -3.94087955e-02f,
  2.48221904e-01f, -5.63946888e-02f, 2.77921975e-01f, -4.63502407e-02f, 2.24111930e-01f, -1.94582433e-01f, -3.94328833e-02f, 1.07377440e-01f, 8.28386918e-02f, 1.62265703e-01f,
  1.30013660e-01f, 1.83894947e-01f, 1.99018672e-01f, -4.40652203e-03f, -2.35918224e-01f, -2.82395370e-02f, 8.30030516e-02f, 1.52296498e-01f, -1.86620057e-01f, -6.95094019e-02f,
  -2.87947208e-01f, 3.64858881e-02f, 1.16353750e-01f, -9.76091921e-02f, 1.81963518e-01f, 1.00323567e-02f, 5.06893843e-02f, -2.23838761e-01f, -1.05987519e-01f, -7.41690248e-02f,
  3.10871135e-02f, 1.57861322e-01f, -3.00629616e-01f, -1.08701382e-02f, -1.24344803e-01f, -2.90975392e-01f, -1.26026630e-01f, -9.54845399e-02f, 1.42136648e-01f, 3.28367464e-02f,
  2.40962163e-01f, -1.21606715e-01f, -1.79650523e-02f, 1.52822994e-02f, 5.22165783e-02f, -1.10912323e-01f, 6.65886924e-02f, -8.18772316e-02f, -1.15572885e-02f, 1.99008837e-01f,
  1.63845360e-01f, 1.52277559e-01f, 9.42543447e-02f, -1.98990941e-01f, 1.35530606e-01f, 1.22811072e-01f, -9.32765082e-02f, -1.84956715e-01f, 7.75556043e-02f, -9.87421498e-02f,
  9.80698988e-02f, 1.05364695e-01f, 1.80336922e-01f, 3.69153380e-01f, 7.65471905e-02f, 9.12693050e-03f, 2.18001947e-01f, 3.46132100e-01f, 6.00030646e-03f, 7.93763995e-02f,
  -8.04481469e-03f, -1.43421218e-01f, 4.46024537e-02f, 1.45057604e-01f, -2.55274355e-01f, 2.05690533e-01f, 4.10593711e-02f, 1.82117820e-01f, 4.43504691e-01f, 9.91860256e-02f,
  -1.67492121e-01f, 3.33921969e-01f, -6.37446791e-02f, -9.57102794e-03f, 8.67290869e-02f, -3.01815253e-02f, -4.65033716e-03f, 2.58534491e-01f, 8.92042369e-02f, -2.63295397e-02f,
  -9.71372053e-02f, -1.27601609e-01f, -1.20621912e-01f, 1.66965052e-01f, 9.58508775e-02f, -2.07231671e-01f, -1.98328197e-01f, -1.14590675e-01f, -4.44193892e-02f, -4.94620390e-02f,
  1.77018777e-01f, -1.49558231e-01f, -7.15848655e-02f, -3.94250929e-01f, -2.12651342e-01f, 1.47307947e-01f, 1.89901277e-01f, 5.79722486e-02f, 1.22943863e-01f, 1.58436611e-01f,
  -2.53336549e-01f, 1.74988937e-02f, 9.92745981e-02f, -7.37404674e-02f, 9.01664644e-02f, 5.31539619e-01f, -2.89644040e-02f, -1.25500560e-01f, 1.13652304e-01f, -4.66420762e-02f,
  -1.80867702e-01f, 1.23710833e-01f, -3.67486686e-01f, 8.44383016e-02f, 5.88706434e-01f, 1.02466851e-01f, 9.42768622e-03f, 8.35371166e-02f, -3.23450714e-02f, 9.76001844e-02f,
  -2.82305963e-02f, -1.46493137e-01f, 7.82019719e-02f, 1.17880911e-01f, 1.97245777e-01f, 2.95366291e-02f, 1.26599431e-01f, -5.26588187e-02f, -1.37060151e-01f, 1.10413164e-01f,
  -9.52628553e-02f, -1.50601700e-01f, 4.55291152e-01f, -2.41894331e-02f, 3.98382805e-02f, -2.02936336e-01f, 2.29464974e-02f, 1.89007252e-01f, 1.15601249e-01f, 1.84850305e-01f,
  8.38005394e-02f, 6.60518408e-02f, 4.89574559e-02f, -6.11931719e-02f, -3.09796296e-02f, 5.20736910e-02f, 4.01934981e-01f, 1.25774130e-01f, 2.07003485e-02f, -2.05602184e-01f,
  -2.65177518e-01f, 9.70248133e-02f, -1.40941516e-01f, -1.72170237e-01f, 1.51458219e-01f, 1.98197901e-01f, 1.21292897e-01f, -4.04452413e-01f, 2.26566061e-01f, 3.60365212e-01f,
  -5.32782637e-02f, 4.68944684e-02f, -5.18320836e-02f, -9.92575586e-02f, 1.39501005e-01f, 3.87003422e-01f, 8.72478783e-02f, 2.97918886e-01f, 5.85839972e-02f, -2.58074075e-01f,
  1.10955037e-01f, 3.85945775e-02f, -9.14964676e-02f, -1.14675626e-01f, -5.42309508e-02f, 2.65045434e-01f, 2.42123976e-01f, 5.36894500e-02f, -1.65187165e-01f, -6.04427308e-02f,
  6.64542615e-02f, 2.62651682e-01f, 1.31755307e-01f, 2.08728388e-02f, 3.09299380e-02f, -1.04034938e-01f, 7.92589113e-02f, -1.18377674e-02f, 1.76886752e-01f, 4.06251438e-02f,
  -1.98572233e-01f, -2.85045709e-02f, -1.53432608e-01f, 1.19680278e-01f, 1.32417390e-02f, -1.42520433e-03f, 1.72521174e-02f, 1.37916908e-01f, -9.19915587e-02f, 5.49524613e-02f,
  -3.45730573e-01f, -5.99421561e-02f, -2.42825493e-01f, -1.18581422e-01f, -3.91608328e-02f, -1.84047386e-01f, 2.44561031e-01f, -6.55066222e-02f, -2.00428545e-01f, -6.22626729e-02f,
  -1.70412123e-01f, -6.95792958e-02f, -5.54366224e-02f, -1.06156051e-01f, -1.43383235e-01f, -2.83300221e-01f, 1.48329465e-02f, -2.38247305e-01f, 1.10167310e-01f, 1.01550870e-01f,
  -5.71716353e-02f, -2.76716471e-01f, 1.65789396e-01f, -2.58733451e-01f, -2.61561424e-01f, 3.51467985e-03f, 2.16321781e-01f, -6.82157278e-02f, -5.06396256e-02f, 1.03222720e-01f,
  2.25673914e-01f, 7.90359825e-02f, 6.63622692e-02f, 9.56519041e-03f, -4.89259660e-02f, -3.07515096e-02f, 1.63819566e-01f, 1.25904366e-01f, -9.27852374e-03f, -3.36764939e-02f,
  2.13689610e-01f, 2.99272835e-01f, -1.85454533e-01f, -3.09258085e-02f, -1.18054256e-01f, 1.52678683e-01f, 6.99110478e-02f, -2.05364898e-01f, 1.35356486e-01f, 1.12500332e-01f,
  1.03838690e-01f, -3.13871443e-01f, 1.92187741e-01f, -1.64034277e-01f, 5.45276329e-02f, -5.94522245e-03f, -2.53722608e-01f, 2.43876994e-01f, -2.16198228e-02f, 2.83623040e-01f,
  9.77801979e-02f, 5.73404366e-03f, 4.92773611e-40f, 4.91878182e-40f, 4.91400339e-40f, -4.92966991e-40f, -4.90660453e-40f, -4.90490896e-40f, 4.91843149e-40f, -4.94720015e-40f,
  4.92584436e-40f, 4.91405944e-40f, 4.93335532e-40f, -4.90652046e-40f, -4.95454295e-40f, 4.93985735e-40f, 4.93891848e-40f, -4.91774486e-40f, -4.91300847e-40f, -4.94549057e-40f,
  -4.94097839e-40f, 4.92278953e-40f, -4.91829136e-40f, -4.95415059e-40f, -5.43263796e-40f, 4.92079969e-40f, 4.91485818e-40f, 5.13261996e-40f, -5.27352052e-40f, 5.15111710e-40f,
  4.92498957e-40f, -4.92241118e-40f, -1.03272045e-23f, 4.93800763e-40f, 4.93360756e-40f, 3.88413310e-40f, 5.10781698e-40f, -4.95962967e-40f, -5.71885318e-40f, 4.93854013e-40f,
  4.92363031e-40f, 4.90687078e-40f, 4.93736304e-40f, 2.31074117e-40f, -1.00593560e-35f, -4.97742616e-40f, 5.77126174e-40f, 1.02184191e-36f, -4.96955086e-40f, -6.30536597e-21f,
  -1.00072484e-22f, 4.93041259e-40f, 4.94823711e-40f, -5.02951242e-40f, 7.03691857e-36f, 6.11783087e-40f, -8.98109873e-23f, -5.02802705e-40f, 5.85504537e-40f, 4.90583382e-40f,
  -4.91361103e-40f, -1.03253133e-26f, 4.96498263e-40f, -4.91220973e-40f, 5.73231965e-40f, 4.98586198e-40f, -2.04567745e-01f, -9.86756384e-02f, -2.64822483e-01f, 4.73604426e-02f,
  -2.18729213e-01f, -2.53497005e-01f, -1.00522555e-01f, 6.20913841e-02f, 9.64248776e-02f, 2.21688271e-01f, -1.95115373e-01f, 1.20087862e-01f, -7.91683197e-02f, -9.82816815e-02f,
  -2.64856778e-02f, -3.18522364e-01f, 1.15060911e-01f, -2.79105380e-02f, -1.74299441e-02f, -3.54838043e-01f, 1.09298579e-01f, 1.23491071e-01f, 1.43776074e-01f, -3.33190888e-01f,
  1.82985306e-01f, -1.30424961e-01f, -1.68683246e-01f, 2.22795606e-01f, 1.60003141e-01f, -1.88483387e-01f, 7.52854496e-02f, 4.92912084e-02f, 6.28373027e-02f, -1.45662930e-02f,
  -8.19909945e-03f, -1.13608189e-01f, 1.41556531e-01f, -1.51250452e-01f, -8.06756392e-02f, 9.29591134e-02f, 6.22118870e-03f, -2.13488042e-01f, 1.82586581e-01f, 3.00263256e-01f,
  4.90927659e-02f, 4.77830395e-02f, 8.54755193e-02f, -5.14658809e-01f, 3.95687148e-02f, -2.46235788e-01f, 2.69682333e-02f, -7.41679668e-02f, -1.56603500e-01f, -1.99923143e-01f,
  -1.84561148e-01f, 8.23760480e-02f, -6.38678223e-02f, 1.26971081e-01f, -1.60361896e-03f, -4.53753658e-02f, 1.62114725e-01f, 4.23141450e-01f, -2.42130309e-01f, -7.42403325e-03f,
  1.94783241e-01f, 1.72548741e-01f, 3.32705468e-01f, 3.64115536e-01f, 3.31632756e-02f, 1.11515269e-01f, 1.67264566e-01f, -2.50206608e-02f, -1.06394023e-01f, -3.03912163e-02f,
  2.23471880e-01f, 1.18322939e-01f, 1.53200626e-01f, -8.47848281e-02f, -1.04886517e-01f, 1.94431648e-01f, -1.32615924e-01f, 1.06433980e-01f, 3.06041390e-01f, 1.99763924e-02f,
  -4.30673689e-01f, -3.57028604e-01f, -1.36172071e-01f, 4.24694538e-01f, -1.11407906e-01f, -8.88147652e-02f, -1.88821420e-01f, 1.37740389e-01f, 6.88761249e-02f, 1.01574384e-01f,
  3.44679318e-02f, -1.98040932e-01f, -7.23663270e-02f, -3.10844630e-02f, -1.70260146e-01f, 3.21441978e-01f, -1.41788032e-02f, 2.03393891e-01f, 1.12851165e-01f, 1.79434106e-01f,
  2.48106003e-01f, 1.22670002e-01f, 4.82617971e-03f, -1.48888409e-01f, -4.70668301e-02f, 1.08832149e-02f, -9.06766877e-02f, -1.76811352e-01f, 2.39607498e-01f, -3.64063913e-03f,
  2.01420695e-01f, 1.05776556e-01f, 1.15418337e-01f, 2.09009334e-01f, -2.40235589e-02f, 4.32808436e-02f, 2.99294382e-01f, -6.97945133e-02f, 4.19324636e-03f, 5.00580370e-02f,
  3.67738446e-03f, -2.00974002e-01f, 3.33637483e-02f, 1.25486106e-01f, -2.92985916e-01f, -4.23224503e-03f, -3.63743722e-01f, -1.40795097e-01f, -2.89808214e-01f, -1.78116307e-01f,
  -1.14342913e-01f, -1.08441599e-01f, 1.01060368e-01f, 5.71306013e-02f, -1.30526185e-01f, -1.63818285e-01f, -1.02374956e-01f, -2.34358944e-02f, 1.69524718e-02f, -5.51182926e-02f,
  8.46178755e-02f, -1.22950472e-01f, -1.35978118e-01f, -3.89130086e-01f, 6.35788310e-03f, -1.87262278e-02f, 1.11642927e-01f, -2.23674059e-01f, 8.19677114e-02f, 4.48903777e-02f,
  1.12224266e-01f, 8.75662733e-03f, 1.66705549e-01f, -1.47232950e-01f, 1.52670503e-01f, 3.27715836e-02f, 3.69656160e-02f, 7.88357109e-02f, 1.60428450e-01f, -8.33698548e-03f,
  1.59805283e-01f, -2.01239631e-01f, 1.16570681e-01f, 5.75883538e-02f, 3.36324088e-02f, -1.46251202e-01f, 1.31190225e-01f, 2.58356035e-01f, 3.69489156e-02f, 2.07460602e-03f,
  4.48772609e-02f, -8.22275355e-02f, -4.25398797e-02f, -1.52456507e-01f, 8.21618512e-02f, 3.93349640e-02f, 5.92991561e-02f, -1.75339252e-01f, -7.27449134e-02f, 9.12841484e-02f,
  2.53154133e-02f, 1.28472328e-01f, -1.93928778e-02f, 3.31370272e-02f, 1.23290971e-01f, 2.38457680e-01f, 7.37586096e-02f, 1.20178729e-01f, -1.15759902e-09f, -1.66556038e-05f,
  -5.76890443e-07f, 1.52589622e-04f, -1.19423032e-06f, -4.43014596e-06f, -1.45130747e-04f, -8.76461127e-05f, 2.06392734e-08f, 5.56509985e-06f, 4.07376518e-07f, 1.69683627e-08f,
  -2.33876039e-04f, 1.10204339e-04f, -1.37931944e-04f, -1.55044779e-06f, 8.79157087e-05f, 1.08804037e-04f, 1.66329335e-06f, 6.10715642e-06f, 1.99820701e-04f, 8.23751689e-05f,
  -1.62091048e-04f, -1.95482004e-04f, -1.24048451e-02f, -2.29715112e-25f, 1.12636564e-22f, -4.94584089e-40f, -2.55580875e-03f, -8.50460026e-04f, -1.20667927e-03f, 4.92869236e-04f,
  -3.13585449e-04f, 4.32490779e-04f, -1.26907637e-03f, -2.37847562e-05f, -3.11467028e-03f, -2.77579820e-04f, -1.20468503e-02f, -4.15299786e-03f, -3.56177939e-03f, 2.79982551e-03f,
  -1.27242450e-02f, -9.19798069e-08f, 2.33960834e-14f, 3.89725319e-03f, -1.95296307e-03f, -6.42514136e-03f, -1.25040691e-02f, -2.54420029e-05f, -2.62511708e-03f, -9.08342190e-03f,
  -8.09166464e-04f, -1.86031917e-04f, -9.23749246e-03f, -1.79001399e-05f, -1.00023635e-02f, -1.20429303e-02f, -3.86768312e-10f, -1.47140690e-03f, -9.28589795e-03f, -4.66906140e-03f,
  -6.19813656e-28f, -5.32220211e-03f, -1.11237943e-01f, 1.82216197e-01f, -1.96055591e-01f, -7.19198287e-02f, -1.71557188e-01f, -3.66590396e-02f, -7.61341006e-02f, -3.52404490e-02f,
  1.43342197e-01f, -3.14373598e-02f, -5.32717723e-03f, -4.63308632e-01f, -7.53469318e-02f, -9.68567505e-02f, 2.50457555e-01f, 5.62448353e-02f, -1.89139828e-01f, -1.07375376e-01f,
  -4.74462472e-02f, -7.21732304e-02f, -2.32619449e-01f, -1.71546847e-01f, 3.54634151e-02f, 1.90098315e-01f, 1.59016937e-01f, 2.78779119e-03f, 2.80696869e-01f, -1.12315953e-01f,
  2.30141833e-01f, 3.32133360e-02f, 8.56199861e-02f, 1.42768398e-01f, 1.20869689e-01f, 8.05633292e-02f, 1.59569874e-01f, 1.66979071e-03f, 1.00937068e-01f, -1.57924280e-01f,
  4.25410308e-02f, 2.70249158e-01f, 5.36609590e-02f, -4.06348556e-02f, 1.97549105e-01f, -6.23118766e-02f, -3.47826593e-02f, 3.94949764e-02f, -1.14439584e-01f, 3.38368192e-02f,
  1.48177400e-01f, -3.91674526e-02f, 2.70642847e-01f, 7.70884752e-02f, 2.92121191e-02f, -1.73774272e-01f, -2.02400431e-01f, 8.47126618e-02f, 2.68894047e-01f, 1.42777190e-01f,
  1.20031133e-01f, 1.17048100e-01f, 2.02238321e-01f, 2.84278654e-02f, -2.63532341e-01f, -2.89812479e-02f, 2.73690343e-01f, -1.36616573e-01f, 2.37494811e-01f, 1.50322825e-01f,
  1.10087961e-01f, 3.30201924e-01f, 6.36176392e-02f, 1.33629311e-02f, 7.17420503e-02f, -2.38701627e-02f, 2.57842660e-01f, 2.59183824e-01f, 1.33436754e-01f, 2.87616313e-01f,
  9.96845141e-02f, 2.15890203e-02f, 1.82783604e-02f, 3.48134607e-01f, -4.63517644e-02f, 4.39320467e-02f, 1.26422197e-01f, 3.01281750e-01f, 7.22998157e-02f, -1.26761928e-01f,
  -9.50255692e-02f, -4.78985123e-02f, 5.01309484e-02f, 1.38499020e-02f, -1.28151089e-01f, -5.54385521e-02f, 2.91473925e-01f, 8.81280974e-02f, 1.32337995e-02f, 1.27335802e-01f,
  2.67307200e-02f, 5.10939583e-02f, 9.71915945e-02f, 3.78795832e-01f, -9.11975130e-02f, -1.37335092e-01f, 2.78689861e-01f, 1.17826991e-01f, 9.06741545e-02f, -1.68329626e-01f,
  -1.51102975e-01f, -2.48969123e-01f, -2.56952703e-01f, 1.03681311e-01f, 2.39898220e-01f, 3.15608829e-01f, 7.04860464e-02f, -1.81762978e-01f, 1.93756431e-01f, -1.96743637e-01f,
  1.22580275e-01f, -8.12126044e-03f, -2.04844430e-01f, -1.64507672e-01f, 2.10828893e-02f, 7.56868944e-02f, -6.72298297e-02f, -1.49100339e-02f, -8.28256831e-02f, -1.80602118e-01f,
  3.37069365e-03f, 9.80768964e-05f, 5.96440768e-05f, 4.69337916e-03f, 3.34716315e-04f, 4.72456357e-03f, -6.43405458e-03f, -2.32656137e-03f, -4.86385496e-03f, 5.26616257e-03f,
  6.04664929e-05f, 6.68814930e-04f, 7.74689324e-05f, 3.57966986e-03f, -3.91664263e-03f, 1.85718236e-04f, 9.57377255e-04f, 1.75206966e-04f, -8.47536212e-05f, -4.99352755e-04f,
  1.14539033e-03f, -5.09588979e-04f, -2.37837597e-03f, -3.86629510e-03f, -2.71395314e-02f, -6.95064789e-26f, -7.71466224e-03f, 5.05154276e-07f, -2.15850323e-02f, -5.62111772e-13f,
  2.39291359e-04f, 7.01674726e-04f, -1.29774241e-02f, -3.83509602e-03f, -1.14716375e-02f, -8.04602692e-04f, -3.70215317e-12f, -1.80345145e-03f, -2.15456984e-03f, -1.09506994e-02f,
  -3.54177610e-04f, -7.99236077e-05f, 9.86017170e-04f, -2.57821448e-05f, -2.88859243e-03f, -2.46808436e-02f, 3.27825197e-04f, 4.66021185e-04f, -2.39299703e-03f, 5.91782534e-09f,
  -3.09394230e-03f, -8.43961141e-04f, -8.10204830e-04f, 2.95244926e-03f, -7.67202862e-03f, -3.47097218e-03f, -2.57827528e-03f, -6.44945120e-03f, -1.81264896e-02f, -2.96610612e-02f,
  -6.46174245e-04f, -5.55673474e-03f, -6.19507534e-03f, -9.45119944e-04f, 3.46710496e-02f, -1.28694512e-02f, 3.03939246e-02f, -8.32949281e-02f, -4.83083725e-02f, 6.33277074e-02f,
  3.76268476e-01f, 1.61413640e-01f, 6.60575703e-02f, -1.66894421e-01f, -1.41114086e-01f, -6.64420277e-02f, 1.20198011e-01f, -9.31321234e-02f, 1.47217110e-01f, 4.84732352e-02f,
  -2.62593001e-01f, -2.36504778e-01f, -6.83052018e-02f, -9.14962497e-03f, -7.17050135e-02f, 1.10243792e-02f, 2.64019251e-01f, -6.25792146e-02f, 2.81995833e-02f, 2.80849427e-01f,
  5.87856211e-02f, -1.59262985e-01f, 7.90750310e-02f, 2.32948400e-02f, -1.40277758e-01f, 3.39748710e-02f, -2.31962139e-03f, 6.19885363e-02f, -1.24349393e-01f, -1.43344915e-02f,
  2.01284382e-02f, -2.32904613e-01f, 1.35706335e-01f, 2.77230293e-02f, -4.07671649e-03f, 3.81369665e-02f, -1.03739142e-01f, -1.99079048e-02f, 5.72972372e-03f, 2.53384501e-01f,
  1.66413650e-01f, 1.39587805e-01f, -1.43398694e-03f, -1.01877205e-01f, -3.89274061e-02f, 1.46649927e-01f, -2.96577141e-02f, 2.40690306e-01f, 3.96590866e-02f, -2.06405725e-02f,
  1.27152100e-01f, -1.32163772e-02f, -3.74384411e-02f, 6.03801459e-02f, 3.64435837e-02f, -2.51072884e-01f, 3.17310065e-01f, 1.96328342e-01f, 4.10459330e-03f, -4.58649965e-03f,
  -3.12361331e-03f, -1.25260290e-03f, 1.56545918e-03f, -2.03430245e-04f, 5.70927048e-04f, -6.90663094e-03f, -5.94009785e-03f, -1.61217351e-03f, -4.92909399e-04f, 1.34304748e-03f,
  2.49001838e-04f, 3.89276841e-03f, -8.43535643e-04f, -5.51618345e-04f, -2.67961016e-03f, -5.56284050e-03f, -3.31074069e-03f, 9.94057045e-04f, -8.05754401e-03f, 7.77327735e-03f,
  -5.34561742e-03f, -6.32296223e-03f, -1.74582750e-02f, -1.99544302e-04f, -1.97383203e-03f, -4.93310309e-40f, -2.10913531e-02f, -2.51870845e-02f, -6.65089488e-03f, -8.90303403e-03f,
  -8.19742400e-03f, -7.89034367e-03f, -9.54936957e-04f, -5.97460708e-03f, -4.32010368e-03f, -2.82747601e-03f, -1.19335344e-02f, -1.74650140e-02f, -4.10957495e-03f, -3.36090960e-02f,
  -1.59213617e-02f, -5.28708939e-03f, -1.11344112e-02f, -1.75132714e-02f, -7.93162081e-03f, 2.66017625e-03f, -2.08068918e-02f, -2.07898319e-02f, -2.02413276e-02f, -1.55031541e-03f,
  -9.82176047e-03f, -1.03979381e-02f, -6.58082310e-03f, -1.73519813e-02f, -1.09774852e-02f, -1.52162770e-02f, -9.67344968e-04f, -1.36622563e-02f, -1.04091046e-02f, -2.11924338e-03f,
  -1.20071592e-02f, -3.42209963e-03f, 9.91816446e-02f, 2.93476343e-01f, 1.07609473e-01f, 6.80319741e-02f, 2.18324922e-02f, 8.46873894e-02f, -2.76300521e-03f, -3.97280864e-02f,
  2.13555489e-02f, 5.20957261e-02f, 2.03727633e-01f, -7.05776643e-03f, 1.57451183e-01f, 2.75852606e-02f, 2.02170491e-01f, 1.80629209e-01f, -2.21269322e-03f, 9.40835401e-02f,
  -1.53475836e-01f, 2.28081167e-01f, -4.63282466e-01f, -1.27869666e-01f, 1.27190545e-01f, 3.20624769e-01f, 1.73731521e-02f, -2.09204406e-01f, 4.51485999e-02f, 1.95926358e-03f,
  -9.50203687e-02f, 1.65327657e-02f, -6.68461546e-02f, -1.43472880e-01f, -3.62243392e-02f, 3.81606854e-02f, -3.40603441e-02f, 3.44993234e-01f, 1.88289825e-02f, 7.88270533e-02f,
  2.17238650e-01f, 2.45541513e-01f, 2.19714165e-01f, -1.64558589e-01f, -6.77547976e-02f, -2.66826957e-01f, 1.03916213e-01f, 2.06776157e-01f, 2.24958733e-01f, 1.47951707e-01f,
  9.88355950e-02f, -5.19907884e-02f, 1.51391238e-01f, 1.53095648e-01f, 6.76087141e-02f, 3.47265542e-01f, -1.49760067e-01f, 1.57073408e-01f, 3.99518102e-01f, 2.19366476e-01f,
  1.64471880e-01f, 7.67149702e-02f, 1.21495157e-01f, -8.43770653e-02f, 5.11646271e-03f, 1.41791135e-01f, 2.19291896e-01f, 7.60108349e-04f, 7.44006857e-02f, -1.84370037e-02f,
  -2.88181514e-01f, 2.06771586e-02f, 6.22470211e-03f, 2.92462945e-01f, 7.76302163e-03f, 9.44071487e-02f, 5.92546687e-02f, -2.18625516e-02f, 7.30729029e-02f, 1.59316778e-01f,
  8.79971758e-02f, -1.15296476e-01f, 3.48669030e-02f, 1.10331409e-01f, 1.98838138e-03f, -1.80981144e-01f, -1.74583226e-01f, -2.18455881e-01f, 6.65637970e-01f, 7.32199028e-02f,
  1.73821688e-01f, 4.95532364e-01f, 1.66658580e-01f, 7.94325545e-02f, -1.17968034e-03f, 3.56270336e-02f, 3.94083112e-02f, 1.03265941e-01f, -3.79591696e-02f, 1.46169990e-01f,
  -9.71544757e-02f, -1.55676007e-01f, 3.47767383e-01f, -2.78524607e-01f, -7.06001520e-02f, 1.94083765e-01f, -1.83551591e-02f, 4.26676124e-02f, 1.19601265e-01f, -2.27400824e-01f,
  1.81707945e-02f, 4.76824641e-02f, 2.87705868e-01f, -4.44923043e-02f, 2.96616908e-02f, 2.52984554e-01f, 5.90302348e-02f, 1.16233990e-01f, -2.36304030e-02f, 1.59686312e-01f,
  -2.69636154e-01f, 1.11687243e-01f, 2.13475958e-01f, 7.52626956e-02f, 1.13075553e-02f, -3.27592604e-02f, 2.04290941e-01f, -6.24639653e-02f, 2.33999595e-01f, 1.54499203e-01f,
  -3.77578177e-02f, 1.32900298e-01f, -1.97156757e-01f, -1.86011791e-01f, 4.13205801e-03f, -1.28067762e-01f, -3.07813622e-02f, 3.03913169e-02f, 1.80849135e-01f, 4.08990830e-02f,
  -1.02699958e-01f, -2.06921265e-01f, -2.09810421e-01f, 1.43420681e-01f, 1.51855364e-01f, -2.43884534e-01f, 2.26852633e-02f, -9.65978280e-02f, 1.75984018e-03f, 8.67557228e-02f,
  1.22896373e-01f, 1.56712055e-01f, 9.95702967e-02f, -1.59333944e-01f, 8.73801559e-02f, 5.23881949e-02f, 3.53420764e-01f, -6.30079135e-02f, 1.34721860e-01f, 1.11390330e-01f,
  -2.87648737e-01f, 1.70610949e-01f, 2.17007488e-01f, -2.25160599e-01f, 5.47403246e-02f, 1.99866667e-01f, 1.21156849e-01f, -1.41793266e-01f, -8.52115080e-02f, -2.41198480e-01f,
  -3.81941311e-02f, 7.51654059e-02f, -3.78690720e-01f, 8.91561359e-02f, 3.04560870e-01f, 1.89132005e-01f, 1.43404631e-02f, 3.86200063e-02f, -1.60482198e-01f, 9.34950560e-02f,
  2.41732262e-02f, -3.00721049e-01f, 1.45724416e-01f, -4.89343144e-02f, 1.67480484e-01f, 2.08788842e-01f, -2.79563566e-04f, 7.19133168e-02f, 9.23643634e-02f, 2.91975558e-01f,
  3.14587384e-01f, -1.05768450e-01f, -8.90053995e-03f, -5.20228744e-02f, 2.29134616e-02f, 1.45618111e-01f, 1.59629121e-01f, -2.81904459e-01f, 2.21212536e-01f, 1.39475837e-01f,
  1.75039954e-02f, -7.50702098e-02f, -8.39524493e-02f, -6.51517734e-02f, -5.93683086e-02f, -7.38995150e-02f, 2.22424362e-02f, -2.22944580e-02f, -6.34375289e-02f, 1.62094563e-01f,
  1.05758764e-01f, -1.13388784e-01f, -7.00036883e-02f, 5.32863021e-01f, -6.30662367e-02f, -8.03297311e-02f, -8.30173269e-02f, 3.41256797e-01f, -1.21594395e-03f, 5.57220764e-02f,
  -2.21740156e-01f, -5.21983914e-02f, -2.75481999e-01f, 1.15287632e-01f, -1.21160947e-01f, 6.65350258e-02f, -2.35881433e-01f, 4.25082892e-02f, 6.87493533e-02f, -7.06511885e-02f,
  -8.25085193e-02f, 2.41954461e-01f, 1.03018649e-01f, 1.72273129e-01f, -9.96488053e-03f, -8.30040500e-02f, -4.41826787e-03f, -2.44396403e-02f, -3.80633622e-01f, 2.09572881e-01f,
  2.22935691e-01f, 9.16017294e-02f, 1.19532973e-01f, -3.45303744e-01f, 2.67186631e-02f, 3.31241280e-01f, -7.55401552e-02f, 1.49185807e-01f, -7.71799451e-03f, -9.82327089e-02f,
  1.22236490e-01f, 1.68250099e-01f, -1.04034804e-01f, -2.50378579e-01f, 5.17287776e-02f, -2.64899701e-01f, -1.89277768e-01f, 1.74090758e-01f, 1.09282937e-02f, -4.99343760e-02f,
  4.78562564e-02f, 8.25490281e-02f, -5.70683256e-02f, -1.05667695e-01f, -2.91236658e-02f, 4.79999073e-02f, 2.44604442e-02f, -5.40126115e-02f, -3.49607430e-02f, 5.87649271e-02f,
  -5.15061282e-02f, -4.18108106e-02f, -4.65519205e-02f, -7.13307352e-04f, -2.10280456e-02f, -2.06650104e-02f, 2.49618455e-03f, -1.80657879e-02f, -3.52401100e-02f, 3.97345759e-02f,
  -6.18419498e-02f, 2.63853315e-02f, 7.97394812e-02f, 4.64111865e-02f, -1.25902239e-02f, 6.65742457e-02f, -6.67056963e-02f, 2.81249359e-02f, 7.10432604e-02f, 3.14861871e-02f,
  2.19617020e-02f, 6.86720833e-02f, 1.92228686e-02f, 4.63372618e-02f, 5.59004731e-02f, 5.22396900e-02f, 3.71460840e-02f, 1.01595946e-01f, 2.08124387e-04f, 2.95367576e-02f,
  1.13653958e-01f, 2.29511149e-02f, 4.79822531e-02f, 5.66066951e-02f, 8.16710740e-02f, 1.04991365e-02f, 2.98561007e-02f, -4.50623501e-03f, 4.22500595e-02f, 6.68533370e-02f,
  2.62204185e-02f, 8.89322162e-02f, 2.66802199e-02f, -1.16875004e-02f, 8.16666782e-02f, 7.13228062e-02f, -8.11927207e-03f, -5.56116514e-02f, 6.13627993e-02f, 6.44428879e-02f,
  1.29597653e-02f, 4.04655337e-02f, -3.17199016e-03f, -3.03134192e-02f, -6.30932003e-02f, 8.23323652e-02f, -1.79263949e-02f, 1.36397779e-02f, 7.83506036e-02f, -9.73108690e-03f,
  -2.88181417e-02f, 1.34145543e-02f, 1.26061598e-02f, -4.83226627e-02f, -2.51533347e-03f, -8.50400794e-03f, 4.31128331e-02f, -3.06282062e-02f, 2.29775277e-03f, -1.14061953e-02f,
  -3.68602313e-02f, 1.66972820e-02f, 6.61191493e-02f, -4.01665047e-02f, -7.43162334e-02f, -3.20640728e-02f, -2.11681668e-02f, -2.45809625e-03f, 2.21728627e-02f, 1.36135733e-02f,
  -1.41015667e-02f, -7.78063312e-02f, 1.32187072e-03f, 1.21183051e-02f, -3.63485329e-02f, -2.80440077e-02f, -3.22840214e-02f, -5.54048233e-02f, -1.51046703e-03f, 6.15341067e-02f,
  -3.37403603e-02f, -5.44680096e-02f, -2.13450249e-02f, -1.63607188e-02f, -2.87844613e-02f, -4.45160344e-02f, 7.29049221e-02f, 4.74913567e-02f, 3.23569216e-02f, 3.01265437e-03f,
  -2.33004689e-02f, -5.46142273e-02f, -7.58222193e-02f, -1.58337317e-02f, -2.98713259e-02f, 9.37383771e-02f, 8.31631720e-02f, -5.33828586e-02f, -2.29296871e-02f, -1.32112633e-02f,
  1.55023560e-02f, -6.79076910e-02f, -6.43075034e-02f, -2.74362564e-02f, 2.02405062e-02f, 1.03358161e-02f, 5.57948574e-02f, 2.69945115e-02f, 6.78080842e-02f, 2.02477071e-02f,
  1.08456407e-02f, -1.23334061e-02f, 1.17542446e-02f, -4.00974117e-02f, -1.29776113e-02f, 1.52853765e-02f, 1.84563920e-02f, 6.25096215e-03f, 2.47920286e-02f, -2.73778010e-02f,
  1.40480138e-02f, 2.42729615e-02f, -8.35304614e-04f, 2.58984584e-02f, -9.51226335e-03f, 4.30491865e-02f, -3.10327373e-02f, 2.70558428e-02f, -6.23105327e-03f, 5.00181615e-02f,
  8.61051399e-03f, -3.48320715e-02f, 9.60287452e-03f, 4.55315970e-02f, -1.66874770e-02f, -4.42929976e-02f, 3.94965149e-02f, -1.30535373e-02f, -3.54000814e-02f, 4.85640056e-02f,
  -2.32977909e-03f, 2.25206139e-03f, 8.76232237e-03f, 1.21380314e-01f, -1.40955271e-02f, 9.67224408e-03f, 9.93840098e-02f, 4.20563631e-02f, -7.40978913e-03f, -8.12006965e-02f,
  -2.67655775e-02f, 5.86209260e-02f, 3.15444842e-02f, 2.97764745e-02f, 3.85360606e-02f, 3.22476178e-02f, 9.09045432e-03f, -4.82877158e-02f, 7.74228573e-02f, 5.18855713e-02f,
  -4.39862488e-03f, 1.25137027e-02f, -1.85478234e-03f, 9.69010219e-03f, 6.56488985e-02f, -1.75280329e-02f, -5.89755177e-03f, -3.61029021e-02f, -1.95830781e-02f, -1.67020485e-02f,
  -2.98757255e-01f, 3.38708609e-02f, -1.78295270e-01f, -3.76499057e-01f, -6.71516657e-02f, -1.07653506e-01f, 6.63091689e-02f, -3.99891138e-02f, 5.43668941e-02f, 6.74847886e-02f,
  -1.29392445e-01f, -3.44544321e-01f, -6.72718287e-02f, 2.93788332e-02f, 1.87636092e-01f, -5.07855155e-02f, -4.95799892e-02f, -2.67951548e-01f, 2.20436734e-04f, 7.83209577e-02f,
  1.38568342e-01f, 2.96232421e-02f, 1.32921085e-01f, -1.40739411e-01f, 8.34696889e-02f, 1.52896762e-01f, 4.26402807e-01f, -8.33015814e-02f, 1.55613273e-01f, -4.80330177e-03f,
  -1.13366976e-01f, 1.05398767e-01f, 1.89583451e-01f, -8.12434927e-02f, 7.21408427e-02f, -5.20231724e-02f, 1.30760491e-01f, -7.43096024e-02f, -1.36940196e-01f, -1.43733323e-01f,
  -1.23307586e-01f, 7.32834935e-02f, -3.06791306e-01f, 1.02065518e-01f, 2.25308269e-01f, 1.53864995e-01f, 8.10052902e-02f, 1.53420731e-01f, -2.18102802e-03f, -2.65047960e-02f,
  -8.29022378e-02f, -2.25573972e-01f, -7.63783138e-03f, -6.72078039e-03f, 3.06864213e-02f, 1.35974646e-01f, 1.49514424e-02f, 1.34770153e-02f, 1.42972529e-01f, 2.03107998e-01f,
  1.84033141e-01f, -4.76559438e-02f, -4.11643274e-03f, 7.81537145e-02f, -2.52484670e-03f, -2.57230531e-02f, -2.26472821e-02f, 1.18776344e-01f, -2.47618556e-02f, -1.33862332e-01f,
  -2.39133567e-01f, 2.15818137e-02f, 7.60705844e-02f, -1.33115038e-01f, -2.84512550e-01f, 2.67735064e-01f, 1.20803893e-01f, 1.76775351e-01f, -1.65524587e-01f, 2.68346537e-02f,
  1.25941783e-01f, 2.91587748e-02f, -1.97426647e-01f, 1.91427216e-01f, 2.09905103e-01f, 2.99727947e-01f, -4.18159775e-02f, -2.31939718e-01f, -1.98889792e-01f, 9.13356319e-02f,
  3.26811224e-02f, 1.79159239e-01f, -1.37604594e-01f, 1.90075964e-01f, 1.92804411e-01f, 2.75771111e-01f, 1.95594534e-01f, 2.05616839e-02f, 8.80219936e-02f, -8.50293562e-02f,
  -1.24517545e-01f, 2.68464714e-01f, 7.18260035e-02f, -2.38513295e-02f, -2.78936718e-02f, 2.94519931e-01f, 6.79275533e-03f, 2.87253946e-01f, 1.67292923e-01f, -4.15449664e-02f,
  -8.30729157e-02f, 1.14423089e-01f, 2.82825753e-02f, 1.94590278e-02f, -2.00322680e-02f, -1.67251885e-01f, 2.06599876e-01f, 1.93813592e-01f, 3.63873750e-01f, 1.90458760e-01f,
  -1.37749642e-01f, -1.23369664e-01f, -2.02928796e-01f, 1.49918213e-01f, -1.66994333e-01f, -1.48673818e-01f, -4.08515446e-02f, -1.23253077e-01f, -1.60925865e-01f, 9.51531529e-02f,
  -2.57728457e-01f, -1.84749752e-01f, 2.50276681e-02f, -8.86383131e-02f, -1.07830293e-01f, 3.92086543e-02f, 8.43935832e-02f, 5.50199486e-02f, -1.29733846e-01f, -7.41203949e-02f,
  -2.96027623e-02f, 6.19026609e-02f, 1.64672006e-02f, 3.05961579e-01f, 1.32029921e-01f, -9.72522795e-02f, -2.31903285e-01f, 3.62472124e-02f, 4.12850350e-01f, 1.95340022e-01f,
  -1.12252936e-01f, -9.35218707e-02f, 5.96069777e-03f, -1.79471105e-01f, -2.87617296e-02f, -1.75351247e-01f, 4.71782545e-03f, -2.28133053e-01f, 2.64338162e-02f, -1.11492224e-01f,
  -3.23317721e-02f, 1.99143123e-02f, 1.68362394e-01f, 5.51477820e-02f, -4.90073524e-02f, 1.23953462e-01f, 1.64691776e-01f, 1.32212294e-02f, 7.69885778e-02f, 3.83126512e-02f,
  3.50314714e-02f, 4.97888885e-02f, 1.42100975e-02f, 8.36118385e-02f, -5.91907790e-03f, 6.69791177e-02f, 1.03667796e-01f, -3.05651426e-01f, 8.34617093e-02f, 4.59077843e-02f,
  1.17836088e-01f, -5.02849072e-02f, 1.16989389e-01f, -1.23699225e-01f, -1.63765661e-02f, 7.98589066e-02f, -3.17771137e-01f, -3.12782563e-02f, 2.61807442e-02f, 9.92638897e-03f,
  2.23989815e-01f, 2.72744633e-02f, 3.55676897e-02f, 7.64073357e-02f, -8.82397369e-02f, 1.09329678e-01f, 7.39990920e-02f, 3.20106186e-02f, -7.86273628e-02f, 1.59083024e-01f,
  2.94892192e-02f, 1.35872159e-02f, -6.81035146e-02f, 1.21322192e-01f, 9.82287899e-02f, 1.86664343e-01f, 6.54877797e-02f, 9.79671329e-02f, 4.97053340e-02f, 2.95237359e-02f,
  -1.71638876e-01f, -2.48654827e-01f, 2.25620478e-01f, 2.48252764e-01f, -1.27437010e-01f, 9.07395855e-02f, -2.18435660e-01f, 8.62269998e-02f, -3.02117085e-03f, -2.01239474e-02f,
  2.46333368e-02f, -2.08469391e-01f, 2.58607507e-01f, 6.62733093e-02f, 3.29998583e-02f, 2.42173076e-01f, 1.21557333e-01f, 8.25220495e-02f, 1.02170454e-02f, 2.15684965e-01f,
  9.69058275e-02f, -1.22154783e-02f, 2.73156196e-01f, 1.43354937e-01f, -8.52419659e-02f, 1.46184683e-01f, 3.97449806e-02f, 1.52051263e-02f, -7.76719525e-02f, 7.24550337e-02f,
  1.87245667e-01f, -6.82624578e-02f, 1.58159435e-01f, -4.10931349e-01f, 2.47378156e-01f, 3.63766775e-02f, 2.33602956e-01f, -9.35998559e-02f, -3.26323539e-01f, 9.37042385e-03f,
  -2.51593083e-01f, -5.14968187e-02f, -2.39174902e-01f, -9.42379832e-02f, 1.62679300e-01f, -1.38773322e-01f, -2.72851214e-02f, -3.69757339e-02f, -8.89426935e-03f, 1.35598173e-02f,
  1.37898410e-02f, 1.15027290e-03f, 8.73408746e-03f, 4.31261770e-02f, -7.82003626e-02f, 3.81456874e-02f, 4.06881720e-02f, 2.51984149e-02f, -2.52613295e-02f, 5.70063889e-02f,
  -5.34567758e-02f, -4.23689820e-02f, 3.29217277e-02f, 4.16007042e-02f, 3.68265323e-02f, -3.85077037e-02f, 3.64703722e-02f, -1.99023485e-02f, -1.32245310e-02f, -4.28561233e-02f,
  -8.67898110e-03f, 1.06534071e-03f, 1.09663708e-02f, 3.06271622e-03f, -2.14851871e-02f, 8.30861405e-02f, -5.18865883e-02f, 3.39799151e-02f, 4.16837111e-02f, -6.90373927e-02f,
  -2.36861575e-02f, 3.89335491e-03f, -7.47332023e-03f, -6.84554037e-03f, -5.14227152e-02f, -6.87855482e-02f, -3.00581362e-02f, 9.86380735e-04f, -4.53459583e-02f, 6.62638620e-02f,
  2.82637179e-02f, -5.41996844e-02f, -1.39652314e-02f, 2.83742100e-02f, -5.97801507e-02f, 1.12809375e-01f, -6.06301762e-02f, -2.65590008e-02f, -2.04368997e-02f, -4.91125248e-02f,
  -9.85273067e-03f, 5.82536459e-02f, -4.19946201e-02f, -3.62338237e-02f, -2.75068190e-02f, -8.68912495e-04f, -1.37858959e-02f, 9.73063707e-03f, 1.02457982e-02f, -8.41124356e-03f,
  9.73920003e-02f, -5.19655608e-02f, 8.10340345e-02f, -1.75547957e-01f, -2.27397284e-03f, 6.68009445e-02f, 9.82321575e-02f, -1.02043830e-01f, -2.83915829e-03f, 1.00164905e-01f,
  1.11439219e-02f, 3.20996344e-02f, 1.60882279e-01f, 3.23951393e-02f, -1.45444609e-02f, 2.23408028e-01f, -9.63099599e-02f, -1.26026928e-01f, -7.10203126e-02f, 2.39295617e-01f,
  2.29281828e-01f, 2.59001940e-01f, -1.20552652e-01f, 2.99713254e-01f, 1.31295621e-01f, -7.94060454e-02f, -5.21959849e-02f, 4.73893583e-02f, -1.56193241e-01f, -9.63079110e-02f,
  1.93314567e-01f, 1.60067409e-01f, 1.19407307e-02f, 2.31596790e-02f, 8.02350864e-02f, -1.83611959e-01f, -1.52691424e-01f, 3.24165970e-01f, 2.68720418e-01f, 6.32718205e-02f,
  2.23396733e-01f, 1.70491785e-01f, 1.79756001e-01f, 1.15233557e-02f, -3.55873942e-01f, 1.29374683e-01f, 7.55820647e-02f, -1.31328642e-01f, 1.05089866e-01f, -1.70816019e-01f,
  4.97779623e-02f, 1.26760259e-01f, 1.67230133e-03f, 1.12159155e-01f, 7.83291832e-02f, -3.13459858e-02f, 1.35161486e-02f, 6.56872988e-03f, -8.56754109e-02f, -5.34690209e-02f,
  1.33012617e-02f, -1.58914089e-01f, -2.18406096e-01f, 8.81545097e-02f, -6.49554236e-03f, 1.97160300e-02f, 2.46124193e-01f, 1.00996107e-01f, 1.39279172e-01f, -9.26802978e-02f,
  6.59760609e-02f, 3.38803291e-01f, -1.04110591e-01f, 1.33446619e-01f, -8.57493877e-02f, 2.93718338e-01f, -1.78687185e-01f, -6.94065243e-02f, 1.29187526e-02f, -1.85161754e-01f,
  -3.54109406e-02f, -3.38119008e-02f, 2.47141078e-01f, 8.91415551e-02f, 1.64335817e-01f, -4.45304811e-02f, -2.13016912e-01f, -1.37740716e-01f, -3.77438888e-02f, 1.21258706e-01f,
  8.25997144e-02f, 7.70705268e-02f, -4.77970839e-02f, 3.38850230e-01f, -8.46060663e-02f, 2.19692633e-01f, 2.30074644e-01f, -2.33057663e-01f, -2.36947164e-01f, 1.18490219e-01f,
  -1.36393383e-01f, 9.90299582e-02f, -6.56220540e-02f, 3.74241024e-02f, -1.46817610e-01f, 2.58076549e-01f, 1.65062189e-01f, 1.79257035e-01f, 1.82010397e-01f, 6.15130551e-02f,
  -5.93459699e-03f, -2.72829503e-01f, -1.82635322e-01f, 1.58747554e-01f, -4.25934233e-02f, 6.17890581e-02f, -1.95360407e-01f, 1.68466166e-01f, 2.07627699e-01f, 2.09061772e-01f,
  -1.31210685e-01f, -5.74018024e-02f, 1.44088820e-01f, 5.85967451e-02f, -2.82190070e-02f, 2.10790336e-01f, 1.47898927e-01f, -4.90710996e-02f, -1.93479472e-08f, -4.07717060e-09f,
  9.24551014e-09f, 1.05726308e-08f, -5.21093968e-09f, -3.51787843e-09f, -6.46247411e-09f, -8.33276825e-09f, -1.63443181e-09f, 4.04114653e-09f, -1.32584939e-08f, 2.91322233e-09f,
  3.19925109e-09f, 6.29459285e-09f, -1.76697501e-09f, -3.98399091e-09f, -1.23382804e-09f, 9.26476762e-09f, -6.18702700e-10f, -7.13109127e-10f, -1.03614024e-08f, -1.06902167e-08f,
  3.15715298e-09f, -3.24580962e-09f, -4.89553242e-09f, 1.85584902e-12f, -8.20061530e-09f, 3.24669631e-11f, 3.87966992e-09f, -5.86290767e-08f, 9.54678003e-10f, -1.82827318e-08f,
  -4.91064434e-08f, -1.12325781e-10f, -1.68390368e-09f, -9.27606614e-09f, -3.12987657e-11f, -5.63361304e-08f, -2.36870878e-08f, -2.64139217e-08f, -2.21306173e-08f, -5.57013280e-08f,
  -2.87508573e-09f, -2.50523655e-08f, -3.77811098e-08f, -1.50118566e-08f, -6.20667406e-12f, 1.28013666e-09f, -2.23196732e-08f, -3.88015167e-08f, -1.73505583e-08f, -5.12899334e-10f,
  -2.93219689e-08f, -7.79568410e-09f, -6.09941537e-08f, -3.65766795e-08f, -9.77738868e-09f, 1.91613614e-09f, -2.57331257e-11f, -3.55244900e-08f, -3.35839623e-09f, -4.43482445e-10f,
  -1.34887934e-09f, -1.68251316e-10f, -1.00810051e-01f, 2.08584324e-01f, -9.56722572e-02f, -1.04685932e-01f, 7.83207864e-02f, -1.46188922e-02f, -9.70196798e-02f, -4.49637622e-02f,
  1.10375293e-01f, -9.06252936e-02f, -1.27003282e-01f, 8.59976634e-02f, -2.10304167e-02f, -4.33369167e-02f, 1.62791573e-02f, 3.56715858e-01f, -1.21873673e-02f, -7.21524432e-02f,
  -5.29622249e-02f, 2.07184732e-01f, -2.21592467e-02f, 6.72695190e-02f, -1.10553596e-02f, 3.05730253e-01f, 7.63482377e-02f, -1.86887890e-01f, -8.72650892e-02f, -8.22892785e-03f,
  -4.69609164e-02f, 1.47108606e-03f, -1.00621305e-01f, -2.36526281e-01f, -3.19858119e-02f, -1.55708179e-01f, 1.49472907e-01f, 3.33664119e-01f, -2.45639071e-01f, 9.45107266e-02f,
  2.44248450e-01f, 1.85314447e-01f, 2.19553068e-01f, -7.94521868e-02f, -1.82641551e-01f, 2.23983289e-03f, 1.68454409e-01f, 2.11778551e-01f, 1.70295611e-01f, 2.59323001e-01f,
  -7.84994662e-03f, -1.85734183e-01f, -3.96203883e-02f, 3.35985333e-01f, 1.35209575e-01f, 2.45291024e-01f, 9.78312641e-02f, -1.04252547e-01f, 2.57657170e-02f, 1.59894824e-01f,
  -1.30211547e-01f, -2.85680257e-02f, -8.99828225e-02f, -1.19093679e-01f, 2.57843554e-01f, 7.23726675e-02f, -1.12449497e-01f, 7.97000900e-02f, -1.31946936e-01f, -8.26035216e-02f,
  -4.66359444e-02f, 2.80646712e-01f, -1.56314448e-02f, 1.02798186e-01f, -3.62257697e-02f, 9.57886055e-02f, 1.41021395e-02f, -1.50996685e-01f, 8.29462260e-02f, 1.30808681e-01f,
  1.25523537e-01f, -6.46158457e-02f, -1.23635530e-01f, -8.04383233e-02f, -9.54487100e-02f, -8.31489712e-02f, 1.45044476e-02f, 1.17230797e-02f, -2.33083516e-02f, 4.72297482e-02f,
  1.53976440e-01f, 3.75170738e-01f, -2.11432520e-02f, 5.03259040e-02f, 1.52894735e-01f, -6.14758171e-02f, 2.38955691e-01f, 4.81913276e-02f, -1.20009989e-01f, 1.38983890e-01f,
  7.08566234e-02f, -1.75132394e-01f, 2.96672761e-01f, -1.32301509e-01f, 3.77070047e-02f, 1.77031279e-01f, 2.05881566e-01f, -2.33713016e-02f, 2.40698919e-01f, 2.05939380e-03f,
  -2.52292454e-01f, -9.43317115e-02f, 1.31292408e-02f, -2.19041452e-01f, 2.03019366e-01f, 4.27066768e-03f, 2.49907330e-01f, 6.69070333e-03f, -5.99590130e-02f, -3.34135145e-02f,
  -4.82190736e-02f, 1.89218596e-01f, -1.08404584e-01f, -1.40343728e-02f, 4.31105383e-02f, 1.29247427e-01f, -2.94575300e-02f, 3.28508258e-01f, -1.39375448e-01f, 2.90617794e-02f,
  -4.78050020e-03f, 2.27088049e-01f, 1.39018282e-01f, 8.18313360e-02f, -4.79336269e-02f, 1.19578019e-01f, -2.65249014e-02f, -1.51778637e-02f, 6.19575717e-02f, 5.46303652e-02f,
  -9.32447705e-03f, 2.01291725e-01f, 3.30903307e-02f, -5.33508994e-02f, -8.25043842e-02f, 2.17941448e-01f, -1.00638501e-01f, 3.22666392e-02f, -1.10973582e-01f, 2.76786804e-01f,
  -5.22191934e-02f, -9.23832953e-02f, 1.40733561e-02f, 2.87968487e-01f, -1.59025997e-01f, -8.01368442e-04f, -7.47785810e-03f, 1.39117077e-01f, -2.92169869e-01f, 5.68928346e-02f,
  -1.25332966e-01f, -1.35438323e-01f, -1.32086903e-01f, -2.60605477e-02f, -6.36900812e-02f, 8.40379298e-02f, -1.41480252e-01f, 2.51933217e-01f, 2.68673062e-01f, 1.27500698e-01f,
  1.83245048e-01f, 8.32533687e-02f, -9.47467163e-02f, -1.14345863e-01f, 1.50133595e-01f, 1.58786774e-01f, 1.24577872e-01f, -2.12243766e-01f, 1.87534302e-01f, -1.11752175e-01f,
  1.86765194e-01f, 1.13700785e-01f, 1.50833979e-01f, 2.03672066e-01f, -8.29242691e-02f, -3.72688957e-02f, 2.91482478e-01f, -6.73104171e-03f, -1.31233046e-02f, -8.66812244e-02f,
  -2.51214541e-02f, -2.34124467e-01f, -5.92816919e-02f, 1.04932494e-01f, 1.88460663e-01f, -4.34322745e-01f, 2.37240523e-01f, 1.28823534e-01f, 9.99012142e-02f, 7.29456171e-02f,
  6.76752329e-02f, 1.21926442e-01f, -1.25173137e-01f, -2.88459715e-02f, 2.21342579e-01f, 1.47009701e-01f, -1.68397620e-01f, 3.97441536e-02f, -1.61315620e-01f, 6.23462200e-02f,
  -6.59268126e-02f, 4.30990547e-01f, 3.00548911e-01f, 1.71440944e-01f, 2.39036027e-02f, 1.13349654e-01f, 8.04678574e-02f, 5.11308834e-02f, 1.97890159e-02f, -3.44883278e-02f,
  -3.61893252e-02f, -5.28400689e-02f, -1.25079483e-01f, 1.31354839e-01f, 5.45463599e-02f, 1.40699998e-01f, 7.88017958e-02f, 1.01730369e-01f, -2.72534370e-01f, -1.76805351e-02f,
  -1.86364353e-01f, 1.15666643e-01f, -7.53135160e-02f, -1.87361702e-01f, -1.31286740e-01f, 7.56501183e-02f, 1.20268919e-01f, 3.17963548e-02f, 4.19692770e-02f, -6.10260814e-02f,
  8.09526220e-02f, 1.73909664e-01f, -1.40446648e-01f, 2.37976834e-01f, -3.20814610e-01f, 2.68982172e-01f, -3.13314497e-02f, 1.16135448e-01f, 6.31811768e-02f, 4.25280705e-02f,
  -1.71397686e-01f, -1.50366753e-01f, -1.31009430e-01f, 6.33859932e-02f, -3.83677661e-01f, -6.15163222e-02f, 2.25847900e-01f, -2.61703748e-02f, 1.77443534e-01f, -1.63682088e-01f,
  1.63584664e-01f, 2.11288869e-01f, -1.71531625e-02f, 1.90606266e-01f, 2.01725289e-01f, 1.57892734e-01f, -2.46710360e-01f, -9.12369564e-02f, 8.41697678e-02f, 1.29799351e-01f,
  -1.45444021e-01f, -1.47667140e-01f, 9.96566657e-03f, 8.47567338e-03f, -1.54905289e-01f, 1.85217500e-01f, 2.86809266e-01f, 1.08601898e-01f, -3.56287688e-01f, -2.94969231e-01f,
  1.31104022e-01f, 2.24046186e-01f, 2.05899566e-01f, 2.14233235e-01f, -2.24554777e-01f, 1.42231897e-01f, -3.71687748e-02f, 2.27821782e-01f, -5.95206246e-02f, 5.75995035e-02f,
  -1.20326176e-01f, 1.49780631e-01f, -2.01833203e-01f, 1.58636679e-03f, 1.19532630e-01f, -1.08348094e-01f, -3.04512400e-02f, 1.69448391e-01f, 1.14298556e-02f, 1.30505517e-01f,
  7.46004507e-02f, 1.71037018e-02f, -1.79282874e-02f, -7.41126686e-02f, 1.70806780e-01f, -1.22491620e-01f, 4.05701697e-02f, 2.22597063e-01f, 1.57599859e-02f, 1.94285274e-01f,
  -1.05476543e-01f, 2.20853895e-01f, -1.78407326e-01f, 1.62828982e-01f, 1.75004750e-01f, -8.38863757e-03f, 5.79890097e-03f, 5.61645962e-02f, 3.52334529e-02f, 6.46254327e-03f,
  2.62577474e-01f, 1.59970835e-01f, 7.92355463e-02f, 9.76556242e-02f, 3.45828950e-01f, 3.29125375e-02f, 1.26865655e-01f, 1.28404228e-02f, 2.76559174e-01f, 1.55076042e-01f,
  -4.41985726e-02f, 2.51757260e-02f, -2.04318836e-01f, 2.39443675e-01f, -9.16220471e-02f, -6.19993918e-02f, -1.91375121e-01f, -3.06219399e-01f, -5.97649366e-02f, -1.35076046e-01f,
  3.23087931e-01f, 2.13170409e-01f, -5.16835153e-02f, -1.15345992e-01f, -3.05633068e-01f, -4.44425307e-02f, 3.07330489e-02f, 3.24642897e-01f, 1.01300970e-01f, 1.82405636e-01f,
  6.55277967e-02f, 3.53761226e-01f, -1.43606842e-01f, 7.27439970e-02f, 2.39081159e-01f, -1.02683559e-01f, -2.58897722e-01f, 2.59339660e-02f, -6.81409538e-02f, -7.80219445e-04f,
  1.74083546e-01f, 8.94543454e-02f, 1.35936871e-01f, 3.35882455e-01f, 7.78233334e-02f, 1.16721414e-01f, 1.18766218e-01f, 1.78745896e-01f, 1.72760412e-01f, -3.39789838e-01f,
  6.22876398e-02f, 2.71633327e-01f, -7.82935247e-02f, 1.11509852e-01f, -4.39551175e-02f, 1.27960280e-01f, 8.33790526e-02f, 2.31796607e-01f, 1.61700755e-01f, -8.26173276e-02f,
  1.00392044e-01f, 1.05700113e-01f, -8.25015083e-02f, -1.32667795e-01f, 4.50994894e-02f, 6.12781383e-02f, 3.01350635e-02f, 1.04094706e-01f, 1.23210639e-01f, 1.00074291e-01f,
  1.66365430e-01f, 1.09596722e-01f, -1.10456526e-01f, -9.46411788e-02f, 1.49891034e-01f, 1.16645908e-02f, 7.93488920e-02f, -6.64085075e-02f, 1.43713683e-01f, 2.55492061e-01f,
  6.76073655e-02f, 5.31509034e-02f, 6.96234405e-02f, 8.18901807e-02f, -2.27893725e-01f, 1.05210513e-01f, 6.90612346e-02f, 2.11695686e-01f, -2.31128782e-01f, 1.75336730e-02f,
  -9.52138752e-02f, -3.21562439e-01f, -1.95501205e-02f, 1.42175794e-01f, 2.35227607e-02f, -3.23822387e-02f, 1.92503020e-01f, -4.50373953e-03f, 6.90141991e-02f, 1.82250112e-01f,
  3.85613799e-01f, 1.76311582e-01f, -1.08041912e-01f, 4.12489712e-01f, -1.05115282e-03f, 1.07328288e-01f, 3.63017350e-01f, 1.45559371e-01f, 4.34072278e-02f, 3.27746645e-02f,
  -9.39047262e-02f, -8.57313797e-02f, -1.37229115e-01f, 2.10329950e-01f, 1.71616107e-01f, 1.73343141e-02f, 2.14219809e-01f, -1.15220606e-01f, 3.87366295e-01f, -1.56049415e-01f,
  8.23023096e-02f, 2.59500416e-03f, -4.46216613e-02f, 6.99136183e-02f, 6.22956231e-02f, -2.46102121e-02f, -2.17003413e-02f, 1.66270565e-02f, -1.41252786e-01f, -5.63175119e-02f
};

// L3_fan_Bp_bar (Shape: 1 x 40)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 40;
const float L3_fan_Bp_bar_data[] = {
  -1.47915808e-02f, 2.91310269e-02f, 1.41701549e-01f, 1.53348334e-02f, -6.40774369e-02f, 5.52848876e-02f, -6.78743888e-03f, 2.90702935e-03f, 4.91625948e-40f, -4.70717475e-02f,
  1.91238075e-02f, 1.00364294e-02f, -1.86877529e-04f, -1.22507267e-01f, 2.30070233e-01f, -7.20786583e-03f, 7.08539262e-02f, -8.46570078e-03f, 1.19215742e-01f, -7.02084079e-02f,
  3.71598788e-02f, -3.51361036e-02f, 2.47094501e-02f, -1.30209727e-02f, 2.30211280e-02f, -2.89496835e-02f, 1.29393622e-01f, 1.18980752e-02f, 9.63349119e-02f, -1.63268317e-02f,
  5.85896000e-02f, 1.35003358e-01f, 1.56553392e-09f, 1.60459220e-01f, 1.19153962e-01f, 4.60997187e-02f, 3.56613062e-02f, -5.81711493e-02f, 5.62686697e-02f, 2.76310034e-02f
};

// L4_linear_W (Shape: 12 x 64)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 64;
const float L4_linear_W_data[] = {
  2.15257406e-01f, 2.79318094e-02f, -1.93437710e-01f, -8.94140974e-02f, -2.29901269e-01f, -1.37419969e-01f, 1.78895181e-03f, -2.27960870e-02f, -2.43508667e-02f, -1.41104097e-02f,
  -9.22943726e-02f, -8.73044208e-02f, -7.63729736e-02f, 2.95734834e-02f, 1.35881543e-01f, -1.77026734e-01f, 9.01557854e-04f, 1.31258428e-01f, -3.02148491e-01f, 1.26046613e-01f,
  -1.55054137e-01f, 1.83533490e-01f, 1.38092637e-01f, -1.01172104e-02f, -9.52197388e-02f, -1.62017331e-01f, 1.55522302e-01f, 3.19215097e-02f, 1.77455664e-01f, -1.94204628e-01f,
  -2.40611985e-01f, 1.64508075e-01f, 5.08888544e-40f, 2.55285621e-01f, -1.36154816e-01f, 1.76096961e-01f, -1.55530646e-02f, 1.62030727e-01f, -5.38009644e-01f, -5.22607530e-04f,
  -2.51274228e-01f, 1.50720049e-02f, 4.52377573e-02f, 1.38179347e-01f, -4.82441097e-01f, -9.10566673e-02f, 1.04846597e-01f, -4.86908015e-04f, -8.16550404e-02f, -4.50103790e-01f,
  -2.87678778e-01f, 4.91422527e-02f, -3.44260812e-01f, -6.34192582e-03f, 1.58199742e-02f, -1.53005853e-01f, -1.35826073e-12f, -1.27252331e-02f, 1.34922385e-01f, -2.86827981e-03f,
  -2.84166019e-02f, -2.94567849e-02f, -3.43146622e-01f, -7.87999630e-02f, -1.81749627e-01f, -7.38595277e-02f, 6.07930124e-02f, -1.56390235e-01f, -1.75079480e-01f, -2.10675910e-01f,
  -5.85278831e-02f, -1.22402117e-01f, 3.99854779e-02f, 1.23908937e-01f, -1.48825899e-01f, -8.90295487e-03f, 3.05752635e-01f, 9.43327621e-02f, 1.90637797e-01f, 2.54996449e-01f,
  -1.26974493e-01f, -1.59863666e-01f, 7.27937520e-02f, 2.11674437e-01f, -1.36195114e-02f, 1.92393661e-01f, -3.89941707e-02f, 1.79577187e-01f, -8.84169638e-02f, -9.56196934e-02f,
  1.87660195e-02f, 6.10649362e-02f, 1.20170027e-01f, 1.44935653e-01f, 1.58661991e-01f, 2.67905861e-01f, 4.94627529e-40f, -1.05079293e-01f, -3.20172995e-01f, -1.34507578e-03f,
  2.27822267e-04f, 1.01272546e-01f, -3.16740312e-02f, -2.36967932e-02f, 4.85091694e-02f, -5.95697984e-02f, -2.78011858e-01f, -3.98194253e-01f, 1.03518568e-01f, -3.72995347e-01f,
  -8.55350271e-02f, -1.23730749e-01f, -1.43711090e-01f, 4.54438031e-02f, 9.90235806e-02f, 1.65572315e-01f, 1.62703469e-01f, -2.46208757e-02f, 1.04632080e-01f, -1.86132327e-01f,
  -6.67846195e-11f, -1.80071983e-02f, 1.41547084e-01f, -2.04513326e-01f, -2.94164866e-01f, -4.71488118e-01f, -1.17273964e-01f, 8.40848982e-02f, -1.37302699e-03f, 1.78132821e-02f,
  -4.19082157e-02f, -5.98555133e-02f, 1.51599407e-01f, 1.01401389e-01f, 2.98641443e-01f, 1.17948748e-01f, 3.01566929e-01f, -1.45498976e-01f, -6.24963976e-02f, -2.61618346e-01f,
  -1.97244242e-01f, 1.63404077e-01f, -3.72014679e-02f, -2.65664637e-01f, 6.82852641e-02f, -2.37116180e-02f, 6.73372447e-02f, 3.43477756e-01f, -3.09889138e-01f, -8.15496370e-02f,
  2.03528598e-01f, 2.23329782e-01f, -2.56731123e-01f, 2.90590804e-02f, 5.17910346e-02f, 1.00035548e-01f, -3.43897492e-01f, -4.49327558e-01f, 2.10346773e-01f, 4.74629514e-02f,
  -5.02742449e-40f, 2.65449509e-02f, 4.20760587e-02f, -2.14527950e-01f, -3.29186187e-05f, -8.21267441e-02f, 1.81516215e-01f, -7.00551085e-04f, -2.94218332e-01f, 1.82556622e-02f,
  -5.47971964e-01f, -5.11414945e-01f, -2.67560273e-01f, -2.80149937e-01f, 6.67215558e-03f, 1.86457206e-02f, 8.20462033e-03f, -4.45827812e-01f, 1.45410508e-01f, -2.47994199e-01f,
  -2.70240232e-02f, 1.29056135e-02f, 1.20997444e-01f, 2.59410411e-01f, -4.34190227e-12f, -5.34765601e-01f, 2.79775131e-02f, -1.23573244e-01f, 2.56248534e-01f, 6.35370165e-02f,
  2.55585879e-01f, 2.27449951e-03f, -1.16133410e-02f, -2.40180969e-01f, -1.99954435e-01f, -1.15051426e-01f, 9.01322737e-02f, -1.29701868e-01f, -1.96220294e-01f, -1.58527970e-01f,
  -5.73942810e-02f, 6.94306493e-02f, -7.99408704e-02f, -2.00312629e-01f, -6.66375607e-02f, 4.06759791e-02f, 2.89970577e-01f, -1.25543848e-01f, -1.10824652e-01f, -1.01071410e-01f,
  -3.55368197e-01f, -4.16525811e-01f, -3.97648141e-02f, -1.34842649e-01f, -3.25981706e-01f, -3.49034160e-01f, 6.74934909e-02f, -5.86075306e-01f, 1.12219661e-01f, 2.34520365e-03f,
  1.13483384e-01f, -5.36939144e-01f, -3.88894491e-02f, -2.59622961e-01f, -5.93867487e-40f, -1.70450196e-01f, 2.77078152e-02f, -1.02431566e-01f, -1.11020291e-02f, -2.27774098e-03f,
  -1.26275033e-01f, -5.79749757e-18f, 1.17134221e-01f, -1.07507431e-03f, 1.09750323e-01f, 2.13695884e-01f, -3.13722253e-01f, 1.55482814e-01f, 3.11712530e-02f, -6.23268485e-02f,
  -4.49771546e-02f, -3.78100663e-01f, -1.12938441e-01f, -3.40959728e-01f, -1.21329881e-01f, -6.75620558e-03f, 1.01169482e-01f, -1.17453985e-01f, 6.05517112e-12f, 4.07381356e-02f,
  1.34121418e-01f, 9.94876772e-02f, -1.48649260e-01f, 1.72749847e-01f, 1.97343882e-02f, -3.84740859e-01f, 2.76201576e-01f, 4.23983596e-02f, 2.52147883e-01f, 5.68148457e-02f,
  1.61492363e-01f, -9.96317249e-03f, 2.82754391e-01f, -5.34204096e-02f, 2.46189311e-01f, -5.95179945e-02f, 9.20549110e-02f, 3.80275436e-02f, -2.36334279e-01f, -3.01500946e-01f,
  2.30588093e-01f, 5.00016510e-02f, -2.33282924e-01f, 3.71727318e-01f, 3.49029116e-02f, 2.02200398e-01f, 1.33623913e-01f, 8.16631503e-03f, 1.37038097e-01f, 2.52913356e-01f,
  -6.76963776e-02f, -1.45712465e-01f, -5.34120537e-02f, 8.88051242e-02f, 1.44284189e-01f, -1.95811018e-01f, -3.88128281e-01f, 3.97347920e-02f, -5.22839871e-40f, -2.62833357e-01f,
  1.42269626e-01f, -1.10539809e-01f, 5.12969214e-03f, 1.83331713e-01f, -3.95932466e-01f, -1.93785783e-02f, 2.15415657e-02f, -4.45478596e-03f, 2.18078330e-01f, -7.69050270e-02f,
  7.84039199e-02f, 2.26601496e-01f, -3.38980481e-02f, -3.09885596e-03f, 5.11147175e-03f, 1.33045867e-01f, -2.20164448e-01f, -2.36401819e-02f, -2.77653724e-01f, -1.54326623e-02f,
  1.31368458e-01f, -1.50151938e-01f, 3.89849472e-11f, 2.38146916e-01f, -7.53659457e-02f, 1.47477120e-01f, -3.73559585e-03f, -5.81226163e-02f, -8.73211771e-02f, -4.61821966e-02f,
  -2.66044348e-01f, 1.37781799e-01f, 7.74248168e-02f, 2.13832751e-01f, 1.75753143e-02f, 1.04747206e-01f, 1.61828563e-01f, -4.07978073e-02f, -1.29178435e-01f, 1.59588516e-01f,
  2.70632356e-01f, 6.39209226e-02f, -1.29178390e-01f, -2.14848623e-01f, -2.44027108e-01f, -5.89015372e-02f, -2.65280664e-01f, -1.77082166e-01f, 2.01925308e-01f, 1.33123800e-01f,
  -1.60794154e-01f, -2.91301250e-01f, 1.76681906e-01f, -3.76773715e-01f, -2.75975645e-01f, 1.37467012e-01f, 1.43449590e-01f, 1.86061248e-01f, 4.35592569e-02f, -1.66657984e-01f,
  -4.13098298e-02f, -1.01655491e-01f, -5.09695692e-40f, -3.03753942e-01f, 2.09710568e-01f, -1.36054829e-01f, -3.27702983e-05f, 1.81163102e-01f, 6.11508824e-02f, -1.48117123e-02f,
  -2.34745979e-01f, -3.12780123e-03f, 6.29466698e-02f, 2.96956468e-02f, -5.21844849e-02f, -4.81468946e-01f, -1.20786689e-01f, -1.57513598e-03f, 2.93605179e-02f, 3.76266800e-02f,
  -1.80127293e-01f, -2.00480491e-01f, -1.62593257e-02f, -7.39749987e-03f, -1.69440359e-02f, -3.02586079e-01f, 8.99917016e-11f, -2.65893370e-01f, 1.90691680e-01f, -3.27173658e-02f,
  -2.43013471e-01f, 2.22738590e-02f, -1.44610330e-01f, 9.54220295e-02f, -2.01636422e-02f, 2.29459792e-01f, -2.06261218e-01f, -6.60121441e-02f, -4.93653044e-02f, 1.97650924e-01f,
  -6.44420683e-02f, 8.59506428e-02f, -8.46101269e-02f, 2.47139901e-01f, 1.30855396e-01f, -8.03719312e-02f, 5.47165982e-04f, -1.47745581e-02f, 6.68896362e-02f, 7.15849400e-02f,
  8.57783034e-02f, 7.21886083e-02f, 8.06168467e-02f, 1.48123549e-02f, 1.75883740e-01f, -2.77300298e-01f, 3.51362070e-03f, 2.16802955e-02f, 4.00580853e-01f, 1.46253645e-01f,
  -4.39676613e-01f, -1.78268477e-01f, -3.63330185e-01f, 5.59692569e-02f, -5.73765598e-02f, -1.65156350e-01f, 5.38443330e-40f, 1.83551654e-01f, -3.59162480e-01f, 1.32138491e-01f,
  -1.20627119e-05f, -2.17903346e-01f, 1.48680672e-01f, -8.94419756e-03f, -2.91641474e-01f, -1.42897749e-02f, -2.44293496e-01f, -3.87561053e-01f, 2.26355016e-01f, -8.20053276e-03f,
  -7.84736797e-02f, 1.41802570e-02f, -8.60077515e-02f, 5.53155132e-02f, 1.19804390e-01f, -3.81903723e-02f, -5.26843369e-02f, 1.85559735e-01f, -3.53520125e-01f, 2.02700004e-01f,
  -7.72737280e-07f, -1.75626874e-01f, 5.76291308e-02f, -3.22427392e-01f, 2.16568783e-01f, -1.03643700e-01f, 8.59156474e-02f, -9.13443789e-02f, 2.17720330e-01f, -1.87279388e-01f,
  1.22864321e-01f, -2.58616339e-02f, -1.58063039e-01f, 1.08630188e-01f, -1.07009724e-01f, 1.49536118e-01f, 7.67678395e-02f, -2.48681381e-01f, 7.94603974e-02f, 1.44094571e-01f,
  -1.19501546e-01f, -1.65285051e-01f, -1.34939030e-01f, 6.32231729e-03f, 1.80344373e-01f, 5.99547550e-02f, -1.47297814e-01f, 8.45029429e-02f, 1.63654000e-01f, 2.35435471e-01f,
  -2.71873385e-01f, 2.02348813e-01f, -2.29662269e-01f, -9.88613963e-02f, 1.74657509e-01f, -1.77293286e-01f, -1.13725036e-01f, 1.21484339e-01f, 9.52510089e-02f, -1.87389046e-01f,
  6.11511236e-40f, -4.41261202e-01f, -1.78715959e-01f, -3.00075799e-01f, 2.23999268e-05f, 1.20161794e-01f, -3.71776938e-01f, 4.16809984e-04f, 1.65239275e-01f, 2.59598275e-03f,
  -4.52815071e-02f, 1.62734494e-01f, 1.89719498e-01f, -2.77725786e-01f, -3.89993005e-02f, 3.85083184e-02f, -2.51107221e-03f, 1.77850813e-01f, 3.33100855e-02f, -5.56346774e-02f,
  -1.07917204e-01f, 2.18640938e-02f, -1.15088843e-01f, 1.29657835e-01f, -3.81112589e-12f, -1.59419820e-01f, -6.59839585e-02f, -1.52450325e-02f, -2.03059718e-01f, -3.36478055e-02f,
  9.57705155e-02f, -3.14495564e-01f, -1.45440742e-01f, 1.36694178e-01f, 1.39881641e-01f, 1.12761252e-01f, 5.17842732e-02f, 1.29734635e-01f, 8.94081667e-02f, 5.53715462e-03f,
  -3.50532681e-01f, 5.11065647e-02f, 1.54942676e-01f, -4.17834409e-02f, -1.50651723e-01f, 7.12869465e-02f, 5.46912104e-02f, -1.87997743e-01f, 2.50528365e-01f, 3.01824212e-01f,
  1.84170175e-02f, -5.71458399e-01f, -2.82583535e-01f, 1.18001215e-01f, -9.47738215e-02f, -4.53624725e-01f, 5.03187597e-01f, -1.72659591e-01f, -7.41565526e-02f, 3.18171903e-02f,
  9.23736691e-02f, -6.84539601e-02f, 2.95872957e-01f, 6.46500336e-03f, 5.01324335e-40f, -3.62023711e-02f, -4.30267036e-01f, -6.64226949e-01f, -1.76553385e-05f, -1.66344360e-01f,
  2.85839617e-01f, -1.50128659e-02f, 7.57344998e-03f, 1.05260452e-02f, -7.10509941e-02f, 9.78587419e-02f, -7.28238374e-02f, 9.04283971e-02f, 7.75398836e-02f, 8.78909254e-04f,
  5.77496812e-02f, -1.28040820e-01f, 1.30901352e-01f, -1.04610212e-01f, 2.12638900e-02f, -1.17659084e-01f, -1.32573381e-01f, -2.95993924e-01f, 5.00207514e-12f, -9.36187953e-02f,
  -4.81779099e-01f, -3.68119329e-01f, 2.59283394e-01f, -1.14959501e-01f, -2.18068957e-01f, 8.80135298e-02f, 1.49816215e-01f, 1.76632673e-01f, 4.06770408e-02f, 4.78675007e-04f,
  -1.55152813e-01f, 1.07263513e-01f, -1.81974843e-01f, -1.46995783e-01f, 4.96452451e-02f, -3.81432138e-02f, -1.02974921e-01f, -1.02096692e-01f, 3.39148603e-02f, 1.41236298e-02f,
  1.55632287e-01f, 2.27589652e-01f, 1.36174083e-01f, -2.10479900e-01f, -9.36077014e-02f, 2.25567698e-01f, 2.85498857e-01f, 1.21875085e-01f, 2.18117908e-01f, 3.43271419e-02f,
  -3.60329300e-01f, 8.76490846e-02f, -2.73098588e-01f, 9.68699604e-02f, -3.36742133e-01f, 1.79186258e-02f, -2.23376378e-01f, -1.49611205e-01f, 4.93711080e-40f, -6.04000270e-01f,
  1.77172974e-01f, -5.69798052e-01f, 3.67166450e-07f, -2.82928664e-02f, -1.15230493e-01f, 5.53647231e-04f, -3.36012572e-01f, 2.77331080e-02f, 5.29457815e-02f, -3.31864685e-01f,
  6.51830286e-02f, -4.24537718e-01f, 3.18718739e-02f, 2.14166660e-02f, 4.19529863e-02f, -1.02119118e-01f, 1.75153285e-01f, -2.25117519e-01f, 1.26752947e-02f, -2.52069831e-02f,
  -1.53969988e-01f, 7.05603734e-02f, -2.87128017e-07f, -1.74362995e-02f, -2.53646135e-01f, 1.54369846e-01f, -2.36066923e-01f, -1.31590348e-02f, 1.99114203e-01f, 6.25981614e-02f,
  2.00786684e-02f, 8.69609267e-02f, 4.22255881e-02f, -2.63666034e-01f, -7.14066997e-02f, -2.33808458e-01f, -1.20148256e-01f, 1.51884019e-01f, -1.29559577e-01f, -3.31461802e-02f,
  -1.26505986e-01f, 1.43490836e-01f, 2.53315508e-01f, -7.32767656e-02f, -1.70238331e-01f, 1.17374204e-01f, 2.43190169e-01f, -8.21937323e-02f, -4.83465269e-02f, -7.13538786e-04f,
  -2.40631849e-01f, -3.03610891e-01f, 6.73538074e-02f, -8.80205333e-02f, -2.06945702e-01f, 3.56646478e-02f, -2.16806158e-01f, -3.83246690e-02f, -2.36605212e-01f, -4.75287557e-01f,
  -1.31381854e-01f, -5.78454256e-01f, -5.49621488e-40f, -3.90038006e-02f, -3.52767631e-02f, -3.90438020e-01f, -5.10754705e-32f, -2.20398158e-01f, 2.22526670e-01f, 4.92514371e-40f,
  -2.47637153e-01f, 5.68906078e-03f, 7.22463578e-02f, -3.53297204e-01f, -3.54594886e-01f, 9.72222164e-02f, -5.90010621e-02f, 4.70194733e-03f, 1.35908693e-01f, -6.53098300e-02f,
  1.32381797e-01f, 1.84397250e-01f, 2.53063947e-01f, -6.48302201e-04f, 2.43844271e-01f, -3.92471552e-01f, -9.77844216e-13f, 2.01429874e-01f, -5.53804962e-03f, 2.28228182e-01f,
  -1.04352415e-01f, -3.08168113e-01f, -3.12224030e-01f, 1.87562749e-01f, -9.64318737e-02f, -2.25685999e-01f, 1.07201450e-01f, 1.11737087e-01f, 2.03087822e-01f, 3.70842405e-02f,
  -2.45862491e-02f, 1.33757712e-02f, -2.24262569e-02f, 1.27486838e-02f, -1.43394426e-01f, 1.20486781e-01f, 1.96218982e-01f, 2.49504298e-01f, -3.22684765e-01f, -7.51020163e-02f,
  -2.74473820e-02f, 2.12318197e-01f, 8.16442817e-02f, -2.82114238e-01f, 3.44228260e-02f, -3.79939318e-01f, -3.81476760e-01f, -2.97386557e-01f, 1.32471368e-01f, -7.66856894e-02f,
  9.96549800e-02f, -4.70295995e-01f, 7.64382705e-02f, 1.04705885e-01f, -2.15614587e-01f, -1.29628554e-02f, -6.01618068e-40f, -2.51575410e-02f, 2.58701682e-01f, -7.47482359e-01f,
  4.93854013e-40f, -3.08998317e-01f, -2.11591780e-01f, -4.25412416e-09f, 6.29256964e-02f, -2.38010404e-03f, 9.13477838e-02f, -7.17922300e-02f, -1.71169072e-01f, -2.46263221e-01f,
  -4.87753469e-03f, -6.53763954e-03f, -3.93088832e-02f, -3.49077940e-01f, -4.15758602e-02f, -8.36432949e-02f, 4.70221555e-03f, -2.91065313e-02f, -3.37894559e-01f, 1.48134157e-01f,
  -5.39925439e-12f, 1.75415635e-01f, -3.86542439e-01f, 1.67378932e-01f, 1.68933079e-01f, 2.41877794e-01f, 1.27158701e-01f, -2.37664863e-01f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  -1.80033714e-01f, 7.19105676e-02f, 1.34480186e-02f, 4.88082319e-02f, -6.35568276e-02f, -1.43127944e-02f, 5.85365705e-02f, -1.37851581e-01f, -6.11457601e-02f, 3.56955193e-02f,
  -4.09490764e-02f, 1.50934741e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 12, 40
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 12, 40
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        64, 12, 40
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        64, 12, 40
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        64, 12
    );
    }
    