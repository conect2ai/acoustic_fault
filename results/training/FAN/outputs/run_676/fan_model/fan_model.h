/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 12 x 120)
const int L0_fan_Wp_rows = 12;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -5.77693582e-01f, 1.80999950e-01f, 2.16155186e-01f, -1.79685339e-01f, -5.96492998e-02f, -6.43517002e-02f, 1.42518759e-01f, -9.46844220e-02f, -3.09566427e-02f, 4.62044403e-02f,
  -4.89014108e-03f, -9.83277895e-03f, -1.99292861e-02f, 1.86509639e-02f, -5.06502353e-02f, 2.57521391e-01f, 2.47139946e-01f, -9.66925099e-02f, -1.95142366e-02f, 7.70426318e-02f,
  1.07079126e-01f, -1.18819200e-01f, -1.44244939e-01f, -1.39340609e-02f, 1.35087162e-01f, 1.09022386e-01f, 1.17975734e-01f, 4.57327105e-02f, 1.91258162e-01f, 3.87587458e-01f,
  2.06549302e-01f, -3.69201191e-02f, -2.43635457e-02f, -3.64838056e-02f, 8.25981870e-02f, 5.36305085e-02f, 7.17309490e-02f, 2.98117977e-02f, -4.02171947e-02f, 1.37822544e-02f,
  2.16089040e-02f, 5.87474741e-02f, 1.92145705e-02f, 6.35803044e-02f, 6.44976720e-02f, 1.10732428e-04f, 3.92469130e-02f, 4.98231724e-02f, 6.16246611e-02f, 5.94103001e-02f,
  8.42985138e-02f, 9.82700214e-02f, -4.33637723e-02f, 6.57790676e-02f, 8.45400915e-02f, 1.22948159e-02f, 6.60144314e-02f, 8.79929513e-02f, 3.07459552e-02f, 4.87325229e-02f,
  9.17960107e-02f, -4.00406159e-02f, 1.41496556e-02f, 4.17017639e-02f, -3.05403005e-02f, 4.75476049e-02f, -3.42955589e-02f, 3.85854617e-02f, -5.06391861e-02f, 8.21912065e-02f,
  -3.62943523e-02f, -5.08334767e-03f, -8.59309640e-03f, -8.08787253e-03f, 1.61568895e-02f, -2.19869930e-02f, -2.11030729e-02f, -2.16099303e-02f, -1.57401362e-03f, -1.07903220e-01f,
  -9.78358090e-02f, -4.95645478e-02f, -7.31779635e-02f, -4.39874455e-02f, 8.05430040e-02f, -1.81539450e-02f, 3.44286463e-03f, 1.44764865e-02f, 4.15415801e-02f, -3.60432733e-03f,
  -7.16331154e-02f, -2.36831874e-01f, -2.39401665e-02f, -1.06532082e-01f, 2.50537810e-03f, 5.03309034e-02f, -3.98396142e-02f, 1.02959648e-02f, -3.03890966e-02f, -5.72736971e-02f,
  3.62052396e-03f, -1.49837658e-02f, -3.82500142e-02f, 1.24716908e-01f, -3.27923335e-02f, -8.94627441e-03f, 5.40280119e-02f, -2.72494312e-02f, -4.97046337e-02f, 6.02448024e-02f,
  4.93132435e-02f, -1.10349193e-01f, -1.55714646e-01f, 6.84513226e-02f, 5.27444929e-02f, -1.22517072e-01f, 1.27405196e-01f, -1.73061509e-02f, -1.88268811e-01f, -3.14861462e-02f,
  -3.63944054e-01f, -5.08830130e-01f, 1.31727144e-01f, -5.11676557e-02f, 2.59042978e-01f, 2.76724577e-01f, 6.51286617e-02f, -8.25470760e-02f, -7.35770091e-02f, 3.19848768e-02f,
  1.23598561e-01f, 1.14316195e-01f, 7.13023171e-02f, 1.72936451e-02f, -2.05033064e-01f, -9.56182182e-02f, -9.32610333e-02f, -4.94635887e-02f, 1.04908295e-01f, 8.18680897e-02f,
  1.04971034e-02f, -2.72768792e-02f, -1.05727784e-01f, -8.15750733e-02f, 5.29571846e-02f, 3.36473584e-02f, -9.78152677e-02f, 2.80783717e-02f, -1.00048833e-01f, -2.01184884e-01f,
  2.29113564e-01f, -1.81359090e-02f, 4.32347655e-02f, -1.34810165e-01f, 3.40745449e-02f, -1.22485183e-01f, -1.90492626e-03f, 7.43089244e-03f, -2.23391149e-02f, 5.74664678e-03f,
  1.31569341e-01f, 1.28785633e-02f, 1.25941798e-01f, -2.49057598e-02f, 7.74363652e-02f, 1.42188538e-02f, -1.55344382e-01f, -5.91433868e-02f, -9.30425301e-02f, 5.02261780e-02f,
  4.75425571e-02f, 3.83992828e-02f, 1.60942242e-01f, 2.40947381e-02f, -8.91925860e-03f, 2.40343399e-02f, 6.63934797e-02f, -7.33858570e-02f, -6.96040094e-02f, -2.12352380e-01f,
  -1.25048622e-01f, -3.87096368e-02f, 1.24370337e-01f, 1.21649951e-02f, 3.35584357e-02f, 2.28285659e-02f, -1.35315247e-04f, 8.94099027e-02f, 8.34318548e-02f, 1.40612945e-02f,
  5.38044013e-02f, 1.37984492e-02f, 1.38544381e-01f, -1.74088795e-02f, 9.39695016e-02f, 7.98940733e-02f, 1.07250949e-02f, 4.70585153e-02f, 9.03558135e-02f, 2.91606341e-03f,
  -2.91294660e-02f, 1.21586606e-01f, 1.64115895e-03f, -6.00589141e-02f, 8.53184834e-02f, 6.95875213e-02f, -6.75402433e-02f, 9.92043316e-02f, 7.54212588e-02f, 8.19653347e-02f,
  4.04193848e-02f, -1.69561319e-02f, -5.12603261e-02f, -1.11673839e-01f, 9.13238432e-03f, -1.12341806e-01f, 7.52644539e-02f, -1.08905971e-01f, 2.91442429e-03f, -2.23908592e-02f,
  8.52539204e-03f, -2.56677568e-02f, -7.16999965e-03f, -7.23487437e-02f, 5.52137494e-02f, -8.94095656e-03f, -6.91368580e-02f, -2.14149076e-02f, -1.04486212e-01f, -3.66547592e-02f,
  -5.21661639e-02f, 6.52718917e-02f, 9.29316357e-02f, -6.80371523e-02f, -1.93584152e-02f, 6.75301030e-02f, 6.19428232e-02f, 1.06242552e-01f, -6.13058805e-02f, -2.14755759e-01f,
  -4.76827145e-01f, 2.42983207e-01f, 4.95089740e-02f, -1.88165307e-02f, 8.72040093e-02f, 8.91130939e-02f, 1.25404388e-01f, -3.08236592e-02f, -1.21260315e-01f, 5.39237969e-02f,
  1.15133680e-01f, -9.29141790e-02f, -2.00058162e-01f, -1.48777798e-01f, -2.35504597e-01f, -2.51477547e-02f, -1.60450742e-01f, -4.55952674e-01f, -4.23924625e-01f, -6.97463155e-02f,
  -1.53917875e-02f, -1.20716035e-01f, -2.51918107e-01f, -2.32356399e-01f, 1.24366060e-01f, -1.96251959e-01f, -9.33489427e-02f, 4.07883264e-02f, 9.40282568e-02f, -1.06858313e-01f,
  4.77904789e-02f, 1.85781717e-01f, -1.26686692e-01f, -7.52063543e-02f, 3.74550885e-03f, -7.92632345e-03f, -3.06157470e-02f, -1.39437288e-01f, 1.05352863e-03f, -1.26314759e-02f,
  -2.17226148e-02f, -9.05021802e-02f, -4.11392711e-02f, 9.81542617e-02f, -2.65725050e-02f, 1.10462680e-03f, -1.21476650e-01f, -7.47129619e-02f, -3.18181515e-02f, 9.96529162e-02f,
  1.68680340e-01f, 1.43975034e-01f, -4.56748940e-02f, -5.01113608e-02f, -6.12655953e-02f, -2.21914753e-01f, 7.90553838e-02f, -4.07819003e-02f, -1.52455688e-01f, -5.49590681e-03f,
  6.17783666e-02f, 7.92857166e-03f, 5.19594699e-02f, -4.46440354e-02f, 4.82296711e-03f, 3.19311721e-03f, -3.59392688e-02f, 4.48923372e-02f, 1.25745423e-02f, -4.84672971e-02f,
  4.32637371e-02f, 2.71084369e-04f, -5.97058572e-02f, 1.38270417e-02f, -5.06897867e-02f, 3.17895748e-02f, 1.67374592e-02f, -6.14840724e-02f, 2.10984573e-02f, -4.38630879e-02f,
  -4.86134700e-02f, 1.49428751e-02f, -4.00100052e-02f, -4.28620540e-03f, -1.10149466e-01f, -8.23611021e-03f, -2.93129608e-02f, -6.16669618e-02f, -7.57626519e-02f, -1.39519805e-02f,
  -1.86332911e-01f, -1.29601553e-01f, -1.91040382e-01f, -3.93531136e-02f, -2.23423392e-02f, -7.76180625e-02f, -5.66554405e-02f, -5.34625277e-02f, -1.24860801e-01f, -1.06097467e-01f,
  -6.42463416e-02f, -9.28337499e-02f, -3.98641266e-02f, -9.03497785e-02f, -1.55167967e-01f, -5.32330237e-02f, -8.40246603e-02f, -1.26813278e-01f, -2.20861752e-02f, -7.65668275e-03f,
  -6.83300421e-02f, -5.22111505e-02f, -1.49261236e-01f, -1.94963086e-02f, -3.84362321e-03f, -2.06317857e-01f, -8.96813273e-02f, -4.07554768e-02f, -1.90666765e-01f, -2.37629369e-01f,
  -4.82395142e-01f, 2.07463592e-01f, -1.65291101e-01f, -5.18836528e-02f, 1.15323424e-01f, -1.59288481e-01f, -1.38843015e-01f, -1.92400694e-01f, -8.05324223e-03f, 5.28205000e-02f,
  1.29831523e-01f, 7.23654032e-02f, -4.36892360e-02f, 5.09350151e-02f, -2.97459543e-01f, 7.22901672e-02f, 5.17770238e-02f, -2.94096917e-01f, -3.80554765e-01f, -2.28931665e-01f,
  3.73107456e-02f, -7.98548386e-02f, -2.16582209e-01f, -6.62887096e-02f, 1.91194877e-01f, -9.43213888e-03f, -2.66749617e-02f, -1.85064264e-02f, 1.33369537e-03f, 1.62604809e-01f,
  -1.03354760e-01f, -4.40798700e-02f, -1.03511766e-01f, 1.40233859e-02f, 7.06442073e-02f, -6.68314472e-02f, 2.08074902e-03f, -1.71335526e-02f, 4.12931442e-02f, -9.61880758e-02f,
  -4.48564664e-02f, 4.73847147e-03f, 1.84440473e-03f, -6.68681115e-02f, -1.10732615e-01f, -7.44336173e-02f, -3.99426408e-02f, -1.93301812e-01f, -1.00467307e-02f, 2.18266342e-02f,
  1.45081773e-01f, -1.61181673e-01f, -1.39843971e-01f, -1.43688157e-01f, -1.72300279e-01f, -1.12111486e-01f, -1.68746471e-01f, -1.56121626e-01f, -2.45558232e-01f, -2.42266178e-01f,
  1.95959769e-02f, 1.36745661e-01f, 8.54933932e-02f, 5.54411784e-02f, -1.85402427e-02f, -5.18795196e-03f, 4.01768461e-02f, 6.96334615e-02f, 3.05104051e-02f, 1.47757716e-02f,
  4.28957008e-02f, -3.52270789e-02f, 2.41333526e-02f, -2.86157485e-02f, 8.09280425e-02f, 8.10684636e-02f, 3.24376225e-02f, 3.19242291e-02f, 1.03326805e-01f, 3.88609469e-02f,
  7.35479146e-02f, 3.24697397e-03f, 6.71161935e-02f, -6.36822544e-03f, 4.96471822e-02f, 4.91001345e-02f, -3.25211845e-02f, 9.76329595e-02f, -7.65099451e-02f, -4.31982093e-02f,
  -1.10632278e-01f, -9.58345365e-03f, -5.16359545e-02f, -1.49994686e-01f, -3.30809504e-02f, -7.71571621e-02f, 5.42235374e-03f, -2.97698546e-02f, -4.86953259e-02f, 1.62276533e-02f,
  -9.03765485e-02f, -1.23236969e-01f, -1.23372078e-01f, -3.50326532e-03f, -1.70038179e-01f, -3.17169428e-02f, -1.40171088e-02f, -1.18702225e-01f, -9.69305113e-02f, -4.79991883e-02f,
  -9.41556171e-02f, -1.30287111e-01f, -1.73502445e-01f, -1.73323005e-01f, -7.44164661e-02f, -1.40620798e-01f, -1.84367612e-01f, -1.22954711e-01f, -3.08220625e-01f, -3.37443918e-01f,
  -2.08784357e-01f, 4.11067098e-01f, 1.69000953e-01f, 8.44769329e-02f, 4.10359129e-02f, 3.75418887e-02f, 3.24410349e-01f, 8.92953649e-02f, 2.85941083e-02f, 1.27732977e-01f,
  -6.81703957e-03f, -7.77434558e-02f, 6.10291085e-04f, -1.81630161e-02f, 1.78446770e-01f, 1.69642031e-01f, 2.33222127e-01f, -4.80393507e-02f, -1.55382961e-01f, -1.23208120e-01f,
  5.60676269e-02f, 8.88618603e-02f, -9.64592993e-02f, 6.95015937e-02f, 5.53429574e-02f, -1.05500363e-01f, 1.13701761e-01f, 9.67086777e-02f, 7.70611092e-02f, 1.68388084e-01f,
  -1.94935739e-01f, 1.25138164e-01f, 4.21382580e-03f, -1.70169249e-02f, 1.91997327e-02f, 1.92563366e-02f, 3.53450291e-02f, -4.45971005e-02f, 7.06016719e-02f, 7.27138221e-02f,
  1.36185676e-01f, -2.84607187e-02f, 8.37498382e-02f, 2.75631752e-02f, 3.06334384e-02f, 6.24857955e-02f, 1.01661079e-01f, 9.17521194e-02f, 1.77776784e-01f, 4.46092486e-02f,
  1.30909115e-01f, 1.66500062e-01f, 1.90469354e-01f, 2.09632635e-01f, 1.26460359e-01f, 2.64538135e-02f, 1.30505562e-01f, 1.25824779e-01f, 1.06830545e-01f, 7.01252297e-02f,
  3.68340649e-02f, -6.12647086e-02f, -1.49452314e-01f, -8.86804536e-02f, -9.14353281e-02f, -7.28565156e-02f, -3.61742713e-02f, -3.26567069e-02f, -6.65167943e-02f, -6.26349226e-02f,
  -1.94021955e-01f, -5.78720421e-02f, -4.63065803e-02f, -1.59123242e-02f, -1.73181351e-02f, -2.57001482e-02f, -6.88606873e-02f, -1.62125938e-02f, -6.11245409e-02f, -8.05005431e-02f,
  -5.50584868e-02f, -9.41074863e-02f, -1.28638327e-01f, -9.22369137e-02f, -6.98000416e-02f, -4.61713038e-02f, -1.52382806e-01f, -1.67404279e-01f, -1.03320852e-01f, 3.49008143e-02f,
  -1.34098947e-01f, 7.07196891e-02f, 3.16759571e-02f, 6.10473119e-02f, 8.62521753e-02f, 3.44940610e-02f, 5.23495153e-02f, 3.47859152e-02f, -2.79691839e-03f, 2.12853272e-02f,
  4.08145413e-03f, 8.14307183e-02f, 7.81512633e-02f, -4.81932163e-02f, -1.25153251e-02f, 4.67298664e-02f, 6.46538734e-02f, 5.11025339e-02f, -2.20603077e-03f, 7.03644529e-02f,
  1.01325400e-01f, 3.59812267e-02f, 4.69348133e-02f, 2.28328817e-02f, 3.19561325e-02f, -5.34651987e-02f, 7.14871064e-02f, -7.27599487e-02f, 4.86958176e-02f, 1.85554046e-02f,
  -3.76172215e-01f, 3.96952301e-01f, 2.86282659e-01f, -1.98318794e-01f, 2.73563206e-01f, 3.31209779e-01f, 3.80576670e-01f, 1.15526453e-01f, -1.43933550e-01f, 1.09602604e-02f,
  1.98924821e-02f, -1.18537173e-01f, -7.43038878e-02f, -1.97570905e-01f, -7.66301081e-02f, 1.90661490e-01f, 1.32669881e-01f, -8.05159062e-02f, -5.60118109e-02f, 4.35560569e-02f,
  5.74181043e-02f, -2.62030587e-02f, -2.38651097e-01f, -1.04173556e-01f, -2.21093614e-02f, -1.57929048e-01f, 3.57388109e-02f, 3.30693945e-02f, 1.21004365e-01f, -1.73011631e-01f,
  9.30362269e-02f, -9.69813094e-02f, -1.83154136e-01f, -1.77415356e-01f, 9.54649784e-03f, -1.21456131e-01f, 4.18406948e-02f, -3.67427059e-02f, -8.73759612e-02f, -8.25063586e-02f,
  3.25690396e-02f, -6.80526048e-02f, 6.18237397e-03f, 7.96671491e-03f, 8.01850110e-02f, -3.25885378e-02f, 2.65298113e-02f, -5.56076765e-02f, -5.21127284e-02f, 7.46600926e-02f,
  4.11068685e-02f, 8.74636844e-02f, 2.35692803e-02f, 1.12212732e-01f, -2.62484308e-02f, -9.56102386e-02f, -3.58346775e-02f, -1.28011376e-01f, -7.65591413e-02f, -5.84934615e-02f,
  -9.36236754e-02f, 4.00792360e-02f, -4.89120185e-02f, -4.86245146e-03f, 8.59865099e-02f, 3.34864818e-02f, 6.92049135e-03f, 7.61005655e-02f, 3.14689986e-02f, 7.47290347e-03f,
  3.98301072e-02f, 5.34751872e-03f, 6.93097562e-02f, 2.45587379e-02f, 5.78277856e-02f, 1.44957244e-01f, 7.29989931e-02f, 7.54311979e-02f, 3.57768089e-02f, 2.88400762e-02f,
  -7.54762590e-02f, 2.77981870e-02f, 1.20505966e-01f, 4.97480948e-03f, 5.32469228e-02f, 8.21956713e-03f, 7.70347491e-02f, 6.26934245e-02f, 7.92670101e-02f, 4.64604236e-02f,
  5.13991937e-02f, -1.24488749e-01f, -1.51144102e-01f, -8.04655403e-02f, -2.84822583e-02f, -2.11245031e-03f, -9.11520645e-02f, -8.57222304e-02f, 2.54954360e-02f, -3.98526713e-02f,
  -9.10393521e-02f, -1.06284693e-01f, 5.48965111e-03f, -4.57657017e-02f, -3.58299650e-02f, -4.97194715e-02f, 1.76801179e-02f, -9.21251029e-02f, 1.92184113e-02f, -2.93355249e-02f,
  1.05685197e-01f, 7.13724717e-02f, 4.62656766e-02f, 3.84655073e-02f, 1.32128317e-02f, 1.34478128e-02f, 1.04004189e-01f, -1.14917224e-02f, 7.51861138e-03f, 9.26944464e-02f,
  -1.90454096e-01f, 2.83089117e-03f, 2.16062739e-01f, -1.24378696e-01f, -1.34295048e-02f, 8.52720663e-02f, 1.21791236e-01f, -9.03342441e-02f, -1.10140510e-01f, 2.60433387e-02f,
  -1.26997232e-01f, -1.45824909e-01f, -1.02230698e-01f, -7.41745159e-02f, -2.14456511e-03f, 1.58811435e-01f, 9.97870341e-02f, 1.06969610e-01f, -6.58451766e-03f, -2.61467338e-01f,
  -2.01992705e-01f, -8.36746395e-02f, -5.67634590e-02f, -7.55429491e-02f, 1.97631516e-03f, 9.96673778e-02f, 1.61745831e-01f, 7.22585991e-02f, 9.17386562e-02f, 2.75787055e-01f,
  2.38997303e-02f, -1.37424305e-01f, -1.15913399e-01f, -2.40712296e-02f, -8.98949951e-02f, -7.47941658e-02f, 3.71537581e-02f, -1.51553348e-01f, -5.07607721e-02f, -1.35002211e-01f,
  -1.43195778e-01f, -7.10146651e-02f, -3.41807082e-02f, -1.57831162e-01f, -1.68181911e-01f, -2.21215516e-01f, -2.53141940e-01f, -9.22086611e-02f, -2.50983424e-02f, -1.26067981e-01f,
  -1.70198828e-01f, -6.92830160e-02f, -9.35355574e-02f, -8.26520994e-02f, -1.40144661e-01f, -5.34937903e-02f, -1.96707454e-02f, -1.09317854e-01f, 6.45724609e-02f, 7.94448033e-02f,
  1.43333137e-01f, 7.90938213e-02f, 9.57905874e-02f, -5.33888973e-02f, -4.90324907e-02f, 5.13594933e-02f, 1.08354315e-01f, 4.71664779e-02f, 7.56653622e-02f, 9.86837000e-02f,
  8.43670033e-03f, 3.91242318e-02f, 1.14139929e-01f, 7.48466924e-02f, 7.64119998e-02f, 8.07717443e-02f, 1.17818333e-01f, 6.97845146e-02f, 7.06612021e-02f, 5.23699895e-02f,
  8.66713934e-03f, 1.30334169e-01f, 8.93985406e-02f, 1.25111833e-01f, 5.72006665e-02f, 9.80807096e-02f, 2.84854919e-02f, 4.34225351e-02f, -5.15257604e-02f, -8.62766989e-03f,
  1.12029715e-02f, -9.66096073e-02f, -5.35756871e-02f, -7.77241886e-02f, -1.04511410e-01f, -1.40391633e-01f, -2.92463135e-02f, -1.04881324e-01f, -1.36377528e-01f, -5.78345694e-02f,
  -6.91213161e-02f, -1.79425284e-01f, -4.92291152e-02f, -3.59249525e-02f, -1.04546666e-01f, -7.14607984e-02f, -1.55478552e-01f, -4.09387164e-02f, -1.16675898e-01f, -9.05452818e-02f,
  -3.16218548e-02f, -7.42265359e-02f, -2.99860188e-03f, 4.60012555e-02f, 2.98373476e-02f, 7.81407654e-02f, 3.10685392e-02f, 1.13806710e-01f, 1.14117950e-01f, 1.33955672e-01f,
  -2.52267480e-01f, -2.16930613e-01f, 3.53923768e-01f, -2.42754027e-01f, -1.75726160e-01f, -5.58760129e-02f, -1.93725780e-01f, -1.78464621e-01f, -1.20349824e-01f, -1.38295621e-01f,
  -9.84588563e-02f, 1.72364891e-01f, 1.10087350e-01f, 2.99802989e-01f, 3.44765484e-01f, 6.78961053e-02f, 9.85231474e-02f, 3.09356481e-01f, 4.33804512e-01f, 3.47309738e-01f,
  9.90688652e-02f, -1.95212103e-02f, 2.26794288e-01f, 2.19035506e-01f, -1.54342446e-02f, -5.18545620e-02f, -1.81840658e-02f, 1.05549030e-01f, 1.86100572e-01f, 8.24291930e-02f,
  3.00704390e-01f, 1.20325580e-01f, 7.96271339e-02f, 5.10209799e-02f, -5.37881143e-02f, 1.20112486e-01f, 9.65025350e-02f, 1.14531159e-01f, 3.77932116e-02f, 1.10150218e-01f,
  -4.76794783e-03f, 1.21791773e-02f, 7.13969916e-02f, 4.08137552e-02f, 3.28074843e-02f, 3.50842625e-02f, 5.77448867e-02f, 1.44914970e-01f, 2.64055114e-02f, 1.92887217e-01f,
  -3.26524638e-02f, 1.51366562e-01f, 8.04254860e-02f, 9.89474654e-02f, 1.97657287e-01f, 9.40744355e-02f, 1.53367162e-01f, 1.75383642e-01f, 1.82960153e-01f, 2.42006518e-02f,
  -1.56294294e-02f, -2.17510939e-01f, -6.87436312e-02f, -1.08036846e-01f, -1.11041911e-01f, -1.88408196e-01f, -4.27625030e-02f, -1.47861496e-01f, -6.84122965e-02f, -8.28673597e-03f,
  -7.69972205e-02f, -4.50515375e-02f, -1.09788373e-01f, -1.29529908e-01f, -8.95679295e-02f, -1.19310223e-01f, -1.26069993e-01f, -1.35241956e-01f, -4.41862419e-02f, -1.42511114e-01f,
  -8.50599259e-02f, -9.39759985e-02f, -6.78142458e-02f, -3.05607505e-02f, -9.37902853e-02f, -1.54508799e-01f, -1.20686494e-01f, -8.64359662e-02f, -1.31311744e-01f, -1.14920869e-01f,
  -1.06938528e-02f, -9.13503617e-02f, 4.31784466e-02f, 7.26220086e-02f, 4.39066812e-02f, 1.49035165e-02f, 5.98426946e-02f, -5.06933965e-02f, 7.41857365e-02f, 1.31851465e-01f,
  7.94034600e-02f, 1.44266158e-01f, 3.96371223e-02f, 5.64448126e-02f, 1.31059811e-01f, 1.14886053e-01f, -7.54695535e-02f, 1.36080058e-02f, 7.33932406e-02f, -2.62391455e-02f,
  -1.19623818e-01f, 5.47314575e-03f, -1.70528446e-03f, -2.12303530e-02f, 1.16128232e-02f, -4.17275280e-02f, 5.17022647e-02f, 1.10776141e-01f, -4.21882793e-02f, -1.36078864e-01f,
  -2.00486276e-02f, -2.32584223e-01f, -1.03575766e-01f, -6.41459748e-02f, -3.33736777e-01f, -4.04778063e-01f, -3.35318357e-01f, -2.65911609e-01f, -1.08222283e-01f, -2.12270081e-01f,
  1.39573608e-02f, 3.04347992e-01f, 3.06542218e-01f, 2.85457194e-01f, 1.63565144e-01f, -3.52555513e-02f, 9.53102484e-02f, 2.61277080e-01f, 9.29638967e-02f, -2.05983028e-01f,
  -1.01612940e-01f, -4.25415896e-02f, 1.07114345e-01f, 4.66248915e-02f, -1.43644512e-01f, -1.64012332e-02f, -7.12501705e-02f, -2.48995468e-01f, -1.53096512e-01f, 7.84968808e-02f,
  1.28093148e-02f, -3.40963989e-01f, 1.25936896e-01f, -7.21805245e-02f, -1.62863791e-01f, 1.11696655e-02f, -3.19257937e-02f, 1.41282883e-02f, -1.41691476e-01f, -3.39775197e-02f,
  -1.04076982e-01f, -1.00981146e-01f, -8.44943821e-02f, -1.13072947e-01f, -1.76528826e-01f, -2.90762493e-03f, -1.06649451e-01f, 4.07653749e-02f, -1.17417231e-01f, -7.34270141e-02f,
  -1.30513355e-01f, -1.59205943e-01f, -2.43369997e-01f, -1.67239949e-01f, 1.86982029e-03f, 2.95962803e-02f, -1.85799330e-01f, -1.85499460e-01f, -1.51691318e-01f, -1.88838113e-02f,
  5.76848537e-02f, 7.80702606e-02f, -3.36059518e-02f, -9.02417768e-03f, 8.12701732e-02f, -2.55012065e-02f, 1.15419045e-01f, 6.82888106e-02f, 4.12806123e-02f, 8.61551464e-02f,
  9.88917276e-02f, 4.25491109e-02f, -4.77578398e-03f, 1.02421455e-01f, 1.86150014e-01f, 7.49692274e-03f, 9.73817632e-02f, 1.63259178e-01f, 1.10200252e-02f, 1.80996303e-02f,
  4.87625375e-02f, 9.53949168e-02f, 1.82322487e-02f, 1.21220693e-01f, -7.16102729e-03f, 1.68270260e-01f, 5.86269833e-02f, 3.07614878e-02f, 1.88639958e-03f, 6.14857562e-02f,
  -5.77313406e-03f, -1.83922593e-02f, 7.50407996e-03f, 7.75806531e-02f, -1.31286517e-01f, -9.45369154e-02f, -1.16607390e-01f, -7.52873570e-02f, -5.93400113e-02f, -8.52669477e-02f,
  -1.28992021e-01f, -6.80739954e-02f, -1.46542877e-01f, -3.58977541e-02f, -9.79421139e-02f, -7.33450353e-02f, -4.13079001e-02f, 3.13523076e-02f, -8.20597261e-03f, -1.18598782e-01f,
  -1.16138846e-01f, -9.48834792e-02f, 1.27057042e-02f, -6.16416521e-02f, -1.13320492e-01f, 7.14314654e-02f, -8.73813555e-02f, -1.62856698e-01f, 3.05707869e-03f, -1.30120665e-01f,
  -7.99448714e-02f, -7.37089217e-02f, -1.62241310e-01f, -5.61673082e-02f, -1.03094831e-01f, -1.36752456e-01f, -2.91290134e-01f, -8.24612454e-02f, 6.60216808e-02f, -1.75968960e-01f,
  5.73046245e-02f, 1.60450578e-01f, 5.15274256e-02f, 9.78049040e-02f, -4.95329872e-02f, -1.54728413e-01f, -1.39664769e-01f, -1.03843749e-01f, -8.53300989e-02f, -2.73593646e-02f,
  3.96986119e-02f, 6.44919872e-02f, -1.04979590e-01f, -1.03145927e-01f, -1.40778735e-01f, -4.21822779e-02f, -1.98088497e-01f, -8.02901611e-02f, -2.49558285e-01f, -2.63486415e-01f,
  6.67072237e-02f, -3.82861532e-02f, -8.13841373e-02f, 5.52193820e-02f, -3.17153782e-02f, -5.50045893e-02f, 3.87484729e-02f, 4.38722931e-02f, 5.84070906e-02f, -5.23196608e-02f,
  -4.45548631e-02f, 2.42870376e-02f, -5.35371341e-02f, -3.43452916e-02f, 4.18915302e-02f, -2.39196680e-02f, 1.00475773e-02f, 1.52986133e-02f, 6.53342977e-02f, -1.85135845e-02f,
  -2.33506598e-02f, -1.70782983e-01f, -6.33956045e-02f, -1.44532412e-01f, -6.34829849e-02f, -1.10257782e-01f, -4.53783050e-02f, -1.74020022e-01f, -1.29513040e-01f, -2.27727219e-01f,
  -2.12870408e-02f, 3.85807455e-02f, -7.58208558e-02f, -5.34198768e-02f, -4.77246642e-02f, 4.45823856e-02f, -8.70447084e-02f, -6.25348985e-02f, -6.01239242e-02f, -1.03210174e-02f,
  -4.80781533e-02f, -6.67656139e-02f, -3.29334773e-02f, -5.93128242e-02f, -1.08250715e-01f, -4.05954011e-02f, -9.02530104e-02f, -1.59412593e-01f, -1.00669034e-01f, -1.83057681e-01f,
  -9.21261981e-02f, -6.48422539e-02f, -7.42767304e-02f, -1.10051595e-01f, -9.09461230e-02f, -2.04611253e-02f, -4.77425866e-02f, -8.52067664e-04f, -8.10656026e-02f, -4.29075696e-02f,
  3.21727425e-01f, -4.42136377e-02f, -1.12524152e-01f, -7.10520595e-02f, -1.05018020e-02f, 5.56091294e-02f, 5.88702783e-02f, -7.47539103e-02f, 5.43136243e-03f, 4.46227901e-02f,
  3.71853523e-02f, 7.94109330e-02f, -8.29102471e-03f, -7.64476089e-03f, -5.92122637e-02f, -3.39772180e-02f, -1.26829505e-01f, -8.89161676e-02f, -2.23716088e-02f, -1.51530430e-02f,
  -2.98940800e-02f, -6.15113564e-02f, -1.55010959e-02f, 5.53481688e-04f, -6.88459724e-02f, -1.77393071e-02f, 1.56506244e-02f, 1.76586416e-02f, -7.31650088e-03f, -1.52605340e-01f,
  4.39194798e-01f, 2.60140263e-02f, -1.45602256e-01f, 1.97159812e-01f, -1.48069695e-01f, -1.23916380e-02f, 3.32261547e-02f, 7.59338364e-02f, 5.13070710e-02f, 5.22137806e-02f,
  -1.78069115e-01f, -2.02170938e-01f, -1.95210800e-01f, -2.78559297e-01f, -9.15110335e-02f, -6.16313145e-02f, -1.38325483e-01f, -3.22878212e-02f, -1.26703873e-01f, -6.18600547e-02f,
  2.11506411e-02f, 1.47557706e-01f, 1.62609115e-01f, -9.30626597e-03f, 2.18353439e-02f, -7.52535611e-02f, -6.20988272e-02f, -1.54042980e-02f, -1.38228461e-01f, -3.63633484e-02f,
  -1.25973418e-01f, 1.67095616e-01f, -1.91900674e-02f, -9.16154906e-02f, -7.81085119e-02f, -4.94307615e-02f, 7.68638402e-03f, -3.15008834e-02f, -1.20063230e-01f, 3.04534100e-03f,
  -1.05408423e-01f, -8.11322331e-02f, -2.75092013e-02f, -3.66568863e-02f, 4.08512726e-02f, 6.36775866e-02f, 3.62505279e-02f, -2.34608985e-02f, -3.92913558e-02f, -2.17527859e-02f,
  -1.25394478e-01f, -4.72518057e-02f, -1.02844298e-01f, -1.16050445e-01f, -1.46720052e-01f, -8.69650319e-02f, 4.56583910e-02f, 1.87803637e-02f, 5.50681315e-02f, 2.01945573e-01f,
  -5.49323820e-02f, -1.14672005e-01f, 1.89303439e-02f, 6.84105232e-02f, -8.46341327e-02f, 8.58237222e-03f, 1.30338194e-02f, -2.08362155e-02f, -3.61240283e-02f, 3.20282243e-02f,
  -1.16804382e-02f, -7.73981214e-02f, 3.63642769e-03f, -5.16053895e-03f, -7.75085762e-03f, -1.37131428e-02f, 3.40517517e-03f, 1.02443248e-02f, -1.27965100e-02f, 2.56407652e-02f,
  -8.94952714e-02f, -3.02312598e-02f, 2.90550720e-02f, -5.23115806e-02f, 5.05999550e-02f, -4.79389131e-02f, 5.60884550e-03f, -2.73945611e-02f, 7.73279518e-02f, -2.41823643e-02f,
  1.68394551e-01f, -1.11831672e-01f, 8.36084783e-03f, -5.01479059e-02f, 6.63923696e-02f, -5.16108125e-02f, -2.71902308e-02f, -3.06891724e-02f, -8.53527114e-02f, -8.56920611e-04f,
  -4.46342155e-02f, 9.75846797e-02f, -3.34422514e-02f, -3.59954685e-02f, -8.38856846e-02f, 3.50582190e-02f, 7.61123896e-02f, -8.45687687e-02f, -1.29878029e-01f, -6.54516667e-02f,
  1.22133214e-02f, 2.32507419e-02f, 5.19584417e-02f, 5.24848439e-02f, -6.53851703e-02f, -1.63728949e-02f, 1.83885824e-02f, 3.21614258e-02f, 7.07996711e-02f, 2.25331768e-01f,
  -1.24523334e-01f, 1.51912272e-01f, -8.54077116e-02f, -1.99117869e-01f, 1.45531163e-01f, 2.67002851e-01f, 2.73519456e-01f, 7.43755251e-02f, 1.72963999e-02f, -9.53347236e-02f,
  -1.36857882e-01f, -3.14174324e-01f, -3.54846418e-01f, -2.14989692e-01f, -1.38809711e-01f, -1.64261665e-02f, -6.69121370e-02f, -1.81726754e-01f, -1.05106473e-01f, -5.52185550e-02f,
  1.66556276e-02f, -1.48947775e-01f, -1.76253363e-01f, -7.59638622e-02f, -1.23078406e-01f, -2.44303674e-01f, -5.41266203e-02f, -1.48479894e-01f, -1.67395741e-01f, -3.88742566e-01f,
  -3.99313241e-01f, -3.26550901e-02f, -1.92944571e-01f, -1.73624635e-01f, -4.79334183e-02f, -1.61139444e-01f, -1.57719523e-01f, -1.60609290e-01f, -1.01624732e-03f, -3.27726007e-02f,
  -2.24885553e-01f, -1.34426191e-01f, -1.70607015e-01f, -4.08164831e-03f, 1.39218764e-02f, -1.27516434e-01f, 8.80778115e-03f, -7.24646077e-02f, -1.54327989e-01f, -9.37676802e-02f,
  -5.46947680e-02f, -5.75858308e-03f, -7.15351105e-02f, 2.90176440e-02f, -1.15761831e-01f, -1.11989208e-01f, 2.41081137e-02f, -1.18247062e-01f, -1.46942645e-01f, -4.95081805e-02f,
  -1.06972540e-02f, 3.41183948e-03f, 3.53023596e-02f, 3.70310210e-02f, 7.46316910e-02f, 8.72587226e-03f, 1.15559980e-01f, 1.28397821e-02f, 2.22045258e-02f, 6.45416752e-02f,
  6.04410842e-02f, 1.48821687e-02f, 1.74224265e-02f, 7.49019682e-02f, -2.03904603e-02f, 2.65564378e-02f, -2.10222718e-03f, 9.45329666e-03f, 9.77166221e-02f, 7.52763227e-02f,
  7.06211999e-02f, -2.05865428e-02f, 3.91246416e-02f, 2.96046697e-02f, 1.17666818e-01f, 3.46408486e-02f, 8.84107649e-02f, 8.73777792e-02f, -2.62358338e-02f, 9.30575207e-02f,
  -7.91558027e-02f, -7.17230514e-03f, -2.45222151e-01f, -1.49651378e-01f, -1.37692410e-02f, -8.25313032e-02f, -9.26921740e-02f, -1.45971403e-01f, -1.41123310e-01f, -3.68358456e-02f,
  -1.45931423e-01f, -1.40619531e-01f, -1.23234905e-01f, -1.11547917e-01f, -1.30176306e-01f, 2.40207277e-02f, -1.15472160e-01f, -2.00140089e-01f, -1.10680811e-01f, -5.83557822e-02f,
  -3.72248441e-02f, 2.85750767e-03f, -1.20580927e-01f, -8.96130130e-02f, -2.18693390e-02f, -1.22683808e-01f, -1.14171624e-01f, -3.27008665e-02f, -9.28750187e-02f, 9.15309116e-02f
};

// L0_fan_Wp_bar (Shape: 40 x 120)
const int L0_fan_Wp_bar_rows = 40;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -4.22476530e-01f, -6.17027402e-01f, -2.14180127e-01f, -6.73743546e-01f, -5.16810358e-01f, -2.39604145e-01f, -5.28716087e-01f, -2.69094616e-01f, -2.83142865e-01f, -6.28435016e-01f,
  -3.39017957e-01f, 7.19068274e-02f, -7.71359280e-02f, 1.16777666e-01f, 3.08512151e-01f, -4.12518114e-01f, -2.70376951e-01f, 3.29819828e-01f, 5.97832084e-01f, 5.09863719e-02f,
  -3.53380620e-01f, -2.59891003e-01f, 2.17521444e-01f, 1.24054089e-01f, -6.98717833e-01f, -1.49082199e-01f, -4.51745450e-01f, -2.75307357e-01f, -6.41615689e-02f, -6.56988621e-01f,
  -3.66867870e-01f, -1.81786805e-01f, 1.82444364e-01f, 1.79216862e-01f, -2.58133590e-01f, 9.74339992e-02f, -9.95724648e-02f, 1.82253476e-02f, 6.41147867e-02f, -8.53821337e-02f,
  -5.19303195e-02f, 4.04331610e-02f, 5.43727577e-02f, 9.22383070e-02f, -1.81779191e-01f, 2.14106031e-02f, -5.77010587e-03f, 1.31149113e-01f, 9.27724913e-02f, -1.41061097e-01f,
  -2.32612297e-01f, -8.86815339e-02f, 1.85261965e-01f, 4.66340408e-02f, 2.18886122e-01f, 1.56232625e-01f, -6.62143454e-02f, 1.11228429e-01f, 2.45535359e-01f, -6.22211397e-01f,
  -6.59208074e-02f, -1.82792366e-01f, -5.69049455e-02f, -6.42412752e-02f, 6.61092922e-02f, -2.27816291e-02f, -8.94237012e-02f, -3.57865095e-02f, 7.31661245e-02f, -2.49680690e-02f,
  3.77328210e-02f, 4.54886518e-02f, 5.49227968e-02f, -1.01816155e-01f, -1.58766121e-01f, -1.19863398e-01f, 1.30582089e-02f, 2.29561161e-02f, -4.46312726e-02f, 6.97701201e-02f,
  7.73783959e-03f, -4.44409586e-02f, -5.16652651e-02f, 5.64735085e-02f, 7.72001594e-02f, 3.92261222e-02f, 8.57188832e-03f, 4.23716521e-03f, -1.56579584e-01f, 5.01610711e-02f,
  -3.61171216e-01f, 3.82313192e-01f, -3.70848656e-01f, 3.22304592e-02f, -1.40799880e-01f, -2.10411083e-02f, -1.20964967e-01f, 1.53666005e-01f, 2.80870814e-02f, -2.16170341e-01f,
  1.19938226e-02f, -9.16150808e-02f, -1.78984225e-01f, -4.74372506e-03f, -3.21197473e-02f, 1.25452187e-02f, 3.93524989e-02f, -2.28091106e-01f, 8.33568051e-02f, -1.19751200e-01f,
  -5.48401140e-02f, 6.66054860e-02f, -1.28962800e-01f, -1.15443558e-01f, -2.02441253e-02f, 4.41945307e-02f, -2.74693429e-01f, -1.28251329e-01f, 2.23048255e-01f, -5.99140108e-01f,
  5.32644987e-01f, -4.25755143e-01f, 2.78617799e-01f, 3.96805555e-01f, 3.91285717e-01f, 2.90472209e-01f, -1.53856397e-01f, -1.29094839e-01f, 1.21204384e-01f, -5.89625072e-03f,
  1.86344367e-02f, 1.07687883e-01f, 2.10980311e-01f, 1.95250418e-02f, 6.30108193e-02f, -1.50467068e-01f, 2.65838597e-02f, 2.89680392e-01f, 3.41869146e-01f, 1.02557495e-01f,
  -1.02808820e-02f, 7.68419057e-02f, -1.88754476e-03f, 6.02801032e-02f, -1.59204996e-04f, 1.73775852e-01f, 3.38169597e-02f, -9.37430467e-03f, -3.59131433e-02f, -1.46166995e-01f,
  -2.18474239e-01f, -6.20416552e-03f, 1.14883840e-01f, 5.57133965e-02f, 3.60638723e-02f, -7.09381998e-02f, 6.12800084e-02f, -1.20913796e-01f, -1.39900669e-01f, -1.90330148e-01f,
  5.73880132e-03f, -4.95895818e-02f, 1.52003551e-02f, -8.30792040e-02f, -3.53258736e-02f, 7.35951141e-02f, -5.86586744e-02f, -7.93834701e-02f, -9.90260467e-02f, 9.32664517e-03f,
  2.61087250e-02f, 1.63501099e-01f, 7.15488866e-02f, 1.08166531e-01f, 1.55047402e-01f, 2.61918694e-01f, 9.50929299e-02f, -5.37497457e-03f, 3.62735018e-02f, -1.50638651e-02f,
  1.89828515e-01f, 1.74440652e-01f, 2.76491255e-01f, 7.50057027e-02f, 4.79341857e-02f, 1.36733145e-01f, -6.86648712e-02f, 1.55534372e-02f, 2.09213793e-01f, 3.51196676e-02f,
  -4.96170558e-02f, 1.62493326e-02f, -6.66894577e-03f, 5.87495752e-02f, 3.54233295e-01f, 2.63271123e-01f, 2.69863177e-02f, 2.50616204e-02f, 2.34825686e-01f, 2.86582019e-02f,
  1.30012617e-01f, -9.36688036e-02f, -5.50996438e-02f, -2.05993667e-01f, -2.20269393e-02f, 2.05107719e-01f, 1.69108331e-01f, 5.91875874e-02f, 3.07047553e-02f, 1.69920661e-02f,
  -4.39509422e-01f, 3.22724462e-01f, 1.26074925e-01f, -1.09593637e-01f, -7.79629499e-02f, 2.12648418e-02f, 1.62831262e-01f, -2.13827506e-01f, -2.90816545e-01f, -1.31611273e-01f,
  -1.19032256e-01f, 1.54935224e-02f, 3.59224118e-02f, -6.69924766e-02f, -2.13135649e-02f, 8.92051607e-02f, -8.50088000e-02f, -4.05159481e-02f, -1.25615433e-01f, -1.77371427e-01f,
  -7.83089101e-02f, 1.10945590e-01f, 7.76722133e-02f, 5.37677892e-02f, 1.22280814e-01f, 2.39240855e-01f, 1.59922138e-01f, -3.87713127e-03f, 1.46119922e-01f, 8.21682587e-02f,
  2.93959260e-01f, 4.76604968e-01f, 3.06655347e-01f, 2.58623362e-01f, 2.03114018e-01f, 4.06911850e-01f, 4.21137452e-01f, 1.66708097e-01f, 1.14183510e-02f, 4.41627530e-03f,
  9.68479812e-02f, 7.18091195e-03f, 9.61900949e-02f, 6.72851950e-02f, 1.73272192e-01f, 9.80375037e-02f, 8.94749239e-02f, 1.24341272e-01f, -2.52469778e-02f, -6.06139889e-03f,
  1.46766290e-01f, 1.44086435e-01f, 3.92094739e-02f, 3.88511689e-03f, 4.05536294e-02f, -3.12430728e-02f, 9.78633389e-02f, 2.27441877e-01f, 1.92535952e-01f, -9.00521427e-02f,
  -4.12633091e-01f, 2.14765862e-01f, -2.83128500e-01f, -2.09634006e-01f, -1.25170246e-01f, -1.83290496e-01f, -1.43483162e-01f, -1.41038254e-01f, 1.62875485e-02f, -1.60242841e-01f,
  -1.61790058e-01f, -1.41667515e-01f, 3.73536386e-02f, -4.61522564e-02f, -8.11174288e-02f, -8.32581893e-02f, -5.38996086e-02f, 2.84014759e-03f, -4.82512973e-02f, -7.65587911e-02f,
  -9.07092914e-02f, 8.31289589e-03f, 8.00940916e-02f, 5.74493036e-02f, 7.41225556e-02f, -1.56254873e-01f, 2.45597027e-02f, -3.28595936e-02f, -4.14998853e-04f, -5.69831841e-02f,
  -2.92478532e-01f, 5.19736558e-02f, -2.29987856e-02f, -6.09674789e-02f, 5.38279340e-02f, -1.75471067e-01f, -4.43876274e-02f, 4.26915549e-02f, -3.40624526e-02f, -1.99338775e-02f,
  -1.85530901e-01f, -1.06607474e-01f, -1.52754515e-01f, -1.97546892e-02f, -1.69526324e-01f, 4.67820540e-02f, 1.08915493e-01f, 2.27107108e-02f, -2.27417871e-02f, -1.12136766e-01f,
  -1.61326793e-03f, -1.31774619e-01f, -7.16391578e-02f, -1.04994506e-01f, -8.72678682e-02f, -3.34896632e-02f, -1.60218045e-01f, -1.79438648e-05f, -7.86734074e-02f, -1.23483269e-02f,
  -1.96209192e-01f, 3.45307663e-02f, -2.65132993e-01f, -8.12654048e-02f, -3.93232666e-02f, -1.05920121e-01f, -8.30394253e-02f, -1.73763275e-01f, -2.08199546e-02f, -1.68980077e-01f,
  6.12507761e-03f, -8.20086598e-02f, -5.68460524e-02f, -2.29457635e-02f, -2.32583806e-01f, -9.84141529e-02f, -1.60008892e-01f, -6.24248236e-02f, -1.36627153e-01f, -1.70482978e-01f,
  9.02865361e-03f, -1.62997007e-01f, -7.11490810e-02f, -5.83103634e-02f, -6.18298613e-02f, -2.00677678e-01f, -1.47877425e-01f, -2.43614182e-01f, -1.60776094e-01f, -3.74358147e-02f,
  7.54708827e-01f, 4.69697982e-01f, 2.53066868e-01f, 2.73438305e-01f, 1.78977147e-01f, -1.46958791e-02f, 9.31486338e-02f, 1.04800671e-01f, 7.82178640e-02f, 2.08543852e-01f,
  1.96858108e-01f, 1.26905426e-01f, 5.29022887e-02f, 1.69998705e-01f, 7.30096102e-02f, 1.32418454e-01f, 1.21555470e-01f, 6.34630024e-02f, 4.27531302e-02f, 2.70415276e-01f,
  3.34301025e-01f, 1.75271079e-01f, 7.82761872e-02f, 9.93300602e-02f, 2.17324212e-01f, 1.52225524e-01f, 9.07520130e-02f, 2.71770269e-01f, 2.31264189e-01f, 4.44522291e-01f,
  3.26927483e-01f, 3.10373485e-01f, -1.61161810e-01f, -4.69637774e-02f, 4.61334810e-02f, -4.46662270e-02f, 1.98505446e-02f, -1.88664645e-01f, 2.04656851e-02f, -3.58404927e-02f,
  -4.37525548e-02f, -2.10231151e-02f, -4.65873405e-02f, -1.10507838e-01f, -9.73916054e-03f, -6.51613902e-03f, -7.53348842e-02f, -3.39574255e-02f, -3.19167338e-02f, 9.11025852e-02f,
  1.32811472e-01f, 5.05827777e-02f, -3.20725515e-02f, -1.43097803e-01f, 4.77662943e-02f, -4.90003526e-02f, -8.42474252e-02f, 7.12189451e-02f, -1.14486031e-01f, -5.17303832e-02f,
  1.03982583e-01f, 2.87083715e-01f, 2.90367544e-01f, 1.72769308e-01f, 3.19235504e-01f, 7.52616599e-02f, 5.95338866e-02f, 4.52537015e-02f, -4.96063009e-02f, 3.87665555e-02f,
  1.79284979e-02f, 2.11821999e-02f, -3.59188393e-02f, 1.66793510e-01f, 8.10042545e-02f, 1.60606056e-01f, 1.52472958e-01f, -2.44928151e-02f, 1.09085976e-03f, -5.82058132e-02f,
  6.65115565e-02f, -2.16487963e-02f, -1.09957851e-01f, -1.03115067e-01f, -1.65548287e-02f, 9.99452323e-02f, 9.54418108e-02f, 3.65697630e-02f, -1.22010261e-02f, 5.71475960e-02f,
  -5.22213995e-01f, -3.20600659e-01f, 1.05386049e-01f, -3.47600728e-02f, -1.03909252e-02f, -8.36021453e-02f, 9.66040045e-02f, -7.09189922e-02f, -5.25536574e-02f, -2.85020694e-02f,
  -3.90482470e-02f, -1.12409787e-02f, -8.60556513e-02f, -1.41181991e-01f, -1.06156327e-01f, -1.93714350e-01f, 8.33604038e-02f, -8.40803534e-02f, -1.54861122e-01f, -1.40455402e-02f,
  -1.18069440e-01f, -2.72926003e-01f, -1.55264407e-01f, -2.32569560e-01f, -9.20837000e-02f, -1.92232132e-01f, -2.14412645e-01f, -2.23533213e-01f, -1.40730411e-01f, -1.59230724e-01f,
  -5.62013984e-01f, -2.19742477e-01f, -2.41655916e-01f, -2.96617448e-01f, 3.12577844e-01f, 3.93377483e-01f, 5.84701180e-01f, 2.92923152e-01f, -9.42497626e-02f, -1.31600216e-01f,
  -3.72914255e-01f, -3.36525351e-01f, -5.16924322e-01f, -1.28575414e-01f, 1.38229460e-01f, 2.66710460e-01f, 1.38871625e-01f, 6.61225617e-02f, 4.14701462e-01f, 5.37271738e-01f,
  3.76475215e-01f, 9.43928510e-02f, -2.07738340e-01f, -4.73649465e-02f, -1.21731542e-01f, -3.96910589e-03f, -2.29742438e-01f, -1.32621557e-01f, 4.84405737e-03f, -2.79506087e-01f,
  -2.27012098e-01f, -4.92904395e-01f, 2.04233199e-01f, -1.04148075e-01f, -7.76995122e-02f, -9.16091725e-02f, 1.41415328e-01f, -8.19630921e-02f, -7.18170926e-02f, -6.93015475e-03f,
  1.32333990e-02f, -4.09018295e-03f, -7.67178163e-02f, 8.43549073e-02f, 5.71763702e-02f, -5.94157353e-02f, -3.42803337e-02f, -1.01123840e-01f, -2.36229151e-01f, -6.38970137e-02f,
  -6.51496351e-02f, -1.68480039e-01f, -1.51386961e-01f, 4.52073887e-02f, -8.77110139e-02f, -5.14028920e-03f, 1.09472517e-02f, 8.53415504e-02f, -1.04634263e-01f, -9.58679318e-02f,
  -6.91665784e-02f, 3.06511875e-02f, 6.35429621e-02f, 1.35643601e-01f, 1.39816225e-01f, 4.41945419e-02f, 3.98104899e-02f, 9.10870545e-03f, 7.13788494e-02f, 1.37679160e-01f,
  -6.04418628e-02f, -8.78954157e-02f, -2.84166764e-02f, -1.43361092e-01f, -1.33936092e-01f, -1.13505967e-01f, -5.30904438e-03f, -7.79505223e-02f, -9.02801454e-02f, -1.08003458e-02f,
  -1.05818873e-02f, 1.06580824e-01f, -1.65810138e-01f, 9.35239438e-03f, -2.33831014e-02f, 3.83999683e-02f, -1.13324411e-01f, 1.62866283e-02f, 8.08541011e-03f, -6.99071437e-02f,
  1.29476011e-01f, -9.31430459e-02f, -2.09225282e-01f, 4.67267819e-03f, -5.36474250e-02f, -1.62070736e-01f, -1.73600256e-01f, -1.24902725e-01f, -1.93539485e-01f, -3.79020609e-02f,
  4.40382808e-02f, 6.12289608e-02f, -2.73324270e-03f, 1.29647031e-01f, 1.98854819e-01f, 1.44981341e-02f, -2.49377023e-02f, 2.34345924e-02f, -1.04002915e-01f, 1.14874996e-01f,
  1.19522333e-01f, 5.93824685e-02f, 1.36896506e-01f, -4.66224924e-02f, -6.65740445e-02f, 1.91081673e-01f, 1.27369598e-01f, 1.79914609e-01f, 1.10642269e-01f, 3.58977139e-01f,
  -1.07634008e-01f, 1.08929165e-01f, 4.24166799e-01f, 1.26806021e-01f, 1.54551029e-01f, -3.24735969e-01f, -6.37230814e-01f, -3.57598871e-01f, 1.17317125e-01f, 1.08011708e-01f,
  -3.06795426e-02f, 4.22388203e-02f, 1.86022729e-01f, 2.17559375e-02f, -2.46250510e-01f, 1.41671896e-01f, 3.47727120e-01f, 3.76510397e-02f, -4.14853752e-01f, -4.31145161e-01f,
  -1.45779654e-01f, -3.24937776e-02f, -4.49173264e-02f, 5.59959980e-03f, 4.30873543e-01f, 1.36579424e-01f, 3.96299005e-01f, 2.84528762e-01f, 1.06580399e-01f, 7.11920857e-01f,
  2.10318446e-01f, 1.45283565e-01f, -2.86089838e-01f, 1.52041176e-02f, 2.34902218e-01f, 4.66054194e-02f, -5.75385354e-02f, 1.79547161e-01f, 1.89897474e-02f, 8.64562765e-02f,
  2.24778980e-01f, 8.17438886e-02f, -4.25123274e-02f, 1.03742585e-01f, -7.06374273e-02f, -2.66198546e-01f, 7.64752254e-02f, -1.24319762e-01f, -3.16736586e-02f, -2.46287845e-02f,
  -1.12045817e-02f, -1.95515230e-01f, -1.75371170e-01f, -1.46794990e-01f, -1.20343365e-01f, 3.50973234e-02f, -1.36315212e-01f, -1.39785782e-02f, -3.30172665e-02f, 2.15281397e-01f,
  -5.05401939e-02f, 1.02621324e-01f, 7.68412873e-02f, 1.43401563e-01f, 1.43467039e-02f, 2.88076159e-02f, 2.29233712e-01f, -3.13927680e-02f, 9.99435633e-02f, 9.70470309e-02f,
  1.01605179e-02f, 1.16220480e-02f, -4.76822555e-02f, -5.30774817e-02f, 7.27590621e-02f, 5.83747588e-02f, 9.85554457e-02f, -1.03554264e-01f, 2.03911290e-02f, 1.29428685e-01f,
  1.37928957e-02f, 1.13742240e-01f, 2.63272911e-01f, -7.58165941e-02f, 2.87245270e-02f, 1.27436265e-01f, 1.80902272e-01f, -7.54644023e-03f, -9.52846371e-04f, 1.04559600e-01f,
  -2.30407685e-01f, -2.93800801e-01f, 1.87021896e-01f, 1.83014460e-02f, 1.10750072e-01f, 9.48206261e-02f, 8.44360143e-02f, -8.42206255e-02f, 4.93736900e-02f, -8.37417394e-02f,
  -1.88528687e-01f, 4.27051767e-04f, 8.43572170e-02f, 1.32305101e-02f, -1.90224737e-01f, 4.72711697e-02f, 6.09421991e-02f, -3.98328714e-02f, -2.33719662e-01f, -3.07564680e-02f,
  -1.30969950e-03f, -4.67775166e-01f, -5.75327337e-01f, -2.83702791e-01f, -8.82544592e-02f, -3.56344253e-01f, -1.30236998e-01f, -2.09232137e-01f, -3.53839368e-01f, -4.50869948e-01f,
  -1.52750537e-01f, -5.16498625e-01f, 3.74961615e-01f, -7.21905306e-02f, -7.90618286e-02f, -1.08269446e-01f, -4.28442322e-02f, -2.47335047e-01f, -3.24454248e-01f, 2.73425449e-02f,
  -4.16689247e-01f, -5.32626510e-01f, -4.21044230e-01f, -4.50026870e-01f, -3.79383028e-01f, 2.05114037e-01f, 1.49373606e-01f, 1.56555235e-01f, 1.50634825e-01f, -2.57088952e-02f,
  -7.76159838e-02f, 1.32414535e-01f, -3.04307248e-02f, -8.27526972e-02f, 2.41861828e-02f, -1.52705640e-01f, 6.48627337e-03f, -3.65875401e-02f, -1.41286582e-01f, 1.65689155e-01f,
  3.61179709e-01f, -4.71841991e-01f, 1.44869030e-01f, -3.43209952e-01f, 2.14569010e-02f, -1.42902061e-01f, -1.53633195e-03f, 9.84135345e-02f, -1.92652479e-01f, 4.39098366e-02f,
  -1.75947070e-01f, -2.12274104e-01f, -1.44056380e-01f, -7.90303648e-02f, 1.27001628e-01f, 6.82083145e-02f, -1.40489861e-01f, -1.66164026e-01f, -2.23825380e-01f, -1.13903992e-01f,
  -3.06294590e-01f, -1.78177342e-01f, -2.39180960e-02f, -9.89280194e-02f, -2.31640562e-01f, -1.48622498e-01f, -9.94005590e-04f, -2.31893331e-01f, -1.93430230e-01f, 1.38014108e-01f,
  5.21358624e-02f, -3.26100960e-02f, -1.79730907e-01f, -2.42339261e-02f, -1.24212541e-01f, -1.70823663e-01f, -3.15293483e-02f, -1.03302814e-01f, -1.57396749e-01f, 3.61601077e-03f,
  -9.25073326e-02f, -1.00756787e-01f, -1.05374485e-01f, -5.52459806e-03f, -1.12671249e-01f, -1.47626817e-01f, -1.13750398e-01f, -9.20579210e-02f, -1.27708465e-01f, -5.20681962e-02f,
  -1.65352046e-01f, -4.93494980e-02f, 7.10022822e-02f, 8.17164853e-02f, -1.32162422e-01f, -6.45066425e-02f, -1.85874216e-02f, -1.61333993e-01f, -5.08865528e-02f, -9.76718590e-02f,
  1.32813543e-01f, -4.26781714e-01f, 3.03837270e-01f, -1.14466704e-01f, 7.58603662e-02f, -1.34037033e-01f, -1.15792103e-01f, -8.40800703e-02f, 2.16732007e-02f, 4.49245889e-03f,
  -2.41910353e-01f, -3.44637707e-02f, 1.24232396e-01f, 3.12160421e-02f, 3.00564557e-01f, 1.40987650e-01f, -8.75103101e-02f, 7.11506456e-02f, -1.10824130e-01f, 8.54157135e-02f,
  7.04765469e-02f, 1.84546962e-01f, 2.84035087e-01f, 1.40931994e-01f, -6.87308162e-02f, 7.98835233e-02f, 3.51109862e-01f, 2.16011718e-01f, 1.96582481e-01f, 5.78423858e-01f,
  -2.74129603e-02f, -3.22079271e-01f, -6.98418140e-01f, 1.59242868e-01f, 1.11929402e-01f, -1.77446678e-01f, -4.80797738e-01f, -2.47287720e-01f, -1.97657160e-02f, -2.03236118e-01f,
  9.49283540e-02f, 3.79368126e-01f, -6.82356628e-03f, 1.01983115e-01f, -9.53046754e-02f, -3.92937928e-01f, -2.06068829e-01f, -1.75581081e-03f, 3.19010437e-01f, 6.35614336e-01f,
  4.55612898e-01f, 3.74128789e-01f, 3.80799770e-01f, 2.96613634e-01f, 2.14608684e-01f, 1.80225700e-01f, -2.77834952e-01f, 1.39396504e-01f, -2.12873635e-03f, 3.40575874e-02f,
  -2.84227163e-01f, -1.53032631e-01f, 5.83658181e-02f, 3.86996627e-01f, 1.90809861e-01f, 1.34435594e-01f, 9.44613740e-02f, 8.67750421e-02f, 9.47846994e-02f, -6.28846809e-02f,
  1.32730052e-01f, 8.49383324e-02f, 2.31617630e-01f, 7.69533142e-02f, -6.81810640e-03f, 1.39937857e-02f, -1.02280080e-01f, -1.45087600e-01f, -3.17943811e-01f, -3.21564712e-02f,
  4.64907587e-01f, 2.43106872e-01f, -2.13008568e-01f, -3.29661548e-01f, -2.48967603e-01f, -7.22036436e-02f, -2.34741375e-01f, 2.60845502e-03f, -4.41514641e-01f, -8.72984007e-02f,
  1.97378784e-01f, -6.63649365e-02f, -1.78155974e-01f, -2.87907630e-01f, -5.15862368e-02f, -8.58866125e-02f, -1.39420271e-01f, 5.85981226e-03f, -7.78786913e-02f, -1.08198740e-01f,
  -2.84206662e-02f, -5.34159690e-03f, 1.19014166e-01f, -1.73099886e-03f, 1.28175780e-01f, -1.00996301e-01f, 3.60912830e-02f, -4.86794859e-03f, -4.25078310e-02f, -5.54347225e-02f,
  3.80748301e-04f, -9.91840437e-02f, -1.30121037e-02f, 6.39845654e-02f, -7.61443377e-02f, -1.59343660e-01f, -1.35878893e-02f, 1.53068662e-01f, 1.03944190e-01f, 1.72506981e-02f,
  -2.18962193e-01f, -2.77933866e-01f, -2.38848463e-01f, 4.85684983e-02f, -1.78004816e-01f, 1.24918334e-02f, -1.03622556e-01f, -7.74066604e-04f, -2.37002775e-01f, -1.05790205e-01f,
  -7.79021755e-02f, -1.50546417e-01f, -2.49348029e-01f, -7.70703005e-03f, 7.16283917e-02f, -1.47605225e-01f, -8.95150527e-02f, -1.14205085e-01f, -2.14460596e-01f, -8.48333314e-02f,
  -2.33685523e-01f, -1.44936055e-01f, -1.84182256e-01f, -4.25844967e-01f, -9.78920162e-02f, -1.82330668e-01f, -2.57619500e-01f, -1.79789439e-01f, -4.38983619e-01f, -2.79519707e-01f,
  1.03345096e+00f, 3.26530635e-01f, -1.03171372e+00f, 3.15668166e-01f, -1.96054906e-01f, -5.07510841e-01f, -3.06792170e-01f, -2.73342282e-01f, 2.32983574e-01f, 1.76734120e-01f,
  2.03415230e-01f, 3.94309163e-01f, 3.92809838e-01f, 1.78088591e-01f, 6.59436807e-02f, -1.69093207e-01f, -2.58545369e-01f, -3.34199876e-01f, -2.73128599e-01f, -2.52861902e-02f,
  3.24600071e-01f, 3.84280175e-01f, 4.36181307e-01f, 3.84247452e-02f, 7.42893443e-02f, 8.01588818e-02f, -2.99159795e-01f, 7.84197450e-03f, 7.39315674e-02f, -4.99553457e-02f,
  -4.81296219e-02f, -1.74861819e-01f, -2.39801168e-01f, 2.68277526e-01f, -2.95226216e-01f, -9.45443008e-03f, -1.12953722e-01f, -1.29474312e-01f, 3.53222564e-02f, 4.31048647e-02f,
  -1.23514839e-01f, -6.66456893e-02f, 4.23306739e-03f, -2.06588972e-02f, -1.48024365e-01f, -1.94117129e-01f, -2.13918760e-01f, -2.95550644e-01f, -3.73729244e-02f, -2.63453692e-01f,
  8.53179246e-02f, -9.81499851e-02f, -4.48483944e-01f, -3.10635090e-01f, -3.54723245e-01f, -1.55691803e-01f, -4.65938181e-01f, -2.82328963e-01f, -2.27769688e-01f, 5.35790361e-02f,
  6.44716248e-02f, -1.85072184e-01f, -5.67481145e-02f, -6.75285533e-02f, 1.42312005e-01f, -6.34384379e-02f, 3.73086706e-02f, 2.04185262e-01f, 1.01290181e-01f, 1.14876246e-02f,
  5.53482659e-02f, 5.22879437e-02f, -1.35891259e-01f, -1.15220152e-01f, 2.15644032e-01f, -7.20113441e-02f, -2.25524515e-01f, 1.31982535e-01f, 1.53993085e-01f, -1.24536015e-01f,
  1.00706937e-03f, -1.20254621e-01f, -9.43097621e-02f, -1.63699135e-01f, -5.52609675e-02f, -2.51806378e-01f, 9.24726650e-02f, 4.96005500e-03f, 1.19078599e-01f, 6.84532225e-02f,
  5.63944757e-01f, -1.16880968e-01f, 2.98622489e-01f, 1.40612107e-02f, -5.91817871e-02f, -1.19094551e-01f, 1.15449540e-01f, 1.56667046e-02f, 5.75948730e-02f, 7.49379322e-02f,
  5.65050691e-02f, 3.52860279e-02f, 9.86795053e-02f, -6.93169311e-02f, -1.42994016e-01f, -3.46246287e-02f, 2.48076886e-01f, 7.42409751e-02f, 3.71193513e-02f, -3.00023913e-01f,
  1.51971936e-01f, 2.32441351e-01f, 1.95586666e-01f, 5.67853376e-02f, -1.72899049e-02f, 2.86043465e-01f, -4.43175733e-02f, -1.33519694e-01f, 7.81079605e-02f, 3.43651801e-01f,
  -2.48988904e-02f, 4.21021394e-02f, 3.90903831e-01f, -8.73182639e-02f, 3.18259597e-01f, 4.12024736e-01f, 6.35011077e-01f, 1.53617859e-01f, -2.00079381e-01f, -8.38828236e-02f,
  -1.28909022e-01f, -4.05135036e-01f, -4.68850851e-01f, -4.43709135e-01f, -1.34942964e-01f, 2.05560192e-01f, 6.92699850e-02f, -1.40969427e-02f, -5.02073281e-02f, -6.20073117e-02f,
  -1.06040142e-01f, -1.47544026e-01f, -1.55753359e-01f, -2.40394324e-01f, -1.43258154e-01f, -1.08817868e-01f, 5.42308502e-02f, 1.58194881e-02f, 1.26351848e-01f, -1.11281127e-01f,
  -1.77908525e-01f, 1.27788424e-01f, -6.63141087e-02f, -3.26327384e-01f, -7.57216439e-02f, 3.38821709e-02f, 1.37949765e-01f, -6.21616691e-02f, 1.55827282e-02f, -1.02284692e-01f,
  -1.72913432e-01f, -1.59967303e-01f, -3.61541435e-02f, -4.35161367e-02f, 8.21299478e-02f, -4.44641598e-02f, -2.05794483e-01f, -3.51806395e-02f, -1.30861610e-01f, -1.72022566e-01f,
  -9.33144093e-02f, 2.25756690e-02f, 1.10516325e-01f, 5.12119569e-02f, 3.97749655e-02f, 7.15583749e-03f, -4.61373031e-02f, -8.21390525e-02f, 4.11842801e-02f, -3.58424932e-02f,
  8.18212703e-02f, 1.56121701e-01f, 4.00266983e-03f, 1.27026707e-01f, 1.24292031e-01f, 1.54603288e-01f, 8.00406858e-02f, 1.58652827e-01f, 2.19962195e-01f, 6.02681264e-02f,
  1.51518926e-01f, 3.05466533e-01f, 2.25094751e-01f, 2.62197137e-01f, -1.88612577e-03f, 8.12678784e-02f, 3.73248488e-01f, 6.96978197e-02f, -4.77875732e-02f, 1.66479990e-01f,
  2.38005072e-02f, 2.44647354e-01f, 1.57713637e-01f, 1.79290697e-01f, 3.39221418e-01f, 7.75913894e-02f, 1.84617251e-01f, 2.34608442e-01f, 1.44049123e-01f, 1.79624125e-01f,
  -1.76161274e-01f, 1.78529680e-01f, -9.08287987e-02f, -2.10332021e-01f, -1.60195865e-02f, 1.70328449e-02f, 4.38369289e-02f, 5.90913370e-03f, 5.95934503e-02f, -2.26247385e-02f,
  8.19428116e-02f, -6.28153086e-02f, 5.57912141e-02f, 2.76666302e-02f, 1.96956098e-01f, 9.78673175e-02f, -4.83096503e-02f, 8.89587216e-03f, -8.56766198e-03f, -9.29084644e-02f,
  2.04557590e-02f, 1.45645902e-01f, 5.32565527e-02f, 1.43045083e-01f, 4.58324254e-02f, 2.72204913e-02f, 4.10438925e-02f, 1.32179961e-01f, 2.11986154e-01f, 1.49612173e-01f,
  6.32649481e-01f, -8.06727052e-01f, -1.50105413e-02f, 1.66415200e-01f, 3.57317552e-02f, 5.34969345e-02f, -3.38535547e-01f, -1.31270707e-01f, 6.79209083e-02f, -2.43954122e-01f,
  -1.52417213e-01f, 6.34606332e-02f, 3.43584530e-02f, -1.16995454e-01f, -5.87279834e-02f, -1.70151100e-01f, -8.00245106e-02f, 2.07933515e-01f, 3.81427318e-01f, -1.39075778e-02f,
  -1.19488269e-01f, -1.01182036e-01f, 1.22078784e-01f, -2.43187193e-02f, -3.27697784e-01f, 5.09388745e-02f, -1.93732023e-01f, -2.38570109e-01f, -2.69787967e-01f, -3.56028438e-01f,
  -1.78013980e-01f, 9.61202383e-02f, 1.28026858e-01f, 7.87163526e-03f, -3.53596993e-02f, -1.77641902e-02f, 1.86153769e-01f, -1.17151193e-01f, -1.38435900e-01f, -1.37709349e-01f,
  7.41311954e-03f, 4.52082604e-02f, 5.64805698e-03f, -2.09283978e-02f, 8.00395291e-03f, 9.29468647e-02f, 9.70827602e-03f, -1.57588452e-01f, -7.58808553e-02f, -8.63058344e-02f,
  -8.06046948e-02f, 5.52016869e-02f, 3.66749763e-02f, 4.58317883e-02f, 1.45765781e-01f, 1.17954686e-01f, 6.80112932e-03f, 1.06410924e-02f, 2.33191237e-01f, 1.31770968e-01f,
  4.13116850e-02f, -5.16954772e-02f, 7.21485987e-02f, 1.47999570e-01f, 1.73033297e-01f, 8.02251324e-02f, 4.47806977e-02f, 2.28024386e-02f, 1.67647839e-01f, 1.67433545e-01f,
  -1.77126855e-01f, 7.68620893e-02f, 1.07557110e-01f, 1.91857815e-02f, 9.70604941e-02f, -1.42988577e-01f, -1.31205201e-01f, -1.70164611e-02f, 1.02830276e-01f, -6.56049252e-02f,
  8.18722621e-02f, -1.93602815e-01f, -1.49750814e-01f, -1.39852390e-01f, -2.58666903e-01f, -3.46092917e-02f, -5.28469048e-02f, -7.55351484e-02f, -1.00499183e-01f, -2.07801357e-01f,
  -5.57499051e-01f, 5.49139857e-01f, 1.25214726e-01f, -1.10520571e-01f, 4.23363969e-02f, -6.88143820e-02f, 3.04211378e-02f, -8.32328126e-02f, -1.48533076e-01f, -7.54447952e-02f,
  5.72188618e-03f, 5.34215346e-02f, 1.26770539e-02f, 4.56105918e-03f, 2.48159260e-01f, 2.46970817e-01f, -5.92219494e-02f, -6.86520785e-02f, -1.52591392e-01f, -1.06706053e-01f,
  -2.09046245e-01f, 8.23648423e-02f, 1.65396929e-01f, 1.24995813e-01f, 1.81652293e-01f, 2.63247401e-01f, 4.79787923e-02f, 1.28414869e-01f, 2.37568349e-01f, 1.69417471e-01f,
  -6.61658764e-01f, 6.10757843e-02f, -1.21986516e-01f, -6.67320073e-01f, -6.45970881e-01f, -4.96526301e-01f, -2.03281939e-01f, -2.80992508e-01f, -4.38511223e-01f, -1.83616474e-01f,
  1.13132142e-01f, 1.32272169e-01f, 3.14461887e-01f, 9.90329031e-03f, 6.95268661e-02f, 9.89452749e-03f, -1.78708106e-01f, -3.46518695e-01f, -4.89174038e-01f, -5.51522434e-01f,
  -4.98593092e-01f, -6.18187606e-01f, -4.32547748e-01f, -2.91680753e-01f, -2.25367159e-01f, -6.08527474e-02f, -6.45628721e-02f, -3.92521679e-01f, -1.93599418e-01f, -1.94532737e-01f,
  4.38837618e-01f, -2.50504017e-01f, -2.09993813e-02f, -9.27402526e-02f, -3.60363647e-02f, 1.26445219e-02f, 2.13278215e-02f, -3.03648441e-04f, 2.01867223e-02f, -9.95070860e-02f,
  -4.40090410e-02f, -4.70979363e-02f, -3.82759161e-02f, 1.06839053e-01f, -1.44752488e-01f, -1.67615250e-01f, -1.60101149e-02f, -8.80472288e-02f, -3.07992157e-02f, 1.33938015e-01f,
  8.30969438e-02f, -1.34621277e-01f, 7.84461647e-02f, 1.46749377e-01f, 9.04417187e-02f, 3.72701958e-02f, 6.32081181e-02f, -1.16809402e-02f, 7.87846372e-02f, 1.09986842e-01f,
  -2.51314789e-01f, 1.59855545e-01f, -1.79988518e-02f, -1.80828556e-01f, 1.44174956e-02f, -3.03561687e-02f, -2.61586364e-02f, -1.12787429e-02f, 1.12522934e-02f, -9.95697528e-02f,
  -7.93484300e-02f, 1.02661606e-02f, 7.15562478e-02f, -2.18067560e-02f, -4.01685610e-02f, -4.41717356e-02f, 2.17430890e-02f, 1.18287019e-01f, -2.79490426e-02f, -6.83741048e-02f,
  -1.00201830e-01f, 4.73990142e-02f, -8.16028789e-02f, -6.13555238e-02f, -1.35149762e-01f, -1.22875579e-01f, -3.71755520e-03f, 1.07535072e-01f, -2.29806751e-02f, -1.40992105e-02f,
  3.47939253e-01f, -1.98204085e-01f, 4.70242351e-02f, 6.81521297e-02f, 4.16496731e-02f, 9.67138913e-03f, 1.56321943e-01f, -6.73426911e-02f, -1.43410608e-01f, -1.25962362e-01f,
  -8.93875286e-02f, -4.76145279e-03f, 7.64468536e-02f, -1.74554717e-02f, -6.22799173e-02f, -1.18960552e-01f, 1.47107784e-02f, -1.02000587e-01f, -8.28325897e-02f, 1.07371537e-02f,
  5.23008453e-03f, -2.27278061e-02f, 1.13945171e-01f, 1.09472953e-01f, 1.93658713e-02f, -4.46468219e-02f, 7.54030198e-02f, 9.35753658e-02f, 1.69299003e-02f, 1.36433989e-01f,
  5.76573491e-01f, -1.29136488e-01f, -5.68983614e-01f, -4.84089851e-02f, -4.31611061e-01f, -3.00248206e-01f, -2.77981281e-01f, -6.41879439e-02f, -7.03460798e-02f, -3.76694113e-01f,
  -1.23940781e-01f, 3.84833617e-03f, -8.11291933e-02f, -1.34008646e-01f, -1.76350977e-02f, -4.37621742e-01f, -4.82181460e-01f, -3.75059754e-01f, -2.18666226e-01f, -2.54818767e-01f,
  -2.75384068e-01f, -1.62224203e-01f, -7.58292079e-02f, -1.38472229e-01f, -3.20507407e-01f, -1.77792609e-01f, -3.14291716e-01f, -2.82028645e-01f, -2.34678909e-01f, -3.68021071e-01f,
  -3.70368540e-01f, 2.11327881e-01f, -1.11852977e-02f, 8.36550072e-02f, -3.94433215e-02f, 9.78768691e-02f, 1.06858917e-01f, -3.22709456e-02f, 2.41638273e-02f, -1.34497425e-02f,
  1.85844861e-02f, -8.82485788e-03f, 5.27093746e-02f, -9.99004543e-02f, -2.27003526e-02f, -2.59623677e-03f, -1.15519732e-01f, -4.43437882e-02f, -1.36759460e-01f, -1.77676052e-01f,
  -1.74780086e-01f, -4.75374311e-02f, 5.82612231e-02f, -6.58509135e-02f, 2.99860928e-02f, -1.97913162e-02f, -7.95034617e-02f, -5.28735220e-02f, 1.54149840e-02f, -7.26887658e-02f,
  -9.28541571e-02f, -1.41144663e-01f, 2.11495031e-02f, 2.63685957e-02f, 7.92598203e-02f, -6.79450929e-02f, -1.46068791e-02f, -9.70016345e-02f, -1.13010094e-01f, -5.02086207e-02f,
  -8.31901878e-02f, -7.12056682e-02f, 3.64738815e-02f, 5.30345812e-02f, -1.50066286e-01f, 1.32961478e-02f, 6.65546060e-02f, -8.39907378e-02f, 1.47648156e-02f, -4.80725430e-02f,
  -1.15549348e-01f, -3.56389359e-02f, -8.00894201e-03f, 3.69472094e-02f, -8.29093978e-02f, 4.40901294e-02f, 6.54117838e-02f, -1.66394468e-02f, 1.30521562e-02f, -1.92191452e-02f,
  2.10503221e-01f, 1.15965724e-01f, 6.83068037e-02f, 1.13627389e-01f, -3.14051169e-03f, -1.07400432e-01f, -3.04993819e-02f, -3.04334704e-02f, -6.65324787e-03f, 8.84915888e-03f,
  -9.29542780e-02f, -2.07522232e-03f, -1.35567207e-02f, -1.21911675e-01f, -1.53105082e-02f, -5.45139574e-02f, 8.91314894e-02f, -8.60976130e-02f, -9.67119262e-02f, -1.68919101e-01f,
  -9.23439413e-02f, 1.07999161e-01f, 2.56989837e-01f, 4.69612069e-02f, 5.91685101e-02f, 1.50187120e-01f, -1.05774194e-01f, -1.61207989e-01f, 2.06119403e-01f, 4.04873453e-02f,
  -7.56997764e-02f, 7.72688538e-02f, -1.78326935e-01f, -2.24930525e-01f, -7.49580413e-02f, 2.51598746e-01f, 6.40405536e-01f, 1.24302961e-01f, -1.29649788e-01f, 3.40977579e-01f,
  -4.38927002e-02f, -6.19404018e-01f, -6.63024366e-01f, -3.07849437e-01f, 8.20289627e-02f, 4.79960144e-01f, 2.88910687e-01f, -1.38643697e-01f, -2.15867609e-01f, 2.17700601e-01f,
  3.76303084e-02f, -1.69858739e-01f, -2.65075296e-01f, -1.83076605e-01f, -3.89314741e-01f, -4.52955574e-01f, -2.51629412e-01f, -2.06506640e-01f, -1.91168375e-02f, -1.71138018e-01f,
  -1.43279180e-01f, -1.79669321e-01f, -1.61783975e-02f, -2.82282233e-01f, -1.45320538e-02f, 5.59306480e-02f, -3.65774408e-02f, -3.52718294e-01f, -1.24537118e-01f, 8.36523622e-02f,
  -1.79440543e-01f, -1.39910385e-01f, -3.54022771e-01f, -2.10755095e-01f, -2.26106092e-01f, -3.64367813e-02f, -1.27648339e-01f, -2.05606967e-02f, -8.52217302e-02f, -4.11717854e-02f,
  1.13660984e-01f, 1.31589621e-01f, -4.83659431e-02f, 1.69314161e-01f, -6.25309162e-03f, -9.91350636e-02f, -1.96401961e-02f, -1.33417502e-01f, -5.74988406e-03f, 8.61878321e-02f,
  2.22345918e-01f, -1.63800810e-02f, -8.28277022e-02f, 4.73989733e-03f, 1.67883664e-01f, 5.57240807e-02f, -1.75506677e-02f, -6.67132512e-02f, 2.94375550e-02f, -1.15327677e-02f,
  9.17059109e-02f, 1.69615850e-01f, 2.83260979e-02f, -3.43285985e-02f, -8.43655169e-02f, 2.73999274e-02f, 8.89012963e-02f, 1.64944410e-01f, 1.30511289e-02f, 5.10492548e-02f,
  -1.41373590e-01f, -1.40379965e-01f, -1.38548747e-01f, -3.40295583e-02f, -1.78516074e-03f, -4.49415930e-02f, -3.78634930e-02f, 2.78487615e-02f, -6.21212274e-02f, -4.28244546e-02f,
  -3.96896869e-01f, 1.88758805e-01f, -8.03001970e-02f, -6.59914538e-02f, -6.87368289e-02f, 1.22894961e-02f, -1.29754871e-01f, 1.96989924e-01f, -1.39381692e-01f, 1.24628089e-01f,
  -6.11678176e-02f, -9.98761388e-04f, -1.31106853e-01f, -4.77350764e-02f, -4.27405015e-02f, 5.38432635e-02f, 2.78610528e-01f, -6.08503819e-02f, 9.69736874e-02f, 9.64627564e-02f,
  1.26665980e-01f, 2.47849628e-01f, 2.18092799e-01f, 9.51567292e-02f, 1.01569556e-01f, 7.72489756e-02f, -6.98172152e-02f, 8.14743116e-02f, 1.08123422e-01f, 4.26271915e-01f,
  1.06407785e+00f, 3.50829184e-01f, -2.07320169e-01f, 2.29014307e-01f, -1.03198037e-01f, 7.24468082e-02f, 1.44194320e-01f, 2.58773953e-01f, 2.49240771e-01f, 2.76410401e-01f,
  1.82847604e-01f, 1.19065151e-01f, 1.77002281e-01f, -7.09228143e-02f, 7.84457028e-02f, -4.07483894e-03f, -1.41801640e-01f, -1.06189542e-01f, -2.20289290e-01f, -1.12265393e-01f,
  -5.45828380e-02f, 4.68673147e-02f, 1.20717578e-01f, 9.47589576e-02f, -4.60114554e-02f, -1.49607575e-02f, 9.49494094e-02f, -5.89010827e-02f, -2.62827128e-01f, -2.84928501e-01f,
  -7.68487155e-01f, -6.76151067e-02f, -6.65460452e-02f, -6.73964098e-02f, 1.17635004e-01f, 2.92524099e-01f, 9.09735486e-02f, 1.11275703e-01f, 1.29172906e-01f, 6.51476011e-02f,
  -1.38203397e-01f, 6.73635080e-02f, -5.07920869e-02f, 2.57572196e-02f, -1.30189843e-02f, -3.09180096e-02f, 3.72708663e-02f, -8.96269083e-02f, -9.88917947e-02f, -2.77459063e-02f,
  -1.11228250e-01f, -7.73668364e-02f, -1.33652717e-01f, -8.73510912e-02f, -1.87391937e-02f, -8.64688680e-02f, 1.59085281e-02f, -2.89028995e-02f, -4.63950150e-02f, 1.78832680e-01f,
  -3.27406153e-02f, 2.14179173e-01f, -1.16971262e-01f, -1.08190000e-01f, -7.55876675e-03f, 7.39601254e-02f, 3.09396517e-02f, -8.41528475e-02f, 5.04766926e-02f, 1.36065885e-01f,
  -4.82064635e-02f, -1.67201653e-01f, -1.67155545e-02f, 9.84654482e-03f, -5.63511737e-02f, -1.43301025e-01f, -1.03180826e-01f, -7.43675902e-02f, -2.03702062e-01f, -4.55592722e-02f,
  -2.00591221e-01f, 8.87553170e-02f, 5.86188659e-02f, -1.31376609e-01f, -8.56694505e-02f, -1.20624946e-02f, -1.75450206e-01f, 1.67554058e-02f, 1.15654208e-01f, 9.06069800e-02f,
  -1.86909318e-01f, -4.02501374e-01f, -1.49997503e-01f, -1.20322675e-01f, 4.44462243e-03f, 1.27622217e-01f, -2.20518053e-01f, -4.69459221e-02f, 6.62930459e-02f, -1.05575100e-01f,
  -1.14713944e-01f, 3.62013169e-02f, 2.26175841e-02f, 1.64376386e-02f, 9.90495086e-02f, -3.06597278e-02f, 1.15140006e-02f, -5.46821021e-02f, -1.10320397e-01f, -2.87342835e-02f,
  -1.99855212e-02f, 2.07714558e-01f, 9.00283530e-02f, 9.98432487e-02f, 4.07532454e-02f, 7.70055652e-02f, 2.47881431e-02f, -1.01548903e-01f, 1.29965588e-01f, 4.89976525e-01f,
  -1.89427614e-01f, 1.82913676e-01f, -4.68503147e-01f, -1.48328558e-01f, 4.84053940e-02f, -6.38430417e-02f, 1.86650064e-02f, -7.16670081e-02f, -9.30407271e-02f, 2.96067749e-03f,
  9.46598966e-03f, -1.37632579e-01f, -4.61994052e-01f, -4.53301400e-01f, -6.83412790e-01f, -4.41437870e-01f, -4.95094091e-01f, -5.98653257e-01f, -3.79391819e-01f, 4.11765009e-01f,
  3.62012118e-01f, -6.89297393e-02f, -2.38204405e-01f, -2.06077427e-01f, 2.03541771e-01f, -2.09196344e-01f, -3.32568645e-01f, -1.73564836e-01f, -3.42726596e-02f, -1.72717571e-02f,
  -3.87782641e-02f, -1.14106111e-01f, -6.29823804e-02f, -7.86740407e-02f, 6.57991990e-02f, 9.45290998e-02f, 1.43329218e-01f, -1.15025550e-01f, 7.72150792e-03f, -1.14926502e-01f,
  9.91954356e-02f, 2.24023059e-01f, -3.14830802e-02f, -3.14076021e-02f, -2.47994065e-02f, -2.86360029e-02f, -1.05936319e-01f, -2.36507744e-01f, -1.59459040e-01f, 2.88302779e-01f,
  2.78679281e-01f, 1.55699980e-02f, -4.05687809e-01f, -6.48259521e-02f, -6.73700720e-02f, -9.93137062e-02f, 5.93279190e-02f, 6.43107146e-02f, -2.23770618e-01f, 7.36603066e-02f,
  -2.32381397e-03f, -3.04103401e-02f, 4.35146838e-02f, 8.62371996e-02f, 2.62728799e-02f, -1.37847081e-01f, -6.38763458e-02f, -4.55110036e-02f, -4.38922718e-02f, -3.31353992e-02f,
  4.27690893e-03f, 6.13215268e-02f, -4.19460051e-02f, -3.15510556e-02f, -7.15888292e-02f, -1.10862508e-01f, -1.39510036e-01f, -1.24632880e-01f, -9.54226628e-02f, -6.59455657e-02f,
  -1.12922922e-01f, -1.28415644e-01f, -3.82212661e-02f, -5.96467443e-02f, -5.64301293e-03f, -1.43802077e-01f, -1.73186380e-02f, -1.32577643e-01f, 1.79790873e-02f, -5.99140339e-02f,
  -2.30229586e-01f, -2.52531171e-01f, -1.69288039e-01f, -1.21728927e-01f, 1.06255300e-02f, 5.76077886e-02f, 9.78230238e-02f, 9.84135419e-02f, -3.04420032e-02f, 1.62513211e-01f,
  1.13196999e-01f, 1.10228702e-01f, 3.59339938e-02f, 1.24774195e-01f, 4.14157957e-02f, -1.39876558e-02f, 6.33463189e-02f, -1.33530959e-01f, -7.14437217e-02f, 3.57101738e-01f,
  4.73267660e-02f, -1.24906681e-01f, -3.36345822e-01f, -1.69577911e-01f, -1.82740092e-02f, -2.50764906e-01f, -2.03036785e-01f, -6.10466525e-02f, -3.56491148e-01f, -9.71181691e-02f,
  4.19075429e-01f, -6.80100143e-01f, -2.65924841e-01f, -2.08744973e-01f, 1.48952141e-01f, 3.62130910e-01f, 1.93732575e-01f, 2.22849116e-01f, 8.78022313e-02f, -7.01761469e-02f,
  -1.30974680e-01f, 1.47236615e-01f, -1.33237362e-01f, -7.86241740e-02f, 1.47657126e-01f, -1.04671918e-01f, -1.74124554e-01f, 5.91466241e-02f, 6.00589991e-01f, 4.94452059e-01f,
  7.92686641e-02f, -7.27448612e-02f, -1.85477119e-02f, -1.24378778e-01f, -3.06451231e-01f, -7.21555203e-02f, -5.37497282e-01f, -3.47749263e-01f, -2.78810114e-01f, -4.92992759e-01f,
  1.78394124e-01f, -1.96639866e-01f, 6.76224232e-02f, -1.72880054e-01f, -9.62473676e-02f, 5.10536470e-02f, 7.45011717e-02f, -2.03015178e-01f, -7.58973137e-02f, -4.47257003e-03f,
  -1.37867123e-01f, -8.05846453e-02f, -1.63560569e-01f, -1.47340894e-01f, -2.69380063e-02f, -6.02110615e-03f, -2.40303412e-01f, -1.19638160e-01f, -2.33292922e-01f, -8.62635449e-02f,
  -3.55207711e-01f, -4.87066805e-02f, 2.64567006e-02f, -1.15944833e-01f, -6.63239583e-02f, -1.63304154e-03f, -1.84452951e-01f, -7.10269958e-02f, -7.54126161e-02f, -1.11273274e-01f,
  1.01180980e-02f, -3.12907505e-03f, 5.01591004e-02f, -5.73099479e-02f, -3.74389067e-02f, 2.77860323e-03f, -4.73877341e-02f, -3.63812521e-02f, 5.01380600e-02f, -4.78638820e-02f,
  6.25160115e-04f, -4.32121865e-02f, 5.00196144e-02f, 1.06454156e-02f, -3.72351110e-02f, -1.04222938e-01f, 5.64571731e-02f, -8.80720541e-02f, 2.02387176e-03f, 4.74039242e-02f,
  4.70161065e-02f, 8.72194543e-02f, 4.11173888e-02f, -2.55940054e-02f, -3.33203152e-02f, -3.78692411e-02f, -1.55629059e-02f, 2.89109256e-02f, 9.18325782e-02f, 8.58539790e-02f,
  9.80874822e-02f, -2.57757735e-02f, 1.55372441e-01f, 7.34078288e-02f, -3.78716998e-02f, -5.20203561e-02f, -1.10652484e-01f, -6.11559078e-02f, -5.17552868e-02f, 6.44459426e-02f,
  -6.89078048e-02f, -7.08051259e-03f, -9.38934311e-02f, -6.01995550e-02f, 1.37898386e-01f, 8.54384601e-02f, -6.57864148e-03f, 7.14264140e-02f, -1.12805977e-01f, -4.28433605e-02f,
  -1.97785333e-01f, 1.75583601e-01f, 2.29614243e-01f, 2.17992008e-01f, 8.96398574e-02f, 3.44823778e-01f, 1.80501670e-01f, 1.20539367e-01f, 2.12173492e-01f, 1.41249195e-01f,
  7.63598025e-01f, -2.64694039e-02f, -7.80018151e-01f, 4.01691586e-01f, -3.47798795e-01f, -4.84140217e-01f, -5.52488089e-01f, 6.57725483e-02f, 4.16807950e-01f, -1.99537069e-01f,
  -1.82800621e-01f, -8.17131698e-02f, -1.31331697e-01f, -3.35878998e-01f, -4.65087831e-01f, -6.51403189e-01f, -5.74292958e-01f, -5.59579790e-01f, -5.27557552e-01f, -2.87431508e-01f,
  -1.40451252e-01f, 4.52265097e-03f, 1.47974407e-02f, -5.85800074e-02f, 1.74071163e-01f, 2.29393374e-02f, -2.81480461e-01f, -1.39638901e-01f, -3.96787792e-01f, -2.15772226e-01f,
  -5.37582397e-01f, -4.32370938e-02f, -2.04959914e-01f, 6.58389628e-02f, 4.39772792e-02f, -2.06446033e-02f, -7.29143471e-02f, 5.96936792e-02f, 1.22882806e-01f, -9.40265879e-02f,
  -1.78245753e-02f, -4.48112264e-02f, -3.59448418e-02f, -1.76768884e-01f, -7.55874366e-02f, -3.67529579e-02f, -7.75253624e-02f, -1.21294059e-01f, -1.27626106e-01f, -1.00183353e-01f,
  -1.68038473e-01f, -2.05442742e-01f, -1.73903808e-01f, -8.31878856e-02f, -9.15706977e-02f, -1.41214669e-01f, -4.00200207e-03f, 2.42141858e-02f, -1.35076463e-01f, 2.09425792e-01f,
  1.19006522e-01f, 1.39688835e-01f, 9.87338834e-03f, 8.02943558e-02f, 1.60022810e-01f, 7.12798163e-02f, -1.16548408e-02f, -6.86073154e-02f, 6.33741096e-02f, -3.43226679e-02f,
  -6.03354983e-02f, -7.10718334e-02f, 1.03464508e-02f, 2.54595987e-02f, -1.81785166e-01f, 3.22981514e-02f, -1.33109363e-02f, -4.84757274e-02f, -1.17367990e-02f, 4.06561978e-03f,
  -1.17511917e-02f, 4.02677692e-02f, 1.34196684e-01f, 8.18439871e-02f, -1.22933723e-01f, -7.18859350e-03f, 1.11379378e-01f, 9.48146805e-02f, 2.65459549e-02f, 4.73376252e-02f,
  3.50954771e-01f, -2.95808941e-01f, 6.47128224e-02f, -2.72860136e-02f, -1.29415676e-01f, -1.00490555e-01f, 5.34499250e-02f, 5.58492690e-02f, 1.13819689e-01f, -8.72755945e-02f,
  -1.97790444e-01f, 7.30361417e-02f, -1.35368273e-01f, 4.89610666e-03f, -1.42868966e-01f, -3.01871467e-02f, 2.85415705e-02f, -9.07787755e-02f, -1.85800463e-01f, 1.85602441e-01f,
  2.93768626e-02f, -8.01553354e-02f, 1.67719364e-01f, 6.72349110e-02f, 1.52889222e-01f, 4.60038222e-02f, 1.30916191e-02f, 8.05399101e-03f, -1.14033684e-01f, 3.03511262e-01f,
  4.90350813e-01f, 5.94670773e-01f, -8.38128403e-02f, 2.49087676e-01f, 9.48757753e-02f, 5.47524020e-02f, 3.02771498e-02f, 3.20442431e-02f, -5.28477654e-02f, 2.09438741e-01f,
  4.51356173e-01f, 2.53665358e-01f, 9.63561460e-02f, 1.14378102e-01f, -1.03319161e-01f, -2.16579571e-01f, -2.66018957e-01f, -1.35745525e-01f, -9.34924111e-02f, -4.61619496e-02f,
  1.36292771e-01f, 1.49023429e-01f, 1.14176288e-01f, -4.39383946e-02f, 2.34946966e-01f, 3.01258042e-02f, 4.63643521e-02f, 3.03164069e-02f, 1.65069163e-01f, -2.59060282e-02f,
  2.48806059e-01f, 3.53011459e-01f, -3.44635732e-02f, 1.05728418e-01f, 1.75141945e-01f, 3.55058303e-03f, 8.37781560e-03f, 7.35266283e-02f, 9.59597230e-02f, -9.56418961e-02f,
  8.61098766e-02f, 5.19902306e-03f, 5.79136275e-02f, 3.87456790e-02f, 1.06563292e-01f, -1.17987522e-03f, 1.46342024e-01f, 7.76810348e-02f, -4.50596698e-02f, 7.07798004e-02f,
  7.20760301e-02f, 1.14054069e-01f, 8.47073048e-02f, -8.92573223e-03f, -4.87232842e-02f, 5.30542992e-02f, 1.85724534e-02f, 3.38839851e-02f, -8.89849141e-02f, -4.96053621e-02f,
  -1.06079519e-01f, 5.60721420e-02f, 6.28004223e-02f, -8.16869512e-02f, -6.83868006e-02f, -1.09481774e-01f, -1.16087236e-01f, -1.32423803e-01f, -1.30141571e-01f, -5.42338425e-03f,
  -8.05275515e-02f, -5.34122810e-02f, -1.21342964e-01f, -6.43861815e-02f, -4.34582084e-02f, -5.86632639e-02f, -1.32513762e-01f, 9.90833528e-03f, 1.84123255e-02f, 6.81244284e-02f,
  4.02944237e-02f, -1.18228570e-01f, 1.26197696e-01f, 2.96269171e-02f, 1.38176814e-01f, 2.06189621e-02f, -9.91153717e-02f, -1.71377659e-02f, -4.90189567e-02f, -5.70366858e-03f,
  8.66887718e-02f, 6.38828501e-02f, -2.59719305e-02f, -6.70599565e-02f, 1.63769707e-01f, 1.37728423e-01f, 2.82051358e-02f, 1.56469122e-01f, 9.55097452e-02f, 5.93382157e-02f,
  -2.64886431e-02f, -6.72708675e-02f, 8.26687738e-02f, 9.67184361e-03f, -5.94777539e-02f, -3.38150677e-03f, 2.47264281e-01f, 2.16123164e-01f, 4.33691144e-02f, 1.29253134e-01f,
  8.95877555e-02f, -4.83877249e-02f, -9.05431509e-02f, -1.37282595e-01f, -1.13042928e-01f, 2.46547703e-02f, 6.46835715e-02f, 6.07556477e-03f, -5.84826581e-02f, -6.97521344e-02f,
  -5.51412344e-01f, -4.61610585e-01f, -3.17721725e-01f, 2.43545935e-01f, 4.32149976e-01f, -2.69247919e-01f, -6.88024819e-01f, -4.25642967e-01f, 1.79131582e-01f, -2.96290994e-01f,
  1.73122704e-01f, 5.29043138e-01f, 9.26881358e-02f, 8.76640230e-02f, -3.61868143e-01f, -4.81488675e-01f, -8.30201060e-02f, -7.12749064e-02f, -1.85447966e-03f, 1.11717619e-01f,
  4.07205611e-01f, 3.05438727e-01f, 6.41628802e-02f, 7.17029383e-04f, 1.88789889e-01f, 2.89013833e-01f, -9.84291174e-03f, 2.07438186e-01f, -7.03836381e-02f, 1.00986240e-02f,
  -3.56858969e-01f, -5.27456045e-01f, 6.14613034e-02f, 2.53082216e-01f, 2.10312262e-01f, -3.07797432e-01f, -3.17213923e-01f, -1.54188290e-01f, -1.20259985e-01f, -2.51589894e-01f,
  1.73936799e-01f, -9.86570194e-02f, 1.33102715e-01f, 3.46713476e-02f, -5.30975536e-02f, -2.52181500e-01f, -3.69970351e-02f, -3.27915490e-01f, -2.84386218e-01f, -2.92133778e-01f,
  2.51889914e-01f, 2.06728891e-01f, -2.25617722e-01f, -1.35880560e-01f, -3.36126804e-01f, 1.95015997e-01f, -2.30095565e-01f, -2.72089928e-01f, -4.45861161e-01f, -4.45279568e-01f,
  7.22696483e-02f, 1.52644813e-01f, 2.40352079e-02f, -9.38882977e-02f, -1.41422525e-02f, 1.87177677e-02f, 3.86546329e-02f, 1.35123106e-02f, 9.25705433e-02f, -1.91118687e-01f,
  3.53723355e-02f, 3.87442373e-02f, 2.61987876e-02f, -8.22412446e-02f, 1.03567190e-01f, -2.91940924e-02f, -5.69701195e-02f, 6.45077378e-02f, 5.60504608e-02f, -1.28934994e-01f,
  -7.41166323e-02f, -5.68463653e-02f, 2.12562159e-01f, -1.02927014e-01f, -1.17451146e-01f, -8.74349177e-02f, -2.52144523e-02f, 5.70790879e-02f, 8.46084505e-02f, -5.25582507e-02f,
  1.12476535e-01f, 1.56179756e-01f, -1.90666020e-01f, -3.76733020e-02f, 1.36439160e-01f, 1.71130300e-01f, 7.21678808e-02f, -6.80935830e-02f, -9.77554247e-02f, -1.26498669e-01f,
  -2.20471129e-01f, -1.49894550e-01f, -1.08562531e-02f, 7.38237947e-02f, -1.03166932e-02f, -8.19376931e-02f, 9.61048529e-02f, 1.54447937e-02f, 2.36132499e-02f, 1.82255954e-02f,
  -1.04875052e-02f, -1.52352974e-02f, -1.68289125e-01f, -2.57955492e-01f, 5.86415678e-02f, 4.50048633e-02f, -1.96774915e-01f, -2.70734161e-01f, -3.35821509e-01f, -4.82744366e-01f,
  -7.53291368e-01f, 5.42175591e-01f, 2.24647403e-01f, -1.94311306e-01f, 3.79213274e-01f, 2.25204498e-01f, 1.93236515e-01f, -2.45520458e-01f, -5.52427284e-02f, 1.94098234e-01f,
  4.10659701e-01f, -2.50650328e-02f, 2.68596169e-02f, -4.92572822e-02f, -3.35767925e-01f, 2.65901536e-01f, 3.34416360e-01f, -2.29073733e-01f, -5.88715553e-01f, -3.76027554e-01f,
  6.22826740e-02f, -2.47979447e-01f, -5.91338217e-01f, -2.81698763e-01f, 2.84760505e-01f, 6.03258668e-04f, 2.45129734e-01f, 1.55625492e-01f, 3.57512355e-01f, 4.62998122e-01f,
  4.91624959e-02f, 6.89052641e-02f, -1.55012205e-01f, -5.02415234e-03f, 2.03736961e-01f, -1.89136520e-01f, -1.65936008e-01f, -1.18693700e-02f, 7.60069340e-02f, -1.30108027e-02f,
  7.75937960e-02f, 3.83313186e-02f, 2.15447292e-01f, -9.46972743e-02f, -1.17786743e-01f, -2.72712559e-01f, -1.97001830e-01f, -3.83529156e-01f, -2.78987408e-01f, -3.78336459e-02f,
  3.16173911e-01f, 9.72218588e-02f, -1.17064409e-01f, -6.56541958e-02f, -1.08150057e-01f, -8.45938846e-02f, -1.08199097e-01f, -1.64814726e-01f, -2.79052049e-01f, -8.96921828e-02f,
  -1.74192023e-02f, 7.23316818e-02f, 3.78206633e-02f, -3.33082750e-02f, -1.20550007e-01f, 1.55533478e-01f, 1.88205302e-01f, 7.05457926e-02f, -6.91823512e-02f, -1.38281569e-01f,
  -3.83716710e-02f, -6.74675927e-02f, -8.64778161e-02f, 4.29959446e-02f, -1.19301945e-01f, -5.98594770e-02f, -2.17113588e-02f, -8.41849297e-02f, 3.47381048e-02f, -5.36284223e-02f,
  -1.20630875e-01f, -3.93754654e-02f, 9.27697197e-02f, -1.27544269e-01f, 1.80899248e-01f, 7.75040090e-02f, 3.56511101e-02f, 1.55114913e-02f, -4.84131500e-02f, 4.91376407e-02f,
  -3.72767985e-01f, -7.13607222e-02f, -1.65212005e-02f, -1.21448569e-01f, -7.10067973e-02f, -1.29983714e-02f, 1.09178592e-02f, 9.05466918e-03f, 8.63631666e-02f, -2.02814266e-01f,
  5.21647185e-02f, -3.29992920e-02f, 1.02694005e-01f, -1.02342807e-01f, -2.59714305e-01f, 2.79852767e-02f, -1.09851547e-02f, -6.36116564e-02f, -1.35944426e-01f, -3.46716307e-02f,
  4.94148470e-02f, -3.32037449e-01f, -3.27069908e-01f, -7.97841996e-02f, -1.15055755e-01f, -3.73445541e-01f, -1.95727825e-01f, -2.36519068e-01f, -3.48520845e-01f, -4.00174230e-01f,
  -1.94685962e-02f, 1.15005419e-01f, 1.81192905e-01f, 8.81733075e-02f, 2.13682353e-01f, -2.15054974e-02f, -1.21321209e-01f, -6.81858435e-02f, -1.66081220e-01f, 1.46410406e-01f,
  2.23025426e-01f, 1.31667368e-02f, -1.93722710e-01f, -2.53838569e-01f, -4.60147440e-01f, -3.89988124e-01f, -3.44340891e-01f, -3.03991914e-01f, -3.20934981e-01f, -2.91222095e-01f,
  -1.67053744e-01f, 1.05553018e-02f, -3.92314382e-02f, -1.42766699e-01f, 9.04448405e-02f, -4.00942303e-02f, 8.16470385e-02f, 2.34202668e-01f, -6.08109795e-02f, -1.21771462e-01f,
  5.62287271e-01f, 3.40059340e-01f, -2.88523138e-01f, -2.11022538e-03f, 1.19081862e-01f, -7.91286081e-02f, -6.65030107e-02f, -1.50974572e-01f, -6.45449460e-02f, 6.01189323e-02f,
  1.81256279e-01f, 1.35992125e-01f, 1.16276719e-01f, 1.58187330e-01f, 2.23982632e-01f, 1.89969346e-01f, 4.08312045e-02f, -1.91794515e-01f, -5.36018908e-02f, 8.63339305e-02f,
  1.47303790e-01f, 1.03698805e-01f, 1.55199707e-01f, -7.66796544e-02f, 3.10849659e-02f, -2.86875181e-02f, 1.06960386e-01f, 5.57112694e-02f, -4.44430895e-02f, -3.91451679e-02f,
  -8.99372399e-02f, -1.15792751e-01f, -8.13644677e-02f, 1.41220540e-01f, 9.90684256e-02f, 6.34828135e-02f, 5.19499853e-02f, -2.27472149e-02f, -1.56859294e-01f, 1.77344397e-01f,
  1.31641254e-01f, -3.32998484e-02f, 3.72981355e-02f, -9.56140831e-02f, -7.40232021e-02f, 1.36984691e-01f, 9.23447013e-02f, 7.76067050e-03f, 1.85443327e-01f, 2.16510907e-01f,
  5.40797748e-02f, 2.11864542e-02f, 1.24621317e-01f, 2.50664800e-02f, 1.70070659e-02f, 1.41881662e-03f, 6.13902621e-02f, 7.59715512e-02f, 1.95090234e-01f, 1.92534745e-01f,
  3.21589679e-01f, 4.24421206e-02f, -1.54150566e-02f, -1.68396413e-01f, 2.00987142e-02f, 1.80142615e-02f, 1.04258783e-01f, -2.57762134e-01f, 1.81974575e-01f, 1.00386202e-01f,
  2.39722058e-01f, 8.30253214e-02f, 1.77594319e-01f, 6.76245317e-02f, -4.08036895e-02f, 7.85854235e-02f, -6.29098192e-02f, -7.26597980e-02f, -1.57680988e-01f, 1.47895947e-01f,
  -7.98363388e-02f, -1.18860081e-01f, -1.89807907e-01f, -2.03341246e-01f, -6.64800853e-02f, -1.29797041e-01f, -1.26388967e-01f, 2.09969170e-02f, -1.55810252e-01f, -1.67769238e-01f,
  -1.76084593e-01f, -3.12189102e-01f, -5.80820262e-01f, -2.73572385e-01f, -3.84551227e-01f, -1.70836553e-01f, -6.21744208e-02f, 9.54710916e-02f, 4.67564352e-02f, -9.88186430e-03f,
  1.78265691e-01f, 1.61221936e-01f, -1.31509721e-01f, -1.24943025e-01f, -2.57417500e-01f, -3.60745221e-01f, -3.83527458e-01f, -4.76323187e-01f, -3.39434326e-01f, -1.14825279e-01f,
  -2.88155347e-01f, -4.97324586e-01f, -4.61621463e-01f, -4.55868393e-01f, -4.24972653e-01f, -3.98492664e-01f, -4.43817347e-01f, -4.96227622e-01f, -4.20005381e-01f, -6.24090612e-01f,
  -3.79364312e-01f, -5.32036182e-03f, 1.00084275e-01f, 1.38141870e-01f, -1.61925822e-01f, 1.59585774e-01f, -4.70088124e-02f, 5.91301546e-02f, 1.67498484e-01f, -1.98314954e-02f,
  1.20005496e-01f, 1.01748548e-01f, -4.67426293e-02f, 3.66461137e-03f, -4.01161872e-02f, -2.87422650e-02f, 1.36352062e-01f, 7.19645023e-02f, 1.60033479e-01f, 1.59253493e-01f,
  1.61893412e-01f, 1.03524007e-01f, 4.70148027e-02f, 2.09757477e-01f, 1.17419444e-01f, 1.05173811e-01f, -6.90655485e-02f, 1.29656270e-01f, 4.07748371e-02f, 9.79908481e-02f,
  -3.05276811e-02f, 8.25104564e-02f, 1.33506551e-01f, 8.01339447e-02f, 1.88942149e-01f, 6.69167116e-02f, 1.69183657e-01f, 1.43816277e-01f, 2.03089062e-02f, -5.23114158e-03f,
  7.59016573e-02f, 1.74590662e-01f, 8.00690129e-02f, -4.53847796e-02f, -9.56945941e-02f, 7.32401153e-04f, -1.30537432e-02f, -3.12771350e-02f, 4.12215106e-02f, 2.15010658e-01f,
  1.38648435e-01f, 1.18770443e-01f, -7.66619891e-02f, -6.48691729e-02f, -6.36083707e-02f, 4.57114242e-02f, -3.43159586e-02f, 1.04483500e-01f, -3.40071768e-02f, 1.84131071e-01f,
  -1.88414589e-01f, -1.40332729e-01f, 1.74747501e-02f, 2.05680758e-01f, -7.80232251e-02f, 4.71171550e-02f, -6.52052388e-02f, -6.15696944e-02f, 9.74310786e-02f, 1.33791305e-02f,
  6.98994547e-02f, -1.16349660e-01f, -1.34262294e-01f, 1.31160066e-01f, -1.12471744e-01f, 6.77082986e-02f, 1.55228555e-01f, 8.69983137e-02f, 6.15032464e-02f, 7.09125474e-02f,
  2.00249255e-01f, 1.59279093e-01f, 2.49132067e-01f, 1.48812339e-01f, 1.41164258e-01f, -8.20172299e-03f, -1.45085320e-01f, 8.58897567e-02f, -1.27725139e-01f, -1.15282489e-02f,
  -9.00193572e-01f, 2.15549812e-01f, 9.54888836e-02f, -5.64767718e-01f, -2.82147586e-01f, -2.60314524e-01f, -1.08827114e-01f, -4.44377065e-01f, -4.63676959e-01f, 1.41992867e-01f,
  2.83346683e-01f, 1.39628336e-01f, 2.77725995e-01f, 4.32023704e-02f, 1.68061480e-02f, 2.22726092e-01f, 1.02470607e-01f, -2.16510817e-01f, -5.17539382e-01f, -3.23908180e-01f,
  -9.54139754e-02f, -3.75390351e-01f, -4.94063795e-01f, -3.05553287e-01f, -3.97044607e-03f, 7.15782074e-03f, 9.94988084e-02f, -9.55420583e-02f, 2.38290235e-01f, 3.09576899e-01f,
  5.36119580e-01f, -1.75019294e-01f, -8.77360776e-02f, -1.09034844e-01f, -3.59641947e-02f, -1.16237044e-01f, -3.31175514e-02f, -3.04971278e-01f, -1.53025255e-01f, 2.52025351e-02f,
  -9.07919258e-02f, 2.45023612e-02f, -1.83807701e-01f, -4.86842282e-02f, -2.88856357e-01f, -1.55372933e-01f, -7.90734142e-02f, -1.17640823e-01f, 9.28787738e-02f, 3.01269948e-01f,
  2.39139900e-01f, 1.25197694e-01f, 1.42108068e-01f, -6.63070902e-02f, -4.89682853e-02f, 1.53674290e-01f, 9.63293910e-02f, 9.81288627e-02f, -3.92154418e-02f, 7.11475238e-02f,
  3.22273932e-02f, 2.17198953e-01f, 7.77301192e-02f, 6.79067289e-03f, 1.00824863e-01f, 1.17187403e-01f, -7.16756880e-02f, -3.62418965e-02f, -3.57542224e-02f, -5.52600399e-02f,
  6.39834674e-03f, 2.22060129e-01f, -2.38141809e-02f, -7.86077827e-02f, -5.85599206e-02f, 1.06286809e-01f, 4.68150564e-02f, 4.94072139e-02f, 2.71339212e-02f, -5.29537313e-02f,
  -1.20357007e-01f, 2.58036014e-02f, 1.67192556e-02f, -1.50479347e-01f, -9.87635702e-02f, 2.84789540e-02f, 1.50210559e-01f, 1.75051853e-01f, 5.87553717e-02f, -1.48138888e-02f,
  5.09172305e-02f, 1.42960742e-01f, 1.77803919e-01f, -1.14687935e-01f, -8.83844797e-04f, -8.72002915e-03f, 1.07588373e-01f, -1.24330364e-01f, -6.03721328e-02f, -1.33235663e-01f,
  7.60897920e-02f, -1.29712215e-02f, -2.67065894e-02f, 5.82343936e-02f, -1.87291652e-01f, -5.94726130e-02f, 1.10039517e-01f, -3.29826623e-02f, 1.77920565e-01f, 2.24919781e-01f,
  1.90811768e-01f, 1.62303522e-01f, 1.23293832e-01f, 1.70576647e-01f, 5.86375967e-02f, 6.80660829e-02f, 1.98830232e-01f, 2.00063333e-01f, 2.28045613e-01f, 7.36446083e-02f,
  5.91920018e-01f, 8.23925361e-02f, 1.56476885e-01f, 3.02927345e-01f, -3.51749837e-01f, -6.04457438e-01f, -7.36988485e-01f, -1.39529556e-01f, 1.49625435e-01f, -6.92171380e-02f,
  -4.54528809e-01f, -2.68529803e-01f, -3.05168759e-02f, -2.43546963e-01f, -3.40259314e-01f, -2.13364050e-01f, 7.19653368e-02f, 1.45734146e-01f, -1.89960182e-01f, -4.22247618e-01f,
  -1.94747150e-01f, 1.03445612e-01f, 2.74078697e-01f, 2.55821973e-01f, 4.59608167e-01f, 3.53637598e-02f, 2.00305849e-01f, 2.23829061e-01f, 9.81543958e-03f, 5.36169469e-01f,
  2.42215648e-01f, 4.89067584e-01f, -2.47555926e-01f, -2.45401673e-02f, -1.06307775e-01f, 1.22356251e-01f, 8.89050514e-02f, 2.92278200e-01f, -3.35327387e-02f, 1.42785430e-01f,
  -1.62545934e-01f, -6.68637305e-02f, 3.36040137e-03f, -5.61271189e-03f, 7.03855082e-02f, -9.15266853e-03f, 1.48238674e-01f, 1.91397324e-01f, 1.47532955e-01f, 1.33528486e-01f,
  -3.60647559e-01f, -1.63135454e-01f, 9.36487108e-04f, -1.15635201e-01f, 6.46554306e-02f, -1.48122773e-01f, -3.70751731e-02f, 1.39984846e-01f, 5.06277382e-02f, 4.72596079e-01f,
  -4.54051495e-02f, 1.71952024e-01f, -1.59340817e-02f, 4.88224402e-02f, -3.62656265e-02f, -7.26942047e-02f, 6.25168383e-02f, -6.23804368e-02f, 6.71907961e-02f, 3.87952067e-02f,
  -6.50835857e-02f, -5.97411171e-02f, 4.02588882e-02f, 1.91313729e-01f, 1.48659691e-01f, 2.16196537e-01f, -6.88885003e-02f, 8.91300216e-02f, 1.19651541e-01f, 1.06764421e-01f,
  -3.94101255e-02f, -3.03768422e-02f, 3.89067754e-02f, -3.03811841e-02f, 3.36558409e-02f, 7.79533833e-02f, 9.09157563e-03f, 1.51108699e-02f, 1.62486687e-01f, 5.35742268e-02f,
  -2.21290603e-01f, -4.93512660e-01f, 4.80275303e-02f, 7.76549196e-03f, 9.43627134e-02f, -6.33439049e-02f, 3.33909020e-02f, -1.08992219e-01f, 1.90758631e-01f, 8.41294974e-02f,
  -1.28591463e-01f, -2.90303510e-02f, 4.48224507e-03f, -2.63610147e-02f, -2.01699242e-01f, -4.25132141e-02f, -2.85962284e-01f, -1.10307001e-01f, -1.72116026e-01f, 1.32837212e-02f,
  -4.91976216e-02f, -4.13820267e-01f, -3.65046322e-01f, -2.34667912e-01f, -6.85101449e-02f, -2.75947511e-01f, -1.80632442e-01f, -1.78634629e-01f, -5.02908409e-01f, -3.35301787e-01f,
  3.07028323e-01f, -6.58071578e-01f, 3.41854125e-01f, -1.38798475e-01f, -1.81392670e-01f, -1.13047712e-01f, -4.60013300e-01f, -2.84672856e-01f, -1.62168100e-01f, -1.47498369e-01f,
  2.08894685e-01f, 6.43127561e-01f, 6.04707420e-01f, 5.19779325e-01f, 3.63668382e-01f, -3.21607262e-01f, -1.71065316e-01f, 6.25688434e-01f, 6.07417643e-01f, 9.89781171e-02f,
  -1.68108419e-01f, -1.65502593e-01f, 1.88597485e-01f, -5.78020215e-02f, -4.28248972e-01f, 2.25126073e-01f, -1.54371902e-01f, -2.10078463e-01f, -2.38484606e-01f, -2.84005255e-01f,
  3.27406496e-01f, -3.09058011e-01f, 1.73798993e-01f, 1.67299993e-02f, -4.87044044e-02f, -1.02145642e-01f, -5.25655150e-02f, -4.99658380e-03f, -8.10229927e-02f, -1.97754800e-01f,
  -7.21696392e-02f, -1.72455944e-02f, -1.40009960e-02f, -1.15780860e-01f, -2.09799692e-01f, -1.70279637e-01f, -1.81645155e-01f, 1.12588368e-01f, 9.65577215e-02f, -5.79850040e-02f,
  -7.31107891e-02f, -3.71076725e-02f, -5.14825573e-03f, -1.03760608e-01f, 7.33492300e-02f, 2.62827814e-01f, 3.22846659e-02f, -3.01856827e-02f, 1.03868432e-01f, -3.14355999e-01f,
  2.83214953e-02f, -3.44919488e-02f, -2.62192488e-02f, 1.50144160e-01f, 1.11929797e-01f, 4.26469259e-02f, 3.23601179e-02f, 1.47325788e-02f, 2.64141485e-02f, -1.42596781e-01f,
  -4.02059965e-02f, -1.36687839e-02f, 2.52878852e-02f, -1.04048841e-01f, 8.36415663e-02f, -3.23034264e-02f, -4.50052088e-03f, -9.89364162e-02f, 7.03903288e-02f, -5.75302280e-02f,
  1.20727263e-01f, -2.51492951e-02f, 7.20409527e-02f, 7.54740206e-04f, -1.09286243e-02f, 7.52827898e-02f, -6.46426901e-02f, -9.61745065e-03f, 1.08140614e-02f, -1.83255941e-01f,
  1.06039429e-02f, 2.58371294e-01f, -5.58764488e-02f, 1.46185393e-02f, -2.36941546e-01f, -2.94839293e-02f, -9.14052799e-02f, -6.45579770e-04f, -5.07629365e-02f, 1.89451352e-02f,
  -4.06461097e-02f, 1.26549497e-01f, -5.65952733e-02f, -7.62545690e-02f, -2.60093138e-02f, 3.36614228e-03f, -7.23870024e-02f, 1.04223877e-01f, -1.64514296e-02f, -6.84240237e-02f,
  -1.88671932e-01f, 3.30108055e-03f, 2.37051234e-01f, 4.08723764e-02f, -1.05739191e-01f, 2.71415710e-01f, 1.84116572e-01f, 9.73585024e-02f, 2.01643363e-01f, -1.67580202e-01f,
  6.80333555e-01f, 1.68279767e-01f, 2.82395184e-01f, 1.43441960e-01f, -2.56701142e-01f, -8.93541723e-02f, -3.06368172e-02f, 1.97858065e-02f, -1.45253226e-01f, 2.64757164e-02f,
  -3.20918232e-01f, -3.41130108e-01f, -2.61726320e-01f, -2.73742884e-01f, -9.16950628e-02f, -8.58331844e-02f, -9.55088239e-04f, 1.37452215e-01f, 2.86260825e-02f, -1.72385544e-01f,
  -2.67031342e-01f, 8.81472379e-02f, 2.17023939e-01f, -1.42196408e-02f, 3.23737413e-02f, -8.39509070e-02f, 5.65184057e-02f, -2.04304350e-03f, -1.21637143e-01f, 3.08353037e-01f,
  5.63042685e-02f, 4.07662064e-01f, -3.03262323e-01f, -2.24935070e-01f, 3.65332165e-03f, 5.25391102e-02f, -1.60257947e-02f, 8.44900161e-02f, -1.59450039e-01f, -1.49073467e-01f,
  8.02402571e-02f, 1.39634222e-01f, 5.88996559e-02f, -1.20624498e-01f, -1.08924828e-01f, -1.19961090e-01f, -3.33657227e-02f, 8.78777876e-02f, -1.29557684e-01f, -3.49723697e-02f,
  -1.97862551e-01f, -2.67965589e-02f, -2.65594628e-02f, -2.46512815e-01f, -5.79559505e-02f, -1.42497256e-01f, -1.34698316e-01f, 1.07537746e-01f, 2.48471927e-03f, 1.04674667e-01f,
  -5.07962465e-01f, 2.54810620e-02f, -1.28972605e-01f, -1.06637672e-01f, -8.13148618e-02f, -1.13156743e-01f, -5.22510596e-02f, -1.05356045e-01f, -1.47733882e-01f, -1.79287687e-01f,
  -1.69544667e-01f, -9.22590643e-02f, -1.01589905e-02f, -1.42856315e-01f, -8.75257626e-02f, 1.62199866e-02f, -3.78260389e-02f, -1.77881077e-01f, -1.36062771e-01f, 1.31507620e-01f,
  9.80159082e-03f, -9.53464508e-02f, -2.83339843e-02f, -1.15490079e-01f, -1.67107508e-01f, -1.75962627e-01f, -1.37285352e-01f, -1.64620906e-01f, -7.15533495e-02f, 1.50539652e-02f,
  -2.83939630e-01f, -9.07651931e-02f, 1.46803319e-01f, 3.31509799e-01f, 3.04390341e-01f, 1.46268889e-01f, 1.30950585e-01f, 1.88857511e-01f, 8.89703706e-02f, -5.21089919e-02f,
  1.32088721e-01f, 1.16178587e-01f, 9.08826143e-02f, 1.90980099e-02f, -1.00986853e-01f, -7.02946261e-02f, -8.20508897e-02f, -1.76867861e-02f, 8.36816151e-03f, 1.28880935e-02f,
  -1.17664933e-01f, -2.17258736e-01f, -2.11720660e-01f, -2.23679140e-01f, -1.64460257e-01f, -1.58845216e-01f, -2.03071177e-01f, -1.03295008e-02f, -1.45920306e-01f, -3.17022562e-01f,
  -7.41785109e-01f, 3.54840219e-01f, 6.56727254e-02f, -4.93926346e-01f, 1.07136630e-01f, 4.11352366e-01f, 5.20732284e-01f, 3.19393456e-01f, -8.04798231e-02f, -5.54731265e-02f,
  2.90557779e-02f, -7.08568320e-02f, -5.42083904e-02f, 5.06337248e-02f, 1.13908865e-01f, 2.86617875e-01f, 2.57206202e-01f, -2.15601817e-01f, -1.49946541e-01f, -2.13971063e-02f,
  6.86130002e-02f, -2.85696238e-01f, -4.38185841e-01f, -1.92254961e-01f, -1.19899191e-01f, -2.06867456e-01f, -9.40031260e-02f, -1.14163809e-01f, 7.37468377e-02f, -1.18424535e-01f,
  -5.34791350e-01f, -1.78452432e-01f, -1.17781721e-01f, -2.28842691e-01f, -1.45784363e-01f, -1.39658943e-01f, -1.77348286e-01f, -2.28266731e-01f, 4.24193364e-04f, -8.84438455e-02f,
  -1.63032666e-01f, 2.23413520e-02f, -1.30203187e-01f, -1.93682574e-02f, -1.76414698e-01f, 1.37132229e-02f, -1.40726253e-01f, -2.32291237e-01f, -1.26867890e-01f, 1.11027017e-01f,
  2.01675713e-01f, -1.93764523e-01f, -2.53329992e-01f, 1.56165406e-01f, 9.01221037e-02f, -3.01788211e-01f, -3.51356752e-02f, -1.08545467e-01f, -1.06768250e-01f, -3.97638440e-01f,
  -1.29335616e-02f, -9.12463740e-02f, 3.82964462e-02f, 2.18984149e-02f, -2.34938022e-02f, -4.92433570e-02f, 6.56590983e-02f, 1.19671367e-01f, -5.25259972e-02f, -6.90824687e-02f,
  2.70745397e-01f, -1.32475689e-01f, -8.24620128e-02f, -1.13248162e-01f, -1.90990478e-01f, -7.15362206e-02f, 8.49904213e-03f, 8.06507468e-02f, -8.35851282e-02f, -2.91022640e-02f,
  -8.07570294e-02f, 1.69285461e-02f, -4.88812588e-02f, 7.18125477e-02f, 6.48389533e-02f, -4.52540778e-02f, -1.33800060e-01f, -1.24682441e-01f, -1.61029890e-01f, -5.63989915e-02f,
  -4.05480534e-01f, 1.78982764e-01f, -3.76257211e-01f, 5.45271635e-02f, -1.27473518e-01f, 1.56273544e-02f, -5.16212359e-02f, 1.47797447e-02f, -2.22144257e-02f, -4.38890159e-02f,
  -9.34823591e-04f, -1.97683930e-01f, -6.55713007e-02f, 6.76006749e-02f, -1.56766549e-01f, -6.84389398e-02f, -2.65958548e-01f, -2.10607097e-01f, 6.91530108e-02f, -1.05117396e-01f,
  -3.71137597e-02f, -2.13340566e-01f, -6.11333907e-01f, -1.52070627e-01f, -1.29271641e-01f, -4.29475635e-01f, -2.22172111e-01f, -2.19077632e-01f, -2.52463520e-01f, -4.75464940e-01f,
  9.26859140e-01f, 6.29881248e-02f, 3.82282704e-01f, 1.18294775e-01f, -2.09971622e-01f, 1.12418436e-01f, 1.22216657e-01f, 1.77356556e-01f, -5.06518781e-02f, 1.38393277e-02f,
  3.53864282e-02f, -6.61059916e-02f, 1.32682383e-01f, 8.54495093e-02f, 1.96279272e-01f, 7.06816092e-02f, -1.21121831e-01f, 2.69648671e-01f, 2.25266516e-01f, 1.10079519e-01f,
  -2.35381410e-01f, -1.04675787e-02f, 3.37557912e-01f, 8.71620551e-02f, -1.62756845e-01f, -1.52381569e-01f, 7.14922324e-02f, -2.77123898e-02f, 6.68422952e-02f, -2.00144559e-01f,
  1.27203003e-01f, 4.43758160e-01f, -1.91293284e-01f, -1.05327435e-01f, -3.45511548e-02f, -2.04279497e-02f, -4.09021564e-02f, -5.52268885e-02f, -1.26552507e-01f, -1.73625171e-01f,
  -1.12454824e-01f, -8.36351961e-02f, 6.79950044e-02f, 7.80703202e-02f, 3.68865803e-02f, 3.52434106e-02f, 7.73904920e-02f, 1.25625491e-01f, 7.20871165e-02f, -4.62028086e-02f,
  -7.50174224e-02f, -9.91850197e-02f, 1.25003591e-01f, -1.38122514e-02f, 6.76136911e-02f, 1.06557608e-02f, -7.19666528e-03f, -3.11564625e-04f, 1.41313210e-01f, -1.37702040e-02f,
  9.74403396e-02f, 1.33084536e-01f, 1.31335169e-01f, 9.28636566e-02f, 1.89021617e-01f, 1.00847460e-01f, -5.35557494e-02f, 1.56641882e-02f, 1.31220996e-01f, 1.29318401e-01f,
  1.45865217e-01f, 2.29020312e-01f, 1.77361295e-01f, 1.45077571e-01f, -1.08660378e-01f, -5.69617301e-02f, -6.67766333e-02f, -3.67946401e-02f, 1.18513048e-01f, -4.59121726e-02f,
  9.69435871e-02f, 6.24733716e-02f, 1.36721045e-01f, 1.35381907e-01f, 3.62365209e-02f, 1.26254171e-01f, -2.35379245e-02f, 4.74839658e-02f, -2.37584487e-03f, -4.32062447e-02f,
  -5.42673469e-01f, 3.16687107e-01f, 1.62719376e-02f, -5.43851778e-02f, 1.02441609e-02f, -8.17013606e-02f, -6.27871305e-02f, -2.34062672e-01f, -3.98266584e-01f, -1.86757118e-01f,
  -8.55652317e-02f, 2.58782897e-02f, 1.26120850e-01f, 5.69115840e-02f, -3.19381468e-02f, -1.89953819e-01f, -6.45397305e-02f, -4.47074063e-02f, -1.43275395e-01f, -2.21492916e-01f,
  -6.94340542e-02f, -3.96694168e-02f, -1.21203624e-01f, -6.03002794e-02f, -5.40413335e-02f, -9.73206013e-02f, -4.26035337e-02f, -8.53994936e-02f, -1.29848598e-02f, -1.97028100e-01f,
  -6.50146723e-01f, -5.89577734e-01f, 2.71133691e-01f, -3.65535855e-01f, -1.46651179e-01f, -6.21512607e-02f, -6.19543254e-01f, -1.22782096e-01f, -1.34162977e-01f, -6.63998723e-01f,
  -3.11520189e-01f, -4.29913141e-02f, -2.05982663e-02f, 8.44570175e-02f, -6.29374757e-02f, -6.97534919e-01f, -2.91976601e-01f, 2.40879133e-01f, 4.83441472e-01f, 2.39050779e-02f,
  -2.62249678e-01f, -1.41583458e-01f, 2.32858688e-01f, 1.54930413e-01f, -4.00942177e-01f, -6.07320592e-02f, -1.69448033e-01f, -1.68462545e-01f, -2.34368369e-01f, -5.61324477e-01f,
  -3.16737384e-01f, -2.38260701e-02f, 4.19215322e-01f, 1.19295277e-01f, -1.92614868e-01f, -5.03721349e-02f, -1.52752191e-01f, 1.11792348e-01f, 2.61044540e-02f, 1.49667123e-02f,
  1.27841989e-02f, 1.16295209e-02f, 4.31956947e-02f, 1.62149761e-02f, 1.55650871e-02f, -4.18767594e-02f, 7.68284425e-02f, 1.37885273e-01f, -3.52613702e-02f, -1.41983792e-01f,
  -3.19517463e-01f, -1.32126197e-01f, 7.15754628e-02f, 1.58365861e-01f, 5.11089638e-02f, 9.37906802e-02f, 1.42105922e-01f, 2.50054181e-01f, 1.54039845e-01f, -5.03129184e-01f,
  -1.25810862e-01f, -5.26458360e-02f, 2.43271012e-02f, 7.29647726e-02f, 2.28399225e-02f, 2.17334628e-02f, -5.69203570e-02f, -2.89115794e-02f, 1.99216008e-01f, -1.12911627e-01f,
  1.19633369e-01f, -2.47746091e-02f, 8.19000229e-03f, -1.69461623e-01f, -6.40328676e-02f, -1.27703752e-02f, -1.32149667e-01f, -4.79594097e-02f, 3.03139444e-02f, -1.37911573e-01f,
  -1.80748515e-02f, 4.26987819e-02f, -3.32007883e-03f, -2.95164492e-02f, 2.32574018e-03f, 6.30598590e-02f, 1.05600571e-02f, 1.52460143e-01f, 9.06213820e-02f, 6.85598254e-02f,
  -3.64614539e-02f, 3.29439670e-01f, -4.04436350e-01f, 1.13089949e-01f, -1.60402283e-02f, 5.20668961e-02f, -7.55709633e-02f, 1.62759542e-01f, 1.33955423e-02f, -3.31582874e-02f,
  1.18641317e-01f, -9.41445902e-02f, -1.98290171e-03f, 9.66026932e-02f, 7.20850239e-03f, 1.60277933e-01f, -8.45144317e-02f, -3.22522633e-02f, 1.13336504e-01f, -1.91019535e-01f,
  -9.32012647e-02f, -1.34508833e-01f, -2.96070844e-01f, -1.12388335e-01f, -1.53437316e-01f, -6.08662143e-02f, -1.15507111e-01f, -1.18081592e-01f, -7.32498989e-02f, -6.96281493e-01f,
  -3.62203926e-01f, 1.55549034e-01f, 5.09992957e-01f, -5.27620018e-01f, 1.70096546e-01f, 1.65100589e-01f, 2.80662447e-01f, -2.58783102e-01f, -5.46020865e-01f, 1.35157527e-02f,
  4.72168386e-01f, -9.57911983e-02f, 1.01957181e-02f, 1.73471011e-02f, 1.79025769e-01f, 2.03350887e-01f, 9.48519856e-02f, 2.07953349e-01f, -2.42623594e-02f, -1.65361598e-01f,
  -8.66250545e-02f, -1.89079762e-01f, -2.29070522e-02f, -8.18648562e-02f, -3.91632408e-01f, -1.87054828e-01f, 2.08666444e-01f, 1.29458025e-01f, 2.86960900e-01f, -1.87344030e-01f,
  -1.71980374e-02f, 1.86612368e-01f, 1.34998560e-01f, 1.28172442e-01f, 2.64762431e-01f, -2.55829990e-01f, -1.20474562e-01f, -1.86935421e-02f, 4.24357876e-02f, -2.58443147e-01f,
  -9.72040370e-03f, 4.55486104e-02f, 3.25712003e-02f, 3.30625810e-02f, -7.13245198e-02f, -1.03680857e-01f, -7.83802718e-02f, -3.45228575e-02f, -5.45772016e-02f, -2.88232472e-02f,
  -7.93172196e-02f, 1.79641265e-02f, 1.51346087e-01f, -4.72412594e-02f, -3.20640594e-01f, -8.42176154e-02f, -1.43469553e-02f, -2.16429979e-01f, 1.30866943e-02f, -4.68161792e-01f,
  1.16888829e-01f, 1.97556898e-01f, 1.41371995e-01f, -1.61624402e-01f, -1.02463789e-01f, -7.99009353e-02f, -1.28401890e-02f, 1.14219412e-01f, 1.09926358e-01f, -2.24715006e-03f,
  -5.91821410e-02f, -2.95778904e-02f, 4.49716374e-02f, 4.93965410e-02f, -4.89482172e-02f, 4.25010603e-06f, -7.07191378e-02f, -2.86208540e-02f, 2.12360770e-01f, -9.54262987e-02f,
  6.68482631e-02f, -7.52991140e-02f, -9.18043479e-02f, -1.69176474e-01f, 6.13163263e-02f, 1.32836342e-01f, -2.61613667e-01f, -4.87475097e-02f, -7.35395178e-02f, 7.80137628e-02f,
  -4.72923040e-01f, 7.01421082e-01f, -1.85205594e-01f, 1.54658318e-01f, 1.48053825e-01f, 2.33944744e-01f, 1.00059293e-01f, 2.12054759e-01f, 1.43564105e-01f, 2.64863502e-02f,
  1.76347420e-02f, 3.55860554e-02f, -1.35061711e-01f, -1.97582934e-02f, 4.11415882e-02f, -1.78889185e-01f, 1.40988365e-01f, 8.55428516e-04f, -1.01392284e-01f, -2.13870704e-01f,
  -1.17808409e-01f, -1.72144741e-01f, -2.09199801e-01f, -1.19207010e-01f, -3.24911743e-01f, -2.46912494e-01f, -1.80032372e-01f, -1.15509257e-01f, 4.51119244e-02f, -3.14239979e-01f,
  1.65651247e-01f, 1.49391070e-01f, 2.97386020e-01f, 4.26496834e-01f, 1.01725839e-01f, 2.66489327e-01f, 2.96446681e-01f, 4.64618504e-01f, 4.18961674e-01f, 3.30126494e-01f,
  3.08197998e-02f, 2.16415912e-01f, 2.12999433e-01f, 3.14464450e-01f, 3.50864857e-01f, 4.98959482e-01f, 5.18135190e-01f, 3.45869362e-01f, 2.32830063e-01f, 2.20494077e-01f,
  2.13244036e-01f, 1.75866410e-01f, 1.50385201e-01f, 2.52592504e-01f, 2.29274288e-01f, 1.61929950e-01f, 9.40786004e-02f, 1.37949929e-01f, 5.97006865e-02f, 4.09049183e-01f,
  -1.54869869e-01f, -3.17797288e-02f, 8.93481970e-02f, -1.51435852e-01f, -2.72707999e-01f, 2.96293553e-02f, 3.08192819e-02f, -2.86341645e-02f, -1.11361347e-01f, 5.49707655e-03f,
  -7.20791072e-02f, -3.29354033e-02f, -2.01037023e-02f, -9.74727944e-02f, -1.34308383e-01f, -2.93927062e-02f, -3.33060883e-02f, 1.78629756e-01f, 1.58719987e-01f, 2.30610985e-02f,
  -6.02455139e-02f, -5.15827835e-02f, 7.27670789e-02f, -7.39672557e-02f, -4.67825010e-02f, -1.42533526e-01f, -1.85310110e-01f, -2.87932232e-02f, -1.46067351e-01f, -2.68205088e-02f,
  2.23557428e-01f, 1.94933102e-01f, -1.32758198e-02f, 3.77566405e-02f, -2.96269618e-02f, -1.26465917e-01f, 1.54348556e-02f, 5.00733852e-02f, 9.18265805e-02f, -2.78140418e-02f,
  -5.62870204e-02f, 3.98955904e-02f, 1.24625035e-01f, 1.09148147e-02f, 7.08416402e-02f, 1.19011775e-01f, 2.28798875e-04f, 6.48624897e-02f, -1.20957769e-01f, -3.83974351e-02f,
  -2.64669862e-02f, 3.76482233e-02f, -5.54079227e-02f, -2.69699059e-02f, -1.51423663e-02f, 1.23053752e-02f, 1.32110044e-01f, 2.98395716e-02f, 5.10285832e-02f, 1.01006500e-01f,
  1.19974829e-01f, -2.13731572e-01f, 5.44178821e-02f, 2.73039013e-01f, -1.14208974e-01f, -1.27585039e-01f, 3.06915172e-04f, -1.48398886e-02f, -1.52236849e-01f, -2.14519911e-03f,
  -7.47386813e-02f, 7.79129788e-02f, -1.26584142e-01f, -7.84068853e-02f, -1.09017782e-01f, -1.05205864e-01f, -2.73190327e-02f, 1.44223660e-01f, 1.44156605e-01f, 4.14955765e-02f,
  3.94633748e-02f, 2.09639952e-01f, 1.25417233e-01f, -2.23372802e-02f, -3.01256608e-02f, 7.41828904e-02f, -1.22084692e-01f, -5.90520799e-02f, -1.28591498e-02f, -5.09462617e-02f,
  -5.19608200e-01f, 1.67746320e-01f, -7.59766161e-01f, 1.78387165e-01f, 2.15672880e-01f, 1.75197184e-01f, 5.49028814e-01f, 3.81188929e-01f, 2.73003101e-01f, 1.68481678e-01f,
  -8.21139887e-02f, -1.02616094e-01f, -1.69373065e-01f, 1.96648445e-02f, 2.64650118e-02f, 3.57969880e-01f, 2.65792102e-01f, -3.37824047e-01f, -3.16944450e-01f, 1.67364895e-01f,
  3.34243059e-01f, 8.66283551e-02f, -3.16945493e-01f, -1.06501312e-03f, 4.31546830e-02f, 1.51008926e-02f, -1.98142114e-03f, -1.11080244e-01f, 3.19129303e-02f, -9.03680846e-02f,
  -7.30627894e-01f, -2.90434599e-01f, -2.00307891e-01f, -2.04324782e-01f, -3.88885856e-01f, -1.51965857e-01f, -7.21030831e-02f, -3.93731415e-01f, 3.85716818e-02f, -9.65725482e-02f,
  -2.41364226e-01f, -2.13512376e-01f, -2.86246389e-02f, -3.29382299e-03f, 2.40157824e-02f, 8.75349641e-02f, -4.79537100e-02f, -2.58123904e-01f, -2.52810836e-01f, -3.10835481e-01f,
  2.81574875e-01f, -2.96040028e-01f, -6.34867191e-01f, 6.59939833e-03f, -1.10407233e-01f, -2.40575492e-01f, -1.58102602e-01f, -2.52018094e-01f, -4.22509521e-01f, -2.90763497e-01f,
  -1.60001352e-01f, -4.84213606e-02f, 1.41719088e-01f, 9.14653763e-02f, 1.97213918e-01f, -2.32109544e-03f, 1.45210307e-02f, 4.23435643e-02f, -3.09446398e-02f, -2.64500212e-02f,
  -6.57921955e-02f, -9.26671177e-02f, -1.55253068e-01f, -4.17491496e-02f, 1.24674372e-01f, -1.09262422e-01f, 1.14027625e-02f, 5.44388890e-02f, 1.27832750e-02f, -2.12342255e-02f,
  1.39168920e-02f, -8.03986862e-02f, -5.68665676e-02f, 7.34182969e-02f, 1.31536618e-01f, -5.66478400e-03f, 1.81251854e-01f, 2.08741184e-02f, -8.64683688e-02f, 1.17745459e-01f,
  8.61571953e-02f, 3.01448792e-01f, -8.00454766e-02f, 2.86267232e-02f, -1.10537618e-01f, 4.97530289e-02f, 1.69690341e-01f, -3.80091891e-02f, -2.23263837e-02f, -6.40548170e-02f,
  -1.99230518e-02f, -1.57648716e-02f, 1.93917677e-01f, 1.51547149e-01f, 4.99100760e-02f, 1.85350433e-01f, 1.72085598e-01f, 8.06243643e-02f, 8.27206969e-02f, 3.35412077e-03f,
  3.61503094e-01f, 1.34633973e-01f, -1.83538452e-01f, -2.45004576e-02f, 1.30050465e-01f, -1.17180385e-02f, -5.51560968e-02f, 2.55357008e-02f, -7.72879645e-02f, 2.15208560e-01f,
  -2.99320519e-01f, 3.29313993e-01f, -5.12788296e-01f, -2.97620483e-02f, -3.71917725e-01f, -4.05353755e-01f, -3.53478901e-02f, 2.15106979e-01f, 1.30922243e-01f, 2.66156316e-01f,
  7.32189566e-02f, -1.36489093e-01f, -1.35033786e-01f, -2.03359738e-01f, -1.74881890e-01f, -3.65036987e-02f, -3.64280730e-01f, -5.30290365e-01f, -5.07033229e-01f, -1.74134970e-01f,
  -4.32625115e-02f, -4.82979007e-02f, -2.01815069e-01f, -9.09801424e-02f, 2.18805298e-01f, 1.25710201e-02f, -2.54047420e-02f, -1.65567532e-01f, -3.43344688e-01f, -2.40152940e-01f,
  1.92474127e-01f, -3.28720182e-01f, -8.59665424e-02f, -1.45868227e-01f, 1.82420820e-01f, 6.42857747e-03f, 1.80879552e-02f, 3.34563367e-02f, 9.37265903e-02f, 8.60369354e-02f,
  -1.14658989e-01f, -7.78147578e-02f, -1.40001878e-01f, -1.26593620e-01f, -1.03188716e-01f, -1.05698481e-01f, -1.99120477e-01f, -2.48245463e-01f, -9.58459675e-02f, 3.14414464e-02f,
  -1.22540064e-01f, -4.85216916e-01f, -6.57126456e-02f, -3.39356102e-02f, 3.97648364e-02f, -4.13463682e-01f, 7.66162574e-02f, -1.37543440e-01f, -2.14182794e-01f, 3.50959420e-01f,
  1.19275853e-01f, 2.01441497e-01f, 1.01099059e-01f, 1.54259533e-01f, 3.31333429e-01f, 7.22187236e-02f, 1.37919500e-01f, 1.13084778e-01f, 3.07025425e-02f, 1.48930654e-01f,
  -2.81042256e-03f, 1.96938157e-01f, 6.43830374e-02f, 3.52019146e-02f, -5.07252663e-02f, -1.39759809e-01f, -2.81742662e-02f, 2.48933420e-01f, -9.37800854e-04f, 1.51449308e-01f,
  -2.77660470e-02f, -2.09503006e-02f, -5.90277882e-03f, 2.25789621e-01f, -1.06399335e-01f, -4.45133969e-02f, -2.58761406e-01f, 1.56633016e-02f, -1.93686500e-01f, -2.80339301e-01f,
  5.27725458e-01f, -3.74425739e-01f, 1.76895365e-01f, -7.29692876e-02f, -3.50286104e-02f, 3.79615277e-03f, 7.03218579e-02f, 6.02960810e-02f, 6.73801079e-02f, 1.18352875e-01f,
  -6.14313670e-02f, 1.85607582e-01f, -3.16760615e-02f, 6.56206906e-02f, -4.92807180e-02f, -2.58378498e-02f, 5.35084046e-02f, -1.21904671e-01f, -1.41688660e-01f, 9.90871564e-02f,
  1.74282894e-01f, -3.34735028e-02f, 2.11398095e-01f, 2.91545838e-01f, 1.54474035e-01f, -1.98152721e-01f, 3.07528645e-01f, 2.32997194e-01f, -1.87203422e-01f, 6.28143132e-01f,
  4.27102864e-01f, 2.84808129e-01f, 2.61740625e-01f, 1.41620994e-01f, 4.93314475e-01f, 3.08862478e-01f, 3.70107621e-01f, -6.37373105e-02f, -9.23010781e-02f, 1.82087705e-01f,
  3.30417484e-01f, -1.62256643e-01f, -2.56923348e-01f, -2.35427007e-01f, -2.55210131e-01f, -1.26892701e-01f, -8.19433331e-02f, 2.08632946e-02f, 1.82557870e-02f, -3.20443697e-02f,
  -7.27509484e-02f, 8.78091753e-02f, 2.13845700e-01f, -7.82273263e-02f, -1.29035236e-02f, -2.63665430e-02f, 1.80893496e-01f, 3.11321497e-01f, 1.89206615e-01f, -6.51624054e-02f,
  9.01469365e-02f, 3.40082556e-01f, -2.93738812e-01f, -7.03578368e-02f, 8.13197643e-02f, -3.10355723e-01f, -9.62828770e-02f, -2.37823755e-01f, 1.21960053e-02f, -9.79977399e-02f,
  1.11379609e-01f, 3.27948518e-02f, 1.35025820e-02f, 1.19325798e-02f, 1.69158190e-01f, 1.50282141e-02f, -8.46010447e-02f, -7.28824809e-02f, -1.22514233e-01f, -3.81334312e-02f,
  -9.49048698e-02f, 2.91053057e-01f, 3.14838111e-01f, -9.96727794e-02f, -1.25054464e-01f, -2.68896166e-02f, 4.37832344e-03f, -5.86101599e-02f, -2.93209907e-02f, -3.91328037e-02f,
  -1.48556992e-01f, 5.25264926e-02f, 1.44477367e-01f, -9.18954164e-02f, 2.20156740e-02f, -8.15487802e-02f, 9.05381888e-03f, 1.82526596e-02f, 1.48203716e-01f, 1.10847972e-01f,
  -1.76021650e-01f, -1.91792045e-02f, -1.88609045e-02f, -1.54578999e-01f, -1.71090707e-01f, 2.95417532e-02f, -7.56095978e-04f, -7.46020004e-02f, 1.26110762e-01f, -2.36041341e-02f,
  -1.14309285e-02f, -2.75184456e-02f, -1.19624594e-02f, -1.03771195e-01f, -2.16776997e-01f, -2.50900149e-01f, -1.73516065e-01f, -1.58128560e-01f, -2.99151894e-02f, 6.01282902e-02f,
  -2.93105960e-01f, 5.90826161e-02f, -2.56874263e-01f, -9.52785611e-02f, 1.88238755e-01f, 7.00905081e-03f, -4.80292253e-02f, 1.55257173e-02f, 4.88070548e-02f, -1.75206289e-01f,
  -3.54488380e-02f, -1.76381141e-01f, -8.81721526e-02f, -7.02101663e-02f, -8.93929228e-02f, -1.17865495e-01f, 6.98160902e-02f, -1.88973080e-02f, 1.78866629e-02f, -1.34958047e-02f,
  -6.60625547e-02f, -9.43256170e-02f, 4.04060930e-02f, -2.35313222e-01f, -2.29334801e-01f, -1.94090843e-01f, -7.40401000e-02f, -6.66484162e-02f, -9.31629017e-02f, -2.43080750e-01f,
  -7.08633900e-01f, -4.33345288e-01f, 2.66337842e-01f, 3.65645170e-01f, 4.75229114e-01f, 2.95451492e-01f, 2.57296294e-01f, 2.10781798e-01f, 2.50023842e-01f, 6.65169384e-04f,
  -2.47893795e-01f, -6.12264350e-02f, 7.38447979e-02f, -2.90369317e-02f, 9.89680737e-02f, 3.90172601e-01f, 4.36582208e-01f, 6.44074827e-02f, 1.34534702e-01f, 2.24775150e-01f,
  1.85982883e-01f, -7.80524127e-03f, -2.22774968e-01f, -5.25742471e-02f, 1.45579323e-01f, 1.64861307e-01f, 6.81688264e-02f, 1.33040637e-01f, -2.08291542e-02f, 2.89786249e-01f,
  2.44105309e-01f, -2.26441175e-01f, 5.85485771e-02f, -2.91626722e-01f, -3.30236226e-01f, -2.69706190e-01f, -7.50694051e-02f, -1.07350171e-01f, -1.62948430e-01f, 1.60411745e-02f,
  -1.49357822e-02f, -5.96459135e-02f, -4.83288765e-02f, -1.17908597e-01f, -6.95843101e-02f, -8.42696205e-02f, -1.50268644e-01f, 4.56778817e-02f, 1.12265386e-01f, -1.07793853e-01f,
  -1.90192327e-01f, 1.04087234e-01f, 1.55453548e-01f, 1.78680569e-01f, 3.42956968e-02f, -6.92726672e-02f, -1.56200230e-01f, -1.05147652e-01f, 6.89434111e-02f, 4.01019715e-02f,
  3.23501006e-02f, -1.64617151e-01f, 9.48981047e-02f, 7.46732056e-02f, 3.86826321e-02f, -6.40824959e-02f, 1.57843620e-01f, 7.55565166e-02f, 4.97263111e-02f, -5.02758212e-02f,
  1.19051486e-01f, 2.36096635e-01f, 9.29001123e-02f, 1.19292341e-01f, -1.15460582e-01f, 4.96755242e-02f, -9.29912329e-02f, -9.58170649e-03f, -6.95710331e-02f, -1.76330153e-02f,
  8.23223405e-03f, -6.51666895e-02f, -2.49609619e-01f, 3.24825123e-02f, -9.05463696e-02f, -6.25645742e-02f, 1.07394205e-02f, -1.16400503e-01f, -1.09016500e-01f, -1.88467354e-01f,
  5.65625846e-01f, 1.39719471e-01f, 2.37144038e-01f, -1.65618118e-02f, 9.52528417e-03f, -3.73526156e-01f, -2.91851442e-02f, -4.59145047e-02f, -3.57869938e-02f, 1.83764249e-01f,
  -9.28077102e-02f, -2.44759440e-01f, -1.04208253e-01f, -5.95749505e-02f, 4.52441387e-02f, 6.60483688e-02f, -1.17746428e-01f, 1.31623909e-01f, 5.28111421e-02f, -8.65324885e-02f,
  -1.54789045e-01f, 1.36896238e-01f, 3.21348667e-01f, 1.22355327e-01f, 1.03343852e-01f, 9.49891880e-02f, 1.22781590e-01f, 2.70316321e-02f, 8.64760205e-02f, 8.49948749e-02f,
  3.92601043e-01f, 4.29632097e-01f, 1.27903685e-01f, 3.32028598e-01f, -5.82580447e-01f, -6.85550451e-01f, -4.04924512e-01f, -1.97346985e-01f, -1.30849987e-01f, 1.05864927e-02f,
  -4.52589959e-01f, -4.46511507e-01f, -3.15776944e-01f, -5.51124699e-02f, -1.13845952e-02f, 2.65914410e-01f, 4.85293120e-01f, 4.28611428e-01f, 5.69526292e-02f, -1.27427325e-01f,
  6.54645935e-02f, 6.23155713e-01f, 6.87801123e-01f, 4.12947476e-01f, 1.29836202e-01f, -1.28592089e-01f, 2.12639526e-01f, 2.58333981e-01f, 3.86074930e-02f, 3.54869217e-01f,
  -1.40209123e-02f, 9.50513557e-02f, -2.73622721e-01f, 1.24671673e-02f, -2.34726608e-01f, 2.84190476e-02f, -8.66818652e-02f, 1.90799430e-01f, -4.05126303e-01f, 8.66013020e-02f,
  -3.41076940e-01f, -2.73261778e-02f, -4.18943197e-01f, -2.32489663e-03f, 1.00800805e-01f, -1.89333469e-01f, 5.08324146e-01f, 2.65991807e-01f, 1.66534066e-01f, -2.49028996e-01f,
  -1.47999480e-01f, -1.32418081e-01f, -3.14221501e-01f, -1.22991122e-01f, -3.02475125e-01f, -2.37270549e-01f, -2.54917949e-01f, -8.27860013e-02f, -2.67429464e-02f, 3.55301738e-01f,
  -3.56105939e-02f, -2.42233083e-01f, 1.07447080e-01f, 1.86936826e-01f, 1.32505924e-01f, -1.57705083e-01f, 4.11352562e-03f, 2.25107856e-02f, -6.42194524e-02f, 7.42146093e-03f,
  -1.82858601e-01f, -8.46314058e-02f, 1.70479640e-02f, 2.32881289e-02f, -1.33565575e-01f, 3.71540301e-02f, -1.88228816e-01f, 3.41017753e-01f, 1.08545423e-02f, -6.25064299e-02f,
  -4.73652929e-02f, -9.85634252e-02f, 9.32104439e-02f, -2.97231432e-02f, 6.67515770e-02f, 1.26082852e-01f, 1.88080400e-01f, -9.71832126e-02f, 9.97494608e-02f, 9.36436728e-02f,
  2.64683127e-01f, -1.34885103e-01f, 7.62740970e-02f, 5.30760884e-02f, 5.11661395e-02f, -5.74582852e-02f, -1.77065805e-01f, -4.87725399e-02f, -2.56563902e-01f, -1.60943270e-01f,
  -2.50959575e-01f, -2.61455446e-01f, 8.14497620e-02f, -6.72016144e-02f, -1.64854050e-01f, -1.41905934e-01f, 8.31861347e-02f, -1.77805483e-01f, -2.62978878e-02f, -2.83919424e-01f,
  1.11792684e-01f, 6.57901838e-02f, -1.65923893e-01f, -2.95532644e-01f, -3.09913665e-01f, -2.21274242e-01f, -5.52626178e-02f, -5.05701900e-02f, -2.59247035e-01f, 2.79839963e-01f,
  1.64280236e-01f, 6.13613904e-01f, 4.01193649e-01f, -3.53904665e-01f, -1.77957922e-01f, 1.25420958e-01f, 4.05792326e-01f, 2.15094134e-01f, -8.07142034e-02f, 3.92175943e-01f,
  1.90301359e-01f, -4.67807770e-01f, -2.28489891e-01f, -2.82857776e-01f, -6.57983683e-03f, 3.69547337e-01f, 6.34524822e-02f, -2.21115947e-01f, -4.36770827e-01f, -3.90609443e-01f,
  -4.16119486e-01f, -3.01151156e-01f, -1.24680959e-01f, 3.52917728e-03f, 4.03362438e-02f, -3.76190037e-01f, 1.81461036e-01f, 6.16170801e-02f, 2.09096730e-01f, -3.71875726e-02f,
  3.19448262e-01f, 5.90049207e-01f, -4.64234471e-01f, -2.88861752e-01f, 4.88553122e-02f, -3.86055000e-02f, 1.04727253e-01f, 7.99113214e-02f, -5.10776788e-02f, 1.30460277e-01f,
  -1.75086334e-01f, 1.67513937e-02f, 2.05316525e-02f, -6.18960783e-02f, -1.86103415e-02f, -1.46150598e-02f, 3.84607613e-02f, 4.05805325e-03f, -1.20169103e-01f, 2.09124193e-01f,
  -4.19054627e-01f, 2.18368545e-02f, 4.18601066e-01f, 1.79023430e-01f, 2.02664539e-01f, -4.11014020e-01f, 1.79591700e-01f, -3.79937957e-03f, 3.63538623e-01f, 2.31203824e-01f,
  3.22257988e-02f, -2.92012170e-02f, 1.76900011e-02f, 6.81151077e-02f, -2.10038975e-01f, -1.20563790e-01f, -3.77852172e-02f, -6.71328083e-02f, -3.32373730e-03f, -9.16845873e-02f,
  -3.62174921e-02f, 2.07477570e-01f, 1.27473846e-01f, 1.24179058e-01f, -9.52659175e-02f, 1.24528714e-01f, -9.63088125e-02f, 7.40172714e-02f, 6.18032478e-02f, 8.61502290e-02f,
  -7.43683428e-02f, -3.73852812e-02f, -4.86319214e-02f, 2.73559764e-02f, 2.16279225e-03f, 1.00217126e-01f, -4.40770350e-02f, -1.23656124e-01f, -1.47680327e-01f, 1.41896158e-01f,
  -5.24903536e-01f, -1.56133980e-01f, -9.02241021e-02f, -8.93454775e-02f, 4.95602638e-02f, 3.10109612e-02f, -2.30897442e-02f, 4.02277149e-02f, 1.23087049e-01f, 5.69007210e-02f,
  2.66675711e-01f, -2.23732907e-02f, 1.68104813e-01f, -2.35895831e-02f, -2.73015916e-01f, -6.43579438e-02f, -1.35094911e-01f, -1.90373585e-01f, -2.37231210e-01f, -1.90402456e-02f,
  -2.26475552e-01f, -2.11463958e-01f, -3.52150112e-01f, -1.71460882e-01f, -1.16502289e-02f, -3.13788533e-01f, -1.27563536e-01f, -2.43722036e-01f, -8.46220925e-03f, -2.14096427e-01f,
  -6.31665904e-03f, -9.25590545e-02f, -2.52593815e-01f, 2.57201549e-02f, 1.11265285e-02f, -1.69246018e-01f, -2.93721348e-01f, -1.59612775e-01f, 1.16005957e-01f, -1.03047006e-01f,
  3.65656652e-02f, 6.76794574e-02f, -1.75529867e-01f, -2.37524211e-01f, -4.44780976e-01f, -4.44569647e-01f, -3.54298681e-01f, -4.65994895e-01f, -3.06462318e-01f, -4.57701162e-02f,
  -1.78865697e-02f, -1.54187396e-01f, -1.36816204e-01f, 1.95760299e-02f, 3.63714099e-01f, 7.43008927e-02f, 9.38025340e-02f, 1.20188557e-01f, -3.51312500e-03f, 2.47315437e-01f,
  8.94134715e-02f, 1.56852499e-01f, -2.68635415e-02f, 4.88444418e-02f, -1.98597740e-02f, -4.42364104e-02f, -1.65669814e-01f, -2.18604449e-02f, -3.84364487e-03f, -7.32749701e-02f,
  -1.95712168e-02f, 2.10080445e-02f, -1.20105622e-02f, 4.62976843e-02f, -5.26712649e-02f, -7.41112977e-02f, -1.71362713e-01f, -2.07599834e-01f, -1.31710902e-01f, 8.61495063e-02f,
  -5.06945625e-02f, -2.56033018e-02f, -1.89540043e-01f, -1.79111622e-02f, 9.18800384e-03f, -1.69278413e-01f, 2.65145469e-02f, 1.57979310e-01f, -7.94096962e-02f, 8.53702873e-02f,
  2.55259246e-01f, -1.55229777e-01f, -1.26993909e-01f, 1.78653970e-02f, -1.26436427e-02f, 1.52514654e-03f, 2.08235960e-02f, 2.10937411e-02f, 1.06904367e-02f, 2.64302697e-02f,
  -8.96903947e-02f, 3.61041874e-02f, 3.86683457e-02f, 4.35190424e-02f, 2.90391240e-02f, -2.67649652e-03f, -1.79550480e-02f, -6.63876068e-03f, -7.67695382e-02f, 1.00323698e-02f,
  -4.33867835e-02f, -4.18269262e-02f, 5.65555086e-03f, -3.43371704e-02f, 7.07062557e-02f, 6.96007237e-02f, 9.41497460e-02f, 1.53006369e-03f, -8.32011029e-02f, 1.40303954e-01f,
  8.75688866e-02f, -1.41454756e-01f, 4.03631516e-02f, -1.24398388e-01f, -9.61906537e-02f, 1.41207784e-01f, 3.89458006e-03f, -7.05074985e-03f, 2.90682800e-02f, 2.35257426e-06f,
  -6.89976364e-02f, -3.15515511e-02f, -1.24363629e-02f, 1.13180075e-02f, -1.53807670e-01f, 2.22093668e-02f, -2.58182734e-01f, -1.41769722e-01f, -1.42472580e-01f, 3.52564789e-02f,
  -1.21204056e-01f, -2.37378538e-01f, -4.20413733e-01f, -2.50850767e-01f, -6.49420395e-02f, -2.46138185e-01f, -1.82702631e-01f, 1.49755357e-02f, -3.08902472e-01f, -2.69571006e-01f,
  -2.70489067e-01f, 8.66714269e-02f, 1.33015454e-01f, 3.33653688e-01f, 3.29417706e-01f, -1.30006641e-01f, -4.72528487e-01f, -2.53174394e-01f, 3.58189732e-01f, 1.74692601e-01f,
  8.10470283e-02f, 9.97692943e-02f, 2.39568666e-01f, -1.59670874e-01f, -4.93626505e-01f, 1.10219285e-01f, 3.13374579e-01f, -2.69415200e-01f, -6.34028494e-01f, -6.64439857e-01f,
  -1.80681810e-01f, 5.76967467e-03f, -2.50971794e-01f, -8.48637372e-02f, 4.26323980e-01f, 1.02133401e-01f, 4.01779741e-01f, 2.22464263e-01f, -3.55098099e-02f, 3.57697994e-01f,
  -1.40368327e-01f, -1.58850089e-01f, -1.77512929e-01f, 1.61957163e-02f, 2.19805732e-01f, -2.28083566e-01f, -1.54065236e-01f, 9.69768688e-02f, 3.06984577e-02f, -1.04007863e-01f,
  9.66826512e-04f, -2.57723004e-01f, 1.10993817e-01f, -1.15740627e-01f, -6.29753023e-02f, -2.63365895e-01f, -9.77186039e-02f, -2.95188904e-01f, -1.10581458e-01f, -3.49958509e-01f,
  -5.30470572e-02f, -2.24768110e-02f, 1.35426903e-02f, -2.02894166e-01f, -1.24042526e-01f, -4.04044650e-02f, -1.40602753e-01f, -1.62403941e-01f, -1.89492032e-01f, -1.15944827e-02f,
  -5.37330322e-02f, -4.11809497e-02f, 2.55018324e-02f, 7.98036680e-02f, -2.06962670e-03f, 1.54489070e-01f, 1.09126069e-01f, -1.29718885e-01f, -2.57251263e-02f, 5.34007400e-02f,
  2.56266352e-02f, 1.26677500e-02f, -2.36354992e-02f, 3.85564230e-02f, 3.71392840e-03f, -7.65319094e-02f, -1.21067964e-01f, -1.29037648e-01f, 6.07896922e-03f, -1.49920017e-01f,
  -3.33707780e-02f, -9.01312102e-03f, 1.63682491e-01f, -9.89194736e-02f, -2.51333043e-02f, -1.09546147e-01f, -9.21598449e-02f, -1.87626421e-01f, -8.89455155e-02f, -9.96778905e-02f,
  1.42240331e-01f, -2.30182678e-01f, 2.95748040e-02f, -2.38653064e-01f, 9.85048115e-02f, 1.25590622e-01f, 5.25459647e-02f, -3.63227092e-02f, 2.33774722e-01f, -1.52026162e-01f,
  -3.62187177e-01f, -1.89300314e-01f, 2.31480747e-01f, -6.11226708e-02f, -2.39040017e-01f, -1.58307087e-02f, 4.08047661e-02f, 4.26364727e-02f, -9.52188745e-02f, 7.79366493e-02f,
  2.56884098e-01f, -2.81487465e-01f, -1.05937943e-01f, 1.38595011e-02f, 1.55277625e-01f, -1.04312822e-01f, -1.43674359e-01f, -1.90191656e-01f, -2.62473792e-01f, -1.54428333e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 40)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 40;
const float L0_fan_Bp_bar_data[] = {
  4.34768289e-01f, 4.41263705e-01f, 2.95498610e-01f, 3.13525945e-01f, 8.21987331e-01f, 5.35430193e-01f, 7.61003017e-01f, 2.33992279e-01f, 5.87428451e-01f, 5.23852050e-01f,
  3.85639191e-01f, 4.94293481e-01f, 4.15129423e-01f, 4.93369848e-01f, 6.95291638e-01f, 2.47518852e-01f, 5.41186929e-01f, 3.05726200e-01f, 1.02322347e-01f, 2.86428452e-01f,
  3.09590340e-01f, 5.50476789e-01f, 3.03800166e-01f, 6.49228036e-01f, 4.98426586e-01f, 7.47826457e-01f, 5.28411567e-01f, 2.58613229e-01f, 5.17476261e-01f, 4.13587511e-01f,
  4.40453410e-01f, 2.93810159e-01f, 5.18767834e-01f, 5.70700765e-01f, 4.19398338e-01f, 4.34596777e-01f, 7.69064963e-01f, 5.88449657e-01f, 1.69440359e-01f, 2.91892648e-01f
};

// L1_linear_W (Shape: 12 x 64)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 64;
const float L1_linear_W_data[] = {
  -7.42270127e-02f, -1.02040745e-01f, 5.91981262e-02f, 1.91129208e-01f, -2.40240172e-01f, -2.73532957e-01f, -4.13999617e-01f, -2.83175334e-02f, -1.73689082e-01f, -8.02955180e-02f,
  -8.96729007e-02f, 2.47518383e-02f, -1.92651048e-01f, 4.82996777e-02f, 5.18345796e-02f, 2.84757372e-03f, -1.03274956e-01f, -3.32666487e-01f, 8.93290062e-03f, 2.32430696e-01f,
  -2.19462752e-01f, 4.59182449e-02f, -9.70226713e-03f, -1.60436898e-01f, 3.60042214e-01f, -1.53547570e-01f, -3.07322204e-01f, -1.88200220e-01f, 4.23549175e-01f, -8.90802026e-01f,
  -9.85746920e-01f, 7.10478723e-01f, -4.00531888e-01f, -5.28823972e-01f, 2.23884761e-01f, -1.95683017e-01f, 2.23393112e-01f, -2.34462842e-01f, -2.57741779e-01f, 4.33311373e-01f,
  2.85179436e-01f, 3.51990283e-01f, 2.23599389e-01f, 4.32900012e-01f, -8.45475614e-01f, -1.03908896e-01f, 2.65794635e-01f, -6.36235356e-01f, -3.77360284e-01f, -2.47222647e-01f,
  -6.33925378e-01f, 1.25181377e-01f, -1.46976277e-01f, 4.70047235e-01f, -6.56078219e-01f, -8.54846656e-01f, 1.75585464e-01f, 2.98569668e-02f, -4.40497577e-01f, -2.60167658e-01f,
  -5.14734209e-01f, -4.16451156e-01f, 2.42577270e-01f, -9.68338847e-01f, -1.71687305e-01f, 6.10629059e-02f, -9.07819793e-02f, 6.22095279e-02f, -3.46776769e-02f, -8.70710821e-04f,
  1.85279641e-02f, 7.71242827e-02f, -6.15405999e-02f, -2.29497366e-02f, -3.47337462e-02f, -6.97059417e-03f, -2.89859027e-01f, -1.17133699e-01f, -1.15435727e-01f, -1.22828498e-01f,
  -2.42675409e-01f, -2.07520187e-01f, -8.08813125e-02f, -1.44558102e-01f, 3.95271838e-01f, 1.46787614e-01f, -1.51825510e-02f, -2.21090198e-01f, 7.87240624e-01f, 2.91684210e-01f,
  2.07508519e-01f, 3.30824494e-01f, -7.02660382e-01f, -9.00130749e-01f, -6.09130144e-01f, -3.76888841e-01f, 5.51940382e-01f, -2.52258420e-01f, 3.68320554e-01f, -1.38427347e-01f,
  5.85075080e-01f, -5.94256878e-01f, 1.89760730e-01f, -7.80196786e-01f, 4.13981259e-01f, 2.38724485e-01f, -6.23832047e-02f, -2.19574928e-01f, -5.21179676e-01f, -6.20983839e-01f,
  2.42022034e-02f, -3.52975801e-02f, -6.00037217e-01f, 7.87712634e-01f, 2.01960020e-02f, -6.38862193e-01f, 6.07701242e-01f, 2.25756481e-01f, -1.97183296e-01f, 4.56382804e-05f,
  -4.51610386e-01f, -3.32304388e-01f, -9.13252532e-02f, -1.18076559e-02f, -1.30905414e+00f, -7.89802313e-01f, -6.50923729e-01f, -4.38546866e-01f, 6.40076175e-02f, 2.81978473e-02f,
  -2.91083264e-03f, 1.11959286e-01f, -5.98177966e-03f, 6.84751794e-02f, 6.64589182e-02f, -3.15641612e-02f, -1.57948345e-01f, 1.08197995e-01f, 2.00881865e-02f, 6.86238259e-02f,
  -1.20658018e-01f, -2.34962359e-01f, -3.14266711e-01f, -5.72997332e-02f, -6.29777461e-02f, -2.20159009e-01f, -3.83307599e-03f, 3.04307699e-01f, 3.52068454e-01f, 1.25002354e-01f,
  -2.63343245e-01f, -1.08550690e-01f, 7.10856080e-01f, 3.17295283e-01f, -2.89138973e-01f, -5.09213448e-01f, -5.06416298e-02f, 2.74666309e-01f, 1.44469216e-01f, 8.61662254e-02f,
  -6.20921791e-01f, -2.79823989e-01f, 3.04368019e-01f, -3.96865308e-01f, -6.31256342e-01f, -2.05009818e-01f, -9.82484370e-02f, -5.55706143e-01f, -3.78719538e-01f, -7.39944041e-01f,
  1.61851138e-01f, 5.14080822e-01f, -3.52520734e-01f, 2.22650960e-01f, -3.89704913e-01f, -2.99653858e-01f, 1.26595110e-01f, 4.24614757e-01f, -2.70714134e-01f, 3.89802493e-02f,
  3.03625944e-03f, 8.33078563e-01f, 5.85152268e-01f, -4.49733436e-01f, -3.62288862e-01f, -4.97005284e-01f, -2.44226679e-01f, -6.24881446e-01f, 5.06642759e-01f, -3.45277518e-01f,
  -2.36216113e-01f, 5.71789294e-02f, 1.26932666e-01f, 5.68452142e-02f, -1.70597151e-01f, -5.25017455e-02f, 1.13898337e-01f, -1.51814669e-01f, 7.10211918e-02f, -7.27776289e-02f,
  -1.43542290e-01f, 1.33959725e-01f, -2.80551851e-01f, 4.14288491e-02f, 5.02624273e-01f, -2.48246808e-02f, 1.68124467e-01f, 7.58075565e-02f, 9.97225270e-02f, 3.04232359e-01f,
  -6.74463958e-02f, 2.04177290e-01f, -2.18600169e-01f, 1.52752042e-01f, -2.62164980e-01f, 7.25771263e-02f, 2.58077264e-01f, -2.22989649e-01f, -2.56455600e-01f, -3.16480666e-01f,
  4.42009062e-01f, -1.55733868e-01f, -4.27503556e-01f, -4.79803264e-01f, -7.77430594e-01f, 3.69886696e-01f, -3.56316954e-01f, 2.24279702e-01f, -2.28822768e-01f, 8.34105790e-01f,
  -6.78346694e-01f, 2.09858537e-01f, -1.04176387e-01f, -8.48833323e-01f, -5.78966439e-01f, -4.23323423e-01f, 5.55133522e-01f, -6.07589424e-01f, 2.38449778e-02f, 6.05772138e-01f,
  -1.02898538e+00f, -6.33106828e-01f, -4.90944207e-01f, 6.10857785e-01f, -2.52771318e-01f, 1.65304959e-01f, 8.83188605e-01f, -4.54498231e-01f, 2.79622585e-01f, -2.30458274e-01f,
  -2.39448056e-01f, -3.53567421e-01f, -5.02335429e-01f, 5.20025849e-01f, -7.62016512e-03f, -4.55446303e-01f, 3.76841053e-02f, -2.23289039e-02f, -1.37913480e-01f, -1.67578742e-01f,
  5.07578216e-02f, 5.26407622e-02f, -9.57739204e-02f, 2.19324697e-02f, -3.25408541e-02f, -2.09840164e-01f, -9.79710091e-03f, 9.48238466e-03f, 2.63363004e-01f, 5.96886910e-02f,
  1.08245544e-01f, 1.45161718e-01f, -1.93616033e-01f, 4.19519767e-02f, -2.98592269e-01f, -2.76082069e-01f, -1.05217442e-01f, -1.80082694e-02f, -2.89167538e-02f, -3.32416780e-02f,
  -3.30639869e-01f, -1.49799632e-02f, -4.37965840e-01f, -5.16247153e-01f, -9.86383319e-01f, 5.43296516e-01f, -3.68153661e-01f, -7.96403587e-01f, -7.76932061e-01f, -4.01769519e-01f,
  -2.66671926e-01f, 3.41966212e-01f, -2.30317377e-02f, -7.22282767e-01f, 1.80472180e-01f, 1.41894743e-01f, -5.44736207e-01f, 2.43379444e-01f, 2.46992931e-02f, 1.13517530e-01f,
  3.10198307e-01f, 1.55657962e-01f, 1.45362675e-01f, 1.66494802e-01f, 4.16933596e-01f, -5.80485940e-01f, -1.68226883e-01f, -4.41182107e-02f, -3.84160370e-01f, 1.17898651e-03f,
  -3.69590759e-01f, 2.39933103e-01f, -1.98035568e-01f, 1.21157162e-01f, -2.55677432e-01f, -1.72806326e-02f, -2.28571773e-01f, 3.92926931e-01f, 3.63104790e-01f, 8.63437235e-01f,
  1.54247805e-01f, -5.29382564e-02f, 1.37185112e-01f, 2.26372927e-01f, 1.08565979e-01f, 3.42121840e-01f, 1.41558737e-01f, -1.90350682e-01f, 1.51524842e-01f, 1.23562351e-01f,
  -1.43100053e-01f, 5.66845620e-03f, -2.88206935e-01f, -2.11869791e-01f, -2.14065298e-01f, 6.77888393e-02f, 3.59388627e-02f, -7.66425356e-02f, -1.74552470e-01f, -3.60334843e-01f,
  4.89296801e-02f, 2.11062767e-02f, 2.81536549e-01f, 1.96073055e-01f, -5.38636625e-01f, -5.28897941e-01f, 3.05217970e-02f, -2.25879669e-01f, -9.72663909e-02f, -5.65493286e-01f,
  6.22065701e-02f, 1.19230457e-01f, 8.50165069e-01f, 6.27762377e-02f, -2.27760330e-01f, -7.33714327e-02f, 2.63568908e-01f, 6.44251108e-01f, 6.70667350e-01f, -7.76400045e-02f,
  -6.44921139e-02f, 5.48349082e-01f, 4.37139831e-02f, 8.78032390e-03f, -9.16832089e-01f, -2.27033392e-01f, 1.37133285e-01f, -3.59734207e-01f, -3.76524478e-01f, -1.02515423e+00f,
  -4.12872791e-01f, -7.01669514e-01f, -4.70212638e-01f, -1.06204438e+00f, -7.28793919e-01f, 7.75577947e-02f, 6.02954030e-01f, 6.44803345e-01f, -3.69220346e-01f, -3.20935398e-01f,
  6.60527110e-01f, -2.45673850e-01f, -1.17014997e-01f, -5.35931066e-02f, -9.46369395e-02f, -2.43339106e-01f, 2.41511986e-01f, 9.20603648e-02f, 1.99653894e-01f, -1.19889155e-01f,
  9.12485495e-02f, -9.44217741e-02f, 8.51824358e-02f, -5.68661420e-03f, 3.91116971e-03f, 8.41788296e-03f, 1.49189815e-01f, -3.23289484e-01f, -1.79466799e-01f, -1.17544584e-01f,
  1.45605922e-01f, -5.11529028e-01f, -1.51167540e-02f, 3.58048856e-01f, 2.72576690e-01f, -3.51353556e-01f, 2.12972671e-01f, -1.56031713e-01f, -2.34106079e-01f, -5.48389614e-01f,
  -3.30254793e-01f, 3.12744230e-01f, -2.19053298e-01f, 3.99829149e-01f, -1.15021698e-01f, -2.13174075e-01f, -3.78753915e-02f, -6.42144918e-01f, -2.50288337e-01f, -1.13930911e-01f,
  -4.23581183e-01f, -3.39464635e-01f, 7.48463944e-02f, -5.02456307e-01f, -1.63906679e-01f, -6.98206961e-01f, 9.23139676e-02f, -9.87240851e-01f, -3.74932915e-01f, -4.14324731e-01f,
  -6.20895684e-01f, -3.92713159e-01f, 8.03176522e-01f, -6.06353223e-01f, 5.77796102e-01f, -3.01158696e-01f, 2.94179648e-01f, -3.86076927e-01f, -5.25356114e-01f, 1.83876529e-01f,
  -7.73908019e-01f, -3.85648787e-01f, -2.96076387e-01f, -5.55045724e-01f, 8.38445306e-01f, 4.56232846e-01f, 2.07942538e-02f, -3.73940825e-01f, -1.50252983e-01f, -1.72620848e-01f,
  -4.65233810e-02f, -2.27869928e-01f, -3.82737458e-01f, -2.33279869e-01f, -3.86977829e-02f, 3.54462005e-02f, -7.00293109e-02f, -5.86099876e-03f, 7.48082399e-02f, 8.16919431e-02f,
  1.75211757e-01f, 1.48161137e-02f, 1.86872244e-01f, 6.02786765e-02f, 2.14801341e-01f, 7.14600012e-02f, 1.39739931e-01f, -1.82703033e-01f, 1.82469770e-01f, -9.42484289e-03f,
  -1.51715115e-01f, 7.85218999e-02f, -4.25737321e-01f, -5.43166660e-02f, 1.62373460e-03f, -1.22856483e-01f, 5.04173577e-01f, 1.14284776e-01f, -2.01722920e-01f, -1.72888070e-01f,
  -1.75298288e-01f, -2.04643980e-01f, -2.37900645e-01f, -3.79263312e-01f, -1.24181397e-01f, -2.74437308e-01f, -5.55265844e-01f, -3.29595447e-01f, -4.68401939e-01f, -1.37722313e-01f,
  -8.71666670e-02f, 1.61363661e-01f, 5.85710227e-01f, -4.84761864e-01f, -4.71197635e-01f, 2.89436191e-01f, -2.60163695e-01f, -4.13246065e-01f, -4.38667089e-01f, 6.33190393e-01f,
  -6.92319870e-01f, -1.71969235e-01f, -1.11501545e-01f, 2.82482952e-01f, 8.02708447e-01f, -4.33962077e-01f, -5.32429516e-01f, 3.88025701e-01f, -4.63115841e-01f, -3.96738559e-01f,
  -3.21924448e-01f, 5.38021564e-01f, 1.88407853e-01f, 9.47646573e-02f, 1.20830782e-01f, -3.52036297e-01f, 1.94337502e-01f, 2.33156696e-01f, -2.69811481e-01f, 1.82210401e-01f,
  3.28898877e-01f, -4.28344011e-02f, 9.61103886e-02f, 9.43400785e-02f, -2.21710116e-01f, 1.54608309e-01f, -3.76048416e-01f, -1.04197018e-01f, -6.90247789e-02f, 7.04871118e-02f,
  3.77518535e-01f, -1.58738181e-01f, -2.28477016e-01f, -3.38146269e-01f, 2.71742046e-01f, -2.16706889e-03f, -3.52292448e-01f, 2.06803858e-01f, -2.36348704e-01f, -2.12831423e-01f,
  7.72237957e-01f, -1.21078715e-01f, 8.08162510e-01f, -1.32777244e-01f, -9.26069021e-01f, 4.14564133e-01f, 3.89919281e-01f, -7.52657056e-01f, -2.95983076e-01f, 4.44940656e-01f,
  1.21835815e-02f, -3.01010758e-01f, 6.92599356e-01f, -3.73618752e-01f, -5.39848804e-01f, -2.71477759e-01f, -1.04573674e-01f, -2.20191538e-01f, -5.38716018e-01f, -5.90950310e-01f,
  -3.11274469e-01f, -1.48343459e-01f, 1.95790574e-01f, -5.77470243e-01f, -1.73299775e-01f, -2.66929716e-01f, -1.09015115e-01f, 1.89416856e-02f, -2.38253418e-02f, -5.51659584e-01f,
  1.71821341e-01f, 3.55740428e-01f, 1.09073728e-01f, -4.48831201e-01f, -2.12737113e-01f, -1.48188278e-01f, -1.04719914e-01f, 1.66677624e-01f, -1.15046464e-02f, -2.45046720e-01f,
  5.83799146e-02f, -2.01645698e-02f, 3.96870263e-02f, 5.11715263e-02f, -2.96404716e-02f, 1.03704199e-01f, -5.11285104e-02f, -1.76738337e-01f, 5.80410138e-02f, -2.14723516e-02f,
  1.11384392e-01f, 3.00180763e-01f, -1.96428940e-01f, -2.45102748e-01f, -1.13174766e-02f, 1.35301039e-01f, 9.08092931e-02f, 9.27800387e-02f, -2.73345798e-01f, -2.83692271e-01f,
  -8.06709111e-01f, 2.23502666e-01f, -3.97315979e-01f, 3.95694047e-01f, -6.36400282e-01f, 5.65667033e-01f, 2.74113476e-01f, 6.58511102e-01f, 4.55748200e-01f, 5.48620224e-02f,
  -1.30706102e-01f, -8.43433082e-01f, -2.99540967e-01f, -1.96823969e-01f, -8.21740448e-01f, 5.47147274e-01f, -4.23693776e-01f, 2.22186565e-01f, 2.14131758e-01f, 7.28676796e-01f,
  4.91844863e-01f, 2.04047456e-01f, -4.29584473e-01f, 2.35626414e-01f, 8.33727941e-02f, -2.14375272e-01f, 2.80394077e-01f, -5.60071170e-01f, -5.58861613e-01f, -9.34126556e-01f,
  1.32148802e-01f, -6.43673420e-01f, -5.28475642e-01f, -4.95196939e-01f, 8.09267461e-02f, 1.23238452e-01f, -9.97115821e-02f, -8.44559491e-01f, 3.67650807e-01f, 3.99406999e-01f,
  1.03920832e-01f, -9.66103598e-02f, 1.68620706e-01f, 2.08244294e-01f, -7.69208372e-02f, 6.22799015e-03f, 6.33848161e-02f, 2.69592144e-02f, 2.85562187e-01f, 5.62985577e-02f,
  1.35334477e-01f, 1.60813898e-01f, 3.56438696e-01f, 3.21302563e-01f, -9.11129266e-02f, -2.35838234e-01f, -2.13666499e-01f, 3.98966640e-01f, 2.68347979e-01f, 2.35042155e-01f,
  2.82897264e-01f, 1.58913359e-01f, -2.43255198e-01f, -1.00583076e-01f, -7.25834250e-01f, -5.48876941e-01f, -2.01716423e-01f, 7.53426179e-02f, 4.57766771e-01f, -2.19250366e-01f,
  6.28722489e-01f, 6.11583404e-02f, -3.05493414e-01f, -1.00325413e-01f, -5.08055627e-01f, 6.63317144e-01f, -3.86785686e-01f, -3.58503401e-01f, -4.23624486e-01f, -3.90328735e-01f,
  2.20193088e-01f, -5.86758256e-01f, -3.66219372e-01f, -4.69232827e-01f, -1.47373587e-01f, 9.14475881e-03f, -4.49878275e-01f, 6.46698594e-01f, -3.41694564e-01f, 6.78024590e-01f,
  -3.30659896e-01f, -3.77587736e-01f, -2.87992179e-01f, -4.55662161e-01f, -2.34822065e-01f, -4.47174877e-01f, -7.23366514e-02f, 6.10203505e-01f, -2.46993005e-01f, 2.18065143e-01f,
  -4.16817218e-01f, -2.24046811e-01f, -3.53187740e-01f, -4.32392716e-01f, 3.06340367e-01f, -4.38210852e-02f, -4.33100946e-02f, 2.30916351e-01f, -2.35495344e-01f, -3.82474177e-02f,
  1.33164316e-01f, 9.96227935e-03f, -3.70032817e-01f, -2.97050364e-02f, 2.64199823e-02f, 7.87435547e-02f, -3.71282071e-01f, 7.01680705e-02f, 3.07054430e-01f, -1.76220015e-02f,
  3.03786844e-01f, 2.82160521e-01f, 3.16084586e-02f, -2.59426624e-01f, -3.69933575e-01f, -1.85849801e-01f, 3.56766313e-01f, 2.74603009e-01f, -2.12605149e-01f, -1.39073148e-01f,
  4.86535311e-01f, 1.13529779e-01f, -2.27340788e-01f, -4.23928261e-01f, -5.56985199e-01f, -6.49003506e-01f, -3.51749361e-01f, 3.43403339e-01f, -5.45192242e-01f, -3.57443959e-01f,
  1.17836341e-01f, 2.32777953e-01f, 6.12941422e-02f, -2.03708172e-01f, -2.97027707e-01f, -3.12265754e-01f, 5.97998640e-03f, -3.10993731e-01f, 1.54001728e-01f, 5.41886091e-01f,
  -3.75310540e-01f, -2.56509572e-01f, -3.58450055e-01f, -4.02745813e-01f, 2.37070531e-01f, 3.93708888e-03f, 5.78454435e-01f, -1.27354130e-01f, 6.71052396e-01f, -3.51506114e-01f,
  -4.58615452e-01f, -2.93201298e-01f, 7.47685134e-01f, -2.06759274e-01f, -5.67374706e-01f, 9.41851914e-01f, -4.44049507e-01f, -2.34377429e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -1.88287094e-01f, -1.04381710e-04f, 3.05828601e-01f, -7.28383735e-02f, 2.71682329e-02f, 1.60401501e-02f, 3.57755199e-02f, 2.76151653e-02f, 8.94246250e-02f, -6.32422864e-02f,
  1.39463976e-01f, -4.97816354e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 12, 40
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        64, 12
    );
    }
    