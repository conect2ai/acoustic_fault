/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 19 x 120)
const int L0_fan_Wp_rows = 19;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  4.01185572e-01f, 4.04933579e-02f, 1.16656788e-01f, 2.55655706e-01f, -2.24336714e-01f, -1.02823913e-01f, -1.01490937e-01f, 3.90322953e-02f, -3.26682255e-02f, 2.16394469e-01f,
  -5.73915020e-02f, -1.73847765e-01f, -5.10893166e-02f, -2.02003077e-01f, -7.42531195e-02f, 1.23332113e-01f, 1.10524140e-01f, -4.59542125e-02f, -1.45413086e-01f, -1.80099174e-01f,
  -2.24853635e-01f, -5.68632968e-02f, 1.42152771e-01f, 6.18710294e-02f, 1.51639059e-01f, 1.17996350e-01f, 1.51399001e-01f, 7.44728372e-02f, -1.93430800e-02f, 2.00873122e-01f,
  3.37342262e-01f, 1.76492184e-01f, -1.55344367e-01f, -9.28870961e-02f, -2.31944094e-03f, 1.08714752e-01f, 6.83592036e-02f, 8.77683908e-02f, -6.67007221e-03f, 1.43052367e-02f,
  -9.03661773e-02f, -2.40869704e-03f, -3.02031171e-02f, -3.23483199e-02f, 8.90234932e-02f, 6.82312921e-02f, 6.29116446e-02f, 8.09186846e-02f, 5.99953718e-02f, -4.50310744e-02f,
  -7.57091567e-02f, -2.61100270e-02f, 1.07590951e-01f, 1.23812342e-02f, 1.74662601e-02f, 7.77666643e-02f, 8.24130997e-02f, 1.73751533e-01f, 2.25612596e-02f, 2.99064279e-01f,
  -8.20708200e-02f, 4.10930701e-02f, -2.67534368e-02f, 6.72290549e-02f, 5.93722612e-02f, 7.52114737e-03f, -3.02315666e-03f, -3.18080373e-02f, -6.17621727e-02f, 1.04349680e-01f,
  -4.66336422e-02f, 2.94415969e-02f, 6.57526180e-02f, 5.62809855e-02f, 1.21744201e-02f, 9.53000188e-02f, -5.78684323e-02f, 3.48011777e-02f, 1.65273976e-02f, 4.04206887e-02f,
  1.40206710e-01f, 1.61616895e-02f, 4.16724123e-02f, 1.61800422e-02f, 2.41112411e-02f, -2.76608691e-02f, 1.21672628e-02f, -3.31706777e-02f, 7.93265924e-02f, 1.27356678e-01f,
  1.06406853e-01f, -2.88393110e-01f, 1.58614695e-01f, 8.65989178e-02f, -3.86809092e-03f, -3.89980413e-02f, -2.16950923e-02f, -4.61281762e-02f, 3.02235447e-02f, 2.54907478e-02f,
  -7.33291805e-02f, -7.31674139e-04f, -9.94929206e-03f, -3.80553491e-02f, -1.06151685e-01f, -9.96564422e-03f, -1.37756169e-02f, -5.08873686e-02f, -7.28506371e-02f, 2.09146254e-02f,
  -6.07335381e-03f, 2.01019198e-02f, 8.63612667e-02f, 6.59045875e-02f, -8.59909058e-02f, 7.44552016e-02f, 1.12452460e-02f, 1.26545295e-01f, 8.22648779e-02f, 2.32082114e-01f,
  -1.83547009e-02f, -5.20240553e-02f, -2.24250168e-01f, -1.44109413e-01f, -4.25572321e-02f, -1.04164161e-01f, -1.26445413e-01f, 3.12164202e-02f, 4.01926711e-02f, 3.49763297e-02f,
  2.18208298e-01f, 4.98870343e-01f, 2.82822549e-01f, 2.81447113e-01f, 1.14024326e-01f, -1.80681631e-01f, -2.59354740e-01f, -3.41791287e-02f, 2.30017975e-01f, 3.09169382e-01f,
  2.66996324e-01f, -1.78813725e-03f, 1.42707363e-01f, 8.74296650e-02f, -6.46383613e-02f, 2.59564310e-01f, -1.05648972e-01f, 5.67568876e-02f, 1.24494411e-01f, -5.05071208e-02f,
  2.32748374e-01f, 3.04739717e-02f, 1.35501295e-01f, 1.52170464e-01f, 8.28550085e-02f, 2.20699027e-01f, 8.86751264e-02f, 7.66910687e-02f, 6.61566183e-02f, 1.79171134e-02f,
  1.95190515e-02f, 7.25383759e-02f, 6.36553094e-02f, 1.13322653e-01f, 6.72136024e-02f, 1.72659695e-01f, 9.88199003e-03f, 7.67095387e-02f, 1.25935599e-01f, 9.96889621e-02f,
  1.72248766e-01f, 4.45718430e-02f, 3.37211415e-02f, -5.30786812e-03f, 1.04633935e-01f, 9.63041633e-02f, 1.49996251e-01f, 1.06301144e-01f, 5.18022701e-02f, 3.95621583e-02f,
  -1.55741870e-01f, -8.65290165e-02f, -4.50318865e-02f, 7.28584453e-03f, -6.87259063e-02f, -4.42330614e-02f, -1.09478392e-01f, 1.16936648e-02f, -1.12835415e-01f, -9.92415696e-02f,
  1.57723203e-02f, -1.35530144e-01f, -2.49649193e-02f, -1.61830008e-01f, -5.28447516e-02f, -1.83232203e-01f, -6.77415403e-03f, -1.51032850e-01f, -7.18491822e-02f, -8.82783532e-02f,
  -5.03643490e-02f, -7.81695098e-02f, -1.32242173e-01f, -4.49644066e-02f, -1.52660403e-02f, -1.54609635e-01f, -6.32728636e-02f, -2.17512138e-02f, -1.00626111e-01f, -1.46278828e-01f,
  2.13405147e-01f, 1.35454074e-01f, 1.07114725e-01f, 8.23102370e-02f, 1.54635590e-03f, -5.95139340e-03f, 1.73905082e-02f, 1.11638367e-01f, 1.35080397e-01f, 8.11917260e-02f,
  1.61413535e-01f, 1.25762060e-01f, -2.37058345e-02f, 6.69420585e-02f, 1.10734105e-01f, 9.33853835e-02f, 1.47110801e-02f, 1.10058218e-01f, 5.14396019e-02f, 3.84358391e-02f,
  4.30765050e-03f, 2.28129104e-02f, 1.48990721e-01f, 1.99375853e-01f, 8.70539248e-02f, 1.29303366e-01f, 1.72512099e-01f, 1.40702724e-01f, 3.83066647e-02f, 1.02918081e-01f,
  -4.77940828e-01f, 4.46261078e-01f, 3.76145691e-01f, -1.96575940e-01f, 1.91992342e-01f, 3.47188115e-01f, 4.41351235e-01f, 1.50684863e-01f, -1.61624506e-01f, 1.23393513e-01f,
  1.27350777e-01f, -1.15185110e-02f, -4.71480675e-02f, 2.85148583e-02f, 1.97325036e-01f, 2.44564131e-01f, 2.97752976e-01f, 1.62586067e-02f, -2.80675218e-02f, -6.05278201e-02f,
  8.32790788e-03f, -1.96954384e-01f, -1.40162379e-01f, -6.36050254e-02f, 1.00970827e-01f, 2.13330388e-02f, 1.67937770e-01f, 6.68618381e-02f, 2.65229732e-01f, 2.04497203e-01f,
  3.18723954e-02f, 1.56729326e-01f, 7.44451359e-02f, -6.03852123e-02f, 1.06157348e-01f, 3.54406685e-02f, 8.22607800e-02f, 4.29360196e-02f, 6.56370595e-02f, 2.20435467e-02f,
  1.44383401e-01f, 4.77428064e-02f, 1.86355650e-01f, 1.20501406e-01f, 5.61314039e-02f, 1.26392856e-01f, 7.25840107e-02f, -6.22575218e-03f, 1.04131706e-01f, 5.94550185e-02f,
  1.61585972e-01f, 4.39525992e-02f, 8.69186595e-02f, 2.37427488e-01f, 7.39170611e-02f, 4.70369495e-02f, 1.28366724e-01f, 2.35189833e-02f, 1.03777550e-01f, -1.06606260e-02f,
  -1.23219527e-01f, -1.30046546e-01f, -6.86059743e-02f, -1.21013291e-01f, -9.14087445e-02f, -1.44056737e-01f, -1.21243060e-01f, -4.04665545e-02f, -1.15871817e-01f, -9.01454762e-02f,
  -1.22284234e-01f, -1.35344520e-01f, -8.02960619e-02f, -1.47702381e-01f, -9.99740213e-02f, -4.98603545e-02f, -1.09048449e-01f, -6.42425939e-02f, -1.00152783e-01f, -6.69215918e-02f,
  -1.17696464e-01f, -3.32529843e-02f, -1.56995326e-01f, -9.79574993e-02f, -1.42662879e-02f, -1.16380043e-01f, -7.87022635e-02f, -1.48013219e-01f, -1.07162982e-01f, -1.19726859e-01f,
  -2.82097220e-01f, 2.46686354e-01f, 3.16376500e-02f, 1.18858330e-01f, 1.40080899e-01f, 6.47226870e-02f, 1.13113649e-01f, 1.07162580e-01f, 1.75748408e-01f, 7.50899389e-02f,
  1.07928634e-01f, 3.12893502e-02f, 1.88949540e-01f, 1.34441659e-01f, 7.08327815e-02f, 3.60267945e-02f, 9.02809128e-02f, 6.33487776e-02f, 1.99393824e-01f, 6.56894967e-02f,
  9.98472124e-02f, 7.35461935e-02f, -5.61825931e-02f, 1.69577613e-01f, 1.26648694e-01f, -7.05694929e-02f, 8.25326294e-02f, 1.39652982e-01f, 6.34866431e-02f, -9.75640789e-02f,
  4.38690335e-02f, 3.65140498e-01f, 2.49687098e-02f, -9.34715942e-02f, -2.76799172e-01f, -2.16959476e-01f, 1.23419963e-01f, 1.44674303e-02f, -1.51167065e-01f, -3.62454206e-02f,
  -1.55345872e-01f, -3.74046654e-01f, -2.90600806e-01f, -2.50158101e-01f, 1.57480501e-02f, 1.61129832e-01f, 1.66940153e-01f, -2.05863804e-01f, -4.21749711e-01f, -4.00399297e-01f,
  -2.03047067e-01f, -1.71528175e-01f, -1.26661986e-01f, -1.31978527e-01f, -1.10112399e-01f, -2.27416024e-01f, 1.34945735e-01f, -3.03883608e-02f, 2.19145715e-02f, 1.21642925e-01f,
  -2.85823017e-01f, -5.18179126e-02f, -4.13754344e-01f, -1.63267821e-01f, -1.65136650e-01f, -1.38585046e-01f, -2.01330766e-01f, -2.82734066e-01f, -1.31322697e-01f, -1.94002971e-01f,
  -2.47159213e-01f, -1.35882035e-01f, -2.10428566e-01f, -1.31286263e-01f, -1.35863736e-01f, -2.09837347e-01f, -1.02770329e-01f, -4.41185571e-02f, -1.19526699e-01f, -8.38015899e-02f,
  -9.81774777e-02f, -9.61341113e-02f, -3.64775434e-02f, -1.74345225e-01f, -1.04809597e-01f, -3.25921506e-01f, -1.25691354e-01f, -1.97450086e-01f, -1.72994718e-01f, -1.37685567e-01f,
  6.60496578e-02f, 1.07521452e-01f, 1.48621693e-01f, 1.92259938e-01f, 1.78881481e-01f, 1.32809624e-01f, 9.53599066e-02f, 1.68007165e-01f, 8.38555470e-02f, 1.49814680e-01f,
  1.53467879e-01f, 1.32254466e-01f, 1.55068770e-01f, 1.64106414e-01f, 6.78533167e-02f, 1.08581394e-01f, 1.33229718e-01f, 1.56547174e-01f, 1.54395208e-01f, 1.25177905e-01f,
  1.46632329e-01f, 8.37233514e-02f, 1.43312499e-01f, 1.05540387e-01f, 1.46198526e-01f, 1.41622961e-01f, 1.97707683e-01f, 1.64427310e-01f, 6.42655045e-02f, 1.20221071e-01f,
  -2.19799191e-01f, -1.58877119e-01f, -2.44644210e-01f, -2.35917747e-01f, -2.48696908e-01f, -1.55600250e-01f, -1.58340439e-01f, -1.43782094e-01f, -2.28683546e-01f, -2.17021182e-01f,
  -1.39735103e-01f, -2.12541237e-01f, -1.62219763e-01f, -1.89001560e-01f, -2.62178838e-01f, -2.42666125e-01f, -6.36432916e-02f, -2.38590136e-01f, -2.05739141e-01f, -1.43672436e-01f,
  -1.09100126e-01f, -1.22139148e-01f, -2.00795546e-01f, -2.20457762e-01f, -1.91059366e-01f, -3.36199611e-01f, -1.68416679e-01f, -2.44703695e-01f, -2.03349307e-01f, -1.39775544e-01f,
  2.16075554e-01f, -8.43808949e-02f, -4.30226624e-01f, 1.18909642e-01f, 9.21801478e-02f, -8.07379559e-02f, -2.17047676e-01f, -4.33365591e-02f, 9.72455069e-02f, 1.09282240e-01f,
  2.96628505e-01f, 2.49841616e-01f, 7.07452521e-02f, -5.99413514e-02f, -1.87699750e-01f, -2.45962068e-01f, -2.23244324e-01f, -3.02328020e-01f, -1.84313640e-01f, -7.75920749e-02f,
  -1.78764239e-02f, -1.59989037e-02f, -4.10996936e-02f, -1.91278189e-01f, -1.61005348e-01f, -2.72328407e-02f, -2.11902618e-01f, -1.30789131e-01f, -1.70868367e-01f, -2.43061483e-01f,
  -1.25123277e-01f, 4.71043028e-02f, 8.62620864e-03f, 2.11908221e-01f, -8.24528572e-04f, 1.61253810e-02f, -4.89060432e-02f, -3.25056277e-02f, -5.85375801e-02f, -1.26246870e-01f,
  3.29575986e-02f, 7.54734501e-02f, -3.70798111e-02f, -6.30333424e-02f, -6.04963861e-02f, -6.66218922e-02f, -7.19691738e-02f, -2.39096746e-01f, -1.14151217e-01f, -1.02702141e-01f,
  1.58748671e-01f, 4.71970774e-02f, -7.73631260e-02f, -1.02668256e-01f, -2.49306872e-01f, -7.98405036e-02f, -2.19443500e-01f, -9.12186131e-02f, -1.83693260e-01f, -3.15018088e-01f,
  1.59923598e-01f, 1.47359911e-03f, -1.25223808e-02f, 2.26674993e-02f, 2.51247678e-02f, 6.88027637e-03f, 1.66196877e-03f, -3.59851643e-02f, -6.43201768e-02f, -3.19434404e-02f,
  -8.87155086e-02f, 1.54173505e-02f, -8.63577873e-02f, 2.11564847e-03f, -6.76808432e-02f, -8.15893933e-02f, -7.43186772e-02f, -1.05820566e-01f, 9.27676726e-03f, -8.80216435e-02f,
  -2.22777259e-02f, -1.25196323e-01f, -3.94610614e-02f, -1.08105965e-01f, -1.05176575e-01f, -9.71973613e-02f, -1.01212472e-01f, 1.74367372e-02f, 2.96695298e-03f, 3.03035993e-02f,
  -3.80154066e-02f, 4.23331559e-02f, -1.15684085e-02f, -1.57812156e-03f, 7.87987281e-03f, -4.61358167e-02f, 2.28901636e-02f, -6.19082414e-02f, 1.88654661e-02f, -1.10778436e-01f,
  -4.03090194e-02f, -8.01192150e-02f, -8.76015127e-02f, -5.71147799e-02f, -3.92491855e-02f, -6.68115988e-02f, 8.78842399e-02f, -4.00581062e-02f, 2.24911999e-02f, -3.89029011e-02f,
  -4.14335281e-02f, -2.93841120e-02f, -3.48922354e-03f, -1.11624762e-01f, -7.03311637e-02f, -4.00940739e-02f, -1.84890315e-01f, -1.43743530e-01f, -1.63225576e-01f, -2.43413925e-01f,
  -4.70677644e-01f, 3.43150169e-01f, 2.37994686e-01f, -1.47782281e-01f, 8.16331152e-03f, -6.12019002e-02f, 1.25299722e-01f, -1.01970285e-01f, -2.26302058e-01f, 1.98325571e-02f,
  8.62118155e-02f, -1.06262311e-01f, -3.09993457e-02f, -1.31295890e-01f, -5.08224219e-02f, 1.61697865e-01f, 2.24207237e-01f, -1.50510311e-01f, -2.81437486e-01f, -2.14056164e-01f,
  -1.15385547e-01f, 3.94562595e-02f, -1.19989179e-01f, -1.08521499e-01f, 8.39290842e-02f, -7.12105185e-02f, 1.77065372e-01f, 6.00195937e-02f, 1.61173061e-01f, 2.39078879e-01f,
  2.33753264e-01f, 8.31947997e-02f, -6.84069619e-02f, 4.18233722e-02f, 1.95950344e-01f, -8.38127509e-02f, 7.91859552e-02f, 1.14778645e-01f, 9.27146599e-02f, -1.69576481e-02f,
  1.05389424e-01f, -2.26544850e-02f, 3.65043804e-02f, 6.33114995e-03f, 5.77276051e-02f, -1.32559286e-02f, 5.64501584e-02f, 5.64592779e-02f, -8.80688727e-02f, 1.62926167e-02f,
  1.79879770e-01f, 1.28817216e-01f, 3.71241244e-04f, -4.07980904e-02f, 4.56626341e-03f, -6.19379319e-02f, 3.76281217e-02f, 5.66849597e-02f, -4.42466550e-02f, -2.56671757e-02f,
  -2.89268214e-02f, 2.47874390e-02f, -5.27722435e-03f, -2.69289911e-02f, -5.01923859e-02f, -5.57106500e-03f, 1.96167324e-02f, -2.94082146e-02f, -1.12103887e-01f, 1.65602732e-02f,
  -4.70172912e-02f, 6.46804227e-03f, -8.83165225e-02f, -1.06281396e-02f, -4.42245789e-03f, 6.37709815e-03f, -5.58710881e-02f, 1.87653601e-02f, 6.49411529e-02f, -4.04414088e-02f,
  5.09984009e-02f, -1.05248168e-01f, -3.70157845e-02f, -6.79785535e-02f, -4.65138145e-02f, 4.26041521e-03f, 2.70019043e-02f, 1.24354940e-02f, -1.02639263e-02f, -2.02386435e-02f,
  -5.21271154e-02f, 3.94960679e-02f, -3.35437283e-02f, -6.22873940e-02f, 1.23655818e-01f, 7.43844509e-02f, 3.63038331e-02f, 4.71577533e-02f, 7.47126043e-02f, 3.35230194e-02f,
  -1.51912356e-02f, -3.81976403e-02f, 6.44130781e-02f, 1.19169958e-01f, -4.59098369e-02f, -5.69339208e-02f, 1.31848380e-01f, 3.07426229e-02f, -1.91434976e-02f, 2.38223057e-02f,
  4.61181247e-04f, -8.10080767e-02f, -1.12880871e-01f, 3.16825509e-02f, 3.12953368e-02f, -8.68067220e-02f, -2.91273296e-02f, 3.45818996e-02f, -1.54530287e-01f, -2.24095583e-02f,
  -3.05563897e-01f, 8.00285861e-02f, -4.59748656e-02f, 5.62853701e-02f, 1.60583928e-01f, -4.74695340e-02f, -4.47244570e-02f, -1.33648410e-01f, 1.25873387e-01f, -1.45396143e-02f,
  8.76110513e-03f, -1.13411099e-01f, -4.95298058e-02f, -1.75042391e-01f, -3.79756629e-01f, 1.29060959e-02f, 7.93418214e-02f, -2.83419192e-01f, -2.42895931e-01f, -2.30379820e-01f,
  -8.39660168e-02f, -1.54037490e-01f, -3.02018404e-01f, -1.67993411e-01f, 9.37668756e-02f, -1.34526752e-02f, 8.82800445e-02f, 6.69608042e-02f, -8.09857547e-02f, 2.01224700e-01f,
  -6.39142692e-02f, -5.07390243e-04f, -1.80736825e-01f, -1.40275195e-01f, 6.61848038e-02f, -8.50352496e-02f, -1.18182354e-01f, 5.21783680e-02f, -2.27246024e-02f, 4.81904931e-02f,
  5.78593947e-02f, -9.50317159e-02f, -5.24280816e-02f, -4.96386886e-02f, 2.97298357e-02f, -7.97393024e-02f, -1.24125339e-01f, -1.64759547e-01f, -6.41588941e-02f, -6.70059025e-02f,
  -1.17168196e-01f, 3.44499461e-02f, -9.33781341e-02f, -6.77647591e-02f, -6.53882921e-02f, -1.50494725e-01f, -4.67456691e-02f, -7.53165632e-02f, -1.05366232e-02f, 5.76157719e-02f,
  -1.51755184e-01f, 4.11055386e-02f, 1.96800400e-02f, 3.72800007e-02f, 1.76252779e-02f, 1.14697173e-01f, 8.30455720e-02f, 3.20395781e-03f, -3.83408330e-02f, 1.20349459e-01f,
  7.07297027e-03f, 1.08679980e-01f, 9.73455086e-02f, 3.68545428e-02f, 8.44291225e-02f, 7.11530596e-02f, 7.81270191e-02f, 5.98375462e-02f, 7.97246993e-02f, 3.84310149e-02f,
  1.06563762e-01f, 7.56495371e-02f, 1.88190416e-01f, 2.41638012e-02f, 7.61483982e-02f, 1.18921928e-01f, 1.39496759e-01f, -4.17426340e-02f, -4.30961256e-04f, 1.34361312e-01f,
  6.15705885e-02f, -2.83494860e-01f, -1.07859196e-02f, -1.22915171e-02f, 1.68170743e-02f, -2.95971124e-03f, 3.01242787e-02f, 5.26086520e-03f, 3.21492851e-02f, -1.26931876e-01f,
  -1.24770373e-01f, -4.37472723e-02f, -1.42006101e-02f, 1.48945423e-02f, -7.71186128e-02f, -6.74162880e-02f, -4.71907817e-02f, 1.28081962e-02f, -2.92986557e-02f, 3.08072157e-02f,
  5.06874882e-02f, -3.01896781e-02f, -2.60332692e-02f, -1.28504001e-02f, -7.44690448e-02f, -1.25873193e-01f, -7.81000650e-04f, -6.35122582e-02f, -1.86659783e-01f, -1.65874895e-03f,
  4.38049912e-01f, 6.86603636e-02f, 2.17775792e-01f, -4.14726743e-03f, -2.06145123e-01f, -2.26816401e-01f, -1.42091781e-01f, -9.85662565e-02f, -1.52985126e-01f, -2.87832059e-02f,
  4.79063876e-02f, 3.11250202e-02f, 7.72071332e-02f, 4.73290905e-02f, 5.71509637e-02f, -5.61355911e-02f, -1.23677693e-01f, 1.68600753e-01f, 1.08223327e-01f, -8.44819695e-02f,
  -1.20679319e-01f, 1.90866273e-02f, 2.03462750e-01f, 1.17757237e-02f, 4.35887165e-02f, 9.81340557e-02f, 1.37402058e-01f, 1.55478895e-01f, 3.06722689e-02f, 2.48231575e-01f,
  2.77022123e-01f, 2.63620377e-01f, -6.54533058e-02f, -4.11075950e-02f, 6.30050749e-02f, 5.46264984e-02f, 2.41170861e-02f, -6.05077855e-03f, 1.78910140e-02f, 1.45379454e-02f,
  -3.50634642e-02f, 1.39055131e-02f, 8.33542496e-02f, -5.38473874e-02f, 4.06594798e-02f, -2.08263677e-02f, -1.07218988e-01f, 1.26764417e-01f, -3.54687832e-02f, -2.04124451e-02f,
  -9.75604430e-02f, 7.07628280e-02f, 6.00362085e-02f, -6.49188682e-02f, 4.88682799e-02f, 1.40733104e-02f, 1.01922080e-01f, 5.24057969e-02f, 1.21613100e-01f, 1.21400885e-01f,
  -6.80914372e-02f, -1.60321046e-03f, 1.32460548e-02f, -6.86407611e-02f, -2.03792248e-02f, -7.88310319e-02f, -1.94866378e-02f, 7.03928545e-02f, -5.45788147e-02f, 2.28976049e-02f,
  -4.52456176e-02f, 3.83393541e-02f, 9.73464735e-03f, 5.83881028e-02f, 6.65728049e-03f, 5.38747422e-02f, 2.57931300e-03f, 4.72440906e-02f, 6.33609220e-02f, 9.18660015e-02f,
  1.60017312e-02f, -1.31226974e-02f, 3.20446752e-02f, 8.42976123e-02f, -3.52589390e-03f, -1.88716371e-02f, -3.97776067e-02f, -6.46341816e-02f, -1.76802445e-02f, -2.91432682e-02f,
  -5.82780130e-02f, 8.17722678e-02f, 5.04488982e-02f, 7.54421949e-02f, -1.02933325e-01f, 1.20867835e-02f, 8.14417657e-03f, 7.08937198e-02f, 2.65477337e-02f, 5.57868928e-02f,
  7.68459588e-02f, 4.61313240e-02f, -3.96079235e-02f, -1.48437163e-02f, 2.00695656e-02f, -4.87719029e-02f, -5.81706613e-02f, 2.22447067e-02f, -5.42837009e-02f, 8.91197100e-03f,
  -9.81427506e-02f, -1.91640984e-02f, -2.20835190e-02f, -2.86111757e-02f, -5.46019971e-02f, -1.02028601e-01f, -4.70283292e-02f, 1.64021011e-02f, -3.18950526e-02f, -9.11174938e-02f,
  1.98216867e-02f, 1.98821142e-01f, -2.28486449e-01f, 2.65316933e-01f, 1.12466462e-01f, 6.11786395e-02f, 1.45798892e-01f, 1.87086999e-01f, 3.62912774e-01f, 2.64989793e-01f,
  3.02446336e-02f, 7.37977475e-02f, -4.83838618e-02f, 1.73373241e-03f, -1.20864093e-01f, 1.11374170e-01f, 1.79562956e-01f, -1.87157109e-01f, -5.01593351e-02f, 2.55341440e-01f,
  3.29065144e-01f, 2.64836639e-01f, 4.87022698e-02f, 2.77525216e-01f, 4.93674099e-01f, 2.33402476e-01f, 1.75492972e-01f, 2.00220242e-01f, 9.62797776e-02f, 4.42826003e-01f,
  6.45658653e-03f, 7.23713562e-02f, 1.30235910e-01f, 2.50512272e-01f, 1.10853538e-01f, 3.12722206e-01f, 2.31696427e-01f, 1.53575152e-01f, 1.34847760e-01f, 2.05649480e-01f,
  1.09740391e-01f, 1.78790450e-01f, 1.55686349e-01f, 1.86136127e-01f, 2.52207607e-01f, 2.41535217e-01f, 2.07788140e-01f, 7.42906407e-02f, 1.03082083e-01f, 1.82750419e-01f,
  1.65947378e-01f, 1.01159357e-01f, 2.85247490e-02f, 1.16584957e-01f, 2.38314986e-01f, 2.62968056e-02f, 1.48869470e-01f, 2.59379685e-01f, 5.31936884e-02f, 3.56518865e-01f,
  5.59796765e-02f, -1.46370545e-01f, -1.03554584e-01f, -1.04764752e-01f, -1.07498050e-01f, -1.22772090e-01f, -1.43634364e-01f, -1.71990797e-01f, -8.97199064e-02f, -1.65650964e-01f,
  -2.22168833e-01f, -1.27625525e-01f, -2.04609618e-01f, -8.97209197e-02f, -2.13523701e-01f, -1.78046405e-01f, -1.98140591e-01f, -1.64770856e-01f, -9.28209275e-02f, -1.72851816e-01f,
  -2.27767393e-01f, -2.29045317e-01f, -1.01664171e-01f, -1.77815199e-01f, -2.19795659e-01f, -1.53463513e-01f, -1.81752607e-01f, -1.05724677e-01f, -1.63528159e-01f, -2.24184081e-01f,
  3.03329974e-01f, -1.37125656e-01f, 1.85235247e-01f, 1.60913154e-01f, 2.37771258e-01f, 2.15246931e-01f, 1.69720694e-01f, 2.72924155e-01f, 1.72755197e-01f, 2.66017973e-01f,
  1.46381676e-01f, 1.03749469e-01f, 1.52016237e-01f, 2.68340677e-01f, 2.08999321e-01f, 2.18152687e-01f, 2.92675853e-01f, 2.08432943e-01f, 2.14913130e-01f, 3.51319849e-01f,
  3.30679774e-01f, 1.93194345e-01f, 8.75146389e-02f, 2.82041609e-01f, 2.50337571e-01f, 8.97776037e-02f, 1.28398582e-01f, 3.32294434e-01f, 3.00888475e-02f, 4.22326416e-01f,
  -3.93303394e-01f, -1.42981065e-02f, -2.82213420e-01f, 7.36968145e-02f, 1.91724166e-01f, 2.52895504e-01f, 2.76403189e-01f, 2.15905309e-01f, 1.88031346e-01f, 1.37234986e-01f,
  -8.12969655e-02f, 6.85632974e-02f, 2.04332564e-02f, 2.91466564e-02f, -1.24222435e-01f, 1.51160480e-02f, 2.36845370e-02f, -1.72903448e-01f, 6.07102271e-03f, 1.74192861e-01f,
  1.88303813e-01f, 2.03528985e-01f, -1.41525611e-01f, 3.95896938e-03f, 1.32332742e-01f, 1.63974106e-01f, 1.01949334e-01f, -4.79937717e-02f, 3.57047468e-02f, -8.33599865e-02f,
  -2.48314410e-01f, -2.34570995e-01f, 1.55119091e-01f, 7.81094329e-03f, 8.54695290e-02f, 3.62114236e-02f, 9.51302275e-02f, 3.97913568e-02f, -1.20347021e-02f, 4.66497317e-02f,
  4.90031615e-02f, 1.79530811e-02f, 1.55328040e-03f, -1.55620081e-02f, 7.50890449e-02f, 1.69925317e-02f, -6.26001805e-02f, -6.60986081e-02f, 2.03290042e-02f, -6.95343018e-02f,
  1.60972431e-01f, -4.77765985e-02f, -8.59574601e-02f, 1.18741937e-01f, -1.00354396e-01f, -6.09241389e-02f, 5.43321371e-02f, -3.72396340e-03f, -1.13240190e-01f, -6.68867826e-02f,
  -2.50228159e-02f, -1.12003140e-01f, -9.95547995e-02f, -9.33978781e-02f, -3.27140689e-02f, -1.15618818e-01f, -8.39505345e-02f, -1.18204139e-01f, -8.00129697e-02f, -4.68067639e-02f,
  -7.49309286e-02f, -9.45679843e-02f, -6.52944371e-02f, -6.85950890e-02f, -3.01683065e-03f, -7.85081089e-02f, -2.35840008e-02f, -1.10934474e-01f, -1.15534462e-01f, -1.15778990e-01f,
  -1.03780605e-01f, -5.27519137e-02f, -1.12744629e-01f, -1.14013813e-01f, -1.80052549e-01f, -1.11020520e-01f, -9.07259881e-02f, -1.01642394e-02f, -8.16383958e-03f, -4.95214015e-03f,
  3.39806348e-01f, -1.26477897e-01f, -2.54931748e-02f, 3.39628533e-02f, 2.09893528e-02f, 4.28969301e-02f, 1.79556310e-02f, 4.40234393e-02f, 5.82211092e-02f, 8.22198987e-02f,
  6.00271206e-03f, 1.24321021e-02f, 3.57566886e-02f, 1.36637241e-01f, 1.58009138e-02f, 5.91338575e-02f, 1.70197368e-01f, 1.41196232e-02f, -7.47309998e-03f, 8.74754041e-02f,
  1.77051455e-01f, 1.59618959e-01f, 7.61542320e-02f, 8.23378190e-02f, 7.02716336e-02f, 1.00153945e-01f, 4.40165885e-02f, 9.89135504e-02f, 1.13351330e-01f, 3.51962596e-01f,
  -2.50493854e-01f, 2.95770496e-01f, -5.13571262e-01f, -7.80107453e-03f, 6.63952529e-02f, -1.64159238e-01f, -1.70983329e-01f, -1.79318681e-01f, -5.50829154e-03f, 9.00581107e-02f,
  1.90071538e-01f, 2.26469100e-01f, 4.92667854e-02f, 5.38831577e-02f, -1.79853663e-01f, -2.06239030e-01f, -1.80897683e-01f, -4.76057470e-01f, -3.89294952e-01f, -1.04345910e-01f,
  2.01684609e-01f, -5.21648750e-02f, -1.11577354e-01f, -7.36408010e-02f, 1.70691207e-01f, 8.01684335e-02f, -6.14427552e-02f, -1.27210915e-01f, -1.05002679e-01f, -1.18081365e-02f,
  -1.92347437e-01f, -9.21209604e-02f, -7.53623396e-02f, 2.58548725e-02f, 5.91270365e-02f, -6.96744248e-02f, -9.80625078e-02f, -1.71017841e-01f, -4.65434603e-02f, -3.91689613e-02f,
  3.65294851e-02f, -1.27164740e-02f, 4.23528142e-02f, 1.58364475e-02f, -7.89355338e-02f, -1.39907718e-01f, -1.26162425e-01f, -1.55277759e-01f, -1.43107325e-01f, -1.07523076e-01f,
  7.83435032e-02f, -2.98020411e-02f, -1.77922398e-01f, -4.83743623e-02f, -1.29560262e-01f, -4.49186713e-02f, -1.23185873e-01f, -1.85922623e-01f, -1.28983110e-01f, -3.36216949e-02f,
  2.34259595e-03f, 7.54562318e-02f, -2.47774702e-02f, 3.66724581e-02f, 5.79515211e-02f, 4.69489768e-02f, 7.97160491e-02f, 3.60816047e-02f, 7.39860767e-03f, 5.49805798e-02f,
  7.29152411e-02f, -2.39595887e-03f, 8.38831291e-02f, -3.98739427e-02f, 1.00047529e-01f, 1.58170648e-02f, -4.41005826e-03f, 1.22711018e-01f, 5.99474646e-02f, 1.27635105e-02f,
  4.15771268e-02f, 2.20460799e-02f, 2.16643643e-02f, 3.40239555e-02f, -3.72055061e-02f, 3.78961116e-02f, -2.26035323e-02f, -3.15707102e-02f, 3.43027571e-03f, 2.04405040e-02f,
  1.63711011e-01f, -1.40882969e-01f, 3.57820769e-03f, -5.37765697e-02f, -6.61957264e-02f, 6.05698768e-03f, 9.79773328e-02f, -3.98974195e-02f, -7.49084726e-02f, -3.50468643e-02f,
  -2.11010687e-02f, -6.37502149e-02f, 1.14984447e-02f, -1.88600738e-02f, -1.11022238e-02f, 3.71288061e-02f, 8.64217803e-02f, -3.00388280e-02f, -6.61285892e-02f, -8.01364251e-04f,
  3.13060847e-03f, -9.45382714e-02f, -1.63772747e-01f, -9.11409780e-02f, -8.30378085e-02f, -7.76668116e-02f, -3.83157842e-02f, -1.09256161e-02f, -1.87880725e-01f, -1.89366657e-02f,
  2.21961826e-01f, -9.66250673e-02f, -1.05716772e-02f, -4.08237949e-02f, -1.92309827e-01f, -3.44166964e-01f, -5.18518329e-01f, -2.96440840e-01f, -6.34767190e-02f, -8.65493640e-02f,
  -8.04984197e-02f, 8.47130865e-02f, 1.30231410e-01f, 1.74819410e-03f, -5.36084548e-02f, -1.33697644e-01f, -1.33338317e-01f, 1.41919181e-01f, 1.03652194e-01f, -2.03119472e-01f,
  -1.93432823e-01f, -2.25502364e-02f, 1.19893342e-01f, -1.57575253e-02f, 6.43976480e-02f, 1.35768754e-02f, -3.12690139e-02f, 9.52652544e-02f, -5.07177003e-02f, 9.89481360e-02f,
  3.27439457e-01f, -1.75078183e-01f, -2.21507549e-01f, -2.27118302e-02f, -1.26091450e-01f, -8.58045444e-02f, -1.00456275e-01f, -9.89083499e-02f, -1.41231656e-01f, -1.87774807e-01f,
  -5.77485636e-02f, -1.19923763e-01f, -8.78586695e-02f, -5.38407937e-02f, -5.25955483e-02f, -9.97386873e-02f, -1.14445455e-01f, -1.45292245e-02f, -1.54309809e-01f, -6.66031018e-02f,
  -1.12459488e-01f, -8.98110569e-02f, -1.70721382e-01f, -2.76565224e-01f, -2.27006108e-01f, 1.55414678e-02f, -8.47957283e-02f, -1.71766400e-01f, -1.69200242e-01f, -8.93316790e-02f,
  -1.87052694e-06f, 9.25199464e-02f, 4.65963520e-02f, 3.09588630e-02f, 3.81905027e-02f, 7.59140775e-02f, 4.04365025e-02f, -4.31994051e-02f, 9.36121121e-03f, 1.41998976e-01f,
  8.62697363e-02f, 4.17946056e-02f, 5.42874122e-03f, 8.22342262e-02f, 9.44632441e-02f, 4.30859923e-02f, 7.54938573e-02f, 2.06397027e-02f, 7.83892572e-02f, 3.60147581e-02f,
  1.60326466e-01f, 5.66052906e-02f, 1.89240381e-01f, 7.94303715e-02f, 6.22180700e-02f, 1.05569124e-01f, 1.10813193e-01f, 1.21964335e-01f, -3.69801273e-04f, -6.43222183e-02f,
  1.90389156e-01f, -3.99918139e-01f, 7.04155490e-02f, -1.46143869e-01f, -8.40357244e-02f, -1.24745853e-01f, -1.35083109e-01f, -9.92344320e-02f, -1.20116599e-01f, -1.04048863e-01f,
  -2.37892002e-01f, -7.93148130e-02f, -8.83582756e-02f, -1.43258497e-01f, -9.34453011e-02f, -1.26126379e-01f, -8.51645172e-02f, -7.29791149e-02f, -1.78582609e-01f, -1.63362220e-01f,
  -1.07714474e-01f, -1.74666002e-01f, -7.33277425e-02f, -6.07330762e-02f, -2.19076008e-01f, 1.23096472e-02f, -9.78623927e-02f, -9.28244591e-02f, -8.80434811e-02f, -1.56834751e-01f,
  -3.31390232e-01f, -5.71598291e-01f, -2.82724611e-02f, -1.38831735e-01f, 2.57565523e-04f, -6.71365932e-02f, -1.97070032e-01f, -2.39052087e-01f, -1.16533630e-01f, 1.17371147e-02f,
  2.54887968e-01f, 3.12785655e-01f, 2.11636543e-01f, 1.82661399e-01f, -6.49160445e-02f, -1.85060248e-01f, -2.07155079e-01f, 1.74114972e-01f, 2.47533694e-01f, 2.17969567e-01f,
  2.81327870e-02f, -2.55003661e-01f, -1.56921774e-01f, -1.58630759e-01f, -1.09410837e-01f, 1.36393020e-02f, -2.34922007e-01f, -4.38385382e-02f, 1.16803594e-01f, 2.62409132e-02f,
  3.73688549e-01f, -1.47237062e-01f, 1.31551232e-02f, -3.89834456e-02f, 7.28635192e-02f, 4.49360423e-02f, 5.46365604e-02f, -1.76575854e-02f, 2.29845420e-02f, -2.24907976e-02f,
  3.32842469e-02f, 6.52975664e-02f, 6.85708225e-02f, 4.34353156e-03f, -3.86976870e-03f, -1.13749374e-02f, -1.95757851e-01f, -1.08879738e-01f, -1.40417647e-03f, 6.32263720e-02f,
  3.85521799e-02f, 8.41185078e-02f, -2.81681530e-02f, -1.22978449e-01f, -6.96899816e-02f, 1.33388847e-01f, -6.40120776e-03f, 1.53980013e-02f, 3.32609117e-02f, -2.07689241e-01f,
  -3.33617404e-02f, -5.67276031e-02f, 4.64281142e-02f, -7.83654898e-02f, 8.25012475e-02f, 1.02063194e-01f, 4.60732840e-02f, 6.09089853e-03f, 1.45004475e-02f, -3.45174931e-02f,
  5.02902791e-02f, 9.93869156e-02f, 1.67105235e-02f, 3.55638862e-02f, 1.17017873e-01f, -4.28402461e-02f, 4.31004986e-02f, 7.18466416e-02f, 1.38181031e-01f, 4.85608689e-02f,
  1.23673640e-01f, 9.54746231e-02f, 4.07898128e-02f, 1.50291799e-02f, 5.59419058e-02f, 4.78152186e-02f, 6.69858456e-02f, -2.33918671e-02f, 1.75147858e-02f, -5.97160459e-02f,
  -7.54736885e-02f, -3.41362059e-02f, 1.30456761e-01f, -7.87017941e-02f, -7.05757439e-02f, -7.35890418e-02f, -4.49109487e-02f, -3.73940244e-02f, 1.08916778e-02f, 4.43951711e-02f,
  2.96303350e-02f, 5.20066544e-02f, 1.33113954e-02f, 2.62612179e-02f, 1.04672676e-02f, 3.74993160e-02f, -3.96447070e-02f, 1.89275946e-02f, 2.47761160e-02f, -1.01744551e-02f,
  -9.81854349e-02f, -7.57647529e-02f, 1.14449270e-01f, -6.73773661e-02f, -4.72161248e-02f, 8.59647840e-02f, -4.59801964e-03f, -1.09976232e-02f, 2.64935810e-02f, -2.06204310e-01f,
  -2.14482367e-01f, -3.92838893e-03f, 1.95084810e-02f, 4.99877222e-02f, 1.36690915e-01f, 1.54041335e-01f, 1.67616293e-01f, 6.17870828e-03f, -9.50343683e-02f, 1.08715810e-01f,
  4.93775010e-02f, -7.76959732e-02f, 4.89425622e-02f, -3.08970101e-02f, 1.17024913e-01f, 6.05807342e-02f, 7.11770505e-02f, -3.23432405e-03f, -1.83840282e-02f, 1.25420257e-01f,
  6.39873147e-02f, 4.33339961e-02f, -1.52659905e-03f, 2.05000211e-02f, -1.40297577e-01f, -8.81862640e-02f, -6.38296083e-02f, -6.57689348e-02f, -7.38043934e-02f, -4.19513248e-02f,
  1.42523814e-02f, -6.76070303e-02f, -1.11406319e-01f, -1.74126804e-01f, -8.32147896e-02f, -2.49218255e-01f, -9.99886319e-02f, -2.06015781e-01f, -2.35671416e-01f, -1.20891266e-01f,
  -6.57789931e-02f, -5.09808771e-02f, -1.44926056e-01f, -2.39140287e-01f, -1.36462554e-01f, -1.59735769e-01f, -5.34321666e-02f, -1.15108594e-01f, -4.97690104e-02f, -8.24171305e-02f,
  -1.66134506e-01f, -1.48435116e-01f, -1.76768437e-01f, -1.53050810e-01f, -1.44145295e-01f, -2.32605085e-01f, -1.62206829e-01f, -1.70518160e-01f, -1.32011428e-01f, -2.25372121e-01f,
  1.33177668e-01f, -4.25819540e-03f, 1.46769837e-01f, 4.97732349e-02f, 1.39475867e-01f, 7.93156475e-02f, 1.13242432e-01f, 1.03718139e-01f, 7.16102198e-02f, 2.20826007e-02f,
  1.19888954e-01f, 1.83842137e-01f, 5.83306067e-02f, 1.78087354e-02f, 5.17379045e-02f, 4.69199046e-02f, 6.15413152e-02f, 7.38695785e-02f, -4.26063016e-02f, 1.34169549e-01f,
  5.95434904e-02f, 8.25090408e-02f, 4.19111252e-02f, 1.32102937e-01f, 7.14386925e-02f, 5.37356175e-02f, 8.19602460e-02f, 5.88762760e-02f, 5.48839718e-02f, 8.63025561e-02f,
  -1.12143740e-01f, -8.66470933e-02f, -2.46940866e-01f, -2.33852625e-01f, -1.56665415e-01f, -1.21582188e-01f, -2.14663982e-01f, -1.52875796e-01f, -1.24449939e-01f, -1.70428514e-01f,
  -1.35651782e-01f, -1.51947081e-01f, -8.09196234e-02f, -2.04532728e-01f, -1.80280894e-01f, -1.18495539e-01f, -4.18340452e-02f, -8.40869173e-02f, -1.05756491e-01f, -7.34505653e-02f,
  -7.43286535e-02f, -2.11862803e-01f, -1.66505098e-01f, -1.40184566e-01f, -1.31081149e-01f, -1.96260139e-01f, -2.01916054e-01f, -2.37644643e-01f, -1.70959920e-01f, -2.29952320e-01f,
  -4.89421844e-01f, 1.03106201e-01f, 2.13576898e-01f, -1.44191831e-01f, 2.63175458e-01f, 1.59889057e-01f, 2.75795728e-01f, -9.80238244e-02f, -1.19870082e-01f, -1.30645961e-01f,
  1.07529918e-02f, -2.40293130e-01f, -2.95151383e-01f, -3.84804726e-01f, -3.63717705e-01f, 3.51865292e-02f, 3.35083194e-02f, -2.08432332e-01f, -2.68151134e-01f, -6.05369620e-02f,
  -1.52118117e-01f, -1.70322821e-01f, -2.19352812e-01f, -2.30965286e-01f, -2.72030700e-02f, -9.15563107e-02f, -2.74663400e-02f, 1.12126693e-01f, 6.87979683e-02f, 8.15812498e-03f,
  1.13801964e-01f, 1.71328895e-02f, -2.76409239e-01f, -2.48023242e-01f, -4.05894779e-02f, -2.02592984e-01f, -1.55470088e-01f, -1.43517658e-01f, -1.64613664e-01f, -1.34510502e-01f,
  -3.31122354e-02f, -1.64774552e-01f, -5.75592406e-02f, -1.39916480e-01f, -7.94800594e-02f, -1.99174911e-01f, -2.03453705e-01f, -1.95714742e-01f, -2.57212430e-01f, -1.75332412e-01f,
  -5.48329167e-02f, 6.02380745e-03f, -8.40438157e-02f, -2.00962633e-01f, -1.64398134e-01f, -1.59742892e-01f, -6.99182674e-02f, -1.50433257e-01f, -1.15397111e-01f, -1.73418254e-01f,
  3.48983742e-02f, 2.19236657e-01f, 1.18379436e-01f, 1.29005209e-01f, 9.88555327e-02f, 1.75939381e-01f, 1.16413765e-01f, 9.02729779e-02f, 1.51337802e-01f, 1.04385234e-01f,
  1.19176976e-01f, 5.78137487e-02f, 1.02397271e-01f, 1.07604153e-01f, 1.40385136e-01f, 1.36678278e-01f, 1.71443790e-01f, 2.92536095e-02f, 1.45866171e-01f, 1.24246210e-01f,
  1.58794731e-01f, 1.45963475e-01f, 1.37969017e-01f, 6.32637739e-02f, 1.25993803e-01f, 1.75394088e-01f, 4.62232195e-02f, 1.56925634e-01f, 1.07952856e-01f, 2.20473543e-01f,
  -5.12691855e-01f, -3.33254099e-01f, -2.11542442e-01f, -2.69199878e-01f, -9.15928409e-02f, -1.90827817e-01f, -1.39792562e-01f, -1.68463588e-01f, -1.10104315e-01f, -1.43758193e-01f,
  -1.51004404e-01f, -1.06491230e-01f, -1.71885446e-01f, -1.44271940e-01f, -1.84410974e-01f, -9.99535844e-02f, -2.58565277e-01f, -2.09473208e-01f, -2.45348349e-01f, -1.40859619e-01f,
  -2.58092612e-01f, -1.92314938e-01f, -2.07619131e-01f, -2.55383015e-01f, -1.44221842e-01f, -3.55019838e-01f, -6.84956685e-02f, -1.43625110e-01f, -2.93783903e-01f, -3.29458058e-01f,
  1.63432628e-01f, -1.79327890e-01f, -4.62433137e-02f, 3.14907171e-03f, -4.12230529e-02f, -3.58070694e-02f, 4.59273495e-02f, 1.49360836e-01f, 1.74046770e-01f, 5.96436709e-02f,
  -1.18537255e-01f, -2.28343811e-02f, 2.48583242e-01f, 1.57249555e-01f, 1.56479761e-01f, 2.87739009e-01f, 1.95328891e-01f, 2.05124483e-01f, 1.42065987e-01f, -5.21884076e-02f,
  1.53180920e-02f, 5.27417175e-02f, 8.97559077e-02f, -5.71258890e-04f, -1.68139532e-01f, 1.23181857e-01f, 1.06981009e-01f, -1.74319252e-01f, -1.99050918e-01f, -1.84164882e-01f,
  -1.21132836e-01f, -1.74432829e-01f, 1.53556377e-01f, 8.24483484e-02f, 2.78323758e-02f, 1.19589075e-01f, 1.19126067e-01f, 1.02896094e-01f, 5.25257178e-02f, 5.68246581e-02f,
  6.80122226e-02f, 7.61069655e-02f, 1.30962580e-01f, -5.55330189e-03f, 1.22475967e-01f, 2.68364083e-02f, 1.53609887e-01f, 4.66727801e-02f, 1.12666585e-01f, -7.12892786e-02f,
  -4.89641987e-02f, -1.55759426e-02f, 1.24628134e-01f, 1.43118247e-01f, 4.98464368e-02f, 2.18224451e-01f, 2.14316621e-02f, -1.13143551e-03f, 2.11180776e-01f, 1.53626472e-01f,
  -1.12881884e-02f, -7.43211359e-02f, -4.97078858e-02f, -1.21702246e-01f, -4.92310077e-02f, -6.28976375e-02f, -7.48870224e-02f, -1.05378337e-01f, -6.19141124e-02f, -4.45554405e-02f,
  -6.20305687e-02f, -1.37395754e-01f, -1.40629396e-01f, -2.84111667e-02f, -1.70099467e-01f, -1.47569135e-01f, -1.24562100e-01f, -1.20302655e-01f, -1.32971346e-01f, -1.26138255e-01f,
  -1.46239728e-01f, -4.68990542e-02f, -1.28942236e-01f, -1.11917116e-01f, -9.71275270e-02f, -7.22388774e-02f, -9.67088491e-02f, -1.51378274e-01f, -5.13006896e-02f, -1.10361904e-01f,
  2.51199901e-01f, 2.46744886e-01f, 1.87403470e-01f, 2.11700529e-01f, 7.58143887e-02f, 1.50879666e-01f, 1.20226694e-02f, 1.06383964e-01f, 2.70156264e-02f, 5.07886522e-02f,
  1.76807269e-02f, 1.54799283e-01f, 1.45566791e-01f, 1.01704128e-01f, 9.32912678e-02f, 1.33933201e-01f, 1.55922607e-01f, 1.60896704e-01f, 1.38865262e-01f, 5.24857081e-02f,
  1.60011247e-01f, 1.69106364e-01f, 2.43287861e-01f, 2.77141243e-01f, 9.24512669e-02f, 2.35094175e-01f, 2.51105994e-01f, 1.85013756e-01f, 3.37452322e-01f, 3.76381308e-01f,
  -1.07631698e-01f, -7.22643211e-02f, -3.04963350e-01f, 4.51694019e-02f, 2.14247704e-01f, 2.29445994e-01f, 3.10683876e-01f, 1.09906219e-01f, 1.88568681e-01f, 7.73363784e-02f,
  -1.46417422e-02f, 4.04701743e-04f, -7.41433501e-02f, -8.09622332e-02f, -1.15643010e-01f, 1.58727080e-01f, 7.94861540e-02f, -2.88510203e-01f, -1.13434747e-01f, 2.79908981e-02f,
  2.48274922e-01f, -1.06012180e-01f, -1.86290547e-01f, -8.28803405e-02f, 4.47429419e-02f, -3.28175947e-02f, -1.67568132e-01f, -1.90174550e-01f, -4.84715169e-03f, -7.42024090e-03f,
  -2.82491595e-01f, -1.59650430e-01f, 1.21842816e-01f, 2.76762042e-02f, -2.01148912e-02f, -3.32322642e-02f, 2.70866863e-02f, -2.23457292e-02f, 8.98820385e-02f, 2.74451263e-02f,
  5.31800510e-03f, -5.96182011e-02f, 3.80147658e-02f, -6.68506846e-02f, -1.91191677e-02f, -6.72049299e-02f, -1.42094493e-01f, -1.39315546e-01f, -1.03148729e-01f, -6.05805404e-02f,
  1.70497105e-01f, 4.38605063e-02f, -1.91295877e-01f, 4.63617705e-02f, 1.76473074e-02f, -6.91264793e-02f, -5.76157905e-02f, -1.38802588e-01f, -6.31057471e-02f, 7.06018740e-03f,
  9.56124887e-02f, -9.52290967e-02f, -3.20460685e-02f, -1.06850840e-01f, 9.20860842e-02f, -1.33965947e-02f, 5.05434535e-03f, -3.72132957e-02f, -1.17684947e-02f, -7.16530457e-02f,
  -2.04823241e-02f, -1.05094900e-02f, -2.20360104e-02f, -4.49439920e-02f, 3.38594131e-02f, -1.54439718e-01f, -6.78466186e-02f, -2.55621132e-02f, -1.83688309e-02f, 2.58262120e-02f,
  1.88032463e-02f, -6.73476458e-02f, -4.32340521e-03f, -8.22720081e-02f, 1.94290783e-02f, -6.86288392e-03f, 1.32033259e-01f, 6.77932575e-02f, -8.32752213e-02f, 3.33665051e-02f,
  -1.63014010e-01f, 8.07351395e-02f, 2.78933626e-03f, 4.06669676e-02f, -4.59115170e-02f, -6.52991310e-02f, -8.09497535e-02f, -3.86951678e-02f, -3.72940209e-03f, -3.29805724e-02f,
  -9.16342624e-03f, -5.03004454e-02f, -1.03280172e-01f, 3.41521064e-03f, 1.48577448e-02f, 1.27084525e-02f, 2.60350294e-02f, 1.74022242e-02f, 5.69415763e-02f, 4.89689745e-02f,
  6.43457919e-02f, 9.51790735e-02f, 1.49387926e-01f, 4.86383736e-02f, 7.51447082e-02f, 8.11428428e-02f, -6.81566373e-02f, 1.72577761e-02f, 1.20933861e-01f, 1.48707986e-01f,
  4.45314124e-02f, -1.91819314e-02f, -1.22329302e-01f, 6.26889765e-02f, 3.54319401e-02f, -2.59535044e-01f, -3.75576884e-01f, -1.73215717e-01f, 1.16777934e-01f, 7.86858946e-02f,
  2.56736994e-01f, 1.82360947e-01f, 2.39387006e-01f, 2.01757513e-02f, -6.74941018e-02f, -2.17333943e-01f, -1.97580025e-01f, -2.14227602e-01f, -1.08344041e-01f, -6.21385016e-02f,
  2.83841565e-02f, 2.77725123e-02f, 6.76335394e-02f, -2.68989690e-02f, -1.26101434e-01f, -1.21481478e-01f, -3.19776982e-02f, 7.23065529e-03f, -1.62464976e-01f, -1.13717318e-01f,
  3.33461538e-02f, -1.25438906e-02f, 3.70230936e-02f, 1.05412133e-01f, 1.60836056e-01f, -8.17157999e-02f, -5.10032810e-02f, -6.79573715e-02f, 1.12296350e-01f, -8.02227482e-02f,
  8.33607614e-02f, 1.13467030e-01f, 8.50933604e-03f, 5.61536103e-02f, -8.09062421e-02f, -2.98983371e-03f, 4.56469618e-02f, 1.97037831e-02f, -7.72194639e-02f, 4.28380668e-02f,
  2.41979528e-02f, 6.54562609e-03f, 2.79069934e-02f, -7.53971785e-02f, -6.80775791e-02f, 4.84319702e-02f, -1.52238369e-01f, -7.25216568e-02f, -4.54711318e-02f, -2.67697424e-01f,
  2.27107063e-01f, -1.63926147e-02f, 3.95075325e-03f, 5.34510687e-02f, -4.06974182e-03f, 2.20592525e-02f, -8.19892436e-02f, -2.86603160e-02f, -3.14200707e-02f, -1.14252679e-01f,
  -2.35256534e-02f, 5.03474697e-02f, -1.18493147e-01f, -1.71443019e-02f, 3.15963812e-02f, -7.52648562e-02f, -1.49342313e-01f, -1.50455497e-02f, -2.22631395e-02f, 2.03194097e-02f,
  -4.69695451e-03f, -2.13118847e-02f, 3.56030203e-02f, -1.31355807e-01f, 1.45891616e-02f, -3.07768658e-02f, 3.38428910e-03f, 6.74462765e-02f, -3.20309289e-02f, -1.80146731e-02f,
  2.46674299e-01f, 2.03915015e-01f, -5.03237657e-02f, -7.16457292e-02f, 3.77623700e-02f, 7.57114887e-02f, 1.22182660e-01f, 9.62936580e-02f, 1.60835132e-01f, -7.72276148e-02f,
  -5.51311672e-02f, -2.86053140e-02f, 2.55253427e-02f, 5.96950017e-02f, 1.67373586e-02f, -2.48747319e-02f, 9.13472772e-02f, -4.18394655e-02f, -2.64341719e-02f, -3.83553430e-02f,
  2.51411293e-02f, -2.31260154e-02f, -1.04511052e-01f, -5.38647659e-02f, -1.34899437e-01f, -1.93566568e-02f, -4.70311232e-02f, -1.80335775e-01f, -5.77155538e-02f, -2.15172559e-01f,
  -4.34744358e-01f, -3.69429499e-01f, -2.73718610e-02f, -3.53188604e-01f, 6.29981682e-02f, 2.96469271e-01f, 1.35084003e-01f, 1.26983091e-01f, -2.75237812e-03f, -2.00309843e-01f,
  1.09915629e-01f, 1.31010562e-01f, 1.92814738e-01f, 2.40356430e-01f, 1.94065705e-01f, -1.04133919e-01f, -2.48922646e-01f, 1.31511509e-01f, 3.84311348e-01f, 7.82592073e-02f,
  -1.71020970e-01f, -1.82222173e-01f, -1.44859195e-01f, -1.05600163e-01f, -2.91082472e-01f, -2.86723394e-02f, -1.24629319e-01f, -1.86704680e-01f, -1.22144617e-01f, -4.65496212e-01f,
  -2.38593966e-02f, -7.11034536e-02f, 8.38560611e-02f, -7.19041973e-02f, 3.23307365e-02f, 4.81741549e-03f, -6.15119711e-02f, -6.46149442e-02f, -8.96428376e-02f, -1.08011536e-01f,
  -2.86036786e-02f, -1.21459849e-01f, -8.74939188e-02f, -2.50783600e-02f, 3.36140627e-03f, 1.10914721e-03f, -3.21336277e-02f, 4.77673449e-02f, 7.84759745e-02f, 4.47913818e-02f,
  -1.26347542e-01f, -2.11927131e-01f, -1.06201638e-02f, 9.15915966e-02f, 4.95115295e-02f, 4.60186787e-02f, 4.03394066e-02f, 9.62186158e-02f, 1.91622019e-01f, -2.55602270e-01f,
  1.39340207e-01f, 8.92274603e-02f, 9.31899026e-02f, 1.04324654e-01f, 1.17306948e-01f, 1.06106758e-01f, 1.51571184e-01f, 8.12754333e-02f, 9.81978700e-02f, 1.03148364e-01f,
  1.41649008e-01f, 1.58236340e-01f, 1.10540859e-01f, 3.22452709e-02f, 3.35307308e-02f, 4.58503403e-02f, 9.79384556e-02f, 4.16911133e-02f, 1.65092081e-01f, 6.41623586e-02f,
  1.72195494e-01f, 1.72724456e-01f, 7.34697431e-02f, 1.97701290e-01f, 1.46871418e-01f, 1.44019380e-01f, 9.26378891e-02f, 1.52849585e-01f, 6.89851120e-02f, 3.46787982e-02f,
  -9.49045345e-02f, 2.13554516e-01f, -2.67714888e-01f, -4.79167774e-02f, -1.83489189e-01f, -7.56719485e-02f, -1.08984336e-01f, -1.14558540e-01f, -9.18760374e-02f, -7.11828023e-02f,
  -3.23616415e-02f, 4.64598536e-02f, -4.52336557e-02f, -4.11046371e-02f, -6.17860816e-03f, -8.97091925e-02f, -9.41596255e-02f, -3.83182950e-02f, 4.53704186e-02f, -6.36457577e-02f,
  -8.59697536e-02f, -4.63009030e-02f, 4.34159636e-02f, -5.36680296e-02f, 5.59617989e-02f, -5.64799532e-02f, -5.33362152e-03f, 1.10863540e-02f, 4.71778326e-02f, -1.73860669e-01f
};

// L0_fan_Wp_bar (Shape: 26 x 120)
const int L0_fan_Wp_bar_rows = 26;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -5.55779934e-01f, 7.12611437e-01f, 2.55076289e-01f, -4.15937752e-01f, -1.74791694e-01f, -9.19812471e-02f, 4.36419129e-01f, -9.54776108e-02f, -3.26236606e-01f, 3.35234702e-01f,
  3.53206456e-01f, -2.84744114e-01f, -1.82074204e-01f, -2.31797084e-01f, -2.98049420e-01f, 1.48188576e-01f, -1.10710718e-01f, -5.81231177e-01f, -9.32370782e-01f, -6.78064525e-01f,
  -3.20726544e-01f, -3.54136825e-01f, -3.36842120e-01f, -3.49029839e-01f, 7.72830769e-02f, -2.65953988e-01f, 2.96483755e-01f, -3.76005024e-02f, 1.29536524e-01f, 3.21167745e-02f,
  2.50186473e-01f, 5.79870269e-02f, -2.85562366e-01f, -1.97177380e-01f, 2.64886588e-01f, 8.17280710e-02f, 4.81302552e-02f, -9.14262682e-02f, 6.21116385e-02f, 1.57906309e-01f,
  5.00023216e-02f, -2.49647461e-02f, -9.74802859e-03f, -1.65513977e-02f, -8.49495530e-02f, -8.08270648e-02f, -7.56756887e-02f, -1.95791051e-01f, -4.40501049e-03f, 3.52471918e-01f,
  2.68599272e-01f, 8.54903832e-02f, 9.72875580e-02f, 5.72903603e-02f, 6.61684200e-02f, -2.83178806e-01f, 2.41794914e-01f, -7.48429447e-02f, -1.22408450e-01f, 2.16538295e-01f,
  -1.11623712e-01f, -2.50458028e-02f, -6.02741987e-02f, 4.02246043e-02f, 1.11671455e-01f, 4.00424823e-02f, -5.58023751e-02f, 1.65373221e-01f, -4.65181917e-02f, 6.72758510e-03f,
  1.38869165e-02f, 1.08900242e-01f, 5.73236570e-02f, -2.41301842e-02f, -7.62604475e-02f, 4.73844968e-02f, 5.38427010e-02f, 1.61509946e-01f, 5.50742485e-02f, 1.05521586e-02f,
  -8.76343101e-02f, 4.54274118e-02f, 7.93209299e-02f, 1.09489253e-02f, 8.77658054e-02f, 2.66874116e-03f, 5.29676080e-02f, 1.61835685e-01f, 6.83838800e-02f, -1.10065028e-01f,
  3.88378128e-02f, -2.63851404e-01f, 2.96808295e-02f, -2.32597008e-01f, -4.66611758e-02f, 1.04971394e-01f, -9.44395550e-03f, -1.14267737e-01f, -1.86016969e-02f, 6.50903434e-02f,
  -7.67150940e-03f, 3.73192467e-02f, 1.81745812e-01f, 1.17530636e-01f, -2.46019214e-01f, -6.91312104e-02f, 1.26972660e-01f, -1.37984883e-02f, -1.63820922e-01f, 2.00518772e-01f,
  2.18134642e-01f, -7.01601207e-02f, -6.25768304e-02f, -6.58029467e-02f, 7.16945305e-02f, -2.34834388e-01f, 1.92520559e-01f, 1.37293011e-01f, -3.80529389e-02f, 1.56159878e-01f,
  -6.26299858e-01f, -6.71940386e-01f, 2.73676515e-01f, 5.05596578e-01f, 6.27246916e-01f, 4.64480698e-01f, 1.46712944e-01f, 1.49559572e-01f, 3.12752932e-01f, 1.23703852e-03f,
  -3.12520079e-02f, 1.06147550e-01f, 9.68683362e-02f, 2.34525830e-01f, 6.87861219e-02f, 3.42421740e-01f, 4.88724679e-01f, 3.51548314e-01f, 4.38399732e-01f, 1.55069858e-01f,
  1.65597469e-01f, 1.28518417e-01f, 1.81972922e-03f, 1.48898110e-01f, 2.58943558e-01f, 4.43751574e-01f, 1.96921572e-01f, 1.23187423e-01f, 1.89256266e-01f, 2.97666550e-01f,
  -3.38861458e-02f, -3.38010013e-01f, 3.03276390e-01f, -1.01147234e-01f, -1.66291386e-01f, -2.72638083e-01f, 2.54542455e-02f, -1.87886626e-01f, -2.13385642e-01f, 6.03318475e-02f,
  -3.92567087e-03f, -1.78577513e-01f, 5.32365069e-02f, -5.00959642e-02f, -9.33702812e-02f, -2.21724939e-02f, -2.46980265e-01f, -3.51077728e-02f, 1.49169222e-01f, -1.44174084e-01f,
  2.74662841e-02f, 2.07471460e-01f, 2.13283882e-01f, 2.09379196e-01f, 4.17437032e-02f, 2.44303703e-01f, -7.43927285e-02f, -6.45217672e-02f, 4.39111851e-02f, -1.46083564e-01f,
  3.87503266e-01f, 2.12983787e-01f, 2.70221144e-01f, 1.24799006e-01f, 6.22592270e-02f, 5.09049818e-02f, 5.58863729e-02f, 1.20502345e-01f, 1.40800059e-01f, -2.99440231e-02f,
  1.74691007e-01f, 3.08313936e-01f, 1.14620008e-01f, 6.02383800e-02f, 7.53082857e-02f, 2.02819824e-01f, 1.17929973e-01f, -2.23898981e-02f, 5.62991686e-02f, 1.28159270e-01f,
  8.85075405e-02f, -3.19020934e-02f, -6.92966431e-02f, -1.83315296e-02f, 1.53502226e-02f, 2.09803924e-01f, 1.54093221e-01f, -2.06019990e-02f, 3.73171605e-02f, -3.61440219e-02f,
  4.87349257e-02f, 4.04266417e-01f, 1.09959073e-01f, -3.79595645e-02f, -8.41938367e-04f, -1.73779935e-01f, 2.31894050e-02f, -1.52224302e-01f, -6.36926442e-02f, -7.13774264e-02f,
  -9.45561603e-02f, -2.52750903e-01f, -1.75999910e-01f, -6.19827062e-02f, -4.32218686e-02f, -7.99668878e-02f, -8.57500285e-02f, 7.48242140e-02f, 5.39924502e-02f, -3.78649272e-02f,
  -1.28215641e-01f, 2.69621313e-01f, 3.72942924e-01f, 2.17130482e-01f, 1.42895788e-01f, 2.72002488e-01f, 8.48756358e-02f, 4.46060784e-02f, 9.30120721e-02f, -1.84119001e-01f,
  9.31433201e-01f, 2.35811826e-02f, -3.29319507e-01f, 6.33239329e-01f, 5.80537260e-01f, -1.05031416e-01f, -6.50586069e-01f, -4.35196042e-01f, 3.79044741e-01f, 8.63496512e-02f,
  -2.41358623e-01f, -2.94889092e-01f, -3.22329968e-01f, -6.25882447e-01f, -1.00429940e+00f, -6.32781923e-01f, -3.54147762e-01f, -6.38398945e-01f, -8.35191846e-01f, -4.61248517e-01f,
  -1.64722931e-02f, 2.16987252e-01f, -1.23213410e-01f, -2.00310662e-01f, 6.17237389e-01f, 2.32309774e-01f, 3.52553815e-01f, 3.85813832e-01f, -1.86751574e-01f, 4.32013094e-01f,
  -2.41545979e-02f, 8.43498856e-02f, -2.42182896e-01f, -1.21629611e-01f, 3.33333760e-01f, 1.28307641e-01f, 3.14606242e-02f, 1.36983991e-01f, 8.11821893e-02f, 3.36723663e-02f,
  1.46202981e-01f, -1.46595761e-01f, -1.95351675e-01f, -3.23958956e-02f, -1.26859635e-01f, -1.14543274e-01f, -2.88991332e-01f, -4.77016777e-01f, -1.41479403e-01f, -1.04734458e-01f,
  -5.14867119e-02f, -1.05945893e-01f, -1.41441122e-01f, -1.49967015e-01f, -1.82376564e-01f, 1.63287595e-01f, -8.73357132e-02f, -2.07957234e-02f, -2.87018120e-01f, 3.44595045e-01f,
  2.27940991e-03f, 8.31437409e-02f, 8.77469182e-02f, 8.26990902e-02f, 7.55781531e-02f, 1.10162146e-01f, 1.15147226e-01f, 6.43003918e-03f, -7.70019963e-02f, -2.25141831e-02f,
  -2.58793026e-01f, -1.17068291e-02f, -9.11679193e-02f, 5.51836751e-02f, 9.21762139e-02f, 1.84876353e-01f, 2.01705933e-01f, -3.25060599e-02f, -5.61389402e-02f, 1.38243735e-01f,
  -7.21435919e-02f, 6.36229292e-02f, 2.25504324e-01f, -1.94574505e-01f, -1.84720512e-02f, 7.66941980e-02f, 2.35847503e-01f, 1.27915181e-02f, 8.92262161e-02f, 1.47632316e-01f,
  1.91091999e-01f, -7.40076542e-01f, 4.18390691e-01f, -2.99382001e-01f, 2.70736694e-01f, -3.97143513e-02f, 3.08469564e-01f, -4.22180519e-02f, 3.61093611e-01f, 1.39381960e-01f,
  -1.61517382e-01f, 1.23755559e-02f, -2.28918210e-01f, -4.56857868e-03f, -2.41747394e-01f, 3.24553028e-02f, -1.86409522e-02f, 8.78363103e-02f, -2.01994359e-01f, 3.03380281e-01f,
  -1.20677790e-02f, -1.02632076e-01f, -2.80625443e-03f, 1.23623848e-01f, 1.70840666e-01f, 7.92951733e-02f, 1.30441755e-01f, -8.21507256e-03f, -3.79097223e-01f, 3.02992284e-01f,
  -6.59815431e-01f, -7.02077985e-01f, 2.38685414e-01f, -3.30571800e-01f, -4.37516719e-01f, -2.60561317e-01f, -7.52780437e-01f, -3.38844717e-01f, -1.09627984e-01f, -2.75727540e-01f,
  -1.45403460e-01f, -2.18334958e-01f, -4.71812300e-02f, -2.02867743e-02f, -1.09312106e-02f, 9.94725600e-02f, 2.42561087e-01f, 1.90606654e-01f, -7.81078637e-02f, -3.75527382e-01f,
  -4.14172083e-01f, -3.65153849e-01f, 1.69461481e-02f, -2.99413949e-02f, -6.10093653e-01f, -3.18633795e-01f, -2.78450064e-02f, -3.08427334e-01f, -9.73920226e-02f, -5.50448418e-01f,
  -4.95570838e-01f, -4.43984628e-01f, 1.94395244e-01f, 2.52314135e-02f, -4.31350898e-03f, 3.09522450e-02f, -2.92080611e-01f, 1.25258639e-01f, 1.30697459e-01f, 8.67853910e-02f,
  -7.94455856e-02f, -8.04568529e-02f, -1.90158978e-01f, -1.10217348e-01f, -1.16070002e-01f, -5.22903167e-02f, 1.94379658e-01f, 7.21120089e-02f, 2.07555979e-01f, 1.42650992e-01f,
  -1.94036849e-02f, -3.80556993e-02f, 4.38401438e-02f, 2.92392254e-01f, 1.54896364e-01f, 3.06708783e-01f, -1.92872155e-02f, -5.89636154e-02f, 2.25093022e-01f, -4.05156136e-01f,
  1.68252155e-01f, 1.04880415e-01f, 7.14309374e-03f, -4.53232042e-02f, 1.52935237e-01f, 1.27989620e-01f, 4.05747481e-02f, -1.57550648e-01f, 9.71212387e-02f, 8.74911530e-06f,
  1.10881284e-01f, 1.54965147e-01f, 8.02556276e-02f, -4.10474464e-02f, -2.35567125e-03f, 9.46376845e-03f, -6.65703639e-02f, 5.88052236e-02f, 1.26634225e-01f, 6.71186075e-02f,
  1.25640584e-03f, -1.14287525e-01f, -7.59115592e-02f, -3.20533942e-03f, 5.11912303e-03f, 1.88442603e-01f, 1.08546093e-02f, -1.23132952e-01f, -8.83484632e-02f, -1.55411894e-02f,
  -4.21291739e-01f, 6.28747225e-01f, -3.49308163e-01f, 6.15611859e-02f, -1.21440561e-02f, 2.88271338e-01f, -1.18754245e-01f, 1.54897913e-01f, -4.97036353e-02f, -2.13661313e-01f,
  -1.99187085e-01f, -2.34429836e-01f, -1.18829444e-01f, 9.69109591e-03f, -1.13417283e-01f, -4.60355766e-02f, 1.25952378e-01f, -3.04560155e-01f, 1.16853610e-01f, 1.57360733e-01f,
  2.81227320e-01f, -6.08008727e-02f, -3.60772759e-01f, -1.11130044e-01f, -6.04546033e-02f, -1.57666713e-01f, -3.14443380e-01f, -3.40277493e-01f, -4.01957147e-02f, -5.02108216e-01f,
  -7.36257493e-01f, -4.90710944e-01f, 2.97082335e-01f, -3.05312335e-01f, 5.72631419e-01f, -9.66322869e-02f, -9.59648788e-01f, -6.72640741e-01f, -8.38753283e-02f, -1.97214797e-01f,
  5.49625337e-01f, 4.78688449e-01f, 3.14378478e-02f, -2.50193756e-02f, -4.60188001e-01f, -6.02824807e-01f, -2.82542676e-01f, -1.07085757e-01f, 1.49057657e-01f, 3.38247925e-01f,
  2.41765872e-01f, -1.18262982e-02f, 4.74600233e-02f, -7.32306242e-02f, -7.64590874e-02f, 1.25031367e-01f, -2.25656517e-02f, 2.23232031e-01f, 1.63685188e-01f, -1.46332115e-01f,
  2.23225862e-01f, -3.22295308e-01f, 3.33448887e-01f, 2.78010696e-01f, 3.28354329e-01f, -3.12600821e-01f, -1.58638254e-01f, -2.30863765e-02f, -4.14018296e-02f, -1.15440980e-01f,
  3.38752419e-01f, 1.74736112e-01f, 1.34923443e-01f, 1.54920164e-02f, -1.04177162e-01f, -2.27959827e-01f, 4.26325900e-03f, -2.31387347e-01f, -3.89268786e-01f, -1.78685822e-02f,
  3.06396931e-01f, 3.61228496e-01f, -1.31509155e-01f, -2.72351027e-01f, -4.53119248e-01f, -4.74048927e-02f, -1.40600577e-01f, -9.94420797e-02f, -3.79204035e-01f, -6.33771002e-01f,
  4.31712009e-02f, 2.73098528e-01f, 5.73425032e-02f, -1.26817748e-01f, 5.44348359e-03f, 1.45794243e-01f, 8.05064198e-03f, 4.25351001e-02f, 1.79400563e-01f, -1.05717480e-01f,
  -1.03350459e-02f, 1.21197194e-01f, 2.49581169e-02f, -9.18572918e-02f, -3.30794714e-02f, -6.52367473e-02f, 5.49463369e-02f, -1.28620788e-01f, 1.02198683e-01f, -1.79770797e-01f,
  1.77595243e-02f, 1.28401965e-01f, 1.92189291e-01f, -1.23110928e-01f, -1.82345938e-02f, -3.57199907e-02f, 2.37980485e-02f, -1.98461730e-02f, 1.36032933e-02f, -9.64068174e-02f,
  -3.46514970e-01f, 2.97322303e-01f, -1.16536677e-01f, -1.59369558e-01f, 7.46016353e-02f, 1.27442390e-01f, -5.28002344e-03f, 1.12543955e-01f, 1.56902093e-02f, -1.42525971e-01f,
  -6.73955604e-02f, -1.27552688e-01f, -4.88758050e-02f, 3.15301642e-02f, -3.20406929e-02f, 1.60581227e-02f, -1.04493737e-01f, 1.32972393e-02f, -1.26188979e-01f, 1.77112371e-02f,
  -2.57657051e-01f, -3.61057371e-01f, -5.03843486e-01f, -5.33027649e-01f, -1.82680309e-01f, -1.11902334e-01f, -3.06340635e-01f, -1.89987510e-01f, -6.09436274e-01f, -9.30607080e-01f,
  8.58077407e-01f, 2.60162562e-01f, 1.06418662e-01f, 1.93278119e-01f, 8.03225636e-02f, 2.11883694e-01f, 1.39773831e-01f, 1.60159513e-01f, 2.16097683e-01f, 3.01291704e-01f,
  4.08023894e-01f, 3.83000731e-01f, 3.02270591e-01f, 1.90309539e-01f, 7.95992687e-02f, 8.58540908e-02f, 1.47171058e-02f, -4.72641736e-02f, 2.21578386e-02f, -5.75676151e-02f,
  -5.57918325e-02f, -1.64540350e-01f, -1.86784547e-02f, 2.93130260e-02f, -1.26124978e-01f, -9.55779254e-02f, -4.85827774e-02f, -1.33579433e-01f, -3.00590992e-01f, -3.45246702e-01f,
  -9.46056172e-02f, 3.29951763e-01f, 1.96338892e-01f, 2.95153648e-01f, 2.17653424e-01f, 2.33362749e-01f, 2.50842631e-01f, 1.78025067e-02f, 1.08676799e-01f, -4.13553938e-02f,
  4.25624065e-02f, 2.91075297e-02f, 9.50748324e-02f, 7.04957871e-03f, 6.25245944e-02f, 8.94971117e-02f, 1.48241505e-01f, -1.69701781e-02f, 3.19295302e-02f, 1.38924420e-01f,
  1.25029728e-01f, 5.71830869e-02f, 4.97763045e-02f, 5.40458001e-02f, 1.74331114e-01f, 8.65210742e-02f, 1.84667110e-02f, 8.14084038e-02f, 1.03254870e-01f, 1.04084827e-01f,
  2.86349446e-01f, 3.34539562e-01f, 3.41546312e-02f, 1.16600931e-01f, 1.65412053e-01f, 5.12818955e-02f, -9.63854864e-02f, 3.37321870e-02f, -6.65493384e-02f, 2.09877267e-02f,
  -7.75466263e-02f, 1.49744563e-02f, -1.08551160e-02f, -1.62407205e-01f, -4.29780744e-02f, -1.36245906e-01f, -2.43853275e-02f, -6.34830520e-02f, 7.38705546e-02f, 1.66344881e-01f,
  -7.44598657e-02f, -1.52108356e-01f, -1.08519755e-01f, -1.93605110e-01f, -1.31909773e-01f, 1.60304662e-02f, -5.63758425e-02f, -1.08903944e-02f, 1.08958267e-01f, -1.12895049e-01f,
  -2.01824173e-01f, 1.68653354e-01f, 2.94967052e-02f, -3.37919742e-02f, -7.29651898e-02f, -3.83405969e-03f, 3.31301987e-02f, -2.85118163e-01f, -1.32474273e-01f, 5.21010123e-02f,
  -1.02348989e-02f, 1.44438250e-02f, 1.20248891e-01f, 1.00429989e-01f, -7.11546466e-02f, 1.03682466e-02f, 1.78695917e-01f, 3.67117673e-02f, -5.72738796e-02f, 9.22938511e-02f,
  1.48317978e-01f, 4.17817868e-02f, 7.86903426e-02f, 1.40403241e-01f, 8.62828940e-02f, 6.32681474e-02f, -6.27384195e-03f, -2.83527169e-02f, 5.07978629e-03f, -7.40755443e-03f,
  -1.89628035e-01f, -5.73784672e-02f, 3.58728051e-01f, -4.17993486e-01f, 2.17963666e-01f, 4.94810045e-01f, 6.30914509e-01f, 2.99736261e-02f, -2.31863469e-01f, 1.15130730e-01f,
  -3.03511798e-01f, -6.43003404e-01f, -6.55228496e-01f, -4.57454294e-01f, -1.58253670e-01f, 4.35141504e-01f, 4.17442739e-01f, -3.20901461e-02f, -1.41875707e-02f, 4.38726805e-02f,
  -9.40244086e-03f, -2.14764383e-02f, -2.06201375e-01f, -7.03252181e-02f, -2.36691713e-01f, -3.70936841e-01f, 7.60214254e-02f, -1.13064274e-01f, 3.15411575e-02f, -1.15353569e-01f,
  2.15330109e-01f, -2.05456316e-01f, -6.13719448e-02f, -2.45390743e-01f, 4.08448093e-02f, -1.38984695e-01f, 7.72317424e-02f, -1.69417318e-02f, -7.86311105e-02f, 1.27165630e-01f,
  -1.34830445e-01f, -1.11989833e-01f, -2.35024393e-01f, -5.92389435e-04f, 5.44894300e-02f, 1.51223302e-01f, 1.90763492e-02f, -1.16344549e-01f, -1.07180767e-01f, -6.30113259e-02f,
  -2.08396956e-01f, -3.59460860e-02f, 1.83225811e-01f, -9.46774147e-04f, -1.55991882e-01f, -1.12099033e-02f, 8.34190845e-02f, -5.27444705e-02f, -2.33490560e-02f, 2.82143354e-02f,
  2.72926658e-01f, 5.03663123e-02f, -2.19522044e-01f, -1.39329210e-01f, -5.43213598e-02f, 8.00301954e-02f, 6.43511191e-02f, -1.30222589e-02f, -8.63895640e-02f, -2.77375653e-02f,
  4.58767191e-02f, -1.55876219e-01f, -1.72643200e-01f, 9.64465737e-02f, -1.77370176e-01f, -1.65554777e-01f, -3.17177437e-02f, -1.22214228e-01f, -8.96394029e-02f, -1.48232743e-01f,
  -1.91462472e-01f, 4.84839901e-02f, 2.09697355e-02f, 4.32689339e-02f, 5.61583266e-02f, 1.94323361e-02f, -4.56514116e-03f, -8.20639580e-02f, -5.68573065e-02f, -1.70595795e-02f,
  -5.60533643e-01f, -3.46792847e-01f, 8.13629776e-02f, -1.46356955e-01f, 3.21468376e-02f, -1.18161954e-01f, -2.07505003e-01f, -6.31018728e-02f, 4.00502831e-02f, -3.83223966e-02f,
  -1.97888985e-02f, -3.83960083e-02f, -6.07970133e-02f, -1.22860357e-01f, 2.18329608e-01f, 5.08832932e-02f, 8.19990486e-02f, -1.12640530e-01f, 5.22933044e-02f, 4.44380268e-02f,
  7.96423033e-02f, 2.79826373e-01f, 1.05360419e-01f, 1.18179411e-01f, -3.98710482e-02f, 5.11391088e-02f, 2.37845451e-01f, 8.32977891e-02f, 2.78654099e-01f, 4.18169051e-01f,
  -4.71674353e-02f, 1.00337014e-01f, 6.97984174e-02f, 6.06144726e-01f, 2.09247544e-02f, -6.45649254e-01f, -7.41143346e-01f, -3.17898095e-01f, 2.81998694e-01f, 1.53254837e-01f,
  8.24579522e-02f, 3.70386302e-01f, 3.08585763e-01f, 1.70604870e-01f, -3.30372065e-01f, 4.10606008e-04f, 3.82735610e-01f, -1.83456633e-02f, -3.21745187e-01f, -3.84339601e-01f,
  1.89920917e-01f, 2.11526841e-01f, 3.32144019e-03f, -1.44952878e-01f, 3.96722138e-01f, 1.86063468e-01f, 2.68326908e-01f, 2.11178899e-01f, -1.16369434e-01f, 7.05962956e-01f,
  5.37130475e-01f, -2.38672525e-01f, -4.18396592e-01f, -1.00122333e-01f, -7.01530883e-03f, -2.62966733e-02f, -1.69076130e-01f, 1.20103061e-01f, -1.39659479e-01f, -3.60773169e-02f,
  9.14245546e-02f, -3.73326577e-02f, 3.25444937e-01f, 7.34049035e-03f, -9.84079167e-02f, -2.92439550e-01f, -9.77926627e-02f, -3.90264213e-01f, -2.75168061e-01f, -1.93822175e-01f,
  3.42357904e-01f, -4.19482365e-02f, -3.78865838e-01f, -4.64330316e-01f, -1.65549919e-01f, -4.39295918e-02f, -3.31717432e-01f, -2.36867025e-01f, -6.20495856e-01f, 1.98943451e-01f,
  2.68028080e-02f, 1.65918712e-02f, -9.31593403e-02f, 7.60406554e-02f, 6.47149011e-02f, 2.00153977e-01f, 1.62517816e-01f, -1.25749940e-02f, 9.37808529e-02f, 5.13701588e-02f,
  -1.94994614e-01f, -1.00051403e-01f, 1.36081651e-01f, 8.51923749e-02f, 4.46091518e-02f, -5.29507361e-02f, -1.45162195e-01f, -2.16159709e-02f, -1.73226856e-02f, -1.06769122e-01f,
  -2.27458682e-02f, -4.08235192e-02f, 2.35235155e-01f, -3.27585302e-02f, 4.47331779e-02f, -5.77848479e-02f, 7.16047361e-02f, -3.45506147e-02f, 8.48032087e-02f, 4.03206348e-02f,
  2.40823135e-01f, -6.56614363e-01f, 2.14901790e-01f, -8.90283510e-02f, 1.52463049e-01f, -2.73395963e-02f, 6.65835440e-02f, -1.66068316e-01f, -1.12487748e-02f, -1.61834121e-01f,
  -3.63228112e-01f, -1.03329353e-01f, 3.28773648e-01f, -4.04686183e-02f, 1.60041317e-01f, 3.46893407e-02f, 1.97865218e-01f, -1.27698794e-01f, -1.22424893e-01f, 9.18460563e-02f,
  3.91300112e-01f, -2.31288657e-01f, -3.22876394e-01f, -3.18631321e-01f, 9.86347124e-02f, -2.49347374e-01f, -2.10139573e-01f, -1.16802298e-01f, -6.83623612e-01f, -2.56736338e-01f,
  1.62567899e-01f, 3.02168757e-01f, -2.93728352e-01f, 4.02117699e-01f, 8.60151574e-02f, 3.22725438e-02f, 3.82073402e-01f, 3.80152881e-01f, 4.13263291e-01f, 5.11560440e-01f,
  7.89498240e-02f, -1.53123513e-01f, -2.51322109e-02f, -1.57319024e-01f, -1.86687678e-01f, 2.66012222e-01f, -2.96781934e-03f, -3.73626679e-01f, -2.66128153e-01f, -7.48559833e-02f,
  -8.00388604e-02f, -5.67391403e-02f, -1.06457934e-01f, 3.88079509e-02f, 2.59683371e-01f, 1.08916257e-02f, 1.23198658e-01f, -2.74232998e-02f, -2.48699725e-01f, -1.45582020e-01f,
  -2.34230012e-01f, -4.77356225e-01f, -3.50721665e-02f, -1.93665445e-01f, -7.34211951e-02f, 9.21580195e-02f, -2.23904420e-02f, 2.56292112e-02f, 2.48282969e-01f, 2.15277702e-01f,
  -4.49157171e-02f, -8.36822540e-02f, -2.32795179e-02f, 1.33678624e-02f, 1.37133896e-01f, 3.37348171e-02f, -3.29374783e-02f, -2.15440821e-02f, -9.84430611e-02f, -8.33933800e-02f,
  -1.27794385e-01f, -1.33870482e-01f, 8.02706107e-02f, 4.79634628e-02f, -1.48458660e-01f, -1.53859109e-01f, 4.87030298e-02f, -3.34718339e-02f, -1.27608657e-01f, 3.13389927e-01f,
  1.02575183e-01f, 3.21106493e-01f, 4.69317101e-02f, -3.36032622e-02f, 1.69414699e-01f, 2.40707532e-01f, 1.85021177e-01f, 9.11476314e-02f, 1.07652992e-01f, 8.60399678e-02f,
  2.02511162e-01f, -2.64144801e-02f, 5.99386878e-02f, 1.08802699e-01f, -3.17934640e-02f, -1.56379566e-01f, -1.29908919e-01f, -6.85020313e-02f, -1.34213582e-01f, -7.80554190e-02f,
  -7.45436177e-02f, 1.95060577e-02f, -1.70784760e-02f, -4.26192395e-02f, -1.39290109e-01f, -8.74460489e-02f, -3.63966227e-02f, -5.53243272e-02f, -1.90926483e-03f, 7.61186853e-02f,
  4.16584432e-01f, -7.57731140e-01f, 2.49837209e-02f, -2.13726968e-01f, -2.17263401e-02f, -3.28485221e-02f, -2.40708336e-01f, -8.21192190e-02f, 1.09543554e-01f, 4.04872596e-02f,
  -2.49615997e-01f, -6.67324886e-02f, 8.55573490e-02f, 4.28159125e-02f, 2.05290660e-01f, -3.55909616e-02f, 2.34988574e-02f, 1.64257854e-01f, 5.01047298e-02f, 8.75372663e-02f,
  8.52183178e-02f, 2.33233079e-01f, 1.83939368e-01f, 1.27117634e-01f, -3.34371775e-02f, 1.11681186e-01f, 1.26127273e-01f, 1.21770196e-01f, 5.50387986e-02f, 3.98352385e-01f,
  -5.82783997e-01f, -6.55538380e-01f, -1.92798659e-01f, -8.47208440e-01f, -5.83705068e-01f, -2.95565188e-01f, -6.66870832e-01f, -4.18638259e-01f, -3.57642263e-01f, -5.27119279e-01f,
  1.66750208e-01f, 6.00931108e-01f, 3.59092414e-01f, 3.70764077e-01f, 4.07219112e-01f, -7.96523571e-01f, -8.79584849e-01f, -6.83601871e-02f, 2.48969376e-01f, -1.30706668e-01f,
  -3.90222132e-01f, -5.80770552e-01f, -2.89494962e-01f, -1.38652429e-01f, -5.65718889e-01f, -1.34566501e-01f, -5.53049922e-01f, -5.92257142e-01f, -1.24177463e-01f, -7.05725789e-01f,
  2.30677098e-01f, -1.47692099e-01f, 1.94156110e-01f, 5.72193116e-02f, -2.22852305e-02f, 1.87523305e-01f, 5.53302541e-02f, -5.75456694e-02f, 1.41354315e-02f, -1.83201835e-01f,
  3.92307378e-02f, 9.78083462e-02f, 1.42817229e-01f, 6.07959442e-02f, -1.64824501e-01f, -3.06917764e-02f, -1.68972492e-01f, -1.83328897e-01f, -1.31577507e-01f, 8.31191987e-03f,
  -8.07071701e-02f, -1.13758944e-01f, 2.66571760e-01f, 1.51518360e-01f, 1.06960513e-01f, 2.44645864e-01f, 4.65390831e-02f, 9.27883610e-02f, 2.59304583e-01f, -5.19851685e-01f,
  -6.16782457e-02f, 1.27621785e-01f, -6.66471794e-02f, 1.09155953e-03f, 2.23359708e-02f, 1.02172112e-02f, -2.90062111e-02f, -7.62653872e-02f, 7.80181438e-02f, -1.13684284e-02f,
  1.85058564e-02f, -1.37633458e-01f, -1.92617197e-02f, -7.01905936e-02f, -1.51410386e-01f, -1.26803964e-01f, 1.00527234e-01f, 1.67182386e-02f, -1.60404518e-02f, -1.93264067e-01f,
  5.10680042e-02f, -3.41802575e-02f, -8.63289088e-03f, -8.17396492e-02f, 2.95384601e-02f, -2.26138737e-02f, 6.60820827e-02f, 2.35795230e-01f, 1.33075237e-01f, 3.37659456e-02f,
  3.40145588e-01f, 2.28273675e-01f, -1.29796967e-01f, 1.12139443e-02f, -1.63302600e-01f, -8.55681673e-02f, -1.35450557e-01f, 2.67071109e-02f, 1.02145985e-01f, -4.69530560e-02f,
  5.04938699e-02f, 2.05180291e-02f, 1.07429765e-01f, 5.35887014e-03f, -8.04886147e-02f, 9.22382399e-02f, -1.30481720e-01f, -1.26028270e-01f, 8.81677568e-02f, -7.46804476e-02f,
  -1.90727249e-01f, 2.81579755e-02f, 7.04794973e-02f, 1.11680619e-01f, 4.94214147e-02f, 3.75769645e-01f, 1.39527217e-01f, 5.25159501e-02f, 3.68519157e-01f, -4.84381706e-01f,
  -5.17298043e-01f, 5.76562762e-01f, 2.63535112e-01f, -2.16794088e-01f, -2.60042638e-01f, -2.31566161e-01f, 4.25292477e-02f, -2.45573893e-02f, -8.42485428e-02f, 1.82991982e-01f,
  -2.77370155e-01f, -3.11957836e-01f, 2.58363364e-03f, 6.76980391e-02f, 4.05879989e-02f, 4.91037488e-01f, 5.77049077e-01f, 1.10815510e-01f, -4.48883474e-01f, -5.21511734e-01f,
  -9.55469757e-02f, -1.67191401e-01f, -2.66516685e-01f, -5.58508635e-02f, 2.21731365e-01f, -6.62008822e-02f, 3.01966697e-01f, 1.29652977e-01f, 2.74800658e-01f, 7.05443561e-01f,
  1.34129643e-01f, 1.03610218e-01f, -4.45337802e-01f, -3.56449366e-01f, -3.16058025e-02f, 2.04343542e-01f, 4.66035903e-02f, 3.81845720e-02f, -4.33920063e-02f, 1.77304119e-01f,
  -1.48710078e-02f, 7.80622363e-02f, 8.89339894e-02f, 1.47944942e-01f, -1.10560216e-01f, -1.73790410e-01f, 1.68443635e-01f, 8.99568796e-02f, 1.22883357e-01f, -2.43377872e-02f,
  2.31259122e-01f, -3.18686813e-01f, -2.52990723e-01f, -1.27377853e-01f, 1.05269678e-01f, -3.01007450e-01f, 4.75486442e-02f, -5.54434769e-02f, -3.42318207e-01f, 3.18672836e-01f,
  -4.20394018e-02f, 8.84620547e-02f, 1.90620452e-01f, 1.64930701e-01f, 1.20653987e-01f, 8.91007483e-02f, 1.18604593e-01f, -4.04967964e-02f, -2.47494457e-03f, -7.72957224e-03f,
  -1.45744812e-02f, -2.45476633e-01f, -2.02550497e-02f, -3.23358066e-02f, -1.13726690e-01f, 6.15489297e-02f, 8.48652497e-02f, -8.49704142e-04f, -9.86456126e-02f, 5.17662317e-02f,
  -6.68124557e-02f, 5.41303642e-02f, -2.20430754e-02f, 1.34579837e-01f, 3.17588225e-02f, 1.06773324e-01f, -1.55311506e-02f, -1.62817255e-01f, -8.65583643e-02f, 1.09400682e-01f,
  -3.01988780e-01f, -1.54513404e-01f, -2.58633047e-02f, 1.45864695e-01f, 8.70668516e-02f, 4.42801267e-02f, 1.24987319e-01f, -1.64824739e-01f, -2.55606454e-02f, -1.61915347e-01f,
  -2.01720506e-01f, -2.17778664e-02f, 1.68120965e-01f, 4.44216095e-02f, -2.55840600e-01f, -2.09740862e-01f, 9.32222139e-03f, -1.17411345e-01f, -8.54878873e-02f, 1.68415494e-02f,
  -9.17000603e-03f, -4.41541463e-01f, -6.98541462e-01f, -2.41067111e-01f, -2.42101669e-01f, -6.87548339e-01f, -2.16942012e-01f, -4.54479337e-01f, -6.07799649e-01f, -2.50872374e-01f,
  -2.88710505e-01f, 5.36121607e-01f, 8.93192112e-01f, -2.10231915e-01f, 2.02438399e-01f, 7.31934458e-02f, -2.11157024e-01f, -1.95133701e-01f, -1.62684634e-01f, 1.63289636e-01f,
  1.69716164e-01f, -5.47155082e-01f, -4.04089354e-02f, -2.82667786e-01f, -4.68884826e-01f, 6.73495010e-02f, 2.01616943e-01f, -6.10906631e-02f, -6.67415798e-01f, -7.74227083e-01f,
  -5.00205219e-01f, -3.87523204e-01f, -1.81652248e-01f, 2.18187142e-02f, 2.86765426e-01f, -6.95660636e-02f, 5.91153860e-01f, 3.26635301e-01f, 2.83742458e-01f, 3.61068577e-01f,
  1.25199944e-01f, 6.35816157e-01f, -3.02918464e-01f, -3.55848402e-01f, 1.50739670e-01f, -1.62262633e-01f, -5.38746715e-02f, 3.46140653e-01f, -9.55920201e-03f, 1.19031899e-01f,
  2.72487197e-02f, -1.10180050e-01f, 7.49617144e-02f, -2.08762437e-01f, -1.41260713e-01f, -2.70080328e-01f, -3.59463207e-02f, -9.96289477e-02f, 1.31910937e-02f, 6.22663721e-02f,
  -3.82366508e-01f, -8.78814980e-02f, 3.72277498e-01f, 1.11678980e-01f, 6.47696406e-02f, -3.35438162e-01f, 2.61991590e-01f, 1.50324360e-01f, 3.35436195e-01f, 8.32927302e-02f,
  -2.94628832e-02f, -4.29062583e-02f, -5.59434071e-02f, 9.06324610e-02f, -2.72599816e-01f, 3.44329476e-02f, -4.74179490e-03f, -1.18121125e-01f, -1.41420215e-01f, -9.30259451e-02f,
  3.97206051e-03f, 6.44252971e-02f, -1.95362121e-02f, 1.30774155e-01f, -3.35725881e-02f, 8.47441051e-03f, -1.21228583e-01f, -1.98998470e-02f, 8.96706432e-02f, 8.25454891e-02f,
  -1.83356717e-01f, -4.47178213e-03f, 1.39671624e-01f, -1.18152387e-01f, 1.98204979e-01f, 1.24344721e-01f, -1.15267359e-01f, -3.10831573e-02f, 1.92949437e-02f, 1.11364052e-01f,
  -5.19135773e-01f, 1.84519708e-01f, -1.60382703e-01f, -2.13268653e-01f, -1.36682820e-02f, 6.56674430e-02f, 5.31413853e-02f, 8.96322280e-02f, 1.20671399e-01f, -2.88468949e-03f,
  1.97068453e-01f, -9.59967971e-02f, 1.79164290e-01f, -1.77983060e-01f, -3.78403366e-01f, 1.30829411e-02f, -5.33700705e-01f, -2.79801369e-01f, -2.61538744e-01f, -1.28132910e-01f,
  -1.96284264e-01f, -5.61622143e-01f, -7.08997786e-01f, -4.40814048e-01f, -1.47768140e-01f, -5.11321127e-01f, -2.74403751e-01f, -1.79439172e-01f, -3.53187054e-01f, -5.36169350e-01f,
  -2.08168179e-01f, -2.70282328e-01f, 1.38087594e-03f, 3.65642868e-02f, -3.85437757e-01f, -3.68861169e-01f, -4.58668977e-01f, -3.33978385e-02f, -7.84750432e-02f, -3.76307189e-01f,
  -5.90509474e-01f, -1.58573374e-01f, -4.75104041e-02f, 1.02192782e-01f, 1.64021060e-01f, 1.75346259e-03f, 3.59768271e-01f, 5.14784098e-01f, 3.86513650e-01f, 2.35494643e-01f,
  1.58607826e-01f, 2.31443137e-01f, 3.97920609e-01f, 4.70413446e-01f, 4.57887501e-01f, 1.54108763e-01f, 4.96947542e-02f, 8.52261558e-02f, -1.94019750e-02f, 6.36116028e-01f,
  -4.20427233e-01f, 7.10596144e-02f, -4.21512909e-02f, -2.31578156e-01f, -5.84686510e-02f, 1.81846887e-01f, 1.50941405e-02f, 1.52051494e-01f, -6.29591895e-03f, 1.68144643e-01f,
  -1.53513849e-01f, 1.12616628e-01f, -7.05533428e-03f, 4.87947948e-02f, -7.51812651e-04f, 6.10217936e-02f, 3.02081704e-01f, 3.40144396e-01f, 4.54152040e-02f, 7.26247802e-02f,
  -5.42511493e-02f, -2.69530058e-01f, -2.85255104e-01f, -2.68698726e-02f, 1.72829181e-01f, -9.67208222e-02f, 8.23041797e-02f, 2.10216910e-01f, -3.40807468e-01f, 1.78786635e-01f,
  8.30330178e-02f, -3.97791453e-02f, 2.06626039e-02f, 1.48640662e-01f, 8.29738230e-02f, 1.39904708e-01f, 1.87201172e-01f, -4.58493158e-02f, 1.08978651e-01f, 1.58945799e-01f,
  1.45064462e-02f, -1.10639699e-01f, 2.12786511e-01f, -1.85558461e-02f, -5.91038093e-02f, -1.83491930e-01f, -8.76853466e-02f, -6.28464893e-02f, -1.72905356e-01f, -3.72630171e-02f,
  -9.45146903e-02f, -2.82706823e-02f, -1.35387080e-02f, 3.98041785e-01f, -2.56514791e-02f, 5.30927591e-02f, 8.70997459e-02f, 4.04000841e-03f, -1.81907937e-01f, -1.28309175e-01f,
  -7.02019930e-01f, -2.38533109e-01f, -5.04703857e-02f, 1.65081054e-01f, -2.50424415e-01f, -1.05674550e-01f, -1.64147168e-01f, 3.39855216e-02f, -6.63258880e-02f, -1.26065910e-01f,
  -2.05098987e-01f, -1.27381280e-01f, -8.92901793e-02f, 1.72198772e-01f, 2.96104345e-02f, -7.71857947e-02f, -3.06799617e-02f, -6.46432862e-02f, -3.16516981e-02f, 1.14405550e-01f,
  -8.26486871e-02f, -2.45299295e-01f, -6.54715240e-01f, -4.04409677e-01f, -1.37667209e-01f, -4.63782698e-01f, -1.05701424e-01f, -2.30111450e-01f, -6.69209123e-01f, -5.43605328e-01f,
  1.23384321e+00f, 4.42856640e-01f, 4.38627034e-01f, 4.86618489e-01f, 8.80644321e-02f, 3.08181733e-01f, 2.34698072e-01f, 3.23509514e-01f, 1.26216471e-01f, 3.49957198e-01f,
  2.89406955e-01f, 9.55095589e-02f, 1.96374521e-01f, 1.42411172e-01f, 2.65942931e-01f, 9.13932920e-02f, -3.39614674e-02f, 2.31469184e-01f, 2.02464342e-01f, 1.07396141e-01f,
  6.86759353e-02f, 5.85920252e-02f, 2.16858670e-01f, 1.91367760e-01f, 1.41618013e-01f, -1.33650107e-02f, 1.00758351e-01f, 9.21957195e-02f, 1.96232900e-01f, 2.18674228e-01f,
  1.78958997e-01f, 5.68922281e-01f, -1.79023877e-01f, -1.80531234e-01f, -1.16221637e-01f, -6.71119541e-02f, 2.07136109e-05f, -3.70806493e-02f, -1.10348299e-01f, -1.11473966e-02f,
  -2.23816469e-01f, -1.32152915e-01f, -5.65041192e-02f, -1.49444789e-01f, -4.02932614e-02f, -4.12460752e-02f, 7.47058308e-03f, 1.40114790e-02f, -2.89226733e-02f, 8.87684245e-03f,
  -1.06611758e-01f, -1.28026873e-01f, -1.04546949e-01f, -8.97962973e-02f, 1.19679928e-01f, -9.96178463e-02f, 7.65304221e-03f, 7.81965554e-02f, 2.39262171e-02f, 9.70905349e-02f,
  -5.68561703e-02f, 2.09379971e-01f, 1.90517455e-01f, 9.03195143e-02f, 1.92184433e-01f, 7.23679143e-04f, 6.09095581e-02f, 3.20918486e-02f, 1.82182580e-01f, -5.23114502e-02f,
  -1.63567767e-01f, 8.86298716e-02f, 1.12662278e-01f, -1.89443957e-02f, 3.81919034e-02f, -2.79928129e-02f, -2.56665889e-02f, -8.63818228e-02f, 1.01212174e-01f, -1.31755665e-01f,
  5.67281060e-02f, -1.75398424e-01f, -1.21799827e-01f, -4.42246795e-02f, -2.73368388e-01f, 1.36427969e-01f, 8.35241079e-02f, -7.40589723e-02f, -4.83842716e-02f, -1.50257081e-01f,
  -5.58864892e-01f, -5.42410724e-02f, 1.54375449e-01f, -1.39137954e-01f, -9.15513486e-02f, 2.71901791e-03f, 1.24764599e-01f, -1.06235079e-01f, -8.41201469e-02f, -2.53757108e-02f,
  -1.42056137e-01f, -6.25419477e-03f, -2.87056714e-02f, -1.32167071e-01f, -2.23391533e-01f, -2.18850195e-01f, -1.24288350e-01f, -4.21776511e-02f, -1.28099486e-01f, -1.99453712e-01f,
  -2.92859942e-01f, -1.81422740e-01f, -1.45233512e-01f, -1.12037480e-01f, -7.41114989e-02f, -2.52187580e-01f, -1.80420011e-01f, -2.86014348e-01f, -1.82702631e-01f, -6.78230077e-02f,
  -5.46205223e-01f, 3.22847337e-01f, -7.21476912e-01f, -3.80917072e-01f, -3.72580349e-01f, -1.21252857e-01f, 7.46569991e-01f, 5.19766271e-01f, -1.00665011e-01f, 4.36218530e-01f,
  -7.74668157e-02f, -5.97224474e-01f, -7.29671419e-01f, -9.83791649e-02f, 1.80007741e-01f, 4.51571375e-01f, -1.29917368e-01f, -4.38899219e-01f, -2.47911841e-01f, 4.21424627e-01f,
  4.95483160e-01f, -5.34228310e-02f, -3.22394311e-01f, -3.04243445e-01f, -1.28502786e-01f, -6.11175179e-01f, -4.79321837e-01f, -3.01775336e-01f, -2.06827044e-01f, -3.45826656e-01f,
  1.02394402e-01f, -5.14874816e-01f, -2.44763941e-01f, -3.86445969e-01f, -6.41823858e-02f, -2.81202327e-02f, 1.51244000e-01f, -2.84251839e-01f, -1.77795738e-02f, 3.42164673e-02f,
  -4.77362216e-01f, -6.66779093e-03f, -3.02937686e-01f, -1.57805756e-01f, -1.01477452e-01f, 6.74414542e-03f, -1.24323346e-01f, -2.97996968e-01f, -1.60864264e-01f, 1.57247543e-01f,
  2.30393857e-01f, -4.16451603e-01f, -5.33265889e-01f, 1.71192124e-01f, -1.04913160e-01f, -4.31250244e-01f, 2.10511405e-02f, -1.56734928e-01f, -3.13910544e-01f, 3.68159384e-01f,
  2.88114846e-01f, -4.12015524e-03f, -5.18302284e-02f, 8.32937136e-02f, 3.09515119e-01f, -1.07793426e-02f, -1.36535197e-01f, -3.69061381e-02f, -3.66667099e-02f, 1.28756434e-01f,
  3.08101270e-02f, 1.21080168e-01f, -5.12599982e-02f, -6.06811792e-02f, -6.03152663e-02f, -1.54545873e-01f, 2.52254382e-02f, 2.65914410e-01f, -6.61415830e-02f, -3.04468512e-03f,
  -1.72312874e-02f, -1.36439279e-01f, -2.29235917e-01f, 1.17405005e-01f, 7.52644688e-02f, -9.00132209e-02f, -1.16626173e-01f, -2.04709489e-02f, 1.23535238e-01f, -1.00286275e-01f,
  3.29272091e-01f, -1.76327601e-01f, 1.94394201e-01f, -2.08157599e-02f, -1.71660855e-01f, 4.70812619e-02f, -3.59375738e-02f, 1.93693817e-01f, -1.79458886e-01f, 8.27824175e-02f,
  2.82834042e-02f, 2.19188584e-03f, -1.03933938e-01f, -1.19761582e-02f, -2.62158141e-02f, 3.00572421e-02f, 3.45226854e-01f, -1.42898830e-02f, -5.36689125e-02f, 9.40428078e-02f,
  3.45349044e-01f, 2.82900751e-01f, 2.00000793e-01f, 1.87778994e-01f, 9.93823856e-02f, -2.27369264e-01f, 7.60251656e-02f, 1.05842166e-01f, -6.69569056e-03f, 1.08027899e+00f,
  -2.60070920e-01f, -2.31385916e-01f, -6.00431561e-01f, -1.84509382e-01f, 4.59177094e-03f, -1.04086548e-02f, 4.87946486e-03f, 1.31917417e-01f, 3.44710350e-02f, -2.33036384e-01f,
  2.76263915e-02f, 5.80910146e-02f, -6.42260253e-01f, -3.57708603e-01f, -6.22103512e-01f, -7.77083516e-01f, -8.31624925e-01f, -7.53798187e-01f, -1.07593358e-01f, 7.10469544e-01f,
  2.91802347e-01f, -1.24017909e-01f, -1.68791100e-01f, -1.33082606e-02f, 1.11765869e-01f, -1.88109174e-01f, -4.12594855e-01f, -2.76552022e-01f, -2.08132818e-01f, -4.25497681e-01f,
  -9.96673629e-02f, 8.34822580e-02f, -9.09508094e-02f, 9.36127082e-03f, -1.60321310e-01f, 1.09750414e-02f, 1.83275923e-01f, -2.50458390e-01f, 3.32359597e-02f, -2.28189826e-02f,
  1.41015917e-01f, 2.86601007e-01f, 1.42988130e-01f, 1.29323438e-01f, 1.13912635e-01f, 8.78126249e-02f, -2.99108922e-01f, -2.55758524e-01f, -2.77424663e-01f, 1.65052012e-01f,
  1.95165142e-01f, -1.10604100e-01f, -5.16829669e-01f, -9.39784721e-02f, 5.56785539e-02f, -3.54237318e-01f, 6.25759363e-02f, 2.56773442e-01f, -2.90157527e-01f, -2.23884672e-01f,
  1.01980381e-01f, -2.58381478e-02f, 1.32673413e-01f, -4.18407544e-02f, -2.98546534e-02f, 1.14049971e-01f, -2.76323454e-03f, 1.36575088e-01f, 1.21272020e-01f, -1.61359366e-02f,
  4.42222841e-02f, -4.85067926e-02f, 7.29689151e-02f, 7.51927346e-02f, -7.76904300e-02f, -1.87942430e-01f, -1.46123722e-01f, -2.32095748e-01f, -1.93153575e-01f, -5.46469092e-02f,
  -7.77558386e-02f, -3.41320820e-02f, -3.07896063e-02f, 4.72200243e-03f, -5.67394160e-02f, -1.49078831e-01f, -4.64441553e-02f, 1.69683639e-02f, 1.42005356e-02f, 1.50151268e-01f,
  -5.46763949e-02f, -1.77681819e-01f, -1.96583107e-01f, -6.64048940e-02f, -1.86277688e-01f, 5.66455834e-02f, -6.46770140e-03f, -1.93066485e-02f, -4.90952283e-02f, 2.13825718e-01f,
  1.92202330e-01f, 2.16647908e-01f, 6.14993423e-02f, 1.86737180e-01f, 2.19274804e-01f, 2.61513796e-02f, -1.72230214e-01f, -2.96233475e-01f, -3.78754525e-03f, 3.20238858e-01f,
  -1.16858169e-01f, -3.10115218e-01f, -5.92047632e-01f, -3.83893907e-01f, 9.57480818e-02f, -3.02146405e-01f, -2.85324335e-01f, -6.89979345e-02f, -5.74039638e-01f, -5.63641906e-01f,
  9.20870602e-02f, 7.07927942e-01f, -2.53395826e-01f, 1.96443394e-01f, 6.60180926e-01f, 4.06503111e-01f, 5.90858936e-01f, 9.90789235e-02f, 1.25391632e-01f, 3.22624266e-01f,
  4.40519780e-01f, 1.53160185e-01f, 3.61048654e-02f, -1.56927273e-01f, -2.48787224e-01f, -5.41454703e-02f, -2.23608166e-02f, -5.14887750e-01f, -3.62845361e-01f, 3.34419943e-02f,
  3.51757318e-01f, 4.51346874e-01f, 9.87520907e-03f, -1.36357576e-01f, 1.78601235e-01f, 5.38304746e-02f, 3.09517771e-01f, 5.78883708e-01f, 3.29769522e-01f, -1.65089458e-01f,
  -3.12835157e-01f, 1.45020798e-01f, -5.27289867e-01f, 2.73237467e-01f, -5.68884201e-02f, -2.66174883e-01f, -1.98669255e-01f, -2.09751025e-01f, 7.17497766e-02f, -1.63724750e-01f,
  3.31472516e-01f, 1.99378371e-01f, 4.66207951e-01f, 1.03748731e-01f, 2.73054987e-01f, 1.04048304e-01f, 1.76034775e-02f, -2.80107558e-01f, -3.93035710e-01f, -1.66953877e-01f,
  1.47606254e-01f, 3.02315444e-01f, 1.73991382e-01f, -1.04948930e-01f, -4.13378149e-01f, -1.02003589e-01f, 1.89649295e-02f, -2.30778202e-01f, -4.19701844e-01f, -3.90083641e-01f,
  -1.19359687e-01f, -1.72406152e-01f, 6.72038123e-02f, -5.71369864e-02f, 1.62881240e-01f, -4.33882065e-02f, -3.71113047e-02f, 1.63201258e-01f, 8.45072940e-02f, 1.35253087e-01f,
  -7.89642259e-02f, -2.12435156e-01f, -2.24853680e-01f, -1.72512084e-01f, -9.19379070e-02f, -2.25875042e-02f, -8.21464285e-02f, -1.38243288e-01f, -5.31856110e-03f, -1.18805297e-01f,
  -6.51487932e-02f, -2.54157454e-01f, -1.35013461e-01f, -1.69021294e-01f, -1.35441884e-01f, -2.87464857e-01f, -3.13309252e-01f, -8.90868530e-02f, 6.57242388e-02f, -2.24153977e-02f,
  1.48781553e-01f, 2.97359582e-02f, -5.84757030e-01f, -1.51667237e-01f, 4.93816286e-02f, 3.92209478e-02f, -7.79739693e-02f, -5.29899932e-02f, 1.43833444e-01f, -3.08688849e-01f,
  4.48216237e-02f, -3.50802332e-01f, 3.07540745e-01f, -2.37881988e-01f, -3.28486785e-02f, -8.83060694e-02f, 2.55504310e-01f, -1.57325163e-01f, -1.37357816e-01f, -1.04673825e-01f,
  -2.34184843e-02f, -2.24822327e-01f, -1.64664447e-01f, -3.36030960e-01f, -3.96534562e-01f, -2.93121576e-01f, -2.38769457e-01f, -1.84065893e-01f, -1.89738706e-01f, -8.90333578e-02f,
  -1.03752768e+00f, 2.13505745e-01f, 2.06676543e-01f, -1.25993833e-01f, 4.58646864e-02f, -1.81384027e-01f, 4.30517830e-02f, -2.93653280e-01f, -1.10661432e-01f, 2.67401248e-01f,
  7.32706264e-02f, 6.42192066e-02f, 2.95175791e-01f, 5.03634922e-02f, -2.29463190e-01f, 4.16602284e-01f, 3.71900231e-01f, -2.42846996e-01f, -7.59874880e-01f, -8.43574703e-01f,
  -3.67707789e-01f, -3.46287876e-01f, -6.83399916e-01f, -3.08675170e-01f, 1.74714327e-01f, 4.25048806e-02f, 4.17270690e-01f, -3.73014398e-02f, -6.58095554e-02f, 7.37280846e-02f,
  4.33996707e-01f, -3.44859958e-01f, 9.64432731e-02f, -1.93523496e-01f, 1.17054217e-01f, -1.64364606e-01f, -1.90423071e-01f, -4.32536501e-04f, -5.17140552e-02f, 1.52917936e-01f,
  -1.13824546e-01f, -5.94201125e-02f, 6.12416901e-02f, 3.46193202e-02f, -5.50405681e-02f, -1.92558527e-01f, 4.37832475e-02f, -8.92844424e-02f, 1.73048377e-01f, 1.32568851e-01f,
  6.01447821e-02f, -1.99360415e-01f, 1.77804857e-01f, 7.29004368e-02f, -1.24408612e-02f, -1.19219929e-01f, 9.35488343e-02f, -2.00882047e-01f, 1.54636963e-03f, 2.02901606e-02f,
  3.02950460e-02f, 2.86702007e-01f, -8.27020258e-02f, -2.00866684e-02f, -8.04345533e-02f, 1.45200208e-01f, 1.03413180e-01f, 3.98912206e-02f, 1.82329118e-02f, 9.10335779e-02f,
  1.16239667e-01f, 5.12498058e-02f, 2.49270201e-02f, 9.95472521e-02f, -1.19678020e-01f, 4.38560061e-02f, -1.83625594e-01f, -1.28601313e-01f, 5.10628223e-02f, -5.29225729e-02f,
  -1.06714657e-02f, 6.92116190e-03f, 7.94225931e-03f, 1.74895320e-02f, -8.85604545e-02f, -2.02448238e-02f, 9.57592800e-02f, -2.54930437e-01f, -9.86252949e-02f, -7.24568814e-02f,
  4.10365731e-01f, -2.19626084e-01f, 3.90363008e-01f, 4.78103422e-02f, -3.15127671e-02f, -4.31979299e-02f, 1.80948693e-02f, -1.68716118e-01f, -1.08782081e-02f, -1.09118186e-01f,
  -2.21409187e-01f, -9.70404968e-02f, 1.19309947e-01f, 7.91711807e-02f, -1.13757603e-01f, -2.00778827e-01f, 6.61439225e-02f, 1.00656986e-01f, 8.39880556e-02f, 1.66726276e-01f,
  1.25074342e-01f, -1.15117624e-01f, 9.39635634e-02f, 2.64170140e-01f, 3.67782302e-02f, -8.20641890e-02f, 1.31114602e-01f, -3.61340195e-02f, 3.66838202e-02f, 1.97544858e-01f,
  -1.10638630e+00f, 3.86015117e-01f, 1.20095551e-01f, -3.60072136e-01f, 5.57015061e-01f, 7.44021952e-01f, 1.00279689e+00f, 2.85837710e-01f, -1.16649918e-01f, -6.43476006e-03f,
  -8.94304514e-02f, -3.43281835e-01f, -3.31510752e-01f, -1.48903519e-01f, 9.40638855e-02f, 5.10228336e-01f, 2.54699677e-01f, -1.15067452e-01f, -1.04260437e-01f, 2.04903215e-01f,
  2.00615078e-01f, -2.69125700e-01f, -6.26757801e-01f, -2.69627541e-01f, -2.26102695e-02f, -1.23285912e-01f, -7.93998763e-02f, -9.68979746e-02f, 2.65274554e-01f, 1.25623479e-01f,
  -6.71252668e-01f, -5.15588447e-02f, 1.32583603e-01f, -3.54744852e-01f, -1.42434999e-01f, -1.32683411e-01f, 3.01431143e-03f, -3.46030384e-01f, -7.11734989e-04f, -7.86016136e-02f,
  -2.07407892e-01f, -8.87089223e-02f, -2.05404177e-01f, 1.79384276e-01f, -1.52470976e-01f, -7.82082453e-02f, -9.63077098e-02f, -2.45301768e-01f, -3.48395824e-01f, -3.85509953e-02f,
  2.68907696e-01f, 1.12175204e-01f, -1.17521495e-01f, 2.66107142e-01f, 1.89404875e-01f, -9.35807526e-02f, 1.10210583e-01f, 5.54550998e-02f, -2.28114188e-01f, -4.62195098e-01f,
  -9.71080959e-02f, -8.74771737e-03f, 2.11985096e-01f, 1.18582003e-01f, 4.81061004e-02f, 1.12483196e-01f, -9.89489555e-02f, 2.24418454e-02f, -4.66978252e-02f, -4.14759293e-03f,
  1.17352055e-02f, -1.02113642e-01f, 1.22637138e-01f, -8.07902515e-02f, -5.01464941e-02f, -4.94120643e-02f, 1.85277522e-01f, -1.99800178e-01f, -1.34814277e-01f, 8.42649937e-02f,
  -3.80254872e-02f, 7.76771307e-02f, -2.20755026e-01f, -6.27890648e-03f, 9.17266384e-02f, 7.89760891e-03f, -4.83175106e-02f, -3.90463583e-02f, -1.16309039e-01f, 2.30917335e-01f,
  -7.75144160e-01f, 3.48780096e-01f, -4.77827996e-01f, -1.13113753e-01f, 8.00737515e-02f, -5.31694032e-02f, -3.75936702e-02f, -7.34417439e-02f, 5.82726151e-02f, -9.78316888e-02f,
  2.94301119e-02f, 3.71907949e-02f, -3.40108499e-02f, 9.60033908e-02f, 2.47553573e-03f, 9.53662619e-02f, 9.73108038e-02f, -3.16267125e-02f, -2.39797086e-02f, 1.47359457e-03f,
  1.27337709e-01f, 2.11435676e-01f, -3.03869396e-01f, 1.86560497e-01f, 8.63871947e-02f, -1.34652806e-02f, -3.08937114e-02f, 5.96636757e-02f, -7.76016638e-02f, -2.66375571e-01f,
  1.28574252e-01f, -6.35911644e-01f, 5.05414188e-01f, 1.65150747e-01f, 2.53948510e-01f, 5.18733919e-01f, 2.39343837e-01f, 6.46230206e-02f, -7.62482658e-02f, -7.63467401e-02f,
  -4.08222735e-01f, 3.33149694e-02f, -4.51089405e-02f, 1.19296405e-02f, 1.28128771e-02f, 1.22561485e-01f, 1.77674219e-01f, 2.57148385e-01f, 5.43324172e-01f, 2.86189407e-01f,
  -2.06258874e-02f, -2.42321566e-01f, -2.26240039e-01f, -1.83707029e-01f, -3.70427698e-01f, 9.82712135e-02f, -2.71394551e-01f, -3.72355372e-01f, -3.29751998e-01f, -3.47766936e-01f,
  1.36591494e-01f, -4.22824353e-01f, 8.30903128e-02f, -3.58473659e-01f, -1.55241117e-01f, -5.16286232e-02f, 1.11611173e-01f, -1.71842784e-01f, -5.85330538e-02f, -8.06347933e-03f,
  -1.59171015e-01f, -1.42226458e-01f, -3.00638564e-02f, -2.25050509e-01f, -3.40586305e-02f, -7.70058110e-02f, -2.92727560e-01f, -1.68430597e-01f, -1.24502555e-01f, -1.19517401e-01f,
  -2.80346870e-01f, -1.26901239e-01f, 1.16980355e-02f, -5.54775912e-03f, -6.63920864e-03f, 4.06919606e-02f, -8.47352818e-02f, -7.58891925e-02f, -3.70588414e-02f, -1.32212356e-01f,
  -2.09124945e-02f, -4.71727997e-02f, -1.30570782e-02f, 3.91476266e-02f, 1.68548003e-01f, 1.43465579e-01f, 1.84492990e-01f, -2.24892162e-02f, 4.20874022e-02f, -1.41438231e-01f,
  -2.23269537e-02f, 4.56077047e-02f, 1.74906254e-02f, -8.09585582e-03f, 4.53827940e-02f, -6.71981201e-02f, -8.42153002e-03f, -5.82996979e-02f, -1.13805190e-01f, -6.45091664e-03f,
  -1.11630619e-01f, -1.64027601e-01f, -8.56556669e-02f, -4.70475666e-02f, -1.89729288e-01f, -2.05454864e-02f, -1.37416750e-01f, -1.36159673e-01f, -1.48716941e-01f, -9.41266045e-02f,
  -3.17090526e-02f, 2.47452334e-02f, 2.56604463e-01f, -1.81648016e-01f, -1.25762209e-01f, -1.45113483e-01f, 9.86019149e-02f, 7.08768666e-02f, -6.31104782e-02f, 6.02396019e-02f,
  -1.86962355e-02f, 4.62187640e-02f, -1.09299742e-01f, -1.43380985e-01f, 1.90984160e-01f, -4.72046882e-02f, -2.15754554e-01f, 7.87787959e-02f, -1.49312302e-01f, -2.31708571e-01f,
  -2.24809825e-01f, 1.82302684e-01f, 3.50877762e-01f, 2.10065633e-01f, 3.33078317e-02f, 2.82842726e-01f, 1.06878452e-01f, 1.95198253e-01f, 2.31979445e-01f, 1.91603497e-01f,
  1.17037964e+00f, -3.23795438e-01f, -1.28541875e+00f, 5.19880690e-02f, -8.88024390e-01f, -7.02985585e-01f, -4.83976841e-01f, 2.69694831e-02f, 3.79001200e-01f, -2.31401265e-01f,
  -1.33237198e-01f, 2.56784856e-01f, 7.88494796e-02f, -1.71058461e-01f, -9.94885154e-03f, -6.14836812e-01f, -6.34864986e-01f, -6.38512909e-01f, -3.54788601e-01f, -3.34799051e-01f,
  -3.91599149e-01f, -2.86152065e-01f, -1.50755048e-01f, -2.12578654e-01f, -3.63594472e-01f, -1.16644733e-01f, -4.03173953e-01f, -4.28100139e-01f, -5.64413607e-01f, -5.08579493e-01f,
  -8.78600359e-01f, -6.29781634e-02f, 1.03273705e-01f, 1.38786241e-01f, -6.43505678e-02f, 1.19012959e-01f, -2.86845099e-02f, 4.01699431e-02f, 2.66640842e-01f, 5.72115891e-02f,
  -1.26813930e-02f, 1.24846742e-01f, 6.47025034e-02f, -6.22206442e-02f, -2.27387361e-02f, -2.03474779e-02f, -1.05324816e-02f, 9.60605294e-02f, 9.76624563e-02f, -5.14860302e-02f,
  -1.06051750e-01f, -3.03382985e-02f, 1.96964536e-02f, 2.08421975e-01f, 1.57919213e-01f, 8.99252892e-02f, 1.33166378e-02f, 1.15098767e-01f, 6.19489774e-02f, 1.90354005e-01f,
  -3.71922076e-01f, -5.66810891e-02f, 3.13654095e-02f, 6.15752041e-02f, 1.07699499e-01f, 7.68645257e-02f, 6.13935739e-02f, -5.50451502e-02f, 4.88482863e-02f, 7.21490160e-02f,
  1.30997807e-01f, 2.03641336e-02f, 2.16791369e-02f, -1.44007340e-01f, -2.16999218e-01f, 5.35368621e-02f, 1.20248340e-01f, -1.30076438e-01f, 1.26889748e-02f, 1.12181753e-01f,
  1.60875097e-01f, 1.82535443e-02f, -3.20980400e-02f, -1.48070246e-01f, -1.13433950e-01f, -3.42640094e-02f, -1.90715236e-03f, -1.16276648e-02f, 1.85234211e-02f, 7.23736584e-02f,
  6.13383129e-02f, 1.25301285e-02f, -1.18722646e-02f, 1.86246380e-01f, 2.19011456e-02f, -1.49517655e-02f, -4.01494317e-02f, -3.92378867e-02f, -7.86853731e-02f, -1.49669766e-01f,
  -2.06092164e-01f, -5.76742925e-02f, -2.43589461e-01f, -3.58667523e-02f, 5.13167232e-02f, -1.49541367e-02f, 1.15056001e-01f, 6.15435503e-02f, 1.08079351e-01f, -1.40290959e-02f,
  -3.33784404e-03f, 2.30488494e-01f, 2.70897597e-01f, 2.07644105e-01f, 2.83333790e-02f, 9.74141061e-02f, -5.35291471e-02f, 9.64299440e-02f, 1.17559351e-01f, 3.18994313e-01f,
  -7.24429905e-01f, -1.40486032e-01f, -6.38639688e-01f, 2.46304125e-01f, -1.55791909e-01f, -2.61554867e-01f, -1.09198041e-01f, -2.42402256e-02f, 2.41583046e-02f, -3.73859584e-01f,
  -4.51786578e-01f, 8.12598038e-03f, -1.11328080e-01f, 6.75478727e-02f, -1.58803575e-02f, -4.56479937e-02f, 1.91884503e-01f, 1.47937402e-01f, 1.28463373e-01f, 1.80636778e-01f,
  4.23445255e-01f, 7.01918423e-01f, 4.98461574e-01f, 2.63686925e-01f, 2.07727984e-01f, 3.66257906e-01f, 1.52976587e-01f, 2.53484011e-01f, -1.31511733e-01f, -1.13249041e-01f,
  -8.78600717e-01f, -4.71349239e-01f, -1.09676355e-02f, 8.28858092e-02f, -6.68793321e-02f, -7.41908699e-02f, -1.79875448e-01f, 3.53940646e-03f, -3.63535643e-01f, -7.24320337e-02f,
  -2.41968021e-01f, -2.90198147e-01f, -1.74309701e-01f, 6.62604123e-02f, -1.99732095e-01f, -2.81563222e-01f, 1.45107299e-01f, 5.80194853e-02f, 2.61184033e-02f, -4.43690568e-01f,
  2.58567244e-01f, -2.94473451e-02f, -6.21340215e-01f, -4.16979566e-02f, -2.50783265e-01f, 1.90106302e-01f, -1.57409683e-01f, -1.93040937e-01f, -2.10241005e-02f, -2.49636278e-01f,
  -8.99647176e-02f, -1.50145605e-01f, -1.32828327e-02f, 9.83534902e-02f, 1.44321933e-01f, -1.43716916e-01f, 2.23559258e-03f, 1.52565524e-01f, -9.10256803e-02f, -1.99635714e-01f,
  -1.50945678e-01f, -1.81638926e-01f, 2.66234260e-02f, -9.43025723e-02f, 6.89661279e-02f, 1.04143903e-01f, -1.29407421e-01f, 4.18592542e-01f, 1.34284243e-01f, 9.21625048e-02f,
  -2.61196308e-02f, -7.05584437e-02f, 1.80233881e-01f, 7.01264367e-02f, 6.05481192e-02f, 1.72535703e-01f, 2.00998455e-01f, 8.52990746e-02f, 1.32216558e-01f, -6.48703426e-02f,
  4.99765277e-01f, 4.99410868e-01f, -5.31159878e-01f, 2.22189173e-01f, -4.97513972e-02f, -8.39825347e-03f, -2.59392485e-02f, 1.56516004e-02f, -2.66879380e-01f, -9.25144628e-02f,
  -1.12945244e-01f, -3.02205265e-01f, 3.36519117e-03f, 5.24318293e-02f, -3.13864052e-01f, -2.78458148e-01f, -2.12812439e-01f, -6.15960956e-02f, -4.02373960e-03f, -2.01479480e-01f,
  9.04093608e-02f, 2.03280617e-03f, -4.40833509e-01f, -4.37889516e-01f, -2.61556447e-01f, -8.60368386e-02f, -2.51354545e-01f, -1.53697774e-01f, -2.87374079e-01f, -1.48277998e-01f,
  -1.22488725e+00f, 8.58871639e-02f, 4.32869941e-01f, -7.47760952e-01f, -3.05117279e-01f, -3.75534110e-02f, 1.36963740e-01f, -1.32913455e-01f, -2.62215853e-01f, 9.33152363e-02f,
  3.01794052e-01f, 2.36106645e-02f, 4.07700613e-02f, 1.01558510e-02f, -2.67454356e-01f, 9.20074508e-02f, -2.08677053e-01f, -6.10096335e-01f, -5.68744600e-01f, -2.64042854e-01f,
  -2.76969284e-01f, -7.21759617e-01f, -6.29283249e-01f, -2.13805646e-01f, 1.57122135e-01f, -3.64027135e-02f, 1.81659684e-01f, -3.07842046e-01f, 8.30489025e-02f, -1.25239670e-01f,
  4.29892510e-01f, -2.07760960e-01f, -1.03288017e-01f, -2.86213130e-01f, 3.65359429e-03f, -6.01161718e-02f, 4.12971005e-02f, 3.51529904e-02f, -5.17097861e-02f, -5.74610159e-02f,
  -1.76114455e-01f, -7.22708404e-02f, -6.41757995e-02f, 1.43724993e-01f, -6.92641065e-02f, -5.31485165e-03f, -3.46534476e-02f, -4.16504256e-02f, 3.52937840e-02f, 3.83830190e-01f,
  3.00944328e-01f, -2.00995486e-02f, 1.19057782e-01f, 1.76226363e-01f, 1.83443800e-01f, -2.34812111e-01f, 2.91924417e-01f, 4.41731177e-02f, 1.43417314e-01f, 5.73272370e-02f,
  -2.70902943e-02f, 6.78534210e-02f, 3.14122960e-02f, 2.25922093e-03f, -4.13870811e-02f, -7.95010775e-02f, 1.92969944e-02f, -5.93717676e-03f, 1.10473791e-02f, 3.78913130e-03f,
  -4.07878421e-02f, 4.51137349e-02f, -5.12180589e-02f, -1.12299129e-01f, 5.29951937e-02f, -5.87955862e-02f, -1.19041152e-01f, 8.78226683e-02f, 1.27898693e-01f, -1.10650197e-01f,
  -1.65625528e-01f, 6.38268702e-03f, -1.26690213e-02f, 4.65409569e-02f, 5.78669198e-02f, -2.47314125e-02f, -9.58320592e-03f, 2.78517064e-02f, 6.75840899e-02f, -6.11810982e-02f,
  2.00500488e-02f, -2.28833526e-01f, -1.37701720e-01f, 7.10362475e-03f, 2.86803246e-02f, 2.07460806e-01f, 2.10817307e-01f, -7.16087669e-02f, -1.58677638e-01f, 2.57557724e-02f,
  1.21459849e-01f, -1.31847411e-01f, -2.62393784e-02f, 1.28020093e-01f, -7.87586272e-02f, 5.23965284e-02f, -2.09741760e-02f, -1.17898192e-02f, 1.30128711e-01f, 2.16918886e-01f,
  1.79012284e-01f, -1.88016772e-01f, -1.45799264e-01f, 1.51948139e-01f, 6.93786331e-03f, -1.98901251e-01f, 1.75502285e-01f, 9.36286449e-02f, -1.13826580e-01f, -1.48685509e-02f,
  9.61957220e-03f, -1.68524668e-01f, -1.15981027e-01f, 4.34336573e-01f, 1.57172471e-01f, -2.09992126e-01f, -3.90206575e-01f, 3.51680607e-01f, 5.23283660e-01f, -2.92132854e-01f,
  -7.83003941e-02f, 1.08493343e-01f, -4.48288918e-02f, -3.02771002e-01f, -4.35963899e-01f, -6.66861892e-01f, -5.85730493e-01f, -3.94061595e-01f, -1.29031956e-01f, -1.70259818e-01f,
  -2.09080324e-01f, 8.79844800e-02f, -3.97213586e-02f, -5.00637144e-02f, 4.21603285e-02f, -3.69555457e-03f, -1.18891776e-01f, -1.03043079e-01f, -5.50460875e-01f, -5.42972684e-01f,
  -5.12964785e-01f, 2.95854360e-01f, 1.01236394e-02f, 3.87947969e-02f, 9.78469551e-02f, 6.94978163e-02f, 2.23710611e-01f, 2.65532464e-01f, 1.79888472e-01f, -1.14426263e-01f,
  -8.52724612e-02f, -5.80363311e-02f, 1.08239219e-01f, 5.78220421e-03f, 5.66343479e-02f, 6.96943328e-02f, 2.04571858e-01f, -6.30790368e-02f, -1.89717218e-01f, -1.57618880e-01f,
  -1.63652614e-01f, -2.87982404e-01f, -3.78033407e-02f, 5.78485653e-02f, 5.75677864e-02f, -6.23350479e-02f, 1.95735078e-02f, 1.48057699e-01f, 6.45493120e-02f, -4.33641523e-02f,
  1.34930834e-01f, -7.67816007e-02f, 4.39508185e-02f, 1.87488973e-01f, -3.53572816e-02f, 6.51572272e-03f, -1.63820535e-01f, -4.24542338e-01f, -2.22525358e-01f, 7.40264207e-02f,
  1.15147047e-01f, -1.15065686e-01f, 2.48052757e-02f, -4.85611148e-02f, -2.30531499e-01f, -2.10031703e-01f, -2.63090134e-01f, -2.32551247e-01f, -3.45818520e-01f, -1.73188865e-01f,
  -1.34553537e-01f, -1.47291005e-01f, 9.95426252e-02f, 2.27807574e-02f, -7.05749318e-02f, 1.85613371e-02f, -5.56661971e-02f, 2.64814887e-02f, 1.68986514e-01f, -2.49324813e-02f,
  2.60334641e-01f, -1.45245090e-01f, -2.36711577e-01f, -4.50386629e-02f, -3.17014724e-01f, 7.35951141e-02f, -1.32305836e-02f, -1.93906613e-02f, -1.06176529e-02f, 4.59149033e-02f,
  -1.56987190e-01f, -2.33508229e-01f, -9.33681708e-03f, 9.93317217e-02f, -5.53855347e-03f, 3.51465829e-02f, -2.91307390e-01f, -3.17568213e-01f, -1.76967070e-01f, -6.46588355e-02f,
  1.12407096e-02f, -3.49701881e-01f, -3.44076991e-01f, -8.72644968e-03f, 1.59690306e-01f, -1.25171840e-01f, -3.04723591e-01f, 8.48767930e-04f, -2.75684029e-01f, -2.11717248e-01f,
  -2.07893342e-01f, -8.12467813e-01f, 3.72492254e-01f, -6.37704954e-02f, 2.88806744e-02f, 1.05005726e-01f, -7.73872659e-02f, -7.02904910e-02f, -1.08489774e-01f, -2.97993392e-01f,
  -2.28638157e-01f, 6.47211745e-02f, 2.67199278e-01f, 2.11052701e-01f, 2.11082816e-01f, 6.92964047e-02f, 1.90715194e-01f, 5.26958942e-01f, 3.95224720e-01f, 1.26370052e-02f,
  -1.60857007e-01f, -2.13054806e-01f, 2.17914116e-02f, 1.30289877e-02f, -2.06081644e-01f, 6.76627457e-02f, -7.20533580e-02f, -2.29485512e-01f, -2.45384634e-01f, -2.99288422e-01f,
  1.59146249e-01f, -4.13772911e-01f, 1.47407562e-01f, -2.02395558e-01f, -1.74916551e-01f, -2.96009313e-02f, -4.31142561e-02f, -1.35985300e-01f, -1.99334100e-01f, -1.19644433e-01f,
  -6.53722063e-02f, -4.13161516e-02f, -4.62676622e-02f, -1.74187765e-01f, -1.06842004e-01f, -1.04928210e-01f, -1.51378185e-01f, 4.17443179e-02f, -3.98291424e-02f, -5.31475879e-02f,
  -1.76285490e-01f, -7.17098117e-02f, 3.85580473e-02f, 9.88736972e-02f, 7.98060298e-02f, 6.28873780e-02f, -7.56408498e-02f, 9.58240684e-03f, 5.51633984e-02f, -1.59950137e-01f,
  2.23482735e-02f, -9.77246985e-02f, 3.85688283e-02f, 9.12573636e-02f, 3.67570519e-02f, 9.46777984e-02f, 4.72089369e-03f, -3.60604422e-03f, 1.90347835e-01f, -5.96984327e-02f,
  -1.43092826e-01f, 3.22195627e-02f, 1.05199456e-01f, -1.42970726e-01f, 3.09814624e-02f, -8.80141184e-02f, 8.88587907e-03f, -1.43383175e-01f, -3.22695039e-02f, -1.71694439e-03f,
  -4.49302122e-02f, -3.48051749e-02f, -1.11192644e-01f, -2.46945433e-02f, -2.04164043e-01f, -4.61155511e-02f, -1.01159476e-01f, -3.97724807e-02f, 5.00239022e-02f, -5.24826385e-02f,
  7.25344941e-02f, 2.99119055e-01f, 1.48551896e-01f, 1.00332033e-02f, -7.03409165e-02f, -1.62210926e-01f, 1.62264809e-03f, -9.62101072e-02f, -4.14912309e-03f, -5.10206819e-02f,
  -1.85899585e-01f, -1.58902071e-02f, -1.24231204e-01f, -8.49522874e-02f, 1.08507715e-01f, 6.93962276e-02f, -1.22224391e-01f, 9.87328514e-02f, 3.80127653e-02f, -7.96549395e-02f,
  -3.18658464e-02f, 7.79649569e-03f, 2.02327877e-01f, 2.19807461e-01f, 2.37262659e-02f, 3.30535173e-01f, 1.95876762e-01f, -2.12711375e-02f, 1.29437670e-01f, -1.54110994e-02f,
  1.01331782e+00f, 2.13705391e-01f, 1.42791286e-01f, 1.00317463e-01f, 1.08025998e-01f, 4.07678366e-01f, 5.55840194e-01f, 3.27554435e-01f, 8.11849535e-03f, 7.65986368e-02f,
  2.00481042e-01f, -1.23054773e-01f, -1.91224843e-01f, -1.15421228e-01f, -5.40896654e-02f, -5.61134191e-03f, -2.86072612e-01f, 3.93040925e-02f, -1.91586409e-02f, 7.81562850e-02f,
  -1.36726186e-01f, 9.92331132e-02f, 3.48020166e-01f, -3.35000865e-02f, -3.01230311e-01f, -3.23166490e-01f, -6.73321076e-03f, 1.18308991e-01f, 6.00694725e-03f, -5.88640273e-01f,
  -3.66920441e-01f, 2.97944158e-01f, -1.47291660e-01f, -1.42043784e-01f, 3.06658633e-02f, -5.71823195e-02f, 9.64884162e-02f, -2.00611781e-02f, -1.32787004e-01f, -2.51255572e-01f,
  -1.67121738e-01f, -4.36770432e-02f, 9.62556377e-02f, 4.40583751e-02f, 3.27489488e-02f, 4.11540382e-02f, 2.01745436e-01f, 2.79869083e-02f, 3.11006438e-02f, -1.16191067e-01f,
  9.40897444e-05f, 2.09008604e-01f, 2.31621504e-01f, 1.14818886e-01f, 1.33088574e-01f, -5.83151542e-02f, 1.03453532e-01f, 3.62570658e-02f, 2.23500747e-02f, -1.54931704e-03f,
  -1.00957096e-01f, 3.47881109e-01f, 2.43911222e-01f, 2.15823695e-01f, 1.76126912e-01f, -2.35210434e-02f, -1.34411991e-01f, 1.00025952e-01f, 1.09742984e-01f, 1.93183452e-01f,
  -8.88973624e-02f, -8.46127942e-02f, 2.17771024e-01f, 2.11973906e-01f, -1.37818959e-02f, 3.35109942e-02f, 8.19971114e-02f, 8.08957592e-02f, 4.73537631e-02f, 1.51323490e-02f,
  1.67403072e-01f, 1.07568413e-01f, 8.38817656e-02f, 1.41125441e-01f, 9.85366926e-02f, 1.01220623e-01f, 3.86154875e-02f, -1.57027245e-02f, 7.29119554e-02f, 1.33073151e-01f,
  -1.49676099e-01f, 4.93367970e-01f, -2.83877522e-01f, -2.02781737e-01f, 6.24947734e-02f, -7.41773918e-02f, 1.85743608e-02f, -1.45144537e-01f, -3.66238296e-01f, -3.11355323e-01f,
  -1.13076478e-01f, 8.69517475e-02f, 1.89144105e-01f, 1.05006970e-01f, 1.34858921e-01f, -1.10141635e-02f, 4.12870161e-02f, 1.19818658e-01f, -1.02531016e-01f, -1.89763844e-01f,
  5.01582548e-02f, 9.67272744e-02f, 4.87600453e-02f, -3.26935798e-02f, 6.10740297e-02f, -4.38960753e-02f, 1.44117950e-02f, -8.95452574e-02f, 1.36830941e-01f, 1.88354954e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 26)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 26;
const float L0_fan_Bp_bar_data[] = {
  9.71888602e-01f, 5.49852967e-01f, 9.02152479e-01f, 7.97261417e-01f, 3.74465823e-01f, 2.12057605e-01f, 9.44872439e-01f, 8.17755699e-01f, 6.80752456e-01f, 6.21968150e-01f,
  6.52353942e-01f, 7.93696702e-01f, 5.64978004e-01f, 8.18702996e-01f, 5.69028437e-01f, 1.60800010e-01f, 4.72591162e-01f, 6.69203281e-01f, 8.14564764e-01f, 1.03525531e+00f,
  5.84615469e-01f, 4.87789959e-01f, 3.08728933e-01f, 1.86079755e-01f, 9.05355513e-01f, 8.93541992e-01f
};

// L1_linear_W (Shape: 12 x 64)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 64;
const float L1_linear_W_data[] = {
  -3.53590548e-01f, -3.35833251e-01f, -1.08432099e-01f, -2.98318695e-02f, -1.08464815e-01f, -1.08909428e-01f, -1.45038194e-03f, -1.69888213e-01f, -9.36875120e-04f, -2.26380661e-01f,
  -1.08849481e-01f, 1.51111826e-01f, 3.76533903e-02f, -1.37315914e-01f, 5.14465645e-02f, 1.26923611e-02f, -6.30677268e-02f, -2.14574590e-01f, -1.66560829e-01f, -1.21262081e-01f,
  2.36355752e-01f, -3.44219387e-01f, -2.55154520e-01f, -1.20176673e-02f, -4.37270403e-01f, -2.82430500e-01f, -5.22070080e-02f, 1.30319268e-01f, 8.76632240e-03f, 1.79645330e-01f,
  -2.12902457e-01f, 2.17471942e-01f, -7.98824430e-02f, -1.25372678e-01f, -1.24186017e-01f, 7.34622627e-02f, -1.58242717e-01f, 2.23194763e-01f, -2.71369904e-01f, -1.01729381e+00f,
  -3.09635282e-01f, 9.20968279e-02f, 3.79221141e-01f, 1.16764091e-01f, -7.53221691e-01f, -7.80596673e-01f, -7.63343722e-02f, 3.47650647e-01f, -1.22858000e+00f, -8.30225408e-01f,
  4.75108504e-01f, -2.56966054e-01f, 2.94400305e-01f, 7.17221797e-01f, -7.15800107e-01f, -1.20428777e+00f, -8.48052837e-03f, -2.94039935e-01f, 1.99553221e-01f, 4.44444537e-01f,
  -2.79396903e-02f, 4.87970561e-01f, -1.94449008e-01f, -3.23787600e-01f, 2.07038030e-01f, -1.12880774e-01f, 1.96956079e-02f, 2.71322206e-03f, 4.28942479e-02f, -1.20386546e-02f,
  1.00053409e-02f, 4.00899015e-02f, 1.98065378e-02f, 6.93077520e-02f, 2.08729193e-01f, -1.25878096e-01f, 8.57854709e-02f, -2.09392726e-01f, -4.89573963e-02f, -1.42803276e-02f,
  2.64757216e-01f, 8.21800306e-02f, 8.90293121e-02f, -1.11893326e-01f, 1.55787900e-01f, -2.35311732e-01f, -1.83815196e-01f, 1.89016208e-01f, -2.83587337e-01f, -2.99141258e-01f,
  8.17318037e-02f, -2.03317732e-01f, -1.68710962e-01f, -9.77224633e-02f, 1.57531723e-01f, 3.61089468e-01f, 2.26205178e-02f, -2.36688927e-01f, 2.45522723e-01f, 1.41477033e-01f,
  2.46235684e-01f, 3.43975455e-01f, -7.78431892e-01f, -9.66792479e-02f, -5.46831131e-01f, 4.76042509e-01f, -4.71667022e-01f, 5.83736785e-02f, -5.62996864e-01f, -1.38890952e-01f,
  -2.94113234e-02f, 1.06624973e+00f, -7.29196429e-01f, -8.71701777e-01f, -6.57572031e-01f, 8.47149611e-01f, -1.08248973e+00f, -6.30223691e-01f, -1.35280460e-01f, -4.97916907e-01f,
  -1.25554967e+00f, 3.18088591e-01f, 6.58863962e-01f, -8.06365907e-01f, -6.12074614e-01f, -1.27691567e-01f, 1.59893453e-01f, 2.77284056e-01f, 7.74001181e-02f, 2.02226818e-01f,
  2.87418306e-01f, 1.24837495e-01f, 2.13607773e-01f, 1.97627991e-01f, 5.03339432e-02f, 2.04857633e-01f, -6.71325997e-02f, 1.92687064e-01f, 3.46394181e-01f, -4.92787249e-02f,
  9.19568166e-03f, 1.00739859e-01f, 5.99301085e-02f, 1.75233096e-01f, -7.98460990e-02f, 1.27554670e-01f, 1.46955520e-01f, -2.69918501e-01f, 4.32960056e-02f, 5.46604209e-03f,
  -1.75840005e-01f, -9.43349525e-02f, -8.65512863e-02f, -3.87530893e-01f, 1.01985246e-01f, -2.33500540e-01f, -2.03878999e-01f, -2.52784431e-01f, 1.92995399e-01f, -3.27052586e-02f,
  3.20976563e-02f, -1.33624092e-01f, 3.15564510e-04f, -2.12135509e-01f, 2.80022949e-01f, 2.75597185e-01f, -5.96402228e-01f, -1.20194368e-01f, -8.02993238e-01f, 7.73465395e-01f,
  5.46571136e-01f, 8.71388987e-02f, 3.79957557e-02f, -1.76484868e-01f, -7.17076898e-01f, -2.93482766e-02f, -7.74238491e-03f, 3.55673403e-01f, 6.73965454e-01f, -8.07329595e-01f,
  -6.02145553e-01f, -9.35424328e-01f, -7.43587375e-01f, -1.96631268e-01f, -4.36199665e-01f, -2.37731397e-01f, -1.11077309e-01f, 7.71083236e-01f, -4.38611388e-01f, 3.31813097e-01f,
  1.64256290e-01f, -3.84961754e-01f, -5.18490851e-01f, 3.53691466e-02f, -3.25158536e-01f, -1.12504564e-01f, 1.48395328e-02f, -1.47607729e-01f, 9.40331221e-02f, -1.15706764e-01f,
  8.47222507e-02f, -3.19558531e-02f, 5.31495772e-02f, -4.32455465e-02f, 2.35037953e-02f, 7.51564726e-02f, -8.08063969e-02f, 4.26051132e-02f, -2.18415171e-01f, -1.14748592e-03f,
  -3.24070424e-01f, -2.23041996e-01f, 1.06892623e-01f, 5.32339633e-01f, 4.49665822e-02f, 1.03109039e-01f, 2.42688209e-01f, -1.46537483e-01f, -2.14968309e-01f, 5.30623980e-02f,
  1.14189185e-01f, 3.20289247e-02f, -3.17214549e-01f, 3.14746410e-01f, 1.02308296e-01f, 4.90482114e-02f, -3.68057676e-02f, 4.70790654e-01f, 1.72145683e-02f, 2.11190924e-01f,
  3.40922326e-01f, -2.05518946e-01f, -1.58882093e+00f, 3.90894234e-01f, 2.62600392e-01f, -6.84685051e-01f, 6.25712037e-01f, -1.27990723e+00f, -2.81073898e-01f, 1.91431299e-01f,
  3.04274321e-01f, 4.10871267e-01f, -2.04181567e-01f, -1.76787272e-01f, 4.67952311e-01f, 2.25426108e-02f, -4.88558680e-01f, -8.82197320e-02f, 1.07630837e+00f, -5.23701787e-01f,
  -4.55239952e-01f, -4.59047914e-01f, 5.10528207e-01f, -6.84840560e-01f, -2.68641680e-01f, -2.69126683e-01f, 7.19651878e-02f, 3.10606528e-02f, 1.48408353e-01f, -8.54194164e-02f,
  -1.39210552e-01f, -5.95462508e-02f, -1.39029190e-01f, -3.24111097e-02f, 2.61802170e-02f, 7.00222328e-02f, -1.02965765e-01f, 2.41995826e-01f, -1.73963159e-01f, -1.14056259e-01f,
  -1.53652191e-01f, 4.55231927e-02f, 5.98066933e-02f, -3.20616782e-01f, 2.55993575e-01f, -1.17345192e-01f, -9.57676768e-02f, 3.76858115e-02f, -3.84791009e-02f, 1.06574282e-01f,
  6.52863085e-02f, 2.25781426e-01f, -1.32951483e-01f, 1.05410703e-01f, 6.34576753e-02f, 9.78032127e-02f, 1.63911341e-03f, -2.33656585e-01f, -1.26611561e-01f, 7.18336627e-02f,
  -1.07634299e-01f, 1.29260700e-02f, 3.08482554e-02f, 7.08323121e-02f, 3.29511285e-01f, 9.95741710e-02f, 2.52655536e-01f, 1.57455012e-01f, 1.11928783e-01f, -1.07623758e-02f,
  -7.52936900e-01f, 8.78973082e-02f, 8.68542865e-02f, -1.14497609e-01f, 2.24587128e-01f, 7.87718773e-01f, -2.46686026e-01f, -5.43097198e-01f, -7.30705082e-01f, -6.10796474e-02f,
  -2.46171057e-01f, 4.44750607e-01f, -5.96534193e-01f, -5.53302109e-01f, 4.30790484e-02f, -4.79189903e-01f, 4.78033334e-01f, 3.07781875e-01f, -2.63839304e-01f, -1.98629230e-01f,
  1.95022061e-01f, 1.79486975e-01f, 9.91578102e-02f, 2.22056285e-01f, 1.73686258e-03f, 2.42457882e-01f, 1.17955223e-01f, 5.87668605e-02f, 1.26556447e-02f, 1.00924626e-01f,
  7.24046901e-02f, 2.12162510e-01f, -8.66906811e-03f, 1.24865975e-02f, -2.39910278e-02f, 1.96330994e-01f, 1.73938751e-01f, 1.19706675e-01f, 1.10225253e-01f, 1.66799158e-01f,
  -5.35267405e-02f, -4.21923637e-01f, 2.41944984e-01f, 2.64002979e-01f, -3.00387084e-01f, 3.84638272e-02f, -1.44864321e-01f, 1.75920978e-01f, 3.12539399e-01f, 3.91787767e-01f,
  -2.27930062e-02f, -5.09004354e-01f, -1.17901839e-01f, -3.85381132e-01f, 1.52572408e-01f, 3.17271650e-01f, 3.23235273e-01f, -4.66423154e-01f, 2.53050737e-02f, -6.83573306e-01f,
  5.12089610e-01f, -4.48163822e-02f, -7.86071181e-01f, -4.80369627e-02f, 1.40688606e-02f, 2.47799382e-01f, 5.41552484e-01f, -5.56256294e-01f, -3.92562836e-01f, -1.43535137e+00f,
  -8.88284147e-01f, -6.89217225e-02f, 1.06253278e+00f, -7.90213868e-02f, 3.96064728e-01f, 2.62266338e-01f, -8.74844730e-01f, -1.85313448e-01f, 3.96433175e-01f, 7.83772051e-01f,
  -6.09770715e-01f, 2.63645768e-01f, -4.67682898e-01f, 3.21691930e-02f, 8.89638625e-03f, -1.23870317e-02f, 2.46225297e-01f, -1.50188521e-01f, -7.09027168e-04f, 1.03210494e-01f,
  3.99426371e-03f, -1.26155466e-01f, 1.92256048e-02f, -2.67562062e-01f, 1.32631630e-01f, -1.03750542e-01f, -2.99537461e-03f, 2.02197865e-01f, 3.63094993e-02f, -7.71181807e-02f,
  -6.38794079e-02f, 3.66836250e-01f, -2.33516037e-01f, 3.58962357e-01f, -6.99208081e-02f, -5.32155409e-02f, 2.39313692e-01f, -3.72447848e-01f, 2.28941530e-01f, -3.32215093e-02f,
  3.81846070e-01f, 8.89790431e-02f, -1.92057014e-01f, -3.41894716e-01f, 4.29949433e-01f, -4.70286191e-01f, 3.16128373e-01f, -8.00900534e-02f, -9.53546986e-02f, -3.33679169e-01f,
  -3.67004693e-01f, -3.65176976e-01f, -9.84802842e-01f, -1.05934393e+00f, -1.94727436e-01f, -5.81752479e-01f, -1.26600206e+00f, 8.75586346e-02f, -4.17867422e-01f, 2.37086177e-01f,
  -2.51693338e-01f, -3.96464050e-01f, 7.02053189e-01f, 4.26732600e-01f, 9.71241176e-01f, 5.99064231e-01f, -2.53076851e-01f, -5.46544492e-01f, -8.35413158e-01f, -6.22427464e-01f,
  -8.40456426e-01f, -6.02844238e-01f, -9.27878857e-01f, -1.64366022e-01f, -4.95511621e-01f, -7.64813304e-01f, -6.23987317e-01f, -1.86426252e-01f, -3.48548554e-02f, -3.32265012e-02f,
  -3.31844151e-01f, 3.71255204e-02f, -1.76760629e-01f, -5.28698713e-02f, -2.93419547e-02f, -3.04118901e-01f, -5.92349768e-02f, -2.10493729e-01f, -8.34966749e-02f, -2.55572855e-01f,
  -2.00695753e-01f, -1.96130544e-01f, -1.23937890e-01f, 4.40255441e-02f, -3.76383923e-02f, 1.08455298e-02f, -2.98793744e-02f, -3.16382736e-01f, -3.01354211e-02f, 2.19748661e-01f,
  8.36452320e-02f, 4.69590118e-03f, 1.20639578e-01f, 2.50765502e-01f, -1.49680302e-01f, 3.65842544e-02f, 2.87887514e-01f, 1.62298054e-01f, -2.82737583e-01f, 1.75992958e-02f,
  -6.86564147e-02f, 3.49489860e-02f, 3.29951639e-03f, 2.95761555e-01f, 1.30579770e-01f, 8.09422880e-02f, -5.38441479e-01f, 4.63394254e-01f, -3.49745512e-01f, -4.69085127e-01f,
  -5.47449470e-01f, -1.11280791e-01f, -4.16342020e-01f, -5.64590879e-02f, -1.08255103e-01f, -3.58382255e-01f, 5.92699587e-01f, -7.96279907e-02f, 5.70011251e-02f, -4.21734214e-01f,
  -3.56428683e-01f, -3.48229438e-01f, 1.30810201e-01f, 7.97070980e-01f, 1.18863976e+00f, -1.24914674e-02f, -1.47792161e-01f, 2.67968982e-01f, -3.78169328e-01f, -3.12642753e-01f,
  2.18828961e-01f, -9.73477244e-01f, -8.78437459e-02f, -7.36504942e-02f, 1.76746562e-01f, 1.19694456e-01f, -1.47291020e-01f, 1.73524573e-01f, 1.23931676e-01f, 1.01714142e-01f,
  1.26140237e-01f, 1.52007356e-01f, -4.96288270e-01f, -1.03253536e-01f, 1.90502435e-01f, 9.04937759e-02f, 5.19324020e-02f, -5.73172234e-02f, 9.79321450e-02f, -3.41277987e-01f,
  1.58340484e-01f, 2.24663317e-01f, -3.50900710e-01f, -3.86383720e-02f, -2.66997993e-01f, -2.43027672e-01f, -2.45113447e-01f, 3.21240053e-02f, -2.86983848e-01f, -5.43947108e-02f,
  2.50294775e-01f, -5.00186682e-01f, -3.74911696e-01f, -5.11219315e-02f, -4.76529356e-03f, -7.66812563e-02f, 9.65329185e-02f, 2.34233543e-01f, -5.83070457e-01f, -5.95512204e-02f,
  -1.19976473e+00f, 3.63121867e-01f, 1.67765871e-01f, -2.96938837e-01f, -5.72926328e-02f, -4.37266022e-01f, 8.53691697e-01f, -1.89058185e-01f, 1.56246066e-01f, -6.91324532e-01f,
  -5.04968762e-01f, -2.17727467e-01f, 5.64847663e-02f, -4.68358904e-01f, -2.83384006e-02f, -3.35421413e-01f, -2.74202496e-01f, -4.37083244e-01f, 4.17618275e-01f, 7.36274660e-01f,
  -2.86395580e-01f, -5.32894790e-01f, -5.81622660e-01f, -6.83140457e-01f, 4.14557904e-01f, 1.65118530e-01f, 1.01879910e-01f, 1.03727147e-01f, -8.58258083e-03f, 1.75005659e-01f,
  -8.91008787e-03f, -2.05764264e-01f, 1.60881821e-02f, 2.20576916e-02f, -5.24815023e-02f, 5.51203303e-02f, -1.10257462e-01f, 1.40096759e-02f, 2.34874904e-01f, -6.46537021e-02f,
  -2.17522129e-01f, -2.00201660e-01f, -1.22754984e-02f, 2.35124920e-02f, -2.97042042e-01f, -1.84111342e-01f, -3.34031275e-03f, -1.11401327e-01f, -1.00634344e-01f, 3.91326308e-01f,
  4.97558981e-01f, 3.27492654e-01f, 3.36669177e-01f, -6.97983615e-03f, -2.50989556e-01f, 3.90609711e-01f, 2.96814859e-01f, 7.12315619e-01f, -3.36529642e-01f, 2.41735294e-01f,
  -1.44492105e-01f, -1.63988635e-01f, 4.16247487e-01f, -5.42707384e-01f, 2.69797117e-01f, -1.93722975e-02f, 1.04942155e+00f, -8.47272575e-01f, 8.95309269e-01f, 8.27496219e-03f,
  -8.06155622e-01f, 7.48099327e-01f, -1.00928497e+00f, -7.85106957e-01f, 1.49414819e-02f, -1.95518583e-01f, -3.41291614e-02f, -2.47848079e-01f, -4.74146634e-01f, 2.89093375e-01f,
  2.55718857e-01f, -4.31514680e-01f, -8.69111121e-01f, -6.50166154e-01f, -2.88962990e-01f, -5.17918020e-02f, -7.89653599e-01f, -1.68011874e-01f, -4.65611637e-01f, -5.88548243e-01f,
  1.51817948e-01f, -2.54604250e-01f, 8.49910229e-02f, -1.65824462e-02f, 1.42969102e-01f, 1.66527256e-01f, -1.83750279e-02f, 1.68887392e-01f, 2.96932533e-02f, -2.33391672e-02f,
  2.14250848e-01f, 1.75391644e-01f, -2.53261536e-01f, -4.74213511e-02f, 1.26944184e-01f, 1.01901218e-01f, -1.49814993e-01f, 1.22490913e-01f, -1.77687895e-03f, 1.80138588e-01f,
  2.51657128e-01f, -1.33998487e-02f, -1.29367113e-01f, -2.99790889e-01f, 2.83301592e-01f, 1.59480527e-01f, -2.74706632e-02f, -8.17263499e-02f, 2.34768748e-01f, 9.98878554e-02f,
  2.52903104e-01f, 3.94406259e-01f, -7.60453790e-02f, -3.02548353e-02f, 2.00749919e-01f, -5.19748867e-01f, -2.56345689e-01f, 2.38454580e-01f, 3.53178918e-01f, -2.88568705e-01f,
  -6.82946026e-01f, -1.22195363e+00f, -5.60507834e-01f, -7.48432577e-01f, 1.08630680e-01f, 1.16928816e-01f, 1.01893261e-01f, 4.46278989e-01f, -3.01078498e-01f, -5.96986115e-01f,
  -2.31115088e-01f, -3.49787682e-01f, 4.30332005e-01f, -4.89238173e-01f, -2.96294153e-01f, 8.75022411e-01f, -3.78974915e-01f, 3.21786553e-01f, -8.23855102e-01f, -3.33423018e-01f,
  6.91765904e-01f, -4.91060853e-01f, 4.82075095e-01f, -4.77301478e-01f, -4.92627081e-03f, -1.20238192e-01f, 5.19515537e-02f, 1.00370228e-01f, 1.81610316e-01f, 1.15282170e-01f,
  1.70788780e-01f, 1.98409200e-01f, 4.88443933e-02f, 8.11949465e-03f, 7.26465276e-03f, -2.09676977e-02f, -3.91690992e-02f, 2.84165535e-02f, -6.23357445e-02f, -7.60062551e-03f,
  9.31645036e-02f, 7.09553808e-02f, 1.26598492e-01f, 1.65036812e-01f, -2.44928226e-01f, 3.48667562e-01f, 1.69738621e-01f, -1.45809859e-01f, 2.99666733e-01f, 1.03956079e-02f,
  1.40890703e-01f, -2.07253873e-01f, -3.01685661e-01f, -1.21741347e-01f, -2.72440642e-01f, -3.81768405e-01f, 2.36904938e-02f, 1.67761877e-01f, -2.90440232e-01f, -2.53460824e-01f,
  -2.66994238e-01f, -8.71021375e-02f, 7.79204547e-01f, -5.52977741e-01f, -9.13028941e-02f, -2.66801089e-01f, -3.06050908e-02f, -2.56770134e-01f, 3.62006158e-01f, -9.10751462e-01f,
  -1.65880084e-01f, -1.44453153e-01f, -2.55966514e-01f, 7.14570522e-01f, -8.39345276e-01f, 3.47750902e-01f, -5.27869046e-01f, -1.61102876e-01f, 8.49163890e-01f, -1.45075768e-01f,
  2.33443141e-01f, -7.14539230e-01f, -8.77248406e-01f, -7.75611818e-01f, -3.11429381e-01f, -4.41848904e-01f, -4.50022161e-01f, 9.12323236e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -1.81502432e-01f, 6.34721890e-02f, 1.31055906e-01f, -2.05476686e-01f, -4.86777455e-01f, 5.91124082e-03f, 4.85617548e-01f, -1.66558966e-01f, -2.16809940e-02f, 3.77637625e-01f,
  9.34153944e-02f, -1.00937515e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 19, 26
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        64, 12
    );
    }
    