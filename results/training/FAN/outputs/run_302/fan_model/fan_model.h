/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  1.32117432e-03f, -2.88079083e-01f, 1.32408395e-01f, -3.69199738e-02f, 1.15175188e-01f, 1.18799299e-01f, 2.32517585e-01f, -4.79048528e-02f, -4.96464632e-02f, -1.97786361e-01f,
  -1.90994411e-03f, -7.60283545e-02f, -6.38131499e-02f, -7.83744827e-02f, 1.50861427e-01f, -1.02635182e-01f, -4.91902977e-02f, -3.51591185e-02f, -1.86503623e-02f, -7.81164616e-02f,
  -2.93215015e-03f, -6.18712753e-02f, 1.34145036e-01f, 3.69423889e-02f, -1.57961696e-02f, -2.33022533e-02f, -1.07237533e-01f, 1.35199666e-01f, -5.24944291e-02f, 3.78281884e-02f,
  1.32004976e-01f, -1.61979690e-01f, 7.95314685e-02f, 1.95156224e-02f, 1.67962424e-02f, 5.65182604e-03f, 3.02453917e-02f, 6.78722262e-02f, 1.22818865e-01f, -5.54478802e-02f,
  2.02992023e-03f, -1.38083764e-03f, 7.49044539e-03f, 1.96283925e-02f, -2.90482473e-02f, 2.91644726e-02f, 3.45581435e-02f, -5.17314253e-03f, 3.03842481e-02f, -1.19343977e-02f,
  -2.77790073e-02f, -5.23980521e-02f, -6.16577268e-02f, -6.97460398e-02f, 3.07656098e-02f, 1.52386008e-02f, -1.93225145e-02f, 1.21971034e-02f, -5.18189557e-02f, -1.31910993e-02f,
  -6.53201342e-02f, 1.57543980e-02f, -4.30949144e-02f, -3.04651819e-02f, 2.17450806e-03f, 1.86286103e-02f, -4.08487879e-02f, 2.78763156e-02f, 4.08554599e-02f, 5.91513561e-03f,
  9.88151319e-03f, 3.56837586e-02f, -8.80839396e-03f, 3.31712700e-02f, -2.01249644e-02f, -4.76496890e-02f, 4.57866192e-02f, -8.74177366e-02f, 6.05764873e-02f, 1.83916036e-02f,
  -2.46654283e-02f, -1.56780668e-02f, -3.43598500e-02f, -2.51345988e-02f, -3.47329304e-02f, -1.23877218e-02f, -8.73856321e-02f, -6.63079787e-03f, -2.71939673e-02f, 5.74793555e-02f,
  -1.10768110e-01f, -2.65105337e-01f, -1.24994004e-02f, -1.08658234e-02f, 1.76365916e-02f, 3.75072584e-02f, 1.24841435e-02f, -7.24856779e-02f, -8.80753696e-02f, 1.23983007e-02f,
  -8.21467955e-03f, 6.28745137e-03f, 2.35461374e-03f, 1.60331279e-02f, 1.18717896e-02f, -1.08411508e-02f, -1.89371668e-02f, 3.41892764e-02f, -1.78977326e-02f, -1.73049998e-02f,
  3.90776582e-02f, -1.04133680e-03f, 3.63005064e-02f, 6.17241412e-02f, -2.50284616e-02f, 1.49000259e-02f, -4.36369777e-02f, 1.52842849e-02f, 1.16929552e-02f, -2.74588261e-02f,
  -3.89808416e-01f, -2.28428710e-02f, -9.19222087e-02f, -6.91985479e-03f, -1.22799955e-01f, -1.32674590e-01f, -1.83429226e-01f, 5.66891991e-02f, 5.74077815e-02f, 1.24294609e-01f,
  -1.86762102e-02f, -1.25501305e-01f, -4.14610431e-02f, -2.95648444e-02f, -8.17548335e-02f, 1.63111135e-01f, 3.16971131e-02f, -1.78766111e-03f, 3.82186808e-02f, -6.75803348e-02f,
  -6.83629438e-02f, 4.50374484e-02f, 2.70023309e-02f, 1.50962457e-01f, -8.88039917e-02f, -4.81439196e-03f, 7.33732879e-02f, -2.86000445e-02f, 8.23443010e-02f, 2.61524636e-02f,
  3.22636887e-02f, 6.80927699e-03f, 6.48268312e-03f, 9.01633650e-02f, -7.62142241e-02f, -3.44246961e-02f, -6.42711073e-02f, 2.06675138e-02f, 2.56533530e-02f, 1.77652109e-02f,
  -1.33186840e-02f, 8.67302250e-03f, -2.79162964e-03f, 7.64752775e-02f, -4.18306403e-02f, 1.98461432e-02f, 3.38254198e-02f, 2.89430711e-02f, -1.09730214e-02f, -7.46439397e-02f,
  -5.88625260e-02f, 1.27889654e-02f, -7.13643357e-02f, -5.61198741e-02f, 1.38996309e-02f, -5.07010370e-02f, 3.77278998e-02f, -1.97640378e-02f, 2.34876815e-02f, -7.60950148e-02f,
  -2.52428614e-02f, 6.59822160e-03f, 3.78016345e-02f, -5.95996529e-02f, -8.84236395e-03f, 9.08279270e-02f, -6.76226988e-02f, 4.02294770e-02f, -6.56469017e-02f, 3.61856297e-02f,
  2.56563742e-02f, -7.39575177e-02f, 6.26999363e-02f, -2.51199324e-02f, 2.93269474e-02f, -7.96683226e-03f, -3.51333469e-02f, 6.28957450e-02f, 8.34636332e-04f, 4.71714139e-02f,
  5.74078932e-02f, -1.29723577e-02f, -1.14532956e-03f, 3.31805320e-03f, 3.71399522e-02f, 1.58607587e-02f, 3.22444662e-02f, -3.50427106e-02f, 8.82042497e-02f, 1.84133823e-03f,
  -4.24694307e-02f, 3.70618291e-02f, -1.80449765e-02f, -1.71014597e-03f, 1.12241879e-01f, 5.37132844e-04f, 7.86024854e-02f, 9.46291955e-04f, 6.84654638e-02f, -3.46440785e-02f,
  -4.76454087e-02f, -6.77224307e-04f, 4.70761433e-02f, -4.21829484e-02f, 5.17854914e-02f, -3.95271070e-02f, 5.36987297e-02f, 6.33293577e-03f, 6.69052973e-02f, 4.34170179e-02f,
  -2.34058071e-02f, -1.17301242e-02f, 1.58335753e-02f, 3.31475697e-02f, 6.14968035e-03f, -1.99538656e-02f, 2.40713032e-03f, 1.86084490e-02f, -6.51063025e-03f, 8.63379911e-02f,
  1.65986761e-01f, -1.92704126e-01f, -1.24503769e-01f, -6.36257902e-02f, 2.35639706e-01f, 2.06212416e-01f, -5.31882863e-04f, 1.01978019e-01f, 3.34394500e-02f, -1.37595788e-01f,
  -1.51458411e-02f, -1.53228223e-01f, -1.39567375e-01f, -2.22198531e-01f, 4.82409671e-02f, -9.48746502e-02f, -1.43542374e-02f, -1.06911540e-01f, 2.10173167e-02f, 4.24703211e-02f,
  4.53928411e-02f, -1.32338837e-01f, -9.43558812e-02f, 9.50491875e-02f, 3.22066061e-02f, 3.39197484e-03f, 1.10600684e-02f, 9.44127212e-04f, -9.36076120e-02f, -4.92292969e-03f,
  -5.55142155e-03f, -9.15189162e-02f, 4.18326184e-02f, -4.28086109e-02f, 3.69390324e-02f, 5.92450090e-02f, -1.28739839e-03f, -4.20742668e-02f, 5.72647825e-02f, 2.32292600e-02f,
  -1.58339124e-02f, 7.82887116e-02f, -6.22628431e-04f, -2.99103931e-03f, -5.02539463e-02f, 3.91534939e-02f, -2.84953211e-02f, 5.07266186e-02f, 2.60808263e-02f, -3.69882770e-02f,
  -4.53311950e-03f, -1.89763047e-02f, 4.05946411e-02f, -7.73295015e-02f, 4.30810861e-02f, 1.14190392e-03f, -2.56169643e-02f, -1.26057975e-02f, -4.01644735e-03f, -4.73036319e-02f,
  -2.70459671e-02f, 3.95973548e-02f, 3.39694484e-03f, -4.48589325e-02f, 6.96858242e-02f, -3.77647616e-02f, 2.78909318e-02f, -5.43070547e-02f, -3.69157121e-02f, -5.02138026e-02f,
  3.81814390e-02f, -3.90847027e-02f, -5.31987473e-03f, 1.61113255e-02f, -4.13538404e-02f, 3.31715448e-03f, 3.54101807e-02f, 1.75890271e-02f, 6.20315671e-02f, 3.64328139e-02f,
  6.09714864e-03f, 2.65966207e-02f, -4.70725037e-02f, 2.47992259e-02f, -7.92813487e-04f, -2.08153296e-02f, -4.30380926e-02f, -7.90898874e-03f, 2.20294893e-02f, -6.44882675e-03f,
  -1.86819565e-02f, -2.65292615e-01f, -4.52144705e-02f, 1.84780080e-02f, -1.16904475e-01f, -3.62118073e-02f, -5.49046323e-02f, -1.98978316e-02f, -8.02517235e-02f, -3.25822309e-02f,
  -2.73354109e-02f, 1.61379911e-02f, -4.30282317e-02f, 7.84162711e-03f, 4.73883934e-02f, -6.35475665e-02f, -4.58499379e-02f, -2.23217458e-02f, -3.67937833e-02f, -4.61555198e-02f,
  1.01265488e-02f, 5.20973094e-02f, -6.49743481e-04f, 2.44609192e-02f, -5.14490232e-02f, -2.20014397e-02f, 2.13294644e-02f, 8.49743432e-04f, -2.61714738e-02f, -7.28059886e-03f,
  -1.20166846e-01f, 9.80165377e-02f, 2.80260056e-01f, -6.78977445e-02f, -8.29077810e-02f, -9.32011157e-02f, 1.83108985e-01f, -5.60223050e-02f, -2.37710446e-01f, -4.19972017e-02f,
  2.96385158e-02f, 1.61136925e-01f, 2.22381622e-01f, 8.86388496e-03f, -4.23728712e-02f, 3.28366794e-02f, -9.52147767e-02f, 4.34156880e-02f, -5.41981161e-02f, -1.09576136e-02f,
  -1.11656271e-01f, -1.68212160e-01f, 1.38818622e-01f, -4.74951081e-02f, 2.24524941e-02f, 6.41084239e-02f, -1.88864768e-03f, 1.91840053e-01f, 7.71342069e-02f, 4.16298397e-02f,
  -8.15703347e-02f, -4.29130569e-02f, 4.38517220e-02f, -1.64224207e-02f, -4.51085828e-02f, -2.14824057e-03f, 1.04167029e-01f, 1.18280128e-01f, 6.32727295e-02f, 3.16737071e-02f,
  9.09697860e-02f, 8.72701220e-03f, -4.05387394e-03f, -6.92405775e-02f, -9.42542497e-03f, -5.85698383e-03f, -3.98452999e-03f, 8.95514898e-03f, 3.39912176e-02f, 2.67838277e-02f,
  -2.34758630e-02f, -3.53885032e-02f, 6.02628253e-02f, -1.26305493e-02f, 1.23099415e-02f, -5.88969444e-04f, 2.37525702e-02f, -3.46268134e-05f, -4.61824164e-02f, -8.83825496e-02f,
  2.17308737e-02f, -5.33871278e-02f, 4.82872613e-02f, -8.23876932e-02f, 1.30178882e-02f, 1.76004656e-02f, -3.32002640e-02f, -5.01804426e-02f, 6.39532655e-02f, -5.52284606e-02f,
  -1.51631655e-02f, -4.65729594e-04f, -2.03329371e-04f, 8.19884241e-03f, -1.53072383e-02f, -5.86927077e-03f, -7.96669442e-03f, -6.28231987e-02f, -7.47834146e-02f, -6.49288017e-03f,
  5.82793206e-02f, 1.11087076e-02f, 1.26763480e-02f, -2.95275953e-02f, -4.62284777e-03f, 5.00166789e-02f, -1.57256109e-05f, 7.63986334e-02f, -3.14724743e-02f, -2.22182125e-02f,
  -2.84706086e-01f, -1.33840740e-01f, -4.06111330e-02f, -4.06481847e-02f, -8.03885609e-03f, -1.01136621e-02f, -5.63291833e-02f, -1.86952259e-02f, 2.73101162e-02f, -7.45244883e-03f,
  -6.97376207e-02f, -5.56557663e-02f, -3.31867896e-02f, -3.89021859e-02f, 4.03445326e-02f, -2.90314890e-02f, 1.78569369e-02f, -1.06150145e-02f, -9.76422131e-02f, -1.82224084e-02f,
  -3.29407565e-02f, 4.66604158e-03f, -1.22306042e-03f, -9.49061569e-03f, -3.22832214e-03f, 7.94022754e-02f, -2.37138551e-02f, 1.93418451e-02f, 3.89002897e-02f, -1.72940306e-02f,
  3.61001223e-01f, -4.44539607e-01f, 2.37057894e-03f, -1.23011902e-01f, 1.36417776e-01f, -2.97497828e-02f, 1.51022244e-02f, 4.67840098e-02f, -7.94256758e-03f, -1.58667400e-01f,
  4.81886268e-02f, -2.02146560e-01f, -5.05767465e-02f, -8.86993483e-02f, 2.87685752e-01f, -9.01804715e-02f, -2.72367876e-02f, -1.71959415e-01f, 2.05256511e-03f, 1.67596899e-02f,
  5.50581813e-02f, -9.55702551e-03f, -9.82499681e-03f, -9.33072492e-02f, -6.63509518e-02f, -4.76881936e-02f, -3.49166840e-02f, -6.20187819e-03f, -5.07954732e-02f, 6.62002265e-02f,
  4.93766293e-02f, -5.88030666e-02f, 4.99264598e-02f, 3.97028327e-02f, 9.16411504e-02f, 1.00637553e-02f, 5.49878366e-02f, 3.34739052e-02f, 6.39004856e-02f, 5.18321469e-02f,
  -4.63530980e-02f, -5.09260818e-02f, -3.38966921e-02f, -1.44366845e-02f, 5.67193739e-02f, -9.50165931e-03f, -4.46337229e-03f, 4.31744829e-02f, -8.60311165e-02f, -1.88110513e-03f,
  -4.51583788e-02f, -5.50018102e-02f, -1.83523726e-03f, -9.05791745e-02f, -1.92443002e-02f, 2.46941913e-02f, -1.05111599e-02f, -9.70638245e-02f, -3.56827043e-02f, 1.66936647e-02f,
  1.39611419e-02f, -6.20010681e-03f, -4.33750153e-02f, 2.98560131e-02f, -1.16665661e-02f, 8.13318938e-02f, -9.82872490e-03f, 8.17341730e-03f, -1.95453595e-02f, 1.03006270e-02f,
  -3.13535482e-02f, -1.23975985e-02f, -1.49842370e-02f, 3.79916504e-02f, -1.46455215e-02f, 1.18261138e-02f, -1.04240160e-02f, -5.77694476e-02f, -7.76827382e-03f, 4.34900708e-02f,
  1.89905539e-02f, -2.01711357e-02f, -1.42957792e-02f, -1.33216204e-02f, -1.02333184e-02f, -1.77335981e-02f, 1.10847270e-02f, -1.50953103e-02f, 5.43929897e-02f, 3.44003625e-02f,
  -1.58719584e-01f, -1.40221655e-01f, 3.64849232e-02f, -7.09473565e-02f, -8.90467465e-02f, -4.52078804e-02f, -3.44217941e-02f, -4.29120064e-02f, -4.24191244e-02f, 1.34608382e-02f,
  9.64866206e-03f, -1.98713206e-02f, 6.48170989e-03f, 2.56910431e-03f, -6.06897362e-02f, 4.44529345e-03f, -5.18356152e-02f, -3.69344503e-02f, -2.95019485e-02f, -7.49904721e-04f,
  4.98245247e-02f, 2.28836872e-02f, 1.78318545e-02f, -4.81888354e-02f, -4.17074822e-02f, -4.95180190e-02f, -3.60148437e-02f, 4.65955436e-02f, 1.93602517e-02f, -1.01024956e-01f,
  -3.02003145e-01f, 4.56041172e-02f, -8.70244205e-02f, -1.41556606e-01f, 1.86688125e-01f, -1.34412244e-01f, -2.53700703e-01f, 1.47367835e-01f, -2.58517593e-01f, 1.50112912e-01f,
  -1.55305387e-02f, -1.59999520e-01f, -6.15828596e-02f, 6.39791265e-02f, -4.90654558e-01f, -2.25527003e-01f, -9.70490575e-02f, -4.13408615e-02f, -4.32309322e-02f, -4.92095686e-02f,
  -8.42867121e-02f, 1.50918737e-01f, -7.95497149e-02f, 2.04350516e-01f, 2.30885055e-02f, 9.56019089e-02f, 1.83301736e-02f, 1.00731000e-01f, 1.29390448e-01f, 7.59796845e-03f,
  4.25986536e-02f, -9.09381732e-02f, 2.64674760e-02f, 7.26004690e-02f, 3.28658074e-02f, 4.80456278e-02f, -3.05927247e-02f, -6.42352700e-02f, -4.33753580e-02f, 5.94278090e-02f,
  -1.30675929e-02f, 3.26067768e-02f, 1.66967362e-02f, 3.30224470e-03f, -1.13840727e-02f, -5.73105067e-02f, 2.56649451e-03f, 2.23324681e-03f, 2.51139272e-02f, -4.72621806e-02f,
  -3.51783383e-04f, -4.00235541e-02f, -2.27640066e-02f, -3.92359830e-02f, -1.89930368e-02f, 2.25379262e-02f, 3.40675493e-03f, -3.09775602e-02f, -1.13073448e-02f, 1.04085123e-03f,
  -2.11479925e-02f, 1.71144530e-02f, -2.81264689e-02f, 3.49336118e-02f, -3.65390815e-02f, 3.25666517e-02f, -3.03553883e-02f, 2.97664404e-02f, -2.72630602e-02f, 7.50713632e-04f,
  -3.49807329e-02f, -1.69345848e-02f, 1.63285211e-02f, -8.29624198e-03f, 4.02902067e-03f, 3.57840471e-02f, -3.49914539e-03f, -8.98710825e-03f, -8.91304389e-03f, 1.46288406e-02f,
  2.72299312e-02f, -4.57931422e-02f, 4.25401330e-02f, 4.42123003e-02f, 1.70717835e-02f, -3.39036137e-02f, 3.74443680e-02f, 5.18965395e-03f, 5.28910477e-03f, -3.97061855e-02f,
  -1.44074902e-01f, -5.94941080e-02f, 1.00177070e-02f, 1.44278049e-03f, -4.12170552e-02f, -3.10044847e-02f, -5.97980013e-03f, 6.47305176e-02f, -1.41729396e-02f, -5.35736419e-02f,
  5.71404286e-02f, 2.56563015e-02f, -1.53775346e-02f, -2.47051921e-02f, -2.79858336e-02f, -1.12596843e-02f, -3.19612958e-02f, 2.80090813e-02f, 4.47251908e-02f, -2.09055580e-02f,
  1.68733560e-02f, -3.22705135e-02f, -4.02556453e-03f, 1.56177441e-02f, -1.04569951e-02f, -5.54310381e-02f, -6.80366755e-02f, -6.13404764e-03f, -1.23585586e-03f, -3.97518277e-02f
};

// L0_fan_Wp_bar (Shape: 52 x 120)
const int L0_fan_Wp_bar_rows = 52;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  2.89317053e-02f, -1.20086558e-01f, -2.16857255e-01f, -1.46344125e-01f, -1.11845165e-01f, 1.25024483e-01f, 1.90832347e-01f, -9.40923691e-02f, -1.32997096e-01f, 2.59782761e-01f,
  2.65865147e-01f, -3.58985402e-02f, 1.51018262e-01f, 3.27869803e-01f, 1.46109723e-02f, 1.68991446e-01f, 3.07073772e-01f, 1.96607396e-01f, -1.56768396e-01f, -1.31776519e-02f,
  7.91316852e-03f, 2.54993439e-01f, 3.66690792e-02f, -4.40342873e-02f, 2.10401360e-02f, -1.10683747e-01f, 2.85512470e-02f, -1.09944642e-01f, 1.00339957e-01f, 1.99905019e-02f,
  2.75954809e-02f, -5.69647457e-03f, -6.85463753e-03f, -2.43244600e-02f, -7.99013600e-02f, -4.64816391e-02f, -1.06562391e-01f, -8.88861716e-03f, 3.37231047e-02f, -5.12248278e-02f,
  -7.49996528e-02f, 1.32306740e-02f, 5.89607749e-03f, 1.64242461e-02f, -4.82104868e-02f, -7.29104057e-02f, 4.67796475e-02f, 1.31142382e-02f, -7.36436397e-02f, -4.75714877e-02f,
  -5.38810343e-02f, 7.74770752e-02f, 3.01824696e-02f, 2.35683527e-02f, 3.61001566e-02f, -7.78899565e-02f, 2.74659265e-02f, -2.56531443e-02f, -8.01197514e-02f, -9.12569836e-02f,
  -2.97428854e-02f, 5.19054383e-02f, 1.39657670e-04f, -3.38278413e-02f, 8.62052366e-02f, 7.92485178e-02f, 1.82891395e-02f, -2.16944935e-03f, -4.76524681e-02f, 5.93975931e-03f,
  -4.24689613e-03f, -3.15984190e-02f, -5.18773533e-02f, -8.97736568e-03f, 8.76612887e-02f, -5.41420914e-02f, 4.07254994e-02f, 3.80382314e-02f, -2.38279365e-02f, -2.69254129e-02f,
  -7.16219842e-03f, 5.26168495e-02f, 7.75353014e-02f, 1.05519794e-01f, -4.65132333e-02f, -6.99988678e-02f, 1.06508750e-02f, -1.35144847e-03f, 9.88555476e-02f, -6.04477664e-03f,
  8.36305320e-02f, -2.02983931e-01f, -2.38643307e-02f, 4.19832207e-02f, -7.51261637e-02f, 1.14376424e-03f, -6.38019592e-02f, -9.47173908e-02f, 3.70868519e-02f, 1.91417281e-02f,
  -1.07859381e-01f, -2.81875599e-02f, 6.06729947e-02f, -7.09105656e-02f, 9.82286409e-03f, 8.91885012e-02f, -4.10508104e-02f, -5.71022518e-02f, -8.02224688e-03f, 7.36256838e-02f,
  -4.79755849e-02f, -2.54002474e-02f, 5.91285247e-03f, -6.72137514e-02f, -8.61082040e-03f, 5.57096489e-02f, -4.47284244e-02f, -6.81926161e-02f, -3.57430913e-02f, 7.15905353e-02f,
  9.87063795e-02f, 5.12027591e-02f, 8.36562663e-02f, 1.39182806e-01f, -1.99045464e-02f, 1.81406550e-02f, 3.26182470e-02f, 1.04151912e-01f, -2.26931311e-02f, -9.61153656e-02f,
  2.14118697e-02f, 6.60291985e-02f, -5.47378473e-02f, 7.30227213e-03f, -1.68232113e-01f, -9.99406427e-02f, -6.65231943e-02f, 4.21187729e-02f, 1.18635176e-02f, -3.53442542e-02f,
  3.12288348e-02f, 2.20853854e-02f, -9.76897776e-04f, 9.42334346e-03f, 9.82244536e-02f, 3.70911858e-03f, -6.46854937e-02f, 7.89277554e-02f, 3.83225605e-02f, 2.68067587e-02f,
  8.50668624e-02f, 1.64099429e-02f, -5.01485355e-02f, -3.54343802e-02f, -2.31784154e-02f, 1.10851675e-02f, -2.34486815e-03f, -3.23624983e-02f, 4.66077216e-02f, -3.54919322e-02f,
  8.85816216e-02f, 1.55229503e-02f, 2.93932837e-02f, 2.47573797e-02f, -4.48887274e-02f, 1.57764126e-02f, -5.36196046e-02f, -4.14146781e-02f, 1.03228755e-01f, -4.51107398e-02f,
  -7.53962621e-02f, 7.14465976e-02f, -4.13514078e-02f, -2.28759814e-02f, -4.74798121e-02f, -7.77321830e-02f, -6.87679648e-02f, 6.15569167e-02f, -6.50169626e-02f, 8.45383406e-02f,
  -7.82822296e-02f, -4.71400954e-02f, -7.85436183e-02f, 1.01673000e-01f, -7.88254812e-02f, -9.25489515e-02f, -3.03893741e-02f, 7.30183050e-02f, -4.47187051e-02f, -7.83839971e-02f,
  6.30882755e-02f, 1.49788791e-02f, 5.65986931e-02f, -2.70154793e-02f, -3.52965854e-02f, -6.12439439e-02f, 5.72254136e-02f, -3.37570421e-02f, -1.59489792e-02f, -4.81095677e-03f,
  -6.20113648e-02f, -2.84724794e-02f, -6.68468885e-03f, 5.41126318e-02f, 2.24715807e-02f, -8.03335533e-02f, 7.88199157e-02f, 5.54822721e-02f, -8.28493237e-02f, 3.41894804e-03f,
  -1.07380792e-01f, -3.55757140e-02f, 5.57379089e-02f, 2.25931928e-02f, 2.12639831e-02f, 5.65337427e-02f, -2.15891525e-02f, 3.77509557e-02f, 1.25802821e-02f, 2.82647423e-02f,
  9.10257455e-03f, -4.93786186e-02f, 3.41367796e-02f, 1.07120927e-02f, 7.67331645e-02f, -6.75313622e-02f, -4.01836969e-02f, 1.52758993e-02f, 4.04110141e-02f, 4.11540158e-02f,
  -8.02529901e-02f, 4.02971655e-02f, -9.02005285e-02f, -7.37109110e-02f, -2.20584925e-02f, 2.05693506e-02f, 1.11517860e-02f, -4.37726602e-02f, -1.08608738e-01f, -8.62602890e-02f,
  3.44433576e-01f, -2.09813237e-01f, 2.88309157e-01f, 3.24690074e-01f, 1.59570083e-01f, -7.31048584e-02f, 7.42205232e-02f, -5.79603575e-02f, 1.64274871e-01f, -1.98891506e-01f,
  -5.77061959e-02f, -2.68995911e-02f, -4.08315398e-02f, -9.75503996e-02f, -2.26326715e-02f, -2.06074640e-01f, -5.56146540e-02f, 8.93895403e-02f, 2.46155970e-02f, 6.73779547e-02f,
  1.22514069e-01f, -1.96153075e-01f, 3.17846588e-03f, -2.08346829e-01f, 5.27179390e-02f, 2.47930251e-02f, -8.23487714e-02f, -1.81072894e-02f, 1.72995531e-03f, -1.81678221e-01f,
  7.54289702e-02f, -4.69968021e-02f, -2.43469290e-02f, -4.84831780e-02f, -5.45103252e-02f, -1.90803409e-02f, 2.55543720e-02f, 1.61435921e-02f, 1.48315996e-01f, -5.23106602e-04f,
  5.01951091e-02f, -2.83148531e-02f, 3.99149861e-03f, 1.20096244e-02f, -8.98436923e-03f, 8.37963820e-03f, -1.42850764e-02f, 1.08606510e-01f, 8.54488369e-03f, 3.82281281e-02f,
  2.99982000e-02f, 1.00376546e-01f, 1.31554753e-01f, -9.12967622e-02f, -3.55849937e-02f, 5.61516695e-02f, 1.67243015e-02f, 4.59754653e-02f, -3.37091126e-02f, 5.91424145e-02f,
  -1.13323368e-01f, -5.24573065e-02f, 4.12770323e-02f, 8.59996900e-02f, 6.99291239e-04f, 1.05238929e-01f, -1.33540062e-02f, -5.95980231e-03f, 5.13343066e-02f, 3.70345376e-02f,
  1.20780431e-01f, -4.11727391e-02f, 2.63213236e-02f, -9.79122892e-02f, 1.01126850e-01f, -6.08006194e-02f, -5.18925628e-03f, 1.76741425e-02f, 5.47989795e-04f, 6.59117848e-02f,
  -5.91250956e-02f, -3.43085863e-02f, -3.52724120e-02f, 1.59806348e-02f, -6.07702434e-02f, 6.65248260e-02f, -7.71267042e-02f, -8.00038874e-03f, 4.21131440e-02f, 1.20157711e-02f,
  -1.28548324e-01f, -1.54426396e-01f, -1.08141467e-01f, -3.90975587e-02f, 4.01779748e-02f, -1.25670945e-02f, 6.27330840e-02f, -2.82678064e-02f, -3.71428207e-03f, 4.23701592e-02f,
  -2.65583470e-02f, 1.18091509e-01f, 5.41213155e-02f, 7.24648461e-02f, -6.80870712e-02f, 4.36836742e-02f, 4.82396595e-03f, -4.93179783e-02f, -8.89268145e-02f, 1.66229550e-02f,
  3.87796690e-03f, -1.95892230e-02f, 9.32223499e-02f, 3.25607806e-02f, -5.57536744e-02f, -7.74326399e-02f, -4.61559407e-02f, 5.74830770e-02f, -1.78030916e-02f, -1.02768056e-02f,
  2.55237013e-01f, 2.73436569e-02f, 2.93714404e-01f, 2.73365617e-01f, -2.10087448e-02f, -1.17012717e-01f, 1.16711862e-01f, -8.66887867e-02f, 1.43407628e-01f, 3.99029963e-02f,
  -2.03739733e-01f, 3.12352747e-01f, -3.32066379e-02f, -8.23341385e-02f, -1.39241919e-01f, -1.28620565e-01f, -8.55829045e-02f, 3.60708795e-02f, -5.70078101e-03f, 6.93878233e-02f,
  6.52665049e-02f, -1.50872216e-01f, -4.26544584e-02f, -1.35579988e-01f, 6.40044808e-02f, 1.61865562e-01f, -8.49567801e-02f, 1.42338164e-02f, -8.56230184e-02f, -9.27898586e-02f,
  5.35274073e-02f, 4.45140041e-02f, 1.97748333e-01f, 4.08744216e-02f, 4.11843359e-02f, 4.24444787e-02f, -4.20092084e-02f, -9.98226702e-02f, -3.03661879e-02f, -5.34652993e-02f,
  8.58796015e-02f, -6.55298829e-02f, -2.90671159e-02f, 2.12043226e-02f, -2.59885788e-02f, 6.51125759e-02f, 1.04684532e-01f, 1.17666140e-01f, 4.24209163e-02f, 1.41057940e-02f,
  8.96314085e-02f, 8.48196670e-02f, 2.48591881e-02f, -3.64047661e-02f, -8.04383121e-03f, 4.44634333e-02f, 3.49861942e-02f, 6.97017610e-02f, 6.81553110e-02f, 2.49718111e-02f,
  -2.67748088e-02f, -9.69368313e-03f, 2.20345357e-03f, -2.58153286e-02f, -4.99175265e-02f, 5.13643175e-02f, -7.09411129e-02f, 1.48995202e-02f, 3.76091041e-02f, -9.80774313e-03f,
  2.81441193e-02f, 5.60119823e-02f, -2.47228593e-02f, 6.63489774e-02f, -4.60240059e-02f, 1.68383978e-02f, 5.62474467e-02f, -1.86488982e-02f, 3.72837707e-02f, 7.74871856e-02f,
  -3.04598212e-02f, -4.94276583e-02f, 6.74351901e-02f, 6.29884452e-02f, -4.70491573e-02f, -1.73665490e-02f, -7.86791295e-02f, 9.75478068e-02f, -5.17986789e-02f, 3.44729908e-02f,
  -1.44287258e-01f, -1.73473850e-01f, 1.89562677e-03f, 1.31041948e-02f, -4.02766690e-02f, -1.18783284e-02f, -7.58503899e-02f, 7.45351911e-02f, -5.51396050e-02f, 3.09959054e-02f,
  5.97002804e-02f, 4.22865562e-02f, -6.74643517e-02f, -3.69176343e-02f, 1.52982222e-02f, 3.02464701e-02f, -6.44729733e-02f, 3.13964635e-02f, 6.15238696e-02f, 7.67572969e-02f,
  7.13547394e-02f, -3.44930142e-02f, 4.43372130e-02f, 4.50756326e-02f, 8.39403942e-02f, 6.77946433e-02f, 1.28156766e-02f, 7.23552778e-02f, 6.39898470e-03f, 4.58413213e-02f,
  -6.83205873e-02f, 1.90142408e-01f, 2.67783493e-01f, -1.78685054e-01f, -5.87955564e-02f, -5.14559895e-02f, -1.77965403e-01f, -8.35749728e-04f, -3.30262235e-04f, -1.84072573e-02f,
  -7.49602690e-02f, 1.88912690e-01f, 1.01335339e-01f, -1.48927405e-01f, -5.59089854e-02f, 1.65429879e-02f, -9.64929685e-02f, -1.07417457e-01f, 2.90492047e-02f, -7.02082068e-02f,
  4.71756514e-03f, -1.38636395e-01f, 4.18326966e-02f, 9.12225470e-02f, -7.17038512e-02f, 5.65962419e-02f, -9.21512544e-02f, 9.58914608e-02f, -2.00504344e-02f, -3.12219579e-02f,
  -1.11872014e-02f, -1.34815767e-01f, 3.95768359e-02f, 2.16340870e-02f, -1.34156227e-01f, -8.38271901e-03f, 7.55099952e-02f, 2.59253606e-02f, 4.19401117e-02f, 2.44060121e-02f,
  5.49769588e-03f, 5.89384995e-02f, 8.62984452e-03f, 2.99030468e-02f, 6.39116243e-02f, -3.01127713e-02f, 2.78838649e-02f, -2.77007669e-02f, 5.27103208e-02f, -3.00151724e-02f,
  2.16830932e-02f, 6.45358264e-02f, 8.03029239e-02f, 6.34879097e-02f, -5.95899224e-02f, 3.39808944e-03f, -9.50683504e-02f, 1.22909218e-01f, -2.73091849e-02f, -7.56532252e-02f,
  5.09226993e-02f, 8.15895759e-03f, -4.66189906e-02f, -6.39445856e-02f, -3.71860899e-02f, -3.51324715e-02f, 5.24839945e-02f, 2.21381965e-03f, 5.34377880e-02f, 6.85146600e-02f,
  -6.14101253e-02f, -8.75728112e-03f, 7.14606419e-02f, -1.33828551e-01f, -1.21954665e-01f, -2.85155773e-02f, 5.50020896e-02f, 7.83782359e-03f, -2.84872297e-02f, 6.42524734e-02f,
  -1.24050930e-01f, -3.53055857e-02f, -4.00049984e-02f, -2.61733625e-02f, 8.82694274e-02f, 1.17428385e-01f, -4.63248901e-02f, 7.92132244e-02f, -9.77267101e-02f, 8.46180990e-02f,
  -5.61328046e-02f, -1.50288895e-01f, -1.02370441e-01f, -1.17618497e-02f, 4.83277924e-02f, -4.17389646e-02f, 1.58573012e-03f, 1.17361555e-02f, 3.67334671e-02f, -2.47542243e-02f,
  -6.51682466e-02f, 1.29182087e-02f, -3.42839845e-02f, 6.71155229e-02f, 1.08071491e-02f, -2.89985240e-02f, -1.01644183e-02f, 7.08196014e-02f, -1.05070017e-01f, 5.73219657e-02f,
  -2.53800098e-02f, -4.28710366e-03f, 4.09608372e-02f, -4.66145687e-02f, -4.06564632e-03f, -7.68065006e-02f, 6.88749775e-02f, -3.21809687e-02f, -7.92452395e-02f, -6.88028559e-02f,
  -2.91271418e-01f, 1.96985543e-01f, -4.22668755e-02f, 4.53221388e-02f, -7.43696243e-02f, -1.10993348e-01f, 2.62842551e-02f, -2.17060260e-02f, -3.88667434e-02f, 1.53789699e-01f,
  3.68106328e-02f, -2.85317027e-03f, 1.28645256e-01f, 8.27547461e-02f, -1.87089622e-01f, -6.03330974e-03f, 4.50282730e-02f, -1.05680479e-02f, -6.15384504e-02f, -1.01026066e-01f,
  -8.83364379e-02f, 4.17892039e-02f, 1.05527230e-01f, 6.03747480e-02f, -9.10703316e-02f, -1.49598727e-02f, -9.04896259e-02f, 3.89266852e-03f, 3.03445524e-03f, 9.58674997e-02f,
  -1.37154236e-01f, -2.70169061e-02f, -2.42549591e-02f, 5.29552288e-02f, -6.01348877e-02f, -2.20232774e-02f, -1.10582486e-01f, 3.80496830e-02f, -1.27115533e-01f, 3.53628397e-02f,
  -6.74454048e-02f, -3.01099811e-02f, -6.31916597e-02f, -7.52969533e-02f, -1.18261203e-01f, 8.51300955e-02f, -1.89908349e-03f, -2.71860491e-02f, 3.02494075e-02f, 5.41747250e-02f,
  9.94707718e-02f, 1.02271371e-01f, 1.71302836e-02f, 6.14984818e-02f, -4.82399599e-04f, 5.00007197e-02f, 6.39982009e-03f, 5.85739762e-02f, 5.10889441e-02f, -5.76423220e-02f,
  4.93393950e-02f, -5.08248946e-03f, 7.09877014e-02f, 4.53243740e-02f, 2.99955737e-02f, -1.61591098e-02f, 3.44966799e-02f, 2.86553781e-02f, -6.73613995e-02f, 2.32788231e-02f,
  6.25795573e-02f, -8.49498957e-02f, 1.41462758e-02f, 6.04397692e-02f, 2.56587118e-02f, 6.69221580e-02f, 9.90065094e-03f, -4.27546389e-02f, 2.94862632e-02f, -6.62797838e-02f,
  3.40856910e-02f, 5.82497418e-02f, -3.59542854e-02f, -7.40114376e-02f, 3.49180251e-02f, 5.52543998e-02f, 7.26517737e-02f, -6.05591647e-02f, -3.69849391e-02f, -1.68969911e-02f,
  -7.18897656e-02f, -1.80630818e-01f, -1.06725134e-01f, -6.92020282e-02f, 3.85359414e-02f, 2.01355629e-02f, 1.88927110e-02f, -5.75890020e-02f, 2.51860358e-02f, -8.97737965e-02f,
  -8.97820070e-02f, 3.99355106e-02f, -8.73252004e-02f, 3.46854068e-02f, 4.23819833e-02f, -2.11337041e-02f, -2.98349280e-02f, -4.20697816e-02f, -1.47823403e-02f, -4.23033424e-02f,
  4.98991832e-02f, -9.47245061e-02f, 7.45911524e-02f, -1.15481438e-02f, 7.11864978e-02f, -2.27903109e-02f, 2.91058999e-02f, -1.06613617e-02f, -4.40311283e-02f, -6.51077852e-02f,
  -1.03856117e-01f, 3.43406573e-02f, 2.40194902e-01f, -6.86942320e-03f, 7.20347539e-02f, 8.76132771e-02f, -1.52471848e-02f, -9.53401402e-02f, -1.36319697e-01f, -1.86006427e-01f,
  -1.00436592e-02f, 5.63909225e-02f, 5.64127117e-02f, -1.78281039e-01f, 2.00744644e-01f, 6.38934970e-02f, 4.26721424e-02f, -5.15995212e-02f, 1.34093225e-01f, 1.35799162e-02f,
  6.38493225e-02f, -6.16958737e-02f, 1.51258022e-01f, -3.54785356e-03f, -2.15410604e-03f, 8.22978560e-03f, -1.41772911e-01f, 1.66560441e-01f, -1.27298042e-01f, -4.85702455e-02f,
  1.33052737e-01f, -8.75657499e-02f, 1.55787855e-01f, 1.27461940e-01f, 3.99824344e-02f, -9.91492718e-03f, 3.87063925e-03f, 3.20894085e-02f, 6.25975057e-02f, 1.19279390e-02f,
  3.75628062e-02f, -3.69271301e-02f, -1.12351656e-01f, -5.32809645e-02f, 6.30746782e-02f, -4.62804735e-02f, -3.17696743e-02f, 8.15242380e-02f, 1.87057629e-02f, 3.68534587e-02f,
  8.25594142e-02f, 2.58672088e-02f, 2.93779792e-03f, -5.93381599e-02f, -8.29763990e-03f, -8.94464925e-02f, 8.74515474e-02f, 9.39487591e-02f, 1.25869326e-02f, -6.37758002e-02f,
  -4.47761044e-02f, 5.96617609e-02f, -3.83602045e-02f, -3.99492914e-03f, -7.24625289e-02f, 5.56877740e-02f, 4.29314300e-02f, 3.64827854e-03f, -8.35516900e-02f, -4.30146828e-02f,
  -6.23031184e-02f, 7.06597194e-02f, 9.47400648e-03f, -1.20102419e-02f, 3.31497267e-02f, 5.34184240e-02f, -7.13481233e-02f, 8.13857652e-03f, 3.07349246e-02f, 8.33249092e-02f,
  3.94082032e-02f, -8.61709937e-02f, -2.12951074e-03f, 4.47903834e-02f, 5.76338992e-02f, -3.06068584e-02f, 7.56342662e-03f, 5.52913286e-02f, 2.86077634e-02f, -3.69876921e-02f,
  1.02999665e-01f, -3.63378786e-02f, 6.72709346e-02f, -2.43806448e-02f, 8.81766230e-02f, 9.41880941e-02f, 3.18532027e-02f, 2.58013755e-02f, 5.50183058e-02f, -5.85243627e-02f,
  -5.25018051e-02f, -3.04597393e-02f, -7.42340984e-04f, 2.67672539e-02f, -8.27147625e-03f, -5.78088649e-02f, 3.52256410e-02f, -2.74599958e-02f, 3.15062515e-02f, 1.02561470e-02f,
  -6.93001524e-02f, -8.54724050e-02f, -1.16250478e-01f, -5.43396287e-02f, 4.51276675e-02f, -1.01223908e-01f, -3.19102332e-02f, -7.43269622e-02f, 9.64200422e-02f, 4.49876785e-02f,
  1.14484748e-03f, -1.78532332e-01f, 2.86616273e-02f, 2.00692311e-01f, 2.22302116e-02f, -8.80100876e-02f, -1.37729757e-03f, 4.07490972e-03f, -8.45361799e-02f, -1.07549891e-01f,
  -5.85733317e-02f, -1.25219561e-02f, 2.14678477e-02f, 4.72394973e-02f, 1.19991481e-01f, 8.85986313e-02f, -9.63562727e-03f, 2.32919138e-02f, -2.36692876e-02f, 9.14847776e-02f,
  2.07226753e-01f, 1.00227237e-01f, 2.43022338e-01f, 1.22623984e-02f, 4.57358919e-02f, 6.95778579e-02f, 2.28855282e-01f, 6.40404820e-02f, 8.72857869e-02f, 8.72183368e-02f,
  -1.70391291e-01f, -1.44283269e-02f, 3.28568146e-02f, -3.90216634e-02f, 7.94773325e-02f, 6.57100454e-02f, 1.02882013e-02f, -1.67801250e-02f, 4.73116413e-02f, 5.73931262e-02f,
  1.65522546e-02f, 4.01454465e-03f, 5.17493226e-02f, 8.78863558e-02f, -4.87416610e-02f, 1.60846170e-02f, 8.21739361e-02f, 4.65602390e-02f, -8.34543779e-02f, -3.63751203e-02f,
  1.10123381e-02f, 3.09292469e-02f, 3.12532741e-03f, 7.91155696e-02f, 1.14030957e-01f, 3.31005491e-02f, -9.27808508e-03f, 8.91353190e-02f, -4.64301510e-03f, 1.17553668e-02f,
  -2.91597527e-02f, 3.65019552e-02f, 7.05682859e-02f, 2.78462246e-02f, -7.01845959e-02f, -6.29097447e-02f, 8.76358524e-03f, -3.18905488e-02f, -8.58783722e-02f, -5.41459285e-02f,
  4.27286290e-02f, 9.20267701e-02f, -7.51603395e-02f, 5.99770546e-02f, 5.78232221e-02f, -5.44290319e-02f, 9.94048566e-02f, -2.63490509e-02f, -3.08133382e-02f, -6.06139451e-02f,
  -8.30328837e-02f, 7.05675036e-02f, 4.02932502e-02f, 5.51810078e-02f, -8.58841185e-03f, 8.91259536e-02f, -2.21159030e-02f, -3.60432304e-02f, -3.64829898e-02f, 5.47220372e-02f,
  -6.61445633e-02f, 1.09675623e-01f, -4.17619869e-02f, 3.19177434e-02f, -4.33080792e-02f, -2.64209602e-02f, 4.47556153e-02f, 1.21585652e-02f, 1.73340607e-02f, -6.69018030e-02f,
  -6.41840622e-02f, -3.70960906e-02f, -1.02988938e-02f, -2.39276737e-02f, 6.83282539e-02f, -3.90867144e-02f, -1.41172530e-02f, 7.34101087e-02f, 8.69528502e-02f, -4.90466179e-03f,
  -5.23847602e-02f, -4.10368554e-02f, 9.77076367e-02f, 7.26875737e-02f, -3.04030627e-02f, 4.01460864e-02f, -3.99516225e-02f, 5.30331694e-02f, 2.29902770e-02f, -4.61465315e-05f,
  1.15143619e-01f, 1.26313955e-01f, 1.19822048e-01f, 6.34271950e-02f, -6.80015832e-02f, -1.27926722e-01f, -2.23487616e-01f, 2.06275824e-02f, -1.95127591e-01f, 2.96938121e-02f,
  -1.27954679e-02f, 1.62745088e-01f, -2.01713473e-01f, -1.33346081e-01f, -3.78771037e-01f, -3.71161252e-01f, -2.01591905e-02f, -9.08396840e-02f, -1.93501487e-01f, 1.69470906e-01f,
  -2.34993994e-02f, -4.76909764e-02f, -5.59269078e-02f, 4.62304838e-02f, 2.11585596e-01f, 3.09569836e-01f, 8.88919458e-02f, -2.08168067e-02f, 1.96952671e-01f, -1.21637166e-01f,
  1.40874628e-02f, 1.67498831e-02f, 4.14538831e-02f, 1.28471004e-02f, 8.04492310e-02f, 5.11126928e-02f, 7.96323270e-02f, 4.71779567e-05f, -5.98664843e-02f, -1.48902610e-02f,
  9.30722654e-02f, -2.10079961e-02f, -9.96061135e-04f, -8.04528128e-03f, 1.19693745e-02f, 1.00256376e-01f, 4.20072712e-02f, 4.58422974e-02f, -1.50402198e-02f, 1.11112129e-02f,
  3.66870314e-02f, 1.30349815e-01f, 1.00798775e-02f, 8.22797939e-02f, -2.86609028e-02f, -1.09321669e-01f, 8.18735212e-02f, 1.10180015e-02f, 5.34462593e-02f, 3.53955943e-03f,
  1.44404024e-02f, 5.85445054e-02f, -6.63197134e-04f, -8.60106479e-03f, 1.57971494e-02f, 2.80501582e-02f, -7.49513432e-02f, 1.27227162e-04f, -5.61169572e-02f, -3.26476581e-02f,
  -4.96659018e-02f, 2.43544430e-02f, -1.12735100e-01f, 5.90458140e-02f, 8.31096247e-02f, -1.22271152e-02f, -2.50362940e-02f, 3.87007114e-03f, -2.29652449e-02f, 4.82239909e-02f,
  -3.69825326e-02f, -1.08135529e-01f, 4.86957952e-02f, 1.66808497e-02f, -6.78158998e-02f, -2.48582810e-02f, 2.00061202e-02f, 9.38392133e-02f, -4.05383520e-02f, 9.94242541e-03f,
  -7.25310892e-02f, 1.61485642e-01f, -7.79799297e-02f, -6.80141002e-02f, 8.37202743e-03f, 3.10451202e-02f, 6.96976250e-03f, -2.00397242e-03f, -3.52286967e-03f, -9.99288708e-02f,
  1.21490248e-01f, -3.81260887e-02f, 8.47200230e-02f, 1.53618120e-02f, -8.98127779e-02f, -6.62250146e-02f, 3.02799996e-02f, 1.78134758e-02f, -1.10913759e-04f, 2.08519008e-02f,
  1.66284949e-01f, 7.95373414e-03f, 7.32583851e-02f, 2.71628927e-02f, -7.93052278e-03f, 9.38763842e-02f, -2.17902642e-02f, 8.58502612e-02f, 8.05665031e-02f, 2.96828942e-03f,
  -4.79744487e-02f, -4.28534299e-02f, -3.99507023e-02f, 1.75932273e-01f, -4.98615839e-02f, -1.10179856e-01f, -9.41922590e-02f, -4.74204868e-02f, -1.55343115e-01f, 1.97066274e-02f,
  4.56469022e-02f, -4.63225786e-03f, 7.49837458e-02f, 1.20349526e-01f, 1.74250573e-01f, 1.24861851e-01f, 4.04514708e-02f, 7.54812434e-02f, -2.39656605e-02f, 1.77230430e-03f,
  1.77722111e-01f, 1.66240320e-01f, 2.28833735e-01f, -8.38414673e-03f, 4.09399066e-03f, 1.25944108e-01f, 1.82120249e-01f, 8.23910013e-02f, 3.52378786e-02f, 9.74615365e-02f,
  6.55514151e-02f, 4.00072299e-02f, 2.70165335e-02f, -8.52303579e-02f, -2.81596426e-02f, 4.04881760e-02f, 6.97934180e-02f, 6.47201836e-02f, -2.95423586e-02f, 5.09406030e-02f,
  -4.32016142e-02f, -4.11680974e-02f, 3.00104916e-02f, 3.64841931e-02f, -3.00690141e-02f, 2.00896338e-02f, 5.25042415e-02f, 3.70159349e-03f, -4.76012081e-02f, 4.25915942e-02f,
  -1.64293386e-02f, 1.07145077e-02f, -8.26440156e-02f, -8.27246308e-02f, -5.42973988e-02f, 3.28590944e-02f, -4.11639027e-02f, -5.04315346e-02f, 5.66812642e-02f, -3.84610072e-02f,
  -9.86900926e-02f, -1.85852200e-02f, 1.72957312e-02f, 7.91579932e-02f, -5.09249456e-02f, -8.22852030e-02f, 5.25450297e-02f, 4.46672580e-04f, -1.00358427e-02f, -1.07448082e-02f,
  7.99972489e-02f, -3.91336605e-02f, 7.55291106e-03f, -2.53711157e-02f, -5.36157787e-02f, 6.44677579e-02f, 6.74887970e-02f, 6.97286204e-02f, -7.43131191e-02f, -3.78117268e-03f,
  -1.66079197e-02f, 6.17725514e-02f, -7.38364607e-02f, 9.29076299e-02f, -8.31785332e-03f, -6.98096678e-02f, -6.02991916e-02f, -3.99863645e-02f, -5.56901935e-03f, 3.15125100e-02f,
  3.27045023e-02f, 1.56004608e-01f, -5.24001196e-02f, -2.13816874e-02f, 7.45104277e-04f, -1.41404653e-02f, -2.20448188e-02f, -3.32767665e-02f, 1.00061879e-01f, -8.48297123e-03f,
  1.01200722e-01f, 3.47596072e-02f, 3.22818011e-02f, -1.35327494e-02f, 5.43745533e-02f, 9.74803977e-03f, -3.38502340e-02f, 6.55564368e-02f, 3.49466056e-02f, 1.09259941e-01f,
  7.63373002e-02f, 7.32411593e-02f, -2.78227516e-02f, 2.52359640e-02f, -4.82003763e-02f, -2.01253016e-02f, -3.55567671e-02f, -7.43241534e-02f, 4.08480167e-02f, 7.99735785e-02f,
  -2.56095305e-02f, -1.66287981e-02f, -6.94316700e-02f, 7.19034225e-02f, -9.81791392e-02f, -5.85082322e-02f, -8.71455446e-02f, -7.25767538e-02f, -7.91215003e-02f, 7.08333775e-02f,
  -5.63952401e-02f, -7.21200332e-02f, 4.09576297e-02f, 1.16091464e-02f, 6.15356416e-02f, 1.92470308e-02f, 2.86803376e-02f, -2.42517423e-03f, 2.10231896e-02f, -2.95919050e-02f,
  -2.33988576e-02f, 5.39679304e-02f, 4.31968197e-02f, -3.34845409e-02f, 2.62979995e-02f, -2.34885588e-02f, 4.54460420e-02f, -2.80344822e-02f, 7.88232982e-02f, -6.07043207e-02f,
  -5.16211018e-02f, -8.13367888e-02f, -2.10211370e-02f, 5.09231053e-02f, -1.89223345e-02f, -5.35660684e-02f, -3.26250419e-02f, -2.92127784e-02f, -2.81753927e-03f, 6.14912389e-03f,
  6.00810014e-02f, 4.73619904e-03f, -2.76422519e-02f, 7.44652525e-02f, -8.78862143e-02f, 6.94252849e-02f, -1.57394242e-02f, 6.34878725e-02f, -1.69060435e-02f, -1.69518963e-03f,
  -4.89478670e-02f, 8.31575543e-02f, 3.65043916e-02f, 3.96817140e-02f, 5.11538945e-02f, -6.60477430e-02f, 8.63900781e-02f, 5.89742400e-02f, -9.31758061e-02f, -5.77665530e-02f,
  2.71205865e-02f, 6.24651536e-02f, -6.14412501e-02f, 2.67420663e-04f, 7.28905573e-02f, 5.40440492e-02f, 4.81656641e-02f, -6.72791079e-02f, -2.45460793e-02f, 1.96833331e-02f,
  -3.62406485e-02f, 5.75689711e-02f, 6.11711890e-02f, -3.40511911e-02f, -5.53681515e-02f, -3.57090868e-02f, 8.05876628e-02f, -3.20116915e-02f, 1.90757811e-02f, -6.44046217e-02f,
  -1.29197203e-02f, 1.61002316e-02f, 7.82357380e-02f, -2.36358158e-02f, 3.59582119e-02f, -3.84310298e-02f, -3.96061018e-02f, 1.46830722e-03f, 1.56985093e-02f, 6.41069561e-02f,
  -7.80279711e-02f, -4.43818532e-02f, -3.84128541e-02f, -3.36621962e-02f, 5.43794818e-02f, 7.78120160e-02f, 3.49455401e-02f, -6.33569211e-02f, -8.69369507e-02f, -9.10390727e-03f,
  -2.63712071e-02f, -3.57581563e-02f, 3.22543904e-02f, -4.62822951e-02f, 7.63921589e-02f, 7.89841786e-02f, -3.61909084e-02f, -5.52872010e-02f, 1.99414827e-02f, 3.86545807e-02f,
  3.53554264e-02f, -7.94497412e-03f, 2.26820558e-02f, -6.64769933e-02f, -2.22548004e-02f, -8.74458849e-02f, -5.41316681e-02f, 6.64852858e-02f, 5.58971465e-02f, -1.91540103e-02f,
  3.14492911e-01f, -3.00525457e-01f, -3.65748167e-01f, -4.87706214e-02f, 1.11677840e-01f, 9.52212065e-02f, -1.32820323e-01f, 3.30133922e-02f, -1.35354131e-01f, -4.50269803e-02f,
  1.29889473e-01f, 7.16984272e-02f, -2.26393580e-01f, 2.55761176e-01f, 1.64733887e-01f, -6.05762820e-04f, 1.36816174e-01f, 1.29223228e-01f, 1.65755935e-02f, 7.27649704e-02f,
  8.93328339e-02f, 3.41743469e-01f, -1.07081413e-01f, 1.49590820e-01f, 1.49487451e-01f, -2.55831424e-03f, 1.95746154e-01f, -1.59991547e-01f, 1.68904513e-01f, 2.06448048e-01f,
  -1.79174654e-02f, 2.35592891e-02f, 1.40418671e-02f, 5.33377100e-03f, -5.11495769e-02f, 7.52322078e-02f, -1.84591860e-02f, 5.11421449e-02f, -4.73489240e-02f, -5.77569641e-02f,
  -2.56734118e-02f, 3.95236583e-03f, -2.05028821e-02f, 8.79406277e-03f, 1.13327838e-01f, -3.29084788e-03f, 1.89489387e-02f, -4.30950485e-02f, -1.00879759e-01f, 9.68689993e-02f,
  -1.49372993e-02f, -9.77560058e-02f, 1.17411241e-02f, 5.07158302e-02f, -1.03308007e-01f, -5.50697297e-02f, -1.28481358e-01f, 1.72422617e-03f, 7.88962394e-02f, -4.14266475e-02f,
  7.53933238e-03f, -1.14618754e-02f, -2.81046722e-02f, 3.44503559e-02f, -2.80926358e-02f, 4.23281118e-02f, 2.14913487e-02f, -3.07372306e-02f, -4.02008928e-02f, 6.70449883e-02f,
  -2.70737093e-02f, -6.12541027e-02f, -3.13249156e-02f, 4.72776070e-02f, 1.37870964e-02f, 7.92061165e-03f, -6.27160221e-02f, -5.00584347e-03f, -4.26515229e-02f, -7.43206143e-02f,
  -7.05748349e-02f, 6.31009117e-02f, -5.99561967e-02f, -1.53230550e-02f, -3.59280892e-02f, 6.76844195e-02f, 7.22229406e-02f, -2.64665601e-03f, -1.28618805e-02f, 1.12134265e-02f,
  5.15419170e-02f, -1.06824383e-01f, -8.50146040e-02f, -6.49098381e-02f, 6.75799474e-02f, 1.09722637e-01f, -5.29609323e-02f, 6.90671569e-03f, -4.37465794e-02f, -1.19250817e-02f,
  8.94033238e-02f, -6.06076326e-03f, -2.88317110e-02f, 1.66565012e-02f, 2.29930580e-02f, 2.40950622e-02f, 4.01153415e-03f, 4.65046428e-02f, 6.81187434e-04f, -5.38886115e-02f,
  -5.17197289e-02f, -7.06466287e-02f, -3.75930555e-02f, -4.99401763e-02f, 8.16040412e-02f, -1.51254144e-02f, 9.97223426e-03f, -3.77625190e-02f, -3.36750597e-02f, -5.55393612e-03f,
  6.63084835e-02f, -1.00838281e-01f, 3.07362303e-02f, 6.51056617e-02f, -2.78792977e-02f, -1.58118308e-01f, -1.20312862e-01f, 1.73318803e-01f, -1.22969776e-01f, -1.08982131e-01f,
  -2.70825662e-02f, -2.07855165e-01f, -1.06864586e-01f, -8.81980062e-02f, -7.39666671e-02f, -8.84941816e-02f, 5.93639724e-02f, -2.59975530e-02f, 1.02980556e-02f, 1.56667665e-01f,
  1.23322442e-01f, 1.24421276e-01f, 9.74074304e-02f, 2.01647609e-01f, 8.07007402e-02f, 2.56711274e-01f, 2.53759652e-01f, 6.74036294e-02f, 1.79304760e-02f, -1.05593503e-01f,
  -9.28922966e-02f, -2.68616397e-02f, 1.13014160e-02f, -3.21555473e-02f, 1.49878159e-01f, -5.39097004e-02f, 3.43493931e-02f, -7.27386326e-02f, 5.38493730e-02f, 5.34460098e-02f,
  -9.61902924e-03f, 4.11790423e-03f, -7.12785199e-02f, 4.52017635e-02f, -2.19263714e-02f, -6.18071929e-02f, -5.50696403e-02f, 2.46680062e-02f, -3.61835510e-02f, 3.99622954e-02f,
  -7.08540678e-02f, -2.11306848e-02f, 6.82538748e-02f, 5.90389408e-03f, 5.51967248e-02f, 4.00551818e-02f, -1.28784189e-02f, -6.19600303e-02f, -4.07311805e-02f, 8.85861292e-02f,
  -4.79659531e-03f, -4.20903787e-02f, -6.29274547e-02f, -3.75126451e-02f, -7.71023035e-02f, 1.17963813e-02f, 6.73602102e-03f, -3.12856585e-02f, -1.76198762e-02f, -5.36279427e-03f,
  -2.83628386e-02f, -1.18632261e-02f, -6.69238798e-04f, -9.14685428e-02f, 9.20521617e-02f, -3.37388180e-02f, -9.31757912e-02f, -6.10534772e-02f, -3.64187583e-02f, -3.10649406e-02f,
  -6.89911470e-02f, 4.69804034e-02f, -6.50565773e-02f, 1.66860707e-02f, -8.80965069e-02f, -4.46414538e-02f, 3.37705687e-02f, -6.92009972e-03f, 8.75083432e-02f, -2.50378549e-02f,
  9.67195481e-02f, 1.54459566e-01f, -8.24625194e-02f, -3.77683379e-02f, -1.37757985e-02f, 4.27789502e-02f, -1.08042583e-01f, -4.99960093e-04f, -5.89398481e-02f, 7.34061003e-03f,
  7.81708732e-02f, -8.88838840e-04f, 3.13693658e-02f, 8.28312803e-03f, 3.94659378e-02f, 2.20881701e-02f, 9.42215174e-02f, 5.21955565e-02f, -2.76857968e-02f, 3.49665880e-02f,
  7.89782926e-02f, 5.33373728e-02f, -9.14925411e-02f, -6.24886714e-02f, -2.84209624e-02f, 7.19750859e-03f, 8.44756588e-02f, 3.53625044e-02f, -6.70696795e-02f, 8.80500954e-03f,
  -9.21380371e-02f, -1.21151268e-01f, 1.07839875e-01f, 6.97396099e-05f, 7.45770559e-02f, 3.42048705e-04f, -1.09967902e-01f, 6.10044785e-02f, -6.26755133e-02f, -6.07506633e-02f,
  2.05982961e-02f, -1.02040321e-01f, -1.54248565e-01f, -5.94281442e-02f, 3.84174325e-02f, -1.61940977e-01f, -9.76118669e-02f, -3.25802602e-02f, 3.92752551e-02f, 9.98836085e-02f,
  4.10225987e-02f, 6.85347393e-02f, 9.94371325e-02f, 7.73683116e-02f, -3.13829780e-02f, 7.17098266e-02f, 1.29044279e-01f, 7.80858845e-02f, 7.54396021e-02f, 5.70533574e-02f,
  -3.73351872e-02f, -1.52446013e-02f, 4.60129008e-02f, 8.46649110e-02f, 4.49919188e-03f, 4.56893593e-02f, 3.86944786e-02f, 7.40149468e-02f, -5.73166125e-02f, -2.61611734e-02f,
  2.33202092e-02f, 1.71515066e-02f, 2.94578914e-02f, 7.97582716e-02f, 7.75238033e-04f, -5.48072217e-04f, 2.03721505e-02f, -9.26838070e-03f, 9.03537720e-02f, 1.31457867e-02f,
  4.40531336e-02f, -2.50615068e-02f, -6.76897168e-02f, -1.06108030e-02f, -3.76191027e-02f, 3.33662815e-02f, 6.88082129e-02f, -2.40228325e-02f, 4.65910845e-02f, 9.02621374e-02f,
  4.96171974e-02f, 1.02694966e-01f, 3.53199132e-02f, 2.41909432e-03f, 1.51628880e-02f, -3.00778598e-02f, 6.81372639e-03f, -6.29737377e-02f, -2.96741333e-02f, -4.67857458e-02f,
  5.08784428e-02f, 9.90107134e-02f, -1.85648892e-02f, -8.00259635e-02f, 7.92835560e-03f, -5.20208403e-02f, -3.31265628e-02f, 5.91334589e-02f, -4.08763513e-02f, 1.06249908e-02f,
  6.31527007e-02f, 6.17330968e-02f, -6.84472620e-02f, -4.03407365e-02f, -6.38192445e-02f, 4.61605527e-02f, 2.04023384e-02f, 1.18980864e-02f, 8.19699317e-02f, 6.04971275e-02f,
  -1.22360364e-01f, -4.15417142e-02f, 4.75312173e-02f, -7.39070028e-02f, -2.87897959e-02f, 4.41198498e-02f, -2.13221237e-02f, 4.92584519e-02f, -4.50477451e-02f, 3.48200388e-02f,
  1.03859594e-02f, -3.73973362e-02f, 8.46756697e-02f, 1.94334984e-02f, 4.91457507e-02f, 2.14365628e-02f, 5.51214349e-03f, -6.03845634e-04f, 4.36311495e-03f, -4.92579006e-02f,
  3.41838133e-03f, 4.83837398e-03f, 4.53976393e-02f, -8.45834333e-03f, 2.05289219e-02f, 5.95716871e-02f, -3.76687525e-03f, 7.69113302e-02f, 5.87878115e-02f, 8.12260136e-02f,
  -4.68853675e-02f, -2.97219396e-01f, -1.20615540e-02f, -2.66586840e-01f, -4.57105190e-02f, -2.11700648e-01f, -5.67206107e-02f, -4.19341147e-01f, -2.83374310e-01f, -3.75661284e-01f,
  -1.61030129e-01f, 9.75192264e-02f, 2.96461821e-01f, -3.28557253e-01f, 3.88506562e-01f, 2.93472528e-01f, -3.05641711e-01f, -5.89729249e-02f, -7.14518428e-02f, -2.90439874e-01f,
  -2.10330747e-02f, -2.20229149e-01f, 9.56651717e-02f, -3.35731596e-01f, -1.77969426e-01f, -3.04702729e-01f, 3.11712045e-02f, 1.21405944e-01f, -2.25661010e-01f, 1.78633891e-02f,
  -3.62671614e-02f, -1.37059808e-01f, -8.50949138e-02f, 6.16049990e-02f, -2.46003661e-02f, -4.75533679e-03f, 1.61198787e-02f, 1.47603899e-01f, 1.62622042e-03f, -2.00660136e-02f,
  4.36611176e-02f, 3.05209775e-02f, -6.50334284e-02f, 8.88765156e-02f, -8.28267261e-02f, -8.35227817e-02f, -3.35544050e-02f, -2.44815629e-02f, 1.17121749e-02f, 5.82949631e-02f,
  9.04582255e-03f, 4.12190668e-02f, -6.92276061e-02f, 1.06606297e-02f, -2.35683136e-02f, -1.21014468e-01f, -8.07238184e-03f, 1.16783708e-01f, -8.22197199e-02f, -6.53058887e-02f,
  3.03027350e-02f, 6.61062449e-02f, 6.98092729e-02f, -4.29562107e-02f, 2.73856819e-02f, 1.31661752e-02f, -6.22874461e-02f, 1.10454179e-01f, 3.27858590e-02f, 5.23398966e-02f,
  1.39424356e-03f, -2.49383412e-02f, -3.32154334e-02f, -8.67628157e-02f, -3.87083367e-02f, -1.81821845e-02f, 8.78120735e-02f, -3.89687419e-02f, -9.65226162e-03f, 5.93711995e-03f,
  2.42437162e-02f, -4.55186926e-02f, 8.00243393e-02f, 5.22259846e-02f, -5.15418500e-02f, 1.41332932e-02f, -7.58737549e-02f, 9.93477553e-03f, 3.51488553e-02f, 8.16677585e-02f,
  -4.75784540e-02f, -2.49096856e-01f, -2.34376825e-02f, -8.56338814e-02f, 5.05471677e-02f, 5.91353960e-02f, -6.53281156e-03f, -8.54732189e-03f, 9.66373086e-03f, -5.45110293e-02f,
  -2.20946800e-02f, 7.44339377e-02f, 3.67804915e-02f, -5.99671565e-02f, -2.51940396e-02f, -6.27586246e-02f, -1.33559220e-02f, 1.70692510e-03f, -2.51854341e-02f, -4.78412732e-02f,
  -5.27813993e-02f, -2.98194084e-02f, 2.87283082e-02f, -9.15196761e-02f, 3.39186639e-02f, -5.04822796e-03f, 3.08526270e-02f, -4.50209267e-02f, 4.14060876e-02f, 6.26042783e-02f,
  7.48391747e-02f, 2.06972763e-01f, 1.71419382e-01f, 1.16576709e-01f, 1.63797121e-02f, -1.32205278e-01f, -1.10937588e-01f, -4.22118492e-02f, 2.89939325e-02f, 1.75669249e-02f,
  -6.44470230e-02f, 1.41324013e-01f, 1.17041348e-02f, 5.30135930e-02f, -1.60478875e-01f, -1.13289118e-01f, -1.73736230e-01f, -5.40067665e-02f, -3.33292261e-02f, 4.30040658e-02f,
  -1.51234075e-01f, -2.12442458e-01f, -3.96795869e-02f, 2.73416992e-02f, 1.37043670e-02f, 1.47082612e-01f, -1.43261686e-01f, -4.87245823e-04f, 1.33268669e-01f, -3.97897064e-04f,
  9.96886566e-03f, 2.65820138e-02f, -2.39845607e-02f, 1.50685802e-01f, 1.56698115e-02f, -2.22899020e-02f, 1.91420522e-02f, -6.58414215e-02f, -3.46559733e-02f, 3.44876088e-02f,
  1.20178111e-01f, -6.53613135e-02f, 3.29344422e-02f, -9.35973898e-02f, 4.11682799e-02f, 4.43983823e-02f, 7.90002868e-02f, 1.33204162e-01f, 7.54219443e-02f, 1.28603086e-01f,
  6.88820854e-02f, -2.22305674e-02f, 8.99693184e-03f, -3.46404351e-02f, -6.85166568e-02f, -5.09042516e-02f, 1.22490618e-02f, 1.02573946e-01f, 1.04746073e-01f, 2.68752035e-02f,
  4.47744764e-02f, 6.20594397e-02f, 4.99610454e-02f, 2.08813567e-02f, -1.92811433e-02f, -2.93381065e-02f, 1.76505521e-02f, 4.96546254e-02f, 1.70715284e-02f, 5.13086375e-03f,
  6.66117370e-02f, -4.17311564e-02f, 7.95856118e-02f, 3.34471501e-02f, -8.42953622e-02f, -9.56811663e-03f, 4.91440743e-02f, -2.41451859e-02f, -2.39586178e-02f, 4.76564951e-02f,
  3.84048708e-02f, -4.26976569e-02f, 2.81343758e-02f, 4.32504863e-02f, -8.21279287e-02f, -8.50147475e-03f, -2.04185415e-02f, -6.24726117e-02f, 9.32201818e-02f, 4.83047552e-02f,
  -1.46103010e-01f, -2.66113207e-02f, 6.89774528e-02f, 6.47297129e-02f, -1.72772985e-02f, 6.31150305e-02f, -3.42025757e-02f, 8.43086317e-02f, -8.25982094e-02f, -6.58690976e-03f,
  5.30132279e-02f, -2.97741443e-02f, 6.32160977e-02f, 4.60351724e-03f, -1.07722916e-01f, -2.47590747e-02f, -1.28248986e-02f, -2.88489927e-02f, 6.93554655e-02f, 8.36033449e-02f,
  -6.60559312e-02f, -4.91234548e-02f, -5.53853810e-02f, -5.76091856e-02f, -3.33764851e-02f, 3.44540030e-02f, 8.16644132e-02f, 6.10746630e-02f, 4.88810278e-02f, -4.20398265e-02f,
  -6.82585239e-02f, 1.54867157e-01f, -2.80918926e-01f, 8.99998769e-02f, -2.35320837e-03f, 2.17878252e-01f, 1.71932131e-01f, 2.69736014e-02f, 1.21941000e-01f, 2.40293846e-01f,
  1.83998376e-01f, -1.67590529e-02f, 7.75418505e-02f, 3.50643694e-01f, 1.14647411e-01f, 5.16569391e-02f, 3.16679537e-01f, 1.98584124e-01f, -8.84002298e-02f, 1.43307105e-01f,
  -7.73480535e-02f, 1.95694372e-01f, 1.33689297e-02f, -3.83351594e-02f, 6.89078793e-02f, -2.28466123e-01f, 2.82335579e-02f, -1.26081869e-01f, 8.73200148e-02f, -4.16413881e-02f,
  -9.88967440e-05f, -2.97264233e-02f, 8.20559822e-03f, -4.59954217e-02f, -1.67500996e-03f, -8.76941681e-02f, -1.11120380e-02f, -9.48557928e-02f, -9.99812260e-02f, 2.49930881e-02f,
  -6.15902543e-02f, 1.22624049e-02f, -4.18036170e-02f, -5.83717301e-02f, -1.16594378e-02f, 2.11577360e-02f, 1.11527601e-03f, 1.16884718e-02f, 8.70495066e-02f, -1.86239332e-02f,
  -9.45223197e-02f, -8.61482993e-02f, 2.21530870e-02f, -2.63680127e-02f, -9.75739583e-02f, 4.32513282e-02f, 4.97398004e-02f, -5.77120818e-02f, -6.53950032e-03f, 6.97833747e-02f,
  4.25252207e-02f, -2.69809701e-02f, 2.91229542e-02f, -5.50562181e-02f, 6.00216575e-02f, -5.71809672e-02f, 5.49069606e-02f, 9.43675190e-02f, -3.19925509e-02f, 3.16173807e-02f,
  3.77807170e-02f, -1.33717675e-02f, 5.78450412e-03f, 7.20661059e-02f, 5.45496233e-02f, -2.42677424e-03f, -3.98388691e-02f, -4.78057228e-02f, 4.08921912e-02f, 1.09874289e-02f,
  -4.29423377e-02f, 3.91730107e-02f, 7.56725594e-02f, 1.82627942e-02f, -2.80923732e-02f, 2.44723149e-02f, 2.46945973e-02f, -4.17705886e-02f, -6.10084459e-02f, 1.98698211e-02f,
  5.90975545e-02f, 1.42871201e-01f, 3.07980571e-02f, 1.46029973e-02f, 3.16006616e-02f, 3.23680192e-02f, 1.87402423e-02f, 6.00889400e-02f, 6.84443489e-03f, -5.42302318e-02f,
  -3.79548520e-02f, 2.36539561e-02f, 2.56341510e-02f, 6.87379837e-02f, 3.18915071e-03f, -1.95268728e-02f, 5.81146069e-02f, 1.01154100e-03f, 4.22066040e-02f, 4.54983227e-02f,
  -3.69594170e-04f, 6.32171333e-02f, -2.96115912e-02f, 2.89574023e-02f, 3.23386528e-02f, -4.21646796e-02f, 5.57845868e-02f, -5.77954426e-02f, -7.47385342e-03f, -4.23077606e-02f,
  3.00518841e-01f, 8.23967680e-02f, 1.47567376e-01f, 2.45270267e-01f, -8.31555855e-03f, 1.62840709e-01f, 1.02626823e-01f, 3.93333323e-02f, 5.01408935e-01f, 4.04643975e-02f,
  -2.50983447e-01f, 3.66806537e-01f, -1.03557788e-01f, -3.70968059e-02f, 1.00987636e-01f, 2.49855202e-02f, 1.87849149e-01f, 1.02297813e-01f, 1.09026954e-01f, 1.47295073e-01f,
  1.54090272e-02f, -5.52755110e-02f, -2.84824818e-01f, -3.15727681e-01f, -1.26011312e-01f, -8.65149647e-02f, -2.70536810e-01f, -2.17559874e-01f, -2.25873753e-01f, -9.75034758e-02f,
  8.49475246e-03f, 2.34715026e-02f, -6.72279671e-02f, 2.05584336e-02f, -2.38182489e-02f, -6.43051714e-02f, 3.73852514e-02f, -5.28141446e-02f, 8.37882794e-03f, 1.16169922e-01f,
  1.01151600e-01f, 6.27723988e-03f, 6.49882630e-02f, -3.67233390e-03f, 4.11699042e-02f, -2.01312210e-02f, 3.48262867e-04f, -6.16607815e-02f, 6.42215535e-02f, -4.36418615e-02f,
  5.81826195e-02f, -2.76331212e-02f, 5.11066765e-02f, 5.59804495e-03f, -5.14790490e-02f, -2.79006809e-02f, 1.10680506e-01f, -6.64724857e-02f, -4.17383872e-02f, 6.29365668e-02f,
  -1.82591602e-02f, 9.95819196e-02f, -8.17920268e-02f, -7.56828412e-02f, 7.18109459e-02f, -1.21293366e-01f, -1.90328285e-02f, -2.22051758e-02f, 6.26923814e-02f, -4.17649094e-03f,
  7.25945085e-02f, -6.45585284e-02f, 2.81655998e-03f, 8.13115984e-02f, 4.90174405e-02f, 5.69488145e-02f, -5.88936694e-02f, -7.50839189e-02f, 3.34881917e-02f, -6.91837743e-02f,
  4.18838905e-03f, 8.74934196e-02f, -5.35107628e-02f, -4.65798080e-02f, 2.51203608e-02f, -5.00169694e-02f, -2.46691033e-02f, 3.00939102e-03f, 5.10611907e-02f, -4.99919206e-02f,
  3.81127372e-02f, 2.82416582e-01f, 3.32175900e-04f, -2.83338111e-02f, 3.58067118e-02f, 9.83628910e-03f, 5.86231006e-03f, 9.19432640e-02f, 2.74558924e-02f, 5.09565696e-02f,
  -8.07052776e-02f, 6.94438517e-02f, 1.09263279e-01f, -8.63850340e-02f, 6.78176433e-02f, 2.40131617e-02f, 1.54033098e-02f, -3.08826063e-02f, 4.00229432e-02f, -3.96506675e-02f,
  -8.07375014e-02f, 1.39574148e-02f, 3.14233191e-02f, 9.29007679e-02f, 1.42226424e-02f, -5.46088889e-02f, 7.51909390e-02f, -4.95274328e-02f, -5.17372079e-02f, 7.32000964e-03f,
  6.76515847e-02f, 2.78644979e-01f, 1.15462296e-01f, 3.45027000e-02f, -1.44864544e-01f, 1.31317135e-02f, 5.02763374e-04f, -5.34944348e-02f, 3.57826315e-02f, 1.20243780e-01f,
  -1.36000529e-01f, 1.64037138e-01f, -1.75843239e-02f, 1.30840752e-03f, -3.02708149e-01f, -1.48552537e-01f, -1.54898807e-01f, 6.33830279e-02f, -2.31873747e-02f, 2.71087606e-02f,
  -1.36924544e-02f, -1.30777210e-01f, 1.48274163e-02f, -7.17232153e-02f, 4.14058790e-02f, 1.55106623e-04f, -1.49630144e-01f, -7.02811256e-02f, 1.47049293e-01f, 6.35123774e-02f,
  -8.92049298e-02f, 1.02425357e-02f, 1.39774883e-03f, -6.51847455e-04f, -3.85688841e-02f, 5.35534620e-02f, -2.67062020e-02f, -3.09807528e-02f, -1.77276079e-02f, 7.56588057e-02f,
  -7.68449949e-03f, -3.16288508e-02f, 1.08974285e-01f, -1.74619723e-02f, 3.24963108e-02f, 1.02102570e-01f, 8.33739638e-02f, -1.92691181e-02f, 1.21722564e-01f, 6.28794953e-02f,
  1.25108674e-01f, 1.39730051e-01f, -2.63030101e-02f, 1.04272023e-01f, -5.24846429e-04f, 1.21281929e-02f, -2.66327020e-02f, 3.87309566e-02f, 1.10622175e-01f, -6.29491284e-02f,
  4.93067615e-02f, -7.82517046e-02f, -4.80465293e-02f, -4.02862504e-02f, -5.23363985e-02f, 1.76570751e-02f, 4.35501076e-02f, -1.33215880e-03f, 4.29453813e-02f, 1.67010576e-02f,
  -5.80534451e-02f, 8.38635564e-02f, 3.39607559e-02f, -5.56394160e-02f, -4.78074290e-02f, 6.75457940e-02f, -5.22175198e-03f, -2.58537829e-02f, 5.43135032e-02f, 2.27435976e-02f,
  -6.70299828e-02f, -3.18668187e-02f, 2.52689142e-02f, -6.73815459e-02f, 6.34663329e-02f, -5.09467758e-02f, 7.79481605e-02f, 1.23205539e-02f, 3.41459438e-02f, -7.32713714e-02f,
  -1.41539872e-02f, -1.25394136e-01f, 7.97348022e-02f, -1.88844334e-02f, 1.43242422e-02f, 5.27065247e-02f, 3.35750468e-02f, 2.41211280e-02f, -8.22156742e-02f, 6.37491094e-03f,
  -3.03489547e-02f, -2.91433278e-02f, 2.57203300e-02f, 6.39327522e-03f, 7.20626814e-03f, -7.62230158e-02f, -8.24498236e-02f, -3.44162360e-02f, 2.92977039e-02f, -1.85266994e-02f,
  8.42242613e-02f, 7.33204037e-02f, 9.83459223e-03f, -6.78987280e-02f, 2.60618720e-02f, -1.12932418e-02f, -3.65521200e-02f, -2.09930837e-02f, -8.44953582e-02f, 1.89526100e-02f,
  -2.35151544e-01f, 6.07410222e-02f, -2.67141491e-01f, -2.22321972e-01f, -1.68912485e-01f, -3.08366358e-01f, -3.21318597e-01f, -1.08108312e-01f, 1.81751475e-01f, 2.81337835e-02f,
  -1.86142270e-02f, 6.42517880e-02f, 1.80980697e-01f, -1.17534265e-01f, -5.16545251e-02f, 1.67693540e-01f, -3.22430551e-01f, -6.17887564e-02f, 1.08472355e-01f, -1.92372262e-01f,
  -9.70189646e-02f, -1.32077605e-01f, 3.07773389e-02f, 1.08952979e-02f, -1.98809475e-01f, -9.48646665e-02f, 3.52713875e-02f, -1.91668794e-02f, -1.92554563e-01f, -2.60203499e-02f,
  -1.84962094e-01f, 8.00997391e-02f, -1.07513815e-01f, -6.63606599e-02f, -1.49177611e-01f, -1.12695202e-01f, -1.56244949e-01f, -8.01030993e-02f, -9.12939012e-02f, -7.50259161e-02f,
  -2.33146176e-02f, 5.78087335e-03f, -3.50718945e-02f, 5.36357313e-02f, -4.78553064e-02f, 7.32596740e-02f, -1.11470008e-02f, -5.57836443e-02f, 2.89605428e-02f, 4.06120978e-02f,
  1.51803754e-02f, -2.56066676e-02f, -3.99411097e-02f, -1.63194053e-02f, -7.70525113e-02f, 5.16739534e-03f, -1.01415366e-01f, -3.95890586e-02f, -9.99535546e-02f, 5.96336201e-02f,
  -7.23807961e-02f, 4.81834300e-02f, -6.49111122e-02f, 3.45443524e-02f, 1.96550917e-02f, -2.15766411e-02f, -3.47481184e-02f, 4.81233150e-02f, 1.34399952e-02f, -5.38873449e-02f,
  3.31186019e-02f, -1.12334639e-02f, 4.55292538e-02f, -1.17593082e-02f, 1.47100314e-02f, -5.66450283e-02f, -6.93111047e-02f, -5.88557087e-02f, 2.29817759e-02f, 6.79771006e-02f,
  -1.49025805e-02f, 5.56490943e-02f, -5.25511540e-02f, -1.15306536e-02f, 2.82728858e-02f, 6.15937896e-02f, 2.10226048e-02f, 4.08922955e-02f, -4.36842814e-02f, -1.23621933e-01f,
  -1.17029876e-01f, -1.17167495e-02f, -1.10383920e-01f, -3.53329815e-02f, -9.57225934e-02f, 1.11126350e-02f, 3.88794020e-02f, -6.21842928e-02f, -6.77155629e-02f, -9.35514569e-02f,
  -2.19971663e-03f, -2.44772658e-02f, 2.16435920e-02f, 6.69093654e-02f, 5.69926463e-02f, 1.44399684e-02f, 3.72817926e-02f, 5.52471876e-02f, -1.28312334e-01f, 7.09534138e-02f,
  3.93996648e-02f, 3.72181050e-02f, 8.53492040e-03f, -8.59458651e-03f, -5.55440485e-02f, -3.58932018e-02f, -1.15136877e-02f, -4.49524540e-03f, -1.79607067e-02f, -6.22723885e-02f,
  -5.68433702e-02f, 7.07567856e-02f, 7.44270757e-02f, -3.20552057e-03f, -1.34266764e-01f, -1.14963939e-02f, 1.32963851e-01f, 4.87203412e-02f, -1.02242939e-02f, 1.42931134e-01f,
  -1.38913259e-01f, 1.58873349e-01f, 8.92306194e-02f, 1.34694487e-01f, -6.76780567e-02f, -2.23563183e-02f, 3.66251245e-02f, 1.53061718e-01f, 1.12106092e-02f, -1.10875880e-02f,
  -1.21324129e-01f, -1.24536112e-01f, -8.45300127e-03f, 4.56402078e-02f, -2.37536468e-02f, 3.09670437e-02f, -8.51164684e-02f, 4.30645011e-02f, -3.76770459e-02f, -1.10637404e-01f,
  9.19811614e-03f, -5.05685396e-02f, 3.93391438e-02f, 4.24887054e-02f, 7.96935484e-02f, -1.08866179e-02f, 4.24622148e-02f, 2.29761824e-02f, 3.03240921e-02f, 7.08681997e-03f,
  9.04740393e-02f, 7.45732412e-02f, 5.96924908e-02f, -1.40128918e-02f, 3.56478505e-02f, -5.90833761e-02f, 9.10047591e-02f, -1.47681143e-02f, 9.59915742e-02f, 3.51954289e-02f,
  7.51935765e-02f, 7.63172880e-02f, 1.16759032e-01f, -9.71435197e-03f, 3.66992541e-02f, 6.01182058e-02f, -6.30687028e-02f, -8.67929310e-02f, -6.79336712e-02f, 1.34050455e-02f,
  -4.94482964e-02f, -4.94673252e-02f, -4.75106575e-02f, -6.44698218e-02f, 1.91824082e-02f, -4.33411449e-02f, 3.65368277e-02f, -7.67127052e-02f, 6.01353757e-02f, -4.88433130e-02f,
  3.38969752e-02f, -8.58858153e-02f, 2.62072962e-02f, 3.25030759e-02f, 4.81685810e-02f, -2.44358387e-02f, -6.80528581e-02f, -6.00164160e-02f, 6.23874404e-02f, 3.67217399e-02f,
  -3.87120806e-02f, 1.07640093e-02f, -6.94754943e-02f, 1.86631996e-02f, -3.05080693e-02f, -8.94987781e-04f, 5.43604940e-02f, 1.61695499e-02f, 6.06072322e-02f, 4.61348146e-02f,
  -8.70853588e-02f, 3.36010717e-02f, 4.33423966e-02f, 9.25715566e-02f, 9.51648429e-02f, 2.94495188e-02f, 6.75176755e-02f, 5.89117073e-02f, 4.90167849e-02f, 1.07369190e-02f,
  -5.89069240e-02f, -2.39041280e-02f, 1.00872636e-01f, 4.25443100e-03f, 1.32182324e-02f, -1.48004582e-02f, 9.42848474e-02f, 4.63839732e-02f, 4.63365130e-02f, -4.78051752e-02f,
  -2.44138185e-02f, -5.16014099e-02f, 4.53475565e-02f, -5.15230708e-02f, -5.43109179e-02f, 8.94445255e-02f, -7.63036385e-02f, -2.65061948e-02f, -4.37082238e-02f, 4.95419689e-02f,
  6.99927285e-02f, -1.86037987e-01f, 8.71652365e-03f, 1.47666901e-01f, 1.16259582e-01f, 3.95096876e-02f, -1.14784315e-02f, -9.97209847e-02f, -2.38151342e-01f, -2.28245333e-01f,
  1.40091479e-01f, 8.78499970e-02f, 2.02567782e-03f, 3.92421894e-02f, 1.70261860e-01f, -4.09786291e-02f, -9.60719958e-02f, 8.06433707e-02f, -5.98020889e-02f, 6.78754076e-02f,
  -2.45640222e-02f, 1.21674143e-01f, 1.48512628e-02f, -1.24204800e-01f, -1.43815689e-02f, -1.29933860e-02f, 9.69209000e-02f, 1.53183073e-01f, 1.17550194e-01f, 1.71309456e-01f,
  6.30416945e-02f, -9.30328071e-02f, -4.98832623e-03f, 8.34115967e-03f, -8.88211653e-02f, -3.20754088e-02f, 6.00751527e-02f, 5.52117862e-02f, 6.71496168e-02f, -7.21629262e-02f,
  -3.45920622e-02f, 1.11247085e-01f, -7.88105354e-02f, 7.08194356e-03f, -2.81813694e-03f, 5.58840074e-02f, -1.89232063e-02f, 5.17304502e-02f, -3.38949338e-02f, -7.87863508e-02f,
  -7.55315498e-02f, -1.23486184e-01f, -3.87352407e-02f, 2.17325706e-02f, -7.31793279e-03f, -6.27474561e-02f, -1.98339280e-02f, 2.68907044e-02f, -8.46336111e-02f, -1.24454409e-01f,
  -1.27811043e-03f, 6.65232539e-02f, -2.45577451e-02f, 7.50195533e-02f, 7.24287704e-02f, 6.19484037e-02f, -7.42832273e-02f, -2.62849033e-02f, 2.96085738e-02f, 3.22279967e-02f,
  6.25198409e-02f, -2.09047087e-02f, 8.47923979e-02f, -9.30542797e-02f, -1.91614926e-02f, 2.20626388e-02f, 7.58844465e-02f, -7.97549114e-02f, 1.39979832e-02f, 3.11979540e-02f,
  -3.10481936e-02f, -3.08967158e-02f, 2.36131325e-02f, 9.11439732e-02f, 5.43005317e-02f, -2.15031877e-02f, 1.03384241e-01f, 1.11301048e-02f, 7.75765777e-02f, -5.70021495e-02f,
  -1.17357694e-01f, -7.57904723e-03f, 3.16136405e-02f, 5.47200814e-02f, -7.39662871e-02f, -1.24963010e-02f, 7.55542070e-02f, -2.27100737e-02f, 4.78102220e-03f, -7.56152272e-02f,
  -1.56012094e-02f, 6.65109083e-02f, -2.88609043e-02f, 2.34243143e-02f, 1.13426119e-01f, -3.18771377e-02f, 6.56073689e-02f, -8.31944942e-02f, 7.04103038e-02f, -1.05563672e-02f,
  -6.77582771e-02f, -8.27994570e-02f, 2.41116732e-02f, -6.87599406e-02f, -1.08213341e-02f, -2.14137544e-04f, 2.41624024e-02f, -2.48371549e-02f, -2.97744758e-02f, -6.43911287e-02f,
  -1.31887104e-02f, -3.32087628e-03f, -1.04163187e-02f, -6.48062304e-02f, 2.80114003e-02f, 1.98802009e-01f, -4.78911065e-02f, -5.12880422e-02f, -1.78605199e-01f, 3.01129278e-02f,
  4.79149409e-02f, -1.80747479e-01f, -3.43216360e-02f, -2.14026272e-02f, 6.04425520e-02f, -2.74404995e-02f, 1.22311912e-01f, -4.13991287e-02f, -2.35489719e-02f, -5.42529225e-02f,
  -1.70250912e-03f, 1.55305535e-01f, 4.90801930e-02f, 5.35189547e-02f, -1.47835016e-02f, 5.06646447e-02f, 8.95442888e-02f, -5.27683273e-02f, 1.30582750e-01f, 8.64015240e-03f,
  1.02490224e-01f, -1.07031107e-01f, -3.68450545e-02f, -3.85949910e-02f, 2.28110794e-02f, 6.90358132e-02f, 7.09930575e-03f, -8.25315043e-02f, -7.97782913e-02f, 4.31080334e-05f,
  -6.76063672e-02f, 5.88587001e-02f, 1.77549962e-02f, -1.00191772e-01f, 8.33531022e-02f, -2.69174799e-02f, 1.06060831e-02f, -6.61862865e-02f, 6.63960725e-03f, 3.00081298e-02f,
  1.22799007e-02f, 1.15074804e-02f, -2.36612745e-02f, -4.25406732e-02f, -5.87116666e-02f, -6.11411668e-02f, -4.87512462e-02f, 2.57608630e-02f, -3.08242682e-02f, 5.44452779e-02f,
  -1.77103542e-02f, -4.05676365e-02f, -4.84386869e-02f, 1.86026413e-02f, -4.40091565e-02f, 5.42733297e-02f, -1.36923790e-02f, 7.66129196e-02f, 9.13165584e-02f, -1.32922698e-02f,
  5.83694689e-02f, -7.13040158e-02f, -6.44270703e-02f, -2.56873313e-02f, -5.31902947e-02f, 4.12432365e-02f, 4.30081598e-02f, 1.17887268e-02f, -7.49697238e-02f, 2.69414857e-02f,
  -9.95707810e-02f, 3.79708745e-02f, 5.06976396e-02f, 4.52806093e-02f, 6.97470531e-02f, 6.53244704e-02f, -2.02869028e-02f, 6.47186190e-02f, 7.58817345e-02f, 6.51967078e-02f,
  -5.84683865e-02f, -6.72908826e-03f, -7.21769929e-02f, -6.62499815e-02f, 1.27093587e-02f, -4.16729525e-02f, 3.99610121e-03f, 4.22266610e-02f, -3.74719389e-02f, 2.61155255e-02f,
  6.21821620e-02f, 4.68449742e-02f, -3.16226333e-02f, -1.07322633e-02f, -5.13264798e-02f, 2.64718458e-02f, -8.73980299e-02f, -1.76081099e-02f, 2.36808788e-03f, 5.35233170e-02f,
  7.64658526e-02f, 2.82216957e-03f, -1.81944892e-02f, 1.03569962e-01f, 6.03403077e-02f, 5.69468401e-02f, 8.37011710e-02f, -1.57331713e-02f, -1.03163794e-02f, 8.90527852e-03f,
  -1.47200584e-01f, -1.73869520e-01f, 8.21763277e-03f, 1.35631785e-01f, -6.39666468e-02f, 2.99471729e-02f, 1.29037678e-01f, -1.63905457e-01f, -1.11544989e-01f, 9.23451334e-02f,
  1.65731981e-01f, -1.27094299e-01f, 6.27464056e-02f, 8.94865617e-02f, 4.19530347e-02f, 1.07303284e-01f, 1.51712969e-01f, 5.51201440e-02f, -1.09898373e-01f, -4.32257494e-03f,
  1.80132035e-02f, 1.04429878e-01f, 3.45865488e-02f, -1.03554688e-01f, -6.58155531e-02f, -3.20555978e-02f, 6.17491864e-02f, -9.98464972e-02f, -3.96102630e-02f, -2.92764846e-02f,
  -1.06127381e-01f, -1.90488733e-02f, 1.42351659e-02f, -1.21663854e-01f, -2.97578480e-02f, 6.60458282e-02f, 4.58429493e-02f, -7.24020526e-02f, -5.97720668e-02f, 5.00103235e-02f,
  -1.56962294e-02f, -4.49468233e-02f, -9.23597664e-02f, -3.00521273e-02f, -6.83049262e-02f, -3.74512486e-02f, -2.39299629e-02f, 5.07395864e-02f, 2.18343362e-03f, -6.39398247e-02f,
  2.88982019e-02f, -7.46124610e-02f, 1.10247560e-01f, -3.41913127e-03f, 7.79114664e-02f, 8.79324153e-02f, -2.54592095e-02f, 7.56599680e-02f, -4.63998541e-02f, -1.00338325e-01f,
  3.73378731e-02f, 5.09830937e-02f, 8.02571625e-02f, -2.40977854e-02f, -4.47404534e-02f, 9.84896161e-03f, -1.44417090e-02f, 1.95989050e-02f, -5.15247360e-02f, 4.81469631e-02f,
  -2.06146166e-02f, -2.21438613e-02f, -3.04817762e-02f, 6.25800639e-02f, 9.35789850e-03f, 7.21546933e-02f, -1.89162809e-02f, -5.85886054e-02f, -4.45043445e-02f, 5.62549122e-02f,
  6.06865399e-02f, -8.75360593e-02f, 6.70058355e-02f, 1.81664266e-02f, 2.98253577e-02f, -2.44764350e-02f, -3.91130857e-02f, 3.59280892e-02f, -3.40923289e-04f, 6.26390148e-03f,
  -8.99350941e-02f, -1.88964054e-01f, 2.54734922e-02f, -6.31998852e-02f, 6.36619255e-02f, -5.06656282e-02f, 5.54509610e-02f, -8.85222703e-02f, -5.57157062e-02f, 1.42546929e-02f,
  -9.51025933e-02f, 7.99824744e-02f, -1.05763622e-01f, 1.41414125e-02f, -1.70957930e-02f, -2.96459161e-02f, 9.35758650e-02f, -8.34110826e-02f, -7.52232363e-03f, -2.00552884e-02f,
  8.71992633e-02f, -7.41549879e-02f, 6.37875944e-02f, -4.91656475e-02f, -2.29057390e-02f, -5.05815856e-02f, -8.78256261e-02f, -5.92880398e-02f, -4.20820490e-02f, -9.13536176e-03f,
  -2.45110914e-01f, 1.82063833e-01f, -2.25761876e-01f, -1.44375846e-01f, 1.50064766e-01f, -8.94858092e-02f, -5.41216843e-02f, 7.45916367e-02f, -2.12317199e-01f, 1.94390133e-01f,
  7.61963427e-02f, -5.88665605e-02f, 4.20071520e-02f, -5.48598282e-02f, -4.28604811e-01f, 6.95510389e-05f, -1.64917767e-01f, -3.65261957e-02f, -8.82267430e-02f, 5.66932596e-02f,
  -2.52893232e-02f, 7.26411641e-02f, -1.57646507e-01f, 2.23721504e-01f, 6.67713657e-02f, 7.17689097e-02f, 1.04033984e-01f, 4.30468023e-02f, 7.05859512e-02f, -9.96453315e-02f,
  7.92557281e-03f, 3.58664989e-02f, 6.98398650e-02f, -3.14215086e-02f, -8.44065845e-02f, 9.37996507e-02f, -1.28567405e-02f, -7.19168335e-02f, -8.32382441e-02f, -7.82329813e-02f,
  -1.02140576e-01f, 2.73348149e-02f, -8.74036998e-02f, -7.89849684e-02f, 4.16439176e-02f, -1.76100451e-02f, -5.65508790e-02f, -1.61537509e-02f, -3.35691497e-02f, -5.27493190e-03f,
  -8.42778087e-02f, 1.95060857e-02f, -7.89788552e-03f, -1.94354157e-04f, -1.45289123e-01f, -5.99178933e-02f, 3.86355072e-02f, 3.92553397e-02f, -1.10236026e-01f, -9.08375829e-02f,
  -1.67454407e-02f, -6.31937608e-02f, 3.32491249e-02f, -2.06486862e-02f, 1.14506539e-02f, -7.23432824e-02f, -4.50033993e-02f, -8.97989497e-02f, 6.40886351e-02f, 4.63051461e-02f,
  -5.08374982e-02f, -6.77868724e-02f, 3.34884785e-02f, 2.28407923e-02f, 3.24428491e-02f, -1.10423472e-02f, 2.74475440e-02f, 2.14308333e-02f, 3.18975747e-02f, 8.16848576e-02f,
  3.95233631e-02f, -2.04527881e-02f, 6.16593622e-02f, -2.65473835e-02f, -3.47836912e-02f, 5.39050139e-02f, -7.56919160e-02f, 3.60061936e-02f, 5.28310612e-02f, 1.17309215e-02f,
  5.87446690e-02f, -4.26258147e-02f, 1.49549521e-03f, -1.82978194e-02f, 7.57473633e-02f, -2.90029962e-02f, -7.98697546e-02f, -6.04747273e-02f, -1.26413956e-01f, -4.80538718e-02f,
  -7.92096257e-02f, 2.57789623e-02f, -8.31048638e-02f, 2.50118524e-02f, -1.30622923e-01f, 5.20545207e-02f, 5.43459058e-02f, -8.36754739e-02f, -2.22137365e-02f, 2.15545855e-02f,
  9.84141789e-03f, 6.62901849e-02f, -2.60695051e-02f, 5.29232174e-02f, 5.35784960e-02f, 2.93300338e-02f, -6.50209635e-02f, -5.84087446e-02f, -1.36168730e-02f, -5.84471822e-02f,
  -4.18987155e-01f, 6.18721545e-02f, -9.69804600e-02f, -1.00180805e-01f, -1.66780278e-01f, -1.73343182e-01f, 5.88771403e-02f, -1.17726557e-01f, -5.99413132e-03f, 2.27541015e-01f,
  1.80453956e-01f, -1.10268101e-01f, 3.01750898e-01f, 1.16502278e-01f, -2.78236002e-01f, 1.81386039e-01f, -8.67990404e-02f, 1.65356189e-01f, -7.78367445e-02f, -1.47698700e-01f,
  -1.14455931e-01f, 7.12528750e-02f, -7.31274933e-02f, 2.54222471e-02f, -1.55338705e-01f, -2.02546090e-01f, -4.28040922e-02f, -4.77914400e-02f, -1.30484849e-01f, -2.87909266e-02f,
  -2.17467606e-01f, -1.60524771e-01f, -2.27088686e-02f, -1.35678902e-01f, -7.93795958e-02f, -6.99458346e-02f, -1.16279488e-02f, 2.10085753e-02f, -4.78689501e-04f, 1.95800364e-02f,
  -1.53888473e-02f, 1.86014338e-03f, -1.08483620e-02f, -4.54918249e-03f, 6.16295310e-03f, 5.09454720e-02f, -1.59569010e-02f, -2.44642049e-02f, 4.43806760e-02f, -2.66383383e-02f,
  -1.98356528e-02f, -5.62667400e-02f, -3.02359685e-02f, 5.66064455e-02f, -1.10416479e-01f, 8.12086388e-02f, 7.41919652e-02f, 1.69885661e-02f, -4.24489342e-02f, 3.14664915e-02f,
  -6.63168803e-02f, 4.73417640e-02f, 7.26803541e-02f, 3.00591178e-02f, 6.18990883e-02f, 3.77017707e-02f, 6.47324249e-02f, 4.36472818e-02f, -9.76420566e-03f, -6.15185387e-02f,
  -2.04005465e-03f, 3.09666991e-02f, -5.22935279e-02f, -8.52132738e-02f, -5.62152006e-02f, 1.32629462e-02f, 1.88185647e-02f, -5.69957215e-03f, -7.69437551e-02f, -7.51980618e-02f,
  -6.63349964e-03f, -8.56859982e-02f, 1.43598314e-04f, 6.64416179e-02f, -1.54266311e-02f, -3.97011973e-02f, 5.59746230e-04f, 4.26475704e-02f, 3.54401730e-02f, -1.35934902e-02f,
  -1.68812484e-01f, -8.89995396e-02f, 5.43153286e-02f, 2.99988668e-02f, 2.09946113e-04f, -2.83064265e-02f, 1.10404962e-03f, -6.63794053e-04f, -8.04167837e-02f, -4.53240834e-02f,
  1.55305779e-02f, 5.95970564e-02f, -5.47454208e-02f, 5.28738312e-02f, -5.86725287e-02f, -4.67080288e-02f, -8.68616849e-02f, -1.41396411e-02f, -8.76178220e-02f, -1.13382861e-01f,
  3.06817982e-02f, 4.55694133e-03f, -2.83104088e-02f, 4.13286537e-02f, 2.49137473e-03f, -1.89926743e-03f, -1.40775681e-01f, -5.53911366e-02f, 2.60179723e-03f, 1.76162203e-03f,
  -2.24254966e-01f, -4.27826121e-02f, -1.99254602e-01f, -1.15295023e-01f, 1.15681984e-01f, 2.85185166e-02f, 4.97139478e-03f, -5.29708564e-02f, -6.31889552e-02f, 1.70910686e-01f,
  1.32800311e-01f, -1.66724414e-01f, 3.84321064e-02f, -6.82043284e-02f, -1.24669760e-01f, -3.03519331e-02f, 1.03420364e-02f, -1.39058772e-02f, -2.34330632e-02f, -3.34969759e-02f,
  -3.37574296e-02f, -5.77974953e-02f, -1.67742655e-01f, 9.19645280e-02f, -1.09357387e-01f, -4.44757156e-02f, 1.11213580e-01f, -3.63266878e-02f, 7.71526396e-02f, 6.56888932e-02f,
  -1.84908994e-02f, -1.40708014e-01f, 1.47517109e-02f, -7.23349452e-02f, -3.87148410e-02f, 1.76747926e-02f, -3.64474431e-02f, -9.34711844e-03f, 2.63722818e-02f, -7.65250623e-02f,
  7.28877112e-02f, -2.97493339e-02f, 6.72829822e-02f, 7.61573836e-02f, 6.52757287e-02f, 4.55549099e-02f, -5.37794605e-02f, -4.76227775e-02f, -8.98795500e-02f, -8.55244976e-03f,
  -1.00993596e-01f, 8.64193514e-02f, 4.33149002e-02f, -3.58840660e-03f, 1.40142841e-02f, -1.73796192e-02f, 5.25339507e-02f, -7.87025392e-02f, 3.82445492e-02f, 2.80946065e-02f,
  6.14806358e-03f, 8.81955922e-02f, -9.33509469e-02f, 2.99298707e-02f, -6.18088655e-02f, 9.07093808e-02f, -3.71835567e-02f, 5.58581129e-02f, -6.89918250e-02f, 1.13385338e-02f,
  5.83399385e-02f, 3.48545909e-02f, -8.12968090e-02f, 3.27108465e-02f, -3.22171673e-02f, 1.95628833e-02f, -2.71262485e-03f, 3.01093003e-03f, 1.73194613e-02f, 3.36122769e-03f,
  -1.58657189e-02f, -5.60541078e-02f, -5.55217825e-02f, 4.83306572e-02f, 8.04280043e-02f, 3.22993845e-03f, 1.11080520e-02f, 6.15499616e-02f, 2.27552727e-02f, 1.04412856e-02f,
  8.43351036e-02f, 8.70526507e-02f, -3.14512923e-02f, -5.33302501e-02f, 1.57778934e-02f, 4.26651947e-02f, -7.66211748e-02f, 2.60618106e-02f, -4.89340201e-02f, 4.45525646e-02f,
  6.81459531e-02f, 7.53418207e-02f, 1.12873577e-01f, -3.91419902e-02f, 6.43161759e-02f, 8.17833617e-02f, 9.26390290e-02f, -4.28162850e-02f, 3.42634991e-02f, 9.59214047e-02f,
  -2.12358776e-02f, 7.06499591e-02f, 6.51196390e-02f, 7.47090206e-02f, 9.91174486e-03f, 5.49434088e-02f, -5.74547201e-02f, 7.89399967e-02f, -6.92805089e-03f, 3.72602865e-02f,
  -4.24161069e-02f, 1.31208166e-01f, 3.28739248e-02f, -2.85068657e-02f, -1.15466081e-01f, -2.19291508e-01f, -1.38550609e-01f, 2.15611774e-02f, 1.41875833e-01f, 1.66033551e-01f,
  3.04181390e-02f, 9.72337723e-02f, 8.83154795e-02f, 3.63894776e-02f, -2.17011318e-01f, 4.08682413e-02f, -1.67410165e-01f, 7.47262314e-03f, -5.37752733e-02f, -5.33004291e-03f,
  7.05495626e-02f, -1.38679609e-01f, 8.62424001e-02f, 7.22696334e-02f, 2.37896554e-02f, 1.33356795e-01f, -2.58289091e-03f, 5.21824583e-02f, -7.00396299e-03f, -7.10388320e-03f,
  4.51027341e-02f, 2.02509612e-01f, 1.41546652e-01f, 2.57704593e-02f, 6.61656559e-02f, 1.78531967e-02f, -4.31099236e-02f, 2.61224899e-02f, -7.82427117e-02f, -2.56238524e-02f,
  6.49579763e-02f, -3.19845718e-03f, 1.03921704e-02f, 6.38392046e-02f, 8.87935758e-02f, 9.97278392e-02f, -3.58682908e-02f, -7.01386929e-02f, 9.67853591e-02f, 7.94484168e-02f,
  -2.48840433e-02f, 1.00935787e-01f, 2.51682978e-02f, -3.98777835e-02f, -4.66828011e-02f, 1.40937548e-02f, -1.17006451e-02f, 9.56681464e-03f, 3.98272425e-02f, -1.90465990e-02f,
  4.55380119e-02f, -2.31474396e-02f, -7.89096504e-02f, -8.34477041e-03f, -5.77489287e-02f, 1.27786949e-01f, 1.25339627e-02f, -2.58167069e-02f, 5.28664067e-02f, 9.21046361e-02f,
  -4.19551507e-02f, 1.12552986e-01f, -5.43427430e-02f, 4.92450222e-02f, 3.71602513e-02f, -4.75669876e-02f, 3.40963937e-02f, 4.26148288e-02f, -3.17510031e-03f, -9.14596245e-02f,
  6.61811680e-02f, -2.72730403e-02f, -5.57826981e-02f, 6.00813329e-03f, 2.89215986e-02f, -1.05754025e-02f, 1.51978461e-02f, 7.60171488e-02f, 9.20990705e-02f, -1.26884535e-01f,
  6.00121506e-02f, 7.71698952e-02f, 1.14868067e-01f, 1.27966478e-01f, -1.78522542e-02f, 2.98107602e-02f, 5.99344866e-03f, 1.18581783e-02f, -7.18243197e-02f, -2.05290853e-03f,
  -6.42013401e-02f, 1.81484986e-02f, 2.53249891e-02f, -4.57558706e-02f, 5.41935163e-03f, 3.26357037e-03f, 5.70955388e-02f, -7.97005445e-02f, -9.35976133e-02f, -4.38295715e-02f,
  1.60434172e-02f, 2.99338046e-02f, 8.10187012e-02f, -6.43881783e-02f, 7.58606121e-02f, 6.02283813e-02f, -6.85531497e-02f, -5.22242151e-02f, 1.01599125e-02f, 5.76317944e-02f,
  1.76319420e-01f, -1.00263292e-02f, -1.96037278e-01f, -9.68792662e-03f, -1.14000723e-01f, 1.28964186e-01f, 2.12723538e-01f, 7.02445656e-02f, 3.37277092e-02f, 2.59382337e-01f,
  1.23901635e-01f, -8.81025270e-02f, 6.98502585e-02f, 5.08065112e-02f, -1.48694357e-02f, 5.31082004e-02f, 2.25469112e-01f, 1.03058830e-01f, 2.36770883e-02f, 3.25901248e-02f,
  3.20373662e-02f, 5.57700247e-02f, -2.12219670e-01f, 1.81631483e-02f, -4.70486544e-02f, -1.01829432e-01f, -7.33438581e-02f, -7.76128396e-02f, -2.06263848e-02f, 3.14907208e-02f,
  7.75297359e-02f, 1.06643118e-01f, -1.15602762e-01f, -2.48748735e-02f, -5.91096617e-02f, 6.33251369e-02f, -2.26766542e-02f, -1.08870886e-01f, -7.11581903e-03f, 5.21440096e-02f,
  4.53682989e-02f, -8.32187757e-02f, 2.17756815e-02f, 2.91894954e-02f, -1.00535564e-01f, -5.03474623e-02f, -1.16755575e-01f, -6.83924630e-02f, -2.05847272e-03f, -5.08009382e-02f,
  -1.06690325e-01f, -3.77718545e-02f, 5.49161434e-03f, -9.45426598e-02f, -7.62137026e-02f, 1.34615079e-02f, 8.66354704e-02f, 1.62502937e-02f, 1.29370287e-01f, 8.60177353e-02f,
  7.36986622e-02f, -2.87087522e-02f, 2.71787867e-02f, 9.06271767e-03f, -9.66695547e-02f, -5.30306436e-03f, -5.67531155e-04f, 1.64388504e-03f, 1.27598867e-02f, -4.06671241e-02f,
  -5.84375300e-02f, 7.83582628e-02f, -4.40665009e-03f, -2.06790678e-02f, 9.23903957e-02f, 4.83522890e-03f, -4.74842340e-02f, 1.46505395e-02f, -7.65578216e-03f, 3.36646549e-02f,
  1.19183231e-02f, -1.14563191e-02f, -6.39406368e-02f, -8.74728896e-03f, 4.29018922e-02f, -2.84970216e-02f, 1.43055618e-02f, 4.55812924e-02f, -5.26422784e-02f, 4.29545017e-03f,
  6.99971467e-02f, 2.29627222e-01f, 3.54204923e-02f, 1.17317624e-02f, -5.20127714e-02f, 4.47893441e-02f, 6.13641627e-02f, 1.68212168e-02f, 9.77812633e-02f, -1.18020922e-02f,
  3.86281200e-02f, 5.76204807e-02f, -6.69390857e-02f, -1.16178188e-02f, -2.56274603e-02f, 2.71821171e-02f, 1.30345812e-02f, 1.16294488e-01f, -1.37836263e-02f, -8.49267021e-02f,
  8.88487026e-02f, 7.55687505e-02f, -4.92547713e-02f, -5.13859838e-02f, 5.79330102e-02f, -3.93600203e-02f, -1.02979308e-02f, 8.34931508e-02f, 8.70309472e-02f, -8.21495280e-02f,
  1.52472585e-01f, 2.17585880e-02f, 1.87032163e-01f, 2.32903123e-01f, -2.26930827e-02f, -2.57055700e-01f, -9.19976681e-02f, 9.54225883e-02f, -5.30939028e-02f, -6.88467845e-02f,
  -3.02244779e-02f, 6.89685866e-02f, -3.07009704e-02f, 7.96776786e-02f, 2.11256593e-01f, -9.61043313e-02f, 3.52654271e-02f, -1.13911413e-01f, 6.87230229e-02f, 1.58455566e-01f,
  8.71397108e-02f, 1.13386638e-01f, 1.35066271e-01f, 4.75899614e-02f, 1.75179109e-01f, 3.71910371e-02f, 2.16336459e-01f, 1.64180193e-02f, 1.18953250e-02f, -4.88396846e-02f,
  -7.28944466e-02f, -4.11938084e-03f, 9.87321213e-02f, -1.41687654e-02f, -4.03676182e-02f, 4.31788974e-02f, -4.76614125e-02f, 1.86140370e-02f, -3.26000117e-02f, -2.42734924e-02f,
  -4.15216610e-02f, 2.13645399e-02f, -4.10304889e-02f, -1.36737311e-02f, -9.53475460e-02f, 3.30795571e-02f, -2.01455392e-02f, 5.10984510e-02f, 5.30397519e-02f, -9.73089971e-03f,
  2.77262945e-02f, -8.39852616e-02f, -1.25431912e-02f, 1.05152568e-02f, -2.52364594e-02f, 2.19869781e-02f, 4.90075536e-03f, 6.74552917e-02f, -7.90877864e-02f, -4.41789776e-02f,
  -8.99029076e-02f, -5.57171665e-02f, -7.33961836e-02f, 9.40923952e-03f, 3.98115329e-02f, 7.36915246e-02f, -9.10878628e-02f, 4.82113510e-02f, -2.78231166e-02f, -2.29640049e-03f,
  -2.66707018e-02f, 1.21247210e-01f, -3.61596383e-02f, 8.38980079e-03f, 2.81501114e-02f, -3.33850831e-02f, 5.60613200e-02f, 8.43267962e-02f, -2.12217425e-03f, 8.65424424e-02f,
  1.10178171e-02f, 7.85986613e-03f, -5.64759970e-02f, -7.98410922e-02f, -1.02679506e-01f, 6.32904246e-02f, 1.76704936e-02f, 5.70350364e-02f, 2.23681591e-02f, -3.00356653e-02f,
  -4.00442071e-02f, 1.78877771e-01f, -5.15948385e-02f, -2.28382684e-02f, -8.41292590e-02f, -8.06075186e-02f, 1.94267952e-03f, -4.31851260e-02f, 4.51903343e-02f, 7.42164403e-02f,
  5.71897663e-02f, 5.81778623e-02f, -6.49248064e-02f, 7.06684589e-02f, -6.69409754e-03f, 2.64556464e-02f, -1.83883086e-02f, -7.73344263e-02f, 2.17479728e-02f, -2.83683781e-02f,
  -4.24577622e-03f, 3.92973237e-02f, 6.62456527e-02f, -8.79176427e-03f, -7.51026869e-02f, -1.05245020e-02f, -8.59775618e-02f, 3.51777971e-02f, 4.81320806e-02f, 4.49422263e-02f,
  -2.43444338e-01f, -1.21995504e-03f, 1.80494979e-01f, -1.35921851e-01f, 1.14265487e-01f, 1.33216158e-01f, 8.19929615e-02f, 1.10406138e-01f, -2.73538437e-02f, 2.03712042e-02f,
  -3.56493518e-02f, -1.11361556e-01f, 3.34236845e-02f, -6.35301471e-02f, -5.47080487e-02f, 5.21510802e-02f, -3.53708714e-02f, -6.34796992e-02f, 6.09897897e-02f, -6.90520033e-02f,
  -1.30817398e-01f, -1.19466513e-01f, -8.02868232e-02f, 8.05204809e-02f, -1.05348207e-01f, 2.07853969e-03f, -1.83384970e-01f, 1.02825657e-01f, -1.07888125e-01f, 3.10274772e-02f,
  6.87736198e-02f, 1.46047992e-03f, 4.36780564e-02f, 3.19194049e-02f, -8.05574283e-02f, -2.28299666e-02f, 3.95330526e-02f, -2.83515863e-02f, -4.34173085e-02f, -4.79762219e-02f,
  -8.09656680e-02f, -6.52597472e-02f, 3.69671360e-02f, 1.05567381e-01f, 1.53766042e-02f, 5.33843134e-03f, -6.50604293e-02f, -2.06771530e-02f, -4.82103415e-02f, 2.10312251e-02f,
  3.92596908e-02f, -6.46244064e-02f, -1.10501148e-01f, -2.50494145e-02f, -1.01085328e-01f, 3.12189572e-04f, 2.54028402e-02f, -7.32561126e-02f, 3.65090147e-02f, 4.25708294e-02f,
  5.84973805e-02f, -5.56835579e-03f, -4.31698710e-02f, -4.17197607e-02f, -1.77630596e-02f, 1.18644340e-02f, -3.64511050e-02f, 5.42507581e-02f, 6.24578260e-02f, 1.58985909e-02f,
  -3.92665714e-02f, 1.02796610e-02f, -1.04176715e-01f, -9.77670476e-02f, -4.82737180e-03f, -6.33303523e-02f, 9.76706296e-03f, 5.95971458e-02f, 2.94966269e-02f, 5.53410798e-02f,
  9.86121446e-02f, -1.12005332e-02f, 9.38616991e-02f, 1.68883037e-02f, -2.34883931e-02f, -8.55354369e-02f, 5.01501746e-02f, -4.82981168e-02f, 5.61982244e-02f, -8.02705362e-02f,
  2.60514300e-02f, 8.00011754e-02f, 2.49850936e-02f, -4.37039696e-02f, 9.55692306e-02f, -1.74419023e-02f, 6.03148453e-02f, -1.36027038e-02f, 4.56034169e-02f, 3.92805375e-02f,
  -8.31541717e-02f, -1.43179274e-03f, -7.32883960e-02f, -4.33165617e-02f, -2.71401387e-02f, 2.80172341e-02f, 4.31202054e-02f, 5.89188933e-02f, -9.86829493e-03f, 7.40116686e-02f,
  -1.89696588e-02f, -2.76864953e-02f, -1.71821509e-02f, -7.28146136e-02f, -1.12614416e-01f, -1.07780777e-01f, 6.80039823e-02f, 8.53844658e-02f, 2.74977945e-02f, 9.79673266e-02f,
  5.68215251e-02f, 1.19004063e-01f, -6.84605390e-02f, 1.67532727e-01f, -8.43282714e-02f, -2.02596977e-01f, -1.42591119e-01f, 2.07014456e-02f, -4.47466895e-02f, 9.21611488e-03f,
  1.04103908e-01f, -5.58787473e-02f, -8.53162333e-02f, 1.55482531e-01f, 6.46417141e-02f, -9.44856405e-02f, 8.82567912e-02f, -7.24736648e-03f, -9.73790977e-03f, 1.74709842e-01f,
  6.83949217e-02f, 1.23517945e-01f, 1.90922618e-01f, 1.13914251e-01f, 1.81015842e-02f, 1.23521090e-01f, 2.86008984e-01f, -6.47925436e-02f, 2.08307371e-01f, -6.60789311e-02f,
  -4.85768355e-02f, 7.78098181e-02f, 5.19895181e-03f, -6.40266910e-02f, 5.69061674e-02f, -6.60016537e-02f, -3.54152769e-02f, 3.63661498e-02f, -3.47470641e-02f, -6.34036064e-02f,
  -7.18237981e-02f, -4.79282998e-02f, -5.40007763e-02f, -7.96313509e-02f, -1.04800023e-01f, 1.85281485e-02f, -3.61977108e-02f, -5.20172566e-02f, -6.51795119e-02f, -5.35762906e-02f,
  -8.49932618e-03f, -6.40683845e-02f, 6.39104769e-02f, 8.28125551e-02f, 6.63540140e-02f, 1.34038050e-02f, 2.33999304e-02f, 6.67108521e-02f, 2.75926869e-02f, 4.98379245e-02f,
  1.11847684e-01f, -8.78826082e-02f, 1.07225990e-02f, -7.84179270e-02f, -9.01086777e-02f, 7.38076940e-02f, 3.71069238e-02f, 5.62597550e-02f, 5.12122363e-02f, 4.32179822e-03f,
  -5.69379404e-02f, -4.54292633e-02f, -5.92827201e-02f, -2.45627062e-03f, 2.12779529e-02f, 3.51551175e-02f, -3.74358855e-02f, -5.15685640e-02f, 5.11817448e-02f, 4.28422391e-02f,
  -2.33909325e-03f, -4.90888916e-02f, -2.10116114e-02f, -6.27374500e-02f, -4.55197133e-02f, -5.78037202e-02f, 3.04312166e-02f, -8.09302274e-03f, -5.52816503e-02f, 7.66350254e-02f,
  -1.10981455e-02f, 2.10372850e-01f, 1.91263985e-02f, -6.27723634e-02f, -1.33897560e-02f, -2.93287095e-02f, 4.33376469e-02f, 8.34600404e-02f, -4.16233949e-03f, 9.96835809e-03f,
  6.21931888e-02f, 6.32304847e-02f, -3.13734123e-03f, 7.32849445e-03f, 5.20462319e-02f, 9.01051238e-02f, 5.12667522e-02f, 7.23232999e-02f, 1.19842030e-01f, 7.02649131e-02f,
  2.52667759e-02f, -1.03078164e-01f, -1.25382571e-02f, -7.60300681e-02f, 4.38288599e-02f, -2.95504592e-02f, -2.27452237e-02f, -1.09623335e-02f, 6.48043230e-02f, 5.74674383e-02f,
  1.87118128e-01f, -3.14731598e-02f, -1.75332814e-01f, 1.94303185e-01f, 1.90412462e-01f, 1.26505360e-01f, -8.61626416e-02f, 7.64518371e-03f, -1.25608757e-01f, -1.35105684e-01f,
  9.95930731e-02f, 2.86474675e-02f, -1.86831221e-01f, 2.37385094e-01f, 2.40785018e-01f, -2.28299573e-01f, 1.74463287e-01f, 2.65589170e-02f, -1.06363900e-01f, -2.23112479e-03f,
  -2.05273908e-02f, 2.17182085e-01f, 3.01393811e-02f, 8.06046054e-02f, 1.43442646e-01f, 1.68583095e-02f, 1.83532715e-01f, -1.46758080e-01f, 2.46358171e-01f, 1.53736651e-01f,
  -5.42464443e-02f, 4.02895641e-03f, 7.33929798e-02f, 8.56377091e-03f, -1.73834357e-02f, 3.41277570e-02f, 7.18917921e-02f, 7.43114017e-03f, -1.64640564e-02f, -7.35654607e-02f,
  -3.57801057e-02f, -1.74802821e-02f, 8.23318735e-02f, 2.11910456e-02f, 6.91404752e-03f, -9.00223153e-04f, -6.17715297e-03f, -6.42149746e-02f, 8.22806135e-02f, 6.19909540e-02f,
  -3.30417268e-02f, -3.45305502e-02f, 1.57717392e-02f, 2.84695867e-02f, 3.38970944e-02f, 6.04903884e-02f, 3.63129266e-02f, -8.65461603e-02f, -1.17487470e-02f, -8.03022981e-02f,
  5.05193286e-02f, -3.96944024e-02f, -4.13233303e-02f, 3.96038964e-02f, 2.59364583e-02f, -2.55367719e-02f, 4.25612479e-02f, -1.23487469e-02f, -8.91378000e-02f, 3.93818766e-02f,
  6.58405200e-02f, 6.53200373e-02f, 7.84226060e-02f, 1.95859913e-02f, -1.79480147e-02f, 2.77508944e-02f, -3.31798792e-02f, 9.52933505e-02f, -7.08489716e-02f, 6.71067610e-02f,
  -2.25830521e-03f, 3.51601951e-02f, -1.32683152e-02f, -2.47306866e-03f, 6.97039366e-02f, 1.51890544e-02f, -2.04967670e-02f, -6.66840598e-02f, 5.17475680e-02f, -8.03277828e-04f,
  -3.64161171e-02f, -7.43693439e-03f, 5.12832170e-03f, -8.49981382e-02f, -6.94974214e-02f, -1.34602198e-02f, -8.49700719e-02f, 4.92352024e-02f, 2.12112311e-02f, -9.04344395e-03f,
  -1.40224928e-02f, 2.96700504e-02f, 5.78633063e-02f, -8.01616311e-02f, -1.34167811e-02f, -4.79793400e-02f, -2.02661604e-02f, -8.81144851e-02f, 7.62952194e-02f, -2.69505428e-04f,
  9.36345458e-02f, 1.38753159e-02f, 5.51324897e-03f, 8.97319638e-04f, 4.83334586e-02f, 4.02675532e-02f, -1.58758555e-02f, -1.35028446e-02f, 5.43073304e-02f, 2.09204964e-02f,
  6.71466291e-02f, -1.97240114e-01f, -2.06648961e-01f, 3.24002020e-02f, 5.48154823e-02f, 7.59094357e-02f, -8.72750729e-02f, -8.69487748e-02f, -3.14339221e-01f, -1.14072420e-01f,
  5.98847978e-02f, -6.57636896e-02f, -2.74727136e-01f, 2.03347474e-01f, 2.21375659e-01f, -1.80965975e-01f, 1.19903125e-01f, 3.32438052e-02f, -1.44717827e-01f, -8.96341633e-03f,
  2.02852022e-02f, 2.43151531e-01f, 1.79246869e-02f, 3.28581512e-01f, 1.78916663e-01f, 1.18036821e-01f, 3.24529320e-01f, -1.00715652e-01f, 3.54309589e-01f, 8.41906741e-02f,
  1.16879217e-01f, -1.12795867e-01f, -9.42641646e-02f, -6.87463656e-02f, 2.23332457e-02f, 1.21729955e-01f, 1.00892037e-01f, 1.45934522e-01f, 4.60947827e-02f, -2.77024861e-02f,
  4.05554287e-02f, 1.66305099e-02f, 8.99192691e-02f, 1.59369223e-02f, 7.90146142e-02f, -5.26367575e-02f, -1.08306974e-01f, -7.12252557e-02f, -8.16404819e-02f, -7.09940046e-02f,
  -1.25165567e-01f, 8.43534544e-02f, 4.26718444e-02f, -2.31549572e-02f, 8.34335852e-03f, 3.49952839e-02f, 7.03530982e-02f, -3.49145830e-02f, -2.00904384e-02f, 8.45172852e-02f,
  1.03086896e-01f, -1.90795939e-02f, -9.28921252e-02f, 5.01929708e-02f, -1.33857094e-02f, 1.33146374e-02f, 7.19179539e-03f, 1.08027896e-02f, 6.26145229e-02f, 2.44741831e-02f,
  -5.49699068e-02f, 5.11595272e-02f, 7.84619004e-02f, -2.70540006e-02f, -2.14146022e-02f, -4.70774919e-02f, 1.39473164e-02f, 9.53574292e-03f, 2.03124899e-03f, 2.62858309e-02f,
  5.65057993e-02f, -4.60324995e-02f, 2.83227731e-02f, -9.39893071e-03f, -4.37485799e-02f, -6.54446632e-02f, 2.76170205e-02f, -1.88948009e-02f, -7.71060288e-02f, 5.60699627e-02f,
  -5.57320472e-03f, -9.12249982e-02f, -5.05811349e-02f, 3.87190990e-02f, 8.74022618e-02f, 5.79389222e-02f, 5.21723144e-02f, 9.65322368e-03f, 1.90389324e-02f, -1.06560420e-02f,
  5.09096421e-02f, 3.39956172e-02f, -8.62685889e-02f, 6.05453402e-02f, 6.06118143e-02f, 4.06182110e-02f, -1.96729153e-02f, 1.02302745e-01f, 6.98522255e-02f, 8.93876031e-02f,
  -1.88110266e-02f, 6.84698895e-02f, -3.06184590e-02f, -7.63094891e-03f, 1.05688475e-01f, 3.95433716e-02f, 6.35172203e-02f, 5.56804612e-02f, 2.98346505e-02f, -1.72919389e-02f,
  5.17501608e-02f, -1.76409632e-01f, -8.23036488e-03f, 2.69196704e-02f, -9.13652182e-02f, 5.22428099e-03f, 2.20888704e-02f, -1.18580878e-01f, -1.78124327e-02f, -1.09819554e-01f,
  -2.30727531e-02f, 1.07122123e-01f, -1.35187013e-02f, -5.46686500e-02f, 9.83484387e-02f, -4.72383387e-02f, 5.20364605e-02f, -1.25137428e-02f, 4.29156981e-02f, 1.64735708e-02f,
  6.30643517e-02f, -1.24351569e-02f, 1.36880204e-01f, -2.87868213e-02f, -2.44387742e-02f, 2.65759006e-02f, 1.84047103e-01f, 5.07868752e-02f, -3.12466230e-02f, -3.86065766e-02f,
  4.10158001e-02f, -4.44250181e-02f, -7.95959234e-02f, -5.61946705e-02f, 4.16827342e-03f, 9.87613946e-02f, -1.52141629e-02f, 7.90438727e-02f, 4.43121120e-02f, -7.74713829e-02f,
  -1.55033050e-02f, 1.51114715e-02f, 3.51258600e-03f, -3.56794186e-02f, 4.58911210e-02f, 3.93857025e-02f, 8.68618861e-02f, 1.41466474e-02f, 5.30213825e-02f, -2.95420922e-02f,
  -3.84697877e-02f, 7.46165588e-02f, 5.98880053e-02f, 1.12137301e-02f, -1.70922857e-02f, -2.73060258e-02f, 5.16956300e-02f, 6.16814755e-02f, 8.50368664e-03f, 4.83596250e-02f,
  3.28583270e-02f, -7.73321912e-02f, 5.27427271e-02f, -7.28770271e-02f, 8.14447030e-02f, 3.13377939e-02f, 7.50550032e-02f, -1.69818022e-03f, 8.78976062e-02f, 3.23709622e-02f,
  7.28612319e-02f, 3.68408151e-02f, 3.87304910e-02f, 7.73158744e-02f, 1.22376848e-02f, -4.15428057e-02f, 9.18739364e-02f, -4.31176163e-02f, 9.04582739e-02f, -7.92201087e-02f,
  4.25567925e-02f, -6.47211820e-02f, 2.67893635e-02f, 6.47816136e-02f, -1.88776907e-02f, 9.44360793e-02f, -9.32116210e-02f, -6.89368993e-02f, -5.98293915e-02f, -6.40424117e-02f,
  9.20443907e-02f, 8.87813717e-02f, -7.26646557e-03f, -6.80740625e-02f, -6.41661137e-02f, 1.85320515e-03f, -1.87929291e-02f, -7.97695220e-02f, -3.45826522e-02f, -9.30629075e-02f,
  3.09578944e-02f, 3.93428616e-02f, -8.42323601e-02f, -3.96692790e-02f, -6.62704185e-02f, -8.94763470e-02f, 8.40770304e-02f, 1.13055212e-02f, 6.04451373e-02f, 9.51386541e-02f,
  2.05455814e-02f, 7.42198974e-02f, -8.15408155e-02f, 7.66807329e-03f, -4.01441790e-02f, -6.39664307e-02f, 8.35099667e-02f, 7.44110271e-02f, -3.36861610e-02f, 4.14269194e-02f,
  1.54279739e-01f, 1.05139822e-01f, 8.88862461e-02f, 1.62113667e-01f, -1.49839446e-01f, -8.15785602e-02f, -1.48621976e-01f, 6.36827946e-02f, -2.13751495e-02f, 1.87999327e-02f,
  7.89403543e-02f, 7.27360174e-02f, -3.50670926e-02f, -4.52825129e-02f, -6.47156164e-02f, -6.13426603e-02f, 8.27902257e-02f, 8.10510293e-03f, -1.52217653e-02f, 1.25657275e-01f,
  1.11784838e-01f, -1.23349033e-01f, 1.38900876e-01f, 7.66732097e-02f, 5.70222661e-02f, 9.74569544e-02f, 9.65400711e-02f, -9.06466022e-02f, 4.19401526e-02f, -4.64620255e-02f,
  2.39184219e-02f, 8.89147818e-02f, -5.23083545e-02f, 6.41275570e-02f, -6.92152008e-02f, 5.50176986e-02f, 5.42907380e-02f, -3.86942476e-02f, 7.21461996e-02f, 6.96151331e-02f,
  -6.06603511e-02f, 3.16159427e-02f, 2.10045129e-02f, 4.91931923e-02f, 5.46974204e-02f, 7.80039579e-02f, 5.80159016e-02f, -5.03921509e-03f, -5.96882254e-02f, 8.00749883e-02f,
  8.10818300e-02f, -4.58864309e-02f, -2.92053036e-02f, -5.99612109e-03f, 9.41548403e-03f, -7.00197592e-02f, 5.50049692e-02f, -3.19384746e-02f, -1.43059511e-02f, -5.16912080e-02f,
  5.17706499e-02f, -4.47876453e-02f, -9.90355462e-02f, -7.58029614e-03f, 5.34231961e-02f, -8.19237158e-02f, -8.67371559e-02f, -3.34749110e-02f, -7.14607015e-02f, -1.76847596e-02f,
  5.67753683e-04f, -5.45044318e-02f, -4.58950624e-02f, -1.39703345e-03f, -2.91625988e-02f, 9.35166515e-03f, -4.56467532e-02f, 6.21676166e-03f, -2.01005246e-02f, 3.89576913e-03f,
  3.27855982e-02f, -2.51811910e-02f, 4.32134569e-02f, 5.98639995e-02f, 5.81902750e-02f, -4.00796682e-02f, 9.15096793e-03f, 5.17941266e-02f, 5.27032465e-02f, 5.35835810e-02f,
  8.77548233e-02f, 5.65351509e-02f, 4.55162227e-02f, -1.01863772e-01f, 3.72225745e-03f, 5.69537729e-02f, -3.69250625e-02f, -4.84061353e-02f, 7.74974450e-02f, 6.41883388e-02f,
  -3.61981280e-02f, 5.43607026e-03f, -8.62626880e-02f, -7.29059279e-02f, -4.67976108e-02f, -2.32310910e-02f, -7.17707723e-02f, -9.19694006e-02f, 1.28097693e-02f, -3.49874981e-03f,
  4.26225923e-02f, 6.19642362e-02f, -5.40583320e-02f, -9.98398475e-03f, -1.21743865e-02f, -9.56979543e-02f, -6.59371866e-03f, 7.94252306e-02f, 5.24039939e-02f, -5.86042441e-02f,
  3.73026952e-02f, -4.25049476e-03f, -1.82610318e-01f, -2.00955376e-01f, 8.89349207e-02f, -6.36208132e-02f, -1.64362267e-01f, 3.34477946e-02f, 4.76766266e-02f, 4.83746603e-02f,
  9.85764340e-03f, -2.57916395e-02f, 5.33456802e-02f, -2.47582421e-01f, -1.80132896e-01f, -7.01943263e-02f, -1.13298744e-01f, -8.99745002e-02f, 2.46044490e-02f, -4.51458469e-02f,
  -5.57265580e-02f, -3.63487080e-02f, -1.44787654e-01f, 6.02542944e-02f, -6.73590079e-02f, 6.34483919e-02f, 2.72095036e-02f, 5.18143699e-02f, -3.51867899e-02f, -9.29282084e-02f,
  -4.02740911e-02f, 8.21442008e-02f, -4.33357134e-02f, 1.25713855e-01f, 1.12052582e-01f, 3.02992109e-02f, 2.77292747e-02f, 2.14363020e-02f, 5.83394319e-02f, 1.07315138e-01f,
  4.26535420e-02f, 4.89843041e-02f, -6.22973703e-02f, 6.18553609e-02f, 3.04575395e-02f, 4.90454659e-02f, -7.82730654e-02f, 7.12011978e-02f, 5.79786673e-02f, 5.35215065e-02f,
  -1.12453856e-01f, -2.21247934e-02f, -9.07279700e-02f, 4.52516116e-02f, 6.22808747e-02f, -3.30448821e-02f, -1.08414799e-01f, -8.62565637e-02f, -6.60633668e-02f, 3.43729518e-02f,
  -2.18135715e-02f, 5.37059568e-02f, -4.63698469e-02f, -8.20226688e-03f, 6.66546971e-02f, 9.78812948e-03f, -4.45258878e-02f, -5.67966290e-02f, 2.89669782e-02f, 2.18750034e-02f,
  1.76885519e-02f, 6.10298887e-02f, 9.66380760e-02f, -2.65191477e-02f, -5.46758212e-02f, -3.08864303e-02f, -3.56623083e-02f, 3.18544284e-02f, -1.46092288e-02f, -1.91151723e-02f,
  -6.25014529e-02f, -9.48416963e-02f, -4.95873503e-02f, -5.33301011e-02f, -9.29565057e-02f, 1.28288742e-03f, 9.81920436e-02f, -1.81818812e-03f, -6.90513328e-02f, 2.71212105e-02f,
  1.05390809e-01f, 3.87945911e-03f, -3.62380445e-02f, -2.43652109e-02f, 4.47737984e-02f, -3.23892981e-02f, 8.41722265e-03f, 2.68180221e-02f, 5.76379746e-02f, 9.83588770e-02f,
  2.65954696e-02f, -3.55143696e-02f, -5.12985103e-02f, -6.76319376e-02f, -2.03584153e-02f, -6.03385083e-02f, -1.87379252e-02f, 4.94488329e-02f, 1.78681016e-02f, -7.34653026e-02f,
  -2.67166123e-02f, -3.00107375e-02f, -5.41746505e-02f, 7.29215071e-02f, 5.90796620e-02f, -6.40874952e-02f, 5.33439070e-02f, 4.13683169e-02f, -5.36290035e-02f, -2.51741745e-02f,
  -2.20912129e-01f, 6.92083091e-02f, 2.01239493e-02f, -2.56514195e-02f, -3.34250666e-02f, -7.83664174e-03f, -1.55584797e-01f, 3.12827304e-02f, -1.45640209e-01f, 1.07400134e-01f,
  8.14891309e-02f, -5.48493639e-02f, 1.00589223e-01f, 5.66431172e-02f, -8.93259794e-02f, 1.09227516e-01f, 1.25280142e-01f, 3.07252873e-02f, -7.92926699e-02f, 5.50333299e-02f,
  4.49313447e-02f, 1.50684297e-01f, 1.39373556e-01f, 3.42722237e-02f, -8.56364667e-02f, 1.15080304e-01f, 1.81110412e-01f, 5.95851764e-02f, 1.12477757e-01f, 5.99757209e-02f,
  5.37487119e-02f, 4.42369282e-02f, 1.77407078e-02f, -1.07977390e-01f, -4.23551463e-02f, -4.90447767e-02f, 4.73648161e-02f, -2.22832356e-02f, 4.98993434e-02f, 1.98362935e-02f,
  5.95125929e-02f, -6.65047765e-02f, 9.51274335e-02f, 5.24975061e-02f, -3.26569341e-02f, 4.97969612e-02f, -3.39778997e-02f, 6.05494203e-03f, 2.59477720e-02f, 5.25025427e-02f,
  1.86554994e-02f, -2.94159949e-02f, -1.38156284e-02f, 5.20459376e-03f, 4.35324237e-02f, -6.86578453e-02f, -5.93163185e-02f, -8.60928595e-02f, -3.95345241e-02f, -1.62293650e-02f,
  -9.95849371e-02f, -1.16152372e-02f, -9.15496126e-02f, 1.75830815e-02f, -3.21147889e-02f, -5.23930304e-02f, 2.15036031e-02f, 3.15691084e-02f, 2.72184350e-02f, 1.80464704e-02f,
  5.60677703e-03f, -1.76236182e-02f, -4.41095829e-02f, 6.81873783e-02f, 7.48219192e-02f, -8.62090439e-02f, 8.35404471e-02f, 4.69577732e-03f, 7.24107400e-02f, -2.36959569e-02f,
  -6.48748502e-02f, -6.14717975e-03f, 2.17051320e-02f, 5.56845553e-02f, 4.56441492e-02f, -4.75640558e-02f, -6.03638850e-02f, -9.01903212e-02f, -2.80249733e-02f, -7.09751993e-02f,
  9.37755480e-02f, 1.20328963e-02f, 7.22571239e-02f, -8.68272968e-03f, -1.29177724e-03f, -6.26469636e-03f, 5.77182360e-02f, 7.43022487e-02f, -3.82615738e-02f, 5.64233884e-02f,
  2.90623438e-02f, -3.08311973e-02f, 3.26766893e-02f, 6.00937121e-02f, 7.87143037e-02f, -7.33077079e-02f, 9.09288451e-02f, 1.53257335e-02f, -2.61339899e-02f, 8.97268355e-02f,
  7.84245878e-03f, 7.72033120e-03f, 6.24391846e-02f, -3.36834267e-02f, 8.20771754e-02f, 1.34033412e-02f, 2.18957532e-02f, -7.17129931e-02f, -5.62195927e-02f, -6.05440773e-02f,
  9.36398655e-02f, -7.14754611e-02f, -1.25926971e-01f, 5.90887479e-03f, -3.85200186e-03f, -2.09523812e-02f, -9.88484025e-02f, 4.99865003e-02f, -8.54062065e-02f, -5.85451014e-02f,
  9.07170996e-02f, -3.20446678e-02f, -1.43023968e-01f, 1.04563870e-02f, -1.82837043e-02f, -9.72868949e-02f, 8.93909708e-02f, 1.14317402e-01f, -1.13205507e-01f, -3.90123427e-02f,
  -1.72093175e-02f, 1.35767600e-02f, -1.58013415e-03f, 1.00212395e-01f, 6.74086660e-02f, 1.97808370e-02f, -4.62247878e-02f, 7.69391432e-02f, 3.59028094e-02f, 5.53358644e-02f,
  1.24091119e-01f, -9.60006416e-02f, -5.02282269e-02f, 5.80934770e-02f, 4.95763160e-02f, -1.61503647e-02f, 8.84410143e-02f, 2.88622566e-02f, -4.07217108e-02f, 4.60878052e-02f,
  6.24380708e-02f, -3.81030068e-02f, -2.96914801e-02f, -4.89867292e-02f, 1.95091777e-02f, 2.49055419e-02f, -9.29619372e-02f, -7.76777864e-02f, 6.67860061e-02f, -9.34623629e-02f,
  1.70649979e-02f, 2.62350794e-02f, -7.98595622e-02f, 7.86267370e-02f, -7.79436827e-02f, 7.28298873e-02f, 3.68076041e-02f, -2.95672975e-02f, -7.46384412e-02f, 6.04116432e-02f,
  -7.37180654e-03f, 6.58051819e-02f, -4.74713631e-02f, 9.88676772e-02f, -4.14918177e-02f, 6.93948269e-02f, 6.04408309e-02f, 4.76330481e-02f, -4.35738498e-03f, -5.98652847e-02f,
  1.85134802e-02f, -3.16793844e-02f, -7.81885833e-02f, 7.33692721e-02f, 3.07058319e-02f, -4.13823426e-02f, -2.77340077e-02f, 8.06094240e-03f, 4.73992042e-02f, -1.17398174e-02f,
  -3.10432799e-02f, -4.72512729e-02f, 2.26605516e-02f, 1.01115461e-02f, 8.55535418e-02f, -5.23139797e-02f, -1.93155706e-02f, -1.59651492e-04f, 7.09238723e-02f, 3.76771614e-02f,
  2.59368122e-02f, -1.28282934e-01f, 1.16919000e-02f, 3.13311704e-02f, -7.51805529e-02f, 1.30560463e-02f, -1.06530897e-02f, -4.10794429e-02f, -3.83904539e-02f, 4.98899706e-02f,
  4.56830487e-02f, 2.15715505e-02f, 2.57635433e-02f, 8.40005204e-02f, -6.55125007e-02f, -9.26522315e-02f, -3.87740768e-02f, -4.41238172e-02f, -3.89250368e-02f, -2.64077149e-02f,
  3.81803885e-02f, -9.25100073e-02f, -3.88787268e-03f, -5.25374487e-02f, -5.27842864e-02f, -2.22569145e-02f, -4.56920527e-02f, -4.34352197e-02f, 2.35994831e-02f, -4.59182151e-02f,
  2.79019117e-01f, -4.24523473e-01f, 1.07198823e-02f, 2.92114824e-01f, 1.87601835e-01f, 4.05568024e-03f, 4.96964157e-02f, 6.89384788e-02f, 1.40776202e-01f, -2.87018210e-01f,
  -1.28081907e-02f, -1.88561417e-02f, -2.29690701e-01f, 1.27562642e-01f, 1.90291390e-01f, -9.88264307e-02f, 1.72678158e-02f, -1.29224760e-02f, -5.04933670e-02f, 7.59545267e-02f,
  8.58821720e-02f, 1.13510378e-01f, -8.70796368e-02f, 7.51072168e-03f, 8.12654719e-02f, 6.43052068e-03f, -5.21841682e-02f, 1.44743314e-02f, 8.86802077e-02f, 6.05400689e-02f,
  2.84347516e-02f, -8.91508684e-02f, 8.41185078e-03f, 7.71782324e-02f, -9.58071128e-02f, -4.73235408e-03f, -4.63530347e-02f, 9.68798250e-02f, 7.13855550e-02f, 3.67804692e-04f,
  -5.66468202e-02f, 8.97734091e-02f, 5.72346374e-02f, -1.33041050e-02f, 2.84209084e-02f, 5.84331639e-02f, 6.76316619e-02f, 5.69957830e-02f, 1.68658942e-02f, -7.93509036e-02f,
  -7.05447197e-02f, -3.33241634e-02f, 4.39067185e-02f, -5.10410070e-02f, -5.89221306e-02f, -3.45640145e-02f, -6.56103864e-02f, 1.54426806e-02f, 4.31759171e-02f, 7.10584000e-02f,
  -4.93204072e-02f, -2.59926487e-02f, -4.33313362e-02f, 3.30912098e-02f, 7.93632418e-02f, 7.79915228e-02f, 2.62190271e-02f, -7.96749257e-03f, 3.58249918e-02f, -2.00003590e-02f,
  1.43828588e-02f, -1.65527370e-02f, 2.07552221e-03f, -4.08671461e-02f, 8.50656778e-02f, 5.38681820e-02f, 5.73233422e-03f, 2.55740434e-02f, -5.32301478e-02f, 3.77777144e-02f,
  -5.73261529e-02f, 1.37508297e-02f, 1.31079387e-02f, 7.76695907e-02f, 9.13539082e-02f, 3.75429802e-02f, 3.47728916e-02f, 2.07107197e-02f, -2.44485959e-02f, -5.97902946e-02f,
  -1.15960501e-02f, -1.65694326e-01f, -1.00105353e-01f, -1.09846164e-02f, -3.39740217e-02f, -3.67817432e-02f, -5.46520688e-02f, -5.29627986e-02f, 1.67460125e-02f, -7.10915923e-02f,
  -7.73408040e-02f, -2.08816584e-02f, -7.39343930e-03f, 1.15126915e-01f, -2.04574130e-02f, -9.12284479e-02f, -6.99486397e-03f, 2.00387239e-02f, -5.47171123e-02f, -5.24818413e-02f,
  -4.46349122e-02f, 1.66596584e-02f, -3.38753080e-03f, 9.94434282e-02f, -2.27171127e-02f, 3.07814293e-02f, 2.75448058e-02f, -1.34583041e-01f, -5.84492162e-02f, -8.67354944e-02f,
  7.24785477e-02f, 7.65870437e-02f, -3.22659835e-02f, -8.81320536e-02f, -9.11250710e-02f, 2.14588657e-01f, 5.87836541e-02f, 4.61704396e-02f, -1.59432247e-01f, 1.98797271e-01f,
  -3.84620540e-02f, 2.94724032e-02f, 1.17586248e-01f, 1.21861242e-01f, -3.35594378e-02f, 1.18198186e-01f, 1.33407377e-02f, 1.76897779e-01f, -8.03163573e-02f, 7.05287158e-02f,
  -1.43009484e-01f, -7.98327550e-02f, -8.99209008e-02f, -9.33174193e-02f, 1.15699954e-02f, -1.33468926e-01f, -1.12303473e-01f, -5.62956668e-02f, 2.23039445e-02f, -8.02748464e-03f,
  8.76624137e-02f, -4.24231365e-02f, -3.28700501e-03f, -2.27105003e-02f, 7.46079907e-02f, 9.61016119e-02f, 7.34717697e-02f, 7.46416226e-02f, -3.67756411e-02f, -1.37053095e-02f,
  6.14810139e-02f, 4.39239219e-02f, -6.83177710e-02f, 2.33136248e-02f, -9.11330581e-02f, 4.62638140e-02f, 2.11582314e-02f, -7.72151574e-02f, 1.09904781e-02f, -9.21885297e-02f,
  7.72964209e-02f, -7.58640934e-03f, -3.23700532e-02f, 1.27379941e-02f, -4.46047597e-02f, -5.70064671e-02f, -6.96767122e-03f, -5.77821508e-02f, -2.01606527e-02f, 3.60285081e-02f,
  9.29503608e-03f, 8.77287388e-02f, 1.01367729e-02f, -1.02913780e-02f, -8.60884190e-02f, 5.89826442e-02f, -3.16761322e-02f, -2.84935236e-02f, -8.27379599e-02f, 4.56952378e-02f,
  2.79919133e-02f, -4.12313081e-02f, 5.10400198e-02f, 3.65401134e-02f, 9.49683115e-02f, 1.70911998e-02f, 5.54584488e-02f, 5.34853190e-02f, 6.73252670e-03f, -1.15080485e-02f,
  4.67853509e-02f, 3.95323709e-02f, 8.22239816e-02f, -8.44676942e-02f, 5.40628470e-02f, -9.35236290e-02f, -9.14099887e-02f, 4.96969558e-02f, -5.38148656e-02f, -5.78362644e-02f,
  -1.65292565e-02f, -4.64330614e-02f, 4.26870137e-02f, -5.52541055e-02f, 9.52579007e-02f, 7.94261545e-02f, 4.26793881e-02f, -2.89567523e-02f, -8.64270106e-02f, -6.87261522e-02f,
  -6.75476575e-03f, -1.74838435e-02f, 5.71953095e-02f, 4.32540625e-02f, 2.67410986e-02f, 3.85635868e-02f, -6.81985542e-02f, 7.28308037e-02f, 2.70838998e-02f, 4.53680893e-03f,
  5.82514890e-03f, 6.26961887e-02f, -7.19242170e-02f, -8.30701813e-02f, -6.85822293e-02f, 3.14012915e-02f, -7.49213248e-02f, 2.99001578e-02f, -5.49422726e-02f, -4.91696894e-02f,
  -1.55537665e-01f, 1.98229134e-01f, 7.01693296e-02f, -1.38006881e-01f, -2.81091053e-02f, -3.36188287e-01f, -2.10803360e-01f, 5.47364056e-02f, 7.24380463e-02f, 1.20751239e-01f,
  -1.61899664e-02f, 1.68700397e-01f, 5.97648919e-02f, -1.17445573e-01f, -2.98640102e-01f, -8.68599191e-02f, -3.10531527e-01f, -2.03397274e-01f, 3.28917876e-02f, 2.16694698e-02f,
  -1.53833002e-01f, -9.99995247e-02f, -7.94522911e-02f, 1.10080399e-01f, -4.52486202e-02f, 1.28883243e-01f, -5.64558478e-03f, 2.04534933e-01f, -1.12972669e-01f, 2.79671233e-02f,
  -5.62610142e-02f, 2.23495290e-01f, 8.64370093e-02f, 4.75860387e-03f, -3.08605339e-02f, -1.05427213e-01f, 4.40481082e-02f, 4.32017222e-02f, 4.69975658e-02f, -2.89486106e-02f,
  -4.79384810e-02f, 1.02339707e-01f, 4.28923741e-02f, 3.62124927e-02f, -4.28874278e-03f, 2.68797297e-02f, 2.31615324e-02f, 4.18950841e-02f, -4.15369356e-03f, -7.25332126e-02f,
  -2.75593717e-02f, -7.30219632e-02f, -9.95872542e-02f, -9.33379233e-02f, 2.46393606e-02f, -2.66170525e-03f, 1.42445602e-02f, 7.50827696e-03f, -4.29623090e-02f, -1.43241780e-02f,
  -1.76959205e-02f, -6.51839972e-02f, 1.15462225e-02f, 2.52727866e-02f, 4.67252843e-02f, 2.11338587e-02f, 7.93770030e-02f, -6.75960481e-02f, 3.99454162e-02f, -3.38760875e-02f,
  3.71890776e-02f, 7.00666606e-02f, 1.99335832e-02f, -1.68169923e-02f, 7.66787212e-03f, 7.46788504e-03f, -4.51811217e-02f, 3.42210829e-02f, -6.19808063e-02f, 3.51902749e-03f,
  7.48718306e-02f, -1.18176974e-02f, 5.58745153e-02f, -1.03348769e-01f, 5.41677419e-03f, -3.92671078e-02f, 1.72367338e-02f, -4.34092097e-02f, -1.08649712e-02f, -1.17341883e-01f,
  -1.96437258e-02f, 2.56199725e-02f, -8.64742044e-03f, 1.45060763e-01f, 1.28941517e-02f, -9.39353183e-02f, -8.59346017e-02f, -6.69438690e-02f, 2.34243218e-02f, -5.87254688e-02f,
  1.98126063e-02f, -7.42024854e-02f, -5.41984998e-02f, -1.67951174e-02f, -5.02222180e-02f, -7.83236548e-02f, 9.92550608e-03f, 5.03115319e-02f, -1.09519795e-01f, 5.06088510e-02f,
  2.70921290e-02f, 4.39734608e-02f, 5.25319390e-03f, -6.89979503e-03f, 1.70403160e-02f, -2.85598785e-02f, 6.94900984e-03f, 5.94328195e-02f, 1.06923347e-02f, 6.02660738e-02f,
  2.72331387e-01f, -1.70949981e-01f, -4.92208153e-02f, 5.42344004e-02f, 1.54880911e-01f, 7.34171420e-02f, 1.99085549e-02f, 5.16706742e-02f, 2.79082786e-02f, -1.32875115e-01f,
  9.29292589e-02f, -7.08225667e-02f, -1.10386927e-02f, 1.79957688e-01f, 1.09134123e-01f, -6.41983300e-02f, 9.15177912e-02f, 4.08269800e-02f, -1.00637255e-02f, 2.26642918e-02f,
  -9.58638452e-03f, 6.81194291e-02f, -1.72941536e-02f, -6.66394457e-02f, 6.63588718e-02f, -9.25736502e-02f, -8.32164213e-02f, -1.35383368e-01f, 4.78280820e-02f, 4.94773984e-02f,
  1.42923342e-02f, 6.29343241e-02f, -7.51544014e-02f, 1.57115608e-02f, -2.67317165e-02f, -9.26713198e-02f, -8.97051543e-02f, -4.85038906e-02f, -3.78876701e-02f, -4.36415710e-02f,
  -3.13209966e-02f, -3.60722654e-02f, 1.02396727e-01f, -9.59121808e-03f, -2.04666480e-02f, 3.23365405e-02f, 3.35201286e-02f, -5.99733703e-02f, 2.23944280e-02f, -5.24805337e-02f,
  -8.42770934e-02f, 2.86157355e-02f, 2.59211920e-02f, 2.78562251e-02f, -2.17202678e-02f, -7.52143785e-02f, 4.39623669e-02f, -4.50481437e-02f, 5.79143241e-02f, -1.06481425e-02f,
  3.77611928e-02f, 7.55912066e-03f, 8.18431601e-02f, -6.13217242e-02f, -6.63607344e-02f, 2.41522044e-02f, 6.39440119e-02f, -6.86224364e-03f, -1.45501271e-02f, -9.92599130e-03f,
  -3.24912108e-02f, 2.16545649e-02f, -8.86612944e-03f, -2.87499614e-02f, 3.83497891e-03f, -5.01422174e-02f, 8.21005479e-02f, 4.81694192e-02f, -1.63570046e-02f, 8.72491002e-02f,
  6.40281290e-02f, 5.98809943e-02f, -5.42360954e-02f, -8.03174824e-02f, 2.62503736e-02f, 4.66156118e-02f, -3.42591405e-02f, -3.73020098e-02f, -2.18531694e-02f, 1.88913457e-02f,
  -4.18258198e-02f, -5.82045130e-02f, 8.28271324e-04f, 6.26055747e-02f, 4.25674161e-03f, -3.25652622e-02f, -1.14500765e-02f, 3.07540651e-02f, -9.25095007e-02f, -5.06377146e-02f,
  -5.38737476e-02f, 2.13905908e-02f, 5.01937680e-02f, -2.86425930e-02f, -6.54672906e-02f, -6.33798726e-03f, 6.57524094e-02f, 1.57130826e-02f, 8.26747492e-02f, -3.92214730e-02f,
  -5.06995581e-02f, -6.41889572e-02f, -3.83699872e-02f, -9.65137109e-02f, 9.03372187e-03f, -6.99324235e-02f, -2.59592608e-02f, -3.16382386e-02f, -2.18897946e-02f, -4.03432250e-02f,
  1.61245003e-01f, 6.04187064e-02f, 4.98368479e-02f, 1.99506760e-01f, -7.05650821e-02f, -2.33846292e-01f, -2.14078963e-01f, -1.37356725e-02f, -5.07712252e-02f, -2.25845352e-02f,
  2.06842348e-02f, 1.54007047e-01f, -1.20467409e-01f, 5.56926243e-02f, 5.63600995e-02f, -2.61645634e-02f, 1.17253810e-01f, -3.80013771e-02f, -1.93237588e-02f, 1.02489531e-01f,
  1.58324450e-01f, -4.84968834e-02f, 1.79996654e-01f, 3.30448337e-02f, -8.10377300e-03f, 1.75053746e-01f, 1.22523420e-01f, -2.98955124e-02f, 1.25424311e-01f, 3.77883762e-02f,
  -1.31271286e-02f, 1.28059918e-02f, 6.81948289e-02f, -9.53684375e-02f, 4.37154397e-02f, -4.63914238e-02f, -5.19941337e-02f, -1.13227949e-01f, 1.17649585e-02f, 2.73657963e-02f,
  3.93889546e-02f, 8.26396272e-02f, 3.08700856e-02f, -5.27441055e-02f, -6.76745921e-02f, 8.86102319e-02f, -1.56992879e-02f, 7.34250844e-02f, 6.69584870e-02f, 8.26500207e-02f,
  3.19319926e-02f, 4.70070690e-02f, 3.64516377e-02f, 1.67680234e-02f, 4.50930446e-02f, 4.42142226e-02f, 4.91714403e-02f, 5.27410097e-02f, 8.71991441e-02f, 1.06425710e-01f,
  4.57438044e-02f, 1.10304561e-02f, -1.20177381e-01f, -7.06215948e-02f, 1.40773179e-02f, -6.91262423e-04f, -1.41561534e-02f, -3.39897238e-02f, 8.26750789e-03f, -9.51258093e-03f,
  -2.81002764e-02f, 7.09861442e-02f, -3.31356414e-02f, -5.75260371e-02f, -5.21556996e-02f, 3.83584090e-02f, 3.40265618e-03f, 2.68041939e-02f, 6.06353246e-02f, -2.51498073e-02f,
  2.40846127e-02f, 6.38653114e-02f, -4.22087945e-02f, 4.38311249e-02f, -4.92741577e-02f, 3.71655524e-02f, 8.78760070e-02f, -6.46721199e-02f, -4.13127728e-02f, 5.06050028e-02f,
  8.39992762e-02f, 2.78960437e-01f, 1.96833108e-02f, -4.44963248e-03f, 7.99881518e-02f, 2.48422194e-02f, -4.89814505e-02f, -6.54990599e-02f, 1.03237770e-01f, -1.02136992e-02f,
  1.27566261e-02f, 5.02454080e-02f, 5.84345013e-02f, 5.33927977e-02f, 8.26230943e-02f, -6.26844019e-02f, 1.10213883e-01f, 8.27414021e-02f, -2.36048829e-02f, 1.95506327e-02f,
  1.07693739e-01f, 3.02965436e-02f, -5.02131917e-02f, -8.97916872e-03f, -3.40326466e-02f, 3.92844900e-02f, -3.28809284e-02f, -4.80718352e-02f, 2.08604406e-03f, 9.21085924e-02f,
  -1.54697299e-01f, -2.26438455e-02f, 8.08335543e-02f, -1.52755186e-01f, -4.73996401e-02f, 7.59988576e-02f, 1.46879748e-01f, -1.60833552e-01f, -1.77812412e-01f, -4.87681478e-02f,
  9.24823806e-02f, 4.02994789e-02f, 2.81635016e-01f, 3.14426459e-02f, 1.96862116e-01f, 2.85394758e-01f, -3.09978034e-02f, -1.32715544e-02f, -1.09889701e-01f, -1.92006961e-01f,
  -2.34687030e-02f, -1.29150808e-01f, 1.78992182e-01f, -9.14248899e-02f, -7.30281323e-02f, -9.08232927e-02f, 7.72450566e-02f, 1.12011299e-01f, -1.58978894e-01f, 4.65228036e-02f,
  -2.28136018e-01f, -1.58402398e-01f, -4.62628379e-02f, 4.40375470e-02f, -3.03066131e-02f, -4.12590988e-02f, 9.17839706e-02f, 1.26589268e-01f, -7.59889605e-03f, 4.31647077e-02f,
  2.81427056e-02f, -9.91760939e-02f, -1.44198731e-01f, -7.42844269e-02f, -1.42831713e-01f, -1.08117759e-01f, -4.83563542e-02f, -3.95627506e-02f, -9.85916471e-04f, 5.53342625e-02f,
  -1.60836335e-03f, 3.29684131e-02f, -6.82671890e-02f, -2.49807537e-02f, 3.00078131e-02f, 1.51210302e-03f, -4.23136279e-02f, -2.65349131e-02f, 6.78917859e-03f, -6.22811541e-02f,
  1.27503676e-02f, -9.05313715e-02f, -6.06483407e-02f, 2.50704139e-02f, -9.50104371e-02f, -1.04108557e-01f, 8.88953879e-02f, -5.71602546e-02f, -2.78708227e-02f, 1.44230267e-02f,
  -8.43046531e-02f, -1.30477563e-01f, -1.03784092e-01f, 4.63189185e-02f, -2.00902261e-02f, -1.43575110e-02f, 2.75604613e-03f, -3.29829939e-02f, 3.50493342e-02f, -9.94820818e-02f,
  -3.27241309e-02f, 3.95271517e-02f, -7.01900870e-02f, -5.87171428e-02f, 2.92624198e-02f, -1.29239205e-02f, -1.01514541e-01f, -9.41821560e-02f, -2.06611529e-02f, 7.88243786e-02f,
  -2.34832764e-01f, -2.12298468e-01f, -1.24949515e-01f, -1.28594294e-01f, 1.34919230e-02f, -4.05487530e-02f, 1.36079034e-02f, -4.66551967e-02f, -8.06058496e-02f, 4.84358929e-02f,
  3.12576257e-02f, -4.91330996e-02f, -4.77243476e-02f, 4.86423150e-02f, 1.19063025e-02f, -8.31334516e-02f, -4.65375930e-02f, 1.33956559e-02f, -5.62281236e-02f, -4.14959304e-02f,
  3.03983744e-02f, 4.01797891e-02f, 1.53137362e-02f, -2.79732514e-02f, -1.93293598e-02f, 5.18536568e-02f, -7.12308288e-02f, 9.47352722e-02f, -3.84972468e-02f, -7.61470497e-02f,
  1.42924562e-01f, 1.58636853e-01f, 1.52375877e-01f, -5.85203506e-02f, -4.02981266e-02f, 1.15553439e-01f, -3.90613526e-02f, -3.41300666e-02f, -5.78734442e-04f, -3.44421901e-02f,
  -1.26681075e-01f, 7.44859353e-02f, -6.85268641e-02f, -1.31304547e-01f, -1.86255530e-01f, -4.15951796e-02f, 1.67001002e-02f, -9.44297463e-02f, -3.81504971e-04f, 1.59280840e-03f,
  -8.48088115e-02f, -1.40978485e-01f, -1.03241116e-01f, 2.59872209e-02f, 1.18933022e-02f, 1.25143245e-01f, -1.20681651e-01f, 1.12127690e-02f, -5.12277558e-02f, -7.78063089e-02f,
  1.97351594e-02f, -3.87802313e-04f, 6.59908578e-02f, -5.91987446e-02f, -9.07226577e-02f, 1.50441676e-02f, -2.96576861e-02f, 2.69948188e-02f, -9.06886533e-02f, -3.13868634e-02f,
  -5.88848069e-03f, -6.77880319e-03f, -6.73648641e-02f, -6.36502281e-02f, 5.81450462e-02f, 1.15994448e-02f, -6.95488136e-03f, 1.33410484e-01f, 6.88115805e-02f, 2.84899622e-02f,
  3.44915986e-02f, 3.14188302e-02f, 2.93665864e-02f, -7.81930536e-02f, 9.81015898e-03f, -8.22882075e-03f, -4.44783829e-02f, -7.11588375e-03f, 1.00599760e-02f, 7.13829696e-02f,
  -3.61609645e-02f, -1.67012718e-02f, -3.57046090e-02f, 7.04554170e-02f, -3.94061804e-02f, -2.89341807e-02f, -1.64845847e-02f, -8.75403211e-02f, 5.44206984e-03f, -5.38801625e-02f,
  6.98016435e-02f, 5.97088858e-02f, -1.97464079e-02f, 1.99414752e-02f, 4.10285732e-03f, 8.98313373e-02f, 7.74886133e-03f, 5.96167445e-02f, 6.18483387e-02f, 5.44507690e-02f,
  -7.12705106e-02f, -9.93701667e-02f, -2.99110683e-03f, -1.80730633e-02f, 5.73151466e-03f, -6.06901832e-02f, 2.63764448e-02f, 4.93177352e-03f, -5.41047007e-02f, -8.87964070e-02f,
  -1.21365115e-02f, -5.14337569e-02f, 7.93149099e-02f, -6.53299168e-02f, -3.08725853e-02f, -7.83266500e-03f, 5.20018814e-03f, -2.96387007e-03f, 5.36662862e-02f, -3.57434456e-03f,
  3.40044163e-02f, 7.88951516e-02f, -1.56312436e-03f, 6.04324490e-02f, 5.35149761e-02f, -5.64768724e-03f, 4.06903103e-02f, 1.60275921e-02f, -8.02934542e-02f, 2.42024008e-02f,
  6.55484796e-02f, -4.12696674e-02f, -3.83543521e-02f, -6.06963225e-02f, 3.56287844e-02f, -4.02502678e-02f, 5.68198152e-02f, -6.86383620e-02f, -4.76616807e-03f, -7.70124421e-02f,
  -3.18328351e-01f, -1.45990059e-01f, -2.41838053e-01f, -1.77910611e-01f, 1.09062552e-01f, -7.42518753e-02f, -1.64666697e-01f, 5.98516539e-02f, -1.65828645e-01f, 2.84240752e-01f,
  7.80501217e-02f, -2.64430463e-01f, 1.24691710e-01f, -3.07621121e-01f, -4.44167972e-01f, -1.40303269e-01f, -3.29119027e-01f, -1.30089253e-01f, -1.31852090e-01f, 1.15711331e-01f,
  -1.67576298e-01f, 9.83570702e-03f, -2.97695011e-01f, 2.17739999e-01f, -8.83934349e-02f, 1.81054115e-01f, 2.81766027e-01f, 2.38163099e-01f, -8.44419152e-02f, -1.16426200e-01f,
  -8.49919766e-02f, 9.92860571e-02f, -5.95723614e-02f, -8.68607014e-02f, 3.82532589e-02f, 9.72507820e-02f, 4.85905521e-02f, -2.55682506e-03f, -8.64743255e-03f, -4.39051539e-02f,
  7.37406313e-02f, -6.69438615e-02f, -6.96511492e-02f, -6.84078932e-02f, -2.94018500e-02f, -1.06624603e-01f, -6.01261705e-02f, 1.68934204e-02f, 2.21264381e-02f, -9.22454298e-02f,
  -6.61599040e-02f, -1.07336521e-01f, -2.28284001e-02f, 1.48749007e-02f, -7.98474178e-02f, -1.43693220e-02f, -7.43499920e-02f, -1.04621192e-02f, 2.09192596e-02f, -1.01976283e-01f,
  6.83789253e-02f, 1.07844817e-02f, 6.52572233e-03f, -1.49289723e-02f, 1.08591970e-02f, 5.56727611e-02f, 7.98631608e-02f, 5.01813181e-02f, 3.26246247e-02f, 3.72351557e-02f,
  -9.46912635e-03f, 1.49133503e-02f, 5.28212730e-03f, 2.49325167e-02f, -3.61026153e-02f, 7.35936165e-02f, 2.10663229e-02f, 3.21037805e-04f, 6.26530964e-03f, -1.02738716e-01f,
  5.66920228e-02f, 4.37978357e-02f, 4.19912450e-02f, 2.80353297e-02f, 1.73770376e-02f, -3.90969776e-02f, 4.06222232e-02f, -8.16495568e-02f, 4.00796756e-02f, 3.25008705e-02f,
  1.63546894e-02f, 1.54704243e-01f, 2.71861609e-02f, 5.59854284e-02f, 1.02615088e-01f, 1.10934153e-01f, -4.83977944e-02f, -1.53821185e-02f, 5.20783737e-02f, 3.79100442e-02f,
  1.39323741e-01f, 4.83525079e-03f, 1.42520428e-01f, -1.85047314e-02f, 1.06131202e-02f, -3.80865508e-03f, 9.18273106e-02f, 2.78625712e-02f, 3.82726043e-02f, 6.42315671e-02f,
  6.58850595e-02f, 4.92959768e-02f, -7.61401094e-03f, -2.14822851e-02f, 2.43355036e-02f, 1.43106341e-01f, 2.50442903e-02f, 6.22676872e-02f, 6.41955063e-02f, -4.53365631e-02f,
  8.41123015e-02f, -9.33684334e-02f, -2.24831346e-02f, -2.57848352e-01f, -6.28899634e-02f, -1.42954886e-01f, -1.97236747e-01f, -3.84201296e-02f, 3.72777134e-02f, -4.62575778e-02f,
  -7.77086839e-02f, 7.07908254e-03f, 1.87090755e-01f, -2.13085279e-01f, 1.97883844e-01f, 2.23210067e-01f, -8.29076990e-02f, -1.51899010e-01f, -3.86199504e-02f, -9.74797457e-02f,
  -7.83278346e-02f, -1.30485713e-01f, -6.29423112e-02f, -1.97628573e-01f, -2.97776282e-01f, -9.62120295e-02f, 6.30412847e-02f, -9.15094465e-02f, -2.09174633e-01f, -7.25314468e-02f,
  -7.06766918e-02f, 4.03319336e-02f, -7.78229951e-05f, 9.03330296e-02f, 3.74613777e-02f, -1.59693696e-02f, -1.10796839e-01f, -1.72532536e-02f, 6.22884631e-02f, 8.89752060e-02f,
  -4.41699065e-02f, 9.95517299e-02f, -6.35183528e-02f, -1.78733021e-02f, -6.45599188e-03f, 4.25487831e-02f, -4.79548015e-02f, -5.75324614e-03f, 2.83887126e-02f, -4.79311906e-02f,
  -2.65161712e-02f, 3.02456543e-02f, -3.75349224e-02f, -8.50980729e-03f, -6.14722148e-02f, 2.84548178e-02f, 9.82151031e-02f, 6.14009835e-02f, 5.90527207e-02f, 3.66360918e-02f,
  -5.27326763e-02f, -4.21983115e-02f, -4.13762182e-02f, 4.05255295e-02f, 9.80883371e-03f, -7.42431208e-02f, -3.10031138e-02f, -7.09643587e-02f, 9.36622359e-03f, -2.84104533e-02f,
  -6.72932267e-02f, 2.77489275e-02f, -3.77775393e-02f, 4.24397662e-02f, -2.33070888e-02f, 1.82107762e-02f, 3.42426784e-02f, -9.12444890e-02f, -9.40339938e-02f, -3.93332727e-02f,
  -4.43314798e-02f, -5.63483648e-02f, 3.86341996e-02f, -4.63817492e-02f, -1.92869548e-02f, -2.62090247e-02f, -9.02543589e-03f, 4.73291464e-02f, -2.08112877e-02f, 7.47273862e-02f,
  1.18742585e-02f, 2.52808183e-02f, 7.80486614e-02f, 3.56892659e-03f, -2.22444627e-03f, -1.72294900e-02f, -4.59661335e-02f, -7.00148791e-02f, -7.15686530e-02f, 9.84820351e-02f,
  -6.15685470e-02f, -6.84826002e-02f, -4.73122997e-03f, -4.10585590e-02f, -7.05523714e-02f, -8.72755796e-02f, 5.27441734e-03f, 9.11101103e-02f, -5.30016534e-02f, -7.30096400e-02f,
  6.00262592e-03f, -1.43748820e-02f, 1.38796166e-01f, -6.40074536e-02f, -5.58183081e-02f, -2.53298618e-02f, 7.21533969e-02f, -2.46147495e-02f, 6.49637282e-02f, 4.11774544e-03f,
  -2.52508283e-01f, 2.27811620e-01f, 1.63973585e-01f, -1.73210934e-01f, 1.23240694e-01f, 1.63389504e-01f, -2.52749547e-02f, 1.52558610e-01f, 1.45904124e-01f, -2.19019443e-01f,
  -1.40750289e-01f, -1.34256765e-01f, 7.47333339e-04f, -7.23193362e-02f, -1.24341801e-01f, 9.76989642e-02f, -7.82587156e-02f, -7.26561174e-02f, 2.64085472e-01f, 7.25068375e-02f,
  -2.33355518e-02f, -4.00146702e-03f, -4.98329103e-02f, 1.11688249e-01f, 2.82164942e-03f, -8.12636167e-02f, -2.67651349e-01f, 1.46733254e-01f, -9.52174515e-02f, 1.87567174e-02f,
  -4.46045445e-03f, -5.18355668e-02f, -1.93727031e-01f, -1.06507115e-01f, -1.37246758e-01f, -7.56104738e-02f, -1.44571006e-01f, 9.60650109e-03f, -1.03944138e-01f, 6.90515488e-02f,
  -6.26992062e-02f, -1.51985968e-02f, 3.74052748e-02f, -3.32165211e-02f, 7.20016956e-02f, -2.87105832e-02f, 1.33032531e-01f, 5.39884120e-02f, 4.55819331e-02f, 1.51343599e-01f,
  1.22782111e-01f, -1.92784090e-02f, -3.00310608e-02f, -5.19810952e-02f, -1.07901264e-02f, -6.96552917e-02f, -1.85435805e-02f, -6.32708222e-02f, -2.26889364e-02f, 3.05973198e-02f,
  2.58856509e-02f, 4.21925932e-02f, -7.46955499e-02f, 7.63896778e-02f, 8.86180811e-03f, -4.90362421e-02f, 3.40473801e-02f, -6.11240827e-02f, -6.14087693e-02f, 2.35572308e-02f,
  -8.52187164e-03f, -9.51988325e-02f, 6.50012568e-02f, 2.34641805e-02f, -5.83009906e-02f, -3.48612852e-02f, 9.13170446e-03f, 1.09180119e-02f, 6.98276460e-02f, 3.92199308e-02f,
  1.96270063e-03f, 1.96710099e-02f, -1.87250730e-02f, 4.86866795e-02f, -8.07023123e-02f, 2.01268699e-02f, -8.11498612e-02f, 8.08727965e-02f, 2.69761272e-02f, -2.52952017e-02f,
  -1.99783221e-01f, -1.65873006e-01f, -5.22591546e-02f, -1.20424695e-01f, -5.12314066e-02f, -9.98650305e-03f, 4.90758345e-02f, -4.85510454e-02f, -7.07423761e-02f, -1.37318792e-02f,
  -6.34905184e-03f, -9.20587108e-02f, -1.09486496e-02f, 2.38412209e-02f, 1.55264754e-02f, 2.57323161e-02f, -2.62613725e-02f, -1.52346343e-01f, -1.07441843e-01f, -7.22045079e-02f,
  -8.18887651e-02f, -8.46448466e-02f, -6.67470992e-02f, 2.57654320e-02f, -2.04833020e-02f, -6.61337599e-02f, 8.32855329e-03f, -1.05958516e-02f, 9.64386668e-03f, -1.21211903e-02f,
  -1.37299951e-02f, -1.46534309e-01f, 7.68967718e-02f, 1.25645638e-01f, -1.40075788e-01f, -1.39115006e-01f, 6.92340657e-02f, -9.08911675e-02f, -1.22101992e-01f, 2.26487182e-02f,
  9.20949355e-02f, 1.17245965e-01f, -2.39468180e-02f, 1.59536690e-01f, 1.91930011e-01f, 7.43348673e-02f, 1.11857362e-01f, 1.74604043e-01f, -5.84710622e-03f, 2.78548594e-03f,
  5.39413951e-02f, 1.24566136e-02f, 1.86082795e-01f, 9.05436743e-03f, 6.92455918e-02f, -6.47735819e-02f, 1.37402818e-01f, -4.15123589e-02f, 8.79231095e-02f, 1.26052365e-01f,
  -6.48031235e-02f, -9.10360739e-02f, -9.97047201e-02f, -1.27739098e-03f, -8.51887763e-02f, 1.76330600e-02f, 2.57274918e-02f, 1.37993619e-01f, 2.85392981e-02f, -9.02893469e-02f,
  6.03750385e-02f, 6.74286932e-02f, -1.51819065e-02f, 1.48554880e-03f, -1.07684836e-01f, 4.14089896e-02f, -1.68866862e-03f, -3.58041488e-02f, 6.04459494e-02f, -5.38287051e-02f,
  -4.49690409e-02f, -1.18790017e-02f, 3.92056778e-02f, -7.74805760e-03f, 5.30510098e-02f, -2.90171932e-02f, 5.24489991e-02f, 4.30080034e-02f, 6.05970360e-02f, -9.03500989e-02f,
  7.01770410e-02f, 4.63171210e-03f, -7.20279757e-03f, -1.47595918e-02f, -6.83147758e-02f, -5.49025126e-02f, 1.43821007e-02f, 4.08602171e-02f, 3.89249176e-02f, 1.94141585e-02f,
  -7.32335895e-02f, 2.16913652e-02f, -3.11590489e-02f, -6.09793253e-02f, 5.07701002e-02f, -3.49731334e-02f, 2.57323105e-02f, -5.01399301e-03f, -1.82846319e-02f, -1.39594954e-02f,
  2.24640593e-02f, -4.27383780e-02f, 4.28070538e-02f, 7.94517919e-02f, -8.35680813e-02f, 2.39545386e-03f, 2.41319556e-02f, -2.08106134e-02f, -6.78309845e-03f, 2.96111796e-02f,
  -1.56928182e-01f, -2.92490032e-02f, 1.84211396e-02f, -4.64425907e-02f, -3.41176949e-02f, -1.56930760e-02f, 6.85822517e-02f, 8.05307273e-03f, -4.92461398e-02f, -9.36123058e-02f,
  -9.19838931e-05f, -4.02903520e-02f, -3.45765539e-02f, 8.65436792e-02f, 2.34611444e-02f, 4.16724496e-02f, 6.09922633e-02f, 4.30882946e-02f, 3.70553918e-02f, -7.41699859e-02f,
  -8.03388283e-02f, -5.92890717e-02f, 7.81086534e-02f, -3.09433844e-02f, 5.74998185e-03f, 1.66677881e-03f, -7.86303077e-03f, -8.31874385e-02f, 2.15061032e-03f, -6.15538396e-02f,
  2.14825034e-01f, 9.94249359e-02f, -3.18705410e-01f, -5.57878390e-02f, 8.55743960e-02f, 1.99581489e-01f, 1.11088306e-01f, 4.62610833e-03f, -2.61222005e-01f, 1.75984085e-01f,
  1.98963106e-01f, -6.44804984e-02f, 1.84423868e-02f, 1.04339935e-01f, 1.03951551e-01f, -6.27477765e-02f, 1.85883731e-01f, 1.28936127e-01f, -1.49838507e-01f, 1.05209216e-01f,
  -1.71337098e-01f, 2.53167450e-01f, -1.90304592e-01f, 5.09721860e-02f, 2.17499789e-02f, -1.86948895e-01f, 3.83367017e-02f, -1.14474349e-01f, 5.78818806e-02f, 2.65745744e-02f,
  1.01039514e-01f, 7.89954048e-03f, 1.10134557e-02f, -5.97209223e-02f, 1.82382315e-01f, 5.64754494e-02f, 4.49313410e-02f, -1.31807104e-02f, -1.14051932e-02f, 6.37798905e-02f,
  -3.08237653e-02f, -1.86161883e-02f, 8.73098001e-02f, -1.40293280e-03f, -1.42737506e-02f, -2.76673473e-02f, -9.86461528e-03f, 1.15331868e-02f, -9.18754488e-02f, -5.20242983e-03f,
  -2.71312464e-02f, 3.39752622e-02f, -6.99776709e-02f, -1.64750386e-02f, -1.53539270e-01f, 3.58565673e-02f, -1.39239151e-02f, -2.40481105e-02f, 8.70061964e-02f, 1.32855717e-02f,
  4.21063416e-02f, -2.93849185e-02f, 2.27577668e-02f, 3.54808494e-02f, -7.68041413e-04f, 2.91933864e-02f, -5.31142429e-02f, 2.10460299e-03f, 2.97976676e-02f, 5.36227450e-02f,
  2.87892465e-02f, 4.17845137e-02f, 6.05304167e-02f, -1.94901600e-02f, 3.57699580e-03f, 3.31234075e-02f, 5.50026447e-02f, 7.14186877e-02f, -2.37685982e-02f, -1.44203454e-02f,
  -1.40589811e-02f, -1.08921984e-02f, 2.26136111e-03f, -1.81370955e-02f, -3.66597530e-03f, -3.34528536e-02f, 3.05277333e-02f, 5.67024276e-02f, -3.39984596e-02f, -5.82171232e-02f,
  1.81179270e-01f, 6.44927248e-02f, 1.29138483e-02f, 1.51698533e-02f, -1.97896976e-02f, 9.83217806e-02f, -3.25507787e-03f, 2.83038374e-02f, -7.13182017e-02f, -1.05255758e-02f,
  7.26577938e-02f, -1.33492827e-01f, 1.03799716e-01f, -4.38673943e-02f, -2.27600709e-02f, 6.20528050e-02f, 7.96314850e-02f, -3.02415751e-02f, -2.58335657e-03f, 1.05425730e-01f,
  3.38160433e-02f, -1.16403894e-02f, -1.23273879e-02f, 8.36750306e-03f, -9.46218148e-03f, -4.09972779e-02f, 7.69483820e-02f, -8.18553120e-02f, 3.53763551e-02f, -7.42071047e-02f,
  -1.15383133e-01f, 1.09389186e-01f, -1.27717882e-01f, -3.69450599e-02f, 3.25571676e-03f, 1.19251274e-01f, 2.19032004e-01f, 2.93681938e-02f, 3.62158865e-02f, 9.40700099e-02f,
  1.58518612e-01f, -3.46764699e-02f, 7.10705295e-03f, 1.06093973e-01f, 4.30218913e-02f, 1.37051269e-01f, 2.53578722e-01f, 1.60377696e-01f, -6.80427253e-02f, 5.57619035e-02f,
  -4.51697409e-03f, -7.35709770e-03f, -1.39323503e-01f, -1.18539929e-01f, -6.21772092e-03f, -1.84044674e-01f, -4.84430082e-02f, -7.41830319e-02f, 1.73705176e-03f, -1.01165744e-02f,
  4.11955602e-02f, -1.07013360e-01f, -1.27824426e-01f, -4.03005220e-02f, 1.06181260e-02f, -7.10173622e-02f, 3.13482224e-03f, 3.88800800e-02f, -6.13178797e-02f, 6.86643049e-02f,
  -2.97787338e-02f, -7.52900988e-02f, -3.51403467e-02f, -8.87562856e-02f, -3.84782180e-02f, -9.43877026e-02f, -2.14737449e-02f, 5.39927706e-02f, -5.90302199e-02f, -1.35547280e-01f,
  -4.33017500e-03f, -2.16497295e-02f, -4.98506688e-02f, 4.97813278e-04f, 7.59435147e-02f, 4.86371815e-02f, 1.47808436e-02f, 8.63426775e-02f, 4.38205227e-02f, 2.62506250e-02f,
  -1.41884396e-02f, 3.38181257e-02f, -1.03296302e-02f, -5.70719726e-02f, 1.01705901e-02f, -3.17566544e-02f, -5.95677719e-02f, -8.60010311e-02f, 3.33483182e-02f, -3.39773819e-02f,
  -2.97639836e-02f, 6.49138764e-02f, 6.43893927e-02f, 6.24364950e-02f, -5.82031347e-02f, 7.14572892e-02f, -7.88230300e-02f, 3.94668318e-02f, -6.51888922e-03f, 5.90189211e-02f,
  -2.32317708e-02f, -5.95066473e-02f, -7.77876303e-02f, 3.42916697e-03f, 6.43461496e-02f, 5.33416532e-02f, 2.74156798e-02f, 5.57538010e-02f, -1.04469359e-01f, -6.95572495e-02f,
  1.27132654e-01f, 1.97023347e-01f, 4.76177968e-03f, -9.43463892e-02f, -7.53790215e-02f, 1.19118512e-01f, 1.33019775e-01f, -7.25161806e-02f, 6.28590360e-02f, 4.40786704e-02f,
  -3.80871482e-02f, 5.18409684e-02f, -3.32946926e-02f, -1.32025208e-03f, -6.58427328e-02f, -1.47049641e-02f, -4.61028554e-02f, -2.79390346e-02f, 1.48866782e-02f, -1.20284021e-01f,
  1.12059424e-02f, -4.32551503e-02f, 6.70242235e-02f, 8.58916417e-02f, -6.08968064e-02f, 2.94074882e-02f, -8.42104480e-02f, -6.72262833e-02f, 7.87984021e-03f, -2.58340798e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 52)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 52;
const float L0_fan_Bp_bar_data[] = {
  5.29348291e-02f, 9.89770740e-02f, 2.60706306e-01f, 2.14589894e-01f, 2.28726193e-01f, 1.33017480e-01f, 8.90151858e-02f, 9.44259614e-02f, 2.79896230e-01f, -4.54325862e-02f,
  -4.76727411e-02f, 1.06789395e-01f, 9.34595466e-02f, 4.61561345e-02f, 2.96771377e-01f, 4.80934717e-02f, 1.29369125e-01f, 2.06872597e-01f, 1.40750047e-03f, 7.61501268e-02f,
  1.59076825e-01f, 1.96514279e-01f, -2.73991134e-02f, 7.63926730e-02f, 2.30322704e-01f, 2.17163250e-01f, 7.44763389e-02f, 9.80801210e-02f, 2.40332767e-01f, 1.59552845e-03f,
  2.02701285e-01f, 5.54288365e-03f, 2.06178352e-01f, 8.13178569e-02f, 4.30030748e-03f, 9.09523144e-02f, 1.52888104e-01f, 8.24789703e-02f, 5.61126210e-02f, 1.50738716e-01f,
  2.22410083e-01f, 1.37057573e-01f, -4.51638503e-03f, 9.50005725e-02f, 1.43457741e-01f, 8.31102580e-02f, 2.48466015e-01f, 1.13319665e-01f, 2.46884182e-01f, 1.28115773e-01f,
  1.52981564e-01f, 8.98346454e-02f
};

// L1_fan_Wp (Shape: 6 x 64)
const int L1_fan_Wp_rows = 6;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  -1.23121887e-01f, 5.67640439e-02f, -5.31796962e-02f, -4.61135767e-02f, 4.85506980e-03f, -1.82563096e-01f, 3.42836976e-01f, 1.38996899e-01f, 1.95285007e-01f, -7.11703077e-02f,
  3.00025672e-01f, -1.36587813e-01f, 6.35585785e-02f, 1.19942343e-02f, 3.14762406e-02f, -3.55028696e-02f, -4.49384265e-02f, 1.11381203e-01f, 7.08057582e-02f, 1.41249910e-01f,
  -3.30328792e-01f, -1.61363006e-01f, -1.39046018e-03f, 1.07606478e-01f, -2.21269876e-01f, 1.20630838e-01f, 2.47782409e-01f, -1.17895558e-01f, -1.14995569e-01f, -3.64467571e-03f,
  -3.89322154e-02f, 1.64573833e-01f, -1.06710099e-01f, -1.43572222e-02f, 1.43752098e-02f, 4.12707068e-02f, -3.52358855e-02f, 2.02338040e-01f, 6.76777363e-02f, 3.32214311e-02f,
  -2.19251841e-01f, -1.65312037e-01f, 1.10804453e-01f, -5.38289994e-02f, -9.81762409e-02f, 1.51245028e-01f, -6.82124645e-02f, -2.06613258e-01f, -9.72868949e-02f, 2.35570949e-02f,
  -6.39168024e-02f, 1.55791402e-01f, -1.09553225e-01f, -3.44134979e-02f, -6.13062046e-02f, -1.63497373e-01f, 2.38089189e-01f, -1.37357473e-01f, -2.17543636e-02f, 1.39538109e-01f,
  1.66848585e-01f, 1.44974247e-01f, -3.32259804e-01f, -1.58760116e-01f, 7.46050999e-02f, -6.69854283e-02f, 1.50155753e-01f, 1.68863863e-01f, -2.67007798e-02f, -3.29296440e-02f,
  1.37996778e-01f, 2.02651724e-01f, 1.12294458e-01f, 1.01025023e-01f, -1.31314257e-02f, -5.07689267e-03f, -2.02240534e-02f, -3.41487713e-02f, -6.55363798e-02f, -2.05703482e-01f,
  1.06135085e-01f, 3.40699330e-02f, 3.30888405e-02f, 4.66587357e-02f, -1.41910389e-01f, 2.29483694e-02f, -7.43253604e-02f, -2.02783450e-01f, -5.08949161e-02f, 7.50599578e-02f,
  2.01385796e-01f, -1.07615031e-01f, -4.32188548e-02f, -2.48690024e-01f, -1.30882069e-01f, 1.68024451e-01f, 6.09889217e-02f, -1.68580398e-01f, -1.11344084e-02f, 8.45512226e-02f,
  1.48154646e-01f, 2.04743952e-01f, 1.54502183e-01f, 1.16713606e-01f, 1.19497940e-01f, -1.69249788e-01f, 1.75269336e-01f, -1.26915395e-01f, -2.62946784e-01f, -1.81906611e-01f,
  -5.29739298e-02f, -2.88252756e-02f, 1.16149299e-01f, -3.38731240e-03f, -7.38071874e-02f, -2.26806805e-01f, 7.49318907e-03f, 8.28568786e-02f, -1.38921186e-01f, -2.26119772e-01f,
  5.70060797e-02f, 4.14570086e-02f, 3.19032341e-01f, 1.46680934e-04f, 1.94082871e-01f, 6.92493469e-03f, -1.14654668e-01f, -2.21150815e-02f, 1.31163999e-01f, 1.18681043e-01f,
  4.00282554e-02f, 1.52736381e-01f, 8.03301930e-02f, 1.01171814e-01f, -2.41433904e-01f, 1.56281725e-01f, -1.38366222e-01f, 4.91807796e-02f, -2.15569839e-01f, 1.94897473e-01f,
  -1.04808502e-01f, -5.67630753e-02f, -1.54032141e-01f, 3.36156897e-02f, 1.72626868e-01f, 1.21702537e-01f, 2.76450184e-03f, 1.05050199e-01f, 1.27843454e-01f, -5.68243265e-02f,
  7.63764903e-02f, -1.54203981e-01f, 7.77105466e-02f, -1.32654365e-02f, 7.28819817e-02f, 9.55033824e-02f, -1.27578795e-01f, -8.23702291e-02f, 1.26508668e-01f, 1.80514231e-01f,
  7.34473243e-02f, -1.64410666e-01f, -3.12784053e-02f, -9.46030989e-02f, 2.32008219e-01f, 1.78115711e-01f, 1.04022443e-01f, 2.79839545e-01f, 6.06568996e-03f, -1.03543609e-01f,
  1.01555973e-01f, 1.30755618e-01f, -1.25245690e-01f, -1.84835628e-01f, 2.59809811e-02f, 9.73565280e-02f, 6.88495636e-02f, 2.41516270e-02f, 3.84030566e-02f, -2.19321281e-01f,
  -2.34246384e-02f, 2.72907019e-01f, -1.53175130e-01f, 7.76553154e-02f, 7.02353492e-02f, 5.48540354e-02f, 1.92130908e-01f, -1.00498967e-01f, -6.39349548e-03f, 2.04281844e-02f,
  -1.39460787e-01f, 7.51192421e-02f, -4.05025901e-03f, -1.36249319e-01f, 2.22730767e-02f, 1.70174651e-02f, -1.42183140e-01f, 1.18173406e-01f, 2.68817469e-02f, -1.16491050e-01f,
  1.96776494e-01f, 5.88903353e-02f, 1.09267846e-01f, 4.21604246e-01f, 2.27271482e-01f, 1.10035352e-01f, 1.81376800e-01f, 1.37321472e-01f, -1.23458311e-01f, 4.75077704e-02f,
  -6.33027703e-02f, -1.29361838e-01f, 2.41966531e-01f, -1.38116181e-01f, 4.66363356e-02f, 2.42675364e-01f, 8.67161602e-02f, -5.81647195e-02f, -1.47336289e-01f, 1.37432992e-01f,
  1.74805522e-01f, -1.07576586e-01f, 1.30532384e-01f, -2.20708981e-01f, -4.89143766e-02f, -1.24483705e-01f, 9.39249396e-02f, 1.16999127e-01f, 8.93005803e-02f, -6.53933510e-02f,
  -8.13790560e-02f, -1.80467945e-02f, -1.20704127e-02f, -1.24355152e-01f, -2.06679627e-01f, 8.81307125e-02f, 1.46059319e-01f, 1.52782112e-01f, -5.21823727e-02f, 1.15526967e-01f,
  -8.60379636e-03f, 6.97440654e-02f, 1.24592610e-01f, 1.22289918e-01f, -4.30096462e-02f, -1.43879250e-01f, 9.85181928e-02f, -1.38355225e-01f, -1.49781674e-01f, 1.77879691e-01f,
  -7.88927749e-02f, -1.74105093e-01f, -3.07073742e-02f, 1.55196898e-02f, 1.33718058e-01f, 9.19941068e-03f, 7.05802813e-02f, -1.50469631e-01f, -2.57943273e-01f, 7.69762248e-02f,
  2.58204564e-02f, -6.42944500e-02f, -2.11494237e-01f, 2.93434143e-01f, -8.93514454e-02f, -2.08895624e-01f, 3.28943506e-02f, 3.02890837e-01f, 7.07948580e-02f, -1.08251713e-01f,
  -4.54049371e-02f, -1.87441126e-01f, -1.48392037e-01f, -4.25385535e-02f, -1.21900655e-01f, 5.00873439e-02f, -3.55932559e-03f, 6.73098266e-02f, 7.90878374e-04f, 3.42148319e-02f,
  1.85022429e-01f, 9.51930583e-02f, -1.49831055e-02f, -9.44011360e-02f, 1.51317000e-01f, -1.65424064e-01f, -9.59252566e-02f, 2.31961176e-01f, -9.26611573e-02f, -1.19323850e-01f,
  4.44391668e-02f, 5.20117730e-02f, 2.40912572e-01f, 1.34879932e-01f, 1.99093878e-01f, -7.62616768e-02f, 2.23472547e-02f, -1.15324669e-01f, 2.09225751e-02f, 1.53857812e-01f,
  -5.67700416e-02f, 3.97428982e-02f, -9.87842456e-02f, 2.93388776e-02f, 1.49501219e-01f, 1.41457170e-01f, -6.19221330e-02f, -8.22045878e-02f, 3.34081240e-03f, 1.44091263e-01f,
  -3.58218104e-02f, -3.81646827e-02f, -1.36080280e-01f, -9.81078073e-02f, 2.82846063e-01f, 1.29760370e-01f, -7.72542804e-02f, -1.31000966e-01f, 7.11804628e-02f, 1.27510682e-01f,
  -4.02696282e-02f, -1.10418648e-01f, -1.37736602e-02f, -1.57360345e-01f, -6.74879849e-02f, -1.62755400e-01f, -5.86013272e-02f, 1.32404551e-01f, -2.43229941e-01f, 3.68688196e-01f,
  -5.74216284e-02f, 7.92289302e-02f, -1.02680981e-01f, 6.37775660e-02f, 1.30450241e-02f, 8.40137526e-02f, 2.06241593e-01f, 1.41506284e-01f, 1.87079459e-01f, 1.39847681e-01f,
  -4.20053750e-02f, 1.64470017e-01f, 1.42186731e-01f, -1.47876725e-01f, -7.61773959e-02f, 5.51132858e-02f, 2.76269704e-01f, 1.85387328e-01f, -2.00581402e-01f, -1.82060272e-01f,
  1.35930687e-01f, 2.59852171e-01f, 5.63043393e-02f, 1.72550216e-01f, -1.51534140e-01f, 1.85477808e-01f, 3.65813971e-02f, 2.29039475e-01f, -1.41239583e-01f, 1.09622739e-01f,
  -2.54571855e-01f, 1.68129802e-01f, 9.64467898e-02f, -9.61695984e-02f, 8.70249048e-03f, -5.31248599e-02f, 3.35359238e-02f, 7.79479817e-02f, -1.04994737e-01f, 1.11471049e-01f,
  -1.40185533e-02f, -1.31475016e-01f, 1.13655031e-02f, 2.84188926e-01f, -8.17031786e-02f, -4.21525016e-02f, 2.73882657e-01f, -5.96441105e-02f, -2.12730598e-02f, 1.01234980e-01f,
  -9.78712961e-02f, 1.74020961e-01f, -2.49601722e-01f, -9.14144292e-02f
};

// L1_fan_Wp_bar (Shape: 52 x 64)
const int L1_fan_Wp_bar_rows = 52;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  1.07941203e-01f, 5.19764759e-02f, 1.20628290e-01f, 1.42983019e-01f, 1.15617193e-01f, 2.40384676e-02f, -1.68268997e-02f, -2.41353303e-01f, -1.07069835e-01f, 1.08795971e-01f,
  1.94854125e-01f, -4.03763533e-01f, 7.09470883e-02f, -3.23111750e-03f, 1.66874424e-01f, 5.51323146e-02f, 1.81767866e-01f, -1.49743333e-01f, 1.57114998e-01f, 1.35326937e-01f,
  8.57566819e-02f, 2.46410016e-02f, -8.15168098e-02f, -3.21430564e-02f, -1.29355505e-01f, 3.90876010e-02f, 2.71108538e-01f, 3.55864875e-02f, -7.28449598e-02f, 3.01834106e-01f,
  2.40243953e-02f, 8.23262930e-02f, 1.63553897e-02f, 2.13338025e-02f, -1.38495594e-01f, -3.86245884e-02f, -1.59536496e-01f, 2.99232882e-02f, 7.28797242e-02f, -8.94087777e-02f,
  1.23163708e-01f, -3.13795060e-02f, 9.26122516e-02f, 1.77381355e-02f, -4.17011082e-02f, -1.05313696e-01f, 1.29340455e-01f, 8.76566991e-02f, -4.31023389e-02f, -1.78687170e-01f,
  2.44501475e-02f, -4.20813039e-02f, 6.86520115e-02f, -9.08700228e-02f, -6.05454147e-02f, -6.25333339e-02f, 1.48370609e-01f, 1.44350946e-01f, -1.71703041e-01f, 2.66770184e-01f,
  -6.57632574e-02f, -3.32913734e-02f, -1.57997999e-02f, 1.60774201e-01f, -4.78047766e-02f, 6.94193020e-02f, -5.01916595e-02f, 1.03104850e-02f, 9.74964127e-02f, 1.93131536e-01f,
  2.46792268e-02f, 1.96821213e-01f, -1.91891462e-01f, -4.78286631e-02f, 2.01533642e-02f, 2.36608796e-02f, 2.99637258e-01f, -5.59445024e-02f, -9.75754559e-02f, -6.07676655e-02f,
  1.12360939e-01f, 1.25333965e-01f, -3.51455137e-02f, -9.10140574e-02f, -1.67032123e-01f, 9.61003304e-02f, 1.53987333e-01f, 7.31167197e-02f, -5.10871261e-02f, -7.97106326e-02f,
  2.63660192e-01f, -9.20391083e-02f, 1.56289294e-01f, -7.86344036e-02f, -7.16918483e-02f, 2.29071677e-01f, 4.09555696e-02f, 7.93113336e-02f, 1.14558619e-02f, 2.51857847e-01f,
  7.23121986e-02f, 3.31342965e-01f, 1.26258563e-02f, 4.82545458e-02f, 1.39996544e-01f, -8.84898603e-02f, 3.27821299e-02f, -1.44856097e-02f, 1.25978291e-01f, 1.26968935e-01f,
  2.30608154e-02f, -1.10697471e-01f, -5.19671626e-02f, 1.40554041e-01f, -4.86883670e-02f, -2.98991185e-02f, 1.82213828e-01f, -1.23965599e-01f, -3.81557248e-03f, 1.31335676e-01f,
  1.81610614e-01f, -9.01378468e-02f, -9.52855349e-02f, 6.75297901e-02f, -1.80247396e-01f, 2.41619304e-01f, 6.16829023e-02f, 1.17114238e-01f, -4.52535041e-02f, 1.11680683e-02f,
  -4.90688197e-02f, -3.51054668e-02f, 1.12427264e-01f, -2.09395334e-01f, 3.98001671e-02f, 1.72633320e-01f, 4.31599356e-02f, -9.99943465e-02f, -9.67690051e-02f, 1.48114204e-01f,
  -1.23135060e-01f, -5.21702431e-02f, 7.98220262e-02f, -4.79613543e-02f, 1.11010663e-01f, 7.36552477e-02f, -4.27599289e-02f, -6.73174933e-02f, 1.81872083e-03f, -1.12306215e-01f,
  -1.13312811e-01f, -3.57068069e-02f, -5.59227914e-02f, 4.94722053e-02f, 1.61792621e-01f, -4.41559777e-02f, -1.52142629e-01f, -2.08889674e-02f, 2.34499611e-02f, 2.60671228e-01f,
  -1.31583452e-01f, -5.96468076e-02f, -1.30411759e-01f, -1.28164440e-01f, 1.77885830e-01f, 1.25025362e-01f, 2.64659952e-02f, 2.24505350e-01f, 1.05168915e-03f, 6.77649900e-02f,
  -7.47846020e-03f, -3.59319933e-02f, -1.25359610e-01f, -4.05127928e-02f, -1.00348532e-01f, 5.66671491e-02f, 2.06058145e-01f, 5.47075793e-02f, 8.19914266e-02f, 7.76172355e-02f,
  -9.71069261e-02f, 2.56918013e-01f, 4.56889272e-02f, 4.55311649e-02f, 8.18655863e-02f, 4.68180440e-02f, 2.64633566e-01f, 1.60225034e-01f, 1.04238205e-01f, -1.08256117e-01f,
  -1.43367559e-01f, -1.01899914e-01f, 2.21711025e-01f, 1.25878692e-01f, 1.16929799e-01f, 2.12438285e-01f, 1.27229065e-01f, 3.43234658e-01f, 1.66642323e-01f, -2.59478420e-01f,
  1.29978240e-01f, 2.32563347e-01f, 1.46673024e-01f, -7.44248852e-02f, -1.53439626e-01f, 4.46740165e-02f, 3.61153692e-01f, 4.32038307e-01f, 2.01212391e-01f, 9.29756183e-03f,
  1.64535254e-01f, 6.11381256e-04f, 1.43157929e-01f, -6.65664598e-02f, -3.53292115e-02f, -1.41222596e-01f, -4.09203954e-02f, 1.18157007e-01f, 1.62234396e-01f, 2.54120588e-01f,
  -1.20808192e-01f, 1.28491074e-01f, 2.51618803e-01f, -1.42684177e-01f, 1.78134486e-01f, 3.34610380e-02f, -7.57278427e-02f, -5.78174405e-02f, 1.83367971e-02f, -1.40676811e-01f,
  -1.80242762e-01f, 1.87630102e-01f, -7.89585784e-02f, 2.71898266e-02f, 1.06016628e-01f, -1.48165420e-01f, -3.09542343e-02f, -1.85112625e-01f, 1.83907468e-02f, 2.14827344e-01f,
  -5.37846684e-02f, -1.26224756e-01f, -1.01461813e-01f, 1.51492834e-01f, 1.35326326e-01f, 1.52220041e-01f, 1.71809234e-02f, 5.99717423e-02f, 5.87160848e-02f, 1.99044541e-01f,
  -3.18588704e-01f, -3.49405669e-02f, 2.54239619e-01f, -7.32665062e-02f, -1.39280394e-01f, -5.44015132e-02f, 1.97264794e-02f, 1.81933820e-01f, -5.35113476e-02f, 1.36511728e-01f,
  7.28607103e-02f, 6.04006276e-02f, 2.29250044e-01f, 1.13864869e-01f, 3.83430682e-02f, 1.70576170e-01f, 5.87658286e-02f, 1.47677839e-01f, 3.98656353e-03f, 1.07517757e-01f,
  -1.09086208e-01f, -9.34152380e-02f, 1.13366500e-01f, 9.73952115e-02f, -1.11154132e-02f, -8.91573727e-02f, -3.39087956e-02f, -5.48510486e-03f, 7.07366243e-02f, -5.93293868e-02f,
  -4.59471345e-02f, -1.88221540e-02f, -1.02325432e-01f, 2.22943574e-02f, -6.87797070e-02f, -1.60014346e-01f, -1.48876458e-02f, 1.19064532e-01f, 1.08572967e-01f, -3.87403220e-02f,
  2.96286400e-02f, -3.51119749e-02f, 1.12410925e-01f, 7.86043610e-03f, 1.25539219e-02f, -1.01813199e-02f, -2.60064453e-02f, 4.66983318e-02f, 4.92495224e-02f, -1.38538003e-01f,
  4.76180278e-02f, -1.21191358e-02f, 2.65210904e-02f, -1.59175899e-02f, -1.23125471e-01f, -3.31917405e-02f, -7.92894289e-02f, -8.97753835e-02f, 5.39878458e-02f, -1.08558200e-01f,
  -1.20929122e-01f, -1.67631343e-01f, 6.09754175e-02f, -1.25118438e-02f, -1.59488842e-01f, -5.86485974e-02f, 1.96348086e-01f, -6.52702153e-02f, -1.62482470e-01f, -2.16739178e-02f,
  -9.00157262e-03f, 7.09745958e-02f, 1.12939671e-01f, 1.11986831e-01f, 9.60804820e-02f, 1.60890982e-01f, 9.17265862e-02f, -2.17714041e-01f, 6.41721562e-02f, -9.39916447e-02f,
  2.41224259e-01f, -2.49227047e-01f, -5.91862388e-02f, -3.12891416e-02f, 1.32031515e-01f, 1.94895267e-01f, 1.39429379e-04f, -7.48140290e-02f, 4.05796207e-02f, -3.83871864e-03f,
  9.12550688e-02f, 5.19746123e-03f, -9.55015719e-02f, 1.71739683e-02f, 8.30026418e-02f, -9.67371613e-02f, 3.01804021e-02f, -2.62652570e-03f, -4.80063781e-02f, 2.03490511e-01f,
  -7.82591477e-02f, -8.32812712e-02f, -1.19274169e-01f, 6.43167794e-02f, -2.55229417e-02f, -3.62180434e-02f, -6.59698099e-02f, -1.28553808e-01f, -1.18258856e-01f, -1.07499383e-01f,
  1.72280267e-01f, 7.62468427e-02f, -5.36711141e-02f, -1.07408687e-01f, 1.69782471e-02f, -3.28424498e-02f, 1.14682809e-01f, -6.96847290e-02f, 2.95510907e-02f, -1.94426194e-01f,
  4.97820079e-02f, 5.87102100e-02f, 1.09027743e-01f, 2.03176551e-02f, 9.53953117e-02f, -3.03240400e-02f, 8.13998654e-02f, 1.05242133e-01f, -2.35089138e-02f, -4.73060980e-02f,
  3.80880758e-02f, -6.82102218e-02f, 1.21829011e-01f, 1.54897571e-01f, 1.69712156e-02f, -1.22524962e-01f, 8.50305930e-02f, -9.40149054e-02f, 6.64393827e-02f, 1.57829672e-02f,
  1.57309115e-01f, -8.02036375e-02f, 6.49849549e-02f, 1.92353100e-01f, -3.88956890e-02f, -1.21541314e-01f, -8.88117850e-02f, -9.16070342e-02f, 8.06663334e-02f, 1.10488892e-01f,
  -1.00372128e-01f, -6.61439449e-02f, 8.24428499e-02f, -6.87808767e-02f, 8.33984688e-02f, 1.64278597e-02f, 4.74554226e-02f, -1.28935382e-01f, 2.77333576e-02f, -4.06180136e-02f,
  2.52778232e-01f, 9.45182666e-02f, -1.46080747e-01f, -1.54937118e-01f, -2.91023985e-03f, -8.62307101e-02f, -7.84991905e-02f, 2.08657563e-01f, -1.16297007e-01f, -1.85817461e-02f,
  -2.11803745e-02f, 1.33300751e-01f, 5.46848848e-02f, 3.12372148e-02f, -8.19389820e-02f, -1.02225631e-01f, -1.21319322e-02f, -6.30149618e-02f, -1.20282864e-04f, 5.94790690e-02f,
  7.21073970e-02f, -1.32138491e-01f, 1.65994279e-02f, 2.17426419e-02f, 2.64062211e-02f, 5.93601204e-02f, -1.69165991e-02f, 1.17189139e-01f, -8.82483944e-02f, -7.65269771e-02f,
  1.25996292e-01f, 4.12351750e-02f, 1.36984304e-01f, 1.29419208e-01f, -1.67821929e-01f, 3.67285721e-02f, 5.11295684e-02f, -3.20525933e-03f, 1.25470713e-01f, 1.61828399e-01f,
  3.39387059e-02f, 1.65085524e-01f, 4.01189253e-02f, 1.70635220e-04f, -1.30854681e-01f, 5.56287020e-02f, -1.85059495e-02f, -1.76155497e-03f, -1.71428636e-01f, 3.70583497e-02f,
  1.80023149e-01f, -3.51266600e-02f, -1.05833776e-01f, -1.40692383e-01f, -5.06804697e-03f, 1.00311823e-01f, 1.31984755e-01f, 6.45024776e-02f, -5.00511639e-02f, 8.21176842e-02f,
  7.62900785e-02f, 4.49584983e-02f, 1.26020849e-01f, -1.02268964e-01f, 5.99343926e-02f, -7.79558122e-02f, 5.46992309e-02f, -1.01469785e-01f, 1.99091085e-03f, 4.57939431e-02f,
  1.10916972e-01f, 6.47443086e-02f, -5.56592084e-02f, 1.12773210e-01f, 1.43042862e-01f, 1.01157218e-01f, 1.15196966e-01f, 6.40583634e-02f, 1.99011922e-01f, -7.15433434e-02f,
  1.11522011e-01f, -8.75486434e-02f, -8.39616433e-02f, 5.72741404e-02f, 1.17558375e-01f, -1.26027182e-01f, -2.63978215e-03f, -8.77473410e-03f, 1.41502619e-02f, -1.31478533e-01f,
  7.00571314e-02f, -1.20804727e-01f, -1.27505913e-01f, -7.54817426e-02f, 4.14643297e-03f, 7.78748561e-03f, 1.91544637e-01f, -1.22881299e-02f, 2.79394500e-02f, -9.87786651e-02f,
  1.65794522e-01f, 2.18086258e-01f, 9.53639820e-02f, 4.32117581e-02f, -6.24262691e-02f, 3.52095738e-02f, 3.54303718e-02f, -1.35402521e-02f, 1.34582967e-01f, -1.94821209e-01f,
  2.56526694e-02f, -1.65926531e-01f, 1.31478623e-01f, -1.30723519e-02f, 3.55203189e-02f, 9.03068557e-02f, 1.39166638e-01f, -4.65545021e-02f, 6.80467486e-02f, 1.09004304e-02f,
  -8.81685838e-02f, -8.72660279e-02f, 8.17740485e-02f, -7.91502818e-02f, -8.77188444e-02f, 1.10264704e-01f, 9.83001962e-02f, -8.13917443e-02f, -3.42419669e-02f, -6.95005432e-02f,
  1.04946926e-01f, 8.03476274e-02f, -3.24860699e-02f, -1.10435419e-01f, 1.05407923e-01f, -7.04588019e-04f, -1.10683054e-01f, 1.05036989e-01f, 5.86662926e-02f, -2.93666907e-02f,
  -9.43964422e-02f, -1.13029353e-01f, 3.82537358e-02f, 2.51566563e-02f, 7.90441558e-02f, 1.90049363e-03f, -1.29484793e-03f, -9.49081779e-02f, 7.81683717e-03f, -3.00509501e-02f,
  -8.48228708e-02f, -9.19797868e-02f, 1.14784241e-01f, 2.44148001e-01f, -1.27934724e-01f, -5.75523376e-02f, 2.03653336e-01f, -9.31728110e-02f, -5.99853434e-02f, -9.79326367e-02f,
  5.57181239e-02f, -1.09666832e-01f, 1.24641910e-01f, -6.40654564e-02f, -8.05563480e-02f, -1.07815668e-01f, 2.11951643e-01f, 3.51704732e-02f, 1.05661198e-01f, 1.73298493e-01f,
  1.60929107e-03f, 2.05001961e-02f, 9.46279541e-02f, 9.56392065e-02f, 2.95671392e-02f, 1.23419233e-01f, -7.94119015e-02f, 8.42766091e-02f, -1.36239722e-01f, -3.09376568e-02f,
  1.00647867e-01f, 1.37650028e-01f, 1.65543810e-01f, 2.75858380e-02f, -2.18000207e-02f, 6.54865950e-02f, 1.53829247e-01f, -3.91218299e-03f, 7.29941577e-02f, -7.71619305e-02f,
  -1.07196972e-01f, 9.36007649e-02f, -8.63240808e-02f, -6.96619926e-03f, 3.25555950e-02f, 1.97771952e-01f, 1.67229269e-02f, 3.42064165e-02f, 9.14406478e-02f, -1.32424995e-01f,
  -2.47462653e-03f, -1.33734152e-01f, 5.23040444e-02f, 2.93980706e-02f, 1.66378748e-02f, 1.14823923e-01f, 8.63179788e-02f, -1.12678461e-01f, 5.71976118e-02f, -3.30866165e-02f,
  -3.19327377e-02f, 9.60234404e-02f, 3.58361155e-02f, -7.97455236e-02f, 7.78713673e-02f, -3.17209102e-02f, -7.74099305e-02f, -3.06037460e-02f, -1.36107923e-02f, 1.35221899e-01f,
  -1.16112590e-01f, 1.77903786e-01f, 1.17615826e-01f, 8.97252485e-02f, -1.05245620e-01f, -4.61597107e-02f, -6.51367307e-02f, -7.66080767e-02f, -1.38982952e-01f, -7.03074262e-02f,
  1.92961767e-02f, 1.54153168e-01f, 3.33198532e-02f, 1.08908691e-01f, 5.92444725e-02f, -1.58971503e-01f, -7.48957768e-02f, 9.38255936e-02f, 1.52476981e-01f, -1.07526936e-01f,
  1.77171663e-03f, 1.41090155e-01f, 2.73535307e-02f, 3.20058763e-02f, -2.04777549e-04f, 6.36146069e-02f, 1.11436658e-01f, -1.46051064e-01f, -3.13974023e-02f, 3.40089723e-02f,
  5.78454547e-02f, -1.19100444e-01f, -5.06624095e-02f, -5.70604801e-02f, 9.54304449e-03f, 1.76822077e-02f, -2.26035826e-02f, 6.88980222e-02f, -1.42120615e-01f, -8.18102658e-02f,
  3.57529446e-02f, 4.01642174e-02f, 5.01219518e-02f, -5.59243336e-02f, -8.55519176e-02f, 4.69563669e-03f, 8.71508792e-02f, -1.11666031e-01f, 9.65743884e-02f, 5.07684350e-02f,
  -2.59012561e-02f, -5.25526702e-02f, -6.14476763e-02f, -4.35578972e-02f, 3.16718183e-02f, -1.20987117e-01f, 1.26838312e-01f, -1.76230427e-02f, 2.03211643e-02f, -9.57522076e-03f,
  -8.82159770e-02f, -1.04553685e-01f, 8.60989317e-02f, -6.29107356e-02f, -1.18036410e-02f, 4.28504162e-02f, -1.40682951e-01f, -1.94497854e-02f, 2.18608603e-01f, -4.01393548e-02f,
  -3.62724327e-02f, -1.19929940e-01f, -1.05505601e-01f, -2.15461943e-02f, 1.38212755e-01f, -7.15289488e-02f, -9.19725280e-03f, 4.97984514e-02f, 2.48202756e-02f, 2.87416093e-02f,
  -8.05757046e-02f, 6.73988760e-02f, 1.07418718e-02f, 2.33459603e-02f, -7.96073675e-02f, -4.04427648e-02f, 1.15169110e-02f, 9.60886776e-02f, 1.19991414e-01f, 1.90955624e-01f,
  6.84677884e-02f, 8.71544704e-02f, -2.62724496e-02f, 5.34988455e-02f, -2.93445066e-02f, -1.39117064e-02f, 2.47917790e-02f, -2.50939596e-02f, -1.00096010e-01f, -2.34888326e-02f,
  -5.70520351e-04f, 1.05845019e-01f, -6.35321736e-02f, 2.06716970e-01f, 5.57982661e-02f, -9.26422402e-02f, -1.67610776e-02f, -1.31036729e-01f, 4.86149006e-02f, -1.01315305e-01f,
  -2.51062913e-03f, -3.06395553e-02f, -1.21923313e-01f, 1.53464705e-01f, -5.95496632e-02f, 5.98837920e-02f, -5.35415150e-02f, 6.65650666e-02f, -9.22949836e-02f, -5.28584979e-02f,
  1.23050168e-01f, 8.69976655e-02f, 7.83157945e-02f, -1.09432004e-01f, -1.07594192e-01f, -8.27014260e-03f, -9.08035412e-02f, 1.77537333e-02f, 8.98331180e-02f, -3.35072465e-02f,
  3.27181816e-02f, 1.55110821e-01f, -5.02461232e-02f, 1.95195191e-02f, -1.10258155e-01f, 7.93343633e-02f, 4.23426740e-03f, 4.26424928e-02f, 8.11137445e-03f, 3.50334011e-02f,
  2.15317801e-01f, -5.98092703e-03f, 1.33095225e-02f, 3.92479189e-02f, 3.25988799e-01f, -1.36819556e-01f, 2.28216842e-01f, 1.31288558e-01f, 3.47412765e-01f, -1.86504442e-02f,
  3.18488702e-02f, -5.02054989e-02f, 1.48874477e-01f, -1.95352850e-03f, -1.50034241e-02f, 2.11652908e-02f, 1.13372922e-01f, 1.65572628e-01f, -1.21159770e-01f, 6.30464330e-02f,
  -8.86180177e-02f, 2.19081298e-01f, -1.13665722e-01f, 1.40415356e-01f, 4.24123138e-01f, -1.46380980e-02f, -1.59975335e-01f, -1.91706538e-01f, -1.15969025e-01f, 7.77678266e-02f,
  4.07129675e-02f, 2.91225374e-01f, 9.74089503e-02f, 8.93877819e-04f, -6.07603155e-02f, -1.38731617e-02f, -1.91373564e-02f, -1.10612310e-01f, -1.22583695e-01f, -8.37061778e-02f,
  -7.71584874e-03f, -1.24920249e-01f, 2.60997176e-01f, 3.09604317e-01f, 1.11591548e-01f, -1.42801940e-01f, -1.25958160e-01f, 6.83932528e-02f, 1.67622432e-01f, 1.77140877e-01f,
  1.33480012e-01f, 3.00542098e-02f, 8.76416266e-02f, -6.48936629e-02f, 2.73379803e-01f, 3.01608685e-02f, -3.58176492e-02f, 1.52462870e-01f, -1.38691198e-02f, 1.29913598e-01f,
  -6.42989948e-02f, 5.32205589e-02f, 2.15937316e-01f, 5.16461618e-02f, 1.23291034e-02f, 1.72798216e-01f, 2.68538266e-01f, 2.31875405e-02f, -2.36614704e-01f, 8.15799981e-02f,
  7.24868011e-03f, -2.06503674e-01f, -1.44629121e-01f, -4.85070050e-02f, -1.32827401e-01f, 3.11553143e-02f, 5.86291328e-02f, 1.65849566e-01f, 1.09559558e-01f, -2.49393173e-02f,
  3.49692516e-02f, -1.37812302e-01f, 1.84730440e-01f, -1.78814441e-01f, -8.26527923e-02f, -6.39099404e-02f, -1.54041722e-01f, -6.39667809e-02f, 5.32444241e-03f, 1.67461216e-01f,
  -7.14446977e-02f, 4.13927466e-01f, 1.37777895e-01f, 1.76144689e-01f, 1.29572839e-01f, -8.92311856e-02f, -1.86666086e-01f, -8.52113217e-02f, -8.42510462e-02f, 7.24693611e-02f,
  -2.86703743e-02f, 8.46859738e-02f, 1.50920168e-01f, -4.67892289e-02f, 4.59747314e-02f, -1.82683207e-02f, -1.43226497e-02f, -1.03107937e-01f, -8.75433534e-02f, -9.68693048e-02f,
  1.62111297e-01f, -1.34528279e-01f, -1.19536407e-01f, 8.13675523e-02f, 1.14573359e-01f, 1.22106791e-01f, -6.33036494e-02f, -1.85555257e-02f, -1.04263924e-01f, -4.33362760e-02f,
  1.14221305e-01f, 2.19898507e-01f, 9.38052386e-02f, 7.66873211e-02f, -1.25326335e-01f, 8.25550482e-02f, 9.84510705e-02f, 8.57907906e-02f, 3.95885073e-02f, -4.30127233e-02f,
  3.28059159e-02f, 2.62102306e-01f, -3.02554697e-01f, -7.88422152e-02f, -2.60667205e-01f, -1.57987565e-01f, -1.57416224e-01f, -3.98820713e-02f, 2.21701413e-01f, 4.25849073e-02f,
  -8.39759409e-02f, -6.14223294e-02f, -2.57787071e-02f, 8.02125484e-02f, -1.74912453e-01f, -1.32182822e-01f, 5.33577204e-02f, 9.31380168e-02f, 2.06470452e-02f, 2.83851057e-01f,
  -2.45527532e-02f, 4.11044732e-02f, 1.00913458e-02f, 3.73008102e-02f, 2.14472800e-01f, 6.41791895e-02f, -2.65356764e-04f, 6.33739382e-02f, 1.00105688e-01f, -1.37507552e-02f,
  -3.80802378e-02f, -7.81654939e-02f, 1.27742320e-01f, 1.69482939e-02f, 1.52391389e-01f, -1.75044294e-02f, 1.63614005e-01f, 6.36405051e-02f, -1.02629229e-01f, 9.02965963e-02f,
  6.95888922e-02f, -9.97337326e-03f, -1.34171531e-01f, 2.43834965e-02f, -1.26593918e-01f, 1.30018398e-01f, 2.46460196e-02f, -1.84461281e-01f, 2.00696960e-01f, -4.58755791e-02f,
  8.68826136e-02f, 9.52965170e-02f, -1.33110853e-02f, 1.15764394e-01f, -7.17594475e-02f, 1.10539272e-01f, 1.84941143e-02f, 9.26086977e-02f, 3.04328024e-01f, 1.74321041e-01f,
  3.15422677e-02f, -7.04364330e-02f, 1.27922028e-01f, 1.11394778e-01f, -1.01530530e-01f, -6.26110584e-02f, 1.63614050e-01f, -1.27776220e-01f, 6.88432455e-02f, 2.86130775e-02f,
  1.93903193e-01f, 4.61920835e-02f, -1.45005984e-02f, -3.08682248e-02f, 1.28758430e-01f, 1.42485753e-01f, -1.07627556e-01f, 7.25232884e-02f, -1.27912536e-02f, 7.10624903e-02f,
  9.54283699e-02f, -7.33851939e-02f, -1.37426719e-01f, 1.05262823e-01f, -9.94147137e-02f, 4.52200510e-02f, -1.63686201e-01f, 3.94789912e-02f, 9.11712348e-02f, 2.13639006e-01f,
  -3.79867107e-02f, 1.02305822e-01f, -5.89584745e-03f, 1.00919949e-02f, -1.07769832e-01f, 5.95862456e-02f, -8.95023867e-02f, 2.01298315e-02f, -1.08068608e-01f, 5.18158935e-02f,
  -6.52332753e-02f, 1.28262907e-01f, 1.06427394e-01f, -1.47424653e-01f, 4.34159972e-02f, 2.69389171e-02f, -7.45636672e-02f, 1.99480038e-02f, -4.64990549e-02f, -9.89717022e-02f,
  1.17345884e-01f, 2.33769119e-01f, -1.44898027e-01f, 7.41770789e-02f, 8.37576687e-02f, 4.25024852e-02f, -1.53667122e-01f, 1.41062394e-01f, -2.08722129e-02f, -2.45291386e-02f,
  -2.70811170e-02f, 1.67088006e-02f, -1.14730477e-01f, 8.86921585e-02f, -6.39125705e-02f, 1.38676509e-01f, 7.09086433e-02f, 5.87802529e-02f, 1.43243715e-01f, -5.00229970e-02f,
  6.59023151e-02f, 1.16079021e-02f, 2.22028270e-01f, -1.73860919e-02f, 1.33243755e-01f, 6.46464080e-02f, -1.43213406e-01f, -6.77363423e-04f, 8.44040215e-02f, 1.37218207e-01f,
  5.61243892e-02f, -1.08746141e-01f, -1.60270289e-01f, -9.51427296e-02f, 1.57249600e-01f, 2.53343862e-02f, 9.13258493e-02f, 4.22812765e-03f, 7.62789175e-02f, 9.91692767e-02f,
  5.76387569e-02f, -7.15684891e-02f, 2.70031877e-02f, 1.15998074e-01f, -1.36378631e-01f, -9.51955318e-02f, 7.68555403e-02f, 4.63958047e-02f, 3.03776525e-02f, 9.83213335e-02f,
  1.63089484e-01f, -8.20789039e-02f, 1.13408834e-01f, -4.67946101e-03f, 6.94986358e-02f, -9.13483202e-02f, -1.01306058e-01f, -1.11714236e-01f, -8.39058533e-02f, -3.64449657e-02f,
  -6.52846619e-02f, -4.54786643e-02f, 1.17845200e-01f, -2.46624369e-02f, -1.11154273e-01f, 9.22107548e-02f, 4.14948352e-02f, 1.41618878e-01f, -9.85602364e-02f, 4.58496064e-02f,
  -6.86923340e-02f, -8.60551894e-02f, 3.14930439e-01f, -9.80039313e-02f, 3.63686755e-02f, -8.00553784e-02f, -4.05847803e-02f, 7.48416260e-02f, -5.67381270e-02f, -2.07111333e-02f,
  1.17919460e-01f, -1.50377620e-02f, 1.64902627e-01f, 4.74191681e-02f, 1.08254403e-01f, -1.59979701e-01f, -3.46623324e-02f, -2.77794674e-02f, 9.18752998e-02f, -6.27208278e-02f,
  4.30759527e-02f, -1.51454918e-02f, 5.70507646e-02f, 1.24924600e-01f, 3.06122582e-02f, -3.17812301e-02f, 1.85056124e-02f, -1.33065339e-02f, 5.62050492e-02f, 1.20814666e-02f,
  1.27882184e-02f, -1.82814430e-02f, 3.57329622e-02f, 1.42557248e-01f, 3.62985246e-02f, 9.68933329e-02f, 4.56598513e-02f, 1.90834150e-01f, 6.09825328e-02f, 3.67939137e-02f,
  1.06428854e-01f, 4.53999788e-02f, -5.58610680e-03f, 9.90657415e-03f, -7.77017251e-02f, -1.02013677e-01f, -6.72591925e-02f, -1.31626293e-01f, 1.20928586e-01f, 1.05194621e-01f,
  8.99513066e-02f, 8.47027227e-02f, 6.88530505e-02f, 2.95166019e-02f, -6.98994026e-02f, -2.99404133e-02f, -1.05494641e-01f, 8.75111390e-03f, -1.11280285e-01f, 4.47411686e-02f,
  -8.02156236e-03f, -1.56998020e-02f, 1.32850170e-01f, -8.90255067e-03f, -1.15335830e-01f, 8.75248294e-03f, 3.32741886e-02f, -9.82054397e-02f, -1.37879714e-01f, 8.22619721e-03f,
  8.78763571e-02f, 2.96830516e-02f, 2.02269495e-01f, 2.13936687e-01f, 2.55719155e-01f, -3.47830802e-02f, 2.77032673e-01f, 2.69185156e-01f, 8.75406936e-02f, 1.13108039e-01f,
  -1.33005574e-01f, -1.88965872e-02f, 2.25508790e-02f, -9.41096023e-02f, 8.09533969e-02f, -1.35678843e-01f, -2.25369439e-01f, -9.25556943e-02f, 2.32403189e-01f, 1.16280295e-01f,
  3.14468481e-02f, -6.75693750e-02f, -1.48924306e-01f, -3.36731263e-02f, 5.78834526e-02f, 9.75877494e-02f, 8.87211785e-02f, 3.56835648e-02f, 3.70137155e-01f, 7.23068863e-02f,
  -4.27683219e-02f, 5.50878830e-02f, 1.26997950e-02f, 1.82196781e-01f, 4.23947051e-02f, -3.32572497e-02f, -4.04458828e-02f, -1.37280583e-01f, 9.89966374e-03f, 9.80552360e-02f,
  -6.70395941e-02f, 6.47391528e-02f, 1.39930798e-02f, -7.19483644e-02f, 2.62741923e-01f, -1.33548245e-01f, -4.22125980e-02f, -1.07847966e-01f, -8.84216428e-02f, -8.10298137e-03f,
  1.31933585e-01f, 8.94536600e-02f, -1.11592151e-01f, -1.50827423e-01f, 5.67289703e-02f, 7.63295870e-03f, -1.37165278e-01f, 6.86859200e-03f, 1.64249480e-01f, 7.23403469e-02f,
  -1.32896885e-01f, 1.29645914e-01f, 2.51112550e-01f, -2.51994305e-03f, 1.53782010e-01f, 1.52951062e-01f, 2.37843990e-02f, -7.11106136e-02f, 1.12588435e-01f, 1.21097423e-01f,
  -6.46524364e-04f, 1.08070120e-01f, -3.96714285e-02f, 7.59143904e-02f, 1.33276477e-01f, -1.36106163e-01f, -1.06526434e-01f, -6.87885191e-03f, 4.16531861e-02f, -1.24682784e-01f,
  -2.48432159e-02f, -1.51937872e-01f, -4.87677306e-02f, 8.50805268e-02f, 1.32228613e-01f, -6.35793656e-02f, -5.98666035e-02f, -1.03736609e-01f, 6.67996556e-02f, -5.14585003e-02f,
  6.92454353e-02f, 1.29874140e-01f, -9.46145132e-03f, -4.26896848e-02f, 7.77939558e-02f, -7.92435706e-02f, 2.06398983e-02f, -6.39931706e-04f, 5.73922060e-02f, 1.00313164e-01f,
  -4.41849083e-02f, 3.49698402e-02f, 1.97985042e-02f, -5.71156256e-02f, 2.54193600e-02f, 9.21010748e-02f, 4.86721210e-02f, -4.82341498e-02f, -2.91208327e-02f, 9.82927755e-02f,
  5.95926493e-02f, 6.25262409e-02f, -9.04987939e-03f, -6.58101514e-02f, 1.51862621e-01f, -1.88977271e-02f, 1.07684277e-01f, 9.09365639e-02f, -8.34965035e-02f, -5.06653972e-02f,
  3.30913775e-02f, -9.76251215e-02f, -8.22091922e-02f, -5.37000671e-02f, 1.58409834e-01f, 1.00721128e-01f, 1.96478471e-01f, 4.92798053e-02f, 1.11593187e-01f, 1.28791824e-01f,
  2.22048342e-01f, 1.91877067e-01f, 2.03645229e-01f, 5.42371981e-02f, -2.58577447e-02f, 9.34527293e-02f, 6.59056008e-02f, -1.03287220e-01f, 8.42371657e-02f, -1.11776195e-01f,
  -3.22209485e-03f, 3.08129787e-01f, 3.48291243e-03f, -6.26915470e-02f, 1.04778975e-01f, 1.48618728e-01f, 7.09240213e-02f, 5.23184761e-02f, -1.57783598e-01f, -1.16790280e-01f,
  3.27507913e-01f, -1.10464431e-01f, -7.03090653e-02f, 2.08642349e-01f, 7.27118701e-02f, -5.99870794e-02f, -1.26695231e-01f, 1.23083536e-02f, 1.05091386e-01f, -1.88657851e-03f,
  1.15491010e-01f, -1.95059210e-01f, -3.26868780e-02f, 1.16543345e-01f, 9.78848487e-02f, 2.24664267e-02f, 2.46817142e-01f, -1.12920523e-01f, 4.42999937e-02f, -5.47997141e-03f,
  1.22934189e-02f, 2.45377067e-02f, 6.31920621e-02f, 6.82980195e-02f, 9.77848396e-02f, 8.99340063e-02f, 2.52370499e-02f, -2.46419515e-02f, -1.60438288e-02f, 1.34496585e-01f,
  1.43574014e-01f, -8.05093944e-02f, 1.32280067e-01f, -7.33748972e-02f, -3.57513502e-02f, 5.71738295e-02f, -7.04574957e-02f, -1.49672991e-02f, 2.48550609e-01f, -1.76908553e-01f,
  -1.83769748e-01f, -1.04477145e-01f, 6.45697862e-02f, 1.23824447e-01f, -5.85836843e-02f, 8.75471234e-02f, 3.69919324e-03f, 5.99657856e-02f, 6.48866445e-02f, -1.51761577e-01f,
  -1.51794091e-01f, -4.50539868e-03f, -1.55232638e-01f, 1.32593960e-01f, 4.35627624e-02f, 5.66890948e-02f, 9.50537175e-02f, 3.29473168e-02f, 9.81841907e-02f, 1.00712620e-01f,
  -6.84855785e-03f, 5.71694113e-02f, -8.80867168e-02f, -1.28247753e-01f, -4.62878635e-03f, -5.51177040e-02f, 8.15679580e-02f, -2.30425075e-02f, -5.02942465e-02f, -9.26678106e-02f,
  3.09024841e-01f, 4.85164821e-02f, -6.31240488e-04f, -3.51155028e-02f, 2.24279463e-02f, 2.85539687e-01f, 2.81881373e-02f, 9.92273912e-02f, -9.49561745e-02f, 1.31015360e-01f,
  1.16145827e-01f, 1.41554773e-01f, 2.87908278e-02f, 1.28213018e-01f, 8.12367871e-02f, -4.29942347e-02f, -5.30086830e-02f, -6.85689300e-02f, -4.48803604e-02f, -8.93369541e-02f,
  5.06614409e-02f, -5.12649491e-02f, 1.17230482e-01f, -8.24945271e-02f, -1.36800138e-02f, 6.99775442e-02f, 1.07892744e-01f, 2.25546420e-01f, 1.10920444e-01f, -8.87400582e-02f,
  1.44280285e-01f, 6.43706173e-02f, 9.10366303e-04f, -1.40642915e-02f, 2.82970024e-03f, 1.20894827e-01f, -2.09983196e-02f, 4.55908440e-02f, 7.29113892e-02f, 3.65468040e-02f,
  2.12904508e-03f, 1.39184758e-01f, 2.88380086e-02f, 2.09631309e-01f, 2.95738373e-02f, 4.96806763e-02f, -7.22700655e-02f, -3.88408676e-02f, -2.73983628e-02f, -1.69636175e-01f,
  2.93618977e-01f, 1.23914436e-01f, -3.60566750e-02f, -1.74213454e-01f, -1.41879722e-01f, 8.50394815e-02f, -5.56680299e-02f, 9.08108894e-03f, 1.30713761e-01f, -4.43645241e-03f,
  -4.34036739e-02f, 1.70329750e-01f, 9.84503105e-02f, -5.87217100e-02f, 6.74208403e-02f, -1.58137724e-01f, 3.23059678e-01f, 5.98786622e-02f, -8.41203406e-02f, 7.05756545e-02f,
  -1.35854138e-02f, 1.50629178e-01f, -6.58065453e-02f, 1.02739416e-01f, -1.35323731e-04f, 4.12472859e-02f, 1.46673638e-02f, -2.92019602e-02f, 1.68900549e-01f, 3.28915976e-02f,
  -1.83361559e-03f, 1.61596492e-01f, 1.95732236e-01f, 1.22552022e-01f, 7.30508044e-02f, 3.85642760e-02f, -9.41298604e-02f, -2.19168030e-02f, -9.79413837e-02f, -5.56646734e-02f,
  8.19788650e-02f, -1.96074128e-01f, 1.17435388e-01f, -2.79698726e-02f, 8.24202150e-02f, -3.92357595e-02f, -1.26629189e-01f, -3.29718404e-02f, -1.87695339e-01f, -2.84242909e-02f,
  1.43409237e-01f, 1.83079243e-01f, 1.51161402e-01f, 3.72936454e-04f, 9.78958458e-02f, 3.34623791e-02f, 1.76958337e-01f, 1.58394675e-03f, -1.05951667e-01f, 1.83457062e-02f,
  -4.22365079e-03f, 5.65798096e-02f, -1.13125414e-01f, 6.90822750e-02f, -5.13278618e-02f, 1.02881648e-01f, -2.99437065e-02f, -1.10274576e-01f, 2.35856324e-02f, 9.55053642e-02f,
  -5.57573289e-02f, -8.18099752e-02f, -1.14534199e-01f, -1.16799576e-02f, 5.83775416e-02f, -4.31944691e-02f, -1.19111627e-01f, -1.39278278e-01f, -1.07036442e-01f, -1.14888594e-01f,
  9.68316346e-02f, -9.83419269e-02f, -1.14911497e-01f, 4.64434959e-02f, 1.38257116e-01f, 8.90689418e-02f, 1.05718344e-01f, -4.66230847e-02f, 1.16633646e-01f, 3.54814269e-02f,
  6.68566376e-02f, -1.09610697e-02f, -4.79550660e-02f, -3.06162741e-02f, 7.33515322e-02f, -6.17768466e-02f, -1.57275610e-02f, 4.12190668e-02f, -4.85912599e-02f, -1.03337124e-01f,
  5.20992614e-02f, 2.69230697e-02f, -4.74013537e-02f, -1.28791913e-01f, 1.45264462e-01f, -8.34667459e-02f, -3.24126258e-02f, -1.37844324e-01f, 5.00976667e-02f, -2.60421392e-02f,
  -2.83086915e-02f, -3.83839458e-02f, -1.78616308e-02f, 8.05493221e-02f, -4.01167125e-02f, 1.07001871e-01f, 4.90830606e-03f, 3.23323975e-03f, 5.07431440e-02f, -7.44560882e-02f,
  1.49628758e-01f, -8.06259513e-02f, -1.09121300e-01f, 1.08596347e-02f, 5.43272719e-02f, -1.74394935e-01f, -6.36315644e-02f, 1.68231308e-01f, 7.02569932e-02f, 9.71403942e-02f,
  -3.07456069e-02f, -1.06628112e-01f, 9.75386128e-02f, -1.71735417e-02f, -4.58725058e-02f, 5.50221801e-02f, 6.82001188e-02f, 6.35641739e-02f, 9.63700935e-02f, 1.56511724e-01f,
  -8.53730645e-03f, 1.40205055e-01f, -8.30998719e-02f, -7.90190920e-02f, 1.49814114e-01f, -1.39640257e-01f, -1.14572883e-01f, -6.49984777e-02f, -1.18017107e-01f, -1.34086446e-03f,
  9.27954018e-02f, -7.37852305e-02f, 2.14094639e-01f, -3.90168540e-02f, 1.17505185e-01f, -9.83122587e-02f, 1.12058327e-01f, -3.09825148e-02f, 1.94069408e-02f, -9.97023005e-03f,
  7.88727105e-02f, 2.17685908e-01f, 7.17811584e-02f, 9.44039300e-02f, 6.92048222e-02f, -6.61580190e-02f, -7.91341960e-02f, 1.68054886e-02f, -9.77449417e-02f, -8.73124003e-02f,
  9.74596664e-02f, -4.78360020e-02f, -7.14263171e-02f, -1.16629958e-01f, 1.36878565e-01f, -1.18933767e-01f, -1.39518365e-01f, 4.35800962e-02f, 1.13416865e-01f, -1.16882615e-01f,
  -5.53584192e-04f, -4.73815352e-02f, 8.88197646e-02f, -3.42207626e-02f, 3.84658160e-05f, 1.09779477e-01f, -1.64706111e-01f, 3.77890766e-02f, -7.65025094e-02f, -2.37735406e-01f,
  3.09588704e-02f, -2.76741153e-03f, 1.04907848e-01f, -5.64375184e-02f, -5.62390648e-02f, -6.03939593e-03f, -2.34286468e-02f, -1.42372966e-01f, -1.61288694e-01f, -9.12233442e-02f,
  8.88711289e-02f, 7.31246993e-02f, 1.09178215e-01f, 1.73605427e-01f, -4.73113097e-02f, -1.18327320e-01f, 3.24671239e-01f, -3.95955853e-02f, 1.02880135e-01f, 1.57826766e-01f,
  -4.60959412e-02f, 2.90838271e-01f, -7.92106614e-02f, 9.95977744e-02f, -1.34496048e-01f, -1.50857523e-01f, -6.30151480e-02f, -8.42720121e-02f, 1.01386704e-01f, 4.80194278e-02f,
  1.61361665e-01f, 1.06526375e-01f, -1.30027652e-01f, -7.16855898e-02f, -1.18610552e-02f, -2.16242149e-02f, 3.11602093e-02f, 1.43298488e-02f, 9.66671854e-02f, -1.27300113e-01f,
  -6.08418435e-02f, -9.58454683e-02f, -6.38384521e-02f, 1.24329943e-02f, -4.12978381e-02f, 1.53672591e-01f, 8.25015083e-02f, 8.77575353e-02f, 6.17693216e-02f, 2.15372279e-01f,
  5.78688011e-02f, -1.22571429e-02f, 4.59048897e-03f, 3.21438536e-02f, -2.45606583e-02f, 1.38610760e-02f, 1.69259876e-01f, -5.93602955e-02f, 1.83964614e-02f, 3.72531777e-03f,
  -8.56725499e-02f, -6.20743409e-02f, -1.34563535e-01f, -1.45318210e-01f, -1.40256897e-01f, 8.54622275e-02f, 1.58614784e-01f, -8.62059370e-02f, -1.55126140e-01f, 6.59544021e-02f,
  8.14670697e-02f, 1.22683503e-01f, 3.97724062e-02f, -2.84020547e-02f, 1.29546717e-01f, 1.63964015e-02f, -3.64793763e-02f, 4.26937453e-02f, 1.34683205e-02f, -5.17333709e-02f,
  -3.45645547e-02f, 1.00696921e-01f, 2.02853270e-02f, -1.27001554e-01f, -9.93848220e-02f, -5.99362478e-02f, 8.67388118e-03f, 5.16781807e-02f, 1.15472814e-02f, -3.41464467e-02f,
  1.17368554e-03f, 1.63249016e-01f, 1.81049034e-01f, 3.42381373e-03f, 1.28214210e-01f, -9.18239206e-02f, -4.69526798e-02f, 7.95482695e-02f, -1.72306951e-02f, 3.45733650e-02f,
  -8.24712515e-02f, 3.80311273e-02f, 7.86072537e-02f, 1.26206562e-01f, -3.61301303e-02f, -1.13969587e-01f, 9.69622657e-02f, 6.36141524e-02f, -7.75673240e-02f, -9.88576096e-03f,
  5.73244877e-02f, -2.02153623e-02f, 1.99333325e-01f, 4.99252267e-02f, -2.79297847e-02f, -3.91697325e-02f, 1.79326653e-01f, 1.56622976e-01f, 6.82474002e-02f, 1.05049625e-01f,
  8.92207250e-02f, 1.90476224e-01f, 1.60990059e-01f, -9.51089635e-02f, -2.50574172e-01f, 7.79066933e-03f, -1.48441538e-01f, -1.84519246e-01f, -1.59249246e-01f, 9.74670351e-02f,
  -6.47744760e-02f, -4.16215025e-02f, -8.19520205e-02f, 4.97331768e-02f, -8.77424981e-03f, 4.64707576e-02f, 3.28065529e-02f, 1.88464984e-01f, 2.13349417e-01f, 1.05936393e-01f,
  -1.10818774e-01f, 1.38457552e-01f, 7.73883536e-02f, -6.71104938e-02f, -9.82532576e-02f, -5.15226871e-02f, -2.85916124e-02f, 1.79462239e-01f, -2.78063044e-02f, -6.81090802e-02f,
  -1.28566951e-01f, -1.07098944e-01f, 3.74641269e-02f, -1.26019746e-01f, 1.48131832e-01f, -9.63249654e-02f, 2.43093185e-02f, -7.85085186e-02f, -2.66429503e-02f, 1.77322268e-01f,
  4.34545875e-02f, 1.22089304e-01f, 3.24774422e-02f, 4.84451279e-02f, 3.17947604e-02f, 8.58625248e-02f, -7.25107044e-02f, 1.41050100e-01f, -3.65746580e-02f, 2.58245748e-02f,
  -1.67928953e-02f, 8.36533085e-02f, -5.59044555e-02f, 1.92536727e-01f, 1.20714046e-02f, -5.33194374e-03f, 2.54770905e-01f, 7.28240311e-02f, -1.78265691e-01f, 7.90312216e-02f,
  -5.43170273e-02f, -8.98827687e-02f, 1.07600458e-01f, -1.88748967e-02f, 1.45173475e-01f, 1.89957261e-01f, -5.14138071e-03f, -5.88285774e-02f, 2.11204827e-01f, 1.58645958e-02f,
  1.71421945e-01f, 1.52143657e-01f, -3.90021801e-02f, 2.49546289e-01f, -5.95843978e-02f, 1.64381161e-01f, 1.71796158e-01f, 9.69900116e-02f, 1.63797677e-01f, 4.39534560e-02f,
  1.59081817e-01f, -7.89542496e-02f, 9.15701985e-02f, 4.05262820e-02f, 6.21622428e-02f, -4.72444408e-02f, 1.19262040e-01f, -6.95054084e-02f, -7.89443925e-02f, -4.58603166e-02f,
  -1.58202380e-01f, -1.11060739e-01f, 1.15621135e-01f, -6.17856160e-02f, -7.88032562e-02f, 1.46687165e-01f, 9.57564488e-02f, 8.02857727e-02f, 2.30877832e-01f, 4.89452742e-02f,
  -4.91670184e-02f, 1.51536524e-01f, -1.21733164e-02f, 1.14593588e-01f, 3.78304906e-02f, -1.16393983e-01f, 3.71459909e-02f, 2.26806700e-02f, -2.73739602e-02f, 1.03540920e-01f,
  6.77944794e-02f, -4.55985181e-02f, 1.10364452e-01f, -1.52223045e-02f, -6.88289925e-02f, 1.86757475e-01f, -3.32824476e-02f, -1.79236103e-02f, -9.47002321e-02f, -9.97645408e-03f,
  1.35189071e-01f, -1.03827760e-01f, 1.13358699e-01f, -1.17644612e-02f, -1.30914167e-01f, -1.45766392e-01f, 1.60565808e-01f, 2.85157114e-01f, 3.21728051e-01f, 2.83470958e-01f,
  2.83216864e-01f, 1.17410421e-01f, -1.33628082e-02f, 1.63489044e-01f, 2.94194315e-02f, 3.06135774e-01f, -3.75521034e-01f, 4.91001308e-01f, 1.66040324e-02f, 1.69099092e-01f,
  -1.75656509e-02f, 2.69829668e-02f, 2.32375190e-01f, 2.57795513e-01f, 1.59943521e-01f, -1.54672042e-01f, 2.76267558e-01f, -1.51935890e-01f, -9.88648310e-02f, -2.04596251e-01f,
  -1.14791967e-01f, 1.30789623e-01f, -1.23405322e-01f, 2.69186318e-01f, -1.37784749e-01f, -1.77345738e-01f, 2.57466793e-01f, 1.34804055e-01f, 1.73542276e-01f, 2.03984603e-02f,
  -8.32922012e-02f, 4.23474163e-02f, 3.95103127e-01f, 2.77458012e-01f, 1.89225420e-01f, 1.50543362e-01f, -1.10736536e-02f, -8.91375914e-02f, 1.83459610e-01f, -7.41961598e-02f,
  -2.02202335e-01f, -1.75921708e-01f, -1.17439330e-01f, -4.27383035e-02f, 2.01019198e-01f, 1.54915065e-01f, -2.37973537e-02f, -1.17977165e-01f, 1.24303773e-01f, 4.00817275e-01f,
  -1.95516884e-01f, 6.17178436e-03f, 1.17676333e-01f, 1.94156185e-01f, 3.84154201e-01f, -1.02737613e-01f, 2.86228627e-01f, -1.76372707e-01f, 5.46918325e-02f, -7.74816573e-02f,
  2.81377971e-01f, 1.33775726e-01f, 2.10808739e-01f, 1.80966184e-01f, 1.23365328e-01f, 2.40663532e-02f, 1.80102468e-01f, -9.50447395e-02f, 3.81157786e-01f, -2.44152024e-01f,
  3.45207453e-01f, 2.77091891e-01f, -9.26818475e-02f, 1.48327202e-01f, 3.34110349e-01f, 7.89506063e-02f, -4.71239686e-02f, -1.74594775e-01f, -4.20557633e-02f, 1.83481693e-01f,
  1.87692463e-01f, -4.24160995e-02f, 5.49405143e-02f, 1.28496021e-01f, 3.29185605e-01f, 2.39964768e-01f, -2.49401093e-01f, -4.17905711e-02f, -5.40586375e-02f, 1.83814123e-01f,
  -1.30709916e-01f, -1.75400108e-01f, -4.88272719e-02f, 1.99129328e-01f, 5.93140796e-02f, 1.01897389e-01f, 3.22766528e-02f, -1.37375310e-01f, 1.36215299e-01f, 5.25605446e-03f,
  4.54618931e-02f, 1.28091872e-01f, 1.64128579e-02f, 1.78621247e-01f, 2.82490015e-01f, 2.71886796e-01f, 5.39930873e-02f, 5.40013947e-02f, 1.63309142e-01f, 5.37899621e-02f,
  -2.23074146e-02f, 3.97329181e-01f, -1.08001210e-01f, -4.35148366e-02f, 3.79055366e-03f, 1.02370605e-01f, -2.39990845e-01f, 3.40957046e-02f, 2.07104877e-01f, -9.18603763e-02f,
  -2.00695116e-02f, -2.97129769e-02f, -1.38033619e-02f, -2.85987128e-02f, 1.09431699e-01f, 4.54961509e-03f, -6.05531260e-02f, -4.38000336e-02f, -3.98197435e-02f, 8.26870799e-02f,
  4.82393093e-02f, 8.49329755e-02f, -9.76533741e-02f, 1.08319290e-01f, -3.91324908e-02f, 4.15344909e-02f, 5.55293597e-02f, 1.35254143e-02f, 1.21167367e-02f, 1.07481673e-01f,
  1.31493583e-01f, 7.13828132e-02f, 1.28464505e-01f, 1.37491152e-01f, 1.15432665e-01f, -3.74638215e-02f, -6.74891546e-02f, 2.73139607e-02f, 1.27994925e-01f, 1.05852857e-01f,
  -3.98029685e-02f, 3.22049148e-02f, 1.52439373e-02f, -1.16428085e-01f, -3.87884639e-02f, -1.13523498e-01f, -8.38538483e-02f, 1.31143287e-01f, 2.43502147e-02f, 1.15970165e-01f,
  -1.77122583e-03f, 7.54478201e-02f, 4.31072414e-02f, -3.52672786e-02f, 1.63346436e-02f, 1.07780412e-01f, -6.91200560e-03f, 4.99756746e-02f, 9.04667005e-02f, 5.98990805e-02f,
  -2.94654332e-02f, -7.06000626e-02f, -1.13664456e-01f, -7.18705654e-02f, -5.37528247e-02f, 1.04404874e-01f, 2.22707186e-02f, 5.04431203e-02f, -6.37608916e-02f, 9.36321467e-02f,
  1.47077441e-01f, -4.61175991e-03f, -9.31073204e-02f, -1.78380460e-02f, 5.77094331e-02f, 6.56047091e-02f, -1.06238067e-01f, -9.98526812e-03f, -7.30654597e-02f, 1.58019364e-01f,
  1.34514704e-01f, 1.95231706e-01f, -4.93912958e-02f, 2.50495642e-01f, 9.08903256e-02f, -1.45373285e-01f, 5.16871922e-02f, -1.22554779e-01f, 2.00871468e-01f, -2.90132970e-01f,
  2.08845690e-01f, -7.53309131e-02f, -1.01072639e-02f, 7.43316337e-02f, 1.74621847e-02f, 9.45945382e-02f, -2.73925252e-02f, -2.17373203e-02f, -4.75937389e-02f, 1.27467200e-01f,
  -1.46626150e-02f, 7.97045901e-02f, 3.19453492e-03f, -1.24256164e-01f, 3.73186529e-01f, 1.80943217e-02f, 1.49384439e-01f, -1.06705442e-01f, 2.65116245e-02f, 3.77438553e-02f,
  3.86962034e-02f, -6.68676896e-03f, 2.78528258e-02f, 1.13392286e-01f, -2.81146960e-03f, 1.44586712e-01f, -7.71784335e-02f, -1.23501554e-01f, -2.92426925e-02f, 6.12378679e-02f,
  -3.61229591e-02f, -1.50821567e-01f, -5.26725091e-02f, 3.11111715e-02f, -5.06948270e-02f, 1.07592186e-02f, 8.19349959e-02f, -9.79194269e-02f, 7.21275732e-02f, 2.01205891e-02f,
  1.47570476e-01f, -1.32295981e-01f, 1.20075522e-02f, 2.01406032e-02f, 9.96716246e-02f, -1.35723993e-01f, 1.42570147e-02f, 7.36071691e-02f, -9.29054469e-02f, 7.90720731e-02f,
  1.11413524e-01f, 1.92166686e-01f, 2.79760152e-01f, 1.62998706e-01f, 1.66915730e-01f, 1.88977212e-01f, 6.19362667e-02f, 1.67758256e-01f, -1.55854896e-01f, 5.38208745e-02f,
  -3.26834559e-01f, 1.32906049e-01f, -2.51564026e-01f, -2.80956656e-01f, 1.60400197e-01f, 2.90265046e-02f, -5.88576868e-02f, 3.20825651e-02f, -7.04586729e-02f, -2.77909376e-02f,
  -5.00178896e-02f, 8.30464885e-02f, 2.07390413e-02f, -7.02786669e-02f, -6.36834875e-02f, -2.55371243e-01f, -1.74283653e-01f, -1.01870067e-01f, -1.71353087e-01f, -1.78302173e-02f,
  2.34040022e-01f, 2.78508514e-01f, 1.49563521e-01f, -5.01411594e-02f, 2.53424197e-01f, 4.61332471e-04f, -1.18409239e-01f, 1.85297877e-01f, -7.25053474e-02f, 8.46170187e-02f,
  -7.68787116e-02f, 1.41185015e-01f, 2.16193140e-01f, -9.21948925e-02f, 9.44029540e-02f, 1.20749585e-01f, -9.73375291e-02f, -1.45530805e-01f, 1.26584563e-02f, 5.43854907e-02f,
  -1.05614074e-01f, 1.27598658e-01f, -1.01770431e-01f, -9.44095924e-02f, 8.78180191e-02f, -2.47354656e-02f, -1.66600168e-01f, 1.03242598e-01f, 1.61753997e-01f, -6.58120885e-02f,
  -4.35619280e-02f, -9.94789302e-02f, -1.76594965e-02f, 1.61898077e-01f, -4.16408256e-02f, 2.01232776e-01f, 5.64023666e-02f, 6.35789260e-02f, 6.57973289e-02f, 1.53887300e-02f,
  1.20740552e-02f, -1.01947047e-01f, 8.36239904e-02f, 1.86928199e-03f, 5.49724698e-02f, 3.23691964e-02f, 1.04115173e-01f, 6.37530088e-02f, -1.22259796e-01f, -1.15381805e-02f,
  -3.74776423e-02f, -1.30103156e-01f, -6.75371140e-02f, 6.75584450e-02f, 1.35568440e-01f, 3.04746367e-02f, -5.84334135e-02f, 1.35803362e-02f, 4.27385839e-03f, -2.61545833e-03f,
  1.33133188e-01f, 9.57154557e-02f, -1.24709852e-01f, 1.92459021e-02f, -4.08794619e-02f, -7.44184107e-02f, -8.99118409e-02f, 3.71523038e-03f, 4.94349003e-02f, 7.64851421e-02f,
  1.55727686e-02f, 7.53442422e-02f, 6.24552667e-02f, 8.89251940e-03f, -3.76890786e-02f, -1.23327442e-01f, -5.34353815e-02f, 6.41454011e-02f, 2.54086056e-03f, 1.38894841e-01f,
  8.42121542e-02f, 2.90708710e-02f, 1.44624263e-01f, 7.51686320e-02f, -1.25980014e-02f, -9.10784230e-02f, 1.34518057e-01f, 1.15041457e-01f, -7.81502202e-03f, -1.08542584e-01f,
  -2.75558550e-02f, -3.00197471e-02f, 5.60802147e-02f, 5.36470897e-02f, 1.06013052e-01f, -2.81321630e-02f, 3.29962336e-02f, 5.98479016e-03f, -9.40314159e-02f, 7.40981326e-02f,
  9.96413901e-02f, 1.84176490e-01f, 5.31478077e-02f, -2.34318469e-02f, 1.78157225e-01f, -8.04443285e-02f, -5.39597757e-02f, -3.13256569e-02f, -3.73702645e-02f, 5.17458059e-02f,
  -1.59783885e-01f, 3.33387107e-02f, -5.73419444e-02f, -1.14549801e-01f, -1.45369574e-01f, -8.26173127e-02f, -3.65747884e-02f, 1.24708340e-01f, -1.01215184e-01f, -5.48647009e-02f,
  -5.50855361e-02f, -6.41090125e-02f, -3.93104330e-02f, 2.85250135e-03f, -1.75002441e-02f, 3.00353765e-03f, 2.38168370e-02f, 6.85460791e-02f, 1.28285289e-01f, 1.67690352e-01f,
  -2.30681873e-03f, -5.47909439e-02f, 7.54662007e-02f, 7.19734132e-02f, -6.70609474e-02f, 9.06315967e-02f, 1.87067434e-01f, 2.43849158e-01f, 7.12968502e-03f, -5.84168211e-02f,
  1.81659549e-01f, -9.57415700e-02f, 5.55924065e-02f, 1.10133961e-02f, -1.68677852e-01f, -1.11401647e-01f, -9.39851403e-02f, -7.51933232e-02f, 1.40940025e-01f, 1.31511226e-01f,
  1.18758395e-01f, 5.53584322e-02f, 1.78313613e-01f, 5.95506243e-02f, 1.70491077e-02f, 3.28591280e-02f, -8.78408924e-02f, 4.37184907e-02f, 2.73948818e-01f, -8.55646282e-03f,
  2.81847524e-03f, -1.14908740e-01f, -4.56070341e-02f, 1.16003729e-01f, 1.03463687e-01f, 8.23011994e-03f, 1.31013811e-01f, 6.52238354e-02f, -5.51324338e-02f, 7.05389678e-02f,
  8.48584920e-02f, 8.58597383e-02f, -6.25245739e-04f, -1.30467415e-01f, -1.85970217e-02f, -5.85573353e-02f, 1.18248597e-01f, -1.10518247e-01f, 1.38709962e-01f, 1.06082574e-01f,
  -2.41568070e-02f, 3.86100449e-02f, -1.08337648e-01f, 2.30465159e-02f, 2.64264978e-02f, -1.02184080e-01f, -4.26568724e-02f, -1.05359934e-01f, -1.06758408e-01f, 2.31328495e-02f,
  9.90565941e-02f, -4.30169189e-03f, 2.22267583e-02f, 2.37221077e-01f, -5.08414060e-02f, -3.80298356e-03f, 6.03439100e-02f, -1.29894063e-01f, 7.57129192e-02f, 4.34555858e-02f,
  -3.61470394e-02f, 9.58605856e-02f, 5.96523881e-02f, -2.04253159e-02f, 5.53757325e-02f, -1.01146422e-01f, -1.28009260e-01f, -7.32368231e-02f, -2.87062619e-02f, -1.45937622e-01f,
  1.17789127e-01f, 6.94659725e-02f, 8.30759853e-02f, -2.12618392e-02f, -6.84859380e-02f, 1.01292014e-01f, 1.00269102e-01f, -1.29746318e-01f, -8.33594725e-02f, -1.10684149e-01f,
  -6.24450743e-02f, -7.83153698e-02f, -1.52459130e-01f, -1.34485289e-02f, 5.43965399e-02f, -6.19733557e-02f, 1.02370884e-02f, -6.54193014e-02f, 3.01729050e-02f, 2.31270000e-01f,
  1.57428309e-01f, 1.13040306e-01f, 5.15532270e-02f, 2.22082019e-01f, 2.37605367e-02f, 3.81055661e-02f, 9.28220302e-02f, 1.76773399e-01f, 6.22492321e-02f, 1.13933377e-01f,
  4.33564112e-02f, -4.14140970e-02f, -9.67363641e-02f, -4.92864773e-02f, 2.08709285e-01f, -1.66705418e-02f, 1.25816196e-01f, -4.24881242e-02f, -1.24277599e-01f, 1.05202295e-01f,
  -2.37535164e-02f, -2.96042189e-02f, 4.55610305e-02f, -5.80809899e-02f, 3.98361266e-01f, -3.88243981e-02f, -1.88262194e-01f, -2.00128853e-01f, -6.00844957e-02f, 2.30145082e-01f,
  -1.28378198e-01f, -6.56887889e-02f, 1.42610654e-01f, 6.32733339e-03f, 1.00209669e-04f, 3.01495027e-02f, 1.32527784e-01f, -1.21055290e-01f, -4.13842984e-02f, -1.06265001e-01f,
  2.12310702e-01f, 5.11894897e-02f, -1.30713090e-01f, 9.65747461e-02f, 1.20393783e-01f, 1.12009328e-02f, 1.02256477e-01f, -8.04169998e-02f, 7.04018399e-02f, -6.04914501e-02f,
  1.37639120e-01f, 1.15725443e-01f, -4.57087941e-02f, -1.44855544e-01f, 2.79537112e-01f, -3.47487293e-02f, -3.71322148e-02f, 2.84625441e-01f, 1.17254235e-01f, -4.41797860e-02f,
  1.13117984e-02f, -1.19083360e-01f, 6.07514083e-02f, -5.78099228e-02f, -6.08778112e-02f, 1.25869568e-02f, -4.74759601e-02f, 1.06947467e-01f, 1.49919480e-01f, -4.40574065e-02f,
  1.14111654e-01f, -7.75694698e-02f, 6.49615526e-02f, 1.05082598e-02f, 5.99073805e-02f, 4.86500151e-02f, 2.28913963e-01f, -1.91109721e-02f, 1.00054920e-01f, -1.35281056e-01f,
  -2.18970869e-02f, 1.00609295e-01f, 1.35868073e-01f, -1.42652541e-01f, -5.79128526e-02f, 2.81912107e-02f, -1.44431181e-02f, 1.13627173e-01f, 6.72351569e-02f, 5.16997203e-02f,
  -1.37690023e-01f, 2.83559933e-02f, -9.75145251e-02f, 3.31873633e-03f, 6.88839927e-02f, 1.29287988e-01f, -6.67649731e-02f, 9.68803391e-02f, -5.06950766e-02f, -3.04921512e-02f,
  1.10713392e-01f, -1.22038417e-01f, -4.62194122e-02f, 5.29983379e-02f, -6.78934669e-03f, -1.32852912e-01f, 4.28914465e-02f, -7.31049478e-02f, 2.57072132e-02f, -8.46512616e-02f,
  1.02866217e-01f, -1.21349439e-01f, 6.96224198e-02f, 1.67145208e-03f, 9.49170887e-02f, -1.12870462e-01f, -7.19937012e-02f, 4.91108336e-02f, 2.34213397e-02f, 8.39342847e-02f,
  1.43468544e-01f, 6.50042593e-02f, 5.39023280e-02f, -2.61130072e-02f, 2.89655887e-02f, 7.99883008e-02f, 9.98645276e-02f, -3.69376354e-02f, 1.57737389e-01f, 6.70243576e-02f,
  4.01402563e-02f, -2.39634719e-02f, 6.83938414e-02f, -1.76375151e-01f, 1.58125069e-02f, 2.49001347e-02f, 5.44174723e-02f, -4.19272408e-02f, -1.30931526e-01f, 1.33752927e-01f,
  1.38954997e-01f, -7.71868005e-02f, 8.83533433e-02f, 5.65837435e-02f, -3.14224744e-03f, -1.65983643e-02f, -1.01698995e-01f, -1.33239642e-01f, 2.90716975e-03f, -2.21089907e-02f,
  -7.85549432e-02f, -2.34998465e-02f, -6.28423644e-03f, 8.73552337e-02f, -1.08064957e-01f, 4.14649509e-02f, -9.97061655e-03f, -1.19913086e-01f, -7.82645866e-02f, 2.23396625e-02f,
  4.59710881e-02f, 1.15797505e-01f, -8.60374495e-02f, -9.81574357e-02f, -3.43916304e-02f, 9.46180224e-02f, -8.99068937e-02f, -1.07261792e-01f, 1.27076104e-01f, -1.45923704e-01f,
  -1.71043724e-02f, -3.54220085e-02f, -3.06774657e-02f, -6.42044991e-02f, 6.71800673e-02f, -5.02971187e-02f, -1.01204075e-01f, -5.26846983e-02f, -5.08055985e-02f, 1.87857375e-02f,
  4.07819673e-02f, 3.77013944e-02f, 8.97691250e-02f, 8.01927596e-02f, -1.37588844e-01f, -1.15586139e-01f, 1.21456034e-01f, 7.50661194e-02f, 9.48773101e-02f, 8.14115554e-02f,
  -3.12429331e-02f, 1.19297996e-01f, -7.34927058e-02f, 1.66308787e-03f, 5.58144264e-02f, -1.08761936e-02f, -1.13909066e-01f, 8.18051398e-02f, -1.50319591e-01f, -3.66029739e-02f,
  6.34183437e-02f, -5.46819754e-02f, 6.08372018e-02f, 8.72879624e-02f, 4.84371632e-02f, 4.29180302e-02f, 2.62907315e-02f, 4.61510790e-04f, -6.31155223e-02f, 7.15468898e-02f,
  1.86731312e-02f, 9.64401439e-02f, 3.65677178e-02f, 2.70452708e-01f, -9.88346040e-02f, 8.78168792e-02f, 8.22667256e-02f, 1.49426252e-01f, 1.68826103e-01f, 8.03550426e-03f,
  8.97444785e-02f, -4.91420254e-02f, 7.64099509e-02f, 1.80737793e-01f, -3.25541347e-02f, 6.20436519e-02f, -7.12656602e-02f, 3.33642364e-02f, -5.35550527e-02f, -1.27584971e-02f,
  -1.11613851e-02f, 7.75343403e-02f, -1.67298451e-01f, 1.67952463e-01f, 3.17928307e-02f, 2.73876786e-01f, -4.24442813e-02f, 9.80273783e-02f, 9.73664895e-02f, 8.97264257e-02f,
  -4.58103977e-03f, 9.02362615e-02f, 1.02587223e-01f, 1.06864378e-01f, -7.67474622e-02f, 1.35524213e-01f, 4.02561314e-02f, -6.30447119e-02f, -1.74522758e-01f, -8.51159915e-02f,
  -6.51220083e-02f, 1.61754042e-02f, 1.52554169e-01f, -5.61267957e-02f, -7.09260209e-03f, 1.01247370e-01f, -1.98754799e-02f, 5.63940965e-02f, 1.57694191e-01f, 1.34809062e-01f,
  8.45187828e-02f, 5.22321798e-02f, 1.77258924e-01f, 1.31336957e-01f, 2.26293936e-01f, -2.74905026e-01f, -5.47239149e-04f, 5.02457805e-02f, 1.89350247e-01f, 1.33882150e-01f,
  -2.41034869e-02f, 1.31649841e-02f, 2.04170540e-01f, -1.51363211e-02f, -9.86287519e-02f, -2.40573920e-02f, 5.80988824e-02f, 3.59442756e-02f, -9.27409902e-02f, -5.46396747e-02f,
  2.36550316e-01f, -5.88340499e-02f, -3.12992148e-02f, 1.22878607e-02f, -1.02311462e-01f, 9.42892805e-02f, 8.26036781e-02f, 3.74323130e-02f, -1.76814906e-02f, 6.41867369e-02f,
  -1.15315452e-01f, 7.86461756e-02f, -5.48729002e-02f, -1.43583000e-01f, 8.99350196e-02f, -7.58550242e-02f, 1.42656371e-01f, -5.93838580e-02f, -3.86812165e-02f, -9.75921229e-02f,
  -1.49328327e-02f, 6.27442915e-03f, 7.11157396e-02f, -6.11088686e-02f, -1.33926004e-01f, 1.40206099e-01f, 2.79634316e-02f, -9.43821818e-02f, 9.84094068e-02f, -6.83609471e-02f,
  1.53594300e-01f, 1.67286173e-02f, -1.83428898e-02f, 2.11357370e-01f, 2.08235443e-01f, 5.73732778e-02f, 2.93447301e-02f, -2.19878461e-02f, 2.13292867e-01f, 1.88022047e-01f,
  1.42886817e-01f, 5.15806004e-02f, 1.78637475e-01f, 1.44493148e-01f, -6.28059357e-02f, -1.12827972e-01f, 5.20929210e-02f, -1.97315931e-01f, -1.25846088e-01f, 2.96944547e-02f,
  -8.21649507e-02f, 5.79369441e-02f, -5.23009002e-02f, 1.76633701e-01f, -3.27053629e-02f, -1.28291890e-01f, 8.72366428e-02f, -1.22813813e-01f, 2.14591995e-02f, -1.80185199e-01f,
  -7.02867135e-02f, 3.47447433e-02f, -4.26191054e-02f, 1.28035313e-02f, -7.35952929e-02f, -8.02878439e-02f, -5.34643158e-02f, 3.91317308e-01f, 2.42259856e-02f, 3.87360379e-02f,
  -4.15805839e-02f, -1.05132081e-01f, 5.31215779e-02f, -9.46728513e-02f, -4.37540039e-02f, -1.25424951e-01f, 5.90492822e-02f, -3.56150270e-02f, 1.60333626e-02f, -1.26467034e-01f,
  1.86534479e-01f, -1.12889349e-01f, 1.10652730e-01f, -1.03693239e-01f, -8.04585963e-02f, 1.92782171e-02f, 8.18217769e-02f, 1.00482903e-01f, -6.84786066e-02f, -2.59870458e-02f,
  1.31400421e-01f, -8.93384516e-02f, 1.15023434e-01f, -5.32123446e-02f, -1.52470931e-01f, 1.88614637e-01f, 4.30931570e-03f, 1.43684864e-01f, 2.35509530e-01f, -1.78305224e-01f,
  4.74126860e-02f, 1.65871382e-01f, -3.01070940e-02f, -2.99679860e-02f, 9.91869420e-02f, 1.50048301e-01f, -7.86461867e-03f, 8.01783800e-02f, 8.38127360e-02f, -8.49755108e-02f,
  6.40843883e-02f, 1.67649671e-01f, 1.50512710e-01f, -5.18042482e-02f, 7.74643496e-02f, -1.05883725e-01f, -7.07821399e-02f, -1.14519283e-01f, 1.10129163e-01f, 5.67331575e-02f,
  1.37952536e-01f, 9.07613561e-02f, 3.33485529e-02f, -5.06257499e-03f, 5.18220030e-02f, 9.01823640e-02f, -6.02454171e-02f, -4.52428311e-02f, 3.21196973e-01f, 1.58437453e-02f,
  -1.43654153e-01f, -3.36412452e-02f, -7.96947926e-02f, -3.98583412e-02f, 3.91067266e-02f, 6.89546764e-02f, 4.78785113e-03f, 1.61390901e-01f, -3.54328081e-02f, 1.50759947e-02f,
  1.26334906e-01f, -1.29455492e-01f, -8.72156844e-02f, -9.23452824e-02f, 2.91582011e-02f, -4.97227497e-02f, -9.48594511e-02f, -5.08834124e-02f, 1.04957581e-01f, -1.11997031e-01f,
  -7.35457093e-02f, 4.49857377e-02f, 6.68455958e-02f, 1.37955338e-01f, -7.90614858e-02f, -9.63774025e-02f, 9.13337991e-02f, 7.99669474e-02f, 1.58929273e-01f, -7.77441412e-02f,
  -7.31960088e-02f, 1.14313588e-01f, -8.98353383e-02f, 1.65571913e-01f, -1.15688056e-01f, -1.24566574e-02f, 5.17902523e-02f, 1.20136663e-02f, 1.65137902e-01f, -5.11105098e-02f,
  -1.64249018e-02f, 1.15314290e-01f, -4.51727435e-02f, -6.20150454e-02f, 3.67698520e-02f, -1.76966667e-01f, -1.54341519e-01f, -5.54147735e-03f, 1.55515417e-01f, -3.27749886e-02f,
  -7.02744648e-02f, -3.39387543e-02f, -5.38944304e-02f, -8.73054937e-02f, -4.59496211e-03f, 6.17997833e-02f, -3.29183973e-02f, -1.04364403e-01f, 5.39825298e-02f, 1.92064598e-01f,
  -7.69804716e-02f, -9.35882851e-02f, -9.42740440e-02f, -5.02148271e-03f, 5.13098724e-02f, -1.01083130e-01f, -3.64695303e-02f, -7.87027031e-02f, -4.83567230e-02f, -5.40923793e-03f,
  1.45715699e-01f, -4.19526435e-02f, 1.00002676e-01f, -6.33634627e-03f, -2.76199561e-02f, 7.68048167e-02f, 2.00172156e-01f, -1.54770151e-01f, -3.22196372e-02f, -5.24383634e-02f,
  1.44040257e-01f, 1.90655932e-01f, 1.13449983e-01f, -1.08173611e-02f, 8.53092372e-02f, 6.93459362e-02f, 1.44564271e-01f, 3.48608382e-02f, 1.04383603e-01f, -1.69537619e-01f,
  1.29503086e-01f, -1.33019462e-01f, 5.62291034e-02f, 8.47491249e-02f, -9.27119106e-02f, -8.31056610e-02f, -2.74843480e-02f, 5.89629933e-02f, 9.83409733e-02f, 1.12547521e-02f,
  1.09239304e-02f, 4.76709306e-02f, 2.61401236e-02f, 9.36670303e-02f, 1.10605016e-01f, -2.88070738e-02f, -9.94807705e-02f, 1.20210052e-01f, 4.23775166e-02f, -1.77365676e-01f,
  -9.39673558e-02f, 1.05055243e-01f, 2.76400983e-01f, 7.05217943e-02f, -1.84283987e-01f, -1.67427093e-01f, -1.36411488e-01f, 3.00509091e-02f, -1.87936753e-01f, 8.05856436e-02f,
  9.00165215e-02f, 1.48613170e-01f, -9.43358988e-02f, 2.29880333e-01f, -1.87471677e-02f, -5.32191508e-02f, -2.31674518e-02f, 9.05540660e-02f, 2.69522667e-01f, -1.15613170e-01f,
  8.18776563e-02f, -5.21544516e-02f, -7.18840584e-03f, -3.81776616e-02f, 1.80310205e-01f, 1.00509733e-01f, 1.10194562e-02f, 1.97334051e-01f, 2.01007292e-01f, -1.06842712e-01f,
  1.63901672e-01f, -5.10148592e-02f, 5.59336953e-02f, -1.22247346e-01f, 1.63757384e-01f, 2.71975249e-01f, 1.18188933e-01f, -1.61321148e-01f, 6.41772198e-03f, -7.28509054e-02f,
  -2.74007972e-02f, -9.35351700e-02f, 1.64541662e-01f, -1.29212007e-01f, 4.84936237e-02f, -1.08065285e-01f, 4.99670953e-03f, -5.68672307e-02f, 2.04937950e-01f, -1.85408555e-02f,
  -4.91061136e-02f, -7.22613484e-02f, 2.39623562e-01f, 1.34461120e-01f, 1.48411140e-01f, 6.96070343e-02f, 2.12212820e-02f, 5.94044998e-02f, 1.81483850e-01f, -7.57031217e-02f,
  -9.79534015e-02f, 1.19589992e-01f, -3.50267775e-02f, -1.61527842e-01f, -1.82542413e-01f, -2.73855850e-02f, -4.98540998e-02f, -1.04234956e-01f, 6.64110035e-02f, 1.51580749e-02f,
  -8.08800757e-02f, 4.15254012e-02f, 1.86417699e-02f, -8.42669904e-02f, 5.91361634e-02f, 3.79605703e-02f, 5.72696403e-02f, 1.56337991e-02f, -1.03816859e-01f, 1.04887694e-01f,
  -1.46886915e-01f, 2.16531381e-02f, 1.87093854e-01f, 1.32195121e-02f, 1.11279495e-01f, -4.58343551e-02f, 1.24668442e-02f, -4.11881506e-02f, -7.87476972e-02f, 6.83745816e-02f,
  -5.63934781e-02f, -8.31586048e-02f, 1.35744795e-01f, -5.32923602e-02f, 5.99518232e-02f, -1.06971845e-01f, 3.15450467e-02f, -2.20459476e-02f, 1.36409625e-01f, 2.29312330e-01f,
  -8.27572718e-02f, 8.62077177e-02f, 1.28911873e-02f, 9.14375409e-02f, 6.78441450e-02f, 1.90433338e-01f, 3.35737765e-02f, -1.31116137e-01f, -7.48697743e-02f, 1.98995937e-02f,
  -1.65996671e-01f, -9.67447460e-02f, -1.68186345e-03f, 2.38602366e-02f, -2.16156337e-02f, 1.50393993e-01f, 9.05152485e-02f, 1.53662264e-01f, -7.19215572e-02f, 6.81017041e-02f,
  1.23334616e-01f, -1.62299629e-02f, 1.36567235e-01f, -7.82945752e-02f, -1.01098843e-01f, -7.41089061e-02f, -5.55833317e-02f, 3.85229141e-02f, 2.74228845e-02f, 1.16646342e-01f,
  -1.15248285e-01f, -2.76528001e-02f, 1.00203278e-03f, 1.36288270e-01f, -3.75095755e-02f, 4.53418912e-03f, -1.64641161e-02f, -1.18815146e-01f, 2.22580731e-02f, -2.54743509e-02f,
  3.15081961e-02f, 6.14084005e-02f, -7.00160414e-02f, 4.63059805e-02f, -6.96634799e-02f, 6.82785586e-02f, -1.83538154e-01f, -7.05570728e-02f, 9.03671682e-02f, 1.60001338e-01f,
  4.71514426e-02f, 1.32892607e-02f, -5.27059399e-02f, 4.63554934e-02f, 1.68258309e-01f, 9.10656229e-02f, 8.11186135e-02f, 1.55228049e-01f, 1.95583403e-02f, 4.06192467e-02f,
  -1.87674407e-02f, 7.60833472e-02f, -5.15580066e-02f, 3.54813784e-02f, 2.71368455e-02f, 9.18034650e-03f, 1.68862700e-01f, 1.44509487e-02f, 3.49839451e-03f, -6.28712103e-02f,
  -1.01929598e-01f, 1.64523065e-01f, -8.49760845e-02f, -1.08532973e-01f, -1.31290510e-01f, 1.12364702e-01f, 1.25847328e-02f, -5.90031631e-02f, 1.59125566e-01f, 1.46220019e-02f,
  -2.50402391e-02f, -1.24528147e-01f, 5.58209345e-02f, 1.06774092e-01f, 4.38709222e-02f, -3.98317985e-02f, 1.41160369e-01f, 9.86132398e-02f, 1.20762594e-01f, -1.56243555e-02f,
  -2.57854257e-02f, 1.41695037e-01f, 1.81231871e-02f, 2.35147044e-01f, -8.50553364e-02f, 3.42233777e-02f, -9.64324847e-02f, 3.99363041e-02f, 1.06534377e-01f, 7.93958530e-02f,
  -6.83570132e-02f, 1.40525848e-01f, 2.46747628e-01f, 1.70882493e-02f, -6.00155219e-02f, 2.08979234e-01f, -2.20755767e-02f, 6.12107255e-02f, -1.00928620e-01f, 9.48095024e-02f,
  -9.16394070e-02f, -8.08781758e-02f, 6.06337190e-02f, -1.61306351e-01f, 3.88679355e-02f, 1.88537583e-01f, 9.82953757e-02f, -8.71091709e-02f, 1.26740620e-01f, 2.17177328e-02f,
  2.23757457e-02f, -1.20857850e-01f, -1.78064167e-01f, 1.42844424e-01f, -9.73686874e-02f, 3.33402045e-02f, 2.19438136e-01f, 3.34117085e-01f, 5.17275855e-02f, 6.07680529e-02f,
  -8.89630988e-02f, -5.67762852e-02f, 1.22558147e-01f, 1.41546682e-01f, -7.74048716e-02f, 3.78353335e-02f, 1.19874077e-02f, 1.59023076e-01f, -1.03667423e-01f, 1.76780000e-02f,
  1.52339458e-01f, -8.21700618e-02f, -1.07589938e-01f, 8.03691074e-02f, 5.14533296e-02f, -4.90272827e-02f, 5.62874265e-02f, 5.19268103e-02f, -9.82226431e-02f, 8.37336332e-02f,
  1.33376658e-01f, 1.33604288e-01f, -2.87517577e-01f, -2.56181322e-02f, -1.27313867e-01f, 1.77932978e-01f, 1.19796447e-01f, -1.73463821e-01f, -1.39676258e-01f, -3.97824496e-02f,
  1.57080188e-01f, 1.58483014e-02f, 1.14492163e-01f, -2.26757098e-02f, 1.74191929e-02f, 2.67332822e-01f, 2.14090809e-01f, 2.93385983e-01f, 1.01779401e-01f, 5.59099168e-02f,
  2.90041238e-01f, 5.09497449e-02f, 2.70857811e-01f, 4.89696674e-02f, 1.20716609e-01f, 2.95689534e-02f, -1.52611926e-01f, 6.76690638e-02f, -1.51407691e-02f, 1.77287593e-01f,
  -4.60908897e-02f, 5.04371971e-02f, -1.43488184e-01f, -1.57108560e-01f, -8.81042704e-02f, 1.41292021e-01f, 9.43993703e-02f, 4.09709543e-01f, -6.43713474e-02f, 4.27560657e-01f,
  9.64330062e-02f, 9.44325328e-02f, 2.15023041e-01f, 1.39506266e-01f, -3.34612243e-02f, 1.77178964e-01f, -9.70225558e-02f, 2.27719522e-03f, -1.66276306e-01f, 1.24107294e-01f,
  -8.18991661e-02f, 4.21482116e-01f, 6.20625280e-02f, -9.68512222e-02f, -1.90470694e-03f, 9.76044834e-02f, -1.61524951e-01f, 2.17010066e-01f, -8.84039551e-02f, -4.34313118e-02f,
  -2.90457718e-02f, 1.50062338e-01f, 6.29562438e-02f, 6.39408901e-02f, 7.24071637e-02f, -1.96228400e-02f, -6.71947300e-02f, 2.04154566e-01f, -1.14552662e-01f, 2.04852775e-01f,
  7.36351684e-02f, 2.15490386e-01f, 2.35255510e-01f, 5.27727697e-03f, -3.14308032e-02f, -1.16702802e-01f, -3.53821367e-03f, 2.85139331e-03f, -7.04279914e-02f, 8.02004784e-02f,
  -1.24926582e-01f, 1.39319614e-01f, 5.02193533e-02f, 7.07507208e-02f, -1.49898753e-01f, -4.60336320e-02f, 2.67509762e-02f, 2.75746379e-02f, -4.87491712e-02f, -1.91575304e-01f,
  6.29942864e-02f, 5.13466075e-03f, -5.35523482e-02f, -2.23054159e-02f, 1.55834869e-01f, 6.07364178e-02f, 6.90599084e-02f, 2.69933432e-01f, 9.44919139e-02f, -8.08012336e-02f,
  -4.31192704e-02f, -1.35977603e-02f, 1.05312489e-01f, 7.47808143e-02f, -6.73947185e-02f, 1.36775255e-01f, -7.83806667e-02f, -4.43275981e-02f, -8.31787512e-02f, 1.80634171e-01f,
  1.20449401e-01f, 1.12301819e-01f, 8.86218697e-02f, 1.47097319e-01f, 3.49143595e-02f, -1.29206151e-01f, 6.25999644e-02f, -1.28453985e-01f, 2.80260318e-03f, 1.24558210e-02f,
  7.88393170e-02f, 1.74005553e-01f, -2.07315851e-02f, 6.85428828e-02f, -3.89193855e-02f, 8.34063739e-02f, -4.48296368e-02f, 8.02714899e-02f, 1.32954465e-02f, -1.57147236e-02f,
  5.77062219e-02f, 2.62210350e-02f, 9.69237462e-02f, -1.41583279e-01f, 1.13714546e-01f, 1.26099303e-01f, -7.58134946e-03f, 8.25780258e-02f, 6.39632866e-02f, -9.00478959e-02f,
  1.33900642e-01f, 5.05445413e-02f, 5.01977839e-02f, 2.01552182e-01f, 7.73268044e-02f, 1.18900880e-01f, 1.81521066e-02f, 1.92692623e-01f, 1.73863783e-01f, 1.44972309e-01f,
  7.70146623e-02f, 1.17528968e-01f, -7.96246454e-02f, -7.51288980e-02f, 6.14706352e-02f, 1.43845111e-01f, -3.04466509e-03f, 1.12646976e-02f, -3.53385359e-02f, 7.15559199e-02f,
  -6.07583076e-02f, -1.09835587e-01f, -1.34580389e-01f, 1.16041325e-01f, -1.44485414e-01f, 9.45261568e-02f, -1.27042294e-01f, 2.04947248e-01f, 1.34080231e-01f, 3.00990939e-01f,
  1.60840258e-01f, -1.73193105e-02f, 5.50933965e-02f, 1.23118453e-01f, -8.76457151e-03f, 3.67125124e-02f, -1.63538456e-01f, -5.59716970e-02f, 6.15031794e-02f, 1.39539868e-01f,
  -5.52112013e-02f, -6.04512766e-02f, -1.70030504e-01f, -9.63566750e-02f, -8.55057091e-02f, 1.78530201e-01f, -1.51240215e-01f, 1.06963394e-02f
};

// L1_fan_Bp_bar (Shape: 1 x 52)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 52;
const float L1_fan_Bp_bar_data[] = {
  2.89503038e-01f, 1.09764941e-01f, 6.85080215e-02f, 2.84008890e-01f, 1.03301398e-01f, 2.45532691e-01f, -3.53436321e-02f, 1.71001226e-01f, 2.88703423e-02f, 9.22162086e-02f,
  2.76387241e-02f, 1.57345131e-01f, 2.49302179e-01f, 1.87605321e-01f, 1.86163604e-01f, -1.86139308e-02f, -3.19425315e-02f, 7.27367401e-02f, 1.42331466e-01f, 4.40877900e-02f,
  1.73942205e-02f, -1.64743643e-02f, 1.52495787e-01f, -3.82871963e-02f, -4.42726910e-02f, -2.90717110e-02f, 1.61785871e-01f, -1.93807890e-03f, 1.16967946e-01f, 2.18539715e-01f,
  2.32582241e-01f, 7.42366388e-02f, 2.26270601e-01f, 2.43897036e-01f, -6.77866349e-03f, 1.42889783e-01f, 2.33385995e-01f, 8.43801573e-02f, 9.98067558e-02f, -1.37080997e-02f,
  7.48264715e-02f, 2.07264498e-01f, 3.01536679e-01f, -3.87319643e-03f, -1.71193257e-02f, 1.95579499e-01f, 3.30537520e-02f, -5.43723814e-03f, 9.60609317e-02f, 3.94922085e-02f,
  7.88520649e-02f, 6.16325822e-04f
};

// L2_linear_W (Shape: 12 x 64)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 64;
const float L2_linear_W_data[] = {
  2.27871850e-01f, 1.98831692e-01f, 6.97321668e-02f, 1.81082442e-01f, -3.62278521e-02f, 2.28914365e-01f, 1.02281250e-01f, 3.48421216e-01f, 3.11430067e-01f, 1.03689723e-01f,
  3.27305913e-01f, 3.26028913e-02f, -2.37622142e-01f, 5.96995890e-01f, -1.35328844e-01f, -3.81734580e-01f, 1.13867655e-01f, -1.49296805e-01f, -5.04080206e-02f, 3.54893595e-01f,
  -1.06086724e-01f, -1.27855718e-01f, -1.74837872e-01f, 8.13980252e-02f, -2.63065219e-01f, -2.26832882e-01f, 2.40486011e-01f, -6.84290379e-02f, -1.96411818e-01f, -2.26082280e-01f,
  -2.27245800e-02f, 2.68777437e-03f, -1.42834634e-02f, 1.96916297e-01f, 2.39729255e-01f, 1.85963243e-01f, -1.06325343e-01f, -1.26922876e-01f, 1.27280071e-01f, -1.24272130e-01f,
  -1.80434182e-01f, 1.77579984e-01f, -4.85451043e-01f, 3.85827906e-02f, 2.01191753e-01f, 4.98979300e-01f, -1.78222638e-02f, 1.88699529e-01f, 1.24235407e-01f, -4.61183786e-02f,
  -6.80106580e-02f, -9.36796591e-02f, 1.92299820e-02f, -7.18447054e-03f, -3.33514273e-01f, 9.51890647e-02f, 1.52882814e-01f, 3.46475601e-01f, 7.47627765e-02f, -1.42844483e-01f,
  -1.93703398e-01f, -3.23081732e-01f, 2.98649073e-01f, -1.38878539e-01f, -1.24715298e-01f, 6.79837987e-02f, 2.66391754e-01f, -3.56166810e-02f, 1.15218975e-01f, -5.84800601e-01f,
  -4.50167775e-01f, -6.21207654e-01f, -3.79678279e-01f, 4.08986062e-01f, 1.78645849e-01f, -3.44921917e-01f, -4.48548011e-02f, 6.52603135e-02f, -2.00821996e-01f, -3.22812408e-01f,
  -1.18521020e-01f, 9.14168432e-02f, -4.12322357e-02f, 1.27244890e-01f, 1.08508624e-01f, -2.91808575e-01f, -1.43947825e-01f, -1.43514916e-01f, -5.86063229e-02f, -1.09185614e-01f,
  5.86327314e-01f, -1.91188127e-01f, -1.18744731e-01f, 7.70347789e-02f, 9.12122875e-02f, 1.02203354e-01f, 2.89482772e-01f, -2.95887087e-02f, 4.35657412e-01f, 3.83030362e-02f,
  3.09962958e-01f, 2.01693475e-01f, 8.22450966e-02f, 2.67072171e-02f, -2.36490771e-01f, -4.37105626e-01f, -1.06733426e-01f, -2.89556179e-02f, 2.60529160e-01f, -1.43607602e-01f,
  -1.67028174e-01f, -3.02353483e-02f, -4.37247343e-02f, -4.05995660e-02f, -2.42618266e-02f, 4.40087431e-04f, 2.44985163e-01f, -1.30487099e-01f, 1.00326858e-01f, -1.67437539e-01f,
  3.76135290e-01f, 4.62767333e-01f, 1.99250579e-01f, -7.51607195e-02f, -1.19357165e-02f, -1.52970389e-01f, 4.65310039e-03f, -1.93964615e-01f, 2.45565891e-01f, -4.26699042e-01f,
  -1.51700050e-01f, -1.63823098e-01f, -3.87469009e-02f, -1.38451770e-01f, 9.94271487e-02f, -4.05091733e-01f, -5.29620051e-01f, 2.79973447e-01f, -4.69986685e-02f, -2.05316320e-01f,
  -3.00538540e-01f, 1.24740154e-01f, -1.09932654e-01f, -3.35028648e-01f, 5.95321767e-02f, -1.30950302e-01f, -1.03456296e-01f, -1.86067998e-01f, 9.85410288e-02f, 4.70378436e-02f,
  -1.67161569e-01f, -1.95505440e-01f, 4.88394856e-01f, -6.95910752e-02f, -2.05976442e-01f, 6.56783357e-02f, -1.21110685e-01f, 8.04337859e-02f, -2.00577393e-01f, 1.69416424e-02f,
  9.62872282e-02f, -1.53671727e-01f, 7.89768472e-02f, 1.18696075e-02f, 2.34072819e-01f, -7.40292594e-02f, -2.39551455e-01f, -7.08389655e-02f, 1.34127155e-01f, -2.58810431e-01f,
  4.51204598e-01f, 1.10134214e-01f, -7.00759441e-02f, -1.83635116e-01f, 2.13923812e-01f, -1.07999034e-01f, -1.93339139e-01f, -1.71658222e-03f, -4.86331135e-02f, -1.29501984e-01f,
  2.52167761e-01f, -1.88221589e-01f, -2.64720917e-01f, 1.27869159e-01f, 1.68866470e-01f, 1.86919361e-01f, 2.31592298e-01f, -6.15586117e-02f, 4.56370682e-01f, -6.43379837e-02f,
  1.81363389e-01f, 3.98151278e-01f, 3.12820710e-02f, -4.61782575e-01f, -2.55401850e-01f, -5.15522659e-02f, -1.84529498e-01f, -4.00419980e-01f, 2.28609577e-01f, 1.10443778e-01f,
  -1.81144819e-01f, -3.46062094e-01f, 4.04538602e-01f, 4.04154122e-01f, -2.96441048e-01f, -1.40504062e-01f, 5.06347597e-01f, -1.83809578e-01f, 1.13035381e-01f, -2.77143270e-01f,
  1.04332946e-01f, -6.32157736e-03f, 1.27944618e-01f, 1.48988971e-02f, 1.27104834e-01f, -5.04050925e-02f, -1.64021373e-01f, 2.05860808e-01f, -1.98892817e-01f, 8.75682533e-02f,
  9.39300470e-03f, -1.16912805e-01f, 2.32092515e-02f, 2.33189482e-02f, -1.22991286e-01f, 2.94293702e-01f, -2.50378191e-01f, 1.25433698e-01f, -2.33418141e-02f, -2.71368790e-02f,
  3.75311822e-02f, -3.29412483e-02f, 2.83047318e-01f, 7.32272089e-01f, -2.85783470e-01f, 3.54979187e-02f, -3.42203468e-01f, -6.63534701e-02f, -7.48487934e-02f, 2.70223737e-01f,
  -1.64905712e-01f, -6.64543733e-02f, -1.43238395e-01f, -6.90574152e-03f, -7.50408173e-02f, -2.02477083e-01f, -5.65994643e-02f, -1.32309094e-01f, -1.33571535e-01f, -2.10286155e-02f,
  -1.29314840e-01f, 3.27398717e-01f, -5.62978871e-02f, -3.25659961e-01f, 2.04243422e-01f, -1.36701986e-01f, 3.18986148e-01f, -1.20430164e-01f, 1.63402021e-01f, 2.26831645e-01f,
  3.57268393e-01f, 4.22283649e-01f, 4.52031255e-01f, 6.83546007e-01f, 6.68983996e-01f, -2.77286470e-01f, -2.61514634e-01f, 3.80680293e-01f, -1.08555071e-02f, -1.32595897e-01f,
  -1.31370991e-01f, 3.62892330e-01f, 3.83029699e-01f, -1.02105930e-01f, -8.82984623e-02f, 1.55416027e-01f, -1.26324549e-01f, 1.22273967e-01f, -1.42877862e-01f, -1.10517293e-01f,
  2.05005884e-01f, -1.40519738e-01f, -7.11373687e-02f, -9.78749096e-02f, -1.92569926e-01f, -1.72831550e-01f, 5.44188201e-01f, 1.30349636e-01f, -1.14475057e-01f, -1.96132407e-01f,
  -2.14569688e-01f, 1.19090647e-01f, -1.18391916e-01f, -2.64206409e-01f, -1.07227050e-01f, -2.54343331e-01f, 9.25657153e-02f, 5.26999652e-01f, -1.65601447e-01f, 8.33869874e-02f,
  2.80469768e-02f, -9.00235027e-02f, 8.07125270e-02f, -2.10451782e-02f, -6.32815734e-02f, 4.93164599e-01f, 9.63961123e-04f, 9.84679535e-02f, -1.03457808e-01f, 1.72556654e-01f,
  1.77466094e-01f, 1.12296730e-01f, -7.20005184e-02f, -1.21978208e-01f, -2.05021381e-01f, 1.60152521e-02f, -7.43350238e-02f, -2.85417736e-01f, 1.58749506e-01f, -6.67314157e-02f,
  4.04754996e-01f, 2.02824160e-01f, 5.18349290e-01f, 1.09047867e-01f, 3.71193528e-01f, 9.61509943e-02f, -1.61157295e-01f, -1.34364637e-02f, 3.36042978e-02f, -5.79038084e-01f,
  -4.89174366e-01f, -6.95103407e-01f, 3.66547108e-01f, -2.31013410e-02f, -2.13406667e-01f, -6.17051683e-02f, -1.53469995e-01f, 1.51236564e-01f, -2.08926201e-01f, 9.13244262e-02f,
  3.24595384e-02f, 1.60951987e-01f, -2.10059504e-03f, 9.08248127e-02f, -2.88327426e-01f, 5.10371864e-01f, 9.77709368e-02f, -2.75238939e-02f, -5.80270067e-02f, 1.33795619e-01f,
  2.07066998e-01f, -4.12820950e-02f, -1.52706027e-01f, -1.18707180e-01f, 8.25084448e-02f, 1.03094980e-01f, -2.09580868e-01f, 5.22430800e-02f, -9.81901884e-02f, 1.35615602e-01f,
  -3.55834335e-01f, -2.14043021e-01f, -1.98328361e-01f, -1.70490921e-01f, -1.02763278e-02f, 6.80048704e-01f, 2.57875584e-02f, 2.90909022e-01f, 1.97524235e-01f, -2.67920941e-01f,
  -1.27460420e-01f, 6.43464699e-02f, -9.45696011e-02f, 5.00354357e-02f, 4.38846678e-01f, -1.74518839e-01f, 6.07499704e-02f, -3.01717338e-03f, 2.08031431e-01f, -6.32913560e-02f,
  -1.83170021e-01f, -1.27094418e-01f, -2.40684554e-01f, -2.62477905e-01f, 3.59688759e-01f, 2.63893038e-01f, 1.28565252e-01f, 3.45879108e-01f, 1.51076272e-01f, 1.18785463e-01f,
  3.79903138e-01f, -2.46746674e-01f, -5.50393403e-01f, 2.94341803e-01f, -3.10258359e-01f, -6.89015090e-01f, 1.49504796e-01f, -3.63662750e-01f, 2.89230607e-02f, 3.94936949e-01f,
  1.25130326e-01f, 4.19529706e-01f, -2.15653375e-01f, -1.93091258e-01f, 4.21929181e-01f, -1.38940319e-01f, 1.02622271e-01f, 1.42343625e-01f, 1.89388692e-02f, 7.85115920e-03f,
  -2.71573603e-01f, 3.73523444e-01f, 1.24130763e-01f, 1.31974131e-01f, -2.79180169e-01f, -3.98988761e-02f, -8.08428321e-03f, -2.32350547e-02f, -4.12410721e-02f, -1.90959126e-01f,
  -8.86721835e-02f, 1.55349737e-02f, -3.33871275e-01f, -7.83234239e-02f, 4.44689840e-02f, -4.39206481e-01f, 6.43609226e-01f, -8.20714328e-03f, 1.19751550e-01f, -1.61723047e-01f,
  4.38456200e-02f, -1.72269404e-01f, 1.72981262e-01f, -2.04879478e-01f, 1.98474303e-01f, 1.64473295e-01f, -1.61980376e-01f, 2.54622459e-01f, 1.22082427e-01f, -3.67455259e-02f,
  -4.33881842e-02f, -2.30025753e-01f, -1.04938529e-01f, -4.74233925e-02f, -1.71677828e-01f, -2.44746476e-01f, -2.39688665e-01f, -3.27109918e-02f, -2.15247273e-01f, -2.65553802e-01f,
  -1.83380142e-01f, -3.32961410e-01f, -1.78681940e-01f, -3.21371913e-01f, 2.52010345e-01f, -9.45766196e-02f, 2.98351675e-01f, -3.49532694e-01f, 2.25915775e-01f, 3.60523969e-01f,
  2.62336791e-01f, 2.04997644e-01f, 2.91742325e-01f, -4.21283469e-02f, -1.66652501e-01f, -7.59499967e-02f, 4.79380600e-02f, 2.67424397e-02f, -1.35656625e-01f, -2.18786858e-02f,
  -3.20268124e-02f, 1.12615280e-01f, 1.36528283e-01f, 2.48017892e-01f, 1.04285188e-01f, -1.02366261e-01f, -4.23073024e-02f, -1.17973782e-01f, 2.89819390e-01f, 1.46679673e-02f,
  -2.72877663e-01f, 3.05937648e-01f, -1.50278419e-01f, -7.64750168e-02f, -3.84508558e-02f, 4.51985389e-01f, -6.95502982e-02f, 5.05848378e-02f, -2.79495388e-01f, -2.19169423e-01f,
  -3.04188132e-01f, -1.38570458e-01f, 1.91353887e-01f, -2.73733586e-01f, -9.72311497e-02f, -3.93733382e-02f, 1.26223257e-02f, 4.08188939e-01f, 1.24020055e-01f, -1.87101230e-01f,
  7.50257000e-02f, 1.46770850e-01f, 2.50043906e-02f, 2.00028107e-01f, -1.25252008e-01f, -2.10243445e-02f, -6.68911412e-02f, 8.39599147e-02f, -2.43605360e-01f, 2.01982677e-01f,
  -9.48357582e-02f, 1.83558881e-01f, -5.24621785e-01f, -3.04375589e-01f, 5.19096628e-02f, -2.06028931e-02f, -1.48884222e-01f, 2.95603871e-02f, -2.69836515e-01f, -4.09682214e-01f,
  9.66592878e-02f, -4.78221364e-02f, 1.36551112e-01f, 2.90790528e-01f, -1.36475964e-02f, 9.18702863e-04f, 3.12739089e-02f, 1.42607950e-02f, -1.89194288e-02f, -1.17881574e-01f,
  1.07924752e-04f, -1.01688258e-01f, -9.33549479e-02f, -1.36971865e-02f, -6.11137003e-02f, 9.20081604e-03f, -2.57682741e-01f, -2.39886716e-01f, 7.11266398e-02f, -1.22767858e-01f,
  -1.61743343e-01f, 1.93193480e-02f, -2.05700040e-01f, -8.65805745e-02f, 1.52740330e-02f, -1.20439075e-01f, 1.62540302e-01f, -1.55215949e-01f, 6.77759945e-02f, 9.61823761e-03f,
  -8.19078013e-02f, 3.92372012e-01f, -5.45430742e-02f, -2.03992605e-01f, 2.14555994e-01f, 1.69541463e-01f, -1.01789609e-01f, 1.64540142e-01f, 8.40910226e-02f, -1.86964318e-01f,
  -2.18374208e-01f, -1.87846631e-01f, -1.47490844e-01f, -1.62465855e-01f, 1.80786550e-01f, -2.12272540e-01f, -2.24189192e-01f, -1.56161860e-02f, -1.98186532e-01f, -1.89903736e-01f,
  -4.23001125e-02f, 2.36257017e-02f, 1.48357585e-01f, 9.13323104e-01f, -3.29539366e-02f, 3.17094028e-01f, -4.22743559e-02f, 2.87229210e-01f, 1.81179315e-01f, 1.57602236e-01f,
  -4.25706297e-01f, 1.92549840e-01f, 3.73351961e-01f, 1.10285856e-01f, -4.67378438e-01f, -2.52442688e-01f, -4.77311969e-01f, 4.82928663e-01f, 4.48011220e-01f, 5.47687449e-02f,
  -1.96672395e-01f, 2.21239746e-01f, -3.57434265e-02f, 2.15061158e-01f, 3.49402696e-01f, -6.31479472e-02f, -8.43065605e-03f, -9.92651433e-02f, 2.61643510e-02f, -6.78917170e-02f,
  6.90537214e-01f, -3.13287109e-01f, -2.92224407e-01f, -8.30081627e-02f, -8.54634494e-02f, 1.53775290e-01f, -2.77099218e-02f, -1.85204431e-01f, -2.13092715e-01f, 1.58811286e-01f,
  9.32029933e-02f, -8.27541053e-02f, -4.72286604e-02f, -1.87636346e-01f, -1.81578532e-01f, -2.57288605e-01f, -2.91023105e-02f, -4.57697690e-01f, -2.33485132e-01f, 8.17702189e-02f,
  3.72823477e-01f, 2.04836149e-02f, -2.17199493e-02f, -1.00583948e-01f, -3.32160369e-02f, 8.66847411e-02f, 1.66435286e-01f, 1.47455290e-01f, 4.03709672e-02f, 3.48144144e-01f,
  -3.35821778e-01f, 3.93030643e-01f, -4.04599309e-02f, -1.34445697e-01f, -2.03646198e-01f, -1.69468597e-01f, 1.44822970e-02f, 8.19644481e-02f, 3.94851863e-02f, -1.34710386e-01f,
  -1.29162818e-02f, -4.36531305e-02f, -3.04029912e-01f, 8.89979769e-03f, -2.51811028e-01f, 4.20980044e-02f, -4.06754375e-01f, 3.57155144e-01f, 4.23079848e-01f, 2.42201552e-01f,
  5.92747629e-01f, -2.06370845e-01f, -2.85791427e-01f, -2.61845380e-01f, 2.34083589e-02f, -2.58262247e-01f, -1.41859740e-01f, -4.49498855e-02f, 1.11711040e-01f, 2.11836144e-01f,
  -2.18069274e-02f, 8.53244886e-02f, 2.82076001e-01f, -3.72204976e-03f, -5.15341349e-02f, -5.30102327e-02f, -1.50654882e-01f, -8.73368990e-04f, 3.27867299e-01f, 3.40401344e-02f,
  -2.90253550e-01f, 1.66369565e-02f, 4.89343345e-01f, -1.93482623e-01f, -1.82285577e-01f, -1.02729890e-02f, 2.99487114e-01f, -1.10665977e-01f, 9.35233831e-02f, 2.60299534e-01f,
  1.49940237e-01f, 4.58214581e-01f, 4.73980516e-01f, -1.13181598e-01f, -1.72112733e-01f, -1.56840608e-01f, 8.87541845e-02f, 2.19302282e-01f, -9.33075622e-02f, -2.99748741e-02f,
  1.70089364e-01f, 1.60410919e-03f, -2.18064770e-01f, -2.71897197e-01f, 1.21943958e-01f, 4.90074717e-02f, 6.02782890e-02f, 2.51416981e-01f, 6.94497302e-02f, 7.26367235e-02f,
  1.96772650e-01f, -2.31363654e-01f, -4.56642024e-02f, -1.72352865e-01f, -2.76767910e-01f, 1.02854811e-01f, -1.60651088e-01f, -1.14968568e-01f, -8.50574449e-02f, 9.50846747e-02f,
  -4.61350352e-01f, -2.24371254e-01f, 4.48476374e-01f, 4.08766299e-01f, -3.84617329e-01f, 3.46451074e-01f, 4.71822172e-02f, -2.00606108e-01f, -1.39995009e-01f, 7.46365964e-01f,
  -5.56737930e-02f, 3.41289910e-03f, -2.62901541e-02f, -2.21989587e-01f, 3.82491834e-02f, 2.88374394e-01f, -3.76506858e-02f, 2.74049759e-01f, -1.65090561e-01f, 2.85443157e-01f,
  8.22610855e-02f, 7.70363510e-02f, -1.37749821e-01f, 7.95931667e-02f, -2.15428427e-01f, -2.38499939e-01f, 2.29643509e-01f, 7.07020536e-02f, -2.65425622e-01f, -9.98228788e-02f,
  -2.83375345e-02f, -1.12835377e-01f, -1.23125978e-01f, -8.34718719e-02f, 1.55508012e-01f, 4.69300687e-01f, -1.23302087e-01f, 5.08508161e-02f, -2.05478936e-01f, 1.47592589e-01f,
  -8.89207050e-02f, -3.98514643e-02f, 7.07729682e-02f, -2.65317202e-01f, 7.02005178e-02f, 7.38254488e-02f, 1.29554302e-01f, -2.27440387e-01f, 9.37711522e-02f, -1.30007610e-01f,
  -5.03236242e-02f, -2.23955214e-01f, 3.70966159e-02f, 1.43475905e-01f, 1.76951677e-01f, -1.82820827e-01f, -1.97452307e-01f, 6.85901847e-04f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  3.21537703e-02f, 6.08654656e-02f, -8.18071142e-02f, -1.01013027e-01f, 2.78974146e-01f, 1.85003966e-01f, 2.08450079e-01f, -2.87081629e-01f, -1.35610074e-01f, -1.13870703e-01f,
  -1.12968169e-01f, 6.22057803e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 52
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 6, 52
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        64, 12
    );
    }
    