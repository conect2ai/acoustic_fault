/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 4 x 120)
const int L0_fan_Wp_rows = 4;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  2.89182752e-01f, -2.21628636e-01f, -5.96953392e-01f, -1.29823923e-01f, -3.16115320e-01f, 3.58506553e-02f, -1.06791496e-01f, 3.00027251e-01f, 1.71200424e-01f, -1.38935506e-01f,
  -7.44957384e-03f, 1.84865624e-01f, 1.41135156e-01f, 1.36851460e-01f, 1.11737765e-01f, -3.19448382e-01f, -5.38035929e-01f, -1.86371505e-01f, 3.11466336e-01f, 2.31164634e-01f,
  -7.10343421e-02f, -4.68966924e-02f, 1.06881306e-01f, -3.61031923e-03f, -9.24407765e-02f, 1.82945222e-01f, -2.24817857e-01f, -1.22958489e-01f, -8.96987095e-02f, -6.14775717e-01f,
  -2.31401488e-01f, -9.71620455e-02f, 1.16625689e-02f, -4.15051542e-02f, -1.01667918e-01f, 8.92904401e-02f, 2.98278350e-02f, -1.31853381e-02f, 6.69840649e-02f, -6.26856089e-03f,
  -5.96355125e-02f, 4.04746905e-02f, -1.35423495e-02f, 5.36941364e-03f, -3.34928301e-03f, 3.97015549e-02f, 1.94440614e-02f, -5.83684035e-02f, -8.97219684e-03f, -1.07946796e-02f,
  -1.76456377e-01f, -2.15911657e-01f, -9.11999121e-02f, -8.79621133e-03f, 1.17254026e-01f, -9.53783318e-02f, -1.36370473e-02f, -1.14779780e-03f, 1.04719751e-01f, -6.41087145e-02f,
  -4.53580171e-03f, 1.36710154e-02f, -3.06542381e-03f, -2.41882484e-02f, 1.47258155e-02f, 4.33141254e-02f, -1.04997329e-01f, -1.06245670e-02f, 4.15116958e-02f, 1.75464451e-02f,
  -4.43396810e-03f, -5.77022620e-02f, -3.92926969e-02f, 2.76037138e-02f, -5.16201481e-02f, -3.75888273e-02f, 4.00639921e-02f, 1.41629614e-02f, 3.31181325e-02f, 3.10144257e-02f,
  7.71737918e-02f, -4.30634804e-02f, -5.19039063e-03f, 1.77669860e-02f, -4.91386019e-02f, 2.86482926e-02f, -1.81067344e-02f, 7.79320002e-02f, 6.57090396e-02f, -1.92534328e-02f,
  2.40549773e-01f, -2.50765868e-02f, -2.13850066e-02f, 7.16505796e-02f, -2.21471023e-02f, 4.01185267e-02f, -8.89967009e-02f, -1.24435658e-02f, -6.10901136e-03f, -2.17842776e-02f,
  6.25996059e-03f, 7.17686787e-02f, -5.85808270e-02f, -1.92660224e-02f, 5.35367131e-02f, 7.11745098e-02f, -3.60577926e-02f, -4.23762240e-02f, -1.44654157e-04f, -7.03035248e-03f,
  -2.12840340e-03f, 5.68898767e-02f, 2.33803183e-01f, 7.35906512e-03f, 6.07992969e-02f, 5.41706197e-02f, -5.21002896e-02f, 1.09875172e-01f, 7.26131797e-02f, 9.48483124e-02f,
  -5.15449464e-01f, -1.09830089e-01f, 1.56907253e-02f, -3.63688439e-01f, -4.30787951e-02f, 8.38560611e-02f, -1.13255836e-01f, -8.62044096e-02f, 3.68125290e-02f, -1.66543275e-01f,
  1.30655169e-01f, 2.56516058e-02f, -2.63704016e-04f, 8.41852799e-02f, -2.82124467e-02f, -2.59906769e-01f, -3.29152286e-01f, -1.58358246e-01f, 1.82378106e-02f, 3.15689705e-02f,
  -1.45549536e-01f, -1.16757177e-01f, -1.95536185e-02f, 5.73726296e-02f, -1.68190971e-01f, 1.07264005e-01f, 9.08448249e-02f, 9.37656686e-02f, 1.83807105e-01f, -2.48557866e-01f,
  -8.60536397e-02f, -1.18177257e-01f, 3.00118234e-02f, -9.51054171e-02f, -6.82432130e-02f, -1.49127021e-01f, -6.25158474e-02f, -1.20452732e-01f, -8.03430378e-02f, -1.34554327e-01f,
  -3.11748423e-02f, -1.98093392e-02f, -1.06384963e-01f, 1.12423245e-02f, -1.56084687e-01f, -9.19784158e-02f, -6.55804500e-02f, -1.81424290e-01f, -1.78224295e-01f, -1.58777852e-02f,
  -1.05002679e-01f, 6.14801571e-02f, -3.67479734e-02f, 6.06986620e-02f, -4.99493256e-02f, 3.91445942e-02f, 1.16109669e-01f, 1.55991660e-02f, 2.03846589e-01f, -1.46253586e-01f,
  2.83828974e-02f, -6.93803886e-03f, 4.93838005e-02f, -9.64215770e-03f, -5.23500964e-02f, 2.35064863e-03f, 1.33630987e-02f, 1.81330517e-02f, -8.33902042e-03f, 9.74101946e-03f,
  4.72439118e-02f, 2.79147644e-02f, -4.16984130e-03f, -3.43952142e-02f, 2.88109947e-02f, -7.02645108e-02f, 4.58639823e-02f, -4.93907481e-02f, 6.30595982e-02f, -3.32955122e-02f,
  -3.26447971e-02f, 2.85210367e-02f, -2.45008394e-02f, 5.10124415e-02f, 3.80451344e-02f, 1.32268518e-02f, -4.19088086e-04f, 1.30973816e-01f, -3.65107544e-02f, -3.23965214e-02f,
  -1.09637372e-01f, 1.88506991e-01f, -1.33508012e-01f, -1.06023267e-01f, -7.76584148e-02f, -1.34953391e-03f, -4.13881764e-02f, -5.59560815e-03f, -5.02319410e-02f, -9.01713818e-02f,
  -2.26200907e-03f, -8.22799876e-02f, -4.89071198e-02f, -2.87184920e-02f, 2.98479684e-02f, -7.69778788e-02f, -9.67390537e-02f, -9.20720249e-02f, 8.44579861e-02f, -3.13888751e-02f,
  3.22561758e-03f, -9.30930525e-02f, -1.07729651e-01f, -4.05735411e-02f, 5.45045594e-03f, -9.33968201e-02f, -3.55881676e-02f, -1.62559431e-02f, -3.68650630e-02f, -2.92996675e-01f,
  5.62638104e-01f, 1.43287122e-01f, 4.81719434e-01f, 1.12368926e-01f, 8.27590525e-02f, 1.78934336e-02f, 3.23073030e-01f, -3.60007025e-02f, -7.62791261e-02f, 1.91445634e-01f,
  -1.95809454e-01f, -3.14126402e-01f, -1.66080475e-01f, -1.54650226e-01f, -2.77412180e-02f, 4.23079580e-01f, 4.96209085e-01f, 1.10960282e-01f, -5.35555370e-02f, -8.01645368e-02f,
  -1.11208774e-01f, 2.77872179e-02f, -1.37567183e-03f, -6.80955499e-02f, 6.21687658e-02f, -1.55349880e-01f, 2.09613238e-02f, -6.36042356e-02f, -1.07714571e-01f, 2.81965166e-01f,
  1.65310502e-01f, 1.74183384e-01f, -1.77826494e-01f, -1.56151071e-01f, -5.59103042e-02f, 3.68630774e-02f, 1.69517566e-03f, -1.01521820e-01f, -9.65599418e-02f, -1.78417489e-02f,
  1.63957402e-02f, -2.27346718e-02f, -3.24804001e-02f, -1.38346225e-01f, 1.40653290e-02f, 2.82204878e-02f, -6.04039915e-02f, 2.09001638e-02f, -2.31495313e-02f, -5.77484109e-02f,
  -1.07755847e-01f, -7.27683157e-02f, 6.32162690e-02f, -6.28729835e-02f, -8.50985572e-02f, -3.53331096e-03f, -9.22120810e-02f, -4.67808917e-02f, -8.88411552e-02f, 3.94800752e-02f,
  1.24614388e-02f, 6.61057234e-02f, 3.50312479e-02f, 6.50003776e-02f, 1.43755497e-02f, 1.50124487e-02f, 3.61020900e-02f, -8.39253989e-05f, -2.17863377e-02f, 8.92756134e-02f,
  -2.81436611e-02f, 2.94627268e-02f, -2.90649757e-02f, 8.85966346e-02f, -9.64871198e-02f, 3.29809971e-02f, 4.50676642e-02f, -2.74674613e-02f, -8.07028487e-02f, -6.91779889e-03f,
  -4.91334386e-02f, 2.51634587e-02f, -1.41931698e-02f, -5.09567410e-02f, 2.50196345e-02f, 4.23334464e-02f, 3.57183963e-02f, -1.31356195e-02f, -4.65149172e-02f, 1.62003338e-02f,
  -1.76546142e-01f, -1.51966333e-01f, 6.59562498e-02f, -1.45571437e-02f, -6.87637599e-03f, -3.90830711e-02f, -9.85692143e-02f, -2.35209037e-02f, 4.18760329e-02f, -2.29794346e-02f,
  -1.00576937e-01f, -1.70795713e-02f, 5.78375952e-03f, -1.49849057e-02f, 1.73126371e-03f, -4.89950087e-03f, -2.98521463e-02f, 4.11034934e-03f, -1.51579166e-02f, -4.91296314e-02f,
  -4.98023964e-02f, 2.47465204e-02f, 1.27139643e-01f, -7.48078851e-03f, -1.50273461e-02f, 5.20180948e-02f, 8.36567301e-03f, -5.70079759e-02f, 6.33519217e-02f, 3.92713360e-02f,
  3.21949005e-01f, -1.31190807e-01f, 2.61474699e-01f, -1.04082763e-01f, 3.75176035e-02f, 2.73537129e-01f, 2.94799209e-01f, 2.91974872e-01f, 1.49583489e-01f, -2.44284924e-02f,
  -1.42305166e-01f, -3.85565341e-01f, -2.39237696e-01f, -1.07840084e-01f, 3.89660010e-03f, -8.08830857e-02f, -2.19154537e-01f, -6.56843334e-02f, 5.47504574e-02f, 1.41610816e-01f,
  -1.93830729e-01f, -3.80363986e-02f, 6.92119300e-02f, 1.54857099e-01f, -4.85694855e-02f, -2.18182847e-01f, 6.51857704e-02f, 7.16525316e-02f, 5.99365085e-02f, -2.78102368e-01f,
  -1.58104852e-01f, 3.32410425e-01f, 4.60608229e-02f, -2.70587541e-02f, -4.75628152e-02f, 4.37239856e-02f, 5.03910556e-02f, 1.77769326e-02f, 9.55098495e-03f, 8.95988718e-02f,
  -5.80734946e-02f, -6.24100827e-02f, -7.08219111e-02f, -4.72075939e-02f, 1.09623961e-01f, 5.10675758e-02f, 9.64729637e-02f, 4.76314388e-02f, -2.71089580e-02f, 8.62139538e-02f,
  -2.02684537e-01f, 5.12569807e-02f, 1.18496068e-01f, 1.37345776e-01f, 1.26533240e-01f, -1.06996559e-01f, 1.53678223e-01f, 2.08808482e-01f, 2.35464886e-01f, 1.12431057e-01f,
  -6.13762327e-02f, -4.09836555e-03f, -7.52485543e-02f, 2.40722317e-02f, -4.93289493e-02f, -4.55442294e-02f, -7.13608786e-02f, 3.91574902e-03f, -6.53052106e-02f, 3.21783088e-02f,
  -5.75397983e-02f, -2.05572154e-02f, -3.65057401e-02f, 4.53260802e-02f, -5.01004346e-02f, 3.23965661e-02f, -3.45834419e-02f, -3.24724354e-02f, 3.18772905e-02f, 3.86276208e-02f,
  -2.71801222e-02f, 4.63018566e-02f, -3.85665186e-02f, -1.49044842e-02f, 2.60312650e-02f, -3.30121443e-02f, -5.20779425e-03f, 5.51238470e-02f, 8.52505490e-02f, 9.20218378e-02f,
  -1.91271603e-01f, -5.81727959e-02f, -4.77623045e-02f, 2.02243794e-02f, -5.04052974e-02f, -4.79373150e-02f, -1.10154115e-01f, -2.87774038e-02f, -1.75537303e-01f, -2.44721840e-03f,
  3.35203074e-02f, -1.93550829e-02f, -8.34895149e-02f, 1.00870235e-02f, -4.22146022e-02f, 4.46906798e-02f, -8.52441266e-02f, -9.76232216e-02f, -2.52384227e-03f, 5.38040772e-02f,
  2.28895638e-02f, 8.28931257e-02f, -2.37880088e-02f, -1.52467145e-02f, 8.95845070e-02f, -6.02786727e-02f, -1.03765607e-01f, -5.96470907e-02f, -5.12675084e-02f, -2.84183007e-02f
};

// L0_fan_Wp_bar (Shape: 8 x 120)
const int L0_fan_Wp_bar_rows = 8;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  4.13097680e-01f, 1.33669943e-01f, -3.25036258e-01f, 5.01449883e-01f, -6.68467209e-02f, -3.58497977e-01f, -4.23526257e-01f, -7.49968588e-02f, 3.05932254e-01f, 1.27101660e-01f,
  -1.77823436e-02f, 1.09969094e-01f, 3.55423335e-03f, -1.87694132e-01f, -4.43914175e-01f, -2.66707808e-01f, -2.05114633e-01f, -3.70992154e-01f, -6.27293110e-01f, -4.73274589e-01f,
  -1.20002285e-01f, -6.48524910e-02f, -5.45578413e-02f, -1.03156418e-01f, 1.96124807e-01f, 8.26273039e-02f, 1.18410148e-01f, -1.69248937e-03f, -1.81578204e-01f, -3.65497023e-02f,
  -3.26152176e-01f, 7.15581477e-02f, -7.57135823e-02f, 1.89151019e-02f, 1.57580320e-02f, 4.80097905e-02f, -5.80121614e-02f, -2.44124630e-03f, 1.08569555e-01f, 2.19444241e-02f,
  -4.90994332e-03f, -6.64463863e-02f, -4.17743400e-02f, -1.19594470e-01f, -5.69559224e-02f, -1.83485240e-01f, -8.32391754e-02f, -1.03355691e-01f, -1.20099410e-01f, -9.40974280e-02f,
  -9.85989273e-02f, -8.96497369e-02f, -1.90877885e-01f, -1.46121674e-04f, -1.49175659e-01f, -1.15573995e-01f, -1.10737465e-01f, -4.61489633e-02f, -2.06081986e-01f, 1.33116797e-01f,
  2.97880120e-04f, 6.02089465e-02f, -3.10694929e-02f, 4.69090380e-02f, 3.98085378e-02f, 5.60081899e-02f, 4.40889504e-03f, -3.33677768e-03f, -5.44266179e-02f, 3.25712631e-03f,
  2.69117001e-02f, -4.17480245e-02f, 3.63308825e-02f, 1.93316527e-02f, 3.49426083e-02f, -3.07948999e-02f, -6.46826532e-03f, -2.82605179e-02f, -2.37250160e-02f, 4.46762294e-02f,
  -5.47447894e-03f, -4.65351157e-02f, 8.53481367e-02f, -2.13205200e-02f, -1.18738800e-01f, 1.16649969e-02f, -1.53226256e-02f, -2.15149745e-02f, 4.07388099e-02f, 1.28523447e-02f,
  2.97524542e-01f, -1.22458898e-01f, 1.13391675e-01f, -1.95324570e-02f, -5.40293939e-02f, 2.14783791e-02f, 3.11594978e-02f, 8.44807252e-02f, 2.84907632e-02f, -8.43341127e-02f,
  -6.82390332e-02f, -2.90543213e-02f, 7.01274872e-02f, -5.70278764e-02f, -7.91945755e-02f, -3.06061804e-02f, 3.07580270e-02f, -1.64757557e-02f, -2.55939737e-02f, 6.40840754e-02f,
  1.14694685e-01f, -1.14647141e-02f, 9.22802389e-02f, 6.72882199e-02f, -1.28601333e-02f, 1.71094984e-02f, -4.56738211e-02f, -1.39366031e-01f, -1.04743212e-01f, 1.73852399e-01f,
  -4.35417891e-01f, 3.79406512e-02f, -2.16161031e-02f, 2.34360680e-01f, 3.29917371e-01f, 8.02143365e-02f, 1.52255028e-01f, 7.67116621e-02f, 8.27608407e-02f, 4.11767364e-02f,
  -2.77225804e-02f, 2.94577420e-01f, 3.23784620e-01f, 2.61374980e-01f, 8.77412558e-02f, 1.81742668e-01f, 3.79921347e-01f, 3.73667702e-02f, 1.46518843e-02f, 1.38195276e-01f,
  3.11351120e-01f, -1.05120055e-02f, -2.20052391e-01f, 8.25148448e-02f, 2.33245656e-01f, 2.09939539e-01f, 8.64162445e-02f, 5.21698594e-02f, 9.91892666e-02f, 4.44819868e-01f,
  -4.10517193e-02f, -1.20576210e-01f, 1.49914250e-01f, 4.13160399e-02f, -8.11519101e-02f, -1.04524814e-01f, -1.75802074e-02f, -7.28230774e-02f, -9.81078204e-03f, -6.91149458e-02f,
  8.23046640e-02f, -6.94190934e-02f, 1.25028178e-01f, 3.89263756e-03f, -5.56268580e-02f, -1.15005625e-02f, -9.03291032e-02f, 6.13352982e-04f, 3.47729363e-02f, -3.76326106e-02f,
  1.53295770e-01f, 1.79711916e-02f, -1.21392392e-01f, 7.32092857e-02f, 8.85070339e-02f, -2.20565423e-02f, -4.27406505e-02f, -8.02167431e-02f, -8.24265331e-02f, -1.80190772e-01f,
  4.77752052e-02f, -1.49453014e-01f, -2.73153484e-02f, -3.43757309e-02f, 1.13690449e-02f, -2.49299984e-02f, 7.99985081e-02f, 5.56723587e-02f, 5.11167757e-03f, 2.44777035e-02f,
  -1.17744589e-02f, 4.29598062e-04f, -2.11858023e-02f, 4.28070277e-02f, 2.87185516e-02f, -1.53458565e-02f, 2.83389203e-02f, -2.22178232e-02f, 9.98583995e-03f, -5.89763224e-02f,
  4.21099365e-02f, 3.73173170e-02f, -1.57408416e-01f, -8.95691477e-03f, -2.38923375e-02f, 2.66327802e-02f, -1.11846952e-02f, 1.01090071e-03f, -5.05340360e-02f, 1.26941008e-02f,
  -1.74303204e-01f, 3.53924446e-02f, 1.67381763e-03f, 3.03592626e-02f, -2.24765334e-02f, -7.30336308e-02f, 8.63001402e-03f, -7.58801773e-02f, -4.22266982e-02f, 7.95262083e-02f,
  -7.12279081e-02f, -9.91906524e-02f, -3.00083254e-02f, -7.39718303e-02f, -1.26004025e-01f, -3.85362878e-02f, -4.15423848e-02f, -3.45154814e-02f, -1.04212314e-02f, -6.11561909e-02f,
  6.61557587e-03f, -5.85706197e-02f, -6.31777868e-02f, -9.38350409e-02f, -2.83708032e-02f, 1.91634987e-02f, -8.90903249e-02f, -1.37259513e-01f, -2.13388979e-01f, -1.16776302e-01f,
  2.35502586e-01f, -3.98285151e-01f, 2.40213305e-01f, 2.41624508e-02f, -4.33654517e-01f, -3.64508867e-01f, -7.12242484e-01f, -1.40241683e-01f, 4.56578434e-02f, -3.83507937e-01f,
  -2.64056653e-01f, 5.51867709e-02f, 1.79866090e-01f, 1.14375643e-01f, 2.36335874e-01f, -2.22519726e-01f, -8.96494016e-02f, 4.40011024e-01f, 4.86581117e-01f, -6.95427135e-02f,
  -1.33036643e-01f, 8.24160874e-02f, 3.67190540e-01f, 1.76044211e-01f, -2.48709962e-01f, -5.29670343e-02f, -2.36369092e-02f, -1.37096988e-02f, -1.48834333e-01f, -2.08519623e-01f,
  -7.69585371e-02f, 8.28645006e-02f, 1.52199298e-01f, -3.60765457e-02f, -1.32788926e-01f, 7.74782449e-02f, -1.11688480e-01f, 9.03658345e-02f, -1.73936095e-02f, 2.86108814e-02f,
  -8.60658102e-03f, -7.20815407e-03f, 1.19707741e-01f, 3.73574495e-02f, -1.02060800e-02f, -3.22409458e-02f, 1.02675632e-01f, 2.79101133e-01f, 7.40196109e-02f, -1.28759935e-01f,
  -2.43035689e-01f, -1.41416654e-01f, 4.15711738e-02f, 2.39198040e-02f, 6.05116487e-02f, 1.45873383e-01f, -1.03460915e-01f, 4.74922080e-03f, 6.06677271e-02f, -2.56566912e-01f,
  -6.14520237e-02f, -2.98090335e-02f, -7.27441981e-02f, -3.75264254e-03f, -8.69963784e-03f, -1.36228343e-02f, 6.91412836e-02f, -5.92912547e-02f, 1.27563858e-02f, -1.09365126e-02f,
  2.06778478e-02f, -3.90089564e-02f, 4.67567481e-02f, 1.16848564e-02f, 4.63726668e-04f, 1.04154600e-02f, -3.96379568e-02f, 3.43155973e-02f, -4.38403673e-02f, 5.38591631e-02f,
  4.16147262e-02f, 8.18209723e-02f, -3.07033118e-02f, 2.82157306e-02f, -5.61222993e-02f, 9.16180238e-02f, 1.16248196e-02f, -6.92332312e-02f, -4.35930006e-02f, -7.47832879e-02f,
  -4.40957583e-02f, 1.24026343e-01f, -8.47611576e-02f, 1.22092009e-01f, -3.62070017e-02f, -1.85828637e-02f, -3.32036167e-02f, 3.65402885e-02f, 9.09061059e-02f, 2.54592206e-02f,
  -1.38855027e-02f, 4.05524038e-02f, 1.51805924e-02f, -7.20225275e-03f, 9.88994632e-03f, -5.31566367e-02f, -1.67591766e-01f, -1.28120405e-03f, 1.23156188e-02f, -1.31633701e-02f,
  -4.23677713e-02f, -8.82067531e-02f, -1.33835748e-01f, -1.30492181e-01f, -9.25432593e-02f, -7.14125261e-02f, -7.44492561e-02f, -1.52695939e-01f, -7.23843053e-02f, -4.42970842e-01f,
  5.23222744e-01f, 2.93135017e-01f, 3.09239060e-01f, 1.53522417e-01f, 5.16478568e-02f, 1.77136101e-02f, 1.19475320e-01f, 1.41727999e-01f, -4.74334173e-02f, 1.94448471e-01f,
  2.41424054e-01f, 9.01046544e-02f, 6.77401423e-02f, -2.71302462e-02f, 1.49049819e-01f, -1.31575078e-01f, -2.21883267e-01f, 7.99312294e-02f, 1.06108412e-01f, -4.11445387e-02f,
  -6.78082854e-02f, 5.82819097e-02f, 3.08569223e-01f, 1.12803057e-01f, -1.60315894e-02f, -2.03969464e-01f, -1.24254702e-02f, 1.46098197e-01f, 1.67743396e-02f, -1.28320716e-02f,
  1.91400632e-01f, 4.27737683e-01f, -3.58056664e-01f, -1.05163187e-01f, 9.69030485e-02f, -2.06419695e-02f, -4.75447513e-02f, 1.57816871e-03f, 8.04346278e-02f, -2.16750912e-02f,
  -5.88308237e-02f, 1.19687222e-01f, 7.12337941e-02f, 7.12975338e-02f, 5.33965304e-02f, -7.86483064e-02f, 1.83578245e-02f, 9.11993384e-02f, 4.80570160e-02f, 5.67910932e-02f,
  -8.24606791e-02f, 1.50670528e-01f, 1.93642378e-01f, -7.00241700e-02f, 8.41131732e-02f, 3.87929170e-03f, 7.90004507e-02f, -4.80923504e-02f, 3.87785811e-04f, 3.13607082e-02f,
  -9.67034400e-02f, -3.67199965e-02f, 5.27410135e-02f, 2.61296183e-02f, 1.14950888e-01f, 3.16751488e-02f, -8.34506154e-02f, 5.21537922e-02f, 1.91432575e-03f, 5.54936379e-02f,
  6.37822598e-02f, -1.67441391e-03f, 1.87665748e-03f, -5.97639661e-03f, -1.43741665e-04f, 8.10091496e-02f, 9.45419106e-06f, -1.76130682e-02f, 6.16387948e-02f, -2.12358665e-02f,
  1.20879494e-01f, -1.95218194e-02f, 6.77569285e-02f, 1.28431479e-02f, -6.45920727e-03f, -4.67026420e-02f, 3.86882536e-02f, 5.35312332e-02f, 3.67606548e-03f, -2.71486882e-02f,
  -1.01957172e-01f, 2.51607090e-01f, -2.04164401e-01f, -1.30568087e-01f, 2.45735161e-02f, -1.93964709e-02f, -1.07194884e-02f, 5.30167995e-03f, 5.12731913e-03f, -1.21703908e-01f,
  1.05343811e-01f, -1.00459922e-02f, 1.63925469e-01f, -8.84643644e-02f, -6.09736815e-02f, -1.12385742e-01f, -2.16692444e-02f, -1.03082523e-01f, -1.52969420e-01f, -6.30336031e-02f,
  -1.16072692e-01f, -1.58489555e-01f, -7.07698315e-02f, -1.60938099e-01f, -2.28500277e-01f, -1.64621741e-01f, -1.40571252e-01f, -1.42539844e-01f, -2.00048372e-01f, -2.02514783e-01f,
  -5.32550693e-01f, 1.05382502e-01f, 4.09683138e-02f, -3.78069282e-01f, 1.28000766e-01f, 2.95863241e-01f, 3.78619105e-01f, 1.40282407e-01f, -2.03375295e-01f, 8.07623416e-02f,
  1.55706570e-01f, -3.69688123e-02f, -2.36397967e-01f, -8.13748781e-03f, 9.08987150e-02f, 1.44699186e-01f, -1.52195722e-01f, -1.26124039e-01f, 1.38454633e-02f, 2.56521106e-01f,
  -6.42788410e-02f, -2.20010117e-01f, -2.91962117e-01f, -2.11971298e-01f, -5.18597178e-02f, -1.78407475e-01f, -2.87919402e-01f, -2.66005784e-01f, 1.83562525e-02f, -2.93695003e-01f,
  -1.36924475e-01f, 7.20178112e-02f, 9.28373262e-02f, -1.49401352e-02f, 3.19527239e-02f, -5.89872822e-02f, 2.63113976e-02f, 1.73182935e-02f, -3.23028974e-02f, -5.78305982e-02f,
  -7.84182101e-02f, 3.58905196e-02f, -3.49486433e-02f, -8.70584249e-02f, -4.31533642e-02f, -9.29075573e-03f, -1.76054966e-02f, -1.58633664e-01f, -4.28385008e-03f, 6.86053187e-02f,
  2.31713858e-02f, -2.46821642e-02f, -1.28769830e-01f, -2.87602167e-03f, 7.73479640e-02f, -1.62073776e-01f, -8.90786722e-02f, -6.61239550e-02f, -2.62668207e-02f, -2.99980730e-01f,
  6.58119693e-02f, 4.91770133e-02f, 1.18824884e-01f, 1.44165494e-02f, -2.89168060e-02f, -2.37425081e-02f, -5.51883727e-02f, -3.14548612e-02f, -3.33229490e-02f, -9.17691067e-02f,
  -6.86641932e-02f, 5.89553304e-02f, -5.11213578e-02f, -4.56622615e-02f, -8.15028474e-02f, 5.14397770e-03f, -6.25604531e-03f, 4.27751616e-03f, -6.62998781e-02f, 4.44131941e-02f,
  -1.41585395e-02f, 6.59976900e-02f, -2.33692657e-02f, -2.82567646e-02f, 5.35428412e-02f, -2.29670331e-02f, 1.17469588e-02f, 9.49793980e-02f, -7.35899620e-03f, 4.19548305e-04f,
  -4.95608807e-01f, 1.38273016e-01f, -1.90834448e-01f, -8.17512050e-02f, -6.38169572e-02f, -9.19120386e-02f, -2.99065914e-02f, -3.45929489e-02f, 4.10951972e-02f, 5.61075993e-02f,
  1.24164075e-01f, 4.38970001e-03f, -1.13766432e-01f, 6.26698360e-02f, -1.86100435e-02f, 3.89668159e-02f, 5.93547635e-02f, -1.22672871e-01f, 4.61214967e-03f, 5.80058731e-02f,
  -2.05493197e-02f, -1.36788487e-01f, -2.37322077e-01f, -1.07079312e-01f, -1.30535722e-01f, -2.73440838e-01f, -9.63482037e-02f, -2.73023993e-01f, -2.59261519e-01f, -4.46751952e-01f,
  3.77143994e-02f, -1.82033420e-01f, 1.63284734e-01f, -1.13510326e-01f, -4.20816839e-02f, 1.76484510e-01f, 1.32292747e-01f, 3.31154764e-02f, -1.30274504e-01f, -2.03246530e-02f,
  -4.08238582e-02f, 1.26946226e-01f, 2.30050758e-01f, 8.31747353e-02f, 1.03465930e-01f, 2.61140708e-02f, 8.74460265e-02f, 1.86013535e-01f, 3.89134377e-01f, 2.27459833e-01f,
  7.68850930e-03f, -1.52474374e-01f, -6.69661835e-02f, -7.78241381e-02f, -3.39449078e-01f, 3.47976871e-02f, -2.02314228e-01f, -1.91345468e-01f, -2.64796913e-01f, -3.60624790e-01f,
  2.52927333e-01f, -1.11369111e-01f, 1.00280419e-01f, -1.83037788e-01f, -1.51697800e-01f, 1.52098462e-02f, 8.10357258e-02f, -2.26942934e-02f, -3.13749947e-02f, -8.03818554e-02f,
  -9.39935222e-02f, -4.75164875e-02f, -1.36152476e-01f, -6.34788647e-02f, -9.36161503e-02f, -4.35772575e-02f, -1.65455759e-01f, 1.07148150e-03f, -8.30703303e-02f, -5.09359390e-02f,
  -1.15782261e-01f, -7.14686066e-02f, 6.96251914e-02f, 1.05126284e-01f, -4.78633717e-02f, 3.33902873e-02f, -1.40841216e-01f, -3.40692252e-02f, -3.57754380e-02f, -1.83845125e-02f,
  4.05520312e-02f, 6.06042221e-02f, -9.42931045e-03f, 1.05937885e-03f, 1.26976311e-01f, 1.45413289e-02f, 2.55233422e-02f, 4.59047370e-02f, 2.86413431e-02f, 7.38560110e-02f,
  1.05533088e-02f, 8.68853405e-02f, 5.63738197e-02f, -9.91983898e-03f, 6.16697520e-02f, -3.35814469e-02f, 3.16368602e-02f, -2.72380412e-02f, -5.29307127e-02f, -4.40657288e-02f,
  5.68078086e-02f, -2.97087803e-02f, 1.04988962e-02f, 1.01307528e-02f, -8.37017074e-02f, 1.12067722e-02f, -1.11715496e-02f, -1.19623709e-02f, -2.59961169e-02f, -8.99493974e-03f,
  1.41757697e-01f, 1.39148220e-01f, 6.97096437e-02f, -3.01019195e-02f, -9.35172290e-02f, -1.98162585e-01f, -3.81348841e-02f, -8.56165588e-02f, -3.75006869e-02f, 1.78738534e-02f,
  -1.30144238e-01f, 4.07106020e-02f, -4.94529344e-02f, -1.32271528e-01f, 9.25061181e-02f, -1.27550568e-02f, -1.90063357e-01f, 7.37950429e-02f, 2.75600720e-02f, -2.23302796e-01f,
  -6.28996193e-02f, 1.14761174e-01f, 4.17660981e-01f, 2.72157997e-01f, 7.30143562e-02f, 3.83345306e-01f, 2.76087821e-01f, 1.53444529e-01f, 2.78459430e-01f, 2.88232416e-01f,
  1.06447029e+00f, 4.37083021e-02f, -1.86274067e-01f, 1.52163520e-01f, -4.53393489e-01f, -4.20752406e-01f, -4.89233464e-01f, -1.76368982e-01f, 1.90900981e-01f, 4.94428799e-02f,
  5.09799942e-02f, 3.94955695e-01f, 4.08340305e-01f, 2.28675738e-01f, 1.42916471e-01f, -1.82041839e-01f, -8.13245177e-02f, 2.42435783e-01f, 1.59746915e-01f, -1.27408773e-01f,
  -6.17513061e-02f, 7.54537294e-03f, 2.80736208e-01f, -3.16463150e-02f, -1.35441273e-01f, 1.03271350e-01f, -2.59064108e-01f, -8.62000138e-02f, -3.49117555e-02f, 2.57990777e-01f,
  1.33464947e-01f, 1.11914501e-01f, 3.11369691e-02f, 1.26783371e-01f, -6.13672473e-02f, 1.08177729e-01f, 7.73066282e-02f, -1.47310738e-03f, -8.25032219e-02f, -6.04765378e-02f,
  -6.94689015e-03f, 1.28507689e-01f, 4.48077545e-02f, -5.50254434e-03f, -1.48714468e-01f, -7.83846527e-02f, -8.24099258e-02f, 3.35800275e-02f, 2.04432029e-02f, -2.54617836e-02f,
  -2.05122232e-02f, 1.03767905e-02f, -1.38437510e-01f, -2.75249690e-01f, -8.32795538e-03f, 6.98292106e-02f, -8.02583918e-02f, -2.38579735e-02f, -5.04398867e-02f, 9.31436941e-02f,
  8.44407976e-02f, 4.62959707e-02f, 5.67422323e-02f, 1.64906622e-03f, 4.48173471e-02f, -2.40955669e-02f, -6.24195710e-02f, 1.22199710e-02f, 6.05912097e-02f, -3.61499675e-02f,
  -7.53530785e-02f, 1.06066443e-01f, -5.80496453e-02f, -1.74932703e-02f, 6.68055788e-02f, -2.32011136e-02f, -1.03447121e-02f, 3.75406034e-02f, 1.03135791e-03f, 1.33357663e-03f,
  8.56185630e-02f, -8.05628598e-02f, -2.12510768e-02f, -4.98285070e-02f, -7.14238361e-02f, -3.33812088e-02f, 4.21625376e-02f, 4.91747297e-02f, -1.43867284e-02f, 1.57159492e-02f,
  -1.42894521e-01f, -6.35066181e-02f, 1.81233302e-01f, 3.77086848e-02f, 3.91662307e-03f, 7.21376156e-03f, 2.35993284e-04f, 2.03351621e-02f, -5.95652349e-02f, -3.12799141e-02f,
  -7.10185990e-02f, -4.87931557e-02f, -2.99902055e-02f, -5.05097657e-02f, 2.32533552e-02f, -3.60063016e-02f, 7.15776011e-02f, 9.75977629e-02f, -5.61107248e-02f, -1.05716601e-01f,
  -1.70393493e-02f, 4.77237180e-02f, 1.07787438e-01f, 8.45102966e-02f, 7.00161979e-02f, 1.07142143e-01f, -4.60478812e-02f, -2.39451397e-02f, 5.06648645e-02f, -2.23864950e-02f,
  3.75015914e-01f, 2.34117404e-01f, -8.19584727e-03f, 8.98166969e-02f, 8.64583552e-02f, 7.65203312e-03f, 6.61608800e-02f, -1.10831022e-01f, -1.30533248e-01f, 1.40215859e-01f,
  8.04950148e-02f, 7.05369860e-02f, -9.74734202e-02f, -9.74666253e-02f, -1.41503289e-01f, -1.56403929e-01f, 8.35962407e-03f, -1.78314243e-02f, -2.65488271e-02f, 2.11970112e-03f,
  1.33824393e-01f, 1.76949263e-01f, 9.20783803e-02f, 5.49339205e-02f, 1.06204614e-01f, 9.26965475e-02f, 4.14396226e-02f, 9.10385624e-02f, 1.49636537e-01f, 1.22221984e-01f,
  1.37607142e-01f, 1.80607125e-01f, -1.28440291e-01f, 9.02168453e-03f, 4.93532754e-02f, -3.74400569e-03f, 5.55902794e-02f, -1.32005448e-02f, -2.80736778e-02f, 4.90843356e-02f,
  1.35670424e-01f, -6.04349514e-03f, 4.92050797e-02f, -3.56095023e-02f, -5.10340482e-02f, -1.09238654e-01f, -1.17825367e-01f, -1.28083840e-01f, -8.46999958e-02f, -6.81801885e-02f,
  5.60915396e-02f, 1.20850079e-01f, -3.66966538e-02f, -8.52294266e-02f, -6.93147331e-02f, -7.51424730e-02f, -8.95301253e-03f, -1.13269105e-03f, -3.01137697e-02f, -8.53901356e-02f,
  -2.54968200e-02f, 6.79322928e-02f, -4.43373993e-02f, 3.92606258e-02f, -1.25419620e-05f, -4.98770783e-03f, -3.87908183e-02f, 3.44100669e-02f, 3.18329372e-02f, -2.12053880e-02f,
  -2.63545732e-03f, 5.73815312e-03f, 1.83543563e-02f, 1.74043681e-02f, 5.39402012e-03f, -4.44454029e-02f, 2.58612875e-02f, -6.60086274e-02f, 3.43350135e-03f, 1.01108201e-01f,
  -4.20874394e-02f, -3.21655022e-03f, -4.75060605e-02f, -5.20851016e-02f, 6.46855086e-02f, -4.46819179e-02f, 1.43494345e-02f, -4.80778664e-02f, -3.87058333e-02f, 4.28210162e-02f,
  7.33673992e-03f, -9.05671343e-02f, -6.71309307e-02f, -2.46912874e-02f, -1.12593109e-02f, -9.32138041e-02f, -3.26523441e-03f, -6.77405894e-02f, -6.01899857e-03f, -2.63950471e-02f,
  4.85477904e-05f, 2.98215225e-02f, -6.79603890e-02f, -1.52913490e-02f, -4.50980999e-02f, -2.66903522e-03f, -3.05820443e-02f, -1.11554493e-03f, -7.83345625e-02f, -8.01822916e-02f,
  -2.49384921e-02f, -6.92770183e-02f, -1.11670837e-01f, -1.80114493e-01f, -1.31895870e-01f, -2.25597825e-02f, -1.23597533e-01f, -4.70856130e-02f, -1.03397332e-01f, -1.82291344e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 8)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 8;
const float L0_fan_Bp_bar_data[] = {
  2.64209867e-01f, 2.78505236e-01f, 4.73342150e-01f, 4.52196330e-01f, 2.91720688e-01f, 7.31312931e-01f, 6.56364441e-01f, 1.13633111e-01f
};

// L1_fan_Wp (Shape: 4 x 16)
const int L1_fan_Wp_rows = 4;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  -6.99753761e-01f, -1.01129711e-01f, -3.75513583e-01f, 1.70965552e-01f, 3.79060894e-01f, -3.87335569e-01f, 7.37009048e-02f, -4.28945750e-01f, -1.68954581e-01f, 4.13471609e-01f,
  -2.28500023e-01f, -3.78696591e-01f, -1.83811590e-01f, 5.13760686e-01f, 1.08322263e-01f, -3.76897246e-01f, -6.76333487e-01f, -2.14297101e-01f, -6.16199553e-01f, -1.65219650e-01f,
  1.14000730e-01f, 3.54290605e-01f, 3.04527804e-02f, 4.96654660e-01f, 1.23409182e-01f, -2.64324069e-01f, 4.35263872e-01f, 1.03594869e-01f, -1.32321596e-01f, 7.54708871e-02f,
  3.04080963e-01f, -2.67244130e-01f, -4.41282362e-01f, -3.17264944e-01f, -1.35749459e-01f, 2.25336745e-01f, -1.44678116e-01f, -8.63389447e-02f, 2.10716158e-01f, 5.87500572e-01f,
  -3.74991819e-02f, -1.84619606e-01f, 4.03970897e-01f, 1.53844163e-01f, -1.09999076e-01f, 4.07638140e-02f, 7.55778253e-01f, 7.01019838e-02f, 3.60765576e-01f, 5.50526343e-02f,
  3.13190334e-02f, 1.12120293e-01f, 2.41878450e-01f, 3.41533273e-01f, -2.95553237e-01f, 5.41052163e-01f, 2.78510123e-01f, -2.58318901e-01f, -3.91842335e-01f, 1.94412395e-01f,
  3.73744786e-01f, -2.30026543e-01f, -6.65936053e-01f, 7.40864351e-02f
};

// L1_fan_Wp_bar (Shape: 8 x 16)
const int L1_fan_Wp_bar_rows = 8;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  7.61605382e-01f, 2.80689478e-01f, 7.29817301e-02f, 6.45709515e-01f, 2.53778428e-01f, -6.77224815e-01f, 5.43165684e-01f, 3.88592899e-01f, -3.84203881e-01f, 3.51413995e-01f,
  -3.99581760e-01f, -2.63061345e-01f, 4.47523743e-01f, 9.71671045e-01f, -1.33653660e-03f, -3.21794808e-01f, -6.21268332e-01f, -1.79265082e-01f, -2.18245551e-01f, 6.29645437e-02f,
  2.40517363e-01f, 2.01457813e-01f, -3.99227172e-01f, -2.38216609e-01f, 8.70637875e-03f, 5.46378016e-01f, -3.05863153e-02f, -3.12053621e-01f, 1.16427195e+00f, 2.86941916e-01f,
  -4.22142804e-01f, 2.33611912e-01f, -2.49821082e-01f, 6.01131082e-01f, 5.07687628e-01f, 3.82389516e-01f, -2.42430240e-01f, 1.16176687e-01f, -3.51546228e-01f, -9.82443810e-01f,
  -1.44133016e-01f, 6.47293448e-01f, 5.37206054e-01f, 2.11578459e-02f, -5.33777952e-01f, 6.82082653e-01f, 4.61611718e-01f, -1.85457662e-01f, -8.00356567e-02f, 5.51791489e-01f,
  1.37267530e-01f, 5.09329140e-01f, -8.53500009e-01f, 2.10904889e-03f, 4.49214071e-01f, -3.80299911e-02f, -2.29016498e-01f, 4.66099847e-03f, 1.06539488e+00f, 7.66740620e-01f,
  7.09601641e-02f, -5.31846821e-01f, 1.04687750e+00f, 3.40757936e-01f, 5.45060635e-01f, 1.54089212e-01f, 5.84722102e-01f, 2.48775870e-01f, 1.04191875e+00f, 4.70112324e-01f,
  -8.48353028e-01f, -4.48582888e-01f, 1.13185489e+00f, 1.87429041e-01f, 2.86349207e-01f, 2.86799103e-01f, -4.10542756e-01f, 2.34544739e-01f, 5.66244483e-01f, -2.13957861e-01f,
  -1.19768843e-01f, 8.00113752e-02f, -2.95127869e-01f, 5.51014207e-02f, -1.48206025e-01f, -5.52053332e-01f, 8.32510591e-01f, 6.83638215e-01f, 3.79768899e-03f, 4.62342381e-01f,
  -4.81309950e-01f, 9.51132834e-01f, 3.04859042e-01f, 4.77181345e-01f, 1.39189109e-01f, 1.82862476e-01f, -2.36836046e-01f, 5.71213305e-01f, 7.30981708e-01f, 1.57323495e-01f,
  1.39731526e-01f, -1.33247599e-02f, 2.42336169e-02f, -7.20980346e-01f, 1.01066399e+00f, 5.93479037e-01f, -6.40700698e-01f, -6.54164627e-02f, -4.25368510e-02f, -1.29989594e-01f,
  5.46291828e-01f, 2.66778111e-01f, 6.86699450e-01f, -2.07208455e-01f, -1.15838431e-01f, -2.56305560e-03f, 2.92723626e-01f, 7.49745667e-01f, -3.98015797e-01f, 1.33966804e-02f,
  -4.37547088e-01f, 1.95781887e-01f, 6.79679155e-01f, 1.24564551e-01f, 5.82359850e-01f, 4.56636190e-01f, 4.50242609e-02f, -3.33868772e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 8)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 8;
const float L1_fan_Bp_bar_data[] = {
  7.40521669e-01f, 6.62627518e-01f, 2.51979649e-01f, 3.39816928e-01f, 2.83252448e-01f, 3.92808646e-01f, 1.54939011e-01f, 2.81038344e-01f
};

// L2_linear_W (Shape: 12 x 16)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 16;
const float L2_linear_W_data[] = {
  4.34411794e-01f, -7.36185551e-01f, -2.55676508e-01f, -1.27724990e-01f, -1.96681425e-01f, 1.10938203e+00f, 5.90875447e-01f, 7.09710777e-01f, -6.26818657e-01f, 1.00802243e+00f,
  -3.25305313e-01f, 6.33361414e-02f, 1.94575146e-01f, -1.67750195e-01f, -3.23898375e-01f, 2.36210093e-01f, 3.08805436e-01f, -4.25461143e-01f, -7.73656964e-01f, -5.75964153e-01f,
  8.04337680e-01f, 8.00037622e-01f, 6.97773993e-02f, -2.11232170e-01f, -2.90120780e-01f, -5.37345469e-01f, 6.69989824e-01f, -9.08619910e-02f, 5.62548816e-01f, 3.45550090e-01f,
  1.30407497e-01f, 2.40009025e-01f, -2.67757267e-01f, 4.41019028e-01f, 6.42196089e-02f, -7.47676240e-03f, -4.72575098e-01f, 1.23995215e-01f, -7.03573003e-02f, -4.24167901e-01f,
  -5.74022174e-01f, -4.83155251e-01f, 6.09346628e-01f, 6.77717924e-01f, -2.17985343e-02f, -9.16085601e-01f, -6.93705022e-01f, 7.89589226e-01f, -2.29143858e-01f, 5.84397495e-01f,
  4.58030134e-01f, -5.69964290e-01f, -5.31324208e-01f, -4.84381169e-01f, -3.35837513e-01f, 6.75511181e-01f, 6.73288107e-01f, 7.18990445e-01f, -5.34762919e-01f, -3.68953466e-01f,
  -2.89457440e-01f, -3.49859625e-01f, -2.89259821e-01f, 6.39813900e-01f, -5.61448455e-01f, 4.74927187e-01f, 4.24327672e-01f, -5.23375511e-01f, -5.39347529e-01f, 5.95662236e-01f,
  -1.47991613e-01f, 8.30877781e-01f, -4.11250204e-01f, -1.33824304e-01f, -7.88899302e-01f, -4.75513458e-01f, 1.19381642e+00f, -2.55825281e-01f, 2.45092452e-01f, 5.37412524e-01f,
  7.30553389e-01f, 3.93769532e-01f, 4.66331124e-01f, 4.21796471e-01f, 2.29456335e-01f, 1.88413769e-01f, 3.65486592e-02f, 2.30499566e-01f, -3.51205515e-03f, -4.09002930e-01f,
  -9.51085314e-02f, -5.63295245e-01f, 8.83133233e-01f, 2.81310380e-01f, 9.45436239e-01f, -9.01560545e-01f, 2.46307567e-01f, 1.44583002e-01f, -7.20986187e-01f, -6.52346611e-01f,
  -2.68526852e-01f, 5.60090765e-02f, -3.60722303e-01f, -5.16205013e-01f, -3.17617990e-02f, -5.17382145e-01f, -1.15463525e-01f, 1.32589257e+00f, -7.79441357e-01f, -3.33961956e-02f,
  -3.65369290e-01f, -3.31625551e-01f, -5.40239215e-01f, -8.80722821e-01f, -1.38656422e-02f, -4.08442259e-01f, 5.29908240e-01f, 1.10740058e-01f, -7.02229261e-01f, -3.48858327e-01f,
  1.05434150e-01f, 6.29397690e-01f, 5.33604681e-01f, -2.17001602e-01f, -8.45293880e-01f, 1.90575629e-01f, 5.16464233e-01f, -9.56028402e-02f, 2.92187601e-01f, -3.24848257e-02f,
  1.07672848e-01f, 3.68278265e-01f, 2.75328279e-01f, -3.06413084e-01f, -1.27154455e-01f, -2.98082799e-01f, 1.27450228e+00f, -1.53798059e-01f, -4.02673453e-01f, -4.51573551e-01f,
  -7.47081220e-01f, 5.89275658e-01f, -4.85879600e-01f, -2.61822164e-01f, -3.32947522e-01f, 1.07653417e-01f, -9.04531181e-02f, -1.59974694e-02f, -5.04432976e-01f, -8.35992575e-01f,
  3.24950337e-01f, -1.66323006e-01f, -1.01360559e+00f, -3.06294024e-01f, 3.99265856e-01f, 6.47398531e-01f, -1.54272884e-01f, -4.45412695e-01f, 9.74829495e-01f, -4.71643090e-01f,
  -2.77979851e-01f, 1.99597433e-01f, 2.20245019e-01f, 3.55328172e-01f, 7.85707474e-01f, -3.79356235e-01f, -1.19965458e+00f, -2.82364786e-01f, 2.86511064e-01f, 1.63289949e-01f,
  6.97712421e-01f, -9.06489909e-01f, 3.73405278e-01f, -6.45512938e-01f, -1.10549465e-01f, 9.84511077e-02f, -1.68352515e-01f, 4.02180761e-01f, 2.47856587e-01f, 4.22501355e-01f,
  -2.93723136e-01f, 3.67602594e-02f, 1.79168373e-01f, 5.04494488e-01f, -2.64337480e-01f, -1.81214511e-01f, -9.53434348e-01f, 5.23195326e-01f, -5.62008917e-01f, 1.07053852e+00f,
  -5.49967825e-01f, -5.10571636e-02f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  3.52907538e-01f, -2.48481199e-01f, -2.15909351e-02f, 3.29389796e-02f, 2.37120241e-01f, -1.04571819e-01f, -2.49259934e-01f, 9.68103558e-02f, 2.15146810e-01f, 1.67705625e-01f,
  -4.62433789e-03f, 2.15896994e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 4, 8
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 4, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        16, 12
    );
    }
    