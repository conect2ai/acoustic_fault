/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 128 (x1)
    * Saída: 12
    * Buffer Máx: 128
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 128;
    const int FAN_MAX_BUFFER_SIZE = 128;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 12 x 120)
const int L0_fan_Wp_rows = 12;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  3.40739161e-01f, -7.42735788e-02f, -1.47340149e-01f, -3.11154574e-02f, -1.58060148e-01f, -2.52924383e-01f, -2.78235465e-01f, -9.87240076e-02f, 8.68908390e-02f, -1.34583935e-01f,
  -1.56360760e-01f, 2.32792390e-03f, -1.01014435e-01f, 8.50062538e-03f, -5.71010970e-02f, -1.35704324e-01f, -1.05333880e-01f, 6.61718398e-02f, 5.66818379e-02f, -9.38567966e-02f,
  -8.19494650e-02f, 4.60771509e-02f, 1.53433755e-01f, 2.94764023e-02f, 5.59852123e-02f, -6.67191250e-03f, -4.35205586e-02f, -1.76279491e-03f, -1.38285264e-01f, 7.27646872e-02f,
  -1.80790484e-01f, 1.89883783e-01f, -9.03986394e-02f, 1.65484380e-02f, 3.55544277e-02f, 5.98691739e-02f, -4.15492132e-02f, 7.02421963e-02f, 5.88351451e-02f, 8.83370042e-02f,
  7.82809630e-02f, 2.44799033e-02f, -3.94612737e-02f, 5.39590754e-02f, 5.49615063e-02f, -5.19393981e-02f, 9.93032530e-02f, 1.05860427e-01f, -3.32755372e-02f, 1.77218169e-02f,
  9.16879810e-03f, -2.56214123e-02f, 3.01233530e-02f, -3.27785462e-02f, -1.09522222e-02f, 5.76290861e-02f, 2.44274531e-02f, 2.60993242e-02f, 1.02919107e-02f, 1.56434059e-01f,
  -7.15430230e-02f, -6.27720505e-02f, -8.84983689e-02f, -8.31439048e-02f, -7.99004957e-02f, -1.90828703e-02f, -2.94910744e-02f, -3.83532792e-02f, -8.50926861e-02f, -8.66698247e-06f,
  -2.26878636e-02f, -6.75862283e-02f, -9.25717056e-02f, -8.23988989e-02f, -3.38405073e-02f, -2.78421175e-02f, -9.21010971e-02f, -1.08960725e-01f, -9.64720398e-02f, -1.56090350e-03f,
  9.76514712e-04f, -4.88338619e-02f, -8.29431228e-03f, -1.15961067e-01f, -1.46343336e-01f, -1.24542348e-01f, -8.29438642e-02f, -7.05755576e-02f, -8.84503126e-02f, -7.67143890e-02f,
  8.52210075e-02f, -1.04503751e-01f, 4.59338538e-02f, 4.74517718e-02f, 1.03094876e-02f, 7.70425573e-02f, -5.78612415e-03f, 3.83027941e-02f, 7.70009756e-02f, -6.17819279e-02f,
  -2.75991694e-03f, 7.21042678e-02f, -6.81493431e-02f, 7.38661587e-02f, -7.42857205e-03f, -2.80164406e-02f, 1.29976710e-02f, 1.56675819e-02f, -1.76051185e-02f, -3.26876598e-03f,
  -6.94257021e-02f, 9.80180725e-02f, 2.74908170e-02f, -3.72223556e-02f, -1.93560198e-02f, 6.89025819e-02f, -6.04685880e-02f, 6.06524535e-02f, -4.07871455e-02f, 4.96151075e-02f,
  -6.24751449e-02f, 1.27392560e-01f, 1.60032704e-01f, -2.82808412e-02f, 1.38478652e-01f, 1.10689797e-01f, 1.31849065e-01f, 6.44358844e-02f, 2.62581464e-02f, -2.02895552e-02f,
  4.72806841e-02f, -1.66044161e-02f, 8.64689499e-02f, 1.48412064e-01f, 8.60884339e-02f, 2.20436916e-01f, 2.33894229e-01f, 1.03912823e-01f, 1.25033289e-01f, -4.85933982e-02f,
  8.03429559e-02f, -8.52248594e-02f, 3.73799838e-02f, -2.53630243e-02f, 4.76534218e-02f, 4.98691238e-02f, 1.22820288e-01f, 5.34135289e-02f, 1.74023464e-01f, 8.60818289e-03f,
  -1.05870217e-01f, 1.06359489e-01f, 3.90685126e-02f, 9.64406058e-02f, 1.30987331e-01f, -6.32978752e-02f, 6.69128820e-02f, -4.94006602e-03f, 1.16655439e-01f, -4.95364368e-02f,
  5.68698905e-02f, 1.06154168e-02f, 7.61198625e-02f, 1.98011771e-02f, 7.72728622e-02f, -4.41132486e-02f, 3.83226164e-02f, -4.37368033e-03f, 1.06196769e-01f, 8.69048387e-02f,
  5.59170917e-02f, 1.87562108e-01f, 1.79321975e-01f, 6.45130575e-02f, -2.31562741e-02f, 9.58017632e-02f, 8.52232054e-02f, 1.36401039e-02f, 5.54194003e-02f, -9.98946726e-02f,
  -2.19563134e-02f, -9.17902403e-03f, -3.72323357e-02f, -8.08376893e-02f, -7.35125169e-02f, -9.90630388e-02f, -1.30644083e-01f, -4.26290631e-02f, -4.62532081e-02f, -8.16311911e-02f,
  -1.39952078e-01f, -3.54140140e-02f, -3.34543549e-02f, -1.50044098e-01f, -1.47922173e-01f, -6.97854161e-02f, -9.02350768e-02f, -6.01162761e-02f, -6.85834438e-02f, -1.11238686e-02f,
  -1.02830678e-01f, -1.19128972e-01f, -4.92005423e-02f, -8.22329149e-02f, -3.47943380e-02f, -1.30359707e-02f, -1.42921552e-01f, -9.82633233e-02f, -6.08731024e-02f, -1.53301969e-01f,
  -2.16308460e-01f, 3.02718580e-01f, 1.99025515e-02f, -3.24950963e-02f, -8.10311362e-03f, 1.37740653e-02f, 6.24944642e-02f, 2.14241836e-02f, 6.67943656e-02f, -1.32756112e-02f,
  8.76891539e-02f, -2.67488509e-02f, 1.54705355e-02f, 7.94563368e-02f, 7.61079565e-02f, -4.05921042e-02f, 9.42320600e-02f, 1.32583916e-01f, 1.30289197e-01f, 4.27501164e-02f,
  4.72586714e-02f, 1.30295932e-01f, 1.01326980e-01f, 5.05793898e-04f, 1.06250018e-01f, 1.49184272e-01f, 1.83025897e-02f, 5.24876565e-02f, 1.35260522e-01f, -4.61908244e-02f,
  -2.38364369e-01f, -2.79662162e-01f, -1.38500497e-01f, -2.01623708e-01f, -3.33985426e-02f, -3.02539527e-04f, -1.49861440e-01f, 8.21398478e-03f, -3.20978239e-02f, -7.17908964e-02f,
  -3.58577780e-02f, -4.21906784e-02f, 2.45386641e-02f, 1.16264727e-02f, -7.02358875e-03f, -2.08520487e-01f, -2.11128220e-01f, -6.28841296e-02f, -5.12664579e-03f, -4.67038639e-02f,
  -1.20462105e-01f, -9.80250463e-02f, -2.32637748e-01f, -2.57251263e-01f, -2.83346266e-01f, -2.44139388e-01f, -2.32775420e-01f, -1.21863693e-01f, -2.07125098e-01f, -3.40991795e-01f,
  -2.49077410e-01f, -2.04652086e-01f, -2.93093901e-02f, -9.10590068e-02f, -1.89873189e-01f, -1.10873766e-01f, -1.02454908e-01f, -1.81086376e-01f, -1.28680453e-01f, -1.44832909e-01f,
  -1.65496781e-01f, -1.04549378e-01f, -8.25969055e-02f, -1.36140317e-01f, -6.56117126e-02f, -1.38452843e-01f, -7.52551183e-02f, -8.04828182e-02f, -5.82646132e-02f, -8.27060342e-02f,
  -5.88532314e-02f, -1.08689725e-01f, -8.44999999e-02f, -1.72114670e-01f, -1.25490308e-01f, -8.59357566e-02f, -1.27526239e-01f, -1.98075697e-01f, -9.56929103e-02f, -2.62836576e-01f,
  1.10437401e-01f, 1.32738009e-01f, 1.24752887e-01f, 1.11573137e-01f, 5.21817617e-02f, 1.70981959e-01f, 3.66983190e-02f, 7.18691349e-02f, 1.35006577e-01f, 7.01483265e-02f,
  6.42648414e-02f, 1.44007623e-01f, 4.66062389e-02f, 9.79737267e-02f, -9.49962158e-03f, 2.20446177e-02f, 8.26397091e-02f, 2.38832999e-02f, 6.78157061e-02f, 1.83514148e-01f,
  5.44511080e-02f, 9.03533846e-02f, 1.37211785e-01f, 2.68823318e-02f, 3.96682322e-02f, 1.19607069e-01f, 1.38124719e-01f, 1.53938577e-01f, 6.12841845e-02f, 1.20385297e-01f,
  -1.97114833e-02f, 8.44329149e-02f, -2.16117039e-01f, -1.49265230e-01f, -2.09637523e-01f, -9.38556492e-02f, -1.90294310e-01f, -9.08825845e-02f, -1.20977685e-01f, -2.15146631e-01f,
  -1.51209338e-02f, -1.55933157e-01f, -1.50216192e-01f, -1.67192191e-01f, -1.52482510e-01f, -1.25278279e-01f, -1.00723326e-01f, -1.37236089e-01f, -6.53726310e-02f, -1.10241264e-01f,
  -1.37628004e-01f, -1.12705246e-01f, -8.11522976e-02f, -6.35136962e-02f, -7.39686191e-02f, 3.30952555e-02f, -4.62960862e-02f, -7.92136714e-02f, 6.34116400e-03f, -2.00490803e-01f,
  -7.16608688e-02f, 3.50531131e-01f, 6.85472712e-02f, 9.88433361e-02f, 8.47345069e-02f, 1.67472512e-01f, 2.37102062e-01f, 6.20718747e-02f, 7.80575052e-02f, 9.92030576e-02f,
  -7.01852813e-02f, -1.45216107e-01f, -1.20481871e-01f, -5.10627478e-02f, -1.15766279e-01f, 1.58820644e-01f, 2.43989110e-01f, -2.45211385e-02f, -1.19076706e-01f, -5.91053516e-02f,
  9.42512676e-02f, -1.44994967e-02f, -1.44597426e-01f, -6.63210228e-02f, 1.02931149e-01f, 2.46959850e-02f, 1.39690995e-01f, 1.26047820e-01f, 2.28896588e-01f, 3.34494025e-01f,
  -2.56018788e-02f, 1.97769627e-01f, -8.52102041e-02f, 4.02489901e-02f, -2.60164551e-02f, -2.35733390e-02f, 5.52646676e-03f, 5.22485003e-02f, 6.21509328e-02f, 1.49640992e-01f,
  4.29108851e-02f, -7.44861225e-03f, 3.22475135e-02f, 1.10652812e-01f, 2.99917813e-02f, 7.14276358e-02f, 8.83930326e-02f, 1.16676157e-02f, -9.74157546e-03f, 1.39020056e-01f,
  1.13235332e-01f, 1.02330193e-01f, 3.83861028e-02f, 1.05539344e-01f, 1.70327619e-01f, 5.86909615e-02f, 7.75186941e-02f, 1.67712912e-01f, -2.35077776e-02f, 1.62735596e-01f,
  -2.44891886e-02f, -4.39611003e-02f, 1.69890821e-02f, 2.36232318e-02f, -1.07399620e-01f, 2.18182965e-03f, -8.34964141e-02f, 2.49615554e-02f, -7.29184672e-02f, -7.85029829e-02f,
  -9.69885066e-02f, -1.59693658e-02f, -7.57725760e-02f, 1.76978577e-02f, -8.58951285e-02f, -2.96717957e-02f, -4.42144126e-02f, -1.93924550e-02f, -4.06489745e-02f, 1.32224634e-02f,
  3.67629073e-05f, -8.41108635e-02f, -4.92455177e-02f, -2.76913028e-02f, -6.72564730e-02f, -7.71609247e-02f, -3.65903936e-02f, -3.34017798e-02f, -4.43493128e-02f, -9.66014042e-02f,
  -5.33460490e-02f, -5.58285080e-02f, 1.14257559e-02f, 1.25974463e-02f, 1.27144963e-01f, 5.68240369e-03f, 2.07090788e-02f, 2.62432527e-02f, 5.63391708e-02f, 7.86683783e-02f,
  3.68514471e-02f, 4.46065776e-02f, 8.46119691e-03f, 2.34790817e-02f, -4.33778390e-02f, 1.31658297e-02f, 7.52068311e-02f, 2.35666502e-02f, 3.53556871e-02f, 1.25591308e-01f,
  1.73416138e-01f, 1.09245591e-01f, 3.27969007e-02f, 7.30448961e-02f, 4.85282838e-02f, 5.05048456e-03f, -2.30820151e-03f, 1.01208642e-01f, -4.87029962e-02f, -2.35300418e-02f,
  -2.36226380e-01f, -4.16346788e-01f, 1.08812727e-01f, 6.29767850e-02f, 4.51839529e-02f, 6.74703419e-02f, 5.36291860e-03f, 4.39725518e-02f, 7.06333434e-03f, -4.02936451e-02f,
  -1.00819156e-01f, -3.56549658e-02f, 5.79963215e-02f, 2.14648433e-02f, 1.84101135e-01f, -3.50158364e-02f, 1.86976999e-01f, 3.03048551e-01f, 3.60874742e-01f, 1.35013789e-01f,
  6.58886507e-02f, 1.15518635e-02f, 4.30683605e-02f, 4.06289659e-03f, -4.54441272e-02f, 1.48075789e-01f, 5.10789938e-02f, 6.48587197e-02f, -6.05656914e-02f, -1.08241115e-03f,
  4.37912755e-02f, -3.19257170e-01f, 1.29170954e-01f, -4.84687835e-02f, 3.19967009e-02f, -5.86053729e-03f, -6.99891075e-02f, 6.65400103e-02f, -1.09444864e-01f, -4.91202809e-04f,
  -5.07525839e-02f, -1.26731545e-02f, 2.37951688e-02f, -8.83187074e-03f, -4.87360880e-02f, -3.49130854e-02f, -6.27003387e-02f, 2.22743675e-02f, 1.34853303e-01f, -9.11014900e-02f,
  -8.07024240e-02f, 3.86259072e-02f, 1.04441851e-01f, 4.23651822e-02f, 2.36003958e-02f, 4.56663929e-02f, -5.42670907e-03f, 2.83095203e-02f, 3.79849644e-03f, 5.47889285e-02f,
  9.66899171e-02f, -2.07875501e-02f, 5.37045076e-02f, -2.61829868e-02f, -4.17387523e-02f, -4.72922772e-02f, 1.76146999e-02f, -3.27728800e-02f, 8.88007134e-02f, -7.39435181e-02f,
  -4.02268197e-04f, 1.51215065e-02f, 4.28299420e-02f, -3.96252749e-03f, 6.82857931e-02f, -9.97301191e-03f, 1.15572043e-01f, -4.80972379e-02f, 1.01030394e-01f, -4.37917672e-02f,
  -3.27171274e-02f, 3.80614065e-02f, 1.86981875e-02f, -1.19788735e-03f, 1.22795857e-01f, 8.45696218e-03f, 1.55799985e-02f, 7.01656416e-02f, -4.63119224e-02f, -7.16424808e-02f,
  -2.34909970e-02f, 1.44602641e-01f, -6.01373166e-02f, 2.69181244e-02f, -3.21535803e-02f, -4.89936993e-02f, -7.85363391e-02f, 5.43193370e-02f, -1.31117955e-01f, -3.82254235e-02f,
  4.92300503e-02f, -1.21677153e-01f, -1.08212546e-01f, 5.01750149e-02f, -2.34802682e-02f, 4.56875972e-02f, -1.67820677e-02f, 7.97911882e-02f, 2.47248095e-02f, -1.46847470e-02f,
  1.54218376e-02f, 1.19413793e-01f, 9.67838913e-02f, 9.13556442e-02f, 1.05154887e-01f, 1.40307412e-01f, 5.11677265e-02f, 6.89443797e-02f, 7.99179003e-02f, -1.42209781e-02f,
  -4.59546238e-01f, -3.32542181e-01f, 1.12843402e-02f, -2.73830444e-03f, 1.94534391e-01f, 2.47307166e-01f, 1.23741187e-01f, 8.28631967e-02f, 2.14267783e-02f, -3.58909443e-02f,
  -2.47149333e-01f, -1.36679247e-01f, -2.42753193e-01f, -1.33187652e-01f, -1.11104071e-01f, -6.05235510e-02f, -3.42982523e-02f, 3.89017425e-02f, -1.87633112e-02f, 8.86202008e-02f,
  9.16314498e-02f, -1.22633554e-01f, -2.43442729e-01f, -1.05820820e-01f, -6.81562871e-02f, 3.34833600e-02f, -3.46544012e-02f, -2.02645808e-02f, -3.09151430e-02f, 3.96263339e-02f,
  -2.06030667e-01f, -2.59518415e-01f, -8.42460766e-02f, -4.76475358e-02f, -7.80862197e-02f, -1.81885764e-01f, -1.63740143e-01f, -1.13646202e-01f, -8.86078179e-02f, -1.01089098e-01f,
  -1.34449424e-02f, -1.29446313e-01f, -6.89446554e-02f, 2.10216362e-02f, -3.23946700e-02f, -8.49550664e-02f, -1.72240451e-01f, -1.99073590e-02f, -6.99458867e-02f, -1.02318175e-01f,
  -7.50137568e-02f, -4.38529141e-02f, -7.66584799e-02f, -1.29740641e-01f, -5.04879765e-02f, -6.77790567e-02f, -5.71520068e-02f, -9.50624943e-02f, -1.40510082e-01f, -1.92123264e-01f,
  7.33349174e-02f, 1.20589182e-01f, 4.73287813e-02f, 9.66489017e-02f, 1.04712240e-01f, 6.47291495e-03f, 8.82833824e-02f, 1.18009001e-01f, 9.44036245e-02f, 7.92274028e-02f,
  7.74327219e-02f, 1.31427214e-01f, 3.12553607e-02f, 8.40224475e-02f, 7.68887922e-02f, 1.32359326e-01f, 8.52229148e-02f, 1.12353876e-01f, 2.26242561e-02f, 7.63104185e-02f,
  1.36149094e-01f, 9.44289416e-02f, 9.82009470e-02f, 7.12925568e-02f, 1.13432206e-01f, 7.31821731e-02f, 7.93293193e-02f, 1.80423602e-01f, 9.08294991e-02f, 2.15150326e-01f,
  -3.08441937e-01f, -2.10629717e-01f, -1.60621196e-01f, -1.38122633e-01f, 1.06662307e-02f, -5.20732440e-02f, -1.11966856e-01f, -1.04346305e-01f, -1.27773941e-01f, -1.31958807e-02f,
  -5.11756279e-02f, -6.66632056e-02f, -1.84591025e-01f, -1.06650896e-01f, 3.64393815e-02f, -2.21277550e-02f, -1.18461132e-01f, -7.76065812e-02f, -1.13776047e-03f, -8.39252546e-02f,
  -1.22744106e-01f, 6.40993530e-04f, -5.35791032e-02f, -1.18471235e-01f, 5.35350703e-02f, -1.47312373e-01f, -9.37682837e-02f, 5.17265871e-02f, -1.05631962e-01f, -1.59443170e-01f,
  -2.43378744e-01f, 3.95486176e-01f, 3.67844433e-01f, -8.37678313e-02f, 1.01496108e-01f, 1.63178474e-01f, 3.96228194e-01f, 1.96085170e-01f, 6.11976162e-02f, 2.43216842e-01f,
  9.66055915e-02f, -6.56523034e-02f, 1.89662222e-02f, 1.12082735e-01f, 1.73518926e-01f, 3.36375773e-01f, 2.93841422e-01f, 3.70048918e-02f, 1.19279446e-02f, -2.04199664e-02f,
  -4.38466705e-02f, -1.40664399e-01f, -3.77299637e-02f, -1.73874088e-02f, 7.39437565e-02f, 7.01967105e-02f, 5.00822440e-02f, 7.81999603e-02f, 1.61032483e-01f, 2.12475404e-01f,
  1.75429553e-01f, -1.22085633e-02f, 1.53082497e-02f, 5.13329878e-02f, 4.82539497e-02f, 2.68697049e-02f, 8.85408372e-02f, 1.38702929e-01f, 2.75219474e-02f, 5.41110709e-02f,
  -6.01322902e-03f, 6.56787008e-02f, -5.76698035e-03f, -7.51686655e-03f, 1.11507751e-01f, 6.35986775e-02f, 6.91153780e-02f, 4.77413386e-02f, 1.19453624e-01f, 6.86926842e-02f,
  1.13669246e-01f, 1.11719988e-01f, 5.67629263e-02f, 1.48298174e-01f, 1.87413052e-01f, 2.95303967e-02f, 1.32845417e-01f, 5.19954599e-02f, 6.45726547e-02f, 1.72961786e-01f,
  -1.50124535e-01f, 2.00359784e-02f, 3.56209688e-02f, -4.56884541e-02f, -3.61289643e-02f, -3.94295268e-02f, -8.69887357e-04f, -4.97701541e-02f, -1.31102027e-02f, -2.97861304e-02f,
  -2.67655198e-02f, -3.03922314e-02f, -1.16818585e-01f, -9.09384042e-02f, -8.03867206e-02f, 4.09441292e-02f, -5.50776049e-02f, -4.23020385e-02f, -8.97297040e-02f, -1.28991222e-02f,
  -1.81436725e-02f, -2.80026458e-02f, -1.20578893e-01f, -1.72921829e-02f, -2.72913538e-02f, 5.18751889e-02f, -7.50155821e-02f, 1.24534247e-02f, -3.07963006e-02f, -8.15961584e-02f,
  3.18639143e-03f, 2.99587417e-02f, 5.75596392e-02f, 4.56284126e-03f, 7.72706941e-02f, 4.75351848e-02f, 6.94016665e-02f, 6.25034645e-02f, 7.16384947e-02f, 1.19161300e-01f,
  3.83512750e-02f, 5.65202720e-02f, 1.37882054e-01f, 1.26026139e-01f, 1.06361911e-01f, 1.48999587e-01f, 4.03162837e-02f, 7.80818146e-03f, 1.41169220e-01f, 1.38121694e-01f,
  1.36174142e-01f, 1.93423882e-01f, 1.27180561e-01f, 2.14913040e-01f, 3.53051983e-02f, 5.68250678e-02f, 1.28949791e-01f, 5.23972996e-02f, 1.09247521e-01f, 1.65401056e-01f,
  -1.58677265e-01f, 3.78087983e-02f, -2.81401545e-01f, 2.86419615e-02f, 1.89140476e-02f, -2.10485250e-01f, -3.03209387e-02f, -1.88210994e-01f, -4.01761606e-02f, 7.80986845e-02f,
  1.43004835e-01f, 3.07222102e-02f, -2.19265580e-01f, -1.53846025e-01f, -3.48617643e-01f, -3.34123015e-01f, -4.06392783e-01f, -4.19646680e-01f, -3.58595431e-01f, -1.72295541e-01f,
  -4.67654429e-02f, -1.88585408e-02f, -2.44775474e-01f, -2.42991954e-01f, -3.36227007e-02f, 2.81640459e-02f, -1.40226275e-01f, -7.11106043e-03f, -1.55121148e-01f, -1.52462721e-01f,
  -1.42983943e-01f, -1.66876093e-01f, -1.75638705e-01f, 8.36485357e-04f, -1.11354366e-02f, -1.73005074e-01f, -9.68967676e-02f, -1.36902675e-01f, -1.20940983e-01f, -6.64828047e-02f,
  -1.00477710e-02f, -4.63123955e-02f, -6.89652888e-03f, -1.11355640e-01f, -1.00423187e-01f, -1.21623188e-01f, -3.21645252e-02f, -2.12396026e-01f, -2.18955502e-01f, 2.80411784e-02f,
  7.83509091e-02f, 6.06867531e-03f, -1.30720809e-01f, -1.77001506e-01f, -1.34476766e-01f, -9.89769176e-02f, -4.69791219e-02f, -2.65432429e-02f, -9.12215561e-02f, 2.90543004e-03f,
  8.46432615e-03f, 9.18265209e-02f, 1.44550085e-01f, 1.68321326e-01f, 1.93206206e-01f, 1.16254851e-01f, 8.02703574e-02f, 1.06096573e-01f, 1.12365171e-01f, 9.46312919e-02f,
  4.89352569e-02f, 1.36651859e-01f, 1.34348527e-01f, 1.42802102e-02f, 1.89662501e-01f, 1.62111953e-01f, 1.18293174e-01f, 1.07670270e-01f, 1.03930615e-01f, 8.79374966e-02f,
  4.37361784e-02f, 1.09484240e-01f, 1.75709918e-01f, 1.56591117e-01f, 1.22333646e-01f, 1.51655853e-01f, 5.32173477e-02f, 2.19153807e-01f, 8.85091498e-02f, 1.51594892e-01f,
  1.00623958e-01f, -2.93282926e-01f, -1.26238450e-01f, -1.14986442e-01f, -4.20862325e-02f, -1.90091118e-01f, -4.55461815e-02f, -7.02023655e-02f, -1.96489483e-01f, -8.12799186e-02f,
  -8.65928158e-02f, -1.40349433e-01f, -1.27477497e-01f, -6.41020364e-04f, -5.43180779e-02f, -3.00090611e-02f, -3.11401510e-03f, -2.08362147e-01f, -2.34041408e-01f, -2.21071858e-02f,
  -1.02448635e-01f, -2.13404328e-01f, -1.96600065e-01f, -8.76564682e-02f, -1.81454971e-01f, -2.12386400e-01f, -1.64559364e-01f, -1.81699038e-01f, -2.28028834e-01f, -7.54561499e-02f,
  2.25217983e-01f, -2.94809580e-01f, -2.64958203e-01f, -8.62934589e-02f, -2.74382867e-02f, 4.27598283e-02f, -9.00832564e-02f, 1.67835336e-02f, 1.41036153e-01f, -4.66964506e-02f,
  -5.91278896e-02f, 1.60602525e-01f, 6.23097010e-02f, 3.14979963e-02f, 1.55425221e-01f, -1.48533985e-01f, -4.21999618e-02f, 5.47185987e-02f, 6.78150654e-02f, 1.07706308e-01f,
  -3.53930891e-02f, -1.08817019e-01f, -1.84502322e-02f, -8.67200419e-02f, -1.21172056e-01f, 1.98094230e-02f, -1.85725272e-01f, -2.05861434e-01f, -1.44568477e-02f, -7.81665221e-02f,
  -2.32611820e-01f, -1.51478425e-01f, 2.59314701e-02f, 3.76052745e-02f, -1.85364410e-01f, -8.27588979e-03f, 3.54568735e-02f, -1.04872212e-01f, -1.28564298e-01f, -1.11783035e-01f,
  -7.99718499e-03f, -3.41286771e-02f, -4.29777838e-02f, -1.16706759e-01f, -6.93483725e-02f, -5.35921715e-02f, -9.79093090e-02f, -1.09341688e-01f, 2.97783446e-02f, 5.63149480e-03f,
  -1.27383590e-01f, -9.04421061e-02f, -5.05996756e-02f, -5.55903325e-03f, 1.92010663e-02f, 6.34882078e-02f, -1.09040655e-01f, -1.15372628e-01f, -1.03080578e-01f, -7.24600405e-02f,
  1.25872999e-01f, 2.16366220e-02f, 2.31264182e-03f, 1.25643700e-01f, 1.25861526e-01f, 1.50805479e-02f, -2.76542213e-02f, 9.62794647e-02f, 4.21327874e-02f, -3.38924937e-02f,
  -1.44661507e-02f, 6.75599650e-02f, 3.43741067e-02f, 1.11785427e-01f, 1.73818190e-02f, -1.63961668e-02f, 2.10768580e-02f, 8.81484803e-03f, -4.45618182e-02f, 3.19505259e-02f,
  1.23718888e-01f, 6.91089919e-03f, -2.31200047e-02f, -1.07637001e-02f, 6.09000288e-02f, 1.30393151e-02f, 4.16454040e-02f, 1.27991170e-01f, 4.00261320e-02f, 3.22060920e-02f,
  -7.94739798e-02f, 2.09415816e-02f, 1.05880022e-01f, 1.07319959e-01f, -8.81403685e-03f, -1.32512629e-01f, -6.45659026e-03f, -6.80832611e-03f, -2.54114578e-03f, -2.02374775e-02f,
  -5.11142910e-02f, -2.18247399e-02f, -1.42501174e-02f, -1.07351653e-02f, 1.53809795e-02f, -4.81210370e-03f, 6.31177425e-02f, -3.80791388e-02f, -8.10238123e-02f, 1.61139687e-04f,
  -7.57913962e-02f, 8.82474333e-02f, -3.52583453e-02f, -5.97205162e-02f, -7.25384355e-02f, 4.41461615e-02f, -7.30525404e-02f, -4.85795401e-02f, 8.00894350e-02f, -6.76885694e-02f,
  -5.13538122e-02f, -1.91528201e-01f, -2.19873749e-02f, 1.30139187e-01f, -1.85779437e-01f, -2.82622159e-01f, -3.32644969e-01f, -1.48162454e-01f, -5.93057498e-02f, -1.36061562e-02f,
  -4.65069339e-03f, 1.71991065e-01f, 1.33621454e-01f, 1.65598154e-01f, 3.90011482e-02f, -4.63656932e-02f, -2.59192176e-02f, 1.96912482e-01f, 1.62510455e-01f, -6.02739081e-02f,
  -8.18399712e-03f, 1.36413738e-01f, 1.44380465e-01f, 9.71790776e-02f, 1.30495774e-02f, 1.01477712e-01f, -3.73986848e-02f, 2.04025023e-02f, -5.64749315e-02f, -1.23546887e-02f,
  -5.97164929e-02f, -1.71096817e-01f, 1.65453479e-02f, -1.04922764e-02f, 7.54645839e-02f, -5.73818805e-03f, 2.55245424e-04f, 1.01157511e-02f, 3.93059570e-03f, -1.09978631e-01f,
  5.69678620e-02f, 1.78170856e-03f, 3.08407401e-03f, 6.25764281e-02f, -1.77003983e-02f, -3.98249179e-02f, 5.66477329e-02f, -3.03481463e-02f, 3.32257971e-02f, 2.07342277e-03f,
  4.35490720e-03f, -5.75035252e-02f, -8.55008066e-02f, -7.76097029e-02f, -1.70955155e-02f, -1.95057038e-02f, -1.29685163e-01f, -8.51895362e-02f, -1.04728110e-01f, -9.01171118e-02f,
  1.64903343e-01f, 1.33214951e-01f, 1.29208118e-01f, 8.06270391e-02f, 5.25955111e-02f, 2.56608892e-02f, 7.81578571e-02f, 4.87823300e-02f, 3.64507362e-02f, 2.42914585e-03f,
  1.72338597e-02f, 5.54853752e-02f, 5.39924987e-02f, -3.80921848e-02f, 1.07181735e-01f, 6.40865043e-02f, 2.46524923e-02f, 7.07083121e-02f, 1.58422850e-02f, 3.49906795e-02f,
  4.16140072e-02f, 8.85420740e-02f, 9.59800705e-02f, 8.64623953e-03f, -3.12197651e-03f, -1.34443408e-02f, -2.04315037e-02f, 3.11036445e-02f, 4.43438394e-03f, -4.88155000e-02f,
  1.02466196e-01f, 3.69134918e-02f, -1.07215345e-02f, 5.51144890e-02f, -1.18059270e-01f, -5.50904237e-02f, 6.30301936e-03f, -2.50514448e-02f, -5.58392815e-02f, -6.70584515e-02f,
  1.59745589e-02f, 3.42826322e-02f, -7.45185316e-02f, -5.43195121e-02f, -1.58114731e-02f, -6.87028915e-02f, 6.61502331e-02f, 2.53834128e-02f, -4.66625318e-02f, -1.34900704e-01f,
  -8.70397836e-02f, -2.50662137e-02f, -5.81788570e-02f, -8.99310187e-02f, -6.12313580e-03f, 6.53867498e-02f, -4.44270559e-02f, -8.88810959e-03f, -1.43910050e-01f, -1.55911833e-01f,
  3.29534173e-01f, 3.42805795e-02f, -6.69732690e-02f, 1.90560371e-01f, 1.10889107e-01f, 1.26414876e-02f, 2.70266794e-02f, 9.25542414e-02f, -1.16772195e-02f, -4.39574830e-02f,
  -1.04311608e-01f, -8.79551098e-02f, -1.99726135e-01f, -2.99800485e-01f, -1.78115457e-01f, -2.11675510e-01f, -1.09209821e-01f, -1.64503470e-01f, 8.81883607e-04f, 3.58118378e-02f,
  -1.43266648e-01f, 2.92129796e-02f, 6.19705245e-02f, 4.33731312e-03f, -1.74038813e-01f, -1.95098177e-01f, -2.77223885e-02f, 3.92075591e-02f, -1.80065125e-01f, -2.03309238e-01f,
  -2.01117277e-01f, 1.17037587e-01f, -8.61836821e-02f, -1.05835065e-01f, -1.36251166e-01f, -1.48118511e-01f, -2.69476622e-02f, -1.00180089e-01f, -4.72224690e-02f, -4.59059179e-02f,
  -1.90937504e-01f, -8.16579312e-02f, -3.12058944e-02f, -9.54783633e-02f, -1.23474911e-01f, -1.77177355e-01f, -1.62066758e-01f, -1.54245719e-01f, -1.49054199e-01f, -1.11827493e-01f,
  -1.24973498e-01f, -1.97793543e-02f, 2.60384530e-02f, -3.49167846e-02f, -1.26628637e-01f, -1.08970888e-01f, -2.06213474e-01f, -2.13465527e-01f, -5.75725771e-02f, -1.66099012e-01f,
  8.85372162e-02f, 1.07141070e-01f, 2.04891898e-03f, 1.87951047e-02f, 7.60540217e-02f, 8.46794806e-03f, 2.73148045e-02f, 1.44989341e-02f, -4.61699292e-02f, 1.03233904e-01f,
  6.60035573e-03f, 2.41674967e-02f, -4.03884239e-02f, 3.98065597e-02f, -3.05308159e-02f, 1.15865327e-01f, 1.70998406e-02f, -2.11198684e-02f, 1.09438099e-01f, 1.21072652e-02f,
  -1.85491852e-02f, 3.48025886e-03f, 4.55753170e-02f, 3.97590958e-02f, 2.89130840e-03f, 3.86719704e-02f, 9.24420729e-02f, -2.57241335e-02f, -2.80899871e-02f, 5.93493506e-02f,
  -2.60407068e-02f, -4.46324572e-02f, -1.74458660e-02f, -1.90691516e-01f, -9.85352099e-02f, -6.14085514e-03f, -1.08722441e-01f, -2.24986598e-02f, 1.06729567e-03f, -1.26645878e-01f,
  -4.43250239e-02f, -4.65644859e-02f, -3.44375260e-02f, -1.73740476e-01f, -3.93284857e-02f, -6.38773218e-02f, -1.78539157e-02f, -1.64269619e-02f, -1.37091801e-01f, -1.50127217e-01f,
  -5.29057086e-02f, 3.20439488e-02f, 2.03667916e-02f, 1.82754025e-02f, -1.16070725e-01f, 1.23271057e-02f, -1.40748456e-01f, -9.78094339e-02f, 1.83802582e-02f, -5.81110679e-02f,
  2.99716443e-01f, 1.73362598e-01f, 1.74945489e-01f, 1.55243665e-01f, -4.07246351e-02f, -6.56127036e-02f, -1.82462335e-01f, -8.54126215e-02f, -8.57806653e-02f, -5.75436950e-02f,
  7.66056329e-02f, 3.07322871e-02f, 2.93436982e-02f, -2.34934576e-02f, -1.52090475e-01f, -5.52582964e-02f, -4.00286950e-02f, 1.41428441e-01f, 1.52190477e-02f, -4.57545742e-02f,
  -1.19492672e-01f, -1.94264371e-02f, 1.37241175e-02f, 2.21122298e-02f, 1.76841050e-01f, 1.06653310e-01f, 1.79462090e-01f, 1.02077812e-01f, 1.53479680e-01f, 2.81047344e-01f,
  9.17970911e-02f, 2.02388406e-01f, -1.33171871e-01f, -1.22290403e-01f, 6.58337325e-02f, -3.09972069e-03f, -1.78573336e-02f, 7.38360211e-02f, -6.33460358e-02f, -2.78158579e-02f,
  3.50781232e-02f, -3.44090983e-02f, -6.82300925e-02f, -4.94159609e-02f, -1.21786796e-01f, -3.24023962e-02f, -3.66938044e-03f, -3.10234688e-02f, -8.94685313e-02f, 2.29983386e-02f,
  -1.61997583e-02f, 6.38104305e-02f, -9.20271277e-02f, -1.96025893e-01f, -5.75047359e-03f, -1.40824886e-02f, 1.22815473e-02f, 1.26276631e-02f, 3.47043462e-02f, -1.15315333e-01f,
  -9.82613787e-02f, 9.27101150e-02f, 8.96176249e-02f, 9.52599868e-02f, -3.30845378e-02f, 7.50677064e-02f, 9.76542011e-02f, -1.15525839e-03f, 3.51867080e-02f, -4.37179208e-02f,
  4.23028842e-02f, -1.90360919e-02f, 7.58752748e-02f, -8.06629076e-04f, -7.21981423e-03f, 1.00261599e-01f, 5.61531484e-02f, 7.35526681e-02f, -2.83756703e-02f, 4.31018807e-02f,
  4.30066735e-02f, 1.89618487e-02f, 8.08180049e-02f, -5.62885776e-03f, 1.02255628e-01f, 1.14035271e-01f, 4.09410335e-02f, 1.52781829e-02f, 4.48372327e-02f, 1.15798607e-01f,
  -2.45156750e-01f, -1.61553308e-01f, -1.21418804e-01f, -1.74420923e-01f, -1.10787354e-01f, -2.11456288e-02f, -6.58312216e-02f, -7.81015381e-02f, -4.40201536e-02f, -1.23331621e-01f,
  -1.25170082e-01f, -2.16770712e-02f, -7.34720752e-02f, 9.49174631e-03f, -3.36065218e-02f, -1.62115604e-01f, -1.15497448e-01f, 1.72548741e-02f, -5.92108592e-02f, -1.24371815e-02f,
  -1.82803974e-01f, -1.74264491e-01f, -2.49732018e-01f, -1.98189467e-01f, -9.86565650e-02f, -1.52995273e-01f, -1.77662432e-01f, -1.01210006e-01f, -2.09056810e-01f, -2.27581799e-01f
};

// L0_fan_Wp_bar (Shape: 104 x 120)
const int L0_fan_Wp_bar_rows = 104;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -3.43268812e-01f, 1.04236744e-01f, -3.86669720e-03f, 1.25644520e-01f, 4.43369657e-01f, 2.95175403e-01f, 2.25135535e-01f, 2.33469546e-01f, 1.83758542e-01f, 9.41506550e-02f,
  3.08212847e-01f, 2.20923319e-01f, 1.50256515e-01f, 1.45373538e-01f, 6.51943907e-02f, 3.73608842e-02f, 1.76857501e-01f, -4.87036593e-02f, -8.83068219e-02f, 1.13512374e-01f,
  2.36162469e-01f, 1.74062014e-01f, -7.36365318e-02f, 1.60951000e-02f, 1.58615351e-01f, 9.18634012e-02f, 1.74408853e-01f, 3.83382827e-01f, 2.90536910e-01f, 1.53913900e-01f,
  -7.29740737e-03f, 7.82210976e-02f, -1.73431590e-01f, 2.38026120e-03f, -4.96063940e-02f, -2.77777493e-01f, -1.23155579e-01f, -1.05393961e-01f, 6.18119687e-02f, -2.29947399e-02f,
  1.03515591e-02f, -1.01094402e-01f, -7.92038441e-02f, 4.91183624e-02f, -3.12804319e-02f, -5.14339991e-02f, -3.64035442e-02f, -6.09054305e-02f, 9.21245217e-02f, -8.35550502e-02f,
  1.55548509e-02f, 1.61073312e-01f, 9.40372646e-02f, -7.17658475e-02f, -3.51711549e-02f, 7.42024854e-02f, 4.71698232e-02f, 2.68498547e-02f, -6.36510327e-02f, -1.12122163e-01f,
  -2.58108713e-02f, -2.75902122e-01f, -1.23109415e-01f, 8.67090300e-02f, 2.06579342e-02f, -6.41122833e-02f, -5.30687114e-03f, 2.35753898e-02f, -8.44808482e-03f, -1.63126841e-01f,
  3.97002846e-02f, 1.21569773e-02f, -4.30964716e-02f, -3.31637450e-02f, -1.92058533e-01f, 2.21100282e-02f, -3.38071175e-02f, -1.02424592e-01f, -1.42095819e-01f, -5.53840101e-02f,
  4.42250296e-02f, -8.89080390e-02f, 1.50556872e-02f, -9.69509557e-02f, -1.13854487e-03f, 7.73296580e-02f, -1.13581009e-01f, 4.09980081e-02f, 1.66233757e-03f, -3.57668400e-02f,
  4.00143653e-01f, 1.17540300e-01f, -9.14770961e-02f, -4.68904339e-02f, 4.74508032e-02f, -1.53368592e-01f, -2.12469902e-02f, 2.28384156e-02f, 5.19777499e-02f, -3.88864018e-02f,
  3.73834260e-02f, -2.14745760e-01f, -8.29535574e-02f, -1.57006364e-02f, -9.78889614e-02f, -8.09011906e-02f, -1.10204503e-01f, -8.02517962e-03f, 2.98038833e-02f, 8.39586332e-02f,
  -1.22191653e-01f, 2.63647716e-02f, -2.78218947e-02f, -9.37359128e-03f, 1.78281218e-02f, -8.40627477e-02f, 1.09900851e-02f, -1.04472451e-01f, 3.66726182e-02f, -1.31550014e-01f,
  -3.78896326e-01f, 2.40170062e-02f, -2.53128409e-01f, 1.42451182e-01f, 2.99551338e-01f, 9.22321714e-03f, -5.60180657e-02f, 1.91507284e-02f, 9.50553175e-03f, -1.77688956e-01f,
  -5.18278703e-02f, 1.27401739e-01f, 9.08926874e-02f, 2.46370416e-02f, -1.29747495e-01f, 4.01481166e-02f, 1.37621194e-01f, 5.32557629e-02f, 6.00406155e-02f, 5.81477731e-02f,
  8.61139148e-02f, 4.02936265e-02f, -2.13441879e-01f, -8.77422020e-02f, 2.67885298e-01f, 5.91171533e-02f, -1.34960636e-01f, 3.42704393e-02f, -5.64569831e-02f, 2.55991369e-01f,
  -3.59364897e-01f, -1.65173531e-01f, 7.93234557e-02f, 2.19520256e-01f, 1.16278775e-01f, -2.14110091e-01f, -1.66877165e-01f, -5.30096628e-02f, -7.85927661e-03f, -5.90786710e-02f,
  -9.66719314e-02f, 4.57107164e-02f, 1.06806248e-01f, 2.55414583e-02f, -2.24860355e-01f, -9.21020210e-02f, -2.99119335e-02f, -1.77532047e-01f, -1.16976291e-01f, -1.67325456e-02f,
  4.37920779e-01f, 1.41235963e-01f, -1.95407420e-01f, -3.91883180e-02f, -1.32002503e-01f, -9.80867520e-02f, -1.79938883e-01f, -1.09413624e-01f, -5.11755645e-01f, -2.77827621e-01f,
  -1.38795758e-02f, -2.89980881e-02f, -5.54020442e-02f, -1.10166483e-02f, -1.16706721e-01f, 3.30219232e-02f, 8.88819173e-02f, -2.62011550e-02f, -9.96234715e-02f, 2.33824961e-02f,
  1.67102158e-01f, -7.47119039e-02f, 1.00426059e-02f, -1.51160164e-02f, -1.49831213e-02f, 1.59877483e-02f, 4.25088033e-02f, -4.39307913e-02f, -4.15254608e-02f, -4.93052676e-02f,
  -4.71226834e-02f, 9.79853496e-02f, 4.83208001e-02f, 2.03829661e-01f, -1.37397826e-01f, 4.11648490e-02f, -1.40459808e-02f, -3.70250754e-02f, -3.90641913e-02f, -1.67794675e-01f,
  -1.45006657e-01f, -2.38289401e-01f, -2.35083327e-01f, 9.11702402e-03f, 9.93365198e-02f, 2.98997629e-02f, 9.16958507e-03f, -1.74738225e-02f, 2.22084299e-02f, -7.55803436e-02f,
  -1.58178717e-01f, -1.21259183e-01f, -1.29845098e-01f, 2.47893389e-02f, -1.45787194e-01f, 6.08939072e-03f, -2.49712929e-01f, -8.24331045e-02f, 1.25567624e-02f, -3.24223414e-02f,
  1.19411997e-01f, -2.97582388e-01f, -3.68901283e-01f, -3.08385402e-01f, -1.94276974e-01f, -3.50554824e-01f, -4.29990768e-01f, -3.49064320e-01f, -5.90622485e-01f, -5.42083204e-01f,
  3.88291717e-01f, 4.44741011e-01f, 1.39507145e-01f, 1.78197801e-01f, -5.19948304e-02f, 1.00707822e-01f, 3.54298294e-01f, 2.65129447e-01f, 1.46505058e-01f, 1.24034487e-01f,
  3.87158878e-02f, -6.62337095e-02f, 6.01859353e-02f, 1.22134008e-01f, 2.43264571e-01f, 9.95471999e-02f, 1.63303658e-01f, 7.67143369e-02f, 7.69984275e-02f, 1.28458356e-02f,
  -2.87757460e-02f, 5.71943587e-03f, 1.15055233e-01f, 1.61452312e-02f, 1.26095504e-01f, -1.75897218e-03f, 4.54629213e-02f, 6.26487881e-02f, 6.28569350e-02f, 1.29292756e-01f,
  -2.08577856e-01f, 2.61536598e-01f, -2.69423366e-01f, -1.78371057e-01f, -1.45709932e-01f, -1.38466418e-01f, -1.47650108e-01f, -1.63887694e-01f, -1.16225027e-01f, 4.30441909e-02f,
  -1.55577734e-01f, -1.29315317e-01f, -1.04683894e-03f, -5.69489971e-02f, 7.20604211e-02f, 5.37935086e-02f, -6.69728126e-03f, 1.44066155e-01f, -1.22591509e-02f, 1.36262737e-02f,
  -5.94065264e-02f, -4.04081009e-02f, -3.10054608e-02f, -8.27052817e-02f, 1.59507871e-01f, -7.62367398e-02f, -6.84357584e-02f, 8.70376229e-02f, 9.59717408e-02f, -8.08237214e-03f,
  1.07564792e-01f, 6.46247789e-02f, 1.97681114e-02f, 1.98032364e-01f, 9.64470059e-02f, -2.18171347e-02f, 6.32192194e-02f, 2.58935727e-02f, 1.10656105e-01f, -5.09901438e-03f,
  1.05793625e-01f, 2.71035060e-02f, 7.46285319e-02f, 2.44981721e-02f, 1.00436956e-02f, 1.41747976e-02f, -6.05896711e-02f, 2.16253251e-02f, -3.94078530e-02f, 4.29332927e-02f,
  4.05267403e-02f, -7.80602470e-02f, 2.17104014e-02f, 1.16341271e-01f, 1.80897713e-02f, 1.14389889e-01f, -5.20113297e-02f, -5.92596978e-02f, 5.35622127e-02f, -2.42729690e-02f,
  -1.72334820e-01f, -1.12601556e-01f, -6.92538321e-02f, 5.48161119e-02f, -1.28216952e-01f, -1.33547530e-01f, -2.15075240e-02f, -2.27606922e-01f, -1.23572953e-01f, -7.07260519e-02f,
  -7.21399710e-02f, -1.77214667e-02f, 1.15230223e-02f, -8.13764632e-02f, -1.05338648e-01f, -2.02853948e-01f, -8.43263883e-03f, -3.68885212e-02f, -1.48090094e-01f, -8.59488174e-02f,
  -1.54877067e-01f, -1.28173590e-01f, -1.27724096e-01f, -2.37760507e-02f, -1.35031655e-01f, -2.73241043e-01f, -4.79099713e-02f, -1.94241121e-01f, -1.11365281e-01f, -6.62251040e-02f,
  4.65544283e-01f, -5.04277796e-02f, -5.44747233e-01f, 6.24176003e-02f, -3.12886953e-01f, -4.13715899e-01f, -3.28858107e-01f, -2.97231108e-01f, 9.34911892e-02f, -2.98151553e-01f,
  -2.42541239e-01f, -6.52861744e-02f, -1.92243025e-01f, -2.97057062e-01f, -4.32946205e-01f, -4.95572776e-01f, -3.24324489e-01f, -5.05355299e-01f, -3.57942700e-01f, -3.33118111e-01f,
  -2.05726683e-01f, -1.61310896e-01f, -1.47795200e-01f, -2.20648751e-01f, -5.77464560e-03f, -1.33380309e-01f, -2.09174365e-01f, -2.44495034e-01f, -2.01110750e-01f, -8.11175108e-02f,
  -3.02039593e-01f, 6.95421249e-02f, -2.97373980e-01f, 6.73181340e-02f, -2.25163355e-01f, -1.50128547e-02f, -2.49599591e-01f, -2.52181962e-02f, 1.04292758e-01f, -2.31967896e-01f,
  -1.67588338e-01f, -1.85732231e-01f, -1.36004597e-01f, -1.53499722e-01f, -1.66589215e-01f, -6.28281832e-02f, -1.70396239e-01f, -2.15698838e-01f, -1.16631530e-01f, -1.05727375e-01f,
  -1.57660190e-02f, -1.41925529e-01f, -3.01872566e-02f, 6.40570046e-03f, -2.63878345e-01f, -3.09287328e-02f, -2.05541030e-01f, -1.20628193e-01f, -1.57237992e-01f, 4.03719135e-02f,
  -5.27080745e-02f, -7.52757266e-02f, -8.79303887e-02f, 8.40902627e-02f, 7.84934834e-02f, 5.71987592e-02f, -3.88268530e-02f, -1.82113141e-01f, -1.05429376e-02f, -1.35441907e-02f,
  -1.70664594e-03f, -5.12583517e-02f, -5.69520295e-02f, -2.62547098e-02f, -8.17646235e-02f, -1.31218612e-01f, 6.34906292e-02f, -1.03554487e-01f, -5.40524423e-02f, 7.88022503e-02f,
  -7.71249831e-02f, -3.60427648e-02f, -6.34783357e-02f, -9.62748602e-02f, -5.53210452e-02f, -8.93830732e-02f, 7.23496750e-02f, -9.67419241e-03f, -1.14385083e-01f, 8.27298760e-02f,
  1.86330173e-02f, -2.04470560e-01f, -3.35053876e-02f, -6.42351732e-02f, -2.41034895e-01f, -1.16839729e-01f, 9.29368809e-02f, -1.55784395e-02f, 1.43725678e-01f, -1.72676921e-01f,
  -2.09044978e-01f, -7.79869929e-02f, -1.22387566e-01f, 1.89208686e-02f, -1.59797564e-01f, 6.50527701e-02f, -1.04184821e-02f, 2.87069734e-02f, -1.58105314e-01f, -2.96191722e-02f,
  2.76666917e-02f, 6.29963353e-02f, 3.70563567e-03f, 5.15411533e-02f, 1.35725796e-01f, -3.23469974e-02f, -1.16264559e-01f, -3.07063963e-02f, 7.61891622e-03f, 7.01065436e-02f,
  5.65233529e-02f, -4.39297743e-02f, -2.78136194e-01f, 1.11657493e-01f, 4.66542831e-03f, -8.00228789e-02f, -1.07414752e-01f, 1.89879045e-01f, 3.21307629e-01f, -2.05972284e-01f,
  -3.83816957e-02f, -5.41409403e-02f, -2.40921244e-01f, -2.41742879e-01f, -2.97395259e-01f, -4.35413182e-01f, -3.88304681e-01f, -4.11652088e-01f, -1.63788766e-01f, 5.49637116e-02f,
  -7.91744441e-02f, -7.76468664e-02f, -1.42248809e-01f, -3.88790406e-02f, 1.25308543e-01f, -5.82599603e-02f, -2.41404861e-01f, -1.17846876e-01f, -2.92898536e-01f, -1.59015566e-01f,
  -1.24547265e-01f, 2.09796309e-01f, 9.02032927e-02f, 2.24019196e-02f, 3.57799605e-02f, -9.63490605e-02f, 2.12587714e-02f, 1.12970686e-02f, 3.97606827e-02f, -1.27985880e-01f,
  -7.25976285e-03f, 6.28262907e-02f, 4.16898839e-02f, 4.94261570e-02f, 1.09366380e-01f, 8.29247385e-02f, 1.72626838e-01f, -9.69922729e-03f, 6.70617586e-03f, 1.02431670e-01f,
  -3.24550346e-02f, -1.95303068e-01f, -2.51524568e-01f, 2.42022891e-02f, 1.76813900e-01f, -1.24445848e-01f, -7.06977174e-02f, 1.41845301e-01f, -1.24248937e-01f, -1.62067413e-01f,
  -1.20406365e-02f, -7.62152835e-04f, 1.53578460e-01f, 1.91777036e-01f, -2.69136541e-02f, 6.05003759e-02f, -4.49577868e-02f, -9.81843024e-02f, -2.96198949e-02f, 1.37372568e-01f,
  4.15945090e-02f, -7.36407787e-02f, -2.44122874e-02f, -1.13542162e-01f, -4.77288328e-02f, -5.40641276e-03f, -1.14764437e-01f, -1.50147781e-01f, -1.94169194e-01f, -3.22681479e-02f,
  -5.83385117e-03f, -1.07523520e-02f, 1.84346527e-01f, -1.25819976e-02f, -1.10899270e-01f, -7.38997161e-02f, 6.38945699e-02f, -1.37088848e-02f, 1.71439528e-01f, -6.26013726e-02f,
  1.62805185e-01f, -2.36575618e-01f, -1.56338796e-01f, -3.10477018e-02f, -9.41323638e-02f, 1.52405398e-03f, 4.68955562e-02f, -1.28165185e-01f, -2.64950562e-02f, -6.85493695e-03f,
  -1.45818926e-02f, -3.34037431e-02f, -2.57985685e-02f, 1.07199967e-01f, -8.55252072e-02f, -3.04126702e-02f, -8.51326957e-02f, -2.47949421e-01f, -1.49530038e-01f, 7.13168681e-02f,
  -1.33348420e-01f, -3.27508003e-01f, -2.99682766e-01f, -2.57906467e-01f, 1.29985198e-01f, -3.48457605e-01f, -2.14214683e-01f, -1.69148058e-01f, -3.28461140e-01f, -3.24501604e-01f,
  2.80910611e-01f, -4.17016625e-01f, -2.36651853e-01f, -6.83487803e-02f, -2.73675859e-01f, -2.12308183e-01f, -2.39859641e-01f, 1.17986798e-01f, 9.32604596e-02f, -1.96365505e-01f,
  8.12256858e-02f, 4.21777993e-01f, 2.99248129e-01f, 3.93319815e-01f, 4.28474188e-01f, -3.65669519e-01f, -2.66167104e-01f, 1.64827153e-01f, 4.23497230e-01f, 2.16213107e-01f,
  1.07200835e-02f, -1.20832801e-01f, 1.89219937e-01f, 1.60979390e-01f, -5.50779760e-01f, -1.71230156e-02f, -3.25097919e-01f, -4.34782743e-01f, -3.54141623e-01f, -7.54303336e-01f,
  -2.77207196e-01f, -9.64333937e-02f, 1.51846170e-01f, 9.88966227e-02f, -1.51102915e-01f, 1.33267194e-01f, -9.64098610e-03f, -1.46702781e-01f, 1.84659939e-02f, -1.74054593e-01f,
  -6.59660548e-02f, 2.08006576e-01f, -1.01872377e-01f, 4.82112356e-02f, -1.16341598e-01f, -3.97927649e-02f, -4.10843939e-02f, 4.48659882e-02f, -1.62742017e-05f, -2.29599476e-01f,
  -3.41251284e-01f, -2.40446091e-01f, -2.72270590e-01f, -1.57108247e-01f, -1.49779424e-01f, 2.92119712e-01f, -3.33383024e-01f, -2.74029374e-01f, 8.24099313e-03f, -6.89564466e-01f,
  -4.26995009e-02f, -5.78297712e-02f, -9.73199122e-03f, -4.84420545e-02f, 1.18812202e-02f, -2.04947987e-03f, -2.95964386e-02f, -8.27581435e-02f, -6.79424545e-03f, -1.35461614e-01f,
  3.23439017e-02f, 5.93551062e-02f, 9.64241289e-03f, -9.31465477e-02f, -5.70032559e-02f, -7.89426938e-02f, -6.71202242e-02f, 3.85512263e-02f, 3.85604352e-02f, 1.94574276e-03f,
  1.01792566e-01f, -1.02615505e-02f, 4.87849787e-02f, 1.10976594e-02f, 1.11054704e-01f, 1.39650643e-01f, -3.62951402e-03f, 1.20959142e-02f, 8.79143402e-02f, -9.94236022e-02f,
  2.71340847e-01f, 4.95551437e-01f, -1.37782931e-01f, 1.78147480e-01f, -1.65405169e-01f, 7.35207945e-02f, -5.89673221e-02f, 1.75103694e-02f, 2.04162896e-02f, 9.83260274e-02f,
  1.99662112e-02f, 2.19130591e-01f, -9.21092182e-02f, -1.47633869e-02f, 4.42016684e-02f, -3.04403864e-02f, 1.63554639e-01f, -1.06681310e-01f, 1.36219993e-01f, -1.63098544e-01f,
  -2.34978329e-02f, -1.19543776e-01f, -5.21034375e-02f, -6.41191080e-02f, -2.00697660e-01f, 2.51071692e-01f, -2.00304985e-01f, -3.20492268e-01f, 2.63637513e-01f, -3.42835903e-01f,
  7.32196748e-01f, 9.82615799e-02f, 1.35848224e-01f, 6.54959157e-02f, 2.01679934e-02f, 1.94806710e-01f, 7.12862089e-02f, 1.87112957e-01f, 1.30364776e-01f, 2.91637313e-02f,
  9.71870683e-03f, 6.35293797e-02f, 9.40229520e-02f, 2.81489026e-02f, 8.60424563e-02f, 1.79799087e-02f, -1.26849741e-01f, -4.41002334e-03f, 9.15282294e-02f, 3.70505601e-02f,
  -4.32871915e-02f, -3.33697796e-02f, 6.96282238e-02f, 9.84563027e-03f, -1.16132244e-01f, -5.56017868e-02f, -7.29210004e-02f, -2.30318420e-02f, -1.69342101e-01f, -2.72908509e-01f,
  -3.24954957e-01f, 2.56830782e-01f, -1.09998077e-01f, -8.96687284e-02f, -1.37495801e-01f, 4.74658720e-02f, -4.48493399e-02f, -1.35036796e-01f, -6.16422854e-02f, -1.30669579e-01f,
  -9.05448720e-02f, 2.21659839e-02f, 1.27670065e-01f, -3.37212831e-02f, 5.45626879e-02f, -1.09443963e-01f, 7.05735758e-02f, 5.27933724e-02f, 1.02063023e-01f, -3.59825045e-02f,
  -1.76857524e-02f, -6.28164932e-02f, -7.40962382e-03f, 1.01502039e-01f, 5.71106263e-02f, 1.22738339e-01f, 1.02867499e-01f, 7.40845129e-02f, 5.88845797e-02f, -4.14527208e-02f,
  -9.98381153e-02f, 2.20668828e-03f, 4.75558378e-02f, 8.58524889e-02f, 4.17212844e-02f, 3.88300605e-02f, 8.89427215e-02f, -4.31838445e-02f, 6.47391984e-03f, 3.28374989e-02f,
  -1.67696759e-01f, -5.73517047e-02f, -5.37339188e-02f, 1.46430535e-02f, -2.19638590e-02f, 3.13127809e-03f, 1.79557465e-02f, -8.96298140e-02f, -6.16197102e-02f, 2.74755508e-02f,
  -3.11718951e-03f, -8.96327198e-03f, 4.91030030e-02f, 7.86486939e-02f, -1.68328330e-01f, 7.53329992e-02f, 9.76122171e-03f, -1.08244619e-03f, 5.67852259e-02f, -4.70698159e-03f,
  -2.18829677e-01f, 2.31159791e-01f, -5.88237792e-02f, -2.85121128e-02f, -1.39231263e-02f, -1.69612374e-02f, -8.12555198e-03f, -1.37128800e-01f, -1.31666213e-01f, -1.37247711e-01f,
  -4.22029831e-02f, 7.30906427e-02f, 5.52060045e-02f, 3.91376298e-03f, 1.01592625e-02f, 4.26876545e-02f, 9.11574215e-02f, 5.41983433e-02f, -2.75620706e-02f, -1.45072684e-01f,
  -1.24024786e-01f, 9.67374966e-02f, 1.45611420e-01f, 1.44150173e-02f, 9.09351632e-02f, 1.42741159e-01f, -6.48759902e-02f, 3.33416685e-02f, 1.74891017e-02f, -5.30086942e-02f,
  4.52101082e-01f, -3.25809687e-01f, 9.32201277e-03f, 1.21172547e-01f, -1.21963687e-01f, -2.81059742e-01f, -3.74473453e-01f, -3.39990646e-01f, -3.06832185e-03f, -1.33302703e-01f,
  -1.34353876e-01f, 1.41663074e-01f, 8.06953683e-02f, 3.77710350e-02f, -4.48571471e-03f, -3.68036151e-01f, -2.47266322e-01f, 6.01958781e-02f, 9.29737687e-02f, -1.62648767e-01f,
  5.67774696e-04f, 8.84778127e-02f, 2.79199690e-01f, 4.77666743e-02f, -7.86472857e-02f, 6.02814667e-02f, 6.32690489e-02f, -9.84656960e-02f, -1.92158177e-01f, -3.20485309e-02f,
  -9.19185281e-02f, 1.11642363e-03f, 8.64043981e-02f, 1.39419377e-01f, 5.57900481e-02f, 2.64765341e-02f, 7.30547830e-02f, 3.12037673e-02f, 5.75410575e-02f, -1.92301944e-01f,
  1.82899833e-02f, 3.71672511e-02f, -3.82719450e-02f, -7.99605548e-02f, -1.23331487e-01f, -6.67200685e-02f, -2.00021826e-02f, -2.40507256e-02f, -9.33529213e-02f, -1.27485201e-01f,
  -1.26860235e-02f, -1.91539198e-01f, -1.67696938e-01f, -7.26536661e-02f, -1.45720482e-01f, 6.60327375e-02f, -1.33642435e-01f, -1.36350721e-01f, -1.06345095e-01f, -3.93489264e-02f,
  -2.90963441e-01f, -1.94231614e-01f, -8.11544880e-02f, -5.23847900e-02f, -1.00220352e-01f, -9.52536520e-03f, -1.91245779e-01f, -2.35479712e-01f, -1.25179246e-01f, -1.40226275e-01f,
  -1.56089917e-01f, 1.93835590e-02f, -1.32020582e-02f, 8.78616571e-02f, 1.06982768e-01f, -5.16427830e-02f, -1.74527436e-01f, -8.23932365e-02f, -4.23527509e-02f, -7.06440508e-02f,
  3.94700691e-02f, -2.35499680e-01f, -3.19691412e-02f, -1.10901035e-01f, -1.56880915e-01f, -2.08785564e-01f, -2.16871276e-01f, -1.70213461e-01f, -1.10452540e-01f, -9.92984250e-02f,
  -1.18201084e-01f, 3.71272743e-01f, 1.52774960e-01f, 1.07472856e-02f, 1.36489227e-01f, 1.41047046e-01f, 1.67388290e-01f, 1.43628612e-01f, 1.30742759e-01f, -6.67858124e-02f,
  3.95332947e-02f, 1.62075087e-01f, -3.66083370e-03f, -3.61341448e-03f, 1.69956774e-01f, 2.09658653e-01f, 8.51443410e-02f, 1.53133888e-02f, -7.58012161e-02f, -9.05278027e-02f,
  -1.00323558e-01f, -4.78062965e-02f, -4.40116040e-02f, 9.98168141e-02f, 1.44653082e-01f, 1.18636750e-01f, -7.96836168e-02f, -2.03371756e-02f, 5.96901588e-02f, -2.37035770e-02f,
  -5.09702802e-01f, -1.13795690e-01f, 4.00644779e-01f, -3.95619512e-01f, -2.06407681e-02f, 3.52176875e-02f, -3.24917346e-01f, -3.51818323e-01f, -1.30310372e-01f, -9.50874314e-02f,
  6.97476789e-02f, 1.20931258e-03f, 1.39239401e-01f, 7.96402544e-02f, -2.40870595e-01f, 3.72286141e-02f, 2.09235698e-01f, -1.85295045e-02f, -1.45774305e-01f, -1.70468003e-01f,
  -2.49626949e-01f, -1.79631501e-01f, -1.54775381e-01f, -8.48949030e-02f, -1.02449723e-01f, 4.14525084e-02f, 1.86525971e-01f, 5.89411706e-02f, 1.37299925e-01f, 1.35569185e-01f,
  3.84776890e-02f, -7.62343854e-02f, 1.62001088e-01f, -4.20597605e-02f, 1.46064103e-01f, -2.86485646e-02f, -9.23961326e-02f, -9.97042879e-02f, 2.27511115e-02f, -4.50505652e-02f,
  2.79140938e-02f, 6.10633865e-02f, -1.48540422e-01f, 7.58386478e-02f, -2.27357581e-01f, -1.12015486e-01f, -4.98374924e-02f, -6.48191571e-02f, 6.42841309e-02f, 1.21307366e-01f,
  2.22313870e-02f, -7.16298521e-02f, -2.78063957e-02f, 4.20028940e-02f, -1.20257586e-01f, 1.70970723e-01f, 6.68031052e-02f, -1.10331498e-01f, 1.05678916e-01f, -2.33553335e-01f,
  4.46048975e-02f, 6.44582286e-02f, 3.08148768e-02f, 4.58266474e-02f, -1.34982482e-01f, 4.80120741e-02f, 6.71683531e-03f, 2.85605621e-02f, 1.21276706e-01f, -3.71235721e-02f,
  3.69447507e-02f, 8.21804926e-02f, -8.61433595e-02f, -8.81636739e-02f, 1.06016919e-02f, -1.02499656e-01f, -1.61227182e-01f, -5.19350497e-03f, -8.08491260e-02f, 3.59003767e-02f,
  -2.29034126e-02f, -1.31214678e-01f, 9.80800390e-03f, -3.53782177e-02f, 6.38478845e-02f, 7.86335096e-02f, 9.83904768e-03f, -5.36653074e-03f, -4.91679944e-02f, 8.88955891e-02f,
  -1.88664511e-01f, 3.67301017e-01f, -2.20142543e-01f, -8.06782395e-02f, -5.74196037e-03f, 1.19386330e-01f, 2.76453625e-02f, 9.33322012e-02f, 4.94818017e-02f, -1.00146636e-01f,
  -3.02364230e-02f, -1.77027211e-01f, -6.65585995e-02f, 7.45839626e-02f, -1.20675743e-01f, -4.12146077e-02f, -1.43347740e-01f, -2.44410429e-02f, 1.06464997e-01f, 5.69780543e-02f,
  -1.81649649e-03f, -3.24922502e-01f, -4.32695866e-01f, -1.13895707e-01f, -2.09336042e-01f, -2.47344941e-01f, -1.75308436e-01f, -2.29048431e-01f, -1.65719658e-01f, -5.28463900e-01f,
  -3.65010828e-01f, 4.46382910e-01f, 2.47330710e-01f, -1.90056428e-01f, 2.15799272e-01f, 3.32330585e-01f, 5.41168272e-01f, 2.75670916e-01f, -1.49064753e-02f, 2.67016977e-01f,
  6.54637516e-02f, -3.55401784e-01f, -8.54127184e-02f, -1.37783989e-01f, 1.21609189e-01f, 3.11910361e-01f, 1.62000924e-01f, -2.35232964e-01f, -3.42748076e-01f, -2.12300956e-01f,
  -1.46412969e-01f, -1.06400698e-01f, -3.50103766e-01f, -1.78469285e-01f, -6.62731081e-02f, -2.88874835e-01f, 2.08338007e-01f, -3.12161841e-03f, 1.99999481e-01f, -8.12202469e-02f,
  -5.54448605e-01f, 1.73742864e-02f, -3.27453077e-01f, -1.39011785e-01f, -1.36186317e-01f, -1.02292210e-01f, -2.03225892e-02f, -1.11715831e-01f, 1.11437151e-02f, 1.68422326e-01f,
  -6.77067339e-02f, 1.30422544e-02f, 1.48611574e-03f, 1.91719830e-02f, -3.86586338e-02f, -4.19457182e-02f, -7.07787126e-02f, -1.02956198e-01f, -1.55131787e-01f, 9.41236317e-02f,
  1.60146698e-01f, -1.38525935e-02f, -2.96197686e-04f, 1.13963455e-01f, 1.17264278e-01f, -2.14674324e-01f, 1.06516808e-01f, -1.32396683e-01f, -3.33940275e-02f, -2.64170259e-01f,
  -1.17265441e-01f, 8.29984099e-02f, 6.57827631e-02f, -7.56125823e-02f, -1.14481330e-01f, -1.26924843e-01f, 1.82058960e-02f, 7.10018724e-02f, 1.42758280e-01f, -3.03915981e-02f,
  1.18716396e-01f, -1.13611352e-02f, -4.42996472e-02f, 7.18763545e-02f, 2.36037597e-02f, 1.68245099e-02f, 3.88028324e-02f, 6.64047077e-02f, -1.89112852e-05f, 7.36690685e-02f,
  -9.80657190e-02f, -3.71843576e-02f, 9.26796198e-02f, -5.22520766e-03f, 5.73875830e-02f, -1.43976035e-02f, 9.75441411e-02f, -4.37530540e-02f, 1.96613558e-02f, 1.28233239e-01f,
  -3.61316651e-01f, 8.39631481e-04f, -1.40908301e-01f, 1.69642717e-02f, 9.07636527e-03f, 2.63825338e-02f, 9.49233118e-03f, 3.07194646e-02f, 1.27402514e-01f, 1.04413964e-01f,
  1.47475317e-01f, 8.32135901e-02f, 2.17696264e-01f, 1.36096209e-01f, -2.02286635e-02f, 7.13789538e-02f, 3.84477116e-02f, -5.36462702e-02f, -8.46901238e-02f, 4.54099290e-02f,
  1.04206473e-01f, -6.42903149e-02f, -1.99525073e-01f, 2.70822793e-02f, -6.35463670e-02f, -2.92394876e-01f, -1.21006832e-01f, -1.86053962e-01f, 1.35843046e-02f, -6.60421699e-02f,
  -3.66328508e-01f, 2.25166634e-01f, -9.70922783e-02f, 3.56109262e-01f, 1.11549877e-01f, -4.34034802e-02f, 9.97542292e-02f, 1.06153339e-01f, 5.15365526e-02f, 5.55463284e-02f,
  -2.22830400e-01f, -1.93125919e-01f, -1.61834300e-01f, -1.19319260e-01f, -2.71856636e-01f, 1.08736023e-01f, 4.56811994e-01f, -1.57510769e-02f, -2.09981710e-01f, -1.22626692e-01f,
  2.79429466e-01f, 3.10187340e-01f, 1.61311388e-01f, 2.86766812e-02f, 1.95287362e-01f, 1.22039430e-01f, 1.76764399e-01f, 1.59987614e-01f, -6.26522303e-02f, 1.55538037e-01f,
  -4.46846664e-01f, -5.10573164e-02f, -4.11807522e-02f, 1.01256788e-01f, -1.40221506e-01f, -2.98813850e-01f, -3.62027556e-01f, -3.17149609e-01f, -2.32658863e-01f, -2.77715266e-01f,
  1.48745971e-02f, -2.67336607e-01f, -1.68771461e-01f, 7.80230761e-02f, -1.02235153e-01f, -2.26658434e-01f, 3.01222771e-01f, -8.07036012e-02f, -2.38092154e-01f, -3.90785038e-01f,
  1.33031949e-01f, -1.11693226e-01f, -7.97872841e-02f, 5.20684719e-02f, -4.62201118e-01f, -3.77945714e-02f, -1.02978833e-01f, -4.21086639e-01f, -2.88350523e-01f, 8.12549591e-02f,
  -2.16628388e-01f, -9.85568315e-02f, 1.00518793e-01f, 1.00794978e-01f, 1.14651926e-01f, 8.89884606e-02f, -2.31088288e-02f, -1.19960174e-01f, -4.88790274e-02f, -1.71353240e-02f,
  -1.16763443e-01f, -1.57777920e-01f, -3.17014635e-01f, -2.95170426e-01f, -5.95637374e-02f, -9.24772993e-02f, -1.24758139e-01f, 1.19407713e-01f, 1.24899216e-01f, -2.17515714e-02f,
  -6.95417896e-02f, -1.16521373e-01f, 1.28118455e-01f, 6.51144842e-03f, -1.16171893e-02f, -3.56882922e-02f, -7.91775957e-02f, -1.84213310e-01f, -9.71409380e-02f, -5.99595718e-02f,
  2.30969518e-01f, 5.41147366e-02f, -2.57813811e-01f, -3.99365835e-02f, 6.08510384e-03f, 2.18549725e-02f, -9.49323550e-02f, -2.06514984e-01f, -2.68004179e-01f, -3.88420463e-01f,
  -2.53429145e-01f, -3.10681462e-01f, -8.84190425e-02f, 5.92467841e-03f, -1.67787686e-01f, -6.68874010e-02f, 2.58583993e-01f, 3.47772807e-01f, 2.21667916e-01f, -3.26508045e-01f,
  3.30621809e-01f, 1.92023188e-01f, 2.06501797e-01f, 1.92621976e-01f, -5.77550232e-02f, 3.10917318e-01f, 5.24998344e-02f, -3.19265202e-02f, -1.01932988e-01f, 3.87293100e-01f,
  -1.28109485e-01f, 1.60995275e-01f, 1.57077745e-01f, 3.10560092e-02f, 2.66212821e-01f, -3.40386868e-01f, -4.48460668e-01f, -5.67084432e-01f, -2.11669669e-01f, 1.10095590e-01f,
  3.21249217e-01f, 1.43125519e-01f, 2.87643105e-01f, -2.42605247e-02f, -3.83969903e-01f, -1.98949963e-01f, -2.25038677e-01f, -1.85010448e-01f, -4.36527193e-01f, -1.71772450e-01f,
  1.24607071e-01f, 7.09000975e-02f, -1.72716051e-01f, -1.75103396e-01f, 2.81411052e-01f, 1.54226616e-01f, 2.82640666e-01f, 1.39845788e-01f, 1.46094620e-01f, 3.77382964e-01f,
  4.80512917e-01f, -2.41860021e-02f, -1.68486357e-01f, -4.22351845e-02f, 1.78102598e-01f, -2.44429871e-01f, -2.68554360e-01f, -1.27456322e-01f, -8.61542225e-02f, -5.14358506e-02f,
  1.38766915e-01f, -9.61148553e-03f, 5.51005192e-02f, 1.24849394e-01f, -3.99244623e-03f, -1.17422663e-01f, -8.26832652e-02f, -3.72141957e-01f, -1.76044181e-01f, 1.67901725e-01f,
  1.77325830e-01f, 1.80185109e-01f, 1.84773088e-01f, -2.40688890e-01f, -1.85787141e-01f, 1.99454144e-01f, 4.65039089e-02f, -7.05977380e-02f, -2.16727585e-01f, 2.79897694e-02f,
  -1.45992383e-01f, 1.42029285e-01f, -3.60535569e-02f, -4.05528471e-02f, -6.00675456e-02f, 2.42869705e-02f, 5.96028306e-02f, 1.36625797e-01f, 5.31546287e-02f, -6.52535632e-02f,
  -4.76948433e-02f, -6.95112273e-02f, -5.85615411e-02f, -3.27556320e-02f, 3.85868102e-02f, 1.12166703e-02f, 1.20632976e-01f, -3.35666761e-02f, 1.58818101e-03f, -1.16198942e-01f,
  -4.06098515e-02f, -6.12650327e-02f, 3.66016328e-02f, -1.98661312e-01f, -6.87870830e-02f, 1.76375099e-02f, 3.89842801e-02f, -8.67567956e-02f, 1.20012499e-01f, 1.08111240e-02f,
  2.59642303e-01f, -1.68543652e-01f, 1.58271044e-01f, -1.67250246e-01f, -1.40115738e-01f, -4.25461773e-03f, 6.96311658e-03f, -2.20025271e-01f, 8.12344328e-02f, 3.68194329e-03f,
  -5.71629256e-02f, -9.76957604e-02f, 1.67931512e-01f, -4.67226170e-02f, -1.17036691e-02f, 4.82888222e-02f, -1.56487059e-02f, 2.32102647e-01f, -1.88169461e-02f, 1.05611555e-01f,
  -6.98667020e-02f, -2.69154251e-01f, 9.49184876e-03f, -8.01407769e-02f, -1.01186158e-02f, -4.24276888e-02f, 2.08617330e-01f, 4.74560298e-02f, -2.57806987e-01f, -2.15511061e-02f,
  9.69068334e-03f, -2.70004541e-01f, 6.34993538e-02f, 2.19003007e-01f, 7.89133310e-02f, -2.55164448e-02f, 5.32261655e-02f, 5.56104705e-02f, 1.79968894e-01f, -5.12602925e-02f,
  -2.30559975e-01f, -3.02604556e-01f, -1.07621714e-01f, -6.30501062e-02f, -7.62952492e-02f, 1.55830041e-01f, 1.65952995e-01f, 2.13331208e-01f, 1.55561030e-01f, 9.09358636e-02f,
  6.90638870e-02f, 2.35540107e-01f, 1.33638978e-01f, 1.74318224e-01f, 3.73924826e-03f, 2.85788868e-02f, -2.67565772e-02f, -1.20443337e-01f, -2.56807804e-01f, 4.24754806e-02f,
  -2.76750624e-01f, -2.34443322e-01f, 7.85775110e-02f, 7.59605765e-02f, 6.80263713e-02f, 2.05489859e-01f, 9.66381654e-02f, 8.54021534e-02f, 1.37744293e-01f, 1.42999753e-01f,
  8.32728203e-03f, 7.98235163e-02f, 4.67607342e-02f, -7.32307509e-02f, 6.75240979e-02f, 1.05292618e-01f, -3.58994678e-02f, -5.08383438e-02f, -7.55783990e-02f, -9.72447395e-02f,
  -1.03628337e-02f, -1.28935277e-01f, -1.50309756e-01f, 5.61480084e-03f, -1.04094163e-01f, -9.12661850e-02f, -1.72694445e-01f, -7.95424581e-02f, -1.74457207e-02f, 5.55950450e-03f,
  8.72815847e-02f, 8.26251432e-02f, -2.35258743e-01f, -1.63710743e-01f, -1.51458144e-01f, 7.98984468e-02f, 4.62756418e-02f, -2.79003978e-02f, -5.15923724e-02f, 6.85976893e-02f,
  7.12599531e-02f, -1.66467488e-01f, -1.70677211e-02f, 1.66242912e-01f, 1.10349230e-01f, -1.10292800e-01f, 2.01773569e-02f, -3.90040465e-02f, -1.12318769e-01f, -6.69049472e-02f,
  -1.47097632e-01f, 1.48733348e-01f, 1.76649258e-01f, -5.54805622e-03f, 2.89372168e-02f, 5.79660237e-02f, 6.84250891e-02f, -4.15045470e-02f, 1.22297578e-01f, 8.64679590e-02f,
  -1.60433099e-01f, -2.52301991e-01f, -2.51803324e-02f, -1.18605487e-01f, -9.22317579e-02f, 4.48612943e-02f, -1.56446248e-01f, -2.67563611e-02f, 9.73272324e-02f, 4.40735593e-02f,
  2.78173685e-02f, 1.01915874e-01f, -8.30829591e-02f, -2.92065330e-02f, 2.16781691e-01f, 1.18236914e-01f, -1.06389962e-01f, -5.07306010e-02f, -2.03854404e-02f, 1.71860531e-02f,
  -7.80654280e-03f, 5.95241748e-02f, 1.14869297e-01f, 1.20453104e-01f, -1.19268056e-02f, 6.21929839e-02f, -2.03419980e-02f, -7.28321355e-03f, 1.07247747e-01f, 2.49210730e-01f,
  -6.48349822e-02f, -1.38142943e-01f, -2.05052644e-01f, 8.65502357e-02f, -1.77432939e-01f, -3.47753942e-01f, -6.01952076e-01f, -1.15932792e-01f, 2.80907489e-02f, -3.92206073e-01f,
  -8.06319937e-02f, 1.99548602e-01f, 7.69684166e-02f, -5.87952174e-02f, -1.66026413e-01f, -5.76027691e-01f, -5.02019644e-01f, -2.98541307e-01f, -4.26787175e-02f, -2.18997836e-01f,
  -1.84230238e-01f, -3.32372114e-02f, 4.28072549e-03f, -8.57892539e-03f, 1.76235154e-01f, 6.55291006e-02f, 9.23628919e-03f, -5.36002442e-02f, -2.54335076e-01f, -1.23624109e-01f,
  1.48308828e-01f, 7.56232888e-02f, -6.44918978e-02f, -6.84919432e-02f, -1.87108181e-02f, 6.58024698e-02f, -4.62190583e-02f, 1.05025411e-01f, -8.58145207e-02f, 2.90204771e-02f,
  2.06121542e-02f, -2.63554882e-02f, 5.31529672e-02f, -5.07118255e-02f, -2.10700836e-02f, -9.49455574e-02f, -2.17121914e-01f, -1.27814993e-01f, -2.24936754e-02f, -6.19279109e-02f,
  -2.11421862e-01f, -1.57343820e-01f, 8.70717410e-03f, 2.80113257e-02f, 6.71690702e-02f, 2.54960340e-02f, 1.60607677e-02f, 7.08162263e-02f, 1.08241372e-01f, 1.72782496e-01f,
  -5.39057814e-02f, 1.32374808e-01f, 5.03690206e-02f, 3.78619060e-02f, 6.99321157e-04f, -9.48991925e-02f, 3.46246809e-02f, -3.57757024e-02f, 2.57131215e-02f, -5.37898280e-02f,
  -1.17386751e-01f, -5.50070964e-03f, -4.59394306e-02f, 2.11960860e-02f, -2.30675675e-02f, -1.54672906e-01f, -1.17615730e-01f, 9.32232961e-02f, -9.22724977e-02f, -3.72204334e-02f,
  4.24738489e-02f, 6.86252117e-02f, -1.31165991e-02f, -2.52087368e-03f, -4.40348759e-02f, -7.92109594e-02f, -1.06575072e-01f, -1.01574525e-01f, 6.99181408e-02f, -8.93176273e-02f,
  3.06312710e-01f, -1.86165959e-01f, 2.85781100e-02f, -5.87657951e-02f, -3.57973762e-02f, 2.15574987e-02f, 7.16303140e-02f, -8.21322054e-02f, 1.00823186e-01f, 3.71441394e-02f,
  -2.78958259e-03f, -7.03747943e-02f, 3.67385410e-02f, 5.05258180e-02f, -1.29578277e-01f, -4.54410799e-02f, -3.11165094e-01f, -6.81828782e-02f, -2.75105946e-02f, 3.36812697e-02f,
  -1.40280366e-01f, -2.40674704e-01f, 9.99241509e-03f, 5.06462008e-02f, 1.53894750e-02f, 1.50968328e-01f, 2.03275621e-01f, 4.83908840e-02f, 1.13336239e-02f, -9.63704363e-02f,
  6.93147331e-02f, -5.51988184e-01f, 2.79651910e-01f, 1.40135974e-01f, 3.02690178e-01f, 2.50788987e-01f, 2.12616399e-01f, 1.41403019e-01f, 2.26938486e-01f, -3.44445184e-02f,
  -2.15571076e-01f, -2.17144832e-01f, -2.53207624e-01f, -2.17998311e-01f, -7.47265443e-02f, 1.62302509e-01f, 2.98272520e-01f, 1.26382232e-01f, 2.53892720e-01f, 1.81633487e-01f,
  -2.67891306e-02f, 6.40720800e-02f, -5.59109785e-02f, 1.94928981e-02f, -4.45365943e-02f, 6.93621188e-02f, 7.73521746e-03f, -4.07744059e-03f, -7.31431991e-02f, 9.03357044e-02f,
  -2.39110067e-01f, -2.96444923e-01f, -2.17242003e-03f, -2.45852485e-01f, -1.41081482e-01f, -1.84602588e-01f, -5.89151904e-02f, -4.43010591e-02f, -1.84092000e-01f, -2.26419438e-02f,
  -9.32744294e-02f, -2.58871801e-02f, -8.15971717e-02f, 1.04684280e-02f, 6.84582535e-03f, -3.73704322e-02f, -1.46910384e-01f, -8.50818679e-02f, -1.20596364e-01f, -1.05876260e-01f,
  -2.39685431e-01f, 6.19420260e-02f, -2.01954674e-02f, 4.13981937e-02f, 1.27689745e-02f, 1.59506127e-02f, -1.93278223e-01f, -1.75101817e-01f, -3.35944854e-02f, -9.31442901e-03f,
  -8.09878334e-02f, -6.25417531e-02f, 3.63979116e-02f, 7.47616775e-03f, -1.48940319e-02f, 1.57827199e-01f, 1.88966155e-01f, 1.35230169e-01f, 1.25245452e-01f, 8.78529400e-02f,
  1.80624440e-01f, 2.48258896e-02f, 8.34919885e-02f, 4.74002883e-02f, 1.65706407e-02f, 4.11518365e-02f, 1.70389727e-01f, -5.53743914e-02f, 5.05973175e-02f, 9.87509489e-02f,
  2.99872626e-02f, 6.59174696e-02f, 5.64191565e-02f, 4.38867658e-02f, 7.30219036e-02f, 4.29494008e-02f, 1.59735113e-01f, -5.47711030e-02f, 1.02596276e-01f, 1.40900970e-01f,
  6.40884042e-02f, -1.62508696e-01f, 6.39714301e-02f, 5.65192737e-02f, 5.72854951e-02f, 3.58916372e-02f, -3.65333669e-02f, 2.65455209e-02f, 4.02456895e-02f, 8.74401480e-02f,
  -3.33027579e-02f, 3.33122723e-02f, 5.27475215e-03f, 6.38259808e-03f, 1.21494807e-01f, 1.24863729e-01f, -1.46237260e-03f, 5.55139594e-03f, -8.12711120e-02f, -4.40463759e-02f,
  5.53559437e-02f, 1.22682907e-01f, 1.17458925e-01f, 9.41228867e-02f, 2.41346974e-02f, 1.41970664e-01f, 1.29144356e-01f, 1.23285130e-01f, 8.41626748e-02f, 1.91932887e-01f,
  -4.21118557e-01f, 3.73419315e-01f, 2.24007363e-03f, -7.89257884e-02f, -6.92226551e-03f, -1.27925158e-01f, 1.38731807e-01f, -1.26920566e-02f, 9.71594304e-02f, 4.16957855e-01f,
  1.37878805e-01f, -2.33949900e-01f, 7.26931617e-02f, -1.90633655e-01f, -2.37830311e-01f, 2.75728524e-01f, 1.45854801e-01f, -3.26616853e-01f, -5.65311134e-01f, -4.46974069e-01f,
  -2.62703419e-01f, -2.82563031e-01f, -4.13951665e-01f, -2.21843705e-01f, 2.67759204e-01f, -5.39080054e-02f, 2.58556008e-01f, -1.62549600e-01f, -6.79032728e-02f, 2.55413920e-01f,
  6.99120089e-02f, 1.20633701e-03f, -1.51060432e-01f, -1.79637834e-01f, 1.88118622e-01f, -4.23127562e-02f, 1.75461806e-02f, 2.81922929e-02f, -1.18551217e-01f, 2.46342812e-02f,
  6.77902251e-02f, -5.32751977e-02f, -7.19909370e-02f, -9.28897932e-02f, -1.98520988e-01f, -1.16380841e-01f, -1.87120587e-01f, -2.69937456e-01f, -1.61767185e-01f, -1.62681609e-01f,
  -5.52936904e-02f, -1.62113935e-01f, -1.93035662e-01f, -8.74465182e-02f, 4.13327441e-02f, -2.73076177e-01f, -7.86666423e-02f, -1.86209425e-01f, -8.01644474e-02f, 1.05194099e-01f,
  1.29692480e-01f, 1.91030875e-01f, -3.82378064e-02f, 8.79409444e-03f, 1.09773822e-01f, 2.67816260e-02f, 1.57661345e-02f, 6.43427148e-02f, -4.82313931e-02f, 6.67703450e-02f,
  -5.88131770e-02f, 1.03178173e-01f, 3.25823538e-02f, 1.55349791e-01f, -9.82355420e-03f, -3.67154516e-02f, -7.48741552e-02f, 1.57428399e-01f, -3.62461507e-02f, -3.06874700e-02f,
  -1.15972258e-01f, 1.62464756e-04f, -9.38326120e-02f, 1.66886095e-02f, 4.25268896e-02f, 1.11277457e-02f, 3.35573927e-02f, 8.58136863e-02f, 4.20002360e-03f, 4.11716662e-02f,
  -6.84896335e-02f, -1.25359893e-01f, 1.57461651e-02f, -5.72276674e-02f, 1.51333690e-01f, 1.05921492e-01f, 6.19206205e-02f, 8.64396710e-03f, 1.50507092e-01f, -2.35251281e-02f,
  -1.21182818e-02f, 7.56140649e-02f, 1.04339816e-01f, -3.67579199e-02f, -7.62197375e-02f, 8.08207020e-02f, 2.53792144e-02f, 4.54684272e-02f, 2.27707084e-02f, 1.93605572e-02f,
  -4.97949421e-02f, 2.50951014e-02f, -9.39900652e-02f, 4.08679731e-02f, 5.86726926e-02f, -1.02494881e-01f, 9.25917237e-04f, 7.06372857e-02f, -4.94347736e-02f, 1.59723133e-01f,
  3.47588599e-01f, 1.93809271e-01f, 1.10683702e-01f, 3.45210254e-01f, 3.61458659e-01f, 1.75440997e-01f, 1.95097372e-01f, 7.05376863e-02f, 4.42464985e-02f, 2.36062616e-01f,
  1.94041714e-01f, 3.43613654e-01f, 2.48937145e-01f, 1.17636159e-01f, 3.08103617e-02f, 4.19977047e-02f, -4.80023324e-02f, -4.62125475e-03f, -5.23186885e-02f, 1.19051225e-01f,
  2.39072338e-01f, 1.88915610e-01f, 4.74735834e-02f, -4.52524163e-02f, 7.45759085e-02f, 1.72898993e-01f, 1.38831615e-01f, 1.18234202e-01f, 1.57533929e-01f, 1.13888852e-01f,
  -2.00347099e-02f, 1.26027372e-02f, -1.03859738e-01f, 6.56211600e-02f, 4.11136113e-02f, -8.85793194e-02f, 4.27314155e-02f, -5.24487421e-02f, -4.85909320e-02f, -4.52533662e-02f,
  -3.66090164e-02f, -5.87484315e-02f, 9.42081138e-02f, -3.79098170e-02f, -1.59293655e-02f, -1.74349353e-01f, -1.93768933e-01f, -1.82847634e-01f, -1.31609589e-01f, 9.06084082e-04f,
  5.20953089e-02f, 1.00637659e-01f, -5.06976098e-02f, -3.41011435e-02f, -9.03168023e-02f, 2.59554684e-02f, -5.62036745e-02f, -5.10415696e-02f, -1.62055075e-01f, -1.02605022e-01f,
  -6.70632944e-02f, -1.30283803e-01f, -8.31259191e-02f, 9.91836935e-02f, 5.40613681e-02f, 3.94129604e-02f, -4.68112417e-02f, 7.13179857e-02f, -1.21420398e-01f, -1.56361178e-01f,
  -1.71606585e-01f, -4.16240357e-02f, -1.07282199e-01f, -1.06719598e-01f, 1.69659510e-01f, -7.51708299e-02f, -3.83410528e-02f, -9.93453711e-02f, 7.76833594e-02f, -7.84173906e-02f,
  5.68235293e-02f, -1.72467098e-01f, -9.93216336e-02f, -6.56716377e-02f, -1.48076728e-01f, 5.50898872e-02f, -1.69693306e-02f, -5.68660684e-02f, -1.77378382e-03f, -2.12825853e-02f,
  -1.64482743e-01f, 1.28935799e-01f, -1.27364900e-02f, -1.22941889e-01f, -4.17287275e-02f, -1.19098723e-01f, 6.51738122e-02f, -7.15010539e-02f, 1.51304509e-02f, 1.85743924e-02f,
  1.02778357e-02f, -5.16628549e-02f, -2.03254446e-02f, -1.67809486e-01f, -3.59661579e-02f, -3.60398255e-02f, -5.68844825e-02f, -8.04630145e-02f, -5.94286323e-02f, -2.11562648e-01f,
  -1.19657971e-01f, -1.07986085e-01f, -1.01623088e-01f, -8.10881853e-02f, 4.09710966e-02f, -6.82252124e-02f, -1.04374968e-01f, -1.61172450e-01f, -1.75215364e-01f, -1.00176923e-01f,
  5.50117671e-01f, -7.48731717e-02f, 3.00700188e-01f, 2.44249180e-01f, 3.39134037e-01f, 4.85971600e-01f, 3.70697051e-01f, 1.62418514e-01f, 6.93062916e-02f, 9.23139676e-02f,
  -2.68210679e-01f, -4.00621593e-01f, -3.36179107e-01f, -2.76012808e-01f, -1.01800911e-01f, 1.20573342e-01f, 2.12037355e-01f, 1.95726633e-01f, 3.33639354e-01f, 1.88213840e-01f,
  -9.06023255e-04f, 1.39694586e-01f, -1.16178291e-02f, -4.79998142e-02f, -4.65783803e-03f, -4.49022017e-02f, -5.17902523e-03f, 1.46302626e-01f, -3.48723121e-03f, -1.84975758e-01f,
  -1.14058100e-01f, 1.68396428e-01f, -1.93678692e-01f, -2.19823062e-01f, -9.04060528e-02f, -9.06776786e-02f, -4.56969291e-02f, -2.98265010e-01f, -5.78024611e-02f, 1.99787430e-02f,
  -1.50343438e-03f, -8.25894326e-02f, -9.87133086e-02f, -1.30751133e-01f, 1.25205711e-01f, 4.86484058e-02f, -1.49202988e-01f, -1.48512036e-01f, -1.27958283e-01f, -1.12889625e-01f,
  -2.93248951e-01f, 1.52317315e-01f, 8.66710246e-02f, -4.36111093e-02f, -1.05608523e-01f, -8.22188333e-03f, 1.00289229e-02f, 7.14747831e-02f, 6.15674146e-02f, -7.90932775e-02f,
  -2.40576491e-01f, -4.30333316e-02f, -1.43696079e-02f, -6.56948909e-02f, 7.31838122e-02f, 6.19278066e-02f, 3.02265957e-02f, 3.33360620e-02f, 5.21707237e-02f, -3.29799280e-02f,
  -1.60159484e-01f, -3.32491994e-02f, -1.21033393e-01f, -2.05342714e-02f, -1.68066919e-01f, -1.14752688e-01f, -3.85897160e-02f, -1.98697343e-01f, -1.26725987e-01f, 4.61186282e-02f,
  -3.77460904e-02f, -3.15685943e-02f, -9.91035178e-02f, -1.48363963e-01f, -1.61331758e-01f, -2.06205584e-02f, -4.44051586e-02f, -1.10101469e-01f, -6.82263747e-02f, -3.49422581e-02f,
  -2.98961103e-01f, 4.64126654e-02f, 4.86770980e-02f, -1.75365701e-01f, 6.33540526e-02f, -1.85154587e-01f, -3.10819317e-02f, -1.51466295e-01f, -1.16638448e-02f, 4.95074466e-02f,
  -3.78669659e-03f, -4.57990170e-02f, -4.03817184e-02f, -6.97427318e-02f, 3.88953947e-02f, -1.44298666e-03f, -1.44736633e-01f, 3.43445167e-02f, -9.02168676e-02f, -3.61426771e-02f,
  -1.47487536e-01f, 8.33577737e-02f, 1.48423985e-01f, 1.55835515e-02f, -5.97763397e-02f, 1.14395045e-01f, 9.53114033e-02f, 7.96387419e-02f, 1.26874521e-01f, 2.05315620e-01f,
  1.01046927e-01f, -5.32583535e-01f, 2.18279690e-01f, 4.03069817e-02f, 1.39176935e-01f, 1.96300492e-01f, -8.42663944e-02f, 2.67854333e-02f, -2.72128023e-02f, -1.72754124e-01f,
  -1.49430990e-01f, 2.05622837e-01f, 1.13622695e-01f, 1.49492681e-01f, 4.57293540e-02f, -1.52645171e-01f, -6.68403693e-03f, 3.13783526e-01f, 2.85151035e-01f, 9.71971378e-02f,
  -1.00906923e-01f, -2.15135142e-02f, 7.40798712e-02f, 7.53899589e-02f, -1.40530035e-01f, 8.87457281e-02f, -6.58252761e-02f, -2.05827028e-01f, -1.88185707e-01f, -2.47380108e-01f,
  1.44387200e-01f, -2.79334307e-01f, 2.03228161e-01f, -7.02957362e-02f, -5.21471128e-02f, -2.43977066e-02f, -1.18361060e-02f, -5.70217855e-02f, -2.31345315e-02f, 3.80235799e-02f,
  1.29213342e-02f, -6.18417636e-02f, -3.22471187e-02f, -2.49323677e-02f, -7.59164765e-02f, 3.14718857e-02f, -1.23485297e-01f, 1.23175150e-02f, 2.44617090e-02f, -5.27378246e-02f,
  -2.45222658e-01f, -3.70131247e-02f, 8.78861398e-02f, -2.48891376e-02f, -6.51250631e-02f, 5.02933050e-04f, 7.05309585e-02f, -2.49448009e-02f, 6.31051585e-02f, -6.25260174e-03f,
  -5.22445515e-02f, 6.28373846e-02f, -1.88410506e-02f, -5.75597547e-02f, 3.95558774e-03f, -3.78603414e-02f, -3.71701568e-02f, 6.42070770e-02f, -4.11755368e-02f, 4.83645201e-02f,
  -7.27139488e-02f, -5.45587949e-03f, 1.17539972e-01f, -9.72297788e-02f, -1.10696936e-02f, 6.27445281e-02f, 9.38512012e-02f, -4.75363806e-02f, 3.43089215e-02f, -1.20604344e-01f,
  -1.01316318e-01f, -1.83617987e-03f, 4.10676673e-02f, -5.29569760e-02f, -8.02434161e-02f, 8.09420273e-02f, 3.35783102e-02f, -6.09397702e-02f, 3.60171348e-02f, -1.65058330e-01f,
  7.79158473e-02f, 3.88986953e-02f, 2.00067065e-03f, -5.62290959e-02f, -1.01273060e-01f, -1.07918717e-01f, 9.55335125e-02f, -7.40718842e-02f, -1.14466392e-01f, 1.08356047e-02f,
  -8.00354481e-02f, 1.06509529e-01f, -1.32147186e-02f, -2.77746767e-02f, 9.25288722e-02f, -6.95511550e-02f, -9.96236503e-02f, 1.02350689e-01f, 3.30514535e-02f, -5.38464412e-02f,
  -2.12798223e-01f, 1.07952185e-01f, 8.55249092e-02f, 1.39230549e-01f, 3.95697244e-02f, 1.51591226e-01f, 1.87536404e-01f, 1.00842595e-01f, 1.77051350e-01f, -2.00307649e-02f,
  1.29594430e-02f, 4.00965273e-01f, 8.20154324e-02f, -3.14700335e-01f, 2.66212374e-01f, 3.74070436e-01f, 5.74632704e-01f, 1.57007888e-01f, -1.65834904e-01f, 6.70885518e-02f,
  3.48126560e-01f, -1.18945561e-01f, -3.91060203e-01f, -3.01553011e-01f, -1.74648598e-01f, -1.15073666e-01f, -2.77480453e-01f, -3.75654846e-01f, -1.70895904e-01f, 1.94666848e-01f,
  3.28554027e-02f, -3.73442098e-02f, -1.41374886e-01f, -1.38747692e-01f, -2.71905750e-01f, -2.77874172e-01f, -2.63122559e-01f, -4.13210243e-02f, 9.00674537e-02f, -5.21853089e-01f,
  -1.74314067e-01f, 2.72871047e-01f, 4.01323698e-02f, -2.67039076e-03f, 1.48504302e-01f, -1.25017449e-01f, 1.01969071e-01f, 1.21296309e-02f, 5.19848987e-02f, -4.93167304e-02f,
  5.62841184e-02f, 1.32060915e-01f, -9.58635379e-03f, 5.40811429e-03f, 7.76933208e-02f, 9.55913514e-02f, 1.11456878e-01f, -1.27313882e-01f, -1.49641365e-01f, 2.79249489e-01f,
  1.96519211e-01f, 2.57446349e-01f, 1.80839613e-01f, -2.02497821e-02f, 2.98897531e-02f, -1.00529671e-01f, 9.87410620e-02f, -5.47053143e-02f, -5.42837381e-02f, -3.42276245e-01f,
  1.27097759e-02f, 3.36373448e-02f, -3.92011851e-02f, 7.49528222e-03f, -1.20119929e-01f, -2.21642898e-03f, -6.29986525e-02f, -7.34991133e-02f, -8.48371908e-02f, 6.47734404e-02f,
  9.80743617e-02f, 4.08326602e-03f, 6.28585964e-02f, 2.72469651e-02f, -2.22791240e-01f, 2.66455878e-02f, 2.47152317e-02f, -7.91458338e-02f, -3.76008116e-02f, 1.00038588e-01f,
  -7.51292109e-02f, -1.60174314e-02f, 7.93073922e-02f, -1.12014916e-02f, -1.89632569e-02f, -8.48238617e-02f, -5.22978753e-02f, 1.80113893e-02f, 1.30821288e-01f, 2.06886560e-01f,
  -2.08566040e-01f, 3.44255358e-01f, -2.26574197e-01f, 1.31725129e-02f, -1.19525008e-01f, -2.66574752e-02f, -4.53871489e-02f, 6.65634274e-02f, 1.09101668e-01f, 3.99930514e-02f,
  2.85358459e-01f, -1.11168427e-02f, 8.06863233e-02f, 4.21737395e-02f, 5.11101745e-02f, -2.09429655e-02f, -2.07782984e-02f, -1.87394887e-01f, -9.10366923e-02f, 9.61220041e-02f,
  -1.47952139e-01f, -1.87982708e-01f, -2.43506521e-01f, -2.03713536e-01f, -5.26209734e-02f, -3.05902094e-01f, -1.88389048e-01f, -1.40471265e-01f, -2.38816485e-01f, -3.36948007e-01f,
  -9.39622521e-01f, -2.41682827e-01f, 1.64467812e-01f, -4.11887586e-01f, 2.88866669e-01f, 4.12469268e-01f, 3.70580167e-01f, -2.76724137e-02f, -4.39374834e-01f, -2.93621778e-01f,
  -1.47038162e-01f, -2.97844857e-01f, -2.14417875e-01f, 2.50806689e-01f, 2.52155542e-01f, 4.58290666e-01f, 4.76495564e-01f, 2.73937762e-01f, 2.03334421e-01f, 1.66037142e-01f,
  2.01928988e-01f, 5.76560982e-02f, -1.05586916e-01f, 9.25611556e-02f, -4.01678681e-01f, -9.19077545e-02f, 8.08019638e-02f, -9.32487696e-02f, 2.37115040e-01f, -3.09121665e-02f,
  -5.06768942e-01f, -5.76753438e-01f, 2.84678251e-01f, -3.30837071e-03f, -6.48190379e-02f, -9.04271305e-02f, -6.64326502e-03f, 3.69044133e-02f, -2.35996814e-03f, -1.02947384e-01f,
  2.27675177e-02f, -1.01886131e-01f, -1.56169578e-01f, 6.67360350e-02f, -2.16318339e-01f, -1.36613637e-01f, 1.87998906e-01f, 2.58829556e-02f, -8.05161819e-02f, -8.13542381e-02f,
  3.30965728e-01f, -6.06818609e-02f, -2.13692442e-01f, 1.69530556e-01f, -2.06705630e-01f, -3.33593003e-02f, -8.10332745e-02f, -2.96667427e-01f, -4.37077060e-02f, -4.05482650e-01f,
  1.07639804e-01f, 2.00253576e-01f, 1.01849116e-01f, 9.47520602e-03f, -5.23545034e-02f, -6.74525127e-02f, -1.99925294e-03f, 2.37247378e-01f, 9.20706242e-03f, -1.26943097e-01f,
  -3.08046807e-02f, 2.55961921e-02f, -8.35287720e-02f, -9.22339559e-02f, -1.42036587e-01f, -1.68709941e-02f, 7.51476213e-02f, 6.38183132e-02f, -5.20627759e-02f, -9.21176150e-02f,
  -7.90120959e-02f, 1.69214420e-02f, 1.14247482e-02f, -1.21360868e-01f, 1.77861407e-01f, 1.95098549e-01f, -5.76516986e-03f, -7.17746392e-02f, 2.56928876e-02f, -1.09818563e-01f,
  -3.99386257e-01f, 5.87587357e-01f, -4.22007322e-01f, -2.25912724e-02f, -1.61899671e-01f, 4.31360602e-02f, -9.70063657e-02f, 1.23547107e-01f, -6.59931749e-02f, -6.13125563e-02f,
  7.41151422e-02f, -5.09943329e-02f, -2.88671255e-01f, 1.65427729e-01f, 6.47532046e-02f, -1.31013617e-01f, 1.46745682e-01f, 8.17721561e-02f, 5.80308512e-02f, 5.89619540e-02f,
  -1.62805188e-02f, -1.04444019e-01f, -3.54116410e-01f, -2.45419312e-02f, -1.92350775e-01f, -2.55074322e-01f, -1.43342957e-01f, -6.68877810e-02f, -1.04532562e-01f, -3.08550566e-01f,
  3.91243696e-01f, 4.76590961e-01f, 1.03744268e-01f, 3.51408631e-01f, 2.91215658e-01f, 2.13564530e-01f, 3.02508414e-01f, 3.80770415e-01f, 3.32951665e-01f, 2.20662251e-01f,
  2.77618855e-01f, 1.81308448e-01f, 2.44209573e-01f, 1.96215928e-01f, 8.65199193e-02f, 1.72338545e-01f, 2.18279734e-01f, -4.54142690e-02f, 9.11266543e-03f, 2.62708962e-01f,
  1.85046345e-01f, 1.40142441e-01f, 4.65131290e-02f, 1.40467525e-01f, 2.56795257e-01f, 1.84498891e-01f, 2.01662421e-01f, 2.59823561e-01f, 2.91454852e-01f, 2.26831064e-01f,
  -1.41113132e-01f, 4.61161062e-02f, -9.93186161e-02f, -1.28236532e-01f, -6.75790980e-02f, -1.42852202e-01f, -1.44243911e-01f, -9.36311930e-02f, 9.40168928e-03f, -1.53674036e-01f,
  -4.29002531e-02f, 6.04396919e-04f, -1.21256232e-01f, -7.50898868e-02f, -1.73327520e-01f, -2.08704486e-01f, -4.52632643e-02f, 3.28305438e-02f, -5.53711914e-02f, -1.49541423e-01f,
  -1.14023991e-01f, 5.72896190e-02f, 5.41373622e-03f, -2.73973458e-02f, -1.24604337e-01f, -1.09966971e-01f, -1.88266486e-02f, -1.43444492e-03f, -4.72979546e-02f, -2.94037424e-02f,
  -1.21572323e-01f, 1.08633541e-01f, 3.46832499e-02f, 3.61402594e-02f, -3.02561242e-02f, -3.34100164e-02f, 9.30057839e-02f, 6.18668534e-02f, -1.04748458e-01f, 3.72538269e-02f,
  5.42226695e-02f, -9.91232470e-02f, -6.02634512e-02f, -1.10338643e-01f, -6.90456554e-02f, 7.71356598e-02f, -4.42257710e-03f, -3.29749808e-02f, -2.76907742e-01f, -1.38204098e-01f,
  -7.84543604e-02f, 6.36749268e-02f, 6.38543977e-04f, -7.34849423e-02f, 5.77192660e-03f, -1.43531770e-01f, -2.80686244e-02f, -8.64314139e-02f, -8.05967674e-02f, 1.14165172e-01f,
  9.60181281e-02f, -2.33768746e-01f, -8.02909583e-02f, 5.97716905e-02f, 2.82810186e-03f, 1.60185359e-02f, 5.76518476e-03f, 1.60117708e-02f, -6.44640997e-02f, -1.08596861e-01f,
  9.92079615e-04f, 1.25016887e-02f, -7.81875476e-03f, 4.73366790e-02f, -5.37147075e-02f, -1.04098298e-01f, 1.06989577e-01f, 2.56078601e-01f, 8.87071565e-02f, 5.26948348e-02f,
  4.77119833e-02f, 1.04097702e-01f, 7.05993995e-02f, 1.68477520e-02f, 3.80573515e-03f, -3.70865427e-02f, -1.95573568e-02f, -6.76315874e-02f, -9.87204816e-03f, 4.92477380e-02f,
  -6.77799463e-01f, -4.26937401e-01f, 4.14195329e-01f, -5.81872880e-01f, -3.01225752e-01f, -8.93490613e-02f, -5.94847679e-01f, -2.84646839e-01f, -2.06184939e-01f, -6.71156466e-01f,
  -3.64947498e-01f, 4.13847901e-03f, 2.37193853e-01f, 1.38410628e-01f, -8.27690214e-02f, -7.10577667e-01f, -3.18315774e-01f, 1.67285353e-01f, 2.69676834e-01f, -2.71180093e-01f,
  -4.70333785e-01f, -3.41531485e-01f, -2.56769527e-02f, 9.29122642e-02f, -1.96949974e-01f, 1.35008097e-01f, 1.30993158e-01f, -4.47062254e-02f, -8.40524491e-03f, -1.17155932e-01f,
  -3.81010957e-02f, -1.07237391e-01f, 1.57906383e-01f, 6.30592480e-02f, -6.25891536e-02f, -1.12678461e-01f, -1.26629293e-01f, 2.94757247e-01f, 6.72853217e-02f, -1.52138710e-01f,
  -5.04397647e-03f, -1.28818393e-01f, 8.30647647e-02f, -7.63755888e-02f, -2.75703520e-01f, -2.39796191e-02f, 5.50286025e-02f, 1.06321149e-01f, -3.42167541e-02f, -9.95578170e-02f,
  -2.12635249e-01f, -1.50078446e-01f, 2.65823543e-01f, 2.28429452e-01f, 1.21245399e-01f, 1.62016124e-01f, 2.64644235e-01f, 2.28262469e-01f, 2.15638965e-01f, -1.52094975e-01f,
  -1.09468088e-01f, 4.49043289e-02f, 3.02325189e-02f, 6.24064319e-02f, -2.06718706e-02f, 2.15685651e-01f, 6.90187588e-02f, -7.64162913e-02f, 1.33372709e-01f, -3.96093056e-02f,
  7.79539049e-02f, 6.38907775e-02f, -3.83904874e-02f, -1.45665064e-01f, 7.61012957e-02f, -1.78597588e-02f, -3.81938145e-02f, -3.10308076e-02f, 5.35135306e-02f, -2.31972896e-02f,
  8.31935331e-02f, 1.99658386e-02f, 1.08022906e-01f, -2.40017055e-03f, -6.24794066e-02f, -7.39098564e-02f, 1.06193587e-01f, 1.12619504e-01f, 9.92318848e-04f, 3.05576902e-03f,
  4.24394989e-03f, 3.05001646e-01f, -2.48163685e-01f, 1.39472440e-01f, -1.42062917e-01f, 1.52935505e-01f, 3.43741588e-02f, -7.25857355e-03f, 6.54362664e-02f, -1.56056046e-01f,
  1.24125145e-01f, -1.32095605e-01f, 7.24287108e-02f, 5.54739684e-02f, -2.34189481e-02f, 7.35546499e-02f, -2.64477104e-01f, 4.63587753e-02f, 8.02003443e-02f, -5.98680675e-02f,
  -1.72289044e-01f, -3.50752026e-01f, -1.87170967e-01f, -1.11280024e-01f, -1.34620771e-01f, 9.74395499e-02f, 5.94350323e-02f, 1.17580920e-01f, -2.06781495e-02f, -5.22315502e-01f,
  6.51575327e-01f, -3.63187373e-01f, -4.86633658e-01f, -3.92338559e-02f, -1.94787130e-01f, -1.89713724e-02f, -1.16882645e-01f, 5.61363138e-02f, 1.79294813e-02f, -2.35797673e-01f,
  -5.26616983e-02f, 7.93858916e-02f, -6.30570129e-02f, -5.08562028e-02f, 3.96684557e-02f, -3.02157313e-01f, -2.70161003e-01f, -8.29552412e-02f, 1.44760653e-01f, 1.54373065e-01f,
  -2.11850908e-02f, 6.64253607e-02f, -2.41265371e-02f, -1.33771837e-01f, -3.12264502e-01f, -1.27682835e-01f, -3.63659233e-01f, -3.07436943e-01f, -3.26774776e-01f, -4.10445780e-01f,
  -4.22646761e-01f, -7.14785978e-02f, 7.54746869e-02f, 1.70630142e-01f, -6.63613603e-02f, -2.30593677e-03f, 7.19036981e-02f, 4.43308167e-02f, 1.74897928e-02f, 7.25856749e-03f,
  -6.42515421e-02f, -1.83533709e-02f, -2.59657595e-02f, -5.58729433e-02f, 1.04369730e-01f, 3.76866236e-02f, 1.67174771e-01f, 1.08994454e-01f, -6.85686097e-02f, -2.62644198e-02f,
  -1.02868833e-01f, 2.41621491e-02f, 1.36413649e-01f, 2.23870009e-01f, 1.33871004e-01f, 5.41578084e-02f, 9.01258271e-03f, 1.26867190e-01f, 3.47228684e-02f, 3.00804585e-01f,
  -3.49752270e-02f, 1.88540325e-01f, 1.49186000e-01f, 2.15524748e-01f, 1.55671567e-01f, 1.57222286e-01f, 1.32294908e-01f, 1.66381091e-01f, 5.18646576e-02f, 1.40102521e-01f,
  5.01983352e-02f, 6.95055053e-02f, -6.60217553e-03f, 4.00422215e-02f, -1.00082681e-01f, -1.08151615e-01f, 6.97601810e-02f, -4.38934602e-02f, -8.60996470e-02f, -8.67344216e-02f,
  6.18478144e-03f, -1.29923940e-01f, -2.72935867e-01f, -9.57233459e-02f, -1.92064628e-01f, -1.16549633e-01f, -1.89869460e-02f, -6.24736398e-02f, -1.84674829e-01f, -1.64353922e-02f,
  -2.06526220e-01f, 4.98632006e-02f, 1.45933971e-01f, 1.56649388e-02f, 1.58637911e-02f, -8.22748244e-02f, -5.13222031e-02f, -1.15990490e-01f, -1.97557107e-01f, -1.03845946e-01f,
  -5.63811930e-03f, -6.21850379e-02f, -1.13670394e-01f, 4.20861468e-02f, 9.49143320e-02f, 6.84095025e-02f, 1.10213809e-01f, 7.50122964e-02f, 3.65239382e-02f, -2.19252676e-01f,
  -1.23796217e-01f, 2.13718519e-01f, 1.85175657e-01f, 8.30517039e-02f, 2.66120285e-01f, 1.71226308e-01f, 3.39018963e-02f, 1.38729960e-01f, 1.44969434e-01f, 3.21985126e-01f,
  5.36146820e-01f, -6.85316443e-01f, 2.95321554e-01f, 2.40385786e-01f, 4.21348035e-01f, 4.02586460e-01f, 1.93255842e-01f, 1.65333331e-01f, 2.24177763e-01f, -8.02526549e-02f,
  -3.34488124e-01f, -2.52589673e-01f, -2.67400444e-01f, -1.61485687e-01f, -1.00779727e-01f, -5.87926731e-02f, -1.05447546e-01f, 6.83385208e-02f, 1.61933079e-01f, 1.56069070e-01f,
  -2.41849765e-01f, 4.52709049e-02f, -3.72705329e-03f, -1.41583428e-01f, -7.15591311e-02f, -4.63848375e-02f, 2.03640060e-03f, 4.77470420e-02f, -2.20295012e-01f, -3.19043577e-01f,
  1.62093118e-01f, 4.77724820e-02f, -7.16348961e-02f, -2.25619748e-01f, -5.33158891e-02f, -2.75564622e-02f, 2.64854841e-02f, -6.52259663e-02f, -4.10628878e-02f, 2.52801795e-02f,
  -4.11474295e-02f, -1.73900872e-01f, 8.57185051e-02f, -2.22501978e-02f, 3.68585773e-02f, 7.48551637e-02f, -1.20986952e-02f, -1.61679611e-01f, -1.77202702e-01f, -1.45930618e-01f,
  -3.08723539e-01f, -3.29816937e-02f, 1.80600107e-01f, 5.03592119e-02f, -1.33861586e-01f, -8.47979262e-02f, -6.73419610e-02f, -2.23688390e-02f, -2.69687343e-02f, -1.40793890e-01f,
  -6.88675418e-02f, 2.16451585e-02f, -5.40486537e-02f, 3.75537872e-02f, -7.95265734e-02f, 6.07795920e-03f, 3.87612134e-02f, -1.30660132e-01f, -5.46533167e-02f, -1.05923600e-01f,
  5.15339300e-02f, 6.94990680e-02f, 1.23990692e-01f, 6.84303790e-02f, -5.31098433e-02f, 1.04930252e-01f, 9.73121226e-02f, -4.78737466e-02f, 5.28806522e-02f, 6.34879321e-02f,
  -1.29740685e-02f, -3.48537527e-02f, 1.37146503e-01f, -7.54505768e-02f, -1.11188879e-02f, 2.33375579e-02f, 1.15228757e-01f, -3.29328366e-02f, -2.32409798e-02f, 6.20510131e-02f,
  5.63361272e-02f, -2.62161903e-02f, 1.37239039e-01f, -3.00731864e-02f, -2.27737501e-02f, -5.54864034e-02f, 6.06363313e-03f, -5.94587326e-02f, 9.42141190e-03f, -8.94119814e-02f,
  -5.49907833e-02f, 6.79778457e-02f, 4.54128161e-02f, -7.81072155e-02f, 6.03191592e-02f, -1.44758159e-02f, -1.28970638e-01f, 2.59109717e-02f, -2.51923292e-03f, -7.29523525e-02f,
  -6.75931275e-02f, 9.59580392e-02f, 1.80196419e-01f, 7.06767067e-02f, -3.95870060e-02f, 1.24581546e-01f, 1.26016662e-01f, 5.34894541e-02f, 9.50178131e-02f, 7.53411278e-02f,
  -4.23657984e-01f, 4.01902229e-01f, -3.39454353e-01f, -2.05917776e-01f, -3.99820022e-02f, 7.62333870e-02f, 4.29904282e-01f, 2.32652992e-01f, 1.99965000e-01f, 3.34109515e-01f,
  4.73904088e-02f, -1.66658938e-01f, 5.74340578e-03f, 1.03191450e-01f, 1.28840664e-02f, 4.18443054e-01f, 2.32353315e-01f, -3.86009395e-01f, -5.76546490e-01f, -3.78180593e-01f,
  9.10838097e-02f, -1.63808063e-01f, -3.86766195e-01f, -1.74272195e-01f, 1.97576031e-01f, 8.16163048e-02f, 2.80179441e-01f, -1.25304252e-01f, 2.21949490e-03f, -7.21665695e-02f,
  -5.46336658e-02f, -2.37483189e-01f, -1.35391235e-01f, -3.82507741e-01f, -1.25496402e-01f, 1.84106566e-02f, -3.92852398e-03f, -1.90177664e-01f, -8.54361653e-02f, -8.09179768e-02f,
  -3.51158887e-01f, -1.39834136e-01f, -1.62999675e-01f, 2.38033906e-02f, -1.43855393e-01f, -1.46263972e-01f, 6.34084130e-03f, -2.69900531e-01f, -1.77894041e-01f, -2.97104239e-01f,
  8.87660757e-02f, -4.41291928e-01f, -4.85953063e-01f, 1.94296818e-02f, -1.39080957e-02f, -1.74476102e-01f, -9.25697386e-02f, -2.37967923e-01f, -9.88114849e-02f, 3.80676836e-02f,
  -6.16366044e-03f, -1.97660923e-01f, -5.43889776e-02f, 1.04593784e-01f, 1.95909757e-02f, 6.61906525e-02f, 5.69132604e-02f, -6.83360472e-02f, -1.47502750e-01f, 4.91191633e-03f,
  2.89346408e-02f, -1.73340570e-02f, 7.99186304e-02f, 1.16313152e-01f, -2.34583635e-02f, -4.23166319e-04f, 2.24953387e-02f, 2.36528337e-01f, 1.26984477e-01f, 9.21797231e-02f,
  6.97229356e-02f, -1.55061439e-01f, -8.29596743e-02f, 1.21482350e-01f, 5.08249700e-02f, 8.22397992e-02f, -3.87316011e-02f, -5.73194325e-02f, -1.46783903e-01f, 1.28041133e-01f,
  2.25253120e-01f, 4.97581400e-02f, 5.29124364e-02f, 7.77998660e-03f, -7.43433228e-03f, 2.17829179e-03f, 1.81422234e-02f, 4.54250956e-03f, -2.98011024e-03f, -1.48482576e-01f,
  -1.02341346e-01f, -1.31843895e-01f, 1.21194661e-01f, -8.36058240e-03f, -1.73466921e-01f, -1.38382360e-01f, 1.24919541e-01f, -1.25429407e-01f, 8.34873021e-02f, -6.81982040e-02f,
  1.89637929e-01f, -3.35397981e-02f, -2.26717874e-01f, 3.91431190e-02f, 1.50153697e-01f, -1.45729870e-01f, 7.76592419e-02f, 5.84162548e-02f, 2.63035819e-02f, 2.87175447e-01f,
  3.90631378e-01f, 3.75227481e-01f, -2.43201345e-01f, 1.99169621e-01f, -3.40865940e-01f, -4.84896392e-01f, -3.12170595e-01f, -2.39753664e-01f, -2.02973876e-02f, 8.73193517e-02f,
  -1.22269526e-01f, -9.63622555e-02f, 2.94974986e-02f, -6.41152710e-02f, 5.59841432e-02f, 5.27875647e-02f, 7.28519857e-02f, 1.92127243e-01f, -1.01626292e-01f, -1.59463152e-01f,
  2.62253881e-01f, 1.97404489e-01f, 2.16767997e-01f, 1.66215941e-01f, 1.20273955e-01f, 1.25006020e-01f, 5.64484857e-02f, 6.30778968e-02f, 8.42396095e-02f, 4.19794440e-01f,
  -8.61135721e-02f, -1.72625855e-01f, -1.78995341e-01f, 1.03709705e-01f, 9.88945588e-02f, 1.96652606e-01f, 7.24287704e-02f, 4.16621082e-02f, -7.49075115e-02f, 9.84240100e-02f,
  5.67577109e-02f, -6.24883212e-02f, -8.15177411e-02f, -4.64950614e-02f, -8.60891864e-02f, -9.77910757e-02f, 1.61080986e-01f, -2.06173789e-02f, 2.93398444e-02f, -1.12835422e-01f,
  5.33460788e-02f, -6.40605763e-02f, -1.97716787e-01f, -1.85667828e-01f, -2.31930032e-01f, -1.93713635e-01f, -1.62294775e-01f, -2.25079924e-01f, -2.97685444e-01f, 1.84545532e-01f,
  -8.71870816e-02f, 8.30572098e-02f, -2.67407745e-02f, 1.08386017e-03f, -4.36008275e-02f, -4.45956877e-03f, -9.15202275e-02f, -2.76067723e-02f, -1.81676243e-02f, -6.85055880e-03f,
  3.07387691e-02f, -8.28359053e-02f, -1.32393256e-01f, -6.57646507e-02f, 2.42421944e-02f, -1.27936214e-01f, -1.02461027e-02f, 9.35374945e-02f, 8.02151859e-03f, 1.77185296e-03f,
  -3.45442593e-02f, -9.37980041e-02f, 1.63272768e-02f, 6.44561872e-02f, 8.60544965e-02f, -1.07029798e-02f, 3.33582684e-02f, -8.81190524e-02f, -3.76557820e-02f, -1.98038127e-02f,
  7.37936422e-02f, -3.74800503e-01f, 1.82354614e-01f, 1.53096020e-01f, 5.71995415e-02f, 2.36022584e-02f, 1.46653578e-02f, 8.57994854e-02f, 1.35148868e-01f, -8.37292429e-03f,
  4.13828380e-02f, 1.51253536e-01f, 7.72462599e-03f, -1.61340330e-02f, -7.59418905e-02f, 1.37513289e-02f, 1.82272777e-01f, 1.35130063e-01f, 1.01091430e-01f, -4.19892296e-02f,
  1.97118193e-01f, -4.51711798e-03f, 1.64409019e-02f, 2.42982130e-03f, 2.25435160e-02f, -6.27294928e-02f, -1.00834660e-01f, -5.74683174e-02f, -1.26784354e-01f, 1.00761332e-01f,
  1.80986181e-01f, 3.73263478e-01f, -1.63972601e-01f, 1.80500522e-01f, -2.33338729e-01f, -3.62275690e-01f, -2.64924988e-02f, 1.33364335e-01f, 2.78420616e-02f, 1.97418958e-01f,
  -2.47880772e-01f, -5.13934612e-01f, -2.02366114e-02f, -1.69366017e-01f, -4.09769043e-02f, 4.45918769e-01f, 4.46125925e-01f, -1.41960666e-01f, -5.50945163e-01f, -5.29463947e-01f,
  -1.82101846e-01f, 9.43915453e-03f, -1.34756997e-01f, 2.67457049e-02f, 2.17760623e-01f, -9.47680548e-02f, 2.54691273e-01f, -1.16450205e-01f, -6.99519664e-02f, 2.58314461e-01f,
  -1.82399154e-01f, 1.93997268e-02f, -4.53125924e-01f, -1.76368475e-01f, -8.93724859e-02f, -1.81225553e-01f, -4.67384607e-02f, 2.70328135e-03f, -2.03585345e-02f, 1.03821270e-01f,
  -2.35937506e-01f, -1.42213985e-01f, 4.00078706e-02f, -3.22879851e-02f, -1.48641616e-01f, -5.37838452e-02f, 2.37323686e-01f, 4.29390818e-02f, -3.85118346e-03f, -7.87821487e-02f,
  -1.72724769e-01f, -3.15716207e-01f, -1.64520830e-01f, 2.69440114e-02f, -7.84748271e-02f, -2.07206607e-01f, -6.48559928e-02f, -3.26369584e-01f, -1.26733229e-01f, 5.12696981e-01f,
  -2.57269163e-02f, -5.20245843e-02f, 1.14449807e-01f, 2.79484559e-02f, -3.15619968e-02f, -1.43271461e-01f, -5.74677587e-02f, -2.21416447e-02f, -5.52688316e-02f, -1.54490545e-01f,
  -4.42513637e-03f, 5.01992367e-02f, -8.77952501e-02f, 6.53916150e-02f, 1.08855985e-01f, -9.50447768e-02f, -2.80709360e-02f, 6.39537573e-02f, 2.44046189e-02f, -1.84387974e-02f,
  -8.49709362e-02f, -6.60136789e-02f, -1.74291968e-01f, 3.70807610e-02f, 3.99605222e-02f, 1.47156781e-02f, 4.77755107e-02f, 5.61055727e-02f, -2.22004093e-02f, -2.77796257e-02f,
  -4.56605740e-02f, -2.38539279e-01f, 1.26508579e-01f, -8.44653472e-02f, -1.72243752e-02f, -2.11687133e-01f, 1.23484293e-02f, 1.23047091e-01f, -7.35726804e-02f, -2.22168773e-01f,
  -2.05163017e-01f, 2.08979119e-02f, 8.57052132e-02f, -2.26729121e-02f, -1.23449065e-01f, -1.82653993e-01f, 5.95147125e-02f, 1.28877107e-02f, -5.43427188e-03f, -8.81433412e-02f,
  2.06593603e-01f, 9.54027812e-04f, 1.19358331e-01f, 9.82349366e-02f, 5.58034740e-02f, -1.87033147e-01f, 2.00681891e-02f, -1.52555197e-01f, 3.63085307e-02f, 5.98559022e-01f,
  -1.99326992e-01f, -3.61581087e-01f, 3.43458690e-02f, -5.43427467e-01f, -3.33644062e-01f, -1.91402920e-02f, -3.33262116e-01f, -3.26556772e-01f, -2.67582953e-01f, -4.15055037e-01f,
  -1.29550561e-01f, 3.38759422e-01f, 2.50357479e-01f, 3.09239656e-01f, 4.56171900e-01f, -1.83551133e-01f, 3.04176807e-02f, 2.73422807e-01f, 3.91436934e-01f, -7.85633326e-02f,
  -2.00932786e-01f, -1.81957915e-01f, 1.75168827e-01f, -4.81440201e-02f, -5.20506322e-01f, 3.90469581e-02f, -1.82317957e-01f, -2.24943772e-01f, 3.91329825e-02f, -2.90502518e-01f,
  -1.64815694e-01f, -2.36518934e-01f, 1.66068345e-01f, 9.36997309e-02f, -1.59363732e-01f, 2.52571851e-02f, -1.77700400e-01f, -1.37751237e-01f, -6.99201152e-02f, -2.05590904e-01f,
  -1.51107982e-01f, -5.70771657e-02f, -9.44581330e-02f, -1.09409511e-01f, -2.53454596e-01f, -1.39012337e-01f, -6.66108653e-02f, 1.10623643e-01f, 1.91294730e-01f, -4.50918712e-02f,
  -8.32801405e-03f, 3.18309409e-03f, 7.42613524e-02f, -5.63871972e-02f, 4.29342035e-03f, 2.64981180e-01f, -8.34512636e-02f, 8.35149735e-03f, 2.08813608e-01f, -4.07741010e-01f,
  -9.69922636e-03f, 2.94992402e-02f, -3.00007928e-02f, -4.74273786e-02f, 9.20413528e-03f, -2.92097162e-02f, 4.61541042e-02f, -3.51266712e-02f, -1.82302687e-02f, -6.49831817e-02f,
  3.76262539e-03f, 7.84336850e-02f, -5.13791926e-02f, -9.45351496e-02f, 5.56822792e-02f, 4.32451777e-02f, -2.67837197e-02f, -9.17357728e-02f, -4.80745845e-02f, 6.94069415e-02f,
  2.70577613e-02f, 1.38822168e-01f, 2.20945496e-02f, 9.39631239e-02f, -1.63498358e-03f, 3.36217061e-02f, -1.23483323e-01f, 3.46022323e-02f, -1.06878832e-01f, -1.95207745e-02f,
  -3.91129434e-01f, 3.81916404e-01f, -2.55228549e-01f, 4.65165749e-02f, -1.02365561e-01f, 5.82427271e-02f, -9.69616622e-02f, -1.29489526e-01f, -5.51366471e-02f, -1.76664561e-01f,
  -1.72180478e-02f, -1.71951577e-02f, -6.58009201e-02f, -1.56068757e-01f, 1.58771612e-02f, 6.23052567e-02f, -8.15286636e-02f, -1.09764952e-02f, 2.62915611e-01f, -9.21705514e-02f,
  1.14609420e-01f, 1.10958643e-01f, -7.95740783e-02f, 7.17395842e-02f, -4.54871692e-02f, 1.63124725e-01f, 2.58388389e-02f, 8.53405744e-02f, 2.80175298e-01f, -2.67589957e-01f,
  -4.35661823e-02f, 9.23540220e-02f, 1.92209765e-01f, -1.22180045e-01f, -1.07558019e-01f, -7.24042580e-02f, -1.87823445e-01f, -1.79273501e-01f, -1.67441264e-01f, 5.99530712e-02f,
  2.28622690e-01f, -7.22879246e-02f, 7.61559457e-02f, 9.75931878e-04f, -1.42534282e-02f, 1.07487872e-01f, 1.36702687e-01f, 1.65566541e-02f, -2.47829244e-01f, -3.52843821e-01f,
  -2.05170929e-01f, -2.61345059e-01f, -1.83750227e-01f, -1.10071398e-01f, -2.26043150e-01f, -4.63880934e-02f, 1.03615895e-01f, -7.33437613e-02f, -3.94404121e-02f, 6.23586448e-03f,
  1.75695807e-01f, -2.29562446e-02f, -1.24703147e-01f, -8.74701049e-03f, 6.86074346e-02f, -1.30518511e-01f, 2.52495185e-02f, -8.37135769e-04f, 7.81837627e-02f, 4.53880168e-02f,
  2.51853596e-02f, -1.00052066e-01f, -2.36620791e-02f, -3.27392332e-02f, -1.38231710e-01f, -1.96867719e-01f, -2.67114993e-02f, -1.51612908e-02f, -5.54810166e-02f, -1.75610960e-01f,
  -9.90199074e-02f, 2.19656415e-02f, 3.45035233e-02f, -1.44898266e-01f, -6.33433089e-02f, 4.14603129e-02f, -6.36713952e-02f, -6.57935739e-02f, -3.23625542e-02f, -2.02114895e-01f,
  -1.98563039e-01f, -7.13814422e-02f, -1.15296833e-01f, -4.40769978e-02f, 1.46434614e-02f, 2.33302154e-02f, -6.28022011e-03f, -4.31351960e-02f, -2.12104619e-02f, -1.10337883e-01f,
  -6.33824915e-02f, -1.93140120e-03f, -2.11354699e-02f, 4.82168272e-02f, -1.08492747e-01f, -1.33939326e-01f, 3.33903283e-02f, -8.29725862e-02f, -3.24482210e-02f, -1.59823466e-02f,
  -2.32846849e-02f, -3.96509543e-02f, -1.50279224e-01f, -8.99163634e-02f, -3.48379128e-02f, -2.30385996e-02f, 6.89845979e-02f, -8.63811523e-02f, -1.00069150e-01f, -2.36155130e-02f,
  -9.42193121e-02f, 3.35397512e-01f, 5.23323789e-02f, -3.09145711e-02f, 1.02742556e-02f, -1.24566846e-01f, 1.07540689e-01f, -4.97487001e-02f, -1.64052714e-02f, -1.87918649e-03f,
  2.90435757e-02f, -1.43958759e-02f, -7.47207403e-02f, -1.14992656e-01f, 1.62085630e-02f, -1.23234302e-01f, -2.70148870e-02f, -6.16864562e-02f, 1.57426274e-03f, -1.12602875e-01f,
  -1.29852265e-01f, -1.89984277e-01f, -4.53276485e-02f, 1.14804357e-02f, -1.50786787e-02f, 1.91876572e-02f, -2.25352566e-03f, -1.46033242e-01f, -7.61395693e-02f, -7.96164349e-02f,
  -3.70170921e-01f, 2.94705033e-01f, 4.51567382e-01f, 1.61527712e-02f, 1.60712555e-01f, 6.68306872e-02f, 1.82469681e-01f, 3.30311209e-02f, -4.45670970e-02f, 5.49522415e-02f,
  1.45197555e-01f, -1.41378492e-01f, -5.09557985e-02f, -2.67409217e-02f, -3.18846442e-02f, 1.20232604e-01f, 4.68480848e-02f, -8.50429460e-02f, -2.20196441e-01f, -3.65614325e-01f,
  -2.59136617e-01f, -1.72662377e-01f, -1.06734931e-01f, -7.98931941e-02f, -3.89775485e-02f, -2.42065936e-01f, 1.74894825e-01f, 1.52763024e-01f, -2.32846308e-02f, -2.93252498e-01f,
  -1.45267220e-02f, 2.15024009e-01f, -1.55782476e-01f, -1.36818141e-01f, 1.60535648e-01f, -1.00569122e-01f, -4.10896391e-02f, -5.24448901e-02f, -1.15559049e-01f, -8.42599273e-02f,
  1.08324938e-01f, -6.03149738e-03f, 4.14011622e-04f, 1.18245825e-01f, 6.96863085e-02f, 5.24484068e-02f, 2.91358698e-02f, 6.07919544e-02f, 1.28750429e-01f, 1.28608823e-01f,
  3.89129743e-02f, 1.12966001e-01f, 1.97992176e-01f, 1.28183752e-01f, 2.15287656e-01f, -1.17556170e-01f, 1.03946008e-01f, -7.63091899e-04f, 8.63081142e-02f, -2.45576724e-01f,
  -1.16262406e-01f, 3.77623434e-03f, 1.35194212e-02f, -8.23088214e-02f, -4.50275727e-02f, -1.54087488e-02f, 1.19982781e-02f, -8.54597613e-03f, -5.99460565e-02f, -7.99289644e-02f,
  2.70318463e-02f, -4.81754988e-02f, 5.32781109e-02f, 3.50618586e-02f, 3.72217856e-02f, 6.45332113e-02f, 1.85063146e-02f, 8.65775943e-02f, 5.37528433e-02f, 1.65923033e-02f,
  7.52637628e-03f, 3.26594128e-03f, 1.59641579e-01f, 3.51961441e-02f, 7.46205375e-02f, -6.50447011e-02f, -3.35491970e-02f, 8.13585706e-03f, -3.89033705e-02f, -1.26831559e-02f,
  -8.14156830e-02f, 2.67028421e-01f, -2.66790658e-01f, 3.13580856e-02f, -2.24899733e-03f, 7.87631422e-02f, 6.73568388e-03f, -8.76297206e-02f, -2.82708798e-02f, -5.10621024e-03f,
  -3.17536667e-02f, 1.41535532e-02f, 1.40936062e-01f, 5.86344600e-02f, -3.23733650e-02f, -7.73527995e-02f, 5.51178195e-02f, 1.24340812e-02f, 1.03028178e-01f, 4.55957614e-02f,
  7.53778145e-02f, -1.00076526e-01f, -1.72912627e-01f, -8.69104117e-02f, -1.67618357e-02f, -2.99974859e-01f, -1.69896752e-01f, -2.30144754e-01f, -1.87426666e-03f, -2.67463624e-01f,
  6.56397939e-01f, 2.49869481e-01f, 3.13068986e-01f, 3.44275013e-02f, 2.69515030e-02f, 1.96721166e-01f, 3.03764969e-01f, 2.53760457e-01f, -4.74553034e-02f, 1.09551743e-01f,
  7.90484473e-02f, -7.15587959e-02f, 4.98846583e-02f, 7.08561316e-02f, 2.21631378e-01f, 1.09271906e-01f, -3.22134979e-02f, 2.50485688e-01f, 1.73469871e-01f, 1.22345366e-01f,
  -1.03214405e-01f, 1.77640080e-01f, 3.03671181e-01f, 1.01736739e-01f, -5.20288721e-02f, -1.10788621e-01f, 1.63368151e-01f, 1.38276175e-01f, 1.76999629e-01f, 3.29435468e-02f,
  -1.21844552e-01f, 3.47517550e-01f, -9.51490700e-02f, -1.16543263e-01f, -7.96362609e-02f, -6.88153207e-02f, -5.21058813e-02f, -5.62750138e-02f, 1.71690937e-02f, 1.98504957e-03f,
  -1.34003162e-01f, -7.01632723e-02f, -1.36019029e-02f, -2.93370541e-02f, -1.92019232e-02f, -7.04469159e-02f, 3.65733579e-02f, 1.71997622e-01f, 2.50712992e-03f, 2.31605563e-02f,
  -5.82934432e-02f, -8.42859223e-02f, 1.20216660e-01f, -7.30082989e-02f, 1.38167456e-01f, -7.40494877e-02f, 1.16762184e-01f, 5.75061999e-02f, 1.78432502e-02f, 9.22538787e-02f,
  -1.26300193e-02f, 1.47795185e-01f, 2.47239798e-01f, 2.41232559e-01f, 8.07228684e-02f, 9.12142321e-02f, 4.73821014e-02f, 1.30287930e-01f, 1.32754505e-01f, 2.33038604e-01f,
  -2.54247393e-02f, 3.96340229e-02f, 9.78090391e-02f, 2.23726667e-02f, 1.21161742e-02f, 1.89261466e-01f, 9.61009711e-02f, 1.43815968e-02f, 5.06704263e-02f, -2.20303833e-02f,
  8.66433531e-02f, 7.79006034e-02f, 8.57343823e-02f, 1.34746879e-01f, -6.72085211e-02f, 9.06934142e-02f, 9.39316079e-02f, 7.67607382e-03f, 1.53176151e-02f, 1.12387508e-01f,
  -1.58688739e-01f, 1.53247088e-01f, -9.49058011e-02f, -7.17610195e-02f, -1.21423556e-02f, 2.21840050e-02f, 1.20028146e-01f, -2.81667635e-02f, -7.80368820e-02f, -1.59943067e-02f,
  -5.66220134e-02f, 1.20142594e-01f, 1.86991040e-02f, 1.08074896e-01f, -3.79029550e-02f, -1.71741664e-01f, -1.14728976e-02f, -1.25556707e-01f, -6.86200932e-02f, -7.06041008e-02f,
  -1.21956199e-01f, -1.04929529e-01f, -9.93682742e-02f, -6.17719665e-02f, -1.21760100e-01f, -2.36405000e-01f, -8.96833837e-02f, -5.69575131e-02f, 3.29760686e-02f, 6.02563238e-03f,
  -1.10958323e-01f, -6.11454546e-01f, 1.36733308e-01f, -2.91464645e-02f, 1.27947539e-01f, 1.33745551e-01f, -3.55108567e-02f, -1.28238484e-01f, -1.01162575e-03f, -8.96029100e-02f,
  -6.07918836e-02f, 8.49130675e-02f, 1.29473871e-02f, 1.05736785e-01f, 3.67541499e-02f, 1.38087487e-02f, 1.94700673e-01f, 3.12266171e-01f, 3.38557661e-01f, -4.68901806e-02f,
  -1.40724555e-01f, 1.12958234e-02f, -7.33034872e-03f, -1.77411940e-02f, -1.68133274e-01f, 8.94612167e-03f, 9.09087900e-03f, -7.22868601e-03f, -4.79884483e-02f, -1.64240375e-01f,
  3.93294901e-01f, -2.75910217e-02f, 1.87127233e-01f, -3.35832854e-04f, -2.64066979e-02f, 5.60138654e-03f, 2.59382147e-02f, -5.20839244e-02f, -2.41247192e-02f, 2.88727283e-02f,
  -6.43333718e-02f, -6.42543137e-02f, 3.90866660e-02f, 4.67491746e-02f, 1.11690380e-01f, 3.97222154e-02f, -3.19213606e-02f, -1.02020994e-01f, 3.45460302e-03f, -6.85921907e-02f,
  1.09238029e-02f, 9.60673466e-02f, 1.38194770e-01f, 1.56935975e-01f, -1.84547286e-02f, 1.60486773e-01f, 4.98621687e-02f, 5.18096983e-02f, 1.28217012e-01f, 2.80627497e-02f,
  2.75605202e-01f, -9.02975968e-04f, 1.68288365e-01f, 2.22057804e-01f, 1.29805490e-01f, 7.49964193e-02f, 1.06475577e-02f, 5.09950146e-02f, 1.15553163e-01f, 5.10201603e-02f,
  -1.60281938e-02f, 1.26121238e-01f, 8.99685696e-02f, -6.62928298e-02f, 1.10077210e-01f, -1.07041776e-01f, -1.21206805e-01f, 1.29813571e-02f, 7.22855181e-02f, -5.41459732e-02f,
  1.55485198e-01f, -1.16880141e-01f, -9.53924358e-02f, 1.45899849e-02f, -1.38238773e-01f, 5.48924990e-02f, 4.63842181e-03f, 9.98249575e-02f, -1.86022166e-02f, -6.97259605e-02f,
  1.18390620e-01f, 3.16380560e-01f, 2.63893921e-02f, 2.96040848e-02f, -8.44052956e-02f, -1.84498832e-01f, 5.79285547e-02f, -9.66589972e-02f, -4.65606712e-02f, 1.08454209e-02f,
  6.27328008e-02f, 1.03770874e-01f, 6.92792190e-03f, -3.45854573e-02f, 1.69583201e-01f, 4.56269607e-02f, -1.44789249e-01f, -1.57054290e-02f, -8.89628828e-02f, -8.57780725e-02f,
  -1.91594884e-01f, 5.71161956e-02f, 1.22843228e-01f, 1.28608793e-01f, 8.10449868e-02f, 2.02352375e-01f, 1.36793852e-01f, 6.01351075e-02f, 1.52008802e-01f, 1.51329516e-02f,
  -3.11718255e-01f, 3.22127253e-01f, 5.31262994e-01f, -3.22265357e-01f, -7.37459064e-02f, 1.77256435e-01f, 4.94516581e-01f, 1.96827218e-01f, -1.61942318e-01f, 9.23050866e-02f,
  -1.90664351e-01f, -4.89692926e-01f, -1.68908477e-01f, -1.49461716e-01f, 9.44047198e-02f, 3.19786847e-01f, 3.23449284e-01f, 7.04218298e-02f, -1.29473686e-01f, -2.62006879e-01f,
  -1.83417842e-01f, -3.17144454e-01f, -2.77803242e-01f, -6.11182116e-02f, 6.99695796e-02f, -1.08391859e-01f, 2.46477157e-01f, -1.42532066e-02f, 2.62970150e-01f, 2.74750918e-01f,
  9.54351202e-02f, 7.83463120e-02f, 2.63073631e-02f, -2.31044546e-01f, -2.17428476e-01f, 5.92175014e-02f, 8.50250870e-02f, -1.00742728e-01f, 5.17181419e-02f, 1.59018233e-01f,
  -1.80116639e-01f, -1.52218208e-01f, -8.22126046e-02f, -3.92927416e-02f, -1.94612443e-01f, -3.69163416e-02f, -1.89004801e-02f, 7.96346813e-02f, 2.48869527e-02f, 1.62452534e-02f,
  -2.18565643e-01f, -3.60847235e-01f, -1.68342546e-01f, 3.63116115e-02f, 1.35794446e-01f, -3.00334930e-01f, 1.07535034e-01f, -4.91960347e-02f, 5.24268076e-02f, 8.37695450e-02f,
  -1.67682007e-01f, -6.85945973e-02f, 9.36382115e-02f, 5.69662973e-02f, 3.61876041e-02f, 6.05873242e-02f, 5.02608903e-02f, -1.51084298e-02f, 4.91538197e-02f, 1.30120575e-01f,
  -5.00039384e-03f, 4.18040380e-02f, 2.02289402e-01f, 1.36480987e-01f, -2.61015794e-03f, -5.29358536e-02f, -2.00185832e-02f, -2.13454738e-02f, 4.98219044e-04f, 7.26668090e-02f,
  -1.32517949e-01f, 1.11179642e-01f, -4.49714623e-02f, -3.61205302e-02f, 2.64417559e-01f, 2.57193912e-02f, -6.22014180e-02f, -9.37699005e-02f, -9.50169787e-02f, 5.92319593e-02f,
  -2.66288489e-01f, -1.52398616e-01f, 1.40063182e-01f, 7.54762441e-02f, -1.22697651e-01f, -2.01718393e-03f, -6.47839159e-02f, -5.03152274e-02f, -9.81453285e-02f, 1.60578489e-01f,
  1.45287380e-01f, -1.01776518e-01f, -1.70608275e-02f, 5.58312275e-02f, -1.16746873e-01f, -1.15252882e-02f, -2.40953296e-01f, -1.54522106e-01f, -2.24833742e-01f, -8.10074434e-02f,
  -4.20749187e-02f, -2.29934856e-01f, -2.86295325e-01f, -4.65385877e-02f, -2.77061224e-01f, -3.37841094e-01f, -6.23436831e-02f, -8.54107812e-02f, -1.15531191e-01f, 3.20405513e-02f,
  4.03275400e-01f, 1.52415216e-01f, 1.28001958e-01f, 2.32939899e-01f, -1.82393000e-01f, -2.12871544e-02f, 5.55449650e-02f, 1.69542223e-01f, 2.66782224e-01f, 2.12772116e-01f,
  -8.36547930e-03f, 2.35598773e-01f, 3.04760128e-01f, 2.58489639e-01f, 3.56124967e-01f, 2.49083310e-01f, 1.85508907e-01f, 1.97348788e-01f, 1.61951736e-01f, 1.19743086e-01f,
  1.97855368e-01f, 8.14293399e-02f, 1.85057968e-01f, 2.03453228e-01f, 4.56767641e-02f, 2.15367183e-01f, 1.15994260e-01f, -2.18570828e-02f, -6.57567233e-02f, 1.39757037e-01f,
  -2.25199923e-01f, -3.07492595e-02f, 3.62301655e-02f, 2.03281138e-02f, 2.56211497e-02f, 1.60566926e-01f, 7.84809291e-02f, 2.14785933e-02f, -1.39098182e-01f, -7.57565424e-02f,
  -2.65986286e-02f, -1.64538231e-02f, -1.13807386e-02f, -1.22400276e-01f, -7.62640089e-02f, -1.57107428e-01f, -4.83166315e-02f, 2.34234016e-02f, 1.31142125e-01f, -2.45564170e-02f,
  9.99598764e-03f, -9.05710682e-02f, -2.09858686e-01f, 3.86836529e-02f, 8.87057185e-02f, -1.96676888e-02f, -6.38290346e-02f, -1.59828812e-02f, 4.77924524e-03f, 5.13509214e-02f,
  2.46126786e-01f, 1.96289420e-01f, -1.08174197e-01f, -7.92361125e-02f, 2.96967216e-02f, -1.37435466e-01f, -1.24976262e-01f, 3.58669125e-02f, 5.32389469e-02f, 5.85926399e-02f,
  -1.46953493e-01f, -1.31130069e-01f, 1.68883782e-02f, -7.89261162e-02f, 1.15686089e-01f, -3.84032801e-02f, -2.03743912e-02f, -4.49857116e-02f, -7.18648210e-02f, 2.60345209e-02f,
  -4.94766096e-03f, -7.57867768e-02f, -9.24517289e-02f, -1.50167063e-01f, -1.62249371e-01f, -8.70586261e-02f, 4.86937277e-02f, 1.98062658e-02f, 1.35212839e-01f, 7.27868453e-02f,
  -1.29456982e-01f, 5.33136865e-03f, 1.89972982e-01f, 2.04608127e-01f, -6.42689243e-02f, -6.52388260e-02f, 5.38755693e-02f, -3.77865471e-02f, -2.03348175e-01f, -7.25193508e-03f,
  -9.29781348e-02f, 5.92207573e-02f, -6.02309108e-02f, 6.83448697e-03f, -9.97161046e-02f, -8.83066058e-02f, -1.23874657e-02f, -1.71247628e-02f, 7.15661198e-02f, -5.22832423e-02f,
  6.40145913e-02f, -8.69365931e-02f, -1.13484330e-01f, -7.45362043e-02f, 2.04460137e-02f, 9.06614214e-02f, -1.05523318e-01f, -5.04813045e-02f, -1.56881824e-01f, -1.42212333e-02f,
  -4.59071666e-01f, 3.25909495e-01f, -1.59775212e-01f, -2.08756134e-01f, -2.45375872e-01f, -2.31733561e-01f, 1.56022936e-01f, 6.12784624e-02f, -1.33711651e-01f, 1.10950842e-01f,
  3.76283787e-02f, -1.51702702e-01f, -7.28894472e-02f, -1.73563018e-01f, -1.61632225e-01f, 3.48685607e-02f, -8.98686498e-02f, -4.26983863e-01f, -4.57200944e-01f, -1.04364432e-01f,
  -1.12505250e-01f, -2.91667789e-01f, -3.75665665e-01f, -2.04968080e-01f, 5.48716895e-02f, -1.17517911e-01f, -1.65447351e-02f, -2.51533687e-01f, -1.87730163e-01f, -1.40387416e-01f,
  1.88181505e-01f, -1.98694155e-01f, -8.28701258e-02f, -4.59087528e-02f, 1.81772802e-02f, 2.95373201e-02f, 3.61423865e-02f, 9.67570096e-02f, 3.28859948e-02f, 4.26670015e-02f,
  -1.22278214e-01f, -6.45727813e-02f, -1.09853625e-01f, 8.66392106e-02f, -2.05686521e-02f, -4.94016744e-02f, 1.60894290e-01f, -6.83659762e-02f, 1.03514142e-01f, 2.53971845e-01f,
  1.94108889e-01f, -8.82118419e-02f, -4.79724370e-02f, 1.33375347e-01f, 3.01542375e-02f, -9.61302146e-02f, 1.78067729e-01f, -1.50754442e-02f, 5.69737889e-03f, 1.25400826e-01f,
  1.51702985e-01f, 1.70855656e-01f, -9.74971652e-02f, -5.83770359e-03f, 6.12657554e-02f, 2.03293972e-02f, 2.85347011e-02f, 6.15714155e-02f, -2.42330339e-02f, 6.90539032e-02f,
  2.11744368e-01f, -4.49162535e-02f, -6.11946769e-02f, -6.88711256e-02f, -4.59105679e-04f, -8.79172760e-04f, -2.21056044e-02f, 3.05040739e-02f, 4.92175333e-02f, -6.01405390e-02f,
  -7.22931847e-02f, -2.52127405e-02f, -3.36259492e-02f, -2.69488171e-02f, -1.67720467e-02f, -2.52374448e-02f, -4.52442914e-02f, -4.35579531e-02f, -4.35466729e-02f, -5.58696836e-02f,
  4.61965911e-02f, -4.48276669e-01f, 9.53795239e-02f, -1.15829386e-01f, -9.35725719e-02f, 9.88172069e-02f, -1.04140945e-01f, -1.40208274e-01f, -6.09564930e-02f, -2.82920375e-02f,
  -1.05608329e-01f, -5.46881594e-02f, 7.29993451e-03f, 1.21107653e-01f, -2.34280229e-02f, -3.83470282e-02f, 9.44312364e-02f, -4.71130386e-02f, 3.32972072e-02f, 1.88659415e-01f,
  2.56616265e-01f, 9.97864008e-02f, 1.15503520e-01f, 1.76257566e-01f, 3.89031414e-03f, -2.24774167e-01f, 1.07194923e-01f, 8.28443170e-02f, -7.15436116e-02f, 1.86314330e-01f,
  4.81931955e-01f, -5.29900193e-01f, 2.96670586e-01f, 1.62154779e-01f, 1.84128940e-01f, 3.77457216e-02f, -1.51440129e-01f, -8.15827176e-02f, -1.44718643e-02f, -4.09146175e-02f,
  -6.52208626e-02f, 1.33485019e-01f, 2.48934925e-01f, 1.10136606e-01f, 2.11349547e-01f, 7.52028823e-02f, 1.29790023e-01f, 3.31935585e-01f, 3.32307875e-01f, -1.08700516e-02f,
  -1.93267077e-01f, 4.79660816e-02f, 6.97159618e-02f, 3.04184314e-02f, -3.09585392e-01f, 1.38157219e-01f, -7.89773837e-02f, -1.29987165e-01f, -1.50424346e-01f, -3.10626090e-01f,
  1.34007290e-01f, -4.23300207e-01f, 1.67428955e-01f, -2.43417770e-01f, -8.80569443e-02f, 8.04038718e-03f, -4.47811335e-02f, -5.94049580e-02f, 1.72093660e-02f, -9.79019552e-02f,
  -4.82599214e-02f, -1.66379213e-01f, -1.96944818e-01f, -4.28351983e-02f, -4.15714644e-02f, -4.79980111e-02f, -1.70725837e-01f, -1.32284150e-01f, -1.30920842e-01f, -1.94152996e-01f,
  -2.81702965e-01f, -2.07351685e-01f, -6.54566884e-02f, -1.16694318e-02f, -1.30181611e-01f, 1.80453464e-01f, -1.26406789e-01f, -1.86215624e-01f, -9.96394232e-02f, -7.03620240e-02f,
  1.36877084e-02f, -6.62963986e-02f, -1.30319908e-01f, 4.01730649e-02f, 1.06804349e-01f, 7.50046223e-02f, -3.02826297e-02f, -1.03893444e-01f, 3.26031866e-03f, -7.82343522e-02f,
  -1.55372083e-01f, -3.18412646e-03f, 2.42387783e-02f, -1.29681975e-01f, -3.30090076e-02f, -1.61362514e-01f, -2.84525454e-02f, -8.17657858e-02f, 4.74420935e-02f, 6.16475455e-02f,
  2.69653909e-02f, -3.33361812e-02f, 9.37054083e-02f, -1.63777880e-02f, 3.51541303e-02f, -4.43454012e-02f, 8.56577680e-02f, -8.15201327e-02f, -1.91653091e-02f, -9.91630256e-02f,
  3.67205665e-02f, 6.03386387e-02f, 4.50193323e-02f, -7.77105838e-02f, -9.42657664e-02f, -5.01867831e-02f, -1.32080754e-02f, 4.48020175e-02f, 4.66337465e-02f, 4.27452959e-02f,
  -1.16463378e-01f, 7.14042550e-03f, -3.10410354e-02f, 2.63363915e-03f, 1.67222410e-01f, 3.02978582e-03f, -8.43583867e-02f, 3.09227481e-02f, -6.35676831e-02f, -3.69076170e-02f,
  -1.22326739e-01f, 3.57161984e-02f, 2.32817188e-01f, 1.71525672e-01f, -2.56353263e-02f, 2.49360621e-01f, 1.02103613e-01f, 2.73920875e-02f, 2.22020075e-01f, 2.48502582e-01f,
  -5.20193458e-01f, 4.47872967e-01f, -1.72136426e-01f, -1.21565692e-01f, 1.43603785e-02f, -9.13266465e-02f, -1.23382360e-01f, -6.27269521e-02f, -3.29036172e-03f, 2.13988274e-01f,
  1.03971809e-01f, -2.70782840e-02f, 7.35624731e-02f, -5.77068515e-02f, -2.66658723e-01f, 3.83421630e-01f, 2.77552783e-01f, -3.54797751e-01f, -5.00282228e-01f, -3.06762278e-01f,
  1.90731332e-01f, -5.26300743e-02f, -3.24700236e-01f, -2.42755532e-01f, 2.97753602e-01f, 2.08179042e-01f, 2.63150096e-01f, 1.23248868e-01f, 1.04386054e-01f, 4.33133096e-01f,
  3.15810479e-02f, -2.02102765e-01f, -3.77258435e-02f, -1.17972814e-01f, 1.30131304e-01f, -6.04696609e-02f, 1.19785499e-02f, -3.87290157e-02f, -1.41982445e-02f, 1.32027492e-01f,
  -1.12066142e-01f, -1.94015414e-01f, -1.27086177e-01f, 3.21107730e-02f, -1.21523142e-01f, -1.50545493e-01f, -2.18569562e-01f, -3.78968179e-01f, -1.13135405e-01f, -2.81043738e-01f,
  3.82520035e-02f, -2.30819672e-01f, -2.43683964e-01f, -1.07511520e-01f, -2.19006583e-01f, -1.91662729e-01f, -1.91818684e-01f, -2.31897041e-01f, -3.56530666e-01f, 9.91178975e-02f,
  -2.35401783e-02f, -7.92555511e-02f, -5.99333979e-02f, -6.71972334e-03f, 1.60051867e-01f, 1.03546120e-01f, 1.45466387e-01f, -1.88029755e-03f, -3.12342923e-02f, 2.38704700e-02f,
  -5.11195138e-02f, -5.49818240e-02f, -4.19781134e-02f, -1.19722091e-01f, -6.15322776e-02f, -8.04646537e-02f, 5.50148357e-03f, 1.42432347e-01f, -1.66328866e-02f, 4.80700396e-02f,
  -4.72524278e-02f, -6.49073869e-02f, -5.83007990e-04f, -8.00555851e-03f, 1.41591029e-02f, -9.31967720e-02f, 5.70244305e-02f, -5.88156767e-02f, 2.02778168e-02f, 9.87950414e-02f,
  2.39998803e-01f, -5.57336733e-02f, 1.72308236e-01f, -9.60617140e-03f, 7.99540877e-02f, 1.11131229e-01f, 4.73020300e-02f, 1.30791049e-02f, 7.91959744e-03f, -1.52460083e-01f,
  -1.47391215e-01f, -1.27335906e-01f, 2.33809710e-01f, -1.66106105e-01f, -2.51159579e-01f, -1.58761993e-01f, 2.06931934e-01f, -4.83402647e-02f, -7.56510794e-02f, 5.51571324e-02f,
  2.08445966e-01f, -9.00971964e-02f, -5.04424348e-02f, 1.77589022e-02f, 6.09378628e-02f, -7.08616301e-02f, -3.87168676e-02f, 3.67368050e-02f, -1.44841233e-02f, 4.49910939e-01f,
  -1.96659476e-01f, -1.58029020e-01f, -7.16421247e-01f, 4.73159283e-01f, 4.79903743e-02f, -7.90128484e-02f, 7.19190985e-02f, 3.84130150e-01f, 3.87339652e-01f, -4.57854979e-02f,
  -3.22581679e-01f, -2.15045270e-02f, -1.60064384e-01f, -1.75988957e-01f, -1.07715309e-01f, -1.69588774e-01f, -7.06244782e-02f, -3.17585886e-01f, 1.25141144e-02f, 1.13120154e-01f,
  2.26502448e-01f, 3.19721699e-01f, 1.63498625e-01f, 1.94588348e-01f, 2.26689294e-01f, 2.03872602e-02f, -4.55954783e-02f, -7.77460784e-02f, -2.59074330e-01f, -3.70348632e-01f,
  -6.79486811e-01f, -1.47313848e-01f, -6.08476438e-02f, -1.01710789e-01f, -2.73900390e-01f, -2.27572873e-01f, 3.31222527e-02f, -6.27037659e-02f, -6.65146336e-02f, -6.56803697e-02f,
  -8.13135877e-02f, 7.90405124e-02f, 6.41134530e-02f, 1.04873471e-01f, 2.00505346e-01f, 5.30181592e-03f, 4.80253957e-02f, -8.79924744e-02f, -2.12331459e-01f, -2.52380669e-01f,
  5.99967763e-02f, -2.61975586e-01f, -3.82167697e-01f, -1.03329785e-01f, 4.34014834e-02f, -1.49895117e-01f, -6.95998892e-02f, -7.52427280e-02f, -3.90393555e-01f, -1.00655258e-01f,
  -2.78423205e-02f, -4.07572202e-02f, 1.71032205e-01f, 1.01534463e-01f, 1.79744646e-01f, -6.86531067e-02f, 2.41040811e-03f, 5.12278154e-02f, 6.81648403e-02f, 9.43949670e-02f,
  -1.34669945e-01f, -1.03065372e-01f, 6.96483701e-02f, 6.17177449e-02f, -3.83198932e-02f, -4.75065522e-02f, -1.31706670e-01f, 3.30104977e-02f, -1.19743787e-01f, 1.05664670e-01f,
  -9.64001417e-02f, 5.16715720e-02f, 5.05504850e-03f, 7.56488889e-02f, -1.82998672e-01f, -5.99401705e-02f, 6.74053356e-02f, 1.03792541e-01f, 4.81037870e-02f, -2.52846386e-02f,
  3.35056961e-01f, -1.55175030e-01f, -1.08876921e-01f, 3.94419022e-02f, -1.03515044e-01f, 1.79767087e-02f, -3.29274125e-02f, -8.12696442e-02f, -1.07185155e-01f, 1.13316439e-01f,
  -3.29765514e-03f, -4.26325947e-03f, 1.45375401e-01f, 8.74374211e-02f, 1.20113432e-01f, 3.93063873e-02f, -4.09916863e-02f, -1.98273495e-01f, 8.32897238e-03f, 8.32987651e-02f,
  3.58789027e-01f, 7.29734078e-02f, -1.65060237e-01f, -3.32831740e-02f, 1.95337266e-01f, -1.34765446e-01f, -1.30613387e-01f, -4.44847718e-02f, -3.18140864e-01f, 2.52098918e-01f,
  -5.41898273e-02f, -4.54317987e-01f, 1.57534614e-01f, 2.22721368e-01f, 3.38161767e-01f, 1.76599503e-01f, -1.08117111e-01f, -7.52290636e-02f, 1.63012683e-01f, 1.09457478e-01f,
  1.03840880e-01f, 2.72887737e-01f, 2.14763075e-01f, 2.42787123e-01f, 4.07877043e-02f, 1.86869483e-02f, 1.95960730e-01f, 3.41492653e-01f, 2.99251944e-01f, 9.21118110e-02f,
  1.80203080e-01f, 6.19276725e-02f, 3.85592505e-02f, 1.09545656e-01f, 1.78817838e-01f, 3.14251840e-01f, -8.71420559e-03f, 3.02935559e-02f, 1.35773346e-02f, 2.53029555e-01f,
  2.64564842e-01f, -1.45930825e-02f, 1.27474323e-01f, 8.01912695e-02f, -3.71605456e-02f, -3.37271132e-02f, 9.55879018e-02f, -1.49216279e-01f, -6.95195720e-02f, -6.05736002e-02f,
  1.40131727e-01f, -7.29257613e-02f, 6.33464679e-02f, -7.57145360e-02f, -1.92694217e-02f, -9.62542444e-02f, -1.26968637e-01f, -1.03903472e-01f, -3.72304171e-02f, -5.55618666e-02f,
  1.19170183e-02f, 9.10079107e-02f, 1.60993859e-02f, 2.63688266e-02f, 4.87277983e-03f, 1.19325154e-01f, 8.53260327e-03f, -5.34136370e-02f, -4.07670252e-02f, -4.81674485e-02f,
  2.45485544e-01f, 4.97489274e-02f, 2.78546333e-01f, 1.26810908e-01f, 1.49060503e-01f, 6.17658310e-02f, 7.39491731e-02f, 1.21466421e-01f, 7.25129247e-02f, 1.21291801e-01f,
  1.00370981e-01f, 2.08918259e-01f, -3.67141403e-02f, 4.46451362e-03f, 1.90505907e-01f, 1.42531380e-01f, 8.92985985e-02f, 2.39342768e-02f, 1.86955601e-01f, 7.50598088e-02f,
  6.47868589e-02f, -3.55325677e-02f, -8.58538821e-02f, 2.36690808e-02f, 1.92698855e-02f, 1.93729997e-01f, 8.28410611e-02f, 1.19644990e-02f, 2.25349255e-02f, -4.10333499e-02f,
  -5.71851917e-02f, 2.47754335e-01f, 2.77017564e-01f, 6.97840191e-03f, 1.55939884e-03f, -1.36666149e-01f, 1.20645210e-01f, -9.99986604e-02f, -1.01369753e-01f, -1.07381515e-01f,
  -7.23404288e-02f, 8.48118123e-03f, 3.51223461e-02f, 8.12169388e-02f, 1.54480502e-01f, -4.69065122e-02f, 7.20421448e-02f, 4.44974527e-02f, -1.29140407e-01f, 4.04295363e-02f,
  -1.83863893e-01f, 1.49692281e-03f, 7.90793598e-02f, 1.99996650e-01f, 9.45007578e-02f, 1.83026478e-01f, -4.41732183e-02f, 6.55734316e-02f, 1.31268622e-02f, -4.09393460e-02f,
  -4.05763760e-02f, 2.14382276e-01f, 1.69097126e-01f, -4.12396044e-02f, 8.15019161e-02f, 2.49138415e-01f, 2.98557490e-01f, 2.16413978e-02f, 6.66236058e-02f, 8.17520916e-02f,
  2.12052673e-01f, 1.24510743e-01f, 1.15019344e-02f, 1.88311860e-01f, 8.74723718e-02f, 2.13270724e-01f, 5.75334094e-02f, 1.36282686e-02f, -5.87422438e-02f, 1.48961116e-02f,
  -9.86171071e-04f, 1.25808762e-02f, -7.52339587e-02f, 4.24170606e-02f, 9.88911986e-02f, 2.24771518e-02f, 1.06214788e-02f, 1.61980584e-01f, 1.54510498e-01f, 1.08414121e-01f,
  -9.60232243e-02f, 6.43417761e-02f, -1.43431902e-01f, -2.23005228e-02f, 6.42106533e-02f, -1.24593124e-01f, -1.32399887e-01f, -7.59008005e-02f, 3.16576622e-02f, -4.63642627e-02f,
  8.92987326e-02f, 7.66552426e-03f, 4.31480408e-02f, -5.88137284e-03f, -1.01604648e-01f, 4.58222926e-02f, 1.53664257e-02f, 5.20844804e-03f, 1.42464742e-01f, -6.63011568e-03f,
  5.31085432e-02f, 7.65054002e-02f, 9.90892202e-02f, 3.86024751e-02f, 3.20267081e-02f, 1.09658353e-01f, 1.11680567e-01f, 7.16626048e-02f, 9.09399837e-02f, -2.99607888e-02f,
  1.46482840e-01f, 1.40763223e-01f, 7.91255608e-02f, 7.08424747e-02f, 1.40101507e-01f, -6.36459142e-02f, 5.20139262e-02f, 1.57134578e-01f, 1.23107649e-01f, 1.90462694e-02f,
  -4.87294421e-02f, 1.65152960e-02f, 8.06588605e-02f, 8.40245783e-02f, 8.26992244e-02f, 9.05070677e-02f, 7.76043627e-03f, -4.56066579e-02f, 9.98244360e-02f, -7.26641789e-02f,
  5.09704240e-02f, 5.76447397e-02f, -1.34964377e-01f, 3.05400714e-02f, -9.47578698e-02f, 7.03658611e-02f, -8.43862519e-02f, -7.20709413e-02f, -1.57137707e-01f, -9.99280661e-02f,
  -3.68689477e-01f, 1.80554315e-01f, -1.18193462e-01f, -1.48271054e-01f, 3.81691307e-02f, -1.00580670e-01f, -2.43109874e-02f, -1.38826251e-01f, -1.64503023e-01f, -8.21311399e-02f,
  -1.22161694e-02f, 4.75982726e-02f, -9.66728479e-02f, -8.78069922e-02f, -1.81174576e-01f, -6.77607432e-02f, -1.29722312e-01f, -2.10008062e-02f, -7.19744936e-02f, -2.51169764e-02f,
  2.18525678e-02f, -2.74341926e-02f, -1.93512335e-01f, -7.11680874e-02f, -7.70827606e-02f, -1.93885446e-01f, -1.65525034e-01f, -9.84839574e-02f, -3.41008231e-02f, -1.04239844e-01f,
  3.35263938e-01f, -1.72761977e-01f, 1.06427416e-01f, 1.63410619e-01f, 3.11166048e-01f, 3.74209493e-01f, 4.06387210e-01f, 1.94949687e-01f, 4.43095043e-02f, 6.92313761e-02f,
  -7.14452639e-02f, -3.53750080e-01f, -3.82055074e-01f, -3.13919634e-01f, -9.77365896e-02f, 1.43280894e-01f, 1.77061483e-01f, 1.01681560e-01f, 1.48101285e-01f, 2.23509625e-01f,
  -6.37575537e-02f, 3.03496033e-01f, 2.47161329e-01f, 1.95865352e-02f, -1.25291228e-01f, -1.10373281e-01f, 1.21552765e-01f, 1.40457973e-01f, -5.41300438e-02f, -2.92476058e-01f,
  -1.19435646e-01f, 1.38803691e-01f, -2.67849863e-02f, -2.01711684e-01f, 1.07014049e-02f, -5.34048602e-02f, -8.07217211e-02f, -2.86575146e-02f, -4.66335937e-02f, 5.01864292e-02f,
  -2.54615899e-02f, -1.18656375e-01f, -3.04359160e-02f, 3.17044444e-02f, 1.41054645e-01f, 1.15820080e-01f, 4.02120650e-02f, -9.87665802e-02f, -2.06135020e-01f, -7.63683170e-02f,
  -1.24003738e-01f, 7.86352679e-02f, 1.68827862e-01f, -1.71262622e-02f, -1.27839833e-01f, -4.25050892e-02f, -1.75241847e-02f, 7.39193186e-02f, -4.30631116e-02f, -3.78755778e-02f,
  1.31295860e-01f, 3.69828418e-02f, 8.09238665e-03f, -1.81619935e-02f, -1.14494145e-01f, -1.02994546e-01f, -8.40691105e-02f, -1.14762701e-01f, 1.94332078e-02f, 5.00160567e-02f,
  7.90799689e-03f, -4.01624180e-02f, -1.17897339e-01f, -1.44736823e-02f, -7.90292323e-02f, -8.69870186e-02f, 7.38072675e-03f, -9.54136029e-02f, -9.55131575e-02f, 1.54684901e-01f,
  2.75726188e-02f, -3.38365100e-02f, -1.80051231e-03f, -9.50741693e-02f, 1.05650648e-02f, -1.45003811e-01f, 4.46075201e-02f, -4.18280177e-02f, 2.08157301e-02f, 9.77863222e-02f,
  -5.71355522e-02f, -1.22891448e-01f, -1.52156815e-01f, -1.21430047e-01f, -2.85193715e-02f, -6.49712980e-02f, -1.66952923e-01f, -5.79808317e-02f, -1.42531488e-02f, -1.85087577e-01f,
  -1.40537441e-01f, -1.93766415e-01f, -2.43435621e-01f, -9.87566561e-02f, 1.12591766e-01f, 4.46762145e-02f, -7.02932701e-02f, -9.55989119e-03f, -1.46837786e-01f, -1.20686956e-01f,
  -9.63777676e-02f, 5.89507781e-02f, 1.52756363e-01f, -1.29787982e-01f, -1.03763871e-01f, -4.62091938e-02f, 4.47447300e-02f, -1.77122895e-02f, 1.43998533e-01f, 1.81330502e-01f,
  -5.06594002e-01f, 1.47890016e-01f, 1.62566856e-01f, -4.05120492e-01f, -1.37650803e-01f, -1.49805835e-02f, 5.74368052e-02f, -3.67276609e-01f, -4.45113361e-01f, -1.15439054e-02f,
  1.25000522e-01f, 1.19557701e-01f, 4.75943685e-02f, 1.08699463e-01f, -1.96690373e-02f, 7.04817399e-02f, -1.44253839e-02f, -5.34175821e-02f, -2.72580445e-01f, -3.29411149e-01f,
  -2.56645054e-01f, -2.43962854e-01f, -3.40765625e-01f, -2.05994427e-01f, -1.95079982e-01f, -2.17566025e-02f, -8.78477395e-02f, -7.85541609e-02f, 3.70509848e-02f, 2.07924228e-02f,
  8.24687853e-02f, -2.15730011e-01f, -7.56149217e-02f, -2.19538752e-02f, -3.51584144e-02f, 3.64397913e-02f, -3.13314386e-02f, 2.82565653e-02f, -3.63553874e-02f, -4.56314534e-02f,
  -8.13163519e-02f, 5.78076951e-02f, -1.81344599e-01f, -4.35075685e-02f, -1.23342261e-01f, -1.73280910e-01f, -7.81302527e-02f, -1.78769454e-01f, 1.02220245e-01f, 8.93511400e-02f,
  1.19761005e-01f, 8.52197334e-02f, -2.23338231e-02f, 1.21331647e-01f, 4.39385921e-02f, -3.63701060e-02f, 1.23819016e-01f, -4.88806032e-02f, 1.61334127e-01f, -8.14798623e-02f,
  -7.63482600e-02f, 1.06291631e-02f, 3.66737996e-03f, 3.32813784e-02f, -1.44589767e-01f, -1.41237020e-01f, -1.71338506e-02f, -1.06771253e-01f, -5.50961532e-02f, 5.44210486e-02f,
  4.65525016e-02f, 2.01449730e-02f, -6.26908019e-02f, -5.79968356e-02f, 3.34789567e-02f, -4.58569378e-02f, 2.19028704e-02f, -3.69573645e-02f, 8.52144435e-02f, -1.36064038e-01f,
  2.00263783e-02f, -1.24020830e-01f, -1.61590561e-01f, -1.20961957e-01f, -6.45702630e-02f, 6.37163967e-02f, -2.44609900e-02f, 6.14897460e-02f, -7.58043900e-02f, -5.21357879e-02f,
  -9.08484012e-02f, 2.67986298e-01f, -1.97870098e-02f, -1.16239704e-01f, -2.95371702e-03f, 8.14892948e-02f, 1.07547000e-01f, 2.10141037e-02f, 9.80814267e-03f, -5.75806685e-02f,
  7.03734858e-03f, 3.17672640e-02f, -7.28417858e-02f, -3.38360816e-02f, -8.43056142e-02f, -1.12344794e-01f, -9.06604826e-02f, -1.27891302e-01f, 3.96967772e-03f, -4.63447496e-02f,
  -2.36038603e-02f, -4.15548645e-02f, 1.38139963e-01f, 8.94941762e-02f, -8.25224221e-02f, 6.84970096e-02f, 1.66553870e-01f, 1.03509881e-01f, 1.92220092e-01f, 9.57028866e-02f,
  -4.08853114e-01f, -2.82297730e-01f, 4.87937510e-01f, 1.91586852e-01f, 1.28731867e-02f, -3.72915506e-01f, -4.63573784e-01f, -3.34397733e-01f, 1.88787922e-01f, -4.35794294e-02f,
  -9.13193226e-02f, -6.50308207e-02f, 3.04091513e-01f, -7.75824562e-02f, -3.10673326e-01f, -7.66425207e-02f, 3.25070769e-01f, 9.09959599e-02f, -2.15812072e-01f, -5.24625957e-01f,
  -2.03367934e-01f, 7.82156885e-02f, 8.77150595e-02f, 3.53713073e-02f, 2.44206086e-01f, 1.41105101e-01f, 2.97208786e-01f, 1.19210817e-01f, 6.25900030e-02f, 4.86108482e-01f,
  5.75954840e-02f, -1.03078671e-01f, 1.27007321e-01f, 1.16975196e-01f, 1.64498389e-01f, -1.94256485e-01f, -1.09517768e-01f, 2.65588403e-01f, -1.14527106e-01f, 8.06459114e-02f,
  -1.83564518e-02f, -6.02632724e-02f, 9.24754590e-02f, -9.81558263e-02f, -1.20214537e-01f, -3.09896857e-01f, -9.53737795e-02f, -4.25680354e-02f, 1.04369685e-01f, -3.76849353e-01f,
  -1.40964583e-01f, -8.36318806e-02f, 3.00228782e-02f, -1.39230445e-01f, 2.31413972e-02f, 2.43436083e-01f, 1.97601244e-02f, -5.24908118e-02f, 4.69175987e-02f, 3.74967940e-02f,
  1.30745918e-01f, 5.68436608e-02f, 3.72363590e-02f, 1.57066539e-01f, -8.21781084e-02f, 1.06751688e-01f, 1.23024561e-01f, 7.45625293e-04f, -3.30673382e-02f, 7.67321438e-02f,
  1.37261935e-02f, -2.70589665e-02f, -3.44322138e-02f, 1.33035926e-03f, 4.30515297e-02f, 1.12789005e-01f, -6.94799274e-02f, -8.54590684e-02f, 8.94032344e-02f, 4.19742428e-03f,
  -9.84141789e-03f, -2.26827245e-02f, 2.53873378e-01f, 6.72697730e-04f, -2.80969273e-02f, 8.89167562e-02f, -6.79988563e-02f, -1.05480485e-01f, -1.16655778e-03f, -5.95937250e-03f,
  4.22057323e-02f, 8.02379251e-02f, -4.80893217e-02f, -1.64294410e-02f, 1.30790800e-01f, -3.34746614e-02f, -2.74766833e-02f, -1.07186422e-01f, -5.78061081e-02f, -1.70064345e-01f,
  -2.44395569e-01f, -1.11587144e-01f, 1.64998561e-01f, 2.56792437e-02f, -1.71449319e-01f, -1.00269385e-01f, -4.88940664e-02f, -8.12788084e-02f, -7.74037018e-02f, -1.79142073e-01f,
  1.06063597e-01f, -3.77845436e-01f, -3.50781053e-01f, -1.79351807e-01f, -5.03259562e-02f, -2.30590135e-01f, -1.05079181e-01f, -7.51151294e-02f, -1.78250596e-01f, -4.99722779e-01f,
  6.82505190e-01f, 1.61243558e-01f, 7.79129565e-02f, 3.70757258e-03f, -2.29024053e-01f, -9.71863195e-02f, 7.94831216e-02f, 9.71084908e-02f, -2.28545424e-02f, 3.27539332e-02f,
  -9.21078622e-02f, -3.00804436e-01f, -2.03087956e-01f, -9.66080353e-02f, 5.83167281e-03f, 1.30020306e-01f, 1.38458893e-01f, 4.81215604e-02f, -1.82481110e-01f, -2.19587162e-01f,
  -1.36098266e-01f, 3.05274706e-02f, 1.08934440e-01f, -6.05632849e-02f, -9.27493200e-02f, -1.46863461e-01f, 1.55670911e-01f, 5.79451472e-02f, -4.05121669e-02f, 4.66437265e-02f,
  -1.73777323e-02f, 2.70413429e-01f, -2.35961482e-01f, -2.98397020e-02f, -1.19529046e-01f, -1.75699138e-03f, -5.00975437e-02f, -6.16805889e-02f, 5.94134517e-02f, 6.96558505e-02f,
  5.72013222e-02f, -3.93782407e-02f, -2.09028646e-02f, -9.89250187e-03f, -1.27519500e-02f, -8.15300122e-02f, 9.46787447e-02f, -8.01737309e-02f, -1.23267218e-01f, -1.21433809e-01f,
  -8.19247887e-02f, -1.19610995e-01f, -4.49711606e-02f, -8.29370916e-02f, 8.02575648e-02f, -2.53333189e-02f, -6.18963093e-02f, 8.07327963e-03f, 2.71977782e-02f, 3.26763280e-02f,
  -3.00045669e-01f, 1.03860773e-01f, -5.01175821e-02f, -2.10839123e-01f, -8.91384408e-02f, -1.99357811e-02f, -3.29761766e-02f, -2.00760849e-02f, -4.42934111e-02f, -1.12591609e-01f,
  -1.68011576e-01f, -1.94659159e-01f, -5.14911450e-02f, -5.53489663e-02f, -1.45636439e-01f, -6.73774108e-02f, -2.87100729e-02f, -2.43917983e-02f, -7.71111324e-02f, -5.12533188e-02f,
  -1.14375904e-01f, -9.59944576e-02f, -1.22421920e-01f, -1.25085443e-01f, -1.75273538e-01f, -1.73347801e-01f, -1.39021426e-01f, -1.47539482e-01f, -4.72855866e-02f, -1.33794621e-01f,
  -1.79503128e-01f, -2.12086111e-01f, -1.17311971e-02f, 8.21879879e-02f, 1.38154656e-01f, -5.05938344e-02f, 1.76121294e-03f, -4.24031131e-02f, -1.47103637e-01f, -8.42140615e-02f,
  -6.86771050e-02f, 4.21537831e-03f, -3.07102241e-02f, 1.29686315e-02f, -8.72284994e-02f, -1.51812546e-02f, 5.33176512e-02f, -1.14148572e-01f, -2.08618324e-02f, -1.15342669e-01f,
  -6.56773970e-02f, 1.16603356e-02f, -6.49326444e-02f, -5.38340658e-02f, -2.27437150e-02f, -7.95420334e-02f, 1.03921145e-02f, 4.23276424e-02f, -6.37398511e-02f, -1.29344742e-04f,
  6.66345358e-02f, 3.16186070e-01f, 3.29259396e-01f, -4.90615696e-01f, -2.31857046e-01f, 2.20560040e-02f, 2.98527658e-01f, -1.46129653e-01f, -4.53498781e-01f, 2.56228037e-02f,
  1.37397856e-01f, -3.68641287e-01f, -3.28489482e-01f, 8.00459683e-02f, 1.86092705e-01f, 3.48085552e-01f, 7.63420910e-02f, 2.39139646e-01f, 1.11600727e-01f, 2.26519153e-01f,
  -4.70807543e-03f, 1.57097820e-03f, 7.08519667e-02f, 1.22157417e-01f, -1.37468547e-01f, -2.08955333e-01f, -7.99933001e-02f, 1.22031488e-01f, 2.30754405e-01f, 1.10159799e-01f,
  2.83146173e-01f, 1.47865787e-01f, -2.41115525e-01f, -1.50733665e-01f, 4.96906638e-02f, -4.52890992e-03f, -5.32344431e-02f, -1.17278077e-01f, -4.12117410e-03f, 1.08701684e-01f,
  6.06853962e-02f, 8.81606340e-02f, -1.10717878e-01f, 5.01860678e-02f, -9.83570609e-03f, 1.00402057e-01f, -1.12195782e-01f, 3.12756933e-02f, -9.05892346e-03f, 1.98228598e-01f,
  5.05839474e-02f, 1.15494475e-01f, 1.36487428e-02f, -1.07041523e-02f, 3.21202166e-02f, -6.78780824e-02f, 1.01989590e-01f, 9.59763303e-02f, 2.65279715e-03f, 2.16152817e-02f,
  -7.61286616e-02f, 9.70124900e-02f, 6.95560724e-02f, 4.08369713e-02f, 4.07260731e-02f, -5.37605025e-02f, -7.00325370e-02f, 8.37753341e-02f, 9.41444933e-02f, 2.88612060e-02f,
  -8.45343620e-02f, 7.64828548e-03f, 1.43052032e-02f, -6.21718802e-02f, -1.92356005e-01f, -1.12857884e-02f, 1.06328232e-02f, 4.14364934e-02f, 3.25670950e-02f, 4.86693345e-03f,
  5.00199981e-02f, -6.89681098e-02f, -2.40722597e-01f, 3.66487764e-02f, -5.24897054e-02f, -1.30302057e-01f, -1.06344260e-01f, 1.65761467e-02f, -1.47637784e-01f, -3.09978947e-02f,
  -3.10980201e-01f, 2.30412722e-01f, -1.22142397e-01f, 9.35325846e-02f, -5.48735820e-03f, -1.05052635e-01f, -9.51019078e-02f, -6.09468408e-02f, -1.47059813e-01f, 8.67572799e-02f,
  2.55724400e-01f, -1.72847975e-02f, -1.67052805e-01f, -5.98631911e-02f, -3.32311541e-02f, -1.74080387e-01f, 8.97959396e-02f, -2.39387795e-01f, -6.43125027e-02f, -7.68245459e-02f,
  -1.46807700e-01f, -5.97296581e-02f, -2.87568510e-01f, -2.97353148e-01f, -2.39684999e-01f, -3.27514321e-01f, -9.97728184e-02f, -1.39501527e-01f, -1.73208803e-01f, -9.96267498e-02f,
  -1.51808381e-01f, -3.15716207e-01f, -4.02626336e-01f, -5.17859161e-01f, -2.28245139e-01f, 2.23868862e-01f, 3.69758233e-02f, 1.45609945e-01f, -2.56364912e-01f, -2.17722028e-01f,
  1.32437661e-01f, 4.60038960e-01f, 2.09355593e-01f, 2.77911037e-01f, 3.10818017e-01f, -4.39286679e-01f, -5.56444228e-01f, -6.66999668e-02f, 4.26282883e-01f, 4.76361245e-01f,
  1.64419293e-01f, -1.58058494e-01f, -1.09528840e-01f, -6.05533533e-02f, -3.72003108e-01f, -9.14555714e-02f, -4.40633327e-01f, -2.85588533e-01f, -4.79091518e-02f, -5.96919596e-01f,
  1.91036314e-02f, 7.46599063e-02f, 1.84946612e-01f, 7.09146485e-02f, -1.21632703e-01f, 5.97525341e-03f, -1.80776268e-02f, -1.09987468e-01f, 4.13710773e-02f, -1.83187068e-01f,
  -1.18762255e-01f, 1.47318617e-01f, 5.90775674e-03f, -6.04165345e-03f, -1.74893633e-01f, 1.55295253e-01f, -1.47351503e-01f, -7.56227598e-02f, -9.90791246e-02f, -4.10646945e-02f,
  -7.46896118e-02f, -4.27572317e-02f, -5.38340434e-02f, -4.50199097e-02f, 1.31272674e-01f, 8.78626779e-02f, 2.92802993e-02f, 1.09882303e-01f, -5.18678017e-02f, -4.35122311e-01f,
  -7.67919943e-02f, -1.40180945e-01f, -5.77273704e-02f, 4.88060564e-02f, 2.54493346e-03f, -2.42059883e-02f, -5.30980863e-02f, 9.71123502e-02f, 6.32790402e-02f, -8.89141560e-02f,
  8.70483443e-02f, 2.06850991e-02f, 8.84758234e-02f, -3.27088833e-02f, -2.63833646e-02f, -1.85420942e-02f, -6.59629703e-02f, 7.82362372e-02f, 6.30567893e-02f, -1.22374948e-02f,
  4.20610122e-02f, -7.43331760e-02f, -2.92731095e-02f, 5.32534085e-02f, 7.92607367e-02f, -2.12294012e-02f, 8.83932039e-02f, 1.68302819e-01f, 8.30565318e-02f, -3.80242243e-02f,
  4.42344509e-03f, 1.40014514e-01f, -4.75086719e-02f, 8.59186426e-02f, -1.80691555e-01f, -6.43309951e-02f, -1.75821826e-01f, -7.97372386e-02f, -7.28866607e-02f, 2.39146575e-02f,
  1.43406421e-01f, 8.96975920e-02f, -6.77267388e-02f, 1.18752858e-02f, 8.20386410e-02f, 6.78453222e-02f, 4.51517478e-02f, 4.94184196e-02f, 7.86422491e-02f, -8.60341042e-02f,
  -1.47868618e-01f, 4.52739932e-02f, 1.34803519e-01f, 5.01575619e-02f, 5.68316951e-02f, 9.71998498e-02f, -8.41387082e-03f, -4.89414148e-02f, 1.96603209e-01f, -3.10395062e-01f,
  -1.46265686e-01f, 2.22296193e-01f, 4.59234677e-02f, 2.13917807e-01f, -9.40576419e-02f, -3.53816599e-01f, -2.22695664e-01f, -1.99978426e-01f, 1.32490084e-01f, 1.82568967e-01f,
  1.14843227e-01f, 2.77648062e-01f, 3.29240412e-01f, 1.17471404e-01f, -1.02794297e-01f, 8.42188150e-02f, 1.41413808e-01f, -1.61809042e-01f, -3.00316930e-01f, -2.95727372e-01f,
  -1.81847420e-02f, 3.92845906e-02f, -1.69863477e-01f, -1.84761792e-01f, 2.91383892e-01f, 1.11701481e-01f, 1.10107735e-01f, 1.58540234e-01f, -4.78695566e-03f, 4.27996725e-01f,
  4.13674414e-01f, -1.90096572e-01f, -5.99247403e-02f, -1.94766484e-02f, 3.74620873e-03f, -9.93025377e-02f, -1.25924787e-02f, 7.82932341e-03f, -8.91050920e-02f, -1.55821536e-02f,
  -1.23301316e-02f, -5.79292327e-02f, 6.13111369e-02f, -7.07591623e-02f, -1.19842105e-01f, -1.64272651e-01f, -1.06169738e-01f, -3.04576606e-02f, -3.84457000e-02f, -9.98575520e-03f,
  5.17250337e-02f, -8.08251835e-03f, 2.61194706e-02f, -4.10923399e-02f, -1.08961090e-01f, 3.21688056e-02f, -4.67927828e-02f, -1.61093920e-01f, -9.77021828e-02f, -3.09735537e-02f,
  -6.78738754e-04f, 3.57831270e-02f, -5.93958087e-02f, -2.05440596e-02f, -1.07271094e-02f, 5.06011769e-02f, 3.23349051e-02f, 2.28303969e-02f, -4.27516103e-02f, 1.02631040e-01f,
  -1.54394621e-03f, 1.14284456e-02f, -2.48658340e-02f, 8.12151730e-02f, 2.76268777e-02f, 6.91734776e-02f, -5.23331016e-02f, 3.46036479e-02f, -9.38374177e-02f, -5.87436296e-02f,
  -6.39893636e-02f, -3.47520895e-02f, 7.20707607e-03f, 6.78894445e-02f, -7.36155733e-02f, -1.52611762e-01f, 2.47298814e-02f, 4.15739380e-02f, -4.25355099e-02f, 1.32836560e-02f,
  4.07279819e-01f, -1.41717836e-01f, 3.03339481e-01f, 4.60903682e-02f, 7.39430562e-02f, 4.46467511e-02f, 1.34744585e-01f, -1.48237403e-02f, 4.74151745e-02f, 3.80891971e-02f,
  -1.01093084e-01f, 6.88891101e-04f, 4.55240235e-02f, 3.31344642e-02f, -1.47914648e-01f, -1.02434315e-01f, 2.54684710e-04f, 5.03323600e-02f, 3.53301540e-02f, 2.18818530e-01f,
  1.50388330e-02f, -1.24892883e-01f, 1.44762158e-01f, 7.11507769e-03f, 9.73016024e-02f, 4.46136557e-02f, 1.15049310e-01f, 3.93522009e-02f, -1.25369787e-01f, 5.16845249e-02f,
  3.11263204e-01f, 7.99551457e-02f, 4.34756547e-01f, 5.48306964e-02f, -7.04650655e-02f, -3.03172052e-01f, -5.58145106e-01f, -3.05462062e-01f, -3.92728820e-02f, -3.67290387e-03f,
  -2.29872875e-02f, -1.20489657e-01f, 2.51612533e-02f, -2.21908003e-01f, -1.99971452e-01f, -2.19704807e-01f, 6.51238486e-03f, 1.00188851e-01f, -1.84596315e-01f, -3.72027695e-01f,
  -2.74101406e-01f, 1.61831796e-01f, 2.79641420e-01f, 1.07173055e-01f, 3.23696882e-01f, 3.02846041e-02f, 2.17882276e-01f, 3.20808679e-01f, 9.57832299e-03f, 4.31491286e-01f,
  1.88413396e-01f, 4.30615425e-01f, -4.16859925e-01f, 1.03792809e-01f, 1.98800191e-01f, -9.53693613e-02f, -8.90496299e-02f, 2.53874391e-01f, -7.10627297e-03f, 5.02072694e-03f,
  -3.79526205e-02f, 7.50528425e-02f, 1.83480754e-01f, -1.65715277e-01f, -6.54332116e-02f, -2.46498585e-01f, 1.97665289e-01f, 4.38876357e-03f, 1.05679542e-01f, 7.24010840e-02f,
  -3.60463828e-01f, -5.43929897e-02f, 2.04495177e-01f, -1.50630191e-01f, 6.86034262e-02f, 2.56380457e-02f, 7.77772963e-02f, 4.56829667e-02f, -1.00025702e-02f, 3.26844335e-01f,
  -4.43018228e-02f, 9.66110528e-02f, -4.26937081e-02f, -8.02385714e-03f, -2.15904087e-01f, -9.31997076e-02f, 1.70867499e-02f, -9.84887406e-02f, -3.94686088e-02f, -2.61064600e-02f,
  -3.84615883e-02f, 3.17282602e-02f, 6.64185500e-03f, 7.18064234e-02f, -7.35243335e-02f, 7.13561326e-02f, -1.39137074e-01f, -7.07852095e-02f, 7.74314255e-02f, 4.03345823e-02f,
  -1.04312986e-01f, 7.04750940e-02f, 1.39315873e-01f, 1.40251743e-03f, 2.07183957e-02f, -4.08948585e-03f, 2.61533959e-03f, 4.33800183e-02f, 1.41834021e-01f, 5.71836941e-02f,
  -1.92136332e-01f, -3.56058657e-01f, -7.10710138e-02f, -3.57366577e-02f, 8.02936032e-02f, 1.00978807e-01f, 1.10945955e-01f, -6.69653118e-02f, 1.58073664e-01f, 1.88798495e-02f,
  -7.42239952e-02f, -1.61643624e-01f, 1.03918619e-01f, -3.44732888e-02f, -2.48470426e-01f, -1.94033049e-02f, -3.24274063e-01f, -1.67970330e-01f, -1.38833717e-01f, 6.27904832e-02f,
  -9.07032490e-02f, -3.29415530e-01f, -3.01277041e-01f, -2.50741631e-01f, 8.51177145e-03f, -3.52995127e-01f, -2.90470093e-01f, -2.80581206e-01f, -4.71089125e-01f, -5.24896204e-01f,
  5.69756508e-01f, -3.82934153e-01f, -3.56980443e-01f, -8.92412383e-03f, -2.91876495e-01f, -4.56248283e-01f, -5.83781958e-01f, -2.11153820e-01f, 3.16117592e-02f, -4.68639702e-01f,
  -1.90805793e-01f, 3.08526754e-01f, 4.92013507e-02f, 6.25468865e-02f, -1.09397881e-01f, -4.72030044e-01f, -4.55166429e-01f, -1.00957595e-01f, 4.91968282e-02f, -1.75473079e-01f,
  -1.42769754e-01f, 3.08823641e-02f, 2.62057662e-01f, -6.35123327e-02f, -2.49476567e-01f, -1.26717061e-01f, -2.83874542e-01f, -2.61813521e-01f, -2.54935592e-01f, -4.12520260e-01f,
  -2.85648704e-01f, -1.69783652e-01f, 3.67379673e-02f, 1.96871638e-01f, 2.40651183e-02f, 2.71345049e-01f, 1.16134889e-01f, 1.59791842e-01f, 1.14293642e-01f, 4.53663692e-02f,
  3.04652788e-02f, 1.95133895e-01f, 1.43383116e-01f, 6.82291687e-02f, -5.83567917e-02f, -4.02302258e-02f, -1.57568585e-02f, 5.29071316e-02f, -5.21874428e-02f, -1.92695513e-01f,
  -3.36119533e-02f, -7.73569122e-02f, 1.44794330e-01f, -1.56256512e-01f, -6.78071827e-02f, 9.03363526e-02f, -3.01490992e-01f, -1.79354280e-01f, -1.39974967e-01f, -2.36030728e-01f,
  -9.94685367e-02f, -1.14371739e-01f, -1.37164563e-01f, -3.37897940e-03f, 7.66120628e-02f, 1.06764389e-02f, 1.87264070e-01f, 4.31442484e-02f, 8.32214430e-02f, -1.11461081e-01f,
  -6.07958063e-02f, -7.76171312e-02f, 1.41773626e-01f, 4.36760373e-02f, -8.56087655e-02f, 4.10261787e-02f, -2.48254836e-02f, 6.91194609e-02f, 6.84268819e-03f, -3.21657350e-03f,
  1.67206511e-01f, -6.33106232e-02f, 2.28496008e-02f, 9.64799970e-02f, -1.48823500e-01f, 2.05293428e-02f, -5.62723354e-02f, -3.16140726e-02f, 6.34312630e-02f, -6.09319247e-02f,
  2.97728628e-01f, -6.12307340e-02f, -9.81974974e-02f, 1.01154834e-01f, -9.97264609e-02f, -2.08596140e-02f, 6.72364756e-02f, 1.32604122e-01f, 2.24069208e-01f, -8.68293568e-02f,
  -1.27934918e-01f, 7.95518234e-02f, 2.11583804e-02f, -1.79217830e-02f, -5.08529553e-03f, -2.97007374e-02f, -1.14773355e-01f, 7.59284273e-02f, -6.83072256e-03f, -6.91172108e-02f,
  -1.22088499e-01f, 3.33924666e-02f, 2.61575639e-01f, -2.12149918e-02f, -2.69475561e-02f, 1.82966396e-01f, -2.53144234e-01f, -2.10610017e-01f, 6.21052757e-02f, -1.17953703e-01f,
  6.87969983e-01f, 2.40929261e-01f, 1.69429719e-01f, 2.28541061e-01f, 2.02940658e-01f, 5.56504652e-02f, 1.65637732e-01f, -3.47658396e-02f, 4.78201471e-02f, 1.84684232e-01f,
  1.77118525e-01f, 2.24030122e-01f, 7.09685236e-02f, 1.06280856e-01f, 9.04187113e-02f, 8.65563925e-04f, -1.24673761e-01f, 3.31432186e-02f, 1.85270160e-01f, 1.24473125e-01f,
  4.00882028e-02f, 2.71809450e-03f, 1.96072847e-01f, -1.41943910e-03f, 4.48504463e-02f, 1.79953836e-02f, -2.56177969e-02f, 3.21986340e-02f, 4.29569483e-02f, -6.60619289e-02f,
  -1.16300238e-02f, 3.14354956e-01f, 2.60561612e-02f, 9.32793971e-03f, 6.16927333e-02f, -4.65262830e-02f, -2.96167377e-02f, 1.84809677e-02f, 7.11703487e-03f, -1.41942665e-01f,
  -9.64840874e-02f, -9.49729010e-02f, 5.40545136e-02f, 2.36056489e-03f, -1.08877048e-01f, -1.21853530e-01f, 1.61546301e-02f, -9.53415334e-02f, 1.25225494e-02f, -5.61057553e-02f,
  -3.22134756e-02f, -2.77211517e-02f, 6.83465824e-02f, 3.55941919e-03f, 6.11678101e-02f, 6.53547142e-03f, -1.01936869e-02f, -6.24572076e-02f, 3.88557799e-02f, 4.77840044e-02f,
  1.23866096e-01f, 3.09139222e-01f, 1.56580195e-01f, 8.60524029e-02f, 1.65912360e-01f, -6.76958915e-03f, -1.79158021e-02f, 7.66977072e-02f, 1.19562790e-01f, 2.88124159e-02f,
  -2.44206265e-02f, 9.76373535e-03f, -1.55433221e-02f, 4.87828925e-02f, 4.75752465e-02f, -3.65400128e-02f, -1.57972425e-01f, -1.06646985e-01f, 9.02564749e-02f, -1.00499459e-01f,
  -3.48425135e-02f, -1.55096769e-01f, -6.80864900e-02f, -5.79488203e-02f, -2.86805294e-02f, 1.20209247e-01f, -1.01699598e-01f, 6.30727336e-02f, -1.05016660e-02f, -8.45965967e-02f,
  -4.86969709e-01f, 2.36458018e-01f, -7.95006007e-02f, -1.78644076e-01f, 5.39629646e-02f, 5.15717566e-02f, 1.71590105e-01f, 1.67312268e-02f, -1.64624259e-01f, -1.27344847e-01f,
  -2.45097633e-02f, -4.10535932e-02f, 8.21583718e-02f, 8.37078039e-03f, -6.42519444e-02f, -1.30729824e-01f, -2.30693575e-02f, -2.84978207e-02f, -5.35824113e-02f, -1.43900290e-01f,
  -1.13584191e-01f, -1.90400556e-01f, -4.82898280e-02f, 1.13476440e-02f, 2.75628511e-02f, -3.13728489e-02f, -7.71726221e-02f, -1.15233555e-01f, -6.10112362e-02f, -8.01994279e-02f,
  -2.40822598e-01f, 3.77565712e-01f, 4.58349973e-01f, -2.20104791e-02f, 1.70778230e-01f, 1.40753478e-01f, 1.98465154e-01f, -9.07965973e-02f, -8.03109631e-02f, 2.83036083e-01f,
  2.86211282e-01f, -1.45384327e-01f, -2.30515543e-02f, -2.33252600e-01f, -3.06363821e-01f, 1.53195769e-01f, 1.98225677e-01f, -2.34760374e-01f, -4.55017895e-01f, -2.81625062e-01f,
  -9.94354412e-02f, -8.04117769e-02f, -3.17938358e-01f, -1.27593473e-01f, 2.77045518e-01f, -6.40854686e-02f, 2.08589062e-01f, 1.51902512e-01f, 1.95550859e-01f, 4.51242030e-01f,
  2.22618356e-01f, 2.89686918e-01f, -3.66241574e-01f, -1.47734031e-01f, 3.34402680e-01f, -1.26783028e-01f, -6.77388757e-02f, 1.17471956e-01f, -5.29977828e-02f, -1.36294616e-02f,
  2.55486786e-01f, -5.83921908e-04f, 5.58896773e-02f, 5.91996685e-02f, -1.42167583e-01f, -9.74411070e-02f, -1.30982116e-01f, -2.11383238e-01f, -1.55603945e-01f, 2.45726127e-02f,
  2.71982513e-02f, 1.82477936e-01f, 2.23976836e-01f, -8.38425383e-02f, -1.04406267e-01f, -3.48795742e-01f, -8.40514675e-02f, -2.31293023e-01f, -3.12973380e-01f, -1.77275211e-01f,
  -5.37397154e-02f, -5.24855144e-02f, 2.56284978e-02f, 2.84787267e-02f, -2.53345907e-01f, -6.08667098e-02f, -1.35972984e-02f, 1.01516306e-01f, -1.42313898e-01f, -1.24142282e-01f,
  3.05722654e-02f, -4.51728515e-03f, 2.94545460e-02f, 8.02091882e-02f, -1.52287051e-01f, -1.00082690e-02f, 5.32178907e-04f, -5.30308783e-02f, 7.78998435e-02f, -9.21961889e-02f,
  8.96097943e-02f, 1.30697072e-01f, 5.92204444e-02f, -1.10286489e-01f, 3.17743793e-02f, 1.39987871e-01f, -8.86770561e-02f, -2.45732963e-01f, -1.23241231e-01f, 9.24335048e-03f,
  -3.59830469e-01f, -1.93636253e-01f, -1.43774822e-01f, -8.32950696e-02f, 7.52081573e-02f, -7.84786511e-03f, 5.91066107e-02f, 6.91701248e-02f, 2.48269036e-01f, 1.17168576e-01f,
  -2.21817829e-02f, 2.14218888e-02f, 1.40703186e-01f, -2.04733014e-02f, -2.14408487e-01f, 1.19389199e-01f, 7.59824663e-02f, 8.73157904e-02f, -1.50680646e-01f, 3.12039517e-02f,
  2.40837745e-02f, -2.35898107e-01f, -3.03829879e-01f, 1.93824936e-02f, -1.68825611e-01f, -4.52668250e-01f, -3.32112640e-01f, -3.64472955e-01f, -3.11587781e-01f, -5.25902510e-01f,
  2.78572589e-01f, 7.48567283e-02f, -3.50680411e-01f, 2.04908103e-01f, 6.51074126e-02f, 1.52100148e-02f, 2.52772123e-01f, 1.85635388e-01f, 7.71113262e-02f, 1.10267520e-01f,
  -1.18074283e-01f, -4.39865083e-01f, -4.32620078e-01f, -3.09095055e-01f, -5.26858270e-02f, 7.35095739e-02f, -8.06716904e-02f, -2.60244071e-01f, -2.09808558e-01f, 1.80467755e-01f,
  1.66453049e-01f, 1.23854287e-01f, 5.59634343e-02f, -3.96389477e-02f, -1.39913723e-01f, -2.48038679e-01f, -5.67402951e-02f, -1.20683789e-01f, -3.35354835e-01f, -2.23247722e-01f,
  -2.52286822e-01f, -8.47713724e-02f, -4.93103564e-02f, -5.24371341e-02f, 2.45348439e-02f, -6.97798422e-03f, 1.14184143e-02f, -5.53625077e-02f, -2.93682516e-02f, -8.79666060e-02f,
  -1.78905085e-01f, -1.84523717e-01f, -2.63402820e-01f, -1.05013080e-01f, 2.25736182e-02f, -6.33461177e-02f, -1.59236297e-01f, -9.07141566e-02f, -8.42708647e-02f, -1.53265238e-01f,
  -1.45486996e-01f, -1.06297871e-02f, -4.09191884e-02f, 1.19525105e-01f, -9.27333981e-02f, -2.70953983e-01f, -2.21824199e-02f, -1.19979352e-01f, -2.11827606e-01f, 1.78757101e-01f,
  1.40615761e-01f, -2.55150273e-02f, -1.89865809e-02f, 1.13114268e-01f, 2.35024497e-01f, -1.10919610e-01f, 2.77886875e-02f, 7.13566616e-02f, 6.49217367e-02f, 8.53265002e-02f,
  2.81751901e-02f, 7.52619728e-02f, 1.05274931e-01f, 6.21269271e-02f, -1.85248405e-01f, -1.23831327e-03f, 1.00151084e-01f, -1.56884417e-02f, 5.77383265e-02f, 7.23271593e-02f,
  -3.69567536e-02f, 4.74440977e-02f, -1.02622323e-01f, 1.31022170e-01f, -1.14273001e-02f, 1.38470624e-02f, 3.91181447e-02f, -4.82637510e-02f, -1.67643189e-01f, 3.72122191e-02f,
  2.80950934e-01f, -1.48017094e-01f, 1.97342485e-01f, 2.52197944e-02f, 2.65582316e-02f, -9.84745622e-02f, -5.09109013e-02f, 1.24523044e-01f, -6.71155974e-02f, 1.00646079e-01f,
  -8.07332024e-02f, 7.94708729e-02f, -7.95103908e-02f, 2.34423131e-02f, 2.41042711e-02f, 3.51768471e-02f, 3.27782407e-02f, 1.60219229e-03f, 1.55407193e-04f, -5.52451191e-03f,
  7.11652823e-03f, 1.24333948e-01f, 2.37844005e-01f, 1.88750252e-01f, -5.03941700e-02f, 7.11342469e-02f, 1.46613419e-01f, 1.41426459e-01f, -4.55472395e-02f, 4.43371892e-01f,
  -2.16665134e-01f, -3.40870768e-01f, 1.09995522e-01f, 2.19871085e-02f, -1.86051652e-01f, -3.84828776e-01f, -4.55087721e-01f, -2.57905900e-01f, -1.73926622e-01f, -4.37980235e-01f,
  -4.84727263e-01f, -1.89345315e-01f, -1.22223794e-01f, 3.49476635e-02f, 2.66304463e-02f, 8.02860931e-02f, 4.63620424e-01f, 5.06059945e-01f, 3.76398981e-01f, 1.51805997e-01f,
  1.25715569e-01f, 4.64168906e-01f, 4.15998220e-01f, 5.85515440e-01f, 3.14179927e-01f, 2.01581314e-01f, 3.49036694e-01f, 2.62563020e-01f, 1.86389580e-01f, 5.87981224e-01f,
  -2.75185287e-01f, -2.44378239e-01f, -3.87459360e-02f, -6.65579140e-02f, -4.75671254e-02f, 5.24181761e-02f, -4.18249853e-02f, 2.28162080e-01f, -1.68780372e-01f, 6.26535714e-02f,
  -7.29830489e-02f, 7.25039095e-02f, -8.21249411e-02f, 1.41731456e-01f, -5.35941832e-02f, -2.36075327e-01f, 1.57772779e-01f, 2.05797195e-01f, 4.61963676e-02f, -1.28617510e-01f,
  1.75298024e-02f, -6.05886802e-02f, -2.90416062e-01f, -2.23842889e-01f, -1.02417022e-02f, 7.08933249e-02f, -6.57758908e-03f, 6.44994453e-02f, -8.47900361e-02f, -5.87009080e-03f,
  -5.62394708e-02f, 5.81309758e-02f, -1.66119248e-01f, 2.03548949e-02f, 1.15614317e-01f, -1.03189517e-02f, 2.01120570e-01f, 1.13118529e-01f, 1.91030335e-02f, -7.97805041e-02f,
  -5.86390682e-02f, -2.46552173e-02f, 8.07916522e-02f, -4.28022891e-02f, 1.16612472e-01f, -4.67710905e-02f, -7.03894347e-02f, 1.10866040e-01f, 1.51787013e-01f, -1.64301954e-02f,
  -4.48726714e-02f, -1.38152555e-01f, -1.77243166e-02f, 6.79089595e-03f, 1.01672754e-01f, 8.99762660e-02f, 1.10719614e-01f, 1.10343462e-02f, -8.63843262e-02f, -8.64090323e-02f,
  -2.39792407e-01f, 1.07130058e-01f, -1.72075182e-01f, -6.46658521e-03f, -4.27161455e-02f, -2.53960286e-04f, -2.53811441e-02f, 8.72275233e-02f, -2.27651313e-01f, -4.89807222e-03f,
  -1.83476359e-01f, -9.46810842e-02f, -1.28638044e-01f, 1.35803163e-01f, 2.01607179e-02f, -8.58921185e-02f, -7.97327794e-03f, -1.46319970e-01f, -9.33623761e-02f, -6.97505753e-03f,
  -1.26935565e-03f, -1.22931540e-01f, -2.31385365e-01f, -3.59348834e-01f, -7.14796409e-02f, -1.58023775e-01f, 5.64493565e-03f, -3.25332172e-02f, -2.97580272e-01f, -2.89561868e-01f,
  -4.59893733e-01f, 3.61250758e-01f, -1.32419229e-01f, -3.65720719e-01f, -2.42908865e-01f, 2.20991783e-02f, 2.71723777e-01f, 1.10433726e-02f, -1.72406062e-01f, 1.23471193e-01f,
  8.12132880e-02f, -2.79460661e-02f, 1.04606384e-02f, 8.62027034e-02f, 1.41941637e-01f, 8.38313401e-02f, -2.39670560e-01f, -3.04105282e-01f, -2.85310410e-02f, 1.41344264e-01f,
  3.03107034e-02f, -1.01254575e-01f, -2.19617248e-01f, -1.64030910e-01f, -2.69819691e-04f, -1.95609912e-01f, -4.38015945e-02f, -6.13248199e-02f, 3.55369523e-02f, -2.28285179e-01f,
  2.63659626e-01f, -2.39239082e-01f, -1.13782108e-01f, -1.88667908e-01f, 1.50930164e-02f, -1.11866444e-01f, -6.64101020e-02f, -1.57050431e-01f, -9.46348086e-02f, 6.19942434e-02f,
  -3.79531123e-02f, -8.05780590e-02f, -1.39551699e-01f, 3.64672542e-02f, -1.18603986e-02f, 4.63674217e-02f, 1.58930402e-02f, -7.05266818e-02f, 2.31763553e-02f, 1.76518753e-01f,
  3.46183367e-02f, -4.08639126e-02f, -7.46312886e-02f, 5.28037511e-02f, -8.10546521e-03f, -4.55156453e-02f, 1.82869390e-01f, -7.21481591e-02f, -7.71528855e-02f, 1.28994986e-01f,
  9.27739497e-03f, 3.63613665e-03f, -4.55863178e-02f, -7.53806438e-03f, 8.42015669e-02f, -7.23452047e-02f, -4.40637581e-02f, 2.14753002e-02f, -6.18033670e-02f, 5.62552288e-02f,
  -1.64649449e-02f, 8.07924494e-02f, 1.11285664e-01f, 1.26572587e-02f, -1.86289363e-02f, -9.62590054e-02f, 1.29910437e-02f, 1.13074586e-01f, 3.97873782e-02f, -1.12051018e-01f,
  -9.94751677e-02f, 2.14560069e-02f, -7.56424665e-02f, -2.70750280e-02f, 3.71712074e-02f, -1.02032244e-01f, 1.74768493e-02f, 9.01922733e-02f, -3.03547904e-02f, 5.56221679e-02f,
  2.33620435e-01f, -1.28423661e-01f, -5.11716716e-02f, -1.11919589e-01f, -1.34273231e-01f, -5.08310720e-02f, -6.02742136e-02f, -1.41533270e-01f, -3.34705152e-02f, 5.00827916e-02f,
  -7.06660822e-02f, -3.68197635e-02f, 6.66000924e-05f, 5.80587871e-02f, 8.90246127e-03f, 2.39435788e-02f, -6.12344742e-02f, -5.17084189e-02f, -4.19267006e-02f, 7.92092271e-03f,
  1.17433704e-01f, 3.48655172e-02f, 3.53207588e-02f, 2.13159509e-02f, -6.73450232e-02f, -1.98422313e-01f, 1.75782174e-01f, 2.63061170e-02f, 6.43983483e-02f, 1.92410737e-01f,
  1.78172290e-01f, -3.99493147e-03f, -2.26142723e-02f, 1.28244758e-01f, -1.40253842e-01f, -3.65464240e-02f, -7.93393627e-02f, -4.27725120e-03f, 1.94048703e-01f, 1.05137534e-01f,
  -1.03972197e-01f, 8.39650184e-02f, 1.54416114e-01f, 1.72854915e-01f, 1.28316626e-01f, 1.60799429e-01f, 1.19206540e-01f, 1.48283660e-01f, 1.92505643e-01f, 1.08318001e-01f,
  8.99418592e-02f, 6.87566698e-02f, 3.67678255e-02f, 2.22772166e-01f, 1.63729429e-01f, 1.69259116e-01f, 2.65672076e-02f, 9.93098244e-02f, 4.69169877e-02f, 3.55391055e-01f,
  1.88354999e-02f, -4.53760475e-02f, -8.95851329e-02f, -6.51628152e-02f, -9.61396173e-02f, 1.01689470e-03f, -2.90500764e-02f, -1.46096304e-01f, -2.44185608e-02f, 3.29170637e-02f,
  -4.72355783e-02f, -9.04597633e-04f, 1.71359796e-02f, -1.12124369e-01f, -1.36071742e-01f, -6.81229830e-02f, 2.88505629e-02f, 8.86177048e-02f, 5.03628552e-02f, -4.86907735e-03f,
  2.40840521e-02f, -1.50395110e-01f, -1.34002700e-01f, 2.21775323e-02f, 7.50496909e-02f, 9.38420556e-03f, -1.11169428e-01f, -7.87143782e-02f, -6.27268702e-02f, 8.19062963e-02f,
  1.91666514e-01f, 2.01619044e-02f, 1.36871025e-01f, 1.66906968e-01f, 2.06226543e-01f, 1.16098449e-01f, 7.89596047e-03f, 7.92664848e-03f, -4.40607108e-02f, 6.63460139e-03f,
  4.76253591e-02f, 1.24483660e-01f, -7.60592222e-02f, 1.00203976e-01f, 3.94907668e-02f, -8.89177620e-02f, -7.14892969e-02f, -1.07682943e-01f, -1.18549585e-01f, -5.32939136e-02f,
  -8.18236098e-02f, 4.79277335e-02f, -1.25771731e-01f, 6.83906376e-02f, 9.19334497e-03f, -8.65770727e-02f, -2.61648297e-02f, -6.24038465e-02f, -1.60631239e-01f, -8.83971006e-02f,
  -2.09576219e-01f, -2.05189690e-01f, 1.59952968e-01f, -7.16408566e-02f, -1.62361607e-01f, -1.96753830e-01f, -8.04011971e-02f, -8.34384486e-02f, -2.49778032e-01f, -6.67380169e-02f,
  -1.24053366e-01f, -3.02180946e-02f, -1.26790807e-01f, -6.79577515e-02f, 2.88556162e-02f, -1.38974622e-01f, -1.31509364e-01f, 1.56652629e-02f, -8.11040252e-02f, -2.25500818e-02f,
  -9.11845267e-02f, -1.45226896e-01f, -1.93379566e-01f, -8.20439588e-03f, 1.95752997e-02f, -1.53590009e-01f, -5.45807108e-02f, -1.32494345e-02f, -1.87904298e-01f, -1.79646999e-01f,
  -1.60534710e-01f, -2.68387526e-01f, -2.81217635e-01f, -2.96742588e-01f, 1.86913088e-01f, 2.60035973e-02f, -3.70483726e-01f, -3.16686183e-01f, -9.36231762e-02f, -1.53922677e-01f,
  2.45660752e-01f, 3.55943888e-01f, -2.47216970e-01f, -1.90021873e-01f, -5.63692570e-01f, -5.44058621e-01f, -4.87624645e-01f, -4.07239079e-01f, -1.47890998e-02f, 3.62422794e-01f,
  2.16525987e-01f, -5.63464239e-02f, -1.06820710e-01f, -1.75853461e-01f, 5.22426032e-02f, -1.63970180e-02f, -1.55488133e-01f, -1.05965301e-01f, 5.62155992e-02f, -1.72406039e-03f,
  -1.27716944e-01f, -8.07276890e-02f, 1.58557862e-01f, 2.01851919e-01f, 1.00925513e-01f, -4.92040161e-03f, 1.36942964e-03f, -5.11001609e-02f, 1.33534849e-01f, -1.56940803e-01f,
  8.27257484e-02f, 1.67751923e-01f, 7.12956041e-02f, 1.15324982e-01f, -1.00372054e-01f, 1.25296684e-02f, -1.78213239e-01f, -2.66628295e-01f, -3.21202695e-01f, 3.86495888e-02f,
  2.17540905e-01f, 4.29690108e-02f, -1.90732062e-01f, -1.04775064e-01f, -2.28346497e-01f, -4.83422317e-02f, -4.64317650e-02f, 6.66386187e-02f, -2.90027112e-01f, -2.34200001e-01f,
  -1.41132072e-01f, -1.10738337e-01f, 2.29133833e-02f, -3.91958877e-02f, -1.10139782e-02f, 2.37514190e-02f, -3.13049257e-02f, -2.68595256e-02f, 9.82680991e-02f, 4.17106673e-02f,
  -5.65438473e-04f, -4.14322689e-02f, -1.05753578e-01f, -8.58582854e-02f, 4.62494344e-02f, -8.82109925e-02f, -5.17807119e-02f, -6.00091182e-02f, 1.45341530e-02f, -1.76792741e-02f,
  9.98539478e-02f, 8.85602180e-03f, -8.52075368e-02f, -2.85541005e-02f, -6.55602887e-02f, -2.17753723e-01f, 2.27014180e-02f, 9.31935608e-02f, -7.96154216e-02f, 4.03550044e-02f,
  -2.31262624e-01f, -1.01685345e-01f, -7.30095431e-02f, -6.40488043e-02f, -1.32808432e-01f, 8.84012356e-02f, 5.70505532e-03f, 3.61598399e-03f, 1.28624856e-01f, 9.96728837e-02f,
  7.94059634e-02f, -2.80246250e-02f, -2.24087894e-01f, 5.60919233e-02f, 5.85769583e-03f, -5.42936893e-03f, -8.32256079e-02f, -6.51019812e-02f, 1.68649864e-03f, 2.20917568e-01f,
  -1.12398490e-01f, -2.38609627e-01f, -3.25189382e-01f, -2.74261504e-01f, -6.31706044e-03f, -1.93781450e-01f, -2.13218689e-01f, -7.85323083e-02f, -2.80992508e-01f, -2.75105178e-01f,
  4.81668413e-01f, 3.77497487e-02f, 2.06037015e-01f, 3.43886435e-01f, 1.58533156e-01f, -2.16762841e-01f, -2.82195836e-01f, -2.34560266e-01f, -5.54555692e-02f, 5.39893657e-02f,
  1.21408105e-01f, 1.75207257e-02f, -1.02035813e-01f, -1.27814442e-01f, -1.53261796e-01f, -1.19582422e-01f, 1.68592278e-02f, 1.18480809e-01f, 2.02248469e-01f, 2.67185271e-01f,
  1.80162936e-01f, 2.49255031e-01f, 2.55139858e-01f, 1.38812795e-01f, 1.97014838e-01f, 1.36494711e-01f, 5.93399853e-02f, 1.87271863e-01f, 1.22203596e-01f, 2.50173897e-01f,
  4.33418781e-01f, 5.52913547e-02f, -2.69828498e-01f, -5.97261153e-02f, 6.14856742e-02f, 8.78926425e-04f, 1.27898389e-02f, -1.74480394e-01f, -3.42220962e-02f, -2.03719065e-02f,
  2.47807615e-03f, -6.31096587e-02f, 3.67214717e-02f, 4.54739928e-02f, -7.53188208e-02f, -2.00613648e-01f, -4.87054661e-02f, -1.32836401e-01f, -1.53468549e-01f, 4.65855785e-02f,
  8.00012797e-02f, 1.98555097e-01f, 1.04868980e-02f, -2.88198650e-01f, -1.70229495e-01f, 8.67503881e-02f, -1.21455081e-01f, 9.42431297e-03f, -2.03025937e-01f, 1.79749690e-02f,
  2.13176161e-02f, -3.20058363e-03f, 2.91960388e-02f, -1.17443345e-01f, -6.45904317e-02f, -1.23278588e-01f, 1.18599739e-03f, -7.72710890e-02f, 9.78720095e-03f, 5.29846139e-02f,
  -6.92561455e-03f, 1.70817479e-01f, 6.85674027e-02f, 4.55559865e-02f, 1.26170283e-02f, -8.45982060e-02f, 1.82609871e-01f, -1.37534186e-01f, 1.48315419e-04f, -4.82591875e-02f,
  2.02547997e-01f, -4.05565947e-02f, 1.26028255e-01f, -9.07116905e-02f, -3.67998928e-02f, -3.42428237e-02f, 6.48503453e-02f, 9.97723863e-02f, 1.03752483e-02f, 2.35644151e-02f,
  -3.02807808e-01f, -4.42917347e-01f, -2.39221063e-02f, -1.35419369e-01f, -1.19635081e-02f, -7.73739219e-02f, -7.52928928e-02f, -8.55248272e-02f, -8.01026374e-02f, -4.28376198e-02f,
  6.76912144e-02f, -2.45009991e-03f, -1.44496918e-01f, -3.55640315e-02f, 3.08331773e-02f, -1.17087074e-01f, 7.36746937e-02f, 7.19618574e-02f, -1.02898419e-01f, -4.57912423e-02f,
  -1.47360429e-01f, -6.53942227e-02f, 1.22212090e-01f, -2.20692530e-01f, -1.46813750e-01f, -9.27303080e-03f, -2.15262007e-02f, -5.88508621e-02f, -8.59622359e-02f, -1.20683447e-01f,
  -6.32520080e-01f, 4.77413973e-03f, -4.09715831e-01f, -6.27165496e-01f, -1.69033274e-01f, 1.12713166e-01f, 5.55159569e-01f, -1.18231587e-03f, -3.51291746e-01f, -5.78719340e-02f,
  1.24462180e-01f, 8.37470144e-02f, -7.02115670e-02f, 1.15644917e-01f, 3.73648673e-01f, 1.66685537e-01f, -1.41148297e-02f, 1.49615454e-02f, 2.58997232e-01f, 4.11118388e-01f,
  2.13095456e-01f, -1.22821048e-01f, -2.10246995e-01f, -1.18247613e-01f, -2.46255115e-01f, -9.53325778e-02f, -3.57496053e-01f, -1.86570138e-01f, 1.23376146e-01f, -2.48657107e-01f,
  1.86207786e-01f, -4.39149737e-01f, 8.55539516e-02f, -9.09514874e-02f, -3.20675224e-02f, -1.15884013e-01f, 1.10326968e-01f, -1.74346954e-01f, -7.82297775e-02f, -1.32746443e-01f,
  -1.20666377e-01f, -5.16952537e-02f, -8.25188996e-04f, -4.61593866e-02f, -7.00550303e-02f, 2.18291637e-02f, -7.35289678e-02f, 1.27164032e-02f, -8.03726390e-02f, -4.32263166e-02f,
  1.46863550e-01f, -1.45807877e-01f, -2.65819728e-01f, 9.22373235e-02f, 5.57778589e-03f, -1.37085706e-01f, 4.84466329e-02f, 2.72617824e-02f, -7.08193034e-02f, -9.53005478e-02f,
  4.23851702e-03f, 3.03567573e-03f, 8.09199065e-02f, 3.56338359e-02f, 1.05758645e-01f, -8.48362315e-03f, -8.79935548e-02f, 6.80787116e-02f, 8.31765756e-02f, -7.62456208e-02f,
  -1.20830290e-01f, -2.55304668e-03f, 2.68612728e-02f, -4.58445847e-02f, 9.61189449e-04f, -8.01794156e-02f, 1.88413635e-02f, 1.19231433e-01f, 8.71260278e-03f, -8.29718411e-02f,
  -9.79376435e-02f, -7.13967755e-02f, -1.32399768e-01f, 8.79723579e-02f, 3.02043706e-02f, -4.22158651e-02f, -1.47249490e-01f, 4.24417034e-02f, 9.61777791e-02f, -4.12505642e-02f,
  9.29772332e-02f, -1.15855746e-01f, -1.33103862e-01f, -7.78843686e-02f, -1.71377733e-01f, -9.43721980e-02f, -3.44010489e-03f, 6.61570057e-02f, -6.04076646e-02f, 1.53112058e-02f,
  6.95426464e-02f, 1.13003828e-01f, 5.69519848e-02f, 5.06426059e-02f, 1.10207386e-01f, -1.89381242e-02f, 1.42890543e-01f, 4.12038267e-02f, 2.80782059e-02f, -5.09761721e-02f,
  2.19241045e-02f, 8.19026381e-02f, 9.88948718e-02f, -4.20803251e-03f, 2.02459246e-02f, 1.49103642e-01f, 4.10565101e-02f, 1.62874654e-01f, 1.43151805e-01f, 2.15798974e-01f,
  3.04953784e-01f, 4.14366663e-01f, 3.41486692e-01f, 1.54305503e-01f, 1.00236088e-02f, -1.67498559e-01f, -1.11242041e-01f, -1.58395860e-02f, 8.32437575e-02f, 7.95373768e-02f,
  5.70670776e-02f, 2.54787412e-02f, 9.13364664e-02f, -1.18152402e-01f, -1.36508539e-01f, -2.15192690e-01f, -1.92083299e-01f, -1.58221483e-01f, -1.90243065e-01f, -2.79336035e-01f,
  -2.99102187e-01f, -8.43018442e-02f, 4.81400779e-03f, 9.45197940e-02f, 1.38510838e-01f, 9.36106965e-02f, 1.14575639e-01f, 1.75229594e-01f, 4.78043742e-02f, 9.31905136e-02f,
  9.19402763e-02f, 2.01217845e-01f, -9.09780860e-02f, 4.87282947e-02f, 2.08946571e-01f, 1.72847047e-01f, -3.70623311e-04f, 1.44880146e-01f, -1.41233290e-02f, -6.25611171e-02f,
  8.78705010e-02f, 3.30040120e-02f, 1.36718929e-01f, 9.81560498e-02f, 4.64178855e-03f, 8.06303173e-02f, -6.16730610e-03f, -9.37461257e-02f, -1.17058314e-01f, 1.25498220e-01f,
  6.62779510e-02f, 2.22411621e-02f, -8.30416530e-02f, -1.54042348e-01f, -1.45619974e-01f, 2.09109858e-02f, 1.98950060e-02f, 5.01017757e-02f, 6.88426569e-02f, 4.05634828e-02f,
  -7.10215643e-02f, 2.47623697e-02f, 6.39125779e-02f, -5.64653762e-02f, -6.53678551e-02f, -1.24978513e-01f, -1.83802042e-02f, -1.64260030e-01f, -1.56214312e-01f, -5.04165748e-03f,
  -7.70118833e-02f, -8.60505551e-02f, 4.47879881e-02f, -1.15705267e-01f, 1.38241649e-02f, 5.54919131e-02f, -5.00231162e-02f, -6.15549907e-02f, -5.81965409e-02f, 1.46986609e-02f,
  -1.60764173e-01f, -2.20478349e-03f, 2.00692222e-01f, -5.12938574e-02f, 2.43347269e-02f, 3.54752764e-02f, 4.63717291e-03f, 6.51527718e-02f, 1.39304936e-01f, -1.31653562e-01f,
  5.61600849e-02f, 3.45476791e-02f, -1.93160608e-01f, -5.37396688e-03f, 5.18174581e-02f, 1.63051918e-01f, 1.11811869e-01f, 1.47812981e-02f, 2.00492535e-02f, -5.62724099e-02f,
  3.93164530e-02f, 4.90342379e-02f, 3.96575667e-02f, -3.96819636e-02f, -1.24968618e-01f, -3.24770994e-02f, -6.36634976e-02f, 6.24851733e-02f, -3.98398563e-02f, 9.13476944e-02f,
  1.32625684e-01f, -1.36250898e-01f, -1.22356728e-01f, -8.03205147e-02f, -7.08832070e-02f, 1.39923330e-04f, -9.07082409e-02f, 5.05174734e-02f, -9.95947570e-02f, -3.74540351e-02f,
  -6.33905530e-01f, 1.80304006e-01f, -4.43625338e-02f, -6.08783066e-02f, -8.83159414e-02f, -1.05157904e-01f, 5.61803877e-02f, -3.01675480e-02f, 1.35127008e-01f, 2.38113269e-01f,
  4.08579297e-02f, -2.09850341e-01f, -1.47978634e-01f, -2.45914638e-01f, -3.84423852e-01f, 3.94467749e-02f, 1.55152064e-02f, -4.74428982e-01f, -5.39758921e-01f, -4.50536758e-01f,
  -4.10182565e-01f, -4.60593820e-01f, -5.74571133e-01f, -3.22205424e-01f, -2.21066661e-02f, -3.20328474e-01f, -4.27647904e-02f, -4.03211474e-01f, -3.39186668e-01f, -1.85099989e-01f,
  1.72595888e-01f, -2.67250508e-01f, -7.29910955e-02f, -7.03033060e-02f, 2.23985799e-02f, 1.16278961e-01f, 2.01894697e-02f, 6.25041723e-02f, 1.70367099e-02f, 7.61412233e-02f,
  6.80799410e-02f, 8.50803629e-02f, -3.92919369e-02f, -3.57813649e-02f, -3.33570577e-02f, -1.02682494e-01f, 8.47044121e-03f, 1.33565124e-02f, 6.12083785e-02f, 2.39878386e-01f,
  7.94726983e-02f, -1.56036586e-01f, -3.64503451e-02f, -8.87185149e-03f, 6.03303686e-02f, -7.69455358e-02f, 3.31436982e-03f, 2.21591126e-02f, -5.35153039e-02f, 1.29402101e-01f,
  1.41561896e-01f, 1.13795906e-01f, 4.85045463e-02f, -4.40605842e-02f, 2.81670522e-02f, -1.64125096e-02f, 3.70315202e-02f, 1.01506151e-01f, -1.10532477e-01f, 1.88519359e-02f,
  4.69598807e-02f, -5.94779151e-03f, -5.63046187e-02f, -7.28215501e-02f, -8.37991759e-02f, -3.30065601e-02f, 1.96578000e-02f, -1.75297931e-02f, -1.16280979e-02f, 4.33044955e-02f,
  -1.75958239e-02f, -4.08875756e-03f, -3.03516872e-02f, 1.12070926e-02f, 1.19730523e-02f, 8.51663649e-02f, 7.48911798e-02f, -4.86047566e-03f, -6.47256151e-03f, -7.02062622e-04f,
  7.91110024e-02f, -2.91054755e-01f, 6.34343028e-02f, -5.29993996e-02f, 1.24451503e-01f, 1.59172341e-01f, 1.87177379e-02f, 8.83173291e-03f, -4.54265624e-02f, 1.43067772e-02f,
  -4.09812666e-02f, -5.05643548e-05f, 1.71997268e-02f, 9.91317108e-02f, -6.53617606e-02f, 1.02642719e-02f, 5.21348715e-02f, 3.91172245e-02f, -2.85068564e-02f, 3.05133879e-01f,
  2.30117977e-01f, 1.07742371e-02f, 9.27973166e-02f, 1.31312400e-01f, 8.92551392e-02f, -1.42003253e-01f, 3.99143584e-02f, 2.77207624e-02f, -9.55022871e-02f, 2.51343727e-01f,
  5.84815323e-01f, 3.01858515e-01f, -3.37798446e-01f, 2.02002317e-01f, -3.23537290e-01f, -3.31289172e-01f, -3.34720343e-01f, -4.24991660e-02f, 8.81145373e-02f, 1.27924785e-01f,
  4.47299816e-02f, 3.80405709e-02f, 2.27144971e-01f, -1.28320158e-01f, -4.54599969e-02f, -1.48058543e-02f, -1.33932576e-01f, -1.37373418e-01f, -3.33151609e-01f, -3.98351938e-01f,
  -2.74810404e-01f, -5.85084930e-02f, -4.82683582e-03f, -9.59590226e-02f, 1.12814102e-02f, -1.71727091e-01f, -3.08934059e-02f, -7.41500184e-02f, -1.13925673e-01f, -2.63693873e-02f,
  -3.94556642e-01f, -1.08873993e-02f, -7.14163855e-02f, 1.28701970e-01f, -1.36747779e-02f, 8.97810385e-02f, -3.31364945e-02f, -1.40466765e-02f, 1.21555343e-01f, -5.35919983e-03f,
  5.79112284e-02f, 4.78481725e-02f, -6.80103060e-03f, -4.59584557e-02f, -1.32550448e-01f, -8.89605284e-02f, -6.37140349e-02f, -8.55513737e-02f, 6.41196370e-02f, 2.03247666e-02f,
  8.99655372e-02f, -1.45712774e-02f, 5.96812889e-02f, -2.45258715e-02f, -8.91761407e-02f, -9.11033154e-02f, -4.57144752e-02f, -1.71408921e-01f, 1.08216330e-02f, 7.27787539e-02f,
  9.38105360e-02f, 2.26509258e-01f, 1.23708062e-01f, 6.95741624e-02f, 6.90016970e-02f, 7.21713975e-02f, 6.92621768e-02f, -4.81187068e-02f, -3.27150226e-02f, 1.00529715e-01f,
  -5.11518717e-02f, 3.43661457e-02f, 5.47100008e-02f, 1.44564450e-01f, 2.01486191e-03f, 9.73489806e-02f, 9.00209323e-02f, 3.35142650e-02f, 3.23189981e-02f, 1.01464249e-01f,
  5.44635616e-02f, 9.64092091e-03f, 8.24742839e-02f, 2.36255117e-03f, -2.33358219e-02f, 1.08840585e-01f, -1.42735709e-02f, -4.92535233e-02f, 7.91930929e-02f, -2.13126373e-02f,
  1.39880523e-01f, 1.09837979e-01f, 1.24034904e-01f, -7.95898810e-02f, -1.37350224e-02f, -1.06623530e-01f, 1.17363706e-01f, -3.10051274e-02f, 1.05505705e-01f, -8.77311155e-02f,
  -4.99257408e-02f, -5.09667536e-03f, 5.34220524e-02f, -9.76093020e-03f, -1.04886815e-01f, -2.01247662e-01f, 1.01726599e-01f, 7.86581263e-03f, 3.00742332e-02f, -3.41203548e-02f,
  1.90034047e-01f, 1.61014125e-01f, 1.95593745e-01f, 8.37381333e-02f, -3.41433063e-02f, 8.76365900e-02f, -2.33439244e-02f, 2.55269138e-03f, 1.18768722e-01f, 2.88841844e-01f,
  -2.52237678e-01f, 2.17492044e-01f, -2.45820865e-01f, 6.94929203e-03f, 2.27919683e-01f, 1.48606777e-01f, 2.75103062e-01f, 1.98544472e-01f, -5.62738515e-02f, 1.76709026e-01f,
  2.51082957e-01f, 3.84282947e-01f, 3.55937779e-01f, 3.13594639e-01f, 1.80674896e-01f, 1.19806193e-01f, -5.15913107e-02f, -1.52422443e-01f, -2.86222473e-02f, 1.44884922e-03f,
  3.41299742e-01f, -1.45851951e-02f, -1.93889454e-01f, -7.46271713e-03f, -1.24561206e-01f, 1.55405849e-01f, -3.27313095e-02f, -5.09089157e-02f, 6.53358325e-02f, -3.11565489e-01f,
  4.66139689e-02f, -2.64841050e-01f, -3.87371331e-02f, -6.90907612e-02f, -1.48869991e-01f, -1.34746090e-01f, -1.75484702e-01f, -3.47381830e-01f, -1.62067235e-01f, -1.59558952e-01f,
  -2.53239363e-01f, -1.70451596e-01f, 1.61549762e-01f, 8.92078578e-02f, -8.88534188e-02f, -6.58734590e-02f, -5.00699468e-02f, -2.60118634e-01f, -1.82951525e-01f, -1.87486440e-01f,
  2.75213361e-01f, -3.76276374e-01f, -3.83993387e-01f, -8.64826143e-04f, -1.88442618e-01f, -1.66090518e-01f, -3.30516219e-01f, -4.99046594e-01f, -2.68437564e-01f, -6.01931095e-01f,
  -2.79038921e-02f, -4.80264537e-02f, -4.70051505e-02f, -3.06159295e-02f, 1.25458259e-02f, -6.52407901e-03f, 6.16363622e-02f, 8.62775221e-02f, -1.93823222e-02f, -7.57243186e-02f,
  8.80710259e-02f, -1.66086815e-02f, -5.81183359e-02f, -1.84996687e-02f, 4.87799458e-02f, -1.34111807e-01f, -2.09161285e-02f, -8.26172382e-02f, -1.04389004e-02f, 9.72075388e-02f,
  8.93344507e-02f, 9.03643575e-03f, 5.73859103e-02f, -2.52505876e-02f, -6.70715123e-02f, 1.14965001e-02f, -9.58075300e-02f, 1.15736179e-01f, 4.72604297e-03f, 5.22226393e-02f,
  2.22052246e-01f, 2.12395638e-01f, -1.07619151e-01f, 8.18806961e-02f, -1.00729965e-01f, 1.39662661e-02f, -4.82560359e-02f, 9.62357372e-02f, 1.26716673e-01f, 1.16547406e-01f,
  -2.11383715e-01f, -6.91074654e-02f, 2.00816840e-01f, 9.76455398e-03f, -3.48568968e-02f, 9.77473035e-02f, 1.98991820e-01f, 1.39323352e-02f, -5.63199669e-02f, -1.98004737e-01f,
  -5.56584373e-02f, -1.68879911e-01f, -8.14338923e-02f, 9.26591381e-02f, -4.45844568e-02f, 1.33692488e-01f, -8.94080568e-03f, -2.72165477e-01f, 9.93326306e-02f, -8.23487192e-02f,
  6.39982462e-01f, -2.25393891e-01f, 1.67541251e-01f, 5.63788600e-02f, -8.05716440e-02f, -1.54814303e-01f, -3.93052071e-01f, -7.52231479e-02f, 1.06665850e-01f, 3.09058800e-02f,
  6.22453280e-02f, 3.28210741e-01f, 3.31148326e-01f, 2.19904587e-01f, 1.49725437e-01f, -1.21557221e-01f, -3.81721258e-02f, 2.93947011e-01f, 6.09498806e-02f, -1.84566200e-01f,
  -2.38487110e-01f, -8.44556242e-02f, 1.17267326e-01f, 8.54670554e-02f, -1.44271091e-01f, 3.14003676e-02f, 4.97105494e-02f, -5.75112812e-02f, -1.14846662e-04f, 5.04638953e-03f,
  4.10748482e-01f, -4.79679704e-02f, -7.23430980e-03f, 9.49269067e-03f, -4.10588197e-02f, -2.16043591e-02f, -4.80362996e-02f, 2.61697005e-02f, -5.57019114e-02f, -7.76418969e-02f,
  -5.96770830e-02f, -2.61860862e-02f, 9.12632793e-04f, -8.37335810e-02f, -8.79445672e-02f, -3.48434933e-02f, 2.86196126e-03f, 2.37825778e-04f, -4.21504304e-02f, -8.44328031e-02f,
  -9.97146145e-02f, -1.00362070e-01f, 5.77239543e-02f, -8.34694803e-02f, -8.84230211e-02f, 1.11487664e-01f, 5.41050509e-02f, 1.26725649e-02f, 7.22256675e-02f, 5.94554655e-02f,
  -9.79345851e-03f, 8.50239098e-02f, -4.20304202e-02f, -1.67292207e-02f, -5.22089750e-02f, -2.72038449e-02f, -6.36925325e-02f, -3.99624258e-02f, 3.96309085e-02f, -7.68242702e-02f,
  -5.99618852e-02f, 1.40014142e-02f, -2.03738967e-03f, -4.06529643e-02f, 2.13842820e-02f, -1.80483051e-02f, 3.16050462e-02f, -6.45559281e-02f, 8.22544247e-02f, 8.51481557e-02f,
  1.28068998e-01f, 1.06392771e-01f, 7.92965591e-02f, 1.15493573e-02f, -2.31505111e-02f, 7.02757388e-02f, 1.10608777e-02f, -4.01100628e-02f, -3.77076417e-02f, -3.35454047e-02f,
  -4.52695675e-02f, 1.33720741e-01f, 1.57206610e-01f, 6.56955019e-02f, -1.07653223e-01f, -6.96879104e-02f, 1.81323122e-02f, -2.42915563e-02f, -5.08455075e-02f, -1.57496203e-02f,
  9.33951419e-03f, 4.62228842e-02f, 4.65398692e-02f, -1.03470748e-02f, -4.20845971e-02f, 5.50547661e-03f, -7.71146342e-02f, 1.24671608e-01f, -2.91905068e-02f, -6.87769204e-02f,
  -4.27261889e-02f, -1.46144047e-01f, 4.93110456e-02f, -7.81679526e-02f, -2.57861596e-02f, 9.04535204e-02f, 7.99482986e-02f, -7.67136440e-02f, -1.24909589e-03f, -1.68601528e-01f,
  3.26871097e-01f, 2.90848523e-01f, 3.64687175e-01f, 2.93879583e-02f, -1.47424728e-01f, 5.02257198e-02f, 1.01097263e-01f, 1.04101896e-01f, -1.13782644e-01f, -5.33475950e-02f,
  -1.41831025e-01f, -2.73920059e-01f, -1.63829342e-01f, -7.37265795e-02f, 6.93412051e-02f, 1.43634468e-01f, 5.49608618e-02f, 3.49178910e-01f, 1.32908568e-01f, 7.25410506e-02f,
  -1.38327554e-01f, 1.84840247e-01f, 1.70578718e-01f, 1.19596235e-01f, -9.03705806e-02f, -1.39551237e-01f, 1.33003034e-02f, 1.20882653e-01f, 4.48451117e-02f, 1.39092714e-01f,
  3.45277861e-02f, 1.03263356e-01f, -3.05386811e-01f, -1.26660898e-01f, 1.06014600e-02f, 1.39607921e-01f, 6.56800196e-02f, 4.10074070e-02f, -4.84523512e-02f, -7.16441795e-02f,
  -6.29389286e-02f, 9.55187231e-02f, 8.71501043e-02f, 9.59628373e-02f, -1.48376143e-02f, 3.67042609e-02f, 3.62252444e-02f, 2.25358680e-01f, 3.87738086e-02f, -1.12346448e-01f,
  -1.83974013e-01f, 1.94398630e-02f, 1.96314439e-01f, -7.07248077e-02f, -1.21543864e-02f, -7.76224360e-02f, 5.59912473e-02f, -8.51335675e-02f, 1.00264326e-01f, 4.11769710e-02f,
  -1.54669091e-01f, 9.99687836e-02f, -9.75284725e-02f, -1.57225151e-02f, 8.53362754e-02f, 3.49736102e-02f, 7.25542232e-02f, -9.98298451e-02f, 7.37199336e-02f, 1.30757183e-01f,
  1.51338130e-01f, 1.78738281e-01f, 1.60449266e-01f, 5.68449823e-03f, -2.45022066e-02f, 1.74847439e-01f, 1.86969563e-01f, 1.40139028e-01f, 3.88197154e-02f, -2.24717949e-02f,
  4.62545492e-02f, 4.63759862e-02f, 7.50379488e-02f, 8.02114233e-02f, 1.16984263e-01f, -7.64318276e-04f, -2.60317996e-02f, 2.65651178e-02f, 6.54396564e-02f, 1.87386423e-01f,
  -1.89247906e-01f, -8.46678168e-02f, -1.23177618e-01f, 3.06376442e-02f, 1.40295839e-02f, -1.55033739e-02f, 5.84616186e-03f, 1.29692405e-01f, 5.86310960e-02f, 5.66502614e-03f,
  5.78259416e-02f, 2.45656446e-02f, -8.30052048e-03f, 1.21129431e-01f, -1.76635161e-02f, -9.50810835e-02f, 2.79777404e-02f, 1.24345161e-02f, 4.09305654e-02f, -9.13701206e-02f,
  -8.90694335e-02f, -2.81508826e-02f, 8.92671198e-03f, -1.61407307e-01f, -1.43264532e-01f, -1.28156319e-01f, -1.20332852e-01f, -1.40522942e-01f, -5.32581024e-02f, -8.79099816e-02f,
  -1.37113437e-01f, -4.82125044e-01f, -2.17714489e-01f, -3.05066735e-01f, -3.76431465e-01f, -2.30141878e-01f, -3.83342385e-01f, -2.08945349e-01f, -2.63669968e-01f, -5.67949176e-01f,
  -2.39505976e-01f, 3.73169065e-01f, 3.51661205e-01f, 1.60024881e-01f, 6.96342364e-02f, -5.07089794e-01f, -3.39034468e-01f, 1.83633971e-03f, 7.09694996e-02f, -3.35667163e-01f,
  -4.64225739e-01f, -2.96762675e-01f, -1.12134747e-01f, -1.27113680e-03f, -3.84153068e-01f, -1.03180623e-02f, -1.35509297e-01f, -1.23214453e-01f, -2.22969428e-01f, -3.31805617e-01f,
  5.85180931e-02f, 2.06209812e-02f, 1.32876351e-01f, 1.45867825e-01f, -1.14237085e-01f, 6.21029316e-03f, -1.43589024e-02f, 9.90306586e-02f, 8.19968209e-02f, -2.24140137e-01f,
  2.57778335e-02f, -8.55686739e-02f, 8.27714652e-02f, -3.42348740e-02f, -2.81353384e-01f, -2.22578600e-01f, -1.85461313e-01f, -1.17766194e-01f, -4.17500399e-02f, -1.67162731e-01f,
  -2.97847718e-01f, -1.52918831e-01f, 1.30097330e-01f, -3.07669155e-02f, 4.39699851e-02f, 1.54063448e-01f, 8.92684683e-02f, 1.12139463e-01f, 8.60203803e-02f, -2.80150980e-01f,
  -1.56583816e-01f, 5.47219366e-02f, 3.29177193e-02f, -1.69874914e-02f, -1.33404732e-02f, 7.98471048e-02f, -7.12255687e-02f, -7.91128576e-02f, 1.47467434e-01f, 1.35404289e-01f,
  -5.13629541e-02f, -9.62254703e-02f, 2.34884042e-02f, -1.75571144e-02f, 1.49051487e-01f, 4.72589210e-02f, 3.22246850e-02f, -9.13686678e-02f, 1.39187491e-02f, 2.23964043e-02f,
  1.39723808e-01f, -6.15519285e-02f, -1.80358905e-02f, 6.29841238e-02f, -5.69361169e-03f, -1.30636856e-01f, -5.33681549e-02f, -2.89720893e-02f, -9.26243737e-02f, -8.21148232e-02f,
  2.33109325e-01f, 2.35792503e-01f, 1.80090610e-02f, 1.94073156e-01f, -4.59212698e-02f, -5.46332151e-02f, 4.49391492e-02f, 3.42668146e-02f, -5.90794347e-03f, -1.04131155e-01f,
  5.72447889e-02f, -3.44847925e-02f, 5.58317900e-02f, -1.65736247e-02f, -4.28368524e-02f, -1.52906924e-01f, -2.37597167e-01f, -6.96324483e-02f, 3.40144732e-03f, -8.84695873e-02f,
  -2.61235952e-01f, -1.37379706e-01f, 1.04166113e-01f, 4.76865694e-02f, -6.96987584e-02f, 1.70968726e-01f, 8.65600780e-02f, -1.93427410e-02f, 7.65152946e-02f, -3.54165703e-01f,
  -1.30314857e-01f, 8.39561149e-02f, -8.27875137e-01f, 2.53223270e-01f, 2.39660069e-01f, -1.07801527e-01f, -1.78840980e-01f, -2.23054588e-01f, 1.81818530e-01f, 1.66284263e-01f,
  1.73742518e-01f, 2.02122808e-01f, 2.66193636e-02f, -4.44771796e-02f, -2.56682307e-01f, 7.25948140e-02f, 3.20678353e-02f, -3.27738643e-01f, -3.47328901e-01f, 1.16071112e-01f,
  5.58051705e-01f, 3.42174351e-01f, -5.36989830e-02f, 3.63061130e-02f, 2.78955638e-01f, 2.84050584e-01f, -1.12146912e-02f, 1.34698302e-01f, 2.46118866e-02f, 6.58847168e-02f,
  -3.28793168e-01f, -3.46709311e-01f, -2.50099301e-02f, 1.76774278e-01f, -8.30485225e-02f, -1.93167642e-01f, -9.13306475e-02f, -2.37932339e-01f, -5.22900512e-03f, 3.09675350e-03f,
  1.21120334e-01f, -9.73890722e-02f, 1.27405301e-01f, 5.01910150e-02f, 6.52995333e-03f, -2.14765012e-01f, -2.37154767e-01f, -3.59988004e-01f, -3.79936725e-01f, -2.87473023e-01f,
  2.72244453e-01f, -5.27654141e-02f, -5.85667789e-01f, -1.63897082e-01f, -4.39915895e-01f, -7.74983615e-02f, -4.38028336e-01f, -2.99839050e-01f, -4.47537303e-01f, -2.85917312e-01f,
  2.95680575e-03f, 6.36327267e-02f, -2.70648468e-02f, -1.23915888e-01f, 2.17806950e-01f, 2.00151857e-02f, 7.87536874e-02f, 7.04944059e-02f, 6.95552230e-02f, -9.06860754e-02f,
  -5.83246686e-02f, -5.26900068e-02f, 1.07547650e-02f, -7.18699442e-03f, 1.41662702e-01f, -3.81652340e-02f, -2.22061779e-02f, 1.85170006e-02f, -6.09979145e-02f, 1.63392089e-02f,
  2.45964099e-02f, -4.90262210e-02f, 5.43271974e-02f, -4.12895828e-02f, -1.00097343e-01f, -1.05197147e-01f, 1.30656645e-01f, -2.44470444e-02f, -9.22990665e-02f, 1.96718276e-02f,
  3.40065986e-01f, 4.10803035e-03f, 1.87161118e-02f, -1.14670821e-01f, 2.96226777e-02f, 4.51452434e-02f, 2.55744636e-01f, 7.29663372e-02f, 5.67787215e-02f, -8.67551640e-02f,
  -1.22091457e-01f, -5.01297675e-02f, 1.84285030e-01f, 6.50239456e-03f, 2.11198237e-02f, 1.11562654e-01f, 2.44928703e-01f, -6.08342104e-02f, -1.42341228e-02f, 6.93160892e-02f,
  1.55122906e-01f, -4.60305437e-02f, 6.89207949e-03f, -1.39669254e-01f, -7.50926696e-03f, 2.95140613e-02f, -6.74110651e-02f, -1.53284207e-01f, -2.33581737e-01f, 1.65470570e-01f,
  -4.20113951e-01f, 5.77551007e-01f, 4.38574791e-01f, -3.26081395e-01f, 7.15157166e-02f, 3.87507290e-01f, 4.89441395e-01f, 8.86877179e-02f, -2.18616173e-01f, 1.61310911e-01f,
  1.00679900e-02f, -3.65553141e-01f, -1.06978945e-01f, -4.45912480e-02f, 6.84783831e-02f, 4.20337439e-01f, 3.29017431e-01f, -1.48328558e-01f, -3.99435580e-01f, -2.39029288e-01f,
  -9.11980495e-02f, -3.54780018e-01f, -3.60455722e-01f, -1.28750280e-01f, 1.75200135e-01f, -1.74303085e-01f, 1.54638723e-01f, 3.28056980e-03f, 3.13216507e-01f, 1.57368109e-01f,
  4.84255143e-02f, 2.91680634e-01f, -1.67610630e-01f, -2.24143341e-01f, 1.77595466e-01f, 3.84947881e-02f, 5.91229536e-02f, 3.89456861e-02f, 9.93320867e-02f, -4.35753316e-02f,
  4.40033302e-02f, 1.82631090e-01f, -1.44380052e-02f, 1.10800132e-01f, -7.86183625e-02f, -8.09556991e-03f, 5.84272332e-02f, -1.72635049e-01f, -4.39251885e-02f, 9.64792445e-02f,
  -6.09302446e-02f, -1.35611415e-01f, -5.02741896e-02f, 1.24001980e-01f, 6.56613484e-02f, -3.27622384e-01f, -1.04346713e-02f, 4.77309264e-02f, 1.07433081e-01f, -3.49353775e-02f,
  -6.53845668e-02f, 5.33088893e-02f, 6.78399354e-02f, 1.10337414e-01f, 9.00837034e-02f, 1.23069085e-01f, 4.86831032e-02f, -1.39837116e-02f, 4.21622582e-02f, -7.21894875e-02f,
  2.31368653e-02f, -7.38399699e-02f, 1.52781578e-02f, 1.01443909e-01f, 7.41275353e-03f, 4.36429195e-02f, 7.23657459e-02f, -9.06285420e-02f, -2.15599197e-03f, 2.83566937e-02f,
  -1.34148374e-01f, 9.00668744e-03f, -8.00618306e-02f, -1.07475705e-01f, 1.00135475e-01f, 1.18228674e-01f, -6.59327507e-02f, -3.51290517e-02f, -7.03812689e-02f, 1.61071494e-01f,
  -3.87975514e-01f, 6.12505451e-02f, -1.67428970e-01f, 6.79654554e-02f, 2.05867916e-01f, 1.95625331e-02f, 7.51374941e-03f, 1.63659938e-02f, 3.40649337e-02f, -1.58965245e-01f,
  9.08936188e-02f, -9.29050334e-03f, -5.79613540e-03f, -1.00545054e-02f, -2.19542220e-01f, -1.03163607e-01f, -8.55268687e-02f, -1.41975597e-01f, -1.40874550e-01f, 6.91797584e-02f,
  7.28892675e-03f, -3.49004298e-01f, -4.66223061e-01f, -2.25966319e-01f, -1.91263303e-01f, -6.02984667e-01f, -2.31474206e-01f, -1.64306447e-01f, -2.10215375e-01f, -3.42760593e-01f,
  -3.36076647e-01f, -5.73652148e-01f, 4.17779922e-01f, 3.01298909e-02f, 2.77049899e-01f, 2.09118366e-01f, 1.87467292e-01f, -1.59135591e-02f, -1.55981198e-01f, -6.18802011e-03f,
  -2.41732776e-01f, -3.54477912e-01f, -3.61670144e-02f, -2.56067127e-01f, -3.33593696e-01f, 1.77267149e-01f, 2.61726260e-01f, 1.69396669e-01f, 1.97778828e-02f, -6.60969391e-02f,
  -2.15069383e-01f, -1.70046955e-01f, -2.82473892e-01f, -1.08612016e-01f, 9.59049612e-02f, 2.07168446e-03f, 1.91206962e-01f, 1.54200010e-02f, -1.25305429e-01f, 4.10841852e-02f,
  3.33466619e-01f, -2.65391350e-01f, 1.43070564e-01f, -2.83240795e-01f, -1.29342183e-01f, -1.74679771e-01f, -3.26969549e-02f, 3.28634232e-02f, -1.09212197e-01f, 3.97923812e-02f,
  -2.19859947e-02f, -1.13117389e-01f, 6.60619512e-03f, 3.94023359e-02f, 5.45010567e-02f, -5.79778291e-03f, -7.11775646e-02f, -1.29556671e-01f, 1.34037361e-02f, -7.36238807e-02f,
  -8.55863243e-02f, -2.99553145e-02f, 2.11562842e-01f, 1.26329169e-01f, -7.21566901e-02f, -5.81862442e-02f, -9.70529951e-03f, -4.37117219e-02f, 5.12805842e-02f, 6.83790073e-02f,
  -1.19826227e-01f, 3.33537422e-02f, -1.47360086e-01f, 3.43003087e-02f, 7.22450912e-02f, 3.10355481e-02f, 4.15220484e-02f, -3.69600169e-02f, 4.14986424e-02f, -8.18549246e-02f,
  -7.06220269e-02f, -3.62186544e-02f, -1.03757447e-02f, -1.02299325e-01f, -8.31822827e-02f, 4.48417937e-04f, -5.80963157e-02f, -4.81173322e-02f, -7.57850111e-02f, 1.16612297e-02f,
  -3.01468745e-02f, 1.23485059e-01f, -6.73744977e-02f, -1.89845841e-02f, -2.45852079e-02f, -7.66552240e-02f, -2.03391481e-02f, -1.43604383e-01f, -1.11729622e-01f, -9.32833925e-02f,
  1.28171459e-01f, -9.54036936e-02f, 1.44513041e-01f, -1.05347879e-01f, -6.08352385e-02f, -1.47405937e-01f, -5.03287874e-02f, -1.34468814e-02f, -5.14221191e-02f, -4.02190723e-02f,
  -1.48914725e-01f, -2.25921590e-02f, 9.47468877e-02f, 2.67262515e-02f, 8.56357515e-02f, 8.13648775e-02f, -1.00211784e-01f, -3.69041786e-02f, -6.72197202e-03f, 1.62090678e-02f,
  -1.45965621e-01f, -9.59221181e-03f, 1.36335522e-01f, 1.43896326e-01f, 9.81749743e-02f, 1.08382575e-01f, 6.03035465e-02f, 1.53224379e-01f, 9.53937545e-02f, 6.92531988e-02f,
  -7.39724517e-01f, -2.02125713e-01f, 2.72362441e-01f, -2.24935517e-01f, 1.39009386e-01f, 2.10622355e-01f, 2.86996424e-01f, -2.10552420e-02f, -2.11003065e-01f, -3.71722295e-03f,
  -1.58802588e-02f, -9.74043738e-03f, 7.58823007e-03f, -6.36566058e-02f, 2.60953829e-02f, 1.01812594e-01f, 9.94398817e-02f, 1.11756898e-01f, 1.39375240e-01f, 1.24621019e-01f,
  -1.03471063e-01f, -1.88985810e-01f, -2.67282069e-01f, -2.27328062e-01f, -6.01340570e-02f, 5.23211844e-02f, 5.92234209e-02f, -1.34958595e-01f, 1.94158629e-02f, -2.22339015e-02f,
  4.41442847e-01f, -2.26585656e-01f, 1.61288641e-02f, -4.71789688e-02f, -1.03391543e-01f, -8.33557472e-02f, -1.99342370e-02f, -5.48249185e-02f, -1.19820654e-01f, -1.26932427e-01f,
  -1.50423408e-01f, -8.84864256e-02f, 3.15638483e-02f, 4.45397245e-03f, -4.14212532e-02f, -9.39724073e-02f, -1.11377306e-01f, -1.89491585e-02f, -3.38448435e-02f, 7.88478702e-02f,
  4.64635380e-02f, -1.04870170e-01f, 1.04828864e-01f, 8.43580887e-02f, -7.40449503e-02f, -1.52034322e-02f, 5.75732179e-02f, -5.16932718e-02f, -8.38331580e-02f, -5.36630824e-02f,
  -5.62558323e-02f, -3.70422984e-03f, 1.18372627e-02f, 7.27867708e-03f, -8.30455497e-02f, 1.03753962e-01f, -1.59935858e-02f, 9.37390402e-02f, 3.31428945e-02f, 9.81656834e-02f,
  1.22330204e-01f, 1.47133982e-02f, 6.96076155e-02f, -6.92670941e-02f, -5.30406907e-02f, 1.35312481e-02f, 1.80083103e-02f, -6.74488097e-02f, -7.52560645e-02f, -9.87661257e-02f,
  5.57286339e-03f, -3.78309116e-02f, -3.80843803e-02f, -5.11308610e-02f, -4.53810068e-03f, -2.40115169e-02f, -1.45482086e-02f, 2.78952215e-02f, -2.14841124e-03f, 8.79271850e-02f,
  2.30286285e-01f, 1.05356887e-01f, 3.81928147e-03f, 2.66684983e-02f, 7.61660784e-02f, 1.94754936e-02f, -9.28694324e-04f, 5.60396016e-02f, 1.27125590e-03f, 7.29243681e-02f,
  -1.34103727e-02f, -3.09275798e-02f, -3.16693485e-02f, -1.51576344e-02f, 1.08556792e-01f, -2.90294196e-02f, -6.92429394e-02f, -6.06355742e-02f, 9.26713496e-02f, 3.74980941e-02f,
  1.28662689e-02f, 1.32895485e-01f, 1.76080227e-01f, 2.27742150e-01f, 9.68459919e-02f, 1.54733405e-01f, 1.62561193e-01f, 9.34126414e-03f, 1.03193693e-01f, 1.07847765e-01f,
  1.82325587e-01f, 1.24889083e-01f, 2.68802822e-01f, -2.84576774e-01f, -5.19208372e-01f, -2.41449833e-01f, -4.28815037e-02f, 1.56622425e-01f, -1.66493475e-01f, -1.26093119e-01f,
  -2.68283695e-01f, -3.32340211e-01f, -2.48137504e-01f, -5.27913980e-02f, 3.79188299e-01f, 2.22105131e-01f, 8.33176523e-02f, 3.58564824e-01f, 3.45413685e-01f, 1.89376757e-01f,
  -7.69999549e-02f, 5.81059679e-02f, 4.28235561e-01f, 3.17707241e-01f, -1.75894171e-01f, -2.36628681e-01f, 5.99248447e-02f, 1.60931814e-02f, 1.34128612e-02f, 5.55570200e-02f,
  -7.26042828e-03f, 2.22218171e-01f, -2.59441137e-02f, -2.91988015e-01f, -1.20815612e-01f, 2.23873764e-01f, 9.19844955e-02f, 1.28888354e-01f, -2.25942507e-01f, 1.47260696e-01f,
  -2.52789229e-01f, -8.44629109e-02f, -3.18815678e-01f, -3.07360161e-02f, -2.53417511e-02f, 1.28478482e-01f, 1.78315148e-01f, 3.14381570e-01f, 1.49553731e-01f, 2.07115352e-01f,
  -4.78677928e-01f, -2.60513932e-01f, -8.86892229e-02f, 8.57982785e-02f, 2.25188613e-01f, -1.80935100e-01f, 7.02627450e-02f, 8.24117959e-02f, 2.24571779e-01f, 2.45387539e-01f,
  -4.58484031e-02f, -1.63608454e-02f, 4.91423830e-02f, 6.95659146e-02f, 1.07478186e-01f, -1.30206138e-01f, -8.26975629e-02f, 4.77706119e-02f, -5.11024743e-02f, 5.39563149e-02f,
  6.13778979e-02f, 2.39140522e-02f, 1.35278374e-01f, 1.15913898e-01f, -1.24854080e-01f, -1.15666188e-01f, 2.17818376e-02f, 5.80084994e-02f, -3.62582728e-02f, 1.50868997e-01f,
  -8.29442292e-02f, 1.66428182e-02f, -1.15955606e-01f, 1.64492399e-01f, -1.23972585e-02f, 5.83345816e-02f, 2.45444179e-02f, 8.08401629e-02f, -3.97333317e-02f, 1.09800808e-01f,
  -1.51683733e-01f, 1.30716294e-01f, -1.10042132e-01f, 4.39001285e-02f, -4.05455679e-02f, -2.88616102e-02f, -1.01253189e-01f, 5.66636398e-02f, -5.86431772e-02f, 2.65915040e-02f,
  -1.35497913e-01f, 4.57397327e-02f, -1.53501257e-01f, -8.32418874e-02f, -5.15460074e-02f, -1.42645046e-01f, -2.55152822e-01f, -3.59363943e-01f, -1.03455976e-01f, -4.14384790e-02f,
  -2.38633201e-01f, -2.27177560e-01f, -3.76481086e-01f, -3.02381426e-01f, -2.62055159e-01f, -3.58965278e-01f, -1.67955592e-01f, -1.67413056e-01f, -2.06477702e-01f, -1.50374815e-01f,
  3.76018554e-01f, 3.37811977e-01f, -7.06853807e-01f, 1.24782950e-01f, -4.58971083e-01f, -4.02956456e-01f, -5.88067733e-02f, 2.62673140e-01f, 2.21713349e-01f, 4.50201705e-02f,
  -2.73457438e-01f, -9.48590934e-02f, -8.10706019e-02f, -1.13190219e-01f, 1.83552355e-02f, -2.17470489e-02f, -2.98056006e-01f, -3.62580478e-01f, -2.22131044e-01f, 4.83013429e-02f,
  1.33284897e-01f, 3.71216238e-01f, 2.39653423e-01f, 1.65580601e-01f, 2.07822528e-02f, -8.67066458e-02f, -1.30856276e-01f, -4.29743193e-02f, -1.66712061e-01f, -1.56184986e-01f,
  1.45934612e-01f, 1.50297089e-02f, -2.44423851e-01f, -3.98739874e-02f, -1.25844151e-01f, 5.70055738e-04f, -1.08978124e-02f, -1.18061990e-01f, -9.05084535e-02f, 3.81973274e-02f,
  -2.28384376e-01f, -5.87717481e-02f, -2.62778252e-01f, -8.47515017e-02f, 1.23216592e-01f, -8.92737135e-02f, 6.22723140e-02f, -5.21468967e-02f, -1.32130096e-02f, 1.63729727e-01f,
  -8.65646154e-02f, -3.68009359e-01f, -2.87819922e-01f, -5.36859334e-02f, -9.28043947e-02f, -3.73370230e-01f, -3.89255621e-02f, -1.13342352e-01f, -1.95529133e-01f, 3.06499660e-01f,
  2.00605497e-01f, -6.54383674e-02f, -8.38334635e-02f, 1.45445615e-01f, 1.45374015e-01f, -1.43327206e-01f, 1.11976918e-02f, 8.93191546e-02f, 5.89548051e-02f, 9.96117108e-03f,
  -1.34203788e-02f, 4.04835194e-02f, 9.69152451e-02f, -4.97029573e-02f, -1.84270880e-06f, -6.91407546e-02f, 3.25192884e-02f, 1.51252329e-01f, 7.85542279e-03f, 7.91508406e-02f,
  4.13929783e-02f, -6.48461804e-02f, -5.97533733e-02f, 1.80162430e-01f, -2.15083942e-01f, -2.73152124e-02f, -1.70042105e-02f, 1.86602827e-02f, 3.26708518e-02f, -3.67815271e-02f,
  4.66729701e-01f, -3.67115796e-01f, 1.02148727e-01f, 3.76448892e-02f, -6.60850331e-02f, -2.32529148e-01f, 5.22001460e-03f, 5.87776154e-02f, -4.31426950e-02f, 1.60989016e-01f,
  -1.61646269e-04f, 1.93054955e-02f, -1.29952386e-01f, -7.00926408e-02f, -1.07945301e-01f, -1.09353401e-01f, 5.84861971e-02f, -2.71140158e-01f, -1.23194307e-01f, 2.34221622e-01f,
  1.02164298e-01f, 2.18784660e-02f, 1.15018971e-01f, 8.26262906e-02f, 7.52277821e-02f, -4.95501906e-02f, 6.33140877e-02f, 2.40676135e-01f, -4.11794186e-02f, 4.64157581e-01f,
  4.76447493e-01f, 1.99423298e-01f, 1.58339679e-01f, 1.19127996e-01f, 2.09431022e-01f, 1.54593125e-01f, 3.44605625e-01f, 9.10146832e-02f, -1.08524943e-02f, 2.41339803e-01f,
  9.54522118e-02f, 4.87523247e-03f, -1.71645567e-01f, -1.19715013e-01f, 2.27843430e-02f, -7.04133511e-02f, -5.56777827e-02f, 7.81609938e-02f, 2.83892862e-02f, 1.65919095e-01f,
  -7.57855400e-02f, 6.23394586e-02f, 1.32510230e-01f, 2.83685196e-02f, -1.30616844e-01f, -5.96049465e-02f, -1.61835819e-03f, 2.31945310e-02f, 4.57469225e-02f, -2.10525408e-01f,
  -1.94847733e-01f, 1.89145148e-01f, -1.80906415e-01f, -5.86502850e-02f, 6.15049303e-02f, 8.26167241e-02f, -4.05219616e-03f, -1.91066923e-04f, -8.52090642e-02f, -9.26712751e-02f,
  -4.35915254e-02f, 4.67211939e-02f, 3.44210900e-02f, 3.09500229e-02f, 1.42133176e-01f, 8.75173509e-02f, -3.42141315e-02f, -3.66619937e-02f, -1.02736555e-01f, -2.82156635e-02f,
  5.46189770e-02f, 2.59714901e-01f, 2.38134012e-01f, 6.35864139e-02f, 1.08342186e-01f, 6.93324283e-02f, 1.51191786e-01f, -1.40799079e-02f, 5.66779450e-02f, -1.46221044e-02f,
  -4.00530882e-02f, 1.96585089e-01f, 1.84288099e-01f, 2.31539443e-01f, 1.58902317e-01f, 1.13213599e-01f, 4.71515916e-02f, 8.90980363e-02f, 1.63124308e-01f, 4.01820578e-02f,
  5.70949391e-02f, -9.07721519e-02f, 2.21586570e-01f, 1.76704437e-01f, 2.19982713e-01f, 2.44129986e-01f, 3.59873891e-01f, 2.86900461e-01f, 1.78801745e-01f, 1.34650812e-01f,
  7.11792111e-02f, 1.11554310e-01f, 1.19227193e-01f, 8.15861970e-02f, 1.74661160e-01f, 2.02797487e-01f, 1.61644548e-01f, 9.81027633e-02f, 1.91418946e-01f, 2.35470548e-01f,
  -1.21405207e-01f, 1.32633895e-01f, -1.02752306e-01f, -9.32148471e-02f, -3.36587639e-03f, -9.47442427e-02f, -8.69846120e-02f, -8.55753571e-02f, -1.71497136e-01f, -6.99566156e-02f,
  -6.72276765e-02f, -6.92861304e-02f, 9.76087824e-02f, -1.15456674e-02f, 8.92371312e-02f, 5.43612316e-02f, -5.59403934e-02f, 3.87101769e-02f, -1.19779460e-01f, -4.10294980e-02f,
  3.84971052e-02f, 1.00063331e-01f, 9.14671719e-02f, -9.52165797e-02f, -6.35380745e-02f, 1.19839972e-02f, -3.25510353e-02f, -2.32374277e-02f, 1.50295153e-01f, 1.33679137e-01f,
  4.12707031e-01f, -7.65478611e-02f, -1.05217472e-01f, -6.03475198e-02f, 2.94362567e-02f, -5.30670285e-02f, -2.31032036e-02f, 3.41064559e-04f, 3.01511493e-02f, 8.06102306e-02f,
  1.39956489e-01f, 9.53467786e-02f, 1.26328811e-01f, 1.34276286e-01f, 1.24390051e-01f, 1.23112739e-04f, 1.07863965e-02f, -2.99420431e-02f, 3.88564600e-04f, 1.09734610e-02f,
  -7.96304792e-02f, -1.52905760e-02f, -5.99878617e-02f, -5.04900888e-02f, 4.40271236e-02f, 4.69668731e-02f, -2.80711558e-02f, -7.05208536e-03f, 7.13958442e-02f, -5.65063842e-02f,
  4.85269800e-02f, 7.54162520e-02f, 1.04221031e-01f, 2.27242261e-02f, -3.24387439e-02f, -4.05170806e-02f, 5.78827038e-02f, -6.44789264e-02f, 9.15203542e-02f, -1.18483286e-02f,
  1.35291358e-02f, 4.08874080e-03f, 6.13226965e-02f, -2.87124235e-02f, -1.01351805e-01f, 7.45015517e-02f, -3.84692997e-02f, -6.27115518e-02f, 5.37306108e-02f, -5.04401105e-05f,
  1.10554107e-01f, 6.88173845e-02f, 1.39569834e-01f, 2.19064578e-02f, 1.35516115e-02f, 7.42247626e-02f, -7.06355646e-02f, 9.94113181e-03f, 4.87175696e-02f, 6.51629269e-02f,
  2.07179025e-01f, 3.61363620e-01f, 2.81368405e-01f, 1.23129509e-01f, 1.57612801e-01f, 1.66816473e-01f, 5.47894388e-02f, 8.91856179e-02f, 1.23073131e-01f, 3.73449922e-02f,
  -1.00611262e-01f, 5.29293232e-02f, -1.14831112e-01f, -1.45408725e-02f, 6.74504489e-02f, -1.44489547e-02f, 3.38257700e-02f, 1.29248068e-01f, 1.61119714e-01f, 1.38208404e-01f,
  -3.23542878e-02f, 1.00438170e-01f, 2.29594745e-02f, -1.53488033e-02f, 1.13025591e-01f, -4.25900891e-03f, 1.65786028e-01f, 1.37870342e-01f, 5.92798144e-02f, 6.11691326e-02f,
  -1.72357783e-01f, 1.60971642e-01f, 8.27634186e-02f, -9.04560909e-02f, 3.93254906e-02f, -9.11960155e-02f, -1.34221300e-01f, -1.45089343e-01f, -4.76943739e-02f, -2.91071162e-02f,
  -1.67259574e-01f, -6.75736591e-02f, -7.18780607e-02f, -8.10929574e-03f, -3.92236896e-02f, 7.21384436e-02f, -7.01000914e-03f, -3.85224670e-02f, -9.58549231e-02f, -1.00941658e-01f,
  5.39261252e-02f, 4.72820736e-02f, 1.03316627e-01f, 2.46451255e-02f, 2.23179278e-03f, 7.38110766e-02f, 8.19717571e-02f, 4.25910316e-02f, 9.11297649e-02f, 1.14293233e-03f,
  3.37774634e-01f, 2.91113108e-01f, 1.20885216e-01f, 1.90338656e-01f, 2.31030270e-01f, 2.60708839e-01f, 2.12788925e-01f, 1.51109084e-01f, 1.60246953e-01f, 1.39321268e-01f,
  2.59325027e-01f, 1.98641837e-01f, 1.53968781e-01f, 7.42205381e-02f, 2.08705053e-01f, 4.18994762e-02f, -9.52179078e-03f, -9.46350172e-02f, 3.71870841e-03f, 1.53250650e-01f,
  1.36530727e-01f, 1.06258973e-01f, 1.86843594e-04f, -4.64051217e-02f, 5.81200533e-02f, -2.94487067e-02f, 2.24109869e-02f, 5.97920865e-02f, 1.37784749e-01f, -3.60516347e-02f,
  -2.67128110e-01f, 5.26970774e-02f, -8.05048645e-02f, 2.99949367e-02f, 4.85975407e-02f, -1.81425229e-01f, -5.39460108e-02f, -1.45882413e-01f, -3.88792567e-02f, -9.17996764e-02f,
  -5.65341227e-02f, -1.10512838e-01f, -4.46832553e-02f, -5.13767637e-02f, -5.17950905e-03f, -7.83402622e-02f, -1.50685042e-01f, -1.53882354e-01f, -6.30794093e-02f, -5.22120781e-02f,
  2.28525186e-03f, 7.88300559e-02f, 7.54094496e-02f, 2.78428346e-02f, 1.51421100e-01f, -7.17773139e-02f, 3.75366509e-02f, 6.43266812e-02f, 7.60789812e-02f, -1.29494458e-01f,
  1.78523548e-02f, 1.65081918e-01f, 4.96198125e-02f, -7.10029006e-02f, -4.22757082e-02f, -1.27333254e-01f, -1.21439420e-01f, 3.67017090e-02f, 6.31773174e-02f, -8.10000766e-03f,
  -2.61393245e-02f, 2.46152026e-03f, -1.41065791e-01f, -1.06426485e-01f, -4.75508124e-02f, -6.04190864e-02f, -2.66061220e-02f, 6.19211979e-03f, -4.19905037e-02f, 1.26939891e-02f,
  -9.43716839e-02f, -5.93219995e-02f, -2.47031655e-02f, -9.27164033e-02f, -1.48431048e-01f, -1.35860637e-01f, -6.53651133e-02f, 5.17079234e-02f, 2.12077796e-02f, -4.62471917e-02f,
  -2.06151798e-01f, 4.65946123e-02f, -1.75855219e-01f, -2.26334762e-02f, 3.02235130e-02f, 1.13195390e-03f, -4.90229391e-02f, -1.83656707e-03f, -6.68149740e-02f, -1.88326880e-01f,
  -1.36250824e-01f, -1.59028262e-01f, 5.47283515e-02f, -1.19112976e-01f, -1.30302548e-01f, -1.30228132e-01f, -9.65324324e-03f, -1.23828903e-01f, -8.43033046e-02f, -8.65891129e-02f,
  4.75092493e-02f, -1.01730153e-01f, -3.86267267e-02f, 1.00924876e-02f, 3.32858339e-02f, 1.19856736e-02f, -1.27586707e-01f, -3.48803252e-02f, -8.45956877e-02f, -1.31671146e-01f,
  4.87552404e-01f, 1.66816950e-01f, -2.55151689e-01f, 2.20027864e-01f, -8.78910795e-02f, -3.19900997e-02f, 8.19500163e-02f, 2.31025264e-01f, 1.50103554e-01f, 1.09438285e-01f,
  7.16338009e-02f, -1.18723698e-01f, -7.94528648e-02f, -1.58547699e-01f, 5.03598712e-02f, -1.71207994e-01f, -1.90021113e-01f, -1.88484937e-01f, -7.16117918e-02f, 6.94372505e-03f,
  7.40256757e-02f, 2.22238213e-01f, 1.39874190e-01f, 1.33424876e-02f, -1.83188722e-01f, -1.01809487e-01f, -1.64619610e-01f, -5.03522083e-02f, -1.19584046e-01f, -1.98107064e-01f,
  -4.52005893e-01f, -2.86454633e-02f, -3.63335833e-02f, 1.97790619e-02f, 1.04941532e-01f, 1.58632815e-01f, 6.32024836e-03f, 1.71180636e-01f, 1.91539913e-01f, 1.16451181e-01f,
  -3.40299532e-02f, -8.26916844e-03f, -4.32407111e-02f, -1.01820573e-01f, 6.32036701e-02f, 3.12883295e-02f, 5.88660967e-03f, -9.90913156e-03f, -1.18239120e-01f, -1.31827399e-01f,
  -1.25963837e-01f, -6.43972829e-02f, 1.00113168e-01f, 3.55436690e-02f, -3.16939689e-02f, -3.97259258e-02f, -2.35440908e-03f, -4.90248054e-02f, -1.03135444e-02f, 1.13626957e-01f,
  1.19177036e-01f, -2.32979972e-02f, -1.08902596e-01f, 2.98271480e-04f, 8.28069970e-02f, 7.33464733e-02f, 1.15298629e-01f, 3.98218557e-02f, -6.87974645e-03f, 1.15131974e-01f,
  1.63393632e-01f, -1.67024702e-01f, -1.15279332e-01f, 8.90651941e-02f, -8.93831626e-02f, -9.28825140e-02f, -9.23519060e-02f, -7.46055320e-02f, -1.19721033e-01f, -1.50986671e-01f,
  -4.85323332e-02f, 1.08192295e-01f, 3.40779871e-02f, -9.73701105e-02f, -6.42592683e-02f, -2.53056251e-02f, -1.51280075e-01f, 5.17025264e-03f, 8.38091597e-02f, 3.80843431e-02f,
  -1.92166954e-01f, -4.71347004e-01f, -1.78416017e-02f, -1.70749947e-01f, -2.49709631e-03f, 5.00257947e-02f, -2.74900317e-01f, 4.88908552e-02f, 5.92859834e-02f, 8.77386611e-03f,
  -9.82444957e-02f, 3.71219367e-02f, -1.21741742e-01f, 8.85013044e-02f, 1.49652719e-01f, 4.94130850e-02f, 6.63913414e-02f, 8.34843069e-02f, -1.17599525e-01f, -3.24355625e-02f,
  1.16571538e-01f, 1.14303164e-01f, 9.56307203e-02f, 1.27609102e-02f, 6.15196005e-02f, 6.50800988e-02f, 6.36454076e-02f, 8.14747885e-02f, -7.22920448e-02f, 3.31830323e-01f,
  -6.85762346e-01f, -1.28992334e-01f, -2.91707534e-02f, -3.54798555e-01f, 7.20382407e-02f, 2.84238100e-01f, 1.52267769e-01f, 3.59820649e-02f, -1.43351302e-01f, 1.19015470e-01f,
  -2.46347077e-02f, -1.86055750e-01f, -2.68386602e-01f, 1.92063190e-02f, -1.05351791e-01f, 1.46765679e-01f, 1.89145789e-01f, -2.23155007e-01f, -2.85981119e-01f, 1.32630784e-02f,
  -3.69565226e-02f, -3.14591199e-01f, -3.94421279e-01f, -2.70597607e-01f, -1.54505894e-01f, -2.73926407e-01f, -1.54986620e-01f, -9.93373692e-02f, 1.01208150e-01f, -1.14662260e-01f,
  -4.60682958e-02f, -5.44677377e-02f, -4.35809493e-02f, -7.38360570e-04f, -9.04263854e-02f, 2.25943644e-02f, -5.53119332e-02f, -6.19601980e-02f, -2.22754348e-02f, 2.85723060e-02f,
  -7.09518418e-02f, 3.34923416e-02f, -1.27997249e-01f, -1.95514457e-03f, -7.10339868e-04f, 6.49969205e-02f, 1.04860164e-01f, 2.92942896e-02f, 3.63640785e-02f, 2.24946842e-01f,
  2.53135085e-01f, 2.97593176e-02f, 1.10779010e-01f, 5.55280112e-02f, 1.31267145e-01f, -1.39743807e-02f, -4.27484214e-02f, 1.39061823e-01f, 1.68349549e-01f, -1.57958418e-01f,
  2.68708337e-02f, 5.91048487e-02f, 2.39796899e-02f, -7.37905428e-02f, -5.90351783e-03f, -4.70330156e-02f, -6.28746003e-02f, 3.53874229e-02f, -1.01181835e-01f, -1.30352125e-01f,
  -5.32649569e-02f, 1.50969297e-01f, -7.45029226e-02f, -1.34687155e-01f, 4.66607213e-02f, -6.47426769e-02f, 3.45970653e-02f, 9.04120058e-02f, 1.68943275e-02f, -3.56195942e-02f,
  2.14985739e-02f, 1.05874270e-01f, -5.15485555e-02f, 3.64054181e-02f, 1.12935334e-01f, 7.25868866e-02f, 1.54580593e-01f, 8.79899114e-02f, 2.96137929e-02f, -2.00299732e-02f,
  -3.97388637e-01f, 1.59239277e-01f, -1.60149574e-01f, 8.78784060e-02f, 5.21811396e-02f, 8.52023512e-02f, 6.22456335e-02f, 9.54866707e-02f, -8.46560870e-04f, 2.44539827e-02f,
  2.44943663e-01f, 4.17043008e-02f, -9.72991437e-02f, -4.18271823e-03f, -1.41164616e-01f, -4.47596377e-03f, 6.49371967e-02f, -1.07158668e-01f, 2.44809255e-01f, 1.97509080e-01f,
  2.76753873e-01f, 1.02558829e-01f, -9.11378711e-02f, 6.86594397e-02f, 1.42964929e-01f, -2.12417860e-02f, -1.35410339e-01f, 3.83060612e-02f, -5.06963395e-02f, -1.87758788e-01f,
  4.92067784e-01f, -1.71690449e-01f, 9.03147757e-02f, 2.41016120e-01f, -7.51615688e-02f, -2.41321951e-01f, -3.42681706e-01f, -2.06011295e-01f, -1.87623352e-02f, 4.77334857e-02f,
  9.74980742e-02f, 2.54273444e-01f, 1.84301108e-01f, 1.56158488e-02f, 3.04974560e-02f, -1.36998311e-01f, 1.11871831e-01f, 1.72571391e-01f, 1.95034355e-01f, 1.62673771e-01f,
  1.72786847e-01f, 1.90050721e-01f, 2.12627813e-01f, 1.34033442e-01f, 2.26240799e-01f, 1.74745530e-01f, -4.92918678e-02f, 1.20319232e-01f, 1.66754529e-01f, 2.40642205e-01f,
  2.60854721e-01f, 1.89945232e-02f, 3.68597619e-02f, 7.72747546e-02f, 7.50669762e-02f, 5.28276414e-02f, -4.40293998e-02f, -7.35637844e-02f, 4.61309478e-02f, -5.48641495e-02f,
  3.79285496e-03f, 7.36740381e-02f, -7.54530579e-02f, 2.96124518e-02f, -1.23604886e-01f, 1.43839382e-02f, -6.57059178e-02f, 3.83750089e-02f, -8.25370941e-03f, -4.00729105e-02f,
  1.56249832e-02f, -6.29885048e-02f, -1.29423663e-01f, -2.06257761e-01f, -3.38837355e-02f, 1.09536208e-01f, -1.34897590e-01f, -6.21733032e-02f, -7.13352412e-02f, -1.01752421e-02f,
  4.90328372e-02f, 1.05599850e-01f, 3.17421667e-02f, 1.03117973e-01f, 1.63951069e-01f, -5.56720681e-02f, -2.14562891e-03f, -2.54460201e-02f, 1.62100475e-02f, 1.23174131e-01f,
  -1.01900682e-01f, -1.57454554e-02f, -2.51929499e-02f, 3.29245217e-02f, 1.06256172e-01f, 4.09288332e-03f, -3.08952648e-02f, -7.55781904e-02f, 6.17432669e-02f, -5.37400357e-02f,
  3.75008918e-02f, -3.31430212e-02f, 3.86606948e-03f, -5.34753576e-02f, -1.33633256e-01f, -3.57667245e-02f, 1.44172266e-01f, -7.17938319e-02f, -5.13543710e-02f, 4.24659140e-02f,
  -3.33901882e-01f, -1.23899788e-01f, 1.54795974e-01f, -4.37541604e-02f, -4.82218852e-03f, -7.57488832e-02f, 7.53902942e-02f, -1.01010174e-01f, -2.38059498e-02f, -1.00151762e-01f,
  -2.82855649e-02f, -8.82210135e-02f, -1.11570761e-01f, -2.60967389e-02f, -7.68307671e-02f, -6.58347756e-02f, -9.10139531e-02f, -2.75383070e-02f, -1.08587377e-01f, -6.92958534e-02f,
  -1.43780172e-01f, -2.26735130e-01f, -1.66765347e-01f, -1.54699907e-01f, -3.17097418e-02f, -8.33524540e-02f, -1.70206487e-01f, -8.02952275e-02f, -2.23833367e-01f, -2.19734430e-01f,
  -3.25291842e-01f, -3.81366640e-01f, -3.48025501e-01f, -6.45239115e-01f, -1.91289246e-01f, 2.50812322e-01f, 5.52722991e-01f, 1.02611892e-01f, -3.50863069e-01f, -2.56259181e-02f,
  -9.75077376e-02f, -2.44271845e-01f, -5.06021321e-01f, -1.56759977e-01f, 1.47171557e-01f, 3.34003210e-01f, 3.25714611e-02f, 5.17313145e-02f, 2.35273391e-01f, 2.57441193e-01f,
  -3.63361575e-02f, -3.22862744e-01f, -2.69224644e-01f, -2.46065244e-01f, -4.26853061e-01f, -1.89114660e-01f, -4.57241327e-01f, -2.78001964e-01f, 1.87940262e-02f, -3.98811311e-01f,
  7.99293667e-02f, -3.83394569e-01f, 8.02357569e-02f, -1.43212691e-01f, -8.25104024e-03f, -1.28155239e-02f, 7.22877607e-02f, -1.46905392e-01f, -7.66343549e-02f, -1.39802396e-01f,
  -1.30642369e-01f, 3.83037701e-02f, -1.92575365e-01f, -1.66096389e-01f, -9.13821757e-02f, -5.17275520e-02f, -7.73749426e-02f, -7.12562799e-02f, -1.20845367e-03f, 4.72849831e-02f,
  -2.52225101e-02f, 4.66887131e-02f, 1.75134018e-02f, 1.75666094e-01f, 6.83808327e-02f, 1.86672900e-02f, 5.76287843e-02f, 1.69958547e-02f, 4.11255658e-02f, -3.85352895e-02f,
  2.39655808e-01f, 3.90228890e-02f, -2.68720482e-02f, -6.80537373e-02f, 1.12145513e-01f, 8.58170316e-02f, -3.97929363e-02f, -5.96793415e-03f, -1.78005756e-03f, -9.58950352e-03f,
  -5.51187992e-02f, 8.64087418e-02f, -8.93021002e-02f, -3.71381454e-02f, 2.10576523e-02f, 2.84412764e-02f, 1.05209323e-02f, 6.08387403e-02f, -9.43091884e-02f, 3.01065054e-02f,
  -1.46133397e-02f, 2.68672388e-02f, -1.78946313e-02f, 5.59322312e-02f, 1.67142078e-01f, -2.33866367e-02f, -9.32378992e-02f, 4.09017392e-02f, -1.16153397e-01f, 2.84547284e-02f,
  -2.10868135e-01f, 2.62450669e-02f, 1.87465176e-02f, 6.32116124e-02f, -5.68207130e-02f, 5.24986014e-02f, -8.01607892e-02f, -4.54751998e-02f, -1.30785868e-01f, -3.25821675e-02f,
  -1.48534492e-01f, -1.07874222e-01f, -8.82815793e-02f, -8.30628276e-02f, 3.12236547e-02f, 7.14386478e-02f, 8.04364011e-02f, -1.01396099e-01f, 5.70749529e-02f, -2.73665730e-02f,
  -3.71997920e-03f, 1.90566033e-01f, 2.93542027e-01f, 1.14573352e-01f, 8.80278796e-02f, 1.89371318e-01f, 9.26744863e-02f, 1.75431743e-01f, 3.25507611e-01f, 2.84979016e-01f,
  -2.11910993e-01f, 1.39080510e-01f, -7.06000701e-02f, 1.34463549e-01f, -1.23091988e-01f, -3.14758569e-01f, -2.60103494e-01f, -1.90995187e-01f, 1.28421456e-01f, 2.35920236e-01f,
  2.00067148e-01f, -7.64685497e-02f, 1.08351797e-01f, -7.37731084e-02f, -3.19809735e-01f, 9.46084857e-02f, -1.23843871e-01f, -3.12561512e-01f, -3.97844911e-01f, -4.60569650e-01f,
  -2.33046770e-01f, -7.15800300e-02f, -4.36758511e-02f, -9.69211459e-02f, 2.11010769e-01f, -4.81442697e-02f, 2.46845886e-01f, -9.53923538e-02f, -3.21953088e-01f, 1.15136698e-01f,
  2.90924877e-01f, -2.89763778e-01f, -2.70438701e-01f, -1.66537881e-01f, 5.83795346e-02f, 1.18310954e-02f, 2.85586398e-02f, 1.09390713e-01f, 1.06342211e-01f, 2.29589626e-01f,
  1.18135042e-01f, 5.67848422e-02f, -1.59108620e-02f, -1.57716796e-02f, 1.35279843e-04f, 1.04200564e-01f, 7.19701359e-03f, -1.63382590e-01f, 7.82484114e-02f, -2.16563698e-02f,
  1.14126308e-02f, -9.90836415e-03f, 7.55867064e-02f, -6.75128959e-03f, -1.29492968e-01f, -2.06515029e-01f, 7.28853093e-03f, -1.20315246e-01f, -1.25121489e-01f, 1.54930547e-01f,
  -3.28509398e-02f, 1.63884088e-01f, -4.31740172e-02f, 1.21655107e-01f, 2.21391961e-01f, 1.64423540e-01f, 2.09813341e-01f, 2.10912988e-01f, -5.98458713e-03f, 1.14036568e-01f,
  2.36084759e-01f, 1.55650705e-01f, 3.21616456e-02f, 1.28515705e-01f, 1.17490746e-01f, 5.22563122e-02f, 7.83667667e-04f, 5.20209596e-02f, 1.34355485e-01f, 2.21290544e-01f,
  1.12405531e-01f, 5.07020056e-02f, 2.10574523e-01f, 8.38197581e-03f, 1.37745272e-02f, 1.23895228e-01f, -3.68228070e-02f, -5.29843103e-03f, 4.66405489e-02f, 2.11448483e-02f,
  3.33335817e-01f, -3.65546405e-01f, 1.49435550e-01f, -5.55581674e-02f, -4.21265401e-02f, 2.74291597e-02f, 6.15568385e-02f, 2.54969243e-02f, 1.78615898e-01f, 1.59935877e-01f,
  3.67958285e-02f, 1.59809172e-01f, 1.58915535e-01f, 4.39707637e-02f, 5.41787185e-02f, 1.19205877e-01f, 1.05464846e-01f, 2.92107556e-03f, -1.28296867e-01f, 5.89040779e-02f,
  1.05585769e-01f, -2.82104444e-02f, 1.15687177e-01f, 1.20518997e-01f, -8.69649202e-02f, -1.89985946e-01f, 6.87214881e-02f, -3.76665853e-02f, -6.19518198e-02f, 3.02359909e-01f,
  -3.29977989e-01f, 2.31629033e-02f, -1.33232668e-01f, -7.86052570e-02f, 1.07588740e-02f, -2.20086545e-01f, -2.88370520e-01f, -3.56658190e-01f, -1.03583969e-01f, -6.87833689e-03f,
  1.44453853e-01f, 2.61416465e-01f, -7.92182609e-02f, -1.81276381e-01f, -5.54722250e-01f, -3.77335489e-01f, -4.07993346e-01f, -4.74522352e-01f, -3.77454102e-01f, -5.95915653e-02f,
  8.34554285e-02f, -1.42763898e-01f, -1.96723878e-01f, -2.06619889e-01f, 4.19663757e-01f, 2.03442678e-01f, -1.05158077e-03f, 2.59612203e-02f, 3.77065735e-03f, 1.50868356e-01f,
  2.25893185e-01f, -1.02041708e-03f, -2.36533687e-01f, -1.02951616e-01f, 5.27817607e-02f, -3.48457098e-02f, -7.02834725e-02f, -1.20112367e-01f, -1.36369497e-01f, -9.75681394e-02f,
  4.79977131e-02f, -3.28662507e-02f, 6.57340437e-02f, 1.20412424e-01f, -1.71084423e-02f, 2.05401704e-03f, -2.57471260e-02f, -1.34387881e-01f, -1.49405256e-01f, 1.08732760e-01f,
  1.13296330e-01f, -1.32358745e-01f, -1.95045531e-01f, -8.58280584e-02f, -9.83762518e-02f, -2.89712306e-02f, 6.79459795e-02f, 1.61600113e-02f, -1.90805733e-01f, -2.64544412e-02f,
  8.18880126e-02f, 4.64442000e-02f, 5.23844361e-02f, 8.29043761e-02f, -5.87287135e-02f, 8.74174293e-03f, 4.94355708e-02f, -2.68975105e-02f, 1.03842001e-02f, -1.37602433e-03f,
  -1.83424819e-02f, 7.90406689e-02f, 6.28154501e-02f, 3.87772135e-02f, -3.13855931e-02f, -4.16877754e-02f, -4.10191044e-02f, -1.96718704e-02f, -4.43438552e-02f, -8.82708132e-02f,
  -1.19947240e-01f, -8.64408836e-02f, 1.00810528e-01f, 1.48126986e-02f, 5.59502803e-02f, -7.77683035e-02f, -3.39718163e-02f, 4.01960723e-02f, 2.43549421e-03f, -6.24878285e-03f,
  1.02412499e-01f, -2.60590315e-01f, 1.01948395e-01f, -1.57404423e-01f, 5.06630400e-03f, 2.72042919e-02f, 8.71039331e-02f, -7.52185062e-02f, -2.59737950e-02f, 5.00047505e-02f,
  -9.81503502e-02f, 9.11706463e-02f, -3.09565780e-03f, 9.66147408e-02f, 1.37822609e-02f, -9.15431008e-02f, -4.23841253e-02f, -2.49924045e-02f, -6.04644828e-02f, 1.88508168e-01f,
  -7.66257271e-02f, -2.19826341e-01f, -2.09206924e-01f, 1.37293367e-02f, -7.90559351e-02f, -9.14960261e-03f, 9.23437253e-03f, 9.70262736e-02f, -2.23507628e-01f, -1.91550422e-02f,
  -4.60221678e-01f, 3.76500338e-01f, 1.37219518e-01f, -3.01944017e-01f, -2.98578113e-01f, -2.40705535e-01f, 1.26632437e-01f, -9.04228985e-02f, -2.00218707e-01f, 2.02829897e-01f,
  1.05304852e-01f, -7.91528448e-02f, 1.13423161e-01f, 2.36467943e-02f, 2.92690564e-02f, 4.73447800e-01f, 2.77262807e-01f, -1.03457280e-01f, -2.54057050e-01f, -1.83441937e-01f,
  6.82310611e-02f, -1.93554774e-01f, -2.65732855e-01f, -1.84490830e-01f, 1.83122888e-01f, -7.99995884e-02f, 1.51854560e-01f, -1.01078257e-01f, 5.08000813e-02f, 3.72418553e-01f,
  3.91179621e-01f, -2.02284202e-01f, -1.59474055e-03f, -4.19086158e-01f, -1.84826657e-01f, 1.78510528e-02f, 5.94657622e-02f, -9.75112543e-02f, 1.99064761e-02f, -3.22712772e-02f,
  -1.57266617e-01f, -6.17203303e-02f, 6.81589991e-02f, 1.93028837e-01f, -8.04206207e-02f, -1.06393941e-01f, 6.18187152e-03f, -1.30688295e-01f, -2.23399833e-01f, 6.43804371e-02f,
  2.22119570e-01f, -8.17296058e-02f, -2.04986706e-01f, 2.08582636e-02f, 8.43873546e-02f, -2.50750005e-01f, -1.95869487e-02f, -2.43568778e-01f, -2.35182405e-01f, 1.00185111e-01f,
  -1.37926444e-01f, -6.47365004e-02f, -4.87296171e-02f, -5.62866367e-02f, 1.50636524e-01f, -1.11671276e-02f, -1.11685656e-02f, 1.26692146e-01f, -3.11357547e-02f, -2.78670955e-02f,
  -1.33324951e-01f, -8.91711041e-02f, 4.96005341e-02f, 2.20829546e-02f, 7.77668357e-02f, -6.43440932e-02f, 6.92680553e-02f, 2.15600342e-01f, -2.67939102e-02f, 8.60188678e-02f,
  -5.36550581e-02f, 4.55553532e-02f, 8.48626252e-03f, 1.54754266e-01f, 1.28082186e-01f, -7.82633126e-02f, 2.18301173e-02f, 3.77712660e-02f, -3.84626985e-02f, 3.74923348e-02f,
  4.22483794e-02f, -1.70505479e-01f, 1.98603407e-01f, 1.19921535e-01f, 1.40611483e-02f, -5.64922355e-02f, 2.22540237e-02f, -1.35014519e-01f, 8.12283009e-02f, -1.56777769e-01f,
  -1.37053594e-01f, 1.22326955e-01f, 8.38638097e-02f, 1.77709982e-02f, 1.05676902e-02f, -2.01366603e-01f, -2.14354545e-02f, -1.45366132e-01f, 2.34725922e-02f, 1.16312236e-01f,
  1.59503236e-01f, -1.27014086e-01f, 3.93386558e-02f, 1.58631682e-01f, -4.53991927e-02f, -1.28642425e-01f, 1.41363204e-01f, -4.13223356e-02f, -1.05684742e-01f, 2.47015014e-01f,
  -7.24590778e-01f, -4.63559091e-01f, 2.27791667e-01f, -2.34191939e-01f, 2.40916952e-01f, 3.51316541e-01f, 3.05717409e-01f, 8.85936692e-02f, -1.32455468e-01f, -1.38839841e-01f,
  -3.94354254e-01f, -4.56128627e-01f, -3.35361004e-01f, -1.46532297e-01f, -2.98863407e-02f, 2.88454682e-01f, 3.13025624e-01f, 9.19745341e-02f, 1.92946628e-01f, 2.20559254e-01f,
  3.01259104e-02f, -1.70512855e-01f, -2.51120448e-01f, -2.42672190e-01f, -1.29021332e-01f, -1.72827765e-01f, -1.00808643e-01f, -3.67765799e-02f, 5.78073300e-02f, -8.43741745e-03f,
  2.43289992e-01f, -3.71269941e-01f, 5.45097776e-02f, -2.29727924e-01f, -1.87710524e-01f, -1.59759417e-01f, 1.02875324e-03f, -9.44778398e-02f, -1.22732520e-01f, -4.48396429e-02f,
  -1.27492577e-01f, -6.21691011e-02f, -3.33289020e-02f, -1.20357700e-01f, -7.08053187e-02f, 3.18522565e-02f, -2.42107451e-01f, -2.30685472e-01f, -1.98624581e-01f, 1.56629514e-02f,
  -7.81733319e-02f, 3.15669850e-02f, -1.99300665e-02f, -9.41481814e-02f, -1.38614625e-01f, -1.06196530e-01f, -7.84584209e-02f, -1.40796706e-01f, 3.47025896e-04f, -6.91754296e-02f,
  2.53827035e-01f, -7.43349418e-02f, -5.02158478e-02f, -3.60447653e-02f, -1.43749669e-01f, 5.39047495e-02f, -7.93933496e-02f, -9.69377533e-02f, -1.38324574e-01f, -1.98054332e-02f,
  -8.99840072e-02f, 6.56935666e-03f, -6.70296922e-02f, 4.37150784e-02f, -1.25762910e-01f, -1.65149927e-01f, -7.29399174e-02f, -1.45607740e-01f, -3.56974676e-02f, -1.01678394e-01f,
  -3.82855237e-02f, -7.77142271e-02f, 1.01343347e-02f, -2.07593874e-03f, -9.76842865e-02f, 2.31891125e-03f, -5.42717390e-02f, -1.57116592e-01f, -1.95617843e-02f, -1.01010047e-01f,
  -2.45657153e-02f, 2.03562796e-01f, 1.36450723e-01f, -1.73187740e-02f, 6.56436235e-02f, -1.42326534e-01f, -1.67322099e-01f, 9.68729630e-02f, 8.03186186e-03f, 5.74044399e-02f,
  8.29671472e-02f, -7.25116134e-02f, 2.56838035e-02f, 1.60039831e-02f, 1.07681148e-01f, 1.12418532e-01f, 8.87248293e-03f, 6.46082610e-02f, 1.31734446e-01f, 6.64625913e-02f,
  1.65637434e-02f, 1.68151557e-01f, 1.67674288e-01f, 3.72211188e-02f, 1.18939817e-01f, 2.56293476e-01f, 1.75825775e-01f, 2.30664939e-01f, 2.02530667e-01f, 1.92200631e-01f,
  -3.17601919e-01f, -4.48014438e-01f, -4.71092135e-01f, 1.66210949e-01f, 3.16956878e-01f, -4.78617549e-02f, -2.76432902e-01f, 3.94737488e-03f, 1.00799978e-01f, -2.26249114e-01f,
  6.65988848e-02f, 2.54868269e-01f, 4.10994440e-02f, 2.38086864e-01f, 4.59396467e-02f, -2.25788221e-01f, 2.53655482e-02f, 5.99584207e-02f, 2.24850208e-01f, 3.05295169e-01f,
  2.79071838e-01f, 6.62206560e-02f, -4.88086045e-02f, 9.63566676e-02f, 8.13082326e-03f, 1.77867651e-01f, -2.00433955e-01f, -4.63335868e-03f, -2.23377347e-03f, -8.92542452e-02f,
  -3.51005822e-01f, -3.85037661e-01f, 2.15099543e-01f, 1.39189705e-01f, 6.94560558e-02f, -7.18590692e-02f, -1.27081499e-01f, -1.38176158e-01f, -8.19456726e-02f, -1.26019329e-01f,
  4.19413187e-02f, -9.45482180e-02f, 5.73426560e-02f, -5.22357933e-02f, -5.51916547e-02f, -6.59664050e-02f, -5.29472008e-02f, -4.91842404e-02f, -6.79451153e-02f, -1.90783024e-01f,
  3.51230413e-01f, 6.22444414e-02f, -1.92837924e-01f, -1.50054395e-01f, -1.11263894e-01f, 4.08579074e-02f, -1.98554248e-01f, -1.30631849e-01f, -2.24032551e-01f, -3.00139397e-01f,
  -1.29949097e-02f, -4.31347154e-02f, -9.66680795e-02f, -9.41485390e-02f, 1.23773955e-01f, -9.68117529e-05f, -3.45327216e-03f, 1.88317657e-01f, 1.05265908e-01f, -1.02193035e-01f,
  -9.47721023e-03f, -9.34265852e-02f, 7.77773038e-02f, -5.86509295e-02f, 1.48410499e-01f, -5.39931096e-02f, 1.02813970e-02f, 4.56194766e-02f, 5.94251603e-02f, 1.02552893e-02f,
  1.92651898e-02f, -2.66404115e-02f, -3.06265224e-02f, 1.53763533e-01f, -6.20827414e-02f, -3.97614725e-02f, -5.97350448e-02f, -5.08266538e-02f, 5.78756304e-03f, -1.86696038e-01f,
  -1.30732119e-01f, 3.33563723e-02f, -1.84245884e-01f, 8.76679569e-02f, 8.28608349e-02f, 1.29668759e-02f, 5.93965463e-02f, 9.49622244e-02f, -7.71685094e-02f, -5.90037815e-02f,
  -5.71688451e-02f, -1.78889170e-01f, -8.46843943e-02f, 3.75659391e-02f, 4.18360122e-02f, -1.04133047e-01f, 5.79776661e-03f, -2.55851392e-02f, -1.07334424e-02f, -1.74907390e-02f,
  1.74080227e-02f, -2.36409958e-02f, -2.02387989e-01f, -1.71092138e-01f, -4.59398814e-02f, 3.99106331e-02f, -2.22509876e-01f, -1.95771128e-01f, -3.08109581e-01f, -3.88051659e-01f,
  1.78800032e-01f, -7.89827481e-02f, -7.23370373e-01f, -2.87691709e-02f, -2.87884116e-01f, -2.26934716e-01f, 1.92825198e-01f, 1.79669410e-01f, 7.74709731e-02f, -8.81701801e-03f,
  -2.71536440e-01f, -2.81149119e-01f, -3.82602513e-01f, -3.06916177e-01f, 2.19089771e-03f, -5.45215458e-02f, -1.43457130e-01f, -2.84375936e-01f, -2.45517731e-01f, 2.23054454e-01f,
  1.18985370e-01f, 1.64143816e-02f, -1.30330339e-01f, -1.48582369e-01f, -1.69714943e-01f, -3.64979953e-01f, -4.30097103e-01f, -3.42186838e-01f, -2.20693052e-01f, -4.34857368e-01f,
  -4.53132510e-01f, -2.61037201e-01f, -4.59106086e-04f, 7.66725466e-02f, -5.98892309e-02f, 1.86774373e-01f, 8.24332312e-02f, -5.24617620e-02f, 9.79284048e-02f, 1.49202337e-02f,
  -1.33519679e-01f, -5.89489974e-02f, -4.56287712e-02f, -1.75865069e-01f, -1.52727649e-01f, 1.69189759e-02f, 1.38981882e-02f, -1.56048939e-01f, -9.47184563e-02f, -1.84050947e-02f,
  1.71989426e-02f, -6.14957288e-02f, -2.95854926e-01f, 3.46951708e-02f, -1.17288977e-01f, -1.75548434e-01f, -8.56759921e-02f, -7.61617124e-02f, -1.29182935e-01f, 8.97359997e-02f,
  2.24354491e-01f, 8.04813579e-02f, 6.57805279e-02f, 4.35503945e-02f, 2.29083002e-01f, 7.79978232e-03f, 8.28641560e-03f, 1.40625732e-02f, 2.31832694e-02f, 6.38477057e-02f,
  -2.20308900e-02f, 7.10795913e-03f, 6.67159781e-02f, 9.46221277e-02f, -1.95887499e-02f, -1.21295072e-01f, 1.00244537e-01f, 1.23002037e-01f, 7.51404911e-02f, 4.31678444e-02f,
  -7.40590096e-02f, -5.42116351e-02f, -1.11019291e-01f, 7.04113394e-02f, -6.88803792e-02f, -2.92320587e-02f, -5.18415086e-02f, -6.22089487e-03f, -3.36774960e-02f, 7.58681148e-02f,
  -1.44891948e-01f, -1.27350822e-01f, -1.42411957e-03f, 9.85976532e-02f, -1.07859708e-01f, -1.29927490e-02f, -1.07325152e-01f, 1.48595825e-01f, -1.54537335e-02f, 8.32716282e-03f,
  -6.44715056e-02f, 4.27233577e-02f, -1.04797721e-01f, 4.64102030e-02f, -1.13268144e-01f, -1.97900441e-02f, 1.49412453e-01f, -1.46769136e-01f, 5.39337434e-02f, 8.39024782e-02f,
  1.72595918e-01f, 2.65395522e-01f, 2.59899527e-01f, 9.09498706e-02f, 9.83463451e-02f, -2.57957727e-02f, -2.13141702e-02f, 2.91834809e-02f, 1.43686399e-01f, 4.52914685e-01f,
  4.72357832e-02f, -1.27888039e-01f, -5.64367831e-01f, -1.26866996e-01f, 8.00584480e-02f, -6.33993894e-02f, -3.11062813e-01f, -2.33142391e-01f, 1.37886619e-02f, -3.78658558e-04f,
  2.84832180e-01f, 1.73863947e-01f, -1.81478739e-01f, 8.19245819e-04f, -1.61764771e-01f, -2.13392779e-01f, -1.52963474e-01f, -1.87777162e-01f, 1.38806507e-01f, 4.47033256e-01f,
  4.57997203e-01f, 2.60150582e-01f, 2.63993621e-01f, -7.12830154e-03f, -6.56482577e-02f, 7.18955621e-02f, -1.34272084e-01f, 6.72364980e-02f, 7.34673589e-02f, -1.40051201e-01f,
  3.32800709e-02f, -2.98472643e-01f, 8.47772211e-02f, 2.79139072e-01f, 2.41409346e-01f, -1.50229171e-01f, -1.57172710e-01f, -1.29405677e-01f, -1.02426589e-01f, -1.89238057e-01f,
  2.12204069e-01f, 4.57787029e-02f, -9.81186256e-02f, 6.34865314e-02f, -4.23396751e-02f, -1.72380880e-01f, -2.45850369e-01f, -3.50485235e-01f, -3.84537190e-01f, -8.24128091e-02f,
  1.57217249e-01f, 1.81762487e-01f, -4.38995808e-01f, -3.16707522e-01f, -4.67503190e-01f, -1.03537388e-01f, -2.85619825e-01f, -2.27461755e-01f, -3.99704039e-01f, -3.14278185e-01f,
  1.10411212e-01f, 1.20546937e-01f, 1.99309550e-02f, -6.46495000e-02f, 1.34907439e-01f, -7.57856518e-02f, 3.95213217e-02f, 1.91460792e-02f, 8.73269979e-03f, 1.51162865e-02f,
  -3.96001153e-02f, 1.95256330e-03f, -5.06744571e-02f, -1.64211576e-03f, -2.53382754e-02f, -8.48677158e-02f, 8.02247524e-02f, -5.68043292e-02f, 5.73112667e-02f, 6.52638897e-02f,
  2.80820169e-02f, -6.99831098e-02f, 8.63490552e-02f, -3.41866650e-02f, -5.07492758e-03f, -1.06991127e-01f, 6.07074983e-02f, -1.11862645e-03f, 4.26463000e-02f, 8.75399448e-03f,
  2.19136581e-01f, 3.28278132e-02f, -9.99867246e-02f, -6.07625805e-02f, 2.50352472e-02f, 6.13803230e-02f, 6.95344731e-02f, 1.00502692e-01f, -1.27629355e-01f, -7.62394443e-02f,
  -6.98289368e-03f, -1.21277355e-01f, -1.01076908e-01f, -7.63151348e-02f, 7.21468106e-02f, -6.14244193e-02f, 4.00130190e-02f, 1.08500337e-02f, -1.07135691e-01f, 5.69433859e-03f,
  -6.02533109e-02f, 5.57431951e-02f, -6.59780353e-02f, -2.54714996e-01f, 2.54599247e-02f, 6.56275675e-02f, -1.62062332e-01f, -6.82063326e-02f, -1.78884953e-01f, 1.23873266e-04f,
  -4.51714247e-01f, -2.53495485e-01f, -3.55249763e-01f, -3.05101007e-01f, 1.70888796e-01f, 1.20413795e-01f, 1.15028895e-01f, -5.71384607e-03f, -1.46927431e-01f, -2.03853980e-01f,
  1.40901685e-01f, 2.01243237e-01f, -1.02626666e-01f, 1.61654904e-01f, 1.45653456e-01f, -1.32262543e-01f, -5.53813949e-02f, -1.10842660e-01f, 2.29698673e-01f, 4.08939511e-01f,
  2.31164664e-01f, -3.02673467e-02f, -1.21910825e-01f, 6.82307482e-02f, -1.00186437e-01f, -1.73926167e-02f, -7.50397742e-02f, -5.08350506e-02f, 1.91201381e-02f, 1.57405641e-02f,
  -3.62243295e-01f, -3.98640901e-01f, 2.11683810e-02f, 1.02924630e-01f, 5.23611009e-02f, -2.81131297e-01f, -1.16967194e-01f, -3.60313319e-02f, 3.36518176e-02f, -1.47640690e-01f,
  1.38717040e-01f, 1.83310404e-01f, 5.72922379e-02f, -7.65711535e-03f, -1.09421730e-01f, -5.25439046e-02f, -2.19335288e-01f, -6.66714385e-02f, -2.65539557e-01f, -1.78106204e-02f,
  3.41181457e-01f, 8.05348828e-02f, -2.51515269e-01f, -1.19703472e-01f, -2.53184497e-01f, -6.33686632e-02f, -9.39308107e-02f, -1.64200813e-02f, -1.55055270e-01f, -2.23141506e-01f,
  6.75616339e-02f, 9.87060368e-02f, -8.67351070e-02f, -6.74294084e-02f, 7.24002123e-02f, -4.24414724e-02f, -1.78832039e-02f, 1.15063913e-01f, 5.55855175e-03f, 1.96764544e-02f,
  1.13006726e-01f, -2.05381885e-02f, -1.90780796e-02f, -1.84291285e-02f, 1.02387831e-01f, -5.78374825e-02f, -2.33804155e-02f, -6.39827177e-02f, 1.30162790e-01f, 1.46398349e-02f,
  4.12049405e-02f, -2.43887100e-02f, 2.43104640e-02f, 1.18222654e-01f, -7.54584819e-02f, 3.86551917e-02f, -1.05701759e-01f, 2.89466494e-04f, -1.96846258e-02f, -1.42489923e-02f,
  -2.95931399e-01f, 9.54621062e-02f, -3.15091699e-01f, 9.18108318e-03f, 1.14336633e-03f, 7.60205463e-02f, -5.28304800e-02f, 5.52090257e-02f, -4.52303514e-02f, -1.65603757e-01f,
  5.67049608e-02f, -6.48831129e-02f, -1.11618467e-01f, -4.89112213e-02f, -2.45834626e-02f, -1.33265570e-01f, -1.08663857e-01f, -1.29513323e-01f, -5.96447289e-02f, -8.20706710e-02f,
  -3.56970765e-02f, -1.24107778e-01f, -3.48631680e-01f, -2.92005837e-01f, -2.08647728e-01f, -2.19793439e-01f, -2.06814975e-01f, -1.10429138e-01f, -2.53902316e-01f, -4.14573222e-01f,
  1.10316314e-01f, -1.76754698e-01f, -2.62677640e-01f, 3.38585265e-02f, -2.70703554e-01f, -2.18201503e-01f, -3.08949262e-01f, -6.22457378e-02f, -1.32460073e-01f, -2.23500669e-01f,
  -8.17165822e-02f, 4.36749578e-01f, 3.51709455e-01f, 2.32083276e-01f, 3.43837798e-01f, -3.47274005e-01f, -2.78889209e-01f, 6.13886826e-02f, 2.48960465e-01f, 1.63310617e-01f,
  1.25734722e-02f, 1.17764622e-01f, 3.10381830e-01f, 1.30863369e-01f, -2.62065381e-01f, 2.59064827e-02f, -2.71987021e-01f, -2.45681643e-01f, -1.74130410e-01f, -4.16179538e-01f,
  1.46999300e-01f, -3.74510258e-01f, 5.85761070e-02f, -6.03401754e-03f, -2.78288294e-02f, 1.22573897e-01f, -5.98396249e-02f, -8.73343349e-02f, -5.39824665e-02f, -1.21317543e-01f,
  -2.96910033e-02f, -7.12711066e-02f, 7.22945333e-02f, 5.29293232e-02f, -5.55286184e-02f, 2.71108933e-02f, 2.07050256e-02f, -8.44991729e-02f, -1.47858178e-02f, -1.44699002e-02f,
  -1.27742723e-01f, -2.62616456e-01f, -2.30318177e-02f, -3.90438549e-02f, -6.19983952e-03f, 7.93319717e-02f, -1.01054266e-01f, -6.91275597e-02f, -1.04521647e-01f, -1.67788014e-01f,
  -3.54009755e-02f, 6.62238225e-02f, -8.14834684e-02f, 1.80513896e-02f, -2.29743347e-02f, -3.16110328e-02f, -5.27756438e-02f, -3.10776215e-02f, 7.14288233e-03f, 6.06793631e-03f,
  -4.31520678e-02f, -5.68748191e-02f, 8.27737600e-02f, -1.07672654e-01f, -5.71731627e-02f, -1.16579928e-01f, 3.14586423e-02f, 1.31854892e-01f, -5.08232452e-02f, -2.01600902e-02f,
  -1.51964501e-02f, -1.59832388e-02f, -6.50652424e-02f, -7.79651478e-03f, -1.05307154e-01f, 8.08765739e-02f, -5.33189997e-02f, 6.77942783e-02f, 1.04629308e-01f, -1.69063032e-01f,
  4.64947760e-01f, 4.30367738e-02f, -6.02554120e-02f, 4.91256006e-02f, -2.13865712e-01f, -2.16083378e-02f, -5.05748130e-02f, -8.76618028e-02f, -7.00416192e-02f, -1.36387506e-02f,
  -4.75674011e-02f, 8.28218758e-02f, 2.15714034e-02f, 7.20537677e-02f, 3.83917950e-02f, 2.89849285e-02f, 7.79061485e-03f, 3.92905027e-02f, -1.09545514e-01f, -5.36950566e-02f,
  -5.57528762e-03f, 7.17043728e-02f, 9.57962722e-02f, 1.30414411e-01f, 2.04861593e-02f, 3.98270823e-02f, 4.17561494e-02f, 7.26093501e-02f, 1.68282151e-01f, 2.00403333e-01f,
  3.64029914e-01f, -1.09116353e-01f, -5.54756403e-01f, -3.12185645e-01f, -3.48423690e-01f, -1.44670337e-01f, -4.00410406e-02f, 1.11918062e-01f, -5.00096641e-02f, -1.73436090e-01f,
  2.17994563e-02f, 1.31150439e-01f, 6.38932735e-02f, 6.20332621e-02f, 2.14405134e-01f, -1.39704660e-01f, -3.24298739e-01f, -1.64264500e-01f, 1.85462847e-01f, 2.32620254e-01f,
  2.08645742e-02f, -1.69824779e-01f, -4.94620167e-02f, -4.96327691e-03f, -3.49665552e-01f, -1.88379407e-01f, -5.15134394e-01f, -3.72324109e-01f, -1.41818792e-01f, -3.96102279e-01f,
  -2.41837472e-01f, -1.35187134e-01f, -3.83131281e-02f, 8.26623142e-02f, -2.05116376e-01f, 8.72285068e-02f, 4.62447293e-02f, -7.60387406e-02f, 1.79228522e-02f, -4.16851081e-02f,
  -1.59478799e-01f, -1.39104109e-02f, -2.48576012e-02f, -1.93493383e-04f, -1.56633139e-01f, -1.02233909e-01f, -1.86414063e-01f, -7.69116133e-02f, -1.27512351e-01f, -4.23732400e-02f,
  -4.82093543e-02f, 5.11391498e-02f, -1.33160830e-01f, 5.64532680e-03f, 1.27737615e-02f, -9.78810340e-02f, -2.09733203e-01f, -2.52073407e-02f, -6.43178355e-03f, -1.85502961e-01f,
  -3.74579281e-02f, -1.40851170e-01f, -2.40625087e-02f, -1.19709782e-01f, 1.11979365e-01f, -6.23528585e-02f, -9.35062915e-02f, 8.23555961e-02f, -1.05160114e-03f, -3.16877067e-02f,
  -4.82481578e-03f, -6.58276901e-02f, 1.14686252e-03f, 8.85447115e-03f, -8.32249131e-03f, -2.11156737e-02f, 9.83406976e-02f, -2.66199261e-02f, -2.00690534e-02f, -9.19929445e-02f,
  1.57016348e-02f, 8.30816850e-02f, -9.44453254e-02f, 1.19402096e-01f, -1.34345330e-02f, -5.48588522e-02f, 1.09695792e-01f, 1.44242123e-01f, -4.00817692e-02f, 2.53934488e-02f,
  7.59508740e-03f, 8.79914090e-02f, 4.17235633e-03f, 1.14793420e-01f, -5.21528423e-02f, -6.80590793e-02f, -1.04779966e-01f, 3.08397599e-02f, -1.83835492e-01f, 2.18323246e-02f,
  4.23198417e-02f, 1.20119005e-01f, -7.19341487e-02f, -1.00236118e-03f, -7.27953389e-02f, -2.90188864e-02f, 1.66029975e-01f, 5.26064746e-02f, -3.21324244e-02f, -5.69738336e-02f,
  2.42798626e-02f, 2.24405095e-01f, 2.64702588e-01f, 6.03909008e-02f, 4.17862162e-02f, 1.42379835e-01f, 1.66506600e-02f, 2.91159339e-02f, 1.34391651e-01f, 9.25635640e-03f,
  4.27504122e-01f, 3.67929429e-01f, 1.31908745e-01f, -1.15226498e-02f, -2.49194190e-01f, -2.01250598e-01f, -2.48058423e-01f, -1.15694277e-01f, -2.08496302e-01f, -3.31781022e-02f,
  -9.96220950e-03f, -5.57959005e-02f, -7.44059682e-02f, -6.64427578e-02f, 1.00252822e-01f, 9.46157053e-02f, 8.45914856e-02f, 3.05108070e-01f, 1.96552381e-01f, 8.87195542e-02f,
  8.16171542e-02f, 3.26388419e-01f, 4.21597183e-01f, 1.76464677e-01f, 1.40862167e-01f, -8.43779668e-02f, 1.09461792e-01f, 1.54973119e-01f, -7.43716508e-02f, 2.80656934e-01f,
  1.40835419e-01f, 1.74496621e-01f, -3.47661376e-01f, 2.92484369e-02f, 8.04349706e-02f, 1.52518496e-01f, 2.01080330e-02f, 2.26230115e-01f, 1.02467192e-02f, -8.67819134e-03f,
  1.19037978e-01f, 5.79109043e-02f, 1.47047281e-01f, 2.81637837e-03f, 7.87473321e-02f, -1.21623740e-01f, 2.10307553e-01f, 1.19717643e-01f, -7.71698654e-02f, 3.25065553e-02f,
  7.96514750e-02f, 3.00643612e-02f, -5.28202355e-02f, -1.82144299e-01f, -1.78698018e-01f, -3.16650346e-02f, -1.47532091e-01f, -4.95581776e-02f, -8.01642165e-02f, -2.28917837e-04f,
  -1.89941570e-01f, 5.66979870e-02f, -2.37212125e-02f, -6.33473247e-02f, -1.17359251e-01f, -1.07158244e-01f, -2.86128726e-02f, -5.00051007e-02f, -7.28133544e-02f, 6.20192103e-02f,
  -1.07662112e-01f, -1.38738334e-01f, -2.83419061e-02f, 2.47101113e-02f, -3.32194567e-02f, -3.68480012e-02f, 8.43008608e-02f, -7.62626529e-02f, -7.87694231e-02f, -9.91913751e-02f,
  -1.47629052e-01f, -4.62954380e-02f, 6.49815276e-02f, 7.17213796e-03f, -4.41766083e-02f, -5.89802675e-02f, -1.16308965e-01f, -1.22759929e-02f, 8.28945041e-02f, -2.64020227e-02f,
  8.80413875e-02f, -2.75090486e-01f, -1.35265931e-01f, 1.01648919e-01f, -1.97875891e-02f, -3.40533108e-02f, -1.34267628e-01f, -7.44570568e-02f, -1.73411474e-01f, 4.02455730e-03f,
  1.08206412e-02f, 1.83191877e-02f, 8.37903172e-02f, 1.12191759e-01f, -5.20842196e-03f, -6.76422566e-02f, 5.94007270e-03f, -7.27209225e-02f, -1.08039401e-01f, 9.48788524e-02f,
  -5.66861667e-02f, -2.32839152e-01f, -2.08220541e-01f, -3.76011193e-01f, -2.76212245e-01f, -3.50123733e-01f, -1.86614007e-01f, -2.26462126e-01f, -1.53511018e-01f, -8.75370726e-02f,
  1.33157466e-02f, 3.90313029e-01f, -2.75717638e-02f, -6.07582647e-03f, 4.30326052e-02f, -2.04078585e-01f, -4.42984812e-02f, -2.27012038e-01f, -1.82853028e-01f, 4.40815538e-02f,
  9.62535813e-02f, -2.13925112e-02f, -1.00755014e-01f, 1.48972850e-02f, -4.59898449e-02f, 4.20387946e-02f, 1.67160794e-01f, 1.93274170e-01f, 8.80993158e-02f, 1.01704538e-01f,
  3.08952004e-01f, 1.77899852e-01f, 8.20763633e-02f, 6.57067597e-02f, 2.93060929e-01f, 1.03299238e-01f, -4.17603217e-02f, 1.65108591e-01f, 1.81241900e-01f, 3.54448855e-01f,
  3.45735669e-01f, -1.76942036e-01f, -3.27448308e-01f, 7.71680474e-02f, 1.00744843e-01f, -2.97781639e-02f, -2.50265555e-04f, -9.07451436e-02f, -7.20335054e-04f, 1.53928641e-02f,
  1.82594791e-01f, 1.20925315e-01f, 8.79650041e-02f, 1.30536616e-01f, -9.74563658e-02f, -5.96635491e-02f, -1.23251885e-01f, -1.26294822e-01f, -9.51639637e-02f, 2.67043244e-02f,
  5.17147541e-01f, 3.30155134e-01f, -9.30027738e-02f, -1.17170237e-01f, -8.53389949e-02f, 1.38749421e-01f, -1.04669839e-01f, 1.15339914e-02f, -2.33489752e-01f, 1.34681597e-01f,
  -8.64358321e-02f, 5.98007115e-03f, 5.36726601e-02f, 8.76824139e-04f, -8.04580972e-02f, 5.04084006e-02f, 1.47946566e-01f, 1.15303591e-01f, 1.02570944e-01f, 7.21539110e-02f,
  -8.39738399e-02f, -9.55862179e-02f, -1.30028322e-01f, 3.18421572e-02f, -5.34447506e-02f, 6.04838319e-02f, 1.58090085e-01f, -1.10825948e-01f, -7.95184076e-02f, -1.65906042e-01f,
  2.08003037e-02f, -3.47138345e-02f, -9.10255387e-02f, -4.46336195e-02f, -1.07894413e-01f, -6.70115203e-02f, -7.84503110e-03f, 8.51764679e-02f, -6.05821498e-02f, -5.19454526e-03f,
  -2.22311854e-01f, -4.22418237e-01f, 1.80030111e-02f, 8.30603242e-02f, 6.01270981e-02f, -3.45475553e-03f, -9.14632380e-02f, 6.12531751e-02f, 1.18985726e-02f, -2.33660582e-02f,
  9.68298316e-02f, 3.45698893e-02f, -8.56769979e-02f, -1.39787178e-02f, -1.45475045e-01f, -1.83158442e-01f, -1.71584485e-04f, 3.92450728e-02f, -1.39950022e-01f, -1.41475620e-02f,
  8.41835048e-03f, -1.20003097e-01f, -1.01182677e-01f, -1.78192869e-01f, -2.91460957e-02f, -2.30753899e-01f, -1.98384196e-01f, -7.76547864e-02f, -2.58058667e-01f, -7.52461553e-02f,
  -4.19988841e-01f, -8.44718963e-02f, 2.75389314e-01f, -2.44189456e-01f, -6.12516627e-02f, -9.98864546e-02f, -2.09199131e-01f, -7.17478469e-02f, 1.49354994e-01f, 7.45118856e-02f,
  1.42284304e-01f, -7.35829293e-04f, -5.70882782e-02f, -1.13678843e-01f, -3.60552698e-01f, -8.90863389e-02f, -1.67406350e-01f, -2.23697186e-01f, -2.14065731e-01f, -2.78098553e-01f,
  -1.89117163e-01f, -1.68825835e-01f, -2.21618891e-01f, -1.57077849e-01f, -8.85529891e-02f, -1.44292504e-01f, 6.97626248e-02f, -1.22839756e-01f, -6.75312802e-02f, -8.35208669e-02f,
  1.16923295e-01f, 4.21748683e-02f, 3.21085192e-02f, -5.31078987e-02f, 7.71856233e-02f, -1.05260320e-01f, 2.25149039e-02f, 1.33767068e-01f, -3.93220596e-02f, 3.11556086e-02f,
  5.21738529e-02f, -4.29135375e-02f, -2.08625346e-02f, 9.91763026e-02f, -8.26269537e-02f, -5.54578453e-02f, 6.18794374e-03f, -1.41724413e-02f, -5.89330681e-02f, 1.45871326e-01f,
  1.31731052e-02f, -2.07851514e-01f, -2.46148318e-01f, -1.64667442e-01f, 1.59861267e-01f, -7.18820840e-02f, -1.55805796e-02f, -1.82771906e-01f, -2.45100170e-01f, -3.00693303e-01f,
  7.85507783e-02f, 1.10654466e-01f, 4.00763266e-02f, -2.19284371e-02f, -1.93322059e-02f, 1.46441802e-01f, -1.25010768e-02f, -3.52248549e-02f, -8.53106901e-02f, -8.33871365e-02f,
  1.37311369e-01f, 1.22717917e-01f, -1.81952547e-02f, -1.14213470e-02f, -1.29192233e-01f, -8.07732046e-02f, -3.64078730e-02f, -1.35070384e-02f, -1.53037474e-01f, -4.06914316e-02f,
  -8.82750526e-02f, -7.83181489e-02f, 9.53835845e-02f, -1.04884125e-01f, 3.02177314e-02f, -1.69620700e-02f, 1.98876828e-01f, -1.29460115e-02f, -2.69277138e-04f, 6.90879077e-02f,
  -8.65261182e-02f, 2.32144333e-02f, -6.56698123e-02f, -5.87854236e-02f, -1.80385530e-03f, 1.65860951e-01f, 2.67110821e-02f, 2.72823330e-02f, 4.10520062e-02f, -1.11909159e-01f,
  2.09771600e-02f, 6.02940470e-03f, -5.38742766e-02f, -3.84336933e-02f, -2.20960975e-01f, 4.74471832e-03f, -5.10590225e-02f, -1.29095033e-01f, -1.36625826e-01f, 1.91325352e-01f,
  -1.20288759e-01f, -2.28917137e-01f, -3.57761621e-01f, -1.91998363e-01f, -1.76358059e-01f, -2.31252804e-01f, -3.46777409e-01f, -2.71192104e-01f, -3.53973001e-01f, -3.22080851e-01f,
  5.83828799e-02f, -9.23731923e-02f, -1.36307823e-02f, 2.38733977e-01f, 2.23500296e-01f, 3.08520943e-02f, -2.63114311e-02f, -1.73229948e-01f, -1.37161678e-02f, 1.67499006e-01f,
  1.56507149e-01f, 2.54668295e-01f, 1.86581761e-01f, 6.99808374e-02f, -6.75058663e-02f, -1.80763930e-01f, -9.57572460e-02f, 3.39080230e-03f, 4.94614653e-02f, 1.31712019e-01f,
  2.37220794e-01f, 1.31691039e-01f, -3.57696228e-02f, -1.90883428e-02f, 1.36622638e-01f, 2.86431104e-01f, -1.19153038e-02f, 3.04928068e-02f, 3.36208120e-02f, 7.80939609e-02f,
  3.34379673e-01f, -2.05057904e-01f, 9.57855731e-02f, -5.29584698e-02f, 1.23197928e-01f, -2.46984780e-01f, 9.63080116e-03f, -1.71729997e-01f, -7.71178454e-02f, -1.42548665e-01f,
  2.84537990e-02f, -1.12352995e-02f, -2.41322089e-02f, -6.68417215e-02f, -9.42569822e-02f, -7.58817196e-02f, -2.66588211e-01f, -2.17780307e-01f, -1.81709096e-01f, -4.67547663e-02f,
  1.33352680e-02f, 3.41803879e-02f, 7.26225227e-02f, -7.07652867e-02f, -1.94344401e-01f, 8.88937563e-02f, -8.60278122e-03f, -1.39516536e-02f, -7.97542706e-02f, -1.59255072e-01f,
  4.66440879e-02f, 1.37885183e-01f, 1.41280636e-01f, -2.75022928e-02f, -1.03532694e-01f, -8.78159925e-02f, -7.62520283e-02f, -1.49585083e-02f, 7.95490015e-03f, 1.23906709e-01f,
  9.27162915e-02f, -6.60052896e-02f, -3.36009040e-02f, 1.50961757e-01f, 1.65242985e-01f, 2.19096288e-01f, 1.69947505e-01f, 6.61515445e-02f, 8.73576701e-02f, 1.19030118e-01f,
  3.39662321e-02f, 7.66584203e-02f, 8.61342847e-02f, -2.15127151e-02f, -2.30714642e-02f, 9.32283327e-02f, 4.90738750e-02f, 1.73816890e-01f, 1.52001828e-01f, 1.08922951e-01f,
  7.77128935e-02f, -4.73265462e-02f, 2.62581222e-02f, -7.67000839e-02f, 5.65165244e-02f, -1.21898964e-01f, 8.12895223e-03f, 9.00311396e-03f, -1.60000902e-02f, -7.69772893e-03f,
  4.63468134e-02f, 8.04595575e-02f, -5.02053015e-02f, -1.04212239e-01f, 6.86652809e-02f, 5.86814024e-02f, -1.83517800e-03f, -6.88402206e-02f, -1.14220314e-01f, 6.75574020e-02f,
  4.58085164e-02f, -6.86243027e-02f, 5.69576249e-02f, 4.54116911e-02f, -7.50900283e-02f, 1.07554123e-01f, 3.39920260e-02f, -4.58937548e-02f, -8.63281488e-02f, -1.38811534e-03f,
  3.52020234e-01f, 2.22223122e-02f, -2.31174186e-01f, 2.78188080e-01f, -2.69340843e-01f, -5.21208346e-01f, -6.45801842e-01f, -1.35404393e-01f, 2.05408871e-01f, 3.11423894e-02f,
  2.60372702e-02f, -1.66067407e-02f, -1.15145981e-01f, -1.75385952e-01f, -4.07863200e-01f, -3.18780005e-01f, -1.23427525e-01f, -2.10217014e-01f, -2.03681931e-01f, -5.07425554e-02f,
  -3.46490219e-02f, 1.20596334e-01f, 9.09683779e-02f, 2.09866032e-01f, 5.18332481e-01f, 1.77166879e-01f, 2.03594252e-01f, 3.01784903e-01f, -2.02919431e-02f, 3.76696169e-01f,
  2.55205274e-01f, 3.43257397e-01f, -2.22132921e-01f, 1.40848979e-01f, -7.23321922e-03f, 5.75918816e-02f, -1.72115326e-01f, 1.42420158e-01f, -1.12259492e-01f, -1.17313315e-03f,
  -3.09727830e-03f, 1.12710044e-01f, -1.12608597e-01f, 1.52088189e-02f, 1.01649821e-01f, -1.52416185e-01f, -8.90761241e-02f, -1.10911906e-01f, -2.28887528e-01f, 1.82433873e-02f,
  -2.69516289e-01f, 1.61439856e-03f, -1.33788332e-01f, -3.37744325e-01f, -5.64454906e-02f, -9.46928188e-02f, -5.73781282e-02f, 3.03213567e-01f, -9.48585421e-02f, 3.51849288e-01f,
  9.78533849e-02f, -1.86738353e-02f, -4.80701365e-02f, -4.54370864e-02f, -1.01123199e-01f, 9.37303230e-02f, 8.79818648e-02f, -1.03970982e-01f, -1.35166422e-02f, -5.36489747e-02f,
  -7.83619508e-02f, -3.06272898e-02f, 3.51588838e-02f, 5.85781485e-02f, 1.48101106e-01f, 3.70092951e-02f, -2.41319500e-02f, -1.74014978e-02f, -7.41646159e-03f, -2.49491027e-03f,
  -9.82853249e-02f, 1.76590513e-02f, 5.23508638e-02f, -1.49682658e-02f, 5.51617220e-02f, 7.76862055e-02f, 1.33515820e-01f, -3.86282764e-02f, -1.92169677e-02f, -5.01266390e-04f,
  -6.30880531e-04f, -3.67848366e-01f, 2.16198396e-02f, 7.53207132e-02f, -2.99678352e-02f, 9.41800103e-02f, 1.29186302e-01f, -9.50161368e-02f, -3.88915353e-02f, -6.97951466e-02f,
  -7.34966919e-02f, -4.79836427e-02f, -8.51536617e-02f, -1.91010475e-01f, -1.69957265e-01f, -1.09424349e-02f, -5.50965853e-02f, -2.15764359e-01f, -2.49511987e-01f, -3.62466611e-02f,
  -2.92929798e-01f, -3.82018656e-01f, -2.75710583e-01f, -3.51699501e-01f, -3.74063626e-02f, -3.46287668e-01f, -1.49699688e-01f, 8.08837172e-03f, -2.79400438e-01f, -3.62963825e-01f,
  -1.01360805e-01f, -8.92952904e-02f, -2.52622634e-01f, 1.25030234e-01f, 1.10570654e-01f, 3.75305228e-02f, -6.03539050e-02f, -1.72370136e-01f, 5.13517261e-02f, 6.78474456e-02f,
  2.12199334e-02f, 5.79040572e-02f, 3.77037376e-02f, -1.18744224e-01f, -1.55334130e-01f, -4.56923321e-02f, -2.03072578e-02f, -1.45844638e-01f, -3.46539952e-02f, -1.21201491e-02f,
  2.15286657e-01f, 2.35450953e-01f, 2.04358414e-01f, -6.77722916e-02f, 2.72811074e-02f, 1.34718686e-01f, -2.46898849e-02f, 9.67805460e-02f, 7.19591603e-02f, 9.21811722e-03f,
  7.52995238e-02f, -2.74235457e-01f, 3.71171236e-02f, 5.99313341e-02f, 6.06488697e-02f, -1.86780989e-01f, -1.00114182e-01f, -1.96701903e-02f, -6.59961849e-02f, -1.13535561e-01f,
  -8.77287164e-02f, 6.53376728e-02f, 4.13761474e-02f, -2.57698577e-02f, -8.72079879e-02f, -1.07390732e-01f, -8.09179172e-02f, -1.59318775e-01f, -1.25678897e-01f, -1.50256664e-01f,
  -1.75246030e-01f, -8.68604928e-02f, -1.19038828e-01f, -2.08660081e-01f, -1.32877722e-01f, 1.74950268e-02f, -9.98649821e-02f, -2.73322761e-01f, -1.42577931e-01f, -8.40816274e-02f,
  8.68698880e-02f, -6.05365913e-03f, 1.12211049e-01f, -1.00116558e-01f, -3.62454192e-03f, -1.43669516e-01f, 1.72607213e-01f, 2.10996926e-01f, 7.05282688e-02f, 2.61948481e-02f,
  4.55249511e-02f, 4.07674946e-02f, 1.16032600e-01f, 1.53613716e-01f, 1.42195389e-01f, 1.96156755e-01f, 1.46794200e-01f, 1.08754516e-01f, 8.06743056e-02f, 1.08602591e-01f,
  1.63334683e-01f, 9.91682410e-02f, 9.94109511e-02f, -3.52260284e-02f, 9.16702449e-02f, 8.53022709e-02f, 2.81266272e-01f, 2.74417400e-01f, 2.57207677e-02f, 2.36100435e-01f,
  3.93037945e-01f, 7.45096356e-02f, -2.20058276e-03f, -1.19715799e-02f, 4.89259958e-02f, 4.22085775e-03f, 1.54202491e-01f, 1.71030432e-01f, 4.98140156e-02f, 1.38003007e-01f,
  -3.68959419e-02f, 9.60984081e-02f, -2.26593800e-02f, -1.01221077e-01f, 1.88466888e-02f, 1.03113189e-01f, 1.60804719e-01f, -6.17707819e-02f, -2.92348862e-02f, -3.76531063e-03f,
  -6.91791996e-02f, -9.67358947e-02f, 6.35197666e-03f, -2.65280250e-02f, -7.38980398e-02f, 9.51880440e-02f, 2.24942807e-02f, 7.38195404e-02f, -6.08951151e-02f, 6.23803437e-02f,
  2.08007544e-01f, -1.98991463e-01f, -4.25161123e-01f, -8.50728340e-03f, -1.67212963e-01f, -2.02381000e-01f, -3.05978656e-01f, -8.66918713e-02f, 1.33119404e-01f, -3.64690810e-01f,
  -2.63002753e-01f, -1.28202990e-01f, -2.35850617e-01f, -2.44507223e-01f, -3.85766774e-01f, -4.07604963e-01f, -4.83024448e-01f, -3.86886418e-01f, -1.49600536e-01f, 1.62287522e-02f,
  -4.64417897e-02f, -3.96728069e-02f, 1.37309032e-02f, -7.90666342e-02f, -5.73107265e-02f, -1.24003008e-01f, -2.21326277e-01f, -2.79657263e-02f, -2.37910315e-01f, -1.18549362e-01f,
  -3.24394524e-01f, 8.20486993e-02f, -1.58836231e-01f, 2.79617496e-02f, -1.42507553e-01f, 3.49708460e-02f, -1.28316760e-01f, -4.68083983e-03f, 6.66265562e-02f, -1.25520736e-01f,
  -2.35312432e-03f, 3.74359712e-02f, 9.93736535e-02f, 2.74287276e-02f, 2.66295802e-02f, -1.21316053e-02f, 5.08746617e-02f, -2.85837688e-02f, -1.55387372e-01f, 4.94257994e-02f,
  4.20915969e-02f, 5.30014001e-02f, -8.06382746e-02f, -4.44750255e-03f, 1.65898100e-01f, 1.33870840e-01f, 1.35100082e-01f, 2.51334280e-01f, 1.14747897e-01f, 9.12657082e-02f,
  5.49586080e-02f, -4.11980029e-04f, 4.54607643e-02f, 1.21298052e-01f, -1.40729528e-02f, -1.28755584e-01f, 3.04416884e-02f, -1.75204813e-01f, 4.13285866e-02f, 4.11328077e-02f,
  -6.41622022e-02f, -2.76694167e-02f, -2.81559769e-02f, -7.35940859e-02f, -9.54826251e-02f, -6.32003918e-02f, 3.63975693e-03f, -2.02070978e-02f, 5.29365875e-02f, 3.71001549e-02f,
  -1.08992577e-01f, -6.18482642e-02f, -1.43377408e-02f, -8.56061056e-02f, 2.16014851e-02f, -1.41475171e-01f, 1.18169440e-02f, -2.11477373e-03f, 1.72281981e-01f, 1.22596197e-01f,
  -2.13326085e-02f, -2.17215285e-01f, -2.17851415e-01f, -1.30786583e-01f, -5.09042032e-02f, -1.26821220e-01f, -1.29505396e-01f, -4.29070890e-02f, -1.17078617e-01f, -4.13451856e-03f,
  5.62864058e-02f, -1.12893559e-01f, -1.56070903e-01f, -4.26870510e-02f, -1.07857056e-01f, -4.77191508e-02f, -1.41552269e-01f, -1.33346438e-01f, -1.05698727e-01f, 4.54694368e-02f,
  1.28400105e-03f, -1.72979131e-01f, -1.05606318e-01f, -3.80172059e-02f, 8.44805315e-02f, -1.15374133e-01f, -8.91885310e-02f, -6.27416745e-02f, -1.50664210e-01f, -9.59308520e-02f,
  9.07014847e-01f, 2.57855743e-01f, -4.58388597e-01f, 1.52742565e-01f, -1.87209427e-01f, -2.23349616e-01f, -1.11475736e-01f, 9.07034278e-02f, 1.15606368e-01f, 2.85963774e-01f,
  2.19317954e-02f, 1.58984587e-01f, 9.73198563e-02f, 4.41596583e-02f, 1.86058849e-01f, 1.19716942e-01f, -9.59265903e-02f, -9.19811577e-02f, -5.37266098e-02f, -1.71063002e-02f,
  1.69414073e-01f, 1.69217423e-01f, 2.86199182e-01f, 1.01374991e-01f, -1.11458398e-01f, 2.80535575e-02f, -8.10328647e-02f, -7.58881047e-02f, -7.26931691e-02f, 1.16408244e-01f,
  -4.12059754e-01f, -1.20243527e-01f, 3.19555029e-02f, 1.64393112e-01f, 2.40466055e-02f, 9.59440842e-02f, -9.26809758e-03f, 1.66826677e-02f, 1.52386114e-01f, 2.85713095e-03f,
  -7.03961104e-02f, -2.66411453e-02f, -1.31872311e-01f, 2.47130953e-02f, -1.25338599e-01f, -4.21619415e-02f, -5.32137752e-02f, -5.30064441e-02f, 5.16630933e-02f, 5.24100964e-04f,
  -7.95359164e-02f, -1.15655921e-01f, -2.89480925e-01f, -1.07473850e-01f, -8.35738927e-02f, -7.06620216e-02f, -7.66583160e-02f, -1.72141213e-02f, -1.10705376e-01f, 1.49397150e-01f,
  -7.22857118e-02f, 4.17207778e-02f, -1.24022901e-01f, 2.09999904e-02f, -2.47655883e-02f, 1.09539278e-01f, -8.30062255e-02f, 3.09717488e-02f, 8.00792500e-02f, 1.33444909e-02f,
  4.91389968e-02f, -7.67066376e-03f, -1.34186327e-01f, -1.46846604e-02f, 5.17351665e-02f, -5.22431396e-02f, -5.79963773e-02f, 1.58780336e-03f, -1.09382346e-01f, -5.73989786e-02f,
  8.87527764e-02f, -4.92144227e-02f, -1.42082926e-02f, -1.40121907e-01f, -2.94163935e-02f, -8.07898939e-02f, -3.40450853e-02f, 2.14031842e-02f, 8.09317231e-02f, 7.33166412e-02f,
  6.48543909e-02f, -3.55370462e-01f, 1.69749022e-01f, 1.36614308e-01f, -8.53840560e-02f, 1.97856519e-02f, 2.90455613e-02f, -5.50476722e-02f, -9.12312344e-02f, 2.06250381e-02f,
  -1.40945017e-01f, 3.21187600e-02f, -3.07344962e-02f, -2.17545163e-02f, 9.83712226e-02f, 1.03230393e-02f, 1.86176315e-01f, 8.94716457e-02f, -2.26143207e-02f, -1.10303074e-01f,
  1.99994817e-02f, 1.30297467e-01f, 9.68540981e-02f, 1.60878561e-02f, 9.38131586e-02f, 1.18645847e-01f, 4.19602059e-02f, -2.08244212e-02f, -3.90706472e-02f, 2.37366274e-01f,
  -4.40274507e-01f, -3.42644751e-02f, 6.10569157e-02f, 3.63119170e-02f, 9.06062871e-02f, 1.82350591e-01f, 2.06579030e-01f, 6.50278386e-03f, -6.33473024e-02f, -4.86234240e-02f,
  -1.72255561e-01f, -4.93996516e-02f, 1.63367186e-02f, -2.11175308e-02f, -3.31687070e-02f, 1.19951002e-01f, 8.74942243e-02f, 5.63155264e-02f, -6.82939813e-02f, 1.64425224e-02f,
  4.12372462e-02f, 3.06545626e-02f, 3.07498430e-03f, -4.23024362e-03f, 8.89632404e-02f, -6.04929775e-02f, 1.11032858e-01f, 1.15825921e-01f, -3.29265594e-02f, 1.18804798e-01f,
  8.56762752e-02f, -3.67958844e-01f, -1.09807096e-01f, -1.46368697e-01f, -9.88089070e-02f, -1.30929738e-01f, -8.76774266e-02f, -5.52721210e-02f, 2.15868615e-02f, 1.05213769e-01f,
  4.22412828e-02f, -8.32400396e-02f, -1.48300737e-01f, -5.52907353e-03f, -3.26730646e-02f, -4.78981994e-02f, -2.70032287e-02f, -7.88739845e-02f, 1.40525191e-03f, -2.97582205e-02f,
  -1.33653671e-01f, 3.90497856e-02f, 3.54547873e-02f, 3.15585220e-03f, -5.62725030e-02f, -1.26010224e-01f, -6.43391758e-02f, -1.74555346e-01f, -9.08755586e-02f, 9.14557725e-02f,
  6.94668666e-02f, -4.40087989e-02f, -2.20448285e-01f, -4.13045213e-02f, -2.87323408e-02f, 3.47963646e-02f, 1.21697634e-01f, 6.67154863e-02f, 1.24993637e-01f, 5.02984226e-02f,
  7.84799233e-02f, -7.04312772e-02f, 9.24813282e-03f, 6.09983020e-02f, -5.08617945e-02f, -1.36185899e-01f, -8.40208977e-02f, -6.89189807e-02f, -7.71473274e-02f, -1.43151373e-01f,
  6.60861726e-04f, 4.86886613e-02f, 6.51228335e-03f, -1.04194982e-02f, -8.60029906e-02f, -1.05459094e-01f, 9.78425294e-02f, -1.05555793e-02f, 7.73885399e-02f, 6.72611147e-02f,
  3.51381719e-01f, -3.27109009e-01f, -7.31380582e-02f, -4.75216731e-02f, -1.02709383e-01f, -1.33526661e-02f, -1.34315223e-01f, -7.74837583e-02f, 5.24168275e-02f, -1.87799670e-02f,
  -2.24617179e-02f, 8.44667852e-02f, -7.27195963e-02f, 2.65702792e-02f, 1.45283073e-01f, 5.87197430e-02f, -2.62600761e-02f, 1.01720698e-01f, -3.10562905e-02f, 4.22351360e-02f,
  1.32280394e-01f, 1.68166593e-01f, 9.97971445e-02f, 1.74749970e-01f, 5.98939322e-02f, 1.33867294e-01f, 1.98570654e-01f, 6.71228543e-02f, 1.74556732e-01f, 3.05886745e-01f,
  -2.80062467e-01f, -1.78001121e-01f, -1.81306764e-01f, -4.28103477e-01f, -2.24182650e-01f, -1.94992006e-01f, -8.52308720e-02f, -7.00221583e-02f, -2.29552746e-01f, -3.24204624e-01f,
  5.61878048e-02f, 2.02121064e-01f, 1.77087396e-01f, 2.76909769e-01f, 3.59154075e-01f, -2.08113194e-01f, -2.38013536e-01f, 2.26341918e-01f, 4.09520239e-01f, 1.33003846e-01f,
  3.57597359e-02f, -1.25851616e-01f, 1.36779711e-01f, 2.96093449e-02f, -3.84794950e-01f, -5.12358639e-03f, -3.49667460e-01f, -1.33508042e-01f, -5.32593168e-02f, -4.09959257e-01f,
  2.23752663e-01f, -1.76191583e-01f, 3.77427675e-02f, 7.46501759e-02f, -1.16475172e-01f, -1.79782473e-02f, 8.08343068e-02f, -1.04698278e-02f, -7.43816867e-02f, -9.81604010e-02f,
  -7.25341812e-02f, 8.48251060e-02f, 2.93496009e-02f, 6.67873994e-02f, -4.55465727e-02f, 6.57168478e-02f, -1.94431748e-02f, -4.80530597e-02f, 4.59632883e-03f, -7.94348791e-02f,
  1.80381220e-02f, -1.27034247e-01f, 5.56750223e-02f, 7.64271070e-04f, -7.15819970e-02f, 8.54767710e-02f, -6.39862940e-02f, 5.12456894e-02f, 2.64316648e-02f, -2.65723795e-01f,
  -7.02122226e-02f, -7.02561736e-02f, -1.88451596e-02f, 5.94446100e-02f, 6.13652810e-04f, -6.27097711e-02f, -1.07163668e-01f, 5.05941510e-02f, 3.18377279e-02f, -7.57307094e-03f,
  -3.35619040e-02f, 1.28972614e-02f, 6.57738447e-02f, -1.19380608e-01f, -1.12213179e-01f, -1.27744060e-02f, 1.15798293e-02f, 4.62969989e-02f, 1.65716477e-03f, 6.10220945e-04f,
  4.96382527e-02f, -1.37322724e-01f, -9.71465185e-02f, 8.83416608e-02f, -9.54973400e-02f, 1.02770828e-01f, 6.28853664e-02f, 9.57792997e-02f, -5.45975454e-02f, -1.60460815e-01f,
  1.40557408e-01f, 2.44799703e-01f, -1.73382327e-01f, 3.04793380e-03f, -1.55345187e-01f, 5.28278947e-02f, -1.37451738e-01f, 9.01938323e-03f, -4.08970490e-02f, 5.49233221e-02f,
  -4.56993468e-02f, 7.36953691e-02f, -5.80942705e-02f, 2.83061657e-02f, 4.75562103e-02f, 5.51493093e-02f, 7.11760595e-02f, -1.79012883e-02f, -3.50057818e-02f, -8.57002288e-02f,
  -7.67935812e-02f, -1.37365550e-01f, 1.26251429e-01f, 5.69248535e-02f, -5.65908551e-02f, 6.13443293e-02f, 1.12461090e-01f, -3.23381126e-02f, 1.79399773e-01f, -8.20081383e-02f,
  -4.34020124e-02f, 2.37274647e-01f, 9.83713716e-02f, -6.29511848e-02f, 3.66485894e-01f, 1.00207411e-01f, -1.41784161e-01f, -5.04589677e-01f, -1.74644917e-01f, 1.76413521e-01f,
  4.56334233e-01f, 4.92614098e-02f, -4.05315131e-01f, -5.15151560e-01f, -6.96609378e-01f, -5.08858085e-01f, -5.35396457e-01f, -4.21689153e-01f, -5.07366896e-01f, -4.18190174e-02f,
  1.45076513e-01f, -9.01691914e-02f, -2.89958566e-01f, -3.56503427e-01f, -4.76734638e-02f, -1.42013401e-01f, -1.13664724e-01f, -7.66454730e-03f, 9.05854278e-04f, -8.59236717e-02f,
  -8.48838910e-02f, -1.09589458e-01f, 2.16695908e-02f, -3.44059989e-02f, 1.75181478e-01f, -6.89012185e-02f, -2.42837500e-02f, 2.24114228e-02f, 8.37629437e-02f, -1.42171338e-01f,
  1.77727178e-01f, 7.68249994e-03f, 9.20953453e-02f, -6.51451871e-02f, -7.26265237e-02f, -1.03054427e-01f, -1.12376034e-01f, -3.25028509e-01f, -1.91096142e-01f, 1.15642101e-01f,
  3.34475756e-01f, 2.58372545e-01f, -1.39181912e-01f, -2.09141463e-01f, -4.72495615e-01f, -1.64339602e-01f, -6.63029328e-02f, -1.57296702e-01f, -3.39063048e-01f, -2.21286654e-01f,
  -5.47470488e-02f, -6.75231079e-03f, 1.15094215e-01f, 2.27572359e-02f, -1.31906671e-02f, 1.95418939e-01f, -9.89750102e-02f, -7.29730651e-02f, 5.83867133e-02f, -4.32993285e-02f,
  7.43035823e-02f, 1.27079457e-01f, -7.06470907e-02f, -3.93775739e-02f, -1.59716874e-01f, -1.89604908e-02f, -8.80688056e-03f, -9.54266936e-02f, -1.09741665e-01f, -1.00240111e-01f,
  -1.42469257e-01f, -9.84047875e-02f, 6.21606782e-02f, -1.94887295e-01f, 5.20080253e-02f, -2.02180058e-01f, -5.92904016e-02f, -2.19115913e-01f, -2.15996861e-01f, -1.04071446e-01f,
  -2.02332348e-01f, 5.16675003e-02f, -8.39019641e-02f, -2.19407558e-01f, 1.85900237e-02f, 1.52551413e-01f, 2.06995100e-01f, 1.47077544e-02f, 1.84890017e-01f, -1.18757762e-01f,
  -1.51224896e-01f, -3.58807482e-02f, -2.09916495e-02f, 5.36560453e-03f, -1.38559580e-01f, -1.44422740e-01f, 7.77614042e-02f, 4.34420109e-02f, -5.68461120e-02f, 2.86346376e-01f,
  -5.02570346e-02f, -1.85124651e-01f, -3.81452262e-01f, -2.34199852e-01f, -1.90826237e-01f, -3.53739649e-01f, -2.63556629e-01f, -3.16451669e-01f, -4.02739912e-01f, -4.28438842e-01f,
  -2.65015423e-01f, 4.51487273e-01f, 3.67008269e-01f, -4.57169086e-01f, 1.23614473e-02f, 3.78739536e-01f, 5.25516689e-01f, 5.59321754e-02f, -4.12437290e-01f, 1.26005873e-01f,
  2.43876249e-01f, -2.31121540e-01f, -2.24494934e-01f, -1.21144913e-01f, 1.70114011e-01f, 2.20023498e-01f, -6.05490431e-02f, 1.60334837e-02f, -9.77777177e-04f, -3.69276218e-02f,
  -2.22057905e-02f, -2.06699476e-01f, -1.91698596e-01f, -2.21486017e-01f, -1.70404434e-01f, -3.12639028e-01f, 1.30828291e-01f, 6.43023700e-02f, 3.28292251e-01f, -7.91779608e-02f,
  2.77871788e-01f, 1.81837529e-01f, -1.92045093e-01f, -1.45058855e-01f, 2.70064063e-02f, -2.54399572e-02f, 1.03474088e-01f, -1.37854204e-01f, -1.62222296e-01f, -2.71711908e-02f,
  -1.06025077e-01f, 1.87445041e-02f, 7.65628144e-02f, 1.53089896e-01f, -4.65185270e-02f, -6.95301145e-02f, 4.87308167e-02f, -2.72409078e-02f, -2.55763251e-03f, 7.97741413e-02f,
  4.81651947e-02f, 9.29621831e-02f, 3.14796418e-02f, 1.69753402e-01f, 1.48068935e-01f, -9.17922705e-02f, 9.75574180e-02f, -3.47985104e-02f, 9.24098864e-02f, -1.62953183e-01f,
  1.64186228e-02f, -4.77437004e-02f, -1.54070081e-02f, -3.47191654e-02f, -1.95075423e-02f, -3.45101357e-02f, -6.89689890e-02f, 1.00594433e-02f, 2.48523802e-02f, 9.58808959e-02f,
  -2.04861332e-02f, 1.46607444e-01f, 7.80526549e-02f, 1.72961764e-02f, 7.36462697e-03f, 6.26851842e-02f, 1.29714161e-01f, 1.19825073e-01f, 1.12960942e-01f, -2.41579171e-02f,
  -1.73133072e-02f, -1.68151762e-02f, 6.57251850e-02f, 1.26768991e-01f, 1.31271914e-01f, -6.20153025e-02f, 2.36462876e-02f, 4.42685075e-02f, 1.03374831e-01f, 9.21987370e-02f,
  -2.54189402e-01f, 2.99500316e-01f, -1.47185758e-01f, -1.70285329e-01f, -6.86506853e-02f, -6.28103837e-02f, 3.61934863e-02f, -7.72101656e-02f, -3.65370587e-02f, -9.22935605e-02f,
  1.32365227e-01f, -2.02975608e-03f, 1.32341251e-01f, 7.66172856e-02f, 1.57007799e-02f, -1.02722466e-01f, -3.48397940e-02f, -1.10055275e-01f, -1.06969513e-01f, -2.35272609e-02f,
  -7.38410000e-03f, 4.20058593e-02f, -1.55069456e-01f, -2.56500766e-02f, 6.61473051e-02f, -8.91226679e-02f, 5.98211656e-04f, 1.57885964e-03f, 1.45324871e-01f, -1.18478529e-01f,
  -2.17024580e-01f, -2.53158420e-01f, 2.69862801e-01f, -1.11703068e-01f, -1.93749681e-01f, -3.67107630e-01f, -5.94418049e-01f, -1.81287214e-01f, -1.76780485e-02f, -2.53540248e-01f,
  -4.44775492e-01f, -1.86412439e-01f, 6.47876114e-02f, 1.78810526e-02f, -1.57477915e-01f, -4.16288108e-01f, -4.93486151e-02f, 3.48598927e-01f, 3.72805715e-01f, -5.83359301e-02f,
  -2.32940093e-01f, 1.80407867e-01f, 3.01916331e-01f, 3.65624666e-01f, 9.67713594e-02f, 1.69327930e-01f, 1.80043742e-01f, 1.36644095e-01f, -9.78456251e-03f, 1.11426972e-01f,
  5.96414953e-02f, 1.40752435e-01f, 6.63349777e-02f, 9.09138098e-02f, 2.56206449e-02f, 1.28895510e-02f, -2.30399117e-01f, 1.72240004e-01f, -9.74937081e-02f, 8.24744031e-02f,
  -2.27001503e-01f, -1.76882923e-01f, -6.92954212e-02f, 3.40048783e-02f, -5.68582229e-02f, 1.12293720e-01f, 3.42374116e-01f, 2.53803462e-01f, 1.36651680e-01f, -3.66708566e-03f,
  -2.57227987e-01f, -1.42864302e-01f, -2.61547621e-02f, 4.39198166e-02f, 2.20056146e-01f, -7.06384033e-02f, 3.30825560e-02f, 2.66618788e-01f, 6.75421059e-02f, 5.27520711e-03f,
  -4.89081480e-02f, -7.86532685e-02f, 6.27456605e-02f, -1.20591961e-01f, -3.58098298e-02f, -3.11886948e-02f, 4.25364487e-02f, 7.98302703e-04f, 1.83714982e-02f, -1.79149862e-02f,
  1.88317895e-02f, -5.11245579e-02f, 8.73561278e-02f, -2.00762693e-02f, 1.21869452e-01f, -2.49109045e-02f, -8.04999471e-03f, 8.79793018e-02f, -1.74376760e-02f, -3.25927162e-03f,
  -9.47863050e-03f, 3.11056687e-03f, 1.69172902e-02f, 5.78844696e-02f, 1.94446985e-02f, 1.73532575e-01f, 2.73794755e-02f, 1.67832449e-02f, 8.07963032e-03f, 5.24958689e-03f,
  -2.95724928e-01f, 4.67211660e-03f, -3.36655736e-01f, 9.04950574e-02f, -1.37028033e-02f, 1.17389977e-01f, -3.89907770e-02f, 3.84115018e-02f, 4.96550687e-02f, 4.48772833e-02f,
  2.07182784e-02f, -2.32878536e-01f, -4.10015658e-02f, -2.94467621e-02f, -1.47818938e-01f, -6.51858049e-04f, -1.81075856e-01f, -1.70348257e-01f, -1.92880452e-01f, -2.50126310e-02f,
  -8.39913040e-02f, -2.81448990e-01f, -4.54747796e-01f, -3.14992309e-01f, -1.49962947e-01f, -2.58920372e-01f, -2.20876455e-01f, -2.26157174e-01f, -2.99722344e-01f, -5.20520031e-01f,
  -4.33481365e-01f, 2.81794854e-02f, -1.81582123e-01f, 2.30846070e-02f, 1.29438424e-02f, 7.81284273e-02f, -2.11033821e-02f, 4.79610190e-02f, 7.11044148e-02f, 3.77339497e-02f,
  3.07094119e-02f, -7.00839758e-02f, -3.55728865e-02f, -7.60296211e-02f, -6.55728057e-02f, 1.96100958e-02f, 3.92184332e-02f, -1.71736851e-01f, -1.36430830e-01f, 1.32908858e-02f,
  1.43219203e-01f, 7.74999335e-02f, -2.58923210e-02f, 3.04659456e-02f, 1.49862081e-01f, -8.17709938e-02f, -1.25722960e-01f, 3.33054438e-02f, 4.52730469e-02f, 2.84830108e-02f,
  1.40229523e-01f, 8.02311972e-02f, 8.51531401e-02f, 1.71958029e-01f, 1.32760137e-01f, -6.62642941e-02f, 9.85565633e-02f, 4.73751361e-03f, 1.62310779e-01f, 1.97087675e-01f,
  1.36864021e-01f, 1.21504985e-01f, -1.02027133e-03f, -9.95556079e-03f, 1.02537334e-01f, 1.47094056e-01f, 1.05190583e-01f, 6.64870068e-02f, 1.17204651e-01f, 2.09428638e-01f,
  1.99445888e-01f, 4.98286150e-02f, 9.91283581e-02f, 2.11772341e-02f, 2.27510147e-02f, 5.28589189e-02f, 8.37097690e-02f, 1.55981451e-01f, 9.87405255e-02f, -4.51144725e-02f,
  3.71762328e-02f, -7.08739331e-04f, 1.66092619e-01f, -1.08546615e-01f, -1.20787479e-01f, 3.91561724e-02f, -4.05589864e-02f, -2.32445542e-03f, -1.40840724e-01f, -5.90005927e-02f,
  6.09578304e-02f, 1.30436018e-01f, -1.77945774e-02f, 2.17700973e-02f, 8.85719731e-02f, -1.30529737e-03f, 2.47238968e-02f, 3.62771414e-02f, 1.36801805e-02f, 3.47044207e-02f,
  4.66080271e-02f, 1.74800560e-01f, 2.43810900e-02f, 1.41736925e-01f, 2.75082260e-01f, 5.22155724e-02f, 5.91711998e-02f, 1.49396230e-02f, 4.01521102e-02f, 2.42705029e-02f,
  2.58888483e-01f, -9.50340647e-03f, 5.64601123e-02f, -3.61370370e-02f, 9.05639678e-03f, 9.60230008e-02f, 1.06446445e-02f, 1.08612396e-01f, 7.63984993e-02f, 1.69768497e-01f,
  6.58439398e-02f, -2.79804375e-02f, 1.38636947e-01f, 4.71705906e-02f, -3.56470272e-02f, 3.64601873e-02f, 7.68739134e-02f, 6.06442988e-02f, 1.78418815e-01f, 1.76204920e-01f,
  2.07019627e-01f, 1.03671953e-01f, -2.35610381e-02f, 4.94321249e-02f, -9.14340913e-02f, -1.20652206e-02f, 5.94859719e-02f, 1.61852136e-01f, -4.09192219e-03f, -4.87756245e-02f,
  1.94928885e-01f, 1.20126307e-01f, 7.29108453e-02f, 1.87943563e-01f, -1.03064552e-01f, -9.56202447e-02f, -4.31103428e-04f, 6.34057745e-02f, -1.58889371e-03f, 4.38309126e-02f,
  -2.57189333e-01f, -1.91717640e-01f, 1.41498342e-01f, 4.71469611e-02f, 1.56615779e-01f, 1.48607746e-01f, 2.89710939e-01f, 3.23742926e-01f, 8.44186470e-02f, 9.35420543e-02f,
  1.28195375e-01f, 1.65152014e-05f, 1.57289326e-01f, 2.05880642e-01f, 3.06646973e-01f, -4.20662351e-02f, 6.75142780e-02f, 5.70236742e-02f, 3.59783992e-02f, 4.01691437e-01f,
  -8.66597816e-02f, -1.60579517e-01f, -1.08520091e-01f, -2.07951114e-01f, -1.15173429e-01f, 1.98807254e-01f, 4.61457856e-02f, -5.31419739e-03f, -4.32290286e-02f, 1.13701738e-01f,
  -1.95318893e-01f, -1.44710839e-01f, 5.76232523e-02f, 8.55532363e-02f, -8.76253098e-02f, -8.23199078e-02f, 1.10669807e-01f, 2.82334149e-01f, 1.83195248e-01f, 9.31596905e-02f,
  5.88849857e-02f, -1.84081733e-01f, -1.44990474e-01f, 2.03206036e-02f, 1.17392354e-01f, -2.10958600e-01f, -2.14520499e-01f, 1.18897088e-01f, -1.48947686e-01f, 1.46221295e-01f,
  -7.02951327e-02f, -7.88676217e-02f, 7.50833098e-03f, 3.22450511e-02f, 7.32332766e-02f, 1.57549053e-01f, 6.50216863e-02f, 7.42045045e-02f, 1.15431808e-01f, 1.97141711e-03f,
  1.63835421e-01f, 9.44586620e-02f, 1.32676914e-01f, 6.03454523e-02f, -8.20458010e-02f, 5.21496087e-02f, 1.38362497e-01f, -1.08799390e-01f, 1.66625772e-02f, -1.31967142e-01f,
  1.12064712e-01f, 1.07976668e-01f, -8.34857076e-02f, 2.40189090e-01f, -2.83030942e-02f, 1.00184428e-02f, 5.82238100e-02f, -6.42543361e-02f, -7.89263248e-02f, -2.66565029e-02f,
  -3.74238938e-01f, -4.41702127e-01f, 1.44518629e-01f, 1.90347247e-02f, -6.17311224e-02f, -2.31800303e-01f, -2.16272324e-01f, -9.71995592e-02f, -3.64006609e-02f, 1.33953974e-01f,
  -2.32301250e-01f, -9.57835987e-02f, -6.79647774e-02f, -2.43387613e-02f, -2.49113031e-02f, -9.98998880e-02f, 4.99353781e-02f, 1.85817018e-01f, -9.74998400e-02f, -6.83290064e-02f,
  3.26858424e-02f, -1.94987357e-02f, -1.94168761e-01f, -1.25376478e-01f, -1.12564385e-01f, -3.38059038e-01f, -1.91975012e-01f, -2.40736514e-01f, -3.91823649e-01f, -6.86484873e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 104)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 104;
const float L0_fan_Bp_bar_data[] = {
  -2.43161083e-03f, 1.04110070e-01f, 1.86346769e-01f, 2.67724156e-01f, -2.19476372e-02f, 6.29965782e-01f, 4.58980024e-01f, 2.82697022e-01f, 2.76079625e-01f, 4.85143244e-01f,
  3.03074718e-01f, 1.83030650e-01f, 4.39896166e-01f, 9.08533037e-02f, 2.64952242e-01f, 3.55072349e-01f, 2.49834463e-01f, 4.29055601e-01f, 4.89913106e-01f, 4.41743433e-01f,
  4.54946071e-01f, 1.97827905e-01f, 3.68435055e-01f, 1.11060634e-01f, 5.55063307e-01f, 4.54159468e-01f, 4.08757716e-01f, 4.16474104e-01f, 3.46417278e-01f, 2.74157792e-01f,
  5.38273513e-01f, 2.86215007e-01f, 3.33093941e-01f, 3.95628184e-01f, 2.31521010e-01f, 3.32783073e-01f, 7.59172916e-01f, 5.76232374e-01f, 3.27858835e-01f, 3.34470004e-01f,
  2.91901648e-01f, 4.15277898e-01f, 2.01936260e-01f, 2.64991373e-01f, 4.33419317e-01f, 3.41900408e-01f, 2.21345797e-01f, 5.02692044e-01f, 4.68660444e-01f, 2.76648521e-01f,
  3.28812301e-01f, 4.22239870e-01f, 2.82733500e-01f, 3.68748397e-01f, 3.59495521e-01f, 1.61639646e-01f, 1.63749933e-01f, 3.14119607e-01f, 2.46065095e-01f, 2.63485700e-01f,
  2.20182568e-01f, 4.21791613e-01f, 2.92949617e-01f, 6.89843118e-01f, 2.34491929e-01f, 8.64279270e-02f, 2.61042684e-01f, 3.78705561e-01f, 5.55270493e-01f, 3.36437374e-01f,
  3.77888083e-01f, 4.51988846e-01f, 3.73772621e-01f, 1.41996667e-01f, 2.30846688e-01f, 3.12531382e-01f, 1.65316351e-02f, 3.36731166e-01f, 2.50432611e-01f, 3.38157952e-01f,
  2.50357985e-01f, 4.90329087e-01f, 5.26744127e-01f, 1.88843131e-01f, 2.86001951e-01f, 2.73036212e-01f, 7.01960176e-02f, 4.43471521e-01f, 2.47362733e-01f, 4.62376893e-01f,
  2.00819597e-01f, 5.28638773e-02f, 1.62403643e-01f, 2.87394762e-01f, 3.38431485e-02f, 2.93955177e-01f, 4.52324331e-01f, 3.64291161e-01f, 4.82176542e-01f, 4.04764175e-01f,
  3.32654923e-01f, 2.99616754e-01f, -9.61019006e-03f, 1.05041705e-01f
};

// L1_linear_W (Shape: 12 x 128)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 128;
const float L1_linear_W_data[] = {
  -4.31936122e-02f, -1.42009810e-01f, -1.47932917e-01f, -2.35495269e-01f, -5.57355070e-03f, -1.19758025e-01f, -2.71623552e-01f, -1.50543302e-02f, -2.19027519e-01f, -1.10819675e-01f,
  -1.55335113e-01f, -5.01099415e-03f, 1.39510050e-01f, -7.38060251e-02f, -4.07782849e-03f, -3.23277675e-02f, -8.02815184e-02f, 2.79801507e-02f, -8.12820122e-02f, 1.25068396e-01f,
  1.64030463e-01f, -8.09501931e-02f, -1.47286817e-01f, -9.18308347e-02f, -2.61188358e-01f, 1.48552895e-01f, -1.88010082e-01f, 1.66159496e-01f, 3.22865188e-01f, 2.69616604e-01f,
  -5.35543589e-03f, -3.38658132e-02f, -1.43709645e-01f, -3.01040798e-01f, -5.17396629e-01f, -4.13286597e-01f, -6.57102540e-02f, 1.74161658e-01f, -1.86763734e-01f, -3.00158948e-01f,
  -2.83555150e-01f, -2.66432822e-01f, 4.38638069e-02f, 2.24461019e-01f, 6.66243955e-02f, -2.65633136e-01f, 9.39036831e-02f, 3.14531058e-01f, -1.39141763e-02f, -1.82005554e-01f,
  -1.84060499e-01f, -7.60101676e-01f, -4.51647043e-02f, -3.66282701e-01f, -1.85007498e-01f, -7.55780190e-02f, 8.15827996e-02f, -5.53617835e-01f, -2.46993363e-01f, -4.25792523e-02f,
  -5.61026573e-01f, -4.81560051e-01f, 4.65133488e-01f, -2.90895343e-01f, -6.50632307e-02f, -9.98201594e-02f, -2.30501518e-01f, -5.72411537e-01f, -3.11607391e-01f, -2.10667267e-01f,
  4.25001919e-01f, -4.70592231e-01f, -3.61982286e-01f, 2.10431337e-01f, -2.69226730e-01f, -6.87234700e-01f, 1.04293920e-01f, 1.95237219e-01f, 4.56220144e-03f, 1.39095876e-02f,
  2.66498446e-01f, -1.40580749e-02f, 1.88850001e-01f, -5.27258217e-02f, -1.68535158e-01f, -3.58087003e-01f, 9.02538095e-03f, -3.27392638e-01f, -2.70414710e-01f, 1.37024760e-01f,
  1.02295399e-01f, -4.84284937e-01f, -4.52288419e-01f, -9.92908031e-02f, 9.01690647e-02f, 1.36549488e-01f, -3.82435232e-01f, -2.12594897e-01f, -2.12541983e-01f, 3.08651458e-02f,
  2.99851713e-03f, -1.31596208e-01f, 5.28805889e-02f, -4.23945487e-01f, 8.85915160e-02f, -5.40882945e-01f, -5.06622851e-01f, 4.16753262e-01f, 1.86406478e-01f, 2.56292075e-01f,
  3.45226645e-01f, 1.64568171e-01f, 2.19595283e-01f, -1.89530805e-01f, -1.04452059e-01f, 3.12835686e-02f, -8.94627497e-02f, 6.16997108e-02f, -1.21800087e-01f, 2.73906469e-01f,
  -4.83704478e-01f, -3.91358435e-01f, 1.95564210e-01f, 8.61772373e-02f, -2.96980977e-01f, 1.30472958e-01f, 1.96749300e-01f, -1.65108308e-01f, -1.46040902e-01f, 2.87543293e-02f,
  -9.19258296e-02f, -1.71547160e-02f, 1.33282378e-01f, 9.01115164e-02f, 9.15574655e-03f, 1.19635694e-01f, -1.61621332e-01f, 1.29517272e-01f, 5.73006794e-02f, 1.24186032e-01f,
  1.27953524e-02f, 3.35377418e-02f, 5.60759343e-02f, -3.02453220e-01f, 1.08875833e-01f, -2.07302183e-01f, -9.35754180e-02f, -2.67497391e-01f, 1.35366336e-01f, 2.71123886e-01f,
  2.98188269e-01f, -8.48734975e-02f, -6.74425885e-02f, -3.37199211e-01f, 1.61553591e-01f, 2.26943210e-01f, -3.99958313e-01f, 5.76944530e-01f, 1.78534627e-01f, 1.84505537e-01f,
  -2.88651407e-01f, -6.28005505e-01f, -7.35489726e-01f, -2.84589618e-01f, -1.54172210e-02f, 1.72813892e-01f, -3.36654559e-02f, -5.22992492e-01f, 2.54532814e-01f, 1.60909370e-02f,
  1.00949630e-01f, -8.63097548e-01f, -7.42419600e-01f, 2.29484811e-02f, 2.87090927e-01f, 3.97701561e-01f, -1.05597507e-02f, -6.04809761e-01f, -1.44637153e-01f, -4.40918326e-01f,
  4.56106216e-01f, 2.50895619e-01f, -6.88668340e-02f, 1.51740998e-01f, 5.42173199e-02f, -1.08518682e-01f, 9.70916077e-02f, -2.98141658e-01f, 2.94394404e-01f, -8.09597552e-01f,
  -4.84568596e-01f, 1.06429845e-01f, 1.54409468e-01f, -2.40267873e-01f, -1.08215977e-02f, -5.00676155e-01f, 6.50672242e-02f, -2.88940102e-01f, 4.72810060e-01f, -8.05369690e-02f,
  -5.46883464e-01f, 4.81243432e-01f, 4.56337035e-01f, -2.33372197e-01f, -2.28915364e-01f, -5.60331464e-01f, -2.29484797e-01f, 1.93693161e-01f, -1.08935192e-01f, 4.74912561e-02f,
  -1.36557799e-02f, -8.49279836e-02f, -4.37485546e-01f, 2.75155097e-01f, 1.84502378e-01f, 4.45415527e-01f, -7.27092326e-02f, 4.78405237e-01f, -2.03175992e-01f, -6.50639474e-01f,
  -2.34312624e-01f, -7.32453018e-02f, -4.81367528e-01f, -2.13404059e-01f, 3.64494808e-02f, 1.55114293e-01f, 2.25385964e-01f, 4.99838963e-02f, -1.80722162e-01f, 1.99376255e-01f,
  8.19902495e-02f, -3.69907528e-01f, -3.81434619e-01f, -4.62962270e-01f, -4.22069609e-01f, 6.27581775e-03f, 2.38182303e-02f, -2.31680777e-02f, -2.08044142e-01f, 3.17649662e-01f,
  3.51025850e-01f, -3.37556571e-01f, -1.63285941e-01f, -3.90411377e-01f, 1.03485763e-01f, -6.12861097e-01f, -9.37883928e-02f, 1.77689921e-02f, 1.34109825e-01f, -1.26285791e-01f,
  3.72433543e-01f, -2.81861126e-01f, -1.44061223e-01f, -4.62020189e-01f, -1.14430934e-01f, 3.05617205e-03f, 9.64187831e-02f, 7.71985995e-03f, -1.27626592e-02f, -1.80913415e-02f,
  1.31420875e-02f, 9.44505632e-02f, 6.25441596e-02f, 4.11963835e-03f, 4.73221391e-02f, -3.80928554e-02f, 8.32079276e-02f, 1.24485478e-01f, 7.35983178e-02f, 9.73670334e-02f,
  2.49476224e-01f, -4.40393239e-01f, 2.51160920e-01f, -7.01640546e-02f, -2.34618902e-01f, -1.97451353e-01f, -1.17936984e-01f, 2.87280351e-01f, -2.35948846e-01f, 2.85284042e-01f,
  -2.43560612e-01f, 5.43746017e-02f, -3.44455242e-01f, -2.39323378e-01f, -1.70905054e-01f, 3.67326468e-01f, -7.62851769e-03f, 1.40133724e-01f, 4.41400915e-01f, -2.57637203e-01f,
  1.56746000e-01f, -2.43241951e-01f, 1.85394958e-01f, -2.50478774e-01f, -1.14523880e-01f, -3.52000713e-01f, -3.99887055e-01f, -3.62405241e-01f, 1.78256854e-01f, -2.09055066e-01f,
  5.03822327e-01f, -5.71645081e-01f, 4.94837672e-01f, -2.24914551e-01f, -9.22609344e-02f, -3.55991662e-01f, -8.63524433e-03f, -1.61602870e-02f, 4.99300838e-01f, 1.22799329e-01f,
  1.06188804e-01f, -1.58926666e-01f, 1.58836037e-01f, -5.56092188e-02f, 2.34436803e-02f, -3.04193854e-01f, 2.87265956e-01f, -1.46285683e-01f, 1.46184685e-02f, 1.69633016e-01f,
  -3.24323960e-02f, -2.58625299e-01f, 4.74971114e-03f, 4.86459613e-01f, -1.35353535e-01f, 8.47287104e-02f, -3.49120200e-01f, -2.60852009e-01f, 1.82672501e-01f, -7.52094900e-04f,
  -1.61700562e-01f, -3.10827762e-01f, -2.92833298e-01f, 4.11375761e-01f, -1.81026757e-01f, -1.57894954e-01f, -1.64031431e-01f, -1.78092718e-01f, -1.28860295e-01f, 1.38103813e-01f,
  -2.82132983e-01f, -1.61815271e-01f, -1.49014831e-01f, 1.85490310e-01f, 4.82045710e-02f, 1.24390423e-03f, -2.52419025e-01f, -1.79868385e-01f, -2.35606268e-01f, -1.55707091e-01f,
  3.42120290e-01f, -3.34618390e-01f, -8.76369476e-02f, -1.12253986e-01f, -2.82901078e-01f, -4.50831838e-02f, -1.93444222e-01f, 5.50492443e-02f, -3.80297661e-01f, -2.56765276e-01f,
  -3.26663852e-01f, -1.56812683e-01f, 1.03063352e-01f, 2.88480759e-01f, -4.36386287e-01f, -2.71852911e-02f, 1.48568943e-01f, 1.75904274e-01f, -3.68849665e-01f, 1.53653905e-01f,
  -1.68376029e-01f, 6.20107390e-02f, -1.98166072e-01f, -2.46992067e-01f, 3.73203233e-02f, -8.32159072e-02f, -2.59093851e-01f, -7.43423328e-02f, 2.77350724e-01f, -1.27173156e-01f,
  -1.41224980e-01f, 5.06845415e-01f, 8.32464769e-02f, -1.08885698e-01f, -1.44865736e-02f, -3.71531919e-02f, -1.24799013e-01f, -5.57375811e-02f, 2.88430620e-02f, -1.29753113e-01f,
  -4.47569136e-03f, -1.62998820e-03f, -1.13930209e-02f, -1.25616714e-01f, 4.43561152e-02f, -5.06530553e-02f, -3.96084636e-01f, 1.61764070e-01f, 1.14257552e-01f, 1.74461201e-01f,
  -1.18551694e-01f, 1.37479931e-01f, 3.10097992e-01f, 1.90136358e-02f, 9.54371244e-02f, -2.79682964e-01f, -2.08776578e-01f, -7.99990967e-02f, -3.41606408e-01f, -9.75783840e-02f,
  -3.26023251e-01f, -1.01913296e-01f, -1.66901350e-01f, 6.54766709e-02f, -4.13810581e-01f, -4.45309877e-01f, 2.70723134e-01f, 4.22256947e-01f, -2.62928218e-01f, -3.41681361e-01f,
  -3.37799221e-01f, -3.36502612e-01f, -9.00937468e-02f, 2.09692299e-01f, -3.19486409e-01f, -1.76842213e-01f, -3.03880394e-01f, 2.33399779e-01f, 4.96671408e-01f, -5.61848104e-01f,
  4.94414605e-02f, -1.96400538e-01f, -5.75491548e-01f, 1.99849457e-01f, -4.21087354e-01f, 6.04585605e-03f, 2.53867328e-01f, 2.09559038e-01f, 8.21355209e-02f, -1.62772119e-01f,
  -2.40470633e-01f, 4.42220271e-01f, -3.91708106e-01f, 1.58989698e-01f, -3.44843000e-01f, 1.87926963e-01f, -5.56948721e-01f, -4.34061110e-01f, 1.99292466e-01f, -1.86268315e-01f,
  3.31297666e-01f, -3.74641120e-01f, -1.66646063e-01f, 4.97159600e-01f, 1.44689262e-01f, -6.89486802e-01f, -5.99793553e-01f, -3.41123968e-01f, -1.04657754e-01f, 1.73057109e-01f,
  -1.12943187e-01f, -6.15169341e-03f, 2.27813691e-01f, -1.79692149e-01f, 6.96234852e-02f, -3.13079685e-01f, 4.36505526e-01f, -3.96186680e-01f, 1.21763125e-01f, -3.58546942e-01f,
  1.13954507e-01f, -6.31862462e-01f, -1.61328912e-01f, -1.41618282e-01f, -2.46530250e-01f, 4.05656636e-01f, -2.03731190e-02f, 3.14511240e-01f, 1.74051836e-01f, -5.24697006e-01f,
  -3.38076614e-02f, 4.46442552e-02f, -5.94346710e-02f, -6.22180343e-01f, 4.24765378e-01f, -1.26227468e-01f, 3.79857242e-01f, -4.27920252e-01f, -5.83743341e-02f, 1.90414831e-01f,
  3.88021022e-01f, -1.78868607e-01f, 6.23744130e-02f, -2.78672129e-02f, 1.96136624e-01f, -5.21085799e-01f, 1.68399885e-02f, -3.18970144e-01f, -1.15968082e-02f, 1.25492126e-01f,
  -4.37876642e-01f, -4.85259771e-01f, -1.26142874e-01f, -1.72043577e-01f, -3.16847205e-01f, -5.45838289e-02f, -3.18682007e-02f, 1.35040745e-01f, 5.75475335e-01f, -1.09873645e-01f,
  -5.87439649e-02f, -1.61264926e-01f, -1.45332525e-02f, -1.05193034e-01f, 1.81498274e-01f, -6.54463023e-02f, -1.48510948e-01f, 3.75324227e-02f, 8.80874768e-02f, -1.11696713e-01f,
  -2.96343723e-03f, -2.23770797e-01f, 9.00692344e-02f, 2.70993281e-02f, 3.92397866e-02f, -2.08034575e-01f, 2.33273640e-01f, 1.98542610e-01f, 8.34681988e-02f, -8.26971903e-02f,
  -1.50112594e-02f, 1.71535164e-01f, -9.57522243e-02f, -1.41491756e-01f, -2.38715280e-02f, 3.88533205e-01f, 1.37421176e-01f, 4.81621213e-02f, -2.47405395e-02f, 1.67049557e-01f,
  1.85550600e-01f, -1.11761138e-01f, 1.01114064e-01f, -1.00598618e-01f, 1.60538435e-01f, 1.34448156e-01f, -7.52074495e-02f, 3.39926034e-01f, -5.34099117e-02f, 2.31781557e-01f,
  -1.29881397e-01f, 2.74719149e-01f, -2.85893649e-01f, -2.79656380e-01f, -7.23222420e-02f, -2.56347433e-02f, -7.12065756e-01f, 1.82267815e-01f, 1.98082685e-01f, -3.44351828e-01f,
  -9.34212178e-04f, 1.34663299e-01f, -1.83103040e-01f, 2.43847415e-01f, -3.99980456e-01f, 1.42407641e-01f, 1.70186162e-01f, -7.51176178e-02f, -2.09835563e-02f, 6.56776354e-02f,
  7.02562109e-02f, 2.94029325e-01f, -2.37927049e-01f, 2.59341300e-01f, -9.55883116e-02f, 3.37370834e-03f, -9.39599499e-02f, -2.32694119e-01f, 9.21948925e-02f, 5.38740337e-01f,
  9.63140801e-02f, -5.34598112e-01f, -2.96485960e-01f, 5.00629656e-02f, 4.10280526e-01f, -6.84370548e-02f, -1.01198196e-01f, 3.05067122e-01f, -1.94533408e-01f, -8.44711736e-02f,
  -1.35923307e-02f, -1.35126978e-01f, 5.82000706e-03f, -7.62443304e-01f, -7.06883729e-01f, 1.98529258e-01f, 4.26106513e-01f, 7.55289793e-02f, -7.94652328e-02f, -1.86166652e-02f,
  -5.27351022e-01f, 7.00466260e-02f, -1.43571973e-01f, 9.73530859e-02f, 5.58830388e-02f, -1.01652898e-01f, -9.95987058e-02f, -9.37466249e-02f, 8.46712850e-03f, 3.39936494e-04f,
  -1.31219253e-01f, -8.72866809e-02f, 6.93451613e-02f, -2.65229493e-01f, -3.50412458e-01f, 3.45982790e-01f, 2.31521353e-01f, -5.41096516e-02f, -5.85868120e-01f, -2.38793820e-01f,
  -2.39013001e-01f, -1.73004746e-01f, -2.05350548e-01f, -2.42223561e-01f, -3.03388178e-01f, -2.60280639e-01f, -6.02528989e-01f, 2.17158616e-01f, -2.89283395e-01f, 4.09688443e-01f,
  -1.90028012e-01f, 7.27287531e-02f, -5.75629510e-02f, -1.46853358e-01f, -4.59615171e-01f, 1.35403857e-01f, -3.65043163e-01f, 1.83098584e-01f, 1.34785203e-02f, -3.72866541e-01f,
  2.47057211e-02f, 7.36024082e-02f, 5.12854457e-02f, 1.50734469e-01f, 7.39938840e-02f, 1.75066125e-02f, 6.10539131e-02f, -1.29977688e-02f, 1.83381751e-01f, 1.65911436e-01f,
  1.17914408e-01f, 1.50905438e-02f, 1.15136832e-01f, -2.19149485e-01f, 4.21841368e-02f, -1.82206064e-01f, -3.52638096e-01f, -2.37355664e-01f, -2.02284217e-01f, 2.29454517e-01f,
  1.85096547e-01f, -2.77335718e-02f, 1.66893974e-01f, -1.34417325e-01f, 1.43499831e-02f, -5.84593117e-01f, -6.12337478e-02f, 2.08220482e-01f, -1.84235442e-02f, -3.13146263e-02f,
  -9.66475345e-03f, -8.62986147e-02f, -4.13965732e-01f, -6.92486018e-02f, 5.52124679e-01f, -9.62285772e-02f, 2.17993408e-01f, -9.96745527e-02f, -1.87459841e-01f, 2.03845873e-01f,
  1.51548430e-01f, -4.65396121e-02f, -2.80776471e-01f, -1.14026349e-02f, -3.15727651e-01f, 1.23428404e-01f, -7.42562354e-01f, 1.28723085e-01f, -7.75852501e-02f, 3.08191776e-01f,
  1.32279441e-01f, 5.99452198e-01f, -4.20498252e-01f, -9.35027599e-02f, -3.86872858e-01f, -4.25613895e-02f, -2.33791992e-01f, -4.55394953e-01f, 8.11000541e-02f, 1.65265039e-01f,
  -6.67072535e-02f, 3.76976460e-01f, 5.34065962e-01f, -4.73623514e-01f, -2.93308109e-01f, 2.29097232e-01f, -1.68453962e-01f, -3.17197978e-01f, 3.64150777e-02f, -3.33438545e-01f,
  -3.97359967e-01f, -7.55973533e-02f, -5.02645552e-01f, 1.00749552e-01f, -8.04791525e-02f, -7.21231103e-01f, 4.24281538e-01f, -4.91351560e-02f, 2.82972436e-02f, -2.32799232e-01f,
  -2.57589906e-01f, -1.76973909e-01f, -1.65717863e-02f, -1.20506614e-01f, 8.07910115e-02f, 3.83799165e-01f, 1.15970239e-01f, -2.34594882e-01f, -2.89837539e-01f, -2.47801602e-01f,
  5.76722682e-01f, -6.78699732e-01f, -2.71629512e-01f, -1.93484887e-01f, -4.39789146e-02f, 5.88151336e-01f, -7.20314011e-02f, -5.37779136e-03f, 3.85887809e-02f, 3.26526493e-01f,
  -2.79262722e-01f, -9.81687680e-02f, 5.99662960e-02f, 3.07058007e-01f, -8.59579518e-02f, 3.83332074e-02f, -3.47536474e-01f, -1.98107183e-01f, 4.23574179e-01f, 2.94143856e-01f,
  -3.85651559e-01f, 9.22779590e-02f, 1.46103516e-01f, 1.24799170e-01f, -2.59966910e-01f, -1.11439161e-01f, -2.32972596e-02f, -4.89460602e-02f, 2.80711442e-01f, -2.82629263e-02f,
  3.61863256e-01f, 1.15887150e-01f, -3.28281373e-01f, -2.52083316e-03f, -3.11188012e-01f, -4.05987948e-01f, -3.88354585e-02f, -2.67272323e-01f, 1.28390864e-01f, 7.70718977e-02f,
  -1.58130944e-01f, 4.67136540e-02f, 5.76192029e-02f, -1.95913613e-02f, 4.71179513e-03f, 1.10208616e-01f, -1.13428412e-02f, 1.11859851e-01f, 5.07535152e-02f, -2.07110792e-01f,
  2.04766363e-01f, -2.29247883e-01f, -1.45460740e-01f, 2.20804393e-01f, -1.14512838e-01f, -1.87324271e-01f, 9.97470692e-02f, -2.21493155e-01f, -6.53412491e-02f, 2.14439314e-02f,
  -6.66029099e-03f, 1.01944596e-01f, -2.84542829e-01f, -7.11164996e-02f, 2.09771097e-01f, -1.34371504e-01f, -2.03301877e-01f, -3.74897242e-01f, -7.14587569e-02f, 1.42826632e-01f,
  -2.39977375e-01f, -2.74608701e-01f, -2.45459691e-01f, -2.82827288e-01f, 2.23868322e-02f, -4.74547088e-01f, -1.40438646e-01f, -3.81863087e-01f, -2.35282645e-01f, -2.57234663e-01f,
  -9.89072323e-02f, -5.49952149e-01f, -5.41732252e-01f, 9.74829122e-02f, -3.63047153e-01f, -3.96733165e-01f, -1.17692359e-01f, -1.22966543e-01f, 4.45415080e-01f, 2.93089211e-01f,
  -3.49989057e-01f, -9.76599976e-02f, -1.59347594e-01f, 2.07726136e-01f, -3.20154756e-01f, 3.75989079e-01f, 2.19506115e-01f, -2.00668111e-01f, -3.77829075e-01f, -2.36833096e-01f,
  -2.77242005e-01f, -2.80931592e-01f, -8.16291198e-02f, -2.89305389e-01f, -2.33645841e-01f, -4.22552712e-02f, 2.41263658e-01f, 3.36348057e-01f, -1.08560987e-01f, 9.47619528e-02f,
  2.99158514e-01f, -5.22601545e-01f, -1.35123119e-01f, 3.34311724e-02f, -8.48413184e-02f, 2.52157748e-01f, -1.35366261e-01f, 2.78297544e-01f, -5.48249304e-01f, 2.22027019e-01f,
  1.19811036e-02f, 9.57967713e-02f, -2.33080730e-01f, -6.75854683e-02f, -6.24275386e-01f, 2.32329950e-01f, 4.15478796e-01f, -2.84323931e-01f, -6.84124291e-01f, 9.93836746e-02f,
  -1.77619860e-01f, -3.04090697e-02f, 5.91405153e-01f, 2.92150855e-01f, -2.22954720e-01f, -1.54585764e-01f, -3.49480391e-01f, -9.18999538e-02f, -2.15876326e-01f, 1.95971340e-01f,
  -1.61487669e-01f, -2.04853848e-01f, -5.07521272e-01f, 1.85709044e-01f, -5.42518497e-01f, -5.33914089e-01f, -1.22630320e-01f, -7.11201191e-01f, -3.97759706e-01f, -1.42720550e-01f,
  -6.42034337e-02f, 3.52858901e-01f, 1.50318325e-01f, -4.01313454e-01f, -2.48681858e-01f, 3.78134340e-01f, -4.02891040e-01f, -8.45147595e-02f, 3.41829360e-01f, -3.92246008e-01f,
  -9.66483802e-02f, -6.92056417e-01f, -2.08775908e-01f, 3.03917319e-01f, 7.92095717e-03f, 3.30814511e-01f, -2.10375652e-01f, -8.06864817e-03f, -2.57460654e-01f, -4.33163717e-02f,
  -1.52003378e-01f, -9.17650759e-02f, -2.62243692e-02f, -2.70360126e-03f, -1.38587341e-01f, 4.41396758e-02f, -1.26026822e-02f, 3.55936289e-02f, -2.60958094e-02f, 9.84962434e-02f,
  -1.32187113e-01f, 1.63643464e-01f, -1.32460684e-01f, 2.12040335e-01f, 1.19361192e-01f, 8.94723460e-02f, -1.11567192e-01f, 1.21382758e-01f, -1.38813078e-01f, -1.21787496e-01f,
  2.24767223e-01f, 3.83217454e-01f, 6.58077598e-02f, -1.67449236e-01f, -1.69870734e-01f, -4.21988338e-01f, -5.69433980e-02f, -4.53344077e-01f, -8.75011533e-02f, 4.08667296e-01f,
  3.82642627e-01f, -2.42983222e-01f, -7.62037262e-02f, -1.96736038e-01f, -3.74483578e-02f, 2.52876729e-01f, -2.38734372e-02f, -1.59432217e-01f, -8.94426033e-02f, -2.83264577e-01f,
  4.53655422e-01f, 8.89087170e-02f, -2.34549940e-01f, -5.35555363e-01f, -1.75121561e-01f, 3.83803517e-01f, -3.50562111e-02f, 3.58131289e-01f, -2.98598796e-01f, -1.33825272e-01f,
  8.29434916e-02f, -2.07726404e-01f, 9.30337757e-02f, 2.71409065e-01f, 9.68791693e-02f, -2.26569742e-01f, -2.59897411e-01f, 3.63351554e-01f, 3.62504870e-01f, 1.27392232e-01f,
  1.62049502e-01f, -3.20698202e-01f, -1.10648505e-01f, 1.05330609e-01f, -3.21357012e-01f, -3.17319244e-01f, -1.75526559e-01f, 2.44219676e-01f, -3.63155752e-01f, -2.13934794e-01f,
  -2.15069294e-01f, 1.50209472e-01f, -2.10139558e-01f, 2.32151132e-02f, -1.34249195e-01f, 7.49016777e-02f, -1.82666704e-01f, -3.37589234e-01f, 1.17540538e-01f, -1.63867638e-01f,
  -1.28494203e-01f, -6.74318969e-02f, 1.59605369e-01f, -3.92662704e-01f, -2.00403288e-01f, -2.05519199e-01f, 2.54542977e-01f, 2.60441333e-01f, 1.67515650e-01f, 2.03123078e-01f,
  -5.18548250e-01f, -3.58647615e-01f, -4.07506257e-01f, -1.33351862e-01f, 1.75501388e-02f, -3.52038354e-01f, 2.00027123e-01f, -2.43319631e-01f, -3.83958310e-01f, -3.38344008e-01f,
  -1.95718750e-01f, 1.63501292e-01f, 2.40242824e-01f, 2.58068949e-01f, -2.19642758e-01f, -3.65631640e-01f, 2.55351305e-01f, -1.03243910e-01f, -2.24530473e-01f, -1.93840474e-01f,
  8.33645537e-02f, -2.12748095e-01f, -1.21027008e-01f, -4.43893492e-01f, -2.06773192e-01f, -2.08937094e-01f, -1.98163867e-01f, 1.21227242e-01f, -2.10938960e-01f, -1.75066307e-01f,
  -2.60680854e-01f, -3.72442394e-01f, 9.28426459e-02f, 1.49516255e-01f, 1.13649100e-01f, 1.12483129e-01f, 1.28867194e-01f, 2.93915533e-02f, -1.19680949e-01f, 2.14199871e-01f,
  3.78636122e-02f, -1.01123275e-02f, 9.17961895e-02f, 1.80605546e-01f, 6.53830124e-03f, 4.49033715e-02f, -1.63134392e-02f, 1.10628111e-02f, -4.95448112e-02f, -3.97289060e-02f,
  3.73530924e-01f, 3.56780469e-01f, 9.26918313e-02f, -1.69445753e-01f, 1.71644270e-01f, -2.00845614e-01f, 1.76834092e-01f, -2.25318953e-01f, -2.51138955e-01f, -7.74997547e-02f,
  -1.48892105e-01f, -4.66055661e-01f, -9.48194489e-02f, -6.08163059e-01f, 3.34195383e-02f, 7.02208132e-02f, -3.26516449e-01f, 6.29488453e-02f, 2.54910290e-01f, -4.81225640e-01f,
  3.05042595e-01f, -1.93986312e-01f, 4.18024570e-01f, -2.24240765e-01f, -1.68114126e-01f, 6.41952932e-01f, 3.06757361e-01f, -3.13680172e-01f, 1.29591927e-01f, -3.89121771e-02f,
  -1.94472149e-01f, 6.52852505e-02f, 6.54516339e-01f, -3.15263450e-01f, -2.86375463e-01f, -2.84697674e-02f, -4.47916836e-02f, -3.75926137e-01f, -3.26930374e-01f, -1.17506497e-01f,
  1.36104316e-01f, 3.02791476e-01f, -2.16531724e-01f, -4.73755091e-01f, 5.04589319e-01f, -1.30583346e-01f, 5.35182655e-02f, 1.35369062e-01f, -1.63341627e-01f, 5.50254345e-01f,
  -3.25719506e-01f, -9.91578028e-02f, 2.13596836e-01f, -2.06010297e-01f, -2.46494159e-01f, -3.85001838e-01f, -2.31113642e-01f, -2.82353312e-01f, -3.49391699e-01f, -9.42332968e-02f,
  2.31183052e-01f, 8.64426643e-02f, -3.49695027e-01f, -9.01602209e-03f, -2.18181968e-01f, 2.09768683e-01f, -8.74240994e-02f, -3.91510695e-01f, -3.22209150e-01f, -3.92212152e-01f,
  -4.18005943e-01f, -5.51791824e-02f, -1.60300378e-02f, -3.78559023e-01f, -2.10029051e-01f, -1.27764672e-01f, 4.33364809e-01f, 1.50895864e-01f, -1.54990181e-01f, -2.60482311e-01f,
  1.27932310e-01f, 5.97512759e-02f, -1.81028426e-01f, 6.62723109e-02f, -4.61987555e-01f, 1.78875797e-03f, 2.32471257e-01f, -1.06173828e-01f, -1.92262590e-01f, -3.00147414e-01f,
  4.71763968e-01f, -2.03567460e-01f, 8.11443478e-02f, -1.83908403e-01f, -3.81962687e-01f, -1.08845428e-01f, -1.57338679e-01f, -1.07758619e-01f, -7.14694336e-02f, -1.27349362e-01f,
  1.68860659e-01f, -3.03701222e-01f, 1.14523634e-01f, -3.52314353e-01f, -2.72837698e-01f, 2.32035935e-01f, -2.63000101e-01f, -1.26496851e-01f, -1.31581813e-01f, -2.17611760e-01f,
  -2.19598591e-01f, 3.70952189e-02f, 4.59475294e-02f, -1.39119789e-01f, -2.90460344e-02f, 6.31149411e-02f, 1.40076289e-02f, 1.32295713e-01f, -4.03582864e-02f, -1.08079180e-01f,
  4.11011241e-02f, -8.50167722e-02f, -9.07613039e-02f, -1.46062732e-01f, 6.73986226e-02f, -8.57021064e-02f, -1.96663573e-01f, 1.92809105e-01f, -2.04503596e-01f, -3.85035314e-02f,
  -1.62222251e-01f, 2.80588418e-01f, -4.76827137e-02f, 1.39616027e-01f, -3.82121876e-02f, 1.09005719e-01f, 1.47924677e-01f, 2.22017482e-01f, -2.67516047e-01f, 2.47462913e-01f,
  1.85382031e-02f, -4.65792596e-01f, -3.66499126e-01f, 3.51900727e-01f, 6.48619384e-02f, -5.83539724e-01f, 2.44201086e-02f, 5.96181929e-01f, -3.94867182e-01f, -3.65592688e-02f,
  -2.01659679e-01f, -1.55602410e-01f, 1.59020409e-01f, -3.88750374e-01f, -2.88797081e-01f, -2.03211159e-02f, -1.12556316e-01f, -3.82701606e-02f, -4.58586127e-01f, -3.89261395e-01f,
  -2.67015576e-01f, -7.20121145e-01f, 2.18467832e-01f, -4.17044699e-01f, -4.43944395e-01f, 7.54735023e-02f, -3.11776489e-01f, -2.92468160e-01f, -2.59272814e-01f, -5.70243657e-01f,
  -4.19044554e-01f, -4.44244444e-01f, -3.07442963e-01f, 2.31433988e-01f, -3.03378969e-01f, 1.78022131e-01f, -4.61923182e-02f, -2.89666653e-01f, -1.74503420e-02f, 1.99692830e-01f,
  -2.39422128e-01f, -4.18913253e-02f, -3.51211280e-01f, 2.36595809e-01f, 1.67076781e-01f, -5.69574311e-02f, -3.60545740e-02f, 2.29567260e-01f, -2.34253243e-01f, 1.09945424e-01f,
  -2.08466917e-01f, -2.13172454e-02f, 4.28587109e-01f, 3.34874928e-01f, -4.39526707e-01f, 1.23346798e-01f, -4.27710503e-01f, 2.36741349e-01f, -1.32982343e-01f, 7.16146305e-02f,
  -8.46442655e-02f, -6.59307897e-01f, 4.26660150e-01f, -3.29685539e-01f, -1.60336688e-01f, -1.57191232e-01f, -4.66712058e-01f, -2.52650172e-01f, 4.18464839e-02f, 2.08844498e-01f,
  -1.04995854e-01f, -2.02331066e-01f, -2.96660930e-01f, 2.91038752e-01f, -2.73334831e-01f, 1.95250690e-01f, 4.17207092e-01f, 1.78950764e-02f, -3.98882031e-02f, 2.55563915e-01f,
  -1.94766268e-01f, 4.20779884e-01f, 1.81479469e-01f, -3.71039122e-01f, -2.86684513e-01f, 7.21051022e-02f, 2.66519904e-01f, -6.83931932e-02f, 4.07377869e-01f, 3.24138969e-01f,
  3.49935740e-01f, 1.02811597e-01f, -2.58090645e-02f, -1.89596593e-01f, -5.25907278e-01f, 4.69327480e-01f, -2.71908432e-01f, -5.38354032e-02f, 6.62276521e-02f, -6.24296106e-02f,
  1.18763879e-01f, -5.06267138e-02f, 4.51820046e-02f, 5.41672809e-03f, 1.07091308e-01f, 6.27594218e-02f, 1.16012217e-02f, 3.67699713e-02f, 1.02814764e-01f, 2.52120905e-02f,
  -7.35622197e-02f, -1.76391229e-01f, -3.34813714e-01f, -2.13472560e-01f, 8.15360621e-02f, -2.06299767e-01f, 2.39817381e-01f, -1.47548184e-01f, 2.54568666e-01f, 1.11298881e-01f,
  -2.08976910e-01f, -1.40407886e-02f, -7.61564896e-02f, -1.56057283e-01f, -3.14376503e-01f, -3.40713143e-01f, -1.31577834e-01f, -5.80927253e-01f, -3.75128329e-01f, -3.64541173e-01f,
  -4.34784353e-01f, -9.79479924e-02f, -3.08726966e-01f, -2.37061843e-01f, -9.48041379e-02f, 3.90315354e-01f, -4.14564073e-01f, 1.57856852e-01f, -3.76937985e-01f, 1.15541622e-01f,
  -3.06671381e-01f, -3.45115721e-01f, 2.14740738e-01f, -3.13161999e-01f, -8.21473822e-02f, -2.86385268e-01f, 9.16156545e-02f, -1.72101215e-01f, -4.87343408e-02f, 2.70986795e-01f,
  -2.88312852e-01f, -2.03755602e-01f, -6.00500926e-02f, -1.04749203e-01f, -5.07621169e-01f, -2.66260654e-01f, 1.11878835e-01f, 1.08045749e-01f, -2.62348890e-01f, 2.96267062e-01f,
  2.28401482e-01f, 3.34742814e-01f, -2.24360883e-01f, -8.70916024e-02f, -1.86415255e-01f, -3.06596220e-01f, 3.21392119e-01f, -3.14567566e-01f, -4.89676781e-02f, 1.91401802e-02f,
  2.46039003e-01f, 3.55591536e-01f, -2.42590740e-01f, -2.62947261e-01f, -2.35836282e-01f, -2.63243705e-01f, 2.50941552e-02f, -3.04229915e-01f, 4.46540296e-01f, 6.00185320e-02f,
  -3.57866675e-01f, -1.12877980e-01f, 4.99957234e-01f, -1.77166894e-01f, 8.22897851e-02f, -2.53654420e-01f, 2.35297114e-01f, -1.00610800e-01f, -1.79648489e-01f, 1.18812934e-01f,
  -3.45726311e-01f, -3.47352892e-01f, 2.72549480e-01f, 4.32981044e-01f, -2.39238217e-01f, 1.80044577e-01f, -2.75824755e-01f, -2.83652288e-03f, -1.96287304e-01f, -3.86203259e-01f,
  -5.02948463e-01f, -1.89387336e-01f, 5.22550195e-02f, 2.99512595e-01f, 2.51675844e-01f, 3.89694333e-01f, 2.24428892e-01f, -2.96549559e-01f, -2.98911244e-01f, -8.24269801e-02f,
  -2.83597916e-01f, 3.49934101e-01f, -7.78803155e-02f, -6.40564859e-02f, 1.44041449e-01f, -2.19244495e-01f, 2.37434983e-01f, -4.40713018e-01f, 5.33620752e-02f, -5.06428182e-01f,
  -3.35554659e-01f, 3.21245253e-01f, 4.52863097e-01f, -5.13520896e-01f, 1.40186101e-01f, -1.21034116e-01f, -2.58983463e-01f, -1.80670805e-02f, 2.04276174e-01f, -1.25363674e-02f,
  7.19470456e-02f, -8.82119089e-02f, 3.95436101e-02f, 4.81832288e-02f, 1.16637215e-01f, 2.77128182e-02f, -6.60940036e-02f, 2.23254282e-02f, -6.28394708e-02f, 1.70526106e-03f,
  -1.09895132e-01f, 2.57642150e-01f, -8.98520723e-02f, 1.21971175e-01f, -2.53588170e-01f, -1.22248858e-01f, 1.25377834e-01f, -3.70033197e-02f, -2.14426309e-01f, -3.29333097e-01f,
  2.71910936e-01f, 2.34040488e-02f, 1.76094547e-01f, -2.16437057e-01f, 1.58184290e-01f, -1.64356053e-01f, -1.19549237e-01f, -2.85244673e-01f, 1.49300024e-01f, -3.45671207e-01f,
  -1.48580536e-01f, 5.22313595e-01f, -2.49699399e-01f, 9.06212777e-02f, -5.44682562e-01f, -2.48592049e-01f, -2.27784291e-01f, -1.14114724e-01f, 4.94034141e-02f, 3.37128520e-01f,
  -2.86212593e-01f, 4.76382017e-01f, -1.42426401e-01f, 8.70659277e-02f, -2.10257247e-02f, -3.03408146e-01f, 2.50777811e-01f, -9.33379009e-02f, -3.04201037e-01f, -7.62512609e-02f,
  -2.47132644e-01f, 1.82252541e-01f, 4.42226976e-01f, 2.93577164e-01f, -2.63038635e-01f, 1.65521055e-01f, -3.67292255e-01f, -2.17189461e-01f, -5.13574302e-01f, -3.88876170e-01f,
  -3.54537547e-01f, -4.26813900e-01f, 2.65258282e-01f, 3.35254729e-01f, -1.41385123e-01f, -2.83091366e-01f, 3.81464839e-01f, 4.18748170e-01f, 1.74912706e-01f, -3.93525958e-01f,
  1.45344079e-01f, -3.26323271e-01f, 1.13331221e-01f, 3.74808669e-01f, 7.36702979e-02f, -5.18287361e-01f, 1.72594309e-01f, -3.86759728e-01f, -2.80698001e-01f, 7.59119466e-02f,
  -9.91657376e-02f, 9.43471268e-02f, -3.31932992e-01f, -1.82863139e-02f, 1.20567847e-02f, -9.59301516e-02f, 2.72766113e-01f, -5.47506325e-02f, -3.77072662e-01f, 3.70055050e-01f,
  -1.12421019e-03f, -1.78011358e-02f, -2.84102969e-02f, -4.23505276e-01f, 3.49019080e-01f, 4.89803776e-02f, 1.95301235e-01f, 7.74426432e-03f, -1.58991128e-01f, -2.90581763e-01f,
  -1.98294893e-01f, -5.03485324e-03f, -2.85155922e-01f, -2.20133215e-01f, -3.07980001e-01f, -4.51653838e-01f, -2.35412583e-01f, -1.51135340e-01f, 5.74270682e-03f, -1.45065710e-01f,
  -1.24335572e-01f, 1.23587132e-01f, 9.70435292e-02f, -2.31265232e-01f, -8.09093490e-02f, -3.01663041e-01f, -7.41418600e-02f, 6.33733049e-02f, -4.69723612e-01f, -3.12877148e-01f,
  1.02614291e-01f, 2.03075781e-01f, 5.13645053e-01f, -4.16139245e-01f, -5.74301668e-02f, -1.82659954e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -1.17565192e-01f, 1.30844221e-01f, 1.06255017e-01f, -8.31201114e-03f, -1.00368723e-01f, 2.70095002e-02f, -3.25524546e-02f, -5.39008379e-02f, 1.44586759e-02f, -4.63472381e-02f,
  -9.11116134e-04f, 4.39143740e-03f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 12, 104
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        128, 12
    );
    }
    