/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 128 (x1)
    * Saída: 12
    * Buffer Máx: 128
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 128;
    const int FAN_MAX_BUFFER_SIZE = 128;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 51 x 120)
const int L0_fan_Wp_rows = 51;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  1.70201167e-01f, -2.93932736e-01f, 1.33311182e-01f, 1.32752985e-01f, 3.01328540e-01f, 1.84215292e-01f, 9.40311030e-02f, 2.16903254e-01f, 1.58108130e-01f, -2.24019781e-01f,
  1.11954629e-01f, -1.88256562e-01f, -1.13802515e-01f, 2.31439304e-02f, 1.73261806e-01f, -6.31835908e-02f, 1.69107765e-01f, -2.71592680e-02f, 3.52184698e-02f, 1.40177190e-01f,
  9.37808082e-02f, 8.99389982e-02f, 6.31003529e-02f, -5.83303859e-03f, 1.48512453e-01f, -1.97823513e-02f, 2.20631976e-02f, -5.55470996e-02f, 4.97895703e-02f, -2.62697693e-02f,
  -1.58184599e-02f, -5.91807216e-02f, -1.01920413e-02f, -7.11868256e-02f, 8.61726701e-02f, -2.82366015e-03f, -4.93361428e-02f, 1.31424991e-02f, -3.55594009e-02f, 3.79039906e-02f,
  -7.81825855e-02f, 2.76858676e-02f, 1.78362578e-02f, -4.97989431e-02f, -1.19790919e-02f, -2.31049443e-03f, 6.40109032e-02f, 4.91590723e-02f, 5.05173877e-02f, 3.55692506e-02f,
  -1.15436977e-02f, 1.01932935e-01f, 9.33020115e-02f, -3.67361158e-02f, 8.79951343e-02f, -3.55697074e-03f, 1.87555738e-02f, 1.32043418e-02f, 1.71581954e-02f, 3.65495645e-02f,
  -2.11099498e-02f, -7.43397251e-02f, 1.56801064e-02f, -7.09938705e-02f, 3.42568196e-02f, 4.17965353e-02f, -1.23369170e-03f, 1.41908135e-02f, 2.11027116e-02f, 5.09246960e-02f,
  1.35587141e-01f, -1.03226956e-02f, 4.59101051e-02f, 7.61646926e-02f, -5.12647629e-02f, 1.93556156e-02f, 6.14282442e-03f, 6.83836415e-02f, 1.15629584e-02f, 5.03253564e-02f,
  1.92115176e-02f, 4.03385609e-02f, 6.71128463e-03f, -4.31477763e-02f, -3.89251336e-02f, 4.43240181e-02f, 4.32098992e-02f, 6.84928373e-02f, -4.24072426e-03f, 4.87573668e-02f,
  -4.17028330e-02f, -4.79272790e-02f, -3.35257053e-02f, 3.90995387e-03f, -4.84050736e-02f, 2.41369735e-02f, 2.04815194e-02f, 9.38312933e-02f, -1.63337868e-02f, 5.21979369e-02f,
  5.99055290e-02f, 2.74569150e-02f, 5.81522211e-02f, -2.13048812e-02f, -5.96279241e-02f, 8.26675892e-02f, -1.67490821e-02f, -3.01609058e-02f, -1.25812264e-02f, 2.29931511e-02f,
  -1.53758423e-02f, 5.15973568e-02f, -3.11448704e-02f, 5.74505776e-02f, 2.32081767e-02f, 1.88860446e-02f, -4.54415753e-02f, -1.87237225e-02f, 2.55466700e-02f, 7.62052601e-03f,
  1.69107527e-01f, -8.11372325e-02f, -2.10131511e-01f, 9.35460720e-03f, -8.80536363e-02f, -1.01643533e-01f, -6.21546879e-02f, -1.52805611e-01f, -2.60392278e-01f, 1.64244741e-01f,
  3.39326933e-02f, 2.38755092e-01f, -3.86529416e-02f, -1.21408058e-02f, 1.12266026e-01f, -1.89727679e-01f, -8.31400529e-02f, 2.26256493e-02f, -2.63244033e-01f, 6.10189363e-02f,
  -1.61943778e-01f, 6.02081120e-02f, -7.69666880e-02f, 1.75251178e-02f, 9.62864235e-02f, 2.83774119e-02f, 1.99691981e-01f, -7.45641738e-02f, 1.82596684e-01f, -4.23918990e-03f,
  1.06081329e-01f, -8.26014876e-02f, -5.62874787e-02f, -8.43101069e-02f, 7.29351416e-02f, 6.18094541e-02f, 2.25102138e-02f, 1.86009667e-04f, -1.84954926e-02f, 4.22877893e-02f,
  1.22385368e-01f, 1.10094823e-01f, 9.81147140e-02f, -7.98935071e-02f, -6.69239610e-02f, -1.63606405e-02f, -6.76539075e-03f, -1.33366752e-02f, -4.72709015e-02f, -1.82260033e-02f,
  -6.83827419e-03f, -6.40421957e-02f, -4.12918106e-02f, -2.96181571e-02f, -1.44062489e-02f, -5.21802604e-02f, -4.62436453e-02f, 4.12821621e-02f, 2.61436719e-02f, -2.63153613e-02f,
  -1.27513930e-01f, -1.09507568e-01f, 2.57708114e-02f, 2.81006936e-02f, 3.76401059e-02f, -1.06580025e-02f, 2.19136570e-03f, 8.90629292e-02f, 1.94218252e-02f, 4.88444557e-03f,
  8.20380822e-02f, 1.33650871e-02f, -2.06908938e-02f, -8.33441243e-02f, 1.00680022e-02f, 2.99280509e-03f, 7.20921159e-03f, 3.51591818e-02f, 1.88468583e-02f, 3.49938571e-02f,
  -3.08028143e-02f, -7.18340650e-02f, -1.25081185e-02f, 7.23079965e-02f, -3.04684266e-02f, 3.31380777e-02f, 1.21763432e-02f, -5.48654869e-02f, 6.16686558e-03f, -4.89410087e-02f,
  7.04038590e-02f, -7.64083443e-03f, -5.35428151e-02f, 6.11340851e-02f, 1.65596344e-02f, 2.55124699e-02f, -8.55021551e-02f, 1.59976315e-02f, 1.44900093e-02f, -3.22365947e-02f,
  -3.82718601e-04f, 1.51849017e-02f, 1.23838216e-01f, -4.11263630e-02f, 1.37362052e-02f, 9.36429016e-04f, 4.21642438e-02f, -7.09949210e-02f, 3.44644263e-02f, 2.57503446e-02f,
  3.61356139e-02f, 3.95840779e-02f, 2.80236974e-02f, 2.14061700e-03f, 2.76358165e-02f, 7.29176328e-02f, 1.03141047e-01f, -4.19938639e-02f, 1.14941085e-02f, 1.25908935e-02f,
  2.29074389e-01f, -1.25239387e-01f, -1.52611658e-01f, -2.72315945e-02f, -9.69016626e-02f, -1.77507937e-01f, -3.08800768e-02f, -4.14816439e-02f, 1.04488611e-01f, 7.81227648e-03f,
  -1.47976354e-01f, -7.98277631e-02f, 7.48105720e-02f, -7.67536238e-02f, -1.49540707e-01f, 9.27204266e-02f, 3.25664878e-02f, -1.00691896e-02f, -2.60208007e-02f, 1.22764595e-01f,
  1.36682183e-01f, 4.83322851e-02f, 6.92145452e-02f, -1.08741261e-01f, -1.28002509e-01f, -1.80861115e-01f, -2.37419680e-01f, -2.18415171e-01f, -2.81514317e-01f, -2.61863112e-01f,
  -3.70708876e-03f, 1.02301082e-02f, 7.04449862e-02f, 5.99898398e-02f, -1.84894633e-02f, 1.48993954e-02f, -6.98584169e-02f, -1.83756396e-01f, 6.44992338e-03f, 1.99722107e-02f,
  4.53763343e-02f, 4.34624031e-02f, 5.55518176e-03f, -7.78849004e-03f, 4.66519110e-02f, -2.22471673e-02f, -3.13934535e-02f, -5.79332421e-03f, 2.98422687e-02f, 1.22815510e-02f,
  8.05096254e-02f, 5.68178669e-02f, -7.20378831e-02f, -6.04228154e-02f, -9.97470990e-02f, -1.04833744e-01f, 4.10378575e-02f, -7.29676411e-02f, -2.93275751e-02f, 1.54095644e-03f,
  -5.57857789e-02f, 9.19545814e-03f, 4.79291007e-02f, 3.63566391e-02f, 2.12618895e-02f, -1.13863230e-03f, 5.30400388e-02f, 3.48433033e-02f, 5.12622588e-04f, 1.66628081e-02f,
  5.75376451e-02f, -1.29737174e-02f, 4.72804978e-02f, 9.47794393e-02f, 2.36551818e-02f, 8.40562955e-02f, -7.19372183e-02f, -8.33745375e-02f, 3.78856175e-02f, -3.88518460e-02f,
  5.48151396e-02f, -8.60257819e-02f, 7.43424669e-02f, 1.24118244e-02f, -2.84127574e-02f, -2.00128108e-02f, -9.15505141e-02f, 1.33296009e-02f, -4.31625880e-02f, -5.50057776e-02f,
  -1.65390715e-01f, -3.60497445e-01f, 2.58089919e-02f, 5.22023067e-02f, -1.21523319e-02f, 8.04309268e-03f, -2.59298477e-02f, -5.21478839e-02f, -1.65610000e-01f, 1.99018884e-02f,
  1.94348246e-02f, 3.72165889e-02f, -3.10035087e-02f, -4.95975651e-02f, -6.09976090e-02f, 5.12866043e-02f, 1.83258019e-02f, -2.13545393e-02f, -3.08434442e-02f, -9.71268192e-02f,
  -2.53219642e-02f, 1.73853175e-03f, -7.67684029e-03f, 2.26652194e-02f, 7.96057582e-02f, -3.46860103e-02f, -5.70721850e-02f, -1.52760660e-02f, -4.87798937e-02f, -6.96339225e-03f,
  -2.58041799e-01f, 1.62975758e-01f, 1.91959105e-02f, -2.01560229e-01f, -8.67388248e-02f, -3.08436668e-03f, -4.96974438e-02f, 6.01726510e-02f, 1.93348169e-01f, 6.34798431e-04f,
  -2.45256163e-02f, -6.73803985e-02f, 1.99595407e-01f, -1.37851164e-01f, -3.34838927e-02f, 3.89953047e-01f, -1.31732866e-01f, -7.10091218e-02f, 1.40948832e-01f, -2.42435664e-01f,
  -3.12925838e-02f, -1.89613044e-01f, -3.20762284e-02f, -3.04600708e-02f, -1.69704393e-01f, -7.57137164e-02f, -2.58740932e-01f, 1.35996178e-01f, -2.79435068e-01f, 7.82590061e-02f,
  5.95739968e-02f, 7.50834644e-02f, -6.11794814e-02f, -3.02755577e-03f, 1.26611190e-02f, -1.37590282e-02f, 1.33056343e-02f, 5.74387871e-02f, 2.22971719e-02f, 8.81802849e-03f,
  -4.48672945e-04f, -1.62798464e-02f, 1.87922250e-02f, 2.60528121e-02f, -2.62110420e-02f, -7.79554993e-02f, -4.93405163e-02f, -3.31979315e-03f, -1.69608947e-02f, -5.98375537e-02f,
  -9.96980965e-02f, 1.17510613e-02f, -2.14850865e-02f, -5.49907014e-02f, -2.60025915e-02f, -3.79603803e-02f, -5.25303781e-02f, -3.77039947e-02f, 2.45930720e-02f, 4.95059416e-02f,
  4.00817730e-02f, 7.18730874e-03f, -5.88738918e-03f, 5.44849262e-02f, -3.98399010e-02f, 2.36956943e-02f, 5.33007905e-02f, 9.22563579e-03f, 2.14977246e-02f, -6.94862828e-02f,
  -2.46073436e-02f, 2.23885849e-02f, 6.49852157e-02f, -8.35842490e-02f, 1.64694004e-02f, -6.71174377e-02f, -9.63319675e-04f, -2.68898904e-02f, -4.10687178e-02f, 9.99976229e-03f,
  5.73643409e-02f, 4.52087335e-02f, -6.90526292e-02f, 1.87930483e-02f, 9.31400359e-02f, 1.18436618e-02f, 3.53912041e-02f, 6.78598601e-03f, 3.96516845e-02f, 1.04000000e-02f,
  -6.63712807e-03f, 5.43839820e-02f, -4.10066061e-02f, -2.74182893e-02f, 1.23881638e-01f, -4.01949286e-02f, 9.21434090e-02f, -5.37476242e-02f, 6.85873441e-03f, 1.07511701e-02f,
  -1.38096735e-01f, -4.21200879e-02f, 7.25256652e-02f, -5.42467348e-02f, 3.47981937e-02f, -4.64145504e-02f, 1.86520796e-02f, -2.62836013e-02f, 1.11829247e-02f, -9.49162338e-03f,
  -1.54804274e-01f, 9.60841868e-03f, 2.33146437e-02f, -5.53900599e-02f, -9.01270583e-02f, -3.20675224e-02f, -4.51075211e-02f, -1.07307956e-01f, 8.93665999e-02f, 1.73710100e-02f,
  1.62474230e-01f, -1.29474744e-01f, 1.67997837e-01f, 1.88781053e-01f, 2.79578894e-01f, -1.73414528e-01f, -8.28799978e-02f, -1.58585340e-01f, 5.40487729e-02f, -3.02518785e-01f,
  -2.94252820e-02f, 5.97548950e-03f, -2.19059423e-01f, 1.67453513e-01f, 3.74981016e-01f, -1.33604631e-02f, 5.46861626e-02f, -8.12342092e-02f, 1.17194504e-02f, -3.93023528e-02f,
  2.12967977e-01f, 1.97223902e-01f, 1.07393153e-01f, -2.18549017e-02f, 1.59431532e-01f, -7.53632840e-03f, 1.61976069e-01f, 1.42796442e-01f, 1.67907819e-01f, 1.89484775e-01f,
  6.86593074e-03f, -1.03777098e-02f, -8.76119081e-03f, 7.99863320e-03f, 1.56329088e-02f, -8.05214047e-02f, 9.10924301e-02f, 2.96711735e-02f, 2.48527918e-02f, -1.56611837e-02f,
  -6.49973825e-02f, 6.17796257e-02f, 1.70921662e-03f, -1.86063200e-02f, -3.40449363e-02f, 1.63201671e-02f, -3.76000442e-02f, -7.11373761e-02f, 1.87731795e-02f, 3.76727283e-02f,
  -4.60891128e-02f, 7.13925138e-02f, -1.55426962e-02f, 1.76444277e-03f, 8.92220289e-02f, -3.11358124e-02f, 2.16153041e-02f, 7.10518286e-02f, 7.42274597e-02f, 1.45341828e-01f,
  5.79423942e-02f, -7.16808289e-02f, -2.82917544e-02f, 2.48197652e-02f, 2.90335026e-02f, 7.43578970e-02f, -9.64448380e-04f, -2.28000283e-02f, -6.38866611e-03f, -2.32204329e-02f,
  2.27653328e-02f, -5.98339662e-02f, 1.91251573e-03f, -7.12671131e-02f, 3.14035942e-03f, -7.10684732e-02f, -1.32785086e-02f, -1.94398034e-02f, 1.90227549e-03f, 1.82997547e-02f,
  6.82330364e-03f, 2.31816676e-02f, -7.90109765e-03f, 7.98079297e-02f, 5.85443201e-03f, 3.23964804e-02f, -3.92523408e-02f, -2.75270566e-02f, -3.26867439e-02f, 1.25969816e-02f,
  1.48825854e-01f, 2.08796859e-01f, -8.80801380e-02f, 2.61129607e-02f, 3.74615043e-02f, -2.86745317e-02f, 6.40968326e-03f, -1.34546980e-02f, 1.27783000e-01f, -3.83417271e-02f,
  -9.70957056e-02f, -4.24416587e-02f, 8.88810307e-03f, 4.68392372e-02f, -5.57649806e-02f, 2.15738844e-02f, 4.90696207e-02f, -9.42533091e-03f, 1.02391616e-01f, -8.07370618e-03f,
  -8.48066956e-02f, -2.90623736e-02f, -3.71714123e-02f, -3.21639888e-02f, -3.24752815e-02f, -5.23062944e-02f, 1.28861926e-02f, -2.76881661e-02f, 8.87094140e-02f, 2.02605184e-02f,
  9.15489197e-02f, 8.61298889e-02f, 1.92805126e-01f, -7.34047741e-02f, 1.35654183e-02f, 1.41798273e-01f, 7.78923705e-02f, -5.06996829e-03f, 1.74252182e-01f, -1.01837300e-01f,
  -4.66823131e-02f, -1.08540863e-01f, 3.77169736e-02f, -2.34805867e-01f, -1.42773077e-01f, 3.59965637e-02f, -1.65763155e-01f, -1.39815703e-01f, 8.99484847e-03f, -9.84231457e-02f,
  -3.23545039e-02f, -3.28806609e-01f, -1.20347768e-01f, -1.36460260e-01f, -1.45855978e-01f, 3.63378748e-02f, -3.33559126e-01f, -5.24720550e-03f, -2.34593555e-01f, -7.70339519e-02f,
  1.16264515e-01f, 4.01812494e-02f, 7.12736771e-02f, 8.28452334e-02f, -4.13522422e-02f, 8.31577107e-02f, 4.14340533e-02f, -5.26116677e-02f, 6.21714480e-02f, 3.30015682e-02f,
  -6.70793117e-04f, -5.95120387e-03f, -3.70231383e-02f, -9.33551812e-04f, 4.98199463e-02f, 2.32290924e-02f, 9.20826010e-03f, 3.44071127e-02f, 2.73349378e-02f, 1.30462544e-02f,
  8.27465430e-02f, 1.46170566e-02f, 2.79558022e-02f, -2.25948729e-02f, -5.55695407e-03f, 4.53356951e-02f, 6.10035770e-02f, 3.25344056e-02f, 3.44402678e-02f, 1.92407053e-02f,
  1.12845572e-02f, -2.23349966e-02f, 4.24311263e-03f, -2.57248594e-03f, -1.46842776e-02f, -1.25493936e-03f, -3.38927805e-02f, -6.14390783e-02f, -6.93863118e-03f, -1.14891268e-02f,
  -4.39185686e-02f, -2.12657414e-02f, 2.11938918e-02f, 5.45762293e-02f, -2.20084991e-02f, 3.10339369e-02f, 5.66054462e-03f, -5.48207015e-03f, 2.72379331e-02f, -2.91556828e-02f,
  -3.32733542e-02f, -1.43091064e-02f, 3.50389816e-02f, 2.70762318e-03f, 7.56314546e-02f, 2.41406187e-02f, -4.83400784e-02f, 8.88907164e-02f, -3.72235328e-02f, -4.68359329e-02f,
  -1.09567828e-01f, -1.29498601e-01f, 1.41303083e-02f, 2.04569101e-02f, 2.17903480e-02f, -2.59787682e-02f, -3.96188386e-02f, 3.33070452e-03f, -2.48463918e-02f, -4.02773358e-02f,
  -1.23855639e-02f, -6.78570010e-04f, -3.01604737e-02f, 2.92840283e-02f, -1.05402060e-02f, 3.01686600e-02f, -3.32047343e-02f, 2.67833453e-02f, -6.40670285e-02f, -8.61643404e-02f,
  -2.41295472e-02f, -1.61851831e-02f, -1.35007836e-02f, -1.62614733e-02f, -1.92567632e-02f, -3.02615296e-02f, -1.83887556e-02f, 2.46190894e-02f, -5.36143109e-02f, -3.78543064e-02f,
  -1.01619124e-01f, 1.11735359e-01f, -2.40862146e-01f, 5.96542098e-03f, -8.09836388e-02f, -2.04985186e-01f, 6.04712986e-04f, 8.60846788e-02f, 1.05273694e-01f, 1.79131076e-01f,
  1.29089937e-01f, -2.19978005e-01f, 1.84602797e-01f, -3.70262749e-02f, -3.31360668e-01f, 5.69281429e-02f, 4.83888648e-02f, -3.10583692e-02f, 8.26443657e-02f, 5.06477058e-02f,
  -1.28428750e-02f, 7.32601956e-02f, -1.39266878e-01f, 6.48268089e-02f, -7.35760108e-02f, 2.61696260e-02f, 1.13812745e-01f, -4.96929474e-02f, -1.27367422e-01f, -1.04062088e-01f,
  -1.03970021e-01f, 1.21740684e-01f, -2.86947582e-02f, -3.49606313e-02f, 4.93620783e-02f, 5.22524565e-02f, -7.23198056e-02f, -5.82983196e-02f, -8.27461481e-03f, 1.58046931e-02f,
  -1.87596586e-02f, -6.76534325e-02f, -5.22609684e-04f, 1.39810098e-03f, -5.94415106e-02f, -5.21670282e-02f, -1.23596735e-01f, -6.35681078e-02f, 7.33178947e-03f, -7.66668320e-02f,
  -4.79773954e-02f, -8.25500563e-02f, 1.20288469e-02f, -5.18214097e-03f, -3.40475515e-02f, -5.94795123e-02f, -2.63007861e-02f, -7.07744434e-02f, -5.11669703e-02f, -6.28413558e-02f,
  -5.47779119e-03f, 7.08271042e-02f, 3.76373120e-02f, -1.70673039e-02f, 3.05716563e-02f, 3.78939509e-02f, -2.87584197e-02f, 9.36067197e-03f, -1.65777635e-02f, 1.85598191e-02f,
  9.45812371e-03f, -2.90625319e-02f, 3.23631167e-02f, -3.61494236e-02f, 4.56383899e-02f, 4.62281331e-02f, -4.47319523e-02f, 4.03577636e-04f, 6.33089021e-02f, -2.98524983e-02f,
  3.52083631e-02f, -5.46899915e-04f, 9.22978390e-03f, -1.81704201e-02f, -2.49247812e-02f, -3.75398286e-02f, -9.11392737e-03f, -5.59941716e-02f, 5.73531128e-02f, -3.25140049e-04f,
  8.38209614e-02f, 2.25776300e-01f, 5.03475703e-02f, -5.40668443e-02f, 9.75780841e-03f, 4.33283001e-02f, -2.44423393e-02f, -4.89993952e-02f, 3.77239175e-02f, 6.18129112e-02f,
  -1.14406478e-02f, 4.62717749e-02f, -2.31109541e-02f, -2.65143514e-02f, -8.79140347e-02f, 6.68080375e-02f, 4.74865101e-02f, 6.01952933e-02f, 4.08756137e-02f, 2.26728898e-02f,
  2.55266745e-02f, 1.00448476e-02f, -4.41989228e-02f, 1.75765697e-02f, 5.04828319e-02f, -3.38440202e-02f, 3.71832438e-02f, -1.57364842e-03f, -1.88114606e-02f, -2.68137101e-02f,
  5.75383544e-01f, -1.31480321e-01f, 1.29445223e-02f, 1.69003338e-01f, 1.49711207e-01f, 1.25461444e-01f, 1.67010605e-01f, 3.19753997e-02f, 7.52135441e-02f, -2.55369425e-01f,
  4.35862131e-02f, 2.15982959e-01f, -1.20162383e-01f, 1.34477109e-01f, 4.65040177e-01f, -8.92631412e-02f, 2.42657915e-01f, 1.12055577e-01f, -3.79345356e-03f, 1.90105274e-01f,
  1.41001508e-01f, 4.03444953e-02f, 9.11803842e-02f, -1.67798206e-01f, 9.73896608e-02f, -1.45760939e-01f, 2.09627151e-02f, -1.67150855e-01f, -1.73368002e-03f, 7.79289678e-02f,
  1.65790856e-01f, -3.60397585e-02f, -5.96217886e-02f, -5.52133620e-02f, 1.01940580e-01f, -8.34897626e-03f, 4.41834815e-02f, -9.37354192e-03f, 1.72876939e-02f, 2.64879018e-02f,
  1.93465184e-02f, 4.28714715e-02f, -7.58405821e-03f, -7.26666749e-02f, -3.24460156e-02f, -8.86030588e-03f, -1.14474737e-03f, 2.31231228e-02f, -3.08222827e-02f, 3.92538905e-02f,
  -3.70221548e-02f, 3.95262754e-03f, -2.67766556e-03f, 1.68224648e-02f, 3.03705353e-02f, -5.66597190e-03f, -2.86804400e-02f, 4.20017354e-02f, 3.78149860e-02f, 4.28421237e-02f,
  9.94065218e-03f, -1.34130558e-02f, -3.96940410e-02f, -3.64519730e-02f, -1.85186546e-02f, 1.54836196e-02f, -5.86340167e-02f, 2.56127845e-02f, 1.89332373e-03f, 5.29581271e-02f,
  5.06297536e-02f, -3.68742049e-02f, 5.82231965e-04f, -2.72620209e-02f, 5.61827153e-04f, 6.81761652e-03f, 5.60696702e-04f, 9.02347453e-03f, 6.90016076e-02f, 4.37183827e-02f,
  -3.38123031e-02f, 3.68179455e-02f, -5.13340055e-04f, 1.79309715e-02f, 1.36238779e-03f, 2.98972637e-03f, -8.10130164e-02f, -2.45089699e-02f, 1.97685100e-02f, 5.29132485e-02f,
  1.94492206e-01f, 3.56181860e-02f, -5.12082987e-02f, 2.79868934e-02f, -2.27374993e-02f, 1.91472040e-03f, -3.43953609e-03f, -1.00537878e-03f, -8.63245595e-03f, -1.34165343e-02f,
  1.80000048e-02f, -4.74571204e-03f, 4.23561819e-02f, 1.62973385e-02f, 1.09271007e-02f, 2.60028546e-03f, 4.47036847e-02f, -1.68553386e-02f, 8.91241133e-02f, 3.27302031e-02f,
  -1.03481170e-02f, 2.55422723e-02f, -2.83630621e-02f, -3.78081687e-02f, 1.24360528e-02f, 2.63883043e-02f, 6.72428831e-02f, -4.34247926e-02f, -2.55443417e-02f, 1.92938447e-02f,
  3.62710863e-01f, -5.05443990e-01f, 2.28887856e-01f, 9.27895606e-02f, -8.60791355e-02f, 6.03020601e-02f, 1.54224724e-01f, -1.53368816e-01f, 6.87360168e-02f, -5.34418449e-02f,
  -1.39957964e-01f, -7.31631275e-03f, -1.92590266e-01f, -1.20652348e-01f, -6.14354797e-02f, -2.17917755e-01f, 8.33224729e-02f, 1.47433922e-01f, -1.27702177e-01f, -1.14714339e-01f,
  -1.67295516e-01f, -1.68879315e-01f, -7.87302405e-02f, -1.82044894e-01f, 5.49287014e-02f, 1.49869859e-01f, -6.31647408e-02f, -3.26062627e-02f, 1.17895350e-01f, -2.89140455e-03f,
  -7.30239078e-02f, -3.68574299e-02f, 8.75236169e-02f, 9.27356631e-02f, 7.10995123e-02f, 7.67063648e-02f, 7.18924850e-02f, 9.78544727e-03f, 5.17068654e-02f, 3.43505107e-02f,
  5.78899421e-02f, -2.84232423e-02f, 3.14760059e-02f, -2.68694218e-02f, 1.53130502e-01f, 3.78860906e-02f, -1.32108489e-02f, 5.65302093e-03f, -2.27328744e-02f, -7.12746456e-02f,
  -2.86120418e-02f, -3.75178456e-02f, 5.06863594e-02f, 2.93031055e-03f, 2.42263079e-02f, 8.93494487e-02f, 1.93730798e-02f, -2.25063786e-02f, 3.48131708e-03f, 2.78319810e-02f,
  4.97050807e-02f, -3.79830115e-02f, -4.61411215e-02f, 1.04897181e-02f, -6.60120100e-02f, -5.64247034e-02f, 4.51221019e-02f, 2.40957155e-03f, 8.69596675e-02f, -1.11151606e-01f,
  3.43112648e-02f, -4.28975672e-02f, -3.19525786e-02f, 5.42760901e-02f, 2.41122469e-02f, 8.62839520e-02f, 3.93381305e-02f, 2.89314482e-02f, 4.04910073e-02f, -5.02469316e-02f,
  -2.55349707e-02f, 3.98190413e-03f, 3.80971506e-02f, 1.60231330e-02f, 8.20093043e-03f, 7.93645903e-03f, -3.87913175e-02f, -1.69020556e-02f, 3.36611271e-02f, 2.52130684e-02f,
  -1.10595606e-01f, -1.32059395e-01f, 1.98576134e-02f, 5.31674316e-03f, -3.45045165e-03f, -4.66680527e-02f, -3.31358686e-02f, 1.73766841e-03f, 1.64921898e-02f, 3.58344550e-04f,
  1.56264957e-02f, 6.94368556e-02f, -2.65203491e-02f, 1.53370108e-02f, 2.83404216e-02f, -1.05663359e-01f, 5.10982499e-02f, 2.18698382e-02f, 5.14871441e-02f, -2.02627834e-02f,
  1.21505614e-02f, 1.11376140e-02f, 2.70518176e-02f, 2.14669947e-02f, 6.89149946e-02f, 2.06100941e-02f, -1.98472589e-02f, -1.72507204e-02f, 1.04497531e-02f, -4.02110182e-02f,
  2.55124457e-02f, -8.38588625e-02f, 2.07013920e-01f, -1.85010880e-01f, -1.77798674e-01f, -1.95418105e-01f, -1.17669143e-01f, -9.04586390e-02f, -7.57837296e-02f, -7.82374144e-02f,
  -2.28814840e-01f, 5.13771661e-02f, 9.87695828e-02f, -3.02761912e-01f, -9.56719555e-03f, -1.00993253e-02f, -1.91621125e-01f, -3.71021256e-02f, 6.10502961e-04f, -2.87216268e-02f,
  -7.89687410e-02f, -2.08111554e-01f, 8.53085145e-03f, -9.59738120e-02f, -8.02738592e-02f, 1.20495968e-02f, 1.08170502e-01f, 1.52809709e-01f, -1.36600152e-01f, -3.10839880e-02f,
  -3.66777405e-02f, 1.41891196e-01f, 9.85062942e-02f, 1.12894088e-01f, 6.39287680e-02f, 5.44982739e-02f, 1.24498174e-01f, 1.13474794e-01f, 5.18599264e-02f, -2.43032034e-02f,
  6.32825047e-02f, 1.19980227e-03f, -6.07647598e-02f, 8.71840641e-02f, -2.25627460e-02f, -4.50183414e-02f, -1.77200008e-02f, -5.87919680e-03f, -9.94835198e-02f, 1.14198523e-02f,
  -6.47157505e-02f, -6.20790757e-03f, -5.05084470e-02f, -1.97560135e-02f, 2.76145730e-02f, -5.49666658e-02f, -5.12433983e-03f, 6.75051361e-02f, -6.07417971e-02f, -4.68191132e-02f,
  1.50595130e-02f, 4.53011990e-02f, 8.68598931e-03f, -3.05435192e-02f, 5.97329773e-02f, -9.25393999e-02f, -1.11196544e-02f, 6.87082822e-04f, 2.12553479e-02f, -2.06557699e-02f,
  -7.69915208e-02f, -3.71144190e-02f, 5.76407649e-02f, 2.69287359e-02f, 2.21913462e-04f, -5.01132831e-02f, 5.83372824e-02f, -8.36818106e-03f, -1.02337755e-01f, 1.75312199e-02f,
  6.64139539e-02f, -4.62369621e-02f, -3.91198844e-02f, 3.19989584e-02f, 3.72951180e-02f, 5.76713607e-02f, 5.80118410e-02f, -6.51530176e-02f, 2.73033455e-02f, 5.83574325e-02f,
  1.08044922e-01f, 2.00465679e-01f, 1.31919805e-03f, -5.83408326e-02f, 1.18808642e-01f, 3.07278484e-02f, 3.82243693e-02f, -3.30367088e-02f, 7.36412629e-02f, 5.35016097e-02f,
  -5.48217958e-03f, -1.46705071e-02f, 3.06514930e-02f, -3.92117202e-02f, -1.52238254e-02f, -3.95631455e-02f, 4.61157076e-02f, 4.49028462e-02f, -2.36167200e-02f, -8.81185755e-03f,
  9.12552103e-02f, -2.99473777e-02f, 1.45846438e-02f, 1.24919266e-02f, 1.60803087e-02f, -9.63653028e-02f, -2.28876527e-02f, -6.18840158e-02f, -1.60420220e-02f, -1.70849282e-02f,
  1.53369710e-01f, -4.04396415e-01f, -6.22788556e-02f, -1.25680894e-01f, -7.80654745e-03f, -1.05522051e-01f, -2.69687083e-02f, -2.64978051e-01f, -2.87946641e-01f, -2.52648026e-01f,
  1.08783273e-02f, -3.26203275e-03f, -7.28442073e-02f, -3.17163497e-01f, 2.29713738e-01f, -1.77956164e-01f, -1.38454422e-01f, -2.80328337e-02f, -7.63182342e-02f, 3.93418074e-02f,
  2.50989720e-02f, 1.07646231e-02f, 3.88849229e-02f, -3.71219888e-02f, -1.21442214e-01f, 1.14280842e-01f, 2.53560781e-01f, 1.18626319e-01f, 4.94948849e-02f, 7.55569339e-02f,
  7.95228686e-03f, -8.50146636e-02f, -7.81924948e-02f, -3.25704180e-03f, 6.03074245e-02f, 9.58778560e-02f, 2.50671729e-02f, 9.82841402e-02f, 2.59360913e-02f, -5.81856072e-03f,
  -2.32114606e-02f, -2.77180597e-02f, -2.72497926e-02f, -1.37654031e-02f, -6.46293238e-02f, -2.28765029e-02f, -1.10560209e-01f, -9.28670242e-02f, -1.21925145e-01f, -3.93641517e-02f,
  -8.00286084e-02f, -7.46596381e-02f, -6.40921742e-02f, -1.30829262e-02f, 4.79202345e-02f, -3.48653346e-02f, 3.73453945e-02f, 9.36214551e-02f, -1.02819018e-01f, 8.00702628e-03f,
  -2.11519301e-02f, 7.73648694e-02f, 4.64497181e-03f, -5.48454225e-02f, 3.71926352e-02f, 3.04561504e-03f, -7.84795433e-02f, 4.26176004e-02f, 4.90770563e-02f, -1.26584433e-02f,
  4.78725582e-02f, -2.52651516e-04f, -9.30871740e-02f, 1.23999165e-02f, 9.01621655e-02f, -2.87821535e-02f, 3.63761745e-02f, 3.16014737e-02f, 4.33899909e-02f, -2.20814925e-02f,
  -3.83032076e-02f, -3.71556208e-02f, 2.09638625e-02f, -1.98149332e-03f, -6.16004802e-02f, 1.68045629e-02f, -4.62308340e-02f, -5.98778874e-02f, 1.46023184e-02f, 8.68165866e-02f,
  8.42670277e-02f, 9.77691635e-02f, -2.53662281e-02f, 1.99327362e-03f, -3.74742448e-02f, -8.31501037e-02f, -6.42676130e-02f, -7.87458494e-02f, 6.56874105e-02f, 1.09854527e-02f,
  1.07891321e-01f, 5.83451055e-02f, -3.00518554e-02f, -3.62271518e-02f, 3.33882943e-02f, -9.13771521e-03f, 5.24627529e-02f, 5.66738844e-02f, 2.31139436e-02f, 3.91218476e-02f,
  3.13325338e-02f, 1.02847867e-01f, -3.92278507e-02f, -3.23222112e-03f, 5.15822768e-02f, 6.05829693e-02f, 1.08219739e-02f, 3.28644887e-02f, -3.23391221e-02f, 1.93596855e-02f,
  2.58768231e-01f, -3.32337588e-01f, -1.58075541e-01f, 2.44229019e-01f, 1.87284186e-01f, 1.45197421e-01f, 1.55430660e-01f, 4.80403006e-02f, -7.62953535e-02f, -1.85752362e-01f,
  2.35630721e-01f, -2.44346395e-01f, -4.10003141e-02f, 1.75141141e-01f, 3.88345659e-01f, -1.29754722e-01f, 1.68826386e-01f, 2.61879154e-03f, 1.74085312e-02f, 9.46058482e-02f,
  1.08596832e-01f, 2.34712809e-01f, 1.46063104e-01f, -3.49039845e-02f, 1.14546798e-01f, -1.57371476e-01f, 1.29045680e-01f, -1.51268691e-01f, 1.08395472e-01f, -2.14523636e-02f,
  4.45538759e-02f, 4.10058834e-02f, 2.46614851e-02f, -1.12839341e-01f, 9.28706974e-02f, -1.26096075e-02f, -1.18924091e-02f, 8.29916354e-03f, 2.29983740e-02f, 4.52231579e-05f,
  -3.31463031e-02f, 2.25540362e-02f, -1.29617676e-02f, -4.83509302e-02f, 1.99052971e-02f, -5.15109785e-02f, -1.95667557e-02f, 8.61776769e-02f, -2.64023128e-03f, 4.14151065e-02f,
  -2.85230484e-02f, -3.53810415e-02f, 7.93084577e-02f, -3.27415057e-02f, 4.47510090e-03f, 8.12827982e-03f, -2.45573819e-02f, -3.38773951e-02f, -6.33100644e-02f, -3.11114397e-02f,
  4.24655899e-02f, 1.65503100e-02f, 1.39425080e-02f, -1.30291088e-02f, 4.05187495e-02f, -4.05983673e-03f, 2.53289063e-02f, 3.69387902e-02f, -3.70671377e-02f, -4.22696769e-03f,
  4.30798009e-02f, -1.50294052e-02f, 4.36898060e-02f, 2.20889430e-02f, 4.37537208e-02f, -2.12043561e-02f, -8.80356133e-03f, -4.61280271e-02f, 6.34254003e-03f, 3.83477397e-02f,
  -1.03495875e-02f, -9.20369290e-03f, -2.91558690e-02f, 3.22498195e-02f, 1.77741610e-02f, -2.55357474e-04f, -3.80518101e-02f, -3.34728658e-02f, 1.89046077e-02f, 4.31026258e-02f,
  8.50282907e-02f, -7.47193322e-02f, -6.96072653e-02f, 3.79851367e-03f, -9.05405059e-02f, -2.52041053e-02f, -5.22006229e-02f, -1.16738947e-02f, -1.49758728e-02f, 3.69009487e-02f,
  4.15614136e-02f, -2.68494934e-02f, -1.14646256e-02f, 3.00196297e-02f, -3.85102676e-03f, 2.60032285e-02f, -1.55951374e-03f, -7.96243772e-02f, 4.17772979e-02f, 1.24609191e-02f,
  2.28821468e-02f, -1.42320164e-03f, -2.41039898e-02f, 9.64778196e-03f, 4.61346358e-02f, -2.03263760e-03f, -5.49787655e-03f, -3.84800956e-02f, 2.45040972e-02f, -6.61716536e-02f,
  -3.01633596e-01f, 2.69551307e-01f, 1.25151545e-01f, -8.88325274e-02f, -4.83284742e-02f, -8.25389251e-02f, -2.53680766e-01f, 1.71851113e-01f, 4.95224856e-02f, 9.64322221e-03f,
  -1.80959076e-01f, 4.10944819e-02f, -3.99062298e-02f, -2.08797559e-01f, -2.79758900e-01f, -1.46415666e-01f, -3.31913568e-02f, -1.63748488e-01f, 8.34966749e-02f, 7.07564354e-02f,
  3.53952274e-02f, -1.42199144e-01f, -1.97517738e-01f, 2.42251739e-01f, -5.86004965e-02f, 2.03201056e-01f, -5.57081103e-02f, 1.74889058e-01f, 4.70970720e-02f, -4.73416410e-02f,
  -8.65448266e-02f, 6.42740214e-03f, -1.07172355e-02f, 8.15580711e-02f, -3.54089513e-02f, -6.42008185e-02f, 2.36533452e-02f, -8.59684646e-02f, -7.55677372e-02f, 5.08092670e-03f,
  -1.16128894e-02f, 3.21575208e-05f, 2.53211223e-02f, -6.35679113e-03f, -9.86177661e-03f, 1.62067041e-02f, -5.54643832e-02f, -4.47974391e-02f, 3.89880724e-02f, -7.34479129e-02f,
  -3.78776751e-02f, -4.57159653e-02f, -2.47488488e-02f, 2.06292123e-02f, 6.87629133e-02f, 4.59662378e-02f, -4.18331707e-03f, 9.30350460e-03f, -4.14694510e-02f, 1.36978244e-02f,
  -3.94131877e-02f, 4.66504321e-02f, -1.68343298e-02f, -4.32240814e-02f, -2.41816267e-02f, 2.80554909e-02f, -3.14901657e-02f, -5.42835705e-02f, 4.53936122e-02f, -5.31227440e-02f,
  1.15421107e-02f, -5.95465526e-02f, -2.49074725e-03f, -5.81392124e-02f, -1.92114189e-02f, -1.38409631e-02f, 2.84439884e-03f, 2.55027320e-02f, 1.77646987e-02f, -1.01855770e-01f,
  -4.69857827e-03f, 2.33646464e-02f, -2.91345287e-02f, -1.67613644e-02f, -2.48274226e-02f, -2.84698457e-02f, 5.87579720e-02f, 3.24909352e-02f, -8.34815856e-03f, -1.89223215e-02f,
  9.74383876e-02f, 3.42729390e-01f, 7.33025149e-02f, 3.32441665e-02f, 2.50993390e-02f, 1.82162188e-02f, -1.04199843e-02f, -1.58294381e-04f, 1.02785878e-01f, 2.18590219e-02f,
  4.13969010e-02f, -1.54906306e-02f, 5.77760860e-02f, -8.34154114e-02f, 3.33625004e-02f, -1.26227923e-02f, 3.36913429e-02f, 4.33682948e-02f, 5.68672791e-02f, 3.25139910e-02f,
  -3.23415883e-02f, 4.49135248e-03f, -1.67852566e-02f, 2.26857606e-02f, -1.33822029e-02f, -1.30600333e-02f, 9.84423757e-02f, 1.20247863e-02f, 3.36065926e-02f, 6.52716262e-03f,
  1.85207352e-01f, 9.50009748e-02f, -1.02216646e-01f, -1.84538495e-02f, 7.08587319e-02f, 1.11878015e-01f, 7.15796202e-02f, 8.16526860e-02f, -2.80360356e-02f, 1.85920015e-01f,
  2.13837907e-01f, 4.83916514e-02f, 5.38047068e-02f, 2.42725462e-02f, -1.45809263e-01f, -2.34747067e-01f, 5.27576581e-02f, 4.91338484e-02f, -7.89189115e-02f, 9.65653807e-02f,
  -1.89130738e-01f, 5.16874790e-02f, -2.06701428e-01f, -1.33498022e-02f, 1.23109721e-01f, -4.55179019e-03f, 2.90367175e-02f, -8.65239650e-02f, 1.34629235e-01f, -1.38973296e-02f,
  3.99468914e-02f, 2.71879081e-02f, 1.21856458e-01f, 9.63208526e-02f, 1.04403935e-01f, -1.60021905e-03f, 3.57245617e-02f, 1.81771070e-02f, -8.76077916e-03f, 4.14717123e-02f,
  4.60553691e-02f, 1.94339417e-02f, 4.29703668e-02f, -4.12647389e-02f, 3.68986577e-02f, 7.77096599e-02f, 2.10684873e-02f, 5.36436625e-02f, 1.34510687e-02f, 2.56451610e-02f,
  -3.59575301e-02f, 2.85208765e-02f, 3.92345786e-02f, 3.86805981e-02f, -1.04685044e-02f, 8.28918442e-02f, -4.98799495e-02f, 3.85897495e-02f, 9.77849290e-02f, 6.66573942e-02f,
  -2.50666644e-02f, -9.80420336e-02f, 2.70923618e-02f, -1.33354524e-02f, 2.73973029e-02f, 2.55894270e-02f, 8.37976579e-03f, 2.56711710e-02f, -9.70863923e-03f, 8.82349610e-02f,
  7.59206936e-02f, 2.32736394e-03f, 1.73810981e-02f, 1.15815597e-02f, -8.27515572e-02f, -1.27265230e-02f, 2.95298528e-02f, 8.36386606e-02f, -7.04907477e-02f, 8.43657739e-03f,
  4.95063188e-03f, -1.11421477e-03f, 4.20892332e-03f, -5.30758761e-02f, 2.17290055e-02f, -4.26395573e-02f, -2.52634141e-04f, -2.98446976e-02f, 3.40064652e-02f, 9.37772170e-03f,
  2.06215486e-01f, 4.74134982e-02f, 3.73815857e-02f, 1.43471286e-01f, 4.72440608e-02f, 7.02540278e-02f, -9.56714675e-02f, 2.06458550e-02f, 4.83347327e-02f, -3.09817046e-02f,
  3.46088335e-02f, 3.09337769e-02f, 5.11673354e-02f, 5.03653139e-02f, -4.32735346e-02f, -2.55656452e-03f, -5.64610250e-02f, 6.37134686e-02f, 4.33677360e-02f, 8.42664465e-02f,
  1.09637588e-01f, 3.50128449e-02f, -6.93557337e-02f, 1.00989928e-02f, 1.21742608e-02f, 6.02022558e-02f, -1.35594085e-02f, -9.97879356e-02f, 4.26036119e-02f, 9.83615313e-03f,
  2.90869325e-02f, 2.20181942e-01f, 2.07176343e-01f, -2.88207456e-02f, 2.12456450e-01f, -4.83965091e-02f, 4.58182357e-02f, 1.31026700e-01f, -1.37512550e-01f, -9.94901732e-02f,
  -1.98645979e-01f, 7.06876293e-02f, -7.06301676e-03f, -2.54975110e-01f, -2.26225272e-01f, -3.14713210e-01f, -2.53229320e-01f, -2.56116837e-01f, -6.77662194e-02f, -2.55564377e-02f,
  2.42147152e-03f, -1.22603346e-02f, 1.33566618e-01f, 3.12429488e-01f, 2.01764584e-01f, 2.92352885e-01f, -1.82708073e-02f, 1.70410573e-01f, 5.57545833e-02f, 7.76679814e-02f,
  -1.26220733e-01f, 6.93558007e-02f, 9.05954316e-02f, 3.63493785e-02f, 1.65025778e-02f, 2.75675487e-03f, -4.12073769e-02f, 1.25960380e-01f, -2.13059057e-02f, 3.57313119e-02f,
  2.44541187e-03f, -4.29528058e-02f, 2.12568566e-02f, 3.95031273e-02f, 9.07753184e-02f, 3.13071385e-02f, -3.77875566e-02f, -1.97980590e-02f, 3.94130759e-02f, 2.25093663e-02f,
  -4.29380871e-02f, -2.77943220e-02f, -6.04898594e-02f, -2.47804224e-02f, 2.98826285e-02f, -4.93220165e-02f, 2.31911466e-02f, 6.04010746e-02f, -7.87597597e-02f, 3.08374260e-02f,
  -6.54892027e-02f, 3.67556736e-02f, 1.30345151e-01f, 3.11263446e-02f, 7.35848993e-02f, 4.28538322e-02f, -1.93134358e-03f, -3.07719819e-02f, 6.46905303e-02f, -2.75700688e-02f,
  -3.36320587e-02f, 3.88379321e-02f, -4.31212187e-02f, 6.61954633e-04f, -1.04917781e-02f, 2.44696587e-02f, 1.37532176e-02f, 1.23706311e-02f, -7.37777054e-02f, 3.33208777e-03f,
  -4.88446327e-04f, -3.45209725e-02f, 5.58262654e-02f, 1.15466407e-02f, -3.92686911e-02f, 3.86935510e-02f, -4.64741187e-03f, 1.79549884e-02f, -3.77439931e-02f, 3.53550725e-02f,
  -1.77714825e-01f, 4.32956666e-02f, 2.70342594e-03f, -6.91296533e-03f, 4.31716442e-02f, -4.11265232e-02f, -2.12684665e-02f, -8.64652451e-03f, -3.87718081e-02f, 3.92930098e-02f,
  -2.65820846e-02f, 3.49326767e-02f, 3.39166820e-02f, -3.40721905e-02f, -9.18955635e-03f, 2.24419348e-02f, -3.95759046e-02f, -4.92414227e-03f, -5.22283874e-02f, -6.44496176e-03f,
  1.19439252e-02f, -7.09459037e-02f, 4.26237509e-02f, 7.56493136e-02f, -3.62298675e-02f, 1.04027018e-02f, -9.52580571e-03f, -1.80663262e-03f, -1.76516157e-02f, -8.95761177e-02f,
  2.98809528e-01f, -8.72026831e-02f, 1.31808937e-01f, 2.80145824e-01f, 2.25806367e-02f, -1.60318777e-01f, 8.99887457e-03f, -8.97866189e-02f, 6.44507110e-02f, -2.12043822e-01f,
  -1.71128467e-01f, 1.44503087e-01f, -4.29603934e-01f, 1.19128391e-01f, 2.39873961e-01f, -2.77680784e-01f, 1.32832438e-01f, 8.84952582e-03f, -7.68244117e-02f, 7.56062418e-02f,
  1.01070330e-01f, 2.81833056e-02f, 9.79135036e-02f, -5.00330441e-02f, 2.14516923e-01f, 1.25774950e-01f, 2.44579524e-01f, 1.83464289e-02f, 2.87290275e-01f, 9.73429531e-02f,
  -9.07104537e-02f, 3.49462032e-02f, 1.95535515e-02f, 2.53757425e-02f, 2.29160711e-02f, -3.61823924e-02f, 5.23274625e-03f, -9.84098110e-03f, -1.22665241e-02f, -1.77704636e-02f,
  -5.41490652e-02f, 1.69224888e-02f, -2.52451021e-02f, -4.13322076e-02f, 6.76988810e-02f, 6.94698617e-02f, 3.50947715e-02f, -1.88242439e-02f, 2.91071218e-02f, 4.16360423e-02f,
  -1.09625608e-02f, 9.71758179e-03f, 9.16144401e-02f, 3.64198051e-02f, 7.76926279e-02f, 1.26987183e-03f, 4.97852340e-02f, 5.42643890e-02f, 1.08526625e-01f, 9.91965383e-02f,
  7.93759804e-03f, -2.57287323e-02f, 1.61048099e-02f, -1.64959393e-02f, -2.20666248e-02f, 1.34315556e-02f, -8.52294266e-03f, 4.35036188e-03f, 7.47386962e-02f, -2.35687033e-03f,
  2.00576838e-02f, 2.48325747e-02f, -2.62281336e-02f, -2.73664556e-02f, 3.22480276e-02f, 3.22287693e-03f, -3.30219418e-02f, -1.12683186e-02f, 6.20400459e-02f, -1.82973649e-02f,
  -1.11141778e-03f, 2.35590916e-02f, -5.17023541e-02f, 2.18250938e-02f, -4.83462848e-02f, 1.69341061e-02f, 1.16992062e-02f, 2.81087980e-02f, -6.08316176e-02f, -2.09348314e-02f,
  1.58123393e-02f, 2.32201815e-01f, -3.38806137e-02f, -2.28927359e-02f, -4.15850477e-03f, -4.22369093e-02f, 6.56198198e-03f, 1.59388874e-02f, 6.38922900e-02f, -2.68466119e-02f,
  -1.81355421e-02f, -7.65395770e-03f, 5.06983586e-02f, 3.50875445e-02f, 5.75141702e-03f, 2.11536009e-02f, -5.16035929e-02f, -3.83911235e-03f, 1.16299853e-01f, -2.01063952e-03f,
  2.40501924e-03f, -6.26745671e-02f, -4.44037141e-03f, 3.65468562e-02f, -1.77241415e-02f, 2.76284143e-02f, 3.76128554e-02f, 4.24561370e-03f, -3.42025235e-03f, -2.73823813e-02f,
  2.75154617e-02f, -4.53829672e-03f, 1.11943297e-01f, -3.65143418e-01f, 9.03102830e-02f, 1.52858958e-01f, 7.50246495e-02f, -3.55948396e-02f, -2.73143113e-01f, -7.23589286e-02f,
  3.93942446e-02f, 1.52558060e-02f, 2.21132204e-01f, -2.74067044e-01f, 6.79612458e-02f, 3.99458446e-02f, -2.78192401e-01f, -1.35348812e-01f, -9.36458483e-02f, -8.04101974e-02f,
  -7.34211057e-02f, -2.47996598e-01f, -9.58642364e-03f, -1.28047332e-01f, -4.09475937e-02f, -8.13522711e-02f, -1.12023577e-01f, 1.39923438e-01f, -1.09882995e-01f, 3.33719291e-02f,
  -4.32631187e-03f, -5.03381304e-02f, 2.55117845e-02f, -3.12012415e-02f, 7.17330212e-03f, 4.14675549e-02f, 4.50925482e-03f, 4.99363169e-02f, -2.41512489e-02f, -1.64397489e-02f,
  3.85000408e-02f, -6.86341822e-02f, -8.92344341e-02f, 1.20763686e-02f, -3.32233310e-02f, -3.17378789e-02f, 7.72621890e-04f, 4.64528985e-02f, 9.81869455e-03f, 6.61601201e-02f,
  3.28199230e-02f, 2.29542069e-02f, 1.42770475e-02f, 1.47316540e-02f, 3.29348072e-02f, -4.22604643e-02f, -3.06632277e-02f, 9.85943973e-02f, 2.47769407e-03f, -3.18963267e-02f,
  5.96464388e-02f, -3.87803651e-02f, 3.76491547e-02f, -3.01791169e-02f, -5.49002737e-03f, 4.02412523e-04f, 2.88537480e-02f, 7.26676881e-02f, 1.72553472e-02f, 3.34056020e-02f,
  -1.00470074e-01f, 6.62483042e-03f, -8.09242725e-02f, -3.06277703e-02f, 1.55639583e-02f, -5.11055961e-02f, 4.49588709e-02f, 4.42767665e-02f, -2.93017272e-02f, 3.60698439e-02f,
  -1.97630003e-02f, -9.91649181e-03f, -5.70237497e-03f, 3.79461311e-02f, -6.19971268e-02f, 5.99291250e-02f, -2.89662927e-02f, 1.93906352e-02f, 1.13249728e-02f, 5.22994399e-02f,
  7.49689564e-02f, -6.50914684e-02f, -2.02880520e-02f, -4.95511442e-02f, -5.75991720e-02f, 2.43568271e-02f, -2.57106405e-02f, 1.76964293e-03f, -4.53519635e-02f, -6.31869137e-02f,
  -6.67822082e-03f, -3.39226983e-02f, 5.36841340e-03f, 1.36174941e-02f, -5.19913472e-02f, -1.42714137e-03f, -2.26286909e-04f, -1.11777112e-01f, 5.36842563e-04f, -1.22327246e-02f,
  2.46587638e-02f, 2.23512612e-02f, 1.39078358e-02f, -3.83682773e-02f, -2.66921278e-02f, 3.39303985e-02f, 5.47968969e-02f, -9.17455330e-02f, 1.10734731e-01f, -6.79742247e-02f,
  -3.14619333e-01f, 2.71006394e-02f, -1.43043920e-01f, -2.33428210e-01f, 2.06133947e-01f, 1.87609047e-01f, 6.59074634e-02f, 1.08736709e-01f, -3.04533899e-01f, 1.23708487e-01f,
  1.94588065e-01f, -3.80766988e-01f, 1.35766968e-01f, 1.82129871e-02f, -1.25618011e-01f, 6.57599717e-02f, -1.38765737e-01f, -1.69716820e-01f, -1.77377090e-01f, -5.86165711e-02f,
  -1.14215255e-01f, 1.68351963e-01f, 6.72246590e-02f, 9.41173285e-02f, 2.23168463e-01f, -1.24992736e-01f, 1.97341472e-01f, 8.23687688e-02f, 1.50846802e-02f, -3.01820319e-02f,
  1.07710958e-01f, -4.90642227e-02f, 1.18429624e-02f, -2.24250965e-02f, 4.21435609e-02f, 1.15887471e-01f, -4.91435193e-02f, -2.32538600e-02f, -5.60369454e-02f, -4.24265787e-02f,
  -2.68728323e-02f, -3.90775315e-02f, -1.87307701e-01f, -7.06438646e-02f, 1.03532344e-01f, -3.06969862e-02f, 5.52015752e-02f, 2.55620992e-03f, -2.20988393e-02f, 4.76407111e-02f,
  8.52222890e-02f, -2.84538623e-02f, -1.59063824e-02f, -1.18641339e-01f, -1.03418138e-02f, -3.83030772e-02f, -3.50189023e-02f, -2.08907183e-02f, 3.71187972e-03f, -3.14611150e-03f,
  -6.95448518e-02f, -4.23312113e-02f, 7.23209418e-03f, 4.76759300e-02f, 6.79161921e-02f, 5.96302934e-02f, -4.85342517e-02f, -1.78568941e-02f, -6.36110902e-02f, 3.98354456e-02f,
  6.50024042e-02f, -2.84287194e-03f, 1.24120703e-02f, -6.08877093e-03f, 1.56388804e-03f, -9.37299579e-02f, -2.89754868e-02f, 4.37445417e-02f, -4.49084565e-02f, 6.14980347e-02f,
  4.07138430e-02f, 2.85231285e-02f, -2.36604288e-02f, 7.42383003e-02f, 7.39840791e-02f, -6.27628863e-02f, -7.54630938e-03f, 5.49497530e-02f, 5.62610365e-02f, 1.41423307e-02f,
  7.13121742e-02f, -1.25972047e-01f, 3.73345576e-02f, -4.28495333e-02f, -1.28910467e-02f, 1.34905085e-01f, -2.11016107e-02f, -2.48701833e-02f, -2.71182004e-02f, -5.62560325e-03f,
  -3.71325538e-02f, 5.70899025e-02f, -2.04009842e-02f, -5.67887351e-02f, 2.15954217e-03f, 5.19313477e-02f, -1.27584606e-01f, -5.67935444e-02f, -2.81718317e-02f, -1.00083314e-01f,
  3.01471874e-02f, -6.75889403e-02f, 2.35532727e-02f, 8.00099894e-02f, 2.48876214e-02f, -1.67231727e-02f, -6.70081377e-02f, -4.57712859e-02f, 5.85396364e-02f, -1.41679030e-02f,
  1.03970848e-01f, -3.69049549e-01f, 2.83458889e-01f, 5.67365922e-02f, 1.26495257e-01f, 9.54840556e-02f, -4.98080887e-02f, 6.83374330e-02f, 4.23282683e-02f, -3.56534958e-01f,
  -8.88856128e-02f, 3.68245994e-03f, -1.11111343e-01f, -8.97943303e-02f, 1.74450576e-01f, -4.82125767e-02f, -7.51592889e-02f, -1.36079028e-01f, 5.32337502e-02f, -6.42376095e-02f,
  9.41538885e-02f, -1.08823627e-01f, 3.70589755e-02f, 3.94463427e-02f, 2.14397497e-02f, 8.66428241e-02f, -8.15874115e-02f, 1.31173536e-01f, -1.74033903e-02f, 8.87183249e-02f,
  -7.94930086e-02f, -4.02098596e-02f, -7.31344447e-02f, 3.58941453e-03f, -4.70204651e-02f, -5.56263179e-02f, 9.08218790e-03f, 5.71101084e-02f, 4.78895428e-03f, -2.01467145e-03f,
  -1.46943387e-02f, 4.60515805e-02f, 2.29492821e-02f, -2.02555228e-02f, -3.19113582e-02f, 3.20950411e-02f, 3.28030474e-02f, 1.15746083e-02f, 2.40828618e-02f, 6.94425851e-02f,
  1.04282573e-02f, 3.03183533e-02f, 1.79536231e-02f, -7.04498636e-03f, 6.52325973e-02f, 3.48688997e-02f, 5.87372258e-02f, 3.07796374e-02f, -4.64071408e-02f, 2.07952876e-02f,
  7.22088665e-02f, -6.69661239e-02f, -9.95776244e-03f, 1.27462263e-04f, 2.97315624e-02f, 3.79135348e-02f, -6.08317107e-02f, 3.39210709e-03f, 2.20245905e-02f, -3.09131648e-02f,
  4.44003120e-02f, -1.84270157e-03f, 3.05725243e-02f, -1.43747339e-02f, -3.37355137e-02f, -1.18280677e-02f, 1.22407367e-02f, 1.34719145e-02f, -8.07385426e-03f, 5.75887747e-02f,
  -1.03128366e-02f, -1.56974944e-03f, -6.29087687e-02f, -7.67320534e-03f, -4.96517820e-03f, -1.89298242e-02f, -2.18097847e-02f, 5.34720272e-02f, -3.14179924e-03f, 4.66159880e-02f,
  -2.32236877e-01f, -2.27827281e-01f, -7.58371800e-02f, -5.17922379e-02f, -3.33977863e-02f, -1.62413474e-02f, 2.68457010e-02f, -4.45775799e-02f, -4.26458269e-02f, -2.07017977e-02f,
  -3.24538536e-02f, -4.89144959e-03f, -8.24302249e-03f, 2.16498263e-02f, -2.87786592e-03f, -2.27694660e-02f, -9.93087292e-02f, -5.43492436e-02f, -8.61893743e-02f, -2.49406099e-02f,
  -2.70264950e-02f, -2.96429135e-02f, 5.42616062e-02f, -4.09950921e-03f, -4.97366488e-02f, -1.78092122e-02f, -3.21934093e-03f, 3.37019600e-02f, 4.76224832e-02f, -2.70612426e-02f,
  1.59405872e-01f, 3.03366799e-02f, 3.32197100e-01f, 9.83215645e-02f, 9.85372812e-02f, -1.22173831e-01f, -2.65762180e-01f, -3.57977897e-02f, 4.67252806e-02f, -3.73449385e-01f,
  -2.71882355e-01f, -1.18721657e-01f, -2.43425146e-01f, -2.19377667e-01f, -5.19576902e-03f, -1.05299979e-01f, -2.46237088e-02f, -3.83797884e-02f, 5.55996262e-02f, -1.53340688e-02f,
  1.54945299e-01f, -2.38230094e-01f, 7.54785389e-02f, -1.45888543e-02f, -5.95796704e-02f, 1.35178879e-01f, -1.44446671e-01f, -7.30091631e-02f, -2.02611852e-02f, -1.07870735e-01f,
  8.52756500e-02f, 2.86983186e-03f, 8.57638791e-02f, 5.20995818e-02f, 5.58695830e-02f, 3.72026116e-02f, 1.30473860e-02f, -6.30383715e-02f, 3.88357081e-02f, 1.54909305e-02f,
  -1.47950025e-02f, 3.97737026e-02f, -2.34014448e-02f, -1.59744322e-02f, 6.48638373e-03f, 6.03544116e-02f, 3.38473879e-02f, 6.38721213e-02f, -2.23620795e-02f, -6.16910867e-03f,
  1.03297306e-03f, 6.61700517e-02f, 4.15560901e-02f, -3.11059467e-02f, 4.03400734e-02f, -3.74010974e-03f, -5.82231022e-03f, -2.38854233e-02f, 1.14382980e-02f, 7.92815164e-02f,
  7.31151085e-03f, -1.99599378e-03f, 1.86802149e-02f, 1.87949184e-02f, 2.10141670e-02f, 2.32902728e-02f, -7.03346282e-02f, -3.71098444e-02f, 3.20702903e-02f, -5.00675663e-02f,
  2.70082019e-02f, 9.57134292e-02f, -3.63469236e-02f, -1.68528464e-02f, -1.70321576e-02f, -2.26626582e-02f, -2.21753418e-02f, -5.52816428e-02f, 3.42619941e-02f, 4.79124077e-02f,
  -4.56338711e-02f, -1.15216896e-02f, -3.53116468e-02f, -3.67108994e-04f, -2.45745424e-02f, -3.72718312e-02f, -3.06692123e-02f, 1.50676994e-02f, -1.62925050e-02f, 2.22119247e-03f,
  -1.48754120e-01f, -2.23393857e-01f, -3.02723348e-02f, -4.67487425e-02f, 1.62209533e-02f, 3.17494832e-02f, 6.68928260e-03f, 4.33305763e-02f, -6.27498180e-02f, -3.18125598e-02f,
  3.41144763e-02f, 4.95995954e-03f, 2.71300226e-02f, -2.09188741e-02f, -2.36602891e-02f, -5.17927855e-03f, -5.74266613e-02f, 3.07116322e-02f, -3.01757380e-02f, -2.61628702e-02f,
  -4.20887663e-04f, -7.23618343e-02f, -9.38412792e-04f, -1.45800970e-02f, 7.36302510e-03f, -1.94376837e-02f, 9.60568711e-03f, 5.20627759e-02f, 1.05234538e-03f, -1.41101889e-02f,
  -3.04344535e-01f, 6.27075136e-02f, 4.05109584e-01f, -2.75969747e-02f, -1.21197559e-01f, -2.20683649e-01f, -1.78226139e-02f, -5.40925339e-02f, -1.27864271e-01f, -4.03819717e-02f,
  -8.33002571e-03f, 8.39548334e-02f, 1.04863279e-01f, -2.47276753e-01f, -2.93276101e-01f, -7.43231643e-03f, -2.11479619e-01f, -9.52334478e-02f, 2.48480756e-02f, -1.69941355e-02f,
  -2.13347804e-02f, -2.96532691e-01f, 1.55005515e-01f, -8.51000324e-02f, -7.21188355e-03f, 1.64130896e-01f, 5.06458862e-04f, 2.06491023e-01f, -1.13092311e-01f, -9.90373567e-02f,
  -3.62469144e-02f, -5.84998576e-04f, 4.54370789e-02f, 5.05795889e-03f, -1.17171286e-02f, -3.86033654e-02f, 7.82370269e-02f, 1.53462272e-02f, -2.00622366e-03f, -1.95311029e-02f,
  2.43595149e-02f, -2.60208454e-02f, -5.93548939e-02f, -4.12523262e-02f, 1.21825282e-03f, 2.53438540e-02f, 9.93017573e-03f, 7.09940866e-02f, 2.82315314e-02f, 3.69063281e-02f,
  8.20623785e-02f, 7.48890489e-02f, 5.02911918e-02f, 2.82436907e-02f, 7.90616274e-02f, 7.96265621e-03f, 3.17914411e-02f, 6.73949420e-02f, -2.82743219e-02f, -9.55732465e-02f,
  -1.48646042e-01f, 3.10135279e-02f, 2.70971041e-02f, 2.55237389e-02f, -2.36372184e-02f, 2.10303310e-02f, 3.52571458e-02f, -5.20472182e-03f, 7.54556060e-02f, -1.88704359e-03f,
  -1.09185204e-02f, 3.78139466e-02f, -4.93265502e-02f, 5.86799392e-03f, -2.61435360e-02f, 8.78896192e-03f, 1.17332421e-01f, -3.48643064e-02f, 4.23202552e-02f, 2.22299490e-02f,
  7.72276297e-02f, -2.94854008e-02f, 1.85672082e-02f, 4.19339724e-02f, -3.53278313e-03f, 4.08257954e-02f, 7.25250226e-03f, 1.92628354e-02f, -9.12540872e-03f, -8.82238802e-03f,
  -8.58469158e-02f, -1.25269592e-01f, 1.32610593e-02f, -1.85154527e-02f, 5.63186742e-02f, -7.59901553e-02f, -7.43203657e-03f, -2.71270081e-04f, -3.07136085e-02f, -8.76459032e-02f,
  -3.58007243e-03f, 4.82933372e-02f, 4.29015681e-02f, -4.62644324e-02f, 2.63592172e-02f, 2.94269738e-03f, 1.21384747e-02f, 1.28318705e-02f, 2.63131727e-02f, -8.30919296e-03f,
  5.04118167e-02f, 1.12300618e-02f, -1.85581427e-02f, -7.54534602e-02f, -2.35048216e-02f, 5.40729146e-03f, -3.36588360e-02f, 1.74055621e-02f, -2.97257900e-02f, 5.52677587e-02f,
  1.31748006e-01f, -2.40615427e-01f, -3.39960486e-01f, -3.35268443e-04f, -6.56477700e-04f, -5.65505102e-02f, 3.63271846e-03f, -9.88640413e-02f, 9.00424868e-02f, 2.11893275e-01f,
  2.47347996e-01f, -8.75498056e-02f, -5.30962832e-02f, 1.71948373e-01f, -3.89301330e-01f, 2.08327081e-02f, -1.37346476e-01f, 1.25361994e-01f, -1.41427919e-01f, 9.35532749e-02f,
  -2.53372137e-02f, 1.45229489e-01f, -2.13244483e-01f, -1.31682649e-01f, -3.00935283e-02f, -2.66203843e-02f, -2.15209043e-03f, -2.01501191e-01f, 2.85082478e-02f, -1.19863927e-01f,
  4.98661362e-02f, 8.22812244e-02f, -6.08233735e-02f, -9.40354019e-02f, 3.87231484e-02f, 2.86725219e-02f, 3.65346968e-02f, -1.10600673e-01f, -1.16236567e-01f, 3.42551209e-02f,
  6.71388581e-02f, -6.75207376e-03f, 3.45722102e-02f, -5.47030009e-02f, 4.55910712e-02f, -3.34981829e-02f, 8.45886692e-02f, 6.86702877e-02f, -2.75664851e-02f, 1.96927469e-02f,
  6.85069803e-03f, 1.86820515e-02f, 1.36832595e-01f, 4.23533395e-02f, -4.24451977e-02f, 6.54908270e-02f, -3.97764035e-02f, -1.16011277e-02f, -4.47483845e-02f, -1.81544665e-02f,
  1.11033358e-01f, -7.59924352e-02f, 2.61673238e-03f, -5.09997010e-02f, -6.71977848e-02f, 7.07452372e-02f, -3.49284559e-02f, 7.41667598e-02f, -1.93952601e-02f, 6.72885741e-04f,
  -2.47089695e-02f, -4.29022275e-02f, 6.03914224e-02f, -8.80754143e-02f, 4.63543981e-02f, 3.67374048e-02f, 3.69738834e-03f, 7.64038414e-02f, 3.15015018e-02f, -3.89031731e-02f,
  -3.69065953e-03f, -3.07308999e-03f, -9.37046185e-02f, 3.07237217e-03f, -4.61708866e-02f, 4.32899483e-02f, 9.23915282e-02f, 3.90390605e-02f, 4.53203097e-02f, -5.56228943e-02f,
  -1.02598302e-01f, -1.20126620e-01f, -1.91163328e-02f, 2.11335775e-02f, -4.11856808e-02f, 1.57224219e-02f, 1.09557854e-02f, 2.79765185e-02f, -1.02079898e-01f, -1.39730703e-02f,
  1.33608371e-01f, 6.66002408e-02f, -1.02757979e-02f, 7.47273192e-02f, -3.20513584e-02f, -2.57945694e-02f, 5.75188883e-02f, -4.95386831e-02f, -3.26620438e-03f, -1.46748452e-02f,
  -1.49598094e-02f, 3.93245965e-02f, -1.47457412e-02f, -5.15502412e-04f, 7.67699853e-02f, 3.88533175e-02f, 6.71014264e-02f, -2.94392500e-02f, 1.48468046e-02f, -6.49678484e-02f,
  -3.60087305e-01f, -1.94191426e-01f, -2.33856991e-01f, -2.28216946e-01f, 4.65329923e-02f, 1.93900332e-01f, -1.59881890e-01f, -1.76335990e-01f, -3.36565793e-01f, 4.81136926e-02f,
  3.54417600e-02f, -2.49681428e-01f, -4.42606732e-02f, 1.99169852e-02f, 1.72645971e-01f, 1.39010727e-01f, 1.23470522e-01f, -1.52946403e-03f, 1.79393589e-03f, -1.19246870e-01f,
  2.22196579e-02f, 2.01349214e-01f, 1.81565672e-01f, 1.44205645e-01f, -8.93334970e-02f, -1.20565072e-01f, 2.10443243e-01f, -3.68343033e-02f, 1.02728911e-01f, 7.92704672e-02f,
  1.58719987e-01f, -2.03327641e-01f, -1.14018165e-01f, -6.85406402e-02f, 8.49825069e-02f, -5.86809916e-03f, 1.91155933e-02f, 4.42713611e-02f, -4.38962765e-02f, 2.30030380e-02f,
  -3.70788537e-02f, -1.03844861e-02f, -2.11060178e-02f, 1.29774669e-02f, -4.26244289e-02f, -2.08271313e-02f, -2.16286499e-02f, 4.43446375e-02f, -1.08859949e-01f, 2.10394170e-02f,
  -7.68442005e-02f, 3.52637507e-02f, -1.94916520e-02f, 4.00377139e-02f, -2.78651025e-02f, 2.63114329e-02f, 4.81381528e-02f, 1.44978520e-02f, 1.35318935e-03f, -3.07185040e-03f,
  9.50613618e-03f, -4.69855033e-02f, -1.83198769e-02f, 4.83353995e-02f, -6.17223307e-02f, 1.22248633e-02f, -7.90607929e-03f, 7.64956549e-02f, -3.19297425e-03f, 9.26041454e-02f,
  3.55960168e-02f, -6.20083697e-02f, -3.71641479e-02f, 3.55948992e-02f, 3.61095630e-02f, 5.59874587e-02f, 7.25584477e-02f, -1.81457791e-02f, -2.73056217e-02f, 1.09301433e-01f,
  6.13876898e-03f, -4.36199736e-03f, 1.15612783e-02f, -9.48765781e-03f, 3.35535556e-02f, 2.47542956e-03f, -1.09026544e-02f, 3.63852270e-02f, 2.91245673e-02f, -1.16908196e-02f,
  5.52608892e-02f, -9.37742293e-02f, 3.23195331e-04f, 3.96116711e-02f, -1.56641100e-02f, 5.12819104e-02f, -9.65439621e-03f, 2.84625348e-02f, -8.30577593e-03f, -2.89115366e-02f,
  4.42716032e-02f, -2.95740794e-02f, 6.29370213e-02f, 4.48684320e-02f, 5.38472682e-02f, 8.31912830e-03f, 3.01614888e-02f, 2.05856934e-02f, 2.40238104e-02f, 2.67841946e-02f,
  4.24723104e-02f, 2.80374903e-02f, -3.78720164e-02f, 2.61034258e-02f, -4.75984160e-03f, -1.25218183e-02f, -3.90737653e-02f, -3.54857463e-03f, 5.42386509e-02f, -2.95401774e-02f,
  -2.40996242e-01f, 3.35527867e-01f, 1.16464093e-01f, -1.61567211e-01f, 1.38726190e-01f, 2.75878459e-01f, 1.00391097e-01f, 2.78149284e-02f, -3.42908204e-02f, -5.91447875e-02f,
  5.17525114e-02f, 1.54767349e-01f, 1.05398647e-01f, 8.11416879e-02f, 7.18853250e-02f, 2.96376981e-02f, 4.02107351e-02f, 3.81974243e-02f, 1.51135065e-02f, 4.04310739e-03f,
  -1.19544109e-02f, 2.08857469e-02f, 4.26136479e-02f, 4.17656787e-02f, 1.45752326e-01f, -1.35175407e-01f, -2.07425967e-01f, 2.12948099e-02f, -7.12441094e-03f, 9.19532403e-02f,
  2.00991500e-02f, -2.12353885e-01f, 7.10249990e-02f, -1.91142485e-02f, -1.40928039e-02f, -3.21132913e-02f, -2.36076284e-02f, 5.16524762e-02f, 3.68369115e-03f, 3.55648436e-02f,
  8.53405148e-02f, 5.78013025e-02f, -4.38380102e-03f, 1.73639059e-02f, 3.79179865e-02f, 4.47055437e-02f, 5.13760485e-02f, 7.35372975e-02f, 4.26934175e-02f, 5.80302738e-02f,
  7.93466344e-02f, 3.70734036e-02f, -1.68701466e-02f, -1.23719033e-02f, 1.05608236e-02f, -6.65767789e-02f, 1.73103926e-03f, 3.54969501e-02f, -1.37936650e-02f, -4.79759909e-02f,
  -2.82039046e-02f, 2.23877095e-02f, 9.80825257e-03f, 1.40131533e-05f, 3.49098220e-02f, -3.69558334e-02f, -1.40460138e-03f, 1.33243734e-02f, -5.00460975e-02f, -1.04284538e-02f,
  1.95640530e-02f, 3.22037973e-02f, -2.61571798e-02f, -3.21026072e-02f, -5.31481318e-02f, -5.06865233e-02f, 4.57247980e-02f, 7.52769690e-03f, 8.16146936e-03f, -2.62313262e-02f,
  -3.98833677e-02f, -2.42086779e-02f, 2.03023311e-02f, 2.45558452e-02f, 6.93646073e-02f, 1.48637407e-02f, 2.65360903e-02f, -1.53581304e-02f, -3.24339084e-02f, 2.78726127e-02f,
  -1.92285050e-02f, -2.73030370e-01f, -3.89186740e-02f, -2.51924321e-02f, 4.81008030e-02f, 2.02225056e-02f, 4.54544909e-02f, 4.77020862e-03f, -6.34713918e-02f, -2.03691740e-02f,
  -6.45299479e-02f, -8.69566798e-02f, -2.46564336e-02f, -2.13838071e-02f, 4.99236137e-02f, 1.62952654e-02f, -4.65014800e-02f, -6.56485409e-02f, -5.85045181e-02f, 2.91338917e-02f,
  -2.44184751e-02f, 1.36452923e-02f, -3.71485800e-02f, -7.66539574e-02f, -1.62453428e-02f, -2.63200272e-02f, -1.03894956e-02f, -1.17800673e-02f, -1.41179096e-02f, 4.86655207e-03f,
  -8.47739652e-02f, -3.23673487e-01f, -2.21621692e-01f, -1.67212635e-01f, 2.12681755e-01f, -2.47047722e-01f, -2.88011700e-01f, 6.66887760e-02f, -2.39339713e-02f, -9.06273648e-02f,
  -1.23541486e-02f, -2.58906215e-01f, -1.79686859e-01f, -2.56183743e-01f, -1.72690079e-01f, -2.24532843e-01f, -2.63411909e-01f, -1.80783048e-01f, 2.81851683e-02f, -7.46267661e-02f,
  -5.92778176e-02f, 5.72492033e-02f, -2.23864347e-01f, 2.56160349e-01f, -5.88647500e-02f, 1.54486775e-01f, 2.46528283e-01f, 1.17003642e-01f, 3.07224412e-02f, 2.89439280e-02f,
  -1.39725044e-01f, -2.96596885e-02f, -3.20596211e-02f, 2.21615173e-02f, -2.20146310e-02f, 1.27798794e-02f, -4.28862870e-02f, -3.13136838e-02f, 4.57313173e-02f, 2.14047283e-02f,
  -5.09721488e-02f, 5.92802763e-02f, 1.96680184e-02f, 4.11588326e-02f, 2.13093380e-03f, 1.36840129e-02f, -1.22208307e-02f, -7.63435736e-02f, 2.16529183e-02f, -1.35801524e-01f,
  -1.17412135e-01f, -6.72456399e-02f, -2.79408861e-02f, -2.97944192e-02f, -3.04757617e-02f, -2.63282973e-02f, -4.45186011e-02f, -6.99726269e-02f, -3.56542729e-02f, 4.65648016e-03f,
  4.03681248e-02f, -1.47552285e-02f, -4.69637550e-02f, 5.65618537e-02f, 2.25853012e-03f, 1.68379284e-02f, -3.15833725e-02f, 2.21790150e-02f, 1.44824432e-02f, -8.27922001e-02f,
  7.48933777e-02f, 2.88036512e-03f, 5.46002686e-02f, 3.98364803e-03f, -1.96756627e-02f, 4.92428779e-04f, -3.44690681e-03f, -3.78770716e-02f, 5.17801605e-02f, 6.17583888e-03f,
  4.78721932e-02f, -3.97505052e-02f, 7.83373602e-03f, 2.15955116e-02f, -2.69841477e-02f, 1.67846903e-02f, 4.14224975e-02f, -2.70415433e-02f, -3.97423282e-03f, -1.96222868e-02f,
  -4.37210239e-02f, -6.89311251e-02f, 1.08687673e-02f, 1.96173023e-02f, -2.83457357e-02f, 2.40363944e-02f, -6.58633783e-02f, 4.21321020e-02f, 1.68398153e-02f, 6.73138127e-02f,
  3.16996053e-02f, -1.41776223e-02f, 4.53860201e-02f, 2.99568605e-02f, 1.63024273e-02f, -2.52965596e-02f, -5.42311706e-02f, 9.02727842e-02f, 1.79539286e-02f, 3.65286246e-02f,
  3.07279322e-02f, -2.83791758e-02f, 5.29500134e-02f, 5.22536337e-02f, -1.81862095e-03f, 5.12654614e-03f, 6.61226513e-04f, 5.41826412e-02f, -4.25770413e-03f, -4.47471887e-02f,
  -8.94526169e-02f, 5.91575317e-02f, 2.05174893e-01f, 2.30883718e-01f, -3.29686314e-01f, -1.93291813e-01f, 9.26670954e-02f, -5.50489537e-02f, 1.48577482e-01f, -9.19463951e-03f,
  -5.13907112e-02f, -1.16871521e-02f, -4.34402898e-02f, 1.68782532e-01f, 1.29613169e-02f, 8.79497454e-02f, 2.42787093e-01f, 5.33805229e-02f, 7.40780458e-02f, 5.71699515e-02f,
  7.51836449e-02f, -2.10055783e-02f, 1.99918777e-01f, -1.04803734e-01f, -3.72608975e-02f, 8.71703625e-02f, -4.24881503e-02f, -1.57578904e-02f, -3.46803218e-02f, -3.18055414e-02f,
  -1.08122811e-01f, 1.16619341e-01f, 6.83242604e-02f, 8.12774077e-02f, 2.14724708e-02f, -4.95627634e-02f, 7.74932699e-03f, 5.44054620e-03f, 3.15802060e-02f, 6.18576817e-02f,
  -3.30092311e-02f, -4.20935377e-02f, 4.33911495e-02f, 5.67285120e-02f, -6.34159967e-02f, 3.34404260e-02f, 3.12458966e-02f, -1.33059677e-02f, 4.58706319e-02f, -3.20751555e-02f,
  5.15471995e-02f, 3.27752046e-02f, 3.37625220e-02f, 5.15325926e-02f, 3.88312638e-02f, 1.27220359e-02f, 7.66920224e-02f, -1.87137220e-02f, -6.47311360e-02f, -6.55608485e-03f,
  3.16459686e-02f, -2.78070420e-02f, -4.69640940e-02f, 3.03081376e-03f, -2.14320924e-02f, 7.99184851e-03f, -6.17427239e-03f, -2.20948793e-02f, 5.81520097e-03f, -5.92956170e-02f,
  -7.59432390e-02f, 2.55278521e-03f, -1.00671472e-02f, -1.67165603e-02f, 2.89906729e-02f, 7.54178390e-02f, -2.43251845e-02f, -4.50939871e-02f, 2.93387379e-02f, -1.95518676e-02f,
  2.23541893e-02f, -3.25139798e-02f, 3.40844854e-03f, -4.91992524e-03f, 3.46491858e-02f, -1.61072090e-02f, 2.75593791e-02f, 1.72204152e-02f, 1.87306516e-02f, -5.63846231e-02f,
  -3.03388417e-01f, -9.69953611e-02f, 6.71221828e-03f, -1.42440081e-01f, -2.46825698e-03f, -4.58374694e-02f, 7.62143880e-02f, 4.15136805e-03f, -3.73975746e-02f, 1.57813597e-02f,
  -2.02066917e-02f, 2.42256690e-02f, -9.63105485e-02f, 4.04732190e-02f, -1.76443625e-02f, -3.00807580e-02f, 1.63341537e-02f, 3.43287960e-02f, -6.00440092e-02f, -6.71147332e-02f,
  4.12170589e-02f, -7.22302720e-02f, 3.76826376e-02f, 2.97524780e-02f, -6.23205910e-03f, -3.85415442e-02f, -3.25721614e-02f, 3.15189287e-02f, -7.75937289e-02f, 5.20764925e-02f,
  4.29015219e-01f, -2.55838186e-01f, 2.28965893e-01f, 1.40768275e-01f, -8.41861069e-02f, -2.28860408e-01f, -2.53990069e-02f, 1.17711149e-01f, 1.15605235e-01f, -6.87967390e-02f,
  -4.97640781e-02f, 2.48350203e-02f, 2.61089988e-02f, -1.24381162e-01f, -1.21606542e-02f, -8.05162936e-02f, -6.91068247e-02f, 2.11353768e-02f, -5.23795001e-02f, 9.05704647e-02f,
  3.67357619e-02f, -1.66335553e-01f, 7.31910169e-02f, -1.94253266e-01f, 7.22557083e-02f, 1.25875860e-01f, 1.32422686e-01f, -6.85281120e-03f, -1.33872047e-01f, -8.18333700e-02f,
  2.84898095e-02f, 2.72399426e-01f, 1.63917810e-01f, 8.31538662e-02f, 2.99010593e-02f, 8.60344544e-02f, 8.87617171e-02f, -3.58618749e-03f, 4.28156927e-02f, -1.66656375e-02f,
  9.51442122e-03f, -1.85110308e-02f, -4.07410190e-02f, -5.38483635e-03f, 4.69950773e-02f, 4.04842794e-02f, -1.61405671e-02f, -3.43379751e-03f, 2.68973410e-02f, 2.20237616e-02f,
  -3.80821005e-02f, -3.95371020e-03f, 6.20258003e-02f, 9.93301626e-03f, 4.71783653e-02f, 1.18904617e-02f, 1.98423881e-02f, 2.57865470e-02f, 1.09509500e-02f, 5.07553853e-02f,
  -4.94646374e-03f, 2.66826935e-02f, 1.96548365e-02f, -6.06693607e-03f, -5.62261194e-02f, -4.82752956e-02f, 2.56568287e-02f, -1.14414254e-02f, 2.79275924e-02f, -1.36709772e-02f,
  -7.65975639e-02f, 2.12585796e-02f, 6.48042560e-02f, 1.31213125e-02f, 4.69787978e-02f, 2.13856134e-03f, 1.85613614e-02f, 1.15200505e-02f, -5.15511148e-02f, -7.96357822e-03f,
  6.08945712e-02f, -2.70476323e-02f, -2.26322059e-02f, 1.68921407e-02f, -4.35322709e-02f, 4.51410636e-02f, 3.71800847e-02f, -1.46809509e-02f, 3.60654294e-02f, 1.32956216e-02f,
  3.42641063e-02f, 2.18591407e-01f, 2.30888147e-02f, -8.71199649e-04f, -3.05965003e-02f, -2.59270351e-02f, 1.01828165e-02f, -2.38246638e-02f, 7.23511213e-03f, 1.51700312e-02f,
  5.33288456e-02f, 5.55685759e-02f, -2.52850465e-02f, 2.14650622e-03f, -5.83397299e-02f, 4.08600159e-02f, -1.00102660e-03f, 5.21183349e-02f, 5.60245179e-02f, -1.57380253e-02f,
  6.27344996e-02f, -1.43717397e-02f, 1.63844712e-02f, 3.32302824e-02f, -4.21925038e-02f, -1.52157461e-02f, 2.11322084e-02f, -5.47784530e-02f, 5.74373687e-03f, -3.23016904e-02f,
  9.03866664e-02f, -2.15058804e-01f, 4.22805585e-02f, 2.15770707e-01f, 2.56344110e-01f, -1.22488201e-01f, -1.73769891e-01f, 2.07390562e-02f, -1.47291586e-01f, -4.81561452e-01f,
  3.13377846e-03f, -1.97411284e-01f, -1.71976775e-01f, -1.25123514e-02f, 1.90823019e-01f, 5.09875268e-03f, 8.95388797e-02f, 1.85488593e-02f, 1.75489008e-01f, 2.22440466e-01f,
  2.76828378e-01f, 2.12068021e-01f, 2.14100957e-01f, 2.04095572e-01f, 1.71421215e-01f, -3.96518521e-02f, 3.52281854e-02f, -2.43235324e-02f, -2.92050447e-02f, -1.01222888e-01f,
  -4.82460521e-02f, 4.08494659e-03f, 4.07310314e-02f, -1.11568421e-01f, -5.93063282e-03f, -5.83220236e-02f, -6.44769371e-02f, -1.61824413e-02f, 4.35471982e-02f, 1.33880526e-02f,
  -4.13386859e-02f, 5.75480144e-03f, -3.06444950e-02f, -3.50469574e-02f, 1.67122502e-02f, 1.26050098e-03f, 1.85947735e-02f, 2.24558990e-02f, -7.00203003e-03f, -3.66106816e-03f,
  -7.65647786e-03f, -3.59167084e-02f, 5.66347279e-02f, -5.10461396e-04f, 1.68110970e-02f, -3.21707949e-02f, -7.54634887e-02f, -6.14626557e-02f, -1.42335398e-02f, 1.91341375e-03f,
  -5.79869598e-02f, 7.48841763e-02f, 7.96270594e-02f, 8.91298130e-02f, -2.16127802e-02f, -1.03611024e-02f, 8.37485567e-02f, -1.99343096e-02f, -7.16238981e-03f, -4.85964380e-02f,
  -1.36490138e-02f, 7.82949030e-02f, 4.69470806e-02f, 2.73730373e-03f, 1.39096314e-02f, -1.20569486e-02f, 1.04251429e-01f, -2.90093049e-02f, -3.45430546e-03f, -1.34888925e-02f,
  7.00617284e-02f, 1.70261189e-02f, -6.17234148e-02f, 7.89274368e-03f, -4.33208868e-02f, 1.25039900e-02f, -4.21758508e-03f, -8.75191018e-02f, 6.86156452e-02f, 1.68048497e-02f,
  -6.51135892e-02f, -1.16979837e-01f, 1.36708682e-02f, -2.04912480e-02f, -1.28546730e-02f, 5.28634675e-02f, 3.10118552e-02f, 6.97751716e-02f, -6.65589049e-02f, 1.54561382e-02f,
  2.58468948e-02f, -3.87861542e-02f, -4.40598726e-02f, 1.37564633e-02f, 6.39529228e-02f, -2.82365941e-02f, 1.33693218e-02f, -6.20272830e-02f, 8.19496065e-02f, -5.73033318e-02f,
  -9.22857504e-03f, 2.83425115e-02f, -1.59020920e-03f, 8.13840702e-02f, 3.15500274e-02f, -8.47585127e-02f, 4.33108732e-02f, -4.65516485e-02f, 4.73048277e-02f, -3.40173244e-02f,
  1.95592314e-01f, -9.16910395e-02f, 1.93976611e-01f, -7.79393613e-02f, 1.29657477e-01f, -4.92539406e-02f, 6.36074767e-02f, 1.79614481e-02f, 5.04953787e-02f, -1.93867579e-01f,
  -9.04375687e-02f, 6.74299970e-02f, 4.34658118e-03f, -2.99445778e-01f, -1.64338768e-01f, -2.40922108e-01f, -1.77375004e-01f, -1.31604195e-01f, -9.80047733e-02f, 5.49586006e-02f,
  -6.05657063e-02f, -2.85788953e-01f, -7.24402294e-02f, -1.08672298e-01f, 8.32387060e-02f, 1.05271913e-01f, -4.75246944e-02f, 7.80105740e-02f, -7.81358406e-02f, -1.40715092e-02f,
  -6.26119673e-02f, -2.98492163e-02f, 1.95369333e-01f, -5.70304366e-03f, 3.73775586e-02f, 1.21835992e-01f, 9.86725241e-02f, 2.65318230e-02f, -4.43935953e-03f, -3.06804688e-03f,
  4.96435054e-02f, -3.09714931e-04f, -5.35318777e-02f, -5.44412434e-02f, 2.74616526e-03f, 4.28845398e-02f, -1.65617093e-02f, 4.11857218e-02f, 4.53299396e-02f, 4.11942117e-02f,
  4.03441712e-02f, 1.60719808e-02f, 2.49835774e-02f, -5.33586144e-02f, 2.09500827e-02f, -2.13845838e-02f, 7.44548906e-03f, 5.26935384e-02f, -8.53554904e-03f, -1.14759961e-02f,
  -6.96757250e-03f, 2.78505357e-03f, -9.98147577e-03f, -1.08727664e-02f, -6.63314909e-02f, 4.64635529e-02f, -3.78359258e-02f, 9.06286109e-03f, 1.27745336e-02f, -6.20071962e-02f,
  -2.20239125e-02f, 5.55422939e-02f, 2.23365589e-03f, -2.51849908e-02f, -2.20618658e-02f, 1.76882464e-02f, 6.60015084e-03f, 1.15673116e-03f, 8.45641270e-02f, 3.12419850e-02f,
  -1.14072394e-02f, 9.31668654e-03f, -4.54064924e-03f, 4.87085693e-02f, -3.69389802e-02f, -1.84796844e-02f, -2.18845513e-02f, 2.42235381e-02f, 3.49929072e-02f, 4.08887975e-02f,
  -1.65935814e-01f, -1.53148130e-01f, -3.27265612e-03f, -2.99881604e-02f, -5.29561862e-02f, 1.90735562e-03f, -1.53919158e-03f, -5.25833815e-02f, -7.88765997e-02f, -4.91066389e-02f,
  -5.72019955e-03f, 1.67457964e-02f, -1.34022785e-02f, 5.30591700e-03f, -3.51559184e-02f, -2.81312093e-02f, 2.78867707e-02f, 5.32424916e-03f, -1.57496575e-02f, 1.97511842e-03f,
  2.62567308e-03f, -3.62845249e-02f, -2.36412473e-02f, 3.09289396e-02f, 3.38939615e-02f, 1.17133847e-02f, 3.66510302e-02f, 1.89450905e-02f, -1.04582934e-02f, -3.04896198e-02f,
  -2.36951441e-01f, -3.47597271e-01f, -1.57690734e-01f, 4.25288901e-02f, 1.48768440e-01f, -1.71828181e-01f, 1.70776360e-02f, -7.15395436e-02f, -1.44832820e-01f, -6.96204901e-02f,
  1.83495596e-01f, -2.35809073e-01f, 1.79178938e-02f, -3.30129415e-02f, 2.57165153e-02f, -6.63984716e-02f, -5.41079454e-02f, -7.42733032e-02f, -9.00351927e-02f, -7.76762664e-02f,
  8.76361318e-03f, 2.11903319e-01f, 7.46795386e-02f, 4.58013266e-02f, 2.98694335e-02f, -8.16295072e-02f, 2.35397860e-01f, 5.49683087e-02f, 4.09937873e-02f, 9.75228995e-02f,
  -9.77607910e-03f, -3.44494195e-03f, 2.96095503e-03f, -8.54747444e-02f, 4.33314452e-03f, 4.90059927e-02f, -1.64304916e-02f, 3.80059220e-02f, 3.66288237e-02f, -3.80185172e-02f,
  -4.85433638e-02f, 1.24710333e-02f, -3.51288766e-02f, 2.39411388e-02f, -3.77509594e-02f, -2.04624850e-02f, -1.67928822e-02f, 9.82822385e-03f, -4.55589928e-02f, -1.13393590e-02f,
  -4.86989804e-02f, -7.16892863e-03f, 2.30626129e-02f, 1.86514631e-02f, -1.87302455e-02f, 1.64252780e-02f, -9.80265811e-03f, -1.01582156e-02f, -1.03370585e-04f, -5.64473011e-02f,
  3.20996866e-02f, -2.05266476e-02f, 5.92045113e-03f, -2.07991935e-02f, -3.72808077e-03f, 5.71939386e-02f, 6.28994033e-03f, 7.92007968e-02f, -7.72675173e-03f, 1.34855118e-02f,
  4.78408039e-02f, -7.33161811e-03f, 2.50258390e-02f, -3.58494446e-02f, 3.14306631e-03f, -9.38535109e-03f, 4.08731252e-02f, -2.92056799e-02f, -1.81381162e-02f, 2.32361481e-02f,
  3.09863612e-02f, -6.41241111e-03f, -1.29149552e-03f, 3.05963699e-02f, 9.27172974e-03f, -4.91465442e-02f, 9.50650405e-03f, -2.08751149e-02f, 2.89198458e-02f, 1.74404103e-02f,
  -6.78314120e-02f, -2.65123826e-02f, 2.87788417e-02f, -1.85715463e-02f, -1.57809835e-02f, -8.42532329e-03f, -2.56981850e-02f, -5.67053519e-02f, -2.76445299e-02f, -9.95046366e-03f,
  -1.06398305e-02f, 6.33277148e-02f, 4.14906675e-03f, 5.26020909e-03f, 1.95619091e-02f, 6.70195650e-03f, 3.75268422e-02f, 1.24839433e-02f, 7.04863667e-02f, 2.07206588e-02f,
  8.04987624e-02f, -1.34169161e-02f, 2.59502120e-02f, 2.26567667e-02f, 5.73564470e-02f, 4.57328223e-02f, -1.21203270e-02f, -4.08921093e-02f, 4.62119281e-02f, 2.79882178e-03f,
  -1.91352904e-01f, 1.75912946e-01f, 1.76041707e-01f, 9.24127400e-02f, -1.06527865e-01f, -1.84632957e-01f, -2.19694853e-01f, -3.98624353e-02f, -1.83013946e-01f, 4.64469790e-02f,
  4.93089408e-02f, 1.85369000e-01f, -1.21124141e-01f, 1.21683076e-01f, -2.61815667e-01f, -2.00579226e-01f, -3.53204980e-02f, -2.20655296e-02f, -3.47992964e-02f, -3.58907469e-02f,
  -1.13467090e-01f, -6.46808967e-02f, -4.31136265e-02f, 8.88984948e-02f, 5.81994727e-02f, 2.34373555e-01f, 1.11527406e-01f, 1.52166545e-01f, 2.80004442e-01f, 6.40702918e-02f,
  -4.64417301e-02f, 6.09617913e-03f, 1.94593798e-02f, 4.41302452e-03f, 8.17401276e-04f, -2.16873456e-02f, 4.30603065e-02f, 3.38032991e-02f, 2.43515074e-02f, 5.61160734e-03f,
  -7.36334641e-03f, 5.58517277e-02f, 7.31624514e-02f, -3.42391320e-02f, -1.55150052e-02f, 5.41804656e-02f, 3.71780084e-03f, -3.02181058e-02f, 1.02927173e-02f, -4.44327369e-02f,
  -1.13788852e-02f, 5.34095196e-03f, -3.20050633e-03f, 3.66873220e-02f, 2.03670729e-02f, 3.53931710e-02f, -3.00742984e-02f, 2.18561590e-02f, -3.68393166e-03f, 2.92463955e-02f,
  -4.14542854e-02f, -1.68849379e-02f, -5.53384759e-02f, -3.59750055e-02f, -6.00915179e-02f, 1.55397421e-02f, -4.19333205e-02f, -1.40341194e-02f, 8.76506940e-02f, 1.78957097e-02f,
  2.65021366e-03f, -1.46242268e-02f, -1.62831694e-02f, -4.51920368e-02f, -8.28269031e-03f, -4.27928716e-02f, -4.64357324e-02f, 8.14991593e-02f, -2.83311098e-03f, 3.74678671e-02f,
  3.33995000e-02f, 2.50722445e-03f, -9.97713301e-03f, 2.82638762e-02f, -6.25780672e-02f, -5.25018908e-02f, 7.05223158e-02f, -1.38172936e-02f, 2.13609282e-02f, -2.79719918e-03f,
  2.66765617e-02f, 1.46275103e-01f, 9.96105373e-03f, 7.67455157e-03f, 5.35776354e-02f, 4.27295873e-03f, 6.85267849e-03f, 2.55361274e-02f, -1.04118499e-03f, -5.69476411e-02f,
  -1.23333710e-03f, -7.24621862e-03f, 4.82123606e-02f, -9.14322119e-03f, 2.32242141e-02f, -8.38433392e-03f, -2.07359809e-02f, 4.19323221e-02f, 1.73916202e-02f, 6.70358017e-02f,
  5.92112914e-02f, 6.65413914e-03f, -1.35808624e-02f, -7.92989954e-02f, -1.56541145e-03f, 5.89299984e-02f, -5.64912893e-03f, -4.82340762e-03f, 6.66265637e-02f, 4.04183455e-02f,
  6.02442920e-02f, 2.67381191e-01f, -1.57915235e-01f, 8.74157324e-02f, -1.38928905e-01f, -3.01774979e-01f, 3.94895338e-02f, -7.18408003e-02f, 7.29050636e-02f, 2.18979567e-01f,
  6.81710988e-02f, 1.58353984e-01f, 1.84840381e-01f, 1.27847001e-01f, -2.59052906e-02f, 1.71004668e-01f, 3.88431475e-02f, 1.39058948e-01f, 1.20127201e-02f, 5.94406240e-02f,
  -6.89396039e-02f, 1.88362151e-01f, -3.97194959e-02f, -6.99829385e-02f, -5.15608229e-02f, -1.25402316e-01f, 7.59025738e-02f, -7.11676925e-02f, -8.02425593e-02f, 3.48097682e-02f,
  2.84295063e-02f, 1.64753482e-01f, -3.74867618e-02f, -2.75930129e-02f, -4.26403359e-02f, -4.00668941e-02f, -3.45139019e-02f, 2.05447115e-02f, -3.20257130e-03f, -2.38045119e-02f,
  5.62204467e-03f, -5.32646887e-02f, 2.72601154e-02f, 5.03397100e-02f, -2.36438602e-04f, -2.58933902e-02f, -7.77303353e-02f, -9.39327478e-02f, 2.33643316e-03f, -5.58392927e-02f,
  -2.24274099e-02f, -6.22550398e-02f, -8.79123583e-02f, 2.72915158e-02f, -9.69120115e-02f, -4.58615087e-02f, -8.49928111e-02f, -7.00446218e-02f, -2.19478551e-02f, -6.42034709e-02f,
  -2.78825723e-02f, -8.48311465e-03f, 5.10352664e-02f, 5.58795109e-02f, 2.44427063e-02f, -6.66571781e-03f, 2.05488149e-02f, -2.39117071e-02f, -6.58394350e-03f, -3.52078700e-03f,
  -5.50118126e-02f, -5.30063361e-03f, -2.40692161e-02f, -6.62569553e-02f, -2.09750663e-02f, 2.92253681e-02f, -1.76512115e-02f, -8.75974074e-03f, -2.27526110e-02f, -3.83532345e-02f,
  5.55017516e-02f, -2.40972154e-02f, 3.89198586e-02f, -1.39537249e-02f, 2.61291638e-02f, -1.74473077e-02f, -6.65102676e-02f, -4.72955965e-02f, -1.04557793e-03f, -3.13697048e-02f,
  7.33524710e-02f, 1.37381777e-01f, 3.44254188e-02f, 1.13911564e-02f, 7.13649169e-02f, -1.38533162e-02f, 4.08774205e-02f, -3.04992683e-02f, 4.05337699e-02f, 4.26924340e-02f,
  -9.21176523e-02f, -8.44650343e-03f, -3.05405334e-02f, -1.84990540e-02f, 4.70262580e-02f, 2.62548421e-02f, 3.35618071e-02f, 4.76580039e-02f, 1.43559044e-02f, 2.40289746e-03f,
  -7.71072414e-03f, -1.27090532e-02f, -3.31892967e-02f, -3.03647816e-02f, -2.92498004e-02f, -9.27477237e-03f, 3.25311907e-02f, -2.00813264e-02f, -5.42776398e-02f, 6.85822393e-04f,
  4.78841513e-01f, 4.89458330e-02f, -2.41209745e-01f, 5.56010157e-02f, 1.84736446e-01f, 1.54783800e-01f, 5.85037619e-02f, 2.37791408e-02f, 2.61031389e-01f, 2.67005414e-02f,
  6.04177900e-02f, 6.64217323e-02f, -4.99967933e-02f, -1.37812838e-01f, 1.48835769e-02f, -2.16101985e-02f, 3.83212976e-02f, 3.92983072e-02f, -5.61823435e-02f, -1.56632550e-02f,
  1.26387924e-03f, 8.12938437e-02f, -2.28276432e-01f, -8.11990350e-02f, -1.06379541e-03f, -3.94596048e-02f, -6.57030940e-02f, -1.65842846e-01f, -1.02750517e-01f, -1.15243467e-02f,
  8.66970494e-02f, 9.23097413e-03f, -7.05784634e-02f, -1.03660990e-02f, -2.83469055e-02f, -8.60235747e-03f, -4.39288877e-02f, -6.34587705e-02f, -2.07832064e-02f, -3.67316939e-02f,
  3.09764445e-02f, 3.45888473e-02f, -4.79318276e-02f, -4.72536162e-02f, 1.15078084e-01f, -2.45552436e-02f, 2.31221188e-02f, -5.88274514e-03f, -4.58250977e-02f, -4.94037457e-02f,
  -2.71282643e-02f, -5.27899116e-02f, -4.46911864e-02f, -1.23884380e-02f, -1.34331379e-02f, 4.74582613e-02f, -2.03835350e-02f, -5.57338446e-02f, 7.21490681e-02f, 4.54433560e-02f,
  -9.65508521e-02f, 4.01264168e-02f, -1.61457385e-04f, -2.24129856e-02f, 5.69935404e-02f, -3.78728136e-02f, -2.75789276e-02f, 2.43868690e-05f, 1.37196248e-02f, 5.17732799e-02f,
  5.13663404e-02f, 5.36973774e-02f, -2.03861557e-02f, 2.54130885e-02f, 7.05059320e-02f, 4.35967594e-02f, -6.04226720e-03f, 7.04020960e-04f, 4.20830771e-02f, 5.77771012e-03f,
  1.29931234e-02f, 3.47521678e-02f, -2.45963801e-02f, 1.30683640e-02f, 1.13673564e-02f, 2.86720879e-02f, -1.10636279e-02f, 3.71326841e-02f, -2.97436453e-02f, -1.26121333e-03f,
  2.94482708e-01f, 6.40467778e-02f, 2.59621684e-02f, 6.98345453e-02f, -5.17607182e-02f, 2.96366345e-02f, -9.20154229e-02f, 4.76474352e-02f, 4.06393744e-02f, -3.81269939e-02f,
  -5.31796366e-02f, 1.85573462e-03f, 2.52270699e-02f, 2.24102046e-02f, -5.69709688e-02f, 8.06832165e-02f, 2.74109691e-02f, 5.77594489e-02f, 6.86464384e-02f, -3.71430740e-02f,
  -3.82894161e-03f, 1.76829044e-02f, -5.50211184e-02f, 1.68086272e-02f, -2.45012250e-02f, 3.05965282e-02f, 5.36553189e-02f, -4.82879067e-03f, -3.05939801e-02f, -6.00950271e-02f,
  -3.73421729e-01f, -1.34740517e-01f, -2.14535311e-01f, -1.12876549e-01f, -9.92359519e-02f, 3.16157103e-01f, 3.25462878e-01f, -1.29485875e-01f, 3.66378315e-02f, 2.17753738e-01f,
  1.01602636e-01f, 6.25640899e-02f, 8.45751613e-02f, -1.52737703e-02f, 2.05877662e-01f, 1.22394428e-01f, 1.07383393e-01f, 1.14263907e-01f, -7.96338096e-02f, -5.38749322e-02f,
  -1.15602106e-01f, 9.66266915e-02f, -1.46645337e-01f, -8.80732983e-02f, -1.35806873e-01f, -1.87352255e-01f, 2.74774544e-02f, 5.75374365e-02f, 8.87858775e-03f, 6.74575865e-02f,
  -4.99547012e-02f, -1.28570020e-01f, -7.09396526e-02f, 4.96146642e-03f, 3.05838063e-02f, 2.95686778e-02f, 2.55562589e-02f, 3.09185088e-02f, 3.51348855e-02f, 1.03037143e-02f,
  -1.18332095e-02f, -4.60101366e-02f, 9.18140169e-03f, 8.17744955e-02f, -5.69138303e-02f, -3.94620895e-02f, -9.83419940e-02f, -3.74031551e-02f, -5.08876108e-02f, -1.39096126e-01f,
  -4.52869311e-02f, -4.69990782e-02f, 3.07417568e-02f, 1.37318410e-02f, -4.39593792e-02f, -5.36272898e-02f, 2.76704784e-02f, 8.39366950e-03f, 9.87596530e-03f, -4.58399318e-02f,
  -3.73703837e-02f, 6.34772331e-02f, 1.14890821e-02f, -3.30480374e-02f, 8.99808258e-02f, -1.15181968e-01f, 8.45795572e-02f, -3.00057954e-03f, 2.61226278e-02f, 3.13886954e-03f,
  1.49965833e-03f, -8.28784481e-02f, 1.46061219e-02f, 6.34518415e-02f, 3.39479819e-02f, -7.42425909e-03f, 1.10075539e-02f, -8.79511144e-03f, 3.11354846e-02f, -6.21129759e-02f,
  3.43224555e-02f, 7.77533948e-02f, 1.19688407e-01f, 1.32088717e-02f, 8.30509961e-02f, 5.81149869e-02f, -2.59672385e-02f, -4.34040874e-02f, 3.34624178e-03f, 5.94160147e-02f,
  2.70282477e-01f, 1.81226388e-01f, 7.19782859e-02f, 5.59978839e-03f, 2.45195124e-02f, 1.99172273e-02f, 6.30227551e-02f, -5.81548698e-02f, 5.88314645e-02f, 5.66937476e-02f,
  -3.89550850e-02f, 2.93665305e-02f, 3.91648151e-02f, -5.68410335e-03f, 7.30808303e-02f, 2.85003688e-02f, 5.64165153e-02f, 9.37797055e-02f, 5.15164919e-02f, 6.03011390e-03f,
  3.68687417e-03f, 1.41210789e-02f, 1.61560662e-02f, 6.89518526e-02f, 1.31019233e-02f, 2.54333671e-02f, 7.32009113e-02f, -1.39794983e-02f, -2.66315718e-03f, 4.49998453e-02f,
  2.31357501e-03f, -3.51575911e-02f, 1.28152668e-01f, 2.41431192e-01f, -2.58276194e-01f, -9.69803520e-03f, 1.74340770e-01f, -9.86900479e-02f, -8.29819310e-03f, -1.29722401e-01f,
  7.14170486e-02f, -1.01160750e-01f, 1.49899825e-01f, 1.45491838e-01f, 2.72984833e-01f, 2.59406835e-01f, 1.74383551e-01f, 7.65517354e-02f, -3.88867185e-02f, 5.07152304e-02f,
  -9.12111159e-03f, 2.27001719e-02f, 1.58016667e-01f, -2.83318311e-01f, 3.62816676e-02f, -1.07608169e-01f, 1.06761292e-01f, -8.41165185e-02f, 1.19320434e-02f, -6.78196102e-02f,
  -4.40128073e-02f, -3.29633392e-02f, -3.58448811e-02f, -1.27035659e-02f, 2.79742889e-02f, 2.69320626e-02f, 2.99273282e-02f, 1.62586551e-02f, -2.86968937e-03f, 2.77476776e-02f,
  4.59490232e-02f, -4.10305187e-02f, -1.39447860e-02f, 1.34087410e-02f, -1.23890817e-01f, -3.67857702e-02f, 3.17446217e-02f, 5.52362166e-02f, -5.59347160e-02f, 8.38166028e-02f,
  1.66427046e-02f, 3.29028107e-02f, 6.45671412e-03f, 6.10774308e-02f, 3.06855179e-02f, -2.00245455e-02f, 2.99607664e-02f, 2.73034740e-02f, 3.06308568e-02f, -2.81130467e-02f,
  -4.41142218e-03f, 8.54918617e-04f, 1.31447548e-02f, -4.90427986e-02f, -1.76342968e-02f, 1.88208348e-03f, -5.03139086e-02f, 1.07128965e-02f, -1.47865321e-02f, 5.07643213e-04f,
  -3.32129863e-03f, 8.43167864e-03f, -1.41166029e-02f, 9.44948755e-03f, 1.06639732e-02f, -2.52039209e-02f, 2.02436224e-02f, 2.59177629e-02f, 4.17576693e-02f, 2.90931538e-02f,
  -5.40162157e-03f, 2.83348970e-02f, -2.22943686e-02f, -1.56944767e-02f, -4.36387919e-02f, 4.38338704e-02f, 4.12716977e-02f, 3.45611759e-02f, -7.33264210e-03f, 3.89162861e-02f,
  1.23422243e-01f, 1.28608346e-01f, 3.81658971e-02f, -5.44945598e-02f, -3.27121280e-02f, -6.06706068e-02f, 9.31438431e-03f, -4.81904112e-02f, -2.61845849e-02f, 3.98561396e-02f,
  -4.33781110e-02f, 2.90815961e-02f, -1.11157633e-02f, -1.87647864e-02f, 4.66331989e-02f, 4.43241326e-03f, 6.48905188e-02f, -9.84790735e-03f, -2.70357169e-02f, 2.52043866e-02f,
  8.01563077e-03f, -3.24934861e-03f, -5.43528236e-02f, -9.49569196e-02f, -4.94825691e-02f, 3.00411452e-02f, -5.97773641e-02f, -4.67043146e-02f, 3.83471511e-02f, 1.55733591e-02f,
  7.95223340e-02f, 2.20154256e-01f, -1.13797963e-01f, -1.45994455e-01f, 2.04174086e-01f, 1.26498222e-01f, 1.00294650e-01f, 9.82260332e-02f, 2.52565145e-01f, -1.02726072e-02f,
  1.29340068e-01f, -1.69975027e-01f, 4.75415103e-02f, -1.35720849e-01f, -3.20295602e-01f, -3.51204127e-02f, -1.27790511e-01f, -5.67254312e-02f, 5.07914498e-02f, -7.96584934e-02f,
  -8.22088867e-02f, -7.89933950e-02f, -2.79883683e-01f, -2.26759482e-02f, -9.48873982e-02f, 1.25661688e-02f, -1.50261208e-01f, 6.73156083e-02f, -2.01203227e-01f, 2.21644919e-02f,
  1.32651359e-01f, 1.12185806e-01f, -6.66724518e-02f, -1.11529967e-02f, -1.76764559e-02f, 3.64733040e-02f, -4.75371256e-02f, -1.28980083e-02f, 4.43782657e-02f, -1.57386456e-02f,
  3.71694867e-03f, -3.82088497e-02f, -5.55969886e-02f, 3.80537696e-02f, 1.09013125e-01f, 2.91384608e-02f, 5.08493837e-03f, 4.91533130e-02f, 6.07167147e-02f, 2.47549987e-03f,
  -1.61026269e-02f, 3.72077711e-02f, 1.34852435e-02f, 2.27570459e-02f, -2.27977335e-02f, 8.48239735e-02f, -8.73662829e-02f, -7.41688460e-02f, 1.68808189e-03f, 5.90788154e-03f,
  2.15939265e-02f, 4.32081260e-02f, -3.66674794e-04f, 2.68448088e-02f, 1.41535224e-02f, 5.20072095e-02f, -3.81752215e-02f, -6.92090690e-02f, -2.06269268e-02f, -1.90484356e-02f,
  9.69182793e-03f, -3.27381492e-02f, 6.63224906e-02f, 4.28322218e-02f, -2.57344116e-02f, 6.50641369e-03f, 8.52446072e-03f, 3.93557288e-02f, 2.54170746e-02f, -9.87132043e-02f,
  3.18472795e-02f, 8.13501105e-02f, -3.65215242e-02f, -1.84153747e-02f, 6.30142726e-03f, -2.24813707e-02f, 3.16073745e-02f, 3.26557420e-02f, 2.21190490e-02f, -3.82480770e-02f,
  2.20945686e-01f, 7.50794262e-02f, 1.82145014e-02f, 5.06494269e-02f, -5.33214351e-03f, -4.88993153e-02f, -6.26159757e-02f, -5.58936000e-02f, 4.23343927e-02f, -2.48013008e-02f,
  -2.08816659e-02f, -5.23872674e-02f, 1.90367624e-02f, 2.55433563e-02f, -6.85966164e-02f, -1.28796017e-02f, 1.66796837e-02f, 5.74174933e-02f, 2.83675711e-03f, 2.34917421e-02f,
  -6.84052240e-03f, -2.23435760e-02f, -9.63529274e-02f, -3.44695710e-02f, -3.02133374e-02f, 2.22994033e-02f, 5.59489578e-02f, 2.78384294e-02f, -2.28181817e-02f, -4.65993248e-02f,
  2.87085861e-01f, -1.64595798e-01f, 1.98689923e-02f, 3.16027313e-01f, 7.90018141e-02f, -1.55941576e-01f, -1.93504274e-01f, -1.88912868e-01f, 2.19001714e-02f, -2.22365364e-01f,
  2.77346760e-01f, -1.88755855e-01f, -4.88369390e-02f, 2.66248494e-01f, 2.77781218e-01f, 2.47379899e-01f, 9.43289921e-02f, -2.03081425e-02f, -2.82233179e-01f, 5.02589345e-02f,
  5.93582653e-02f, 2.90438175e-01f, 2.12016642e-01f, -1.76229015e-01f, -2.25765873e-02f, -1.82004258e-01f, 4.35382389e-02f, -1.64860740e-01f, 5.45677431e-02f, -8.84844139e-02f,
  3.74112688e-02f, 4.70155589e-02f, -1.56830028e-02f, -8.35240185e-02f, 6.60195202e-02f, 3.36277112e-02f, -4.30317000e-02f, 1.34383170e-02f, 4.19272296e-02f, -9.80678126e-02f,
  -8.08955580e-02f, 3.47708203e-02f, -2.84807589e-02f, 9.50709283e-02f, 2.73344293e-02f, -2.48976033e-02f, 1.06572313e-02f, -1.45775732e-02f, -4.71248031e-02f, 4.79510762e-02f,
  2.95670927e-02f, 6.43242821e-02f, 5.35276383e-02f, -5.61110638e-02f, -3.17075998e-02f, -2.45447978e-02f, 5.31393429e-03f, -3.14457193e-02f, -1.62752892e-03f, -7.81286694e-03f,
  -1.44875636e-02f, -4.24087346e-02f, 9.49117020e-02f, 4.29973518e-03f, -1.09360404e-02f, 5.09929359e-02f, 1.20034104e-03f, -2.53727660e-02f, -5.98354973e-02f, 6.62510702e-03f,
  7.53655881e-02f, 3.69030312e-02f, 4.73364489e-03f, 5.48014268e-02f, -1.67050213e-02f, -1.56027293e-02f, 1.33294547e-02f, 3.61338109e-02f, 1.11466711e-02f, 1.50413625e-02f,
  -7.66927451e-02f, 5.18865064e-02f, -2.90319379e-02f, 8.25591572e-03f, -6.29868358e-02f, -9.63187311e-03f, 5.02398284e-03f, 2.29353411e-03f, 1.70922149e-02f, 6.09667599e-02f,
  -9.74662304e-02f, -9.42884311e-02f, -4.51794490e-02f, -9.39756781e-02f, -8.82342085e-02f, -1.89455263e-02f, 1.57829374e-02f, -3.63911539e-02f, -9.38857570e-02f, -4.01812531e-02f,
  -2.90126633e-02f, 4.50834166e-03f, 2.23672558e-02f, 9.47591886e-02f, 9.96333431e-04f, 3.92401814e-02f, -1.35770645e-02f, 2.04881690e-02f, 7.66164511e-02f, -8.13898221e-02f,
  3.80316302e-02f, -3.77308130e-02f, -4.93045598e-02f, -7.99753293e-02f, -2.98743322e-02f, -1.36000030e-02f, -3.28119770e-02f, 4.24332879e-02f, 8.45028982e-02f, 1.81427263e-02f,
  -2.62674063e-01f, 1.53639138e-01f, 2.47496702e-02f, -2.46284053e-01f, 1.71859488e-01f, -1.54810324e-01f, -2.20359072e-01f, -8.73384706e-04f, 2.07186062e-02f, 1.08460978e-01f,
  -1.05054669e-01f, -3.68865468e-02f, 3.84078547e-02f, -1.42859787e-01f, -5.21384537e-01f, -8.29640999e-02f, -3.27762276e-01f, -1.80748001e-01f, 4.37866002e-02f, -6.54605553e-02f,
  -5.15940264e-02f, -1.25513479e-01f, -7.21656308e-02f, 1.34959251e-01f, 1.29066452e-01f, 9.37059447e-02f, -2.59654969e-02f, 9.86061171e-02f, -4.13504764e-02f, -3.42249051e-02f,
  -1.07531145e-01f, -3.56930681e-02f, 1.20462194e-01f, -4.10475815e-03f, -3.06323785e-02f, 4.45936993e-02f, 6.64752815e-03f, -2.08108053e-02f, -4.62608831e-03f, -2.15906817e-02f,
  3.42372321e-02f, -7.79320858e-03f, -6.26441613e-02f, 4.14094441e-02f, 4.86772619e-02f, 4.06327732e-02f, 1.10760763e-01f, 9.21855867e-02f, 2.36747451e-02f, 2.78330613e-02f,
  3.68815772e-02f, -7.90955219e-03f, -4.98728332e-05f, -4.18583266e-02f, 5.76286064e-03f, -5.06909192e-03f, -2.40511317e-02f, 5.89312939e-03f, -4.35793139e-02f, -2.17025802e-02f,
  -2.62126490e-03f, 7.00575160e-03f, 2.18538996e-02f, -1.70723721e-02f, -4.61264625e-02f, 6.81089386e-02f, -1.68338139e-02f, -1.15556624e-02f, 2.83398014e-02f, -1.03277881e-02f,
  -1.28019834e-02f, -4.60529653e-03f, 2.52679326e-02f, 3.68659087e-02f, 1.40428366e-02f, -1.05136596e-02f, -1.21253086e-02f, -3.51725239e-03f, 1.47856539e-02f, -1.77439172e-02f,
  -1.85628552e-02f, -3.12745497e-02f, -6.34006737e-03f, 6.99786143e-03f, -7.02840537e-02f, 4.32950445e-03f, 6.84820488e-02f, 3.06083150e-02f, 2.55520269e-02f, -3.81502062e-02f,
  -2.19329923e-01f, -2.75517792e-01f, -7.75894150e-03f, -6.23044185e-02f, -2.28833500e-02f, 3.44423787e-03f, 2.49154493e-02f, 5.11985943e-02f, -3.30076031e-02f, -2.34573111e-02f,
  4.24671397e-02f, 4.45683151e-02f, 3.81288654e-03f, -8.05811957e-04f, -2.94847321e-02f, -1.05533674e-02f, -3.88611183e-02f, -2.63531925e-03f, -9.20365080e-02f, -5.23605794e-02f,
  -2.86491513e-02f, -3.76151130e-03f, -2.59607434e-02f, 4.64320108e-02f, 4.30688076e-03f, -1.12184994e-02f, -8.04078877e-02f, 1.13677047e-02f, -2.81096641e-02f, 3.44524235e-02f,
  2.35105470e-01f, -2.56239802e-01f, -2.19649225e-02f, -2.48318791e-01f, 7.33628646e-02f, 1.31839260e-01f, 3.36500145e-02f, -3.77891921e-02f, -4.64471504e-02f, -1.10445581e-01f,
  -4.43258323e-03f, -1.33637100e-01f, 1.13257691e-01f, -3.08699191e-01f, 2.87376553e-01f, -3.43697332e-02f, -1.02093145e-01f, -1.12640217e-01f, 6.06362382e-03f, -2.35445146e-03f,
  3.47781256e-02f, -4.65225168e-02f, 2.19297931e-02f, 1.01566836e-02f, -3.92751070e-03f, -1.15608675e-02f, 2.13905916e-01f, 7.02689067e-02f, -1.57960489e-01f, 2.77091805e-02f,
  6.62073120e-02f, -1.03990838e-01f, -1.80281661e-02f, 5.25606498e-02f, 1.27150297e-01f, 8.23657885e-02f, 7.65722021e-02f, 3.63564864e-02f, -4.74104472e-03f, -4.81411330e-02f,
  5.95416948e-02f, 6.55722979e-04f, -6.16908371e-02f, -1.45724565e-02f, 3.27629037e-02f, -2.32873224e-02f, -7.21088424e-02f, -1.28602143e-02f, -6.41084136e-03f, -1.41488891e-02f,
  -4.94638644e-02f, -1.16358828e-02f, 1.43334297e-02f, -3.72883007e-02f, 8.48208517e-02f, -9.77393091e-02f, -2.96836626e-02f, 7.46276081e-02f, -2.78200321e-02f, -2.85966583e-02f,
  9.07853767e-02f, 9.56990384e-03f, -3.74486335e-02f, -6.18447959e-02f, 4.40363260e-03f, 4.82940823e-02f, -3.97869982e-02f, 2.45933961e-02f, 3.27425152e-02f, 5.19736893e-02f,
  4.34842892e-02f, -6.11835532e-02f, -1.58085562e-02f, -4.69563156e-03f, -1.91483053e-03f, -1.94894765e-02f, 3.32393348e-02f, -3.29210162e-02f, 6.96717277e-02f, -2.28819139e-02f,
  -1.85078643e-02f, -2.53696198e-04f, -4.01886664e-02f, 6.43885359e-02f, -2.34594964e-03f, 2.81474413e-03f, -2.52414607e-02f, -4.60355803e-02f, 6.23611268e-03f, 1.07388906e-01f,
  2.62541175e-01f, 1.89639956e-01f, 2.20329557e-02f, 1.75044592e-02f, -3.26216482e-02f, -1.13457034e-03f, -2.75487136e-02f, -4.03123498e-02f, 4.66207303e-02f, 8.59241337e-02f,
  -6.93668704e-03f, -8.23299959e-03f, 1.11276172e-01f, 4.84356191e-03f, 2.80121882e-02f, 8.18110444e-03f, 3.11240666e-02f, 6.04762807e-02f, 1.02528930e-01f, 8.17441270e-02f,
  1.45438164e-02f, 4.46486659e-02f, 1.92601811e-02f, 6.74355626e-02f, 8.62972345e-03f, 6.28085807e-02f, 1.83576103e-02f, -8.57158750e-02f, 2.35349461e-02f, -3.28754634e-02f,
  -1.91862285e-01f, -1.29198462e-01f, -1.01555221e-01f, -5.57414331e-02f, 5.37556000e-02f, -2.86909640e-02f, -1.31381452e-01f, 5.42369448e-02f, -2.94764906e-01f, -1.14982808e-02f,
  7.84311742e-02f, -1.68764025e-01f, 3.89152095e-02f, 5.06409407e-02f, -4.08058427e-02f, 7.26135373e-02f, 1.79179698e-01f, 2.64408708e-01f, 1.14002593e-01f, 1.75715506e-01f,
  1.07876830e-01f, 2.92605698e-01f, 2.28438973e-01f, 2.80091137e-01f, 2.69860208e-01f, 1.11717343e-01f, 1.70119777e-01f, 9.94971171e-02f, 1.96428999e-01f, 5.49892113e-02f,
  -1.35248974e-02f, -7.06793666e-02f, -1.48618827e-02f, 6.61981665e-03f, 5.90712987e-02f, -8.87608808e-03f, 8.80608559e-02f, 1.07218344e-02f, -7.16410503e-02f, 4.11013179e-02f,
  4.33292836e-02f, 1.03668950e-01f, 1.88986789e-02f, -5.23220561e-02f, -6.28783628e-02f, -2.33694054e-02f, -5.66401111e-04f, 3.23195271e-02f, 1.25027867e-02f, -1.02865342e-02f,
  -2.73308456e-02f, 7.10659325e-02f, 1.86775171e-04f, 4.78216708e-02f, -1.35133579e-01f, -4.40513827e-02f, -7.66938701e-02f, 4.29640636e-02f, 4.43545058e-02f, -1.29962474e-01f,
  1.34131283e-01f, 4.65920381e-02f, 1.09143369e-01f, 3.56380790e-02f, -2.89916713e-02f, -3.77273187e-02f, -3.44165191e-02f, 1.73716489e-02f, -2.89911162e-02f, -1.47334374e-02f,
  -3.31828259e-02f, -1.90776177e-02f, -1.08390609e-02f, -2.83440799e-02f, 3.09265014e-02f, -6.06553145e-02f, 7.66890943e-02f, 4.09552418e-02f, -3.96352215e-03f, 2.86920220e-02f,
  -5.95033588e-03f, -1.96128227e-02f, -2.08907668e-03f, 5.10928631e-02f, -6.02178415e-03f, -1.19910866e-01f, 6.27120435e-02f, -3.26047689e-02f, 2.06926391e-02f, 1.55200303e-01f,
  -2.64821127e-02f, -4.11912687e-02f, -4.58995104e-02f, 3.74280810e-02f, -4.39882763e-02f, 4.52534622e-03f, -1.47961313e-02f, 7.04142526e-02f, 7.85387978e-02f, -2.72634309e-02f,
  -2.27739029e-02f, 1.20978050e-01f, -4.43774275e-02f, -1.16165662e-02f, 7.48485774e-02f, -4.71702702e-02f, 3.72275747e-02f, -7.41660371e-02f, 2.00634915e-02f, -1.76766682e-02f,
  6.17584623e-02f, 3.65936980e-02f, 4.83467244e-02f, 9.79471952e-02f, 3.23375165e-02f, -2.54690424e-02f, -1.23568065e-02f, -5.41499592e-02f, 1.45755351e-01f, 1.00768059e-02f,
  -1.52443483e-01f, -2.73700058e-01f, 7.08917305e-02f, -1.00932233e-02f, -1.89380953e-03f, -1.12990916e-01f, 1.37615398e-01f, -1.95706666e-01f, 9.61281061e-02f, -2.05600739e-01f,
  -3.68163623e-02f, 6.03262428e-03f, 1.07696794e-01f, -1.63131908e-01f, 1.81646347e-01f, 1.81458414e-01f, -1.77002355e-01f, -6.87670708e-02f, 1.37032926e-01f, -1.62588924e-01f,
  2.36697309e-02f, -6.31134585e-02f, 8.97777975e-02f, -1.02840073e-01f, -1.81574807e-01f, -6.88032880e-02f, 2.58692652e-02f, 1.31062016e-01f, -1.65687397e-01f, 5.27994111e-02f,
  -1.55364424e-01f, -5.36940098e-02f, -4.29816870e-03f, 2.12305114e-02f, -1.07032016e-01f, 2.03607045e-02f, 1.74755491e-02f, 1.40635520e-01f, 7.12039098e-02f, -8.80310219e-03f,
  1.65071506e-02f, -2.83993557e-02f, -3.33512388e-02f, 1.07041575e-01f, -4.65049595e-02f, -9.38300788e-03f, -7.62173953e-03f, -7.64573440e-02f, 2.63653453e-02f, 2.57197469e-02f,
  -1.07775768e-02f, -3.90996113e-02f, -3.64882275e-02f, -1.77486036e-02f, 6.04916699e-02f, 5.65435030e-02f, 5.69037301e-03f, 3.81902937e-04f, -4.69972827e-02f, -3.52043658e-02f,
  9.63948593e-02f, 8.11429620e-02f, 3.12685445e-02f, -6.01130771e-03f, -2.54498795e-02f, 2.35284325e-02f, -5.79943066e-04f, -1.03226267e-02f, 2.54312679e-02f, -9.92732402e-03f,
  -3.69086228e-02f, -4.14923541e-02f, -7.57575929e-02f, 4.55163978e-03f, 1.98169425e-02f, 5.60700474e-03f, 2.61116568e-02f, -5.54196611e-02f, -3.09889540e-02f, 1.50025357e-02f,
  2.58791503e-02f, 4.83382074e-03f, -6.89199567e-02f, -6.62710145e-03f, 6.24020305e-03f, 1.03531603e-03f, -4.13355082e-02f, -1.91078000e-02f, 1.71547458e-02f, 6.54183775e-02f,
  -1.97172865e-01f, -2.43865848e-01f, 6.34926707e-02f, -2.51697097e-02f, 1.97890978e-02f, -2.09702626e-02f, 6.42002299e-02f, -3.60134169e-02f, -3.85169499e-02f, 3.04497941e-03f,
  -4.72723618e-02f, 1.12269102e-02f, -6.95022643e-02f, -6.57666195e-03f, 2.74798777e-02f, -7.99049065e-03f, -3.31522487e-02f, 3.98104033e-03f, -7.19212403e-05f, -8.10489655e-02f,
  -2.90980451e-02f, 3.26385945e-02f, 7.34861717e-02f, -2.65597235e-02f, 2.46368162e-02f, -6.83785742e-03f, -4.02569249e-02f, 7.21955448e-02f, -2.13228203e-02f, 5.50398836e-03f,
  -1.57041430e-01f, -3.49715650e-01f, -6.71564117e-02f, -4.31346208e-01f, 1.61256805e-01f, 1.20802388e-01f, -2.21876949e-01f, -9.91355777e-02f, -2.75081128e-01f, -2.10717320e-01f,
  5.16629778e-03f, -9.78323072e-02f, -1.03254385e-01f, -2.54710197e-01f, 1.88756123e-01f, -1.21394403e-01f, -2.09710866e-01f, -1.85172483e-01f, -7.37140030e-02f, -1.20587207e-01f,
  -3.53100412e-02f, -8.98372233e-02f, -6.28677458e-02f, 5.86744510e-02f, -1.17892422e-01f, -6.62119538e-02f, 8.26846957e-02f, 1.04069375e-01f, 4.71653417e-03f, 1.20117672e-01f,
  -5.24194762e-02f, -1.14013322e-01f, -3.61932255e-02f, 2.84005497e-02f, -4.17491645e-02f, 3.63317388e-03f, 2.99169011e-02f, 9.25665051e-02f, 5.20906672e-02f, -2.99763475e-02f,
  -1.01420656e-02f, 3.07355523e-02f, -4.68906350e-02f, 2.91135479e-02f, -6.16527759e-02f, 1.55428033e-02f, 9.28974885e-04f, 2.29781829e-02f, -4.98104431e-02f, -2.27508396e-02f,
  -7.75297657e-02f, -1.37459906e-02f, -4.48726937e-02f, -3.12137324e-02f, 2.28675380e-02f, -2.18198709e-02f, -4.72760722e-02f, 5.55960536e-02f, 1.67041027e-03f, -3.13168317e-02f,
  -2.16846280e-02f, -1.07560018e-02f, -6.10791817e-02f, -1.31575707e-02f, -1.97828021e-02f, 1.84067134e-02f, -2.81298831e-02f, 2.40311027e-02f, -2.19817124e-02f, -1.81343015e-02f,
  9.43849981e-03f, -7.38433003e-03f, -2.81137545e-02f, -3.45873870e-02f, -1.16494177e-02f, -6.54792637e-02f, 2.02743653e-02f, -1.36817573e-02f, -4.07998599e-02f, 4.20193039e-02f,
  2.56327126e-04f, -1.19248535e-02f, -3.10310498e-02f, 2.47894805e-02f, 2.21041963e-03f, 6.64347131e-03f, -1.72876753e-02f, -2.40359064e-02f, 2.58034095e-02f, 4.27448899e-02f,
  -3.14034545e-03f, -1.56229705e-01f, -1.39933443e-02f, 3.15540396e-02f, 2.02385653e-02f, 1.56171005e-02f, -1.10223079e-02f, -2.48545092e-02f, -2.31074337e-02f, -3.37404460e-02f,
  3.77756208e-02f, -2.04738490e-02f, 8.18776840e-04f, 1.94254536e-02f, 3.17686349e-02f, -3.46770324e-02f, -4.71620187e-02f, 5.82716661e-03f, 4.34925742e-02f, 4.48264368e-02f,
  2.58614379e-03f, -1.71703342e-02f, 2.45724116e-02f, -3.59475464e-02f, -2.08410304e-02f, 1.59890633e-02f, 2.06749048e-02f, -1.88029837e-02f, 2.22331062e-02f, -2.03119628e-02f,
  2.49772564e-01f, -2.67305106e-01f, 1.64803073e-01f, 3.36137414e-01f, 2.30811946e-02f, -4.65161920e-01f, -1.09181032e-01f, -1.04934335e-01f, 1.38934493e-01f, -2.27982357e-01f,
  1.12765352e-03f, 1.72242776e-01f, -1.31559819e-01f, -1.08928733e-01f, -3.23626846e-02f, -4.17438298e-02f, -2.01567382e-01f, -7.83454999e-02f, 1.20456114e-01f, -1.07015140e-01f,
  9.83181521e-02f, -1.01712324e-01f, 1.86158344e-02f, -1.10437959e-01f, 8.30119476e-03f, 1.60382390e-01f, -6.61207810e-02f, 7.63297826e-02f, -8.74025747e-02f, 5.14353625e-02f,
  -1.66661754e-01f, 1.28643498e-01f, 8.40897765e-03f, -3.51151265e-03f, -7.11811855e-02f, -8.13161731e-02f, -1.58834234e-02f, 4.56203371e-02f, 7.22540766e-02f, 2.80507393e-02f,
  -4.67315204e-02f, 5.06234309e-03f, 2.60198414e-02f, 4.74518947e-02f, 1.94292869e-02f, 2.76608486e-02f, 2.21103374e-02f, -5.60877658e-03f, 3.37011032e-02f, 3.46288010e-02f,
  5.84434532e-02f, -8.16162117e-03f, -1.97662581e-02f, -3.07180919e-02f, 5.67454621e-02f, 4.50419597e-02f, 2.25079563e-02f, -6.71446137e-03f, -4.07627150e-02f, 1.62889194e-02f,
  1.08201101e-01f, -5.04415967e-02f, -2.81495770e-04f, -1.93332396e-02f, 3.30449603e-02f, 4.14813720e-02f, -2.67701969e-02f, -2.77344268e-02f, 3.66630740e-02f, -3.28523144e-02f,
  -3.92040275e-02f, 7.85745829e-02f, 1.15217466e-03f, 1.00657512e-02f, 8.99334205e-04f, 8.28362443e-03f, 1.01851262e-02f, 5.05181123e-03f, -4.72261161e-02f, 5.29138893e-02f,
  3.41428444e-02f, -4.37188037e-02f, -4.16594148e-02f, -8.38372558e-02f, -1.42988469e-02f, 6.79400489e-02f, -3.37665677e-02f, 1.66288204e-02f, -2.13166010e-02f, 6.69913134e-03f,
  -4.23630238e-01f, -2.50017881e-01f, -7.76937455e-02f, -1.09377652e-02f, 1.90963410e-02f, -2.84499656e-02f, 5.49972616e-02f, -1.63048524e-02f, -5.32332696e-02f, -2.67541446e-02f,
  -1.88358233e-03f, -9.03381035e-03f, -2.15928350e-02f, 3.52616534e-02f, 7.70658301e-03f, -6.63067494e-03f, 1.51933748e-02f, 2.14516139e-03f, -2.07235627e-02f, -8.85735080e-02f,
  -6.59310222e-02f, 1.77981295e-02f, -3.09917610e-02f, -5.82062546e-03f, -7.34725967e-02f, 1.72123108e-02f, 1.64830368e-02f, 3.04598343e-02f, 6.15551416e-03f, -1.04251252e-02f,
  6.47364855e-02f, 2.00108990e-01f, -3.82129550e-02f, -2.63949744e-02f, 1.37302890e-01f, -1.23787306e-01f, -1.51995659e-01f, 5.98363616e-02f, -1.03831120e-01f, 1.62012860e-01f,
  -9.05222371e-02f, 1.11303017e-01f, -1.84470251e-01f, 2.83242539e-02f, -3.08796406e-01f, -2.98353046e-01f, 8.04173499e-02f, 6.33470947e-03f, -6.86205402e-02f, 2.07784936e-01f,
  2.47252211e-02f, 9.70819890e-02f, -4.77459952e-02f, 1.53910056e-01f, 1.38727710e-01f, 1.02894261e-01f, 1.68710917e-01f, -3.07054259e-02f, 1.57299355e-01f, 1.28035704e-02f,
  -7.37536922e-02f, 1.40193179e-02f, 2.94364970e-02f, -9.08975676e-02f, 8.94137025e-02f, 4.30819355e-02f, 2.35460643e-02f, -6.33750185e-02f, -5.76428548e-02f, 2.34568790e-02f,
  2.98429397e-03f, -2.46883463e-02f, 1.77555494e-02f, -6.90625934e-03f, 6.30149990e-02f, 1.06599452e-02f, -4.43063416e-02f, -2.71205902e-02f, 1.02054700e-02f, -2.54761744e-02f,
  -3.81724611e-02f, 1.28412442e-02f, 7.27224872e-02f, 6.29962841e-03f, -1.24520352e-02f, -1.63909711e-03f, -2.15806020e-03f, 5.68089820e-03f, 6.64501116e-02f, 3.88039276e-02f,
  2.50756815e-02f, 5.46825677e-02f, 1.57560520e-02f, -5.01208939e-02f, -5.54419830e-02f, 5.87914232e-03f, 4.23665112e-03f, -2.53112391e-02f, -1.53912297e-02f, 1.45742241e-02f,
  9.31344181e-03f, 5.25763771e-03f, -8.34244210e-03f, 2.31689960e-02f, 2.82689054e-02f, 2.90243402e-02f, -1.04015218e-02f, 2.60940474e-02f, 2.19834428e-02f, -5.89929409e-02f,
  -3.56514305e-02f, 1.70802027e-02f, -2.74781864e-02f, -9.72982217e-03f, -2.83463262e-02f, -2.99251715e-05f, 1.49043296e-02f, 2.11472921e-02f, -1.50495553e-02f, -3.05441041e-02f,
  5.38521186e-02f, 2.15644762e-01f, -6.05986901e-02f, -2.95825358e-02f, 2.43753362e-02f, -4.64110123e-03f, -1.81253515e-02f, 3.04395910e-02f, 2.40381411e-03f, 3.82422917e-02f,
  1.19948186e-01f, 3.06856651e-02f, 1.15961954e-01f, 4.72530089e-02f, 1.43499468e-02f, 2.97303516e-02f, 5.05194105e-02f, 3.58262882e-02f, 8.27642307e-02f, 6.93714693e-02f,
  7.50776976e-02f, 6.45834282e-02f, 7.96030015e-02f, -1.15146730e-02f, 8.23107287e-02f, 4.99577597e-02f, 7.60910138e-02f, 1.89463701e-02f, -5.83572425e-02f, 2.29413551e-03f,
  -5.83449863e-02f, 3.74019504e-01f, 2.19435185e-01f, -1.39830813e-01f, -7.09478259e-02f, -1.45009071e-01f, -2.97040343e-01f, 8.94341543e-02f, 4.74867262e-02f, -4.82812449e-02f,
  -2.59981543e-01f, 1.16479702e-01f, 3.88476290e-02f, -2.52229840e-01f, -2.33308107e-01f, -4.57649641e-02f, -1.96929201e-01f, -1.10875428e-01f, 1.16317376e-01f, 2.94501316e-02f,
  -1.72129869e-02f, -3.05013686e-01f, -5.06342426e-02f, 4.25994545e-02f, -1.89357195e-02f, 2.06252128e-01f, -5.23625873e-02f, 2.32300535e-02f, -5.03734760e-02f, -1.04859389e-01f,
  -1.16262682e-01f, 6.93779364e-02f, 4.02938128e-02f, -1.49777969e-02f, 1.06355213e-02f, -3.38089690e-02f, -1.95759386e-02f, -6.11704066e-02f, 1.39822275e-03f, 2.89264694e-02f,
  3.04317679e-02f, -7.17110513e-03f, -1.81136038e-02f, -1.61408670e-02f, 1.36159826e-02f, 5.01423515e-02f, 1.05976559e-01f, 3.81258391e-02f, 8.01884085e-02f, 1.81399453e-02f,
  4.09102067e-02f, 3.36363502e-02f, -9.49437916e-03f, -3.04466095e-02f, 4.05392684e-02f, -3.06353085e-02f, -3.80768394e-03f, 3.50152664e-02f, 6.85449615e-02f, 3.51099409e-02f,
  -2.31526196e-02f, -1.86648760e-02f, -2.18911488e-02f, -9.45296430e-04f, -3.37670222e-02f, -2.71144137e-03f, -1.10566812e-02f, -2.41570435e-02f, 2.39929706e-02f, 9.42250621e-03f,
  -4.38202173e-02f, 1.96861494e-02f, -6.07803613e-02f, -1.83821563e-02f, -5.12695685e-02f, 1.76907852e-02f, 5.92583045e-03f, 3.29735130e-02f, -1.91532983e-03f, 3.83407697e-02f,
  -5.74191995e-02f, -2.24433113e-02f, 7.02786632e-03f, 2.47715111e-03f, -6.78328425e-02f, -1.03141936e-02f, -3.36479954e-02f, 1.19632808e-02f, 5.57908043e-03f, -1.81356091e-02f,
  2.02776343e-02f, 1.33240998e-01f, -1.99407768e-02f, -3.58323567e-02f, 9.26770084e-03f, -4.60163428e-04f, -2.05251854e-02f, 5.43089397e-02f, -1.55300228e-02f, -3.25070322e-02f,
  -2.56935675e-02f, -2.51839645e-02f, 3.07937730e-02f, -2.71323193e-02f, -6.25886023e-03f, 1.76974304e-03f, -6.87366053e-02f, -7.17562623e-03f, -2.84795258e-02f, 3.60316150e-02f,
  4.23173467e-03f, 3.48391794e-02f, -3.37243974e-02f, 1.14315068e-02f, -3.26044112e-02f, -1.81290358e-02f, 5.88666350e-02f, 1.91183724e-02f, -1.58792529e-02f, 2.76353639e-02f,
  -7.97494426e-02f, 1.55457065e-01f, 8.78186803e-03f, -9.35959816e-02f, 3.04086894e-01f, -4.05213796e-02f, -3.60742882e-02f, 1.55528232e-01f, -9.41142887e-02f, 6.34059682e-02f,
  -9.05307904e-02f, -1.44611284e-01f, -1.37586787e-01f, -1.41129121e-01f, -4.48337913e-01f, -3.12743336e-01f, -3.02752972e-01f, -1.70314044e-01f, -1.31078094e-01f, -5.39752096e-02f,
  -1.19871706e-01f, 7.14415684e-02f, 3.79493944e-02f, 2.81417042e-01f, 2.65594691e-01f, 1.79610401e-01f, -3.18226255e-02f, 1.55235082e-01f, 5.23522273e-02f, -1.67865362e-02f,
  1.23513686e-02f, 5.09615950e-02f, 1.00963324e-01f, 3.17337625e-02f, -3.25296931e-02f, 4.38114442e-02f, -4.18962389e-02f, 1.11186123e-02f, -5.36652729e-02f, -1.05188889e-02f,
  -1.82544738e-02f, -5.02021797e-02f, -2.23700379e-04f, 2.83349548e-02f, 8.27773660e-02f, 1.68791413e-02f, -9.31040035e-04f, 1.65293515e-02f, 6.44441769e-02f, 3.71453608e-03f,
  -3.55353486e-03f, -9.02669355e-02f, -9.22742039e-02f, -1.32471368e-01f, -7.32397288e-02f, -2.41471622e-02f, 3.67317796e-02f, -6.60430407e-03f, -4.77267504e-02f, -2.82366145e-02f,
  3.91596854e-02f, -4.28788252e-02f, -1.23570701e-02f, 1.62069034e-02f, -1.34994118e-02f, 3.92277166e-02f, -5.30991107e-02f, 2.47997586e-02f, -2.65950114e-02f, -1.29800607e-02f,
  -6.14858642e-02f, 4.59136032e-02f, 5.31070307e-03f, 2.67775413e-02f, -4.22004759e-02f, 8.80177915e-02f, -2.10850760e-02f, -8.19217116e-02f, 5.11714034e-02f, -7.00773252e-03f,
  5.80969751e-02f, 2.54747877e-03f, 2.75608916e-02f, 7.68216979e-03f, -1.65159423e-02f, 1.86388921e-02f, 2.26532947e-02f, 5.13755158e-02f, 8.83107074e-03f, 6.50885282e-03f,
  -1.48896217e-01f, -7.82105550e-02f, 1.79106351e-02f, 3.65882218e-02f, -2.07370054e-02f, 1.05217018e-03f, -2.25302689e-02f, 1.84254833e-02f, -3.15912291e-02f, -1.67457573e-02f,
  3.09097506e-02f, 2.36680303e-02f, -3.06804851e-02f, -4.85663395e-03f, -2.28656009e-02f, -3.49991880e-02f, -5.89132309e-02f, 1.36267561e-02f, -1.73157509e-02f, -3.20174284e-02f,
  5.34862503e-02f, -1.61396731e-02f, 2.76368000e-02f, 1.24564193e-01f, 6.30944222e-02f, -8.70326068e-03f, -2.04014461e-02f, 8.69102255e-02f, -2.89856363e-02f, -4.38448414e-02f,
  2.91893065e-01f, -3.57927293e-01f, 1.91433832e-01f, -6.44964576e-02f, 1.73627418e-02f, -6.70713484e-02f, -2.39727516e-02f, -1.10132568e-01f, 3.41568775e-02f, -3.47108036e-01f,
  -1.11028120e-01f, -1.15116470e-01f, 9.39912535e-03f, -2.59243518e-01f, 2.91653067e-01f, 3.49474140e-02f, -1.36552393e-01f, -1.41465396e-01f, 9.15448591e-02f, -1.88573394e-02f,
  1.69003025e-01f, -2.67613083e-01f, 1.25747159e-01f, -5.77633791e-02f, -7.17376247e-02f, 4.34226356e-02f, 3.24963704e-02f, 9.31523368e-02f, -2.13192165e-01f, -2.24709157e-02f,
  -2.83696596e-02f, -6.01965599e-02f, -4.18874100e-02f, 6.53315634e-02f, 9.30532143e-02f, -4.51740921e-02f, 1.89528079e-03f, -2.26674862e-02f, 5.29038645e-02f, 2.05615349e-02f,
  -2.06712671e-02f, -1.08275805e-02f, -7.22424537e-02f, -7.79489381e-03f, 4.07074532e-03f, -7.48267910e-03f, 6.28025457e-02f, 7.92405568e-04f, -4.47638258e-02f, 3.74872014e-02f,
  8.62074047e-02f, -3.90759809e-03f, 4.18498777e-02f, -6.65279776e-02f, 5.77574223e-02f, -1.22272931e-02f, 1.47151556e-02f, 3.09705194e-02f, -5.45759760e-02f, -5.85985556e-03f,
  -2.02649888e-02f, 8.88768509e-02f, 2.39754971e-02f, 1.34104975e-02f, -4.21974063e-02f, 6.50229538e-03f, -3.14957723e-02f, -4.79278676e-02f, 6.34876117e-02f, -3.44365984e-02f,
  5.31401336e-02f, -1.08715519e-02f, -2.68673077e-02f, -7.59502221e-03f, -1.73421800e-02f, -1.09484512e-03f, 5.47086634e-02f, -5.69894873e-02f, 7.47505799e-02f, -1.44421868e-02f,
  -4.29297052e-02f, 2.80124359e-02f, -3.98678593e-02f, -2.00041803e-03f, -1.85523331e-02f, 1.98047422e-02f, -5.19714244e-02f, 8.16946104e-03f, -4.64285500e-02f, 5.07945716e-02f,
  -1.02667093e-01f, -4.31619398e-02f, -2.98453346e-02f, -5.87463602e-02f, -5.70664406e-02f, 4.37918417e-02f, 1.14035122e-02f, -1.40645280e-02f, -2.40403749e-02f, 5.77096008e-02f,
  1.00059267e-02f, -1.85775645e-02f, 4.50572670e-02f, -4.41622883e-02f, -4.01219120e-03f, 1.84026789e-02f, 4.94594965e-03f, -2.09864392e-03f, 2.38101842e-04f, -2.12856773e-02f,
  -5.31171709e-02f, -3.60685252e-02f, 1.03449645e-02f, -2.17553470e-02f, -6.61690980e-02f, -1.15911299e-02f, -5.63378669e-02f, 1.29225515e-02f, -1.47014717e-03f, -7.85716921e-02f,
  -3.68678421e-01f, 1.08422428e-01f, 1.91257209e-01f, -1.05127305e-01f, -1.69545412e-01f, 3.15613389e-01f, 5.78785427e-02f, -5.80203459e-02f, -1.86659663e-03f, -9.14663821e-03f,
  7.03995116e-03f, -5.85518964e-02f, 1.73098326e-01f, 5.89923188e-02f, 2.03425616e-01f, 3.46297920e-01f, 2.76226774e-02f, 3.73716541e-02f, 1.40152099e-02f, -1.66218653e-01f,
  -3.09532247e-02f, -1.27288625e-01f, 9.63794887e-02f, -7.48212859e-02f, -1.45350486e-01f, -9.06247273e-02f, -2.23145008e-01f, -4.63164076e-02f, -7.15274587e-02f, 5.18407812e-03f,
  -5.36395004e-03f, -1.04254678e-01f, 3.66580382e-04f, 8.43106881e-02f, -5.01450486e-02f, 3.13765858e-03f, -1.04686338e-02f, 4.82752658e-02f, 2.60403641e-02f, 1.91430114e-02f,
  3.39852534e-02f, 4.74930182e-03f, -2.73492169e-02f, 3.63563895e-02f, -2.76530664e-02f, 2.72737686e-02f, 9.25270319e-02f, 5.77581972e-02f, -8.58548936e-03f, 7.03365877e-02f,
  6.45735785e-02f, 6.20363280e-02f, 1.82918850e-02f, 6.02108985e-02f, 2.53734365e-02f, 7.10573941e-02f, 3.29371952e-02f, 2.75719501e-02f, 2.44889334e-02f, -3.02248597e-02f,
  5.50653376e-02f, -5.07850535e-02f, 1.96405426e-02f, -1.42000876e-02f, 2.98735723e-02f, -7.15093166e-02f, 1.18046934e-02f, 3.29216200e-05f, -1.25340819e-02f, 3.98625294e-03f,
  -3.92159447e-02f, -2.08817553e-02f, -7.10332543e-02f, 3.17570977e-02f, -6.16220273e-02f, -3.91581394e-02f, 3.82489152e-02f, -6.79277331e-02f, -6.97586760e-02f, 2.93779783e-02f,
  -7.39367632e-03f, -1.80552830e-03f, -1.38944723e-02f, -7.67127611e-03f, 2.05983631e-02f, -9.51486407e-04f, -1.69585459e-02f, 5.04742302e-02f, 7.08304159e-03f, 1.41738346e-02f,
  -1.46128014e-02f, -1.31162539e-01f, -1.58242360e-02f, -4.25200909e-02f, -8.70401785e-03f, 1.41692050e-02f, 5.40746003e-02f, 2.74129957e-02f, 1.33792209e-02f, 2.37608869e-02f,
  -2.66564507e-02f, -5.98407350e-02f, -9.40878019e-02f, -1.56439543e-02f, 8.52570590e-03f, 1.03247296e-02f, -9.38109830e-02f, -4.32724170e-02f, -6.15041368e-02f, -6.09555095e-02f,
  -4.21498641e-02f, -8.52350742e-02f, 1.99604034e-02f, -3.83852422e-02f, -2.21730825e-02f, -6.20736815e-02f, -5.78248985e-02f, 1.85124576e-02f, 5.77750206e-02f, 1.60588641e-02f,
  1.35754317e-01f, -3.40267867e-01f, 2.43844599e-01f, 1.22558616e-01f, 1.37243614e-01f, 1.51247993e-01f, 1.45448580e-01f, 1.28540069e-01f, 2.62744159e-01f, -2.88973600e-01f,
  -2.77300447e-01f, 1.95577312e-02f, -2.09572703e-01f, -8.21212083e-02f, 2.26292685e-01f, -8.89997371e-03f, 7.67190158e-02f, 6.68122917e-02f, 5.26627116e-02f, 2.36287732e-02f,
  7.46385455e-02f, -8.73462781e-02f, -3.31282057e-02f, -4.71501313e-02f, -5.90614751e-02f, 3.60335670e-02f, -1.72169954e-01f, 3.99989486e-02f, -1.01613685e-01f, 9.57594141e-02f,
  -4.96829711e-02f, -3.29815336e-02f, -1.20092802e-01f, -6.20735064e-02f, -6.42752647e-02f, -4.76637371e-02f, -3.49358879e-02f, 7.69449621e-02f, 4.89980951e-02f, -3.11597195e-02f,
  -5.56472577e-02f, 1.94211695e-02f, 2.84633087e-03f, 7.57533759e-02f, 3.48732099e-02f, -5.33794314e-02f, 4.78428043e-02f, -5.17672561e-02f, -3.77163477e-02f, 3.72718312e-02f,
  -1.24800568e-02f, -1.71652753e-02f, -3.75852101e-02f, 1.80970598e-02f, 2.51654536e-02f, -1.51386834e-03f, 4.51868288e-02f, 7.95655251e-02f, -5.52641675e-02f, 5.91143034e-02f,
  3.62460352e-02f, 7.81861842e-02f, 2.41252948e-02f, 2.01903544e-02f, -1.39466417e-03f, -1.30317057e-03f, 5.32870647e-04f, -4.85404842e-02f, 7.51139447e-02f, -3.43003869e-02f,
  -6.97484389e-02f, 4.27821688e-02f, 4.74761538e-02f, -4.14571501e-02f, 1.51767512e-04f, 5.19046374e-02f, 1.85006149e-02f, 6.71602860e-02f, -4.69877943e-02f, -5.56182303e-03f,
  3.56074423e-02f, 5.37502281e-02f, -4.57240045e-02f, -3.84804886e-03f, 1.49236824e-02f, -1.26536582e-02f, -8.01485106e-02f, 7.20859542e-02f, -1.79520827e-02f, 5.22603467e-03f,
  -1.92814976e-01f, -3.01575940e-02f, -7.12434426e-02f, -1.44513562e-01f, 3.51584777e-02f, -7.56621510e-02f, 3.36352810e-02f, 6.78797811e-02f, -1.99216343e-02f, -1.41183175e-02f,
  -7.94298667e-03f, -4.57773283e-02f, -7.25170374e-02f, 5.00099584e-02f, -3.54794860e-02f, -8.00734162e-02f, 1.74563460e-03f, 1.79252997e-02f, -9.10619497e-02f, -3.23394760e-02f,
  -4.80358303e-02f, -3.66964377e-02f, 9.34592038e-02f, 6.62918109e-03f, -7.76546076e-02f, -6.82310462e-02f, -3.28049809e-02f, 7.04458952e-02f, 2.65540387e-02f, -2.08096448e-02f,
  -1.89261153e-01f, 1.81746021e-01f, -2.27128685e-01f, -2.53429413e-01f, 2.06211746e-01f, -2.45192379e-01f, -2.64990240e-01f, 1.50651678e-01f, -8.99270326e-02f, 1.81066796e-01f,
  1.66207239e-01f, -1.16194643e-01f, 1.65782660e-01f, -3.76069546e-02f, -2.03303561e-01f, -4.09330428e-02f, -1.88687041e-01f, -1.61815286e-01f, 3.94096747e-02f, 7.85192102e-02f,
  -8.58172327e-02f, 1.76762179e-01f, -8.95710438e-02f, 2.64545560e-01f, 2.02388931e-02f, -2.89953463e-02f, 2.27608308e-01f, -1.11587327e-02f, 1.07428879e-02f, 2.77186986e-02f,
  -5.87054938e-02f, 1.28207952e-01f, -6.56439066e-02f, -2.45320927e-02f, -1.84284318e-02f, 3.67145129e-02f, -9.48501229e-02f, -1.06701758e-02f, -6.34594187e-02f, 8.37294664e-03f,
  -4.29122783e-02f, 2.94929855e-02f, 1.14055090e-02f, 3.78884338e-02f, -6.25293143e-03f, -8.70460737e-03f, -5.20391669e-03f, -6.62246197e-02f, 8.87682009e-03f, -3.75290513e-02f,
  -1.88132133e-02f, 9.62409563e-03f, -9.48217362e-02f, 1.73169877e-02f, -4.82128039e-02f, -7.01368451e-02f, -8.78584981e-02f, -7.91034922e-02f, -1.33007513e-02f, -4.79995683e-02f,
  6.75654933e-02f, -3.13797332e-02f, 1.76081769e-02f, 4.80987467e-02f, 1.47061991e-02f, 9.87400934e-02f, 2.17914879e-02f, 4.45533544e-02f, -5.60244806e-02f, 3.07977796e-02f,
  -6.15098455e-04f, 2.54303701e-02f, 2.45733969e-02f, 2.64759809e-02f, -8.47518630e-03f, -3.57461646e-02f, -6.17367700e-02f, 3.66312936e-02f, -3.59039120e-02f, -1.50788678e-02f,
  3.65362735e-03f, -9.30559170e-03f, -3.38745490e-02f, 2.12325882e-02f, -2.67091747e-02f, 3.53708640e-02f, 8.66354704e-02f, -5.66655130e-04f, -6.12287130e-03f, -3.57398950e-02f,
  6.28173575e-02f, 1.46283463e-01f, -2.83026900e-02f, -1.48993013e-02f, -2.83054058e-02f, 5.81355691e-02f, -5.45626655e-02f, -2.11479608e-02f, 2.56092893e-03f, 1.01897046e-01f,
  -2.61079017e-02f, 1.75401680e-02f, 1.17516117e-02f, 3.63901779e-02f, -9.45249125e-02f, 9.01679322e-02f, -4.04672995e-02f, -1.46261463e-02f, -2.84445081e-02f, 6.67678192e-02f,
  -1.28474329e-02f, 4.82804254e-02f, -3.35438251e-02f, -1.58444990e-03f, -1.06111923e-02f, 2.14203838e-02f, -6.04154170e-02f, 1.73635818e-02f, 1.38429422e-02f, -1.92649662e-02f,
  -2.11564049e-01f, -2.51846313e-01f, -1.70847610e-01f, 1.85553908e-01f, 3.00967306e-01f, 2.87247837e-01f, 1.53181061e-01f, 1.53621629e-01f, 2.26370022e-01f, 6.29959330e-02f,
  2.40665823e-01f, -5.18145896e-02f, -2.29688287e-01f, 1.62624598e-01f, 5.03294636e-03f, -1.64869368e-01f, 3.11100066e-01f, 1.35732695e-01f, -1.32401899e-01f, 3.98679003e-02f,
  2.99344286e-02f, 1.86725065e-01f, -7.51100928e-02f, 8.81604254e-02f, -9.50639322e-03f, -8.19834769e-02f, 1.55659486e-02f, -1.88766450e-01f, 1.27867118e-01f, 4.81297374e-02f,
  4.11729654e-03f, -3.85127254e-02f, 7.59487525e-02f, -6.78724870e-02f, 1.27054542e-01f, -1.73594523e-02f, -4.96457294e-02f, -6.61591440e-02f, -9.50027630e-02f, 2.20791828e-02f,
  -6.42885864e-02f, -9.62774903e-02f, 9.32102427e-02f, 1.29089959e-03f, -3.08128055e-02f, -2.42186394e-02f, -9.23995227e-02f, 7.85503089e-02f, -1.10466823e-01f, -1.51830629e-01f,
  -7.02194646e-02f, -1.05108455e-01f, -5.06405544e-04f, 1.98650025e-02f, 1.49127012e-02f, -2.65901741e-02f, -1.03276521e-01f, 4.13177256e-03f, 2.52692066e-02f, 4.77212630e-02f,
  -2.54138075e-02f, -4.57231104e-02f, -2.14857273e-02f, -4.61466499e-02f, -1.95792820e-02f, -6.21507056e-02f, 2.76970211e-04f, -5.55452891e-02f, -3.38481106e-02f, -3.51212658e-02f,
  5.37215583e-02f, 1.66039318e-02f, 2.77443393e-03f, 7.12835137e-03f, 7.14819655e-02f, -4.68053296e-02f, -3.72421346e-03f, -4.61937524e-02f, 1.11747809e-01f, -5.08859660e-03f,
  -3.98274846e-02f, -2.33984999e-02f, 5.22690900e-02f, 9.85013042e-03f, 1.78037677e-02f, 6.02981821e-02f, 5.57526834e-02f, -2.60045025e-02f, 2.58433670e-02f, 4.73612808e-02f,
  1.34508044e-01f, 9.51114446e-02f, 1.11993134e-01f, 5.57577796e-02f, -9.92254633e-03f, 5.70368953e-02f, 7.97320306e-02f, 7.32519850e-02f, -2.33983900e-02f, 3.91568206e-02f,
  9.81322005e-02f, 1.83787085e-02f, 9.12172943e-02f, -2.54713409e-02f, -2.55719069e-02f, 1.31382763e-01f, -3.20223044e-03f, 8.44255090e-02f, 1.03599727e-01f, 2.61733960e-03f,
  2.83065252e-02f, 1.70814362e-03f, 2.57481858e-02f, 1.36705056e-01f, 6.63681179e-02f, 3.55401225e-02f, 2.36690957e-02f, 4.50873980e-03f, -9.92549583e-02f, 5.85577302e-02f
};

// L0_fan_Wp_bar (Shape: 26 x 120)
const int L0_fan_Wp_bar_rows = 26;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -1.79693595e-01f, 1.70405760e-01f, -1.06231095e-02f, -3.47517133e-01f, 1.03621162e-01f, -1.31576851e-01f, -2.81026125e-01f, 2.27811888e-01f, 8.91177803e-02f, 4.59088106e-03f,
  -1.99716255e-01f, -2.04789206e-01f, 1.93010524e-01f, -3.20161074e-01f, -1.71259627e-01f, 6.79327697e-02f, -4.35578257e-01f, -2.95483410e-01f, 1.55749470e-01f, -3.27823818e-01f,
  -8.85250196e-02f, -1.85815886e-01f, -5.49765676e-02f, 1.98828161e-01f, -8.29299837e-02f, 5.37781306e-02f, -4.98651490e-02f, 1.94539949e-01f, -1.79656297e-01f, 6.83054626e-02f,
  -6.67188615e-02f, -6.18395675e-03f, -3.20386328e-02f, 1.08626291e-01f, -4.50932086e-02f, -1.03704371e-01f, -4.01887670e-02f, 1.18641253e-03f, -7.45185316e-02f, 4.61926125e-02f,
  -9.43377893e-03f, 1.02187783e-01f, -5.98622859e-03f, 1.37378082e-01f, 5.02067767e-02f, 8.35087821e-02f, 3.16906981e-02f, -6.83196411e-02f, -2.70470185e-03f, 4.36493121e-02f,
  -5.28150499e-02f, 4.88300808e-02f, -7.90649429e-02f, 4.70543932e-03f, 1.41656967e-02f, -4.88068350e-03f, -7.55096301e-02f, -4.78505157e-02f, 5.22637740e-02f, -3.40084061e-02f,
  5.32757957e-03f, -8.38239565e-02f, -2.68640332e-02f, 1.67181775e-01f, -8.28683898e-02f, 4.66675833e-02f, -6.45379582e-03f, -1.46413306e-02f, 3.98180448e-02f, -2.11738106e-02f,
  9.34382156e-03f, -5.60143404e-03f, 9.13800448e-02f, -3.38169187e-02f, -1.26251996e-01f, -5.13843596e-02f, -1.02274798e-01f, 7.80944452e-02f, 7.44664250e-03f, -1.43393790e-02f,
  2.20555197e-02f, -4.95283566e-02f, 3.12909074e-02f, 7.30241761e-02f, 2.32411129e-03f, 9.13738310e-02f, 9.63760540e-02f, -2.66405754e-02f, 7.85231125e-03f, -3.47373635e-02f,
  -1.68152913e-01f, -2.31760606e-01f, -1.06189083e-02f, 9.33694616e-02f, -3.16966474e-02f, -4.50626984e-02f, -6.43479824e-02f, 1.00776061e-01f, -1.93384010e-02f, 4.18444537e-02f,
  -1.02472277e-02f, -7.64406770e-02f, -8.05752166e-03f, 7.76820537e-03f, -9.49304700e-02f, 7.85778742e-03f, -1.90000296e-01f, -5.88573888e-02f, -1.23313479e-01f, 6.83334246e-02f,
  -8.30684975e-03f, 3.07088792e-02f, -7.77358115e-02f, 8.51690695e-02f, -1.10199498e-02f, -3.60261835e-02f, -4.22044620e-02f, 4.67577502e-02f, -5.97733539e-03f, -3.12159918e-02f,
  -6.12013973e-02f, 4.75508213e-01f, 2.19572932e-01f, 6.48372918e-02f, -3.11861396e-01f, -1.81051120e-01f, -3.23674530e-02f, -1.00657888e-01f, 4.62222658e-02f, 3.11634600e-01f,
  -1.16621837e-01f, 3.95227969e-01f, -4.42005582e-02f, 1.05329357e-01f, -4.43689436e-01f, -8.12038407e-02f, -8.06339551e-03f, 1.84138238e-01f, -1.31700456e-01f, -1.00903474e-01f,
  -1.40863851e-01f, -3.45021695e-01f, -3.39240320e-02f, -2.57903516e-01f, 2.62720231e-02f, 1.11226752e-01f, -2.03334078e-01f, -1.03431784e-01f, 1.15584239e-01f, -1.25720315e-02f,
  -1.82454232e-02f, -1.11552082e-01f, 1.25469685e-01f, 2.91739721e-02f, -7.32506514e-02f, 4.08458114e-02f, 6.26307577e-02f, -2.42725648e-02f, -9.91966203e-02f, 2.14559771e-03f,
  3.66547666e-02f, -5.55757880e-02f, -2.12079864e-02f, -1.09342914e-02f, 6.40403247e-03f, 5.25612980e-02f, 1.08907940e-02f, 7.61647224e-02f, 2.62715537e-02f, 6.32426739e-02f,
  8.18723887e-02f, 8.93743932e-02f, -2.66194474e-02f, 4.88235392e-02f, -5.12411259e-02f, -1.12748509e-02f, 6.75498396e-02f, 6.99298680e-02f, 7.33371004e-02f, -3.40309031e-02f,
  -1.64688993e-02f, -8.80269781e-02f, -6.69532362e-03f, 5.68201393e-03f, -6.75820559e-02f, -5.39483968e-03f, -4.24833037e-02f, 4.48311400e-03f, 3.71965542e-02f, -4.99881431e-02f,
  -5.79137057e-02f, 8.92958939e-02f, -5.80129102e-02f, 1.50908241e-02f, 7.96789187e-04f, 8.60875398e-02f, -8.09202343e-03f, 4.18818742e-02f, 4.61876509e-04f, 4.95670997e-02f,
  -3.68316993e-02f, 5.99671947e-03f, -1.58790161e-03f, 5.64806350e-02f, 1.40774287e-02f, -5.24688587e-02f, -2.51154089e-03f, 1.11460932e-01f, -1.44915814e-02f, -1.30072728e-01f,
  -2.83426970e-01f, -3.16853642e-01f, -8.62601027e-02f, 5.21518812e-02f, 2.42215153e-02f, 5.20591214e-02f, -2.99518202e-02f, 1.27593512e-02f, -9.36169252e-02f, -9.99223962e-02f,
  1.09857516e-02f, 8.22453201e-02f, -2.47067586e-03f, -6.40038913e-03f, -4.86809611e-02f, -4.94087785e-02f, -7.51411915e-02f, -4.04563919e-03f, -6.96476176e-02f, -1.29789142e-02f,
  6.60071522e-02f, 3.34178214e-03f, 4.47709719e-03f, -2.32510455e-02f, 4.50072698e-02f, -3.29338275e-02f, 1.70437910e-03f, 8.30726549e-02f, -8.89483243e-02f, 5.93737140e-02f,
  -8.33457112e-01f, 2.37708196e-01f, 4.57403898e-01f, -2.03351602e-01f, -2.74371117e-01f, 4.56847697e-01f, 1.43291414e-01f, 1.46776274e-01f, 1.50992036e-01f, 1.77371651e-01f,
  -8.93277153e-02f, -2.43154705e-01f, 2.51567066e-01f, 1.35698304e-01f, 2.01251194e-01f, 4.84157503e-01f, 2.10862473e-01f, 1.18073829e-01f, 6.63085580e-02f, -1.49802446e-01f,
  -1.17798299e-01f, -1.92896351e-01f, 2.30465859e-01f, -4.17197086e-02f, -2.37569228e-01f, -1.16272189e-01f, -2.35507503e-01f, 1.89992152e-02f, -4.38901521e-02f, -7.31265992e-02f,
  -8.62082094e-02f, -2.52407670e-01f, -8.43512714e-02f, 1.15269884e-01f, 3.89789194e-02f, -7.44720921e-02f, 3.29522938e-02f, -6.47956729e-02f, -3.61108482e-02f, -1.81125908e-03f,
  -8.94636214e-02f, 3.04022226e-02f, -9.81336012e-02f, -4.03095968e-03f, 3.26425880e-02f, 1.03851622e-02f, 3.83040048e-02f, 7.86992088e-02f, 4.70070057e-02f, 1.00904584e-01f,
  1.14724055e-01f, 9.73700210e-02f, 4.35838923e-02f, 8.49844143e-02f, -6.08691350e-02f, 1.92930121e-02f, 1.54746696e-01f, -9.60596800e-02f, -3.46634015e-02f, -2.11323088e-04f,
  5.46486340e-02f, 1.27501171e-02f, 6.20314591e-02f, 1.48868710e-02f, -1.04702022e-02f, -5.00422530e-02f, 5.25107011e-02f, -5.84662557e-02f, -3.18995751e-02f, -2.62499955e-02f,
  -5.00089005e-02f, -8.53726715e-02f, -1.74942259e-02f, 6.13341741e-02f, -1.89503431e-02f, -7.21658161e-03f, -2.88379584e-02f, -4.21431214e-02f, 7.31479749e-02f, -1.26211243e-02f,
  -3.49801742e-02f, 3.57976258e-02f, -1.04838327e-01f, 9.86496359e-03f, 6.19129129e-02f, -1.12142833e-02f, -3.56151983e-02f, 9.60018709e-02f, -1.03355432e-03f, -1.27817646e-01f,
  3.68866324e-02f, -2.93624569e-02f, -4.44484316e-02f, -7.55864605e-02f, 4.75873835e-02f, -1.54031226e-02f, 5.95195889e-02f, -4.60662507e-02f, 7.30206743e-02f, -2.33863778e-02f,
  9.43737384e-03f, 1.92064717e-02f, -5.21597974e-02f, -1.29713339e-03f, 6.69584125e-02f, 6.97898045e-02f, -8.07721261e-03f, -4.07395959e-02f, 3.07123531e-02f, -2.41091009e-02f,
  -4.84561957e-02f, -4.64116856e-02f, 3.72682549e-02f, -1.01545267e-01f, -1.62616819e-02f, -1.04400404e-01f, -1.24669909e-01f, -4.12850119e-02f, -8.68494585e-02f, 8.16452280e-02f,
  1.41372755e-01f, 3.03245246e-01f, 1.71021402e-01f, 1.97666675e-01f, 1.98574841e-01f, 3.10736507e-01f, 2.64766961e-01f, 3.12798411e-01f, 5.33673346e-01f, -1.88265543e-03f,
  -1.21583909e-01f, 2.18076751e-01f, -1.05637163e-01f, 8.52403194e-02f, -2.30130851e-01f, -7.90138468e-02f, 5.72063662e-02f, 1.33368269e-01f, 2.63752222e-01f, -3.52636389e-02f,
  -1.60957966e-02f, -2.32904822e-01f, -2.95568556e-01f, -1.45220533e-01f, 5.74389771e-02f, 2.37280950e-02f, -3.20707530e-01f, -1.88606717e-02f, -2.76986994e-02f, 1.19117990e-01f,
  7.24598542e-02f, 2.15839699e-01f, 6.71086311e-02f, 1.13421381e-01f, -4.98078391e-02f, 1.70405433e-02f, -4.87770373e-03f, 6.79443171e-03f, -2.90709697e-02f, 1.39569432e-01f,
  -5.29705994e-02f, -1.45102516e-02f, 1.82447527e-02f, 2.76946574e-02f, 1.36275500e-01f, 8.68347660e-02f, 5.62113412e-02f, 4.55450937e-02f, 6.57969639e-02f, 5.50333336e-02f,
  -4.30454984e-02f, 5.61912395e-02f, 1.86237413e-02f, 9.16195884e-02f, 5.09340130e-02f, 1.39364496e-01f, 8.17162916e-02f, 6.67885020e-02f, 6.92582801e-02f, 1.18408367e-01f,
  3.89620177e-02f, 6.69537624e-03f, -2.19716523e-02f, -1.34749478e-02f, 5.23777455e-02f, -2.88184416e-02f, -1.84969679e-02f, -9.10797119e-02f, 8.92913565e-02f, 6.88145403e-03f,
  3.36935483e-02f, 1.39679521e-01f, 3.58363166e-02f, 7.92040005e-02f, -1.22608226e-02f, 5.36865219e-02f, -2.67898683e-02f, 6.22308739e-02f, 1.40741179e-02f, 1.72591442e-03f,
  2.89508272e-02f, -1.27576575e-01f, 1.22468062e-02f, -9.97630209e-02f, -4.47292700e-02f, -1.11145359e-02f, -7.18510849e-03f, 4.83187959e-02f, -4.78203669e-02f, -1.33944049e-01f,
  6.16204739e-02f, 1.72283709e-01f, 6.11358285e-02f, 1.43779963e-01f, -2.70107239e-02f, -3.11842356e-02f, 2.17507891e-02f, 1.12006381e-01f, 3.26631553e-02f, 1.08803712e-01f,
  -4.51218523e-02f, 7.64433295e-02f, -8.58792067e-02f, 8.98050796e-03f, -2.39889808e-02f, -2.33950615e-02f, -5.85309789e-02f, 5.45391738e-02f, -3.46679240e-02f, -6.50715083e-03f,
  -2.96693053e-02f, -1.33762769e-02f, -4.61042151e-02f, 2.66040545e-02f, 3.72496732e-02f, -6.95154220e-02f, 2.92230248e-02f, 6.40295893e-02f, -5.24954386e-02f, -6.16105087e-02f,
  -4.09787774e-01f, -2.05503747e-01f, -5.32323480e-01f, 2.42925119e-02f, 2.92857699e-02f, 3.05897862e-01f, 1.00420043e-01f, -4.91563678e-02f, -3.68991196e-01f, 3.36561739e-01f,
  3.25838774e-01f, -3.76202732e-01f, -2.04875723e-01f, 4.53614563e-01f, -1.46182373e-01f, -8.63534734e-02f, 4.10280049e-01f, 2.77055144e-01f, -2.03513607e-01f, -8.21031928e-02f,
  -8.45762044e-02f, 3.56572717e-01f, -8.91046077e-02f, 1.89040869e-01f, 8.36371332e-02f, -1.10552907e-01f, 2.88489521e-01f, -2.26456508e-01f, 3.75614434e-01f, 1.12164326e-01f,
  1.61272123e-01f, -1.32174447e-01f, -7.83197060e-02f, -3.79234739e-02f, -3.25418892e-03f, 7.73058832e-02f, 7.03571811e-02f, -6.84271613e-03f, -3.84697951e-02f, -6.93827122e-02f,
  -1.33540425e-02f, -6.71287403e-02f, -1.42419878e-02f, -9.38836336e-02f, 5.32460108e-04f, -7.82918558e-03f, -9.33947340e-02f, -1.70144532e-02f, -6.92656562e-02f, -1.46548524e-01f,
  -2.31375024e-01f, 4.59304042e-02f, 3.57232615e-02f, 3.27984733e-03f, -5.35186790e-02f, -3.98963504e-02f, 2.84656119e-02f, -1.14892200e-01f, 3.49291079e-02f, -5.03552705e-02f,
  -4.49812934e-02f, 4.83671250e-03f, -7.94063509e-02f, 2.61193234e-02f, -8.36267322e-02f, 6.22922443e-02f, 1.13049068e-01f, 7.89427683e-02f, -9.66893584e-02f, -1.11293206e-02f,
  6.54471898e-03f, -4.94779609e-02f, 8.81174728e-02f, 5.73716201e-02f, 5.47248572e-02f, 7.28996843e-02f, 9.09138191e-03f, -3.06101004e-03f, -1.06599793e-01f, 7.79056475e-02f,
  -4.71241772e-03f, -6.30584583e-02f, -1.89391561e-02f, 1.24475218e-01f, 1.03892498e-01f, -1.43163353e-01f, 1.03798293e-01f, -4.20049801e-02f, -5.99826546e-03f, 4.24203835e-02f,
  1.08557083e-01f, -1.86299458e-01f, -7.80278444e-02f, 9.47881564e-02f, -7.95162935e-03f, 4.04827669e-03f, -1.36263780e-02f, -3.68637890e-02f, -2.84944884e-02f, -4.81312610e-02f,
  2.50395108e-02f, 5.22499122e-02f, 9.81787369e-02f, -3.22322398e-02f, 7.31430352e-02f, -3.44185121e-02f, 5.29869236e-02f, -1.56520586e-02f, 1.15850665e-01f, 3.04258261e-02f,
  -5.86048560e-03f, -1.87014639e-02f, 2.38938965e-02f, -2.56568007e-02f, 1.41522080e-01f, -1.11784777e-02f, -5.13186399e-03f, -7.45931640e-03f, 1.09309301e-01f, -1.62228961e-02f,
  3.78657222e-01f, -6.55769706e-02f, -2.75908828e-01f, 8.54487941e-02f, 2.57367224e-01f, 8.70693997e-02f, -3.28589082e-01f, 1.73713952e-01f, -1.38187408e-01f, -3.69727701e-01f,
  1.45954154e-02f, -1.33042589e-01f, -3.97582203e-01f, 3.39100957e-01f, 4.73883957e-01f, -1.67003840e-01f, 4.75286126e-01f, 1.65838495e-01f, 1.59104988e-01f, 3.28981847e-01f,
  3.02796811e-01f, 5.78870058e-01f, 2.15475455e-01f, 4.88939852e-01f, 2.88062811e-01f, 9.02374238e-02f, 6.98378384e-02f, -1.25547692e-01f, 1.63013667e-01f, 1.60818845e-01f,
  7.22275004e-02f, 1.95864346e-02f, 4.15137336e-02f, 9.09172290e-04f, 2.41102614e-02f, -4.40261029e-02f, -7.54190013e-02f, -5.65580465e-02f, -7.28915706e-02f, -1.00584425e-01f,
  -1.33242726e-01f, 8.74971598e-02f, 8.15934986e-02f, 3.99300344e-02f, 9.69926044e-02f, 2.76145451e-02f, 6.58597499e-02f, -7.22366050e-02f, -5.19094877e-02f, 5.10574654e-02f,
  -9.28705931e-03f, -5.05819023e-02f, -1.06719350e-02f, -3.50526441e-03f, -2.71835253e-02f, -3.89305502e-03f, -8.55476782e-02f, -1.50034830e-01f, 2.78913020e-03f, -1.32832415e-02f,
  1.38938800e-01f, -6.54966384e-02f, 4.78244834e-02f, -5.18744215e-02f, 3.48576829e-02f, 1.49038061e-02f, -3.86073403e-02f, -1.95590444e-02f, 4.05941624e-03f, -1.40304109e-02f,
  -6.01496212e-02f, -4.14752066e-02f, 4.01292406e-02f, -6.21601380e-02f, 5.65984696e-02f, 6.20043837e-02f, -2.23065242e-02f, 2.51889881e-03f, -1.01622483e-02f, -5.09441271e-02f,
  -2.79877242e-02f, 9.13363621e-02f, -3.84945273e-02f, -8.60953331e-02f, 2.28987373e-02f, -7.59277642e-02f, 3.11382283e-02f, -3.37478891e-02f, -3.79239321e-02f, 4.40957583e-02f,
  -2.39443369e-02f, 1.43744379e-01f, -5.46463728e-02f, -1.69725325e-02f, -2.56963056e-02f, 1.10904939e-01f, 6.81584999e-02f, 1.05828866e-01f, 3.59244347e-02f, 4.82086577e-02f,
  3.23723331e-02f, -1.08911268e-01f, -1.31284654e-01f, 4.10650782e-02f, 6.36614040e-02f, 3.30038182e-02f, -8.87596384e-02f, -7.91574866e-02f, 8.43612850e-03f, 1.37876198e-01f,
  -3.03876735e-02f, -4.79370058e-02f, 9.59931593e-03f, 4.75280546e-02f, 6.03025705e-02f, -1.86006770e-01f, 4.26254757e-02f, -4.64159772e-02f, -4.09116689e-03f, -2.29043644e-02f,
  3.83739978e-01f, 2.84960810e-02f, -2.70106107e-01f, 8.39267448e-02f, -2.26296738e-01f, -3.51855233e-02f, -1.04192972e-01f, -6.58280356e-03f, 2.55006492e-01f, 1.30261704e-01f,
  -5.83629571e-02f, 1.50348976e-01f, 5.75227030e-02f, 3.80510390e-02f, 3.02622676e-01f, 2.44463488e-01f, 1.80903852e-01f, 1.57234877e-01f, 6.58619180e-02f, 8.55550021e-02f,
  1.09490499e-01f, 7.54869059e-02f, -2.28854179e-01f, -1.72327027e-01f, -2.85304487e-01f, -1.81451738e-01f, -1.88728154e-01f, -3.01616013e-01f, -1.79855809e-01f, -8.87271240e-02f,
  -7.44455904e-02f, 2.76112631e-02f, -3.90729159e-02f, -4.58427798e-03f, -1.15239089e-02f, -2.63052955e-02f, -4.15679514e-02f, -9.41603724e-03f, 9.80391726e-03f, 5.02805188e-02f,
  1.02447808e-01f, 7.48722181e-02f, 1.41454801e-01f, -1.25430282e-02f, 2.49773730e-02f, -2.60846689e-02f, 3.51442508e-02f, -6.42132610e-02f, -4.90310416e-02f, -5.34974225e-02f,
  -4.73278575e-02f, -3.09364311e-02f, -1.74723566e-02f, 9.60015580e-02f, 3.78639135e-03f, 7.08926022e-02f, -5.31041203e-03f, -6.67966455e-02f, -1.07652619e-02f, 8.19362625e-02f,
  5.92846870e-02f, 6.34103715e-02f, -2.11767294e-02f, -7.08284900e-02f, -2.76071690e-02f, -5.35619184e-02f, 1.71715505e-02f, -1.61310975e-02f, 4.59839962e-02f, -5.09231985e-02f,
  -5.56603521e-02f, -2.73086987e-02f, 3.45063722e-03f, 1.48765119e-02f, 9.60423499e-02f, 3.72280814e-02f, 9.97462310e-03f, 1.47526274e-02f, 7.05231503e-02f, -1.33228591e-02f,
  -7.88079575e-02f, 5.90298846e-02f, -5.39562777e-02f, -7.73315132e-02f, -3.04890368e-02f, -1.57486517e-02f, 7.30273873e-02f, -2.98700556e-02f, -6.83085471e-02f, -6.31448105e-02f,
  8.16390440e-02f, 1.35906070e-01f, 2.00775117e-02f, 2.56641321e-02f, 4.45636781e-03f, 2.09854287e-03f, 5.51008545e-02f, 5.65144047e-02f, 2.69754268e-02f, 3.62446457e-02f,
  1.06081873e-01f, -4.86122415e-04f, -1.91841815e-02f, -2.65964195e-02f, 3.16817947e-02f, 1.84337068e-02f, 9.96165797e-02f, 3.16843693e-03f, -2.71198563e-02f, 2.87047755e-02f,
  -7.84837008e-02f, 6.98931590e-02f, 4.55448888e-02f, -1.06907811e-03f, 7.96598271e-02f, 4.88148145e-02f, 4.77827601e-02f, -3.09752543e-02f, -2.32425556e-02f, 7.05620721e-02f,
  3.53449285e-01f, 4.45131063e-01f, 2.91123539e-01f, 3.45702976e-01f, -3.22889447e-01f, -3.68433803e-01f, -2.12382913e-01f, 6.53924420e-02f, 1.84707701e-01f, -3.40590924e-02f,
  -2.05473304e-01f, 3.42763901e-01f, -8.44359770e-02f, 1.50284633e-01f, 1.68942641e-02f, -4.60844189e-02f, 1.97319090e-01f, 3.10831238e-02f, 8.42198655e-02f, 3.08212072e-01f,
  2.59212285e-01f, -4.05275822e-02f, 2.37351492e-01f, -3.85616571e-02f, 2.10605875e-01f, 2.48995572e-01f, 8.59214664e-02f, -1.65942851e-02f, 1.41696006e-01f, -1.68001831e-01f,
  -4.35031913e-02f, 1.18775427e-01f, 1.31135121e-01f, -4.81188484e-02f, 8.05094764e-02f, -3.91850695e-02f, -1.23034427e-02f, -5.10171913e-02f, -5.79987504e-02f, 1.96032822e-02f,
  8.84446800e-02f, 9.01291892e-03f, 3.61074805e-02f, -3.22045833e-02f, -3.71340252e-02f, 7.27313608e-02f, 9.63809639e-02f, 6.13431372e-02f, 6.41816854e-02f, 1.14867412e-01f,
  2.08395481e-01f, 7.52838477e-02f, 8.31335559e-02f, 3.72263826e-02f, 6.90395460e-02f, -1.58754420e-02f, 1.47997532e-02f, 5.75833768e-02f, 8.28557760e-02f, 4.83759306e-02f,
  4.53051273e-03f, -3.00646722e-02f, -2.61702873e-02f, 1.56330056e-02f, 3.39753926e-02f, 1.81688685e-02f, 2.31051277e-02f, -7.26410449e-02f, -1.55625530e-02f, 6.33207941e-03f,
  -2.88572423e-02f, 6.16230778e-02f, -2.92320698e-02f, -3.53462971e-03f, 6.46624938e-02f, 5.18100522e-02f, -4.34044003e-02f, -1.18627930e-02f, 5.63782752e-02f, 7.83604681e-02f,
  -6.61988258e-02f, -9.38064829e-02f, 2.61638984e-02f, -5.57347760e-02f, -1.48356065e-01f, -1.91292819e-02f, 6.39899448e-02f, 1.05675183e-01f, -4.79512997e-02f, 4.79435921e-02f,
  5.94063066e-02f, 2.45213777e-01f, 2.17683166e-02f, -8.09404701e-02f, 1.21256337e-02f, 3.01564056e-02f, -3.79018625e-03f, 1.15672164e-01f, 7.28956684e-02f, -4.67271693e-02f,
  4.28802595e-02f, -4.59834673e-02f, -4.40873355e-02f, -5.17437700e-03f, -1.33490926e-02f, 1.31866097e-01f, 6.39571846e-02f, 3.59036960e-02f, 6.79679289e-02f, 1.48851812e-01f,
  7.27396682e-02f, -7.26663768e-02f, 6.59402087e-02f, 5.15570864e-04f, 4.91460785e-02f, -4.06626845e-03f, 2.97762230e-02f, 1.24167874e-02f, 5.28950654e-02f, 2.00422201e-02f,
  -1.89658478e-01f, 2.37051714e-02f, -3.93305957e-01f, -2.04209879e-01f, -3.44881900e-02f, -4.08433110e-01f, -2.00568795e-01f, -8.77055991e-03f, 1.75353512e-01f, 2.27073461e-01f,
  6.17919005e-02f, 1.32824644e-01f, 2.60166347e-01f, -1.04787722e-01f, -2.94660538e-01f, 1.43093139e-01f, -4.44110632e-01f, -1.31861195e-01f, 1.22611240e-01f, -1.24876589e-01f,
  -9.18654576e-02f, 6.95806146e-02f, -2.43994310e-01f, 1.49463013e-01f, -3.11274767e-01f, -1.31548166e-01f, -1.34950459e-01f, 1.07803635e-01f, -3.34953010e-01f, 4.34734412e-02f,
  -7.97272194e-03f, 2.65347779e-01f, -8.95866379e-02f, -2.05677953e-02f, -2.50069916e-01f, -1.00547448e-01f, -1.56664312e-01f, -2.20767185e-02f, 5.38685136e-02f, -3.63940895e-02f,
  5.59070753e-03f, 1.35674775e-01f, 5.05485125e-02f, 8.30352902e-02f, -4.37857956e-02f, -2.54933946e-02f, -3.24191637e-02f, -2.06442505e-01f, 5.37325703e-02f, -5.48628680e-02f,
  -5.93054555e-02f, -8.50804374e-02f, -1.29448220e-01f, -2.07440108e-02f, -6.10680282e-02f, 1.24764936e-02f, -7.91231394e-02f, -1.26872644e-01f, -9.94870588e-02f, -7.79013783e-02f,
  -8.60696472e-03f, 8.44040327e-03f, 5.59851434e-03f, 4.01756279e-02f, 3.67335044e-03f, -1.27712488e-02f, 4.22392562e-02f, 2.29442976e-02f, 2.32023187e-03f, -4.37347777e-02f,
  -1.25984680e-02f, -3.42343352e-03f, 8.80767182e-02f, -1.08263232e-01f, -5.10473400e-02f, -1.44342100e-02f, -3.89246084e-02f, 4.13655229e-02f, -1.48979664e-01f, -7.22368956e-02f,
  9.81240794e-02f, -5.72942710e-03f, 4.46000211e-02f, -3.87708507e-02f, -5.98312058e-02f, 1.88346989e-02f, 1.73357800e-02f, -2.75028720e-02f, -2.04312336e-02f, -6.12754282e-03f,
  -1.31949559e-01f, 1.75699033e-02f, 7.51807168e-02f, 1.37986749e-01f, 3.11628100e-03f, -2.99422108e-02f, 3.17554851e-03f, -7.65528381e-02f, -3.30122635e-02f, 3.11352592e-02f,
  -1.07669987e-01f, -7.09037436e-03f, -1.23939410e-01f, 4.22102250e-02f, -2.02831924e-02f, -6.70438707e-02f, 4.40462586e-03f, 2.51848507e-03f, -6.70350417e-02f, -7.35288337e-02f,
  1.74921844e-02f, 6.90768063e-02f, 8.58832076e-02f, -1.07439421e-02f, -6.04720041e-02f, -3.74962911e-02f, -6.62712380e-03f, 1.04760239e-02f, -1.28730116e-02f, -1.99684147e-02f,
  -2.04895318e-01f, 2.43289232e-01f, -9.19722244e-02f, 3.65500413e-02f, -2.47317269e-01f, 3.88169259e-01f, 2.16459125e-01f, -6.57243431e-02f, 9.68720093e-02f, 2.81145662e-01f,
  4.81460383e-03f, -1.13304548e-01f, 6.95711374e-02f, 1.35175213e-01f, 6.37482181e-02f, 3.30266237e-01f, 2.90656298e-01f, 1.34159461e-01f, -9.13911536e-02f, -7.82408416e-02f,
  -6.90400153e-02f, 5.01417033e-02f, -1.39880657e-01f, -7.67208338e-02f, -1.67660639e-01f, -1.77344173e-01f, -1.84348404e-01f, -2.63961762e-01f, -7.69513845e-02f, -1.00147881e-01f,
  1.25477031e-01f, -4.07353379e-02f, -1.20622985e-01f, 3.54801491e-02f, 2.60316171e-02f, -4.24891561e-02f, -1.24098277e-02f, -1.70317087e-02f, -9.68093351e-02f, -2.78007127e-02f,
  1.69917755e-02f, -1.47035699e-02f, 8.37143511e-02f, -1.13845535e-01f, -7.47702941e-02f, 2.76955124e-03f, -3.18198502e-02f, 1.94258697e-03f, 1.03208539e-03f, -7.63480887e-02f,
  -2.15126537e-02f, -3.20772902e-04f, -6.92711724e-03f, 1.17254853e-01f, -9.57855657e-02f, 5.66190202e-03f, 1.18210427e-01f, -5.05574010e-02f, 1.19267009e-01f, 3.86696309e-02f,
  -1.27473995e-01f, 1.05693996e-01f, 1.03577338e-01f, 4.56837751e-02f, 1.03096012e-02f, 3.95551622e-02f, -3.41172181e-02f, -3.75264473e-02f, -3.22925523e-02f, 1.81642119e-02f,
  2.96059735e-02f, -1.01264343e-01f, -1.47915806e-03f, 2.73633040e-02f, 5.07004336e-02f, 7.47858807e-02f, -2.46844832e-02f, -4.47433814e-02f, 7.05328807e-02f, 9.74781215e-02f,
  -5.69659173e-02f, 4.09062281e-02f, -9.08597466e-03f, 4.86036326e-04f, 2.99153402e-02f, -1.24940157e-01f, -8.31514746e-02f, 1.63547453e-02f, 1.43085131e-02f, -3.59723605e-02f,
  2.25884348e-01f, 1.75174266e-01f, 6.66955039e-02f, 3.91475372e-02f, 3.60281654e-02f, -3.37451622e-02f, 7.91595951e-02f, 1.94591712e-02f, 8.22234303e-02f, -2.58202874e-03f,
  -3.10836788e-02f, 4.22551384e-04f, 1.23027429e-01f, -9.11225379e-02f, 1.90896038e-02f, 1.09656498e-01f, 5.66578433e-02f, -4.07207794e-02f, 3.85248549e-02f, -8.48977268e-02f,
  -2.27766205e-02f, 1.07624479e-01f, 3.39809284e-02f, 8.90747756e-02f, 8.13471153e-03f, 5.23752940e-04f, 5.70076220e-02f, -6.14306852e-02f, -4.95863671e-04f, 3.93153764e-02f,
  -6.92081630e-01f, 2.24301249e-01f, -2.24852219e-01f, -1.04260191e-01f, -1.52341068e-01f, -2.72646785e-01f, 2.76067276e-02f, -6.81988597e-02f, 5.20706475e-02f, 3.83752257e-01f,
  1.98190838e-01f, -8.70226473e-02f, 3.44511271e-01f, 1.26092926e-01f, -4.30363953e-01f, 2.72541404e-01f, -1.35617316e-01f, 4.65222225e-02f, 8.47376287e-02f, -1.09070614e-01f,
  -2.04158515e-01f, 7.52202496e-02f, -1.92168117e-01f, 1.08022362e-01f, -2.45712757e-01f, -1.12731352e-01f, 4.40792628e-02f, 4.83319722e-02f, -1.03284992e-01f, -4.26003411e-02f,
  -2.07391679e-01f, -6.45894185e-02f, -4.56019640e-02f, -1.55175030e-01f, -1.48383826e-01f, -7.74468342e-03f, -5.55066243e-02f, -2.27635149e-02f, 2.53565833e-02f, -4.90732305e-02f,
  -3.29721496e-02f, -4.98373397e-02f, 3.60694602e-02f, 7.87389800e-02f, -2.55026147e-02f, -3.95665206e-02f, -4.40241657e-02f, -2.96414923e-02f, -1.48561075e-02f, -8.34321454e-02f,
  -2.98043471e-02f, -1.87757108e-02f, -6.48918971e-02f, 1.60038508e-02f, -9.87974927e-02f, 3.24840993e-02f, -1.10177351e-02f, -1.06675960e-01f, -1.15561336e-01f, -9.59043428e-02f,
  -9.26589314e-03f, 2.13769246e-02f, 3.81419957e-02f, -4.25996550e-04f, 4.21649516e-02f, 3.75464261e-02f, 4.47851382e-02f, 4.36539715e-03f, -4.44263453e-03f, -4.15479206e-02f,
  -7.44189508e-03f, -6.91203633e-03f, -9.18296166e-03f, -9.45828680e-04f, -2.06438405e-03f, 4.01980393e-02f, 8.47834535e-03f, -4.99074198e-02f, -5.78036578e-03f, -6.66723102e-02f,
  4.08077128e-02f, -2.29986347e-02f, 4.58273431e-03f, 7.03772996e-03f, -2.30239481e-02f, -1.66974682e-02f, -1.76213626e-02f, -3.59423198e-02f, 4.48013805e-02f, -8.49721134e-02f,
  -3.55538517e-01f, -2.73909062e-01f, 1.43755917e-02f, -7.40922615e-02f, -1.99964084e-02f, -6.88652396e-02f, 6.55799955e-02f, -4.55842316e-02f, -1.11423165e-01f, -2.42070295e-02f,
  -7.21629933e-02f, 1.38014276e-02f, -1.07608162e-01f, 2.46391725e-02f, -7.70796835e-03f, 2.04596296e-03f, 5.43814674e-02f, 1.71498619e-02f, -6.02385178e-02f, -5.21510467e-02f,
  2.14073248e-02f, 2.85801701e-02f, 6.94860816e-02f, -9.71639901e-03f, 1.61195528e-02f, -2.99620535e-02f, -7.03044012e-02f, 6.33861683e-03f, -6.16404712e-02f, 5.35763204e-02f,
  -7.01937795e-01f, 4.29472953e-01f, 3.09938304e-02f, -1.55196950e-01f, 7.39010284e-03f, 2.72467613e-01f, 1.25273049e-01f, 1.00690410e-01f, -1.80689707e-01f, 2.31265336e-01f,
  2.19829857e-01f, -5.81743233e-02f, 2.27390200e-01f, 3.09720695e-01f, -1.58706814e-01f, 2.00325131e-01f, 1.00876831e-01f, 6.90955296e-02f, -9.26249474e-03f, -1.47290915e-01f,
  -1.19823642e-01f, 3.72222699e-02f, 7.92754963e-02f, 4.35379781e-02f, 3.08754463e-02f, -2.13375285e-01f, -1.45014450e-02f, 3.66266322e-04f, 1.61017552e-01f, 1.16310470e-01f,
  -1.62082687e-01f, -2.63458669e-01f, -1.13536991e-01f, -1.14268385e-01f, -1.19381979e-01f, -1.18397735e-01f, -9.20398235e-02f, -1.02966251e-02f, -1.23709172e-01f, -2.46220976e-02f,
  -4.14652079e-02f, 2.70507932e-02f, 1.63965169e-02f, -6.92600608e-02f, -1.00099683e-01f, 2.59622495e-04f, 1.75608441e-01f, 8.24726224e-02f, 8.64860862e-02f, 1.20126985e-01f,
  1.19140387e-01f, 7.08478689e-02f, 4.60022837e-02f, 7.56857023e-02f, 3.58251221e-02f, 1.23493467e-02f, -2.34976057e-02f, -7.79994734e-05f, 3.16120870e-02f, -4.76757698e-02f,
  -7.43047595e-02f, -3.18613686e-02f, 4.43577580e-02f, -5.83877694e-03f, 2.02023238e-02f, 5.93940578e-02f, 5.92870302e-02f, 4.11680937e-02f, -5.39961644e-03f, 3.76083404e-02f,
  2.14201752e-02f, -2.04131706e-03f, -9.55026299e-02f, -5.35966530e-02f, -4.80856411e-02f, -6.45671859e-02f, -5.53626008e-02f, -1.57895703e-02f, 7.52027798e-03f, 2.72159446e-02f,
  -9.03277192e-04f, -9.09369998e-03f, 1.41881958e-01f, 5.06116971e-02f, -1.09476410e-02f, -1.33753545e-03f, -9.73252393e-03f, 7.48582035e-02f, -7.07807578e-03f, -7.89690912e-02f,
  -3.37855071e-01f, -4.05919284e-01f, -4.18748148e-02f, -5.17811254e-02f, -6.22661710e-02f, -2.99624857e-02f, -5.62385209e-02f, 3.91360512e-03f, -6.70754090e-02f, -7.06666633e-02f,
  -6.81588650e-02f, 8.29313509e-03f, -1.00641847e-01f, -7.35259727e-02f, -7.31154531e-02f, 3.49953994e-02f, -4.69557978e-02f, -1.05944365e-01f, -7.62906224e-02f, 3.27418768e-03f,
  -3.10867447e-02f, -3.66315395e-02f, 2.97556575e-02f, 7.63286948e-02f, 1.72279831e-02f, 3.21868621e-03f, -9.09255967e-02f, -4.31676768e-03f, 2.24314462e-02f, 6.54933676e-02f,
  -1.71023250e-01f, -4.31573004e-01f, -1.60867676e-01f, 3.82336602e-02f, 3.99760120e-02f, -1.63608924e-01f, -2.27735102e-01f, -3.42037857e-01f, -1.05590597e-01f, -2.88948804e-01f,
  -1.86619848e-01f, 1.42309725e-01f, -3.09558749e-01f, -3.21150720e-02f, 3.27104777e-01f, -5.58177792e-02f, 1.09384190e-02f, 3.24626639e-02f, 3.60838091e-03f, -2.63012767e-01f,
  -6.65239384e-03f, -4.05981988e-02f, 4.86174691e-03f, -4.61142920e-02f, -1.16792247e-01f, 1.53547302e-01f, 3.67181897e-01f, 3.53014134e-02f, 3.06086928e-01f, 2.42370367e-01f,
  -7.70835653e-02f, -1.18794002e-01f, -3.29178236e-02f, 1.07657269e-01f, -7.40208626e-02f, -5.01297740e-03f, 1.24238141e-01f, 8.39223340e-02f, 1.23419881e-01f, -3.15670818e-02f,
  8.30428824e-02f, 8.11405703e-02f, 7.73619907e-03f, 1.05994023e-01f, -4.22539152e-02f, 1.85207017e-02f, -5.86241810e-03f, -4.20172140e-02f, 9.15177260e-03f, -6.97342455e-02f,
  -1.09680504e-01f, -8.68046060e-02f, -2.19297893e-02f, 1.08091019e-01f, 3.05616893e-02f, -1.92746762e-02f, 6.65025264e-02f, -2.57228911e-02f, 5.16674817e-02f, 7.48494128e-03f,
  -5.55141233e-02f, 1.32373478e-02f, -9.90642086e-02f, -4.79240566e-02f, -3.13343294e-02f, 7.47629777e-02f, -1.63933504e-02f, -2.69188615e-03f, 6.13023266e-02f, -6.59476519e-02f,
  -1.15385614e-02f, -1.60396136e-02f, 3.10107749e-02f, -4.15971689e-03f, -1.16294391e-01f, -6.59498349e-02f, 5.04062362e-02f, 3.34173143e-02f, -4.69372459e-02f, -1.31432181e-02f,
  3.52626815e-02f, 7.17356354e-02f, -1.18572051e-02f, 7.06056831e-04f, -5.34498505e-02f, -3.51396799e-02f, 1.94905736e-02f, 3.88060580e-04f, 2.24404167e-02f, 2.68391408e-02f,
  4.23653014e-02f, -9.41103250e-02f, 4.65149898e-03f, 4.42819260e-02f, 6.17976338e-02f, -1.50722954e-02f, -2.51803477e-03f, -1.83696933e-02f, -3.16477977e-02f, -1.52364537e-01f,
  -4.40640897e-02f, 6.50060475e-02f, 1.25757363e-02f, 6.89304993e-02f, 5.67858517e-02f, -6.22514598e-02f, 3.73596838e-03f, 1.00270033e-01f, 2.15808842e-02f, 1.32550709e-02f,
  1.71533264e-02f, -2.24101190e-02f, 4.16426361e-02f, 2.34755245e-03f, 4.57391143e-02f, 2.04699603e-03f, -1.44265117e-02f, -4.56048399e-02f, 8.09370205e-02f, 7.73565322e-02f,
  3.64082187e-01f, -2.48121440e-01f, 1.75981224e-01f, 2.55394816e-01f, 2.62537003e-01f, 1.71141565e-01f, 3.61180097e-01f, 1.38642803e-01f, 5.30442417e-01f, -2.94065595e-01f,
  -1.69420972e-01f, -1.36023745e-01f, 3.54396030e-02f, -2.34980166e-01f, 2.91523218e-01f, 1.22307569e-01f, 2.59255040e-02f, -4.52634022e-02f, 1.70635924e-01f, -5.31295489e-04f,
  7.64107779e-02f, -2.12421149e-01f, -8.24019685e-02f, -3.37843418e-01f, -1.42145827e-01f, -1.08447067e-01f, -2.71215200e-01f, 2.50233822e-02f, -3.87835324e-01f, -3.87214795e-02f,
  7.27912784e-03f, -3.39748003e-02f, -1.06143601e-01f, -2.53475364e-02f, 4.14575823e-02f, 3.33858617e-02f, -4.35030982e-02f, 3.18696797e-02f, 1.78226203e-01f, 1.92955714e-02f,
  7.87626300e-03f, -5.10998443e-02f, -2.44619027e-02f, 2.01434698e-02f, 8.12226459e-02f, -4.39464264e-02f, 5.45892911e-03f, -2.89411452e-02f, -3.67838927e-02f, 2.61744130e-02f,
  2.92728301e-02f, 4.53467574e-03f, -2.76978351e-02f, 4.23491420e-03f, -3.44567671e-02f, -5.04496507e-02f, -4.30137804e-03f, 1.83704181e-03f, 4.32981225e-03f, 2.78863795e-02f,
  -1.04822308e-01f, 4.06390280e-02f, -3.78213525e-02f, 4.66802865e-02f, 8.35484117e-02f, 1.47140147e-02f, -2.09878758e-02f, -3.63512635e-02f, 4.58654091e-02f, -3.76205519e-02f,
  6.44043535e-02f, -2.56942585e-02f, 7.52252191e-02f, 6.15398176e-02f, -4.24599089e-02f, 5.72770163e-02f, -7.96686765e-03f, 1.44759081e-02f, 8.41252133e-03f, -2.67910324e-02f,
  -2.25341937e-04f, 2.16665138e-02f, 4.62828716e-03f, 3.79571915e-02f, 3.46382335e-02f, 2.55638715e-02f, -8.84437934e-02f, 4.38912176e-02f, 1.83897130e-02f, -6.30600974e-02f,
  -4.46195342e-02f, -1.37080744e-01f, -1.15331590e-01f, -9.70323011e-02f, -6.05498115e-03f, -7.06058666e-02f, 1.08601870e-02f, -5.45135029e-02f, 6.35164678e-02f, -5.90486685e-03f,
  -7.70942420e-02f, 5.83654291e-05f, 1.09615391e-02f, -3.75489742e-02f, -8.24188292e-02f, 4.39999811e-03f, -2.13352628e-02f, -4.97415364e-02f, -4.45435680e-02f, -1.07672654e-01f,
  -5.84189370e-02f, 6.11859560e-03f, 1.01656895e-02f, -2.90209204e-02f, -8.72598961e-02f, -3.75189483e-02f, 1.57998130e-02f, -3.42883803e-02f, 1.19520789e-02f, 4.10591848e-02f,
  2.33883172e-01f, -1.20862134e-01f, -7.63244033e-02f, -3.16275924e-01f, -1.17533341e-01f, -2.18069822e-01f, -3.56683493e-01f, -1.66189983e-01f, -2.38264993e-01f, -2.05328301e-01f,
  -2.52602518e-01f, 7.71242157e-02f, 5.34902848e-02f, -2.54996508e-01f, 2.47151300e-01f, 1.71168044e-01f, -1.83764413e-01f, -1.48438230e-01f, 5.58104254e-02f, -1.78667903e-01f,
  -4.22469042e-02f, -2.49828830e-01f, 5.61568066e-02f, -1.96067214e-01f, -2.47808233e-01f, -4.19890657e-02f, 7.96740875e-02f, -1.50406763e-01f, -1.53822720e-01f, -6.68036118e-02f,
  2.10454762e-02f, -2.97267046e-02f, -1.59846600e-02f, 7.50051588e-02f, -2.62328386e-02f, 9.02037323e-03f, 6.57862797e-02f, -2.27382742e-02f, -3.98407206e-02f, 2.46106982e-02f,
  7.42844269e-02f, 4.95844483e-02f, -9.49147344e-02f, 2.52278578e-02f, -9.32432190e-02f, -8.73877257e-02f, -9.26694181e-03f, 4.16024514e-02f, -1.44390278e-02f, 6.90618530e-02f,
  -5.25829159e-02f, 7.06815049e-02f, 1.86875626e-03f, -1.93895344e-02f, -9.94969308e-02f, -1.15193710e-01f, 6.72049820e-02f, 7.55869225e-03f, -3.43009382e-02f, 3.51825766e-02f,
  1.68928597e-02f, 5.37412576e-02f, -6.29131868e-03f, -5.51080778e-02f, -4.84906286e-02f, -6.05846904e-02f, -7.22864876e-03f, 5.97139448e-03f, 9.77290608e-03f, -1.22687127e-02f,
  -5.44509590e-02f, 7.93551188e-03f, -5.27243689e-02f, -6.60119858e-03f, 5.65655567e-02f, 9.99988019e-02f, 2.55131666e-02f, 7.91524537e-03f, -8.06171522e-02f, 1.13436515e-02f,
  -2.82971375e-02f, -6.99938908e-02f, -7.82242268e-02f, -1.35649946e-02f, 3.30897747e-03f, 5.75080812e-02f, -9.91401169e-03f, 3.90000939e-02f, 5.58660999e-02f, 6.76521212e-02f,
  1.24705378e-02f, -4.45923507e-02f, -7.52560794e-02f, -1.05754741e-01f, 4.38184254e-02f, 1.24098100e-01f, 3.72570194e-02f, -1.13251954e-01f, -3.15854177e-02f, 7.95812719e-03f,
  1.40278013e-02f, -3.09868045e-02f, 1.47695951e-02f, 4.44753189e-03f, -9.77952853e-02f, -8.24725702e-02f, -9.81594324e-02f, -2.63008885e-02f, 3.15874554e-02f, -1.92035306e-02f,
  -4.71140333e-02f, -4.98320609e-02f, 1.25314239e-02f, -1.19640775e-01f, -8.30713362e-02f, 1.79386176e-02f, 6.13626577e-02f, -6.62668841e-03f, -3.52988727e-02f, -7.27720112e-02f,
  -1.43772990e-01f, -1.79479852e-01f, 1.66739792e-01f, -3.51385087e-01f, 9.59611535e-02f, 1.02128517e-02f, 1.94054350e-01f, -1.93825796e-01f, -1.91988528e-01f, -2.55109131e-01f,
  -8.73465613e-02f, 2.83472389e-01f, 3.56284827e-01f, -2.82182187e-01f, 3.79542679e-01f, 2.00814918e-01f, -3.21633130e-01f, -2.68193875e-02f, -3.83357139e-04f, -1.28123268e-01f,
  -1.27745360e-01f, -1.88179955e-01f, 4.64312322e-02f, -2.02284917e-01f, -1.11018457e-01f, -2.14107543e-01f, -1.69267133e-02f, 3.03666919e-01f, -2.58819193e-01f, 1.76979139e-01f,
  -1.44440800e-01f, -2.06744418e-01f, -5.31437062e-02f, -2.46598143e-02f, -1.33757189e-01f, 2.13567652e-02f, 2.58236378e-02f, 2.44139090e-01f, 2.63666753e-02f, -1.08851260e-02f,
  9.81630236e-02f, -3.65669876e-02f, -6.00248016e-02f, 7.88841099e-02f, -7.26274550e-02f, -6.91356510e-02f, -3.58222760e-02f, -7.31713399e-02f, -6.49612863e-03f, -1.45993726e-02f,
  -1.09459572e-02f, -2.59569082e-02f, -9.95170400e-02f, -5.59620187e-02f, 6.60931468e-02f, -1.08091414e-01f, -5.50639257e-02f, 1.14175528e-01f, -5.56211919e-02f, -1.13749452e-01f,
  2.11007856e-02f, -6.71021920e-03f, 2.59470381e-02f, -5.98271703e-03f, 3.84456478e-02f, -7.42807090e-02f, -1.89874936e-02f, 2.66891010e-02f, -2.85514612e-02f, -1.90087482e-02f,
  -6.58728480e-02f, 3.73981819e-02f, -9.05884653e-02f, -1.07504301e-01f, -4.93138172e-02f, -1.62333008e-02f, 1.18093468e-01f, -8.17807857e-03f, -8.69864672e-02f, -1.61529668e-02f,
  1.54908709e-02f, -2.30087619e-02f, -2.23791059e-02f, -6.24739155e-02f, -9.97726396e-02f, 8.26847702e-02f, -7.63832033e-02f, -5.33302836e-02f, 1.77616859e-03f, 1.57887042e-01f,
  -1.34506956e-01f, -2.52602667e-01f, 2.37373207e-02f, -6.85392544e-02f, 4.73529175e-02f, -6.94920197e-02f, 1.43880639e-02f, -7.12981373e-02f, -8.04559735e-04f, 7.73446285e-04f,
  -9.36721563e-02f, -2.33624484e-02f, -4.01448160e-02f, -1.35162445e-02f, 8.52879286e-02f, -8.62647593e-02f, 7.48283565e-02f, 3.49924937e-02f, -4.99728974e-03f, -2.18937434e-02f,
  -2.94975005e-03f, 4.86359894e-02f, 4.88947742e-02f, -1.28101885e-01f, -6.62116483e-02f, -7.72835454e-03f, -2.74717864e-02f, -2.56573614e-02f, 7.34147504e-02f, 7.45758926e-03f,
  2.95471817e-01f, 2.28075847e-01f, -4.64575440e-02f, -6.07856400e-02f, -1.41977906e-01f, -3.53540063e-01f, -2.52452821e-01f, -1.79466322e-01f, -4.45306376e-02f, 1.54674560e-01f,
  -2.55850226e-01f, 2.92771190e-01f, -5.23376912e-02f, -2.35516265e-01f, -5.33588171e-01f, -1.66132018e-01f, -2.01360598e-01f, 4.98408489e-02f, 5.27294585e-03f, 3.07407521e-04f,
  -1.14827596e-01f, -3.01648706e-01f, -2.01651871e-01f, -1.36465073e-01f, -9.72012058e-03f, 1.95759743e-01f, -1.30800884e-02f, 2.76891724e-03f, -2.67438814e-02f, -1.44814312e-01f,
  -5.00763804e-02f, 8.41813236e-02f, 5.69606088e-02f, 4.58388729e-03f, -9.92741734e-02f, 5.17586097e-02f, 9.16305557e-02f, -1.02881812e-01f, -4.43732515e-02f, 3.59242316e-03f,
  1.03172049e-01f, -5.99663984e-03f, -3.54449786e-02f, -4.30744551e-02f, 8.59819204e-02f, 1.86727885e-02f, -2.39496250e-02f, 4.74717431e-02f, 5.43934554e-02f, 5.95340021e-02f,
  6.90257773e-02f, 9.77053940e-02f, -2.15529911e-02f, 4.23136242e-02f, -3.42096463e-02f, -5.46006151e-02f, 1.02050588e-04f, 4.93040606e-02f, 9.02272314e-02f, 2.08591931e-02f,
  3.02899964e-02f, 5.16014211e-02f, 2.09898036e-02f, 1.33381579e-02f, -4.09524441e-02f, -2.98889074e-02f, -1.44290971e-02f, 7.62365526e-03f, -7.89647363e-03f, -1.26719894e-02f,
  4.27160086e-03f, -9.31722950e-03f, -6.36769310e-02f, -1.42123709e-02f, 2.14248691e-02f, 5.91211580e-02f, 1.76191498e-02f, 6.60873652e-02f, 4.44499217e-03f, -4.44966964e-02f,
  4.19992059e-02f, -5.59881888e-02f, -4.59573435e-04f, 6.96784183e-02f, -1.15004189e-01f, -4.53253575e-02f, -1.47405704e-02f, 3.89276147e-02f, -3.23773851e-03f, -8.84876400e-02f,
  -8.17290321e-02f, -8.21836293e-02f, -8.29729885e-02f, 4.22012731e-02f, -1.44739179e-02f, 1.03734247e-02f, -3.17697525e-02f, -1.04286000e-02f, -2.19981447e-02f, -5.30991293e-02f,
  6.14318773e-02f, 4.55501154e-02f, 4.67040017e-02f, -3.30258720e-03f, -3.00240386e-02f, -1.39743671e-01f, 1.89304855e-02f, 7.34362230e-02f, -7.58758327e-03f, 1.89790037e-02f,
  1.12449460e-01f, 1.05529748e-01f, -1.00104921e-02f, -1.00793270e-02f, 1.09167360e-01f, 5.74135743e-02f, 3.44133303e-02f, 1.39812985e-02f, 5.90183996e-02f, 2.83611920e-02f,
  -1.99685201e-01f, -3.01262081e-01f, 1.58329941e-02f, -2.30516866e-01f, -7.70783275e-02f, 2.25658834e-01f, 5.54154180e-02f, -1.53836936e-01f, -2.24947155e-01f, 1.59200914e-02f,
  -2.11935475e-01f, 3.40304263e-02f, 2.52002209e-01f, -4.13940340e-01f, 2.94928730e-01f, 9.63290557e-02f, -2.43559480e-01f, 5.19031249e-02f, -1.85015157e-01f, 4.17820476e-02f,
  -7.73816258e-02f, -1.86067820e-01f, -2.38636206e-03f, -1.83953017e-01f, -3.05556804e-01f, -1.50691032e-01f, 1.28172711e-01f, -8.16748571e-03f, -2.35174000e-01f, -1.64135009e-01f,
  -2.35211462e-01f, -2.20077887e-01f, -1.64607629e-01f, 2.17755069e-03f, -1.62357725e-02f, 9.08517092e-02f, 4.24520038e-02f, 2.70058289e-02f, -1.22969439e-02f, 3.08875497e-02f,
  5.98057099e-02f, 4.53759469e-02f, -1.80597678e-01f, 2.31894050e-02f, -4.99822833e-02f, -1.60788029e-01f, -7.54427835e-02f, -1.24092951e-01f, -9.96311158e-02f, 3.31407376e-02f,
  6.94910884e-02f, -9.51390192e-02f, -1.01625644e-01f, 7.99034759e-02f, -3.89137305e-02f, -1.62006631e-01f, 7.61622638e-02f, 2.35227928e-01f, -8.00503269e-02f, 1.38116321e-02f,
  6.61031296e-03f, 1.67352602e-01f, 6.17597252e-03f, -5.59804328e-02f, -5.74739315e-02f, -8.28758106e-02f, 5.78051582e-02f, -2.67211702e-02f, -2.84653325e-02f, -1.02985375e-01f,
  -1.14164323e-01f, 4.15290371e-02f, -1.10694980e-02f, 7.30173811e-02f, -6.24556327e-03f, -5.50614595e-02f, 6.96810037e-02f, 5.63676283e-03f, 1.79799590e-02f, 2.27249209e-02f,
  -7.25056008e-02f, -5.02984300e-02f, 1.34216091e-02f, 5.02186343e-02f, 8.18992313e-03f, 1.51527867e-01f, -1.10491607e-02f, 3.19263600e-02f, -7.05757663e-02f, 1.07589252e-01f,
  5.96871600e-02f, 3.53431562e-03f, -1.32620454e-01f, -1.09741904e-01f, 8.92434642e-02f, 1.90815516e-02f, -8.03398117e-02f, 3.03222835e-02f, 3.83038707e-02f, 3.59288864e-02f,
  4.17230539e-02f, 1.02306008e-01f, 4.45884950e-02f, 2.26626694e-02f, 5.02434224e-02f, 8.86957161e-03f, 4.04891521e-02f, -8.99946690e-02f, 1.04172409e-01f, -4.84973751e-02f,
  5.27786911e-02f, 5.23933247e-02f, 6.93628341e-02f, 4.16450342e-03f, -3.23959775e-02f, 5.58649860e-02f, 1.05322622e-01f, 2.97863502e-02f, -1.10199684e-02f, 6.47343993e-02f,
  4.66642946e-01f, -3.07633765e-02f, 3.78646672e-01f, 4.32454169e-01f, 2.14048147e-01f, -2.40783885e-01f, -1.72119036e-01f, 2.72989720e-01f, 3.54628921e-01f, -2.70970762e-01f,
  4.17793021e-02f, -9.44036245e-02f, -1.64541125e-01f, 2.23337576e-01f, -1.46642208e-01f, -1.93136737e-01f, -4.32604812e-02f, -1.36461824e-01f, 1.04154222e-01f, 1.13685489e-01f,
  1.70834064e-01f, -2.09473133e-01f, 1.45497024e-01f, -1.43733218e-01f, 2.08025903e-01f, 1.36499196e-01f, -1.72261104e-01f, -8.63477141e-02f, -2.72537321e-02f, -1.72539189e-01f,
  1.24169067e-01f, 2.37171650e-01f, 2.16426134e-01f, 4.85776961e-02f, 1.09357439e-01f, -9.85880569e-02f, -7.81380478e-03f, -6.70421794e-02f, 1.15139969e-01f, 2.59290263e-02f,
  -6.14783019e-02f, -4.64888327e-02f, 5.63110644e-03f, -6.75758198e-02f, 1.59249276e-01f, 9.27987173e-02f, 1.35011986e-01f, 1.53369144e-01f, 5.50645478e-02f, 5.78823313e-02f,
  1.41642019e-01f, 4.90186438e-02f, 6.83057457e-02f, -1.38541073e-01f, 6.28259555e-02f, 4.23592366e-02f, -1.24850951e-01f, -9.02128816e-02f, -4.82616425e-02f, 4.60933968e-02f,
  -9.45573077e-02f, -1.10490285e-01f, -1.29068159e-02f, 9.44133848e-02f, -5.67997620e-02f, 9.94220376e-02f, -4.26011086e-02f, -7.45987818e-02f, -1.57158598e-02f, -5.51228113e-02f,
  4.62269560e-02f, 5.12470305e-02f, 8.75208080e-02f, 1.31721618e-02f, 4.68395231e-03f, 2.28256155e-02f, -6.47348613e-02f, -9.35150087e-02f, 6.20326921e-02f, 6.32477999e-02f,
  -6.38635978e-02f, -5.17735928e-02f, 4.25378000e-03f, 1.76245645e-02f, -4.80847843e-02f, -2.74299439e-02f, 3.74199934e-02f, 6.94798380e-02f, 1.16297714e-01f, -1.06815830e-01f,
  -1.03016719e-01f, -3.65836233e-01f, 2.66112238e-02f, -4.30501848e-02f, 7.60344695e-03f, 8.68685246e-02f, -8.11225828e-03f, 4.28604428e-03f, -3.22761945e-02f, -5.63501194e-02f,
  9.58902389e-03f, 3.47574614e-02f, -2.59067565e-02f, 7.60192722e-02f, -4.30053174e-02f, -6.08992158e-03f, -1.00597158e-01f, -1.48515061e-01f, -8.62093419e-02f, -1.53258145e-02f,
  -2.57339925e-02f, -5.49852513e-02f, -3.89150642e-02f, -1.29837934e-02f, -1.60360504e-02f, -5.96660525e-02f, -6.12235069e-02f, -2.22465256e-03f, -1.14201546e-01f, -8.26720148e-02f,
  2.92067617e-01f, 6.79536462e-02f, -3.89970504e-02f, 3.75581563e-01f, 3.74842256e-01f, 1.97887167e-01f, 2.61023104e-01f, 2.93872714e-01f, 6.30802393e-01f, -8.15955251e-02f,
  -1.31069897e-02f, -9.41356719e-02f, -1.91224009e-01f, 1.44756019e-01f, 6.76639900e-02f, -4.50808443e-02f, 3.72156441e-01f, 1.83622837e-01f, 2.44651556e-01f, 1.57816350e-01f,
  1.48243979e-01f, 5.82543351e-02f, -3.17245156e-01f, -4.65242229e-02f, 3.60065922e-02f, -5.55928312e-02f, -2.79799759e-01f, -1.50649950e-01f, -2.05055684e-01f, -5.12436703e-02f,
  -3.47578600e-02f, 1.30393162e-01f, -1.06454626e-01f, -1.48456484e-01f, 4.64944057e-02f, 1.05378712e-02f, -6.15953244e-02f, -1.36399508e-01f, -6.52905479e-02f, -1.43268004e-01f,
  1.18496437e-02f, -1.25610501e-01f, -1.47722540e-02f, -7.96756595e-02f, 4.55466062e-02f, -2.02984624e-02f, -7.41834342e-02f, -3.44139598e-02f, -2.18762662e-02f, -4.53220531e-02f,
  -4.55889329e-02f, 3.03287636e-02f, 4.55087535e-02f, -7.58020282e-02f, -1.89109147e-02f, 1.38656807e-03f, 5.69342040e-02f, -6.27040565e-02f, -4.62000184e-02f, 9.41656232e-02f,
  2.76265275e-02f, 1.78958878e-01f, -9.95309651e-02f, -8.71626809e-02f, -4.23147576e-03f, -7.80005613e-03f, 4.39874753e-02f, 2.94973399e-03f, 3.28466780e-02f, 4.10197005e-02f,
  -9.29548478e-05f, -1.23475436e-02f, 9.95502397e-02f, -1.42913815e-02f, 1.16805613e-01f, 4.19494882e-02f, -6.35359064e-02f, -7.18060657e-02f, 8.48145783e-02f, 2.52585895e-02f,
  5.06996550e-02f, 2.19697263e-02f, -1.47909895e-01f, 2.91227233e-02f, 5.44009637e-03f, -1.13372900e-01f, 8.53046700e-02f, 1.93720106e-02f, 3.72729450e-02f, 3.24849449e-02f,
  2.82746583e-01f, 3.12563062e-01f, -2.66641669e-04f, -1.16409935e-01f, 2.68318783e-02f, 4.89427075e-02f, 6.88016415e-02f, 2.67421938e-02f, 1.17379509e-01f, -3.39915883e-03f,
  1.04083590e-01f, 2.65665874e-02f, -1.60857085e-02f, -3.93337682e-02f, -1.25481682e-02f, 3.68816219e-03f, -3.13473456e-02f, 7.92961046e-02f, 1.39963254e-01f, 9.73705482e-03f,
  6.07834989e-03f, 1.33250192e-01f, 7.13823512e-02f, 3.69970687e-02f, 3.50754969e-02f, -2.83079688e-02f, 1.22416787e-01f, -3.51319425e-02f, -1.18919685e-02f, 3.79979089e-02f,
  -4.32076246e-01f, 3.43033165e-01f, 2.64382102e-02f, 3.34560633e-01f, -1.98230252e-01f, -5.32247066e-01f, -1.02292433e-01f, 7.67686591e-02f, -1.10552050e-01f, 3.47829103e-01f,
  4.46477979e-01f, -1.36255443e-01f, 3.50925088e-01f, 3.63150686e-01f, -2.90609419e-01f, 2.23575801e-01f, 1.26245141e-01f, -1.21711905e-03f, -1.31095126e-01f, 1.73300326e-01f,
  -3.64121795e-02f, 2.45541826e-01f, 2.99675614e-01f, 1.34594798e-01f, -2.39040493e-03f, 1.13684647e-01f, 3.62040550e-01f, 8.20615441e-02f, 9.02235135e-02f, -1.17887266e-01f,
  1.04173990e-02f, 2.45371640e-01f, 1.24329031e-02f, -8.13679025e-02f, 2.94951163e-02f, -2.13890933e-02f, -5.43045402e-02f, -5.95124140e-02f, -1.29793957e-02f, -6.43991574e-04f,
  -5.03546558e-02f, -1.45594105e-02f, -7.71723986e-02f, -1.18243610e-02f, -8.84380788e-02f, -6.88742753e-03f, -9.62257236e-02f, -9.31573510e-02f, -5.23250960e-02f, 1.59570519e-02f,
  3.33881155e-02f, -2.54860930e-02f, -3.47736711e-03f, 8.79532695e-02f, -9.00362339e-03f, 6.45695254e-03f, -2.82522738e-02f, -1.83148198e-02f, -3.94725874e-02f, -3.94873060e-02f,
  4.87597175e-02f, -4.41978872e-02f, -2.57716794e-02f, 1.35667920e-02f, -6.58757091e-02f, 4.01761159e-02f, -1.58766136e-02f, -3.61382626e-02f, -4.88624070e-03f, 1.06004857e-01f,
  2.97210645e-02f, 4.09360789e-03f, 2.41320226e-02f, 2.02666689e-02f, -1.29027367e-02f, 6.08576322e-03f, -2.51211878e-02f, 5.07030860e-02f, -3.34200007e-03f, -1.40486034e-02f,
  1.05450831e-01f, -4.37893011e-02f, -6.14808165e-02f, 2.60796752e-02f, -3.00475024e-02f, 8.97398815e-02f, 7.68580288e-02f, 3.59768458e-02f, 3.42269540e-02f, -3.10291909e-02f,
  1.54117152e-01f, 3.03886533e-01f, 5.89303821e-02f, -5.84352016e-02f, 4.00493965e-02f, -6.11176156e-02f, 5.85492551e-02f, -7.91743174e-02f, 5.43731488e-02f, -3.42341959e-02f,
  -2.98097935e-02f, -4.85740304e-02f, -7.43195489e-02f, 3.14428471e-02f, -3.69137451e-02f, 9.14546698e-02f, 8.83057937e-02f, -3.63193378e-02f, 8.58734027e-02f, 3.91633454e-04f,
  1.24787763e-01f, -1.80813279e-02f, 4.41740826e-02f, -5.96622787e-02f, 2.01091124e-03f, 1.09236218e-01f, -3.19594145e-02f, -1.45301567e-02f, 9.84225795e-02f, 3.03667225e-02f,
  2.19789058e-01f, -2.28425905e-01f, -2.16114476e-01f, -2.31184557e-01f, 8.46731514e-02f, 3.24229032e-01f, 4.70376521e-01f, -1.94120467e-01f, -3.69885713e-01f, 1.47729114e-01f,
  3.28813761e-01f, -3.69529463e-02f, 3.66164923e-01f, 1.38440654e-01f, 2.33575776e-01f, 2.10662588e-01f, 7.41429180e-02f, 1.16378024e-01f, -1.28602043e-01f, 7.25681186e-02f,
  -6.04217090e-02f, 2.58029908e-01f, 1.82927608e-01f, -2.32347608e-01f, 1.71477899e-01f, -2.26873666e-01f, 4.41972874e-02f, 6.35731593e-02f, -7.13108480e-02f, 1.36685371e-01f,
  6.31995648e-02f, -2.01645959e-02f, 6.64868727e-02f, 9.63841006e-03f, 1.59637243e-01f, 1.18407875e-01f, 1.19378284e-01f, 1.56411946e-01f, -7.02680722e-02f, -5.69721730e-03f,
  2.85552982e-02f, -1.50273666e-01f, -1.12532981e-01f, 2.99807284e-02f, -6.91341311e-02f, -1.58018693e-01f, -1.37118101e-01f, 6.63615903e-03f, -1.15653850e-01f, 1.25529706e-01f,
  5.43406010e-02f, -6.13790564e-02f, -2.12853937e-03f, -1.45165861e-01f, -3.78661379e-02f, -6.52923137e-02f, 3.79708782e-02f, 7.09415153e-02f, -6.38267547e-02f, -3.71187180e-02f,
  2.51646154e-02f, 3.33660059e-02f, 5.99821210e-02f, -5.13970070e-02f, 3.17611918e-02f, -6.56320378e-02f, -2.07543392e-02f, 8.83909699e-04f, -9.63858142e-03f, 1.24630205e-01f,
  -1.32666826e-01f, -1.05461068e-01f, 2.97226328e-02f, 3.99945378e-02f, 6.41045943e-02f, -2.83478405e-02f, 8.76994431e-02f, -3.04143149e-02f, -1.16930073e-02f, -7.27143884e-02f,
  9.20676102e-04f, -4.97690551e-02f, 7.06214160e-02f, 3.05122286e-02f, -1.30595127e-03f, 7.96233788e-02f, -1.54394619e-02f, 6.28831908e-02f, -1.74272284e-02f, 8.30489248e-02f,
  1.07517697e-01f, -6.32986575e-02f, -2.85737254e-02f, -5.95086254e-02f, 1.48455705e-02f, 8.37580264e-02f, 5.59379384e-02f, -8.42408389e-02f, 7.76245678e-03f, 3.91252227e-02f,
  -5.76345846e-02f, -8.11579451e-02f, -4.46388796e-02f, 4.12111022e-02f, -1.57455862e-01f, 3.81055102e-02f, -4.69494611e-02f, -3.20485905e-02f, -3.90069559e-02f, -1.02860965e-01f,
  3.93163487e-02f, -3.98337394e-02f, -1.05123684e-01f, -5.05505092e-02f, -1.07673466e-01f, 1.40790880e-01f, 6.19088439e-03f, -4.55418937e-02f, -5.97612448e-02f, -8.24769363e-02f,
  1.46434546e-01f, -2.78351426e-01f, -3.61826152e-01f, -1.55707508e-01f, 2.68235356e-01f, 2.75962889e-01f, -1.33613318e-01f, 1.68671966e-01f, -3.33885431e-01f, 6.65568262e-02f,
  6.30496368e-02f, -3.66245449e-01f, -2.35773593e-01f, -1.19051419e-01f, -8.45381618e-02f, -3.25401932e-01f, 1.62317008e-01f, -5.53979054e-02f, -1.35116294e-01f, 1.44904479e-01f,
  -8.81975982e-03f, 2.70096272e-01f, -1.32062137e-01f, 3.21365535e-01f, 2.53720820e-01f, 1.97774723e-01f, 3.71467561e-01f, -2.23723496e-03f, 2.39383116e-01f, 1.48018803e-02f,
  7.28149666e-03f, -1.05663538e-01f, -7.78787062e-02f, -8.79535004e-02f, 1.22042567e-01f, 2.14050770e-01f, 5.19482493e-02f, -1.36530800e-02f, -4.44521084e-02f, -8.34423900e-02f,
  2.09864676e-02f, 5.14945760e-03f, 1.37689319e-02f, -1.12954741e-02f, 3.84275950e-02f, 5.68439364e-02f, -4.87932488e-02f, -4.59135883e-03f, -1.29225969e-01f, -1.02982789e-01f,
  -8.61441046e-02f, 4.57418412e-02f, 6.47509396e-02f, -5.16144857e-02f, -9.14067850e-02f, 2.84844358e-02f, 9.55669060e-02f, 2.73932349e-02f, 2.30749715e-02f, 6.21870384e-02f,
  1.77510113e-01f, 7.80426115e-02f, 7.04553202e-02f, -1.46221280e-01f, -6.19695261e-02f, -6.07084110e-03f, -3.87194864e-02f, -1.84952151e-02f, -8.58267248e-02f, 2.09630765e-02f,
  -9.75428335e-03f, -7.30307307e-03f, -6.24985360e-02f, 2.19097771e-02f, 8.99390802e-02f, 2.55421307e-02f, 5.08895442e-02f, 1.45085501e-02f, -1.75892711e-02f, -5.55236824e-02f,
  -8.13981965e-02f, 4.95004207e-02f, -2.84951758e-02f, 2.27398295e-02f, -1.75498109e-02f, -1.37508968e-02f, 5.85871823e-02f, -1.77217089e-02f, -4.56131287e-02f, 3.22635323e-02f,
  1.08432770e-01f, 1.47520542e-01f, 1.96275581e-03f, -4.37770598e-02f, -9.31722969e-02f, 1.23047031e-01f, -9.25063156e-03f, -2.54032109e-02f, 9.43747407e-04f, 4.32998594e-03f,
  1.86431482e-01f, 6.11917675e-02f, 9.21918973e-02f, 5.51547594e-02f, 1.94916856e-02f, 1.02233432e-01f, 1.23397796e-03f, 1.70841087e-02f, 1.19947828e-01f, 3.97298299e-02f,
  1.17127694e-01f, 1.15329593e-01f, -1.75090712e-02f, -2.67031379e-02f, 6.40570521e-02f, 1.01511419e-01f, 1.32595122e-01f, 5.57435676e-04f, -5.05592034e-04f, -8.37725624e-02f,
  2.83165872e-01f, -4.83088315e-01f, -3.47565971e-02f, 3.24886262e-01f, 9.22991857e-02f, -2.13802949e-01f, 2.43471146e-01f, -1.32908538e-01f, 2.44899467e-01f, -3.02366018e-01f,
  1.47709936e-01f, -1.03409864e-01f, 1.36720717e-01f, -9.13296193e-02f, 1.59793124e-01f, 1.71413928e-01f, -7.63405114e-02f, -4.36208621e-02f, 1.41367748e-01f, -1.44023985e-01f,
  9.48649868e-02f, -1.08136401e-01f, 1.01178341e-01f, -3.70723873e-01f, -6.90384135e-02f, -1.10489503e-01f, 2.17469316e-02f, -4.10004109e-02f, -2.79613912e-01f, -3.80599871e-02f,
  -1.57279998e-01f, 1.21807784e-01f, 1.03568241e-01f, -1.05193742e-01f, -5.11939116e-02f, -2.80109025e-03f, 1.20181842e-02f, 5.13744913e-02f, 8.42094943e-02f, -4.81964909e-02f,
  -2.06474517e-03f, -3.50127816e-02f, -1.00134380e-01f, -2.45436677e-03f, 4.02169377e-02f, -4.78203744e-02f, 1.06730964e-02f, 4.73795347e-02f, 1.05469516e-02f, 2.01943740e-02f,
  5.12702949e-02f, -2.59008240e-02f, 3.66562530e-02f, 8.01944267e-03f, 8.47164392e-02f, 1.30366478e-02f, 2.11523240e-03f, -7.29866326e-03f, -7.60637224e-02f, -1.29271736e-02f,
  2.93047708e-02f, 6.10792860e-02f, 3.89435589e-02f, -6.70930296e-02f, -5.94098121e-02f, 6.50496483e-02f, 3.38198006e-04f, -5.96107058e-02f, 3.77378948e-02f, -1.73082259e-02f,
  -1.05964234e-02f, -2.93503911e-03f, -2.56312685e-03f, 7.73927644e-02f, 6.03679828e-02f, 3.51282954e-02f, -1.34988455e-02f, -1.14948221e-01f, 5.07606938e-02f, 2.62972880e-02f,
  1.60757415e-02f, -5.74083403e-02f, 2.29902137e-02f, 5.10645024e-02f, -5.44271879e-02f, 6.57433346e-02f, -3.42937484e-02f, -3.95185081e-03f, 1.02199785e-01f, -1.26911635e-02f,
  -4.15177673e-01f, -3.55336457e-01f, 4.03364301e-02f, -4.47867289e-02f, -1.37688875e-01f, -8.01014081e-02f, -4.65455912e-02f, -1.12043031e-01f, -9.71675515e-02f, 4.72401641e-02f,
  -8.31447244e-02f, 1.80408377e-02f, -6.14748709e-02f, 4.13412927e-04f, -4.54896167e-02f, 3.67454514e-02f, -3.12102754e-02f, -8.80165920e-02f, 1.61773805e-02f, -1.39783397e-01f,
  -7.73295835e-02f, -7.63839716e-03f, -2.08838135e-02f, 9.93579030e-02f, -3.92032154e-02f, -2.53989268e-02f, -1.12894148e-01f, 1.38806356e-02f, -4.95385900e-02f, -7.60331377e-02f,
  -1.25728711e-01f, -1.47876576e-01f, -1.88267291e-01f, -2.12664157e-02f, 5.88568561e-02f, -3.07045072e-01f, -2.76086152e-01f, 1.07284039e-01f, 1.76167786e-01f, -3.84111032e-02f,
  -8.97809491e-02f, -3.55210572e-01f, 1.75876431e-02f, -3.33073348e-01f, -1.22267231e-01f, -7.18225092e-02f, -3.21635097e-01f, -2.75610089e-01f, 5.42350598e-02f, -2.32274488e-01f,
  4.13954034e-02f, 8.85335822e-03f, -5.93666658e-02f, 1.96092829e-01f, -7.87587389e-02f, 1.93742454e-01f, 2.31235757e-01f, 9.85999405e-02f, -9.72243249e-02f, 7.50418976e-02f,
  -8.04730281e-02f, 1.36829838e-01f, 9.10279341e-03f, 2.75149234e-02f, 4.71265018e-02f, -7.08637461e-02f, -6.70195222e-02f, 6.20646030e-03f, 3.32786180e-02f, 4.67138775e-02f,
  -1.11208698e-02f, 8.76650512e-02f, 1.23519367e-02f, 4.09721546e-02f, 6.95243403e-02f, -4.41744998e-02f, 6.02574460e-02f, 9.35108662e-02f, -7.43546262e-02f, -1.21160306e-01f,
  -8.74873400e-02f, -3.24799195e-02f, -3.34828049e-02f, 1.08592808e-01f, 2.05315109e-02f, 2.95071187e-03f, -5.99178150e-02f, -1.16640195e-01f, 3.16026062e-02f, 3.92577425e-02f,
  8.48585740e-03f, -7.76192266e-03f, -9.31364298e-02f, 1.04213744e-01f, 3.41310278e-02f, 4.06319425e-02f, 7.04281405e-02f, 3.19655170e-04f, 1.06582932e-01f, -8.77733305e-02f,
  9.80338380e-02f, 1.71341393e-02f, 2.29718871e-02f, -5.65731339e-02f, -7.56184161e-02f, 3.46629769e-02f, -4.71519791e-02f, -2.55947169e-02f, 2.74124071e-02f, -5.37306536e-03f,
  -9.27460752e-03f, -6.62340745e-02f, 7.61585534e-02f, 8.73741787e-03f, -2.07862779e-02f, 8.37381110e-02f, -6.79644868e-02f, -8.82740691e-02f, -1.58992112e-02f, -3.42163779e-02f,
  -4.83907051e-02f, 6.70308322e-02f, 8.95710438e-02f, 5.11705652e-02f, -1.06949424e-02f, -2.66294368e-02f, -7.66760185e-02f, 2.29984317e-02f, 3.28886770e-02f, 4.42144135e-03f,
  -2.82905344e-02f, -2.54180990e-02f, 1.27757946e-02f, 3.55637185e-02f, 3.32333297e-02f, -4.16733399e-02f, 3.45981196e-02f, 1.71173856e-01f, 7.41606206e-02f, 6.45228997e-02f,
  -3.26198637e-02f, -1.18200049e-01f, 6.09987117e-02f, 8.62503573e-02f, -4.27692868e-02f, -7.72411295e-05f, -6.16788492e-02f, -5.00709489e-02f, 6.50976226e-03f, -4.64479299e-03f,
  7.47774899e-01f, -3.05918932e-01f, -6.06023259e-02f, 1.91906065e-01f, 1.05808772e-01f, 2.70661116e-01f, 3.94275099e-01f, -7.93901756e-02f, 8.11953004e-03f, -2.29000777e-01f,
  -6.36032820e-02f, 1.47808045e-01f, -2.24450976e-01f, 2.20645100e-01f, 2.52597839e-01f, -2.50596374e-01f, 2.55046070e-01f, 1.67025104e-01f, -9.19373557e-02f, 1.07552961e-01f,
  3.72551866e-02f, 2.95187384e-02f, -4.54071984e-02f, -1.68549255e-01f, 2.87675172e-01f, 6.33597597e-02f, -2.05876485e-01f, -7.84567073e-02f, 6.98835552e-02f, 1.52514979e-01f,
  1.45457715e-01f, -1.42437536e-02f, 2.78198812e-02f, -2.12715156e-02f, -6.25621602e-02f, 6.04091287e-02f, 1.53153203e-02f, 4.89760749e-02f, 6.69722036e-02f, -1.05855409e-02f,
  -4.31747502e-03f, 1.88294183e-02f, 1.64349214e-03f, 1.08673945e-02f, 1.28137171e-01f, 1.01035289e-01f, 2.54320577e-02f, -4.14593071e-02f, -4.04120646e-02f, 1.62942726e-02f,
  2.36737467e-02f, 4.64118049e-02f, 6.28852993e-02f, -6.46488741e-04f, -1.14343867e-01f, 3.01625784e-02f, 2.36521419e-02f, 4.20455728e-03f, 4.53129858e-02f, 7.72582069e-02f,
  -4.29961197e-02f, -3.94389443e-02f, 2.51885280e-02f, 9.88748446e-02f, 1.48077160e-02f, 1.89882759e-02f, 1.00199603e-01f, -2.84176189e-02f, -1.70975886e-02f, -2.39371248e-02f,
  4.42755930e-02f, 9.66921225e-02f, -1.67692285e-02f, 5.23107722e-02f, -1.51339862e-02f, 4.78985496e-02f, -2.24133744e-03f, -3.19310836e-02f, -7.33634159e-02f, 4.27003056e-02f,
  6.27646744e-02f, 6.03859127e-02f, -2.66731344e-03f, 4.72165719e-02f, 2.80990265e-02f, -6.21787645e-02f, -6.30862191e-02f, 1.27810333e-02f, -7.36735836e-02f, 5.19673061e-03f,
  -8.74227062e-02f, -4.16521370e-01f, -1.18888944e-01f, -5.00782467e-02f, -7.49199688e-02f, -3.58580053e-03f, -1.20257037e-02f, 6.30305856e-02f, 1.33720180e-03f, 1.40794730e-02f,
  -4.25706170e-02f, 3.08516771e-02f, -8.03040266e-02f, 6.67380169e-02f, 1.02312025e-02f, -9.84177440e-02f, -5.98537736e-02f, -5.31275794e-02f, 5.74361533e-03f, -3.32637765e-02f,
  -1.17623806e-02f, 1.94919035e-02f, 9.77826342e-02f, 3.61709623e-03f, -7.98456743e-02f, -5.74023947e-02f, 3.49712707e-02f, 4.97599598e-03f, -2.57448275e-02f, 3.12792626e-03f
};

// L0_fan_Bp_bar (Shape: 1 x 26)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 26;
const float L0_fan_Bp_bar_data[] = {
  3.99181545e-01f, 3.59954268e-01f, 2.97025800e-01f, 3.03522587e-01f, 2.97422498e-01f, 4.24292386e-01f, 3.12751800e-01f, 3.57283622e-01f, 2.20417842e-01f, 2.75999427e-01f,
  2.38269955e-01f, 3.43475044e-01f, 3.10422421e-01f, 3.21487129e-01f, 1.69880554e-01f, 3.84106636e-01f, 3.15390110e-01f, 4.19424534e-01f, 4.16614145e-01f, 2.15675443e-01f,
  3.88284951e-01f, 2.85656571e-01f, 3.95240426e-01f, 3.86964977e-01f, 4.34567481e-01f, 5.13962328e-01f
};

// L1_linear_W (Shape: 12 x 128)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 128;
const float L1_linear_W_data[] = {
  2.66435686e-02f, 5.29376939e-02f, 8.79025832e-02f, 1.72014728e-01f, -2.46327624e-01f, 1.08684324e-01f, -8.09917599e-02f, 3.44227143e-02f, -9.49180052e-02f, -1.39389172e-01f,
  -7.26999119e-02f, 2.49032229e-02f, -1.01442099e-01f, 1.27108604e-01f, -2.92312771e-01f, -9.54010040e-02f, 1.12894252e-02f, -1.54341444e-01f, -2.09166631e-01f, -2.18301922e-01f,
  1.60431996e-01f, 8.15626830e-02f, -1.18463881e-01f, -3.43421916e-03f, -1.60637006e-01f, -2.19874546e-01f, -1.35246903e-01f, -1.26467571e-01f, -2.67214984e-01f, 7.98696950e-02f,
  7.33616650e-02f, -1.42342776e-01f, -5.32280914e-02f, -2.31787845e-01f, -1.23150393e-01f, -2.76517551e-02f, 2.87697632e-02f, 1.13641508e-01f, -2.12810084e-01f, 1.31599933e-01f,
  6.79793060e-02f, -1.23596877e-01f, -1.38512373e-01f, -1.20152578e-01f, -1.13715924e-01f, -1.71472892e-01f, -2.10498229e-01f, -2.05428481e-01f, -6.21839985e-03f, -1.09131664e-01f,
  4.34936862e-03f, -2.73984730e-01f, -1.65381745e-01f, 2.69644678e-01f, 3.19516994e-02f, -2.17427537e-01f, -1.84238568e-01f, 2.17693552e-01f, -3.59904975e-01f, 4.18620594e-02f,
  -6.37755264e-03f, -1.18061423e-01f, 4.27991040e-02f, -2.01389953e-01f, -1.92453474e-01f, -2.80028820e-01f, -1.95972785e-01f, -1.95024282e-01f, 1.76990032e-01f, -2.09784597e-01f,
  -1.71123013e-01f, -4.90576141e-02f, 2.42297173e-01f, 2.46156976e-01f, -3.94371003e-02f, -9.55430493e-02f, 3.98115247e-01f, -8.90146717e-02f, -2.76948094e-01f, -1.93111166e-01f,
  1.27187192e-01f, -3.50280218e-02f, 1.41223356e-01f, -3.70599419e-01f, 2.31190994e-01f, 3.07037592e-01f, -2.23696113e-01f, 1.42018974e-01f, 2.28535905e-02f, -3.57128263e-01f,
  2.87227899e-01f, 7.09213763e-02f, -2.49575779e-01f, -1.19793132e-01f, -6.32680058e-02f, -3.43598306e-01f, -1.09489381e-01f, -2.72346467e-01f, 2.58515596e-01f, -3.42593998e-01f,
  -1.75588727e-02f, 2.72298038e-01f, -4.56893951e-01f, 3.25812399e-01f, 5.39607108e-01f, -4.49532896e-01f, 5.52001953e-01f, -5.97542405e-01f, -1.72291204e-01f, -2.08557606e-01f,
  -7.01028705e-02f, 3.84552240e-01f, 4.75771219e-01f, 5.18053174e-01f, -4.53043245e-02f, -4.40651268e-01f, -2.77000517e-01f, -3.19022357e-01f, -1.36940032e-01f, -7.06195310e-02f,
  -8.45338106e-02f, -4.01775390e-01f, 4.39443290e-01f, 2.56302178e-01f, -3.42030764e-01f, 1.73804119e-01f, -2.22438917e-01f, -4.54295516e-01f, -8.78595635e-02f, 8.94739875e-04f,
  -9.72033069e-02f, 9.05164853e-02f, 3.38542193e-01f, -3.14375050e-02f, 8.94184336e-02f, -1.00216724e-01f, -1.65085923e-02f, -2.88320035e-01f, 5.39728217e-02f, -1.77399904e-01f,
  -1.13826506e-02f, -1.54781729e-01f, -4.07155603e-02f, 4.23106521e-01f, 1.34217575e-01f, 2.17575043e-01f, -7.45486617e-02f, -3.76327276e-01f, -4.86216217e-01f, 5.00058979e-02f,
  1.17290385e-01f, -3.37503990e-03f, -7.48045975e-03f, 3.89022827e-02f, 7.88577199e-02f, 2.01149255e-01f, -1.45931542e-01f, 1.24359943e-01f, 9.32799876e-02f, 3.03962976e-02f,
  -2.17207223e-01f, -1.30293474e-01f, 7.34687373e-02f, 2.60119528e-01f, -6.42405823e-02f, -1.88769236e-01f, -5.16390540e-02f, 8.60210806e-02f, -1.67722166e-01f, 6.14349246e-02f,
  -2.74054706e-01f, 2.89447214e-02f, -1.91659763e-01f, 1.35932937e-01f, -2.39312217e-01f, 1.84132561e-01f, -7.42275491e-02f, 1.12669811e-01f, -4.01176125e-01f, 3.84439491e-02f,
  2.72819281e-01f, -1.71642110e-01f, -3.55879158e-01f, 3.60075921e-01f, -3.23481560e-01f, 7.37431794e-02f, 3.94888222e-01f, -3.16534191e-01f, -3.37351054e-01f, -2.58444339e-01f,
  3.97481650e-01f, -3.92431855e-01f, 4.41966265e-01f, -3.22104156e-01f, 1.30459383e-01f, 3.69064286e-02f, 3.14437032e-01f, -3.74164760e-01f, -3.14512432e-01f, -2.11506158e-01f,
  3.14904183e-01f, 2.30930164e-01f, 2.68118352e-01f, -2.85069048e-01f, -4.91588861e-01f, -3.48439217e-01f, -8.93561263e-03f, -2.42149606e-01f, -5.56794778e-02f, -2.51814038e-01f,
  2.88255095e-01f, 4.65141237e-01f, -7.66240954e-02f, -5.78852929e-03f, 7.31648952e-02f, 2.64851511e-01f, -2.90280491e-01f, -7.65927741e-03f, 2.10401744e-01f, -3.90218496e-01f,
  -2.20113263e-01f, -3.86556000e-01f, 1.78153574e-01f, -2.49926329e-01f, -1.91907078e-01f, -2.88163185e-01f, -3.44011709e-02f, -3.22269946e-01f, 2.57554322e-01f, -3.84552628e-01f,
  -1.10060066e-01f, -3.94048303e-01f, -4.23914880e-01f, 1.09873176e-01f, 3.09877098e-01f, 3.99206489e-01f, 1.89765900e-01f, -1.10343046e-01f, -5.38203157e-02f, 8.29369798e-02f,
  -4.38614249e-01f, 9.42703038e-02f, -5.02027750e-01f, -3.25215012e-01f, 1.41781196e-01f, -3.10062736e-01f, 1.72020402e-02f, -4.57588583e-01f, -2.78781682e-01f, 2.12966502e-01f,
  -1.16696075e-01f, 4.96721685e-01f, 3.20848227e-01f, -3.82673830e-01f, -3.04043293e-01f, 2.18853027e-01f, -5.42688929e-02f, 1.63719896e-02f, 4.93980087e-02f, -2.56328255e-01f,
  -2.47151837e-01f, -1.95762411e-01f, -1.75238848e-01f, -1.94874797e-02f, 5.09019382e-02f, -1.00467667e-01f, -2.96604354e-02f, -1.61187053e-01f, 4.56951074e-02f, 1.07898116e-01f,
  -1.45156339e-01f, -2.56335974e-01f, -2.27141619e-01f, -5.48842421e-04f, -1.51859596e-01f, 1.39554545e-01f, -1.41706809e-01f, 7.85136670e-02f, -1.26494542e-01f, 3.85717042e-02f,
  -1.14228338e-01f, -1.35250501e-02f, 1.09258257e-01f, -2.40942806e-01f, 2.85030585e-02f, -1.80248529e-01f, -6.70033693e-02f, -5.52930124e-02f, 7.52030015e-02f, 3.96666527e-02f,
  8.88074636e-02f, -2.82126248e-01f, -9.77142230e-02f, -1.74562022e-01f, 7.34928846e-02f, -8.87318552e-02f, 1.01990022e-01f, -1.01169184e-01f, 1.37716264e-01f, 5.89454584e-02f,
  -2.64068872e-01f, -1.48923591e-01f, 1.57321021e-01f, 4.61658351e-02f, -4.86695617e-02f, 2.03411356e-02f, -8.86558518e-02f, 1.58412620e-01f, 2.53431827e-01f, -2.12177187e-01f,
  -1.71438769e-01f, 1.76145509e-01f, -2.69564629e-01f, -3.28541934e-01f, 1.70594398e-02f, 3.33711326e-01f, -2.75743783e-01f, 3.15912396e-01f, 1.05497412e-01f, -1.81796864e-01f,
  -4.87255491e-02f, -2.30270773e-02f, 7.96772242e-02f, -3.08256596e-01f, -7.10798651e-02f, 3.50316167e-01f, 1.46690413e-01f, -2.30628416e-01f, 3.20648998e-02f, 2.77808696e-01f,
  -1.02547713e-01f, 3.19194734e-01f, 6.22727238e-02f, -2.39263073e-01f, 2.30361581e-01f, -1.41674995e-01f, 1.77103579e-01f, 1.90204382e-01f, -2.57559478e-01f, -2.13824466e-01f,
  -5.75447045e-02f, -1.71756193e-01f, -2.49414384e-01f, 1.84038371e-01f, 2.07482241e-02f, -1.66658819e-01f, 2.46898443e-01f, 7.94566125e-02f, 3.23560953e-01f, 3.39816540e-01f,
  4.33259271e-02f, -2.41626069e-01f, 1.24962442e-01f, -5.10468632e-02f, -1.40624672e-01f, 3.35379034e-01f, -2.21897960e-01f, 2.65738696e-01f, -1.36569917e-01f, -1.09862819e-01f,
  -1.48851961e-01f, -2.86540270e-01f, 5.22908509e-01f, 5.55002272e-01f, 6.52913302e-02f, -3.21311742e-01f, -1.56676710e-01f, -3.02260995e-01f, -1.50862291e-01f, -2.05090433e-01f,
  5.66740215e-01f, -3.47387522e-01f, -2.14327708e-01f, -1.37801766e-01f, -2.45980680e-01f, -1.56741545e-01f, -7.63718924e-03f, -1.90896899e-01f, -5.43647289e-01f, -4.26238835e-01f,
  3.38443249e-01f, -2.34804302e-01f, 1.45003140e-01f, 4.08753663e-01f, -1.75669834e-01f, 1.28972992e-01f, 6.21820763e-02f, 2.48096660e-02f, -1.60239458e-01f, 1.36558875e-01f,
  -8.54451284e-02f, -4.30256009e-01f, -1.15517735e-01f, 4.03378233e-02f, 2.14346126e-01f, -2.91697085e-01f, -1.39296338e-01f, -1.08542237e-02f, -8.60604718e-02f, -2.94521391e-01f,
  9.01235938e-02f, 1.49244058e-03f, 3.69165912e-02f, -8.06963891e-02f, -5.53244166e-02f, -3.76861505e-02f, -1.47342142e-02f, -1.50403567e-02f, -5.03575206e-02f, 9.74482670e-02f,
  -1.85276151e-01f, -6.59554973e-02f, -1.84793361e-02f, 2.86405091e-03f, -3.71746644e-02f, 1.20150978e-02f, 4.92133796e-02f, -6.42967969e-02f, -2.65887588e-01f, -2.35986590e-01f,
  -3.08679312e-01f, -3.55466485e-01f, 1.74903162e-02f, 1.79761782e-01f, 9.12218690e-02f, 1.05097130e-01f, -2.36000909e-04f, 2.01977462e-01f, -2.08042236e-03f, -2.91017830e-01f,
  -5.07783405e-02f, 2.24005088e-01f, -4.60905209e-02f, -3.68428349e-01f, 5.61243780e-02f, -2.76379138e-01f, -1.34152815e-01f, 1.74883634e-01f, 3.60172242e-01f, 2.11241655e-02f,
  2.12299645e-01f, 3.19170773e-01f, -6.10397086e-02f, -2.69073159e-01f, 8.46822932e-02f, -4.00912493e-01f, -1.27730504e-01f, 1.76595926e-01f, -2.35596504e-02f, 3.39904666e-01f,
  -2.25796551e-01f, 1.23891421e-01f, 2.59371269e-02f, -1.30035177e-01f, -1.73939392e-01f, 1.94888383e-01f, 8.34131613e-02f, -2.85180300e-01f, 2.25255832e-01f, 3.85191172e-01f,
  -1.79993227e-01f, -1.92942083e-01f, 3.39317508e-02f, 2.21328698e-02f, 1.62902519e-01f, 1.75284028e-01f, 2.58948892e-01f, -1.77077100e-01f, -6.77583367e-02f, -2.34114975e-01f,
  2.32242063e-01f, 4.25026476e-01f, -8.37653726e-02f, -3.70169759e-01f, -1.61209464e-01f, 1.47537470e-01f, 7.25933462e-02f, 2.23234564e-01f, 1.00660682e-01f, 5.40581569e-02f,
  2.65167683e-01f, -2.87592709e-01f, -1.68756142e-01f, -2.04641610e-01f, 2.45698795e-01f, -2.66914994e-01f, 4.54772711e-01f, 1.02647014e-01f, -4.29100543e-01f, 1.64997593e-01f,
  -2.71643907e-01f, -1.75333545e-01f, -2.71561831e-01f, -3.90173048e-01f, 6.52903378e-01f, -4.24605757e-01f, 5.69919586e-01f, 1.78038687e-01f, -2.72979379e-01f, -3.96839321e-01f,
  -4.03135806e-01f, 1.85659871e-01f, 1.14353485e-01f, -2.09502995e-01f, -1.08621009e-01f, -2.37779647e-01f, 4.07271832e-01f, -1.52018085e-01f, -3.58074844e-01f, -3.57535481e-02f,
  3.06464285e-01f, -1.63870603e-01f, 1.29207179e-01f, -1.76389590e-01f, 2.05395535e-01f, -1.44282924e-02f, 1.52991816e-01f, -1.49967372e-01f, 2.10121199e-01f, 1.29398927e-01f,
  -6.91335574e-02f, -1.96945425e-02f, -2.80221961e-02f, 7.20402002e-02f, 2.63575852e-01f, -2.48513818e-01f, 3.86962175e-01f, 2.51388010e-02f, -9.55726728e-02f, -2.21261289e-02f,
  1.96209565e-01f, 1.26698181e-01f, 4.04816680e-02f, -4.24389392e-02f, -1.22027405e-01f, -1.88859597e-01f, 4.15645778e-01f, 6.55011833e-02f, -2.89534897e-01f, -2.92740017e-01f,
  1.83205187e-01f, 9.17173848e-02f, 2.41787225e-01f, -2.15959121e-02f, -1.11403137e-01f, 2.58361787e-01f, 2.25896195e-01f, -8.27933699e-02f, 1.28455117e-01f, 1.02942079e-01f,
  4.11676466e-02f, -4.03057694e-01f, 1.55808583e-01f, 5.27783372e-02f, 1.56372190e-01f, 1.48423672e-01f, 2.00226426e-01f, 3.31063628e-01f, 1.48385599e-01f, -2.83269972e-01f,
  6.81934655e-02f, 3.42862248e-01f, 1.64113507e-01f, 6.15604371e-02f, -3.19776028e-01f, -2.72280276e-02f, 3.54928762e-01f, -1.58159211e-01f, 1.63395330e-01f, -3.47512752e-01f,
  -4.00436014e-01f, -4.22835559e-01f, -1.11281089e-01f, -2.45653272e-01f, -2.54153281e-01f, 2.82531232e-01f, -2.50387669e-01f, 1.76377550e-01f, -4.25650775e-01f, 2.81442612e-01f,
  3.41494530e-01f, 3.47952992e-01f, 2.46423423e-01f, 2.35811427e-01f, -4.78513420e-01f, 3.34954292e-01f, 4.26034391e-01f, -1.79935783e-01f, 4.90296446e-02f, -2.48519883e-01f,
  1.90810606e-01f, -4.33710329e-02f, -1.65955812e-01f, -6.66970685e-02f, -4.10823345e-01f, -3.89181942e-01f, 8.68093048e-04f, -1.24489181e-01f, -2.97073349e-02f, -4.66371894e-01f,
  4.35365200e-01f, -1.33057693e-02f, 4.92044836e-02f, 1.69948518e-01f, 3.57856005e-01f, -2.72119373e-01f, -3.37912589e-01f, 3.44915718e-01f, 2.02970251e-01f, 2.24733785e-01f,
  4.01920825e-01f, 2.14916751e-01f, 2.73454171e-02f, -2.14589417e-01f, 2.63424486e-01f, 1.57125015e-02f, 5.90921104e-01f, 9.36819613e-02f, -4.16708469e-01f, 3.13230991e-01f,
  -5.70425272e-01f, -1.66362405e-01f, -1.79567903e-01f, 3.11696101e-02f, -9.26393196e-02f, 4.50012892e-01f, -1.80105478e-01f, -7.32607916e-02f, 1.91890568e-01f, 1.67063534e-01f,
  -5.35011292e-01f, 1.47529691e-01f, 1.29049256e-01f, -4.74243432e-01f, -3.40657085e-01f, 6.24481402e-03f, -4.87939417e-02f, -2.41514102e-01f, -1.53348312e-01f, -5.42917430e-01f,
  1.60225019e-01f, -2.12504506e-01f, -3.19506079e-01f, -1.92530230e-01f, -2.21460208e-01f, 2.15156198e-01f, -1.41133377e-02f, 2.61925966e-01f, 3.46371643e-02f, 2.33872011e-01f,
  2.53505111e-02f, 4.07209247e-01f, 2.44030029e-01f, 6.75430372e-02f, 7.50350505e-02f, -1.36058345e-01f, 7.67709175e-03f, 1.18382134e-01f, 1.73751608e-01f, 1.47531942e-01f,
  1.94671363e-01f, -6.47809580e-02f, 7.49089122e-02f, 4.97012362e-02f, -9.70736966e-02f, 9.17269662e-02f, 2.57952183e-01f, 1.84875593e-01f, 1.20321073e-01f, -8.92657340e-02f,
  7.27049410e-02f, 5.17886914e-02f, -1.34204852e-03f, -1.03204660e-01f, 2.11390872e-02f, -4.77551594e-02f, 1.74722686e-01f, -2.51630377e-02f, 6.61129579e-02f, 1.86017692e-01f,
  1.25865906e-01f, -1.03877254e-01f, 1.66072339e-01f, 1.81160077e-01f, 3.05643052e-01f, -4.71003614e-02f, 3.45724195e-01f, 5.34544177e-02f, 2.68107019e-02f, -3.30860578e-02f,
  1.33056685e-01f, -1.58639789e-01f, -2.61435747e-01f, -9.81438383e-02f, 2.24244446e-01f, -2.05493286e-01f, 1.40464857e-01f, 1.09693624e-01f, 2.33777121e-01f, 8.42134580e-02f,
  -3.91785726e-02f, -1.10147551e-01f, -2.37063169e-01f, 3.16748470e-01f, -6.86072782e-02f, -3.29669863e-01f, 6.32629991e-02f, -2.44148284e-01f, -5.27670622e-01f, -2.25500554e-01f,
  -1.92024842e-01f, -4.87064630e-01f, -2.75655150e-01f, -3.22281212e-01f, 1.39319906e-02f, -1.98161110e-01f, 1.55070990e-01f, -5.11445962e-02f, -4.06911790e-01f, -3.00687581e-01f,
  -3.27275902e-01f, -3.86643806e-03f, 2.57910609e-01f, 3.42977673e-01f, 4.75733697e-01f, 1.26377821e-01f, 3.54309350e-01f, -2.74785787e-01f, -3.84047210e-01f, 6.12304211e-02f,
  -4.91540372e-01f, 6.34503067e-02f, -3.31110418e-01f, -2.88873494e-01f, -3.22605297e-02f, -6.58584014e-02f, -3.63231897e-01f, -1.83229133e-01f, 1.72109753e-01f, 4.13128167e-01f,
  -4.07976836e-01f, 3.91622990e-01f, -4.35753256e-01f, -2.06927016e-01f, 3.12185943e-01f, 4.15978163e-01f, -5.68425834e-01f, -1.93355039e-01f, 3.49463344e-01f, 1.77707285e-01f,
  9.33567658e-02f, 3.72221798e-01f, -1.68863997e-01f, -4.92779702e-01f, 3.12628672e-02f, 1.98088855e-01f, -2.38187328e-01f, -1.29163608e-01f, -1.59463093e-01f, 2.81100631e-01f,
  -5.29051840e-01f, 4.37652975e-01f, -3.67971122e-01f, -3.28219146e-01f, -4.23472226e-01f, -4.14524376e-01f, -1.44809008e-01f, -1.04056939e-01f, -4.58022505e-01f, -8.05053115e-02f,
  1.10909663e-01f, 4.47352119e-02f, 8.88914689e-02f, 7.85598755e-02f, 3.99826840e-02f, -1.45917282e-01f, -7.31853992e-02f, -2.82204729e-02f, 1.64361417e-01f, -1.51054069e-01f,
  -5.19994758e-02f, 1.82714492e-01f, -1.73141733e-01f, 9.67052355e-02f, 1.76414862e-01f, -1.07262321e-01f, -2.18829513e-01f, -1.37932837e-01f, 1.81480750e-01f, -1.19060993e-01f,
  -1.13579100e-02f, 1.76830627e-02f, 3.91096175e-02f, -4.36149836e-02f, 1.31509751e-02f, -1.15080178e-01f, 3.09884176e-02f, 1.53656099e-02f, 2.10356750e-02f, -9.63264108e-02f,
  2.12924890e-02f, -2.95781754e-02f, -1.03436485e-01f, 1.49148211e-01f, -1.73876747e-01f, 1.90513223e-01f, 2.61141080e-02f, -1.18849790e-02f, 1.65788114e-01f, 1.19243763e-01f,
  -1.14692196e-01f, 9.38029736e-02f, 1.86416090e-01f, -4.87494320e-02f, -7.57939667e-02f, 8.60747248e-02f, -2.62013763e-01f, -1.11922294e-01f, -8.54555070e-02f, 1.18341744e-01f,
  -3.22424501e-01f, 5.40105999e-01f, -1.96099594e-01f, 9.42024067e-02f, 3.50732863e-01f, 6.71939701e-02f, -4.54073623e-02f, 6.31431341e-02f, -2.43040860e-01f, -1.72449708e-01f,
  3.43106806e-01f, -2.40121752e-01f, -1.58158988e-01f, 8.18469003e-03f, 2.55321711e-01f, -2.63978690e-01f, 1.55688375e-01f, 1.93970919e-01f, 3.59491408e-01f, -1.64132208e-01f,
  3.37352276e-01f, -3.87882650e-01f, -2.10867286e-01f, 2.52958924e-01f, 2.08889917e-01f, 3.37620944e-01f, 4.12014186e-01f, 2.92488903e-01f, 2.03911401e-02f, -5.17231226e-01f,
  -1.99561834e-01f, 3.42709512e-01f, -4.06451762e-01f, -1.06453188e-01f, 2.02829793e-01f, 1.86490044e-01f, 3.70927937e-02f, 5.13452701e-02f, -1.39241621e-01f, 2.20211998e-01f,
  -2.20538363e-01f, 2.87176877e-01f, -1.33599922e-01f, -1.21645428e-01f, 3.78039032e-01f, 4.51070547e-01f, -1.78899109e-01f, 9.59510803e-02f, -5.10645099e-02f, 3.08425814e-01f,
  2.49603093e-01f, -4.06663924e-01f, -4.98097509e-01f, 1.66390836e-01f, -3.84683579e-01f, 7.16974363e-02f, 1.70721620e-01f, -1.87383518e-02f, -1.91029340e-01f, -1.43230349e-01f,
  -2.45801464e-01f, -3.33760083e-01f, -3.35347950e-01f, 5.38901925e-01f, -3.44928235e-01f, -4.82375801e-01f, -4.20553595e-01f, -5.70410013e-01f, 6.47195339e-01f, 4.72038507e-01f,
  -2.47102857e-01f, -2.33583823e-01f, 4.48285090e-03f, 5.35411894e-01f, 2.94977635e-01f, 3.62560332e-01f, -2.01625690e-01f, -6.56057708e-03f, -1.84529215e-01f, -9.24771875e-02f,
  -1.02637038e-01f, -8.84857699e-02f, -3.78331207e-02f, 2.08588261e-02f, 4.84328531e-02f, -1.56483367e-01f, -2.64696358e-03f, -1.03018068e-01f, 1.18654013e-01f, -1.33342013e-01f,
  -5.32495342e-02f, -9.20140818e-02f, -1.43660992e-01f, -2.39608623e-02f, -3.28456424e-02f, 5.37837110e-03f, 6.55751228e-02f, 1.03023939e-01f, -5.04477620e-02f, -1.06627613e-01f,
  -2.93169469e-02f, -4.33235504e-02f, 4.54577357e-02f, -5.93298338e-02f, -9.01389271e-02f, 5.06886579e-02f, -7.74965957e-02f, -1.11976855e-01f, 1.45214132e-03f, -7.96225369e-02f,
  1.00499570e-01f, -7.88054615e-03f, 1.43579707e-01f, 4.84013669e-02f, 4.39914130e-03f, -1.92284510e-01f, -1.92335606e-01f, -1.22921124e-01f, -2.13419452e-01f, -8.27142149e-02f,
  -8.44618753e-02f, 1.75676756e-02f, -2.16787025e-01f, -1.99302062e-02f, 8.80182013e-02f, -7.93613121e-03f, -2.56851971e-01f, -1.89343959e-01f, 8.58797580e-02f, 1.29880264e-01f,
  7.84349889e-02f, 7.20907887e-03f, -1.11445948e-01f, -2.00690050e-03f, 3.78067023e-04f, -8.43046680e-02f, 2.13867009e-01f, 2.12208793e-01f, -2.28339821e-01f, -6.00235052e-02f,
  -2.71955132e-01f, -2.38328457e-01f, 9.83067006e-02f, -3.92494462e-02f, -6.78044856e-02f, 4.35774997e-02f, 1.56685859e-01f, -5.70784882e-02f, 1.38136119e-01f, 7.63636604e-02f,
  -2.99939841e-01f, 2.02887550e-01f, -4.54316027e-02f, 2.06356987e-01f, -1.28559500e-01f, -8.80752355e-02f, 2.55456637e-03f, -1.00948237e-01f, 8.98037329e-02f, 1.03519082e-01f,
  -1.41360387e-02f, -5.28972857e-02f, -6.19159080e-02f, 1.62555799e-01f, 1.78429291e-01f, 2.32140377e-01f, -4.05214615e-02f, 1.96654230e-01f, 9.01073664e-02f, 1.09807454e-01f,
  -1.32279070e-02f, 1.60796538e-01f, -2.51533389e-01f, 1.74719572e-01f, -3.91376670e-03f, 9.11481865e-03f, 1.71311378e-01f, -1.36082292e-01f, 3.36599022e-01f, 1.63639411e-01f,
  -1.44357949e-01f, -3.03944409e-01f, -1.90032050e-01f, -1.63383380e-01f, 2.40087822e-01f, 4.26451303e-02f, 3.76915246e-01f, 2.02581915e-03f, 8.24201256e-02f, -2.61884630e-01f,
  3.94959420e-01f, 1.39164776e-01f, 5.74146211e-01f, 2.95593083e-01f, 2.83933759e-01f, 3.53661150e-01f, -1.53328821e-01f, -1.65421724e-01f, -3.32926482e-01f, -3.01650465e-01f,
  -2.49264330e-01f, 2.68924654e-01f, 3.90018642e-01f, -3.16894442e-01f, 9.86618400e-02f, 3.42430063e-02f, -1.95024498e-02f, -1.31546572e-01f, -2.35623389e-01f, -3.26542109e-01f,
  5.43697625e-02f, 8.80964324e-02f, -7.87741169e-02f, 1.75011873e-01f, 4.58279811e-02f, -3.63602862e-02f, 2.61367075e-02f, 4.28411551e-03f, 8.79386961e-02f, -3.40228945e-01f,
  -1.75220743e-01f, 2.34118607e-02f, 7.97477644e-03f, 1.42592624e-01f, 1.82276666e-01f, -3.70525606e-02f, 6.27439395e-02f, -4.38866839e-02f, 8.19870755e-02f, -4.10289615e-02f,
  -8.71346071e-02f, -1.65787891e-01f, 2.71715466e-02f, -2.66595054e-02f, -1.89695239e-01f, -6.90051615e-02f, -4.87188175e-02f, -7.87802190e-02f, -1.27582237e-01f, -1.78579018e-01f,
  -6.60440624e-02f, -8.78387839e-02f, 1.21371135e-01f, -1.00049816e-01f, -2.58217771e-02f, -1.12452701e-01f, -2.87483074e-02f, -1.30493909e-01f, 6.78227246e-02f, 9.25343037e-02f,
  3.95653658e-02f, -8.99995491e-02f, 1.42039388e-01f, -1.20303426e-02f, 1.48263067e-01f, 1.32393986e-01f, 3.76517363e-02f, -2.65242606e-01f, -1.71339005e-01f, 2.32656658e-01f,
  -1.55974403e-01f, 1.80255219e-01f, 7.80870467e-02f, -2.72883236e-01f, 1.52373478e-01f, 1.31656080e-01f, 5.68344519e-02f, 2.87843645e-01f, -5.62689938e-02f, 2.66607434e-01f,
  7.91839883e-02f, -1.21653661e-01f, -2.73749292e-01f, -3.16066965e-02f, -9.00409520e-02f, 7.20920116e-02f, -3.60138416e-01f, -1.49560601e-01f, -2.56718218e-01f, -8.85971710e-02f,
  3.54905397e-01f, 3.43923092e-01f, 2.27451548e-01f, -2.09997311e-01f, 9.62510705e-02f, 2.47163385e-01f, 2.21812576e-01f, -2.86103517e-01f, -2.22714886e-01f, 3.01100999e-01f,
  -2.98791200e-01f, 2.00736880e-01f, -2.12222844e-01f, 3.25054564e-02f, 1.95455909e-01f, -1.12297297e-01f, -2.48215869e-01f, 1.40753955e-01f, 1.64909676e-01f, 1.65947765e-01f,
  -1.87804386e-01f, 1.01729870e-01f, -2.44931310e-01f, -2.03301758e-01f, 1.75898403e-01f, 3.42912078e-02f, -1.65238991e-01f, -2.67092496e-01f, -8.14691931e-02f, -2.99376875e-01f,
  -3.14268708e-01f, 3.71849597e-01f, 6.93638772e-02f, 6.19698822e-01f, -2.32299596e-01f, -2.85392791e-01f, -6.58314675e-02f, -2.16081396e-01f, -4.66835611e-02f, -1.58672333e-01f,
  -4.79115844e-02f, -1.44653782e-01f, -1.04813851e-01f, -1.90903232e-01f, 2.09171414e-01f, 7.53429085e-02f, 6.30661488e-01f, -3.07969451e-01f, 4.69806381e-02f, -7.33204633e-02f,
  1.82299674e-01f, -4.57713008e-01f, 1.28620252e-01f, 4.88734543e-02f, -1.16849840e-02f, 1.84921384e-01f, 5.97893596e-02f, 3.89026701e-02f, -1.92995816e-01f, -1.21810250e-02f,
  5.09903468e-02f, 1.80750221e-01f, -3.73594277e-02f, 2.17452403e-02f, -2.38736600e-01f, -1.20076630e-02f, 1.85692415e-01f, 1.73438519e-01f, -7.61583894e-02f, 1.48182005e-01f,
  -3.02690808e-02f, 1.08824447e-01f, 8.71947333e-02f, 1.45091936e-01f, 1.75847843e-01f, 3.75306495e-02f, 1.47164362e-02f, 1.39045715e-03f, 1.34759814e-01f, 1.37898266e-01f,
  6.85985312e-02f, 6.20611794e-02f, -1.48629591e-01f, 9.58284065e-02f, 1.34393170e-01f, 8.83230940e-02f, -7.47183338e-02f, 5.38135022e-02f, -2.29065344e-02f, 7.65475631e-02f,
  -1.45930462e-02f, 1.21981114e-01f, -2.96633512e-01f, 5.26683293e-02f, 4.62303422e-02f, -1.32565051e-01f, -8.78259074e-03f, 9.31078196e-02f, -6.19997941e-02f, 4.54200990e-02f,
  -6.11191289e-03f, -2.20795795e-01f, 7.61754215e-02f, 1.95947647e-01f, 1.47729099e-01f, -1.34691954e-01f, 8.90320074e-03f, 2.45445445e-01f, 4.12850231e-02f, -2.29771733e-01f,
  3.81981492e-01f, 3.95200014e-01f, 2.67681301e-01f, 4.78018939e-01f, 1.86109617e-01f, -2.71923751e-01f, -6.18784130e-02f, 2.85072438e-02f, -9.33000818e-03f, 4.77148324e-01f,
  -1.22110010e-03f, 2.22635403e-01f, -1.19045243e-01f, 2.03895047e-01f, -2.57222265e-01f, 4.10643630e-02f, 1.77502781e-01f, -3.13887149e-01f, -8.60309377e-02f, 1.30886823e-01f,
  2.66966391e-02f, 2.68701047e-01f, 1.98517188e-01f, 1.61180310e-02f, -1.84580207e-01f, -1.88957572e-01f, 2.50422716e-01f, 3.35114807e-01f, -2.76383966e-01f, 1.99480265e-01f,
  -3.03386599e-01f, 4.37922955e-01f, -6.09264299e-02f, 2.71395743e-01f, 3.37855011e-01f, 3.22341591e-01f, -3.53557467e-01f, -3.37194532e-01f, -3.33627731e-01f, 1.57448605e-01f,
  2.18580917e-01f, 1.30048618e-01f, -2.46608213e-01f, -3.16625774e-01f, -5.10232925e-01f, -6.51507676e-02f, -1.47076026e-01f, -4.26355630e-01f, -3.35946649e-01f, -5.69944859e-01f,
  -2.64778733e-01f, -4.54069853e-01f, -2.88073421e-01f, -3.05751801e-01f, -3.33391666e-01f, -9.90371555e-02f, 2.31936187e-01f, 3.07080775e-01f, 1.11837804e-01f, 6.90216959e-01f,
  -2.16656938e-01f, 4.15478945e-01f, -3.47178519e-01f, -5.88826597e-01f, -3.47832553e-02f, 5.11836767e-01f, -2.77454525e-01f, 3.87164474e-01f, -4.39306021e-01f, 2.62240976e-01f,
  2.01035336e-01f, 7.02929944e-02f, 1.03843294e-01f, 1.47677381e-02f, 2.33917743e-01f, 1.91716641e-01f, -5.19720688e-02f, 1.19381502e-01f, 1.85167030e-01f, 1.26766235e-01f,
  -1.36721566e-01f, 1.51405483e-01f, -1.45204946e-01f, -7.48784393e-02f, 1.87388808e-02f, 2.87111491e-01f, 5.83494529e-02f, -6.76645860e-02f, 1.43637270e-01f, 2.14549035e-01f,
  8.43742415e-02f, 9.07763615e-02f, 1.58767104e-01f, 7.58407861e-02f, -2.16331437e-01f, -9.61085632e-02f, 2.47475475e-01f, 2.21308380e-01f, 8.31183493e-02f, 5.78970350e-02f,
  1.85456183e-02f, 5.55461645e-02f, 8.74181911e-02f, 8.48255903e-02f, -9.43312980e-03f, 3.79517414e-02f, -2.42719427e-02f, 3.68295275e-02f, -2.47082934e-02f, 4.88245711e-02f,
  5.11901593e-03f, -5.51368073e-02f, 5.61478324e-02f, -1.60916567e-01f, 6.71581551e-02f, 1.07372869e-02f, 8.28048214e-02f, -6.41205758e-02f, -6.50861040e-02f, 1.66589115e-02f,
  1.20666951e-01f, -4.78439145e-02f, 2.53330976e-01f, -2.25046530e-01f, -3.10561776e-01f, -3.08696568e-01f, -5.73755577e-02f, 2.28682831e-01f, -4.26307172e-01f, 1.68276131e-01f,
  3.41555536e-01f, 4.19254303e-01f, -1.03429660e-01f, 2.85034120e-01f, 3.06193739e-01f, 4.03138958e-02f, -9.51030478e-02f, 1.89787582e-01f, 2.76412606e-01f, -2.00800240e-01f,
  -1.25317171e-01f, 1.81854397e-01f, 3.31045926e-01f, 1.84310079e-01f, -3.49224240e-01f, 3.26922089e-01f, -3.80626649e-01f, 1.75097197e-01f, -2.22675785e-01f, 2.76022077e-01f,
  2.83070683e-01f, 2.32424557e-01f, -3.44335079e-01f, 7.77407438e-02f, 1.95233360e-01f, -2.75990725e-01f, 3.31917226e-01f, -5.00205755e-01f, 3.67258608e-01f, 4.42541063e-01f,
  2.18427166e-01f, -2.66751230e-01f, 3.11181724e-01f, -4.64497775e-01f, 2.26342410e-01f, 1.16735712e-01f, 1.95001230e-01f, -2.55809538e-02f, -3.05942684e-01f, -2.23708525e-01f,
  3.03933710e-01f, 2.73995131e-01f, 2.70819124e-02f, -2.13495493e-01f, -2.05824599e-01f, -3.32601637e-01f, 3.76699746e-01f, -4.55145150e-01f, -2.81722039e-01f, -2.74690777e-01f,
  -3.19994509e-01f, -2.90491488e-02f, -1.91734880e-01f, -4.81349498e-01f, 6.46385998e-02f, -1.81142569e-01f, -1.07582912e-01f, -2.27630720e-01f, 1.75873771e-01f, 3.55681390e-01f,
  -3.82524729e-01f, 1.02459580e-01f, -3.57072167e-02f, 4.73773070e-02f, 6.02869451e-01f, -3.19119275e-01f, 2.10328519e-01f, -4.79309320e-01f, 1.29886240e-01f, 6.30397275e-02f,
  5.71179874e-02f, 6.06805794e-02f, 6.02538586e-02f, -3.27399932e-02f, 5.30809015e-02f, 1.69720754e-01f, -7.16381818e-02f, 1.37520745e-01f, 1.83261819e-02f, -1.21678337e-01f,
  4.20776606e-02f, 4.94453497e-02f, -9.31801349e-02f, 8.57164562e-02f, -2.44072210e-02f, -1.27842918e-01f, 9.08499882e-02f, -1.85222309e-02f, -1.15637071e-01f, 1.08016089e-01f,
  -2.42670402e-01f, 8.81680250e-02f, 6.62100017e-02f, 9.40313265e-02f, 1.51820956e-02f, 3.55208702e-02f, -1.00389071e-01f, -1.95535541e-01f, -4.87975702e-02f, 1.40211985e-01f,
  5.16233295e-02f, -1.14815906e-01f, 5.78617258e-03f, 1.33867025e-01f, 2.17843335e-02f, -4.30677226e-03f, -1.35701060e-01f, 5.16323075e-02f, -5.98456562e-02f, -7.83528537e-02f,
  5.39258122e-02f, 3.74597870e-02f, -2.07372293e-01f, 1.12284400e-01f, 1.33754881e-02f, 6.30635768e-02f, 1.44331604e-01f, 1.02123678e-01f, 8.05462003e-02f, -2.31507808e-01f,
  9.35454890e-02f, 1.14174232e-01f, -2.03127950e-01f, -2.75921077e-01f, 2.47549579e-01f, -2.06822321e-01f, -1.02008894e-01f, 2.71375448e-01f, 4.71314676e-02f, -2.55856007e-01f,
  -3.03430676e-01f, 1.21304333e-01f, 2.04758018e-01f, 2.40277246e-01f, 1.83660477e-01f, 1.08099245e-01f, -2.84327090e-01f, -2.82558706e-02f, 3.06587964e-01f, 1.67566463e-01f,
  5.78212403e-02f, -1.85582295e-01f, 1.28513679e-01f, -3.31953257e-01f, 2.15829164e-01f, 2.01824009e-01f, -2.00835928e-01f, 2.91695416e-01f, -3.57853502e-01f, 3.21532786e-01f,
  -7.18443170e-02f, -3.51791456e-02f, -3.21395129e-01f, -2.46644959e-01f, -2.19509937e-02f, -1.59393206e-01f, 2.39865869e-01f, -3.69280577e-01f, -1.65099338e-01f, -2.26424202e-01f,
  -2.62439966e-01f, 2.45287895e-01f, 3.14838827e-01f, 2.93787837e-01f, 2.72888094e-01f, -1.82918772e-01f, -1.14178695e-01f, 4.24394645e-02f, -2.92102695e-01f, -3.00817281e-01f,
  -1.12649731e-01f, 7.27669895e-01f, -3.18216950e-01f, 3.92307281e-01f, -1.31075263e-01f, -3.67405266e-01f, -7.98751861e-02f, 4.26962793e-01f, -3.29537064e-01f, -2.90028930e-01f,
  -3.10072988e-01f, -9.86198485e-02f, -1.34327665e-01f, -1.71053231e-01f, -2.37516835e-02f, -2.29576409e-01f, 5.45070946e-01f, -2.33536899e-01f, 3.94138455e-01f, -1.32100523e-01f,
  -1.75727829e-01f, -2.20878974e-01f, -2.96399176e-01f, -2.20752150e-01f, -4.29839343e-01f, 3.26381445e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  1.26979519e-02f, -2.03861762e-03f, -7.35146701e-02f, 1.15238205e-02f, 1.22303672e-01f, 4.36198451e-02f, -4.08175476e-02f, -7.94605389e-02f, 8.06695595e-02f, -3.09999343e-02f,
  5.93585987e-03f, 4.15409766e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 51, 26
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        128, 12
    );
    }
    