/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 4 x 120)
const int L0_fan_Wp_rows = 4;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  2.79615730e-01f, 4.45885360e-02f, 3.76299955e-02f, 3.03444922e-01f, 2.30762109e-01f, 1.68833658e-01f, 2.04927936e-01f, -3.47068831e-02f, 1.17656648e-01f, 4.10877988e-02f,
  1.89179704e-01f, 4.73900586e-02f, -1.07181281e-01f, -1.72402203e-01f, -2.47126356e-01f, -2.62596339e-01f, -2.49248266e-01f, -2.92725831e-01f, -1.63354605e-01f, 8.63664746e-02f,
  -2.97683515e-02f, 9.31475833e-02f, -1.24785811e-01f, -1.05257191e-01f, -5.97087406e-02f, -1.03171661e-01f, -3.68893594e-02f, 4.66063954e-02f, -1.29735038e-01f, -4.57570225e-01f,
  3.41228954e-02f, 1.13344252e-01f, 6.60674646e-02f, 4.57040500e-03f, 1.01303540e-01f, 1.64264888e-02f, 6.04897998e-02f, 3.56612131e-02f, 8.40314701e-02f, 2.69101057e-02f,
  9.69608203e-02f, 2.97698099e-02f, 6.91158697e-02f, -8.37019552e-03f, 1.11201741e-01f, 6.52058423e-02f, 2.70535015e-02f, -1.95385888e-02f, 2.23911572e-02f, 3.07770334e-02f,
  1.00057319e-01f, 1.17793061e-01f, 1.39355659e-01f, 2.39333138e-03f, 8.19758326e-02f, -1.12442831e-02f, 5.60846850e-02f, -2.74270773e-02f, 2.79009789e-02f, -5.61357737e-02f,
  -1.89629178e-02f, -3.81574780e-02f, 1.01983557e-02f, 7.95302615e-02f, -3.63699421e-02f, 9.00523886e-02f, -7.34249800e-02f, -5.55695631e-02f, -5.85548468e-02f, 5.86848259e-02f,
  -7.69693479e-02f, 7.65460171e-03f, -2.61688512e-02f, -1.72922146e-02f, -8.73932019e-02f, -4.11860012e-02f, -4.40677032e-02f, -9.44585577e-02f, -8.45574364e-02f, -1.37465328e-01f,
  -3.29471268e-02f, 4.90335040e-02f, -2.75449883e-02f, -5.23757450e-02f, -6.37622401e-02f, -5.28523736e-02f, -2.51693390e-02f, -3.87869589e-02f, -2.39839200e-02f, 7.58872321e-03f,
  3.27434152e-01f, 9.70738307e-02f, 2.48358119e-02f, 1.24444021e-02f, -5.61977411e-03f, -1.06236618e-02f, -9.78773739e-03f, -4.03606705e-02f, 1.13210149e-01f, 5.14609776e-02f,
  1.37545586e-01f, 1.31000087e-01f, 5.96495457e-02f, 5.13866171e-02f, -7.24254269e-03f, 1.22324675e-01f, 8.46755505e-02f, 1.37856096e-01f, 1.49030369e-02f, 1.26773134e-01f,
  7.32262880e-02f, 4.95793223e-02f, 9.41542238e-02f, 8.28504413e-02f, 1.12425826e-01f, 1.74975902e-01f, 7.96420276e-02f, 1.53226629e-01f, 1.99856400e-01f, 1.98177025e-01f,
  -1.95687532e-01f, -6.40212178e-01f, 4.52218624e-03f, -1.14057787e-01f, 1.05048440e-01f, 9.35252309e-02f, -3.41610044e-01f, 4.19803243e-03f, 7.80824646e-02f, -2.82313824e-01f,
  -9.79192648e-03f, 1.08489893e-01f, 4.96183261e-02f, 9.23796222e-02f, 7.08289817e-02f, -1.50783271e-01f, -2.11315587e-01f, 1.57118998e-02f, 4.55706418e-01f, 3.34829956e-01f,
  -7.61834830e-02f, -1.26112118e-01f, 1.28576726e-01f, 5.18351384e-02f, -3.25253427e-01f, 7.10845739e-02f, -2.20185116e-01f, -1.95013389e-01f, -1.33398101e-01f, -7.21400678e-01f,
  -1.30698934e-01f, -2.84199238e-01f, 3.20268750e-01f, 6.02705106e-02f, -1.00967795e-01f, 2.49304194e-02f, 5.41359894e-02f, -6.13157451e-02f, -5.61798038e-03f, 3.89051549e-02f,
  -2.26188526e-02f, -1.83732603e-02f, -8.16581026e-02f, -4.76540672e-03f, -4.02041189e-02f, 4.86158356e-02f, -3.19339670e-02f, -4.07288633e-02f, -1.06396256e-02f, -6.86651692e-02f,
  -1.06766433e-01f, -1.23392485e-01f, -8.46530795e-02f, 8.33469853e-02f, 3.98198105e-02f, 6.68990314e-02f, -8.84267911e-02f, -8.43339413e-02f, 7.43475258e-02f, -3.94206047e-01f,
  2.86692828e-02f, -6.87624291e-02f, -3.70553918e-02f, 1.58543733e-03f, -4.66687605e-02f, 5.51990904e-02f, 1.55538963e-02f, 1.91066228e-03f, 4.02145088e-03f, 1.70024280e-02f,
  2.47978256e-03f, 8.63197371e-02f, 4.37494628e-02f, 6.03386723e-02f, -4.31624539e-02f, -8.09548646e-02f, -2.23265379e-03f, -3.38569097e-02f, 9.62299183e-02f, -4.29005269e-03f,
  2.61071306e-02f, -2.35258155e-02f, 1.63357034e-02f, -8.90096929e-03f, 4.95041907e-02f, -1.19659659e-02f, 3.30368541e-02f, 6.52327165e-02f, 4.01804298e-02f, -5.00576906e-02f,
  2.09543873e-02f, 2.76063532e-01f, -2.14952510e-02f, 5.55028059e-02f, -9.21099447e-03f, -3.42596602e-03f, -2.68406197e-02f, 6.18395284e-02f, 1.44975260e-02f, -1.64665207e-02f,
  4.40173931e-02f, 8.68810154e-03f, -4.50244583e-02f, 1.44673500e-03f, 9.28898752e-02f, -1.27512426e-03f, -1.98398549e-02f, -2.68225409e-02f, 9.73329246e-02f, -5.67825325e-02f,
  1.00858547e-02f, 3.71070988e-02f, 1.17019445e-01f, -8.01750459e-03f, 4.30537164e-02f, 2.10310891e-01f, 4.22480851e-02f, 1.45757660e-01f, 1.22659519e-01f, -1.07497007e-01f,
  -2.45346725e-01f, 1.65539995e-01f, 6.34117007e-01f, -2.40043774e-01f, 1.12681009e-01f, 1.79335058e-01f, 5.08470476e-01f, 1.85783714e-01f, -1.26133949e-01f, 5.72091714e-02f,
  -1.78962708e-01f, -4.03972089e-01f, -9.06476825e-02f, -7.44959339e-02f, 1.61692798e-02f, 3.23984385e-01f, 3.32162678e-01f, 2.99110949e-01f, -1.07646242e-01f, -4.62758422e-01f,
  -2.84290135e-01f, -1.04468465e-01f, -1.78556010e-01f, 1.16295524e-01f, -1.31026745e-01f, -9.98226330e-02f, 2.16227695e-01f, 3.51941325e-02f, 9.29675251e-02f, 9.92694274e-02f,
  -4.47603539e-02f, 1.69682633e-02f, 2.86301062e-03f, -1.26066178e-01f, -2.84805521e-02f, -3.35111767e-02f, -7.37794861e-02f, 3.00950073e-02f, 3.61364312e-03f, 4.56611402e-02f,
  -8.17947239e-02f, -7.97045231e-02f, -4.56221867e-03f, 1.02648744e-02f, 2.70673390e-02f, -8.21471913e-04f, -1.93303265e-02f, 1.64517358e-01f, 6.45857081e-02f, 3.06374766e-02f,
  -9.44471881e-02f, 7.45116547e-02f, 7.08542913e-02f, 8.73578191e-02f, 1.76593319e-01f, 7.25878626e-02f, 9.11320373e-03f, -8.83079041e-03f, 6.45781532e-02f, -4.98665273e-02f,
  -9.24399570e-02f, -1.62936561e-02f, 2.20399946e-02f, 2.88804993e-03f, -4.50769998e-02f, 1.13296118e-02f, -3.43724415e-02f, -5.60295582e-02f, -7.17321634e-02f, 2.34505162e-02f,
  3.91878523e-02f, 2.76622537e-04f, 7.72993341e-02f, 5.10290526e-02f, -5.15642203e-02f, 7.80697241e-02f, 3.58470827e-02f, -6.12452850e-02f, -8.10937658e-02f, -3.62680368e-02f,
  -2.57603340e-02f, 1.37649983e-01f, 2.74265860e-03f, 2.83826631e-03f, 2.89446395e-02f, 1.03630506e-01f, -7.71785304e-02f, -5.94447404e-02f, -1.37258857e-01f, 2.80911662e-02f,
  -1.74988568e-01f, 1.33342162e-01f, -8.39545950e-02f, 6.75131846e-03f, 4.67916504e-02f, -3.25566493e-02f, -1.85922086e-02f, -4.90560569e-02f, -1.60383731e-02f, 4.61690016e-02f,
  1.11861387e-02f, 4.99623567e-02f, 1.22298211e-01f, 7.41652995e-02f, -6.92786202e-02f, 1.56863015e-02f, -6.75016791e-02f, 3.23088951e-02f, -2.43000127e-02f, 1.33820102e-02f,
  7.46898055e-02f, -3.30265015e-02f, -8.57931226e-02f, 2.55951681e-03f, -3.66549008e-02f, -1.37726605e-01f, 5.16749024e-02f, -4.84154634e-02f, 7.01475441e-02f, -6.74026683e-02f,
  7.40416229e-01f, 3.81525643e-02f, 2.48626381e-01f, 8.92274007e-02f, -2.54996240e-01f, -2.17111185e-01f, -2.42648095e-01f, -2.11929202e-01f, -6.50871964e-03f, 1.49915680e-01f,
  1.96626298e-02f, -1.49238840e-01f, 1.16199240e-01f, -9.63186622e-02f, 1.49966683e-03f, -2.64597181e-02f, 1.29734529e-02f, 2.37409398e-01f, -1.43025354e-01f, -2.90383279e-01f,
  -1.88200235e-01f, 3.31621729e-02f, 3.71975660e-01f, 1.53173925e-02f, 3.11564095e-02f, -1.77120462e-01f, 1.62291944e-01f, 6.40090033e-02f, 3.36251245e-03f, 3.27028245e-01f,
  2.66526073e-01f, 2.06488103e-01f, -1.63064003e-01f, 3.06155216e-02f, 5.65393418e-02f, 1.05867386e-01f, 1.12843357e-01f, 1.38671800e-01f, -1.06328847e-02f, 5.43207005e-02f,
  8.69206414e-02f, 5.55089256e-03f, 1.99347865e-02f, 2.78922599e-02f, -1.70129109e-02f, 1.02710672e-01f, 1.18678100e-01f, 1.01279117e-01f, 1.04359090e-01f, 1.59861799e-02f,
  -9.76905972e-02f, 1.28047904e-02f, 7.42431507e-02f, -1.20858446e-01f, -9.63237956e-02f, 6.40027076e-02f, -6.65259510e-02f, -7.03508109e-02f, 1.07633784e-01f, 1.29338637e-01f,
  -1.00979738e-01f, -1.89430472e-02f, 2.87217796e-02f, -1.03536416e-02f, 7.80282635e-03f, 2.85356473e-02f, -4.50209118e-02f, -1.32423071e-02f, -5.17996252e-02f, 1.46687534e-02f,
  -2.72378381e-02f, 7.97219649e-02f, -2.90569309e-02f, 5.87301776e-02f, -5.20948358e-02f, 9.70458239e-03f, 2.32670158e-02f, -3.60666178e-02f, -1.31117944e-02f, -9.46431980e-03f,
  9.30501428e-03f, 6.45811344e-03f, 3.53426263e-02f, 1.91298854e-02f, -4.96263020e-02f, 7.03994781e-02f, 1.91920660e-02f, 2.34369319e-02f, 4.63950215e-03f, 5.37354648e-02f,
  -1.37939528e-01f, -9.11687762e-02f, 1.28849104e-01f, -2.64448952e-02f, 1.90978255e-02f, 6.36588084e-03f, 2.80465968e-02f, -5.69891650e-03f, 4.68554907e-02f, -6.39871582e-02f,
  -7.35098049e-02f, 8.99111703e-02f, 6.79445192e-02f, -6.92640431e-03f, 4.12658229e-03f, -4.67144735e-02f, -4.53598658e-03f, 1.08461522e-01f, -7.43320361e-02f, 3.95785179e-03f,
  -4.50163446e-02f, -5.72083890e-02f, -5.96652143e-02f, 6.69511482e-02f, -5.90844229e-02f, -1.04059458e-01f, 1.65540318e-03f, 3.07766162e-02f, 6.10411949e-02f, 1.03959315e-01f
};

// L0_fan_Wp_bar (Shape: 8 x 120)
const int L0_fan_Wp_bar_rows = 8;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -1.06033158e+00f, -4.27616537e-02f, -5.27572334e-01f, -5.55511177e-01f, -5.86498737e-01f, -4.62712854e-01f, -2.07558244e-01f, 1.74470156e-01f, -1.67491809e-01f, -3.12211156e-01f,
  8.49868134e-02f, 7.51212016e-02f, -3.11734200e-01f, -1.40953615e-01f, -2.86345154e-01f, -5.90313017e-01f, -8.12829137e-01f, -6.76186144e-01f, -1.83827013e-01f, 3.08433801e-01f,
  -3.42104584e-02f, -5.00151098e-01f, -3.32537860e-01f, -1.28218591e-01f, -3.36528867e-02f, 1.27199560e-01f, -3.20119590e-01f, -1.57272205e-01f, -5.12776934e-02f, -3.67278606e-01f,
  3.59219871e-02f, -1.36975557e-01f, 3.83921503e-03f, -2.74874479e-01f, -3.39837037e-02f, -3.14194337e-03f, 3.71529534e-03f, -4.57351469e-02f, -9.15454626e-02f, -2.54443567e-02f,
  -1.15423568e-01f, 8.71036723e-02f, -1.46436602e-01f, -2.29396839e-02f, -2.81830162e-01f, -1.67578124e-02f, -8.03202391e-02f, -1.27574354e-01f, 1.87178329e-02f, 1.74937114e-01f,
  8.79922509e-02f, -1.15082793e-01f, -1.12564594e-01f, 1.32004097e-01f, 1.36861518e-01f, -1.42495707e-01f, 3.57300013e-01f, 3.15124810e-01f, 9.73907039e-02f, 3.70014012e-01f,
  3.00231408e-02f, 9.03152004e-02f, 3.23075578e-02f, 1.65282473e-01f, -1.60152018e-02f, -1.33498877e-01f, -1.07947290e-01f, -8.94386545e-02f, -2.22158544e-02f, 5.68946125e-04f,
  1.03171531e-03f, 2.41776388e-02f, 6.52017817e-02f, -9.03906673e-02f, -7.96405599e-02f, -1.22680791e-01f, -4.14897166e-02f, 1.57769471e-01f, -4.16410267e-02f, -7.71153793e-02f,
  -1.15502499e-01f, 7.37788379e-02f, -9.35784131e-02f, 1.77300751e-01f, -1.36896208e-01f, -8.79934505e-02f, -1.23368509e-01f, 1.73696414e-01f, 9.04277060e-03f, -6.74313307e-02f,
  1.12080298e-01f, -2.21149951e-01f, -3.32038365e-02f, 9.97641385e-02f, -8.80778655e-02f, 2.12596226e-02f, 8.52888450e-02f, 3.70418355e-02f, -2.54697919e-01f, -5.75257652e-02f,
  -1.20315604e-01f, 5.92733622e-02f, -1.08069770e-01f, 1.16103590e-01f, -1.07035235e-01f, 6.26178607e-02f, 1.60401575e-02f, -3.96284387e-02f, 1.02035031e-02f, 2.07972169e-01f,
  6.24323674e-02f, -3.64940614e-02f, 4.93133664e-02f, 1.24437638e-01f, 8.58274326e-02f, -9.29631889e-02f, 1.63206339e-01f, 3.46128404e-01f, 1.68902293e-01f, 4.01470661e-01f,
  -1.98168218e-01f, -4.42095965e-01f, 2.49524772e-01f, 4.60372090e-01f, 3.47916186e-01f, 2.30068788e-01f, 4.43366170e-02f, 7.79286176e-02f, 2.56968141e-01f, 3.67928520e-02f,
  -3.51056695e-01f, -1.85221016e-01f, -1.19332947e-01f, -3.66168655e-02f, -2.24065274e-01f, 2.32156366e-01f, 6.03016436e-01f, 2.23854810e-01f, 8.52832645e-02f, 2.89960325e-01f,
  4.13678288e-01f, 2.13119984e-01f, 4.87314574e-02f, 7.87802190e-02f, 1.15020415e-02f, 1.31736502e-01f, 6.31869957e-02f, 9.82244983e-02f, -5.92684327e-03f, 2.60257035e-01f,
  -1.46987140e-01f, -8.26858059e-02f, 1.79431722e-01f, 4.74315137e-02f, -9.81740654e-02f, -1.51446819e-01f, -5.17636612e-02f, 7.09315529e-03f, -4.71153744e-02f, 9.53520909e-02f,
  -5.22430278e-02f, -4.71557528e-02f, -2.42865141e-02f, -1.24193951e-02f, 9.88827422e-02f, -8.67201090e-02f, -1.41827330e-01f, 6.26713187e-02f, 1.70335695e-02f, -9.23468694e-02f,
  -3.32654873e-03f, 1.11531816e-01f, 3.83391827e-02f, -6.98130280e-02f, -2.73182336e-02f, -6.59714565e-02f, -1.33152202e-01f, -7.30655119e-02f, 7.40457932e-03f, 2.55713224e-01f,
  -1.97029442e-01f, 2.13614777e-02f, 4.71125916e-02f, 4.55646068e-02f, -1.40594304e-01f, 1.99741259e-01f, 1.92617193e-01f, -1.07105561e-01f, 5.19367233e-02f, 3.86995152e-02f,
  5.38319238e-02f, 4.14018854e-02f, -4.69137654e-02f, 9.91548672e-02f, -4.76808473e-02f, -2.61552748e-03f, -1.11365253e-02f, -6.84410855e-02f, -2.24280447e-01f, -1.68723479e-01f,
  -1.44796535e-01f, -9.49201435e-02f, -4.84411009e-02f, -1.74501300e-01f, -1.10683233e-01f, -4.49601226e-02f, -1.47252724e-01f, -2.08380684e-01f, -1.11824073e-01f, -8.12074170e-02f,
  2.64949024e-01f, -1.58507213e-01f, 1.66151613e-01f, -1.55355513e-01f, -1.21447425e-02f, -3.05918902e-01f, -9.28302258e-02f, -3.18576843e-02f, -9.48384926e-02f, 4.24032956e-02f,
  -4.97350879e-02f, -1.69479862e-01f, -9.83744338e-02f, -2.05738060e-02f, -8.89201164e-02f, -2.59897131e-02f, -1.39985666e-01f, -1.68673266e-02f, 5.06476611e-02f, -1.08602038e-02f,
  -1.24368191e-01f, 1.61859825e-01f, -8.44556279e-03f, -6.21294715e-02f, 9.25652981e-02f, 8.02218914e-02f, 1.61893982e-02f, 7.92441815e-02f, 1.11590877e-01f, 2.61748075e-01f,
  -5.52224398e-01f, -7.46942401e-01f, 5.70360661e-01f, -5.54133356e-01f, 2.29501911e-02f, -1.37070045e-01f, -9.85061452e-02f, -5.38915873e-01f, -5.98712981e-01f, -7.92429957e-04f,
  -1.87329859e-01f, -2.24892452e-01f, 7.27059767e-02f, -5.20849973e-02f, -1.92031294e-01f, 3.39678288e-01f, 3.79684865e-01f, 3.84237260e-01f, 4.22429055e-01f, -3.80283237e-01f,
  -4.84802961e-01f, 3.74252610e-02f, -2.04793155e-01f, -5.19001798e-04f, -4.36409116e-01f, 7.19183758e-02f, 3.46196324e-01f, -1.63979933e-01f, -5.70083372e-02f, -2.77487546e-01f,
  3.65761578e-01f, -4.22669411e-01f, 6.83995187e-02f, -1.50419071e-01f, 5.27576618e-02f, -7.69623369e-02f, 2.76613720e-02f, 2.62238011e-02f, -5.01486696e-02f, 1.59124611e-03f,
  -1.68050349e-01f, -9.19143781e-02f, -8.60676989e-02f, -5.61872199e-02f, -1.14029711e-02f, -1.45403177e-01f, -1.36163905e-01f, -1.00989416e-01f, -2.95218471e-02f, -3.66879180e-02f,
  -1.11909956e-01f, -2.06506491e-01f, 5.78780249e-02f, 3.09114009e-02f, -4.00207192e-02f, 1.79831171e-03f, -2.84441262e-02f, -1.96561798e-01f, -4.37287018e-02f, -5.37560880e-02f,
  1.22681178e-01f, 6.25320850e-03f, -9.58938971e-02f, 3.98933254e-02f, -5.29412273e-03f, 1.38458863e-01f, -2.08914503e-02f, -1.60135459e-02f, -9.56122875e-02f, 3.07650268e-02f,
  3.69026288e-02f, 8.05442221e-03f, -1.13999337e-01f, -1.53914643e-02f, -4.21789885e-02f, -1.06179453e-01f, -6.68509747e-05f, 3.49686965e-02f, 1.96492001e-02f, -8.39638487e-02f,
  -6.45916462e-02f, -5.31217642e-02f, 2.02697758e-02f, -2.31626946e-02f, -1.11155055e-01f, -1.58600248e-02f, -5.33066392e-02f, -2.26320717e-02f, -1.27783697e-03f, -8.93911347e-02f,
  2.06111297e-01f, 6.77340701e-02f, 7.37503245e-02f, -9.49670225e-02f, -3.89360934e-02f, -6.78418204e-02f, -1.63575988e-02f, 2.35379338e-02f, 5.75851873e-02f, -9.83477831e-02f,
  -1.44225299e-01f, 2.64530610e-02f, 6.99894875e-02f, -7.50681236e-02f, 7.33602643e-02f, 2.37569269e-02f, -3.75702567e-02f, 2.60060970e-02f, -9.92869772e-03f, -3.45817991e-02f,
  -4.44999477e-03f, 1.14845514e-01f, 2.53122985e-01f, 1.90658018e-01f, 2.18495149e-02f, 2.40436077e-01f, 2.98405081e-01f, 3.39936316e-02f, 2.45354995e-01f, 3.59301120e-01f,
  8.13741624e-01f, -4.42984760e-01f, 3.38355511e-01f, -1.20064747e-02f, -3.93379509e-01f, -3.62595797e-01f, -5.71673930e-01f, -1.78950176e-01f, 6.73949942e-02f, -2.13591978e-02f,
  5.61495274e-02f, 2.14747012e-01f, 4.75056022e-01f, 3.80278647e-01f, 2.51717925e-01f, -2.23229274e-01f, -1.29772738e-01f, 4.17002410e-01f, 4.22265619e-01f, -2.06756443e-01f,
  -2.73020059e-01f, -2.01651216e-01f, 1.79679319e-01f, 3.03211599e-03f, -2.46806458e-01f, 1.19075745e-01f, 4.27817628e-02f, -1.58109739e-01f, 1.17515652e-02f, 2.02572092e-01f,
  2.54643559e-02f, -9.08246040e-02f, -3.11107188e-02f, 1.46591514e-01f, -1.09866112e-01f, -2.76362114e-02f, -1.62461214e-02f, 7.74139725e-03f, -5.43701649e-02f, -2.62337681e-02f,
  1.90832727e-02f, -7.90989473e-02f, -1.01805571e-03f, 2.14918200e-02f, -1.17453024e-01f, -3.29190679e-03f, 1.14772633e-01f, 1.83298394e-01f, 1.17793024e-01f, -8.52472335e-03f,
  -1.28854215e-01f, -6.32657185e-02f, 9.34720337e-02f, -2.12887283e-02f, 9.40160975e-02f, 1.95459515e-01f, 7.45637389e-03f, 1.16695143e-01f, 2.11446553e-01f, 1.07891880e-01f,
  -1.57666072e-01f, 6.60397485e-02f, 1.11166202e-02f, 2.43644565e-02f, 1.32568583e-01f, -1.58147160e-02f, -7.73853436e-02f, -5.83661906e-03f, 1.84051450e-02f, -7.54122734e-02f,
  -3.84231210e-02f, 3.68542969e-02f, 4.96495217e-02f, 1.89861469e-02f, -6.32676333e-02f, -2.66173249e-03f, -5.85053749e-02f, -2.25199200e-02f, 1.19236996e-03f, 3.72308567e-02f,
  1.25382528e-01f, 4.93792258e-03f, -3.81447151e-02f, 3.23585384e-02f, 1.53622152e-02f, 9.23114493e-02f, 1.23705892e-02f, 2.30215862e-02f, -1.74195826e-01f, -2.26326033e-01f,
  -1.63602918e-01f, 3.70402098e-01f, 5.82742840e-02f, 1.48583367e-01f, -7.89774880e-02f, -2.19888035e-02f, 6.55524209e-02f, 5.99085866e-03f, -3.13614756e-02f, 3.80381271e-02f,
  -5.92657505e-03f, 1.75655857e-01f, -1.17265983e-02f, 2.57651974e-03f, -4.15204652e-02f, -2.61063855e-02f, -1.33982554e-01f, 8.63852203e-02f, -1.42380418e-02f, -1.36566624e-01f,
  -1.38478234e-01f, 5.50946891e-02f, 1.18083075e-01f, 1.23952895e-01f, -1.80109248e-01f, 3.88175324e-02f, -1.36846201e-02f, -6.25771508e-02f, 1.19738303e-01f, -1.94968626e-01f,
  -7.64736772e-01f, -4.73330408e-01f, -8.32120702e-03f, -4.89966393e-01f, 2.48935178e-01f, 3.01529467e-01f, -2.66530275e-01f, 9.29375514e-02f, 8.68691504e-02f, -5.83182693e-01f,
  -1.21336386e-01f, 1.20517351e-01f, -9.48941037e-02f, 9.57118161e-03f, -3.47635224e-02f, -5.55642188e-01f, -2.92156398e-01f, 1.28529947e-02f, 4.81100172e-01f, 1.93451986e-01f,
  -1.78343102e-01f, -4.80862349e-01f, -9.88439694e-02f, 7.24050328e-02f, -4.50913012e-01f, -2.72193044e-01f, -4.92048591e-01f, -1.16322920e-01f, 1.70002773e-01f, -6.02764487e-01f,
  -3.13176006e-01f, 5.90786934e-02f, 2.22477034e-01f, 2.35709362e-02f, -1.62283093e-01f, -1.67632654e-01f, -1.24247588e-01f, 5.43923154e-02f, 2.52774179e-01f, 8.09457153e-02f,
  2.96931043e-02f, 1.30097404e-01f, 5.10963902e-04f, -6.80405498e-02f, 8.79677162e-02f, -1.61561757e-01f, -1.70003533e-01f, -2.41527073e-02f, -2.00254947e-01f, 7.41435215e-02f,
  -1.61523610e-01f, 2.56813973e-01f, 2.48912439e-01f, 1.99781105e-01f, 1.83291450e-01f, 1.81934848e-01f, 1.70374766e-01f, 1.02202654e-01f, 1.15880527e-01f, -4.61597443e-01f,
  9.47380625e-03f, -2.07098145e-02f, 2.35886760e-02f, 1.87752284e-02f, 2.36445908e-02f, 1.22964382e-01f, -3.08223478e-02f, 6.01676144e-02f, -1.96089372e-02f, -7.89576396e-02f,
  1.74683884e-01f, 2.07414832e-02f, -1.85889095e-01f, -2.00573996e-01f, -3.98306586e-02f, -1.00724109e-01f, -9.17820632e-03f, -4.75125909e-02f, -5.19352183e-02f, -7.70105869e-02f,
  1.20176375e-01f, -3.33248936e-02f, -3.95085029e-02f, -1.10662170e-01f, -5.47219515e-02f, -6.56082928e-02f, 1.44425750e-01f, 1.00004874e-01f, -7.56214336e-02f, 1.31927043e-01f,
  -3.92193049e-01f, 2.40355983e-01f, -2.86222816e-01f, -1.40065506e-01f, -1.24382131e-01f, -1.52267013e-02f, -1.11593366e-01f, 4.81234454e-02f, 9.66152083e-03f, -1.71583191e-01f,
  3.12161315e-02f, -1.96369782e-01f, -1.33812487e-01f, -8.69266167e-02f, 6.06620833e-02f, 8.84652436e-02f, -1.45583913e-01f, -1.48997873e-01f, 2.01300174e-01f, -1.20092802e-01f,
  -1.89305454e-01f, -6.90694228e-02f, -1.76648229e-01f, -5.44823445e-02f, -5.35802320e-02f, 1.76321771e-02f, -2.21061766e-01f, -2.50584155e-01f, -8.93247202e-02f, -6.99321568e-01f,
  1.69172674e-01f, -2.32550904e-01f, -2.16063425e-01f, 7.03955412e-01f, 4.05291319e-02f, -3.71589333e-01f, -8.49423289e-01f, -5.19418955e-01f, 3.93037021e-01f, -5.01398146e-02f,
  3.05562038e-02f, 3.44772607e-01f, 2.30954453e-01f, 9.76680312e-03f, -4.69905138e-01f, -3.13627720e-01f, -2.48210505e-01f, -4.33445245e-01f, -5.13889253e-01f, -2.80952066e-01f,
  1.03135973e-01f, -2.61560176e-02f, -1.74482629e-01f, -2.96346754e-01f, 3.40522289e-01f, 3.11705887e-01f, 2.14803681e-01f, 3.09580922e-01f, -2.08798423e-02f, 6.03149772e-01f,
  3.33717346e-01f, -1.24071606e-01f, 4.46914285e-02f, -7.56461872e-03f, 1.42632484e-01f, -1.41594797e-01f, -2.64251709e-01f, 1.79832969e-02f, 4.87069562e-02f, -1.63920745e-01f,
  1.83128595e-01f, -4.65665869e-02f, 3.59248556e-02f, 1.51749253e-01f, -1.90540850e-01f, -1.55376986e-01f, -4.69086543e-02f, -4.92477685e-01f, -3.71082515e-01f, 3.21973930e-03f,
  1.74213633e-01f, 1.54215582e-02f, -2.46199608e-01f, -1.77616060e-01f, -1.92495540e-01f, -3.24702524e-02f, -1.49856493e-01f, -3.17689055e-03f, -1.43498600e-01f, 2.06906274e-01f,
  3.19557153e-02f, 3.21043432e-02f, 4.39025722e-02f, 1.66070145e-02f, -4.04592492e-02f, 1.89056128e-01f, -4.43391539e-02f, 1.21123372e-02f, -9.71431937e-03f, -3.03598121e-02f,
  1.13715716e-02f, -2.76642363e-03f, -6.57691211e-02f, -1.95210241e-02f, 4.78424272e-03f, 5.14070988e-02f, 3.69558074e-02f, -4.04864438e-02f, -1.13786407e-01f, 1.07143242e-02f,
  -1.69096515e-01f, 1.04650095e-01f, 1.91065863e-01f, -5.08971810e-02f, 3.42501290e-02f, 5.57006523e-03f, -9.30642784e-02f, -1.86941847e-02f, -9.43769887e-02f, -1.54809281e-01f,
  1.67926297e-01f, -2.30328545e-01f, 7.07597956e-02f, -1.74307093e-01f, 1.36211827e-01f, -1.56170083e-02f, 1.73279122e-01f, -1.35241494e-01f, 1.24711826e-01f, -8.46209228e-02f,
  -1.79768234e-01f, -2.61956807e-02f, 1.87139496e-01f, -1.54751658e-01f, 3.42966765e-02f, -6.26891479e-02f, 2.17385422e-02f, 9.12669972e-02f, -5.86024709e-02f, 1.13853261e-01f,
  -7.25152269e-02f, -1.50874063e-01f, -4.45596948e-02f, 1.05480207e-02f, 1.27137050e-01f, -1.57112941e-01f, -7.40333945e-02f, -1.34287715e-01f, -1.24093987e-01f, -2.58134544e-01f,
  8.97669375e-01f, -4.68456805e-01f, 5.52887440e-01f, 4.08672243e-01f, 2.88560688e-01f, 3.73713851e-01f, 2.88816631e-01f, 5.94861768e-02f, 1.97324291e-01f, 1.49060547e-01f,
  -7.13459728e-03f, -1.43383026e-01f, -1.83414340e-01f, -3.21012199e-01f, -6.91118762e-02f, -9.24482122e-02f, -1.47602618e-01f, 2.37296090e-01f, 3.53422314e-01f, 3.12118053e-01f,
  -1.93927154e-01f, -9.30877496e-03f, 1.98337317e-01f, -4.83561903e-02f, -8.48268420e-02f, 7.61101022e-03f, 3.22042406e-02f, -1.00933155e-02f, -1.13784581e-01f, -3.42032611e-01f,
  -9.23673436e-02f, 1.18256263e-01f, 1.05244488e-01f, -1.67094454e-01f, -1.22049443e-01f, -3.35071050e-02f, -1.87577475e-02f, 6.30131736e-02f, -5.04113100e-02f, -1.52952000e-01f,
  -2.05288574e-01f, -5.08484766e-02f, -3.02087963e-02f, 1.47108361e-01f, 5.67517430e-02f, 7.92588107e-03f, 6.99895900e-03f, -7.23796785e-02f, -1.69280451e-02f, 2.44049709e-02f,
  -2.35987723e-01f, 4.91096713e-02f, 1.29647583e-01f, 1.14280879e-01f, -8.59475657e-02f, 9.41481218e-02f, 4.99903336e-02f, -5.63969649e-02f, 9.60407704e-02f, -1.19632930e-02f,
  9.69469249e-02f, 1.64029077e-02f, 8.15782100e-02f, 4.70665991e-02f, 5.13387881e-02f, -6.21785037e-02f, -9.65519845e-02f, 2.15362292e-02f, 4.19604965e-02f, 5.57909720e-02f,
  -4.39921692e-02f, 3.59411612e-02f, 8.94959867e-02f, 4.40477245e-02f, 4.87849079e-02f, 9.05862823e-02f, 9.31108277e-03f, -2.81634312e-02f, 1.38212247e-02f, 2.93010548e-02f,
  8.89035314e-02f, -5.87325022e-02f, 9.47907940e-02f, -7.18738362e-02f, -8.39999616e-02f, -2.30538938e-02f, 4.74012420e-02f, -5.13709662e-03f, 1.78326666e-02f, 1.06329778e-02f,
  -2.73511529e-01f, 2.78841585e-01f, -1.10504299e-01f, -1.16922125e-01f, -5.32910377e-02f, -5.26364818e-02f, 1.51427403e-01f, -5.28531931e-02f, -2.34563261e-01f, -2.20819443e-01f,
  6.05403259e-02f, -9.13376212e-02f, 7.78940693e-02f, -1.72675177e-02f, 1.94804356e-01f, 7.80832767e-02f, -1.42928183e-01f, 1.75699010e-01f, -2.16601044e-01f, -5.15776388e-02f,
  -2.95313537e-01f, 2.34683797e-01f, 2.12490037e-01f, 6.59720525e-02f, 1.27913058e-03f, 6.79652095e-02f, 1.15511321e-01f, 5.52277677e-02f, 1.18782707e-01f, 3.49623971e-02f,
  6.85685217e-01f, -1.03364810e-01f, -7.80531943e-01f, 4.93216276e-01f, -2.24605620e-01f, -2.31481224e-01f, 1.57097116e-01f, 2.09226072e-01f, 3.49019259e-01f, -3.13109532e-02f,
  -3.28793824e-01f, -2.47466385e-01f, 4.71210778e-02f, -1.32219329e-01f, -1.89468175e-01f, -8.66060555e-02f, -1.97821274e-01f, -2.41339982e-01f, -3.21475387e-01f, -4.13368762e-01f,
  -4.90268394e-02f, 1.97040483e-01f, 2.17883028e-02f, -1.58246696e-01f, 1.60412237e-01f, -1.41525149e-01f, -1.99072644e-01f, -2.78520644e-01f, -6.26076162e-01f, -2.73379236e-01f,
  -6.27290130e-01f, -1.07749343e-01f, 1.32699043e-01f, -4.22815643e-02f, 6.86673969e-02f, 1.61377579e-01f, 2.29962301e-02f, 1.57721654e-01f, 2.80291408e-01f, 8.83959606e-02f,
  -7.58715943e-02f, -1.19567765e-02f, 5.96382841e-02f, 1.70026459e-02f, 2.38512661e-02f, -6.94514289e-02f, 5.53719625e-02f, 5.49670532e-02f, 1.49331763e-01f, -8.92107189e-02f,
  -1.66418672e-01f, -1.86278716e-01f, -1.01074792e-01f, 8.24006945e-02f, -1.07605875e-01f, -8.23954418e-02f, 3.90316136e-02f, -1.45899057e-01f, -2.22908616e-01f, 2.69780427e-01f,
  -4.92412075e-02f, 6.64329678e-02f, -1.05026066e-01f, 2.28384957e-02f, 1.37268677e-01f, 8.92865285e-02f, 2.10808776e-02f, -2.85219923e-02f, 9.55143496e-02f, -1.27889030e-02f,
  1.74274921e-01f, -5.54456450e-02f, -1.35506317e-02f, -3.97065133e-02f, -1.17785946e-01f, -3.17982696e-02f, -4.92800847e-02f, 9.63532850e-02f, -9.33256596e-02f, 6.72356635e-02f,
  -6.79253116e-02f, -8.08892120e-03f, 8.21535126e-04f, -5.09447139e-03f, -1.94291487e-01f, -3.90716605e-02f, -1.54606223e-01f, -1.05381263e-02f, 6.53308351e-03f, 2.49038674e-02f,
  1.97254032e-01f, -8.09330344e-02f, 1.71852306e-01f, -2.50360835e-02f, -1.04453385e-01f, -6.79309666e-02f, -1.54076502e-01f, 4.30443399e-02f, -1.54815651e-02f, 6.59514917e-03f,
  -2.70228773e-01f, -7.61660039e-02f, -5.57594486e-02f, 1.36414962e-02f, 6.36486262e-02f, -4.22989130e-02f, -1.51559860e-01f, -2.78863553e-02f, -1.35694686e-02f, -4.07627560e-02f,
  7.53751844e-02f, 1.30495921e-01f, 2.83912957e-01f, 1.95688501e-01f, 2.32439991e-02f, -4.26818058e-02f, 1.23728529e-01f, 4.06010374e-02f, -2.52188649e-02f, 5.67472994e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 8)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 8;
const float L0_fan_Bp_bar_data[] = {
  3.92345935e-01f, 1.94484442e-01f, 1.08223855e+00f, 3.64143401e-01f, 7.12557197e-01f, -1.53839350e-01f, 3.19830090e-01f, 2.77873069e-01f
};

// L1_fan_Wp (Shape: 4 x 16)
const int L1_fan_Wp_rows = 4;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  -1.22239523e-01f, -1.67914256e-01f, 3.54975939e-01f, -2.53089726e-01f, -2.96570927e-01f, 5.45911528e-02f, -8.03934410e-03f, 3.35487694e-01f, -3.08736086e-01f, 1.97207838e-01f,
  -2.57815849e-02f, 2.21555024e-01f, 1.27470061e-01f, 5.70077419e-01f, -3.17648023e-01f, -2.49454364e-01f, 1.47810861e-01f, 5.46660781e-01f, 9.71449837e-02f, 7.52538517e-02f,
  1.40990764e-01f, 1.06990211e-01f, 3.72098804e-01f, -2.13979036e-01f, -2.45658271e-02f, 7.67719895e-02f, 4.55138385e-01f, -4.04462695e-01f, -4.81297255e-01f, -3.52614701e-01f,
  -3.43968198e-02f, -7.85493255e-02f, 1.21710271e-01f, 2.19246626e-01f, -1.19715884e-01f, 2.09055796e-01f, 5.21486960e-02f, 1.37226365e-03f, -4.31406081e-01f, -2.71674484e-01f,
  -8.42541754e-02f, 2.47599259e-01f, 2.04035103e-01f, -3.35863382e-01f, -2.00986132e-01f, -1.33111119e-01f, -6.57541603e-02f, 3.63191336e-01f, -1.33539706e-01f, -6.59559309e-01f,
  -2.66662478e-01f, -3.16756129e-01f, 6.31582290e-02f, -1.86932325e-01f, 1.29993185e-01f, 2.36724228e-01f, 1.06496915e-01f, -1.22945346e-01f, -4.62749571e-01f, -2.61391699e-01f,
  4.63205218e-01f, -3.53197247e-01f, -1.41573980e-01f, -2.26250589e-01f
};

// L1_fan_Wp_bar (Shape: 8 x 16)
const int L1_fan_Wp_bar_rows = 8;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  3.60955805e-01f, 1.38625979e-01f, 5.29963434e-01f, 2.40110755e-01f, 3.27877402e-01f, -5.44409752e-01f, -1.95181951e-01f, 7.24784255e-01f, -1.56957433e-02f, 7.57438987e-02f,
  -2.72175401e-01f, -9.15667936e-02f, -9.42221358e-02f, 1.13016033e+00f, 8.26211095e-01f, 6.73538744e-01f, 1.83007449e-01f, 2.58582354e-01f, 6.72985017e-01f, 1.00777417e-01f,
  -1.20211765e-01f, 2.48275086e-01f, 7.13183522e-01f, 1.51017353e-01f, -1.76226601e-01f, -3.45618129e-02f, 7.16951966e-01f, -2.10495200e-02f, 4.44857985e-01f, -8.69089440e-02f,
  4.10299212e-01f, -4.39913422e-01f, 1.70681477e-02f, 1.01721108e+00f, 3.70377630e-01f, 5.19976139e-01f, -3.95002544e-01f, 5.43019831e-01f, 1.33082792e-02f, -2.95286775e-01f,
  1.41633302e-01f, 9.28983837e-02f, 1.11345029e+00f, -3.63995247e-02f, -4.10114586e-01f, -1.73565358e-01f, 4.88888055e-01f, 4.16714519e-01f, 6.14444435e-01f, -6.52920529e-02f,
  -5.31630442e-02f, 5.92143238e-01f, 7.81546235e-01f, 1.91904411e-01f, 5.04665136e-01f, -2.66217999e-02f, -1.00153543e-01f, -2.06995264e-01f, 1.00310385e+00f, -3.20484377e-02f,
  3.82370770e-01f, -9.16219115e-01f, 6.21875346e-01f, 3.05640727e-01f, 9.03936923e-02f, 3.13888401e-01f, 4.70885217e-01f, 5.48438191e-01f, -5.46109259e-01f, 4.98814493e-01f,
  1.54105231e-01f, -4.93271708e-01f, 5.96334755e-01f, -4.04515028e-01f, 2.77890921e-01f, 2.64126539e-01f, 7.46044040e-01f, -1.23044252e-01f, -1.80071056e-01f, -5.09053886e-01f,
  1.37610808e-02f, -2.96968669e-01f, -6.04399405e-02f, -1.57680348e-01f, -3.34075481e-01f, -3.52015883e-01f, -6.19193651e-02f, -9.27271128e-01f, 3.26276839e-01f, 4.93659973e-01f,
  -2.14986932e-02f, -8.73106420e-01f, 5.59966087e-01f, 4.01338696e-01f, -6.29372597e-01f, -2.60298133e-01f, 5.09727180e-01f, 3.81406456e-01f, 3.62281531e-01f, 8.23837340e-01f,
  4.04605031e-01f, 3.72223884e-01f, -9.66702521e-01f, -2.73939818e-01f, 8.32567096e-01f, -5.15957534e-01f, 4.02366877e-01f, -1.23254560e-01f, 4.37999845e-01f, 6.77255571e-01f,
  4.17069979e-02f, 6.64583445e-01f, 2.38312423e-01f, -4.89240140e-01f, 1.52195126e-01f, 2.16781288e-01f, 3.21777493e-01f, -2.45964322e-02f, -3.63660127e-01f, 4.61089790e-01f,
  -2.44070679e-01f, 1.15657344e-01f, 1.03879079e-01f, 5.35284758e-01f, 1.61464944e-01f, -5.77078313e-02f, 3.17421436e-01f, -4.38620038e-02f
};

// L1_fan_Bp_bar (Shape: 1 x 8)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 8;
const float L1_fan_Bp_bar_data[] = {
  5.61415315e-01f, 3.10786247e-01f, -4.54156585e-02f, 3.21494579e-01f, 4.54251021e-01f, 4.56500441e-01f, 8.24384332e-01f, 2.99833957e-02f
};

// L2_fan_Wp (Shape: 4 x 16)
const int L2_fan_Wp_rows = 4;
const int L2_fan_Wp_cols = 16;
const float L2_fan_Wp_data[] = {
  -7.30462790e-01f, 4.22449589e-01f, 2.42944062e-01f, 7.61424780e-01f, 1.01135314e-01f, -2.77891189e-01f, -9.76064876e-02f, 2.61452883e-01f, -1.30531996e-01f, 2.85998076e-01f,
  4.43401709e-02f, -1.26464022e-02f, 4.05568689e-01f, 2.04750925e-01f, -3.39364022e-01f, 6.91049099e-02f, 1.80930153e-01f, -3.83650422e-01f, 1.88951828e-02f, -5.29652774e-01f,
  -4.77078378e-01f, -5.22706285e-03f, 2.94511378e-01f, -2.27580369e-01f, -1.04057789e-01f, 2.68457562e-01f, 2.78804868e-01f, 6.70716837e-02f, 4.95096035e-02f, -5.00492752e-01f,
  -8.83434713e-02f, 3.49526048e-01f, 2.27621928e-01f, 3.76708299e-01f, -2.56713063e-01f, 6.11746848e-01f, -8.04407820e-02f, 6.86467230e-01f, -2.49429867e-01f, 4.55079377e-02f,
  4.15695637e-01f, -9.67505053e-02f, -2.83109881e-02f, -1.64114341e-01f, -1.49948850e-01f, 1.56687707e-01f, 1.49603292e-01f, -3.72498691e-01f, 3.70341599e-01f, 8.26384649e-02f,
  -1.90270782e-01f, -1.96443517e-02f, -4.09671158e-01f, 1.74816340e-01f, 2.45619893e-01f, -7.30975121e-02f, -6.33011088e-02f, -3.30096185e-01f, 4.66768034e-02f, 4.61899340e-02f,
  9.21092108e-02f, -1.55268773e-01f, 2.47157246e-01f, -3.47405255e-01f
};

// L2_fan_Wp_bar (Shape: 8 x 16)
const int L2_fan_Wp_bar_rows = 8;
const int L2_fan_Wp_bar_cols = 16;
const float L2_fan_Wp_bar_data[] = {
  1.30474299e-01f, 2.66408384e-01f, 7.83647716e-01f, 2.04470381e-01f, 8.98289740e-01f, 1.16778398e+00f, -3.23791087e-01f, -1.31761432e-01f, -5.48017740e-01f, 7.06524670e-01f,
  4.14071500e-01f, -1.77778423e-01f, 6.65766954e-01f, 1.17732537e+00f, -2.17953362e-02f, -9.50377226e-01f, -2.95205802e-01f, -1.94614783e-01f, -2.32499987e-01f, -3.52158621e-02f,
  -1.09114456e+00f, 1.35417116e+00f, 2.92122275e-01f, 9.00153875e-01f, -9.30663764e-01f, -2.78675091e-02f, 6.47122264e-02f, 1.86814338e-01f, 5.75836539e-01f, 2.44092241e-01f,
  8.60757008e-02f, -1.81115463e-01f, 8.86917055e-01f, 1.45973578e-01f, 1.22948460e-01f, -3.30834508e-01f, -1.21433294e+00f, -2.56868243e-01f, 2.14129895e-01f, -2.57489324e-01f,
  3.61948162e-01f, -7.51363993e-01f, -2.16499612e-01f, -2.75715470e-01f, 3.93238634e-01f, 5.93276978e-01f, 8.18359077e-01f, -1.53136864e-01f, 6.05102062e-01f, 4.45410848e-01f,
  -4.56659496e-01f, -4.98721421e-01f, -4.99857038e-01f, 4.69703913e-01f, 4.66031581e-02f, -8.09899032e-01f, -5.70245646e-02f, 6.54519081e-01f, 1.13329542e+00f, 1.23064458e+00f,
  4.28720832e-01f, -8.38727951e-01f, 6.40821993e-01f, -1.59746036e-01f, 6.62765026e-01f, 7.13453233e-01f, 7.48195887e-01f, 1.07425201e+00f, -8.92910421e-01f, 1.39811590e-01f,
  -4.35293615e-01f, 6.49530590e-01f, -3.06301206e-01f, 8.95138159e-02f, -6.98965967e-01f, 9.99462247e-01f, 6.11645639e-01f, 5.54608703e-01f, 1.94116533e-01f, -1.77602582e-02f,
  6.20396137e-01f, 5.66798076e-02f, -5.56445904e-02f, -1.63165554e-01f, -1.01320744e+00f, 2.35607892e-01f, 1.23764503e+00f, -2.69099027e-01f, 7.74768472e-01f, -5.40581718e-02f,
  3.53321433e-01f, 2.09484830e-01f, -6.89833999e-01f, 6.16587818e-01f, 3.53064746e-01f, -3.51091921e-02f, 8.91222894e-01f, -4.10835713e-01f, 6.28299475e-01f, -3.15142870e-01f,
  -2.47983411e-01f, 3.37840170e-01f, 4.50963795e-01f, -1.10156462e-02f, 4.74913746e-01f, -5.92071652e-01f, -1.00104935e-01f, -6.49113357e-01f, 7.59000003e-01f, 2.97850937e-01f,
  9.66518104e-01f, -5.14481902e-01f, 7.52022862e-01f, 2.95440823e-01f, 8.53665113e-01f, 1.23483932e+00f, 1.18249726e+00f, -1.57353663e+00f, -1.09633315e+00f, -8.66800010e-01f,
  7.20392883e-01f, 5.30265510e-01f, -1.07122444e-01f, -2.95052886e-01f, 5.70297778e-01f, -3.43315333e-01f, 1.81017190e-01f, 1.88706443e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 8)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 8;
const float L2_fan_Bp_bar_data[] = {
  3.46505225e-01f, 1.09604755e-02f, 4.11425680e-02f, -2.64147669e-01f, 4.29929420e-02f, 3.58952582e-01f, 4.72714692e-01f, 2.92321295e-01f
};

// L3_linear_W (Shape: 12 x 16)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 16;
const float L3_linear_W_data[] = {
  4.37113255e-01f, -8.59669268e-01f, -1.54551998e-01f, -7.01270759e-01f, 4.40022349e-01f, 1.33180648e-01f, -2.82809883e-02f, -2.61682391e-01f, -1.85839280e-01f, 4.84566182e-01f,
  3.60258788e-01f, -5.69887638e-01f, 3.06077510e-01f, -8.10190812e-02f, 3.56533915e-01f, -7.73641169e-01f, 3.62056613e-01f, -9.77037787e-01f, 5.02557456e-01f, 1.36811798e-02f,
  -9.29118812e-01f, 2.25784540e-01f, -1.56879759e+00f, 7.67953217e-01f, -1.33876562e+00f, -2.28718176e-01f, 1.13473758e-01f, 5.19366562e-01f, -6.48570582e-02f, -9.38887894e-02f,
  -3.34665716e-01f, 3.71421933e-01f, 3.27578448e-02f, -4.57691193e-01f, -4.35150921e-01f, 4.73528326e-01f, -1.53158322e-01f, 9.10456777e-01f, -9.63625789e-01f, -2.88588524e-01f,
  3.47393692e-01f, -7.54051745e-01f, -1.17127097e+00f, 5.96503615e-01f, -1.98128715e-01f, -1.16127932e+00f, -2.62182027e-01f, 3.97224545e-01f, -1.23842001e+00f, 5.54480791e-01f,
  1.90447569e-01f, 3.78557742e-01f, -2.97004491e-01f, -6.66206002e-01f, -1.79511920e-01f, 7.77173460e-01f, 4.15385604e-01f, 6.26161754e-01f, -1.51222855e-01f, -7.03985095e-02f,
  3.19218963e-01f, -9.55484569e-01f, -1.28167093e-01f, -2.27948099e-01f, 1.65486425e-01f, 4.55885902e-02f, -3.74600619e-01f, -4.78267372e-01f, 5.03909290e-02f, -8.60433221e-01f,
  -3.36620390e-01f, 1.60017896e+00f, -2.13780906e-02f, -1.01444817e+00f, 1.59656867e-01f, -3.57888825e-02f, -1.55503362e-01f, -5.67772388e-02f, 2.87036091e-01f, 3.15994412e-01f,
  -3.95197183e-01f, 7.73079097e-01f, -4.60032433e-01f, -3.63749474e-01f, -5.74748591e-02f, 1.09025073e+00f, 1.18858099e+00f, 2.55218923e-01f, -5.17430842e-01f, -4.27134037e-01f,
  3.24295104e-01f, 2.05724522e-01f, -9.58357573e-01f, 7.78562486e-01f, -5.78456447e-02f, -7.15906024e-01f, 9.58296359e-02f, 5.51337600e-01f, 8.75985920e-01f, -2.50530154e-01f,
  1.14888513e+00f, -1.41663778e+00f, 8.49385917e-01f, -1.01054919e+00f, -8.46191943e-01f, -2.78183579e-01f, -1.71565270e+00f, -8.52383375e-01f, -5.45887709e-01f, -9.69756484e-01f,
  -1.59745538e+00f, 1.07635379e+00f, -2.59851217e-02f, -3.78127366e-01f, 7.91839063e-02f, -1.58957809e-01f, 6.02497518e-01f, -1.03850245e+00f, -4.84798133e-01f, -4.83048409e-01f,
  1.08907211e+00f, -1.48845625e+00f, -5.01603901e-01f, -5.29762864e-01f, 2.06066370e-01f, 3.39681208e-01f, -6.45457029e-01f, 2.06347570e-01f, -3.49650532e-01f, -6.06190488e-02f,
  2.86444306e-01f, 6.04138613e-01f, -6.14684880e-01f, -1.19343720e-01f, -9.37620848e-02f, -6.30448520e-01f, -4.91843820e-01f, -6.44607127e-01f, -1.62875843e+00f, 7.95777440e-01f,
  -2.99486727e-01f, 5.74211240e-01f, -1.63936234e+00f, -9.80903149e-01f, 6.22998118e-01f, 6.12602174e-01f, -2.55671382e-01f, 1.23590541e+00f, -6.44987047e-01f, -2.41098419e-01f,
  7.72198498e-01f, -6.35237813e-01f, -8.37361157e-01f, -1.15241992e+00f, 3.73328924e-02f, -1.05050731e+00f, -1.00375092e+00f, 9.07485932e-02f, 6.40264630e-01f, 6.28025830e-01f,
  -1.55515056e-02f, -5.41893661e-01f, -2.73109585e-01f, 2.48000026e-01f, -4.03968811e-01f, 2.54051149e-01f, -5.14274180e-01f, 1.01534855e+00f, 4.66941029e-01f, 5.13600647e-01f,
  -3.82257819e-01f, 3.47032011e-01f, -2.27854401e-01f, -1.09896950e-01f, -8.51468667e-02f, -1.48488629e+00f, 2.04156756e-01f, 1.25529563e+00f, 5.97184658e-01f, 5.71828008e-01f,
  9.81909633e-02f, 1.02830482e+00f, 8.12865734e-01f, -6.82829618e-01f, -7.95843482e-01f, -7.97558248e-01f, -7.69245446e-01f, 9.53881294e-02f, 1.25294995e+00f, 1.43751070e-01f,
  -1.38375676e+00f, 5.23854196e-02f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  1.69130474e-01f, 1.44601032e-01f, -2.98936814e-01f, -1.60747439e-01f, -3.02208930e-01f, 3.34354311e-01f, 2.77396470e-01f, 4.08254504e-01f, -3.70613411e-02f, -1.79174826e-01f,
  -4.34398264e-01f, 3.09600849e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 4, 8
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 4, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        16, 4, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        16, 12
    );
    }
    