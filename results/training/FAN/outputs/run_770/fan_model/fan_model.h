/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 1 x 120)
const int L0_fan_Wp_rows = 1;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  1.95509598e-01f, -2.09852234e-01f, -4.90166754e-01f, -4.65239724e-03f, -2.64939100e-01f, -2.39318088e-01f, -4.73740339e-01f, 1.71994772e-02f, 1.61042541e-01f, -1.29796267e-01f,
  -1.51825733e-02f, 2.84110665e-01f, 1.43433720e-01f, 1.49392292e-01f, -3.45276110e-02f, -3.49716902e-01f, -4.56113011e-01f, -1.63622081e-01f, 7.00036250e-03f, 1.08903199e-01f,
  7.63484985e-02f, 1.41355377e-02f, 2.34923422e-01f, 1.44532144e-01f, -2.16033142e-02f, -3.71535681e-02f, -1.75254345e-01f, -5.14089018e-02f, -1.29004046e-01f, -6.85027540e-02f,
  -1.94145441e-01f, 7.44350478e-02f, -1.47235133e-02f, 1.66497186e-01f, 2.13291198e-02f, 5.27534448e-02f, -4.65993024e-02f, 4.09726501e-02f, 6.65073320e-02f, -3.02106813e-02f,
  9.61275697e-02f, 1.41010493e-01f, -6.31851032e-02f, 6.10099360e-02f, -2.49082199e-03f, -2.50432696e-02f, 5.76048978e-02f, 9.57363322e-02f, 1.67322531e-02f, 1.43824536e-02f,
  1.38259679e-03f, -5.95643334e-02f, -2.11342484e-01f, -2.40637045e-02f, -3.43153030e-02f, 9.88638029e-02f, -4.03777808e-02f, 9.55438316e-02f, 2.39450089e-03f, 1.15366042e-01f,
  4.58024815e-02f, 2.04607602e-02f, -3.29389349e-02f, 2.12485045e-02f, -2.58675609e-02f, -4.51562367e-02f, -5.42948395e-02f, -6.12762161e-02f, 1.96456127e-02f, -1.33395568e-02f,
  3.88895869e-02f, -3.36348824e-02f, -2.76966281e-02f, -6.00883998e-02f, 5.29958829e-02f, -5.14158010e-02f, -5.05610369e-02f, -6.72492897e-04f, -1.18595613e-02f, 9.29526910e-02f,
  5.21952473e-02f, -4.49664667e-02f, -2.34649125e-02f, 4.52460311e-02f, 1.46622071e-02f, -1.41916079e-02f, -3.91922556e-02f, 4.34251465e-02f, 4.39417036e-03f, 1.92061886e-02f,
  9.62373242e-02f, -1.64093021e-02f, -1.46147637e-02f, 6.12229258e-02f, -1.55193480e-02f, 7.83832893e-02f, -7.37785129e-04f, 4.59417794e-03f, 2.39708982e-02f, 3.97715531e-02f,
  1.47047965e-02f, 3.99256647e-02f, -6.20673075e-02f, 1.12055875e-02f, 6.58215359e-02f, 5.98423146e-02f, -5.88316582e-02f, -2.88310591e-02f, -1.68026499e-02f, 4.24699411e-02f,
  -8.26031901e-03f, -1.22560710e-01f, -1.20882466e-01f, -9.31582674e-02f, -1.03724763e-01f, -1.07168138e-01f, -1.47514373e-01f, -8.70711505e-02f, -1.74193770e-01f, -1.83565974e-01f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -6.31451607e-01f, -3.07778537e-01f, -2.55088322e-02f, -2.19444884e-03f, 1.02678165e-01f, -1.38853252e-01f, -4.77142841e-01f, -4.25907403e-01f, -7.18908235e-02f, -1.17458746e-01f,
  7.51425698e-03f, 2.52659619e-01f, 1.41394153e-01f, -3.49059748e-03f, -1.55668840e-01f, -1.71004161e-01f, 2.45968737e-02f, 1.60188735e-01f, 3.38916853e-02f, 1.45312445e-02f,
  1.88110441e-01f, 1.86862186e-01f, 8.09161142e-02f, 1.80539578e-01f, 1.53708473e-01f, 1.57554492e-01f, 1.47508606e-01f, 7.95257017e-02f, 1.75124183e-02f, 1.83861539e-01f,
  -1.92532286e-01f, -4.62229967e-01f, 1.09549157e-01f, 2.17410460e-01f, 1.89543754e-01f, -2.58614242e-01f, -2.98079755e-02f, -8.88625458e-02f, 3.20477076e-02f, -9.60452557e-02f,
  1.20979458e-01f, -3.74999493e-02f, 7.52157718e-02f, -5.47706261e-02f, -1.59393534e-01f, -1.10839151e-01f, -8.72928947e-02f, -1.79005802e-01f, -3.20599154e-02f, -1.10671923e-01f,
  1.30688816e-01f, 2.09050458e-02f, -1.27164751e-01f, -1.19162589e-01f, -9.99604240e-02f, 1.42496794e-01f, -1.06974088e-01f, -1.24593578e-01f, -1.17421024e-01f, -3.05361032e-01f,
  1.14803258e-02f, 2.34614126e-02f, -8.44270457e-03f, -6.87219873e-02f, -9.02103726e-03f, 3.19112837e-02f, -1.99714396e-02f, 5.32753468e-02f, -5.24511142e-03f, 1.31625375e-02f,
  5.95745333e-02f, -5.30761182e-02f, 6.25908561e-03f, -9.20676664e-02f, 1.22046910e-01f, -5.44373840e-02f, -1.94783304e-02f, -8.53629969e-03f, 5.17158359e-02f, 3.91492769e-02f,
  1.03077786e-02f, -4.57823798e-02f, 7.09219202e-02f, 2.58789305e-02f, -3.68574485e-02f, 2.96648871e-02f, -4.68543209e-02f, 1.03974715e-02f, -5.32822870e-02f, -2.14344729e-02f,
  6.35345234e-03f, 2.48743981e-01f, -1.69920981e-01f, -1.74781352e-01f, 1.93100073e-03f, 6.33423254e-02f, 3.06000351e-04f, 8.77526030e-02f, 1.53740132e-02f, -1.70864865e-01f,
  -4.57097776e-04f, -1.61671147e-01f, -3.87448967e-02f, -1.55829089e-02f, -1.25245741e-02f, -1.19864605e-01f, -3.38602327e-02f, 2.16708090e-02f, 6.76701441e-02f, -9.01838765e-02f,
  -5.19429930e-02f, -3.03238094e-01f, -3.52415293e-01f, -2.88431615e-01f, -1.60184607e-01f, -1.21083580e-01f, -1.37141541e-01f, -1.98250443e-01f, -2.26870716e-01f, -4.75251883e-01f,
  -9.27917063e-02f, -5.22096932e-01f, -5.66206336e-01f, -2.48210460e-01f, -2.05749735e-01f, -2.89284110e-01f, -3.25808346e-01f, -1.85567617e-01f, -1.80226728e-01f, -3.73535544e-01f,
  -1.45538941e-01f, 8.04265440e-02f, -2.54306998e-02f, -9.23818126e-02f, -1.88810438e-01f, -4.15025502e-01f, -5.84548295e-01f, -2.44646862e-01f, 1.35034341e-02f, -1.41707305e-02f,
  -1.69250280e-01f, -9.91427302e-02f, -3.64489071e-02f, -4.60239165e-02f, -8.21867883e-02f, -2.19060965e-02f, -3.21646273e-01f, -2.06449106e-01f, -1.80636764e-01f, -1.86504081e-01f,
  1.92971513e-01f, 3.79740372e-02f, 1.05638832e-01f, -4.34824545e-03f, -7.43183270e-02f, -9.26826149e-03f, -1.40376184e-02f, 5.40019125e-02f, 1.38718188e-02f, -1.11305617e-01f,
  3.25840269e-03f, 4.37387340e-02f, 5.80758005e-02f, 8.74848291e-02f, 2.78806556e-02f, -4.47706319e-02f, -2.00325936e-01f, -2.78716553e-02f, -8.38469490e-02f, -7.78115988e-02f,
  -1.07821092e-01f, -1.40978828e-01f, 1.02189519e-02f, -5.13777621e-02f, 5.75129949e-02f, -5.17554395e-02f, -6.64426759e-02f, -3.07499487e-02f, 4.51345220e-02f, 3.84062752e-02f,
  -1.01579711e-01f, -9.09529068e-03f, -4.54474799e-03f, 7.08049387e-02f, 1.01535572e-02f, 8.14795680e-03f, -1.36326384e-02f, 8.74575824e-02f, 6.57560229e-02f, -5.34381135e-04f,
  3.55463810e-02f, -9.07888287e-04f, -2.33297590e-02f, -2.03128662e-02f, -6.68975785e-02f, -1.16453201e-01f, -1.01267621e-02f, -7.84887299e-02f, -9.65925604e-02f, 3.89939058e-03f,
  2.82699261e-02f, 3.85070220e-02f, 5.34944497e-02f, 6.38458356e-02f, -1.20705627e-01f, -1.03524767e-01f, 3.24173123e-02f, 9.42546055e-02f, -6.83610793e-03f, -6.31131157e-02f,
  3.56627613e-01f, -1.61518589e-01f, -1.41960178e-02f, 1.18464001e-01f, -2.38018241e-02f, -2.49004606e-02f, -3.57241556e-03f, 5.30116223e-02f, 1.19870007e-01f, 2.51881424e-02f,
  1.05483688e-01f, 1.02897137e-01f, 1.85923488e-03f, -3.70804332e-02f, -4.97527272e-02f, -1.47554902e-02f, -1.82204172e-01f, -1.80369373e-02f, -1.12699710e-01f, -5.15542328e-02f,
  -1.92213714e-01f, -1.33521035e-01f, 6.87793791e-02f, 7.61733204e-03f, 4.49131392e-02f, 1.00652292e-01f, 1.03471160e-01f, 6.07548356e-02f, -2.13804119e-03f, 3.76433246e-02f,
  7.34655201e-01f, 3.28959823e-01f, 1.88945103e-02f, 4.82492745e-01f, -1.75353900e-01f, -5.57578325e-01f, -7.08193600e-01f, -3.64151388e-01f, 9.87716690e-02f, 2.08492830e-01f,
  1.82888657e-01f, 6.05194531e-02f, 1.98905151e-02f, -2.50048876e-01f, -4.61842120e-01f, -1.35101184e-01f, -3.97571549e-02f, -2.21425131e-01f, -5.17145097e-01f, -4.03895050e-01f,
  -1.57978937e-01f, 7.43260980e-02f, 5.35249189e-02f, -4.35631648e-02f, 3.96658689e-01f, 7.05328509e-02f, 3.31168562e-01f, 2.36973345e-01f, 8.42105299e-02f, 6.26917899e-01f,
  4.44117278e-01f, 3.04774940e-01f, -4.04684752e-01f, 5.54428436e-02f, 1.02395482e-01f, 6.48042411e-02f, 3.43730003e-02f, 7.28552714e-02f, 3.10929623e-02f, 4.21488211e-02f,
  9.87315401e-02f, 3.61531265e-02f, -3.77811305e-03f, -8.40085745e-02f, 3.62644531e-02f, -1.04256719e-01f, 9.78093245e-04f, -1.12261273e-01f, -1.76772445e-01f, -3.44736502e-02f,
  -2.40432788e-02f, 8.89928639e-02f, -1.22707531e-01f, -2.11543441e-01f, -1.30665913e-01f, -1.53803647e-01f, -4.70443144e-02f, -7.33909830e-02f, -1.94419816e-01f, 3.33104402e-01f,
  -5.69560900e-02f, 5.88022023e-02f, -2.35069748e-02f, 2.47719623e-02f, -6.14432804e-02f, 1.05307393e-01f, 1.77144408e-02f, 8.85011069e-03f, -6.76010624e-02f, 5.82957454e-02f,
  -8.47672224e-02f, 4.69713919e-02f, -4.15702835e-02f, 6.94691464e-02f, 1.08156353e-01f, 5.39503843e-02f, -3.70587036e-02f, -7.49271289e-02f, -1.35899913e-02f, 6.40282631e-02f,
  -3.57834250e-02f, -7.08085299e-02f, 1.31852493e-01f, -9.14852098e-02f, 1.07504111e-02f, 3.93987857e-02f, -2.24910397e-02f, -5.19387834e-02f, 1.25954859e-02f, 1.07916296e-01f,
  7.01623186e-02f, -6.21793687e-01f, 2.54991293e-01f, -5.75227700e-02f, 1.83626220e-01f, 1.36771146e-03f, 1.29018441e-01f, -2.01227423e-02f, 1.14180855e-01f, -7.76999816e-02f,
  -1.11739852e-01f, 1.49040215e-03f, 7.69363493e-02f, -9.70802754e-02f, -1.80806026e-01f, -1.30389139e-01f, 6.29864680e-03f, -5.39412349e-02f, -1.43804565e-01f, 1.10689983e-01f,
  -6.14758842e-02f, -2.62255371e-01f, -2.12051049e-01f, -2.46523038e-01f, -8.21634755e-02f, -2.46524557e-01f, -2.00056121e-01f, -2.01321483e-01f, -3.12815011e-01f, -5.11343069e-02f,
  6.77158237e-01f, -8.88392329e-01f, 5.73727004e-02f, 2.92931169e-01f, 3.68233532e-01f, 3.11293632e-01f, -1.60921425e-01f, -1.84791535e-02f, 2.04157516e-01f, -1.41588032e-01f,
  -2.79225618e-01f, 1.83794554e-02f, -2.80249212e-03f, -8.97639692e-02f, 1.20124482e-02f, -1.93034589e-01f, 1.66446537e-01f, 4.20229942e-01f, 4.87358451e-01f, 1.63859293e-01f,
  -1.13680981e-01f, 6.03132360e-02f, 1.06798075e-01f, -1.85303465e-02f, -2.26540729e-01f, 1.21903792e-01f, -1.05659805e-01f, -1.85193345e-01f, -2.68232197e-01f, -2.54904836e-01f,
  -4.01553273e-01f, -2.06608385e-01f, 3.55813861e-01f, 3.23336311e-02f, -1.77441373e-01f, 2.24727523e-02f, 9.32865515e-02f, -1.64126344e-02f, 4.78719594e-03f, -1.22112848e-01f,
  -8.14109296e-02f, 2.26065237e-02f, 4.64822464e-02f, -1.21250957e-01f, 7.30609428e-03f, 2.84753125e-02f, -8.79291631e-03f, -7.51154944e-02f, 3.31711881e-02f, -2.34948352e-01f,
  -2.84601808e-01f, 6.95177317e-02f, 5.93969822e-02f, -4.72801700e-02f, 4.64081671e-03f, 1.99744806e-01f, -2.05968007e-01f, -4.88446765e-02f, 1.03772633e-01f, -1.56772092e-01f,
  1.33106448e-02f, 7.06687868e-02f, -2.41445899e-02f, 2.14505289e-02f, 1.63064338e-02f, 5.09243906e-02f, 4.83397432e-02f, 2.24898965e-03f, 5.72912097e-02f, 2.70850640e-02f,
  -2.39786170e-02f, 6.48880303e-02f, 2.70184763e-02f, 4.93648686e-02f, -1.38596175e-02f, 1.10694589e-02f, 7.51712769e-02f, -1.39516756e-01f, 4.87162359e-02f, 6.62941039e-02f,
  4.22923453e-02f, 6.49059936e-02f, -1.75316143e-03f, -9.50282738e-02f, -3.63866314e-02f, -3.56898904e-02f, 2.00357698e-02f, -1.12399377e-01f, 2.68171504e-02f, -2.24846005e-02f,
  -1.49938077e-01f, 3.04923892e-01f, -1.68776568e-02f, -2.84522604e-02f, 6.61508888e-02f, -9.73118022e-02f, -2.83710323e-02f, -5.97646162e-02f, -1.33188769e-01f, -9.15311500e-02f,
  -8.73432830e-02f, -4.87529486e-02f, -1.40695706e-01f, -1.27168685e-01f, 1.84332728e-01f, 8.01026300e-02f, -1.22834235e-01f, 1.03670850e-01f, -6.67003617e-02f, -1.29604921e-01f,
  -2.06168875e-01f, 2.19745800e-01f, 2.91558892e-01f, 2.28984028e-01f, -2.82770190e-02f, 3.70385110e-01f, 8.29942152e-02f, 2.56339111e-03f, 2.41014972e-01f, 1.47082388e-01f,
  3.57471406e-01f, 5.17008781e-01f, 3.04990351e-01f, 1.80184364e-01f, 1.90787598e-01f, 1.76573649e-01f, 3.30918193e-01f, 3.40140462e-01f, 1.50569558e-01f, 2.12862134e-01f,
  1.68476269e-01f, 3.11273825e-03f, 1.75611645e-01f, 6.47397563e-02f, 2.58316576e-01f, 2.33177170e-01f, 1.49310261e-01f, 2.05580443e-01f, -3.15505452e-02f, 7.02775344e-02f,
  1.47004547e-02f, 2.10676119e-02f, 1.17270261e-01f, 1.53513461e-01f, 1.49859548e-01f, 5.49614280e-02f, 1.45551205e-01f, 1.51426792e-01f, 1.52103245e-01f, 1.43044934e-01f,
  -3.62178087e-02f, 4.08743620e-01f, -6.43734187e-02f, -8.39031264e-02f, -8.14981610e-02f, 1.17794881e-02f, -3.96896899e-02f, -1.18824951e-01f, 6.32434934e-02f, -1.91764496e-02f,
  -1.63856093e-02f, -2.77252458e-02f, -5.67652583e-02f, -3.47938463e-02f, -9.56899971e-02f, -4.63097543e-02f, -3.22792046e-02f, 4.23814654e-02f, 3.54016125e-02f, -2.78765932e-02f,
  -1.23343706e-01f, -1.48937926e-01f, -4.05658409e-02f, -4.13521752e-02f, 6.75035268e-02f, -6.26291111e-02f, 4.31244560e-02f, -3.60653340e-03f, 4.44149040e-02f, 2.18758099e-02f,
  9.21171606e-02f, -1.43571547e-03f, 2.07030540e-03f, 7.94972554e-02f, 1.60630234e-02f, 4.07649437e-03f, 9.75286402e-03f, 4.62047802e-03f, 7.08450302e-02f, -4.98647243e-02f,
  6.93632439e-02f, -4.39211838e-02f, -3.42687452e-03f, 1.87455099e-02f, -7.32831806e-02f, -4.26192023e-02f, -5.77325448e-02f, 7.34232217e-02f, -5.09023741e-02f, 2.45652385e-02f,
  -6.87438920e-02f, -6.25546873e-02f, -3.55753079e-02f, 5.33486344e-02f, -3.03094462e-02f, 3.38848531e-02f, -1.29505053e-01f, -7.88933858e-02f, -2.89506912e-02f, -1.39392586e-02f,
  -3.71126205e-01f, -9.20064449e-02f, -6.27530664e-02f, -4.35783193e-02f, 5.61674237e-02f, -1.14064151e-03f, 1.17073946e-01f, -7.56202731e-03f, -4.15231511e-02f, 1.98100973e-02f,
  6.31880321e-05f, -2.04553101e-02f, -9.35471151e-03f, -2.24614218e-02f, -5.09888493e-02f, -1.41369984e-01f, -3.11070848e-02f, -2.66499892e-02f, 2.21584588e-02f, -1.00787682e-02f,
  -2.89502945e-02f, -1.77496195e-01f, -1.35104164e-01f, -6.26834631e-02f, -1.04479268e-02f, -2.59066015e-01f, -2.40333080e-01f, -1.17999300e-01f, -9.53269675e-02f, -2.10221633e-01f,
  2.31387138e-01f, 8.69868696e-02f, 4.39554751e-01f, -2.47930735e-01f, -3.67420793e-01f, -3.55483711e-01f, -1.67463824e-01f, -2.24796217e-02f, -3.11587244e-01f, -1.95455119e-01f,
  -4.99967247e-01f, -3.18856657e-01f, -1.65157944e-01f, 1.29090175e-01f, 1.94400027e-01f, 2.08229467e-01f, 2.10756555e-01f, 5.74469984e-01f, 3.39314252e-01f, 8.91682133e-02f,
  -1.15816884e-01f, 2.30385587e-01f, 2.86126614e-01f, 3.38712960e-01f, -1.23509489e-01f, -1.42210260e-01f, 8.00526813e-02f, 8.26687813e-02f, 1.55636445e-02f, 2.17352867e-01f,
  2.70382268e-03f, 1.39705896e-01f, -7.38776550e-02f, -2.12098256e-01f, -5.76732010e-02f, 4.54579256e-02f, -7.96940774e-02f, 1.54802471e-01f, -6.61202669e-02f, 9.34731737e-02f,
  -8.59948099e-02f, -5.04893661e-02f, -1.19725512e-02f, -2.98098288e-02f, 5.13045751e-02f, 2.81054191e-02f, 1.97065756e-01f, 4.04529512e-01f, 7.81815127e-02f, -7.13778334e-03f,
  -1.34440586e-01f, -1.60379067e-01f, -3.76411453e-02f, -8.00161734e-02f, 8.41030702e-02f, -4.44654413e-02f, -4.75896895e-02f, -8.11858699e-02f, 9.41090360e-02f, 5.37751727e-02f,
  -4.43795733e-02f, 7.57395774e-02f, -8.67718011e-02f, 8.38607624e-02f, -1.36230914e-02f, 8.48910678e-03f, 6.59569874e-02f, 1.06114019e-02f, 1.53620802e-02f, 2.53919158e-02f,
  5.05891480e-02f, -3.67846005e-02f, 7.49328211e-02f, 1.64383221e-02f, -7.85595328e-02f, 3.42283286e-02f, 2.86541358e-02f, 3.27554159e-02f, -5.61956950e-02f, 3.50086167e-02f,
  -4.12392132e-02f, 5.63029908e-02f, -2.33914386e-02f, 9.87620577e-02f, 2.44931467e-02f, 9.58970711e-02f, 1.24688176e-02f, -5.12578227e-02f, -1.03474110e-01f, -8.41750130e-02f,
  -3.25116307e-01f, -9.69148874e-02f, -1.36296228e-01f, 1.07177049e-01f, -4.88125086e-02f, 2.55234484e-02f, -1.40172720e-01f, 5.79274967e-02f, -6.61101714e-02f, -4.76943366e-02f,
  -4.86690365e-02f, 2.53389366e-02f, -4.81846742e-02f, -2.63909306e-02f, -8.91353413e-02f, -1.65560260e-01f, -6.51443973e-02f, -6.71166554e-02f, -3.48127373e-02f, -6.32440895e-02f,
  -1.34313777e-01f, -3.02170098e-01f, -3.92979532e-01f, -2.08501235e-01f, -2.51708090e-01f, -2.97544926e-01f, -7.65445754e-02f, -1.86020970e-01f, -1.67066485e-01f, -2.54595697e-01f,
  2.68915862e-01f, 4.49827984e-02f, -2.88780868e-01f, 2.85788625e-01f, 2.78258145e-01f, 8.85003153e-03f, 2.07485944e-01f, 1.49905503e-01f, 1.51863992e-01f, 1.94491401e-01f,
  -1.59378260e-01f, -2.65173644e-01f, -2.54677147e-01f, -2.57114470e-01f, -2.35617727e-01f, -7.77277648e-02f, -4.49523292e-02f, -1.46512508e-01f, -1.55892223e-01f, 5.56825660e-02f,
  2.31573418e-01f, 2.64238715e-01f, 1.85499683e-01f, 1.27888277e-01f, 3.05708707e-03f, -1.01054281e-01f, -3.76173742e-02f, 2.79353019e-02f, -1.07312165e-01f, -2.60887481e-02f,
  -2.27130368e-01f, -1.51398808e-01f, 5.04401959e-02f, 7.52287954e-02f, 3.81117244e-03f, 1.86038148e-02f, 3.19034234e-03f, -2.44785007e-02f, 5.03733754e-02f, 9.77155343e-02f,
  -1.05516583e-01f, 3.48623767e-02f, -7.65084922e-02f, 1.17175169e-02f, 7.96795264e-02f, 1.95704736e-02f, -9.37846601e-02f, -6.14653006e-02f, -8.33211392e-02f, -3.66694815e-02f,
  -3.77218276e-02f, -3.28997150e-02f, -6.51338026e-02f, -9.31969211e-02f, -2.98225880e-01f, -2.75515318e-01f, -1.15310699e-01f, -1.27186731e-01f, -1.45378664e-01f, 1.95352525e-01f,
  3.72344516e-02f, 1.58270933e-02f, -9.13565531e-02f, 4.02131379e-02f, -3.24032269e-02f, 2.41613202e-02f, 7.23269135e-02f, 5.17453104e-02f, 4.84397523e-02f, 2.17258576e-02f,
  6.19623773e-02f, -3.34723964e-02f, -7.23577291e-02f, 3.64497751e-02f, -7.37053752e-02f, -8.01903531e-02f, -6.71765208e-02f, 1.52014045e-03f, 1.17896562e-02f, -1.34404958e-03f,
  -9.49805006e-02f, -1.11924605e-02f, 1.02345899e-01f, -6.46481104e-03f, -4.29326072e-02f, -8.75887051e-02f, 2.92143994e-03f, -4.16218936e-02f, 3.73027064e-02f, -3.60558704e-02f,
  3.70881468e-01f, -4.86738980e-01f, -1.62348971e-02f, -1.57406136e-01f, -1.30872661e-02f, 7.55797001e-03f, -1.07247807e-01f, -6.04520598e-03f, 1.49966730e-02f, 1.67789459e-02f,
  -1.20935500e-01f, -1.20473810e-01f, -1.03009781e-02f, 4.41442840e-02f, 1.55718014e-01f, -1.59447938e-02f, 1.37841895e-01f, -3.84280346e-02f, -1.01020806e-01f, 2.37262249e-02f,
  7.63044134e-02f, 1.87988147e-01f, 1.32486641e-01f, 1.24737710e-01f, -8.60970616e-02f, -1.46075319e-02f, 1.54171109e-01f, 1.64144903e-01f, -2.99449321e-02f, 7.11308062e-01f,
  -3.01828265e-01f, -1.09449066e-01f, -1.76125348e-01f, 2.55517483e-01f, 7.12444633e-02f, -2.14047819e-01f, -2.07840621e-01f, -1.67788163e-01f, 3.43800336e-02f, -1.31767616e-02f,
  6.18162155e-02f, 3.21964622e-01f, 1.51323602e-01f, 1.70976222e-01f, -6.94669262e-02f, -9.74199176e-02f, 1.20185286e-01f, 7.21715391e-02f, -6.27617687e-02f, 1.20907895e-01f,
  3.66422445e-01f, 1.55584723e-01f, 1.07695945e-02f, 9.51425433e-02f, 3.46016407e-01f, 2.57159263e-01f, 1.00334831e-01f, 2.10174292e-01f, 1.03273436e-01f, 4.03896689e-01f,
  3.64487991e-02f, -2.17826828e-01f, -3.38984840e-02f, 2.83249356e-02f, 1.18729658e-01f, -2.39805095e-02f, -1.08479582e-01f, -1.10652052e-01f, 2.03231368e-02f, -6.11878783e-02f,
  1.21010065e-01f, 1.24543030e-02f, 7.93354064e-02f, 6.97897151e-02f, -7.17669129e-02f, -3.44138779e-02f, -8.85347575e-02f, -1.01790093e-01f, -1.19636022e-01f, 2.79187169e-02f,
  2.77696431e-01f, 1.05140861e-02f, -2.46536866e-01f, -2.21699581e-01f, -1.26089260e-01f, 1.57488376e-01f, -1.49264604e-01f, -3.30852866e-02f, -1.74421713e-01f, -2.84341443e-02f,
  1.08001634e-01f, -2.87559368e-02f, -4.04340886e-02f, -9.26049333e-03f, 1.02915913e-01f, -6.46511391e-02f, 1.10961467e-01f, 9.91842821e-02f, 2.04183478e-02f, 7.24399043e-03f,
  5.00740968e-02f, -6.19962998e-02f, 3.31249125e-02f, -6.14859443e-03f, 3.76941264e-02f, -3.57859395e-02f, 4.48859297e-02f, 5.85735105e-02f, -7.46537223e-02f, -6.19879887e-02f,
  -5.57389390e-03f, -1.59397405e-02f, -4.42527086e-02f, 6.57497160e-03f, -2.22199187e-02f, 1.75407734e-02f, 6.05199933e-02f, 4.76700999e-02f, -4.27386351e-02f, -2.89379731e-02f,
  -9.76600721e-02f, -3.29342157e-01f, 4.87127416e-02f, -3.96044627e-02f, 7.82780796e-02f, -6.09098412e-02f, 1.30425796e-01f, -5.48350997e-02f, 6.90085366e-02f, -5.97335473e-02f,
  1.38746537e-02f, 2.41152775e-02f, -1.00039743e-01f, -1.24581181e-03f, -4.42727953e-02f, -1.13206401e-01f, 7.32932836e-02f, 4.22157310e-02f, -1.19898587e-01f, -6.63592201e-03f,
  -3.22884321e-02f, -1.10844687e-01f, -1.49343327e-01f, -1.71494275e-01f, 4.69575636e-03f, -5.84409609e-02f, -1.48494959e-01f, -1.33018389e-01f, -3.01559091e-01f, -2.04849452e-01f,
  1.31751597e-01f, 4.84331250e-01f, 1.60606295e-01f, 9.45916807e-04f, 4.42958474e-01f, 4.39102322e-01f, 6.05087817e-01f, 1.06778868e-01f, -6.40398487e-02f, 1.05459079e-01f,
  2.40822464e-01f, -1.80190340e-01f, -3.16539437e-01f, -2.51906365e-01f, -2.19967753e-01f, -1.72196620e-03f, -3.80236097e-02f, -2.69407928e-01f, -2.19640478e-01f, 6.56277314e-02f,
  3.10875662e-02f, 3.18031646e-02f, -7.13260695e-02f, -1.93416730e-01f, -2.02672221e-02f, -2.62571663e-01f, 5.13846800e-02f, 1.52020812e-01f, 8.80895481e-02f, -1.70587391e-01f,
  -9.16563496e-02f, 4.77663368e-01f, -2.47552365e-01f, -1.29472032e-01f, 2.03152243e-02f, -5.87760471e-02f, 2.94072889e-02f, -6.63511381e-02f, -3.99322584e-02f, -1.77599266e-02f,
  1.20060191e-01f, 5.49626499e-02f, 1.17735425e-02f, 1.12762231e-04f, 1.47283552e-02f, -1.62081178e-02f, -4.56391014e-02f, -2.92161852e-01f, -1.77759126e-01f, -1.02884926e-01f,
  8.77294987e-02f, 3.13399494e-01f, 2.37033755e-01f, -3.90317664e-02f, -2.50891615e-02f, -9.26258937e-02f, 9.00408626e-02f, -7.60270730e-02f, -6.91943839e-02f, -1.24164872e-01f,
  -7.20035583e-02f, 9.72816646e-02f, -1.55988652e-02f, -4.28753644e-02f, 3.18847746e-02f, -1.38985682e-02f, -5.25619164e-02f, 7.94377401e-02f, 6.34168275e-04f, 6.07856885e-02f,
  -7.75555596e-02f, -1.19810235e-02f, -9.63273924e-03f, -7.11400136e-02f, -8.45992714e-02f, 1.80155388e-03f, 3.22325490e-02f, 3.26247476e-02f, 3.78005095e-02f, -4.66606300e-03f,
  4.48397212e-02f, -6.69649094e-02f, 9.24704522e-02f, -5.93771748e-02f, 4.41607237e-02f, -7.41171315e-02f, -3.88610400e-02f, -4.15546224e-02f, -4.27841246e-02f, -1.58405565e-02f,
  -4.27830815e-01f, 8.95208195e-02f, -2.30255187e-01f, -1.17606305e-01f, 5.73800579e-02f, -5.31819463e-02f, -2.95395218e-02f, 1.85917430e-02f, 2.67819185e-02f, 5.86728193e-03f,
  1.38666928e-01f, 4.01551696e-03f, 5.63689992e-02f, -8.31993073e-02f, -7.48190358e-02f, -5.03497161e-02f, 8.75399783e-02f, -4.93448153e-02f, -1.49064213e-01f, 2.51693707e-02f,
  -5.94828911e-02f, 5.07529080e-02f, -1.61330730e-01f, -1.49116322e-01f, -1.54459685e-01f, -2.32988968e-01f, -1.01312853e-01f, -1.66281447e-01f, -7.83950537e-02f, -2.16070652e-01f,
  1.44800274e-02f, 7.90513977e-02f, -9.65808153e-01f, 3.10246974e-01f, -8.97202715e-02f, -1.28892601e-01f, 4.76362146e-02f, 3.93763214e-01f, 3.37604612e-01f, 9.91201773e-02f,
  -6.96691349e-02f, -6.94731325e-02f, -8.18779785e-03f, -1.55101359e-01f, -5.02093919e-02f, -8.27720538e-02f, -1.77667856e-01f, -4.61321056e-01f, -3.65431219e-01f, 7.01129213e-02f,
  2.67016888e-01f, 2.72851259e-01f, -8.26359168e-02f, 7.18044350e-03f, 3.34394500e-02f, 5.75392274e-04f, -1.09165460e-01f, -1.96539730e-01f, -3.40267509e-01f, -3.39941084e-01f,
  -6.47421062e-01f, -2.18290240e-01f, -5.67611195e-02f, 1.48489447e-02f, -1.83275864e-01f, 1.78961456e-02f, -7.28278309e-02f, -8.02725106e-02f, -9.43778902e-02f, -6.84252232e-02f,
  -5.71345948e-02f, -7.53781712e-03f, -8.88484046e-02f, -6.46607205e-02f, 9.47818346e-03f, -1.15851626e-01f, 6.45347759e-02f, -2.05240235e-01f, -9.43867862e-02f, -1.41537502e-01f,
  -1.98603924e-02f, -3.34400207e-01f, -3.97716433e-01f, -6.86912835e-02f, -3.07255238e-02f, -3.12216192e-01f, -2.16725767e-01f, -2.17702150e-01f, -2.22612888e-01f, 7.41415471e-02f,
  5.96206151e-02f, -6.89837150e-03f, -4.13427269e-03f, 6.31636605e-02f, 1.50057390e-01f, 6.98987441e-03f, -4.88605164e-02f, 2.26345453e-02f, 1.05352383e-02f, 1.98736824e-02f,
  -1.50032081e-02f, -1.00910686e-01f, 9.31079760e-02f, 1.04429476e-01f, -3.28536890e-02f, 1.50676360e-02f, 1.28362682e-02f, 1.05799899e-01f, 5.95695479e-03f, 1.77875217e-02f,
  9.84305516e-03f, -1.12143897e-01f, -5.48720062e-02f, 2.39257812e-02f, -9.08088014e-02f, -2.50666402e-02f, 2.12772209e-02f, 8.10058564e-02f, 1.75232589e-02f, 8.24562982e-02f,
  3.92945886e-01f, -2.00106114e-01f, -5.05081825e-02f, 9.94979292e-02f, -1.46137821e-02f, -3.61576378e-02f, 3.37556899e-02f, -2.50833072e-02f, -1.00709341e-01f, -2.66313031e-02f,
  -9.32931155e-02f, 1.10224886e-02f, 1.37996366e-02f, 2.43906397e-02f, -8.28754306e-02f, -6.98167924e-03f, 1.78563789e-01f, -6.14773035e-02f, 2.59487182e-02f, 5.79838566e-02f,
  2.32218012e-01f, 9.26361680e-02f, -1.24418717e-02f, 8.13678801e-02f, 5.76246865e-02f, -1.37935832e-01f, -1.06147796e-01f, -8.26870874e-02f, -1.14610672e-01f, 3.98910284e-01f,
  -1.06304324e+00f, 2.37419546e-01f, 4.08626080e-01f, -5.97650409e-01f, -7.65645429e-02f, 2.13355884e-01f, 1.84440032e-01f, -1.36324316e-01f, -1.09139755e-01f, 7.56026134e-02f,
  1.13894753e-01f, -1.59521714e-01f, -1.26204982e-01f, -2.23258436e-01f, -1.86064795e-01f, 7.47615695e-02f, -2.42943242e-02f, -4.08702761e-01f, -4.49835807e-01f, -3.10248047e-01f,
  -2.88777113e-01f, -4.78045225e-01f, -6.20536387e-01f, -2.14464456e-01f, 9.79729556e-03f, -1.14657842e-01f, 1.62713453e-01f, -5.28728142e-02f, 1.49447799e-01f, -1.27786547e-01f,
  6.30111158e-01f, -2.96270791e-02f, -1.29984677e-01f, -2.17095345e-01f, 8.22858885e-02f, -1.33955684e-02f, 3.96808796e-02f, -8.23147073e-02f, -8.09921697e-02f, -1.90824410e-03f,
  3.49666388e-03f, -5.98062538e-02f, -7.36534223e-02f, 7.36405626e-02f, -7.09750429e-02f, -2.79014856e-02f, -7.12827966e-02f, -1.29537717e-01f, 4.52690497e-02f, 2.17225209e-01f,
  1.37506530e-01f, -6.90715238e-02f, 7.10539985e-03f, 2.04303637e-01f, 2.29696885e-01f, -1.33491695e-01f, 1.85317025e-01f, 1.11143090e-01f, 1.52230352e-01f, 3.18605267e-02f,
  1.55424874e-03f, 1.14766151e-01f, -4.25965004e-02f, -6.86406717e-02f, -2.25682254e-03f, -2.92993430e-03f, 1.37888244e-03f, -3.47810984e-02f, -2.28930358e-02f, -4.81853113e-02f,
  9.41875651e-02f, 8.92381743e-02f, 1.80062447e-02f, -3.13366130e-02f, -7.10032647e-03f, 8.66261963e-03f, -2.67258473e-02f, -2.54856353e-03f, 4.77591790e-02f, -3.85810919e-02f,
  -7.13663995e-02f, 5.23948930e-02f, 4.20928858e-02f, -1.27943363e-02f, 9.96621773e-02f, -3.86624411e-02f, 7.43066147e-02f, 3.80945280e-02f, -2.29228195e-02f, -8.67214799e-02f,
  -3.89592275e-02f, -1.03969850e-01f, -5.74802384e-02f, -1.77217856e-01f, 1.27975950e-02f, -3.64674767e-03f, 4.52031866e-02f, 1.91659145e-02f, -1.89255998e-02f, -2.42693126e-02f,
  3.94799784e-02f, -1.41317144e-01f, 1.14379451e-01f, -2.86787841e-03f, -8.49540159e-02f, 1.63154583e-02f, -1.36464134e-01f, -1.67346835e-01f, 7.97758065e-03f, 1.72717631e-01f,
  5.09692617e-02f, -1.31067216e-01f, -1.98454484e-01f, 5.31997159e-02f, 1.55907962e-02f, -1.39306188e-01f, 1.21959940e-01f, 2.37252973e-02f, 1.33069688e-02f, -8.87868777e-02f,
  -3.77150685e-01f, -1.08777583e-01f, 2.83132672e-01f, -2.69914865e-01f, 5.98577745e-02f, 7.56009761e-03f, -1.09364107e-01f, -1.75018564e-01f, -2.87142247e-01f, -1.85077578e-01f,
  6.06359281e-02f, -1.56847332e-02f, -3.17003876e-02f, -1.76427681e-02f, -9.48987808e-03f, -1.50583923e-01f, 9.29204747e-02f, 5.92198521e-02f, 7.13407248e-02f, 9.90194082e-03f,
  -2.31230576e-02f, -7.33661130e-02f, 8.65977556e-02f, 2.03858856e-02f, -9.85253230e-02f, 5.40551730e-02f, 3.09879445e-02f, 3.14189866e-02f, -2.43531279e-02f, -1.38146728e-01f,
  -4.85539548e-02f, -1.73189566e-01f, 2.81771868e-02f, 1.00757755e-01f, 1.76570266e-01f, -1.58635631e-01f, -1.32994419e-02f, -8.79639611e-02f, 2.81502288e-02f, -5.22276014e-02f,
  -2.43665278e-02f, 3.90014313e-02f, -7.96686858e-02f, -1.22052319e-01f, 7.47093791e-03f, -1.63707491e-02f, 4.75669913e-02f, 4.45738696e-02f, -2.67268550e-02f, -9.83586386e-02f,
  1.82773601e-02f, -5.86718135e-02f, -2.01991312e-02f, -5.23064397e-02f, -1.49371088e-01f, 5.43591976e-02f, -1.45201206e-01f, -1.61806151e-01f, 8.22222419e-03f, -3.77664387e-01f,
  1.09291613e-01f, 1.73412208e-02f, -1.80332288e-02f, 6.59079477e-02f, -6.59903437e-02f, 2.32482422e-02f, -1.84945646e-03f, 7.84015059e-02f, -3.10618617e-02f, -5.82300462e-02f,
  3.61313336e-02f, -3.01522799e-02f, 2.42776331e-02f, -8.54383260e-02f, -1.94095243e-02f, 2.38101762e-02f, 2.94136666e-02f, -4.18829694e-02f, -1.51579734e-02f, -1.65098030e-02f,
  -1.77942645e-02f, 5.04355356e-02f, 2.13380624e-02f, 2.12074872e-02f, 4.45643440e-02f, 5.01778014e-02f, 3.87562588e-02f, -5.16061746e-02f, 1.29223997e-02f, 3.16774175e-02f,
  -1.59111023e-01f, 4.75278437e-01f, -3.14843595e-01f, -8.54049847e-02f, -3.66065316e-02f, 4.48048450e-02f, 2.70841848e-02f, 4.03508320e-02f, -8.24470371e-02f, -7.29167089e-02f,
  3.97070944e-02f, -6.05398864e-02f, -2.90565994e-02f, 2.38559265e-02f, -4.88800816e-02f, -1.25140637e-01f, -2.26443540e-02f, -6.63381070e-02f, -9.94667336e-02f, 1.44720869e-03f,
  9.86844953e-03f, -1.98918238e-01f, -2.80350775e-01f, -1.67933464e-01f, -2.04184607e-01f, -1.32997319e-01f, -1.34238198e-01f, -3.04993272e-01f, -1.62956655e-01f, -4.26957667e-01f,
  -8.58339846e-01f, -1.52338624e-01f, -1.67583302e-01f, -3.08505118e-01f, 1.04900531e-01f, 2.91046560e-01f, 4.39129055e-01f, 2.39476487e-01f, 5.63658588e-02f, 1.47546818e-02f,
  -6.75440133e-02f, -1.54456392e-01f, -1.73886493e-01f, 8.95706564e-02f, 1.62058368e-01f, 2.93897986e-01f, 2.08307132e-01f, -9.98016000e-02f, 2.37650387e-02f, 1.53733566e-01f,
  6.60513341e-02f, -1.45077571e-01f, -4.46596056e-01f, -1.07344590e-01f, 1.02913687e-02f, -6.41343296e-02f, -1.44370034e-01f, -9.82224569e-02f, -6.84377365e-03f, 3.01983394e-02f,
  -3.81058246e-01f, -2.03375682e-01f, 7.06195235e-02f, -6.44050422e-04f, -1.13684304e-01f, -4.21575084e-02f, -6.13918081e-02f, -1.53887823e-01f, 2.08445266e-02f, -6.57478869e-02f,
  -6.38449043e-02f, -1.98799893e-02f, 4.99078073e-02f, 5.58875576e-02f, -7.80094862e-02f, -9.46953718e-04f, -4.81748730e-02f, -4.14314568e-02f, -4.60305847e-02f, -4.29945886e-02f,
  1.77497834e-01f, -5.70303909e-02f, -2.30677351e-01f, 2.19832342e-02f, 1.49539877e-02f, -9.52573568e-02f, -1.36723429e-01f, 1.86079107e-02f, -1.04642965e-01f, -1.92971364e-01f,
  4.26731221e-02f, -5.48851900e-02f, 1.03421040e-01f, 1.58914793e-02f, -1.51120508e-02f, -1.44065833e-02f, 9.28103179e-02f, -1.57613810e-02f, 6.68730363e-02f, -7.28435442e-02f,
  -6.95852377e-03f, 3.49295093e-03f, -4.10729125e-02f, -4.66525666e-02f, -4.01159329e-03f, 3.82398143e-02f, 5.56583889e-02f, -3.78026627e-02f, 2.22258959e-02f, 1.35856429e-02f,
  -8.47030282e-02f, 6.82707950e-02f, -8.61767307e-02f, -1.07162409e-02f, 9.15536955e-02f, -3.93926958e-03f, 1.40302051e-02f, 4.08639573e-02f, -2.90593598e-02f, -3.53557244e-02f,
  -3.74193847e-01f, 1.27515732e-03f, -3.32883559e-02f, -1.44350147e-02f, -2.67073829e-02f, -7.85635710e-02f, -7.73564279e-02f, -6.91382289e-02f, -1.49546027e-01f, 5.66463266e-03f,
  -3.56338397e-02f, -2.98951268e-02f, -1.26853168e-01f, 1.49328485e-01f, 6.75907708e-04f, 1.90021340e-02f, -6.37734309e-02f, -7.69907609e-02f, 6.00742362e-02f, 1.83835644e-02f,
  6.98053315e-02f, -5.14094867e-02f, -2.74814844e-01f, 3.55103984e-02f, -3.15721482e-02f, -1.26342773e-01f, -1.64293513e-01f, -1.36399940e-01f, -1.22338012e-01f, -2.26854339e-01f,
  2.60201752e-01f, 1.37337863e-01f, -3.33344787e-01f, -3.97170275e-01f, -3.98035020e-01f, -3.46966773e-01f, -1.70253500e-01f, -1.77456245e-01f, -1.04175970e-01f, 9.13588107e-02f,
  1.97578877e-01f, 5.18962026e-01f, 4.06322271e-01f, 2.85453498e-01f, 2.99140930e-01f, -1.33964613e-01f, -2.62071311e-01f, 1.83350444e-02f, 2.70405024e-01f, 1.37083784e-01f,
  7.52526661e-03f, 1.34319104e-02f, 1.64934210e-02f, -9.98958871e-02f, -1.30735993e-01f, 1.22882083e-01f, -1.89773694e-01f, -1.68379128e-01f, -3.88505235e-02f, -1.68398887e-01f,
  5.17838120e-01f, -3.94173682e-01f, 7.47074634e-02f, 1.60394888e-02f, -1.29630491e-01f, -3.10527328e-02f, -1.93418637e-02f, -1.61212549e-01f, -9.33852047e-02f, -1.65381283e-01f,
  -7.17336386e-02f, 1.44069800e-02f, -4.69016172e-02f, -6.49632365e-02f, -5.23692146e-02f, -3.06247510e-02f, -1.13890216e-01f, -1.84347913e-01f, -1.43312931e-01f, 4.26331833e-02f,
  8.66986290e-02f, -1.14719354e-01f, -9.89093632e-02f, -4.81269360e-02f, -2.85055906e-01f, 2.33209003e-02f, -8.30765739e-02f, -2.61224240e-01f, -2.00814411e-01f, -1.64783802e-02f,
  6.20220900e-02f, 9.20538679e-02f, 2.57400014e-02f, 2.69606803e-02f, 9.95704830e-02f, -1.93713829e-02f, -6.87113823e-03f, 1.01340160e-01f, -3.13281044e-02f, 2.14649495e-02f,
  2.19609197e-02f, -3.46290767e-02f, 7.57964700e-03f, 1.38823362e-02f, -3.27639803e-02f, -7.80095235e-02f, 1.98910255e-02f, 7.10513368e-02f, 2.34726183e-02f, -2.57653724e-02f,
  -1.16171837e-02f, -8.28120410e-02f, -1.10889405e-01f, 5.38949594e-02f, -7.44325370e-02f, -3.16180959e-02f, 3.33552510e-02f, 9.23779160e-02f, 4.32767272e-02f, -8.93788710e-02f,
  3.61804634e-01f, -9.99291241e-02f, 1.83907136e-01f, 1.14529468e-01f, -1.85877606e-01f, -7.37781301e-02f, 2.54979208e-02f, -6.01405650e-02f, -1.43687218e-01f, -9.15545411e-03f,
  -1.45074045e-02f, -1.92578696e-02f, 7.49378726e-02f, -6.47071302e-02f, 3.45886946e-02f, 6.86332630e-03f, -1.67181250e-02f, 5.58107160e-02f, -6.47687837e-02f, -1.98717229e-02f,
  -1.09507158e-01f, 1.09186076e-01f, 3.86978060e-01f, 1.39510229e-01f, -1.08841188e-01f, 2.09048048e-01f, 2.56759584e-01f, 1.38429150e-01f, 2.28356615e-01f, 3.41520518e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  3.27807307e-01f, 1.97187766e-01f, 7.12865829e-01f, 6.97743177e-01f, 1.12080157e-01f, 3.35702926e-01f, 4.07249629e-01f, 5.21581769e-02f, 4.71188635e-01f, 5.23692012e-01f,
  4.89638001e-01f, 3.32433045e-01f, 2.13527367e-01f, 7.13955104e-01f
};

// L1_linear_W (Shape: 12 x 16)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 16;
const float L1_linear_W_data[] = {
  -1.16498446e+00f, -4.93456088e-02f, 1.20403677e-01f, 9.20957506e-01f, -7.37285912e-01f, -8.03778041e-03f, -2.85279185e-01f, -5.77516891e-02f, 1.22396193e-01f, 9.78757367e-02f,
  -6.28763111e-03f, 8.61271620e-01f, -5.77864759e-02f, 3.30039412e-02f, 2.90041775e-01f, -2.04751968e-01f, 2.23744020e-01f, 4.95410383e-01f, -4.79548365e-01f, 7.81206727e-01f,
  -2.64705032e-01f, 9.80744720e-01f, 6.07367456e-01f, -5.23439646e-01f, -6.27203584e-01f, 1.65339276e-01f, -5.68077028e-01f, -3.47175859e-02f, -7.79443622e-01f, -2.72589594e-01f,
  -3.34769994e-01f, 8.11502337e-01f, 2.17482582e-01f, 3.90942216e-01f, 9.40659702e-01f, -3.95994037e-01f, -3.83532256e-01f, 3.43155056e-01f, -4.91743416e-01f, 8.57076108e-01f,
  -3.82195890e-01f, 2.69901082e-02f, -5.36080897e-01f, -4.25619453e-01f, -7.12852031e-02f, 8.54829311e-01f, -8.09853226e-02f, -2.31573030e-01f, 2.49928698e-01f, 3.59802336e-01f,
  -5.43955639e-02f, -3.78730476e-01f, -9.16271269e-01f, -7.52915293e-02f, -3.28570396e-01f, -2.28770752e-03f, -3.33699316e-01f, -3.91620696e-01f, 4.52406734e-01f, -9.29667428e-02f,
  1.33303273e+00f, 4.65839744e-01f, 9.46345270e-01f, -2.90311813e-01f, -1.41518027e-01f, 6.21565223e-01f, 2.53806263e-02f, 1.71180546e-01f, 1.04710507e+00f, -4.22502726e-01f,
  1.55097887e-01f, -3.42435807e-01f, -1.56242847e-01f, -2.77860194e-01f, 1.12939458e-02f, 2.56028175e-01f, 1.00197089e+00f, -1.88786518e-02f, -1.72810152e-01f, -6.10113382e-01f,
  5.54667711e-01f, 3.34924191e-01f, -4.15217698e-01f, 7.83437639e-02f, 3.01053435e-01f, -1.80885628e-01f, 1.39073655e-01f, -4.94424790e-01f, 1.15054679e+00f, -2.21511319e-01f,
  -3.72938327e-02f, 1.28612196e+00f, -4.33496326e-01f, -3.49181086e-01f, -5.20846903e-01f, 4.05826211e-01f, 5.08014083e-01f, 2.02854708e-01f, -7.53247142e-01f, -5.42263567e-01f,
  8.79772067e-01f, -5.44581950e-01f, 3.90752345e-01f, 1.28665626e+00f, -8.57501477e-02f, 3.06308046e-02f, -2.29406953e-01f, -3.79066408e-01f, -4.76932108e-01f, -5.43556988e-01f,
  -6.61665723e-02f, -1.91616848e-01f, -1.76750064e-01f, -3.55743438e-01f, 4.29888010e-01f, -4.43154991e-01f, -4.91695970e-01f, -1.51943684e-01f, 4.07511353e-01f, -1.06561497e-01f,
  1.37800708e-01f, 5.43395042e-01f, 2.34597102e-01f, 4.53622699e-01f, -3.92563939e-01f, 4.87213880e-02f, 9.88970876e-01f, -4.38924193e-01f, -6.95086420e-01f, -9.12457705e-01f,
  -3.44819009e-01f, -2.87005156e-01f, -2.35308513e-01f, 1.42065752e+00f, -1.97484151e-01f, -2.43031919e-01f, 5.47353804e-01f, -2.90768057e-01f, 1.11901142e-01f, -5.93241811e-01f,
  -3.98356676e-01f, -2.63113707e-01f, 1.24626167e-01f, -1.07778020e-01f, 1.14590162e-02f, 3.62218708e-01f, 6.38465762e-01f, -2.68545330e-01f, 1.24416530e+00f, -1.52635023e-01f,
  -2.66501963e-01f, -4.17585403e-01f, 6.67362614e-03f, 9.54365790e-01f, 2.39804551e-01f, -5.10460913e-01f, -2.35132411e-01f, 1.03235438e-01f, -2.83894092e-01f, 1.59758791e-01f,
  2.31331587e-01f, -7.00794220e-01f, -3.07137430e-01f, 4.09996808e-01f, -3.32391858e-01f, -5.04690289e-01f, -2.74904221e-01f, -8.69439244e-02f, 9.64016188e-03f, 2.92246602e-02f,
  -2.34635741e-01f, -5.81347287e-01f, 5.77282429e-01f, -3.57036173e-01f, -3.50768358e-01f, 1.32850862e+00f, 1.20181171e-02f, -9.13539231e-01f, -3.21005434e-01f, -4.76738930e-01f,
  1.33570731e-01f, -4.19311315e-01f, 3.53408575e-01f, 1.77999854e-01f, 4.09109816e-02f, -5.78651726e-01f, 1.43453157e+00f, -4.06381965e-01f, 2.05168664e-01f, 2.14476496e-01f,
  -2.01608315e-01f, -4.66709197e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -4.88494933e-01f, 5.52448750e-01f, 4.74171549e-01f, -2.43696004e-01f, -7.26995692e-02f, 5.61092019e-01f, -1.37966856e-01f, -2.58958489e-01f, 3.61444354e-01f, -2.11010516e-01f,
  -2.27435023e-01f, 2.71838099e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 1, 14
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        16, 12
    );
    }
    