/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -1.19677231e-01f, 2.77782977e-01f, 4.13131155e-02f, 1.79149151e-01f, -7.27352872e-02f, 2.94425040e-01f, 2.71255255e-01f, 2.36227307e-02f, 3.07391942e-01f, 1.58789575e-01f,
  5.48313670e-02f, 9.04879496e-02f, 1.48332074e-01f, 2.83582211e-01f, 1.92196310e-01f, 2.95059174e-01f, 7.79998228e-02f, 8.85258317e-02f, 1.34313591e-02f, -7.48298168e-02f,
  4.99752872e-02f, 3.48094165e-01f, 3.32469679e-02f, 5.69044091e-02f, -1.87686086e-01f, -1.48022892e-02f, -6.56144246e-02f, -1.35635540e-01f, -4.97233383e-02f, -5.46834012e-03f,
  4.01477702e-03f, 1.31774083e-01f, -8.54213312e-02f, 1.03470638e-01f, 7.48274475e-02f, -8.00052732e-02f, -5.79081811e-02f, -4.35726643e-02f, -9.81540605e-03f, 3.17655802e-02f,
  -2.64178365e-02f, 2.30939295e-02f, 5.70515022e-02f, 1.12179652e-01f, 6.66733682e-02f, -3.76367196e-02f, 1.41741866e-02f, -4.69671264e-02f, -1.40854577e-02f, 4.21224274e-02f,
  -1.81063544e-02f, -6.83427453e-02f, -1.35361170e-02f, -4.75092456e-02f, -3.86063084e-02f, -1.19762886e-02f, -1.83618087e-02f, -3.58137004e-02f, -7.56689832e-02f, 3.50263380e-02f,
  5.39292246e-02f, -2.13650353e-02f, 5.70067503e-02f, -8.92396569e-02f, 6.91704154e-02f, -8.35408866e-02f, 1.80368498e-02f, 4.52785529e-02f, -7.41199329e-02f, 4.96602952e-02f,
  -7.60201141e-02f, 5.17256707e-02f, -2.53029279e-02f, 3.54691371e-02f, 4.28720936e-02f, -3.74253392e-02f, 3.71066816e-02f, -4.24014963e-02f, -6.22292142e-03f, -9.46966112e-02f,
  -3.30087095e-02f, -7.65045686e-03f, 2.03242116e-02f, -6.05618916e-02f, -3.55891092e-03f, 7.53652025e-03f, 7.33763054e-02f, -3.84964123e-02f, -2.56560445e-02f, 5.97734749e-02f,
  2.52849758e-01f, 2.24592969e-01f, 6.82257786e-02f, -3.91329639e-02f, 4.95841308e-03f, -3.64913754e-02f, 1.30892862e-02f, 8.19686055e-02f, -3.71898301e-02f, 1.93421133e-02f,
  -5.01765609e-02f, -1.16952863e-02f, 9.84745938e-03f, -1.33459926e-01f, -3.45295854e-02f, 6.40438199e-02f, 2.97730020e-03f, -5.79789169e-02f, -8.80424306e-02f, -4.70891446e-02f,
  2.03861855e-02f, -1.09662488e-02f, -6.41376078e-02f, 1.82040017e-02f, 6.01371066e-05f, -2.56688539e-02f, -2.18978719e-04f, -3.10992245e-02f, 1.58560369e-02f, 6.47805631e-02f,
  -2.51260251e-01f, 3.74972939e-01f, 1.82941601e-01f, -2.47784287e-01f, -5.32543175e-02f, -7.43504837e-02f, -2.18674242e-01f, 1.25926301e-01f, -6.32202625e-02f, 1.61729723e-01f,
  -9.85910222e-02f, 6.18777089e-02f, -1.32991991e-04f, 1.27970148e-02f, -3.83396208e-01f, -5.75709976e-02f, -1.82367399e-01f, -2.73075923e-02f, 3.36902402e-02f, -3.76668349e-02f,
  -9.55754742e-02f, -1.90979853e-01f, 6.14266284e-02f, 1.79513738e-01f, 5.70780970e-02f, 1.19148865e-01f, -1.37794882e-01f, 9.00061801e-02f, -6.06839405e-03f, -2.37775762e-02f,
  1.17999718e-01f, 1.41344577e-01f, 1.20940626e-01f, 6.58472925e-02f, -2.32344605e-02f, -2.41097528e-02f, -6.86610863e-02f, -3.15075479e-02f, -1.26039498e-02f, -5.45574911e-03f,
  -3.21512036e-02f, -1.14498585e-02f, -6.65733963e-02f, 5.72206266e-03f, -1.93343952e-03f, 5.76799437e-02f, 1.89679861e-02f, 3.34843695e-02f, 3.67328562e-02f, 4.42670919e-02f,
  2.95293629e-02f, 1.03013739e-02f, -9.55078658e-03f, -9.86076519e-02f, -2.16870625e-02f, 4.48913360e-03f, -4.13382426e-02f, 4.27407138e-02f, -1.23157762e-02f, -5.24440408e-02f,
  -3.80736627e-02f, -2.44634468e-02f, 1.06860762e-02f, 4.13436368e-02f, -2.87988428e-02f, 2.73038540e-02f, -5.34869470e-02f, -3.78015568e-03f, 2.17264071e-02f, -2.57024094e-02f,
  3.99369895e-02f, 4.76255314e-03f, 1.88088771e-02f, -1.37660243e-02f, -2.02192683e-02f, 7.01296628e-02f, -6.70516193e-02f, 3.64791714e-02f, -2.24396437e-02f, 7.28506921e-03f,
  1.75581016e-02f, -5.89518249e-02f, 3.65240835e-02f, -4.23997194e-02f, -4.34444798e-03f, -1.54204890e-02f, 1.69590507e-02f, 3.41351815e-02f, -4.30924706e-02f, -4.65804189e-02f,
  -1.79279491e-01f, -1.51923686e-01f, -6.04168372e-03f, 5.95632568e-03f, -7.42543489e-03f, 2.33212411e-02f, 1.26476362e-02f, 1.42952092e-02f, -2.11061779e-02f, -1.14115486e-02f,
  1.33871450e-03f, 4.30564815e-03f, 1.71132525e-03f, -2.19017155e-02f, 7.61692785e-03f, -5.70339970e-02f, -3.81394774e-02f, -3.26658972e-02f, -3.45280990e-02f, -3.82955279e-03f,
  -7.76045164e-03f, -3.18732932e-02f, -3.52675579e-02f, 7.35998303e-02f, -4.35703695e-02f, -2.88793538e-02f, -3.48334424e-02f, -1.49891814e-02f, -2.84736753e-02f, 2.03787442e-03f,
  4.69216198e-01f, -1.90196812e-01f, 1.25665724e-01f, 4.32014287e-01f, 9.68122557e-02f, -4.24982250e-01f, 2.44971171e-01f, -6.64622709e-02f, 1.20772459e-01f, -2.12119028e-01f,
  1.19389609e-01f, -4.39568087e-02f, 1.19383775e-01f, -1.48937762e-01f, 2.12591454e-01f, 9.37067792e-02f, 6.42773788e-03f, -1.84970945e-02f, -9.76642072e-02f, -1.04585197e-02f,
  -4.38918807e-02f, 4.52291081e-03f, 9.82998908e-02f, -1.45779997e-01f, 7.72310644e-02f, 4.21429090e-02f, 5.37729561e-02f, 7.64712244e-02f, -2.09076673e-01f, 4.92825136e-02f,
  -9.57763344e-02f, 1.53096184e-01f, 3.49271931e-02f, -1.68998897e-01f, 5.66202477e-02f, -3.33112404e-02f, -1.22280993e-01f, -3.24937478e-02f, 2.21211631e-02f, 1.35952430e-02f,
  5.03019728e-02f, 2.83796079e-02f, -3.33284922e-02f, -2.43449491e-02f, 4.73154197e-03f, 4.68246192e-02f, 4.79158722e-02f, 2.00107228e-02f, 3.49135771e-02f, 1.84417013e-02f,
  -9.31928027e-03f, -2.09365296e-03f, 3.27067263e-02f, -9.10066739e-02f, -5.61521985e-02f, 3.06760278e-02f, -1.23477979e-02f, 6.61772639e-02f, -5.12895472e-02f, 1.56507138e-02f,
  -3.41027901e-02f, 3.44852731e-02f, 1.21016994e-01f, 1.59582011e-02f, 6.79106712e-02f, -5.35541736e-02f, 8.57365280e-02f, -3.42034139e-02f, 6.50793985e-02f, -1.73531212e-02f,
  1.53155595e-01f, 6.43165931e-02f, 1.45750241e-02f, -5.85905686e-02f, 4.04003970e-02f, -4.24294658e-02f, 5.25268773e-03f, -2.10807659e-02f, -1.70988906e-02f, -2.96044193e-04f,
  -5.68685457e-02f, -4.24147770e-02f, 5.73974326e-02f, -1.57209169e-02f, 9.34265554e-03f, 4.97014150e-02f, -3.15170246e-03f, -1.49694448e-02f, -2.84986496e-02f, 3.76673532e-04f,
  -7.03355521e-02f, -1.26647055e-01f, -3.94735560e-02f, 7.34036565e-02f, -7.76871666e-02f, -2.78898310e-02f, 8.36898610e-02f, -8.03741291e-02f, -5.06921224e-02f, 1.62699670e-02f,
  -1.06210433e-01f, -3.72296646e-02f, 1.59106720e-02f, -9.49385762e-02f, -1.46976160e-02f, 4.24876576e-03f, -5.55881895e-02f, -1.58555396e-02f, -5.29475398e-02f, -2.09137369e-02f,
  -1.19726593e-02f, -4.42160368e-02f, 1.98969934e-02f, -3.25947776e-02f, -1.11479238e-01f, 3.52829620e-02f, -7.61619434e-02f, -1.24839805e-02f, -1.26285590e-02f, -5.01019657e-02f,
  1.02296554e-01f, -9.07169655e-03f, 2.51304954e-01f, -1.09469006e-02f, 6.21729530e-03f, -1.59252152e-01f, 7.68372044e-03f, 1.36764959e-01f, 4.04721290e-01f, -1.63171351e-01f,
  -1.80840120e-01f, 2.09422633e-01f, -1.73247475e-02f, -3.15578103e-01f, 2.76986450e-01f, -8.51380154e-02f, -2.36268327e-01f, 6.45544007e-03f, 1.96741968e-01f, -1.89956632e-02f,
  5.70359305e-02f, -2.25840822e-01f, -4.05015647e-02f, -4.06455472e-02f, -1.55659005e-01f, 9.32030529e-02f, -1.17414989e-01f, -4.14141716e-04f, -2.01753125e-01f, 1.09951524e-02f,
  -1.46750405e-01f, -7.51792267e-02f, -3.33839990e-02f, 4.74280789e-02f, -5.89104779e-02f, -1.12646837e-02f, -3.39824930e-02f, 2.75657661e-02f, 9.03311893e-02f, -3.42553183e-02f,
  1.17373895e-02f, 3.90828997e-02f, 5.69829717e-02f, -3.74133624e-02f, 1.79262497e-02f, 1.94222685e-02f, 1.27605665e-02f, -7.92227015e-02f, 3.50834318e-02f, -1.05903067e-01f,
  2.98206471e-02f, -3.77472490e-02f, -4.51112837e-02f, 6.44814074e-02f, 5.98586649e-02f, 5.02751488e-03f, 1.93733461e-02f, -8.35028514e-02f, 3.82160209e-02f, 4.33674194e-02f,
  -4.51838505e-03f, 2.02205852e-02f, -1.80767290e-02f, -4.90483083e-02f, -1.54731306e-03f, -4.22947146e-02f, -2.49872729e-02f, 1.29972566e-02f, 5.90209588e-02f, -2.36173831e-02f,
  -3.62614319e-02f, 2.23129634e-02f, 4.69682887e-02f, -1.11854002e-02f, -1.16107101e-02f, 4.12511714e-02f, -4.01843451e-02f, 2.18192544e-02f, 1.41570866e-02f, 2.54631080e-02f,
  2.89177354e-02f, -2.21616891e-03f, -7.54110739e-02f, -4.39447016e-02f, 1.16171204e-02f, 5.58977155e-03f, -1.15895960e-02f, -2.77676359e-02f, -2.74098571e-02f, 1.43452557e-02f,
  1.26627356e-01f, 3.18546593e-01f, 2.47256402e-02f, -3.35483029e-02f, 6.91238195e-02f, -2.58769412e-02f, 2.35788692e-02f, 2.72638798e-02f, 3.18293623e-03f, 2.38978732e-02f,
  -7.92078823e-02f, -3.09574809e-02f, -2.81172842e-02f, -2.58488469e-02f, 6.05061390e-02f, -1.28290318e-02f, -7.36637600e-03f, 9.52895507e-02f, -1.51062552e-02f, 5.72303822e-03f,
  -8.41299146e-02f, 4.52591218e-02f, 7.41119757e-02f, -2.55556814e-02f, -6.39273375e-02f, -2.91700214e-02f, 3.49814929e-02f, 6.81447312e-02f, -3.77796404e-02f, -2.47782934e-02f,
  -1.80498347e-01f, 2.53578931e-01f, -3.15265685e-01f, 3.88758361e-01f, -9.55860838e-02f, 8.02544132e-02f, 6.42352626e-02f, 9.54962298e-02f, 1.56374365e-01f, 1.60075128e-01f,
  8.49207267e-02f, -1.62681445e-01f, 1.19162880e-01f, 2.45060310e-01f, 1.08553089e-01f, 3.43521088e-01f, 2.76925921e-01f, 1.15714878e-01f, 7.47551993e-02f, 9.87673849e-02f,
  8.69238079e-02f, 1.49473473e-01f, 6.37020096e-02f, -9.76454525e-04f, 6.57844767e-02f, -1.21871255e-01f, 4.76955511e-02f, -1.80380210e-01f, 2.83663645e-02f, -7.07228333e-02f,
  -7.08505288e-02f, -5.36172278e-03f, -2.87079569e-02f, -1.03602529e-01f, -7.38720298e-02f, -1.24963950e-02f, -3.14427242e-02f, -1.28761068e-01f, -3.99544537e-02f, -7.02059316e-03f,
  -3.09756361e-02f, -1.04228586e-01f, 5.73135074e-03f, -7.81102777e-02f, -1.21458568e-01f, -7.03279749e-02f, 2.66445405e-03f, 3.22721526e-02f, 4.39371578e-02f, -3.17139216e-02f,
  8.88853967e-02f, -2.39430442e-02f, 7.85337985e-02f, 8.16723481e-02f, -2.67408602e-02f, 2.41443329e-02f, -3.85651775e-02f, -4.29897346e-02f, 9.43927541e-02f, 5.03071398e-02f,
  -5.30251712e-02f, -1.11446053e-01f, -3.77721228e-02f, 8.08039159e-02f, -4.72946838e-02f, 4.30526324e-02f, -1.61952397e-03f, -2.56412346e-02f, 1.69103127e-02f, 2.37227306e-02f,
  9.47862267e-02f, -3.44935469e-02f, 7.86131099e-02f, 9.60683916e-03f, -1.45199690e-02f, 9.94596854e-02f, -1.10299006e-01f, 5.57151809e-02f, 2.35304106e-02f, 1.36428788e-01f,
  6.16901815e-02f, 4.19298224e-02f, -2.12727580e-02f, 2.53299028e-02f, 3.12830657e-02f, -2.78309733e-02f, -6.32495880e-02f, -1.85116716e-02f, 9.22924001e-03f, -2.73527782e-02f,
  3.80497500e-02f, -1.37208194e-01f, -1.26727670e-02f, 5.64520806e-02f, 6.07309267e-02f, 5.78343049e-02f, 7.63818100e-02f, -3.38057801e-02f, 5.65609299e-02f, 7.32794330e-02f,
  -3.65970917e-02f, -1.70311984e-02f, -5.96856065e-02f, 1.22082522e-02f, 8.87333006e-02f, 6.62186295e-02f, -6.37196563e-03f, 1.87723860e-02f, 6.45036474e-02f, -5.83832450e-02f,
  -6.12285249e-02f, 3.66271250e-02f, -2.09581461e-02f, 2.67150514e-02f, 1.35440826e-02f, 2.71969680e-02f, 7.55802244e-02f, -2.61350386e-02f, -4.89925891e-02f, -2.09904313e-02f,
  4.53322232e-02f, -1.99870676e-01f, 2.18966171e-01f, -1.86053757e-02f, 8.16993043e-02f, 1.13646224e-01f, -1.29549652e-01f, 1.18044235e-01f, 7.75563717e-02f, -2.93817699e-01f,
  -2.35471055e-02f, -1.14247344e-01f, -1.69319019e-01f, 1.19389139e-01f, -2.08033353e-01f, -8.40018392e-02f, 2.12463904e-02f, -6.60274178e-02f, 1.53211966e-01f, -8.80880207e-02f,
  7.37474114e-02f, -3.77973430e-02f, 9.15606469e-02f, 1.11758627e-01f, -3.55246142e-02f, 3.43957432e-02f, -3.00173074e-01f, 7.77700469e-02f, -2.31036562e-02f, 6.59041256e-02f,
  1.29127726e-01f, 8.23023915e-02f, 9.06886533e-02f, 6.63780700e-03f, -1.42135084e-01f, -8.32885951e-02f, -5.86449280e-02f, 6.19267002e-02f, 5.64067513e-02f, 7.03358576e-02f,
  -1.23346046e-01f, 2.95084789e-02f, 4.81159650e-02f, 1.22623779e-01f, 5.28038330e-02f, 7.26334825e-02f, 6.24307953e-02f, 8.81105363e-02f, 4.59844843e-02f, 6.52784556e-02f,
  1.13190934e-01f, 8.77767578e-02f, 1.74785368e-02f, -3.32180187e-02f, 2.74108127e-02f, 6.42790124e-02f, 1.95537377e-02f, -2.00540349e-02f, -1.77865699e-02f, 3.29578444e-02f,
  4.37014028e-02f, -4.22980823e-02f, -1.49147008e-02f, 7.00758945e-04f, -2.79305857e-02f, 8.06188881e-02f, -2.35579349e-02f, 2.16954071e-02f, -3.76033364e-03f, -4.49885204e-02f,
  -7.53060207e-02f, -6.99606631e-03f, -4.21339733e-04f, -5.78175439e-03f, -1.77856945e-02f, -4.92950864e-02f, 4.45331680e-03f, 1.19846771e-02f, -2.19714381e-02f, 8.32007602e-02f,
  -2.03468762e-02f, -4.06801701e-03f, -5.47654480e-02f, 4.41092663e-02f, 3.79533768e-02f, -2.18828190e-02f, -4.51172516e-02f, 4.57107648e-02f, 6.92633539e-03f, -3.75006674e-03f,
  -4.19396669e-01f, -4.57088053e-01f, -5.33527955e-02f, 5.30878408e-03f, 4.49593663e-02f, 1.69031657e-02f, 2.13516969e-02f, 1.81494709e-02f, -9.43027958e-02f, -6.36103302e-02f,
  2.12503988e-02f, 1.88737866e-02f, -1.13861732e-01f, 8.53610691e-03f, -3.28427367e-02f, -6.07934818e-02f, -7.65239522e-02f, -1.28652126e-01f, -1.07799307e-01f, -6.60146996e-02f,
  -5.05128801e-02f, -8.62878263e-02f, 2.08243616e-02f, 2.16381811e-02f, -2.98495218e-03f, -6.12612851e-02f, -4.31962758e-02f, 1.91335287e-02f, 3.80433921e-04f, -7.54796946e-03f
};

// L0_fan_Wp_bar (Shape: 4 x 120)
const int L0_fan_Wp_bar_rows = 4;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -7.79849827e-01f, -1.55389413e-01f, -6.58989489e-01f, -2.69422799e-01f, -6.90561831e-02f, -1.10778809e+00f, -4.12811279e-01f, 4.53918725e-02f, -1.65003538e-01f, 4.32272106e-01f,
  2.68831670e-01f, -3.23451161e-01f, 5.22318661e-01f, -1.87915191e-01f, -7.15107083e-01f, 2.25659087e-01f, -5.48579156e-01f, -6.78904280e-02f, -3.11985631e-02f, 2.81571392e-02f,
  -2.12402016e-01f, 1.97545260e-01f, -2.84165591e-01f, 3.25739741e-01f, -3.68427485e-01f, 3.14370766e-02f, 7.31426060e-01f, 9.70432758e-02f, -6.47770986e-02f, -8.45800415e-02f,
  -1.85080886e-01f, 2.67478466e-01f, -9.75276306e-02f, -5.11710756e-02f, -1.17711835e-01f, 3.83657254e-02f, -1.39282867e-02f, -7.12975413e-02f, -5.73347509e-02f, -1.25998765e-01f,
  -3.37171182e-02f, 7.00440258e-02f, -4.45247106e-02f, 4.52964939e-02f, -1.21205278e-01f, -3.44388559e-03f, -1.31865397e-01f, -2.12449744e-01f, -1.02648139e-01f, -2.48524696e-01f,
  -2.48679668e-01f, -8.46975818e-02f, 1.42015107e-02f, 8.18476900e-02f, -1.17790729e-01f, 1.29581569e-02f, 2.90189907e-02f, -9.33093727e-02f, -4.08637747e-02f, 1.04724802e-02f,
  -2.60059396e-03f, -8.32099840e-03f, 4.22448143e-02f, -3.95459458e-02f, -2.97567900e-02f, -3.57531081e-03f, 2.91940458e-02f, 9.74627808e-02f, 9.60488431e-03f, 9.36128292e-03f,
  -2.54100817e-03f, -8.20502490e-02f, 4.37596366e-02f, -1.32335545e-02f, -4.72310185e-02f, 6.89424947e-02f, 4.08542752e-02f, 1.01252563e-01f, -1.56069666e-01f, -1.48492351e-01f,
  1.66203335e-01f, 3.28331329e-02f, 7.35682845e-02f, -2.11554654e-02f, -9.77402925e-03f, 4.49152775e-02f, -3.04000564e-02f, -5.04989512e-02f, 2.67702015e-03f, -4.44744267e-02f,
  9.41004083e-02f, 2.00779825e-01f, -8.22906196e-03f, -3.19532268e-02f, 2.48000119e-02f, -1.48468748e-01f, -9.42024291e-02f, -5.39060123e-02f, -2.19856314e-02f, 6.12925366e-02f,
  9.04032290e-02f, 2.15255897e-02f, -5.54677332e-03f, -8.88931826e-02f, 2.32396200e-02f, -1.42938681e-02f, 1.93809226e-01f, 6.60408959e-02f, 7.42498860e-02f, 9.79948044e-02f,
  1.22750930e-01f, 5.76497279e-02f, -6.43513678e-03f, -1.05576664e-01f, 1.33881541e-02f, 7.22395331e-02f, -1.07394107e-01f, 2.78342161e-02f, 7.03391060e-02f, 1.12237399e-02f,
  9.62399900e-01f, 6.06826127e-01f, 4.85175848e-01f, 6.62367582e-01f, 1.22068459e-02f, -3.38993669e-01f, -1.50537922e-03f, 1.65413275e-01f, 2.67596930e-01f, -1.05850898e-01f,
  -2.84200292e-02f, 2.76116699e-01f, 5.45520484e-02f, 1.93113923e-01f, -1.51619881e-01f, -1.40061095e-01f, 1.18320249e-01f, 6.75391629e-02f, 1.00173563e-01f, 2.31036499e-01f,
  2.94985026e-01f, -2.46857747e-01f, 1.71182871e-01f, -1.87787801e-01f, 2.17918441e-01f, 3.14743698e-01f, 3.68188769e-02f, -1.81163266e-01f, 1.80622026e-01f, -2.15879440e-01f,
  -9.97937173e-02f, 1.77163988e-01f, 1.80966213e-01f, -1.96606256e-02f, 3.43923643e-02f, 8.69976729e-03f, 2.30062846e-02f, -1.48650065e-01f, -1.61687471e-02f, -8.03078932e-04f,
  -5.90137951e-02f, -2.58221943e-02f, -2.83077117e-02f, -2.35812627e-02f, -1.65088789e-03f, 7.62032643e-02f, 7.26155341e-02f, 1.66040570e-01f, 9.98857617e-02f, 2.31044204e-03f,
  6.62931874e-02f, 7.53238052e-02f, 3.17424834e-02f, -1.93535648e-02f, 1.56962112e-01f, 1.34500340e-02f, -3.04056015e-02f, 9.34380293e-02f, 1.22553058e-01f, 2.62766872e-02f,
  -4.99126613e-02f, -4.08720635e-02f, -2.34011970e-02f, -2.45893095e-02f, 3.28161791e-02f, 2.33690199e-02f, 1.22714471e-02f, -1.53712882e-02f, -3.81616643e-03f, 2.10977159e-02f,
  2.18528919e-02f, 3.89496535e-02f, -1.49599528e-02f, 1.45326806e-02f, -6.19414225e-02f, 3.26782912e-02f, 5.25006978e-03f, -8.91240686e-03f, 2.76558213e-02f, 5.52220419e-02f,
  1.14654796e-02f, -3.20610963e-02f, 2.68475339e-02f, -2.66540237e-02f, -4.21268642e-02f, -5.19544557e-02f, 5.76827414e-02f, 3.70532647e-02f, 5.14423847e-03f, -3.26285250e-02f,
  -1.51604980e-01f, -1.27393320e-01f, -2.64652576e-02f, 2.27441806e-02f, -8.82765725e-02f, 1.94994118e-02f, -2.76857018e-02f, 1.04219675e-01f, 3.57316546e-02f, -3.65471840e-02f,
  8.53937864e-02f, 1.20099280e-02f, -3.22440490e-02f, 2.68928707e-03f, -1.63880531e-02f, -4.46718521e-02f, 2.48198421e-03f, -1.01630889e-01f, -2.94593349e-02f, 3.10736988e-02f,
  5.37500791e-02f, -1.16568804e-01f, -3.82513851e-02f, 4.44036983e-02f, 7.25996271e-02f, -9.59290043e-02f, 9.97910798e-02f, -4.66135256e-02f, -5.09741083e-02f, -1.93813853e-02f,
  -3.92983705e-01f, -3.77813935e-01f, 6.72518509e-03f, -4.18591887e-01f, -1.58455640e-01f, -4.89915758e-01f, -1.43902704e-01f, -4.59764421e-01f, -2.28674367e-01f, -2.51984835e-01f,
  -2.97312587e-02f, 1.81918681e-01f, 5.71735680e-01f, -4.24061686e-01f, 8.42866063e-01f, 6.01945043e-01f, -5.33118486e-01f, -1.50646806e-01f, -4.45798188e-02f, -5.72741628e-01f,
  9.18932632e-02f, -3.41236204e-01f, 4.03172612e-01f, -4.23159033e-01f, -2.21792117e-01f, -3.05234820e-01f, 2.81001627e-01f, 4.82262783e-02f, -4.62999910e-01f, 5.10371961e-02f,
  -2.16119856e-01f, -3.13681006e-01f, -6.87361136e-02f, 6.89352751e-02f, -1.18978776e-01f, 9.09662992e-02f, 2.88815959e-03f, 1.54070705e-01f, -8.69718492e-02f, 5.95093109e-02f,
  3.68449022e-03f, -1.21481389e-01f, -1.32976815e-01f, 2.00849734e-02f, 3.99166020e-03f, -1.11763224e-01f, 6.62469566e-02f, -1.55071018e-03f, -4.28150967e-02f, 1.35608464e-01f,
  2.01787710e-01f, 2.68415790e-02f, -1.02963582e-01f, -6.65196124e-03f, 4.55431640e-02f, -2.63661236e-01f, -4.48256060e-02f, 1.68499991e-01f, -4.17314209e-02f, -1.61543444e-01f,
  -1.89072609e-01f, 3.25470120e-02f, 1.03948917e-02f, -3.82295027e-02f, -3.33431214e-02f, -7.51570389e-02f, -6.07748181e-02f, 2.34096311e-02f, -4.79586096e-03f, -1.47199824e-01f,
  -5.59119470e-02f, -6.00459576e-02f, -1.10729598e-01f, -8.73862654e-02f, -6.74657673e-02f, -4.11881022e-02f, 2.78869886e-02f, 2.44248863e-02f, -2.55531073e-02f, 4.09026258e-03f,
  6.42831475e-02f, -4.00132760e-02f, -3.17496620e-02f, 2.48629060e-02f, -8.10121819e-02f, 1.23696215e-01f, -4.31046709e-02f, -3.54178585e-02f, 3.00717205e-02f, 1.06308497e-01f,
  -1.80979207e-01f, -6.42609894e-01f, -9.22655687e-03f, -1.36246651e-01f, -1.91768596e-03f, -2.18114052e-02f, -5.07195145e-02f, -9.47431922e-02f, -6.24347068e-02f, -7.28739947e-02f,
  -1.04465850e-01f, 8.68856907e-02f, -1.08349413e-01f, -1.87713969e-02f, -3.29432189e-02f, -7.85905793e-02f, -4.39473800e-02f, -3.06914058e-02f, -4.80306782e-02f, -1.35726631e-01f,
  -9.18421894e-02f, 2.64563151e-02f, 5.33360764e-02f, -7.16171116e-02f, -4.40733321e-02f, 1.16032742e-01f, -3.84314768e-02f, -6.62481040e-02f, 4.60322388e-02f, -5.08523732e-03f,
  3.43865782e-01f, -8.29692632e-02f, -1.84693113e-01f, 8.15123320e-02f, 3.39872032e-01f, -1.70974582e-01f, -8.59959602e-01f, 6.14560187e-01f, -4.35589701e-01f, -1.41176790e-01f,
  3.05418521e-01f, -1.83544099e-01f, -2.33494624e-01f, 1.82529092e-01f, 5.69200814e-01f, -5.60463130e-01f, 4.30972219e-01f, -4.60760407e-02f, -1.40345126e-01f, 3.67085427e-01f,
  1.87145352e-01f, 7.34840155e-01f, 2.54152149e-01f, 7.33718634e-01f, 3.00589830e-01f, 4.08385664e-01f, 9.23123360e-01f, 7.91929886e-02f, 5.51811695e-01f, 3.03267866e-01f,
  -6.53271824e-02f, -3.55665013e-02f, 3.63746397e-02f, -1.43929794e-01f, 1.50945321e-01f, 5.69834039e-02f, -7.04043135e-02f, 7.17800930e-02f, -6.69392273e-02f, -2.16808505e-02f,
  -1.40907750e-01f, 1.26093924e-01f, -1.63750425e-02f, 5.68546588e-03f, 2.33679148e-03f, 4.85443883e-02f, -8.66985098e-02f, 2.18601488e-02f, -2.18228146e-01f, -3.22596729e-02f,
  -1.84006244e-01f, -2.79419031e-02f, 4.80916910e-02f, -1.32420421e-01f, -2.82762721e-02f, 4.14387733e-02f, -1.11631393e-01f, -1.61418412e-02f, -4.02206257e-02f, 3.76342572e-02f,
  1.35069430e-01f, 1.72518883e-02f, 6.47265986e-02f, -8.70434940e-02f, 7.87876323e-02f, -9.52983797e-02f, 4.45516594e-02f, 6.33333698e-02f, 9.14780248e-04f, -2.06220318e-02f,
  -1.50830355e-02f, -8.36742371e-02f, -4.59998362e-02f, -3.96298282e-02f, -2.52459124e-02f, -2.19475459e-02f, -1.12314867e-02f, 5.00860177e-02f, -9.22649726e-02f, -9.98327136e-02f,
  -1.02754533e-01f, 7.48758987e-02f, -9.73619297e-02f, 2.76093930e-02f, -4.79422137e-02f, -6.30547553e-02f, 6.91497028e-02f, 3.07247341e-02f, -1.31763011e-01f, 7.35038519e-02f,
  3.60932350e-02f, 3.77389908e-01f, -4.90692966e-02f, 2.68359222e-02f, -1.47693813e-01f, 1.88596756e-03f, 6.46461453e-03f, 3.27367918e-03f, 1.24109108e-02f, -2.52130926e-02f,
  8.97756517e-02f, 4.87438776e-02f, 1.27399880e-02f, 5.16500808e-02f, -3.03913262e-02f, -5.27249426e-02f, 4.93665747e-02f, -1.46711003e-02f, 7.66825527e-02f, 1.73478961e-01f,
  8.96005258e-02f, -5.21321632e-02f, -3.10416277e-02f, 9.70029309e-02f, 6.17092587e-02f, 5.17137609e-02f, 9.76731479e-02f, -7.82879516e-02f, 1.40043959e-01f, -8.51986837e-03f
};

// L0_fan_Bp_bar (Shape: 1 x 4)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 4;
const float L0_fan_Bp_bar_data[] = {
  9.97809649e-01f, 1.68988854e-01f, 5.41610062e-01f, 6.91579163e-01f
};

// L1_fan_Wp (Shape: 6 x 16)
const int L1_fan_Wp_rows = 6;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  -2.63735592e-01f, 4.47385192e-01f, 1.17602497e-01f, 2.15723261e-01f, 3.72363299e-01f, -1.61169581e-02f, -3.20776433e-01f, 5.24065733e-01f, -2.22488955e-01f, 7.27149427e-01f,
  -3.03912401e-01f, -8.34664404e-01f, -2.69966274e-01f, 5.93417287e-01f, 1.84572145e-01f, -9.93769765e-02f, -5.05897820e-01f, 8.25938463e-01f, -2.88120657e-01f, -2.94365913e-01f,
  -1.43036917e-01f, -5.02478540e-01f, 7.30031669e-01f, -6.60716712e-01f, 4.01400864e-01f, 3.74973953e-01f, 5.54677129e-01f, -3.30721378e-01f, -1.69767380e-01f, 5.26958853e-02f,
  -3.29642780e-02f, 6.94672540e-02f, -1.90009013e-01f, 6.97519839e-01f, 4.74336535e-01f, -2.44734138e-01f, -4.10787672e-01f, 1.64228380e-02f, 3.43682677e-01f, -3.63882124e-01f,
  -3.18041176e-01f, -4.52407539e-01f, 1.48871262e-02f, -8.06671754e-02f, -2.16880128e-01f, -5.39861739e-01f, 3.10712188e-01f, -3.40095833e-02f, 3.01487088e-01f, 3.65564562e-02f,
  -8.08428228e-02f, 2.65290856e-01f, 5.62347591e-01f, -5.53589799e-02f, -5.84976636e-02f, -2.88077176e-01f, 1.74158633e-01f, 1.23507822e+00f, -7.85922259e-03f, 4.58287239e-01f,
  1.08203985e-01f, -6.16591215e-01f, 1.65647730e-01f, 1.09377474e-01f, -7.62223303e-02f, -6.41261041e-01f, 8.14299509e-02f, -3.85607064e-01f, 4.78064835e-01f, 2.10278198e-01f,
  6.38476685e-02f, 8.87238562e-01f, 6.13614321e-02f, 1.23636439e-01f, -6.94784939e-01f, 1.35866448e-01f, 6.57231081e-03f, 2.78793462e-02f, 3.36657882e-01f, -4.17409182e-01f,
  -6.50114045e-02f, 2.02701911e-01f, 4.39281994e-03f, 1.07891969e-01f, -3.99444345e-03f, -3.48025024e-01f, 6.96971655e-01f, 3.13830048e-01f, 2.69407213e-01f, 1.28522873e-01f,
  7.56800413e-01f, 1.96849525e-01f, -1.44107386e-01f, 4.98127460e-01f, -2.85853922e-01f, 2.68385023e-01f
};

// L1_fan_Wp_bar (Shape: 4 x 16)
const int L1_fan_Wp_bar_rows = 4;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  1.63973379e+00f, -3.23949158e-02f, 2.61786561e-02f, 8.70136976e-01f, 6.67368650e-01f, -1.76973090e-01f, -1.08268654e+00f, -1.23595677e-01f, 1.75893140e+00f, 3.74335378e-01f,
  -6.51402235e-01f, 1.61108649e+00f, 8.54214802e-02f, 1.12446618e+00f, 1.29329956e+00f, 1.20180929e+00f, 1.10073245e+00f, -1.74419954e-02f, 9.56377566e-01f, -2.67586142e-01f,
  -6.21798448e-02f, 2.51498133e-01f, 1.58984944e-01f, 2.36593676e+00f, -1.61306024e+00f, -6.46840632e-01f, 2.98423827e-01f, 3.40727091e-01f, 1.41962242e+00f, -1.27283752e+00f,
  5.81986606e-01f, -1.89985171e-01f, -4.92120594e-01f, 1.02853942e+00f, 7.42588222e-01f, -3.86106253e-01f, -6.42745554e-01f, 6.41254723e-01f, 6.59389555e-01f, -1.30503702e+00f,
  1.58986211e-01f, -2.15295836e-01f, -1.09910652e-01f, -1.45553339e+00f, 1.56755054e+00f, -1.78503141e-01f, 8.62535417e-01f, -1.94230154e-01f, -3.95719856e-01f, -8.07629153e-02f,
  2.84485877e-01f, 8.09784472e-01f, -5.50375760e-01f, 9.74230394e-02f, -1.38750315e+00f, -7.49772549e-01f, -3.63285512e-01f, -1.48938620e+00f, 3.32607441e-02f, -1.59670484e+00f,
  4.58241314e-01f, -5.30375123e-01f, -6.90873861e-01f, 1.67208815e+00f
};

// L1_fan_Bp_bar (Shape: 1 x 4)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 4;
const float L1_fan_Bp_bar_data[] = {
  4.69843566e-01f, 3.47967386e-01f, 7.22963512e-01f, 1.39479637e-01f
};

// L2_linear_W (Shape: 12 x 16)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 16;
const float L2_linear_W_data[] = {
  -2.15244830e-01f, 1.04375494e+00f, -1.21183372e+00f, -3.72847080e-01f, 5.27396262e-01f, 5.45039952e-01f, -1.52356899e+00f, 1.41811773e-01f, 1.08055973e+00f, -2.22518325e+00f,
  -5.87462246e-01f, 6.33701906e-02f, -1.68417823e+00f, 5.57723701e-01f, 8.72513831e-01f, -8.07557881e-01f, 1.37550563e-01f, 1.33418292e-01f, 1.31366611e-01f, -6.85073622e-03f,
  -1.65998471e+00f, 7.16812313e-02f, -7.73024559e-01f, 1.13873398e+00f, 1.27851903e+00f, -1.81709254e+00f, -1.19606219e-02f, 1.12225378e+00f, -8.80124032e-01f, -1.25016069e+00f,
  3.21805954e-01f, 9.49526966e-01f, -3.04056704e-01f, 1.47266239e-01f, 9.86189604e-01f, 2.97632273e-02f, -1.12166834e+00f, -3.38005275e-01f, -1.71094537e+00f, -9.95002806e-01f,
  2.76613146e-01f, 1.32041073e+00f, -3.31957728e-01f, 5.68642259e-01f, 3.63215536e-01f, -1.42961156e+00f, -2.17842269e+00f, 5.63097894e-01f, -1.03234269e-01f, -1.17136824e+00f,
  -1.17053652e+00f, -5.78980029e-01f, -6.04802072e-01f, -9.21395957e-01f, -1.83289015e+00f, 1.34997392e+00f, -1.79053295e+00f, 1.27349985e+00f, 1.88200033e+00f, -8.08934391e-01f,
  -7.41811574e-01f, 7.86361277e-01f, 2.57265091e-01f, -5.57478189e-01f, 6.47422075e-01f, 5.32192402e-02f, 8.75858247e-01f, -1.90611675e-01f, 2.61938006e-01f, 9.22622681e-01f,
  6.59374297e-01f, -1.49306178e+00f, 1.32369614e+00f, 1.28104794e+00f, 4.78403538e-01f, -2.92686690e-02f, 2.54717499e-01f, 1.11247408e+00f, -1.31781554e+00f, -6.43137693e-01f,
  8.71970594e-01f, 5.58916152e-01f, 1.09797204e+00f, 1.19304276e+00f, 7.50510752e-01f, 7.50847697e-01f, 1.92557847e+00f, 1.70062888e+00f, 1.10205150e+00f, 1.91126931e+00f,
  -1.13157642e+00f, 1.38937008e+00f, -1.00058818e+00f, -8.19232702e-01f, 8.82614315e-01f, -1.13333356e+00f, 5.92260778e-01f, 1.00499082e+00f, 4.52821374e-01f, 9.40518975e-01f,
  9.56635892e-01f, -3.84964973e-01f, 9.22821581e-01f, 1.72029638e+00f, -1.73930860e+00f, 1.09149170e+00f, -1.28453159e+00f, 1.46207440e+00f, 8.92143130e-01f, -1.70102966e+00f,
  -2.06552029e+00f, -1.19486344e+00f, -1.63435328e+00f, 1.23369940e-01f, -5.80761850e-01f, -1.01358736e+00f, -5.94764948e-01f, -5.14379084e-01f, 3.42893988e-01f, -5.41179240e-01f,
  4.91839826e-01f, -1.93730429e-01f, -2.72742301e-01f, 2.21758187e-01f, -2.51569245e-02f, 1.18215792e-01f, 6.64997160e-01f, -7.39060342e-01f, -2.47757405e-01f, -5.04448295e-01f,
  -1.72459781e+00f, -7.54475966e-02f, -4.07509774e-01f, -1.43134248e+00f, 8.49797666e-01f, 1.19428742e+00f, -1.46137893e+00f, -8.33921075e-01f, 8.10990155e-01f, -1.21811962e+00f,
  4.96657789e-01f, -6.56617343e-01f, -1.25855014e-01f, 3.16767663e-01f, 6.07927799e-01f, 5.83086789e-01f, 7.74888992e-01f, -6.14629328e-01f, 5.30193329e-01f, -8.84259865e-02f,
  2.03423753e-01f, -9.27357078e-01f, 1.39399266e+00f, 8.45012426e-01f, 9.66087759e-01f, -2.17584610e+00f, 7.10912585e-01f, -1.84613919e+00f, 1.57145977e-01f, -1.10156894e+00f,
  9.92498174e-02f, -1.29970706e+00f, 8.41310620e-01f, 1.11260138e-01f, 8.00539434e-01f, -3.09327930e-01f, 9.93189991e-01f, -1.45377338e+00f, -1.07411444e+00f, -5.61111212e-01f,
  -8.72232795e-01f, -1.78521931e+00f, -1.22163081e+00f, 2.14105502e-01f, 2.28389442e-01f, 7.91125238e-01f, -1.93601263e+00f, -1.74798381e+00f, -1.20407736e+00f, -1.06600747e-01f,
  4.69786942e-01f, 5.00364184e-01f, 4.00239676e-01f, -1.91520679e+00f, -7.05930173e-01f, -2.00785255e+00f, 1.95598376e+00f, 1.21423483e+00f, 8.31759453e-01f, -7.91771948e-01f,
  -1.30127561e+00f, -9.10603702e-01f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  -3.71601284e-01f, 2.65893906e-01f, -5.52759349e-01f, -3.68405521e-01f, 1.78778708e-01f, 7.71226048e-01f, 2.42271200e-01f, -6.05081856e-01f, -4.68786031e-01f, -3.47880840e-01f,
  -5.63804805e-01f, 6.35731459e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 4
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 6, 4
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        16, 12
    );
    }
    