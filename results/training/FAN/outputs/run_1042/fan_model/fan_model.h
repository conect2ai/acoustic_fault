/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 12 x 120)
const int L0_fan_Wp_rows = 12;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  6.22165978e-01f, -2.67913546e-02f, -6.57252893e-02f, 2.09147677e-01f, -1.09438576e-01f, 9.90441255e-03f, 1.39707908e-01f, 2.14922056e-01f, 1.24624938e-01f, 5.97852506e-02f,
  -2.06336513e-01f, -3.12168092e-01f, -2.80755699e-01f, -2.48245567e-01f, 6.04614988e-02f, 9.18348655e-02f, 7.20777363e-02f, 8.22812840e-02f, 2.23634038e-02f, 1.09127603e-01f,
  -1.24691732e-01f, 1.34043649e-01f, 3.02107573e-01f, 4.66562398e-02f, -1.18050948e-01f, -2.54778653e-01f, -9.28451717e-02f, -9.74099413e-02f, -2.40729764e-01f, -2.15085834e-01f,
  -3.24028045e-01f, 1.56570181e-01f, 3.24728452e-02f, 3.34172063e-02f, -9.46062803e-02f, 7.84838796e-02f, 1.68378904e-01f, 8.06254148e-02f, 8.73340219e-02f, 1.04666337e-01f,
  -5.75184971e-02f, 2.76074745e-02f, 6.51200637e-02f, -2.54750233e-02f, 7.56233335e-02f, 9.87291485e-02f, 2.93148868e-02f, 6.57659993e-02f, 5.62205315e-02f, -2.61056218e-02f,
  -2.23955125e-01f, -1.10357270e-01f, -6.05358146e-02f, -1.46159217e-01f, -1.10187560e-01f, -2.03008592e-01f, -4.24003862e-02f, -4.19533476e-02f, -8.32556263e-02f, 3.85824405e-02f,
  8.11311752e-02f, 8.36957619e-03f, -5.43942936e-02f, 3.53945643e-02f, 9.84819047e-03f, 8.27781036e-02f, -1.57451686e-02f, -7.58873522e-02f, -3.47870141e-02f, 8.91138799e-03f,
  -1.65704004e-02f, 1.13508217e-02f, 1.19506530e-02f, 4.84407805e-02f, -5.64300977e-02f, 7.56732514e-03f, -3.77483293e-02f, -1.08159864e-02f, -2.61500981e-02f, 5.58645874e-02f,
  1.74322631e-02f, -7.05984011e-02f, 7.09979534e-02f, -1.62097681e-02f, 1.23854130e-04f, 4.92829755e-02f, 1.33673183e-03f, 9.56001431e-02f, 3.16840298e-02f, 1.00474082e-01f,
  -1.43387048e-02f, -7.51358569e-02f, -3.46565582e-02f, -3.34353931e-02f, 3.87800522e-02f, -6.73311353e-02f, -1.38520330e-01f, -5.11897169e-02f, -7.50032663e-02f, -7.67391920e-02f,
  -4.42602392e-03f, -4.43034293e-03f, -6.81293011e-02f, -3.81795317e-02f, -4.23629917e-02f, -9.51272026e-02f, -7.95008391e-02f, -1.38894588e-01f, -8.33402388e-03f, -1.38691217e-02f,
  2.14169640e-02f, 7.49936933e-03f, -2.86145993e-02f, -1.70116033e-02f, -1.05475008e-01f, -7.17253312e-02f, -1.49456680e-01f, -6.49259165e-02f, -1.26231700e-01f, 1.56500280e-01f,
  2.57978410e-01f, -3.01774532e-01f, -3.02951396e-01f, -1.60543751e-02f, -1.63000047e-01f, -4.37588096e-02f, -2.77807206e-01f, -3.87409106e-02f, 1.20988436e-01f, -1.27960071e-01f,
  5.71347103e-02f, 3.18318576e-01f, 2.27916524e-01f, 1.21441580e-01f, 4.67438847e-02f, -2.89607525e-01f, -2.81320661e-01f, -4.33893278e-02f, 2.32614532e-01f, 4.08220626e-02f,
  3.17574218e-02f, -7.86198117e-03f, 5.96172735e-02f, -3.13350186e-02f, -2.02211484e-01f, 2.77278963e-02f, -1.44075945e-01f, -1.77370667e-01f, -9.64346230e-02f, -4.44730014e-01f,
  -1.11594670e-01f, -2.18624115e-01f, 8.29092860e-02f, 1.09167174e-01f, -1.03097156e-01f, -2.68403981e-02f, 4.50988188e-02f, -1.16810158e-01f, 6.88379537e-03f, -4.76513803e-02f,
  -1.15505710e-01f, -2.12034918e-02f, -4.03927155e-02f, -9.57457647e-02f, -9.04678330e-02f, 1.09083392e-02f, -1.34750992e-01f, -4.11427766e-02f, -2.39562821e-02f, -1.65325761e-01f,
  -1.32720515e-01f, -1.55599996e-01f, -1.06273755e-01f, -7.95572158e-03f, -2.79259887e-02f, -5.10816723e-02f, -7.09843934e-02f, -5.76087944e-02f, 4.99472395e-02f, -1.31797031e-01f,
  1.65224135e-01f, 6.84658736e-02f, 6.56735748e-02f, 3.23763266e-02f, 1.84860569e-03f, 7.55339041e-02f, 5.22451885e-02f, 3.49177904e-02f, 1.01592124e-01f, -4.35763411e-02f,
  -2.23326191e-04f, -3.29076573e-02f, 6.69537708e-02f, 8.83754052e-04f, -4.30395603e-02f, -5.88123538e-02f, -2.20719744e-02f, 9.35080424e-02f, -2.27401499e-03f, 5.40057989e-03f,
  1.16618834e-02f, 1.10338919e-01f, -2.78467275e-02f, -3.26120481e-02f, -2.68174019e-02f, 9.46101695e-02f, 1.01548969e-03f, 2.85300408e-02f, 8.38886295e-03f, -7.52933621e-02f,
  1.26837894e-01f, 5.44824563e-02f, -2.32478641e-02f, -4.26978357e-02f, -5.55747598e-02f, -2.85334997e-02f, -2.60575078e-02f, -9.57975984e-02f, -1.23186789e-01f, -3.55056375e-02f,
  -1.06968224e-01f, -7.77324587e-02f, -4.83390316e-02f, -3.68071198e-02f, -7.41368532e-03f, -5.05199693e-02f, 1.84653196e-02f, -3.87273580e-02f, -9.35704261e-02f, 9.63577721e-03f,
  2.64900066e-02f, -6.98505193e-02f, 9.87551808e-02f, 4.20783907e-02f, 1.61949117e-02f, 5.03214225e-02f, 1.44220460e-02f, 1.92844104e-02f, -2.45882440e-02f, 4.84265983e-02f,
  -2.69829817e-02f, -4.10729110e-01f, -2.94418097e-01f, -2.28568744e-02f, 1.12729155e-01f, 3.54671329e-02f, -2.97084749e-01f, -1.75412953e-01f, 1.53352067e-01f, -2.79888585e-02f,
  2.51086317e-02f, 2.25107148e-01f, 2.30665401e-01f, 7.97885656e-02f, -1.71577975e-01f, -2.71427006e-01f, -1.17478423e-01f, 3.40278121e-03f, 1.14155129e-01f, 5.26601709e-02f,
  8.12885985e-02f, 1.44104719e-01f, -4.24210504e-02f, 8.88338014e-02f, -1.33784294e-01f, 2.00945720e-01f, -1.67956695e-01f, -1.41473398e-01f, -1.53650157e-02f, -1.36132419e-01f,
  6.24986216e-02f, -2.36207396e-01f, 1.92677066e-01f, 1.86146304e-01f, 1.25181466e-01f, 9.80070084e-02f, -2.02681087e-02f, -4.86756396e-03f, 5.89262918e-02f, -5.80720045e-02f,
  -6.02157554e-03f, -5.71227595e-02f, -7.59719610e-02f, 1.26423696e-02f, -9.74170864e-02f, 4.78205159e-02f, -4.32825312e-02f, -2.02635720e-01f, -9.67792496e-02f, -1.14486469e-02f,
  -1.46796852e-01f, -2.14933343e-02f, -1.39115840e-01f, 7.27473199e-02f, -1.67718992e-01f, 1.73253134e-01f, -9.27162245e-02f, -3.26614007e-02f, -2.64321957e-02f, 2.13483442e-02f,
  1.52327448e-01f, 1.91638142e-01f, 3.98146920e-02f, -4.84919325e-02f, 1.33008454e-02f, 6.83831573e-02f, -8.59688744e-02f, 8.51635486e-02f, 4.79709910e-04f, 4.29789238e-02f,
  -2.94034407e-02f, -8.85772780e-02f, -1.29992753e-01f, -9.19817239e-02f, -1.58469416e-02f, 1.33593641e-02f, -6.47838116e-02f, -5.95728792e-02f, 5.95388114e-02f, 2.10680962e-02f,
  6.58713430e-02f, 4.40991633e-02f, 4.88584787e-02f, -3.65019403e-02f, -4.90574501e-02f, -1.50313333e-03f, -4.01116796e-02f, -9.88619216e-03f, 2.37347055e-02f, 1.12310365e-01f,
  2.26895764e-01f, 1.62964854e-02f, 1.17163628e-03f, -3.61454859e-02f, 5.03306352e-02f, 1.27895966e-01f, 1.35900795e-01f, 2.77470779e-02f, 1.04820855e-01f, 7.09619522e-02f,
  -1.10152803e-01f, 3.47394682e-02f, -2.59132124e-02f, -2.41465890e-03f, -2.92391237e-02f, 4.64131543e-03f, 1.57963838e-02f, -2.38625929e-02f, 5.26745282e-02f, 2.61743721e-02f,
  4.05082218e-02f, 2.91252714e-02f, 8.15623328e-02f, 6.16115741e-02f, 9.99048874e-02f, 2.24935636e-01f, 1.24638312e-01f, -1.91611759e-02f, 1.33469388e-01f, 2.63706535e-01f,
  3.49971920e-01f, 1.67518761e-02f, -1.78256501e-02f, -8.17487314e-02f, -2.87053287e-01f, -2.35818923e-01f, 6.11322001e-02f, -3.87376547e-02f, -5.59868068e-02f, 4.54357378e-02f,
  -1.78649753e-01f, -1.02260187e-01f, 2.05315500e-02f, -6.70603886e-02f, 5.92452884e-02f, 8.79324228e-02f, -1.45109773e-01f, 1.88827723e-01f, 1.26685917e-01f, 8.44716057e-02f,
  -4.49818186e-02f, -2.17098910e-02f, 9.27560627e-02f, -9.12805572e-02f, -1.11105919e-01f, -3.72606330e-02f, -5.92160784e-03f, -1.85344845e-01f, -7.81165883e-02f, 8.15155581e-02f,
  2.48970926e-01f, -3.46353948e-02f, -6.33027107e-02f, -2.09017396e-02f, -1.60250515e-01f, 4.39494103e-02f, -2.17533819e-02f, -4.03423533e-02f, -1.10116623e-01f, -8.68439004e-02f,
  -1.22570023e-01f, -1.50705546e-01f, -1.12953313e-01f, -1.39837191e-01f, -5.97155914e-02f, 1.31340073e-02f, -1.20035633e-01f, -1.26474172e-01f, -1.48572445e-01f, -4.52314727e-02f,
  -2.48182997e-01f, -2.18698874e-01f, -9.10509825e-02f, -1.19179346e-01f, -1.24984540e-01f, -1.04005128e-01f, -1.45389093e-02f, -1.62754565e-01f, -9.95911658e-02f, 1.92165047e-01f,
  1.50216548e-02f, 1.12215698e-01f, -5.05498564e-03f, 1.53256744e-01f, 8.84080157e-02f, -3.02416757e-02f, 2.40393486e-02f, 2.11101398e-02f, 1.53056458e-01f, 7.18580708e-02f,
  -3.85291991e-03f, 1.07334554e-01f, 6.61974698e-02f, 1.41739428e-01f, -7.41032436e-02f, -6.88489005e-02f, 5.67318201e-02f, 1.01236708e-01f, 4.25017402e-02f, -2.89291050e-02f,
  9.14561301e-02f, 2.10814346e-02f, 5.43807335e-02f, 4.12453972e-02f, 4.86802198e-02f, 6.87098056e-02f, -6.61774771e-03f, 7.13409781e-02f, 1.47935286e-01f, 1.25160575e-01f,
  8.58909562e-02f, -1.31145567e-01f, 1.48875520e-01f, -9.72959250e-02f, -4.88276631e-02f, -1.18064485e-01f, -9.86356363e-02f, -1.02199577e-01f, -1.22764327e-01f, 5.93199991e-02f,
  -1.39548048e-01f, -4.41920422e-02f, -2.75721867e-03f, -7.01902062e-02f, 8.00765827e-02f, -3.83085869e-02f, -8.44998211e-02f, 5.58274426e-02f, -1.22317739e-01f, -1.89281538e-01f,
  -6.26569539e-02f, 3.93187590e-02f, 1.73337340e-01f, -3.40662966e-03f, -2.20101653e-03f, 6.07215166e-02f, 9.43607911e-02f, 1.20965108e-01f, 1.92833677e-01f, 4.17117417e-01f,
  -2.98662096e-01f, -6.55802190e-02f, -2.67562252e-02f, 2.13148490e-01f, -8.08673501e-02f, -1.52563766e-01f, -4.06773418e-01f, -3.07262037e-02f, 7.59504363e-02f, -4.22907323e-02f,
  -7.55535141e-02f, 1.50819942e-01f, 1.92790180e-01f, 1.21921986e-01f, -2.04794869e-01f, -2.13388093e-02f, 7.06596375e-02f, -1.12843543e-01f, -1.19793184e-01f, -7.66427219e-02f,
  4.57572155e-02f, 7.72694498e-02f, 1.42647669e-01f, 1.09287813e-01f, 1.60637051e-01f, 2.04949766e-01f, 2.26121470e-01f, 3.49154845e-02f, 9.56344828e-02f, 1.42117932e-01f,
  -2.15961888e-01f, -1.53379679e-01f, -4.79866890e-03f, -1.25941053e-01f, 6.74929768e-02f, 4.26472723e-02f, -6.94621876e-02f, 5.16752154e-02f, -1.78052951e-02f, 9.30567272e-03f,
  -1.01525877e-02f, 2.79609617e-02f, -7.92886093e-02f, 1.51534574e-02f, -1.60821620e-02f, 4.12738957e-02f, 1.35289267e-01f, -1.51407095e-02f, -2.48513520e-02f, 2.14558896e-02f,
  -3.86847742e-02f, -1.22439772e-01f, -1.36401147e-01f, -5.81164025e-02f, -1.05615638e-01f, 5.37103079e-02f, 5.13732657e-02f, 5.44370674e-02f, -5.53504713e-02f, -3.85879837e-02f,
  1.35587985e-02f, -7.25535378e-02f, -3.79364006e-02f, -5.83439087e-03f, 1.08137526e-01f, 9.98031069e-03f, 1.23336181e-01f, -5.67012541e-02f, 4.18021046e-02f, 3.11167911e-02f,
  3.15258019e-02f, -4.85719368e-02f, -1.51667446e-02f, -4.07570601e-02f, 6.05002185e-03f, -3.67288291e-02f, 2.03638710e-02f, 6.92979991e-02f, 1.85004734e-02f, 3.45489942e-02f,
  -1.20396214e-02f, -2.79109124e-02f, 3.04622315e-02f, 1.31489811e-02f, -8.11440200e-02f, -2.60511506e-02f, -1.37860971e-02f, 4.70729023e-02f, 4.02142853e-02f, -7.41602946e-03f,
  -1.53849367e-02f, -2.43179854e-02f, 1.00647900e-02f, -5.32596279e-03f, -6.05077744e-02f, 9.29421559e-02f, -1.41699314e-02f, -3.74395512e-02f, 3.14865857e-02f, -8.06984399e-03f,
  -5.10258749e-02f, -3.73668820e-02f, 2.92026997e-02f, -4.60068230e-03f, 3.26749049e-02f, 4.03577238e-02f, 3.59255522e-02f, 3.92319784e-02f, -3.45912799e-02f, -4.64420132e-02f,
  2.72571500e-02f, -4.71000560e-02f, -1.54691115e-01f, 1.12475234e-03f, -7.42178559e-02f, -1.02484062e-01f, -2.16337908e-02f, -4.68168221e-02f, -3.62014286e-02f, -4.16587517e-02f,
  -7.67854571e-01f, -6.53275922e-02f, -1.61678359e-01f, 1.85780540e-01f, 3.66942704e-01f, 7.50899985e-02f, -1.70617737e-02f, 9.65423062e-02f, 1.95535973e-01f, 9.34870467e-02f,
  -4.60251495e-02f, 3.06903962e-02f, 6.78331256e-02f, 1.10141896e-02f, -1.22991316e-01f, 6.25492781e-02f, 1.72418132e-01f, -4.37692180e-02f, -1.02481395e-01f, 2.66104154e-02f,
  2.97864169e-01f, 2.36372259e-02f, -8.43171924e-02f, -5.58775663e-02f, 1.19566508e-01f, 1.06132440e-01f, 1.50199726e-01f, -2.16652043e-02f, 4.97309910e-03f, 1.86998263e-01f,
  -4.18468982e-01f, -1.75882384e-01f, 1.45161852e-01f, 1.31467581e-01f, -5.46937622e-02f, -2.02956107e-02f, 4.68209898e-03f, -7.75270686e-02f, 2.49864459e-02f, 3.82653363e-02f,
  -2.11415609e-04f, 4.12976742e-02f, 6.25931192e-03f, 7.84895793e-02f, -6.31040777e-04f, -2.67987233e-02f, 4.79692034e-02f, -7.24569261e-02f, 4.44384068e-02f, -7.64704719e-02f,
  1.47604927e-01f, -3.77042778e-02f, -1.77402943e-02f, 8.70730728e-02f, 5.10179996e-02f, 5.71403243e-02f, 3.04605253e-02f, 6.59033358e-02f, -8.19260404e-02f, -8.12987164e-02f,
  4.56487313e-02f, -7.66149387e-02f, -4.23669368e-02f, -8.61032866e-04f, -2.34775990e-02f, 7.13384850e-03f, 2.61749811e-02f, -3.41383219e-02f, -2.52300650e-02f, 2.12313309e-02f,
  -2.86757108e-02f, 3.95167656e-02f, 7.95975551e-02f, 4.64197919e-02f, -1.01957172e-02f, 4.88978904e-03f, 7.73959085e-02f, 5.09797148e-02f, 4.03998755e-02f, 1.61100198e-02f,
  3.46035697e-02f, -2.65564173e-02f, 2.91175395e-02f, 1.34106763e-02f, 2.17984468e-02f, 2.24140007e-02f, 9.90213156e-02f, 5.59354909e-02f, 1.87310874e-02f, 7.95973539e-02f,
  1.05811954e-01f, 9.88878608e-02f, -3.39862728e-03f, -4.17220294e-02f, -3.91080603e-02f, 3.24355662e-02f, -1.77273955e-02f, 3.17224371e-03f, -9.95649919e-02f, -1.07929692e-01f,
  -5.30991443e-02f, -1.39017284e-01f, -1.25345029e-02f, 8.49747378e-03f, -7.64116198e-02f, -3.30275372e-02f, 5.53455167e-02f, -1.47709269e-02f, 7.49285668e-02f, -7.92534463e-03f,
  9.91256088e-02f, -9.54036508e-03f, -9.59331766e-02f, -7.18369782e-02f, 2.32162327e-02f, -1.16434269e-01f, -4.87952754e-02f, -4.98851463e-02f, -8.39823186e-02f, -9.37572792e-02f,
  -7.96884239e-01f, -2.68044651e-01f, 6.31148517e-02f, -1.60116538e-01f, 1.44501731e-01f, 8.76162350e-02f, -7.45375641e-03f, 1.70794159e-01f, 3.45114022e-02f, 4.52960929e-04f,
  -5.63805625e-02f, 1.44251287e-01f, 1.05591364e-01f, 3.03406596e-01f, 3.29205282e-02f, 7.43836090e-02f, 1.06458277e-01f, 8.30125138e-02f, 3.13433170e-01f, 1.72852874e-01f,
  2.75966585e-01f, -1.27609357e-01f, -6.85421824e-02f, 1.47158995e-01f, -3.09871174e-02f, 1.86929420e-01f, 1.07737534e-01f, -7.44202808e-02f, 9.66847017e-02f, 4.86085713e-02f,
  -1.05351731e-01f, -2.40927324e-01f, 1.61452860e-01f, 1.91699769e-02f, 1.73369143e-02f, 2.96912454e-02f, 5.90139627e-02f, 1.58504788e-02f, 2.29803268e-02f, -2.08302177e-02f,
  2.05409415e-02f, 3.40314396e-02f, 1.71643272e-02f, 1.51650924e-02f, -4.15995577e-03f, -5.66641092e-02f, 6.49828389e-02f, 1.76598262e-02f, 4.61812429e-02f, 8.51677582e-02f,
  7.28863999e-02f, -6.39958074e-03f, -2.25045700e-02f, 4.94571179e-02f, -7.23820627e-02f, 8.11742619e-02f, -3.31611857e-02f, -6.55051842e-02f, -1.74707156e-02f, -3.99430543e-02f,
  -3.60167841e-03f, -1.23494066e-01f, -1.51485624e-02f, -7.17633143e-02f, -2.13281848e-02f, 3.69104818e-02f, 5.48524298e-02f, -1.20230541e-02f, 5.96228875e-02f, -1.02512605e-01f,
  -2.21424457e-03f, -2.27161627e-02f, 4.27064672e-02f, 8.96334555e-03f, 7.55019411e-02f, 7.44894817e-02f, -3.56711224e-02f, 2.88400240e-02f, -4.63559618e-03f, -2.61057857e-02f,
  -6.27961755e-02f, -4.13870253e-02f, 1.16006881e-02f, 7.47010997e-03f, 9.66387056e-03f, -4.64141276e-03f, 1.49411708e-02f, -2.69056205e-02f, -8.12562089e-03f, -1.64549833e-03f,
  9.53018293e-02f, 1.12919606e-01f, 2.86693661e-03f, 7.73038492e-02f, 5.43907378e-03f, 3.37906019e-03f, 1.86035000e-02f, -2.89474633e-02f, -9.28168520e-02f, 3.32452729e-02f,
  -6.04566932e-02f, 1.44874514e-03f, 1.11257052e-02f, 1.30985662e-01f, -3.61902490e-02f, 9.24316794e-02f, 3.56381200e-02f, 7.64036328e-02f, 1.03605449e-01f, -2.13762391e-02f,
  1.28525212e-01f, 3.29375491e-02f, -2.06412300e-02f, 6.02740087e-02f, -8.98793619e-03f, 6.05096929e-02f, 8.86056479e-03f, 8.14376250e-02f, 3.32655795e-02f, 5.91328330e-02f,
  -6.70076311e-01f, 1.56437203e-01f, -6.13614880e-02f, -2.05816880e-01f, 1.83674186e-01f, 1.19608767e-01f, 2.72307456e-01f, -7.71556646e-02f, -1.72707722e-01f, 1.30193800e-01f,
  4.63164970e-02f, -1.09431529e-02f, -5.35178259e-02f, 5.54449148e-02f, -9.47630331e-02f, 2.65869200e-01f, 1.79147586e-01f, -1.42519757e-01f, -2.44150639e-01f, 4.20503784e-03f,
  1.57244176e-01f, -7.33174682e-02f, -2.46866435e-01f, -1.48626164e-01f, 6.01421297e-02f, 2.01023355e-01f, 2.15747461e-01f, -7.66435564e-02f, 1.06590033e-01f, 1.14756776e-02f,
  -4.34691049e-02f, -1.74854994e-01f, 1.28757566e-01f, -9.22078863e-02f, -6.75732866e-02f, -1.09841779e-01f, 3.19002494e-02f, -1.29695982e-01f, 3.49290334e-02f, 3.95898521e-02f,
  5.05875349e-02f, -1.01906642e-01f, -2.36694645e-02f, -8.57393816e-03f, -1.80409905e-02f, 4.64645214e-02f, -8.16128999e-02f, -9.92133170e-02f, -1.21240001e-02f, 4.49044332e-02f,
  4.03192304e-02f, -1.59607735e-02f, -3.94233502e-02f, 6.41037971e-02f, -2.87425369e-02f, -5.80974035e-02f, -2.35468168e-02f, -8.54609981e-02f, -4.25507426e-02f, -5.94372600e-02f,
  7.46393278e-02f, -1.54496729e-02f, -1.60846133e-02f, -4.05138955e-02f, -1.54329743e-02f, 3.45601588e-02f, 1.35982223e-02f, 1.15653481e-02f, 5.29630333e-02f, -1.25204038e-03f,
  3.86907719e-02f, -1.80842783e-02f, -1.79963931e-02f, 1.95250362e-02f, 5.27364984e-02f, -4.81021293e-02f, -7.31063262e-02f, 7.96155706e-02f, -2.44044885e-02f, 1.21818101e-02f,
  -6.32040342e-03f, -3.28104198e-02f, 2.71299034e-02f, -6.29053265e-02f, 3.15311328e-02f, -4.83374000e-02f, -3.89284380e-02f, 1.18196700e-02f, -7.15567172e-02f, -1.75906811e-02f,
  1.28977582e-01f, 7.27357268e-02f, -3.46312039e-02f, 4.20996286e-02f, 7.02685304e-03f, 6.88111484e-02f, 6.63581938e-02f, 3.00378986e-02f, -2.17189882e-02f, -2.99080685e-02f,
  1.95903201e-02f, -2.85850856e-02f, 4.62781973e-02f, 4.35357288e-06f, 2.50422657e-02f, 5.20375259e-02f, 2.72838715e-02f, 1.59304738e-02f, 7.37716705e-02f, -4.13682126e-02f,
  4.65248786e-02f, 9.06891674e-02f, -5.11271553e-03f, 9.06588696e-03f, 8.55188444e-02f, 7.24380463e-02f, 9.52511728e-02f, 4.07171063e-02f, -6.31770939e-02f, 6.31699786e-02f,
  -1.31396532e-01f, -3.84987414e-01f, 2.13640146e-02f, -8.19968507e-02f, -1.71129569e-01f, 4.56835590e-02f, -2.47192115e-01f, 6.30415082e-02f, -3.07881478e-02f, -2.59630024e-01f,
  -7.14373291e-02f, 3.50610286e-01f, 2.85833299e-01f, 2.12836236e-01f, 1.88358352e-01f, -2.26216510e-01f, -1.65939569e-01f, 2.41658539e-01f, 5.46015322e-01f, 2.37199217e-01f,
  -1.55178294e-01f, -9.12259221e-02f, 1.73780456e-01f, 9.97012556e-02f, -2.14684516e-01f, 6.31135255e-02f, -1.00464053e-01f, -1.19841933e-01f, -1.02756701e-01f, -3.77943128e-01f,
  -1.51823848e-01f, -1.81940213e-01f, 1.04051232e-02f, -4.55234498e-02f, -6.10034689e-02f, -5.13417199e-02f, -2.75026653e-02f, -7.27428123e-02f, -8.47996995e-02f, -8.13577976e-03f,
  -2.51489170e-02f, -9.36229806e-03f, 9.03998762e-02f, 5.49488962e-02f, -8.28399062e-02f, -6.01017475e-02f, 3.83220054e-02f, 9.83032957e-02f, -3.27744223e-02f, -3.02920472e-02f,
  -1.39624327e-01f, -2.42109075e-02f, 1.06808454e-01f, -6.07860200e-02f, 5.87747544e-02f, 1.21769868e-01f, 2.22891681e-02f, -2.56122965e-02f, -2.19754092e-02f, -2.00292453e-01f,
  -6.60697073e-02f, -4.06319387e-02f, 2.69226618e-02f, -5.36172055e-02f, 6.38023019e-02f, 6.98620230e-02f, -1.10949297e-02f, -4.48745582e-03f, 1.57356821e-03f, -6.67026490e-02f,
  3.01467199e-02f, -6.40341863e-02f, 5.00412658e-02f, -2.33325381e-02f, 3.65562215e-02f, -6.61495700e-02f, 2.34535150e-02f, -6.20550523e-03f, 4.70220372e-02f, 3.53864423e-04f,
  -1.49622932e-02f, -9.76280775e-03f, -1.19359547e-03f, 8.42139497e-02f, 1.06623061e-02f, -2.55513303e-02f, -3.70628051e-02f, 1.91923566e-02f, -1.49128968e-02f, -1.55346051e-01f,
  -4.21831897e-03f, 2.01686889e-01f, -1.99904829e-01f, -9.18148831e-02f, -1.41522840e-01f, -1.15054958e-01f, -1.67925015e-01f, -1.13751523e-01f, -2.15420369e-02f, -9.42625031e-02f,
  -8.88466090e-03f, -5.97481839e-02f, 1.52840102e-02f, -1.34915113e-01f, 9.12700519e-02f, -5.67844473e-02f, -1.05618432e-01f, -2.78169792e-02f, -7.07250759e-02f, -1.62148178e-01f,
  -1.03544734e-01f, 3.26994285e-02f, 1.81835547e-01f, -8.38644709e-03f, -1.20948225e-01f, -3.19057554e-02f, -2.49279011e-02f, -5.40587828e-02f, 2.34033982e-03f, -2.25740626e-01f,
  -9.65396091e-02f, -2.94425905e-01f, -3.00139099e-01f, -1.98150471e-01f, -1.40118990e-02f, -2.37815138e-02f, -3.69332880e-01f, -5.94521165e-02f, 9.35638696e-02f, -2.05470338e-01f,
  3.95222381e-02f, 1.05595224e-01f, -1.04072332e-01f, -3.72969136e-02f, -5.14719449e-02f, -4.40202445e-01f, -4.06752884e-01f, -4.56963014e-03f, 1.95328116e-01f, 1.09898180e-01f,
  -6.20634556e-02f, -6.44134656e-02f, 2.37231910e-01f, 1.10244595e-01f, -2.31529936e-01f, 5.56394905e-02f, -1.99223101e-01f, 1.53885290e-01f, 3.02667897e-02f, -3.26262206e-01f,
  -4.45832580e-01f, -1.53105697e-02f, 5.90626858e-02f, 8.17590207e-02f, 3.36040631e-02f, 1.21242709e-01f, -2.10280456e-02f, 6.24021925e-02f, 1.89202968e-02f, 2.02742442e-02f,
  8.09499100e-02f, 1.61703601e-01f, 7.34354258e-02f, 1.48787585e-04f, 6.79648370e-02f, 8.03580508e-03f, 2.74970941e-02f, -5.08185141e-02f, -2.57613994e-02f, -1.28093690e-01f,
  -2.78515667e-02f, 1.23049930e-01f, -3.31201940e-03f, -6.88230097e-02f, -2.33749691e-02f, 1.73226222e-01f, 5.48216142e-02f, 2.61428915e-02f, 7.46105388e-02f, -1.34625435e-01f,
  -5.39892428e-02f, -5.85104711e-03f, -3.51660326e-02f, 4.16517854e-02f, 1.11590018e-02f, 4.89577418e-03f, -1.80956386e-02f, -4.66508269e-02f, 2.70207860e-02f, 3.24864313e-02f,
  8.92806612e-03f, 1.92277655e-02f, 3.64849181e-03f, -5.55081628e-02f, -9.40150097e-02f, 3.86216715e-02f, -6.38502389e-02f, -1.60561074e-02f, 1.99120808e-02f, 2.06582379e-02f,
  1.08276598e-01f, 2.30785348e-02f, 9.75678849e-05f, -3.13314167e-03f, -3.83937242e-03f, -5.00570722e-02f, -2.77177207e-02f, 5.63754439e-02f, -1.38707496e-02f, 9.86009017e-02f,
  5.95453084e-02f, 1.34738982e-01f, -2.16417536e-01f, -1.71264485e-02f, 4.06929106e-02f, 5.94318472e-02f, 6.81067957e-03f, -1.90826617e-02f, 7.94358626e-02f, -1.24781653e-02f,
  3.34380828e-02f, 2.11143587e-02f, -9.70877782e-02f, 3.39826643e-02f, -2.57337298e-02f, 4.29566540e-02f, 4.79924940e-02f, -2.11444367e-02f, 3.89382765e-02f, -3.78083698e-02f,
  -8.90702158e-02f, 1.58665758e-02f, 7.44169652e-02f, -8.56609270e-02f, -5.32818921e-02f, 4.75397706e-02f, -4.35310528e-02f, -3.29390168e-02f, 1.22886553e-01f, -1.42145246e-01f,
  -1.81582302e-01f, -6.80766627e-02f, -4.57831144e-01f, -2.86905080e-01f, -5.36388516e-01f, -3.18913281e-01f, -2.63187230e-01f, 4.30304632e-02f, 2.90984265e-03f, -1.33682594e-01f,
  -1.86118241e-02f, 9.40151047e-03f, 1.27258584e-01f, -2.14274880e-02f, 2.45263055e-02f, -1.47131145e-01f, -1.56949386e-01f, -2.10459724e-01f, -1.90313026e-01f, -2.47716337e-01f,
  -1.88822776e-01f, -1.80270970e-01f, -1.70171365e-01f, -1.52057037e-01f, -1.80999786e-01f, 3.73040214e-02f, -1.84989318e-01f, -1.53277040e-01f, -7.53503218e-02f, -2.79100299e-01f,
  -2.20918640e-01f, -1.63328260e-01f, -2.30788309e-02f, 1.50205418e-02f, -7.59404227e-02f, 4.18593548e-02f, -1.27695426e-01f, 1.21694669e-01f, 1.50795504e-01f, -2.14562491e-02f,
  -7.06403032e-02f, -1.30836666e-01f, 4.04120274e-02f, -1.16022661e-01f, -4.27882746e-02f, -4.79953028e-02f, 1.01293018e-03f, -9.53147188e-02f, -1.05500497e-01f, 1.37424115e-02f,
  -7.70989247e-03f, -5.88142909e-02f, 4.64830063e-02f, 9.24110934e-02f, -4.66196574e-02f, -7.04311728e-02f, 3.31496261e-02f, -2.95792352e-02f, -1.71933845e-02f, 1.59876972e-01f,
  8.67608711e-02f, -1.84926274e-03f, -3.94689552e-02f, 5.81714213e-02f, -2.57173609e-02f, 1.22092918e-01f, -1.03663422e-01f, -2.95609441e-02f, 3.38115240e-03f, 5.24720526e-04f,
  -9.23543796e-02f, 1.16992883e-01f, 4.67819721e-02f, 6.97077140e-02f, -6.82753474e-02f, 3.43048424e-02f, -1.08897611e-02f, -3.39310877e-02f, 2.10068040e-02f, 3.56105268e-02f,
  -6.63846955e-02f, -6.55177385e-02f, -4.61716503e-02f, 1.09590970e-01f, -2.37603355e-02f, -1.01580508e-01f, 1.59525909e-02f, 2.56831478e-02f, 5.87760936e-03f, 3.67724001e-02f,
  9.30199996e-02f, -9.35007259e-03f, 3.93134467e-02f, 8.73945728e-02f, 8.15839600e-03f, 2.20135599e-02f, 6.20195530e-02f, 1.18380301e-01f, -3.55069637e-02f, -4.15061861e-02f,
  -1.62744019e-02f, 1.59312189e-02f, 3.37357484e-02f, 2.67266072e-02f, 7.70488940e-03f, 2.46545300e-02f, 3.95830385e-02f, 3.22318114e-02f, 7.90163223e-03f, 2.44008079e-02f,
  4.18492593e-02f, 7.71753713e-02f, 8.88993591e-02f, 1.73888266e-01f, 1.19391151e-01f, 1.00214273e-01f, 1.95222691e-01f, 1.66292086e-01f, 1.12071242e-02f, 1.55811265e-01f,
  3.64297658e-01f, -2.75827616e-01f, 1.41394034e-01f, -1.99875347e-02f, -2.58533925e-01f, -2.88860410e-01f, -3.98570597e-01f, -4.19448055e-02f, 8.42541084e-02f, -2.08993763e-01f,
  -1.72582433e-01f, 6.91173673e-02f, -3.01248441e-03f, 1.52177677e-01f, 1.29616454e-01f, -1.66811287e-01f, 3.74378078e-02f, 3.89803469e-01f, 2.79539049e-01f, 1.04062691e-01f,
  -1.14814751e-01f, 4.16335873e-02f, 3.12091589e-01f, 2.24151611e-01f, -1.11326769e-01f, 6.83340803e-02f, -1.61077812e-01f, -5.18134050e-02f, -3.11164558e-02f, 1.29446894e-01f,
  8.03320631e-02f, 4.63582799e-02f, 6.29860815e-03f, 4.76267003e-02f, 9.29675344e-03f, 6.90794662e-02f, 1.31244706e-02f, 7.08751082e-02f, -1.14691239e-02f, -1.31820897e-02f,
  8.51572491e-03f, 4.92948964e-02f, -1.20592006e-02f, 7.94288591e-02f, -1.44930184e-02f, 3.98346037e-02f, -1.73113756e-02f, 1.86157778e-01f, 2.50911210e-02f, -2.85764039e-02f,
  -4.28323895e-02f, 6.68928102e-02f, 1.90590862e-02f, 8.18804838e-03f, -1.07103605e-02f, 1.64067611e-01f, -2.38547064e-02f, 2.41228670e-01f, 1.04638726e-01f, -1.38934571e-02f,
  5.21383919e-02f, 1.10908873e-01f, 3.82269472e-02f, 1.37816872e-02f, -1.87526569e-02f, -2.06109276e-03f, 5.12059629e-02f, 5.75163849e-02f, 4.19113897e-02f, 1.35738542e-03f,
  6.27623796e-02f, -7.07425177e-02f, 4.87429500e-02f, -6.81790663e-03f, 1.11456579e-02f, -1.92311537e-02f, 1.20781204e-02f, 3.45566086e-02f, -7.97280227e-04f, 4.36337441e-02f,
  2.01874203e-03f, 7.96307996e-02f, -6.22587316e-02f, -2.25551426e-02f, -4.49017398e-02f, 5.04511781e-03f, -3.53247188e-02f, -1.97715499e-02f, -6.36032373e-02f, 9.81271267e-02f,
  -1.69534132e-01f, -3.19955498e-02f, -4.84118797e-02f, 9.69760194e-02f, -6.61566332e-02f, -2.56916918e-02f, -5.03606685e-02f, 1.84401479e-02f, 4.72020637e-03f, 3.60200480e-02f,
  -9.16111246e-02f, -6.04135804e-02f, -4.97152051e-03f, 3.21428291e-02f, -8.89633223e-03f, -2.61523928e-02f, -8.34001675e-02f, -5.99447303e-02f, 1.00057488e-02f, -4.81379740e-02f,
  -7.66467629e-03f, -1.22284271e-01f, -1.49093300e-01f, -5.66780977e-02f, 3.16279307e-02f, -2.70135161e-02f, -1.04513966e-01f, -1.27848819e-01f, -9.18599963e-02f, -3.84599894e-01f
};

// L0_fan_Wp_bar (Shape: 8 x 120)
const int L0_fan_Wp_bar_rows = 8;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  7.27516294e-01f, 1.20814949e-01f, -1.08978713e+00f, 4.38646078e-01f, -3.33294660e-01f, -2.64064640e-01f, 2.91345492e-02f, 2.99648851e-01f, 3.80051047e-01f, 5.56862764e-02f,
  -3.93621549e-02f, 1.40574783e-01f, 8.04508403e-02f, -1.24536410e-01f, -5.31954365e-03f, -2.29874730e-01f, -3.51614445e-01f, -3.64187956e-01f, -1.55200422e-01f, 1.16434827e-01f,
  1.48469299e-01f, 3.51894885e-01f, 2.24026501e-01f, 1.31008938e-01f, -5.66382408e-02f, -4.69329283e-02f, -1.92005605e-01f, -1.04179367e-01f, -4.74242233e-02f, -3.91073316e-01f,
  -5.99912286e-01f, -1.79677799e-01f, -1.72652807e-02f, 1.77705795e-01f, -4.45140563e-02f, 3.84750739e-02f, -1.14432320e-01f, -7.81267956e-02f, 5.28442971e-02f, -1.02542363e-01f,
  -1.25628620e-01f, -3.47696384e-03f, 7.75108440e-03f, -5.59554808e-02f, -4.55907844e-02f, 9.27993506e-02f, 8.22292827e-03f, -2.37112883e-02f, -5.39669022e-02f, -1.01426519e-01f,
  1.32384468e-02f, -2.03193814e-01f, -2.88571626e-01f, -9.16151181e-02f, -1.61664754e-01f, -2.38270983e-01f, -3.24293882e-01f, -2.49333665e-01f, -2.32332289e-01f, -1.07583754e-01f,
  -2.25092024e-02f, 1.36329317e-02f, -5.57055734e-02f, 3.67537700e-02f, 1.22433186e-01f, 9.64038819e-02f, -4.52575870e-02f, -2.46015228e-02f, 3.58695239e-02f, -7.67884776e-03f,
  -2.35360092e-03f, -1.39648570e-02f, 1.95715800e-02f, 2.10100636e-02f, 3.16153690e-02f, -1.07013851e-01f, -1.29346490e-01f, -6.87532201e-02f, 1.07056284e-02f, 1.02010228e-01f,
  7.37777948e-02f, -1.17741443e-01f, 6.73240498e-02f, 1.25882234e-02f, -1.06573358e-01f, -2.29028501e-02f, -1.26173288e-01f, 5.63864149e-02f, 1.03931092e-01f, 2.88093835e-02f,
  4.28945839e-01f, -1.40753418e-01f, 1.37455195e-01f, -4.52676825e-02f, -6.71025142e-02f, -4.66562919e-02f, 3.78737338e-02f, 4.52660210e-02f, 1.47050694e-01f, 5.30581102e-02f,
  1.40259024e-02f, -3.81921455e-02f, -2.45619472e-03f, -1.69902528e-03f, 6.70181587e-02f, -3.98639217e-02f, 1.18830800e-01f, -2.80792378e-02f, 1.01665266e-01f, 8.22402462e-02f,
  2.60310054e-01f, 1.75930321e-01f, 3.52753513e-02f, -1.98174454e-02f, 1.19730130e-01f, 2.20087059e-02f, -5.98137975e-02f, 2.84600127e-02f, -1.71761036e-01f, 4.82672423e-01f,
  2.64808387e-01f, 4.01905954e-01f, -8.73473287e-02f, 1.38034686e-01f, -6.82389960e-02f, 1.77942440e-02f, 5.84111214e-02f, 1.84324592e-01f, 3.55406329e-02f, 1.10547051e-01f,
  3.67128849e-01f, 5.11516035e-01f, 3.28328490e-01f, 3.31459433e-01f, 2.13638291e-01f, 1.08474474e-02f, -1.37775719e-01f, 2.09079534e-02f, 1.07363269e-01f, 9.37077403e-02f,
  -2.92578079e-02f, -5.24084307e-02f, 2.00751387e-02f, -4.16929647e-02f, -1.74254179e-01f, 1.77184045e-02f, -1.81688413e-01f, -2.27209359e-01f, -1.73783779e-01f, -2.50907063e-01f,
  1.24665983e-01f, -3.93402204e-02f, 1.84972167e-01f, 7.82745704e-02f, -6.60520270e-02f, -3.07168849e-02f, 8.16088840e-02f, 6.75613210e-02f, 6.41992912e-02f, 8.42384845e-02f,
  7.49222562e-02f, -7.24563152e-02f, 2.39731260e-02f, -1.70611829e-01f, -3.35484780e-02f, -2.75639538e-03f, -5.52863330e-02f, 6.60164207e-02f, 1.11465052e-01f, 5.25944419e-02f,
  1.00557640e-01f, -1.62334032e-02f, 5.98456487e-02f, 7.91226476e-02f, 1.18896842e-01f, 1.71685796e-02f, -3.58874574e-02f, -4.64234427e-02f, -1.46685867e-03f, -5.75110950e-02f,
  1.90309435e-01f, -2.06407215e-02f, -1.22299165e-01f, -2.92666852e-02f, 1.60220824e-02f, -2.77746860e-02f, -1.16149880e-01f, 2.79762540e-02f, -1.38621097e-02f, -4.37715910e-02f,
  3.28842178e-02f, 6.40237108e-02f, 7.61386231e-02f, 7.61161223e-02f, 7.04914778e-02f, -4.76728193e-02f, -5.27996421e-02f, 1.04452772e-02f, -6.03493340e-02f, -1.22741118e-01f,
  4.57828157e-02f, -1.01304352e-01f, -1.37982205e-01f, -9.81314480e-02f, 3.66712036e-03f, 8.00663680e-02f, 8.77211709e-03f, 1.49774134e-01f, 1.27429012e-02f, -1.00499511e-01f,
  4.91438389e-01f, 1.41589522e-01f, -9.30042285e-03f, 6.41012192e-02f, -2.10107043e-01f, -1.23406805e-01f, 4.75238077e-02f, 3.20404358e-02f, -3.24212424e-02f, 1.60396382e-01f,
  1.71500128e-02f, 6.32843876e-05f, -3.62962931e-02f, -1.03793994e-01f, -6.98740408e-02f, 8.04432929e-02f, -3.23658213e-02f, 1.23421863e-01f, 1.82787612e-01f, -4.69333166e-03f,
  3.08996229e-03f, 8.06168690e-02f, 2.86748916e-01f, 2.21660823e-01f, 8.82297084e-02f, 3.56896780e-02f, 1.02015957e-01f, 7.82715380e-02f, -7.64472187e-02f, 5.33506647e-02f,
  2.38814086e-01f, -7.49092028e-02f, 9.86799076e-02f, 5.58293462e-02f, 5.60530365e-01f, 6.28345013e-01f, 8.25628161e-01f, 3.15148383e-01f, 1.52194798e-01f, 1.86119422e-01f,
  -2.22415373e-01f, -6.30623460e-01f, -4.67137277e-01f, -4.87516403e-01f, -1.92245647e-01f, 1.29218236e-01f, 2.10370272e-01f, -1.53203756e-01f, -7.79037774e-02f, 1.85526416e-01f,
  8.62450246e-03f, 2.29993507e-01f, 5.27485348e-02f, -1.04763962e-01f, -5.34295067e-02f, -2.44971454e-01f, 1.26334071e-01f, 1.32833436e-01f, -1.48805082e-01f, -5.25372088e-01f,
  -3.06599915e-01f, -3.17179933e-02f, -9.51775610e-02f, -1.50394872e-01f, 6.33604154e-02f, -1.30718157e-01f, -6.46059141e-02f, -2.25880463e-02f, 2.94689033e-02f, 9.69153829e-03f,
  -9.21233818e-02f, 5.80456927e-02f, -9.97596756e-02f, 1.28463045e-01f, 1.90777004e-01f, 1.14553042e-01f, 3.94677036e-02f, -1.39267951e-01f, -1.41746730e-01f, -6.49957731e-02f,
  -2.27238372e-01f, 3.65786143e-02f, 2.40048051e-01f, 1.74089372e-01f, -1.65998653e-01f, -1.34516031e-01f, -6.46085432e-03f, -3.68210860e-02f, -2.23896187e-02f, -1.11607842e-01f,
  -1.27107665e-01f, -4.26018350e-02f, -6.17246889e-02f, 8.25810828e-04f, -1.25431791e-02f, 1.01665124e-01f, -9.50381830e-02f, -1.26711428e-04f, -4.69076335e-02f, 7.70167187e-02f,
  -4.15269239e-03f, -7.21785203e-02f, -6.19855970e-02f, 1.35651054e-02f, -5.69747426e-02f, -2.43466366e-02f, 1.72277257e-01f, -8.20923820e-02f, -8.31372291e-02f, 9.70306620e-02f,
  -1.08347479e-02f, 6.51251525e-02f, -3.23667154e-02f, -6.06755279e-02f, -3.92190591e-02f, -8.26235190e-02f, -1.35512248e-01f, -7.23163113e-02f, 2.55340729e-02f, 4.77808118e-02f,
  -2.08883703e-01f, 2.87010279e-02f, -8.87832940e-02f, -2.03572467e-01f, -1.59595460e-02f, -8.59087855e-02f, -1.57179847e-01f, -1.10627614e-01f, 8.49108174e-02f, -1.40237272e-01f,
  7.77677121e-03f, -1.45671606e-01f, -9.28766187e-03f, 7.15154186e-02f, 6.60120025e-02f, 7.29544237e-02f, -2.73803133e-03f, -1.21938221e-01f, -9.72146019e-02f, -3.88217308e-02f,
  3.76605503e-02f, 1.46465600e-01f, -1.45727927e-02f, 2.00540312e-02f, -4.29334566e-02f, 4.21457514e-02f, 1.79402813e-01f, 1.77685693e-01f, 1.31129667e-01f, 2.35329032e-01f,
  1.87450811e-01f, 3.51311237e-01f, 1.14650406e-01f, 2.91102856e-01f, 2.93812215e-01f, 3.75800937e-01f, 6.54977143e-01f, 3.93831491e-01f, -3.62077318e-02f, 1.76360607e-01f,
  2.68439561e-01f, 1.26738131e-01f, 3.82975042e-02f, 4.20863852e-02f, 1.93085626e-01f, 1.25126719e-01f, -5.56071848e-02f, -1.59477144e-01f, -1.54577315e-01f, 2.54076086e-02f,
  2.47940258e-03f, 6.17379583e-02f, -1.00255802e-01f, -1.23633482e-01f, 2.32306913e-01f, -1.35214821e-01f, 1.68734044e-01f, 2.56955445e-01f, 2.39475787e-01f, -1.91579908e-02f,
  -3.16519648e-01f, 3.31247628e-01f, -2.72752911e-01f, -1.14068806e-01f, -3.62157775e-03f, -2.19169274e-01f, -1.97291017e-01f, -4.13990356e-02f, -9.14863199e-02f, -1.81248903e-01f,
  -7.35187456e-02f, -9.81517322e-03f, 1.30118728e-01f, 1.90750789e-02f, 2.90090460e-02f, -2.90461779e-02f, 3.93018778e-03f, 7.85294101e-02f, 9.22071785e-02f, -4.32899110e-02f,
  2.17250928e-01f, 2.18428880e-01f, 1.72946244e-01f, 1.70004666e-01f, 1.46854460e-01f, -4.56962618e-04f, 1.07788280e-01f, 6.12489134e-02f, 9.06975940e-02f, -5.02221845e-02f,
  -6.88036010e-02f, 9.68138203e-02f, 1.77015290e-01f, 2.24174242e-02f, 1.18817493e-01f, -2.94682570e-02f, -1.00839743e-03f, 3.95232104e-02f, 5.83798327e-02f, 5.60622662e-02f,
  -1.00219443e-01f, 4.04504966e-03f, -9.94471461e-03f, -7.44328350e-02f, -4.06292044e-02f, 1.92449242e-01f, 8.42092093e-03f, 3.03788558e-02f, 7.85953458e-03f, 6.20137639e-02f,
  1.58998985e-02f, -5.33621386e-02f, 3.36071961e-02f, 1.88728750e-01f, 5.41279204e-02f, 2.85734739e-02f, 3.72987837e-02f, 4.98473831e-02f, 1.27961248e-01f, -9.04082730e-02f,
  -4.94669884e-01f, 1.37651175e-01f, -1.38161659e-01f, -1.32855233e-02f, 1.26079097e-01f, 2.93688825e-03f, 8.32313597e-02f, -8.17730874e-02f, -1.01505347e-01f, -3.14789340e-02f,
  2.11890023e-02f, -1.36064410e-01f, 1.44682989e-01f, 3.75391245e-02f, -2.83838302e-01f, -3.60710360e-02f, 1.35817781e-01f, 7.68292621e-02f, 2.75687594e-02f, -1.69056535e-01f,
  4.30684909e-03f, -1.52548507e-01f, -1.25463128e-01f, 3.28065008e-02f, -5.67659214e-02f, -3.00805718e-01f, -5.83490171e-02f, -2.27821693e-02f, -1.22977532e-01f, -2.66751319e-01f,
  -8.68086994e-01f, 3.09528351e-01f, -1.05421342e-01f, -3.60459685e-01f, -4.98346984e-03f, -5.77829555e-02f, 1.54792950e-01f, 2.17463180e-01f, 5.47734611e-02f, 2.13717461e-01f,
  1.72415785e-02f, -2.97118843e-01f, -1.80500656e-01f, -3.71882729e-02f, -1.76062822e-01f, 6.95257960e-03f, -8.50846395e-02f, -5.54108322e-01f, -5.18045306e-01f, -1.90610096e-01f,
  -9.59534273e-02f, -5.32139540e-01f, -5.50100625e-01f, -1.93852618e-01f, 9.25451443e-02f, -1.60373747e-01f, -7.48503814e-03f, -5.31578511e-02f, 1.20853558e-02f, 5.37532941e-02f,
  -9.12401006e-02f, 2.13556364e-02f, -5.47087863e-02f, -6.25278577e-02f, 9.09033492e-02f, -4.72894758e-02f, -6.07986264e-02f, 1.07153384e-02f, 1.55493975e-01f, 1.66209713e-01f,
  -2.49629226e-02f, 4.68786620e-02f, -1.26341730e-01f, 1.17803685e-01f, -1.42521158e-01f, -9.04844925e-02f, 1.60606280e-01f, 1.96381621e-02f, -1.76895987e-02f, 1.34100989e-01f,
  2.05004752e-01f, 7.81216100e-02f, 8.31613168e-02f, 2.54548073e-01f, 1.73726067e-01f, 2.98645180e-02f, 1.85683027e-01f, 9.52612385e-02f, 2.09955230e-01f, 2.93691188e-01f,
  6.29993528e-02f, 1.39221475e-01f, -3.33499420e-03f, 5.63702062e-02f, 8.38472769e-02f, 5.49779236e-02f, -8.56082886e-02f, 8.41291994e-03f, -7.50276893e-02f, 4.01281901e-02f,
  2.02731505e-01f, 1.57492552e-02f, 8.40224400e-02f, -3.73992287e-02f, -1.20819494e-01f, -1.95749272e-02f, -3.02807819e-02f, -3.03038675e-03f, 1.00442618e-01f, -4.53639659e-04f,
  1.07552141e-01f, 1.03455439e-01f, -7.99505338e-02f, 3.19811106e-02f, 9.85643864e-02f, 8.78970399e-02f, -3.90656339e-03f, -5.85419871e-02f, -4.35217358e-02f, -7.90337846e-02f,
  4.02331464e-02f, -3.00669193e-01f, -2.15830058e-01f, 1.58607494e-02f, -3.77901681e-02f, 1.31144777e-01f, -5.41247725e-02f, 4.93093170e-02f, 9.28637665e-03f, -2.54347175e-02f,
  -5.32940961e-02f, -5.30726984e-02f, -3.92220877e-02f, 1.48152769e-01f, -1.18463039e-01f, 1.70422215e-02f, 1.61139518e-01f, -5.12367077e-02f, 3.33338901e-02f, 1.33064032e-01f,
  9.16575268e-02f, 1.57043889e-01f, -2.27421545e-03f, 1.79272398e-01f, 4.42579985e-02f, -1.45961389e-01f, 1.25037069e-02f, -3.24673541e-02f, -4.44855653e-02f, 3.12545896e-01f,
  -1.96265534e-01f, 3.77477735e-01f, -1.90787032e-01f, -5.30839600e-02f, 2.93833584e-01f, -9.15852487e-02f, -1.18620694e-01f, -2.71490812e-01f, -8.03048164e-02f, 1.75437614e-01f,
  2.38553062e-01f, 5.75038120e-02f, 5.26064485e-02f, -2.77570505e-02f, -2.63231665e-01f, 1.29519790e-01f, 3.73253286e-01f, -1.54758602e-01f, -6.83136642e-01f, -4.00093317e-01f,
  2.01912627e-01f, -3.92302871e-02f, -3.11313182e-01f, -2.08088174e-01f, 2.66274065e-01f, -1.44218579e-01f, 1.08145960e-01f, 1.96011931e-01f, 2.21520320e-01f, 7.84374952e-01f,
  7.77619481e-02f, 3.64067666e-02f, -4.64711748e-02f, 1.56354923e-02f, 1.37888849e-01f, -1.24849372e-01f, -6.52286410e-02f, 6.63284305e-03f, 5.25817461e-02f, 5.25968559e-02f,
  2.11168215e-01f, 1.16654150e-01f, 1.71048045e-01f, -2.08179019e-02f, -7.27992356e-02f, -1.88025236e-01f, -1.51955724e-01f, -1.82025462e-01f, -2.52112240e-01f, 2.20378116e-02f,
  5.06488323e-01f, 1.86718121e-01f, -1.99164778e-01f, -2.00929135e-01f, -1.07817709e-01f, -5.92205301e-02f, -7.38872588e-02f, -2.62471847e-02f, -3.28373224e-01f, -8.91628787e-02f,
  -5.85551634e-02f, 6.17312342e-02f, 9.07946229e-02f, -1.21672965e-04f, -7.01317564e-02f, 9.95889455e-02f, 1.43101454e-01f, -5.53149655e-02f, 4.67381403e-02f, -1.36730615e-02f,
  2.57227942e-02f, -1.04083493e-01f, -2.28433423e-02f, -1.22177554e-03f, -1.77864730e-02f, 1.48460660e-02f, -3.50808129e-02f, -1.72365233e-01f, 3.08147222e-02f, -7.95953814e-03f,
  -1.71777308e-02f, -5.44642890e-03f, 4.72733900e-02f, -1.38534874e-01f, 3.47865187e-02f, -1.11706555e-02f, 3.14518660e-02f, -4.96301465e-02f, -8.71337280e-02f, 5.12432382e-02f,
  -1.51519820e-01f, 1.43525517e-02f, -4.05107550e-02f, -4.86179888e-02f, -8.61437991e-03f, -1.81309208e-01f, 1.19991556e-01f, 1.97900925e-02f, 1.53697073e-01f, -1.96410492e-01f,
  -1.30177721e-01f, -5.74493706e-02f, 6.27370253e-02f, 1.36615690e-02f, -2.37544760e-01f, -3.70207541e-02f, 4.90711443e-02f, -1.25771388e-01f, -1.28363833e-01f, -2.95785703e-02f,
  -1.49393678e-01f, -2.65569478e-01f, -4.41393077e-01f, -1.61183611e-01f, -7.03364015e-02f, -4.80869204e-01f, -2.68394679e-01f, -1.70718476e-01f, -3.64871174e-01f, -3.15355450e-01f,
  -8.78352642e-01f, -5.34522422e-02f, 1.74054448e-02f, -7.71429062e-01f, 1.00096337e-01f, 3.57234448e-01f, 2.70452619e-01f, 8.32520798e-02f, -1.58046469e-01f, -9.69956070e-02f,
  5.55631891e-02f, -7.81619996e-02f, -1.91379711e-01f, 1.92701384e-01f, 5.73585406e-02f, -1.19031584e-02f, -6.87446222e-02f, 3.87958959e-02f, 2.81690478e-01f, 2.38276318e-01f,
  2.09544539e-01f, -3.68881732e-01f, -1.87355235e-01f, -1.53291514e-02f, -3.35475922e-01f, -1.33196682e-01f, -1.70143649e-01f, -3.05447906e-01f, 1.51157394e-01f, -3.17795843e-01f,
  -4.35821444e-01f, -2.22203463e-01f, 2.77890742e-01f, 7.53352717e-02f, -6.77564889e-02f, -7.01609403e-02f, -3.43289189e-02f, -2.11879034e-02f, 1.00206800e-01f, -1.92201585e-02f,
  -1.48186579e-01f, 2.72409379e-01f, -1.43219486e-01f, -2.43208669e-02f, -5.41326180e-02f, 5.00791296e-02f, 1.84670180e-01f, 7.83709288e-02f, 8.12584683e-02f, 4.16897684e-02f,
  1.88660901e-02f, -1.09228991e-01f, -1.24648765e-01f, 2.29053840e-01f, 8.43713954e-02f, 1.08921574e-02f, 4.56345230e-02f, 2.44482420e-02f, 2.30210960e-01f, -2.52641946e-01f,
  6.37135059e-02f, 4.05784287e-02f, 5.36528453e-02f, 1.15097933e-01f, -4.89470027e-02f, -4.78374511e-02f, -8.12004432e-02f, -7.08293468e-02f, 7.83098713e-02f, -1.94383621e-01f,
  5.97768277e-02f, 1.65559701e-03f, 2.15730593e-02f, -9.43328440e-02f, -1.06102973e-02f, -9.07646418e-02f, -5.12479106e-03f, -3.73407714e-02f, -6.63245842e-02f, 4.83228117e-02f,
  -6.06253650e-03f, -1.64742991e-01f, -1.57659367e-01f, 9.69325751e-02f, 1.52077958e-01f, 1.16888741e-02f, 4.45809960e-02f, 1.04670763e-01f, -6.86769336e-02f, 1.37809575e-01f,
  -5.26198447e-01f, 5.55978119e-01f, -2.79850692e-01f, -8.90398622e-02f, -1.81595355e-01f, -6.48645386e-02f, -1.83730930e-01f, 8.99863243e-02f, -1.64811626e-01f, -1.25057548e-02f,
  2.03969285e-01f, -1.03061035e-01f, -1.27368346e-01f, 2.96954736e-02f, 7.76302218e-02f, -1.03682531e-02f, -9.21575427e-02f, 3.35586704e-02f, 3.48511562e-02f, -2.28607971e-02f,
  -7.05466270e-02f, -1.80940136e-01f, -2.60093123e-01f, -7.94256702e-02f, -2.19188809e-01f, -1.89450085e-01f, -2.28853494e-01f, -2.12280348e-01f, -2.08475173e-01f, -3.93101752e-01f,
  -7.63755620e-01f, -1.23534106e-01f, -2.06082612e-01f, -1.66542172e-01f, -1.79534271e-01f, -1.08631030e-01f, -1.11884370e-01f, 2.46586323e-01f, -3.28707434e-02f, -2.36577809e-01f,
  -5.10962717e-02f, 2.18202919e-01f, -1.38834998e-01f, -1.48526922e-01f, -3.52578968e-01f, -4.68739241e-01f, -6.66622877e-01f, -6.30659401e-01f, -1.88542098e-01f, 1.21204019e-01f,
  -9.36168432e-02f, -2.38327131e-01f, -3.15280527e-01f, 2.84912102e-02f, 8.89656097e-02f, 1.29821733e-01f, -1.89998239e-01f, -1.44181758e-01f, -1.09663196e-01f, -4.35350180e-01f,
  1.17901023e-02f, 1.52186245e-01f, -3.73175293e-02f, -2.08599225e-01f, 1.17509924e-01f, -6.77156001e-02f, 1.44771278e-01f, 1.41791344e-01f, 3.51707824e-02f, 2.23660469e-02f,
  -1.55489504e-01f, 3.97277549e-02f, -5.23581952e-02f, 8.54479596e-02f, -1.62098836e-02f, -1.00426003e-01f, -3.19648385e-02f, -1.00835867e-01f, -8.16692505e-03f, 2.32001111e-01f,
  3.95980477e-02f, -2.67563105e-01f, -1.44527599e-01f, 9.55321826e-03f, 1.33404091e-01f, -5.84776886e-02f, 2.54014701e-01f, 2.27522716e-01f, 1.08531207e-01f, 8.87202546e-02f,
  9.78095382e-02f, 1.16619684e-01f, 4.63147536e-02f, 3.91554646e-02f, -1.30211592e-01f, -1.43326716e-02f, -3.04422341e-02f, 5.44568943e-03f, 4.25675586e-02f, 1.31564707e-01f,
  -5.55396974e-02f, -8.16077366e-02f, -9.13183466e-02f, -4.35192771e-02f, 1.60475902e-03f, -4.40955311e-02f, -9.11746174e-02f, -4.76910435e-02f, -4.05406654e-02f, -1.07502945e-01f,
  -7.98273608e-02f, -6.76763132e-02f, -1.40770897e-02f, 6.12426400e-02f, -1.57032371e-01f, -7.27605000e-02f, -8.28941762e-02f, 5.14177084e-02f, 1.60098046e-01f, -1.11638635e-01f,
  1.50648281e-01f, -2.30582893e-01f, -9.58093628e-02f, 2.46419594e-01f, 1.10098124e-02f, 7.82329962e-02f, 9.83181316e-03f, 8.21782947e-02f, -4.27833945e-02f, -7.22282827e-02f,
  -3.72971967e-02f, -8.77445638e-02f, -9.03287157e-02f, 4.50432375e-02f, -8.98155198e-02f, 5.78029081e-02f, -1.18348703e-01f, -1.26810953e-01f, -2.28993103e-01f, 4.54324223e-02f,
  -8.50332826e-02f, -1.99670553e-01f, -3.03783327e-01f, -1.71092823e-01f, 7.52955005e-02f, -2.29255661e-01f, 1.36632666e-01f, 1.78780794e-01f, -8.84661376e-02f, 1.44599274e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 8)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 8;
const float L0_fan_Bp_bar_data[] = {
  3.43802094e-01f, -1.20941415e-01f, 3.49645793e-01f, 3.64627272e-01f, 3.11538950e-02f, 3.38527143e-01f, 1.87789783e-01f, -3.65944654e-02f
};

// L1_fan_Wp (Shape: 12 x 32)
const int L1_fan_Wp_rows = 12;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  -7.64840990e-02f, -3.63596380e-02f, 2.61076182e-01f, 1.07703246e-01f, -6.76924810e-02f, 7.57324323e-02f, 3.53154466e-02f, -1.99750438e-02f, 1.47323251e-01f, 2.93579251e-01f,
  -3.52878571e-02f, 2.54633814e-01f, -1.76673442e-01f, 9.50988084e-02f, 6.59867898e-02f, -1.51382327e-01f, -1.56350642e-01f, 1.87925667e-01f, 1.86002761e-01f, 3.66376311e-01f,
  6.71817884e-02f, 1.20272413e-01f, 1.78020045e-01f, -2.70940304e-01f, -6.98833019e-02f, 1.69695169e-01f, 2.07227215e-01f, -3.14229190e-01f, 4.01413858e-01f, -4.56698798e-02f,
  1.76445529e-01f, 1.91543370e-01f, -3.20748636e-03f, 6.45750985e-02f, -6.51194109e-03f, 9.48884115e-02f, 1.35526983e-02f, -7.81053156e-02f, 1.05572641e-02f, -1.15410119e-01f,
  -1.06205903e-01f, 3.32617499e-02f, 8.72787014e-02f, 8.44955668e-02f, -1.87665075e-01f, -1.47861198e-01f, -9.94545873e-03f, -1.42523184e-01f, 8.63505062e-03f, 1.94320709e-01f,
  2.19931528e-01f, 3.32157671e-01f, 2.46895310e-02f, 2.84624010e-01f, 3.89088728e-02f, -1.03311822e-01f, -4.59856629e-01f, 1.21213524e-02f, 2.11250246e-01f, -1.96112454e-01f,
  2.30102137e-01f, 1.16924703e-01f, 6.32044315e-01f, -4.35435772e-03f, 1.90245494e-01f, 1.30174279e-01f, -2.92885993e-02f, -6.36586547e-02f, 2.52514090e-02f, 1.65184408e-01f,
  -1.65663217e-03f, 1.37732029e-01f, 3.71086746e-02f, 1.70716703e-01f, -9.21209604e-02f, -3.38049829e-02f, 2.49812946e-01f, 1.93056837e-02f, -1.30217476e-02f, 3.24479789e-02f,
  -1.68343961e-01f, -6.29795417e-02f, -2.59121358e-01f, -1.56549856e-01f, -8.59186798e-02f, -5.64074703e-03f, -1.09650800e-02f, 5.86635172e-02f, 4.00731117e-01f, 2.55888075e-01f,
  1.86977312e-01f, -6.81218877e-02f, -1.62954003e-01f, -2.71620780e-01f, -4.38124359e-01f, -2.47173876e-01f, -1.58413187e-01f, 7.44835585e-02f, -1.79094195e-01f, -3.97898816e-02f,
  -8.84927958e-02f, 1.79830849e-01f, -9.49741453e-02f, -1.00616984e-01f, 1.19273923e-02f, 3.28786969e-01f, 6.23411946e-02f, -3.42669524e-02f, 2.20296741e-01f, -3.98715645e-01f,
  -1.64655060e-01f, 2.19794326e-02f, 1.36383101e-01f, 3.73382792e-02f, -1.47603348e-01f, -1.94538027e-01f, -2.43639618e-01f, -2.29677334e-01f, -1.62034810e-01f, 1.79601923e-01f,
  -2.54195243e-01f, -1.63083389e-01f, 1.14082202e-01f, -1.03403434e-01f, 7.35587254e-02f, 4.31053936e-01f, 5.40799387e-02f, -5.42789996e-02f, -1.29310250e-01f, -1.87206477e-01f,
  -1.59154348e-02f, -1.05407171e-01f, -2.12101668e-01f, -2.33690307e-01f, -2.61293143e-01f, -2.49743044e-01f, -8.39140639e-02f, -2.94232935e-01f, -8.94162580e-02f, 1.05097607e-01f,
  -1.09737881e-01f, -1.89550407e-02f, -2.90025454e-02f, -3.74146849e-02f, -5.68649285e-02f, 5.18282838e-02f, -1.76398158e-01f, 2.37589672e-01f, -1.14638470e-01f, 4.50002551e-02f,
  6.55534193e-02f, -2.51628518e-01f, 3.99695516e-01f, 3.08341328e-02f, 9.20565575e-02f, 1.57236248e-01f, 1.44279167e-01f, -5.72444201e-02f, 2.03841045e-01f, 9.72296298e-02f,
  -8.88475403e-02f, 1.64460137e-01f, 1.66851237e-01f, -7.17065064e-03f, -1.17640104e-02f, -1.78108871e-01f, -2.92030692e-01f, -2.05205783e-01f, 8.68247673e-02f, 3.60975146e-01f,
  1.03491597e-01f, 7.56058022e-02f, -2.31556907e-01f, -1.10064343e-01f, 1.47111341e-01f, -1.13112427e-01f, -5.64511120e-03f, 2.95035131e-02f, -1.15795434e-02f, 3.07295054e-01f,
  -1.65789381e-01f, 1.22977741e-01f, 1.37232915e-02f, -2.88896501e-01f, 9.88138169e-02f, -1.20316826e-01f, 4.34306949e-01f, 2.65801281e-01f, 3.50218154e-02f, 7.44629651e-02f,
  -2.63206363e-01f, -1.89811543e-01f, -9.57649574e-02f, 1.60816591e-02f, -2.12245956e-02f, 4.71984446e-02f, 2.20097139e-01f, -4.89975065e-02f, 8.36095512e-02f, -1.57367602e-01f,
  2.18257234e-02f, -1.05708212e-01f, -2.11669458e-03f, 6.06419221e-02f, -5.59729487e-02f, 1.66741237e-01f, -3.11975349e-02f, 1.29150942e-01f, 4.46979627e-02f, 8.55204836e-02f,
  2.41558954e-01f, 1.49626896e-01f, -5.02595641e-02f, -3.20206612e-01f, 1.42961279e-01f, -7.56057501e-02f, 3.40643138e-01f, -9.64453220e-02f, 3.38310480e-01f, -8.31233934e-02f,
  7.29821110e-03f, -4.67547685e-01f, 8.09920728e-02f, 1.18489474e-01f, -7.67216831e-02f, -9.66552868e-02f, 7.95526803e-02f, -7.67731369e-02f, 8.29513744e-02f, 1.90185308e-01f,
  9.70058516e-03f, 1.02991946e-01f, -5.77577911e-02f, -7.79876709e-02f, -4.59325649e-02f, 1.70427963e-01f, 2.91487187e-01f, -6.02158606e-02f, 9.23214257e-02f, -1.50256053e-01f,
  1.73310414e-01f, 1.24288760e-01f, 3.03752767e-03f, -1.18979968e-01f, -3.45226452e-02f, 1.00094035e-01f, 2.11688474e-01f, -2.55806674e-03f, 2.89442122e-01f, -1.35169655e-01f,
  -1.13785692e-01f, -1.55790389e-01f, 6.37150779e-02f, -1.49058774e-01f, -1.46910980e-01f, 3.30876321e-01f, 1.53615564e-01f, -9.49216038e-02f, 1.01646900e-01f, 7.16054738e-02f,
  3.22070010e-02f, -8.21362212e-02f, -8.68825316e-02f, 1.65424332e-01f, -1.15129665e-01f, -3.53133172e-01f, -9.71392822e-03f, 6.08288012e-02f, -8.63856524e-02f, -6.31152689e-02f,
  -8.55538696e-02f, -1.64429490e-02f, 3.19781214e-01f, 1.38105661e-01f, -1.27040878e-01f, -1.72634155e-01f, 5.72994947e-02f, 1.44325346e-01f, -1.68420807e-01f, 3.10965091e-01f,
  1.32509947e-01f, 7.89197534e-02f, -2.50124633e-01f, 1.65581390e-01f, -5.87156191e-02f, 2.50154167e-01f, -9.63029265e-03f, -4.45093811e-02f, 6.69831112e-02f, -9.65325087e-02f,
  -6.96515739e-02f, -1.87396556e-02f, -1.99438985e-02f, -1.21760145e-01f, -1.08427197e-01f, -7.76122734e-02f, -6.80725053e-02f, -3.14795315e-01f, 4.26229686e-02f, 6.09978959e-02f,
  -5.83099276e-02f, -6.62984326e-02f, -4.96833175e-02f, 7.73808360e-02f, -9.36423689e-02f, -3.44694145e-02f, -1.42123923e-01f, 4.46775556e-03f, -8.25745910e-02f, -6.68780953e-02f,
  -7.28335530e-02f, 1.08786467e-02f, -1.28394738e-01f, 5.47071770e-02f, -1.89238191e-01f, 2.98475534e-01f, -2.12472171e-01f, 4.22532052e-01f, -2.11927682e-01f, -2.08441943e-01f,
  1.04461081e-01f, 6.03053533e-02f, 1.43289551e-01f, 2.47139279e-02f, 7.25355968e-02f, 2.10581478e-02f, -1.10614086e-02f, 5.15215956e-02f, -1.93933956e-02f, -1.10752739e-01f,
  1.26145512e-01f, 2.07209900e-01f, -1.86492339e-01f, -1.64194107e-02f, -6.32596686e-02f, -1.92584276e-01f, 3.10045421e-01f, 1.16235286e-01f, -1.42253652e-01f, -1.62581936e-01f,
  1.32532835e-01f, 2.07505226e-01f, -7.25356415e-02f, 1.57624066e-01f, -2.31400415e-01f, 9.76709574e-02f, -4.25793916e-01f, -4.88566980e-02f, 1.40880421e-01f, 5.91701031e-01f,
  -4.87790704e-02f, -1.64069802e-01f, 4.03966941e-03f, -3.51097509e-02f, -1.91488966e-01f, 9.59836394e-02f, 3.79913747e-02f, -9.61384922e-02f, -5.14931716e-02f, -1.21425912e-01f,
  1.90165803e-01f, 1.33950815e-01f, -4.08948362e-02f, 1.59758568e-01f, -5.12033366e-02f, 1.47470310e-02f, 7.09181204e-02f, 1.34040937e-01f, 1.13575816e-01f, 6.46317452e-02f,
  -1.67289078e-01f, 1.06106207e-01f, -8.38295817e-02f, 4.57289629e-02f, -5.79220653e-02f, -2.66666621e-01f, 1.25456825e-01f, -5.41995801e-02f, 1.64016798e-01f, -1.19899921e-01f,
  -2.26031646e-01f, 5.45835197e-01f, -6.11598551e-01f, 4.02052514e-02f
};

// L1_fan_Wp_bar (Shape: 8 x 32)
const int L1_fan_Wp_bar_rows = 8;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  2.59700269e-01f, 6.77620694e-02f, 3.34160328e-01f, -7.10779652e-02f, 2.61330783e-01f, 4.55527231e-02f, -2.52786100e-01f, 9.81183201e-02f, 4.03365456e-02f, 1.51294738e-01f,
  1.18281990e-01f, 2.94119924e-01f, -5.49806535e-01f, -5.33071347e-02f, 1.03209242e-01f, -4.34242815e-01f, 6.06981456e-01f, 3.81212354e-01f, 4.80640888e-01f, 4.85756397e-01f,
  2.79749811e-01f, 3.54814976e-01f, 9.96024534e-02f, -1.73515335e-01f, -1.00743026e-01f, -3.40931147e-01f, 4.59706746e-02f, -3.69579643e-02f, 1.41159117e-01f, 6.16304517e-01f,
  6.83780313e-01f, 4.80302662e-01f, -1.36498669e-02f, 4.40437526e-01f, 6.11320972e-01f, 5.67890406e-02f, 1.49851546e-01f, 4.42392409e-01f, 4.06196594e-01f, 2.26906076e-01f,
  2.54078537e-01f, 5.08797944e-01f, 2.70320028e-01f, 2.59381354e-01f, -1.06623553e-01f, -4.95570600e-02f, 4.57867324e-01f, 1.12620080e-02f, 1.78296864e-02f, 4.00111854e-01f,
  2.88520306e-01f, 3.86500925e-01f, -2.05767259e-01f, 1.78053662e-01f, 4.79548946e-02f, -2.81455398e-01f, 1.10747904e-01f, -4.07285780e-01f, 4.11105394e-01f, -2.72486210e-01f,
  5.25260925e-01f, 2.24073961e-01f, 3.74807626e-01f, -1.06261820e-01f, 4.12157089e-01f, -1.74965084e-01f, 3.81963477e-02f, 2.57003129e-01f, 1.10039696e-01f, -2.49910215e-03f,
  -2.36666530e-01f, 1.96273595e-01f, 1.73210517e-01f, 2.64864583e-02f, -2.64833182e-01f, 4.25737500e-01f, -2.01796561e-01f, 3.65567170e-02f, 8.54776502e-02f, -2.37026289e-01f,
  -2.14293063e-01f, 4.21709232e-02f, -3.85886669e-01f, -4.49487641e-02f, -8.34046751e-02f, 2.51181960e-01f, -1.84054971e-01f, -1.72700956e-01f, 7.91100621e-01f, -7.83507377e-02f,
  4.81417745e-01f, 6.49818718e-01f, 7.50412270e-02f, 4.18098867e-01f, 2.90971190e-01f, -1.60504609e-01f, 6.01875305e-01f, 2.99097169e-02f, 4.50136848e-02f, 2.44411379e-02f,
  2.42662951e-01f, 1.00360796e-01f, 3.44006151e-01f, 2.97752529e-01f, -5.85753545e-02f, -7.79572964e-01f, 2.60792393e-02f, 2.88375765e-01f, -1.13665901e-01f, 3.89296353e-01f,
  2.57041037e-01f, 3.45906429e-02f, -4.50395405e-01f, -2.76866198e-01f, 8.39195549e-02f, -5.01742661e-01f, 6.93518162e-01f, 3.45047921e-01f, -2.40446225e-01f, 4.74950701e-01f,
  7.72592723e-02f, -2.10867807e-01f, -3.53913791e-02f, 3.12638402e-01f, -4.15559918e-01f, -6.64511442e-01f, 4.73374248e-01f, 1.10596756e-03f, 2.75367379e-01f, 1.29266247e-01f,
  -1.45797044e-01f, -3.10189158e-01f, -1.68220460e-01f, 3.39558087e-02f, -1.16820365e-01f, 4.39580560e-01f, -8.46327171e-02f, 2.13450387e-01f, 2.74888843e-01f, 2.26115733e-01f,
  1.52937680e-01f, -1.33938119e-01f, 1.00122653e-01f, 3.23207416e-02f, -6.51667655e-01f, -2.74854507e-02f, -1.92736596e-01f, 4.55176271e-02f, 1.34911418e-01f, -8.73687044e-02f,
  -1.78399429e-01f, -1.58425584e-01f, -7.24648297e-01f, -3.73369306e-01f, 7.55951643e-01f, 1.33892596e-01f, -3.29339772e-01f, -2.03277543e-01f, -2.20986828e-01f, -3.02371114e-01f,
  1.91143334e-01f, -2.57366914e-02f, -2.08982825e-01f, -1.34962723e-01f, 2.50856936e-01f, -1.79631546e-01f, -2.44191568e-02f, -5.28620519e-02f, 1.52554050e-01f, -1.08911030e-01f,
  1.56071335e-01f, -9.19436067e-02f, 5.14449120e-01f, -4.32469964e-01f, -3.83203804e-01f, 1.28998570e-02f, -2.12710768e-01f, -1.37060732e-01f, -1.09270237e-01f, -8.80077928e-02f,
  -1.99235052e-01f, -5.28807819e-01f, -2.15454847e-01f, -2.70592600e-01f, -5.10371625e-01f, -3.12314898e-01f, 5.86340368e-01f, 1.56786740e-01f, -2.36376658e-01f, 1.35497421e-01f,
  5.81738539e-03f, -2.12424994e-01f, 9.06123370e-02f, 3.87799256e-02f, 2.52140790e-01f, 1.31193966e-01f, 4.14786518e-01f, 2.44241748e-02f, 1.57426924e-01f, 3.51003796e-01f,
  8.30478966e-02f, -2.77177002e-02f, -1.02638498e-01f, 3.76435399e-01f, 1.97816536e-01f, 3.08461159e-01f, 1.15328401e-01f, 2.43371665e-01f, 1.45943835e-01f, -8.22459757e-02f,
  -1.06190369e-01f, -8.38533342e-02f, -1.11709431e-01f, -2.35935718e-01f, 3.17539066e-01f, -1.94903508e-01f, 9.57162380e-01f, 4.43410054e-02f, 2.04342932e-01f, -9.70997289e-02f,
  2.88926095e-01f, -4.69450653e-01f, -2.22193137e-01f, 4.78190929e-01f, 3.60639304e-01f, 1.24715388e-01f, -4.63229939e-02f, 2.17407167e-01f, -7.92358592e-02f, 2.11865604e-01f,
  1.33075818e-01f, 9.99313220e-02f, 3.43881756e-01f, 4.83912021e-01f, 1.84177563e-01f, 4.94983569e-02f, -2.88211763e-01f, -2.37008885e-01f, 6.08894080e-02f, -1.22047685e-01f,
  -5.10229617e-02f, 1.78240731e-01f, -3.20896238e-01f, -1.17590195e-02f, 1.50038630e-01f, 1.20792478e-01f, -2.30579108e-01f, -1.34522378e-01f, -2.97462106e-01f, -2.43300751e-01f,
  1.10039771e-01f, 1.81721210e-01f, 3.27219635e-01f, 6.82701468e-01f, 1.05280869e-01f, -1.72423348e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 8)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 8;
const float L1_fan_Bp_bar_data[] = {
  2.71834247e-02f, -4.37949644e-03f, 2.70811021e-01f, 1.89076737e-01f, 1.30720232e-02f, 1.46977618e-01f, -7.60652348e-02f, 1.04056858e-01f
};

// L2_fan_Wp (Shape: 12 x 32)
const int L2_fan_Wp_rows = 12;
const int L2_fan_Wp_cols = 32;
const float L2_fan_Wp_data[] = {
  1.31937936e-01f, 3.78212407e-02f, 2.19862416e-01f, 2.32348651e-01f, 2.78315460e-03f, -5.37099503e-02f, 1.52919127e-03f, 2.57993191e-01f, -3.68213207e-01f, -2.91985214e-01f,
  9.35133770e-02f, 1.81039259e-01f, -1.58550739e-01f, -1.46432266e-01f, -4.12757814e-01f, 3.59940439e-01f, 1.16220452e-01f, -1.86862200e-01f, 4.24164021e-03f, 3.03311825e-01f,
  -3.86012048e-01f, 2.19662011e-01f, 4.23824154e-02f, -2.74479259e-02f, 5.90285026e-02f, 1.76679567e-01f, 5.90183400e-02f, -5.70640445e-01f, 4.53114122e-01f, 1.12872705e-01f,
  -2.42881626e-01f, 3.89746696e-01f, -3.79724771e-01f, 1.01968318e-01f, 6.85640424e-02f, -5.69027252e-02f, 1.75626546e-01f, -2.02919245e-01f, 1.27255216e-01f, 1.39357239e-01f,
  -8.68620072e-03f, -1.77309532e-02f, -8.53342265e-02f, 2.19778955e-01f, -2.37532407e-02f, -1.74533501e-01f, 1.44152328e-01f, 7.19322711e-02f, -2.89967626e-01f, -1.32618807e-02f,
  -1.87036827e-01f, -8.34304169e-02f, -1.92176402e-02f, 1.62679136e-01f, -4.55544703e-02f, 4.24432069e-01f, -3.03188771e-01f, -4.09352064e-01f, -5.91812655e-02f, 1.06486112e-01f,
  5.19799650e-01f, 2.67343313e-01f, -2.42110297e-01f, -2.08924413e-02f, 1.90025419e-01f, 1.22218858e-02f, 3.59876841e-01f, 2.19783738e-01f, 6.31097257e-02f, -1.33364365e-01f,
  -5.75022511e-02f, -2.35563740e-01f, -8.01596716e-02f, 2.26459265e-01f, -1.17301881e-01f, 3.58551256e-02f, 2.51132965e-01f, 2.44975910e-01f, -5.05284786e-01f, -1.04342714e-01f,
  3.36107731e-01f, 4.15034384e-01f, 2.14117721e-01f, 6.25871420e-02f, 7.28999823e-02f, -3.07368904e-01f, 1.06247768e-01f, -1.61905229e-01f, 4.08202052e-01f, 1.24136351e-01f,
  -1.81998238e-01f, -1.08668357e-01f, -3.17697585e-01f, -2.33616292e-01f, 2.66588390e-01f, -3.22334796e-01f, -3.36717159e-01f, 3.27150732e-01f, 2.27097154e-01f, 1.19144648e-01f,
  -9.14471000e-02f, -1.82923734e-01f, -1.86456352e-01f, -5.04022511e-03f, -3.57530981e-01f, -1.82176411e-01f, 8.07810873e-02f, 2.32444599e-01f, 2.78252959e-01f, 7.46560276e-01f,
  4.12462652e-02f, -1.73178799e-02f, 2.39760458e-01f, 2.11287737e-01f, 3.59727800e-01f, 4.41116005e-01f, -2.47835606e-01f, -1.42250255e-01f, 5.16150072e-02f, -1.66773185e-01f,
  2.32362986e-01f, -1.99003145e-01f, 1.82891339e-01f, 1.54769987e-01f, 3.54685217e-01f, 1.60037324e-01f, 7.98754469e-02f, -4.18911338e-01f, -6.55391514e-01f, 1.87129945e-01f,
  1.97259456e-01f, -3.53738040e-01f, 1.74092308e-01f, 3.16302001e-01f, -3.89585435e-01f, 1.54707760e-01f, -1.38161942e-01f, 1.12245478e-01f, 5.18512586e-03f, 3.36315274e-01f,
  1.38984531e-01f, 2.89971679e-01f, 9.48989093e-02f, -9.70602501e-03f, -4.03037935e-01f, -7.18284547e-01f, 8.14334955e-03f, 1.93014771e-01f, -1.98331758e-01f, -3.12421232e-01f,
  2.31424402e-02f, -1.05017321e-02f, -1.97592184e-01f, 1.27198189e-01f, -1.80840656e-01f, 1.15575984e-01f, -1.52945012e-01f, 1.94564760e-01f, 1.89227894e-01f, -2.94118643e-01f,
  -2.04420447e-01f, -1.88632291e-02f, 8.56921170e-03f, 2.44181439e-01f, -8.23682547e-03f, 9.57857072e-02f, -5.55779457e-01f, 9.68309939e-02f, -1.14755265e-01f, 9.06145666e-03f,
  4.77806516e-02f, -5.59682474e-02f, 3.57795417e-01f, -5.36599793e-02f, 5.32487221e-02f, -5.52126057e-02f, -1.29010752e-01f, 2.96373606e-01f, 3.08772504e-01f, 4.16033179e-01f,
  -2.39319801e-01f, -3.57905000e-01f, -1.87006980e-01f, 2.27303922e-01f, -1.17355369e-01f, 2.39277020e-01f, 3.19996588e-02f, -3.40642542e-01f, 3.39192748e-02f, -8.26087147e-02f,
  3.07667881e-01f, -3.63770485e-01f, -5.06562367e-02f, -3.58653128e-01f, -1.81546167e-01f, 6.91199377e-02f, -6.55818433e-02f, 3.88175324e-02f, -2.66114354e-01f, 2.33376980e-01f,
  -7.45523572e-02f, -1.34875819e-01f, 6.68354481e-02f, 1.49174228e-01f, -4.58953716e-02f, -5.72576225e-01f, -4.03472275e-01f, -2.87066009e-02f, -1.42547935e-01f, -3.71105403e-01f,
  5.53446487e-02f, 1.43956810e-01f, -6.02168143e-01f, -3.38603616e-01f, -9.98205505e-03f, -2.35607773e-01f, 1.71939522e-01f, 3.76103342e-01f, -1.30315989e-01f, 1.39903113e-01f,
  -2.95909911e-01f, -1.64897680e-01f, -1.94189716e-02f, -7.24119693e-02f, -5.05189598e-01f, -3.06647599e-01f, 5.79562426e-01f, 2.22330451e-01f, -1.84485927e-01f, 7.10274577e-02f,
  2.27261633e-01f, -4.13393006e-02f, 1.78156897e-01f, 3.32031101e-01f, -1.43484831e-01f, 3.13893929e-02f, -2.26977646e-01f, 5.20587981e-01f, -2.46284619e-01f, -5.14224023e-02f,
  -1.29771262e-01f, -3.34583968e-01f, -4.02181000e-01f, 4.69333306e-02f, 3.71682197e-01f, -2.05528364e-01f, 4.04241771e-01f, 1.33635461e-01f, 9.72235501e-02f, -1.28221303e-01f,
  -2.22266510e-01f, -2.21437320e-01f, -5.08451581e-01f, 8.69860351e-02f, 3.69641095e-01f, 1.48158610e-01f, -1.47628123e-02f, 1.65987194e-01f, -3.45767885e-01f, 2.85321355e-01f,
  -1.69784557e-02f, 1.69564299e-02f, 9.46889520e-02f, -5.38993955e-01f, 2.46773854e-01f, 1.92912400e-01f, -4.25304085e-01f, 2.89001758e-03f, 1.46684200e-01f, 4.90738958e-01f,
  3.21037397e-02f, -2.17506170e-01f, 2.15479080e-02f, 8.50840136e-02f, -1.30024299e-01f, -2.30143428e-01f, 3.06373864e-01f, -8.82385224e-02f, -3.30470363e-03f, 4.14398223e-01f,
  -1.03783615e-01f, -3.18950206e-01f, 6.98112398e-02f, -2.41488412e-01f, 6.48513436e-01f, 1.37311863e-02f, 2.36088663e-01f, -2.49200454e-03f, 2.66095161e-01f, -1.81038424e-01f,
  -1.03836125e-02f, -1.56484433e-02f, -2.15999961e-01f, -6.94782361e-02f, -1.04156613e-01f, -3.01592469e-01f, -2.35888618e-03f, 1.65626824e-01f, -8.21626335e-02f, 2.43269518e-01f,
  5.06745219e-01f, 2.44964197e-01f, 2.25040540e-01f, -7.16928020e-02f, -3.20809007e-01f, 5.10386348e-01f, -1.05235055e-01f, 1.62162483e-01f, 2.09447846e-01f, -4.42258082e-02f,
  -3.53522778e-01f, 2.13031262e-01f, -2.51928836e-01f, -2.64590263e-01f, 1.69401661e-01f, 3.78629833e-01f, 3.36989045e-01f, 1.21051393e-01f, 2.33513370e-01f, -1.92517415e-02f,
  1.55856379e-03f, 1.22105621e-01f, 2.53663301e-01f, -1.36699721e-01f, -3.58538151e-01f, -2.42152363e-01f, 5.91007136e-02f, -3.49141300e-01f, 1.60925254e-01f, 4.17246640e-01f,
  -5.66591084e-01f, -1.33748397e-01f, 3.72099946e-03f, 8.63578141e-01f, -6.46256506e-01f, 2.04803929e-01f, 1.69195652e-01f, -1.13407999e-01f, -1.59690052e-01f, 3.75787579e-02f,
  3.62348437e-01f, -3.54355276e-01f, 2.12379649e-01f, 1.07416129e-02f, 5.33603653e-02f, 1.29485101e-01f, -6.74308836e-02f, -8.21295679e-02f, -3.96842539e-01f, -3.30081522e-01f,
  3.12498242e-01f, -1.49308339e-01f, -2.71908402e-01f, 4.94226545e-01f, 1.47092372e-01f, -1.34556875e-01f, 7.65820742e-02f, 8.11450332e-02f, 1.60358891e-01f, 3.20071101e-01f,
  -2.59246260e-01f, 2.85853118e-01f, -1.01042196e-01f, 4.15465325e-01f, 9.24800858e-02f, 1.26737967e-01f, -1.04328036e-01f, -3.27684164e-01f, -4.75633681e-01f, -2.14509562e-01f,
  -3.13223392e-01f, -2.57321537e-01f, 1.86528996e-01f, 1.80038035e-01f, -1.52763963e-01f, 2.34868169e-01f, 4.72060740e-02f, -2.34782010e-01f, -3.11884493e-01f, 3.38964343e-01f,
  -4.04797286e-01f, -7.70361628e-04f, 9.39639211e-02f, 1.65545166e-01f
};

// L2_fan_Wp_bar (Shape: 8 x 32)
const int L2_fan_Wp_bar_rows = 8;
const int L2_fan_Wp_bar_cols = 32;
const float L2_fan_Wp_bar_data[] = {
  8.13654661e-02f, 4.18897033e-01f, -4.99074101e-01f, 8.92197415e-02f, -1.74801886e-01f, -2.02507943e-01f, 4.11057234e-01f, 5.24101079e-01f, 3.87197882e-02f, 7.30397999e-02f,
  1.76440597e-01f, 2.96507716e-01f, -1.07328460e-01f, -1.38549089e-01f, 3.07044357e-01f, 2.54649110e-03f, -5.24850547e-01f, -1.29804447e-01f, -1.90270856e-01f, -8.79233718e-01f,
  4.87052500e-01f, 1.98606297e-01f, 2.15973005e-01f, 1.58435360e-01f, 9.03450027e-02f, -1.06941283e-01f, 1.93185002e-01f, 1.18415332e+00f, 8.48447502e-01f, 1.01409924e+00f,
  -3.51321340e-01f, 1.86644435e-01f, -1.70081303e-01f, 1.81823596e-01f, 6.35307908e-01f, 2.42481962e-01f, 6.60454452e-01f, 4.76877064e-01f, 3.66147906e-01f, 6.94248155e-02f,
  3.54595751e-01f, -5.57493754e-02f, 1.67023525e-01f, -3.59282121e-02f, -1.50476471e-02f, -1.21136881e-01f, 1.45914434e-02f, 4.67694402e-01f, 6.31353199e-01f, -4.67240065e-02f,
  -5.52677274e-01f, -1.89763695e-01f, 5.66459775e-01f, 6.97151184e-01f, 5.99284410e-01f, 7.14057088e-01f, 2.09216788e-01f, -9.89202932e-02f, 5.11640429e-01f, -8.52568686e-01f,
  1.79201350e-01f, 3.05314094e-01f, -1.69583589e-01f, 6.61934137e-01f, 4.52563703e-01f, -2.36340702e-01f, -4.54115868e-01f, 2.13859081e-01f, -6.13438606e-01f, -5.68248272e-01f,
  1.69134319e-01f, -3.71924996e-01f, 1.08426549e-02f, -1.68056548e-01f, 1.59599409e-01f, -5.53238392e-01f, 6.50416017e-01f, -1.63339183e-01f, 4.36364770e-01f, -5.29416740e-01f,
  6.90417647e-01f, 3.84646237e-01f, -1.89030856e-01f, 9.98281762e-02f, 3.98147672e-01f, -2.34122556e-02f, 1.20532259e-01f, -2.41701216e-01f, 2.77292788e-01f, 2.42676251e-02f,
  6.66957915e-01f, 9.50959623e-01f, 1.94002211e-01f, 1.47662058e-01f, 2.65437335e-01f, 4.25220579e-02f, 2.96652526e-01f, 5.44764400e-01f, 1.13661908e-01f, 3.76590550e-01f,
  1.82831556e-01f, 3.01701963e-01f, 1.27325758e-01f, 4.62336332e-01f, 4.58963402e-02f, 9.40758213e-02f, -5.89767635e-01f, 2.05986068e-01f, -2.58531749e-01f, 4.51145023e-01f,
  -4.26448375e-01f, 4.85755682e-01f, -4.72011179e-01f, 2.44920254e-01f, -1.62954554e-01f, -1.26301333e-01f, -3.05887818e-01f, -1.35501042e-01f, 1.01305082e-01f, 5.43732941e-01f,
  3.96369219e-01f, 5.20808041e-01f, 2.64511228e-01f, -2.16396332e-01f, 1.00260043e+00f, -7.81452581e-02f, -4.37609643e-01f, 5.63830018e-01f, 4.14968967e-01f, -4.80834059e-02f,
  -2.20163360e-01f, 3.92428219e-01f, -3.71848308e-02f, 2.28023216e-01f, 3.02385211e-01f, 2.27291048e-01f, 2.52592504e-01f, 3.58809471e-01f, -3.97387803e-01f, -9.49098691e-02f,
  -2.85832375e-01f, -3.09113234e-01f, -1.63779631e-01f, 1.91008151e-01f, -5.12350380e-01f, -3.47247213e-01f, -3.45136166e-01f, 3.58178616e-01f, -1.98490068e-01f, -2.16584608e-01f,
  2.00657606e-01f, -4.63932067e-01f, 5.55832386e-01f, 8.22367609e-01f, 8.83034542e-02f, 7.45566189e-01f, -2.20950440e-01f, -8.44867706e-01f, -2.37311214e-01f, 2.76495159e-01f,
  -5.62095761e-01f, -3.74740243e-01f, -5.00786364e-01f, 2.74317086e-01f, -4.47405316e-02f, -1.79484054e-01f, 9.51782912e-02f, -3.65909964e-01f, 4.01357472e-01f, -3.41408104e-01f,
  1.25751570e-01f, 9.93738696e-02f, 1.98349819e-01f, 5.81985824e-02f, -4.66745108e-01f, 1.86751127e-01f, 8.45925510e-01f, -3.42881680e-01f, 1.44465476e-01f, 3.90066236e-01f,
  -4.88241054e-02f, -5.50603628e-01f, 3.88575971e-01f, 2.06289753e-01f, 7.20308185e-01f, 7.02303290e-01f, 3.40579033e-01f, -4.36755158e-02f, -4.59904879e-01f, 6.83212802e-02f,
  2.29414091e-01f, -1.03431672e-01f, -2.53945053e-01f, 3.03816110e-01f, -1.83741644e-01f, 5.42470157e-01f, 7.94711590e-01f, 4.95885342e-01f, -6.63446859e-02f, 3.47381324e-01f,
  1.59637153e-01f, 4.53880191e-01f, 1.11503430e-01f, -1.39215002e-02f, 4.83225524e-01f, -3.32863063e-01f, 6.64185166e-01f, -3.30300182e-02f, 6.02408685e-02f, 7.37830520e-01f,
  8.00415993e-01f, 2.89353937e-01f, -7.64906287e-01f, -3.14078301e-01f, -7.33345449e-01f, 6.91918731e-01f, -2.72327095e-01f, 8.20812345e-01f, 4.38583791e-01f, -7.22940207e-01f,
  8.36200833e-01f, 2.54979491e-01f, 4.24505413e-01f, 5.00825882e-01f, 4.91722405e-01f, -2.73828238e-01f, -2.11738780e-01f, -2.15575531e-01f, 1.99960724e-01f, 9.06147286e-02f,
  3.07382524e-01f, 8.71615633e-02f, 2.90970981e-01f, 1.99396133e-01f, 4.69260871e-01f, -7.18703419e-02f, -2.43088424e-01f, -5.03992379e-01f, 6.76859677e-01f, -4.52598006e-01f,
  2.97329463e-02f, 1.27254516e-01f, -3.92188132e-01f, 2.47560605e-01f, 2.15353802e-01f, 3.55652452e-01f, 1.05104841e-01f, -3.85347120e-02f, -8.90865266e-01f, -3.19943875e-01f,
  4.91271228e-01f, 9.56807315e-01f, 1.81135133e-01f, 2.39352256e-01f, 1.16735660e-01f, 8.45343322e-02f
};

// L2_fan_Bp_bar (Shape: 1 x 8)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 8;
const float L2_fan_Bp_bar_data[] = {
  4.59039152e-01f, 2.61170864e-01f, 2.98298448e-01f, 1.03055462e-01f, -2.48058841e-01f, 1.97955102e-01f, 2.73755640e-01f, -1.17270462e-02f
};

// L3_linear_W (Shape: 12 x 32)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 32;
const float L3_linear_W_data[] = {
  -6.69338763e-01f, -9.58525836e-02f, -2.77870208e-01f, -1.34745806e-01f, -1.53543323e-01f, 1.13094300e-01f, 3.54889780e-01f, -1.99984834e-01f, -1.23766601e-01f, 4.06288542e-02f,
  -5.93068480e-01f, 7.80083165e-02f, -6.37748957e-01f, 1.48315281e-01f, -5.60764134e-01f, -4.94656235e-01f, -1.24389835e-01f, 5.85552633e-01f, 4.19523597e-01f, 3.58599097e-01f,
  -2.40807179e-02f, 3.92976642e-01f, 2.29773074e-01f, -1.61288559e-01f, -1.53518438e-01f, -1.19943845e+00f, 6.66153789e-01f, -8.37409914e-01f, -4.09788871e-03f, 2.61196166e-01f,
  -5.77113330e-01f, -7.41546690e-01f, -1.05043143e-01f, 5.37890673e-01f, 2.41775960e-01f, 3.22625786e-01f, -1.52820677e-01f, 4.75077838e-01f, -1.51646495e-01f, 5.34868129e-02f,
  2.34917611e-01f, -2.68605053e-01f, -4.59221631e-01f, 3.15795779e-01f, -3.40628892e-01f, -5.94670236e-01f, 9.23945382e-03f, 1.12511598e-01f, -4.06593084e-02f, -1.06403358e-01f,
  -1.03385545e-01f, -4.55519885e-01f, 1.26319565e-02f, 3.36774170e-01f, -4.35509831e-01f, 5.93507066e-02f, 6.00732192e-02f, -2.88786590e-01f, 4.66943681e-01f, -8.63568604e-01f,
  -9.49275717e-02f, -5.95345438e-01f, -3.91601592e-01f, 7.38240659e-01f, 6.04646988e-02f, -1.27403498e-01f, 4.71023649e-01f, 4.11194175e-01f, 3.98003310e-01f, -6.22299649e-02f,
  1.42864157e-02f, -1.39318585e-01f, -1.91928819e-01f, 2.81593114e-01f, -7.51548633e-02f, -1.36640802e-01f, -1.26277938e-01f, -3.15609097e-01f, 5.16309381e-01f, -5.20840228e-01f,
  1.06766103e-02f, -4.24819440e-01f, 3.44903648e-01f, 4.29772019e-01f, -3.97029594e-02f, -5.00860870e-01f, 6.88031375e-01f, 3.53068501e-01f, 3.29772323e-01f, -7.94578850e-01f,
  -3.09622169e-01f, 4.33908015e-01f, 4.96851563e-01f, -1.31627917e-01f, -1.11751807e+00f, -1.96477816e-01f, -3.29211384e-01f, 4.17331532e-02f, 1.74331680e-01f, 5.72563946e-01f,
  -7.75030971e-01f, 1.21438168e-01f, -5.33186674e-01f, 7.36353815e-01f, -1.47166514e+00f, -6.57278299e-01f, 8.98397148e-01f, -4.73593503e-01f, -4.37944904e-02f, 2.68257439e-01f,
  3.69615048e-01f, 1.21665820e-01f, -2.98521280e-01f, -1.40142277e-01f, -3.97788227e-01f, 7.79739916e-02f, -3.26374590e-01f, 2.45647982e-01f, -3.38904530e-01f, -4.93896097e-01f,
  -5.00125527e-01f, -3.47707599e-01f, -1.62533551e-01f, 1.56956017e-02f, 4.14942861e-01f, 1.40996829e-01f, -6.03598282e-02f, -1.19312692e+00f, 4.47953343e-01f, -1.00185044e-01f,
  -3.63588601e-01f, -2.91340381e-01f, 4.43376750e-01f, 2.51884401e-01f, -1.63173914e-01f, -7.90523171e-01f, 6.71939909e-01f, 2.20310986e-02f, -8.26369822e-01f, 3.00991118e-01f,
  5.36751866e-01f, 2.00707018e-02f, -1.33681089e-01f, 3.78876001e-01f, -2.99384713e-01f, 2.98532754e-01f, 3.56944382e-01f, -2.20985085e-01f, -1.35058582e-01f, -6.84490263e-01f,
  3.88020456e-01f, -5.10450661e-01f, -1.05980766e+00f, 4.22893286e-01f, -2.22289622e-01f, -7.89665952e-02f, 2.74203420e-02f, 2.93818504e-01f, -2.82320678e-01f, -3.25502932e-01f,
  3.59561116e-01f, -6.23427987e-01f, -1.00583471e-01f, 3.01170409e-01f, 3.69826943e-01f, -6.66304052e-01f, 3.41245204e-01f, 1.21573992e-01f, 1.62879825e-01f, -2.48369083e-01f,
  -5.83806783e-02f, 7.28255063e-02f, -6.68376029e-01f, -1.56395435e-01f, 7.68743217e-01f, -4.34503481e-02f, -1.53579161e-01f, -1.44059002e-01f, -9.54870433e-02f, -3.34223330e-01f,
  3.23699951e-01f, 3.75411123e-01f, -2.85729766e-01f, -8.87696266e-01f, -7.10381985e-01f, -2.11049765e-01f, -3.23244631e-02f, -9.14176702e-01f, -4.26791549e-01f, 4.04680595e-02f,
  5.40283382e-01f, -1.56999324e-02f, 2.71280259e-01f, -3.63657326e-01f, -7.32604742e-01f, -3.81997436e-01f, 4.43553537e-01f, -3.64639573e-02f, 2.07291216e-01f, 4.74223971e-01f,
  3.96368027e-01f, 4.16180342e-01f, -5.98513901e-01f, -6.42620400e-02f, 7.10129857e-01f, 9.69442904e-01f, -1.59770742e-01f, -2.79802293e-01f, -4.36429866e-02f, -5.42574823e-01f,
  -5.88670015e-01f, 6.33352280e-01f, -4.14940000e-01f, -9.07190237e-03f, -6.99956656e-01f, 6.10751629e-01f, 3.81605178e-01f, 3.30284804e-01f, -8.77271473e-01f, -1.41550228e-01f,
  -9.28520799e-01f, -8.08055818e-01f, -2.06961244e-01f, 1.99313655e-01f, -3.93460304e-01f, 1.53314903e-01f, 4.35623854e-01f, 3.27877551e-01f, -1.61473811e-01f, -2.46905401e-01f,
  -7.19946763e-03f, 2.94457585e-01f, 9.04168785e-02f, 3.49904954e-01f, 7.66486347e-01f, -2.09938750e-01f, 2.20903665e-01f, -7.55379647e-02f, -1.98650822e-01f, 6.24641418e-01f,
  8.08697522e-01f, -2.55925089e-01f, -9.08221751e-02f, -3.62936944e-01f, 1.49615064e-01f, -3.10684055e-01f, -5.76283187e-02f, -1.23678416e-01f, 1.90755278e-01f, 3.00864756e-01f,
  2.52442330e-01f, -4.57242317e-02f, -7.53442407e-01f, 1.38897136e-01f, -5.33237398e-01f, -6.45904958e-01f, -1.75651480e-02f, 2.33101025e-01f, 2.00261846e-02f, -3.24080855e-01f,
  3.18234265e-01f, 1.93375841e-01f, 1.51112199e-01f, -3.56102794e-01f, -9.80358198e-02f, -3.57302427e-01f, -2.45898023e-01f, -9.17896703e-02f, 5.76794624e-01f, 5.50270140e-01f,
  -8.64006400e-01f, 2.90703654e-01f, -1.18789464e-01f, 8.92924011e-01f, -6.20562017e-01f, -3.57095122e-01f, 7.32273817e-01f, 2.92500615e-01f, -1.77768648e-01f, -3.42717439e-01f,
  1.86538354e-01f, -5.18079460e-01f, -3.82749170e-01f, 3.84670615e-01f, -5.94517767e-01f, -4.64645773e-01f, 5.64642251e-01f, -2.49455824e-01f, -2.84266233e-01f, 3.75325233e-01f,
  2.68771976e-01f, -4.58951980e-01f, -6.71537399e-01f, 7.44964704e-02f, 6.74810350e-01f, 3.29667419e-01f, -7.79460417e-03f, 1.75826937e-01f, 6.84095621e-01f, 1.31047055e-01f,
  -1.30227972e-02f, -3.29242170e-01f, -7.30374396e-01f, -4.28354561e-01f, -5.66236198e-01f, -2.85995424e-01f, -4.02880371e-01f, -2.24336475e-01f, 1.41199395e-01f, -4.45900381e-01f,
  -3.31911445e-01f, 5.59870899e-01f, -2.32826825e-02f, 3.08006018e-01f, -7.37822831e-01f, 4.30390745e-01f, 2.41710648e-01f, -9.30702925e-01f, 5.53323561e-03f, -5.96386075e-01f,
  5.21569967e-01f, -4.65175152e-01f, -8.46425831e-01f, -6.24088168e-01f, -3.69919330e-01f, -8.86232018e-01f, 7.23229125e-02f, 4.13759917e-01f, 2.01189801e-01f, 5.09327948e-01f,
  6.15043163e-01f, 2.93989927e-01f, 7.89635181e-02f, -5.93109488e-01f, 4.19672102e-01f, 8.16329360e-01f, 7.30400860e-01f, 7.31301546e-01f, 5.76960742e-01f, 6.95757806e-01f,
  -9.75980043e-01f, -1.32969901e-01f, 3.63899529e-01f, 1.19788015e+00f, -5.78636110e-01f, -5.96759975e-01f, -1.61944759e+00f, -1.36947306e-02f, -2.38967717e-01f, 3.13518755e-02f,
  5.39586008e-01f, -1.12927818e+00f, -2.53458619e-01f, -4.89590019e-01f, -1.60849601e-01f, 4.42288488e-01f, -9.35200989e-01f, -2.31869407e-02f, -9.54561949e-01f, -4.36327249e-01f,
  -5.24202287e-01f, -4.51284051e-01f, -3.41496408e-01f, 1.14144415e-01f, -9.97390300e-02f, 4.17625457e-01f, 1.04871377e-01f, -2.20663816e-01f, -2.04483405e-01f, -4.76352870e-01f,
  3.33716244e-01f, -2.77536809e-01f, 4.75094080e-01f, 5.69522440e-01f, 5.12164235e-01f, -1.99757472e-01f, 1.64947212e-01f, 2.37686679e-01f, -1.13705425e-02f, 6.53014556e-02f,
  -7.91048586e-01f, -1.21160650e+00f, 1.15472697e-01f, 3.15475643e-01f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  -1.73522487e-01f, 1.22468114e-01f, 1.22754239e-02f, -3.52750510e-01f, -1.65116206e-01f, 4.52304669e-02f, 2.82435894e-01f, -1.78182125e-01f, -2.70731188e-02f, -6.88562403e-03f,
  3.20526659e-01f, -2.26212740e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 12, 8
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 12, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        32, 12, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        32, 12
    );
    }
    