/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 128 (x1)
    * Saída: 12
    * Buffer Máx: 128
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 128;
    const int FAN_MAX_BUFFER_SIZE = 128;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 38 x 120)
const int L0_fan_Wp_rows = 38;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -3.50411773e-01f, 9.91747826e-02f, 1.35486305e-01f, -2.29847342e-01f, -7.22380131e-02f, 3.15770805e-01f, 1.60506427e-01f, -5.71719371e-02f, -1.86378762e-01f, 4.91265543e-02f,
  -1.29172802e-01f, -1.35355189e-01f, 1.25370905e-01f, -1.73274167e-02f, -4.52539604e-03f, 1.56070977e-01f, -9.02836118e-03f, 4.77585047e-02f, 3.43235582e-02f, -1.37968808e-01f,
  -1.33511275e-01f, -9.34517607e-02f, 1.11652739e-01f, 1.43029271e-02f, -3.35510075e-02f, -1.34845614e-01f, 1.34700900e-02f, 5.05742431e-02f, 4.03297646e-03f, 3.04952338e-02f,
  2.22688578e-02f, -1.14398204e-01f, 3.13903987e-02f, 6.84868486e-04f, -2.14505419e-02f, -1.07411081e-02f, 2.36186758e-02f, 5.42664044e-02f, -2.55808770e-03f, -3.41865569e-02f,
  2.80683413e-02f, -7.34583661e-02f, -5.39879911e-02f, -6.45273328e-02f, -5.34013249e-02f, 3.59114595e-02f, -1.85650832e-03f, -6.68266974e-03f, -3.75867262e-02f, -2.95231175e-02f,
  4.53164987e-02f, -3.74168344e-02f, -2.17907112e-02f, 5.02603017e-02f, -3.24045890e-03f, -8.70721489e-02f, 4.65918295e-02f, 1.00577343e-02f, 2.27917265e-02f, 1.46406274e-02f,
  -1.98611785e-02f, 1.48414019e-02f, -2.98650824e-02f, -4.15059738e-02f, 8.77664238e-03f, -1.28034446e-02f, -3.73307280e-02f, 3.46183218e-02f, -1.28043192e-02f, 1.09118838e-02f,
  -2.25681830e-02f, -3.60701308e-02f, -6.19382132e-03f, 2.07142928e-03f, 2.99255550e-02f, -3.72593328e-02f, 3.44820321e-02f, -5.20590730e-02f, 7.29457438e-02f, -4.05893736e-02f,
  1.38133876e-02f, 9.35492292e-03f, 4.00287546e-02f, 6.51818216e-02f, 1.19340457e-02f, 1.66298216e-03f, 4.36282568e-02f, 6.18651658e-02f, -7.57418061e-03f, -5.14185708e-03f,
  8.95874351e-02f, -7.04338700e-02f, 9.28995758e-02f, 5.55247404e-02f, 3.27460095e-02f, 2.23739464e-02f, 5.69326989e-02f, 1.54731469e-02f, -2.85957977e-02f, 9.68184788e-03f,
  -4.28615659e-02f, 5.11822142e-02f, 6.77331463e-02f, 4.19524312e-02f, 3.20818052e-02f, -2.16070320e-02f, 2.34236065e-02f, 1.38199581e-02f, -3.74686308e-02f, 1.27938734e-02f,
  -1.08281903e-01f, 5.24614751e-02f, -2.76856944e-02f, -6.04060367e-02f, 7.78720761e-03f, 5.02462909e-02f, -2.32752394e-02f, -3.35006006e-02f, -4.41037752e-02f, 8.67042597e-03f,
  2.08177179e-01f, -1.09172482e-02f, 2.10052907e-01f, 6.63882270e-02f, -2.68039070e-02f, 4.18540686e-02f, 1.84448566e-02f, -1.84011310e-01f, -1.72229260e-01f, -9.59654897e-02f,
  -4.78396825e-02f, 2.72397786e-01f, 1.16125653e-02f, 9.55761746e-02f, -6.10282384e-02f, -5.48971891e-02f, -3.65623757e-02f, 3.04119084e-02f, -3.12215872e-02f, -5.86464517e-02f,
  -8.76162872e-02f, -1.65951192e-01f, 3.49551588e-02f, -1.84700996e-01f, 6.81172907e-02f, 8.01635906e-02f, 1.40986172e-02f, 1.97695717e-02f, 3.59100178e-02f, 3.09029948e-02f,
  1.31428742e-03f, -8.21523517e-02f, 1.01561911e-01f, -1.23146258e-03f, -1.05568536e-01f, -1.84554756e-02f, 8.52194056e-03f, 1.04115427e-01f, 5.21037243e-02f, -1.96104161e-02f,
  -1.43056279e-02f, -6.81798533e-02f, -5.19019458e-03f, 2.29269769e-02f, -3.88559960e-02f, 2.93720569e-02f, 8.06185901e-02f, 4.46614623e-02f, -1.87155064e-02f, 3.68742459e-02f,
  6.61432222e-02f, -3.97115536e-02f, 6.01307116e-02f, -3.37378643e-02f, -6.74234796e-03f, -1.64858885e-02f, 5.98667674e-02f, 1.21070169e-01f, -7.16454089e-02f, 5.57054132e-02f,
  3.91704030e-02f, -3.74405533e-02f, 3.33715267e-02f, 7.69294500e-02f, -2.40706503e-02f, -1.80489700e-02f, -2.99833734e-02f, 6.26385882e-02f, 7.00666979e-02f, 2.86813192e-02f,
  -7.94461668e-02f, -1.93029083e-02f, -7.02997223e-02f, 1.49774672e-02f, -1.13158859e-02f, -4.05972525e-02f, 1.07614249e-01f, 4.53077676e-03f, -7.13682398e-02f, -2.33694464e-02f,
  -7.09277540e-02f, -1.24540227e-02f, -3.95308584e-02f, -3.39319594e-02f, -5.69280088e-02f, 6.50184304e-02f, 1.24493679e-02f, 4.76227067e-02f, -9.27587971e-03f, 3.78501341e-02f,
  -1.04763612e-01f, -1.97763205e-01f, 3.54325399e-02f, -5.17777763e-02f, 5.48796263e-03f, 3.10609788e-02f, -2.93511823e-02f, 1.22055477e-02f, -1.27356008e-01f, -1.47823319e-02f,
  -5.06234579e-02f, 6.22166805e-02f, 1.69578027e-02f, -2.32953709e-02f, -1.39673678e-02f, -7.46281520e-02f, -9.37445685e-02f, -1.26876514e-02f, -3.03481966e-02f, 3.57444547e-02f,
  1.23948501e-02f, 4.77160513e-02f, -7.70484731e-02f, 9.85405035e-03f, -2.90322788e-02f, 2.93660313e-02f, 2.30987575e-02f, 6.63802847e-02f, -2.74315607e-02f, -9.50797722e-02f,
  -2.86400672e-02f, 7.83192441e-02f, -1.83376372e-01f, -1.52044892e-02f, 1.54968739e-01f, -2.08823428e-01f, -2.23676100e-01f, 5.60257137e-02f, -3.18426900e-02f, 1.19355880e-01f,
  -7.65092224e-02f, -2.49487106e-02f, -1.88268516e-02f, -1.75963417e-01f, -2.75861055e-01f, -2.87966907e-01f, -1.54541507e-01f, -5.52237481e-02f, -1.14517100e-01f, 2.98632719e-02f,
  -1.03456415e-01f, 5.29833930e-03f, -1.71486050e-01f, 1.78820550e-01f, 9.06120315e-02f, 1.43542334e-01f, 1.44410774e-01f, 3.40005523e-03f, 1.16049811e-01f, 7.16420710e-02f,
  8.49499032e-02f, -1.21157095e-02f, -3.39422040e-02f, 1.10356838e-01f, -1.86309498e-02f, 2.95187999e-02f, 4.48151119e-02f, -5.24076521e-02f, -8.23149234e-02f, 5.56747280e-02f,
  2.09568981e-02f, -4.51449770e-03f, 8.04033428e-02f, -5.48658706e-02f, 6.12706169e-02f, 2.73803230e-02f, 1.39982244e-02f, -3.94863710e-02f, 3.22198868e-02f, -4.65364493e-02f,
  -2.69374289e-02f, 3.30581740e-02f, 8.69216546e-02f, -2.18411703e-02f, -7.20397532e-02f, -8.33092406e-02f, -5.97839504e-02f, -8.17444697e-02f, 5.10382950e-02f, 5.57605252e-02f,
  4.51403335e-02f, -2.25421339e-02f, 2.49215029e-02f, -2.29793508e-02f, -1.72919929e-02f, 1.14609022e-02f, 1.76239684e-02f, -1.60185955e-02f, -5.40725812e-02f, 1.20757129e-02f,
  -5.88682387e-03f, 8.53579938e-02f, 8.78050458e-03f, 1.42523348e-02f, -1.43159665e-02f, -3.69456112e-02f, 7.84169696e-03f, 2.70268936e-02f, 3.67498323e-02f, -1.40865343e-02f,
  8.01724568e-02f, 4.14844602e-02f, 6.83391988e-02f, -6.36909623e-03f, 4.73912209e-02f, -7.74007514e-02f, 3.10978536e-02f, -2.16684416e-02f, 4.08174060e-02f, 1.96173117e-02f,
  -3.55621986e-02f, 5.32734841e-02f, -6.47765538e-03f, -3.76500264e-02f, 1.54809030e-02f, 6.15547504e-03f, -7.85477832e-02f, -3.01850028e-02f, 1.15476409e-02f, 3.39628384e-02f,
  -1.54523011e-02f, 9.06661036e-04f, 1.05119667e-04f, 5.36709949e-02f, 8.20812806e-02f, -5.81845418e-02f, 4.57351245e-02f, -9.98689141e-03f, 4.13076840e-02f, -4.74188616e-03f,
  9.49886888e-02f, 5.04560545e-02f, -3.79689187e-02f, 6.03175275e-02f, 5.17737260e-03f, 5.41284829e-02f, 2.20281491e-03f, 1.00098751e-01f, 6.12784661e-02f, -6.64179623e-02f,
  2.75573939e-01f, -1.55226365e-01f, -1.90035570e-02f, 2.26470411e-01f, -3.49933915e-02f, 3.18005234e-02f, 1.88271165e-01f, -2.13344041e-02f, 2.23491669e-01f, -6.62461817e-02f,
  1.18679300e-01f, 1.16344005e-01f, -1.14350505e-01f, 1.40789479e-01f, 1.96421370e-01f, 6.31447230e-03f, 5.30269034e-02f, 1.62159130e-01f, -1.39230664e-03f, 1.01768762e-01f,
  6.76245615e-02f, 4.41663116e-02f, -9.15054083e-02f, -1.46978363e-01f, -4.89148265e-03f, -1.18440017e-01f, -1.86054930e-02f, -9.30129215e-02f, -9.93100107e-02f, -9.63557884e-02f,
  1.30110234e-01f, 1.77246034e-01f, -6.09139958e-03f, -7.54454732e-02f, 2.57930979e-02f, 9.02175233e-02f, 3.58364731e-02f, 1.90956257e-02f, -3.50609334e-04f, 2.80906446e-02f,
  1.01132588e-02f, -3.08799613e-02f, -2.51916703e-02f, -4.16541174e-02f, 4.52946909e-02f, -9.08652470e-02f, -9.54062268e-02f, -7.75257796e-02f, -9.72710252e-02f, -8.12757108e-03f,
  7.86652863e-02f, -6.97273389e-02f, 1.63650718e-02f, -7.84028769e-02f, -1.68258941e-03f, -4.17892449e-02f, -5.19156456e-02f, -3.29321437e-02f, -1.75858464e-03f, 6.50122240e-02f,
  5.57849603e-03f, 8.93020816e-03f, -6.09695651e-02f, 3.19172372e-03f, -3.55572277e-03f, -3.73013057e-02f, 4.62331958e-02f, -1.41236661e-02f, -8.21330175e-02f, -5.05412631e-02f,
  7.24297166e-02f, 2.72534136e-02f, 4.02911194e-03f, 3.64757665e-02f, 4.07107882e-02f, 6.76674172e-02f, 2.86621116e-02f, -9.73003283e-02f, 3.13642360e-02f, 5.08366674e-02f,
  -2.51811277e-03f, 2.87110656e-02f, 3.09204403e-02f, 1.42390141e-02f, 3.26516964e-02f, -1.71486307e-02f, -2.75509655e-02f, -1.10288123e-02f, 4.71996441e-02f, -4.00532931e-02f,
  1.77386552e-01f, 1.17402896e-01f, 6.28344342e-02f, 3.23688574e-02f, -3.15225162e-02f, -7.21253976e-02f, 2.55193189e-02f, -1.86024141e-02f, 1.16552543e-02f, -4.56697075e-03f,
  -1.39417797e-02f, -5.48512712e-02f, -6.24995073e-03f, -6.12153150e-02f, 2.70253960e-02f, 3.67008783e-02f, 2.29794811e-02f, 8.22215527e-02f, 4.32098582e-02f, -6.60855845e-02f,
  -2.99136136e-02f, -2.14960091e-02f, 2.60250922e-02f, 3.39884683e-02f, -5.67011535e-02f, -6.00976236e-02f, -2.03277040e-02f, 4.20564711e-02f, 6.33750902e-03f, -2.61966605e-02f,
  8.91949236e-02f, 5.55949435e-02f, 2.28314936e-01f, 1.07567772e-01f, 5.69415353e-02f, -6.34438999e-04f, 1.79545656e-01f, 1.15769550e-01f, 2.09299847e-01f, 1.71472058e-02f,
  -6.82543069e-02f, 2.52812430e-02f, 3.78244407e-02f, 9.56991911e-02f, -6.84521198e-02f, -3.60748894e-03f, 1.20307252e-01f, -4.00436819e-02f, 9.06807855e-02f, 1.38330594e-01f,
  -5.52932695e-02f, -5.92756607e-02f, -3.55292670e-02f, -1.57353714e-01f, 2.44522654e-02f, -5.01899375e-03f, -1.18009500e-01f, 3.83592211e-02f, -1.04019139e-02f, -7.86484331e-02f,
  8.23666528e-02f, 1.33966029e-01f, 3.24215218e-02f, -4.87042032e-02f, -5.11020832e-02f, -5.15183955e-02f, -4.07520309e-02f, 1.86927766e-02f, -4.29965518e-02f, 5.83730340e-02f,
  6.69234172e-02f, 4.66021523e-02f, 6.92668930e-02f, -6.11128323e-02f, 1.66037958e-02f, 1.64044593e-02f, 7.29160607e-02f, -1.84299666e-02f, -5.60123175e-02f, 4.45993841e-02f,
  1.21631727e-01f, 3.51010002e-02f, -1.64421014e-02f, 1.80342551e-02f, 5.18519245e-02f, 4.76841778e-02f, 2.78258609e-04f, 5.14291823e-02f, -1.90703850e-02f, 5.20283170e-02f,
  5.24423681e-02f, 5.22310324e-02f, -6.82114810e-02f, 8.77210274e-02f, -1.94989573e-02f, 6.72735423e-02f, 8.31014439e-02f, -1.86076183e-02f, 8.74390900e-02f, -1.23133156e-02f,
  -5.20724058e-02f, 8.27750117e-02f, 2.33907765e-03f, 5.70886806e-02f, -2.88445149e-02f, 4.57986407e-02f, -4.10926230e-02f, -7.71572292e-02f, -3.90072539e-02f, -7.41172731e-02f,
  4.98196706e-02f, -3.17990519e-02f, -4.65902835e-02f, 3.78584266e-02f, -2.97515411e-02f, 9.14238691e-02f, 6.13715090e-02f, 9.15121511e-02f, 6.79976260e-03f, -8.33515376e-02f,
  -1.99707616e-02f, 4.94538955e-02f, 6.60712346e-02f, 6.39731064e-02f, 7.27818236e-02f, -4.00406830e-02f, 3.64885442e-02f, 2.68488247e-02f, -2.13141143e-02f, -5.29340766e-02f,
  9.57979169e-03f, 4.87438552e-02f, -9.48144868e-02f, 2.00930890e-02f, -4.46580760e-02f, 1.07677998e-02f, -5.95015648e-04f, 4.75677177e-02f, 2.78818738e-02f, 6.38699112e-03f,
  -2.43214378e-03f, -3.71840894e-02f, 5.76496422e-02f, -8.44202656e-03f, -9.23426747e-02f, -8.84228423e-02f, -1.18758790e-02f, 5.09723946e-02f, -1.78728171e-03f, -2.38311086e-02f,
  -3.41999494e-02f, -5.29338159e-02f, -6.04740856e-03f, -1.15495464e-02f, 7.90146366e-02f, 1.70417249e-01f, 4.57734056e-02f, 2.80814208e-02f, 2.19086967e-02f, -4.02170531e-02f,
  1.10459030e-02f, -1.25466928e-01f, 9.34733599e-02f, 1.10529445e-01f, 2.24829137e-01f, 1.86374247e-01f, 6.02448322e-02f, -3.96704674e-02f, 8.60722288e-02f, -7.93911442e-02f,
  1.30836710e-01f, 7.23385438e-02f, 1.38660803e-01f, 1.11972876e-01f, -1.24165274e-01f, -1.96328774e-01f, -6.03077793e-03f, -3.17018405e-02f, -6.95002377e-02f, 9.36588123e-02f,
  6.26189113e-02f, 7.73832249e-03f, 1.31085161e-02f, 4.19732444e-02f, -4.30302583e-02f, -3.90964039e-02f, -1.78271311e-03f, 3.41769047e-02f, -5.13230190e-02f, 6.01920448e-02f,
  -5.10820225e-02f, -1.22734383e-02f, -3.70465592e-02f, -4.96903062e-03f, -1.68992933e-02f, -2.47994950e-03f, 3.83845866e-02f, -4.31973115e-02f, 1.84440892e-03f, -1.15198654e-03f,
  -6.50739744e-02f, 3.67418081e-02f, -5.45765273e-03f, -2.95013282e-02f, -3.80728617e-02f, -4.76686098e-02f, -5.38799632e-03f, -3.00625823e-02f, -9.96046886e-02f, -3.02237570e-02f,
  -5.71480803e-02f, 2.78401114e-02f, 5.34583032e-02f, 3.45744304e-02f, 7.91340023e-02f, 6.01393059e-02f, -6.68634176e-02f, 1.85308158e-02f, -8.56388807e-02f, 3.45473625e-02f,
  -1.09727822e-01f, -7.61163458e-02f, -5.22632003e-02f, -3.62059064e-02f, -1.84908684e-03f, -3.94061953e-02f, -4.48680967e-02f, -1.30925362e-03f, -8.57296139e-02f, -2.26247255e-02f,
  4.50443709e-03f, -1.17585817e-02f, 4.92155105e-02f, -1.26401875e-02f, 5.72616421e-02f, 5.11710569e-02f, 1.80609114e-02f, -1.27234077e-02f, -6.44750241e-03f, 3.84950154e-02f,
  5.54688275e-03f, -2.48315036e-02f, -3.52523960e-02f, 2.13377513e-02f, -3.55241522e-02f, 5.74359344e-03f, 2.98406035e-02f, 5.48711978e-02f, -1.09830021e-03f, 7.18790144e-02f,
  -6.70912117e-02f, -3.85072790e-02f, -9.02087837e-02f, 5.26990443e-02f, -6.31867908e-03f, -5.19311382e-03f, -5.81197962e-02f, 2.84908973e-02f, -6.02881573e-02f, 1.61741246e-02f,
  -8.10764804e-02f, -6.61934316e-02f, 1.58526246e-02f, -8.33022234e-04f, -1.14199370e-02f, -8.90643299e-02f, 2.86339615e-02f, 6.49908045e-03f, 4.86714654e-02f, 4.10326198e-02f,
  1.90045521e-01f, 2.59604454e-01f, -3.75362188e-02f, 1.86792776e-01f, -1.75113559e-01f, -7.64711648e-02f, -7.86194056e-02f, 8.25415105e-02f, 2.18497828e-01f, 1.56101331e-01f,
  -1.96398020e-01f, 1.59466878e-01f, -8.08023661e-02f, -8.91672969e-02f, -1.10297717e-01f, -6.13182522e-02f, 3.39249857e-02f, 3.63099948e-02f, 1.20410167e-01f, 4.35558707e-02f,
  5.83572797e-02f, -9.24887881e-02f, -2.28671908e-01f, -1.09414414e-01f, -4.95278090e-02f, 1.32579282e-01f, -5.88331111e-02f, -1.33958861e-01f, -7.64103085e-02f, -1.41495973e-01f,
  6.53538108e-02f, 1.17339514e-01f, 8.77696201e-02f, -1.48666361e-02f, -7.45221321e-03f, 1.27803916e-02f, 2.90464610e-02f, -1.04282700e-01f, -1.17707280e-02f, 7.45108211e-03f,
  -1.37527278e-02f, 6.17570728e-02f, 7.17594549e-02f, -6.63167760e-02f, 1.52231287e-02f, -2.91373227e-02f, 3.97954322e-02f, -6.97199032e-02f, 5.68567887e-02f, -2.71281265e-02f,
  -7.58334994e-02f, -1.17702419e-02f, -2.63999943e-02f, 9.12405923e-03f, -1.96817759e-02f, 4.66912724e-02f, 2.96539087e-02f, 1.38474442e-02f, 6.67873025e-02f, -5.00142854e-03f,
  -3.75207439e-02f, -4.29141987e-03f, 5.68106323e-02f, -5.25124446e-02f, -4.54601534e-02f, -4.64716777e-02f, -5.92014864e-02f, 1.01325009e-02f, 1.41418548e-02f, -3.72642167e-02f,
  5.79044572e-04f, 3.68252099e-02f, -3.16396393e-02f, 7.02853082e-03f, -1.36508988e-02f, 3.63352485e-02f, 1.70974247e-02f, 7.09730014e-02f, -5.00862449e-02f, 2.03676596e-02f,
  -1.40727395e-02f, 4.09345925e-02f, 2.68304795e-02f, -9.16262344e-03f, -1.14213666e-02f, -6.18627109e-03f, 2.16012895e-02f, -3.62748504e-02f, -6.79618679e-03f, -1.82395801e-02f,
  2.51092553e-01f, 3.36211294e-01f, -4.59353589e-02f, 8.43843743e-02f, -1.34262722e-02f, 2.71246880e-02f, -3.20795029e-02f, 8.18719044e-02f, 3.97191904e-02f, 2.32934300e-02f,
  4.09253947e-02f, 3.38296629e-02f, 1.74581129e-02f, 4.45336252e-02f, -4.33153994e-02f, 6.33675233e-02f, 4.85972166e-02f, 7.41866976e-02f, 4.53306269e-03f, -3.14146876e-02f,
  1.03695996e-01f, 7.28598088e-02f, 3.84163298e-03f, 5.91472387e-02f, -4.10283133e-02f, -1.60045587e-02f, 2.26123389e-02f, -3.75850908e-02f, -6.28503710e-02f, 1.86893065e-03f,
  -1.60815760e-01f, 2.37044469e-01f, -9.16760042e-02f, -1.75818488e-01f, -2.21431896e-01f, -1.07061425e-02f, -2.60665757e-03f, 8.33677277e-02f, -7.09263310e-02f, 3.30786079e-01f,
  3.97717133e-02f, 6.31332621e-02f, 2.31395304e-01f, 1.59650788e-01f, -1.39704570e-01f, 2.70561546e-01f, 1.03935815e-01f, 4.68704179e-02f, -1.86197122e-03f, -8.83281976e-02f,
  -1.20918639e-02f, 1.57437637e-01f, 5.78981685e-03f, 1.60662979e-02f, -9.57145616e-02f, -1.77474439e-01f, -6.19904101e-02f, -1.68061957e-01f, 3.42926346e-02f, -1.05762981e-01f,
  7.63288960e-02f, 2.00321674e-02f, -7.49670789e-02f, 8.48550163e-03f, -6.53053448e-02f, -4.98484075e-03f, -6.84271678e-02f, 2.31662896e-02f, -1.47780210e-01f, 3.04344073e-02f,
  -3.15071680e-02f, -4.59252894e-02f, 2.32116506e-02f, -1.96684301e-02f, -1.23065673e-01f, -3.42940241e-02f, -1.68687440e-02f, -9.69453305e-02f, -3.73990759e-02f, -3.50261070e-02f,
  -5.70388092e-03f, 6.65404648e-02f, -2.33634543e-02f, 7.83919170e-02f, -1.25509307e-01f, -6.37907907e-02f, -4.69292663e-02f, -8.07138085e-02f, 5.77376224e-02f, 2.24187020e-02f,
  5.70313223e-02f, -5.22703044e-02f, 1.35926651e-02f, 4.06366549e-02f, -2.21009683e-02f, -4.95450050e-02f, 7.36191915e-03f, -3.90791520e-02f, -8.41100588e-02f, 4.18802118e-03f,
  -4.06386591e-02f, -2.55045388e-02f, -2.33908501e-02f, -3.86828445e-02f, -2.84107607e-02f, 4.92320918e-02f, 8.96361377e-03f, 1.50784850e-02f, -3.94388251e-02f, -6.80052117e-02f,
  1.82489734e-02f, -4.94338982e-02f, 6.29621893e-02f, 4.14509438e-02f, 6.23242110e-02f, -2.61354782e-02f, 1.78200193e-02f, 1.11368842e-01f, -2.97154188e-02f, -2.77980119e-02f,
  6.86043501e-02f, 9.71221700e-02f, 5.71898259e-02f, 2.43168585e-02f, 7.58866034e-03f, 7.36480281e-02f, 5.87014295e-02f, -1.99497491e-02f, 7.09936842e-02f, -2.62223128e-02f,
  4.41920236e-02f, -6.75168559e-02f, 2.36925129e-02f, -2.09078752e-03f, -2.89786141e-02f, 3.41403857e-02f, 2.41929181e-02f, -2.71611828e-02f, 5.88898687e-03f, 3.87175940e-02f,
  4.48039593e-03f, -6.53356984e-02f, 2.24244408e-02f, -5.13422489e-02f, 3.00902314e-02f, -4.52100970e-02f, 3.83641496e-02f, 4.25861664e-02f, -4.34632588e-04f, -3.21780033e-02f,
  4.49645430e-01f, -2.78127611e-01f, 1.64488837e-01f, 9.24774036e-02f, 1.36864498e-01f, 1.95613932e-02f, -1.14430182e-01f, -1.23769864e-01f, -1.09530397e-01f, -3.46469551e-01f,
  -1.70666203e-01f, 2.95206048e-02f, -1.65455058e-01f, -1.49745435e-01f, 1.06016085e-01f, -2.18114763e-01f, -2.11419955e-01f, -7.78936520e-02f, 3.81047428e-02f, 1.08380020e-02f,
  4.10428569e-02f, -2.06446260e-01f, -3.82020697e-02f, -1.36748433e-01f, 6.23699836e-02f, 1.36236608e-01f, -1.65757816e-02f, 8.51669461e-02f, -1.01224646e-01f, 2.84559447e-02f,
  4.57158871e-02f, -8.17100692e-04f, 9.64419246e-02f, 1.22809047e-02f, 9.92980376e-02f, 8.52804482e-02f, 5.65639697e-02f, 7.97920376e-02f, -2.77285017e-02f, 3.98027413e-02f,
  1.55570125e-03f, -2.89665833e-02f, -2.21620761e-02f, -4.87165861e-02f, 3.81797291e-02f, -3.94565314e-02f, -2.86631845e-02f, 1.45144463e-02f, -4.51050922e-02f, -2.53152903e-02f,
  -1.56316366e-02f, 6.60863966e-02f, 4.85725664e-02f, -4.48872112e-02f, 7.96373002e-03f, 5.06091025e-03f, -5.17341457e-02f, 4.98031527e-02f, 6.34432770e-03f, -3.67152132e-02f,
  -4.84408019e-03f, -2.51593813e-03f, 3.09552997e-02f, 2.35629920e-02f, 1.83764147e-03f, 1.91232916e-02f, 1.69632081e-02f, -3.30088921e-02f, 8.15608632e-03f, 8.10523611e-03f,
  -2.16348339e-02f, 9.12880003e-02f, -6.98135346e-02f, 1.45346010e-02f, 2.23078746e-02f, -1.48374797e-03f, 5.57217970e-02f, -5.09658381e-02f, 7.74575444e-03f, 2.51118816e-03f,
  -4.41299453e-02f, 3.90784331e-02f, -6.25118241e-02f, 4.36113589e-02f, -7.22090062e-03f, -2.35691853e-02f, -3.56663652e-02f, 2.39537582e-02f, -1.92284472e-02f, 8.13749358e-02f,
  -2.24646956e-01f, -2.52756417e-01f, -9.06097665e-02f, -3.09297312e-02f, -6.50239438e-02f, -3.30829434e-02f, -1.18113235e-02f, -5.45774761e-04f, 1.62361003e-02f, -3.25767957e-02f,
  5.33132181e-02f, 1.79933924e-02f, -1.29862018e-02f, 3.58307213e-02f, -1.00992676e-02f, 1.10682640e-02f, -4.63478267e-03f, 3.01823318e-02f, -2.29287110e-02f, 1.14978859e-02f,
  -5.37326699e-03f, -6.91353604e-02f, 3.22145298e-02f, 6.08903170e-02f, -3.56318988e-02f, -2.57526115e-02f, -1.17504876e-02f, -2.49888599e-02f, -6.68973429e-03f, -7.69457743e-02f,
  -9.26207304e-02f, 1.20862760e-01f, 2.45246828e-01f, -7.44549930e-02f, 2.15754837e-01f, 3.76150869e-02f, -8.48884657e-02f, 2.58616626e-01f, 1.50232524e-01f, -7.86352679e-02f,
  -8.61438289e-02f, -1.48446038e-01f, -2.21755598e-02f, -7.33489320e-02f, -1.07900895e-01f, 6.54964242e-03f, -1.90440178e-01f, -1.91525936e-01f, 1.27454087e-01f, -2.47536320e-02f,
  9.81014129e-03f, -1.86923638e-01f, -4.75143492e-02f, 5.36952429e-02f, 1.02683559e-01f, 6.20481595e-02f, -2.18194187e-01f, 1.59516737e-01f, -5.54455742e-02f, -1.63416041e-03f,
  -2.15343684e-02f, 3.57068330e-02f, 3.39665972e-02f, 2.66853683e-02f, -5.01610823e-02f, -7.91918412e-02f, -6.34294376e-02f, 9.72138066e-03f, 4.79968823e-02f, 1.88618507e-02f,
  -3.27280760e-02f, 1.80691890e-02f, -5.93969151e-02f, 5.11600114e-02f, 9.42472219e-02f, 7.39020901e-03f, 9.31326151e-02f, 6.30752593e-02f, 4.54332530e-02f, 1.44225121e-01f,
  4.92496006e-02f, -1.67954173e-02f, -1.83037054e-02f, 1.77917667e-02f, 1.23098288e-02f, 4.46214527e-02f, -3.47379558e-02f, -4.82179597e-02f, -1.45481376e-03f, -2.58609485e-02f,
  9.99471024e-02f, -4.63947840e-02f, -1.85153373e-02f, -2.05807853e-02f, -3.42738628e-02f, 5.18259890e-02f, -6.43782169e-02f, -7.17641935e-02f, -3.79580632e-02f, -1.28076952e-02f,
  -1.75169948e-02f, -7.33319670e-02f, 8.45055655e-02f, 6.56617358e-02f, -1.21841773e-01f, -1.42332800e-02f, -7.75668249e-02f, -2.95453575e-02f, 4.76807244e-02f, -2.17769183e-02f,
  -4.31304835e-02f, -4.48338874e-03f, -4.29393686e-02f, -8.45299754e-03f, 1.46779250e-02f, 4.84951073e-03f, -6.36621378e-04f, -2.70542596e-03f, 3.04460507e-02f, -2.28128973e-02f,
  -1.48378268e-01f, -6.03043959e-02f, 9.69490334e-02f, 3.35201137e-02f, -4.90259156e-02f, 4.44354713e-02f, -2.53583472e-02f, 9.43167019e-04f, 2.78653949e-02f, -3.38707194e-02f,
  -3.92951770e-03f, -1.98996458e-02f, -4.46705110e-02f, -9.66283493e-03f, 8.22748337e-03f, 4.90014069e-03f, -1.30879238e-01f, -3.31693143e-02f, -2.30378844e-02f, 4.63861413e-02f,
  3.80389020e-02f, 3.78667936e-02f, 3.18232775e-02f, -1.50096649e-02f, -3.46501619e-02f, -7.95266777e-02f, -6.68863729e-02f, 8.68948847e-02f, -3.46012902e-03f, 1.28907198e-02f,
  1.19443767e-01f, 1.47610202e-01f, -2.05962807e-02f, 1.16411239e-01f, 1.37119284e-02f, 1.17518567e-01f, -5.22425994e-02f, 2.40409821e-02f, 8.50891769e-02f, 4.17012200e-02f,
  -4.97082882e-02f, 9.27034393e-02f, -2.70592630e-01f, 2.32617185e-01f, -1.41094059e-01f, -1.03155255e-01f, 1.47537351e-01f, 1.08819716e-01f, -6.40462786e-02f, 9.39959213e-02f,
  1.34305907e-02f, -1.23302778e-02f, 4.74812370e-03f, 1.86051559e-02f, 1.64709374e-01f, 8.68441537e-02f, -1.86029717e-01f, -1.29653662e-01f, 2.06328556e-01f, -4.23608907e-02f,
  1.54654637e-01f, 6.11943565e-02f, 4.19768468e-02f, -2.43140832e-02f, -5.11389636e-02f, 4.74081449e-02f, 1.03136012e-03f, -5.25871329e-02f, -4.42995653e-02f, 1.89115684e-02f,
  -1.85217280e-02f, -6.40981644e-02f, 1.25531321e-02f, -6.67750090e-02f, 4.04673219e-02f, 4.28625196e-02f, 9.02355909e-02f, 7.16781430e-03f, 3.60378698e-02f, 7.71749392e-02f,
  7.50836506e-02f, 8.17955509e-02f, -1.24864234e-02f, 3.32619553e-03f, 4.05457020e-02f, 8.03990737e-02f, 7.34632984e-02f, -3.60449962e-02f, 6.92998767e-02f, -1.41589642e-02f,
  -1.26043083e-02f, 4.12984677e-02f, -3.18961614e-03f, -4.59449226e-03f, 1.52045330e-02f, 5.14281839e-02f, 1.60389375e-02f, -1.68503355e-02f, -4.49153371e-02f, -1.25196548e-02f,
  1.82204749e-02f, 6.08239621e-02f, -5.80862314e-02f, -1.48132034e-02f, 4.89862412e-02f, 8.63787681e-02f, 3.21919248e-02f, 2.03245580e-02f, 4.82375594e-03f, -1.99469477e-02f,
  -6.73475116e-02f, 5.14554419e-03f, -1.28007354e-02f, -4.82035726e-02f, 2.99336538e-02f, -1.00550376e-01f, -6.11955412e-02f, 6.51058927e-03f, -1.31763741e-02f, 1.05159814e-02f,
  8.74502212e-03f, -1.27268270e-01f, -3.53943780e-02f, 9.18547530e-03f, -5.68980072e-03f, 1.30199012e-03f, 8.03160891e-02f, 2.65896618e-02f, -6.38217805e-03f, -1.81910042e-02f,
  3.89939398e-02f, 1.11199673e-02f, 3.60224606e-03f, 9.32123140e-03f, 5.11776507e-02f, -5.17053045e-02f, -8.60799029e-02f, -4.39010747e-02f, -5.65423891e-02f, -3.62453349e-02f,
  -8.00678581e-02f, -1.54441213e-02f, 3.68991867e-02f, 7.68783391e-02f, -5.10479473e-02f, -7.33269900e-02f, 2.55116373e-02f, 1.40713025e-02f, 7.33298250e-03f, 3.44940908e-02f,
  -1.47002250e-01f, -2.56636828e-01f, -2.68751234e-01f, -2.04818442e-01f, 1.43023416e-01f, 1.32173479e-01f, 2.66456809e-02f, -8.22289009e-03f, -2.57426679e-01f, 4.71390188e-02f,
  1.67239264e-01f, -2.92208403e-01f, 1.59820974e-01f, 8.45335647e-02f, 5.56017756e-02f, 6.52488172e-02f, -3.22174169e-02f, -6.00683801e-02f, -6.47630990e-02f, -1.19333245e-01f,
  -4.65925643e-03f, 7.31705949e-02f, -3.49874869e-02f, 4.90870420e-03f, -3.81656736e-02f, -1.59283459e-01f, 1.19911671e-01f, 1.27817869e-01f, 4.09740806e-02f, 2.68919077e-02f,
  -7.43742613e-03f, -8.59007314e-02f, -5.84740527e-02f, -5.63809127e-02f, 9.32192197e-05f, 8.55173022e-02f, 3.45343351e-03f, 1.47089317e-01f, -6.58068359e-02f, -3.57121192e-02f,
  -5.85753731e-02f, 7.51219392e-02f, -5.88828176e-02f, 3.78339663e-02f, 2.36958656e-02f, -8.83521959e-02f, 4.13058251e-02f, -8.10981244e-02f, 6.72471896e-03f, -6.23405054e-02f,
  -5.20221293e-02f, -7.68277124e-02f, 3.23439091e-02f, 2.40650494e-02f, -3.25262137e-02f, 3.16598341e-02f, 2.94980463e-02f, 5.88608794e-02f, 2.13270038e-02f, -1.09353982e-01f,
  6.77993223e-02f, 5.67339687e-03f, 3.78571264e-02f, -3.50995245e-03f, 6.80022836e-02f, 3.43276002e-02f, 1.94064938e-02f, 4.06111889e-02f, 4.64160927e-02f, -1.88433956e-02f,
  -1.38792675e-02f, 4.31222375e-03f, 2.58210432e-02f, -4.62083966e-02f, -2.63253991e-02f, -5.28850183e-02f, 7.67383203e-02f, 1.97256040e-02f, -7.91124254e-02f, -3.16767842e-02f,
  4.09972761e-03f, -1.67696550e-03f, 2.20864695e-02f, 4.46119830e-02f, -1.08659116e-03f, -9.46524367e-03f, -6.48891903e-04f, 4.59844358e-02f, 3.08172517e-02f, 4.49705310e-02f,
  -1.00606821e-01f, -6.40066266e-02f, -7.18960464e-02f, -3.42974961e-02f, -2.39787828e-02f, 4.53642495e-02f, 3.58337909e-02f, -2.32499875e-02f, 3.59053425e-02f, 2.94291954e-02f,
  8.18741322e-02f, -5.62420525e-02f, -2.75323391e-02f, 1.07892975e-03f, -2.60341614e-02f, 4.33735847e-02f, -8.97031128e-02f, -3.44716199e-02f, -6.62598982e-02f, -7.89228640e-03f,
  8.21200982e-02f, -1.18019683e-02f, -2.74597276e-02f, 3.16286124e-02f, -2.15637288e-03f, 1.69659276e-02f, -8.27283114e-02f, -9.77054685e-02f, 1.40498346e-02f, -2.43640002e-02f,
  -2.93305099e-01f, 1.46630809e-01f, 6.05237223e-02f, 2.56179571e-02f, -9.96956676e-02f, -3.25456351e-01f, -2.23593190e-01f, 4.34405357e-02f, -1.51959851e-01f, 4.81379218e-02f,
  -9.51307043e-02f, 9.10407156e-02f, -3.00247502e-02f, -2.52668560e-02f, -2.88642555e-01f, -1.33063614e-01f, -1.29757732e-01f, -1.00761622e-01f, -1.01616513e-02f, 1.43136606e-02f,
  1.92817915e-02f, -7.78426975e-02f, 5.33439703e-02f, 2.42561191e-01f, 4.62852120e-02f, 1.85429439e-01f, 8.19798633e-02f, 1.53014258e-01f, 1.10331222e-01f, -2.70634424e-02f,
  -9.21721458e-02f, -2.06828713e-02f, -6.03425200e-04f, 7.78874308e-02f, 1.05348732e-02f, -7.38695785e-02f, -5.56215681e-02f, 4.33055758e-02f, 4.58324142e-02f, 3.31792645e-02f,
  3.27090034e-03f, 4.63507399e-02f, 6.40516430e-02f, 1.24224052e-02f, -3.60895060e-02f, 6.61770925e-02f, 2.22912878e-02f, -3.22993733e-02f, 5.22430092e-02f, 3.43469791e-02f,
  2.32796483e-02f, -4.29351851e-02f, -1.33721167e-02f, -9.42462403e-03f, 5.51414602e-02f, -3.47737521e-02f, -4.64729592e-02f, 4.44890819e-02f, -1.34028066e-02f, 4.43547368e-02f,
  -1.07913591e-01f, 1.58176944e-02f, -5.67846047e-03f, 9.94784385e-03f, -6.66994648e-03f, 1.31158270e-02f, -1.43679848e-03f, 4.80746739e-02f, 2.47335974e-02f, -5.47100678e-02f,
  -7.52896592e-02f, 7.75622055e-02f, 2.10202001e-02f, -6.77209347e-02f, 1.46624986e-02f, -2.96243243e-02f, 4.61608768e-02f, -3.17237563e-02f, -2.73417775e-02f, 2.92798746e-02f,
  -3.50663029e-02f, 6.58267271e-03f, -3.11569069e-02f, 4.51739803e-02f, 4.28224206e-02f, -2.59164143e-02f, 7.06732199e-02f, 3.05884574e-02f, -1.29923113e-02f, -7.03670159e-02f,
  -1.53992027e-01f, 9.79231000e-02f, 3.89993394e-04f, -6.22511655e-02f, 4.23081815e-02f, -3.58465873e-03f, 4.50116917e-02f, -4.97230962e-02f, -7.95845538e-02f, -4.08955850e-02f,
  -2.36981455e-03f, -2.68343408e-02f, -1.81756821e-02f, 5.60678281e-02f, -4.34390008e-02f, -4.86829095e-02f, -3.73815000e-02f, 3.95294726e-02f, -4.16346304e-02f, 6.32238463e-02f,
  2.50375811e-02f, -5.64961210e-02f, 2.84867659e-02f, 6.35337606e-02f, -1.63601898e-02f, 4.72968502e-04f, 1.92917679e-02f, -1.53360199e-02f, 1.27523672e-03f, -6.08325982e-03f,
  3.37159708e-02f, -1.33587960e-02f, -4.61312979e-02f, -8.67338926e-02f, -1.63760614e-02f, 3.88670027e-01f, 2.82273859e-01f, 3.99326980e-02f, -8.93848166e-02f, 1.34214804e-01f,
  1.10903211e-01f, -2.04084635e-01f, 1.66492119e-01f, 9.95021313e-02f, 1.55998349e-01f, 2.52557397e-01f, 1.95434913e-01f, 7.24075958e-02f, -2.73375977e-02f, -3.35348099e-02f,
  1.97262522e-02f, 1.44844100e-01f, -5.14414795e-02f, -2.66943537e-02f, 7.18730548e-03f, -2.25263759e-01f, -1.22705556e-01f, -1.10984623e-01f, -1.05361424e-01f, -5.79312863e-03f,
  9.77365747e-02f, -4.28124238e-03f, -1.53888611e-03f, -4.66326512e-02f, 1.37722585e-02f, -3.01430691e-02f, 3.68703087e-03f, -5.02157211e-02f, -1.91224869e-02f, -2.04862631e-03f,
  3.90466377e-02f, 2.02774592e-02f, -1.49381126e-03f, -2.79632024e-02f, 3.89578752e-02f, -7.68495053e-02f, -4.80206423e-02f, -1.69780198e-02f, -6.89254031e-02f, -3.92855182e-02f,
  -1.25158317e-02f, 3.66521664e-02f, -3.31956372e-02f, 4.14727209e-03f, -1.91684309e-02f, 5.11909164e-02f, -1.81237534e-02f, 1.59095488e-02f, -5.57860844e-02f, -8.44501483e-04f,
  -3.51335593e-02f, 5.62226549e-02f, 6.56524450e-02f, -2.38068160e-02f, -2.80152950e-02f, -3.88680324e-02f, -5.50548686e-03f, 3.09829209e-02f, 2.88379416e-02f, 3.55799980e-02f,
  -4.11623307e-02f, -3.29938158e-02f, 1.09440815e-02f, 7.42739290e-02f, -4.80856895e-02f, 3.87977026e-02f, 3.11124958e-02f, -3.09211621e-03f, -4.42598807e-03f, 1.87956709e-02f,
  -5.54751791e-02f, 9.74496976e-02f, -7.51717687e-02f, 1.33929197e-02f, 5.34584969e-02f, 3.19629721e-02f, -2.16633789e-02f, 1.46359783e-02f, -4.88684960e-02f, 6.70834482e-02f,
  1.09768562e-01f, -1.53816119e-01f, -2.69025229e-02f, -6.53393120e-02f, 4.66996171e-02f, 8.25431272e-02f, -3.95190865e-02f, -2.69396249e-02f, -6.95658326e-02f, -1.59469489e-02f,
  5.83269745e-02f, 3.29619907e-02f, 3.15515734e-02f, -5.29683800e-03f, -4.82721776e-02f, 6.56110197e-02f, -1.25641515e-02f, -9.49745439e-03f, 2.96305064e-02f, 6.62368489e-03f,
  3.49140838e-02f, 2.70077288e-02f, 2.34290748e-03f, -4.62050438e-02f, 1.81477908e-02f, -2.81381235e-02f, -2.26432197e-02f, 2.21638079e-03f, 2.27177255e-02f, -2.41445694e-02f,
  6.95706382e-02f, -1.93459272e-01f, 3.07396531e-01f, 2.00489148e-01f, 9.96706355e-03f, -7.72647262e-02f, 8.75485390e-02f, 8.80337656e-02f, 4.92478125e-02f, -2.07414553e-01f,
  -1.23340249e-01f, -3.41717862e-02f, -8.50418136e-02f, 2.00530887e-02f, 1.83900535e-01f, -4.62918989e-02f, 5.85555378e-03f, -1.52192125e-02f, 6.51043802e-02f, -2.08274592e-02f,
  1.62879422e-01f, -1.44930065e-01f, 1.90093264e-01f, 3.26733832e-04f, -2.14532427e-02f, 1.78573076e-02f, -1.35876939e-01f, -4.20319624e-02f, -2.68184226e-02f, -6.06594048e-03f,
  3.42277624e-02f, 3.36019024e-02f, 1.85464174e-02f, 8.36035609e-03f, -1.11863380e-02f, -3.42333615e-02f, -1.22555541e-02f, 1.20313261e-02f, 6.37566671e-03f, 6.20831065e-02f,
  -6.30303705e-03f, 7.24154934e-02f, 6.60856441e-02f, 9.26105380e-02f, -2.89264657e-02f, 2.22472046e-02f, 1.08438043e-03f, 4.10723500e-02f, 1.74527860e-03f, 9.70780477e-02f,
  2.29942380e-03f, -3.57973315e-02f, 7.23848864e-02f, -9.07829590e-03f, 4.01361138e-02f, 8.28483957e-04f, 7.86170736e-02f, 5.17510138e-02f, 1.95589429e-03f, 8.32731724e-02f,
  1.53168030e-02f, -7.38695115e-02f, 6.47097751e-02f, -2.46622004e-02f, -1.37702925e-02f, 1.13268034e-03f, 2.69295517e-02f, 3.74529958e-02f, 1.24458950e-02f, -3.15717272e-02f,
  -4.71238010e-02f, -8.23470391e-03f, -5.83513156e-02f, -3.39703746e-02f, -4.71500792e-02f, -1.03847887e-02f, 4.43042107e-02f, 1.72534939e-02f, 1.48951905e-02f, 1.95319150e-02f,
  4.53509353e-02f, -1.47830984e-02f, -5.23554683e-02f, 3.99056189e-02f, 4.87194248e-02f, -4.04911935e-02f, 2.47224048e-02f, 2.32725851e-02f, 7.11432053e-03f, -5.33260293e-02f,
  -3.16297501e-01f, -1.28857315e-01f, -1.37352690e-01f, -1.20610908e-01f, -3.08898240e-02f, -7.59496018e-02f, -1.62477195e-02f, 1.13659110e-02f, -7.91452527e-02f, -1.85995772e-02f,
  -6.31502271e-02f, -3.43385823e-02f, -5.64829707e-02f, -5.14162928e-02f, -6.33147061e-02f, 1.64255593e-02f, 2.71643419e-02f, -9.48918909e-02f, -3.14318165e-02f, -9.05660912e-02f,
  2.80090515e-02f, 8.62161256e-03f, -4.26352173e-02f, 9.82792210e-03f, -5.64712472e-02f, -5.94987124e-02f, -9.03112888e-02f, 6.29406469e-03f, -2.47415877e-03f, -4.90347221e-02f,
  1.36861354e-02f, -2.72250082e-02f, 8.21180120e-02f, 4.53261398e-02f, -2.52548337e-01f, -7.92362727e-03f, 3.03981211e-02f, -1.88804373e-01f, -3.27657238e-02f, 7.77779426e-03f,
  -5.34904860e-02f, 2.56083161e-01f, 7.75685459e-02f, -4.05841395e-02f, 2.33772382e-01f, 2.00380728e-01f, 5.34552857e-02f, 9.83732641e-02f, -3.27835828e-02f, -1.38976723e-01f,
  -8.95943046e-02f, -1.92470491e-01f, 3.52160782e-02f, -2.79436797e-01f, -1.73065588e-01f, -1.26497582e-01f, 1.21951448e-02f, -1.36115506e-01f, -3.36727947e-02f, 3.31705846e-02f,
  1.32141650e-01f, -7.03248531e-02f, -3.48797366e-02f, 2.27900296e-02f, -8.44395831e-02f, -5.48726171e-02f, 9.26114246e-02f, 6.93084672e-02f, 9.19943154e-02f, 5.13506271e-02f,
  3.67179811e-02f, -1.03898449e-02f, 4.53779101e-02f, 4.49926928e-02f, -5.34370393e-02f, -3.28088962e-02f, 9.91250761e-03f, -3.43108848e-02f, 4.12228480e-02f, -3.02805081e-02f,
  4.39487025e-02f, -1.01269940e-02f, -2.57220026e-03f, 8.67220983e-02f, 8.89196545e-02f, -8.50212127e-02f, 3.85514200e-02f, 7.18147168e-03f, 1.25249452e-03f, -6.07872568e-02f,
  -9.83914286e-02f, -2.12408975e-03f, -6.62367493e-02f, 4.94530462e-02f, 8.52366909e-03f, 2.36814320e-02f, -4.13976945e-02f, 2.32501607e-02f, 6.78410754e-02f, -3.74427773e-02f,
  -3.53598632e-02f, 2.51080608e-03f, -5.07148765e-02f, 3.25219184e-02f, -4.29766206e-03f, -5.31803370e-02f, -8.47526547e-03f, -8.45852960e-03f, 9.29399300e-03f, -1.08542228e-02f,
  1.55376066e-02f, 6.80754706e-02f, -4.59309295e-02f, 2.01903600e-02f, 3.70176546e-02f, 3.74180190e-02f, -8.85890499e-02f, 6.95683137e-02f, -4.49792370e-02f, 4.77445796e-02f,
  -3.41136903e-02f, -1.48614883e-01f, 1.95866730e-02f, -6.00392092e-03f, 6.38418868e-02f, -7.04095587e-02f, -3.22022997e-02f, -3.15228961e-02f, -2.66642850e-02f, -2.89142821e-02f,
  -4.89296280e-02f, 3.67030911e-02f, 8.57197214e-03f, -3.30965109e-02f, 1.47754988e-02f, 4.08747327e-03f, 1.20247016e-02f, 9.76710171e-02f, 4.36639460e-03f, -6.19253553e-02f,
  -8.56897086e-02f, -3.16657498e-02f, 2.00360361e-02f, -2.31295303e-02f, -1.56259090e-02f, 5.75782135e-02f, 2.63260435e-02f, -2.28645350e-03f, 2.16909461e-02f, 2.01073959e-02f,
  2.60602772e-01f, -1.89426124e-01f, -8.88429508e-02f, 2.44255010e-02f, -2.81055737e-02f, 9.24216211e-02f, 1.21064425e-01f, -8.52029920e-02f, 4.51575480e-02f, -1.15207329e-01f,
  -9.77810547e-02f, 1.07100643e-01f, -6.05154894e-02f, 1.56904701e-02f, 5.64652681e-01f, 1.13910653e-01f, 1.36870310e-01f, 1.59862280e-01f, 4.15681861e-03f, -1.64406467e-02f,
  1.18355617e-01f, 9.30647776e-02f, -1.26205042e-01f, -2.44092196e-01f, -1.06735960e-01f, -1.93390772e-01f, -1.85536705e-02f, -1.11533746e-01f, -1.01813497e-02f, 6.07241392e-02f,
  -8.53121057e-02f, -6.03251383e-02f, -1.12613648e-01f, -6.16935641e-02f, 2.30746735e-02f, -1.85004435e-02f, 4.00259569e-02f, 3.39355357e-02f, -5.04017025e-02f, 4.25209999e-02f,
  4.04000841e-02f, 1.83604695e-02f, 4.68196012e-02f, -1.27179688e-03f, 4.51107323e-03f, -7.59777054e-02f, -2.03722697e-02f, -7.16438144e-02f, -1.38988337e-02f, 2.68454831e-02f,
  -6.19743168e-02f, 4.02539447e-02f, 4.13543247e-02f, -1.81506965e-02f, 7.08027035e-02f, 1.69816539e-02f, 9.95374992e-02f, -9.03625623e-05f, 1.41592789e-02f, 4.19944637e-02f,
  3.36691029e-02f, 3.48437428e-02f, -3.17672174e-03f, -7.35239089e-02f, 6.86932728e-03f, -5.57114892e-02f, -2.08028145e-02f, 5.60612753e-02f, -4.18988196e-03f, -2.23443247e-04f,
  1.44340824e-02f, -4.33838170e-04f, 4.14862251e-03f, -1.69179738e-02f, -1.83991354e-03f, 1.60463285e-02f, 1.06026223e-02f, 2.96457931e-02f, 8.77333991e-03f, -1.98066924e-02f,
  -6.48806840e-02f, 5.75134680e-02f, -1.12151345e-02f, -1.94391608e-02f, 5.03616706e-02f, -6.77338541e-02f, 3.14514078e-02f, 1.23484461e-02f, 1.60163026e-02f, 7.71316439e-02f,
  9.73229557e-02f, 1.73291087e-01f, 6.02199277e-03f, -5.79864681e-02f, 2.88743135e-02f, -8.26366246e-03f, -1.39896302e-02f, -1.77311935e-02f, 1.92070715e-02f, 1.41791264e-02f,
  2.18707602e-02f, -4.70371805e-02f, -3.33504402e-03f, 5.99097200e-02f, -1.58867408e-02f, -4.52222489e-03f, 9.80282351e-02f, 5.52315712e-02f, 6.21423796e-02f, 1.86359789e-02f,
  -6.00369973e-03f, 4.26036716e-02f, 7.90061429e-03f, 3.42510194e-02f, 1.90396409e-03f, 5.56675643e-02f, -1.60702188e-02f, 5.23181520e-02f, 2.89620943e-02f, 1.25632621e-02f,
  -3.29518761e-03f, -1.00248374e-01f, 3.29388604e-02f, 5.12829721e-02f, 3.16536501e-02f, 1.16356485e-01f, 1.81678280e-01f, -2.49269977e-02f, -1.25466600e-01f, -6.87758019e-03f,
  1.28538013e-01f, 2.54170666e-03f, 6.66576857e-03f, 1.05947353e-01f, 3.96715663e-02f, -1.16067730e-01f, -1.89722758e-02f, 4.50603142e-02f, -2.48542428e-02f, 7.06048235e-02f,
  -7.34389201e-02f, 2.08594874e-01f, 3.36220413e-02f, -2.53772717e-02f, 1.56295359e-01f, -1.39141828e-03f, 1.52176812e-01f, 1.42644495e-01f, 1.27323434e-01f, 5.66528216e-02f,
  9.84473899e-03f, 1.27066122e-02f, 4.24881242e-02f, 2.34085578e-03f, -8.80224407e-02f, 1.72669478e-02f, 2.70230416e-02f, 9.32574272e-02f, 1.81412082e-02f, -7.06493035e-02f,
  4.28583175e-02f, -4.07132283e-02f, 8.10834859e-03f, -4.93802316e-02f, 2.62350999e-02f, -5.91057763e-02f, -8.22627395e-02f, -8.93682241e-02f, 1.67712662e-02f, -8.01319778e-02f,
  -3.04566473e-02f, -2.14110482e-02f, -7.86833167e-02f, -1.06996231e-01f, -4.77629490e-02f, 5.98510206e-02f, 2.51090117e-02f, 5.60946055e-02f, -9.09444839e-02f, -7.36875683e-02f,
  -5.69530651e-02f, 5.47248088e-02f, 7.62995034e-02f, -4.90517877e-02f, 8.90287943e-03f, -2.30739024e-02f, -5.65154552e-02f, 2.36144066e-02f, 4.80637066e-02f, 4.32334989e-02f,
  6.45621717e-02f, 3.13744321e-02f, 5.08559905e-02f, -2.78058909e-02f, -4.11204882e-02f, 9.89215076e-03f, -6.35462347e-04f, -4.68933061e-02f, -7.49449581e-02f, -7.77696669e-02f,
  -2.93341186e-02f, 2.35655271e-02f, -1.65866024e-03f, 2.65701897e-02f, -2.05674823e-02f, -1.46569218e-02f, -1.09951086e-02f, 1.25715975e-02f, -4.23922949e-02f, 7.04019964e-02f,
  -7.90093839e-02f, -2.46799123e-02f, -8.14861059e-02f, 8.42463747e-02f, -2.28500012e-02f, -6.62474930e-02f, 3.78798619e-02f, 2.83069834e-02f, 5.70036173e-02f, 4.44591194e-02f,
  -3.21072340e-03f, 7.89149851e-02f, -7.43398592e-02f, 3.14351209e-02f, 9.34244022e-02f, -2.31805537e-02f, 8.18445534e-02f, -3.77913937e-02f, -2.88631748e-02f, -2.64486037e-02f,
  4.13963385e-02f, -2.52017155e-02f, 7.63133960e-03f, -1.12125352e-02f, -9.47895832e-03f, 2.48480067e-02f, -3.79547812e-02f, -8.37394446e-02f, 8.86775404e-02f, -5.57484478e-02f,
  -3.09832245e-01f, 1.96516830e-02f, -4.25699204e-01f, -1.80124834e-01f, 2.01805145e-01f, 2.84485459e-01f, 8.77004191e-02f, 1.28161818e-01f, -5.98796122e-02f, 1.86812997e-01f,
  2.51546651e-01f, -9.84183326e-02f, -1.14090413e-01f, 1.03908695e-01f, -8.28704163e-02f, 5.51516982e-03f, 1.94158033e-01f, 7.69913867e-02f, -8.88162032e-02f, 6.95645362e-02f,
  -8.31690878e-02f, 2.66052455e-01f, -1.19057730e-01f, 2.38992348e-01f, 3.02783810e-02f, -2.18192972e-02f, 1.36199892e-01f, -6.39790297e-02f, 1.72447622e-01f, 3.71200889e-02f,
  3.49106155e-02f, -3.33267190e-02f, -7.05097690e-02f, -1.30820110e-01f, 2.54748370e-02f, -4.37691510e-02f, 4.36051330e-03f, -1.97562892e-02f, -4.39289063e-02f, 1.66424140e-02f,
  -6.83957189e-02f, 2.08500642e-02f, 2.09267326e-02f, 1.70561485e-02f, -1.63808893e-02f, 2.01032013e-02f, -2.83827372e-02f, 2.77453521e-03f, -2.45733988e-02f, -1.36709601e-01f,
  -9.26654115e-02f, 4.88637723e-02f, -4.15430106e-02f, 6.45003915e-02f, -3.99929322e-02f, -2.05532163e-02f, 4.65009399e-02f, 4.29110223e-04f, 1.00151487e-02f, 6.77520335e-02f,
  2.54407618e-03f, 2.68234070e-02f, -1.23969861e-03f, 2.51313159e-03f, -2.96638478e-02f, 1.35601507e-02f, 6.79056793e-02f, -3.88718098e-02f, -1.07907606e-02f, 6.87185861e-03f,
  4.59207632e-02f, -7.45653734e-02f, -2.55193003e-02f, -1.21872015e-02f, 7.78541109e-03f, -2.66503301e-02f, -1.64652523e-02f, -2.27288678e-02f, 3.61366244e-03f, 1.90395694e-02f,
  -3.80923152e-02f, 7.01468065e-02f, 1.62071805e-03f, -2.11144891e-02f, 8.25704541e-03f, -7.45988125e-03f, 4.75277342e-02f, -2.38343943e-02f, 2.72693373e-02f, -4.67802258e-03f,
  1.60690218e-01f, 6.18193820e-02f, -2.16249283e-02f, 1.31696165e-02f, -6.00508228e-02f, -1.53417001e-02f, -2.58999206e-02f, 5.13077341e-02f, -3.39598805e-02f, -2.68517584e-02f,
  1.16627128e-03f, 1.46376789e-02f, 2.26923693e-02f, -3.99271660e-02f, 6.63188249e-02f, 6.87854066e-02f, 3.63570526e-02f, 1.73764825e-02f, 1.10100888e-01f, 9.03511122e-02f,
  7.87777305e-02f, -2.17024181e-02f, 9.40446183e-03f, 5.84527403e-02f, 8.87882933e-02f, 4.45318148e-02f, 8.65313113e-02f, -5.28260367e-03f, 8.87426510e-02f, -1.17872069e-02f,
  4.07942742e-01f, -3.65380526e-01f, 7.68266991e-02f, 1.65724084e-01f, 2.12131172e-01f, 8.09563324e-03f, -1.21861368e-01f, 1.09860644e-01f, 4.28453460e-02f, -3.14290762e-01f,
  -7.61015639e-02f, -2.29028799e-02f, -2.65148103e-01f, -1.01913102e-01f, 2.93559849e-01f, -1.88020289e-01f, 1.20411441e-02f, -1.21634386e-01f, 1.26260174e-02f, 3.85925546e-02f,
  1.74929097e-01f, 8.74950271e-03f, 6.98341280e-02f, 1.25563974e-02f, 1.55250639e-01f, -1.78529602e-02f, 4.54482734e-02f, -2.49087624e-02f, 5.14218472e-02f, 2.10401905e-03f,
  7.53814653e-02f, -2.77702557e-03f, -3.49967219e-02f, 8.13029036e-02f, 6.31338134e-02f, 1.88846271e-02f, -4.66094874e-02f, -1.06773654e-03f, 4.32544202e-02f, 7.38595128e-02f,
  2.22794376e-02f, -3.79924364e-02f, -1.87428063e-03f, -2.37135999e-02f, 7.84407184e-02f, 1.00536048e-01f, 3.27757038e-02f, 3.82340350e-03f, 2.45155320e-02f, -7.26626813e-03f,
  2.42221262e-02f, -2.40132380e-02f, 5.51640615e-02f, -5.32368347e-02f, -1.43711164e-03f, 9.01027117e-03f, -9.79787707e-02f, -1.99823007e-02f, -3.94256562e-02f, 2.71141045e-02f,
  -2.56142523e-02f, -2.85650026e-02f, 3.28235961e-02f, 6.80019483e-02f, 8.89690127e-03f, 9.84935649e-03f, -1.11918086e-02f, 2.25720764e-03f, 6.04931749e-02f, -5.49451932e-02f,
  4.04970869e-02f, 1.81454420e-02f, 4.30400893e-02f, 3.80551480e-02f, 3.00761200e-02f, -1.16531672e-02f, 6.56320676e-02f, -3.54457535e-02f, -1.16038704e-02f, 2.78438367e-02f,
  -1.03546018e-02f, 9.89107881e-04f, -5.91836870e-02f, -5.70938748e-04f, 2.15620939e-02f, 3.58284116e-02f, 7.48866063e-04f, 3.33126970e-02f, 3.52728218e-02f, 6.26700148e-02f,
  -1.19527109e-01f, -2.83316970e-01f, -8.15463513e-02f, -4.80568632e-02f, -1.01543806e-01f, -2.74436772e-02f, -5.00034839e-02f, -5.83264558e-03f, 1.48471107e-03f, -1.70910358e-02f,
  -4.09857780e-02f, 7.17286468e-02f, -6.87016100e-02f, 4.84366864e-02f, -7.11411238e-02f, -5.97800985e-02f, -5.77761270e-02f, -1.90479476e-02f, 4.09370475e-02f, 2.68342867e-02f,
  -2.54711136e-02f, -2.90693566e-02f, -2.41854079e-02f, 8.79743323e-03f, -1.14078773e-02f, 7.10328296e-03f, 7.91632980e-02f, 6.23166608e-03f, 4.20890823e-02f, -7.02835619e-02f,
  -1.03319742e-01f, 1.08082015e-02f, -5.60043231e-02f, 1.05493732e-01f, -4.77267131e-02f, -2.47348398e-01f, -2.34395340e-01f, 1.91162489e-02f, -1.91711381e-01f, 8.26397762e-02f,
  1.35742128e-01f, 1.63982779e-01f, -1.28221616e-01f, 1.54952884e-01f, 2.33562086e-02f, -9.91676003e-02f, -2.10309643e-02f, 1.59215517e-02f, -8.46307874e-02f, 1.40621336e-02f,
  -3.54152285e-02f, 1.33275554e-01f, 1.20785207e-01f, 1.04471005e-01f, 1.37524903e-01f, 1.89580515e-01f, 2.90170580e-01f, -2.94960197e-02f, 1.88614234e-01f, 2.48174313e-02f,
  -9.82727557e-02f, -7.21619725e-02f, 2.44841781e-02f, -1.49535453e-02f, 3.75027172e-02f, -2.53270976e-02f, -3.17644998e-02f, 1.87633820e-02f, -1.53133934e-02f, -8.77665877e-02f,
  6.22957759e-02f, 6.16257116e-02f, 5.83387259e-03f, 2.35738866e-02f, -1.89115498e-02f, 4.37468477e-02f, 1.33888191e-02f, -2.87808944e-02f, 1.13229863e-02f, -7.44074956e-02f,
  1.80400498e-02f, 4.17388836e-03f, 1.24584632e-02f, -2.85872221e-02f, -1.87447909e-02f, -2.77869552e-02f, -6.67031556e-02f, -1.66697260e-02f, -1.02377171e-02f, 7.39662489e-03f,
  -3.73415612e-02f, -2.32223626e-02f, -1.90112041e-03f, -3.68114710e-02f, -3.28098945e-02f, 8.65399614e-02f, -4.08734344e-02f, 4.80979867e-02f, 5.18597886e-02f, -2.74330582e-02f,
  4.85475324e-02f, 2.08906829e-02f, 4.33919728e-02f, -4.94115651e-02f, 3.55090015e-02f, -1.26321232e-02f, 2.98014171e-02f, 2.96699535e-02f, 2.24508438e-02f, -1.15589693e-03f,
  3.56774144e-02f, 5.34683419e-03f, 8.07579085e-02f, -4.87403087e-02f, -1.23753930e-02f, -7.22694099e-02f, 1.14132874e-01f, -3.68324704e-02f, 4.22321036e-02f, -1.69096217e-02f,
  -2.76989080e-02f, -3.31179053e-02f, -2.03296617e-02f, 4.38241735e-02f, -4.62643895e-03f, 1.14134550e-02f, 2.74392013e-02f, 5.18045202e-02f, 2.02077590e-02f, -4.15720791e-03f,
  7.64429718e-02f, -4.38085124e-02f, 2.12661494e-02f, -1.79363396e-02f, -1.13293109e-02f, 3.74162458e-02f, -5.29252877e-03f, 6.68563321e-02f, -1.94601864e-02f, 9.34709609e-02f,
  1.10976338e-01f, 5.36868498e-02f, -2.95571648e-02f, 3.04261670e-02f, 1.42118218e-03f, -2.95520537e-02f, -3.32596451e-02f, -6.29637539e-02f, 5.74258640e-02f, 1.83018520e-02f,
  3.53511482e-01f, -2.09627360e-01f, 2.35622618e-02f, 1.95860133e-01f, 4.26005572e-03f, -6.86089369e-03f, 3.78873646e-02f, -5.35637103e-02f, -7.21537918e-02f, -2.21004352e-01f,
  -3.71478572e-02f, 3.62131111e-02f, -7.01615214e-02f, 5.82844317e-02f, 1.50164574e-01f, -9.43785012e-02f, 7.96900764e-02f, -5.98359481e-02f, 3.09106018e-02f, 2.14103445e-01f,
  1.35728016e-01f, 3.08873076e-02f, 1.67083904e-01f, 2.89493408e-02f, 1.23391576e-01f, 6.78960606e-02f, 4.81625237e-02f, 3.28478031e-02f, 6.58682585e-02f, 1.42365054e-03f,
  1.37405470e-01f, -6.85533229e-03f, 6.10324144e-02f, -7.13109449e-02f, 1.21783964e-01f, 8.90479982e-02f, -3.08744665e-02f, -4.48124073e-02f, -2.10512765e-02f, 1.38279395e-02f,
  2.98397783e-02f, 2.81271711e-02f, -1.51297441e-02f, -6.46843016e-02f, -7.16800615e-02f, 5.03028929e-02f, -3.92372161e-02f, -1.15150427e-02f, 2.20648907e-02f, -6.97952881e-02f,
  2.05113832e-02f, 3.02587613e-03f, 1.09105418e-02f, 3.49926725e-02f, 4.44184653e-02f, -5.69902360e-02f, 1.81864742e-02f, -1.71666685e-02f, -7.73875937e-02f, -7.53861433e-03f,
  5.57815209e-02f, 1.28226550e-02f, -3.70637663e-02f, 5.13939373e-03f, 3.44916172e-02f, -5.79811968e-02f, -5.65909334e-02f, -4.34967466e-02f, 1.43334884e-02f, 3.51866730e-03f,
  2.14096252e-02f, -2.17950232e-02f, 5.54191973e-03f, -1.73437074e-02f, 5.88054806e-02f, 4.50607091e-02f, 6.56948015e-02f, 6.60924017e-02f, 5.12154289e-02f, 5.01101092e-03f,
  -3.52892056e-02f, 4.78394935e-03f, -6.27943724e-02f, 4.67180870e-02f, 3.04051042e-02f, 6.38647890e-03f, 2.47347206e-02f, -2.06208788e-02f, 6.37620762e-02f, 1.67502612e-02f,
  1.12887129e-01f, 1.57389849e-01f, 3.41951139e-02f, 1.93029698e-02f, -5.15499674e-02f, -2.69289012e-03f, 8.47289115e-02f, 3.99091952e-02f, -4.55728881e-02f, 6.32309318e-02f,
  5.73529676e-02f, -2.33592372e-03f, 1.82478633e-02f, -4.68917079e-02f, -4.17506173e-02f, -2.35561077e-02f, 4.91271801e-02f, 8.65077898e-02f, 5.97735532e-02f, 7.12881908e-02f,
  5.40521890e-02f, 3.81652154e-02f, 4.39982153e-02f, -5.35269491e-02f, -6.06328659e-02f, 2.31840052e-02f, -1.50429998e-02f, -1.81259215e-02f, -3.80076654e-02f, 2.66256724e-02f,
  6.78763986e-02f, 4.10812795e-02f, -1.76706895e-01f, 2.03887075e-01f, -1.14722230e-01f, -7.75149912e-02f, 1.03630446e-01f, -4.00102371e-03f, 7.03373104e-02f, 1.32075489e-01f,
  4.50839363e-02f, -5.36371022e-02f, -1.75059199e-01f, 2.18440101e-01f, 3.58724929e-02f, -1.24904029e-01f, 3.27442616e-01f, 1.33631915e-01f, -8.07841197e-02f, 7.92445987e-02f,
  1.06990762e-01f, 2.49074027e-01f, -4.48329654e-03f, -3.40301340e-04f, 9.13084000e-02f, 3.26439403e-02f, 5.67439720e-02f, -1.89481348e-01f, 6.93649650e-02f, -3.83393094e-02f,
  1.84894115e-01f, 1.73625257e-02f, 1.86359591e-03f, -3.06208134e-02f, 1.14672706e-01f, -1.14049949e-02f, 5.53367734e-02f, -1.36611611e-01f, 3.11137401e-02f, -6.43715933e-02f,
  -2.58547254e-02f, -6.42686188e-02f, 2.68597994e-02f, -2.97720786e-02f, -2.49441974e-02f, 2.66606677e-02f, -1.99714638e-02f, -2.82705594e-02f, 2.48362478e-02f, 1.69990063e-02f,
  -3.21438946e-02f, -4.59329598e-02f, 9.52975601e-02f, -3.85953188e-02f, -7.61806816e-02f, -2.05786787e-02f, 6.29193187e-02f, -1.00960113e-01f, -3.80501561e-02f, 3.54349948e-02f,
  -7.29831830e-02f, -1.26255061e-02f, -1.34624615e-02f, 2.75221765e-02f, -1.22824153e-02f, 3.12921368e-02f, -5.33851758e-02f, -4.06239629e-02f, -8.14442430e-03f, 3.43749449e-02f,
  1.08556813e-02f, 6.39220327e-02f, 3.36904861e-02f, 4.16230150e-02f, 7.96794668e-02f, -2.75635365e-02f, -3.00416946e-02f, 3.50547358e-02f, 9.47725475e-02f, -3.92621756e-02f,
  -1.72300562e-02f, -1.76152829e-02f, 1.98761746e-02f, 3.69083025e-02f, 1.45563930e-02f, -7.02713653e-02f, 2.71955580e-02f, 2.07649861e-02f, 4.13710112e-03f, -4.61808853e-02f,
  2.02652931e-01f, 2.32819259e-01f, 1.38178868e-02f, 1.64056178e-02f, 2.16957205e-03f, -4.52028289e-02f, -3.73882875e-02f, 3.04777082e-02f, -1.07564880e-02f, -1.95430592e-02f,
  4.08756845e-02f, 1.29045518e-02f, -3.19582969e-02f, 1.40566379e-02f, -2.67592669e-02f, 8.35810304e-02f, 1.46506205e-02f, -1.12056686e-02f, -2.60836370e-02f, 8.76231566e-02f,
  -3.31929103e-02f, 4.79605654e-03f, -3.12630720e-02f, 9.74328890e-02f, 7.01419115e-02f, -7.65618309e-03f, -3.46919000e-02f, -1.61222201e-02f, 1.38475038e-02f, -7.13055721e-03f,
  1.55703351e-01f, 6.81773797e-02f, 1.89419091e-01f, 1.37691647e-01f, -2.15237781e-01f, 9.03120339e-02f, 1.76597722e-02f, -4.11911048e-02f, 2.43245751e-01f, -6.73649386e-02f,
  -1.93957746e-01f, 2.59952068e-01f, 9.96129028e-03f, 8.56851111e-04f, 2.02929169e-01f, 9.39815342e-02f, 6.91133067e-02f, 1.35717578e-02f, 1.09180108e-01f, -1.08617311e-03f,
  8.12858865e-02f, -2.60113686e-01f, -5.65523393e-02f, -2.21752673e-01f, -1.75918773e-01f, -4.19708863e-02f, -1.99895963e-01f, -3.80071662e-02f, -1.13607399e-01f, -1.38332015e-02f,
  -4.35210504e-02f, -1.22879677e-01f, 1.29781454e-03f, 9.99136195e-02f, -4.93993051e-02f, -4.87798080e-02f, 5.07279038e-02f, -2.03808900e-02f, -3.71307693e-02f, -5.36808372e-02f,
  3.25512737e-02f, 9.81133431e-03f, 5.87303899e-02f, -1.34601491e-02f, 9.43347998e-03f, 6.65262640e-02f, -3.27489004e-02f, -9.45520401e-02f, 1.59653798e-02f, -3.94335277e-02f,
  4.01468687e-02f, -4.80091758e-02f, 5.45869395e-02f, 4.49892785e-03f, -3.03764138e-02f, -6.93376036e-03f, 7.17831999e-02f, -1.65398289e-02f, -1.42382486e-02f, 9.13660154e-02f,
  -2.57587638e-02f, 4.72495146e-02f, -1.31748011e-02f, 2.98103746e-02f, -2.91612279e-02f, -6.95625320e-02f, -1.46755083e-02f, -6.42835572e-02f, 2.37998217e-02f, -3.33804227e-02f,
  -1.93602964e-03f, -1.85489897e-02f, 3.56915444e-02f, -1.99159179e-02f, 1.46582155e-02f, 3.22172865e-02f, 3.59254070e-02f, 6.33360222e-02f, 3.36846933e-02f, -2.13314984e-02f,
  -3.60422470e-02f, 5.48809469e-02f, -4.63132001e-02f, -2.63367463e-02f, 4.18012962e-02f, -5.15274890e-02f, -4.63865697e-02f, -6.41045452e-04f, -2.60309353e-02f, -2.09454373e-02f,
  -9.44546610e-02f, 1.30427569e-01f, -7.21249208e-02f, -8.64509866e-02f, 5.20395264e-02f, -4.99561913e-02f, 4.75284718e-02f, 9.37346742e-02f, 1.02080718e-01f, 4.81326208e-02f,
  2.35997699e-02f, 1.16105322e-02f, 6.38713613e-02f, 1.41093315e-05f, 2.10971441e-02f, -7.25210905e-02f, 1.41852698e-03f, 4.02646922e-02f, -3.68407853e-02f, 7.62053113e-03f,
  -5.66361733e-02f, -2.69299969e-02f, 6.90622255e-02f, 3.26086432e-02f, 3.98467295e-02f, -1.36512220e-02f, 5.24012074e-02f, 6.11461885e-03f, 2.16936562e-02f, 3.64840310e-03f,
  -3.89294773e-01f, 2.85514921e-01f, 1.82493374e-01f, -9.82035697e-02f, -9.69932452e-02f, 3.86742018e-02f, 9.37384367e-02f, 3.65300998e-02f, -4.92371097e-02f, 1.28745332e-01f,
  6.83792606e-02f, -9.16377977e-02f, 2.80611753e-01f, 2.18949899e-01f, 4.24126871e-02f, 2.14406088e-01f, 4.96017933e-03f, 7.15827197e-02f, -4.63297926e-02f, 4.32677679e-02f,
  -1.01082891e-01f, 5.48759028e-02f, 2.40869254e-01f, 9.83797908e-02f, 2.46675033e-02f, -1.41070515e-01f, -9.60764363e-02f, 2.01974139e-02f, 2.29782443e-02f, 1.06415935e-01f,
  3.66148129e-02f, 3.39671262e-02f, -7.20269755e-02f, 8.34628642e-02f, 5.49617186e-02f, -8.71834308e-02f, -9.07438919e-02f, 4.54264618e-02f, 4.38091010e-02f, -2.33188961e-02f,
  -9.48455036e-02f, 3.19831744e-02f, -3.38739045e-02f, 1.03858048e-02f, -1.48583043e-04f, -4.73850518e-02f, 6.13326803e-02f, 2.58665700e-02f, 1.67770870e-02f, 5.69925196e-02f,
  3.94208468e-02f, 2.74470448e-02f, -1.04082981e-03f, 3.07530127e-02f, -1.52028808e-02f, 5.13672642e-02f, -1.42715750e-02f, 5.45622706e-02f, -5.91421984e-02f, -2.97969747e-02f,
  -5.41442446e-02f, 9.54153202e-03f, 1.26833856e-01f, 1.77322445e-03f, 3.76518890e-02f, 8.70333891e-03f, 8.48691165e-02f, 6.58961087e-02f, 2.15696301e-02f, 5.37826307e-02f,
  4.98018749e-02f, 2.70314310e-02f, 6.53123036e-02f, 8.59334040e-03f, -2.29973681e-02f, 3.27933766e-02f, -2.57198475e-02f, 1.91394072e-02f, -2.95009147e-02f, 3.26347239e-02f,
  2.08679475e-02f, 2.08715778e-02f, 6.78251013e-02f, -1.63154416e-02f, 1.10453798e-03f, -1.61870159e-02f, -3.53018870e-03f, 3.56281474e-02f, -1.31345941e-02f, -8.10688809e-02f,
  5.92249222e-02f, -1.32988684e-03f, -1.13322074e-02f, 2.28554122e-02f, -2.04514507e-02f, -6.95567802e-02f, 5.12724631e-02f, 1.78313386e-02f, -3.58716771e-02f, -1.93301123e-02f,
  1.68044530e-02f, -1.39451046e-02f, -2.66708471e-02f, -5.42481951e-02f, -3.86888906e-02f, 3.46212387e-02f, 5.14128171e-02f, -6.83052987e-02f, -2.64253421e-03f, 2.23792512e-02f,
  3.82270552e-02f, 4.42867540e-03f, 1.21883601e-02f, -9.83972996e-02f, -4.36642617e-02f, -1.26158390e-02f, -4.70209755e-02f, -2.46227868e-02f, 2.92087700e-02f, 4.36476320e-02f,
  9.83986259e-03f, -8.41940567e-02f, -6.48045018e-02f, -1.47961825e-01f, -1.95437938e-01f, -2.28624836e-01f, -2.17663869e-01f, -1.57574981e-01f, -1.93863735e-01f, 6.10950552e-02f,
  -9.71598476e-02f, 1.25239259e-02f, -7.20935175e-03f, -2.95117527e-01f, -2.07961023e-01f, -6.70732036e-02f, -2.31418356e-01f, -1.25662610e-01f, -7.45613649e-02f, -4.62437458e-02f,
  -6.51581883e-02f, -1.02766566e-01f, -1.37495086e-01f, 9.63538289e-02f, -1.78743869e-01f, 5.04298694e-02f, 1.42457992e-01f, 2.57974789e-02f, -5.47040515e-02f, -3.95235494e-02f,
  8.22852273e-03f, -5.01264334e-02f, -4.31466661e-02f, 2.94435527e-02f, 2.36297003e-03f, -4.43352247e-03f, 1.99478846e-02f, -2.61953119e-02f, -1.95627045e-02f, -8.54001790e-02f,
  4.45900746e-02f, -5.24190739e-02f, 4.10742462e-02f, -2.30888687e-02f, -1.92467216e-02f, -2.72534285e-02f, -2.21651942e-02f, -2.90037394e-02f, -7.40518719e-02f, 1.84539557e-02f,
  -2.30308250e-02f, -4.12722789e-02f, -8.10462534e-02f, -7.53225340e-03f, -9.05296057e-02f, -6.38808757e-02f, -6.08448945e-02f, -2.75182258e-03f, -2.10707244e-02f, -9.20689479e-02f,
  6.21639052e-03f, 3.70583013e-02f, -2.20730938e-02f, -5.27169071e-02f, -3.19383740e-02f, 3.19219045e-02f, -7.35493079e-02f, 3.66509296e-02f, -1.38660381e-02f, -5.94803505e-03f,
  -3.52371857e-02f, -4.70370390e-02f, 6.92504644e-03f, -1.27419401e-02f, -6.85797632e-02f, 8.08745250e-03f, 6.88295960e-02f, 3.98199111e-02f, -1.29503999e-02f, -4.01181951e-02f,
  -2.51026265e-02f, 1.91585235e-02f, -3.17270570e-02f, 7.63638467e-02f, -6.61977977e-02f, 4.67840433e-02f, -1.81267876e-03f, -4.31097597e-02f, 3.65954898e-02f, 7.14827105e-02f,
  -1.26758367e-01f, 1.21295899e-01f, 3.95601206e-02f, 1.91492643e-02f, 4.04278561e-02f, 4.29029316e-02f, 2.55014952e-02f, -1.57627575e-02f, -2.18713712e-02f, 5.79518192e-02f,
  3.58693935e-02f, -1.42447734e-02f, -1.06577314e-02f, 2.61441302e-02f, -3.05617023e-02f, 1.69146899e-02f, 3.63289826e-02f, 3.19939628e-02f, -6.06192369e-03f, 5.72730089e-03f,
  2.13024933e-02f, -2.68971082e-02f, 3.39431055e-02f, -6.45275787e-02f, 5.06852195e-02f, 5.64899147e-02f, 4.61479649e-02f, 4.02476378e-02f, 2.73209605e-02f, -5.77749982e-02f,
  -3.88905823e-01f, -1.20493039e-01f, -2.50620041e-02f, -1.91464156e-01f, -5.07139415e-02f, -1.48335159e-01f, -1.05807506e-01f, -3.92290652e-02f, -1.66749172e-02f, 7.10701272e-02f,
  1.35522615e-02f, -8.44158903e-02f, 1.69673026e-01f, -8.16235691e-02f, -1.82390362e-01f, 2.07735613e-01f, -1.34655029e-01f, -9.11149904e-02f, 6.62598759e-02f, -2.19223961e-01f,
  -7.09723309e-02f, -3.44745182e-02f, -6.88491506e-04f, -7.64817977e-03f, -1.11568466e-01f, -5.80993742e-02f, 5.51961474e-02f, 1.25634938e-01f, -1.46573395e-01f, -1.00020664e-02f,
  -1.28856674e-01f, -2.84117237e-02f, 5.45541234e-02f, 4.96928394e-02f, -9.92498696e-02f, 5.60928732e-02f, -6.11779466e-02f, 1.11780494e-01f, 4.38572979e-03f, -2.92586330e-02f,
  -3.97867784e-02f, 1.38337146e-02f, -2.70597786e-02f, 5.96503466e-02f, 5.74698858e-03f, -2.70156600e-02f, 2.58345623e-02f, 4.51660827e-02f, -4.38875817e-02f, -6.90804273e-02f,
  -1.53423371e-02f, -1.94803178e-02f, 3.48691642e-02f, -1.24163339e-02f, -2.00006701e-02f, 1.82050001e-02f, 1.34541793e-02f, -1.00422055e-01f, -1.12457000e-01f, -9.53303501e-02f,
  -5.09806089e-02f, 4.74612415e-02f, 9.05112305e-04f, -2.21416317e-02f, 2.55019516e-02f, 2.12814473e-02f, -5.45043908e-02f, -7.65154837e-03f, 3.53234150e-02f, -4.37591039e-02f,
  -2.33377758e-02f, -4.30087075e-02f, 5.05989380e-02f, -2.05906220e-02f, 2.62041320e-03f, 1.77663565e-02f, -2.10960172e-02f, -5.56503013e-02f, 2.00963765e-02f, -2.20983922e-02f,
  -4.77425521e-03f, -5.84225990e-02f, -5.55478455e-03f, 3.61049771e-02f, 2.41429601e-02f, 4.28582396e-04f, -1.27799325e-02f, -2.35348642e-02f, 4.31203172e-02f, -1.58645101e-02f,
  -3.02098334e-01f, -2.59590268e-01f, -1.95689257e-02f, -2.92759780e-02f, -3.60385105e-02f, -4.87330183e-02f, -2.59494353e-02f, 1.23951724e-03f, 1.22964857e-02f, -2.62032989e-02f,
  -5.52048068e-03f, -3.45527902e-02f, -8.76495317e-02f, -1.30275665e-02f, -2.46483535e-02f, 9.67669021e-03f, -1.73113530e-03f, -4.85990234e-02f, -2.27994770e-02f, 1.17169702e-02f,
  -6.35556728e-02f, 6.60182349e-03f, -4.42274325e-02f, 9.40262247e-03f, -9.33032134e-04f, -5.76510876e-02f, -9.09634531e-02f, 2.69271955e-02f, -2.83624940e-02f, -3.48294824e-02f,
  -4.43659443e-03f, -2.57595122e-01f, -3.17648768e-01f, -1.77862421e-02f, -3.20823714e-02f, 3.57138850e-02f, -8.47878382e-02f, -1.61933452e-01f, -1.17098168e-01f, -5.87843023e-02f,
  9.85576138e-02f, -4.09753583e-02f, -4.73131835e-02f, -3.57602872e-02f, 2.50655651e-01f, 7.75215030e-02f, -5.81703521e-02f, 8.38939995e-02f, -9.86759588e-02f, -5.29074073e-02f,
  -8.41972455e-02f, 1.46084070e-01f, -4.05683666e-02f, 9.08961613e-03f, -1.40188217e-01f, -1.16866559e-01f, 1.12665631e-01f, -8.08623880e-02f, -6.48891693e-03f, 1.45342126e-01f,
  1.65654328e-02f, -3.82458232e-02f, -9.24141891e-03f, 5.82075827e-02f, -1.05370261e-01f, 3.69743481e-02f, 2.83544660e-02f, 1.01936661e-01f, 8.90624803e-03f, -6.81790709e-02f,
  -8.22132751e-02f, -3.07453033e-02f, 4.73836586e-02f, 4.21386696e-02f, -6.37326017e-02f, -5.35674505e-02f, -5.11822626e-02f, 3.24449688e-02f, -1.12789616e-01f, 5.32923872e-03f,
  -9.45354179e-02f, -7.79108331e-02f, -4.58854809e-02f, -1.52151892e-02f, 3.49890888e-02f, -8.01532641e-02f, 4.72016186e-02f, -5.11114970e-02f, -8.84205569e-03f, 3.50253694e-02f,
  -4.65554297e-02f, -6.36682659e-02f, -1.83713958e-02f, -3.74191627e-03f, 9.01560578e-03f, -1.12889400e-02f, 7.01494748e-03f, 5.80894537e-02f, -7.70750642e-02f, -3.78392413e-02f,
  4.59468514e-02f, -1.44385248e-02f, 3.79767418e-02f, 2.03683078e-02f, -6.14593215e-02f, -2.49652620e-02f, -4.04852405e-02f, -1.40696019e-02f, -9.56525356e-02f, 8.44251737e-03f,
  5.31796105e-02f, -1.49356155e-02f, -5.38110696e-02f, -1.69898178e-02f, 8.27691238e-03f, 6.33398667e-02f, -3.75031345e-02f, 1.15649682e-03f, -2.59438213e-02f, 5.17684519e-02f,
  -7.04166666e-02f, -2.15381861e-01f, -1.04290724e-01f, 1.95516702e-02f, 6.35428950e-02f, -4.80128527e-02f, -1.21421237e-02f, 1.18722124e-02f, -6.85632452e-02f, -1.47141609e-02f,
  5.87043464e-02f, 7.41841048e-02f, -6.56240508e-02f, 6.29193336e-02f, 6.41076192e-02f, -1.75432190e-02f, 6.71341121e-02f, -7.39475042e-02f, 5.13761230e-02f, 4.61629555e-02f,
  5.38285784e-02f, -2.54943948e-02f, -3.65262181e-02f, -4.06485703e-03f, 6.51686415e-02f, 6.44164681e-02f, -7.64268711e-02f, -5.63205965e-03f, 1.91796087e-02f, -2.66513191e-02f,
  3.69894743e-01f, -9.44003537e-02f, -7.66011849e-02f, 3.89591187e-01f, -2.30560750e-02f, 1.29614592e-01f, 2.10276514e-01f, 9.26482454e-02f, 1.24637857e-01f, -8.36780444e-02f,
  1.38864249e-01f, -8.26887265e-02f, -1.46414205e-01f, 2.71198213e-01f, 3.99417162e-01f, -2.80066393e-02f, 2.67922074e-01f, 1.47753775e-01f, -6.10195547e-02f, 9.83584225e-02f,
  1.80870131e-01f, 2.74422139e-01f, 3.50806750e-02f, -7.39447102e-02f, 1.69428885e-01f, 6.24712510e-03f, 5.26149757e-02f, -1.82371050e-01f, 7.27522299e-02f, -1.58484709e-02f,
  2.24754885e-02f, 5.95463030e-02f, -5.17653674e-02f, -2.24623550e-02f, 3.08466330e-02f, -8.38296954e-04f, 4.81624417e-02f, -3.10822204e-02f, 5.30791581e-02f, 9.42540239e-04f,
  -5.81951551e-02f, -1.81434825e-02f, 2.27944627e-02f, -2.24797148e-02f, 3.27749774e-02f, -2.17313543e-02f, 1.63658597e-02f, -4.93322797e-02f, 3.09511013e-02f, 3.83212417e-03f,
  3.04292459e-02f, -2.15783305e-02f, 4.01053950e-02f, -4.55377065e-02f, 1.70921274e-02f, -1.26457419e-02f, 7.77177792e-03f, -4.86482456e-02f, -4.12849709e-02f, 2.20672879e-03f,
  5.12718782e-02f, -1.82727166e-02f, 1.16336858e-02f, -2.90193446e-02f, 4.46456000e-02f, -1.49498433e-02f, 2.52916031e-02f, 1.69510245e-02f, 1.70138255e-02f, 3.06301303e-02f,
  -1.86064783e-02f, 3.46319228e-02f, 1.19521897e-02f, -7.98390992e-03f, 7.33523741e-02f, 6.39285846e-03f, 1.76838189e-02f, -4.92914803e-02f, 9.18700639e-03f, -2.24624909e-02f,
  -1.30736474e-02f, 1.07338727e-02f, -4.99148294e-03f, -3.22107449e-02f, -1.06183309e-02f, -3.92668359e-02f, 2.91842432e-03f, -8.25283751e-02f, -4.48236503e-02f, -1.08307144e-02f,
  -1.88293308e-02f, -1.80244185e-02f, -5.55824023e-03f, -2.81289853e-02f, -2.20334530e-02f, 5.59001043e-02f, -1.08030960e-02f, -1.20753841e-02f, 2.08115727e-02f, 2.42423061e-02f,
  -8.49328469e-03f, 2.84145586e-02f, -1.35214310e-02f, 1.03176041e-02f, 2.90878527e-02f, 9.11076888e-02f, 2.38818154e-02f, 4.71727438e-02f, 3.24445143e-02f, -4.43854323e-03f,
  -4.76064458e-02f, 2.05129180e-02f, -7.02833524e-03f, 5.89962974e-02f, -3.29904705e-02f, 4.70616855e-02f, 1.47789391e-02f, -1.97460093e-02f, -6.38995618e-02f, 1.93856731e-02f,
  -2.71860600e-01f, -4.70136432e-03f, 5.77836670e-02f, 5.06907143e-02f, -1.30278766e-01f, 1.55996770e-01f, 1.81318760e-01f, -5.60013354e-02f, -2.98822850e-01f, 1.83682933e-01f,
  1.69590235e-01f, -2.26374939e-01f, 7.93567225e-02f, 2.33564347e-01f, 2.30300009e-01f, 9.95773226e-02f, 2.27424875e-01f, 9.93784517e-02f, -2.13861652e-02f, 2.53457371e-02f,
  3.15221548e-02f, 2.18830407e-01f, 2.10122347e-01f, 8.14121664e-02f, 5.70942648e-02f, -1.92604288e-02f, 9.23619419e-02f, -1.54914958e-02f, 1.02590516e-01f, 4.29142043e-02f,
  1.12161875e-01f, -1.35872945e-01f, -2.38067973e-02f, -1.53724784e-02f, 3.95212099e-02f, -1.90365408e-02f, 1.06405281e-01f, 6.36772811e-02f, -1.68564934e-02f, -2.44258922e-02f,
  -5.41992523e-02f, 1.14666102e-02f, -5.10628261e-02f, 6.79995166e-03f, -1.06095597e-01f, 5.57136582e-03f, -1.17197921e-02f, -3.65459919e-02f, -8.16837102e-02f, 4.67203148e-02f,
  4.49812505e-03f, -3.14228795e-02f, 3.76012251e-02f, 7.04539614e-03f, 3.29812728e-02f, -4.76756766e-02f, 1.68897621e-02f, 3.15970220e-02f, -1.30504509e-02f, -3.94595899e-02f,
  5.07711316e-04f, -9.60219838e-03f, -4.01506610e-02f, -5.37228864e-03f, -4.56271134e-02f, 4.80374917e-02f, 2.31234916e-02f, 4.98597287e-02f, -4.77034412e-02f, 3.99313904e-02f,
  -2.05513909e-02f, -5.81844226e-02f, -3.79427113e-02f, 4.72553521e-02f, -2.09444873e-02f, 1.06560849e-02f, 7.28573725e-02f, -2.06069574e-02f, 3.89261991e-02f, -3.02250553e-02f,
  1.43499859e-02f, -1.84737723e-02f, -5.95147274e-02f, 1.35102468e-02f, 1.94660984e-02f, -8.23867023e-02f, -1.21885501e-02f, -2.18883399e-02f, -2.68366151e-02f, 8.57415050e-02f,
  6.43451586e-02f, 1.14539586e-01f, -6.70444965e-02f, -6.86263144e-02f, 4.48592305e-02f, 4.79757451e-02f, -4.73480411e-02f, -1.02868965e-02f, -2.16647610e-02f, -2.52025481e-03f,
  -1.71707675e-03f, 3.16894129e-02f, 6.51281178e-02f, 1.67587567e-02f, 4.15525958e-02f, 1.55739430e-02f, 6.56657061e-03f, 6.64841831e-02f, 6.35688603e-02f, 2.51564998e-02f,
  1.01936208e-02f, 2.29253974e-02f, -7.51309618e-02f, -3.79384309e-02f, 5.19950427e-02f, 2.73371357e-02f, -7.43540796e-03f, -4.95374054e-02f, 2.63091773e-02f, 3.41070555e-02f,
  1.07279727e-02f, -6.59654941e-03f, 2.65762806e-01f, -7.91426823e-02f, -1.34395406e-01f, 9.12133530e-02f, 2.56631166e-01f, -9.30866227e-02f, 1.55883417e-01f, 5.20332530e-02f,
  -8.10610130e-02f, 1.59804732e-01f, 1.20548300e-01f, -2.03352019e-01f, -1.90303981e-01f, -4.87919934e-02f, -2.41416931e-01f, -3.24581303e-02f, -1.19594567e-01f, -2.17079103e-01f,
  -1.17672563e-01f, -3.65221411e-01f, -8.37835073e-02f, -3.12489092e-01f, -1.84580702e-02f, 4.25859690e-02f, -1.74217433e-01f, 3.59929428e-02f, -1.26996934e-01f, -9.03970301e-02f,
  1.01761026e-02f, 4.05482352e-02f, 1.20224833e-01f, 1.15130678e-01f, -6.81407899e-02f, 4.47457731e-02f, 6.54178262e-02f, 7.74146542e-02f, 3.12547646e-02f, -2.94464314e-03f,
  4.01690528e-02f, -5.46234138e-02f, -1.03857107e-01f, 9.35612060e-03f, 1.55973225e-03f, 7.87949339e-02f, 2.22407514e-03f, 2.96500977e-02f, 8.46630856e-02f, -2.78301146e-02f,
  9.96896178e-02f, 2.73694936e-02f, 7.31951520e-02f, 2.50787009e-02f, 4.92111258e-02f, 2.98049208e-02f, 9.34733003e-02f, 6.89829588e-02f, -5.67892976e-02f, 2.95182550e-03f,
  -1.25968652e-02f, -5.30684404e-02f, 2.41121445e-02f, -4.17699777e-02f, -2.63343584e-02f, 6.59624999e-03f, 6.69334037e-03f, -4.26152200e-02f, 7.20483661e-02f, -4.17839363e-02f,
  -4.74017411e-02f, -1.30901057e-02f, 5.78698330e-02f, 3.15084346e-02f, -2.85055600e-02f, 3.45580578e-02f, -2.59312037e-02f, -3.01438961e-02f, 3.46660949e-02f, -1.57372467e-02f,
  2.14243904e-02f, -3.41412313e-02f, -7.55721144e-03f, -1.47817312e-02f, -1.99309457e-02f, -4.94304171e-04f, 1.61341131e-02f, -1.28374109e-02f, 1.20789418e-02f, -2.84010991e-02f,
  -1.81939244e-01f, -2.82281905e-01f, -4.54528593e-02f, -5.13744392e-02f, 2.14627432e-03f, -1.44017851e-02f, -9.94723141e-02f, -9.70426202e-02f, -3.91723104e-02f, -4.36498597e-02f,
  -3.24838087e-02f, 5.62707409e-02f, 1.13959862e-02f, 2.50246041e-02f, 2.63692494e-02f, -7.01428205e-02f, 9.02286149e-04f, 1.01207616e-02f, -7.55916908e-02f, -5.83849214e-02f,
  -8.95625129e-02f, -6.54379353e-02f, 1.38580585e-02f, -6.44030795e-02f, -3.60302255e-02f, -4.67838049e-02f, -4.54707816e-02f, 4.28777561e-02f, -4.30478193e-02f, 4.22920324e-02f,
  -1.63032427e-01f, 1.97999999e-02f, 1.05720185e-01f, -2.34792039e-01f, -2.56290678e-02f, 2.06356030e-02f, -8.75444040e-02f, 4.50689755e-02f, 1.83527887e-01f, -1.64960578e-01f,
  -1.87332019e-01f, -1.41967893e-01f, 1.38680086e-01f, -2.82602966e-01f, 1.76257007e-02f, 1.12685226e-01f, -1.78265035e-01f, -1.44050002e-01f, 1.88288748e-01f, -7.45432749e-02f,
  3.49734724e-02f, -1.19911559e-01f, -2.22465917e-02f, -3.13163474e-02f, -1.78709105e-01f, -3.26313674e-02f, -1.32446989e-01f, 1.19656585e-02f, -2.10939273e-01f, 1.30909141e-02f,
  -9.26543996e-02f, 3.69899087e-02f, -5.01784943e-02f, -1.38378134e-02f, 3.68151627e-02f, -6.20281734e-02f, -9.24728811e-02f, -4.31462377e-02f, 3.39316316e-02f, 5.22699840e-02f,
  -4.34963629e-02f, 5.54936789e-02f, -2.13873629e-02f, 2.59668436e-02f, 1.51837496e-02f, -2.45657074e-03f, 4.71285731e-02f, -3.10975574e-02f, 6.32656589e-02f, -6.24716021e-02f,
  2.16794312e-02f, -6.26237616e-02f, -5.46692647e-02f, -3.65559310e-02f, 9.47468430e-02f, -4.67599854e-02f, -4.87534218e-02f, -1.46365957e-02f, 6.55825890e-04f, 6.57622442e-02f,
  4.27721767e-03f, -3.98345031e-02f, 1.15091670e-02f, 1.74898859e-02f, -3.46862786e-02f, 8.62447359e-03f, -2.21375301e-02f, 2.77503859e-02f, -1.51562085e-02f, 8.44650058e-05f,
  -6.93898182e-04f, -2.32233535e-02f, -5.73130585e-02f, -3.90835218e-02f, 5.83953969e-03f, -1.89892284e-03f, 3.75977755e-02f, 5.50554460e-03f, -2.54082344e-02f, 6.40150532e-03f,
  5.05205616e-02f, 2.84271613e-02f, -2.14850865e-02f, -2.12202892e-02f, -8.30102991e-03f, -6.10131770e-02f, -1.16203912e-03f, 7.10094795e-02f, -3.62323485e-02f, -3.06364633e-02f,
  7.50612170e-02f, 8.96643698e-02f, 2.04204135e-02f, 7.39744306e-03f, -2.49514896e-02f, -2.24338043e-02f, -1.11972522e-02f, -2.17809211e-02f, 5.87803824e-03f, 2.72901952e-02f,
  -1.23564247e-02f, -8.09430033e-02f, -5.19470796e-02f, -4.80340561e-03f, 3.82484347e-02f, -2.83812881e-02f, -7.96912014e-02f, -3.87088768e-02f, 7.05768401e-03f, 1.28710913e-02f,
  -3.99600305e-02f, 3.65864970e-02f, -1.49896217e-03f, 4.74197678e-02f, -7.28186518e-02f, -1.30221341e-02f, -4.15103398e-02f, 4.23129871e-02f, 5.24226241e-02f, 1.95586644e-02f,
  -1.80456355e-01f, 1.68671861e-01f, -2.01282188e-01f, -2.90335923e-01f, 1.34888530e-01f, -1.19962841e-01f, -5.30467257e-02f, 4.62623164e-02f, 2.22227653e-03f, 2.46672958e-01f,
  1.27340198e-01f, -1.01409130e-01f, 2.01993600e-01f, -1.74809679e-01f, -2.91898668e-01f, -1.36868199e-02f, -2.01295152e-01f, -9.01969597e-02f, -5.28847054e-02f, -4.29303683e-02f,
  -1.42510086e-01f, -1.30852051e-02f, -8.25652704e-02f, 4.27183993e-02f, -4.85536419e-02f, -6.00081831e-02f, 5.48863336e-02f, 7.51100779e-02f, -1.12369366e-01f, 1.81683600e-02f,
  -1.07952654e-01f, 6.17823936e-02f, 2.44803391e-02f, -2.89205350e-02f, 1.57661198e-04f, 5.75854182e-02f, -2.45227246e-03f, 4.55698036e-02f, -1.01422995e-01f, -5.37231378e-02f,
  9.40569676e-03f, -6.56803027e-02f, -8.13880861e-02f, 6.01541959e-02f, 4.89310250e-02f, -2.59647314e-02f, -5.25442325e-02f, -8.27841610e-02f, 1.09550487e-02f, 2.81352866e-02f,
  -5.95362298e-02f, 4.64071566e-03f, -1.57196317e-02f, -1.09366246e-01f, -2.44676825e-02f, 4.75406609e-02f, 1.11078303e-02f, 1.19786886e-02f, -1.39291855e-02f, 2.40347255e-02f,
  -1.45094935e-02f, -4.70823608e-02f, 3.33535895e-02f, -3.45351361e-02f, 4.19482999e-02f, 1.00269355e-02f, -7.19454000e-03f, 2.80303955e-02f, 4.63579521e-02f, -3.69796753e-02f,
  -6.86330870e-02f, -1.41835632e-02f, -2.65958859e-03f, -1.44850947e-02f, -1.26172146e-02f, -5.24037816e-02f, 3.32819074e-02f, 2.98330076e-02f, -9.23664495e-02f, -8.26902166e-02f,
  7.20227882e-02f, 2.36471575e-02f, -3.76678584e-03f, -5.73262610e-02f, 3.01384218e-02f, -1.66228153e-02f, 6.74582943e-02f, 1.13018556e-03f, 4.78550717e-02f, -2.73995288e-02f,
  -7.41446449e-04f, -2.65212409e-04f, 4.47824672e-02f, -4.51467140e-03f, -6.45125955e-02f, -1.90535635e-02f, -4.57819998e-02f, -2.26413179e-02f, -3.94666847e-03f, 1.29906666e-02f,
  -3.03548994e-03f, -2.13729162e-02f, 3.40746678e-02f, 6.65806327e-03f, -8.05236399e-02f, 6.47854013e-03f, 6.18156679e-02f, 3.95615362e-02f, -3.71638797e-02f, -3.12603936e-02f,
  -1.55996371e-04f, 4.24259342e-02f, 1.53684588e-02f, 6.82328343e-02f, -7.85304755e-02f, -3.33113223e-02f, 1.11521697e-02f, -1.22586330e-02f, -2.97297239e-02f, -6.01047464e-02f,
  8.66591930e-02f, 1.13615923e-01f, 6.17476813e-02f, 1.24400653e-01f, 6.92908615e-02f, -2.13449478e-01f, -2.59228766e-01f, 1.72781512e-01f, 2.32351512e-01f, -1.04040019e-01f,
  2.03815680e-02f, 1.74997579e-02f, -9.29517969e-02f, 1.81702953e-02f, 9.46629718e-02f, -1.45392781e-02f, 5.60253561e-02f, -1.40212104e-01f, 4.81878892e-02f, 5.40346131e-02f,
  1.66001916e-01f, 1.20225191e-01f, -4.18781256e-03f, 1.05846211e-01f, 6.20057769e-02f, 1.35216385e-01f, -2.53261346e-02f, -7.27818757e-02f, 1.10877287e-02f, 3.25266719e-02f,
  -3.46237831e-02f, 7.34522194e-02f, 2.07819324e-02f, 1.96658447e-02f, 2.45333482e-02f, -8.55083317e-02f, -8.59296694e-02f, -3.70947458e-02f, 3.32185477e-02f, -2.29339711e-02f,
  -3.47219184e-02f, -4.68887128e-02f, 4.50253370e-04f, 7.53917843e-02f, 1.01647966e-01f, 3.13565135e-02f, -2.14143749e-02f, -7.57173672e-02f, 1.60004906e-02f, 3.76021378e-02f,
  -4.50774562e-03f, 4.12863642e-02f, 8.14503282e-02f, -4.88902368e-02f, 7.57485554e-02f, -2.00298317e-02f, -6.01530075e-02f, -7.39122257e-02f, -6.36631250e-02f, 1.48867182e-02f,
  -8.57894123e-02f, 4.31470089e-02f, -6.25014827e-02f, 7.54676312e-02f, -4.43182699e-02f, 2.55521387e-02f, 3.18680741e-02f, -3.59319262e-02f, 2.32378743e-03f, -1.87842604e-02f,
  7.19682872e-02f, -3.72137725e-02f, 9.63087007e-02f, -6.64349943e-02f, 7.90685415e-02f, -6.71928748e-02f, 2.54333448e-02f, -7.45206997e-02f, -1.78146958e-02f, -1.99028244e-03f,
  -8.23556632e-02f, 2.46652067e-02f, 2.33206302e-02f, 1.33329751e-02f, 2.76966002e-02f, 3.66413854e-02f, -3.04115918e-02f, -6.09163381e-02f, -1.65082570e-02f, 4.04489934e-02f,
  -4.57176194e-03f, 8.84126052e-02f, -2.47905478e-02f, 8.65026005e-03f, -6.38543293e-02f, 1.04796905e-02f, -3.00452411e-02f, -3.38825248e-02f, -2.94832233e-02f, 8.49199519e-02f,
  -8.74600187e-02f, 7.12215826e-02f, -1.04498118e-02f, -1.70884244e-02f, -4.79376316e-02f, 4.98773251e-03f, -3.66731323e-02f, 3.13492119e-02f, -3.82606052e-02f, -6.83786487e-03f,
  -7.15872571e-02f, -8.91631171e-02f, -2.88632866e-02f, 4.62769978e-02f, -5.53131290e-02f, 2.07246691e-02f, 4.09706756e-02f, -5.54447845e-02f, -8.94196406e-02f, -1.55221801e-02f,
  -2.84072682e-02f, 3.38482261e-02f, 5.51645942e-02f, -6.07098872e-03f, 7.65246674e-02f, -7.79389739e-02f, -7.40238950e-02f, 1.15750901e-01f, -1.33552268e-01f, 7.00595677e-02f,
  1.67797636e-02f, -5.54620475e-03f, -1.14047304e-01f, 1.73303634e-01f, -7.52826259e-02f, -1.07665665e-01f, 3.91769409e-02f, -4.50543240e-02f, 1.12327898e-05f, -8.08701962e-02f,
  5.29411528e-03f, 8.99410546e-02f, 4.00676839e-02f, 1.35583565e-01f, 1.10353440e-01f, 1.09645627e-01f, -1.00397140e-01f, -4.34717610e-02f, 1.69078022e-01f, 2.16688477e-02f,
  1.43531576e-01f, 3.13918293e-02f, 4.48488183e-02f, 3.11876982e-02f, -8.90627801e-02f, 9.51154903e-03f, 3.24144028e-02f, -7.19620585e-02f, -4.68480363e-02f, -3.34913097e-02f,
  -1.00246482e-02f, 4.68169637e-02f, 7.24295750e-02f, 2.94869021e-02f, -2.88096555e-02f, -2.44721454e-02f, 5.57871424e-02f, -7.44812330e-03f, 8.87368321e-02f, 2.13026181e-02f,
  -1.39249703e-02f, 5.65066654e-03f, -1.02472417e-01f, -1.54671893e-02f, -3.09357289e-02f, -4.26717512e-02f, 3.88031714e-02f, 2.14258134e-02f, -4.90029231e-02f, -2.01094579e-02f,
  -5.76945022e-03f, -1.11177959e-01f, -4.52572517e-02f, 8.02088901e-02f, -1.17897158e-02f, 3.95001210e-02f, 4.87749055e-02f, -3.57269980e-02f, -7.73185268e-02f, 3.48902754e-02f,
  -6.49076253e-02f, 3.16771753e-02f, 3.31410319e-02f, 4.86405604e-02f, -6.50732666e-02f, 5.04852384e-02f, -2.95358133e-02f, -1.51252504e-02f, -2.79733222e-02f, 3.42385471e-02f,
  -2.98368447e-02f, -2.78927926e-02f, -7.78846294e-02f, 5.99207208e-02f, 1.41663738e-02f, 3.41852494e-02f, 4.24179584e-02f, 5.75705022e-02f, 6.44737855e-02f, -8.81436616e-02f,
  -1.45050988e-01f, -1.66649133e-01f, -5.35600670e-02f, 9.34095606e-02f, 3.83281074e-02f, 4.97797132e-03f, -3.99585441e-02f, 5.26901037e-02f, -1.07459705e-02f, 1.31359044e-02f,
  -3.35124694e-02f, -3.12977731e-02f, -7.53375590e-02f, 8.76165330e-02f, 2.49596722e-02f, 9.31595732e-03f, -1.08420409e-01f, -4.76590618e-02f, -5.49804457e-02f, -4.80865575e-02f,
  3.63676548e-02f, -5.66612557e-02f, -7.08975494e-02f, 5.74084409e-02f, 7.87054002e-02f, -3.83268371e-02f, -6.47366568e-02f, 7.27380533e-03f, -1.99091844e-02f, 2.05538180e-02f,
  -1.05003729e-01f, -1.89769760e-01f, -1.53317228e-01f, 1.25742629e-01f, 1.09151468e-01f, 1.15211882e-01f, 1.66031495e-01f, 3.15553062e-02f, -1.40341371e-01f, 2.08220705e-02f,
  2.66340703e-01f, -1.86032146e-01f, -5.30195795e-02f, 1.35357365e-01f, 2.36332901e-02f, -7.92119280e-02f, 1.83069721e-01f, 4.06182930e-03f, -1.71642393e-01f, 9.97986421e-02f,
  1.52572189e-02f, 1.40200242e-01f, 6.19699210e-02f, 8.15312490e-02f, 1.85973734e-01f, 2.37670410e-02f, 1.91695273e-01f, 1.77175421e-02f, 2.15398207e-01f, 2.78949048e-02f,
  7.68469498e-02f, -1.04394518e-01f, 1.67961996e-02f, -7.76380226e-02f, 2.95651704e-02f, 1.03813246e-01f, -4.51671854e-02f, -1.78684480e-02f, 5.17685413e-02f, -6.06737286e-02f,
  3.29243056e-02f, -6.76328875e-03f, -2.20462121e-02f, 1.61038786e-02f, -1.53026078e-02f, -6.12944923e-02f, 4.76347916e-02f, 7.26548135e-02f, 3.05394493e-02f, -4.27882448e-02f,
  -1.88304055e-02f, -1.62743237e-02f, 5.76841459e-03f, 5.57206385e-02f, 5.82449101e-02f, -3.07021663e-02f, 1.69375129e-02f, -5.66586852e-02f, -1.26656517e-02f, -5.84844574e-02f,
  3.14502493e-02f, 1.91568546e-02f, -5.99509757e-03f, -1.90190393e-02f, 3.37767899e-02f, 3.15215029e-02f, 5.25773270e-03f, 5.29658981e-02f, -4.17494625e-02f, -9.73595865e-03f,
  -1.09151891e-02f, -3.13801542e-02f, 7.77910277e-02f, -4.38689478e-02f, 8.34384561e-03f, 1.62010118e-02f, -4.30032937e-03f, -1.57308020e-02f, -3.38298641e-02f, 4.36670370e-02f,
  5.05822003e-02f, -3.02182268e-02f, 4.54556048e-02f, 7.81680718e-02f, -2.89077573e-02f, -8.32859054e-03f, -1.02452813e-02f, 1.43428082e-02f, -2.76515773e-03f, 6.18757270e-02f,
  1.04957566e-01f, -2.48942021e-02f, -5.14099523e-02f, 1.30982383e-03f, -1.20407343e-02f, 3.63989919e-02f, -4.31667604e-02f, -7.68827498e-02f, -2.40731537e-02f, 5.84388152e-02f,
  3.44204456e-02f, -9.44762025e-03f, 9.75445751e-03f, -1.02230127e-03f, 6.94786832e-02f, 4.03752625e-02f, 1.87585538e-03f, -5.31068817e-02f, 9.89810601e-02f, 2.61492375e-02f,
  -5.31942621e-02f, 5.59975319e-02f, -3.37119587e-02f, -4.44430225e-02f, -3.00407298e-02f, 1.15737133e-02f, -1.22366091e-02f, 6.43300731e-03f, 7.26952553e-02f, 3.94100286e-02f,
  -2.59366721e-01f, 3.82540435e-01f, -6.67953044e-02f, -1.77455306e-01f, -1.07010819e-01f, -2.90423930e-01f, -2.05353752e-01f, 5.30743264e-02f, -4.68513779e-02f, 3.00096571e-01f,
  9.11192130e-03f, -2.74612308e-02f, 1.78080872e-01f, 7.05069723e-03f, -2.90258110e-01f, 1.47167921e-01f, -1.77732602e-01f, 2.37370264e-02f, 6.84497356e-02f, -3.46250124e-02f,
  -8.44459459e-02f, -3.90150249e-02f, 1.52704976e-02f, 7.25390464e-02f, -1.18435502e-01f, 6.85464684e-03f, -2.18773410e-02f, 5.57694323e-02f, 6.35968223e-02f, -3.78661677e-02f,
  -8.27773288e-02f, 8.51433128e-02f, -1.68954022e-02f, 6.23878848e-04f, -7.23002180e-02f, 2.65581422e-02f, -3.22846733e-02f, -8.20690393e-02f, -6.27827793e-02f, -6.56697154e-02f,
  -3.95028433e-03f, -5.56144398e-03f, 1.57053228e-02f, -3.15957107e-02f, 1.17591564e-02f, 5.25865369e-02f, 6.80969283e-02f, -5.39936647e-02f, 7.78689934e-03f, -5.56782559e-02f,
  -1.81599092e-02f, 2.74681412e-02f, 5.15548624e-02f, -3.08458507e-03f, 1.31691387e-02f, -1.55463582e-02f, -2.00354066e-02f, -4.77189459e-02f, -2.78800633e-02f, -7.99569935e-02f,
  2.47063804e-02f, -6.94925264e-02f, 6.36815727e-02f, 9.29970369e-02f, -3.79607677e-02f, 5.84546290e-02f, 5.03676431e-03f, 8.41618329e-02f, -2.16866862e-02f, -2.25989185e-02f,
  7.85965100e-03f, -3.14395837e-02f, -3.21997255e-02f, 4.60961834e-02f, -5.06247766e-02f, 2.80066505e-02f, -6.90951794e-02f, 4.32070829e-02f, -6.88315555e-02f, 3.30390967e-02f,
  -1.22740061e-03f, -4.12206315e-02f, 2.62498669e-02f, -5.33541925e-02f, -2.98683997e-02f, -4.92524654e-02f, 9.45052784e-03f, -2.73978524e-03f, 2.15190873e-02f, -1.69131290e-02f,
  -6.23442195e-02f, 8.33931938e-02f, 7.12355375e-02f, 6.36413693e-02f, 7.26632327e-02f, 3.24616656e-02f, -6.36621437e-04f, 3.77999991e-02f, 4.80487458e-02f, -3.34352963e-02f,
  -1.98388584e-02f, -6.66931039e-03f, -4.04864028e-02f, -4.67615165e-02f, -4.40814942e-02f, 1.22461515e-03f, 6.03294820e-02f, 4.82553542e-02f, -2.26253606e-02f, 8.72886479e-02f,
  4.63506915e-02f, -6.29842132e-02f, -8.33346099e-02f, -1.86603554e-02f, 2.21593492e-02f, -2.10031513e-02f, -5.48514053e-02f, 5.08953854e-02f, 1.71042290e-02f, 7.32241049e-02f,
  -1.10400252e-01f, -7.63085783e-02f, 2.54634678e-01f, 8.93184170e-02f, 3.62202786e-02f, -2.27527431e-04f, 4.31502648e-02f, 1.81639101e-02f, -1.52443111e-01f, -1.03414603e-01f,
  -2.79511176e-02f, -1.54945543e-02f, 1.31658828e-02f, -1.19639792e-01f, -1.24562643e-01f, -1.32669061e-01f, -2.05608919e-01f, -6.00857921e-02f, 4.69775535e-02f, 9.44202989e-02f,
  3.46012488e-02f, -9.49017331e-03f, 1.80319712e-01f, 1.07512111e-03f, 5.65408543e-02f, 1.57587543e-01f, 2.73187514e-02f, 2.37260282e-01f, 6.62379041e-02f, 2.63059232e-02f,
  -7.02252388e-02f, -5.61152734e-02f, -4.88479529e-03f, -1.39240995e-02f, -5.11061912e-03f, 5.13071604e-02f, 6.60696626e-02f, 6.96871206e-02f, -3.27568837e-02f, 6.92223310e-02f,
  3.13190487e-03f, 5.04290052e-02f, -4.76385988e-02f, -3.95248681e-02f, -4.86524627e-02f, -7.01295445e-03f, 8.82441178e-02f, 1.94608960e-02f, 9.60135534e-02f, 8.45650584e-02f,
  7.66424835e-02f, 1.01495899e-01f, 1.04080088e-01f, -1.28343338e-02f, 8.35250318e-02f, -1.25193000e-02f, 9.06131193e-02f, 8.58754758e-03f, 1.89323891e-02f, -5.84963337e-02f,
  -5.11333756e-02f, 6.32273629e-02f, 9.76875722e-02f, 4.14150059e-02f, -6.71969503e-02f, 3.30238082e-02f, -8.55638180e-03f, 2.31072512e-02f, 6.66119624e-03f, -5.71146375e-03f,
  3.88123132e-02f, 2.36113146e-02f, -5.16268462e-02f, 8.78484920e-02f, 2.59977542e-02f, -7.72269592e-02f, -6.18548784e-03f, -1.34908385e-03f, 1.00653209e-01f, 2.19396260e-02f,
  2.27294341e-02f, -3.79487835e-02f, 8.83140787e-02f, -3.78244333e-02f, 9.39565524e-03f, 2.52216365e-02f, -4.00174931e-02f, -1.17117912e-02f, 3.10058426e-02f, -8.81604850e-03f,
  -4.58329096e-02f, -2.26108339e-02f, 6.85584024e-02f, -2.57191863e-02f, -5.35577610e-02f, -1.31476954e-01f, -6.45072907e-02f, -1.02312930e-01f, -3.15704979e-02f, -6.35629892e-02f,
  1.49400914e-02f, 3.36697921e-02f, -7.72468895e-02f, 4.42180820e-02f, 4.77959625e-02f, -1.31124318e-01f, 3.33198346e-02f, 1.61738656e-02f, 3.89509797e-02f, 6.12640940e-02f,
  1.14648845e-02f, -1.51886577e-02f, -8.17881446e-05f, 5.26882336e-02f, -3.55085991e-02f, 6.49559349e-02f, -4.31992747e-02f, 2.36065425e-02f, 4.27775495e-02f, 6.15755878e-02f
};

// L0_fan_Wp_bar (Shape: 52 x 120)
const int L0_fan_Wp_bar_rows = 52;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  4.30676937e-02f, 8.02039877e-02f, 1.24962352e-01f, 5.29715121e-02f, -2.72699948e-02f, -3.62926602e-01f, -2.00312525e-01f, 2.67801322e-02f, 4.12820242e-02f, -1.22816851e-02f,
  2.76662111e-02f, -4.54043746e-02f, 4.78468239e-02f, 3.66211333e-03f, 8.44606459e-02f, 1.73269883e-01f, -1.52535290e-01f, -1.66415647e-01f, -2.19521448e-02f, 7.77158067e-02f,
  1.09028801e-01f, 7.35611990e-02f, 1.01489276e-01f, -6.47383975e-03f, -2.33853497e-02f, 1.65837839e-01f, 1.61011010e-01f, 5.90536185e-02f, -4.58553946e-03f, -4.73436601e-02f,
  -1.12848960e-01f, 1.88373089e-01f, 5.69617562e-03f, -7.41816359e-03f, -2.91117467e-02f, -1.02628849e-01f, -1.06416531e-01f, 2.37081014e-02f, -9.96767823e-03f, 5.27052768e-02f,
  5.14129624e-02f, -3.08896378e-02f, -4.35591303e-02f, 1.52481627e-02f, 3.11659314e-02f, 1.71488002e-02f, 3.23155858e-02f, 4.24609594e-02f, 2.10435875e-02f, -1.01996688e-02f,
  -3.10374610e-02f, -4.08172421e-02f, -7.54430443e-02f, -1.72060132e-02f, 6.43613636e-02f, -6.78350553e-02f, -2.75827968e-03f, 5.62432557e-02f, -5.26948692e-03f, -9.78873298e-03f,
  1.14668412e-02f, -7.18599930e-02f, -2.05656439e-02f, -2.03543548e-02f, 4.92096925e-03f, -5.71268098e-03f, 7.02401698e-02f, -8.61776546e-02f, -3.48703898e-02f, 5.21555133e-02f,
  -5.51590137e-02f, 7.53515065e-02f, 3.06512602e-02f, -5.06523885e-02f, -6.41517043e-02f, 8.33255351e-02f, -9.38248336e-02f, 2.49494892e-02f, 1.05776470e-02f, 8.64356663e-03f,
  1.97588224e-02f, -9.08352807e-02f, 1.51708545e-02f, 5.57390042e-02f, -4.50514406e-02f, 1.02578355e-02f, 5.89295290e-02f, 4.58474569e-02f, -6.96315989e-02f, 1.87359918e-02f,
  9.89287812e-03f, 2.14454979e-01f, 7.21882135e-02f, -3.44877653e-02f, -7.53612742e-02f, -9.53485072e-02f, 1.03245741e-02f, -3.44844311e-02f, 3.09186615e-02f, 2.72920579e-02f,
  3.19827460e-02f, 2.02514138e-02f, -7.74471369e-03f, 8.02010074e-02f, -6.10571131e-02f, 3.18200104e-02f, 8.39204118e-02f, -3.46225314e-02f, 9.00407955e-02f, 5.19978181e-02f,
  3.57042775e-02f, 7.09011555e-02f, -1.51901357e-02f, -2.95076054e-03f, 1.82952005e-02f, 1.51781319e-02f, -4.03270870e-02f, 3.48142236e-02f, 3.05795930e-02f, 5.19592687e-02f,
  -1.28200442e-01f, -4.19226140e-02f, -3.20115149e-01f, -9.96735096e-02f, -4.27331254e-02f, -1.04061738e-01f, -6.13185205e-02f, 2.01749653e-02f, -7.90279284e-02f, 2.64313549e-01f,
  2.02872276e-01f, -5.66743724e-02f, 2.78590061e-02f, 7.95502737e-02f, -1.86838448e-01f, -3.15262750e-02f, -5.36558069e-02f, 1.12909332e-01f, -2.30545178e-02f, -3.30927335e-02f,
  -7.89201334e-02f, 1.44620731e-01f, -8.87411926e-03f, 7.08098635e-02f, -3.58975083e-02f, 1.01836096e-03f, 4.46935631e-02f, -3.55063565e-02f, 6.34916872e-02f, -8.56667161e-02f,
  4.04798752e-03f, 5.99681996e-02f, -5.70518747e-02f, -3.66035067e-02f, -1.02717981e-01f, -8.09384733e-02f, 2.36247852e-03f, -9.53852013e-02f, -5.53072095e-02f, 5.55538526e-03f,
  4.16942202e-02f, -5.53472824e-02f, 2.75921449e-02f, 6.71197027e-02f, 5.31981476e-02f, -5.10355048e-02f, -3.64874788e-02f, 1.66123118e-02f, 3.00029712e-03f, -8.79757628e-02f,
  -1.21340021e-01f, 2.55831275e-02f, -1.42780421e-02f, 1.31324707e-02f, 4.10174280e-02f, 7.50559494e-02f, -7.41053745e-02f, 3.57422642e-02f, 5.01326770e-02f, -5.85951544e-02f,
  -7.28310347e-02f, -2.74467058e-02f, 6.73234016e-02f, -8.95370692e-02f, -1.59365404e-02f, 1.56626608e-02f, -4.53190282e-02f, 6.49732798e-02f, -1.46140158e-02f, -8.30862555e-04f,
  -2.33903136e-02f, -1.02879405e-01f, 9.52816159e-02f, 5.29331490e-02f, 3.14498842e-02f, 6.51715696e-02f, 6.58602044e-02f, -2.19691303e-02f, -2.62386855e-02f, -6.38520271e-02f,
  -2.76620239e-02f, -7.99501240e-02f, 3.98572572e-02f, 1.06723465e-01f, 6.34654760e-02f, -6.16082735e-02f, -4.20066305e-02f, -8.67145956e-02f, -2.76016556e-02f, 4.40816022e-02f,
  4.53659073e-02f, -5.12235910e-02f, -3.72988582e-02f, -5.77650452e-03f, -1.98653266e-02f, 2.32705195e-02f, -2.27878895e-02f, -7.86468387e-02f, -4.91173305e-02f, -7.25039244e-02f,
  -2.33406303e-04f, 9.06993672e-02f, 7.41989017e-02f, -4.06584255e-02f, -1.86141289e-03f, -6.49684519e-02f, 1.09387524e-01f, -7.71335810e-02f, -4.51864637e-02f, -1.57158002e-02f,
  -5.23811616e-02f, -7.99171478e-02f, -7.91512877e-02f, -3.05332802e-02f, 1.82715489e-03f, -4.44111004e-02f, -7.91128129e-02f, -3.62097309e-03f, -6.91114971e-03f, 1.87850464e-02f,
  -6.86195791e-02f, 2.24174932e-01f, 1.15143456e-01f, -8.71689692e-02f, -2.25860234e-02f, -3.13431174e-02f, -1.82054296e-01f, 2.02095117e-02f, 1.94317736e-02f, -8.74983966e-02f,
  -8.13852400e-02f, 8.10919553e-02f, 6.03709258e-02f, 8.28086585e-03f, -9.27653909e-02f, 1.21278383e-01f, -1.06828183e-01f, -5.98931462e-02f, 1.02387711e-01f, -9.32627842e-02f,
  6.38286248e-02f, -2.56329700e-02f, 9.80444923e-02f, 1.61851764e-01f, -8.29549208e-02f, 7.54027292e-02f, -8.92480388e-02f, 2.05175262e-02f, -3.90151851e-02f, 1.89601649e-02f,
  -6.32077903e-02f, -1.16841018e-01f, -8.44941586e-02f, -2.05885023e-02f, -3.86062525e-02f, -1.29374728e-01f, -2.93651298e-02f, -5.79161476e-03f, 2.10767332e-02f, 3.94421257e-02f,
  7.65428394e-02f, -5.69353774e-02f, 5.09238504e-02f, -7.51922205e-02f, 1.27370637e-02f, 9.23788697e-02f, 4.89202514e-02f, 7.13108778e-02f, -3.89463082e-02f, -4.08924632e-02f,
  -1.25786457e-02f, 1.10695414e-01f, 3.60651612e-02f, -1.77178308e-02f, -8.32167864e-02f, 3.52035761e-02f, 5.07090650e-02f, -6.83765858e-02f, 4.08847742e-02f, 4.55772690e-02f,
  8.96051675e-02f, -6.62964508e-02f, 7.19834678e-03f, -9.72233638e-02f, 1.66124701e-02f, 7.80416206e-02f, -4.28303257e-02f, -4.62641791e-02f, -5.83877154e-02f, 8.65454413e-03f,
  8.72321352e-02f, -7.02300221e-02f, 6.57525659e-02f, 6.77855173e-03f, -1.49220750e-02f, -7.37119019e-02f, 4.31630015e-02f, 2.62394529e-02f, 8.42909589e-02f, -5.88315949e-02f,
  -4.53738868e-02f, 4.37728837e-02f, -6.33717254e-02f, 1.81172974e-02f, 3.41661423e-02f, -7.48327151e-02f, -8.45117271e-02f, 7.33938664e-02f, 4.19891514e-02f, -3.39922085e-02f,
  -2.98859794e-02f, 5.11418283e-02f, -6.91962019e-02f, 1.91600509e-02f, -1.01057999e-02f, -9.56186652e-02f, -7.96955153e-02f, -2.26455946e-02f, -2.43646707e-02f, -2.93244887e-02f,
  -8.58508572e-02f, 5.93334883e-02f, -8.66112858e-02f, -1.80052388e-02f, -6.65344894e-02f, 2.79343855e-02f, -2.28941292e-02f, 3.29163224e-02f, -2.48096213e-02f, -7.02036992e-02f,
  7.28961602e-02f, -8.33184421e-02f, -5.46980184e-03f, -6.12556078e-02f, -1.01435415e-01f, -3.22542898e-02f, -1.11335829e-01f, 4.38768119e-02f, -4.65616286e-02f, 7.30966255e-02f,
  -2.38325112e-02f, 1.44360542e-01f, -5.45578972e-02f, 1.17304642e-02f, 6.87428117e-02f, -1.35057211e-01f, -2.49807946e-02f, 7.73111358e-02f, 1.19909100e-01f, 6.74414635e-02f,
  1.21483073e-01f, 1.40603129e-02f, 8.19321722e-02f, -5.98998182e-02f, -5.60588427e-02f, 7.94329047e-02f, -1.39103979e-01f, -1.24424152e-01f, -2.54909508e-02f, 6.73055872e-02f,
  -1.27700254e-01f, 7.30128214e-02f, -1.42461270e-01f, 5.79558685e-02f, 2.09206399e-02f, 7.43903220e-02f, 7.12762848e-02f, 5.20574227e-02f, -6.04756689e-03f, 1.03459321e-01f,
  -4.20752950e-02f, 1.08756088e-01f, 4.74187871e-03f, -1.85821783e-02f, -8.63428041e-02f, -1.12167910e-01f, -6.71238115e-04f, 6.78776801e-02f, 5.59078082e-02f, 7.02491105e-02f,
  4.42642383e-02f, 1.06726855e-01f, -1.47380307e-02f, -1.38239088e-02f, 5.80354519e-02f, 2.21148282e-02f, -5.18370233e-02f, 5.10476939e-02f, -4.37571779e-02f, 2.63289008e-02f,
  -2.69268975e-02f, -9.60938931e-02f, -5.44817299e-02f, -2.98978109e-02f, 7.15069398e-02f, -2.84646321e-02f, -5.43855131e-04f, 4.60301191e-02f, -7.83970505e-02f, 3.06383669e-02f,
  9.24525559e-02f, -6.52963966e-02f, 4.96070534e-02f, -4.37662043e-02f, 3.90644139e-03f, 2.23987140e-02f, 5.22203483e-02f, -3.81442606e-02f, 7.83869848e-02f, 1.01373589e-03f,
  -7.82201812e-03f, 8.95025022e-03f, -4.72285897e-02f, -1.07046589e-01f, 1.78155256e-03f, 7.28006139e-02f, 1.11845499e-02f, -4.41792682e-02f, -4.15374264e-02f, 7.41157159e-02f,
  1.92945972e-02f, -1.58991979e-03f, 4.94910665e-02f, -4.16634604e-02f, 5.29039018e-02f, -3.00142113e-02f, 2.62641348e-02f, 3.40188555e-02f, -2.64852662e-02f, -3.79990302e-02f,
  6.42214492e-02f, 1.09240577e-01f, 2.00467557e-02f, 4.89343368e-02f, -9.44467559e-02f, 4.15415205e-02f, 6.30690902e-02f, 5.94837628e-02f, -6.15991373e-03f, 7.45998695e-02f,
  -1.18330546e-01f, 6.53986633e-02f, -7.56120980e-02f, -4.67511043e-02f, 8.88630748e-02f, 8.95507857e-02f, 2.56359694e-03f, -3.78105082e-02f, -4.47174460e-02f, 1.73558295e-02f,
  -4.00115177e-02f, 1.76401194e-02f, 4.69068484e-03f, 6.85662180e-02f, -1.84515975e-02f, -1.14683490e-02f, -4.30688320e-04f, -5.98803908e-02f, -2.44104806e-02f, 6.70841858e-02f,
  1.72420056e-03f, -8.64775628e-02f, -1.62843376e-01f, -1.51373655e-01f, 1.49059862e-01f, -1.72768265e-03f, -1.01074472e-01f, 8.95863250e-02f, -1.04791172e-01f, 1.47281930e-01f,
  1.08781280e-02f, -1.40216544e-01f, -6.08100481e-02f, -1.52641386e-01f, -1.75830275e-01f, -2.70024180e-01f, -1.23663947e-01f, -9.02650729e-02f, -2.07379639e-01f, 1.51783660e-01f,
  -6.36975002e-03f, 5.69613138e-03f, -1.33572534e-01f, 8.71801600e-02f, 7.19906986e-02f, 1.42266139e-01f, 1.72915995e-01f, 1.19059965e-01f, 2.00276643e-01f, 4.76764664e-02f,
  -2.90499572e-02f, -5.70442118e-02f, -3.26780975e-02f, -1.17202558e-01f, 1.23923622e-01f, 3.39055695e-02f, 3.38563770e-02f, 2.00272743e-02f, -2.61945669e-02f, 1.62593238e-02f,
  4.70663942e-02f, 1.44598428e-02f, -6.46738335e-02f, -6.92407265e-02f, -3.61952856e-02f, 4.51696813e-02f, -3.58985513e-02f, -5.55399060e-02f, -6.80459812e-02f, -2.11087354e-02f,
  4.68340442e-02f, -2.59364061e-02f, 5.52911982e-02f, -9.75959841e-03f, 5.69511987e-02f, 4.72605042e-02f, 7.03384653e-02f, 2.38289572e-02f, 2.28666440e-02f, 1.05802435e-02f,
  8.92288014e-02f, -3.87700200e-02f, -7.57035911e-02f, -6.28749430e-02f, -6.26068488e-02f, 2.40173750e-02f, -1.02583483e-01f, 5.59662608e-03f, -4.94252108e-02f, 7.30117336e-02f,
  8.74309707e-03f, -8.08631182e-02f, -9.12312791e-02f, 5.07061221e-02f, 3.92885059e-02f, -2.96080988e-02f, 5.28282821e-02f, -5.99068403e-02f, -7.16334656e-02f, -1.70430839e-02f,
  -5.35166375e-02f, 2.11872142e-02f, -6.45725727e-02f, -9.63203609e-03f, 2.83889063e-02f, 2.34473925e-02f, 2.30346043e-02f, -3.52769494e-02f, -2.91773882e-02f, 2.86186561e-02f,
  6.74618483e-02f, 1.55081511e-01f, 1.92296747e-02f, 6.85838843e-03f, -1.08699147e-02f, 1.54412510e-02f, -9.84521117e-03f, -4.14713174e-02f, 8.77958834e-02f, -3.87123749e-02f,
  1.82602391e-01f, 2.05561947e-02f, 2.43347213e-02f, 4.36607301e-02f, 7.89465457e-02f, 4.32337709e-02f, -5.19106947e-02f, 1.12893447e-01f, 4.89898436e-02f, 7.16402158e-02f,
  -9.13249422e-03f, 3.54440371e-03f, 2.79556640e-04f, -4.90125939e-02f, 5.88619001e-02f, 2.77609173e-02f, 1.47573361e-02f, 5.66449054e-02f, 2.64017452e-02f, 4.59997579e-02f,
  1.56263188e-01f, -2.09883407e-01f, 8.19380358e-02f, 2.18725279e-01f, 1.34649396e-01f, -4.96725477e-02f, 9.51806307e-02f, 4.58189175e-02f, 1.68856472e-01f, -1.42491043e-01f,
  5.79975396e-02f, -1.35695338e-01f, -1.03625260e-01f, -1.49109261e-03f, -1.07640224e-02f, -2.10136194e-02f, -5.91517054e-02f, -3.64562869e-02f, 1.01064011e-01f, -1.93290524e-02f,
  4.37705629e-02f, 5.01216277e-02f, 8.66798386e-02f, -1.12568498e-01f, 8.42249542e-02f, 2.18159845e-03f, -1.48924664e-02f, -1.07364692e-01f, -2.91396063e-02f, -6.13280982e-02f,
  -6.71819001e-02f, -1.18615627e-02f, 4.46984507e-02f, -5.62101677e-02f, -6.43329471e-02f, 7.72692338e-02f, -4.65116315e-02f, 3.24782990e-02f, 2.96016168e-02f, 6.99371547e-02f,
  -2.13325042e-02f, -1.47864250e-02f, 6.62704110e-02f, -8.41175690e-02f, -1.45146493e-02f, -3.00516412e-02f, 2.57633328e-02f, -3.33973095e-02f, 7.09811002e-02f, 3.19916126e-03f,
  -1.07286475e-03f, 7.42053241e-02f, 4.11996022e-02f, -4.31316420e-02f, -5.64963035e-02f, -2.60295477e-02f, 8.14792812e-02f, -8.31364170e-02f, 1.02607096e-02f, 4.34043556e-02f,
  3.77801545e-02f, -9.62046981e-02f, -7.45767578e-02f, 1.04002573e-01f, 6.04104018e-03f, -2.88640745e-02f, -2.73237377e-02f, -5.29356785e-02f, 4.94074337e-02f, -8.59234780e-02f,
  1.02307849e-01f, 8.18440244e-02f, -6.16523959e-02f, 1.58207435e-02f, 5.61644286e-02f, 5.89812361e-03f, 4.95483428e-02f, 3.75188962e-02f, 4.03779112e-02f, -4.18263637e-02f,
  -5.07183969e-02f, 7.18912333e-02f, -6.25592694e-02f, -1.79853383e-03f, 8.16232152e-03f, 3.47656049e-02f, -4.48832661e-02f, 2.41194256e-02f, 3.83797176e-02f, -8.07509199e-02f,
  -5.01125073e-03f, -6.88529760e-02f, 2.46848706e-02f, -8.08890834e-02f, -4.81497012e-02f, 5.16582690e-02f, 7.58724138e-02f, 2.35123243e-02f, 2.10713893e-02f, 3.94632312e-04f,
  -4.03434932e-02f, 6.81749508e-02f, -1.60722248e-02f, 6.84881285e-02f, 7.51385512e-03f, -6.91325665e-02f, -8.40228572e-02f, -1.05829246e-01f, -8.64386857e-02f, -7.52514824e-02f,
  -2.24506743e-02f, -8.12379271e-02f, 6.23264574e-02f, 7.34446943e-03f, -1.20639699e-02f, 6.83041438e-02f, -7.63888881e-02f, -7.93254524e-02f, 1.83545798e-02f, 5.44141233e-02f,
  2.83144414e-02f, 1.82031896e-02f, -3.15930694e-02f, -1.18547365e-01f, -1.10570788e-02f, 1.42946273e-01f, 1.36203002e-02f, 4.07316908e-02f, -1.25150001e-02f, -4.85625155e-02f,
  5.85059039e-02f, 2.87407469e-02f, 1.09222069e-01f, 5.14811982e-05f, 4.57576141e-02f, -1.57091748e-02f, 8.34448040e-02f, -7.76768699e-02f, 9.04051438e-02f, -4.25848998e-02f,
  5.48247397e-02f, 9.32508782e-02f, 6.56266585e-02f, -8.90156720e-03f, 6.68765306e-02f, -9.79308737e-04f, -1.23169817e-01f, 6.52045086e-02f, -1.01643264e-01f, -3.80102322e-02f,
  1.02153793e-01f, -9.26432088e-02f, -9.53273922e-02f, 2.05378747e-03f, -5.16318716e-02f, 2.13388968e-02f, 2.55271932e-03f, -6.43353164e-02f, -7.62005076e-02f, -4.81432378e-02f,
  2.98829027e-03f, -7.20039904e-02f, -7.30880648e-02f, 2.90472750e-02f, -7.61680752e-02f, 3.59411947e-02f, -5.89440838e-02f, 3.60970609e-02f, 3.19464728e-02f, -5.87311648e-02f,
  3.65379639e-02f, 3.97716984e-02f, 4.39808657e-03f, -2.98115555e-02f, -3.62792313e-02f, 7.94518888e-02f, -6.06046841e-02f, -6.25281408e-02f, 9.28906538e-03f, -7.87923187e-02f,
  -5.35364263e-02f, -5.65334689e-03f, -3.61196771e-02f, 9.99050662e-02f, -3.07467952e-02f, -8.96651968e-02f, -4.55122590e-02f, 7.67958676e-03f, 7.73742944e-02f, 8.31762254e-02f,
  -2.28119902e-02f, -7.95653760e-02f, -7.66048878e-02f, -7.68191293e-02f, -4.18109857e-02f, -4.59185950e-02f, 2.94516291e-02f, -5.09383436e-03f, 4.05754633e-02f, 5.74389920e-02f,
  -1.86021179e-02f, 7.93730319e-02f, 5.71551099e-02f, -9.28270668e-02f, 2.32701954e-02f, 4.81675528e-02f, -7.10137412e-02f, 8.24210569e-02f, -3.12979855e-02f, -4.05777395e-02f,
  -1.71148777e-02f, -5.93973771e-02f, -7.14013800e-02f, -4.27079163e-02f, 5.33910245e-02f, -5.08575998e-02f, 5.73965348e-02f, 7.85348658e-03f, -1.04824409e-01f, -4.73169014e-02f,
  -1.36087034e-02f, -1.09017298e-01f, 3.01920250e-02f, -3.91456746e-02f, 6.59523681e-02f, -2.41933130e-02f, -2.01545227e-02f, -1.18192896e-01f, 4.59753722e-03f, 7.11105019e-02f,
  -6.05893768e-02f, 5.91796339e-02f, -7.26699978e-02f, -5.56117147e-02f, -5.42366728e-02f, -5.29383030e-03f, -4.42873240e-02f, 4.66848351e-02f, -1.50180236e-02f, -1.72803700e-02f,
  -1.20575748e-01f, -6.15692660e-02f, -1.64437979e-01f, 8.86515155e-02f, -4.25252393e-02f, 1.11488670e-01f, 4.24802303e-02f, -3.77805457e-02f, -2.40659900e-02f, 1.04113236e-01f,
  5.47702089e-02f, -9.31657292e-03f, -5.83871044e-02f, 1.32731557e-01f, 8.95332396e-02f, 1.14151709e-01f, 2.10037306e-01f, 5.12954593e-02f, 1.84271503e-02f, 1.17790131e-02f,
  -4.75186780e-02f, 5.97315952e-02f, -3.61866206e-02f, 6.48279116e-02f, -4.60282564e-02f, -4.37819026e-02f, -1.05997801e-01f, -1.20613538e-01f, -1.90397669e-02f, 6.66474774e-02f,
  2.51470041e-03f, 2.05471870e-02f, -6.96851164e-02f, -1.01726748e-01f, -1.05947100e-01f, -1.08144451e-02f, -5.10892309e-02f, 5.77976555e-02f, 2.86307409e-02f, -5.40437922e-02f,
  -1.83230676e-02f, 1.28876269e-02f, 6.47341534e-02f, -3.38468589e-02f, 2.35162955e-02f, -8.95324051e-02f, 5.45155555e-02f, 2.68369019e-02f, 8.09745397e-03f, -3.38360183e-02f,
  -7.18917176e-02f, -6.94265217e-02f, 8.25392306e-02f, 5.63057847e-02f, -1.72295831e-02f, 7.55773410e-02f, -2.08671335e-02f, -1.52987242e-02f, -7.09912553e-02f, 4.70061898e-02f,
  -4.24822569e-02f, 6.23099320e-02f, -7.08354041e-02f, 6.77816244e-03f, -8.42503980e-02f, -4.31072563e-02f, -5.07772826e-02f, 8.44384134e-02f, -7.04285726e-02f, 8.05401504e-02f,
  -7.32858032e-02f, -9.19054747e-02f, -1.79894473e-02f, 9.97114927e-02f, 1.39902374e-02f, 5.23188189e-02f, 6.97170710e-03f, -3.00861569e-03f, 4.31137271e-02f, -2.06302665e-02f,
  1.30500342e-03f, -6.59880340e-02f, -6.18838370e-02f, -2.96327230e-02f, 2.80960966e-02f, -1.61003936e-02f, -8.44218209e-02f, -9.26811656e-04f, 7.94636011e-02f, -5.93986213e-02f,
  -5.06809801e-02f, -7.98507705e-02f, -7.36976229e-03f, -2.53314935e-02f, 4.94878963e-02f, 4.48382646e-02f, -3.26829702e-02f, -7.62122348e-02f, -2.87531074e-02f, 1.54224532e-02f,
  7.59304091e-02f, 3.64972390e-02f, -3.93439159e-02f, 2.13757977e-02f, 5.29611222e-02f, -1.30380476e-02f, -6.20660745e-03f, -7.05386410e-05f, 9.78247672e-02f, 4.22849320e-02f,
  -6.34812191e-02f, 5.00920340e-02f, 7.67561123e-02f, -8.88525788e-03f, 2.44717989e-02f, -5.65159917e-02f, 5.07700033e-02f, 6.92316666e-02f, -5.09019494e-02f, 2.00765245e-02f,
  -1.65972933e-01f, 1.72302476e-03f, -8.45974162e-02f, 3.96986911e-03f, 6.33333474e-02f, -2.38171760e-02f, -7.06558675e-02f, -8.89747143e-02f, -1.05385892e-01f, 1.31613865e-01f,
  1.12544812e-01f, -1.34049207e-01f, 3.03215496e-02f, -1.08137988e-01f, -2.12733537e-01f, -7.90982321e-02f, -5.17097004e-02f, 7.97427669e-02f, -1.56979933e-01f, -6.70697019e-02f,
  -1.22597389e-01f, -3.10684089e-03f, -1.29623935e-02f, -6.69420185e-03f, -1.75181329e-02f, 1.21721134e-01f, 1.27196610e-01f, -4.09390368e-02f, 3.88668366e-02f, -2.00773291e-02f,
  -3.34656164e-02f, 1.40928784e-02f, 6.75116181e-02f, -3.02625895e-02f, 1.15760721e-01f, 7.69918412e-02f, 9.74143371e-02f, 2.47576106e-02f, -8.43869299e-02f, -1.88693535e-02f,
  6.42327368e-02f, -5.65288402e-02f, -6.61809668e-02f, -6.71444014e-02f, 6.84789792e-02f, 3.24501400e-03f, -8.68474171e-02f, 2.20183153e-02f, 9.61356759e-02f, 1.83855873e-02f,
  -5.30222580e-02f, 9.69490707e-02f, -6.68289000e-03f, 9.43634473e-03f, -8.57991427e-02f, -8.05098414e-02f, -3.15646939e-02f, -7.85341784e-02f, -4.53227423e-02f, 4.24747840e-02f,
  -1.04173362e-01f, 6.58248663e-02f, 4.53439914e-02f, 1.51314016e-04f, -3.45980227e-02f, 5.62529117e-02f, -1.82728842e-02f, 8.68576486e-03f, 7.39147700e-03f, -2.56666057e-02f,
  -5.19090369e-02f, 5.67993708e-03f, -6.18226640e-02f, 4.06703167e-02f, 3.27585801e-03f, -9.18579698e-02f, 8.20861533e-02f, 2.38949955e-02f, 9.63489711e-03f, -8.56643617e-02f,
  -1.37226814e-02f, 3.03073004e-02f, -7.81518370e-02f, 8.91385823e-02f, 3.14933807e-02f, 3.52696665e-02f, 6.68678954e-02f, 6.28274083e-02f, 1.52246235e-02f, -3.15887108e-02f,
  1.10116586e-01f, 3.29917334e-02f, -4.35358956e-02f, -2.35477649e-02f, 7.53888264e-02f, 5.81728369e-02f, -5.68456538e-02f, 1.91190615e-02f, -9.69927534e-02f, -1.39694652e-02f,
  -1.17407413e-02f, 1.94225833e-02f, 8.76874775e-02f, 2.37202067e-02f, -3.38257775e-02f, 1.04024895e-01f, 5.43106832e-02f, 9.74273831e-02f, 8.62402562e-03f, 2.42220741e-02f,
  9.83162671e-02f, 1.06130540e-01f, 7.06359595e-02f, -2.42540054e-02f, 2.22731829e-02f, -1.93276275e-02f, 1.03218697e-01f, -3.41901071e-02f, 1.56013295e-02f, -2.00120453e-02f,
  3.79021205e-02f, -1.34332344e-01f, -6.06533624e-02f, 1.82880774e-01f, 1.81640655e-01f, 1.21800685e-02f, -2.34963316e-02f, 8.57625827e-02f, 1.69082358e-01f, -1.24816075e-01f,
  -8.76784623e-02f, -5.77790774e-02f, -2.43691713e-01f, 1.22788250e-01f, 3.50010209e-02f, -2.27121785e-02f, 1.21672049e-01f, 6.02075644e-02f, 4.08261828e-02f, 6.00308441e-02f,
  -1.79240983e-02f, 8.32092389e-02f, 1.23572052e-02f, -2.42728945e-02f, 4.11047898e-02f, -1.56688020e-02f, -1.09520191e-02f, -2.69102305e-02f, 1.33338302e-01f, 1.21608295e-01f,
  -7.40089491e-02f, 2.17211675e-02f, -2.11905148e-02f, 3.13212425e-02f, -1.12259397e-02f, 3.82093480e-04f, -7.79135600e-02f, -5.92729729e-03f, 1.97723582e-02f, -8.13497826e-02f,
  -1.45907342e-01f, 2.65850052e-02f, 1.14524037e-01f, -4.23042029e-02f, 5.72159737e-02f, -2.00595986e-02f, -4.12698798e-02f, -2.26496551e-02f, 3.58001739e-02f, 3.23556699e-02f,
  -2.01629065e-02f, 5.22252582e-02f, 6.42986782e-03f, 5.56726661e-03f, -1.06986356e-03f, -1.52840549e-02f, 2.25148275e-02f, 3.58272679e-02f, 3.95245105e-03f, 1.06759429e-01f,
  4.37016934e-02f, -8.70910212e-02f, 3.85055654e-02f, 1.32373376e-02f, 1.90920976e-03f, -6.01710044e-02f, -1.70839466e-02f, 5.24562076e-02f, 2.36125551e-02f, -4.48062532e-02f,
  -5.51811196e-02f, 3.91682833e-02f, 1.08685516e-01f, 3.65421874e-03f, -5.45733012e-02f, 4.49578231e-03f, 2.41981782e-02f, 8.20568576e-02f, -1.64154898e-02f, -8.30020085e-02f,
  4.64476347e-02f, 2.67500672e-02f, 1.97419226e-02f, -4.68503647e-02f, -4.66698147e-02f, -3.49364914e-02f, 1.71248778e-03f, -6.62821382e-02f, -5.69458529e-02f, 6.84637576e-02f,
  -4.33335230e-02f, -1.23672280e-03f, 6.02136552e-02f, -7.12323934e-02f, -4.17490005e-02f, -1.29091681e-03f, 2.67926380e-02f, -1.56705007e-02f, 6.64365217e-02f, 5.20227884e-04f,
  -2.31240541e-02f, 3.42493579e-02f, 4.49632257e-02f, 3.42689864e-02f, 6.68490976e-02f, -3.82854529e-02f, -4.52097915e-02f, 1.26304468e-02f, 8.58262647e-03f, -8.54545087e-02f,
  -3.85220838e-03f, 5.78323416e-02f, 1.91379280e-03f, -3.72168086e-02f, 2.75600385e-02f, -3.24926190e-02f, 8.48585740e-02f, -6.58340529e-02f, -7.82766119e-02f, 4.80117723e-02f,
  -1.81525797e-02f, -1.58618316e-01f, 1.09579399e-01f, -1.29737973e-01f, 1.21443635e-02f, 5.74633926e-02f, 9.95598361e-02f, -1.36400580e-01f, -2.26677239e-01f, -3.19850236e-01f,
  -3.94044891e-02f, -3.13575789e-02f, 1.08928189e-01f, -1.98033884e-01f, 2.15135619e-01f, 6.98042735e-02f, -1.01868689e-01f, -4.02262621e-02f, 7.91117400e-02f, 6.27482822e-03f,
  5.33720776e-02f, -2.43920460e-02f, 2.53587186e-01f, -1.45740941e-01f, -9.75110084e-02f, -1.11594252e-01f, -7.30533749e-02f, 1.14481419e-01f, -8.18688795e-02f, 1.05876878e-01f,
  4.76130694e-02f, -1.28315672e-01f, -1.33503303e-02f, 3.81425172e-02f, 6.76251352e-02f, -4.93166186e-02f, 2.71227714e-02f, 1.09232366e-01f, 2.21224800e-02f, -3.62745188e-02f,
  4.31099124e-02f, -2.31187884e-03f, -8.39605629e-02f, 1.69164874e-02f, -1.16570994e-01f, -8.16110056e-03f, -2.96932738e-02f, -5.18958606e-02f, -1.64727529e-03f, 3.77554037e-02f,
  9.18950811e-02f, -8.30066055e-02f, 5.20471856e-03f, -7.29690641e-02f, 1.05545186e-02f, 4.39075008e-02f, 3.92510854e-02f, -1.06005371e-02f, -7.06764609e-02f, 1.20851174e-02f,
  -7.46472254e-02f, -6.33075014e-02f, 2.24170163e-02f, 5.31285144e-02f, 3.03833105e-04f, 6.05470650e-02f, 9.06263664e-03f, 4.84352969e-02f, -4.86507528e-02f, -1.59758106e-02f,
  2.15501282e-02f, -4.74242419e-02f, -9.22199711e-03f, -5.71342520e-02f, -5.07696047e-02f, 8.12608227e-02f, 6.25207946e-02f, 3.03777978e-02f, 1.70175303e-02f, -6.99221864e-02f,
  3.76691744e-02f, 6.74390793e-03f, -2.30660290e-02f, -5.21911234e-02f, 4.04843478e-04f, 5.24085648e-02f, -6.38510510e-02f, 2.70595178e-02f, -2.10050251e-02f, 7.33327568e-02f,
  -3.77057679e-03f, -1.50808632e-01f, -1.51139442e-02f, -5.86261824e-02f, -5.31281494e-02f, -6.09021038e-02f, -8.77947360e-03f, -1.56193748e-02f, 2.25204304e-02f, -6.74550310e-02f,
  9.16118640e-03f, -1.47158802e-02f, -2.30603777e-02f, -2.01965831e-02f, 5.85486852e-02f, 2.13203784e-02f, -9.14467406e-03f, -4.73505743e-02f, 1.40493521e-02f, 1.48204109e-02f,
  5.41766137e-02f, 2.90105883e-02f, -7.42829824e-03f, 4.30456214e-02f, -2.22396962e-02f, -1.28331691e-01f, 5.62937520e-02f, 6.16065674e-02f, -7.03274384e-02f, -5.44612296e-02f,
  -5.61322607e-02f, 5.21893911e-02f, -1.57712363e-02f, 8.18202645e-03f, -8.11227411e-02f, 5.95959928e-03f, -1.21288076e-01f, 9.84148607e-02f, -1.89529762e-01f, -6.26784712e-02f,
  -5.76578528e-02f, -1.52142733e-01f, -4.78706583e-02f, -9.25178304e-02f, -1.40649796e-01f, -1.31631702e-01f, 3.04387789e-02f, -1.17067844e-01f, 7.03485915e-03f, 1.10295177e-01f,
  1.07218072e-01f, 1.56934425e-01f, 2.14292817e-02f, 1.79092631e-01f, 3.64260487e-02f, 1.58489987e-01f, 1.72460809e-01f, 1.56379744e-01f, 7.77372643e-02f, 8.18230510e-02f,
  -6.74691424e-02f, -8.93222466e-02f, -2.88016964e-02f, -3.63695621e-02f, -3.22600417e-02f, 3.90250906e-02f, 8.68472829e-02f, 1.05083985e-02f, 3.18938233e-02f, -5.80347069e-02f,
  -8.14382657e-02f, -5.50257191e-02f, -2.95849741e-02f, -2.83668097e-02f, -4.22630087e-02f, 1.42029859e-02f, 7.32251927e-02f, -6.88696420e-03f, -1.84368156e-02f, -7.53893256e-02f,
  8.49865153e-02f, 4.11684550e-02f, -5.58635928e-02f, 3.38761061e-02f, -8.03992823e-02f, -5.03814742e-02f, -6.56631449e-03f, 4.74849679e-02f, -6.71038404e-02f, -2.55325604e-02f,
  1.75413415e-02f, -6.83409348e-02f, -2.15277094e-02f, -4.09846939e-02f, -1.90763194e-02f, -5.00886850e-02f, 1.92066412e-02f, 4.53090817e-02f, -2.26821704e-03f, 2.06522625e-02f,
  -2.12724395e-02f, -3.33686434e-02f, -3.45895253e-02f, -7.91038647e-02f, 9.75767989e-03f, -3.25504206e-02f, -3.23880836e-02f, 1.76926591e-02f, -6.02524579e-02f, -8.94462243e-02f,
  -3.20515409e-02f, 2.65524164e-02f, 2.05439497e-02f, 4.42088172e-02f, -3.74183850e-03f, -4.91797142e-02f, 1.13990353e-02f, -5.68364561e-02f, -5.04408330e-02f, 4.41465974e-02f,
  8.01000893e-02f, 1.34125084e-01f, 8.75831172e-02f, -5.73507175e-02f, -3.89030389e-02f, 6.13062978e-02f, -4.71929573e-02f, -3.38116065e-02f, 6.03704266e-02f, -6.73842505e-02f,
  2.25422494e-02f, 7.42713064e-02f, 9.51510668e-02f, 3.30614019e-03f, -4.07957062e-02f, 6.90556914e-02f, 5.78355715e-02f, 7.42807463e-02f, 4.44305427e-02f, 3.84831801e-02f,
  -1.98801644e-02f, -3.15670744e-02f, 1.81499235e-02f, -3.73407602e-02f, 4.47649136e-02f, -7.63800815e-02f, -1.07493643e-02f, 1.87972710e-02f, 2.09658630e-02f, -8.35320726e-02f,
  -1.71313033e-01f, -1.59168109e-01f, 8.44694208e-03f, 2.02515438e-01f, -4.51810518e-03f, -1.48100972e-01f, -2.34702453e-01f, -8.01051557e-02f, -1.63041800e-01f, -1.45816520e-01f,
  5.67582920e-02f, -4.40543853e-02f, -1.77097589e-01f, 8.23058933e-02f, 1.43961400e-01f, -1.92763269e-01f, 1.07885577e-01f, -2.33268403e-02f, -8.13897252e-02f, 7.06691220e-02f,
  1.96202233e-01f, 4.63347398e-02f, 5.98548204e-02f, 2.40968823e-01f, 3.26169841e-02f, 2.15839624e-01f, 2.42618352e-01f, 1.56982075e-02f, 2.87393183e-01f, 1.36196285e-01f,
  -8.53403732e-02f, -1.02351576e-01f, 2.27253307e-02f, -3.54946628e-02f, 2.13571806e-02f, 1.74416322e-02f, 4.28555943e-02f, -2.15430353e-02f, 9.97276902e-02f, 4.63909023e-02f,
  -2.55823601e-02f, 4.05274071e-02f, 1.03812233e-01f, -3.27590704e-02f, 3.63465212e-02f, 1.82806235e-02f, 3.84609401e-02f, -4.90203351e-02f, -1.20688863e-02f, -3.64859812e-02f,
  3.91745986e-03f, -4.01925147e-02f, 5.59574440e-02f, 3.06830686e-02f, -5.16585894e-02f, -3.01196892e-03f, 4.78416234e-02f, 3.47186700e-02f, 7.34268427e-02f, -3.73461619e-02f,
  -2.59044264e-02f, -1.49975317e-02f, -3.06781642e-02f, 4.44611907e-02f, -2.99067535e-02f, 4.32767160e-02f, 6.33779839e-02f, 4.80349734e-02f, 2.95969974e-02f, 7.11295009e-03f,
  4.90610413e-02f, -4.16329354e-02f, -9.35399719e-03f, 5.71580864e-02f, 2.66541187e-02f, -5.27630784e-02f, 1.80305436e-03f, 3.37933563e-02f, -3.80765572e-02f, 2.54642479e-02f,
  3.39731462e-02f, -2.90736258e-02f, -5.95265348e-03f, -6.95539936e-02f, -7.06222877e-02f, 4.83458638e-02f, -5.39694950e-02f, -5.78470156e-02f, -2.57610474e-02f, -7.50389695e-02f,
  4.72618118e-02f, 1.47895887e-01f, 1.78356040e-02f, 5.87804280e-02f, 8.17565843e-02f, -2.88595129e-02f, -6.31778035e-03f, -3.09605841e-02f, 3.93225178e-02f, -5.20136617e-02f,
  8.12623352e-02f, 5.25151007e-02f, 5.55515522e-03f, 7.06746504e-02f, 1.06294975e-01f, -1.05520897e-02f, 8.47809091e-02f, 7.94096738e-02f, 8.47006738e-02f, 6.55751303e-02f,
  1.25993078e-03f, 5.58237021e-04f, -4.91989106e-02f, -3.83784585e-02f, -1.38537269e-02f, 3.60767059e-02f, 3.38720828e-02f, 4.04943936e-02f, 4.64915968e-02f, 8.76073316e-02f,
  6.02341555e-02f, 1.20799862e-01f, 7.36989751e-02f, -4.91625909e-03f, -1.64996530e-03f, -1.49232252e-02f, -1.50759533e-01f, -7.04951361e-02f, 3.54894698e-02f, -7.17205182e-03f,
  -1.85969900e-02f, 2.45685992e-03f, -5.82153574e-02f, -1.08050272e-01f, -1.43479249e-02f, 4.01865169e-02f, 1.05492398e-02f, -1.23500355e-01f, 2.77225059e-02f, -1.14802882e-01f,
  9.61074159e-02f, -9.92215797e-03f, 2.04492342e-02f, -8.20164010e-02f, -1.58215284e-01f, -4.97379228e-02f, -1.42106060e-02f, -2.32606791e-02f, 1.12766419e-02f, 4.20968682e-02f,
  6.28978685e-02f, 7.23775625e-02f, 4.84174006e-02f, 9.54553559e-02f, 1.28009850e-02f, -2.90224962e-02f, -3.89788076e-02f, -4.35581896e-03f, -1.77983735e-02f, 6.86852708e-02f,
  4.88577560e-02f, 2.01329291e-02f, 1.79937985e-02f, 4.10029739e-02f, 5.67614250e-02f, -1.46350898e-02f, 1.19255669e-03f, -2.00949013e-02f, 2.98372880e-02f, 2.66786385e-02f,
  1.51980401e-03f, -7.18377009e-02f, 7.74216801e-02f, 8.46745521e-02f, 8.79813880e-02f, 2.47863471e-03f, 5.69531918e-02f, 2.77218521e-02f, 6.82236776e-02f, 4.19539288e-02f,
  1.78247411e-02f, -3.84154581e-02f, 4.26888503e-02f, -7.67963156e-02f, -8.14731345e-02f, 5.40468022e-02f, -7.01074600e-02f, -2.86740847e-02f, 1.89202223e-02f, -4.39866930e-02f,
  -7.79250115e-02f, 3.77482958e-02f, -6.42443746e-02f, 7.76623189e-02f, 8.47580507e-02f, 8.07077214e-02f, 3.25292088e-02f, -8.09545293e-02f, -3.17309014e-02f, 5.42319342e-02f,
  3.42290848e-02f, -9.36177652e-03f, 6.33312464e-02f, 2.32778080e-02f, -4.16144989e-02f, 2.43919790e-02f, 3.98591124e-02f, -7.47091398e-02f, 8.24122727e-02f, -1.09394610e-01f,
  1.85828842e-02f, -3.38743851e-02f, -5.34024090e-02f, 2.67120544e-02f, 4.68262807e-02f, 4.22973149e-02f, 7.34976381e-02f, -6.49397150e-02f, 2.85590906e-02f, 3.83990537e-03f,
  -1.63779743e-02f, 7.14669004e-03f, -7.69388825e-02f, -5.82421720e-02f, 8.90261214e-03f, -4.84880581e-02f, -4.08437699e-02f, 8.36289153e-02f, -3.81901115e-02f, 6.43577278e-02f,
  -9.69752222e-02f, 3.30555327e-02f, -3.90179604e-02f, 3.84608731e-02f, 2.59278435e-02f, 3.11537813e-02f, 6.18571378e-02f, -8.14027637e-02f, -8.16040561e-02f, -3.09004262e-02f,
  3.24677229e-02f, 1.30307958e-01f, 2.15747301e-02f, 2.87616663e-02f, 1.78447261e-03f, -1.02060504e-01f, -1.36840418e-01f, 5.17580099e-02f, -2.34316774e-02f, -1.13046214e-01f,
  9.43252742e-02f, -3.02811414e-02f, -1.23922769e-02f, 2.73876023e-02f, 1.44007169e-02f, 4.52266559e-02f, 1.21662498e-01f, -6.21748082e-02f, -4.81739780e-03f, 3.79909836e-02f,
  1.74074441e-01f, 7.67878070e-02f, 1.98258400e-01f, 1.44850448e-01f, 6.86531737e-02f, 8.39958191e-02f, 2.00467303e-01f, 7.55269155e-02f, 1.68894172e-01f, -1.87824145e-02f,
  1.39735062e-02f, -2.23397575e-02f, 1.47476923e-02f, -1.05251729e-01f, -3.12318876e-02f, -2.16972418e-02f, -6.73053786e-02f, 7.88527876e-02f, 2.74467655e-02f, -1.99976154e-02f,
  -4.00271080e-02f, 6.01789914e-03f, -6.37741014e-02f, 1.02908285e-02f, -8.70701447e-02f, -4.13550399e-02f, 6.42490834e-02f, -5.48948571e-02f, 2.96721067e-02f, -1.65718738e-02f,
  -5.32234274e-02f, -3.61443148e-03f, 5.56449555e-02f, -3.49998139e-02f, 3.60004492e-02f, 5.58447726e-02f, -1.14438301e-02f, 1.36661704e-03f, 5.85872158e-02f, 2.57153120e-02f,
  -5.45694865e-02f, 2.11740285e-02f, 3.85289863e-02f, -3.31462920e-02f, 5.24611026e-02f, 6.69387951e-02f, -5.83010502e-02f, 3.19780745e-02f, -1.86308641e-02f, 1.10859219e-02f,
  -5.85499778e-02f, 5.87711968e-02f, 1.66647993e-02f, 5.63032776e-02f, -2.86622848e-02f, -6.85982779e-02f, 7.67708570e-02f, -1.89529173e-02f, -2.07518861e-02f, 1.83962453e-02f,
  1.40787652e-02f, 5.86943105e-02f, -7.41861686e-02f, 5.70050627e-03f, -5.63597865e-02f, 7.82884657e-02f, 9.55828130e-02f, 7.25788847e-02f, -4.64419425e-02f, 5.09249792e-02f,
  3.09725329e-02f, 2.04202145e-01f, -5.63196354e-02f, -1.01295292e-01f, -4.42929491e-02f, 1.78075451e-02f, 6.09660856e-02f, -1.63436844e-03f, 2.91798674e-02f, 8.60004127e-02f,
  -5.20321429e-02f, -7.36679956e-02f, 7.88522065e-02f, -7.12952986e-02f, -4.76560369e-02f, -1.09477239e-02f, 2.29035933e-02f, -6.92071840e-02f, -2.74458975e-02f, 2.85958610e-02f,
  -5.00940606e-02f, -8.03107470e-02f, 1.85392667e-02f, -8.66922289e-02f, -1.96469226e-03f, -9.10772309e-02f, 5.08725084e-02f, 5.50945066e-02f, -1.61869135e-02f, 8.27571228e-02f,
  -2.36606076e-02f, -7.36731440e-02f, -5.02823712e-03f, -2.04981510e-02f, -1.00507341e-01f, -1.92648042e-02f, -6.11011274e-02f, -8.07472169e-02f, -9.67254639e-02f, -1.34606259e-02f,
  2.56423969e-02f, 1.25169381e-01f, -9.92964394e-03f, 1.08000256e-01f, 8.85730460e-02f, 2.97207888e-02f, 5.98253356e-03f, 3.15075293e-02f, -4.81575280e-02f, -7.35047534e-02f,
  4.98331152e-02f, 4.76512797e-02f, 2.00937083e-03f, -4.65194769e-02f, -2.74161268e-02f, 5.45206405e-02f, 1.74627472e-02f, 1.23714993e-03f, -9.71779507e-03f, 1.53222047e-02f,
  2.54080128e-02f, -2.50684209e-02f, -1.18055092e-02f, 2.86610015e-02f, -4.61041629e-02f, 1.89758278e-02f, 8.27267766e-02f, 2.13731616e-03f, -6.67213788e-03f, -1.02086633e-01f,
  -4.44405749e-02f, 2.44386643e-02f, 6.49265647e-02f, -6.57020807e-02f, -8.78802463e-02f, -2.99845450e-02f, 6.47886246e-02f, -7.88886473e-02f, 2.38693375e-02f, 4.43078876e-02f,
  -1.92872807e-02f, 6.31866679e-02f, -6.99639844e-04f, -3.87225784e-02f, 1.33430194e-02f, -8.06634501e-02f, 8.91795233e-02f, -3.18727270e-02f, -6.94851950e-02f, 6.80276752e-02f,
  2.55240444e-02f, 3.37160602e-02f, 4.57270183e-02f, -6.39308169e-02f, -4.75296564e-03f, -7.41197839e-02f, 1.41472332e-02f, -2.03804057e-02f, -5.63692376e-02f, 2.75751371e-02f,
  3.33868503e-03f, -8.90167728e-02f, 5.87309934e-02f, -7.66328499e-02f, -6.19550981e-02f, 6.88352659e-02f, -5.86256459e-02f, 4.14080918e-02f, -2.87570097e-02f, -1.71802454e-02f,
  4.12860736e-02f, 6.33057300e-03f, 2.68303175e-02f, -2.24843305e-02f, 7.64183030e-02f, 4.97318618e-02f, 8.41349810e-02f, -6.85683489e-02f, 8.12753737e-02f, -6.82266057e-02f,
  6.63556010e-02f, -4.12617810e-02f, 6.48273900e-02f, 9.83486045e-03f, -4.34792787e-02f, -4.00989912e-02f, 6.98906407e-02f, 1.88211352e-02f, 3.37252915e-02f, -8.38814080e-02f,
  -6.23286441e-02f, 7.66670182e-02f, -7.60744289e-02f, 1.00122951e-01f, -2.52673980e-02f, 6.18626922e-02f, -4.85237874e-02f, 1.03548110e-01f, -7.71353312e-04f, 6.58167228e-02f,
  -1.54839866e-02f, 7.70076737e-02f, -4.37939577e-02f, 6.53136987e-03f, 7.04419538e-02f, -4.95237187e-02f, 4.03920822e-02f, 8.68004560e-02f, 3.21852751e-02f, 1.59133971e-02f,
  -1.60966635e-01f, -7.36444071e-02f, 2.01726481e-02f, -1.25842392e-01f, -6.35483637e-02f, 8.11731368e-02f, 1.60671603e-02f, -5.16054109e-02f, -6.58235997e-02f, -1.76141262e-02f,
  -5.97223341e-02f, -1.21612206e-01f, -4.22847159e-02f, -3.54186185e-02f, -9.95799229e-02f, 5.06124161e-02f, 3.52461375e-02f, -5.41816019e-02f, -7.92222694e-02f, 5.79329766e-02f,
  4.35304791e-02f, -1.45775735e-01f, 5.73155992e-02f, 5.40739708e-02f, 1.90568585e-02f, 9.17333458e-03f, 7.76483864e-02f, 9.39489622e-03f, -7.20556825e-02f, 3.60392220e-02f,
  -3.44543979e-02f, -7.81789646e-02f, -1.24850469e-02f, 5.71807288e-02f, -3.14318053e-02f, 3.31694223e-02f, 7.28574023e-02f, 8.93781334e-03f, -2.65934486e-02f, 4.48322631e-02f,
  -9.41237658e-02f, -3.55795887e-03f, 1.70425288e-02f, -5.74273467e-02f, -8.17722976e-02f, 2.33684923e-03f, -4.85496707e-02f, 6.99510947e-02f, -2.80153044e-02f, 3.65130045e-02f,
  -3.54900844e-02f, -4.48643975e-02f, 9.55350399e-02f, 3.33932750e-02f, 7.84751102e-02f, -6.26922473e-02f, -1.08372308e-02f, -8.61710869e-03f, -1.29881408e-02f, -3.15353237e-02f,
  -8.58448222e-02f, 9.06601399e-02f, -8.12928230e-02f, 6.45116642e-02f, 3.17713879e-02f, 3.03200372e-02f, -6.77892193e-02f, -5.72960712e-02f, -5.91047145e-02f, -1.31265260e-02f,
  -4.94209342e-02f, 8.30366984e-02f, -4.34161052e-02f, -5.72574213e-02f, 3.52558568e-02f, 3.02018560e-02f, -2.54513212e-02f, 8.66475329e-02f, -4.96492311e-02f, 8.91974047e-02f,
  -3.65845375e-02f, -4.07375917e-02f, 2.44685058e-02f, -7.90911466e-02f, 3.27196382e-02f, -7.23371375e-03f, -9.25827958e-03f, -8.54135007e-02f, -3.90694290e-02f, -3.78169641e-02f,
  -3.89271565e-02f, -3.99412923e-02f, -2.03014370e-02f, 2.20779721e-02f, -3.08712516e-02f, -5.07493550e-03f, 4.57918681e-02f, -4.09385469e-03f, 4.10143146e-03f, 6.47031218e-02f,
  8.84056613e-02f, 9.88649428e-02f, 7.33284205e-02f, 6.22553453e-02f, -3.21476981e-02f, -1.56045705e-02f, 3.59538235e-02f, -7.07397982e-02f, 6.21107370e-02f, 8.14253241e-02f,
  -6.86717257e-02f, 6.35908619e-02f, 8.69646668e-02f, 7.74283707e-02f, 1.63021497e-02f, 6.39700145e-02f, 7.45911449e-02f, -8.79858583e-02f, 4.00020480e-02f, -6.11636862e-02f,
  -8.14533851e-04f, -1.78407714e-01f, 4.72585205e-03f, -9.43524614e-02f, -6.50517121e-02f, -1.64741933e-01f, -7.10562095e-02f, -2.12667868e-01f, 4.09483723e-02f, -6.56896383e-02f,
  4.05680574e-02f, 3.55858766e-02f, 6.73240870e-02f, -8.75014961e-02f, 1.07262835e-01f, 2.04010800e-01f, -7.45191649e-02f, -9.59486067e-02f, 6.40051067e-02f, -2.02932209e-01f,
  2.06287149e-02f, -1.70243308e-01f, 2.32948661e-02f, -7.28204697e-02f, -1.61778882e-01f, -3.58689837e-02f, -1.80977006e-02f, 2.55822744e-02f, -1.15443274e-01f, -2.38264706e-02f,
  -1.31564662e-01f, -1.62418842e-01f, -6.21097051e-02f, -7.63402833e-03f, -9.36664939e-02f, -5.69019578e-02f, 4.64152172e-02f, -2.77069135e-04f, 3.88748273e-02f, -5.37374206e-02f,
  1.34604210e-02f, -7.78915361e-02f, 2.12770551e-02f, 1.02768630e-01f, -3.13885845e-02f, -8.97333175e-02f, 4.11792211e-02f, 3.92288603e-02f, -7.41328225e-02f, 5.38525619e-02f,
  4.83681783e-02f, -2.14910358e-02f, 1.07913151e-01f, -2.07433216e-02f, 1.10399105e-01f, -5.09038642e-02f, 5.78780510e-02f, 1.10615425e-01f, -1.04112938e-01f, -7.74276555e-02f,
  4.54418771e-02f, 8.09724033e-02f, -7.51421973e-02f, 4.22576964e-02f, -2.86306236e-02f, 1.02245837e-01f, -7.65699074e-02f, -5.27116098e-02f, -5.74233234e-02f, -4.59036976e-02f,
  2.18385011e-02f, -8.06284416e-03f, -2.27184240e-02f, -1.74213620e-03f, 2.28003617e-02f, -6.10388629e-02f, 1.10200979e-01f, -9.10938978e-02f, 8.26516375e-03f, 8.11216310e-02f,
  -2.85719819e-02f, 1.29232407e-02f, 6.09719492e-02f, 2.63191517e-02f, -3.29009108e-02f, 5.55234738e-02f, 2.53637582e-02f, -2.37704571e-02f, 7.46650770e-02f, -8.84138197e-02f,
  -1.84519261e-01f, -2.25978315e-01f, -1.03201695e-01f, -3.41872908e-02f, -5.93527332e-02f, -3.73995455e-04f, 2.48376410e-02f, -1.15029454e-01f, -1.42904833e-01f, -5.49869947e-02f,
  -9.31595117e-02f, 7.63986558e-02f, -4.43434641e-02f, -8.15371796e-02f, -3.12495176e-02f, 1.23133585e-02f, 3.36591974e-02f, -4.18965816e-02f, 1.61795635e-02f, -6.12301566e-02f,
  -5.32070361e-02f, 1.69807505e-02f, 7.03088343e-02f, 7.95792565e-02f, 2.58881096e-02f, -9.86953005e-02f, -1.60837173e-02f, 4.83567975e-02f, 4.46480699e-02f, 7.63740111e-03f,
  2.02808902e-01f, -6.65004328e-02f, -1.37295723e-01f, 2.96827145e-02f, -5.09309163e-03f, 7.37299398e-02f, 1.00542963e-01f, -5.18785454e-02f, -3.13637219e-02f, -6.06063195e-02f,
  4.47603203e-02f, -2.04743035e-02f, -1.43971406e-02f, 1.71606511e-01f, 1.07301801e-01f, 1.08655751e-01f, 1.34249434e-01f, 7.26028234e-02f, -7.29900375e-02f, 1.28311977e-01f,
  1.91118494e-02f, 8.64578784e-02f, -9.49268341e-02f, -3.32453772e-02f, 1.16170980e-02f, -1.72071066e-02f, -6.84200302e-02f, -8.65174830e-02f, -2.98140813e-02f, 8.11073035e-02f,
  8.46368968e-02f, 5.52613102e-02f, 4.59161662e-02f, 1.35149499e-02f, 7.63809904e-02f, -6.70422986e-02f, -9.21711922e-02f, 7.46759698e-02f, 5.40911295e-02f, -9.73121822e-03f,
  4.18173261e-02f, -9.39709023e-02f, 7.56119639e-02f, 7.19330311e-02f, 1.60992320e-04f, -2.61400547e-02f, -5.13272099e-02f, 1.31464554e-02f, -6.10220917e-02f, -4.20584716e-02f,
  -5.83092719e-02f, -3.50747593e-02f, 4.05990444e-02f, 2.15505641e-02f, -4.19382416e-02f, 2.10570419e-04f, -1.64130889e-02f, -4.99941707e-02f, -5.04387505e-02f, 3.67451049e-02f,
  4.22344357e-02f, 6.32196963e-02f, -1.92659944e-02f, -1.68205500e-02f, 2.24811658e-02f, -1.08803818e-02f, -3.28257196e-02f, 5.69330752e-02f, -6.15092739e-02f, 4.89723049e-02f,
  -5.86064868e-02f, 7.32849985e-02f, -5.47435023e-02f, -6.90543791e-03f, -2.43977923e-02f, -7.89778382e-02f, -6.08386621e-02f, 3.65627706e-02f, -3.88626941e-02f, 3.80213968e-02f,
  -2.01620497e-02f, 5.29276300e-03f, 5.74485324e-02f, -3.22351493e-02f, -7.86443353e-02f, -1.21025071e-02f, 5.59639968e-02f, 1.18864663e-02f, 3.77392918e-02f, 7.29260147e-02f,
  -2.52235644e-02f, 7.33225420e-02f, -5.53446449e-02f, -9.08347517e-02f, -9.87236276e-02f, 3.77275841e-03f, 4.90268730e-02f, 8.31631348e-02f, -4.13228339e-03f, 8.01459849e-02f,
  6.55978844e-02f, 3.70682627e-02f, 9.20063555e-02f, 9.62218922e-03f, -7.51680732e-02f, 8.19313675e-02f, 3.49832512e-02f, -5.14296480e-02f, 5.48580736e-02f, -5.51869646e-02f,
  1.00097654e-03f, 3.52062914e-03f, 2.57120449e-02f, 4.15548384e-02f, 4.97177877e-02f, 5.73900603e-02f, 2.89714411e-02f, -8.09882507e-02f, -1.10967262e-02f, -8.73475627e-04f,
  -3.61920521e-02f, 9.33359712e-02f, 1.27846122e-01f, 2.24885084e-02f, -4.62988690e-02f, -2.44075790e-01f, -1.47379190e-01f, 1.05679492e-02f, -1.31356686e-01f, -1.46432206e-01f,
  -1.66690059e-03f, -2.00355016e-02f, 7.89614692e-02f, 9.52271670e-02f, 1.14336058e-01f, 1.26016945e-01f, -8.52825027e-03f, -3.59000149e-03f, 5.46486601e-02f, 1.37840569e-01f,
  1.24184102e-01f, 6.31172061e-02f, 2.79257149e-01f, 1.61227524e-01f, 8.74104798e-02f, 1.79155052e-01f, 1.09873109e-01f, -1.23150868e-03f, -1.80144422e-02f, -7.49298781e-02f,
  3.77975665e-02f, 1.05275780e-01f, 1.17517607e-02f, -1.04679428e-01f, 1.14207051e-03f, 3.16228457e-02f, 1.86630376e-02f, -3.41808274e-02f, -7.46363550e-02f, -6.83286265e-02f,
  4.87982929e-02f, -4.38728370e-02f, -5.21968864e-02f, 3.49736512e-02f, 5.85630499e-02f, -2.45417822e-02f, 1.05979498e-02f, -6.00601453e-03f, -7.14531416e-05f, -1.11101680e-02f,
  -1.21730724e-02f, -7.03190193e-02f, 1.54772373e-02f, -2.25918517e-02f, 8.23572055e-02f, -5.71365654e-02f, 1.79908909e-02f, 8.63972977e-02f, -2.28339359e-02f, 9.50536504e-03f,
  1.07145637e-01f, -6.52480945e-02f, -4.80649173e-02f, -5.62435873e-02f, 5.76537475e-02f, 1.32311555e-02f, -2.91553233e-02f, 4.05336730e-02f, 5.25534824e-02f, -7.72781372e-02f,
  3.87967117e-02f, -1.00760972e-02f, -3.13355550e-02f, -5.07338643e-02f, -2.68296637e-02f, -4.59525809e-02f, -7.94382319e-02f, -5.52398302e-02f, -7.96252768e-03f, 7.59531632e-02f,
  -8.45859796e-02f, -7.20939189e-02f, -6.82081329e-04f, -1.01210684e-01f, 3.24656479e-02f, -4.11917791e-02f, 6.37694001e-02f, 5.13975099e-02f, 4.87422831e-02f, 7.74184242e-02f,
  1.38427336e-02f, 2.04359815e-01f, 7.01732188e-02f, -7.14542866e-02f, 7.18464404e-02f, -5.30727319e-02f, -3.72365490e-02f, 1.60031095e-02f, 3.78459552e-03f, -2.75637750e-02f,
  -2.26529147e-02f, -7.61803538e-02f, -3.58912162e-02f, 5.10254912e-02f, 6.65060580e-02f, 4.82896380e-02f, -1.61205698e-02f, -5.22391088e-02f, 2.00796183e-02f, 6.75496235e-02f,
  7.73672312e-02f, -3.36957313e-02f, -4.59936075e-03f, -2.17519794e-03f, -7.00202584e-02f, 4.46245372e-02f, -4.33959626e-02f, -4.06303667e-02f, 2.65943594e-02f, 5.57992887e-03f,
  -1.21579908e-01f, 1.31873459e-01f, 3.27938912e-03f, 1.36314467e-01f, -1.12997442e-01f, -1.37273192e-01f, 2.47258469e-02f, -5.08491769e-02f, -4.79902998e-02f, 1.83932126e-01f,
  6.41130954e-02f, 8.06072429e-02f, 8.32678229e-02f, 6.83076158e-02f, -3.94722372e-02f, 1.85295548e-02f, 1.26401305e-01f, 2.74540111e-02f, -1.96125098e-02f, 4.57968339e-02f,
  -8.62945765e-02f, -1.81594789e-02f, 6.39864057e-02f, -5.44917285e-02f, -3.59871536e-02f, 5.81388883e-02f, 6.77991807e-02f, -8.26039235e-04f, -5.58306165e-02f, -1.28147975e-01f,
  -1.22164227e-01f, 9.53647867e-02f, -3.60568240e-02f, -1.13279328e-01f, -7.91402236e-02f, 5.70690632e-02f, -4.98327836e-02f, -8.22641701e-02f, -6.67552948e-02f, -4.22195792e-02f,
  -1.02255598e-01f, -4.78594564e-02f, -8.80674925e-05f, -7.50007331e-02f, -1.80955534e-03f, 3.74514088e-02f, -6.12245239e-02f, -4.36436646e-02f, -4.95096184e-02f, -7.21240789e-02f,
  1.01462975e-02f, 4.28588549e-03f, 3.21943387e-02f, 9.08112153e-02f, -5.83215505e-02f, -7.75081888e-02f, 2.13796925e-02f, 2.86309570e-02f, 4.26335484e-02f, -3.38270143e-02f,
  6.53073639e-02f, 1.66090578e-02f, -6.31723031e-02f, -7.69561753e-02f, 7.37839639e-02f, 5.29560000e-02f, -6.54379129e-02f, 7.15742111e-02f, -5.19329533e-02f, 5.53471483e-02f,
  5.12504429e-02f, 4.85325744e-03f, -1.50399962e-02f, -6.77337348e-02f, 5.44992164e-02f, -2.23982371e-02f, -2.86889300e-02f, -8.93060640e-02f, -7.20629171e-02f, 2.40313355e-03f,
  2.84878979e-03f, 4.64025736e-02f, 6.90655690e-03f, -6.86307698e-02f, -9.61542800e-02f, 7.45203421e-02f, 1.07069790e-01f, 3.59382853e-02f, -4.72018272e-02f, 2.43550614e-02f,
  -1.00108877e-01f, 1.39519900e-01f, -5.45118488e-02f, -7.62315392e-02f, -1.99694671e-02f, 5.12325205e-02f, -6.02763668e-02f, -7.43851736e-02f, 1.15721889e-01f, 9.55521837e-02f,
  1.01016937e-02f, 2.46134726e-03f, -5.30093759e-02f, 8.35712254e-02f, -5.70805036e-02f, -8.48240852e-02f, 7.90549889e-02f, -7.94989429e-03f, -2.20107175e-02f, 1.03610158e-02f,
  2.37882342e-02f, 4.75144722e-02f, 7.55245835e-02f, -6.94871694e-02f, -1.23949451e-02f, 5.28780371e-02f, -7.79634789e-02f, 4.26788852e-02f, -2.23050117e-02f, 8.91528428e-02f,
  9.06062219e-03f, 1.08505413e-01f, 6.98297545e-02f, 5.19904010e-02f, 3.75831574e-02f, 6.09377325e-02f, 4.28173095e-02f, 7.93363824e-02f, 1.05247386e-02f, -8.73354375e-02f,
  -7.62888193e-02f, 8.08935016e-02f, -4.20746766e-02f, 2.58235633e-03f, 2.80090384e-02f, 2.18334086e-02f, -1.35291992e-02f, 9.36385095e-02f, 7.59600848e-02f, -3.31763849e-02f,
  1.00835018e-01f, 2.00705417e-02f, -1.93576906e-02f, 3.38048898e-02f, -3.43253054e-02f, -1.64249595e-02f, -1.03812948e-01f, 6.20261915e-02f, -5.14755473e-02f, 7.92140663e-02f,
  6.14367276e-02f, 3.28161865e-02f, -3.41943875e-02f, -8.85215774e-02f, -5.65631390e-02f, -1.02899440e-01f, 1.98834781e-02f, 7.67523935e-03f, 5.68718463e-02f, 6.57958686e-02f,
  7.71383196e-02f, 4.45752330e-02f, -4.18442525e-02f, 8.96101817e-02f, -1.70008540e-02f, -1.38282767e-02f, -6.80751130e-02f, -4.37739380e-02f, 5.53817227e-02f, -9.61096883e-02f,
  -2.95317788e-02f, -1.44837368e-02f, -2.89101545e-02f, -1.93700604e-02f, 2.43569282e-03f, -6.39325008e-02f, 7.46257901e-02f, 6.93910047e-02f, -3.43270774e-04f, -6.21254221e-02f,
  -4.41579148e-02f, 1.11002870e-01f, -3.41831632e-02f, -3.41867954e-02f, 7.05720782e-02f, 8.44812319e-02f, -4.25168984e-02f, -3.42703499e-02f, -5.57521023e-02f, -8.31245407e-02f,
  -2.07496770e-02f, -8.57761800e-02f, 4.09199856e-02f, 2.12133173e-02f, -2.04987768e-02f, -2.00059451e-02f, -1.35666626e-02f, -3.59110124e-02f, 6.48475066e-02f, -7.27206841e-02f,
  -5.73112145e-02f, -8.36852044e-02f, -3.33502926e-02f, -4.11697775e-02f, -8.03623796e-02f, 6.68574348e-02f, -9.61480141e-02f, -8.45767260e-02f, 6.98786899e-02f, -5.13978787e-02f,
  4.36195126e-03f, 5.04722781e-02f, 3.17693353e-02f, 2.37469971e-02f, -2.65076067e-02f, -8.95393491e-02f, 1.34298252e-02f, -6.37745038e-02f, 7.91762993e-02f, 2.19851248e-02f,
  7.21497387e-02f, 4.32712352e-03f, 1.49863558e-02f, 4.04190533e-02f, 1.57944523e-02f, -3.92278731e-02f, -6.24890439e-03f, 1.98241509e-02f, -2.51206215e-02f, 3.38079855e-02f,
  -8.16667229e-02f, 7.58325979e-02f, -3.82615961e-02f, 5.03749698e-02f, -9.30950865e-02f, 4.22525704e-02f, -1.40604388e-03f, 5.53526245e-02f, -8.00996423e-02f, 7.08842278e-02f,
  5.38777784e-02f, 1.22601189e-01f, -1.59529239e-01f, -5.41527532e-02f, 5.48889786e-02f, 1.48480192e-01f, 8.66816640e-02f, 6.22905120e-02f, 4.00255173e-02f, 1.48951456e-01f,
  7.37756416e-02f, -3.04475706e-03f, -1.46031668e-02f, 3.14754881e-02f, -4.36845869e-02f, 4.28267792e-02f, 3.97384055e-02f, 9.21370462e-02f, -1.41889723e-02f, 9.87162217e-02f,
  -1.91651620e-02f, 1.89193264e-02f, -2.73012295e-02f, -2.20358055e-02f, -3.34373191e-02f, -1.36917755e-01f, -3.00838668e-02f, -3.89098898e-02f, 7.83117786e-02f, 6.99088871e-02f,
  -4.78772782e-02f, -9.73853841e-02f, 2.12916452e-02f, 2.24822182e-02f, 5.34440151e-05f, -2.83361208e-02f, -2.51434147e-02f, -4.11073714e-02f, 3.29234339e-02f, 8.33083969e-03f,
  9.79253463e-03f, -5.65298572e-02f, 2.05286825e-03f, -5.33342250e-02f, 8.92054811e-02f, -7.61721730e-02f, -8.37442055e-02f, -6.33646408e-03f, 1.31466091e-02f, -7.28522986e-02f,
  5.09445481e-02f, 3.17496285e-02f, 6.58108070e-02f, -4.53011249e-04f, 3.15742195e-02f, -9.14936662e-02f, -2.29701977e-02f, -1.67046413e-02f, 6.88401759e-02f, -2.84844544e-02f,
  7.00043291e-02f, -7.94938877e-02f, -5.91218323e-02f, -2.61028996e-03f, 1.19555146e-02f, -3.10809724e-02f, 2.93131042e-02f, -7.34745190e-02f, 7.38056153e-02f, 1.02631124e-02f,
  -1.91568416e-02f, 3.64625491e-02f, -5.59925586e-02f, 5.43813338e-04f, 5.76874651e-02f, 8.61593261e-02f, -1.20899063e-02f, 2.29758490e-03f, 1.62772276e-02f, -4.73223962e-02f,
  4.11618222e-03f, 2.51286626e-02f, 7.59511739e-02f, 4.68487106e-02f, -5.10169007e-02f, -1.26981586e-02f, 4.21053059e-02f, -2.75764074e-02f, -9.57981721e-02f, -3.07370648e-02f,
  8.03746283e-02f, 1.14285067e-01f, -7.84201920e-03f, -2.84724869e-02f, -5.32157086e-02f, 7.62156546e-02f, -5.84900677e-02f, -8.01727325e-02f, -9.21998639e-03f, 5.08676320e-02f,
  1.47897946e-02f, 8.68322402e-02f, -3.71029787e-02f, 4.75172363e-02f, -7.47802928e-02f, 3.35386544e-02f, 3.10771577e-02f, -2.19958350e-02f, 7.85388723e-02f, -2.02289075e-02f,
  1.82602871e-02f, 2.65044477e-02f, -3.79256951e-03f, 6.26153871e-02f, 6.76611885e-02f, -7.97328055e-02f, 3.07522081e-02f, -3.69087458e-02f, 5.11634424e-02f, 6.10571238e-04f,
  1.37124900e-02f, -1.45494625e-01f, -1.81371719e-01f, -1.06115878e-01f, 7.13747218e-02f, 1.98344141e-02f, -1.00523151e-01f, -9.09476578e-02f, -1.45200923e-01f, -2.67850608e-02f,
  -2.41437834e-02f, -5.18212505e-02f, -1.47067904e-02f, 1.40131503e-01f, 1.35721579e-01f, -2.90796421e-02f, 8.85875970e-02f, 3.18176821e-02f, 1.86364539e-02f, -3.26680355e-02f,
  -2.07503326e-02f, 6.28078133e-02f, 9.58509073e-02f, 1.49706930e-01f, 5.33404350e-02f, 4.25366350e-02f, 1.39335796e-01f, -9.41997021e-02f, 1.56511620e-01f, 6.62137419e-02f,
  5.75662255e-02f, -1.00466959e-01f, -6.17900006e-02f, -6.77783228e-03f, -3.48402858e-02f, -2.63580624e-02f, -5.70266768e-02f, -6.30936325e-02f, -1.86244724e-03f, 6.40843585e-02f,
  8.99543811e-04f, 2.16359049e-02f, 1.58853084e-02f, -3.66018862e-02f, 9.25236475e-03f, -5.44555895e-02f, -4.77926061e-02f, 1.41563499e-02f, 7.87103176e-03f, 3.52806598e-02f,
  2.53527015e-02f, 5.50951296e-03f, -5.14613949e-02f, -1.05453758e-02f, -3.08902841e-02f, -1.06452063e-01f, -2.49752756e-02f, 4.52438369e-02f, -6.81222752e-02f, 5.78099862e-02f,
  -2.86693573e-02f, 7.59779811e-02f, -5.76306414e-03f, 6.36665002e-02f, 1.34292189e-02f, -6.53933063e-02f, 4.32792790e-02f, 4.34726886e-02f, 4.42901663e-02f, -5.93304746e-02f,
  -9.81282890e-02f, -3.53067406e-02f, 4.39841412e-02f, -3.26121077e-02f, -5.90920523e-02f, -4.75142756e-03f, 9.28938463e-02f, 2.69334838e-02f, -7.50164241e-02f, -4.22478803e-02f,
  -4.97445688e-02f, 5.56599256e-03f, -4.15264852e-02f, 5.95407225e-02f, -3.36727723e-02f, 1.45128286e-02f, 8.20371211e-02f, 6.21594861e-02f, -7.60507807e-02f, -6.35456741e-02f,
  -2.52281707e-02f, 4.45485227e-02f, 1.11354301e-02f, 3.58142331e-02f, 3.34807411e-02f, -4.70220335e-02f, 6.58159554e-02f, 2.14867629e-02f, 6.11937903e-02f, -8.71629715e-02f,
  -1.89888738e-02f, -5.35613261e-02f, -3.73043539e-03f, 3.00586503e-02f, -2.71927733e-02f, 3.09295696e-03f, -7.09596053e-02f, 8.00057128e-03f, -2.04394269e-03f, 6.13252074e-02f,
  5.04183257e-03f, -1.29572358e-02f, 8.07402655e-02f, -7.12167323e-02f, 4.99400944e-02f, -3.60610187e-02f, 2.59909388e-02f, 6.86270967e-02f, -1.82651374e-02f, 4.42966707e-02f,
  -4.05215062e-02f, -2.82414854e-02f, 1.73568234e-01f, 3.84244113e-03f, -2.53192764e-02f, -2.40751803e-02f, 3.10426988e-02f, 7.28020966e-02f, 7.08732679e-02f, 6.35197908e-02f,
  2.86843535e-02f, 2.50150934e-02f, 1.04068443e-01f, 3.07306405e-02f, -6.07628077e-02f, 5.05964011e-02f, 8.72174352e-02f, -5.98356081e-03f, -8.37192461e-02f, -9.95169431e-02f,
  -1.06040873e-02f, -1.32229075e-01f, 1.28694206e-01f, -6.37694448e-02f, 6.15624413e-02f, -1.75544638e-02f, -1.50102815e-02f, -3.09960102e-03f, 3.16218585e-02f, -8.76444578e-02f,
  -6.92612529e-02f, -3.83533612e-02f, 7.61796981e-02f, 7.47479722e-02f, 2.20313594e-02f, -5.43497130e-02f, -4.57088053e-02f, 1.31218182e-02f, 1.11116171e-02f, 4.22654413e-02f,
  -2.52994825e-04f, 6.51279762e-02f, 4.41939719e-02f, -8.95764679e-02f, 4.46954481e-02f, 6.41286653e-03f, 9.09995735e-02f, 3.69529165e-02f, 9.78578329e-02f, 7.18846992e-02f,
  9.72970799e-02f, 8.17067251e-02f, 9.34011340e-02f, 9.00980085e-03f, -3.04982793e-02f, 8.25326219e-02f, 6.47291914e-02f, 7.55036995e-02f, -7.43157640e-02f, -5.29876584e-03f,
  -3.36182257e-03f, 8.19821954e-02f, 2.58535761e-02f, 8.40386897e-02f, 7.19102994e-02f, -1.24026313e-02f, 2.05859472e-03f, -4.37344089e-02f, 4.57150824e-02f, -6.51025102e-02f,
  -7.24054798e-02f, -1.92521978e-02f, -1.88302826e-02f, 7.93642923e-02f, -2.58208159e-02f, -1.75639763e-02f, 7.92340785e-02f, -7.77119994e-02f, 6.36214316e-02f, 8.62542465e-02f,
  -2.89341249e-02f, -1.27775073e-02f, 6.60059676e-02f, 3.64133641e-02f, -3.47116068e-02f, -5.99416904e-04f, -1.80046652e-02f, -6.85680434e-02f, 8.84568468e-02f, 4.71872054e-02f,
  1.05670711e-03f, -1.07262358e-01f, 9.44952518e-02f, -2.73142867e-02f, 1.66038200e-02f, 3.33940350e-02f, 3.13113704e-02f, 5.32929376e-02f, 5.67008071e-02f, -8.95810872e-03f,
  9.50375348e-02f, 3.41096967e-02f, -1.45149846e-02f, -5.16657755e-02f, 5.61521463e-02f, 2.17749868e-02f, -9.69472714e-03f, -5.80633134e-02f, 6.48551434e-02f, 2.61313934e-02f,
  9.41218436e-02f, -4.89111058e-02f, 6.97372034e-02f, 1.05808407e-01f, -5.68677559e-02f, 4.89331186e-02f, -9.86360162e-02f, 9.71399844e-02f, 5.72126321e-02f, -4.09485698e-02f,
  -1.09943943e-02f, -1.02655869e-02f, -1.28493741e-01f, 2.92567462e-02f, -1.00578004e-02f, -8.23402703e-02f, 1.08433440e-02f, -1.83350705e-02f, 1.11292079e-01f, 1.03919521e-01f,
  -3.05705005e-04f, 9.42803100e-02f, 7.31048882e-02f, 5.57792634e-02f, -3.24674845e-02f, 1.61170304e-01f, -7.36125037e-02f, -7.20658153e-03f, 6.88015893e-02f, -1.06994510e-01f,
  -9.24044773e-02f, -1.17984992e-02f, -1.13408320e-01f, -4.18458432e-02f, -1.54576629e-01f, -5.76583249e-03f, -8.18580762e-02f, -3.89044099e-02f, -9.19477362e-03f, 3.98003533e-02f,
  8.63188803e-02f, 1.07010469e-01f, -7.10655823e-02f, 2.70092599e-02f, -1.89065263e-02f, 4.59536128e-02f, 2.75149029e-02f, -5.21054380e-02f, 5.87095693e-02f, 4.86953594e-02f,
  -5.02982624e-02f, -3.64886224e-02f, -1.56179797e-02f, 1.04003824e-01f, -6.80163428e-02f, -6.04914464e-02f, -1.01410143e-01f, -8.27256218e-02f, -1.51236616e-02f, -1.26578763e-01f,
  4.08245102e-02f, -1.11425273e-01f, -6.58803657e-02f, 2.09706519e-02f, -7.32428357e-02f, 7.88415298e-02f, -1.07178371e-02f, 1.89502549e-03f, -9.08526331e-02f, 4.17561876e-03f,
  -5.04273735e-02f, 8.34628493e-02f, 1.65313482e-02f, 7.64108002e-02f, -8.43421593e-02f, 5.48421964e-02f, -4.95759547e-02f, 6.16608709e-02f, 7.55358487e-02f, -8.00117478e-02f,
  -1.59304347e-02f, -7.84161240e-02f, 5.78213558e-02f, 6.95277154e-02f, 8.23695734e-02f, -5.77391833e-02f, 6.71279654e-02f, -3.95466350e-02f, 6.15422763e-02f, -1.70416497e-02f,
  2.69455975e-03f, 3.09368782e-02f, -4.14864458e-02f, -5.60122170e-02f, 2.85127573e-02f, 2.34972388e-02f, -3.58144864e-02f, -7.75562376e-02f, -7.47649595e-02f, -5.85961342e-03f,
  3.06409914e-02f, 1.44280400e-02f, 5.39186411e-02f, 9.76762269e-03f, -4.41330448e-02f, -5.34121227e-03f, 6.70863986e-02f, -6.50124475e-02f, -4.45840433e-02f, -4.06693034e-02f,
  -1.80030745e-02f, 7.63933659e-02f, -4.30159010e-02f, 1.07375439e-03f, -6.05935752e-02f, 2.77147219e-02f, -2.81715933e-02f, -7.90599287e-02f, -1.37237553e-02f, -9.16142538e-02f,
  -1.74746960e-02f, 1.04195319e-01f, -7.19576841e-03f, 3.26374127e-03f, -4.59589995e-02f, -2.47599278e-02f, -5.99456653e-02f, 6.22687414e-02f, -2.07754336e-02f, -6.04705438e-02f,
  -1.34606525e-01f, -1.47271022e-01f, 1.45019546e-01f, -6.92600161e-02f, 6.51961342e-02f, 2.35516384e-01f, 1.40495867e-01f, 6.42237663e-02f, -1.81767151e-01f, -1.23409241e-01f,
  3.17312479e-02f, -3.61917652e-02f, 5.93022145e-02f, -4.23470419e-03f, 9.31014568e-02f, 1.19988576e-01f, 1.62253436e-02f, -7.16634840e-02f, -5.85781969e-02f, -5.66775091e-02f,
  5.27109466e-02f, -4.20683473e-02f, 1.89703405e-01f, -1.41457627e-02f, -2.08860449e-02f, -1.03440143e-01f, -6.48069233e-02f, 6.64361045e-02f, 6.30237237e-02f, 1.05661526e-01f,
  7.21324310e-02f, -1.33504033e-01f, 4.38739881e-02f, -2.65281126e-02f, 9.77983549e-02f, 1.69509798e-02f, 7.84758478e-02f, -3.36894840e-02f, -5.22296838e-02f, -7.03630671e-02f,
  -1.11452304e-01f, -5.46127483e-02f, 1.74131207e-02f, -3.86804044e-02f, -3.48678529e-02f, -4.38883118e-02f, -4.83355969e-02f, 5.96920885e-02f, 8.41394285e-05f, 7.32870847e-02f,
  -5.12415543e-02f, 6.95546865e-02f, -2.65885051e-02f, 2.00626496e-02f, -3.10138538e-02f, -5.20274639e-02f, -3.95867340e-02f, -3.43573578e-02f, -4.81567392e-03f, 4.99381498e-02f,
  -5.32441474e-02f, -1.04309566e-01f, 9.77277011e-03f, -5.48626631e-02f, 5.74081093e-02f, -1.56522803e-02f, -7.60742202e-02f, 2.04286426e-02f, -6.65379986e-02f, 7.81002715e-02f,
  5.44126146e-02f, 1.43165169e-02f, 3.12210284e-02f, 3.36270444e-02f, 5.18913828e-02f, -8.82014632e-03f, -3.41804624e-02f, 9.75702715e-04f, -3.59605812e-02f, 3.60940285e-02f,
  -3.86421080e-03f, -5.26920408e-02f, 2.87485197e-02f, -5.26277795e-02f, -2.87238192e-02f, -7.12730065e-02f, 2.79814601e-02f, 5.56039438e-02f, -1.25446506e-02f, 9.95595977e-02f,
  -1.28806919e-01f, -7.09216073e-02f, 5.04436046e-02f, 2.19303388e-02f, -3.72505188e-02f, 5.79597503e-02f, 1.51273999e-02f, 3.55967991e-02f, 5.49347177e-02f, -5.07554859e-02f,
  -1.75810102e-02f, -5.99253513e-02f, 2.88732518e-02f, -6.33150935e-02f, -4.91221920e-02f, -3.11191063e-02f, 1.44321229e-02f, -1.00666411e-01f, -6.53644875e-02f, 4.15499285e-02f,
  8.06412473e-02f, -6.51482344e-02f, 6.28418997e-02f, 7.01210182e-03f, -7.26085156e-02f, -7.23942369e-02f, 5.60995191e-02f, -3.88785936e-02f, -3.07388157e-02f, 1.68381836e-02f,
  1.01568133e-01f, -2.62681842e-01f, -1.15573466e-01f, 1.51305079e-01f, 1.27215728e-01f, 1.44306179e-02f, -5.74254841e-02f, -1.94900464e-02f, -6.46527112e-02f, -1.83863118e-01f,
  -4.16704863e-02f, -1.92924943e-02f, -2.61017352e-01f, 8.69820341e-02f, 2.17010841e-01f, -1.64636686e-01f, 1.68676198e-01f, 8.42843950e-02f, 7.95040950e-02f, -5.55985942e-02f,
  1.11297742e-01f, 1.64701506e-01f, 6.66224360e-02f, 1.65072277e-01f, 1.51476920e-01f, -4.31885831e-02f, 1.05968505e-01f, -1.16416298e-01f, 2.28100315e-01f, 1.47019133e-01f,
  7.24025518e-02f, 6.14974685e-02f, 6.11603856e-02f, 7.07649952e-03f, -9.11602303e-02f, 2.60953363e-02f, 6.52763620e-02f, 9.09450576e-02f, 4.99958880e-02f, -1.66317895e-02f,
  4.52172458e-02f, 8.12802464e-02f, 6.94383159e-02f, 8.82928222e-02f, -4.89054620e-02f, 8.73701721e-02f, 6.32070675e-02f, -7.67617226e-02f, -2.91315019e-02f, -2.79454216e-02f,
  -5.43914922e-02f, 1.11458544e-02f, 2.47786939e-02f, -4.50788671e-03f, -4.24563102e-02f, 7.54376650e-02f, -8.23243037e-02f, -8.81633069e-03f, 5.31003922e-02f, 3.33516151e-02f,
  3.10589653e-02f, -7.27174655e-02f, -1.44195501e-02f, 4.94894758e-02f, -1.89492274e-02f, 3.38151604e-02f, 5.27490079e-02f, -8.34834799e-02f, -8.61411318e-02f, -6.16758242e-02f,
  -1.48846477e-03f, 7.15409890e-02f, 2.19002832e-02f, -4.33987416e-02f, -5.70804365e-02f, -4.14918130e-03f, -4.16162647e-02f, 7.16321468e-02f, -1.94600429e-02f, -1.47356987e-02f,
  4.66275588e-02f, -4.39971834e-02f, 1.94592476e-02f, -8.07732344e-02f, 7.78273046e-02f, -1.03706405e-01f, 4.64329906e-02f, -8.62786621e-02f, -7.78544992e-02f, 6.78759366e-02f,
  -1.03696287e-01f, -1.88850686e-01f, 3.36816646e-02f, 4.06892262e-02f, -3.42307650e-02f, 1.94157194e-02f, -1.29371425e-02f, 9.44910198e-02f, -1.01366349e-01f, -6.52307644e-02f,
  -6.95603564e-02f, 6.45136535e-02f, 4.16580029e-02f, -5.76937906e-02f, -3.36139090e-02f, -4.19528894e-02f, -3.99738699e-02f, 2.29867827e-02f, -5.96013628e-02f, -7.93205760e-03f,
  -4.15488072e-02f, -8.58935863e-02f, 8.24717432e-02f, 6.76162690e-02f, -4.10857610e-02f, -6.76878169e-02f, 2.62065772e-02f, -2.30632368e-02f, -3.52683887e-02f, -1.69026870e-02f,
  1.05948806e-01f, -1.21914506e-01f, -1.57829404e-01f, -1.13478959e-01f, -1.54315472e-01f, -2.37193108e-01f, -1.61826670e-01f, -1.76952168e-01f, 4.90947329e-02f, -1.00723796e-01f,
  -1.55622885e-01f, -3.85913849e-02f, 1.23835556e-01f, -1.59934729e-01f, 1.77451864e-01f, 1.76613033e-01f, -1.21163368e-01f, -6.59653619e-02f, -6.77776560e-02f, -1.32761866e-01f,
  -1.83454584e-02f, -1.80447280e-01f, -1.11794226e-01f, -1.75542280e-01f, -1.08662643e-01f, 5.76985860e-03f, 1.14284374e-01f, -1.32262588e-01f, -8.80370662e-02f, -5.34600094e-02f,
  2.38100905e-02f, -4.29042988e-03f, -8.63938183e-02f, -8.06725770e-02f, -5.85295167e-03f, -6.21244647e-02f, 3.36171389e-02f, 1.35576837e-02f, 1.04021151e-02f, -1.35520520e-02f,
  9.53208730e-02f, 3.47637595e-03f, -1.06302656e-01f, 4.35962304e-02f, 4.37023789e-02f, -5.27878702e-02f, -2.52905805e-02f, -5.15089087e-05f, 5.20068547e-03f, 6.94407746e-02f,
  -2.34812545e-03f, -5.14316224e-02f, 5.23837246e-02f, -4.37514670e-02f, -3.66188698e-02f, 4.63285707e-02f, -2.95084529e-02f, -3.23920846e-02f, -3.75826098e-02f, 4.38682772e-02f,
  9.67895538e-02f, -2.29187659e-03f, -2.74287742e-02f, -2.26052362e-03f, 3.51798907e-02f, 3.97353899e-03f, -9.30140540e-03f, 7.13288784e-02f, 8.48498717e-02f, 3.82802263e-02f,
  2.67988467e-03f, 5.26903905e-02f, 2.82893777e-02f, 7.17313886e-02f, -5.14081568e-02f, -6.63934425e-02f, -2.67245341e-02f, -7.17284605e-02f, -5.85393347e-02f, 3.10945958e-02f,
  -8.23894590e-02f, -8.19563307e-03f, -6.89346343e-02f, 4.89601344e-02f, -7.49505833e-02f, 4.73164134e-02f, 2.28756983e-02f, 7.08675906e-02f, 2.27444395e-02f, 1.16818761e-02f,
  -5.73906526e-02f, -6.88674450e-02f, 2.17661709e-02f, -1.10859945e-02f, 6.44238144e-02f, -2.61467453e-02f, -2.26360257e-03f, 5.24271429e-02f, -9.06689987e-02f, 7.42636025e-02f,
  -4.41858843e-02f, 6.06556498e-02f, 4.85987850e-02f, -4.26253751e-02f, 1.29492227e-02f, -9.29240733e-02f, 4.23309319e-02f, 4.39982601e-02f, 2.97135077e-02f, 5.54855131e-02f,
  3.38980034e-02f, -6.82412134e-03f, 7.58087412e-02f, 7.48991920e-03f, 1.61457937e-02f, 5.40841110e-02f, -2.33950485e-02f, -1.79636925e-02f, -5.33979349e-02f, 8.64630193e-02f,
  1.64724817e-03f, -9.07997638e-02f, 2.40184609e-02f, 7.56120160e-02f, -6.27368987e-02f, -6.56563938e-02f, -1.68066278e-01f, -2.07143482e-02f, 2.94129252e-02f, -3.22220847e-02f,
  7.30855316e-02f, -9.31779742e-02f, -4.45027240e-02f, 3.15908864e-02f, 1.85364723e-01f, -3.31695611e-03f, 1.74808931e-02f, -4.79492657e-02f, 6.36546984e-02f, 3.30601558e-02f,
  8.97228997e-03f, -1.04357049e-01f, 5.97654991e-02f, -1.08946815e-01f, -1.69012994e-01f, 6.46575615e-02f, 1.37535691e-01f, -3.43342824e-03f, -5.71229793e-02f, -8.71408060e-02f,
  5.15628867e-02f, -3.05517577e-02f, 5.23576662e-02f, 3.92401554e-02f, 7.43006216e-03f, -2.89150747e-03f, -2.65965350e-02f, 5.37194200e-02f, 1.10118113e-01f, -4.52795476e-02f,
  -3.08432057e-02f, -4.55863401e-02f, 3.43430787e-02f, -7.59864897e-02f, 4.81745340e-02f, 5.11604175e-02f, 6.58025816e-02f, -2.16345228e-02f, -4.54698987e-02f, -4.13679294e-02f,
  -3.36447544e-02f, 8.17587525e-02f, -3.86119932e-02f, 9.32016447e-02f, 1.14736073e-01f, 3.99674587e-02f, -3.46887708e-02f, 2.74672825e-02f, -5.51976264e-02f, -4.12410609e-02f,
  -8.46827626e-02f, -1.49878440e-02f, -7.12041855e-02f, -8.19832385e-02f, 3.57532352e-02f, 2.84777116e-02f, -2.09744014e-02f, -2.94248052e-02f, -1.33929458e-02f, -1.34604257e-02f,
  -3.00793853e-02f, 3.51820029e-02f, -5.96098155e-02f, -1.59009080e-02f, -3.52350324e-02f, -1.36302132e-02f, 7.45853409e-02f, 1.88280921e-02f, -1.48967383e-02f, -3.98767889e-02f,
  7.86963850e-02f, 7.66926557e-02f, 6.52497485e-02f, -3.71394902e-02f, -4.14450653e-02f, 7.11351484e-02f, -2.85053309e-02f, -7.95218274e-02f, -3.78553569e-03f, 4.38641198e-02f,
  1.37050049e-02f, 1.25671849e-01f, 4.17635851e-02f, -8.31151828e-02f, -6.98768571e-02f, -3.08731273e-02f, -7.29002282e-02f, 7.25678355e-02f, -4.49511148e-02f, -8.66648406e-02f,
  -8.34000111e-02f, -1.36817591e-02f, -5.40254898e-02f, 5.29984385e-02f, 9.74817500e-02f, -3.28323580e-02f, -5.00666648e-02f, -1.95481256e-03f, -5.95487580e-02f, -1.33804576e-02f,
  2.11040974e-02f, -5.97310700e-02f, -6.17234549e-03f, -6.25030696e-03f, 7.46923089e-02f, 3.40644382e-02f, 6.74179047e-02f, 6.70426413e-02f, -7.70290717e-02f, 5.21910526e-02f,
  -7.24225678e-03f, -7.28231519e-02f, -4.45023505e-03f, 1.12201110e-01f, 3.80422361e-02f, 1.37043551e-01f, 1.42012089e-01f, 1.11969352e-01f, 1.96308464e-01f, 5.30000180e-02f,
  -1.21211126e-01f, -8.85700211e-02f, -1.31943688e-01f, 6.39264286e-02f, -6.20499998e-02f, 3.21403099e-03f, 1.23838156e-01f, 1.19917365e-02f, 1.44781753e-01f, -3.67156900e-02f,
  1.79790687e-02f, -1.16088428e-01f, 6.60142163e-03f, -1.25370577e-01f, -6.21703379e-02f, -4.89305593e-02f, -1.32700354e-01f, 4.02686596e-02f, -1.68009073e-01f, 1.37730483e-02f,
  1.20490156e-01f, -2.42549106e-02f, -1.20428763e-01f, -9.05099437e-02f, 2.24726144e-02f, -9.73441154e-02f, 1.99674144e-02f, -3.70985642e-02f, 6.41976371e-02f, 3.35543267e-02f,
  -1.09973729e-01f, -5.96786179e-02f, 7.29552433e-02f, -4.41011749e-02f, 9.67155173e-02f, -4.32189379e-04f, 6.79594874e-02f, 1.55677972e-02f, -7.12545067e-02f, -9.92299095e-02f,
  5.25702462e-02f, -2.45083235e-02f, 6.71954080e-02f, 7.02164993e-02f, -5.28114736e-02f, 9.49168056e-02f, 2.68172901e-02f, 6.97783679e-02f, -1.27628380e-02f, 6.31705076e-02f,
  -2.56136861e-02f, 1.90738905e-02f, -4.70782816e-02f, -5.90951703e-02f, 3.74886282e-02f, 3.18742879e-02f, -6.24464005e-02f, -6.31559789e-02f, 1.05608888e-02f, 7.22633898e-02f,
  2.39292625e-02f, 8.24730173e-02f, 6.70901462e-02f, -3.38073890e-03f, -5.85192218e-02f, -7.34356865e-02f, 5.26592461e-03f, -5.12094833e-02f, 8.10313001e-02f, -4.42766510e-02f,
  6.62886130e-04f, -4.80204225e-02f, -8.91504511e-02f, -9.66925547e-03f, 5.28887808e-02f, -6.12244830e-02f, -2.53925123e-03f, -8.62345658e-03f, 8.13332275e-02f, 1.91843547e-02f,
  9.42390338e-02f, 6.53086603e-02f, -5.57440259e-02f, 1.97387626e-03f, 5.55802062e-02f, -7.02131018e-02f, 1.05125390e-01f, -2.06283350e-02f, 1.11476460e-03f, -2.33718995e-02f,
  -2.96985321e-02f, 1.22875683e-02f, -7.73523422e-03f, 2.23237574e-02f, 9.49610323e-02f, 6.11933693e-02f, 5.06410263e-02f, -2.60999799e-02f, 6.11006469e-02f, -7.87053257e-02f,
  2.57698423e-03f, 7.95021579e-02f, -3.48887779e-02f, 1.11493282e-01f, -1.64718088e-02f, -5.04460419e-03f, 5.58363833e-02f, -2.61644945e-02f, 2.07702089e-02f, 5.99500798e-02f,
  1.10834502e-01f, 2.67503858e-01f, 2.83872604e-01f, 1.94311351e-01f, -1.30751908e-01f, -1.52150214e-01f, 2.26330124e-02f, -7.50010833e-02f, 1.21616781e-01f, 8.17976668e-02f,
  -8.51135701e-02f, 2.64324725e-01f, -2.15675700e-02f, 9.94565263e-02f, -9.41926315e-02f, -1.29030645e-03f, 1.09725036e-01f, -7.81298801e-03f, -4.91451360e-02f, 1.96404874e-01f,
  1.18590489e-01f, -1.26658082e-01f, 1.35966003e-01f, -5.33016622e-02f, 8.34657717e-03f, 7.27348924e-02f, -4.14232947e-02f, 1.83768515e-02f, 8.62329304e-02f, 2.82998402e-02f,
  -8.11102334e-03f, -1.65246241e-02f, 9.72178131e-02f, 3.76227126e-02f, 2.45508142e-02f, 1.13299238e-02f, 9.79220793e-02f, 5.04831634e-02f, 8.61117989e-03f, 5.19490391e-02f,
  1.00235857e-01f, -6.47383928e-02f, 6.32824898e-02f, -5.53263165e-02f, 3.86047526e-03f, 4.28798869e-02f, 8.83074850e-02f, -9.41113196e-03f, 8.98920372e-02f, 7.29085058e-02f,
  7.21466616e-02f, 7.40217865e-02f, 6.01143613e-02f, 1.18936263e-01f, 5.84210567e-02f, -6.32700622e-02f, 7.76377022e-02f, 2.28238385e-02f, 3.15151289e-02f, 8.60209689e-02f,
  -1.33604305e-02f, 4.30579903e-03f, 2.34414767e-02f, -4.18079719e-02f, 3.33771892e-02f, 2.20594667e-02f, 3.53865102e-02f, -3.05414293e-02f, -5.96837141e-02f, -3.10248043e-02f,
  -3.87723818e-02f, -1.62414871e-02f, 4.68981341e-02f, 4.33223462e-03f, -6.37574680e-03f, -4.24972065e-02f, -7.53935650e-02f, -1.65766925e-02f, 1.47656668e-02f, -6.25657663e-02f,
  -1.60651971e-02f, -6.18958585e-02f, -1.73296537e-02f, -7.90592283e-02f, -9.10471845e-03f, 2.06524990e-02f, 5.19753899e-03f, 8.04640576e-02f, -1.38336727e-02f, 7.66629130e-02f,
  7.99471438e-02f, 2.16816619e-01f, 3.38359103e-02f, -3.22691798e-02f, 4.17027809e-02f, 4.08817157e-02f, -2.02695671e-02f, 7.49492273e-02f, -1.72402170e-02f, -4.15256508e-02f,
  1.08693112e-02f, -1.41055202e-02f, 1.28184762e-02f, -4.67329882e-02f, 5.27682081e-02f, 6.64668565e-04f, 7.37593789e-03f, 1.01324633e-01f, 3.52586620e-03f, 6.68080300e-02f,
  9.61431563e-02f, 3.87251889e-03f, -3.10814288e-02f, -1.22318370e-02f, 7.08272606e-02f, 9.29805078e-03f, 5.21940887e-02f, 5.11097983e-02f, 8.31557065e-02f, -2.23641917e-02f,
  -1.80487242e-02f, -1.62718389e-02f, 8.59419182e-02f, -8.99272412e-02f, 2.17776746e-03f, 1.67455971e-01f, -7.06373155e-03f, 1.32394254e-01f, 9.70110297e-02f, 6.11207858e-02f,
  3.24409418e-02f, 6.93924911e-03f, 7.15493485e-02f, -6.65758271e-03f, 3.43843438e-02f, -2.46842182e-03f, 2.83272583e-02f, -3.18514779e-02f, 1.00305296e-01f, 7.28700906e-02f,
  5.20002693e-02f, 3.93010397e-03f, -1.38003767e-01f, 2.58500557e-02f, -5.75304888e-02f, -5.42247817e-02f, -1.15936972e-01f, 4.76164557e-02f, -8.72667134e-02f, -6.26067817e-02f,
  -6.76997658e-03f, -8.93601589e-03f, 3.75076458e-02f, 6.12456873e-02f, -5.87663688e-02f, -6.69988915e-02f, 2.99440380e-02f, -5.72102964e-02f, 7.13882409e-03f, 7.15517104e-02f,
  5.73184155e-02f, -3.57915051e-02f, -4.39207852e-02f, -1.01103753e-01f, -7.57668465e-02f, 2.11260449e-02f, 3.48059051e-02f, -2.46517770e-02f, -1.70386806e-02f, -3.92580181e-02f,
  -7.02845156e-02f, -8.29702020e-02f, -4.72257435e-02f, 2.19572689e-02f, 5.67703098e-02f, -1.77882183e-02f, -6.96496218e-02f, -7.57082785e-03f, 6.49992228e-02f, -8.04698444e-04f,
  6.56038942e-03f, 6.95581213e-02f, -7.28535354e-02f, 5.11309169e-02f, -6.24245517e-02f, -8.13197866e-02f, 4.48721386e-02f, -1.60625447e-02f, 3.96021344e-02f, -6.93212077e-02f,
  2.88131963e-02f, 3.10733691e-02f, 2.71697883e-02f, -6.65345788e-02f, 2.49806102e-02f, -5.87678887e-02f, 5.31580783e-02f, -4.82085459e-02f, 6.07788973e-02f, -1.04210719e-01f,
  -9.16983485e-02f, -3.07487082e-02f, 4.71606925e-02f, 6.64104894e-03f, 1.88837480e-02f, -1.80961918e-02f, 7.68805761e-03f, 9.00982171e-02f, -7.67537132e-02f, -6.37545511e-02f,
  8.48209858e-03f, 4.89711165e-02f, -6.74540401e-02f, 9.46546793e-02f, 8.89888331e-02f, -5.64127266e-02f, -2.95714960e-02f, 1.26154535e-02f, -6.30941540e-02f, -2.27018446e-03f,
  2.94591580e-02f, 8.92563164e-02f, 5.43695204e-02f, 1.06329685e-02f, 1.84420645e-02f, 9.25634280e-02f, 8.81730020e-02f, -2.82155313e-02f, 2.56195832e-02f, -3.24511975e-02f,
  5.06803989e-02f, -3.99239250e-02f, -3.18775363e-02f, 2.27425043e-02f, 3.13184075e-02f, -6.21689558e-02f, 3.65361497e-02f, -5.74073708e-03f, 5.95600232e-02f, 6.23077676e-02f,
  1.96996033e-01f, -1.43192217e-01f, 6.87706843e-02f, 2.37359866e-01f, 2.55962402e-01f, 1.33153513e-01f, 8.38999748e-02f, 1.27030268e-01f, 2.25975245e-01f, -2.16323249e-02f,
  1.48192439e-02f, 2.47785524e-02f, -2.22953796e-01f, 1.00935563e-01f, -1.27194673e-01f, -1.24027587e-01f, 5.89888170e-02f, 2.77176918e-03f, 2.89002787e-02f, 1.98431928e-02f,
  1.10970333e-01f, 4.79663908e-02f, -1.03852823e-01f, -1.00581005e-01f, 8.61218348e-02f, -2.01488361e-02f, -1.48776636e-01f, -1.88248143e-01f, -1.54770147e-02f, -1.92403924e-02f,
  1.07275665e-01f, 1.12739556e-01f, -8.44960287e-03f, -5.48786148e-02f, 4.50598970e-02f, 1.99902300e-02f, -1.05638832e-01f, -6.27648830e-02f, -7.74802938e-02f, -2.41677593e-02f,
  -4.14603688e-02f, -6.58834819e-03f, 7.16926083e-02f, -5.11323772e-02f, -1.62360556e-02f, 5.44731319e-02f, 6.52724430e-02f, 1.18183851e-01f, -1.35715539e-02f, 3.86377349e-02f,
  -3.02980430e-02f, -3.84000950e-02f, 3.04863080e-02f, -8.03712830e-02f, 2.05981731e-02f, -6.33342639e-02f, -7.27597326e-02f, -3.55047062e-02f, 7.95976669e-02f, -3.66696306e-02f,
  -9.13083702e-02f, -4.39214408e-02f, 1.29246467e-03f, -6.81825578e-02f, 6.20267577e-02f, 6.91555366e-02f, 6.64087310e-02f, 6.33558631e-02f, -4.15283255e-02f, 3.74828391e-02f,
  -3.02061602e-03f, -5.21669239e-02f, 5.07905670e-02f, -1.79447457e-02f, -6.31172583e-02f, 1.06787132e-02f, -6.17790446e-02f, 5.73084131e-02f, 3.39961089e-02f, -4.47713071e-03f,
  -4.89030406e-02f, 1.11700660e-02f, -2.28264485e-03f, -5.37216105e-02f, -9.62254107e-02f, -8.65171105e-03f, 4.73468974e-02f, 9.91876796e-02f, -5.28762639e-02f, -1.22015120e-03f,
  -3.04947384e-02f, -1.34600937e-01f, 4.00573164e-02f, 6.34567514e-02f, -9.27263051e-02f, 1.43127561e-01f, 4.28337231e-03f, 3.52622531e-02f, 5.24271699e-03f, 4.03634124e-02f,
  4.77505289e-02f, 6.88755140e-02f, 2.66653728e-02f, 4.37510982e-02f, -6.88912794e-02f, 5.19001447e-02f, 1.06459828e-02f, 2.88872514e-02f, -4.98482883e-02f, -3.88211086e-02f,
  -4.74767527e-03f, 3.59243825e-02f, -3.21808532e-02f, -5.75548261e-02f, 7.85495862e-02f, 2.70701349e-02f, 9.16741788e-03f, 2.66512781e-02f, 5.67184575e-03f, -1.19954848e-03f,
  7.34044909e-02f, -1.74822107e-01f, 2.53135506e-02f, 4.23989967e-02f, 1.44555762e-01f, 1.16508201e-01f, 7.28137195e-02f, 1.77809298e-01f, 1.75035462e-01f, -1.51056722e-01f,
  -4.46072966e-02f, -5.49736023e-02f, -2.16143161e-01f, 1.06846094e-01f, -5.96998110e-02f, -9.85913873e-02f, 8.37534741e-02f, 2.23934976e-03f, 1.19189546e-01f, 7.78501034e-02f,
  8.76928940e-02f, -3.34999673e-02f, -1.01850264e-01f, -4.85899887e-04f, 7.68502876e-02f, 7.24328682e-02f, -1.54792786e-01f, -3.92570980e-02f, 5.33031560e-02f, -7.65554979e-02f,
  7.86916912e-02f, 1.32043287e-02f, 7.03240931e-02f, 9.08790752e-02f, 2.97401175e-02f, 5.05312495e-02f, -7.68271163e-02f, -1.73476040e-02f, -4.70419787e-02f, -3.20256762e-02f,
  -1.00347288e-01f, -5.82288802e-02f, 8.31407681e-02f, -5.48825264e-02f, -2.78876014e-02f, -1.54661341e-02f, 1.00721672e-01f, -1.43571803e-03f, 2.93587614e-02f, 1.02070920e-01f,
  7.53728151e-02f, -5.01078963e-02f, 4.20143642e-02f, 4.29143384e-02f, 9.73880962e-02f, -4.93399054e-02f, -7.47257099e-02f, 2.56611258e-02f, 3.60312387e-02f, -4.69084010e-02f,
  4.65781093e-02f, -5.54448403e-02f, 3.15822400e-02f, 9.67859477e-02f, -2.66773365e-02f, -4.68284637e-02f, -2.88745183e-02f, -6.60534063e-03f, 1.83961429e-02f, -1.38374809e-02f,
  -4.57591116e-02f, -4.05653305e-02f, 4.80672233e-02f, 5.92841506e-02f, 1.28543405e-02f, -6.37792945e-02f, -7.37921596e-02f, 3.45491916e-02f, 6.84463466e-03f, -4.89266850e-02f,
  -2.97447424e-02f, -4.89445776e-02f, -7.40651488e-02f, -3.00240441e-04f, -1.24247512e-03f, 2.75057610e-02f, 7.35027567e-02f, 2.84763295e-02f, 4.75442670e-02f, -1.82690248e-02f,
  -8.27759355e-02f, -1.52432144e-01f, 1.85854696e-02f, -3.17776129e-02f, -1.33769959e-02f, -6.86918944e-02f, 1.39364135e-02f, 7.01295584e-02f, -3.32393423e-02f, -5.57917058e-02f,
  4.07590121e-02f, 6.38403893e-02f, -1.19158201e-01f, 4.67317970e-03f, -1.04398772e-01f, 5.22417203e-03f, -2.08750516e-02f, -3.95486988e-02f, -1.02454260e-01f, 1.34726614e-03f,
  -2.92138997e-02f, 2.54442692e-02f, -4.25933376e-02f, -1.81706846e-02f, 7.30937719e-02f, -8.74740928e-02f, 5.20225726e-02f, -7.09054759e-03f, -1.07179247e-01f, -5.67166172e-02f,
  1.45536199e-01f, 5.97081706e-02f, -5.45702912e-02f, -4.92047556e-02f, 9.33615267e-02f, -2.14339476e-02f, -1.35857716e-01f, -4.21542004e-02f, -5.22531085e-02f, 1.12686463e-01f,
  -1.56407263e-02f, 8.69765878e-02f, -1.37921050e-01f, -1.12706527e-01f, -2.25628003e-01f, -2.44348004e-01f, -2.33739871e-03f, 9.52934287e-03f, -7.14009851e-02f, -2.42179483e-02f,
  -2.33094562e-02f, 8.05740201e-05f, -2.70836838e-02f, 9.87487882e-02f, 2.31859069e-02f, 1.07200213e-01f, 1.65032428e-02f, -7.25385845e-02f, 1.70709342e-01f, -1.15062870e-01f,
  -4.33733165e-02f, 3.83795165e-02f, -6.97044143e-03f, -3.94554697e-02f, -3.34463641e-02f, 1.54447138e-01f, 1.18378416e-01f, 3.95717584e-02f, -1.23370225e-02f, -5.57790920e-02f,
  7.28108212e-02f, -3.18545941e-03f, 1.15601597e-02f, -6.94772005e-02f, 3.60855125e-02f, -6.86853305e-02f, -7.01171160e-02f, -1.82538424e-02f, 4.22112495e-02f, -3.78115512e-02f,
  -4.94265184e-02f, 6.98498935e-02f, -2.10603923e-02f, 2.36290228e-02f, -3.70283844e-03f, -6.45644739e-02f, 5.57366423e-02f, 9.58970040e-02f, 9.29118171e-02f, -4.72392105e-02f,
  8.21032971e-02f, 8.01105723e-02f, -6.96842447e-02f, -1.04093097e-01f, 1.01418020e-02f, 5.04226014e-02f, 6.98548481e-02f, -5.27957594e-03f, -4.00222234e-05f, -1.58554763e-02f,
  5.02013892e-04f, -2.39134347e-03f, 5.24219964e-03f, 7.41424859e-02f, -7.17364550e-02f, 4.76931361e-03f, 3.01694330e-02f, -4.38746065e-02f, -3.53222042e-02f, -8.85569304e-02f,
  4.91098277e-02f, -3.26894037e-02f, 5.81771769e-02f, 2.86293998e-02f, -7.09399283e-02f, -1.03627771e-01f, -7.99116120e-03f, 6.35357127e-02f, -7.46930540e-02f, 5.37489243e-02f,
  4.60190400e-02f, -2.17937608e-03f, -9.85381678e-02f, 4.77238037e-02f, 4.24529724e-02f, 1.25731692e-01f, -2.58696899e-02f, -5.41776828e-02f, 1.04301032e-02f, -5.01641855e-02f,
  1.02087751e-01f, 6.51648492e-02f, 5.08494675e-02f, 3.08353715e-02f, 1.66094452e-02f, -2.83078663e-02f, 8.58040303e-02f, -1.48624287e-03f, 7.53581077e-02f, 8.09950978e-02f,
  -2.15320643e-02f, 1.04292594e-01f, 4.86893170e-02f, 8.61406326e-02f, -1.23081328e-02f, 9.16462541e-02f, 6.03474900e-02f, 8.02961960e-02f, -1.89555809e-02f, 7.60401636e-02f,
  -1.40163139e-01f, 2.51852989e-01f, 1.84126601e-01f, -9.54613164e-02f, 4.27787341e-02f, 1.17147706e-01f, 2.01892015e-02f, 1.70925930e-01f, -3.39814636e-04f, -5.01698740e-02f,
  -1.47862703e-01f, 9.81993079e-02f, -8.15455690e-02f, -4.76493575e-02f, 1.10348403e-01f, 1.81555152e-02f, -3.55920382e-02f, -1.44991204e-01f, 1.10515989e-01f, 6.16519824e-02f,
  -1.49653591e-02f, -9.11859572e-02f, 7.54047856e-02f, 4.87757921e-02f, -4.98995483e-02f, 6.12246878e-02f, -2.09399059e-01f, -6.59605935e-02f, -7.32724369e-02f, -1.16580334e-02f,
  8.32307637e-02f, -9.90116224e-02f, -1.22843221e-01f, -5.49387932e-02f, -1.05164751e-01f, 6.45260736e-02f, -8.26432854e-02f, -2.83520296e-02f, 2.92060394e-02f, -3.53413038e-02f,
  -1.33105367e-01f, -2.83245482e-02f, 3.88371088e-02f, -6.96744248e-02f, 7.44360611e-02f, -4.92798798e-02f, 5.20841102e-04f, 1.00633577e-01f, -9.68516711e-03f, 4.62741181e-02f,
  -2.99833026e-02f, 4.84997518e-02f, -1.45022692e-02f, 3.40829715e-02f, -6.51491657e-02f, 8.24018270e-02f, -9.83990263e-03f, -7.64806196e-02f, -5.28342510e-03f, 7.39639103e-02f,
  3.15118255e-03f, 3.82076018e-02f, 3.17245699e-03f, -8.24244544e-02f, -8.37904587e-02f, -7.28264377e-02f, -5.48514016e-02f, -6.71003945e-03f, 6.54504597e-02f, -2.08982490e-02f,
  -3.60798165e-02f, 3.72329876e-02f, 1.33995954e-02f, 6.76578935e-03f, 1.04330042e-02f, -2.68250448e-03f, 6.07721768e-02f, 3.39442007e-02f, -7.41202012e-02f, 2.80876309e-02f,
  -7.79088140e-02f, 2.63673272e-02f, -1.07175745e-02f, -4.29768674e-02f, 1.87554527e-02f, 8.29920173e-02f, 1.47874597e-02f, 8.63180757e-02f, -7.98165798e-02f, -2.93625910e-02f,
  3.03076152e-02f, -1.11708932e-01f, -7.99568649e-03f, -6.23117797e-02f, -2.66057439e-03f, 7.22132102e-02f, -6.82759583e-02f, -3.69046326e-03f, 2.45138761e-02f, 5.88197745e-02f,
  7.98487850e-03f, -1.72466952e-02f, 6.37964085e-02f, -6.80031627e-03f, 5.89054711e-02f, 4.41298261e-02f, 4.03525606e-02f, -2.41759047e-02f, -3.46951969e-02f, 2.24767961e-02f,
  1.43993180e-02f, -1.03363268e-01f, -6.02634475e-02f, -6.99298903e-02f, 4.42826711e-02f, -8.14543813e-02f, -2.09330022e-02f, 8.73239897e-03f, 2.32250690e-02f, 2.94590741e-02f,
  -5.30871376e-02f, 1.25749707e-01f, -8.90987366e-02f, -1.72612146e-01f, 1.35215238e-01f, 1.72427982e-01f, -2.30954960e-02f, 6.12736605e-02f, -1.19340032e-01f, -5.59525974e-02f,
  -4.30593677e-02f, -1.80624098e-01f, 7.75109679e-02f, -7.25827515e-02f, -7.85756856e-02f, -9.52917635e-02f, -3.92994704e-03f, -8.11180547e-02f, -5.51678389e-02f, 5.47592603e-02f,
  -4.00006622e-02f, 3.86106931e-02f, -1.74867641e-02f, 1.85367182e-01f, -2.73893699e-02f, 7.03359842e-02f, 1.86232161e-02f, 2.65561026e-02f, -3.77643369e-02f, 8.25935900e-02f,
  1.32983774e-01f, -7.11820601e-03f, 6.71955273e-02f, -3.54097299e-02f, 1.22544272e-02f, -7.32989609e-03f, 5.03456891e-02f, 5.64192608e-03f, 9.41080879e-03f, 7.95954913e-02f,
  -7.11980388e-02f, -1.35251516e-02f, -5.14159037e-04f, 4.91946749e-02f, 5.10409623e-02f, -2.81774160e-02f, -3.10590770e-02f, 1.16235865e-02f, -1.78693477e-02f, 6.44311458e-02f,
  2.44781934e-02f, -5.10581359e-02f, -5.17741814e-02f, -1.37714744e-01f, 3.99165936e-02f, -2.54981052e-02f, 3.59404869e-02f, -1.36393625e-02f, -1.03590399e-01f, 2.41921004e-02f,
  2.82960497e-02f, 9.64839980e-02f, 1.96756236e-02f, 5.86225651e-02f, -3.16114686e-02f, -4.57614623e-02f, 1.47961471e-02f, -3.16559672e-02f, -5.49625941e-02f, -5.77094816e-02f,
  6.27363846e-02f, 5.65184914e-02f, 5.05840369e-02f, 6.61198571e-02f, 6.55951351e-02f, 2.81086005e-02f, -1.06783314e-02f, -8.66376385e-02f, 7.65017271e-02f, -3.94999683e-02f,
  -7.10788146e-02f, 2.56248228e-02f, 6.91616610e-02f, -8.34006295e-02f, 8.28486681e-03f, -7.31347222e-03f, -3.63740325e-02f, -2.21778918e-02f, 8.62412378e-02f, 5.38129434e-02f,
  4.22324724e-02f, -4.79215160e-02f, -6.45311782e-03f, -1.11919574e-01f, 1.08493075e-01f, 1.01343043e-01f, -4.32772981e-03f, -2.11936086e-02f, -4.09367792e-02f, 5.67118004e-02f,
  7.70644993e-02f, 8.02485496e-02f, 4.44667740e-03f, 1.89563502e-02f, -1.27799099e-03f, -3.05988069e-04f, 4.43918025e-03f, 2.60988884e-02f, -1.82334706e-02f, -3.53330523e-02f,
  8.48810561e-03f, 5.38903363e-02f, -3.50982063e-02f, -8.46341625e-02f, -2.76467707e-02f, 3.22577208e-02f, -8.02213624e-02f, -1.90121103e-02f, -3.96383218e-02f, 1.12725585e-03f,
  1.58190653e-01f, -4.13104072e-02f, -1.41579837e-01f, -1.66030779e-01f, 4.63450328e-02f, -2.64066905e-02f, -8.33577141e-02f, -1.34074558e-02f, -1.15753584e-01f, 9.18132141e-02f,
  -4.76646535e-02f, 6.21212758e-02f, 2.97255497e-02f, -7.47262686e-02f, -9.51497033e-02f, -1.57575065e-03f, 6.15272298e-02f, -5.70970476e-02f, -8.55166018e-02f, 5.90608381e-02f,
  2.10257061e-02f, -1.41855050e-03f, 3.34938131e-02f, -1.77806113e-02f, -7.84340575e-02f, -7.15562999e-02f, 9.68167633e-02f, -8.97803083e-02f, -5.00794575e-02f, 1.10161342e-02f,
  9.28639919e-02f, -3.72039713e-02f, -3.62909772e-02f, -5.00613637e-02f, -3.06006894e-02f, 1.24532348e-02f, -5.56877479e-02f, 4.49843071e-02f, 3.99803892e-02f, 2.00583767e-02f,
  -8.51890724e-03f, -7.31910067e-03f, -4.91317213e-02f, -3.46024968e-02f, -3.57093699e-02f, -1.41891018e-02f, -9.29045118e-03f, -3.54829878e-02f, -2.73130536e-02f, 7.23188147e-02f,
  -8.98185149e-02f, -1.06112482e-02f, -4.59497645e-02f, -2.22812984e-02f, -6.00137115e-02f, -1.16372211e-02f, 8.49375501e-02f, 4.82811444e-02f, 1.68687161e-02f, -4.51973565e-02f,
  9.48648080e-02f, -2.14098860e-03f, -1.00711603e-02f, 4.83799092e-02f, 1.31730214e-02f, -3.22149089e-03f, -1.00939974e-01f, 1.34021118e-02f, -7.53288195e-02f, -4.49120663e-02f,
  1.40517801e-02f, -9.39084440e-02f, -6.39708564e-02f, 1.58934556e-02f, 8.96497965e-02f, 3.66624002e-03f, -2.70167831e-02f, 4.65396466e-03f, 6.46877587e-02f, -3.81771885e-02f,
  2.42686253e-02f, 2.70473771e-02f, 4.74877805e-02f, 6.46025985e-02f, -9.35349911e-02f, 5.88090830e-02f, 4.39900532e-02f, -5.62892370e-02f, 2.78313253e-02f, -4.01691683e-02f,
  3.72514427e-02f, 5.79612516e-02f, -8.33081603e-02f, 5.12214843e-03f, 7.09467456e-02f, 1.56386325e-03f, 3.25055830e-02f, -5.22707924e-02f, -6.15009144e-02f, 7.84186944e-02f,
  9.07879174e-02f, -1.11337252e-01f, -1.42063498e-02f, 6.07764535e-02f, -1.00015968e-01f, -4.56066132e-02f, -4.09795120e-02f, 3.93335149e-02f, -1.13907866e-01f, -8.92812833e-02f,
  -5.04848585e-02f, -5.09146564e-02f, -2.03565080e-02f, -2.75122076e-02f, -8.93107429e-03f, 9.22293589e-03f, -5.56154475e-02f, -9.44991782e-03f, -1.56424660e-02f, -7.24510625e-02f,
  1.26630887e-01f, -6.06610067e-02f, 6.85727894e-02f, 2.30534032e-01f, 1.40332609e-01f, -1.69853151e-01f, 8.87609497e-02f, 4.78771962e-02f, 3.50796103e-01f, -1.36984110e-01f,
  7.79702067e-02f, -6.37269691e-02f, 2.24079601e-02f, -3.26294601e-02f, -1.18738905e-01f, -2.43084673e-02f, -1.24429688e-01f, -6.81032091e-02f, 3.83584797e-02f, 1.01257779e-01f,
  2.21875776e-02f, -3.34508866e-02f, -1.20368063e-01f, -5.15648760e-02f, 1.86530361e-03f, -7.27108121e-02f, -1.50397554e-01f, 4.29062545e-02f, -1.57065362e-01f, -9.48593840e-02f,
  6.33761808e-02f, -6.15544803e-02f, 5.00786155e-02f, -1.50050856e-02f, 5.18365763e-03f, -7.78234378e-02f, 2.65971897e-03f, 3.77800353e-02f, 7.04895929e-02f, 3.85354832e-02f,
  -3.67017370e-03f, -6.15891032e-02f, -1.96929071e-02f, 7.41622318e-03f, 9.92568582e-02f, -4.52688336e-02f, 2.74849348e-02f, -3.98322567e-02f, -5.37010096e-02f, 2.87646372e-02f,
  8.59730691e-03f, 3.11393999e-02f, -5.27366437e-02f, -1.00944743e-01f, -5.41681647e-02f, 3.81414108e-02f, -1.54909929e-02f, -1.38577268e-01f, -9.02126655e-02f, -5.44972494e-02f,
  -8.97464678e-02f, 5.91265559e-02f, -2.43357308e-02f, -2.42751208e-03f, 2.23209267e-03f, 3.10321455e-03f, -4.95994687e-02f, 4.28360291e-02f, 4.43569124e-02f, -2.73639169e-02f,
  -2.30743941e-02f, 7.85683542e-02f, -3.81033607e-02f, 6.12628981e-02f, 2.50851810e-02f, -2.74758060e-02f, -2.94582103e-03f, -1.60811134e-02f, 6.08527614e-03f, -6.62931800e-02f,
  -1.23700248e-02f, -2.30335630e-03f, 8.50572716e-03f, -5.60692437e-02f, 4.47279289e-02f, -2.00749747e-02f, 2.51793060e-02f, 1.07116364e-02f, 5.74361794e-02f, 6.03314210e-03f,
  -1.35378659e-01f, -1.84245586e-01f, 1.08721182e-02f, -7.93259218e-02f, 2.95855198e-02f, -1.20969377e-01f, -7.46358710e-04f, -2.40386669e-02f, -2.85269488e-02f, -8.32814872e-02f,
  4.08923291e-02f, -1.96774341e-02f, -4.30912385e-03f, 7.55364671e-02f, -4.82476167e-02f, -7.11209476e-02f, 4.65436466e-02f, -6.35113716e-02f, -8.43108818e-02f, -8.75020325e-02f,
  -3.43610160e-02f, 1.21804606e-03f, -3.48622799e-02f, 2.26199012e-02f, 1.21439015e-02f, -3.88828199e-03f, 3.36992703e-02f, 1.65893734e-02f, -6.65339306e-02f, 5.16772345e-02f,
  -1.94298804e-01f, 4.46692824e-01f, 1.15877070e-01f, 1.97357927e-02f, -2.86780223e-02f, -1.37829185e-01f, -4.76280116e-02f, 3.51816081e-02f, 1.66059688e-01f, 2.43881434e-01f,
  1.74114313e-02f, 2.93721527e-01f, 4.60173674e-02f, 1.32163242e-01f, -3.78579229e-01f, -2.92269457e-02f, -6.52506351e-02f, 1.05130440e-02f, 2.80248579e-02f, 6.52870461e-02f,
  -7.60756060e-02f, 7.77407596e-03f, -6.20159432e-02f, 5.82046388e-03f, 5.59464470e-02f, -5.01829088e-02f, -2.07118288e-01f, -1.64719298e-04f, 5.33843376e-02f, -1.28822913e-02f,
  -1.25226185e-01f, -1.37837678e-02f, 1.08417287e-01f, -3.00744809e-02f, 4.26898128e-04f, -3.58714908e-02f, -4.37339135e-02f, -6.79766312e-02f, -2.39957254e-02f, 3.07236332e-02f,
  2.95257047e-02f, 1.65533088e-02f, 5.33991642e-02f, -4.69429269e-02f, 1.27956746e-02f, 8.35742652e-02f, -2.15627179e-02f, -2.60100327e-02f, 1.40252039e-01f, -6.68005869e-02f,
  1.79617852e-01f, 5.06864451e-02f, 1.50435427e-02f, -4.38871980e-02f, -3.48772928e-02f, 6.72453716e-02f, -6.83327466e-02f, -9.33317468e-02f, 2.14327406e-02f, -5.90998270e-02f,
  7.00971410e-02f, -7.83682242e-02f, 1.38205914e-02f, 5.78755550e-02f, -1.08565185e-02f, -4.46434170e-02f, 3.20316255e-02f, 5.76467160e-03f, -2.92853378e-02f, 1.97185501e-02f,
  5.77630177e-02f, 1.78421680e-02f, 6.26276508e-02f, -7.01595470e-02f, 1.79023072e-02f, 1.27512570e-02f, 8.80891383e-02f, 2.58757863e-02f, 3.33751142e-02f, -6.60049841e-02f,
  8.24622288e-02f, 1.63540356e-02f, 5.08217663e-02f, 1.03856027e-02f, 5.27235214e-03f, -6.71586096e-02f, 1.80290416e-02f, -3.61391082e-02f, -5.93506172e-02f, 1.35841025e-02f,
  -1.71672970e-01f, -2.04936415e-01f, -2.81802588e-03f, -1.62350852e-02f, -4.72785197e-02f, -9.72210839e-02f, -1.99449304e-02f, -4.81581949e-02f, -1.24088474e-01f, 3.71971652e-02f,
  -3.05823795e-02f, 2.66532023e-02f, -1.33841783e-01f, 8.45327452e-02f, 1.96701419e-02f, 2.48287898e-02f, -2.39730552e-02f, 2.68658958e-02f, 2.13726482e-04f, 3.67109227e-04f,
  2.26342541e-04f, 2.33262666e-02f, -4.63022888e-02f, -7.69881606e-02f, 2.36605816e-02f, 4.35297145e-03f, -5.76486206e-03f, -2.85130981e-02f, -7.26514086e-02f, 9.12973806e-02f,
  -1.59969121e-01f, 1.20896302e-01f, -1.45734146e-01f, -4.40714508e-03f, -1.12976834e-01f, -1.77939348e-02f, -1.83518336e-03f, -5.05422428e-02f, -2.34624818e-02f, 2.18511790e-01f,
  1.85349464e-01f, -2.13159934e-01f, 1.66944429e-01f, 2.05773100e-01f, -1.02307983e-01f, 8.64945725e-02f, 1.69797212e-01f, 1.76593408e-01f, -7.47008845e-02f, -5.86297140e-02f,
  2.64577195e-02f, 5.78445848e-03f, 1.19497731e-01f, -4.25369292e-02f, -1.25608787e-01f, -7.58797973e-02f, -2.41080355e-02f, 1.05171306e-02f, 8.79722238e-02f, -4.00192142e-02f,
  -4.27439138e-02f, -4.05336767e-02f, -6.85451319e-03f, -1.49727523e-01f, -4.44320589e-03f, -7.88990855e-02f, -4.64891084e-02f, -7.80388787e-02f, 4.61828820e-02f, 4.70564626e-02f,
  -2.94291545e-02f, -7.19376504e-02f, -5.90606146e-02f, -1.42605826e-02f, -7.31658712e-02f, -7.30717778e-02f, -1.04344636e-01f, 5.81306480e-02f, 4.11179848e-02f, -1.76321398e-02f,
  7.24714473e-02f, -3.30438502e-02f, 6.04070444e-03f, 1.12908959e-01f, -2.37272214e-02f, -1.11316964e-02f, 1.15633234e-02f, 6.77283062e-03f, 2.69639753e-02f, 4.08142731e-02f,
  -6.09416664e-02f, 5.09897955e-02f, 2.14251708e-02f, 7.60113597e-02f, -5.49577782e-03f, 1.16238473e-02f, 6.13835827e-02f, -7.65105560e-02f, -7.24792629e-02f, -2.90560778e-02f,
  -7.69594610e-02f, 1.40639152e-02f, -3.23406756e-02f, -4.56869081e-02f, 8.63188207e-02f, -6.57950640e-02f, 6.88805431e-02f, -5.59448730e-03f, 7.77692646e-02f, 4.62967828e-02f,
  2.51547135e-02f, -1.17488876e-01f, 7.96812400e-02f, -2.88517550e-02f, 5.50305471e-02f, 6.88658282e-02f, -2.65102386e-02f, -3.74667831e-02f, 6.34859949e-02f, 6.50146157e-02f,
  -4.11095396e-02f, -1.78744137e-01f, 1.80583522e-02f, 1.58792268e-02f, -4.75251004e-02f, 5.07406890e-02f, -5.16872155e-03f, 1.13613261e-02f, -7.08074868e-02f, -5.60342893e-03f,
  -4.41201515e-02f, 1.70967858e-02f, 5.10027036e-02f, -2.37994511e-02f, 2.52095740e-02f, -4.24126396e-03f, -4.90545742e-02f, -6.98578451e-03f, -3.34590524e-02f, -8.17294270e-02f,
  -9.63429883e-02f, -3.70079540e-02f, -6.40094467e-03f, 4.25824709e-02f, 1.58811677e-02f, 5.71021549e-02f, -8.72436166e-02f, 5.91761544e-02f, -8.39041993e-02f, 5.08081764e-02f,
  -1.00097544e-01f, -2.50401884e-01f, 6.37428313e-02f, 9.87705737e-02f, 2.92850826e-02f, 1.04263425e-01f, 2.66937643e-01f, -1.53492287e-01f, -1.73798591e-01f, -7.62496293e-02f,
  4.48673368e-02f, -2.27128044e-02f, 9.11707208e-02f, 1.32214859e-01f, 7.26300105e-02f, 1.14475891e-01f, -7.30675533e-02f, -2.32170820e-02f, -4.36743088e-02f, -1.00380637e-01f,
  -2.76222508e-02f, 1.51194017e-02f, 1.09054156e-01f, -1.06651001e-01f, 1.45442961e-02f, -1.24791246e-02f, -4.81649376e-02f, 1.60185814e-01f, -1.12266071e-01f, 7.55872652e-02f,
  2.34349929e-02f, -3.87677946e-03f, 4.56526354e-02f, -1.08294569e-01f, -2.40468476e-02f, 3.38053480e-02f, -3.34903561e-02f, 3.40046734e-02f, 3.14242393e-02f, 2.73530819e-02f,
  7.48270899e-02f, -5.30692823e-02f, -7.61064962e-02f, -2.70627122e-02f, -8.10552482e-03f, -9.06457826e-02f, 5.95662743e-02f, -1.93350073e-02f, 2.08678320e-02f, -7.61923790e-02f,
  -1.59523450e-02f, -8.85572657e-02f, 3.10260076e-02f, 4.53172298e-03f, -1.02620786e-02f, -9.39650983e-02f, -1.25073073e-02f, 5.30819073e-02f, -3.36679220e-02f, -3.03434245e-02f,
  4.40245569e-02f, 3.99796143e-02f, -5.37137240e-02f, 4.24446678e-03f, -6.87935203e-02f, -3.11558992e-02f, 5.92394099e-02f, -2.91830264e-02f, -3.64944804e-03f, -1.28645226e-02f,
  4.04616445e-02f, 6.40565008e-02f, 3.27872299e-02f, -6.46002814e-02f, 5.19940928e-02f, 7.60097355e-02f, -2.79542021e-02f, -2.39919927e-02f, 1.25550404e-02f, -6.26637507e-03f,
  -3.28854397e-02f, 4.41694930e-02f, 4.62913886e-02f, 8.45920015e-03f, -8.79871771e-02f, -4.40513901e-02f, -7.84242339e-03f, -9.40572545e-02f, -4.10070606e-02f, -3.06321364e-02f,
  -2.25944012e-01f, -2.63615102e-01f, -1.47252753e-02f, -9.75925103e-02f, -5.01057953e-02f, -3.65563408e-02f, 4.72421572e-02f, 4.10737703e-03f, 2.24979017e-02f, -3.63485441e-02f,
  -4.58787195e-02f, 4.20496017e-02f, -8.31648260e-02f, 5.50320074e-02f, 7.31233656e-02f, 1.95863303e-02f, -3.76055539e-02f, -4.70107980e-03f, 2.79843900e-02f, -1.18782789e-01f,
  -8.62920806e-02f, -1.82666467e-03f, 7.59457275e-02f, 5.24553098e-03f, 3.01398691e-02f, 4.08740453e-02f, -6.46224022e-02f, -5.73798502e-03f, -3.22968587e-02f, -4.76727597e-02f,
  -2.45817215e-03f, 5.04727103e-02f, -1.31370440e-01f, -1.60868093e-02f, -3.32525447e-02f, 3.03101148e-02f, 8.66059884e-02f, -4.05313559e-02f, -1.03259027e-01f, 1.51565105e-01f,
  1.73263788e-01f, -1.11963844e-03f, -5.94324572e-03f, 1.11185998e-01f, 1.33275196e-01f, 1.45388782e-01f, 1.14575014e-01f, 1.09812930e-01f, 1.70246568e-02f, 1.52639151e-01f,
  3.10671404e-02f, 2.53768384e-01f, -2.02981792e-02f, 2.16035843e-02f, 2.33265273e-02f, 3.56035889e-03f, 3.24435122e-02f, -1.33239180e-01f, 1.39188960e-01f, -2.88512874e-02f,
  7.88680837e-02f, 1.08948909e-01f, -9.19847339e-02f, 7.46433297e-03f, 8.84824097e-02f, 1.07826225e-01f, -2.29085945e-02f, -5.01505472e-02f, -8.11589435e-02f, -2.22355090e-02f,
  -1.41873062e-02f, -6.07624091e-02f, 6.58336803e-02f, -9.26563069e-02f, -5.09571582e-02f, -6.65068477e-02f, 1.77413244e-02f, -7.66372532e-02f, -5.10404781e-02f, 2.18932349e-02f,
  1.10423407e-02f, 7.52035379e-02f, 3.01371422e-02f, 1.04641235e-02f, 6.66086189e-03f, 4.89635877e-02f, -3.21638957e-02f, -2.31157783e-02f, 4.88609038e-02f, -5.01940725e-03f,
  1.08109720e-01f, -2.15826114e-03f, 8.65151137e-02f, -3.74229327e-02f, 2.17829347e-02f, 2.48991046e-02f, 4.37144116e-02f, 6.09913096e-02f, 3.35777812e-02f, 8.10886919e-03f,
  5.41829318e-02f, 3.73309180e-02f, 5.45727946e-02f, 7.27025792e-02f, 8.34505558e-02f, -6.61095753e-02f, -1.43721579e-02f, 6.13420159e-02f, 2.40289699e-02f, -1.64295752e-02f,
  -2.82647014e-02f, 8.19914117e-02f, 4.68342658e-03f, 8.45172442e-03f, 6.39215559e-02f, -3.70554830e-04f, 2.78657340e-02f, 1.82642823e-03f, -3.12923454e-02f, -6.86206343e-03f,
  1.37946680e-01f, 1.59369573e-01f, 1.58281680e-02f, -4.26915064e-02f, 6.11351505e-02f, 1.38067314e-02f, -2.23551467e-02f, 5.94487824e-02f, 1.06924750e-01f, 9.01305303e-02f,
  -1.44661358e-02f, -1.10854149e-01f, -1.40897986e-02f, 2.00509820e-02f, 1.85898803e-02f, 5.88123268e-03f, 8.34617540e-02f, -6.43390194e-02f, -6.30754903e-02f, 3.96527797e-02f,
  -4.14518751e-02f, 5.46934046e-02f, 2.96686552e-02f, -4.36030179e-02f, -7.03389272e-02f, -2.25923397e-02f, -5.49772903e-02f, -7.87511691e-02f, 9.91066396e-02f, -2.97833141e-02f,
  1.03481315e-01f, -2.93110050e-02f, -4.11478541e-04f, -1.83486976e-02f, 7.26073384e-02f, 1.65378898e-01f, 1.24967493e-01f, -1.98764354e-02f, -1.38379380e-01f, 1.35087240e-02f,
  3.23140323e-02f, 1.11852929e-01f, 1.34602919e-01f, -1.93299390e-02f, 1.60359234e-01f, 5.12237623e-02f, 2.84494745e-04f, 1.07625432e-01f, -7.60242492e-02f, -2.38370430e-05f,
  2.88289296e-03f, 8.85640755e-02f, 2.43489482e-02f, -4.17665025e-04f, 6.51864484e-02f, -6.40967414e-02f, 8.93689040e-03f, -2.90646385e-02f, -8.85173213e-03f, -3.26250307e-02f,
  7.46977143e-03f, 7.16997907e-02f, 3.06499600e-02f, -1.20979562e-01f, -8.37575644e-02f, -1.02845430e-02f, 8.38736743e-02f, 2.02423278e-02f, -2.81527592e-03f, 8.20478201e-02f,
  -1.24812657e-02f, 5.97848929e-02f, -1.23065040e-02f, -4.34005540e-03f, -7.34983608e-02f, 1.89529192e-02f, -3.85582596e-02f, -8.87631439e-03f, 5.35393320e-02f, 3.12134661e-02f,
  9.68616921e-03f, -6.36945292e-02f, -2.04802305e-02f, -1.89941227e-02f, -1.23709567e-01f, -1.04132205e-01f, -8.31183046e-02f, -3.74094471e-02f, -4.89362478e-02f, 7.56063536e-02f,
  2.66251303e-02f, 2.18583569e-02f, 8.68964717e-02f, 9.26524517e-04f, -3.94157209e-02f, 4.43327501e-02f, 5.75020835e-02f, -5.83968908e-02f, -5.39725237e-02f, 7.92931020e-02f,
  -1.47248683e-02f, 2.01080367e-02f, 2.96954531e-02f, 8.61481652e-02f, -5.85197918e-02f, -1.78645793e-02f, 7.48849437e-02f, -6.84265420e-02f, 5.66179380e-02f, -9.64878127e-02f,
  -7.03725815e-02f, 3.10150869e-02f, 4.30262871e-02f, -6.79788813e-02f, 2.15729717e-02f, 4.32734117e-02f, 6.42400607e-02f, -5.37872612e-02f, -3.30571830e-02f, -4.12021168e-02f,
  8.31447989e-02f, 4.55512144e-02f, 1.17063904e-02f, 5.24255000e-02f, -5.37209623e-02f, 6.96903765e-02f, -7.27360230e-03f, -6.73813671e-02f, 3.22075635e-02f, 5.61020523e-03f,
  -8.21255296e-02f, -2.00126343e-03f, 3.72549929e-02f, -8.90186429e-02f, -1.81039926e-02f, 2.12268289e-02f, -6.35849312e-02f, 3.47571597e-02f, -6.79759234e-02f, 4.11831262e-03f,
  -8.72235596e-02f, 5.45999371e-02f, 3.60645577e-02f, 2.91573443e-02f, -4.15249877e-02f, -1.22775394e-03f, 2.47977674e-02f, -4.78368402e-02f, -2.17502490e-02f, -6.91134948e-03f,
  9.56684500e-02f, -1.00514954e-02f, -6.24983348e-02f, -2.89108995e-02f, -1.39267355e-01f, -2.05104370e-02f, -7.39083588e-02f, 2.32399092e-03f, 5.53483553e-02f, 5.79310581e-02f,
  1.09147295e-01f, 8.94910246e-02f, 1.14657365e-01f, -3.73973474e-02f, -6.39158264e-02f, -2.88763754e-02f, -1.14301711e-01f, 3.40686669e-03f, -4.75847954e-03f, -8.47915858e-02f,
  3.55556868e-02f, -1.84968077e-02f, 7.84367397e-02f, -2.12422591e-02f, 7.73667358e-04f, 8.52030069e-02f, 6.61100373e-02f, 6.25271932e-04f, -8.35956037e-02f, 5.90757579e-02f,
  1.58429760e-02f, -5.78031875e-03f, 3.93831097e-02f, -9.45466571e-03f, 3.26835364e-02f, 1.14192152e-02f, -1.17479945e-02f, 3.16843241e-02f, 6.43246397e-02f, -7.93452337e-02f,
  -7.61442855e-02f, -5.23755187e-03f, -1.38376616e-02f, 7.26360008e-02f, -1.23710316e-02f, -7.85099417e-02f, 6.75179362e-02f, 7.85406679e-02f, -4.48105782e-02f, 1.22579252e-02f,
  5.63393645e-02f, 1.05799837e-02f, -7.03112334e-02f, -7.22881556e-02f, 2.92954668e-02f, -2.09622514e-02f, 5.12034297e-02f, -5.62081449e-02f, 8.13442394e-02f, -4.31776308e-02f,
  8.17843527e-02f, 5.88005595e-02f, 3.57647426e-02f, -3.05665806e-02f, 7.69479387e-03f, 1.19992672e-02f, 1.22954296e-02f, -4.81034517e-02f, -4.12825607e-02f, 7.37421513e-02f,
  -3.94679792e-02f, 2.72215456e-02f, -6.46121800e-02f, 3.53393552e-04f, -7.30878767e-03f, -4.93062213e-02f, 5.16901016e-02f, -8.22634771e-02f, -1.65356766e-03f, -6.72052056e-02f,
  6.68724850e-02f, -8.99933353e-02f, -5.76547859e-03f, 9.61720720e-02f, -2.43959632e-02f, -2.92884205e-02f, 6.45334795e-02f, 2.33604051e-02f, -3.69027629e-02f, 2.34027188e-02f,
  -8.18954594e-03f, 6.88913539e-02f, 6.96699694e-02f, -8.01705942e-02f, 1.19872317e-02f, 5.96877001e-02f, -2.07960662e-02f, 2.82875355e-02f, 5.39742149e-02f, 6.36363700e-02f,
  -8.60287473e-02f, 4.15925533e-02f, 2.08523758e-02f, 6.40019104e-02f, 4.00058962e-02f, 2.59222817e-02f, 4.27210936e-03f, 2.84006577e-02f, -8.99411961e-02f, -4.23078862e-04f,
  -6.03407156e-03f, -1.68008711e-02f, 4.13848925e-03f, 4.35392894e-02f, -9.60282609e-02f, 8.24256614e-02f, -5.10546342e-02f, 1.52819627e-03f, 1.05312735e-01f, 7.64013305e-02f,
  -3.96838747e-02f, -6.10318184e-02f, -5.00785410e-02f, -2.75480840e-02f, 3.69733199e-03f, 3.81472446e-02f, 4.86675203e-02f, -2.69226469e-02f, 4.86511327e-02f, 5.21256849e-02f,
  -8.93151667e-03f, 1.80501696e-02f, -2.77675204e-02f, -9.34592565e-04f, 8.43892992e-02f, -3.34244641e-03f, 7.70117193e-02f, -6.34454265e-02f, -1.10406235e-01f, -1.64702889e-02f,
  -7.22473338e-02f, -9.34065282e-02f, -5.38815148e-02f, 2.48441584e-02f, -9.50353742e-02f, 5.27879409e-02f, -7.11041838e-02f, -6.19538799e-02f, 1.50461318e-02f, -1.21663436e-01f,
  1.63065102e-02f, -1.04692452e-01f, -7.39963055e-02f, 4.48692739e-02f, -3.39747965e-02f, -4.30140831e-02f, 2.76908427e-02f, -1.70209110e-02f, -4.58722003e-02f, -4.74682041e-02f,
  1.23310737e-01f, -6.86965808e-02f, -4.47769314e-02f, 4.53909207e-03f, -8.06756839e-02f, -9.43203494e-02f, 7.53411353e-02f, -6.42880276e-02f, 7.64554814e-02f, 5.72180487e-02f,
  7.28382990e-02f, 8.35606307e-02f, 4.90632840e-02f, 2.66419854e-02f, 3.61256823e-02f, 8.45696125e-03f, 1.66357588e-02f, -3.58876511e-02f, -7.90787935e-02f, -3.78874354e-02f,
  4.54017036e-02f, 1.23470807e-02f, 5.63878007e-02f, 3.55401821e-02f, 1.76271014e-02f, -4.11414802e-02f, 3.82873788e-02f, 1.78112015e-02f, -6.09503649e-02f, 9.94264930e-02f,
  4.46535870e-02f, 1.00816023e-02f, -2.26518009e-02f, 8.35401118e-02f, -3.47292498e-02f, -9.61189531e-03f, 2.32051201e-02f, -5.49974479e-02f, 7.42342323e-02f, -4.08325903e-02f,
  -5.85395284e-02f, -9.25103873e-02f, 2.65051313e-02f, 5.81493266e-02f, -4.45122942e-02f, 1.52333006e-02f, -2.45686676e-02f, 8.38890821e-02f, 6.64948896e-02f, -4.28559110e-02f,
  7.33146816e-02f, 8.17038044e-02f, 4.02678363e-02f, 4.97661792e-02f, 5.90926334e-02f, 8.30815732e-02f, -3.60786282e-02f, 9.94823407e-03f, -1.83725860e-02f, 8.48822296e-04f,
  -9.40583926e-03f, 4.57195453e-02f, 3.88521291e-02f, -9.07423422e-02f, -5.55923432e-02f, 9.85877216e-02f, -2.37576012e-03f, 4.00898755e-02f, -3.91915441e-02f, -4.16759634e-03f,
  5.44409901e-02f, -6.45179674e-02f, -5.23193367e-02f, 1.00408196e-01f, -6.79870173e-02f, 3.84570733e-02f, 5.40855117e-02f, -4.09374386e-02f, 1.08034508e-02f, 1.02270283e-01f,
  -4.44035120e-02f, -3.83055024e-02f, 5.74871339e-02f, 2.57825628e-02f, -9.02965367e-02f, -3.45629491e-02f, -2.61819316e-03f, -1.95283431e-03f, -9.01607424e-02f, 1.21697234e-02f,
  -9.31761190e-02f, 6.42501935e-02f, -4.96130101e-02f, -1.41195282e-01f, -2.16128170e-01f, -1.68789431e-01f, -2.08291672e-02f, 7.89664313e-02f, 1.55872218e-02f, 6.50247335e-02f,
  5.30543588e-02f, -1.23939320e-01f, -3.97962816e-02f, 5.54933362e-02f, 5.23057096e-02f, 1.31536826e-01f, 6.50054440e-02f, -6.68174326e-02f, 3.01769860e-02f, -3.36245522e-02f,
  -2.80226469e-02f, 1.13951005e-02f, 6.75567463e-02f, -6.82803318e-02f, -1.98160727e-02f, 4.26327623e-03f, 4.45407070e-02f, 8.83442909e-03f, 7.50498250e-02f, -8.56713485e-03f,
  4.40533459e-02f, 2.22929288e-02f, 1.02956966e-02f, 1.89934485e-02f, 3.92799005e-02f, -6.62526116e-02f, 5.27717248e-02f, 8.05488438e-04f, -7.28911981e-02f, 4.96610925e-02f,
  2.47154236e-02f, 1.26394089e-02f, 2.88981833e-02f, 1.82436046e-03f, 6.31756261e-02f, -2.36747339e-02f, 5.28959744e-02f, 1.01244070e-01f, 6.99042007e-02f, 2.66672727e-02f,
  1.76193696e-02f, 1.54385511e-02f, -1.53042059e-02f, -9.48466808e-02f, -1.67337842e-02f, -4.59785759e-02f, 2.33303830e-02f, -4.00351435e-02f, 2.45218519e-02f, -4.15779315e-02f,
  7.01586530e-02f, -1.17415655e-02f, -8.19126442e-02f, -2.01535970e-02f, -3.38500775e-02f, -3.47571559e-02f, 7.86861032e-02f, 3.56880873e-02f, 6.93020523e-02f, 3.45565639e-02f,
  -9.36801881e-02f, -2.10606642e-02f, -6.84827939e-02f, -1.31675825e-02f, -7.13201016e-02f, -3.16868536e-02f, 8.17205682e-02f, 8.93970430e-02f, 5.22977347e-03f, -5.59752295e-03f,
  8.32995325e-02f, -3.94531526e-02f, -2.01280415e-02f, 7.24129081e-02f, -2.36823726e-02f, 6.99389353e-02f, -6.78836033e-02f, -9.33181569e-02f, 4.14035954e-02f, -5.37346750e-02f,
  -8.48060288e-03f, 3.46286856e-02f, -3.46216783e-02f, 1.10895718e-02f, 5.34048816e-03f, -4.50131446e-02f, 5.33945449e-02f, -1.27535136e-02f, 8.52262750e-02f, 3.48358750e-02f,
  9.63581651e-02f, 3.28842551e-02f, -3.73464311e-03f, 2.07444260e-04f, -1.92259848e-02f, 8.27958733e-02f, -4.20421064e-02f, 4.66811508e-02f, 7.44323153e-03f, 4.74526472e-02f,
  -9.46945399e-02f, 3.54874730e-02f, 1.71677619e-01f, -3.46696973e-02f, -5.43816462e-02f, 1.51183382e-01f, 5.36454841e-02f, -9.11137611e-02f, -1.63160875e-01f, -1.45441800e-01f,
  -9.39593166e-02f, 1.32176787e-01f, -1.17895797e-01f, -1.70481782e-02f, 1.42477438e-01f, -4.96773981e-02f, -8.38393420e-02f, 1.09515442e-02f, -9.17525962e-02f, -9.44163948e-02f,
  -1.07295282e-01f, -1.76469162e-01f, 7.01564327e-02f, 3.86975482e-02f, -4.13518846e-02f, -1.50213651e-02f, -1.30538851e-01f, 4.59181815e-02f, 1.78875271e-02f, 5.74138239e-02f,
  4.40873988e-02f, -1.21759787e-01f, 8.69170576e-02f, 2.70993896e-02f, -1.82739235e-02f, 2.88083758e-02f, 3.05489190e-02f, 6.16930872e-02f, -3.69087905e-02f, -3.32277082e-03f,
  5.88663593e-02f, 6.65382370e-02f, -6.66609965e-03f, 2.44831573e-02f, 9.02592018e-03f, -6.17845021e-02f, -5.39895566e-03f, -2.86699198e-02f, 8.14796388e-02f, 1.46676853e-01f,
  1.16670787e-01f, 1.10072516e-01f, -2.18669605e-02f, -4.66631576e-02f, -4.57989089e-02f, 4.49141115e-02f, 1.34624112e-02f, -9.15457867e-03f, 5.67324609e-02f, 2.78605567e-03f,
  2.43946910e-02f, 4.28486392e-02f, -5.49411513e-02f, -1.26641132e-02f, 4.84639499e-03f, 4.88818362e-02f, 4.58052233e-02f, 5.80249801e-02f, -8.55426118e-03f, -4.11088057e-02f,
  2.10784636e-02f, 7.40556046e-02f, -2.19642986e-02f, -2.05972809e-02f, 2.67007742e-02f, -5.36432080e-02f, 1.34291366e-01f, 6.39697313e-02f, -1.22820195e-02f, -1.42073259e-02f,
  -8.08774158e-02f, -4.19439040e-02f, 4.38668877e-02f, -3.78666967e-02f, 6.79427907e-02f, 6.69649839e-02f, 5.13153896e-02f, -1.89558286e-02f, -8.30852389e-02f, -3.66034033e-03f,
  1.21165905e-03f, -1.82929546e-01f, -5.08006513e-02f, 2.71047112e-02f, -2.59758178e-02f, 8.66241977e-02f, -3.82533967e-02f, -5.76008260e-02f, 3.76142608e-03f, -9.53216478e-02f,
  -3.70638259e-02f, -2.92150658e-02f, -7.12557435e-02f, 1.36650419e-02f, 7.14364126e-02f, -1.74978990e-02f, 7.64497602e-03f, 1.95448264e-03f, -3.27727683e-02f, -5.66921122e-02f,
  -4.46387678e-02f, -3.57424654e-02f, 6.58620894e-03f, -5.57032116e-02f, -1.13091348e-02f, 5.01828194e-02f, -9.47271436e-02f, 8.80838260e-02f, -1.83394235e-02f, 2.83596804e-03f,
  7.57512599e-02f, 1.79965161e-02f, -8.61192867e-02f, 9.35948361e-03f, 1.19311377e-01f, -1.36102801e-02f, -1.56063791e-02f, 9.29262266e-02f, 1.46860778e-01f, 1.99896600e-02f,
  -3.15719172e-02f, 3.61368470e-02f, 6.80700168e-02f, -5.64139672e-02f, -9.84929651e-02f, 2.52871402e-02f, -8.88962746e-02f, 4.95829880e-02f, -4.44575250e-02f, 5.83829470e-02f,
  -7.27886185e-02f, 9.05657560e-02f, -4.49377969e-02f, 1.12614579e-01f, 7.87336230e-02f, -9.27103870e-03f, 5.42570231e-03f, 7.60122091e-02f, -1.17500968e-01f, -4.02568206e-02f,
  -2.15981677e-02f, 1.05171993e-01f, -5.03721051e-02f, -4.09226455e-02f, 6.80060387e-02f, 5.68919480e-02f, -1.19206242e-01f, -3.30337808e-02f, 8.04339275e-02f, 2.88842805e-02f,
  -8.95044729e-02f, -8.64487216e-02f, 7.21775144e-02f, 4.82161976e-02f, -1.70391332e-02f, -7.14813173e-02f, -1.05301943e-03f, 1.79116968e-02f, 2.90224864e-03f, -7.27980509e-02f,
  7.81293288e-02f, -1.02714770e-01f, -6.28990456e-02f, 5.99549860e-02f, 5.50464429e-02f, 5.15373498e-02f, -9.82473642e-02f, -5.37212044e-02f, -1.00238927e-01f, 7.38759874e-04f,
  3.06053776e-02f, 3.93945761e-02f, 7.09020421e-02f, 8.93145278e-02f, 3.47688384e-02f, -4.17641513e-02f, -3.06179514e-03f, -8.95453691e-02f, 7.31138811e-02f, -4.80850451e-02f,
  -2.77841687e-02f, 1.35724118e-03f, 5.04426286e-02f, 6.44470612e-03f, 6.05357066e-02f, 6.39894083e-02f, 1.48996664e-02f, -1.28012113e-02f, 4.42757867e-02f, -8.04549903e-02f,
  -2.02232171e-02f, -4.31450596e-03f, 1.41401365e-02f, -9.39012542e-02f, 3.00530158e-03f, -1.09245833e-02f, -7.74004012e-02f, -8.21461529e-02f, -2.30797119e-02f, 8.33662450e-02f,
  4.52208593e-02f, -4.94972616e-02f, -2.98719630e-02f, -5.56977987e-02f, 4.69444413e-03f, 1.37445824e-02f, -5.57387769e-02f, 5.91805112e-03f, -5.59916757e-02f, -6.97534308e-02f,
  -8.82108137e-02f, -7.54365399e-02f, 3.65711674e-02f, -4.62786295e-03f, 8.01808983e-02f, -2.92181652e-02f, -7.91394860e-02f, 8.70842040e-02f, 3.40521857e-02f, 3.24250832e-02f,
  7.67040392e-03f, 7.52439573e-02f, 7.25923479e-02f, -1.68918911e-02f, -1.23877820e-04f, -7.48077175e-03f, 1.13707650e-02f, 5.64197302e-02f, 6.51449487e-02f, 3.44878472e-02f,
  -9.81459692e-02f, 1.13646373e-01f, 6.64629191e-02f, -4.75250520e-02f, 8.19110870e-02f, 1.02179669e-01f, 3.76126692e-02f, 8.39804262e-02f, 1.11853428e-01f, 9.31314379e-02f,
  -3.71601135e-02f, -1.97550673e-02f, 5.21330498e-02f, -3.05331964e-02f, 1.13610253e-01f, 9.72894356e-02f, 9.17982236e-02f, -1.07175624e-02f, 1.98074076e-02f, -8.17232281e-02f,
  -2.90592052e-02f, -6.93485141e-02f, -9.08676721e-03f, 2.69662663e-02f, -9.58922580e-02f, 6.18405789e-02f, -6.48159087e-02f, -1.20309405e-01f, -1.14847481e-01f, 5.63187897e-02f,
  -3.35800424e-02f, 5.95403090e-02f, 1.43087395e-02f, 1.14434436e-02f, -1.09852301e-02f, 2.96231993e-02f, 4.80077267e-02f, -5.07838950e-02f, 6.76606596e-03f, 5.73060811e-02f,
  -5.01918085e-02f, -6.34296611e-03f, 3.67647633e-02f, -5.34856133e-02f, 7.26380646e-02f, 1.31249437e-02f, 7.36212963e-03f, -4.87156957e-03f, 6.28601015e-02f, 2.92287655e-02f,
  7.91303292e-02f, -2.40205545e-02f, -4.06177193e-02f, -7.67523572e-02f, -5.29279467e-03f, -9.68317688e-03f, -5.61665976e-03f, 3.60152721e-02f, 2.83126738e-02f, 9.46941748e-02f,
  -3.07408590e-02f, 1.41872540e-02f, 7.00514838e-02f, -3.92735749e-02f, -4.25470003e-04f, 3.89975347e-02f, -3.05441469e-02f, 1.72629282e-02f, -8.07479098e-02f, -6.01680167e-02f,
  -8.11950043e-02f, -1.83246508e-02f, -2.56380569e-02f, 5.44044487e-02f, -7.71656483e-02f, -9.61471200e-02f, 3.66894975e-02f, -1.76313017e-02f, 4.66775969e-02f, 5.42408898e-02f,
  -6.53964281e-02f, 9.79881436e-02f, -9.84512269e-02f, -4.14400920e-02f, -6.04958013e-02f, 2.24809013e-02f, -2.49061659e-02f, -3.06758713e-02f, -6.22567832e-02f, 4.67460006e-02f,
  4.69343141e-02f, -3.22300531e-02f, -9.18932110e-02f, -9.76213068e-02f, -8.19952507e-03f, 5.27120978e-02f, 4.89283428e-02f, 3.70640755e-02f, 2.10093614e-02f, 5.34229353e-02f,
  7.85466805e-02f, 1.58679783e-02f, 5.58904000e-02f, 1.02232695e-02f, 2.09576469e-02f, -1.66271422e-02f, 2.65857223e-02f, 4.31090742e-02f, 4.56072539e-02f, 1.00221299e-01f,
  -1.05595037e-01f, -1.05508817e-02f, -3.66899148e-02f, 7.19150826e-02f, -2.98512280e-02f, 5.15605416e-03f, -3.86161320e-02f, -5.93000352e-02f, 4.29461263e-02f, 4.22384329e-02f,
  1.93064064e-01f, -2.93556094e-01f, 7.51452670e-02f, 2.66666561e-01f, 1.56163618e-01f, 6.08892180e-02f, 6.96801320e-02f, 8.91374126e-02f, 2.25802273e-01f, -1.37820974e-01f,
  -4.33839485e-02f, -7.33802542e-02f, -2.52415270e-01f, 1.06723875e-01f, -3.78403626e-02f, -1.47915691e-01f, 9.77996439e-02f, -4.54132557e-02f, 8.08168799e-02f, 3.02152871e-03f,
  1.01484112e-01f, 1.01712264e-01f, -2.64911391e-02f, 5.96351102e-02f, 9.31376964e-02f, 5.16693071e-02f, 6.02833787e-03f, -1.68622777e-01f, -2.43305042e-02f, -5.97120114e-02f,
  -3.90218608e-02f, -2.68443003e-02f, -5.36480509e-02f, -2.99568870e-03f, 3.99208777e-02f, 4.45049331e-02f, 1.00055467e-02f, -4.81607877e-02f, 9.83142573e-03f, -5.79984039e-02f,
  -7.90222436e-02f, 3.29709053e-02f, -2.90442188e-03f, -7.21950904e-02f, 9.44113359e-02f, 8.44585896e-02f, 9.59849432e-02f, 8.03960562e-02f, 1.23868790e-02f, 7.81037584e-02f,
  -5.10628615e-03f, 6.82311729e-02f, 2.61067674e-02f, -3.23629715e-02f, 1.61219910e-02f, -2.45530270e-02f, 7.23362938e-02f, -4.16839458e-02f, 3.00876168e-03f, 1.20154738e-01f,
  -3.19466107e-02f, -2.23156439e-06f, -7.59188533e-02f, -4.73191962e-02f, -3.49433720e-02f, 3.88389602e-02f, -7.14287534e-02f, 2.74568759e-02f, 3.32533605e-02f, 2.69209296e-02f,
  1.23641221e-03f, -7.14049041e-02f, 6.33063465e-02f, -5.03724702e-02f, -8.72161835e-02f, 9.97517407e-02f, -1.17585892e-02f, 4.18114848e-02f, 1.95747018e-02f, -2.08682679e-02f,
  1.43000260e-02f, -1.00729996e-02f, 2.62169503e-02f, 5.01102544e-02f, -9.64926034e-02f, 1.50169106e-02f, -6.20830469e-02f, 6.50200024e-02f, -3.16470265e-02f, 2.55637523e-02f,
  -1.46585077e-01f, -2.07355097e-01f, 2.20869575e-02f, -3.27181444e-02f, 1.17952162e-02f, 5.74333929e-02f, -3.36340368e-02f, 3.18309516e-02f, -7.52194002e-02f, -1.08568938e-02f,
  6.05206145e-03f, 3.85354310e-02f, 1.32649420e-02f, 7.04332292e-02f, 1.95768941e-02f, 4.19031875e-03f, -5.22060618e-02f, 2.92172879e-02f, -5.00512384e-02f, -5.15713021e-02f,
  1.70298964e-02f, 3.47256213e-02f, 3.93888280e-02f, -6.85922755e-03f, 2.93054990e-02f, 5.45699112e-02f, -6.59043789e-02f, -9.75573249e-03f, 4.04142402e-03f, -4.37358841e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 52)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 52;
const float L0_fan_Bp_bar_data[] = {
  1.14757299e-01f, 7.26830885e-02f, 1.08843334e-01f, -1.84653122e-02f, 1.57372564e-01f, -3.23960371e-02f, 1.01970993e-01f, 2.29375381e-02f, 1.65827721e-01f, 3.19400989e-02f,
  1.61223978e-01f, 9.88272503e-02f, 7.46009424e-02f, 4.90928926e-02f, -2.12294180e-02f, 6.07860386e-02f, 4.62355129e-02f, 9.96732265e-02f, 8.42785761e-02f, 2.79604399e-04f,
  5.03505468e-02f, 4.28356640e-02f, -7.92420655e-03f, 1.17944507e-02f, 1.00905057e-02f, 9.66762751e-02f, 1.21951900e-01f, 6.88156486e-02f, 5.78458644e-02f, 1.65943280e-02f,
  -2.14557368e-02f, 1.88594684e-01f, 5.18830447e-03f, 1.10228963e-01f, 1.34488553e-01f, 2.06921220e-01f, 8.17224905e-02f, 3.35855633e-02f, 1.04097715e-02f, 2.20446572e-01f,
  2.05158338e-01f, 4.63533886e-02f, 1.57664970e-01f, 1.49139225e-01f, 1.06504612e-01f, -2.19910853e-02f, -7.07725883e-02f, 5.21088913e-02f, 1.71532318e-01f, 7.79543743e-02f,
  1.24848865e-01f, 1.24883570e-01f
};

// L1_linear_W (Shape: 12 x 128)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 128;
const float L1_linear_W_data[] = {
  -7.86368325e-02f, 4.06530984e-02f, -1.09261602e-01f, 5.14300428e-02f, 1.38216175e-03f, 1.25726787e-02f, 1.21742431e-02f, -3.11528116e-01f, -3.75983983e-01f, -4.72188257e-02f,
  -1.03689721e-02f, -1.42421573e-01f, 6.25513569e-02f, -2.25094691e-01f, 4.82797846e-02f, 2.33383421e-02f, 1.49645329e-01f, 6.97875321e-02f, -7.68221170e-02f, -3.22001547e-01f,
  1.49821118e-01f, -6.74501583e-02f, 1.31534085e-01f, 1.51094105e-02f, -3.05585772e-01f, 1.46297216e-01f, -8.35884828e-03f, 4.60961722e-02f, 2.69280881e-01f, -2.61301935e-01f,
  1.84938475e-01f, 8.65904838e-02f, -2.85789724e-02f, -4.63533364e-02f, -4.82233800e-03f, -1.70910545e-02f, -1.01738490e-01f, 1.19699821e-01f, 2.40910098e-01f, -7.07022026e-02f,
  -1.16962314e-01f, -8.57794210e-02f, -6.42922595e-02f, 1.64118275e-01f, -2.21584141e-01f, 2.97206193e-01f, -3.15849632e-01f, -3.47990513e-01f, 3.44673060e-02f, 1.57475606e-01f,
  -1.68098673e-01f, 3.14539850e-01f, -1.11330971e-01f, 2.44637117e-01f, -1.55697569e-01f, 2.04643141e-02f, 2.17174128e-01f, -3.93534958e-01f, -3.99550200e-02f, -3.40908885e-01f,
  2.73741573e-01f, -1.38856754e-01f, 2.90731341e-01f, -1.89388290e-01f, 4.42672819e-01f, 1.26626655e-01f, 1.38164923e-01f, 4.53952610e-01f, 4.08016630e-02f, -2.89753914e-01f,
  9.16776434e-02f, -2.18093872e-01f, 7.33337179e-02f, 1.89958215e-01f, 1.86258450e-01f, -2.28685915e-01f, -1.86987743e-01f, 3.03027213e-01f, -7.18327537e-02f, -1.28177136e-01f,
  -2.11578399e-01f, -2.48495024e-02f, 4.40776646e-02f, 2.51526177e-01f, 1.66001767e-01f, -1.79730058e-01f, -2.18696166e-02f, -1.75423652e-01f, -7.94297084e-02f, -7.59628713e-02f,
  -1.36585459e-01f, 8.02244321e-02f, 6.88562542e-02f, 1.34021312e-01f, 1.75313149e-02f, -1.12498857e-01f, 2.75054663e-01f, -1.03738204e-01f, 8.82780403e-02f, -8.70275870e-03f,
  1.21182732e-01f, 1.43289402e-01f, 2.19079647e-02f, -2.46447340e-01f, -1.21283144e-01f, -1.12803932e-02f, 5.79872392e-02f, -3.49895507e-02f, -9.45349410e-02f, -1.86566696e-01f,
  -1.26831502e-01f, -1.78472474e-01f, -1.70294434e-01f, -1.76026151e-02f, -5.62730012e-03f, -4.66409102e-02f, 2.57362068e-01f, 5.41642129e-01f, 1.96605533e-01f, 2.67824233e-01f,
  1.07563324e-02f, 1.21869659e-02f, 5.49517684e-02f, -8.19788426e-02f, -1.31909207e-01f, -5.42146526e-02f, -5.34356199e-02f, -1.12401322e-01f, 1.00004077e-01f, 6.64217621e-02f,
  1.12267040e-01f, -9.78988260e-02f, 6.84379712e-02f, -5.29895350e-02f, 1.68101430e-01f, 1.22583330e-01f, -1.50517792e-01f, -4.20322679e-02f, -7.11755082e-02f, 1.96303979e-01f,
  -9.17485058e-02f, -7.45713338e-02f, 2.47132592e-02f, 1.34176329e-01f, 4.70936894e-02f, 2.25613713e-02f, -4.44323242e-01f, 2.77489007e-01f, 1.30233541e-01f, -2.76890155e-02f,
  -6.09363914e-02f, 1.36319175e-01f, 8.82466137e-02f, -2.09460512e-01f, -1.55543849e-01f, 2.25476939e-02f, -1.66642129e-01f, 3.04720141e-02f, -1.90986678e-01f, -1.51862904e-01f,
  2.72659898e-01f, 4.51042242e-02f, 5.26534021e-02f, -1.70478746e-01f, 7.34834895e-02f, -1.89060882e-01f, -1.72458813e-01f, -1.06013730e-01f, 1.14269159e-03f, 1.88666210e-01f,
  -9.60931182e-02f, 1.35155633e-01f, 7.74979219e-02f, 3.98092359e-01f, -3.02169234e-01f, -2.37377033e-01f, 1.69573009e-01f, 2.50543565e-01f, -3.45233172e-01f, 4.21480387e-01f,
  -4.38156307e-01f, -2.40011498e-01f, 3.05339247e-01f, 9.42505151e-02f, 3.15882266e-01f, -4.28470299e-02f, 4.67557870e-02f, 9.24151763e-02f, 3.05498421e-01f, -2.72483021e-01f,
  9.46968347e-02f, -2.23873064e-01f, -4.66887683e-01f, 1.55965015e-01f, 4.21587199e-01f, 2.64259458e-01f, -4.85429078e-01f, -2.49029934e-01f, -8.49928856e-02f, -5.13909347e-02f,
  8.32622126e-02f, 2.08598599e-01f, -1.71360895e-01f, -3.73144865e-01f, -1.17056340e-01f, 1.43541828e-01f, -1.75807551e-01f, 8.39850977e-02f, 6.64173365e-02f, -6.64036199e-02f,
  9.96117890e-02f, 7.86764547e-02f, -5.86697347e-02f, 2.68075019e-02f, -7.63544217e-02f, 1.82875823e-02f, -2.04577640e-01f, -8.62411335e-02f, 3.64201255e-02f, -5.31628588e-03f,
  -6.78061694e-02f, -2.52345383e-01f, 3.06269675e-01f, 4.89271916e-02f, -1.52780280e-01f, -4.74473909e-02f, 2.31316105e-01f, 1.70832694e-01f, -1.75396830e-01f, 9.06535704e-03f,
  -1.27024595e-02f, 1.09638199e-01f, 1.04610687e-02f, -1.55945897e-01f, -9.14567038e-02f, -8.62715095e-02f, 1.42743662e-02f, 2.03759506e-01f, 2.92943455e-02f, 1.09816253e-01f,
  -4.21691015e-02f, 4.62696031e-02f, 2.17079893e-01f, -2.32533395e-01f, -8.06551501e-02f, -5.44072054e-02f, -1.98848397e-01f, 4.24362481e-01f, 2.12684855e-01f, 9.54521298e-02f,
  -2.62592025e-02f, -1.64722860e-01f, -9.42790508e-02f, 3.45936678e-02f, -5.47134411e-03f, -4.32974100e-02f, -7.88673535e-02f, 1.24301957e-02f, -9.68099833e-02f, 6.76804259e-02f,
  -9.10570621e-02f, -8.49910360e-03f, -1.26391679e-01f, -1.03611723e-01f, -2.60961503e-02f, -5.56341037e-02f, -4.12080921e-02f, 4.52253334e-02f, 1.20314181e-01f, 1.61623955e-02f,
  1.26370974e-02f, -2.83339880e-02f, -9.10366029e-02f, -1.25007495e-01f, -6.17644973e-02f, -2.83209383e-01f, -6.94511160e-02f, -2.60081086e-02f, 2.84513831e-02f, -3.60258631e-02f,
  -7.57545307e-02f, 2.06217468e-02f, -4.20506373e-02f, -1.24905057e-01f, -1.06952868e-01f, -4.30843420e-02f, -1.53796896e-01f, -8.29440504e-02f, -2.68115669e-01f, -1.70715488e-02f,
  -6.04463518e-02f, -1.19392633e-01f, -9.72680748e-02f, 4.72247265e-02f, -9.61687788e-02f, 3.77777740e-02f, 8.01220983e-02f, -3.28348763e-02f, -2.08512709e-01f, 1.18303381e-01f,
  -2.52047896e-01f, -2.39296779e-01f, 3.01732600e-01f, -1.94906637e-01f, 1.78478673e-01f, 1.27317652e-01f, 1.25349700e-01f, -7.86029175e-02f, 2.35996112e-01f, 2.21332442e-02f,
  1.08331852e-01f, 1.46898404e-01f, 3.44366044e-01f, 3.88571471e-01f, 3.36578786e-01f, 2.17398331e-01f, 1.46576747e-01f, -1.86708733e-01f, -2.05742523e-01f, -1.45545200e-01f,
  -6.89652935e-02f, 3.43336940e-01f, 2.52340198e-01f, 2.10162759e-01f, -4.03389364e-01f, -3.54891926e-01f, -3.02184910e-01f, 1.24980301e-01f, 3.09043437e-01f, 2.52544641e-01f,
  -3.38874847e-01f, 6.95135444e-02f, -2.51123905e-01f, 9.54970531e-03f, -1.11548742e-02f, -4.21636645e-03f, 5.32596670e-02f, 7.62212873e-02f, -1.36858165e-01f, 1.58314154e-01f,
  -1.34390881e-02f, 3.22505444e-01f, 1.73436198e-03f, 1.14136778e-01f, 4.92482334e-01f, -1.60683170e-02f, 2.58300845e-02f, 5.49729280e-02f, -8.34966265e-03f, -1.13173097e-01f,
  4.92469892e-02f, -9.86609012e-02f, -2.04592004e-01f, 1.95539873e-02f, -1.25200033e-01f, 2.34253079e-01f, -1.51842043e-01f, -8.17441791e-02f, 4.13320586e-02f, 6.49291098e-01f,
  -1.29145131e-01f, 6.98733553e-02f, -4.85268468e-03f, -2.36839935e-01f, -8.83215219e-02f, 3.19511257e-02f, 1.12728298e-01f, 8.02398324e-02f, -1.32725487e-04f, -7.38995820e-02f,
  -1.14495501e-01f, -1.17054582e-01f, -1.33834109e-01f, -8.97568837e-02f, 8.61533508e-02f, -4.72597368e-02f, -9.89832580e-02f, -1.51991144e-01f, -1.06568336e-01f, -2.46029422e-02f,
  1.05446309e-01f, -4.29757945e-02f, -9.23399553e-02f, 3.11231345e-01f, -2.06163842e-02f, -4.40626889e-02f, -1.30229697e-01f, -1.31492347e-01f, 5.48286214e-02f, 4.91524413e-02f,
  -3.36133167e-02f, 8.55479538e-02f, 7.73274824e-02f, -7.04668835e-02f, 1.25857489e-02f, 3.43312658e-02f, -9.04564336e-02f, -4.29741405e-02f, 5.11589367e-03f, 1.22437114e-02f,
  -3.24099809e-01f, 1.20383434e-01f, 1.59851670e-01f, -1.78659871e-01f, 5.24415188e-02f, -1.57252833e-01f, -5.37953004e-02f, 5.89391449e-03f, 1.03790149e-01f, -3.00793555e-02f,
  -3.05542916e-01f, 3.05450261e-02f, -3.24569017e-01f, -3.67843322e-02f, 1.39620721e-01f, 3.45820524e-02f, -4.26236749e-01f, -4.51555327e-02f, -3.82442884e-02f, 1.41814083e-01f,
  -3.12383562e-01f, 1.84722349e-01f, -1.22166552e-01f, -5.27844466e-02f, 3.14529777e-01f, -1.29347011e-01f, -1.13770319e-02f, -6.08756281e-02f, -9.85696316e-02f, 1.49378076e-01f,
  -2.61328816e-01f, 2.84988672e-01f, -1.79537609e-01f, 1.09171577e-01f, 3.99828434e-01f, -2.67238975e-01f, -2.75850862e-01f, -2.93798268e-01f, -3.40476602e-01f, 2.66149510e-02f,
  8.57972279e-02f, -2.01554447e-01f, 5.32057621e-02f, -3.59958887e-01f, -3.08697075e-01f, -3.35522145e-01f, 1.69222444e-01f, 3.41811508e-01f, 3.97299558e-01f, -7.31612220e-02f,
  -2.52480149e-01f, -3.99537593e-01f, 1.60371035e-01f, 2.52179205e-01f, 2.72299349e-01f, 9.82028991e-02f, 1.45149514e-01f, -2.77341127e-01f, 2.58029699e-01f, 6.62540719e-02f,
  1.80947810e-01f, 2.46114880e-01f, 1.23582512e-01f, 3.63798618e-01f, 2.35041771e-02f, -1.17323205e-01f, 5.32793812e-02f, -1.14095412e-01f, 8.12136158e-02f, 4.16504685e-03f,
  -1.14555068e-01f, 2.31913943e-02f, -1.02003127e-01f, -4.00841562e-03f, -5.64883016e-02f, -1.09642759e-01f, -9.65326000e-03f, 4.65288982e-02f, -1.38171420e-01f, 5.09218487e-04f,
  7.23701715e-02f, -6.03228901e-03f, -4.52325456e-02f, -7.62970671e-02f, -1.46357685e-01f, 1.48554802e-01f, -2.07301229e-01f, -1.74646284e-02f, -1.61728844e-01f, -9.04481262e-02f,
  -9.06023383e-02f, -9.69206989e-02f, -2.69768126e-02f, -1.35686919e-01f, -8.62265527e-02f, -4.65502627e-02f, 1.45079789e-03f, 9.44334045e-02f, -1.58219840e-02f, 2.88889498e-01f,
  4.83618051e-01f, 3.89852449e-02f, 7.78412223e-02f, -5.42736165e-02f, -8.09753090e-02f, 7.98779875e-02f, -1.30871728e-01f, -7.33322948e-02f, -1.38152108e-01f, 1.97923020e-01f,
  -1.45153165e-01f, -1.34974122e-01f, -2.16466963e-01f, 1.12525880e-01f, 2.16819480e-01f, 2.63439585e-02f, 3.33199054e-02f, -4.78639230e-02f, -6.57743737e-02f, 1.42469317e-01f,
  2.30008736e-01f, -2.32464120e-01f, 1.61993161e-01f, 6.92949742e-02f, 1.88136980e-01f, 1.62061572e-01f, 3.15661989e-02f, 6.43170029e-02f, 2.42671385e-01f, 1.18170805e-01f,
  1.38068259e-01f, 1.72051221e-01f, 1.76559947e-02f, -7.93404505e-02f, -5.86746484e-02f, 4.58957776e-02f, -1.39574260e-01f, 1.55927166e-01f, 2.98126042e-02f, 1.09481797e-01f,
  7.97031745e-02f, 1.00332081e-01f, -1.02658033e-01f, -9.52189714e-02f, 1.76187485e-01f, 1.39925703e-01f, 7.32689500e-02f, 1.46151200e-01f, 2.87541300e-01f, 8.45759287e-02f,
  4.43527132e-01f, -3.33384946e-02f, -2.68352747e-01f, -4.14706051e-01f, -1.72388200e-02f, 2.92145342e-01f, -3.78840357e-01f, 4.70249131e-02f, -9.13431719e-02f, 3.94881368e-01f,
  -3.42233777e-02f, 6.01519719e-02f, 7.30403885e-02f, 2.46436387e-01f, 2.21045673e-01f, -3.63305807e-02f, -3.10610592e-01f, -2.19017953e-01f, -4.57237884e-02f, -1.07651994e-01f,
  -2.10131273e-01f, -1.59957930e-01f, -3.35897326e-01f, 3.52579914e-02f, 3.69038314e-01f, -1.71546102e-01f, 3.76391202e-01f, -1.83809116e-01f, -5.81554890e-01f, 1.16664805e-01f,
  -1.10410638e-01f, 4.22382474e-01f, 1.06726818e-01f, -7.68976212e-02f, 1.01601146e-01f, -1.66450873e-01f, 9.37492102e-02f, 1.42503455e-01f, -1.56058669e-01f, -2.47699484e-01f,
  2.53387213e-01f, -9.45665315e-02f, -1.60969764e-01f, -8.47169086e-02f, 2.09254637e-01f, -1.21993922e-01f, -9.55207273e-02f, -6.62149414e-02f, 2.82300770e-01f, 7.92440772e-02f,
  -1.24083154e-01f, 7.57081211e-02f, 2.96407752e-02f, -3.88075821e-02f, 1.54502302e-01f, 6.79266900e-02f, -1.71302468e-01f, 1.52676120e-01f, -7.56828636e-02f, 8.29000771e-03f,
  -9.84732732e-02f, 4.58532162e-02f, 1.52518600e-01f, -1.55506700e-01f, 3.30367714e-01f, -9.50718522e-02f, -2.08588287e-01f, -8.76016393e-02f, 6.37621805e-03f, -1.45836055e-01f,
  5.03739379e-02f, -1.42012164e-01f, 1.29143819e-01f, -1.89616859e-01f, 4.27358836e-01f, 2.36084476e-01f, -2.44590323e-02f, -1.26237899e-01f, 2.76926402e-02f, 9.08844813e-04f,
  2.32800245e-02f, -5.62987812e-02f, -3.81181017e-02f, -1.12574719e-01f, 1.10272691e-02f, -1.57337114e-01f, 2.70024747e-01f, -6.94521293e-02f, 1.95533127e-01f, -1.65965676e-01f,
  1.16624117e-01f, 1.43419523e-02f, 1.29103437e-01f, 1.16467634e-02f, -4.09877785e-02f, 2.54713818e-02f, -5.31234294e-02f, 3.01809181e-02f, 1.88926741e-01f, 9.15074795e-02f,
  7.08468333e-02f, -3.47464457e-02f, -4.08319198e-02f, -2.45108791e-02f, 1.67461172e-01f, -3.58761884e-02f, -1.32787479e-02f, 9.77181345e-02f, 3.77811223e-01f, 1.46053195e-01f,
  -9.86198410e-02f, 2.12257668e-01f, 2.68135786e-01f, -2.32093558e-01f, 8.26920420e-02f, 9.96881165e-03f, 4.15904187e-02f, 1.83183234e-02f, 2.33806178e-01f, 2.84202009e-01f,
  3.47834498e-01f, 4.40326519e-02f, 1.46072298e-01f, 1.16751619e-01f, -1.80006083e-02f, 1.03412293e-01f, 2.83261150e-01f, 2.39123013e-02f, 1.14785522e-01f, -2.25877643e-01f,
  -2.88680822e-01f, 4.50827539e-01f, 1.97381899e-01f, 1.10219531e-01f, 4.76233393e-01f, 1.21528320e-01f, -3.80019277e-01f, 3.49808075e-02f, 1.99425202e-02f, -3.37038815e-01f,
  -3.58783394e-01f, 1.54231906e-01f, -5.43501154e-02f, 1.25125736e-01f, 4.02880430e-01f, -8.74251351e-02f, 1.25364855e-01f, -3.98293018e-01f, -3.13629001e-01f, -6.01090714e-02f,
  1.11238942e-01f, 6.23174846e-01f, 1.83322541e-02f, -1.23194106e-01f, -2.30371311e-01f, -1.65174067e-01f, 1.21262059e-01f, -3.62656415e-02f, 1.67883951e-02f, 2.28548244e-01f,
  -1.55133754e-01f, 7.78127043e-03f, -2.74727970e-01f, -2.89601594e-01f, -2.15316027e-01f, -2.76921898e-01f, -1.32328004e-01f, -1.48363501e-01f, -6.38841093e-02f, 7.93085098e-02f,
  -1.69316947e-01f, -7.43136406e-02f, 7.01493118e-03f, 9.45143774e-02f, -2.08005965e-01f, 1.85432673e-01f, -2.82849610e-01f, -1.63549230e-01f, -5.91464043e-02f, 5.90683557e-02f,
  -6.38868958e-02f, -5.49970903e-02f, -9.02201161e-02f, -2.95907408e-01f, 1.00996032e-01f, -1.96436048e-01f, 4.85655405e-02f, 2.03755736e-01f, 1.44754589e-01f, -1.52502343e-01f,
  -6.99885860e-02f, 1.69251055e-01f, -1.79381043e-01f, -1.74238205e-01f, -1.43845566e-02f, 4.18416783e-02f, 3.80693972e-01f, 2.55730927e-01f, 2.10675493e-01f, -4.72783707e-02f,
  -2.36813780e-02f, -1.10896066e-01f, 1.72999755e-01f, -1.41500518e-01f, -4.06217501e-02f, 5.43197989e-02f, 6.50023073e-02f, -1.73376963e-01f, -1.89956650e-01f, 7.36725852e-02f,
  4.40033935e-02f, -9.91740897e-02f, 1.39979899e-01f, -1.22881278e-01f, -1.22952260e-01f, 4.82779779e-02f, 1.68106109e-01f, -1.09501638e-01f, -5.51394112e-02f, 1.00217208e-01f,
  9.94897354e-03f, -2.12419584e-01f, -1.15873724e-01f, 1.52517557e-02f, 1.01431921e-01f, -1.90636143e-01f, -6.01246208e-02f, -9.38772783e-02f, 2.32141223e-02f, 1.18492670e-01f,
  -4.40196767e-02f, 1.10137805e-01f, -2.15947539e-01f, 6.42625522e-03f, -9.20510385e-03f, 1.00090086e-01f, 1.19357266e-01f, -3.43261778e-01f, 7.29390010e-02f, 5.06802015e-02f,
  1.16392985e-01f, -4.09675296e-03f, -6.65192008e-02f, -3.91621031e-02f, 7.51658604e-02f, 1.63383260e-01f, -6.40250519e-02f, 1.20713703e-01f, 2.50983924e-01f, 1.12164415e-01f,
  -1.91290881e-02f, -9.32663307e-02f, -3.16153839e-02f, 6.96671307e-02f, -1.38851553e-01f, 8.89710337e-02f, -2.91432083e-01f, -7.57998005e-02f, -1.16593592e-01f, 2.14314237e-01f,
  1.32224247e-01f, 7.43413866e-02f, 9.42753721e-03f, -3.03010911e-01f, 3.94072115e-01f, 2.65021235e-01f, 1.30953342e-01f, -1.77602947e-01f, -2.26507843e-01f, 9.04935375e-02f,
  3.79452229e-01f, -2.04426274e-01f, -6.50190711e-02f, -9.26879346e-02f, -1.91849187e-01f, 3.38434845e-01f, -2.70690203e-01f, 2.81589836e-01f, 6.66380152e-02f, -2.52392124e-02f,
  -3.06641668e-01f, -2.71759450e-01f, -6.72025466e-03f, -1.52423277e-01f, 4.25086439e-01f, -4.06424612e-01f, 1.65680110e-01f, 8.38970616e-02f, -1.64665908e-01f, 2.32846469e-01f,
  5.47517501e-02f, 1.93613693e-02f, -3.30103219e-01f, -2.80346796e-02f, -8.45466461e-03f, -1.67060256e-01f, -8.83210972e-02f, -6.66988343e-02f, -1.37731493e-01f, 3.75658333e-01f,
  2.27571838e-02f, -2.16303412e-02f, -9.24009085e-02f, 1.58866093e-01f, -3.83146964e-02f, -1.15581974e-01f, -2.35081092e-01f, 5.53272776e-02f, -1.40960455e-01f, -1.89408600e-01f,
  -4.48919944e-02f, 6.81409687e-02f, 8.55567679e-02f, 2.98746891e-04f, -1.23576179e-01f, 3.26065645e-02f, -1.27713114e-01f, -2.05599695e-01f, 4.78108227e-02f, 3.87047455e-02f,
  -1.96659844e-02f, 1.06005497e-01f, -2.65889224e-02f, 3.44953164e-02f, 2.43964046e-01f, -1.05821133e-01f, 3.37445037e-03f, 5.14008403e-01f, 4.29523319e-01f, -1.50050670e-01f,
  3.14842686e-02f, 8.43050182e-02f, -7.87772238e-02f, 4.73218918e-01f, -1.17306657e-01f, -9.51740146e-02f, 9.89341885e-02f, -1.11975580e-01f, -7.64021501e-02f, -8.35035518e-02f,
  -6.56747520e-02f, -1.17801934e-01f, -1.84107244e-01f, 1.35757774e-01f, -1.99675318e-02f, 5.07699966e-01f, 7.04074055e-02f, 4.52729836e-02f, 3.50746661e-02f, 9.19610709e-02f,
  -1.12220779e-01f, 1.14315197e-01f, 3.89861204e-02f, -4.70922142e-02f, 1.34668782e-01f, -7.86558166e-02f, -2.58480161e-02f, -6.09284043e-02f, -5.74592985e-02f, -1.18811220e-01f,
  1.28397137e-01f, -1.51755497e-01f, -2.41551511e-02f, -2.43744105e-01f, -8.24197456e-02f, 1.22316852e-01f, -1.40228033e-01f, 4.14142460e-02f, -5.67471050e-02f, -1.11512989e-01f,
  3.14488038e-02f, -2.94749379e-01f, -9.10598040e-02f, -5.28663807e-02f, -1.73479170e-01f, -2.06569359e-01f, -1.94165632e-02f, -2.66540885e-01f, -3.26995589e-02f, 4.56944816e-02f,
  -7.19894245e-02f, -2.69201607e-01f, -4.38750722e-02f, 1.47820832e-02f, -1.25245944e-01f, -2.65661394e-03f, 6.09000362e-02f, -6.01243414e-02f, -1.67544410e-01f, 4.83610816e-02f,
  1.88593671e-01f, 8.20877180e-02f, 1.78871512e-01f, -1.11001924e-01f, -1.76218301e-01f, -5.21088392e-02f, -3.51599902e-02f, -1.08758673e-01f, -1.01292141e-01f, 3.18542391e-01f,
  2.03641072e-01f, -3.66661102e-01f, -3.39321673e-01f, 2.37738173e-02f, 1.94798093e-02f, -5.62929772e-02f, -1.86347634e-01f, 1.61933318e-01f, -2.66079098e-01f, 3.28418881e-01f,
  3.24718654e-01f, 3.10012311e-01f, -2.00712189e-01f, -2.34652579e-01f, 1.35882804e-02f, 2.67079055e-01f, 1.09762251e-01f, 3.13266963e-02f, -1.79284692e-01f, -2.88981140e-01f,
  1.55076221e-01f, -2.82510996e-01f, 1.80300921e-01f, 7.53430054e-02f, 1.16851434e-01f, 1.22730443e-02f, -1.17644913e-01f, -7.64854997e-02f, -3.19509506e-02f, -6.48872554e-02f,
  -2.71545369e-02f, -6.05659895e-02f, 1.65743291e-01f, -1.09885260e-01f, 9.63954546e-04f, 1.96782216e-01f, -6.91331178e-02f, 1.11952007e-01f, 4.27020378e-02f, 4.70471889e-01f,
  -5.32346442e-02f, 3.18069384e-02f, -5.36776558e-02f, -1.52075719e-02f, -1.35829905e-02f, 6.70003071e-02f, -6.54065013e-02f, 1.92240715e-01f, -1.59612596e-01f, -1.01583023e-02f,
  5.52248299e-01f, 1.82379782e-01f, -1.34439558e-01f, -1.01190239e-01f, -2.23845430e-02f, -1.19625673e-01f, -5.47325537e-02f, 4.64195311e-02f, -3.57062602e-03f, -1.18749216e-01f,
  1.33819163e-01f, 1.44707546e-01f, -2.29607865e-01f, 3.52753960e-02f, -1.10437520e-01f, -7.68470615e-02f, -6.48298711e-02f, 1.16965577e-01f, 8.32160264e-02f, -2.85666273e-03f,
  -1.53786837e-04f, -2.52002869e-02f, 2.62967870e-02f, -1.09695956e-01f, -8.65078866e-02f, -7.55993575e-02f, -6.46914765e-02f, 5.36184646e-02f, -1.54584823e-02f, -6.28594588e-03f,
  6.68763667e-02f, 5.12346178e-02f, 1.05803078e-02f, 5.24606854e-02f, 1.01965420e-01f, -9.28767100e-02f, -1.85549870e-01f, -3.76518779e-02f, 6.15470968e-02f, -7.93212876e-02f,
  5.52392267e-02f, -9.78875556e-04f, 1.05587607e-02f, 7.04688206e-02f, -2.54600853e-01f, -2.14882433e-01f, -6.94875941e-02f, -3.37510295e-02f, -3.94115485e-02f, 7.18631223e-02f,
  -1.18853003e-01f, 2.58002300e-02f, -7.31376261e-02f, -1.46957174e-01f, -2.65257508e-01f, -3.62856388e-02f, -1.29252121e-01f, -2.15157628e-01f, 3.36764194e-02f, 8.11328143e-02f,
  2.35127769e-02f, 1.45729780e-02f, -2.90368110e-01f, -9.13454965e-02f, -3.96453664e-02f, 3.82159315e-02f, 1.43853072e-02f, 3.17364223e-02f, 1.40915215e-01f, -2.46817549e-03f,
  -3.47108729e-02f, -1.36990994e-01f, -1.17807016e-01f, -2.17736155e-01f, 3.21217030e-01f, -3.20950627e-01f, 4.54660580e-02f, -1.26222596e-01f, 5.76918907e-02f, 7.02049285e-02f,
  -1.66204110e-01f, 9.54264477e-02f, 2.93548286e-01f, 3.02900255e-01f, 2.05639020e-01f, -4.31977697e-02f, 1.62201867e-01f, -6.03299402e-02f, -2.93457329e-01f, -2.55336612e-01f,
  2.52369821e-01f, 1.79029301e-01f, -3.02105308e-01f, -9.28712562e-02f, -1.77980840e-01f, 2.63128877e-01f, -1.91744454e-02f, 1.56966895e-01f, 5.02822697e-02f, 1.60889238e-01f,
  4.53440726e-01f, -1.38226554e-01f, 1.39382586e-01f, 1.00733191e-01f, 2.93428004e-02f, -2.95099095e-02f, -1.10692188e-01f, -1.22432187e-01f, -1.13007143e-01f, 7.08825793e-03f,
  3.90953235e-02f, 2.58522987e-01f, 4.12719548e-01f, 1.39054293e-02f, 4.04726118e-01f, 6.21833503e-02f, -4.42024022e-02f, -9.70488340e-02f, -2.80878041e-03f, 5.02326250e-01f,
  2.24823892e-01f, 5.96366823e-02f, -1.35892525e-01f, 2.93900985e-02f, 5.23024276e-02f, -1.63721591e-01f, -8.68941993e-02f, 3.53183150e-02f, -7.86347240e-02f, 1.77250534e-01f,
  -3.78779471e-02f, 3.55316520e-01f, -1.06485270e-01f, -2.07379952e-01f, -2.06066981e-01f, -6.62070559e-03f, 5.34393042e-02f, -1.29329741e-01f, -1.41673520e-01f, -1.21160075e-01f,
  -8.18658061e-03f, -5.02508171e-02f, -1.71884388e-01f, 1.70383394e-01f, -6.15286492e-02f, 6.32224977e-02f, -5.09975031e-02f, -3.58413137e-03f, -1.35732114e-01f, -1.80236939e-02f,
  7.05235824e-03f, -1.26309186e-01f, 4.47660200e-02f, -1.77806348e-01f, -3.10574248e-02f, 8.85843337e-02f, 1.69554830e-01f, -8.65736157e-02f, -1.08998075e-01f, 2.45084986e-03f,
  -9.71155688e-02f, 2.42308706e-01f, 4.77394350e-02f, 1.79948639e-02f, 9.15410183e-03f, 5.74564412e-02f, -1.60046928e-02f, 2.43962626e-03f, -3.96474525e-02f, 6.23756275e-03f,
  -4.37288657e-02f, 7.88543895e-02f, -6.45295382e-02f, 6.70997500e-02f, 4.16216739e-02f, 2.23369524e-02f, 4.79592010e-02f, 1.39138758e-01f, 9.13346782e-02f, 6.75648227e-02f,
  2.26644903e-01f, 1.55206965e-02f, 2.37342827e-02f, -2.09681187e-02f, 1.12502359e-01f, 2.89736167e-02f, 3.08227651e-02f, 1.07779726e-01f, -1.05344318e-01f, 6.47064373e-02f,
  1.77044123e-01f, 3.35745901e-01f, -3.77021253e-01f, 2.10649773e-01f, -1.96928792e-02f, 8.31454471e-02f, -4.21726257e-01f, -3.67723078e-01f, 4.29257482e-01f, -1.80276290e-01f,
  -3.47316831e-01f, 2.19284952e-01f, -3.28607410e-01f, 1.45004377e-01f, 1.73874050e-01f, 4.07631457e-01f, 3.44997048e-01f, 2.85985202e-01f, -2.76472032e-01f, 2.68099725e-01f,
  -6.40361756e-02f, 2.55564302e-01f, -3.83379549e-01f, 1.02215692e-01f, -9.65152693e-04f, -8.92353952e-02f, 3.35211493e-02f, 1.83872506e-01f, 1.02361478e-01f, 1.10851489e-01f,
  3.99576098e-01f, -3.75894196e-02f, -2.14106679e-01f, -3.56750101e-01f, -1.76849455e-01f, 1.07828945e-01f, -4.23979253e-01f, 2.14315370e-01f, -1.06347740e-01f, -1.44070819e-01f,
  -1.76096976e-01f, -8.31404030e-02f, -1.84102759e-01f, 2.53184065e-02f, 8.57843012e-02f, -1.28826454e-01f, -1.25467479e-01f, -1.29144818e-01f, 5.42597830e-01f, -2.14783862e-01f,
  -1.58369347e-01f, -1.08108856e-01f, -7.99733624e-02f, 8.88655260e-02f, 1.64685282e-03f, 2.57604927e-01f, 1.92726851e-02f, -8.51143524e-02f, -2.80282926e-02f, 2.12323554e-02f,
  -1.12992458e-01f, -5.18542342e-02f, 2.93429997e-02f, 1.36650838e-02f, 2.65822291e-01f, 1.20583707e-02f, 1.25032039e-02f, -1.55376522e-02f, -1.33032650e-01f, -1.16691710e-02f,
  -6.79064691e-02f, -1.61990851e-01f, -1.11332998e-01f, -1.29630744e-01f, -1.10247999e-01f, -1.42211765e-01f, -7.63544887e-02f, 8.82896855e-02f, -2.66444206e-01f, -1.64355323e-01f,
  4.97768939e-01f, -1.23884395e-01f, 1.71096340e-01f, -4.19606753e-02f, -1.33722769e-02f, -1.57603305e-02f, 2.64390826e-01f, -8.24238956e-02f, -1.59552395e-01f, -8.20360184e-02f,
  9.65328142e-02f, 2.23494526e-02f, -1.76230267e-01f, 4.79337424e-02f, 4.22672816e-02f, -7.82016888e-02f, 1.15417801e-02f, 1.03746794e-01f, 1.81435481e-01f, 9.87637490e-02f,
  1.00389220e-01f, 4.58306633e-02f, 1.44796565e-01f, 1.38506740e-01f, -5.37904277e-02f, -5.55841140e-02f, 2.53861975e-02f, -5.57458401e-02f, -7.38038272e-02f, 1.10556632e-01f,
  1.00425713e-01f, 1.41492963e-01f, 1.13532357e-01f, -1.41745001e-01f, -2.25504581e-02f, -6.89304769e-02f, 2.83608377e-01f, 7.03549990e-03f, 9.37977899e-03f, 1.76509500e-01f,
  2.73720652e-01f, 9.84976068e-02f, 7.04431441e-03f, -9.36126933e-02f, 3.01789213e-02f, -3.27235423e-02f, 1.55250728e-01f, -9.73830074e-02f, 3.83169763e-02f, -1.61671266e-01f,
  3.15855920e-01f, -1.63951620e-01f, -2.14071363e-01f, -2.60555565e-01f, 8.74969065e-02f, -2.59580016e-01f, 9.81118754e-02f, -5.96071891e-02f, -1.29979208e-01f, 1.62174582e-01f,
  1.90961838e-01f, -8.12228471e-02f, -3.88550878e-01f, -3.01904261e-01f, -1.98355064e-01f, -2.52529397e-04f, 4.18929189e-01f, -9.12733227e-02f, 1.55115128e-01f, 3.97165455e-02f,
  -9.32739396e-03f, -2.58369148e-01f, -2.75484741e-01f, 4.42061692e-01f, -7.31939822e-02f, -1.11384988e-01f, -3.20119470e-01f, -9.63688176e-03f, -3.09240147e-02f, -4.36764695e-02f,
  3.74679536e-01f, -1.46253556e-01f, -1.32317409e-01f, 2.29806453e-01f, -8.68530013e-03f, 1.12316236e-01f, -1.21693954e-01f, 1.66172132e-01f, -2.22655892e-01f, -9.02028456e-02f,
  5.98266125e-01f, -9.38922241e-02f, -1.30539328e-01f, -9.49092060e-02f, 3.82024646e-01f, -1.54531598e-01f, -5.40033020e-02f, 2.74899721e-01f, 2.16934770e-01f, -9.25236568e-02f,
  3.79743869e-03f, -9.07712802e-02f, 2.04366967e-01f, -1.09088272e-01f, -1.60185739e-01f, -1.81971505e-01f, -2.58146822e-02f, -9.62826833e-02f, 6.42759204e-02f, -2.29581892e-02f,
  -4.50538136e-02f, -1.23603247e-01f, -7.36682042e-02f, -2.12153926e-01f, -4.55391370e-02f, -7.72821158e-02f, 3.10544521e-02f, -1.36118755e-01f, -2.85491664e-02f, -1.01771262e-02f,
  -9.87777486e-02f, 3.56370449e-01f, -1.71909750e-01f, 1.40217170e-01f, 4.59350459e-02f, -1.37207404e-01f, -3.03828537e-01f, -5.73432595e-02f, -3.34324576e-02f, -4.57748957e-02f,
  -5.88819683e-02f, -3.46247144e-02f, 1.10897280e-01f, 2.00833172e-01f, -4.94642444e-02f, -1.60645822e-03f, -8.42130631e-02f, -1.00405969e-01f, 1.42014213e-02f, -1.17646337e-01f,
  3.45143490e-02f, 6.55423151e-03f, 3.44705284e-02f, -1.38054430e-01f, -1.01866685e-01f, 1.71495005e-02f, 1.37057966e-02f, 1.08651966e-02f, -8.79314318e-02f, -2.97413260e-01f,
  2.30192649e-03f, 1.75071470e-02f, 3.86490114e-02f, 1.40358672e-01f, -4.80077714e-02f, -2.29047853e-02f, -7.75110275e-02f, 1.42743558e-01f, 1.93922296e-01f, 2.37363726e-01f,
  8.08562785e-02f, 5.82708009e-02f, 4.75103520e-02f, 1.69333309e-01f, 2.79664379e-02f, -9.88726020e-02f, 1.09304577e-01f, -4.78606224e-02f, -1.56707689e-01f, 6.45979047e-02f,
  2.62931615e-01f, 2.23356001e-02f, 4.05023247e-02f, 2.53233239e-02f, 1.26630113e-01f, -5.02564944e-02f, -1.28741711e-01f, 4.89482552e-01f, 1.55804470e-01f, -2.85261981e-02f,
  2.01366082e-01f, -3.32159877e-01f, 2.80916184e-01f, -1.07721440e-01f, 2.08540872e-01f, 1.36976168e-01f, 5.21429121e-01f, -4.02032077e-01f, 2.33174533e-01f, -3.58296275e-01f,
  8.10393542e-02f, 9.75066796e-02f, -3.08294624e-01f, -1.10654913e-01f, -3.55177164e-01f, 4.64287475e-02f, 1.06315978e-01f, 3.56532037e-02f, -6.23808987e-02f, 2.04838946e-01f,
  -1.32797197e-01f, 2.23616678e-02f, -2.06154436e-01f, -3.07419747e-01f, -3.01670849e-01f, -2.87322789e-01f, 4.33723003e-01f, -2.17913628e-01f, -1.33313149e-01f, -2.18116436e-02f,
  2.33787701e-01f, -2.30347827e-01f, 8.47330466e-02f, 1.05996765e-01f, -1.03256911e-01f, -8.31745863e-02f, 9.50367749e-02f, -6.06000423e-02f, -4.72820587e-02f, -1.49658211e-02f,
  -3.03038694e-02f, -1.19320467e-01f, -9.11318511e-03f, -7.70732202e-03f, -1.57241240e-01f, -4.83487546e-02f, -9.36957747e-02f, 9.10217762e-02f, -3.37674022e-02f, 3.41239222e-03f,
  4.11870144e-02f, -7.99837634e-02f, -1.16319008e-01f, -6.88310340e-02f, 2.76519675e-02f, -7.93340337e-03f, 2.55398843e-02f, -2.51916088e-02f, 1.69461012e-01f, -9.43818390e-02f,
  -1.75908968e-01f, -4.42513041e-02f, -1.24049924e-01f, -1.21229388e-01f, -1.34378403e-01f, 4.43778634e-01f, -8.72357264e-02f, 1.98128164e-01f, 7.95791000e-02f, 2.55850911e-01f,
  1.35350659e-01f, -2.16699302e-01f, -5.41599132e-02f, 1.06770895e-01f, 4.64832395e-01f, -7.30854198e-02f, -1.13907501e-01f, -2.10912198e-01f, -9.16741043e-02f, -1.32500315e-02f,
  -8.55869905e-04f, 2.17571795e-01f, 2.12523818e-01f, -5.82024194e-02f, -5.73625937e-02f, 1.08894750e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  3.59247401e-02f, -1.51782297e-02f, 1.35205602e-02f, 6.46991879e-02f, 3.34922224e-02f, 3.56992260e-02f, -7.91829526e-02f, 2.01797616e-02f, -4.99394871e-02f, -6.12636395e-02f,
  -9.08096656e-02f, 7.94964433e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 38, 52
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        128, 12
    );
    }
    