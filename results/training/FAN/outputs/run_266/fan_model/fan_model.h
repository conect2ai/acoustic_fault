/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 3 x 120)
const int L0_fan_Wp_rows = 3;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -3.91486168e-01f, -4.68231589e-02f, 1.58935994e-01f, -3.09100479e-01f, -1.31340316e-02f, 1.35028452e-01f, 1.03285000e-01f, -1.73257649e-01f, -2.31711701e-01f, -9.93550569e-02f,
  -8.97950307e-02f, -5.25142327e-02f, 1.25717789e-01f, 1.72197714e-01f, 1.08296297e-01f, 1.64574623e-01f, -7.63171762e-02f, -4.46537174e-02f, 5.32754734e-02f, -1.49347454e-01f,
  -8.45655575e-02f, 1.95744149e-02f, 1.50077045e-01f, -5.83972968e-02f, -5.90246208e-02f, -9.69903246e-02f, -7.03353062e-02f, -1.96664259e-02f, 6.66333511e-02f, 1.20189928e-01f,
  1.22379251e-02f, -1.95886329e-01f, 6.28466010e-02f, 5.12434577e-04f, -8.09773430e-02f, -1.53557565e-02f, -2.77440771e-02f, 1.18942894e-01f, 2.22981330e-02f, 1.65042318e-02f,
  1.95048582e-02f, 2.82096746e-03f, -1.53997382e-02f, 8.15771520e-02f, -4.73075174e-03f, 3.78073528e-02f, 1.87808671e-03f, 5.66715449e-02f, -4.70295129e-03f, -4.17375471e-03f,
  3.41602899e-02f, 6.08764254e-02f, 1.97354592e-02f, 3.00593190e-02f, 4.46055196e-02f, 6.31158799e-02f, 2.41102558e-02f, 3.65953073e-02f, -3.91889773e-02f, -5.51118925e-02f,
  -5.80755807e-03f, -2.72666886e-02f, -2.08066944e-02f, 4.81170528e-02f, -1.56263597e-02f, -2.97266226e-02f, 1.32058300e-02f, -4.29614969e-02f, 1.37117840e-02f, -8.02978873e-02f,
  -3.60876210e-02f, -7.91927576e-02f, -1.92184877e-02f, -2.15775445e-02f, -4.04748246e-02f, -6.82965741e-02f, 3.26157026e-02f, -3.29780579e-02f, -3.14475177e-03f, -5.83361909e-02f,
  -3.82412635e-02f, 1.90153590e-03f, -5.00525488e-03f, -1.13968819e-03f, 2.02027187e-02f, 1.44354869e-02f, -2.83053089e-02f, -1.59391612e-02f, 9.07597784e-03f, 6.18059281e-03f,
  -8.65612924e-02f, -3.82157952e-01f, 1.60421077e-02f, -7.27479681e-02f, 4.94210310e-02f, 3.54062989e-02f, -2.75945012e-02f, -2.80018225e-02f, 1.05177492e-01f, -5.20017259e-02f,
  1.07323816e-02f, -4.32725996e-02f, -2.80919895e-02f, 1.39541849e-02f, -1.43419122e-02f, 6.42160559e-03f, -1.28809158e-02f, -1.89439412e-02f, -6.65900037e-02f, -4.98065203e-02f,
  -8.68284106e-02f, -2.16612611e-02f, 4.20589335e-02f, -8.89136270e-02f, 2.98237661e-03f, -3.20608094e-02f, -4.96030375e-02f, -1.03254747e-02f, 2.01679580e-03f, 1.44380564e-02f,
  -5.24109542e-01f, 2.53587633e-01f, -2.41289422e-01f, 3.16892236e-01f, -6.70060366e-02f, -7.49566257e-02f, 4.89117168e-02f, 7.58121014e-02f, 2.80949976e-02f, 1.22488812e-01f,
  2.03097984e-02f, -6.57399893e-02f, -1.01524591e-02f, 2.12589920e-01f, -1.68258831e-01f, 1.49011075e-01f, 4.92641069e-02f, 4.29568291e-02f, 8.40430707e-02f, -5.80384582e-03f,
  -7.74583071e-02f, 1.67061985e-01f, -1.67372808e-01f, 8.48841667e-02f, -6.47513494e-02f, -8.99170190e-02f, 3.45653035e-02f, -8.61643441e-03f, -1.71175115e-02f, 1.24905938e-02f,
  -1.48276731e-01f, 6.54784739e-02f, -4.32034843e-02f, -5.60503267e-02f, -7.41905421e-02f, -8.05303231e-02f, -5.32632321e-02f, -1.53313950e-02f, -4.96128714e-03f, -6.78704008e-02f,
  -1.63760595e-02f, 2.00509503e-02f, 2.22932287e-02f, 2.71956865e-02f, 6.99814968e-03f, -6.83928933e-03f, -1.19376052e-02f, 1.47354798e-02f, -3.28358710e-02f, -2.16052607e-02f,
  -4.03076299e-02f, -3.02052293e-02f, -1.30200880e-02f, -3.48307937e-02f, -2.81738378e-02f, 7.52218962e-02f, -2.29450893e-02f, -3.01722903e-02f, -3.69571373e-02f, -5.37432805e-02f,
  -3.43860649e-02f, -6.31818846e-02f, -2.74781641e-02f, 6.95837885e-02f, 2.35473504e-03f, 4.45106160e-03f, -1.89941917e-02f, -3.34643498e-02f, -9.49706510e-03f, 4.78058569e-02f,
  1.39253261e-03f, 3.32877710e-02f, 2.48134765e-03f, -8.44238233e-03f, 2.75323447e-02f, 3.36763784e-02f, 1.51286768e-02f, -3.63027155e-02f, 2.47169435e-02f, 4.67771478e-03f,
  6.90453723e-02f, -4.30561267e-02f, 2.46378407e-02f, -3.90879624e-03f, -6.66320836e-03f, -7.09219091e-03f, -3.19370534e-03f, -1.88845340e-02f, -1.83977326e-03f, -3.59003171e-02f,
  9.60650221e-02f, 2.55372878e-02f, 3.10409442e-02f, 9.62762162e-03f, 1.05561325e-02f, 3.46569903e-02f, 5.73149584e-02f, -1.98337296e-03f, 2.73462459e-02f, 5.16352849e-03f,
  -6.96402267e-02f, 7.99933972e-04f, -7.52352551e-02f, -4.11327323e-03f, 7.21887639e-03f, 6.52990770e-03f, 2.03225091e-02f, 2.93270079e-03f, -5.37763489e-03f, 2.08710954e-02f,
  6.00991845e-02f, 1.23436730e-02f, 5.20535232e-03f, 2.92272512e-02f, -3.94646870e-03f, -2.15007477e-02f, -1.91728380e-02f, -1.37291523e-02f, -7.30220899e-02f, 2.86089852e-02f,
  8.37741196e-02f, -9.15316939e-02f, 2.19972149e-01f, -1.53650954e-01f, 6.61538392e-02f, -3.40060741e-01f, -2.10279852e-01f, 7.08134770e-02f, 1.42625580e-02f, -1.63593099e-01f,
  -2.51660317e-01f, 1.26512885e-01f, -8.36190581e-02f, -2.41996557e-01f, -1.73721477e-01f, -7.55146444e-02f, -3.10743302e-01f, -1.49787292e-01f, 1.76427171e-01f, -8.38954821e-02f,
  1.16067924e-01f, -3.17692190e-01f, 1.91718359e-02f, 3.37991267e-02f, -6.89753890e-02f, 2.30364636e-01f, -9.03848261e-02f, 1.63586080e-01f, -1.09727368e-01f, -2.47152317e-02f,
  -1.57228112e-01f, 1.13890864e-01f, 3.37083749e-02f, 8.27415437e-02f, -8.80110785e-02f, -4.61296700e-02f, -8.34850073e-02f, 4.43054549e-02f, 5.45532927e-02f, 4.74504419e-02f,
  -1.05168426e-03f, 2.41029654e-02f, -1.56793911e-02f, 4.94899042e-02f, 1.95060968e-02f, 1.04847290e-01f, 7.81864375e-02f, -3.46123129e-02f, 7.15724602e-02f, -2.52201352e-02f,
  3.47172506e-02f, -1.03707522e-01f, -1.65059939e-02f, -1.15182269e-02f, 1.21004684e-02f, 1.82514843e-02f, -3.65128331e-02f, -1.42180230e-02f, 3.94404819e-03f, 1.23588613e-03f,
  -1.93346590e-02f, 1.22563392e-02f, 3.21499519e-02f, -2.93158162e-02f, -6.23398926e-03f, -2.12133769e-02f, 2.52759680e-02f, -8.80526938e-03f, -2.89021041e-02f, 3.77047900e-03f,
  -4.07093503e-02f, 1.73309222e-02f, -1.27085708e-02f, -1.32890763e-02f, -5.08335158e-02f, -2.27139015e-02f, 3.53265740e-03f, 5.58694005e-02f, -1.48862274e-02f, 2.88494164e-03f,
  -3.21741700e-02f, 5.38299344e-02f, -3.53281125e-02f, -7.89326057e-02f, -6.68553934e-02f, 1.28687744e-03f, 5.81423845e-03f, 4.12997790e-02f, -2.04465538e-02f, 5.19825183e-02f,
  -1.12424985e-01f, 2.72208769e-02f, 4.69077080e-02f, -1.46248545e-02f, 3.07591856e-02f, 5.37629751e-03f, -4.26647067e-03f, -1.32044666e-02f, 6.22702837e-02f, -1.35640064e-02f,
  -5.84434420e-02f, 7.77714234e-03f, -4.10025902e-02f, -2.19032709e-02f, 3.03076170e-02f, -2.75374781e-02f, -5.60837612e-02f, -1.55324508e-02f, -2.09666719e-03f, 2.86740121e-02f,
  2.41137147e-02f, -4.18378823e-02f, 6.05219491e-02f, -5.53582460e-02f, -2.95476746e-02f, -9.28654596e-02f, -9.67559498e-03f, -2.66629388e-04f, 2.29967702e-02f, -3.09186690e-02f
};

// L0_fan_Wp_bar (Shape: 26 x 120)
const int L0_fan_Wp_bar_rows = 26;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  6.71133101e-02f, 2.03394637e-01f, 1.89066097e-01f, 8.44167620e-02f, 1.14826150e-01f, -1.63175300e-01f, -3.42996977e-02f, 1.57848179e-01f, 2.40846157e-01f, 9.24092978e-02f,
  -1.29162565e-01f, 3.14548135e-01f, -2.17249647e-01f, -8.64214450e-02f, -4.47527260e-01f, -3.53471994e-01f, -1.64565653e-01f, -4.37241010e-02f, -5.08804712e-03f, -2.54708529e-02f,
  -1.28690109e-01f, -2.42532685e-01f, -1.43168524e-01f, -6.92885593e-02f, 5.81739917e-02f, 2.37634405e-01f, -1.42802373e-01f, -7.59656280e-02f, 1.19537212e-01f, -3.44192833e-02f,
  6.48670197e-02f, 2.17210427e-02f, 1.37373671e-01f, 7.73464367e-02f, 2.19336920e-03f, -2.88050482e-03f, -6.33378997e-02f, -7.48601481e-02f, -5.10973930e-02f, 2.41520703e-02f,
  -1.27816701e-03f, 3.49412411e-02f, -4.21960559e-03f, -3.05151567e-02f, 1.81914404e-01f, 6.21971935e-02f, 1.42330199e-01f, 6.96111843e-02f, 7.62749314e-02f, -2.54627857e-02f,
  1.11423969e-01f, 6.17857575e-02f, -5.37216477e-02f, -2.57302057e-02f, -3.24018411e-02f, 9.29126143e-02f, 1.28227230e-02f, -7.70582166e-03f, 7.02273846e-02f, 7.24609420e-02f,
  -1.12446152e-01f, -6.06299751e-03f, -3.21915112e-02f, 1.61228195e-01f, -3.50501426e-02f, 6.60014339e-03f, -1.11601420e-01f, 2.22044121e-02f, 1.70308258e-02f, -5.28346784e-02f,
  1.64088719e-02f, 3.61972377e-02f, 2.62953434e-02f, -2.91750375e-02f, -9.42173973e-02f, 7.24403560e-02f, -3.33876200e-02f, 6.30704984e-02f, -4.32359315e-02f, -1.00296075e-02f,
  6.69211447e-02f, 1.70463268e-02f, 7.89262429e-02f, -7.38961399e-02f, 4.67246100e-02f, 1.78135633e-02f, -1.80451311e-02f, 5.12416661e-02f, -7.32488781e-02f, -1.51463315e-01f,
  -1.98549092e-01f, -2.31236354e-01f, -9.45681185e-02f, 2.21637990e-02f, -2.01626178e-02f, -3.46673317e-02f, -7.29393438e-02f, 3.46276872e-02f, -2.27639638e-02f, 1.82411671e-02f,
  4.59725633e-02f, 8.82556941e-03f, -5.35610244e-02f, -5.15150763e-02f, -3.08972993e-03f, -2.98334621e-02f, -2.83390991e-02f, -2.87444307e-03f, -7.73493648e-02f, -5.04427440e-02f,
  -1.97845586e-02f, -5.81197720e-03f, 1.76103339e-02f, 1.20965578e-02f, -7.84574375e-02f, 6.76971599e-02f, 9.47940536e-03f, 4.82980795e-02f, -1.10707069e-02f, 3.20678949e-02f,
  -6.20023832e-02f, 1.64015323e-01f, 2.39246964e-01f, 1.79785907e-01f, -1.42120525e-01f, -3.51583391e-01f, -2.44357049e-01f, 9.81657803e-02f, -1.71025455e-01f, -5.10623008e-02f,
  -7.44752362e-02f, -1.01559772e-03f, -1.85627230e-02f, -5.57428189e-02f, -2.66932011e-01f, -1.26430631e-01f, -8.30685645e-02f, -1.56127781e-01f, -2.29667779e-02f, 2.50714749e-01f,
  1.15247935e-01f, 7.41474032e-02f, 1.89221919e-01f, 1.01221815e-01f, 9.16695669e-02f, 3.00306231e-01f, 1.88080892e-01f, 9.27709565e-02f, 1.94910213e-01f, -1.60144180e-01f,
  -1.11036539e-01f, 1.95316896e-02f, -1.01218082e-03f, -4.36768979e-02f, 8.11067149e-02f, 4.94729690e-02f, 5.11177853e-02f, -4.93729673e-02f, 6.34662621e-03f, 3.52725200e-02f,
  -2.95773353e-02f, 8.01000372e-02f, -8.10450837e-02f, -8.72927681e-02f, -6.17815368e-02f, 5.37612475e-02f, -7.74408281e-02f, 6.13171980e-02f, -1.43920351e-02f, -4.96599041e-02f,
  4.16015759e-02f, 5.19942939e-02f, 1.01371117e-01f, -1.58422943e-02f, 1.28425928e-02f, -8.60793702e-03f, 9.95695032e-03f, 2.64172107e-02f, -1.81081928e-02f, -8.22633598e-03f,
  -7.48193706e-04f, 5.12208454e-02f, -5.41195013e-02f, -2.83374544e-02f, -1.47289541e-02f, -9.19797458e-03f, -4.74613011e-02f, -5.09693585e-02f, 5.58707304e-02f, -7.96677992e-02f,
  -3.32021364e-03f, 3.03196609e-02f, -6.38222471e-02f, -5.03256433e-02f, 2.75700130e-02f, 3.64930406e-02f, 5.71343675e-02f, 4.20558313e-03f, 4.31032144e-02f, -1.60224717e-02f,
  2.41263341e-02f, -3.00116818e-02f, 4.09174375e-02f, -3.36955041e-02f, -6.54633790e-02f, 3.76211256e-02f, 5.14001884e-02f, -3.29391733e-02f, -2.43854267e-03f, -6.25166297e-02f,
  4.83422577e-02f, 1.89314753e-01f, 9.67624411e-02f, -1.22214526e-01f, 2.60474160e-02f, -9.45105627e-02f, -7.91154578e-02f, -9.36939195e-02f, 9.82397124e-02f, -9.58810896e-02f,
  5.30482689e-03f, 9.55748484e-02f, 1.58478320e-02f, -6.49758503e-02f, 4.59624790e-02f, -5.23908883e-02f, 1.44615062e-02f, -6.34505749e-02f, 8.48192498e-02f, 1.05112486e-01f,
  1.23890378e-01f, -1.31681859e-01f, -1.14058159e-01f, -3.00430786e-02f, 5.44000082e-02f, 4.56367098e-02f, -2.34739520e-02f, 2.01717466e-02f, -5.57134906e-03f, -6.88393191e-02f,
  1.70365661e-01f, 1.00883387e-01f, 6.87514171e-02f, 4.59035710e-02f, 5.21977954e-02f, -4.15416919e-02f, 5.73898247e-03f, 3.86816449e-02f, 3.73659916e-02f, 4.64945426e-03f,
  -3.65121625e-02f, 1.12531811e-03f, 5.48078259e-03f, 1.85431764e-02f, 6.29172474e-03f, -7.72719905e-02f, -4.43015713e-03f, 1.15021162e-01f, 3.13003175e-03f, 4.81651127e-02f,
  -4.71430980e-02f, 6.85067475e-03f, -1.01391308e-01f, -5.33324964e-02f, 2.29391344e-02f, -4.72768061e-02f, -8.49228948e-02f, 9.41815600e-03f, -7.60744289e-02f, -9.02829468e-02f,
  1.06472857e-01f, 5.11456728e-02f, -3.83953899e-02f, -4.49263714e-02f, -1.07783312e-02f, 2.38771737e-03f, 4.16676812e-02f, 6.20216765e-02f, 4.50388994e-03f, 9.26935673e-02f,
  -1.48923630e-02f, 1.99792758e-02f, -1.04561001e-02f, -6.72842935e-02f, -7.19096586e-02f, 3.10104042e-02f, 1.00233324e-01f, -2.43852008e-02f, 7.71172121e-02f, 6.91230595e-03f,
  -1.97446737e-02f, 1.68138985e-02f, -4.57637534e-02f, 2.77536921e-02f, 7.14831501e-02f, -7.12225437e-02f, -5.45560103e-03f, -7.90182203e-02f, -7.80587420e-02f, 2.09597182e-02f,
  -3.33814062e-02f, -7.49863982e-02f, 4.59421724e-02f, 6.10726848e-02f, -7.88352415e-02f, 4.08685170e-02f, 6.49933517e-02f, -6.59122318e-02f, -2.07636375e-02f, -9.27365050e-02f,
  -9.41962525e-02f, 4.94291410e-02f, -7.14132488e-02f, -7.03788623e-02f, 2.10335404e-02f, -1.57451723e-02f, -9.06223282e-02f, 5.51137328e-02f, 8.29082951e-02f, 1.17626227e-03f,
  1.99541729e-02f, -5.81464777e-03f, 2.01699510e-02f, 9.29263458e-02f, -7.24236742e-02f, -4.21857722e-02f, 6.95067868e-02f, -1.03224218e-02f, -1.74975337e-03f, 1.46001205e-02f,
  -6.49349242e-02f, 3.81610990e-02f, 4.45607863e-02f, 2.83885468e-02f, -9.56045315e-02f, 8.63639042e-02f, 3.81174572e-02f, -4.38401327e-02f, 4.07206751e-02f, -7.66140074e-02f,
  3.58305336e-03f, -2.72764266e-02f, 1.84306279e-02f, 8.35727751e-02f, 4.86553460e-02f, 7.04591870e-02f, -6.89885244e-02f, -5.50379045e-02f, 4.93352152e-02f, -7.84829259e-02f,
  -1.54779404e-02f, 9.64426026e-02f, 7.64999771e-03f, 9.29014087e-02f, -1.04791969e-01f, -3.53528522e-02f, 3.91231328e-02f, -6.59957603e-02f, -1.01509310e-01f, 4.70979996e-02f,
  -2.82780267e-02f, 2.36523643e-01f, 1.30347326e-01f, 1.42194733e-01f, -1.59644369e-05f, 2.95128673e-01f, 3.00165057e-01f, 1.55417040e-01f, 2.68660665e-01f, 8.76988322e-02f,
  -5.99128492e-02f, 1.50442168e-01f, -7.55643398e-02f, 1.67106241e-01f, 2.54836261e-01f, 1.01648897e-01f, 2.72036493e-01f, 1.25579357e-01f, 4.29758504e-02f, 5.62140122e-02f,
  -5.21084107e-02f, -2.53849663e-02f, -2.50835419e-01f, -3.33374768e-01f, -1.02844991e-01f, -2.96777278e-01f, -1.73297375e-01f, -1.45795971e-01f, -9.47921872e-02f, -4.45125289e-02f,
  -4.62870039e-02f, -4.21556383e-02f, -1.20898355e-02f, -7.21110776e-02f, -3.96808088e-02f, -6.98504671e-02f, -3.82214859e-02f, -9.36267711e-03f, 4.75985184e-02f, -5.57388477e-02f,
  8.48967135e-02f, 2.44652890e-02f, 6.34970441e-02f, 2.91670281e-02f, 8.67291689e-02f, -5.53283095e-02f, 9.03669558e-03f, -1.91227682e-02f, -5.02385981e-02f, -1.03325896e-01f,
  2.09484659e-02f, 2.45623533e-02f, 2.03485377e-02f, -8.06703418e-02f, -8.47297162e-02f, -6.38239086e-03f, -2.25289539e-02f, -4.08871248e-02f, 3.03802397e-02f, -2.55986955e-02f,
  5.04549295e-02f, 1.43365609e-03f, 3.08123957e-02f, -7.07779601e-02f, -3.49391960e-02f, -5.30561954e-02f, -3.05200256e-02f, -9.63848680e-02f, -4.43556085e-02f, -4.74737324e-02f,
  4.33473662e-02f, 1.17682396e-02f, 8.00760686e-02f, -4.79530320e-02f, 9.99676287e-02f, 1.53996078e-02f, 5.42720817e-02f, -4.20141667e-02f, 3.26735936e-02f, -5.62846549e-02f,
  6.33623675e-02f, -5.56388125e-02f, -3.15941386e-02f, -6.37804568e-02f, -3.92514989e-02f, -2.71653384e-02f, -8.47293362e-02f, -4.87233289e-02f, 5.56598864e-02f, -6.66838279e-03f,
  9.88343656e-02f, 2.26181537e-01f, -1.23955697e-01f, -4.14203480e-03f, 5.04004396e-02f, 2.34592520e-03f, 5.12215011e-02f, 7.95862637e-03f, 1.15396269e-01f, 4.25793007e-02f,
  5.12379445e-02f, -2.84927282e-02f, -3.98483314e-02f, -5.76659106e-02f, -4.29766588e-02f, 6.37254342e-02f, 5.75908981e-02f, 7.97560588e-02f, -4.63602785e-03f, -1.57813856e-03f,
  -6.87248111e-02f, 1.29318222e-01f, 5.40533066e-02f, -1.71742740e-03f, 3.28403674e-02f, -3.22179198e-02f, -1.47817181e-02f, 1.71704888e-02f, -2.40969360e-02f, 8.76452252e-02f,
  2.92706221e-01f, -2.49968678e-01f, 2.11893514e-01f, 2.70812899e-01f, 2.25042984e-01f, 3.85374278e-02f, 1.48646027e-01f, 8.99717361e-02f, 2.09952727e-01f, -2.88540393e-01f,
  -7.12131187e-02f, -8.49018395e-02f, -1.06801987e-01f, 6.16678745e-02f, 1.73448965e-01f, 2.72160931e-03f, 3.35417725e-02f, 6.67447448e-02f, 1.11987412e-01f, 8.76192078e-02f,
  1.48423865e-01f, -7.11319745e-02f, -1.56932082e-02f, -1.03740804e-01f, 6.11760020e-02f, -1.16977558e-01f, -1.02911316e-01f, -1.04282871e-01f, -1.05513848e-01f, 7.79487342e-02f,
  8.46607052e-03f, 8.82883221e-02f, -3.48170884e-02f, -2.42216829e-02f, -9.66296904e-03f, -8.16219971e-02f, -6.13310970e-02f, -7.15300441e-02f, 9.87810642e-02f, 7.58871287e-02f,
  -8.26727226e-02f, 8.13805908e-02f, 1.13865724e-02f, 5.53275347e-02f, 5.01929931e-02f, 2.68010963e-02f, 9.84309539e-02f, -1.87712200e-02f, 7.28990138e-02f, -3.27513143e-02f,
  4.08638418e-02f, 4.96304147e-02f, 3.20095867e-02f, 1.28073618e-02f, 4.35537249e-02f, 5.80679700e-02f, 5.94317541e-02f, -6.92620501e-02f, 5.27237654e-02f, 6.89307377e-02f,
  -8.16131607e-02f, 8.71191919e-03f, -4.27661464e-02f, 4.86425422e-02f, -1.59137100e-02f, 5.78897633e-02f, -1.38444146e-02f, 9.05137286e-02f, 6.72011971e-02f, 7.10129924e-03f,
  -6.27531037e-02f, 4.95695742e-03f, 3.95269245e-02f, -5.99853098e-02f, -6.47445023e-02f, 6.67377412e-02f, -3.83763127e-02f, -1.47750899e-02f, 4.43798713e-02f, 6.71420852e-03f,
  -3.29109794e-03f, 1.89118609e-02f, 7.54294777e-03f, 3.19359079e-02f, -6.80102482e-02f, -6.43091053e-02f, -5.72837107e-02f, -8.16961080e-02f, 2.51908414e-02f, -5.91569655e-02f,
  -1.01209544e-01f, -1.08001404e-01f, 4.01040949e-02f, -3.32566630e-03f, -7.38965347e-02f, -1.47121340e-01f, -3.41666155e-02f, 7.02892169e-02f, -6.40210435e-02f, 2.74532381e-02f,
  -7.05903247e-02f, -1.78042834e-03f, -1.08939864e-01f, -6.97720125e-02f, -1.50695831e-01f, -8.49026591e-02f, 7.83848111e-03f, -9.49428231e-02f, -9.52752680e-02f, -8.85902867e-02f,
  4.69162507e-04f, -3.64543498e-02f, 7.84057230e-02f, -2.65808380e-03f, 1.29819093e-02f, -7.71054924e-02f, -1.17198408e-01f, 1.53549714e-02f, -1.21252328e-01f, -4.88694608e-02f,
  -2.79457197e-02f, -4.77151796e-02f, -5.65250218e-02f, 1.26468405e-01f, 3.27790342e-02f, -9.96437371e-02f, -3.06271426e-02f, 1.84502155e-02f, -1.14656486e-01f, 8.35420415e-02f,
  3.17668840e-02f, -8.64118710e-02f, 2.14171950e-02f, 6.08126223e-02f, -4.77202646e-02f, -9.23070088e-02f, -2.94358027e-03f, -3.24961878e-02f, -3.52816433e-02f, 3.77982040e-03f,
  -1.00072801e-01f, 1.43289477e-01f, -1.99930333e-02f, 5.12586646e-02f, 9.48449001e-02f, -6.07786775e-02f, 1.18458666e-01f, -1.56115238e-02f, 4.00811024e-02f, 7.70495906e-02f,
  -1.08404763e-01f, -6.89013228e-02f, -5.51442243e-02f, 6.13563880e-02f, 4.41946089e-02f, -7.11142570e-02f, -3.74163538e-02f, -1.32502289e-02f, 1.18085435e-02f, -6.62756637e-02f,
  -5.06242439e-02f, -1.81274600e-02f, 9.64296758e-02f, 8.35293159e-02f, -7.61069730e-02f, -2.21033511e-03f, -1.14477426e-02f, 3.58279943e-02f, 4.15777750e-02f, -1.24817424e-01f,
  -9.06675458e-02f, 2.98486520e-02f, -5.59639335e-02f, -8.72717500e-02f, -2.21141800e-02f, 7.02781305e-02f, 1.59492530e-02f, -1.67327486e-02f, -2.69782860e-02f, -4.40536737e-02f,
  -5.06643169e-02f, -1.94822587e-02f, 4.60265540e-02f, -3.83600295e-02f, 6.71209721e-03f, -3.49096656e-02f, -2.70872042e-02f, -6.25839038e-03f, -6.18406050e-02f, 5.86747825e-02f,
  -2.39669625e-02f, -7.07596913e-02f, -7.22456276e-02f, -2.44940519e-02f, 2.49773394e-02f, -3.02241929e-03f, 1.15716094e-02f, 5.64128347e-02f, 2.29504202e-02f, -8.28023553e-02f,
  -9.24871191e-02f, 2.46278942e-03f, -7.19573407e-04f, -7.34229684e-02f, -1.10598058e-02f, 5.49185909e-02f, -5.37159331e-02f, -9.19036120e-02f, -2.65789926e-02f, -6.40594214e-02f,
  -2.44511198e-02f, -1.92414050e-03f, 7.15873810e-03f, 9.57956631e-03f, -1.34968711e-02f, 2.21904293e-02f, 7.40320981e-02f, -2.78953388e-02f, 1.22177936e-02f, 5.75541109e-02f,
  -2.08008420e-02f, 3.31735099e-03f, -5.04844487e-02f, 7.90672936e-03f, 1.02412969e-01f, -7.37668052e-02f, -1.51455412e-02f, 4.30507958e-02f, 8.22753832e-02f, 6.53467998e-02f,
  2.96463147e-02f, 1.80857838e-03f, 3.43647748e-02f, 7.21528567e-03f, 5.14087863e-02f, -2.55118981e-02f, -4.89342175e-02f, 8.07943121e-02f, 9.80527699e-02f, -8.82094949e-02f,
  -8.45076796e-03f, 1.61396950e-01f, 3.04910600e-01f, 1.21833146e-01f, 5.61149791e-02f, 1.40267298e-01f, 1.04290657e-01f, 9.51598808e-02f, 1.99145705e-01f, -1.38063297e-01f,
  -1.82599083e-01f, 8.58695656e-02f, 7.85511434e-02f, 7.10530579e-02f, 1.47874177e-01f, 2.36657709e-02f, 8.67639855e-02f, 7.61783496e-02f, 1.22937351e-01f, 5.50898239e-02f,
  5.30006476e-02f, -2.01717049e-01f, 5.61871044e-02f, -8.17555562e-02f, -3.73161398e-02f, 2.92324964e-02f, -2.45106831e-01f, 2.09394060e-02f, -1.16815194e-01f, 8.36645439e-02f,
  -2.18003746e-02f, -7.63080036e-03f, -1.40025631e-01f, -2.45923642e-02f, 1.51506886e-02f, 2.58069001e-02f, 2.22749189e-02f, 7.77476430e-02f, 5.04285507e-02f, 2.55445316e-02f,
  -7.15839043e-02f, -8.46339241e-02f, 3.40681821e-02f, -7.52599612e-02f, -6.30880846e-03f, -4.33566272e-02f, 1.07477922e-02f, 4.35045548e-02f, -4.05371450e-02f, 7.77996629e-02f,
  6.91690445e-02f, 3.03010959e-02f, 5.81960566e-02f, 7.97366500e-02f, -3.92460674e-02f, -5.74783981e-02f, 7.28328675e-02f, -1.21909045e-02f, -3.34248655e-02f, -3.63713540e-02f,
  4.73700128e-02f, 3.53476368e-02f, -7.46196881e-02f, 3.42487246e-02f, -6.60878345e-02f, -1.45073924e-02f, -8.31170380e-02f, 2.96932198e-02f, 7.56204203e-02f, -3.87719087e-02f,
  -4.54802439e-03f, -7.63424262e-02f, 6.09341152e-02f, 6.71065077e-02f, 5.93361147e-02f, -4.85746516e-03f, -5.13636023e-02f, -3.43318805e-02f, 1.52630964e-02f, 3.53536522e-03f,
  5.01115620e-03f, -2.99005047e-03f, 3.45759988e-02f, 8.66701156e-02f, 1.08435743e-01f, 1.96101554e-02f, -2.87287682e-03f, 3.31895128e-02f, -7.13462308e-02f, -1.65331420e-02f,
  -5.93471415e-02f, -3.75494063e-02f, -8.06702301e-02f, -2.01420076e-02f, -9.23116971e-03f, -8.36634636e-02f, -5.49632311e-02f, 3.95494513e-02f, 6.28230944e-02f, -9.66604427e-03f,
  -4.18801792e-02f, 5.31244874e-02f, 1.77226104e-02f, 1.26176616e-02f, -5.33639863e-02f, 1.35282222e-02f, 7.05707371e-02f, -3.32585797e-02f, -5.66264801e-02f, 1.61619913e-02f,
  2.70379316e-02f, -4.30397578e-02f, -6.95371926e-02f, -2.10928395e-02f, 5.00993170e-02f, -3.68558876e-02f, 1.84501242e-02f, 3.83515023e-02f, -1.08876154e-02f, 1.26806116e-02f,
  -3.42824340e-01f, 4.13556546e-02f, -2.36576393e-01f, -8.32649842e-02f, 1.65310770e-01f, -1.96101889e-01f, -4.60128337e-02f, 7.10283741e-02f, -8.80485475e-02f, 2.67278820e-01f,
  9.72333699e-02f, -1.25911385e-01f, 9.57833156e-02f, -1.48535579e-01f, -6.25739872e-01f, -1.58630431e-01f, -2.52826303e-01f, -1.17686525e-01f, -1.48885578e-01f, 2.93809306e-02f,
  -1.37750417e-01f, 1.47010209e-02f, -2.26815492e-01f, 1.94407523e-01f, -5.28026894e-02f, 1.92927808e-01f, 1.85099661e-01f, 1.63632512e-01f, -6.16964735e-02f, 6.05381913e-02f,
  -3.80778164e-02f, 1.61426112e-01f, 7.48378411e-02f, -1.82003044e-02f, -7.32263401e-02f, 7.55242929e-02f, 6.33743331e-02f, 2.89605036e-02f, 2.91490313e-02f, 9.94685758e-03f,
  -2.25894190e-02f, 2.15287390e-03f, 1.26122842e-02f, 1.34060988e-02f, -1.80907976e-02f, 6.49533514e-03f, 4.97904867e-02f, -1.22309744e-01f, -2.80253906e-02f, 6.86951214e-03f,
  -6.32131845e-02f, 5.26340865e-02f, 4.80339825e-02f, 5.38352467e-02f, -8.96326900e-02f, 4.85489145e-02f, -5.43777533e-02f, -9.37409550e-02f, -6.50406480e-02f, -9.42475051e-02f,
  3.05400640e-02f, 2.18257424e-03f, 1.17608877e-02f, -4.99315485e-02f, -1.97906252e-02f, 5.46943359e-02f, 3.15500307e-03f, 1.30129661e-02f, -2.38661896e-02f, -4.64103185e-03f,
  6.93359300e-02f, -5.45563027e-02f, 2.92950310e-02f, 5.46576716e-02f, -5.63324876e-02f, 4.92144674e-02f, -4.39768424e-03f, 6.60048332e-03f, -2.44313758e-02f, -1.13727339e-01f,
  8.07672925e-03f, -2.27982588e-02f, -2.45640520e-02f, 5.93925118e-02f, -5.04627861e-02f, -1.76830939e-03f, 6.67593926e-02f, 9.68311727e-03f, 1.86102092e-02f, 2.33716145e-02f,
  1.36123896e-01f, 1.93267819e-02f, 2.45771669e-02f, 1.19022932e-02f, 1.17011905e-01f, 7.79111218e-03f, -6.50297105e-02f, -6.29941747e-02f, 3.70290689e-02f, -5.93256857e-03f,
  6.47905022e-02f, 1.66940615e-02f, 7.27030709e-02f, 5.24489060e-02f, -6.19146936e-02f, -2.89050266e-02f, -5.94076002e-03f, 2.16940865e-02f, 7.64714628e-02f, -2.43900791e-02f,
  5.67881465e-02f, 6.05097041e-02f, -2.69680843e-02f, 9.10839736e-02f, 4.32957150e-02f, 1.00398324e-01f, -4.60281633e-02f, -1.99523363e-02f, 3.44496742e-02f, 9.18500870e-03f,
  5.29997088e-02f, -1.09960243e-01f, -6.84816465e-02f, 1.23525485e-01f, 1.49673432e-01f, -1.19773030e-01f, -3.63296084e-02f, -2.34013293e-02f, -6.92836801e-03f, 6.82576895e-02f,
  1.43745905e-02f, -5.06977737e-02f, -8.13442916e-02f, -1.58783212e-01f, -3.34636979e-02f, -1.69773147e-01f, -3.06314765e-03f, -1.37497380e-01f, -1.04510384e-02f, 1.19915336e-01f,
  7.51147792e-02f, -3.02157295e-03f, 2.07039993e-04f, 1.97692379e-01f, 1.32016420e-01f, 7.31738284e-02f, 6.08095713e-02f, -2.24085022e-02f, 1.76818073e-02f, -2.75349021e-02f,
  2.16325112e-02f, -9.29506123e-03f, 1.56680755e-02f, -5.89314215e-02f, 5.28144576e-02f, 7.17948526e-02f, 9.25310776e-02f, 2.64450219e-02f, 7.10778758e-02f, -6.27542362e-02f,
  3.51684541e-02f, -8.26390181e-03f, -5.91832586e-02f, 4.59184162e-02f, 9.52929556e-02f, 5.43522090e-02f, -8.03477541e-02f, 1.49263656e-02f, 5.76871373e-02f, -9.63472426e-02f,
  -1.06661059e-02f, -4.24756110e-02f, 1.06707461e-01f, 5.01371920e-02f, 4.00267169e-02f, 1.81289520e-02f, 6.16811849e-02f, -1.54181616e-02f, -4.51450273e-02f, -7.89543837e-02f,
  6.06822148e-02f, -3.01856678e-02f, 3.59822810e-02f, -7.58066624e-02f, -1.05095364e-01f, -1.28102312e-02f, -9.96089503e-02f, -8.29155818e-02f, 4.44979891e-02f, 3.70710790e-02f,
  5.84638231e-02f, -8.04188699e-02f, -2.37294249e-02f, -3.00617535e-02f, -7.29843676e-02f, 1.81291383e-02f, -4.33498062e-02f, 4.07771543e-02f, 9.14162546e-02f, -6.81193471e-02f,
  4.41931784e-02f, 5.53581044e-02f, 1.45343971e-02f, 3.67205814e-02f, -5.00670783e-02f, 7.61769488e-02f, -7.01396493e-04f, 2.79585831e-02f, 2.38008443e-02f, -5.17993644e-02f,
  -3.61705609e-02f, -3.12961228e-02f, -7.12399036e-02f, -4.02469561e-03f, -1.34457834e-02f, 7.73283616e-02f, -5.62237464e-02f, 1.23023950e-02f, -1.44880386e-02f, -1.08654916e-01f,
  6.43301234e-02f, 1.39019459e-01f, 6.28600717e-02f, -8.31973553e-02f, 5.93505353e-02f, 5.72576486e-02f, -2.90258825e-02f, 5.61275445e-02f, 9.28447247e-02f, 7.35384747e-02f,
  3.79947126e-02f, -2.12934241e-02f, 8.17382857e-02f, -2.75763739e-02f, 5.86028472e-02f, 2.13166717e-02f, 8.05987790e-02f, 3.35408491e-04f, -5.76036945e-02f, -3.08049880e-02f,
  -1.72563046e-01f, 3.94961715e-01f, 1.24443956e-01f, 4.66405660e-01f, -3.17571700e-01f, -1.75048098e-01f, -5.39512485e-02f, 1.09195121e-01f, 9.02335718e-02f, 1.48803458e-01f,
  1.06405847e-01f, -2.27882378e-02f, 5.51157854e-02f, 4.69021738e-01f, -6.61236048e-02f, 1.58274397e-01f, 2.51707584e-01f, 1.23539843e-01f, 4.94951531e-02f, 8.77009481e-02f,
  9.66006964e-02f, 1.07744157e-01f, 2.24937841e-01f, -5.06206229e-02f, -5.51917255e-02f, 3.50124240e-02f, 4.20734026e-02f, -7.89805278e-02f, 1.23509265e-01f, -1.21274695e-01f,
  -1.38880074e-01f, 5.91854081e-02f, 1.88070182e-02f, -7.82069471e-03f, -5.80715798e-02f, -7.84102604e-02f, -5.23188673e-02f, -9.85720605e-02f, -4.67092246e-02f, 9.02055856e-03f,
  -9.48071554e-02f, -2.49570869e-02f, -1.13285854e-02f, 2.66446266e-02f, -7.17146322e-02f, 3.04407235e-02f, 2.46176384e-02f, 4.77466499e-03f, 7.77261518e-03f, -8.96824226e-02f,
  -2.51444243e-02f, -1.14772348e-02f, 5.24412952e-02f, -1.55357074e-03f, 2.87043359e-02f, -2.26342455e-02f, 2.58574914e-02f, -4.39276174e-02f, -3.63513231e-02f, 4.55530584e-02f,
  -9.91498679e-02f, 3.46581303e-02f, 6.62593022e-02f, -2.93148682e-02f, 3.99722829e-02f, -4.32561412e-02f, 1.73827130e-02f, 1.91422496e-02f, 1.36148278e-02f, -1.61918141e-02f,
  -3.36567946e-02f, -1.01630017e-02f, -2.92941965e-02f, 4.69390154e-02f, 2.81780418e-02f, -9.46993940e-03f, -1.10939190e-01f, -2.39671823e-02f, -3.35133784e-02f, 2.66899937e-03f,
  -7.51364045e-03f, 3.15617509e-02f, 9.13507119e-02f, -2.85393540e-02f, 1.39623201e-02f, -6.23766184e-02f, 1.11265048e-01f, 6.44940808e-02f, -6.24376759e-02f, 7.07332185e-03f,
  1.05480544e-01f, 2.37670243e-01f, -3.91839247e-04f, -9.92315412e-02f, -3.09591237e-02f, -4.86794040e-02f, 5.18704355e-02f, 1.23289926e-02f, 9.12595987e-02f, -2.37228330e-02f,
  3.25317355e-03f, 1.11572761e-02f, -2.75303405e-02f, -3.29138301e-02f, 5.94546795e-02f, 5.50323576e-02f, 7.51919672e-02f, -2.78641433e-02f, 5.50299212e-02f, -5.48211932e-02f,
  1.43667636e-02f, -7.16149062e-02f, -1.10033760e-03f, 3.85441864e-03f, -3.07694189e-02f, -5.35042286e-02f, -2.89800968e-02f, -4.99957912e-02f, -7.22131655e-02f, 7.38666803e-02f,
  2.16758624e-01f, -2.06800327e-01f, -2.51788288e-01f, 8.42541307e-02f, 9.88291502e-02f, 4.16334756e-02f, -1.41407192e-01f, -8.65386873e-02f, -1.63995642e-02f, -4.18107361e-02f,
  -3.60326767e-02f, -7.24999085e-02f, -2.51479089e-01f, 2.03942195e-01f, 1.24043964e-01f, -9.99864787e-02f, 1.76427305e-01f, 7.94649795e-02f, 3.14821228e-02f, -6.02737926e-02f,
  2.48578433e-02f, 2.26280704e-01f, -1.66778546e-02f, 1.16968434e-02f, 1.28474340e-01f, -8.96816775e-02f, 9.74944383e-02f, -1.58020690e-01f, 1.69073448e-01f, 1.01049982e-01f,
  2.02568546e-02f, 3.82580049e-02f, 2.22690590e-02f, 3.24114375e-02f, -9.01275203e-02f, -3.83919775e-02f, -1.71475150e-02f, 7.10235722e-03f, -2.87942607e-02f, -9.23527926e-02f,
  -5.01584038e-02f, 5.65601178e-02f, 5.26157096e-02f, -8.15308169e-02f, 6.99107274e-02f, 1.28215877e-02f, 7.75636137e-02f, -3.59614205e-04f, -5.78401014e-02f, 1.36668999e-02f,
  -9.59383138e-03f, 5.83521947e-02f, -3.40756550e-02f, -2.41031591e-02f, -1.18716903e-01f, -2.02324651e-02f, 3.62666249e-02f, -2.82848463e-03f, -3.61822955e-02f, 6.18275329e-02f,
  3.95065583e-02f, 6.68568909e-02f, -7.53104910e-02f, 9.07821581e-02f, -1.91907410e-03f, 6.36683870e-03f, 2.45633461e-02f, 1.13028266e-01f, -8.81555080e-02f, 1.05745057e-02f,
  -3.04124020e-02f, 5.03831133e-02f, -3.32729444e-02f, 2.73703467e-02f, 3.84504162e-02f, 4.15382795e-02f, 9.22706053e-02f, 4.81333472e-02f, -3.93480435e-02f, 6.08808510e-02f,
  -1.08179580e-02f, -6.46357238e-02f, -7.92780519e-02f, -6.46822080e-02f, 7.53544345e-02f, 1.61286592e-02f, -2.38770004e-02f, -3.98844667e-02f, -1.53517993e-02f, 5.24642393e-02f,
  -1.11312434e-01f, -1.78959131e-01f, -8.03212449e-02f, 7.22457394e-02f, -1.29626803e-02f, -3.10457349e-02f, -2.40672845e-02f, 1.82713401e-02f, 8.71660747e-03f, -8.83903950e-02f,
  9.54353884e-02f, 1.65324323e-02f, 3.48589569e-03f, -4.43398952e-02f, -6.12827465e-02f, -6.69393018e-02f, 3.52733806e-02f, 1.89822540e-02f, 1.43917473e-02f, 5.11280112e-02f,
  1.26603432e-02f, -3.73420976e-02f, 8.98938626e-02f, -5.22489846e-02f, 4.22523990e-02f, -9.54507217e-02f, 2.45306082e-02f, 5.06626144e-02f, 1.14170564e-02f, 1.44218439e-02f,
  4.76506263e-01f, -2.80488670e-01f, 6.07456416e-02f, 1.12155661e-01f, 2.97922671e-01f, 8.50772113e-02f, 2.08850458e-01f, -1.93466187e-01f, 1.01781406e-01f, -3.15172106e-01f,
  9.55248252e-02f, 1.51603948e-02f, -3.09206937e-02f, -2.98012719e-02f, 1.13755591e-01f, -1.45988300e-01f, 6.14675286e-04f, 7.15358108e-02f, -9.05053690e-02f, -2.05191271e-03f,
  4.01881151e-02f, -4.72472841e-03f, -1.26824349e-01f, -2.33116060e-01f, 8.56925845e-02f, -9.24322978e-02f, -3.06804944e-02f, 5.90653643e-02f, -8.20062682e-02f, -6.31834520e-03f,
  -5.50360791e-02f, 5.36475219e-02f, 7.73618743e-02f, -3.60868275e-02f, -7.38000870e-02f, -1.74836405e-02f, 3.18945311e-02f, 7.24981800e-02f, 4.06667963e-02f, -1.08429790e-01f,
  -3.85773368e-02f, 4.00738604e-03f, -2.16724873e-02f, -5.77536337e-02f, 3.53091024e-02f, 3.17322053e-02f, -1.72409718e-03f, 2.28810078e-03f, -1.11641772e-01f, 2.40926445e-02f,
  9.56206489e-03f, -4.38751876e-02f, 5.80691919e-02f, -4.13649045e-02f, 1.27887696e-01f, -4.32298668e-02f, -8.33196491e-02f, 9.99995619e-02f, -5.36956266e-02f, 5.69537617e-02f,
  -9.91190076e-02f, 1.09516300e-01f, 2.45912024e-03f, -2.40005106e-02f, 4.89321277e-02f, -4.53081578e-02f, -3.27561516e-03f, -1.19560314e-02f, 4.93305102e-02f, 6.92858920e-03f,
  8.79621208e-02f, 4.65018296e-04f, 3.92067991e-02f, 4.71445061e-02f, 3.45187373e-02f, -3.35065946e-02f, 4.68937941e-02f, 5.13915829e-02f, 9.76737440e-02f, 4.04564925e-02f,
  3.98261696e-02f, -1.65368188e-02f, 3.91585790e-02f, -1.04205392e-01f, -5.75712994e-02f, -6.04092143e-04f, -8.81249905e-02f, 1.44723179e-02f, -4.94656786e-02f, 1.08634084e-02f,
  -6.24167323e-02f, -1.31778806e-01f, 1.25074089e-02f, 1.65730435e-02f, -4.79578115e-02f, -1.28842536e-02f, 4.71594334e-02f, -8.11918154e-02f, 2.87533831e-02f, -6.25970140e-02f,
  5.42295463e-02f, 5.08586057e-02f, 1.19735468e-02f, 2.12136172e-02f, 2.00718008e-02f, -5.10168113e-02f, 6.26682937e-02f, 6.29607067e-02f, 2.74384245e-02f, 1.47756850e-02f,
  -4.22223024e-02f, 2.24135499e-02f, 1.69263761e-02f, 3.98249440e-02f, -9.05835908e-03f, 1.19269378e-02f, 7.07592396e-03f, -4.03268402e-03f, -6.43094582e-03f, -7.19424263e-02f,
  -2.49718040e-01f, 8.81126300e-02f, 1.56467538e-02f, -1.19042046e-01f, 1.19780907e-02f, 7.78282210e-02f, 6.64771944e-02f, 2.45376490e-02f, -8.80656466e-02f, -1.75595889e-03f,
  -1.68372896e-02f, 2.78936420e-02f, -3.06711886e-02f, -6.80923909e-02f, -8.20404366e-02f, 2.43347753e-02f, -7.53968656e-02f, -1.14991598e-01f, -5.02581671e-02f, 5.95289879e-02f,
  8.20674840e-03f, 1.41432537e-02f, 2.26304941e-02f, 1.37081087e-01f, -8.24400783e-02f, -8.64800587e-02f, 2.12878082e-02f, 1.41570792e-01f, -1.05409361e-01f, -9.53646451e-02f,
  -5.68580851e-02f, -1.11024790e-02f, -7.03915954e-02f, -5.63974828e-02f, -5.92285618e-02f, -7.78125003e-02f, -5.65748755e-03f, -8.17544907e-02f, -5.92380427e-02f, 2.67751068e-02f,
  -8.35401658e-03f, 8.23387038e-03f, 2.96919830e-02f, 4.39597061e-04f, 1.98215339e-02f, -6.04143441e-02f, 1.48073048e-03f, -1.51424315e-02f, -6.40257308e-03f, 7.08613768e-02f,
  9.45819542e-03f, 3.89988758e-02f, -3.82188857e-02f, -3.28015164e-02f, -8.53157192e-02f, -5.25712483e-02f, 8.87993071e-03f, -6.41086772e-02f, 2.43586767e-02f, 1.37300156e-02f,
  1.13922944e-02f, 7.10183829e-02f, -6.47939444e-02f, -1.87897142e-02f, -4.15669531e-02f, -5.02155675e-03f, -4.75627668e-02f, 4.18001451e-02f, -4.69080508e-02f, 3.88207100e-03f,
  4.46016267e-02f, -6.35106713e-02f, -3.57541591e-02f, -6.94147423e-02f, 8.33440050e-02f, 8.50574002e-02f, -3.26442160e-02f, -3.23220119e-02f, 1.59417856e-02f, -2.02383175e-02f,
  5.44234887e-02f, -6.64651021e-02f, 2.99887694e-02f, -5.96635342e-02f, -6.04077354e-02f, -9.58467200e-02f, -4.79228012e-02f, 4.97321272e-03f, -7.03378916e-02f, -4.71308455e-02f,
  -1.48703650e-01f, -7.96475783e-02f, -1.13979809e-01f, -4.15652134e-02f, 2.92676277e-02f, -1.00460403e-01f, 5.92335649e-02f, -2.55823229e-02f, -1.16673619e-01f, -2.26708818e-02f,
  -1.90671887e-02f, -6.17586225e-02f, -9.73608345e-02f, -3.99675332e-02f, -1.64382476e-02f, 7.05329105e-02f, 7.15897232e-02f, -8.58845189e-02f, 4.16664742e-02f, -8.89740661e-02f,
  3.91429700e-02f, -6.52721822e-02f, 1.71161816e-03f, 2.83486601e-02f, 4.83865291e-02f, -7.64649287e-02f, -4.01714258e-02f, 7.65616149e-02f, 6.84428439e-02f, 6.49308320e-03f,
  4.84655619e-01f, -3.32930923e-01f, -1.59843504e-01f, 3.68735343e-01f, 2.24955201e-01f, -1.87225610e-01f, -1.71815261e-01f, 2.77524263e-01f, 4.81546260e-02f, -2.33159631e-01f,
  6.01521060e-02f, -1.93294600e-01f, -3.86009514e-01f, 1.99052706e-01f, 1.56550676e-01f, -3.91166776e-01f, 1.25020012e-01f, -5.98957501e-02f, -4.00335640e-02f, 1.41800284e-01f,
  2.13287771e-01f, 2.73583740e-01f, 9.54142585e-02f, 3.18579376e-01f, 1.39863580e-01f, 2.60338396e-01f, 2.09796160e-01f, -1.27635226e-01f, 3.19556147e-01f, 5.70001416e-02f,
  5.03908992e-02f, 5.18008173e-02f, -9.20875277e-03f, -6.32608980e-02f, 1.34564871e-02f, -2.91494559e-02f, -1.52283832e-01f, -4.58311364e-02f, 3.24538685e-02f, 1.64543651e-02f,
  -6.25678152e-02f, 1.12451657e-04f, 2.37700101e-02f, 9.89715308e-02f, 6.57295287e-02f, 6.78776251e-03f, 1.34807274e-01f, 1.13847610e-02f, -8.50828271e-03f, 1.21161025e-02f,
  -1.96570810e-02f, 3.49967480e-02f, -3.42658795e-02f, -3.99083346e-02f, 1.35955857e-02f, 3.57510932e-02f, -6.51476607e-02f, -9.98063087e-02f, 9.33857784e-02f, 5.20725176e-02f,
  1.15084454e-01f, -7.49875084e-02f, -2.19634511e-02f, 8.36646780e-02f, -1.19492598e-02f, 8.04940984e-03f, 3.04825194e-02f, -7.86193386e-02f, -2.18236595e-02f, -3.53389978e-02f,
  4.24319580e-02f, 9.27514806e-02f, 5.41769229e-02f, 4.56455536e-02f, -1.73839349e-02f, -1.87092740e-02f, -3.26265022e-02f, -5.79994395e-02f, -3.46920528e-02f, 2.65646353e-02f,
  -5.85840642e-02f, 3.54516394e-02f, -7.12515190e-02f, 3.10409237e-02f, 4.61343937e-02f, -5.88319525e-02f, 6.62921667e-02f, 1.06459260e-02f, -1.28330532e-02f, -4.79637124e-02f,
  -8.49237964e-02f, -3.79445334e-03f, -2.74062715e-02f, 1.08411834e-02f, -6.71654195e-02f, -5.22979796e-02f, -3.41718458e-02f, 2.53629554e-02f, 4.53450605e-02f, 9.14211571e-02f,
  4.02646586e-02f, -3.63698937e-02f, -1.62220225e-02f, 3.07271089e-02f, 9.35489461e-02f, 5.47674336e-02f, -2.93391943e-02f, -1.90442745e-02f, -8.72292891e-02f, 1.21109644e-02f,
  -2.52403263e-02f, 6.39428869e-02f, -6.44910485e-02f, -5.62287075e-03f, 6.70600012e-02f, -3.84503007e-02f, 4.07451876e-02f, 8.94231647e-02f, -7.96653703e-02f, -1.44594209e-02f,
  8.48649666e-02f, -1.62420586e-01f, -2.80160934e-01f, -3.97050619e-01f, -2.15993017e-01f, -3.69690716e-01f, -4.38600659e-01f, -2.28715003e-01f, -3.79386209e-02f, -2.00025693e-01f,
  -1.89141706e-01f, 4.95734587e-02f, 1.22520626e-01f, -2.34107554e-01f, 1.10091075e-01f, 3.35915625e-01f, -2.65483797e-01f, -2.67085344e-01f, 1.62344754e-01f, -1.63557947e-01f,
  -2.94553582e-03f, -1.78295985e-01f, -1.50102470e-02f, -4.33180258e-02f, -1.86580807e-01f, -6.35146722e-02f, -4.81943972e-02f, 4.52185273e-02f, -2.71951526e-01f, -8.37394893e-02f,
  6.94068614e-03f, 1.23373441e-01f, -1.29885480e-01f, 4.30501103e-02f, -1.27268150e-01f, -2.42170561e-02f, -5.75464666e-02f, 5.48568815e-02f, -7.57056149e-03f, -1.03518866e-01f,
  4.02558893e-02f, 7.16788918e-02f, -2.58241352e-02f, 6.58457773e-03f, -1.55474832e-02f, -7.70307481e-02f, 2.71365214e-02f, -4.72668558e-02f, -9.35802385e-02f, 6.58145509e-05f,
  -5.30704036e-02f, -1.39134265e-02f, -1.27329394e-01f, 2.99229380e-02f, 4.86539416e-02f, -5.30238636e-02f, -4.90884148e-02f, -5.73621467e-02f, -4.30511981e-02f, -6.65515289e-02f,
  1.38735145e-01f, -9.34077520e-03f, -2.19189245e-02f, -3.56630683e-02f, -3.78389657e-02f, -2.38885265e-02f, 1.27389673e-02f, 3.64637344e-05f, -9.72191617e-03f, 5.35193831e-02f,
  3.78034376e-02f, -4.08592895e-02f, 3.49675454e-02f, -1.58002116e-02f, -5.45631023e-03f, 4.93256450e-02f, 7.04470351e-02f, -1.73540618e-02f, -2.62900461e-02f, 2.88823899e-02f,
  9.50626284e-02f, -6.18622191e-02f, 2.76796557e-02f, -2.48497892e-02f, -1.11438848e-01f, 4.93419543e-02f, -5.94031904e-03f, -1.70443133e-02f, -5.88658936e-02f, -6.19547889e-02f,
  -1.82282597e-01f, -2.16072470e-01f, 2.00917777e-02f, 3.03948913e-02f, -2.36696545e-02f, -1.08407326e-01f, 2.28248127e-02f, -7.33797923e-02f, -1.42929882e-01f, -1.77687202e-02f,
  -1.15507960e-01f, 6.80803433e-02f, -9.19831321e-02f, -1.00429609e-01f, 5.42502739e-02f, -1.59336478e-01f, -6.60976619e-02f, 1.36222094e-02f, -8.85225013e-02f, -9.32110250e-02f,
  8.92061740e-03f, 1.13760298e-02f, 8.88637453e-02f, 7.44571304e-03f, -4.35568504e-02f, -5.31136245e-02f, -4.08386700e-02f, 9.38777924e-02f, 1.62889045e-02f, 4.52595018e-02f,
  -2.74905086e-01f, 8.64878595e-02f, -9.49209556e-02f, -1.99708879e-01f, -3.84482332e-02f, -1.52243391e-01f, -5.73236383e-02f, 7.10113123e-02f, 1.40527906e-02f, 1.01683825e-01f,
  1.21604100e-01f, -8.13819766e-02f, 6.47787601e-02f, -6.20623603e-02f, -1.35180876e-01f, -4.54430170e-02f, -1.99202165e-01f, -9.60200354e-02f, -7.05263689e-02f, -1.65060148e-01f,
  -1.15226597e-01f, -3.21058407e-02f, -1.54610321e-01f, 7.54862046e-03f, -3.97256128e-02f, -4.38181721e-02f, -4.52038366e-03f, 6.73131347e-02f, -1.39809117e-01f, 1.08570129e-01f,
  -1.11020863e-01f, 2.15006843e-02f, -1.16592750e-01f, -1.05744703e-02f, -1.05412938e-01f, -7.61262923e-02f, -4.87578101e-02f, -1.40597746e-02f, -9.26348418e-02f, -1.21964142e-01f,
  -3.02506741e-02f, -5.33769280e-02f, -4.76305431e-04f, 8.24838504e-02f, -9.01299417e-02f, 5.83819263e-02f, 1.17079597e-02f, 3.89544144e-02f, 1.48127070e-02f, -7.82176927e-02f,
  6.05899729e-02f, -6.61270171e-02f, -3.97291481e-02f, -4.30144519e-02f, -1.42561281e-02f, 2.92822383e-02f, 1.72765888e-02f, 2.73392666e-02f, -2.76432522e-02f, -8.41643959e-02f,
  -4.55777049e-02f, -3.84766841e-03f, 4.90150750e-02f, -3.61573547e-02f, -4.97829579e-02f, 4.71939296e-02f, 6.26000166e-02f, 1.52775701e-02f, -8.03873539e-02f, -7.03250542e-02f,
  -1.41108586e-02f, 4.29480337e-02f, -2.25311182e-02f, -1.93885081e-02f, 3.99300605e-02f, -4.74830642e-02f, -2.50774696e-02f, 1.14651909e-02f, -4.69508395e-02f, -6.49753958e-02f,
  -2.07818095e-02f, -5.17261513e-02f, 1.47278681e-02f, 8.36291239e-02f, 6.69232532e-02f, -7.68723413e-02f, -3.74840125e-02f, -1.75066087e-02f, 5.10404818e-02f, 9.90082789e-03f,
  -6.74286410e-02f, -1.62580565e-01f, -7.17987940e-02f, 8.84090737e-02f, -7.07146376e-02f, -1.03316523e-01f, -1.20833563e-02f, 6.62480667e-02f, -2.01894548e-02f, -8.30428749e-02f,
  -2.26731575e-03f, -1.28481211e-02f, -1.90833025e-02f, -8.12757015e-02f, -1.53790535e-02f, 9.70283151e-03f, 4.53526676e-02f, -1.70220411e-03f, -2.21674014e-02f, 4.45754603e-02f,
  -4.94945645e-02f, -4.02631192e-03f, -5.89465983e-02f, 5.83409369e-02f, 4.16909941e-02f, -4.70652385e-03f, -1.04450919e-01f, 2.60746758e-03f, 2.31127888e-02f, -5.82239740e-02f,
  4.39714938e-02f, 5.48521541e-02f, -2.98230443e-02f, -1.31121159e-01f, -3.59789282e-02f, -8.88876542e-02f, -2.55856425e-01f, 1.15863532e-02f, 1.62409397e-03f, -2.26909071e-02f,
  -6.22652285e-02f, -8.78237933e-02f, 1.23472856e-02f, -1.75077900e-01f, -5.67701161e-02f, -4.81444485e-02f, -2.50994593e-01f, -1.31830409e-01f, -9.70336348e-02f, -1.13169611e-01f,
  -8.91736224e-02f, -2.32594237e-02f, -1.57312959e-01f, 6.98572174e-02f, -7.62542412e-02f, -6.62757382e-02f, 1.42315611e-01f, 7.58180395e-02f, -1.01108022e-01f, -3.51673067e-02f,
  -8.89833048e-02f, 3.30390856e-02f, -1.01444922e-01f, 4.25991975e-02f, 3.78161445e-02f, -1.98096316e-02f, 2.62861680e-02f, -5.00939116e-02f, 7.52567649e-02f, 3.22809927e-02f,
  9.00226757e-02f, 5.80908731e-02f, -6.14386983e-02f, 1.05528899e-01f, 9.40174013e-02f, -4.54268679e-02f, -2.14442555e-02f, -6.70431331e-02f, -9.82049555e-02f, -6.61293343e-02f,
  -6.83244839e-02f, -2.03005429e-02f, 5.72800264e-02f, 7.45382905e-02f, -4.22761925e-02f, -2.16965191e-02f, -6.39741570e-02f, -3.76279838e-02f, 6.72816020e-03f, 4.66268659e-02f,
  -1.35759814e-02f, -5.68683110e-02f, 2.41623223e-02f, 1.21786512e-01f, -4.73578349e-02f, 3.76146547e-02f, -3.10110580e-02f, 5.45343123e-02f, 3.80535796e-02f, 4.92908955e-02f,
  4.83749099e-02f, 3.00533924e-04f, 3.09684966e-02f, 4.74882498e-02f, 5.75033166e-02f, -4.74293865e-02f, -3.30178216e-02f, -3.71742435e-02f, 1.99888051e-02f, 1.43561726e-02f,
  7.76809007e-02f, 1.93726327e-02f, -3.30305472e-02f, -5.20278746e-03f, -1.40338382e-02f, -3.20892259e-02f, 3.47249545e-02f, 2.88440324e-02f, 1.94872748e-02f, -3.21607362e-03f,
  -7.22316429e-02f, -4.82988581e-02f, -9.76424366e-02f, -4.73917052e-02f, 7.02562109e-02f, 9.49571431e-02f, 7.26395994e-02f, -6.84026554e-02f, 8.70259479e-02f, 4.12244089e-02f,
  1.68743432e-02f, -2.97392718e-02f, -6.05738871e-02f, 8.52336287e-02f, -2.90027894e-02f, 2.07983535e-02f, 9.69329476e-02f, 7.32181445e-02f, -9.37031582e-02f, 3.70593891e-02f,
  4.07711715e-02f, 9.09163442e-04f, 5.00338636e-02f, 7.78710172e-02f, 4.04551178e-02f, -6.01882339e-02f, 2.25300919e-02f, 5.80176413e-02f, -5.32239303e-02f, 5.07112034e-02f,
  7.64511004e-02f, 1.79127771e-02f, 1.03881553e-01f, 1.40338078e-01f, 6.72713015e-03f, 4.11300957e-02f, 1.78439487e-02f, -3.92404832e-02f, 1.52219962e-02f, -3.10113914e-02f,
  2.31882725e-02f, 1.06344663e-01f, -6.39835326e-03f, -1.82411283e-01f, -1.77337572e-01f, -2.43783951e-01f, -2.56526819e-03f, -7.42695928e-02f, 6.38937354e-02f, 2.32214183e-02f,
  6.92964047e-02f, -1.11063965e-01f, -1.26393899e-01f, -6.97896257e-02f, 5.93605116e-02f, 1.04953900e-01f, -2.97302455e-02f, 1.45730197e-01f, 5.04305288e-02f, 1.00617586e-02f,
  -8.43780488e-02f, -5.50191589e-02f, -2.87457998e-03f, 1.31470035e-03f, 4.06715833e-02f, -3.87913994e-02f, 1.02493979e-01f, -1.64958101e-03f, 2.80654151e-02f, -5.23474962e-02f,
  -2.88659008e-03f, 3.24900006e-03f, -6.62279055e-02f, -2.18717586e-02f, -4.23920676e-02f, -3.77775356e-02f, -2.53794398e-02f, 1.13988623e-01f, 3.00085787e-02f, -5.03475815e-02f,
  -2.02506240e-02f, -4.13400754e-02f, 1.65185463e-02f, -2.97630690e-02f, -2.94667203e-02f, 6.19835891e-02f, 2.86210589e-02f, 1.28408568e-02f, 6.66316226e-02f, -6.65027369e-03f,
  3.97879854e-02f, -3.44810933e-02f, -2.01678351e-02f, -7.34011978e-02f, 4.74309474e-02f, -3.55871059e-02f, -3.16156745e-02f, -2.17370931e-02f, -4.77709547e-02f, 5.30368015e-02f,
  3.67050208e-02f, 6.72407895e-02f, -6.58431947e-02f, -3.77482027e-02f, 1.04122423e-01f, -5.08788340e-02f, 7.45319724e-02f, 4.27691899e-02f, 9.74470004e-02f, 2.34865956e-02f,
  -7.56761283e-02f, -2.07518768e-02f, -4.13492359e-02f, 6.48715496e-02f, -6.45164996e-02f, -7.70337135e-02f, -9.56029519e-02f, -2.89037414e-02f, 1.35646705e-02f, 2.33564479e-03f,
  5.62587567e-02f, 1.36952117e-01f, 6.25474378e-02f, -5.58368713e-02f, 5.27989976e-02f, 3.27759087e-02f, 1.56651232e-02f, 1.87880732e-02f, 1.43208285e-03f, -1.26338294e-02f,
  9.62044746e-02f, 1.71302147e-02f, -4.80353571e-02f, -1.64304692e-02f, 1.96562111e-02f, 1.67366546e-02f, 2.94354651e-02f, 4.38823067e-02f, -5.46315871e-02f, -5.17121591e-02f,
  3.43437009e-02f, 1.50970012e-01f, -1.63508244e-02f, 7.02554807e-02f, -3.53438146e-02f, -3.69507484e-02f, 3.52849402e-02f, 1.25198275e-01f, -1.97653808e-02f, -5.11541143e-02f,
  2.42901221e-01f, 3.70759815e-01f, 4.09022778e-01f, 4.05521393e-01f, -1.99420467e-01f, -2.87615031e-01f, -6.23377934e-02f, -2.66667712e-03f, 1.75526991e-01f, 2.64103152e-02f,
  -2.20799640e-01f, 3.46401900e-01f, -2.21280590e-01f, 1.61069483e-01f, -3.27087075e-01f, -9.74859744e-02f, 9.22730938e-02f, 6.78886240e-03f, 2.89345626e-02f, 1.81652606e-01f,
  2.07222234e-02f, -9.91483033e-02f, -2.40425230e-03f, -3.56013961e-02f, 2.60084003e-01f, 3.27358276e-01f, -8.50554556e-02f, -1.34627476e-01f, 2.01002821e-01f, -4.28603776e-02f,
  3.77723426e-02f, 2.43718714e-01f, 8.66393521e-02f, 1.33430272e-01f, 2.72980379e-03f, -3.87234124e-03f, -1.61420032e-02f, -9.82049853e-02f, -5.73117249e-02f, -9.34764219e-04f,
  1.07193053e-01f, -9.06665102e-02f, 5.83292358e-02f, -1.28910318e-02f, 6.96393475e-02f, 3.41487043e-02f, 3.80683541e-02f, 1.04947776e-01f, 9.49179828e-02f, 1.03330009e-01f,
  1.07515790e-01f, 8.78213421e-02f, -2.27280557e-02f, 8.03321525e-02f, 9.28048864e-02f, -2.02697497e-02f, -1.50893256e-02f, -5.19289486e-02f, 1.13549873e-01f, -1.96505655e-02f,
  2.78812349e-02f, -3.29469964e-02f, -6.78627044e-02f, 6.91220388e-02f, 1.32444520e-02f, 5.92410788e-02f, 5.51697388e-02f, -9.70009938e-02f, -1.93545092e-02f, -5.21864146e-02f,
  6.92093885e-03f, 3.36288735e-02f, -2.89741252e-02f, -7.16179551e-04f, -2.85932235e-02f, 9.16487649e-02f, 7.31100980e-03f, 5.08589856e-02f, 7.62498751e-02f, 1.84899177e-02f,
  -8.14524963e-02f, -9.16851759e-02f, 3.55388736e-04f, 1.44529063e-02f, -1.38305709e-01f, -8.39827955e-03f, 1.60640161e-02f, 6.85903132e-02f, 1.57956243e-03f, 4.23956327e-02f,
  4.01525460e-02f, 9.69015956e-02f, 8.98679495e-02f, -5.26330955e-02f, -2.27790736e-02f, -9.03293714e-02f, 3.16580757e-02f, 5.44208214e-02f, -1.84085011e-03f, -5.21367230e-02f,
  -5.34265861e-03f, -2.01657582e-02f, 9.67427194e-02f, -4.81882840e-02f, -5.56881204e-02f, 5.34349568e-02f, 5.17109185e-02f, 6.39887005e-02f, -5.73385246e-02f, 6.45435378e-02f,
  -8.20025206e-02f, -1.00052916e-01f, 8.41586664e-03f, -4.22139466e-02f, -2.97239888e-02f, 4.21750657e-02f, 7.06672817e-02f, 8.11513513e-02f, -6.78871423e-02f, -2.01706011e-02f,
  2.31730312e-01f, 1.17094412e-01f, -2.60230333e-01f, 8.36711228e-02f, 1.18935488e-01f, -3.70252952e-02f, -3.73708457e-02f, -6.26302138e-02f, -1.40807346e-01f, 3.35219093e-02f,
  1.28139585e-01f, 1.12966307e-01f, -9.09818113e-02f, 3.11908394e-01f, 3.02116573e-01f, -4.06606086e-02f, 3.42737615e-01f, 1.31815478e-01f, -2.67523210e-02f, 9.43583697e-02f,
  4.92522344e-02f, 3.84888023e-01f, -4.33293805e-02f, 2.26879790e-02f, 5.96181862e-02f, -1.42268226e-01f, 9.81583297e-02f, -1.73481375e-01f, 1.12835184e-01f, 1.14438415e-01f,
  3.78848873e-02f, 1.31124333e-01f, 2.82825623e-02f, -3.49662714e-02f, -3.36357653e-02f, 4.44469340e-02f, -8.99602324e-02f, 2.84244921e-02f, -8.88018161e-02f, 3.82246412e-02f,
  -5.23436889e-02f, -2.35207309e-03f, 1.41999125e-01f, -4.92159240e-02f, 3.25458832e-02f, -2.84962747e-02f, -3.71493138e-02f, -8.54655132e-02f, -7.70706087e-02f, -5.43361250e-03f,
  1.61533710e-02f, -2.53580566e-02f, 5.76424506e-03f, -3.15185562e-02f, 3.21758017e-02f, 5.27036823e-02f, 1.88556931e-03f, 3.13042104e-02f, 8.50154739e-03f, -1.48479799e-02f,
  7.40142912e-02f, -5.16023785e-02f, 7.08968788e-02f, 5.82756884e-02f, 1.00931875e-01f, 4.44535427e-02f, 5.87717704e-02f, 5.37157767e-02f, -4.63262796e-02f, 4.79494780e-02f,
  -3.48927639e-02f, -6.69960454e-02f, 5.57687767e-02f, 3.90584953e-02f, -2.53273640e-02f, 8.56073722e-02f, -1.12517597e-02f, 2.59987321e-02f, -3.11900117e-02f, -2.91421195e-03f,
  -5.98741090e-03f, 5.07558286e-02f, 4.83728312e-02f, -1.11496873e-01f, 3.82177643e-02f, -5.12665994e-02f, 6.05305508e-02f, -1.59269758e-03f, -7.53401369e-02f, -2.44689211e-02f,
  1.62663192e-01f, 4.78131920e-02f, 7.92579167e-03f, 1.56559646e-02f, -3.57573703e-02f, 1.69565737e-01f, -3.63836661e-02f, 2.43679043e-02f, -7.19952025e-03f, 6.13589808e-02f,
  7.58212134e-02f, 2.01672297e-02f, -3.63420956e-02f, -6.59344271e-02f, -3.48924175e-02f, -3.29024680e-02f, -5.60574383e-02f, 1.42346118e-02f, 8.64054114e-02f, 1.18322503e-02f,
  2.62177289e-02f, -2.98036970e-02f, 4.32243459e-02f, -1.92179400e-02f, 4.63524312e-02f, -3.16910893e-02f, -8.96492973e-02f, -7.39087537e-02f, 4.37190235e-02f, -1.15159526e-03f,
  3.56747471e-02f, -4.09460925e-02f, -4.82448302e-02f, 3.77021693e-02f, 2.39715595e-02f, -5.99570759e-02f, -1.23930529e-01f, -2.03217771e-02f, 1.45941883e-01f, -4.68435362e-02f,
  2.30292790e-02f, 1.29360594e-02f, -1.06713131e-01f, 2.55451873e-02f, -1.06395006e-01f, -1.40194297e-01f, -1.41598627e-01f, 5.25670685e-02f, -5.02676889e-02f, -2.16691522e-03f,
  7.44458521e-03f, 1.75527856e-02f, -1.39593646e-01f, -1.51972119e-02f, 7.92084858e-02f, -4.82107177e-02f, -6.77378476e-02f, 3.47738117e-02f, -9.17348042e-02f, -6.44354150e-02f,
  6.49299845e-02f, 2.71936972e-02f, 3.48122641e-02f, -7.34767094e-02f, -1.43175153e-02f, -3.40548530e-02f, 3.79079371e-03f, -3.45087089e-02f, -5.09008858e-03f, 5.61649762e-02f,
  -3.97475809e-02f, -9.46877822e-02f, -4.95340973e-02f, 3.72298583e-02f, 7.35285357e-02f, -1.84993371e-02f, -6.52998015e-02f, 7.61654675e-02f, -9.94028151e-03f, -6.50240555e-02f,
  -9.61385444e-02f, -8.59428197e-02f, 8.87263194e-02f, -5.89012951e-02f, 1.87676158e-02f, 8.72465298e-02f, 8.08892846e-02f, -1.86643153e-02f, -6.42201900e-02f, 4.63155610e-03f,
  4.55204397e-03f, -7.00310692e-02f, -6.91751465e-02f, 1.17959986e-02f, -7.63955787e-02f, -5.41462190e-02f, 7.67228305e-02f, 7.38463551e-02f, -7.98026659e-03f, 6.89792261e-02f,
  -4.58652712e-02f, -2.91134268e-02f, -8.82247984e-02f, 8.17137808e-02f, -7.69207776e-02f, -2.21137609e-02f, 2.86550727e-02f, -2.44894288e-02f, 4.01074532e-03f, 9.94486921e-03f,
  8.58950894e-03f, 1.81701258e-02f, -1.11644305e-02f, 6.31381050e-02f, 3.89182195e-02f, 2.05204170e-02f, 8.44850913e-02f, -5.89712076e-02f, 9.02026799e-03f, 7.11469203e-02f,
  -3.70979570e-02f, -6.02774834e-03f, 3.45014744e-02f, 1.17845209e-02f, -7.86697939e-02f, 6.59275055e-03f, -2.23348308e-02f, 5.44874780e-02f, -4.64110412e-02f, -5.95707148e-02f,
  6.67255232e-03f, -2.14601830e-02f, 4.29190835e-03f, 4.28088680e-02f, 2.89690197e-02f, 5.52769601e-02f, 8.94903839e-02f, 2.74185482e-02f, -8.37971792e-02f, 1.89070683e-02f,
  -7.66756162e-02f, -7.63643384e-02f, 6.16467968e-02f, 5.18801585e-02f, -7.28871375e-02f, 6.01817891e-02f, -2.64362264e-02f, 1.26760593e-02f, 5.58965877e-02f, -6.05824180e-02f,
  -1.69248611e-01f, 1.61377136e-02f, -1.95069704e-02f, -2.35006556e-01f, 2.25929320e-01f, -2.06970088e-02f, -1.77826032e-01f, 6.36811703e-02f, -8.99659619e-02f, -8.82407501e-02f,
  -6.92835674e-02f, -1.13642760e-01f, 1.15120523e-01f, -2.19918817e-01f, -2.37271503e-01f, -1.62346158e-02f, -2.97196537e-01f, -1.13490559e-01f, 1.46811098e-01f, -3.73223275e-02f,
  -8.57177302e-02f, -1.37737125e-01f, 4.65814136e-02f, 1.39157578e-01f, 3.07089370e-02f, -3.12532373e-02f, -1.17412105e-01f, 1.62516445e-01f, -6.75453618e-03f, 4.36430685e-02f,
  -1.38791457e-01f, -6.23801118e-03f, 2.66236961e-02f, -7.49515072e-02f, -7.06139654e-02f, 1.01047419e-02f, -1.16678350e-01f, 1.37136867e-02f, 4.35959846e-02f, 6.56655282e-02f,
  -1.87846478e-02f, -4.70629260e-02f, 1.70824584e-02f, -8.82658269e-03f, 4.51234356e-03f, 5.52859344e-02f, 2.02749553e-03f, 8.20031613e-02f, 9.54420194e-02f, 7.92910084e-02f,
  8.05194154e-02f, 6.12477772e-02f, -9.44595709e-02f, -6.35903403e-02f, -2.68414449e-02f, -2.49490310e-02f, 1.73315722e-02f, 5.11445776e-02f, -7.80907273e-02f, 3.34712714e-02f,
  -3.46332490e-02f, 4.29477431e-02f, 6.61151707e-02f, 6.24987017e-03f, 1.24310344e-01f, 2.43182816e-02f, 3.79518867e-02f, 2.26701722e-02f, 4.10414375e-02f, -1.26251904e-03f,
  -1.51773756e-02f, 7.71534741e-02f, 8.92213061e-02f, -9.81201306e-02f, -3.14616896e-02f, 3.64376158e-02f, -3.27043906e-02f, 9.80209559e-03f, -5.00255339e-02f, 5.78271188e-02f,
  -7.70684928e-02f, 2.71960311e-02f, -1.51395127e-02f, 1.99406296e-02f, 8.91794786e-02f, -2.85417144e-03f, -6.26312867e-02f, -2.75237374e-02f, 7.05201104e-02f, 2.30517276e-02f,
  -1.47168845e-01f, -1.95880786e-01f, -7.12957382e-02f, -8.90345052e-02f, -8.78390148e-02f, -6.07761070e-02f, 1.94350109e-02f, -3.61774452e-02f, -6.83979690e-02f, 3.90415918e-03f,
  2.14015283e-02f, -3.07412650e-02f, -8.77952129e-02f, -2.69745123e-02f, -6.10700101e-02f, -2.53915042e-02f, 1.29814120e-02f, -6.31244332e-02f, -1.63710877e-01f, -1.42641272e-02f,
  -6.19439259e-02f, 6.21851012e-02f, 3.51631036e-03f, -2.96879802e-02f, 5.66805899e-02f, -1.02652013e-01f, -3.49190235e-02f, -2.68793460e-02f, -1.55111654e-02f, -6.24193512e-02f,
  4.16810542e-01f, -2.16751322e-02f, -5.16029336e-02f, -3.66730057e-02f, -5.38300863e-03f, -9.09935981e-02f, -6.21443056e-02f, 1.01074517e-01f, 1.66858330e-01f, -9.08892974e-02f,
  -1.09745346e-01f, -1.80591792e-02f, -3.26049291e-02f, -1.22134984e-01f, 1.84004694e-01f, 1.51873822e-03f, 9.57013946e-03f, -7.79652521e-02f, 1.49550259e-01f, -9.53100771e-02f,
  4.09335420e-02f, -2.23941401e-01f, -4.05670516e-02f, -1.53151602e-01f, -1.63969681e-01f, -5.99918254e-02f, -2.16536477e-01f, -2.28120491e-01f, -1.98764026e-01f, -7.82351568e-02f,
  1.02962535e-02f, 1.43752038e-01f, 8.45845416e-02f, 8.87781456e-02f, 3.30670029e-02f, 8.34578574e-02f, -6.37494549e-02f, -8.63460749e-02f, 3.11625209e-02f, -1.32870162e-02f,
  6.24786727e-02f, 6.36131968e-03f, 9.02556255e-02f, 1.27506018e-01f, 1.23033822e-01f, 8.04954916e-02f, 1.02920625e-02f, -4.18177396e-02f, -3.77562977e-02f, 9.00942907e-02f,
  -2.83668563e-02f, 1.46005917e-02f, -2.94553246e-02f, -6.32836744e-02f, 7.38084549e-03f, 5.01609668e-02f, -5.76436743e-02f, -6.07556589e-02f, 6.85827434e-02f, -3.64562613e-03f,
  4.46312129e-02f, -8.26226994e-02f, -5.39723188e-02f, 1.00212000e-01f, -2.26988383e-02f, -2.41209473e-02f, 1.45815397e-02f, -7.83385858e-02f, -1.75744556e-02f, -3.95204201e-02f,
  -5.63875176e-02f, 4.17703800e-02f, 2.10693348e-02f, -1.60132479e-02f, 8.46096575e-02f, 6.67265132e-02f, -2.46768668e-02f, -7.60279670e-02f, 2.93329265e-03f, -9.05538574e-02f,
  -1.00295998e-01f, 7.51935169e-02f, -4.46172282e-02f, 2.01288871e-02f, -1.12209171e-02f, -7.93509278e-03f, 4.23158035e-02f, 4.95437235e-02f, -8.12727362e-02f, 9.74002574e-03f,
  -1.69143453e-02f, -9.43114087e-02f, -4.72837090e-02f, -1.22478381e-02f, -6.41111331e-03f, -4.07959595e-02f, -6.14242442e-02f, 1.28164351e-01f, 3.42559181e-02f, 9.36626550e-03f,
  -1.43124657e-02f, 2.90248469e-02f, -9.02329981e-02f, 4.05835873e-03f, -5.10817245e-02f, 1.28057405e-01f, -1.33549288e-01f, 2.90906914e-02f, 3.62901725e-02f, -3.33343968e-02f,
  1.79260243e-02f, 9.06831771e-02f, -1.47719830e-01f, -1.52000156e-03f, -7.30292080e-03f, 7.71339536e-02f, 7.01972842e-02f, -5.98142780e-02f, -9.29507427e-03f, 7.73452893e-02f,
  7.06977323e-02f, -2.29706556e-01f, -1.68286100e-01f, 2.92338356e-02f, 1.49994507e-01f, 7.19260648e-02f, -4.36054252e-04f, -1.45973429e-01f, -7.03478158e-02f, -3.30435857e-02f,
  4.85336557e-02f, 4.47942577e-02f, -5.87166138e-02f, 1.72064960e-01f, 1.25236288e-01f, -1.01781055e-01f, 1.35248810e-01f, 1.40887156e-01f, -4.66732867e-02f, 7.42328241e-02f,
  2.04693787e-02f, 2.79559165e-01f, 4.18440811e-02f, 3.42682600e-02f, 1.08583055e-01f, -1.38571206e-02f, 4.15775776e-02f, -1.05854400e-01f, 6.89786375e-02f, 5.63910455e-02f,
  8.84336606e-02f, -5.47693633e-02f, -1.36419222e-01f, 3.80044691e-02f, 6.84332335e-03f, 2.23324653e-02f, 8.62581879e-02f, 3.90402935e-02f, -7.53102545e-03f, -8.81872624e-02f,
  1.50034465e-02f, -5.15471734e-02f, 3.73970121e-02f, -3.55405770e-02f, 3.50339711e-02f, 6.50237054e-02f, -1.07599758e-01f, 3.67865823e-02f, -2.15245932e-02f, -3.53804082e-02f,
  -4.36195359e-02f, -5.78338392e-02f, -5.99431060e-02f, 1.46978954e-02f, -4.40685116e-02f, -1.04434796e-01f, -2.35949140e-02f, -8.13177675e-02f, -2.55915746e-02f, -7.51292482e-02f,
  2.80840676e-02f, 6.88897148e-02f, -9.08668935e-02f, 4.17665318e-02f, 1.88034736e-02f, 2.02879719e-02f, -2.11227443e-02f, -2.83976067e-02f, 3.15977447e-02f, -3.37533802e-02f,
  4.56269048e-02f, 3.04458337e-03f, 4.52342294e-02f, -3.96283343e-02f, -5.14414487e-03f, -4.16132212e-02f, 7.37869367e-02f, -1.11932352e-01f, 9.17329267e-02f, -8.13199282e-02f,
  2.93161701e-02f, -6.58917427e-02f, 6.87098652e-02f, -4.58055697e-02f, -8.53953790e-03f, 1.04127787e-01f, 8.31462890e-02f, 1.83842182e-02f, -9.94706377e-02f, 1.76624488e-02f,
  1.44811422e-02f, -6.65601641e-02f, -1.26161516e-01f, 8.03591236e-02f, 6.89979270e-02f, -3.18065174e-02f, 7.81354457e-02f, 4.50616330e-02f, 2.15952825e-02f, -4.88424525e-02f,
  -2.84046270e-02f, -7.49851242e-02f, 5.10894656e-02f, 6.55643195e-02f, -8.46407562e-02f, 8.17884058e-02f, -5.92664890e-02f, -5.68281785e-02f, -2.48962492e-02f, -8.92214552e-02f,
  9.02377963e-02f, 1.02491798e-02f, -2.12163886e-05f, -1.04784993e-02f, -6.54253662e-02f, 3.14364657e-02f, -7.76122808e-02f, 7.35804811e-02f, -2.59316340e-02f, 1.08489422e-02f,
  2.43417677e-02f, 4.18718979e-02f, 1.76720172e-01f, 6.06688708e-02f, 3.50235999e-02f, 7.28693455e-02f, 2.45856971e-01f, -1.08408391e-01f, 2.64272299e-02f, -1.17914435e-02f,
  4.79148328e-02f, 1.79590032e-01f, -5.18305674e-02f, 2.69173011e-02f, 8.09781551e-02f, -2.12528068e-03f, 2.88957451e-02f, 1.31216541e-01f, 1.14883527e-01f, 9.49728563e-02f,
  -2.67683938e-02f, -1.00270428e-01f, 4.76331636e-02f, -9.61841792e-02f, -3.17855701e-02f, -1.15505703e-01f, -1.67020246e-01f, 2.98041385e-02f, -7.43613020e-02f, 5.10597676e-02f,
  -1.18539274e-01f, 2.82235947e-02f, 4.75967415e-02f, 3.28401066e-02f, -8.20129365e-02f, 2.25221720e-02f, -5.50008789e-02f, 3.63018513e-02f, 7.10943416e-02f, -5.79101332e-02f,
  5.07926494e-02f, -4.95477878e-02f, 3.68107632e-02f, -5.81864221e-03f, 4.52768058e-02f, -7.22822323e-02f, 6.54994175e-02f, 4.56189699e-02f, -3.70043553e-02f, -6.39289692e-02f,
  -1.72075033e-02f, -5.66622578e-02f, 7.51903430e-02f, 9.19503346e-02f, -3.37911248e-02f, -4.51914407e-02f, 7.24967271e-02f, 6.28464818e-02f, 1.38443103e-02f, -5.32213375e-02f,
  2.36453563e-02f, 7.03207450e-03f, -6.13649376e-02f, 2.41231639e-02f, -4.24709022e-02f, -8.14089403e-02f, 1.49685480e-02f, -3.70982885e-02f, 2.48200167e-03f, -2.96580866e-02f,
  -6.31058663e-02f, 8.32827091e-02f, -7.12602884e-02f, 3.44515815e-02f, -9.24584363e-03f, 8.56059417e-03f, 3.89169157e-02f, -9.41529423e-02f, -3.00711468e-02f, -9.19353776e-03f,
  -9.77285802e-02f, -5.32543696e-02f, -3.11225019e-02f, -3.52030471e-02f, 7.96704069e-02f, -5.06443828e-02f, 3.87863368e-02f, 2.75498275e-02f, 2.41567586e-02f, -1.42179141e-02f,
  -3.22811492e-03f, 4.70921732e-02f, -1.25796543e-02f, -2.64637973e-02f, -1.08555697e-01f, -8.08524042e-02f, 6.36253580e-02f, -7.54387677e-02f, 1.42891221e-02f, 7.13194609e-02f,
  -5.10328002e-02f, -5.56720495e-02f, -7.21750557e-02f, -6.87911436e-02f, -3.11007742e-02f, -1.08471513e-01f, 2.48077866e-02f, -7.84825087e-02f, -7.72988573e-02f, -7.02375099e-02f,
  5.99475838e-02f, -4.81877811e-02f, 7.44281486e-02f, -9.62035879e-02f, -6.16317317e-02f, 3.42861265e-02f, -2.06288714e-02f, 3.74391004e-02f, -9.19201523e-02f, 7.70264566e-02f,
  1.70369625e-01f, -3.77049536e-01f, -3.25505137e-02f, 1.95772871e-01f, 1.48563057e-01f, -3.83646111e-04f, -1.12948532e-03f, 1.23931579e-01f, 1.37819484e-01f, -2.28241965e-01f,
  -1.23640426e-01f, -1.23135507e-01f, -2.13123605e-01f, 1.04761444e-01f, 5.05584404e-02f, -1.56781644e-01f, 9.37573537e-02f, -3.47748399e-02f, 6.99075982e-02f, -3.02627720e-02f,
  5.73138930e-02f, 1.13156311e-01f, 2.63050143e-02f, 1.00416854e-01f, 8.60374942e-02f, 9.94049683e-02f, 4.68108850e-03f, -9.50014219e-02f, 1.06752045e-01f, 7.69449472e-02f,
  4.60016131e-02f, 2.40815599e-02f, 7.29408339e-02f, -6.20396696e-02f, -4.26935069e-02f, -2.90053412e-02f, -1.89661820e-04f, 8.25370699e-02f, 4.05631140e-02f, -9.57683921e-02f,
  -9.40387845e-02f, 4.03958000e-02f, 8.48160014e-02f, 1.00746781e-01f, 3.55694443e-02f, 7.67166987e-02f, -7.25917146e-03f, 3.98530513e-02f, 7.94854760e-02f, -1.60549849e-01f,
  -5.42725064e-02f, -1.78283118e-02f, 1.08512677e-01f, 3.48742492e-02f, -7.76461884e-03f, 6.62804991e-02f, 4.94815819e-02f, -1.18964307e-01f, 1.78422015e-02f, 2.10672878e-02f,
  -6.10491596e-02f, -2.76125316e-02f, -7.85567164e-02f, -9.26539954e-03f, 2.19612177e-02f, 9.41800699e-02f, -6.59634396e-02f, -7.14971498e-02f, -8.48282352e-02f, -1.88354626e-02f,
  7.63646960e-02f, -6.00978136e-02f, -2.19544657e-02f, -7.04719052e-02f, 5.30292764e-02f, 7.39919767e-02f, 2.57083774e-02f, 9.56039652e-02f, -9.29955617e-02f, 3.62874791e-02f,
  -1.39625203e-02f, 3.76966991e-03f, 7.34607596e-03f, 9.57828611e-02f, -1.32539524e-02f, 1.17010111e-02f, -1.34186801e-02f, -5.54813482e-02f, 4.05850001e-02f, 3.15686781e-03f,
  -1.46441191e-01f, -2.80033082e-01f, 1.33791771e-02f, -9.72926170e-02f, -3.63578945e-02f, 3.15520391e-02f, 6.30792901e-02f, -9.21193510e-02f, -5.50522208e-02f, -2.01580320e-02f,
  1.24670137e-02f, 4.43103239e-02f, -2.00925954e-02f, 2.29451880e-02f, -3.64247225e-02f, -4.77692187e-02f, 5.71139343e-03f, 3.47317345e-02f, 8.84666666e-02f, -2.79406346e-02f,
  -1.12908361e-02f, -7.46779516e-02f, -1.73459891e-02f, -5.28229922e-02f, 3.04086525e-02f, -1.71947330e-02f, -7.20250793e-03f, -7.36324340e-02f, 3.19222920e-02f, -3.69148701e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 26)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 26;
const float L0_fan_Bp_bar_data[] = {
  3.75044286e-01f, 1.66345686e-01f, 2.75618173e-02f, 2.68487781e-01f, 2.33764574e-01f, 6.99083740e-03f, 7.27897212e-02f, 2.31378540e-01f, 4.16881479e-02f, 3.40633363e-01f,
  1.59782497e-03f, 2.16118574e-01f, 2.09207367e-02f, 2.77863681e-01f, 2.19912872e-01f, 4.68225107e-02f, 1.42003387e-01f, 1.52705908e-01f, 2.70144910e-01f, 2.98126042e-01f,
  -9.86564159e-02f, 2.72446215e-01f, 2.86995709e-01f, 2.00322181e-01f, 1.42157212e-01f, 7.07511157e-02f
};

// L1_fan_Wp (Shape: 3 x 32)
const int L1_fan_Wp_rows = 3;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  -1.56713560e-01f, -3.23135227e-01f, -4.55651730e-01f, 1.98951274e-01f, 5.46810746e-01f, -1.87136844e-01f, -1.88165352e-01f, 6.85265735e-02f, -1.69483185e-01f, -1.56107321e-01f,
  -1.94316685e-01f, 2.93736875e-01f, -3.51746947e-01f, 1.61270440e-01f, 1.58350095e-01f, 2.44941249e-01f, 2.36720920e-01f, -1.53524414e-01f, 2.17003644e-01f, 3.03410083e-01f,
  -2.29171455e-01f, 2.79111296e-01f, 7.75461495e-02f, -1.21829033e-01f, -1.64325267e-01f, 3.11346114e-01f, -1.58111066e-01f, 1.68640688e-02f, -3.32167208e-01f, 1.78836033e-01f,
  -4.29616086e-02f, -8.70753487e-04f, -4.79765795e-02f, -3.61097790e-02f, -2.34124631e-01f, -8.02962929e-02f, 3.99591386e-01f, -5.78818358e-02f, -1.35727912e-01f, 1.11355603e-01f,
  6.27611056e-02f, 1.41442984e-01f, -1.96038745e-02f, 6.78540543e-02f, -1.86430831e-02f, 2.07711071e-01f, 5.65300547e-02f, 3.01875859e-01f, 1.49155974e-01f, -1.37086868e-01f,
  7.96749592e-02f, 2.41167247e-01f, -1.00026444e-01f, 7.97731280e-02f, -6.22853078e-02f, -1.79429725e-01f, -5.67083023e-02f, 1.57978758e-01f, 1.15623146e-01f, -1.36327088e-01f,
  -4.26717550e-02f, 8.26766938e-02f, -1.44394517e-01f, -4.52173427e-02f, 2.46820878e-02f, 9.94125903e-02f, 3.90952349e-01f, -3.75793904e-01f, -2.75113463e-01f, -1.38294056e-01f,
  -2.76192009e-01f, 3.14085573e-01f, -1.41826570e-01f, 1.02991657e-02f, 9.68098491e-02f, 1.07399439e-02f, 4.24507856e-02f, -6.58626780e-02f, 1.39444739e-01f, -5.58894388e-02f,
  5.53110354e-02f, 1.16410539e-01f, -3.02105211e-02f, 2.89904833e-01f, -3.16447258e-01f, -3.70211862e-02f, 1.42780170e-01f, 1.32435426e-01f, -2.23587319e-01f, 2.73966268e-02f,
  1.57929175e-02f, -1.22586854e-01f, 8.93169343e-02f, 3.41967167e-03f, -1.61815174e-02f, 2.33103693e-01f
};

// L1_fan_Wp_bar (Shape: 26 x 32)
const int L1_fan_Wp_bar_rows = 26;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  -6.25722036e-02f, 1.78457186e-01f, 4.12492901e-01f, 5.74952722e-01f, 1.05649307e-01f, 4.14034605e-01f, 3.21906507e-01f, 3.04098837e-02f, -6.95488900e-02f, -2.40932375e-01f,
  1.20811380e-01f, -1.48696393e-01f, 2.41908848e-01f, 6.94775358e-02f, 2.66158953e-02f, -1.92154050e-01f, -1.59987405e-01f, -1.36134908e-01f, 2.46395677e-01f, -4.90869135e-02f,
  2.64727175e-01f, 2.86624283e-01f, 8.78291503e-02f, -1.06947213e-01f, -2.48673856e-01f, -7.15421662e-02f, -5.05024642e-02f, 4.63756472e-01f, 2.25903437e-01f, -1.05426669e-01f,
  -9.75166112e-02f, 6.36133458e-03f, 3.19177836e-01f, 3.29456925e-01f, 3.85546416e-01f, 1.34256914e-01f, 2.09899917e-01f, 3.76526713e-01f, 6.63901627e-01f, 1.01033725e-01f,
  1.41243845e-01f, 2.29639158e-01f, -6.62485063e-02f, -1.44955724e-01f, 2.41433438e-02f, 3.19202423e-01f, 1.65115952e-01f, 2.34539494e-01f, -1.39170736e-01f, 6.03375696e-02f,
  2.40360469e-01f, -1.86369896e-01f, 1.29116416e-01f, 9.59270075e-02f, 9.28634405e-02f, 1.79902554e-01f, 5.30540764e-01f, 9.81018543e-02f, 2.13293567e-01f, 3.48375678e-01f,
  2.03481875e-02f, -1.09386757e-01f, 9.98486355e-02f, -1.12102792e-01f, 1.77353919e-02f, -1.54514194e-01f, -6.49949536e-02f, -2.12585732e-01f, -9.82252322e-03f, 2.74942312e-02f,
  1.20113447e-01f, 5.25358468e-02f, -6.70872480e-02f, 2.21963122e-01f, 9.71705019e-02f, -1.35684505e-01f, 1.58093035e-01f, 1.39667809e-01f, -3.02978238e-04f, -2.37914287e-02f,
  7.72457123e-02f, -1.39745742e-01f, -1.13167219e-01f, -1.48676366e-01f, 4.07485059e-03f, -1.76883295e-01f, 4.17666286e-02f, 1.68016162e-02f, -3.42169143e-02f, 8.32850300e-03f,
  7.72471204e-02f, 6.50243387e-02f, -8.18705708e-02f, 1.01039834e-01f, 8.08017105e-02f, -1.55821189e-01f, -1.17546625e-01f, 5.72279431e-02f, -4.06099437e-03f, -7.77432844e-02f,
  -2.90342066e-02f, 1.36383340e-01f, -7.04324543e-02f, 2.60394625e-02f, -5.75407073e-02f, -1.30857378e-01f, -1.35261118e-01f, 1.15464240e-01f, -2.07322314e-01f, 8.21812600e-02f,
  1.85840026e-01f, -1.14443839e-01f, 8.77236798e-02f, -1.68949813e-01f, -7.87072349e-03f, -2.05911733e-02f, -9.86135155e-02f, 1.47258595e-01f, 1.89393193e-01f, -8.19011107e-02f,
  1.25341788e-01f, 1.96398366e-02f, 1.66039720e-01f, -6.79456666e-02f, -5.66932335e-02f, -1.21899903e-01f, -7.58572593e-02f, -9.03223827e-02f, 6.23858392e-01f, 4.44043100e-01f,
  3.87469679e-01f, -4.03915346e-01f, -5.01520872e-01f, -1.90668806e-01f, 5.27763031e-02f, -1.99704319e-01f, 7.80127719e-02f, 2.24599540e-01f, 6.18325114e-01f, 3.84565108e-02f,
  3.16895433e-02f, 2.77864048e-03f, 2.57324487e-01f, -3.12513232e-01f, 3.09817791e-01f, 7.13490844e-01f, -5.10447659e-02f, 6.84295416e-01f, -1.68201357e-01f, 1.23854252e-02f,
  -3.02539393e-02f, 1.27038896e-01f, -3.23190242e-01f, 1.80464581e-01f, -3.81253287e-02f, 8.14143270e-02f, 3.20526332e-01f, 2.80393362e-01f, 2.52247721e-01f, 5.31809390e-01f,
  1.98133960e-01f, 1.68368459e-01f, -1.21239685e-02f, -5.70358820e-02f, -1.54334307e-01f, -3.85604858e-01f, 2.09526531e-02f, -1.84060931e-01f, 9.92082879e-02f, 2.80144423e-01f,
  -1.67482510e-01f, 1.30669668e-01f, 1.57678977e-01f, -1.57443225e-01f, -5.51951416e-02f, 1.22875102e-01f, 1.36304334e-01f, 1.34171143e-01f, -1.27024814e-01f, 1.30920231e-01f,
  -2.46627778e-02f, -1.25829384e-01f, -1.28375679e-01f, 8.11534896e-02f, -3.52065414e-02f, 2.46036351e-01f, 4.64332886e-02f, -7.67940357e-02f, 9.77137834e-02f, 2.21661881e-01f,
  2.16789424e-01f, 3.56371403e-02f, 8.93104002e-02f, 1.61016658e-01f, -1.25475511e-01f, -2.48188823e-01f, 1.71755254e-01f, 1.22043371e-01f, 2.55892500e-02f, 1.75993890e-02f,
  -8.04567635e-02f, 2.79081702e-01f, 2.24116538e-02f, 1.69533357e-01f, 1.82630926e-01f, 1.46875814e-01f, -1.03565477e-01f, 2.16466680e-01f, -1.36243522e-01f, -4.28258814e-02f,
  4.57797013e-02f, 1.26800805e-01f, -1.58342481e-01f, -1.08403079e-01f, -1.37886584e-01f, 1.51081368e-01f, 1.84600458e-01f, 1.11366985e-02f, -1.19261973e-01f, -1.41075909e-01f,
  2.18954235e-01f, -1.03566647e-01f, 3.27282362e-02f, -1.03704236e-01f, 1.68740451e-01f, 1.80660382e-01f, -3.12635481e-01f, 1.65288165e-01f, 1.80140153e-01f, -1.49124181e-02f,
  3.23021412e-02f, -1.05325855e-01f, -1.23476379e-01f, -3.99107039e-02f, -1.06820077e-01f, -4.06084545e-02f, -9.67837498e-02f, 1.76823944e-01f, -1.57950535e-01f, 8.99441466e-02f,
  2.26026118e-01f, -9.07592699e-02f, -1.48626611e-01f, 1.28528148e-01f, 4.86908108e-01f, -5.67520075e-02f, 2.91015476e-01f, -2.12602779e-01f, -2.08302200e-01f, 2.30326712e-01f,
  1.12699673e-01f, 1.28316700e-01f, 2.49012843e-01f, 1.79977849e-01f, -1.86940372e-01f, 9.57984254e-02f, 6.89151660e-02f, -1.33869901e-01f, 6.95310608e-02f, -1.20458253e-01f,
  -2.58846004e-02f, -9.25790891e-02f, -1.00850396e-01f, 1.01438621e-02f, 1.53845519e-01f, -1.71352729e-01f, -6.94919005e-02f, 1.77539796e-01f, 1.20291837e-01f, -7.41147101e-02f,
  5.10833450e-02f, -1.65264577e-01f, 1.32827282e-01f, 8.63377601e-02f, -1.47549259e-02f, 7.60172307e-02f, 6.26547262e-02f, -7.12357163e-02f, -1.62859678e-01f, 1.80539668e-01f,
  2.93143280e-02f, -9.20982286e-02f, -1.12973168e-01f, -2.13103741e-03f, -1.09388016e-01f, -6.29748181e-02f, -1.33429796e-01f, -8.07856470e-02f, 3.97372037e-01f, 3.00595343e-01f,
  1.80165917e-01f, -4.88909453e-01f, -1.67505145e-01f, -1.68002874e-01f, 2.87996799e-01f, 2.70159870e-01f, 1.30062386e-01f, 2.46235073e-01f, 2.53813177e-01f, -4.70765047e-02f,
  3.63619253e-02f, -1.76628560e-01f, 1.62822589e-01f, 3.83951187e-01f, -1.49796447e-02f, 1.41978145e-01f, -1.15537576e-01f, 3.49361748e-01f, -9.37869027e-02f, -1.30176947e-01f,
  1.01543806e-01f, 1.97684169e-01f, 4.88095969e-01f, 1.51168063e-01f, 3.97393256e-02f, -1.37978271e-01f, 1.94110721e-01f, -7.89925233e-02f, 1.18673310e-01f, 7.78824314e-02f,
  2.64450371e-01f, -1.46086931e-01f, -2.27825224e-01f, 3.17520767e-01f, 4.20728713e-01f, -3.52370888e-01f, -4.10674326e-02f, -9.16230157e-02f, 9.48768482e-02f, -5.03630228e-02f,
  -9.23809037e-02f, 1.30848780e-01f, -2.23130003e-01f, 7.94545114e-02f, -1.72451049e-01f, 2.07158566e-01f, 1.00556530e-01f, -5.15498407e-02f, -2.35015638e-02f, 8.14103112e-02f,
  2.57068157e-01f, 2.82646000e-01f, -1.03174008e-01f, -1.72989413e-01f, -3.93406451e-02f, 7.64247254e-02f, -9.87950787e-02f, -7.32740760e-02f, -8.16684142e-02f, 2.10568249e-01f,
  1.13945290e-01f, 3.12324092e-02f, 1.51042804e-01f, -7.81161636e-02f, -2.01976672e-02f, 1.07409708e-01f, 6.59608543e-02f, -1.04489610e-01f, -2.11896095e-03f, -6.17743842e-02f,
  -3.30611691e-02f, -1.37041897e-01f, 9.27829519e-02f, 1.04315393e-01f, -1.88279673e-01f, 1.47874311e-01f, 1.42792955e-01f, -1.46290243e-01f, 1.10496990e-01f, 6.09180443e-02f,
  -8.26487243e-02f, 9.90889147e-02f, -4.52892631e-02f, -6.41523823e-02f, 5.49508594e-02f, 9.25411880e-02f, -2.20924571e-01f, -6.51865527e-02f, 1.12194948e-01f, 1.76571667e-01f,
  3.13744470e-02f, 2.05715433e-01f, -1.10744700e-01f, 1.84784815e-01f, 7.56114647e-02f, 3.59327458e-02f, -1.19284540e-01f, -2.88827062e-01f, 2.76813477e-01f, 3.72719020e-02f,
  4.35636118e-02f, 2.81840295e-01f, 4.06133421e-02f, 2.10925058e-01f, 1.38171604e-02f, 7.93880001e-02f, 8.19789693e-02f, -1.79974943e-01f, -9.08190757e-02f, 3.79834086e-01f,
  -6.54742941e-02f, 3.14217769e-02f, -1.27859682e-01f, 1.58698514e-01f, -2.90821195e-02f, -1.58934101e-01f, -1.74159646e-01f, -2.64702179e-02f, 5.43839097e-01f, 2.95685679e-02f,
  -4.19434234e-02f, -1.15999490e-01f, 2.55148053e-01f, 6.78745359e-02f, 1.03184752e-01f, -2.08615810e-01f, 6.17455058e-02f, -6.64320737e-02f, 3.65868323e-02f, -1.60500720e-01f,
  -5.49935549e-02f, -1.03128282e-02f, 2.33891010e-01f, 2.31928065e-01f, 1.28729090e-01f, -1.27388805e-01f, -2.10392505e-01f, 9.48565826e-02f, -7.36514330e-02f, 3.64480853e-01f,
  1.38468012e-01f, -4.36723493e-02f, 3.32874469e-02f, -1.99290380e-01f, -9.45524499e-02f, -2.87401112e-04f, 1.43317655e-02f, 6.80836365e-02f, 7.28485174e-03f, 1.18076615e-01f,
  5.44830188e-02f, -4.97026034e-02f, 2.95724664e-02f, 3.40534933e-02f, 4.04133759e-02f, -1.61331922e-01f, -5.81093170e-02f, -2.49041021e-01f, 5.92201613e-02f, -2.76082493e-02f,
  -3.55012529e-02f, 1.08853228e-01f, -1.27774417e-01f, 8.57287720e-02f, 3.09518456e-01f, 2.42708579e-01f, 1.79109260e-01f, -8.76265764e-02f, 2.65460998e-01f, -1.49848700e-01f,
  4.13236097e-02f, -1.94766149e-01f, 1.78685516e-01f, 3.30602765e-01f, 1.85588911e-01f, -1.09594204e-01f, 2.87707504e-02f, 1.09285310e-01f, 7.56728202e-02f, -1.43195465e-01f,
  -1.27610788e-01f, -1.48616806e-02f, 2.21431166e-01f, 2.80865371e-01f, -1.33125499e-01f, 1.27552316e-01f, 2.17175350e-01f, 1.59915358e-01f, -5.45127168e-02f, 8.18241164e-02f,
  1.03529982e-01f, -1.11309633e-01f, 3.09748333e-02f, -1.38412520e-01f, 1.35699555e-01f, -1.36919603e-01f, -2.58519024e-01f, -7.14588761e-02f, -2.81796101e-02f, 2.43773475e-01f,
  -2.31516361e-02f, -9.65290219e-02f, -7.37193078e-02f, 8.08957890e-02f, 5.85199073e-02f, -8.82957317e-03f, 1.15030438e-01f, 1.28127569e-02f, 1.41212210e-01f, 2.24891696e-02f,
  1.86545491e-01f, 1.01649158e-01f, 9.65277851e-02f, 5.08449078e-02f, -1.83414910e-02f, 1.89167500e-01f, -9.32899565e-02f, 1.61486611e-01f, 1.28595009e-01f, 3.90969664e-02f,
  2.78674322e-03f, 4.73826043e-02f, 7.00334683e-02f, 9.19597894e-02f, 7.21250251e-02f, -4.55708206e-01f, 3.09422642e-01f, -1.95659101e-01f, -1.32765710e-01f, 4.10455644e-01f,
  1.30655080e-01f, 2.71856517e-01f, 4.00968567e-02f, -1.37920398e-02f, -1.67214260e-01f, 3.14174622e-01f, 1.23705044e-01f, 4.00086373e-01f, -1.10309333e-01f, -4.69664969e-02f,
  -9.03430358e-02f, 5.26780665e-01f, 8.60057026e-02f, 3.05484775e-02f, 2.24586457e-01f, -3.12141553e-02f, 3.70616734e-01f, 4.10379440e-01f, 9.28038135e-02f, -1.08420812e-01f,
  1.56854868e-01f, 8.27722698e-02f, -1.77063346e-02f, 1.65170357e-01f, 2.97520310e-01f, 6.83304965e-02f, -3.00625414e-01f, -1.87971413e-01f, -1.10202350e-01f, 1.38953000e-01f,
  -1.44394249e-01f, -2.67671198e-01f, 1.60752907e-01f, 2.57238802e-02f, 8.99548754e-02f, -3.09496485e-02f, -1.48088083e-01f, -2.08356217e-01f, 6.19642958e-02f, -6.98087364e-02f,
  3.19407105e-01f, 2.15784505e-01f, -1.17687359e-01f, 3.57443333e-01f, 4.93550450e-01f, 1.31312713e-01f, 1.97786808e-01f, -6.59327358e-02f, -4.66977758e-03f, 4.20786917e-01f,
  1.28596425e-01f, -1.25461772e-01f, 3.42441857e-01f, 1.81249112e-01f, -2.06177741e-01f, 2.03891411e-01f, -6.52138726e-04f, -7.20242709e-02f, -2.85329372e-02f, -5.97789399e-02f,
  4.48417179e-02f, -2.86715142e-02f, 2.24774852e-01f, -3.99693139e-02f, -1.19508162e-01f, 1.13636060e-02f, 4.87734117e-02f, -4.25902270e-02f, 1.24814190e-01f, 2.08050851e-02f,
  -3.38275321e-02f, -6.48186803e-02f, -6.80763787e-03f, -7.92930797e-02f, -3.98360267e-02f, 6.75142854e-02f, -1.11756362e-01f, 1.89642292e-02f, 3.77384908e-02f, -8.92014578e-02f,
  2.35985920e-01f, 4.47122455e-02f, -5.51163442e-02f, -1.47714820e-02f, 1.39936030e-01f, -9.46138725e-02f, 2.88354903e-02f, -2.44898275e-02f, 1.35431334e-01f, 1.65264338e-01f,
  2.89161950e-02f, 3.38858008e-01f, 1.65823191e-01f, 3.87929738e-01f, 2.24925786e-01f, 1.18678324e-01f, 1.21395327e-01f, -1.62853837e-01f, 2.26315901e-01f, 1.24412432e-01f,
  -7.38546476e-02f, 2.26886824e-01f, 9.39795151e-02f, -1.12048768e-01f, 1.10770250e-02f, -1.37382358e-01f, 3.81076746e-02f, -1.23540305e-01f, 5.55556178e-01f, 2.55933195e-01f,
  2.85283446e-01f, 1.74565867e-01f, 6.48759454e-02f, 1.16548367e-01f, -2.35780254e-02f, 3.91826540e-01f, 1.65574640e-01f, 3.16300690e-02f, 1.63148135e-01f, 3.88145098e-03f,
  2.63612065e-02f, -1.62416756e-01f, -1.19740546e-01f, 1.34672731e-01f, 2.66130030e-01f, 1.68820456e-01f, -1.08210659e-02f, 5.91655709e-02f, -1.37012405e-03f, -4.91448082e-02f,
  3.88106629e-02f, 1.26557797e-01f, -1.18098855e-01f, -7.20054656e-02f, -8.75040889e-02f, 1.98485836e-01f, 1.62084818e-01f, -1.90079719e-01f, -6.25142753e-02f, -8.50570574e-02f,
  2.77706802e-01f, 3.96028794e-02f, -1.08122081e-01f, -1.98989421e-01f, -1.11615814e-01f, -5.42174131e-02f, -1.71343818e-01f, 2.06357211e-01f, -1.23251267e-01f, -4.99570509e-04f,
  -7.22577795e-02f, -1.16772735e-02f, 2.21777454e-01f, 6.23525167e-03f, 2.88815767e-01f, 3.35406929e-01f, 2.90126055e-01f, -5.17211184e-02f, 4.45393883e-02f, 1.58680543e-01f,
  -2.00994872e-02f, 3.28500330e-01f, 1.68008618e-02f, 8.71622935e-02f, 1.18374690e-01f, 1.65038258e-01f, -1.35025516e-01f, 2.27883205e-01f, -1.97371513e-01f, -1.42623425e-01f,
  2.03546226e-01f, -3.06782842e-01f, -6.10407107e-02f, 8.58963653e-02f, -8.71503800e-02f, 6.77353218e-02f, 5.60495816e-02f, -4.30597030e-02f, -1.93187490e-01f, -1.09979495e-01f,
  -2.48400476e-02f, 1.99712440e-01f, 1.18533909e-01f, -1.48117272e-02f, 2.86177676e-02f, -2.58136378e-03f, -1.49435356e-01f, -6.96638599e-02f, 7.19071180e-02f, -1.36575522e-02f,
  2.28945147e-02f, 2.35886797e-02f, -7.69096240e-02f, -1.08831108e-01f, -7.14941695e-02f, 1.41907394e-01f, -2.08751410e-01f, 3.01003456e-02f, -1.42211437e-01f, -5.68844527e-02f,
  -1.57614306e-01f, -6.77338019e-02f, 1.43252939e-01f, -6.24243869e-03f, -5.58935180e-02f, 1.72405735e-01f, -2.34817144e-05f, 1.45643666e-01f, -1.36820465e-01f, 1.29003435e-01f,
  -5.30978702e-02f, -5.90159111e-02f, -1.67003393e-01f, -1.34341583e-01f, -5.24025559e-02f, -3.15155238e-02f, -9.23307687e-02f, -1.56037316e-01f, 9.28017125e-02f, -8.34312513e-02f,
  -1.85508449e-02f, 1.98275782e-02f, 3.29035781e-02f, 2.49283072e-02f, 1.85211286e-01f, 1.62554868e-02f, 1.39424115e-01f, 3.53188291e-02f, -5.57424463e-02f, -5.94602115e-02f,
  3.16940323e-02f, 2.33009487e-01f, -6.76566511e-02f, 8.29402879e-02f, -5.19050471e-02f, -7.85547048e-02f, 9.97074321e-02f, -1.44193336e-01f, -4.51523922e-02f, 1.27859876e-01f,
  2.08226651e-01f, 2.05864329e-02f, -8.46275240e-02f, -1.96000353e-01f, -1.00478813e-01f, -7.90220797e-02f, 1.18496314e-01f, -1.04985632e-01f, 1.01441585e-01f, 2.28973683e-02f,
  1.47379890e-01f, -3.75940591e-01f, 2.18107656e-01f, 2.73810387e-01f, 3.20044279e-01f, 3.35962087e-01f, -1.42634436e-01f, -3.12439620e-01f, 2.88027860e-02f, 9.36827064e-02f,
  -3.27278614e-01f, 6.88861191e-01f, 8.56367424e-02f, 5.62041253e-02f, 5.48621714e-02f, 7.66939968e-02f, 8.00382160e-03f, 2.83140779e-01f, 1.66178904e-02f, 7.34973997e-02f,
  2.27159724e-01f, 2.58003086e-01f, 3.43784578e-02f, -8.75528753e-02f, 4.96271364e-02f, 2.88500488e-01f, -2.14954376e-01f, 4.19435278e-02f, -1.65560931e-01f, 1.43363446e-01f,
  -6.98360568e-03f, 3.61148059e-01f, 1.27959654e-01f, 2.65590996e-01f, 5.88186570e-02f, -7.62468800e-02f, -2.19500214e-01f, -2.41778925e-01f, 8.37890953e-02f, 3.47274542e-01f,
  1.27101913e-01f, -6.85472637e-02f, 7.05810934e-02f, -2.38445088e-01f, -5.57132363e-02f, 1.67806447e-02f, -1.10151162e-02f, 2.23572940e-01f, -5.13327830e-02f, -5.95773496e-02f,
  4.05531734e-01f, 9.24424157e-02f, 3.18111628e-02f, 1.53249325e-02f, -2.25428998e-01f, 2.53913879e-01f, -1.98850453e-01f, -4.68583107e-02f, 2.87378058e-02f, 3.35719362e-02f,
  7.59325027e-02f, -1.07614383e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 26)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 26;
const float L1_fan_Bp_bar_data[] = {
  2.89361328e-01f, 4.52159494e-01f, 4.42050509e-02f, 1.52031574e-02f, 5.53479314e-01f, 9.40189213e-02f, 2.25015476e-01f, -3.17086023e-03f, -1.21926412e-01f, 1.84406072e-01f,
  2.81730443e-01f, 1.82165280e-02f, 3.28893274e-01f, 1.77826986e-01f, 1.55273557e-01f, 1.97029635e-01f, 2.36444950e-01f, -4.56677284e-03f, -1.23074792e-01f, 1.26843765e-01f,
  1.98863819e-01f, 4.33598220e-01f, -1.50314018e-01f, -9.65062063e-03f, 3.46344352e-01f, 3.29928428e-01f
};

// L2_fan_Wp (Shape: 3 x 32)
const int L2_fan_Wp_rows = 3;
const int L2_fan_Wp_cols = 32;
const float L2_fan_Wp_data[] = {
  4.73164879e-02f, -2.21763596e-01f, -2.96633065e-01f, 4.65524971e-01f, 2.31957436e-01f, 4.90866661e-01f, -2.45783418e-01f, -2.31628388e-01f, 1.09434351e-01f, -8.51146951e-02f,
  -8.83631781e-03f, 4.30646352e-02f, -6.43655285e-03f, -8.61568898e-02f, 1.30295783e-01f, 1.89193785e-01f, 1.41892701e-01f, 9.69641507e-02f, -2.13586260e-02f, 9.54598654e-03f,
  -1.06532142e-01f, 1.78047001e-01f, 1.97372749e-01f, 2.77430583e-02f, -1.33987978e-01f, -1.91586807e-01f, 1.57499015e-01f, 2.01988351e-02f, 1.27341360e-01f, -5.96008375e-02f,
  5.87085262e-02f, -3.87635157e-02f, 4.47261073e-02f, 3.05710077e-01f, -3.02263927e-02f, 7.07050189e-02f, -5.35602570e-02f, -1.29112735e-01f, -4.29090485e-02f, 1.16527006e-01f,
  1.29456937e-01f, 5.53356409e-02f, -2.05444902e-01f, -3.26779447e-02f, -1.06269926e-01f, -5.68726957e-02f, 8.65167454e-02f, -7.03550354e-02f, 1.35421023e-01f, 1.07829645e-01f,
  -2.27542162e-01f, 1.87540520e-02f, -1.61501959e-01f, -1.57585010e-01f, -5.95439188e-02f, -1.85210526e-01f, -3.04805133e-02f, -9.72933397e-02f, 5.00964448e-02f, 1.27231598e-01f,
  5.45363314e-02f, -7.62704089e-02f, 9.91849080e-02f, -2.77152032e-01f, 1.76387876e-01f, 1.38097778e-01f, -2.12675452e-01f, 8.28397274e-03f, 1.16298907e-01f, -4.94503081e-02f,
  2.10015014e-01f, -2.23524302e-01f, -4.15195264e-02f, 1.82882175e-01f, 2.92539835e-01f, 1.34895951e-01f, 3.59066688e-02f, 2.94744313e-01f, -1.22601971e-01f, -4.37195003e-02f,
  1.71182767e-01f, 2.08455443e-01f, -1.23712450e-01f, -1.33467183e-01f, -2.01424938e-02f, 1.74370757e-03f, -6.73173815e-02f, 3.11938375e-01f, 5.56310043e-02f, 2.15668064e-02f,
  8.25162306e-02f, -3.38872552e-01f, 2.51466362e-03f, -9.76551026e-02f, 1.35500878e-01f, 4.70292345e-02f
};

// L2_fan_Wp_bar (Shape: 26 x 32)
const int L2_fan_Wp_bar_rows = 26;
const int L2_fan_Wp_bar_cols = 32;
const float L2_fan_Wp_bar_data[] = {
  1.09917410e-01f, -1.33006200e-01f, -3.58451903e-02f, 1.74037457e-01f, -2.31013998e-01f, 1.74184665e-01f, 2.72350153e-03f, -1.99825019e-01f, -1.05716303e-01f, 1.63359210e-01f,
  3.89351130e-01f, 5.36727495e-02f, 8.96811113e-02f, -7.33639747e-02f, 1.59907281e-01f, 8.42410102e-02f, 2.90247668e-02f, 1.35860229e-02f, -7.23742843e-02f, -7.74737448e-02f,
  1.88245356e-01f, -1.13126747e-01f, 1.71931591e-02f, -7.73115605e-02f, -1.28274798e-01f, 1.96946338e-01f, 1.80939455e-02f, -7.04434663e-02f, 6.27339482e-02f, 6.39698207e-02f,
  1.74763203e-01f, 7.11811241e-03f, 1.67587861e-01f, 2.03200117e-01f, -3.90672423e-02f, 4.02983725e-01f, 1.76862925e-01f, 2.07496643e-01f, -1.58961654e-01f, -1.86177537e-01f,
  -3.42111588e-02f, 1.44737720e-01f, 4.59708214e-01f, -6.05919436e-02f, 6.16863668e-02f, 1.21663317e-01f, -7.71187199e-03f, 1.50804058e-01f, 1.52399629e-01f, -8.18466395e-02f,
  2.85307914e-02f, -6.43823445e-02f, 1.76344484e-01f, -7.66819343e-02f, 3.54553223e-01f, 3.01267415e-01f, 1.47035673e-01f, 6.29940331e-02f, -9.49270371e-03f, -6.42262921e-02f,
  -1.98650528e-02f, -7.15320632e-02f, 3.08108270e-01f, -1.58691838e-01f, 3.41156453e-01f, 1.90800428e-01f, 2.18519107e-01f, -1.66666329e-01f, -1.08331673e-01f, 1.39732122e-01f,
  3.86036247e-01f, 1.34234890e-01f, -1.16592370e-01f, 2.07958430e-01f, -6.05828222e-03f, -9.01459083e-02f, -9.92505699e-02f, 2.40775675e-01f, 1.35110319e-01f, -2.42640004e-01f,
  -9.80535001e-02f, 6.95884414e-03f, -2.65312135e-01f, 2.27698281e-01f, -1.89106956e-01f, 2.26471245e-01f, 1.86134994e-01f, 2.26103261e-01f, -2.10166350e-01f, 3.72981727e-01f,
  1.13683522e-01f, 1.52952015e-01f, 4.82624061e-02f, -1.20030314e-01f, 2.03439638e-01f, 2.05881614e-02f, -4.79496606e-02f, 3.07323456e-01f, 2.09712461e-01f, 3.21321666e-01f,
  1.63125023e-01f, 3.62806946e-01f, -2.93513805e-01f, -2.13292867e-01f, 1.71124011e-01f, -2.43446365e-01f, 6.93267882e-01f, 3.60270590e-01f, -6.28234074e-02f, 1.86420128e-01f,
  4.01026942e-02f, 1.22054450e-01f, 1.12499200e-01f, 2.07165807e-01f, -1.48967162e-01f, -2.06026182e-01f, 2.17355620e-02f, 2.92697996e-01f, -2.77691837e-02f, 4.30119663e-01f,
  3.25545259e-02f, 1.20328039e-01f, -4.36969660e-02f, 4.36830819e-02f, -7.64434561e-02f, -9.50190350e-02f, -1.03339933e-01f, 2.57420391e-01f, 1.26910716e-01f, 4.01953340e-01f,
  4.01813895e-01f, 2.12819517e-01f, 1.37239784e-01f, -7.22979248e-01f, 6.28218502e-02f, 7.65455425e-01f, -3.60611193e-02f, -9.30069461e-02f, -5.02336025e-01f, 3.59731838e-02f,
  5.65503165e-02f, 8.59474689e-02f, -2.64007568e-01f, 1.61339760e-01f, 3.17402720e-01f, -1.69765174e-01f, 1.47856131e-01f, 1.93969563e-01f, 3.04068655e-01f, -1.75786138e-01f,
  -6.01379387e-02f, -2.62301207e-01f, 5.90266136e-04f, 2.79247135e-01f, 3.15452158e-01f, 3.98533136e-01f, 5.35427593e-02f, 9.95829701e-02f, 1.63191676e-01f, -1.37978166e-01f,
  3.42056394e-01f, 4.41378653e-01f, 1.17208436e-01f, -3.09878856e-01f, -3.96639556e-01f, -2.51310349e-01f, 6.95740342e-01f, 3.55482042e-01f, 4.74024611e-03f, 2.41826549e-02f,
  -1.22109670e-02f, -1.46765545e-01f, -2.31047109e-01f, 3.61928105e-01f, -8.03902224e-02f, -1.45985708e-01f, 1.27222165e-01f, 6.35541975e-02f, -3.20937663e-01f, -8.36941600e-02f,
  -6.98357299e-02f, 1.63171694e-01f, -1.87420577e-01f, 4.86403555e-02f, -1.99488193e-01f, 6.33356929e-01f, -1.12894559e-02f, 5.63143604e-02f, -5.15395477e-02f, -1.23457454e-01f,
  3.94031145e-02f, 2.02850893e-01f, -1.56278953e-01f, 2.79626567e-02f, 9.65498909e-02f, -2.90366530e-01f, -1.23358458e-01f, 9.86586604e-03f, 1.49622113e-01f, 2.50124335e-01f,
  8.80089402e-02f, -1.64104238e-01f, -9.71677825e-02f, 1.03879824e-01f, 1.41743049e-01f, -1.46904796e-01f, 1.62927315e-01f, 2.10981995e-01f, -1.62641227e-01f, -9.97778550e-02f,
  -2.69323345e-02f, -4.31030020e-02f, 6.90794289e-02f, 5.72829098e-02f, 6.48647249e-02f, 1.14312962e-01f, 1.27614409e-01f, 1.41041473e-01f, -6.29375950e-02f, 1.67969856e-02f,
  -7.45865479e-02f, 4.09125797e-02f, -7.42262453e-02f, -1.83810443e-01f, 3.68470758e-01f, 3.64783257e-01f, 1.52252004e-01f, 1.54581979e-01f, 2.80784518e-01f, 2.38355502e-01f,
  8.08610618e-02f, 2.23990716e-02f, 1.52876228e-01f, -1.04485542e-01f, -4.85296994e-02f, 1.91923365e-01f, 7.70549923e-02f, -7.38612190e-02f, 1.37638459e-02f, 3.29598598e-02f,
  2.73709595e-01f, -1.12319747e-02f, 6.31891415e-02f, -1.89769238e-01f, -1.01674803e-01f, 1.05753049e-01f, 2.74928659e-01f, -2.08934978e-01f, -5.53406402e-02f, -1.82202250e-01f,
  4.81671803e-02f, 3.80419016e-01f, -6.21398278e-02f, 5.74862920e-02f, 2.54790410e-02f, 2.91747838e-01f, -9.31508988e-02f, 4.52276282e-02f, -2.69558400e-01f, 3.21336240e-01f,
  2.70874798e-01f, 1.82356745e-01f, 8.59737992e-02f, -1.60587773e-01f, 6.05657361e-02f, 4.11935374e-02f, 3.64649296e-01f, 1.01876624e-01f, 5.03667705e-02f, -3.02182045e-02f,
  -1.55056164e-01f, 5.77609800e-02f, 7.44982958e-02f, -2.47197715e-03f, -1.59674957e-01f, -1.61738083e-01f, 5.43809757e-02f, -8.81569460e-02f, 2.94769377e-01f, 1.09350286e-01f,
  1.16886109e-01f, -2.23621994e-01f, 3.79079431e-02f, 6.71552867e-02f, 3.38413082e-02f, -1.22535765e-01f, 6.54906267e-03f, 1.01671796e-02f, 2.65444547e-01f, 9.29317996e-02f,
  9.92933810e-02f, 6.76950812e-02f, 4.97340374e-02f, 6.20796308e-02f, 1.84360117e-01f, 6.07218742e-01f, 1.04563609e-01f, 5.20555340e-02f, 1.02209255e-01f, -2.70436555e-01f,
  2.39568293e-01f, -2.75487572e-01f, 8.54828283e-02f, 4.11797881e-01f, -2.72700995e-01f, 1.16010718e-01f, 2.89944828e-01f, 2.34392911e-01f, 1.74400344e-01f, -3.38169038e-02f,
  3.45381290e-01f, -1.77956149e-01f, 9.54717547e-02f, 2.29009926e-01f, -6.68870211e-02f, -1.41261891e-01f, -1.43548042e-01f, -4.70029339e-02f, 5.99140406e-01f, -3.04454476e-01f,
  -3.92700657e-02f, 3.41788232e-01f, 3.49445522e-01f, -6.35449946e-01f, -2.64341712e-01f, -2.07962751e-01f, 3.83755088e-01f, 8.35444480e-02f, 3.65127660e-02f, -2.54997671e-01f,
  2.60532767e-01f, 3.44060622e-02f, 4.27802913e-02f, -7.61616901e-02f, -1.94444239e-01f, 1.03632711e-01f, -1.01709336e-01f, 5.50957024e-03f, 1.36259079e-01f, -5.87710254e-02f,
  9.64889377e-02f, 3.48893441e-02f, -2.17366174e-01f, -8.43613595e-02f, 8.71142074e-02f, 2.38888443e-01f, 1.96119159e-01f, 2.97123548e-02f, -2.69159108e-01f, -3.41097265e-02f,
  -3.43898803e-01f, 2.59496301e-01f, -1.95363075e-01f, -1.13847055e-01f, -1.43128440e-01f, -4.38928604e-02f, -1.92188527e-02f, 1.89123806e-02f, -1.10981785e-01f, -1.43047616e-01f,
  6.46367967e-02f, -1.09263003e-01f, 4.77399886e-01f, -1.17137201e-01f, 8.18827078e-02f, 1.06733270e-01f, -1.69626493e-02f, 2.56427050e-01f, -4.77486569e-03f, 6.33175820e-02f,
  4.97685513e-04f, -1.25055999e-01f, 1.39741629e-01f, 2.31898855e-02f, -1.28040567e-01f, 2.54648685e-01f, 1.56583816e-01f, -9.28412601e-02f, 3.36201079e-02f, -2.20046744e-01f,
  2.17572320e-03f, -1.79014802e-01f, -5.60812503e-02f, -2.49840505e-03f, -1.22025006e-01f, -2.83315554e-02f, 2.95812041e-01f, -3.03346246e-01f, -3.75618756e-01f, 2.21193880e-02f,
  2.32430443e-01f, 3.21209691e-02f, -9.76121873e-02f, 1.05533153e-01f, 2.04733342e-01f, 1.87880814e-01f, -1.07678629e-01f, 8.18315372e-02f, -9.81024504e-02f, -7.29893744e-02f,
  1.61300048e-01f, 1.26394937e-02f, 7.43346810e-02f, -1.80826172e-01f, 1.64386407e-01f, -1.19171858e-01f, -2.58507192e-01f, 3.38707507e-01f, -1.97799712e-01f, 2.53711008e-02f,
  -6.71949983e-02f, 3.86795588e-02f, -5.69196185e-03f, -4.31114137e-02f, -2.04908460e-01f, 1.71413302e-01f, 1.30565211e-01f, -5.78964576e-02f, -1.17268726e-01f, 1.27744988e-01f,
  7.71974698e-02f, -1.65419169e-02f, 2.04559982e-01f, 3.38353664e-02f, 5.38593009e-02f, -8.50443840e-02f, 3.81338336e-02f, -1.70842886e-01f, -5.09091606e-03f, -1.45228937e-01f,
  1.07300058e-01f, -3.23026367e-02f, 1.50677487e-01f, 1.28751919e-01f, 1.46420166e-01f, 1.84123129e-01f, -1.55709535e-01f, -8.21751952e-02f, 2.62550533e-01f, -1.60952508e-01f,
  -1.79492235e-01f, 1.13870770e-01f, 1.35966301e-01f, 1.16519600e-01f, -9.88374203e-02f, 8.20978731e-02f, 3.95563304e-01f, -9.52513888e-02f, -5.43966852e-02f, 1.20183237e-01f,
  4.08240169e-01f, 5.46604633e-01f, 5.10665536e-01f, -5.65290116e-02f, -2.61146277e-01f, -3.99478078e-02f, -1.05296403e-01f, 3.17528322e-02f, -1.99681088e-01f, 1.48008332e-01f,
  2.41819724e-01f, 5.03893346e-02f, -1.13492399e-01f, 1.58171535e-01f, 3.29162925e-01f, -7.45855495e-02f, 2.80251235e-01f, -2.10184723e-01f, 2.34864488e-01f, 2.90556967e-01f,
  3.12687337e-01f, 1.07051350e-01f, -1.93833694e-01f, -4.79540341e-02f, -6.16863295e-02f, 1.50911435e-01f, -4.12205756e-02f, 1.44576460e-01f, -1.59756199e-01f, -2.82034418e-03f,
  1.89549044e-01f, 1.79833338e-01f, 2.28744343e-01f, -1.58247367e-01f, -1.00828826e-01f, 4.04752523e-01f, -9.33442712e-02f, 7.99975842e-02f, -1.22849345e-01f, -1.79278806e-01f,
  5.37643015e-01f, -1.73960745e-01f, 5.61173335e-02f, -1.64975420e-01f, -1.07134692e-01f, -1.32103264e-01f, -1.76357836e-01f, -6.31012081e-04f, -2.65251666e-01f, -6.16957135e-02f,
  3.15826945e-02f, -3.58325578e-02f, -1.60925955e-01f, -1.52492464e-01f, -1.78194597e-01f, -1.78758204e-02f, 1.86656211e-02f, -8.77674948e-03f, 8.26605782e-02f, 9.69540626e-02f,
  1.16661631e-01f, -8.00961480e-02f, 1.44145623e-01f, 4.04345840e-01f, 1.48250952e-01f, -3.78571689e-01f, -2.12105021e-01f, 4.09840614e-01f, -1.64486676e-01f, 1.38792368e-02f,
  -9.53917056e-02f, -2.27619875e-02f, 7.36687601e-01f, 3.17456454e-01f, -7.38801658e-02f, -6.67189360e-02f, 7.63729513e-02f, 3.09027255e-01f, -3.30211706e-02f, 1.47638828e-01f,
  -2.22120777e-01f, 1.56084254e-01f, -2.03904942e-01f, 5.48031330e-02f, -8.15712884e-02f, -4.25376371e-02f, -1.53095588e-01f, -6.61850572e-02f, -2.09219128e-01f, 4.39612521e-03f,
  -1.29326060e-01f, -1.28733153e-02f, 2.19379574e-01f, -7.52921328e-02f, 4.71188575e-02f, 1.37603700e-01f, 2.27731779e-01f, 8.67100060e-02f, 3.31760719e-02f, -3.57308388e-01f,
  2.08223984e-01f, 3.47786874e-01f, -7.56363571e-02f, 9.29848105e-02f, -2.05304489e-01f, -4.37068790e-02f, 1.41369432e-01f, 1.28459698e-02f, 8.09143186e-02f, -2.19082519e-01f,
  2.48457089e-01f, -4.77315895e-02f, 2.45510018e-03f, -8.32394976e-03f, 8.20773542e-02f, -3.36593613e-02f, 1.64544955e-02f, -1.39618009e-01f, 1.21282399e-01f, 1.29590929e-01f,
  -3.95399425e-03f, 7.01620355e-02f, 7.93682933e-02f, 2.47667376e-02f, -1.80816390e-02f, -3.12002543e-02f, 6.09620521e-03f, 1.34287804e-01f, 9.54810083e-02f, 6.92911386e-01f,
  4.86278653e-01f, 2.06319187e-02f, -1.53643772e-01f, -2.56403863e-01f, -1.09744988e-01f, 8.93162265e-02f, -2.76881922e-02f, 1.65300727e-01f, -1.74773280e-02f, 3.01276267e-01f,
  -1.62633494e-01f, 1.44725636e-01f, 3.02016437e-01f, -1.31558582e-01f, 9.48911980e-02f, 3.43503952e-02f, 2.26102605e-01f, 9.04923677e-02f, 4.07519728e-01f, 3.63533907e-02f,
  5.97626269e-02f, -1.55817391e-02f, 2.08968550e-01f, 1.68918982e-01f, -9.87118334e-02f, -5.91995977e-02f, -4.49437983e-02f, 2.56912887e-01f, 6.19893253e-01f, 6.95298493e-01f,
  9.23116148e-01f, -9.66809452e-01f, -3.11914742e-01f, 2.44734198e-01f, 1.36578679e-01f, 2.96270996e-01f, 1.50164915e-02f, -1.51565567e-01f, 4.11856294e-01f, 5.91194555e-02f,
  1.23204283e-01f, -3.72109890e-01f, -1.31005328e-02f, 5.73724583e-02f, -2.20944777e-01f, -1.88181326e-01f, 7.78577775e-02f, -1.11170141e-02f, -3.60775851e-02f, -1.16519583e-02f,
  -1.05303518e-01f, -4.41383839e-01f, 1.06324725e-01f, -1.75755054e-01f, -2.37257317e-01f, 4.29588497e-01f, -2.06066966e-01f, -1.23517603e-01f, -2.88456649e-01f, 3.36026430e-01f,
  1.55406117e-01f, 6.11261986e-02f, -1.21206507e-01f, -9.88582671e-02f, -1.69797599e-01f, 2.91735649e-01f, -5.87460920e-02f, -1.45763218e-01f, 2.51206532e-02f, -1.39912680e-01f,
  -1.28256697e-02f, 1.24840617e-01f, -1.30340248e-01f, -1.67148724e-01f, -4.07156646e-02f, -1.09597534e-01f, -5.45340553e-02f, -3.78243662e-02f, 1.22061454e-01f, -1.03108972e-01f,
  1.23206586e-01f, -1.56146120e-02f, -2.09392905e-02f, 8.96773860e-03f, -1.09241359e-01f, -7.68938437e-02f, 1.68368712e-01f, -6.45228550e-02f, -1.04083605e-01f, 1.68314174e-01f,
  6.02932945e-02f, -2.60555055e-02f, 1.21701770e-01f, 2.13366777e-01f, 3.18158925e-01f, 2.60538936e-01f, 5.55868685e-01f, 2.58432627e-01f, -2.49610141e-01f, 5.00989497e-01f,
  1.75269675e-02f, 9.01322216e-02f, -5.97152263e-02f, 5.17494157e-02f, 3.51052940e-01f, 8.14693049e-02f, -1.98903844e-01f, 4.32430983e-01f, -1.23841316e-01f, -2.18024626e-01f,
  5.07330835e-01f, 2.63955712e-01f, 5.50769940e-02f, 1.14678264e-01f, 6.04300678e-01f, -1.60483690e-03f, 1.62814945e-01f, 9.11926329e-02f, -1.61177918e-01f, 1.12200044e-01f,
  -4.40652035e-02f, -6.88341260e-03f, 3.95090550e-01f, -1.60845801e-01f, -2.90207744e-01f, 1.53466225e-01f, 2.98025906e-01f, -4.71216619e-01f, -2.12860242e-01f, 8.90441388e-02f,
  -2.54664391e-01f, 2.04018041e-01f, 1.71760783e-01f, -1.82323009e-01f, 2.12382168e-01f, 9.01666135e-02f, 2.53609657e-01f, 7.85735846e-02f, -1.45628350e-02f, 5.33633709e-01f,
  -7.04934075e-02f, -2.95003831e-01f, 3.09378445e-01f, -1.45151600e-01f, 8.17122981e-02f, -8.41233358e-02f, 2.84466147e-01f, 3.69939655e-01f, 6.80986093e-03f, 1.20489247e-01f,
  8.28072876e-02f, -8.37180391e-02f, 1.89478248e-02f, 2.30476409e-01f, -2.32873604e-01f, 2.77329028e-01f, 1.23067899e-02f, -1.24558359e-01f, -1.28074139e-01f, 7.04871938e-02f,
  2.06184253e-01f, -3.14641088e-01f, 2.81594872e-01f, 2.30750129e-01f, 4.98112068e-02f, -1.43534299e-02f, -2.63314545e-01f, -7.06177205e-02f, -4.85160872e-02f, 2.62301654e-01f,
  -4.48343605e-02f, -3.09411287e-01f, 2.43645579e-01f, 3.45232687e-03f, 3.42877544e-02f, 9.00544077e-02f, -1.94972545e-01f, 1.72960743e-01f, -1.52186975e-02f, 9.65374634e-02f,
  -1.12547494e-01f, 3.79150420e-01f, 1.26863837e-01f, -1.09857313e-01f, 7.97316879e-02f, -1.43695384e-01f, 3.10068280e-01f, 9.97443944e-02f, -1.91242784e-01f, -1.09472595e-01f,
  -1.67638764e-01f, 1.25267580e-01f, -3.77915353e-02f, 1.15444876e-01f, 7.88293630e-02f, -3.56931314e-02f, -1.01933599e-01f, 1.49996594e-01f, 4.89300519e-01f, -3.11948024e-02f,
  -8.38935375e-02f, -1.81775048e-01f, 9.60390568e-02f, 3.40811193e-01f, -2.39369050e-01f, 1.96084678e-02f, 1.70858875e-02f, -8.57772008e-02f, 2.43805900e-01f, -2.03248590e-01f,
  5.44829294e-02f, -9.64942798e-02f, -8.26928485e-03f, 5.86782470e-02f, -1.90285407e-02f, -1.12537518e-01f, 1.06754033e-02f, -1.22570455e-01f, 1.11906767e-01f, -2.10343808e-01f,
  -1.16857708e-01f, 5.00600226e-02f, -6.44833669e-02f, -3.14687550e-01f, -2.49298457e-02f, 2.89806962e-01f, 7.25336745e-02f, -1.32410690e-01f, -3.12462952e-02f, -6.70521036e-02f,
  8.08939636e-01f, 9.33732092e-02f, -7.30516091e-02f, -2.47661937e-02f, -1.32236034e-02f, 3.03039700e-01f, -1.53553575e-01f, -7.36667775e-03f, -7.58698583e-02f, -9.85936895e-02f,
  8.22792575e-02f, -1.13767870e-01f, -2.53929105e-02f, 6.11009598e-02f, -2.94963140e-02f, 8.54104906e-02f, -2.31737062e-01f, -1.77768871e-01f, -1.90453187e-01f, -8.24135244e-02f,
  -2.89165657e-02f, -4.05142317e-03f
};

// L2_fan_Bp_bar (Shape: 1 x 26)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 26;
const float L2_fan_Bp_bar_data[] = {
  5.15167341e-02f, 7.00982064e-02f, 1.44935399e-01f, 2.45674357e-01f, 5.61384857e-01f, 2.08330363e-01f, 7.44505897e-02f, 3.19942564e-01f, 5.07831872e-02f, 4.28846804e-03f,
  2.88007498e-01f, 7.50217959e-02f, 4.18271832e-02f, 2.56639812e-02f, 2.06201434e-01f, 6.93249106e-02f, 2.32548758e-01f, 1.08044008e-02f, 2.50859469e-01f, 6.55849457e-01f,
  6.59282953e-02f, 4.18567568e-01f, 2.15896651e-01f, 1.87231079e-01f, -1.04949676e-01f, 1.80162415e-01f
};

// L3_linear_W (Shape: 12 x 32)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 32;
const float L3_linear_W_data[] = {
  5.35832703e-01f, 1.87613383e-01f, 4.48470920e-01f, 4.74644363e-01f, 1.94222286e-01f, -2.41796255e-01f, 4.97330688e-02f, 2.68509444e-02f, -1.38214782e-01f, 9.55654010e-02f,
  7.17748225e-01f, -1.85199395e-01f, -3.01328629e-01f, 3.56420338e-01f, 7.81462491e-02f, -2.63430059e-01f, -2.63054669e-01f, -2.48101652e-01f, -1.93033487e-01f, 6.75315857e-02f,
  6.49434745e-01f, 5.33133633e-02f, -4.14178044e-01f, 2.54139274e-01f, 5.58750629e-01f, -3.88700455e-01f, 1.91667154e-02f, 2.48891011e-01f, -4.22712803e-01f, 2.49652937e-01f,
  -2.04060912e-01f, -3.84328038e-01f, 2.06329852e-01f, -8.18234608e-02f, -1.20569207e-01f, 8.98076296e-01f, -3.36150587e-01f, 7.10207880e-01f, -8.17824230e-02f, 4.52724576e-01f,
  1.55857787e-01f, 6.41166508e-01f, -5.37800610e-01f, -2.96362221e-01f, -2.44436860e-01f, 1.60403550e-01f, 9.97172967e-02f, -1.55750677e-01f, -2.79224724e-01f, 4.91059339e-03f,
  3.27668339e-02f, -2.39443421e-01f, 4.88943666e-01f, -1.83999553e-01f, -2.30655700e-01f, -1.45570323e-01f, 4.38828498e-01f, -2.26814166e-01f, -1.34276554e-01f, 2.34464332e-01f,
  2.49004692e-01f, -1.02022931e-01f, -3.01695526e-01f, -8.08529630e-02f, -4.60854590e-01f, -7.66843110e-02f, -5.82975924e-01f, 5.31098843e-01f, -1.27091572e-01f, -9.59425643e-02f,
  2.99252003e-01f, 4.95917290e-01f, -1.24488711e-01f, 4.77586657e-01f, -4.47456926e-01f, -2.61530459e-01f, -1.69663876e-01f, 6.30425364e-02f, 5.66977739e-01f, -4.16745022e-02f,
  -4.39905733e-01f, 3.61106843e-01f, -1.89744189e-01f, -5.69180846e-02f, -2.37601832e-01f, 5.36048897e-02f, 4.13634926e-01f, 8.47338960e-02f, 2.53537834e-01f, -6.94390178e-01f,
  2.27515757e-01f, -4.01069969e-01f, -2.90166408e-01f, 8.61016735e-02f, 3.87057513e-01f, 3.18965048e-01f, -2.16103151e-01f, -5.66920340e-02f, -6.94528595e-03f, -4.50330764e-01f,
  1.54628158e-01f, 1.39633417e-02f, -6.34832159e-02f, -1.24555677e-01f, 2.30096817e-01f, -3.97082448e-01f, 5.86922467e-01f, 4.61308897e-01f, -7.23365247e-02f, -1.61211744e-01f,
  -9.03614834e-02f, 3.75129580e-01f, -1.84728444e-01f, -6.48076981e-02f, -3.17626297e-01f, 2.63547838e-01f, -1.74152572e-02f, -1.11747265e-01f, -4.83306438e-01f, 4.23948050e-01f,
  -1.23509131e-01f, -4.08013165e-01f, -1.97352275e-01f, 7.97759369e-02f, -5.45491517e-01f, 4.88134891e-01f, -1.10847503e-01f, -3.79972607e-01f, -8.62857923e-02f, 1.79416075e-01f,
  4.33956951e-01f, -5.53243160e-01f, -3.39370295e-02f, -5.25454618e-02f, -7.99801499e-02f, -5.27228974e-02f, 2.86713690e-01f, -4.56281126e-01f, 3.08580518e-01f, 7.06786036e-01f,
  5.42845158e-03f, 1.77450046e-01f, -1.40286878e-01f, -1.93534195e-02f, 6.08247340e-01f, -8.76517221e-02f, 1.31894767e-01f, -1.84265748e-01f, -2.11240306e-01f, 6.67081475e-02f,
  -2.71305442e-01f, 3.25791836e-01f, 1.07742243e-01f, 8.73524845e-01f, 1.33872315e-01f, -4.18200076e-01f, -2.78647095e-01f, -2.16727570e-01f, 4.98836860e-02f, -2.76127666e-01f,
  2.77370304e-01f, -7.13729486e-02f, 4.17983383e-01f, -4.02410924e-02f, -1.06161229e-01f, -1.37539923e-01f, -3.35278988e-01f, -2.17686981e-01f, -1.49421185e-01f, 1.11543238e-02f,
  -8.86625424e-02f, -3.53681982e-01f, 6.31576106e-02f, 4.80638146e-01f, -9.95244309e-02f, -1.95182204e-01f, 1.93832785e-01f, -1.91826433e-01f, -2.09524691e-01f, -2.19824031e-01f,
  1.27262041e-01f, -5.41121289e-02f, 2.19450757e-01f, -1.01091228e-01f, -1.02750473e-01f, 8.94647121e-01f, 8.61436352e-02f, 3.29291791e-01f, 4.72882122e-01f, -2.81381845e-01f,
  -3.15910578e-01f, -9.43142176e-02f, 1.37143493e-01f, -8.76590237e-02f, -3.23041648e-01f, 2.00319588e-01f, 1.48683667e-01f, 3.62467289e-01f, 1.53635234e-01f, 2.58733839e-01f,
  -1.02890253e-01f, 7.55867586e-02f, -5.49309134e-01f, -2.33154595e-01f, 2.96731535e-02f, -3.02889168e-01f, -1.20580615e-02f, 1.00669235e-01f, 3.11839879e-02f, 3.03222269e-01f,
  5.24245314e-02f, -5.75150736e-02f, -3.04685026e-01f, 3.62508297e-01f, 3.16909254e-01f, -1.91226810e-01f, -4.42323923e-01f, 1.66667849e-01f, 8.79382491e-02f, -1.52485564e-01f,
  3.12663287e-01f, 2.52062245e-03f, 3.87122720e-01f, 5.63901484e-01f, -2.16085613e-01f, -3.19987595e-01f, -1.54436439e-01f, -2.83143431e-01f, -3.95332932e-01f, 3.22292596e-01f,
  -2.29620170e-02f, 3.29254232e-02f, 4.15692657e-01f, -1.14694200e-01f, 8.63046274e-02f, 7.62202859e-01f, 2.30117273e-02f, -3.97664070e-01f, -2.01215819e-01f, -1.68882817e-01f,
  3.08453858e-01f, 1.07212655e-01f, 2.51706421e-01f, -1.15823068e-01f, -2.24609122e-01f, -1.48461774e-01f, -2.68113852e-01f, 1.51854783e-01f, -2.21124268e-03f, -7.63310671e-01f,
  -4.79531735e-02f, -2.38560066e-01f, 1.27493456e-01f, 4.51887697e-01f, -2.22853515e-02f, -7.40551054e-02f, -3.47939789e-01f, -2.61539727e-01f, -1.33558810e-01f, 5.42208433e-01f,
  -2.55835980e-01f, -5.04367471e-01f, 1.62113562e-01f, 1.78057611e-01f, -2.30378598e-01f, -2.86890566e-01f, -1.40731439e-01f, -3.44324887e-01f, 7.41580501e-02f, 8.28023329e-02f,
  4.46111076e-02f, 4.82638836e-01f, -2.50776857e-01f, -3.84917222e-02f, -2.57236391e-01f, 2.47509941e-01f, 3.10591936e-01f, 5.16725518e-02f, -4.27052289e-01f, -1.86433911e-01f,
  3.06973845e-01f, -4.82793301e-01f, 1.91991463e-01f, 5.86571515e-01f, 1.00313485e-01f, -1.61072910e-01f, 2.74570286e-01f, -1.43550947e-01f, 2.78588206e-01f, 6.66250214e-02f,
  3.17770988e-01f, -2.18742415e-01f, -1.86190397e-01f, 1.37844518e-01f, 1.94111824e-01f, -3.24042231e-01f, 2.61388458e-02f, 3.49313378e-01f, -5.42943656e-01f, 2.05599576e-01f,
  1.30709708e-02f, -7.38337263e-02f, -2.46613204e-01f, -6.00615144e-01f, 3.66714835e-01f, 4.43199277e-03f, 4.50614810e-01f, -1.61689848e-01f, -3.87044698e-01f, 4.85965133e-01f,
  4.82642978e-01f, -1.49982676e-01f, -3.92465502e-01f, 7.44023025e-01f, 1.79864317e-01f, -8.62122178e-01f, 8.61855224e-02f, -1.88958481e-01f, -2.05717623e-01f, 3.98737550e-01f,
  3.83593082e-01f, 2.52229601e-01f, 2.90204316e-01f, 2.03630305e-03f, 1.63423538e-01f, 4.96534631e-02f, 7.40413964e-02f, 2.54016161e-01f, 4.75846767e-01f, -1.75443560e-01f,
  -1.03188738e-01f, 9.56273973e-02f, -1.65198460e-01f, 1.48460269e-01f, -5.34906276e-02f, 5.94624579e-01f, -4.17333990e-01f, -1.20918266e-01f, -2.09376290e-01f, 2.33289406e-01f,
  -2.96122789e-01f, 3.15708846e-01f, 3.95576239e-01f, -3.34527269e-02f, -2.82837212e-01f, 3.21491897e-01f, 3.46472077e-02f, 3.90083462e-01f, -4.25491810e-01f, -5.09468652e-02f,
  -2.99110822e-02f, -1.65663227e-01f, -4.08809066e-01f, -1.01696283e-01f, -1.06796399e-01f, -5.64214885e-01f, 9.35037732e-02f, -5.09739161e-01f, -1.40668318e-01f, -2.24535167e-01f,
  -3.81821364e-01f, -4.16205615e-01f, 6.19321287e-01f, -1.92713991e-01f, 2.60143131e-01f, -3.26540679e-01f, -1.64240927e-01f, 5.36393523e-01f, 1.40675768e-01f, -4.93746251e-02f,
  -3.69060859e-02f, -1.98407739e-01f, -1.31471992e-01f, -2.76792705e-01f, -1.16909280e-01f, 1.83140591e-01f, -3.24264735e-01f, 1.57868177e-01f, -9.71583426e-02f, 2.43848920e-01f,
  3.03185463e-01f, -3.09619278e-01f, 2.09706292e-01f, -1.46734133e-01f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  2.38061786e-01f, 7.41378963e-02f, -1.80888757e-01f, -2.88420469e-01f, 2.25846216e-01f, -2.49538105e-02f, -2.47516241e-02f, -2.41084278e-01f, -2.97216535e-01f, 1.57885432e-01f,
  -1.19396569e-02f, -2.56867766e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 3, 26
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 3, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        32, 3, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        32, 12
    );
    }
    