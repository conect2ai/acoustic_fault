/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 25 x 120)
const int L0_fan_Wp_rows = 25;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  2.10083932e-01f, 4.31872249e-01f, 2.54493594e-01f, 2.22467273e-01f, 1.15499116e-01f, -4.71080728e-02f, 3.31122391e-02f, 1.64333642e-01f, 2.52618521e-01f, -7.90670365e-02f,
  -9.66906175e-02f, 5.12642562e-02f, -9.70847234e-02f, 1.02379978e-01f, 1.13619054e-02f, 3.33853029e-02f, 9.45901573e-02f, -7.18476325e-02f, 1.79987967e-01f, 8.11825693e-02f,
  1.51586393e-02f, -2.55308226e-02f, 4.62061074e-03f, 4.40239422e-02f, 7.57500306e-02f, 7.42790699e-02f, -8.92660767e-02f, 7.42262304e-02f, -4.80989218e-02f, -3.76038924e-02f,
  -1.06605962e-01f, 2.60189138e-02f, 2.22162195e-02f, -2.91787349e-02f, 5.08626401e-02f, 4.08874825e-02f, -8.87015983e-02f, -1.25220895e-01f, 3.05478424e-02f, 1.86810235e-03f,
  -2.05023121e-03f, 3.08733694e-02f, -9.59191006e-03f, -1.83720309e-02f, 7.00589940e-02f, -1.76816601e-02f, -4.16989997e-02f, 5.44051975e-02f, 1.00282459e-02f, 1.64581593e-02f,
  1.47403087e-02f, -1.89295765e-02f, -7.61656044e-03f, 2.27893144e-02f, 5.52617349e-02f, 5.30371964e-02f, -3.61180566e-02f, 2.97124647e-02f, 5.78662492e-02f, 3.32002155e-02f,
  -1.00236669e-01f, 9.72909678e-04f, 3.90573256e-02f, -5.70338555e-02f, 6.03847578e-02f, -7.02682808e-02f, -4.74620275e-02f, 1.14948042e-02f, 3.53946239e-02f, 4.06636111e-02f,
  3.33273634e-02f, 4.93311286e-02f, 6.21858463e-02f, 7.43090175e-03f, 1.35314921e-02f, -1.87319368e-02f, 2.27459334e-03f, 4.14707772e-02f, 4.09841677e-03f, -3.23809907e-02f,
  -7.30031803e-02f, -5.55378459e-02f, 1.60064804e-03f, -5.51806539e-02f, -9.42034926e-03f, -4.58311243e-03f, 3.96285877e-02f, 1.38752966e-03f, 1.27419559e-02f, -1.53606413e-02f,
  6.48412332e-02f, 7.98173174e-02f, 1.43679036e-02f, -1.56543050e-02f, 2.74300221e-02f, -1.47812683e-02f, 6.55648634e-02f, 1.46952746e-02f, 1.10552208e-02f, 9.25897714e-03f,
  -3.12681281e-04f, -2.14331448e-02f, 5.26183145e-03f, 3.36316451e-02f, -2.50528622e-02f, -8.42052978e-03f, 2.54368577e-02f, -3.03011620e-04f, -1.01350052e-02f, -2.69560609e-02f,
  -1.10569680e-02f, -1.37206502e-02f, -6.41004834e-03f, 7.96804857e-03f, 1.20223062e-02f, -6.68954626e-02f, -6.76413774e-02f, 2.07500048e-02f, -6.54091090e-02f, -1.74591935e-03f,
  -2.34774780e-02f, 1.16901249e-01f, -1.12944387e-01f, -2.61487905e-02f, -1.77755192e-01f, -3.27784605e-02f, -7.16640130e-02f, 8.33288133e-02f, -2.70356946e-02f, 1.20884642e-01f,
  -9.70527977e-02f, 2.88200881e-02f, -1.82770006e-02f, 5.78350611e-02f, -6.09946474e-02f, 1.29963130e-01f, 7.97455981e-02f, -5.18384315e-02f, -7.56819034e-04f, -1.69582516e-02f,
  1.52487112e-02f, 5.36821857e-02f, 1.62989631e-01f, 9.02412087e-02f, -4.26129438e-02f, -4.38373946e-02f, -6.61589950e-02f, -3.95077206e-02f, -7.01073781e-02f, -1.25342056e-01f,
  -1.62817072e-02f, -5.67654297e-02f, -3.74455452e-02f, -5.92563376e-02f, 5.26408032e-02f, -3.36907543e-02f, -2.42819032e-03f, 1.95052419e-02f, -1.00584161e-02f, 5.67633845e-02f,
  1.50422752e-02f, 1.24772443e-02f, -5.35332747e-02f, 2.64666546e-02f, -8.27584639e-02f, -2.00817659e-02f, -3.76200005e-02f, 3.10414806e-02f, -5.81167899e-02f, -3.46986130e-02f,
  1.06633507e-01f, 1.66670009e-02f, -3.27892117e-02f, -2.64216773e-02f, -1.97830591e-02f, -1.61296166e-02f, -4.37607728e-02f, 2.94896346e-02f, -3.13865878e-02f, -5.91837876e-02f,
  5.94177805e-02f, 4.85248081e-02f, -3.45639810e-02f, 1.41673833e-02f, 5.56730516e-02f, -2.31963135e-02f, 6.64011091e-02f, 6.48375927e-03f, 1.56770237e-02f, -3.39869522e-02f,
  -8.85116905e-02f, -1.48205273e-02f, -7.08671659e-02f, -5.65471835e-02f, -7.10333586e-02f, -1.97618175e-03f, 4.62555923e-02f, 3.28214765e-02f, 1.02329152e-02f, 6.10434152e-02f,
  2.06504781e-02f, -7.14639351e-02f, 1.92510877e-02f, 3.89665389e-03f, -4.59830537e-02f, 4.22107540e-02f, -2.30125692e-02f, 5.58528304e-02f, -1.64804552e-02f, -1.69451442e-02f,
  3.74446660e-02f, -1.96465887e-02f, -7.00128675e-02f, 1.09323906e-03f, -7.93701261e-02f, 1.19798882e-02f, -2.03496888e-02f, -1.75375491e-02f, -1.09612517e-01f, 3.29118483e-02f,
  -1.60483830e-02f, 3.59698269e-03f, -6.70934049e-03f, -1.88190509e-02f, 3.49576399e-02f, 9.00818855e-02f, 1.21121220e-02f, -2.81808563e-02f, -4.17729430e-02f, 2.99447794e-02f,
  -4.02234588e-03f, -1.08073153e-01f, 2.35902425e-02f, 1.06315285e-01f, 3.64643894e-02f, -5.89771047e-02f, 2.06085574e-02f, -3.28159109e-02f, 2.71749720e-02f, -1.18559925e-02f,
  4.10354622e-02f, -4.74138670e-02f, 1.42589524e-01f, 2.52111126e-02f, 8.12701136e-02f, -2.64294863e-01f, -1.94800511e-01f, 8.96517336e-02f, -6.45647720e-02f, -1.65184245e-01f,
  -2.11356655e-01f, -5.00009917e-02f, -2.42964793e-02f, -9.23798382e-02f, -7.66184330e-02f, -6.79597035e-02f, -1.15220115e-01f, -1.23213068e-01f, 1.75117463e-01f, -4.56578517e-03f,
  -2.01412998e-02f, -1.54296517e-01f, 1.20796867e-01f, 9.82616991e-02f, -2.75324862e-02f, 3.74827608e-02f, 4.58442941e-02f, 1.37859643e-01f, 2.39309501e-02f, 2.45428681e-02f,
  -1.95010468e-01f, -3.74703407e-02f, 4.82673645e-02f, -4.23739776e-02f, -4.92711477e-02f, -4.75597149e-03f, 3.01039126e-02f, 3.67494337e-02f, -9.10640359e-02f, -2.80371029e-02f,
  -9.16215032e-02f, -3.67945200e-03f, -7.40716606e-02f, 7.94006232e-03f, -8.59476179e-02f, 7.72050619e-02f, -6.98772166e-03f, -2.10775752e-02f, 5.26022017e-02f, 4.34435718e-02f,
  -9.11300071e-03f, 6.84259087e-02f, 1.36025529e-02f, -2.64206659e-02f, 6.80690855e-02f, 1.70709658e-02f, 5.11913188e-02f, -2.33304445e-02f, -4.73377854e-02f, 8.58894959e-02f,
  6.10418431e-02f, 2.70190910e-02f, -6.57561719e-02f, 5.66350706e-02f, -2.50556832e-03f, 5.73990084e-02f, -4.58055288e-02f, -3.15194055e-02f, 1.09025992e-01f, -2.14799736e-02f,
  1.50413448e-02f, -5.27986698e-02f, 9.30802301e-02f, -5.52707464e-02f, -4.38902304e-02f, 5.15475646e-02f, -1.65316723e-02f, 1.49558438e-02f, 2.93688551e-02f, 4.29791631e-04f,
  3.89674418e-02f, -1.12688556e-01f, 9.87610407e-03f, 2.02985220e-02f, -3.71646918e-02f, 1.14485741e-01f, -7.44040962e-03f, 5.97260445e-02f, -9.41119194e-02f, 4.99781929e-02f,
  -2.93462932e-01f, -3.68132070e-02f, -8.52256045e-02f, -2.89396588e-02f, 4.01734859e-02f, -7.31528550e-02f, -7.93990791e-02f, -2.64598597e-02f, -2.75345035e-02f, -5.71685173e-02f,
  -5.87436557e-02f, -9.31919552e-03f, 4.81928140e-02f, -3.35251056e-02f, 5.98989241e-02f, -8.28340463e-03f, -2.19016038e-02f, 1.18787577e-02f, 5.73148206e-03f, -1.24395667e-02f,
  2.58497056e-02f, -3.87448594e-02f, -2.22896766e-02f, 8.74963030e-02f, 1.62782948e-02f, -1.57573889e-03f, 6.54780790e-02f, -3.33760027e-03f, 1.88040175e-02f, -6.39443621e-02f,
  1.48439050e-01f, 9.37293693e-02f, -3.15913945e-01f, 1.88333720e-01f, -1.32341295e-01f, -2.88988911e-02f, 8.59487150e-03f, 3.50694135e-02f, 2.41666809e-01f, 2.49654040e-01f,
  -1.53641803e-02f, -5.38332425e-02f, 7.61783049e-02f, 1.66020647e-01f, 7.10481033e-02f, 8.74691680e-02f, 1.29808992e-01f, 3.07934172e-02f, -8.70888215e-03f, -5.51062590e-03f,
  5.83933927e-02f, 1.13682531e-01f, -1.38677642e-01f, -8.98866802e-02f, -1.26892045e-01f, -8.53931233e-02f, 2.48920172e-02f, -1.54135332e-01f, -5.23367077e-02f, -9.26876962e-02f,
  -2.50512641e-02f, 5.77596985e-02f, -5.15871905e-02f, -3.06710675e-02f, -3.02658137e-02f, -6.57299459e-02f, -4.84644510e-02f, -1.38355434e-01f, -6.66209981e-02f, -3.79218049e-02f,
  5.71374856e-02f, -2.86017042e-02f, 5.84924594e-02f, 8.07956886e-03f, -1.06887385e-01f, -6.18650578e-02f, 2.38527525e-02f, 2.08928268e-02f, 5.02632596e-02f, -8.98692086e-02f,
  -2.78973449e-02f, 4.02170494e-02f, 1.40159065e-02f, 4.80427518e-02f, -5.81559092e-02f, 4.10579219e-02f, -1.42007805e-02f, -6.78671896e-02f, 2.02233307e-02f, 1.03556197e-02f,
  2.95185521e-02f, -4.25815508e-02f, -4.08768170e-02f, -7.92631414e-03f, 8.45348462e-03f, 2.33643968e-02f, 5.16529754e-02f, -2.08137296e-02f, -4.73335478e-03f, 1.94186810e-02f,
  3.99110606e-03f, 1.50537360e-02f, -5.58509305e-03f, 2.00525243e-02f, 5.40960282e-02f, -6.25246763e-02f, -2.57467367e-02f, -7.44448230e-02f, -1.13918455e-02f, 1.52416993e-02f,
  5.55432513e-02f, -2.59288978e-02f, -1.03546977e-01f, -2.00004745e-02f, -3.09946835e-02f, 1.19597055e-02f, -3.66960978e-03f, 1.16453916e-02f, -2.62325443e-02f, 5.08641973e-02f,
  1.29151970e-01f, 2.52345502e-01f, -1.72051433e-02f, -6.87237829e-02f, 5.70986830e-02f, -8.01950507e-03f, -2.65220925e-02f, 4.56499793e-02f, 8.36191475e-02f, 5.57931559e-03f,
  -2.72166356e-02f, -9.90101844e-02f, 1.51477475e-02f, -6.66103140e-02f, 5.35535924e-02f, 7.97002241e-02f, 2.04245262e-02f, 7.49846967e-03f, 2.18432155e-02f, -2.22772267e-02f,
  -4.85580089e-03f, 2.96791922e-02f, 3.60757373e-02f, -6.91399053e-02f, 2.44212840e-02f, 4.76744585e-03f, -2.72569414e-02f, -4.15261090e-02f, 8.68256297e-03f, 5.03835157e-02f,
  3.62242818e-01f, -1.67041458e-02f, -6.88317642e-02f, 1.75870880e-01f, 1.18006334e-01f, 2.58088261e-01f, 1.48882121e-01f, 9.35184360e-02f, 9.66819283e-03f, 4.74429615e-02f,
  7.40545765e-02f, -2.49715567e-01f, -7.72144869e-02f, 1.39216617e-01f, 5.43704927e-02f, -3.51416953e-02f, 1.61528930e-01f, 5.92539907e-02f, 6.37441641e-03f, 1.25922754e-01f,
  -3.08529064e-02f, 1.65817007e-01f, 1.88525748e-02f, 9.42567587e-02f, 3.46490368e-02f, 3.73636261e-02f, 1.48947677e-02f, -5.25370501e-02f, -2.23568045e-02f, 8.04108083e-02f,
  -6.10488355e-02f, -6.83861449e-02f, 1.76994745e-02f, -1.25616014e-01f, 2.50641685e-02f, 6.52469229e-04f, -1.80682447e-02f, 1.85574777e-02f, -8.17110948e-03f, 3.29010934e-02f,
  1.97438840e-02f, 2.03224700e-02f, -8.73868316e-02f, -3.86300012e-02f, -3.29904780e-02f, 1.10283671e-02f, -2.04641521e-02f, -8.23628083e-02f, -1.56455711e-02f, -1.99158322e-02f,
  6.75869669e-05f, 7.67866895e-03f, 8.08365792e-02f, -5.35636162e-03f, 2.71851700e-02f, -4.79083695e-02f, 3.62352878e-02f, -4.47118022e-02f, 1.54196972e-03f, 9.49669071e-03f,
  1.77940726e-02f, -4.71108779e-02f, 3.52107659e-02f, 2.28994526e-02f, 4.65231948e-02f, 2.90664025e-02f, 5.47453277e-02f, 1.08015668e-02f, 4.27109608e-03f, -5.83201880e-04f,
  -1.69610288e-02f, -1.05370935e-02f, -2.37165634e-02f, -4.15384816e-03f, 5.82041442e-02f, 5.73251620e-02f, -2.48499978e-02f, 8.50750878e-03f, 2.77102720e-02f, -4.74259108e-02f,
  4.10423763e-02f, 4.96273376e-02f, -1.49703994e-02f, 4.63004410e-02f, -8.42250418e-03f, 1.85829098e-03f, -5.42536117e-02f, -1.78851727e-02f, -3.28867026e-02f, 2.22158898e-02f,
  1.06521554e-01f, 8.17092732e-02f, -2.58539431e-02f, 4.49355692e-02f, -6.66507408e-02f, -1.52601078e-02f, -2.00341060e-03f, 1.20375991e-01f, 3.95204611e-02f, -6.00609044e-03f,
  6.77178847e-03f, 2.60108529e-04f, 8.43650103e-02f, -7.06315190e-02f, -4.69785370e-03f, 2.55369046e-03f, 5.04529066e-02f, 5.36470041e-02f, 3.88198979e-02f, 3.89092937e-02f,
  4.21015844e-02f, 1.81090850e-02f, 1.09403571e-02f, 2.62747961e-03f, 5.60457334e-02f, 7.73366988e-02f, 9.46504064e-03f, 3.14021739e-03f, 2.39170957e-02f, -5.40450886e-02f,
  2.46571317e-01f, -5.32659255e-02f, -3.49157117e-02f, 6.34847255e-03f, 1.34563921e-02f, -3.91871706e-02f, 3.43755335e-02f, 2.24177493e-03f, 4.93606292e-02f, 8.80435109e-03f,
  1.09891780e-01f, -2.46628392e-02f, 1.18969744e-02f, 5.83278062e-03f, -3.05839498e-02f, -1.48958385e-01f, 5.47337569e-02f, 6.35505095e-02f, 5.12338132e-02f, -5.08001857e-02f,
  3.22852805e-02f, -2.05641538e-02f, -6.32349625e-02f, 1.74401104e-02f, 6.94576055e-02f, 5.96084595e-02f, 6.65553734e-02f, -1.29534945e-01f, 4.39279377e-02f, 5.65525256e-02f,
  8.67873505e-02f, 1.06579013e-01f, 3.15526202e-02f, 1.03669576e-01f, 7.79436976e-02f, 5.24413697e-02f, -5.92206679e-02f, 2.26180702e-02f, 7.78186023e-02f, 7.99903355e-04f,
  1.60704087e-02f, -4.69284318e-02f, 2.41583143e-03f, -5.78891253e-03f, 7.99139682e-03f, 7.81216323e-02f, 6.94502220e-02f, 1.40580498e-02f, 1.51610319e-02f, -6.80569485e-02f,
  -3.78141589e-02f, -4.11030166e-02f, -2.87994593e-02f, 4.72901873e-02f, 1.34847010e-03f, 1.45278396e-02f, 1.54708596e-02f, 9.89835057e-03f, -3.55574749e-02f, -5.68079017e-02f,
  4.98450398e-02f, 4.83049825e-02f, 3.11717093e-02f, 1.02154925e-01f, -1.91414971e-02f, 1.25025958e-02f, -8.52355063e-02f, 4.37043421e-02f, 2.31902637e-02f, 3.67613658e-02f,
  3.57011780e-02f, 8.46266840e-03f, -1.49169322e-02f, 1.41662862e-02f, -7.54983872e-02f, 3.52924131e-02f, 3.99714932e-02f, 9.87255573e-02f, -4.94663008e-02f, 2.16994788e-02f,
  -4.59594652e-02f, -1.94719508e-02f, 1.00091174e-02f, 6.50624484e-02f, 4.85566296e-02f, 8.04860592e-02f, -1.41453072e-02f, 4.81943712e-02f, -6.51525985e-03f, 4.30852994e-02f,
  -4.53272350e-02f, 2.61302311e-02f, 2.89301183e-02f, 1.53144286e-03f, 7.31681883e-02f, -1.02221519e-02f, -5.25421929e-03f, -2.95163561e-02f, -9.36886948e-03f, 3.25361751e-02f,
  -2.65447591e-02f, 6.64030900e-03f, -4.29787673e-02f, 4.97710705e-02f, 4.48350841e-03f, 5.80484159e-02f, 6.17093407e-02f, 6.62160888e-02f, 6.35177568e-02f, 1.90069024e-02f,
  6.90358728e-02f, -3.40421088e-02f, 1.33340424e-02f, -3.44032645e-02f, -5.08232648e-03f, 1.11840345e-01f, 2.01440286e-02f, -4.96676750e-02f, -3.36800516e-02f, 5.75406253e-02f,
  9.05391648e-02f, 1.51058584e-01f, 5.21433763e-02f, 1.81611665e-02f, -1.06163666e-01f, 1.07633337e-01f, 2.72511579e-02f, -7.34716132e-02f, 6.15317449e-02f, 1.37806356e-01f,
  9.68474299e-02f, 1.53638139e-01f, 1.09761946e-01f, 1.65996686e-01f, 9.67075452e-02f, 9.36828032e-02f, -5.03951982e-02f, -2.34593693e-02f, -5.74940965e-02f, -2.50336900e-02f,
  -4.94685620e-02f, 5.62743936e-03f, -2.18019895e-02f, -5.02237417e-02f, -9.69984755e-02f, -8.31637457e-02f, -9.19164196e-02f, 5.87052144e-02f, -5.45297451e-02f, 6.19048588e-02f,
  -4.39219316e-03f, 1.83274336e-02f, 1.54317999e-02f, 5.06730191e-02f, -4.87965569e-02f, 7.56812841e-02f, -1.91136021e-02f, 3.09685431e-02f, 7.58585110e-02f, -4.42712717e-02f,
  -4.44353819e-02f, 2.24020928e-02f, 4.08470370e-02f, 4.90669087e-02f, -7.65693095e-03f, -1.29676722e-02f, -3.11135296e-02f, -8.46598763e-03f, 2.94735353e-03f, 7.18833134e-02f,
  -4.76549417e-02f, -4.58301343e-02f, -3.99921238e-02f, -2.93912496e-02f, -3.25066387e-03f, 9.15364400e-02f, 1.03612535e-01f, -5.29403798e-02f, -4.81472053e-02f, 8.93541127e-02f,
  -6.60572052e-02f, 3.82068641e-02f, 2.86249500e-02f, -5.48951402e-02f, 4.81311679e-02f, 2.06861701e-02f, -3.26305106e-02f, 1.97908245e-02f, -8.13881960e-03f, 8.68496969e-02f,
  -4.75055017e-02f, -7.81327114e-03f, 2.48384308e-02f, 2.53124945e-02f, -5.28908744e-02f, 3.49935293e-02f, -4.79245745e-02f, -1.02558704e-02f, 2.14838143e-02f, 9.07289609e-03f,
  -4.44147140e-02f, 9.30634066e-02f, 1.74870424e-03f, 7.22611472e-02f, -2.39135996e-02f, -5.03566563e-02f, -5.91086186e-02f, 5.23223244e-02f, 7.29401037e-02f, 5.84367178e-02f,
  -1.45917654e-03f, 3.90886255e-02f, -1.10861836e-02f, -6.79659322e-02f, -4.47092503e-02f, -4.71553989e-02f, -6.84737414e-02f, 2.53639035e-02f, -5.88890575e-02f, 5.29754311e-02f,
  7.03522712e-02f, -3.67177017e-02f, 1.40069183e-02f, -6.98674396e-02f, 4.71365936e-02f, -1.67544815e-04f, 1.20222671e-02f, -5.97109050e-02f, -2.57957056e-02f, -4.34392244e-02f,
  -4.59326524e-03f, -1.39091732e-02f, 8.34582970e-02f, 7.43571296e-02f, -2.83354404e-03f, -1.50714805e-02f, 4.30975929e-02f, 5.44184148e-02f, -3.01053133e-02f, -5.08889444e-02f,
  2.15561837e-01f, -2.40106285e-01f, -2.84722019e-02f, -2.32250452e-01f, -2.61097476e-02f, -2.97839850e-01f, -3.40660423e-01f, -9.13811773e-02f, 2.27711387e-02f, -1.33781627e-01f,
  -1.23546511e-01f, 2.38870662e-02f, -1.67447031e-02f, -2.65415490e-01f, 2.89941933e-02f, 7.68839717e-02f, -1.82956666e-01f, -1.15200177e-01f, 5.93482563e-03f, -5.13637923e-02f,
  4.63782325e-02f, -1.27034470e-01f, -8.80163759e-02f, -1.08479887e-01f, -1.27917886e-01f, 1.35830212e-02f, 2.72714961e-02f, 1.72500238e-02f, -1.73026845e-01f, 2.64451467e-02f,
  1.26633435e-01f, 2.64020741e-01f, 9.77125484e-03f, -6.28382852e-03f, -2.73183715e-02f, -7.82433674e-02f, -3.67671810e-02f, 8.27288404e-02f, 7.81857967e-02f, 9.51787271e-03f,
  -7.62100518e-02f, 2.98874117e-02f, 1.26093328e-02f, -3.15000340e-02f, -4.69103195e-02f, 3.83693054e-02f, -2.55149584e-02f, -5.88225648e-02f, -7.74195790e-02f, -2.73375567e-02f,
  -6.28239512e-02f, 1.13745881e-02f, -2.94999965e-02f, -2.72758566e-02f, -4.24038544e-02f, 1.83351468e-02f, 5.41305915e-02f, 2.82651614e-02f, -8.54874961e-03f, -6.02783523e-02f,
  -1.07754013e-02f, 5.42770475e-02f, 4.74326359e-03f, 8.23564176e-03f, 1.72434226e-02f, 3.92910279e-02f, -3.33395749e-02f, 1.92249995e-02f, 5.67408977e-03f, 2.46087518e-02f,
  -3.11518293e-02f, 2.40539704e-02f, -6.79247174e-03f, -4.08108421e-02f, -3.86355668e-02f, 1.63629893e-02f, 2.74284109e-02f, -6.30622916e-03f, -5.43338358e-02f, 2.89666746e-02f,
  -2.68117599e-02f, 2.80030183e-02f, -6.30620345e-02f, -3.91818844e-02f, 6.36325106e-02f, 4.23720665e-03f, -5.70611991e-02f, 1.72720980e-02f, -1.77111588e-02f, 1.21365832e-02f,
  -3.52438353e-02f, 1.13351882e-01f, 1.19340187e-02f, -5.26619367e-02f, 7.41759837e-02f, 8.68547335e-03f, 1.65713243e-02f, -2.35454645e-02f, -4.68451418e-02f, -2.38904562e-02f,
  6.87258542e-02f, -2.80209049e-03f, 1.77496090e-03f, -4.01072800e-02f, -2.94306665e-04f, -4.05915752e-02f, -1.57818552e-02f, 1.54812001e-02f, -2.17636656e-02f, -1.47313410e-02f,
  -6.47920743e-02f, 4.04321626e-02f, 2.72194184e-02f, -9.09773540e-03f, -3.56862918e-02f, -1.07513759e-02f, 9.50160250e-03f, 2.02316698e-02f, 6.14063181e-02f, -1.14216916e-02f,
  3.35893691e-01f, -3.10713742e-02f, 3.63042839e-02f, 2.33841971e-01f, -9.00423303e-02f, 9.04896036e-02f, 9.68914405e-02f, 1.34088853e-02f, 2.11319938e-01f, 4.92039137e-03f,
  -1.01298257e-03f, 1.34648710e-01f, -6.37853518e-02f, 1.28318354e-01f, 1.41273811e-01f, 4.83796187e-02f, 1.11426115e-01f, 1.51942915e-03f, -1.15215871e-02f, 3.18660066e-02f,
  1.34305105e-01f, 3.32931317e-02f, 7.07332715e-02f, -1.06354132e-01f, 3.05019622e-03f, -2.19717212e-02f, -9.77863073e-02f, -3.67753208e-02f, -3.20103057e-02f, 8.31749141e-02f,
  1.07344678e-02f, -1.01587571e-01f, -3.90576608e-02f, 4.70773913e-02f, -4.40649651e-02f, -5.33069670e-03f, -7.29335546e-02f, 4.43641171e-02f, -4.22773100e-02f, 5.94961606e-02f,
  -4.21931334e-02f, -4.09213938e-02f, 9.60578620e-02f, 7.28715062e-02f, 2.76607275e-02f, 6.50079176e-02f, -6.89388160e-03f, -1.40188225e-02f, 2.32752487e-02f, 7.10707484e-03f,
  -4.79991473e-02f, -8.71612802e-02f, 5.60694598e-02f, -7.46298581e-02f, 5.77643327e-02f, 5.18522821e-02f, -3.94221656e-02f, 4.56348546e-02f, -2.88642161e-02f, 4.70744073e-03f,
  3.80536094e-02f, -5.68480715e-02f, -6.66385004e-03f, 2.95296405e-02f, 3.04309390e-02f, -6.79085925e-02f, 6.15935512e-02f, -4.11302261e-02f, 7.80067891e-02f, 3.95824760e-02f,
  9.88192409e-02f, -5.72158303e-03f, 4.09193784e-02f, 2.66844649e-02f, -6.55938461e-02f, -8.31981283e-03f, -1.31971128e-02f, -8.89765173e-02f, -5.37497215e-02f, -1.26806973e-02f,
  3.10735721e-02f, 6.77502602e-02f, -1.14341164e-02f, -4.28407872e-03f, -7.87126422e-02f, 2.09432431e-02f, -4.08787169e-02f, 1.82130840e-02f, -1.61022525e-02f, 6.27214909e-02f,
  3.63292024e-02f, 1.47654898e-02f, 4.07345220e-02f, 2.75493059e-02f, -6.57580942e-02f, -4.04736847e-02f, 7.45763183e-02f, 1.71126574e-02f, 4.34468687e-02f, -7.84334317e-02f,
  1.93807241e-02f, 5.64912818e-02f, -4.18291688e-02f, -3.03093456e-02f, -4.90028411e-02f, 7.80440792e-02f, -4.93151918e-02f, 1.57084595e-02f, 3.67343463e-02f, 3.00144237e-02f,
  3.17035988e-02f, 1.42983580e-02f, 6.43794090e-02f, -2.86852922e-02f, 2.88374554e-02f, -3.65485586e-02f, -4.05679308e-02f, -2.16700248e-02f, 9.96063184e-03f, 6.87299967e-02f,
  -2.81129330e-01f, 7.98176751e-02f, 3.70655321e-02f, -7.25592971e-02f, 2.56460682e-02f, -1.16842262e-01f, -1.17513649e-01f, 4.96753715e-02f, 1.09971419e-01f, 1.27194421e-02f,
  4.85109687e-02f, -1.36699723e-02f, 3.83880269e-03f, -5.48935570e-02f, -1.87910974e-01f, -1.46024033e-01f, -7.94825703e-02f, -3.24114487e-02f, -3.29506248e-02f, -1.09954521e-01f,
  -1.56675190e-01f, -1.55187950e-01f, -8.45362097e-02f, -9.64374766e-02f, -1.19298123e-01f, 3.99320647e-02f, -3.05341817e-02f, 9.51475184e-03f, 7.01772645e-02f, 5.68136200e-02f,
  -1.19376935e-01f, 6.82151988e-02f, 7.04436302e-02f, 8.50093812e-02f, -1.45032760e-02f, -4.94356174e-03f, -5.31847551e-02f, 5.54162115e-02f, 7.34261191e-03f, -7.19292685e-02f,
  -4.96132299e-02f, -9.84314978e-02f, 2.04205457e-02f, 7.95525610e-02f, -9.02683288e-02f, 6.77641034e-02f, 1.07462946e-02f, -1.04102843e-01f, 8.42759386e-02f, 4.28129099e-02f,
  -2.51730364e-02f, -5.42177670e-02f, -1.97032075e-02f, 7.55167007e-02f, -4.37451601e-02f, 7.47328475e-02f, -3.76639739e-02f, -5.90188615e-02f, -7.02802390e-02f, -2.12980295e-03f,
  1.06949098e-02f, -1.59083512e-02f, 4.02827598e-02f, 1.52414171e-02f, 5.15014194e-02f, 6.29281334e-04f, -1.44319162e-02f, 5.53346500e-02f, 4.66466099e-02f, -8.69744364e-03f,
  1.20446421e-02f, 2.67365035e-02f, 3.36083435e-02f, 3.76297459e-02f, 1.45422341e-02f, 2.06601806e-03f, -1.07402347e-01f, 2.46254541e-02f, 5.02704941e-02f, -5.70998946e-03f,
  -3.51801142e-02f, 3.77556197e-02f, 7.65819801e-03f, -4.29066457e-02f, -4.16028164e-02f, -2.79917214e-02f, 5.49775101e-02f, 9.00959894e-02f, 5.50659783e-02f, -8.80304053e-02f,
  -4.91729043e-02f, 1.20759971e-01f, 1.05600491e-01f, -4.82803248e-02f, 8.42590481e-02f, -5.30210994e-02f, 4.50655073e-02f, 1.23719238e-02f, 8.55737552e-02f, 3.38692404e-02f,
  3.38021293e-02f, -1.70723982e-02f, -5.22532612e-02f, -1.95300058e-02f, -2.29206383e-02f, -4.61935764e-03f, 2.64430735e-02f, 5.39626665e-02f, 1.20363720e-02f, 9.25220363e-03f,
  8.12285207e-03f, 4.08098893e-03f, 3.09059843e-02f, -1.09875370e-02f, 4.59641926e-02f, -5.74416816e-02f, 4.48890887e-02f, -4.92485687e-02f, -9.34574604e-02f, 1.37027919e-01f,
  -8.28510225e-02f, -5.53947538e-02f, 3.55171710e-02f, -9.28885862e-02f, -1.87009588e-01f, 1.70666948e-01f, 1.88349187e-01f, -2.10536681e-02f, -5.05739041e-02f, 5.66866696e-02f,
  -6.84158802e-02f, 4.38729860e-02f, 2.26214044e-02f, 1.54417176e-02f, 1.65276408e-01f, 2.22410008e-01f, -7.77719542e-02f, 1.08980741e-02f, 5.65266944e-02f, -4.36667949e-02f,
  -1.27652124e-01f, 2.56340653e-02f, 1.08205162e-01f, 4.66539524e-02f, -1.05878515e-02f, -8.48015323e-02f, -1.06570713e-01f, 5.68529889e-02f, -8.23154300e-02f, 3.88830230e-02f,
  2.21976899e-02f, 1.91175751e-02f, -1.16731143e-02f, 2.97717340e-02f, 7.16705322e-02f, -7.63122663e-02f, 6.18689768e-02f, 1.46311462e-01f, -3.29343751e-02f, 1.69880744e-02f,
  9.25645232e-02f, -6.34333640e-02f, -7.87496716e-02f, -3.87979969e-02f, -6.72627464e-02f, -2.38031317e-02f, -1.05154127e-01f, -7.28044510e-02f, -8.91555473e-03f, 2.62423847e-02f,
  6.66755885e-02f, -6.18503056e-02f, -3.38082276e-02f, -1.18965814e-02f, -6.55625761e-02f, -1.36869345e-02f, 1.03826344e-01f, 6.43933639e-02f, 3.38861831e-02f, -6.56508505e-02f,
  -7.61416554e-02f, -1.13500208e-02f, 6.51898384e-02f, 1.24398647e-02f, 8.99127393e-04f, -1.96552593e-02f, 6.10031821e-02f, -6.21812455e-02f, 6.51150495e-02f, -5.11904508e-02f,
  -2.36740895e-03f, -4.22636345e-02f, 1.61547251e-02f, 6.36446178e-02f, -2.83614304e-02f, -2.41985563e-02f, 4.23063301e-02f, -8.87975097e-03f, -1.67384353e-02f, 1.99126638e-02f,
  -1.24007780e-02f, 5.76047413e-02f, 7.53523596e-03f, -2.74723619e-02f, -4.02836986e-02f, -3.58334668e-02f, -8.36541597e-03f, -9.90528706e-03f, -5.82015216e-02f, 4.77445535e-02f,
  -4.58916500e-02f, 5.97829632e-02f, 4.23829705e-02f, 7.37183094e-02f, -5.80351986e-03f, -6.33837655e-02f, 4.45722714e-02f, -5.95122129e-02f, 4.58799973e-02f, 1.93473150e-03f,
  3.05493604e-02f, -2.03003399e-02f, -2.73000523e-02f, 1.72812473e-02f, 7.45313661e-03f, 3.87297058e-03f, -7.15845218e-03f, 6.23433036e-04f, 3.54163162e-02f, -4.81009893e-02f,
  -3.79859209e-02f, 3.05391047e-02f, 3.82008553e-02f, 5.82375238e-03f, -5.72248884e-02f, 1.80883706e-02f, -1.16486859e-03f, -6.85972534e-03f, -7.37229064e-02f, 1.88148767e-02f,
  1.51012346e-01f, -6.81309029e-02f, 4.20959517e-02f, 9.87037346e-02f, 1.32609988e-02f, -2.09216073e-01f, -2.02935636e-01f, -2.23535392e-03f, 3.86967808e-02f, 4.01004776e-03f,
  9.98534411e-02f, -1.03899632e-02f, -1.52676120e-01f, 3.02886050e-02f, -1.19493127e-01f, -1.99810624e-01f, -2.28149500e-02f, 2.35114731e-02f, -8.10755715e-02f, 5.54597415e-02f,
  3.68343554e-02f, 3.00116483e-02f, -1.02205440e-01f, 4.73284200e-02f, 1.25872984e-03f, 4.00505867e-03f, -1.44230109e-02f, 3.80394422e-02f, 1.22572497e-01f, -1.75649807e-01f,
  6.66389242e-02f, 5.89446388e-02f, -3.06709670e-02f, -5.04499935e-02f, 3.22492197e-02f, -2.76996866e-02f, -6.79588784e-03f, 2.42203716e-02f, 5.99386506e-02f, 3.13324332e-02f,
  5.65512925e-02f, 4.72673774e-02f, -4.33591679e-02f, 9.25513916e-03f, -4.61333878e-02f, 7.50367567e-02f, 5.15153557e-02f, 3.23675387e-02f, 3.97995934e-02f, 3.34684327e-02f,
  3.75978649e-02f, -2.21045278e-02f, -2.16593612e-02f, 1.30876694e-02f, -3.97020802e-02f, 3.58334333e-02f, -9.52346250e-02f, -9.15349498e-02f, 6.54662959e-03f, 2.86693173e-03f,
  1.70517266e-02f, -5.81703335e-02f, 1.84499808e-02f, -1.18599571e-02f, 4.88325432e-02f, -4.17738594e-02f, 1.49473120e-02f, -5.32431677e-02f, -3.70869488e-02f, -4.71604839e-02f,
  -4.37766239e-02f, 4.00722213e-02f, -4.40223888e-02f, -1.12056909e-02f, 2.88300402e-02f, -1.81467216e-02f, -5.00292741e-02f, 9.02116671e-03f, -4.27216329e-02f, 4.10202742e-02f,
  -3.36535312e-02f, 6.64935634e-02f, 2.25029029e-02f, -4.80808169e-02f, -5.39003983e-02f, -3.60755473e-02f, 6.35640249e-02f, 1.79375187e-02f, 1.12562431e-02f, 8.78146850e-03f,
  -7.92253390e-02f, 4.10859771e-02f, -1.09390974e-01f, 6.64557591e-02f, -7.05991685e-02f, 3.71462256e-02f, 1.35233486e-02f, -8.80422816e-03f, -1.47884088e-02f, 2.75056362e-02f,
  1.13938928e-01f, -6.30562305e-02f, 1.02928588e-02f, 5.56716658e-02f, -3.70325372e-02f, 3.62143070e-02f, -3.51980627e-02f, -6.21411502e-02f, -4.87280935e-02f, -2.00219511e-04f,
  4.99446653e-02f, 6.55153673e-03f, 8.02701041e-02f, 5.78662418e-02f, 4.86796126e-02f, 4.50644903e-02f, 3.37749198e-02f, -4.64471541e-02f, 3.64153869e-02f, -5.26990592e-02f,
  -1.04999945e-01f, 9.58982632e-02f, -1.90311506e-01f, -6.10813163e-02f, -1.88170522e-02f, 5.27186394e-02f, -1.15375482e-01f, 6.18371442e-02f, -9.71352682e-02f, 1.60638228e-01f,
  -2.15174425e-02f, 3.31454128e-02f, -1.14280477e-01f, 4.84120995e-02f, 4.85465936e-02f, -4.74976078e-02f, 8.48694369e-02f, 8.83295536e-02f, -3.75516596e-03f, -1.87907200e-02f,
  -5.36174439e-02f, 1.06643207e-01f, -1.42775148e-01f, 1.30612850e-01f, -4.64148149e-02f, -3.15290056e-02f, 4.29550149e-02f, -3.01347170e-02f, 7.30187669e-02f, 2.07861345e-02f,
  5.81689784e-03f, 8.89129639e-02f, -6.17020540e-02f, -1.37864659e-02f, 1.54524865e-02f, 7.35037401e-02f, 7.42581114e-02f, -4.95616943e-02f, 1.34359859e-02f, -4.12951782e-02f,
  -5.16154766e-02f, -2.42315400e-02f, 5.34092821e-03f, -7.89338201e-02f, 3.20428312e-02f, -2.94326775e-04f, -3.12142801e-02f, -6.82653785e-02f, 8.58163927e-03f, 9.35277343e-02f,
  -4.87737954e-02f, -2.90727764e-02f, 7.88614899e-03f, 7.56209940e-02f, 4.09130007e-02f, 8.10677409e-02f, 3.98465618e-02f, 5.95737062e-02f, 7.84578770e-02f, -4.54940982e-02f,
  3.54082249e-02f, 1.12035498e-02f, 1.26932329e-02f, 4.82186601e-02f, -6.57882318e-02f, 9.86155495e-03f, 5.49628809e-02f, -6.91034123e-02f, -1.24466037e-02f, 4.57659625e-02f,
  -8.34699422e-02f, 3.43332402e-02f, -5.14914580e-02f, -3.27566117e-02f, 5.50235920e-02f, 1.79615617e-02f, 1.82639435e-02f, -3.63345221e-02f, -5.04268967e-02f, 7.08778948e-02f,
  -1.06385322e-02f, -2.74029262e-02f, 3.74656767e-02f, -3.15009616e-02f, -4.52790335e-02f, -4.05369960e-02f, 6.50807098e-02f, -5.98411597e-02f, -8.28859210e-02f, -4.67424355e-02f,
  4.26298715e-02f, 5.13515025e-02f, 2.97421869e-02f, 5.01346923e-02f, -3.30074206e-02f, 5.30652294e-04f, -3.74716818e-02f, -3.49778719e-02f, -4.29661535e-02f, -5.61688095e-02f,
  5.29700778e-02f, -6.25370294e-02f, 1.14134159e-02f, 3.42193469e-02f, 9.50833724e-04f, -5.02704568e-02f, -2.15170681e-02f, -5.34099434e-03f, -1.89083442e-02f, 3.57223526e-02f,
  6.71671564e-03f, 3.70724835e-02f, 2.38574911e-02f, -3.24345939e-02f, 4.52520885e-02f, 5.35297617e-02f, 2.28323489e-02f, 3.73792164e-02f, 1.69195805e-03f, -1.08662955e-02f,
  -7.46741891e-02f, 2.09456727e-01f, 1.28802434e-01f, -3.25384252e-02f, -2.49072328e-01f, -2.55274057e-01f, -1.15407258e-01f, -1.82015896e-02f, -2.21015215e-01f, 5.97371422e-02f,
  3.02689802e-02f, 1.27931297e-01f, 4.40385453e-02f, 4.71859016e-02f, 1.20822601e-02f, -4.36814316e-02f, 2.78808959e-02f, -3.95288169e-02f, -3.86146717e-02f, 6.64117634e-02f,
  3.19225155e-02f, -3.04146726e-02f, 1.48705751e-01f, 1.18956573e-01f, -1.01824393e-02f, 8.46228004e-02f, 9.90575328e-02f, 1.22496754e-01f, 1.29753336e-01f, -9.01038796e-02f,
  8.33315216e-03f, -5.78648672e-02f, 8.07407647e-02f, 4.61638384e-02f, 7.81294107e-02f, 3.21085155e-02f, -5.77053279e-02f, 2.20833570e-02f, -1.27239097e-02f, 7.25576207e-02f,
  4.66173841e-03f, 4.84575927e-02f, 4.90580052e-02f, 3.94065008e-02f, -1.22671075e-01f, 5.44211194e-02f, -9.81088877e-02f, -6.36153594e-02f, -3.07819452e-02f, 2.29065698e-02f,
  3.22525427e-02f, -9.31397267e-03f, -2.66324095e-02f, 5.54838497e-03f, 3.11143473e-02f, -6.45310655e-02f, -8.75681639e-02f, -1.14065418e-02f, 1.93640161e-02f, -5.27012274e-02f,
  -7.50182196e-02f, -5.79752028e-02f, -3.02318279e-02f, -2.34092935e-03f, 1.82022639e-02f, -6.55744001e-02f, -4.10906114e-02f, -5.30377321e-04f, 2.20750808e-03f, -1.95936561e-02f,
  3.42292115e-02f, -3.03233173e-02f, 4.76998976e-03f, -4.40252721e-02f, -3.46018933e-02f, -5.82972802e-02f, 1.38984015e-02f, 1.77819338e-02f, -1.45264156e-02f, 1.38113815e-02f,
  -1.04463235e-01f, -1.88947823e-02f, 1.05683625e-01f, -5.53508252e-02f, 7.17177317e-02f, 1.65719576e-02f, -4.90022413e-02f, 1.55529892e-02f, 2.00447962e-02f, 4.18344848e-02f,
  1.15162648e-01f, 2.01494128e-01f, 7.26351589e-02f, 1.63483750e-02f, 2.05627475e-02f, -4.07246798e-02f, 5.36532747e-03f, 1.66043174e-02f, 5.48383705e-02f, -1.53720127e-02f,
  1.53995855e-02f, 4.11653928e-02f, -1.00715913e-01f, -3.96700688e-02f, 1.46498047e-02f, 1.58738736e-02f, 4.78637479e-02f, 9.17863324e-02f, 6.98407739e-02f, 6.14887998e-02f,
  9.38148126e-02f, -2.66970834e-03f, -2.21842006e-02f, 4.62597329e-03f, 1.95128378e-02f, 5.01710270e-03f, 6.13922477e-02f, 8.44013225e-03f, -3.78857180e-02f, 2.79163420e-02f,
  -3.15176487e-01f, -2.42883489e-02f, 2.22160354e-01f, 1.51091099e-01f, 2.05813006e-01f, 3.84090990e-01f, 3.31501991e-01f, 9.43616033e-02f, 1.04764052e-01f, -1.14931166e-01f,
  -4.11927439e-02f, -9.35478881e-02f, 4.00120541e-02f, -4.11082953e-02f, 9.00300443e-02f, 1.76446423e-01f, 9.59308445e-02f, 2.96742022e-02f, 2.58545466e-02f, -5.35671376e-02f,
  4.42386651e-03f, 6.75918981e-02f, -7.33078038e-03f, -8.43183547e-02f, 5.98887121e-03f, -1.53424874e-01f, -2.95989122e-03f, 8.84963199e-03f, -1.00789696e-03f, 4.99957800e-03f,
  1.29203707e-01f, 2.13357918e-02f, 1.88599224e-03f, 2.12212335e-02f, 6.76561892e-02f, 2.51189675e-02f, 5.14013916e-02f, 8.71856436e-02f, -2.73888875e-02f, 6.49854243e-02f,
  -8.52737054e-02f, -2.15014461e-02f, -2.29537860e-02f, -3.41885425e-02f, 8.36866349e-03f, -6.09819253e-04f, -2.63320096e-03f, 3.33546139e-02f, -1.10497000e-02f, 6.72165453e-02f,
  -8.27145949e-02f, 2.77802106e-02f, -2.84161065e-02f, 1.25702089e-02f, -4.39990731e-03f, -5.70977526e-03f, 3.46787013e-02f, 2.53097601e-02f, -7.30888394e-04f, 3.73693220e-02f,
  8.55154544e-03f, 1.75314341e-02f, -8.70636106e-03f, 8.27690028e-03f, 6.24761684e-03f, -1.51146874e-01f, -4.55832034e-02f, -6.13875873e-03f, -4.14270768e-03f, -3.13027296e-03f,
  -2.04449501e-02f, -2.38585602e-02f, 1.25406384e-02f, 3.04703973e-02f, 3.46938334e-02f, 1.47478702e-02f, -7.81345181e-03f, 3.06110922e-02f, 2.55217496e-02f, 2.34750677e-02f,
  1.26671512e-02f, -3.06594111e-02f, 2.19364427e-02f, 3.99830714e-02f, 6.48017526e-02f, 1.36785991e-02f, -3.21941776e-03f, 1.30324829e-02f, -5.83680300e-03f, -1.99305620e-02f,
  4.87127826e-02f, -1.42189022e-02f, -1.10001573e-02f, -4.70549092e-02f, 3.48999165e-02f, 6.15574978e-03f, 8.69383663e-02f, -9.82922539e-02f, -1.29298205e-02f, -4.48550768e-02f,
  1.96115896e-02f, 3.87595221e-02f, -5.09982854e-02f, 3.21459547e-02f, -1.46634039e-02f, 5.55582941e-02f, 5.27218543e-03f, 9.02916864e-03f, -4.26845029e-02f, 6.94610644e-03f,
  -2.78871693e-02f, -1.01852968e-01f, -3.15235704e-02f, 1.16611179e-02f, 4.62554358e-02f, -5.46779297e-02f, 1.14539340e-02f, -4.51502427e-02f, 3.56134325e-02f, 8.05149227e-02f,
  4.50141460e-01f, 1.12562077e-02f, 1.37599818e-02f, 1.79761097e-01f, 9.17937309e-02f, 7.61206669e-04f, 3.30644995e-02f, 1.32528186e-01f, 9.95041355e-02f, -1.13017391e-02f,
  -3.80582511e-02f, 1.68643907e-01f, -1.10078035e-02f, 4.75763641e-02f, 2.37855092e-02f, -1.06820926e-01f, 5.49587160e-02f, 8.89394358e-02f, -6.00998476e-02f, 4.55666408e-02f,
  -2.75294073e-02f, -5.60103320e-02f, -9.19204429e-02f, 1.45365379e-03f, 1.40310749e-01f, -2.68390663e-02f, 7.23382384e-02f, -5.04142679e-02f, -1.12815555e-02f, 4.58663143e-02f,
  1.10207535e-01f, 1.80563346e-01f, -2.63309386e-02f, -3.18634063e-02f, -1.41854007e-02f, -3.98895293e-02f, 1.41447014e-03f, -2.01152284e-02f, 1.63434092e-02f, -5.92718571e-02f,
  5.79391681e-02f, 6.77404180e-02f, 4.77147065e-02f, 3.46895568e-02f, 9.13923085e-02f, -6.77373782e-02f, 5.31079173e-02f, 3.89223062e-02f, 4.57955003e-02f, -5.78132197e-02f,
  -2.02734396e-03f, 7.80950487e-02f, 3.82546000e-02f, 2.73216777e-02f, -4.48382422e-02f, -2.98348255e-02f, 7.47868270e-02f, -6.48682043e-02f, -8.49526301e-02f, 4.61694486e-02f,
  -5.62561937e-02f, 5.33947982e-02f, -1.01479806e-01f, 3.34439576e-02f, 1.00248922e-02f, 6.47783186e-03f, 3.39786373e-02f, 7.49615803e-02f, -5.15029579e-02f, -2.29836218e-02f,
  2.33808346e-02f, 3.54066901e-02f, -1.42328165e-04f, -8.33979398e-02f, 3.83105688e-02f, -1.59546752e-02f, -6.29154891e-02f, 1.85972191e-02f, 3.14650163e-02f, 2.43825652e-02f,
  7.59307593e-02f, 6.31398382e-03f, 2.44331677e-02f, -9.39944014e-02f, 6.01406721e-03f, -1.01252031e-02f, 1.39889205e-02f, 5.22282422e-02f, 2.93153841e-02f, -1.11399285e-01f,
  1.80548839e-02f, 1.03633456e-01f, 3.47246043e-02f, -5.38781323e-02f, -1.88301485e-02f, 3.14152800e-03f, 2.12740675e-02f, -4.04791627e-03f, 4.62733768e-03f, -3.51535566e-02f,
  -1.94028616e-02f, -1.11371581e-03f, 3.50342169e-02f, 6.18398674e-02f, -3.11052315e-02f, -4.85366173e-02f, 1.46126643e-01f, 2.12381799e-02f, 4.38146945e-03f, 2.27480214e-02f,
  -6.22175783e-02f, -1.82062536e-02f, -9.13470238e-02f, 2.19157431e-02f, -3.47483605e-02f, -3.06847598e-02f, 4.18156087e-02f, 1.13528380e-02f, -2.64196694e-02f, 2.81956494e-02f,
  -3.75176728e-01f, 6.37736470e-02f, -1.20996252e-01f, -7.85530433e-02f, -3.74334715e-02f, -1.71276063e-01f, -1.28395289e-01f, 1.40613727e-02f, 3.10152466e-03f, -2.31574709e-03f,
  -1.43763617e-01f, 6.49612844e-02f, 4.78571560e-03f, -5.47052436e-02f, -1.05229445e-01f, 2.07518041e-02f, -1.95810542e-01f, -1.81137547e-01f, 1.15729235e-01f, -4.35747094e-02f,
  -1.72072183e-02f, -1.14797398e-01f, -8.94416273e-02f, 7.86635354e-02f, -8.60777497e-02f, 1.87013000e-02f, -4.28874567e-02f, 5.94744943e-02f, -1.50450826e-01f, 7.52769336e-02f,
  -5.84198385e-02f, 2.67483089e-02f, -1.02400310e-01f, -8.80501121e-02f, -1.48187980e-01f, -6.11730060e-03f, -2.48475913e-02f, 3.29077622e-04f, 6.06802665e-02f, 4.38100062e-02f,
  -2.54327264e-02f, 5.35451137e-02f, -6.04442172e-02f, 5.76586612e-02f, 4.71525826e-02f, -2.13625208e-02f, 3.65075320e-02f, -1.01460226e-01f, 8.33656639e-03f, -2.52148658e-02f,
  2.31193341e-02f, -7.08826724e-03f, 4.12589759e-02f, -5.90236336e-02f, 6.34118170e-03f, 3.84345613e-02f, 1.96908750e-02f, 1.53398560e-02f, -1.19506806e-01f, -1.07876413e-01f,
  -2.87886597e-02f, 2.64433082e-02f, -8.03807825e-02f, 4.16183695e-02f, 1.43813004e-03f, -3.67515534e-02f, -2.55006156e-03f, 6.21470250e-02f, 2.75062490e-02f, 1.65900551e-02f,
  -5.52846938e-02f, 2.18044966e-02f, -4.73417342e-03f, -1.74177028e-02f, -3.31865996e-02f, -7.62351528e-02f, -2.83835474e-02f, 1.86691917e-02f, -5.04141077e-02f, -2.74411682e-02f,
  5.41172214e-02f, -5.02930470e-02f, -1.03178585e-03f, 9.01161507e-03f, 1.68581214e-03f, 1.85359530e-02f, 6.87664095e-03f, 6.38736710e-02f, 2.88537540e-03f, 2.12874133e-02f,
  -1.36990741e-01f, -6.00488111e-02f, -2.85642315e-03f, 2.18890724e-03f, -2.56902240e-02f, -6.14564158e-02f, -4.22822163e-02f, -4.27187644e-02f, 2.60339677e-03f, 8.53060046e-04f,
  -9.09163579e-02f, -5.04846033e-03f, -3.04618459e-02f, 4.01584208e-02f, 6.74023330e-02f, -2.41500326e-02f, -1.03691937e-02f, -2.21221801e-02f, -2.55931839e-02f, -7.93874115e-02f,
  -4.62542381e-03f, -6.20363280e-02f, -5.77785773e-04f, 4.89267595e-02f, -8.51639882e-02f, -5.59164174e-02f, -1.02604128e-01f, -5.04664239e-03f, 2.64836829e-02f, 1.13733150e-02f,
  -4.49307144e-01f, -1.38404861e-01f, -4.39412557e-02f, -3.63581479e-02f, -1.74745500e-01f, -1.06195301e-01f, -8.64489600e-02f, -6.38462603e-02f, -2.18640581e-01f, 1.47523796e-02f,
  -2.98672263e-02f, 1.06297655e-03f, 8.05281010e-03f, 1.10646583e-01f, -1.81216836e-01f, -3.55823077e-02f, -1.79607403e-02f, -2.63911858e-02f, -8.24236125e-02f, 6.88556358e-02f,
  -1.04929388e-01f, -3.14046144e-02f, -1.62819512e-02f, 2.84306966e-02f, 7.41548017e-02f, -2.77301092e-02f, -5.02791777e-02f, 4.56925407e-02f, 4.13703173e-02f, 3.80073464e-03f,
  -7.87718222e-02f, -1.35772496e-01f, 1.64541248e-02f, -2.88446993e-02f, 1.85659137e-02f, 2.98070796e-02f, -1.49928557e-03f, 6.99455589e-02f, 1.00614987e-01f, 3.73098440e-02f,
  9.48897079e-02f, 4.21831571e-02f, 1.23447469e-02f, -6.55719498e-03f, 1.28332451e-02f, -1.00333253e-02f, 1.04073577e-01f, 9.52022374e-02f, 1.27838925e-01f, -6.47176104e-03f,
  -4.24411930e-02f, -5.18945009e-02f, 2.87397038e-02f, -1.08771548e-01f, 4.56324518e-02f, -3.97198983e-02f, -4.94128354e-02f, 2.90176179e-03f, -7.72802159e-02f, 7.52477581e-03f,
  -1.60242930e-01f, -2.48461310e-02f, -2.57489234e-02f, 1.33093689e-02f, 2.32265168e-03f, -3.27117853e-02f, 7.51138777e-02f, -4.86234855e-03f, -3.90087068e-02f, 3.35721672e-02f,
  5.31223556e-03f, 3.05213239e-02f, -4.04557772e-02f, -3.05796191e-02f, -7.02558609e-04f, -2.36825012e-02f, 4.51692678e-02f, -6.07953593e-03f, 2.00431217e-02f, 4.08342248e-03f,
  3.24365348e-02f, 6.89463764e-02f, -5.37483767e-02f, -3.88581380e-02f, -5.40193133e-02f, 6.47352859e-02f, -5.57518974e-02f, -1.62869673e-02f, -3.32595371e-02f, 2.74895318e-02f,
  -3.71678136e-02f, -2.60320365e-01f, -3.60026807e-02f, -9.21958387e-02f, -7.67934993e-02f, 3.39361168e-02f, -2.06392519e-02f, 1.70792509e-02f, -4.27526562e-03f, -1.08481668e-01f,
  4.41735424e-02f, -2.98517421e-02f, 1.82051845e-02f, -1.79284960e-02f, 2.45206859e-02f, 1.11481128e-02f, 3.83731164e-02f, -3.71151455e-02f, -7.73737431e-02f, 2.85933726e-02f,
  6.46870881e-02f, -1.69034246e-02f, 8.41161907e-02f, -8.02754089e-02f, 2.06057392e-02f, 4.07309793e-02f, -6.19529858e-02f, -3.72858485e-04f, 3.52618173e-02f, -6.83087483e-02f,
  -1.83894441e-01f, -3.97720933e-02f, 1.36179551e-01f, -1.73677385e-01f, -1.12449251e-01f, 8.91087651e-02f, 1.39823467e-01f, -9.57558677e-02f, 8.33744034e-02f, -7.65995309e-02f,
  -5.37776165e-02f, -9.79093835e-02f, 1.04111262e-01f, -2.91573733e-01f, -3.21392953e-01f, 3.91059592e-02f, -2.27681369e-01f, -4.45799455e-02f, -5.72589338e-02f, -1.44797891e-01f,
  -1.01940073e-01f, -3.37036878e-01f, -2.03911379e-01f, -1.25896126e-01f, 4.31549102e-02f, 8.40485394e-02f, -1.94441170e-01f, 8.61957371e-02f, -5.14712110e-02f, -1.08680144e-01f,
  -1.44633695e-01f, 3.55197042e-02f, -4.03654855e-03f, 1.23441417e-03f, -1.55374715e-02f, 7.99541548e-02f, -1.80959161e-02f, 4.65571415e-03f, -3.67115997e-02f, -5.97148156e-03f,
  9.10516232e-02f, 1.23544326e-02f, -2.26378720e-02f, 6.69241045e-03f, 7.16175362e-02f, 3.72169390e-02f, 1.55004449e-02f, 3.90820466e-02f, 4.00971696e-02f, -4.87931147e-02f,
  9.51899365e-02f, 2.44751270e-03f, 5.97937107e-02f, -7.04617519e-03f, -8.40846729e-03f, 6.35461062e-02f, -2.15941146e-02f, 2.73457598e-02f, 1.00134112e-01f, -2.88471822e-02f,
  8.23243260e-02f, 8.65138415e-03f, 3.00209578e-02f, -5.54781072e-02f, -3.49552780e-02f, 6.01527607e-03f, 6.96839066e-03f, -9.53804050e-03f, -1.72365494e-02f, -6.03838526e-02f,
  -9.51972697e-03f, -1.26923062e-02f, -4.12324816e-02f, 8.53832290e-02f, -7.40783988e-03f, 4.19024602e-02f, -3.12452856e-02f, 4.08657603e-02f, 1.72373690e-02f, 2.10557655e-02f,
  -1.38057023e-02f, 5.11781201e-02f, -1.16295246e-02f, 1.41928876e-02f, -7.60990568e-03f, 1.80523973e-02f, -1.59739666e-02f, 2.14177184e-02f, 4.09292541e-02f, 6.54840097e-02f,
  -2.07742438e-01f, -9.51542556e-02f, 9.15396679e-03f, -4.29609865e-02f, -2.25319583e-02f, -1.33586219e-02f, -5.86085115e-03f, 2.97022164e-02f, 5.12070283e-02f, 2.47574206e-02f,
  -3.24696414e-02f, -3.16467546e-02f, -1.40348554e-03f, 1.40949124e-02f, -3.57795544e-02f, -7.49682263e-03f, 2.32479745e-03f, -1.38201434e-02f, -3.57767642e-02f, -2.26108730e-02f,
  3.71364802e-02f, -3.28311808e-02f, 3.05458810e-02f, 7.37269060e-04f, -5.34320157e-03f, 2.02533565e-02f, -1.42818969e-03f, 3.47852744e-02f, -1.76773611e-02f, 2.15413943e-02f,
  -1.39636472e-01f, 3.15026850e-01f, -1.10826567e-01f, -4.16249298e-02f, -2.40746617e-01f, -3.08883339e-02f, -2.93426830e-02f, 4.89943661e-02f, 1.32024974e-01f, 1.31621465e-01f,
  -1.18695181e-02f, -2.19300715e-03f, 6.51521981e-02f, 1.19914107e-01f, -6.75071031e-02f, 2.41255447e-01f, 7.76835680e-02f, -1.90224778e-02f, 8.30431134e-02f, 1.07929101e-02f,
  -2.88774371e-02f, 4.17549200e-02f, -1.02151603e-01f, 2.99280100e-02f, 2.49322932e-02f, -1.91332307e-02f, -4.35978994e-02f, -6.64130524e-02f, -9.75657851e-02f, -3.45397345e-03f,
  -7.12800995e-02f, 7.34921694e-02f, -4.29211818e-02f, 4.14869152e-02f, 4.70236503e-02f, -3.53494026e-02f, -9.19629112e-02f, 1.78981852e-02f, -4.78653163e-02f, 2.26351805e-02f,
  -3.57160792e-02f, 4.85462546e-02f, -1.56501867e-02f, -1.01207525e-01f, 7.07966611e-02f, 4.19078283e-02f, 1.79312229e-02f, 2.61029452e-02f, -7.21255094e-02f, -1.49948616e-02f,
  7.29059055e-02f, -3.81219909e-02f, -5.92657411e-03f, -3.16257812e-02f, -2.35673785e-02f, -2.49307808e-02f, 6.43583909e-02f, -5.54923974e-02f, 1.64435955e-03f, -1.33670084e-02f,
  3.73117067e-02f, 8.05652421e-03f, 6.49361089e-02f, -1.01266941e-03f, -1.38444714e-02f, 6.48438856e-02f, 1.23532647e-02f, -3.64538245e-02f, -5.12932017e-02f, -4.76625189e-02f,
  1.70946475e-02f, -6.85296655e-02f, -2.58708093e-02f, 2.43932456e-02f, -3.36957723e-02f, 2.34377850e-02f, -3.28332633e-02f, -2.78455969e-02f, 8.02771468e-03f, -6.98340237e-02f,
  5.47956973e-02f, 4.65473905e-02f, -1.91069450e-02f, -6.82753175e-02f, 7.32451454e-02f, -3.04861460e-02f, -5.77796390e-03f, -1.97852682e-02f, -3.47827598e-02f, 2.03368571e-02f,
  1.02747306e-01f, 2.40197793e-01f, 3.96317467e-02f, -6.41063377e-02f, 9.07763839e-02f, 4.28259745e-03f, 8.10357258e-02f, 2.06006579e-02f, 6.84599429e-02f, 2.46380083e-02f,
  -8.79486799e-02f, 4.50616479e-02f, 2.61935517e-02f, 9.83830262e-03f, -2.83797197e-02f, 9.57966223e-02f, 3.28213163e-02f, 5.89683875e-02f, 2.35231519e-02f, 4.03507166e-02f,
  1.38303541e-04f, 8.79383013e-02f, 4.54807803e-02f, -1.86260138e-02f, -4.95529696e-02f, -2.57386751e-02f, 3.82714197e-02f, -3.18715461e-02f, 4.85228971e-02f, -9.60751728e-04f,
  -1.87109008e-01f, -1.44010141e-01f, -1.79046661e-01f, -1.90647006e-01f, 7.71950707e-02f, 3.03842634e-01f, 1.12947963e-01f, -1.36956766e-01f, -1.12995222e-01f, -3.84784653e-03f,
  1.22691384e-02f, -1.21262550e-01f, 7.43058398e-02f, -1.42721981e-01f, -1.30231688e-02f, -8.84416401e-02f, -2.42458936e-02f, -1.81590449e-02f, -5.88129386e-02f, -1.22257710e-01f,
  -2.08321977e-02f, 1.13614738e-01f, -1.11459583e-01f, 2.05993466e-02f, 1.47509389e-02f, -2.96420734e-02f, 1.45927221e-01f, 9.16966274e-02f, 8.49912167e-02f, 1.27592549e-01f,
  4.53456938e-02f, -7.53532350e-02f, -3.03010941e-02f, 2.14502085e-02f, -5.89489890e-03f, 1.09204531e-01f, 2.85009965e-02f, 8.27338994e-02f, 2.81948503e-02f, -8.53233878e-03f,
  2.61277556e-02f, 3.64136845e-02f, 3.02361348e-03f, 3.44872959e-02f, -9.68108252e-02f, -5.53594232e-02f, -1.08304508e-01f, 5.09843081e-02f, -7.34479129e-02f, -1.94079150e-02f,
  -8.97252709e-02f, 2.13713315e-03f, -7.06518292e-02f, -2.70053502e-02f, 3.91044319e-02f, -3.03341206e-02f, 3.59958746e-02f, 5.65101355e-02f, 6.75177015e-03f, -5.91950603e-02f,
  2.98662316e-02f, 6.62457794e-02f, -9.94699076e-03f, 2.35060137e-02f, -5.42574655e-03f, 3.69002149e-02f, 3.62527929e-02f, 1.92167349e-02f, 2.15629693e-02f, 5.00274338e-02f,
  6.12116419e-02f, -5.10603562e-02f, -2.28099059e-02f, 6.24158746e-03f, 2.76775081e-02f, -9.75541864e-03f, -2.22429517e-03f, -3.47617939e-02f, -2.79180761e-02f, -3.41692530e-02f,
  2.83331294e-02f, -2.71413866e-02f, 1.02017540e-02f, -4.98174094e-02f, 6.44441023e-02f, 4.86668125e-02f, -1.35566350e-02f, 3.35215516e-02f, -6.52650967e-02f, 9.43638235e-02f,
  -2.22306270e-02f, -5.27672805e-02f, 4.90712784e-02f, -1.45329442e-03f, 4.53122519e-02f, -9.94399097e-03f, 3.29240263e-02f, -1.08352020e-01f, -2.14492995e-02f, -2.39079688e-02f,
  5.53512238e-02f, 4.73227166e-02f, 6.50086552e-02f, -4.54841442e-02f, 2.70957500e-02f, 1.51814679e-02f, 6.59696087e-02f, 1.97554026e-02f, 1.16193861e-01f, -4.98293154e-03f,
  -8.54440778e-03f, 9.01990607e-02f, 3.14171538e-02f, 4.08917852e-03f, 2.98116188e-02f, 1.47277145e-02f, -2.01516058e-02f, -3.66059728e-02f, 5.45638613e-04f, 2.39025857e-02f,
  -1.99877992e-01f, -1.80204719e-01f, -2.78708369e-01f, -2.26335227e-02f, -2.43815538e-02f, -7.94846565e-02f, -2.36121025e-02f, -9.57558528e-02f, -1.43321782e-01f, -1.97173506e-02f,
  1.33420616e-01f, -1.65609494e-01f, -7.78912976e-02f, -2.90277302e-02f, 1.39277503e-01f, 5.93135059e-02f, 3.97940874e-02f, -3.95114440e-03f, -1.19656160e-01f, -7.18394946e-03f,
  -2.79535968e-02f, 1.37384146e-01f, 1.76845528e-02f, 1.10004112e-01f, -8.04381371e-02f, -2.91733667e-02f, 1.61534846e-01f, -3.29200551e-02f, 1.55335695e-01f, 2.27422006e-02f,
  -1.00278817e-01f, 2.04226114e-02f, -4.19814698e-03f, -5.01774698e-02f, 3.55390646e-02f, -8.15754291e-03f, 8.77206214e-03f, -4.49260734e-02f, -5.30414581e-02f, -5.20380288e-02f,
  -1.55616561e-02f, -3.87156475e-03f, 2.38688141e-02f, 5.29932976e-02f, 2.28753369e-02f, 4.49818512e-03f, -1.49907079e-03f, -2.95158122e-02f, -9.12519991e-02f, -5.59401792e-03f,
  -3.78041640e-02f, 7.58356154e-02f, -6.60163090e-02f, 4.74326964e-03f, -4.51870225e-02f, 2.39672419e-02f, 1.95653420e-02f, -8.53357092e-02f, 3.95028815e-02f, 5.17895482e-02f,
  -2.42777877e-02f, -2.86545977e-03f, 9.85904969e-03f, -3.61928977e-02f, 1.37208328e-02f, 4.75491397e-02f, -1.14151172e-03f, 2.26957947e-02f, 6.01794152e-03f, -3.89295258e-02f,
  -2.46635787e-02f, 4.84780222e-02f, 5.99106140e-02f, -3.07881674e-05f, -4.24370617e-02f, 6.45558313e-02f, -6.36888295e-02f, 5.89945018e-02f, -6.18189946e-02f, 4.04493362e-02f,
  -2.63226945e-02f, -3.18294577e-02f, -2.62113698e-02f, 5.85797913e-02f, 2.16713250e-02f, 3.43811400e-02f, 5.32843061e-02f, -7.58631825e-02f, 2.07141619e-02f, 1.58148562e-03f,
  6.04914129e-02f, 1.16504826e-01f, 2.16683093e-02f, 2.23529525e-02f, 1.50961960e-02f, 5.28996922e-02f, 3.08246762e-02f, 4.14421894e-02f, -5.72241396e-02f, -2.05603018e-02f,
  6.94460198e-02f, 9.34300274e-02f, -7.67620951e-02f, -2.04246901e-02f, -5.27507775e-02f, -1.35865947e-03f, 3.68529595e-02f, 8.78037699e-03f, 1.04661986e-01f, -4.27723750e-02f,
  -1.08257290e-02f, -2.56479066e-02f, -4.77338284e-02f, 3.06903012e-02f, 5.63955046e-02f, 1.96581054e-02f, -2.55858861e-02f, 3.42798531e-02f, 4.09881361e-02f, 3.36292051e-02f,
  -8.26270655e-02f, -1.42259046e-01f, -8.73677954e-02f, -6.33762404e-02f, 5.32142743e-02f, 1.23713158e-01f, 1.91226557e-01f, -4.88745384e-02f, -1.04500093e-01f, -6.23442903e-02f,
  2.67920662e-02f, 6.71819225e-02f, 7.13530853e-02f, -9.02080908e-03f, 2.99191236e-01f, 2.34299630e-01f, 1.09833933e-01f, 1.09763280e-01f, 2.55636889e-02f, -2.48953439e-02f,
  -8.20724666e-03f, 1.10968752e-02f, 3.19938362e-02f, 9.41491380e-05f, -1.43967122e-01f, -1.04461424e-01f, -5.44664599e-02f, -7.86804408e-03f, 2.35999469e-02f, 7.74749666e-02f,
  -2.24828199e-02f, 1.03602801e-02f, -8.91946629e-02f, 1.61752105e-02f, -6.02837615e-02f, -7.11579323e-02f, 5.43340221e-02f, -4.21769358e-03f, -8.55428278e-02f, 1.32175079e-02f,
  8.53265170e-03f, -7.63588632e-03f, -1.93685032e-02f, -2.02858038e-02f, -7.10983723e-02f, 6.85916543e-02f, 4.09561954e-02f, -5.95796779e-02f, -4.10500057e-02f, -5.67404926e-02f,
  1.40651353e-02f, 1.86085701e-02f, 2.35807132e-02f, 8.58733580e-02f, -1.40772993e-02f, 5.93847148e-02f, -2.83862241e-02f, 1.68480966e-02f, -6.53577270e-04f, 1.42761990e-02f,
  6.85649142e-02f, 5.62975183e-02f, 1.30032953e-02f, -8.33218396e-02f, -3.43221091e-02f, -2.61162035e-02f, 4.56261188e-02f, 4.12921570e-02f, 1.40371239e-02f, 1.86293274e-02f,
  -1.43268285e-02f, 4.62141857e-02f, -5.15418984e-02f, -5.54030463e-02f, -2.43385099e-02f, 1.99590549e-02f, 2.09651757e-02f, -1.95069180e-03f, 1.14351213e-02f, -4.80750576e-02f,
  -2.13045143e-02f, 1.50446473e-02f, -5.52194230e-02f, -3.91211882e-02f, 4.01135199e-02f, 1.72575228e-02f, 8.31615850e-02f, -5.52838333e-02f, 4.17071246e-02f, 1.67054757e-02f,
  5.24004065e-02f, -1.55459940e-02f, 3.61251296e-04f, 5.88141568e-02f, -8.89643654e-03f, 3.72464471e-02f, 3.98121141e-02f, 1.94030534e-02f, 2.22498160e-02f, -5.89742959e-02f,
  2.64184438e-02f, -1.33776467e-03f, 2.20164433e-02f, -1.09518329e-02f, -6.44078851e-02f, -4.27517481e-02f, -2.26000939e-02f, 2.44327448e-02f, 1.49168847e-02f, 4.27788589e-03f,
  1.65130738e-02f, 2.68248860e-02f, -4.15540412e-02f, 1.39985150e-02f, 1.73909254e-02f, 7.89543912e-02f, -7.79409558e-02f, -6.92662001e-02f, -3.14192586e-02f, -4.98292968e-02f,
  2.98250139e-01f, -2.18388781e-01f, 1.02961414e-01f, 1.70689732e-01f, 4.80434634e-02f, 4.60640062e-03f, 2.41282657e-01f, 1.62463654e-02f, -1.67387798e-02f, -1.32980481e-01f,
  1.11386850e-01f, -4.66328934e-02f, 6.52833208e-02f, 1.04788058e-01f, 3.35277081e-01f, -7.25029327e-04f, 1.65480256e-01f, 6.98880553e-02f, 3.04386392e-02f, 7.06393272e-02f,
  1.79692030e-01f, 1.22971207e-01f, 1.49168059e-01f, 1.35236466e-02f, 5.51995672e-02f, -4.21596989e-02f, 5.50135225e-02f, 2.61530355e-02f, -1.05710765e-02f, -5.17087057e-02f,
  2.98343170e-02f, -5.88984005e-02f, -4.33311090e-02f, -9.63756219e-02f, 7.16166198e-02f, -1.94113248e-03f, -4.65174727e-02f, 6.88541085e-02f, 1.46786068e-02f, 3.65533754e-02f,
  -4.63998057e-02f, -3.75422090e-03f, 2.71409284e-02f, -5.65663492e-03f, -3.02452147e-02f, -6.08020797e-02f, -5.83239906e-02f, -7.76345748e-03f, -9.73508507e-02f, 2.30221003e-02f,
  7.40513504e-02f, -1.98477637e-02f, -6.00113766e-03f, -6.47956505e-02f, 8.15293118e-02f, 3.69993411e-02f, -1.67476963e-02f, -2.29029600e-02f, -7.00496659e-02f, -6.12530150e-02f,
  -5.89828752e-03f, -3.35249156e-02f, -4.36884314e-02f, -2.00994126e-02f, -2.42976844e-02f, 1.68394148e-02f, 5.60754798e-02f, -3.93907679e-03f, 1.67816989e-02f, -1.06211212e-02f,
  1.36535717e-02f, 4.91319895e-02f, -1.30186155e-02f, 3.34751196e-02f, -2.51669120e-02f, -1.67382136e-02f, 3.98575366e-02f, -1.15482081e-02f, 6.71218485e-02f, 4.38389666e-02f,
  8.67848191e-03f, 2.22338457e-02f, -4.46134852e-03f, -2.99120285e-02f, 1.92821175e-02f, 3.33172753e-02f, 3.05345608e-03f, 1.78185459e-02f, -4.15610932e-02f, 3.47914472e-02f,
  -1.01018399e-01f, -4.38623615e-02f, 7.09010288e-02f, 1.57833076e-03f, -2.72023920e-02f, -2.97823697e-02f, 3.75336930e-02f, 9.80585231e-04f, 4.27588411e-02f, 3.90824750e-02f,
  -2.79327948e-03f, 4.45547216e-02f, -1.22348957e-01f, 4.02335897e-02f, 5.69051057e-02f, 7.84287155e-02f, 5.52716665e-02f, -4.41195145e-02f, 1.53760957e-02f, -5.44756278e-03f,
  -3.86835486e-02f, -8.65052417e-02f, -2.20736302e-02f, 7.55665184e-04f, -2.43847724e-02f, -4.79026400e-02f, 6.23002509e-03f, -3.41530852e-02f, -7.99555331e-02f, 7.16686482e-03f,
  -1.38534606e-01f, 4.88372520e-02f, -1.22944176e-01f, -3.17199156e-02f, -2.63376310e-02f, 9.72478744e-03f, -6.95602298e-02f, 6.80588484e-02f, 2.67725158e-02f, 2.99487840e-02f,
  1.57263532e-01f, 1.13362279e-02f, -2.28745863e-02f, 9.36695337e-02f, -3.98376063e-02f, 3.35388109e-02f, 4.72194962e-02f, 5.58976345e-02f, 9.04963389e-02f, 7.10881129e-02f,
  1.20738648e-01f, 2.36080989e-01f, -1.87034812e-02f, 1.11762993e-01f, 1.19672604e-01f, -5.11698946e-02f, 1.00484863e-01f, 4.20457078e-03f, 1.30104899e-01f, 6.93794638e-02f,
  7.23698959e-02f, 7.28494748e-02f, -9.47510377e-02f, -9.82264876e-02f, -9.43194851e-02f, -9.77108777e-02f, -5.82563132e-02f, -8.01551118e-02f, -1.90975033e-02f, 3.58256735e-02f,
  -4.74360399e-02f, 2.48329155e-02f, 5.81076741e-02f, 7.01065585e-02f, 3.31899561e-02f, -8.29605609e-02f, 2.70807762e-02f, 1.26281632e-02f, 1.60442498e-02f, 6.01790026e-02f,
  -4.25118022e-02f, -1.13859801e-02f, -4.85895164e-02f, 2.72781365e-02f, -5.56851849e-02f, 1.68726500e-02f, 4.67926376e-02f, -6.78488165e-02f, -3.37839350e-02f, 7.18730614e-02f,
  -3.06031555e-02f, -6.43052533e-02f, 1.68503057e-02f, 3.62445065e-03f, -1.73541717e-02f, 4.27576341e-02f, 7.81993866e-02f, 5.91106378e-02f, -3.74652147e-02f, 9.02458280e-02f,
  8.52726623e-02f, 6.94057867e-02f, -2.14475039e-02f, -4.65337262e-02f, -3.87826003e-02f, -5.82594536e-02f, -4.70522605e-02f, 7.03375712e-02f, -1.16762789e-02f, -6.96097389e-02f,
  -7.33073950e-02f, -5.47018892e-04f, -7.27956067e-04f, -4.76791747e-02f, -7.78649226e-02f, -6.08320273e-02f, 3.43959779e-02f, 7.69147947e-02f, -4.63882051e-02f, -5.66054024e-02f,
  4.05880734e-02f, 6.38055131e-02f, 2.63460707e-02f, -1.68410745e-02f, -6.75422549e-02f, 4.13684212e-02f, -1.23009793e-02f, 2.58635986e-03f, -7.16759488e-02f, 7.07902834e-02f,
  3.11927181e-02f, 4.45797965e-02f, 1.75878424e-02f, -2.52663773e-02f, -1.43322377e-02f, -4.67251912e-02f, 1.77987886e-03f, -1.71143357e-02f, 8.64123367e-03f, 6.46363199e-02f,
  3.63466702e-02f, 6.19031601e-02f, -6.06304221e-02f, -4.61525563e-03f, -5.37869427e-03f, 7.16223419e-02f, -5.01596630e-02f, 5.72794536e-03f, -5.51851392e-02f, -6.05764464e-02f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  1.10388640e-03f, 2.80274730e-02f, -5.22287600e-02f, 2.47528907e-02f, 3.04789636e-02f, 1.44136148e-02f, -2.54377797e-02f, 3.95423546e-02f, -8.98462683e-02f, 4.13821712e-02f,
  2.54789796e-02f, 4.90780361e-02f, 8.26761276e-02f, 4.81704064e-02f, -3.50691075e-03f, -4.77570035e-02f, -5.62009364e-02f, 8.22054148e-02f, 4.84931692e-02f, 2.93462910e-02f,
  -7.13793514e-03f, -9.09018505e-04f, 1.61100831e-02f, -7.92760625e-02f, 6.49442058e-03f, 5.61854281e-02f, -6.34972230e-02f, 5.45983687e-02f, -4.87373695e-02f, -9.48087201e-02f,
  9.70559344e-02f, -6.84760734e-02f, 2.43867487e-02f, 4.54126224e-02f, 2.55519096e-02f, -4.66964245e-02f, -6.42135516e-02f, 3.92880924e-02f, 5.85457161e-02f, 8.51738825e-03f,
  7.82890469e-02f, 6.76552430e-02f, 4.80500385e-02f, -4.07831892e-02f, -9.08861980e-02f, -4.48178612e-02f, 1.81217771e-02f, -7.15390518e-02f, 6.72824606e-02f, 5.79133257e-02f,
  -6.52688891e-02f, 2.14527100e-02f, -5.30007221e-02f, 2.96369866e-02f, 1.50913757e-03f, -8.51533487e-02f, -5.84416650e-03f, -2.15786155e-02f, 4.85848859e-02f, 1.42806470e-02f,
  -4.43660915e-02f, -8.07318985e-02f, 3.32255587e-02f, -8.52259547e-02f, 8.33061188e-02f, -3.36485393e-02f, -3.31593603e-02f, -7.91030303e-02f, -4.86621028e-03f, 1.91508979e-02f,
  4.78564128e-02f, 6.84570298e-02f, -3.96101939e-04f, 8.76402706e-02f, -7.89247975e-02f, -2.07097679e-02f, -5.34406714e-02f, 8.75859782e-02f, 2.75618490e-02f, 7.26181492e-02f,
  -6.65716529e-02f, -6.95734844e-02f, -8.14453736e-02f, -7.85843432e-02f, -2.43171100e-02f, -5.42589612e-02f, -7.58018047e-02f, 8.30927268e-02f, 7.68135935e-02f, 9.11040977e-02f,
  -5.98243158e-03f, -3.63342427e-02f, 3.28990147e-02f, -6.75864071e-02f, 6.11980148e-02f, -8.79991353e-02f, -3.66508402e-02f, -2.82551832e-02f, 4.08825092e-02f, -1.19940266e-02f,
  8.17091390e-02f, 6.94267899e-02f, 1.51076932e-02f, -3.89174782e-02f, -3.50409336e-02f, -6.90157935e-02f, -6.02579154e-02f, 8.58382881e-02f, -7.92008936e-02f, -1.90407913e-02f,
  -1.54092181e-02f, 6.65126443e-02f, 2.49353629e-02f, -6.32468238e-02f, 2.22592708e-02f, 5.38061671e-02f, 4.14945222e-02f, 2.07336619e-02f, 7.42094591e-02f, -7.10748658e-02f,
  1.06869005e-01f, -3.44245583e-02f, -3.66293490e-02f, 3.01422905e-02f, -6.20410033e-02f, -1.56411882e-02f, -2.66453288e-02f, 4.82085235e-02f, 1.06571093e-01f, 1.78300403e-02f,
  -5.38113490e-02f, -4.90073413e-02f, 1.28618127e-03f, 6.11777455e-02f, -5.84987327e-02f, -7.92108178e-02f, 4.15733978e-02f, -4.59014103e-02f, 6.12684824e-02f, 2.40752869e-03f,
  6.74641132e-02f, -5.27137630e-02f, 1.30980955e-02f, -3.94510254e-02f, -4.70382273e-02f, 8.13429207e-02f, -1.06369294e-01f, 6.53217211e-02f, 4.50208597e-02f, -9.55666229e-02f,
  -7.22534256e-03f, -6.30136877e-02f, 9.38173160e-02f, 7.60214105e-02f, -6.90992922e-02f, 3.40556316e-02f, -1.62909199e-02f, 1.12513388e-02f, 2.95721199e-02f, -9.32230242e-03f,
  -8.01692531e-02f, -4.31638770e-02f, -5.50538935e-02f, -6.83147162e-02f, 6.10406063e-02f, -2.45367717e-02f, -2.98390836e-02f, 1.76319517e-02f, 6.61621392e-02f, -8.03719461e-02f,
  -2.23245826e-02f, -9.21018273e-02f, 1.59337670e-02f, -3.50434892e-02f, 1.24848038e-02f, -3.68822105e-02f, -4.51358184e-02f, -6.68995231e-02f, -6.56041801e-02f, -1.59759838e-02f,
  6.15966786e-03f, 9.17811617e-02f, -3.78118269e-02f, 2.88722161e-02f, -2.05369275e-02f, 4.39476967e-02f, -5.54575212e-02f, -4.97223362e-02f, 2.73629781e-02f, 4.32339609e-02f,
  8.02849382e-02f, 2.57570725e-02f, -3.34371664e-02f, 2.29314668e-03f, -6.41741306e-02f, -2.69240281e-03f, -3.73695269e-02f, -5.19773625e-02f, -8.25361386e-02f, -4.90955710e-02f,
  2.93135066e-02f, -1.62713453e-02f, 3.35942246e-02f, 3.10267676e-02f, 4.38857675e-02f, -1.18000628e-02f, -7.33488724e-02f, -3.87776978e-02f, -3.52567714e-03f, 2.79791076e-02f,
  2.27068812e-02f, 2.91423649e-02f, 2.88929380e-02f, -1.06676966e-01f, -7.97738656e-02f, 7.43591273e-03f, -3.35768946e-02f, 2.45260205e-02f, 2.29293387e-02f, 6.19164146e-02f,
  -3.80049422e-02f, 2.56255977e-02f, -3.97166843e-03f, 1.57946628e-02f, -8.73692185e-02f, -1.45577183e-02f, 7.18876049e-02f, -7.15839416e-02f, 5.41399792e-03f, -3.72216627e-02f,
  9.51421037e-02f, -2.70385034e-02f, 4.92228381e-02f, -2.22003739e-02f, -4.54782695e-02f, 6.28221110e-02f, 3.98533009e-02f, -7.95361698e-02f, -2.00215261e-02f, 6.12051401e-04f,
  -9.98865906e-03f, -1.30439579e-01f, -2.45219305e-01f, -8.58762637e-02f, -2.09083464e-02f, -2.67771065e-01f, -2.87351608e-01f, -7.52073601e-02f, 6.10714406e-02f, 2.38180831e-02f,
  -1.25912502e-01f, 3.26720662e-02f, 1.16062097e-01f, -2.48894826e-01f, 1.41522447e-02f, 1.10194132e-01f, -2.50156581e-01f, -9.16747600e-02f, 1.34234130e-01f, -1.01629026e-01f,
  -1.11593464e-02f, -1.47351861e-01f, -9.54027697e-02f, -5.36176935e-02f, -1.54241219e-01f, 1.48500234e-03f, 1.55694887e-01f, -7.21945092e-02f, -1.14082128e-01f, -8.26110318e-02f,
  -4.69661094e-02f, -4.01901826e-02f, -5.87899163e-02f, 6.23872830e-03f, -1.27620608e-01f, -5.54091409e-02f, -3.09938472e-02f, 4.63803336e-02f, -1.49722239e-02f, 1.33640384e-02f,
  1.65290609e-02f, 5.70545681e-02f, -3.27279717e-02f, 1.90440025e-02f, 2.62583997e-02f, -1.79081298e-02f, -4.77576479e-02f, 8.02801996e-02f, -1.01757281e-01f, -4.55187634e-02f,
  -7.51908720e-02f, -3.83681096e-02f, -6.57011569e-02f, -1.58613846e-02f, 2.22437643e-02f, -1.04555465e-01f, -6.26510978e-02f, -4.92573250e-03f, -8.54373351e-02f, 5.11741862e-02f,
  3.85332443e-02f, 2.62726494e-03f, -3.47813964e-02f, -1.40167912e-02f, 2.78363656e-02f, -4.94492166e-02f, 3.49553302e-02f, 5.51739372e-02f, 3.69622968e-02f, 1.24283717e-03f,
  4.69173566e-02f, 3.27920020e-02f, 2.97317747e-02f, -3.52518223e-02f, 4.95340936e-02f, 9.25635993e-02f, 3.70799676e-02f, -3.76752876e-02f, 4.19422844e-03f, -1.62730068e-02f,
  3.38520259e-02f, 5.50238006e-02f, 3.75331123e-03f, 6.70628324e-02f, -1.01879972e-03f, 2.99866572e-02f, -5.43280467e-02f, 1.57693587e-02f, -4.80156485e-03f, -6.06299266e-02f,
  -3.59454937e-02f, -1.22672349e-01f, 3.97838131e-02f, 2.19294988e-03f, 4.25777957e-02f, -2.39255354e-02f, 5.59803285e-02f, -5.24488874e-02f, 3.54657248e-02f, -9.67938825e-02f,
  -5.53597920e-02f, 1.66510530e-02f, 4.51833308e-02f, 6.03147149e-02f, -1.06495805e-02f, 2.49785208e-03f, -1.33752811e-03f, 3.09638213e-02f, -2.19942126e-02f, 2.94266306e-02f,
  -2.51011495e-02f, 8.95847194e-03f, 1.29502255e-03f, 6.55084029e-02f, 2.12915186e-02f, -2.37723421e-02f, -1.88775547e-02f, 9.14982706e-02f, 9.70043801e-03f, 1.03570707e-02f,
  4.92334999e-02f, 1.54610991e-01f, 2.05609933e-01f, 3.90506312e-02f, -7.71753713e-02f, -1.88070118e-01f, -2.15270855e-02f, 1.18146166e-02f, -3.35191377e-02f, 3.69830579e-02f,
  1.08499695e-02f, 8.90650749e-02f, -4.34288643e-02f, -3.25555950e-02f, -1.57271862e-01f, -1.18349843e-01f, 2.89279614e-02f, -6.28278181e-02f, 4.53204215e-02f, 5.96658811e-02f,
  -1.29760683e-01f, 6.99636433e-03f, 3.30673382e-02f, 9.36860815e-02f, -2.23495904e-02f, 2.47185342e-02f, -1.21716514e-01f, 6.05712719e-02f, 1.47561748e-02f, -2.69355793e-02f,
  -5.33347651e-02f, 4.79012206e-02f, 1.21901616e-01f, -2.67596953e-02f, -4.77200300e-02f, -6.73900619e-02f, -6.85453564e-02f, -7.12162852e-02f, 3.58198434e-02f, 1.48153557e-02f,
  6.77778646e-02f, -2.62896996e-02f, 8.88433009e-02f, -2.09874809e-02f, 4.39756922e-02f, -3.21835652e-02f, 1.02610856e-01f, 9.81619656e-02f, -4.10654284e-02f, 8.29629377e-02f,
  3.94795313e-02f, 8.51184055e-02f, -6.31039590e-02f, -1.37910359e-02f, 3.77153270e-02f, 7.61208013e-02f, 5.04988171e-02f, 1.46127036e-02f, -5.85793378e-03f, 8.13591033e-02f,
  5.01869172e-02f, -7.45513514e-02f, -1.08880043e-01f, 1.46794720e-02f, -6.70176744e-02f, -3.84491161e-02f, 3.78711000e-02f, -6.67587221e-02f, -8.93278420e-02f, 4.60280292e-03f,
  -8.73391703e-02f, 3.69809717e-02f, -7.86677897e-02f, -4.09957804e-02f, -1.34868640e-02f, -6.45066872e-02f, -5.54100946e-02f, -6.96103051e-02f, 4.16726805e-02f, -9.82841104e-03f,
  9.61165056e-02f, -8.66345912e-02f, 7.55485594e-02f, 4.93540242e-02f, -2.92276405e-02f, -9.22678411e-03f, 7.67740831e-02f, -6.52895635e-03f, -1.18842945e-02f, 1.05331689e-02f,
  2.44949274e-02f, 5.34819998e-02f, 9.01815295e-03f, 9.93223116e-02f, 5.64815588e-02f, -2.85312869e-02f, 7.09749684e-02f, 8.02441388e-02f, -6.80371597e-02f, -4.24175151e-03f,
  -2.98037863e-04f, 5.88606447e-02f, 1.16065731e-02f, 1.88597515e-02f, -6.60915822e-02f, 3.10890526e-02f, 1.13515835e-02f, 6.56485185e-02f, -7.38035282e-03f, 9.54576135e-02f,
  6.41063834e-03f, -6.00424744e-02f, 2.31397264e-02f, -4.56076562e-02f, 4.08636332e-02f, 6.71695918e-02f, 2.68595703e-02f, 3.42495628e-02f, 3.73635665e-02f, 4.08864394e-02f,
  -2.09170412e-02f, 1.37997447e-02f, -7.36645758e-02f, 3.99913564e-02f, 9.84321069e-03f, -1.08530536e-01f, -1.11988224e-01f, 8.06685090e-02f, -1.61169976e-01f, 9.00292769e-02f,
  -6.84249252e-02f, -9.76812541e-02f, -6.53451830e-02f, -1.35656282e-01f, -6.50264323e-02f, -1.85374454e-01f, 3.88172902e-02f, -1.27686113e-01f, -1.77428231e-01f, 9.55734849e-02f,
  -3.42017524e-02f, 6.09525703e-02f, 7.44119957e-02f, 1.56383455e-01f, 1.63905188e-01f, 1.61823094e-01f, 2.88557261e-01f, 7.66423941e-02f, 1.78036764e-01f, 5.49844913e-02f,
  -2.66228095e-02f, -3.51675674e-02f, -3.51391621e-02f, -1.43676642e-02f, 7.26046860e-02f, 1.04819804e-01f, 8.44984874e-02f, -5.53041734e-02f, -6.06193803e-02f, -1.30995706e-01f,
  -2.76189130e-02f, -5.07589802e-02f, -8.93380642e-02f, -9.01137292e-02f, 4.32548337e-02f, -5.71070723e-02f, 1.25218732e-02f, 6.37471974e-02f, -3.70788649e-02f, -1.70024801e-02f,
  -4.53080647e-02f, -7.04744309e-02f, 5.78565672e-02f, -1.56770609e-02f, -1.93288215e-02f, 3.98852825e-02f, 4.08650823e-02f, 5.37462495e-02f, 3.07415072e-02f, -3.06852106e-02f,
  6.31286129e-02f, -2.23488752e-02f, 7.81705603e-03f, -5.26365638e-02f, -8.84403735e-02f, -7.06031099e-02f, -6.24218583e-02f, 3.93782258e-02f, 1.40938545e-02f, -5.90379536e-02f,
  6.48900047e-02f, -2.75919847e-02f, -2.46509891e-02f, 5.48780933e-02f, -3.24125253e-02f, -4.22464907e-02f, 3.88389453e-03f, 6.97035268e-02f, 2.54477636e-04f, -6.94657415e-02f,
  -9.79384128e-03f, 3.87903154e-02f, -3.24149877e-02f, 7.42253140e-02f, -6.16574138e-02f, -1.22087998e-02f, -7.24608661e-04f, 1.03693670e-02f, 5.70280962e-02f, 1.09037779e-01f,
  2.22676471e-02f, 2.06009805e-01f, -2.20109499e-03f, -4.70699035e-02f, -6.90319091e-02f, -1.04096860e-01f, -2.97796559e-02f, 3.27013470e-02f, 1.48661509e-01f, 5.28029650e-02f,
  2.93774419e-02f, 4.19140980e-02f, 6.08846620e-02f, 5.91063835e-02f, 9.20432582e-02f, -1.44723840e-02f, 2.66467570e-03f, 5.84425889e-02f, 8.01786855e-02f, 5.39102703e-02f,
  1.30545154e-01f, -4.43429984e-02f, 3.16681750e-02f, 8.12979713e-02f, 1.81931295e-02f, -2.72755548e-02f, 2.82096472e-02f, -3.22664864e-02f, -1.22927297e-02f, -6.61916053e-03f,
  1.34218028e-02f, 1.23436995e-01f, -5.69965504e-03f, 7.78657943e-02f, -5.54361604e-02f, 5.26387393e-02f, 4.51679267e-02f, -4.18176614e-02f, 8.68656337e-02f, 1.54578596e-01f,
  2.20378283e-02f, 1.32601663e-01f, 7.38429576e-02f, -2.14292426e-02f, 1.22714527e-01f, 8.04954916e-02f, 1.31657064e-01f, 2.76318695e-02f, 8.96153972e-03f, -4.15413361e-03f,
  -2.72011105e-02f, 5.49538247e-02f, -1.48167551e-01f, -7.74565935e-02f, -3.60474437e-02f, -8.93731862e-02f, -7.69742131e-02f, -8.94342959e-02f, -7.05265999e-02f, -8.13139379e-02f,
  -7.79835433e-02f, 4.86732535e-02f, -4.50725593e-02f, 7.04517663e-02f, 6.15213923e-02f, 3.70188267e-03f, -2.19497513e-02f, -3.85393240e-02f, 4.09555100e-02f, 1.64543465e-02f,
  -3.12792026e-02f, 5.08271679e-02f, 9.81571451e-02f, 2.45083887e-02f, 4.41040611e-03f, 3.96186560e-02f, 5.83285950e-02f, 2.14179810e-02f, -5.13130538e-02f, -4.64956369e-03f,
  -7.39595154e-03f, 3.59650292e-02f, -9.05863792e-02f, -2.53675096e-02f, -7.77218044e-02f, 2.68903077e-02f, -6.05267286e-02f, -3.10971029e-02f, 7.61144608e-02f, -1.07401535e-02f,
  2.69577969e-02f, 6.96886936e-03f, -2.81477571e-02f, 4.15010890e-03f, 1.52129065e-02f, -1.00241296e-01f, -5.67002594e-02f, -6.06616363e-02f, -6.86973110e-02f, -3.31656411e-02f,
  -4.45603244e-02f, 2.17137802e-02f, -1.06068607e-02f, 4.59215082e-02f, 3.34199071e-02f, -1.05163101e-02f, -6.97641447e-02f, 4.19575535e-02f, 4.20366749e-02f, 2.44037323e-02f,
  -4.22380725e-03f, 5.44226356e-02f, 9.36668739e-03f, -2.12291609e-02f, 7.55639672e-02f, 2.97735427e-02f, -4.13566530e-02f, -5.43922819e-02f, -7.82874152e-02f, -5.42128384e-02f,
  8.81204102e-03f, 1.57238647e-01f, 4.02251817e-02f, 7.86788613e-02f, 1.20882215e-02f, 6.56792987e-03f, -4.66396026e-02f, -6.56867772e-02f, 7.89838880e-02f, 6.95634037e-02f,
  8.66177604e-02f, -8.90264213e-02f, 4.65646945e-02f, -3.00977435e-02f, 8.05921927e-02f, -5.88232763e-02f, 8.85582878e-04f, -6.94726706e-02f, 5.10923229e-02f, 2.73363534e-02f,
  -5.02068102e-02f, 2.55277120e-02f, 8.11367780e-02f, -6.26113405e-03f, -1.48603087e-02f, -3.57774422e-02f, 1.11258402e-01f, 5.78442328e-02f, 3.80569734e-02f, 8.50370601e-02f,
  1.12199284e-01f, -5.36776967e-02f, -7.12925792e-02f, 6.76205233e-02f, 5.74267581e-02f, -1.00742253e-02f, 1.00338154e-01f, -4.31330167e-02f, 9.18127447e-02f, 1.20623775e-01f,
  7.47330114e-02f, 1.18313562e-02f, 4.43869755e-02f, 3.71665247e-02f, 1.15252793e-01f, -4.05140184e-02f, 1.02527551e-01f, -2.98042819e-02f, 6.40088841e-02f, 1.11060403e-01f,
  5.74118942e-02f, 1.90167688e-02f, -3.28264609e-02f, 1.32767158e-02f, 9.69663337e-02f, -1.77250628e-03f, -7.34195346e-03f, -9.51735079e-02f, 7.47820362e-02f, -5.36803249e-03f,
  -8.30868632e-02f, 5.60278371e-02f, 1.04085933e-02f, -5.96395731e-02f, 7.65490755e-02f, 6.26017079e-02f, 1.96954850e-02f, -7.07475469e-02f, 5.64849563e-02f, -7.18296170e-02f,
  -2.40689535e-02f, 4.26709987e-02f, -7.84903020e-02f, -1.24763632e-02f, 4.71159853e-02f, -4.74496596e-02f, -5.88397160e-02f, -3.55372131e-02f, 6.66431934e-02f, 1.29366983e-02f,
  -7.32623190e-02f, -8.00225660e-02f, 8.27879272e-03f, -8.23471248e-02f, -1.12917617e-01f, 6.88528717e-02f, -2.71689855e-02f, -9.44605693e-02f, -4.23588380e-02f, -2.80231722e-02f,
  -4.32543568e-02f, 6.08723648e-02f, 3.72934826e-02f, -1.57108009e-02f, -2.45264806e-02f, 1.87675171e-02f, 7.76138017e-03f, -2.60687852e-03f, -4.62514162e-02f, 6.65375665e-02f,
  3.26113030e-02f, -4.82802130e-02f, -2.62421668e-02f, 6.97664022e-02f, 7.22968131e-02f, -3.56896594e-02f, -2.31213868e-02f, -2.06197593e-02f, 5.23295300e-03f, 4.80688214e-02f,
  -4.57296893e-02f, -5.58574125e-02f, -1.17149241e-02f, -3.13831605e-02f, -6.14819564e-02f, 1.76327880e-02f, 8.29592571e-02f, -6.34997897e-03f, 4.73858556e-03f, 4.10136543e-02f,
  2.43058987e-02f, -1.17593342e-02f, -6.52441457e-02f, 2.55103093e-02f, 7.22635090e-02f, 4.17408533e-02f, 6.72993883e-02f, -5.92454523e-02f, -8.59999433e-02f, 1.32080000e-02f,
  -1.32156229e-02f, 1.86306331e-02f, -3.30031924e-02f, 1.61572136e-02f, 3.78179178e-02f, 2.59481929e-02f, -8.57351720e-02f, 1.33504188e-02f, 6.77336678e-02f, -5.27476296e-02f,
  2.57003829e-02f, -2.03227391e-03f, 8.94342214e-02f, -6.61947131e-02f, -9.17249024e-02f, 4.88350801e-02f, 6.75230101e-02f, 4.13138326e-03f, 7.32353106e-02f, -5.30346595e-02f,
  -5.89444414e-02f, -1.81264699e-01f, -1.00219004e-01f, -7.46865233e-04f, 1.36691570e-01f, -6.92599714e-02f, -4.42015417e-02f, 5.68685047e-02f, -1.59472376e-01f, -3.52278352e-02f,
  1.44064710e-01f, 3.87620330e-02f, -1.48753658e-01f, 1.16837911e-01f, 1.34366050e-01f, -4.55225781e-02f, 1.64648280e-01f, 2.93004978e-02f, 3.57528329e-02f, -1.74974706e-02f,
  -2.15029940e-02f, 2.14184925e-01f, -4.15606201e-02f, 1.51104063e-01f, 2.04080995e-02f, -3.69666493e-03f, 1.25205472e-01f, -8.50477219e-02f, 2.14120239e-01f, 2.01713294e-01f,
  -8.02280083e-02f, -3.16706859e-02f, -8.02534968e-02f, 3.72092687e-02f, 2.68204454e-02f, 3.03824488e-02f, -9.50020924e-02f, 1.32900821e-02f, 7.90489838e-02f, 4.58593965e-02f,
  -7.58245168e-03f, 7.16080815e-02f, 2.92269532e-02f, 4.52247262e-02f, -3.03844716e-02f, 1.05629288e-01f, -1.13091953e-02f, -2.65826266e-02f, -6.11417852e-02f, -3.82542275e-02f,
  -1.24739997e-01f, -5.54359034e-02f, 8.39158893e-03f, -2.05126163e-02f, -6.09470867e-02f, -6.27687275e-02f, -7.08312020e-02f, 1.50297675e-02f, -1.00682080e-02f, -7.52683356e-03f,
  -8.49698186e-02f, -7.28708580e-02f, 2.86613274e-02f, 7.06696436e-02f, -1.34018129e-02f, 3.97877432e-02f, -2.52855234e-02f, 3.09329201e-02f, 1.58170462e-02f, 4.74034362e-02f,
  9.21367260e-04f, -2.84050498e-02f, 7.18814433e-02f, 4.83791605e-02f, -4.99102771e-02f, -3.52164358e-02f, -4.87871692e-02f, -3.02192308e-02f, 5.19139208e-02f, -3.93859148e-02f,
  -6.04691878e-02f, -4.52091843e-02f, -7.84061626e-02f, -2.44321395e-02f, -3.60783450e-02f, -3.86452377e-02f, 3.43207791e-02f, -5.24588451e-02f, -2.72100400e-02f, 1.23599963e-02f,
  -3.83802466e-02f, -1.00135338e-02f, 5.66961616e-02f, -3.52215990e-02f, 7.45375976e-02f, 8.89859274e-02f, 7.99166858e-02f, 4.41874675e-02f, -3.97427529e-02f, 3.37205641e-02f,
  -4.74425741e-02f, -6.31546304e-02f, 2.87553817e-02f, -2.53770780e-02f, 7.49606788e-02f, -3.87632400e-02f, -5.51862381e-02f, 3.43724638e-02f, -5.34686819e-03f, 4.35308814e-02f,
  4.18524444e-02f, 5.82553074e-03f, 4.42587100e-02f, 4.82114889e-02f, 1.89442746e-02f, 1.42699564e-02f, -5.93687221e-02f, 3.56612243e-02f, 2.78894845e-02f, 4.86798622e-02f,
  -1.10211574e-01f, 6.36383891e-02f, -1.66486040e-01f, -6.60890937e-02f, -1.01924784e-01f, -1.20611973e-02f, -7.90780261e-02f, -6.19531237e-02f, -2.45227553e-02f, 1.58454880e-01f,
  -5.22966348e-02f, -2.60469783e-03f, 1.45013362e-01f, 1.19007096e-01f, 3.86237539e-02f, 4.09875065e-02f, 5.22933081e-02f, 5.02871498e-02f, -4.21015982e-04f, -6.80095553e-02f,
  6.75853938e-02f, -6.32071942e-02f, -7.22018769e-03f, 6.91378042e-02f, 6.56052493e-04f, 3.12263556e-02f, 2.73412224e-02f, -6.02315888e-02f, -5.36526889e-02f, -9.83037576e-02f,
  -2.79552247e-02f, -6.50997460e-02f, -1.05605453e-01f, -7.14673325e-02f, -5.08328481e-03f, -9.00024176e-02f, -6.17374070e-02f, 6.82621226e-02f, -4.86859865e-02f, -2.90546454e-02f,
  -3.62267904e-02f, -3.98395471e-02f, -5.86847067e-02f, 4.05504815e-02f, -8.77670050e-02f, -7.01012760e-02f, 4.91671674e-02f, 9.29200351e-02f, 2.95108780e-02f, 5.47886789e-02f,
  -1.42115569e-02f, 7.52104595e-02f, 9.27498713e-02f, -1.93586498e-02f, -7.59829162e-03f, 7.02836588e-02f, 2.88939420e-02f, -3.54562774e-02f, -6.75835162e-02f, 1.41273148e-03f,
  3.86564136e-02f, -3.78359072e-02f, -3.35960798e-02f, 9.42634866e-02f, -6.77750213e-03f, 1.01103686e-01f, -2.32058186e-02f, -1.03299789e-01f, -4.56219167e-02f, 1.14924845e-03f,
  -2.64384113e-02f, 1.59724969e-02f, -2.06341464e-02f, -3.08120027e-02f, -2.79848147e-02f, 8.80927742e-02f, 7.72874281e-02f, -1.34587837e-02f, 5.25066294e-02f, 1.22499773e-02f,
  4.61240336e-02f, -2.05348618e-02f, -1.94190376e-04f, 1.42873116e-02f, -5.88261932e-02f, 3.44880000e-02f, 8.27125609e-02f, 6.76045716e-02f, 1.53551875e-02f, 2.72357203e-02f,
  -5.85603230e-02f, -7.26260468e-02f, 1.66970845e-02f, -5.80472238e-02f, 6.78492486e-02f, 4.84957062e-02f, -2.72606816e-02f, 2.10714135e-02f, 3.55319381e-02f, -2.40931753e-02f,
  -9.86704230e-02f, -8.57184678e-02f, -1.61756184e-02f, -3.05443653e-04f, 6.33497313e-02f, -6.87891711e-03f, 6.02031276e-02f, -2.11942289e-02f, 7.56898371e-04f, -5.70731051e-02f,
  7.56671205e-02f, -4.68091108e-02f, -1.63724385e-02f, -5.41756004e-02f, -9.07496607e-04f, -2.34249197e-02f, 6.51092678e-02f, 1.91702452e-02f, -3.25863883e-02f, -1.14383452e-01f,
  -2.22008899e-02f, 6.59561828e-02f, -2.92693283e-02f, -1.17797032e-01f, 3.47013511e-02f, 6.81279823e-02f, 6.65784068e-03f, -4.61421274e-02f, 1.31834170e-03f, 3.87118123e-02f,
  2.62563247e-02f, -3.84909585e-02f, 5.43178692e-02f, -8.17506611e-02f, -3.39710563e-02f, 1.55479293e-02f, -2.49560513e-02f, 4.89459820e-02f, -7.64977485e-02f, -1.56485140e-02f,
  6.63063452e-02f, -7.07616936e-03f, 9.33382288e-02f, -2.81348377e-02f, -4.89756875e-02f, 7.76561275e-02f, -1.34203490e-02f, 2.44369693e-02f, -3.98365632e-02f, 5.17920256e-02f,
  -7.35838013e-03f, -5.65423146e-02f, -8.14616159e-02f, -4.92519289e-02f, 5.97983524e-02f, 5.59491403e-02f, 7.26032108e-02f, -9.88686737e-03f, 3.93017083e-02f, -1.38826938e-02f,
  2.79888324e-02f, -5.83906993e-02f, -3.39010619e-02f, -4.11333852e-02f, -8.69171321e-02f, -7.79107213e-03f, -7.91555494e-02f, 6.58264682e-02f, -9.14327055e-02f, -3.50513458e-02f,
  3.15906852e-02f, 1.12035517e-02f, 1.88393723e-02f, -1.44538265e-02f, 3.75626534e-02f, -7.65451640e-02f, -4.74874564e-02f, 4.77472097e-02f, -1.59885604e-02f, -3.73016559e-02f,
  -2.32289336e-03f, 5.21584414e-03f, -4.12012488e-02f, 3.35934646e-02f, 2.49342397e-02f, 3.15180272e-02f, 7.89503679e-02f, 2.33840514e-02f, 7.71070793e-02f, 2.27403678e-02f,
  -1.60175525e-02f, 9.45183784e-02f, 5.95761172e-04f, -2.48638149e-02f, -6.83750138e-02f, -7.41462260e-02f, -8.01008567e-02f, 7.64558613e-02f, 9.77678038e-03f, -5.11987731e-02f,
  2.80822976e-03f, -2.84828246e-02f, -2.30947267e-02f, -3.99142057e-02f, -8.42670351e-02f, -7.54780844e-02f, 4.43339013e-02f, 5.39114513e-02f, 8.76810476e-02f, -5.61862066e-02f,
  6.67406097e-02f, -6.12344034e-02f, -8.82540196e-02f, 3.73381935e-02f, -7.33664185e-02f, 5.26251644e-02f, 2.28066407e-02f, 2.95497440e-02f, -4.48095873e-02f, -4.48255707e-03f,
  -3.06156762e-02f, 7.61555210e-02f, -1.30286422e-02f, 4.76009957e-02f, -4.65762615e-02f, -7.35368133e-02f, -8.12731963e-03f, 4.56197001e-02f, -8.13760757e-02f, 1.89076085e-02f,
  -1.11983074e-02f, 6.89940676e-02f, 4.63008471e-02f, 8.35728124e-02f, -3.82485762e-02f, 3.13714519e-02f, 5.88901201e-03f, -5.17647564e-02f, -3.07817850e-02f, 7.05789849e-02f,
  3.07737701e-02f, 3.97076048e-02f, 1.07107889e-02f, 8.75958577e-02f, -7.15135410e-02f, -2.68013198e-02f, 1.14745133e-01f, -9.34039652e-02f, -9.11137983e-02f, 8.35763738e-02f,
  -3.98775935e-02f, 4.52785343e-02f, 4.92943563e-02f, 5.70969954e-02f, -4.83674444e-02f, -5.05574048e-02f, 4.63837646e-02f, 1.06108293e-01f, -1.15657367e-01f, 8.64727721e-02f,
  9.23630409e-03f, -3.67471091e-02f, -8.22063237e-02f, -3.86470482e-02f, 8.63548834e-03f, 2.83685215e-02f, 6.62413985e-02f, -4.36770730e-02f, 7.05470070e-02f, 6.01515584e-02f,
  -4.03212942e-02f, -5.99877313e-02f, -8.49940032e-02f, -2.84570679e-02f, -3.86772417e-02f, -7.28815496e-02f, 5.78677990e-02f, -8.86610821e-02f, 6.27368838e-02f, -4.63041104e-02f,
  -4.55007032e-02f, -2.74435300e-02f, -4.43239957e-02f, -4.45947833e-02f, 1.97193772e-02f, 7.32961297e-03f, 5.20883985e-02f, 1.71349384e-04f, -1.00466534e-02f, 1.72612760e-02f,
  -2.74001360e-02f, -8.47697109e-02f, 6.30738726e-03f, 7.02883489e-03f, 1.12147098e-02f, -1.02446325e-01f, -6.95386007e-02f, 8.92899092e-03f, -6.69108555e-02f, -4.80604731e-02f,
  5.87089173e-02f, -2.82708593e-02f, -6.31884038e-02f, 2.54044738e-02f, 6.01451918e-02f, 2.29366999e-02f, 6.71830922e-02f, 6.98780715e-02f, 7.91197047e-02f, 2.83485632e-02f,
  1.19861923e-02f, -7.52653778e-02f, -1.01360790e-02f, -8.56888145e-02f, -4.95309614e-05f, 9.45972055e-02f, -2.79793199e-02f, 5.12893461e-02f, -6.65502325e-02f, -4.55364585e-02f,
  6.09580874e-02f, -4.01521474e-02f, -3.17102112e-02f, 3.05026434e-02f, -8.78403708e-02f, -6.92123398e-02f, -9.30294991e-02f, 1.36724394e-02f, 5.41949607e-02f, -7.14580566e-02f,
  -9.58900200e-04f, -9.19460803e-02f, -2.46459395e-02f, -3.51049118e-02f, 7.50110000e-02f, -1.66595113e-02f, -8.72838721e-02f, 7.03007653e-02f, -6.84070364e-02f, 3.78606655e-02f,
  9.34000537e-02f, 5.80813028e-02f, -4.16568294e-02f, -5.17274104e-02f, 7.37397075e-02f, -1.66820269e-02f, -7.82495644e-03f, 4.51912694e-02f, -7.62935877e-02f, 3.92768756e-02f,
  -8.91256556e-02f, -5.88477291e-02f, -2.53645610e-02f, -5.65000586e-02f, 3.40764597e-02f, 8.75854790e-02f, 7.42868930e-02f, -3.08955018e-03f, 6.77937567e-02f, -3.67195494e-02f,
  -7.11689517e-02f, -9.95275155e-02f, -7.40708783e-02f, 7.04609677e-02f, 7.55003095e-02f, -3.42962407e-02f, -1.21893749e-01f, 4.02410626e-02f, -1.04718588e-01f, -6.40358925e-02f,
  2.92645097e-02f, 2.46813870e-03f, -1.29484311e-02f, 1.02130853e-01f, 2.62045441e-03f, -1.23958915e-01f, 1.24679193e-01f, -4.05625105e-02f, 1.12699941e-02f, -2.61108465e-02f,
  1.37384105e-02f, 1.45338267e-01f, 1.93674471e-02f, 5.99115975e-02f, 8.89064372e-02f, -3.95905375e-02f, 1.58186018e-01f, -2.40335818e-02f, 1.67525321e-01f, -1.97166819e-02f,
  4.20211405e-02f, -2.26025726e-03f, -5.63389733e-02f, 6.18784726e-02f, 1.90230999e-02f, 6.25132816e-03f, 6.39293576e-03f, 9.33394954e-03f, -2.99177263e-02f, 7.63600022e-02f,
  1.53584899e-02f, -5.24939261e-02f, 6.03556037e-02f, -2.75866874e-02f, 3.63493487e-02f, 5.24569489e-02f, 5.53139783e-02f, 1.37199908e-02f, -9.34272818e-03f, 5.44480272e-02f,
  -4.78270538e-02f, 2.85573006e-02f, 9.40885022e-02f, -5.90424277e-02f, -5.57969324e-02f, -1.83451399e-02f, 1.54013941e-02f, 3.26194279e-02f, 7.49969631e-02f, -4.33508828e-02f,
  -4.35935520e-02f, 8.96830559e-02f, 5.27982973e-02f, 3.13330330e-02f, 9.13352445e-02f, -7.30681345e-02f, 3.69107351e-02f, -1.45208407e-02f, -3.02583016e-02f, -2.86766477e-02f,
  -6.94706291e-02f, 1.38265491e-02f, -2.07179487e-02f, -1.58435907e-02f, 7.53988847e-02f, 8.84213597e-02f, 3.53193060e-02f, 1.08795986e-02f, -1.48346294e-02f, -7.46257789e-03f,
  -7.46647536e-04f, 7.78803378e-02f, -6.73476905e-02f, -8.41710251e-03f, 7.54954144e-02f, -8.93163905e-02f, 3.43333632e-02f, 4.71987240e-02f, 4.59464975e-02f, -3.28825898e-02f,
  1.55494437e-02f, 1.92805789e-02f, -2.41069049e-02f, 8.47961009e-02f, 8.22924972e-02f, 4.90011200e-02f, -4.84387353e-02f, -4.41870186e-03f, -3.69219445e-02f, 2.02754512e-02f,
  -1.35894036e-02f, -5.02513573e-02f, -1.04700029e-02f, -8.05634931e-02f, -7.15952832e-03f, -2.90759820e-02f, -3.27603221e-02f, -7.36302510e-02f, -2.92112771e-03f, -2.71701720e-02f,
  -3.51826772e-02f, -8.85893125e-03f, 5.12183122e-02f, -9.69965532e-02f, -3.19715254e-02f, -6.57657832e-02f, 2.00565066e-02f, -1.41468057e-02f, 2.78673079e-02f, 4.04455625e-02f,
  7.56846815e-02f, -9.10712639e-04f, 4.39922437e-02f, 6.77659437e-02f, 1.11811906e-01f, 4.27437797e-02f, 1.19258231e-02f, 4.74855267e-02f, -1.19420104e-01f, 2.47127879e-02f,
  6.68189675e-02f, -8.63472372e-02f, -9.27798375e-02f, 1.46395396e-02f, 2.08505476e-03f, -9.77000669e-02f, 6.45182878e-02f, -8.07809308e-02f, -2.59739487e-03f, -3.28666251e-03f,
  6.60971403e-02f, 5.57307564e-02f, -9.07536596e-02f, -3.42118442e-02f, -5.71778379e-02f, 1.10896872e-02f, 7.46919811e-02f, -3.01774684e-02f, 8.76215100e-02f, 4.13737111e-02f,
  -4.66561094e-02f, -7.26286024e-02f, -8.55435580e-02f, -5.08406833e-02f, 6.99120834e-02f, -5.72931916e-02f, -5.75344637e-02f, -2.36654039e-02f, -8.74889921e-03f, -1.89732632e-03f,
  -3.74840684e-02f, 6.05826192e-02f, 2.67031062e-02f, 6.22050501e-02f, -3.00466903e-02f, -7.24009052e-02f, 2.25230516e-03f, -3.35548967e-02f, -1.12837162e-02f, -1.94901135e-02f,
  1.18711870e-02f, 7.00012818e-02f, -6.13250844e-02f, 3.56572680e-02f, -5.77379912e-02f, 3.84955592e-02f, -3.53454985e-02f, 1.04751596e-02f, -1.98649708e-02f, -3.40619795e-02f,
  8.99651721e-02f, -9.91568808e-03f, -6.57469183e-02f, 4.15167883e-02f, 7.03990608e-02f, 6.91168103e-03f, 3.03049907e-02f, -8.89898092e-02f, -7.11712167e-02f, -5.84291294e-02f,
  2.73142010e-02f, 7.88083002e-02f, 6.43906668e-02f, -6.95853308e-02f, 4.88405898e-02f, 2.79461034e-03f, -6.26228750e-02f, 8.77574608e-02f, 3.69511656e-02f, 4.67482097e-02f,
  -6.56678602e-02f, 1.80438682e-02f, 7.58484751e-03f, 7.60376230e-02f, -1.24769574e-02f, 2.08230298e-02f, -6.77776858e-02f, 8.24905187e-02f, 5.34276925e-02f, -5.99396974e-02f,
  -4.86912690e-02f, -5.45148067e-02f, 7.60424659e-02f, 1.96827594e-02f, -4.99111637e-02f, 9.90883261e-03f, -8.98711011e-02f, 3.32579501e-02f, -8.53881165e-02f, 2.32803393e-02f,
  6.58172220e-02f, -3.87642682e-02f, -3.48320007e-02f, -1.54853868e-03f, -5.39731905e-02f, -5.57357222e-02f, -4.96091284e-02f, -2.66346708e-02f, -2.74330378e-02f, -4.92952019e-02f,
  7.42390379e-02f, 2.62527280e-02f, 7.36691952e-02f, 7.21692890e-02f, -3.22939493e-02f, 8.96712393e-03f, 5.91771379e-02f, -4.25942242e-02f, 2.04790365e-02f, -1.58701148e-02f,
  1.01405792e-02f, 2.69353539e-01f, 1.48833722e-01f, 8.49956498e-02f, -1.36768699e-01f, -2.83798099e-01f, -5.42490892e-02f, 1.41157806e-01f, 3.24911922e-02f, -4.67923768e-02f,
  -1.43441726e-02f, 1.64983228e-01f, 6.17343970e-02f, 3.23075540e-02f, 5.13994637e-05f, -2.20732130e-02f, 7.79523551e-02f, 4.54947799e-02f, 7.55682364e-02f, 1.24262467e-01f,
  9.44880918e-02f, 1.18079390e-02f, 9.00401101e-02f, 1.45368829e-01f, 8.35494474e-02f, 2.11117834e-01f, 7.38401490e-04f, -3.55928801e-02f, 1.28346354e-01f, 3.19788861e-03f,
  -8.98225233e-02f, 1.32995754e-01f, 4.51457314e-02f, -9.98968165e-03f, -4.49080057e-02f, -6.25943542e-02f, 7.68125728e-02f, 4.36747037e-02f, 5.81024727e-03f, 6.57836767e-03f,
  -1.62010789e-02f, -6.50283918e-02f, -4.81384359e-02f, -4.14688960e-02f, -1.08297944e-01f, 3.97310667e-02f, 5.26824482e-02f, 3.78742479e-02f, 7.58685991e-02f, 9.99793038e-02f,
  8.91297013e-02f, 2.74460088e-03f, -8.56372118e-02f, -6.99028596e-02f, -8.12675990e-03f, -6.14617020e-02f, -2.80484315e-02f, 1.03476830e-01f, 9.23183337e-02f, -4.88077067e-02f,
  -7.81096593e-02f, -3.44357528e-02f, -3.50275077e-03f, 1.07892510e-02f, 4.35829945e-02f, 9.54786092e-02f, 1.16765685e-02f, -4.61406596e-02f, 3.27998661e-02f, -3.56004126e-02f,
  -5.42705283e-02f, -1.28724491e-02f, -7.35295787e-02f, -5.33049740e-02f, -1.74286887e-02f, -5.30081242e-02f, 2.00485196e-02f, -1.03404280e-02f, 5.45137096e-03f, 8.49405676e-02f,
  4.06848751e-02f, -6.08966649e-02f, 3.27768661e-02f, 3.15652415e-02f, 7.75733450e-03f, -5.92788495e-02f, 7.30023608e-02f, -3.90033722e-02f, -4.88949157e-02f, -4.31860099e-03f,
  -9.72422585e-02f, 1.04924142e-01f, -1.27606662e-02f, 2.04241313e-02f, 4.16928931e-04f, -2.85390224e-02f, -3.83990370e-02f, 6.66405447e-03f, -6.20263480e-02f, 5.71831013e-04f,
  5.32201082e-02f, 4.26612422e-02f, -3.08073666e-02f, -1.33659700e-02f, 8.25288985e-03f, 1.10310754e-02f, -2.85527967e-02f, 2.10093521e-02f, 6.19332083e-02f, -5.72677189e-03f,
  3.83070782e-02f, -6.44926429e-02f, -3.03166598e-04f, -8.31402689e-02f, 3.84198898e-03f, -5.51652536e-02f, -4.15187329e-02f, 3.87418792e-02f, 1.70418639e-02f, -7.14987284e-04f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  4.87425812e-02f, 2.51114070e-02f, -5.46389669e-02f, 1.18234247e-01f, 7.14091584e-02f, 9.99287292e-02f, -3.37029845e-02f, 1.07398264e-01f, 4.91258353e-02f, -6.49526864e-02f,
  -4.17180024e-02f, 8.47495720e-03f, 5.04847616e-02f, -2.06903089e-02f
};

// L1_fan_Wp (Shape: 25 x 64)
const int L1_fan_Wp_rows = 25;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  7.79277412e-03f, -9.64206383e-02f, -3.49177495e-02f, 6.52525946e-02f, -1.31126596e-02f, -7.44207762e-03f, -3.52390972e-03f, -2.13750854e-01f, 2.72786040e-02f, -1.82522908e-02f,
  -8.34104940e-02f, 1.32972538e-01f, -5.46770394e-02f, 1.37901396e-01f, -9.66198277e-03f, 1.75849237e-02f, 4.61140089e-02f, -4.66927774e-02f, 1.27968192e-01f, 6.09770380e-02f,
  8.21704045e-02f, 1.01800822e-01f, 5.64507432e-02f, 5.69964685e-02f, -4.25984189e-02f, -8.71766284e-02f, 1.04655325e-01f, -9.52038020e-02f, 1.06922016e-01f, -7.36354887e-02f,
  -1.64943546e-01f, 9.34718773e-02f, -4.17583957e-02f, -1.63069427e-01f, 8.90356768e-03f, 5.46501942e-05f, -1.83267623e-01f, -7.83372298e-02f, 1.41210228e-01f, 2.10062101e-01f,
  -7.49363378e-02f, 7.65277445e-02f, 3.55128609e-02f, -7.96609223e-02f, 1.58073783e-01f, 1.10409908e-01f, 4.01582755e-02f, 1.68943599e-01f, -6.11921325e-02f, -7.74156116e-03f,
  -8.22387263e-02f, -9.56165567e-02f, 2.06904653e-02f, 2.83819977e-02f, -1.71770081e-01f, -1.02127446e-02f, 3.01490109e-02f, 4.90696449e-03f, 1.24545000e-01f, 8.29394311e-02f,
  -8.29231143e-02f, -7.34739304e-02f, 2.72113867e-02f, -1.82512626e-02f, -1.75194070e-01f, 5.55310175e-02f, -2.03089401e-01f, 2.29920577e-02f, -2.33414456e-01f, -1.40179247e-01f,
  -1.87804893e-01f, -3.68894160e-01f, 1.10928282e-01f, -1.75218597e-01f, -4.12919670e-02f, -1.15073919e-01f, -2.14723311e-02f, 1.40816182e-01f, -1.51587486e-01f, -3.38897221e-02f,
  1.02504157e-01f, -9.21674073e-02f, -8.11592638e-02f, -6.46754578e-02f, -1.13463476e-02f, -2.93324422e-02f, -9.99322385e-02f, 1.94550842e-01f, -8.60446319e-02f, -1.88746601e-01f,
  7.82131031e-02f, -1.67758629e-01f, 3.40917856e-01f, 7.91880190e-02f, 7.05294609e-02f, 5.59318103e-02f, -2.02432483e-01f, 6.62622079e-02f, -3.84010188e-02f, -1.72272660e-02f,
  -6.16206266e-02f, 8.15167129e-02f, 3.80007997e-02f, 6.84328228e-02f, -4.02993150e-02f, 1.28338346e-02f, -6.62707910e-02f, -2.42755041e-01f, 1.03686742e-01f, -2.38349475e-03f,
  2.60176539e-01f, 1.13564655e-01f, -4.20672186e-02f, 5.90719245e-02f, 3.46665457e-03f, -1.14095278e-01f, 1.91216215e-01f, -1.97685704e-01f, -7.68757612e-02f, 7.08595440e-02f,
  9.86181796e-02f, 1.30928263e-01f, 1.43742999e-02f, -1.07149303e-01f, 6.20908290e-02f, -6.94941655e-02f, 7.33323544e-02f, -3.87806781e-02f, 5.71579188e-02f, -1.02505311e-01f,
  1.19324304e-01f, 5.85918985e-02f, -3.11225019e-02f, -6.84748963e-02f, -3.41485478e-02f, 3.04182827e-01f, 7.46453106e-02f, 4.32399586e-02f, -6.60272315e-02f, -8.83772895e-02f,
  -3.54575627e-02f, -2.59719878e-01f, -2.80010793e-02f, 8.77464190e-02f, 1.31936938e-01f, 1.08788416e-01f, 1.49758905e-01f, -2.89237518e-02f, -6.42581424e-03f, -4.12876643e-02f,
  -7.06008002e-02f, -2.10841037e-02f, 1.25265449e-01f, 3.74428779e-01f, -2.09741201e-02f, 2.09632650e-01f, -5.21962084e-02f, 1.10612564e-01f, -7.06873387e-02f, -3.77057604e-02f,
  1.99379161e-01f, 1.97092205e-01f, -6.05498441e-02f, 8.80401134e-02f, 5.03009334e-02f, -1.06051624e-01f, 2.77020298e-02f, -1.33710086e-01f, 5.67097291e-02f, 4.63571846e-02f,
  -2.01862752e-01f, 1.22222602e-01f, -3.12696099e-02f, -1.74328730e-01f, -3.05159152e-01f, -1.84522886e-02f, 9.49200764e-02f, -9.81704369e-02f, -6.65369779e-02f, -1.08056277e-01f,
  -2.52692044e-01f, 3.15383971e-02f, 9.45575163e-02f, 1.01897649e-01f, -3.59809250e-02f, -1.44210964e-01f, -1.61161572e-01f, 1.23919018e-01f, -1.86644401e-02f, -1.55741856e-01f,
  -9.57912952e-02f, 2.33077258e-01f, 6.82701617e-02f, 7.12691918e-02f, -4.55298312e-02f, -2.99197361e-02f, -7.10905716e-02f, 9.17864069e-02f, 1.77569035e-02f, -6.91940859e-02f,
  2.40520313e-02f, 6.01857714e-02f, 5.04204705e-02f, -7.89827630e-02f, -6.76326677e-02f, -1.52478695e-01f, -1.33886477e-02f, -3.30566131e-02f, -3.93185802e-02f, 1.08517736e-01f,
  -2.31617555e-01f, 3.99191752e-02f, -1.04712611e-02f, -1.04251660e-01f, -6.28899187e-02f, -2.78210640e-02f, -1.90483667e-02f, 2.83760726e-01f, 1.11411974e-01f, 3.65251452e-02f,
  -1.75574347e-02f, 2.96726942e-01f, 9.11322907e-02f, 1.03634045e-01f, -1.41140878e-01f, 2.27244809e-01f, -1.89982325e-01f, -1.99860513e-01f, 1.50013149e-01f, 8.17711130e-02f,
  8.33334103e-02f, -3.37837301e-02f, 1.90105036e-01f, -2.53681183e-01f, -5.05197607e-02f, -7.27050677e-02f, 5.02217328e-03f, -1.24873519e-01f, -9.23133045e-02f, -4.00903597e-02f,
  2.63733000e-01f, 6.04511164e-02f, -8.89152065e-02f, 4.31321226e-02f, -1.96298420e-01f, 6.79665431e-02f, 7.38337785e-02f, 1.26906019e-02f, 1.92561433e-01f, 1.37290224e-01f,
  -1.05185747e-01f, -4.10438469e-03f, -1.32608384e-01f, 9.07756016e-02f, -2.76604034e-02f, 1.70764267e-01f, -5.50619848e-02f, 2.04089787e-02f, -4.87599485e-02f, -9.68133099e-03f,
  8.96774232e-02f, 5.59640229e-02f, 8.48001093e-02f, 1.30584165e-01f, -2.52289623e-02f, -1.37643982e-03f, 4.54479679e-02f, 1.06636889e-01f, -3.98665778e-02f, -7.36403465e-02f,
  -2.16077967e-03f, 5.59459068e-02f, 5.56763001e-02f, 1.45869732e-01f, -1.31151555e-02f, -1.35956453e-02f, -5.48208356e-02f, 9.38786417e-02f, 8.24607909e-02f, -1.04037434e-01f,
  -1.07506536e-01f, 1.41850367e-01f, 2.71377079e-02f, 6.29036054e-02f, 5.47421239e-02f, 2.44839653e-01f, 1.58788692e-02f, -7.51716122e-02f, 8.58889818e-02f, 2.18539611e-01f,
  -1.92596361e-01f, -1.07312024e-01f, 9.09976587e-02f, 4.73833047e-02f, 2.59661134e-02f, -1.23641081e-01f, 1.94924384e-01f, -1.45139620e-01f, -1.67746410e-01f, -1.38459578e-01f,
  -1.69888645e-01f, -8.85768309e-02f, 1.01505764e-01f, -1.15559474e-01f, 1.13382563e-01f, 1.02926105e-01f, -1.05182163e-01f, 9.07350481e-02f, -1.39193490e-01f, -8.13548118e-02f,
  1.98109329e-01f, 1.02819674e-01f, 6.87414631e-02f, 1.34038314e-01f, -4.71504256e-02f, 2.53927242e-02f, -1.00981727e-01f, 1.72364548e-01f, 1.62631810e-01f, -9.04850587e-02f,
  -1.18401326e-01f, 2.14086026e-02f, -4.79902625e-02f, -9.16604772e-02f, -1.71754643e-01f, -1.06828809e-02f, -9.68668461e-02f, -1.04129501e-01f, 1.21308632e-01f, -1.06422529e-01f,
  1.35456771e-01f, 7.27900788e-02f, 2.06782855e-02f, -1.12172747e-02f, 2.26636394e-03f, 1.02627814e-01f, -6.44850656e-02f, -5.24144098e-02f, -2.03578964e-01f, -5.59976809e-02f,
  -4.71618325e-02f, -5.61195686e-02f, 4.33429852e-02f, -8.17800388e-02f, -6.70831427e-02f, -1.34946676e-02f, 5.57466643e-03f, 7.62207583e-02f, 2.54022002e-01f, 6.59511909e-02f,
  4.43618596e-02f, -1.06309645e-01f, 3.84154506e-02f, 6.52675778e-02f, -5.72892763e-02f, 5.09432703e-02f, 4.84139696e-02f, 1.13975527e-02f, 9.75554436e-02f, -1.21125847e-01f,
  8.27093273e-02f, -1.08592294e-01f, -1.70880407e-01f, -2.28938162e-01f, 8.58083293e-02f, -7.14485943e-02f, 8.67946297e-02f, -5.39507866e-02f, -1.78301949e-02f, -2.52661351e-02f,
  -5.04130572e-02f, 3.03616049e-03f, 1.06328823e-01f, -1.29376501e-01f, 9.29856673e-02f, 4.64940583e-03f, -4.18144977e-03f, 1.24406964e-01f, 1.85803045e-02f, 6.40573576e-02f,
  4.32137921e-02f, -3.68524380e-02f, -5.36552295e-02f, 8.08182731e-02f, 5.02114967e-02f, 2.21828092e-03f, 3.14234663e-03f, 1.38982441e-02f, 3.09581067e-02f, -3.66272107e-02f,
  3.59897986e-02f, 8.80523622e-02f, 9.40048993e-02f, 4.35349271e-02f, -4.40505110e-02f, -6.71326891e-02f, -9.82753187e-02f, 2.97640283e-02f, 5.29997908e-02f, -8.15634895e-03f,
  9.20904353e-02f, 4.67966124e-02f, 5.85994571e-02f, -1.06549591e-01f, 6.25140667e-02f, -9.94698778e-02f, -5.44638336e-02f, 1.49105817e-01f, 1.44497259e-02f, -8.02981332e-02f,
  3.36207524e-02f, -5.72402328e-02f, -1.60137955e-02f, -8.21950957e-02f, 8.94717202e-02f, -4.03523147e-02f, -3.87931429e-02f, 8.20896775e-02f, -5.19415457e-03f, 9.16542858e-02f,
  4.55022417e-02f, -1.19477093e-01f, -4.33103628e-02f, 4.85917963e-02f, 9.99022871e-02f, -1.14794210e-01f, 3.66984382e-02f, 7.94774368e-02f, -4.49934090e-03f, -5.50330207e-02f,
  4.20151874e-02f, -3.97991017e-02f, -2.48547811e-02f, -1.39274657e-01f, 1.10176712e-01f, 4.74894717e-02f, -6.94713444e-02f, -3.46431285e-02f, 9.65025574e-02f, -4.45062220e-02f,
  4.37051617e-02f, 4.63630632e-02f, 5.53586381e-03f, 2.16790419e-02f, 7.20097572e-02f, -9.02628824e-02f, -6.06277101e-02f, -8.21935833e-02f, 1.29171014e-02f, -2.87444089e-02f,
  4.22610017e-03f, -6.04990683e-02f, -1.23159237e-01f, -5.12320101e-02f, 1.34895056e-01f, -6.28689453e-02f, 2.86776535e-02f, -1.53781623e-01f, 6.72367448e-03f, -6.01581782e-02f,
  3.33696161e-03f, -1.47119388e-02f, -1.71773881e-02f, -7.64000043e-02f, -2.40255101e-03f, -1.33027986e-01f, 6.27110600e-02f, 4.02192771e-02f, 6.26925603e-02f, -1.17314093e-01f,
  4.49590199e-02f, 9.67355743e-02f, 4.75443527e-02f, 1.76475585e-01f, 1.14527293e-01f, -3.06786727e-02f, 5.91281764e-02f, -1.95795789e-01f, -8.55785608e-03f, -8.70949328e-02f,
  -9.17105600e-02f, -1.55788973e-01f, 2.54254103e-01f, -4.14030440e-02f, -1.34858172e-02f, 4.40201648e-02f, 1.50727853e-01f, 1.72793400e-03f, -4.41520996e-02f, 2.55586714e-01f,
  1.76233813e-01f, -1.01305701e-01f, 2.00532958e-01f, -1.26292050e-01f, -6.51009008e-02f, 9.28670540e-03f, -2.95238167e-01f, 1.33212537e-01f, -8.73636901e-02f, -4.26594689e-02f,
  5.65365218e-02f, 1.41606659e-01f, -1.19862832e-01f, 1.12999216e-01f, -1.92300169e-04f, -1.02842420e-01f, 8.60189721e-02f, -1.78077966e-02f, 3.18440869e-02f, -6.96887150e-02f,
  -1.32666081e-01f, 1.75670639e-01f, -5.34540564e-02f, -4.98886295e-02f, -3.87564860e-02f, -6.18400872e-02f, 2.20763683e-02f, -8.00668299e-02f, -1.18657187e-01f, 2.60058105e-01f,
  8.74348159e-04f, 1.72273174e-01f, -9.16195437e-02f, -5.16201705e-02f, -9.75695550e-02f, -1.31818011e-01f, 9.45458934e-02f, 2.25615893e-02f, 1.45420879e-01f, 2.49639917e-02f,
  -5.84806688e-02f, -8.01278874e-02f, -1.21246316e-01f, -2.26338990e-02f, -9.62623507e-02f, -2.76809395e-03f, -6.60557821e-02f, 2.79151708e-01f, -5.60374744e-03f, 5.71409315e-02f,
  -2.82482114e-02f, 7.05374181e-02f, 2.39126720e-02f, 3.41945961e-02f, -1.34608867e-02f, 2.25397453e-01f, -1.15692347e-01f, -3.54869291e-02f, -7.48096108e-02f, -7.14998618e-02f,
  9.39971488e-03f, -6.56865463e-02f, 2.00111493e-01f, -1.87921569e-01f, -2.59866506e-01f, -7.07170069e-02f, -3.01929610e-03f, -1.04074925e-01f, -1.25163063e-01f, -9.74064469e-02f,
  2.18172729e-01f, 1.03254407e-03f, -4.72865859e-03f, 1.18212467e-02f, -2.01307654e-01f, 8.54809731e-02f, 5.84581718e-02f, 1.69665128e-01f, 5.61417080e-02f, -1.01162411e-01f,
  -2.04962939e-02f, -3.39768119e-02f, -5.42838918e-03f, -1.01986982e-01f, -7.82383159e-02f, 1.09030776e-01f, 9.53249410e-02f, -6.84928373e-02f, 1.11753516e-01f, -1.09919362e-01f,
  1.79563209e-01f, 4.29319143e-02f, -5.79229370e-02f, 2.64750898e-01f, -9.75230858e-02f, -2.33616438e-02f, -5.51411733e-02f, 6.13836618e-03f, 1.05612330e-01f, -6.70304894e-03f,
  1.10195354e-01f, -2.82413699e-03f, 1.79280683e-01f, 4.26080450e-02f, 6.77111968e-02f, -1.14913071e-02f, -6.19946122e-02f, 4.67682350e-03f, 4.65065949e-02f, 1.19172819e-01f,
  1.36469752e-01f, -7.85864443e-02f, -1.57073617e-01f, 5.75797074e-02f, -7.63136148e-02f, 1.19682655e-01f, -1.40138954e-01f, -1.03996113e-01f, -8.17731023e-02f, -6.64797723e-02f,
  3.77590992e-02f, 1.10895701e-01f, 2.33870391e-02f, 6.93090111e-02f, 2.59953681e-02f, 1.47403121e-01f, -7.56049901e-03f, -4.34780009e-02f, 1.20496474e-01f, 3.23434956e-02f,
  -1.56436309e-01f, 2.16641307e-01f, 2.73494441e-02f, 6.27624989e-02f, 1.74958840e-01f, 2.03125109e-03f, -2.44839303e-02f, -4.95271571e-02f, -2.52749175e-01f, -8.03177506e-02f,
  -6.59727976e-02f, -1.20997086e-01f, -5.11567062e-03f, -9.98598337e-02f, -1.19946145e-01f, 4.13879342e-02f, 1.20101988e-01f, 7.55876750e-02f, -6.75646067e-02f, -2.13096783e-01f,
  -9.53645334e-02f, 1.04723006e-01f, 1.66454181e-01f, 6.81148097e-02f, 7.57836476e-02f, 3.86010334e-02f, 1.48652434e-01f, 1.17304519e-01f, -1.14889644e-01f, 3.56232151e-02f,
  -5.16766906e-02f, -8.99692997e-02f, -5.93029894e-02f, -1.57080099e-01f, 5.34066334e-02f, -4.45134901e-02f, 5.62365763e-02f, 1.46036536e-01f, -6.48064166e-02f, 2.24483404e-02f,
  -1.38200521e-01f, -1.53334856e-01f, -1.21665560e-01f, -3.60705629e-02f, 9.82257202e-02f, -2.42249966e-02f, -6.42936081e-02f, 1.59578815e-01f, -9.62978378e-02f, -1.65006116e-01f,
  1.43006116e-01f, -1.22492626e-01f, 8.12614262e-02f, -1.43059239e-01f, 2.13838011e-01f, -1.58793032e-01f, 1.35031939e-01f, 1.31611407e-01f, 1.80873066e-01f, -1.83506519e-01f,
  2.87447684e-02f, -4.38490743e-03f, 1.36367813e-01f, 1.73024863e-01f, -2.94068139e-02f, -7.01863840e-02f, -9.34082568e-02f, -2.21036240e-01f, -1.51773736e-01f, 6.08240701e-02f,
  -5.04445769e-02f, 1.97707256e-03f, 1.26455158e-01f, 1.21453933e-01f, 2.73867417e-02f, -2.54670903e-02f, -8.67567956e-02f, 1.41651303e-01f, -1.38721466e-01f, 1.54224560e-02f,
  3.60917971e-02f, 1.24050446e-01f, -1.15342058e-01f, 2.18588725e-01f, 4.32152227e-02f, -1.06898069e-01f, -8.79712924e-02f, -2.24201363e-02f, -9.25319195e-02f, 1.20592338e-03f,
  9.16511714e-02f, -8.28137994e-02f, -6.92955256e-02f, -5.14200814e-02f, 3.04902736e-02f, -8.09579045e-02f, -1.08547278e-01f, -6.13768883e-02f, -1.24491051e-01f, 5.35070971e-02f,
  -9.72082019e-02f, -5.89037724e-02f, 4.54434715e-02f, 6.07573837e-02f, -4.54098172e-02f, 2.96464060e-02f, 1.11630015e-01f, -1.01024523e-01f, 1.64558943e-02f, -1.48836166e-01f,
  -6.54923916e-02f, -2.41431631e-02f, -1.24942688e-02f, 4.18869480e-02f, 5.71218580e-02f, 5.14631532e-02f, -8.04801006e-03f, 8.84876400e-02f, -1.93598062e-01f, 1.40887618e-01f,
  -1.14586726e-01f, -2.72100065e-02f, -7.81858116e-02f, 1.74975514e-01f, 3.30875255e-02f, 4.83060591e-02f, -1.24232054e-01f, -1.49484619e-01f, -1.47700071e-01f, -7.59649202e-02f,
  2.50617284e-02f, 1.96579903e-01f, 2.03436419e-01f, -1.02201626e-01f, -8.20557624e-02f, -4.27627414e-02f, -1.18117206e-01f, -1.13512650e-01f, -5.40307835e-02f, 1.01246446e-01f,
  -6.11993410e-02f, 1.31504506e-01f, -1.97687801e-02f, 6.60689175e-02f, 1.00239944e-02f, -1.88842751e-02f, 6.73752353e-02f, -6.14387393e-02f, 5.09420112e-02f, 1.82368755e-02f,
  -2.06581056e-02f, 6.21530898e-02f, 6.49122298e-02f, 3.74294296e-02f, 9.93954763e-02f, 2.17101336e-01f, 7.52580613e-02f, 1.84332103e-01f, -7.37001225e-02f, 7.35047683e-02f,
  6.55478463e-02f, -1.03361890e-01f, 5.97077347e-02f, -5.75688668e-02f, 1.72746375e-01f, 1.39658809e-01f, 9.29194018e-02f, -4.45343554e-02f, -4.42420645e-03f, -1.16064340e-01f,
  1.32471707e-03f, -7.01401904e-02f, -9.52543691e-02f, 2.23728959e-02f, 2.88872253e-02f, 2.18629092e-02f, -1.69368923e-01f, -6.99360967e-02f, 1.26748443e-01f, -1.27674922e-01f,
  1.75100774e-01f, 5.70095293e-02f, -1.75959855e-01f, -4.42999266e-02f, 6.30012080e-02f, -1.25185728e-01f, -9.40778702e-02f, -2.17295781e-01f, 1.03134193e-01f, -1.20461166e-01f,
  -2.40386371e-02f, 5.09777777e-02f, -2.77154863e-01f, -1.62344113e-01f, -1.79852054e-01f, 6.16805106e-02f, 1.55601501e-01f, -1.90878361e-01f, 9.25306603e-02f, -8.90695006e-02f,
  -2.01136932e-01f, 2.92237625e-02f, 9.73557159e-02f, -6.31224513e-02f, -6.90229237e-02f, -5.50428629e-02f, -9.78725329e-02f, -7.72346407e-02f, 1.02814749e-01f, 7.92564452e-02f,
  -8.54941178e-03f, 1.78235337e-01f, -1.25924915e-01f, 1.99162737e-02f, 9.56906527e-02f, -2.03316715e-02f, 9.50293764e-02f, 9.96910315e-03f, 4.22096252e-02f, 2.38719314e-01f,
  -1.94238182e-02f, 1.50197506e-01f, 1.54600544e-02f, 1.94684730e-03f, 4.84325625e-02f, 4.88847680e-02f, -8.76743719e-02f, -1.13415956e-01f, 9.01176929e-02f, 2.97296960e-02f,
  6.37936294e-02f, -1.11028692e-02f, -6.77381083e-02f, 6.31856248e-02f, -1.14553899e-01f, 8.72025490e-02f, 3.93329524e-02f, 5.49748465e-02f, -1.06399536e-01f, 3.92209031e-02f,
  -1.43534496e-01f, -6.29719570e-02f, 6.55540079e-02f, 1.75375462e-01f, -6.77219257e-02f, 7.30707943e-02f, 5.23981415e-02f, 4.06362116e-02f, -5.91127500e-02f, -1.17374500e-02f,
  -7.96798896e-03f, 4.85307351e-02f, 1.88031420e-01f, -1.16308838e-01f, 8.83815065e-03f, 1.65674925e-01f, 5.47883213e-02f, -8.23291615e-02f, -9.57249701e-02f, -8.11793879e-02f,
  -6.33421242e-02f, -1.92906067e-01f, -1.32254055e-02f, -7.44607896e-02f, -1.32184073e-01f, 1.04180619e-01f, -4.32346202e-02f, 8.56263787e-02f, 8.10151547e-02f, 2.59999782e-02f,
  2.38118484e-03f, 3.88368219e-02f, 1.02087371e-01f, -7.33375326e-02f, 4.52007875e-02f, -8.93681124e-02f, 4.86239828e-02f, -6.14630803e-02f, 4.62964661e-02f, -2.32517477e-02f,
  -1.29979029e-01f, -9.47990119e-02f, 6.41355664e-02f, 3.19849253e-02f, 1.01998277e-01f, -6.98207989e-02f, -1.23580962e-01f, 5.25193624e-02f, -3.86825837e-02f, -2.83691976e-02f,
  -4.69941162e-02f, 5.47644831e-02f, 1.54503539e-01f, -1.49639845e-01f, 1.32732764e-01f, -1.41386077e-01f, 5.69366664e-02f, 8.15184265e-02f, -4.10440704e-03f, 1.15434721e-01f,
  -3.40383463e-02f, 1.15169711e-01f, 1.24288127e-02f, -1.70198336e-01f, -1.02784839e-02f, 8.64088163e-02f, -4.29626293e-02f, -5.96325519e-03f, -3.50911282e-02f, 9.72655267e-02f,
  -8.54862556e-02f, -7.38364458e-02f, -1.24026328e-01f, 4.19406071e-02f, -9.32183191e-02f, 4.61087301e-02f, -5.45933619e-02f, -2.29832977e-02f, -4.60044190e-04f, -2.88294479e-02f,
  -2.33068559e-02f, 6.70192167e-02f, 9.00413916e-02f, 9.99751315e-02f, 1.18450476e-02f, -7.55095184e-02f, -1.71206426e-02f, 1.05316088e-01f, -9.02621672e-02f, -4.65593636e-02f,
  -1.43125877e-01f, 1.34599417e-01f, 9.57476422e-02f, -1.13533922e-01f, 9.79885161e-02f, -1.27883956e-01f, 1.36944905e-01f, 4.38922867e-02f, 1.12500474e-01f, 2.55450811e-02f,
  -1.81804970e-01f, -6.15680739e-02f, -8.48305449e-02f, 1.08825386e-01f, -8.24339911e-02f, 1.04528770e-01f, -8.35096538e-02f, -2.03098506e-02f, -2.76509410e-04f, 3.43621187e-02f,
  5.42281941e-02f, 1.05591819e-01f, 6.28422052e-02f, -9.83269140e-02f, -2.93661878e-02f, 2.42659869e-03f, 3.18830796e-02f, 5.15185855e-02f, -1.55833319e-01f, -6.65851980e-02f,
  5.59310317e-02f, 1.78629160e-02f, 5.71423285e-02f, 8.12529176e-02f, 1.69028435e-02f, 5.58028277e-03f, 1.06186941e-01f, -1.35836557e-01f, 2.68633336e-01f, 1.51905403e-01f,
  4.97706495e-02f, -3.20308730e-02f, 8.19327757e-02f, 1.63802430e-01f, -4.73482497e-02f, -1.27100691e-01f, -6.37126565e-02f, 7.24080130e-02f, 1.62062084e-03f, 4.26614732e-02f,
  9.03132483e-02f, -5.87806152e-03f, -1.36815652e-01f, -1.17470764e-01f, 1.19320735e-01f, 9.43300650e-02f, 4.94405674e-03f, 3.81227322e-02f, 1.17097102e-01f, 1.00822337e-01f,
  7.94216692e-02f, 1.22200735e-02f, 1.18239619e-01f, -1.25500575e-01f, 1.00551195e-01f, 1.21465385e-01f, 1.31846383e-01f, 5.76963425e-02f, -9.29373056e-02f, -6.99237660e-02f,
  1.26320403e-02f, 1.41489953e-01f, -1.18256919e-02f, 4.06643935e-02f, 4.31060325e-03f, 1.84988845e-02f, -2.60786386e-03f, 6.14140816e-02f, -4.93358187e-02f, -1.22217825e-02f,
  -7.97329992e-02f, 1.32477405e-02f, 4.75883931e-02f, 4.99233119e-02f, -3.92852239e-02f, 7.43922964e-02f, 8.30033123e-02f, 4.10797000e-02f, -3.60119380e-02f, -9.91340205e-02f,
  4.23716940e-02f, -6.72525242e-02f, 2.33777404e-01f, 6.32203519e-02f, 3.30464207e-02f, -7.60301352e-02f, 3.50115681e-03f, 8.45088903e-03f, -3.98305664e-03f, -8.71541277e-02f,
  1.08759925e-01f, -9.83221531e-02f, -1.97716102e-01f, 9.33474954e-03f, -1.45630464e-01f, 1.12396851e-02f, -1.62713364e-01f, 4.40322310e-02f, -8.57770965e-02f, 1.11812696e-01f,
  -1.97879985e-01f, 4.29562367e-02f, -9.59470570e-02f, 2.76300281e-01f, -3.67533378e-02f, 1.48227558e-01f, 8.56426656e-02f, 4.18351665e-02f, 1.41950205e-01f, 1.22267365e-01f,
  -1.66847885e-01f, -2.23776419e-02f, -5.42859100e-02f, 1.66842043e-02f, 7.69439787e-02f, -9.41259973e-03f, -1.54302418e-01f, -8.70420560e-02f, -1.69249356e-01f, -3.36776897e-02f,
  -3.12268790e-02f, -1.51940688e-01f, 2.98045706e-02f, 1.34152891e-02f, -1.81016140e-02f, -4.56416346e-02f, -3.56348343e-02f, -7.61603042e-02f, -4.94507216e-02f, -1.32473096e-01f,
  3.46075445e-02f, -1.06855102e-01f, 1.25682995e-01f, -1.04589872e-01f, 5.09174587e-03f, -1.12597160e-01f, 4.15941775e-02f, -4.58704382e-02f, -1.28028378e-01f, -9.30750649e-03f,
  2.69589275e-02f, 9.41119641e-02f, 3.53067145e-02f, -9.62700322e-02f, -1.09126143e-01f, 1.11202709e-01f, 1.27461568e-01f, 1.12921104e-01f, -1.22101349e-03f, -9.94623154e-02f,
  6.81062117e-02f, -8.85897875e-02f, 1.24969274e-01f, -2.15156212e-01f, 2.23405063e-02f, 4.70945276e-02f, -2.18224466e-01f, -2.21119732e-01f, -1.86450947e-02f, -1.72164172e-01f,
  1.75115645e-01f, -2.00168103e-01f, 1.87053338e-01f, 6.62700459e-02f, 8.57996661e-03f, -8.69026631e-02f, -4.03315388e-03f, -2.30638981e-02f, -1.89088091e-01f, 1.02539761e-02f,
  1.89604193e-01f, 1.86729252e-01f, 6.15546405e-02f, 9.93719473e-02f, 9.80442762e-03f, -9.78960171e-02f, -1.90370515e-01f, -6.31216019e-02f, -9.39599518e-03f, -1.08113430e-01f,
  1.17308326e-01f, 1.59986678e-03f, 6.34645373e-02f, 3.35548483e-02f, -8.46509188e-02f, -6.92871064e-02f, -2.30906997e-02f, 8.21655765e-02f, -3.74479443e-02f, 1.87597405e-02f,
  2.30768714e-02f, 4.71857525e-02f, -9.11691785e-03f, -3.93053032e-02f, 6.75753132e-02f, -1.29922912e-01f, 1.29174218e-02f, -6.61427900e-02f, 4.62776907e-02f, 9.04777274e-02f,
  2.28798240e-02f, -3.92105756e-03f, 2.80652046e-02f, 3.67088094e-02f, -2.19736695e-02f, 1.44400939e-01f, -1.51769474e-01f, -4.69342992e-02f, 4.79011200e-02f, -3.74241907e-04f,
  1.81327924e-01f, 3.92769240e-02f, 9.82419699e-02f, -6.25967532e-02f, -8.65570977e-02f, 1.40967906e-01f, 7.25031048e-02f, 1.60125673e-01f, -6.00933097e-02f, 3.87645923e-02f,
  9.02636573e-02f, -1.25559837e-01f, -1.12346321e-01f, 9.44847688e-02f, -1.18839033e-01f, 2.60000061e-02f, 1.15601659e-01f, 1.48859873e-01f, -1.51390076e-01f, -1.65570065e-01f,
  -1.21493220e-01f, 1.23564154e-01f, 7.70584941e-02f, 1.76184982e-01f, -1.54465251e-02f, 9.91860405e-02f, -5.87976165e-03f, -1.20410807e-01f, -1.76364258e-01f, 7.20909014e-02f,
  -4.38815542e-02f, 8.40243995e-02f, -1.26790563e-02f, 5.86558739e-03f, -1.76069096e-01f, 9.46210250e-02f, -2.22089306e-01f, 1.18326508e-01f, -1.32121697e-01f, -2.86739264e-02f,
  -8.61997437e-03f, -3.46966721e-02f, 4.14899811e-02f, -1.08122326e-01f, 3.21114510e-02f, 1.13346977e-02f, 2.33543087e-02f, -1.54746941e-03f, 2.22496599e-01f, 1.24054559e-01f,
  5.47310486e-02f, -3.44207473e-02f, -4.94355932e-02f, 1.24721982e-01f, 4.65720594e-02f, -1.02593318e-01f, 1.07674569e-01f, 8.01800936e-02f, 4.87158485e-02f, 3.37318070e-02f,
  5.77632524e-02f, -9.79239121e-02f, -8.44555050e-02f, 4.09760624e-02f, -1.85134664e-01f, 9.00057405e-02f, -1.11895733e-01f, -1.13655165e-01f, -2.26270929e-02f, -2.09384173e-01f,
  -6.38889149e-02f, -1.81765556e-02f, 4.45587980e-03f, 3.11233640e-01f, -2.18991324e-01f, -1.79699957e-01f, -9.72557217e-02f, -4.63660769e-02f, 1.89750105e-01f, -1.47103623e-01f,
  1.62248075e-01f, -8.47869143e-02f, -1.18878763e-02f, -5.28423935e-02f, 1.33816808e-01f, -1.69259831e-01f, -2.01345921e-01f, 2.30552644e-01f, 2.36605898e-01f, 9.99595374e-02f,
  -1.99305177e-01f, -1.02159850e-01f, 6.90972507e-02f, -5.04440255e-02f, -5.85349351e-02f, -8.04798082e-02f, -1.57655794e-02f, -1.13086700e-01f, 7.38688856e-02f, 9.77788642e-02f,
  7.25060585e-04f, -2.04547986e-01f, -1.42696321e-01f, 1.54306531e-01f, 6.84960932e-02f, -6.12501334e-03f, 8.13054095e-04f, 9.24684182e-02f, 8.33436921e-02f, 1.93301961e-01f,
  -1.51686281e-01f, 3.65951620e-02f, -1.82338968e-01f, -6.67082518e-02f, 2.42293179e-02f, 7.39980862e-02f, -1.52867392e-01f, -9.26359650e-03f, -7.31097013e-02f, -9.57940742e-02f,
  -5.87707348e-02f, -6.71993643e-02f, -4.20424230e-02f, -5.42462096e-02f, 3.59813310e-02f, -1.50014669e-01f, -1.89513676e-02f, -1.18537150e-01f, 1.19094156e-01f, -2.04681978e-03f,
  1.21149182e-01f, -1.03784651e-01f, 1.19645640e-01f, -1.51652573e-02f, -1.17763830e-02f, 1.04445748e-01f, 5.88063337e-02f, -1.15677640e-01f, 1.40817910e-01f, -1.24566928e-01f,
  6.25544577e-04f, 1.87813476e-01f, -1.00350559e-01f, 3.92448865e-02f, 5.94841614e-02f, 1.13556467e-01f, -4.55519669e-02f, 1.35913477e-04f, 8.27177316e-02f, 9.55791175e-02f,
  -6.04516715e-02f, -4.18970771e-02f, 8.80075544e-02f, -5.22735976e-02f, 2.39636838e-01f, -6.63195327e-02f, 9.03746858e-02f, 8.58096927e-02f, -6.15248308e-02f, 1.03216739e-02f,
  6.13594754e-03f, 9.60763486e-04f, -1.71314962e-02f, 3.14100869e-02f, -1.77637279e-01f, -2.47365721e-02f, -7.88521916e-02f, -1.62497357e-01f, 1.36010960e-01f, -1.11466400e-01f,
  4.30089869e-02f, -9.65758711e-02f, 1.21656507e-02f, 1.29777148e-01f, -4.32686396e-02f, -1.12505769e-02f, -7.08805621e-02f, -1.33991718e-01f, 6.81890100e-02f, -5.73946275e-02f,
  -6.10989667e-02f, 9.59584862e-02f, 6.25440478e-02f, 6.74972981e-02f, -1.73297394e-02f, -1.19232744e-01f, -9.46249142e-02f, -1.80830210e-02f, 5.25106303e-02f, 6.68895319e-02f,
  1.08919375e-01f, -2.00996529e-02f, 3.21113057e-02f, -1.40115857e-01f, 5.18011414e-02f, -1.28138624e-02f, -2.70375405e-02f, 1.19097039e-01f, -1.20074205e-01f, -7.17698634e-02f,
  -1.29684076e-01f, -9.02707055e-02f, 6.66771382e-02f, 3.79277505e-02f, 4.68260981e-02f, 6.32526875e-02f, -3.38994861e-02f, -7.05505982e-02f, -7.57694468e-02f, 3.41996141e-02f,
  1.10365771e-01f, -1.11510217e-01f, -8.64665806e-02f, 6.02724813e-02f, -2.52493732e-02f, -1.35642692e-01f, 9.90437418e-02f, -6.12757206e-02f, -5.49834557e-02f, 9.83163416e-02f,
  6.34227619e-02f, -8.34945068e-02f, 6.31951727e-03f, -4.13123406e-02f, 7.01485053e-02f, 9.55198258e-02f, -1.23183891e-01f, 4.15141173e-02f, 9.65544507e-02f, -4.78521548e-02f,
  -1.02179222e-01f, 1.35199036e-02f, -7.22965971e-02f, 5.68699539e-02f, 2.64106393e-02f, 6.43365830e-02f, 9.29335877e-02f, -5.25819585e-02f, 1.14336004e-03f, -4.71826270e-02f,
  -8.39346573e-02f, -5.95961958e-02f, -1.43716037e-01f, 1.10134177e-01f, -1.38199463e-01f, -3.19368280e-02f, -3.51209641e-02f, 6.92957863e-02f, -7.82246664e-02f, 1.27138361e-01f,
  -7.88557678e-02f, -4.37500663e-02f, -1.50923114e-02f, 4.69488278e-02f, -4.24431823e-02f, -5.53694554e-02f, 1.11369811e-01f, -1.07240742e-02f, 1.66458443e-01f, 3.30032781e-02f,
  -3.05692814e-02f, -3.25571634e-02f, -7.27003142e-02f, -9.71455052e-02f, 6.05178811e-03f, -1.83352351e-01f, 1.08872518e-01f, 1.83651760e-01f, 7.72057772e-02f, 1.12615757e-01f,
  -1.74291492e-01f, 1.13598526e-01f, -1.38167650e-01f, 1.31157160e-01f, -1.04869567e-01f, -3.00980918e-02f, -1.16525330e-01f, 2.44748488e-01f, -1.07402742e-01f, -1.85901031e-01f,
  -8.71771947e-02f, -9.39170793e-02f, -1.02402084e-01f, 2.34868545e-02f, 1.71956927e-01f, 2.26171896e-01f, 2.87325352e-01f, 7.65547678e-02f, -3.31987627e-02f, -4.45819367e-03f,
  -1.17200486e-01f, -1.64761588e-01f, -5.78866303e-02f, 1.20296188e-01f, 5.18688606e-03f, 6.61126152e-02f, -1.39474915e-02f, 5.93651235e-02f, 1.48483217e-02f, -6.20607138e-02f,
  -8.20359737e-02f, -1.66382462e-01f, -3.86760314e-03f, 4.05951440e-02f, 5.92775047e-02f, 1.03731692e-01f, -2.53777578e-03f, -2.42450461e-02f, 2.58940123e-02f, -5.81312887e-02f,
  -3.48546263e-03f, -7.71299526e-02f, 1.59145854e-02f, -8.10618028e-02f, -6.00937707e-03f, -1.81231089e-02f, 1.25133559e-01f, -8.65045413e-02f, -3.82266901e-02f, 1.03293113e-01f,
  -1.43096060e-01f, -1.78590175e-02f, -6.28651008e-02f, 6.26555905e-02f, 2.64234878e-02f, 4.07337062e-02f, 5.54280588e-03f, -4.54692682e-03f, 9.84153301e-02f, -3.25015094e-03f,
  1.06190555e-01f, 2.11176500e-02f, -6.40180260e-02f, -3.16987559e-02f, 9.11023393e-02f, -8.94922987e-02f, 1.98471949e-01f, -1.61735028e-01f, 1.11410074e-01f, 1.75729573e-01f,
  1.84706226e-01f, -1.68734610e-01f, -6.47956729e-02f, -2.39009503e-03f, -8.58936831e-02f, -1.57607589e-02f, 1.20906092e-01f, 5.62931299e-02f, 1.02905773e-01f, -1.89870950e-02f,
  -1.32070065e-01f, 6.57303110e-02f, -7.01332092e-02f, 6.60392568e-02f, 7.97150359e-02f, 1.22156486e-01f, 3.59053202e-02f, 1.17028959e-01f, -8.31713248e-03f, 5.91627918e-02f,
  9.85112227e-03f, -5.37306778e-02f, -6.69435039e-02f, 1.10687323e-01f, 2.25523505e-02f, 4.93099308e-03f, 1.36937886e-01f, 1.14050992e-01f, 1.09563962e-01f, -8.59643370e-02f,
  1.12648740e-01f, 1.49276316e-01f, -7.48151392e-02f, 1.85669303e-01f, 3.29894684e-02f, 4.93144207e-02f, 1.10737942e-01f, -6.55734912e-02f, -1.05633393e-01f, 6.65201340e-03f,
  -8.14077939e-05f, 1.70811843e-02f, 1.19303979e-01f, 5.94488941e-02f, 1.05449501e-02f, 5.02167270e-02f, -1.24495268e-01f, -1.07650220e-01f, -1.28775194e-01f, -1.58231705e-01f,
  1.35057703e-01f, -4.24551889e-02f, -1.65981397e-01f, 1.37805864e-01f, -1.28952667e-01f, 1.11309877e-02f, 1.71091482e-01f, 7.62121454e-02f, 7.24061802e-02f, -7.23976688e-03f,
  -3.73624749e-02f, -9.20908749e-02f, 9.12202448e-02f, -1.81510225e-02f, -3.72657515e-02f, -2.32851923e-01f, 1.58613667e-01f, -1.93239287e-01f, 3.94897051e-02f, 1.40567422e-01f,
  -6.30538315e-02f, 9.92194563e-02f, -9.97695550e-02f, -1.43704578e-01f, -4.40979749e-02f, -1.36142550e-02f, -4.78906184e-02f, -2.13961080e-02f, -1.11321039e-01f, 5.55164963e-02f,
  1.90726727e-01f, -4.60007563e-02f, 1.00086957e-01f, 1.37235999e-01f, 1.61352437e-02f, 1.42333210e-02f, -1.23889394e-01f, -6.09769411e-02f, 4.34990786e-02f, 3.36967148e-02f
};

// L1_fan_Wp_bar (Shape: 14 x 64)
const int L1_fan_Wp_bar_rows = 14;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  1.48700504e-02f, 1.19468495e-01f, 8.37646052e-02f, 8.08835700e-02f, 1.19360425e-01f, 1.60214111e-01f, 1.06139444e-01f, 1.45437494e-01f, 1.31101646e-02f, 1.44021779e-01f,
  1.25480354e-01f, 1.17877588e-01f, -9.08440202e-02f, -1.25022769e-01f, 1.26145342e-02f, 6.44812211e-02f, 4.07923758e-02f, 1.67801812e-01f, -1.14885047e-02f, 4.43456545e-02f,
  1.46656549e-02f, -6.57561421e-02f, 6.77339919e-03f, -3.58349346e-02f, 1.53978676e-01f, -1.09430112e-01f, -1.41572088e-01f, 2.39944030e-02f, -2.59918664e-02f, 1.34173483e-01f,
  2.24878881e-02f, -1.35480285e-01f, 1.79731455e-02f, 8.51394162e-02f, -1.51986942e-01f, -1.34553701e-01f, 3.75948586e-02f, -1.47210941e-01f, -1.12915330e-01f, -2.82716900e-02f,
  9.77731869e-02f, -1.20594151e-01f, -3.42760421e-02f, -9.04659331e-02f, -2.69640200e-02f, 9.23827663e-02f, 2.11017635e-02f, -1.82214826e-02f, 1.37791276e-01f, 1.41098231e-01f,
  -5.51673919e-02f, -8.94099772e-02f, 1.20397642e-01f, 4.32205433e-03f, 1.59176230e-01f, -5.17619066e-02f, -5.32529727e-02f, 1.56293496e-01f, -9.81503353e-02f, 1.33958785e-02f,
  -8.14839154e-02f, -3.30837397e-03f, 1.35189280e-01f, 6.43221065e-02f, -4.26820591e-02f, 1.49406403e-01f, 1.31413803e-01f, -1.72558408e-02f, -8.60660449e-02f, 3.19804102e-02f,
  1.83408633e-01f, -2.32730389e-01f, 5.46213090e-02f, 1.60322208e-02f, 1.25715435e-01f, -3.31602395e-02f, 5.77849895e-02f, 1.08464569e-01f, -4.17464375e-02f, -1.85460318e-02f,
  -5.22219092e-02f, 1.59909666e-01f, -7.78356045e-02f, 1.09029397e-01f, -8.32407642e-03f, 1.39156774e-01f, 1.89132303e-01f, -2.87817791e-02f, -3.69268060e-02f, 2.31032539e-02f,
  -5.88212013e-02f, -6.12891987e-02f, 1.31598160e-01f, 2.93812044e-02f, -6.12528063e-02f, 3.63363810e-02f, -1.11760244e-01f, -8.23299736e-02f, 5.76711036e-02f, -3.34533267e-02f,
  3.93373184e-02f, 1.45541161e-01f, 1.35523155e-01f, -9.73639265e-02f, -2.98258364e-02f, 6.07986748e-02f, 1.07746990e-02f, -1.36119664e-01f, 1.49502397e-01f, -9.08492040e-03f,
  6.66598082e-02f, 5.69764934e-02f, -8.27201754e-02f, 7.38406032e-02f, 7.78063536e-02f, 1.41531259e-01f, 9.16238055e-02f, -1.08382583e-01f, 1.31977856e-01f, 1.17973715e-01f,
  1.34205922e-01f, -1.78324655e-02f, 1.47846341e-01f, -9.17440280e-02f, 1.97475757e-02f, 7.59475082e-02f, -9.11183432e-02f, -5.11697419e-02f, 6.89064711e-02f, -5.51253371e-02f,
  6.39979765e-02f, 9.35559422e-02f, -2.13480205e-03f, 5.19992299e-02f, 1.15274936e-01f, 1.86229497e-02f, 1.29004166e-01f, 2.08008271e-02f, 4.91045080e-02f, -2.37261932e-02f,
  -4.02481891e-02f, 1.95821404e-01f, 1.61760360e-01f, -6.42188685e-03f, 1.97464496e-01f, 1.15432307e-01f, 1.82859764e-01f, -1.20862722e-01f, 7.12191314e-02f, 1.47958860e-01f,
  -1.31473131e-02f, 1.04489006e-01f, -4.59403992e-02f, -3.08799207e-01f, -2.01655328e-02f, -1.38980553e-01f, -1.61967054e-02f, 1.97832454e-02f, 5.05822934e-02f, -1.88319772e-01f,
  -5.83591163e-02f, -1.15088038e-01f, -3.56739163e-02f, 1.66353937e-02f, 1.04686816e-03f, 8.97966921e-02f, 1.60426870e-01f, 1.11303572e-03f, -1.38693765e-01f, 2.50563603e-02f,
  1.84904426e-01f, 8.15907642e-02f, -1.36402056e-01f, 2.28571981e-01f, 1.57779232e-01f, 8.01653564e-02f, -1.59879569e-02f, -5.45751303e-03f, 2.55394410e-02f, -1.35182351e-01f,
  -6.88298568e-02f, -1.18150204e-01f, 1.62968606e-01f, -5.13536781e-02f, -2.75948606e-02f, 1.03509061e-01f, 1.10361293e-01f, 1.20048463e-01f, 1.48420379e-01f, 1.16103955e-01f,
  -3.08984090e-02f, -1.55526221e-01f, -5.37432246e-02f, -8.37477520e-02f, -5.14864922e-02f, -1.30413651e-01f, -6.27135560e-02f, -1.19311087e-01f, -5.86783327e-02f, -6.43727109e-02f,
  7.72087798e-02f, -5.93527332e-02f, 1.79751478e-02f, -1.28826335e-01f, 7.42763951e-02f, 2.10540965e-02f, 8.88428763e-02f, -1.15499888e-02f, -6.75837696e-02f, -8.16330165e-02f,
  8.59824792e-02f, -9.89868194e-02f, 9.87033322e-02f, -5.02075851e-02f, 7.74063691e-02f, -1.31396040e-01f, 5.85730653e-03f, -6.31147027e-02f, 2.87053594e-03f, 1.85794346e-02f,
  -2.39931922e-02f, 9.42160785e-02f, 4.24770378e-02f, 4.84359264e-02f, 4.71490398e-02f, -2.77850423e-02f, 7.10616037e-02f, 6.86462596e-02f, -1.02463409e-01f, 8.41401070e-02f,
  1.21469393e-01f, 5.88688403e-02f, -1.09825425e-01f, 3.22113233e-03f, 8.35580304e-02f, 2.35727634e-02f, 5.56452991e-03f, 3.77378985e-02f, -1.20598584e-01f, -2.69675646e-02f,
  -1.18979895e-02f, -8.61854553e-02f, -9.67638195e-03f, -2.39145886e-02f, -8.86510834e-02f, -1.52190877e-02f, 9.69661549e-02f, 1.08226836e-01f, -3.98847349e-02f, -8.05374384e-02f,
  -1.19263463e-01f, 1.23118252e-01f, -3.60898487e-02f, -6.52127117e-02f, -5.11679426e-02f, 5.73005565e-02f, -5.34631088e-02f, 1.26535883e-02f, 1.02740293e-02f, -3.46069299e-02f,
  1.48405999e-01f, 1.07262641e-01f, 2.71172579e-02f, 7.28024170e-02f, 7.64623210e-02f, -3.10221668e-02f, -9.50877648e-03f, 1.84577964e-02f, 1.29127607e-01f, 4.74456102e-02f,
  -2.79032607e-02f, -5.65058552e-02f, 1.11120775e-01f, 8.12133483e-04f, 1.46190181e-01f, -2.32984666e-02f, -3.14478092e-02f, -4.41300981e-02f, 9.31635424e-02f, 1.64636865e-01f,
  1.37018219e-01f, 1.47278771e-01f, 6.49972633e-02f, -4.75647151e-02f, 1.42938361e-01f, -6.67655095e-02f, -2.07864703e-03f, -7.86822215e-02f, -1.43219769e-01f, 1.28752589e-01f,
  3.32512669e-02f, -7.18533918e-02f, 1.93171743e-02f, 1.08535767e-01f, 2.52397936e-02f, 1.41359076e-01f, 9.66196805e-02f, -3.71431224e-02f, 4.39424142e-02f, -5.44073842e-02f,
  7.23382533e-02f, -1.14251534e-02f, 5.90977855e-02f, 9.86372754e-02f, -4.85557839e-02f, -1.73833609e-01f, -2.58907359e-02f, -7.51886144e-02f, 8.70471150e-02f, -7.45664537e-02f,
  9.36741009e-02f, 1.72878996e-01f, -1.06190681e-01f, 7.79370591e-03f, 9.53013450e-02f, 1.02598161e-01f, -7.24120364e-02f, -3.91360745e-02f, -1.32206589e-01f, 4.56839427e-02f,
  5.38469478e-02f, -3.60736027e-02f, 1.28134906e-01f, -1.35532496e-02f, -1.16887972e-01f, -3.15850899e-02f, -5.63737564e-02f, 7.13742152e-02f, 7.05990419e-02f, -7.94236641e-03f,
  -1.31053263e-02f, 3.35207023e-02f, -2.58159526e-02f, -1.56747594e-01f, 4.12011519e-02f, -6.53606355e-02f, 3.78983170e-02f, -3.80372219e-02f, 8.28571711e-03f, -5.68265617e-02f,
  6.41193287e-03f, 1.38777524e-01f, 1.62472561e-01f, 7.85106644e-02f, 1.33580402e-01f, 2.16552809e-01f, 1.42454002e-02f, 2.92454269e-02f, 8.40533152e-02f, 1.58153817e-01f,
  -3.80071439e-02f, -9.53520760e-02f, 3.16824056e-02f, 5.19175492e-02f, -3.24389338e-02f, -7.09574893e-02f, 8.62983540e-02f, -1.05874658e-01f, 1.29172757e-01f, 4.54329625e-02f,
  7.81031623e-02f, -1.53103560e-01f, -2.85830703e-02f, -1.68108195e-01f, 7.70372376e-02f, -7.46670272e-03f, 9.74335745e-02f, -3.16152610e-02f, 1.51825875e-01f, 1.18750192e-01f,
  3.77301127e-02f, 1.71517057e-03f, 9.15338174e-02f, 6.81760162e-02f, 1.44991666e-01f, 6.45133406e-02f, 1.35969609e-01f, -2.49066437e-03f, -3.58106755e-02f, -8.80718455e-02f,
  5.11002131e-02f, 7.19590038e-02f, -7.18607605e-02f, 1.44170329e-01f, 4.38904613e-02f, 1.52044564e-01f, -1.75119974e-02f, 2.86332201e-02f, 4.46285754e-02f, 1.36323243e-01f,
  -6.41189218e-02f, 1.15436256e-01f, 1.37167767e-01f, 7.00397789e-02f, 2.45870035e-02f, 6.33209646e-02f, 1.49529800e-01f, -7.25353286e-02f, -7.61895329e-02f, -6.30990788e-02f,
  7.01146498e-02f, -3.88916843e-02f, -7.97228739e-02f, -2.48845145e-02f, -3.48191685e-03f, 9.31351408e-02f, 1.02008633e-01f, 1.44580435e-02f, 8.91679749e-02f, 2.37947166e-01f,
  -2.52116285e-02f, 6.20514480e-03f, 1.52624711e-01f, 5.35633825e-02f, 9.07961652e-02f, -9.55504365e-03f, -1.03847407e-01f, -2.38765543e-03f, 8.50544348e-02f, -1.39287934e-01f,
  8.14526603e-02f, 3.11450642e-02f, -4.23782654e-02f, 1.51098855e-02f, 1.89437985e-01f, -5.56956865e-02f, -1.84549958e-01f, 3.44700627e-02f, 1.60729256e-03f, -1.11521132e-01f,
  -1.17904924e-01f, -1.18530624e-01f, 1.12055220e-01f, -4.17859759e-03f, 6.09437972e-02f, 1.12023251e-02f, 2.17101071e-02f, -4.05970290e-02f, 2.85333605e-03f, -7.31115267e-02f,
  1.02987260e-01f, -6.70370162e-02f, 6.16478473e-02f, 2.79072281e-02f, 1.11468635e-01f, 4.04329859e-02f, 1.37717083e-01f, -5.02375104e-02f, -5.97932516e-03f, 3.90531830e-02f,
  -4.51915115e-02f, 1.22567944e-01f, -9.66703817e-02f, 1.39869228e-01f, 1.48191899e-01f, -1.68401986e-01f, 1.25204951e-01f, -1.08920150e-01f, -5.14288666e-03f, 1.13730811e-01f,
  -3.59228775e-02f, 1.06312133e-01f, 2.34837346e-02f, -1.03391886e-01f, -3.27276289e-02f, -5.02389036e-02f, -2.03957576e-02f, 7.27286711e-02f, -7.17801452e-02f, 1.00253329e-01f,
  1.53196886e-01f, 6.72655255e-02f, 8.02113265e-02f, -1.33259058e-01f, -1.77229661e-02f, 8.72081295e-02f, -5.48021821e-03f, -9.37265977e-02f, -1.17526256e-01f, -2.12115422e-02f,
  -7.27230981e-02f, -1.34981707e-01f, 3.16540934e-02f, 6.36832938e-02f, -1.02372065e-01f, 5.50096072e-02f, -7.78987035e-02f, -4.26590554e-02f, -1.16746373e-01f, 1.40948147e-01f,
  -5.44614270e-02f, 1.41147133e-02f, -1.48412166e-02f, -6.57517686e-02f, 8.03236961e-02f, 2.12296639e-02f, -7.87155256e-02f, 1.61251694e-01f, 5.27211465e-02f, -2.73121577e-02f,
  2.18741223e-01f, -9.84203350e-03f, 5.37802950e-02f, -1.71114877e-02f, -9.73257348e-02f, -8.26542303e-02f, 1.60145879e-01f, 7.17630563e-03f, -8.73586461e-02f, -6.13964954e-03f,
  4.18635346e-02f, 9.12023485e-02f, -4.07510586e-02f, -2.95505207e-02f, -7.67948339e-03f, 1.43573796e-02f, -5.36546437e-03f, 7.18591064e-02f, 8.33766237e-02f, -9.26048320e-04f,
  -1.01222761e-01f, -1.54646169e-02f, 3.16451937e-02f, -1.23834610e-01f, -1.06926270e-01f, 1.28838792e-01f, 9.09183547e-03f, -1.15177445e-02f, 7.13156462e-02f, -1.04840524e-01f,
  -6.62185252e-02f, 1.06633017e-02f, 1.01577369e-02f, -1.15615636e-01f, -1.52566694e-02f, 8.38262960e-02f, 6.46423772e-02f, -1.37682389e-02f, -3.57520767e-02f, -6.13078848e-02f,
  -6.15857318e-02f, 2.79231686e-02f, -1.11888945e-01f, -1.20803587e-01f, 7.57560506e-02f, 8.31455588e-02f, 4.44132313e-02f, -8.55764002e-02f, 3.09571680e-02f, 7.45785236e-02f,
  -1.24425672e-01f, -8.76948088e-02f, -3.01804654e-02f, 8.82997215e-02f, 1.01273976e-01f, 8.84550810e-02f, 5.36050973e-03f, -4.26469631e-02f, 7.47912973e-02f, 1.19006984e-01f,
  -1.67594273e-02f, 3.96216251e-02f, -9.68807861e-02f, -1.24489062e-01f, 6.46292642e-02f, 6.29460663e-02f, -1.70186404e-02f, 8.11660886e-02f, -5.73787699e-03f, 8.47366825e-02f,
  -9.80069339e-02f, -4.89911251e-02f, -9.82180461e-02f, 8.39667916e-02f, 2.95728724e-02f, 5.90505339e-02f, 1.73323810e-01f, 6.29938915e-02f, 3.64598865e-03f, 5.05061494e-03f,
  1.24908283e-01f, -3.62236798e-02f, 5.59532456e-02f, -9.20941215e-03f, -8.70141536e-02f, -7.28053525e-02f, 1.35661513e-01f, 1.03264853e-01f, 5.56858554e-02f, 1.25642210e-01f,
  1.97014451e-01f, 1.18753813e-01f, 8.64257291e-02f, 7.78872939e-03f, 7.06331506e-02f, 5.65291457e-02f, -1.34533808e-01f, -2.93188561e-02f, -2.71008015e-02f, -1.16334245e-01f,
  1.53741464e-01f, -1.37888148e-01f, 5.63161261e-02f, 4.31989692e-02f, -7.57739618e-02f, 1.64896041e-01f, -1.01371050e-01f, -5.27271219e-02f, -7.32042193e-02f, -7.64446259e-02f,
  -8.99534579e-03f, -6.46974221e-02f, 6.97893510e-03f, 1.53729349e-01f, -2.22767275e-02f, -4.81787557e-03f, -2.59691160e-02f, -4.42369878e-02f, 1.25437185e-01f, -8.04522261e-02f,
  -2.08872750e-01f, 2.08944440e-01f, 2.17859596e-01f, 9.84125063e-02f, -3.80579121e-02f, 7.20232800e-02f, -5.04886284e-02f, -1.40250877e-01f, -1.19366825e-01f, 5.19325361e-02f,
  2.18482643e-01f, -1.14758573e-01f, 1.52872354e-02f, 2.55987912e-01f, -1.39058515e-01f, 3.21217515e-02f, -6.70358613e-02f, 4.10343595e-02f, 7.70915151e-02f, 7.10204318e-02f,
  -6.07092939e-02f, -4.53869179e-02f, -4.17974070e-02f, -5.47213666e-02f, 9.67035815e-02f, 9.95507464e-02f, -9.58786905e-03f, 1.81095466e-01f, 1.45955950e-01f, -5.83800450e-02f,
  -6.60573551e-03f, 1.14051662e-01f, 4.71418016e-02f, -5.62286982e-03f, 1.15348622e-02f, 8.91764276e-03f, 1.50013566e-01f, 1.38065517e-01f, 5.54224588e-02f, -3.76302376e-02f,
  -4.89761271e-02f, -5.16601093e-02f, 9.18499380e-02f, -7.50121996e-02f, 9.99494642e-02f, -6.39626980e-02f, 8.23537260e-02f, -6.11677319e-02f, 7.93524459e-03f, -1.74468243e-03f,
  -1.34632990e-01f, -5.55122681e-02f, -1.23336324e-02f, -6.61814362e-02f, -4.72689047e-03f, 1.34545416e-01f, -1.26857832e-01f, -9.26132500e-02f, 3.27365249e-02f, 1.21335953e-01f,
  4.47445922e-02f, -7.83437714e-02f, 1.18473426e-01f, 9.24982652e-02f, 5.61119057e-02f, -8.75813328e-03f, -1.14314705e-01f, 1.48485778e-02f, -1.16042905e-01f, -7.06878155e-02f,
  4.23652083e-02f, -1.73445717e-02f, -7.28871003e-02f, 1.14782564e-01f, -1.35360405e-01f, 5.75691126e-02f, 4.64862026e-02f, -8.92908052e-02f, 4.39244248e-02f, 6.50019944e-02f,
  -4.35759164e-02f, -2.68748719e-02f, 5.66562004e-02f, -7.53894970e-02f, 7.37072900e-02f, 9.96436849e-02f, 2.41752677e-02f, -5.52251786e-02f, 6.96827099e-02f, 5.48261125e-03f,
  1.11097865e-01f, -2.69702971e-02f, 1.06510021e-01f, 7.69722760e-02f, 5.92493042e-02f, -7.49570131e-02f, 1.07447093e-03f, -7.35279694e-02f, -1.03482649e-01f, -1.88025031e-02f,
  -1.08696287e-02f, -8.23260322e-02f, -6.53645694e-02f, -4.03401852e-02f, 1.58631682e-01f, -7.07748085e-02f, -1.97375994e-02f, -4.03627232e-02f, -5.54192401e-02f, 1.88511182e-02f,
  1.23512395e-01f, 6.64008409e-02f, 1.03012152e-01f, -1.41768515e-01f, 3.31202056e-03f, 1.17765307e-01f, -7.26672774e-03f, -3.87072973e-02f, 6.54072762e-02f, 6.64030621e-03f,
  -1.04634054e-01f, 9.75807086e-02f, 3.09829265e-02f, 9.29516181e-02f, -7.11891502e-02f, 4.76129279e-02f, 1.50176167e-01f, -8.17928687e-02f, 1.30382061e-01f, -1.18195519e-01f,
  3.71787734e-02f, 1.67073254e-02f, -1.43130738e-02f, -1.01264395e-01f, 1.20935790e-01f, -4.79882061e-02f, -4.39645089e-02f, 5.41261733e-02f, 3.24881449e-02f, 4.78815436e-02f,
  4.69144881e-02f, 5.66018298e-02f, 1.22109815e-01f, 2.25100014e-02f, -4.91487980e-02f, -5.29229157e-02f, -9.60720517e-03f, -6.73024207e-02f, -1.14856243e-01f, -5.61095327e-02f,
  -5.17347492e-02f, 5.74822761e-02f, -2.27651782e-02f, -7.51626492e-02f, -9.80795398e-02f, 2.74665025e-03f, -1.19320303e-01f, 9.95352119e-02f, -3.81620415e-02f, -1.27000496e-01f,
  9.63686779e-02f, -2.87452172e-02f, -8.65733027e-02f, -1.15657803e-02f, 1.71177480e-02f, -8.71753767e-02f, -2.83933785e-02f, -5.43402843e-02f, -9.72594842e-02f, 5.58882803e-02f,
  -3.88169885e-02f, -9.55406427e-02f, -1.06895849e-01f, 2.72357720e-03f, 1.11471094e-01f, 1.00414999e-01f, -7.20959529e-02f, 9.01942104e-02f, -7.95904845e-02f, -7.27986991e-02f,
  -3.91102359e-02f, -1.01143949e-01f, -8.72644931e-02f, 1.13448344e-01f, -1.08247306e-02f, 9.48650837e-02f, 3.01048905e-02f, 2.56933160e-02f, 4.38172417e-03f, 1.36110084e-02f,
  -2.57073995e-02f, 1.18592389e-01f, -1.70708506e-03f, -5.14419153e-02f, 4.05697636e-02f, -7.90396929e-02f, 9.49624106e-02f, -6.81449249e-02f, 2.61987224e-02f, 9.51875299e-02f,
  -1.18915580e-01f, 1.51956771e-02f, -7.28403181e-02f, 1.04478091e-01f, -2.78104423e-03f, 6.19426742e-02f, 3.25952433e-02f, -6.80470257e-04f, -4.50955443e-02f, -4.42508459e-02f,
  8.45347643e-02f, 3.32044438e-02f, -7.85350651e-02f, -1.50085818e-02f, 6.73717409e-02f, -7.19576403e-02f, 7.15718940e-02f, -1.96896344e-02f, -5.21841161e-02f, -1.00282930e-01f,
  -5.00316434e-02f, 5.67566827e-02f, 7.50497356e-02f, 1.27854764e-01f, -2.74723000e-03f, 5.71180582e-02f, 5.82280941e-02f, -2.72844117e-02f, -2.72559724e-03f, -7.96314254e-02f,
  -1.06965691e-01f, -5.15224561e-02f, -1.05548576e-01f, 6.90138936e-02f, -7.52435997e-02f, -3.35778221e-02f, -5.54512441e-02f, 8.81286636e-02f, 9.84970406e-02f, 4.98164259e-02f,
  -3.34113203e-02f, 8.48806798e-02f, -2.12403443e-02f, -6.87606633e-02f, 6.90936521e-02f, -3.64614949e-02f, 3.91613394e-02f, -6.27055839e-02f, 4.78340313e-02f, -5.51855974e-02f,
  3.18911299e-02f, 2.63166800e-02f, -3.36021222e-02f, 2.76698098e-02f, 8.87510329e-02f, -7.71228820e-02f, 1.13900945e-01f, -1.20711431e-01f, -1.20391492e-02f, 8.14396515e-02f,
  4.66952436e-02f, -8.19747895e-02f, -9.58822221e-02f, -8.16500038e-02f, -3.82540450e-02f, -1.24745853e-01f, -5.52215241e-02f, 1.10083558e-01f, 6.54378533e-03f, -2.91039329e-02f,
  -3.27787101e-02f, 7.02475831e-02f, -7.38549605e-02f, -8.71260986e-02f, -1.22367762e-01f, 4.37512286e-02f
};

// L1_fan_Bp_bar (Shape: 1 x 14)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 14;
const float L1_fan_Bp_bar_data[] = {
  -6.95051625e-02f, 1.22580148e-01f, 1.14103250e-01f, -1.06092334e-01f, 7.50819512e-04f, 1.28110036e-01f, 1.86235402e-02f, -7.23760203e-02f, -8.05172324e-02f, 1.01338707e-01f,
  5.12527563e-02f, -1.56294834e-02f, -5.57302646e-02f, 1.94339845e-02f
};

// L2_fan_Wp (Shape: 25 x 64)
const int L2_fan_Wp_rows = 25;
const int L2_fan_Wp_cols = 64;
const float L2_fan_Wp_data[] = {
  -1.35794640e-01f, -5.27983233e-02f, 3.06792706e-02f, 1.07523777e-01f, 1.07494570e-01f, -2.49813683e-02f, 6.27195463e-04f, 5.66495508e-02f, -1.38838977e-01f, -6.12749495e-02f,
  4.72789444e-02f, 5.07176146e-02f, 1.69367254e-01f, 8.84664729e-02f, -7.13963136e-02f, 1.17765352e-01f, 5.00656478e-02f, -6.68954477e-02f, 2.30663214e-02f, 2.14852259e-01f,
  -8.04790556e-02f, -7.60396197e-02f, 5.87829016e-02f, 9.54374671e-02f, -6.17686776e-04f, 7.33295903e-02f, 1.29224092e-01f, -2.74676859e-01f, -2.82207578e-01f, -1.86906710e-01f,
  -1.77159477e-02f, 3.99092734e-02f, 1.37258703e-02f, -3.03351790e-01f, 8.88341980e-04f, 6.34769127e-02f, 1.10330090e-01f, -1.39956430e-01f, -1.24050371e-01f, -6.05000630e-02f,
  -7.08168596e-02f, 1.06606424e-01f, 2.71934569e-01f, -2.38961428e-02f, 7.02792555e-02f, -2.91533750e-02f, -9.15719047e-02f, -1.34123743e-01f, 4.27057743e-02f, -6.25699311e-02f,
  2.67873164e-02f, 3.52698490e-02f, 1.94729760e-01f, -6.72985688e-02f, -1.11600056e-01f, -8.58991295e-02f, -1.90990955e-01f, 1.99143156e-01f, 9.94221121e-03f, 1.74821988e-01f,
  8.49670097e-02f, -6.58978568e-03f, -2.75173923e-03f, 9.19987187e-02f, -1.11188151e-01f, -6.17734753e-02f, 1.63572595e-01f, 9.62842852e-02f, 1.22935474e-01f, 9.53884516e-03f,
  -9.85980555e-02f, -9.87246782e-02f, 4.52703908e-02f, -1.03980988e-01f, 1.18400797e-01f, 4.96374443e-02f, 9.59076881e-02f, 7.26778209e-02f, 9.30443928e-02f, 1.23099282e-01f,
  1.23365603e-01f, 2.39663734e-03f, -1.06712401e-01f, 5.15320599e-02f, -1.15888245e-01f, -6.61638156e-02f, 5.66650108e-02f, -8.07776600e-02f, -6.23824559e-02f, -5.97689152e-02f,
  3.00993677e-02f, -1.67203560e-01f, -1.48696005e-01f, -1.11129604e-01f, -1.95311382e-01f, 6.39748480e-03f, -1.42966166e-01f, -5.54341264e-02f, 1.96830720e-01f, -1.38320804e-01f,
  4.40739021e-02f, 1.59875199e-01f, 1.43952399e-01f, 1.56084761e-01f, -7.77361840e-02f, 7.87562355e-02f, 1.57692656e-01f, 9.98712424e-03f, 3.04242969e-02f, -2.33170320e-03f,
  1.74972892e-01f, 1.33941382e-01f, -1.59523994e-01f, -1.12016134e-01f, 8.48623142e-02f, -1.28381029e-01f, 1.46089181e-01f, 8.72549191e-02f, 1.04960643e-01f, -1.34835973e-01f,
  -8.42613652e-02f, 5.15822433e-02f, 6.91727102e-02f, 5.51922172e-02f, -8.98940414e-02f, 4.36866768e-02f, -2.47536157e-03f, -1.25613272e-01f, -1.05610630e-02f, -6.99059165e-04f,
  -6.42156377e-02f, 1.93420406e-02f, -1.24170706e-01f, 4.27016951e-02f, -4.25090566e-02f, -1.30992100e-01f, 1.19421981e-01f, 1.03388578e-01f, 1.42039239e-01f, -7.66157508e-02f,
  1.15942517e-02f, 1.06253894e-02f, 1.72708016e-02f, 5.52380159e-02f, 2.20669881e-02f, -4.48603854e-02f, -1.42597575e-02f, 1.45258665e-01f, -1.26198903e-01f, -7.16655850e-02f,
  -3.25030163e-02f, -7.63093382e-02f, -6.01626635e-02f, 1.52626187e-02f, -4.05449569e-02f, -1.07424565e-01f, -7.35665485e-02f, 1.28142210e-02f, 1.28380269e-01f, 7.64268190e-02f,
  -6.23922125e-02f, 3.85707524e-03f, 8.88826475e-02f, -1.63223818e-01f, 9.23730955e-02f, 7.42556229e-02f, -1.45431116e-01f, 1.29952148e-01f, 1.11154385e-01f, 2.49450803e-02f,
  -1.76622346e-01f, 1.23457685e-01f, -6.82075098e-02f, -8.54307190e-02f, 1.32619545e-01f, 1.74781218e-01f, -5.33337519e-02f, -4.93651964e-02f, 1.17153712e-01f, -2.75784452e-02f,
  5.40518090e-02f, -1.15043253e-01f, 5.71164452e-02f, -7.38625899e-02f, 1.15421481e-01f, 7.74946511e-02f, -5.46572097e-02f, -3.71913314e-02f, -7.11221397e-02f, 9.08236876e-02f,
  -1.01525247e-01f, -9.47013348e-02f, 1.60409417e-02f, 8.71550143e-02f, -9.85862315e-02f, -1.89986848e-03f, -9.80722532e-02f, -6.24617487e-02f, -1.49091454e-02f, 4.11729291e-02f,
  -2.64025968e-03f, -2.25972645e-02f, -9.10522193e-02f, 1.15515642e-01f, -3.76461670e-02f, -9.44299698e-02f, 2.93337591e-02f, -6.91321045e-02f, 1.43055424e-01f, -2.52441429e-02f,
  -1.30151570e-01f, -6.76499829e-02f, 3.24728116e-02f, -1.40586877e-02f, 1.29420236e-01f, -8.81759301e-02f, 9.82163772e-02f, 6.67919265e-03f, 1.51951879e-01f, -1.56760097e-01f,
  8.32773373e-02f, -1.07938059e-01f, 1.02074802e-01f, 1.54633194e-01f, -2.38841195e-02f, -6.48415163e-02f, -4.46180515e-02f, -1.72401488e-01f, 1.44123733e-01f, -1.06549084e-01f,
  1.07395090e-01f, 1.70193419e-01f, 2.85872612e-02f, 5.54566793e-02f, -1.53091788e-01f, 8.87940172e-03f, -2.19056487e-01f, -7.52544962e-03f, 6.09007813e-02f, 6.99785575e-02f,
  -9.94580016e-02f, 5.54880407e-03f, -3.33472826e-02f, -5.34819113e-03f, 7.38934055e-02f, -1.09822685e-02f, 1.44898191e-01f, -1.06230065e-01f, -7.44016096e-02f, -6.99245036e-02f,
  3.32017466e-02f, -3.67320329e-02f, -9.64200124e-02f, 1.16652824e-01f, -4.00742665e-02f, -1.10485479e-01f, -6.60537109e-02f, 1.71688482e-01f, -1.58665016e-01f, 1.77014843e-02f,
  -1.03505000e-01f, 1.02222465e-01f, 8.69921148e-02f, -1.28766760e-01f, -3.02164927e-02f, -9.81484577e-02f, 5.78373782e-02f, -4.97399159e-02f, -1.13575645e-01f, 1.47897586e-01f,
  -2.91195195e-02f, 6.09155931e-03f, 9.09695849e-02f, 4.08756398e-02f, 9.56616551e-02f, 1.52044892e-01f, -1.51394412e-01f, -8.52487516e-03f, -3.19160754e-03f, 5.23760989e-02f,
  7.82146156e-02f, 5.70387840e-02f, 2.02507246e-02f, -1.38097286e-01f, 1.31448552e-01f, 3.98156270e-02f, 3.69858965e-02f, 7.89624080e-02f, 4.91638388e-03f, -1.41649857e-01f,
  -9.97637287e-02f, -8.98451135e-02f, 3.63482861e-03f, 7.01657310e-02f, -4.57325093e-02f, 8.61176550e-02f, 1.41362801e-01f, -7.52321929e-02f, -1.20283458e-02f, -1.43475935e-01f,
  6.41540736e-02f, 7.71170110e-02f, -7.54405111e-02f, 1.14966203e-02f, 1.32811606e-01f, -1.41219467e-01f, 1.27507702e-01f, 1.34659946e-01f, 4.66028452e-02f, -8.50412175e-02f,
  1.72640346e-02f, -6.76342621e-02f, -4.93523553e-02f, 1.04907043e-01f, 5.06701879e-02f, 2.29174513e-02f, -2.69588251e-02f, 6.76082522e-02f, -3.40421572e-02f, 8.43131244e-02f,
  7.50928447e-02f, 9.32719335e-02f, -1.01384103e-01f, -1.36655658e-01f, 7.61267245e-02f, -1.09781260e-02f, -5.02952375e-03f, 1.08044624e-01f, -1.31522402e-01f, 8.05554390e-02f,
  6.92017153e-02f, -6.71446323e-03f, -7.62502477e-02f, 1.04217067e-01f, -5.61350584e-02f, 4.61587124e-02f, 3.83512191e-02f, -1.17061146e-01f, 1.00183904e-01f, -3.71649973e-02f,
  -1.15978003e-01f, -5.86226918e-02f, 6.74399287e-02f, -3.64764631e-02f, -5.50983325e-02f, -3.57288979e-02f, 5.65222129e-02f, -1.56988859e-01f, 3.87593806e-02f, -1.45385966e-01f,
  6.31406009e-02f, -1.16492830e-01f, 2.03471482e-01f, 2.40773819e-02f, -5.28854653e-02f, -2.53645014e-02f, -6.94801435e-02f, -1.63628295e-01f, -1.71873257e-01f, 1.03666365e-01f,
  -2.33307965e-02f, 1.38193727e-01f, 3.78359817e-02f, 1.32709006e-02f, 8.17889944e-02f, 1.59077287e-01f, 6.90922961e-02f, 5.09378910e-02f, 1.35203153e-01f, -6.77973256e-02f,
  1.93578452e-02f, 5.87746389e-02f, 1.00007527e-01f, 8.29469487e-02f, -3.29879150e-02f, -3.42823714e-02f, 6.53498173e-02f, 1.40872851e-01f, 1.14607871e-01f, 1.14793286e-01f,
  -8.64000544e-02f, 1.25925377e-01f, 6.30560378e-03f, 4.66244221e-02f, 9.39174220e-02f, 2.16754436e-01f, 5.31745218e-02f, 2.95727663e-02f, 2.28770599e-01f, 3.23030632e-03f,
  -6.49896711e-02f, 8.04186389e-02f, -1.36181772e-01f, -1.13517962e-01f, 2.33100336e-02f, 5.49699832e-03f, 1.87310994e-01f, 1.14859454e-01f, -9.37726870e-02f, -6.83566481e-02f,
  -5.61514571e-02f, -1.78414490e-02f, -4.70676385e-02f, -1.86943546e-01f, 1.33095339e-01f, -3.20937764e-03f, 1.15397811e-01f, 2.42088977e-02f, -1.79075710e-02f, 1.03025943e-01f,
  2.75136739e-01f, -2.18826845e-01f, -2.42500603e-01f, -1.59704313e-01f, -1.87347904e-02f, 1.38821909e-02f, 1.66812733e-01f, -1.41655236e-01f, -1.19984739e-01f, -1.58548892e-01f,
  4.86456193e-02f, -1.61877945e-01f, -1.14634462e-01f, -5.44801615e-02f, -9.52820182e-02f, 1.70681342e-01f, 8.43242183e-02f, 1.63642630e-01f, -6.24461509e-02f, 1.98639780e-01f,
  -1.41244322e-01f, 1.12901874e-01f, -7.39714578e-02f, -1.97328761e-01f, -2.36628458e-01f, 1.46285966e-01f, -1.12635590e-01f, -1.03213944e-01f, 8.50409269e-02f, -1.64720222e-01f,
  -1.34263501e-01f, 1.26823142e-01f, 1.05022982e-01f, -1.80544794e-01f, -5.26293218e-02f, 5.11118285e-02f, 5.14366962e-02f, 6.78315759e-02f, 9.00898799e-02f, -2.16061056e-01f,
  2.70361956e-02f, 5.63150160e-02f, -8.92918184e-03f, 1.95726454e-02f, 3.36571261e-02f, -2.96054650e-02f, 9.86965746e-02f, -2.56818123e-02f, 2.44594831e-02f, -1.94100648e-01f,
  -1.15163647e-01f, -5.78195555e-03f, 6.84748888e-02f, 1.07044838e-01f, -1.25344083e-01f, 1.89590845e-02f, 1.25029072e-01f, 5.67858331e-02f, -1.39616162e-01f, -2.57354677e-02f,
  -1.73890799e-01f, -1.42436311e-01f, -2.77356915e-02f, -8.75050798e-02f, -1.73726976e-01f, -1.03590162e-02f, -4.97325100e-02f, -1.56514645e-01f, -1.59413442e-01f, 1.67089906e-02f,
  1.32351860e-01f, -1.45173863e-01f, 3.79029587e-02f, 1.50588825e-01f, -1.54015660e-01f, 1.61494881e-01f, 1.17705151e-01f, 3.10808681e-02f, -8.77956674e-02f, -3.09261847e-02f,
  2.04073623e-01f, 1.03310123e-01f, 1.03450224e-01f, 4.25860547e-02f, 4.14519832e-02f, -2.27018252e-01f, -1.43151348e-02f, 1.51743069e-01f, 1.05985096e-02f, -1.60510689e-01f,
  1.97679192e-01f, -7.32104555e-02f, -2.68912427e-02f, -8.51395652e-02f, -1.18477978e-01f, -1.15189567e-01f, -1.30469371e-02f, 1.09856658e-01f, 9.24517214e-02f, -8.38751942e-02f,
  5.73862605e-02f, -6.26279861e-02f, -7.22006708e-02f, -1.15150891e-01f, 1.21329784e-01f, -7.17176497e-02f, -6.63572624e-02f, -1.16985850e-01f, -1.45369604e-01f, -1.06313676e-01f,
  1.30277872e-01f, -1.12892680e-01f, -9.63780582e-02f, -9.39939618e-02f, 2.76782792e-02f, -6.79468289e-02f, -3.98785509e-02f, -1.10924840e-02f, -1.42191201e-01f, -5.08857742e-02f,
  -9.51585397e-02f, 2.90879700e-02f, -1.22861855e-01f, -4.27917466e-02f, 1.27649575e-01f, -1.23259783e-01f, -2.17443593e-02f, -3.12786438e-02f, -2.47806385e-01f, 1.16686702e-01f,
  -1.15230484e-02f, -1.68427322e-02f, 9.03068632e-02f, -1.26293590e-02f, -1.41763672e-01f, 7.37061724e-02f, 7.01921955e-02f, 9.07899439e-02f, -4.62054685e-02f, 1.89648330e-01f,
  1.55816171e-02f, 4.61023524e-02f, -7.51954019e-02f, -2.80225128e-02f, 3.49972732e-02f, 2.22153198e-02f, 1.71723828e-01f, -1.45669505e-01f, 2.30151974e-02f, -4.38276790e-02f,
  5.61940344e-03f, -4.41184780e-03f, -7.22264722e-02f, -7.03402609e-02f, 1.13767825e-01f, 4.94083529e-03f, -5.34081599e-04f, -5.61561249e-02f, 3.62368785e-02f, -1.41634330e-01f,
  1.62840337e-02f, -3.96193862e-02f, 1.32518128e-01f, -4.70466614e-02f, 6.03315746e-03f, 4.79912795e-02f, 5.10971285e-02f, 8.45701899e-04f, 7.12474948e-03f, 1.07092835e-01f,
  5.07517643e-02f, 7.08038453e-03f, 1.02393381e-01f, -3.24961171e-02f, -4.32516858e-02f, -5.11698574e-02f, 4.70527671e-02f, 1.45188689e-01f, 2.04737857e-02f, 6.51592538e-02f,
  7.99845532e-02f, 1.48693994e-02f, -5.52882738e-02f, 1.42679363e-01f, 8.78602546e-03f, -9.42924246e-02f, 7.76811084e-03f, 1.11076325e-01f, 1.61607295e-01f, 4.70816679e-02f,
  -1.84357800e-02f, 9.27493125e-02f, 1.20997047e-02f, -1.03669092e-01f, -1.71965584e-01f, 5.03785796e-02f, -5.53354435e-02f, -3.43080126e-02f, 3.22422236e-02f, 1.11947253e-01f,
  1.76570147e-01f, -5.16084135e-02f, 4.35110964e-02f, -1.58483479e-02f, 1.51273951e-01f, 1.66039392e-01f, -1.00738406e-01f, 1.61208779e-01f, -9.40413624e-02f, 1.58491284e-01f,
  -1.41862705e-01f, 1.75202802e-01f, -6.38251007e-02f, 2.06443384e-01f, -1.34449080e-01f, 4.60569263e-02f, -1.34884685e-01f, -1.44685686e-01f, -4.97094244e-02f, 8.52688178e-02f,
  1.11331597e-01f, 6.38805106e-02f, -9.43152755e-02f, 8.04404020e-02f, 2.47226097e-02f, -5.43461852e-02f, 1.53964758e-01f, 1.15380637e-01f, -5.99568747e-02f, -6.81304485e-02f,
  -2.65932176e-02f, 6.21585781e-03f, 1.21392503e-01f, 4.11532857e-02f, 5.53828105e-02f, 1.00018680e-01f, -8.72580707e-03f, 3.49896960e-02f, 1.29053906e-01f, -2.17620842e-02f,
  -6.59056306e-02f, 7.53011033e-02f, 1.10707721e-02f, -4.97483369e-03f, 5.38827069e-02f, 4.00578231e-02f, 1.67966679e-01f, 1.43982500e-01f, 9.34624448e-02f, -5.98018318e-02f,
  3.80619280e-02f, 9.43082646e-02f, -3.04899272e-02f, 1.65075630e-01f, 9.80952308e-02f, -1.29657090e-01f, -1.85333624e-01f, 2.29682043e-01f, 8.31732973e-02f, 1.30144551e-01f,
  -2.65316591e-02f, -5.59954792e-02f, 4.04125750e-02f, 1.02952063e-01f, -2.90566813e-02f, 1.07584566e-01f, -1.15535170e-01f, 5.13830280e-04f, 4.90822382e-02f, 1.10348329e-01f,
  -1.29892239e-02f, -1.34210000e-02f, 2.98496801e-02f, 1.13601603e-01f, -1.39780521e-01f, 1.55820549e-02f, 3.67163084e-02f, -1.09630354e-01f, -8.92581493e-02f, -4.70819660e-02f,
  -1.09049067e-01f, 5.88255152e-02f, -1.66496977e-01f, -1.27261430e-01f, 1.02905028e-01f, -9.95899066e-02f, 1.80390403e-01f, -9.85159278e-02f, 4.08652313e-02f, -1.50055543e-01f,
  1.24328375e-01f, -2.20995340e-02f, -5.12035526e-02f, -7.46587440e-02f, 1.99609846e-02f, 2.01402660e-02f, 1.15246110e-01f, 8.63826647e-02f, 6.90028593e-02f, -7.85642490e-02f,
  -1.85219373e-03f, 8.18433911e-02f, 1.55431449e-01f, -6.28975332e-02f, 4.57968377e-02f, 9.13120806e-03f, 5.55708371e-02f, -1.24283709e-01f, 7.20805451e-02f, 1.15279235e-01f,
  -5.72734214e-02f, 1.38957590e-01f, -5.75360842e-02f, -1.39260933e-01f, 2.40261834e-02f, 3.23174000e-02f, 7.74542391e-02f, 1.23339996e-01f, 1.57899693e-01f, 1.51296973e-01f,
  1.37635797e-01f, 3.40920687e-02f, -1.11385122e-01f, 6.56529963e-02f, -1.32054701e-01f, 1.47143705e-02f, 1.10829145e-01f, 9.62692127e-02f, 3.27756777e-02f, -1.37950018e-01f,
  -9.80111063e-02f, 1.21254323e-03f, 1.49144437e-02f, 3.98694463e-02f, 9.28363279e-02f, 8.04712102e-02f, -5.02452813e-02f, 2.60921903e-02f, -2.58071274e-01f, 3.67860235e-02f,
  8.11043233e-02f, -7.21939141e-03f, -7.99141005e-02f, -1.65810138e-01f, -1.73906758e-01f, 9.46954712e-02f, -5.04900962e-02f, -1.04221627e-01f, -2.35663238e-03f, -8.92107934e-02f,
  1.25422508e-01f, -9.61386785e-02f, 2.41999701e-03f, -2.16051489e-01f, -3.71473767e-02f, 7.33431131e-02f, 8.66234899e-02f, -9.77881402e-02f, -7.82118812e-02f, 2.18797270e-02f,
  -9.31945220e-02f, 5.60805723e-02f, 8.71155709e-02f, 3.94095443e-02f, -3.72565128e-02f, 1.49450585e-01f, -1.15533568e-01f, -1.50329620e-01f, -4.35750224e-02f, -1.23098902e-01f,
  1.16734765e-01f, -5.29675744e-02f, -1.23865165e-01f, -3.63176316e-02f, -8.46339539e-02f, 9.64939520e-02f, 3.57437953e-02f, 1.82836264e-01f, 3.60921994e-02f, -8.29374641e-02f,
  -1.20298259e-01f, -1.38793111e-01f, 5.18395901e-02f, 2.02764153e-01f, 2.87016872e-02f, -7.28422105e-02f, -2.31883049e-01f, -1.22006722e-01f, -9.77316275e-02f, -1.46366149e-01f,
  1.71618655e-01f, -1.81529298e-01f, -1.40522003e-01f, 4.31065224e-02f, -8.43354687e-02f, -1.98442966e-01f, -2.58903820e-02f, -1.03039883e-01f, -6.06765412e-02f, 1.40525997e-01f,
  2.02568874e-01f, 1.58844385e-02f, 5.01675867e-02f, 1.25939220e-01f, -2.51041520e-02f, -9.22100544e-02f, 8.19523335e-02f, -1.11529149e-01f, -6.01785220e-02f, 1.35560676e-01f,
  4.13302518e-02f, -8.55748802e-02f, 1.06972083e-01f, -1.37474820e-01f, -1.20562799e-01f, 1.72772318e-01f, 6.46549240e-02f, -1.83698744e-01f, -1.48945693e-02f, -1.35420589e-02f,
  1.26054296e-02f, 2.34402088e-03f, 1.29412375e-02f, -1.56453401e-01f, 3.80228609e-02f, 8.59927610e-02f, 1.36930406e-01f, 2.72311419e-02f, -4.97898683e-02f, -7.76030496e-02f,
  9.08753052e-02f, -8.43530819e-02f, -7.22533390e-02f, -8.53551626e-02f, -7.35739479e-03f, 1.10112540e-02f, 8.37099850e-02f, -9.28844139e-02f, 1.22817084e-01f, 1.97360963e-02f,
  1.06689043e-01f, -1.91212092e-02f, 4.71724942e-02f, -1.54056179e-03f, -3.86242755e-02f, -1.22203544e-01f, -1.15157560e-01f, 8.63158181e-02f, 1.40710445e-02f, -1.14764363e-01f,
  -2.02368811e-01f, 8.18238687e-03f, -5.17473780e-02f, 5.19360937e-02f, 1.13437325e-01f, -3.34323682e-02f, -1.14560738e-01f, 1.85633734e-01f, -1.07033826e-01f, 5.20239398e-02f,
  1.18592396e-01f, 6.70139343e-02f, -2.41315901e-01f, 3.34194601e-02f, 2.11403027e-01f, 6.89357892e-02f, 1.92933187e-01f, -6.42362759e-02f, 5.30692041e-02f, -8.92608706e-03f,
  4.30819131e-02f, 1.47120968e-01f, -7.12650269e-02f, -1.39813088e-02f, 8.92511904e-02f, -5.05977757e-02f, 4.86810990e-02f, -1.65743455e-01f, -1.43487543e-01f, -6.46909028e-02f,
  9.47570577e-02f, -2.11646724e-02f, 8.39338526e-02f, -2.79127583e-02f, -1.56766400e-02f, -8.47636815e-03f, -4.35840599e-02f, -1.67733282e-01f, -4.64396887e-02f, -9.78066847e-02f,
  -5.63960224e-02f, -1.31624103e-01f, 1.01561375e-01f, -3.65273328e-04f, -8.35492015e-02f, 1.17471457e-01f, -1.24273263e-01f, -1.30992848e-02f, -1.34546623e-01f, 1.03430584e-01f,
  9.72097293e-02f, 1.21379517e-01f, -3.90805602e-02f, 1.10008448e-01f, 9.76117402e-02f, 1.10106625e-01f, -4.79981396e-03f, -7.45132044e-02f, 4.88038585e-02f, -1.17415108e-01f,
  2.13664249e-02f, 1.44694084e-02f, -1.83491006e-01f, 1.45102143e-01f, 7.41226524e-02f, 7.26136118e-02f, 6.06322326e-02f, 6.09736145e-02f, -1.74583197e-01f, 7.94324055e-02f,
  -4.40737158e-02f, 1.57839924e-01f, -4.32542786e-02f, 1.74334973e-01f, 3.01073864e-02f, -1.68997601e-01f, -1.63160682e-01f, 8.77740681e-02f, 6.47619143e-02f, -5.09899966e-02f,
  6.17971160e-02f, -3.79363149e-02f, -4.82293963e-03f, -6.88604563e-02f, -5.01289591e-02f, 1.40544534e-01f, 9.55633521e-02f, -1.41057923e-01f, 6.85470626e-02f, 1.13878667e-01f,
  -1.57338068e-01f, 9.41387564e-02f, 1.05071075e-01f, -2.74637789e-02f, -5.17111868e-02f, -9.22239348e-02f, -4.18776944e-02f, -2.41237436e-03f, -1.05844952e-01f, -1.05337597e-01f,
  -1.00899814e-02f, -8.05482790e-02f, 5.63190244e-02f, -9.46128517e-02f, 9.30536464e-02f, 1.21923104e-01f, 5.11819497e-02f, 4.98694628e-02f, -3.02834846e-02f, 3.71578485e-02f,
  2.70756539e-02f, -1.64705217e-02f, 2.08222345e-02f, 3.38734896e-03f, -1.18443007e-02f, 1.03225512e-03f, 1.17328867e-01f, -7.39916787e-02f, -7.35502690e-02f, 1.35536745e-01f,
  -8.50203484e-02f, 1.01360403e-01f, 9.57951397e-02f, -7.20996559e-02f, 6.38994798e-02f, -7.03185648e-02f, 5.80230393e-02f, 1.98106114e-02f, 6.22878112e-02f, 2.30231926e-01f,
  1.58994332e-01f, 1.00733027e-01f, -1.93748772e-01f, 4.56395000e-02f, -4.15058993e-02f, -2.15643016e-03f, -8.62551704e-02f, 9.18684229e-02f, 3.15140821e-02f, -6.89402074e-02f,
  1.14165105e-01f, -9.44900438e-02f, 1.70444399e-02f, -2.14986682e-01f, -8.01413283e-02f, -1.25510037e-01f, 5.44483773e-02f, -4.05841544e-02f, 8.81051868e-02f, 1.97947949e-01f,
  2.03228071e-01f, 1.08550832e-01f, 1.22757629e-01f, -1.60379447e-02f, 8.74606669e-02f, 3.23098265e-02f, -2.75893249e-02f, -8.38195458e-02f, 9.35739726e-02f, -8.38864967e-03f,
  -3.12410742e-02f, -3.07517499e-02f, 8.85201767e-02f, -9.03737694e-02f, -6.07506260e-02f, -5.17649464e-02f, -1.56193018e-01f, -6.37356564e-02f, -2.03526005e-01f, -6.94596469e-02f,
  1.32248001e-02f, -2.65083443e-02f, -6.43909201e-02f, 9.73624066e-02f, 4.80761658e-03f, 4.09340747e-02f, -9.73655432e-02f, -9.07677114e-02f, -7.81802386e-02f, -6.55896366e-02f,
  -8.91682785e-03f, -1.64745718e-01f, -1.99770015e-02f, -4.71477360e-02f, 4.43805903e-02f, -1.41281828e-01f, -1.90423623e-01f, -1.27720460e-01f, 3.64756696e-02f, -1.38854295e-01f,
  1.03877626e-01f, 5.52068129e-02f, 1.50516927e-01f, -3.62831168e-02f, -6.48249732e-03f, -1.46208316e-01f, 1.76844195e-01f, -1.23679250e-01f, -2.42743969e-01f, 2.02761725e-01f,
  -1.28988445e-01f, -8.18440095e-02f, -1.48344398e-01f, -1.24497741e-01f, 1.24406151e-03f, -1.21601656e-01f, -9.37449113e-02f, 3.00288238e-02f, 1.21871047e-01f, -8.59796852e-02f,
  -1.54203013e-01f, -2.10282296e-01f, 3.62966806e-02f, -4.80469614e-02f, 8.67552683e-02f, 7.65664969e-03f, -2.16013655e-01f, 8.36277455e-02f, -8.92912671e-02f, 8.06360133e-03f,
  1.53132975e-01f, 1.35844693e-01f, -1.00893658e-02f, -1.08949400e-01f, 1.08263167e-02f, -5.62559292e-02f, 5.12605021e-03f, -9.08195153e-02f, 3.45184952e-02f, 4.33044657e-02f,
  -7.95122981e-02f, -1.78540587e-01f, -1.65327430e-01f, -1.30783156e-01f, 2.57197069e-03f, -6.61008656e-02f, 5.70441559e-02f, -1.65273637e-01f, -3.92432362e-02f, -1.19835302e-01f,
  -6.38398230e-02f, -1.00107186e-01f, -6.58027083e-02f, 3.04435939e-02f, -1.42501295e-01f, -7.06531331e-02f, -1.03756808e-01f, 4.40369621e-02f, -1.24539800e-01f, -4.34671901e-03f,
  -3.67231704e-02f, -2.48380564e-02f, -5.42683862e-02f, -1.03137232e-01f, -8.26144740e-02f, 8.98257270e-02f, 1.15618207e-01f, 8.29746202e-02f, 6.11844808e-02f, -1.02173053e-01f,
  7.13075846e-02f, -1.57212429e-02f, 1.44490108e-01f, 2.88362563e-01f, 5.89107610e-02f, 1.33432478e-01f, 3.53121273e-02f, -1.08485349e-01f, 8.42290446e-02f, -2.17391267e-01f,
  1.57214388e-01f, -1.58847824e-01f, 2.70669937e-01f, -1.85436130e-01f, -1.06449403e-01f, -1.79224581e-01f, -2.09908020e-02f, 6.13742582e-02f, -3.21767330e-02f, -1.45255178e-02f,
  5.18584847e-02f, -6.69721067e-02f, -1.84435889e-01f, -9.12197381e-02f, 3.63641754e-02f, 1.18356735e-01f, 8.17550048e-02f, 1.34720236e-01f, 4.86081429e-02f, -6.31939471e-02f,
  8.01511109e-02f, -3.38262953e-02f, -9.10490677e-02f, 1.64920688e-01f, -1.30138934e-01f, 7.60706002e-03f, 1.70225892e-02f, 8.06250647e-02f, -8.16642717e-02f, 2.54859030e-02f,
  -1.91051513e-01f, -1.09024361e-01f, -1.35120749e-02f, 4.30092104e-02f, 1.01428196e-01f, 4.57287617e-02f, -9.78213176e-02f, -4.43907343e-02f, -2.06280183e-02f, -1.43640742e-01f,
  -5.05657755e-02f, -1.75357655e-01f, -2.69066542e-02f, 6.45025773e-03f, -2.98262499e-02f, 4.67659496e-02f, 3.90797965e-02f, 2.57530987e-01f, 3.26033980e-01f, -6.82120323e-02f,
  -1.46237105e-01f, -1.71199426e-01f, 1.55746177e-01f, -7.24152057e-03f, 2.01155081e-01f, -8.41104090e-02f, -2.62814522e-01f, -1.15764678e-01f, -9.12897214e-02f, -1.89852133e-01f,
  -3.10026179e-03f, 1.22203104e-01f, 3.41611952e-02f, 6.26964588e-03f, -3.20112966e-02f, 1.27916723e-01f, -1.65210932e-01f, 2.01118916e-01f, 1.58092845e-03f, 2.75162868e-02f,
  -1.04468893e-02f, -2.50895232e-01f, -1.01838559e-01f, 3.60729918e-03f, 2.14923825e-02f, 1.46639068e-02f, 1.31361470e-01f, -2.25870740e-02f, 2.61981646e-03f, -3.56180035e-02f,
  1.02629766e-01f, -8.15350264e-02f, -6.59454390e-02f, 1.51931107e-01f, -9.09770951e-02f, 1.18288413e-01f, -1.17752038e-01f, -3.79892550e-02f, -1.54358849e-01f, -1.91063955e-01f,
  -1.67476058e-01f, 6.87818006e-02f, 8.64428058e-02f, 1.96278859e-02f, -1.88780904e-01f, -2.94690370e-03f, -1.58416517e-02f, -2.88759060e-02f, 3.17952596e-02f, 1.20468102e-01f,
  8.19901600e-02f, 3.00699677e-02f, -4.86979410e-02f, -3.97264920e-02f, -7.34852701e-02f, 1.08929565e-02f, -4.81355079e-02f, 4.96271625e-02f, -3.55248451e-02f, 1.23932354e-01f,
  4.17842083e-02f, -9.74055007e-02f, 1.40907034e-01f, 5.33214845e-02f, 1.89191461e-01f, 1.34042606e-01f, 1.66053042e-01f, -6.96576685e-02f, 1.65734306e-01f, -1.02592774e-01f,
  -1.98153526e-01f, 1.41790435e-01f, 1.97067242e-02f, -1.46452533e-02f, -1.65137842e-01f, 6.02241256e-04f, 4.57580611e-02f, -5.26211597e-02f, -3.33174057e-02f, -7.96763524e-02f,
  1.45224690e-01f, -1.16687052e-01f, -9.50587690e-02f, -7.48567656e-02f, -6.66960422e-03f, 3.98654193e-02f, 3.95053066e-02f, 1.60825297e-01f, -1.23866476e-01f, -5.15860058e-02f,
  -8.68775174e-02f, 5.29968925e-02f, -6.56740218e-02f, 9.98483747e-02f, 2.75593214e-02f, 3.62493768e-02f, -1.33294404e-01f, 1.05916902e-01f, 6.64693639e-02f, 1.07219331e-01f,
  -5.65878339e-02f, 1.53798699e-01f, -7.72237256e-02f, -1.24846563e-01f, -1.25819802e-01f, 1.58213869e-01f, -9.56666768e-02f, -6.11594804e-02f, -9.65044573e-02f, -6.45633712e-02f,
  1.05784364e-01f, 1.68036878e-01f, 6.41100854e-03f, 5.94714005e-03f, 3.67875770e-02f, 9.05084759e-02f, -5.54490127e-02f, -1.07192703e-01f, 1.16951160e-01f, -9.46908519e-02f,
  4.23831828e-02f, -2.58810651e-02f, 6.21928945e-02f, -7.36096725e-02f, -4.49231155e-02f, -1.47569075e-01f, 1.40195906e-01f, 5.32345362e-02f, 2.62863874e-01f, 2.47726962e-01f,
  1.44724444e-01f, 1.66635085e-02f, -2.00879350e-01f, 2.46763453e-01f, 1.19489012e-02f, -3.56634893e-02f, -9.48167033e-03f, -7.44296014e-02f, 1.67169552e-02f, 1.05337955e-01f,
  2.27457270e-01f, -1.37834087e-01f, -7.60812908e-02f, -1.31366059e-01f, -2.11451352e-01f, 2.30374821e-02f, 4.00292464e-02f, 1.21685356e-01f, 6.52112588e-02f, 1.06937870e-01f,
  9.26652551e-02f, 7.70405680e-02f, -1.58328101e-01f, 7.24636465e-02f, 1.40672594e-01f, 1.47683010e-01f, 8.27325583e-02f, -6.82227165e-02f, -1.37386043e-02f, -1.59286126e-01f,
  -7.17485175e-02f, -1.08991772e-01f, 1.03127822e-01f, 1.45018771e-02f, -1.37336344e-01f, -8.99322052e-03f, -5.62128872e-02f, -2.77582705e-02f, 1.54736876e-01f, -3.99082415e-02f,
  5.08599579e-02f, -7.31449127e-02f, -1.29878679e-02f, -5.27418256e-02f, 6.12703860e-02f, 3.52332629e-02f, -2.18182430e-02f, 1.36957198e-01f, -1.96856856e-02f, -2.44582426e-02f,
  8.71767700e-02f, 4.07702886e-02f, 5.27207442e-02f, -9.26202442e-03f, 1.09549083e-01f, 6.11530840e-02f, 1.13126941e-01f, 4.88612205e-02f, 4.86101210e-02f, 6.99813515e-02f,
  2.34050393e-01f, -2.04280704e-01f, -2.87324116e-02f, -1.30100697e-01f, 8.73849690e-02f, -1.44505516e-01f, -3.67024355e-02f, -1.14967011e-01f, -1.77881159e-02f, 6.79600313e-02f,
  7.17273876e-02f, -5.99629171e-02f, -1.61217868e-01f, -1.02205433e-01f, -6.82909042e-02f, -6.19776435e-02f, 1.40298188e-01f, -1.26601294e-01f, 5.19096889e-02f, -8.56077597e-02f,
  -3.33856628e-03f, -9.75914598e-02f, 4.56305370e-02f, -1.28191411e-01f, -1.26959100e-01f, 2.55382694e-02f, 5.78055754e-02f, -4.24629077e-03f, -7.08344877e-02f, -1.13759145e-01f,
  -8.78886729e-02f, -1.62870169e-03f, -6.13992698e-02f, -3.83649059e-02f, 1.01927921e-01f, 9.06049609e-02f, -1.20824985e-01f, 3.68931144e-02f, -1.03244312e-01f, 7.65181407e-02f,
  -7.71409273e-02f, -8.23741928e-02f, -1.50316998e-01f, -9.98154096e-03f, 5.77878691e-02f, -5.76782040e-02f, 3.54483277e-02f, -1.43818647e-01f, -4.94121723e-02f, -7.85975680e-02f,
  7.54980817e-02f, -5.34554906e-02f, 4.63705435e-02f, 9.67229456e-02f, 1.21530313e-02f, 1.16549373e-01f, 5.65321790e-03f, 4.23396602e-02f, 2.18225662e-02f, -6.40896782e-02f,
  -1.00241385e-01f, 6.35167584e-02f, 5.46423569e-02f, 1.30794197e-01f, 1.81699648e-01f, -2.15069160e-01f, 7.10685849e-02f, 8.00821036e-02f, 1.43805355e-01f, 3.63518149e-02f,
  -3.09137031e-02f, -1.54014185e-01f, -1.44885540e-01f, -3.87342274e-02f, -2.70973444e-02f, 3.69225033e-02f, -2.06056237e-01f, -1.05480246e-01f, 1.35391653e-01f, -1.51532993e-01f,
  -7.12640863e-03f, -1.54378548e-01f, -5.90864345e-02f, -5.21830767e-02f, 4.54841442e-02f, 5.92094064e-02f, 1.40134335e-01f, -1.35571569e-01f, -6.06387071e-02f, 1.92701995e-01f,
  1.40494987e-01f, 4.46716845e-02f, -1.02168210e-02f, 6.67605698e-02f, 3.07118855e-02f, 1.15504205e-01f, -4.89644781e-02f, 9.21838135e-02f, -1.31643116e-01f, -7.91866928e-02f,
  9.43700820e-02f, -3.05707706e-03f, -2.42059212e-02f, 7.49349594e-02f, -9.35182795e-02f, 1.28893077e-01f, -9.17998608e-03f, -8.10129195e-02f, 9.36070681e-02f, -5.72423749e-02f,
  1.89325556e-01f, 1.38726488e-01f, -3.64486827e-03f, -2.07326487e-02f, 8.22313428e-02f, 5.47978915e-02f, -1.10936433e-01f, -4.97335754e-02f, 1.04265675e-01f, -7.34502301e-02f,
  -1.00123651e-01f, -2.17010006e-01f, -7.80527368e-02f, 1.30498573e-01f, 2.18070835e-01f, -3.55493352e-02f, 5.37816845e-02f, 1.31271631e-01f, 2.27518052e-01f, -1.62815467e-01f,
  1.90093398e-01f, 1.21994701e-03f, -5.55900335e-02f, -5.02043143e-02f, -1.75737977e-01f, 3.77131999e-02f, 2.22857833e-01f, -3.28731537e-01f, 1.35593399e-01f, -7.85823092e-02f,
  8.45285505e-02f, 2.29803979e-01f, 1.77090883e-01f, 1.44548550e-01f, -2.67547786e-01f, 1.58087671e-01f, -3.04773301e-01f, 7.35916197e-02f, 7.51443356e-02f, 1.80430979e-01f,
  -2.04170674e-01f, -7.04548582e-02f, -6.08069114e-02f, 3.52010410e-03f, 4.20836546e-02f, 2.63826661e-02f, -2.37333830e-02f, -7.07404390e-02f, 7.92015418e-02f, -1.30451918e-01f,
  -9.25071687e-02f, -8.76187533e-02f, 1.23554915e-02f, -6.21497668e-02f, -2.57132072e-02f, 6.34277314e-02f, -8.06871951e-02f, 1.54243544e-01f, 7.94039518e-02f, 1.79908305e-01f,
  -4.17928956e-02f, -1.17033780e-01f, 3.35746305e-03f, -8.03119391e-02f, 8.71948823e-02f, -1.83004916e-01f, -5.68468161e-02f, 1.33570507e-02f, 1.64549076e-03f, -1.49301821e-02f,
  4.06277645e-03f, -5.38168065e-02f, 9.09845382e-02f, 5.76926805e-02f, 5.44600710e-02f, 1.76940262e-01f, 8.68115947e-03f, -1.28905848e-01f, -1.06591042e-02f, -5.30242100e-02f,
  -1.43908849e-02f, 1.98979884e-01f, 1.38514414e-01f, -2.88980126e-01f, -2.13169500e-01f, 2.99728550e-02f, 6.82299957e-04f, 4.17486690e-02f, -9.84776616e-02f, -2.25179881e-01f,
  1.48872644e-01f, -9.47015807e-02f, 1.33681521e-01f, -5.37299477e-02f, 3.06657539e-03f, -3.76323871e-02f, -1.57846108e-01f, 2.32462045e-02f, 5.55618070e-02f, -6.79270253e-02f,
  -9.84517485e-02f, -2.85583567e-02f, 1.33927867e-01f, 1.01188794e-01f, -7.51680275e-03f, -6.19114889e-03f, 9.20637175e-02f, 4.45509069e-02f, 2.96908319e-01f, 8.15469995e-02f,
  -6.68060407e-02f, -1.19130015e-01f, -1.87708631e-01f, -4.63168323e-02f, 8.44201967e-02f, 4.36209626e-02f, 4.25086990e-02f, 3.20075303e-02f, -1.23138964e-01f, 5.28522059e-02f
};

// L2_fan_Wp_bar (Shape: 14 x 64)
const int L2_fan_Wp_bar_rows = 14;
const int L2_fan_Wp_bar_cols = 64;
const float L2_fan_Wp_bar_data[] = {
  1.38563663e-01f, 1.52600631e-01f, 9.32016000e-02f, -3.07978578e-02f, -5.94136976e-02f, -1.72255859e-02f, 5.72532937e-02f, -1.57299682e-01f, 8.99540186e-02f, 6.54618517e-02f,
  8.39379728e-02f, -4.25303243e-02f, 1.33407891e-01f, 9.59576517e-02f, 1.25139683e-01f, 2.72909142e-02f, 7.30310455e-02f, -1.96789224e-02f, 1.80014864e-01f, -5.67695834e-02f,
  -1.36605829e-01f, 1.08472921e-01f, 1.74091533e-01f, -6.60256818e-02f, 4.12404910e-02f, -4.06497270e-02f, 1.12264395e-01f, -1.50201470e-01f, 5.88347204e-02f, 2.17295006e-01f,
  7.09489807e-02f, -2.67277714e-02f, -1.83447883e-01f, 6.50828332e-02f, 1.21305630e-01f, 3.22591141e-02f, 8.73166397e-02f, 2.98978612e-02f, 3.07063572e-02f, 5.78544661e-02f,
  7.07512200e-02f, -1.27025425e-01f, -1.95364878e-02f, -6.36902973e-02f, -2.90077012e-02f, -1.13523677e-01f, 1.19681291e-01f, 4.52063009e-02f, -1.03067324e-01f, -6.85261155e-04f,
  1.67772785e-01f, 1.13254741e-01f, 1.66308368e-03f, 8.27774685e-03f, 4.36447263e-02f, 8.58450830e-02f, 3.37309688e-02f, 7.52468780e-02f, -3.95939313e-02f, 1.01320297e-01f,
  -6.93248063e-02f, -1.23788580e-01f, 8.08720011e-03f, 3.33941728e-02f, -6.69230372e-02f, 8.29368234e-02f, 2.69410647e-02f, -1.06545798e-01f, -1.49363175e-01f, -3.55999405e-03f,
  1.30066603e-01f, 1.13313578e-01f, 9.21715051e-02f, -2.15043556e-02f, -5.93432859e-02f, 4.68383059e-02f, -8.60134698e-03f, 1.41232789e-01f, -4.18398120e-02f, 6.69802204e-02f,
  7.81981498e-02f, 5.05984724e-02f, -3.92725244e-02f, 1.19660124e-01f, 7.00398609e-02f, -3.88081186e-03f, 1.90550730e-01f, 1.13031812e-01f, 6.41629472e-02f, 1.09984413e-01f,
  -7.50272498e-02f, -2.19938252e-03f, -5.46215363e-02f, 2.32057571e-02f, 1.27670512e-01f, -3.94426063e-02f, -1.36701152e-01f, 1.42509043e-01f, -1.44268498e-01f, 2.63887327e-02f,
  5.02843149e-02f, 1.54769812e-02f, 2.67514009e-02f, -1.17396779e-01f, 1.25782326e-01f, -1.81650281e-01f, -8.32007267e-03f, -1.17473669e-01f, -4.89866398e-02f, 2.49783900e-02f,
  -1.03830643e-01f, -5.23502342e-02f, 1.58165902e-01f, -1.23421371e-01f, 1.11369088e-01f, 1.57599613e-01f, -1.39193563e-02f, -5.60589656e-02f, 6.94399029e-02f, 1.78035393e-01f,
  7.69213885e-02f, -8.19669291e-02f, -1.70873385e-02f, 2.72878930e-02f, 5.91542684e-02f, 7.99748972e-02f, -1.06780298e-01f, 2.97089927e-02f, -1.56434663e-02f, 8.15715194e-02f,
  1.80235848e-01f, 9.38069299e-02f, 1.23306267e-01f, -1.16403112e-02f, 1.63724452e-01f, 1.06017135e-01f, -3.27345431e-02f, -9.28900787e-04f, -1.67575013e-02f, 1.22587122e-01f,
  1.41813710e-01f, 1.32627338e-01f, 1.74514085e-01f, 5.05046733e-02f, 8.48038681e-03f, 1.38303518e-01f, 1.15370899e-01f, 1.75124735e-01f, -2.01428123e-02f, 7.92403966e-02f,
  4.71098721e-02f, 1.57776445e-01f, 6.10708520e-02f, 5.13942502e-02f, -3.05706918e-01f, 2.08910182e-01f, -2.33526334e-01f, -8.84304792e-02f, -1.68836489e-01f, -3.94016355e-02f,
  -3.34545039e-02f, -4.23385985e-02f, 2.34508991e-01f, -7.41290078e-02f, 8.18820745e-02f, 5.02916314e-02f, 1.46991670e-01f, -9.41096917e-02f, -1.22170977e-01f, 8.12484324e-02f,
  -5.36395460e-02f, -4.53360565e-02f, -2.24160217e-02f, -1.57577381e-01f, -6.00460246e-02f, -5.67929111e-02f, -6.52942285e-02f, 1.16738332e-02f, 1.21690974e-01f, -1.11816280e-01f,
  8.79366770e-02f, 5.31062596e-02f, 4.78023887e-02f, 4.67132740e-02f, -5.26644997e-02f, -5.06625809e-02f, 7.08858157e-03f, 1.64902538e-01f, 1.95764042e-02f, 1.14934534e-01f,
  1.09988421e-01f, -8.44357833e-02f, 1.40892297e-01f, 8.98577720e-02f, 1.32303238e-01f, 2.51680296e-02f, -9.31333601e-02f, 5.98927364e-02f, -2.67317556e-02f, -2.12249786e-01f,
  1.13904439e-01f, 4.81241271e-02f, 2.00314850e-01f, 1.80696934e-01f, -1.40678957e-01f, 1.71062693e-01f, 1.25046805e-01f, 1.09848022e-01f, -8.57646298e-03f, -1.98231805e-02f,
  1.58427566e-01f, 1.26517579e-01f, 7.02982172e-02f, 1.35854781e-01f, 1.68697372e-01f, -4.71659414e-02f, 1.96882606e-01f, -1.35140419e-02f, -6.69948682e-02f, 1.82595804e-01f,
  1.70574397e-01f, 4.85966019e-02f, 2.31917668e-02f, -5.75397015e-02f, -1.87141642e-01f, 1.89138964e-01f, 1.46413073e-01f, -1.54155552e-01f, 1.70955002e-01f, 1.89820021e-01f,
  -1.61019992e-02f, -5.43365777e-02f, 8.54962245e-02f, 7.06503764e-02f, -7.36388117e-02f, 1.00178249e-01f, 5.71463779e-02f, 2.56681815e-02f, 6.24169223e-02f, 6.59764484e-02f,
  -1.69629723e-01f, 6.33657575e-02f, 2.15975091e-01f, -1.74701244e-01f, -1.22647598e-01f, 9.82984826e-02f, -1.40652701e-01f, 1.35790378e-01f, -7.02596605e-02f, -1.40938088e-01f,
  9.74067301e-02f, 4.67494018e-02f, -1.55940466e-02f, -1.13894023e-01f, -9.86147448e-02f, 1.08397804e-01f, -6.89344853e-02f, 1.61552489e-01f, 6.98321685e-02f, 6.80718124e-02f,
  3.59470472e-02f, -1.62539855e-02f, -4.10258248e-02f, 8.90216455e-02f, 1.10092543e-01f, -8.56507868e-02f, -7.81414099e-03f, 3.35879885e-02f, 9.40565541e-02f, 1.31907374e-01f,
  4.04304117e-02f, -8.61232057e-02f, -7.90777877e-02f, 1.22004077e-02f, -6.68914169e-02f, -4.54876535e-02f, 1.17645711e-01f, 9.52262133e-02f, 1.91994250e-01f, 8.94363746e-02f,
  1.14330053e-01f, 1.16441853e-01f, -1.60320587e-02f, 1.76324233e-01f, -1.64364681e-01f, 2.31457520e-02f, -1.43322870e-01f, 1.10919520e-01f, -1.54250979e-01f, 6.53925091e-02f,
  -5.84211666e-03f, -7.27061108e-02f, -5.64670004e-02f, 7.36949071e-02f, 1.49253517e-01f, 1.00422725e-01f, 8.73750523e-02f, 1.36263698e-01f, -4.29489919e-05f, 1.70161277e-01f,
  5.30778021e-02f, -8.49046037e-02f, -3.61030176e-02f, 5.26862666e-02f, -1.47409946e-01f, -6.56044930e-02f, -7.40026415e-04f, -7.49656260e-02f, -1.10693440e-01f, -1.06052630e-01f,
  5.56954928e-02f, -2.30957987e-03f, 4.18311208e-02f, 8.51221085e-02f, -7.71097373e-04f, -8.50537419e-02f, 5.95692657e-02f, 1.25790700e-01f, -9.03900266e-02f, 1.11388847e-01f,
  5.08800820e-02f, 1.23299189e-01f, 1.09555051e-01f, -5.76549862e-03f, 1.09116010e-01f, 1.24433056e-01f, 2.09615394e-01f, 1.75904095e-01f, 9.46901515e-02f, 1.79297477e-01f,
  1.40668496e-01f, 8.99894238e-02f, 2.64717281e-01f, -3.95288318e-02f, -2.68104416e-03f, 1.63090497e-01f, 9.43353251e-02f, 2.25515161e-02f, 1.03651462e-02f, -1.37715191e-01f,
  1.79699376e-01f, 1.10505290e-01f, 2.45600224e-01f, 1.97053552e-01f, 1.93585157e-01f, 2.61651307e-01f, 5.75781576e-02f, -1.90445513e-01f, 2.19354816e-02f, -3.94763984e-02f,
  7.30519295e-02f, 8.37076008e-02f, 1.50887847e-01f, -9.07432660e-02f, -3.75486277e-02f, -2.46399209e-01f, -4.86853309e-02f, -2.59608537e-01f, 8.04476514e-02f, -1.44110192e-02f,
  1.60211772e-01f, 2.41094053e-01f, -8.36035460e-02f, 2.26804122e-01f, -2.20324442e-01f, 1.37136936e-01f, -1.23532414e-01f, 2.01730877e-01f, 1.53179392e-02f, -3.14319909e-01f,
  -9.33423638e-02f, 1.08453281e-01f, -5.43511696e-02f, 6.41092807e-02f, 3.53602506e-02f, 7.23437816e-02f, 1.42918736e-01f, 5.61207123e-02f, 6.68279007e-02f, -1.94881141e-01f,
  9.44931805e-02f, 4.66282777e-02f, 2.81801559e-02f, 5.56138828e-02f, -1.15799522e-02f, -3.12430020e-02f, 5.77266030e-02f, -1.14813158e-02f, -8.79744589e-02f, 9.02687162e-02f,
  -5.76050989e-02f, -6.50770441e-02f, 1.19445883e-01f, 1.21692091e-01f, 8.38210806e-02f, 1.05699047e-01f, 1.08004501e-02f, -6.30229414e-02f, -8.12823623e-02f, 1.26206890e-01f,
  -4.69444841e-02f, 8.17696601e-02f, -1.14681602e-01f, -8.16214085e-02f, -7.87186176e-02f, 3.11207250e-02f, -3.92779037e-02f, 1.32514238e-01f, -6.41700700e-02f, 5.18258214e-02f,
  -4.57099341e-02f, 4.74976096e-03f, -7.04189166e-02f, -9.92423296e-02f, 1.13834701e-01f, -6.79489896e-02f, 1.26529053e-01f, 2.71179285e-02f, 5.32657877e-02f, -1.27832934e-01f,
  -8.00738707e-02f, 2.13451050e-02f, 9.05916393e-02f, 7.60706067e-02f, 1.25200346e-01f, 1.05192035e-01f, -8.98489580e-02f, 1.70767680e-02f, -1.50462881e-01f, 4.44352180e-02f,
  -4.10335138e-02f, 8.33310485e-02f, 1.05525583e-01f, -1.29800528e-01f, 6.94533950e-03f, -7.27748126e-03f, 1.24943621e-01f, -8.77954438e-02f, -9.85532254e-02f, -1.21083908e-01f,
  -1.21545836e-01f, 6.19022101e-02f, -6.60950094e-02f, -5.71718141e-02f, -7.86376521e-02f, -1.19179748e-02f, -6.35983497e-02f, 9.28017572e-02f, 6.76485598e-02f, 1.84448272e-01f,
  3.28972302e-02f, 6.23649582e-02f, -5.68153709e-02f, 1.73632383e-01f, 1.64676011e-01f, -1.18704788e-01f, 1.08662490e-02f, -9.90522429e-02f, 3.50620016e-03f, -5.34332581e-02f,
  1.40193567e-01f, 1.94511026e-01f, 1.25344008e-01f, 1.54954568e-01f, 9.48998425e-03f, 3.59583162e-02f, 1.12005882e-01f, -2.97449157e-03f, -1.24254584e-01f, 2.59006303e-02f,
  3.88154015e-02f, 4.84568663e-02f, -1.91075914e-02f, 1.41015872e-01f, 5.70979752e-02f, -2.94231862e-01f, -1.50292972e-02f, 1.33579582e-01f, -9.43602622e-02f, 1.12374991e-01f,
  -1.10228106e-01f, -2.31283516e-01f, 1.45602033e-01f, 3.69564779e-02f, -7.19902143e-02f, -6.29683137e-02f, -1.08083427e-01f, -1.38122933e-02f, 1.22575477e-01f, -5.44580035e-02f,
  1.21687211e-01f, -1.84166715e-01f, 3.21446620e-02f, -2.42967531e-02f, 9.94917005e-02f, 1.52683929e-01f, 1.61984693e-02f, 8.72923285e-02f, 3.61551307e-02f, 5.47242835e-02f,
  3.29739809e-01f, -1.31117925e-01f, -4.51310212e-03f, 4.28117625e-02f, 1.82643179e-02f, -8.36590677e-02f, 9.33931321e-02f, 2.88994431e-01f, 1.73202958e-02f, -4.70099896e-02f,
  5.34311347e-02f, 1.05930723e-01f, -3.03681884e-02f, 8.81314576e-02f, 5.83857857e-02f, 1.50430337e-01f, 2.59468675e-01f, -3.32130864e-02f, 6.29267320e-02f, -1.15387961e-02f,
  1.92601591e-01f, 4.67244051e-02f, 1.12956539e-01f, 1.90220371e-01f, -3.01212724e-02f, 6.54086918e-02f, 6.91575706e-02f, 1.68345749e-01f, 1.29114658e-01f, 1.12171367e-01f,
  -3.49434316e-02f, 1.22007042e-01f, 1.14936279e-02f, 1.64410174e-01f, 7.61916116e-02f, 5.03560491e-02f, 1.07759699e-01f, 1.09160922e-01f, -3.17488641e-01f, 2.42982805e-01f,
  -1.64027452e-01f, 1.27736973e-02f, -2.87088513e-01f, 2.09047586e-01f, -7.69550726e-02f, -3.34314480e-02f, 2.35772431e-01f, -1.04993328e-01f, -1.30299807e-01f, 2.60720104e-01f,
  2.84871131e-01f, 1.08881667e-01f, -1.85380563e-01f, 2.50871718e-01f, -4.34162281e-02f, 2.97469079e-01f, -1.76588997e-01f, 1.19343087e-01f, -3.21701216e-03f, -5.83422594e-02f,
  -1.27432331e-01f, -6.67123646e-02f, -9.08932090e-02f, -2.14967087e-01f, -6.27307519e-02f, -1.07965373e-01f, 1.50915027e-01f, -1.36721894e-01f, -2.14331504e-02f, -1.37328342e-01f,
  5.13840280e-02f, -1.97434321e-01f, 1.83658883e-01f, 4.11233902e-02f, -5.08546196e-02f, -1.15227722e-01f, 3.51429470e-02f, -2.30629686e-02f, -9.05348957e-02f, -8.58389363e-02f,
  -1.17760904e-01f, -1.27997759e-04f, 8.54482353e-02f, 5.20223379e-02f, 1.30418427e-02f, 1.15056746e-02f, -7.05741718e-02f, 2.57273335e-02f, 7.78181776e-02f, 1.91156901e-02f,
  6.48956448e-02f, 1.24548823e-01f, -9.49236751e-02f, -1.97839960e-02f, 7.88168609e-02f, 1.06504308e-02f, 3.84293832e-02f, 6.38977960e-02f, -8.97181928e-02f, 1.01007961e-01f,
  -4.16055731e-02f, -1.16992585e-01f, -5.72007783e-02f, -1.08855039e-01f, -5.08073308e-02f, 1.62095711e-01f, 9.43645649e-03f, -1.33594498e-01f, 3.96750309e-02f, -8.12585950e-02f,
  7.42439106e-02f, -7.23022372e-02f, -7.44587183e-02f, -3.21896188e-02f, -8.75497684e-02f, -8.09548870e-02f, 9.69740599e-02f, -9.66033563e-02f, -1.28815725e-01f, 9.16900262e-02f,
  -7.60746300e-02f, -1.35636121e-01f, -2.18324680e-02f, -3.66989477e-03f, 7.78382942e-02f, 1.03903338e-02f, 1.63415428e-02f, 6.61007911e-02f, -7.08236499e-03f, -6.67490214e-02f,
  1.02533340e-01f, -3.50247361e-02f, 1.29581675e-01f, 7.32221082e-02f, 3.45560070e-03f, 5.99131780e-03f, -1.32774755e-01f, -9.47238319e-03f, 1.01237476e-01f, -8.61424729e-02f,
  1.43265083e-01f, -9.26868990e-02f, -1.44183896e-02f, 8.40723235e-03f, -2.08367109e-02f, 1.22957394e-01f, -1.40299648e-02f, 3.69718969e-02f, 1.40093520e-01f, 1.37322932e-01f,
  1.08053245e-01f, 5.39400280e-02f, -1.26618430e-01f, -5.82442693e-02f, 1.23015396e-01f, 6.12661652e-02f, 2.11923514e-02f, 8.48298818e-02f, 1.46764778e-02f, 7.16433376e-02f,
  1.94523945e-01f, 9.70553011e-02f, 1.27701119e-01f, -2.90444177e-02f, -3.16714607e-02f, -4.02962193e-02f, -6.62625134e-02f, 2.74167329e-01f, 2.15247750e-01f, 6.41638935e-02f,
  -7.07596391e-02f, 7.63348043e-02f, -1.52963683e-01f, 3.47773343e-01f, -7.86013305e-02f, 7.05485716e-02f, -8.85202959e-02f, 1.02875702e-01f, 1.85921103e-01f, 3.76146436e-02f,
  6.33647293e-02f, -1.55996770e-01f, -1.53693259e-02f, 9.21428874e-02f, -5.81062064e-02f, -7.86239728e-02f, 3.14325057e-02f, -7.51847699e-02f, -1.94090520e-04f, 1.66781262e-01f,
  9.73885506e-02f, -3.12570035e-02f, -2.26502478e-01f, -8.88221860e-02f, 1.05108529e-01f, 8.02774802e-02f, 1.23326063e-01f, -1.05139017e-01f, -1.19247183e-01f, -6.41736537e-02f,
  1.30960971e-01f, -2.46493965e-02f, -9.13641527e-02f, 2.26860195e-02f, 2.79134326e-02f, -1.18412282e-02f, 1.05914883e-01f, -2.40661260e-02f, -1.22790551e-02f, 7.19426721e-02f,
  1.02809474e-01f, -6.43301830e-02f, -8.27474222e-02f, 3.61012369e-02f, 9.95941684e-02f, 3.01249437e-02f, -4.19677831e-02f, -1.08516052e-01f, -6.60725823e-03f, -6.07168600e-02f,
  1.67169366e-02f, 5.65277524e-02f, -7.39352033e-02f, -1.17069915e-01f, -8.48285705e-02f, 1.13547623e-01f, 1.26879528e-01f, 6.63991943e-02f, 2.58055013e-02f, -4.34499793e-02f,
  4.52378280e-02f, 1.00618407e-01f, -6.33075163e-02f, 4.67836484e-03f, -7.14183524e-02f, 1.05627850e-01f, 4.24076207e-02f, -3.53725138e-03f, 9.59302336e-02f, -3.36589776e-02f,
  3.77839431e-02f, 8.60096589e-02f, -1.09663099e-01f, -1.79320443e-02f, 2.93445271e-02f, 6.44077063e-02f, 5.35347946e-02f, -1.65465567e-02f, -5.63810393e-02f, 7.83674642e-02f,
  -9.63679180e-02f, 3.84152085e-02f, 6.65902272e-02f, 1.11180387e-01f, -2.21526455e-02f, 3.18431556e-02f, 9.65554034e-04f, 5.74084930e-02f, -8.80870223e-02f, 8.47541168e-02f,
  -6.28961325e-02f, -1.02323957e-01f, -3.74768041e-02f, 9.84620955e-03f, -4.67406549e-02f, -3.03413644e-02f, -9.15356353e-02f, -5.56114800e-02f, 1.21265016e-01f, 6.02900870e-02f,
  3.36612388e-02f, -5.77870086e-02f, -6.24233223e-02f, 1.51965134e-02f, 1.29636064e-01f, -1.51623607e-01f, 1.18535407e-01f, -7.08938986e-02f, 6.68444708e-02f, 1.08614109e-01f,
  4.88452390e-02f, 4.84835356e-02f, 1.00810565e-01f, 5.07248789e-02f, 1.36496976e-01f, 1.06933728e-01f, 9.07011181e-02f, -6.23205826e-02f, -3.71186472e-02f, 6.80270121e-02f,
  -5.23179397e-03f, 3.02207489e-02f, -8.08150545e-02f, -1.43207863e-01f, -7.16054887e-02f, 1.12671740e-01f, 1.33673459e-01f, 6.59574866e-02f, -4.42915037e-02f, 7.90904760e-02f,
  -2.00305626e-01f, 1.56710714e-01f, 2.80027520e-02f, 4.43042628e-02f, 1.38783053e-01f, 9.78893340e-02f, 8.83097574e-02f, -7.59152249e-02f, -4.66276444e-02f, -1.40825108e-01f,
  -6.57181889e-02f, -1.06261879e-01f, 8.30143020e-02f, -5.87275289e-02f, -6.60777166e-02f, 1.34375632e-01f, -1.08627193e-01f, 1.72228664e-01f, 9.76376384e-02f, -1.41078204e-01f,
  -2.21690610e-02f, 7.39875063e-02f, -3.75034139e-02f, -9.98974964e-02f, -4.45461348e-02f, 7.95487408e-03f, -6.64589182e-02f, 1.09911382e-01f, 1.06229454e-01f, -5.78818731e-02f,
  7.01078847e-02f, -4.60353047e-02f, -4.57307324e-02f, -4.78206575e-02f, -1.09893240e-01f, 1.05850041e-01f, -1.08705483e-01f, -1.60393137e-02f, 1.29771009e-01f, -6.64400756e-02f,
  -8.93014297e-02f, 1.31841525e-01f, -7.28533790e-02f, 1.38605069e-02f, -6.64358288e-02f, 8.32486004e-02f, -8.49248022e-02f, -3.44408192e-02f, -1.01758637e-01f, 9.98418182e-02f,
  4.33995947e-02f, 6.28967434e-02f, -5.42032905e-02f, -9.32512432e-02f, 7.55989030e-02f, -3.40512432e-02f, -7.74211958e-02f, -6.51801080e-02f, 6.60245270e-02f, 1.36209026e-01f,
  6.74572065e-02f, 5.52152283e-02f, -9.35934782e-02f, 5.65371662e-03f, 5.33117354e-02f, 4.50291410e-02f, -2.96767280e-02f, 1.13349043e-01f, -6.74217045e-02f, -7.60836601e-02f,
  5.01535349e-02f, -5.71072325e-02f, 4.29592887e-03f, 7.60825574e-02f, -4.73627970e-02f, -5.29911369e-02f, -1.96920894e-02f, 7.18792081e-02f, -3.64644527e-02f, -7.63470158e-02f,
  -7.27310032e-02f, 9.11859721e-02f, -1.73841149e-03f, 6.62016198e-02f, -2.60492358e-02f, -4.28190753e-02f, -3.60287204e-02f, -8.14837497e-03f, -2.13779677e-02f, 8.86231065e-02f,
  -5.89345247e-02f, -6.07699305e-02f, -1.94829889e-02f, -3.52313519e-02f, -8.45821872e-02f, -3.63625586e-02f
};

// L2_fan_Bp_bar (Shape: 1 x 14)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 14;
const float L2_fan_Bp_bar_data[] = {
  -4.96112704e-02f, 1.34517625e-01f, -2.29320284e-02f, 2.07719859e-02f, 1.36813074e-01f, 6.39611036e-02f, -7.12010413e-02f, 1.77817361e-03f, 6.44279197e-02f, 9.33081657e-02f,
  5.72967641e-02f, -1.16686232e-01f, 8.37902352e-02f, -7.02744303e-03f
};

// L3_fan_Wp (Shape: 25 x 64)
const int L3_fan_Wp_rows = 25;
const int L3_fan_Wp_cols = 64;
const float L3_fan_Wp_data[] = {
  6.86598122e-02f, -7.13709146e-02f, 5.07872999e-02f, -1.95658393e-02f, 2.76034269e-02f, -1.44613698e-01f, -2.56395414e-02f, -1.29383907e-01f, -4.13706116e-02f, 7.75260702e-02f,
  -1.12786993e-01f, -6.65393695e-02f, 2.89346930e-02f, -1.37108058e-01f, -2.88252644e-02f, -6.65007681e-02f, -8.52261633e-02f, 4.49958965e-02f, -1.65238664e-01f, -7.37211555e-02f,
  -4.78173271e-02f, 4.22297455e-02f, -2.60205250e-02f, 4.96315435e-02f, -4.12539132e-02f, -3.42840612e-01f, 1.01590091e-02f, -1.27830813e-02f, 1.89782673e-04f, 1.83297438e-03f,
  -1.20512351e-01f, -2.44527042e-01f, -5.54004125e-02f, 1.65635556e-01f, 9.63434801e-02f, 1.56641662e-01f, -1.58700161e-02f, -3.01444441e-01f, -1.25344366e-01f, 1.83032498e-01f,
  1.07816011e-01f, -1.90749124e-01f, -3.37951481e-02f, -1.25426427e-01f, -1.60490721e-01f, 7.63165802e-02f, -2.13860422e-01f, -1.82345733e-01f, 2.31642779e-02f, -1.59145594e-01f,
  3.47634405e-02f, -8.97058100e-02f, 8.65421668e-02f, 1.37631938e-01f, 8.09209719e-02f, -2.87540406e-02f, -6.86644167e-02f, -6.13212772e-02f, 1.27100646e-01f, 3.76734324e-02f,
  2.90677458e-01f, 3.69947031e-02f, 1.77470922e-01f, 1.63338911e-02f, 6.62520602e-02f, -1.03890607e-02f, 1.53816855e-02f, 1.20412953e-01f, -9.98245031e-02f, -1.56536326e-02f,
  -1.65620491e-01f, -5.23675159e-02f, 3.32491212e-02f, 1.51703089e-01f, -6.85063303e-02f, 6.07741848e-02f, -2.82782197e-01f, -5.63027486e-02f, -8.43301639e-02f, -1.93994224e-01f,
  1.46914124e-01f, 2.40613252e-01f, -1.40090175e-02f, -6.23246990e-02f, 1.79194689e-01f, -6.13866486e-02f, 6.19856417e-02f, -4.92418371e-02f, 2.70299707e-02f, -2.25370392e-01f,
  -2.14138567e-01f, -5.25005236e-02f, 4.17382121e-02f, 4.42468747e-02f, -1.19149640e-01f, -2.33153462e-01f, 1.16586529e-01f, 6.50167167e-02f, -1.95553735e-01f, -2.10332572e-02f,
  -2.10141659e-01f, -1.65936172e-01f, 1.02642579e-02f, 1.44610837e-01f, 7.06467405e-02f, 4.21573129e-03f, 4.09902707e-02f, -8.20163712e-02f, 2.85394937e-02f, 9.41141974e-03f,
  -1.28109202e-01f, 6.47568405e-02f, -1.02207668e-01f, 7.54710427e-03f, 1.05528250e-01f, 1.01996936e-01f, -7.58566931e-02f, 6.54162541e-02f, -7.00705200e-02f, -3.26556355e-01f,
  -2.13681199e-02f, 1.56190947e-01f, -8.28259289e-02f, 8.64541233e-02f, 1.34622052e-01f, 1.17449753e-01f, 1.79331139e-01f, 4.34908420e-02f, 1.45977169e-01f, -1.13647670e-01f,
  1.81766171e-02f, 5.99818602e-02f, -4.85714115e-02f, 6.89421743e-02f, 6.42985031e-02f, 3.52895819e-02f, -1.03672050e-01f, -1.53073698e-01f, -1.05467804e-01f, 5.03620021e-02f,
  -3.43926214e-02f, 7.49070123e-02f, 9.80755538e-02f, 4.08741273e-02f, -1.84666529e-01f, -8.75642523e-02f, 6.60952851e-02f, -1.44741014e-01f, 1.93947166e-01f, 1.22311212e-01f,
  -1.39420956e-01f, 1.56030580e-01f, 7.43082762e-02f, -1.40188873e-01f, 2.50272095e-01f, 2.84361746e-02f, 1.58239216e-01f, -3.24726440e-02f, -6.09504879e-02f, -7.04811700e-03f,
  -2.51056515e-02f, -2.73541715e-02f, 2.04788983e-01f, 5.62148839e-02f, 4.77160886e-02f, -2.81453192e-01f, -6.95203468e-02f, -2.63035838e-02f, 1.50902197e-01f, -3.94736417e-02f,
  -6.64676800e-02f, -1.07193924e-01f, -1.44333154e-01f, -5.95486015e-02f, -1.74589176e-02f, -6.36646301e-02f, 3.06147516e-01f, 1.15234576e-01f, 9.29525588e-03f, -3.97855863e-02f,
  1.17074922e-01f, 2.25951388e-01f, -2.06070561e-02f, -9.55413431e-02f, 9.70490128e-02f, 9.81352106e-02f, 2.11800948e-01f, -8.34438019e-03f, -1.06504254e-01f, -6.58994913e-02f,
  5.69345430e-02f, -4.45693843e-02f, -2.73561534e-02f, 9.39718187e-02f, -5.67470044e-02f, -7.78131783e-02f, 2.90774889e-02f, -7.64828250e-02f, 3.21066119e-02f, -4.48232591e-02f,
  5.72261512e-02f, -1.17594905e-01f, -8.47954825e-02f, -8.50080103e-02f, 9.25787836e-02f, 7.85014480e-02f, -4.28075641e-02f, 2.85617113e-02f, -1.92511305e-01f, 2.46194527e-02f,
  -9.41070989e-02f, 1.05438709e-01f, -3.70078906e-02f, -2.24829726e-02f, -3.89086232e-02f, -4.88163121e-02f, 8.07863995e-02f, 1.16775833e-01f, 1.37329727e-01f, -8.60898569e-02f,
  -5.00755459e-02f, -7.48919249e-02f, -1.69005260e-01f, -2.27189586e-01f, 1.88155949e-01f, -5.42865694e-02f, 2.17773747e-02f, -1.70076843e-02f, 3.32300067e-02f, -1.91369265e-01f,
  1.66163906e-01f, 2.80640945e-02f, 1.30395547e-01f, -7.49939755e-02f, -6.82798550e-02f, -4.48764451e-02f, -1.41359404e-01f, 2.56498042e-03f, -1.24571450e-01f, -1.88378077e-02f,
  -8.38571563e-02f, 9.19457078e-02f, 6.27939850e-02f, -6.25695065e-02f, 1.04081057e-01f, -6.91808239e-02f, 9.35563967e-02f, -1.79223970e-01f, -4.86939177e-02f, 6.47890121e-02f,
  2.40906119e-01f, -9.73309204e-02f, 7.48529136e-02f, -4.73961281e-03f, 5.34916781e-02f, -1.12089351e-01f, -3.85781676e-02f, 8.86819363e-02f, -3.80594507e-02f, 9.76408422e-02f,
  3.87926102e-02f, 1.96463317e-02f, 9.83976647e-02f, -8.25463831e-02f, -1.28250718e-01f, -7.94144720e-02f, 1.30249113e-01f, 8.82706493e-02f, 1.72518119e-01f, 8.54799077e-02f,
  -1.71485096e-02f, 2.31843982e-02f, -1.50163740e-01f, -9.70688611e-02f, 2.34689459e-01f, 9.52082425e-02f, -4.60160896e-02f, -9.93620530e-02f, -1.08873382e-01f, -1.04468606e-01f,
  1.29902929e-01f, 1.67744070e-01f, -1.07035656e-02f, -1.01355322e-01f, 2.95025725e-02f, -3.90114449e-02f, 3.95603962e-02f, 2.26873830e-01f, -2.02770859e-01f, 1.19510833e-02f,
  8.00736845e-02f, 4.60190102e-02f, -1.46583328e-02f, 2.05901325e-01f, -1.51549028e-02f, -2.28891343e-01f, -1.34402156e-01f, 7.86103867e-03f, -6.69720843e-02f, 2.12420419e-01f,
  -5.46287298e-02f, -1.00710183e-01f, 1.99047234e-02f, 1.01250984e-01f, 2.84861982e-01f, 1.36496782e-01f, -9.26526710e-02f, -9.10698175e-02f, -1.11256381e-02f, -1.22723067e-02f,
  9.80937779e-02f, 2.36241683e-01f, -5.70701575e-03f, -1.27963359e-02f, 8.35863203e-02f, 5.28948829e-02f, -9.31196436e-02f, -7.04219043e-02f, -7.36976042e-02f, -7.78245926e-02f,
  4.16906103e-02f, -1.53981194e-01f, -1.42055944e-01f, -1.20067596e-01f, 5.88166080e-02f, -4.68497537e-02f, 1.05499953e-01f, -2.66686138e-02f, -6.03721552e-02f, -1.14350766e-01f,
  7.15125576e-02f, -4.13837917e-02f, 8.69397968e-02f, 7.81649426e-02f, -1.07009113e-01f, 5.16786473e-03f, -6.14574701e-02f, 5.38222268e-02f, 9.29479972e-02f, -1.80526271e-01f,
  -8.69001448e-02f, -1.53599739e-01f, -1.61107965e-02f, 7.18002440e-03f, -1.47777155e-01f, 1.86801434e-01f, 2.12362722e-01f, -1.46718752e-02f, 7.08792210e-02f, 6.46277145e-02f,
  -4.24401723e-02f, 1.52506018e-02f, 1.10734105e-01f, 1.14686593e-01f, 5.91534413e-02f, -7.53081366e-02f, 4.80867513e-02f, 1.06964134e-01f, -3.76100801e-02f, -4.89487350e-02f,
  -1.46635892e-02f, 1.00443296e-01f, -2.18953714e-02f, 1.08442448e-01f, -6.41646981e-02f, -1.84667036e-01f, 1.84736460e-01f, 4.46525142e-02f, 3.56729254e-02f, 1.41625747e-01f,
  3.01035270e-02f, -1.08292833e-01f, 8.69018510e-02f, -1.58009827e-01f, 3.84133048e-02f, -6.63508400e-02f, 1.71159860e-02f, 1.16907738e-01f, 7.06952512e-02f, -1.43263131e-01f,
  -1.48721710e-01f, -2.05691513e-02f, 5.56466691e-02f, -5.98855615e-02f, -1.11345783e-01f, 1.02057621e-01f, -6.66940734e-02f, 1.28782362e-01f, 7.15841800e-02f, -4.96501140e-02f,
  1.78184256e-01f, 2.42485180e-02f, 1.17330495e-02f, -7.02776015e-02f, 1.85037464e-01f, -7.11781979e-02f, 2.98585370e-02f, -4.88489978e-02f, 6.39786869e-02f, -1.10061755e-02f,
  -4.16607037e-02f, -1.51464269e-01f, 2.20288172e-01f, 3.37368585e-02f, -6.05512522e-02f, 5.67592401e-03f, 1.16492316e-01f, 1.43634707e-01f, 9.32044834e-02f, 2.60672301e-01f,
  -3.55774746e-03f, 1.05898693e-01f, 3.48571427e-02f, 1.33929551e-01f, 1.77306518e-01f, 2.43497238e-01f, 2.28742920e-02f, -1.20625779e-01f, -3.63454744e-02f, 6.61373138e-02f,
  6.74887449e-02f, 1.21242836e-01f, 1.19778641e-01f, -2.14387059e-01f, -1.25384644e-01f, -5.31642465e-03f, -9.39171016e-02f, 2.05834180e-01f, 7.58449510e-02f, -2.12494746e-01f,
  1.73629969e-01f, 4.76648659e-02f, 1.18415706e-01f, -3.63432877e-02f, -1.14474282e-01f, -9.38217714e-02f, 4.31472063e-02f, -1.46113858e-01f, 3.68629731e-02f, 2.26119712e-01f,
  9.57795456e-02f, 1.12217017e-01f, -9.91306752e-02f, -1.00022383e-01f, -2.11062282e-01f, -5.70734143e-02f, -9.60736424e-02f, 9.50556807e-03f, 1.50565907e-01f, -1.14929855e-01f,
  -4.41667400e-02f, 7.71817490e-02f, -2.55633965e-02f, -1.63994625e-01f, -2.13025063e-02f, -1.03897884e-01f, 2.17728205e-02f, -8.35871473e-02f, 7.24825710e-02f, 4.75080833e-02f,
  -1.13809958e-01f, 1.89755708e-02f, 3.78218852e-03f, -4.90972027e-02f, -2.61074841e-01f, -5.80994133e-03f, -2.27017134e-01f, -1.20740645e-01f, 1.39438853e-01f, 9.02609378e-02f,
  -8.92779976e-02f, -3.71066555e-02f, 2.98417192e-02f, -7.51615316e-02f, 2.42782772e-01f, 1.62629560e-01f, 1.82328522e-01f, 1.52945802e-01f, -9.71213391e-04f, -8.17606077e-02f,
  6.48922995e-02f, 1.67335019e-01f, 8.08148682e-02f, -1.18075922e-01f, -1.29677281e-01f, -6.43290728e-02f, -7.33707426e-03f, 5.17493337e-02f, 8.17504525e-02f, -1.79061204e-01f,
  1.02168150e-01f, 1.33621022e-01f, -1.53225707e-03f, -1.91768296e-02f, -7.53285224e-03f, 1.90657824e-01f, 1.19673148e-01f, 3.28484535e-01f, 2.96174828e-02f, -7.78916478e-02f,
  -6.15199618e-02f, 1.01818278e-01f, -3.58193251e-03f, -7.63652381e-03f, -1.48411272e-02f, 1.79706275e-01f, -1.24017343e-01f, -1.09166361e-01f, -8.58663172e-02f, -3.79745625e-02f,
  9.96726453e-02f, -8.30324516e-02f, 3.17010321e-02f, 1.27102938e-02f, -5.84123842e-03f, -5.49899340e-02f, 8.18540826e-02f, 1.51242688e-01f, -5.57644404e-02f, 1.48030356e-01f,
  2.57459171e-02f, 1.02926753e-01f, 2.31232867e-01f, 1.26684368e-01f, 8.47301856e-02f, 1.25995770e-01f, 3.19714099e-02f, -4.51325476e-02f, 1.22622922e-01f, 9.53281298e-02f,
  1.38538018e-01f, 2.19987482e-01f, -1.41025826e-01f, 1.19362794e-01f, 1.79346502e-01f, 6.63341358e-02f, 3.51551063e-02f, 2.59007275e-01f, -1.90235197e-03f, 1.10550389e-01f,
  -1.08789369e-01f, 2.17066154e-01f, 1.92499638e-01f, 1.04831509e-01f, 9.19119492e-02f, -1.49015844e-01f, -1.25722304e-01f, -1.68193802e-02f, -9.86952037e-02f, 1.35269850e-01f,
  -1.64831765e-02f, 7.79141039e-02f, 1.19206674e-01f, 2.15761848e-02f, 5.74784242e-02f, 2.11938731e-02f, 1.07429415e-01f, -1.46157360e-02f, 6.53545856e-02f, 2.36351237e-01f,
  -2.16776013e-01f, 1.49490610e-01f, 7.25536495e-02f, 1.57216154e-02f, 1.70477942e-01f, 9.92106125e-02f, -9.85043272e-02f, 8.34227428e-02f, -4.99833860e-02f, 1.26225278e-01f,
  -2.66954184e-01f, 5.78978285e-02f, -1.66216552e-01f, -4.18451764e-02f, -1.11215293e-01f, -3.78150940e-02f, -7.55842030e-02f, 9.17520225e-02f, -7.51369894e-02f, -8.85165483e-02f,
  3.64570022e-02f, -4.29744124e-02f, -1.53119981e-01f, 1.40742883e-01f, 1.89118952e-01f, -2.42331647e-03f, -1.20348707e-01f, 8.91357735e-02f, -6.59047812e-02f, -1.88761409e-02f,
  6.29558577e-04f, 3.84735093e-02f, -9.14653689e-02f, 1.87064320e-01f, -1.84635773e-01f, 5.25444038e-02f, -1.27447292e-01f, 2.20469069e-02f, 2.44863909e-02f, 1.30231306e-01f,
  6.73335791e-02f, -8.93144235e-02f, 7.68298805e-02f, 7.37621784e-02f, -3.25235911e-02f, -9.03055444e-02f, -7.40771443e-02f, -2.64833122e-01f, 1.88525856e-01f, 1.52547717e-01f,
  7.66679412e-03f, 9.83903781e-02f, 4.04948741e-02f, -2.17782602e-01f, -2.52683256e-02f, 1.38592452e-01f, -1.91410743e-02f, -4.88508940e-02f, 1.37347961e-02f, -2.59020239e-01f,
  -6.81872666e-03f, -9.21470597e-02f, -1.37054652e-01f, -2.76338935e-01f, 4.99606840e-02f, -1.56279504e-01f, 9.40616578e-02f, -1.44184694e-01f, 1.77915901e-01f, 2.10985709e-02f,
  3.22084920e-03f, -1.22557759e-01f, -9.84992385e-02f, -1.26238316e-01f, 2.74856240e-01f, -8.25200155e-02f, 1.55657798e-01f, -3.78865451e-02f, 1.50865614e-01f, -1.10467905e-02f,
  -1.17749069e-02f, -3.62439528e-02f, 8.27610046e-02f, 3.80276591e-02f, 1.06346875e-01f, 7.20062107e-03f, -1.80659130e-01f, 1.02028482e-01f, 4.30608951e-02f, -6.99947029e-02f,
  -2.47293562e-02f, -2.51471698e-02f, -2.48184383e-01f, -7.19395876e-02f, -1.70434378e-02f, 1.01494081e-02f, 6.92879185e-02f, 1.17019422e-01f, -7.36569390e-02f, -1.23744316e-01f,
  8.89359713e-02f, -1.51190042e-01f, -1.04510725e-01f, 3.60972174e-02f, 8.72343108e-02f, -2.45600238e-01f, -1.47984490e-01f, 3.01627256e-02f, 1.23667438e-02f, 4.91366424e-02f,
  -1.61847621e-01f, -2.21606016e-01f, -1.15293890e-01f, 1.48146242e-01f, -1.17685251e-01f, -4.85503525e-02f, -1.54310629e-01f, -7.77452067e-02f, -2.54270379e-02f, 4.62126397e-02f,
  7.95173794e-02f, -4.19730544e-02f, 1.52329728e-01f, -1.92075685e-01f, 1.30798399e-01f, 4.47407402e-02f, -1.76488906e-01f, 3.35225947e-02f, -1.28238037e-01f, -1.48074746e-01f,
  4.91097383e-02f, 6.17568642e-02f, 1.59257293e-01f, 3.02121639e-01f, 1.37913883e-01f, -6.61405846e-02f, -9.12778005e-02f, -1.48439601e-01f, 7.14730993e-02f, -4.66123223e-02f,
  2.24738628e-01f, 9.54223052e-02f, 8.01519901e-02f, 8.05103499e-03f, -3.47004198e-02f, 5.40570468e-02f, 1.08028218e-01f, 1.48956827e-03f, 4.03071120e-02f, -1.88580174e-02f,
  -2.70239681e-01f, 1.35899693e-01f, -4.18914147e-02f, 1.40430495e-01f, 1.10575110e-01f, 8.31546485e-02f, -2.24713013e-01f, 1.16906583e-01f, 4.20349315e-02f, -1.50170088e-01f,
  1.16779454e-01f, 2.26910725e-01f, -1.11283347e-01f, -1.14965066e-02f, 6.92992881e-02f, -8.19661375e-03f, 4.66684364e-02f, 9.18387547e-02f, -2.68900320e-02f, -5.32222651e-02f,
  -1.77386686e-01f, -4.61263768e-02f, -1.49217220e-02f, 1.48165882e-01f, -6.96386769e-02f, -9.30267572e-02f, -1.16152301e-01f, 1.28087491e-01f, -6.47804663e-02f, -1.85757782e-02f,
  -1.11411132e-01f, 8.39881971e-02f, 5.44729158e-02f, 1.77702054e-01f, -1.83122158e-02f, -3.22643109e-02f, -5.76259270e-02f, 2.36358177e-02f, 2.21277088e-01f, 3.61966342e-02f,
  9.49183665e-03f, 1.86591908e-01f, -2.61767536e-01f, -1.53712407e-01f, 1.42451435e-01f, 1.51407331e-01f, -9.38921142e-03f, 9.62421745e-02f, 5.49220778e-02f, -1.72739416e-01f,
  -1.13833621e-01f, 8.71046484e-02f, -7.25169480e-02f, -4.04242165e-02f, 2.02694833e-01f, -3.26539623e-03f, 9.20588672e-02f, 4.99470122e-02f, -1.23224020e-01f, -5.03040990e-03f,
  1.14276357e-01f, -3.01418938e-02f, -1.43869013e-01f, -9.87096205e-02f, -2.40420535e-01f, 4.75137569e-02f, -4.20265384e-02f, 6.87179267e-02f, -4.15351316e-02f, 7.28571117e-02f,
  -3.04988742e-01f, 9.21023265e-02f, 7.74982944e-02f, 6.34594308e-03f, 1.64188027e-01f, 1.82428971e-01f, 5.88188916e-02f, 4.68997546e-02f, -3.34919989e-02f, 5.56082204e-02f,
  6.98063076e-02f, -2.04805844e-02f, 1.60323121e-02f, -8.48917216e-02f, -2.66758174e-01f, 5.81823140e-02f, -4.16013896e-02f, -4.31272425e-02f, -3.04156239e-03f, -4.90536541e-02f,
  -1.25992641e-01f, 3.66822779e-02f, 4.81000133e-02f, 9.14204493e-02f, -1.25872076e-01f, 4.60983403e-02f, -9.52938348e-02f, -8.21233243e-02f, -3.46868634e-02f, 1.19143941e-01f,
  1.50498986e-01f, 4.99603748e-02f, 1.48230031e-01f, 2.50113934e-01f, -1.44868970e-01f, 1.94517851e-01f, -1.42816976e-01f, -1.39896587e-01f, 1.57252885e-03f, 1.90857083e-01f,
  -8.02703016e-03f, 2.21387669e-01f, 6.71634153e-02f, -8.17623809e-02f, 4.80022840e-02f, -2.87440550e-02f, -2.85496950e-01f, 1.33649617e-01f, 3.63113917e-02f, -1.25569142e-02f,
  1.12136848e-01f, 1.21299691e-01f, 7.51149058e-02f, -1.34965688e-01f, 9.63927805e-03f, -7.62447342e-02f, 5.77171333e-02f, 4.85684611e-02f, -1.12716734e-01f, -6.22306094e-02f,
  1.17561840e-01f, -1.25763029e-01f, -8.59619081e-02f, -6.80615455e-02f, 2.14059964e-01f, -1.95322596e-02f, -1.15547255e-01f, 7.54689425e-02f, -1.20739438e-01f, -1.18459888e-01f,
  7.26000741e-02f, -8.70436430e-02f, -7.18633235e-02f, 1.36362612e-01f, -7.09135309e-02f, -4.29883860e-02f, -8.67911726e-02f, 4.91020866e-02f, -2.39650663e-02f, -6.71110004e-02f,
  -3.50538008e-02f, -1.29159205e-02f, 8.73772725e-02f, -3.04447729e-02f, 9.19432193e-02f, 8.64560530e-02f, 1.39372602e-01f, -1.18422061e-02f, 1.74737081e-01f, -8.35704803e-02f,
  -8.46639648e-02f, -1.16201937e-01f, -1.16962932e-01f, -1.22026078e-01f, 5.35649173e-02f, 7.70001113e-03f, -1.06520951e-01f, -1.11983374e-01f, -7.16867894e-02f, -2.57451925e-02f,
  3.53030786e-02f, -4.35163938e-02f, -1.72748744e-01f, 1.22886762e-01f, 1.16909452e-01f, -1.44696772e-01f, 1.60402775e-01f, 1.53476164e-01f, 1.39252484e-01f, -4.51330990e-02f,
  1.16243653e-01f, 7.78738633e-02f, 9.28417519e-02f, 1.01219811e-01f, -1.65766194e-01f, -1.95285417e-02f, 1.68093462e-02f, -8.76496881e-02f, 4.24217656e-02f, -1.04309199e-02f,
  4.10142355e-02f, 4.74175550e-02f, 9.94230360e-02f, 1.24578655e-01f, 6.82485569e-03f, -6.62596598e-02f, 1.02656953e-01f, 6.93616569e-02f, 1.06654577e-01f, 1.31793827e-01f,
  1.30711794e-01f, 2.21241087e-01f, 8.91131610e-02f, 5.37212864e-02f, 1.82824194e-01f, -4.10972685e-02f, -2.25116573e-02f, 1.32352725e-01f, 9.90660638e-02f, 1.76666245e-01f,
  -6.44767582e-02f, 2.62419969e-01f, 5.70832342e-02f, -1.29573382e-02f, 1.23455204e-01f, 5.00015132e-02f, -1.74464826e-02f, 2.22423211e-01f, 1.76342681e-01f, 8.95317048e-02f,
  1.04582988e-01f, -6.88327327e-02f, 5.71219139e-02f, 3.16564322e-01f, 6.47214055e-02f, 9.07859951e-02f, -9.16022211e-02f, 7.76931792e-02f, -1.62947044e-01f, 9.35878456e-02f,
  5.87325841e-02f, -2.68063128e-01f, -1.87637880e-02f, 4.60637622e-02f, 9.27493498e-02f, -3.79217528e-02f, -1.85183436e-01f, -1.16758727e-01f, 9.42076221e-02f, -5.19855581e-02f,
  -2.81596147e-02f, 1.33758798e-01f, 8.10572878e-02f, -9.79334861e-02f, 2.23997951e-01f, 6.35428950e-02f, -1.37148663e-01f, 7.10094124e-02f, 1.82506058e-03f, 4.23887931e-02f,
  -6.95144944e-03f, -6.79604039e-02f, -5.65948077e-02f, 4.58379127e-02f, -8.09424371e-02f, 1.39415875e-04f, -9.25538540e-02f, 1.30919099e-01f, -2.44517867e-02f, -8.48554298e-02f,
  7.43734324e-03f, -8.77569467e-02f, -1.92610323e-01f, 7.57540837e-02f, 1.07628256e-01f, 1.41544258e-02f, 7.04412684e-02f, -2.13151351e-01f, -5.20030744e-02f, -1.45021882e-02f,
  6.79917783e-02f, -3.25901546e-02f, -1.14186965e-01f, -6.89728409e-02f, -1.17151566e-01f, -1.77941576e-01f, 5.61787151e-02f, 2.02492729e-01f, 1.84631169e-01f, 1.47997275e-01f,
  3.25120911e-02f, 1.60501748e-01f, -1.62129432e-01f, 4.03813720e-02f, 1.35789871e-01f, 4.10605036e-03f, 1.04039818e-01f, 1.70427755e-01f, -1.49536774e-01f, -6.29401058e-02f,
  7.37757161e-02f, -2.09908560e-02f, -1.11257389e-01f, 1.99557841e-01f, -9.80446562e-02f, 1.70971587e-01f, 7.52615780e-02f, 4.87284027e-02f, 1.95227012e-01f, 1.03210002e-01f,
  2.40345132e-02f, -4.66597220e-03f, -2.06356511e-01f, -1.56912487e-04f, 7.75946230e-02f, 1.44919619e-01f, 8.01384740e-04f, 8.75109136e-02f, -1.88866071e-02f, -1.05590746e-01f,
  -5.35080023e-03f, 8.86295885e-02f, 5.20902388e-02f, 4.08452675e-02f, 4.35262099e-02f, 8.63359720e-02f, 4.91040433e-03f, -6.08988069e-02f, -1.92887220e-03f, 3.20816636e-02f,
  -1.13708815e-02f, 1.85550749e-02f, 2.95198150e-02f, 1.54211745e-01f, -7.61955380e-02f, 1.39917240e-01f, 2.66235709e-01f, 8.57982039e-02f, 1.33694112e-01f, 1.12923399e-01f,
  -8.38239864e-02f, -6.25439286e-02f, 1.28717750e-01f, 1.13701686e-01f, -7.16349036e-02f, -6.87702522e-02f, 1.24450415e-01f, 3.11770998e-02f, 7.59113953e-02f, 3.30860883e-01f,
  -5.89402346e-03f, -7.80047327e-02f, 7.78482929e-02f, 4.82348017e-02f, 1.37550116e-01f, -5.76600470e-02f, 2.18430191e-01f, 3.12049836e-02f, 4.87490743e-02f, 1.14482395e-01f,
  -2.63267625e-02f, 1.09909780e-01f, 2.25207701e-01f, 7.80189969e-03f, -1.16852209e-01f, -1.20324679e-01f, 2.62278300e-02f, -6.22722879e-02f, -8.91360454e-03f, -2.36377805e-01f,
  2.26099104e-01f, -2.81459615e-02f, -1.74819991e-01f, 2.00043917e-02f, -2.21176654e-01f, -1.70546576e-01f, 1.61248580e-01f, -1.56376779e-01f, -3.51642519e-02f, -1.18495211e-01f,
  1.55206667e-02f, 8.86201337e-02f, 1.50410622e-01f, -2.66208667e-02f, -6.46594092e-02f, -8.49745125e-02f, 1.42280583e-03f, 6.34356365e-02f, -1.33372307e-01f, 9.70653296e-02f,
  3.81871462e-02f, 1.44540495e-03f, -9.51928198e-02f, -6.15831874e-02f, -2.91230649e-01f, 1.41037717e-01f, 8.88812449e-03f, 1.76451355e-01f, 8.52758903e-03f, 5.26250415e-02f,
  -2.89422184e-01f, 1.04766883e-01f, 1.06385695e-02f, 8.22889060e-03f, 2.17248112e-01f, 1.04419917e-01f, -1.11094162e-01f, 5.97552471e-02f, 1.05546549e-01f, 7.57972337e-03f,
  -6.96804449e-02f, -7.48313665e-02f, -9.72672030e-02f, 1.68526713e-02f, -1.61090389e-01f, 1.99195500e-02f, -1.74186110e-01f, 1.33771703e-01f, 4.13867384e-02f, 6.09657504e-02f,
  1.00053705e-01f, 3.06546944e-03f, -5.86235756e-03f, 5.63353784e-02f, -1.68849364e-01f, 2.37764139e-02f, -1.25480980e-01f, 6.20585447e-03f, -8.67044926e-02f, 4.44937870e-02f,
  1.96412444e-01f, 1.17860094e-01f, 2.69150198e-01f, 8.12392458e-02f, 9.18865204e-02f, 1.33253053e-01f, -1.41504064e-01f, -1.32744133e-01f, 1.41543761e-01f, -5.59410863e-02f,
  -1.09797470e-01f, -3.78649756e-02f, -1.65463433e-01f, -9.12780240e-02f, -4.06105556e-02f, -5.00795580e-02f, -2.59817183e-01f, 1.33971453e-01f, 8.70873481e-02f, 9.25365239e-02f,
  1.71403661e-01f, 5.97222596e-02f, 1.23866439e-01f, 6.02991208e-02f, -1.19727045e-01f, -1.74717996e-02f, -3.44571769e-02f, -1.00405492e-01f, -8.05967674e-02f, -6.33925498e-02f,
  3.54505442e-02f, 8.56338963e-02f, -7.09029734e-02f, -3.41651887e-02f, -2.53914654e-01f, -1.56325419e-02f, 1.73449684e-02f, -4.17832052e-04f, -9.53846201e-02f, 3.04049402e-02f,
  -4.13208082e-02f, -4.85063680e-02f, 5.40853515e-02f, 1.61849614e-03f, 4.87544797e-02f, -2.95538474e-02f, -6.18194193e-02f, -3.27681333e-01f, 6.49055019e-02f, 4.89734486e-02f,
  -3.54197398e-02f, -9.26326811e-02f, -1.54165342e-01f, -2.14204505e-01f, 2.45592892e-02f, 1.82751287e-02f, 3.02922800e-02f, 3.47247571e-02f, 1.23892769e-01f, -1.96053863e-01f,
  -2.95198224e-02f, 1.12973481e-01f, -8.32155645e-02f, 3.41615193e-02f, -1.28434762e-01f, -1.37416437e-01f, -1.62401535e-02f, 1.36887655e-01f, 2.79336125e-02f, -1.46866858e-01f,
  -5.72518148e-02f, 6.59851544e-03f, 7.56381974e-02f, -1.18540272e-01f, -1.19243935e-01f, 2.93292463e-01f, -1.65793132e-02f, -1.40345633e-01f, 4.60984232e-03f, -1.94387659e-01f,
  3.13561298e-02f, -3.90869044e-02f, 1.80418491e-01f, -8.24715570e-02f, 6.65758476e-02f, 9.31374058e-02f, 5.00357151e-02f, -9.29499697e-03f, 4.54523116e-02f, -2.06610952e-02f,
  -8.04749802e-02f, -1.12052843e-01f, 6.29706234e-02f, -1.54141530e-01f, -7.94989243e-03f, -1.58279613e-01f, -2.07531154e-01f, -1.13988563e-01f, -4.94516417e-02f, -7.84093812e-02f,
  -8.00379440e-02f, 2.58334335e-02f, -2.60198355e-01f, -1.43785849e-01f, -8.85491073e-02f, 1.32644717e-02f, 1.15532599e-01f, -6.53585326e-03f, 4.05463204e-02f, 1.37149990e-01f,
  -2.58402433e-02f, -5.44756688e-02f, 1.12012342e-01f, -9.20380652e-02f, 2.29806811e-01f, -1.60740539e-02f, -1.45607546e-01f, 1.08048461e-01f, -2.77453568e-02f, -3.43016200e-02f,
  4.23134305e-02f, -4.33739908e-02f, 1.27320915e-01f, -8.26632082e-02f, 1.27390936e-01f, -4.97772433e-02f, -5.04491180e-02f, 5.85248927e-03f, 1.08442083e-02f, 9.06514302e-02f,
  -1.90993160e-01f, 1.90653838e-02f, -5.81799746e-02f, -1.14452869e-01f, 2.22682044e-01f, -1.82577055e-02f, -5.79020269e-02f, -1.78247243e-01f, -8.27833191e-02f, 9.19931456e-02f,
  8.40806589e-03f, 1.68887347e-01f, 1.21849133e-02f, -1.20062798e-01f, 2.03723580e-01f, -1.12607516e-01f, 1.07174903e-01f, 1.34270266e-01f, -5.18056080e-02f, 5.28307967e-02f,
  2.75519937e-02f, 1.28072828e-01f, -8.91620293e-02f, 3.21394019e-02f, 6.49374910e-03f, -1.25150084e-02f, 4.06069718e-02f, 1.20320972e-02f, -1.23180039e-01f, -5.58449179e-02f,
  9.17203799e-02f, 1.34504557e-01f, 1.33117452e-01f, -1.56970564e-02f, 1.24445915e-01f, -1.09494291e-01f, -1.11930437e-01f, 7.74438307e-02f, 5.04480265e-02f, 1.54257715e-01f,
  1.20162174e-01f, -8.52980465e-02f, -1.36212632e-01f, -1.84181020e-01f, 1.25691548e-01f, 2.40772501e-01f, 8.11309442e-02f, -7.98860192e-02f, 1.20053910e-01f, 9.18708183e-03f,
  5.08230217e-02f, 3.28334607e-02f, -9.58831906e-02f, -1.18782796e-01f, -4.16017808e-02f, -1.37323022e-01f, 2.53499560e-02f, 8.54650587e-02f, 6.50725001e-03f, -2.01851219e-01f,
  1.24992333e-01f, -7.76458308e-02f, 1.16129011e-01f, 1.48333579e-01f, -8.34148824e-02f, 4.41027246e-03f, 1.97692201e-01f, 2.74829026e-02f, -9.06161070e-02f, 2.23904893e-01f,
  1.16915189e-01f, -1.87172480e-02f, -1.35288000e-01f, -2.03363121e-01f, -1.48304477e-01f, 7.54607888e-03f, 3.37077491e-02f, 1.95939437e-01f, -1.85990244e-01f, -2.14366782e-02f,
  -1.18186250e-01f, -5.61992414e-02f, -3.83927189e-02f, 1.60394982e-02f, 3.65786105e-02f, -7.75005727e-04f, 4.13283482e-02f, -3.06704193e-02f, 5.55168800e-02f, -1.85605288e-02f,
  1.13753766e-01f, 4.26954515e-02f, 1.40827715e-01f, 3.25543284e-02f, -7.84190223e-02f, -3.10240574e-02f, 1.26552179e-01f, 3.88360433e-02f, 8.89149010e-02f, -1.46614492e-01f,
  -1.36681274e-01f, 2.04620913e-01f, -1.63931176e-01f, -3.36719193e-02f, -3.83408554e-02f, -1.01786889e-02f, 4.56220210e-02f, 1.03680402e-01f, 2.18246821e-02f, 2.77734250e-01f,
  1.15073420e-01f, -8.69633853e-02f, -1.27547467e-02f, -6.12377785e-02f, -8.69382843e-02f, -2.68292308e-01f, 2.86935598e-01f, 1.71672955e-01f, 5.33645526e-02f, -7.99165741e-02f,
  1.21540576e-02f, 4.27334160e-02f, 1.43951863e-01f, 1.18903846e-01f, -3.14544812e-02f, -4.63119000e-02f, 9.89346132e-02f, -2.71313339e-01f, -6.75339252e-02f, -2.31888026e-01f,
  -2.77562384e-02f, -2.18551718e-02f, -2.20282048e-01f, 1.38616860e-01f, 9.01306421e-02f, -1.26101241e-01f, 1.02677405e-01f, -5.91023965e-03f, -1.38681754e-01f, -2.96923637e-01f,
  4.63107936e-02f, 6.55098259e-02f, -6.27116486e-02f, -1.12074330e-01f, -1.65542215e-01f, -1.04207620e-01f, 1.49333522e-01f, -1.65224615e-02f, -4.02265508e-03f, -8.73154849e-02f,
  -8.19095373e-02f, -2.56155655e-02f, -8.75352100e-02f, 7.49078691e-02f, 9.64949951e-02f, 3.43939215e-02f, 1.53679341e-01f, 4.45487201e-02f, 1.88566521e-01f, 9.54813063e-02f,
  -6.30890811e-03f, 1.54855192e-01f, -5.15075065e-02f, -2.18825918e-02f, 7.37277344e-02f, 1.53023750e-02f, -8.57311860e-02f, 4.82437909e-02f, 9.36524868e-02f, -4.38928977e-02f,
  8.27263668e-02f, 8.82037729e-02f, 8.56474191e-02f, 1.95092902e-01f, 1.44571349e-01f, 4.90390398e-02f, -1.29563451e-01f, 1.47588447e-01f, -8.13931748e-02f, -1.62501723e-01f,
  1.16400503e-01f, -6.06854595e-02f, 5.21903187e-02f, -1.78303737e-02f, -1.06101684e-01f, -3.18646245e-02f, -6.20085222e-04f, 4.51740436e-02f, 1.30109504e-01f, -4.57163574e-03f,
  1.57771111e-02f, -1.09748639e-01f, -6.78345263e-02f, -5.98920807e-02f, 5.64974099e-02f, -7.46439863e-03f, -2.14169323e-01f, 1.74408540e-01f, 1.18440777e-01f, -1.19112739e-02f,
  3.16956490e-02f, 8.53461474e-02f, -1.19231440e-01f, -1.55483574e-01f, 5.94998933e-02f, 1.96738720e-01f, -6.48060590e-02f, 7.76208043e-02f, -1.10559084e-01f, 6.79760650e-02f,
  1.34003693e-02f, -1.68649592e-02f, -3.44390720e-02f, 1.06071360e-01f, -2.64643542e-02f, 7.41471872e-02f, -1.21957744e-02f, 1.25618145e-01f, 2.33148202e-01f, 4.42937650e-02f,
  1.53346315e-01f, 9.04357731e-02f, -1.61830485e-02f, 9.20914635e-02f, 1.86295807e-01f, -3.70672122e-02f, 8.88373107e-02f, 1.26255170e-01f, 8.79587084e-02f, 9.08844266e-03f,
  1.07505560e-01f, -6.23988621e-02f, -2.14713022e-01f, 5.26592275e-03f, -4.06984538e-02f, 6.04580417e-02f, -5.21109663e-02f, 4.10772622e-01f, 2.26376563e-01f, -1.09016344e-01f,
  -1.79356098e-01f, -1.23478107e-01f, 3.16889286e-02f, -2.08032075e-02f, 1.62907615e-01f, -2.65683327e-02f, 6.13621771e-02f, 1.54956402e-02f, -1.09414190e-01f, 2.81498224e-01f,
  1.02333210e-01f, 2.24093199e-02f, -1.03216553e-02f, 2.81373803e-02f, 9.40796658e-02f, -5.58772050e-02f, -1.37314990e-01f, -2.71209985e-01f, 7.31519610e-02f, -3.05390432e-02f,
  -2.49696583e-01f, 1.26190171e-01f, -1.86360911e-01f, 2.77798623e-02f, -1.09878043e-02f, -1.42112881e-01f, 6.03688918e-02f, -1.05868429e-01f, -5.53085469e-02f, -6.61864281e-02f,
  6.08243607e-02f, -8.44924375e-02f, -8.16986114e-02f, -1.10953441e-02f, -1.88369259e-01f, -2.40622200e-02f, -1.46001026e-01f, 1.08889371e-01f, 1.29485205e-01f, 1.36887074e-01f,
  7.22178221e-02f, -2.31791772e-02f, 5.70862032e-02f, 1.06799491e-01f, 7.85770640e-02f, -8.70563462e-02f, 3.58593240e-02f, 5.40092252e-02f, 2.22951248e-01f, 3.07192355e-02f,
  -3.47900987e-02f, 1.73249960e-01f, 1.47339210e-01f, -1.22853808e-01f, 1.20105334e-01f, 9.32942033e-02f, -5.49313799e-02f, 9.44757089e-02f, 5.44008203e-02f, -6.88379034e-02f,
  1.04895614e-01f, 3.08994502e-01f, 1.52901774e-02f, -4.50938083e-02f, 1.05996080e-01f, 3.74351069e-02f, -2.47177836e-02f, 1.81848705e-01f, -1.18404366e-01f, -1.98667198e-01f,
  1.32554084e-01f, 4.13218737e-02f, 1.88449621e-01f, 2.28283480e-01f, 1.07656226e-01f, -4.29334939e-02f, -1.69221908e-01f, 1.06970564e-01f, -9.98556241e-02f, 2.21391156e-01f,
  1.76744565e-01f, 7.11998111e-03f, 1.38134167e-01f, 3.66488360e-02f, 1.12068266e-01f, 1.11684196e-01f, 3.72331254e-02f, 5.13060614e-02f, -6.64060116e-02f, -2.27330700e-01f,
  -1.04210861e-01f, 3.22005570e-01f, -2.83848792e-02f, -7.85369128e-02f, -1.32878900e-01f, 4.24506068e-02f, -1.85606301e-01f, -4.39022668e-02f, -1.19826816e-01f, -3.04681920e-02f
};

// L3_fan_Wp_bar (Shape: 14 x 64)
const int L3_fan_Wp_bar_rows = 14;
const int L3_fan_Wp_bar_cols = 64;
const float L3_fan_Wp_bar_data[] = {
  -1.31462902e-01f, 7.34512061e-02f, 1.87644824e-01f, 1.06093749e-01f, 6.75756559e-02f, 6.29636347e-02f, 5.50647005e-02f, -1.73469968e-02f, 2.34598145e-02f, -1.27132293e-02f,
  3.11277032e-01f, 1.73947781e-01f, 4.18842249e-02f, 1.34712666e-01f, 2.11686984e-01f, 1.67778194e-01f, 1.04399081e-02f, 1.63124084e-01f, -5.50316535e-02f, 6.03313670e-02f,
  1.53119713e-01f, 2.02472687e-01f, 7.14726746e-02f, 6.40521944e-02f, 3.78738753e-02f, 3.79687428e-01f, 1.28998086e-01f, -4.05267477e-02f, -1.85884789e-01f, 1.50298893e-01f,
  4.43449989e-02f, 5.51996194e-02f, 6.37895102e-03f, -2.99041392e-03f, -8.49331096e-02f, 5.58368443e-03f, -1.00201011e-01f, 1.93295226e-01f, 3.85781825e-02f, -8.56340975e-02f,
  1.06214821e-01f, -5.21869883e-02f, 1.37924068e-02f, -2.10511535e-02f, -7.82777816e-02f, -2.24701628e-01f, 2.26973653e-01f, 2.87749972e-02f, -2.13303640e-01f, 2.69378573e-01f,
  7.84321427e-02f, 7.71967620e-02f, 2.44739562e-01f, -1.36075988e-02f, 7.08068386e-02f, -6.45717606e-02f, -8.82735848e-02f, 3.04994822e-01f, -8.63375217e-02f, 8.53306651e-02f,
  -1.94464341e-01f, 1.39516243e-03f, -2.06415020e-02f, 8.95855501e-02f, 1.53503343e-01f, 2.88610086e-02f, 1.61678672e-01f, -9.57428105e-03f, 2.25283593e-01f, 1.13201529e-01f,
  -1.24956127e-02f, 7.54447877e-02f, 1.67141885e-01f, -3.19012627e-02f, -2.71499418e-02f, 1.30949751e-01f, 1.91099253e-02f, -8.24277550e-02f, 2.80313864e-02f, 1.71473026e-01f,
  -5.86114861e-02f, 2.62394577e-01f, -5.91585934e-02f, 7.77875260e-02f, -1.23822473e-01f, 1.51076972e-01f, 2.14526266e-01f, 4.31985110e-02f, 9.21973139e-02f, -1.27039835e-01f,
  2.70207338e-02f, -7.27321655e-02f, -8.31694677e-02f, -1.62828863e-01f, -1.16700009e-01f, 9.62093007e-03f, 2.46353477e-01f, -5.76316379e-02f, 8.65027308e-02f, 9.28799435e-02f,
  -1.22113511e-01f, 6.01379350e-02f, 8.45015496e-02f, 1.15261838e-01f, 3.07968706e-02f, 1.78065505e-02f, -6.81261271e-02f, -2.26772323e-01f, -9.83126387e-02f, -2.12450132e-01f,
  -1.29032865e-01f, -2.75196761e-01f, -1.76619425e-01f, -1.19325265e-01f, -6.40019849e-02f, 5.09892143e-02f, 3.04445267e-01f, 1.28663421e-01f, 3.34332027e-02f, -4.21241708e-02f,
  3.22886668e-02f, -8.02517086e-02f, 2.09009737e-01f, -7.87264556e-02f, 2.73005247e-01f, 1.28068998e-01f, 1.46802828e-01f, 5.75253600e-03f, 1.20267719e-01f, -5.39359152e-02f,
  8.84421021e-02f, -4.48451489e-02f, -1.56519283e-02f, -9.28312447e-03f, -5.50145395e-02f, 2.94913650e-02f, 6.02938049e-03f, -8.53630602e-02f, 9.78251100e-02f, -5.42170089e-03f,
  1.24254540e-01f, -1.04195066e-01f, -1.11181557e-01f, -1.15240864e-01f, -1.24035001e-01f, -3.00308019e-02f, -1.08686887e-01f, -1.01954630e-02f, -1.00188471e-01f, 1.17968202e-01f,
  8.42464063e-03f, -6.14848919e-02f, -1.09835215e-01f, 9.58403572e-03f, 6.95317611e-02f, -1.74491201e-02f, -5.47858924e-02f, -1.23943962e-01f, -2.85166763e-02f, -1.05159871e-01f,
  9.92305577e-02f, 6.78169355e-02f, -9.22535136e-02f, -6.75461069e-02f, -5.23817539e-02f, -7.51190558e-02f, 1.01376347e-01f, -8.94480571e-02f, -4.11480628e-02f, 7.81453550e-02f,
  -1.07940868e-01f, -9.12236422e-02f, -4.66986336e-02f, -1.04386687e-01f, -6.60615489e-02f, 4.19117026e-02f, 6.37190267e-02f, 1.37675211e-01f, 3.08723170e-02f, 5.52082341e-03f,
  1.08624689e-01f, 8.43014419e-02f, 1.28973827e-01f, 5.32239415e-02f, 1.66416001e-02f, 1.27656057e-01f, 3.17298286e-02f, 6.20365292e-02f, -3.35796215e-02f, 1.14060871e-01f,
  -5.18477932e-02f, 8.48478526e-02f, 8.22002739e-02f, 7.88185000e-02f, -3.47837843e-02f, 5.16463257e-02f, -9.26924348e-02f, -7.28695393e-02f, 2.35520620e-02f, -1.88641734e-02f,
  3.65159884e-02f, -1.05548002e-01f, -5.08694202e-02f, 2.24925522e-02f, -1.11250624e-01f, 2.81972643e-02f, 2.65023094e-02f, -3.45352255e-02f, -9.50167626e-02f, -1.43742114e-01f,
  1.51385292e-02f, -1.18754573e-01f, 6.82244152e-02f, 2.24631447e-02f, 1.15606599e-01f, -1.25655442e-01f, -4.33476605e-02f, -5.75635731e-02f, -8.14156756e-02f, -9.87504870e-02f,
  -1.94850750e-02f, -3.91059294e-02f, -4.75630797e-02f, 3.37988064e-02f, 3.06023695e-02f, 1.01916008e-02f, -1.04267806e-01f, 5.74285015e-02f, 1.08006395e-01f, -7.92238563e-02f,
  -8.26287642e-02f, 7.03239301e-03f, -8.17331523e-02f, -2.35805660e-02f, -7.22146407e-02f, 4.89518903e-02f, 7.44976327e-02f, 1.38507979e-02f, -5.23908027e-02f, -1.05250739e-01f,
  2.93390099e-02f, 1.90581717e-02f, -7.38049224e-02f, 5.28110005e-02f, 3.39071974e-02f, 2.80086156e-02f, 8.44649505e-03f, 1.85658664e-01f, 8.17663819e-02f, 2.31811125e-02f,
  9.18121040e-02f, -6.62304163e-02f, 6.84102774e-02f, 5.25240712e-02f, 5.12144044e-02f, -4.41486426e-02f, 7.52432048e-02f, 1.28193647e-01f, -4.32776473e-02f, -6.16142415e-02f,
  -7.01460317e-02f, -3.56856734e-02f, 4.12363186e-02f, 2.02541798e-02f, -4.11697067e-02f, 2.13624928e-02f, -9.02209133e-02f, 1.30194560e-01f, 7.09074363e-02f, 8.92905146e-02f,
  -3.16574462e-02f, 4.38032709e-02f, 1.49411872e-01f, 1.36539727e-01f, -3.53198801e-03f, 1.11509986e-01f, -1.59503475e-01f, 1.11061022e-01f, 1.10017516e-01f, -7.44665489e-02f,
  -5.41275963e-02f, 6.84419274e-02f, 9.74780414e-03f, -7.29827136e-02f, -1.02402776e-01f, -6.80700317e-02f, 7.07210153e-02f, -5.78426942e-02f, 2.01519936e-01f, -7.54471170e-03f,
  -9.41576958e-02f, 5.80629781e-02f, 4.02215160e-02f, 1.01315439e-01f, 3.75344045e-02f, -7.98645765e-02f, 1.14653632e-01f, -8.02411214e-02f, 3.40221152e-02f, -1.05047271e-01f,
  -8.33365694e-03f, -1.95374340e-01f, 1.24467514e-01f, -8.67804438e-02f, -1.13709256e-01f, -1.16986297e-01f, 4.96226139e-02f, -1.49871394e-01f, -2.40277965e-02f, 4.98322770e-02f,
  1.20370448e-01f, 5.33091053e-02f, -7.96052534e-03f, 2.08377908e-03f, 1.09577827e-01f, 7.39910528e-02f, -9.03014615e-02f, -2.63492158e-03f, 1.15747862e-02f, -5.34113403e-03f,
  -1.18196271e-02f, 2.69599073e-02f, -8.72283578e-02f, 5.89350797e-02f, -8.57636258e-02f, -5.10802679e-02f, -1.48821250e-01f, -2.84874272e-02f, 4.32138368e-02f, -1.85538642e-02f,
  1.23585582e-01f, -7.14665800e-02f, -1.31025091e-01f, 8.15546811e-02f, 5.44524379e-02f, -1.77484155e-02f, 3.57555635e-02f, 6.53741881e-02f, -7.10928217e-02f, 9.01915953e-02f,
  -6.03354350e-03f, -5.23443669e-02f, 1.13976322e-01f, 1.21581465e-01f, 9.20251980e-02f, -8.04132447e-02f, 1.86097100e-01f, 5.07190675e-02f, -5.85773177e-02f, 1.01803511e-01f,
  -2.94896737e-02f, -8.44793990e-02f, 1.22366548e-01f, 4.69483697e-04f, -8.94221589e-02f, -3.48597988e-02f, -1.12104521e-03f, 1.10394515e-01f, 1.16376020e-01f, -4.97309566e-02f,
  1.17522739e-01f, -5.95623255e-02f, 1.26582429e-01f, 4.02599163e-02f, 4.03623208e-02f, 6.07250072e-02f, -7.99946114e-02f, 4.60321754e-02f, 7.68356472e-02f, 1.57919973e-01f,
  6.07785732e-02f, -4.70514745e-02f, 3.71372811e-02f, 1.70261171e-02f, -4.92982715e-02f, 8.94722529e-04f, -1.78215727e-02f, 2.17048183e-01f, 1.12112559e-01f, 9.61413905e-02f,
  -1.10021234e-02f, -6.60364553e-02f, 9.57083106e-02f, 3.26510780e-02f, 3.11386809e-02f, 1.23446934e-01f, 6.92199767e-02f, -2.70026885e-02f, 4.51578759e-02f, 3.14070247e-02f,
  -1.36750430e-01f, -3.13344486e-02f, -6.81451857e-02f, 9.50066969e-02f, 8.99039283e-02f, -7.59043247e-02f, 6.76619634e-03f, 4.82825749e-02f, 3.33813892e-04f, -1.11813150e-01f,
  4.97150235e-02f, 6.59137815e-02f, -1.37221292e-01f, 1.75389424e-02f, 1.00411601e-01f, 2.61222962e-02f, 1.05533779e-01f, -1.36497080e-01f, 1.18574210e-01f, -7.45274127e-02f,
  1.19912647e-01f, -3.80230844e-02f, -1.45479944e-02f, 9.23890173e-02f, -8.57486576e-02f, -6.19349591e-02f, -9.27379206e-02f, 7.55630210e-02f, -6.25356287e-02f, 1.26139283e-01f,
  1.28440395e-01f, 3.11822500e-02f, -3.56995463e-02f, -1.48829827e-02f, 1.07314870e-01f, -7.56353140e-02f, 4.59791087e-02f, 1.99345518e-02f, -4.34409007e-02f, -1.32616028e-01f,
  3.57447304e-02f, 1.65123448e-01f, -1.11815654e-01f, 1.25929624e-01f, -8.39096308e-02f, 3.50972712e-02f, -2.43276916e-03f, -7.83545375e-02f, -6.57394677e-02f, 6.23230487e-02f,
  5.11712618e-02f, 2.00511590e-01f, -3.86888683e-02f, 6.19662106e-02f, -7.06690103e-02f, 8.80583674e-02f, -5.96564859e-02f, -6.17073178e-02f, 2.61752848e-02f, 1.81871668e-01f,
  1.52498290e-01f, 8.45440477e-02f, -6.67310953e-02f, 1.90740272e-01f, 1.22835040e-01f, 3.30201313e-02f, -9.21212137e-02f, -1.61489528e-02f, 8.40985924e-02f, -6.43748268e-02f,
  -5.16573861e-02f, 2.29502320e-02f, 9.32502672e-02f, 8.41017589e-02f, -1.22642882e-01f, -2.19273597e-01f, 2.38049641e-01f, -2.55193338e-02f, 1.74651086e-01f, 3.63387093e-02f,
  -7.44016171e-02f, 1.24360129e-01f, 1.64040849e-01f, -1.12635285e-01f, 5.76623529e-02f, -4.46765274e-02f, 2.38513276e-01f, 1.30152643e-01f, 7.67860562e-03f, 1.93751991e-01f,
  -1.71057835e-01f, -1.72526956e-01f, 1.51667237e-01f, 1.55403301e-01f, 2.52149254e-01f, -3.06754522e-02f, -1.77872628e-01f, -2.52089173e-01f, 5.60070574e-02f, -1.73817903e-01f,
  -2.53002942e-01f, 1.88343614e-01f, -1.52508676e-01f, 1.26879841e-01f, 5.29700555e-02f, 1.03521414e-01f, 2.82956213e-01f, -6.89922422e-02f, 1.86131641e-01f, 1.60562381e-01f,
  9.21152607e-02f, -2.44306270e-02f, 1.20172955e-01f, 4.77574229e-01f, 1.53407171e-01f, 2.03119032e-03f, 4.43874858e-03f, 7.30395243e-02f, 7.89930522e-02f, 7.72651061e-02f,
  -1.02735728e-01f, 4.03324999e-02f, 6.29166737e-02f, 3.57440859e-02f, 1.11427344e-01f, 1.17282830e-01f, 1.62268817e-01f, 1.14154205e-01f, 4.41663451e-02f, -7.75811300e-02f,
  2.10342743e-02f, 2.01333195e-01f, -7.81739205e-02f, 1.98030502e-01f, 6.87163919e-02f, 5.57254534e-03f, -4.90698889e-02f, 7.28272125e-02f, 1.14084065e-01f, 4.61264476e-02f,
  6.83942437e-02f, 2.19622269e-01f, 3.00292447e-02f, 2.74277832e-02f, 8.40961114e-02f, -1.04375131e-01f, 1.67005599e-01f, -1.09114759e-01f, 7.89638385e-02f, -2.94097094e-03f,
  -1.61902517e-01f, 4.60981159e-03f, 2.34686136e-02f, -1.30606651e-01f, 2.69775093e-01f, -6.83082715e-02f, -4.12204601e-02f, 9.69415903e-02f, 9.00009796e-02f, 3.00340224e-02f,
  2.48451725e-01f, 1.87771525e-02f, 7.95994028e-02f, 2.95732766e-02f, -1.34358287e-01f, -1.12314470e-01f, -1.33533180e-01f, 1.41989551e-02f, -5.61230220e-02f, -1.25461727e-01f,
  -2.16036201e-01f, -1.82040036e-01f, -1.69251814e-01f, -9.28374976e-02f, 6.18686453e-02f, -8.87256935e-02f, -9.71627757e-02f, -5.66127487e-02f, -1.30425856e-01f, -1.14058979e-01f,
  1.70719743e-01f, -9.77916643e-02f, 9.39114690e-02f, -4.33299057e-02f, -3.82058956e-02f, 6.28130659e-02f, 1.84520707e-01f, 1.48385763e-01f, -7.95840472e-02f, 1.59790620e-01f,
  -1.15345769e-01f, 1.34157851e-01f, -3.25063206e-02f, -8.72358121e-03f, -7.95013011e-02f, -3.27939652e-02f, -1.24740377e-02f, -6.24479465e-02f, -1.30820006e-01f, 1.29368737e-01f,
  -4.11007600e-03f, 5.57800047e-02f, -2.23695353e-01f, -6.70781592e-03f, 2.80742701e-02f, -9.41506994e-04f, 2.21640736e-01f, 7.84969181e-02f, 1.14988886e-01f, -2.70425640e-02f,
  1.79287121e-01f, 1.68191188e-03f, 1.67094573e-01f, 1.76902458e-01f, -4.41953167e-02f, -2.40853261e-02f, -4.61698659e-02f, 8.60399082e-02f, -1.63738057e-01f, -1.14352137e-01f,
  8.98821056e-02f, 3.15976553e-02f, -4.72935513e-02f, 1.78066958e-02f, -8.72884244e-02f, -1.12630874e-01f, 1.15566388e-01f, -2.04249844e-01f, 3.46189775e-02f, 1.12691626e-01f,
  -1.30001724e-01f, 1.22384526e-01f, -5.90702693e-04f, 7.87590072e-02f, 1.00650407e-01f, 1.51798919e-01f, 2.02011585e-01f, 9.13637206e-02f, 1.80720374e-01f, -4.68088351e-02f,
  5.12408800e-02f, -4.79911231e-02f, -6.93445057e-02f, 2.68497646e-01f, 8.42652693e-02f, 4.98313680e-02f, -1.48870274e-01f, 8.44500586e-02f, 7.62722045e-02f, -7.04699084e-02f,
  8.10909942e-02f, -9.92069319e-02f, 1.77914128e-01f, 1.89908892e-01f, -3.01590897e-02f, -9.91960764e-02f, 1.28509954e-01f, 1.67296767e-01f, 1.29326686e-01f, -1.09526344e-01f,
  -1.22874841e-01f, -1.14752755e-01f, 7.81542063e-02f, 1.51011497e-01f, 1.22698456e-01f, 1.65116176e-01f, -2.98192263e-01f, -7.66598359e-02f, -1.98048372e-02f, 2.43503950e-03f,
  8.51836130e-02f, 1.64374918e-01f, 6.21138327e-02f, 2.24009067e-01f, -6.87539577e-02f, -1.08573191e-01f, 3.49455118e-01f, 1.78542003e-01f, -1.68673787e-02f, -1.73624650e-01f,
  -6.42217398e-02f, -1.35419937e-02f, 4.29128408e-02f, 5.50363511e-02f, 1.37906969e-01f, -1.67152863e-02f, 2.00104967e-01f, -1.91396028e-01f, 4.07870822e-02f, 1.18980967e-01f,
  1.56826321e-02f, -1.78219110e-01f, -2.26975903e-01f, 5.39777949e-02f, -3.47023100e-01f, -6.55192584e-02f, -1.25093982e-01f, -2.40295425e-01f, 2.52890408e-01f, 1.64131075e-01f,
  -3.64109464e-02f, 1.54262679e-02f, 2.49909088e-01f, 1.51069164e-01f, 2.93325305e-01f, 2.60962546e-02f, 1.38710812e-02f, -1.02109835e-01f, 5.63175023e-01f, -1.66148767e-01f,
  -3.29872244e-03f, -6.74649626e-02f, 3.09695601e-02f, -1.10937685e-01f, 7.78880110e-03f, 7.19055012e-02f, 8.65209475e-02f, 7.65766650e-02f, -3.56125012e-02f, -5.00518978e-02f,
  8.21166113e-02f, 3.53993364e-02f, -3.39788152e-03f, 4.92805019e-02f, 1.58391610e-01f, -6.04791157e-02f, 1.69401556e-01f, 9.76036787e-02f, 6.92143738e-02f, -6.60493523e-02f,
  -1.51769489e-01f, 3.12555842e-02f, -1.27720274e-02f, -4.12999652e-02f, 1.50241256e-01f, 1.31560102e-01f, 3.06386389e-02f, 9.60489511e-02f, -7.26233199e-02f, 2.17449576e-01f,
  2.85908883e-03f, -1.07400931e-01f, -8.66401568e-02f, 1.44100368e-01f, 3.96517590e-02f, -7.16829151e-02f, -1.34339388e-02f, 4.78352793e-02f, 1.76053438e-02f, 4.95648831e-02f,
  1.02973290e-01f, 1.67275723e-02f, 1.31329983e-01f, -1.10258952e-01f, -1.06258109e-01f, -1.15845194e-02f, -1.59743473e-01f, 1.26390737e-02f, -1.07489839e-01f, -1.73354819e-01f,
  4.66997810e-02f, 1.15956262e-01f, 1.56674962e-02f, 8.93079024e-03f, 1.19124413e-01f, 9.95841324e-02f, -4.07335395e-03f, -1.11078270e-01f, 1.11524709e-01f, 1.33464202e-01f,
  5.78658981e-03f, 1.52229309e-01f, 1.28187269e-01f, -1.68394037e-02f, -6.94123656e-02f, -2.11157296e-02f, 6.99754432e-03f, -1.18507102e-01f, -2.89460290e-02f, 3.05975303e-02f,
  1.18605571e-03f, 1.04045831e-01f, 2.02646223e-03f, -5.27300611e-02f, -7.38353119e-05f, -4.83177714e-02f, -5.39582185e-02f, -1.11796215e-01f, 9.61845368e-03f, -5.00941910e-02f,
  2.12803364e-01f, 8.33607018e-02f, 7.62813985e-02f, 1.14311278e-03f, -2.30340287e-02f, -4.50101830e-02f, -5.90421893e-02f, -6.36620075e-02f, 7.01816678e-02f, 1.16044112e-01f,
  6.60936534e-02f, 1.58696413e-01f, -9.13545117e-02f, 1.83127925e-01f, 1.10708192e-01f, -7.46566663e-03f, 6.97234571e-02f, -3.52255404e-02f, 5.29247001e-02f, 1.55576378e-01f,
  -3.77020054e-03f, -1.01017892e-01f, 1.53205439e-01f, -5.43021820e-02f, 1.10492751e-01f, 1.49128035e-01f, -6.78557977e-02f, -3.79489386e-03f, -7.24400207e-02f, 7.05665126e-02f,
  -4.56460193e-03f, 5.31386882e-02f, 4.18613199e-03f, -2.32586116e-01f, 5.28149381e-02f, 5.31265996e-02f, 8.80662799e-02f, -7.66443787e-03f, -9.23238248e-02f, 6.74386770e-02f,
  8.69272277e-02f, 7.78922513e-02f, 8.30768421e-02f, 1.47595644e-01f, -4.67178114e-02f, 5.07720187e-02f, 2.38450721e-01f, -9.51118246e-02f, -1.14293404e-01f, 7.63725564e-02f,
  8.72498099e-03f, -3.94709893e-02f, 1.60796091e-01f, -2.36521251e-02f, 8.39631930e-02f, 1.69698205e-02f, 1.51996493e-01f, 1.52085170e-01f, 1.86047032e-01f, 1.78589255e-01f,
  -4.17440347e-02f, 7.47079868e-03f, 1.46697806e-02f, 3.86972092e-02f, -1.17634073e-01f, 5.98780718e-03f, -3.43180001e-02f, 5.18098138e-02f, -5.91915026e-02f, -8.77365246e-02f,
  1.96019560e-01f, -6.43676668e-02f, -4.34822589e-02f, -4.49324250e-02f, 7.18394853e-03f, 5.41991480e-02f, 9.49377194e-02f, -3.97850610e-02f, 2.48899415e-01f, 2.08772674e-01f,
  2.00090423e-01f, 7.73981437e-02f, 3.29223797e-02f, 1.43929601e-01f, -1.82654947e-01f, -6.70662448e-02f, 9.58981067e-02f, 1.26288101e-01f, 1.92981526e-01f, -2.15609759e-01f,
  -1.69004411e-01f, -1.35630623e-01f, -1.17717572e-01f, -2.30792850e-01f, -2.43017077e-01f, -1.08941467e-02f, -2.34783739e-01f, 1.64609730e-01f, -1.19551778e-01f, -1.64560735e-01f,
  4.22770977e-01f, 6.21899925e-02f, 1.68191954e-01f, -1.54382721e-01f, 8.36741272e-03f, 2.87406832e-01f, 1.66678801e-02f, 2.97040641e-01f, -6.77457303e-02f, 1.48056746e-01f,
  2.46617958e-01f, 5.20101190e-03f, -6.68019801e-02f, -4.01903922e-03f, 1.43172741e-01f, 1.10916812e-02f
};

// L3_fan_Bp_bar (Shape: 1 x 14)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 14;
const float L3_fan_Bp_bar_data[] = {
  1.66279718e-01f, 9.71102342e-02f, -8.27854127e-02f, 3.91775183e-03f, 8.85672495e-02f, -3.62228639e-02f, 1.75039750e-02f, 3.76123004e-02f, 1.91894904e-01f, -3.84660298e-03f,
  -4.42121550e-02f, -5.27040362e-02f, -8.20837095e-02f, 8.22299793e-02f
};

// L4_linear_W (Shape: 12 x 64)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 64;
const float L4_linear_W_data[] = {
  -1.26811355e-01f, -4.26824689e-01f, 1.23911798e-02f, 4.56835032e-02f, -2.54059821e-01f, 7.29553401e-02f, -1.98926613e-01f, 7.51505196e-02f, 4.16426035e-03f, 4.59117591e-02f,
  -2.87865281e-01f, 2.35718749e-02f, -1.51873708e-01f, -1.72263309e-01f, -3.91482323e-01f, -1.96240813e-01f, -1.33357793e-01f, -7.96717927e-02f, -3.77411515e-01f, 8.55741128e-02f,
  1.65161062e-02f, -1.50927067e-01f, 1.19006149e-01f, 1.52896702e-01f, -4.16841120e-01f, -3.59819263e-01f, -4.87889200e-02f, 9.24727693e-02f, -2.20894843e-01f, 1.87108889e-01f,
  2.68686920e-01f, 1.78636998e-01f, 2.38781318e-01f, -7.97383860e-02f, -3.42214406e-01f, -4.10152107e-01f, -2.19032586e-01f, -3.15283388e-01f, 2.35451147e-01f, 2.17568055e-01f,
  2.92765856e-01f, 1.02958545e-01f, -1.08623341e-01f, -1.19116865e-01f, 2.12094098e-01f, 1.30861595e-01f, -1.49658442e-01f, -1.12927295e-01f, -3.29699516e-02f, 1.19595386e-01f,
  9.14354920e-02f, -3.27097625e-01f, -2.24568602e-02f, -7.39163393e-03f, -1.43751472e-01f, 5.45578077e-03f, 8.36676136e-02f, 3.07266712e-01f, -1.40330195e-01f, 1.02056772e-01f,
  1.81937829e-01f, 1.81066424e-01f, 3.49298596e-01f, 2.76293397e-01f, 4.13340420e-01f, 2.23961636e-01f, -6.04385808e-02f, 1.61913976e-01f, 7.33688921e-02f, -7.39998743e-02f,
  2.17519984e-01f, 7.42580667e-02f, 1.77883804e-02f, 1.62789568e-01f, 3.99122685e-01f, 6.28889501e-02f, 9.76874828e-02f, 2.55546302e-01f, 2.82282501e-01f, 5.65242171e-02f,
  3.10905483e-02f, 4.87178341e-02f, 1.32876605e-01f, 2.06285808e-02f, 1.67045742e-01f, -1.50978029e-01f, 2.77239475e-02f, -1.26514286e-01f, 1.33336291e-01f, 2.44284779e-01f,
  -8.40313062e-02f, 2.78875947e-01f, -1.76725626e-01f, 2.71886826e-01f, -1.82394519e-01f, 2.00854361e-01f, 1.69571653e-01f, 1.63010567e-01f, -3.95513356e-01f, -1.79552332e-01f,
  -5.03154211e-02f, 1.87031515e-02f, -1.65415272e-01f, -2.48060897e-01f, 1.78250670e-01f, -2.71970034e-01f, -2.44805396e-01f, 1.43903343e-03f, 2.05164272e-02f, 2.23350540e-01f,
  -2.88834989e-01f, 2.80445553e-02f, -3.69639248e-01f, 3.83501500e-01f, -1.27505884e-01f, -3.80914181e-01f, -2.49725617e-02f, 5.30876108e-02f, -4.48505655e-02f, -9.39012878e-03f,
  4.63018902e-02f, 5.08641541e-01f, -1.14608899e-01f, 1.88791648e-01f, -2.65799671e-01f, 4.40894440e-02f, -1.72968701e-01f, 4.00492460e-01f, 1.47174045e-01f, -1.73281357e-01f,
  -8.23943242e-02f, 1.02222994e-01f, 4.56813201e-02f, 7.75218457e-02f, 4.19007987e-02f, -1.49486154e-01f, -1.74507812e-01f, -8.38876292e-02f, -1.86409190e-01f, -2.66043335e-01f,
  -1.36591375e-01f, -9.64422226e-02f, 9.13994685e-02f, 7.52275437e-02f, 3.22709292e-01f, -2.43131700e-03f, 2.09674519e-02f, 6.89584985e-02f, 1.54957324e-01f, 2.56250240e-02f,
  -2.46663317e-01f, -1.14648707e-01f, -6.53449073e-02f, 1.47682905e-01f, 2.33590275e-01f, 2.39958510e-01f, 8.14495087e-02f, -3.21087182e-01f, -2.30392784e-01f, -2.71227777e-01f,
  3.97252619e-01f, 1.15336068e-01f, 2.15239406e-01f, 3.76632243e-01f, 3.73958261e-03f, 4.46654946e-01f, -1.71191901e-01f, -2.15683952e-01f, 8.61630440e-02f, -2.48366788e-01f,
  4.00024474e-01f, -4.33332380e-03f, -2.92809099e-01f, -3.07260477e-03f, 3.18619251e-01f, 1.14897616e-01f, -2.78364867e-01f, -3.13451856e-01f, 2.50883400e-01f, 4.15779054e-02f,
  -7.08835050e-02f, 2.33890917e-02f, -3.28714661e-02f, 2.92606682e-01f, 1.28345611e-03f, -1.10819221e-01f, -2.56606191e-01f, 4.37174678e-01f, -1.18500724e-01f, -7.42778853e-02f,
  2.18372550e-02f, 2.03565042e-02f, 1.06903143e-01f, 1.94600254e-01f, 1.70098141e-01f, 2.17087030e-01f, 1.36906967e-01f, 9.09907222e-02f, 1.73613355e-02f, -1.69614390e-01f,
  -2.58210897e-01f, 4.59381491e-01f, 2.43884146e-01f, 1.59395784e-01f, 1.06446192e-01f, 2.33066812e-01f, -2.44909763e-01f, -1.47351876e-01f, -1.49379045e-01f, 3.49856526e-01f,
  -1.01898745e-01f, -7.83469155e-02f, 1.75018355e-01f, 2.26101860e-01f, 2.14601066e-02f, -3.26581270e-01f, -8.68810713e-02f, -6.40732765e-01f, -2.55671978e-01f, -3.47721875e-01f,
  6.31359965e-02f, 1.75233975e-01f, -4.42182310e-02f, 4.47274178e-01f, -3.39126766e-01f, 9.66941938e-02f, 7.58811384e-02f, -2.35099867e-01f, -8.37147906e-02f, -8.22758079e-02f,
  -1.23753026e-01f, 3.47013533e-01f, -1.30960509e-01f, 1.83227286e-01f, -6.76084757e-02f, -2.20794857e-01f, -1.89223468e-01f, 1.09098796e-02f, 3.80212337e-01f, 1.96259364e-01f,
  2.14112833e-01f, 5.31716168e-01f, 2.56468832e-01f, 2.38356397e-01f, -1.69914775e-02f, 6.87295124e-02f, 2.81121999e-01f, -1.33823127e-01f, -1.52481049e-01f, -2.33151823e-01f,
  2.37315416e-01f, -1.93088666e-01f, -5.21797121e-01f, -2.75966190e-02f, 7.20897987e-02f, -1.93045363e-01f, 3.03524435e-01f, -3.68731558e-01f, 9.73984748e-02f, -6.51959479e-02f,
  1.69810709e-02f, -1.39920963e-02f, 2.18365286e-02f, -1.44693032e-01f, -4.87127854e-03f, 8.11016113e-02f, 2.59575784e-01f, 2.42589816e-01f, -1.03247255e-01f, -6.86021894e-02f,
  -3.60401779e-01f, -8.50050002e-02f, -3.31160158e-01f, -3.24569523e-01f, 7.15167895e-02f, 2.17298165e-01f, -2.84767821e-02f, 2.55954325e-01f, 9.09223184e-02f, -2.70495474e-01f,
  5.24594523e-02f, 6.10405914e-02f, -3.79064143e-01f, 3.15888464e-01f, -1.52218789e-02f, 3.36130619e-01f, 8.95819291e-02f, 3.16779763e-01f, -2.10392714e-01f, 7.70213231e-02f,
  3.28807980e-01f, -1.56217411e-01f, -7.58664608e-02f, -3.01789343e-01f, 2.73456097e-01f, 6.51876405e-02f, -2.15203777e-01f, 1.79460868e-01f, -2.80238271e-01f, -2.19558254e-01f,
  1.20971669e-02f, -1.72346890e-01f, 1.61995649e-01f, 9.17502046e-02f, 3.26267093e-01f, 2.61538088e-01f, 1.46263719e-01f, 2.22717434e-01f, 9.72457975e-02f, -6.07316382e-02f,
  1.02615662e-01f, -6.87556192e-02f, -1.92523703e-01f, 4.11170423e-02f, -1.55360075e-02f, -1.22981772e-01f, 3.89822364e-01f, 1.44123569e-01f, 2.50133604e-01f, 1.42376348e-01f,
  -9.09219235e-02f, -1.71539202e-01f, -2.03262150e-01f, -7.69183785e-02f, -7.92239457e-02f, -6.25418350e-02f, 1.30431131e-01f, -1.02425553e-01f, 3.22887391e-01f, 1.97642401e-01f,
  1.24629699e-01f, 8.50800872e-02f, 1.64601784e-02f, -1.98708847e-01f, 1.76837593e-02f, -6.67778030e-02f, 1.09440558e-01f, -3.20159495e-01f, 1.80810779e-01f, -1.68437570e-01f,
  6.62932992e-02f, -3.11009586e-01f, -1.43103218e-02f, 8.79997015e-02f, 1.41005874e-01f, 3.12926531e-01f, -1.58454508e-01f, 5.54367080e-02f, 3.88189405e-02f, 3.36009145e-01f,
  -1.39559090e-01f, 1.63354874e-01f, -1.87125340e-01f, -4.89189267e-01f, 3.41597557e-01f, 5.37681505e-02f, -2.94223517e-01f, -1.05317742e-01f, 1.86021701e-01f, 5.18530747e-03f,
  1.45332128e-01f, -2.31106132e-01f, -2.57828739e-02f, -8.29191655e-02f, 4.38743651e-01f, -2.66543984e-01f, -4.34317827e-01f, -3.36873204e-01f, -3.18452984e-01f, 2.10449070e-01f,
  -4.93445456e-01f, 1.52347907e-02f, 2.67468728e-02f, 2.75853962e-01f, -1.32037327e-01f, -1.58100910e-02f, -2.27323472e-02f, 4.98834789e-01f, -8.70651081e-02f, 1.79908648e-01f,
  3.39165062e-01f, -4.41281386e-02f, 1.12852581e-01f, 2.61675715e-01f, -2.99044192e-01f, 1.04013272e-01f, -2.90060133e-01f, 3.07823531e-02f, 1.20513201e-01f, -2.31883213e-01f,
  -3.11171502e-01f, 1.45263240e-01f, 3.02945316e-01f, -3.50680470e-01f, -2.60549366e-01f, -7.07735941e-02f, 1.66648611e-01f, 6.39718473e-02f, 1.61847621e-01f, 1.22092225e-01f,
  1.12326950e-01f, 2.26095915e-01f, -2.63372868e-01f, 1.20423235e-01f, -3.24601769e-01f, -1.22376233e-02f, 5.82002886e-02f, -1.47078544e-01f, -1.20366588e-01f, -1.91485479e-01f,
  3.05718124e-01f, 2.30321512e-01f, 1.78130008e-02f, -2.95506954e-01f, -2.26700027e-03f, -1.07352033e-01f, -3.48835289e-02f, -1.47681490e-01f, -8.51157904e-02f, -5.84600202e-05f,
  2.73667365e-01f, 2.78868824e-01f, -8.44312236e-02f, -2.57017970e-01f, 1.72365904e-01f, -4.22146380e-01f, -1.99174462e-03f, 1.94677919e-01f, 6.50198385e-02f, -2.44583786e-01f,
  -2.13047788e-01f, -5.87305240e-02f, -2.75056928e-01f, -2.50702381e-01f, -3.87488931e-01f, 3.15348841e-02f, -1.26275271e-01f, -1.03485957e-02f, -5.02216518e-02f, 1.15343787e-01f,
  2.68397350e-02f, 1.38288587e-01f, 1.01210982e-01f, 2.99558919e-02f, 3.24231952e-01f, -2.92628616e-01f, -1.83380693e-01f, 3.58809590e-01f, -4.33483452e-01f, 7.15146959e-02f,
  1.47784933e-01f, -4.95920852e-02f, -2.39404999e-02f, 1.36081472e-01f, -2.45507225e-01f, 1.41919211e-01f, -2.49562994e-01f, -7.85128623e-02f, 2.15734869e-01f, -4.55087796e-02f,
  4.09786440e-02f, 3.15537564e-02f, -1.44054994e-01f, 2.56813109e-01f, 8.46607164e-02f, -5.20482883e-02f, -7.58572444e-02f, -7.69255776e-03f, -8.15467983e-02f, 6.57689348e-02f,
  1.75281003e-01f, 1.69922620e-01f, -3.76494795e-01f, -3.60498101e-01f, -1.00166477e-01f, -2.45365798e-01f, -2.77123541e-01f, 1.34595752e-01f, -5.60486410e-03f, 4.14570779e-01f,
  -2.53830016e-01f, 5.58249019e-02f, -5.17604530e-01f, -1.22697093e-01f, 2.95138985e-01f, 3.94796878e-01f, -1.50997534e-01f, 2.52280533e-01f, 2.38498822e-01f, 1.35262355e-01f,
  3.69683832e-01f, -2.48901144e-01f, -2.07984790e-01f, 1.72957867e-01f, -2.37491086e-01f, 1.58659920e-01f, 1.03871375e-01f, 3.09049249e-01f, 3.51225406e-01f, -4.80077326e-01f,
  3.49030234e-02f, 6.41297251e-02f, -2.08289586e-02f, 8.19649827e-03f, 1.36079893e-01f, 2.38270774e-01f, -8.67510065e-02f, 5.12885265e-02f, -3.91544014e-01f, 1.62021130e-01f,
  6.95581287e-02f, -3.69726717e-01f, -5.64571247e-02f, -2.94876426e-01f, 2.56000787e-01f, 2.63692260e-01f, -1.47231579e-01f, -2.64948756e-01f, -3.86205196e-01f, 1.74472690e-01f,
  4.46038097e-02f, 3.34910713e-02f, -4.88544554e-01f, -3.59270513e-01f, -4.57613945e-01f, 1.47755414e-01f, 5.62689789e-02f, -5.45718446e-02f, 5.46756573e-02f, -1.52270898e-01f,
  1.28137127e-01f, -1.92292452e-01f, -2.21229866e-01f, 2.13712424e-01f, 8.02948177e-02f, -1.75894603e-01f, 2.25624312e-02f, 2.89279342e-01f, 1.15857027e-01f, -2.79541284e-01f,
  -2.20576614e-01f, -2.48306960e-01f, -2.39261180e-01f, -3.52681994e-01f, -2.74860591e-01f, 2.16914266e-01f, 2.84235775e-01f, -4.71610669e-03f, -1.16336145e-01f, 1.80951923e-01f,
  -1.23433154e-02f, -4.42861259e-01f, -1.23002268e-01f, -4.22984481e-01f, 3.69290262e-01f, 1.24230556e-01f, -2.26879507e-01f, -3.09055686e-01f, -1.62333980e-01f, 1.08053632e-01f,
  -2.92066038e-01f, -4.03022826e-01f, -5.76242339e-03f, 3.18270147e-01f, -1.00205980e-01f, 8.15254375e-02f, -1.22892685e-01f, -1.52329817e-01f, -2.50732079e-02f, -3.28402698e-01f,
  -1.56934693e-01f, -2.81281263e-01f, -4.02931422e-01f, -1.34862408e-01f, 3.23233567e-02f, -3.45365286e-01f, -1.86230704e-01f, 3.52813780e-01f, -3.09034616e-01f, -2.15108186e-01f,
  1.13918290e-01f, 1.89940766e-01f, 1.79139063e-01f, -7.22361878e-02f, 1.88955396e-01f, -3.27550858e-01f, 4.92650736e-03f, 2.41232827e-01f, -2.87679974e-02f, 6.05909452e-02f,
  -8.86743218e-02f, 6.59079328e-02f, 1.59388989e-01f, -3.57047588e-01f, 6.91562966e-02f, 1.87456585e-03f, -1.09982051e-01f, 9.92515013e-02f, -1.90338239e-01f, 2.45768562e-01f,
  1.13785304e-01f, 2.33874202e-01f, -1.98715273e-02f, -2.57728815e-01f, -6.17818441e-03f, -2.27621328e-02f, 2.11046636e-01f, -2.33979657e-01f, 3.87544960e-01f, -1.68204620e-01f,
  1.33156031e-01f, 2.21172839e-01f, -6.19326569e-02f, -2.61090875e-01f, 7.47294025e-03f, 2.08848327e-01f, -9.65737477e-02f, 1.26351863e-01f, -8.00060332e-02f, 2.43587181e-01f,
  2.77071148e-01f, -2.77037546e-02f, 2.69325703e-01f, 1.55518696e-01f, -8.57124776e-02f, -3.28098506e-01f, 2.67732479e-02f, 1.15379378e-01f, 1.60306990e-01f, 9.67601836e-02f,
  -6.19895905e-02f, -1.04201436e-01f, -5.03242947e-02f, -1.66010514e-01f, -1.75018549e-01f, 7.25359991e-02f, 6.13169670e-01f, 6.86513707e-02f, 1.48231745e-01f, 2.07007214e-01f,
  4.78342593e-01f, 1.94497466e-01f, 1.90203115e-01f, -2.05180004e-01f, 1.26766756e-01f, 4.92706969e-02f, 1.74630389e-01f, 2.34989792e-01f, -1.90983653e-01f, 4.86205928e-02f,
  2.76920110e-01f, 2.70331483e-02f, 1.67776451e-01f, 1.67042956e-01f, 2.11680770e-01f, -2.78137594e-01f, -6.21961281e-02f, 4.44866307e-02f, 4.85462360e-02f, -4.83591035e-02f,
  1.63079172e-01f, -3.83569181e-01f, -2.93325663e-01f, -1.37397544e-02f, 2.26577014e-01f, 8.47530887e-02f, 3.07124376e-01f, 7.28792101e-02f, 3.68559331e-01f, -2.93868750e-01f,
  1.66358314e-02f, -1.44551307e-01f, 1.00461252e-01f, 8.56444798e-03f, 3.40503216e-01f, 1.10059068e-01f, 2.54491776e-01f, -1.82401419e-01f, 1.14928178e-01f, -4.08662297e-02f,
  -1.69623151e-01f, 3.59108776e-01f, -5.90472110e-02f, -2.86063015e-01f, -2.20344007e-01f, 2.15482444e-01f, 3.02752554e-01f, 2.10046202e-01f, 2.92071283e-01f, -2.20205098e-01f,
  4.18823332e-01f, 1.31796924e-02f, 7.19476342e-02f, -1.16398595e-01f, 3.43653969e-02f, 1.84299499e-01f, 2.56912708e-01f, -2.69526303e-01f, 1.30395964e-01f, 1.04561046e-01f,
  -1.01138212e-01f, 1.67170748e-01f, -2.37290747e-02f, -4.00548875e-01f, -1.36675507e-01f, 1.86235070e-01f, 2.11869568e-01f, -1.62755787e-01f, -3.02084237e-02f, -4.09579165e-02f,
  -2.17231706e-01f, -3.55239771e-02f, 4.02385175e-01f, -2.72662610e-01f, 4.15948108e-02f, 3.26725580e-02f, 1.93567827e-01f, 1.55466586e-01f, 1.36666313e-01f, -2.09174573e-01f,
  6.13077475e-07f, 2.60486364e-01f, 2.11959973e-01f, 2.14293733e-01f, 9.05399024e-03f, 3.12991850e-02f, 9.79065299e-02f, 1.70265302e-01f, -6.19062781e-03f, 2.71869600e-01f,
  3.58960062e-01f, 1.67071551e-01f, 9.76754427e-02f, -3.27350676e-01f, -1.31990731e-01f, -3.87753218e-01f, -2.29439735e-01f, -1.80554271e-01f, 3.18191238e-02f, 2.46568769e-01f,
  2.80552894e-01f, -6.43436834e-02f, 1.12199165e-01f, 6.04625866e-02f, -1.98644966e-01f, 3.57857436e-01f, 8.03956669e-03f, 3.53427649e-01f, 4.01741676e-02f, -2.16438532e-01f,
  2.89091557e-01f, 8.39054137e-02f, 9.17529464e-02f, -4.20870066e-01f, -1.52604625e-01f, 3.64076197e-01f, -1.19039521e-01f, -4.03930284e-02f, 1.41176060e-01f, -4.61945198e-02f,
  -7.26211234e-04f, -3.37026030e-01f, 5.21100044e-01f, -2.57843673e-01f, 4.18279357e-02f, -1.12238809e-01f, -3.77038568e-02f, -3.54547292e-01f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  -1.64917022e-01f, -2.74303020e-03f, 6.04741350e-02f, 6.76074922e-02f, -8.98978859e-02f, -1.94861338e-01f, 6.34956360e-02f, 8.87972564e-02f, 1.53881639e-01f, -1.04272053e-01f,
  -6.67358860e-02f, -7.06394017e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 25, 14
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 25, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        64, 25, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        64, 25, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        64, 12
    );
    }
    