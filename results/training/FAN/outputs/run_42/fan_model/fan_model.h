/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 4 x 120)
const int L0_fan_Wp_rows = 4;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  7.56099075e-02f, 1.19626880e-01f, 2.19709009e-01f, 1.66717358e-02f, 6.88554272e-02f, 9.99791026e-02f, 5.03708236e-02f, 1.88497212e-02f, 3.76299083e-01f, -1.68234855e-01f,
  -1.49855211e-01f, -1.46554098e-01f, 1.78846732e-01f, -2.69620746e-01f, -2.57565260e-01f, 7.56970197e-02f, -1.88898370e-01f, -4.63602617e-02f, 1.32040814e-01f, -8.88054296e-02f,
  3.42004262e-02f, -4.00242448e-01f, -1.01682790e-01f, -2.56244153e-01f, -1.82664171e-01f, 8.80489498e-02f, -3.05950791e-01f, 1.13190629e-01f, -2.76936799e-01f, -3.97275575e-02f,
  1.53175956e-02f, 1.44079383e-02f, -1.55061409e-02f, 4.84333523e-02f, -7.70992115e-02f, 7.28997439e-02f, -3.74118127e-02f, 9.37156007e-03f, 9.61115435e-02f, 8.31298064e-03f,
  4.36146371e-03f, -6.17780350e-02f, 7.22739659e-03f, 4.10355292e-02f, 3.14822607e-02f, -2.60533653e-02f, 1.84354354e-02f, 7.81612769e-02f, -2.32388675e-02f, 6.65538236e-02f,
  9.03863162e-02f, 4.79044616e-02f, 1.90151446e-02f, 2.86911940e-03f, 6.28412142e-02f, 5.52326627e-02f, 4.61626165e-02f, 7.41056129e-02f, -3.79061177e-02f, 4.09554690e-02f,
  -9.13298428e-02f, 1.16931394e-01f, -4.22133282e-02f, 4.39171642e-02f, -6.75153509e-02f, -1.28657306e-02f, -5.55520989e-02f, -2.28742938e-02f, -9.53774713e-03f, -7.18812123e-02f,
  -2.29124408e-02f, 2.33374517e-02f, -2.29634959e-02f, 1.59795843e-02f, 2.78408974e-02f, -3.77526842e-02f, 8.98081623e-03f, -1.87663417e-02f, 4.65821810e-02f, -7.92106334e-03f,
  -8.22431669e-02f, -1.95087623e-02f, -4.22931686e-02f, 3.03583797e-02f, 1.32421190e-02f, 5.85896969e-02f, -4.57042083e-02f, 2.50817016e-02f, 1.17548086e-01f, 1.64381173e-02f,
  -9.99007560e-03f, 6.69914111e-02f, 8.73193070e-02f, 3.95753141e-03f, 3.47347297e-02f, -1.13635436e-01f, -1.53770857e-02f, -2.73599592e-03f, -2.01111380e-02f, 6.16168510e-03f,
  2.30648126e-02f, 4.39576469e-02f, -1.03194036e-01f, 4.02096398e-02f, -2.87085362e-02f, -1.16759753e-02f, 3.07073705e-02f, 4.54765605e-03f, -4.75272946e-02f, -1.14534311e-01f,
  -8.03164542e-02f, -1.51741486e-02f, -1.64855290e-02f, -2.46646181e-02f, -6.20502941e-02f, -6.44711778e-02f, -3.67977098e-02f, 2.53875810e-03f, -9.52508152e-02f, 4.98742573e-02f,
  -1.83469042e-01f, 3.98112088e-01f, -3.98779325e-02f, 2.04628259e-01f, -1.50093332e-01f, 3.33727688e-01f, 2.02499345e-01f, 1.23069972e-01f, 1.50470957e-01f, 3.14725012e-01f,
  8.49095136e-02f, 1.29990317e-02f, 1.29102886e-01f, 3.36259007e-01f, 5.25514893e-02f, 2.44926244e-01f, 2.78283328e-01f, 1.62833527e-01f, -2.52038892e-02f, 7.51425028e-02f,
  -1.76216774e-02f, 2.30771646e-01f, 5.05697401e-03f, 1.90263726e-02f, -1.21334335e-02f, -1.07546546e-01f, -4.81684022e-02f, -1.84268028e-01f, 3.32040079e-02f, 5.57576232e-02f,
  -2.20991038e-02f, -3.50954123e-02f, -5.00089489e-02f, 9.19807516e-03f, 8.99543148e-03f, -2.23414805e-02f, -3.69814262e-02f, -1.15758695e-01f, -2.13185661e-02f, 1.10989772e-02f,
  1.79495867e-02f, -5.74144609e-02f, 9.46098473e-03f, -2.22423635e-02f, -3.27976905e-02f, 1.34881362e-02f, -1.25589808e-02f, 4.31954749e-02f, 1.68994833e-02f, -1.73142534e-02f,
  2.32877918e-02f, 3.38467881e-02f, 3.76825258e-02f, 7.61612281e-02f, -3.50022614e-02f, 3.67508829e-02f, -3.80035769e-03f, -8.60508829e-02f, -3.27579421e-03f, 7.13823810e-02f,
  -7.27803446e-03f, -6.64532825e-04f, -1.61686521e-02f, 3.47186290e-02f, 2.16033347e-02f, -2.79617147e-03f, 2.23913994e-02f, -2.81784516e-02f, -3.32202576e-02f, 6.61275303e-03f,
  2.08095871e-02f, -1.26735792e-02f, 1.65191051e-02f, 8.60170648e-03f, -4.43946943e-02f, 3.37204300e-02f, -3.74898016e-02f, -6.45267172e-03f, 8.56375042e-03f, 3.04871257e-02f,
  4.79084440e-02f, 1.20130572e-02f, 3.88725549e-02f, -2.48889495e-02f, 2.84125246e-02f, 9.24034137e-03f, 6.13034777e-02f, -4.18028422e-02f, -5.62737174e-02f, -2.72768084e-02f,
  2.13734195e-01f, 1.90934509e-01f, 1.84385963e-02f, -2.12671515e-02f, 1.95974158e-03f, 7.21122185e-03f, 1.83320977e-02f, 3.73199135e-02f, -1.88972447e-02f, 2.43360996e-02f,
  -6.41459599e-02f, 2.25951876e-02f, 2.08276305e-02f, -5.19823879e-02f, 4.46480848e-02f, 6.66861758e-02f, 5.08133434e-02f, -6.87527284e-02f, 5.85939959e-02f, -2.04664804e-02f,
  4.57244273e-03f, -3.60983647e-02f, -6.25014827e-02f, -4.96445671e-02f, 1.38403348e-05f, -2.53466498e-02f, -9.22013726e-03f, -3.68121900e-02f, -1.76247898e-02f, 4.75361161e-02f,
  -3.61972839e-01f, -2.39771366e-01f, -9.83100906e-02f, -3.97518367e-01f, -1.10772200e-01f, 2.99713202e-02f, 2.52001524e-01f, -2.60705471e-01f, -2.71246672e-01f, 1.17450863e-01f,
  2.00271383e-01f, -4.87103723e-02f, 2.83385485e-01f, -1.96540296e-01f, -6.78248778e-02f, 1.03466533e-01f, -1.26892507e-01f, -3.67482491e-02f, -9.76675302e-02f, -1.13853410e-01f,
  -1.40419960e-01f, -5.69975786e-02f, 4.01519202e-02f, -5.44692650e-02f, -5.91279790e-02f, -1.26035601e-01f, 1.76203236e-01f, 2.27687716e-01f, -3.01075373e-02f, 7.17805102e-02f,
  1.18111752e-01f, 2.44933814e-02f, -8.92851129e-02f, -9.48108267e-03f, 5.32826558e-02f, 2.31651030e-02f, 5.03015555e-02f, 8.49417597e-02f, -5.68296248e-03f, -9.48609598e-03f,
  7.96691254e-02f, 1.93118155e-02f, -8.81677046e-02f, 1.10141030e-02f, -7.27199167e-02f, -1.09311575e-02f, 8.95008969e-04f, -5.53257624e-03f, -7.10473135e-02f, 4.79283333e-02f,
  -4.97685522e-02f, 5.00067770e-02f, -6.63439259e-02f, -1.27536347e-02f, -5.40026203e-02f, 1.35398246e-02f, 5.24362139e-02f, -2.28310525e-02f, -1.05108935e-02f, -1.19246200e-01f,
  -3.45568522e-03f, 2.05533318e-02f, 2.06554644e-02f, 2.05953252e-02f, 1.82837322e-02f, -3.12598795e-02f, -1.91462096e-02f, 4.28065136e-02f, -4.53480184e-02f, -2.82300543e-03f,
  -3.10380440e-02f, -1.23774052e-01f, 1.09903617e-02f, -1.39637254e-02f, -1.38912899e-02f, -5.02548763e-04f, 5.26617952e-02f, 3.32871228e-02f, -4.58871610e-02f, -3.53484526e-02f,
  3.51784565e-02f, -3.76649685e-02f, 4.14629504e-02f, 2.38392688e-02f, -2.45574266e-02f, 4.40070145e-02f, -6.42821863e-02f, -1.58046242e-02f, 3.42173092e-02f, 4.90972027e-02f,
  -5.95472753e-02f, -4.90902588e-02f, -3.78412530e-02f, -7.88857229e-03f, 6.99251667e-02f, 4.37727049e-02f, -3.69577222e-02f, -5.84026538e-02f, -1.75665151e-02f, 1.93721184e-03f,
  -4.16536676e-03f, -8.66260156e-02f, -6.30816212e-03f, 6.61097234e-03f, -5.34159206e-02f, -2.10053753e-02f, 4.65660803e-02f, -3.29972617e-02f, -6.80657998e-02f, -4.19119783e-02f,
  3.88272293e-02f, 8.82020071e-02f, -1.11301169e-01f, -1.12344198e-01f, -7.05979764e-02f, 5.48641607e-02f, -1.12752043e-01f, 4.56908755e-02f, -6.18754067e-02f, -2.24084686e-02f,
  4.42781210e-01f, 6.78076223e-02f, 1.18281379e-01f, 3.14798683e-01f, -1.21531850e-02f, 2.68630952e-01f, 2.01695755e-01f, -2.96811406e-02f, 2.13263899e-01f, -4.76839021e-03f,
  6.38026223e-02f, 9.54609811e-02f, 4.64752056e-02f, 3.11389387e-01f, 3.32537621e-01f, 7.30797723e-02f, 2.07876742e-01f, 4.68375906e-02f, 6.47108108e-02f, 3.23086008e-02f,
  9.58479792e-02f, 3.54115777e-02f, 6.49534315e-02f, -1.11062862e-01f, -5.26524335e-02f, -2.13611618e-01f, -8.21532235e-02f, -1.49793670e-01f, -6.23780675e-02f, 5.65590039e-02f,
  -3.41611286e-03f, -6.48013502e-02f, -3.40897143e-02f, 4.51954082e-02f, 3.91517691e-02f, -8.23117122e-02f, -6.78772628e-02f, -5.56801744e-02f, 4.88615185e-02f, -2.32563019e-02f,
  -4.12162393e-02f, -3.00436094e-02f, 2.35788319e-02f, -7.40966722e-02f, -5.35396219e-04f, -3.96393649e-02f, 1.69355962e-02f, -4.15483899e-02f, -3.68406139e-02f, 1.12092100e-01f,
  3.71229351e-02f, -2.58797258e-02f, 1.20840231e-02f, -4.10284027e-02f, 2.35954039e-02f, 9.18093473e-02f, 8.49539638e-02f, -3.91053967e-02f, 1.98451262e-02f, 3.02510057e-02f,
  -7.81470090e-02f, 1.45262405e-02f, 7.28154089e-03f, 1.14050187e-01f, 6.48768619e-02f, 3.66661139e-02f, 7.45472014e-02f, -4.74916101e-02f, -8.00587051e-03f, -5.26512899e-02f,
  1.16042541e-02f, 4.37725894e-02f, -2.08265297e-02f, 2.62773074e-02f, -3.36327963e-02f, 2.68488582e-02f, 1.16771022e-02f, 5.36114275e-02f, 3.84787694e-02f, 2.80083958e-02f,
  1.67260934e-02f, 7.41924569e-02f, 9.63724125e-03f, 2.50683352e-02f, 1.11192977e-02f, 2.35016495e-02f, -1.29475743e-02f, -4.90406062e-03f, -3.05484757e-02f, 5.27652763e-02f,
  2.41247043e-02f, -9.91434753e-02f, 1.95463076e-02f, 2.24719495e-02f, 2.84929369e-02f, 7.43345469e-02f, -1.02478256e-02f, -3.11058555e-02f, -7.44176507e-02f, 2.97881793e-02f,
  -4.21625301e-02f, 5.66813722e-02f, -7.28019699e-02f, 1.20101005e-01f, -6.92181513e-02f, 4.75537516e-02f, -4.51548770e-02f, -1.45211928e-02f, -5.16678207e-02f, 1.61456093e-02f,
  -1.02781348e-01f, 7.41869584e-03f, -2.59891450e-02f, -5.26623130e-02f, -8.26418679e-03f, -9.49489251e-02f, 4.21870267e-03f, -4.49311920e-02f, 1.84146706e-02f, -2.19991766e-02f
};

// L0_fan_Wp_bar (Shape: 8 x 120)
const int L0_fan_Wp_bar_rows = 8;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -2.17679575e-01f, 1.79630071e-01f, 5.96175492e-01f, -2.36396864e-01f, 3.45444411e-01f, 2.54193395e-01f, -1.84812948e-01f, 2.79949367e-01f, 1.39240682e-01f, -2.22912371e-01f,
  -2.37310320e-01f, 5.46262786e-03f, -1.21015310e-01f, -8.14138502e-02f, 2.50710994e-02f, -3.34740467e-02f, 2.69497428e-02f, -1.55714199e-01f, 1.86540753e-01f, 7.42878839e-02f,
  -4.02908698e-02f, -2.66648561e-01f, 2.23017424e-01f, 1.76995143e-01f, 1.87493086e-01f, 1.58035666e-01f, -1.56451538e-01f, 2.53546666e-02f, -1.31301656e-01f, -8.88960660e-02f,
  2.84425527e-01f, -5.56317009e-02f, 1.09942973e-01f, 1.70468494e-01f, 1.70740396e-01f, -3.10727824e-02f, -5.47497906e-03f, 1.43978093e-02f, -4.35179435e-02f, 1.23216142e-03f,
  -5.20773120e-02f, 1.29347676e-02f, -3.60695273e-02f, 5.42091914e-02f, 9.36089456e-02f, 9.48916599e-02f, 1.66285858e-01f, 1.19193271e-01f, 1.56290263e-01f, 1.36156335e-01f,
  2.30435252e-01f, 6.36710972e-02f, 1.33699894e-01f, -1.16355695e-01f, 5.53002097e-02f, -6.39790669e-02f, 7.38037925e-04f, 5.31358011e-02f, 4.94508492e-03f, -3.85980643e-02f,
  -5.09528965e-02f, -6.03208467e-02f, 1.45027293e-02f, 6.54126778e-02f, -5.15065938e-02f, 1.88478343e-02f, -1.35753220e-02f, 8.66592079e-02f, -4.19500507e-02f, 3.21893580e-02f,
  3.74837480e-02f, -8.62174258e-02f, 1.50095239e-01f, -1.72567759e-02f, -9.99136940e-02f, 3.88447717e-02f, -2.83529144e-02f, 1.41360601e-02f, -9.34085548e-02f, -3.21535617e-02f,
  -3.97770479e-02f, -6.62707984e-02f, -9.99210626e-02f, 1.23184659e-02f, -5.47452178e-03f, 6.48296177e-02f, 2.11110525e-02f, 9.48140025e-02f, 3.92205641e-02f, -3.75555083e-02f,
  -2.89732397e-01f, -4.21974659e-01f, -1.18820723e-02f, -4.26042117e-02f, 2.58314144e-02f, -1.77050792e-02f, -2.62015183e-02f, 8.08780640e-03f, -1.76663503e-01f, -1.78150814e-02f,
  9.29732993e-02f, -6.75126240e-02f, -7.63502121e-02f, -5.29135205e-02f, -7.90186375e-02f, -4.03850824e-02f, -1.46491557e-01f, -1.72901019e-01f, -1.26783893e-01f, -4.36178446e-02f,
  -6.84645325e-02f, -1.82707101e-01f, -2.79742889e-02f, -1.10702943e-02f, -4.55823615e-02f, -2.12554447e-02f, -6.29311502e-02f, -7.13871419e-02f, -7.65853822e-02f, -3.86354048e-03f,
  -6.22057803e-02f, 3.12578380e-01f, 1.61548659e-01f, -1.50333539e-01f, -3.03348005e-01f, -5.39107144e-01f, -3.11828822e-01f, 2.74757296e-02f, 6.79848194e-02f, 1.91752940e-01f,
  -1.65101573e-01f, 4.51572388e-01f, 8.76021236e-02f, -1.56573392e-02f, -6.62027955e-01f, -9.40118060e-02f, -3.76864195e-01f, -9.82865244e-02f, -8.27538073e-02f, -7.46597573e-02f,
  -2.75528640e-01f, -4.51786757e-01f, -8.81175622e-02f, -5.17298728e-02f, -1.92459784e-02f, 2.31456429e-01f, -2.82976478e-01f, 7.97521025e-02f, 9.85450521e-02f, -5.45825735e-02f,
  6.86906949e-02f, 2.44647980e-01f, 1.56762868e-01f, 2.59789601e-02f, -1.26214743e-01f, -1.37897478e-02f, -4.90896739e-02f, -5.77265918e-02f, 2.93882949e-05f, 2.71636788e-02f,
  -4.11800705e-02f, -6.24200478e-02f, -2.10269151e-04f, 2.62106061e-02f, 2.48426013e-02f, 5.80029450e-02f, 9.42642242e-02f, 1.91490296e-02f, 7.07525238e-02f, 2.46661790e-02f,
  7.16108531e-02f, -4.45975251e-02f, 5.14517678e-03f, 6.34913100e-03f, 4.74806083e-03f, 9.72495526e-02f, 1.71026569e-02f, -2.56828740e-02f, 8.66900459e-02f, -4.53146087e-04f,
  -7.38532394e-02f, -1.57018006e-01f, -4.07500826e-02f, 2.08076015e-01f, -5.67934290e-03f, -5.57218120e-02f, -5.41059859e-02f, -3.30698006e-02f, -3.06132939e-02f, -1.05561517e-01f,
  -5.73448697e-03f, 4.47199494e-02f, 1.17163971e-01f, -4.24536504e-02f, -1.64109636e-02f, 5.58799431e-02f, -4.39044535e-02f, 1.09948255e-01f, -1.01477660e-01f, -5.22874631e-02f,
  6.05112985e-02f, -8.40873122e-02f, 9.75460783e-02f, 3.03542018e-02f, -6.48625791e-02f, -4.86617349e-02f, -2.20762175e-02f, 1.26532227e-01f, 2.14917101e-02f, -1.19644091e-01f,
  -2.24324942e-01f, -1.73060685e-01f, -2.64212284e-02f, 5.31379431e-02f, 9.54863280e-02f, -5.22025228e-02f, 6.59740623e-03f, -3.16700153e-02f, -1.38001099e-01f, -3.52502875e-02f,
  -9.29782540e-02f, 1.71528093e-03f, -6.46389425e-02f, 4.89672134e-03f, -1.13338165e-01f, -1.60907939e-01f, -8.19020122e-02f, -8.20585638e-02f, -8.38826969e-02f, -9.26576704e-02f,
  1.19074360e-01f, 3.54054645e-02f, -4.31712344e-02f, -8.58781412e-02f, -1.48402713e-02f, -1.00319214e-01f, -3.63999419e-02f, 2.89742183e-02f, -6.89543635e-02f, -5.91396019e-02f,
  -1.02462746e-01f, -2.24858299e-01f, -4.35455926e-02f, 6.94685653e-02f, -2.07854696e-02f, -3.41270477e-01f, -5.89387238e-01f, 9.83570591e-02f, -2.11243927e-01f, -6.71621338e-02f,
  1.48734778e-01f, -2.12505132e-01f, -2.51804113e-01f, -1.59416441e-02f, -5.38558252e-02f, -3.77862155e-01f, 1.52892530e-01f, -5.92407100e-02f, -7.11881891e-02f, -2.60868985e-02f,
  1.02985464e-01f, 4.78915982e-02f, 7.67387897e-02f, 2.94947535e-01f, -1.12728305e-01f, 1.35006949e-01f, 4.87963438e-01f, 2.87567209e-02f, 3.03528160e-01f, 1.10719696e-01f,
  -4.08561118e-02f, -2.16051385e-01f, 1.18100299e-02f, 2.15832666e-02f, 1.41776269e-02f, -4.01465073e-02f, -9.92957726e-02f, -9.63440090e-02f, 4.91754115e-02f, -1.05514877e-01f,
  -1.91868600e-02f, 8.52370784e-02f, -6.36888072e-02f, 1.95759814e-02f, -1.09236799e-01f, 1.39277011e-01f, 2.83490922e-02f, -3.50700356e-02f, -1.57622397e-02f, -1.00172177e-01f,
  -9.36351717e-02f, -1.16983932e-02f, 4.95412648e-02f, 7.50265121e-02f, -4.64012939e-03f, -2.35499367e-02f, 2.99118068e-02f, -5.78638539e-02f, 3.38795176e-03f, 4.69293706e-02f,
  8.43246430e-02f, -2.47626589e-03f, -4.75506596e-02f, -1.59603395e-02f, -4.47324067e-02f, -1.47355534e-02f, 1.83298737e-02f, 8.81285965e-02f, -2.32009608e-02f, 4.02588816e-03f,
  2.75204121e-03f, -9.19473842e-02f, 1.27461627e-01f, -1.64762229e-01f, -4.53713089e-02f, -4.12724391e-02f, 1.56819541e-02f, 2.04643719e-02f, -6.44430071e-02f, -6.30005598e-02f,
  -1.51759479e-02f, -1.05124496e-01f, -1.18636280e-01f, 8.61267596e-02f, 7.66449347e-02f, -7.33077750e-02f, 4.38812003e-02f, -5.81572913e-02f, 5.36655448e-02f, -1.58790452e-03f,
  1.76025908e-02f, -4.36050519e-02f, -7.07981661e-02f, 7.96369612e-02f, 2.22762395e-03f, -8.19535851e-02f, -5.27810641e-02f, -7.41212070e-02f, 4.36886474e-02f, -1.62556157e-01f,
  5.55810332e-02f, 2.28603184e-02f, 8.88345465e-02f, 7.37776831e-02f, -1.92675111e-03f, -4.54373769e-02f, 1.21165439e-01f, 1.85436960e-02f, 1.16742939e-01f, -4.01198231e-02f,
  8.06286931e-04f, -1.78420022e-01f, 2.39125155e-02f, -8.05939287e-02f, 5.38951904e-02f, -2.21927222e-02f, 5.99898621e-02f, 2.01434421e-04f, 1.03006475e-01f, 1.79093760e-02f,
  2.68299907e-01f, -1.68173388e-02f, 8.30765814e-02f, 1.34704873e-01f, -7.88883194e-02f, -5.00312261e-02f, -2.77392983e-01f, 1.61212441e-02f, -3.04174609e-02f, -6.62704110e-02f,
  -5.26274741e-02f, -1.04622699e-01f, -2.71354526e-01f, -4.28984538e-02f, -2.62894303e-01f, -2.25684062e-01f, 1.61242913e-02f, -1.56889837e-02f, -6.78276643e-02f, -1.81066655e-02f,
  6.76588938e-02f, 1.19061500e-01f, 4.52862121e-02f, 1.34985954e-01f, 3.22496980e-01f, 1.86307430e-01f, 1.16984114e-01f, 1.43928021e-01f, 2.66104132e-01f, -5.80062233e-02f,
  -3.76375020e-02f, -1.87967435e-01f, 2.09046081e-02f, 8.18347409e-02f, 5.78397326e-02f, 1.96360812e-01f, 1.77647278e-01f, -1.69892926e-02f, 1.19561600e-02f, 1.36328684e-02f,
  2.56587714e-02f, 6.82011172e-02f, -4.84503200e-03f, 7.91239645e-03f, 6.70643523e-02f, -9.67374742e-02f, 7.08117932e-02f, 4.52288687e-02f, -7.86703080e-02f, 3.72772925e-02f,
  -2.45413780e-02f, -3.43864970e-02f, 1.10442147e-01f, -8.21082070e-02f, -3.32758836e-02f, -1.58828661e-01f, 2.37892196e-02f, 8.06879625e-03f, -3.25527997e-03f, -9.90011618e-02f,
  8.70865211e-03f, 8.43935087e-02f, 1.08016483e-01f, 2.99828942e-03f, 5.33803478e-02f, -3.37338187e-02f, -9.44729149e-02f, -1.65363163e-01f, -8.63270164e-02f, -1.01673029e-01f,
  8.52274224e-02f, -5.41108213e-02f, 5.88287972e-03f, 8.09178352e-02f, 1.06720567e-01f, -5.79955094e-02f, 3.77289131e-02f, 2.86954101e-02f, 1.10711828e-01f, 4.27130796e-02f,
  1.06035741e-02f, 1.20711671e-02f, 1.30760208e-01f, 2.90131904e-02f, -1.59749568e-01f, 8.80290866e-02f, 1.29490256e-01f, 1.03830539e-01f, 4.73622046e-03f, 8.74548964e-03f,
  -2.88174022e-02f, -1.00035351e-02f, -5.08916155e-02f, -4.81320769e-02f, -1.31123975e-01f, 2.20166240e-02f, -9.49556902e-02f, 8.99010897e-02f, 7.98341781e-02f, 1.54239193e-01f,
  -1.15006054e-02f, -8.34254101e-02f, -1.08190048e-02f, 1.32723883e-01f, -2.94682775e-02f, 8.09592679e-02f, -9.71993357e-02f, 3.19485255e-02f, -1.01449311e-01f, -1.04522593e-01f,
  1.32424846e-01f, 7.94339776e-02f, -5.40244617e-02f, -2.70122644e-02f, -8.42038989e-02f, 3.67416516e-02f, -1.10009452e-02f, 6.49633706e-02f, -1.23429373e-02f, -1.57296389e-01f,
  -1.16994286e+00f, 4.28348750e-01f, -2.08990976e-01f, -3.61210108e-01f, -8.85420963e-02f, -2.66835183e-01f, -1.96768031e-01f, 2.30444651e-02f, -2.23225236e-01f, 5.49597479e-02f,
  -1.26304835e-01f, -5.09687141e-02f, 1.82017282e-01f, -8.48275870e-02f, -1.19584531e-01f, 1.33910611e-01f, -9.88795981e-02f, -2.63349146e-01f, 1.88091919e-01f, -1.39409259e-01f,
  -7.88493901e-02f, 3.99941467e-02f, -4.32168692e-02f, 3.84702146e-01f, -2.79185861e-01f, -6.29548430e-02f, -8.88236314e-02f, 1.25016242e-01f, -1.33084536e-01f, 7.67862573e-02f,
  3.23917600e-03f, -8.61239061e-02f, 2.81337649e-04f, 1.69721488e-02f, -1.65651590e-01f, 1.59467347e-02f, -3.27392966e-02f, -1.66309476e-02f, 4.48598042e-02f, 1.58837419e-02f,
  -4.69584428e-02f, 1.30258784e-01f, 4.34109867e-02f, 5.94053194e-02f, -8.87540579e-02f, 9.07743070e-03f, 1.10801704e-01f, -2.28164140e-02f, 4.03817333e-02f, 4.43633385e-02f,
  -3.01298779e-03f, -5.79776168e-02f, -1.04087614e-01f, -3.32327187e-02f, -4.27361876e-02f, 1.59952696e-03f, 2.38033780e-03f, -2.60206852e-02f, -5.77176549e-02f, -1.13001399e-01f,
  1.77252680e-01f, 2.68697180e-02f, 1.06562234e-01f, -7.84631446e-02f, 6.33495376e-02f, -7.86822066e-02f, 2.25401530e-03f, -7.31167123e-02f, 9.82868392e-03f, -2.00326592e-02f,
  -1.09956294e-01f, -4.67747413e-02f, 3.32132801e-02f, -1.89221017e-02f, -9.72610936e-02f, -3.52358387e-04f, -1.45231606e-02f, -3.34430635e-02f, -3.00746337e-02f, 1.41764702e-02f,
  -2.55174772e-03f, -4.75789458e-02f, -7.56769925e-02f, -7.97484890e-02f, -2.45809164e-02f, -2.53523923e-02f, 9.75806862e-02f, -4.00531776e-02f, -3.80785612e-04f, -3.85208204e-02f,
  -3.54659200e-01f, -3.57571363e-01f, 6.06807927e-03f, 6.32597506e-02f, -6.70227483e-02f, 3.85251231e-02f, -2.34612040e-02f, 2.73015611e-02f, 7.70818442e-02f, -4.34612520e-02f,
  -7.53421113e-02f, -3.94340381e-02f, -1.62715800e-02f, 2.51086093e-02f, 1.33745253e-01f, 5.06197140e-02f, -8.03633109e-02f, 3.67733347e-03f, -1.38609409e-01f, 5.85701726e-02f,
  -7.43582025e-02f, -6.65702373e-02f, -9.38392652e-04f, 2.75273379e-02f, 1.61708631e-02f, -2.56539751e-02f, -7.48795792e-02f, 7.01167807e-02f, -1.38891991e-02f, 1.46778524e-01f,
  1.08228035e-01f, 4.88113850e-01f, 3.00634563e-01f, 2.48078778e-01f, -1.94280416e-01f, -4.76267248e-01f, -3.54399800e-01f, 1.02457888e-01f, -1.10559545e-01f, -1.83668450e-01f,
  -7.72106200e-02f, -6.39582872e-02f, 1.07548311e-01f, 1.20766208e-01f, 2.78527260e-01f, 6.00739419e-02f, -4.25728038e-02f, -1.86247244e-01f, 1.19791746e-01f, 9.71636027e-02f,
  1.30227312e-01f, -3.80738191e-02f, 3.64098758e-01f, 1.53074622e-01f, -1.24326264e-02f, 6.55659512e-02f, 3.48950140e-02f, 5.81185482e-02f, 2.08957326e-02f, -5.51337786e-02f,
  -6.33964241e-02f, 5.34804910e-02f, 6.19039088e-02f, -1.07800113e-02f, 1.89251881e-02f, 5.98874949e-02f, 9.88722313e-03f, 1.14272416e-01f, -7.99081400e-02f, -1.86917931e-02f,
  4.58869115e-02f, 1.57386083e-02f, -3.64498086e-02f, 3.84841003e-02f, -8.21467042e-02f, -4.35307771e-02f, -7.68362880e-02f, 6.99661952e-03f, -8.44317600e-02f, -2.65880637e-02f,
  4.74199690e-02f, 2.75724232e-02f, -1.40451211e-02f, 1.48854494e-01f, 3.22185382e-02f, -2.88492087e-02f, 4.78706183e-03f, 1.43305333e-02f, -8.40096399e-02f, -3.93980145e-02f,
  6.57049417e-02f, -4.24528494e-03f, -3.71785574e-02f, -1.59768071e-02f, 5.82719482e-02f, -1.64776936e-03f, -3.53498384e-02f, -3.16920690e-02f, 5.45585901e-02f, 2.68424414e-02f,
  -4.54388149e-02f, -4.99124937e-02f, -4.48038317e-02f, -7.46714836e-03f, 3.32633266e-03f, -2.47690082e-02f, -4.91420962e-02f, -3.13527659e-02f, -9.26923901e-02f, -1.68172821e-01f,
  -2.06014849e-02f, -9.64768901e-02f, -9.65562910e-02f, -6.23049308e-03f, 8.05316865e-03f, 7.25580528e-02f, 8.75566155e-02f, 2.32260004e-02f, -6.25531971e-02f, -5.70983328e-02f,
  5.68452701e-02f, 2.18150124e-01f, -8.45904499e-02f, -1.49767429e-01f, 7.82563984e-02f, 2.38219071e-02f, 5.38012497e-02f, 6.67965189e-02f, 9.62894186e-02f, 5.84094748e-02f,
  5.42948358e-02f, 8.56756326e-03f, -1.45727135e-02f, 4.83118482e-02f, -6.32567331e-02f, 9.22478735e-02f, 3.57987992e-02f, 3.12221656e-03f, -1.05260788e-02f, 7.41792172e-02f,
  -1.67341176e-02f, -8.61349702e-02f, 5.02395667e-02f, -9.83614773e-02f, -7.01646730e-02f, -6.47073016e-02f, -8.52767974e-02f, -1.01237386e-01f, 1.18791454e-01f, 6.67033270e-02f,
  -2.47221529e-01f, -2.09986314e-01f, -5.67883886e-02f, -2.88075984e-01f, -2.32898250e-01f, -4.12659883e-01f, -7.59258717e-02f, -2.00483263e-01f, -3.28278020e-02f, 7.72648230e-02f,
  -6.03255704e-02f, -1.87370986e-01f, 1.07594311e-01f, -7.06230849e-02f, 1.99859455e-01f, 3.18851829e-01f, -1.26104027e-01f, 1.04853064e-02f, -4.75878231e-02f, -2.94436604e-01f,
  -9.17285308e-02f, -2.00912341e-01f, 2.71138042e-01f, -3.74760717e-01f, -3.49503487e-01f, -3.69751036e-01f, 5.91561534e-02f, -1.61367804e-01f, -2.77775496e-01f, 1.76709760e-02f,
  -2.78570890e-01f, -4.85395566e-02f, -1.45070329e-02f, 2.37281304e-02f, -1.24267034e-01f, -1.19011149e-01f, -1.99530297e-03f, -1.34032264e-01f, 3.28812213e-03f, -3.28795910e-02f,
  -7.20744282e-02f, -1.13048889e-01f, -1.36650205e-01f, -8.21029767e-04f, -1.17552795e-01f, -1.54675487e-02f, 6.14273921e-02f, 6.40575169e-03f, -9.90023091e-02f, -1.78395305e-02f,
  3.34362052e-02f, 5.74872121e-02f, 1.00021608e-01f, 7.84810334e-02f, 1.12661242e-01f, -1.15229547e-01f, 1.20308101e-01f, 2.87161693e-02f, -5.20962849e-02f, 2.14724876e-02f,
  -7.83699527e-02f, 1.34454146e-02f, 1.06234618e-01f, -1.31931007e-01f, -6.79167062e-02f, 7.18123391e-02f, -7.56419525e-02f, 2.56110225e-02f, -7.07473829e-02f, -3.10224108e-02f,
  6.32925250e-04f, 1.77935790e-02f, -8.23609307e-02f, -6.75129816e-02f, -1.50273908e-02f, 1.05459116e-01f, 2.98583396e-02f, -2.45622285e-02f, 1.59941196e-01f, 5.99125922e-02f,
  -1.75389543e-01f, -5.81319369e-02f, 4.98549417e-02f, 5.55513538e-02f, -1.21147335e-02f, 8.73930305e-02f, 9.41258892e-02f, 1.42410606e-01f, -1.90479401e-02f, 2.16159574e-03f,
  -5.09354949e-01f, -4.93115067e-01f, 3.43934111e-02f, -8.50604698e-02f, -7.15066567e-02f, 6.79917447e-03f, -7.63485720e-03f, -2.89618224e-02f, -8.21931362e-02f, -1.17162131e-01f,
  1.11890491e-02f, 1.17641255e-01f, -8.33312050e-02f, -9.82758030e-02f, 2.05914397e-02f, -6.73075020e-02f, -9.07625258e-03f, -9.15157273e-02f, 1.29370511e-01f, -7.58318976e-02f,
  -5.28973602e-02f, 7.44363852e-03f, 1.47806853e-01f, 3.06847505e-03f, -5.91954729e-03f, -7.06777424e-02f, 7.88598973e-03f, -4.83489921e-03f, -6.47591129e-02f, 1.62815414e-02f,
  7.18970150e-02f, -4.68178578e-02f, -2.29263112e-01f, -3.52459364e-02f, -3.04201454e-01f, -5.68737924e-01f, -2.95574993e-01f, -1.22824520e-01f, 5.97143322e-02f, 1.05992593e-01f,
  1.92302093e-02f, 8.91210958e-02f, 1.98457479e-01f, 8.30555707e-02f, -2.57983088e-01f, 4.25894976e-01f, 4.94435243e-02f, -3.52047496e-02f, 2.69211382e-01f, -1.28168343e-02f,
  1.32485926e-01f, -2.21075881e-02f, 2.29452893e-01f, -2.27289572e-02f, -4.50662114e-02f, 2.28780821e-01f, 3.01414549e-01f, -3.45837548e-02f, 6.43912852e-02f, 4.69353143e-03f,
  -1.64863784e-02f, 5.83145991e-02f, -3.18718962e-02f, 2.42040516e-03f, -4.86038532e-03f, 1.38243707e-02f, -5.65346442e-02f, -9.95174199e-02f, -1.48465976e-01f, 1.07171804e-01f,
  -1.59999609e-01f, 1.73552968e-02f, -9.87444967e-02f, 6.98712319e-02f, -3.97145599e-02f, -1.00600444e-01f, 4.70984802e-02f, 4.96597290e-02f, -3.29045318e-02f, 1.49146784e-02f,
  -5.54434136e-02f, -2.70573068e-02f, -1.05464824e-01f, 2.50072200e-02f, -1.15818091e-01f, 9.45007615e-03f, 5.24882376e-02f, 4.60577477e-03f, -5.07216416e-02f, -1.02140352e-01f,
  1.75063685e-02f, 4.08619307e-02f, 5.56717105e-02f, -1.88814700e-02f, 3.84995379e-02f, 2.85023674e-02f, -3.40751372e-02f, 5.74114621e-02f, 5.61514162e-02f, 1.42487168e-01f,
  5.55876195e-02f, 3.50433476e-02f, 2.33547926e-01f, -7.51072094e-02f, -6.98645487e-02f, 6.11115322e-02f, -3.61807086e-02f, 5.50657064e-02f, -3.57439220e-02f, -6.51309416e-02f,
  1.74762920e-01f, 3.16379555e-02f, 2.34734844e-02f, 7.49343783e-02f, -6.63235225e-03f, -1.06978409e-01f, 1.31994803e-02f, 4.93148044e-02f, 4.43920791e-02f, -9.31053162e-02f,
  1.35293797e-01f, 1.33882940e-01f, -9.06453431e-02f, -4.49048318e-02f, 8.51522833e-02f, 1.11447219e-02f, -1.74211338e-02f, -7.89711103e-02f, 9.26548094e-02f, -5.10919653e-02f,
  -2.09169090e-01f, 2.01466326e-02f, 1.04345560e-01f, 5.14337122e-02f, 2.58863214e-02f, 2.98788380e-02f, 1.74525660e-02f, -1.11932449e-01f, 3.59387556e-03f, 5.92191927e-02f,
  -1.87212713e-02f, -5.76109327e-02f, 9.62151121e-03f, -2.15179436e-02f, -1.70385763e-01f, -5.06246352e-06f, -6.23195507e-02f, -1.10455886e-01f, 8.80158916e-02f, 4.90907095e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 8)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 8;
const float L0_fan_Bp_bar_data[] = {
  7.76521862e-02f, 1.11298993e-01f, 1.85192466e-01f, 1.34881034e-01f, 1.19293407e-02f, -2.84698099e-01f, 3.24314117e-01f, -2.48905525e-01f
};

// L1_fan_Wp (Shape: 4 x 16)
const int L1_fan_Wp_rows = 4;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  -3.43210949e-03f, -4.78788644e-01f, -8.81578177e-02f, 7.24780411e-02f, -2.69658655e-01f, -2.90705562e-01f, 4.53930378e-01f, 2.52871346e-02f, -2.39060834e-01f, -3.36008459e-01f,
  -5.65341450e-02f, -8.83823931e-02f, -3.10280859e-01f, 2.46826679e-01f, 2.64484674e-01f, 3.01168144e-01f, -2.28967533e-01f, 2.25618649e-02f, 1.90562397e-01f, -9.66233090e-02f,
  -3.57825369e-01f, 3.84979881e-02f, -1.04516275e-01f, -1.31539032e-01f, -1.28412008e-01f, -2.63847321e-01f, 2.70024776e-01f, 9.10246000e-02f, -3.63934457e-01f, 3.35337549e-01f,
  -5.09558499e-01f, -8.91103521e-02f, -2.20672131e-01f, -1.97809830e-01f, 7.92202130e-02f, 5.09133399e-01f, -2.05290154e-01f, 3.09607655e-01f, -2.91520804e-01f, 4.40826535e-01f,
  8.96281078e-02f, -2.87064761e-02f, 1.69585571e-02f, 1.33337136e-02f, -2.20779717e-01f, 2.73294985e-01f, 2.26083517e-01f, 2.69740731e-01f, -3.45083058e-01f, -3.71846288e-01f,
  2.10539371e-01f, 1.80043504e-01f, 9.90867913e-02f, 5.28352559e-01f, -6.99042857e-01f, 3.63476276e-01f, 1.11391097e-01f, 9.76936296e-02f, 1.51455998e-01f, 3.07412744e-01f,
  -2.35368282e-01f, -1.55630580e-03f, -1.43444300e-01f, -1.33079559e-01f
};

// L1_fan_Wp_bar (Shape: 8 x 16)
const int L1_fan_Wp_bar_rows = 8;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  8.17284212e-02f, 8.46066296e-01f, 1.43043444e-01f, -5.96857183e-02f, 6.97125345e-02f, -7.15619087e-01f, -3.21984023e-01f, -4.85718101e-01f, 2.65699595e-01f, 4.56523299e-01f,
  4.54762667e-01f, 1.28034964e-01f, 2.24860609e-01f, -6.29315019e-01f, 3.34530294e-01f, -4.32210326e-01f, -7.35795125e-02f, -3.87659341e-01f, 1.94740772e-01f, 6.07104063e-01f,
  -1.85777694e-01f, 3.85026366e-01f, 5.22433996e-01f, 5.43544114e-01f, 2.68904388e-01f, -2.73669332e-01f, -4.90645856e-01f, -2.12662473e-01f, 4.81594145e-01f, -1.74819991e-01f,
  2.68657446e-01f, 4.42276783e-02f, 2.12132245e-01f, -3.81094217e-01f, 1.96357116e-01f, -3.69170532e-02f, -2.32082143e-01f, -1.28216267e-01f, 5.30809611e-02f, -5.20581186e-01f,
  -3.73753995e-01f, 1.82457313e-01f, 6.90102428e-02f, -3.52027893e-01f, 1.75740182e-01f, -4.54096973e-01f, 3.78237873e-01f, 2.39072308e-01f, 2.83153623e-01f, 1.43307999e-01f,
  1.28041193e-01f, 2.65519023e-01f, 7.89647549e-02f, -6.21160746e-01f, 7.78912425e-01f, 1.51147693e-01f, -5.21125011e-02f, -3.06147546e-01f, -3.30202490e-01f, -4.00779963e-01f,
  -6.91400826e-01f, -1.60527587e-01f, 3.11251193e-01f, -2.72634178e-01f, 6.38858259e-01f, 2.82989949e-01f, 6.47500828e-02f, 3.34004700e-01f, 5.87515831e-01f, -1.48076072e-01f,
  1.60227165e-01f, 4.52199459e-01f, 7.34181881e-01f, -7.65387654e-01f, -4.42793578e-01f, -3.73272002e-01f, 1.94831654e-01f, 3.99538539e-02f, 2.53717601e-01f, -1.51527241e-01f,
  -1.63608298e-01f, -5.74947178e-01f, -6.29791431e-03f, 5.23001194e-01f, -9.00246650e-02f, 4.59981740e-01f, 4.82139707e-01f, 3.77548099e-01f, -5.35856038e-02f, -3.88108101e-03f,
  -2.33456254e-01f, -1.58314295e-02f, 2.60614008e-01f, -4.11187917e-01f, 3.00137371e-01f, 3.40812981e-01f, 6.10488653e-01f, -3.04124691e-02f, 2.63940454e-01f, 2.25554869e-01f,
  -4.74162191e-01f, -2.70260185e-01f, 6.53981745e-01f, -6.17369175e-01f, -8.06226730e-02f, 3.62304389e-01f, 1.08092964e-01f, -1.89277343e-02f, 7.07016528e-01f, -3.38873118e-02f,
  4.14810389e-01f, 3.66568863e-01f, -2.06216842e-01f, 5.67218304e-01f, 1.49146721e-01f, 3.00570905e-01f, -2.26585612e-01f, -3.13567333e-02f, 1.16587579e-01f, 1.08522542e-01f,
  4.69331414e-01f, 5.83804548e-01f, -3.20831925e-01f, -3.41690511e-01f, 5.80493510e-01f, 2.45493516e-01f, 2.72172421e-01f, -1.80070132e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 8)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 8;
const float L1_fan_Bp_bar_data[] = {
  6.10308290e-01f, 3.39665622e-01f, 8.61670822e-02f, -8.25589523e-02f, 3.64582092e-01f, 3.57402444e-01f, 5.67302704e-01f, -4.31724911e-04f
};

// L2_fan_Wp (Shape: 4 x 16)
const int L2_fan_Wp_rows = 4;
const int L2_fan_Wp_cols = 16;
const float L2_fan_Wp_data[] = {
  1.18946105e-01f, -1.94204897e-01f, 1.99223030e-02f, -2.80973226e-01f, 2.76011750e-02f, 4.39800948e-01f, 2.39324450e-01f, 4.99365538e-01f, -8.00069943e-02f, 1.34432659e-01f,
  -4.50480878e-01f, 1.75527394e-01f, -2.83187091e-01f, -3.05661410e-01f, -1.98279098e-01f, -1.58236668e-01f, -4.14265394e-01f, -1.92748439e-02f, -1.49956018e-01f, 1.30847208e-02f,
  -1.78125367e-01f, -3.61404628e-01f, -1.94023356e-01f, -8.97273868e-02f, 2.05798373e-01f, -3.50772500e-01f, -1.79288074e-01f, 9.56377536e-02f, -2.04305977e-01f, -2.50807166e-01f,
  -3.51856239e-02f, 3.59243274e-01f, 5.21385372e-01f, 3.31396647e-02f, -1.68608084e-01f, 3.45942348e-01f, 2.07205564e-01f, 3.33081663e-01f, -4.21328694e-02f, -1.79613143e-01f,
  1.89998951e-02f, -1.70353293e-01f, -6.85064420e-02f, 3.77343148e-01f, 2.16344446e-01f, -5.85470870e-02f, -1.64814726e-01f, -5.82237065e-01f, 2.22703680e-01f, -4.10457939e-01f,
  9.87449884e-02f, -1.62504539e-02f, 3.70211184e-01f, 4.45031196e-01f, 6.00713551e-01f, 3.17458481e-01f, -2.94851273e-01f, 6.13634214e-02f, -4.82588448e-02f, 5.21934591e-02f,
  -3.05996954e-01f, 4.79320198e-01f, 9.70795155e-02f, -2.12321803e-01f
};

// L2_fan_Wp_bar (Shape: 8 x 16)
const int L2_fan_Wp_bar_rows = 8;
const int L2_fan_Wp_bar_cols = 16;
const float L2_fan_Wp_bar_data[] = {
  4.45235372e-01f, 9.86032039e-02f, 9.71346796e-02f, 6.69787884e-01f, -3.47214229e-02f, 8.91509175e-01f, 3.48101705e-01f, 7.45138109e-01f, 7.15296507e-01f, -4.15860355e-01f,
  -3.25711370e-01f, -2.20659420e-01f, -5.77776022e-02f, -3.08123022e-01f, 2.41290525e-01f, -4.52790737e-01f, 5.20257093e-02f, 3.42064887e-01f, 4.73007858e-01f, 3.02236378e-01f,
  -6.04337215e-01f, -5.52391052e-01f, 4.56863433e-01f, 1.15210581e+00f, 3.96209836e-01f, -2.21455961e-01f, -5.54162502e-01f, -8.67061019e-01f, -1.05964079e-01f, -3.73392031e-02f,
  -4.04079199e-01f, 3.63742560e-01f, 3.14931780e-01f, 2.67740309e-01f, 4.22918648e-01f, 1.39766306e-01f, 5.64249039e-01f, -1.46815553e-01f, 8.71918499e-02f, -7.23490477e-01f,
  3.81423205e-01f, 5.97317815e-01f, 7.30552137e-01f, 4.28114474e-01f, 1.05107032e-01f, 3.12096208e-01f, 8.98537993e-01f, 4.00780827e-01f, 3.31395179e-01f, 6.22227848e-01f,
  9.28012431e-01f, 3.84897202e-01f, -6.60133421e-01f, -8.54702413e-01f, 4.14745927e-01f, 6.79355741e-01f, -1.06839940e-01f, 8.08150530e-01f, -4.19323087e-01f, -6.87964439e-01f,
  1.18760884e+00f, 5.36641300e-01f, -1.08963862e-01f, 5.37061155e-01f, -4.49142694e-01f, 4.02266681e-01f, 1.36967495e-01f, 1.63613319e-01f, -4.12866861e-01f, -9.18134078e-02f,
  -5.99657774e-01f, -2.30426043e-01f, 9.55139697e-01f, -4.52374935e-01f, -1.54781044e-02f, -4.31097686e-01f, -1.82034776e-01f, -4.85699326e-01f, 4.68254060e-01f, 5.45967221e-01f,
  2.12985724e-01f, -6.04426026e-01f, -3.63439351e-01f, 2.42734654e-03f, 2.22142294e-01f, 6.54388309e-01f, 5.02435744e-01f, 8.90612185e-01f, 4.05208588e-01f, -6.20837569e-01f,
  -3.69244367e-01f, 1.18494920e-01f, -5.02231658e-01f, -7.66394556e-01f, -1.96852893e-01f, 4.83028471e-01f, 6.55546546e-01f, 6.05942756e-02f, 1.17123000e-01f, 2.79487878e-01f,
  4.38570559e-01f, 3.46245676e-01f, 9.97650623e-01f, 8.48693430e-01f, -8.74429405e-01f, 5.31118035e-01f, 1.82167873e-01f, -6.17281079e-01f, -3.95258576e-01f, 5.18984199e-01f,
  3.74250859e-01f, -3.56842950e-03f, -6.97495878e-01f, 8.66234004e-02f, 6.35557920e-02f, 2.46293068e-01f, -6.37410641e-01f, -2.26638258e-01f, -6.24889076e-01f, 4.44857851e-02f,
  8.60104859e-01f, -3.26260448e-01f, -2.22057417e-01f, -6.87970638e-01f, -2.61710137e-01f, -3.73687804e-01f, 5.68859875e-01f, 4.99591082e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 8)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 8;
const float L2_fan_Bp_bar_data[] = {
  8.61954987e-01f, 4.15729582e-01f, 3.26923341e-01f, 5.72989225e-01f, 2.60196507e-01f, 6.82762086e-01f, 7.48677313e-01f, 1.60425246e-01f
};

// L3_fan_Wp (Shape: 4 x 16)
const int L3_fan_Wp_rows = 4;
const int L3_fan_Wp_cols = 16;
const float L3_fan_Wp_data[] = {
  -1.67317644e-01f, 2.54559606e-01f, -1.10405241e-03f, -1.56028261e-02f, 3.78921747e-01f, 2.63307840e-02f, -4.50727949e-03f, 2.03475684e-01f, 1.03969447e-01f, -4.67907310e-01f,
  8.21086839e-02f, -4.05784369e-01f, -6.17161915e-02f, 4.36822414e-01f, 1.90558001e-01f, -7.69373402e-02f, -2.34912649e-01f, 1.35849833e-01f, 2.78241634e-01f, -2.98271060e-01f,
  -2.89829224e-01f, -3.37338388e-01f, 9.23295766e-02f, 4.20148611e-01f, 3.06170583e-01f, -4.59899455e-01f, 2.91161090e-01f, 8.75101704e-03f, -1.97528422e-01f, 6.05659604e-01f,
  2.18058690e-01f, -9.62271169e-02f, -7.74986595e-02f, 1.84821323e-01f, -1.35341674e-01f, -1.55505136e-01f, 4.26547825e-01f, -5.33830151e-02f, 3.06517005e-01f, 8.96232203e-02f,
  2.62130499e-01f, 1.29867032e-01f, -3.44619304e-01f, 7.05711916e-02f, -2.88565278e-01f, 9.21423882e-02f, 3.16316277e-01f, -1.49659440e-01f, 2.27453366e-01f, -2.27027670e-01f,
  1.39874622e-01f, 1.20132990e-01f, -4.22438234e-01f, -1.22969653e-02f, -2.17180178e-01f, -2.50743866e-01f, -2.07059115e-01f, 2.92458296e-01f, -3.13723311e-02f, 4.14580613e-01f,
  7.57946223e-02f, -3.64303708e-01f, -5.65790832e-02f, 1.08735107e-01f
};

// L3_fan_Wp_bar (Shape: 8 x 16)
const int L3_fan_Wp_bar_rows = 8;
const int L3_fan_Wp_bar_cols = 16;
const float L3_fan_Wp_bar_data[] = {
  -8.37948844e-02f, -9.82222259e-01f, -1.04318333e+00f, -2.60497034e-01f, 5.76647878e-01f, -3.15191925e-01f, -6.93480611e-01f, 5.85438371e-01f, -3.93130094e-01f, 1.15817226e-01f,
  1.34432808e-01f, 4.79868293e-01f, 2.06206352e-01f, 7.96126202e-02f, 6.63851738e-01f, 5.14423311e-01f, -1.43203706e-01f, -5.27758360e-01f, -2.76412994e-01f, -6.36768043e-01f,
  -1.86301842e-01f, 5.12384593e-01f, 4.05838788e-02f, -6.12314105e-01f, -1.22569993e-01f, 1.35017604e-01f, 4.15274017e-02f, 3.39529216e-01f, 6.12319231e-01f, -5.65771580e-01f,
  -6.48575485e-01f, 9.23079669e-01f, -7.14881495e-02f, -3.59953158e-02f, -5.47723889e-01f, 1.72915503e-01f, 3.59128028e-01f, 5.64328909e-01f, -5.07546604e-01f, 2.30888307e-01f,
  6.63669169e-01f, 4.68501359e-01f, 2.77395606e-01f, -9.40172076e-02f, 6.13372624e-01f, 1.37997758e+00f, -4.19940442e-01f, 6.31705463e-01f, 4.36672717e-01f, 6.64694846e-01f,
  8.78145158e-01f, 2.47640133e-01f, -8.94464731e-01f, 2.50324190e-01f, 4.98722792e-01f, -7.44911671e-01f, 7.58782148e-01f, 6.51440501e-01f, -7.10516050e-02f, 1.09348083e+00f,
  4.29667890e-01f, -3.78931791e-01f, -8.26268733e-01f, 1.16159208e-01f, 6.19792700e-01f, 3.70936662e-01f, 2.74350315e-01f, 1.07117593e-01f, 7.41620719e-01f, -6.87816918e-01f,
  2.96432912e-01f, 8.62462997e-01f, 8.05252969e-01f, 8.94566357e-01f, -3.29998493e-01f, 5.70520103e-01f, -4.63233203e-01f, 6.86954558e-01f, 1.22530043e+00f, -3.62141848e-01f,
  -8.96393880e-02f, 7.49914646e-02f, 3.31341058e-01f, -2.77792007e-01f, 2.69381255e-01f, -5.69448769e-01f, 4.92573738e-01f, 6.22542560e-01f, 6.02855921e-01f, -7.27259040e-01f,
  7.16962814e-01f, -5.43326318e-01f, 2.86479324e-01f, -4.09870921e-03f, 6.89336061e-01f, 1.81678429e-01f, -5.36477983e-01f, -2.91010678e-01f, -6.40847385e-01f, -1.38971537e-01f,
  4.09472495e-01f, 3.61966044e-02f, -9.21955258e-02f, 1.02726594e-01f, -9.62792695e-01f, -5.11595368e-01f, 5.12461305e-01f, 4.90784377e-01f, 1.35067403e-01f, -2.93067932e-01f,
  -1.10566609e-01f, -4.87677343e-02f, -1.61597818e-01f, 5.25730133e-01f, 3.18254471e-01f, 4.87853616e-01f, -4.41578537e-01f, -4.73692894e-01f, -1.15987673e-01f, 1.18299551e-01f,
  -8.06340992e-01f, 2.08263844e-02f, 8.48589182e-01f, 1.26584196e+00f, -3.97997648e-01f, -1.55566767e-01f, 2.06180811e-02f, -7.64018357e-01f
};

// L3_fan_Bp_bar (Shape: 1 x 8)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 8;
const float L3_fan_Bp_bar_data[] = {
  -2.73527682e-01f, -9.23822150e-02f, -4.66478020e-02f, 6.89047396e-01f, 5.05894601e-01f, 6.18681133e-01f, -4.41979803e-02f, 4.27955031e-01f
};

// L4_linear_W (Shape: 12 x 16)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 16;
const float L4_linear_W_data[] = {
  2.20508888e-01f, -5.14683783e-01f, 3.78987044e-01f, -4.44270909e-01f, 5.96932955e-02f, 1.84214085e-01f, 3.25319201e-01f, -9.02743358e-03f, 2.87682265e-01f, -5.12367129e-01f,
  -8.89880300e-01f, -7.50084639e-01f, -2.62138367e-01f, 7.14571103e-02f, 2.48441890e-01f, 3.79172921e-01f, 5.84743857e-01f, 1.45213962e-01f, -1.86768129e-01f, 8.31591845e-01f,
  5.77296197e-01f, 7.09494710e-01f, 3.07274014e-01f, 8.41647565e-01f, 2.95943677e-01f, -3.31226230e-01f, -1.13580942e+00f, -4.01823938e-01f, 5.13812423e-01f, 6.04999185e-01f,
  -1.02264678e+00f, -2.18830213e-01f, 3.79465342e-01f, 4.51234728e-01f, -1.23819616e-03f, 4.39117968e-01f, 6.12616837e-01f, 4.63272095e-01f, 4.07346547e-01f, -5.12737095e-01f,
  -3.05440277e-01f, -6.37288630e-01f, 6.25719249e-01f, 4.23715357e-03f, 2.48195112e-01f, -2.72933662e-01f, 1.19435750e-01f, -9.38609362e-01f, 2.93274730e-01f, -2.59286642e-01f,
  1.58678979e-01f, 8.62678215e-02f, -3.61147761e-01f, -3.75372320e-01f, -2.39908934e-01f, 2.04434648e-01f, 3.75708371e-01f, 5.34704566e-01f, 1.56313792e-01f, -7.62210488e-01f,
  -3.39082390e-01f, 1.36039630e-01f, 1.98275000e-01f, -7.20413387e-01f, -3.21221841e-03f, 1.28771991e-01f, -2.03829110e-01f, 3.85187715e-01f, -1.10233396e-01f, -1.65829360e-01f,
  -1.97139323e-01f, -4.10722941e-01f, 2.90469974e-01f, 1.37871861e-01f, 1.24025814e-01f, -1.98119149e-01f, -6.55728281e-01f, -7.00525999e-01f, 3.79691333e-01f, 3.23363990e-01f,
  -9.12694857e-02f, -1.39643863e-01f, -1.91115260e-01f, -3.84163827e-01f, -6.95819974e-01f, -9.11181927e-01f, 5.85223377e-01f, 1.70861498e-01f, -2.16422290e-01f, -1.24090159e+00f,
  -8.14867914e-01f, 1.52781650e-01f, 3.86405140e-01f, -9.63806152e-01f, -5.01799107e-01f, 3.75169724e-01f, -3.39484870e-01f, -1.57108650e-01f, 6.76944852e-01f, -1.61000058e-01f,
  7.46724680e-02f, -3.82054329e-01f, 7.10633755e-01f, -1.87035650e-01f, -9.06380832e-01f, 1.65048212e-01f, -1.70613497e-01f, 6.58798933e-01f, -2.87641227e-01f, -5.29178739e-01f,
  -5.61855674e-01f, -1.11123815e-01f, -4.58347470e-01f, -2.25735366e-01f, -1.11377209e-01f, 5.09849131e-01f, 3.43958110e-01f, 3.97412986e-01f, 1.96984708e-02f, 1.53708115e-01f,
  2.05282480e-01f, -4.98972178e-01f, 3.20874035e-01f, -9.19546425e-01f, -8.43239784e-01f, 5.25943279e-01f, 2.49587640e-01f, 6.15141131e-02f, -6.61629736e-01f, -5.77122867e-01f,
  -9.92911682e-02f, -7.60904312e-01f, -9.36338082e-02f, 3.65424249e-03f, 1.70309365e-01f, -5.94130456e-01f, -6.03539348e-01f, -3.14168818e-02f, 1.26826484e-02f, -1.19182420e+00f,
  5.60947180e-01f, 7.60195911e-01f, -8.04284737e-02f, -1.10364163e+00f, 3.34400475e-01f, 3.17658603e-01f, 8.67074542e-03f, -4.19392437e-01f, -1.86192289e-01f, 3.48339617e-01f,
  -5.22667408e-01f, 3.04931730e-01f, -1.09519291e+00f, -5.28003871e-01f, -6.42023325e-01f, 2.43815795e-01f, -9.69069004e-01f, -4.96968254e-02f, 1.41006783e-01f, 7.50306964e-01f,
  4.39002931e-01f, 3.29599679e-01f, -2.68626750e-01f, 1.63968235e-01f, -2.35055596e-01f, -4.18615013e-01f, -4.21660453e-01f, 6.94536209e-01f, -9.01247680e-01f, 2.01042771e-01f,
  7.83175826e-02f, 2.99682975e-01f, -9.84730840e-01f, 6.21975780e-01f, -7.91965425e-01f, -5.64923584e-01f, -4.57596958e-01f, -4.33166832e-01f, -1.80049092e-01f, -2.91985214e-01f,
  6.30635396e-02f, -8.55567399e-03f, -5.57091951e-01f, -4.00094628e-01f, 3.06914419e-01f, 2.39640370e-01f, 5.93147039e-01f, 8.13260227e-02f, -6.18297815e-01f, -8.61334145e-01f,
  -8.67675006e-01f, -9.04890418e-01f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  -2.37926841e-01f, 3.02327007e-01f, -2.31092479e-02f, -1.19397128e-02f, 3.74023467e-02f, -1.38369262e-01f, -3.89772914e-02f, -1.28982784e-02f, -8.83546397e-02f, 8.33956376e-02f,
  8.89636502e-02f, 8.13893825e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 4, 8
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 4, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        16, 4, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        16, 4, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        16, 12
    );
    }
    