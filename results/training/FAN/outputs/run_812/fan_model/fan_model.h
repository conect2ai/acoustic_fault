/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 4 x 120)
const int L0_fan_Wp_rows = 4;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -4.34714139e-01f, 1.90857261e-01f, 2.76282847e-01f, 3.65201645e-02f, 6.98771849e-02f, -2.13290490e-02f, 1.19788274e-01f, 2.43234977e-01f, 1.90804247e-02f, 1.10715054e-01f,
  -1.47734120e-01f, -7.84691200e-02f, -2.63554454e-02f, -7.42710605e-02f, -8.20470974e-02f, 3.89253721e-02f, 1.69593200e-01f, -3.94068621e-02f, -5.59088737e-02f, 7.82777146e-02f,
  5.26357964e-02f, 8.58308151e-02f, -1.21496283e-01f, 3.95569727e-02f, 1.74986631e-01f, -1.42976061e-01f, 1.08910099e-01f, -2.38648560e-02f, -1.18088454e-01f, 3.25202972e-01f,
  -2.21570700e-01f, 5.89626059e-02f, 7.89550617e-02f, -9.82503742e-02f, -4.81520826e-03f, -7.40858987e-02f, -9.14101750e-02f, -1.04877967e-02f, -8.41822177e-02f, 1.25188357e-03f,
  3.58378771e-03f, 5.92425428e-02f, -5.26878648e-02f, -1.55344559e-02f, 1.20280730e-02f, 4.72009368e-02f, -3.98964714e-03f, 4.53684367e-02f, -7.96234980e-02f, 4.53814026e-03f,
  1.28131658e-01f, -1.46992821e-02f, -6.89677671e-02f, 5.67175634e-02f, 9.06235129e-02f, 6.36621788e-02f, 2.42105313e-02f, 7.19501078e-02f, 1.46275729e-01f, 3.57997753e-02f,
  -1.64663512e-02f, -8.48437697e-02f, -1.28751658e-02f, -3.04058604e-02f, 8.40042531e-02f, 1.35446908e-02f, 5.25995232e-02f, -3.19171436e-02f, 1.09606758e-01f, -3.74099985e-02f,
  5.39302342e-02f, 2.96154208e-02f, 5.97148426e-02f, -6.44674757e-03f, -7.15873251e-03f, 4.10442166e-02f, 9.76984762e-03f, -7.20622949e-03f, -1.25530455e-02f, 1.57315255e-04f,
  -5.15756644e-02f, -4.40574214e-02f, 5.61685152e-02f, 4.12451401e-02f, -1.37188351e-02f, 4.72950749e-02f, 1.35900471e-02f, -4.61863875e-02f, 6.90087900e-02f, -1.84076484e-02f,
  -6.73502460e-02f, 4.50581387e-02f, 2.33646780e-02f, 7.71622956e-02f, 3.35010365e-02f, -2.00394709e-02f, 2.97642872e-02f, -6.01469167e-02f, -4.19896841e-02f, 1.05812047e-02f,
  -8.10149964e-03f, -8.85140225e-02f, 5.69647662e-02f, 2.28655450e-02f, 2.47271229e-02f, 2.44885497e-02f, -1.60604622e-02f, 6.17411546e-03f, 2.19254158e-02f, 1.51665257e-02f,
  6.12872168e-02f, 5.90300327e-03f, -1.85603574e-01f, -3.01491860e-02f, -3.52398753e-02f, -4.77442481e-02f, -7.64329955e-02f, -2.23783107e-04f, -9.13490281e-02f, -8.36597085e-02f,
  -2.58814216e-01f, 4.15536016e-01f, 3.02196294e-01f, -1.64563749e-02f, 1.30399659e-01f, 4.39210236e-02f, 1.36732355e-01f, -1.22290514e-01f, -1.00795887e-01f, 1.44970700e-01f,
  1.31751776e-01f, -6.56166747e-02f, -1.38832808e-01f, -6.06736057e-02f, -1.37155950e-01f, 1.31376326e-01f, 7.77170807e-02f, -1.45142982e-02f, -3.56151640e-01f, -1.17228717e-01f,
  6.10759133e-04f, 8.77650976e-02f, -7.47999027e-02f, -1.07131816e-01f, 1.23595074e-01f, -3.47489059e-01f, 8.29526931e-02f, 1.80106685e-01f, -8.03148299e-02f, 5.13341129e-01f,
  6.12061433e-02f, 2.35306561e-01f, -1.87433556e-01f, -6.15077429e-02f, 7.49263465e-02f, -7.00611323e-02f, -8.66752770e-03f, -3.00508216e-02f, 1.89118292e-02f, 5.41618317e-02f,
  1.48977796e-02f, -5.23416623e-02f, -4.77098860e-02f, -3.16262171e-02f, 5.51073365e-02f, 3.34058106e-02f, 4.55320030e-02f, -6.02762438e-02f, -5.73036745e-02f, 6.77679107e-02f,
  7.82675147e-02f, 1.21869974e-01f, 4.11363766e-02f, -1.58165973e-02f, -9.40946639e-02f, -1.04765750e-01f, 1.33316712e-02f, -4.34257388e-02f, -1.27001524e-01f, 3.98599282e-02f,
  1.85985770e-03f, 5.49489409e-02f, 9.47954059e-02f, 4.94595729e-02f, -4.39879261e-02f, -2.56932639e-02f, -6.90399436e-03f, -1.02148065e-03f, -2.63074189e-02f, -2.43510734e-02f,
  1.41444849e-03f, -2.43628677e-02f, -1.48270559e-02f, -1.55758113e-02f, 2.18618941e-02f, 2.25362368e-02f, -4.34692251e-03f, -1.55405244e-02f, 6.94154501e-02f, -5.75632788e-02f,
  -3.62590216e-02f, 8.66348743e-02f, -3.29478718e-02f, 7.96507299e-02f, -4.27480182e-03f, 7.04739802e-03f, -6.77720681e-02f, -4.97726947e-02f, -5.53155020e-02f, -1.18498993e-03f,
  -1.80402949e-01f, -4.90556583e-02f, -3.33163664e-02f, -1.09832024e-03f, 1.82339959e-02f, -3.64812687e-02f, 8.51042662e-03f, 1.65581349e-02f, 7.29310289e-02f, 3.24370246e-03f,
  -9.75185446e-03f, 1.78094693e-02f, 1.49122337e-02f, -1.82708614e-02f, -1.17239140e-01f, -2.27101091e-02f, -1.35059021e-02f, -4.97590601e-02f, -5.02782594e-03f, -7.92184006e-03f,
  -4.17631604e-02f, -6.51957169e-02f, -1.39652207e-01f, -1.24154769e-01f, -7.50725791e-02f, -1.24989793e-01f, -3.23758125e-02f, -1.89189151e-01f, -2.21731246e-01f, -2.47178435e-01f,
  -5.16422629e-01f, -5.39598390e-02f, -1.58229426e-01f, -1.37544140e-01f, -1.58948407e-01f, -3.84295374e-01f, -4.01552260e-01f, -1.35601878e-01f, 2.75971703e-02f, -9.66541097e-02f,
  -5.40816970e-03f, 3.16873282e-01f, 1.75641909e-01f, 2.66349465e-01f, 2.15310864e-02f, -2.97812581e-01f, 6.18900079e-03f, 3.02892420e-02f, -1.09780878e-01f, -2.74953961e-01f,
  2.11055726e-02f, 5.13131320e-02f, 1.03516966e-01f, 4.06969301e-02f, 8.09502378e-02f, 1.75264031e-01f, 2.07585797e-01f, -4.08206731e-02f, 7.55936233e-03f, 5.70591271e-01f,
  1.15529105e-01f, -8.70933533e-02f, -2.34448053e-02f, 2.09732316e-02f, 5.02237342e-02f, 1.97377447e-02f, -1.91291291e-02f, 1.02657646e-01f, 1.58969741e-02f, -5.44875413e-02f,
  1.46089271e-01f, 5.27755059e-02f, 4.95225862e-02f, 6.16642833e-02f, 5.62801510e-02f, 1.51559161e-02f, 7.43785203e-02f, 3.71407457e-02f, 4.26784456e-02f, 5.63581809e-02f,
  2.32902039e-02f, -1.48093837e-04f, -5.29466793e-02f, 6.33890852e-02f, -6.29914328e-02f, 2.11367477e-02f, 2.07849108e-02f, -6.72047138e-02f, -6.06164150e-02f, 1.35695279e-01f,
  -1.24507248e-02f, 2.31267288e-02f, 1.15595218e-02f, -6.69462755e-02f, 7.06443470e-03f, -4.00283746e-02f, 1.00020707e-01f, -8.59326625e-04f, 3.11087468e-03f, -5.51023930e-02f,
  5.31439371e-02f, -2.43563894e-02f, 8.39133933e-02f, -2.74472162e-02f, 4.73201424e-02f, -7.54380692e-03f, -2.80242264e-02f, 2.61138678e-02f, 8.02828446e-02f, -2.92923744e-03f,
  -1.10919802e-02f, 1.50294276e-02f, -3.08794174e-02f, 4.50234115e-02f, -7.45294243e-02f, 1.00617977e-02f, 1.15552777e-03f, 3.86903435e-02f, -6.42252788e-02f, -1.65715627e-02f,
  4.82005216e-02f, -3.34085152e-02f, -1.56125706e-03f, 2.62154508e-02f, -1.82529986e-02f, -4.95941862e-02f, -3.86655852e-02f, -1.03356587e-02f, -1.32694729e-02f, -3.73979062e-02f,
  -8.30513984e-02f, -1.44035080e-02f, -1.47925934e-03f, -3.08183506e-02f, -8.36964995e-02f, -1.12146586e-01f, -6.43212870e-02f, 8.99014715e-03f, 1.27082793e-02f, 4.89261448e-02f,
  3.15635838e-02f, -9.45672020e-02f, -1.09998723e-02f, 3.74122560e-02f, 4.19501625e-02f, 9.58169997e-02f, 4.98675369e-02f, -2.23300289e-02f, -1.45757571e-01f, -1.61880061e-01f,
  2.87210673e-01f, -1.64073184e-01f, 2.27316096e-01f, -1.02443039e-01f, -1.30952969e-01f, 2.10197166e-01f, 2.19789565e-01f, 6.21955879e-02f, -7.53666610e-02f, -6.76584989e-03f,
  -1.74459014e-02f, -1.19739383e-01f, -9.96689498e-03f, -2.60945093e-02f, 1.82191461e-01f, 2.63609082e-01f, 2.36178756e-01f, 7.25690126e-02f, 1.70503333e-01f, -8.50777328e-02f,
  -1.29129231e-01f, -1.93027809e-01f, -8.53751972e-03f, -1.03463158e-01f, 1.02158934e-01f, -2.07092658e-01f, -2.72833817e-02f, -4.10113409e-02f, -1.56515479e-01f, 1.51919842e-01f,
  3.57244089e-02f, 1.33110195e-01f, 7.86683708e-03f, -2.76787933e-02f, -1.21901371e-01f, 7.02186441e-03f, 4.83850650e-02f, -4.75174701e-03f, -3.39011215e-02f, 2.81791203e-02f,
  -3.24017443e-02f, -9.83404964e-02f, 7.24346861e-02f, -4.88360822e-02f, -9.35944205e-04f, 5.53866029e-02f, 4.68306690e-02f, 7.40808174e-02f, 1.07385255e-01f, 4.07525226e-02f,
  -3.77326570e-02f, 4.79795039e-02f, 4.00294103e-02f, 2.11325809e-02f, 1.12708181e-01f, 9.20685157e-02f, -4.30386662e-02f, 7.48118460e-02f, 2.05693051e-01f, -8.75178650e-02f,
  -4.90053222e-02f, -1.26730828e-02f, 3.08413748e-02f, -5.91654982e-03f, 9.02763102e-03f, -1.26596764e-02f, 2.32884232e-02f, -7.24239647e-02f, 3.26573215e-02f, -2.74723656e-02f,
  -4.06178683e-02f, 4.71213199e-02f, -2.72236969e-02f, 5.99884894e-03f, 7.70985987e-03f, 6.38854504e-02f, -8.46764888e-04f, 5.71849663e-03f, -2.66738310e-02f, 5.19738868e-02f,
  -5.82661538e-04f, 3.14702578e-02f, -7.29470253e-02f, 8.27196799e-03f, 8.47265869e-02f, 4.78005335e-02f, 3.20371203e-02f, 2.73555834e-02f, -6.81989193e-02f, 9.38980468e-03f,
  -2.78227627e-01f, 2.00112581e-01f, -7.04464540e-02f, 1.60002597e-02f, -2.13325978e-03f, -1.21119933e-03f, 5.82020078e-03f, 1.64359831e-03f, -1.26350466e-02f, -4.84762602e-02f,
  -3.78917414e-03f, 1.96719356e-02f, -4.12947200e-02f, 6.26206282e-04f, 7.31420296e-04f, 1.02944234e-02f, -6.44991398e-02f, 3.52132320e-02f, 1.86504479e-02f, 2.33771168e-02f,
  -5.97970523e-02f, 1.54719234e-03f, -5.81154153e-02f, 3.97252478e-02f, -6.92304075e-02f, 2.59642326e-03f, -7.85458386e-02f, -7.11330473e-02f, 1.16386071e-01f, -3.07039320e-01f
};

// L0_fan_Wp_bar (Shape: 8 x 120)
const int L0_fan_Wp_bar_rows = 8;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  9.14790928e-02f, -1.94705576e-02f, 5.23609072e-02f, 1.30897179e-01f, 3.55981402e-02f, -1.05799422e-01f, -1.46862268e-01f, -9.57264453e-02f, -4.02192697e-02f, 4.36566733e-02f,
  5.21686934e-02f, 6.25849515e-02f, 7.91505426e-02f, 1.03340484e-03f, -1.05250008e-01f, -3.51995230e-02f, -5.30758277e-02f, -5.09229489e-02f, -1.74435601e-01f, -4.39528525e-02f,
  -7.82424882e-02f, -8.37853625e-02f, -3.13662775e-02f, -1.24763213e-02f, 1.91453751e-02f, -8.13823938e-02f, -5.34711033e-02f, 3.21437605e-02f, -1.35220423e-01f, 9.09211263e-02f,
  -1.36778085e-02f, -5.16377054e-02f, -1.77183505e-02f, -4.01219130e-02f, 2.02474333e-02f, 1.13615446e-01f, -1.99112315e-02f, 2.07162462e-02f, 7.17570633e-02f, -4.47774306e-02f,
  -1.42780170e-02f, -7.04633296e-02f, -4.57326928e-03f, 2.42157858e-02f, 8.33895132e-02f, 3.07349898e-02f, -2.40864735e-02f, -4.22769077e-02f, -6.85430244e-02f, 6.83366582e-02f,
  -6.58505708e-02f, -1.92123018e-02f, -3.99279557e-02f, -1.19072385e-01f, -1.39693869e-02f, 2.33341735e-02f, -2.03997754e-02f, -7.46853882e-03f, -1.40986040e-01f, -2.98539735e-02f,
  1.13913342e-01f, -6.21762080e-03f, -6.92008957e-02f, 1.03149235e-01f, 4.19341102e-02f, 3.76132764e-02f, -6.67862073e-02f, 3.87508757e-02f, 2.01220494e-02f, 1.07214257e-01f,
  -5.67795187e-02f, -5.22078760e-02f, -8.73551369e-02f, 6.55892445e-03f, 6.17908202e-02f, 1.07962471e-02f, 2.36591008e-02f, 4.72088903e-02f, -6.13280684e-02f, 1.26187637e-01f,
  -4.27190587e-02f, -4.87300009e-02f, 3.55108567e-02f, -2.34483834e-02f, 6.97684363e-02f, 1.91345811e-04f, 6.67420179e-02f, -6.97426207e-04f, 3.20554674e-02f, -4.00771201e-02f,
  4.60687131e-02f, -2.07554847e-01f, 6.16479944e-03f, -1.28997430e-01f, -3.62071581e-02f, -9.94754434e-02f, -1.15245041e-02f, 4.30144034e-02f, -5.60167879e-02f, -8.95955712e-02f,
  -3.06077935e-02f, -2.73319334e-02f, -5.89189166e-03f, -1.29764089e-02f, -4.26917970e-02f, 4.26351614e-02f, -1.40909284e-01f, -7.42767379e-02f, -8.59116912e-02f, 1.13718992e-03f,
  4.53587696e-02f, -1.49759203e-01f, -9.33935866e-02f, -1.56572774e-01f, -3.56109478e-02f, -1.14139486e-02f, -1.65613517e-01f, -7.81464651e-02f, -1.92354307e-01f, -2.35423204e-02f,
  -3.27122748e-01f, 1.02862515e-01f, 4.68577147e-02f, -1.30848689e-02f, 2.17975959e-01f, 2.74155021e-01f, 5.28267205e-01f, 3.02236497e-01f, 3.83568034e-02f, 5.25146797e-02f,
  -3.53845730e-02f, -5.85475191e-02f, -1.84426010e-01f, 1.03406608e-03f, 1.90708205e-01f, 2.02588141e-01f, 1.85246676e-01f, -1.68446582e-02f, -4.33943532e-02f, 8.41905698e-02f,
  -1.83783693e-03f, -2.07806975e-02f, -1.75347865e-01f, 4.55270931e-02f, 1.06220692e-01f, -1.40200406e-01f, 6.90449774e-03f, 5.39000295e-02f, -3.37490514e-02f, 8.74236673e-02f,
  -1.24623673e-02f, 2.16232628e-01f, -9.64728594e-02f, -5.35062477e-02f, 3.04988287e-02f, 4.77093756e-02f, -8.99982452e-03f, 6.05849475e-02f, 9.15118027e-03f, -1.28756203e-02f,
  -2.99263466e-02f, 7.50865117e-02f, 6.30099475e-02f, -4.13404778e-02f, 3.72799635e-02f, -9.00911614e-02f, 1.71681345e-02f, -6.91411123e-02f, -7.74440467e-02f, -2.28107441e-03f,
  1.16764329e-01f, -1.09906020e-02f, 1.33071199e-01f, 1.15835302e-01f, 1.14772350e-01f, -1.33901417e-01f, 3.60204168e-02f, -4.48137671e-02f, 1.49679944e-01f, -1.36899993e-01f,
  -6.48625866e-02f, 1.19603612e-02f, -1.81389581e-02f, -8.84436071e-04f, -2.82221828e-02f, -1.24807738e-01f, -3.97119001e-02f, 4.54244129e-02f, -4.07992005e-02f, -6.90190718e-02f,
  5.22758067e-02f, -3.70229557e-02f, -8.06820579e-03f, -1.45753464e-02f, -3.02846115e-02f, -6.95289224e-02f, 4.18577641e-02f, 7.21587986e-03f, -6.99312165e-02f, 3.77027690e-02f,
  -1.27714291e-01f, 5.05028442e-02f, 7.46291652e-02f, 1.18425019e-01f, -3.88566628e-02f, 4.34472449e-02f, 6.99194847e-03f, -4.22814898e-02f, -3.94026041e-02f, 1.01953438e-02f,
  -9.93252397e-02f, -5.15683880e-03f, -1.12618707e-01f, -8.38218108e-02f, 6.26968816e-02f, -1.16389774e-01f, -4.99925911e-02f, -4.37453948e-02f, 1.26529699e-02f, 1.75107285e-01f,
  4.69820946e-02f, 7.34953806e-02f, 1.84111297e-02f, -1.03013679e-01f, -5.30506633e-02f, -3.50104198e-02f, -6.67320788e-02f, -2.89326888e-02f, 5.13600409e-02f, 4.24662568e-02f,
  -4.01129238e-02f, 6.14809915e-02f, -3.70043367e-02f, 2.29709316e-02f, 2.88324227e-04f, -1.48557186e-01f, -1.19901896e-01f, -5.69325797e-02f, -6.92155734e-02f, -1.35729462e-01f,
  -4.98763621e-01f, -5.33467047e-02f, 7.91730825e-04f, -1.73978955e-01f, 2.48926133e-02f, 1.37503490e-01f, -9.93136093e-02f, 1.84580460e-02f, -7.00402781e-02f, -2.30076998e-01f,
  -1.55899853e-01f, -1.93801761e-01f, -2.10208878e-01f, -9.92390960e-02f, -2.18000352e-01f, -2.27833614e-01f, -2.21908957e-01f, -2.29349628e-01f, -1.67096496e-01f, 2.49409489e-02f,
  -9.82806012e-02f, -2.35599265e-01f, -1.59018248e-01f, 8.54962468e-02f, -4.74267034e-03f, 5.43417223e-02f, -4.16835062e-02f, -7.48503283e-02f, 2.95483530e-01f, 1.46239819e-02f,
  -1.85611293e-01f, 1.03924386e-01f, 8.34739432e-02f, -1.43053895e-02f, 7.05260858e-02f, -1.66358962e-03f, 7.80278146e-02f, 3.52372788e-02f, 6.35647401e-02f, -9.43112373e-02f,
  -5.66415256e-04f, 1.22634642e-01f, 1.71363112e-02f, 7.16935396e-02f, -9.10335332e-02f, 5.18392771e-02f, 3.38632837e-02f, 5.49864136e-02f, -7.45084733e-02f, -4.79059964e-02f,
  -2.24761721e-02f, 5.67787439e-02f, -8.12048614e-02f, 8.92221034e-02f, 2.01215714e-01f, -3.01685110e-02f, 1.09012775e-01f, 1.80045471e-01f, 1.98849857e-01f, 1.06962413e-01f,
  1.02236770e-01f, 1.47330482e-02f, 8.41278434e-02f, 4.13571931e-02f, 2.14865226e-02f, -3.29031982e-02f, -9.91407931e-02f, -3.93827669e-02f, -1.26413172e-02f, -7.99899548e-03f,
  -3.14058061e-03f, -1.23373650e-01f, -1.08074889e-01f, 2.57621221e-02f, 3.94281149e-02f, -2.75228806e-02f, -2.45182812e-02f, -1.06222451e-01f, -5.06770872e-02f, 3.95800918e-02f,
  3.64980884e-02f, 1.42051533e-01f, -1.00509137e-01f, -2.96533927e-02f, 1.16665952e-01f, 1.44253923e-02f, -2.56397463e-02f, 2.65878644e-02f, -4.36209403e-02f, 2.95843706e-02f,
  -3.27336311e-01f, 4.92589511e-02f, -9.13082361e-02f, -1.54721476e-02f, -2.86103468e-02f, 4.63575199e-02f, -2.55412329e-03f, -4.73654742e-04f, -3.02064642e-02f, 8.18574354e-02f,
  3.59308608e-02f, -7.52830729e-02f, -6.90686479e-02f, 9.99715626e-02f, -7.62424022e-02f, 1.29967406e-01f, 7.18873693e-03f, -1.57190025e-01f, 1.69039704e-02f, 3.54916640e-02f,
  -1.31144777e-01f, -1.54152229e-01f, -1.72616437e-01f, -1.69082507e-01f, 5.11617959e-02f, -1.72441676e-01f, -1.64287269e-01f, -5.45889847e-02f, -7.91232064e-02f, -2.95175105e-01f,
  -3.45236123e-01f, 1.71586052e-01f, 2.42642895e-03f, -3.05339247e-02f, 2.18313709e-02f, -7.88929872e-03f, 1.03717804e-01f, 9.85163357e-03f, -9.84717309e-02f, -7.26043731e-02f,
  7.96815306e-02f, 1.32271260e-01f, 3.15759405e-02f, 4.81454022e-02f, -3.39087695e-02f, -1.95427537e-02f, -7.10231513e-02f, -1.01471275e-01f, 8.27705711e-02f, 1.28156722e-01f,
  2.43864022e-02f, -1.67424351e-01f, -8.72611627e-02f, 5.82032390e-02f, 6.05508359e-03f, 7.07822964e-02f, 1.54839195e-02f, -7.28865042e-02f, 9.33266431e-02f, -1.30919471e-01f,
  2.07452532e-02f, 8.09688866e-02f, 1.70113761e-02f, 2.55730394e-02f, 1.00073926e-01f, 9.59223658e-02f, 1.30669344e-02f, 2.57867482e-02f, 1.35290641e-02f, -3.21116187e-02f,
  -1.13157285e-02f, 9.60259587e-02f, -4.89318185e-02f, 8.29415992e-02f, -2.39269435e-02f, 1.84300151e-02f, 9.69708189e-02f, -4.17270735e-02f, -1.29776057e-02f, 6.47269487e-02f,
  6.27402440e-02f, -1.13835810e-02f, 2.54965816e-02f, 1.14796557e-01f, 2.57048830e-02f, 8.51538256e-02f, 1.66707575e-01f, 1.50949329e-01f, 9.77457315e-02f, -9.18921374e-04f,
  -3.61478538e-03f, -9.45499837e-02f, 6.05544858e-02f, 9.49125290e-02f, -4.84492667e-02f, -2.17744093e-02f, -4.75747958e-02f, -7.84089342e-02f, -2.93519311e-02f, -4.32451814e-02f,
  -1.48828812e-02f, -2.59517040e-02f, 2.34208535e-03f, -1.87161029e-03f, 3.72414626e-02f, 6.80518225e-02f, 1.40475594e-02f, 1.04234718e-01f, -1.31194983e-02f, -7.19560608e-02f,
  -2.09493749e-02f, 4.05307263e-02f, -3.25804092e-02f, 2.16766484e-02f, -3.02046463e-02f, 1.90422572e-02f, 4.63894084e-02f, 6.28690869e-02f, -6.76907087e-03f, -3.83816361e-02f,
  -6.69683367e-02f, 1.07381314e-01f, -2.88051944e-02f, -1.34329703e-02f, -1.06781587e-01f, 9.54729319e-03f, -3.65243629e-02f, 8.41168538e-02f, -1.13727659e-01f, 5.66753931e-02f,
  -9.46153998e-02f, 2.14969255e-02f, 4.78818566e-02f, -1.43904267e-02f, -2.67414376e-02f, -2.45734565e-02f, 2.33608037e-02f, -1.38062373e-01f, 3.01282685e-02f, 3.81121896e-02f,
  1.36908293e-01f, 3.69595475e-02f, 1.17929488e-01f, 1.25887200e-01f, -1.04600735e-01f, 3.35191786e-02f, 2.73591485e-02f, -3.28019969e-02f, -5.96122928e-02f, 5.29866433e-03f,
  4.86383557e-01f, -2.71967590e-01f, 5.26073240e-02f, 1.38875410e-01f, -1.07738987e-01f, -2.65954524e-01f, -5.40614963e-01f, -2.70402938e-01f, 5.14867716e-03f, -5.66217303e-02f,
  -1.16484016e-01f, 9.79070142e-02f, 3.14433053e-02f, 3.17859687e-02f, -1.78623110e-01f, -1.37761489e-01f, 5.12640513e-02f, 1.62586749e-01f, -7.92448819e-02f, -4.88665290e-02f,
  4.83183824e-02f, 2.09565327e-01f, 1.67431787e-01f, -8.06397647e-02f, 8.50763917e-02f, 3.48819457e-02f, -3.47673371e-02f, 1.35263026e-01f, 1.34775966e-01f, 6.61973536e-01f,
  3.20919871e-01f, 7.55847571e-03f, -1.38902245e-02f, 2.55609788e-02f, 9.48345885e-02f, -2.22697128e-02f, 8.25804695e-02f, 5.15998751e-02f, 2.47915499e-02f, -2.95037031e-03f,
  3.36518399e-02f, 1.04155317e-01f, -1.31812826e-01f, 9.46661681e-02f, -7.86764398e-02f, 2.29715207e-03f, 3.06700803e-02f, 4.39134575e-02f, -4.26109955e-02f, -6.89536482e-02f,
  -2.70010177e-02f, 3.45236659e-02f, -1.96287215e-01f, -2.19479367e-01f, -3.15797627e-02f, -3.64754200e-02f, 5.18633844e-03f, 1.08827852e-01f, -4.78337854e-02f, 6.92866370e-02f,
  -5.14593609e-02f, -2.05143020e-02f, -1.33371083e-02f, -6.73690811e-02f, -1.07527554e-01f, 3.47752683e-02f, 4.08359729e-02f, 1.07745379e-02f, -2.15797350e-02f, 1.60996709e-02f,
  -7.00940378e-04f, 2.39287019e-02f, -6.72313049e-02f, -2.65784618e-02f, -9.58027132e-03f, 2.60170992e-03f, -2.21823510e-02f, -4.15794067e-02f, -5.35935443e-03f, -1.06710140e-02f,
  5.91814928e-02f, -8.38416740e-02f, 5.91367930e-02f, -6.65406138e-02f, 5.02058789e-02f, 2.41445806e-02f, 4.28973064e-02f, 3.66826132e-02f, -1.42300902e-02f, 5.91483898e-02f,
  -3.62345353e-02f, -1.35271937e-01f, 1.41322240e-01f, 2.17007101e-02f, 6.01198152e-02f, 7.62621909e-02f, 1.77304130e-02f, 3.69808860e-02f, 1.17233088e-02f, -3.26629616e-02f,
  -2.86946688e-02f, 1.29400650e-02f, -3.75097133e-02f, 7.61188492e-02f, -6.03704108e-03f, 3.47625241e-02f, 4.30186950e-02f, -6.67137951e-02f, -4.26967368e-02f, 1.55238993e-02f,
  4.27751504e-02f, -7.25674853e-02f, -1.40720487e-01f, -1.15427725e-01f, -3.81039307e-02f, -8.34791660e-02f, -4.27392684e-02f, 6.42488822e-02f, -1.57344863e-01f, -1.05090179e-01f,
  -3.40012014e-01f, -1.27559856e-01f, -1.13126770e-01f, -1.47417501e-01f, 9.88811180e-02f, 1.64986238e-01f, -1.31761327e-01f, -7.74711594e-02f, 4.73893881e-02f, -7.61857256e-03f,
  2.31981218e-01f, 1.86493143e-01f, -9.35060997e-03f, 9.31255072e-02f, -3.14441882e-02f, 7.61736333e-02f, 2.73461193e-02f, -1.95083842e-02f, 1.60192594e-01f, 2.00532615e-01f,
  2.03602374e-01f, -9.34678242e-02f, -1.41070753e-01f, 1.87033236e-01f, -6.68132231e-02f, -3.53626050e-02f, -1.73411980e-01f, -1.52909487e-01f, 1.13107160e-01f, -4.91047084e-01f,
  9.87917334e-02f, 2.12050751e-02f, -1.58990901e-02f, -8.38415548e-02f, -5.80323078e-02f, -4.82820831e-02f, -1.61430631e-02f, -5.94769977e-02f, 1.04402332e-02f, 5.68431616e-02f,
  4.07974683e-02f, 1.27165556e-01f, -7.08300918e-02f, 5.28119542e-02f, 2.74477731e-02f, 3.05996016e-02f, -4.30575199e-03f, -1.86675675e-02f, -3.41031365e-02f, 3.37508507e-02f,
  1.05547987e-01f, 1.62374154e-01f, -1.27450347e-01f, -1.03620842e-01f, -2.87697930e-02f, 6.25658706e-02f, -1.46460786e-01f, -1.12943672e-01f, -1.46878034e-01f, -3.68344486e-01f,
  -7.08635002e-02f, -1.11775454e-02f, 1.99560374e-02f, -4.38880660e-02f, -1.01871431e-01f, -1.12849474e-02f, 8.63480940e-02f, -1.09035522e-02f, 3.61399166e-02f, -9.01709870e-02f,
  3.66895348e-02f, 4.75230739e-02f, 1.46885635e-02f, -2.82849483e-02f, 5.25281429e-02f, 6.44938573e-02f, 6.52369410e-02f, 7.47970957e-03f, 2.72003431e-02f, 2.12849025e-03f,
  -1.93503685e-02f, -2.99140122e-02f, 2.18481873e-03f, 1.25947930e-02f, 6.08557649e-03f, 9.26642790e-02f, 8.39158669e-02f, 1.77377351e-02f, -1.12510026e-01f, 1.39439395e-02f,
  -3.37663919e-01f, 1.15041316e-01f, -6.24195382e-04f, 4.60364372e-02f, 7.08920583e-02f, -2.69270763e-02f, -8.81071016e-03f, 4.13329042e-02f, 6.00934811e-02f, -6.01445511e-02f,
  -8.54894891e-02f, -1.63996946e-02f, -6.31332844e-02f, -8.77034813e-02f, -8.50734860e-02f, -1.52152395e-02f, -1.25059858e-01f, -2.60058437e-02f, -2.01292019e-02f, 7.37598315e-02f,
  -3.34373526e-02f, -1.16859779e-01f, -4.22016352e-01f, -2.05996111e-01f, -1.06816933e-01f, -1.47486418e-01f, -1.79549947e-01f, -2.23793551e-01f, -2.43317276e-01f, -5.45127928e-01f,
  -6.57500744e-01f, 8.83649960e-02f, 1.22443840e-01f, -3.72444928e-01f, -1.66951939e-01f, 5.88511005e-02f, 2.06226222e-02f, -1.03307918e-01f, -1.30538866e-01f, -2.66895406e-02f,
  2.71635838e-02f, 1.16056567e-02f, 5.03828861e-02f, 1.94427460e-01f, 6.91108685e-03f, 9.43783596e-02f, -8.64633620e-02f, -1.36270627e-01f, 3.04343384e-02f, 1.47071764e-01f,
  -6.34223074e-02f, -2.29508415e-01f, -3.03774685e-01f, -8.68123993e-02f, 5.70287183e-02f, -9.47969034e-02f, -8.27328637e-02f, -8.04384872e-02f, 2.16699153e-01f, -1.63287595e-02f,
  2.84931391e-01f, -5.04863746e-02f, -4.87897471e-02f, -1.70708969e-01f, -6.83463886e-02f, -1.10742133e-02f, 1.02738328e-02f, -6.93408251e-02f, 2.00941339e-02f, -2.65508834e-02f,
  -5.30973747e-02f, -4.10943553e-02f, -1.62060678e-01f, 4.56622317e-02f, -2.18998920e-02f, -2.69490387e-02f, 2.93448977e-02f, -4.63785790e-02f, 1.95298735e-02f, 1.31915346e-01f,
  1.01503460e-02f, -5.17308153e-02f, 9.18110386e-02f, 1.14365920e-01f, 8.12779069e-02f, -2.29074080e-02f, 7.44791925e-02f, 5.70366979e-02f, 3.36904377e-02f, -1.19274305e-02f,
  3.13054211e-02f, -2.91846674e-02f, -4.98888083e-02f, -7.27100447e-02f, 2.43673660e-02f, -9.68548842e-03f, -1.65570658e-02f, 9.33478177e-02f, -1.81819983e-02f, -2.37314645e-02f,
  2.87766792e-02f, 5.44650219e-02f, -3.39655690e-02f, -6.77203387e-02f, 2.13748403e-02f, -3.04711238e-02f, -1.34635866e-01f, 6.39813319e-02f, 5.25521636e-02f, 6.16108766e-03f,
  4.40015383e-02f, -3.60484421e-02f, -8.75763744e-02f, 6.60738572e-02f, 5.65776490e-02f, 3.39550115e-02f, -1.48790982e-02f, 9.46732610e-02f, -5.77902049e-02f, -3.47555466e-02f,
  1.15597621e-01f, -3.33016589e-02f, -7.19622672e-02f, -7.41870515e-03f, -2.23893151e-02f, 1.50238378e-02f, -2.81753298e-02f, 6.82343245e-02f, -7.72655904e-02f, -1.67252719e-02f,
  -2.04902980e-03f, 7.10655190e-03f, -1.48745738e-02f, 2.78227609e-02f, 6.12123832e-02f, -4.68759164e-02f, -3.23207676e-02f, 6.28239140e-02f, 1.70177054e-02f, 1.91420205e-02f,
  1.62802525e-02f, 4.64194342e-02f, 7.40444362e-02f, 1.27029112e-02f, -1.63870268e-02f, -1.09171756e-02f, 9.25727338e-02f, 1.04365095e-01f, -4.12036590e-02f, 2.25063059e-02f,
  2.45745242e-01f, -2.65810549e-01f, 4.01559412e-01f, 1.89535350e-01f, 2.60452449e-01f, 3.03679883e-01f, 2.75069356e-01f, 1.15024589e-01f, -5.17850928e-02f, 9.82485246e-04f,
  -1.54226691e-01f, -2.32111990e-01f, -3.58905792e-01f, -3.50841194e-01f, -8.89210999e-02f, 4.50929552e-02f, 6.44757375e-02f, -3.42782661e-02f, 1.62532136e-01f, 3.08891565e-01f,
  -7.38352686e-02f, -2.31469460e-02f, 1.73893739e-02f, 2.03966219e-02f, 2.51045488e-02f, 5.57576157e-02f, 8.42139572e-02f, 5.80674782e-02f, -3.44438329e-02f, -8.43669176e-02f,
  4.44677658e-02f, 7.08581805e-02f, 9.96987671e-02f, -1.03799939e-01f, 1.34214954e-02f, 4.45313789e-02f, -1.03064291e-02f, 5.60223460e-02f, 1.08060479e-01f, -3.04622054e-02f,
  -4.91697574e-03f, 7.14404183e-03f, 1.54611496e-02f, 6.34569675e-02f, 6.50275871e-02f, 1.37028769e-01f, -3.45209204e-02f, -7.07627013e-02f, -2.81399414e-02f, 4.04927656e-02f,
  -1.65207282e-01f, 3.82259600e-02f, 5.58024049e-02f, 1.38671786e-01f, 9.97283608e-02f, -6.93461113e-03f, 1.05775908e-01f, 1.25588821e-02f, 3.80139388e-02f, -2.07995344e-03f,
  6.65887296e-02f, -2.87208147e-02f, -3.45731117e-02f, -9.17497091e-03f, -4.99202386e-02f, -3.29356603e-02f, 9.40476134e-02f, -3.22034359e-02f, -8.92923679e-03f, 5.18611409e-02f,
  -3.05985939e-02f, 2.11637877e-02f, -1.61065534e-02f, 3.93509530e-02f, -1.06158175e-01f, 2.47146599e-02f, 5.05982526e-03f, -3.89928073e-02f, -7.11390227e-02f, 3.01789362e-02f,
  -3.72000709e-02f, -2.85299718e-02f, 4.56583537e-02f, -7.66391307e-02f, -2.22885553e-02f, -1.90564641e-03f, -3.60875693e-03f, -2.87727453e-03f, 5.58332959e-03f, 8.95378366e-02f,
  -2.56918252e-01f, -8.15687552e-02f, -1.24835586e-02f, -9.63496119e-02f, 8.71017501e-02f, -1.22371353e-01f, -4.69866358e-02f, -2.40226667e-02f, -1.38758138e-01f, -2.28390396e-02f,
  -1.00626647e-01f, -3.87925915e-02f, -1.06150776e-01f, 5.49162924e-02f, 1.40467823e-01f, 4.37981561e-02f, -1.95594028e-01f, 1.98034607e-02f, -6.41901791e-02f, -9.75882709e-02f,
  -3.63599584e-02f, 1.20255336e-01f, 1.02841087e-01f, 4.01181392e-02f, -5.71473725e-02f, 1.34161234e-01f, -6.22202526e-04f, 3.94738913e-02f, 6.39552101e-02f, 4.53134365e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 8)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 8;
const float L0_fan_Bp_bar_data[] = {
  4.57713706e-03f, 1.05437748e-01f, 6.70928061e-02f, -2.74865404e-02f, 1.93678990e-01f, 8.70963410e-02f, -4.05624099e-02f, -1.44472988e-02f
};

// L1_fan_Wp (Shape: 4 x 16)
const int L1_fan_Wp_rows = 4;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  1.77582547e-01f, -1.33498624e-01f, -2.08609160e-02f, 9.61463079e-02f, -3.67781296e-02f, 7.06346557e-02f, 4.16567653e-01f, -4.65165645e-01f, -1.25208542e-01f, -8.21559504e-02f,
  -1.54013813e-01f, 2.66601950e-01f, -2.30900082e-03f, 8.59268010e-02f, 1.56916007e-01f, -2.99849570e-01f, 4.05186787e-02f, 2.23229766e-01f, -1.31998748e-01f, 4.48691135e-04f,
  -2.89610952e-01f, -4.42246735e-01f, 6.62564486e-02f, -5.20298898e-01f, 3.13814998e-01f, -3.17205280e-01f, -3.23327035e-02f, -1.64487451e-01f, 4.28869963e-01f, -2.03018002e-02f,
  -3.31405669e-01f, -6.71776244e-03f, -5.62950611e-01f, -3.85483891e-01f, 2.93093145e-01f, -3.17271948e-02f, -2.64378130e-01f, -2.69090254e-02f, -9.46569666e-02f, 5.92578053e-01f,
  1.06516793e-01f, 3.73741001e-01f, -2.41539776e-01f, 1.70377698e-02f, 1.88451540e-02f, -2.83540428e-01f, -7.04471111e-01f, 3.00363153e-01f, -3.42688501e-01f, -2.47329567e-02f,
  2.07104668e-01f, -1.07881971e-01f, -3.35508287e-01f, 4.53824401e-02f, -2.22368747e-01f, 8.37578923e-02f, 6.11409135e-02f, -1.51399942e-02f, -4.80649322e-01f, -1.68967098e-02f,
  -1.22112267e-01f, -4.95714396e-01f, 1.23580107e-02f, 1.36658609e-01f
};

// L1_fan_Wp_bar (Shape: 8 x 16)
const int L1_fan_Wp_bar_rows = 8;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  1.26130566e-01f, -3.05078536e-01f, 7.47154579e-02f, -7.15733469e-02f, 2.04363480e-01f, 6.03019446e-02f, -8.73749182e-02f, -1.25815645e-01f, 6.49145916e-02f, 1.79881662e-01f,
  -5.91991208e-02f, 4.52354580e-01f, 1.06927954e-01f, 4.03286099e-01f, 3.37341353e-02f, -9.48596224e-02f, 3.84540781e-02f, 2.54706889e-01f, 4.05123651e-01f, 5.88621914e-01f,
  5.05187750e-01f, 8.62094581e-01f, 7.67359138e-01f, 5.47299862e-01f, 1.76857337e-01f, 1.69037461e-01f, 2.46746123e-01f, -1.96309239e-01f, 7.18906581e-01f, -3.61442403e-03f,
  -1.98799089e-01f, -2.50099599e-01f, 2.93282032e-01f, 3.37685406e-01f, -2.48894602e-01f, 5.69619127e-02f, -1.88611686e-01f, -2.31348634e-01f, -3.22043478e-01f, 2.03216891e-03f,
  -1.02998547e-01f, -2.03393564e-01f, -1.36496022e-01f, -1.50425002e-01f, 9.12958235e-02f, -1.71579346e-01f, 1.60024896e-01f, 1.25448868e-01f, 3.87148499e-01f, 4.24530983e-01f,
  2.18705535e-01f, -4.06990647e-02f, 6.25898391e-02f, -1.96314394e-01f, -8.79684687e-02f, -4.06466246e-01f, -3.79078463e-02f, -3.82036954e-01f, 5.63456297e-01f, 1.80745602e-01f,
  -6.66206330e-02f, 6.73422694e-01f, 2.36625165e-01f, -2.23318174e-01f, 2.44779646e-01f, 1.19778015e-01f, -2.96250105e-01f, 2.66132563e-01f, 5.38275018e-02f, -1.12403147e-01f,
  -5.53697586e-01f, -1.45353839e-01f, -2.40398109e-01f, -7.97871649e-02f, -7.85662234e-02f, -1.09125569e-01f, -9.76724178e-02f, -2.49323383e-01f, 1.18519485e-01f, 7.09817827e-01f,
  1.24107681e-01f, 2.20755577e-01f, 4.12077546e-01f, 3.26567709e-01f, -1.42335013e-01f, 1.22688219e-01f, -9.20435041e-02f, -1.37298703e-01f, -1.69622332e-01f, 1.18610531e-01f,
  6.38894200e-01f, -2.61973590e-02f, -3.17071497e-01f, 5.84149301e-01f, 3.19008529e-01f, 7.16194436e-02f, -1.34228945e-01f, -2.57145166e-02f, -1.19862989e-01f, -6.79099783e-02f,
  -1.97622448e-01f, 1.80481628e-01f, 7.20383078e-02f, 5.59242768e-03f, -2.71289982e-02f, 3.17808777e-01f, -1.93821102e-01f, 1.70396358e-01f, -2.30241790e-02f, 3.09294015e-01f,
  -1.36434630e-01f, -9.59649533e-02f, 3.37880731e-01f, 1.82031959e-01f, 1.93281144e-01f, 2.48132944e-01f, -7.39223287e-02f, 4.63548332e-01f, 4.34698313e-01f, -1.03151491e-02f,
  3.24365497e-01f, -4.04547632e-01f, 1.01033255e-01f, -1.67635977e-01f, 6.81131899e-01f, -2.10674256e-01f, -1.35591209e-01f, -2.70143628e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 8)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 8;
const float L1_fan_Bp_bar_data[] = {
  -8.94072652e-02f, 7.87396610e-01f, 6.95290267e-02f, 3.77094179e-01f, 2.71260738e-01f, 1.09732628e-01f, 7.12897852e-02f, 2.15134770e-01f
};

// L2_fan_Wp (Shape: 4 x 16)
const int L2_fan_Wp_rows = 4;
const int L2_fan_Wp_cols = 16;
const float L2_fan_Wp_data[] = {
  -2.22131118e-01f, 1.48181885e-01f, 3.93998474e-01f, 3.96537364e-01f, -3.57686967e-01f, 2.80571043e-01f, 3.91204655e-01f, 3.36120158e-01f, -3.22291404e-01f, -5.23942634e-02f,
  -2.48849448e-02f, -2.29508162e-01f, 1.47917703e-01f, -5.95451817e-02f, -1.62201494e-01f, -4.07120325e-02f, 1.56857193e-01f, 1.22984916e-01f, 1.63423941e-01f, 3.24608654e-01f,
  -2.36512229e-01f, 3.83629322e-01f, -7.80642256e-02f, 2.40630135e-01f, -3.21211070e-01f, -1.98043868e-01f, 2.39410564e-01f, -1.47392005e-02f, 8.74723196e-02f, 5.24355099e-02f,
  -1.12215444e-01f, -5.90546057e-02f, -2.97573149e-01f, -4.52929646e-01f, 1.66895583e-01f, 6.09713793e-02f, 6.06389977e-02f, 4.91654307e-01f, 1.84550107e-01f, -1.88378002e-02f,
  2.28625268e-01f, 2.56635725e-01f, -1.12243704e-01f, -3.08936983e-01f, -1.96681023e-01f, -4.03902054e-01f, 2.19771683e-01f, 1.13820709e-01f, -5.62310545e-03f, -3.77888530e-02f,
  2.42351405e-02f, 9.44209248e-02f, 5.44915646e-02f, -5.45785427e-01f, -5.09038232e-02f, 1.43575314e-02f, 2.92508662e-01f, 5.10215163e-01f, -2.79886723e-01f, -1.21713718e-02f,
  -3.04057658e-01f, -8.11399892e-02f, 2.09275648e-01f, 3.09891403e-01f
};

// L2_fan_Wp_bar (Shape: 8 x 16)
const int L2_fan_Wp_bar_rows = 8;
const int L2_fan_Wp_bar_cols = 16;
const float L2_fan_Wp_bar_data[] = {
  2.18169525e-01f, 3.09851140e-01f, 3.06585670e-01f, 3.11730057e-01f, 3.51493537e-01f, 4.38143373e-01f, -1.66135624e-01f, 1.25078067e-01f, -1.24175303e-01f, 9.55915451e-01f,
  4.11377251e-02f, -1.76599905e-01f, -2.08355173e-01f, -2.08545327e-01f, 1.67039931e-01f, 6.47611916e-01f, 2.19339982e-01f, 1.66702390e-01f, -2.11465910e-01f, -9.75132659e-02f,
  1.39945090e-01f, 4.19829071e-01f, -5.54559112e-01f, -4.70118970e-01f, 5.87086789e-02f, 2.71297425e-01f, 9.54207033e-02f, 5.71608663e-01f, -1.13570787e-01f, 4.47781757e-02f,
  8.53638873e-02f, 2.06900954e-01f, 3.88521373e-01f, 2.46089354e-01f, 6.29339933e-01f, 4.34458047e-01f, -4.40226018e-01f, -1.38065249e-01f, 5.11541486e-01f, -1.26426369e-01f,
  -2.87939966e-01f, 2.33932838e-01f, 2.94322222e-01f, -3.89187992e-01f, 6.97937727e-01f, 7.69528598e-02f, -1.32811353e-01f, 1.17660925e-01f, -1.93754863e-02f, 4.14274037e-02f,
  -2.61891633e-01f, 3.69798243e-02f, 2.86351800e-01f, 1.80950880e-01f, -3.46576571e-01f, 9.14798230e-02f, -2.49703825e-01f, -3.24497432e-01f, 2.05884278e-02f, 2.51360208e-01f,
  6.60580758e-04f, 2.79190708e-02f, -1.00359924e-01f, -1.26622036e-01f, -1.61031634e-01f, -1.49935737e-01f, -1.31055359e-02f, 1.75455630e-01f, 7.16503337e-02f, 7.16243088e-02f,
  -7.74296671e-02f, 2.33798269e-02f, -1.44132301e-01f, -2.16186374e-01f, 7.00188875e-02f, -1.27724648e-01f, 1.01931244e-01f, 6.95282891e-02f, -1.00686990e-01f, -2.41017625e-01f,
  1.48000658e-01f, 8.63288064e-03f, 2.99964279e-01f, 3.26060116e-01f, 1.34557933e-01f, -2.42551938e-02f, 3.70973945e-02f, -2.90761679e-01f, -2.11206555e-01f, 1.07720625e+00f,
  -1.71319500e-01f, -1.18567511e-01f, -3.55882555e-01f, -2.23141223e-01f, -2.25934386e-01f, 6.62881136e-01f, 2.11240962e-01f, 4.03199762e-01f, 8.58632326e-02f, -2.46894285e-01f,
  3.73158962e-01f, -1.92922682e-01f, -5.28028369e-01f, -5.73669858e-02f, 6.32218495e-02f, 1.05782777e-01f, 4.96161208e-02f, 8.65193903e-01f, -2.37331182e-01f, 8.52192998e-01f,
  2.67044771e-02f, -4.60433736e-02f, 4.97872055e-01f, -3.20382684e-01f, 5.46673715e-01f, 3.00917059e-01f, -2.90017933e-01f, -8.87285948e-01f, 6.09613001e-01f, -2.82307327e-01f,
  7.79405609e-02f, 8.35119605e-01f, -1.90382808e-01f, -1.87934712e-01f, -2.94372082e-01f, 4.41143602e-01f, 1.48148954e-01f, -3.56511712e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 8)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 8;
const float L2_fan_Bp_bar_data[] = {
  1.71916783e-01f, 2.14404911e-01f, 3.78016382e-01f, 3.74231100e-01f, -2.12926984e-01f, -3.91248688e-02f, 1.26253068e-01f, 4.52592403e-01f
};

// L3_fan_Wp (Shape: 4 x 16)
const int L3_fan_Wp_rows = 4;
const int L3_fan_Wp_cols = 16;
const float L3_fan_Wp_data[] = {
  -2.78662175e-01f, 2.41620511e-01f, -4.72426191e-02f, 4.37211961e-01f, 2.50213705e-02f, 2.58631885e-01f, -4.35167670e-01f, -1.42464548e-01f, -2.06543609e-01f, 3.16393495e-01f,
  5.15845455e-02f, 1.28785118e-01f, 6.16878755e-02f, -3.03452700e-01f, 1.73326835e-01f, -3.11565340e-01f, 3.41945559e-01f, -3.83509159e-01f, -3.02419197e-02f, -2.93713629e-01f,
  3.34186852e-01f, 1.20401978e-01f, 3.28862160e-01f, -2.29499146e-01f, 1.11740552e-01f, -1.60722777e-01f, -1.25723928e-01f, -2.33530939e-01f, 3.28732119e-03f, 4.57212359e-01f,
  -2.87326515e-01f, 5.12815833e-01f, -3.56037676e-01f, -1.64817646e-01f, -1.86286524e-01f, 6.37576357e-02f, -6.41851798e-02f, 1.82514757e-01f, -2.82081574e-01f, 2.64784619e-02f,
  -3.20711672e-01f, 1.92208380e-01f, 2.45175958e-01f, -2.02167109e-01f, -2.48212025e-01f, -3.19725394e-01f, 3.66179079e-01f, -2.74305135e-01f, -4.26499732e-02f, 2.50754684e-01f,
  2.73796767e-01f, 4.99984156e-03f, 4.35375839e-01f, 5.30949794e-03f, 3.34239393e-01f, -2.48189449e-01f, 3.62047940e-01f, -2.28630632e-01f, 3.40245903e-01f, -1.14024207e-01f,
  -1.68347925e-01f, -5.49072325e-02f, -3.50216299e-01f, 3.79656434e-01f
};

// L3_fan_Wp_bar (Shape: 8 x 16)
const int L3_fan_Wp_bar_rows = 8;
const int L3_fan_Wp_bar_cols = 16;
const float L3_fan_Wp_bar_data[] = {
  -7.62679636e-01f, 1.87871397e-01f, -4.83918309e-01f, -2.34681457e-01f, -2.25450248e-01f, -4.44838852e-01f, -2.62609839e-01f, 1.13611005e-01f, -3.90684068e-01f, 3.32394958e-01f,
  -2.41427064e-01f, -2.03206420e-01f, 1.03990354e-01f, -2.41546988e-01f, 9.47017848e-01f, 4.06861871e-01f, 3.71152125e-02f, 2.31587663e-01f, 2.62320668e-01f, -9.96482000e-02f,
  4.63649482e-01f, 3.25947613e-01f, 1.10473707e-01f, -3.26061934e-01f, 7.80470222e-02f, -4.03517246e-01f, 7.70752013e-01f, 1.72001660e-01f, 2.44110003e-01f, 1.70239031e-01f,
  -3.74821723e-01f, 4.16708261e-01f, 5.16308784e-01f, 1.30468056e-01f, 4.54121768e-01f, 4.24634755e-01f, 5.48375070e-01f, 6.06241465e-01f, -4.02493805e-01f, -5.33015192e-01f,
  1.72358509e-02f, 2.03677416e-02f, 8.48760009e-01f, -1.26761347e-01f, -1.08836479e-01f, 1.73152581e-01f, -1.55000925e-01f, -1.89627796e-01f, 5.53521141e-02f, 3.33032794e-02f,
  7.58845061e-02f, -5.49538672e-01f, -1.79763854e-01f, -1.55744657e-01f, 5.24224222e-01f, 3.79049808e-01f, 1.02236307e+00f, 3.53821248e-01f, -2.98962053e-02f, -1.52381256e-01f,
  5.63064925e-02f, 1.14267850e+00f, 2.94884052e-02f, 2.70627499e-01f, -2.02336516e-02f, 8.89636278e-02f, -1.21306732e-01f, -4.14486647e-01f, -3.02792639e-02f, 1.37707353e-01f,
  3.19300830e-01f, -6.14782721e-02f, 6.28557503e-01f, 3.91081095e-01f, 1.71574727e-01f, -2.23569661e-01f, -1.37191772e-01f, 3.98386538e-01f, -7.26114362e-02f, -2.27804929e-01f,
  2.68270046e-01f, 5.23237348e-01f, 5.17113388e-01f, 4.72783297e-01f, 4.58762527e-01f, -5.64277247e-02f, 1.84339598e-01f, 7.35972464e-01f, 1.35828525e-01f, -4.42895532e-01f,
  5.15239239e-01f, -7.48647749e-02f, -3.60386893e-02f, 2.89002230e-04f, 1.30142588e-02f, 1.30828547e+00f, -1.28347844e-01f, 4.36277479e-01f, -3.26845765e-01f, 2.40672529e-01f,
  -2.83926249e-01f, 3.27744722e-01f, -1.99249625e-01f, -2.67946631e-01f, -1.00411914e-01f, 2.57628947e-01f, -3.01178366e-01f, 4.23011124e-01f, -5.87506406e-02f, -5.37189662e-01f,
  3.85260105e-01f, -4.22568440e-01f, 8.81713688e-01f, 4.21686441e-01f, 7.35700130e-01f, 8.90107393e-01f, -1.49451822e-01f, 3.63461822e-01f, -7.33888745e-01f, 2.90060565e-02f,
  5.03005207e-01f, 4.23581898e-01f, -3.69155377e-01f, 2.87200660e-01f, -8.13094676e-02f, -1.61975861e-01f, 7.04777002e-01f, -7.02372015e-01f
};

// L3_fan_Bp_bar (Shape: 1 x 8)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 8;
const float L3_fan_Bp_bar_data[] = {
  1.46064430e-01f, 1.62268847e-01f, 5.09518564e-01f, 4.32986617e-02f, -4.99866083e-02f, 2.61479855e-01f, 2.22198114e-01f, 7.95457482e-01f
};

// L4_linear_W (Shape: 12 x 16)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 16;
const float L4_linear_W_data[] = {
  -8.43933403e-01f, -2.75638491e-01f, -2.08944634e-01f, 7.27854595e-02f, 2.96185073e-03f, 1.69674903e-02f, 1.31403878e-01f, -2.74023324e-01f, 6.23221219e-01f, -1.06707834e-01f,
  -4.25216883e-01f, -5.47892749e-01f, -1.34221271e-01f, -2.09957123e-01f, 6.43515885e-01f, 2.11622730e-01f, 8.99500847e-01f, 5.61792433e-01f, 6.69364333e-01f, 1.17437296e-01f,
  -2.01764300e-01f, 2.47641712e-01f, -4.52714294e-01f, 1.00210190e+00f, -3.41373295e-01f, 1.85821071e-01f, 3.08588684e-01f, -3.00000161e-01f, -1.54667184e-01f, 7.55919158e-01f,
  -3.29340369e-01f, 4.28070486e-01f, -4.97817947e-03f, 5.47022708e-02f, -3.54037434e-02f, 8.62871706e-01f, -1.10713291e+00f, 7.50767171e-01f, -6.41551733e-01f, 2.04803139e-01f,
  -2.36298770e-01f, -4.06163067e-01f, -8.75460953e-02f, 6.13818645e-01f, 3.52381706e-01f, -3.01534869e-03f, -2.52422214e-01f, 1.64532319e-01f, 2.20564343e-02f, -1.85311362e-01f,
  -2.48298272e-01f, -1.97851598e-01f, 7.70042896e-01f, -4.63161945e-01f, 6.16478682e-01f, -7.33933926e-01f, 1.02279055e+00f, -2.20012795e-02f, -7.00514615e-02f, -3.24770391e-01f,
  -1.87216282e-01f, 6.78973943e-02f, 8.23426023e-02f, -4.14344609e-01f, -9.67460424e-02f, -9.62448493e-02f, 4.50400174e-01f, -5.24006374e-02f, 3.80326390e-01f, -2.58545399e-01f,
  6.77844703e-01f, -8.60573292e-01f, 2.45951489e-01f, -4.17821296e-02f, -6.02104008e-01f, 4.21369612e-01f, 2.98832268e-01f, -3.33559006e-01f, -2.75214106e-01f, 3.13814253e-01f,
  3.81622434e-01f, 5.99988222e-01f, 5.99253833e-01f, 7.49074936e-01f, 2.85526425e-01f, -8.81167501e-02f, 1.64816678e-01f, 2.40419507e-01f, -6.10087395e-01f, -7.30365664e-02f,
  7.73051500e-01f, -2.38899469e-01f, -5.73041588e-02f, -3.75715464e-01f, -1.95180371e-01f, 9.75776911e-01f, -1.30221054e-01f, 1.79651245e-01f, 1.03610657e-01f, -2.86020100e-01f,
  7.94951022e-02f, -1.25011906e-01f, 5.61773896e-01f, -2.94328213e-01f, -2.81763881e-01f, 5.85899591e-01f, -6.67494386e-02f, 6.06691837e-01f, 4.69366848e-01f, -4.98974882e-02f,
  -2.26669669e-01f, -6.61884487e-01f, -6.24501646e-01f, -6.88675046e-01f, -6.56440139e-01f, -4.97399747e-01f, -5.05868137e-01f, -3.78492743e-01f, -2.68826127e-01f, 1.73579976e-01f,
  -4.09509614e-03f, 3.61769907e-02f, -4.59900111e-01f, 3.52208257e-01f, -2.07504049e-01f, 8.14009905e-01f, -6.66288212e-02f, -5.32629490e-01f, 5.27601898e-01f, 3.53293449e-01f,
  1.34968102e-01f, -5.42298198e-01f, 2.15926111e-01f, 1.37796670e-01f, -3.20555060e-03f, 7.71009326e-01f, -1.53220063e-02f, 7.40214646e-01f, 9.61301386e-01f, -6.84322059e-01f,
  1.59128308e-01f, 9.05862004e-02f, -2.79632539e-01f, -8.09363067e-01f, -7.11815178e-01f, -5.68359554e-01f, -7.61842132e-01f, -3.09508920e-01f, -3.19436975e-02f, -2.25517675e-01f,
  1.49502739e-01f, 7.49632657e-01f, -2.70182669e-01f, -3.06768775e-01f, -2.89597511e-01f, 8.23353708e-01f, 5.47432423e-01f, -4.26461607e-01f, -1.16338290e-01f, -4.56554055e-01f,
  -4.63333121e-03f, 4.61638384e-02f, 6.28393471e-01f, 4.10822123e-01f, 4.14335698e-01f, -3.16476732e-01f, 1.11590013e-01f, -9.38708961e-01f, -4.19258565e-01f, -2.87171662e-01f,
  -3.47066760e-01f, -6.80445910e-01f, -2.49663800e-01f, -7.38221169e-01f, 6.37618840e-01f, 1.05633056e+00f, 1.99853539e-01f, -1.71039775e-01f, -1.00863568e-01f, -6.02534533e-01f,
  -7.60937274e-01f, 7.71483839e-01f, -5.54007292e-01f, 4.29041415e-01f, -3.29752147e-01f, 4.35885191e-01f, 4.10343185e-02f, -4.33430135e-01f, -3.65397334e-01f, 1.12933385e+00f,
  -4.47559267e-01f, -7.38216579e-01f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  -1.76248208e-01f, 4.32086378e-01f, -5.16093746e-02f, 1.12015873e-01f, 1.44140124e-01f, 5.53396717e-02f, -3.90159011e-01f, -4.57386784e-02f, 1.73331203e-03f, -1.20694876e-01f,
  1.60379812e-01f, -7.85018727e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 4, 8
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 4, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        16, 4, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        16, 4, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        16, 12
    );
    }
    