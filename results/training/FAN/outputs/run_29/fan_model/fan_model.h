/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 3 x 120)
const int L0_fan_Wp_rows = 3;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  3.42580855e-01f, -3.51462774e-02f, -6.62437379e-02f, 1.85684890e-01f, 1.60369262e-01f, 9.55835581e-02f, 1.84569523e-01f, 3.89547013e-02f, -2.28139237e-02f, -6.11142069e-02f,
  1.88223690e-01f, -4.92691472e-02f, -6.89721406e-02f, -4.99290181e-03f, 2.59540468e-01f, -2.65496016e-01f, 2.58146614e-01f, 3.16964015e-02f, -3.15352306e-02f, 2.19413519e-01f,
  2.88526379e-02f, 2.47947887e-01f, -4.42884229e-02f, -1.37293294e-01f, 9.47254449e-02f, -1.07935317e-01f, 6.28206506e-02f, -5.39758243e-02f, -6.50088713e-02f, 8.28825161e-02f,
  5.65399453e-02f, -3.68506983e-02f, -1.09442838e-01f, -5.04856706e-02f, 1.19654752e-01f, 1.49585940e-02f, 1.05391182e-02f, -8.35420266e-02f, 6.40505105e-02f, -6.46419451e-02f,
  -3.16706412e-02f, -2.80065183e-02f, 3.92269120e-02f, -4.76996712e-02f, -8.33908543e-02f, -6.97129443e-02f, -8.45113117e-03f, -3.26849967e-02f, -2.72578485e-02f, -2.34458651e-02f,
  -5.57675362e-02f, -7.15215206e-02f, -4.84442636e-02f, -1.05005026e-01f, 5.95309772e-02f, -2.76143104e-02f, -2.41451561e-02f, -1.86856929e-02f, 1.81736667e-02f, 8.09500664e-02f,
  -9.65994820e-02f, 2.01045088e-02f, 1.21057462e-02f, 1.47156501e-02f, -5.57830371e-02f, -6.35880157e-02f, 1.74237154e-02f, 3.92025715e-04f, -2.66401246e-02f, 3.59146334e-02f,
  1.47447184e-01f, 8.05193409e-02f, -4.28342670e-02f, -9.31980610e-02f, 1.60669852e-02f, 6.17563277e-02f, -2.04091035e-02f, 7.16113672e-02f, 6.42833337e-02f, 3.22929434e-02f,
  -4.38085794e-02f, -3.74302305e-02f, 2.74470635e-02f, -4.90968078e-02f, 3.54146175e-02f, 2.63334159e-02f, -1.75359100e-02f, -6.32866696e-02f, -8.38207901e-02f, 3.24641429e-02f,
  2.54309624e-01f, 2.37386078e-01f, -5.54644167e-02f, 2.66344734e-02f, 7.54855759e-03f, -1.28061720e-03f, -4.80029359e-03f, -3.80332544e-02f, -2.99557820e-02f, 1.15047554e-02f,
  1.24275228e-02f, -3.39151383e-03f, 1.47905245e-01f, 4.69113402e-02f, 2.95122303e-02f, 5.26738018e-02f, 1.84120998e-01f, 3.08505055e-02f, 5.90895042e-02f, 1.30975574e-01f,
  3.68859395e-02f, 1.51637429e-02f, -3.54745612e-02f, 6.21125028e-02f, -4.55245748e-02f, -3.37686874e-02f, 3.86374332e-02f, -3.01843099e-02f, 7.77934678e-03f, -3.52346003e-02f,
  7.36396387e-02f, 3.92685086e-02f, -3.36539038e-02f, 2.79924870e-01f, -9.90629792e-02f, 1.36018004e-02f, -4.12833318e-02f, -4.57819831e-03f, -1.80393174e-01f, 1.08431689e-01f,
  2.23615974e-01f, -2.14699015e-01f, -4.73251902e-02f, 5.02616346e-01f, -8.88676345e-02f, 1.57901980e-02f, 2.41787270e-01f, 1.38759226e-01f, -3.05562079e-01f, 5.62611148e-02f,
  -6.30156249e-02f, 1.92388594e-01f, 1.21492296e-02f, -1.47844359e-01f, 4.87640984e-02f, -5.88447265e-02f, 2.53422529e-01f, -1.01552777e-01f, 1.41940162e-01f, 9.16798413e-02f,
  -2.17853766e-02f, -3.35945860e-02f, 1.16638690e-01f, -4.65149507e-02f, 4.85185087e-02f, 7.41987303e-02f, 6.85829446e-02f, 1.23566553e-01f, -1.38129771e-01f, 2.79180636e-03f,
  -1.41267888e-02f, 3.45356092e-02f, 6.02578595e-02f, 3.26069910e-03f, -1.16762385e-01f, 1.48989977e-02f, -2.75987368e-02f, -2.65721697e-02f, 1.81524374e-03f, -1.44904731e-02f,
  -5.58964424e-02f, 3.18938643e-02f, 8.67262408e-02f, 3.90836149e-02f, -7.73014575e-02f, -3.54646109e-02f, -5.30708171e-02f, 5.49864806e-02f, 2.38712952e-02f, -7.35321045e-02f,
  7.50257373e-02f, -1.15504734e-01f, -7.00658411e-02f, 6.32683039e-02f, -1.79572739e-02f, 5.36831021e-02f, -8.84318426e-02f, 3.22221629e-02f, -7.01227784e-02f, 6.08299822e-02f,
  -4.32697274e-02f, -2.29926910e-02f, 7.35241398e-02f, 8.16384256e-02f, 1.88661832e-02f, 2.29603965e-02f, -3.32650356e-02f, 7.49939531e-02f, 1.35032842e-02f, -6.32411465e-02f,
  3.19490917e-02f, -1.03396967e-01f, -6.45590946e-02f, 4.79914621e-02f, 8.78591910e-02f, -8.99352431e-02f, 1.28311869e-02f, 2.07394026e-02f, -3.41731086e-02f, -6.90602958e-02f,
  2.89942957e-02f, 2.46715248e-02f, -4.20780703e-02f, -5.88183701e-02f, -3.43077928e-02f, -9.65286344e-02f, 8.05384219e-02f, 7.04005212e-02f, 4.69968393e-02f, -8.01708922e-02f,
  3.15840580e-02f, 7.46686608e-02f, -3.84974331e-02f, 5.34078740e-02f, -2.57708076e-02f, -9.06809643e-02f, 2.75328532e-02f, 1.52607495e-02f, 9.48275328e-02f, -1.13727719e-01f,
  2.11040061e-02f, -3.72914015e-03f, -4.96835299e-02f, -5.14218863e-03f, 7.93860108e-02f, -2.98118964e-02f, -1.50680542e-03f, -8.38363320e-02f, 2.77765431e-02f, 5.89505471e-02f,
  4.31153089e-01f, 6.34266715e-03f, -5.78635558e-02f, 3.27113181e-01f, -2.80355979e-02f, 2.89572477e-01f, 3.77964824e-01f, -1.17574714e-01f, -1.49139238e-03f, 3.43805663e-02f,
  7.38411322e-02f, 4.56659868e-02f, 1.19603254e-01f, 1.75279602e-01f, -1.65567957e-02f, -4.78911996e-02f, 3.74209166e-01f, 1.92188993e-01f, -1.60048585e-02f, 4.63168770e-02f,
  1.03149086e-01f, 1.53944761e-01f, 1.22448258e-01f, -2.20911503e-01f, 1.60332918e-01f, 6.25969097e-02f, -9.39556211e-03f, 4.97489683e-02f, 4.22875658e-02f, -1.65667966e-01f,
  -1.16491079e-01f, -1.79720700e-01f, -2.52342410e-03f, 1.00779505e-02f, 6.34690523e-02f, -1.02530560e-02f, 6.52338937e-02f, 1.23886028e-02f, -6.85569495e-02f, 8.71786103e-02f,
  2.02554977e-03f, -6.24204502e-02f, 8.49073101e-03f, -3.83789428e-02f, 2.88726557e-02f, -5.55546908e-03f, -9.99271274e-02f, 8.41624290e-03f, -9.51237381e-02f, 1.43805388e-02f,
  2.22699950e-03f, -1.57338846e-02f, 7.59588555e-02f, -3.53659950e-02f, 5.34753539e-02f, 2.03784332e-02f, 1.48138460e-02f, 2.45688651e-02f, -2.40985639e-02f, 4.25247699e-02f,
  -3.95834818e-02f, 7.24440673e-03f, -1.84184387e-02f, -2.90341154e-02f, -8.90489947e-03f, -4.07674722e-02f, 1.93082392e-02f, -7.95251206e-02f, 1.64488703e-02f, 1.55708836e-02f,
  5.62191531e-02f, -5.97949214e-02f, 2.42157211e-03f, 8.47041458e-02f, 1.82260163e-02f, -1.56528838e-02f, 1.46893393e-02f, -1.43703574e-03f, 7.00356588e-02f, 2.43188851e-02f,
  2.67591141e-02f, 3.19977552e-02f, 2.89481273e-03f, 4.08422910e-02f, -2.03404613e-02f, -2.04152334e-03f, 1.68773718e-02f, -2.52937619e-02f, 4.11313623e-02f, 4.11454327e-02f,
  -2.14848127e-02f, 1.54472709e-01f, 4.41604014e-03f, -8.25403407e-02f, -3.71621512e-02f, 1.65849179e-02f, -3.69924158e-02f, 1.82708297e-02f, -7.40720471e-03f, -6.45797094e-03f,
  4.63756025e-02f, 5.22274487e-02f, 1.85430585e-03f, 6.53284788e-02f, -2.01660022e-02f, 7.54739419e-02f, 3.04841110e-03f, -4.80635371e-03f, 6.99933171e-02f, -7.89760202e-02f,
  2.11335113e-03f, 8.49930476e-03f, -5.14761098e-02f, -8.06573480e-02f, 6.03029504e-02f, 6.71773702e-02f, 1.18986638e-02f, 2.06236616e-02f, 1.31454542e-02f, -5.71436286e-02f
};

// L0_fan_Wp_bar (Shape: 10 x 120)
const int L0_fan_Wp_bar_rows = 10;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -1.15644947e-01f, 2.64016688e-01f, 2.10759193e-02f, -5.62281441e-03f, 2.14506418e-01f, -2.04768404e-01f, -5.89402765e-02f, 1.15207255e-01f, -2.50416547e-01f, 8.94757137e-02f,
  -8.67087767e-02f, -1.51462942e-01f, 1.54173863e-03f, -4.85096097e-01f, -4.58261639e-01f, -4.48899925e-01f, -5.98194562e-02f, -2.94246733e-01f, -1.52771086e-01f, 2.29811504e-01f,
  4.95168194e-03f, -5.68325520e-02f, -1.64682761e-01f, 2.95037270e-01f, 8.83863196e-02f, 2.22787291e-01f, 6.13497794e-01f, 2.10594311e-01f, 2.71372765e-01f, -8.90208781e-02f,
  -3.52831811e-01f, -1.15869075e-01f, -8.20079371e-02f, 5.33860885e-02f, 9.26427394e-02f, 1.93439573e-01f, 1.24716260e-01f, -1.77777689e-02f, -3.23117152e-02f, -9.32413116e-02f,
  4.13978696e-02f, -6.30427748e-02f, -3.77943702e-02f, -1.48153111e-01f, 1.51327640e-01f, -6.39174134e-02f, -9.13021564e-02f, 6.77075908e-02f, -1.38799027e-02f, -1.64981529e-01f,
  5.68223894e-02f, 1.88548528e-02f, 2.41900161e-01f, 1.78574305e-02f, -3.00148278e-02f, -1.07202210e-01f, 1.55444771e-01f, -2.10443437e-02f, 7.71032721e-02f, -1.00812353e-01f,
  -8.61994177e-03f, 1.18926577e-01f, 1.71857923e-02f, -4.55891937e-02f, 4.02012430e-02f, -1.73799843e-02f, -4.99436222e-02f, 6.65358603e-02f, -2.30576769e-02f, -9.33480561e-02f,
  1.44753441e-01f, -8.09122920e-02f, 1.11723337e-02f, 7.98071623e-02f, 1.96779165e-02f, -1.21432766e-01f, 4.58716713e-02f, -4.22963090e-02f, 8.93279761e-02f, -1.42431423e-01f,
  -1.60655286e-02f, 1.16107166e-01f, 5.34572788e-02f, 6.62837550e-02f, -7.04058483e-02f, -2.14469936e-02f, 5.07075712e-02f, 5.81428483e-02f, 1.26727834e-01f, 9.74456966e-02f,
  1.18747100e-01f, 2.38219172e-01f, 2.14455221e-02f, -8.00503269e-02f, 6.43415600e-02f, -5.05134743e-03f, -3.94683331e-02f, 2.60752384e-02f, 2.80633452e-03f, 1.20317370e-01f,
  1.40948817e-01f, 1.10939637e-01f, 2.32980281e-01f, -1.73396487e-02f, -9.58454236e-02f, 1.17641957e-02f, 1.54304713e-01f, 4.74951155e-02f, 1.59739509e-01f, 3.63254361e-02f,
  1.98820144e-01f, 3.35410461e-02f, -1.50183523e-02f, 1.65404066e-01f, -3.98975983e-02f, 1.60111234e-01f, 3.44973383e-03f, -7.64386263e-03f, 8.44088122e-02f, -3.32714729e-02f,
  1.11158706e-01f, -3.46799821e-01f, 5.73839545e-01f, -1.06450774e-01f, 2.85767734e-01f, 3.04828525e-01f, 6.34271979e-01f, -2.27500856e-01f, 5.92235625e-02f, -5.35220981e-01f,
  -1.77425042e-01f, -1.72004923e-01f, 3.93692404e-01f, -5.11031687e-01f, 8.27406764e-01f, 2.20065176e-01f, 6.72979876e-02f, -7.21623749e-02f, 7.39872828e-02f, 1.80365313e-02f,
  -1.24043360e-01f, -4.20019537e-01f, 3.19242105e-02f, -5.44123173e-01f, -2.95755327e-01f, -1.85340464e-01f, -2.36119673e-01f, 3.45064461e-01f, -6.32262230e-01f, 1.35018274e-01f,
  -9.99859348e-02f, -1.06423087e-01f, 2.48805434e-02f, -7.26415962e-02f, 7.73419114e-03f, 4.58248146e-02f, 1.66920032e-02f, 2.71677524e-01f, 8.81499648e-02f, -3.17253470e-02f,
  1.58834253e-02f, -1.05463602e-01f, -9.25388485e-02f, 2.06270777e-02f, 3.25755440e-02f, -4.96826060e-02f, -6.17580637e-02f, -1.01075903e-01f, -7.29240179e-02f, 1.98759869e-01f,
  1.18335590e-01f, 5.72712198e-02f, 6.94040954e-02f, 1.52220568e-02f, 3.65394950e-02f, 7.07525061e-03f, 5.37489317e-02f, 2.05742434e-01f, 1.26810923e-01f, -8.33787024e-02f,
  4.08808477e-02f, 1.46259472e-05f, -5.08050025e-02f, -1.85978383e-01f, -1.36786960e-02f, -1.79371029e-01f, -5.55353537e-02f, 7.45505095e-03f, 3.42020579e-02f, -9.73424595e-03f,
  -5.87408729e-02f, 6.87579736e-02f, 7.73633793e-02f, 5.95275424e-02f, -1.22957118e-01f, -8.86975825e-02f, 4.74174209e-02f, -5.01793511e-02f, 2.51471102e-02f, -1.18213132e-01f,
  -1.25900935e-02f, 7.64144436e-02f, -7.98180252e-02f, -2.98631266e-02f, 1.59870476e-01f, 1.65727928e-01f, -9.59213972e-02f, 3.39345522e-02f, 2.14952305e-02f, 9.43707600e-02f,
  -3.06890935e-01f, -1.71333671e-01f, 1.46118049e-02f, -6.81177378e-02f, -9.94466022e-02f, -9.79238972e-02f, 6.39025494e-02f, -8.13020244e-02f, -6.35016263e-02f, 4.00520153e-02f,
  -4.61935066e-02f, -1.30865410e-01f, -1.73250213e-02f, 5.55764809e-02f, -1.15767092e-01f, 1.40100326e-02f, -4.31506597e-02f, -5.37369549e-02f, 1.25224655e-02f, -1.18820123e-01f,
  -2.55846046e-02f, 1.06079347e-01f, 9.63726193e-02f, -1.76120341e-01f, -1.36795685e-01f, -8.47482607e-02f, -6.88470528e-02f, 1.04550548e-01f, 1.14427090e-01f, -6.69978606e-03f,
  1.57599539e-01f, -7.61542797e-01f, -3.46368730e-01f, 1.68212414e-01f, 5.00744879e-01f, -1.66094139e-01f, -5.12463935e-02f, -3.95418495e-01f, -1.44357324e-01f, -2.97078341e-01f,
  1.02923557e-01f, 3.59618753e-01f, -1.20158322e-01f, 2.95470119e-01f, 6.92378461e-01f, -1.17869288e-01f, 8.68754312e-02f, 3.02371621e-01f, 1.44544588e-02f, -2.83506066e-01f,
  1.13862120e-01f, 2.38570809e-01f, 2.05433145e-01f, 7.00821821e-03f, 1.77722171e-01f, -7.55627453e-02f, 2.97768891e-01f, -9.03014019e-02f, 1.35589456e-02f, 3.22960526e-01f,
  5.79639263e-02f, -2.47488901e-01f, -1.08812742e-01f, -9.56494957e-02f, -1.86848238e-01f, -3.15322019e-02f, 1.29813567e-01f, 2.45254695e-01f, 1.20097585e-02f, -8.81343186e-02f,
  6.16319813e-02f, 1.06981218e-01f, 2.51059979e-02f, 4.85100448e-02f, 1.99972745e-02f, -9.81822610e-02f, 1.88225672e-01f, -2.16774121e-02f, -1.32021442e-01f, 7.35538229e-02f,
  -6.48070425e-02f, -1.99067704e-02f, -3.17145400e-02f, -1.71850380e-02f, 4.50176280e-03f, -6.78528473e-02f, 1.68334395e-02f, -6.77205548e-02f, -4.00003977e-02f, -1.28643632e-01f,
  -8.24261680e-02f, 4.76360247e-02f, -2.36066747e-02f, 7.02368990e-02f, -4.20607068e-02f, 1.83474049e-02f, -5.76469339e-02f, -7.29248673e-02f, -1.14084922e-01f, -5.15628718e-02f,
  1.68705098e-02f, -1.66216008e-02f, -1.41659863e-02f, 4.49359529e-02f, 8.99676010e-02f, -5.09413816e-02f, 6.53679967e-02f, -1.36729777e-02f, -5.00086434e-02f, 1.28791571e-01f,
  1.26869872e-01f, -3.53818946e-02f, 4.93785478e-02f, 2.56038625e-02f, 4.87199426e-02f, 6.36562854e-02f, -1.59981728e-01f, -1.33686200e-01f, 4.80697869e-04f, 3.72693315e-02f,
  -1.81556940e-01f, -6.43845916e-01f, -1.56543627e-01f, 1.55693233e-01f, -7.30049908e-02f, -7.38421967e-03f, 1.53981941e-02f, -1.78202186e-02f, -1.58411160e-01f, -1.49912968e-01f,
  4.69239838e-02f, 2.06427962e-01f, -1.04527339e-01f, 3.54493707e-02f, -5.92092576e-04f, -1.29051089e-01f, 4.40973565e-02f, -2.39970256e-02f, 1.07432447e-01f, -1.98636353e-01f,
  -4.42392901e-02f, -6.11644015e-02f, 1.12003684e-01f, 7.66765997e-02f, 1.01836510e-01f, 3.50468978e-02f, 7.07962662e-02f, -1.44927993e-01f, 4.25381660e-02f, 1.60892099e-01f,
  2.02223182e-01f, 2.28809968e-01f, -3.53129089e-01f, -1.89128473e-01f, -1.51973531e-01f, 5.02106488e-01f, 3.77233326e-01f, 7.27940165e-03f, -9.05148908e-02f, 4.51884508e-01f,
  2.61172324e-01f, -6.76354617e-02f, 3.51593554e-01f, 5.69084883e-01f, 1.55631959e-01f, 1.94038972e-01f, 4.04673845e-01f, 3.69025797e-01f, -1.94965333e-01f, 8.42768624e-02f,
  -1.20662220e-01f, 4.15376514e-01f, -1.46275818e-01f, -6.78123012e-02f, 1.32238358e-01f, -4.09815282e-01f, 9.93778855e-02f, -2.89707065e-01f, -5.70238382e-02f, 1.53185979e-01f,
  -8.22415017e-03f, -8.60941634e-02f, 5.52237369e-02f, 5.18389978e-02f, 1.31849676e-01f, 2.21740734e-02f, 8.59896690e-02f, -6.97587579e-02f, -2.49256611e-01f, 1.94061361e-02f,
  8.91379938e-02f, -1.12198658e-01f, 6.00123182e-02f, -7.87470937e-02f, 2.72641703e-02f, -2.32814044e-01f, -2.09969819e-01f, -9.79139209e-02f, -1.01876445e-02f, 8.63551125e-02f,
  -6.56913370e-02f, -7.40757352e-03f, -4.94350083e-02f, 3.13319415e-02f, -2.17594653e-01f, -5.65486774e-02f, 1.49294302e-01f, 8.40300042e-03f, 1.20348092e-02f, -3.01194377e-02f,
  3.25186877e-03f, 9.21651945e-02f, 8.38983208e-02f, 5.51990084e-02f, -3.99186797e-02f, -6.75301207e-03f, 4.52093780e-02f, 2.51626056e-02f, -1.28911678e-02f, 2.92494558e-02f,
  -3.76495197e-02f, 2.67937500e-02f, 8.14372376e-02f, 1.44859493e-01f, -4.40938510e-02f, 8.40132087e-02f, -3.29494327e-02f, 7.59596899e-02f, -1.29288390e-01f, -1.61258527e-03f,
  1.24133201e-02f, 6.88309129e-03f, -8.62211734e-02f, 7.80400634e-02f, 1.99374985e-02f, -8.89818966e-02f, 1.87972203e-01f, -5.43233491e-02f, -1.80066228e-02f, 2.35974099e-02f,
  4.70595397e-02f, 2.13504195e-01f, -1.67282484e-02f, -4.02944498e-02f, 2.21823957e-02f, 1.69823647e-01f, 8.71998891e-02f, 8.99301544e-02f, -4.76731509e-02f, 1.59489661e-01f,
  3.36269513e-02f, 2.78798137e-02f, -2.91087013e-02f, -1.52769282e-01f, -1.57555789e-01f, 1.37909383e-01f, 4.00100183e-03f, -1.77614555e-01f, 3.32926470e-03f, -6.79453909e-02f,
  -1.20302133e-01f, 5.46603054e-02f, 5.65580204e-02f, -3.88045721e-02f, 2.96929125e-02f, 1.11228712e-01f, 3.71098146e-02f, -5.67487739e-02f, 8.18555132e-02f, -7.88429193e-03f,
  2.00974762e-01f, -2.18587503e-01f, -6.91816881e-02f, 2.85550535e-01f, -3.62497307e-02f, -2.27531239e-01f, -2.64769912e-01f, 1.35892242e-01f, -2.05155477e-01f, -6.50612265e-02f,
  2.39746019e-01f, 7.69878998e-02f, -6.60015941e-02f, 2.91292846e-01f, 2.84777105e-01f, -4.61705804e-01f, 1.70695633e-01f, -1.00074314e-01f, -1.24263763e-01f, 2.85813421e-01f,
  2.66818106e-01f, 3.75916362e-01f, 3.71795624e-01f, 1.27770081e-01f, 1.98502913e-01f, 1.50846645e-01f, 2.41136223e-01f, 1.12955950e-01f, 3.93402934e-01f, 1.69485182e-01f,
  2.27372944e-02f, 1.46503434e-01f, -4.64888252e-02f, -6.23590238e-02f, 7.84892589e-02f, -4.17188331e-02f, -1.50882691e-01f, -3.30944210e-02f, 1.12787904e-02f, 6.94794506e-02f,
  -1.59651846e-01f, 2.29779333e-02f, 1.05320968e-01f, 6.50896057e-02f, -1.19766151e-03f, 3.35210711e-02f, -2.62298365e-03f, -5.12709050e-03f, -1.32234201e-01f, -5.39182103e-04f,
  1.92974303e-02f, 3.90297920e-02f, 8.18572752e-03f, -1.16577558e-01f, 1.19103342e-02f, -2.02307589e-02f, -1.39483720e-01f, 1.98447317e-01f, -1.12625929e-02f, 9.52763930e-02f,
  1.02294823e-02f, -4.24923003e-02f, -1.24872945e-01f, -7.25818574e-02f, -8.18514451e-02f, -9.25633907e-02f, -2.02850342e-01f, -1.17227994e-01f, -9.84274298e-02f, 4.99969870e-02f,
  4.43996303e-02f, -4.34687659e-02f, 4.20035236e-02f, 9.34830382e-02f, -8.06590766e-02f, 5.22498898e-02f, -3.88290249e-02f, 2.58445770e-01f, 2.19621271e-01f, -1.97499678e-01f,
  -1.39917940e-01f, 2.28692695e-01f, 2.19334848e-02f, 2.94640269e-02f, -2.29123272e-02f, 9.34660435e-02f, 1.44952163e-01f, 1.73159733e-01f, 2.69032884e-02f, -7.96439573e-02f,
  1.00483738e-01f, 3.00656557e-01f, -1.51644284e-02f, -1.30420923e-01f, -1.03775166e-01f, -2.57135421e-01f, -7.43279755e-02f, 6.40463009e-02f, 6.99277520e-02f, 2.80027967e-02f,
  2.16203719e-01f, -1.61384314e-01f, 4.35774699e-02f, 1.51074156e-01f, 6.52851909e-02f, 4.07077335e-02f, 1.50435254e-01f, -2.41996441e-03f, -5.52411340e-02f, 7.95906037e-02f,
  8.72757509e-02f, -2.86962688e-02f, -9.88988504e-02f, -2.56444693e-01f, -3.59241664e-02f, -2.36179065e-02f, -1.60087436e-01f, 1.50035232e-01f, 1.07082061e-01f, -1.51306270e-02f,
  -1.59729481e+00f, 6.95836186e-01f, 2.49875844e-01f, 1.13917768e-01f, -1.78517416e-01f, 7.24752605e-01f, 5.70657849e-01f, 2.09036898e-02f, -1.82907805e-02f, 4.08142328e-01f,
  -1.95009261e-03f, -1.99097395e-01f, 1.05474263e-01f, 2.81880140e-01f, -2.31466107e-02f, 3.51901621e-01f, 2.75900483e-01f, 1.90999076e-01f, 1.85205713e-01f, -1.56853706e-01f,
  -8.05513486e-02f, 1.46881625e-01f, 1.54629737e-01f, 5.98868392e-02f, -1.63471252e-01f, -1.62264347e-01f, -1.08755179e-01f, 1.44364089e-01f, -1.03859790e-02f, 5.23925796e-02f,
  -3.92853558e-01f, -5.15074193e-01f, -3.17068785e-01f, -1.41510651e-01f, -1.42248139e-01f, -3.72460373e-02f, -2.05716677e-02f, 5.64172417e-02f, -9.93202776e-02f, -4.49593738e-02f,
  -9.05694067e-02f, -4.44625616e-02f, -2.26351600e-02f, 6.59016240e-03f, -7.80284554e-02f, -6.40641823e-02f, 1.92450769e-02f, -5.35850488e-02f, 4.31669392e-02f, -8.96433890e-02f,
  1.46690547e-01f, 1.40122488e-01f, 8.58997703e-02f, 6.96657225e-02f, -1.21934794e-01f, 6.60884529e-02f, 1.34607330e-01f, 8.72786418e-02f, 7.93941915e-02f, -2.61964779e-02f,
  -3.91556099e-02f, -3.65256355e-03f, -6.53230324e-02f, -1.07415050e-01f, -7.22446814e-02f, -1.64548218e-01f, 3.75905000e-02f, -1.63545117e-01f, 1.08288445e-01f, -4.37860824e-02f,
  -3.64437662e-02f, 6.17256295e-03f, -1.11151107e-01f, 6.63404390e-02f, 4.00592666e-03f, -1.02350555e-01f, 4.27811295e-02f, 6.06863946e-02f, 1.60889581e-01f, -2.54761409e-02f,
  8.39960724e-02f, 3.23812589e-02f, 1.05384178e-01f, 3.22751589e-02f, 1.71595179e-02f, 7.23209679e-02f, 4.91312426e-03f, -3.56577672e-02f, 8.29271274e-04f, -4.80586756e-03f,
  1.24943182e-01f, -1.54156482e-03f, -2.77854465e-02f, -1.16786323e-02f, -1.03559271e-01f, -7.83819053e-03f, 2.55160574e-02f, -5.03606871e-02f, 1.03151120e-01f, -1.11252345e-01f,
  -4.54926342e-02f, -6.96716383e-02f, 5.41469641e-02f, -3.43246339e-03f, 1.09368414e-01f, 1.04425691e-01f, 6.13371618e-02f, 1.35259837e-01f, -6.64852373e-03f, -5.06893685e-03f,
  -1.01831041e-01f, -4.52036187e-02f, 5.47199249e-02f, -1.16457669e-02f, 6.45970087e-03f, -2.64449175e-02f, -1.17127120e-01f, 4.63618264e-02f, -4.49675135e-02f, 1.17422961e-01f,
  -4.96582836e-01f, 3.94698769e-01f, 1.64629042e-01f, -2.78290063e-01f, 3.96729171e-01f, -3.38698715e-01f, -3.81036475e-02f, 2.06226945e-01f, -3.54364738e-02f, 3.43421996e-01f,
  6.61658794e-02f, 1.72326431e-01f, 1.86160002e-02f, -7.53538162e-02f, -8.96500647e-01f, -5.23348093e-01f, -5.35950780e-01f, -1.84152529e-01f, -2.37739757e-01f, 8.98058489e-02f,
  -3.15908790e-01f, -1.33502111e-01f, -2.79331982e-01f, 2.45860875e-01f, 3.03882450e-01f, 2.20176965e-01f, -1.20744713e-01f, 4.16390479e-01f, -1.99630819e-02f, 2.88198050e-02f,
  -1.73828080e-01f, 1.98941782e-01f, 2.32398719e-01f, 7.64861330e-02f, -1.73936505e-03f, 3.41913886e-02f, 3.28779290e-03f, -9.84529555e-02f, -3.99823114e-02f, 5.46884872e-02f,
  3.49997953e-02f, -1.90024227e-02f, -3.72191183e-02f, 3.93875539e-02f, 1.52411371e-01f, 1.00387283e-01f, 8.36984292e-02f, -3.93568072e-03f, 1.44526273e-01f, 1.70481637e-01f,
  1.36614606e-01f, 8.85798112e-02f, 5.44311143e-02f, -8.88866857e-02f, 4.76696081e-02f, 9.26842466e-02f, -1.73627272e-01f, 9.72356554e-03f, 7.80294789e-03f, -6.90068901e-02f,
  -5.98507635e-02f, 1.19274855e-01f, -4.14304361e-02f, 1.01608306e-01f, 5.13718724e-02f, 2.23485883e-02f, -5.49930111e-02f, -6.90816939e-02f, -1.89805112e-03f, 3.54148410e-02f,
  -8.97233188e-02f, 8.48562196e-02f, 1.16967008e-01f, 3.36847864e-02f, -1.96977690e-01f, 4.77243923e-02f, -9.33114532e-03f, -4.51178923e-02f, -7.18215480e-02f, 7.88605958e-02f,
  2.91895289e-02f, -1.70715395e-02f, 1.16712175e-01f, 4.17624786e-02f, -6.87840432e-02f, 5.61680384e-02f, 7.65841156e-02f, 6.36266693e-02f, -2.53511481e-02f, -4.11334708e-02f,
  -2.08328322e-01f, -1.74273744e-01f, -5.38258627e-02f, 2.25686654e-02f, -7.10834861e-02f, -5.04096039e-02f, -2.53200959e-02f, 2.50335317e-02f, -1.89118221e-01f, -4.77848463e-02f,
  2.88918819e-02f, 1.03937611e-02f, -6.56067804e-02f, -7.32328091e-03f, -1.78104222e-01f, -1.06664769e-01f, -5.36483116e-02f, -9.58197284e-04f, -3.49961668e-02f, -8.41330737e-02f,
  1.22976139e-01f, 7.58263245e-02f, -1.49312839e-01f, -6.40257001e-02f, 1.01649817e-02f, -3.14196311e-02f, 5.96176460e-02f, 6.66123927e-02f, -8.05194899e-02f, -2.16448698e-02f,
  7.18528748e-01f, 3.36075544e-01f, 5.71339726e-01f, 6.15571618e-01f, -1.29631966e-01f, 2.85717815e-01f, 2.37910122e-01f, 1.76914468e-01f, 6.49680257e-01f, -3.08142938e-02f,
  -4.61835384e-01f, 5.28592169e-01f, -4.20751333e-01f, 4.00263488e-01f, -1.87706798e-01f, -9.06034186e-02f, 3.78425956e-01f, 1.26379788e-01f, 2.38387927e-01f, 1.59731612e-01f,
  9.68166739e-02f, -3.94346029e-01f, -1.56310797e-01f, -3.74782294e-01f, 1.70859680e-01f, 1.78744078e-01f, -5.95879436e-01f, -2.08944589e-01f, -1.51574224e-01f, -9.05414000e-02f,
  -2.88779028e-02f, 1.98596433e-01f, 3.18216980e-02f, 5.49350604e-02f, -1.15056209e-01f, -6.20438010e-02f, 1.57452058e-02f, -4.62314561e-02f, -3.88427638e-02f, 4.17709127e-02f,
  7.41556734e-02f, -6.40139505e-02f, 3.62986210e-03f, 1.58101320e-02f, 6.06516711e-02f, 9.16070640e-02f, 1.69928610e-01f, 8.55325982e-02f, 9.80700925e-02f, 3.39655764e-02f,
  1.12550281e-01f, 8.20007697e-02f, 7.95275494e-02f, 7.56775513e-02f, 8.23884457e-02f, -6.23679813e-03f, 5.71737811e-02f, 1.97596420e-02f, 1.05545148e-01f, 1.37379035e-01f,
  -1.24146566e-01f, 3.80788371e-02f, -2.35959217e-02f, -8.59117731e-02f, -9.55835450e-03f, -5.42961434e-02f, -7.05659315e-02f, -1.02690317e-01f, 1.59233674e-01f, -3.15871313e-02f,
  5.52903004e-02f, 4.39475998e-02f, -5.02243545e-03f, -2.12223250e-02f, 7.37315789e-02f, 1.60446553e-03f, 3.01436614e-02f, 1.30216926e-02f, 7.51584023e-02f, 1.71664022e-02f,
  -5.62632903e-02f, 8.95609856e-02f, 2.64393282e-03f, -6.22959808e-02f, -7.74883246e-03f, -4.11334075e-02f, 3.42772305e-02f, 2.56605148e-02f, 2.01302134e-02f, -3.63529585e-02f,
  -2.65269820e-02f, 4.61743213e-02f, 8.83572102e-02f, -6.56874944e-03f, -1.33027788e-02f, -2.74461266e-02f, 4.14630733e-02f, 1.64928511e-01f, 7.60914087e-02f, 5.37637323e-02f,
  3.64821628e-02f, 1.93159468e-02f, 4.58528101e-02f, -4.59253378e-02f, -2.55914386e-02f, -1.37054780e-02f, -7.51150539e-03f, -1.31882340e-01f, -4.99688052e-02f, -2.16978848e-01f,
  -2.75901854e-02f, -1.64370127e-02f, 1.32350504e-01f, -9.75318067e-03f, 3.15596461e-02f, -8.14400315e-02f, 9.86976475e-02f, -1.78700557e-03f, -4.69252542e-02f, 9.50635318e-03f,
  3.67323011e-01f, -5.19865453e-01f, -4.29913342e-01f, 2.96465516e-01f, 6.13279223e-01f, 3.26777488e-01f, 1.42767698e-01f, 3.66059572e-01f, 2.02507913e-01f, -3.71016599e-02f,
  1.79056093e-01f, -5.77095449e-01f, -6.50833130e-01f, -6.26407862e-02f, 1.93054840e-01f, -4.65373516e-01f, 2.73313582e-01f, 5.41017130e-02f, -1.12107918e-01f, 1.12347461e-01f,
  1.17885634e-01f, 3.93383920e-01f, -3.37483287e-01f, 2.96872646e-01f, 2.17818707e-01f, 1.33574426e-01f, 2.31081277e-01f, -2.77712494e-01f, 2.65059233e-01f, 1.66714136e-02f,
  7.91781992e-02f, -6.15649000e-02f, -8.82168169e-05f, -1.82762295e-01f, 5.37403040e-02f, 1.15469933e-01f, -5.78434430e-02f, -1.50049418e-01f, 1.10278256e-01f, -1.45071864e-01f,
  -1.42539039e-01f, -9.02411267e-02f, 5.58227524e-02f, 5.53048588e-02f, 1.12884767e-01f, 9.15043503e-02f, -6.60525337e-02f, 6.81219846e-02f, -1.47949043e-03f, -1.89120725e-01f,
  -1.54665768e-01f, 1.66604090e-02f, 1.23232849e-01f, -1.84245817e-02f, -3.45343798e-02f, 4.49884273e-02f, 2.72417422e-02f, -9.90438759e-02f, 4.59344424e-02f, -6.35124929e-03f,
  5.37168793e-02f, -7.53949434e-02f, 1.96177810e-02f, 4.09278944e-02f, 3.80130783e-02f, 2.27105618e-02f, 1.07714884e-01f, -9.18491185e-02f, 1.05937608e-01f, -7.34757856e-02f,
  1.81508198e-01f, 8.49124119e-02f, 8.96322913e-03f, 5.83966309e-03f, -2.28422657e-02f, 5.34844883e-02f, 1.33732595e-02f, -4.15247791e-02f, 7.01527372e-02f, 1.53149709e-01f,
  -7.11564114e-03f, 5.52053638e-02f, -2.71098930e-02f, 7.16070682e-02f, -5.38696125e-02f, 3.95883769e-02f, -6.95316354e-03f, 6.37713000e-02f, 1.82388052e-02f, 6.40046671e-02f,
  6.08554557e-02f, -2.29145288e-01f, -1.97786719e-01f, -8.83069336e-02f, -1.21672563e-01f, 1.72016606e-01f, -1.30207434e-01f, 4.42092121e-02f, -1.37189016e-01f, -4.22567241e-02f,
  1.18002541e-01f, 4.05262224e-02f, 9.29048806e-02f, 3.98841277e-02f, 5.74344657e-02f, 2.78512575e-02f, -4.10761833e-02f, 4.40287739e-02f, 9.58510414e-02f, -2.22269003e-03f,
  2.77753212e-02f, 1.41646266e-01f, 2.83903908e-02f, 1.20329320e-01f, 7.78519586e-02f, -6.88469112e-02f, 6.94500282e-02f, 2.47606505e-02f, 6.17262674e-03f, -1.33032613e-02f,
  -6.24118388e-01f, 7.95029029e-02f, 1.26438392e-02f, 5.24655759e-01f, -1.05209261e-01f, -4.66359586e-01f, -3.69404376e-01f, 2.71323800e-01f, -2.04892784e-01f, -2.44399700e-02f,
  1.37883231e-01f, -1.59470394e-01f, -1.49724901e-01f, 4.99151587e-01f, 3.80025208e-01f, 1.88919500e-01f, 3.08260977e-01f, 8.13981667e-02f, 2.20118657e-01f, 6.37268946e-02f,
  2.93984741e-01f, 2.43567139e-01f, 4.57041264e-01f, 5.94609901e-02f, 7.35886693e-02f, 3.11752111e-01f, 2.38470465e-01f, -8.52599798e-04f, 3.62766504e-01f, -6.34306371e-02f,
  -2.60637909e-01f, 2.58121658e-02f, 8.12020525e-02f, -1.38253525e-01f, -4.62957565e-03f, -7.88588449e-02f, -1.59318656e-01f, -8.95258710e-02f, -2.70332601e-02f, 1.22084156e-01f,
  -1.81140721e-01f, 9.29944217e-03f, 1.15115836e-01f, -1.34440744e-02f, -5.37986942e-02f, 9.76226628e-02f, 4.94853873e-03f, -1.66823745e-01f, 5.48222326e-02f, -7.42730591e-03f,
  7.58475438e-02f, 1.63604468e-01f, 3.96598279e-02f, 1.22625284e-01f, -2.27063857e-02f, -1.61837205e-01f, -3.83126113e-04f, -3.75066623e-02f, 8.20439756e-02f, -7.98610505e-03f,
  -1.19099356e-01f, -1.41215548e-02f, 5.28137758e-02f, 6.18733242e-02f, -6.00854866e-02f, 4.43774201e-02f, 7.11894259e-02f, -1.63329422e-01f, -7.83417150e-02f, 1.37463599e-01f,
  5.52484021e-02f, 9.48988795e-02f, -1.24331251e-01f, -1.34337381e-01f, 1.54384479e-01f, -9.42203775e-02f, 8.84191394e-02f, 1.75756169e-03f, -9.64194611e-02f, -7.34330760e-03f,
  -7.38520697e-02f, 6.40465394e-02f, -3.47515531e-02f, -1.74602002e-01f, -8.18490013e-02f, 9.03226361e-02f, 1.43648475e-01f, -1.44727882e-02f, 1.84753817e-02f, -2.11873371e-02f,
  -1.84937581e-01f, 2.36382633e-01f, 1.72020532e-02f, -1.60123855e-01f, 9.50780418e-03f, 1.55269474e-01f, 3.87977548e-02f, 7.31091499e-02f, -2.26833839e-02f, 2.29623467e-02f,
  1.16646700e-01f, -1.05117388e-01f, -3.20307985e-02f, -1.83026977e-02f, 8.62187445e-02f, 5.77881485e-02f, 2.78816167e-02f, -6.28301725e-02f, 1.45439282e-01f, 1.25237241e-01f,
  3.55354995e-02f, -5.98942786e-02f, 7.44867995e-02f, -5.87268472e-02f, 3.84643227e-02f, -3.61656696e-02f, -1.40995353e-01f, -1.07680209e-01f, 5.91021329e-02f, -1.02408025e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 10)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 10;
const float L0_fan_Bp_bar_data[] = {
  -3.31675828e-01f, 7.32219815e-01f, 3.81720811e-01f, 1.56518772e-01f, 5.13983667e-02f, 6.66223288e-01f, 4.76248860e-01f, 5.13308346e-01f, 3.66679341e-01f, -7.98469856e-02f
};

// L1_fan_Wp (Shape: 3 x 16)
const int L1_fan_Wp_rows = 3;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  1.28599808e-01f, -8.35002288e-02f, 6.50069043e-02f, 2.86820114e-01f, 3.97738874e-01f, 3.31101865e-01f, 2.74289668e-01f, -1.58788562e-01f, -3.34774293e-02f, -1.30285127e-02f,
  2.42609501e-01f, 4.03802097e-02f, 5.18746614e-01f, -1.45566240e-01f, 9.38276425e-02f, 7.50331804e-02f, 1.56268343e-01f, 3.24088365e-01f, 5.57022035e-01f, 4.38865364e-01f,
  -1.32819101e-01f, 3.70378166e-01f, 4.45089102e-01f, 2.23344252e-01f, -2.06188574e-01f, 1.44775361e-01f, 2.25769937e-01f, -3.48792970e-01f, -2.27954522e-01f, 2.77577639e-01f,
  2.62135584e-02f, 2.58705020e-01f, -2.79653639e-01f, -2.38183066e-01f, -1.88068990e-02f, 1.16669886e-01f, 5.86557984e-01f, 3.91555838e-02f, 5.15605211e-01f, -3.24597746e-01f,
  -9.08746645e-02f, 2.15073943e-01f, 1.41336009e-01f, 1.42982185e-01f, 4.01123576e-02f, -5.11168301e-01f, 1.93104222e-01f, 2.10800588e-01f
};

// L1_fan_Wp_bar (Shape: 10 x 16)
const int L1_fan_Wp_bar_rows = 10;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  6.39444292e-01f, 9.31594133e-01f, 7.55736470e-01f, 5.84454417e-01f, -6.49790391e-02f, 8.91434669e-01f, -5.60853221e-02f, 6.85051382e-01f, 2.95230716e-01f, 7.42167950e-01f,
  1.53693408e-01f, 9.31803524e-01f, 5.61249964e-02f, 4.42920208e-01f, 5.33238292e-01f, -6.51492715e-01f, 2.33216435e-01f, 1.89291179e-01f, 3.16387624e-01f, -3.35615188e-01f,
  5.73058963e-01f, -1.29700556e-01f, -2.07655296e-01f, 4.88549381e-01f, 1.87468678e-01f, 4.03198391e-01f, 4.89221722e-01f, 6.86561108e-01f, -4.89881128e-01f, -2.92162240e-01f,
  -1.80827722e-01f, 3.68224174e-01f, -2.33889297e-01f, 7.98594505e-02f, 1.90158308e-01f, 5.78275502e-01f, 5.35223067e-01f, 8.14676657e-02f, 4.94408756e-01f, -7.12623000e-01f,
  4.87482578e-01f, 2.32802421e-01f, 6.87740982e-01f, -1.47077188e-01f, -4.31317538e-02f, -3.36046457e-01f, 5.80654085e-01f, 8.15058053e-01f, 4.20533776e-01f, 2.22878680e-01f,
  3.97540122e-01f, 3.58476281e-01f, 2.69354023e-02f, 5.16909398e-02f, 6.99020743e-01f, 3.81906718e-01f, 5.59235930e-01f, -6.47979319e-01f, -1.71881533e-04f, -7.49027610e-01f,
  3.19276229e-02f, -5.18240631e-02f, 7.21242785e-01f, 8.88594463e-02f, 4.70943362e-01f, 4.74420428e-01f, 6.70153618e-01f, -9.54564512e-01f, 7.71410391e-02f, -2.43456736e-01f,
  -5.41606903e-01f, 3.72495987e-02f, -5.02826571e-01f, 6.44187257e-02f, -8.38380530e-02f, 8.25321078e-01f, 8.12351882e-01f, 4.69165385e-01f, -6.69627547e-01f, 1.49810672e-01f,
  7.58781657e-02f, 2.03401655e-01f, -3.38309914e-01f, -5.27296007e-01f, -6.53483272e-01f, -8.35296333e-01f, -5.22426248e-01f, 5.02206624e-01f, 3.77255768e-01f, -8.91317204e-02f,
  8.56538266e-02f, 1.56446800e-01f, 8.63102078e-02f, -5.40301681e-01f, -4.24984723e-01f, 4.59111556e-02f, 7.60455132e-01f, 4.80260223e-01f, 5.09554207e-01f, -5.57397485e-01f,
  -9.87526253e-02f, -5.04927695e-01f, 6.81157887e-01f, -1.49597540e-01f, -1.89208031e-01f, -1.28966063e-01f, -1.46286011e-01f, 5.47474921e-01f, 1.02925336e+00f, -8.49404991e-01f,
  2.08632216e-01f, 6.44204766e-02f, 2.34919086e-01f, 2.43192777e-01f, -2.79126823e-01f, -6.85234427e-01f, -3.51863891e-01f, -8.60190332e-01f, -6.53609753e-01f, 4.20563817e-01f,
  5.41113794e-01f, -4.38445926e-01f, 1.64453253e-01f, 2.04206526e-01f, 5.90020381e-02f, -6.66439295e-01f, -2.82843977e-01f, 4.84101146e-01f, 3.36098075e-01f, 5.27380526e-01f,
  4.49669480e-01f, -1.39038667e-01f, -8.64295512e-02f, 6.29678130e-01f, 1.44345850e-01f, -2.06061929e-01f, -2.77725011e-01f, -3.23026061e-01f, -3.62007767e-02f, -2.54230917e-01f,
  7.52771378e-01f, 8.09108198e-01f, 2.19434008e-01f, -3.77171665e-01f, 2.08072200e-01f, 1.85967252e-01f, 2.94185113e-02f, -1.51006117e-01f, -6.90879941e-01f, -2.52439559e-01f,
  -5.07851422e-01f, 9.90696967e-01f, 7.74837315e-01f, -5.68121791e-01f, 1.61774158e-01f, 3.88891175e-02f, -3.96945298e-01f, -1.59915667e-02f, 6.68776035e-01f, -2.71123797e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 10)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 10;
const float L1_fan_Bp_bar_data[] = {
  7.82519042e-01f, 5.74654043e-01f, 2.95014769e-01f, 1.71660572e-01f, 2.91763842e-01f, 3.70456159e-01f, 1.92085147e-01f, 7.21487045e-01f, 6.02661371e-01f, 6.62456334e-01f
};

// L2_fan_Wp (Shape: 3 x 16)
const int L2_fan_Wp_rows = 3;
const int L2_fan_Wp_cols = 16;
const float L2_fan_Wp_data[] = {
  -1.86536804e-01f, -1.89062208e-01f, -1.64888203e-01f, -2.37020209e-01f, 1.98928013e-01f, -2.07005255e-03f, 1.47367418e-01f, 3.53709877e-01f, 3.77741009e-02f, -3.05165023e-01f,
  1.97685361e-01f, -1.06839910e-01f, -1.19925007e-01f, -1.21158503e-01f, -2.17059776e-01f, -2.49324322e-01f, -1.37579381e-01f, 2.00530794e-03f, 8.83281231e-02f, 1.70386687e-01f,
  1.89999938e-01f, 2.50747353e-01f, 1.85361624e-01f, 1.07335165e-01f, 8.72669592e-02f, 3.46841067e-01f, -1.49778621e-02f, -1.62505925e-01f, 3.96736152e-02f, -2.66196847e-01f,
  -3.97242546e-01f, -2.97841221e-01f, -2.71715790e-01f, -1.38661921e-01f, -2.18908012e-01f, 3.04814279e-01f, -1.83181301e-01f, 1.94102973e-01f, -2.73229539e-01f, 2.26954982e-01f,
  -6.82203025e-02f, 1.25956699e-01f, 2.88292468e-01f, 1.97412632e-02f, -2.76120729e-03f, 8.70131478e-02f, 2.73493171e-01f, -3.47801328e-01f
};

// L2_fan_Wp_bar (Shape: 10 x 16)
const int L2_fan_Wp_bar_rows = 10;
const int L2_fan_Wp_bar_cols = 16;
const float L2_fan_Wp_bar_data[] = {
  3.61917675e-01f, 1.95517719e-01f, -1.93468451e-01f, 3.13539594e-01f, 2.88818896e-01f, 6.91695571e-01f, 5.89002430e-01f, 5.17486453e-01f, 7.12957859e-01f, -5.26707292e-01f,
  4.67599869e-01f, -6.69923127e-01f, -5.46483815e-01f, -7.36063957e-01f, 3.92766327e-01f, -9.63447392e-01f, 1.70207933e-01f, -2.58072048e-01f, 8.13374296e-02f, 4.24260557e-01f,
  1.62531331e-01f, -2.10743830e-01f, 7.01362908e-01f, 1.73764616e-01f, -8.52762461e-01f, 1.01316266e-01f, 8.80296528e-01f, -8.64032581e-02f, 9.54905510e-01f, -2.98941415e-02f,
  6.01804852e-01f, -2.25673780e-01f, 1.41425222e-01f, 6.53538946e-03f, 3.62319201e-01f, 2.83223391e-01f, 7.69385636e-01f, -1.07548378e-01f, 8.01545322e-01f, -5.43727100e-01f,
  3.31966221e-01f, 7.89482892e-01f, -3.13241929e-01f, -3.92117143e-01f, -5.43504469e-02f, -5.36530554e-01f, 2.70740598e-01f, 6.46321774e-01f, 3.73725981e-01f, 3.68853062e-01f,
  2.16739371e-01f, -8.22363317e-01f, 3.46985489e-01f, -7.84542680e-01f, 9.66660202e-01f, 1.05020416e+00f, -4.56042975e-01f, 6.11269958e-02f, 3.67097318e-01f, 8.46323907e-01f,
  -5.67192316e-01f, 1.01780605e+00f, -4.05182362e-01f, 9.69526052e-01f, 4.32825312e-02f, 5.05835354e-01f, 6.03968166e-02f, 1.97045296e-01f, 4.10547674e-01f, -2.31236771e-01f,
  5.01948655e-01f, -1.97879151e-01f, -4.05214190e-01f, -5.32463849e-01f, 1.05686295e+00f, 2.01835185e-01f, 1.27072394e+00f, 8.09854362e-03f, 7.22818613e-01f, -5.24079204e-01f,
  1.39125302e-01f, -8.78431648e-02f, 1.41623542e-01f, 3.12298596e-01f, 1.92355394e-01f, 6.06129766e-01f, 5.66752076e-01f, 6.47768915e-01f, 5.97696483e-01f, 7.61563659e-01f,
  -3.73709381e-01f, -5.69689810e-01f, 4.27393496e-01f, -4.17970538e-01f, -2.84962595e-01f, 4.59113896e-01f, -6.84059039e-02f, -1.60829023e-01f, 2.21432298e-02f, 4.13147390e-01f,
  7.03354999e-02f, 2.66524345e-01f, -4.14532900e-01f, -1.30522311e-01f, 7.37519324e-01f, 9.66047049e-01f, 1.49273902e-01f, -5.86735427e-01f, -2.41661910e-02f, -3.05380315e-01f,
  7.14666784e-01f, 4.85838920e-01f, -2.12847039e-01f, -3.82775337e-01f, 2.70215243e-01f, 5.24007976e-01f, 9.66983512e-02f, 5.89929819e-01f, -2.87998617e-01f, 5.67075789e-01f,
  8.13227952e-01f, 3.18811446e-01f, 1.89030617e-02f, -9.65000540e-02f, 7.37288713e-01f, 1.87269330e-01f, 3.00081167e-03f, -7.41423547e-01f, 2.12034106e-01f, -3.52194756e-01f,
  -6.28806353e-02f, 3.05925220e-01f, 8.16458225e-01f, -7.96637163e-02f, 1.00294232e+00f, 1.55751556e-01f, -2.67668098e-01f, -1.12629205e-01f, -2.93415636e-01f, -2.57126033e-01f,
  -1.72422618e-01f, -7.13137925e-01f, 2.00765461e-01f, 1.47662044e-01f, 4.92895216e-01f, -3.28102022e-01f, 4.57931235e-02f, -1.67000234e-01f, 4.52481180e-01f, -7.85302341e-01f,
  4.37406957e-01f, -4.88552332e-01f, -4.04362172e-01f, 2.62920141e-01f, 2.57248312e-01f, -8.18144560e-01f, -5.57233334e-01f, -9.40426767e-01f, 1.06556463e+00f, 2.93004811e-02f
};

// L2_fan_Bp_bar (Shape: 1 x 10)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 10;
const float L2_fan_Bp_bar_data[] = {
  1.78345770e-01f, 2.08349466e-01f, 1.12447821e-01f, 4.11710262e-01f, 1.87243253e-01f, -1.19242799e-02f, 8.64232481e-02f, 1.25393689e-01f, 4.17273372e-01f, 4.26051289e-01f
};

// L3_linear_W (Shape: 12 x 16)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 16;
const float L3_linear_W_data[] = {
  -2.04119772e-01f, -5.00926673e-01f, -1.46019742e-01f, 2.48085290e-01f, 2.92309910e-01f, 4.31455463e-01f, 6.65255249e-01f, 2.56490558e-01f, -9.34419692e-01f, 1.30581826e-01f,
  -5.79662994e-02f, 3.64950374e-02f, -5.49505472e-01f, -8.72799382e-02f, 3.86760831e-02f, -9.14451718e-01f, -2.80836731e-01f, -2.92161852e-01f, 7.49262050e-02f, 5.75424910e-01f,
  2.81299412e-01f, -4.63274568e-01f, 7.29537070e-01f, -5.47785759e-01f, 3.88197988e-01f, -3.19215566e-01f, -6.90612972e-01f, 2.30847344e-01f, -4.00581509e-01f, -8.43058992e-03f,
  7.76544750e-01f, -5.86550772e-01f, 1.17769688e-01f, -2.66683340e-01f, -3.27804565e-01f, -3.48632306e-01f, -2.02374250e-01f, -2.19875231e-01f, -4.37239319e-01f, -7.08924651e-01f,
  5.93770564e-01f, -1.66661739e-01f, -4.94052887e-01f, 5.20023465e-01f, 5.18926919e-01f, -1.04923546e-01f, -5.13313949e-01f, -4.59865868e-01f, -4.57326978e-01f, 3.14233422e-01f,
  -2.32848302e-01f, -1.49616554e-01f, -4.57259893e-01f, 1.09656900e-02f, -5.05230665e-01f, 6.95362687e-01f, -8.78418267e-01f, -7.74726927e-01f, 4.81400400e-01f, -7.44575083e-01f,
  -4.72838789e-01f, 1.22516222e-01f, -6.56251371e-01f, -3.87327880e-01f, 6.46610498e-01f, 1.07144251e-01f, 2.04999894e-01f, 6.10684931e-01f, -3.26639079e-02f, 3.04597080e-01f,
  -7.21035957e-01f, 2.43563280e-01f, -3.58774424e-01f, 5.30278444e-01f, 5.47838688e-01f, -4.67397511e-01f, -5.58049232e-02f, -6.88991487e-01f, -5.77139914e-01f, -2.36731276e-01f,
  2.67233830e-02f, 3.55139971e-01f, 6.42497838e-01f, 5.52113712e-01f, 6.28327787e-01f, -2.38204032e-01f, 6.59957975e-02f, 1.80918992e-01f, 9.39044803e-02f, 1.28046080e-01f,
  -2.23021153e-02f, -5.60234427e-01f, -8.49420249e-01f, -7.93096423e-01f, 5.69684267e-01f, 4.85909820e-01f, 4.35317913e-03f, 1.84446171e-01f, -2.06102729e-01f, -3.68726432e-01f,
  9.22411308e-02f, -3.02605301e-01f, -1.08494496e+00f, 1.34324674e-02f, 3.19553167e-01f, -1.74993426e-01f, -5.32084703e-01f, 7.23799989e-02f, 3.20385993e-01f, -4.60864514e-01f,
  4.77596849e-01f, 8.55524957e-01f, -2.06943229e-01f, -2.12889954e-01f, 3.61587644e-01f, -8.73141646e-01f, -6.92725599e-01f, -6.10220075e-01f, -6.47076219e-02f, -1.02640486e+00f,
  -5.07061660e-01f, 1.00394559e+00f, -9.08448994e-01f, -8.91259491e-01f, -2.32297450e-01f, -1.72543347e-01f, -8.22913587e-01f, -3.13748837e-01f, -4.48493659e-02f, 6.74735382e-02f,
  -9.84535646e-03f, 2.72483438e-01f, 1.65773615e-01f, 6.39579833e-01f, 4.17227596e-01f, -4.87653226e-01f, -5.97623348e-01f, -5.29247344e-01f, -4.28337783e-01f, 3.38699281e-01f,
  5.00686228e-01f, 8.54761004e-01f, -6.00013077e-01f, -2.46320695e-01f, 1.14921793e-01f, 2.42742404e-01f, -9.32796821e-02f, 1.99176475e-01f, -4.12285060e-01f, 3.37567717e-01f,
  -6.53318286e-01f, 2.78299861e-02f, 2.88601875e-01f, 4.87589926e-01f, -9.16401029e-01f, -6.86133131e-02f, -5.70870399e-01f, -1.79307625e-01f, 3.02039981e-01f, -5.88055968e-01f,
  -2.59086460e-01f, -1.46938995e-01f, 2.65811197e-02f, -4.65001673e-01f, 4.57202077e-01f, 4.66834635e-01f, -3.33647847e-01f, 2.44502842e-01f, 4.08341289e-01f, -1.09365332e+00f,
  2.48565435e-01f, 2.03920752e-01f, 6.11053500e-03f, 3.43296111e-01f, 1.41043440e-01f, -3.28843594e-01f, 2.87946314e-01f, -2.35409379e-01f, -4.24813420e-01f, -7.05673754e-01f,
  -2.52135217e-01f, 1.94359139e-01f, 4.52062607e-01f, 2.45352387e-01f, -1.69248320e-02f, -6.32564247e-01f, 3.53081614e-01f, -1.00972974e+00f, 4.83237296e-01f, -6.37102842e-01f,
  -1.95618942e-02f, 6.69092715e-01f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  -2.39464998e-01f, 4.24323194e-02f, -1.83805123e-01f, 1.78937361e-01f, 9.97151360e-02f, -1.27591684e-01f, -1.76737905e-01f, 4.88448203e-01f, 2.54592430e-02f, -2.02874601e-01f,
  -1.00325890e-01f, -2.74080962e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 3, 10
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 3, 10
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        16, 3, 10
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        16, 12
    );
    }
    