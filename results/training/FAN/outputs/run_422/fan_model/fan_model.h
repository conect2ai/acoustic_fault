/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 1 x 120)
const int L0_fan_Wp_rows = 1;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -1.78080648e-01f, -3.15247104e-02f, 9.42380575e-04f, 1.77408323e-01f, -1.54710218e-01f, -4.13174123e-01f, -1.65744171e-01f, 1.84063872e-04f, 1.45929113e-01f, -3.73069607e-02f,
  -6.55080676e-02f, -2.93818638e-02f, 9.40388441e-02f, -8.62879083e-02f, 1.69367492e-01f, 3.70418951e-02f, 9.53663215e-02f, -1.01485275e-01f, 9.09105912e-02f, 4.08768363e-04f,
  8.70262831e-02f, -2.39577498e-02f, -9.11155995e-03f, 4.38754521e-02f, -1.05989575e-01f, 1.36424243e-01f, 1.03153795e-01f, -2.26100888e-02f, -1.06168613e-01f, 8.19147192e-03f,
  -1.88590258e-01f, 1.77130282e-01f, 7.07449485e-03f, -3.38121271e-03f, -6.76620286e-03f, -1.17719024e-01f, -4.82185259e-02f, -5.17847389e-02f, -2.25642063e-02f, 1.46490159e-02f,
  1.35777825e-02f, 7.16582388e-02f, -4.06447612e-03f, -1.76775753e-02f, -1.40396906e-02f, 3.86864729e-02f, 1.11241359e-02f, -3.10383979e-02f, 2.00242810e-02f, -5.05037419e-02f,
  -1.72182713e-02f, -4.58086934e-03f, 1.70862139e-03f, -2.79027801e-02f, 6.44166768e-02f, 4.45981212e-02f, 3.34013021e-03f, -5.96240349e-02f, 1.04877185e-02f, 1.04850931e-02f,
  -1.01509634e-02f, 3.17303464e-02f, -3.56105599e-03f, 3.92834134e-02f, 4.82995203e-03f, 4.38755937e-02f, 4.90522385e-02f, -2.43810602e-02f, -1.28762228e-02f, 6.91505428e-03f,
  1.35030989e-02f, -1.54253207e-02f, 1.08438525e-02f, -9.46460757e-03f, 5.83512057e-03f, 2.59995554e-02f, 5.85637540e-02f, -3.31025221e-03f, 5.62554318e-03f, -6.73051253e-02f,
  6.41281484e-04f, -1.22091100e-02f, 2.05269530e-02f, -6.33617267e-02f, 1.50596742e-02f, 3.72170508e-02f, 1.00895844e-01f, -5.32210618e-02f, 5.49039505e-02f, -5.44987768e-02f,
  8.50711763e-02f, 2.83805221e-01f, 1.89870514e-03f, -2.35094912e-02f, 8.74555111e-03f, 3.91204543e-02f, 4.66550253e-02f, -6.84375837e-02f, 4.72487733e-02f, 1.20073259e-02f,
  -1.42684598e-02f, -1.01369239e-01f, -3.27784233e-02f, 5.55861322e-03f, 1.34822419e-02f, 3.08454856e-02f, 8.41607451e-02f, 2.74663474e-02f, 1.03232311e-02f, 1.14444243e-02f,
  2.01487783e-02f, -8.78569707e-02f, 4.60072644e-02f, -6.30002245e-02f, -9.45656225e-02f, -6.70025544e-03f, -2.13242974e-02f, 5.34077100e-02f, -1.90703981e-02f, -6.98523670e-02f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -4.27872926e-01f, 4.62254614e-01f, -7.86479488e-02f, 2.36417934e-01f, 5.68700731e-01f, 7.96600699e-01f, 4.31148887e-01f, 3.39837164e-01f, 4.22573119e-01f, -6.30308166e-02f,
  -6.80220425e-02f, -1.55831590e-01f, -2.93829381e-01f, 1.27672851e-02f, 2.01963618e-01f, 1.42979130e-01f, 4.83436167e-01f, 1.89408675e-01f, 3.03161651e-01f, -4.31998745e-02f,
  1.90225005e-01f, 3.12972158e-01f, -1.61747143e-01f, 2.73543298e-01f, 6.57292083e-02f, 8.13304484e-02f, 5.62028261e-03f, -1.38100833e-01f, 1.36019588e-01f, 2.85598069e-01f,
  7.94983581e-02f, -2.84178197e-01f, -1.98807001e-01f, -1.98633343e-01f, 1.25993952e-01f, -1.77743137e-02f, 3.13494243e-02f, -9.69150886e-02f, -8.65357965e-02f, -1.33745959e-02f,
  -1.85879365e-01f, -1.10855855e-01f, 2.25803275e-02f, -9.95823182e-03f, 1.06475897e-01f, -5.07009029e-02f, -3.19982693e-02f, -4.79192398e-02f, 3.15585569e-03f, -7.04357354e-03f,
  -9.14946049e-02f, 8.09890404e-02f, -5.93422838e-02f, 5.02968691e-02f, -1.27334699e-01f, 5.68065010e-02f, 4.36171480e-02f, 7.87818730e-02f, 1.56081095e-01f, 1.93027616e-01f,
  9.45134982e-02f, 9.08174515e-02f, -8.09462667e-02f, -5.83827831e-02f, 7.16608465e-02f, 1.17749684e-01f, 8.56225193e-03f, 1.01654612e-01f, -2.66600996e-02f, -8.97269696e-02f,
  5.29493392e-02f, -1.22476518e-02f, 1.72291398e-01f, 3.53986472e-02f, 1.28268242e-01f, -7.17274174e-02f, -1.01803042e-01f, 6.69126585e-02f, -2.53796671e-02f, 6.82845116e-02f,
  -8.57664719e-02f, -8.58559608e-02f, 7.10170623e-03f, -2.56050490e-02f, -3.88080329e-02f, -5.07419445e-02f, -7.29236901e-02f, 3.70216556e-03f, -6.79059327e-02f, -9.39554423e-02f,
  3.74367207e-01f, 3.57265472e-01f, 2.98674181e-02f, -5.62000871e-02f, 9.69945714e-02f, 3.90262678e-02f, -3.96540808e-03f, 8.40743408e-02f, 2.05521628e-01f, -6.70210943e-02f,
  5.88226356e-02f, 5.73191866e-02f, -1.31621808e-01f, -3.76698263e-02f, 7.06296787e-02f, 1.48645833e-01f, 3.17822061e-02f, 7.55387247e-02f, 1.13545842e-01f, 5.78045435e-02f,
  -1.98483840e-01f, -7.71615356e-02f, -2.07809936e-02f, -4.28454578e-02f, 6.47183806e-02f, -1.57678761e-02f, -2.20478605e-02f, 7.84513876e-02f, 9.69241709e-02f, -3.59675288e-03f,
  -7.43803203e-01f, 1.29990906e-01f, -4.94753361e-01f, -1.43843368e-01f, -2.10836768e-01f, -3.92179668e-01f, -9.47505683e-02f, -1.83170691e-01f, 1.19022459e-01f, 2.02147454e-01f,
  8.58435482e-02f, -1.68561190e-01f, 1.66608125e-01f, -4.57083918e-02f, -3.38742018e-01f, 3.00980985e-01f, -1.10084869e-01f, 8.82420503e-03f, 1.20816886e-01f, -3.87767762e-01f,
  -1.25345374e-02f, 1.81212183e-03f, -9.52473506e-02f, -2.35864054e-02f, -3.03854972e-01f, -1.36038437e-01f, -6.39058603e-03f, -1.88890681e-01f, -4.56727184e-02f, -7.21155666e-03f,
  -4.08996254e-01f, -4.22062218e-01f, -1.52032509e-01f, -3.85614894e-02f, -1.77602038e-01f, -8.21472257e-02f, -1.35066763e-01f, 2.15437282e-02f, -1.13835745e-01f, -9.73145962e-02f,
  -4.94346172e-02f, -7.07685351e-02f, 5.02783395e-02f, 4.10264079e-03f, 2.24458911e-02f, 5.19873910e-02f, 4.52646129e-02f, 1.05893807e-02f, 4.16944623e-02f, -2.18329709e-02f,
  -7.59360492e-02f, -9.78505760e-02f, -1.41911030e-01f, 1.29632771e-01f, 5.21763675e-02f, -3.86525430e-02f, -1.46353781e-01f, -7.99264684e-02f, -1.04497179e-01f, -6.73791394e-02f,
  1.69217084e-02f, 1.00877360e-01f, 2.97208242e-02f, 1.08779497e-01f, -1.05988353e-01f, 2.96248514e-02f, -3.14307585e-02f, 7.30583593e-02f, -1.27828866e-02f, 7.37710074e-02f,
  -4.58422936e-02f, 3.91585976e-02f, -6.28501698e-02f, -5.87969944e-02f, -9.40446556e-03f, 8.90612043e-03f, 1.75138786e-02f, -1.36764541e-01f, 1.19990535e-01f, 9.32157263e-02f,
  -1.54700791e-02f, 2.25471947e-02f, 9.75685194e-02f, 3.76407010e-03f, -6.98948875e-02f, 7.45936334e-02f, 6.22252151e-02f, -4.55858745e-02f, -1.10150479e-01f, -1.00858927e-01f,
  -2.79386938e-01f, -5.48521101e-01f, 3.76363397e-02f, 3.64965363e-03f, 8.30404684e-02f, -8.32568109e-02f, 1.04935177e-01f, -9.30145606e-02f, -1.13656059e-01f, -1.28974110e-01f,
  2.84407958e-02f, 7.77241215e-02f, -1.17282093e-01f, -2.11454760e-02f, 1.48007125e-02f, 7.71235302e-02f, -1.45038486e-01f, -1.14299897e-02f, -1.68048009e-01f, -7.91898221e-02f,
  -2.01347638e-02f, -3.44353542e-02f, 1.81450769e-01f, 7.09633976e-02f, 1.41968817e-01f, -7.55565008e-03f, 2.33175997e-02f, -2.50054467e-02f, 5.25483442e-03f, 9.73158106e-02f,
  -4.59888577e-02f, -4.23199058e-01f, -1.55131802e-01f, 1.11395486e-01f, -3.08752377e-02f, -2.86819428e-01f, -4.52379286e-02f, -3.10619265e-01f, 1.91846862e-01f, -2.35366434e-01f,
  -4.58560809e-02f, 1.11551121e-01f, 2.21305907e-01f, -5.06425083e-01f, 6.03448331e-01f, 2.29004547e-01f, -3.37958038e-01f, -1.40215918e-01f, 1.01169832e-01f, -1.94169909e-01f,
  4.94457074e-02f, -2.42381498e-01f, 4.52798158e-02f, -3.16172153e-01f, -1.71336442e-01f, -1.07189305e-01f, 1.49720460e-01f, 4.37623002e-02f, -3.23729575e-01f, 7.76835680e-02f,
  -1.80376574e-01f, 9.37498584e-02f, -1.06780268e-01f, -1.72046665e-02f, -9.56560150e-02f, -5.06667420e-02f, 5.53556755e-02f, 1.56343982e-01f, 9.18016583e-03f, -6.26147911e-02f,
  -6.98307157e-02f, -3.05447076e-02f, -8.34812224e-02f, 1.28450081e-01f, -2.10726839e-02f, -1.13370210e-01f, 4.57774289e-02f, -2.03187075e-02f, -8.76353681e-02f, 6.15505315e-03f,
  -1.59179494e-01f, -4.54841880e-03f, -1.19027488e-01f, 4.30954769e-02f, -5.04739764e-05f, -9.11320373e-02f, -7.56015629e-02f, 1.48419410e-01f, -3.87547761e-02f, 8.61346163e-03f,
  5.94924800e-02f, 3.38889286e-02f, -2.98946854e-02f, -1.01157144e-01f, -1.64061859e-02f, -1.14969842e-01f, -5.45973219e-02f, 6.02356680e-02f, 4.31592911e-02f, -8.27899575e-02f,
  -6.64536282e-02f, -1.21987807e-02f, -5.08301258e-02f, 8.54290202e-02f, -3.49808596e-02f, 1.41771948e-02f, 9.26974714e-02f, -1.22562731e-02f, -1.01513676e-01f, -4.81960662e-02f,
  4.43505533e-02f, -1.90850887e-02f, -1.15002068e-02f, 1.03255220e-01f, 5.85838780e-03f, 1.32875443e-01f, -1.14730649e-01f, 1.76703483e-02f, 2.40260437e-02f, 6.52805418e-02f,
  5.75433299e-02f, 7.68486485e-02f, -9.14772972e-02f, 6.41166931e-03f, 1.27009535e-02f, -4.29558866e-02f, -3.74530964e-02f, -3.46257761e-02f, 5.06167598e-02f, 6.94730226e-03f,
  -2.60069482e-02f, 6.81473017e-02f, 2.65808851e-02f, -2.07045451e-02f, -2.32762825e-02f, -8.38576555e-02f, -3.65676023e-02f, -3.75332334e-03f, 3.37708555e-02f, 3.08142658e-02f,
  -7.19202962e-03f, 4.39937487e-02f, 1.46868631e-01f, 1.23543246e-02f, -1.86155159e-02f, -1.13245379e-02f, -2.70038508e-02f, -1.29042650e-02f, 2.32285392e-02f, 7.46887270e-03f,
  7.86006987e-01f, 3.47012319e-02f, -8.50126967e-02f, 5.10257065e-01f, 2.86176771e-01f, 2.64243424e-01f, 1.55337930e-01f, 3.40552449e-01f, 7.32355714e-01f, -1.02241628e-01f,
  -3.20880190e-02f, -2.32670009e-01f, -1.07555419e-01f, -5.59875183e-02f, -5.52974269e-02f, 5.72896674e-02f, 1.69414774e-01f, -9.92588326e-02f, 3.00163537e-01f, 9.46824104e-02f,
  3.08305800e-01f, 4.55084369e-02f, -3.16896915e-01f, -4.28258330e-02f, -5.88783920e-02f, -6.38172822e-03f, -2.62404919e-01f, -1.59362331e-01f, -3.00601423e-01f, -7.54166618e-02f,
  5.60725890e-02f, 4.03957255e-03f, -8.77832919e-02f, 2.91043930e-02f, -5.18282466e-02f, -1.94480047e-02f, -1.49417415e-01f, -1.19143315e-01f, 9.01829153e-02f, -4.78614196e-02f,
  -1.02696620e-01f, 2.37742458e-02f, 5.71044050e-02f, 4.70162965e-02f, 9.35543403e-02f, 7.85232708e-02f, 1.35152135e-02f, 2.50150692e-02f, -2.78875381e-02f, -1.13256462e-03f,
  -7.65630454e-02f, -7.35957525e-04f, 6.04084358e-02f, -6.21475205e-02f, -4.20531770e-03f, 1.44200185e-02f, -1.09792143e-01f, -8.55734795e-02f, -1.21499531e-01f, 1.70054808e-02f,
  -2.11905800e-02f, 2.83496268e-02f, -8.12875926e-02f, 4.62347977e-02f, 2.91050039e-02f, 4.98988554e-02f, -3.57748172e-03f, -1.15923300e-01f, 1.35132775e-01f, -8.52166265e-02f,
  5.88619001e-02f, -2.61817556e-02f, 8.62103626e-02f, 6.98383059e-03f, 9.87328310e-03f, 9.26542506e-02f, -5.79113932e-03f, -4.89086248e-02f, 3.95663790e-02f, 6.69794902e-02f,
  8.79224166e-02f, -1.36657916e-02f, -7.89629668e-02f, 6.53106207e-03f, -4.36759088e-03f, -3.36755738e-02f, -1.30370203e-02f, 2.82034092e-02f, -1.31740570e-02f, -2.70349756e-02f,
  2.38900427e-02f, -3.97359990e-02f, 1.05128884e-01f, -3.01899668e-02f, -7.49018937e-02f, -2.56818831e-02f, 5.73017709e-02f, 1.18582798e-02f, -1.33353189e-01f, 7.23810568e-02f,
  -1.34160416e-02f, 4.79253903e-02f, -3.02655958e-02f, -3.81199121e-02f, -9.14715827e-02f, -4.85790409e-02f, -9.36945751e-02f, -1.83503311e-02f, -3.35175581e-02f, -2.13768072e-02f,
  -5.42312413e-02f, -1.19341770e-02f, 5.04954383e-02f, 9.33195129e-02f, 6.68209717e-02f, -1.23596400e-01f, 8.66726488e-02f, -1.72117651e-02f, -1.26071900e-01f, -3.68723348e-02f,
  1.41537935e-01f, -5.25432155e-02f, -5.94563633e-02f, -2.76633203e-01f, -2.06199184e-01f, -1.09319218e-01f, -9.95624065e-02f, -2.88213849e-01f, -3.81863117e-01f, -1.14787064e-01f,
  -1.74639925e-01f, -3.23427677e-01f, 3.56209457e-01f, -1.04172543e-01f, 2.03411475e-01f, 3.95007074e-01f, -1.57077119e-01f, -1.56389717e-02f, 1.86998338e-01f, 5.85273094e-02f,
  -4.71777935e-03f, 8.45123529e-02f, 4.07195687e-01f, -1.25668487e-02f, -1.94123968e-01f, -7.24109337e-02f, -6.02069907e-02f, 3.15078087e-02f, -1.71522275e-01f, -3.04486826e-02f,
  9.72060934e-02f, 6.86705299e-03f, -2.22443603e-02f, 2.06603128e-02f, 9.43217054e-02f, 5.93197569e-02f, 4.51866128e-02f, 1.08843043e-01f, -6.22491539e-02f, -1.24962889e-01f,
  -3.48245772e-03f, -3.28515619e-02f, -6.36429861e-02f, -5.19642644e-02f, 4.35839184e-02f, -1.03734791e-01f, 3.57963778e-02f, -9.59339216e-02f, 3.28638218e-02f, 1.39479429e-01f,
  -8.79897177e-02f, -5.81167312e-03f, -6.97704852e-02f, 7.02059940e-02f, -2.08673015e-01f, -4.54580691e-03f, 4.81387526e-02f, -3.54095586e-02f, -1.45483211e-01f, -1.78418532e-01f,
  -3.81160565e-02f, 4.10519466e-02f, 1.25601972e-02f, 4.81430031e-02f, 6.75477311e-02f, 1.14153601e-01f, 1.04415426e-02f, 3.30350958e-02f, -1.26507938e-01f, 2.91091241e-02f,
  -9.78589430e-02f, -1.57079756e-01f, 1.32788187e-02f, 7.56796300e-02f, -1.12570003e-02f, -1.66485701e-02f, 2.46151313e-01f, -7.18159601e-02f, -1.17886402e-01f, 1.27402991e-02f,
  1.55400842e-01f, -3.92703339e-02f, -1.51528507e-01f, 6.74605668e-02f, 2.45898776e-02f, -1.74692401e-03f, -4.51555587e-02f, 3.35452966e-02f, 3.35387178e-02f, -7.17273727e-02f,
  -1.23386450e-01f, -2.39357129e-01f, 9.29753333e-02f, -8.99666026e-02f, 6.86348006e-02f, -4.91286181e-02f, 9.19481739e-02f, -1.16248466e-01f, -1.72648728e-01f, -1.29785076e-01f,
  -1.19878784e-01f, 1.26581684e-01f, -6.63094074e-02f, 2.41994206e-02f, -1.66162640e-01f, -7.28719309e-02f, 3.97908986e-02f, -8.95067826e-02f, -1.26667753e-01f, -1.37660597e-02f,
  -8.52996781e-02f, -1.84674431e-02f, -4.53931093e-02f, -1.14543818e-01f, -7.82569647e-02f, -9.93144885e-02f, -1.47635713e-01f, -4.35133576e-02f, -2.02729460e-02f, -1.11083478e-01f,
  5.48676681e-03f, 1.66389450e-01f, -4.57758427e-01f, -1.75754935e-01f, -4.85081851e-01f, 1.23450696e-01f, 1.08546495e-01f, -1.16891690e-01f, -3.23667563e-02f, 4.17249292e-01f,
  1.64689437e-01f, -1.26710152e-02f, 4.56020445e-01f, 8.83185267e-02f, 3.63054127e-02f, 5.64786077e-01f, 1.62877589e-01f, 5.49340062e-02f, -6.29251674e-02f, 6.43289983e-02f,
  -6.78272620e-02f, 2.47573033e-01f, 5.09233437e-02f, 3.42678465e-02f, -2.09650323e-01f, -1.97802126e-01f, -1.08180465e-02f, -2.15355277e-01f, -1.64610177e-01f, -9.06591713e-02f,
  8.52209255e-02f, 2.67747510e-02f, -9.58889201e-02f, 2.24425141e-02f, -1.26263782e-01f, -1.31518498e-01f, -1.27516970e-01f, -2.01200277e-01f, -4.76532876e-02f, 8.14528298e-03f,
  1.42523721e-01f, -1.17783090e-02f, 6.46077543e-02f, -1.46398172e-01f, -1.13353975e-01f, -7.97175616e-02f, -1.21195652e-01f, 8.74395948e-03f, -1.69738550e-02f, -1.92578137e-02f,
  1.05993725e-01f, -4.44051400e-02f, -9.47605595e-02f, 5.42540662e-02f, -7.01935664e-02f, 3.87353823e-02f, 9.65375006e-02f, -6.38610795e-02f, -5.44629060e-04f, -4.43281978e-02f,
  1.68065799e-05f, -1.05199337e-01f, 3.78725827e-02f, 6.31992444e-02f, 2.76510194e-02f, -2.91422978e-02f, 1.95299443e-02f, -6.57927096e-02f, 1.02912910e-01f, 1.95195861e-02f,
  -4.92224842e-02f, 1.30974753e-02f, 1.02873240e-02f, 7.76474997e-02f, -4.68215309e-02f, 1.21307023e-01f, -2.39544958e-02f, -1.27968714e-02f, 7.90927792e-04f, -5.89995757e-02f,
  -3.04303486e-02f, 5.21600395e-02f, -4.88373190e-02f, -5.32974210e-03f, 3.65498029e-02f, -6.40101731e-02f, 9.04935077e-02f, 4.57649119e-03f, 1.87723804e-02f, 7.99358189e-02f,
  2.77683381e-02f, -6.11578627e-03f, 6.05621524e-02f, 7.00641796e-02f, -9.00889263e-02f, 4.52103689e-02f, -5.86197898e-02f, -2.86706146e-02f, -1.53408647e-01f, 1.87149748e-01f,
  1.04710624e-01f, 9.80062857e-02f, -8.77302438e-02f, -2.25588400e-02f, 6.11690693e-02f, 1.43527195e-01f, 4.93955053e-02f, 2.03770380e-02f, -2.97524408e-02f, -1.46039069e-01f,
  1.61441222e-01f, 1.55469641e-01f, 1.10337637e-01f, -4.78616543e-02f, -1.24213502e-01f, 5.59264496e-02f, -7.03398213e-02f, -6.47356734e-02f, -5.46465367e-02f, 8.67915079e-02f,
  -1.04564333e+00f, 2.90919334e-01f, -2.93046944e-02f, -4.92594928e-01f, 1.42894492e-01f, 1.76606432e-01f, -1.92237776e-02f, 2.54877716e-01f, -8.74259248e-02f, 1.09713785e-01f,
  2.26520542e-02f, -2.29973450e-01f, 3.63329023e-01f, 1.11287333e-01f, -2.89636225e-01f, 2.31509790e-01f, -1.55720651e-01f, -7.79437572e-02f, 1.35217473e-01f, -1.12903103e-01f,
  -1.69658214e-01f, -5.34997843e-02f, -1.17240421e-01f, 2.20338821e-01f, -1.54729828e-01f, -1.72689095e-01f, -3.94578695e-01f, 2.38329738e-01f, -2.40597397e-01f, 3.97232696e-02f,
  -3.78216505e-01f, -2.19000075e-02f, -1.06089674e-01f, 1.23963766e-02f, -1.86862066e-01f, -7.63242543e-02f, -1.31752178e-01f, 3.35322209e-02f, 3.18497717e-02f, 9.57072452e-02f,
  -4.86313812e-02f, 6.72631152e-03f, -3.02561279e-02f, 1.35381237e-01f, 1.61565151e-02f, 4.13688570e-02f, -7.31366649e-02f, -2.29524300e-02f, -1.81230269e-02f, 4.40691449e-02f,
  5.11058941e-02f, -4.07882407e-02f, -1.08455256e-01f, -9.39544290e-02f, -1.19419284e-01f, 1.13824653e-02f, 1.62755847e-02f, -1.07701141e-02f, -1.31749868e-01f, -6.00248054e-02f,
  2.40866579e-02f, -2.42036898e-04f, 6.58915192e-02f, 2.33193319e-02f, 7.01170042e-02f, -2.30762996e-02f, 7.28802010e-02f, -3.93794328e-02f, -4.63385098e-02f, -1.23271709e-02f,
  -7.99655318e-02f, -2.68841833e-02f, 4.19793390e-02f, -1.01041459e-01f, -1.01407312e-01f, -4.46535870e-02f, -4.05722260e-02f, 3.14162485e-02f, 5.39949350e-02f, -1.08484842e-01f,
  -7.08216205e-02f, 7.04242587e-02f, 4.36745957e-02f, -5.94512075e-02f, 1.42478561e-02f, -3.85047421e-02f, 8.67119431e-02f, -3.40270214e-02f, -1.39400745e-02f, -6.52896538e-02f,
  -3.12909007e-01f, -3.85605097e-01f, 8.84077996e-02f, 9.40307882e-03f, -5.91254309e-02f, -1.49640972e-02f, -3.53118330e-02f, 7.30454409e-03f, 1.12571064e-02f, 5.86834587e-02f,
  -6.64518476e-02f, -7.46935531e-02f, -1.44754052e-01f, -2.06703343e-03f, -2.66322698e-02f, -1.17252380e-01f, -3.59277576e-02f, -1.29507303e-01f, -1.66359305e-01f, -1.33525683e-02f,
  -9.35766250e-02f, 3.35103758e-02f, 4.54790480e-02f, 2.97210887e-02f, 1.66498460e-02f, -1.48675129e-01f, -1.92863215e-02f, -2.82449089e-02f, -2.46934928e-02f, 7.38991275e-02f,
  -5.55714965e-01f, -6.83992729e-03f, -6.68946246e-04f, -3.61161798e-01f, 5.87047264e-02f, -9.28032175e-02f, -2.32679427e-01f, 2.69803971e-01f, -3.65192533e-01f, 9.56075639e-02f,
  1.97259352e-01f, -4.42950368e-01f, 3.29984158e-01f, -4.01075840e-01f, -2.28178576e-01f, -1.21755049e-01f, -2.45545268e-01f, -1.25858903e-01f, -1.31153569e-01f, 2.77215511e-01f,
  -5.58584780e-02f, 1.09801076e-01f, 8.49684626e-02f, 2.45058522e-01f, 4.24836613e-02f, 2.06958592e-01f, 5.12752950e-01f, 2.47861058e-01f, 4.01027687e-02f, -2.72771977e-02f,
  -8.21108148e-02f, -1.95049252e-02f, 7.75208101e-02f, 2.55377088e-02f, 1.65618554e-01f, 2.90255900e-02f, 6.37993142e-02f, -9.96470153e-02f, 7.61176832e-03f, -1.01963691e-02f,
  2.34071258e-02f, -1.81289967e-02f, -7.10020661e-02f, -3.63338366e-02f, -1.42212853e-01f, -8.05328563e-02f, 6.61860406e-02f, 1.02457486e-03f, -3.32037220e-04f, -3.31246406e-02f,
  -8.29118341e-02f, -5.08843921e-02f, -1.77240111e-02f, -3.44479680e-02f, -6.35843650e-02f, -5.21460958e-02f, -1.74541213e-02f, 2.04624142e-02f, -2.80822385e-02f, -9.81101096e-02f,
  -2.25736909e-02f, 3.49020027e-02f, 1.64034236e-02f, -1.42125096e-02f, -2.04407927e-02f, -4.15533409e-02f, -9.12218615e-02f, 6.89268932e-02f, -1.07187785e-01f, -4.66923937e-02f,
  1.35470005e-02f, -9.75391492e-02f, -4.08792980e-02f, 2.81890226e-03f, 6.15783073e-02f, 2.71888394e-02f, -2.55718697e-02f, 8.42019990e-02f, -6.05884865e-02f, -7.66988322e-02f,
  -9.47578158e-03f, -1.86060891e-01f, -2.66482532e-02f, -1.53897079e-02f, -2.35269517e-02f, 5.94873130e-02f, -1.63765699e-02f, -2.53235735e-02f, 4.02085893e-02f, 5.23986258e-02f,
  2.22908318e-01f, 3.66542190e-01f, -6.08537951e-03f, -1.04021020e-02f, 1.23649454e-02f, 4.70800931e-03f, -5.97351231e-02f, 9.74771753e-03f, 2.76144277e-02f, 5.48136495e-02f,
  1.04166687e-01f, -6.82378607e-03f, 9.22307931e-03f, -1.34190172e-01f, -3.44698317e-02f, -1.29168795e-04f, 1.18402377e-01f, 5.43906465e-02f, 3.70544530e-02f, -2.31211726e-02f,
  1.05952136e-01f, -9.15663410e-03f, -1.72866434e-01f, -1.91268008e-02f, -1.03225872e-01f, 6.75099641e-02f, 3.33952494e-02f, -2.05376241e-02f, -1.48799550e-02f, -5.77056482e-02f,
  5.61828315e-01f, -3.26546460e-01f, -3.36529240e-02f, 5.45265991e-03f, 4.43658650e-01f, 3.28288466e-01f, 8.39902103e-01f, 6.24012351e-02f, 1.12056889e-01f, -5.18977791e-02f,
  3.73495579e-01f, -8.44808444e-02f, 2.58229613e-01f, 1.03344277e-01f, 4.18157309e-01f, 3.04735433e-02f, 1.55508444e-01f, 3.11465040e-02f, -1.43058926e-01f, 3.93913202e-02f,
  1.47151828e-01f, 1.98987395e-01f, -1.71750952e-02f, -2.12993085e-01f, 9.10446867e-02f, -1.74558327e-01f, 3.59399430e-02f, 4.41286936e-02f, -7.49185607e-02f, 6.43165633e-02f,
  6.42277524e-02f, 1.14093877e-01f, 1.95606407e-02f, -1.21610887e-01f, 1.94023140e-02f, -2.39776615e-02f, -5.02736717e-02f, 1.72169097e-02f, 1.19869359e-01f, 3.51831056e-02f,
  -3.50604882e-03f, -3.82144302e-02f, -1.27416989e-02f, 3.95987518e-02f, 3.85746770e-02f, -6.71838820e-02f, 7.46979704e-03f, -4.49367277e-02f, -5.36172502e-02f, -7.80739635e-02f,
  3.34679969e-02f, -3.33588980e-02f, -4.63188104e-02f, -1.44238815e-01f, 4.87612560e-03f, -9.24593434e-02f, -2.44936161e-02f, 2.36424361e-03f, 2.92688143e-02f, -3.54619473e-02f,
  1.80215668e-02f, -2.78254282e-02f, 1.14320271e-01f, 4.97890413e-02f, 4.80638109e-02f, -3.98894288e-02f, 6.45761043e-02f, 7.36984313e-02f, -1.16938896e-01f, 3.79479602e-02f,
  1.95473600e-02f, 1.30468577e-01f, -1.54218348e-02f, -9.85277537e-03f, 1.00179859e-01f, -3.81993242e-02f, 1.46775031e-02f, 8.40704367e-02f, 4.57065329e-02f, 2.62552258e-02f,
  -7.04142358e-03f, 8.00066292e-02f, 1.70185976e-02f, -5.66083491e-02f, -3.43325431e-03f, 3.98771092e-02f, 4.44104448e-02f, -5.01917163e-03f, -2.83315144e-02f, 1.24811329e-01f,
  -1.10329445e-02f, -1.63906813e-01f, 3.22545767e-02f, -2.66999155e-02f, -1.63905919e-01f, -1.19562238e-01f, -7.33674988e-02f, 1.81381386e-02f, -5.63067570e-02f, 1.61666088e-02f,
  -7.18619525e-02f, -2.61573996e-02f, 7.09017320e-03f, -4.81900871e-02f, -1.24769984e-02f, 3.93001325e-02f, 1.39545146e-02f, -7.27791339e-02f, 6.27982430e-03f, -5.19476533e-02f,
  9.54195205e-03f, 6.64010942e-02f, 4.25864682e-02f, 6.35335445e-02f, -3.04696206e-02f, -1.98534806e-03f, -6.19289726e-02f, -2.22086273e-02f, 1.12668863e-02f, -3.95834111e-02f,
  1.48107827e-01f, -2.69439965e-01f, -4.77865905e-01f, 2.83247590e-01f, -1.10486843e-01f, -2.79274166e-01f, -5.23118198e-01f, 1.75536647e-01f, -2.86956459e-01f, -1.09693162e-01f,
  3.11937213e-01f, -2.82002002e-01f, -3.33479822e-01f, 6.00892246e-01f, 5.59245408e-01f, -1.05986714e-01f, 4.62715894e-01f, 1.46076441e-01f, -3.53486389e-02f, 2.07804590e-01f,
  3.64993572e-01f, 7.40992725e-01f, 2.49536127e-01f, 5.32420456e-01f, 9.89530087e-02f, 1.70579866e-01f, 5.24584889e-01f, -1.70598343e-01f, 4.74536091e-01f, 1.21305123e-01f,
  -1.82363074e-02f, 1.20825253e-01f, -3.70451808e-02f, -8.99746418e-02f, 3.73794734e-02f, -6.15028217e-02f, -5.33196554e-02f, 2.06024311e-02f, 2.34923381e-02f, 4.92350832e-02f,
  -1.56144634e-01f, 5.69620430e-02f, 1.04659274e-01f, -1.22006983e-02f, -2.71475036e-02f, 1.19126728e-02f, -5.08220531e-02f, -1.38196021e-01f, -2.08405674e-01f, -3.76315676e-02f,
  -1.39660060e-01f, -1.17780194e-01f, -5.48668951e-02f, -1.13266222e-01f, -4.79600672e-03f, -2.36033667e-02f, -1.23008631e-01f, 6.61623525e-03f, -1.55906398e-02f, 6.07245937e-02f,
  6.18639812e-02f, -1.19940937e-01f, -3.98318768e-02f, -5.62007166e-02f, 5.93457967e-02f, -3.35387625e-02f, -2.94317934e-03f, -4.18837965e-02f, -3.47138904e-02f, -5.62391318e-02f,
  9.29200873e-02f, -5.94018176e-02f, 1.87952293e-03f, -7.57898390e-02f, 9.18262973e-02f, -1.46583440e-02f, 2.38695331e-02f, -5.06616430e-04f, 3.90051231e-02f, 1.68199893e-02f,
  -1.09903060e-01f, 1.03779458e-01f, 8.40809196e-02f, 3.10050547e-02f, 4.50717006e-03f, 7.37413615e-02f, 1.53748170e-01f, -1.04052052e-01f, -1.97484791e-02f, -1.77631453e-02f,
  1.36208177e-01f, 3.08600187e-01f, -1.12570100e-01f, -2.48180851e-02f, -6.35673031e-02f, -1.40013760e-02f, -1.04634129e-02f, 8.33281279e-02f, 9.90839005e-02f, -2.63531636e-02f,
  4.61199209e-02f, 6.71052700e-03f, -7.24913627e-02f, 6.71274737e-02f, 1.36123434e-01f, 9.02318880e-02f, 5.27334623e-02f, -1.17169693e-02f, 1.05620921e-01f, 1.31939650e-01f,
  5.20437509e-02f, -1.01964846e-02f, 1.67221967e-02f, -9.42798108e-02f, 5.75154945e-02f, 1.16835982e-02f, 1.60950571e-01f, 4.74158092e-04f, 1.43723622e-01f, -5.80447204e-02f,
  -6.53508961e-01f, -1.13189049e-01f, -3.62199157e-01f, -2.07983270e-01f, 3.59873921e-02f, -3.10380399e-01f, -1.24739207e-01f, 9.63254087e-03f, -9.18513164e-02f, 3.00069183e-01f,
  1.09689176e-01f, -1.71716198e-01f, 2.32284099e-01f, -3.86146516e-01f, -3.53603244e-01f, -6.69773817e-02f, -2.12258473e-01f, -1.53115258e-01f, -3.82194780e-02f, 1.44194774e-02f,
  -1.45422980e-01f, 5.65520488e-02f, -3.77561420e-01f, 1.24591753e-01f, -1.90066218e-01f, 1.27772853e-01f, 3.67291331e-01f, 2.37468868e-01f, -1.88111737e-01f, -9.79543477e-02f,
  -1.22369766e-01f, 6.06345274e-02f, -3.76777239e-02f, -7.68506303e-02f, -3.26549262e-02f, 6.18323162e-02f, -1.69410631e-02f, -6.01527747e-04f, -5.92988692e-02f, -6.69388622e-02f,
  -3.57767977e-02f, -2.58423761e-02f, -9.40103903e-02f, 1.02811940e-02f, -1.44514948e-01f, -6.20968677e-02f, 9.76346992e-03f, 5.44027798e-03f, -5.84257417e-04f, -1.11924700e-01f,
  -1.54711172e-01f, -2.98922174e-02f, -5.77030331e-02f, -3.41664553e-02f, -3.44228745e-02f, -2.87953764e-02f, -9.86587405e-02f, 8.50974396e-02f, -5.85824288e-02f, -4.36742790e-02f,
  -5.77596910e-02f, -1.08587928e-01f, -2.24907044e-02f, 1.92961060e-02f, 1.19097633e-02f, 1.02743603e-01f, -8.52587447e-02f, 1.64454486e-02f, -1.07971817e-01f, -1.51430145e-02f,
  -9.42398831e-02f, -2.03058962e-02f, -1.48742236e-02f, -8.26882944e-02f, 1.93511359e-02f, -1.54181407e-03f, -7.43066818e-02f, 1.30659401e-01f, -2.19026878e-01f, -1.10438270e-02f,
  2.27049008e-01f, -4.57948782e-02f, -5.39917052e-02f, 9.23035443e-02f, -6.17837533e-03f, 6.51000161e-03f, -2.47685947e-02f, 9.21579003e-02f, 4.84612100e-02f, 1.67245343e-01f,
  1.50544733e-01f, 3.84237826e-01f, 8.91800672e-02f, -3.21830101e-02f, 5.63872308e-02f, 9.79036093e-03f, -5.32345064e-02f, -8.24115053e-02f, 1.71749908e-02f, -5.10980450e-02f,
  -7.45633617e-02f, -4.69811494e-03f, 1.98123250e-02f, -2.31083925e-03f, 2.79962365e-03f, 1.02717213e-01f, 5.11863269e-02f, 8.86322036e-02f, 1.22939512e-01f, 1.09473392e-01f,
  2.48133168e-01f, 1.06224738e-01f, 7.97558203e-02f, -3.86152156e-02f, -9.92727354e-02f, 4.88686338e-02f, -3.28386687e-02f, 1.29990121e-02f, -5.09962179e-02f, -9.08159316e-02f,
  4.98214029e-02f, 1.41346589e-01f, -1.42980188e-01f, 2.24169821e-01f, -3.03739250e-01f, 2.18676224e-01f, 5.06475031e-01f, -1.75453991e-01f, 2.65687048e-01f, 2.36052528e-01f,
  -1.10294878e-01f, 1.47265971e-01f, 2.60664165e-01f, 4.37572226e-03f, 2.87096441e-01f, 4.32181299e-01f, 2.49163091e-01f, 1.66077852e-01f, 9.24414098e-02f, -1.54969059e-02f,
  -1.13085598e-01f, 7.91270882e-02f, -9.58924592e-02f, -6.87621832e-02f, -3.19411933e-01f, 4.90540080e-03f, -1.27669930e-01f, 1.16497893e-02f, -5.63211888e-02f, -9.75180715e-02f,
  9.41134567e-05f, 1.73368230e-01f, -1.94661841e-01f, 1.68019518e-01f, -2.48833410e-02f, -5.54998368e-02f, -9.75968502e-03f, 7.67389089e-02f, -7.64983296e-02f, 1.44635230e-01f,
  1.67546570e-02f, -1.11656450e-01f, 1.19588554e-01f, -6.00704737e-02f, -9.48935002e-02f, -8.96073356e-02f, -1.11077555e-01f, -1.31081730e-01f, 2.32826900e-02f, -1.45595819e-01f,
  -2.68320926e-02f, -1.75580144e-01f, -1.12417765e-01f, 2.68099569e-02f, -4.32210825e-02f, 2.94703618e-02f, 5.63455857e-02f, -1.44124672e-01f, 9.76292193e-02f, 5.38792014e-02f,
  -8.70638713e-02f, 1.02391370e-01f, 4.36350256e-02f, -2.44490523e-03f, 9.04009119e-02f, -3.53814140e-02f, 8.39518756e-03f, -1.33089289e-01f, 5.53058013e-02f, -5.81121631e-03f,
  -2.95142774e-02f, -5.01842983e-02f, -3.54520269e-02f, 7.17307553e-02f, -2.41345111e-02f, -4.20445353e-02f, -1.17426105e-01f, 2.95746396e-03f, 7.62344301e-02f, -8.76089036e-02f,
  -5.59414364e-02f, 9.95536521e-02f, 1.70268584e-02f, -1.75587833e-02f, 2.48812456e-02f, 3.17151770e-02f, 2.44629569e-02f, -1.51905790e-01f, 1.68342236e-02f, 5.66053316e-02f,
  1.70130908e-01f, 3.36762130e-01f, 1.34176835e-01f, 3.18535380e-02f, 1.58131849e-02f, 1.42577952e-02f, 2.63023879e-02f, 8.38147923e-02f, 1.74261019e-01f, 1.08960062e-01f,
  -5.83332963e-02f, 4.10226695e-02f, -1.30917775e-02f, -6.70224577e-02f, 2.60034169e-04f, 6.18447661e-02f, 1.65042296e-01f, -7.55288973e-02f, 2.88046412e-02f, -7.90019855e-02f,
  -9.85138416e-02f, 1.38953194e-01f, -2.25959383e-02f, 1.58596598e-02f, 8.27973410e-02f, -5.45788556e-02f, 8.50388333e-02f, 3.87879685e-02f, -2.98309941e-02f, 3.15270647e-02f,
  -2.53908396e-01f, 3.77478898e-01f, -1.78272650e-01f, -5.54061383e-02f, -1.10925250e-01f, 7.85370231e-01f, 4.84295696e-01f, 2.47914776e-01f, 1.44728065e-01f, 5.21131098e-01f,
  2.24824503e-01f, -1.41166626e-02f, 3.00989836e-01f, 3.63325030e-01f, 3.58499996e-02f, 5.19729972e-01f, 2.77606517e-01f, 2.71680474e-01f, -6.41712397e-02f, -4.85397838e-02f,
  -1.29406914e-01f, 1.97693706e-01f, -6.61250874e-02f, 1.38109684e-01f, -1.69822827e-01f, -2.39881977e-01f, -3.68073806e-02f, -1.14851788e-01f, 1.84442177e-02f, 1.30860776e-01f,
  5.46921603e-02f, -1.00354582e-01f, -1.02780573e-01f, -9.16140676e-02f, -3.86710949e-02f, -9.80122909e-02f, -1.09401112e-02f, -1.61318287e-01f, -6.73088729e-02f, 2.11661998e-02f,
  2.24807579e-02f, 1.96828507e-02f, 4.31823079e-03f, -1.59282938e-01f, -3.57514573e-03f, 5.14549576e-03f, 6.67134970e-02f, -1.23514151e-02f, 7.35803246e-02f, -4.67817597e-02f,
  7.87093788e-02f, 4.18962203e-02f, 3.16320844e-02f, 9.88047868e-02f, 1.77113749e-02f, 1.05391972e-01f, 4.21874896e-02f, 7.92798698e-02f, 6.73891529e-02f, 5.23231924e-02f,
  -6.63990080e-02f, -2.28099432e-02f, 2.37571131e-02f, -8.60422403e-02f, -2.07392648e-02f, -1.53039604e-01f, -4.70482605e-03f, -1.87758673e-02f, -4.33308855e-02f, 1.38560180e-02f,
  -4.89228591e-02f, 6.14943821e-03f, -4.58372720e-02f, 2.21810471e-02f, -8.03734548e-03f, 5.43856472e-02f, -5.85560873e-02f, 1.50027514e-01f, 1.06988661e-01f, 5.29567748e-02f,
  1.37881577e-01f, 1.76506087e-01f, 3.56189944e-02f, -5.02404049e-02f, 5.18321432e-02f, -1.46563863e-02f, 4.33359183e-02f, 1.57830548e-02f, 5.61369173e-02f, 4.36095372e-02f,
  2.44502112e-01f, 1.82004616e-01f, 4.59907763e-02f, -2.02530064e-02f, 1.98381916e-02f, 9.10464488e-03f, 2.69897357e-02f, 9.23146959e-03f, 1.55316010e-01f, 4.04718295e-02f,
  -5.05390204e-03f, -4.42152619e-02f, 5.74701279e-02f, 4.20781337e-02f, 6.49748789e-03f, 3.89556922e-02f, -6.86349645e-02f, -4.09719646e-02f, 4.14779596e-02f, 3.11068427e-02f,
  -3.39968689e-02f, -5.74772097e-02f, -2.25957856e-02f, -7.80222192e-02f, -7.96644092e-02f, -2.11302284e-02f, -4.89598028e-02f, -8.68347958e-02f, -9.81020331e-02f, -7.76876137e-03f,
  2.34872580e-01f, 1.36184856e-01f, -1.75320700e-01f, -8.47106352e-02f, 2.89646946e-02f, 2.55413651e-01f, 4.09987241e-01f, -3.61486385e-03f, -1.43586934e-01f, 3.80135864e-01f,
  4.73471373e-01f, -3.47481519e-02f, 3.05399179e-01f, 4.74827230e-01f, -6.01958968e-02f, 1.61748543e-01f, 3.17479551e-01f, 2.16611192e-01f, -9.30817798e-02f, -6.81449845e-03f,
  -1.06393769e-01f, 4.70957279e-01f, 1.19581498e-01f, 9.98482257e-02f, 1.97137281e-01f, -2.49867484e-01f, 1.77097797e-01f, -1.36462271e-01f, 1.34188756e-01f, 7.23268986e-02f,
  1.92742899e-01f, 1.15877286e-01f, 3.89553085e-02f, 4.22547795e-02f, 1.02829680e-01f, 9.29640532e-02f, -6.75994679e-02f, -7.13076517e-02f, -9.07189474e-02f, -9.69704464e-02f,
  -7.87542090e-02f, -7.14892447e-02f, 4.72215265e-02f, -1.23603335e-02f, -1.17163002e-01f, -7.12761506e-02f, -8.43186826e-02f, 8.50408897e-02f, -7.33474195e-02f, -2.82595549e-02f,
  -7.76298866e-02f, -2.41241697e-02f, -7.70100253e-03f, 5.56804426e-02f, -3.11296489e-02f, 6.41786084e-02f, 6.78824633e-03f, -6.39151335e-02f, -6.25048727e-02f, 6.36478513e-03f,
  -4.18604948e-02f, 1.10605676e-02f, 4.17518467e-02f, 1.02601819e-01f, 7.69921616e-02f, 8.18253607e-02f, -1.13035711e-02f, 4.76768166e-02f, 3.30616999e-03f, -5.48619777e-03f,
  -5.74935190e-02f, -7.40301386e-02f, 5.99388890e-02f, 2.16928422e-02f, -3.15784514e-02f, -1.07917301e-01f, -2.39295177e-02f, -6.09548111e-03f, -2.26598210e-03f, -7.78179839e-02f,
  7.38497227e-02f, -1.39938816e-01f, 5.92318363e-02f, 3.72189321e-02f, -2.80029811e-02f, -1.68654203e-01f, -8.11657775e-03f, -1.31290719e-01f, -2.04935074e-02f, 4.95778620e-02f,
  -5.09691685e-02f, -1.59247976e-03f, -6.95623085e-02f, 3.98485586e-02f, -2.27200594e-02f, 1.03915751e-01f, -1.34911295e-02f, -1.54103756e-01f, 3.21573112e-03f, 1.49013519e-01f,
  1.19731255e-01f, -1.29430164e-02f, -7.63576552e-02f, 1.38113752e-01f, -5.68164997e-02f, 1.22439265e-01f, 7.26910383e-02f, 8.72246549e-03f, -4.04115617e-02f, 3.29047733e-04f,
  7.29866326e-02f, 4.72549275e-02f, -9.56706982e-03f, -3.00704278e-02f, -2.78717093e-02f, 1.20606817e-01f, -5.85748777e-02f, -8.09468403e-02f, -8.04445371e-02f, 1.66116003e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  5.35464704e-01f, 1.87489286e-01f, -7.92222098e-02f, 3.56402725e-01f, 2.56037533e-01f, -2.84210732e-03f, 2.55406022e-01f, 2.04145893e-01f, 3.75501245e-01f, 4.15052995e-02f,
  1.61897987e-01f, 3.84846747e-01f, 3.09433073e-01f, -9.27573144e-02f
};

// L1_fan_Wp (Shape: 1 x 16)
const int L1_fan_Wp_rows = 1;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  -1.52944118e-01f, 1.58517640e-02f, -1.56405985e-01f, 9.05230194e-02f, 6.01648927e-01f, -2.64777094e-01f, 1.88307062e-01f, 4.13885117e-01f, -4.66364712e-01f, -1.25029191e-01f,
  1.77622244e-01f, -1.31461397e-01f, -2.71068662e-01f, 2.31818631e-02f, 2.80809790e-01f, 4.13191319e-01f
};

// L1_fan_Wp_bar (Shape: 14 x 16)
const int L1_fan_Wp_bar_rows = 14;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  -8.61590430e-02f, 6.76603243e-03f, -8.30850936e-03f, 3.05400610e-01f, 8.27828944e-01f, -4.38988358e-01f, 5.33054888e-01f, 4.90422733e-03f, -2.06770390e-01f, -2.48439461e-01f,
  7.78544962e-01f, -8.83039758e-02f, -1.06013425e-01f, 2.06485704e-01f, 2.39472046e-01f, 4.84701693e-01f, 8.06770444e-01f, -6.97813392e-01f, 3.30660075e-01f, 1.15972191e-01f,
  -4.58798051e-01f, -9.72852856e-03f, 4.02956814e-01f, 2.54485488e-01f, -6.64049014e-02f, -2.02837601e-01f, -3.04566473e-01f, 4.78289068e-01f, -3.57626617e-01f, -4.44985665e-02f,
  2.87215233e-01f, 4.71528798e-01f, 1.00896525e+00f, -7.66072720e-02f, 5.69178522e-01f, -2.06229076e-01f, -6.41065598e-01f, 8.04441512e-01f, -3.50511700e-01f, 2.95621939e-02f,
  -1.13305688e-01f, 5.19265831e-01f, -3.38904798e-01f, 2.73288876e-01f, 1.26913577e-01f, 1.76368192e-01f, 1.87723443e-01f, -6.78120852e-01f, 5.90973020e-01f, -2.62718443e-02f,
  5.04972398e-01f, -1.98820531e-01f, -1.60427764e-01f, 5.31504750e-01f, 1.79512411e-01f, 4.03069943e-01f, 2.68260986e-01f, -2.17001662e-01f, 2.81423271e-01f, -2.43367270e-01f,
  -4.58063304e-01f, 4.60826874e-01f, 3.59367222e-01f, 2.87737370e-01f, 5.90337753e-01f, 2.67257899e-01f, 4.47061062e-01f, 3.68928671e-01f, 3.22127223e-01f, 8.60508010e-02f,
  4.01866287e-02f, 3.59991670e-01f, 4.11868095e-01f, 1.58120647e-01f, 7.34735206e-02f, -4.35600042e-01f, 2.81575710e-01f, 5.11073172e-01f, 1.75315902e-01f, -3.26090038e-01f,
  3.40875179e-01f, -2.88740814e-01f, 6.53024673e-01f, 6.25479102e-01f, -9.50598568e-02f, -1.51792064e-01f, 2.18748525e-01f, 4.75693166e-01f, 7.71053374e-01f, 8.45362902e-01f,
  -3.73472095e-01f, 1.19563498e-01f, 8.03891659e-01f, 1.90745920e-01f, 6.53010607e-01f, 1.87040433e-01f, 3.22289199e-01f, -6.29442215e-01f, 1.15557216e-01f, 2.61746228e-01f,
  -9.12538946e-01f, -1.02708209e-02f, 3.00210238e-01f, -2.37651557e-01f, 1.43859133e-01f, 1.81364566e-01f, 3.36752206e-01f, 8.06511223e-01f, 3.07988912e-01f, -1.37725160e-01f,
  1.38396740e-01f, 2.61312634e-01f, -4.50008899e-01f, 7.36167908e-01f, 3.59535396e-01f, 4.24561977e-01f, 6.70195222e-02f, 1.31947085e-01f, 2.73272470e-02f, -1.90516576e-01f,
  -2.46341731e-02f, 3.80898118e-01f, -1.15758345e-01f, 8.88364792e-01f, 5.95704138e-01f, 2.05401763e-01f, -5.18661380e-01f, -3.08694933e-02f, -2.90333569e-01f, 7.50907838e-01f,
  2.96274364e-01f, 5.50196469e-01f, 3.76235753e-01f, -8.98905769e-02f, 4.66260761e-02f, 4.35936898e-01f, 3.90021980e-01f, -2.36055002e-01f, -1.04575910e-01f, -2.13054240e-01f,
  3.84413213e-01f, 5.79493701e-01f, 4.05858964e-01f, 1.59739062e-01f, 7.84463704e-01f, -5.69841802e-01f, 4.40215051e-01f, -1.46907941e-01f, -2.48407528e-01f, 4.61291760e-01f,
  3.61432731e-01f, 7.85456155e-04f, 2.43700013e-01f, -1.00478083e-02f, 5.10484159e-01f, -9.02661756e-02f, -5.36551535e-01f, 2.06882387e-01f, 3.70262295e-01f, 2.24171430e-01f,
  6.89650297e-01f, -4.58183557e-01f, 3.07693988e-01f, -3.92643273e-01f, -9.69939530e-02f, 7.06458330e-01f, 2.05564022e-01f, 6.68295696e-02f, -3.79216701e-01f, -3.92797664e-02f,
  6.48412228e-01f, -2.09695287e-03f, -6.59453690e-01f, 1.04272000e-01f, -1.93009913e-01f, -1.79109648e-01f, 4.55941498e-01f, -5.89265704e-01f, 3.72868121e-01f, 2.12200329e-01f,
  -1.95543513e-01f, -2.53112078e-01f, 4.90354523e-02f, 2.12195128e-01f, -2.44779617e-01f, -3.56942564e-01f, 6.87175691e-01f, 1.83223695e-01f, -3.00842553e-01f, -2.24774778e-01f,
  3.38558853e-01f, 6.41639173e-01f, 3.47822934e-01f, -1.82529557e-02f, 2.83205003e-01f, -5.62250435e-01f, 1.07461169e-01f, 5.37132800e-01f, 5.07003963e-02f, 3.01301271e-01f,
  -4.70864922e-01f, 1.85428202e-01f, 7.27185369e-01f, -1.47492245e-01f, -4.57730472e-01f, 3.68323863e-01f, 3.17816645e-01f, 3.78844023e-01f, 3.26897144e-01f, -2.85441548e-01f,
  5.22154748e-01f, 6.47336125e-01f, -7.07559437e-02f, -4.31686670e-01f, 5.35471857e-01f, -1.18319698e-01f, 8.17928910e-01f, 6.26882315e-01f, 5.59998229e-02f, -2.36673430e-01f,
  5.62457919e-01f, 1.70734406e-01f, 5.28275073e-01f, 7.34223202e-02f
};

// L1_fan_Bp_bar (Shape: 1 x 14)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 14;
const float L1_fan_Bp_bar_data[] = {
  8.39705691e-02f, 6.17920518e-01f, 1.04331946e+00f, 5.69273889e-01f, 5.18285096e-01f, 4.15410608e-01f, 4.44945872e-01f, 1.44706026e-01f, -2.33324450e-02f, 7.88758159e-01f,
  5.51264286e-01f, -7.68519863e-02f, 1.78196266e-01f, 6.00471199e-01f
};

// L2_fan_Wp (Shape: 1 x 16)
const int L2_fan_Wp_rows = 1;
const int L2_fan_Wp_cols = 16;
const float L2_fan_Wp_data[] = {
  -8.11295211e-02f, -4.30548012e-01f, 6.53834939e-02f, -5.30185342e-01f, -1.09346854e-02f, -1.72249943e-01f, -2.47202873e-01f, 2.01261684e-01f, -1.07671447e-01f, 3.74402195e-01f,
  -2.25041294e-03f, -1.38086483e-01f, 1.72771662e-02f, -1.99726120e-01f, -3.02593946e-01f, 1.97149128e-01f
};

// L2_fan_Wp_bar (Shape: 14 x 16)
const int L2_fan_Wp_bar_rows = 14;
const int L2_fan_Wp_bar_cols = 16;
const float L2_fan_Wp_bar_data[] = {
  -1.12125166e-01f, 4.18203741e-01f, 4.17627394e-01f, 2.94900239e-02f, -5.20119548e-01f, -5.16043305e-02f, 4.28966045e-01f, 3.52258593e-01f, -9.32848603e-02f, 2.09238268e-02f,
  4.78289604e-01f, 3.11213970e-01f, 1.90951139e-01f, 3.93757850e-01f, -1.95533991e-01f, 6.14119411e-01f, 3.42146046e-02f, -1.87007234e-01f, -4.35862720e-01f, 6.47410214e-01f,
  4.51775789e-01f, 1.18763566e-01f, -5.61318874e-01f, -2.50469267e-01f, 4.34072465e-01f, 8.12842906e-01f, -9.41571221e-02f, 1.74558491e-01f, 3.80124718e-01f, 1.18009873e-01f,
  1.16736665e-01f, -5.83935142e-01f, 6.07744813e-01f, -4.51799989e-01f, -4.42464292e-01f, 2.45221049e-01f, 6.73728526e-01f, -2.07722157e-01f, -4.50510025e-01f, 2.24025659e-02f,
  5.79504788e-01f, 6.91644013e-01f, -6.84453726e-01f, -1.22413009e-01f, 1.08960316e-01f, -1.37615964e-01f, -2.86805838e-01f, -1.73589528e-01f, 4.97468382e-01f, 4.32884723e-01f,
  4.95369226e-01f, 4.30072844e-01f, 2.83480763e-01f, 8.03914309e-01f, 3.97375822e-01f, -2.21229285e-01f, 4.67667401e-01f, -3.93006057e-01f, -1.50863692e-01f, 7.16245830e-01f,
  9.19018030e-01f, 7.67026663e-01f, 9.08622861e-01f, 5.39689772e-02f, -1.74450755e-01f, -3.60513568e-01f, 2.04240963e-01f, -1.77778959e-01f, -1.59740761e-01f, 4.54606265e-02f,
  -3.45394492e-01f, -1.57814309e-01f, -3.92928898e-01f, -5.10034323e-01f, 7.84818754e-02f, -1.50093824e-01f, 2.39421632e-02f, 5.19851334e-02f, -2.30967611e-01f, 1.49868906e-01f,
  1.78011358e-01f, -1.40702680e-01f, -3.54193836e-01f, -2.98617363e-01f, 4.56601173e-01f, 1.04435407e-01f, 6.31226778e-01f, 2.30194166e-01f, -2.86592215e-01f, 4.73628163e-01f,
  2.32696474e-01f, -8.59820843e-02f, -2.53397316e-01f, -5.45199811e-01f, -4.13220823e-02f, 5.12750387e-01f, -2.42403463e-01f, 5.97725034e-01f, 2.25694448e-01f, -8.08143541e-02f,
  -9.04137641e-02f, -3.81104499e-01f, 3.23197782e-01f, 3.17997068e-01f, 1.88811775e-02f, 8.57293844e-01f, 5.05261660e-01f, -3.23726773e-01f, -7.29151309e-01f, 3.81201319e-02f,
  -1.65840596e-01f, 9.79054049e-02f, -4.37094033e-01f, -3.49851817e-01f, -5.60439467e-01f, 3.79785635e-02f, 3.24574351e-01f, 3.54079574e-01f, 4.77058172e-01f, 7.14810371e-01f,
  3.70380163e-01f, 6.12659395e-01f, 5.65015972e-01f, 6.98405430e-02f, -4.57660228e-01f, -7.19962344e-02f, 1.18215680e-01f, 5.41977704e-01f, 3.90336290e-02f, -1.27247393e-01f,
  -4.36289519e-01f, 2.53567666e-01f, 6.09487951e-01f, 6.86174273e-01f, 1.89088523e-01f, -3.21943253e-01f, -6.06745705e-02f, -2.54332989e-01f, 4.69260998e-02f, 5.83283722e-01f,
  7.10231960e-01f, -5.23354523e-02f, 8.06431532e-01f, -5.17275691e-01f, 3.44774008e-01f, -3.67802531e-01f, -5.17612576e-01f, 6.95857584e-01f, 8.42926621e-01f, 5.87812364e-01f,
  4.10244942e-01f, 4.71562713e-01f, -7.07781166e-02f, -7.17481852e-01f, -1.55680344e-01f, 4.96200442e-01f, 3.18725795e-01f, 1.11121900e-01f, 5.44766821e-02f, 5.13869487e-02f,
  -2.12973148e-01f, -7.10391551e-02f, 1.33364752e-01f, -2.82721221e-01f, 2.26294562e-01f, 3.26529086e-01f, 5.32729208e-01f, 2.19609380e-01f, -7.85660803e-01f, 5.31363726e-01f,
  5.64822555e-01f, -1.16177954e-01f, 2.68971831e-01f, -5.47308385e-01f, -3.27021331e-02f, -9.83756706e-02f, 6.55423343e-01f, -1.12023675e+00f, -6.35178685e-01f, 3.25248778e-01f,
  6.99707627e-01f, -1.45234033e-01f, 8.84897709e-02f, 2.08331704e-01f, 5.21384120e-01f, -6.46613585e-03f, -4.75398570e-01f, 1.91827118e-01f, -3.32824320e-01f, -7.37219036e-01f,
  -7.97172785e-01f, 2.44063556e-01f, -1.72322080e-01f, 5.37245989e-01f, 6.48840487e-01f, 5.88292718e-01f, -1.43296450e-01f, 2.73637325e-01f, -1.13124639e-01f, 3.39542836e-01f,
  7.98179656e-02f, -4.17863298e-03f, 3.01306486e-01f, 2.25537777e-01f, 7.47511312e-02f, 7.63901234e-01f, -4.10142690e-02f, 3.98157746e-01f, -1.20421715e-01f, -4.29887116e-01f,
  -2.60439538e-03f, 2.66337097e-01f, 3.49447548e-01f, -2.58779705e-01f, -1.89432383e-01f, 8.29814732e-01f, 9.49880421e-01f, 4.88085836e-01f, -1.10885486e-01f, 7.68342689e-02f,
  -4.32905048e-01f, 5.69866709e-02f, 1.10207558e-01f, 7.34251678e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 14)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 14;
const float L2_fan_Bp_bar_data[] = {
  -2.57065112e-04f, -8.76094848e-02f, 5.45372903e-01f, 6.13137662e-01f, -2.16047600e-01f, 3.04615617e-01f, 1.04340769e-01f, -9.90457982e-02f, 1.19084492e-01f, 2.76251435e-01f,
  -1.50383972e-02f, 7.32774615e-01f, -2.22991988e-01f, 1.83021098e-01f
};

// L3_fan_Wp (Shape: 1 x 16)
const int L3_fan_Wp_rows = 1;
const int L3_fan_Wp_cols = 16;
const float L3_fan_Wp_data[] = {
  2.13020846e-01f, -1.50176719e-01f, 1.09502643e-01f, 3.00182998e-02f, -1.08263142e-01f, -6.35261163e-02f, 2.99304817e-02f, -2.46393338e-01f, 2.65526026e-01f, -1.44099509e-02f,
  6.29532933e-02f, 5.27597778e-02f, -8.64520222e-02f, -1.60650790e-01f, 1.90333158e-01f, -7.45849162e-02f
};

// L3_fan_Wp_bar (Shape: 14 x 16)
const int L3_fan_Wp_bar_rows = 14;
const int L3_fan_Wp_bar_cols = 16;
const float L3_fan_Wp_bar_data[] = {
  -8.90995562e-02f, 1.73824191e-01f, -1.89512908e-01f, 3.48335296e-01f, 4.13412392e-01f, -3.89012486e-01f, -1.13502912e-01f, 2.38759980e-01f, 3.14514190e-02f, 5.19400299e-01f,
  -2.40258560e-01f, 2.45003775e-02f, -3.14243168e-01f, 5.03704131e-01f, -3.70612502e-01f, 4.74858552e-01f, 1.37561768e-01f, 1.19130814e+00f, 8.34331363e-02f, -1.48360580e-01f,
  -4.67645317e-01f, 3.05670798e-02f, 3.21216404e-01f, 9.50833142e-01f, 6.64923370e-01f, 7.60344684e-01f, 2.54089266e-01f, 3.55006218e-01f, 7.90983081e-01f, -2.52689004e-01f,
  1.36991203e-01f, 4.53625113e-01f, -3.04038227e-01f, 4.44808722e-01f, -2.49773189e-01f, -9.07857791e-02f, 2.48630702e-01f, -6.26943171e-01f, 1.48689777e-01f, 2.94153243e-01f,
  1.82551339e-01f, 2.12549016e-01f, -5.27863204e-02f, -2.69915015e-01f, -1.02346092e-01f, 3.58024776e-01f, -3.64992768e-01f, 3.65820259e-01f, -3.00228328e-01f, -7.87879705e-01f,
  3.54593635e-01f, -4.82652366e-01f, -4.03969109e-01f, 1.39944270e-01f, -1.58235878e-01f, -5.65279245e-01f, 5.28237522e-01f, -1.22521995e-02f, 2.90210787e-02f, -1.53325379e-01f,
  -3.50324720e-01f, -4.74259287e-01f, 3.85614425e-01f, 3.87868464e-01f, 6.11473098e-02f, -3.28833431e-01f, 6.88854039e-01f, -6.57405674e-01f, -8.94496560e-01f, 2.55945802e-01f,
  1.81329399e-01f, -1.17642447e-01f, -4.02691811e-02f, 2.91007966e-01f, -9.65458527e-02f, 1.53881133e-01f, -4.10554439e-01f, -5.55182882e-02f, 6.98761404e-01f, 2.90981591e-01f,
  -4.67365161e-02f, 1.49154231e-01f, 2.86744177e-01f, -6.68580890e-01f, -9.95780453e-02f, 4.71654572e-02f, -1.60681650e-01f, 1.66137457e-01f, -1.13248855e-01f, 2.15891123e-01f,
  -3.03720474e-01f, 3.96110833e-01f, 7.05053518e-03f, 6.84707463e-02f, 3.70241821e-01f, 3.26340497e-01f, -8.40299785e-01f, 1.25897601e-01f, -1.58569276e-01f, 1.12863505e+00f,
  3.60861093e-01f, 1.54366329e-01f, 6.20935321e-01f, -2.14673296e-01f, 4.63328421e-01f, 4.11440074e-01f, 1.56548306e-01f, -5.13253987e-01f, -1.23499759e-01f, -2.81944394e-01f,
  -1.92130022e-02f, 3.85447025e-01f, -8.69558513e-01f, 1.62544504e-01f, 4.88882810e-01f, -7.49511659e-01f, -4.84382421e-01f, 1.41825095e-01f, -6.73711181e-01f, 1.56423569e-01f,
  7.15216100e-02f, 4.21027064e-01f, -1.45052016e-01f, -2.19748262e-02f, -7.20610246e-02f, 2.89641947e-01f, 7.54625723e-02f, 1.40986964e-01f, 4.04101610e-01f, -9.73146439e-01f,
  -6.27735972e-01f, 8.27228367e-01f, 1.01802003e+00f, 2.51823306e-01f, -1.73631385e-01f, -1.11156285e-01f, -4.26578104e-01f, 3.15041840e-02f, -5.69728874e-02f, 1.28717363e-01f,
  -3.53755862e-01f, 8.70927632e-01f, 1.30483970e-01f, 2.85303771e-01f, 2.38355443e-01f, 4.21077341e-01f, 1.01980664e-01f, 3.49778347e-02f, 2.95652419e-01f, -5.60909688e-01f,
  -5.95572740e-02f, 5.12625456e-01f, 5.35939634e-01f, 5.11563063e-01f, -5.08427024e-01f, -5.29075086e-01f, 4.60514098e-01f, 1.48989558e-01f, -9.61543024e-02f, 2.47760311e-01f,
  3.13272119e-01f, -2.12898865e-01f, -3.19476485e-01f, 1.18829250e-01f, 1.08383268e-01f, 4.93710399e-01f, -3.68259996e-01f, -1.02645285e-01f, -2.82407880e-01f, 1.39663011e-01f,
  7.73315310e-01f, 7.79960275e-01f, -2.91555434e-01f, 2.28284717e-01f, 3.54327977e-01f, -4.18436043e-02f, 9.86624882e-02f, 3.67723703e-01f, 2.87338644e-01f, 5.68994701e-01f,
  1.31567670e-02f, -2.96673030e-01f, -4.58120912e-01f, 2.66000181e-01f, 2.87581027e-01f, -9.65498984e-02f, 8.93217996e-02f, -4.91908133e-01f, 4.26568419e-01f, -5.43584049e-01f,
  2.63180733e-01f, 2.16516897e-01f, 9.48641777e-01f, -5.59278250e-01f, 7.64669618e-03f, -1.48863792e-01f, 4.71429616e-01f, -4.40355577e-02f, -5.24404883e-01f, 3.35247791e-03f,
  -2.71663338e-01f, 6.20605685e-02f, -2.32155457e-01f, 5.00066757e-01f, -5.04522085e-01f, 1.05285120e+00f, -1.14504680e-01f, 7.03101099e-01f, -3.39758366e-01f, -7.20186651e-01f,
  -2.20228881e-01f, -4.62697595e-01f, -2.22680226e-01f, 8.16375077e-01f, -8.21543455e-01f, -2.88493782e-01f, -5.21399915e-01f, -5.38561165e-01f, 6.72272205e-01f, 3.58407468e-01f,
  2.35385120e-01f, -1.40401214e-01f, -2.73353476e-02f, -3.85225445e-01f
};

// L3_fan_Bp_bar (Shape: 1 x 14)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 14;
const float L3_fan_Bp_bar_data[] = {
  2.68469065e-01f, -1.13317056e-03f, -2.55013287e-01f, 1.48291141e-01f, -2.34437451e-01f, -1.19704213e-02f, -3.49306315e-01f, 5.45618355e-01f, 4.18946803e-01f, 1.06071495e-01f,
  3.15235317e-01f, -6.00828156e-02f, 4.88812596e-01f, 8.12309861e-01f
};

// L4_linear_W (Shape: 12 x 16)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 16;
const float L4_linear_W_data[] = {
  -4.19245511e-01f, 1.11299999e-01f, -5.99593759e-01f, 4.79821768e-03f, 2.16233328e-01f, 4.14738476e-01f, 1.64362401e-01f, 2.49475509e-01f, 1.33966610e-01f, 3.40281665e-01f,
  -4.79786336e-01f, -2.39366636e-01f, 1.01755701e-01f, 7.27005377e-02f, -1.72549009e-01f, -6.64096713e-01f, -3.79029512e-01f, 1.71933919e-01f, -4.52609867e-01f, -1.74917698e-01f,
  2.88074255e-01f, 3.72864842e-01f, 2.57626623e-01f, 1.88710719e-01f, 4.48897600e-01f, -5.84015012e-01f, 1.00571021e-01f, -1.77311301e-01f, 1.97793856e-01f, 3.95547241e-01f,
  1.86430067e-01f, -3.69682834e-02f, -2.31184602e-01f, -2.23719984e-01f, -1.89434718e-02f, -5.75069368e-01f, -3.26855838e-01f, -4.82384920e-01f, -3.38251024e-01f, -3.44405562e-01f,
  5.19108772e-01f, -3.17835212e-01f, 6.25543475e-01f, -3.73086423e-01f, 1.21084005e-01f, -1.38639838e-01f, 1.28783509e-01f, -5.43870807e-01f, 1.19585261e-01f, -5.13180673e-01f,
  5.01661040e-02f, 1.06656052e-01f, 3.69391263e-01f, -1.09736152e-01f, 1.32423593e-02f, -1.61752045e-01f, 3.39093804e-01f, 3.82299006e-01f, -9.57255423e-01f, 2.78661340e-01f,
  -6.17841959e-01f, 5.62177226e-02f, 8.79736617e-02f, -3.80835086e-01f, 4.82957244e-01f, 4.08507623e-02f, 2.75068972e-02f, 1.05549552e-01f, -6.65989399e-01f, -3.46223652e-01f,
  2.96889991e-01f, 4.46792580e-02f, -4.86427069e-01f, 2.58462224e-02f, 8.94786566e-02f, -9.00700763e-02f, -1.04593132e-02f, -2.48161554e-01f, 5.19305885e-01f, -7.48800993e-01f,
  3.90960068e-01f, 4.29396152e-01f, -4.43480581e-01f, 4.49764013e-01f, 1.05024688e-01f, -6.87913954e-01f, -3.96408699e-03f, 3.05520147e-01f, -1.77069634e-01f, -9.14890394e-02f,
  -2.63954103e-01f, -4.22778666e-01f, 2.77156800e-01f, -3.23782861e-01f, -5.22207022e-01f, -9.28106718e-03f, 4.18615676e-02f, 2.81882286e-01f, -3.35417151e-01f, 7.99125284e-02f,
  -6.52456954e-02f, -4.02184099e-01f, -4.34036702e-01f, -4.10812169e-01f, 2.78856635e-01f, -9.97941554e-01f, 4.51142602e-02f, -9.82669294e-02f, 3.09910595e-01f, 2.30212316e-01f,
  -9.15393293e-01f, 5.64095199e-01f, -5.72696552e-02f, 6.48206353e-01f, -4.09527510e-01f, 3.37132335e-01f, -3.23989779e-01f, 3.82177055e-01f, -3.20308544e-02f, -3.75017412e-02f,
  1.10635340e-01f, -9.32485312e-02f, -4.86480087e-01f, 3.76675218e-01f, -5.81373811e-01f, 7.12316453e-01f, -4.91542011e-01f, -3.10970157e-01f, -3.56249698e-02f, -1.71444565e-01f,
  3.70429218e-01f, -1.89349815e-01f, 4.60426301e-01f, 1.23267889e-01f, -3.51132929e-01f, -6.66203082e-01f, 4.86834884e-01f, -8.89389455e-01f, 1.79351285e-01f, 4.78602111e-01f,
  -4.36885178e-01f, 3.32856953e-01f, 1.06016904e-01f, -6.99376613e-02f, 3.06100100e-01f, 6.26540303e-01f, -4.18579698e-01f, -7.53049314e-01f, -9.86838415e-02f, 6.49161339e-01f,
  2.25174442e-01f, 3.63008082e-02f, -6.57223582e-01f, 4.78773087e-01f, -1.75304532e-01f, -3.01327199e-01f, 8.69583264e-02f, -2.36046210e-01f, -1.04544842e+00f, 6.06983066e-01f,
  -2.19736204e-01f, -2.44003847e-01f, 3.69151771e-01f, 6.26867414e-02f, 3.43805671e-01f, -7.25123405e-01f, -5.60623884e-01f, -1.39229195e-02f, -2.59009123e-01f, -1.66093651e-02f,
  3.45357438e-03f, 3.12597841e-01f, -2.53796607e-01f, -6.16700172e-01f, 4.99350727e-01f, -2.45154768e-01f, 3.71385455e-01f, -4.18798298e-01f, -2.85756081e-01f, -5.68751037e-01f,
  -6.43234789e-01f, -6.15629852e-01f, -7.52909362e-01f, -3.55301015e-02f, -1.15767276e+00f, -3.43307078e-01f, 5.67308128e-01f, -4.12742138e-01f, 3.12885106e-01f, -5.09976089e-01f,
  7.17306912e-01f, 3.34204793e-01f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  -2.27089763e-01f, -4.70596850e-01f, 1.62733331e-01f, -5.69197908e-02f, 1.20742328e-01f, -1.97014645e-01f, -2.66236765e-03f, 1.59087688e-01f, -1.61066085e-01f, 4.29885477e-01f,
  -1.78470284e-01f, 6.18715882e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 1, 14
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 1, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        16, 1, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        16, 1, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        16, 12
    );
    }
    